/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.33640915e-01f, 4.29817811e-02f, 8.27468112e-02f, -1.50893956e-01f, 9.33980569e-02f, 2.82771349e-01f, 1.55379057e-01f, -1.01348504e-01f, 2.79794745e-02f, -6.50400892e-02f,
  -1.05385832e-01f, 2.30411049e-02f, -1.99839827e-02f, -2.04797685e-01f, 3.34894508e-02f, 1.84138734e-02f, -8.58226046e-02f, 3.01060248e-02f, 1.32604092e-01f, -1.83711007e-01f,
  -1.75772339e-01f, -1.03005253e-01f, -1.24557771e-01f, -8.08093101e-02f, -5.19942753e-02f, -1.16304055e-01f, -1.26078844e-01f, -4.66341712e-02f, -1.44474983e-01f, 1.54018566e-01f,
  -4.05870192e-02f, -1.70797616e-01f, 2.46138796e-02f, 6.13255724e-02f, 8.78998544e-03f, -2.26028226e-02f, 6.20847121e-02f, 1.24228045e-01f, 7.31143579e-02f, 5.80823235e-02f,
  1.04072906e-01f, 1.45196319e-02f, -2.31259074e-02f, -6.76334053e-02f, 2.30654608e-02f, 9.70898289e-03f, -1.58826765e-02f, 9.60981771e-02f, -7.77777955e-02f, 1.21813947e-02f,
  -6.21674582e-02f, -3.42541039e-02f, -1.28171504e-01f, -3.56590785e-02f, 6.86674286e-03f, -4.84789573e-02f, 1.61367413e-02f, 4.03085686e-02f, -1.33477757e-02f, 4.27621193e-02f,
  4.44954121e-03f, 2.64710393e-02f, -8.17099884e-02f, 9.48036090e-02f, -1.02825034e-02f, -5.54457270e-02f, -2.34544799e-02f, 3.39287333e-02f, 1.41782891e-02f, -3.86580117e-02f,
  -4.39800369e-03f, -6.84129596e-02f, -6.06589904e-03f, 5.74612580e-02f, -8.00395310e-02f, -1.56368718e-01f, 9.20632482e-03f, -1.06866091e-01f, -1.35077555e-02f, 4.03884575e-02f,
  -1.11568205e-01f, -7.53331929e-02f, 2.00124551e-02f, 1.58504903e-01f, 7.18523413e-02f, -3.28589454e-02f, -1.05102330e-01f, -1.12327315e-01f, -5.49960956e-02f, 1.25975534e-01f,
  3.64869721e-02f, -2.43229330e-01f, -2.67461091e-02f, -5.25577739e-02f, 3.46309319e-02f, 1.00510761e-01f, 5.32537401e-02f, 1.05269574e-01f, 1.02513529e-01f, -2.87339147e-02f,
  -5.79196624e-02f, -6.86947107e-02f, -8.08997080e-02f, -5.24178557e-02f, 2.83815060e-02f, -4.34053130e-02f, 6.05034456e-03f, 4.92347851e-02f, -5.31141572e-02f, 4.51294370e-02f,
  -1.81584358e-02f, -1.96248800e-01f, 1.39054269e-01f, 7.18564764e-02f, 4.95592989e-02f, -2.68132538e-02f, -1.47754531e-02f, 2.69836187e-02f, -4.75368612e-02f, 8.24668854e-02f,
  -2.80493021e-01f, 3.09110105e-01f, -1.45054922e-01f, 2.99782485e-01f, -1.10188551e-01f, 3.39437813e-01f, 1.59298658e-01f, 1.11255795e-01f, 4.72748131e-02f, 2.00097278e-01f,
  2.72307508e-02f, 3.83035541e-02f, -1.53002799e-01f, 2.18999356e-01f, -2.49640509e-01f, -1.63539797e-01f, 9.84804258e-02f, -1.04579898e-02f, 4.46280986e-02f, -4.53414507e-02f,
  -8.31149295e-02f, 1.73380196e-01f, -1.65204749e-01f, 4.61654477e-02f, 1.24786310e-01f, 1.42190427e-01f, -7.17185363e-02f, -2.62298603e-02f, 1.85821950e-01f, 1.96096096e-02f,
  -1.10452861e-01f, -1.02573812e-01f, -9.56702009e-02f, -9.18736160e-02f, -9.74149778e-02f, -9.11316797e-02f, -4.08875719e-02f, -2.70792563e-02f, -1.07711598e-01f, 3.15238871e-02f,
  -2.89256014e-02f, 3.39693315e-02f, -1.29798194e-02f, -6.14037588e-02f, 3.32971625e-02f, 4.79509160e-02f, -4.76374887e-02f, 3.21907327e-02f, 3.96570079e-02f, -1.45905465e-02f,
  6.10420145e-02f, 5.47264926e-02f, 2.07156781e-02f, -4.26360518e-02f, 6.38523698e-02f, 1.61048889e-01f, 8.68155137e-02f, 6.85512275e-02f, 2.79902741e-02f, 1.17580719e-01f,
  4.75806696e-03f, 2.13452056e-02f, -7.43771270e-02f, 3.25080194e-02f, 5.62888607e-02f, -4.49925661e-03f, -2.64989566e-02f, -3.53395343e-02f, 6.36500269e-02f, -1.59302969e-02f,
  -2.43193004e-02f, 8.73374194e-03f, 1.48606987e-03f, -3.77231687e-02f, 1.54503090e-02f, 6.62659928e-02f, -4.09543402e-02f, -6.59118465e-04f, 1.41115293e-01f, 2.78585367e-02f,
  -3.90130877e-02f, 6.22258559e-02f, -3.26902308e-02f, -3.95069420e-02f, 1.28126913e-03f, -5.27971750e-03f, 3.98155600e-02f, 8.56990144e-02f, -1.24879077e-01f, -9.01746452e-02f,
  1.11727603e-02f, -6.91083819e-02f, 1.80377867e-02f, -3.19674332e-03f, -9.40537304e-02f, -1.29906386e-02f, -3.07989027e-02f, 1.85931578e-01f, -8.85567665e-02f, -3.28094810e-02f,
  2.51379125e-02f, -5.04057109e-02f, -4.01761644e-02f, -1.94694735e-02f, 4.47508432e-02f, 3.56937461e-02f, -9.54957679e-02f, -1.63914058e-02f, -4.92701344e-02f, 8.33300054e-02f,
  -4.01214212e-02f, -5.47434799e-02f, 2.85628363e-02f, -1.76416971e-02f, 2.06227545e-02f, -3.67171802e-02f, 2.26466749e-02f, 3.61963399e-02f, -7.18502030e-02f, -3.48339863e-02f,
  -4.85464558e-02f, 2.81331521e-02f, -8.07066634e-02f, 2.26473838e-01f, 2.38257702e-02f, 2.45345399e-01f, 4.27035362e-01f, 5.06951325e-02f, 2.20703259e-01f, 2.59115338e-01f,
  2.17751682e-01f, 1.36222795e-01f, 1.06697775e-01f, 2.56905496e-01f, 4.70548831e-02f, -8.35492983e-02f, 2.39908725e-01f, 3.72307338e-02f, -5.53783178e-02f, -1.93230510e-02f,
  -6.16536289e-02f, 2.12944627e-01f, -5.27762473e-02f, -5.14573678e-02f, -2.18889527e-02f, -8.68166462e-02f, -2.41439529e-02f, -2.72750929e-02f, 5.41091003e-02f, 4.44191769e-02f,
  -6.85860291e-02f, -6.84432164e-02f, -2.19724316e-04f, -8.28979686e-02f, -5.12413941e-02f, -4.52497080e-02f, -2.12986628e-03f, -4.91979681e-02f, -4.03953455e-02f, 2.69757658e-02f,
  -4.16573742e-03f, -1.96295008e-01f, 6.07324839e-02f, 6.04182407e-02f, -5.45961736e-03f, -2.50367206e-02f, -1.18671380e-01f, -2.75726356e-02f, -2.50600204e-02f, -2.03919085e-03f,
  1.01453736e-01f, -8.31435248e-03f, 6.88238442e-03f, -1.21819116e-02f, 1.94440708e-02f, 9.48954374e-02f, -1.46082528e-02f, -1.31297391e-02f, 3.54795717e-02f, 1.22868225e-01f,
  4.39784564e-02f, -5.71640134e-02f, -2.75269188e-02f, -9.62393582e-02f, -4.16946299e-02f, -1.54475078e-01f, 3.05463523e-02f, -1.27169386e-01f, -5.66022769e-02f, 3.54933776e-02f,
  2.02112496e-02f, -7.57692754e-02f, -4.73279553e-03f, -2.88120490e-02f, 2.31847726e-02f, 8.69650468e-02f, -2.09161900e-02f, -9.05047581e-02f, 8.53355799e-04f, -2.77377553e-02f,
  9.11902729e-03f, -1.18978089e-02f, 2.45698858e-02f, -5.94661757e-02f, -2.24715136e-02f, 3.93640958e-02f, 4.72640023e-02f, 6.54435297e-03f, 4.21579145e-02f, 1.63152721e-02f,
  -5.20296283e-02f, 1.32736331e-02f, -2.89509352e-02f, -1.18160686e-02f, -5.65129966e-02f, -3.13544534e-02f, -2.73090638e-02f, -2.71559227e-02f, -3.22511867e-02f, 3.95237021e-02f,
  1.41757652e-02f, -7.24194571e-02f, 4.39889217e-03f, 4.87812385e-02f, -8.26367438e-02f, 9.16249976e-02f, -4.86735441e-02f, -1.95287261e-02f, 6.06955700e-02f, 1.13761388e-02f,
  -3.78804356e-02f, -4.48585525e-02f, -1.03906713e-01f, 2.28090212e-02f, 2.10041702e-02f, 7.85351396e-02f, -1.16011146e-02f, 3.42234294e-03f, -2.02302784e-02f, -5.98533973e-02f,
  9.48510244e-02f, -1.44817963e-01f, -2.77568340e-01f, 9.82375145e-02f, 6.36129007e-02f, -3.99821103e-02f, -1.23320535e-01f, 2.14137122e-01f, -1.11952126e-01f, -3.60511243e-02f,
  2.19365954e-01f, -2.53104478e-01f, -2.69670576e-01f, 2.43380014e-02f, -6.45380393e-02f, -3.05216700e-01f, 2.68392116e-02f, -1.53462682e-02f, -6.25114888e-02f, 1.05267704e-01f,
  9.61726233e-02f, 1.73970640e-01f, -1.49937496e-01f, 1.56060651e-01f, 1.48409203e-01f, 1.10182561e-01f, 1.42522395e-01f, -1.93428785e-01f, 1.63667604e-01f, 3.41098495e-02f,
  8.40422809e-02f, 4.31494787e-02f, -4.63018529e-02f, -4.58258623e-03f, 1.09163992e-01f, 2.79195886e-02f, -7.40022734e-02f, -5.39489463e-02f, -1.40096350e-02f, -5.87575287e-02f,
  -5.44431172e-02f, -3.12871598e-02f, 1.39787555e-01f, -1.51217595e-01f, -4.62768190e-02f, -3.23111638e-02f, -3.49895209e-02f, 2.12310869e-02f, -2.74129324e-02f, -4.49917056e-02f,
  -2.81522125e-02f, -5.78072779e-02f, -3.60171348e-02f, 6.75422931e-03f, -4.94103581e-02f, 2.87108514e-02f, -3.70054469e-02f, -3.79796475e-02f, 9.80092138e-02f, -2.06182357e-02f,
  4.60621268e-02f, -1.18417911e-01f, 5.83975613e-02f, -1.51714925e-02f, 9.34025049e-02f, 1.48095891e-01f, -1.74729247e-02f, 3.44040170e-02f, 1.36713833e-01f, -4.15599011e-02f,
  9.88415256e-02f, 1.24090284e-01f, -3.66423428e-02f, -2.99362801e-02f, -1.09969163e-02f, 2.28075795e-02f, -4.34549935e-02f, 1.21461749e-02f, -1.68433934e-02f, 4.80388813e-02f,
  -5.33020496e-02f, -4.71075997e-02f, 5.61673865e-02f, 6.13302272e-03f, -4.55251597e-02f, 3.04144658e-02f, 4.49377083e-04f, -3.50731239e-02f, -7.94533789e-02f, 5.20386808e-02f,
  1.22216351e-01f, 1.68517947e-01f, 2.61936951e-02f, 1.56434793e-02f, -1.79444384e-02f, 6.61224425e-02f, -4.30578589e-02f, 8.27659387e-03f, -2.23488756e-03f, -5.47699928e-02f,
  4.36204448e-02f, 1.07860574e-02f, -4.46860492e-02f, -6.08623102e-02f, -9.71969590e-02f, 4.54230933e-03f, -4.33959812e-03f, 8.59312713e-02f, 8.87515321e-02f, 1.37105405e-01f,
  1.47180840e-01f, 1.08408831e-01f, 2.59482414e-02f, 3.24313603e-02f, 4.37442698e-02f, -1.00442450e-02f, 2.09960297e-01f, 1.81956440e-02f, 7.43919387e-02f, -9.74152908e-02f,
  2.47658845e-02f, -8.26928094e-02f, -1.81642454e-02f, 3.36917907e-01f, 1.53117165e-01f, -1.35906637e-01f, -1.02145717e-01f, 2.16097921e-01f, 1.88167259e-01f, 4.01107147e-02f,
  9.92391184e-02f, -1.01478383e-01f, -2.53538191e-01f, 8.77313912e-02f, -2.10143864e-01f, -2.30126694e-01f, 9.50463414e-02f, -5.34656197e-02f, 6.23924509e-02f, 4.77620214e-03f,
  8.09044912e-02f, 2.01683044e-01f, 4.00324129e-02f, 2.33789176e-01f, 1.17415406e-01f, 2.09143400e-01f, 1.23483106e-01f, -1.71984360e-01f, 2.15268075e-01f, -1.22967184e-01f,
  -1.86498493e-01f, -2.74895579e-02f, 2.57048327e-02f, -5.99988848e-02f, -6.77082539e-02f, 1.83423851e-02f, -3.17382216e-02f, -8.00180063e-02f, -1.14839904e-01f, 1.94844119e-02f,
  -6.89767748e-02f, -7.07496982e-03f, 1.82982787e-01f, 5.03276251e-02f, 8.93784463e-02f, 6.97154850e-02f, 6.57873740e-03f, 6.26069978e-02f, 5.65001974e-03f, -1.07723586e-01f,
  -1.96301434e-02f, -3.21065895e-02f, 1.10616580e-01f, -9.73761678e-02f, -2.99625844e-03f, 5.33318520e-02f, 4.07144800e-03f, -8.25868100e-02f, -1.47427963e-02f, 3.28620113e-02f,
  9.35661234e-03f, -4.33243141e-02f, -6.42479106e-04f, -9.67891887e-03f, -3.78485471e-02f, 3.88766080e-02f, -6.96457643e-03f, -7.30246603e-02f, -2.41536107e-02f, -4.26431075e-02f,
  2.33972035e-02f, 3.44643071e-02f, 3.95497531e-02f, -8.97507556e-03f, 5.11632860e-02f, 4.06530499e-02f, -7.19451681e-02f, 3.15930881e-02f, 8.63792747e-02f, -4.73498106e-02f,
  7.98630062e-03f, -5.72087197e-03f, -6.25356212e-02f, -1.71290874e-03f, -4.27393131e-02f, -1.42088365e-02f, 5.51967137e-02f, 9.74425524e-02f, -4.34313249e-03f, 5.20893522e-02f,
  -9.22835022e-02f, 1.29106678e-02f, 6.14884170e-03f, -1.05931461e-01f, -3.94631512e-02f, 1.31025948e-02f, 5.58525184e-03f, 4.18168269e-02f, -5.05449846e-02f, 5.75080551e-02f,
  7.34778447e-03f, -4.41801324e-02f, -4.20235395e-02f, 6.78991899e-02f, -8.94395709e-02f, 7.27080777e-02f, 2.13677585e-02f, 4.41831760e-02f, 1.94815286e-02f, 9.83844418e-03f,
  -7.93602783e-03f, -1.59697421e-02f, -7.13150129e-02f, 4.57208827e-02f, -7.96764530e-03f, -3.84858362e-02f, 7.42495134e-02f, -6.90813176e-05f, -2.76971143e-02f, -5.28874509e-02f,
  -4.58177216e-02f, 9.56176445e-02f, -2.03346610e-01f, -1.07108697e-01f, -1.08005434e-01f, 1.60141572e-01f, -1.19870923e-01f, 1.20082825e-01f, 5.23531344e-03f, 3.04587305e-01f,
  8.44864920e-02f, -1.19715549e-01f, 8.11710432e-02f, -6.70673512e-03f, 1.23026948e-02f, 1.20471448e-01f, 1.88032553e-01f, 5.62589020e-02f, -1.89745415e-03f, 5.37645295e-02f,
  -5.16904937e-03f, 8.25176984e-02f, 1.72909666e-02f, 9.45079327e-02f, -5.67087159e-02f, -6.43507391e-02f, 8.28884616e-02f, -1.42895371e-01f, 6.96333796e-02f, -1.45479534e-02f,
  7.56575093e-02f, 1.38014276e-02f, 2.95226108e-02f, 5.39062023e-02f, 1.15369260e-01f, 7.00584333e-03f, -2.62377933e-02f, -1.23134837e-01f, 4.03546989e-02f, 7.74306133e-02f,
  8.49298611e-02f, 1.01878375e-01f, -4.22398597e-02f, 3.65501014e-03f, -9.79072377e-02f, -8.49696435e-03f, 5.08366115e-02f, 4.84135486e-02f, -4.26645130e-02f, -3.61513644e-02f,
  3.66704874e-02f, -1.86869130e-02f, 6.03907071e-02f, 1.33644585e-02f, -2.22376920e-03f, -1.81735437e-02f, -1.47594064e-01f, -9.88241434e-02f, -8.21314566e-03f, 2.58983998e-03f,
  3.98237631e-02f, -6.15661629e-02f, 1.28706098e-02f, 1.88404545e-02f, 7.88037702e-02f, -6.62421482e-03f, 1.18620340e-02f, -1.01082008e-02f, -5.48517667e-02f, 1.01704493e-01f,
  4.74089757e-02f, -1.18668012e-01f, -1.16096810e-01f, -5.93735352e-02f, 1.06026836e-01f, -4.04201038e-02f, -1.90504622e-02f, -8.34114384e-03f, -9.29993466e-02f, -4.05056141e-02f,
  -4.64087911e-02f, -1.35963662e-02f, 3.17068174e-02f, 7.08615482e-02f, -7.99354631e-03f, -1.59655400e-02f, 1.25226304e-02f, -8.10245499e-02f, -7.72052184e-02f, -3.52990180e-02f,
  2.99424529e-01f, 3.08099657e-01f, -2.21991763e-02f, 1.23496234e-01f, 8.54410082e-02f, -1.18354131e-02f, -3.57961915e-02f, -6.00317195e-02f, 1.06118605e-01f, -1.45199662e-02f,
  6.28779903e-02f, 5.18894903e-02f, 1.63467545e-02f, 2.44133528e-02f, 3.70628871e-02f, -3.46826352e-02f, 3.43825929e-02f, 7.40758330e-02f, 4.88426127e-02f, 4.12238464e-02f,
  4.45187800e-02f, 9.33734104e-02f, 1.28275603e-01f, 8.32504332e-02f, 7.51389191e-02f, 1.31482035e-02f, 6.51183305e-03f, -2.37242263e-02f, 1.70674063e-02f, 8.15444067e-02f,
  5.76179884e-02f, -1.49856731e-01f, 6.67910427e-02f, -2.79443115e-01f, 5.46304416e-03f, -3.23614508e-01f, -3.04319233e-01f, -9.72420126e-02f, -1.04767807e-01f, -1.79865107e-01f,
  -1.53180465e-01f, -1.79593302e-02f, -4.73584011e-02f, -2.88506359e-01f, -1.45810530e-01f, -2.97098123e-02f, -3.91115427e-01f, -3.56981866e-02f, 2.91742906e-02f, -4.75473180e-02f,
  -2.11046468e-02f, -1.89430013e-01f, -6.02550842e-02f, 8.49090442e-02f, 2.43347753e-02f, 9.17140245e-02f, 2.42679492e-02f, 2.56176531e-01f, -9.77734700e-02f, 3.76396365e-02f,
  1.21572666e-01f, 1.30966887e-01f, 2.29656715e-02f, 1.63178951e-01f, 1.29884318e-03f, -3.34936045e-02f, 8.64844844e-02f, 3.42270881e-02f, 9.45674106e-02f, -2.69837491e-02f,
  4.28034291e-02f, 5.37054799e-02f, -5.06564602e-03f, -4.16126512e-02f, -6.06943704e-02f, -1.56841017e-02f, 1.02062766e-02f, 2.60764845e-02f, -8.35705698e-02f, 1.10705504e-02f,
  -1.99327264e-02f, -1.04625486e-01f, -7.39121139e-02f, -2.89272238e-02f, 1.66822411e-02f, -7.88738430e-02f, -8.53451993e-03f, -2.74010617e-02f, -1.02518670e-01f, -5.69063500e-02f,
  -8.26244801e-02f, -4.82222885e-02f, -4.41510417e-02f, 1.12923257e-01f, 2.56105177e-02f, -2.68379622e-03f, 1.73132457e-02f, 6.36692569e-02f, 1.37321264e-01f, 4.35417555e-02f,
  -3.16274464e-02f, -8.04556236e-02f, 4.19378057e-02f, 1.23317279e-02f, 7.75150349e-03f, -1.37322936e-02f, 3.18028890e-02f, 2.51245908e-02f, -2.97776777e-02f, 6.98999241e-02f,
  -2.45918985e-02f, 3.68719064e-02f, 6.44693747e-02f, -2.59575583e-02f, 6.71715196e-03f, -2.77652754e-03f, -4.73766215e-02f, 2.88883615e-02f, -5.66509478e-02f, -1.97379291e-02f,
  -2.55666710e-02f, -6.40438348e-02f, 6.20961078e-02f, -7.76011357e-03f, 5.08214831e-02f, -3.99750052e-03f, 1.12427279e-01f, -3.86584625e-02f, 3.71679589e-02f, 4.26987186e-02f,
  -2.85755917e-02f, 6.19735159e-02f, -3.63125503e-02f, 1.60728153e-02f, -5.80706215e-03f, -1.25901818e-01f, 1.83274467e-02f, 1.28288284e-01f, -1.01524428e-01f, -6.92628920e-02f,
  -1.67690739e-02f, -5.62732071e-02f, 7.43734390e-02f, -3.47993919e-03f, 2.38973200e-02f, 4.56084311e-02f, 1.91317815e-02f, -8.72886106e-02f, -4.36532125e-02f, 9.48762894e-02f,
  -5.36300600e-01f, 4.65365291e-01f, 3.80146503e-02f, -9.08135697e-02f, 1.30085364e-01f, -1.02560595e-01f, -1.21855913e-02f, 2.96367228e-01f, -3.72229293e-02f, 3.60068560e-01f,
  9.42283720e-02f, -1.22758396e-01f, 1.40276775e-01f, -3.41340229e-02f, -3.28509510e-01f, -8.79405513e-02f, -4.91297096e-02f, -1.09210230e-01f, 1.28971413e-01f, 1.77079335e-01f,
  -6.24630190e-02f, -1.68497097e-02f, 7.58301020e-02f, 2.90115356e-01f, 1.34579837e-01f, 1.53113306e-01f, 1.09251939e-01f, 1.97589677e-02f, 1.81249250e-02f, -3.90349366e-02f,
  -8.07901099e-02f, 6.68174028e-02f, 1.36412337e-01f, -3.41180759e-03f, -2.99876891e-02f, 7.49660004e-03f, 1.53718106e-02f, 4.55711456e-03f, -2.79994328e-02f, 7.27039203e-02f,
  -1.45758223e-03f, -4.97509465e-02f, 2.65283044e-02f, 5.70697039e-02f, -4.03737538e-02f, 5.44513538e-02f, 8.76137540e-02f, -1.46702975e-02f, 7.32549801e-02f, 1.50265102e-03f,
  2.10285354e-02f, -4.04070839e-02f, 4.59029945e-03f, -6.50472119e-02f, 6.49228245e-02f, 4.71992083e-02f, 1.81135107e-02f, -7.27120414e-02f, -9.62997414e-03f, -2.39979234e-02f,
  4.01270948e-02f, 5.12460188e-04f, -5.03103249e-02f, -4.16192003e-02f, -1.08199185e-02f, 2.97417343e-02f, 5.53215481e-02f, -3.94812413e-02f, -2.14334019e-02f, 4.04976867e-02f,
  5.86710731e-03f, -1.65765081e-02f, -1.02266567e-02f, 2.01057680e-02f, -8.59757885e-04f, -2.25230586e-02f, -8.48816335e-02f, 1.08377315e-01f, -9.40688513e-03f, -9.87092499e-03f,
  -2.71726586e-02f, 2.59914231e-02f, -1.68009056e-03f, -1.18854549e-02f, 7.45170005e-03f, -6.88876584e-02f, -2.40737549e-03f, 8.61477256e-02f, 7.65583962e-02f, 6.81308433e-02f,
  1.61915943e-01f, 2.90622562e-01f, 2.31523067e-02f, 7.49951089e-03f, -1.09745339e-02f, 2.35696100e-02f, -4.71097901e-02f, 1.20430209e-01f, 9.65062976e-02f, 7.61515051e-02f,
  5.42892106e-02f, 6.66778088e-02f, 1.83557160e-02f, -8.84645358e-02f, -1.51793621e-02f, 3.53775024e-02f, 1.58224860e-03f, 5.73051609e-02f, -2.94141732e-02f, 1.85160507e-02f,
  1.15321772e-02f, 6.63957149e-02f, -1.16344586e-01f, -2.40884116e-03f, -4.44317050e-02f, -4.63368855e-02f, -4.85900082e-02f, -9.95574985e-03f, 3.76681574e-02f, 9.61373188e-03f,
  -4.79457527e-01f, 1.49803028e-01f, -1.04873188e-01f, -2.74501920e-01f, -2.49743223e-01f, 9.98685956e-02f, -2.05779642e-01f, 1.85901560e-02f, -2.73839355e-01f, 2.12734923e-01f,
  3.36851440e-02f, -6.11613691e-02f, 1.74108267e-01f, 4.05061478e-03f, -3.78414124e-01f, 5.04285246e-02f, -1.05530180e-01f, -6.88360780e-02f, -4.52205203e-02f, 5.56762218e-02f,
  -2.85889730e-02f, 3.60682458e-02f, -1.35701150e-01f, 1.63363397e-01f, -1.23197645e-01f, -6.94254413e-02f, 2.84778923e-02f, 2.44325679e-02f, 2.11197063e-02f, -1.27366170e-01f,
  -8.88710935e-03f, 6.06981898e-03f, -4.35349196e-02f, 5.82158789e-02f, 5.98980188e-02f, 9.47880596e-02f, 8.30733106e-02f, -9.58209410e-02f, -4.35523652e-02f, 6.00401647e-02f,
  1.38381934e-02f, -1.07063074e-02f, -6.72436971e-03f, -1.52305931e-01f, 3.96648096e-03f, -2.42720675e-02f, -6.96842670e-02f, 1.44108906e-02f, 9.86000374e-02f, 3.00613269e-02f,
  -6.43520569e-03f, 5.69079481e-02f, 3.14261913e-02f, 6.28652573e-02f, -1.15816861e-01f, -1.33262128e-01f, -2.33283751e-02f, 5.78458272e-02f, 1.10899862e-02f, -5.42739555e-02f,
  5.93928918e-02f, 9.27789323e-03f, -1.53213153e-02f, 2.83013694e-02f, -1.08573362e-02f, 1.69114154e-02f, 7.97865689e-02f, 1.21904910e-01f, -5.54586761e-02f, -9.49943718e-03f,
  -1.44257564e-02f, 6.83289096e-02f, 4.43235748e-02f, -3.99417244e-02f, 2.56605502e-02f, 1.05083197e-01f, 3.67888249e-02f, 2.10648472e-03f, -8.80199205e-03f, 4.54536453e-02f,
  4.73722927e-02f, -1.49793759e-01f, -9.01165530e-02f, -1.69631466e-02f, 2.56391745e-02f, -1.65134091e-02f, 1.20066598e-01f, -1.88571457e-02f, 6.98855072e-02f, 8.42510760e-02f,
  3.11700962e-02f, 1.21497360e-04f, -4.89232177e-03f, 3.45630310e-02f, 9.62247774e-02f, 5.46710268e-02f, 3.51254158e-02f, -7.53595680e-02f, -5.51902615e-02f, 3.68254073e-02f,
  5.77024333e-02f, -2.28869729e-02f, 6.96087703e-02f, -5.17279729e-02f, -7.06852227e-02f, 1.70705855e-01f, -1.16499148e-01f, -5.65644838e-02f, -5.62875299e-03f, 1.55301886e-02f,
  6.37510419e-02f, 1.30119734e-04f, -4.71096858e-02f, 3.02043781e-02f, -3.30385682e-03f, 4.80617397e-03f, -5.39061287e-03f, -3.65973376e-02f, 2.40831841e-02f, -1.10032089e-01f,
  1.88265368e-02f, 6.06532916e-02f, 5.90544455e-02f, -3.12928520e-02f, -6.46964535e-02f, -3.77273589e-01f, -1.28174365e-01f, 1.06568515e-01f, 2.57625848e-01f, -1.10854611e-01f,
  -1.33868977e-01f, 2.01947704e-01f, 1.96701717e-02f, -1.72169715e-01f, -3.13054919e-02f, -7.68721998e-02f, -1.79900900e-01f, -2.21019313e-01f, -1.06298486e-02f, -7.93978870e-02f,
  -5.04296087e-03f, -2.36212075e-01f, -1.04262799e-01f, -1.08851880e-01f, -1.11331239e-01f, 1.41219661e-01f, -1.15071096e-01f, 5.98506629e-02f, -1.36971220e-01f, -7.27913305e-02f,
  -1.04210317e-01f, 3.82679515e-02f, 4.89630327e-02f, -6.97844056e-03f, -1.10251782e-02f, -1.09965324e-01f, -9.19267982e-02f, 3.28627042e-02f, 9.97754708e-02f, -4.66327779e-02f,
  1.84327215e-02f, 1.62665714e-02f, -5.07860407e-02f, -1.33468844e-02f, -5.15006818e-02f, 8.12851489e-02f, 6.64009750e-02f, 1.07312957e-02f, 1.36146843e-01f, -6.02215482e-03f,
  3.94561626e-02f, 2.44740024e-02f, 1.03751816e-01f, 4.62740287e-02f, -1.94183420e-02f, -2.51043290e-02f, 3.46106365e-02f, -2.03290060e-02f, 5.91065697e-02f, -2.49480158e-02f,
  -5.88023774e-02f, -6.79901466e-02f, -5.61985606e-03f, -8.05247575e-02f, -4.53438424e-02f, 1.00321531e-01f, -1.92944370e-02f, -3.80027257e-02f, 4.06034105e-02f, -4.66932692e-02f,
  -5.20846285e-02f, 5.24364561e-02f, -5.75343966e-02f, 9.20200814e-03f, -6.50043115e-02f, -3.35675962e-02f, -5.62089980e-02f, -6.81205420e-03f, 3.30847385e-03f, -2.64159683e-02f,
  2.65370347e-02f, -1.83440037e-02f, -7.78502077e-02f, -3.06461174e-02f, -1.11785829e-02f, -2.78167110e-02f, 8.79442617e-02f, 6.52146861e-02f, 4.00704555e-02f, 1.34347361e-02f,
  -4.93171671e-03f, -2.12522447e-02f, -3.07609998e-02f, -9.65587981e-03f, 2.41152029e-02f, -3.51214316e-04f, -2.75697596e-02f, -2.90892888e-02f, 2.57608574e-02f, -1.24227852e-02f,
  -9.86105576e-02f, -1.36695299e-02f, -1.04876995e-01f, 2.29786877e-02f, 2.85229925e-02f, -1.60450656e-02f, -3.19056287e-02f, 2.50122491e-02f, -1.10802287e-02f, -8.31862167e-02f,
  1.80930365e-02f, -1.01734335e-02f, -2.11762860e-02f, -5.33970855e-02f, -5.78559823e-02f, -9.91216302e-03f, -1.17753096e-01f, 5.74165024e-02f, -2.31304318e-02f, 6.61052065e-04f,
  1.50826275e-01f, -6.86052963e-02f, -3.77428859e-01f, 9.08101648e-02f, -1.19649425e-01f, 1.00692451e-01f, -3.52687016e-02f, -8.36149901e-02f, 1.80004746e-01f, 1.89895809e-01f,
  -4.39554043e-02f, -8.14470425e-02f, -9.79537293e-02f, 3.04583341e-01f, 1.31846247e-02f, 9.28995013e-02f, 3.91446471e-01f, 1.36689290e-01f, 6.72287494e-02f, 1.14744008e-01f,
  -1.03278328e-02f, 1.63261622e-01f, -1.88776374e-01f, -4.29551117e-02f, -1.71627775e-01f, -3.55932601e-02f, 9.97975618e-02f, -2.33383283e-01f, 9.34524164e-02f, -1.28820434e-01f,
  4.19703797e-02f, -2.95637529e-02f, -2.27206992e-03f, -4.56985608e-02f, -6.19952418e-02f, 3.58794034e-02f, 4.98446710e-02f, -1.52465716e-01f, 1.22184795e-03f, -4.39325348e-03f,
  -1.30821407e-01f, -6.82334229e-02f, -3.57586555e-02f, -3.80588323e-02f, -1.22982204e-01f, -1.52895944e-02f, -4.01232392e-02f, -4.08681557e-02f, -1.24119669e-01f, -1.54003814e-01f,
  4.07572053e-02f, -2.36993078e-02f, 6.87476322e-02f, 2.45606084e-03f, -5.55359013e-02f, 9.55552086e-02f, -4.28051651e-02f, -6.95094615e-02f, 3.93007137e-02f, 1.17020108e-01f,
  3.51137631e-02f, -4.97211069e-02f, -1.03197545e-01f, -9.02410150e-02f, 8.89948010e-02f, 6.15053068e-05f, -5.21642454e-02f, -4.99079302e-02f, 1.15756225e-02f, -1.22949444e-02f,
  4.14061248e-02f, -1.25027761e-01f, -4.38175313e-02f, 5.42191565e-02f, 3.17413695e-02f, 7.61207193e-02f, -8.42873603e-02f, -7.94485305e-03f, 4.82831076e-02f, -1.01828642e-01f,
  1.89761724e-02f, 6.44026548e-02f, 1.78333335e-02f, -1.25810638e-01f, -3.55469668e-03f, -7.35345259e-02f, -3.45887616e-02f, 2.12915819e-02f, 2.37532463e-02f, -1.32388443e-01f,
  4.15822044e-02f, 1.78549349e-01f, 2.72499882e-02f, 8.91653262e-03f, -5.97912148e-02f, 4.31556851e-02f, -7.72239342e-02f, 1.72172282e-02f, 2.61478890e-02f, -9.84300394e-03f,
  -8.31603131e-04f, -1.01664737e-02f, 4.76271175e-02f, -1.14502804e-02f, -8.79249424e-02f, -9.45795700e-02f, 1.28675506e-01f, 3.69315073e-02f, 9.82262492e-02f, -7.49585032e-02f,
  7.04489201e-02f, 1.09810822e-01f, 1.04830302e-02f, 3.53088453e-02f, -3.31672318e-02f, 8.43795598e-04f, 3.70418653e-02f, 4.66063581e-02f, 1.89935938e-02f, 3.75821837e-03f,
  -1.99295551e-01f, 2.60225534e-01f, 3.01021904e-01f, 7.47072995e-02f, 9.75211710e-02f, 2.96001077e-01f, -8.56793206e-03f, 1.16087444e-01f, -1.59974173e-01f, -2.17734590e-01f,
  -1.30717248e-01f, -1.41357362e-01f, 4.76109236e-02f, -9.59596857e-02f, 1.00168645e-01f, -5.23015223e-02f, 1.04613543e-01f, 5.22270165e-02f, 6.50156615e-03f, 1.89402565e-01f,
  6.97987303e-02f, 1.88550651e-01f, 1.19279407e-01f, 8.27956051e-02f, 5.50680012e-02f, -7.61869503e-03f, -5.47320507e-02f, -4.01720963e-02f, 4.85020084e-03f, -4.12520096e-02f,
  -7.26990774e-03f, -4.22333069e-02f, -1.04771005e-02f, -4.91450876e-02f, 1.64867610e-01f, 1.80263445e-02f, -1.02730565e-01f, -6.49117306e-02f, -1.35701811e-02f, 1.11128785e-01f,
  1.81139242e-02f, -8.76358002e-02f, 3.05434864e-04f, -3.77448052e-02f, 7.65203983e-02f, -1.43966302e-02f, 5.04806638e-02f, 9.12601948e-02f, 5.70084825e-02f, -4.30944674e-02f,
  7.98625946e-02f, 6.43913448e-02f, 6.16676770e-02f, 8.73354822e-02f, 1.26431072e-02f, -1.07877571e-02f, -2.23180912e-02f, 7.46665075e-02f, 1.20999768e-01f, 7.41582215e-02f,
  -1.16624683e-02f, -8.83796290e-02f, 1.98524743e-02f, -1.04052834e-01f, 5.10820113e-02f, -1.20812327e-01f, -1.61782454e-03f, 4.35407925e-03f, -4.02809903e-02f, 3.05508431e-02f,
  -4.75487076e-02f, 5.92907928e-02f, -1.26167506e-01f, 4.72696219e-03f, -1.61638707e-02f, -4.72270958e-02f, -8.64521787e-02f, -9.90677327e-02f, -4.71188948e-02f, 1.97544936e-02f,
  -1.55333862e-01f, -1.97463017e-02f, -9.80331600e-02f, -1.37002440e-02f, -1.09455232e-02f, 6.35997355e-02f, 7.68079981e-02f, -1.03199162e-01f, -4.80452068e-02f, 1.97284684e-01f,
  1.48712054e-01f, 1.85426667e-01f, -1.95326537e-01f, -1.17272139e-01f, -1.37321040e-01f, 3.31301205e-02f, 2.09818445e-02f, -4.84127477e-02f, 8.30409452e-02f, 7.49677867e-02f,
  2.71198098e-02f, -1.05203740e-01f, 9.64335203e-02f, -5.79901524e-02f, 5.74054457e-02f, -7.66154155e-02f, -3.37494314e-02f, -3.47357802e-02f, 4.96362299e-02f, -1.08314119e-01f,
  5.92275001e-02f, -2.09747627e-02f, -2.45354008e-02f, 5.56613542e-02f, -9.69878118e-03f, -6.05729595e-02f, 2.36016661e-02f, -6.91653788e-02f, 1.15358524e-01f, -6.99423030e-02f,
  1.36309117e-01f, -5.95420226e-02f, -8.85933861e-02f, -2.34286219e-01f, -3.02994639e-01f, 4.99060862e-02f, -2.12042443e-02f, -9.01254490e-02f, -1.46430284e-01f, 6.06295578e-02f,
  -1.02283871e-02f, 4.01093140e-02f, 3.59369963e-01f, -3.50871049e-02f, 6.76735044e-02f, 3.05295855e-01f, -2.23635986e-01f, -1.61084026e-01f, -2.62741633e-02f, -3.95067297e-02f,
  4.49124314e-02f, -1.90354317e-01f, 9.38959345e-02f, -9.07917172e-02f, -1.40938729e-01f, -2.53953915e-02f, -5.35469353e-02f, 2.97982767e-02f, -1.26841277e-01f, -6.59527481e-02f,
  -4.05469388e-02f, 4.57305722e-02f, 1.10479556e-02f, 9.00251493e-02f, -2.80219261e-02f, -2.05696002e-02f, -9.82386619e-02f, -1.41298408e-02f, 4.01480496e-02f, -4.96206135e-02f,
  8.28966498e-02f, 6.88244775e-02f, 9.41753620e-04f, 4.36823778e-02f, -7.25236610e-02f, -1.67740267e-02f, 4.08685543e-02f, -5.78607805e-02f, 1.78932603e-02f, 1.15129195e-01f,
  2.92705372e-02f, 4.12587896e-02f, 3.69676985e-02f, -6.25262484e-02f, 1.11902170e-01f, -4.83444035e-02f, 4.39284518e-02f, 4.35833447e-03f, 1.53247073e-01f, -6.20608106e-02f,
  4.19236645e-02f, 4.75945249e-02f, 5.18252701e-02f, -8.69917125e-02f, -8.10828581e-02f, -1.21231236e-01f, 8.36977512e-02f, 9.21847522e-02f, -1.33656546e-01f, -5.77559806e-02f,
  -6.76453039e-02f, -4.51764576e-02f, 1.15946028e-02f, 5.92399314e-02f, 5.59623502e-02f, 4.23840620e-02f, 8.26152563e-02f, -4.53802496e-02f, -7.50879645e-02f, -2.70760227e-02f,
  8.93270001e-02f, 4.87993471e-02f, 2.77602486e-02f, 4.89433557e-02f, -1.20581731e-01f, -5.92265390e-02f, 7.87697807e-02f, 9.70017090e-02f, -6.15157979e-03f, -4.29204461e-04f,
  5.72830662e-02f, -9.49778780e-03f, 1.13592967e-02f, 6.96645528e-02f, -9.06439051e-02f, -8.93992633e-02f, -6.71408623e-02f, -9.90992710e-02f, 5.17005734e-02f, 4.14767396e-03f,
  1.12411298e-01f, 1.00945204e-01f, 1.31617710e-01f, 1.35700386e-02f, 3.71885151e-02f, 2.87499055e-02f, 6.09546229e-02f, -6.28627390e-02f, -7.25094303e-02f, -1.89998653e-02f,
  6.41363114e-02f, -1.12499557e-02f, -2.42508147e-02f, -9.92197096e-02f, 4.15392444e-02f, 1.16274714e-01f, -5.19609638e-02f, 3.97529416e-02f, 1.27353668e-01f, 1.22673763e-02f,
  -3.49962324e-01f, 3.01449597e-01f, 1.52092678e-02f, -6.41715303e-02f, -4.97264452e-02f, 3.69021356e-01f, 1.49104133e-01f, 2.03713283e-01f, 1.55195609e-01f, 2.82360256e-01f,
  1.14311697e-02f, -4.53549586e-02f, 1.40497074e-01f, 2.06631720e-01f, 5.54207154e-02f, 1.56696633e-01f, 1.68393284e-01f, -3.27327102e-02f, -3.42076197e-02f, -7.64612108e-02f,
  -3.07074822e-02f, 8.40882584e-02f, 1.29860237e-01f, 6.00069612e-02f, 8.56873393e-02f, -8.68485048e-02f, -8.41926336e-02f, -1.30230442e-01f, 1.40742362e-01f, 9.47137550e-02f,
  -6.08787760e-02f, -4.82899919e-02f, 1.87119525e-02f, 3.43489721e-02f, 2.84054801e-02f, -1.90188568e-02f, -5.93050867e-02f, -4.80243526e-02f, -5.54496236e-02f, 4.54033017e-02f,
  -2.64099836e-02f, 5.07932575e-03f, 3.39272507e-02f, 3.43670659e-02f, -8.18948895e-02f, 1.15675271e-01f, 4.35883291e-02f, 2.51701716e-02f, 5.34204356e-02f, -4.99234647e-02f,
  1.18673384e-01f, -1.02068968e-02f, 4.61384244e-02f, -3.01709748e-03f, 2.43840297e-03f, 7.12402761e-02f, 3.45853827e-04f, -3.00172232e-02f, 7.50163198e-02f, 2.07300335e-02f,
  7.17841983e-02f, -2.73958649e-02f, -1.25439344e-02f, 3.49615444e-03f, -2.66796723e-02f, -2.47779004e-02f, 3.97836231e-02f, -7.14323893e-02f, 5.06861880e-02f, 3.84307615e-02f,
  -9.85482186e-02f, 2.07586922e-02f, -5.97478962e-03f, 3.96407694e-02f, -6.10086024e-02f, -1.28842294e-01f, -9.97146517e-02f, 1.58770625e-02f, -4.96815071e-02f, 3.73457512e-03f,
  -9.82464850e-02f, 3.00127584e-02f, 1.15848966e-01f, 4.66863886e-02f, 6.48488924e-02f, -2.51083430e-02f, 1.45697180e-04f, 5.26847020e-02f, -4.01450247e-02f, 2.29747836e-02f,
  1.84359387e-01f, 9.16344896e-02f, 1.65728740e-02f, -4.95125763e-02f, -4.61387672e-02f, 2.00521238e-02f, -1.90425534e-02f, 1.48605078e-01f, 4.97745685e-02f, -1.17911762e-02f,
  -2.22655479e-02f, -1.92574747e-02f, -4.30582017e-02f, 9.36582237e-02f, 3.66118588e-02f, 3.41114774e-02f, -2.66168881e-02f, 9.00183711e-03f, -1.37685761e-02f, -4.19434346e-02f,
  -3.81600000e-02f, -8.28747749e-02f, -4.89480905e-02f, -1.06217293e-02f, -5.34028672e-02f, -5.13618216e-02f, -1.22654028e-01f, 5.95877122e-04f, 2.78661144e-03f, 1.04538590e-01f,
  6.33812249e-02f, -1.56158835e-01f, -4.17232476e-02f, -2.66328715e-02f, 2.55218029e-01f, 1.28375143e-01f, 3.09246868e-01f, 7.52792731e-02f, 3.79878394e-02f, -2.85812795e-01f,
  -1.05619468e-01f, 5.12147648e-03f, 1.07842252e-01f, 7.61460885e-02f, 3.95954937e-01f, 6.29326552e-02f, -1.12821631e-01f, -1.85811013e-01f, -2.07391270e-02f, 1.40840814e-01f,
  2.54513770e-01f, 7.28185475e-02f, 1.67723611e-01f, 5.53134410e-03f, -3.50436941e-02f, -6.04544654e-02f, -4.47734408e-02f, 2.08755150e-01f, -5.61614484e-02f, 5.84263168e-02f,
  -1.96440950e-01f, -1.79734558e-01f, 8.25787487e-04f, -1.32764891e-01f, -6.96633384e-02f, -3.03828046e-02f, 3.26858014e-02f, 2.08489113e-02f, -4.90033813e-03f, 4.71988022e-02f,
  -7.50117004e-02f, 3.00599039e-02f, 6.76632226e-02f, -2.96172127e-02f, 2.49014460e-02f, -7.76784588e-03f, 1.01455301e-01f, -1.06331877e-01f, 1.50353268e-01f, 1.35989681e-01f,
  1.47911817e-01f, 4.64926139e-02f, 3.22687104e-02f, 7.99745787e-03f, 5.72869405e-02f, -1.23226438e-02f, -7.60427490e-02f, 7.07348064e-02f, -2.82407552e-02f, -2.14918833e-02f,
  1.47730947e-01f, -1.51373923e-01f, 7.04771206e-02f, -1.16173655e-01f, 3.32837924e-02f, 4.71222177e-02f, 4.98755388e-02f, -6.27215281e-02f, -1.11761307e-02f, -1.10740669e-01f,
  -4.04721946e-02f, -3.05491854e-02f, -1.21578470e-01f, -3.26501168e-02f, -8.46292078e-02f, 1.15478095e-02f, 1.57790333e-02f, -6.72031417e-02f, 6.05930127e-02f, 2.69406755e-02f,
  -7.64229745e-02f, -2.22109538e-03f, 1.74602568e-02f, -5.53078875e-02f, -1.02739193e-01f, 5.65263070e-02f, -2.31720544e-02f, -5.35841612e-03f, 6.18047789e-02f, 4.80189174e-02f,
  -2.35367507e-01f, -2.19040468e-01f, 1.20932721e-02f, -1.55080920e-02f, -4.81692255e-02f, -5.00930585e-02f, 2.15245243e-02f, 5.44067100e-03f, -1.80473048e-02f, 6.68207929e-02f,
  -1.13730378e-01f, -3.63697745e-02f, -8.70619042e-05f, 2.86771711e-02f, 4.74739773e-03f, 4.02179398e-02f, 1.38121143e-01f, -6.56233216e-03f, 7.22276121e-02f, 4.68719117e-02f,
  -7.52332760e-03f, -1.33809801e-02f, -4.19323042e-04f, 1.23003662e-01f, -8.49213079e-02f, 2.42562070e-02f, -9.36282054e-02f, -6.28938247e-03f, 3.37658674e-02f, -9.56222862e-02f,
  1.29086003e-01f, -1.95012897e-01f, -2.69970521e-02f, 5.76297473e-03f, 1.85827047e-01f, 2.24890426e-01f, 7.68533796e-02f, 1.06230959e-01f, 2.73515674e-04f, -2.08897367e-01f,
  5.91000319e-02f, -1.48552164e-01f, -3.78730819e-02f, 7.92013258e-02f, 3.37187409e-01f, -1.09104976e-01f, 9.85731184e-02f, -4.44406979e-02f, -1.31437466e-01f, 1.68381222e-02f,
  1.49478510e-01f, 6.96846247e-02f, 2.39535724e-03f, -1.27330393e-01f, -1.09564885e-01f, -1.13342986e-01f, 2.61519160e-02f, -2.40907893e-01f, -9.43194106e-02f, 4.79093120e-02f,
  1.19503401e-01f, -1.12046421e-01f, -4.84505445e-02f, 6.38180366e-03f, 1.28027588e-01f, -1.22848682e-01f, -7.15476722e-02f, -9.76097137e-02f, 1.04183123e-01f, -3.77349369e-02f,
  -1.21791875e-02f, -3.04243881e-02f, 4.79025207e-02f, -1.24762714e-01f, -7.24802166e-02f, -1.06687471e-03f, 9.81037915e-02f, 3.38100195e-02f, -1.52370874e-02f, 4.00237413e-03f,
  2.65817605e-02f, 1.15953442e-02f, -1.75511874e-02f, -5.15335128e-02f, 6.69800267e-02f, 7.46243596e-02f, -5.46313971e-02f, -2.34683789e-02f, 1.37132863e-02f, 1.74881853e-02f,
  3.35929543e-02f, 3.54115888e-02f, -1.96450017e-02f, -4.17081118e-02f, 1.11185550e-03f, 1.17432944e-01f, 2.26615043e-03f, -6.94717020e-02f, 7.74260331e-03f, -3.06513114e-03f,
  -1.35598816e-02f, 3.98331136e-02f, -2.12017391e-02f, -1.09603554e-01f, 1.00217555e-02f, -4.30254787e-02f, -2.35739574e-02f, -1.07160702e-01f, 2.05431785e-02f, 8.04868937e-02f,
  -1.18947990e-01f, 3.94348502e-02f, 9.48494971e-02f, 1.37663364e-01f, 6.65975586e-02f, -2.05533067e-03f, -1.84141025e-02f, -1.83245465e-02f, 7.00054169e-02f, 7.72842094e-02f,
  1.65974960e-01f, 6.57110959e-02f, 4.38167155e-02f, -1.68924453e-03f, 7.42854178e-02f, -7.14765713e-02f, 1.41873565e-02f, -5.75285591e-02f, 3.72398384e-02f, -5.30804321e-02f,
  -2.11599792e-04f, -4.91405167e-02f, -4.06916849e-02f, -1.44498628e-02f, -1.35799246e-02f, 4.40811999e-02f, 6.83998764e-02f, 8.57517421e-02f, 1.00869440e-01f, 1.12587269e-02f,
  3.84563580e-02f, 1.07067581e-02f, 2.98739318e-02f, 3.95211540e-02f, -6.98059201e-02f, 1.33110955e-01f, 4.01352160e-02f, -4.83408608e-02f, 2.49802954e-02f, 3.40508297e-02f,
  1.86448634e-01f, -1.25109777e-01f, -6.03575706e-02f, -2.17978340e-02f, 2.22749650e-01f, 6.39222711e-02f, -2.03679670e-02f, 7.80822520e-05f, -2.25647673e-01f, -4.55593877e-02f,
  2.09025592e-01f, 6.70687715e-03f, 4.80093695e-02f, -1.29855322e-02f, 2.55016863e-01f, -6.01478368e-02f, 8.04535300e-02f, 9.16277245e-02f, 3.22963297e-02f, 1.36788517e-01f,
  9.09411833e-02f, 1.24373823e-01f, 1.70025483e-01f, 8.87672305e-02f, 1.24210246e-01f, 1.02818012e-02f, 2.43187189e-01f, -4.24152091e-02f, 1.70318782e-01f, 2.48266365e-02f,
  5.47739938e-02f, 4.85170074e-03f, 3.06812767e-02f, -5.73717281e-02f, 1.67778313e-01f, -9.77095291e-02f, 1.03124441e-03f, 5.58395032e-03f, 7.38334805e-02f, 3.00184134e-02f,
  1.16713196e-02f, 8.36042389e-02f, -1.30552337e-01f, -1.62729979e-01f, -1.03176929e-01f, -5.11421496e-03f, 5.67311384e-02f, 7.26313666e-02f, 4.42257002e-02f, 7.57633224e-02f,
  7.59026110e-02f, 8.51428416e-03f, -9.71146151e-02f, 2.09528245e-02f, 7.00001568e-02f, 4.94354293e-02f, 4.35848571e-02f, 1.51453421e-01f, 2.15467308e-02f, -1.95198432e-02f,
  -1.09132016e-02f, -2.61945054e-02f, 6.52475804e-02f, 3.73501442e-02f, 4.90589105e-02f, 9.32926312e-02f, 7.48279318e-03f, 1.06794514e-01f, 1.87287349e-02f, 5.07232994e-02f,
  5.81949204e-02f, 4.70218919e-02f, -1.24462739e-01f, -1.82904378e-02f, -7.05159176e-03f, -1.44438744e-01f, 3.38723743e-03f, 1.64485108e-02f, -3.01386602e-02f, -4.23349962e-02f,
  -1.91663206e-01f, -7.33888596e-02f, 1.28779277e-01f, 3.33128013e-02f, -4.69577163e-02f, 5.36230393e-02f, 2.63105053e-02f, -1.82683486e-02f, 5.75339831e-02f, 4.23077159e-02f,
  1.42673239e-01f, 5.80086336e-02f, -5.71257435e-03f, 4.55834065e-03f, 7.95556419e-03f, 2.09169500e-02f, -6.27853423e-02f, -4.67381626e-02f, 8.78417641e-02f, 1.76048484e-02f,
  9.05894935e-02f, 4.11282443e-02f, -8.14867392e-02f, 3.57667468e-02f, -6.19444661e-02f, 1.43952575e-02f, 9.21370834e-02f, 1.13547027e-01f, 1.11720022e-02f, 1.50573403e-01f,
  9.31094363e-02f, 1.16476551e-01f, -1.14059367e-03f, 2.88361721e-02f, -1.36683419e-01f, 1.43411890e-01f, 3.31686139e-02f, -5.43545410e-02f, 3.69034000e-02f, -4.96609956e-02f,
  5.57038784e-01f, -1.64739579e-01f, 1.61821887e-01f, 2.40245480e-02f, -6.02832884e-02f, 7.18805119e-02f, 2.78818727e-01f, -7.08849803e-02f, 2.92340249e-01f, -1.50408730e-01f,
  2.07465095e-03f, 9.63573977e-02f, 1.45593822e-01f, -1.27890572e-01f, 1.58088982e-01f, 1.91210493e-01f, -1.38290167e-01f, -6.72794431e-02f, 8.01957771e-02f, -9.78010520e-02f,
  1.09012373e-01f, -3.24602604e-01f, -2.86542475e-02f, -2.83386946e-01f, -6.57576174e-02f, 2.89919637e-02f, -3.22343588e-01f, 2.09956598e-02f, -2.44528085e-01f, -7.33735263e-02f,
  -8.35829042e-03f, 6.56032488e-02f, 9.80987847e-02f, 8.11488554e-02f, -1.20490920e-02f, 1.09692356e-02f, 4.65486944e-02f, 2.51110494e-02f, 7.01923482e-03f, 2.27398835e-02f,
  8.02172348e-02f, 9.75233912e-02f, 4.86545870e-03f, 7.15620220e-02f, -2.20699310e-02f, -2.48468686e-02f, -1.06953112e-02f, 1.96413491e-02f, 1.06096594e-03f, 4.08658609e-02f,
  6.02633804e-02f, -4.23273034e-02f, 2.38547567e-02f, 4.06962354e-03f, 2.52588149e-02f, 3.96032669e-02f, -2.52700020e-02f, 4.60479371e-02f, 9.93007445e-04f, 4.09497544e-02f,
  1.64968595e-02f, -7.74185266e-03f, -7.39731789e-02f, 4.45349477e-02f, -4.76074927e-02f, -4.31438945e-02f, 5.05625270e-04f, -9.91966501e-02f, 5.01792431e-02f, -3.91555056e-02f,
  -6.83332048e-03f, -7.48750269e-02f, 4.53330986e-02f, 1.51112210e-02f, 2.01170985e-03f, -2.04240121e-02f, -4.55630594e-04f, -5.29540442e-02f, 5.17766885e-02f, -1.73641704e-02f,
  1.43644679e-02f, 4.23209332e-02f, 2.54586935e-02f, 5.74165024e-02f, 1.16239071e-01f, 1.77102722e-02f, -1.32452309e-01f, 8.80899727e-02f, 3.01983654e-02f, -2.05175136e-03f,
  -1.17124647e-01f, -1.47863343e-01f, 6.36400953e-02f, 3.34074795e-02f, -2.69863345e-02f, -1.28118666e-02f, 6.64583826e-03f, -4.01974563e-03f, 1.60284191e-02f, -2.06028484e-02f,
  -4.06168541e-03f, 6.51365072e-02f, -3.13552655e-03f, 4.61599836e-03f, 1.33764162e-03f, -6.36396110e-02f, -8.71195178e-03f, 7.30395466e-02f, 1.61083229e-02f, -1.26348913e-01f,
  -1.00327596e-01f, 7.79026598e-02f, 4.84952293e-02f, -9.23721418e-02f, -7.73003697e-02f, 8.70327465e-03f, -1.45490309e-02f, 3.83289382e-02f, -7.39148334e-02f, 2.24529440e-03f,
  3.10838252e-01f, -1.82811126e-01f, 8.83319527e-02f, -2.33383492e-01f, 1.12064719e-01f, -1.53351292e-01f, -6.87826201e-02f, 7.33511671e-02f, 2.07463712e-01f, -1.43890589e-01f,
  -7.91074410e-02f, -4.32375781e-02f, 1.58663362e-01f, -3.05812538e-01f, -2.69557685e-01f, -1.91137657e-01f, -3.51159722e-01f, -2.08253592e-01f, 3.83857563e-02f, 5.02734184e-02f,
  2.92582214e-02f, -2.66041696e-01f, -2.40045801e-01f, -6.16548918e-02f, 3.81604931e-03f, 1.48500785e-01f, -7.44520575e-02f, 4.25853431e-02f, -1.97112247e-01f, -1.35155097e-01f,
  -5.67196682e-02f, 1.32652596e-01f, 1.21420190e-01f, 7.83800036e-02f, 5.16552329e-02f, 9.08339992e-02f, -2.92921066e-02f, 2.53279805e-02f, 4.84615006e-02f, 1.41447037e-02f,
  -3.76730934e-02f, 5.80040216e-02f, 4.20335233e-02f, 6.07707798e-02f, -2.45691817e-02f, -4.96786647e-02f, 2.15362827e-03f, 8.36564414e-03f, 1.47163793e-02f, 9.26886685e-03f,
  -2.88695563e-02f, -7.06889182e-02f, -1.49569949e-02f, -4.76491712e-02f, 2.43362878e-02f, 2.53682956e-02f, -8.58587697e-02f, 5.13674272e-03f, 9.73617956e-02f, -7.85886645e-02f,
  -1.28015503e-02f, 9.87015739e-02f, 1.71352103e-02f, 6.15115464e-03f, 2.79184245e-03f, -8.22384804e-02f, -4.80762981e-02f, -2.94452831e-02f, 5.39609510e-03f, -8.48716646e-02f,
  6.84626475e-02f, 4.99830991e-02f, 3.36999372e-02f, 9.71395597e-02f, -2.57157590e-02f, -2.70921309e-02f, 8.53457972e-02f, 3.97354830e-03f, 1.44958990e-02f, -2.62840074e-02f,
  -4.11233567e-02f, 5.75760566e-02f, 7.89177865e-02f, 1.13615021e-03f, -1.50207669e-01f, 2.44158357e-02f, -6.48197457e-02f, 2.97443196e-02f, 5.97159192e-02f, 4.60500829e-02f,
  -7.45037943e-03f, -3.29246409e-02f, 9.53827798e-02f, 5.42285331e-02f, -5.75379208e-02f, 5.21845855e-02f, 2.69985069e-02f, 5.28323539e-02f, -4.21912745e-02f, 7.49770030e-02f,
  -1.69870220e-02f, 4.83539850e-02f, -6.89370185e-03f, 2.68083271e-02f, -1.32307813e-01f, -3.01907826e-02f, -8.18180963e-02f, 4.22877632e-02f, -1.88956934e-03f, -2.27094274e-02f,
  1.29553117e-02f, 5.77074327e-02f, -2.91477274e-02f, -7.09021613e-02f, -7.96238407e-02f, 6.99152648e-02f, 3.82959135e-02f, -7.30704342e-05f, 5.98464627e-03f, -2.64603756e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.14331931e-01f, -1.47840694e-01f, -2.88862854e-01f, -2.41280824e-01f, -1.10147744e-01f, -2.03663528e-01f, -3.56126368e-01f, -7.27990195e-02f, -8.50647911e-02f, 2.80891769e-02f,
  -8.41759518e-02f, -3.91257964e-02f, 1.01113647e-01f, -1.40720204e-01f, 7.42221326e-02f, 2.77872980e-01f, -2.05441132e-01f, 4.19711694e-02f, 8.31174105e-02f, -1.78268135e-01f,
  1.91389918e-02f, -2.54276432e-02f, -3.39124389e-02f, -7.86333308e-02f, -2.01056510e-01f, -3.28950547e-02f, 9.19308886e-02f, -1.20274529e-01f, -1.24297999e-01f, -8.37126672e-02f,
  2.06804182e-02f, 4.21684757e-02f, -9.09659639e-02f, -2.44610142e-02f, -7.83400387e-02f, -7.91379139e-02f, -1.24053493e-01f, -1.16502885e-02f, -1.57875940e-02f, 3.19031551e-02f,
  -3.35368179e-02f, 4.46223989e-02f, -1.03045832e-02f, 5.66566549e-02f, 9.66845527e-02f, -3.42743695e-02f, 3.67736742e-02f, 4.62500416e-02f, -5.72197102e-02f, 7.02157198e-03f,
  -1.47107646e-01f, 3.78680266e-02f, -6.37628958e-02f, 1.12496436e-01f, 5.77383526e-02f, -1.30201835e-04f, -6.08178824e-02f, 1.66967697e-02f, -4.62984573e-03f, -3.77180963e-03f,
  3.71426567e-02f, 1.78430267e-02f, 7.10864514e-02f, -6.19855821e-02f, -1.47444487e-01f, 2.11219080e-02f, -5.95724247e-02f, 2.16081608e-02f, -3.76719423e-02f, 3.57734747e-02f,
  5.92295974e-02f, -1.12197399e-01f, 8.68041348e-03f, 7.18375593e-02f, -8.15757588e-02f, 1.84761081e-02f, 1.21730473e-02f, -2.87976279e-03f, -1.25684559e-01f, 1.59797389e-02f,
  3.08254454e-02f, -1.74249138e-03f, -1.95692349e-02f, 5.04659526e-02f, -5.87082375e-03f, -1.88999381e-02f, -5.04028164e-02f, 6.69796914e-02f, 3.15988325e-02f, -4.96331677e-02f,
  -1.13109872e-01f, -8.03197026e-02f, 9.79241636e-03f, -5.55669591e-02f, -3.98234464e-02f, 3.08062993e-02f, -5.48296124e-02f, -5.74390143e-02f, 4.71238932e-03f, -3.22074741e-02f,
  2.40040012e-02f, 2.52515916e-02f, -3.52143496e-02f, 6.75334781e-02f, 2.75803171e-02f, -1.10894293e-01f, -3.18753757e-02f, -7.80458003e-02f, -1.31769255e-01f, -9.56030190e-03f,
  -7.28316605e-02f, 1.02543868e-02f, 3.58305089e-02f, 1.02043249e-01f, 7.93311074e-02f, -8.34307298e-02f, -6.91936314e-02f, -1.80259557e-03f, -3.08539509e-03f, 4.71189059e-02f,
  2.70574868e-01f, 1.23241305e-01f, 2.77338445e-01f, 2.28854150e-01f, 1.12136319e-01f, 2.01687083e-01f, 8.65190327e-02f, 3.59906077e-01f, 4.15451407e-01f, -1.56048805e-01f,
  -1.62754253e-01f, 8.22919235e-03f, 5.29485866e-02f, -6.49598092e-02f, -1.82936385e-01f, 4.76267375e-02f, 1.19269192e-01f, 2.58641653e-02f, 2.85771251e-01f, 1.47755027e-01f,
  5.93782887e-02f, -1.23863965e-01f, -6.03809096e-02f, 1.02850050e-01f, -5.74880466e-03f, 2.01664083e-02f, -4.44188714e-01f, -3.02389022e-02f, -2.69731224e-01f, -7.76509643e-02f,
  -9.51588303e-02f, 1.91778079e-01f, 2.00061258e-02f, 9.86943319e-02f, 5.96616119e-02f, 4.70924117e-02f, -2.24677131e-01f, -9.10948664e-02f, -8.34489539e-02f, 2.27617528e-02f,
  -3.49308476e-02f, -5.46882264e-02f, 1.17434086e-02f, -5.08161727e-03f, 1.12357020e-01f, 2.29617264e-02f, 1.20335799e-02f, 1.33603171e-01f, 4.74255830e-02f, 1.79284185e-01f,
  1.06353596e-01f, 7.19922110e-02f, 1.23571225e-01f, -1.13493288e-02f, -8.43982399e-02f, -2.83216722e-02f, 1.15518197e-02f, -1.02188699e-01f, -6.71547046e-03f, 1.34173393e-01f,
  6.40343800e-02f, 4.25112136e-02f, -1.72690991e-02f, 4.30734530e-02f, 8.63843411e-03f, -8.78399797e-03f, -7.86936134e-02f, -1.30522087e-01f, 3.73426676e-02f, 3.44268745e-03f,
  -8.05519819e-02f, -1.32429361e-01f, 1.42181024e-01f, 2.40744986e-02f, 6.91090599e-02f, 9.09856856e-02f, 2.18781717e-02f, 1.29664559e-02f, 1.56165687e-02f, -5.77673651e-02f,
  8.01610351e-02f, 3.07020713e-02f, -5.45576736e-02f, -5.56653030e-02f, 6.98751211e-02f, 2.97586732e-02f, -9.99155641e-02f, 1.30722523e-01f, 1.16755785e-02f, -4.53903427e-04f,
  -1.38876334e-01f, -2.25386582e-02f, -1.14668719e-01f, 7.94773921e-03f, -4.27993238e-02f, -1.84263159e-02f, -5.05377818e-03f, 9.85468272e-03f, -4.79033999e-02f, 9.61821973e-02f,
  7.25668902e-03f, 5.29093901e-03f, -8.15411434e-02f, -6.44422174e-02f, -7.87791312e-02f, -6.10166341e-02f, -1.09495245e-01f, -1.53855858e-02f, -6.31912053e-02f, 2.65030153e-02f,
  6.20585531e-02f, -7.82769993e-02f, -5.72885349e-02f, -2.36282386e-02f, 1.13937473e-02f, -1.43182576e-01f, 3.63510810e-02f, 6.60422221e-02f, 5.35288220e-03f, 3.40342452e-03f,
  1.63135082e-01f, 3.68133187e-01f, 2.16040686e-01f, 1.97570503e-01f, -2.59391725e-01f, -7.96810761e-02f, 2.70360336e-02f, -1.02481712e-02f, 1.01283297e-01f, 1.51233926e-01f,
  -2.50129342e-01f, 4.15018916e-01f, -1.70027509e-01f, -2.38039102e-02f, -2.42746487e-01f, -3.08378875e-01f, 5.65655045e-02f, 6.94503710e-02f, -2.06154827e-02f, 6.60361573e-02f,
  7.16727693e-03f, -3.33779603e-01f, -1.15572728e-01f, -1.67781860e-01f, 2.99719218e-02f, 1.15469530e-01f, -2.34653443e-01f, -1.33492008e-01f, 1.89958900e-01f, -6.96764216e-02f,
  5.75007573e-02f, 1.38862859e-02f, 3.66606703e-03f, 4.23303992e-02f, -5.78096882e-03f, -9.45140719e-02f, -1.19441319e-02f, -6.07093759e-02f, -9.38575249e-03f, -3.37374350e-03f,
  5.73656000e-02f, -4.17396575e-02f, 2.11008877e-01f, -8.88978019e-02f, -1.66447368e-02f, 5.36999628e-02f, 2.42941566e-02f, 1.08006746e-01f, 1.28890574e-01f, -1.14308689e-02f,
  2.01943833e-02f, 1.14733338e-01f, -1.16038900e-02f, 1.29878491e-01f, 3.00051682e-02f, 1.19327791e-01f, 1.04011185e-01f, 9.77668911e-03f, 1.04758881e-01f, 5.98446056e-02f,
  8.53944942e-02f, -1.26528680e-01f, -1.07648328e-01f, -4.28241305e-02f, -6.76381066e-02f, 4.81161149e-03f, 6.53323010e-02f, 9.44421999e-03f, 1.19058438e-01f, -1.90113902e-01f,
  -5.55634573e-02f, 6.59411354e-03f, -4.82302271e-02f, 6.41452475e-03f, 3.20369974e-02f, -2.09700726e-02f, -9.44431573e-02f, 2.81646363e-02f, 3.20685096e-03f, 5.07207662e-02f,
  -6.61192834e-02f, -4.87684943e-02f, 1.27973850e-03f, 1.85499564e-02f, -7.79546499e-02f, 5.54760285e-02f, 2.94905715e-02f, 1.85041931e-02f, 1.31074456e-03f, 1.79181658e-02f,
  2.06470750e-02f, 1.65616527e-01f, 3.97077091e-02f, -3.42062488e-02f, 4.43775170e-02f, -3.37595716e-02f, 6.58740848e-02f, 6.63527325e-02f, 1.45923495e-01f, -1.65193066e-01f,
  -6.01620376e-02f, -6.52944595e-02f, 2.52230205e-02f, -4.43925224e-02f, -6.75436668e-03f, 7.27935880e-02f, 8.29041675e-02f, 4.77557220e-02f, 1.74455214e-02f, 8.81924469e-04f,
  1.51202679e-02f, 3.19577716e-02f, 2.07185205e-02f, 3.28524970e-02f, -1.50886225e-02f, 6.86422884e-02f, 6.74763918e-02f, 1.13085829e-01f, -8.07379484e-02f, 4.98386361e-02f,
  -2.93252128e-03f, -2.73559871e-03f, -5.88407032e-02f, 1.68264419e-01f, -1.00932553e-01f, -8.43599662e-02f, -8.94117132e-02f, -1.16877504e-01f, -1.70371026e-01f, 1.17358178e-01f,
  7.11277500e-02f, 1.68074314e-02f, 1.81032375e-01f, 1.73419327e-01f, -2.27699685e-03f, 5.74737042e-02f, 2.07495227e-01f, 1.25960141e-01f, -8.27600434e-02f, 2.91799098e-01f,
  1.30178824e-01f, 1.59891263e-01f, 7.33929649e-02f, 9.52753648e-02f, 1.98099930e-02f, 1.07499305e-03f, 1.13877073e-01f, 1.05073921e-01f, 2.36110926e-01f, -3.23718339e-02f,
  3.20528299e-02f, 8.38696361e-02f, -7.83970132e-02f, 2.26228833e-02f, 5.37823290e-02f, 8.84174556e-02f, 3.03139500e-02f, -4.72334176e-02f, -4.11791429e-02f, 1.19849285e-02f,
  -3.20955440e-02f, -9.99350846e-02f, -2.54492890e-02f, -3.24859358e-02f, -8.18664581e-02f, -7.73999989e-02f, -4.52623256e-02f, -1.10057425e-02f, 2.93785445e-02f, 6.33963048e-02f,
  3.45257763e-03f, -7.11994767e-02f, -2.96757706e-02f, 4.57214899e-02f, -2.63504460e-02f, -4.87037264e-02f, -3.81906070e-02f, 7.80372275e-03f, -7.71948621e-02f, -3.52322403e-03f,
  1.56611241e-02f, 1.07193708e-01f, -4.54242434e-03f, -6.93426132e-02f, 3.45575884e-02f, 6.21010130e-03f, -3.15717347e-02f, 6.24633543e-02f, 1.32470615e-02f, 1.19177684e-01f,
  5.79904094e-02f, 1.68973673e-02f, 3.96855660e-02f, -7.98068196e-02f, 1.89681817e-02f, 1.33853704e-02f, -9.36325490e-02f, -9.87704936e-03f, 7.20830187e-02f, -5.78047521e-02f,
  2.09031906e-03f, -7.89464638e-03f, 4.07818938e-03f, -3.41607118e-03f, 1.18007980e-01f, -4.80669225e-03f, 1.75263971e-01f, -2.30932999e-02f, -6.28463030e-02f, -4.11384888e-02f,
  4.15308587e-02f, 1.56001568e-01f, -3.22511536e-03f, -2.75076982e-02f, -7.44007993e-03f, 1.35815972e-02f, -2.36486774e-02f, 5.14332317e-02f, 8.09026137e-02f, -2.96379309e-02f,
  1.44530386e-01f, -1.85798615e-01f, 2.69807875e-02f, 3.76509354e-02f, 5.16181774e-02f, 1.24213994e-01f, 1.28639698e-01f, -3.18362862e-02f, 7.28198588e-02f, 6.20392933e-02f,
  -1.96230114e-02f, -8.34291577e-02f, 8.99079740e-02f, -4.02077101e-02f, 8.85910690e-02f, 3.30259502e-02f, -7.84024317e-03f, -3.97647470e-02f, -4.65846211e-02f, -1.69272404e-02f,
  -3.14853400e-01f, 2.35578269e-01f, -3.07454526e-01f, 6.65351078e-02f, -1.71541825e-01f, 4.33127582e-02f, 1.47114843e-01f, 9.40306336e-02f, -2.64691599e-02f, 1.97169930e-01f,
  2.45859295e-01f, -7.10461065e-02f, 2.57830411e-01f, 2.44320497e-01f, -7.08211660e-02f, 1.86954677e-01f, 1.22275159e-01f, 1.47555932e-01f, 5.99377230e-02f, 1.92746967e-01f,
  -3.47700939e-02f, 2.94647574e-01f, 1.23623237e-01f, 1.16355322e-01f, 1.31236985e-01f, -6.46076500e-02f, 4.07355167e-02f, -1.55204558e-03f, 1.26022741e-01f, 3.44046727e-02f,
  5.84578440e-02f, 8.32935050e-02f, 4.94511984e-02f, -4.39868905e-02f, 3.50692235e-02f, -8.31839740e-02f, -4.92082499e-02f, -1.26820922e-01f, 4.89122272e-02f, 1.25372512e-02f,
  -6.66808337e-02f, -6.98505417e-02f, -2.82184035e-02f, -3.29346880e-02f, -1.04943201e-01f, -5.65752760e-02f, 5.95447272e-02f, -3.59135717e-02f, 9.21034068e-03f, 1.32472962e-02f,
  3.57387625e-02f, -4.26038951e-02f, 7.47257471e-02f, 6.17101267e-02f, -6.81195781e-02f, 8.91237035e-02f, -4.67089936e-03f, 1.75532755e-02f, 5.21217706e-03f, 3.55230421e-02f,
  7.09401891e-02f, -8.64177793e-02f, 1.17035471e-02f, 5.24262972e-02f, 4.74968813e-02f, 1.50833786e-01f, 1.46440780e-02f, 6.81963712e-02f, -7.13091269e-02f, -1.55863920e-02f,
  5.86806461e-02f, 1.20235272e-01f, 1.08869843e-01f, -3.07104159e-02f, 5.21717817e-02f, -7.07783401e-02f, 5.57754450e-02f, 1.84443835e-02f, -6.00043647e-02f, 9.49797481e-02f,
  4.71414216e-02f, -7.15325400e-02f, 3.05030830e-02f, 3.63898613e-02f, -8.95940140e-03f, -1.00105405e-02f, 7.84103423e-02f, 1.41017109e-01f, 5.36768585e-02f, 2.83551570e-02f,
  1.91205293e-01f, 9.19930935e-02f, -2.55783042e-03f, -4.64861803e-02f, -1.05525292e-02f, 3.05176415e-02f, 1.71673875e-02f, 4.31490019e-02f, 3.01751290e-02f, -1.04558967e-01f,
  2.08299309e-02f, -7.48408260e-03f, -9.36202109e-02f, -6.13378771e-02f, -1.44789040e-01f, 1.03897169e-01f, 1.35185212e-01f, -2.36457326e-02f, -5.85827716e-02f, -5.91236763e-02f,
  2.51341052e-02f, -6.39254078e-02f, 1.59393214e-02f, 1.38836456e-02f, -1.19980492e-01f, 1.11117639e-01f, -7.36814514e-02f, -9.25262570e-02f, -1.10965082e-02f, 8.84457231e-02f,
  -3.56543720e-01f, 4.41881455e-02f, -2.88754165e-01f, -2.06739008e-01f, 1.66040331e-01f, -4.71613169e-01f, -2.15358272e-01f, 1.26086194e-02f, 1.19987398e-01f, 3.19292724e-01f,
  9.81965885e-02f, -7.76558416e-03f, 1.65856868e-01f, -2.77579039e-01f, -3.92961144e-01f, -5.53279929e-02f, -3.70872468e-01f, -2.61061162e-01f, -3.80083099e-02f, -1.91140160e-01f,
  -1.05620965e-01f, -2.09828001e-03f, -2.46009618e-01f, 2.61136025e-01f, -1.67670399e-01f, 4.64504249e-02f, 1.61751136e-01f, 1.37586370e-01f, -1.59842685e-01f, 7.10431561e-02f,
  9.97373927e-03f, 1.95498496e-01f, -2.70471498e-02f, -4.57776114e-02f, -9.56819355e-02f, -3.60375009e-02f, -9.71008316e-02f, 1.08530253e-01f, -3.34648625e-03f, -6.62381127e-02f,
  4.05211584e-04f, 2.51160413e-02f, 3.82876471e-02f, 8.61793570e-03f, -5.88450879e-02f, 1.84819996e-02f, -4.11828533e-02f, -1.07468314e-01f, 6.75812662e-02f, -1.09173827e-01f,
  -4.12189066e-02f, -5.46278656e-02f, -1.71362534e-01f, 5.02968207e-02f, -1.07516333e-01f, -1.25704445e-02f, -2.03881130e-01f, -2.10322607e-02f, -1.57122072e-02f, 1.17738377e-02f,
  -2.87947077e-02f, -1.34334594e-01f, 5.17296605e-02f, 6.45475686e-02f, 2.76258308e-02f, 1.41685128e-01f, 1.29168676e-02f, -5.87756597e-02f, -4.64812964e-02f, -1.54257733e-02f,
  -5.46044856e-02f, -3.93924303e-02f, 4.91932556e-02f, -4.70421314e-02f, -5.17419986e-02f, 4.45567779e-02f, -6.32187501e-02f, -2.08351351e-02f, -8.77550840e-02f, -1.80620998e-02f,
  9.26167071e-02f, -5.84561415e-02f, 4.43759821e-02f, 2.90421378e-02f, 4.04363610e-02f, -3.97947803e-02f, -6.56237230e-02f, 5.99843524e-02f, 3.04972520e-03f, -3.00449487e-02f,
  2.14473028e-02f, -2.87340209e-02f, 5.95460869e-02f, 1.05385922e-01f, 1.81455031e-01f, -7.61119574e-02f, -1.72064006e-01f, -3.03859916e-02f, -4.60198410e-02f, -7.85079673e-02f,
  6.43370766e-03f, 1.35187549e-03f, -1.19368851e-01f, 8.41386318e-02f, 5.49419783e-02f, -9.39435363e-02f, -3.85047793e-02f, 1.26278866e-02f, 4.12022360e-02f, 8.39089800e-04f,
  2.98969503e-02f, 8.50000083e-02f, -1.93790235e-02f, 6.76853061e-02f, -3.19771543e-02f, 4.94291782e-02f, -1.93086062e-02f, 8.43681321e-02f, -2.10907552e-02f, 1.04916394e-02f,
  -2.55059004e-01f, 3.85823905e-01f, -4.89426069e-02f, 1.26172140e-01f, -3.97655547e-01f, 2.60108173e-01f, 2.93643564e-01f, 2.22847052e-03f, 9.80080590e-02f, 3.11368674e-01f,
  -7.41773397e-02f, 1.44055799e-01f, 7.06262663e-02f, 1.75739035e-01f, 5.36595471e-02f, 2.78240383e-01f, 1.60391584e-01f, 1.17999740e-01f, -8.26876163e-02f, -3.31501365e-02f,
  -5.44853844e-02f, 7.22548589e-02f, -8.14139172e-02f, -7.45362267e-02f, -2.00896487e-01f, -1.26471579e-01f, -1.53002977e-01f, -7.31464699e-02f, -5.27142100e-02f, -3.05207074e-02f,
  -7.71094160e-03f, -7.57773742e-02f, -3.97835635e-02f, 1.33669600e-01f, 8.13507587e-02f, -2.20349021e-02f, 4.31203246e-02f, -2.56481972e-02f, -1.13949798e-01f, 3.73030268e-02f,
  2.48455256e-02f, 1.80924628e-02f, -1.66623797e-02f, -8.33896697e-02f, -4.62073386e-02f, 6.91089109e-02f, -2.94570718e-02f, -2.19903421e-02f, 8.02711695e-02f, 2.14444511e-02f,
  1.36799077e-02f, -2.70981211e-02f, 3.01054982e-03f, 8.28235447e-02f, -8.36233199e-02f, -8.79267007e-02f, 5.93195148e-02f, 2.18611062e-02f, 5.93317710e-02f, -4.03513983e-02f,
  1.70875899e-02f, -5.70575707e-02f, 4.72318344e-02f, -5.06462641e-02f, 1.26325032e-02f, -1.24510765e-01f, -2.78891195e-02f, -8.93164128e-02f, 4.67156172e-02f, -6.30099922e-02f,
  -3.61318626e-02f, -1.83431953e-02f, -4.33108844e-02f, -1.24881743e-02f, 3.05141453e-02f, 5.61083257e-02f, -1.54909035e-02f, 3.79978195e-02f, -9.66185145e-03f, 3.09717581e-02f,
  7.84610305e-03f, 2.33855061e-02f, -8.24265555e-03f, -2.76155826e-02f, -2.78926231e-02f, 1.63715258e-02f, 6.70943931e-02f, -2.58062258e-02f, -4.57117818e-02f, 7.36052520e-04f,
  1.21481694e-01f, 1.34582460e-01f, 7.53165409e-02f, 1.15846634e-01f, 2.40819957e-02f, -3.45035903e-02f, 2.50679683e-02f, 8.83499905e-02f, 8.96405354e-02f, -2.47622784e-02f,
  8.52691382e-03f, -1.18337302e-02f, -3.90662514e-02f, -9.23090130e-02f, -5.14018163e-02f, 1.20086811e-01f, -6.05794527e-02f, 2.16258559e-02f, 1.84825563e-03f, -1.20250590e-01f,
  9.42222960e-03f, -3.55310589e-02f, 1.32034132e-02f, 1.04426565e-02f, 2.73797698e-02f, -2.02208422e-02f, -8.21874849e-03f, -6.71973825e-02f, -3.04960310e-02f, -9.94511694e-02f,
  -1.70708999e-01f, 2.69403636e-01f, -1.26700193e-01f, 3.13262492e-02f, 1.39740165e-02f, 2.69550502e-01f, 2.34568387e-01f, 1.87047347e-01f, 2.01203883e-01f, 1.32244021e-01f,
  8.39691237e-02f, 8.12442228e-02f, -6.73545599e-02f, 2.77163029e-01f, 2.43383702e-02f, 1.29732490e-01f, 1.97482213e-01f, 3.21400538e-02f, 2.91977376e-02f, 6.66875020e-02f,
  1.53018922e-01f, 2.80145891e-02f, -2.47483358e-01f, -1.56560615e-01f, -1.41923815e-01f, -2.43962452e-01f, -1.82597283e-02f, -6.92164227e-02f, -3.53900678e-02f, 7.18425885e-02f,
  4.52575199e-02f, 2.61445697e-02f, -5.74454740e-02f, -5.59958778e-02f, -5.76340556e-02f, -4.97969799e-02f, -4.21711206e-02f, -7.86453411e-02f, -3.23680639e-02f, -9.68983676e-03f,
  6.73563927e-02f, -6.64277747e-02f, 5.09024188e-02f, -9.44137871e-02f, -1.26453256e-02f, -3.56439571e-03f, 1.35494210e-02f, -9.54695195e-02f, 5.55953942e-03f, -4.93963361e-02f,
  1.75839830e-02f, 6.59906480e-04f, 5.76891750e-02f, 1.19251318e-01f, -5.31219654e-02f, 3.63112725e-02f, 3.78318503e-02f, 2.46017594e-02f, -1.08907804e-01f, 1.76355422e-01f,
  1.10017397e-02f, 8.96296874e-02f, -9.10932869e-02f, -1.25938416e-01f, -5.09084910e-02f, -7.36911520e-02f, 1.67065617e-02f, -2.14837547e-02f, -7.33400583e-02f, 5.99355362e-02f,
  2.08864324e-02f, -7.82769546e-03f, 1.58205663e-03f, -4.64449972e-02f, 7.80948475e-02f, -6.76864684e-02f, -1.07372120e-01f, 3.20532918e-02f, -3.03457287e-04f, 9.11284145e-03f,
  5.17597720e-02f, -1.36475703e-02f, -1.47156715e-01f, 3.22551955e-03f, -4.13920879e-02f, -6.69426918e-02f, 4.02234271e-02f, -3.13714594e-02f, -9.00237635e-03f, 2.84019895e-02f,
  2.56963730e-01f, 3.48836720e-01f, -8.03247541e-02f, 1.48284128e-02f, 5.00001907e-02f, 1.10018849e-02f, -3.07806134e-02f, 2.40778197e-02f, 3.97126041e-02f, 2.05510808e-03f,
  -8.14823061e-02f, -3.60927358e-02f, 5.43862395e-02f, 1.58620682e-02f, 1.03538204e-02f, 9.69209746e-02f, 8.23026821e-02f, 1.78237958e-03f, 1.12744331e-01f, 4.27790508e-02f,
  -6.46627992e-02f, -3.08387801e-02f, -5.21160662e-02f, -1.07101875e-03f, -3.84429917e-02f, -1.19932545e-02f, 6.43651783e-02f, -2.02794783e-02f, -4.59775776e-02f, 1.49115011e-01f,
  1.20464545e-02f, -1.97411850e-01f, -1.11878909e-01f, 1.68949142e-01f, 2.64457077e-01f, -1.05853498e-01f, 6.79031536e-02f, 1.38006359e-01f, 1.72968283e-01f, 3.87166180e-02f,
  5.86264096e-02f, -2.68614233e-01f, -2.22786382e-01f, -1.30922258e-01f, -1.61471620e-01f, -3.00855488e-01f, 1.41630042e-02f, -1.76159948e-01f, 3.69803309e-02f, -5.63673489e-02f,
  1.59559399e-01f, 8.74060169e-02f, -3.07890698e-02f, 1.73338279e-01f, 9.39476937e-02f, 2.90643215e-01f, 2.45952785e-01f, 9.83742177e-02f, 5.42399175e-02f, 8.54971074e-03f,
  4.30639610e-02f, 2.81944522e-03f, -1.12770377e-02f, -6.89585358e-02f, 7.22466111e-02f, 4.81367996e-03f, -2.13768017e-02f, -1.28543243e-01f, 1.36057988e-01f, -1.01830184e-01f,
  -8.44100025e-03f, -6.36642128e-02f, -4.68335152e-02f, -2.90699992e-02f, 1.64314821e-01f, 2.88237985e-02f, -3.93728688e-02f, 5.70584983e-02f, 5.52302934e-02f, -8.04402903e-02f,
  -7.87173025e-03f, -9.22110826e-02f, 1.66566044e-01f, -4.55366559e-02f, 3.85685638e-02f, 1.11909822e-01f, 3.13613638e-02f, -6.93221539e-02f, 8.36689174e-02f, 3.14573124e-02f,
  -3.48220877e-02f, 3.83093096e-02f, -9.34348479e-02f, 3.86006869e-02f, 6.09293953e-02f, 8.16873536e-02f, 1.57381296e-02f, -5.38421124e-02f, 1.23995341e-01f, 4.64933179e-03f,
  1.59417883e-01f, 7.49550760e-02f, -2.23119035e-02f, 9.84054729e-02f, 2.97272690e-02f, -4.01187204e-02f, -1.33847147e-02f, -1.71937764e-01f, 5.12354374e-02f, -3.18437293e-02f,
  -4.42141704e-02f, -1.96003336e-02f, -6.44444395e-03f, 1.07843988e-01f, 2.99272430e-03f, 1.00263812e-01f, -6.98655769e-02f, -8.22211802e-03f, 1.05715683e-02f, 5.83101697e-02f,
  -4.67729941e-02f, -1.02697149e-01f, 8.20218176e-02f, -1.31364129e-02f, 8.49887505e-02f, -9.70722362e-02f, -4.39224429e-02f, -3.49853262e-02f, 5.62356636e-02f, -7.23460168e-02f,
  1.00474343e-01f, 4.67568450e-02f, -3.55162807e-02f, 1.01280175e-02f, 4.83021811e-02f, 7.53176585e-02f, -4.26111966e-02f, 1.35216892e-01f, 4.29596156e-02f, -4.38958518e-02f,
  -5.64993881e-02f, -2.01094933e-02f, 8.37217942e-02f, 1.20632991e-01f, 3.70001681e-02f, 1.81267783e-02f, -2.09966302e-02f, 5.62842451e-02f, 3.69028673e-02f, -6.26789778e-02f,
  2.23738119e-01f, -3.08352053e-01f, 6.21478446e-02f, 1.13823891e-01f, 7.41247982e-02f, -1.46683827e-01f, -1.75199136e-01f, 5.40163964e-02f, -7.13561997e-02f, -1.69492066e-01f,
  3.32120769e-02f, -1.12566985e-01f, -6.29684404e-02f, 1.66559562e-01f, 2.13713288e-01f, -9.32869613e-02f, 6.03453219e-02f, 5.44200614e-02f, 2.63271909e-02f, 1.26464721e-02f,
  2.54107028e-01f, 1.73446417e-01f, 2.75728852e-01f, 1.62222907e-01f, 1.37315795e-01f, 2.09849149e-01f, 1.15048766e-01f, 1.39170572e-01f, 2.39766136e-01f, 1.82747975e-01f,
  -1.58785228e-02f, -5.49323857e-02f, -7.27012679e-02f, 8.40012804e-02f, 2.67383773e-02f, -2.78297886e-02f, -5.57356030e-02f, 8.26554894e-02f, 3.63516957e-02f, 4.71049454e-03f,
  -5.35235256e-02f, 8.14289153e-02f, 2.13096533e-02f, 3.89288552e-02f, -8.24652091e-02f, -1.61383152e-02f, -1.25303147e-02f, -2.68555284e-02f, -1.02701031e-01f, -3.97602888e-03f,
  3.69495414e-02f, -4.64206934e-02f, -3.19959335e-02f, 3.56089436e-02f, 1.08671645e-02f, 1.63360853e-02f, -7.87032247e-02f, 8.92547891e-02f, -6.40546251e-03f, -2.23446880e-02f,
  1.44390136e-01f, 2.99495831e-02f, -3.69314267e-03f, 1.25644848e-01f, 1.65022686e-02f, -1.45720556e-01f, -6.59382716e-02f, -9.33816433e-02f, -7.33243376e-02f, -1.06280021e-01f,
  -1.44349605e-01f, 2.32220292e-02f, 3.13923582e-02f, -1.92624256e-01f, 1.94504634e-02f, -6.84702471e-02f, -4.05482091e-02f, 1.47120226e-02f, 1.08815499e-01f, -1.18552461e-01f,
  6.16615079e-03f, 1.03475720e-01f, -4.36902530e-02f, -4.94510382e-02f, 4.66708653e-02f, 3.61494869e-02f, -2.80660354e-02f, 8.00505728e-02f, -1.27758980e-02f, 3.69528793e-02f,
  -7.33077601e-02f, -3.62305380e-02f, 3.26834880e-02f, 8.25547129e-02f, 8.23565274e-02f, -7.83658996e-02f, -6.14777878e-02f, 7.26417974e-02f, -2.98882779e-02f, -1.37527045e-02f,
  -1.14547856e-01f, 2.25592665e-02f, -9.74046886e-02f, -2.31686421e-02f, 3.63517962e-02f, -4.81326766e-02f, 9.77504998e-02f, -2.35036742e-02f, -1.34803622e-03f, -4.38969769e-02f,
  9.54930708e-02f, -1.34045199e-01f, -1.63270477e-02f, 8.11653212e-02f, 7.12902797e-03f, -7.72156939e-02f, 1.21400505e-03f, 2.78483890e-02f, -1.13656223e-01f, 2.53043585e-02f,
  8.56372043e-02f, 1.70537651e-01f, 2.23641783e-01f, 3.32784265e-01f, -9.91157144e-02f, -3.79988939e-01f, -3.90450150e-01f, 1.24747142e-01f, 8.92968923e-02f, -1.14511713e-01f,
  4.87602539e-02f, 9.64303315e-02f, 2.56652888e-02f, 1.05735101e-01f, 1.55828416e-01f, -7.53222480e-02f, 1.39643094e-02f, -1.13104239e-01f, 8.78340453e-02f, 1.19297609e-01f,
  1.76445290e-01f, 2.25928053e-02f, 3.08562130e-01f, 6.74791709e-02f, 9.45089683e-02f, 1.36651009e-01f, 2.50026226e-01f, 1.79431457e-02f, 2.00198159e-01f, -9.70348567e-02f,
  -1.20370843e-01f, -4.52581467e-03f, 6.36756420e-02f, -9.87881646e-02f, -1.58844981e-02f, -7.43996678e-03f, -5.27861528e-02f, 1.40432749e-04f, 2.46427469e-02f, -7.56368646e-03f,
  -7.77455270e-02f, -1.23968035e-01f, 3.96554209e-02f, 1.48045477e-02f, -9.06437635e-02f, 1.69522446e-02f, 7.73979425e-02f, -2.86614317e-02f, 1.97645277e-02f, 7.32447505e-02f,
  1.09235026e-01f, 2.18193028e-02f, -9.15767476e-02f, -3.77142355e-02f, 6.30470132e-03f, -1.44208625e-01f, -7.44648231e-03f, 9.34882611e-02f, 2.77981926e-02f, 6.00038506e-02f,
  -7.52194831e-03f, 6.43026037e-03f, 1.84641238e-02f, 2.74887197e-02f, 9.62132402e-03f, -2.57909950e-02f, -6.68781996e-02f, -5.70778325e-02f, -9.54656973e-02f, -1.28963066e-03f,
  6.39025792e-02f, -5.93384653e-02f, 4.11041304e-02f, 7.28678852e-02f, 4.04553041e-02f, 2.29753237e-02f, -1.14678144e-01f, -6.23066872e-02f, -5.78530468e-02f, 5.52150160e-02f,
  4.51715142e-02f, 9.50142294e-02f, 4.75934371e-02f, -9.19321701e-02f, -5.19256406e-02f, -3.94114628e-02f, 6.84123039e-02f, -3.74209434e-02f, 9.62145030e-02f, 6.59192652e-02f,
  -1.98278222e-02f, 2.09945738e-01f, 5.81076602e-03f, -1.13428853e-01f, -5.80536686e-02f, -2.97356639e-02f, 7.84147084e-02f, -2.82560941e-02f, 3.98347341e-02f, 1.08095994e-02f,
  -4.21230868e-02f, -4.05790135e-02f, -4.77345707e-03f, -5.82465790e-02f, 6.31794408e-02f, 5.13252914e-02f, 1.09503709e-01f, -1.25124510e-02f, 3.27404663e-02f, 4.58417796e-02f,
  7.31434226e-02f, -1.19234942e-01f, -8.01163316e-02f, -2.92181130e-02f, 5.90155050e-02f, -1.22012503e-01f, -4.21672389e-02f, 8.19015428e-02f, 7.55134448e-02f, 1.06230713e-01f,
  -6.39148235e-01f, -4.81975079e-02f, -1.60795804e-02f, -1.60322651e-01f, -6.28865436e-02f, -7.47883171e-02f, 3.17621492e-02f, 1.36663646e-01f, -9.24088210e-02f, 1.59741715e-01f,
  2.11050034e-01f, -2.47080758e-01f, 2.36881718e-01f, 6.22961074e-02f, -3.09472173e-01f, 3.45357098e-02f, -5.56858219e-02f, -3.17776129e-02f, 7.68555999e-02f, -3.68806953e-03f,
  -9.93477255e-02f, 1.86583847e-01f, 5.34100011e-02f, 9.83814076e-02f, -8.40408877e-02f, 1.94242373e-02f, -2.24593212e-03f, 3.00122537e-02f, 4.90823165e-02f, -4.96896394e-02f,
  -1.40482679e-01f, 1.23214871e-01f, 2.92994529e-02f, -1.62554719e-02f, 8.01234916e-02f, -7.23387254e-03f, 3.54863182e-02f, -8.68825766e-04f, 1.04103619e-02f, -3.92223299e-02f,
  -5.85441366e-02f, -5.33081368e-02f, -4.15445343e-02f, 1.14940051e-02f, 8.07419270e-02f, 7.71705136e-02f, 1.36891287e-02f, 3.40084657e-02f, 7.11682439e-02f, -3.53215002e-02f,
  -4.83109429e-03f, 8.99885446e-02f, 2.54935399e-02f, 3.49150039e-02f, 5.65723423e-03f, 3.78965400e-02f, -1.80322584e-02f, -1.06160631e-02f, 4.67892960e-02f, -3.34499143e-02f,
  3.29399183e-02f, -6.22892976e-02f, -1.00491541e-02f, 4.97840717e-02f, 6.14808947e-02f, 6.73939735e-02f, 3.45912240e-02f, -3.94432954e-02f, -5.38730398e-02f, -1.73989534e-02f,
  -9.08148140e-02f, 2.53521893e-02f, 6.71962202e-02f, 4.37537655e-02f, -5.84809221e-02f, -5.89513872e-03f, -4.15676460e-02f, -4.09262925e-02f, -9.94257722e-03f, -4.55645435e-02f,
  1.00687012e-01f, -1.41169265e-01f, 4.60571311e-02f, 1.48380086e-01f, -8.36611632e-03f, 6.58760145e-02f, 1.12278603e-01f, 2.85052247e-02f, -4.69340198e-02f, -4.78869863e-02f,
  -1.73651874e-02f, 2.73795798e-02f, 1.52869955e-01f, -4.16352227e-02f, 1.64038222e-02f, -1.58414580e-02f, 5.27565703e-02f, 3.06476392e-02f, 3.53467017e-02f, -7.68405721e-02f,
  -6.21941639e-03f, -4.68692668e-02f, -8.92019123e-02f, 3.95685025e-02f, 1.45446090e-02f, 7.21691549e-02f, 6.44036904e-02f, -5.24627082e-02f, -1.63751859e-02f, 5.67394011e-02f,
  3.05457525e-02f, -2.78077610e-02f, -6.40776530e-02f, 6.27902569e-03f, -9.24669802e-02f, -1.53237805e-02f, -7.56878182e-02f, 2.97464784e-02f, -2.82543991e-02f, -6.99513033e-02f,
  1.81425169e-01f, 1.12221375e-01f, -4.14061622e-04f, 2.40837589e-01f, 1.69413090e-01f, 5.80232777e-02f, -6.78715203e-03f, 1.78864405e-01f, 4.15182918e-01f, -1.46537811e-01f,
  1.67922854e-01f, -8.08816850e-02f, -1.91834792e-01f, 1.16431385e-01f, 6.45977855e-02f, 7.77153298e-02f, 2.30125830e-01f, 5.82428947e-02f, 1.34749502e-01f, 1.77439347e-01f,
  1.84575126e-01f, 2.83497926e-02f, -1.43255115e-01f, -1.52116090e-01f, -1.24094058e-02f, -4.96859513e-02f, -1.62326589e-01f, -2.44758174e-01f, -1.88888341e-01f, -4.07581311e-03f,
  -4.18861993e-02f, 6.30347282e-02f, -1.22372143e-01f, 2.13398207e-02f, -4.08006161e-02f, -8.03990960e-02f, -9.67849120e-02f, -1.15428247e-01f, 3.86846019e-03f, 3.58607806e-02f,
  -2.76221056e-02f, -7.65789393e-03f, 1.20253943e-01f, 3.08374893e-02f, -7.58895511e-03f, 1.28652796e-01f, 6.94220141e-02f, -5.50398324e-03f, -6.76268935e-02f, -2.93940119e-02f,
  9.94293019e-03f, 1.48728592e-02f, 1.37147620e-01f, -1.77200586e-02f, 1.05638854e-01f, 5.46416640e-02f, 2.62184292e-02f, -1.63999602e-01f, -4.99907546e-02f, -1.63906608e-02f,
  -8.88573844e-03f, 4.89658788e-02f, 6.12051189e-02f, -3.24676000e-02f, 1.42468750e-01f, 5.26623055e-02f, 7.68125653e-02f, 1.00769132e-01f, 1.46906734e-01f, 2.93191466e-02f,
  2.52180602e-02f, 4.84280242e-03f, 5.47772683e-02f, -3.39172184e-02f, -8.95193145e-02f, 2.43406892e-02f, -3.81095149e-02f, 6.90581724e-02f, 2.46730763e-02f, 1.15162514e-01f,
  -3.22559997e-02f, 9.43449675e-04f, -8.18173736e-02f, -3.84660326e-02f, -9.15871486e-02f, 1.04546510e-02f, 3.22569758e-02f, -9.44621265e-02f, -1.11805625e-01f, 6.43200651e-02f,
  1.16271749e-01f, 2.07786962e-01f, -1.16029494e-01f, -9.01668519e-02f, -2.23786589e-02f, 7.13651180e-02f, 1.33545995e-01f, 7.11870119e-02f, 8.91772807e-02f, 1.14499226e-01f,
  3.16797420e-02f, -2.81344336e-02f, -1.52249886e-02f, -2.36838944e-02f, -7.20163286e-02f, 1.37521252e-01f, 4.73397272e-03f, 3.28759961e-02f, -7.52839372e-02f, -1.37857590e-02f,
  -1.21393308e-01f, -9.93505120e-03f, 2.42028502e-03f, 1.05439825e-02f, 2.03891397e-02f, -6.61650375e-02f, -8.17288458e-02f, -2.71469131e-02f, -1.63733959e-02f, 1.89768504e-02f,
  1.90211892e-01f, -1.29239410e-01f, -1.67767659e-01f, 2.56724507e-02f, 5.67779839e-02f, -1.41444072e-01f, -2.63816893e-01f, 9.72530395e-02f, -9.20676738e-02f, -5.96400760e-02f,
  3.21380161e-02f, -2.10058726e-02f, -2.46564537e-01f, 1.99543342e-01f, 3.54059368e-01f, -2.02976301e-01f, 2.19253317e-01f, 2.40758192e-02f, -2.79005058e-03f, 1.64987698e-01f,
  7.92835951e-02f, 2.71012276e-01f, 1.30056962e-01f, 2.63389856e-01f, 1.48497015e-01f, 1.40143856e-01f, 2.75429964e-01f, -5.24455458e-02f, 3.44733328e-01f, 1.47295147e-01f,
  3.26778814e-02f, 4.35394198e-02f, -1.28305882e-01f, -5.95137775e-02f, -6.91065267e-02f, 6.32923469e-02f, -2.95709651e-02f, 4.57857326e-02f, -2.64289156e-02f, 3.38344723e-02f,
  -3.65621261e-02f, 5.87928556e-02f, 4.92085256e-02f, 1.12020940e-01f, 4.85671647e-02f, -1.14896642e-02f, -3.85568105e-02f, -3.18272412e-02f, -6.37659505e-02f, 5.09709753e-02f,
  -3.34568880e-02f, 7.21952245e-02f, 3.48109789e-02f, -7.96916559e-02f, -1.06409609e-01f, -2.82133017e-02f, -4.12393399e-02f, 7.02455360e-03f, -9.95890237e-03f, -7.56431650e-03f,
  7.55901262e-02f, -3.43679190e-02f, 9.20028090e-02f, 3.52369174e-02f, -5.21141626e-02f, 5.33868074e-02f, -1.74870081e-02f, -3.43870036e-02f, -1.76117569e-02f, -8.37156177e-03f,
  -6.01699166e-02f, 3.78712527e-02f, 4.91805114e-02f, -8.55952725e-02f, 1.67443454e-02f, 5.61847538e-02f, -7.71801639e-03f, -3.54414321e-02f, -5.06088324e-02f, -5.54796420e-02f,
  -2.75789034e-02f, 5.05971611e-02f, -5.35336584e-02f, 6.49449974e-02f, 1.34855568e-01f, -7.39081055e-02f, -2.36630682e-02f, 4.48282324e-02f, -1.04606234e-01f, 1.24008767e-02f,
  -2.28856187e-02f, 1.01773575e-01f, -2.33143326e-02f, -6.78919107e-02f, -1.11306638e-01f, 5.47391847e-02f, -2.98256539e-02f, 5.81724904e-02f, 1.75902722e-04f, -2.76465435e-02f,
  3.18550877e-02f, 1.15975849e-02f, -5.43817580e-02f, 5.49636073e-02f, 9.90832523e-02f, 7.17821065e-03f, -9.08266008e-03f, 2.55321898e-02f, -1.98957347e-03f, 5.49883544e-02f,
  -2.21123025e-02f, 8.93733203e-02f, 3.45951295e-03f, -7.38208741e-02f, -8.18032995e-02f, -6.14020787e-02f, 9.17842984e-02f, -2.88920924e-02f, 4.68753502e-02f, -3.85917351e-02f,
  2.34508872e-01f, 3.14235806e-01f, 2.74444044e-01f, 1.56105742e-01f, -1.89374954e-01f, -3.18682343e-01f, -1.29533246e-01f, 3.23698344e-03f, 7.38944039e-02f, 1.26512438e-01f,
  -9.77466479e-02f, 3.33797663e-01f, -6.28747120e-02f, 1.35848254e-01f, -1.47049636e-01f, -2.74434566e-01f, 1.50094191e-02f, -1.30961657e-01f, -1.01481520e-01f, 2.74798386e-02f,
  2.33596042e-02f, -2.12064326e-01f, 5.48701063e-02f, -1.77089393e-01f, 1.20027281e-01f, 2.57182449e-01f, 2.29963325e-02f, -9.51482728e-02f, 1.94309652e-01f, 3.25611681e-02f,
  1.24250194e-02f, 1.06020398e-01f, 1.39573574e-01f, 1.08844444e-01f, 2.86127143e-02f, -9.78125408e-02f, -6.00572862e-02f, 3.69589254e-02f, 1.81624200e-02f, 8.78120121e-03f,
  2.52457652e-02f, -6.10080771e-02f, 8.53177086e-02f, -5.62423505e-02f, -8.21495708e-03f, 7.17355981e-02f, 3.71594797e-03f, 1.69080615e-01f, 1.73129290e-01f, 7.69264027e-02f,
  3.00755142e-03f, 6.16947226e-02f, 7.67335594e-02f, 1.17534943e-01f, 4.49747443e-02f, 5.04565872e-02f, -7.32515380e-03f, 3.33308466e-02f, 5.36223464e-02f, 7.50412866e-02f,
  -6.06951155e-02f, -9.26066488e-02f, 3.80459949e-02f, -2.52544638e-02f, -4.44933772e-02f, -6.86822517e-04f, 4.15743738e-02f, -2.06216406e-02f, -3.15741114e-02f, -9.49126086e-04f,
  8.62394795e-02f, 8.70059580e-02f, -1.10502951e-01f, -2.30946671e-02f, 1.38641167e-02f, -2.91974638e-02f, -9.11235884e-02f, -3.04380599e-02f, 1.56593043e-02f, 1.43124729e-01f,
  -6.92341700e-02f, -9.00448561e-02f, 7.82846883e-02f, -8.92041251e-04f, -1.74192265e-01f, -2.43096575e-02f, 1.33287147e-01f, -1.93029493e-02f, 9.00684744e-02f, -8.32230411e-03f,
  -4.75548469e-02f, 1.00439012e-01f, 2.70579141e-02f, 4.69129495e-02f, -3.75218391e-02f, -2.21555354e-03f, -1.11177348e-01f, 6.66509941e-02f, 5.97400852e-02f, -7.00857565e-02f,
  -5.94030842e-02f, 1.85657293e-02f, -9.61805359e-02f, -2.34697573e-02f, -6.19221143e-02f, 5.12517355e-02f, 4.40705866e-02f, 3.11440602e-02f, 1.01526946e-01f, 4.40607443e-02f,
  9.83454362e-02f, 2.41711587e-02f, 4.14430425e-02f, 1.75563991e-01f, -6.38866425e-02f, 5.68506084e-02f, -3.34600173e-02f, 6.05502129e-02f, -9.65535920e-03f, -1.40690617e-02f,
  1.91328079e-01f, -4.39660430e-01f, -2.73763895e-01f, -6.78854585e-02f, 1.84015021e-01f, 2.65213490e-01f, 7.07516223e-02f, -6.21588603e-02f, -2.13469416e-01f, -2.47173477e-02f,
  2.02978298e-01f, -3.56133915e-02f, -1.18562460e-01f, 2.38474369e-01f, 3.32814008e-01f, -1.16203517e-01f, 1.47168458e-01f, 2.01837316e-01f, -1.76653743e-01f, -7.94563740e-02f,
  4.35057320e-02f, 2.86696166e-01f, 8.61171633e-02f, 1.38776362e-01f, 1.27380520e-01f, -6.71008080e-02f, 8.07613805e-02f, 3.86312907e-03f, 2.42499888e-01f, 3.14987302e-01f,
  5.46677671e-02f, -1.06315434e-01f, -3.90096419e-02f, 6.43977895e-02f, -8.65689069e-02f, 1.67744197e-02f, 1.25432508e-02f, 1.50236577e-01f, 1.89213045e-02f, -4.67679426e-02f,
  1.54536134e-02f, 3.34371105e-02f, -5.44777848e-02f, -2.24067271e-02f, -7.38417124e-03f, 6.94113038e-03f, -8.98962840e-02f, 1.42171932e-02f, -6.67170510e-02f, 2.65538115e-02f,
  -5.09931594e-02f, 7.18805473e-03f, -7.11450726e-02f, -7.62941986e-02f, -3.83152254e-02f, -9.62789953e-02f, -6.00198247e-02f, -6.15582541e-02f, -6.76912069e-02f, 9.89266485e-03f,
  2.83278227e-02f, 5.07741421e-02f, -3.87903750e-02f, 5.45279235e-02f, -8.67703557e-02f, 4.55284603e-02f, 4.18198369e-02f, -2.64733355e-03f, -7.84635544e-02f, -9.38785635e-03f,
  -7.94005767e-02f, -7.22768828e-02f, 3.97135280e-02f, 2.09889710e-02f, 1.01367414e-01f, 1.07407846e-01f, 2.26528030e-02f, 6.83503076e-02f, -1.15254298e-01f, -7.46048242e-02f,
  9.21099558e-02f, 3.89588036e-04f, 1.21799931e-02f, -8.73336755e-03f, 8.50919485e-02f, -4.95634181e-03f, 2.37326808e-02f, 4.44554165e-02f, -1.82935596e-02f, 1.48356939e-02f,
  -2.29633562e-02f, -2.33775139e-01f, -2.87460983e-02f, 2.62737460e-02f, -1.72680601e-01f, -8.81856773e-03f, 2.67041922e-02f, 4.67033461e-02f, -1.44784421e-01f, -6.55227378e-02f,
  -1.16756195e-02f, -1.75130181e-02f, -1.34513322e-02f, -2.60048006e-02f, 7.23053887e-02f, -9.77013409e-02f, -9.18714255e-02f, -1.39003946e-02f, 5.66263907e-02f, 1.61514245e-02f,
  -9.88750160e-02f, -4.40944657e-02f, 6.58176616e-02f, -9.24195424e-02f, 3.33167762e-02f, -1.15208752e-01f, 5.85475229e-02f, 2.96092816e-02f, -3.28741744e-02f, 2.90527828e-02f,
  -2.67818362e-01f, -1.34465605e-01f, -2.41842166e-01f, -1.12039402e-01f, 1.81596041e-01f, 1.16817906e-01f, 4.25325008e-03f, -6.80776015e-02f, -1.90821275e-01f, 1.84744313e-01f,
  -4.41943072e-02f, -1.90109178e-01f, -1.28717393e-01f, -2.58147955e-01f, -2.86033779e-01f, -4.06894982e-01f, -1.24238074e-01f, 6.24661930e-02f, -2.20181495e-01f, 9.90371965e-03f,
  -1.84517249e-01f, 1.98323205e-02f, -1.53953701e-01f, 1.87451899e-01f, 4.53105830e-02f, 1.10638246e-01f, 3.71011376e-01f, 4.40003760e-02f, 1.77747488e-01f, 4.63118069e-02f,
  -7.40206167e-02f, -2.07544148e-01f, -1.17255241e-01f, -7.47139975e-02f, 1.05383784e-01f, 1.89753175e-01f, 1.31311923e-01f, 1.39317068e-04f, -5.36153838e-02f, -4.93840277e-02f,
  6.19152747e-02f, -6.03703037e-02f, -4.06076200e-02f, 4.32151891e-02f, 1.27552487e-02f, 5.12216315e-02f, -7.39691556e-02f, -1.32540748e-01f, -1.27890661e-01f, -1.00390270e-01f,
  -8.12606961e-02f, 6.47168374e-03f, 1.27859995e-01f, -4.47965413e-02f, -4.96190861e-02f, 6.83269391e-05f, 2.18692347e-02f, 1.34180859e-01f, 5.45056537e-02f, -3.36763486e-02f,
  4.85712327e-02f, 9.50333774e-02f, -3.11381072e-02f, -1.55802250e-01f, -7.61855766e-02f, 3.88729968e-03f, -1.24466322e-01f, -6.89938478e-03f, 6.11131079e-02f, 1.63693205e-02f,
  -3.36013846e-02f, -6.36712834e-02f, -7.64815807e-02f, 3.87066379e-02f, 3.95398103e-02f, 1.49452565e-02f, 5.84256388e-02f, -5.18118814e-02f, 6.52112439e-02f, -2.80523896e-02f,
  5.31264022e-03f, -3.44706117e-04f, -2.74878424e-02f, 2.11902168e-02f, 4.62807110e-03f, -2.07877904e-02f, -2.36517023e-02f, -2.61838995e-02f, 6.01399280e-02f, 6.50523975e-02f,
  1.68800533e-01f, 5.02733961e-02f, -7.58763030e-02f, 8.71594157e-03f, 3.09096668e-02f, 4.97676292e-03f, -2.38901991e-02f, -2.37117037e-02f, 3.38526964e-02f, -1.57794766e-02f,
  1.36715725e-01f, -1.82772968e-02f, 1.70376524e-01f, -1.37430103e-03f, 9.18833762e-02f, 6.56372458e-02f, 3.86986472e-02f, 5.65643013e-02f, 7.71901160e-02f, -2.92302202e-03f,
  1.41423538e-01f, 6.76878393e-02f, 2.46665068e-03f, 6.46951096e-03f, 1.56733036e-01f, 7.36160204e-02f, 1.59306198e-01f, 6.28523231e-02f, -8.84059258e-03f, -3.11800446e-02f,
  -6.63051801e-03f, 1.93820536e-01f, -1.40168428e-01f, -1.97288364e-01f, -6.53673112e-02f, -5.07667810e-02f, -2.23859191e-01f, -9.60679166e-03f, -1.95675179e-01f, -1.37921020e-01f,
  -2.07763612e-01f, -7.40171075e-02f, 7.59452134e-02f, 5.89737631e-02f, 8.71205479e-02f, 2.95757353e-01f, -5.35367951e-02f, 3.97221092e-03f, 1.21847540e-01f, 1.33314177e-01f,
  1.30217850e-01f, 2.07694501e-01f, 2.32422292e-01f, 1.43549696e-01f, 6.80440068e-02f, -3.99263427e-02f, 1.88661143e-02f, -1.99045949e-02f, -1.05291948e-01f, -4.92177121e-02f,
  4.06853259e-02f, -2.95677129e-02f, -9.67204422e-02f, -2.71699820e-02f, 3.02667543e-02f, -1.08867481e-01f, -4.68508452e-02f, -9.29963775e-03f, -1.62349775e-01f, 1.46535970e-02f,
  -3.70854102e-02f, -8.04513097e-02f, -8.05182680e-02f, 7.01600388e-02f, 7.10413978e-02f, -1.80783495e-01f, 2.97250021e-02f, 6.03411207e-03f, 3.73330042e-02f, 1.42504156e-01f,
  -8.47963542e-02f, 7.29511678e-02f, 3.22297029e-02f, 3.71858552e-02f, -4.50952873e-02f, -8.04949850e-02f, -6.01351336e-02f, 1.06921024e-03f, -2.94157974e-02f, -4.06955257e-02f,
  -1.67136434e-02f, 4.07888740e-03f, 7.87361860e-02f, -1.69923753e-01f, -1.26619507e-02f, 4.49830741e-02f, -2.30626743e-02f, 2.28370447e-02f, -1.30221099e-01f, 3.84797305e-02f,
  -7.41515830e-02f, -5.35543784e-02f, -2.86552240e-03f, -3.61842290e-02f, -2.63110530e-02f, 3.25954072e-02f, -3.51148844e-02f, -2.50327773e-02f, -7.77626261e-02f, 1.70944687e-02f,
  -2.60792598e-02f, -3.62286679e-02f, -9.63929668e-02f, 3.42199183e-03f, -4.28790273e-03f, 2.83080824e-02f, -1.25950063e-02f, 6.68297261e-02f, 8.27286690e-02f, 5.04077934e-02f,
  8.25949535e-02f, -2.76665646e-03f, -1.00728869e-01f, -1.64379120e-01f, -5.25621176e-02f, 5.04774936e-02f, -4.25847881e-02f, 1.06863886e-01f, -2.93873679e-02f, 1.53621435e-02f,
  -3.87872756e-02f, -5.22441939e-02f, 5.89922071e-02f, 7.06514940e-02f, -4.40873317e-02f, 6.39808178e-02f, 1.15474947e-01f, -2.77574956e-02f, -2.32421197e-02f, -5.75090870e-02f,
  8.48229602e-03f, -2.89077237e-02f, 5.47811203e-02f, 4.25692648e-02f, -5.19865900e-02f, -6.18192218e-02f, -5.21315709e-02f, -1.92560554e-02f, -3.18529978e-02f, -2.25272309e-02f,
  -7.27121830e-01f, 4.01123494e-01f, 1.22408438e-02f, -6.43246323e-02f, -5.22428118e-02f, -2.04510286e-01f, -4.55194488e-02f, 2.32176427e-02f, 1.49322236e-02f, 7.31291249e-02f,
  -6.70475811e-02f, 2.35169288e-02f, 8.25706795e-02f, 2.19854519e-01f, -3.40471894e-01f, 1.48414686e-01f, -6.76159710e-02f, -6.65037036e-02f, 1.32111311e-01f, -7.85527602e-02f,
  -1.42071605e-01f, 3.57735530e-02f, 3.58129591e-02f, 1.42586544e-01f, -7.69045427e-02f, -2.84606256e-02f, -1.32285163e-01f, 9.45845023e-02f, 9.62807448e-04f, 3.36406268e-02f,
  -2.76967973e-01f, -2.35969111e-01f, -1.02528870e-01f, 5.76466555e-03f, -1.90644369e-01f, -2.50439718e-02f, -1.17684744e-01f, -5.32238968e-02f, 1.30145149e-02f, -9.63420421e-03f,
  -5.32023748e-03f, 5.34787290e-02f, -7.41005270e-03f, -5.02772555e-02f, -5.95908239e-02f, 8.87026116e-02f, 1.15622118e-01f, -1.16735473e-02f, -3.29301581e-02f, 3.88353989e-02f,
  3.40553038e-02f, -3.14280726e-02f, -5.25183603e-02f, -1.09607326e-02f, -3.95982005e-02f, -5.96360378e-02f, 4.81284820e-02f, -1.06722459e-01f, -6.22969605e-02f, -8.72589871e-02f,
  2.85580065e-02f, -5.07068560e-02f, -5.97634912e-03f, -8.19018707e-02f, 2.96105966e-02f, -8.53020772e-02f, -3.67206968e-02f, -2.86621582e-02f, 5.09107858e-02f, -5.22589721e-02f,
  1.94103678e-03f, -3.27183306e-02f, -6.70718178e-02f, -1.29958719e-01f, 6.03739694e-02f, -8.66888240e-02f, -5.20935953e-02f, -5.30978665e-02f, 3.14337797e-02f, -1.03416562e-01f,
  -4.23385613e-02f, 2.40821689e-02f, 5.93177266e-02f, -1.32306730e-02f, -3.01865693e-02f, -1.58626307e-02f, 3.73283029e-02f, -7.81299621e-02f, -1.26482204e-01f, -4.43682261e-02f,
  -4.67733711e-01f, -4.00708020e-01f, -6.69577578e-03f, -6.75979704e-02f, -2.73462944e-02f, -4.00519185e-02f, 5.72523177e-02f, -6.08794466e-02f, 4.28709667e-03f, -1.27265286e-02f,
  4.64770980e-02f, -4.03964184e-02f, -4.67149578e-02f, 5.95629867e-03f, 9.79234185e-03f, -7.62182251e-02f, -2.21722759e-02f, 1.31456088e-03f, -1.20176025e-01f, 4.10454050e-02f,
  -5.56339473e-02f, 1.27304122e-02f, 4.09411006e-02f, -3.27909477e-02f, -6.39031678e-02f, -6.33964166e-02f, -3.61120254e-02f, 5.97768351e-02f, -2.11057905e-02f, 1.27713338e-01f,
  -7.26271212e-01f, 4.15730476e-02f, 4.62252498e-01f, -3.12513888e-01f, 1.48825645e-01f, 2.38416031e-01f, 1.84356332e-01f, -8.49777013e-02f, -2.75791824e-01f, -3.86446938e-02f,
  1.21078081e-01f, -1.24706678e-01f, 2.74779230e-01f, -1.09553695e-01f, 1.64524764e-01f, 8.09116140e-02f, -7.21392259e-02f, -1.02585973e-02f, -8.90854076e-02f, -1.19558141e-01f,
  1.46392286e-02f, -9.85836312e-02f, 1.20946720e-01f, -1.79374162e-02f, -1.19970590e-02f, -2.45128915e-01f, 2.21750736e-02f, 1.85831070e-01f, -3.42990346e-02f, 1.16673253e-01f,
  -1.55854076e-01f, -3.25986564e-01f, -1.65257633e-01f, -1.22016817e-02f, 7.03002214e-02f, -5.76453917e-02f, 6.33122073e-03f, 1.79507472e-02f, -1.42597184e-02f, 4.47232425e-02f,
  -7.13201910e-02f, -2.08885893e-02f, -1.22083232e-01f, 1.67275425e-02f, -1.65453076e-01f, 5.15296794e-02f, 3.19931912e-03f, 6.19228780e-02f, 1.42351622e-02f, 1.69740040e-02f,
  1.62528709e-01f, 8.45486373e-02f, 7.24052638e-02f, -4.29900251e-02f, 9.70409140e-02f, 1.62501577e-02f, -8.31975043e-02f, 9.98668149e-02f, -1.89659726e-02f, -7.01790601e-02f,
  6.98027015e-02f, 2.02511065e-02f, 9.94592682e-02f, -1.17017366e-02f, 9.25582424e-02f, -8.05341918e-03f, -1.39087392e-02f, -5.15014417e-02f, 3.11054140e-02f, -3.37385722e-02f,
  9.37622935e-02f, -1.08523816e-01f, -8.54181722e-02f, 1.45240754e-01f, 7.20828958e-03f, -9.42282230e-02f, 4.21808548e-02f, -3.88082191e-02f, 6.21842183e-02f, -4.11489643e-02f,
  -1.26272053e-01f, -1.21138440e-02f, 5.44935130e-02f, -1.56038869e-02f, 5.50232306e-02f, 4.11429740e-02f, 2.04498344e-03f, 5.13725653e-02f, -3.31088081e-02f, 9.58177075e-02f,
  -2.70270348e-01f, -2.36713275e-01f, -2.10159216e-02f, -5.00959493e-02f, -7.53185228e-02f, -3.41928266e-02f, -9.89025384e-02f, 1.82376169e-02f, -2.67383624e-02f, -7.05944821e-02f,
  -2.66028452e-03f, -1.16036855e-01f, 8.88569572e-04f, 4.07517552e-02f, 1.08858749e-01f, 3.15809399e-02f, 5.60960136e-02f, -4.56334688e-02f, 1.31370455e-01f, -5.85850179e-02f,
  -1.09892553e-02f, -8.93110335e-02f, 1.91433839e-02f, 9.05553997e-03f, -8.76364484e-02f, -1.89569145e-02f, -1.27035409e-01f, -1.57371033e-02f, -5.06917480e-03f, 6.17986023e-02f,
  1.06219999e-01f, -2.67925113e-01f, -1.64858755e-02f, -1.80984765e-01f, -1.13984160e-01f, -7.65468702e-02f, -1.40564665e-01f, -2.06924573e-01f, -1.71030670e-01f, -1.98891774e-01f,
  -1.33967355e-01f, -5.65380324e-03f, 3.95218506e-02f, -1.75931364e-01f, 1.83390111e-01f, 1.59847453e-01f, -2.81371623e-01f, 4.15940247e-02f, 4.69783619e-02f, -5.46987168e-03f,
  -1.23517611e-03f, -1.24815710e-01f, 7.19771460e-02f, -3.39385755e-02f, -1.55136406e-01f, -5.11405580e-02f, 6.41388595e-02f, 5.98874390e-02f, -1.52859330e-01f, -2.99167968e-02f,
  1.15198076e-01f, 6.51857033e-02f, 4.01038267e-02f, 3.78276482e-02f, -5.14170639e-02f, 1.69058405e-02f, 7.24840257e-03f, 3.72639671e-02f, -5.15010096e-02f, 8.46166164e-02f,
  -7.29766721e-03f, 2.58814599e-02f, -1.07604101e-01f, 8.09848607e-02f, -4.84525673e-02f, -1.21143803e-01f, -7.05412626e-02f, -7.23818019e-02f, -4.57842536e-02f, 6.45390600e-02f,
  4.33954075e-02f, -1.34962294e-02f, -4.58008312e-02f, 7.04619382e-03f, -3.40011083e-02f, -1.22736596e-01f, 7.42835552e-02f, 6.17871769e-02f, -8.08549374e-02f, -7.67511576e-02f,
  9.89344493e-02f, 8.09084401e-02f, 2.86879502e-02f, -1.73264574e-02f, -4.78359275e-02f, -5.49363578e-03f, -7.96227157e-03f, 3.31971012e-02f, -1.16643652e-01f, -3.49199846e-02f,
  -5.99098653e-02f, -9.37008187e-02f, 3.49474438e-02f, 6.07490074e-03f, -3.02912761e-02f, 9.88336001e-03f, 1.19280584e-01f, -1.40199410e-02f, -1.10318281e-01f, 4.80879284e-02f,
  5.07755578e-02f, 6.37348816e-02f, -9.22435671e-02f, -8.84614363e-02f, 1.34876460e-01f, 4.76140343e-02f, -7.32641742e-02f, -5.17969504e-02f, -2.62935460e-02f, -1.99758783e-02f,
  2.42065042e-02f, 5.93969338e-02f, -4.97135334e-02f, -8.69052932e-02f, -1.38414660e-02f, -1.11753559e-02f, -1.77126266e-02f, -4.07971963e-02f, -1.36305571e-01f, 1.01980176e-02f,
  -5.00212312e-02f, -3.36983390e-02f, 3.85491252e-02f, 7.83392191e-02f, -3.20677049e-02f, -1.16419062e-01f, 8.89467523e-02f, -9.64011550e-02f, -1.22167230e-01f, -1.66658517e-02f,
  -1.96476411e-02f, 1.18193338e-02f, 1.14854932e-01f, 7.18765333e-02f, 2.11084038e-02f, -3.04530058e-02f, 5.81806973e-02f, 5.73498383e-02f, -9.70913023e-02f, -3.03922240e-02f,
  1.50367856e-01f, 1.76208287e-01f, 2.68056005e-01f, 1.89887956e-01f, -5.39321564e-02f, -3.42651993e-01f, -8.58433992e-02f, 2.50456613e-02f, 9.71883982e-02f, 7.79451206e-02f,
  -1.61069453e-01f, 2.14061573e-01f, -1.48597673e-01f, 3.43779288e-02f, -3.00250679e-01f, -1.39654279e-01f, 5.44915535e-02f, -3.69804390e-02f, -8.29558074e-02f, 1.20953627e-01f,
  1.40328094e-01f, -1.35616809e-01f, 1.53380528e-01f, -1.24887489e-01f, 2.03578576e-01f, 3.26697499e-01f, -2.66247592e-03f, -1.17962919e-01f, 3.43404382e-01f, -1.16955116e-01f,
  -5.11663444e-02f, 1.99290961e-02f, 9.16245431e-02f, -5.42534217e-02f, 1.10148504e-01f, -1.08379824e-02f, -2.26720031e-02f, -6.48136511e-02f, 5.80487773e-02f, 1.90830212e-02f,
  8.27606246e-02f, -6.52173609e-02f, 1.46724107e-02f, -1.62223186e-02f, 2.05112211e-02f, 2.50082202e-02f, 1.45032287e-01f, 1.47196233e-01f, 2.71632914e-02f, 5.92941791e-02f,
  1.10881403e-01f, 7.31157139e-02f, 9.16538835e-02f, 1.55892566e-01f, 3.09253670e-02f, 5.13647906e-02f, 6.00394458e-02f, 6.25720201e-03f, 7.68278390e-02f, 1.28987014e-01f,
  6.81331083e-02f, -1.26580909e-01f, -1.18714415e-01f, 4.79611531e-02f, 1.30139431e-02f, -2.49710754e-02f, -6.96905181e-02f, -5.40559441e-02f, 2.88224388e-02f, 6.27878234e-02f,
  1.39190242e-01f, 5.61495796e-02f, -4.09633890e-02f, 9.32788774e-02f, 1.55702978e-01f, -3.07193920e-02f, 2.33337823e-02f, 5.94789051e-02f, 5.32992696e-03f, 5.22232950e-02f,
  -4.22773920e-02f, -1.08436145e-01f, -8.25950038e-03f, 1.56476758e-02f, -8.63568634e-02f, 9.84081849e-02f, -3.73902991e-02f, -5.35277836e-02f, 2.33067703e-02f, 5.35802469e-02f,
  1.14200003e-01f, 7.08120093e-02f, 2.71931738e-02f, 7.95980636e-03f, -1.45054379e-04f, -6.92501441e-02f, -8.42575952e-02f, 3.55790518e-02f, -2.87681278e-02f, -8.16639215e-02f,
  1.14079185e-01f, 3.46838422e-02f, -5.23680449e-02f, 3.90203185e-02f, 4.12739953e-03f, 1.17932716e-02f, 2.96745449e-02f, 8.37965012e-02f, 3.00072376e-02f, -1.38456849e-02f,
  7.36014694e-02f, -9.75592211e-02f, 4.98444289e-02f, 1.08624473e-01f, 1.43707460e-02f, 2.31779721e-02f, -7.93000087e-02f, 1.14266418e-01f, 4.53399681e-02f, -5.64151406e-02f,
  2.36264259e-01f, 2.06593603e-01f, 7.48447999e-02f, 9.29945782e-02f, -1.72067299e-01f, -2.78222591e-01f, -2.13516101e-01f, 5.62851969e-03f, -1.85384363e-01f, -2.15502772e-02f,
  -1.72637384e-02f, -2.18660161e-02f, 3.12263239e-02f, 1.49883628e-01f, 2.38755971e-01f, -1.31885916e-01f, 1.29649028e-01f, -5.75151965e-02f, 8.55733752e-02f, 2.61952937e-01f,
  4.41888534e-02f, 2.48983935e-01f, 2.42161497e-01f, 1.42530560e-01f, 1.28553554e-01f, 5.13518080e-02f, 2.28370160e-01f, 4.70578261e-02f, 1.64081499e-01f, 4.06082235e-02f,
  -1.72754598e-03f, 3.70659418e-02f, 5.56732789e-02f, -8.58809873e-02f, 5.59464246e-02f, 3.88775431e-02f, -3.02312486e-02f, -1.59475766e-02f, -2.62899324e-02f, 2.01792605e-02f,
  -9.19588804e-02f, 1.01727527e-02f, -2.50736950e-03f, 6.33822531e-02f, 3.65349986e-02f, 2.04743561e-03f, 3.11736651e-02f, -7.24585727e-02f, -4.31909086e-03f, 1.25233516e-01f,
  4.80706291e-03f, -1.05154656e-01f, -1.97791755e-02f, 1.23095252e-02f, -6.33445159e-02f, -9.60983112e-02f, -1.11211305e-02f, -4.52506728e-02f, -1.42571256e-01f, -5.56948632e-02f,
  6.15502931e-02f, 2.04597935e-02f, -7.93390349e-02f, 3.49672278e-03f, 7.09128156e-02f, 7.68520534e-02f, -9.22876671e-02f, -3.29081789e-02f, 1.31753594e-01f, 4.89026271e-02f,
  -1.12248451e-01f, 8.71267691e-02f, -1.43600861e-02f, -3.63836363e-02f, 3.22686695e-02f, 8.32766667e-02f, 4.67745438e-02f, 6.17781514e-03f, -1.73320249e-02f, -1.88025888e-02f,
  -5.88407256e-02f, 6.00200519e-02f, -5.96615113e-02f, -9.04608741e-02f, 3.24078612e-02f, -4.37460840e-02f, -3.82967778e-02f, 2.91373357e-02f, 1.12704448e-02f, -8.24007541e-02f,
  -1.50940046e-02f, 2.15321139e-01f, -3.53781655e-02f, -1.35653675e-01f, -5.31379730e-02f, 1.05884865e-01f, 4.55107391e-02f, -2.01513804e-02f, -7.91159868e-02f, 7.46996552e-02f,
  4.77572046e-02f, 1.55372070e-02f, -1.12487406e-01f, 5.92041649e-02f, 5.40665090e-02f, -5.94314449e-02f, 1.72527395e-02f, -9.95889753e-02f, 2.12964006e-02f, 7.30214864e-02f,
  -2.74674632e-02f, 9.36195999e-03f, 1.70581676e-02f, -4.76824753e-02f, -4.16417494e-02f, -1.02508269e-01f, 5.70499040e-02f, -9.18648541e-02f, 7.70960003e-02f, -4.24620658e-02f,
  -2.09679127e-01f, -2.49378130e-01f, -2.16769040e-01f, -1.30386502e-01f, -1.02485254e-01f, 2.01340646e-01f, 1.36759907e-01f, 1.14244232e-02f, -1.26528367e-01f, 2.72265345e-01f,
  1.94902807e-01f, -2.52577871e-01f, 1.31576702e-01f, 1.38981566e-01f, -1.32456943e-01f, -5.69839701e-02f, 1.25137374e-01f, 8.99568796e-02f, -1.04950897e-01f, 3.95724773e-02f,
  3.13270316e-02f, 1.40830517e-01f, 1.48009816e-02f, 5.91937127e-03f, -6.25218004e-02f, -2.71621123e-02f, 1.76404849e-01f, -7.75273144e-02f, 1.19846389e-01f, -1.25887319e-01f,
  8.29824153e-03f, -1.20828681e-01f, -4.38023359e-02f, 2.38162968e-02f, 8.69533643e-02f, 1.18100554e-01f, 5.47734648e-02f, -3.74255143e-02f, 4.36207466e-03f, -7.72536695e-02f,
  -9.42287818e-02f, -1.02261841e-01f, 4.33207601e-02f, -7.34553412e-02f, -2.31234971e-02f, -1.36330783e-01f, -7.97471926e-02f, 1.86878275e-02f, -4.50780839e-02f, -1.55870719e-02f,
  3.28448340e-02f, -8.57736357e-03f, 1.03677409e-02f, 1.01929776e-01f, -1.05766386e-01f, -1.60134130e-03f, -2.50383560e-02f, -2.14289576e-02f, 6.79974332e-02f, -8.50657523e-02f,
  3.07780132e-03f, 3.51748616e-02f, 4.26992476e-02f, -6.96546882e-02f, -4.50687110e-02f, 1.32289663e-01f, 6.31639063e-02f, 3.77813019e-02f, -5.20156287e-02f, -3.87732387e-02f,
  -1.24041671e-02f, 2.99688242e-02f, -6.15568049e-02f, 9.73272789e-03f, 3.95730659e-02f, 3.11938934e-02f, 5.67239299e-02f, 6.46940172e-02f, 3.86469178e-02f, 9.20213982e-02f,
  -7.98807293e-03f, -1.57936484e-01f, -1.02144508e-02f, 3.56881060e-02f, 3.05171013e-02f, 3.50475833e-02f, 6.03215359e-02f, 9.27168578e-02f, 1.93941101e-01f, 5.99301234e-02f,
  1.18914194e-01f, -3.52241583e-02f, -6.53271303e-02f, -8.10709298e-02f, -1.20038502e-02f, -7.06548095e-02f, 3.12771946e-02f, 5.19406460e-02f, 7.89579824e-02f, -4.09920067e-02f,
  4.47914973e-02f, -4.00319658e-02f, 1.84160411e-01f, 6.32721139e-03f, -4.58194409e-03f, 2.56754067e-02f, 1.08687125e-01f, 1.05781019e-01f, 5.15401997e-02f, 8.65487158e-02f,
  8.82948712e-02f, 1.53635457e-01f, -6.79965317e-02f, 9.67579037e-02f, 8.38784352e-02f, 1.70376357e-02f, -3.91946025e-02f, 8.23149364e-03f, -2.02723984e-02f, -1.41923949e-01f,
  1.16213620e-01f, -4.69238237e-02f, -6.42578527e-02f, -1.01418952e-02f, -8.38549063e-02f, -6.49708789e-03f, -1.56210542e-01f, -2.24174894e-02f, -2.17613339e-01f, -5.15019614e-03f,
  -5.84094459e-03f, -1.79269180e-01f, -6.17256574e-02f, -1.28069326e-01f, -9.56959724e-02f, -2.51613587e-01f, -3.06833982e-02f, 1.48276687e-02f, -5.75729646e-02f, 1.40015721e-01f,
  3.26601751e-02f, -3.99745144e-02f, 1.10519314e-02f, 1.96398571e-01f, -3.67615744e-02f, 2.08362892e-01f, 2.85514057e-01f, 1.65082335e-01f, 1.69091552e-01f, 1.51005853e-02f,
  8.37606261e-04f, -1.85097307e-02f, -5.73341362e-02f, -9.62157473e-02f, 1.16584204e-01f, 1.01053856e-01f, 1.69095725e-01f, -5.24841016e-03f, -5.99412061e-02f, -1.38991280e-02f,
  -4.98512015e-03f, 3.19884047e-02f, -4.98676896e-02f, -5.31600602e-03f, -2.68470254e-02f, -7.19597414e-02f, -6.22449629e-02f, -5.33243380e-02f, -1.26752257e-01f, -2.43367404e-02f,
  -8.82243887e-02f, -5.75980172e-03f, -3.58498096e-02f, 5.49244229e-03f, -6.49926737e-02f, -5.13807572e-02f, 6.61874050e-03f, 5.13413623e-02f, -1.17203012e-01f, -1.97920483e-02f,
  1.36056900e-01f, 6.78433031e-02f, -1.74727943e-02f, -8.82637501e-02f, -2.64811292e-02f, 1.14420773e-02f, -1.16601326e-01f, 1.43085839e-03f, 1.88940503e-02f, 1.17151001e-02f,
  -9.44151878e-02f, -1.04921378e-01f, 4.19629999e-02f, 3.19681130e-02f, 1.29816696e-01f, -1.86880250e-02f, 1.19914889e-01f, -3.64639461e-02f, -6.83826534e-03f, -1.04749791e-01f,
  -9.81087536e-02f, -9.17418674e-03f, -4.41166461e-02f, 2.97682062e-02f, -4.18663658e-02f, 2.32521538e-02f, -2.60854010e-02f, 8.44607502e-02f, -1.66970827e-02f, 1.40355080e-02f,
  1.12885080e-01f, 1.55976832e-01f, -5.26137315e-02f, -1.12513974e-01f, -2.55601630e-02f, -1.12310536e-02f, -5.86563908e-02f, 3.85692492e-02f, 4.07247059e-02f, 8.30746740e-02f,
  1.45190626e-01f, -2.13836208e-02f, 2.42219418e-02f, -3.79618742e-02f, -1.78909916e-02f, -2.59130523e-02f, 7.12857395e-02f, 8.12792860e-04f, 3.56509686e-02f, 7.50639066e-02f,
  5.33051193e-02f, 4.65293080e-02f, -3.34571153e-02f, -1.06934585e-01f, -2.28335802e-02f, 6.25100657e-02f, 1.12861626e-01f, 1.13905475e-01f, -8.43393728e-02f, 1.38024976e-02f,
  -9.57652330e-02f, 2.86791660e-02f, -5.06928414e-02f, -2.84727544e-01f, 5.20320609e-02f, -2.72967845e-01f, -1.92655861e-01f, -1.21569172e-01f, 9.08924043e-02f, -1.27037361e-01f,
  -9.43532735e-02f, 5.21007963e-02f, 1.28129810e-01f, -2.27182791e-01f, 1.13575280e-01f, -7.72054493e-03f, -3.41143668e-01f, -1.89435706e-01f, -6.15941361e-02f, -3.57628256e-01f,
  -9.39081758e-02f, -2.69142151e-01f, -1.71671495e-01f, -1.50298029e-01f, -2.70910054e-01f, -6.71652704e-02f, 9.08567756e-02f, -1.45104202e-03f, -8.44067782e-02f, 1.17391437e-01f,
  -5.95551990e-02f, -4.35982049e-02f, -5.60603030e-02f, -1.02614172e-01f, -3.74142639e-02f, -5.49819171e-02f, -1.00802600e-01f, 3.25960806e-03f, -3.71182263e-02f, -1.55973777e-01f,
  5.98451421e-02f, 7.13857450e-03f, 4.84534614e-02f, 5.28628156e-02f, 2.02497002e-02f, 8.46132822e-03f, 4.06112196e-03f, -4.68758903e-02f, -3.86545174e-02f, 1.99776608e-02f,
  -3.31254043e-02f, 4.06478718e-02f, 4.71183099e-02f, 1.97514426e-02f, 8.42364281e-02f, 2.37875301e-02f, -6.23960048e-02f, -1.91392917e-02f, -4.88663763e-02f, -2.73743551e-02f,
  -3.33594270e-02f, -8.61773193e-02f, -4.29965630e-02f, 3.84096429e-02f, -8.38269144e-02f, 1.01467641e-02f, 1.10242143e-02f, -8.97618160e-02f, -9.42066386e-02f, 9.87709314e-02f,
  9.01304781e-02f, 7.06197247e-02f, -7.27349594e-02f, -5.55125810e-02f, -6.50769621e-02f, 5.70829585e-02f, -3.66941579e-02f, -1.49193987e-01f, -3.18688229e-02f, -2.43838802e-02f,
  1.65675823e-02f, 5.53653669e-03f, 2.64221560e-02f, -9.18310434e-02f, -3.10377106e-02f, 6.86028153e-02f, 5.55983819e-02f, -1.36007499e-02f, -2.84696333e-02f, 1.69003159e-02f,
  -5.76673374e-02f, -1.86084107e-01f, -1.00297295e-02f, 6.53386340e-02f, -1.56851124e-03f, -1.62905931e-01f, -3.89989354e-02f, -1.07015483e-01f, -5.70362546e-02f, -6.80685714e-02f,
  -3.45977023e-02f, -6.48434311e-02f, 6.12347713e-03f, -4.28624675e-02f, 4.26334701e-02f, -1.90759338e-02f, -4.91061509e-02f, 1.71397813e-02f, -5.75861298e-02f, -2.14018561e-02f,
  -9.47778486e-03f, 6.45449236e-02f, 1.96443394e-01f, -6.91321865e-02f, -3.52295712e-02f, 9.12844613e-02f, -1.28764257e-01f, 5.15524298e-02f, -5.38496822e-02f, 7.91918635e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.80130841e-02f, 2.88939387e-01f, 1.14708908e-01f, 3.13430056e-02f, -2.18986496e-02f, 5.48594333e-02f, 1.83331192e-01f, 3.62774618e-02f, 7.09033012e-02f, 6.00415282e-02f,
  -1.51158003e-02f, 1.34911612e-01f, 2.62265727e-02f, 8.62129927e-02f, 5.48365973e-02f, 1.79326966e-01f, 9.82273296e-02f, 4.64330800e-02f, 1.21336572e-01f, 1.28192008e-01f,
  2.55640727e-02f, 6.12226054e-02f, -1.22707756e-02f, 4.71837148e-02f, 3.80698889e-02f, 1.72703058e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.60043256e-02f, 2.72760779e-01f, -6.19072132e-02f, -5.02081960e-02f, -1.19580574e-01f, 1.43183628e-02f, 2.25342810e-02f, 1.47539124e-01f, -5.73254526e-02f, 1.35643527e-01f,
  1.77929606e-02f, 9.73794386e-02f, -1.45166487e-01f, -2.79779304e-02f, 4.82435785e-02f, 1.33127738e-02f, -2.09368672e-02f, -9.75485668e-02f, -4.04824428e-02f, 5.13003357e-02f,
  3.49785946e-02f, 7.78423902e-03f, 2.32050955e-01f, 1.78585231e-01f, 1.04277939e-01f, -9.94839575e-05f, 6.90942034e-02f, -9.93796960e-02f, -6.56750947e-02f, 2.18535006e-01f,
  9.23463479e-02f, -7.82115161e-02f, -2.38100123e-02f, 9.06413868e-02f, 8.01200047e-02f, 5.56354225e-02f, -1.51066169e-01f, 4.90597002e-02f, -6.02819845e-02f, 8.52897838e-02f,
  -5.52671738e-02f, -3.30932960e-02f, -1.42239273e-01f, -1.99341998e-01f, 4.58346903e-02f, 2.00734168e-01f, 2.45426685e-01f, 6.72573075e-02f, -3.41148004e-02f, -1.02686495e-01f,
  2.65739322e-01f, 1.52874038e-01f, -2.48389572e-01f, 6.33381009e-02f, 2.39837483e-01f, -1.08731888e-01f, -3.86936158e-01f, -3.01076740e-01f, -1.29960001e-01f, -1.95659138e-02f,
  -4.79061417e-02f, 6.27364367e-02f, 1.91881042e-02f, -1.80324391e-01f, -2.36998752e-01f, 4.70374674e-02f, -4.25103232e-02f, 9.66241509e-02f, 4.67045009e-02f, -5.71380705e-02f,
  -1.45881921e-01f, -1.30244255e-01f, 7.51505047e-02f, -6.78482652e-02f, 4.85134050e-02f, -6.19692914e-02f, 7.71929994e-02f, -8.47235788e-03f, -1.06496878e-01f, -1.66670263e-01f,
  1.86498892e-02f, -8.39094818e-02f, -1.95714887e-02f, -8.74628201e-02f, 2.62146220e-02f, -1.26355842e-01f, -5.37439808e-03f, 1.28622577e-01f, -1.73573032e-01f, 7.81277791e-02f,
  1.34440064e-01f, -5.51810786e-02f, 1.91626057e-01f, -2.48885363e-01f, -7.71904066e-02f, -8.51776376e-02f, -1.24384195e-01f, 2.33646557e-02f, -1.23788320e-01f, 2.09012181e-02f,
  -1.55470237e-01f, 1.09559901e-01f, -8.59688222e-03f, 1.85538991e-03f, 1.36491910e-01f, -5.18129431e-02f, -4.89356816e-02f, 2.88466960e-01f, -1.90760508e-01f, -1.87173814e-01f,
  -8.24564546e-02f, -5.73272482e-02f, 1.48093686e-01f, -5.80668170e-03f, -9.91911814e-02f, 4.08680625e-02f, 1.95101351e-01f, -2.35003904e-01f, -8.95761624e-02f, 5.44918031e-02f,
  9.24592987e-02f, -1.12518575e-02f, -1.21003829e-01f, 2.34595373e-01f, 1.01430029e-01f, -3.24822992e-01f, 3.93877663e-02f, 1.75843567e-01f, -1.67808775e-02f, -7.29053244e-02f,
  -5.00067100e-02f, 1.45432865e-02f, 1.11568362e-01f, 7.38493912e-03f, 1.03075348e-01f, -2.25652456e-01f, -1.12965599e-01f, -1.48752937e-02f, -4.39304784e-02f, -1.35211110e-01f,
  8.56572464e-02f, -1.58103649e-02f, -1.22908369e-01f, -1.51619390e-01f, -1.27714351e-01f, -2.74433773e-02f, 1.21090874e-01f, 6.71732128e-02f, -1.50010228e-01f, 3.21329795e-02f,
  -1.57232821e-01f, -1.46851748e-01f, 4.42822427e-02f, 1.94771960e-02f, 6.72826245e-02f, -1.10162729e-02f, 3.73204146e-03f, -2.32287541e-01f, 1.35981403e-02f, 1.69378012e-01f,
  7.47664943e-02f, 1.51514545e-01f, 1.36985123e-01f, 1.56328186e-01f, 2.51132026e-02f, 7.56502375e-02f, -1.04358688e-01f, -1.38009533e-01f, -2.85863936e-01f, -7.47535676e-02f,
  -1.68539700e-04f, 2.30877429e-01f, -1.31586000e-01f, -1.67405099e-01f, 2.70556081e-02f, -1.14818595e-01f, -1.05435684e-01f, 1.06375478e-01f, -8.90230909e-02f, -1.51895210e-01f,
  -1.43245339e-01f, -3.29644755e-02f, -2.39831824e-02f, 1.91231985e-02f, 3.18658352e-02f, 3.39034945e-01f, 1.19682848e-01f, -2.39396229e-01f, 3.93254273e-02f, -6.21973909e-02f,
  -4.36939904e-03f, 1.16442837e-01f, -1.04458787e-01f, -1.65665731e-01f, -5.93640320e-02f, -3.42448056e-02f, 1.18730433e-01f, -1.31741874e-02f, -1.41692404e-02f, -1.28385544e-01f,
  6.10447414e-02f, -6.64437860e-02f, -3.02284006e-02f, -7.87239522e-02f, 8.81382227e-02f, -1.38903663e-01f, -2.44493689e-02f, -5.69031574e-02f, -7.47004971e-02f, -5.04366979e-02f,
  1.38843460e-02f, 1.96716492e-03f, 2.21650489e-02f, -1.31502524e-01f, -1.20569207e-02f, -3.86435241e-02f, 6.63017482e-02f, 1.66127414e-01f, 2.09863141e-01f, 1.92107171e-01f,
  1.12915955e-01f, -1.32934839e-01f, -1.11700706e-01f, 4.72292900e-02f, -6.72037378e-02f, -9.33265090e-02f, -2.53800545e-02f, -6.95412233e-03f, -1.24107428e-01f, 4.63603474e-02f,
  1.64518923e-01f, -1.43231034e-01f, -5.83066680e-02f, 1.96420830e-02f, 1.23750664e-01f, 3.41465503e-01f, -8.80001634e-02f, -8.33245069e-02f, -7.56698102e-02f, -8.28021318e-02f,
  5.83621711e-02f, 2.24303618e-01f, -1.73694357e-01f, -8.05599988e-03f, -1.74267776e-02f, -6.61410764e-02f, -1.69688873e-02f, 1.15202144e-01f, 3.00054342e-01f, 2.34987706e-01f,
  6.77707344e-02f, 1.40188131e-02f, 5.36589026e-02f, -2.37884372e-02f, 7.76514784e-02f, 2.14720339e-01f, -1.24829449e-01f, -3.21960039e-02f, -8.99640918e-02f, -1.87905878e-01f,
  -6.43032119e-02f, -8.89263973e-02f, -4.96396497e-02f, 6.37566205e-03f, 2.08009016e-02f, -7.28332326e-02f, -3.04039437e-02f, -4.89862338e-02f, 5.16213942e-03f, -9.62793902e-02f,
  -3.76361981e-02f, -4.27943543e-02f, -1.59499109e-01f, -1.33933112e-01f, 6.81901500e-02f, 4.08555567e-02f, 6.63463920e-02f, -6.86438307e-02f, 9.72091928e-02f, 9.09197796e-03f,
  7.77082220e-02f, 1.86671503e-02f, 7.65283331e-02f, -1.38397411e-01f, -1.45412690e-03f, -3.44030783e-02f, 1.53299794e-01f, -9.85526517e-02f, 1.87876225e-02f, 7.88209215e-02f,
  1.81490809e-01f, 2.92817265e-01f, -7.49121755e-02f, -8.70296136e-02f, -1.41173422e-01f, -1.27799034e-01f, -1.28483966e-01f, 1.36976829e-02f, -2.58889291e-02f, -1.45935178e-01f,
  -6.37112558e-02f, 3.15821432e-02f, -6.50673360e-02f, 1.64010435e-01f, 1.89387977e-01f, -7.58801922e-02f, -2.31246580e-03f, 1.48481235e-01f, -2.50800624e-02f, 1.00855850e-01f,
  -7.40640536e-02f, 5.03698662e-02f, -1.75428644e-01f, 9.84851494e-02f, -4.12996784e-02f, -3.74543108e-02f, 2.74510711e-01f, -9.68471095e-02f, 8.46174881e-02f, -5.39620593e-02f,
  -6.22299388e-02f, -3.57931145e-02f, -1.76006816e-02f, -3.62409651e-02f, 7.48162642e-02f, 1.49235381e-02f, -9.02170688e-02f, 3.21661234e-01f, 1.31449893e-01f, -1.47865310e-01f,
  -1.33393779e-02f, -3.44467256e-03f, -8.16909689e-03f, -6.89355433e-02f, 3.74398232e-02f, 1.73362017e-01f, 1.16157189e-01f, 8.73620287e-02f, -1.65430307e-02f, -5.60950525e-02f,
  2.00517103e-01f, -3.41819264e-02f, 1.95136026e-01f, 8.26663896e-02f, 8.07974339e-02f, 2.33590999e-03f, 1.74240872e-01f, 1.93389028e-01f, -9.44061279e-02f, 1.36170968e-01f,
  4.77981977e-02f, -1.17574051e-01f, 5.68629541e-02f, -2.34422177e-01f, -1.40365437e-01f, 1.62455216e-02f, -1.65547490e-01f, -1.08385123e-01f, -1.65058255e-01f, 4.73545119e-02f,
  2.49060541e-01f, 1.87300220e-01f, 1.92609429e-01f, -3.69017810e-01f, 1.12595499e-01f, 9.86935869e-02f, -1.18556924e-01f, -6.94440901e-02f, 1.04017153e-01f, -8.94304067e-02f,
  -6.84175938e-02f, 1.15609944e-01f, 2.03384921e-01f, -1.85436923e-02f, 7.78921247e-02f, 3.64020728e-02f, 1.14937434e-02f, -1.82177082e-01f, -1.24653138e-01f, 2.89291084e-01f,
  8.94899815e-02f, 9.71731469e-02f, -3.80392298e-02f, -2.42385417e-01f, -3.83400470e-02f, -1.67353973e-02f, -8.48765746e-02f, -2.24980377e-02f, 1.37285125e-02f, -9.71552283e-02f,
  7.61145726e-02f, 2.16094345e-01f, 1.36688426e-01f, -4.43659863e-03f, -1.16492786e-01f, 4.71036471e-02f, 1.00282751e-01f, -1.12033047e-01f, 1.39716677e-02f, 1.30597517e-01f,
  6.76956028e-02f, 3.79254147e-02f, -3.30558904e-02f, 5.71472421e-02f, 8.21165293e-02f, 1.33926764e-01f, -4.29019593e-02f, -1.15868278e-01f, 1.11395590e-01f, -5.94225787e-02f,
  5.71173765e-02f, 3.30365193e-03f, -3.23733985e-02f, 6.37363642e-02f, 1.33170694e-01f, 2.68803257e-02f, 3.10467690e-01f, -7.02769831e-02f, 1.46043390e-01f, 1.09163307e-01f,
  9.82391238e-02f, -2.37316459e-01f, -4.21603695e-02f, 4.58011590e-03f, -1.46174416e-01f, 3.13777924e-02f, 1.59317359e-01f, -3.02913845e-01f, 2.76038438e-01f, 8.31781179e-02f,
  -6.55583218e-02f, -3.91901955e-02f, -9.34395045e-02f, 7.26866052e-02f, -4.78503481e-03f, 4.93501220e-03f, -1.79191649e-01f, 1.23723425e-01f, -1.49178863e-01f, 1.88836992e-01f,
  1.01191409e-01f, 1.44746229e-01f, -3.57845537e-02f, -9.90954936e-02f, -7.51717687e-02f, -7.15821460e-02f, -9.10255015e-02f, -4.43753414e-02f, 1.21611401e-01f, 1.15458161e-01f,
  9.14103761e-02f, -1.55013084e-01f, -3.55175026e-02f, -2.01762188e-02f, 8.70789140e-02f, -6.18572859e-03f, -1.59719616e-01f, 5.84665798e-02f, 4.63319160e-02f, 8.97554010e-02f,
  -3.24007608e-02f, 1.12456847e-02f, 1.57941803e-02f, 3.42820846e-02f, 2.27748007e-02f, -7.17628002e-02f, 2.14316733e-02f, 5.77081814e-02f, -3.15316878e-02f, 7.30349347e-02f,
  8.66931602e-02f, -4.57133874e-02f, 1.79303978e-02f, -2.25247331e-02f, -1.23672456e-01f, -1.27807230e-01f, -1.41958222e-01f, 1.40175521e-01f, -7.47288689e-02f, 3.69520076e-02f,
  -1.04705714e-01f, 5.05016893e-02f, 1.48093686e-01f, 8.46881717e-02f, 1.24425806e-01f, 1.46751180e-01f, -4.74746563e-02f, -1.98984593e-02f, -1.96732134e-01f, 4.22073901e-02f,
  -3.24561559e-02f, -8.58343765e-02f, -6.66190237e-02f, 1.04989968e-01f, 1.77501678e-01f, 5.89575134e-02f, -1.71288937e-01f, -2.16032919e-02f, 1.12905517e-01f, 4.15074360e-03f,
  -1.69009462e-01f, 2.16514558e-01f, 1.54757738e-01f, -6.59014806e-02f, -2.46082008e-01f, -9.63703245e-02f, 3.32808457e-02f, -1.34509578e-01f, -7.94084072e-02f, 1.67445868e-01f,
  5.68431579e-02f, -1.73287272e-01f, -5.26810251e-02f, 1.35303631e-01f, 6.49948511e-03f, -1.16089702e-01f, 3.15583199e-02f, -2.70317513e-02f, -2.59704161e-02f, -2.72658803e-02f,
  -8.27337801e-02f, 1.26788870e-01f, -6.48291409e-02f, 3.45403585e-03f, 7.19023496e-02f, -8.10235459e-03f, -7.58190528e-02f, -3.87094617e-02f, -3.06747984e-02f, -1.82229087e-01f,
  -2.49067508e-02f, -6.36974201e-02f, -1.87425733e-01f, 3.11716814e-02f, 9.19506550e-02f, 6.36495203e-02f, 7.24058226e-02f, 9.74675349e-04f, 2.35845950e-02f, -3.00332278e-01f,
  -1.08033054e-01f, 7.28404801e-03f, 5.22791594e-02f, -6.10234775e-02f, -5.08099720e-02f, 1.05061837e-01f, 1.79370463e-01f, 2.38470674e-01f, -2.63984408e-02f, 3.82960215e-02f,
  -1.61856160e-01f, -5.28213941e-02f, -2.18012869e-01f, 9.01931226e-02f, 6.20778464e-02f, -1.49730682e-01f, -1.45717770e-01f, -1.46561144e-02f, 9.96303558e-02f, 1.54251322e-01f,
  1.39664993e-01f, -1.26090020e-01f, 1.88851729e-01f, 7.25801140e-02f, -7.21486434e-02f, 1.63295493e-01f, 8.99810046e-02f, -1.24594294e-01f, -3.24362367e-01f, 6.94811717e-02f,
  3.29837874e-02f, -8.79794732e-02f, 2.38127246e-01f, 7.53009133e-03f, 1.94553971e-01f, -1.63515002e-01f, -1.16000235e-01f, 2.70209312e-02f, -1.31119281e-01f, -5.72223812e-02f,
  -1.36608630e-01f, -1.42972574e-01f, -9.84813273e-03f, -1.04649715e-01f, 2.91387271e-02f, 5.69819622e-02f, 2.41809580e-02f, -8.22407976e-02f, -3.32089067e-02f, 1.33775687e-02f,
  7.32307956e-02f, -1.37302861e-01f, -1.41643062e-01f, -1.23076633e-01f, 5.21862358e-02f, -8.92510563e-02f, 1.26953423e-02f, 6.77683130e-02f, 1.13174781e-01f, 1.41227573e-01f,
  5.22751138e-02f, -8.71767104e-02f, -6.64733127e-02f, -3.01789850e-01f, 1.03169447e-02f, 1.51112154e-01f, 1.22553915e-01f, -1.60915181e-01f, 5.54764420e-02f, 1.86736703e-01f,
  1.77062690e-01f, 4.06791493e-02f, 5.66485673e-02f, -1.61904618e-02f, -4.19505015e-02f, 2.00841665e-01f, 5.05760945e-02f, 8.45346227e-02f, -5.82444817e-02f, -2.26325631e-01f,
  5.76516092e-02f, 1.42242432e-01f, 1.24317572e-01f, 1.83168456e-01f, 1.67176291e-01f, -1.16245747e-01f, 2.95341790e-01f, 1.92114592e-01f, 1.45107448e-01f, 1.78630814e-01f,
  -2.30627641e-01f, 6.34937957e-02f, -1.88135773e-01f, -1.95961311e-01f, -7.78492242e-02f, 6.25642017e-02f, 1.72832862e-01f, -2.04676047e-01f, -2.58719106e-03f, -7.99028501e-02f,
  7.88817480e-02f, 4.05039266e-02f, 1.41460136e-01f, 2.47048717e-02f, -8.44779909e-02f, -5.93165495e-02f, 5.10816686e-02f, -2.43059054e-01f, -1.30779207e-01f, 9.28346142e-02f,
  6.81511909e-02f, 3.96947525e-02f, 2.37749517e-02f, 8.76142755e-02f, -2.96938140e-02f, -1.73925132e-01f, 2.14407817e-02f, -1.53423607e-01f, 7.75794089e-02f, -7.67700896e-02f,
  -3.53779346e-02f, 3.85296606e-02f, 1.67338699e-02f, 1.07721560e-01f, -2.65064240e-01f, 4.32000980e-02f, -1.72839373e-01f, -2.20908538e-01f, 5.49743511e-02f, -1.52449608e-01f,
  -1.04813017e-01f, -4.42848131e-02f, -2.46009901e-01f, 1.34633958e-01f, -2.62320153e-02f, 2.56335679e-02f, -7.35204890e-02f, 1.08859465e-01f, -1.39241023e-02f, 4.15949225e-02f,
  2.26041172e-02f, -1.02278076e-01f, -1.47545844e-01f, 1.32771835e-01f, -1.14521936e-01f, -1.44231036e-01f, 7.78022036e-02f, 1.64536327e-01f, 1.89489841e-01f, -9.61735770e-02f,
  -1.17106847e-02f, 7.39857778e-02f, 6.37991950e-02f, 4.66283299e-02f, -2.43928051e-03f, -1.38739958e-01f, -9.72066820e-02f, -9.20078233e-02f, -4.21138667e-02f, 1.79396942e-01f,
  4.94160429e-02f, -1.74783558e-01f, 2.20916774e-02f, 8.61304551e-02f, 1.65329292e-01f, 1.23042576e-01f, 9.28646624e-02f, 7.93597922e-02f, -4.78122532e-02f, -2.85333712e-02f,
  1.75807953e-01f, 1.69511691e-01f, -8.51133540e-02f, 1.05948322e-01f, -7.94803798e-02f, 5.10878302e-02f, -4.53270711e-02f, 3.52025777e-02f, 4.29163128e-02f, -3.94397788e-02f,
  1.35236233e-01f, 2.20098086e-02f, 1.16800338e-01f, 4.12189700e-02f, -4.60596010e-02f, 1.33581072e-01f, -1.32532939e-01f, -8.59133974e-02f, -1.57119840e-01f, -1.70224503e-01f,
  -1.68059036e-01f, -2.25267932e-01f, 2.13096105e-02f, -2.96241306e-02f, 8.88821781e-02f, 6.15696907e-02f, 6.84092343e-02f, 1.01198763e-01f, -3.65241989e-02f, -4.42798622e-02f,
  3.87753636e-01f, 1.17770150e-01f, -9.38907415e-02f, 2.14608029e-01f, 1.93410575e-01f, -1.07484832e-01f, -2.57333130e-01f, -2.36155242e-01f, 1.27397120e-01f, -5.32514378e-02f,
  5.27831502e-02f, -1.45606875e-01f, -9.87249166e-02f, -2.35460281e-01f, -7.82520138e-03f, -2.61298537e-01f, 6.23197518e-02f, -2.59664387e-01f, -1.19153209e-01f, -7.31522441e-02f,
  -2.12325722e-01f, -1.63442165e-01f, -3.85898650e-02f, 1.02146722e-01f, -8.05415139e-02f, -9.36252773e-02f, -2.34847125e-02f, -6.91554174e-02f, -3.44543755e-02f, 5.10808341e-02f,
  8.49834159e-02f, 7.64786080e-02f, 1.11857429e-01f, 6.62921369e-03f, -1.68271754e-02f, 1.77188829e-01f, 2.63140276e-02f, 1.04843631e-01f, 4.56443615e-02f, 1.17748305e-01f,
  8.21714252e-02f, 3.47332321e-02f, 8.18682611e-02f, 1.47158980e-01f, 1.20975748e-01f, 1.78558573e-01f, -7.67948627e-02f, 8.90663080e-03f, 1.53961673e-01f, -2.35847291e-02f,
  5.01773730e-02f, 1.50336668e-01f, 9.47568268e-02f, -1.44816544e-02f, 2.03784376e-01f, 2.06742585e-01f, -2.55665239e-02f, 6.60945922e-02f, 6.60175383e-02f, -2.92706992e-02f,
  1.11986831e-01f, -1.78465813e-01f, -1.94036722e-01f, -2.68589407e-01f, -8.69791955e-02f, 5.44006974e-02f, -6.90239444e-02f, 2.45986164e-01f, 1.53769150e-01f, -2.04003439e-03f,
  5.41706830e-02f, 1.46615684e-01f, 2.41513439e-02f, 9.07567739e-02f, 1.18131377e-01f, -1.62220418e-01f, -6.25077114e-02f, 1.80430755e-01f, -5.80871012e-03f, -1.65989086e-01f,
  3.04182395e-02f, -2.23234877e-01f, 1.06384031e-01f, -7.03246742e-02f, 2.03406319e-01f, 4.13447706e-04f, -1.31204590e-01f, 1.30145729e-01f, -5.55270091e-02f, 1.00638494e-01f,
  3.96517627e-02f, -9.39691067e-02f, 1.67745456e-01f, -1.15357107e-03f, -2.12085880e-02f, 1.43646151e-01f, -1.30206337e-02f, 8.09990428e-03f, 5.50780036e-02f, -2.11608469e-01f,
  -5.81330769e-02f, -5.41143380e-02f, 8.24562609e-02f, -4.43572253e-02f, -1.01052232e-01f, 8.76624957e-02f, -7.44665563e-02f, -1.36516973e-01f, 1.68332726e-01f, -1.14381071e-02f,
  7.53981248e-02f, -6.82247430e-02f, -8.91226381e-02f, 2.02771306e-01f, -9.08472911e-02f, 1.14297986e-01f, -2.35474274e-01f, -3.77506055e-02f, -2.62061626e-01f, -1.04423217e-01f,
  6.04690192e-03f, -1.48527414e-01f, -2.27264345e-01f, -8.21935758e-03f, -1.89443767e-01f, 9.29211453e-02f, -1.43695980e-01f, -1.35284483e-01f, 1.46629423e-01f, 1.01053573e-01f,
  1.32888794e-01f, -4.49021161e-03f, 9.34258550e-02f, -1.22312814e-01f, -1.55347571e-01f, 1.82847112e-01f, -5.49999885e-02f, -2.52088517e-01f, 1.75893679e-02f, -5.82876168e-02f,
  -9.75071043e-02f, -8.74466151e-02f, -2.55533401e-02f, -1.21185165e-02f, 1.33839315e-02f, 1.33983672e-01f, -1.46633804e-01f, -1.27551988e-01f, 8.53521824e-02f, -5.97404763e-02f,
  -2.56391168e-02f, 2.42030639e-02f, -1.42884746e-01f, -1.33603647e-01f, -2.33104050e-01f, 1.16008088e-01f, 1.85658727e-02f, 7.03253970e-02f, -5.51202819e-02f, -9.06794295e-02f,
  -1.04158674e-03f, -3.71131077e-02f, -3.21819596e-02f, 5.14172614e-02f, -3.00377943e-02f, -3.62814381e-03f, 4.74984087e-02f, 5.41989543e-02f, 7.42336316e-03f, -4.07944433e-02f,
  7.07723647e-02f, -1.04375160e-03f, -5.03531694e-02f, -1.48419112e-01f, 1.11445948e-01f, 8.93471763e-02f, -3.85677181e-02f, -1.20942265e-01f, 1.58488706e-01f, 1.57644413e-02f,
  1.12627961e-01f, 6.13333881e-02f, -7.48728886e-02f, -2.18647420e-01f, -2.91350745e-02f, 9.94427502e-02f, -1.53944548e-02f, 2.65609240e-03f, -1.25060797e-01f, 8.12513754e-02f,
  1.23328499e-01f, 2.55992055e-01f, -1.09279253e-01f, 9.34740305e-02f, -5.53793274e-02f, -5.85151538e-02f, -1.61089331e-01f, -4.68762405e-02f, -6.00829981e-02f, -1.56089723e-01f,
  -1.25008985e-01f, 1.28467962e-01f, -1.83008760e-02f, 1.90601453e-01f, 1.22448601e-01f, -1.76745877e-01f, 1.32727787e-01f, 1.17674135e-01f, -4.85612974e-02f, 1.32708058e-01f,
  9.88206416e-02f, 4.24791202e-02f, -3.11888218e-01f, -1.30356655e-01f, 1.24651287e-02f, 3.34891602e-02f, 1.91103026e-01f, -3.40941921e-02f, 1.23733163e-01f, 9.28715616e-02f,
  -1.46828115e-01f, -3.79267633e-02f, -1.38054803e-01f, -1.03989735e-01f, -1.24464072e-01f, -2.87982151e-02f, -1.71427310e-01f, -9.14029733e-05f, 1.21105872e-01f, -7.64748380e-02f,
  -9.82733369e-02f, -1.33142292e-01f, -1.29372224e-01f, 3.05844229e-02f, -2.86582913e-02f, 5.29940380e-03f, 6.97707683e-02f, 1.14755081e-02f, -1.51586160e-01f, -1.29047409e-01f,
  9.58209708e-02f, -1.85276871e-03f, 1.91507757e-01f, 2.21154734e-01f, 2.04937875e-01f, -5.88719547e-02f, 2.62169063e-01f, 1.23514220e-01f, -1.29902467e-01f, 1.99774593e-01f,
  6.81583509e-02f, -1.91442207e-01f, 7.04724863e-02f, -5.84415607e-02f, 6.04794268e-03f, 1.23798445e-01f, -2.68927932e-01f, -2.46663406e-01f, -1.96595535e-01f, -1.85726751e-02f,
  -1.06560104e-01f, 1.65789455e-01f, 1.69519871e-01f, -4.50720154e-02f, -6.14065155e-02f, 1.23992458e-01f, 3.13503593e-02f, 1.67971417e-01f, 1.65279463e-01f, 3.82925533e-02f,
  5.54254912e-02f, 2.77869612e-01f, -1.96608137e-02f, 2.04313114e-01f, 2.55992189e-02f, 6.21515550e-02f, 1.33316871e-02f, -2.06327587e-01f, -2.13540360e-01f, -9.97302588e-03f,
  1.91164017e-01f, -3.35012674e-02f, 3.01571842e-02f, -2.77069092e-01f, 1.50460288e-01f, 9.96704549e-02f, 3.92882042e-02f, 6.17002137e-02f, -1.59665886e-02f, -3.56572829e-02f,
  2.33954445e-01f, 1.32373869e-01f, -4.92663644e-02f, 5.85391335e-02f, -2.16101445e-02f, 8.60945210e-02f, 8.70478749e-02f, 2.65921280e-02f, -2.44188346e-02f, 2.77782455e-02f,
  5.93886524e-02f, -6.54061958e-02f, 1.85789347e-01f, 8.76669809e-02f, -5.48368320e-02f, 6.45220354e-02f, -2.18455866e-01f, -1.42253190e-01f, -1.00310415e-01f, -7.55483508e-02f,
  -1.21594332e-01f, -1.35814548e-01f, 5.40356934e-02f, -1.39511973e-01f, 3.63878906e-02f, 1.32768080e-01f, 7.95871019e-02f, 2.13002503e-01f, 6.73215836e-02f, -2.56105792e-02f,
  3.04046422e-01f, 3.42660658e-02f, -1.58309206e-01f, 1.76202938e-01f, 9.87629499e-03f, -1.74847245e-01f, -1.21543445e-01f, -1.06609136e-01f, 1.37445042e-02f, -7.33530223e-02f,
  3.44814695e-02f, -9.04194489e-02f, -1.35508761e-01f, -1.05485037e-01f, -3.15923430e-02f, -1.70139655e-01f, 2.89580952e-02f, -1.11252330e-01f, -1.80240959e-01f, -1.05398543e-01f,
  -5.19890338e-02f, 9.22501236e-02f, 2.19355691e-02f, -7.87336603e-02f, -5.29742725e-02f, -5.18083200e-02f, -4.36617769e-02f, -9.61365327e-02f, 4.61792648e-02f, 4.78570275e-02f,
  -7.57925510e-02f, -7.71061033e-02f, -4.77003641e-02f, 4.00659442e-03f, -9.76680294e-02f, 1.99596033e-01f, -3.61465327e-02f, -3.03456914e-02f, -1.33371070e-01f, 7.28829298e-03f,
  -1.59978688e-01f, -3.08793504e-02f, 5.79898320e-02f, 1.32733593e-02f, -7.42869824e-03f, -2.10431293e-02f, -1.00077912e-01f, -6.71112211e-04f, 5.08391112e-02f, 1.19965583e-01f,
  -5.40766083e-02f, -2.09193259e-01f, 1.67784929e-01f, -1.39746651e-01f, -1.33619785e-01f, 1.07024059e-01f, -7.80385658e-02f, 2.54092485e-01f, -1.76873669e-01f, 6.20434284e-02f,
  5.67456372e-02f, -1.72036961e-01f, -1.63329486e-02f, -5.37880361e-02f, 2.50722505e-02f, -1.69595107e-01f, 1.95569843e-01f, -1.68860897e-01f, 6.72619939e-02f, 7.68572316e-02f,
  1.05033323e-01f, -1.55089289e-01f, 2.98613757e-01f, 1.74341619e-01f, -1.39586866e-01f, -1.75434858e-01f, -1.91381350e-01f, -9.93401557e-02f, -9.11196843e-02f, -1.37879297e-01f,
  -1.02717049e-01f, 4.49864157e-02f, 9.78039056e-02f, 3.61215919e-02f, -9.98223796e-02f, -1.67642638e-01f, -7.86041282e-03f, -6.98115602e-02f, -6.30793534e-03f, 2.34764278e-01f,
  1.43222883e-01f, -1.71193659e-01f, 2.03733027e-01f, -5.04872296e-03f, 5.35958447e-02f, -1.21058919e-01f, 4.32523862e-02f, 1.32623790e-02f, 9.87522751e-02f, 7.01317471e-03f,
  2.49195844e-02f, 6.74643591e-02f, 4.71762754e-02f, 1.36892855e-01f, 6.83369040e-02f, -3.90952304e-02f, -6.77915663e-02f, 2.23868061e-02f, 2.86248475e-02f, -8.97954926e-02f,
  -6.70018513e-03f, 1.08876616e-01f, 4.74328222e-03f, -1.40765011e-01f, 1.45029113e-01f, -2.70549208e-02f, -9.79110599e-02f, 3.81357186e-02f, -4.28139158e-02f, -3.36850062e-02f,
  -9.92812440e-02f, 5.29788136e-02f, 4.99126874e-02f, -2.72215955e-04f, -5.49956746e-02f, 6.32856116e-02f, 1.68382585e-01f, 2.32338667e-01f, -7.79200494e-02f, 7.01353699e-02f,
  -1.23210892e-01f, -4.29215692e-02f, -3.37845087e-02f, -6.67375252e-02f, -1.38151035e-01f, -1.54912576e-01f, -1.56120256e-01f, -5.26504591e-02f, 1.10970074e-02f, 1.40108019e-01f,
  -1.16402395e-01f, -1.30872309e-01f, 4.98183742e-02f, 9.38564911e-02f, -1.27388805e-01f, 2.66178727e-01f, 2.51354039e-01f, -7.64558837e-02f, -2.95125753e-01f, 1.27872169e-01f,
  -2.15383470e-02f, 7.84194749e-03f, 4.33626175e-02f, 1.01930931e-01f, 1.52264848e-01f, -1.28287807e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.69712782e-01f, 1.56083211e-01f, 1.54425099e-01f, 9.72961858e-02f, 6.15495816e-02f, 6.02501333e-02f, 2.15576440e-01f, 1.81551635e-01f, -3.49753797e-02f, 1.61026090e-01f,
  4.21242043e-02f, 7.21685141e-02f, 6.49912730e-02f, 1.69746488e-01f, 3.73642445e-02f, 1.55156896e-01f, 1.08911082e-01f, 2.51018330e-02f, 1.40418246e-01f, 1.10790536e-01f,
  -1.51883304e-01f, 1.47220492e-01f, -1.14151061e-01f, -1.78199783e-01f, -6.41270354e-02f, -1.37006253e-01f, -1.38135642e-01f, -1.21882163e-01f, -1.07638929e-02f, -6.01974726e-02f,
  8.45100284e-02f, 1.21315621e-01f, 7.79062808e-02f, 1.77154511e-01f, 6.01259023e-02f, -1.60102695e-02f, 3.50021660e-01f, 6.99981069e-03f, -1.01675540e-01f, 1.60734236e-01f,
  2.87539884e-02f, -4.85773757e-02f, -4.44191284e-02f, -1.46319449e-01f, 1.08512275e-01f, 4.74593192e-02f, 4.41520922e-02f, -6.63160300e-03f, -1.34770185e-01f, -6.57710582e-02f,
  5.60445525e-02f, -1.18681096e-01f, 5.64840585e-02f, 2.62652282e-02f, -4.47184108e-02f, -7.67926648e-02f, -5.11763878e-02f, 1.89915091e-01f, 7.69031346e-02f, -4.27514017e-02f,
  -4.03260440e-02f, 5.94835766e-02f, -8.22020844e-02f, -6.21148273e-02f, 1.26340136e-01f, 1.42811254e-01f, 3.35477665e-02f, 6.84794337e-02f, -3.18538025e-02f, -4.59319837e-02f,
  1.49609759e-01f, 2.40011543e-01f, -3.79818045e-02f, 4.96067964e-02f, 4.42047007e-02f, 1.96057901e-01f, -4.10266034e-02f, 3.88687328e-02f, 1.63457781e-01f, 2.91605610e-02f,
  4.25210185e-02f, 1.06103204e-01f, 2.41535101e-02f, 8.09090137e-02f, 7.71508813e-02f, 9.23095047e-02f, -8.68852884e-02f, 1.00660682e-01f, 9.01519656e-02f, -9.04380754e-02f,
  -3.19745280e-02f, -1.36586800e-01f, 1.06376559e-01f, 1.86365306e-01f, 1.81575254e-01f, 6.23975955e-02f, 2.60648847e-01f, 3.61897126e-02f, -2.00559366e-02f, -1.56556621e-01f,
  2.04500407e-01f, 3.28345113e-02f, 2.59282961e-02f, 4.71567899e-01f, 1.04943834e-01f, -2.43469719e-02f, -9.68648270e-02f, -1.87971875e-01f, 2.52676964e-01f, 3.30369174e-01f,
  1.34833157e-01f, -6.84159547e-02f, -2.95994002e-02f, -6.81806058e-02f, 2.85608023e-01f, -1.26827314e-01f, 7.97061622e-02f, -2.39805683e-01f, -1.48923099e-01f, 9.93331969e-02f,
  -7.98655115e-03f, -2.12478206e-01f, -6.68926239e-02f, 4.01843898e-02f, -1.70388058e-01f, 2.22574305e-02f, -1.57841325e-01f, 9.53551941e-03f, -1.95250157e-02f, 1.44969672e-01f,
  -1.14333862e-02f, 8.76242816e-02f, -3.09060272e-02f, 4.81561460e-02f, 2.45065126e-03f, 3.27296048e-01f, 1.52579825e-02f, 4.38859537e-02f, 3.93691882e-02f, 1.45340398e-01f,
  -1.06289722e-01f, 3.36913280e-02f, 1.43637225e-01f, 7.68907219e-02f, 9.26401019e-02f, 1.49145693e-01f, 2.86541451e-02f, 5.14973029e-02f, 5.46075590e-02f, 2.64245749e-01f,
  -6.48573115e-02f, -3.32300439e-02f, 2.07632914e-01f, -1.78594306e-01f, -4.43707146e-02f, -1.25886872e-01f, -8.57729986e-02f, 1.93947613e-01f, 1.84444398e-01f, -2.42663901e-02f,
  3.05370957e-01f, 8.08795728e-03f, 1.03282437e-01f, -1.02288172e-01f, 2.74585694e-01f, -1.15374923e-01f, -5.35636384e-04f, 3.12025487e-01f, -9.45377499e-02f, -1.67671517e-02f,
  1.45077080e-01f, -2.19881698e-01f, 3.00147474e-01f, 2.65503734e-01f, 1.36712238e-01f, -9.31610987e-02f, -1.89429924e-01f, 4.55332994e-02f, 2.64354885e-01f, 4.54218835e-02f,
  -1.49497867e-01f, -1.37406677e-01f, -2.14434430e-01f, 1.20014459e-01f, 1.46549076e-01f, -9.52760056e-02f, 1.10291645e-01f, -1.54822573e-01f, -3.90545502e-02f, 7.15509430e-02f,
  -1.43878117e-01f, -3.73792427e-04f, 1.24022320e-01f, -1.16236895e-01f, -8.16698223e-02f, 1.18861564e-01f, 9.22935903e-02f, 9.09561366e-02f, 7.51613174e-03f, 3.00849557e-01f,
  1.12751372e-01f, -6.53976724e-02f, 3.23131904e-02f, -6.66143969e-02f, 5.48799336e-02f, -2.91335471e-02f, 1.36642784e-01f, 1.98634729e-01f, 8.99226293e-02f, 1.45093724e-01f,
  -5.57767898e-02f, 1.42401218e-01f, 1.27164215e-01f, -3.93763520e-02f, -1.14098556e-01f, -8.05738717e-02f, -2.21598037e-02f, -2.83612106e-02f, 2.07304150e-01f, 2.37757623e-01f,
  1.63935795e-02f, -9.49335024e-02f, 1.03976235e-01f, -6.76272511e-02f, 3.02343547e-01f, -1.19500868e-01f, -3.82728577e-02f, -4.21532132e-02f, -3.41304438e-03f, -1.92043185e-01f,
  1.61372535e-02f, 3.96858156e-03f, 1.62903115e-01f, -2.33137254e-02f, 2.24302962e-01f, -1.62221089e-01f, 1.85994893e-01f, 2.76906174e-02f, -1.78898588e-01f, -1.66225091e-01f,
  -9.15613398e-02f, 5.19040525e-02f, -6.23672195e-02f, -5.25487363e-02f, 1.14191044e-02f, -2.97489073e-02f, -7.85785541e-03f, 1.00958049e-01f, 1.80309564e-01f, 2.99882740e-01f,
  -2.27410961e-02f, -5.52440062e-02f, -4.11347821e-02f, 6.03125095e-02f, -1.30760511e-02f, -2.58672354e-03f, 2.06396490e-01f, 2.01733664e-01f, 1.30785733e-01f, 1.39823169e-01f,
  8.53204131e-02f, 1.51718378e-01f, 1.07540034e-01f, -4.33951877e-02f, -1.59110516e-01f, 1.93269104e-01f, 7.04194009e-02f, 9.43603218e-02f, 1.70574829e-01f, 2.70865649e-01f,
  -4.85225916e-02f, -1.03886284e-01f, 1.73059568e-01f, 2.63745151e-02f, 1.49036720e-01f, 5.63319400e-02f, -1.64115652e-01f, 1.28291231e-02f, -6.60828650e-02f, 1.47665530e-01f,
  -1.99910179e-01f, -1.52762746e-02f, -4.85773273e-02f, -1.48129269e-01f, -1.34778507e-02f, -1.26368850e-01f, 3.93041931e-02f, -6.25578761e-02f, -1.47641078e-01f, 2.89202869e-01f,
  -8.43124986e-02f, -9.07721892e-02f, 7.63669685e-02f, 1.93640083e-01f, -1.44671008e-01f, 3.31602693e-01f, -6.14673086e-02f, -1.57801494e-01f, -1.96631148e-01f, 2.95258641e-01f,
  -2.86229312e-01f, -1.28859997e-01f, 3.12871486e-01f, 4.96501625e-02f, -7.98183456e-02f, 7.67423958e-02f, 9.60552022e-02f, -7.86733255e-02f, -1.12511002e-01f, 1.52020186e-01f,
  1.28644764e-01f, -1.41354099e-01f, 2.58655809e-02f, 1.23204939e-01f, 1.62388161e-02f, -4.12108004e-02f, -3.24084796e-02f, 1.80329215e-02f, -1.51234318e-03f, 1.15099654e-01f,
  1.65886089e-01f, -2.45592650e-02f, 9.00866911e-02f, -7.30483904e-02f, 2.69171178e-01f, 1.04810514e-01f, 5.86228520e-02f, 1.07006177e-01f, -7.43100559e-03f, 1.41139729e-02f,
  2.63647288e-02f, 9.14906561e-02f, 1.93141818e-01f, -5.18928878e-02f, 4.83948588e-02f, 1.63759306e-01f, 1.84516348e-02f, 1.24574907e-01f, -5.49522974e-02f, 2.64494196e-02f,
  2.53641218e-01f, 2.39913408e-02f, 1.80340663e-03f, -6.04172498e-02f, 1.31008178e-01f, 1.68368239e-02f, 2.20932946e-01f, 3.14227045e-01f, -2.17544660e-01f, 1.03348605e-01f,
  -1.04965009e-01f, 1.86183937e-02f, 8.23154449e-02f, -2.26534009e-01f, 2.78567988e-02f, -7.14198053e-02f, -1.51594236e-01f, -7.30967000e-02f, 7.16043264e-02f, -2.05293342e-01f,
  -1.38995439e-01f, 1.68107912e-01f, 3.41046244e-01f, 2.00710654e-01f, 1.31607786e-01f, 1.42670363e-01f, 7.87354186e-02f, -8.44977647e-02f, -2.38534614e-01f, 3.68112564e-01f,
  -6.83062747e-02f, -8.12437385e-02f, -1.89725116e-01f, 1.74910262e-01f, 3.19978684e-01f, 1.19115345e-01f, 2.59914428e-01f, 3.10334325e-01f, 1.18507758e-01f, -2.37379119e-01f,
  -5.44346794e-02f, 3.53261024e-01f, 9.48394313e-02f, -2.01006979e-02f, 2.73059905e-01f, 1.85152173e-01f, 1.15839377e-01f, -9.63171273e-02f, 1.92426089e-02f, 1.51170492e-01f,
  3.78528796e-02f, -3.57910991e-02f, -6.24212325e-02f, 4.78971601e-02f, 1.64943144e-01f, 2.33937144e-01f, 4.19854261e-02f, 1.86198249e-01f, 5.62521555e-02f, 6.35043904e-02f,
  4.62064743e-02f, -7.45386630e-02f, -1.98386656e-03f, 3.72566432e-02f, -1.06162615e-01f, -2.22530942e-02f, 2.09537670e-01f, -5.18094469e-03f, -1.19261503e-01f, 3.99843836e-03f,
  -1.77457139e-01f, -1.93938717e-01f, -1.32076487e-01f, 8.35778117e-02f, -1.46339580e-01f, -5.85984811e-02f, -2.01527923e-01f, 1.83213487e-01f, 1.87225461e-01f, 1.09446205e-01f,
  -1.13782607e-01f, 1.45308673e-01f, -9.65161696e-02f, -7.03262240e-02f, -2.59344578e-01f, -6.21228963e-02f, -2.09356725e-01f, 5.32288775e-02f, -2.73669034e-01f, -6.46967366e-02f,
  3.20376575e-01f, 3.13204467e-01f, -1.26980871e-01f, -4.07693945e-02f, 1.89200398e-02f, 2.99025327e-01f, -2.59414852e-01f, 4.73494530e-01f, 3.35554212e-01f, -2.47003078e-01f,
  -2.71527857e-01f, -5.68606481e-02f, -9.99785438e-02f, -9.07697156e-02f, -2.21972819e-02f, 1.40390843e-01f, 1.41835406e-01f, -2.24344432e-02f, -1.38235778e-01f, 2.54046381e-01f,
  1.43063307e-01f, 2.30391502e-01f, 1.23344377e-01f, 6.27372488e-02f, 1.23362370e-01f, 9.25240144e-02f, 7.44230160e-03f, 1.88891128e-01f, -2.16352474e-02f, 4.26477753e-02f,
  2.10027531e-01f, 1.60019860e-01f, 2.79029030e-02f, 3.56410369e-02f, 3.87124941e-02f, 3.77445444e-02f, -1.86134013e-03f, -1.41125880e-02f, -6.60797432e-02f, -8.18379298e-02f,
  -6.16581962e-02f, 1.54432654e-01f, 4.01900634e-02f, 6.57277107e-02f, 3.22275460e-01f, 1.26364231e-01f, 1.65008426e-01f, 1.26468595e-02f, 1.95707276e-01f, -1.11162663e-01f,
  6.60932362e-02f, -5.79975434e-02f, -1.80941746e-01f, -1.43796682e-01f, -5.55866696e-02f, 1.16517209e-01f, -2.60444209e-02f, 4.05877113e-01f, 2.84457982e-01f, 5.20781940e-03f,
  -2.43584625e-02f, 2.27430642e-01f, -2.31754547e-03f, 9.16177034e-02f, 6.87121600e-02f, -1.23004420e-02f, 3.26667517e-01f, 2.17343256e-01f, 8.35328028e-02f, -7.94448406e-02f,
  2.65093088e-01f, -3.29635054e-01f, -2.65507903e-02f, 6.63957447e-02f, 2.07738161e-01f, 1.57391876e-02f, -4.98012714e-02f, 2.52570748e-01f, 1.73941717e-01f, 2.07352955e-02f,
  9.12696309e-03f, 6.27138652e-03f, 3.92779298e-02f, -2.05658719e-01f, -2.68670805e-02f, -4.34856117e-02f, 4.79721418e-03f, 2.43453458e-02f, -1.02537302e-02f, -1.14891306e-01f,
  -3.64657305e-02f, -2.45862789e-02f, 1.19195975e-01f, -5.02226315e-02f, -9.84243751e-02f, -9.20862854e-02f, -1.25815153e-01f, 4.16488871e-02f, -1.14855386e-01f, 1.77925173e-02f,
  7.81363100e-02f, 3.96519788e-02f, -1.05045356e-01f, -1.20863095e-01f, -6.01451397e-02f, -2.02558175e-01f, -6.50169104e-02f, 1.03486948e-01f, -2.05180123e-01f, -1.11014508e-02f,
  1.24538593e-01f, -2.44717505e-02f, -1.93117872e-01f, 1.30848691e-01f, -1.31752878e-01f, -1.31404400e-02f, 5.58512099e-02f, 1.68787971e-01f, 8.06878358e-02f, 3.68511528e-02f,
  2.66162694e-01f, -2.01433867e-01f, -1.08930163e-01f, -7.37636313e-02f, -5.28190359e-02f, 2.04071850e-02f, -9.25872177e-02f, -6.04743846e-02f, -1.07091472e-01f, 1.21363059e-01f,
  -5.60449529e-03f, -9.43356156e-02f, -8.52541551e-02f, 1.54039562e-01f, -7.00329095e-02f, 1.97875157e-01f, -1.53844997e-01f, 1.24302842e-01f, 1.06506431e-02f, 1.58151045e-01f,
  1.98082939e-01f, -1.05527252e-01f, -1.00656021e-02f, -8.61158147e-02f, 7.66551420e-02f, 2.18235865e-01f, 1.14072904e-01f, 1.93506151e-01f, 4.70285825e-02f, -6.68611452e-02f,
  9.02395621e-02f, 3.60055119e-02f, -1.72198266e-02f, 1.16535842e-01f, -4.49108519e-02f, 5.24658561e-02f, 3.51240262e-02f, 1.18089773e-01f, -1.62062736e-03f, 5.88586479e-02f,
  1.39785543e-01f, 1.01703309e-01f, -1.00418478e-02f, 2.77422071e-02f, 8.08855577e-04f, -1.79568008e-02f, -1.34126702e-02f, -2.20655929e-02f, 2.55107105e-01f, 1.37987688e-01f,
  9.02906656e-02f, -7.39206001e-02f, 7.35310391e-02f, -4.45697941e-02f, 5.57002751e-03f, 2.78755367e-01f, 1.02789976e-01f, -1.04548514e-01f, -7.47777894e-02f, -6.18326589e-02f,
  8.46071765e-02f, 1.13993749e-01f, -1.78278968e-01f, 1.60687473e-02f, 6.34082556e-02f, 8.95978659e-02f, 7.53540322e-02f, 1.69962898e-01f, 6.08465541e-03f, -1.71868637e-01f,
  4.86819297e-02f, 2.46657372e-01f, 1.85246140e-01f, 1.38389751e-01f, 9.95156169e-02f, -1.82339586e-02f, 2.52802819e-01f, 1.87550470e-01f, 1.22633986e-01f, 1.59395218e-01f,
  2.46008828e-01f, 9.63866059e-03f, -3.60749483e-01f, -2.83932626e-01f, 1.12667447e-02f, 1.78239182e-01f, 1.31121546e-01f, 1.08203053e-01f, 1.82486594e-01f, -1.13037258e-01f,
  -3.56495380e-02f, -4.75548878e-02f, -4.28840481e-02f, -6.97145537e-02f, 1.61282539e-01f, 2.96438504e-02f, -2.61260923e-02f, 1.21767677e-01f, 1.07037365e-01f, 5.13594970e-02f,
  -1.82168148e-02f, -1.00871764e-01f, 1.52136892e-01f, -1.23900890e-01f, -6.63119778e-02f, 7.09319040e-02f, -6.18931353e-02f, 3.12911384e-02f, 4.31780517e-02f, 6.62043095e-02f,
  8.93408805e-02f, -1.27153963e-01f, 5.63886277e-02f, -7.95535222e-02f, 1.53156966e-01f, 9.41405892e-02f, 4.01007444e-01f, 2.13721871e-01f, -4.59830128e-02f, -5.12406901e-02f,
  1.63433194e-01f, 8.58854968e-03f, 1.07515790e-01f, -1.00747354e-01f, 1.08769469e-01f, 1.21140905e-01f, -2.05336556e-01f, -2.86050066e-02f, 6.96249655e-04f, -9.26085282e-03f,
  -6.63208291e-02f, 1.11665830e-01f, 1.75305188e-01f, -4.72847372e-02f, 7.38727953e-03f, 6.19199760e-02f, -3.27010080e-02f, 2.80834385e-04f, 6.94742203e-02f, 1.89312994e-01f,
  4.01914269e-02f, 7.53759146e-02f, -5.07092662e-02f, -5.28509989e-02f, 7.84456879e-02f, 1.83378071e-01f, 1.07109360e-01f, 3.44798744e-01f, 8.72763023e-02f, -1.11431926e-01f,
  2.06712767e-01f, 1.44835144e-01f, 2.34215960e-01f, 3.56034525e-02f, -6.38948902e-02f, 3.95699926e-02f, -5.07133305e-02f, -3.63073200e-02f, -7.71808028e-02f, 1.78557783e-02f,
  3.12275570e-02f, -4.73449305e-02f, 1.85642205e-02f, 3.44869196e-02f, 5.99551164e-02f, 7.25561604e-02f, -1.00867987e-01f, 6.74099550e-02f, 2.46167574e-02f, 4.99895513e-02f,
  3.80030926e-03f, -8.27896819e-02f, -4.42420654e-02f, -1.06702998e-01f, -5.18773682e-02f, 1.24133684e-01f, 1.59156844e-01f, 8.98516700e-02f, -5.10419719e-02f, -1.00609303e-01f,
  -1.86434254e-01f, -3.25262934e-01f, 1.09747425e-02f, 1.13537461e-01f, 4.39027213e-02f, -1.69601366e-01f, 2.83330921e-02f, 1.89226389e-01f, 2.07142457e-01f, 6.17626570e-02f,
  3.06171319e-03f, -8.62177685e-02f, -8.33021030e-02f, 6.69802129e-02f, -2.46826373e-02f, 8.45435634e-02f, -7.85637349e-02f, -1.22650608e-01f, -5.02176844e-02f, 1.29368946e-01f,
  2.03294426e-01f, 3.19125623e-01f, 2.06013650e-01f, -1.51499808e-01f, 2.68309623e-01f, 2.75816292e-01f, -4.62783948e-02f, 2.35673130e-01f, -1.04823999e-01f, -1.38165113e-02f,
  -2.66646177e-01f, -1.26831010e-01f, -8.22313316e-03f, 6.33943081e-02f, 1.45851895e-01f, -1.08228825e-01f, -4.45708670e-02f, -2.97730472e-02f, -1.03595190e-01f, -2.53422379e-01f,
  -5.71435466e-02f, 6.59263087e-03f, -5.12999706e-02f, 5.52545823e-02f, -6.61771446e-02f, -2.25304544e-01f, -2.44444553e-02f, -1.01930387e-01f, 1.00372858e-01f, -1.19266093e-01f,
  -1.54025435e-01f, -1.63772762e-01f, -2.26341337e-02f, 2.70321742e-02f, -1.30400747e-01f, -1.33568898e-01f, -9.88473296e-02f, -9.95687302e-03f, -1.67362854e-01f, -1.63944006e-01f,
  -4.14064191e-02f, -7.94909447e-02f, -5.56050576e-02f, 1.16883762e-01f, -2.18092203e-01f, 1.59385577e-02f, 2.13821098e-01f, 1.98046863e-02f, -1.63095444e-01f, 6.21420145e-02f,
  -1.91505268e-01f, -9.86765474e-02f, 3.78627181e-02f, 8.99056643e-02f, 4.26096981e-03f, 1.46484524e-01f, 3.66282821e-01f, -4.89258580e-02f, -6.17068708e-02f, -5.34513965e-03f,
  -1.05243802e-01f, 1.99635312e-01f, -1.09481171e-01f, -2.81096175e-02f, -6.80068359e-02f, 9.20463447e-03f, 1.25678048e-01f, -6.98508099e-02f, 2.58327574e-02f, 7.36090913e-02f,
  1.54680982e-02f, -9.42746997e-02f, -1.70866385e-01f, 3.91594730e-02f, -4.82743345e-02f, -1.12951644e-01f, 2.64955252e-01f, -1.47446021e-02f, -1.72201879e-02f, -5.37116565e-02f,
  6.52546436e-02f, 3.23869795e-01f, -2.94396840e-02f, 1.10209668e-02f, -2.02017725e-02f, -1.33848920e-01f, 7.20584840e-02f, -4.55597974e-02f, 2.33445223e-02f, 1.61356032e-01f,
  2.13327110e-01f, -2.54033804e-02f, 8.07203576e-02f, -4.65674400e-02f, -6.43748790e-03f, -7.99731761e-02f, 9.15377140e-02f, 1.11986421e-01f, -3.40338498e-02f, 3.00061665e-02f,
  1.10734396e-01f, -7.91111682e-03f, 1.60138085e-01f, -5.82462549e-02f, 2.00708941e-01f, -1.18687190e-01f, 1.98828787e-01f, -1.94627214e-02f, 6.85908794e-02f, -2.02190578e-02f,
  -1.02435425e-01f, 6.12650849e-02f, 9.00993198e-02f, -9.17150974e-02f, 2.53455132e-01f, 3.58765572e-02f, 2.68115461e-01f, 2.47496530e-01f, -1.45895109e-01f, -1.25092626e-01f,
  1.59281358e-01f, 3.30531970e-02f, -5.26768528e-02f, 1.72662716e-02f, 1.18521251e-01f, -2.12525025e-01f, 1.38974577e-01f, 2.39412472e-01f, -3.72788422e-02f, 3.24358463e-01f,
  4.88871969e-02f, 8.10712576e-03f, 1.56778336e-01f, 3.54138404e-01f, 6.28191326e-03f, 2.85047948e-01f, -1.32439271e-01f, 2.06317067e-01f, -7.76292384e-03f, 1.40033796e-01f,
  1.91118374e-01f, -7.46593326e-02f, 2.97718734e-01f, -2.65770219e-02f, 1.15730852e-01f, 8.94872621e-02f, 2.75451839e-02f, 1.27919510e-01f, 2.01919526e-01f, 1.74303621e-01f,
  8.59197974e-02f, 1.27717778e-01f, 1.78597212e-01f, -3.37795052e-03f, -6.61326200e-02f, 1.77103892e-01f, 2.77163405e-02f, 8.33904818e-02f, 1.42150834e-01f, 1.51285052e-01f,
  1.07494488e-01f, 7.83255547e-02f, 9.20057148e-02f, 4.13094722e-02f, 2.38188908e-01f, 1.62696540e-01f, -1.91553786e-01f, 3.55024673e-02f, -2.34408736e-01f, -1.29182577e-01f,
  -9.38190967e-02f, 2.60789730e-02f, 4.25843224e-02f, -2.49840505e-03f, 1.03923753e-01f, -2.15345114e-01f, 1.27203673e-01f, 1.32040188e-01f, 5.40609621e-02f, 1.46278918e-01f,
  -4.49380837e-02f, -1.78062901e-01f, 2.16947511e-01f, 1.18802734e-01f, -5.34162261e-02f, 4.06535536e-01f, 1.05220161e-01f, -2.16023177e-01f, -4.21719886e-02f, 1.96178570e-01f,
  -4.68148664e-02f, 1.07601725e-01f, 1.43434301e-01f, -4.34390567e-02f, -1.64479371e-02f, 1.78596795e-01f, -8.74465215e-04f, -1.73232302e-01f, -7.43606761e-02f, -1.32108420e-01f,
  -1.22937158e-01f, 1.11641824e-01f, 2.64288664e-01f, 1.52740330e-01f, 6.66818917e-02f, -3.14794555e-02f, -1.66946426e-01f, -1.30295819e-02f, -1.79143056e-01f, 2.46453837e-01f,
  2.87669543e-02f, -5.42178331e-03f, -4.24715970e-03f, 8.83635506e-02f, 4.97896448e-02f, 5.15322313e-02f, -4.79950905e-02f, 1.24782436e-01f, 7.49596208e-02f, -6.25590384e-02f,
  -2.88447924e-03f, 7.69235566e-03f, 3.40209925e-03f, -1.03292139e-02f, 1.53579801e-01f, 8.87853280e-02f, 1.05294421e-01f, 2.19947413e-01f, -9.22880694e-02f, -1.02745751e-02f,
  1.19973883e-01f, 1.07500002e-01f, -8.33470970e-02f, 2.57633794e-02f, 9.36302170e-02f, -1.96094830e-02f, 1.15220815e-01f, 1.95881203e-01f, -9.33662616e-03f, 1.16894059e-01f,
  -3.51760089e-02f, 2.86170691e-02f, 2.19094619e-01f, -1.24191962e-01f, -1.50513783e-01f, -2.34463811e-01f, -5.92467487e-02f, -9.82161984e-02f, 1.28499940e-01f, 9.47745368e-02f,
  2.68675573e-02f, 5.71976714e-02f, 2.07898661e-01f, 1.70012936e-01f, 2.87728757e-01f, 1.63561359e-01f, -8.55630729e-03f, -2.03140348e-01f, -1.49857774e-01f, 1.87634572e-01f,
  1.03782881e-02f, -6.91760927e-02f, -5.35760932e-02f, -1.46290153e-01f, -6.92965761e-02f, 9.67803299e-02f, 3.23924899e-01f, 1.57941412e-02f, 6.54064193e-02f, -1.09986000e-01f,
  -1.26873225e-01f, 1.80507317e-01f, -1.36153996e-01f, 1.05593260e-02f, -4.75445017e-02f, -2.92035807e-02f, -2.21828558e-02f, 1.56923711e-01f, 1.07593425e-01f, 2.49944273e-02f,
  8.80098902e-03f, -6.28351271e-02f, 1.10787451e-01f, -9.82894376e-02f, 9.36798304e-02f, -1.55264422e-01f, 7.25121563e-03f, 1.30052656e-01f, 4.95335832e-02f, -7.00053945e-02f,
  5.21912687e-02f, 1.41865194e-01f, 1.18767127e-01f, 6.38620509e-03f, 1.62057310e-01f, -1.53314069e-01f, -1.21098667e-01f, 3.71275358e-02f, -1.29442528e-01f, 1.13011897e-01f,
  8.06497782e-02f, 1.90867081e-01f, 1.65138736e-01f, -2.75027841e-01f, -1.16190106e-01f, -2.14083660e-02f, 2.15539671e-02f, -1.17906801e-01f, -2.31351838e-01f, -2.01711118e-01f,
  -1.25189498e-01f, 5.80548309e-02f, -1.67401768e-02f, 1.29520521e-01f, 2.40076974e-01f, -1.67591691e-01f, -1.21174632e-02f, 1.67306542e-01f, -1.23689085e-01f, -1.66943520e-01f,
  -9.79857594e-02f, -1.83495045e-01f, -2.84593012e-02f, 1.10673688e-01f, -2.72512645e-01f, 4.23243269e-02f, 7.02364147e-02f, -1.80575877e-01f, 5.10866195e-02f, 3.04566883e-02f,
  3.57979387e-01f, 8.06735009e-02f, -6.37445822e-02f, 1.59353003e-01f, -1.20301312e-02f, -1.00334063e-01f, 1.68495458e-02f, 1.86247364e-01f, 2.43754946e-02f, 2.51744948e-02f,
  1.32534713e-01f, 1.37100935e-01f, 1.64582118e-01f, -1.91333033e-02f, 1.12101078e-01f, 2.93176979e-01f, 1.54104978e-01f, -1.21298097e-02f, 7.56157488e-02f, -7.10809231e-02f,
  1.02686666e-01f, 2.25778520e-02f, 8.45914781e-02f, 1.15573235e-01f, 1.19377486e-01f, 1.04206659e-01f, 1.55923218e-01f, 6.35484532e-02f, 8.92516598e-03f, 6.00523315e-02f,
  -1.89231038e-01f, -9.03717950e-02f, -2.24297401e-02f, -1.24002829e-01f, -8.38557724e-03f, -2.64591002e-03f, 1.21434063e-01f, -1.19170658e-01f, 1.64676279e-01f, 8.03930238e-02f,
  2.02485144e-01f, -6.34303465e-02f, 6.59498479e-03f, -1.89850722e-02f, 2.80845910e-01f, -7.92967677e-02f, 6.42793328e-02f, 2.27506116e-01f, 2.19410002e-01f, -2.11939607e-02f,
  1.29081756e-01f, -2.32224643e-01f, 1.41955778e-01f, 2.26987693e-02f, -7.97886029e-02f, -5.61282411e-03f, 1.36087328e-01f, -2.78587025e-02f, 1.07581606e-02f, -4.43504825e-02f,
  2.98840106e-01f, -2.33216912e-01f, -2.40297303e-01f, 2.09808946e-01f, 8.78573284e-02f, 2.31604993e-01f, 7.83387572e-02f, 1.33794501e-01f, 1.33139804e-01f, -6.65790141e-02f,
  -1.32366151e-01f, 1.06739216e-01f, 7.62564018e-02f, 2.30408475e-01f, 1.54952645e-01f, 1.66627407e-01f, 5.18342294e-02f, 1.83105752e-01f, 1.86801120e-03f, -7.72967711e-02f,
  -1.45359144e-01f, 1.81364357e-01f, 1.00996703e-01f, 1.76459491e-01f, 7.69451261e-02f, 1.39224321e-01f, 5.79373799e-02f, 2.78160498e-02f, 9.80658680e-02f, 1.25596235e-02f,
  -7.29464740e-02f, -1.87492166e-02f, -3.12919579e-02f, -1.28515586e-01f, 1.12256952e-01f, 2.42909715e-01f, -9.29761529e-02f, 6.78443834e-02f, 2.04069465e-01f, 9.84054133e-02f,
  2.58278437e-02f, -2.07402296e-02f, 9.13120527e-03f, -8.46510530e-02f, -1.40104949e-01f, 4.59264219e-03f, -1.80552348e-01f, -1.00390032e-01f, -2.75960684e-01f, 1.60541788e-01f,
  -1.21613212e-01f, 1.91135958e-01f, 1.18966952e-01f, 8.55723619e-02f, -1.44273892e-01f, 2.96114922e-01f, -2.11076900e-01f, -4.95633818e-02f, 2.38518566e-01f, 5.73183373e-02f,
  1.68778270e-01f, 1.35225013e-01f, 1.18345641e-01f, 1.78333875e-02f, -2.88325995e-02f, -4.92972359e-02f, 3.14784229e-01f, -8.92277434e-02f, -2.49161590e-02f, -1.30577743e-01f,
  -1.05800636e-01f, 1.69890553e-01f, -4.00453061e-02f, 1.43768609e-01f, 1.65634632e-01f, 5.02983332e-02f, 7.11110756e-02f, 1.60682231e-01f, 1.79706052e-01f, 2.38578513e-01f,
  1.25518113e-01f, 7.15443417e-02f, 5.19362278e-02f, -7.77821764e-02f, 2.12687142e-02f, 2.43180264e-02f, 1.18576013e-01f, 6.29994571e-02f, 2.14637101e-01f, 1.38994351e-01f,
  1.95214562e-02f, 5.27519220e-03f, 1.84222430e-01f, 6.96609244e-02f, 1.56194508e-01f, 4.85017300e-02f, -1.06862321e-01f, 7.15953931e-02f, -1.26205251e-01f, 4.39371215e-03f,
  -9.79124755e-02f, 1.08317800e-01f, 2.64246669e-02f, 8.73703733e-02f, 1.24873564e-01f, -1.29266739e-01f, -1.19680233e-01f, 2.93103829e-02f, -1.11353859e-01f, -1.08245358e-01f,
  -2.14804322e-01f, -2.17175305e-01f, 3.62977060e-03f, 3.57576944e-02f, 1.53611422e-01f, 1.47988737e-01f, 2.20211267e-01f, 1.01755969e-02f, -2.71883770e-03f, 3.86938572e-01f,
  -1.22696059e-02f, 1.21349236e-02f, 5.75545356e-02f, -7.53810555e-02f, 8.31961185e-02f, 1.72357529e-01f, 1.61627699e-02f, -9.95923355e-02f, 4.88576144e-02f, -1.80221781e-01f,
  9.82061848e-02f, -3.80054004e-02f, 1.66975558e-01f, 6.06825994e-03f, 5.39396890e-02f, 6.85057864e-02f, -1.58925742e-01f, -1.73889585e-02f, -1.13928720e-01f, 1.30924419e-01f,
  4.61541563e-02f, -1.13396809e-01f, 7.55046457e-02f, 8.85420516e-02f, 1.22301906e-01f, 3.62574086e-02f, 1.37613267e-01f, 1.15571223e-01f, 1.19011104e-01f, -3.87017578e-02f,
  1.00804627e-01f, -1.33562991e-02f, -4.23430018e-02f, -3.94873917e-02f, 6.20871000e-02f, 2.31529742e-01f, 4.70485538e-02f, 5.06863892e-02f, 2.31139362e-01f, 5.00573926e-02f,
  -1.24204807e-01f, -1.37931230e-02f, -1.60246134e-01f, -2.79102117e-01f, -4.60348949e-02f, -1.93486568e-02f, -1.36259913e-01f, -7.93550014e-02f, 1.90117881e-01f, -2.17088357e-01f,
  -5.52095361e-02f, 1.70075953e-01f, 3.22071053e-02f, -7.29998872e-02f, 1.72392670e-02f, 1.39458910e-01f, 2.12707192e-01f, -1.12661375e-02f, 7.78773129e-02f, -5.76812699e-02f,
  1.90924212e-01f, -5.79482764e-02f, -8.69054124e-02f, -2.42427945e-01f, 4.56458330e-02f, -4.67930697e-02f, -3.12980145e-01f, -7.64137926e-03f, 1.23724781e-01f, -2.20603451e-01f,
  -1.19986512e-01f, -1.47965429e-02f, 2.42086351e-01f, -6.55623972e-02f, -1.53784543e-01f, 9.09648184e-03f, -5.14892451e-02f, 1.77640259e-01f, 8.98016524e-03f, 1.92687497e-01f,
  3.56362760e-02f, -9.64086875e-02f, -4.53154445e-02f, 2.48113677e-01f, 6.86426312e-02f, 2.43832961e-01f, 1.16843186e-01f, 2.05047801e-01f, 6.15956895e-02f, 5.18724434e-02f,
  9.01628807e-02f, 1.32428169e-01f, -1.27351133e-03f, 2.12215394e-01f, 1.22746481e-02f, 1.41245648e-01f, 2.41612289e-02f, 1.58927977e-01f, 1.53568432e-01f, 1.48493694e-02f,
  1.44636020e-01f, 3.36630121e-02f, 1.27866149e-01f, -6.32676035e-02f, -1.21435337e-01f, 1.69844449e-01f, -1.87312718e-02f, 9.48176384e-02f, -8.26261491e-02f, -6.59439191e-02f,
  -1.26787141e-01f, -2.09445894e-01f, 1.06977850e-01f, 6.29033372e-02f, 1.16440088e-01f, -1.15440749e-02f, -7.37692639e-02f, 4.77270633e-02f, -7.16863126e-02f, -1.15226462e-01f,
  3.23768139e-01f, 2.19381213e-01f, -4.90129739e-03f, 4.14661586e-01f, 3.43201339e-01f, -1.47269303e-02f, -1.16144866e-01f, -2.01610938e-01f, 4.83997129e-02f, 1.67655617e-01f,
  1.75132722e-01f, -9.02392790e-02f, 2.22236201e-01f, -1.99888438e-01f, 2.41935894e-01f, -9.22420174e-02f, 2.86479652e-01f, -3.71853441e-01f, -5.25714755e-02f, -6.01478219e-02f,
  -2.31824398e-01f, -2.59287685e-01f, -5.88121116e-02f, 3.18974912e-01f, 3.89688089e-02f, -8.22870731e-02f, -3.84704247e-02f, -9.27067101e-02f, -2.01665889e-02f, -1.49821952e-01f,
  3.39507759e-02f, 2.14157775e-02f, -1.75185241e-02f, 9.07814279e-02f, 2.03620613e-01f, -1.68838769e-01f, 1.75203159e-02f, 2.74938866e-02f, 7.11039528e-02f, -1.03371046e-01f,
  8.42038393e-02f, -1.19469659e-02f, -7.65305832e-02f, -3.97781767e-02f, -1.22837916e-01f, -2.55574770e-02f, 2.60947615e-01f, 1.58994675e-01f, -1.50544718e-01f, -7.61251077e-02f,
  -1.97651133e-01f, -2.31121480e-01f, -1.01158448e-01f, 1.16649717e-01f, -1.80562155e-03f, -3.85701992e-02f, 1.12522602e-01f, -3.10627878e-01f, -3.27198394e-02f, 1.60269290e-01f,
  6.69309348e-02f, 1.64535388e-01f, 1.03464447e-01f, 1.24705583e-01f, 1.11090980e-01f, 5.85915707e-02f, 9.10944864e-02f, 4.26210389e-02f, -4.52517457e-02f, -1.85908481e-01f,
  -1.42405018e-01f, 2.30580524e-01f, -1.70896783e-01f, -1.51988924e-01f, -5.59971295e-02f, 3.77322733e-02f, 1.02901016e-03f, 7.67226666e-02f, -1.43700629e-01f, 4.43788543e-02f,
  -4.52338085e-02f, 6.16842806e-02f, -1.81390822e-01f, 1.07839011e-01f, 2.09927231e-01f, 3.77891421e-01f, 1.87598616e-01f, -2.02989697e-01f, 5.82984909e-02f, -1.23931982e-01f,
  -8.75148475e-02f, 3.36758077e-01f, -3.80856134e-02f, 1.93711370e-01f, 2.34754965e-01f, 1.83525443e-01f, 1.37745813e-02f, 2.17701495e-01f, 1.75864026e-01f, -7.45221302e-02f,
  7.81111941e-02f, 2.11878642e-01f, 5.10110706e-02f, 1.22101918e-01f, 1.60162970e-01f, 1.10616535e-01f, 4.59993184e-02f, 1.03043482e-01f, 5.93294129e-02f, -2.70753540e-03f,
  1.19841829e-01f, 1.65126696e-02f, -1.42000705e-01f, -1.06540993e-01f, -3.95322889e-02f, 7.72512183e-02f, -1.61899880e-01f, -5.30304797e-02f, 1.06482692e-01f, -1.14850432e-01f,
  6.66543562e-03f, -2.10033998e-01f, 2.07865730e-01f, -1.43788710e-01f, -1.49889380e-01f, 1.48338675e-01f, -4.04849388e-02f, 1.15040354e-01f, -1.32599026e-01f, 3.24392803e-02f,
  -1.53806269e-01f, 1.76756278e-01f, 2.42815882e-01f, 1.06866993e-01f, -8.24548304e-02f, -2.12304264e-01f, -1.96330041e-01f, -9.19006094e-02f, -3.94648686e-02f, 2.02700868e-01f,
  3.55419368e-01f, -8.38778615e-02f, 2.55168155e-02f, 1.72926515e-01f, 2.13442072e-01f, 1.52527429e-02f, 5.92725277e-02f, -1.10267792e-02f, -1.34623423e-01f, 1.22492962e-01f,
  -2.43667856e-01f, 3.86113286e-01f, 7.72043839e-02f, -1.16909154e-01f, 9.27802771e-02f, 8.31305683e-02f, 2.46720039e-03f, -2.15284243e-01f, -7.44016841e-02f, -4.04260755e-02f,
  6.24953769e-02f, 8.37373957e-02f, 1.12222075e-01f, 2.65980121e-02f, 1.04078345e-01f, -8.75225216e-02f, 1.00970306e-01f, -1.17014997e-01f, 2.61058076e-03f, -1.20013393e-01f,
  -8.82477984e-02f, 1.38999477e-01f, 2.56207166e-03f, 1.58312973e-02f, -3.51794064e-02f, 9.67503786e-02f, -4.29624915e-02f, -1.03047274e-01f, -1.30447611e-01f, -1.85381219e-01f,
  -7.21848831e-02f, 7.10699037e-02f, 2.37586838e-03f, 8.10598731e-02f, 2.74130963e-02f, -1.22159392e-01f, -2.65907981e-02f, 5.56794703e-02f, 3.19979452e-02f, -6.36862824e-03f,
  1.71008483e-01f, 1.42135099e-01f, 4.74396944e-02f, -8.26321244e-02f, 1.87598974e-01f, -1.25680909e-01f, -1.11440085e-01f, -2.45491117e-02f, 7.92531222e-02f, -5.09193540e-02f,
  6.63452130e-03f, -8.34119692e-02f, -1.42792746e-01f, 5.53913116e-02f, -1.04503594e-01f, 2.19938308e-02f, -1.17666878e-01f, 9.24062729e-02f, -6.18102103e-02f, 1.93847448e-01f,
  -1.82753772e-01f, 1.89798027e-01f, 1.16920233e-01f, 3.44148874e-01f, 1.95351824e-01f, -1.84617192e-01f, 4.80422154e-02f, 4.51699495e-02f, -3.73219438e-02f, 1.63318485e-01f,
  1.13185011e-01f, 4.82460018e-03f, 1.54330090e-01f, -7.06557839e-05f, 2.28146203e-02f, 6.36172369e-02f, 2.20183536e-01f, -1.04733966e-01f, -4.72564772e-02f, 1.33370340e-01f,
  8.82302076e-02f, 6.33722320e-02f, 1.42112046e-01f, 6.46947846e-02f, -1.14237033e-01f, 8.07548165e-02f, 3.66113968e-02f, -1.31930426e-01f, 2.29907706e-01f, 1.61495030e-01f,
  -1.49339765e-01f, 4.65911329e-02f, -1.44073084e-01f, -2.44228050e-01f, -1.83289528e-01f, -6.59799725e-02f, -1.13944650e-01f, -1.84160307e-01f, -6.13301210e-02f, -2.58605957e-01f,
  4.74366583e-02f, 1.86118439e-01f, -9.61289853e-02f, 2.54887491e-01f, 1.52445614e-01f, 2.70391762e-01f, 1.42636970e-01f, 5.92065752e-02f, -8.74450356e-02f, -1.00001007e-01f,
  -1.94585338e-01f, -5.83213903e-02f, -1.00360662e-01f, 3.50781754e-02f, -1.51834890e-01f, -1.66599393e-01f, -9.74069536e-03f, 8.99415314e-02f, -1.71632953e-02f, -4.61101495e-02f,
  -1.11613959e-01f, -1.93862114e-02f, -9.71294641e-02f, 1.71048209e-01f, 1.85399950e-02f, 1.74455252e-02f, 6.49958244e-03f, 4.25367296e-01f, 1.76455423e-01f, -1.68364719e-01f,
  6.99717104e-02f, 3.24428687e-03f, 8.38329196e-02f, 1.09101042e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.04889318e-01f, 8.46488178e-02f, 1.19870700e-01f, 3.93088385e-02f, 8.10302943e-02f, 1.77718833e-01f, 8.91241133e-02f, -1.69412103e-02f, 7.44772106e-02f, 8.11479799e-03f,
  1.50570376e-02f, 9.77500305e-02f, 6.93961978e-02f, 1.52314231e-01f, 9.74668786e-02f, 7.52453953e-02f, -4.99516651e-02f, 4.78669629e-02f, 1.94409478e-03f, 5.49035221e-02f,
  4.14704010e-02f, 5.53598963e-02f, 9.49544236e-02f, 8.94652307e-02f, 5.28412946e-02f, 7.44599029e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  5.01666367e-02f, 1.67947114e-02f, -7.93669932e-03f, 7.52619728e-02f, 6.93496466e-02f, 8.22502747e-02f, -1.06819622e-01f, 5.25573045e-02f, 9.70159322e-02f, -9.46686510e-03f,
  -3.85165066e-02f, 9.57209393e-02f, 4.06581350e-02f, 4.89379391e-02f, -3.18534486e-02f, -3.60880382e-02f, -7.68972337e-02f, 4.02533635e-02f, -1.41107813e-02f, 1.86198980e-01f,
  -1.03637658e-01f, -5.53900748e-02f, -1.76878318e-01f, 1.18386112e-02f, -1.35501325e-01f, 6.09225035e-02f, 9.01072845e-02f, 1.42974898e-01f, 1.39914900e-01f, 6.97501525e-02f,
  8.26963410e-02f, -6.94358870e-02f, -6.97610602e-02f, 1.14479370e-01f, 1.48945674e-02f, 1.11730017e-01f, -1.91897806e-02f, 4.10861857e-02f, 6.65686950e-02f, 9.16522443e-02f,
  9.69813466e-02f, -1.21153206e-01f, 6.57900842e-03f, -8.51660371e-02f, 2.40012586e-01f, -2.87395413e-03f, -8.55739191e-02f, 1.05578855e-01f, -6.70339614e-02f, 1.72350734e-01f,
  -9.61697102e-02f, 1.41696870e-01f, -4.88654822e-02f, -2.88941916e-02f, -1.60676315e-01f, -9.41443220e-02f, -2.67166551e-02f, -1.09485202e-01f, -1.27374856e-02f, 4.96342480e-02f,
  1.70809738e-02f, 1.04130656e-01f, -1.33502319e-01f, 1.05609111e-01f, 5.39674573e-02f, 5.96700646e-02f, -1.51700014e-02f, 4.16098051e-02f, 9.78383422e-03f, -4.46380004e-02f,
  -4.83105779e-02f, 4.42118421e-02f, 9.04522836e-03f, -3.92954536e-02f, 8.18614587e-02f, -1.12588927e-02f, 1.50907815e-01f, -3.12266573e-02f, -5.29139629e-03f, 1.06451781e-02f,
  -4.77884896e-02f, -3.90857197e-02f, 5.78655712e-02f, 1.72544464e-01f, 6.63644299e-02f, -4.96414118e-02f, -8.41387063e-02f, 1.23058274e-01f, -5.06733842e-02f, -9.54620764e-02f,
  3.49767022e-02f, 2.57520884e-01f, 2.05960229e-01f, 1.48843750e-01f, -1.81071788e-01f, -5.68599366e-02f, -8.49859640e-02f, 2.35039547e-01f, 7.81025887e-02f, -6.65129647e-02f,
  2.59607174e-02f, 1.27790749e-01f, -7.72424862e-02f, -1.29327968e-01f, 2.01448575e-02f, -9.92272943e-02f, 8.12059939e-02f, 9.94582474e-03f, 1.59223035e-01f, -1.04425503e-02f,
  9.89699177e-03f, 1.91823065e-01f, 4.48137196e-03f, 1.45887181e-01f, 1.11610152e-01f, 1.13885954e-01f, -9.78294015e-02f, -6.76524639e-02f, 1.06394747e-02f, -9.04912278e-02f,
  1.30104810e-01f, -3.06055583e-02f, -4.04814668e-02f, 3.28388140e-02f, -2.29759123e-02f, 1.50849164e-01f, -8.01335424e-02f, 5.91344349e-02f, 1.12251617e-01f, -1.54958933e-03f,
  1.29644543e-01f, 5.61362365e-03f, 1.47865191e-01f, 1.16347030e-01f, 2.61298288e-03f, 1.43512145e-01f, 1.43510878e-01f, 1.00357592e-01f, 8.10855031e-02f, 3.81329842e-02f,
  6.93247318e-02f, 4.82029468e-02f, 1.60375312e-01f, 7.92813152e-02f, 1.48335502e-01f, 3.85627784e-02f, 2.06056476e-01f, -1.15763873e-01f, -2.98148170e-02f, -1.23440474e-01f,
  2.84723304e-02f, -4.24095355e-02f, 1.63504347e-01f, 1.61676072e-02f, -9.93421301e-02f, -1.10142246e-01f, 5.07856049e-02f, -1.08179892e-03f, -1.31258711e-01f, 1.82764485e-01f,
  -3.47273350e-02f, -7.75735602e-02f, 2.00424735e-02f, -6.90434724e-02f, 3.72862145e-02f, -1.93872914e-01f, 4.23263106e-03f, 1.70099601e-01f, 1.97264478e-01f, 1.73202872e-01f,
  8.05981830e-03f, 2.50010639e-01f, -1.40604094e-01f, 1.69218659e-01f, 1.18749380e-01f, 8.85787681e-02f, 1.07488431e-01f, -1.31392945e-02f, 1.55251861e-01f, 8.69561434e-02f,
  1.55184269e-01f, 2.83695191e-01f, 1.60085723e-01f, 1.33022457e-01f, 3.82692665e-02f, 1.51449338e-01f, 1.60414964e-01f, -4.25153645e-03f, 1.24816000e-01f, -9.65536982e-02f,
  1.17835492e-01f, -5.48593700e-02f, 1.57993417e-02f, 1.57228127e-01f, -8.27560481e-03f, 3.29035916e-03f, -4.11320180e-02f, 8.75239819e-02f, -6.99497163e-02f, -3.25105861e-02f,
  -5.61420545e-02f, 5.07886335e-02f, -8.11517015e-02f, 9.32958871e-02f, 5.17607890e-02f, -5.24479672e-02f, 8.02567452e-02f, -5.42533323e-02f, 3.78890894e-02f, 2.14190707e-02f,
  -4.74079028e-02f, -9.17522609e-02f, 9.08959880e-02f, 1.28875002e-01f, 3.04195546e-02f, 5.40371910e-02f, -2.10181713e-01f, 4.48795147e-02f, -1.87315680e-02f, 4.17493358e-02f,
  -5.33684995e-03f, 1.49414495e-01f, 3.44077617e-01f, -1.05150580e-01f, 8.56549516e-02f, 7.11568668e-02f, -1.46340936e-01f, 2.96404839e-01f, -1.43690497e-01f, 1.14892647e-01f,
  1.61750436e-01f, -6.82519749e-02f, -4.44446579e-02f, -2.31570434e-02f, 1.38609618e-01f, -2.29044899e-01f, -1.10414781e-01f, 3.51443887e-02f, -1.67986974e-01f, -2.51660179e-02f,
  -6.71187090e-03f, -6.74187019e-02f, -1.44553721e-01f, -2.73826662e-02f, 3.46971899e-02f, -1.57388538e-01f, -2.23220754e-02f, 8.08184147e-02f, -8.35596621e-02f, -5.18811606e-02f,
  1.07705399e-01f, 1.18190475e-01f, -3.38225663e-02f, 1.65614143e-01f, -1.21999299e-02f, 9.18461382e-02f, -6.68130443e-02f, -6.28134608e-02f, -8.29853341e-02f, -5.08172922e-02f,
  -1.54689401e-01f, -2.03750432e-01f, -9.20527503e-02f, -5.04508130e-02f, -2.54766285e-01f, -2.48971194e-01f, -7.52309933e-02f, -1.34207621e-01f, -1.18059263e-01f, 3.27725001e-02f,
  -1.71740085e-01f, -8.78441110e-02f, -1.60611436e-01f, -1.13829613e-01f, -1.65350810e-01f, -1.09308623e-01f, 1.73025936e-01f, 2.13927343e-01f, 6.47772625e-02f, 1.25150010e-01f,
  -2.05948368e-01f, -1.43583089e-01f, -7.25466013e-02f, 6.22446351e-02f, -1.29991576e-01f, 1.29578322e-01f, -1.55377761e-01f, -1.50947362e-01f, 2.05401376e-01f, -2.38740668e-02f,
  -3.80352139e-02f, 1.92822013e-02f, -1.30502418e-01f, -8.92272443e-02f, -1.59091413e-01f, -2.86264092e-01f, -1.61075532e-01f, -1.71561196e-01f, -4.46714200e-02f, -8.07118788e-02f,
  -8.18107352e-02f, -5.37000149e-02f, -4.48360182e-02f, -1.29303992e-01f, -1.23952501e-01f, 5.45123667e-02f, -2.62516439e-02f, -9.16408896e-02f, -4.85158749e-02f, -1.43260598e-01f,
  9.84408259e-02f, -1.44142583e-01f, 6.90635294e-02f, 5.05006388e-02f, -1.41438916e-01f, -1.51561037e-01f, 1.48948774e-01f, -5.44986641e-03f, -8.73389915e-02f, 8.80804379e-03f,
  -2.70473529e-02f, -6.88872188e-02f, -1.11913502e-01f, 1.85446851e-02f, -7.19842836e-02f, 4.33677882e-02f, 7.65999630e-02f, -4.50390652e-02f, -1.70450211e-02f, -1.23168282e-01f,
  7.49358833e-02f, -4.70045693e-02f, -1.66706312e-02f, -3.53614055e-02f, 2.40092967e-02f, 9.21544880e-02f, -4.46625017e-02f, -1.70927122e-02f, 6.52356148e-02f, 7.18190968e-02f,
  7.07635880e-02f, -2.79637277e-02f, -8.46878588e-02f, 7.82566816e-02f, -4.22382131e-02f, -1.07304431e-01f, 3.69368754e-02f, 3.24127413e-02f, 6.47978485e-02f, 1.18423939e-01f,
  1.82262242e-01f, -1.57767385e-02f, 4.36354056e-02f, 1.25925643e-02f, -1.32524803e-01f, 9.22031105e-02f, -3.61338705e-02f, -7.84169231e-03f, 1.04028516e-01f, 8.53705779e-02f,
  1.23089897e-02f, -1.33622631e-01f, -6.91112801e-02f, -7.00374022e-02f, -2.59394143e-02f, 1.39203280e-01f, -1.67425528e-01f, 1.01009756e-01f, -9.21333209e-02f, 9.94123742e-02f,
  -2.03398690e-01f, -1.25084400e-01f, 7.23342523e-02f, -8.64289142e-03f, -1.31312981e-01f, 4.16698009e-02f, 5.42899817e-02f, 8.26915354e-02f, 8.30467492e-02f, 1.51423261e-01f,
  -5.92516623e-02f, 8.67526531e-02f, -1.65777847e-01f, 2.87558232e-02f, 7.88776949e-03f, 3.10237668e-02f, 5.10242246e-02f, 6.21102285e-03f, 3.60082909e-02f, 1.04641408e-01f,
  4.23840098e-02f, 4.22292985e-02f, 7.03891963e-02f, 1.91812925e-02f, -1.54321715e-02f, 9.94935334e-02f, 1.45009205e-01f, -1.30034745e-01f, -7.11750938e-03f, -4.88586957e-03f,
  -5.87510914e-02f, -1.17385007e-01f, 1.04730017e-02f, 1.25073090e-01f, -1.42721415e-01f, -4.87038754e-02f, -2.35532653e-02f, 5.90312891e-02f, 3.63582037e-02f, 2.41479605e-01f,
  6.53005391e-02f, 1.16217665e-01f, 1.00634426e-01f, -2.34956041e-01f, -3.40200849e-02f, 1.42419100e-01f, -1.75211564e-01f, 9.58012119e-02f, 6.45812750e-02f, 7.08030611e-02f,
  4.19153720e-02f, -1.44859438e-03f, -1.76733341e-02f, 2.02537179e-01f, 2.64975607e-01f, 3.85035463e-02f, -5.36805892e-05f, -7.55885020e-02f, -2.21951492e-02f, 4.60674539e-02f,
  -1.08273931e-01f, 1.12961046e-01f, 1.51725128e-01f, 3.66639569e-02f, -1.17028117e-01f, 1.49747699e-01f, 7.61925802e-02f, 1.05629712e-02f, -1.10915333e-01f, -3.00083868e-02f,
  -1.28209785e-01f, -1.23198569e-01f, -8.99426863e-02f, 9.53682736e-02f, -2.52828691e-02f, 1.62569042e-02f, -1.78484097e-02f, -2.10519414e-02f, 3.10276244e-02f, -6.11323901e-02f,
  -5.89670390e-02f, -8.26446526e-03f, 5.92802977e-03f, 1.47309005e-02f, 6.61729351e-02f, 1.55525384e-02f, 2.97419261e-02f, 1.47931486e-01f, 1.31452419e-02f, -4.52496484e-02f,
  -3.54818888e-02f, 1.52681069e-02f, -4.22481969e-02f, 1.25402540e-01f, 8.57840702e-02f, -5.24974279e-02f, 7.30773956e-02f, -1.33865997e-01f, 2.10596155e-02f, -1.15021905e-02f,
  -1.73706040e-02f, -5.78947067e-02f, 1.74559161e-01f, -1.42608315e-03f, -3.27528827e-02f, -1.39261276e-01f, -1.16913937e-01f, -7.11540356e-02f, 2.08875671e-01f, 9.34496149e-02f,
  3.37391272e-02f, -1.64943129e-01f, -2.74111759e-02f, 1.49496868e-02f, 4.84138578e-02f, -4.44576629e-02f, 1.44711092e-01f, 6.21237755e-02f, -1.33029569e-03f, 1.20137148e-01f,
  -7.97758698e-02f, 2.02482015e-01f, -1.55811146e-01f, 3.99035215e-02f, -1.38213485e-01f, -1.14428654e-01f, 3.38062420e-02f, -1.37700096e-01f, -1.93202466e-01f, -6.55830055e-02f,
  -2.88167521e-02f, 1.05661958e-01f, 9.24814865e-02f, 9.64521095e-02f, -6.37433976e-02f, 9.39801056e-03f, 4.05938216e-02f, 3.96446064e-02f, -1.40895665e-01f, -6.65681288e-02f,
  -4.72207703e-02f, -6.33508489e-02f, -1.11449450e-01f, -4.81236093e-02f, -6.93147480e-02f, -1.27347916e-01f, -4.54053804e-02f, -7.60601014e-02f, -5.67018501e-02f, -9.83239040e-02f,
  -6.26116991e-02f, -1.13479227e-01f, 4.85357903e-02f, -8.11628774e-02f, -9.93464813e-02f, -3.59749347e-02f, -3.95008475e-02f, 1.91800389e-02f, -7.62071684e-02f, 8.23071040e-03f,
  -1.02001451e-01f, 8.33630841e-03f, 2.48578489e-01f, -6.73281029e-02f, 3.13055590e-02f, 9.39571857e-02f, 1.07300907e-01f, -2.88280785e-01f, -1.31033644e-01f, -1.96635902e-01f,
  -1.68212205e-02f, 6.15799055e-02f, -8.05141330e-02f, 6.84759319e-02f, 2.63718665e-02f, -3.26863043e-02f, 2.82321405e-02f, -1.68552324e-01f, -3.43083628e-02f, -1.13875262e-01f,
  -1.08921513e-01f, -2.97317356e-02f, -1.23368718e-01f, 2.42470764e-02f, -6.34094998e-02f, -5.04549593e-02f, -4.25299108e-02f, 1.90379232e-01f, 5.38963778e-03f, 6.71111196e-02f,
  -2.85508055e-02f, -5.11581218e-03f, 9.32331160e-02f, 6.15912341e-02f, -3.74087133e-02f, 5.25409775e-03f, 1.78373307e-01f, -3.83061878e-02f, 6.29872009e-02f, 4.17274237e-02f,
  -1.89139508e-02f, 5.56188412e-02f, -4.04649079e-02f, 7.37819746e-02f, -9.21877474e-02f, -1.65630728e-01f, -8.49605054e-02f, 3.72311808e-02f, 3.37449927e-03f, -3.90093513e-02f,
  4.37835865e-02f, -6.59159869e-02f, 2.36917683e-03f, 1.35256387e-02f, -7.86560588e-03f, -1.74634159e-02f, -9.55196694e-02f, -4.25577052e-02f, 1.49160661e-02f, -1.69875026e-01f,
  -4.99819219e-02f, -5.62368846e-03f, 4.05302010e-02f, -1.13449916e-01f, -4.67290021e-02f, -5.48675191e-03f, -1.58460811e-01f, -1.30095422e-01f, 3.95848528e-02f, 1.65046185e-01f,
  1.32733464e-01f, 1.84331492e-01f, -1.31768718e-01f, 1.74805541e-02f, 7.47102574e-02f, -2.00979874e-01f, -6.93493113e-02f, 1.00491270e-01f, -1.94771126e-01f, 4.64677103e-02f,
  2.05501139e-01f, -8.34221020e-02f, 7.56463557e-02f, 2.67329291e-02f, -5.45224883e-02f, 1.00050829e-01f, 1.71616107e-01f, 1.04870394e-01f, -2.34371468e-01f, 2.60468870e-02f,
  -9.67349485e-02f, 5.85032590e-02f, -8.53791460e-03f, -2.40441021e-02f, 1.33226275e-01f, -4.13890034e-02f, -7.94627890e-02f, 9.76393893e-02f, -1.50214493e-01f, 5.90293929e-02f,
  -1.04348116e-01f, 1.34967342e-01f, -1.35352612e-01f, -2.31702566e-01f, 1.00758888e-01f, -1.25498176e-01f, -9.77464952e-03f, -5.19989766e-02f, 5.65170534e-02f, -1.25411719e-01f,
  1.72052179e-02f, 2.04873793e-02f, -1.34654874e-02f, 4.51545939e-02f, 9.00357962e-02f, -4.88443561e-02f, -6.14536367e-02f, 1.48581505e-01f, 1.09989330e-01f, 5.30296490e-02f,
  6.88115805e-02f, -1.88310202e-02f, -2.91580558e-02f, -6.24770708e-02f, 1.43423732e-02f, -3.22605856e-02f, -8.10655430e-02f, 1.17723487e-01f, -3.76715958e-02f, 1.37000009e-01f,
  -1.55165732e-01f, 3.97192650e-02f, -2.26992555e-02f, 1.09921552e-01f, 4.47986461e-03f, -9.86521989e-02f, 5.81822470e-02f, 1.48640960e-01f, 3.30714397e-02f, 4.76648435e-02f,
  -1.60221592e-01f, -4.37668264e-02f, -9.99648124e-02f, 1.04468159e-01f, 3.65938991e-02f, -7.57145584e-02f, 1.83651403e-01f, 8.03357586e-02f, 3.60006802e-02f, -1.84040979e-01f,
  -5.03437445e-02f, -1.63359810e-02f, -4.28906605e-02f, 1.53204575e-01f, 1.48456827e-01f, -1.28844678e-01f, 3.32482159e-02f, -1.06884036e-02f, 1.22317873e-01f, -2.59631164e-02f,
  -3.19151469e-02f, 5.63299917e-02f, -1.66297168e-01f, -5.25085628e-02f, -3.82722542e-02f, -1.79789066e-01f, 2.87372787e-02f, 2.70216856e-02f, -6.56702146e-02f, -7.86900595e-02f,
  -2.32275911e-02f, -6.98437095e-02f, -7.01233447e-02f, 5.45991175e-02f, 8.64287391e-02f, -1.63206160e-01f, 9.81647801e-03f, 5.01662381e-02f, 8.29261467e-02f, 5.21335984e-03f,
  1.36458680e-01f, 1.18290391e-02f, 1.65203139e-02f, 1.55811578e-01f, -9.35352892e-02f, -7.00061843e-02f, 2.62830127e-02f, -9.20620933e-02f, -4.86313030e-02f, 1.28090531e-01f,
  1.30206030e-02f, -8.26548412e-02f, 7.76202306e-02f, -1.07191756e-01f, -1.36159420e-01f, -3.77463996e-02f, -1.16538927e-01f, -7.30479211e-02f, 1.70115873e-01f, 1.29010573e-01f,
  3.34224701e-02f, -8.11723992e-02f, 1.87697392e-02f, -3.98243666e-02f, 3.04673880e-01f, 2.82400884e-02f, 4.04900648e-02f, -1.02868877e-01f, -4.81882924e-03f, 1.06167100e-01f,
  1.20668046e-01f, 9.56036747e-02f, 1.82363242e-01f, 1.05208583e-01f, 1.71113476e-01f, 1.21060558e-01f, 3.71485874e-02f, 1.39983937e-01f, -1.00136846e-01f, -6.09275363e-02f,
  -8.27065781e-02f, -7.43073821e-02f, -5.95116839e-02f, -2.68449113e-02f, -1.68907881e-01f, 4.86433730e-02f, -6.16088361e-02f, 1.31501034e-01f, -1.08038194e-01f, 1.45539284e-01f,
  -1.43219262e-01f, -3.35407667e-02f, 1.17033847e-01f, 1.00738131e-01f, -1.92519203e-01f, -8.47713128e-02f, 3.91847044e-02f, 6.40357053e-03f, 5.38525656e-02f, 7.62171373e-02f,
  -2.50956807e-02f, 5.41382469e-02f, 2.44889893e-02f, -2.27810093e-03f, 4.07257676e-02f, -1.89960059e-02f, -8.05560723e-02f, -1.91079248e-02f, 1.15922242e-01f, 4.29738499e-02f,
  -8.78943577e-02f, 1.11152474e-02f, 3.22137848e-02f, 2.30484717e-02f, -1.12205045e-02f, 4.59831767e-02f, 8.11075345e-02f, -2.21233785e-01f, 8.74388963e-02f, 2.32977018e-01f,
  1.96230859e-01f, 5.25274761e-02f, -1.13771111e-02f, -2.24507302e-02f, -5.38259596e-02f, -1.82531141e-02f, -2.00784549e-01f, -2.15829611e-02f, -2.18073521e-02f, -8.49641103e-04f,
  -4.20611314e-02f, -1.10761821e-01f, -1.31175116e-01f, 5.04086576e-02f, -2.06479281e-01f, 1.11362137e-01f, -1.65176205e-02f, -1.55758485e-01f, -6.63635582e-02f, 2.66093686e-02f,
  -1.47914737e-02f, 1.47131205e-01f, -1.44633725e-01f, 6.19774275e-02f, -1.20041735e-01f, -1.24225602e-01f, 1.88889161e-01f, -5.56661375e-02f, -2.21719697e-01f, -6.08630851e-02f,
  1.59460139e-02f, -5.04656658e-02f, 1.64333895e-01f, 1.01830274e-01f, 6.79051504e-02f, 6.48722276e-02f, 2.93472293e-03f, -9.47559774e-02f, 2.82253288e-02f, 9.67757925e-02f,
  -4.85069258e-03f, 1.13616198e-01f, -1.32779712e-02f, -8.23203549e-02f, -8.33943710e-02f, 7.40989894e-02f, -4.94889682e-04f, -8.59663263e-02f, -9.90846381e-02f, -4.86230403e-02f,
  -9.12918001e-02f, -7.02977255e-02f, 5.29328268e-03f, -4.88439761e-02f, -1.09834615e-02f, -6.73048273e-02f, -5.93850575e-02f, -1.74644917e-01f, -8.24964419e-02f, 5.99942030e-03f,
  -8.47387686e-02f, -1.86942052e-02f, 1.56327978e-01f, -3.26265953e-02f, -7.43368268e-02f, 1.05443045e-01f, 6.19204901e-02f, -1.12800881e-01f, -8.45130086e-02f, -2.12007165e-02f,
  7.20331147e-02f, 2.71862000e-02f, -9.89317968e-02f, -9.15836245e-02f, 4.62549068e-02f, 4.79960628e-02f, 1.04772970e-01f, -8.54312330e-02f, 3.12642083e-02f, 2.53615770e-02f,
  -7.90179968e-02f, -3.50358114e-02f, -5.16613461e-02f, 6.57144859e-02f, -1.27127096e-01f, -8.92203525e-02f, -3.64344455e-02f, -4.43729125e-02f, 9.19161364e-02f, 9.26667601e-02f,
  -1.86008643e-02f, 4.22777534e-02f, 7.95179158e-02f, 3.73623259e-02f, -7.96371326e-02f, -6.16781302e-02f, 2.38917947e-01f, -2.08390455e-04f, 1.82753429e-02f, 3.46263126e-02f,
  1.10804722e-01f, -9.36306417e-02f, 3.13274525e-02f, 9.25874636e-02f, 3.72894518e-02f, -7.14911371e-02f, 2.13460680e-02f, 6.54593334e-02f, -4.89231721e-02f, 8.29391330e-02f,
  1.39885154e-02f, -2.59691048e-02f, -8.33540484e-02f, -3.82465944e-02f, -2.24387199e-02f, 1.33946508e-01f, 3.68841924e-02f, 7.56115988e-02f, 6.64999634e-02f, -1.32760033e-02f,
  -7.54566938e-02f, -8.35986957e-02f, 8.42722505e-02f, 3.02978344e-02f, 8.05173069e-02f, -1.74884081e-01f, 7.90133849e-02f, 6.00034371e-03f, 2.21337639e-02f, 9.12471414e-02f,
  3.10486946e-02f, 1.53813034e-01f, -1.44601762e-01f, -1.40142888e-02f, -3.63429524e-02f, -7.99982026e-02f, -1.05233483e-01f, -1.82877611e-02f, 5.39428275e-03f, -5.41671067e-02f,
  5.73498085e-02f, -1.70862041e-02f, -2.87884790e-02f, -1.40467957e-01f, -1.48824090e-02f, -7.82014243e-03f, 6.07254878e-02f, 1.67834818e-01f, -1.69884354e-01f, 8.94465819e-02f,
  -1.60023361e-01f, 1.36084063e-02f, 1.26798838e-01f, -7.51635879e-02f, 1.36776119e-01f, 1.87299326e-02f, 1.34108335e-01f, 2.08693802e-01f, 2.04237569e-02f, 7.07879141e-02f,
  4.64154705e-02f, 9.10777524e-02f, -1.54724136e-01f, 2.82191373e-02f, 1.53004616e-01f, -1.12659104e-01f, 1.04990691e-01f, 1.89481769e-02f, 1.29867941e-01f, -7.41461143e-02f,
  -7.83732533e-02f, -7.54963309e-02f, 3.32538337e-02f, 6.74320310e-02f, 1.08513804e-02f, -8.25427845e-02f, 3.77293117e-02f, -9.39635560e-03f, 2.72089355e-02f, 1.14845023e-01f,
  -7.81104490e-02f, -4.51281630e-02f, 2.34118532e-02f, 4.78646792e-02f, -2.95554264e-03f, -8.22170377e-02f, -8.27291689e-04f, 9.47626159e-02f, -5.73871098e-02f, 2.37023830e-02f,
  -1.51191637e-01f, -1.49377435e-01f, -9.48730633e-02f, -7.08400905e-02f, 2.99575478e-01f, 1.77421831e-02f, 4.24774960e-02f, -7.97189474e-02f, 8.05030018e-02f, -5.97108789e-02f,
  1.06495619e-02f, -4.64741662e-02f, -2.40772329e-02f, 2.35695299e-02f, 5.77373877e-02f, -1.22779191e-01f, 1.86983541e-01f, 9.77183357e-02f, 1.51308521e-03f, 1.19669050e-01f,
  8.32282230e-02f, 1.50171950e-01f, -1.10496514e-01f, 6.44115284e-02f, 1.60356797e-02f, -2.40735978e-01f, 1.71251118e-01f, 1.40738770e-01f, -1.33364260e-01f, 1.44993113e-02f,
  1.94451481e-01f, -9.95673123e-04f, -1.42406896e-01f, 5.04466183e-02f, -1.05446011e-01f, 9.47943404e-02f, -1.71243340e-01f, -1.06131159e-01f, 1.91981450e-01f, -9.14463867e-03f,
  -1.03774533e-01f, -6.43271133e-02f, 9.82678384e-02f, -7.41947815e-02f, 4.79110666e-02f, -3.04446071e-02f, -2.37583518e-02f, 1.12990022e-03f, -3.34194899e-02f, 4.21034871e-03f,
  1.40618250e-01f, -9.07527935e-03f, -1.45389196e-02f, 6.30590543e-02f, -3.47699150e-02f, 4.56570946e-02f, 5.83377481e-02f, 1.14841284e-02f, 3.83981168e-02f, 1.14449054e-01f,
  1.01342320e-01f, -2.55093407e-02f, 4.00505774e-02f, 3.15296911e-02f, -6.32936209e-02f, -7.98806399e-02f, -1.65259168e-01f, -8.65940750e-02f, 4.20802310e-02f, 1.47063332e-02f,
  1.85724229e-01f, -4.82097715e-02f, 7.13054091e-02f, 4.15929183e-02f, 2.35119060e-01f, -8.46825764e-02f, 9.07854363e-02f, -2.23736782e-02f, -1.24427676e-01f, 1.12436287e-01f,
  2.21449509e-02f, 5.93368001e-02f, 2.04111978e-01f, 1.94671839e-01f, 1.43201172e-01f, -7.33011439e-02f, 6.90580085e-02f, -1.15467183e-01f, 4.53174077e-02f, -9.53848958e-02f,
  -1.05646878e-01f, 3.62821185e-04f, -2.11215138e-01f, 7.58936256e-02f, -6.56867996e-02f, -8.23121592e-02f, 3.55825275e-02f, -5.54827712e-02f, -5.57425879e-02f, 9.29486826e-02f,
  -4.33716774e-02f, 8.51507410e-02f, 2.00495105e-02f, 2.18474865e-01f, -1.70309335e-01f, -8.50968510e-02f, -1.31456673e-01f, 1.27533986e-03f, -7.73164779e-02f, -9.93035361e-02f,
  6.89222664e-02f, -1.55486956e-01f, 1.29884388e-02f, 5.92430821e-03f, 9.47441626e-03f, 8.61295238e-02f, 6.68883920e-02f, 1.95874870e-02f, 2.30522119e-02f, -4.07331362e-02f,
  -2.38517951e-02f, 8.27413052e-02f, 5.22810258e-02f, 1.34201810e-01f, -7.81970322e-02f, -5.40175214e-02f, -9.02281553e-02f, 1.56090796e-01f, -4.97596487e-02f, 2.76906081e-02f,
  -1.47525504e-01f, -7.28963017e-02f, -1.65211350e-01f, -1.20714299e-01f, 1.61881432e-01f, 1.18679963e-01f, 4.75725681e-02f, 1.39442340e-01f, 1.04906194e-01f, -1.10021912e-01f,
  1.10036246e-01f, 6.92594005e-03f, -1.69889465e-01f, 2.99090948e-02f, -2.48467010e-02f, -6.99196607e-02f, 1.10989816e-01f, 1.58511084e-02f, 5.52495830e-02f, -2.26374686e-01f,
  1.48164913e-01f, -6.89345151e-02f, 2.44048774e-01f, -4.99781854e-02f, -6.89163283e-02f, 1.17765451e-02f, -1.43110037e-01f, 7.35848397e-02f, -3.13639850e-03f, -1.74294814e-01f,
  1.15566701e-01f, -2.56835166e-02f, -1.13446534e-01f, -1.69830784e-01f, 1.07260980e-01f, 1.21136554e-01f, -7.99438581e-02f, -9.54376627e-03f, 8.62849224e-03f, 5.56317670e-03f,
  -1.85132176e-01f, 1.06218353e-01f, 4.75164838e-02f, 1.22764647e-01f, 8.24392959e-02f, -3.79003808e-02f, -4.98434063e-03f, 1.73277110e-01f, 4.68923571e-03f, 4.07828651e-02f,
  -7.87340850e-02f, 8.88498407e-03f, 7.45099708e-02f, 5.87290619e-04f, 7.23834336e-02f, 1.07614614e-01f, 6.30607503e-03f, 2.26519734e-01f, 2.42047533e-02f, -8.50296300e-03f,
  5.13307489e-02f, 2.02331841e-02f, 4.86801490e-02f, 1.06727034e-01f, 9.83617529e-02f, -1.22825556e-01f, -1.72667697e-01f, -7.11124316e-02f, 6.70223460e-02f, -4.29741070e-02f,
  -8.78047422e-02f, 7.88767040e-02f, -5.52480519e-02f, 5.96355051e-02f, 9.09973606e-02f, -9.37692747e-02f, -1.68514431e-01f, -5.55850472e-03f, -7.25264326e-02f, 8.73429887e-03f,
  -6.70877472e-02f, -1.63111147e-02f, -4.02692668e-02f, -3.61514613e-02f, 2.46122107e-01f, 2.11985409e-02f, 8.36004987e-02f, 1.09896980e-01f, -6.08092025e-02f, -4.10112478e-02f,
  -1.98181812e-02f, -5.73675558e-02f, 5.18172942e-02f, -1.25738367e-01f, 2.17584401e-01f, 4.53518890e-02f, 1.49085879e-01f, -2.05156934e-02f, 1.85230672e-01f, 1.76702783e-01f,
  -1.56846792e-01f, -2.70556230e-02f, -1.94987282e-02f, -6.02767132e-02f, -4.12794910e-02f, -4.20728996e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  9.76347402e-02f, 4.86631133e-02f, 4.05826606e-02f, -4.52669300e-02f, -6.30164072e-02f, 2.57673115e-01f, 8.33532289e-02f, 3.75627428e-02f, 4.86477725e-02f, -2.92891767e-02f,
  -5.61879724e-02f, 6.08940274e-02f, -1.47148430e-01f, 2.72681732e-02f, -6.52372390e-02f, 3.35815430e-01f, 1.52221799e-01f, -7.86993802e-02f, 1.15509760e-02f, -9.22512338e-02f,
  3.76093425e-02f, 1.48257185e-02f, 1.93088457e-01f, -1.72156557e-01f, 9.44229066e-02f, 2.51725335e-02f, -1.80484448e-03f, -2.87402511e-01f, -2.06969127e-01f, -1.79855049e-01f,
  -2.45948546e-02f, 2.64840245e-01f, -1.48779988e-01f, -2.39640713e-01f, -6.58336431e-02f, -4.47749393e-03f, -1.08296797e-01f, -5.96814677e-02f, 7.84975439e-02f, 2.17149973e-01f,
  3.89389805e-02f, 1.16266124e-01f, 2.11806938e-01f, 2.13693157e-01f, -9.75888222e-02f, 2.98631698e-01f, -1.85531795e-01f, -1.73176434e-02f, 1.37500271e-01f, -1.59771815e-01f,
  -3.29136521e-01f, -1.11071765e-01f, 2.61825591e-01f, 1.12526052e-01f, 1.29726827e-01f, 1.52374269e-03f, 2.84861952e-01f, 2.19776854e-01f, -2.06687912e-01f, -5.64346686e-02f,
  -2.73172688e-02f, -4.78405654e-02f, -6.03994280e-02f, -1.09040290e-01f, 1.73982922e-02f, 6.43259659e-02f, 9.77632180e-02f, -1.28958113e-02f, -1.51075553e-02f, 1.45551115e-02f,
  -1.16561346e-01f, 5.83470464e-02f, 8.62103552e-02f, -1.71175286e-01f, 6.32772874e-03f, -2.12894250e-02f, 9.44112763e-02f, -1.50672615e-01f, 2.98026856e-02f, -1.05099715e-01f,
  -1.13230340e-01f, -4.98389378e-02f, 8.62159282e-02f, 3.20963204e-01f, 2.25520413e-02f, -1.84508875e-01f, -5.09016626e-02f, 2.80723758e-02f, 3.53833400e-02f, -6.61516637e-02f,
  1.23360239e-01f, 1.19639874e-01f, 1.49697021e-01f, -3.91788222e-02f, -6.50812313e-02f, 1.94719613e-01f, -1.65249631e-01f, 2.40334481e-01f, 1.24219246e-01f, -6.89347014e-02f,
  1.31178454e-01f, 1.84421211e-01f, -2.23528259e-02f, 5.27023822e-02f, 4.80072685e-02f, -1.44189224e-01f, 7.17149377e-02f, 9.13877487e-02f, 2.70012975e-01f, 1.11024685e-01f,
  -1.05039686e-01f, 3.10393423e-01f, 8.94562975e-02f, 1.25932693e-01f, 8.46629292e-02f, 2.33014733e-01f, -3.20737436e-02f, 1.50740882e-02f, -1.67020008e-01f, -9.34519470e-02f,
  2.41889745e-01f, -3.45121026e-02f, -1.11749351e-01f, 1.27049059e-01f, -1.39387995e-01f, 6.01513684e-02f, -1.05002910e-01f, -8.73197913e-02f, 4.12876941e-02f, 3.79901677e-02f,
  -3.61129716e-02f, 1.66216001e-01f, 4.89396192e-02f, 9.01314616e-02f, -1.50410846e-01f, 9.17107388e-02f, 2.18857318e-01f, 4.23087142e-02f, -1.02433525e-02f, 3.70774195e-02f,
  -1.31845206e-01f, -4.40385714e-02f, 5.01598045e-02f, 6.37802854e-02f, -1.41385319e-02f, 1.27669588e-01f, 8.98928791e-02f, 2.23771617e-01f, -1.30126029e-01f, -2.32653052e-01f,
  9.32608619e-02f, -1.20272413e-01f, 2.81354457e-01f, 2.28005257e-02f, -4.68923450e-02f, -9.06365067e-02f, -6.64553568e-02f, -1.84018523e-01f, -2.19434127e-01f, 2.37389222e-01f,
  -3.39230239e-01f, 2.14611962e-02f, 2.01440528e-01f, -1.48588657e-01f, 2.46801287e-01f, 1.49895415e-01f, -2.60992907e-02f, 5.86398467e-02f, 7.78672248e-02f, 3.14925551e-01f,
  -2.14334652e-01f, 3.14160228e-01f, 1.26051819e-02f, 4.03423607e-02f, 3.80718857e-02f, 3.51060331e-01f, 2.56233096e-01f, 3.55273038e-02f, -1.24613466e-02f, 2.15308174e-01f,
  -1.97409555e-01f, 2.12883338e-01f, -7.83157125e-02f, 4.73612845e-02f, 2.31865078e-01f, -3.11847292e-02f, -1.36004565e-02f, -1.50600344e-01f, -1.65317342e-01f, 5.78843169e-02f,
  2.33730283e-02f, -5.97704798e-02f, 2.42342539e-02f, 2.26810593e-02f, -3.02125905e-02f, -2.01832503e-02f, -4.56482954e-02f, -9.20540839e-02f, 2.89949891e-03f, -7.41141737e-02f,
  -1.21037647e-01f, 1.33658156e-01f, 8.04033503e-03f, 6.13026693e-03f, 1.61878373e-02f, 7.59940967e-02f, -9.18893367e-02f, -6.30389899e-02f, -8.24077334e-03f, 3.12707387e-02f,
  -1.33230286e-02f, -3.20712388e-01f, 7.07029626e-02f, 2.25493997e-01f, 1.04069628e-01f, -1.21910265e-02f, -1.28108680e-01f, 3.56834494e-02f, -1.67929739e-01f, -8.63908157e-02f,
  -1.83644250e-01f, -1.34119205e-02f, -8.63920823e-02f, -1.46997407e-01f, 1.75542787e-01f, -1.69043779e-01f, -3.17499302e-02f, -3.67977284e-03f, -1.25809714e-01f, -1.73040792e-01f,
  4.10160832e-02f, -1.99672565e-01f, -1.09683394e-01f, 1.77094489e-01f, 5.41680343e-02f, 1.83377057e-01f, -1.45174533e-01f, 1.40093686e-02f, 2.06834063e-01f, -3.06338161e-01f,
  6.73985407e-02f, -1.16262466e-01f, 9.99513790e-02f, -2.89499201e-02f, 1.91478744e-01f, 1.08079180e-01f, 2.16278866e-01f, 1.55504331e-01f, -9.45130661e-02f, 2.00415030e-01f,
  1.37210622e-01f, -2.56921053e-01f, 2.79709518e-01f, -5.29957712e-02f, 1.87326357e-01f, 1.34399548e-01f, 2.85952203e-02f, 1.24245837e-01f, -2.20192540e-02f, 1.80783778e-01f,
  8.88346210e-02f, -1.82491973e-01f, 1.03009038e-01f, 3.85421664e-02f, 6.27924688e-04f, 9.41389725e-02f, 2.19421551e-01f, 1.58430278e-01f, 7.31915236e-02f, 6.59270212e-03f,
  1.20114557e-01f, -2.61359245e-01f, -4.89389673e-02f, 2.22085029e-01f, 1.67492345e-01f, -2.91868508e-01f, 1.95275638e-02f, 2.09321082e-01f, 1.51879057e-01f, 7.49091804e-02f,
  -2.63748635e-02f, 1.34519979e-01f, -1.13497593e-01f, 4.37456276e-03f, -1.56119183e-01f, 1.21406959e-02f, 1.67023912e-01f, -1.92967698e-01f, 8.79408121e-02f, 2.33653537e-03f,
  -1.32222518e-01f, 1.59256116e-01f, -1.16660848e-01f, 1.29852414e-01f, 1.68015495e-01f, -1.56744644e-02f, -1.16638765e-01f, 1.93779990e-01f, -1.64393723e-01f, -2.23007426e-01f,
  -1.91375107e-01f, -2.48988327e-02f, 1.65738150e-01f, 2.94893142e-02f, 7.98887387e-02f, -9.80328862e-03f, 1.73342004e-01f, 1.50211230e-01f, 9.03857201e-02f, -1.34343833e-01f,
  5.95242716e-03f, 2.73624152e-01f, -1.99362859e-01f, 4.39545549e-02f, 4.92113262e-01f, 9.30738822e-02f, 3.42024505e-01f, 2.83931613e-01f, 2.14947060e-01f, 3.49182665e-01f,
  4.25577834e-02f, 7.90370181e-02f, 5.71531430e-02f, -3.85607854e-02f, -4.08488251e-02f, -1.30644977e-01f, -4.39543054e-02f, -4.31053191e-02f, -1.00306511e-01f, 6.29014894e-02f,
  1.81620255e-01f, 7.68642128e-02f, 4.49226238e-02f, 8.18848461e-02f, -3.43082137e-02f, -1.72280818e-01f, -4.63578552e-02f, 6.15847297e-02f, 6.78847209e-02f, -2.09978521e-01f,
  1.17079154e-01f, 2.57927626e-01f, 1.33725762e-01f, -3.98900732e-03f, -2.33724296e-01f, -1.18517809e-01f, -1.16360359e-01f, -8.06100946e-03f, -1.78984925e-01f, 7.49515593e-02f,
  8.50284919e-02f, -1.03654556e-01f, 1.42658740e-01f, 4.80124028e-03f, -2.07257792e-01f, 7.88426548e-02f, -1.44787401e-01f, 1.46524474e-01f, 1.25377541e-02f, -2.37967014e-01f,
  -2.55116373e-01f, 1.89400781e-02f, 1.82603806e-01f, -1.07686305e-02f, -4.91317064e-02f, 2.20914790e-03f, 2.59283274e-01f, -1.01933084e-01f, 7.94092119e-02f, -2.02809215e-01f,
  2.43075743e-01f, -2.96350149e-03f, 2.09315270e-01f, 2.14664321e-02f, 3.50732148e-01f, 2.02255845e-01f, 1.27483513e-02f, 2.05494016e-01f, 2.45424360e-01f, -3.70666310e-02f,
  3.71096551e-01f, 1.33819938e-01f, 1.52975932e-01f, 2.83654839e-01f, 4.20673937e-03f, -4.17783335e-02f, -8.02547559e-02f, 1.23072229e-01f, 2.87888274e-02f, 9.92936194e-02f,
  -3.71120009e-03f, 1.23501129e-01f, 2.09097743e-01f, 2.01865826e-02f, 2.95654638e-03f, 9.69927087e-02f, -1.29892245e-01f, 2.21239820e-01f, 7.63942003e-02f, 6.11594841e-02f,
  1.17484212e-01f, 9.50647891e-02f, -1.04869306e-01f, 1.64877892e-01f, -2.15205640e-01f, -1.46795511e-01f, -1.34877428e-01f, -2.24577010e-01f, 1.75157413e-01f, -3.64801958e-02f,
  1.96749911e-01f, -1.34557083e-01f, -3.00604291e-02f, 6.32436713e-03f, 2.39244923e-02f, -7.24067912e-02f, 1.67903695e-02f, -3.40036899e-02f, 5.53000113e-03f, -9.33922976e-02f,
  2.34112993e-01f, 1.24676816e-01f, 2.20554590e-01f, 1.25741474e-02f, 7.74494857e-02f, 7.00484514e-02f, -3.14007550e-02f, 2.53532708e-01f, 3.79605114e-01f, -2.61717290e-01f,
  -3.07876896e-03f, 1.55285269e-01f, -2.17047200e-01f, -1.29161822e-02f, -1.11644723e-01f, -5.46061546e-02f, -5.93292937e-02f, 9.87230539e-02f, -6.07636683e-02f, -1.43923983e-01f,
  9.58286077e-02f, -2.10868977e-02f, 7.85540696e-03f, 2.56189588e-03f, -2.19046205e-01f, 4.37606350e-02f, -7.35308304e-02f, 7.77172372e-02f, 9.13634285e-05f, -2.02447772e-01f,
  2.50431057e-02f, 1.30101917e-02f, 8.37252755e-03f, -1.29197180e-01f, -7.85849020e-02f, 2.15377193e-02f, -3.09217758e-02f, -1.68422870e-02f, -1.77479148e-01f, -1.58767104e-01f,
  -9.93039608e-02f, -9.48597342e-02f, -1.12501584e-01f, -1.01246074e-01f, -6.23772666e-02f, -6.92313537e-02f, -5.29576130e-02f, -7.83760753e-03f, -9.44589674e-02f, -1.25660583e-01f,
  -3.88005450e-02f, 4.90781255e-02f, 1.37666330e-01f, 1.42250970e-01f, 5.38245365e-02f, 5.26995584e-02f, -6.17563203e-02f, -1.73350483e-01f, -1.97875679e-01f, 2.68184934e-02f,
  -8.01364928e-02f, -4.97023389e-02f, 2.78264463e-01f, -1.32090807e-01f, 2.42543563e-01f, -5.10574691e-02f, -4.86385375e-02f, -5.05327284e-02f, 1.41152650e-01f, 1.73161671e-01f,
  -3.43476683e-01f, 2.86936432e-01f, -7.07602426e-02f, -2.17887327e-01f, 5.80482148e-02f, 5.76502942e-02f, 8.48735943e-02f, 3.60533525e-03f, -2.90463138e-02f, 1.59975186e-01f,
  -2.66929984e-01f, 1.09969281e-01f, -7.38008246e-02f, -1.68377012e-02f, -1.92117855e-01f, -1.67727932e-01f, -1.07954092e-01f, -3.00192207e-01f, -1.79100171e-01f, -3.69566798e-01f,
  8.21084753e-02f, -2.11723089e-01f, 1.76761132e-02f, -9.83090512e-03f, 5.88577054e-02f, 3.99152264e-02f, 1.02935955e-01f, 1.84616134e-01f, 3.23993638e-02f, 6.64110184e-02f,
  4.05392498e-02f, -1.65126100e-01f, -6.52037561e-02f, -6.26454651e-02f, 1.31273821e-01f, 9.64511707e-02f, -5.44702858e-02f, -7.08826557e-02f, 2.83386782e-02f, -8.95826444e-02f,
  -7.84912109e-02f, 3.52743238e-01f, -1.56635270e-01f, -2.42142200e-01f, -2.23063111e-01f, 7.67876208e-02f, 1.42183276e-02f, 7.83461034e-02f, 4.24382947e-02f, 1.98330298e-01f,
  2.93254614e-01f, 4.14732285e-02f, -7.23468438e-02f, 1.06471078e-02f, -1.96498837e-02f, 1.56294778e-01f, 1.64339602e-01f, -1.80327427e-02f, -3.52373696e-03f, -4.20828015e-02f,
  5.45171201e-02f, 2.27611154e-01f, 2.35805392e-01f, -1.33812606e-01f, 1.02400586e-01f, -1.30095482e-01f, 3.12638879e-01f, 9.48064029e-03f, -2.92817149e-02f, 2.27879211e-01f,
  -2.18029087e-03f, 3.05751562e-01f, -1.40405267e-01f, 2.66289234e-01f, -4.22822013e-02f, -2.58390401e-02f, -2.68873781e-01f, -8.43888223e-02f, 1.07815653e-01f, -1.68032452e-01f,
  -1.28950879e-01f, 8.13047439e-02f, -8.48770216e-02f, 1.43574819e-01f, -9.20560807e-02f, -3.90440002e-02f, 9.32218134e-02f, 1.15240581e-01f, -4.54659536e-02f, 1.60442770e-01f,
  2.83679320e-03f, -1.85714826e-01f, -1.22955054e-01f, -7.16845691e-02f, 7.18585309e-03f, -1.39065430e-01f, 9.25052986e-02f, -6.34432584e-02f, -1.62117574e-02f, -1.62303969e-01f,
  4.31176573e-02f, -1.30807430e-01f, -7.28686824e-02f, 4.52106111e-02f, 1.04253627e-01f, 1.56596214e-01f, 2.20564738e-01f, -1.62645996e-01f, 6.72462583e-02f, -1.50907990e-02f,
  1.91915497e-01f, -1.54367253e-01f, -1.01745732e-01f, 3.41236852e-02f, 1.01592401e-02f, 1.17646776e-01f, 4.98131737e-02f, 1.73114687e-01f, -1.06245898e-01f, 9.34528261e-02f,
  -3.93060967e-02f, -3.01365871e-02f, 4.41293232e-02f, 1.09020509e-01f, -2.15772130e-02f, 4.16914038e-02f, -1.65961266e-01f, 1.78272709e-01f, -1.24845766e-01f, -6.56454489e-02f,
  -1.83773562e-02f, 3.70135993e-01f, -5.37013039e-02f, 3.43018562e-01f, 2.23265052e-01f, 1.65083691e-01f, -4.71842773e-02f, 1.33763671e-01f, -1.35995671e-01f, -3.57348546e-02f,
  1.11402191e-01f, 2.23945111e-01f, 2.26028427e-01f, 2.80025769e-02f, 1.66624799e-01f, 2.94099092e-01f, -1.71323732e-01f, 2.70743191e-01f, -1.23653419e-01f, -1.44057930e-01f,
  -8.76229815e-03f, 9.38598067e-02f, 6.70518950e-02f, 6.40482083e-02f, 7.44277835e-02f, 4.20330539e-02f, -6.83044568e-02f, 6.08038232e-02f, 1.44832119e-01f, 7.50247389e-02f,
  1.38209000e-01f, 5.66567704e-02f, -7.88558051e-02f, -9.59080830e-03f, 1.04350530e-01f, -3.11008878e-02f, -3.69213969e-02f, 6.04428723e-02f, 2.39020213e-02f, 5.74839627e-03f,
  -4.71392646e-02f, 1.44617736e-01f, 1.35439828e-01f, -5.38928248e-02f, -5.12013733e-02f, 3.72505821e-02f, 1.20009584e-02f, -2.09978539e-02f, -1.39209419e-01f, -1.51780829e-01f,
  -3.02264214e-01f, 1.54572837e-02f, -1.74882099e-01f, 2.67343875e-02f, 1.13978870e-02f, -6.94702268e-02f, 1.33481454e-02f, 1.39313236e-01f, -5.93826920e-03f, -1.18520416e-01f,
  -5.21769300e-02f, 9.81223211e-02f, 4.64464463e-02f, 3.83510560e-01f, 1.52633622e-01f, 3.42532992e-02f, 1.50057331e-01f, -8.60459171e-03f, 2.60773867e-01f, -8.80809054e-02f,
  6.07194304e-02f, 1.26744270e-01f, 9.66388062e-02f, 1.19689658e-01f, 1.36951432e-01f, -1.48203194e-01f, 1.17212400e-01f, 4.58176807e-02f, -3.18285525e-02f, -2.47345343e-01f,
  1.79214284e-01f, -3.68670374e-02f, 1.49762824e-01f, 2.03022733e-01f, -1.83755532e-02f, 8.67737383e-02f, 2.44874693e-02f, -7.32409433e-02f, -8.35996866e-03f, 5.32903187e-02f,
  6.27383664e-02f, 5.80829429e-03f, -3.77040952e-02f, -1.32470978e-02f, 8.11163932e-02f, 2.32004691e-02f, 9.65441540e-02f, 1.17743239e-01f, 8.53829011e-02f, 6.46426231e-02f,
  6.03078417e-02f, 4.91295755e-02f, 6.53002486e-02f, 2.68440880e-02f, 1.50179058e-01f, 4.93063256e-02f, -3.01862862e-02f, -9.38796997e-02f, -7.67967701e-02f, -1.75198093e-01f,
  -2.75121238e-02f, -7.34355450e-02f, 4.84896339e-02f, 1.90962568e-01f, 1.63967967e-01f, -2.45530847e-02f, 1.39849126e-01f, -4.46339250e-02f, -2.16364712e-01f, 5.49584664e-02f,
  -1.84633568e-01f, -2.43468434e-02f, 1.33400828e-01f, 1.64434224e-01f, 4.91620898e-02f, -1.14958778e-01f, 3.46141964e-01f, -2.28240490e-01f, 6.35852814e-02f, 2.41454929e-01f,
  -2.22187936e-02f, 7.39218444e-02f, -9.29030031e-02f, 1.52923256e-01f, 1.16324596e-01f, -1.15642026e-01f, 3.10716450e-01f, 9.28534102e-03f, 1.55356750e-01f, 1.25651687e-01f,
  2.90424407e-01f, 2.96436310e-01f, 1.32865965e-01f, 3.56208950e-01f, 1.57025918e-01f, 3.41496974e-01f, -9.70866997e-03f, 8.60031992e-02f, 4.00156491e-02f, 4.38725874e-02f,
  -1.81160159e-02f, 8.27158689e-02f, 2.17314184e-01f, 9.27428976e-02f, 2.63959989e-02f, 7.39653483e-02f, 2.09516168e-01f, 2.01342374e-01f, -1.65240634e-02f, 1.08180605e-01f,
  3.59092019e-02f, 8.64462089e-03f, 6.44565150e-02f, -5.97812869e-02f, 1.66191235e-01f, -2.58975625e-02f, 8.01812932e-02f, -3.73450890e-02f, -3.09872895e-01f, -6.69256821e-02f,
  2.65560988e-02f, -2.16176622e-02f, 1.12216294e-01f, 4.02623683e-01f, -8.35842919e-03f, -6.35936484e-02f, 6.95121512e-02f, -2.96868533e-01f, -1.46164343e-01f, 1.49835140e-01f,
  -2.92307764e-01f, 1.62754357e-02f, 1.45647064e-01f, -1.65926591e-02f, 2.13194698e-01f, 3.02031189e-02f, 2.13859916e-01f, 7.02304989e-02f, 2.22253576e-01f, 2.40961835e-01f,
  -1.79995239e-01f, 2.71093309e-01f, 7.48118088e-02f, -1.16516627e-01f, -1.43752676e-02f, 2.59063784e-02f, 2.16297492e-01f, 7.17689320e-02f, -9.52102244e-02f, 3.24012011e-01f,
  4.73591983e-02f, 2.18098626e-01f, -1.14229200e-02f, 1.45045191e-01f, -1.00750163e-01f, -2.32914925e-01f, 1.99593995e-02f, -2.31905401e-01f, 8.28937963e-02f, -1.79835349e-01f,
  2.42353871e-01f, 9.20545533e-02f, 7.41491839e-02f, -8.56063440e-02f, -5.20665683e-02f, -1.33658322e-02f, -9.61955935e-02f, -1.43930107e-01f, -1.30451145e-02f, -6.63036406e-02f,
  -1.00804284e-01f, -8.74570906e-02f, 6.13431409e-02f, -1.36902526e-01f, 2.93011814e-02f, -1.07484557e-01f, -1.18423505e-02f, 8.91742930e-02f, -1.45349521e-02f, -1.34788286e-02f,
  1.40481547e-01f, 5.03469482e-02f, 2.47076303e-01f, -2.14336261e-01f, 1.21963285e-02f, -5.07480465e-03f, 1.34757534e-01f, -1.59999207e-01f, -1.49097949e-01f, -9.29477811e-02f,
  1.41854391e-01f, 7.12193698e-02f, 1.04379177e-01f, 1.70938745e-01f, 6.14771284e-02f, -2.43156459e-02f, -1.89216714e-02f, -7.74838477e-02f, 2.71304660e-02f, -1.71316564e-01f,
  -1.51297990e-02f, 2.99134642e-01f, 1.07579358e-01f, 1.82590216e-01f, -9.53356177e-02f, 2.56788563e-02f, -3.35713834e-01f, 5.21746635e-01f, -3.92165221e-02f, 2.58325517e-01f,
  1.04675882e-01f, 1.26648650e-01f, 1.47513017e-01f, 8.75896886e-02f, 6.82285652e-02f, 2.40005046e-01f, 1.58374816e-01f, 3.09978932e-01f, 2.06132442e-01f, 2.35556111e-01f,
  1.99060723e-01f, 4.23586488e-01f, -1.55325711e-01f, 1.75588042e-01f, -1.12019792e-01f, -3.05913776e-01f, 4.31405082e-02f, -9.54892579e-03f, 1.02083653e-01f, -1.33403301e-01f,
  -3.04348357e-02f, 2.96023756e-01f, 7.73831308e-02f, 4.70557660e-02f, -3.55961099e-02f, -5.74789643e-02f, 1.91861428e-02f, -5.78893498e-02f, -3.20320092e-02f, -2.31206529e-02f,
  -8.15972537e-02f, 2.47557819e-01f, 1.03127003e-01f, -1.06093347e-01f, -2.08146707e-03f, -6.36733249e-02f, -9.78202373e-02f, 1.08046077e-01f, 2.40981281e-01f, 3.33983637e-02f,
  -2.26898808e-02f, 2.19807044e-01f, -2.78051607e-02f, -4.56471071e-02f, -4.03694063e-02f, -2.39991173e-01f, -2.01464519e-01f, 2.15987638e-01f, -2.04433948e-01f, -1.56460553e-01f,
  1.05441928e-01f, -1.69639945e-01f, -1.07901327e-01f, -2.34872892e-01f, -2.04209182e-02f, 1.28875256e-01f, 2.38615707e-01f, 1.73470587e-01f, 4.29420806e-02f, 3.88431221e-01f,
  -1.40206516e-01f, 1.93204895e-01f, -9.80640575e-02f, -2.42801337e-03f, 3.21855396e-01f, -1.03803113e-01f, -1.29148960e-01f, 9.09109265e-02f, 1.94770530e-01f, 2.11572394e-01f,
  7.56973699e-02f, -2.30786391e-02f, 8.27946588e-02f, 1.00504428e-01f, -2.20441073e-01f, -2.17813909e-01f, 8.73145685e-02f, -2.16835946e-01f, 1.56394895e-02f, -1.14590608e-01f,
  -5.15733585e-02f, 1.69033721e-01f, 1.03350081e-01f, 7.00799152e-02f, 1.68153062e-01f, 1.73352286e-02f, -3.70444916e-02f, -4.30688970e-02f, 1.22987732e-01f, 1.14823215e-01f,
  1.09824007e-02f, 3.59199457e-02f, 6.03607371e-02f, 7.26590082e-02f, 5.77119105e-02f, -2.51004040e-01f, 1.03156790e-01f, 8.42730179e-02f, -1.56998020e-02f, -2.06857666e-01f,
  -1.25725836e-01f, 1.37696236e-01f, 1.30988136e-01f, 1.70029607e-02f, -4.91264462e-02f, 2.26739138e-01f, -3.90079767e-02f, 1.08994618e-01f, -1.42739654e-01f, -1.12185910e-01f,
  -3.72118086e-01f, -5.44003919e-02f, -1.68140307e-01f, 3.52585576e-02f, 1.17001213e-01f, -1.10203706e-01f, -8.91004726e-02f, 1.83143407e-01f, 2.93588359e-02f, -2.16363162e-01f,
  -7.32950568e-02f, 1.79181382e-01f, -5.13628796e-02f, 2.38714471e-01f, 1.37826741e-01f, -1.22065991e-01f, 3.48979235e-01f, -5.32387989e-04f, 2.53909230e-01f, -3.59687246e-02f,
  2.06622183e-01f, 3.31635535e-01f, 6.61713257e-02f, -5.32720573e-02f, 8.11929405e-02f, -6.95510348e-03f, 3.28478292e-02f, -2.58180536e-02f, 1.29106134e-01f, -3.06773037e-01f,
  3.64639282e-01f, 1.90061294e-02f, 3.57877642e-01f, 3.31262797e-01f, 9.72257629e-02f, 6.19860962e-02f, 1.25413299e-01f, 1.12173960e-01f, -3.17969285e-02f, 1.36592552e-01f,
  8.18005055e-02f, 2.63570109e-03f, 1.66056871e-01f, -1.45979077e-02f, -3.31002437e-02f, 3.91009524e-02f, -7.21515119e-02f, 5.63694350e-02f, 1.39949724e-01f, 1.92302391e-01f,
  1.34850085e-01f, -4.03639242e-05f, 1.13930270e-01f, 1.47422060e-01f, -4.91687432e-02f, -1.02643475e-01f, 7.54655600e-02f, -2.06309199e-01f, 1.35782599e-01f, 7.24502802e-02f,
  4.75947820e-02f, -2.14552075e-01f, -5.07016852e-02f, -1.31532297e-01f, 1.83369592e-01f, 3.01255435e-01f, -2.06432760e-01f, -1.27689466e-01f, -6.99549764e-02f, 2.24932525e-02f,
  1.43528283e-01f, 1.08712196e-01f, 1.08146250e-01f, 3.78843635e-01f, 3.17693383e-01f, 2.79886812e-01f, -2.19460595e-02f, 1.64859489e-01f, -5.93155697e-02f, 2.48621017e-01f,
  -1.63554832e-01f, 1.82821900e-01f, 1.17086887e-01f, -4.60172370e-02f, -1.81922853e-01f, -4.03956696e-02f, 1.42223492e-01f, 7.97767192e-02f, -1.59402698e-01f, 2.25279763e-01f,
  5.60825169e-02f, -4.11501806e-03f, 3.72281857e-02f, 3.42132986e-01f, -1.56202137e-01f, -1.27266310e-02f, -1.25658065e-01f, -7.27613270e-02f, -1.41956106e-01f, -1.09284900e-01f,
  -6.77375421e-02f, -1.76908672e-01f, -5.97032383e-02f, -3.31423990e-03f, 1.21629596e-01f, -4.70890924e-02f, -4.10923697e-02f, -4.32475582e-02f, 5.67033440e-02f, -6.66195452e-02f,
  2.58137546e-02f, 1.38234407e-01f, 1.98734850e-02f, 8.43521282e-02f, 1.05340682e-01f, -6.84395134e-02f, -1.45192653e-01f, 1.48179129e-01f, 4.47459333e-02f, -1.64134324e-01f,
  -8.94141048e-02f, -3.62146869e-02f, 1.04246855e-01f, -1.76947325e-01f, 6.88087344e-02f, -1.52854249e-01f, 1.32753775e-01f, 9.18920934e-02f, 1.27976537e-02f, 1.26007767e-02f,
  1.35234356e-01f, 4.88645164e-03f, -3.78178731e-02f, -1.34551167e-01f, 5.11220098e-02f, -3.26101594e-02f, 4.92292270e-02f, 1.39167562e-01f, 6.75826222e-02f, -9.95872691e-02f,
  1.99026629e-01f, -5.67650199e-02f, 2.14589059e-01f, -8.52373019e-02f, 6.98810024e-03f, 3.69348377e-02f, -2.55032837e-01f, 8.97697881e-02f, 1.18333735e-01f, 4.07354198e-02f,
  8.33734572e-02f, 1.14613742e-01f, 2.27351949e-01f, -1.48017213e-01f, 1.20955765e-01f, 1.31846830e-01f, -8.53809789e-02f, 1.90852612e-01f, -4.54960763e-02f, -1.92792509e-02f,
  -1.48290783e-01f, -1.67017534e-01f, -5.68666644e-02f, 1.19241312e-01f, 2.60567367e-02f, -3.66980210e-02f, 2.06678107e-01f, 1.09097950e-01f, 2.57560998e-01f, 6.58548847e-02f,
  4.97099794e-02f, 1.01790197e-01f, 1.08354606e-01f, 9.17720944e-02f, 1.36890113e-01f, -4.09309417e-02f, 5.40933870e-02f, -6.58935383e-02f, 7.34490305e-02f, -2.21539848e-02f,
  2.86003742e-02f, -7.97061846e-02f, -1.30520150e-01f, 1.64279714e-01f, -5.69450632e-02f, 1.21974900e-01f, -9.11797360e-02f, 3.55090022e-01f, -3.06554371e-03f, 1.52575508e-01f,
  1.29541948e-01f, 8.05541053e-02f, 3.19901586e-01f, -4.31244820e-02f, -1.22445356e-02f, 4.53748368e-02f, -1.31721959e-01f, 2.84302145e-01f, -2.98697501e-01f, 1.25345156e-01f,
  3.38183194e-01f, 2.79264927e-01f, 2.54086465e-01f, 4.31146473e-02f, 1.90408587e-01f, -3.08410943e-01f, 7.87472129e-02f, 1.44975744e-02f, -7.74670690e-02f, -3.78851779e-02f,
  -9.70679987e-03f, 2.29371235e-01f, -2.64603704e-01f, 2.78611511e-01f, 2.92001873e-01f, -1.22851156e-01f, -3.54286097e-02f, 2.90259063e-01f, -8.14878568e-02f, -1.22336924e-01f,
  1.83208570e-01f, 3.06614250e-01f, 2.86397427e-01f, 3.69328141e-01f, 2.18735784e-02f, 3.65067035e-01f, -7.13714287e-02f, -1.66613534e-01f, 1.01128563e-01f, -2.33994499e-01f,
  -1.88496262e-01f, -9.79908705e-02f, -6.77469447e-02f, -4.40429077e-02f, -1.78363085e-01f, -7.16328844e-02f, -1.89764410e-01f, -1.88379750e-01f, -5.35337031e-02f, 6.42387271e-02f,
  -1.60062835e-01f, -1.35380933e-02f, -4.17899601e-02f, -4.44297828e-02f, -1.24276407e-01f, -2.83462763e-01f, 1.34234890e-01f, 3.30424160e-02f, 7.55396560e-02f, -6.96766749e-02f,
  -4.15043868e-02f, -1.54673055e-01f, -1.90454081e-01f, -2.18670756e-01f, -2.18675211e-01f, 7.78759457e-03f, -2.34051913e-01f, -1.10571012e-01f, 2.36236796e-01f, -2.46083155e-01f,
  1.40062749e-01f, -2.28191346e-01f, 8.52479320e-03f, -4.18077767e-01f, -1.22398324e-01f, -1.18530862e-01f, 5.24863079e-02f, 1.90614447e-01f, -1.17802784e-01f, 2.57422775e-01f,
  -3.20851177e-01f, 3.44574340e-02f, 2.26229921e-01f, -2.59911269e-01f, 1.09370556e-02f, -1.80055246e-01f, 3.45052272e-01f, -8.10984969e-02f, 1.09744847e-01f, 3.44959110e-01f,
  1.66936234e-01f, 1.10228313e-02f, -4.04003076e-02f, 2.29877472e-01f, -4.68703061e-02f, -3.98575813e-01f, 1.56571612e-01f, -4.74674940e-01f, 2.75928140e-01f, -2.27267221e-01f,
  2.27739923e-02f, -1.75610222e-02f, 5.81982397e-02f, 1.28548304e-02f, -6.95589185e-02f, 8.12671781e-02f, 7.59191886e-02f, -6.68325797e-02f, -3.64026241e-02f, 6.32720962e-02f,
  4.35530096e-02f, -1.58597827e-02f, -8.60149562e-02f, 6.37504980e-02f, -4.66035083e-02f, 8.39729905e-02f, 5.61914258e-02f, 7.95954093e-02f, 5.26149459e-02f, -1.71136305e-01f,
  1.89393431e-01f, -4.98020649e-03f, 9.80193540e-02f, -1.84495121e-01f, 6.07763007e-02f, -1.16436914e-01f, -9.13960412e-02f, -1.89080656e-01f, -1.80267379e-01f, -3.53787877e-02f,
  1.56184524e-01f, 1.15298152e-01f, 4.89452146e-02f, -2.14010596e-01f, -1.92634493e-01f, -4.37440798e-02f, -1.92614377e-01f, -1.25321075e-01f, 7.01819584e-02f, 1.53068930e-01f,
  -1.28503395e-02f, 1.56728253e-01f, 1.29836202e-01f, 6.80032372e-02f, -1.82127163e-01f, 3.62525046e-01f, -5.36372028e-02f, -1.80504154e-02f, -3.96924838e-02f, -1.02232277e-01f,
  -1.16395533e-01f, -1.63256198e-01f, 3.27707410e-01f, 1.76149175e-01f, 2.37634659e-01f, 1.98627412e-01f, 2.30004340e-01f, 3.16079289e-01f, 7.26907849e-02f, 1.27747282e-01f,
  2.15567015e-02f, 1.20267555e-01f, 4.30376362e-03f, -6.53328151e-02f, 9.63018090e-02f, 6.27098000e-03f, 2.01155171e-01f, 2.68637412e-03f, -5.86976893e-02f, 7.21392361e-03f,
  4.68219593e-02f, -1.88780285e-03f, 5.57546243e-02f, -6.23313934e-02f, -5.86370751e-02f, -1.65208057e-02f, -1.14910871e-01f, 3.85557376e-02f, 9.17838439e-02f, 1.96074337e-01f,
  -3.75065170e-02f, -4.90131490e-02f, 8.34422931e-02f, 1.14513133e-02f, 2.21828558e-02f, 9.01699737e-02f, 1.37639955e-01f, -1.84734687e-01f, -3.22152004e-02f, -5.48240133e-02f,
  1.13156952e-01f, 3.36748436e-02f, -2.65614033e-01f, -4.19337451e-02f, 7.75667503e-02f, 1.39049217e-01f, -6.58900887e-02f, -1.33957937e-01f, -1.76380724e-01f, 1.16154132e-02f,
  -1.28106147e-01f, 2.22157598e-01f, 1.88043848e-01f, 9.06153489e-03f, -3.61894518e-02f, 6.80572316e-02f, 3.02009642e-01f, 2.57002294e-01f, 8.54884535e-02f, 1.59108981e-01f,
  -1.66433752e-01f, -2.83700174e-05f, 1.42915905e-01f, -1.87269151e-01f, -2.79463708e-01f, -2.41351932e-01f, 1.63676649e-01f, -1.70917623e-02f, 5.03867529e-02f, -4.61764708e-02f,
  2.39102483e-01f, 1.70003757e-01f, -1.17430255e-01f, 1.58243105e-01f, -3.53841148e-02f, 1.26613438e-01f, -4.41387743e-02f, 1.05613217e-01f, -8.00722688e-02f, -3.70533951e-02f,
  6.02330528e-02f, 2.32645385e-02f, -2.73736212e-02f, 4.93867137e-02f, -1.57582741e-02f, 9.07018632e-02f, -1.38929281e-02f, -5.44832461e-02f, -8.59092921e-02f, 1.75657198e-02f,
  -4.13071215e-02f, 1.75351501e-01f, 3.53517421e-02f, 3.25429924e-02f, -1.68342274e-02f, -2.06133220e-02f, -1.19058907e-01f, 2.15983421e-01f, -2.33514756e-02f, 3.94774973e-02f,
  -2.17031315e-01f, -9.07205716e-02f, -1.94682866e-01f, -3.47438991e-01f, 2.37813175e-01f, 1.30912527e-01f, 3.17294672e-02f, 2.24904612e-01f, -5.26132360e-02f, -1.94050089e-01f,
  2.40182310e-01f, 1.01109698e-01f, -8.43937173e-02f, -3.93862277e-03f, -1.29290894e-01f, 1.47235632e-01f, 1.03515662e-01f, -2.54186869e-01f, -2.02602834e-01f, -2.41009310e-01f,
  4.64282393e-01f, -6.41067773e-02f, 6.31430805e-01f, -5.15222773e-02f, -5.16770966e-02f, 1.38903588e-01f, -9.40853581e-02f, 3.14189464e-01f, -2.37283960e-01f, -1.78315461e-01f,
  1.34489268e-01f, -2.05135748e-01f, 1.59624606e-01f, -2.48787671e-01f, 3.57058346e-01f, 2.17867941e-01f, -1.23327695e-01f, 5.39312251e-02f, 4.27652057e-03f, 2.01203644e-01f,
  -2.01652199e-01f, 2.00241148e-01f, 1.49586098e-02f, 6.62856847e-02f, 1.38297483e-01f, 2.85604447e-02f, 1.77936777e-02f, 1.18538395e-01f, 2.50455420e-02f, 2.92241108e-02f,
  4.59023342e-02f, 6.41499236e-02f, -4.73944731e-02f, 2.08300948e-02f, -2.00748770e-03f, 1.49290953e-02f, 1.58788767e-02f, 1.23159564e-03f, 5.32850847e-02f, 4.24028262e-02f,
  3.87707837e-02f, -1.29414290e-01f, -3.27405035e-02f, 2.37724572e-01f, 1.26875579e-01f, -5.18891364e-02f, -1.39344350e-01f, -3.22018489e-02f, 4.54591960e-02f, 7.95937553e-02f,
  -2.44084686e-01f, -3.62107456e-02f, -1.92619950e-01f, 3.10833822e-03f, -2.07724851e-02f, -6.59173205e-02f, 3.75574245e-03f, -3.47830839e-02f, -9.55054536e-02f, 7.26525709e-02f,
  1.28240049e-01f, -2.52151102e-01f, -8.92278105e-02f, 1.08193256e-01f, 2.99614519e-01f, 3.04111481e-01f, 1.89222842e-01f, -4.96385023e-02f, 4.53929277e-03f, -4.46897857e-02f,
  1.62586182e-01f, -1.23783745e-01f, -8.43016282e-02f, -1.55711234e-01f, 1.11409821e-01f, 9.60414261e-02f, 1.35030806e-01f, -1.46538213e-01f, 1.33545384e-01f, 1.16457172e-01f,
  -1.57904163e-01f, -2.49591589e-01f, 2.14079082e-01f, -7.80337080e-02f, 1.29290253e-01f, 2.46519536e-01f, 8.35800767e-02f, -1.91373974e-02f, 6.42317608e-02f, 6.39666766e-02f,
  1.96593985e-01f, 1.42340735e-01f, 1.34223402e-01f, 1.36528254e-01f, 2.02192903e-01f, 2.43723929e-01f, 1.09081104e-01f, 1.17430441e-01f, 1.03648014e-01f, -1.20080383e-02f,
  1.02203682e-01f, -1.68244429e-02f, 1.36107758e-01f, 6.62420467e-02f, 1.05146162e-01f, 4.37807068e-02f, -4.06503379e-01f, -7.94103891e-02f, -2.32452035e-01f, -1.46675408e-01f,
  -7.57919401e-02f, 3.05752456e-01f, 2.20762178e-01f, 7.02511966e-02f, 2.44773924e-01f, -1.86289430e-01f, 1.80910587e-01f, -4.40765684e-03f, -1.18120275e-02f, 7.46974349e-02f,
  3.10356263e-02f, 1.41283229e-01f, 1.99233413e-01f, -3.71025354e-02f, 3.37439358e-01f, 3.20948988e-01f, 4.58215386e-01f, -2.50493903e-02f, -3.37307230e-02f, -9.12178960e-03f,
  -2.10242327e-02f, -2.46589839e-01f, 2.68756300e-01f, 3.76352593e-02f, 3.86934797e-03f, 2.10081995e-01f, 1.65743142e-01f, 1.58128232e-01f, 2.16468155e-01f, 1.70026869e-01f,
  -3.60563666e-01f, 2.72440255e-01f, -2.45479718e-01f, -3.22655141e-02f, 2.88021445e-01f, 1.24046415e-01f, 2.82412738e-01f, -2.65581518e-01f, 1.45268232e-01f, 2.66246468e-01f,
  -9.21570510e-02f, -1.21983076e-02f, 2.11161864e-03f, 7.34661531e-04f, 1.11768976e-01f, -1.62214264e-02f, -1.85053889e-02f, 9.27197689e-04f, 9.83308256e-03f, -1.00945488e-01f,
  -4.41819280e-02f, -4.93319593e-02f, 1.72592372e-01f, 9.44799837e-03f, -6.21437393e-02f, -2.11615413e-01f, -8.81755129e-02f, -1.54345399e-02f, -5.41273691e-02f, 2.13116422e-01f,
  -6.06503598e-02f, -1.14023454e-01f, -2.12135598e-01f, 1.84803486e-01f, -7.73724392e-02f, -2.30723992e-02f, 6.43679649e-02f, 2.74572581e-01f, 2.14476958e-01f, 1.11768506e-01f,
  -1.24031678e-01f, -1.19119816e-01f, 3.47159952e-02f, 2.21425861e-01f, 1.43660620e-01f, -1.73262227e-02f, -4.89423946e-02f, 7.07065985e-02f, 2.52778437e-02f, -7.32483193e-02f,
  3.58749740e-02f, -1.41029462e-01f, 1.08502276e-01f, -2.28879452e-02f, 3.51750672e-01f, -2.95273177e-02f, 8.54899436e-02f, 2.12648243e-01f, 7.24063963e-02f, 3.73307109e-01f,
  6.98392093e-02f, 2.80090898e-01f, -1.11552626e-01f, -1.31208509e-01f, -1.17966026e-01f, -2.53229700e-02f, 7.75865391e-02f, -1.55288905e-01f, 9.47482698e-03f, -3.31305340e-02f,
  9.02496129e-02f, 2.48014316e-01f, 5.30701652e-02f, 1.07898332e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  6.78618550e-02f, -9.61510651e-03f, 1.44892126e-01f, 1.94214601e-02f, -7.00298557e-03f, 3.39808054e-02f, 9.26664472e-02f, 3.67574282e-02f, 9.31890681e-02f, 2.78285854e-02f,
  9.03056487e-02f, 1.08036689e-01f, 1.14286512e-01f, 5.86648136e-02f, 4.29809559e-03f, 9.10094827e-02f, -3.12132519e-02f, 2.81803943e-02f, 8.21135193e-02f, 1.71212070e-02f,
  2.73320302e-02f, 1.82191702e-03f, 6.26147771e-03f, 3.20503041e-02f, 5.33798933e-02f, 5.59200533e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -4.51952219e-02f, -1.23657823e-01f, -8.26530531e-02f, -2.39064336e-01f, -6.06064871e-02f, 1.10567197e-01f, 1.03800438e-01f, -1.66701034e-01f, 1.10429317e-01f, -4.30615842e-02f,
  7.91329443e-02f, -1.47311822e-01f, 3.92684788e-02f, -3.77385207e-02f, -3.73270623e-02f, -2.74616946e-03f, 1.30598396e-01f, -2.37102490e-02f, 6.58808053e-02f, -2.07011580e-01f,
  -1.95219472e-01f, 3.70931514e-02f, -1.40487716e-01f, -1.29773661e-01f, -2.41164759e-01f, 1.77322164e-01f, 3.53212766e-02f, -1.24866098e-01f, 1.12954639e-01f, 2.16772370e-02f,
  -7.53543675e-02f, 1.58825904e-01f, -1.35780439e-01f, 5.90611808e-02f, 3.62353832e-01f, -5.46168583e-03f, -9.31128263e-02f, 1.00397609e-01f, 1.46578789e-01f, -1.59685314e-01f,
  2.30749816e-01f, 1.11536318e-02f, -4.54528183e-01f, -4.21011329e-01f, 9.81720611e-02f, 3.55490744e-01f, -1.25469714e-01f, -1.79791942e-01f, -3.44713451e-03f, -4.35095519e-01f,
  1.64825723e-01f, -1.98641811e-02f, 1.45781428e-01f, 9.80773941e-03f, 1.70225665e-01f, -2.21422523e-01f, -5.56283712e-01f, 4.59724933e-01f, -6.07507080e-02f, 1.03460796e-01f,
  -2.91862369e-01f, 1.50340751e-01f, -7.57398382e-02f, -3.34141523e-01f, 3.21044214e-02f, -2.92971246e-02f, 7.25111589e-02f, -2.02243254e-01f, 7.49292001e-02f, 1.02323927e-01f,
  -2.16897085e-01f, 7.64419809e-02f, 8.90879631e-02f, -2.78332621e-01f, 3.84534746e-02f, 8.98793414e-02f, 5.57940628e-04f, -3.61447483e-02f, 9.91233997e-03f, -1.98779240e-01f,
  1.08247109e-01f, 5.90963103e-02f, -1.96250051e-01f, 1.81064770e-01f, 2.57102966e-01f, 2.22516745e-01f, -8.50399360e-02f, -3.23339790e-01f, -1.11319669e-01f, -5.87812029e-02f,
  4.14698683e-02f, -1.37735046e-02f, 1.61229476e-01f, 2.26197034e-01f, 2.20334783e-01f, -1.75179705e-01f, 8.17661285e-02f, 1.22968838e-01f, 2.19510734e-01f, 4.14341465e-02f,
  -1.20864160e-01f, -2.43458107e-01f, -3.97643030e-01f, 1.78814203e-01f, 2.02565536e-01f, -2.18670219e-01f, -1.64794832e-01f, 4.08515483e-02f, 8.30760226e-02f, 3.11110109e-01f,
  7.78990164e-02f, 1.82084851e-02f, 9.30462703e-02f, -5.06163895e-01f, 3.10552627e-01f, -6.43460974e-02f, -1.17132567e-01f, 2.04806656e-01f, -2.50046719e-02f, 7.58419605e-03f,
  -6.02655709e-02f, -3.67696345e-01f, -4.49981660e-01f, -3.82663816e-01f, -3.34096193e-01f, -1.41423583e-01f, 2.40651131e-01f, 1.22395076e-01f, -1.68540522e-01f, -5.32582477e-02f,
  -5.86852394e-02f, 1.66676581e-01f, -1.89694483e-02f, 3.62669267e-02f, 7.87763968e-02f, -2.13073909e-01f, 5.26814573e-02f, 2.23054036e-01f, -9.49093141e-03f, -2.80639995e-02f,
  -1.53340310e-01f, -7.53837526e-02f, 6.56539723e-02f, 5.49563728e-02f, 5.94838336e-02f, -1.27447769e-02f, 5.50982021e-02f, -1.96405143e-01f, -1.62473053e-01f, -2.97621459e-01f,
  -1.28530979e-01f, 1.60940543e-01f, 2.55004279e-02f, 1.78134739e-01f, 3.16598788e-02f, 1.35149762e-01f, -1.30395278e-01f, 2.32107624e-01f, -1.64873108e-01f, -1.30623370e-01f,
  1.77696452e-01f, -2.24774942e-01f, 3.17828171e-02f, -3.89156863e-02f, 2.82626182e-01f, -1.64383888e-01f, -3.49323928e-01f, 4.06795666e-02f, -7.50547333e-04f, -2.05406979e-01f,
  -3.94483298e-01f, -3.55524421e-01f, 2.62443185e-01f, -1.86980397e-01f, 2.86536515e-01f, -9.13074389e-02f, -1.31075799e-01f, -9.78892073e-02f, 1.36002963e-02f, -6.63063943e-01f,
  -5.49985051e-01f, 7.41612762e-02f, -4.99260515e-01f, 1.81486174e-01f, 8.99318308e-02f, -6.71274215e-02f, -4.59425420e-01f, -3.52538258e-01f, 3.80977452e-01f, -3.01628243e-02f,
  -1.51890904e-01f, 3.43977988e-01f, -7.12129250e-02f, 1.61761791e-01f, 7.81422481e-03f, -1.19698092e-01f, -1.78799689e-01f, 7.94461370e-02f, -6.35958835e-02f, 1.13289900e-01f,
  -1.64725840e-01f, -2.32681558e-01f, -6.34653354e-03f, 8.75308439e-02f, -1.79455146e-01f, 1.02657571e-01f, 1.15344569e-01f, -2.52827018e-01f, -2.41080439e-03f, -3.91997099e-02f,
  1.73133854e-02f, -7.17765167e-02f, -8.44258368e-02f, 2.25663379e-01f, -2.03341067e-01f, 2.96102077e-01f, 6.32977784e-02f, -2.18541890e-01f, 1.46121532e-01f, 2.62499571e-01f,
  -1.47724956e-01f, -6.75829276e-02f, -1.43719479e-01f, 7.47132674e-02f, 4.41763438e-02f, 1.53887123e-01f, -1.30766407e-01f, -1.27021447e-01f, 2.13516548e-01f, -1.71251401e-01f,
  2.39459231e-01f, -2.83489048e-01f, -3.44244063e-01f, 1.95664957e-01f, -4.54237163e-01f, 4.16162908e-02f, -4.16192979e-01f, -6.50708228e-02f, -3.98491055e-01f, -2.68345267e-01f,
  5.15732840e-02f, 6.28824160e-02f, -5.21899700e-01f, 7.81073719e-02f, 2.93138891e-01f, -1.85156003e-01f, -2.73085952e-01f, 1.59939229e-01f, -3.56572300e-01f, 4.38618064e-01f,
  1.68962121e-01f, 2.22056988e-03f, 1.26945153e-01f, 1.95837393e-01f, -5.44281244e-01f, -3.05805117e-01f, 1.63352877e-01f, -1.55894473e-01f, 1.48484120e-02f, 2.59251267e-01f,
  1.17289707e-01f, 1.34033859e-01f, 1.75384805e-01f, 1.14387073e-01f, 1.29837826e-01f, 2.90744513e-01f, -2.42284715e-01f, 1.68678388e-01f, -2.46424004e-01f, -6.00568317e-02f,
  -2.58204758e-01f, -9.53893885e-02f, 5.45386113e-02f, -1.62409171e-01f, -2.03263417e-01f, -2.00079888e-01f, 1.09043285e-01f, 1.43238202e-01f, 3.42934504e-02f, -2.25943744e-01f,
  -1.54247582e-01f, 2.62293249e-01f, 8.64158422e-02f, -2.12126806e-01f, 3.40621978e-01f, 2.04750672e-02f, 2.61881918e-01f, 4.49788980e-02f, -1.18399207e-02f, 5.37033640e-02f,
  -3.22867841e-01f, -1.22992277e-01f, -3.91310185e-01f, 6.89399615e-02f, 2.16341600e-01f, -2.35422105e-01f, -6.11991771e-02f, 1.22767799e-01f, 8.97677913e-02f, 7.67978504e-02f,
  -4.17576313e-01f, -2.56215572e-01f, -1.45726994e-01f, -1.59637675e-01f, 1.03642672e-01f, -2.08778251e-02f, 1.57652602e-01f, -1.85101017e-01f, 2.38395527e-01f, 2.69367725e-01f,
  6.26530647e-02f, -2.11346149e-01f, 2.33468279e-01f, -1.70614988e-01f, 8.47779661e-02f, 4.76269349e-02f, -4.95520175e-01f, 1.87838376e-01f, -7.32892677e-02f, -2.08047137e-01f,
  9.36294347e-02f, 7.12659359e-02f, -3.70916352e-02f, 1.04184985e-01f, -1.09944090e-01f, -1.87200755e-01f, -1.28131896e-01f, -1.00123182e-01f, 1.28630802e-01f, -3.02051324e-02f,
  6.18412085e-02f, -1.30328432e-01f, 5.33671938e-02f, -1.33543713e-02f, 1.38115719e-01f, 1.26819285e-02f, -1.98276654e-01f, 2.00217709e-01f, 1.85674056e-01f, 1.67838961e-01f,
  -1.23660587e-01f, 1.85307249e-01f, -2.48110875e-01f, -2.36530259e-01f, 2.24725142e-01f, -5.73633760e-02f, 1.24281839e-01f, 6.22349568e-02f, 2.65624791e-01f, -3.22049946e-01f,
  -8.82295445e-02f, -1.68045625e-01f, -1.41668588e-01f, 4.90563922e-02f, 1.42308742e-01f, 2.48157054e-01f, 8.78545735e-03f, 4.48801294e-02f, 1.32603779e-01f, -9.64157507e-02f,
  5.53581789e-02f, -2.57116675e-01f, -9.93862450e-02f, -4.24466103e-01f, 1.01939134e-01f, -1.49335206e-01f, 7.20899105e-02f, -4.73132916e-02f, -2.24802732e-01f, 2.68876497e-02f,
  8.12814310e-02f, 1.79896444e-01f, 1.10472560e-01f, -4.20806587e-01f, 3.28578889e-01f, 1.13003895e-01f, 1.15076058e-01f, -3.48295808e-01f, 4.12745327e-02f, -1.85796976e-01f,
  -3.78680438e-01f, -2.85298556e-01f, 3.09303075e-01f, -3.30395788e-01f, -2.85150915e-01f, -3.94608267e-02f, -1.47332862e-01f, -1.20129175e-01f, -1.50592113e-02f, -1.97370514e-01f,
  -2.02834427e-01f, 9.63160470e-02f, -5.77749684e-02f, -1.11904023e-02f, -6.84637725e-02f, 9.10097733e-02f, -1.21963218e-01f, -8.10996592e-02f, -1.06326431e-01f, -6.21881448e-02f,
  -9.26673040e-02f, -2.49433845e-01f, -3.12780067e-02f, 4.51880470e-02f, 2.72549450e-01f, -2.60428458e-01f, 8.41511339e-02f, 3.38750333e-01f, 1.06701240e-01f, 1.14491545e-01f,
  -2.94719219e-01f, -2.14708254e-01f, -1.90027356e-01f, -1.25351340e-01f, 2.39440471e-01f, -3.00603896e-01f, -8.91490057e-02f, -2.78818101e-01f, -8.29086304e-02f, 1.77818444e-02f,
  1.11647867e-01f, 2.71615416e-01f, -1.12851121e-01f, 1.30554378e-01f, -4.76355612e-01f, -2.46564478e-01f, -2.09524319e-01f, -1.99014574e-01f, 1.87238064e-02f, -1.08082741e-01f,
  1.96036234e-01f, -1.49684235e-01f, -4.84754205e-01f, 2.21068427e-01f, -3.31455886e-01f, -9.59559903e-02f, -3.61526817e-01f, -5.10464191e-01f, 1.19159564e-01f, 1.50071099e-01f,
  2.71613508e-01f, -4.58602514e-03f, -6.14105985e-02f, 1.93344355e-01f, 2.63873100e-01f, -1.73160490e-02f, 1.00482203e-01f, 9.51054618e-02f, -1.39923170e-01f, 4.42209607e-03f,
  -9.13458914e-02f, 4.56704497e-02f, 4.62633092e-03f, -6.06254265e-02f, -1.32234350e-01f, -7.66049176e-02f, -4.14386317e-02f, 1.47289872e-01f, -1.14937052e-01f, -1.52162597e-01f,
  1.94775462e-01f, -6.50621578e-02f, -1.60947084e-01f, 1.79064840e-01f, 6.97806776e-02f, 4.43410911e-02f, -7.12788403e-02f, -7.97832385e-02f, -1.43670276e-01f, 1.17540091e-01f,
  -1.67457148e-01f, 1.75621137e-02f, -2.70571679e-01f, -2.08622143e-01f, -2.16445416e-01f, 1.25516474e-01f, -1.74774960e-01f, -1.26318991e-01f, -2.28274569e-01f, -2.34912708e-01f,
  2.27999493e-01f, 5.62715195e-02f, 2.28989527e-01f, -1.94254264e-01f, -1.87505528e-01f, 7.04518631e-02f, -4.07112211e-01f, -1.28221482e-01f, -2.41139099e-01f, 1.97352871e-01f,
  2.51260459e-01f, 1.91876158e-01f, -1.58769026e-01f, -1.76170558e-01f, -2.06419379e-01f, -1.58505008e-01f, 3.03430241e-02f, 1.79371700e-01f, -3.00288677e-01f, 1.25494562e-02f,
  -3.01450253e-01f, 2.64612198e-01f, -4.10972476e-01f, 1.19720548e-01f, -2.19304830e-01f, 4.84819651e-01f, 1.98823921e-02f, -4.94081795e-01f, -2.56058514e-01f, -8.35374463e-03f,
  2.03654710e-02f, -5.54799810e-02f, -1.63946867e-01f, -1.45631447e-01f, 4.72622886e-02f, 1.08941980e-01f, -9.14081186e-02f, -1.73204705e-01f, -5.23868762e-02f, -1.39343917e-01f,
  -1.63795680e-01f, 9.75076482e-02f, 1.17683798e-01f, -9.87792611e-02f, 1.29910544e-01f, -1.20900273e-01f, 2.23561972e-02f, 1.22089349e-02f, -1.01503640e-01f, -1.43921364e-03f,
  2.39124727e-02f, 7.25873932e-02f, -1.38013154e-01f, -3.89618464e-02f, 2.08207548e-01f, 1.67285651e-01f, 8.39340016e-02f, 1.19533598e-01f, -1.67766184e-01f, 8.48461911e-02f,
  2.74150401e-01f, 4.40917313e-02f, -2.56256521e-01f, 4.00120802e-02f, 2.04008669e-01f, 1.20120607e-01f, -2.71236271e-01f, -1.99550152e-01f, -2.39603996e-01f, -2.35992387e-01f,
  -3.41763020e-01f, 2.28134826e-01f, 1.40055731e-01f, -2.03769773e-01f, 1.18230335e-01f, -9.90293473e-02f, -2.95366585e-01f, -1.79260209e-01f, 1.31045446e-01f, 3.79114211e-01f,
  -1.68584451e-01f, 2.51423120e-02f, -3.09760958e-01f, 3.69387150e-01f, -3.60175133e-01f, -1.21903986e-01f, -9.23478529e-02f, -4.45394993e-01f, 1.55760003e-02f, -1.25290796e-01f,
  -9.93068963e-02f, -1.87449127e-01f, -1.08439170e-01f, -2.82159120e-01f, -3.42077076e-01f, 1.71833038e-01f, -2.06929445e-02f, 2.11615920e-01f, 8.12253281e-02f, -1.19255744e-01f,
  -2.11666785e-02f, 1.32007435e-01f, 1.20514013e-01f, 1.76036835e-01f, -2.31896296e-01f, -2.12101359e-02f, 2.04695970e-01f, -2.89862640e-02f, 2.03975618e-01f, 4.94147986e-02f,
  2.38426384e-02f, 4.35774103e-02f, 1.32225111e-01f, 1.60326153e-01f, 2.33786583e-01f, 2.65054256e-01f, 7.12981448e-03f, -1.92352816e-01f, 3.27668518e-01f, 5.31360991e-02f,
  2.06918195e-01f, -6.57486171e-02f, -2.60546245e-02f, -2.43503675e-01f, -2.32150495e-01f, 2.26223618e-02f, 2.09944546e-01f, 1.37132406e-01f, -1.95345327e-01f, 2.62710541e-01f,
  -9.57456976e-02f, 2.96838105e-01f, 3.07965249e-01f, 1.10152856e-01f, -3.01700920e-01f, -4.16133195e-01f, -3.77839476e-01f, 1.69901341e-01f, 3.42999220e-01f, 1.87752694e-01f,
  1.54156268e-01f, -1.86022952e-01f, -1.65180728e-01f, -4.29228783e-01f, 3.34040844e-03f, 2.66479179e-02f, -4.99182269e-02f, -6.29549444e-01f, -4.33954209e-01f, 1.98641524e-01f,
  -1.91683084e-01f, -1.97678328e-01f, 2.70470709e-01f, -6.54097736e-01f, -7.79096186e-02f, -9.41841584e-03f, 1.24350548e-01f, 2.19232216e-01f, 2.38874972e-01f, -3.47990356e-02f,
  3.05277221e-02f, -4.85274568e-03f, -4.91709188e-02f, -7.48802051e-02f, 8.75644311e-02f, 1.24885067e-01f, 1.20681703e-01f, 1.42074138e-01f, 4.24860530e-02f, 7.42223114e-03f,
  -1.63325500e-02f, 8.99598449e-02f, -1.06620543e-01f, 5.01327179e-02f, -8.23487341e-02f, 3.94517183e-02f, 1.46215893e-02f, 1.54434061e-02f, -2.05156133e-01f, 5.40952571e-02f,
  1.77641213e-01f, -2.14122668e-01f, -8.52009058e-02f, -5.07255644e-02f, 5.36056757e-02f, -1.21448096e-03f, -3.43079939e-02f, 1.40728831e-01f, -2.73884922e-01f, 2.14647338e-01f,
  -2.55131572e-01f, 1.54599063e-02f, -1.17687225e-01f, -2.32765123e-01f, -1.95818737e-01f, -1.41140804e-01f, 2.48822033e-01f, 2.00323090e-02f, 2.04630688e-01f, 1.97967783e-01f,
  2.76635915e-01f, -2.34263808e-01f, -3.56830448e-01f, -7.38139525e-02f, 1.95555463e-01f, -2.91468769e-01f, -1.18622683e-01f, 8.04440677e-02f, 2.80168980e-01f, 8.06866307e-03f,
  -1.90020666e-01f, -1.69654354e-01f, -2.04708651e-02f, 1.62445102e-02f, 1.78529054e-01f, -6.30023191e-03f, -3.60447407e-01f, -3.92715901e-01f, -1.29205901e-02f, 2.62840152e-01f,
  2.41944477e-01f, 2.18211889e-01f, -4.65254992e-01f, -2.60667831e-01f, 7.14258328e-02f, 5.59566319e-02f, 1.12809740e-01f, 4.55760695e-02f, 3.04235891e-02f, -1.75431848e-01f,
  1.35870218e-01f, -1.89468145e-01f, -1.66032895e-01f, 7.82117099e-02f, -1.07519902e-01f, -9.66256708e-02f, -4.22512740e-02f, 5.26615717e-02f, 1.48130983e-01f, 5.55816479e-02f,
  -1.58656150e-01f, 4.75091860e-02f, -1.26053825e-01f, -2.35149488e-01f, -2.77765635e-02f, 1.36056403e-02f, 1.95638001e-01f, -6.49354532e-02f, 4.99836095e-02f, -2.71426737e-01f,
  2.16285467e-01f, 2.79291660e-01f, -1.16271406e-01f, 1.15211263e-01f, 1.62272036e-01f, 2.52765208e-01f, 2.14738220e-01f, 7.50230253e-02f, 1.23780012e-01f, 1.71655685e-01f,
  -1.77854583e-01f, 1.88253358e-01f, 2.12177075e-02f, -4.15129304e-01f, -2.06568405e-01f, 2.28324602e-03f, 1.18855022e-01f, 4.40178104e-02f, 2.50825901e-02f, -3.49114873e-02f,
  -3.89970392e-01f, 2.03998342e-01f, -3.68695498e-01f, 1.73780769e-01f, -4.44907844e-01f, 3.38065416e-01f, -3.43257695e-01f, -3.79494071e-01f, 1.42683193e-01f, 1.50755197e-01f,
  5.29401675e-02f, -3.72950405e-01f, 1.98844925e-01f, 3.53530496e-02f, -1.07324861e-01f, -1.59937888e-01f, -3.52783889e-01f, -6.01940513e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -6.51369169e-02f, 9.21924338e-02f, 7.10538868e-03f, 2.80639878e-03f, 1.82296801e-02f, 6.77247122e-02f, 4.31582853e-02f, -1.48368319e-02f, -7.83279464e-02f, -1.91152096e-02f,
  3.32169980e-02f, 6.65143877e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    