/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.82742625e-01f, -3.22071880e-01f, -2.61271089e-01f, 7.09786862e-02f, 7.19131380e-02f, -2.39824317e-02f, 2.32607991e-01f, -3.21216732e-01f, -1.39950335e-01f, 5.18590659e-02f,
  1.44865885e-01f, -9.41155776e-02f, 6.77407384e-02f, 1.08510770e-01f, 1.87770694e-01f, 1.14441536e-01f, 4.21456397e-02f, 1.47033297e-02f, -1.22792661e-01f, -1.12185240e-01f,
  1.10313809e-02f, 1.06747329e-01f, 1.45792365e-01f, -1.77164942e-01f, 2.33895294e-02f, -1.52911350e-01f, 2.02601463e-01f, -9.07666758e-02f, -4.20925356e-02f, -1.22778052e-02f,
  1.53317600e-01f, -3.79991978e-02f, 3.05050798e-02f, -6.55386895e-02f, 6.65805191e-02f, 3.97756435e-02f, 1.89260747e-02f, 3.66836414e-02f, 2.77040191e-02f, 3.36112455e-02f,
  5.37378863e-02f, -9.41638183e-03f, -3.65664437e-02f, -5.78387156e-02f, -2.64653116e-02f, 6.09928854e-02f, -7.78740123e-02f, -6.12426177e-02f, -6.77497825e-03f, 8.08717310e-02f,
  3.48537304e-02f, 1.62099283e-02f, -2.08027661e-02f, -1.80994850e-02f, 1.25461705e-02f, -5.43827191e-02f, 4.29663770e-02f, 2.79324898e-03f, -1.42937582e-02f, -4.55825850e-02f,
  -3.15866023e-02f, -3.63571085e-02f, -9.65928938e-03f, 3.38061601e-02f, -3.09920078e-03f, -2.05229651e-02f, 4.23134416e-02f, 9.87395272e-02f, -1.54681951e-02f, 3.85514610e-02f,
  2.33626720e-02f, 3.24060284e-02f, -6.31879866e-02f, 3.85570191e-02f, -3.12582264e-03f, 1.37721794e-02f, 5.39197661e-02f, -2.87043974e-02f, -1.08658290e-02f, 6.16081320e-02f,
  -3.94947967e-03f, -3.65252560e-03f, -2.06012744e-03f, 5.41568957e-02f, -5.08428290e-02f, 6.68853745e-02f, -9.24812816e-03f, 2.09663417e-02f, 5.37135638e-02f, 5.38254865e-02f,
  -5.55490516e-02f, -3.07514280e-01f, -7.47782551e-03f, 2.47515440e-02f, -2.42502447e-02f, 3.15039121e-02f, -4.11556363e-02f, 1.30486340e-04f, -5.94642647e-02f, -3.41247208e-02f,
  -3.76295224e-02f, 4.92628925e-02f, -2.36329399e-02f, 5.55283055e-02f, 2.65583978e-04f, -7.21155480e-02f, 2.62150783e-02f, -2.30631605e-03f, 1.47861224e-02f, -2.80100480e-02f,
  7.35472217e-02f, -1.30361579e-02f, 1.37664936e-03f, -1.85311716e-02f, 5.68132624e-02f, 1.15050361e-01f, -6.11266904e-02f, 1.04315905e-03f, 4.95717190e-02f, 2.22294368e-02f,
  -9.67631936e-02f, 4.32838425e-02f, 2.31144607e-01f, -4.64561470e-02f, 5.62419444e-02f, 4.80370671e-01f, 4.68747228e-01f, 2.70094313e-02f, 1.58141300e-01f, 4.33108434e-02f,
  5.73817380e-02f, -7.02859759e-02f, 9.46237966e-02f, 1.16389930e-01f, 3.91303301e-01f, 3.68341595e-01f, 1.96242616e-01f, 7.12734014e-02f, 3.14086787e-02f, 1.39030954e-02f,
  1.02993824e-01f, 1.31641090e-01f, 1.14505060e-01f, -4.03300487e-03f, 1.91640221e-02f, -1.96082979e-01f, -2.31212154e-01f, -8.33057314e-02f, -8.31326544e-02f, 4.68909880e-03f,
  1.69740230e-01f, -5.70019260e-02f, -7.35372538e-04f, 8.15950148e-03f, 1.09054744e-02f, -2.28264388e-02f, -7.65869915e-02f, 4.18240055e-02f, -1.01211309e-01f, -2.41699209e-03f,
  6.69233035e-03f, -3.24616916e-02f, -7.94891268e-04f, 3.75731266e-03f, 1.03768837e-02f, -7.17412541e-03f, -3.53447488e-03f, 3.66956950e-03f, -9.11834650e-03f, 3.16860452e-02f,
  -2.13486329e-03f, 1.16398651e-02f, -2.65275985e-02f, 8.91833231e-02f, 3.52044194e-03f, 1.15650019e-03f, 6.25494123e-02f, 1.74192265e-02f, 1.30878249e-03f, -6.96709566e-03f,
  -2.07996070e-02f, -1.24822827e-02f, 2.35464089e-02f, -3.46768200e-02f, 2.93219346e-03f, -7.42849708e-02f, 3.85427512e-02f, -8.24370235e-03f, 1.89833809e-03f, 5.60784861e-02f,
  4.97937649e-02f, -2.86601894e-02f, 2.64744833e-03f, 3.86614874e-02f, 2.92147580e-03f, -3.10762972e-02f, 9.15391254e-04f, 3.64134274e-03f, 5.09351157e-02f, 1.67779848e-02f,
  -4.10584180e-04f, 1.69616975e-02f, -4.98484224e-02f, -5.30396961e-03f, 8.01775325e-03f, -4.14595790e-02f, -3.40931816e-03f, -4.45023105e-02f, -3.05467285e-03f, 2.28790734e-02f,
  1.33978188e-01f, -4.90146130e-02f, 6.59425184e-03f, 4.02780110e-03f, -3.35102193e-02f, -6.20515570e-02f, 8.11642855e-02f, -4.42143390e-03f, 8.40763822e-02f, 4.37828228e-02f,
  -3.87453921e-02f, -1.42682614e-02f, 3.33047993e-02f, -7.24933459e-04f, -3.58582288e-02f, -3.36889103e-02f, -3.73749286e-02f, -1.64483115e-02f, 2.96099111e-03f, -8.71568918e-02f,
  -6.89752027e-02f, -4.79638055e-02f, -1.15825534e-02f, 1.84404161e-02f, 1.78213418e-02f, 3.59460190e-02f, -2.67435554e-02f, 1.17921792e-02f, -3.01099177e-02f, 4.64771092e-02f,
  4.32703376e-01f, -1.73881367e-01f, 3.93069029e-01f, 5.49143888e-02f, 5.64682335e-02f, -1.37567014e-01f, -6.03639893e-02f, -1.21760912e-01f, -3.17557296e-03f, -2.51919597e-01f,
  -9.58015546e-02f, 2.16699974e-03f, -1.54971704e-01f, -1.34388685e-01f, 2.39193976e-01f, -1.52998850e-01f, -5.76549545e-02f, -9.82778221e-02f, 2.86354814e-02f, -8.22769478e-02f,
  -2.54492019e-03f, -1.74972132e-01f, 5.90768130e-03f, -1.83896169e-01f, 6.81787590e-03f, 5.28680384e-02f, -1.49603672e-02f, -5.59140742e-02f, -7.25059882e-02f, -4.35145013e-02f,
  1.11785181e-01f, -7.34625105e-03f, 1.23930238e-01f, 5.04616275e-02f, 5.15495427e-02f, -1.50533132e-02f, 5.59422374e-02f, 3.96120511e-02f, -3.17898169e-02f, -4.09354828e-02f,
  -1.11807417e-03f, -1.70675700e-03f, 9.87075921e-03f, 6.03752024e-02f, 1.43719185e-02f, 8.62251073e-02f, -4.78212126e-02f, -3.96477766e-02f, -7.37923309e-02f, -8.29561614e-03f,
  -1.96249876e-02f, 1.71440970e-02f, 1.74780395e-02f, -2.67524440e-02f, 3.46137360e-02f, 4.56303358e-02f, -1.66529901e-02f, 1.68005507e-02f, 1.75515804e-02f, -2.43581254e-02f,
  -7.24127740e-02f, -1.48523644e-01f, -3.99125293e-02f, 5.30511364e-02f, 2.23687151e-03f, -3.17825973e-02f, -7.27950856e-02f, -2.52311025e-03f, -1.33985281e-02f, 2.88223680e-02f,
  1.35293715e-02f, 6.17433488e-02f, -7.65202785e-05f, 1.49583044e-02f, -5.51515929e-02f, 3.96337695e-02f, 4.50188592e-02f, -8.84017870e-02f, -5.69651015e-02f, 3.52964886e-02f,
  -3.33608384e-03f, -3.74985859e-02f, -7.46870786e-02f, 1.13741700e-02f, 1.61320865e-02f, 4.81366031e-02f, -3.29046249e-02f, -1.12003395e-02f, 1.52709773e-02f, -8.62714648e-03f,
  -2.39375710e-01f, -2.96164334e-01f, -3.60791236e-02f, -2.56808065e-02f, -3.89008410e-02f, 6.19842000e-02f, -4.21016254e-02f, -3.31655629e-02f, -2.97440644e-02f, -4.10320703e-03f,
  6.99165743e-03f, 1.47538232e-02f, 1.05335163e-02f, -3.58676142e-03f, -2.55163759e-02f, -6.20329231e-02f, -7.86982328e-02f, -2.91038100e-02f, -8.48550629e-03f, -1.48234433e-02f,
  -1.96181261e-03f, -1.37605434e-02f, 7.49786347e-02f, 3.03877350e-02f, 2.94321980e-02f, 2.53898576e-02f, 1.90969575e-02f, 8.17289669e-03f, -6.53512552e-02f, 2.85502877e-02f,
  -3.34708959e-01f, -5.43782972e-02f, -3.33374977e-01f, -5.77931292e-02f, -8.25324506e-02f, -8.90876949e-02f, 4.83054928e-02f, -1.38942972e-01f, -2.15692654e-01f, 1.87574059e-01f,
  1.51839718e-01f, -1.72690198e-01f, 3.67564261e-02f, 4.68325391e-02f, -1.13681436e-01f, 4.86765150e-03f, 2.09865738e-02f, 3.73236760e-02f, -9.20839235e-02f, 6.84748264e-03f,
  -1.59764424e-01f, 1.62619427e-01f, -2.49109700e-01f, 1.08731546e-01f, -1.06587030e-01f, -1.41711654e-02f, 1.14243343e-01f, -5.77143542e-02f, 8.18359777e-02f, 8.67372658e-03f,
  -2.29156781e-02f, 4.08807863e-03f, -5.10090254e-02f, 4.30835485e-02f, 5.10166958e-03f, -2.69194483e-03f, 4.13825810e-02f, -7.50105269e-03f, -5.98187326e-03f, 3.31554301e-02f,
  2.57516261e-02f, -5.70642799e-02f, 1.99421868e-02f, -1.09815113e-02f, -4.66588028e-02f, -5.22219650e-02f, -8.89579579e-02f, -5.09191789e-02f, -8.44479129e-02f, -1.10804781e-01f,
  -9.87338722e-02f, -6.73401877e-02f, 1.90023668e-02f, 6.95080906e-02f, -6.25135452e-02f, 1.46720335e-02f, 1.71057396e-02f, -1.88960973e-02f, 9.78481863e-03f, -6.25022035e-03f,
  2.66812202e-02f, -6.38951957e-02f, -2.39411416e-03f, 2.19378211e-02f, 2.38402225e-02f, 3.50506678e-02f, -4.91455048e-02f, -9.18968435e-05f, -4.90622304e-04f, 5.00107557e-02f,
  3.90973389e-02f, -5.15094399e-03f, -1.51596265e-02f, -1.09466584e-02f, -5.88841364e-03f, 5.33713996e-02f, 2.69676633e-02f, 4.19899970e-02f, -5.40081859e-02f, -2.23174063e-03f,
  1.94046926e-02f, -4.07213345e-02f, -1.30211255e-02f, 1.03656277e-02f, 3.79301608e-02f, -3.00939400e-02f, -3.00826486e-02f, -4.96956035e-02f, -7.81632494e-04f, 1.11157459e-03f,
  1.75348535e-01f, 1.70411035e-01f, 1.85012221e-02f, -3.94580439e-02f, 2.12299321e-02f, 4.92044948e-02f, -6.14252314e-02f, -5.16777672e-03f, -7.92956352e-03f, 1.90429855e-02f,
  1.91661716e-03f, 5.04549965e-02f, 1.41210703e-03f, 1.59208644e-02f, -2.06840150e-02f, 5.71759790e-02f, 5.17974906e-02f, 6.45747110e-02f, 6.83424398e-02f, -2.76243854e-02f,
  3.62776741e-02f, 3.77701521e-02f, -2.41875462e-02f, -5.88589441e-03f, 1.17104597e-01f, -3.48113524e-03f, 4.96326853e-03f, 2.05870736e-02f, 3.70869897e-02f, -2.46793739e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.40373209e-01f, 8.14153329e-02f, -1.64188609e-01f, -1.30810067e-01f, -8.60878918e-03f, -3.17934006e-01f, -2.06202120e-01f, 3.86860222e-02f, 2.73996852e-02f, 1.20850302e-01f,
  2.27328315e-02f, 6.81556389e-02f, 8.41133371e-02f, -1.69243962e-01f, -2.67129511e-01f, -5.51332869e-02f, -3.91175628e-01f, -2.03296572e-01f, -1.09253591e-02f, -1.65435702e-01f,
  -8.65927041e-02f, -1.60188347e-01f, -1.86375141e-01f, 9.43161324e-02f, -1.23320274e-01f, 5.71997762e-02f, 3.82112451e-02f, 1.92211658e-01f, -1.48337230e-01f, 6.32825168e-03f,
  -6.38824627e-02f, -6.62716180e-02f, -7.40334243e-02f, -1.85559727e-02f, -1.49012357e-01f, -9.40729082e-02f, -7.62954876e-02f, -6.05930341e-03f, 4.40995358e-02f, -1.52407009e-02f,
  9.87367332e-02f, -2.07537077e-02f, 4.36127894e-02f, 9.58912820e-02f, 3.77680436e-02f, 6.01156875e-02f, -1.23014292e-02f, -7.07407966e-02f, -7.72072449e-02f, -3.74814346e-02f,
  -3.30973454e-02f, -8.55320785e-03f, -8.10623169e-02f, 2.00778376e-02f, 4.06446978e-02f, -1.24114174e-02f, -6.21152893e-02f, -6.39611483e-03f, -7.10035935e-02f, -3.24179698e-03f,
  -1.06827855e-01f, -1.70285925e-02f, -2.33950885e-03f, 2.55851187e-02f, 1.20306890e-02f, 1.59167661e-03f, 3.45186032e-02f, 3.53077538e-02f, 5.09172399e-03f, 2.83202138e-02f,
  -3.15262489e-02f, 1.90901291e-02f, 1.12730323e-03f, -6.31103814e-02f, 2.20921729e-03f, -1.87287871e-02f, -2.65676100e-02f, -6.02838583e-03f, -2.70186048e-02f, -5.49454540e-02f,
  2.51908824e-02f, -3.09113301e-02f, 7.18136430e-02f, 3.72347347e-02f, -6.26541302e-02f, 4.01505902e-02f, 4.77228388e-02f, -6.79500327e-02f, 6.77485391e-02f, 2.16006767e-03f,
  -1.26132682e-01f, -1.60087086e-02f, 1.36848669e-02f, -1.90914776e-02f, -1.46536715e-02f, -1.52757997e-02f, -2.84994207e-02f, -3.45019139e-02f, 1.09279202e-03f, -1.17550697e-02f,
  -4.45775464e-02f, -2.11035497e-02f, -8.06015432e-02f, -2.20097471e-02f, 3.89785059e-02f, -4.85307239e-02f, 4.73038759e-03f, 1.24100514e-01f, -5.75581342e-02f, 3.98775153e-02f,
  4.52770591e-02f, 1.19723845e-02f, 7.12391213e-02f, -9.35976282e-02f, -8.91907960e-02f, 5.57009913e-02f, -7.18128160e-02f, -6.41721785e-02f, -3.95293199e-02f, -6.82312064e-03f,
  9.30515885e-01f, -2.62434065e-01f, -2.26247549e-01f, 2.35870346e-01f, 3.83899271e-01f, 3.68013531e-01f, 1.64458260e-01f, 1.90933987e-01f, 1.61771238e-01f, -1.42369211e-01f,
  1.17671914e-01f, -1.70189857e-01f, -2.41014272e-01f, 2.44763136e-01f, 4.30083990e-01f, -1.89321190e-01f, 3.38039815e-01f, -5.99196414e-04f, 3.66983190e-02f, 1.36488490e-03f,
  1.44628674e-01f, 3.20370406e-01f, -1.20900899e-01f, 3.23032178e-02f, 1.38712347e-01f, -1.11142270e-01f, -8.49973410e-02f, -2.24002585e-01f, 7.11615160e-02f, 1.07361913e-01f,
  1.62666142e-01f, 3.95897627e-02f, -6.07440248e-04f, -5.07303923e-02f, 1.54486904e-02f, -3.15483063e-02f, -7.94287771e-02f, -6.84915110e-02f, -1.55168818e-02f, -7.13087320e-02f,
  -3.72674465e-02f, 4.71645407e-02f, 4.43588905e-02f, 1.88895091e-02f, 9.25545916e-02f, 4.87843677e-02f, 3.32698114e-02f, -2.54267007e-02f, -6.18294738e-02f, 5.43992817e-02f,
  -1.16798654e-03f, -1.56327114e-02f, 1.88284405e-02f, -7.67972320e-02f, -1.38338478e-02f, 7.35950395e-02f, -3.62053104e-02f, -6.19693063e-02f, 1.71999205e-02f, 1.06298953e-01f,
  9.45734456e-02f, -1.94794510e-03f, -2.98944470e-02f, 3.53947915e-02f, 3.51963565e-02f, 1.79112777e-02f, 2.85368576e-03f, 2.05887910e-02f, 4.07647192e-02f, -3.33707058e-03f,
  -1.62364088e-03f, 1.84662398e-02f, 1.48571999e-04f, 5.73710762e-02f, 7.77140725e-03f, 2.03636102e-02f, -2.96069309e-02f, -8.16340744e-03f, -7.05833780e-03f, -2.69395206e-03f,
  -1.45998672e-02f, 4.49379161e-02f, -6.61376864e-02f, 2.12629847e-02f, 2.10047867e-02f, -1.01155154e-02f, 3.62796187e-02f, -9.18774214e-03f, -5.38249649e-02f, -2.45995168e-02f,
  -9.39158648e-02f, -2.92683750e-01f, -5.81780560e-02f, 3.59263532e-02f, -4.35470231e-02f, 2.82117315e-02f, 2.54339408e-02f, 1.00062758e-01f, -2.62835026e-02f, 6.61767349e-02f,
  2.32275086e-03f, -8.05376191e-03f, -6.09929115e-03f, 6.13689376e-03f, -5.59280999e-02f, -1.72975510e-02f, -8.60845000e-02f, -2.13181153e-02f, -4.87399520e-03f, 1.54677068e-03f,
  -6.95380718e-02f, -4.41885262e-04f, -2.91794464e-02f, 1.72583889e-02f, 1.52853429e-02f, -6.65537864e-02f, 3.23426374e-03f, 6.10266859e-03f, -5.17493188e-02f, -5.83201349e-02f,
  -6.54323725e-03f, -2.43770108e-01f, 1.83899347e-02f, -8.01516771e-02f, 7.14150518e-02f, 1.01457402e-01f, 1.66880533e-01f, -2.76975036e-01f, -2.65139759e-01f, -2.81388462e-01f,
  3.17819836e-03f, 2.09101965e-03f, 1.43479750e-01f, -1.88488141e-01f, 3.23781192e-01f, 7.65648857e-02f, -7.74349123e-02f, -4.21148650e-02f, -1.17791496e-01f, -1.87378645e-01f,
  2.77532283e-02f, -1.74162477e-01f, 1.11011848e-01f, -1.21756606e-01f, -7.58893415e-02f, -1.21935137e-01f, -2.20887382e-02f, 1.25770703e-01f, -5.27853034e-02f, 1.04897179e-01f,
  -1.50121301e-01f, -2.05723688e-01f, -7.07358047e-02f, -5.87903187e-02f, -5.75316884e-02f, 5.33673391e-02f, 4.31516990e-02f, 1.83611646e-01f, 2.81065442e-02f, 3.97324972e-02f,
  -2.02656668e-02f, -2.39958558e-02f, -6.25464693e-02f, -4.28594388e-02f, -1.39646921e-02f, -6.50572553e-02f, -7.38686789e-03f, 2.81225946e-02f, -7.19662160e-02f, -1.03227878e-02f,
  -2.33319458e-02f, 6.74582040e-03f, -3.52934748e-02f, -4.85158376e-02f, 1.84107032e-02f, 1.70570184e-02f, -5.01013212e-02f, 3.69236469e-02f, -1.11308768e-02f, -1.87947061e-02f,
  1.41800225e-01f, 9.58597362e-02f, 4.79687452e-02f, -6.71599060e-02f, -1.40485456e-02f, 2.73163168e-04f, -2.79655971e-04f, -8.52095243e-03f, 5.39559387e-02f, -3.02303564e-02f,
  -2.27784384e-02f, 1.06606204e-02f, -1.17936684e-02f, -6.48483215e-03f, 6.96032345e-02f, -1.70043521e-02f, -7.33774109e-03f, 1.09610683e-03f, -7.83290435e-03f, -6.03483021e-02f,
  2.34415792e-02f, -1.38681456e-02f, 3.67153026e-02f, 3.62017378e-02f, 3.54145244e-02f, -3.54832411e-02f, -1.15797661e-01f, -6.56905677e-03f, -3.03796139e-02f, 7.42037818e-02f,
  -2.22023115e-01f, -2.26066664e-01f, -5.71448691e-02f, -7.86047727e-02f, -2.69574337e-02f, 2.28505805e-02f, 7.55180046e-03f, -4.67579030e-02f, -5.72939403e-02f, 4.81922738e-03f,
  -9.50156245e-03f, 4.97475546e-03f, -3.89612727e-02f, 4.89056669e-02f, 5.40599674e-02f, 2.80437823e-02f, -2.18519084e-02f, 1.32208467e-02f, -7.09119141e-02f, -3.27244624e-02f,
  -8.49894285e-02f, -2.84523889e-02f, -6.29312871e-03f, 4.36554104e-02f, -2.61682086e-02f, -6.59941137e-02f, 3.47849019e-02f, 2.45321393e-02f, 6.27794042e-02f, -3.12426127e-02f,
  -6.20874405e-01f, 2.62550175e-01f, 2.03159347e-01f, -2.37683520e-01f, -4.75409180e-02f, 1.35732383e-01f, -5.60560338e-02f, 7.48234913e-02f, -1.86827451e-01f, 6.32308889e-04f,
  1.85764749e-02f, -3.01652670e-01f, 5.86225390e-02f, 4.84345518e-02f, 1.42851099e-01f, 3.32922712e-02f, 8.46471414e-02f, 3.90730053e-03f, 5.13274074e-02f, -8.87433365e-02f,
  6.44307807e-02f, -5.73920794e-02f, 1.23704426e-01f, 8.36825743e-02f, 1.09329201e-01f, -1.58335697e-02f, -6.12371378e-02f, -3.09150722e-02f, 3.82735841e-02f, 7.51461461e-02f,
  -1.82841450e-01f, -2.76618987e-01f, -7.13566169e-02f, 6.02177195e-02f, 3.46694961e-02f, 1.06388684e-02f, -8.71440687e-04f, -7.70540908e-02f, -3.33816670e-02f, -4.24138308e-02f,
  -4.58517298e-02f, -3.21581513e-02f, -6.56559616e-02f, 3.70514914e-02f, -4.29657707e-03f, 3.57435942e-02f, 2.05426496e-02f, 5.16999774e-02f, -1.33561185e-02f, 9.59785357e-02f,
  9.07571316e-02f, 2.50767693e-02f, 3.64113264e-02f, 3.20853181e-02f, 1.48267662e-02f, 3.22649889e-02f, -5.87555245e-02f, -6.52972795e-03f, -3.41074681e-03f, 1.31843137e-02f,
  3.11035216e-02f, -3.56213264e-02f, 5.16277142e-02f, 4.49185967e-02f, 3.02177947e-02f, 2.07516998e-02f, -1.21132480e-02f, 4.43378873e-02f, -3.33630182e-02f, -1.43077429e-02f,
  -3.78449485e-02f, -2.53612958e-02f, -3.73416729e-02f, 3.44679020e-02f, -6.02182895e-02f, -3.74600589e-02f, -2.01979019e-02f, -2.24324074e-02f, 3.48972417e-02f, -2.75065098e-02f,
  -3.38785984e-02f, 6.66048285e-03f, 6.43760478e-03f, -2.52331700e-03f, 1.92012768e-02f, 2.02296674e-02f, 1.26311565e-02f, 2.28625461e-02f, -4.92986850e-02f, -4.58527096e-02f,
  -1.38098955e-01f, -3.09895992e-01f, -1.63313076e-02f, -8.83644894e-02f, -2.03094464e-02f, 9.43066925e-02f, 1.28179444e-02f, 7.65549466e-02f, 3.96163464e-02f, -4.64951172e-02f,
  -1.30791664e-02f, 1.62671357e-02f, 7.69316480e-02f, 3.33508127e-03f, 4.50136289e-02f, 4.10187384e-03f, -5.38343005e-02f, -6.39994666e-02f, -3.19634639e-02f, 7.54749775e-02f,
  2.94140284e-03f, -5.09396084e-02f, 2.38534133e-03f, -9.33592841e-02f, -1.34855006e-02f, 1.71438400e-02f, 1.20721140e-03f, 1.12106428e-02f, -3.77846621e-02f, 5.76257668e-02f,
  -9.27794650e-02f, -1.37477234e-01f, -6.29785731e-02f, 1.14258081e-01f, 5.25125628e-03f, -2.07766682e-01f, -3.24482650e-01f, 6.03432208e-02f, -2.27805004e-01f, -1.11735567e-01f,
  1.93935689e-02f, -2.71995157e-01f, -2.20272973e-01f, -7.75296539e-02f, 7.87954256e-02f, -2.25439221e-01f, 2.62494739e-02f, -5.06669246e-02f, -1.63359553e-01f, 2.95681693e-02f,
  5.06035425e-02f, 6.67290241e-02f, 1.57020837e-01f, 3.51428241e-01f, 1.08996011e-01f, 3.10330927e-01f, 3.71596098e-01f, 7.87273720e-02f, 3.45252842e-01f, 1.21594384e-01f,
  -1.83122844e-01f, -1.39815331e-01f, -3.62376496e-02f, -2.56416723e-02f, 7.30846226e-02f, 8.95851105e-02f, -2.17145216e-02f, -5.38452826e-02f, -1.91048981e-04f, 4.60871011e-02f,
  -6.78179264e-02f, -9.70820151e-03f, 3.26505862e-02f, 2.80897766e-02f, -5.38099483e-02f, 1.27164144e-02f, 1.73390808e-03f, 3.80559801e-03f, -1.21577037e-02f, -3.07713132e-02f,
  -9.25625637e-02f, -4.38415911e-03f, 4.12491597e-02f, 5.74686602e-02f, 1.80408568e-03f, -8.62860121e-03f, 2.39271540e-02f, -3.63412462e-02f, 8.93948227e-02f, 5.61709553e-02f,
  -3.78378592e-02f, 3.30417603e-02f, 3.93351130e-02f, 4.45345268e-02f, 4.73520113e-03f, 6.21589720e-02f, -1.56589653e-02f, 2.15133950e-02f, 1.26751401e-02f, -2.79856678e-02f,
  1.46876797e-01f, 2.14309953e-02f, -2.41537509e-03f, -8.48583598e-03f, 4.22056317e-02f, -6.99051768e-02f, 2.92485934e-02f, 6.73844367e-02f, 6.01633918e-04f, -1.56735294e-02f,
  -5.66466190e-02f, 7.57725760e-02f, -1.01380851e-02f, 1.33746704e-02f, -9.08258278e-03f, -1.19802123e-02f, -1.54682726e-03f, -2.62560658e-02f, -1.15633560e-02f, 6.50772154e-02f,
  -4.44017984e-02f, 1.07162476e-01f, 1.35668470e-02f, 1.54746016e-02f, 5.52464873e-02f, 6.34945780e-02f, -1.16048474e-02f, 3.60837430e-02f, 9.08602681e-03f, -3.02028414e-02f,
  4.39183898e-02f, 5.60557470e-04f, 1.39671890e-02f, -1.96732604e-03f, 3.98169458e-02f, -2.21062135e-02f, 4.85999361e-02f, 6.31312206e-02f, 8.09592977e-02f, 1.05622951e-02f,
  6.45038709e-02f, -3.78310271e-02f, 2.66342219e-02f, 6.11066669e-02f, -3.27276587e-02f, 4.17237245e-02f, 7.12232813e-02f, 6.17425852e-02f, 4.34892289e-02f, -5.78144155e-02f,
  1.65149793e-01f, 6.11958280e-02f, 1.53587863e-01f, 1.65026460e-03f, -7.35713094e-02f, -4.14189026e-02f, -3.70485038e-02f, -9.17865243e-03f, -3.86974700e-02f, 2.79297698e-02f,
  -1.03248075e-01f, 2.08502740e-01f, -8.24754834e-02f, -6.87177777e-02f, -1.60142526e-01f, -1.73005403e-03f, -9.70381424e-02f, 6.79333657e-02f, -1.96262132e-02f, 8.97809342e-02f,
  -4.85526659e-02f, -1.84121594e-01f, -1.07915467e-02f, -6.47130758e-02f, -5.49327284e-02f, 9.88752022e-02f, -4.71243486e-02f, -5.21142036e-02f, 4.86472547e-02f, -1.03612497e-01f,
  3.66704934e-03f, -6.56040907e-02f, 1.16076320e-01f, 1.03874435e-03f, 9.16861370e-03f, -1.71045089e-04f, -5.42228296e-02f, -8.82830378e-03f, 6.22977540e-02f, 1.02230355e-01f,
  3.50173116e-02f, 5.57173416e-03f, -3.37969810e-02f, -4.37663086e-02f, 5.08562364e-02f, -3.25192115e-03f, 5.70396222e-02f, -7.95323774e-03f, 6.00906909e-02f, 9.27645564e-02f,
  8.60649422e-02f, 9.46530141e-03f, 5.96161373e-02f, 4.21723202e-02f, 3.15536819e-02f, -1.51278488e-02f, 2.79486030e-02f, 6.58640265e-02f, -1.69755407e-02f, 2.95849778e-02f,
  1.20281531e-02f, -1.22049123e-01f, -1.09854870e-01f, -5.21543100e-02f, 3.06447037e-02f, 5.63067794e-02f, 8.60811770e-02f, -3.47983912e-02f, 6.84385449e-02f, 4.17758897e-02f,
  3.31630278e-03f, 5.60711138e-02f, -1.07418180e-01f, 6.36031032e-02f, 6.92413375e-02f, 2.31851228e-02f, 8.81261826e-02f, 5.54572307e-02f, -4.07027528e-02f, 1.07419446e-01f,
  -1.02451071e-01f, -7.79384449e-02f, 6.06070943e-02f, -5.85922636e-02f, -8.79263505e-02f, 3.37828286e-02f, -3.91816497e-02f, 2.03264840e-02f, 3.59109156e-02f, -3.97164747e-02f,
  1.41636103e-01f, -2.04487480e-02f, -4.49998565e-02f, 2.43136156e-02f, 2.29373202e-02f, 3.11510637e-03f, 3.30212489e-02f, 6.28315881e-02f, 8.68590325e-02f, -5.20327687e-02f,
  -5.06059267e-02f, 2.89166421e-02f, 2.09825505e-02f, 3.96910422e-02f, -8.29609707e-02f, 3.16931196e-02f, 1.07274810e-02f, 3.26747596e-02f, 2.10096892e-02f, -8.00903654e-04f,
  8.46790895e-02f, -2.41386537e-02f, -5.29462937e-03f, -1.03702582e-01f, 4.90923375e-02f, 4.21807766e-02f, -2.63330862e-02f, 4.97352406e-02f, 3.03702801e-02f, 8.12344626e-02f,
  -1.32975072e-01f, -1.21498816e-01f, 3.71069200e-02f, 2.50107765e-01f, 2.64724456e-02f, -3.66134077e-01f, -4.56129760e-01f, 7.02093244e-02f, -2.56733358e-01f, -2.61058807e-01f,
  7.54352063e-02f, 7.70465061e-02f, -1.23143554e-01f, 2.54883051e-01f, 4.60077822e-01f, 2.64894087e-02f, 1.64085731e-01f, 5.03322408e-02f, -1.77255366e-02f, 9.81233865e-02f,
  3.38431895e-01f, 2.40942836e-01f, 2.81800330e-01f, 9.34111029e-02f, -4.36194837e-02f, 3.57288867e-02f, 3.53294939e-01f, -1.07280277e-01f, 2.77483404e-01f, 8.74435902e-02f,
  -3.03737000e-02f, 2.52955742e-02f, -2.57048290e-02f, -4.08705510e-03f, -1.99661963e-02f, -1.14421673e-01f, -4.19835187e-02f, 4.57309857e-02f, 3.06856520e-02f, 5.36069227e-03f,
  2.65511870e-02f, 6.02602735e-02f, -5.30778803e-03f, -3.33814695e-03f, -2.95703709e-02f, 5.76325506e-02f, -3.66821629e-03f, -3.76520492e-02f, -4.54630926e-02f, -1.40623860e-02f,
  -1.50519349e-02f, 3.17072449e-03f, -2.04836670e-03f, 2.60978937e-02f, 1.55693367e-02f, -1.14888228e-01f, -1.20564073e-01f, -1.62919462e-02f, -4.87693287e-02f, 4.77825198e-03f,
  -2.20781714e-02f, -8.27403441e-02f, -3.30573022e-02f, -1.14553552e-02f, -8.90863538e-02f, -1.76726189e-02f, -1.08525055e-02f, -9.82804224e-03f, -3.25430520e-02f, -4.23724465e-02f,
  -4.98951077e-02f, -1.30820870e-02f, 1.43458340e-02f, -8.13354254e-02f, -4.35859486e-02f, -5.14129996e-02f, -2.79833078e-02f, 3.98269668e-02f, 4.17270921e-02f, -4.68847901e-03f,
  -2.06490718e-02f, -1.84214897e-02f, -6.95818439e-02f, -3.93269770e-02f, 1.87197141e-02f, 2.64420137e-02f, 1.00917540e-01f, -4.70819026e-02f, 6.06738357e-03f, -6.44242391e-02f,
  1.26890913e-01f, 2.11675569e-01f, -5.27739711e-02f, -1.53061589e-02f, -9.46062654e-02f, -2.17769053e-02f, 7.59023726e-02f, 1.67923141e-02f, 1.59400385e-02f, -1.92349348e-02f,
  2.08874308e-02f, -1.18496604e-02f, 4.13732268e-02f, -1.14450026e-02f, 5.71620129e-02f, 2.24074386e-02f, 2.95169204e-02f, 2.26284359e-02f, 8.67741853e-02f, 1.32937506e-01f,
  3.42542157e-02f, -3.32205817e-02f, -3.00767254e-02f, -1.27966061e-01f, 2.58150641e-02f, 2.72012781e-03f, 4.17069159e-02f, -5.24266586e-02f, 4.23480123e-02f, 4.04477417e-02f,
  -3.01736653e-01f, -2.77111381e-01f, -2.48162329e-01f, -4.14983600e-01f, -1.00757051e-02f, -3.64974409e-01f, -5.24835408e-01f, -6.64298758e-02f, 2.57969145e-02f, -1.20128065e-01f,
  -2.23221660e-01f, 6.56953603e-02f, 1.41444385e-01f, -2.34060675e-01f, 1.06508777e-01f, 1.54412910e-01f, -3.42464924e-01f, -2.48601466e-01f, 1.45735875e-01f, -2.18813866e-01f,
  -8.93342197e-02f, -2.61035234e-01f, -3.07325274e-02f, 3.38733867e-02f, -2.54986584e-01f, -1.96442939e-02f, -2.44163442e-02f, 1.85431447e-02f, -4.98009957e-02f, 2.24008951e-02f,
  1.40109032e-01f, 2.16744751e-01f, 2.23111138e-02f, 1.75893381e-02f, -1.12403587e-01f, -3.22143137e-02f, -1.15071200e-01f, 8.28033909e-02f, 4.12460268e-02f, -3.62368077e-02f,
  -7.67417923e-02f, 7.13760480e-02f, 2.27846559e-02f, 4.10037041e-02f, -5.73988035e-02f, -7.42493605e-04f, 1.07355997e-01f, 1.90105308e-02f, 1.82305127e-02f, 3.38214263e-02f,
  -2.69832388e-02f, 9.38737020e-03f, -1.64084986e-01f, -3.80358249e-02f, -2.69101355e-02f, 3.79396044e-02f, -1.24610914e-02f, 3.13593037e-02f, -7.19405711e-02f, -6.15920983e-02f,
  1.22134518e-02f, -2.22463831e-02f, -1.11776389e-01f, 3.10357530e-02f, -1.69461574e-02f, 8.46232027e-02f, -4.93838005e-02f, 8.50990694e-03f, -3.36709395e-02f, -1.94043554e-02f,
  -6.77325949e-03f, 4.78307903e-03f, 3.17120701e-02f, -2.71942634e-02f, -1.12064131e-01f, -1.60217769e-02f, 1.63691919e-02f, -3.24658025e-03f, -6.88918307e-02f, 3.57515961e-02f,
  3.83658260e-02f, 1.62547715e-02f, -4.17715237e-02f, -7.48342425e-02f, 1.72340181e-02f, 1.72487833e-02f, 4.42217197e-03f, 1.73473451e-02f, -8.78872257e-03f, -2.54313722e-02f,
  -1.73175722e-01f, -2.14951262e-01f, 4.35325690e-02f, 3.62313762e-02f, 1.17319770e-01f, -5.08657247e-02f, 4.87127677e-02f, -5.78895807e-02f, -1.24950327e-01f, 3.73873971e-02f,
  -9.56845880e-02f, -6.83603510e-02f, -1.09709822e-01f, -2.58500781e-02f, -6.37466088e-02f, -7.35771051e-03f, -5.55780753e-02f, -6.32807761e-02f, -1.01992182e-01f, -1.10273875e-01f,
  -3.82899120e-02f, 5.81476139e-04f, 8.36246088e-02f, 5.12529127e-02f, -2.25245338e-02f, -1.14900202e-01f, 7.39218434e-03f, 5.33249862e-02f, 1.39158033e-02f, -3.58509757e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.47902682e-01f, 4.01777208e-01f, 6.06288090e-02f, 1.44588560e-01f, 1.22333251e-01f, -8.51603448e-02f, -4.18668017e-02f, 8.74457359e-02f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.63308516e-01f, 2.08307341e-01f, 1.91891342e-01f, 5.36115579e-02f, -3.68442595e-01f, 2.54039943e-01f, 7.38418221e-01f, -9.02778506e-01f, -2.75260359e-01f, -8.34811553e-02f,
  1.38011351e-01f, 1.05297439e-01f, 2.28433624e-01f, 1.57325268e-01f, 1.68350890e-01f, 7.54434317e-02f, -1.69859111e-01f, 1.79137617e-01f, -1.15735933e-01f, 8.30881000e-02f,
  1.14607319e-01f, -2.27398574e-01f, 4.08764005e-01f, -5.55899382e-01f, -3.19531783e-02f, 7.74126053e-02f, 1.01914838e-01f, -3.10800165e-01f, 2.81026334e-01f, 4.02858257e-02f,
  -7.22557455e-02f, -5.07227063e-01f, -3.85235190e-01f, 6.78535998e-02f, -1.80012807e-01f, 1.25202939e-01f, 1.01080537e-01f, 1.58176109e-01f, -6.14011027e-02f, -1.76867172e-01f,
  2.99463332e-01f, -2.71163911e-01f, 1.24915615e-01f, 3.71874005e-01f, -2.89870232e-01f, -2.26443365e-01f, 1.12658210e-01f, 4.80582654e-01f, -1.68052867e-01f, 2.59559080e-02f,
  -1.92515060e-01f, 4.72940281e-02f, 6.34962201e-01f, 4.95141596e-01f, 3.71509671e-01f, 1.37479678e-02f, -1.55421719e-01f, -1.14370301e-01f, 3.41067314e-01f, 4.75888252e-01f,
  -4.94446754e-02f, -1.53765664e-01f, -7.34157488e-02f, 3.84316355e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -2.74169538e-02f, 2.33977214e-01f, -1.31597951e-01f, 1.99603423e-01f, 1.41014472e-01f, -2.31172919e-01f, -4.49472398e-01f, 4.89326268e-01f, -1.25259921e-01f, 2.50691205e-01f,
  -2.81385481e-01f, -8.76695216e-02f, 3.36988807e-01f, -2.52378583e-01f, 3.25827569e-01f, -1.11470200e-01f, -5.79726286e-02f, 5.00943372e-03f, -1.95246488e-01f, 1.28936172e-01f,
  4.53353643e-01f, 2.43738398e-01f, 1.37585133e-01f, -3.07387680e-01f, 4.92177382e-02f, -4.32810672e-02f, 6.79296434e-01f, -7.01023191e-02f, -4.75721732e-02f, -1.07782409e-01f,
  3.67801636e-01f, 1.49420470e-01f, -1.94164589e-01f, 5.29767200e-02f, -8.94984230e-02f, -1.84765682e-01f, -2.18943909e-01f, 2.66342741e-02f, 1.32114053e-01f, 1.42995566e-01f,
  2.04904661e-01f, 6.90757334e-02f, -2.49476731e-01f, 1.33218979e-02f, -1.59106642e-01f, -2.53894597e-01f, 2.43862290e-02f, 1.07809110e-02f, 4.15380269e-01f, -1.57093689e-01f,
  4.01566207e-01f, 3.33817393e-01f, -5.31024709e-02f, 2.22176135e-01f, -5.70956111e-01f, 4.76099402e-01f, 3.66521955e-01f, 2.17331439e-01f, -1.64468482e-01f, 5.58406413e-01f,
  -1.18906453e-01f, -3.32381099e-01f, -3.06019485e-01f, 4.92241770e-01f, 4.27604616e-01f, 1.23479225e-01f, 9.15494934e-02f, 4.18243527e-01f, 7.18731642e-01f, 6.30057931e-01f,
  -3.91912945e-02f, -5.69951981e-02f, -2.87023813e-01f, 1.02902555e+00f, 4.13210541e-02f, -1.82576507e-01f, 1.89648956e-01f, -2.78549224e-01f, -3.49794924e-01f, -9.69966352e-02f,
  1.27016798e-01f, 8.49895328e-02f, 4.34032083e-01f, 3.86855543e-01f, 8.11071768e-02f, -8.49178493e-01f, 1.36473924e-01f, 1.57619938e-01f, 6.58766985e-01f, 1.26842828e-02f,
  1.74096316e-01f, -1.13968581e-01f, 6.79791033e-01f, 4.31067087e-02f, 9.51815367e-01f, 6.57067478e-01f, 4.39335346e-01f, 1.70822367e-02f, -6.89313188e-02f, 1.67131186e-01f,
  1.88414201e-01f, -8.59741345e-02f, -3.95346247e-02f, 3.80285144e-01f, 1.51847854e-01f, 8.49031687e-01f, -3.01642239e-01f, -2.51318336e-01f, 4.84752804e-01f, -2.70120531e-01f,
  1.27741620e-01f, -2.85601556e-01f, 1.33153915e-01f, 2.85610944e-01f, -3.28821331e-01f, -3.47572453e-02f, 6.21097684e-01f, 2.27456674e-01f, -3.32299232e-01f, 2.56108046e-01f,
  -3.02183300e-01f, 6.72077715e-01f, -2.17514277e-01f, 8.33390281e-02f, -6.50277734e-02f, -1.06579661e-01f, 2.36048162e-01f, -4.45450582e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  3.91993403e-01f, 1.61728531e-01f, -1.32200494e-01f, 7.12761521e-01f, 2.57083774e-01f, 1.24940485e-01f, 8.89584497e-02f, -3.26631777e-02f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.26282528e-01f, -7.95050383e-01f, -6.07600093e-01f, -5.07816672e-01f, -7.04355538e-01f, -3.41229737e-01f, 1.32996470e-01f, 2.80477274e-02f, 2.03018069e-01f, 4.12198156e-02f,
  2.64077663e-01f, -9.63591412e-02f, -6.46371692e-02f, 3.24138403e-01f, 2.61218905e-01f, 4.87017363e-01f, 5.10891192e-02f, 5.68543553e-01f, 5.53029060e-01f, 6.12496734e-01f,
  5.23675978e-01f, -1.78605750e-01f, 3.85358214e-01f, -4.31593090e-01f, -2.14807272e-01f, -4.17306572e-01f, 1.60489708e-01f, 3.61188233e-01f, -2.33737126e-01f, -6.29900992e-02f,
  -2.34064654e-01f, -3.28040212e-01f, -6.52529374e-02f, -4.31903809e-01f, -5.05397916e-02f, -3.95641297e-01f, 8.23228061e-02f, -6.04945362e-01f, 6.70676291e-01f, 5.92924833e-01f,
  -1.49799228e-01f, -2.84254581e-01f, -2.52529234e-02f, 3.23633701e-01f, -1.70725971e-01f, -2.84327823e-03f, -2.93137014e-01f, 4.41124439e-02f, -2.01343492e-01f, 1.83816314e-01f,
  1.39844837e-03f, 3.04996431e-01f, -2.18302920e-01f, 1.37605727e-01f, -9.31717735e-03f, -3.61161351e-01f, 3.21525037e-01f, 1.67047027e-02f, 1.34336933e-01f, -2.23825887e-01f,
  3.56071368e-02f, 1.65874019e-01f, 1.02903515e-01f, 2.23689839e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -2.25315899e-01f, -1.12725742e-01f, -5.60229160e-02f, 3.67860466e-01f, -1.83963060e-01f, 5.73497355e-01f, -3.79836142e-01f, 5.22795320e-01f, 2.92634845e-01f, -9.68690030e-03f,
  -1.24052301e-01f, 8.57578442e-02f, 1.22259223e+00f, -1.60505995e-01f, 8.43393862e-01f, 6.74976468e-01f, 6.35750368e-02f, 3.20589393e-01f, 2.32085526e-01f, 5.01325727e-01f,
  -1.14924622e+00f, -7.25491345e-01f, 3.08130961e-02f, -5.08483291e-01f, 5.08487940e-01f, -3.40670019e-01f, -1.47018999e-01f, 5.74660599e-01f, -8.33938196e-02f, -1.15809143e-01f,
  1.04653440e-01f, 6.91402107e-02f, 4.07345109e-02f, -2.66564071e-01f, -3.03990513e-01f, -1.69947907e-01f, -2.06991881e-01f, -2.43620723e-01f, 6.92214966e-01f, 2.29915664e-01f,
  -2.74855018e-01f, -4.95519377e-02f, -5.87531403e-02f, 6.11523509e-01f, -2.94158876e-01f, 8.91333103e-01f, -3.87396634e-01f, -4.18014616e-01f, 5.13985455e-01f, 6.96033299e-01f,
  8.95676613e-02f, -7.69277364e-02f, 2.89210659e-02f, 1.48249522e-01f, -2.17571273e-01f, -5.45696795e-01f, 4.93475795e-01f, 1.54770344e-01f, -8.84707570e-02f, -2.29129359e-01f,
  -1.61829740e-01f, 1.37143910e+00f, 4.53977615e-01f, -1.17696695e-01f, 3.44578415e-01f, 7.72123218e-01f, 5.66229284e-01f, 7.74504662e-01f, 9.32610452e-01f, 2.85144988e-02f,
  -2.39426628e-01f, -3.12709510e-01f, -3.14706028e-01f, -8.83373171e-02f, -2.63004124e-01f, 2.09555879e-01f, 3.70301396e-01f, -4.50614333e-01f, -7.66480640e-02f, -2.40061432e-01f,
  3.85438144e-01f, 2.62229025e-01f, 9.24697444e-02f, 6.97386384e-01f, -9.61905301e-01f, -8.65177333e-01f, -3.91745836e-01f, -6.20458961e-01f, 2.05928788e-01f, -4.78648275e-01f,
  1.61519349e-02f, 8.67954075e-01f, 6.58171773e-01f, -4.15855139e-01f, 5.82127750e-01f, 2.80565619e-01f, 1.19997695e-01f, 1.78533822e-01f, 4.84203041e-01f, 2.08970770e-01f,
  -1.48917750e-01f, -8.78910184e-01f, 1.18400311e+00f, 1.27951515e+00f, -1.38965845e-01f, 5.70053220e-01f, -2.40145475e-01f, 6.73949063e-01f, 3.10304612e-01f, 1.80343201e-03f,
  -2.67032862e-01f, 2.05405712e-01f, 1.39835820e-01f, 9.48926210e-02f, -2.42275774e-01f, 9.24560502e-02f, -3.83857995e-01f, 8.97536799e-02f, 2.00653136e-01f, -2.81686664e-01f,
  -4.25221585e-02f, 3.07089146e-02f, 2.87139297e-01f, 4.31827940e-02f, -1.08104594e-01f, 7.76097998e-02f, 2.19430178e-01f, 1.36590481e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  -1.45683661e-01f, 4.13970053e-01f, 4.58643526e-01f, 2.90404499e-01f, 8.73804629e-01f, 3.23303461e-01f, 7.24676788e-01f, 9.65397134e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  5.69764435e-01f, 4.94615972e-01f, 3.18728685e-01f, 1.30426094e-01f, 1.52784273e-01f, 1.80830225e-01f, 4.65734154e-01f, -1.66003749e-01f, 9.87438783e-02f, 6.09370589e-01f,
  -2.98805475e-01f, -9.22412694e-01f, -4.68039215e-01f, 5.26720285e-01f, 8.86960983e-01f, 1.43313721e-01f, -5.29097080e-01f, -8.29302818e-02f, 5.90397343e-02f, -3.82236898e-01f,
  6.73266888e-01f, -8.24254513e-01f, -3.03251296e-01f, 6.10536002e-02f, 5.73411167e-01f, 5.29148281e-01f, -3.64704996e-01f, -3.01936895e-01f, -2.70957619e-01f, 8.90656173e-01f,
  -1.53602958e-01f, 2.39481509e-01f, -6.40350938e-01f, -8.39101076e-01f, -3.89327675e-01f, -4.38754350e-01f, 4.78868723e-01f, -3.12946260e-01f, 1.42759070e-01f, -4.82558925e-03f,
  9.31441367e-01f, -3.31250489e-01f, 1.07039921e-01f, 3.61090571e-01f, -4.85709101e-01f, 1.81139007e-01f, -6.19049966e-01f, 5.32268584e-02f, -2.10889965e-01f, -1.53179497e-01f,
  2.62828320e-01f, -6.47029951e-02f, 7.72198141e-01f, 4.78182703e-01f, 7.03947723e-01f, 1.63825452e-01f, -3.99887711e-01f, 6.48143291e-01f, 7.75705993e-01f, -7.15741292e-02f,
  -4.01334345e-01f, -4.99725668e-03f, 2.40515411e-01f, 2.89814204e-01f, 3.74718994e-01f, -4.26101148e-01f, 1.31779999e-01f, 2.02367991e-01f, -6.81103885e-01f, 8.05593371e-01f,
  9.71416891e-01f, -4.41836923e-01f, -4.21211094e-01f, -3.88562918e-01f, 4.23479438e-01f, -4.35302198e-01f, 4.85767752e-01f, -3.21679115e-01f, 1.24029768e+00f, -1.71251997e-01f,
  -6.44528493e-02f, -1.69225335e-02f, 3.80493432e-01f, -8.54967311e-02f, -4.01097596e-01f, 4.72802371e-01f, -3.87611330e-01f, -2.03282192e-01f, -2.81962514e-01f, 3.98709744e-01f,
  -6.84747279e-01f, -3.24707568e-01f, 1.03723478e+00f, 1.03103399e+00f, -1.41755119e-01f, -3.83823514e-02f, 1.04049698e-01f, 2.28559554e-01f, -5.69827974e-01f, 2.23788276e-01f,
  -4.55727100e-01f, -3.59399766e-01f, -5.32877088e-01f, 1.63516685e-01f, 1.16929853e+00f, -6.66353881e-01f, 5.49972504e-02f, -4.35806692e-01f, 3.95352602e-01f, 2.42852837e-01f,
  -7.34979689e-01f, 9.79984999e-02f, -4.79515404e-01f, 2.28136957e-01f, -3.83544028e-01f, 1.17245927e-01f, 5.20355105e-01f, -7.07694411e-01f, 7.65214801e-01f, -5.01068473e-01f,
  -2.37432912e-01f, -4.77459073e-01f, 1.00392330e+00f, 2.41726488e-01f, -2.40459979e-01f, -8.28215063e-01f, 3.24205756e-01f, -7.68845063e-03f, 2.65017331e-01f, 1.36721715e-01f,
  -4.70815182e-01f, -2.69464016e-01f, 3.55704576e-01f, 2.82669198e-02f, -5.86187243e-01f, 6.16121590e-01f, -1.11034155e-01f, -2.02150941e-01f, -1.74317047e-01f, 1.06979501e+00f,
  -4.31274921e-01f, -7.84499347e-01f, -5.61025441e-01f, 2.11912498e-01f, 2.25858107e-01f, 4.66291070e-01f, 6.06517553e-01f, 5.71654439e-01f, -9.74844992e-01f, -4.70076501e-01f,
  -6.01398587e-01f, -1.86609924e-01f, 4.23581988e-01f, -7.12336123e-01f, -3.00935149e-01f, -6.78426474e-02f, 3.77041072e-01f, -8.05281043e-01f, 9.87321258e-01f, -1.86679393e-01f,
  5.19049466e-01f, 2.86138624e-01f, 2.07290381e-01f, 6.84838071e-02f, 1.29168823e-01f, 1.10353500e-01f, -5.98584056e-01f, 2.76034802e-01f, -5.42061210e-01f, 8.12251031e-01f,
  -1.61861733e-01f, 5.73156655e-01f, -2.42818609e-01f, 6.39064074e-01f, -6.12958670e-01f, 5.41269965e-02f, -5.34842968e-01f, -3.61458898e-01f, 2.07419559e-01f, 5.32131553e-01f,
  -9.08573687e-01f, 8.78278434e-01f, -8.62110555e-01f, 4.52630013e-01f, -3.66931617e-01f, -2.69284368e-01f, 2.72421706e-02f, 5.49219310e-01f, 1.12231529e+00f, -6.12224638e-01f,
  -6.51756585e-01f, -1.26036823e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.06219876e-01f, -4.02241230e-01f, -3.86575103e-01f, -2.98549056e-01f, -5.85592836e-02f, -3.51300649e-02f, -1.43493742e-01f, -1.79278806e-01f, -2.66162902e-02f, 3.66466641e-01f,
  -1.80516466e-01f, 2.44807079e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    