/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.48602673e-02f, -2.10858524e-01f, -1.97656900e-01f, 1.57053769e-01f, -1.23403639e-01f, -4.78034765e-02f, -3.02658647e-01f, 1.02871142e-01f, 1.43622175e-01f, -8.84513333e-02f,
  -3.23375501e-02f, 2.37503663e-01f, 3.79387997e-02f, 4.72814254e-02f, 1.41880453e-01f, -4.68352661e-02f, -3.30068283e-02f, 1.20621704e-01f, 3.50932926e-01f, 1.97995663e-01f,
  1.02026060e-01f, 9.82503369e-02f, 1.25357822e-01f, 1.24846511e-01f, -2.47009862e-02f, 7.81975389e-02f, -6.93586841e-02f, -1.61489844e-01f, -1.48569509e-01f, -1.95999630e-02f,
  -1.85412407e-01f, -1.68480828e-01f, 7.54024833e-02f, 8.76027420e-02f, -9.28857997e-02f, 5.60741164e-02f, -8.62882882e-02f, -8.88031051e-02f, -2.49001719e-02f, 2.36733705e-02f,
  3.60640213e-02f, -3.78067046e-02f, 1.11615747e-01f, 1.65861584e-02f, -7.09388182e-02f, -4.35318612e-02f, 6.67101070e-02f, 3.93450521e-02f, -1.55659048e-02f, -5.58554055e-03f,
  -1.33402292e-02f, -2.07261071e-02f, -1.02660082e-01f, -1.03332676e-01f, -5.06530236e-03f, 7.77647495e-02f, -5.58435321e-02f, -1.04093373e-01f, -8.77646655e-02f, -7.87203610e-02f,
  8.51404741e-02f, 1.40334778e-02f, -1.00500286e-01f, -4.51912582e-02f, 2.93707084e-02f, -8.75382125e-02f, 1.11615539e-01f, -3.38923074e-02f, -4.32898328e-02f, -2.82680355e-02f,
  3.23176058e-03f, 4.54603396e-02f, -4.15078975e-04f, -1.21552385e-02f, 4.16631475e-02f, 7.02612847e-02f, -3.56423599e-03f, 2.86772754e-02f, 7.12245032e-02f, 6.76500238e-03f,
  4.67930213e-02f, 7.26271719e-02f, -4.59919730e-03f, -2.76069865e-02f, 1.89147680e-03f, -7.64237018e-03f, 8.62764427e-04f, -1.05285682e-02f, 4.08935919e-02f, 3.98622453e-02f,
  -6.89705089e-02f, 3.26673947e-02f, 9.09377113e-02f, 7.18751103e-02f, -3.73546109e-02f, -1.56249739e-02f, -9.75795388e-02f, -6.38892874e-04f, 2.27547083e-02f, 8.00640211e-02f,
  3.63531336e-02f, 1.55216366e-01f, 5.48855141e-02f, -6.53036833e-02f, 5.68576716e-02f, 1.05442278e-01f, -8.59806165e-02f, -3.25028808e-03f, 3.22888382e-02f, 1.03677744e-02f,
  -5.81225082e-02f, 1.06128193e-02f, -5.48072197e-02f, -4.40602489e-02f, -5.10714613e-02f, 6.10492378e-02f, -9.08576474e-02f, -5.83093576e-02f, -7.50678405e-02f, -1.60680950e-01f,
  3.81704539e-01f, 7.10208267e-02f, 3.22452933e-01f, 1.05944999e-01f, -1.93528067e-02f, -1.57846093e-01f, -1.46890447e-01f, -1.43413469e-01f, -8.92017409e-02f, -4.01019566e-02f,
  2.54464615e-02f, -5.37138805e-02f, 5.55027649e-02f, -1.29893735e-01f, -8.20659772e-02f, -3.94679382e-02f, 1.93324033e-03f, 7.50954077e-02f, 2.82004364e-02f, -1.37838036e-01f,
  -1.16823226e-01f, 5.76545708e-02f, 1.18806601e-01f, -2.00022720e-02f, 7.84308538e-02f, 9.69159603e-02f, 1.08572200e-01f, 1.78407818e-01f, 1.01382382e-01f, 1.07459784e-01f,
  2.66364664e-01f, 1.72092125e-01f, -8.16009715e-02f, 9.70617868e-04f, 6.30839542e-02f, -6.19030520e-02f, -2.26312447e-02f, -1.71430334e-02f, -3.96596380e-02f, -3.04213930e-02f,
  -6.16308078e-02f, -5.98413683e-02f, -6.47636205e-02f, 3.88794988e-02f, -4.43149507e-02f, 4.34250683e-02f, -4.20349613e-02f, 8.58979151e-02f, -9.19279158e-02f, -1.10581778e-01f,
  -1.74241275e-01f, 3.01277898e-02f, 1.08481444e-01f, 6.67577703e-03f, -1.95272006e-02f, -7.69928023e-02f, -9.08168331e-02f, 4.50955145e-02f, 6.11276506e-03f, 4.45071645e-02f,
  -1.43322935e-02f, 7.52025992e-02f, 7.43179023e-02f, -9.31593124e-03f, -8.85900762e-03f, 3.88407288e-03f, -3.56310196e-02f, -5.63043691e-02f, 2.03036377e-03f, 3.19103003e-02f,
  -4.00724006e-04f, 3.11324205e-02f, -5.75757883e-02f, 3.24008428e-02f, -6.30889609e-02f, -9.22135916e-03f, -5.88175990e-02f, 2.97675864e-03f, -5.15853427e-02f, 3.51810269e-02f,
  -4.67753410e-02f, -2.85940077e-02f, -5.43428259e-03f, -3.15494314e-02f, 8.16381164e-03f, 1.61558148e-02f, 3.08798254e-02f, -7.26079196e-02f, 7.70758390e-02f, -5.06008696e-03f,
  7.83810988e-02f, -1.07276082e-01f, 1.06123043e-02f, -5.97803295e-02f, 4.28065732e-02f, 7.97704887e-03f, 4.39155772e-02f, -4.50383052e-02f, -1.69784632e-02f, -1.34853527e-01f,
  -1.48314700e-01f, -9.31877270e-02f, -6.11147173e-02f, 1.44878309e-02f, -4.37098928e-02f, -6.12539463e-02f, -9.07767564e-02f, -3.68669741e-02f, -1.49058506e-01f, -4.05137017e-02f,
  -1.48419052e-01f, -1.72550187e-01f, 2.87826434e-02f, -5.82174212e-02f, -1.31883264e-01f, 5.20517631e-03f, 1.46166626e-02f, 2.56995838e-02f, -3.60979848e-02f, 7.68075883e-02f,
  -2.44330809e-01f, -5.52997030e-02f, 1.58882022e-01f, -2.00089723e-01f, 2.47635320e-01f, 3.17575067e-01f, 5.57207108e-01f, 4.13194066e-03f, -1.54142871e-01f, 7.85981417e-02f,
  -4.30503227e-02f, -2.28969261e-01f, -1.48470625e-01f, -1.72345117e-01f, -1.30191326e-01f, 1.19415887e-01f, 2.04109743e-01f, 1.69372726e-02f, -5.44794723e-02f, 1.86052948e-01f,
  -2.63702916e-03f, 1.73684899e-02f, -2.47425601e-01f, -7.76369199e-02f, 1.47626009e-02f, -9.17212814e-02f, 4.58967723e-02f, 7.98822567e-02f, -3.46974283e-03f, -1.34883858e-02f,
  1.98084563e-01f, 3.50144096e-02f, 5.96834607e-02f, -9.05276686e-02f, 1.14359306e-02f, -3.67770605e-02f, -3.04535646e-02f, 3.29891928e-02f, 1.83764230e-02f, -5.97669417e-03f,
  -4.00197227e-03f, -4.20119129e-02f, -6.44899160e-02f, -1.58452708e-03f, 2.81144530e-02f, 1.79880466e-02f, -5.80578297e-02f, -6.91337287e-02f, -4.78041247e-02f, 7.34721944e-02f,
  2.80019105e-03f, 2.32702103e-02f, 1.24972954e-01f, 1.27212897e-01f, 2.58827955e-02f, 1.31752351e-02f, -3.25654969e-02f, -7.35333785e-02f, -1.29253298e-01f, 9.84958466e-03f,
  -6.63896501e-02f, 5.35545722e-02f, -7.15249637e-03f, 3.35023366e-02f, -8.53547268e-03f, 3.29205468e-02f, 1.92941241e-02f, -4.73500453e-02f, 3.70192640e-02f, -9.90707576e-02f,
  -2.38184053e-02f, -1.78996976e-02f, -5.46851307e-02f, 6.51521385e-02f, -6.33306950e-02f, 5.67287765e-03f, -1.27025386e-02f, -2.72728801e-02f, -6.78453073e-02f, -2.66604740e-02f,
  4.29718867e-02f, 3.33703049e-02f, 7.83119351e-02f, -4.58788984e-02f, 1.58195924e-02f, -1.16817139e-01f, 3.09950393e-02f, -2.31977310e-02f, -8.41838270e-02f, 2.97861006e-02f,
  -8.79062861e-02f, -6.05499074e-02f, 2.64930781e-02f, -6.76699206e-02f, -6.34335130e-02f, -9.14272293e-02f, -5.26255667e-02f, -2.08315086e-02f, -9.01868567e-02f, 1.91154685e-02f,
  3.36906165e-02f, -5.04373722e-02f, -6.11010529e-02f, 5.26673719e-02f, -1.19119277e-02f, 7.45306611e-02f, -1.09682135e-01f, -6.02122433e-02f, -2.87437048e-02f, 2.12421454e-02f,
  -6.08552471e-02f, 4.58056740e-02f, 1.54221421e-02f, 2.87067164e-02f, -4.17896397e-02f, 5.71614355e-02f, 8.31729993e-02f, 1.38666183e-02f, 3.98209617e-02f, 1.34337783e-01f,
  -5.47808670e-02f, 3.09416175e-01f, 2.88552970e-01f, -2.26352856e-01f, -9.17053744e-02f, -1.34352222e-01f, 1.42724931e-01f, -6.61945194e-02f, -2.30210006e-01f, 3.53069492e-02f,
  8.96436349e-02f, -2.26297230e-02f, 7.70945251e-02f, 3.80637422e-02f, 8.36158618e-02f, 1.43395349e-01f, 2.01526538e-01f, 9.87542570e-02f, -1.26859099e-01f, -2.08423078e-01f,
  -4.49694060e-02f, -4.90933582e-02f, 1.10813510e-02f, 3.55472462e-03f, 1.39246598e-01f, -6.70630261e-02f, 1.89160958e-01f, 1.20862581e-01f, 1.30024135e-01f, 3.79782528e-01f,
  2.20102534e-01f, 1.10237554e-01f, -6.68743551e-02f, 1.87944788e-02f, 1.02235407e-01f, 8.26158896e-02f, 3.49459760e-02f, 1.62519187e-01f, 4.52561267e-02f, 1.10830158e-01f,
  -3.53800058e-02f, 9.95547697e-02f, 5.55437170e-02f, 1.07539371e-02f, 7.83822164e-02f, 6.12626784e-02f, 6.16961308e-02f, 1.88055992e-01f, 9.17260945e-02f, 1.15480222e-01f,
  -1.55727807e-02f, 1.23504683e-01f, 3.66894975e-02f, -2.34222673e-02f, 1.53035969e-01f, -4.62877937e-02f, 8.00609365e-02f, 1.10737696e-01f, 8.66206065e-02f, 2.34172255e-01f,
  -1.14383668e-01f, 1.47377448e-02f, 4.93850410e-02f, 4.95623164e-02f, -3.25009450e-02f, -2.51589566e-02f, -2.21801270e-02f, 2.00842749e-02f, -1.61236972e-01f, 2.93792952e-02f,
  6.13535345e-02f, 1.84102245e-02f, -4.85266112e-02f, 3.12690903e-03f, -4.83285859e-02f, -6.52587088e-03f, -6.47534281e-02f, 1.91541035e-02f, -1.32993415e-01f, -2.43501477e-02f,
  -1.38991233e-03f, -4.10733232e-03f, -8.06274638e-02f, 9.22604278e-02f, 6.35564700e-02f, -2.39870604e-02f, -1.15634557e-02f, 2.39269529e-02f, -4.85648885e-02f, -2.90768258e-02f,
  -2.22573698e-01f, -4.51286137e-02f, -8.46548900e-02f, 1.41492337e-02f, -6.88037928e-03f, 2.89281737e-02f, 4.15912382e-02f, 8.22821353e-03f, 1.53132668e-03f, 2.46572550e-02f,
  4.92513776e-02f, 2.89151389e-02f, 7.53603950e-02f, 1.58108119e-02f, -1.26869082e-01f, -1.20794959e-01f, 9.24151391e-03f, 4.21064645e-02f, 3.86053398e-02f, -9.27373767e-02f,
  -2.94791181e-02f, -2.00526252e-01f, -1.29638061e-01f, 5.45272417e-02f, -3.41709852e-02f, -2.08617628e-01f, -4.05664183e-02f, -6.86051920e-02f, -8.61502960e-02f, -4.76191118e-02f,
  1.48597866e-01f, -2.86635663e-02f, 8.18830505e-02f, 2.13496685e-01f, 1.55414507e-01f, -6.82900148e-03f, -3.05606518e-04f, -1.29410416e-01f, 6.09893650e-02f, 9.73417982e-02f,
  -1.23636834e-01f, -8.59048739e-02f, 1.93695258e-02f, -1.30569384e-01f, -2.05929019e-03f, 2.04291001e-01f, 3.53101701e-01f, 1.68417484e-01f, -9.91115496e-02f, 2.38081962e-02f,
  -3.55236456e-02f, 1.40863582e-01f, 2.10811999e-02f, 9.30471253e-03f, 2.36941814e-01f, 2.25041453e-02f, 7.28899166e-02f, -1.96751673e-02f, 5.08283377e-02f, 4.53327179e-01f,
  2.85306454e-01f, 2.94822231e-02f, -5.55355363e-02f, 3.24098170e-02f, -4.23546806e-02f, -4.00874093e-02f, -4.46225191e-03f, -1.77065860e-02f, -3.16385776e-02f, 1.84092131e-02f,
  3.44514698e-02f, -2.20797230e-02f, 7.71557018e-02f, 1.39445756e-02f, 9.32382643e-02f, -1.04503684e-01f, -2.46599354e-02f, 5.77831790e-02f, 1.90477297e-02f, 9.19875596e-03f,
  4.99546331e-05f, 8.83399472e-02f, 3.13867405e-02f, -6.95558265e-02f, -5.36897182e-02f, 1.19471975e-01f, -7.21069202e-02f, 2.62785014e-02f, -1.11739181e-01f, 3.56442519e-02f,
  -1.88921986e-03f, -5.35944700e-02f, -9.00456980e-02f, -7.64800459e-02f, -3.44555527e-02f, 1.95696242e-02f, 1.89080890e-02f, 4.07765694e-02f, 2.66822823e-03f, -6.43936247e-02f,
  -6.38214126e-02f, 4.67636483e-03f, -8.20700638e-03f, -1.03849228e-02f, 4.78611328e-02f, -3.86552364e-02f, -2.36770455e-02f, -6.13026768e-02f, -3.84433493e-02f, -3.39126401e-02f,
  -4.22241874e-02f, -2.08313596e-02f, 2.53433324e-02f, -3.26144509e-02f, -2.63926592e-02f, -3.31929140e-02f, 5.04924729e-02f, -1.01659074e-02f, -4.06217948e-02f, 2.91613284e-02f,
  8.36355612e-02f, -2.87423193e-01f, 1.76675975e-01f, 6.33852333e-02f, 1.71373729e-02f, -4.25155507e-03f, -1.21704424e-02f, 1.37360580e-02f, 7.69448057e-02f, 1.11948699e-01f,
  -1.84763083e-03f, 2.56922971e-02f, -2.19737124e-02f, 1.80184729e-02f, -1.09035913e-02f, 1.22698015e-02f, 3.77211049e-02f, 9.14449021e-02f, 4.24433947e-02f, 9.11320560e-03f,
  4.27345410e-02f, 6.41082153e-02f, -3.76399048e-02f, -6.51339218e-02f, 4.85498123e-02f, 2.68346407e-02f, 1.07603006e-01f, 1.28937319e-01f, -7.63854384e-02f, 2.48492025e-02f,
  -5.06118089e-02f, 3.41529064e-02f, 2.37573057e-01f, -2.10518166e-01f, -2.12500114e-02f, -5.65284118e-02f, -1.06460854e-01f, -1.12289712e-01f, -2.01684773e-01f, -1.49180919e-01f,
  -1.08364865e-01f, -3.86066921e-02f, 1.49159618e-02f, 7.20660910e-02f, 6.78965002e-02f, -5.23788445e-02f, 3.99775282e-02f, 1.15682639e-01f, 9.51568559e-02f, -1.71194568e-01f,
  -8.67433697e-02f, -1.27744481e-01f, -1.10601559e-01f, -4.05738987e-02f, -1.17806852e-01f, -5.15904501e-02f, -2.73544248e-02f, 2.84096133e-03f, 1.17365375e-01f, 2.93738712e-02f,
  6.45664632e-02f, 5.26130237e-02f, 6.20529838e-02f, -5.06054014e-02f, 1.86670683e-02f, 4.30048518e-02f, 8.84451866e-02f, -1.25046857e-02f, 3.96966413e-02f, -4.08862345e-02f,
  -4.99280766e-02f, -6.45985231e-02f, -1.65447872e-03f, 1.19956926e-01f, 4.31723595e-02f, -7.88599700e-02f, 9.24458727e-02f, 8.18963870e-02f, 1.26713753e-01f, -4.89671305e-02f,
  6.06605895e-02f, 1.20328311e-02f, 1.25763312e-01f, 5.06423600e-02f, 1.72088981e-01f, 1.58868968e-01f, 1.02759726e-01f, 1.54220685e-01f, 2.47868985e-01f, 1.49971815e-02f,
  -2.54271198e-02f, -6.47986978e-02f, -1.14532389e-01f, 2.26638317e-02f, -8.95258598e-03f, 4.20011468e-02f, -2.77606230e-02f, -9.36755631e-03f, -6.00606725e-02f, -9.30671673e-03f,
  4.59492346e-03f, -8.66898224e-02f, 1.45205623e-02f, -9.24509391e-02f, -1.17478251e-01f, 6.58270717e-02f, 3.90573740e-02f, -2.84695309e-02f, 3.96653414e-02f, -4.07976285e-02f,
  5.25396802e-02f, -6.23884574e-02f, 4.75042425e-02f, 1.63082909e-02f, 5.21724857e-02f, 7.97369257e-02f, 1.44666359e-02f, -9.61021855e-02f, -9.05240551e-02f, 1.81379691e-02f,
  -1.21013492e-01f, 1.87638447e-01f, -3.95034142e-02f, -4.02711257e-02f, 8.17580372e-02f, 2.58529652e-02f, 4.74341586e-02f, 4.66558263e-02f, 3.81700099e-02f, 6.80865645e-02f,
  1.67466998e-02f, 3.29270177e-02f, -4.25810292e-02f, 2.44156960e-02f, -8.89121965e-02f, -2.91504711e-02f, -8.37652460e-02f, -6.91389292e-02f, -2.60681082e-02f, -1.02378301e-01f,
  -6.48232549e-02f, -5.04916683e-02f, -6.77140206e-02f, -2.90174223e-02f, -6.52154535e-02f, -9.95626301e-03f, -1.19932080e-02f, 3.53626683e-02f, -2.80988757e-02f, -2.29193628e-01f,
  5.64225726e-02f, -4.24769282e-01f, -1.18370205e-01f, 1.85878187e-01f, -5.84221520e-02f, -2.28888635e-02f, -2.80715942e-01f, -8.04435164e-02f, 1.66653991e-01f, -9.19882730e-02f,
  -2.61403751e-02f, 2.21780047e-01f, 1.90745458e-01f, 9.50104445e-02f, -3.77232134e-02f, -6.53175339e-02f, -5.53753190e-02f, 1.24693125e-01f, 1.77840233e-01f, -3.93487886e-02f,
  1.80329364e-02f, 5.98642454e-02f, 1.39214501e-01f, 8.33703205e-03f, -1.17947295e-01f, 1.77375481e-01f, 2.20368505e-02f, -6.42559528e-02f, -1.62666291e-01f, -1.18986815e-01f,
  -7.13237301e-02f, -2.88813174e-01f, 1.89443707e-01f, -4.35897987e-03f, 9.83395427e-03f, 5.53513132e-02f, -1.43586248e-02f, 1.52351167e-02f, -1.26845613e-02f, -6.38462603e-02f,
  -1.98408365e-02f, -1.06707469e-01f, -3.84000950e-02f, -1.19845949e-01f, -9.87356529e-02f, -1.88634265e-02f, -1.09243438e-01f, -8.40366036e-02f, -1.51947411e-02f, -1.67770553e-02f,
  -2.16513023e-01f, -4.03702408e-02f, -1.57800883e-01f, -9.42908004e-02f, -1.19655766e-01f, -2.66434830e-02f, -4.86098118e-02f, -3.92709374e-02f, -3.38114351e-02f, -6.71261474e-02f,
  1.99872945e-02f, -2.07133237e-02f, -1.29609182e-02f, 7.51771331e-02f, 2.78893989e-02f, 2.52015553e-02f, 1.10188229e-02f, 2.99064387e-02f, 2.14348193e-02f, 1.03864186e-01f,
  -2.16571875e-02f, 8.96755010e-02f, 3.59749123e-02f, 3.61461006e-02f, 1.31313443e-01f, -3.47120538e-02f, 4.62885341e-03f, 4.43139710e-02f, 6.41898066e-02f, 6.90315068e-02f,
  1.06295556e-01f, -1.60352830e-02f, 8.22228268e-02f, 9.43551660e-02f, 8.29992667e-02f, 5.37271909e-02f, 4.57721390e-02f, 4.87809926e-02f, 6.32998645e-02f, 1.01261988e-01f,
  1.75076887e-01f, -3.96476537e-02f, 1.05791375e-01f, 2.66291406e-02f, -4.15227003e-02f, -4.20737267e-02f, 2.60171890e-02f, 1.15289707e-02f, -8.18062108e-03f, -1.53064923e-02f,
  -5.21368794e-02f, 5.27502596e-02f, 2.45678015e-02f, -1.49347372e-02f, 6.97480813e-02f, 1.33928489e-02f, -9.50687304e-02f, 3.61943431e-02f, -1.54683171e-02f, -5.72316237e-02f,
  4.58856113e-02f, 2.94690933e-02f, 1.12067468e-01f, 9.04133320e-02f, 6.52282611e-02f, 2.40683153e-01f, 3.99154350e-02f, 9.12796110e-02f, 1.31731048e-01f, 6.26494363e-02f,
  5.04739463e-01f, 6.00524880e-02f, -1.84957877e-01f, 1.77851409e-01f, -9.26311389e-02f, -6.21248595e-02f, 6.99409470e-02f, 1.45951152e-01f, 1.72893927e-01f, 1.84920982e-01f,
  -1.17070228e-02f, 1.01185203e-01f, 4.26266752e-02f, 6.39166161e-02f, 1.05730863e-02f, 1.69105157e-02f, -8.72469842e-02f, -3.31137842e-03f, 8.07398185e-02f, 7.64296576e-02f,
  -7.69618973e-02f, 4.69161905e-02f, 1.01178341e-01f, 1.47717103e-01f, 2.14664191e-02f, 1.06194057e-01f, 4.90270834e-03f, -1.86060369e-02f, -7.76101798e-02f, -2.28338435e-01f,
  -6.61637038e-02f, 8.83573294e-02f, 1.85709819e-02f, 1.34336308e-01f, -1.26659935e-02f, 1.00777403e-01f, -1.79323144e-02f, -2.60511297e-03f, 5.79682738e-02f, 6.57887086e-02f,
  -8.33235607e-02f, 7.82691240e-02f, 2.93825474e-02f, -7.21590295e-02f, 6.61286265e-02f, 9.35910866e-02f, 2.72513889e-02f, -4.65996973e-02f, 6.87891915e-02f, -8.57378244e-02f,
  -1.51168108e-02f, -1.15447067e-01f, 1.88448541e-02f, -6.57725707e-02f, 5.47646955e-02f, -7.34467879e-02f, -1.20083932e-02f, 4.73967753e-02f, 9.73767415e-02f, 1.86147794e-01f,
  6.03728332e-02f, -7.67189488e-02f, 2.63690781e-02f, -6.64519565e-03f, 3.37689044e-03f, 1.26475906e-02f, -8.27449560e-02f, 5.47500663e-02f, -5.81528805e-02f, 3.46195549e-02f,
  3.78968865e-02f, 8.15636071e-04f, -7.48579344e-03f, 6.39252067e-02f, -1.07046686e-01f, 1.67990364e-02f, -5.14945425e-02f, 6.30688295e-02f, -5.42814992e-02f, 4.57146987e-02f,
  2.47473475e-02f, 2.76082824e-03f, -6.46772981e-02f, -1.59174502e-02f, -8.49421602e-03f, 4.59709056e-02f, -3.91556360e-02f, -4.02718559e-02f, -3.86690199e-02f, -2.64060050e-02f,
  1.91429749e-01f, -1.26283810e-01f, 4.19535004e-02f, 4.34185825e-02f, 6.10396154e-02f, -1.00170383e-02f, 4.74231131e-02f, 6.10803403e-02f, 1.63173694e-02f, 8.81660506e-02f,
  4.27576490e-02f, 4.72037159e-02f, -8.09728652e-02f, 1.98883545e-02f, 4.18185815e-03f, 2.09384020e-02f, 1.48162898e-02f, 9.44478065e-02f, 3.18947174e-02f, 3.80100682e-02f,
  4.45753522e-02f, 1.88347325e-01f, 2.11101681e-01f, 6.41524419e-02f, 7.11018145e-02f, 1.24376424e-01f, 1.46969175e-02f, 1.29172638e-01f, 1.11159824e-01f, 3.45774949e-01f,
  -3.82240295e-01f, 9.32665262e-03f, -1.86839655e-01f, -3.25201392e-01f, -3.81410122e-01f, -1.49155721e-01f, 1.37090636e-03f, 1.18117504e-01f, 1.50969960e-02f, 1.48763672e-01f,
  5.66353202e-02f, -4.79256064e-02f, -5.62328845e-02f, -5.49498498e-02f, 9.21687707e-02f, 1.10744961e-01f, 3.35426740e-02f, -1.54722109e-01f, -3.52118164e-01f, -2.80818611e-01f,
  -1.56510383e-01f, -2.63337165e-01f, -3.05026501e-01f, -7.65808895e-02f, -9.26912129e-02f, -1.54924169e-01f, 4.27923910e-03f, -2.36957014e-01f, -1.97173096e-02f, -1.41429901e-01f,
  -1.47823870e-01f, -1.64100096e-01f, 6.10117018e-02f, -5.05407266e-02f, -5.28197698e-02f, -2.35910378e-02f, -1.10277042e-01f, -2.82588881e-02f, 1.26563519e-01f, 3.52857597e-02f,
  -1.31257027e-01f, -3.77254523e-02f, 2.04295404e-02f, -9.31336079e-03f, -1.49321437e-01f, 6.58215582e-03f, 6.91350177e-02f, 1.17089808e-01f, 1.01255059e-01f, -7.10870922e-02f,
  -8.64636060e-03f, 3.41031794e-03f, 4.63067926e-02f, 1.78427473e-01f, 1.00804940e-01f, -6.19811118e-02f, 6.44457787e-02f, 1.92606624e-03f, 1.24206237e-01f, 1.18545793e-01f,
  1.88792095e-01f, 1.09215528e-02f, 1.40215773e-02f, -4.72937115e-02f, -3.88787650e-02f, 5.34457490e-02f, 3.36486287e-02f, 1.84407625e-02f, 5.78633975e-03f, -4.05592844e-02f,
  -7.13606924e-03f, 1.48379141e-02f, 7.58090476e-03f, 3.74174714e-02f, -8.33401177e-03f, -4.45919996e-03f, -3.17647234e-02f, -3.48105468e-02f, 3.45911607e-02f, -2.41824854e-02f,
  -7.04878345e-02f, -7.99134523e-02f, -6.05836734e-02f, -9.43620279e-02f, -1.57139786e-02f, 1.24187376e-02f, -1.83560271e-02f, 1.89377125e-02f, 1.41946115e-02f, -1.34936459e-02f,
  5.51759712e-02f, -4.41718139e-02f, -1.55112082e-02f, 6.94881603e-02f, 3.50855589e-02f, 1.75386637e-01f, 7.30745867e-02f, 1.66012943e-01f, -4.40796800e-02f, -3.53385061e-02f,
  -3.31951939e-02f, 1.99023876e-02f, -5.96407317e-02f, 5.92202321e-02f, -9.69717875e-02f, -6.17610440e-02f, 1.34929851e-01f, 1.31747555e-02f, 2.99790148e-02f, 1.92193105e-03f,
  9.72482935e-02f, 7.24453852e-02f, 4.93290052e-02f, 8.91259462e-02f, 1.13858201e-01f, 1.66907739e-02f, -4.21876311e-02f, 1.11885503e-01f, 1.42148301e-01f, 2.88657993e-01f,
  9.96183455e-02f, 2.92115092e-01f, -2.13840514e-01f, 2.40631491e-01f, -5.24353348e-02f, -1.59314647e-01f, -3.10458522e-02f, 5.72127476e-02f, 1.68780729e-01f, -4.61051660e-03f,
  5.47795407e-02f, 4.06577857e-03f, -4.62092869e-02f, 4.39186320e-02f, -2.71214377e-02f, -2.51651332e-02f, 9.14890543e-02f, -3.47455628e-02f, -1.08114235e-01f, -2.89423224e-02f,
  8.76981542e-02f, 1.17875963e-01f, 7.80038834e-02f, 1.88197970e-01f, 1.19383626e-01f, -5.05974106e-02f, 3.49850282e-02f, 1.31137371e-01f, 1.46199897e-01f, 2.54589111e-01f,
  -2.10653469e-01f, 7.88059980e-02f, 2.20432784e-02f, 1.69249535e-01f, 8.22635069e-02f, 1.62964892e-02f, 6.88505024e-02f, 5.05237058e-02f, 9.80449691e-02f, 1.42630026e-01f,
  7.01008886e-02f, 8.19015279e-02f, 5.76464832e-02f, 6.84533417e-02f, 1.29075304e-01f, 6.23592846e-02f, 1.49006501e-01f, 3.68440300e-02f, 3.42766270e-02f, -1.13798669e-02f,
  1.46024823e-02f, 3.84257846e-02f, -1.08940043e-01f, 7.97256306e-02f, 2.84876227e-02f, 1.28818871e-02f, 8.25505927e-02f, 6.53998693e-03f, -1.59527082e-02f, 1.96712315e-01f,
  -3.82611118e-02f, -9.31831747e-02f, -4.03512940e-02f, 5.88596873e-02f, -6.71207458e-02f, -1.40164539e-01f, -1.47920195e-02f, 6.02162145e-02f, 5.99056599e-04f, 9.84823424e-03f,
  -6.87982589e-02f, -5.90226352e-02f, 1.84142962e-02f, -5.52717261e-02f, -6.04280494e-02f, -1.15445144e-01f, -5.21041118e-02f, -4.38499190e-02f, -3.73179838e-02f, -1.20233335e-02f,
  -8.62736180e-02f, -7.70615786e-02f, -1.38224110e-01f, -1.02801427e-01f, 3.46615911e-02f, -7.25543685e-03f, -5.19346222e-02f, -1.10410929e-01f, -4.04472649e-03f, -7.23745003e-02f,
  -2.42443401e-02f, -5.53338453e-02f, 5.77739589e-02f, 9.52221006e-02f, 6.24134950e-02f, 5.95724992e-02f, 1.19402505e-01f, 1.04742855e-01f, 1.36701008e-02f, -5.23774140e-02f,
  -2.99780574e-02f, 6.16712980e-02f, 4.90485094e-02f, 4.98138219e-02f, 1.31715134e-01f, 7.98125491e-02f, 2.63504940e-03f, 3.60371806e-02f, 1.38257146e-01f, 5.63875251e-02f,
  9.39574465e-02f, -3.64859104e-02f, -1.96373969e-01f, -6.29045814e-02f, 8.27110466e-03f, -9.09247622e-02f, 2.06424352e-02f, 6.08611889e-02f, 1.83079112e-02f, 8.79137218e-02f,
  -6.45351470e-01f, 3.25204760e-01f, -3.45313460e-01f, -1.78359583e-01f, 1.13756783e-01f, 3.57531458e-02f, 3.24720480e-02f, -9.84992906e-02f, 8.60713236e-03f, 2.40603369e-02f,
  2.74304390e-01f, 9.15007293e-02f, -3.60450223e-02f, -6.72183633e-02f, -1.87140062e-01f, -1.13434263e-01f, -1.52346939e-01f, -3.91187459e-01f, -2.71033227e-01f, 1.27984285e-01f,
  2.53315359e-01f, 6.61137179e-02f, -1.15804240e-01f, -1.01957798e-01f, 6.84673041e-02f, 7.63556808e-02f, 8.44811946e-02f, 6.71784803e-02f, 1.14432715e-01f, -1.12552457e-01f,
  2.91137025e-02f, 2.81393658e-02f, -5.62978238e-02f, 4.21404615e-02f, 1.17100708e-01f, -5.40486015e-02f, 8.05079639e-02f, -8.95024091e-02f, -2.04639789e-02f, 7.69644007e-02f,
  -5.40620945e-02f, 9.87888202e-02f, -1.86070371e-02f, 9.46837664e-02f, 2.33150497e-02f, 2.18310114e-02f, 1.70777421e-02f, -1.61902606e-01f, -4.92965356e-02f, 8.25286657e-02f,
  8.59092698e-02f, 1.80860862e-01f, -8.36432502e-02f, 9.12658870e-02f, -1.08643442e-01f, -7.43642543e-03f, 8.86157230e-02f, -5.15476651e-02f, -9.42409933e-02f, 5.76838702e-02f,
  9.29269865e-02f, 1.78976059e-02f, -5.19401170e-02f, 2.63630692e-02f, 1.61690954e-02f, 4.02172096e-02f, -1.27138421e-01f, 3.05239367e-03f, -6.76713884e-04f, 1.26689300e-02f,
  2.82514486e-02f, -4.56970558e-02f, -3.27354223e-02f, 3.70613262e-02f, 7.37435818e-02f, -5.16663566e-02f, -4.61006500e-02f, 6.21284619e-02f, -2.03433167e-02f, 2.98130624e-02f,
  2.83015221e-02f, -3.97697054e-02f, -1.69342719e-02f, -6.97115213e-02f, 3.59324664e-02f, -2.03368589e-02f, -7.48762637e-02f, 8.20441693e-02f, 3.50621156e-02f, 9.22090635e-02f,
  6.54246286e-02f, -8.68426710e-02f, -5.32559939e-02f, -2.06999737e-03f, -1.00661352e-01f, 2.50329040e-02f, -1.50734875e-02f, -2.19357815e-02f, -2.60208435e-02f, -8.13742653e-02f,
  4.57640067e-02f, -1.35251239e-01f, 8.40792526e-03f, 5.20574488e-02f, -7.65461847e-02f, 1.22843655e-02f, 1.37070090e-01f, -2.91679241e-02f, -6.90572932e-02f, 8.13519061e-02f,
  -1.28376409e-02f, 1.67950839e-02f, -5.46939000e-02f, -1.04846269e-01f, 4.26455550e-02f, -7.62372911e-02f, -5.21160197e-03f, -4.53676842e-02f, -1.27614945e-01f, 1.53266415e-02f,
  4.13625389e-01f, 1.01362437e-01f, -3.54177505e-02f, 1.05881542e-01f, 9.44268554e-02f, 2.23683223e-01f, 4.35015112e-01f, 2.42375746e-01f, 1.19315110e-01f, 1.00865565e-01f,
  -5.54178543e-02f, -1.75202042e-01f, -6.39559701e-02f, -1.99080750e-01f, 9.13374275e-02f, 1.32685602e-01f, 1.36085913e-01f, 2.21425202e-02f, 1.34659007e-01f, 1.46213874e-01f,
  -5.20674214e-02f, 1.00513138e-01f, 1.45292744e-01f, -6.38181493e-02f, -4.91258688e-02f, -2.02589296e-02f, -1.08716907e-02f, 7.20873475e-03f, 2.01434083e-02f, -8.84901509e-02f,
  -1.20074980e-01f, 1.64976284e-01f, 5.77697605e-02f, -4.29657139e-02f, -1.78459417e-02f, 5.16367815e-02f, 1.93379968e-02f, -6.91925138e-02f, -5.64748514e-03f, 1.79890438e-03f,
  -2.21952870e-02f, -3.40725668e-02f, -2.02194881e-02f, -7.97878131e-02f, 4.51574139e-02f, 3.70550379e-02f, -3.36964950e-02f, 1.24125011e-01f, -1.30795566e-02f, 1.11310899e-01f,
  -1.53692160e-02f, 7.17873201e-02f, 5.61163463e-02f, 5.88706806e-02f, 8.31388235e-02f, -1.47243775e-02f, -1.10685743e-01f, -1.93401203e-02f, -3.49877328e-02f, 2.36363318e-02f,
  -1.47801195e-03f, -9.89629328e-02f, -5.89331202e-02f, -1.38303852e-02f, -1.30525203e-02f, -1.13378465e-01f, -6.84310198e-02f, -4.61766198e-02f, -6.79827780e-02f, -1.01935588e-01f,
  -1.04024179e-01f, -6.50237948e-02f, -1.27898335e-01f, 2.26578284e-02f, -5.95854479e-04f, 7.20471963e-02f, 3.44618261e-02f, -5.91388047e-02f, -2.99043637e-02f, 2.43391190e-02f,
  -4.28818241e-02f, 5.93563216e-03f, 5.81443310e-02f, 4.13808674e-02f, -2.80333813e-02f, -4.16344814e-02f, -3.02329976e-02f, 2.87223272e-02f, -9.60367769e-02f, 5.37482277e-02f,
  -4.06352915e-02f, 9.35623720e-02f, 2.23061461e-02f, -1.20565491e-02f, -4.04264703e-02f, -5.96562251e-02f, 5.95342815e-02f, 8.31556395e-02f, 6.86471164e-02f, 1.01149969e-01f,
  1.15405813e-01f, 5.51810004e-02f, -8.01317990e-02f, 2.23855190e-02f, 1.02616884e-02f, 1.08805671e-01f, -3.15155871e-02f, 4.22710143e-02f, -1.02758000e-03f, 1.51244491e-01f,
  6.20000735e-02f, 1.11875288e-01f, 8.08342174e-02f, 1.19831413e-02f, 3.27450559e-02f, 1.43973857e-01f, 8.55940506e-02f, 1.92626622e-02f, 8.26110020e-02f, 1.27875239e-01f,
  5.66176176e-01f, 1.25603735e-01f, 6.56704903e-02f, 4.39907640e-01f, 2.04684377e-01f, -3.29576656e-02f, 9.97125506e-02f, -7.87326694e-03f, 1.83975771e-01f, 1.38264403e-01f,
  -1.63161587e-02f, 2.36942004e-02f, 5.74947484e-02f, 4.32244409e-03f, 5.53603508e-02f, 1.08152926e-01f, 1.66576579e-01f, 5.96203580e-02f, 9.46150869e-02f, 8.74721333e-02f,
  8.97753984e-02f, 2.93274969e-01f, 2.05901638e-01f, 5.92335314e-02f, 1.02215372e-01f, 4.73568402e-02f, 3.76977883e-02f, 4.18231785e-02f, -8.67994055e-02f, 1.42810732e-01f,
  3.43957543e-02f, 5.47750294e-02f, 3.00862510e-02f, 8.78886208e-02f, 7.22109228e-02f, 5.51451892e-02f, -9.06452071e-03f, -1.20243235e-02f, -5.19211441e-02f, 3.50348875e-02f,
  1.10090710e-02f, -2.87107024e-02f, 4.73005921e-02f, 4.15639132e-02f, 1.63757443e-01f, -2.34863423e-02f, 3.01290210e-02f, 1.20882867e-02f, 1.03010740e-02f, -3.51725542e-03f,
  1.79648120e-02f, 7.88975209e-02f, 6.59620762e-03f, -7.55383298e-02f, -2.06187852e-02f, 1.29145131e-01f, -2.17073485e-02f, -1.01488903e-01f, -9.49421227e-02f, 5.34897558e-02f,
  -3.71743063e-03f, -1.39810875e-01f, 1.69824017e-03f, -5.12792617e-02f, 4.89402637e-02f, -9.76369381e-02f, 1.34122204e-02f, 5.19351102e-02f, -4.33629677e-02f, 1.22676883e-02f,
  -2.18809675e-02f, 8.85891542e-02f, -3.69362161e-02f, 8.88077449e-03f, -8.20768625e-03f, 7.85749964e-03f, 5.76955825e-02f, 2.16528755e-02f, 9.51017737e-02f, 5.17346859e-02f,
  1.75333824e-02f, 8.81541564e-05f, -4.30666208e-02f, -1.90331824e-02f, 4.16829810e-02f, 7.65741915e-02f, 3.72524112e-02f, -8.09190199e-02f, -3.12594064e-02f, 7.34534413e-02f,
  1.37490660e-01f, -1.02294698e-01f, 8.99227634e-02f, -1.15359221e-02f, -6.51567010e-03f, -7.90282786e-02f, 5.48245013e-02f, -2.61553396e-02f, 1.30313739e-01f, 9.01815593e-02f,
  6.42038956e-02f, 2.62431111e-02f, 4.51567806e-02f, -1.01528078e-01f, 1.81628559e-02f, -1.20048719e-02f, 4.80803587e-02f, 1.65890083e-01f, -4.29875124e-03f, -7.32155815e-02f,
  -1.24826275e-01f, -6.63092658e-02f, 8.13605413e-02f, -5.87999858e-02f, -7.49598369e-02f, 1.25308782e-01f, -7.46424124e-03f, -9.19495896e-02f, -5.02796359e-02f, 8.38406608e-02f,
  -1.99120387e-01f, -3.41946810e-01f, 1.80968866e-01f, -1.24542393e-01f, -1.95523337e-01f, -1.49997190e-01f, -3.56578112e-01f, -1.10531934e-01f, -9.99702439e-02f, -1.73399761e-01f,
  -3.16202454e-02f, 3.35426748e-01f, 3.25237602e-01f, 1.81118950e-01f, 2.44668663e-01f, -2.85071224e-01f, -2.08081275e-01f, 2.17518464e-01f, 3.25450540e-01f, -1.52487708e-02f,
  2.19551679e-02f, -1.01257503e-01f, 1.34346932e-01f, 4.17801291e-02f, -1.00718230e-01f, 1.57308593e-01f, 2.81227026e-02f, -7.98476264e-02f, 1.17482260e-01f, 6.33311793e-02f,
  2.81792790e-01f, -1.45571098e-01f, 7.86268860e-02f, -6.13974594e-02f, -4.97300550e-02f, -4.65279408e-02f, -1.13072339e-02f, 2.78530270e-02f, -8.63623470e-02f, 4.31203358e-02f,
  1.34296175e-02f, 3.51011120e-02f, -6.51587080e-03f, 8.16069990e-02f, -7.36953914e-02f, 3.19627225e-02f, -5.91121688e-02f, 8.39660466e-02f, -8.97601023e-02f, -7.40711857e-03f,
  -2.86683775e-02f, -2.07675725e-01f, -5.08368574e-02f, -1.35019436e-01f, -6.35166653e-03f, 2.32554972e-02f, -3.96136977e-02f, -9.27321836e-02f, 5.03601804e-02f, -1.10936299e-01f,
  -1.14768066e-01f, -8.26612189e-02f, -5.22198491e-02f, 3.03490423e-02f, -6.24583010e-03f, -2.11255215e-02f, 8.94770399e-02f, 2.54103113e-02f, 1.02742516e-01f, -3.42286564e-02f,
  3.13368589e-02f, -2.04445012e-02f, 5.55969141e-02f, -3.80648486e-02f, 9.81515795e-02f, -3.85360979e-02f, 5.09071462e-02f, -5.41025102e-02f, 2.64115981e-03f, -3.73075679e-02f,
  5.67847863e-02f, 1.79896168e-02f, 2.64329985e-02f, 5.19619845e-02f, 4.29379120e-02f, 8.40931907e-02f, 1.09305233e-01f, 4.71744947e-02f, 8.52572098e-02f, -3.73929702e-02f,
  2.06994295e-01f, -1.62564758e-02f, -1.98009089e-02f, -8.42638090e-02f, -1.63508862e-01f, -9.41308066e-02f, -2.80793831e-02f, -1.68663040e-01f, -2.84178536e-02f, 1.07807005e-02f,
  -2.41471436e-02f, -1.20792650e-02f, 8.35386589e-02f, -3.68061773e-02f, -6.35024831e-02f, -7.98436999e-02f, -8.81479401e-03f, -5.35266139e-02f, -6.82920590e-02f, -1.51705101e-01f,
  -1.20639369e-01f, -9.80780944e-02f, -2.43150368e-02f, -2.24304516e-02f, -9.48706046e-02f, -7.77778700e-02f, -2.48425896e-03f, 1.31399781e-02f, 4.50877026e-02f, -1.28496855e-01f,
  -3.68212372e-01f, -2.81369001e-01f, 5.45531698e-02f, -1.08561121e-01f, -1.70123205e-01f, -4.41937447e-02f, -2.65474498e-01f, 9.05786380e-02f, 5.33661135e-02f, -1.44713357e-01f,
  1.79847721e-02f, 3.48910809e-01f, 2.33340561e-01f, 3.19491416e-01f, 2.40739763e-01f, -2.07821220e-01f, -1.87213644e-01f, 8.84550139e-02f, 3.20405185e-01f, 5.89869432e-02f,
  -7.25955889e-02f, -1.83999971e-01f, 1.19634103e-02f, 1.35666430e-01f, -1.92265943e-01f, 5.18999510e-02f, -1.44640341e-01f, -1.76315680e-01f, -9.03853551e-02f, -1.64919049e-01f,
  1.20088413e-01f, 7.70822749e-04f, 1.42612413e-01f, 8.39212611e-02f, 9.96998418e-03f, 1.80615131e-02f, -2.33126599e-02f, -7.20016006e-03f, -1.81092005e-02f, -5.66432811e-03f,
  -6.40370175e-02f, 8.51947740e-02f, -1.48842600e-03f, 7.01371133e-02f, -8.40965193e-03f, 5.20016477e-02f, -5.52758425e-02f, 2.09276378e-02f, 1.13044083e-01f, 1.35449404e-02f,
  -8.60234126e-02f, -3.08349598e-02f, -1.82108022e-02f, 1.44144446e-01f, 7.20116049e-02f, 5.53666912e-02f, 3.70784067e-02f, 9.62260067e-02f, 1.89486504e-01f, -1.10740833e-01f,
  -9.76597443e-02f, -3.17926332e-03f, 3.12258378e-02f, -9.40763131e-02f, -1.24656662e-01f, -8.28537866e-02f, 6.25243783e-02f, -8.18204656e-02f, 2.00290941e-02f, -1.40764732e-02f,
  -2.64311638e-02f, -5.47402203e-02f, 2.96371374e-02f, -6.82933703e-02f, -7.84303900e-03f, 4.77470197e-02f, -2.70582549e-02f, -2.38189362e-02f, 4.38766703e-02f, -3.44097540e-02f,
  1.78228635e-02f, -7.28768557e-02f, 7.41947815e-02f, 9.93021298e-03f, -7.38481283e-02f, -8.87596421e-03f, -2.39623003e-02f, 1.35678072e-02f, 1.86397582e-02f, -1.51657864e-01f,
  1.88052103e-01f, 2.92690814e-01f, 3.55488248e-02f, 5.85101806e-02f, -5.01299016e-02f, 5.98684102e-02f, -7.81198777e-03f, -1.04452960e-01f, -4.30554301e-02f, -5.22580482e-02f,
  -1.96859557e-02f, -4.13153544e-02f, -4.03036326e-02f, -3.28908372e-03f, 5.18228374e-02f, -3.79060246e-02f, -9.77543965e-02f, 5.87538332e-02f, 1.15387244e-02f, 5.00220656e-02f,
  -7.10211992e-02f, -1.29534388e-02f, 9.35505405e-02f, 1.25006974e-01f, -8.99107531e-02f, 1.06037445e-01f, 8.44326839e-02f, -2.33483128e-02f, 5.12866899e-02f, -9.34230313e-02f,
  2.79125839e-01f, -1.07265763e-01f, -2.65148699e-01f, 2.33706906e-01f, -1.43091753e-01f, -2.12188572e-01f, -2.81191945e-01f, -4.92227748e-02f, 2.33528167e-01f, -1.79358929e-01f,
  -2.16956139e-02f, 2.16937438e-01f, 1.33278221e-01f, 9.27206781e-03f, 8.09528977e-02f, -2.51278222e-01f, 8.88131093e-03f, 1.18721224e-01f, 1.87728480e-01f, 1.26333848e-01f,
  6.80062324e-02f, 7.46679455e-02f, 1.52513787e-01f, 1.58578232e-01f, 2.10571941e-03f, 1.56699374e-01f, -1.10106297e-01f, -7.17999563e-02f, -1.56537071e-01f, 1.01476104e-03f,
  -1.95650607e-01f, -2.02693567e-02f, 5.73980529e-03f, 7.04496577e-02f, 1.47948181e-02f, 1.29581420e-02f, 4.54355665e-02f, 6.49040788e-02f, -3.36584300e-02f, 3.37561294e-02f,
  -2.12571807e-02f, 2.47290879e-02f, 1.56110093e-01f, 8.31735283e-02f, 8.67823735e-02f, 8.62241387e-02f, 9.43364054e-02f, -4.55179298e-03f, -4.79227938e-02f, 9.83979367e-03f,
  2.35744696e-02f, 4.95496467e-02f, -1.80128720e-02f, -5.49493134e-02f, 4.51197401e-02f, 1.07982822e-01f, -8.26225951e-02f, 1.00547457e-02f, 7.45934620e-02f, 2.29965281e-02f,
  1.22970559e-01f, -4.87658828e-02f, -9.61437672e-02f, -3.13877538e-02f, -6.32920936e-02f, -1.69290863e-02f, 8.35467887e-04f, -3.90745103e-02f, -1.54428845e-02f, -1.70354843e-02f,
  -4.41410840e-02f, -1.04177237e-01f, 3.77765521e-02f, 1.34397410e-02f, -6.40242547e-02f, 2.20118575e-02f, -3.14812995e-02f, -4.57207556e-04f, -9.46234688e-02f, -1.13585393e-03f,
  -1.70826968e-02f, -7.88832025e-04f, -8.65457021e-03f, 6.90159127e-02f, -3.50331212e-03f, -2.20122114e-02f, -8.41803011e-03f, 1.71706658e-02f, 4.72319946e-02f, 2.45135333e-02f,
  1.59701798e-02f, 1.13977738e-01f, 5.57617098e-03f, 5.21098003e-02f, 1.51798716e-02f, 9.12166014e-03f, 4.88952249e-02f, -5.03574274e-02f, -8.49362239e-02f, -4.17565405e-02f,
  1.92948673e-02f, 1.16172498e-02f, -3.26157436e-02f, 1.57573879e-01f, -3.30644064e-02f, -7.54639357e-02f, 1.54195670e-02f, 8.86486992e-02f, -5.45984507e-02f, 6.34361953e-02f,
  3.24526206e-02f, -3.38854939e-02f, 7.98072014e-03f, -6.36527836e-02f, -8.66013765e-02f, 6.63635358e-02f, 1.33303022e-02f, 6.33965386e-03f, -8.55248645e-02f, 3.60387787e-02f,
  6.84147105e-02f, -2.67553069e-02f, 1.85628317e-03f, 9.91940964e-03f, -2.97337800e-01f, -3.28242838e-01f, -3.96609008e-01f, -1.58005700e-01f, 2.73610465e-02f, -1.91550180e-01f,
  -1.02757521e-01f, 7.12694600e-02f, 1.05287902e-01f, 2.29306757e-01f, 1.42348930e-01f, -1.53787136e-01f, 2.11182088e-01f, 3.31451088e-01f, 5.35115190e-02f, -9.28473659e-03f,
  7.92005658e-02f, 1.83363214e-01f, 2.90948719e-01f, 2.79953510e-01f, 7.30369538e-02f, 1.11124806e-01f, 7.39587322e-02f, 9.06572118e-02f, -1.17573915e-02f, 3.69675666e-01f,
  -1.05119556e-01f, -1.53513895e-02f, -6.16954528e-02f, 6.80736452e-02f, -5.17664813e-02f, 2.14557033e-02f, 6.00288098e-04f, 1.34303272e-01f, -8.00220370e-02f, -3.04808076e-02f,
  -1.35693178e-02f, 4.69078608e-02f, 3.33735347e-03f, 5.88394850e-02f, -1.30374357e-01f, -7.26903230e-03f, 3.40651572e-02f, 1.69018805e-01f, 2.42469087e-02f, 7.00540887e-03f,
  1.24116339e-01f, 7.98408017e-02f, -4.60969806e-02f, -1.61184371e-02f, -7.70547837e-02f, 1.31692201e-01f, -9.83176231e-02f, 2.52518579e-02f, -2.62189601e-02f, 1.40447944e-01f,
  1.94708612e-02f, 5.86350448e-03f, 3.08588818e-02f, -2.49728747e-02f, -5.35926335e-02f, 2.46973187e-02f, -4.43822145e-02f, 1.53114609e-02f, 4.48365025e-02f, 4.14085053e-02f,
  7.76619315e-02f, -8.56202096e-02f, 2.67221089e-02f, 3.73368226e-02f, 6.87437505e-02f, 8.65402147e-02f, 4.35167402e-02f, 5.91863953e-02f, 5.48117831e-02f, -4.37851660e-02f,
  1.88109130e-02f, 4.59698886e-02f, 5.42906858e-02f, 1.02128953e-01f, 5.09916395e-02f, 6.84736595e-02f, 1.12815380e-01f, 3.48182134e-02f, -9.73351747e-02f, 3.46756680e-03f,
  -8.05678740e-02f, -4.74022664e-02f, 1.71403692e-03f, -3.77848418e-03f, -4.75101285e-02f, 3.55257541e-02f, 1.88426729e-02f, 2.91583710e-03f, -5.07899374e-02f, -3.06177810e-02f,
  -8.26346725e-02f, 5.02491929e-02f, -1.42459437e-01f, 6.01559542e-02f, -1.20208740e-01f, -7.80858994e-02f, 1.78709161e-02f, 1.87609848e-02f, -3.73534411e-02f, -8.12858939e-02f,
  -6.40406683e-02f, -3.07680704e-02f, -1.35885060e-01f, -1.23433694e-01f, -6.35062009e-02f, -9.25649926e-02f, -8.16074163e-02f, -7.55005181e-02f, -1.11264072e-01f, -6.20816350e-02f,
  7.82268980e-05f, 2.81722397e-01f, 1.10565200e-01f, 1.29579203e-02f, 6.39354344e-03f, 6.79603666e-02f, 3.08236867e-01f, 8.00115231e-04f, -2.21717194e-01f, 1.27601564e-01f,
  8.88996199e-02f, -5.82045913e-02f, -8.19118693e-02f, 4.13047299e-02f, -3.40912342e-02f, 1.10766813e-01f, 4.21523936e-02f, -7.93598071e-02f, -2.47634843e-01f, -3.38050462e-02f,
  -6.55764043e-02f, -1.53533034e-02f, 1.56668387e-02f, 2.79589184e-02f, -3.32647329e-03f, -2.59826183e-01f, -1.80303026e-03f, 8.24347287e-02f, 8.11641291e-02f, 9.39794555e-02f,
  9.55494270e-02f, 1.51449412e-01f, -9.99344811e-02f, -4.49072309e-02f, -4.24148217e-02f, 4.46625389e-02f, -7.68368784e-03f, -7.89558813e-02f, -1.87935885e-02f, -4.43969220e-02f,
  7.31821358e-02f, -6.26803637e-02f, 4.03465219e-02f, 2.41585192e-03f, -4.08362523e-02f, 3.26390639e-02f, 4.81198691e-02f, -3.05605847e-02f, 2.06091553e-02f, 1.28461316e-01f,
  -1.31450202e-02f, -2.38666032e-02f, 1.11205429e-01f, 3.58914323e-02f, -3.23623009e-02f, -6.90742880e-02f, -4.52564321e-02f, -8.73745903e-02f, -4.89088520e-02f, -1.00068659e-01f,
  -1.64043427e-01f, 6.77267089e-02f, 3.92763652e-02f, 5.12989573e-02f, 1.65743253e-03f, -3.64883505e-02f, 4.55652736e-02f, -6.83641806e-02f, -2.53438316e-02f, 1.56863835e-02f,
  -2.65310351e-02f, 1.37093719e-02f, -8.49703047e-03f, 1.65818632e-02f, -2.52920650e-02f, 6.63670525e-02f, -4.12052264e-03f, 2.75650863e-02f, 9.85298678e-02f, 9.60548818e-02f,
  -1.29535012e-02f, 1.04117557e-01f, 3.60844508e-02f, 2.63674948e-02f, -3.20726261e-02f, -2.70444509e-02f, -1.70867518e-02f, -2.68189143e-02f, 4.51498851e-02f, 3.96729745e-02f,
  -2.06628665e-01f, 1.15581661e-01f, -5.01716137e-02f, -4.69840057e-02f, -9.74446163e-02f, -6.11627894e-03f, 1.07557580e-01f, -5.62687404e-02f, -5.91336377e-02f, 8.57331045e-03f,
  4.36547250e-02f, -2.71159858e-02f, 3.67919840e-02f, 4.90697473e-02f, -2.89616138e-02f, -1.57569884e-03f, -4.77388948e-02f, 2.74608303e-02f, -9.42666754e-02f, -8.83205310e-02f,
  -9.28454250e-02f, -1.76177204e-01f, -1.81541353e-01f, -5.52874506e-02f, -1.65311933e-01f, -2.53435314e-01f, -1.38424739e-01f, -7.56573007e-02f, -1.17104851e-01f, -2.19328716e-01f,
  3.63657832e-01f, 6.12748694e-03f, -9.74523742e-03f, -1.90703914e-01f, -3.02413255e-01f, -6.51291162e-02f, 1.24473721e-01f, 8.13951790e-02f, 2.15289984e-02f, 5.75418174e-02f,
  -2.06362590e-01f, -1.87274307e-01f, -1.26938552e-01f, 2.46918947e-02f, 2.25687206e-01f, 1.03611678e-01f, 7.77971745e-02f, 8.15379173e-02f, 2.64519006e-01f, 5.47297299e-02f,
  -1.03028268e-01f, 1.00622989e-01f, 1.42635047e-01f, 1.27789050e-01f, 3.69397774e-02f, 1.42958879e-01f, -1.06051657e-02f, 8.74839649e-02f, 2.14947723e-02f, 6.95371479e-02f,
  1.54334441e-01f, 4.64352816e-02f, -4.41620275e-02f, 7.03248978e-02f, -1.20251160e-03f, 1.77443922e-02f, 1.48276379e-02f, 7.21767694e-02f, 5.48891351e-02f, -2.52269916e-02f,
  1.14738215e-02f, -8.45529884e-02f, -6.27908260e-02f, 2.22008899e-02f, 2.32307333e-02f, 1.02031462e-01f, -2.56609861e-02f, 1.79035574e-01f, -2.28826841e-03f, 9.61851031e-02f,
  -9.51936096e-02f, -1.89707000e-02f, 1.57707296e-02f, 1.15797967e-02f, 2.56803110e-02f, 2.68682875e-02f, -3.20707895e-02f, 1.43566817e-01f, 2.24478900e-01f, 2.78796256e-01f,
  9.96952411e-03f, 4.38565649e-02f, -9.95358452e-02f, -1.15793722e-03f, 8.77277367e-03f, -6.82535693e-02f, 4.64298716e-03f, 1.53505802e-02f, -1.63235366e-02f, 5.86226396e-02f,
  -3.73402499e-02f, -1.54501945e-02f, -2.40748972e-02f, -4.12840880e-02f, -3.35615203e-02f, -9.06654000e-02f, 8.09963327e-03f, -4.71570529e-02f, -5.90868928e-02f, -6.44400790e-02f,
  1.23867318e-02f, -6.87053278e-02f, -9.66315195e-02f, -2.63486840e-02f, 3.36411558e-02f, 2.07623979e-03f, -8.04417059e-02f, 3.93700860e-02f, -5.55615351e-02f, 4.93894629e-02f,
  3.58765647e-02f, -1.60175607e-01f, 1.35938644e-01f, 8.81443322e-02f, -5.59918769e-03f, -7.38109602e-03f, -8.60682502e-02f, 1.51398201e-02f, 1.47049474e-02f, 8.67879018e-02f,
  2.42619533e-02f, 8.85151178e-02f, 5.15896603e-02f, 1.66859291e-02f, 1.15461145e-02f, 1.25469118e-01f, 5.11764474e-02f, 5.85562252e-02f, -1.21157672e-02f, -2.99258698e-02f,
  7.40404576e-02f, 8.37090835e-02f, 1.77339271e-01f, 1.84750810e-01f, 1.61515772e-02f, 1.43979371e-01f, 1.94895029e-01f, 1.38976336e-01f, 1.82875410e-01f, 3.34922642e-01f,
  -4.54998285e-01f, 1.25394270e-01f, -1.80016890e-01f, 5.63130789e-02f, 1.60833582e-01f, 7.44376285e-03f, 2.37203222e-02f, 2.94126049e-02f, 6.48962567e-03f, 5.73542044e-02f,
  7.89696947e-02f, -7.64896497e-02f, -1.23175569e-01f, 4.94253226e-02f, -7.32923597e-02f, -6.77556470e-02f, 7.21422657e-02f, -2.12010324e-01f, -2.07873017e-01f, 2.23477948e-02f,
  6.48089871e-02f, -2.98238918e-02f, -8.33879933e-02f, 3.54509689e-02f, 1.75915822e-01f, 3.01459134e-02f, 1.29429802e-01f, 1.81713000e-01f, 1.55541927e-01f, 1.49358913e-01f,
  -1.34579957e-01f, 1.60321265e-01f, -6.12379946e-02f, 3.42515782e-02f, 6.45208731e-02f, -4.05706465e-03f, 1.96126215e-02f, 6.29020184e-02f, 9.16575119e-02f, 6.46540746e-02f,
  1.65489629e-01f, 8.67410377e-02f, -1.27319442e-02f, 9.00063291e-02f, -2.82154344e-02f, 1.36135602e-02f, 1.30420417e-01f, 1.18751749e-01f, 9.69475880e-02f, 4.66246232e-02f,
  1.98404178e-01f, 1.74763665e-01f, 3.48364972e-02f, 5.76866150e-04f, 5.25757205e-03f, 3.87798324e-02f, 6.40503466e-02f, 1.85662076e-01f, 1.49174899e-01f, -1.09181833e-02f,
  -1.87042821e-02f, -2.83281580e-02f, 3.62055283e-03f, -3.54067143e-03f, 6.08753180e-03f, -5.72780818e-02f, 6.22351319e-02f, -4.89657894e-02f, -1.02059700e-01f, -8.87146592e-02f,
  1.33939898e-02f, 2.30847206e-02f, -5.51089831e-02f, -7.44887441e-02f, 3.57592367e-02f, 9.93400365e-02f, -8.30501765e-02f, 4.68018614e-02f, 3.68267857e-02f, 1.31938942e-02f,
  4.96362001e-02f, 2.72304937e-02f, -8.73922650e-03f, 5.42239193e-03f, 1.76008716e-02f, 4.53741252e-02f, 3.35175768e-02f, 4.56946008e-02f, -4.73731309e-02f, 4.38478701e-02f,
  -1.61670640e-01f, 1.91743765e-02f, -6.91886842e-02f, -6.21259026e-03f, -4.52560298e-02f, 1.09816648e-01f, 1.07265890e-01f, 3.33220735e-02f, 1.13893554e-01f, 5.01705781e-02f,
  4.21847031e-03f, -7.18016364e-03f, 4.78281565e-02f, 1.03109172e-02f, 9.81190335e-03f, 4.18516016e-03f, 8.03170651e-02f, -7.04013407e-02f, 1.26227662e-02f, 1.13051467e-01f,
  -2.92660855e-02f, -4.86232452e-02f, -1.66443124e-01f, 2.27414090e-02f, 6.05014637e-02f, 1.06429374e-02f, 2.33256854e-02f, -5.55270258e-03f, -1.37235999e-01f, -2.17990518e-01f,
  -4.04015392e-01f, -2.11179629e-02f, 3.09541285e-01f, -1.86745465e-01f, 1.25298470e-01f, 1.44049987e-01f, 1.47856206e-01f, -1.56175286e-01f, -2.53094405e-01f, -3.13602090e-02f,
  -3.49887796e-02f, -1.23846032e-01f, -2.81678475e-02f, -3.50258015e-02f, 1.15066040e-02f, 1.63103431e-01f, 1.47262394e-01f, 2.14956805e-01f, 1.17235139e-01f, 1.30605474e-01f,
  5.62515892e-02f, -1.83955580e-02f, -1.68212801e-01f, -3.45637999e-03f, 1.00277685e-01f, 5.78486882e-02f, 1.38531417e-01f, 9.54060331e-02f, 1.52099222e-01f, 1.95871070e-01f,
  3.61997992e-01f, -3.25191729e-02f, -4.98630330e-02f, -9.36241746e-02f, -7.27132335e-03f, -1.18233435e-01f, 4.97982576e-02f, -9.73689035e-02f, -1.21994965e-01f, 3.08905616e-02f,
  -2.24103816e-02f, -6.93350807e-02f, -4.17918339e-02f, 5.06004840e-02f, -4.04793397e-02f, 1.82713158e-02f, -4.07126620e-02f, -7.29280636e-02f, -4.80299667e-02f, -1.40262593e-03f,
  -1.87379494e-02f, 1.26543976e-02f, 2.04282477e-02f, -6.63998276e-02f, -8.89778361e-02f, 6.14737980e-02f, 6.57201558e-02f, 5.82886711e-02f, -5.17676510e-02f, -1.16367288e-01f,
  8.86068121e-02f, -4.98579349e-03f, 3.28926817e-02f, 9.12327506e-03f, -9.18398425e-02f, -9.26262587e-02f, 7.89209455e-02f, -1.58445332e-02f, 4.34778742e-02f, -4.60118172e-04f,
  -4.39900719e-02f, 4.39280048e-02f, 1.38071068e-02f, 6.95490045e-03f, 2.84179635e-02f, 3.29984836e-02f, 3.84671278e-02f, 4.32118699e-02f, -7.93672353e-03f, -8.60266984e-02f,
  5.61694498e-04f, -1.58064521e-03f, -3.93144339e-02f, -4.98974063e-02f, 9.61404145e-02f, 2.29537468e-02f, 3.01838014e-02f, 6.38807714e-02f, -5.66311292e-02f, -1.09884739e-02f,
  -1.83032259e-01f, -1.43031225e-01f, -3.06630433e-02f, -2.55656503e-02f, -1.18277045e-02f, -1.57660276e-01f, -4.64116298e-02f, -1.86843239e-02f, -1.02340028e-01f, 7.90072605e-02f,
  -8.15706849e-02f, -3.81945968e-02f, 5.68414759e-03f, -3.42753157e-03f, 4.71872650e-02f, -6.11953102e-02f, -1.19882405e-01f, -7.14571327e-02f, -2.25490499e-02f, 5.13917059e-02f,
  -4.73207720e-02f, -1.15684375e-01f, -3.04962359e-02f, 5.88525180e-03f, -6.91808686e-02f, 3.28159668e-02f, 5.77958673e-02f, 3.04087847e-02f, -6.26077317e-03f, -1.42888188e-01f,
  2.38360226e-01f, -3.90961200e-01f, 2.45898992e-01f, 3.81047018e-02f, 8.74675810e-03f, 2.43737012e-01f, 2.40719274e-01f, 9.61160585e-02f, 6.04036301e-02f, -1.08505920e-01f,
  -1.40023038e-01f, -5.96912093e-02f, -5.18201105e-02f, 8.54826719e-03f, 1.51554644e-01f, 1.53334484e-01f, 7.58783296e-02f, 2.42152289e-01f, 2.93793589e-01f, 1.18217349e-01f,
  -1.18983202e-01f, -8.94412100e-02f, 7.83923045e-02f, 4.48697768e-02f, -1.69040769e-01f, -1.23413958e-01f, -5.35602830e-02f, 7.93556422e-02f, 1.42395869e-02f, -1.77470669e-01f,
  -7.74361342e-02f, 1.87988207e-01f, 1.11449920e-02f, -1.80071324e-01f, -2.91070947e-03f, 7.64877126e-02f, 1.84437744e-02f, 7.77691752e-02f, -1.00546949e-01f, 4.12467308e-02f,
  2.41232174e-03f, 1.02077890e-03f, 5.79265468e-02f, 5.61455302e-02f, -3.93152982e-02f, 1.06477641e-01f, -1.41835809e-02f, 4.55870368e-02f, 1.34175569e-02f, 3.95065062e-02f,
  -1.29924923e-01f, -1.84224267e-02f, 5.61222471e-02f, -5.03958389e-03f, 3.90679799e-02f, 2.51494069e-02f, -9.34913382e-02f, -7.67312273e-02f, 6.27934113e-02f, -3.28883268e-02f,
  -1.36380102e-02f, 5.12219928e-02f, 3.56152677e-03f, -1.79939270e-02f, 5.77106960e-02f, -6.92124069e-02f, -8.71067569e-02f, -1.40904546e-01f, 8.07698350e-04f, -4.24378626e-02f,
  -4.28064615e-02f, -2.71086600e-02f, -7.29832724e-02f, 7.49546736e-02f, -6.96233436e-02f, 2.41721864e-04f, 7.36100785e-03f, 2.21253261e-02f, -7.31341839e-02f, 2.88072024e-02f,
  7.80378515e-03f, -4.32196893e-02f, -3.74360420e-02f, -1.53884608e-02f, 1.83877368e-02f, 6.82653189e-02f, -4.93534794e-03f, 4.86719087e-02f, 1.07122265e-01f, -1.64625440e-02f,
  -9.73420218e-02f, 1.89122722e-01f, -1.23648020e-02f, 6.90014800e-04f, -1.05755795e-02f, 1.80570036e-03f, 4.35076579e-02f, -7.37166554e-02f, 1.81453452e-02f, -1.35806687e-02f,
  2.45880038e-02f, -7.42057478e-03f, -2.45539397e-02f, 5.42211533e-02f, 7.48469755e-02f, 5.03241979e-02f, 8.63629160e-04f, 1.02080390e-01f, 4.02855389e-02f, -4.96849082e-02f,
  -1.91743448e-02f, 8.72725174e-02f, 4.55384590e-02f, 6.59106970e-02f, 1.00478098e-01f, 1.07752820e-02f, 2.68065184e-02f, 2.35336274e-02f, 1.54162005e-01f, 3.71565111e-02f,
  4.60127115e-01f, 6.02484494e-02f, -1.56673789e-02f, 3.17882657e-01f, 1.08878374e-01f, -3.52321059e-01f, -3.48244756e-01f, -1.01507515e-01f, 7.63827860e-02f, -4.26170090e-03f,
  -6.72050519e-03f, 1.23005077e-01f, 1.59079149e-01f, -2.90841237e-02f, -5.63605316e-02f, 6.58915341e-02f, 1.88445508e-01f, 7.47015923e-02f, -1.97430681e-02f, -1.80835009e-01f,
  -2.16260087e-02f, 2.27459118e-01f, 2.95570642e-01f, 3.76250967e-02f, 2.57228948e-02f, 4.33478169e-02f, 1.26995265e-01f, 1.93702891e-01f, -2.88637262e-02f, 1.61381721e-01f,
  -1.50550302e-04f, 5.25240637e-02f, 5.39814159e-02f, 2.42475197e-01f, -4.29069325e-02f, 3.86406407e-02f, 8.01542867e-03f, 5.86751997e-02f, 1.58242919e-02f, 4.85032722e-02f,
  1.21853665e-01f, 4.93222028e-02f, 1.32500961e-01f, 9.41338483e-03f, -5.28412648e-02f, -1.92139181e-03f, 1.03537276e-01f, 1.07908256e-01f, -1.89884063e-02f, -1.69847995e-01f,
  7.81308264e-02f, 1.54922605e-01f, 5.34240119e-02f, 3.50858346e-02f, 2.09716670e-02f, 1.52771607e-01f, -7.47924745e-02f, -2.15814973e-04f, 4.27987576e-02f, -2.06011292e-02f,
  -2.34139580e-02f, -1.05026178e-02f, -8.02388713e-02f, -9.93191823e-02f, 5.53422142e-03f, 2.15516351e-02f, 4.87521105e-02f, -4.60995696e-02f, -2.09747050e-02f, -1.04271345e-01f,
  -4.27025370e-03f, -2.63787638e-02f, -4.87806834e-03f, 1.39628677e-02f, 4.07476202e-02f, 1.76606383e-02f, -9.86895412e-02f, 4.90931384e-02f, -3.60599123e-02f, -5.81582747e-02f,
  4.43435237e-02f, -1.19970933e-01f, 8.53214115e-02f, -1.36323318e-01f, -2.06490792e-02f, -9.57059022e-03f, -1.11484081e-01f, -6.86190873e-02f, -7.62354163e-03f, -1.39941629e-02f,
  1.53153948e-02f, 2.75327060e-02f, 2.60477210e-03f, 2.57661231e-02f, 1.30708233e-01f, 4.59070057e-02f, 9.27859396e-02f, 1.52703449e-01f, 9.32278857e-02f, -6.79450855e-02f,
  -4.63054106e-02f, 1.75949633e-02f, 9.12790969e-02f, -6.80529103e-02f, 1.34330923e-02f, -3.88799980e-02f, 1.79796800e-01f, 2.43853386e-02f, 2.19706427e-02f, -2.18226705e-02f,
  6.65900810e-03f, 2.07480043e-02f, 1.03055596e-01f, 7.31291026e-02f, 1.46922981e-02f, 1.11979626e-01f, -1.05998680e-01f, -7.38658458e-02f, 1.08791543e-02f, -3.63365747e-02f,
  4.14297283e-01f, -3.52250598e-02f, -1.30161613e-01f, -1.40180055e-03f, -2.22897723e-01f, 4.19301987e-02f, 2.25586295e-01f, 9.41178501e-02f, -5.50213531e-02f, 7.29078203e-02f,
  -1.03957817e-01f, 3.97182349e-03f, -1.02681205e-01f, 4.29857224e-02f, 9.33440104e-02f, 1.92305520e-01f, -1.26153696e-02f, 1.43372742e-02f, 4.42561992e-02f, 7.32130408e-02f,
  -1.00963376e-01f, -3.98738086e-02f, 1.25835583e-01f, 2.12565754e-02f, -1.05844609e-01f, -7.54719526e-02f, -4.23476323e-02f, -1.98794231e-02f, -9.56954509e-02f, -7.87268803e-02f,
  -2.76645869e-02f, 1.35812201e-02f, 4.46046107e-02f, 6.16753623e-02f, -1.33684561e-01f, -7.52124563e-02f, -1.11854970e-01f, -1.07820041e-01f, -3.69655974e-02f, -8.96436349e-02f,
  4.48580459e-03f, -4.89774011e-02f, -7.18157738e-02f, -1.48269728e-01f, -1.01957873e-01f, 8.61727819e-02f, 3.02078892e-02f, 1.87194545e-03f, -3.06707174e-02f, -2.97319274e-02f,
  -1.96175709e-01f, -1.49475530e-01f, 5.08065857e-02f, -3.67141329e-02f, -1.73275232e-01f, -6.69459254e-02f, -9.65821147e-02f, -1.61706120e-01f, -6.44946396e-02f, 2.44435556e-02f,
  -2.46935301e-02f, 5.35421818e-02f, -4.22339179e-02f, 2.13523675e-02f, 1.51911173e-02f, -4.26449999e-03f, -1.21411607e-02f, 2.56526675e-02f, 4.83717732e-02f, 9.90887359e-02f,
  2.94554532e-02f, -4.52638492e-02f, 6.48747757e-03f, 3.12878471e-03f, -6.88655907e-03f, -9.38470140e-02f, -1.07128760e-02f, 9.90581289e-02f, 4.47617956e-02f, 3.31418775e-02f,
  -6.63858354e-02f, -4.43376414e-03f, 4.91017103e-02f, 5.22366017e-02f, 9.05741826e-02f, 6.07450120e-03f, 9.77419317e-03f, 5.54004088e-02f, 9.95305032e-02f, 1.00180022e-01f,
  8.53064209e-02f, -4.52787690e-02f, 2.57982705e-02f, 1.07089050e-01f, -8.77695531e-02f, 3.23709063e-02f, -8.53581131e-02f, -7.88002983e-02f, -1.36089459e-01f, -4.28466909e-02f,
  -2.51570735e-02f, 8.61819251e-04f, -4.61128913e-02f, -5.91575447e-03f, 9.35885981e-02f, 3.26950513e-02f, 1.08016528e-01f, 4.98113148e-02f, -1.69771597e-01f, -8.35615844e-02f,
  5.96824810e-02f, -3.54936793e-02f, 1.65014476e-01f, -8.91640969e-03f, 5.18643521e-02f, 2.51774359e-02f, 3.73696201e-02f, 1.04193147e-02f, 6.60251677e-02f, 2.82226533e-01f,
  -5.36287189e-01f, 1.29341438e-01f, -6.94086254e-02f, 1.52850961e-02f, 1.53257787e-01f, -4.19545881e-02f, -1.77822448e-02f, 1.04147913e-02f, 3.34286541e-02f, 8.30526128e-02f,
  1.68237373e-01f, 2.05284208e-01f, 9.03372839e-02f, 1.62762433e-01f, -1.22218654e-01f, -4.31572683e-02f, -7.87277985e-03f, -9.81916636e-02f, -2.19688997e-01f, 1.14834737e-02f,
  9.13141072e-02f, -1.60316750e-02f, -1.39475226e-01f, 4.49663820e-03f, 3.79897915e-02f, -1.25963911e-02f, 3.36535871e-02f, -4.06896248e-02f, 1.05762400e-01f, 5.73754609e-02f,
  -1.05532870e-01f, -1.55185714e-01f, 7.23628188e-03f, 5.13634644e-02f, 3.96416113e-02f, -1.52289733e-01f, -1.51004657e-01f, 3.91481351e-03f, 8.12645331e-02f, -5.70346490e-02f,
  8.28109086e-02f, -6.76389188e-02f, 2.84268595e-02f, 9.13676620e-03f, -1.12261780e-01f, 1.73779745e-02f, 1.11737987e-02f, -2.30878443e-02f, -9.95880961e-02f, -3.38817425e-02f,
  1.62185192e-01f, 2.08947808e-01f, 3.64274196e-02f, 8.75451341e-02f, -8.08271691e-02f, 1.38508573e-01f, 1.05285652e-01f, -8.93072411e-03f, 8.95392075e-02f, -1.04454689e-01f,
  -4.09542546e-02f, 4.95838113e-02f, -2.01968532e-02f, -1.44463912e-01f, -3.14166327e-03f, 6.43364266e-02f, 4.38294597e-02f, -4.37456928e-02f, -3.38807106e-02f, -4.51096781e-02f,
  -2.07833317e-03f, -4.57666442e-02f, -1.05182407e-02f, -2.50064284e-02f, 6.41937926e-02f, 2.89042182e-02f, -5.83424307e-02f, 1.94433071e-02f, 3.36916074e-02f, -2.86225323e-02f,
  -6.83965683e-02f, -2.93464921e-02f, -2.02800054e-02f, -4.15097699e-02f, 2.48436108e-02f, -7.94132724e-02f, -7.87752643e-02f, 2.47392891e-04f, -5.29765487e-02f, -1.60677731e-02f,
  -4.19087708e-02f, 1.19871423e-01f, -7.59381130e-02f, -4.94390577e-02f, -9.96771231e-02f, 4.35914695e-02f, 7.18367845e-03f, 8.84286314e-02f, 2.05065012e-02f, -6.47779629e-02f,
  -3.82692330e-02f, -1.57568857e-01f, -6.49167448e-02f, 6.95542917e-02f, -2.50029117e-02f, -1.32413274e-02f, 4.08893600e-02f, 1.70149263e-02f, -1.31031377e-02f, 5.25143137e-03f,
  -8.54899734e-02f, 4.80250195e-02f, 3.70320369e-04f, -8.38280320e-02f, -8.57091099e-02f, -1.16327032e-01f, -1.01527803e-01f, -8.39964002e-02f, -1.63898140e-01f, -1.04885235e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.44057885e-01f, 3.04033548e-01f, 2.97226846e-01f, 2.62071759e-01f, 2.35492140e-01f, 2.62209654e-01f, 1.90742403e-01f, 2.34565109e-01f, 1.58995956e-01f, 1.47079170e-01f,
  3.10000509e-01f, 3.15258056e-01f, 1.74336329e-01f, 2.12569520e-01f, 1.07545629e-01f, 5.85907139e-02f, -2.15719324e-02f, 3.45068611e-02f, 7.49252513e-02f, 1.09336369e-01f,
  1.40714357e-02f, -7.67294243e-02f, -5.27187176e-02f, -1.72199663e-02f, 7.01409280e-02f, 1.29736308e-02f, -5.20759560e-02f, -4.00276966e-02f, 1.09145194e-01f, 1.85692739e-02f,
  4.20269549e-01f, 1.15186080e-01f, 1.82247590e-02f, 6.05675057e-02f, 2.12761667e-02f, -1.84263811e-01f, 9.66097340e-02f, -5.81093393e-02f, -5.51635139e-02f, -5.14417887e-02f,
  -5.21321595e-02f, -3.61185186e-02f, -4.01125737e-02f, -9.01854932e-02f, 4.30172794e-02f, -2.42031971e-03f, -1.34549335e-01f, 8.42887536e-02f, 8.36171359e-02f, 1.47292122e-01f,
  1.08675212e-01f, 9.71392989e-02f, 7.17623830e-02f, -6.91285497e-03f, 5.22818565e-02f, 7.63301775e-02f, 9.51849893e-02f, -8.49891230e-02f, 2.28463765e-02f, 3.76248383e-03f,
  1.68284804e-01f, 1.13430105e-01f, 1.31916106e-01f, 1.22322023e-01f, 9.95123759e-03f, 1.28653049e-01f, 1.17569715e-02f, 3.80190238e-02f, 1.04264291e-02f, -7.60004818e-02f,
  -1.16478698e-02f, 2.22803921e-01f, 1.10477418e-01f, 1.31578455e-02f, 1.71079040e-02f, 1.45355642e-01f, -1.51236751e-03f, 1.36991337e-01f, -2.01858003e-02f, 1.42373770e-01f,
  3.57166901e-02f, 1.14881217e-01f, -1.50507726e-02f, -1.60970185e-02f, -1.02547370e-02f, 4.78082113e-02f, 8.18949416e-02f, -1.12348385e-02f, -1.28418654e-01f, -3.37016955e-02f,
  3.24139237e-01f, 2.81236202e-01f, 9.58305523e-02f, -7.51073286e-02f, -4.46862392e-02f, -8.64398256e-02f, 1.36988893e-01f, 2.41807383e-03f, 4.18490544e-02f, 4.16484512e-02f,
  -4.96452078e-02f, -3.39452066e-02f, 9.34669934e-03f, -6.57654628e-02f, -1.00358680e-01f, -6.38500974e-02f, -4.63208891e-02f, 3.71801108e-02f, 4.19076495e-02f, 1.99583471e-01f,
  6.33224174e-02f, -7.45191872e-02f, 6.04552068e-02f, 4.75296602e-02f, -3.93545181e-02f, 5.75023331e-03f, 7.63022229e-02f, 2.48703510e-02f, 4.83774990e-02f, -1.69397190e-01f,
  -7.75952786e-02f, 2.11323157e-01f, 1.42160013e-01f, 1.10435501e-01f, 2.33971193e-01f, 3.65527183e-01f, 5.80920577e-01f, 3.09748292e-01f, 2.26344746e-02f, 2.48488784e-02f,
  -4.39939611e-02f, -2.17584953e-01f, -1.62813470e-01f, -8.89030322e-02f, 9.31300595e-02f, 1.31461963e-01f, 7.28353187e-02f, 8.67838189e-02f, 7.49428049e-02f, 7.81768858e-02f,
  -2.21142873e-05f, 8.20358768e-02f, 6.48552179e-02f, 6.23268858e-02f, 9.26020220e-02f, -1.18494645e-01f, 2.79922839e-02f, 1.21171907e-01f, 4.61741127e-02f, 1.00201085e-01f,
  -2.41823599e-01f, 1.77036133e-02f, -2.74629802e-01f, -2.13270620e-01f, -1.25025570e-01f, -1.66519448e-01f, -1.61402375e-01f, -1.73552752e-01f, -5.80612682e-02f, -8.75888616e-02f,
  -7.22577199e-02f, -9.70857963e-02f, 1.31891981e-01f, 7.27757215e-02f, 1.65571436e-01f, 7.56248236e-02f, 3.44039649e-02f, 1.24051265e-01f, 5.80341108e-02f, -1.07614137e-02f,
  2.11630147e-02f, 1.41576692e-01f, 2.21832320e-01f, 2.25954294e-01f, 2.03327566e-01f, 9.31189880e-02f, 9.11083966e-02f, -6.23322185e-03f, 2.90683564e-02f, -1.09938346e-01f,
  -1.62306800e-02f, 1.23879656e-01f, 6.41282797e-02f, -9.28007886e-02f, -2.90136766e-02f, -2.95165218e-02f, -7.27642328e-02f, 1.55738294e-01f, 1.09666631e-01f, 7.03317076e-02f,
  2.94175018e-02f, -6.62629977e-02f, 4.30348031e-02f, 4.28906782e-03f, -7.09662363e-02f, 1.05798773e-01f, 8.86276141e-02f, -6.70951456e-02f, 1.49570704e-02f, -5.58796711e-02f,
  4.87891659e-02f, 5.48667163e-02f, 7.86086451e-03f, 1.56515792e-01f, -5.48903942e-02f, 4.03535329e-02f, -9.98665839e-02f, 3.79502997e-02f, -1.19691212e-02f, 7.69995674e-02f,
  -2.61893362e-01f, 1.70526668e-01f, -2.26870149e-01f, -6.40354604e-02f, -1.01179378e-02f, -7.45625719e-02f, -3.85917863e-03f, -1.20438427e-01f, -4.50395010e-02f, -2.03224435e-01f,
  -1.80730820e-02f, -8.26804414e-02f, 1.82712391e-01f, 2.07257792e-02f, 1.55576849e-02f, -6.91000314e-04f, -2.33816616e-02f, 4.71664369e-02f, 8.32027271e-02f, -9.99862105e-02f,
  3.05213872e-02f, 2.25654189e-02f, -4.97032776e-02f, 1.26142159e-01f, -3.42599340e-02f, -3.92677709e-02f, -4.13897932e-02f, -4.86203022e-02f, -4.68201973e-02f, -1.50036842e-01f,
  3.92903201e-02f, -2.90357471e-02f, -3.64622980e-01f, 1.12991631e-01f, -1.06672369e-01f, -1.49431378e-01f, -3.62269878e-01f, 1.21402293e-01f, 1.95970297e-01f, -3.79936904e-01f,
  -6.14764728e-02f, 1.62040405e-02f, -1.60459191e-01f, -1.65598452e-01f, -4.33232218e-01f, -5.47472835e-01f, -4.30619448e-01f, -4.06571716e-01f, -1.43517002e-01f, 4.17020433e-02f,
  2.36626286e-02f, -1.17639452e-02f, 1.51138222e-02f, 1.51517913e-01f, 1.62280098e-01f, 3.89434546e-02f, -1.59540519e-01f, -8.56556557e-03f, -4.83790599e-02f, -1.21271387e-01f,
  -1.93743363e-01f, 1.74078211e-01f, 1.91085879e-02f, -4.12273481e-02f, 3.27247940e-02f, -9.00278389e-02f, -7.86822513e-02f, -3.03664096e-02f, -1.03665091e-01f, -2.09318951e-01f,
  2.91008353e-02f, -7.77148753e-02f, 6.62726611e-02f, 1.29638031e-01f, 1.34025477e-02f, -1.47778377e-01f, -1.55106395e-01f, -4.56925929e-02f, -1.76635042e-01f, -8.44569951e-02f,
  -1.65106833e-01f, -1.01848930e-01f, -1.53818980e-01f, 2.05761869e-03f, -7.68940374e-02f, -1.37476206e-01f, 1.07354149e-01f, 1.81711137e-01f, -8.38230774e-02f, 1.20929107e-01f,
  -4.26272191e-02f, 4.08934951e-02f, -9.82129499e-02f, 5.38967401e-02f, 7.54406163e-03f, -8.37361440e-02f, 5.56819998e-02f, 2.62642186e-02f, 1.54074412e-02f, -5.65710627e-02f,
  -1.14193866e-02f, -2.31837146e-02f, 4.50129667e-03f, -2.73610596e-02f, -7.12548196e-02f, -5.74450456e-02f, -5.12387929e-03f, -8.29914063e-02f, -2.90614758e-02f, -1.01629160e-01f,
  -6.30629584e-02f, 5.54905199e-02f, 2.78782193e-03f, 4.33946997e-02f, -4.24107462e-02f, -5.05739748e-02f, -1.85115375e-02f, 6.29184023e-03f, -1.83077976e-02f, -1.37142077e-01f,
  1.83517054e-01f, -1.75248384e-01f, -2.46370267e-02f, 3.35805528e-02f, -7.26452693e-02f, 2.85360944e-02f, 2.99974792e-02f, 1.75608061e-02f, -4.81695049e-02f, -1.25232011e-01f,
  2.48109400e-02f, 1.66101672e-03f, -3.48020829e-02f, 8.40922892e-02f, -7.33026490e-02f, -6.27280399e-02f, -4.23596501e-02f, 8.01788419e-02f, -2.33393252e-01f, 9.66686234e-02f,
  -1.40603840e-01f, -1.89635232e-01f, -1.10519662e-01f, -1.30158579e-02f, 8.60908329e-02f, 2.73016766e-02f, 5.01041934e-02f, 1.02047317e-01f, -1.83399111e-01f, -7.15416744e-02f,
  -1.72086567e-01f, -1.99248701e-01f, -5.84044540e-03f, -2.78296590e-01f, -1.99337870e-01f, -1.17464237e-01f, -1.42501548e-01f, -8.90495032e-02f, -2.72221752e-02f, -1.67805150e-01f,
  8.37837532e-02f, 2.67454684e-01f, 2.22848088e-01f, 2.71556556e-01f, 1.46006465e-01f, -1.12830453e-01f, -2.44117618e-01f, 1.56089664e-01f, 3.18389237e-01f, 9.48487446e-02f,
  -2.30255090e-02f, -1.90768689e-01f, 3.13833207e-02f, 7.17342794e-02f, -1.64019942e-01f, 7.06829354e-02f, -1.61003828e-01f, -8.61657262e-02f, -1.95966046e-02f, -3.22537541e-01f,
  4.59131867e-01f, -1.63092375e-01f, 7.96757191e-02f, 5.65990731e-02f, -1.20726012e-01f, -7.13095069e-02f, -8.31151847e-03f, -8.21937695e-02f, -8.16831663e-02f, -4.80850972e-02f,
  -3.51004042e-02f, -9.22464132e-02f, -6.66156337e-02f, -1.71454027e-01f, -3.12189683e-02f, -5.17366938e-02f, -6.31959438e-02f, -3.24394107e-02f, -3.25095579e-02f, 7.66506344e-02f,
  3.59835215e-02f, 7.52315484e-03f, 8.41637254e-02f, 1.79765239e-01f, 1.16387114e-01f, 1.81135669e-01f, 3.63130458e-02f, -4.19971347e-02f, 9.53491032e-02f, -1.30230382e-01f,
  4.56338599e-02f, 1.62577316e-01f, 1.36794955e-01f, 1.86876580e-02f, 3.07895578e-02f, 5.08537004e-03f, -7.90970996e-02f, 4.97036800e-02f, 5.78129329e-02f, -5.76641522e-02f,
  -5.84745854e-02f, -2.28807628e-02f, -2.82648411e-02f, 4.18475755e-02f, 4.47294526e-02f, -6.11527190e-02f, 4.21887683e-03f, -2.76544783e-03f, 7.59326713e-03f, -2.05872387e-01f,
  -2.44807377e-02f, 4.93460102e-03f, -1.39540091e-01f, -1.42446294e-01f, -1.92739904e-01f, -5.19953147e-02f, -5.90442419e-02f, 5.43099865e-02f, -1.55156970e-01f, -2.48404965e-03f,
  1.61805212e-01f, 2.38735005e-01f, -5.51526211e-02f, 2.13520341e-02f, -1.11444227e-01f, -1.71642601e-01f, 7.75470212e-03f, 9.49324854e-03f, 9.36347023e-02f, 5.46711013e-02f,
  1.42117068e-01f, 1.81956336e-01f, 1.07313514e-01f, 3.39182317e-02f, 4.88993041e-02f, 1.01902306e-01f, -4.17673923e-02f, 4.16800454e-02f, 1.06736600e-01f, 6.46322817e-02f,
  -2.83013918e-02f, 1.86288822e-02f, 3.12643945e-01f, 1.00849725e-01f, 1.59309208e-01f, 1.75816149e-01f, 1.60919070e-01f, 7.81607330e-02f, 2.40184829e-01f, -1.16841622e-01f,
  1.64119944e-01f, 6.68615550e-02f, 3.54975104e-01f, 3.58059891e-02f, -2.91310530e-03f, 2.97147073e-02f, -1.05650753e-01f, 5.52003505e-03f, -2.56423149e-02f, -2.39879657e-02f,
  -2.13640206e-03f, -2.03375854e-02f, -5.06364880e-03f, -2.13065259e-02f, 1.38519794e-01f, -2.06769072e-02f, 5.35548031e-02f, 1.10643543e-01f, 6.72316030e-02f, -1.28371701e-01f,
  -2.17822343e-01f, -1.34409204e-01f, 6.56929389e-02f, 3.57361212e-02f, -1.11775011e-01f, -7.69514889e-02f, 6.80011660e-02f, -1.11394592e-01f, -1.28577426e-01f, 3.74643728e-02f,
  1.29845768e-01f, 2.10637197e-01f, 6.17732070e-02f, 1.25979155e-01f, 5.46968915e-02f, 1.05147650e-02f, 8.03438351e-02f, 8.34504366e-02f, 6.81453049e-02f, 1.86704937e-02f,
  1.38766527e-01f, -5.68908080e-02f, -1.14134282e-01f, -1.21527448e-01f, -2.84117293e-02f, -2.92144343e-02f, -1.23046106e-02f, -5.97409718e-02f, 3.93734835e-02f, 5.85978441e-02f,
  -1.24463648e-01f, -8.75968784e-02f, -7.92151988e-02f, -9.82623249e-02f, 3.88717130e-02f, -2.72270963e-02f, 6.42890111e-03f, -2.38453373e-02f, -4.32224991e-03f, -1.44662097e-01f,
  5.71080223e-02f, -6.34311885e-02f, -1.46113291e-01f, -1.20938815e-01f, -1.49506599e-01f, -1.37098953e-01f, -7.18614385e-02f, -3.95282172e-03f, -6.17871769e-02f, -1.80517405e-01f,
  -1.43462077e-01f, 5.07403947e-02f, 8.14189538e-02f, -6.28796294e-02f, 6.94919676e-02f, -4.19077091e-02f, 2.24427022e-02f, 4.82779816e-02f, 1.90024413e-02f, -1.75462905e-02f,
  -7.56274536e-02f, -2.49004345e-02f, -2.28157011e-03f, -2.17424668e-02f, -3.21958102e-02f, -5.82846627e-02f, -2.95982882e-02f, -4.84437048e-02f, -3.19536701e-02f, -6.86179325e-02f,
  1.70641571e-01f, 3.05074632e-01f, -6.90947995e-02f, 1.95945278e-01f, 1.08438559e-01f, 1.12743050e-01f, 1.81766316e-01f, 9.30765793e-02f, 1.74691126e-01f, 1.95474535e-01f,
  1.54908329e-01f, 1.00131094e-01f, -6.10446595e-02f, -1.25802979e-01f, -1.24697603e-01f, -3.31821255e-02f, -8.34768340e-02f, -3.09228245e-02f, 1.07135706e-01f, 1.54874206e-01f,
  4.82656583e-02f, 1.46123543e-02f, -1.85819417e-02f, 4.36324663e-02f, 1.74808707e-02f, 1.53533788e-02f, 4.55540493e-02f, -6.80584237e-02f, 1.52035370e-01f, -9.64818671e-02f,
  7.60158002e-01f, -1.81717977e-01f, -4.92379516e-02f, 2.89560527e-01f, 8.83921310e-02f, 1.63900137e-01f, 1.98153704e-01f, 2.48046935e-01f, 2.01157019e-01f, 1.70268759e-01f,
  6.27662465e-02f, 1.20321110e-01f, 2.12112591e-02f, 2.80261338e-02f, 4.91827130e-02f, 1.02926448e-01f, 5.56520075e-02f, 8.65239464e-03f, 2.45475650e-01f, 1.68236971e-01f,
  9.34944004e-02f, 7.85866156e-02f, 1.96700007e-01f, 1.28096640e-01f, -9.44605544e-02f, 8.62356871e-02f, -8.80518183e-02f, -1.58768848e-01f, -5.66295907e-02f, -1.14497863e-01f,
  -5.36475599e-01f, -1.70716822e-01f, 1.57802626e-02f, -3.35859843e-02f, -1.03993788e-01f, 9.22334418e-02f, 1.19146012e-01f, -3.11930552e-02f, 1.18477069e-01f, 4.74052764e-02f,
  -1.22146226e-01f, -9.94079039e-02f, -1.95280500e-02f, 9.08093527e-03f, 1.62057262e-02f, 8.96903947e-02f, 8.03827047e-02f, 1.08253583e-01f, 4.54227477e-02f, -7.58572668e-02f,
  -1.19026385e-01f, -7.76865939e-03f, -7.02081174e-02f, -2.73517668e-02f, 4.34622681e-03f, -1.00720294e-01f, -7.77840540e-02f, 2.76747104e-02f, 8.74439254e-02f, 4.20396030e-02f,
  1.68985859e-01f, 1.69344008e-01f, -3.96470949e-02f, 1.27742350e-01f, 7.74357095e-03f, 1.43420517e-01f, 7.54130259e-02f, -6.68343902e-02f, 8.18666629e-03f, -3.87327932e-02f,
  7.85766989e-02f, -5.35320304e-02f, 2.88300775e-03f, 7.62413666e-02f, -7.55693838e-02f, -3.35419737e-02f, -5.76215535e-02f, -1.80196241e-01f, -1.58812776e-01f, -5.74315898e-02f,
  -5.35149425e-02f, -6.28533736e-02f, -4.23754565e-02f, -2.07282215e-01f, -1.81759894e-02f, -3.18782181e-02f, -7.38603324e-02f, -7.74988756e-02f, 9.80137214e-02f, -1.96006591e-03f,
  -2.78620780e-01f, -1.00849479e-01f, 7.61098638e-02f, -8.81405920e-02f, -7.62314573e-02f, -7.30991885e-02f, -1.40211001e-01f, -7.62264654e-02f, -1.52363047e-01f, -1.49306670e-01f,
  -8.67458731e-02f, 4.13232669e-03f, -1.06931031e-01f, -4.45393622e-02f, 6.30661547e-02f, 3.21324766e-02f, 3.09260264e-02f, 2.85868347e-03f, -7.77857527e-02f, -1.58637986e-01f,
  7.20053649e-05f, 2.54903793e-01f, 1.36146963e-01f, 1.65870905e-01f, 5.64601878e-03f, 1.16611376e-01f, 3.25958827e-03f, -5.14520109e-02f, 2.95260679e-02f, 2.57168531e-01f,
  5.02976835e-01f, -2.97383249e-01f, -5.36167085e-01f, 1.30300343e-01f, -2.27990579e-02f, 4.37258594e-02f, -1.05975591e-01f, 1.39619395e-01f, 2.37441301e-01f, -1.48824900e-01f,
  -2.20430836e-01f, 1.60670914e-02f, -1.65203378e-01f, -7.77179822e-02f, -1.13226973e-01f, -3.37213784e-01f, -1.99721053e-01f, -3.57861444e-02f, 1.13011658e-01f, 9.11779180e-02f,
  -2.20515137e-03f, -1.36941662e-02f, -2.18033940e-02f, 4.58217546e-04f, -2.69662946e-01f, -2.15626240e-01f, -4.24840957e-01f, -1.90102890e-01f, -2.16431230e-01f, -4.84817564e-01f,
  -2.78343976e-01f, 5.01502790e-02f, 1.09260231e-01f, 8.24098475e-03f, 3.69397574e-03f, 1.21938623e-01f, 1.25306368e-01f, 1.08420752e-01f, 2.37497896e-01f, 1.70380667e-01f,
  -2.04861313e-02f, 3.22602279e-02f, 3.42907719e-02f, 8.26722458e-02f, 1.12389505e-01f, 9.45668146e-02f, 1.00235134e-01f, -6.52662516e-02f, -1.15301246e-02f, 1.72028877e-02f,
  6.56094868e-03f, 1.53000914e-02f, 3.43520455e-02f, -1.88184679e-02f, -1.33771589e-02f, 5.57689965e-02f, 3.29503454e-02f, 2.93670893e-02f, 2.82346737e-02f, 1.27854139e-01f,
  -1.55338526e-01f, -5.65538555e-02f, -2.37482507e-03f, 9.87574384e-02f, 2.01319858e-01f, 4.55111302e-02f, 4.71167490e-02f, -5.92095964e-02f, 3.66585702e-02f, -4.74279420e-03f,
  -1.22056138e-02f, -1.52837098e-01f, 5.55143831e-03f, -2.02399157e-02f, -1.23335078e-01f, 3.71736474e-02f, -3.67720835e-02f, 7.85030499e-02f, 4.93353643e-02f, 4.08549719e-02f,
  9.37198848e-03f, -5.96562102e-02f, -7.90543258e-02f, -5.95752336e-02f, -8.03059116e-02f, 8.07642490e-02f, -1.00383021e-01f, -6.26355931e-02f, -1.09821884e-03f, 1.82617232e-02f,
  1.08310387e-01f, -1.04918368e-01f, 3.06382012e-02f, -2.61434447e-02f, -1.31443627e-02f, -7.12208450e-02f, -2.85860132e-02f, 1.39417928e-02f, 6.34208247e-02f, 9.82182249e-02f,
  -6.30132705e-02f, -6.61500841e-02f, -4.82259840e-02f, -1.24276280e-01f, 1.52684199e-02f, -9.34127532e-03f, -3.96853387e-02f, 4.89809923e-02f, 3.70801869e-03f, -3.91950924e-03f,
  -5.62703647e-02f, 1.95438787e-01f, 2.29496971e-01f, 1.19792735e-02f, 8.89047384e-02f, 1.57722116e-01f, 1.74343679e-02f, 1.02717511e-01f, -1.89696010e-02f, 8.36542472e-02f,
  -3.09999913e-01f, 4.21582609e-01f, -7.57787973e-02f, -1.72084616e-03f, 2.66083241e-01f, 8.13041627e-02f, 2.71244556e-01f, 4.20445614e-02f, -2.15738323e-02f, 9.06767920e-02f,
  1.74135938e-01f, 9.58018005e-02f, 2.27906227e-01f, 8.74366388e-02f, 1.81387775e-02f, 1.26187563e-01f, 1.50373906e-01f, 6.64457353e-03f, -1.55074120e-01f, -5.91585785e-02f,
  1.16852395e-01f, 1.27198575e-02f, -2.50590414e-01f, -1.86973825e-01f, 2.96113100e-02f, -6.88713267e-02f, -6.39240369e-02f, 1.01933405e-01f, 5.41169569e-02f, 1.01808809e-01f,
  -1.58224344e-01f, 2.59621302e-03f, -2.32003704e-01f, 1.42548293e-01f, 8.62179324e-02f, -1.60539180e-01f, 2.13925745e-02f, 7.63649568e-02f, 1.26700342e-01f, 5.89340143e-02f,
  1.80645674e-01f, 4.60362546e-02f, 2.56355584e-01f, 2.86216643e-02f, 2.00658515e-02f, -4.59959432e-02f, -1.96967665e-02f, -5.21793552e-02f, -1.26960441e-01f, -7.85335973e-02f,
  1.21841878e-01f, 1.42904490e-01f, 1.06216229e-01f, -2.52092443e-02f, -9.37511623e-02f, -4.17236276e-02f, -1.69231147e-01f, -8.58885571e-02f, -2.14792848e-01f, -1.39802307e-01f,
  4.04270887e-02f, -2.17606481e-02f, 6.40905425e-02f, -6.80029392e-02f, 3.19794677e-02f, -4.18695286e-02f, -3.00244056e-02f, 1.19407095e-01f, 3.12692262e-02f, -4.55970205e-02f,
  9.86687168e-02f, -2.48306289e-01f, -2.16096360e-02f, -1.42704755e-01f, -1.91131115e-01f, 1.23395093e-01f, -6.25715256e-02f, -9.01729167e-02f, -3.32080461e-02f, -3.28916684e-02f,
  1.18888423e-01f, 4.35965471e-02f, -7.32506588e-02f, 8.21713582e-02f, 2.92665418e-03f, -7.32733635e-03f, -1.21518485e-01f, -1.11081578e-01f, -7.00701699e-02f, -1.22696115e-02f,
  -5.26952371e-02f, 2.56988760e-02f, -2.98268139e-01f, 7.01930448e-02f, 5.29866554e-02f, 3.67375240e-02f, -3.23091745e-02f, 6.12098798e-02f, 4.37207557e-02f, -4.63627875e-02f,
  -8.12142715e-02f, -1.73732728e-01f, 6.45688325e-02f, -3.40784080e-02f, -2.68880390e-02f, 2.13671606e-02f, 5.97476847e-02f, 3.80556732e-02f, -3.73673774e-02f, -7.67118633e-02f,
  -6.64953068e-02f, -1.68602094e-01f, -1.09796576e-01f, -2.74275988e-02f, -1.41389206e-01f, -2.90533006e-01f, -1.79566666e-01f, -2.47856468e-01f, -1.85418680e-01f, -3.54561865e-01f,
  -4.13492411e-01f, -5.77489138e-02f, -4.68568593e-01f, 1.65656060e-01f, 3.19422811e-01f, 1.22698195e-01f, 1.54328972e-01f, 1.13547117e-01f, 6.23479038e-02f, 1.83998600e-01f,
  -2.38554589e-02f, 5.36346808e-02f, -3.47098173e-03f, -4.54939865e-02f, -4.88864630e-02f, 2.55320668e-01f, 2.26571381e-01f, -1.27321392e-01f, -2.76562005e-01f, -1.40001941e-02f,
  2.24736184e-01f, -1.32434338e-01f, -3.46069902e-01f, -1.44642726e-01f, 1.67577401e-01f, 7.38297105e-02f, 6.04394749e-02f, -1.38725024e-02f, 9.24342275e-02f, 1.44623116e-01f,
  -1.76617190e-01f, -1.12089567e-01f, 1.17689416e-01f, -7.80765042e-02f, -1.79786190e-01f, -1.60593808e-01f, -2.65929159e-02f, -1.96625471e-01f, -1.28899030e-02f, 3.64887305e-02f,
  -1.04989661e-02f, -8.14708322e-02f, -2.58194450e-02f, -1.02530070e-01f, -7.81366676e-02f, -1.12187274e-01f, -1.25122413e-01f, -1.79734647e-01f, -2.79360354e-01f, -2.42849842e-01f,
  1.14620484e-01f, -7.88301080e-02f, -3.75538617e-01f, 2.81825457e-02f, -1.05994724e-01f, -7.96239451e-02f, -1.71149313e-01f, -1.73514768e-01f, -2.94220001e-01f, -1.38548523e-01f,
  -5.62772760e-03f, -4.11316790e-02f, 2.88335923e-02f, 2.45401310e-03f, -4.94905300e-02f, 1.00440949e-01f, -8.60748217e-02f, -2.62738410e-02f, 1.18413195e-01f, 2.22077798e-02f,
  -2.33892854e-02f, -5.65107726e-02f, 6.36996776e-02f, 4.10540178e-02f, 2.48060729e-02f, 6.89585060e-02f, -3.30739543e-02f, -6.94740042e-02f, 1.33613283e-02f, -6.45765439e-02f,
  -8.94932896e-02f, 4.38553020e-02f, -2.69064158e-02f, -1.77839145e-01f, -3.02080791e-02f, 6.23793993e-03f, 1.07525535e-01f, -9.04285982e-02f, -1.76504120e-01f, 4.21350785e-02f,
  1.78393528e-01f, 9.94685888e-02f, 1.17564321e-01f, -1.63767692e-02f, 2.91531608e-02f, -9.28004384e-02f, 1.32493377e-02f, -1.14881277e-01f, 2.15793215e-02f, -5.17494977e-02f,
  -8.01508352e-02f, -8.06345697e-03f, 1.48128003e-01f, 9.40354839e-02f, 1.34929665e-03f, 5.83576411e-02f, 7.18433782e-02f, -2.40843017e-02f, 7.66595379e-02f, 5.30066639e-02f,
  9.34793055e-02f, 7.92044923e-02f, -2.33270034e-01f, -2.13716179e-02f, -2.65004188e-02f, -1.30171515e-02f, -1.50996134e-01f, -1.68036133e-01f, -1.80252999e-01f, -6.84896931e-02f,
  -1.29048377e-01f, -3.32580507e-01f, -2.84401793e-02f, -2.44306982e-01f, -1.53617356e-02f, 6.52807578e-02f, -2.27084965e-01f, 8.52454919e-03f, -1.12004606e-02f, -4.11055982e-01f,
  -1.19418032e-01f, 2.26252720e-01f, 1.32148728e-01f, 2.67554790e-01f, 2.68977195e-01f, -1.74964532e-01f, -3.83375585e-02f, 2.83556253e-01f, 5.29941142e-01f, 1.42323166e-01f,
  6.91620111e-02f, 4.01758915e-03f, 2.30493605e-01f, 2.27237374e-01f, -3.88259858e-01f, 1.02064153e-03f, -1.79762781e-01f, -1.89619005e-01f, -3.10301483e-02f, -4.79605466e-01f,
  -3.13378930e-01f, -2.38393292e-01f, 1.30563512e-01f, 9.59411711e-02f, -9.56000686e-02f, 5.31874858e-02f, -1.11055695e-01f, -1.75470442e-01f, -2.12987009e-02f, -3.36830923e-03f,
  -1.02303199e-01f, 3.86749022e-02f, 6.02006279e-02f, -5.14140958e-03f, 3.27901985e-03f, -1.31270299e-02f, 3.59285474e-02f, 1.03895567e-01f, 8.22259709e-02f, -6.21371083e-02f,
  1.75516810e-02f, -1.06334582e-01f, 3.00512426e-02f, 6.51720762e-02f, 3.48722935e-02f, 1.55327395e-01f, -9.46045481e-03f, 3.73450629e-02f, 1.82262719e-01f, -4.35532510e-01f,
  7.70172430e-03f, 2.68471465e-02f, 8.79289359e-02f, -4.51526344e-02f, -6.34189546e-02f, 6.79836497e-02f, -1.38421198e-02f, -3.52383852e-02f, 9.76647157e-03f, -5.85076697e-02f,
  1.26978308e-01f, 2.90381536e-02f, -3.52458842e-03f, -3.31459120e-02f, 1.54871726e-02f, -8.24514851e-02f, -5.48471436e-02f, 2.59856936e-02f, -1.11176502e-02f, 6.77629709e-02f,
  1.05965503e-01f, 4.19593276e-03f, -2.71675177e-02f, 5.79304881e-02f, 8.01893175e-02f, 1.94211714e-02f, -8.80972967e-02f, 1.19671766e-02f, -5.28715141e-02f, -1.50547251e-02f,
  -9.05282050e-02f, 2.40411341e-01f, -2.38997772e-01f, 4.56273295e-02f, -8.60153139e-02f, -9.73778870e-03f, -9.08210725e-02f, 8.51635709e-02f, -7.62749016e-02f, -2.76645571e-02f,
  -8.73309281e-03f, 8.15969240e-03f, -1.41497388e-01f, 3.38726677e-02f, 2.64862506e-03f, 3.91926095e-02f, -5.65903336e-02f, 3.67800817e-02f, 1.02729693e-01f, -1.72903106e-01f,
  -3.56768407e-02f, 6.25465661e-02f, 1.49029652e-02f, -7.49739856e-02f, -1.27451703e-01f, 2.94659305e-02f, -1.65502250e-01f, -8.31597969e-02f, 3.09609789e-02f, -3.42316449e-01f,
  -6.94485426e-01f, -1.88899532e-01f, -2.75839269e-01f, -2.24397391e-01f, 1.92742854e-01f, 1.22021444e-01f, 2.42704913e-01f, 8.12919438e-02f, 1.74004976e-02f, 6.19750246e-02f,
  3.06360144e-02f, 1.02240562e-01f, 1.16834298e-01f, 7.83843473e-02f, 9.22759250e-02f, 1.46128207e-01f, 2.82158643e-01f, 5.70049062e-02f, -5.68887852e-02f, 1.43131360e-01f,
  1.45812124e-01f, -1.14697650e-01f, -2.02088535e-01f, 5.88977449e-02f, -2.01994963e-02f, -4.59090434e-02f, -4.77740653e-02f, -5.26261143e-02f, 5.55676501e-03f, 1.67682216e-01f,
  -2.14327753e-01f, -1.85262799e-01f, 2.35445425e-01f, -1.10859707e-01f, 9.59377140e-02f, -1.49028808e-01f, -2.76361480e-02f, -9.04123560e-02f, 2.10548639e-02f, 3.89471166e-02f,
  3.40358689e-02f, 8.71561021e-02f, 6.15805201e-02f, 6.43857941e-02f, -1.09897867e-01f, 7.13926274e-03f, -2.61793155e-02f, 9.77925677e-03f, -1.40516877e-01f, 5.27408952e-03f,
  2.92825460e-01f, -1.10611349e-01f, -2.36269251e-01f, -3.57239731e-02f, 5.03400639e-02f, -7.72399530e-02f, 7.30926245e-02f, 1.37322083e-01f, -5.50077409e-02f, 4.59420606e-02f,
  1.79218084e-01f, 1.17604226e-01f, -4.54819314e-02f, 2.84538027e-02f, 1.16872407e-01f, 9.90734324e-02f, 1.26118183e-01f, 1.52821630e-01f, 1.46690905e-01f, -2.41466537e-02f,
  -6.81643635e-02f, 5.68973366e-03f, 2.29391735e-02f, 9.80181154e-03f, 7.94588104e-02f, -5.76814301e-02f, 1.51118696e-01f, 1.50348976e-01f, -1.73840411e-02f, -3.66401114e-02f,
  -6.65145218e-02f, 3.24157882e-04f, 3.15884016e-02f, 1.27489969e-01f, -3.86317223e-02f, 2.97590271e-02f, -1.12704579e-02f, -3.51997800e-02f, -5.34531064e-02f, -5.03325984e-02f,
  -3.01287472e-01f, 5.55565488e-03f, 1.48380950e-01f, 5.34833372e-02f, 5.26292473e-02f, -3.48246582e-02f, -1.80654824e-01f, 4.40353937e-02f, -1.14809267e-01f, -5.86723872e-02f,
  -8.71711746e-02f, -7.10953698e-02f, -7.10594133e-02f, 7.95696527e-02f, -8.89666826e-02f, -8.54400322e-02f, 4.85714450e-02f, 1.30352274e-01f, 5.59008345e-02f, -5.48529848e-02f,
  -8.63933340e-02f, -4.50817980e-02f, -2.84108430e-01f, -6.50986377e-03f, -7.20918775e-02f, -8.31004605e-02f, -9.55149680e-02f, -2.07799584e-01f, -1.27521917e-01f, -3.08746159e-01f,
  -3.01085919e-01f, -1.25878140e-01f, -1.89455941e-01f, -8.27907026e-02f, 1.36535207e-03f, 3.11821606e-02f, -2.30154637e-02f, 2.72833437e-01f, 1.03214353e-01f, -1.66302830e-01f,
  7.91665614e-02f, 3.94264646e-02f, -1.14312045e-01f, -3.53990830e-02f, 3.58576886e-02f, -2.59957314e-01f, -2.94759482e-01f, -3.92848247e-04f, 2.71041334e-01f, 3.13595742e-01f,
  4.70740460e-02f, -7.04012141e-02f, -1.87756392e-04f, -4.34247777e-02f, -1.92748889e-01f, -1.27780184e-01f, -2.83791602e-01f, -1.00884266e-01f, -1.31183654e-01f, -3.86599094e-01f,
  -3.62069547e-01f, -5.39593138e-02f, 1.03835210e-01f, -7.48946040e-05f, -1.19610615e-01f, 6.97244257e-02f, -2.38333698e-02f, 3.41740362e-02f, 1.29024833e-04f, -7.71440640e-02f,
  3.16674262e-02f, 9.42052007e-02f, -2.76244748e-02f, 2.74091568e-02f, 7.15352893e-02f, 2.43180874e-03f, 1.75234340e-02f, 8.54996294e-02f, -5.69641925e-02f, -5.49891852e-02f,
  -9.48061496e-02f, 6.56516254e-02f, 7.00932518e-02f, 6.25058785e-02f, 1.26307517e-01f, 3.21084596e-02f, -2.46379711e-02f, -3.73973623e-02f, -4.35514748e-02f, -2.71288663e-01f,
  -5.80511168e-02f, -1.20558515e-01f, -6.48396313e-02f, 1.42507404e-01f, 5.43489754e-02f, -8.78490806e-02f, -9.13048312e-02f, -7.23904057e-04f, -2.40799170e-02f, 2.99122185e-02f,
  3.89111377e-02f, 2.11933795e-02f, 9.29096043e-02f, -1.52452499e-01f, -9.53503102e-02f, 2.70501841e-02f, 2.65322980e-02f, -8.77407715e-02f, -5.11643700e-02f, -5.28862700e-02f,
  1.27028361e-01f, 5.93547039e-02f, -3.78910005e-02f, 3.47314812e-02f, -7.03504533e-02f, -1.01692164e-02f, -1.33636907e-01f, 5.34771718e-02f, 9.47577208e-02f, -2.10350212e-02f,
  -7.74495155e-02f, 1.26365900e-01f, -2.23926768e-01f, 1.12214357e-01f, -4.59103584e-02f, -4.31910865e-02f, -2.07481608e-02f, 2.74196789e-02f, 2.14520618e-02f, 6.60597607e-02f,
  1.49761051e-01f, 1.49185052e-02f, -1.30849868e-01f, 5.51069826e-02f, 4.98047285e-02f, 1.00716902e-02f, -2.23872885e-02f, -5.27033675e-03f, 1.31763846e-01f, 5.39716780e-02f,
  -6.67047948e-02f, 5.74981309e-02f, -7.37751182e-03f, -9.33379978e-02f, 3.68346609e-02f, -7.29239732e-02f, -1.90387323e-01f, -1.57847345e-01f, -9.65434238e-02f, -3.04113328e-01f,
  -6.70574188e-01f, 5.31164296e-02f, -1.63802713e-01f, -3.02046895e-01f, -2.64793169e-02f, 6.82461634e-02f, -2.07571555e-02f, 2.31465101e-01f, 1.07873626e-01f, -1.96914181e-01f,
  -5.43123484e-02f, -2.60167848e-02f, -1.89130217e-01f, -6.71927184e-02f, -1.79224581e-01f, -2.80927926e-01f, -3.55855763e-01f, -3.75573277e-01f, -1.29746109e-01f, 2.29826495e-01f,
  -1.05645191e-02f, -2.42695838e-01f, -1.86922565e-01f, -5.00062853e-02f, -6.64334148e-02f, -9.34055820e-02f, -2.33898997e-01f, -3.90029699e-02f, 5.46563081e-02f, -1.89924344e-01f,
  -2.55680770e-01f, 8.82016644e-02f, -3.54806683e-03f, -4.40344913e-03f, -9.70333442e-02f, 7.44509790e-03f, -1.20138921e-01f, -1.85168181e-02f, 1.16051823e-01f, 9.65592742e-04f,
  1.25541138e-02f, 1.01571910e-01f, -1.40109003e-01f, -5.19646406e-02f, -3.96826826e-02f, 1.47561550e-01f, 1.00714210e-02f, -8.16512294e-03f, 2.57028528e-02f, 1.01947211e-01f,
  1.07497975e-01f, 1.75150353e-02f, -1.07805785e-02f, 1.49838388e-01f, 1.70830652e-01f, 3.66036333e-02f, 7.69801810e-02f, 1.71201363e-01f, 1.74574211e-01f, 9.13712233e-02f,
  -6.44445568e-02f, 2.55845916e-02f, -1.56870426e-03f, 2.24933811e-02f, 5.09347543e-02f, -2.45718937e-03f, -1.08080924e-01f, -9.10527334e-02f, -6.04981966e-02f, -2.64119878e-02f,
  3.65503319e-02f, -6.50176629e-02f, -2.92376466e-02f, -6.34207428e-02f, -1.23133897e-04f, 4.31939438e-02f, -8.70879069e-02f, 3.44598331e-02f, 6.07559830e-02f, 6.05202839e-02f,
  7.04933479e-02f, 1.09122425e-01f, -6.93714023e-02f, 1.10018067e-01f, -3.52135561e-02f, 2.18400639e-02f, 9.14346054e-02f, 1.35526955e-01f, 7.79192671e-02f, 1.25211835e-01f,
  -2.16241449e-01f, -7.41942227e-02f, -2.76263326e-01f, 1.20341599e-01f, -2.00432371e-02f, 8.59569833e-02f, -4.24355976e-02f, 6.90884069e-02f, 5.59670366e-02f, -3.66697349e-02f,
  2.20643178e-01f, -3.47627923e-02f, -1.37134761e-01f, 4.95022386e-02f, -4.92973300e-03f, 1.34430185e-01f, 1.05085552e-01f, 1.69194136e-02f, 1.44056469e-01f, 1.73913464e-01f,
  1.18104823e-01f, 2.55337637e-02f, 2.54166294e-02f, 8.76773745e-02f, 9.44926962e-02f, -8.82552415e-02f, -6.12003207e-02f, 4.03568856e-02f, -3.68955010e-03f, -3.79406326e-02f,
  3.39506924e-01f, -9.51492488e-02f, -3.65311891e-01f, 1.04608141e-01f, -3.79843742e-01f, -2.09245548e-01f, -3.63761038e-01f, 3.97915058e-02f, 1.48828611e-01f, 1.69042945e-02f,
  9.09803144e-04f, 2.06522629e-01f, 2.06450164e-01f, 1.16463467e-01f, 9.42743719e-02f, -1.70676276e-01f, -1.51373982e-01f, -6.10504262e-02f, 1.51528478e-01f, -6.81823418e-02f,
  6.51176497e-02f, 1.25192329e-01f, 2.08007932e-01f, -2.16895975e-02f, -1.50433369e-02f, 6.35391250e-02f, -3.90544571e-02f, -8.47273022e-02f, -7.59427920e-02f, -2.64157355e-01f,
  5.60559034e-02f, -2.16498002e-01f, -2.92646110e-01f, 4.99430522e-02f, -1.79780666e-02f, -7.56027848e-02f, -4.61354665e-03f, -1.18918985e-01f, 2.82412441e-03f, -6.57604635e-02f,
  -8.73425081e-02f, -1.97436232e-02f, 9.07592401e-02f, 1.38564436e-02f, 5.93668781e-03f, 7.12706670e-02f, -1.10666960e-01f, -6.34830073e-02f, -1.97837222e-02f, 8.62964988e-02f,
  -8.50069150e-02f, -1.75229963e-02f, -1.51426062e-01f, -1.84431925e-01f, 2.50732806e-02f, -2.70871874e-02f, -1.81566715e-01f, -1.94946736e-01f, -6.60828203e-02f, -1.63082674e-01f,
  -6.78817332e-02f, 6.42511770e-02f, 1.11685004e-02f, -7.53590167e-02f, 8.49066153e-02f, 3.57986777e-04f, -5.02539985e-02f, 1.13210835e-01f, 6.39259294e-02f, 1.79433003e-02f,
  -1.13203250e-01f, -6.83387592e-02f, -1.87847279e-02f, 1.91477686e-03f, 1.14860140e-01f, 2.24810299e-02f, 7.69997239e-02f, 5.92614412e-02f, -6.08085059e-02f, 1.23009747e-02f,
  4.05124165e-02f, -9.03637521e-03f, -2.15803981e-02f, -4.12378237e-02f, -9.25231799e-02f, -6.13717213e-02f, -2.37177256e-02f, 2.72913724e-02f, 2.72267335e-03f, -1.97186712e-02f,
  3.39717001e-01f, -8.18112195e-02f, 9.94509459e-02f, 3.80930416e-02f, -7.90798217e-02f, -5.95402718e-03f, 6.72145933e-02f, -5.38097648e-03f, 1.37367085e-01f, -5.14922626e-02f,
  -1.45903274e-01f, 5.07130427e-03f, 7.01854527e-02f, -2.38248985e-03f, 4.48448723e-03f, -8.27933103e-03f, -6.28748685e-02f, 1.67623237e-02f, 1.47041276e-01f, 2.75541749e-02f,
  7.04077631e-02f, 4.29105461e-02f, 4.26061302e-02f, 9.47331786e-02f, 6.78570867e-02f, 1.41935319e-01f, 1.48503959e-01f, -4.17035539e-03f, 1.65036470e-01f, 2.28885815e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -8.93706679e-02f, 2.17933580e-01f, 3.79045121e-02f, 1.84888989e-01f, -7.70293847e-02f, 2.83997118e-01f, -3.79250124e-02f, 2.54408293e-03f, 1.24569789e-01f, 1.91312343e-01f,
  9.39624105e-03f, 6.74665272e-02f, 8.05910826e-02f, 3.33842903e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.23145290e-01f, -3.65429483e-02f, 2.64277309e-02f, -2.00667560e-01f, -3.30641896e-01f, 7.00827548e-03f, 2.31227446e-02f, 7.62173757e-02f, 2.09317088e-01f, -3.65341529e-02f,
  -2.12009475e-01f, 3.26811343e-01f, -1.85132802e-01f, 2.13375911e-02f, 1.58855114e-02f, -9.21090692e-02f, -2.79953897e-01f, -1.09599993e-01f, 1.73631877e-01f, 1.01406239e-02f,
  -5.81443496e-02f, 1.79180220e-01f, -2.60348588e-01f, 6.51219934e-02f, -1.67175964e-01f, 3.58710527e-01f, -2.54459679e-01f, 4.10404801e-02f, -1.32472351e-01f, 1.37254938e-01f,
  8.83181915e-02f, -4.49997149e-02f, -2.89625507e-02f, 3.71997021e-02f, -3.78333516e-02f, 6.69991691e-03f, 1.55429319e-01f, 2.95487456e-02f, 1.74411610e-01f, 2.69112676e-01f,
  3.19387466e-02f, 1.00497790e-01f, -8.80569071e-02f, 1.31448522e-01f, -1.40812591e-01f, 3.21238607e-01f, -4.66253050e-03f, 9.49684978e-02f, 1.61769122e-01f, -1.36197016e-01f,
  1.20325185e-01f, -3.45925242e-02f, -7.19544059e-03f, 7.04108998e-02f, -9.65658426e-02f, 1.34027839e-01f, -4.76580448e-02f, -2.29268029e-01f, 3.55509408e-02f, 4.62317139e-01f,
  2.40521550e-01f, 1.76666200e-01f, 2.01028422e-03f, -7.64997005e-02f, 3.32817063e-02f, -3.87016200e-02f, -1.72787271e-02f, -2.53299829e-02f, -2.38740090e-02f, 3.79820354e-02f,
  -7.64450133e-02f, 8.90443847e-02f, 9.97400954e-02f, -2.30701882e-02f, 1.22291632e-01f, -8.17020535e-02f, -1.97639260e-02f, 5.20712463e-03f, -1.01111745e-02f, 8.26282352e-02f,
  -2.60094572e-02f, 9.18969139e-02f, -1.54176667e-01f, 3.20782103e-02f, -8.07587430e-02f, 4.60950565e-03f, -6.48168996e-02f, 2.53291018e-02f, -8.88281688e-02f, 4.88957055e-02f,
  -5.68163805e-02f, 1.07979558e-01f, -1.69654861e-01f, -8.72386247e-02f, -1.19447611e-01f, 7.21895248e-02f, -4.89469953e-02f, 4.84126359e-02f, 7.70111755e-02f, 3.15522373e-01f,
  2.22541317e-02f, -3.95307019e-02f, -2.86797106e-01f, -1.94191083e-01f, 3.25292908e-02f, 4.44998741e-02f, -3.05725373e-02f, 2.65752729e-02f, 2.19388008e-01f, 1.50055485e-02f,
  -1.40106499e-01f, -1.03830762e-01f, -8.41950029e-02f, 1.30976036e-01f, -2.21850470e-01f, 6.07901961e-02f, 5.18980101e-02f, -2.54759192e-03f, 6.08834438e-02f, -5.45784943e-02f,
  2.45443344e-01f, 1.49885193e-01f, 2.78200030e-01f, -1.43196210e-01f, 1.18177131e-01f, 8.65606666e-02f, 1.20263807e-01f, -1.97908953e-02f, -2.45881267e-02f, -2.16293987e-02f,
  5.22702113e-02f, 1.53489470e-01f, 7.28689209e-02f, -1.90117642e-01f, -5.85361272e-02f, 3.50835845e-02f, -2.32358098e-01f, -1.69803447e-03f, 1.12192459e-01f, 2.26978868e-01f,
  -2.73426950e-01f, -4.66116481e-02f, -1.75073177e-01f, -6.11502789e-02f, 2.19527423e-01f, 4.09181677e-02f, 1.52052507e-01f, 2.05382735e-01f, -1.16371185e-01f, 1.41326532e-01f,
  -2.52317148e-03f, 7.20662670e-03f, -4.90916520e-02f, -9.28056464e-02f, 3.50408778e-02f, -8.65621194e-02f, 3.55026908e-02f, -3.04951370e-01f, -9.33283642e-02f, -1.74218770e-02f,
  1.63731083e-01f, 1.56178057e-01f, 1.14240848e-01f, 4.46637243e-01f, -1.31251127e-01f, -1.35731503e-01f, -1.03004850e-01f, 2.66271364e-02f, 2.67269351e-02f, -2.46363595e-01f,
  1.47214830e-01f, 1.21906092e-02f, 8.34682509e-02f, -2.48390079e-01f, -1.56420574e-01f, 9.45355743e-02f, -7.17981979e-02f, 3.03193063e-01f, 1.03689004e-02f, -9.19301063e-02f,
  3.25874835e-02f, 2.22305749e-02f, 1.03475653e-01f, 5.75638227e-02f, 6.97515020e-03f, -7.31896907e-02f, -8.11568350e-02f, 2.60255575e-01f, -2.32995868e-01f, 3.12227815e-01f,
  1.24062538e-01f, 9.96801779e-02f, 6.77589551e-02f, 8.12324807e-02f, -3.99528109e-02f, 1.81103975e-01f, 1.87969938e-01f, -1.54563725e-01f, -1.78629175e-01f, 6.87969998e-02f,
  -1.16109531e-02f, 1.82843618e-02f, 1.19334646e-02f, -1.25883743e-01f, 1.33434832e-01f, -2.43624449e-01f, -1.63601041e-01f, -6.58561066e-02f, 1.61021575e-01f, -1.90023050e-01f,
  2.25870803e-01f, 5.32572009e-02f, 1.59496620e-01f, -2.92560980e-02f, -5.02040014e-02f, 1.55186981e-01f, 8.26930553e-02f, -2.99332678e-01f, -1.57804757e-01f, 2.15217501e-01f,
  7.81097561e-02f, 2.59685926e-02f, -3.46867554e-02f, -4.67030033e-02f, -9.55649465e-02f, 2.22391412e-02f, -9.84006450e-02f, 1.78748578e-01f, 1.30043715e-01f, -2.65060775e-02f,
  -6.38783351e-02f, -9.51175019e-02f, -1.93333134e-01f, -2.75179893e-01f, 7.94174522e-02f, 7.28608295e-02f, -4.32613343e-02f, 2.61058658e-01f, 2.97411364e-02f, -1.43602774e-01f,
  1.56702418e-02f, -1.86553318e-02f, -6.71486035e-02f, 2.28388712e-01f, -2.40318537e-01f, 8.25793818e-02f, -1.18542463e-01f, -1.12465523e-01f, -4.83087711e-02f, 2.65889198e-01f,
  4.59404066e-02f, -5.01812696e-01f, -1.20228507e-01f, -3.92738074e-01f, -3.14501524e-02f, 1.11916708e-02f, 5.72879389e-02f, -1.69497848e-01f, 5.47590032e-02f, 5.52562717e-03f,
  3.33998613e-02f, 5.16904369e-02f, 2.07937155e-02f, -3.78587730e-02f, -4.14840132e-02f, 1.10368300e-02f, 6.89579099e-02f, 5.60588203e-03f, 4.41866852e-02f, 1.14420559e-02f,
  -5.48217557e-02f, 3.14868577e-02f, -1.43958256e-01f, 6.83166180e-03f, -5.24655581e-02f, 5.24872951e-02f, -8.44006017e-02f, -6.88157305e-02f, 3.50238308e-02f, 3.78722325e-02f,
  -1.03407405e-01f, 7.67905191e-02f, 5.73024116e-02f, -1.03938170e-01f, 1.33367181e-01f, 2.33408879e-03f, 2.22577266e-02f, -1.51110604e-01f, -7.03283697e-02f, -1.73426256e-01f,
  2.18777694e-02f, -1.49467159e-02f, -1.08327024e-01f, 9.37185735e-02f, -6.46649860e-03f, -1.20851435e-01f, 4.32837903e-02f, 8.87857080e-02f, 1.13187216e-01f, -3.31948511e-02f,
  8.96885321e-02f, -3.06174625e-02f, -1.17762618e-01f, 1.55970171e-01f, -1.28808975e-01f, -6.27564848e-04f, 6.44422993e-02f, 3.86751667e-02f, 2.43070975e-01f, -2.69170225e-01f,
  -2.12225437e-01f, -2.92633548e-02f, -9.25982818e-02f, 2.26021230e-01f, 1.49698883e-01f, -4.15933579e-01f, 1.05744831e-01f, -2.22373426e-01f, -9.68963653e-02f, -3.74690257e-02f,
  3.63926142e-02f, -4.10935692e-02f, -1.15868663e-02f, -6.16480522e-02f, -8.59225690e-02f, 1.17622606e-01f, 9.98638421e-02f, 7.87434950e-02f, -3.98359261e-02f, 6.09278232e-02f,
  -8.11147690e-02f, 6.90193474e-02f, -1.57894716e-01f, 2.36268342e-02f, -6.11841977e-02f, -8.21582302e-02f, -2.10033834e-01f, 7.62586221e-02f, -2.45332923e-02f, 1.46355964e-02f,
  3.15169096e-02f, 3.02600451e-02f, -7.65775964e-02f, -3.46843302e-02f, 5.85850924e-02f, 4.04353105e-02f, -2.75047608e-02f, -1.09398164e-01f, -2.20256541e-02f, -2.85647511e-02f,
  1.68216974e-01f, -5.66451252e-02f, -1.26121998e-01f, -1.42531499e-01f, 3.59776951e-02f, 5.97979128e-02f, -2.18004897e-01f, 1.13165542e-01f, 1.58494815e-01f, 1.39315605e-01f,
  -1.19908601e-02f, 5.12859151e-02f, -1.87436175e-02f, -7.94421285e-02f, 1.61462188e-01f, 1.98049054e-01f, -2.57613733e-02f, 2.06633732e-02f, -1.85504615e-01f, 9.39821228e-02f,
  -1.62996590e-01f, 7.09889978e-02f, 2.94000395e-02f, -1.20208666e-01f, -4.68580797e-02f, 2.66036279e-02f, -1.45994335e-01f, 3.51885296e-02f, 6.36390299e-02f, 1.24886580e-01f,
  2.18520015e-01f, 9.55441743e-02f, 9.90640000e-02f, -1.10377043e-01f, 2.16674119e-01f, 8.01306218e-03f, 9.18686539e-02f, 1.00119203e-01f, 1.34511843e-01f, 7.97646791e-02f,
  3.46211642e-02f, -1.61073413e-02f, -1.33501843e-01f, 3.12249921e-02f, 9.67195779e-02f, 9.46416780e-02f, 2.24392321e-02f, 5.12966737e-02f, 1.18178241e-02f, 2.90393922e-02f,
  -1.30012147e-02f, 1.06250443e-01f, 7.85245840e-03f, -2.37983800e-02f, -2.36303341e-02f, 1.18348427e-01f, 6.90885708e-02f, 8.05907231e-03f, 2.88532693e-02f, -2.47194707e-01f,
  2.20688820e-01f, -2.04020858e-01f, 1.38923496e-01f, 1.09345220e-01f, 1.46637426e-03f, 1.26712143e-01f, -1.31782219e-02f, 1.64632965e-02f, -1.14197187e-01f, -2.32358679e-01f,
  -1.71436876e-01f, -9.09069106e-02f, 2.35582724e-01f, -5.12682050e-02f, -2.68228687e-02f, 6.23305216e-02f, 7.66438991e-02f, 1.19033635e-01f, -1.78400904e-01f, 5.04307523e-02f,
  1.59226228e-02f, 9.13813263e-02f, 1.19278394e-01f, -1.01004988e-01f, 1.69323370e-01f, -1.79679468e-01f, -9.80008766e-02f, 2.30453853e-02f, 1.79139718e-01f, 4.82107028e-02f,
  -5.83084077e-02f, -7.26957768e-02f, -3.68882686e-01f, 9.56360325e-02f, -1.80829570e-01f, -2.02345461e-01f, -1.64784864e-01f, 1.66973785e-01f, -1.24433767e-02f, 1.25736445e-01f,
  -1.64724469e-01f, -1.23641223e-01f, -1.95671558e-01f, 7.18768388e-02f, -6.30830526e-02f, 1.07891336e-01f, 1.87090859e-02f, -2.01047752e-02f, -3.40082124e-02f, -9.18531641e-02f,
  -4.60471958e-02f, -1.43027287e-02f, -1.35222852e-01f, -1.48618400e-01f, -2.52098054e-01f, -5.08778878e-02f, 2.53002904e-02f, 7.23450854e-02f, -4.21479568e-02f, -7.69951344e-02f,
  3.15309986e-02f, 1.20049782e-01f, -1.20532960e-01f, 2.19857916e-01f, -1.00301921e-01f, 1.74611360e-01f, -8.89317915e-02f, 2.03142211e-01f, 3.29494625e-02f, 8.53539258e-02f,
  -3.19520198e-02f, -9.08669829e-02f, 7.92531371e-02f, -4.19703692e-01f, 5.52039873e-03f, 4.01928276e-02f, 1.79485995e-02f, 4.07840833e-02f, 1.08645536e-01f, 7.98726156e-02f,
  -9.50951874e-02f, 1.53701961e-01f, -1.89523131e-01f, 4.32288200e-02f, 1.20406419e-01f, 5.03612608e-02f, 2.29340255e-01f, -1.91794083e-01f, 1.17830426e-01f, -6.64006025e-02f,
  -7.68852159e-02f, 2.81009436e-01f, -3.17500643e-02f, -5.42940162e-02f, 1.64695561e-01f, -2.48708993e-01f, -1.11502647e-01f, 2.25469202e-01f, -1.13982864e-01f, 1.15296990e-01f,
  1.36519715e-01f, 1.03930019e-01f, 1.48524120e-01f, 5.11175059e-02f, 4.57482636e-02f, -4.00725156e-02f, 9.98417586e-02f, 1.67657018e-01f, 5.64224422e-02f, -1.78327411e-02f,
  5.80841824e-02f, -1.39692381e-01f, -8.10272247e-02f, -1.71935841e-01f, 1.84298656e-03f, -1.46791756e-01f, 8.75467509e-02f, 5.49655668e-02f, 1.04574203e-01f, -1.50599137e-01f,
  -2.29305103e-02f, -2.96170805e-02f, 1.08287774e-01f, -2.99501084e-02f, -9.31025203e-03f, -1.53223649e-01f, 1.18775778e-02f, -1.70747802e-01f, 2.48305574e-02f, 1.70495495e-01f,
  1.69350579e-01f, 1.28852054e-01f, -1.10103870e-02f, -3.37305963e-02f, -1.48039728e-01f, -2.64583796e-01f, -1.54839486e-01f, -3.44312713e-02f, 6.48109466e-02f, 1.18974850e-01f,
  9.25101116e-02f, -6.04373738e-02f, -1.46022588e-01f, -8.28153938e-02f, 1.68079913e-01f, -4.76585217e-02f, 3.07242312e-02f, 2.70762026e-01f, 1.83876939e-02f, 4.32342179e-02f,
  3.30158509e-02f, 1.97262932e-02f, 8.26888233e-02f, 1.44997448e-01f, -2.48096824e-01f, 2.17515845e-02f, 8.79383311e-02f, 2.51813322e-01f, -7.55545683e-04f, 6.26313314e-02f,
  6.69457912e-02f, -2.10145265e-01f, -4.21230607e-02f, -2.69118637e-01f, -1.07502818e-01f, -2.06128627e-01f, -1.02786154e-01f, 3.00323758e-02f, 1.46870092e-01f, -2.16976013e-02f,
  -5.21382643e-03f, 5.65709211e-02f, 6.34398311e-02f, 6.36253208e-02f, 1.37646914e-01f, -2.53429841e-02f, -7.47366250e-02f, -2.01996379e-02f, -2.63625253e-02f, -8.96870866e-02f,
  1.56439528e-01f, -7.98528716e-02f, -2.12125316e-01f, 1.25733793e-01f, 3.63293886e-02f, -4.43476103e-02f, 5.46312705e-02f, -4.35165651e-02f, -2.02486172e-01f, -1.52149022e-01f,
  4.83210832e-02f, -3.25122140e-02f, -3.34119760e-02f, 3.06219570e-02f, 2.93163378e-02f, 3.62931229e-02f, -1.09198913e-02f, -3.82593311e-02f, -8.54499489e-02f, 1.07312553e-01f,
  1.07480236e-03f, 2.73286939e-01f, -2.07389072e-01f, -2.20626235e-01f, 2.10251376e-01f, 1.31601363e-01f, -2.06752613e-01f, 6.88827708e-02f, -1.08637646e-01f, -1.14883192e-01f,
  -8.31412384e-04f, 2.08018869e-01f, -7.42143616e-02f, -1.09328948e-01f, -2.50399917e-01f, 1.16194762e-01f, -4.34776396e-02f, -2.41304472e-01f, 1.81398019e-01f, 1.46641329e-01f,
  -8.58724564e-02f, -1.04094811e-01f, -1.77874520e-01f, -1.17785528e-01f, -2.05482945e-01f, 2.11132124e-01f, 1.12253860e-01f, 5.44595122e-02f, 1.48432538e-01f, -7.15559348e-02f,
  -6.64933175e-02f, 9.90448147e-02f, -3.09910588e-02f, 1.46352604e-01f, 1.23122059e-01f, 8.17213729e-02f, -5.68198822e-02f, -9.10514146e-02f, 1.26537755e-01f, -3.15004657e-03f,
  -6.03496321e-02f, 1.32943792e-02f, -8.67838413e-03f, -6.55427873e-02f, -6.87716156e-02f, -1.03652373e-01f, 1.16317995e-01f, 2.11000396e-03f, 1.69613806e-03f, -2.82630231e-02f,
  9.04903188e-02f, 6.12772666e-02f, -9.27795991e-02f, 1.28119186e-01f, -3.04030254e-03f, -7.44689554e-02f, -1.33492216e-01f, 9.82526541e-02f, -1.07218854e-01f, -2.64336150e-02f,
  8.66957456e-02f, -3.68299186e-02f, -9.75726694e-02f, -5.53523339e-02f, -5.54404482e-02f, 9.40772817e-02f, -1.40298113e-01f, 1.11328319e-01f, 8.54464062e-03f, 1.87355816e-01f,
  -1.62862659e-01f, -1.62013546e-01f, -7.48796854e-03f, 5.73569573e-02f, 1.13497548e-01f, 1.20492347e-01f, -2.77320039e-04f, 1.97429005e-02f, 2.69771889e-02f, 5.53596057e-02f,
  4.31505553e-02f, 1.57383740e-01f, -1.83796525e-01f, 2.56443828e-01f, 2.10057780e-01f, 2.04967391e-02f, -1.09714214e-02f, -9.95953083e-02f, 1.90140024e-01f, 2.94673383e-01f,
  1.30638108e-01f, 1.68165892e-01f, 1.16687365e-01f, -2.76258230e-01f, -1.25318274e-01f, 6.98499307e-02f, -1.74648184e-02f, 3.61047010e-03f, -3.93269360e-02f, -2.22681277e-02f,
  -1.35098606e-01f, -8.60127583e-02f, -5.76219819e-02f, 5.51343821e-02f, 1.69209912e-02f, 1.87080521e-02f, 4.80846316e-02f, 2.77999733e-02f, 8.69664177e-02f, -3.03499773e-02f,
  8.93178657e-02f, -2.49068700e-02f, 1.64485976e-01f, 5.32674836e-03f, -8.08896497e-02f, -1.02008209e-02f, 3.90485823e-02f, 1.01666987e-01f, -6.76143691e-02f, 4.88371179e-02f,
  -7.16120750e-02f, -3.23424861e-02f, -1.65148526e-01f, 1.50341362e-01f, -3.93120311e-02f, -3.01866420e-03f, 1.27411157e-01f, -2.51582056e-01f, 9.56718102e-02f, 3.00151892e-02f,
  1.28642246e-01f, 1.45551354e-01f, -3.02658260e-01f, -3.12155098e-01f, -3.51831876e-03f, -2.25885719e-01f, -6.70327321e-02f, 6.70252070e-02f, -1.84144322e-02f, -1.19095899e-01f,
  -4.29865811e-03f, 1.96470052e-01f, 1.06188506e-01f, -1.27643391e-01f, -5.37887625e-02f, 2.21900687e-01f, -1.68399066e-01f, -9.80357304e-02f, -4.23962325e-02f, 4.15312827e-01f,
  1.06638864e-01f, 6.27651662e-02f, 2.29388908e-01f, -3.38207841e-01f, -7.06810653e-02f, -8.69004801e-02f, -1.76452085e-01f, 1.78944897e-02f, 9.60091054e-02f, 6.15089610e-02f,
  4.19036597e-02f, -2.30585769e-01f, 7.52834082e-02f, 7.89296255e-02f, -1.47032272e-02f, -3.59951444e-02f, 5.45080230e-02f, -3.51499133e-02f, -2.78216042e-02f, 1.41177997e-02f,
  -3.97025049e-02f, 3.70707996e-02f, -1.52040511e-01f, -6.30825907e-02f, -4.38544108e-03f, -2.78137475e-01f, -1.33863136e-01f, 1.02005191e-01f, -3.90757583e-02f, 1.03810742e-01f,
  -1.03715837e-01f, 1.56316742e-01f, 3.42717161e-03f, -3.12377721e-01f, 7.00784549e-02f, 1.53671890e-01f, 2.30209157e-02f, 1.84988394e-01f, 1.05091268e-02f, -1.30296364e-01f,
  1.61277819e-02f, -8.84933844e-02f, 6.00042567e-02f, -1.70700684e-01f, 2.28409663e-01f, 1.61474273e-01f, -1.25983536e-01f, -1.05708376e-01f, 6.02450036e-03f, -2.96619534e-01f,
  1.47514194e-01f, 9.69260558e-02f, -8.28788206e-02f, 1.43495023e-01f, 1.22925736e-01f, -6.94845170e-02f, -1.32563210e-03f, -1.30412966e-01f, 7.68478364e-02f, 9.13523808e-02f,
  -2.18440279e-01f, -3.52146178e-02f, 1.31073147e-01f, -6.17156215e-02f, -1.60705764e-02f, 3.67315672e-02f, -3.40529889e-01f, -3.11965793e-01f, -1.76767081e-01f, 2.10085921e-02f,
  -2.23934308e-01f, -2.59897828e-01f, 2.25427411e-02f, 9.90789086e-02f, -4.54752184e-02f, 1.75084844e-01f, -2.42573805e-02f, 1.04850151e-01f, 5.68090528e-02f, -7.05381781e-02f,
  1.61064658e-02f, -4.67593856e-02f, -3.74647714e-02f, -6.15419708e-02f, -9.30184424e-02f, 2.12576985e-02f, 1.70844987e-01f, 3.23590674e-02f, -4.68815006e-02f, 7.86125660e-02f,
  5.30209243e-02f, 1.00748129e-01f, 5.50480699e-03f, 1.38433883e-03f, 1.14319483e-02f, 8.66998825e-03f, 3.95786949e-02f, 2.26302043e-01f, -9.92066562e-02f, 7.41107389e-02f,
  8.86869952e-02f, 9.47461277e-02f, -4.99508670e-03f, -9.19109657e-02f, -1.19575426e-01f, -1.37730613e-01f, 5.22272103e-02f, -2.03912064e-01f, 1.66214854e-01f, 2.19619811e-01f,
  8.72788019e-03f, -1.20444141e-01f, -5.30883223e-02f, -1.39909489e-02f, 1.44681960e-01f, -3.38609628e-02f, -8.00599977e-02f, 8.02496597e-02f, 1.46329761e-01f, 1.77957386e-01f,
  5.85730672e-02f, 6.52350262e-02f, 6.38810769e-02f, 1.97558969e-01f, -2.19988018e-01f, 5.02760261e-02f, 9.55346823e-02f, 1.53606772e-01f, -2.83317029e-01f, 3.40927672e-03f,
  1.36001995e-02f, 7.72698298e-02f, 7.42249861e-02f, 2.48214696e-02f, -1.36597827e-01f, -3.63231421e-01f, -6.49020672e-02f, 5.25782593e-02f, 1.33188635e-01f, 1.94705069e-01f,
  1.50305599e-01f, 6.20355271e-02f, -3.24274451e-02f, -1.69089660e-01f, -1.21969124e-02f, 1.04870990e-01f, 4.20912681e-03f, 8.67184401e-02f, -1.29915355e-02f, 2.28234883e-02f,
  -5.47329634e-02f, -1.47296354e-01f, -5.24006970e-02f, -2.72455662e-02f, 1.12003230e-01f, 1.43516719e-01f, 1.87978819e-01f, -2.86467299e-02f, -7.64489695e-02f, 4.94442694e-02f,
  1.31518006e-01f, -2.31686831e-01f, -5.07924967e-02f, 1.12767674e-01f, 2.35083848e-01f, 5.98716363e-02f, 1.51525453e-01f, 6.69962987e-02f, -1.20340765e-01f, -2.77916580e-01f,
  -2.00559897e-03f, -1.90114930e-01f, -7.55323693e-02f, -6.94992021e-02f, 4.86205369e-02f, -6.63943663e-02f, 6.54143617e-02f, 8.06284137e-03f, -5.98795749e-02f, 1.34334322e-02f,
  -5.46512865e-02f, 8.18890706e-02f, 5.14566340e-02f, -3.23624238e-02f, 2.04280484e-02f, 2.18071342e-02f, 4.14333865e-02f, 1.61415741e-01f, -2.67352104e-01f, 1.13742679e-01f,
  -6.54294947e-03f, -1.47747695e-01f, -2.34269053e-01f, 1.32962853e-01f, -1.35191396e-01f, 2.97453981e-02f, 2.16005534e-01f, -1.31741330e-01f, -1.43391743e-01f, -1.87472135e-01f,
  -2.33048853e-02f, -9.11168829e-02f, -1.42395914e-01f, 8.21425170e-02f, 2.41895039e-02f, 7.34743103e-02f, 7.95910507e-02f, 1.29792644e-02f, 2.31375545e-01f, 4.88282666e-02f,
  1.19071588e-01f, 1.09409299e-02f, -1.28098115e-01f, 5.05130133e-03f, 2.09880680e-01f, -1.92624673e-01f, -1.85945436e-01f, 1.67327821e-01f, -1.41461536e-01f, -4.13922742e-02f,
  1.02046952e-01f, -2.19267011e-02f, -1.44325979e-02f, 3.69211752e-03f, 2.23590042e-02f, 2.17537850e-01f, 1.32592887e-01f, -9.27147940e-02f, 6.02040328e-02f, 4.79456894e-02f,
  8.40224400e-02f, -1.15700953e-01f, -2.59642094e-01f, -4.38349023e-02f, 8.99378359e-02f, 1.02603972e-01f, -7.64205977e-02f, 1.31922603e-01f, 5.10559827e-02f, -6.13948442e-02f,
  4.79171574e-02f, 1.79051995e-01f, 1.20410666e-01f, -7.32837543e-02f, 2.77131289e-01f, -4.27548550e-02f, -4.86732014e-02f, -9.51785408e-03f, -1.69593632e-01f, 7.20954761e-02f,
  -9.82304215e-02f, 1.08061276e-01f, 2.39902779e-01f, 7.84649029e-02f, 1.34825096e-01f, -1.28040552e-01f, 9.51489583e-02f, 5.75023368e-02f, 1.08445726e-01f, 3.21749687e-01f,
  2.42191210e-01f, 1.73174307e-01f, 1.32524699e-01f, -4.64885011e-02f, 1.68831617e-01f, 1.67935621e-02f, -7.94931427e-02f, -1.50028884e-01f, 2.56731063e-01f, 9.99576449e-02f,
  -4.62358184e-02f, 1.04344264e-01f, -1.61142856e-01f, -8.95683169e-02f, -4.54589501e-02f, 1.64222978e-02f, -1.47038594e-01f, 5.41443378e-03f, -3.51705961e-02f, 5.39807864e-02f,
  -7.05999555e-03f, -2.57935002e-02f, -1.86387058e-02f, 1.13997936e-01f, 1.49664864e-01f, 1.39106840e-01f, 2.24662460e-02f, 2.09426670e-03f, 7.30656236e-02f, -1.38658479e-01f,
  1.49105132e-01f, 1.83995292e-01f, 3.12099695e-01f, -3.28393690e-02f, 2.17471570e-01f, -1.85577959e-01f, 9.27578211e-02f, -1.87709238e-02f, -4.13851887e-02f, -2.20739573e-01f,
  4.48809043e-02f, 1.08531125e-01f, 3.80403809e-02f, -8.87364000e-02f, -1.99455783e-01f, -3.58317554e-01f, 1.88342571e-01f, 1.75172210e-01f, -9.89882722e-02f, 2.05433667e-01f,
  2.13740870e-01f, -1.89509407e-01f, 1.70157745e-01f, -3.41632754e-01f, -2.06144214e-01f, 1.17832392e-01f, -1.63821533e-01f, -5.21752685e-02f, 9.38665345e-02f, 1.29795864e-01f,
  -1.94073588e-01f, -1.54895661e-02f, -3.51523817e-01f, -4.57504131e-02f, -1.86011836e-01f, -1.56369075e-01f, -1.48962200e-01f, -4.18950059e-02f, 1.45908803e-01f, 1.04211019e-02f,
  -9.91374552e-02f, -9.52171236e-02f, 4.16968502e-02f, -3.54164578e-02f, -8.44186693e-02f, 6.92742225e-03f, 1.40272304e-01f, 1.18369885e-01f, -2.43624002e-02f, -1.83903873e-02f,
  1.87938847e-02f, -3.08952667e-03f, -1.66975837e-02f, 1.16937995e-01f, 1.16801433e-01f, -6.81931600e-02f, -8.14770088e-02f, -7.30444193e-02f, 1.66609615e-01f, 7.55085424e-02f,
  2.15280652e-01f, 3.97425219e-02f, -3.23585570e-02f, -1.88220695e-01f, 2.47644521e-02f, 4.70179506e-02f, 3.72616686e-02f, -4.65446077e-02f, 2.01103657e-01f, -1.11298166e-01f,
  -2.73971945e-01f, -6.66485503e-02f, 2.79411499e-04f, -2.82895327e-01f, 3.61117646e-02f, -6.98496476e-02f, -1.85730055e-01f, -1.08189788e-02f, -1.50794964e-02f, -1.92770138e-01f,
  1.40037268e-01f, 3.48908901e-02f, 1.12759411e-01f, -3.91912460e-02f, 1.77490801e-01f, 4.71593104e-02f, -1.65833935e-01f, -6.37764782e-02f, 7.90246204e-02f, 2.86888093e-01f,
  -3.33206624e-01f, -1.17242940e-01f, 9.16934684e-02f, -8.05637836e-02f, 3.51589173e-02f, 1.99723113e-02f, -3.90809812e-02f, 2.17440575e-01f, 7.67304823e-02f, 1.51269227e-01f,
  -1.46889925e-01f, -3.63710910e-01f, -1.14821211e-01f, -5.78543209e-02f, 2.90964544e-02f, 1.20944671e-01f, -8.63873214e-02f, -9.95706692e-02f, 2.48581246e-02f, -5.00694886e-02f,
  -6.05071373e-02f, -1.36789177e-02f, 4.36320007e-02f, -4.50546443e-02f, -9.26712602e-02f, -1.50139555e-02f, -1.05839752e-01f, 6.36344850e-02f, 1.47117138e-01f, 4.79130223e-02f,
  -5.21328151e-02f, -1.48948342e-01f, -1.04134806e-01f, 8.42646882e-03f, -4.19734120e-02f, -1.21555459e-02f, 6.62439615e-02f, 1.08893827e-01f, 1.39800282e-02f, 8.37441310e-02f,
  -1.27229616e-01f, -4.54888083e-02f, 5.13104834e-02f, -1.56488135e-01f, -7.60271698e-02f, -1.42754719e-01f, 3.06323953e-02f, 3.68829608e-01f, 9.69775617e-02f, 5.25181741e-02f,
  -8.00156817e-02f, 1.58669632e-02f, -1.08891129e-01f, -1.01188406e-01f, 1.19432896e-01f, -3.27806056e-01f, -6.44108728e-02f, -9.98549387e-02f, -5.81781268e-02f, 4.24865782e-02f,
  6.61522476e-03f, 3.74205597e-02f, 2.57674187e-01f, -5.45506948e-04f, 4.10425328e-02f, -1.02306746e-01f, -3.10082827e-02f, -3.03819142e-02f, 2.59936862e-02f, 2.07970679e-01f,
  2.96489120e-01f, -1.17795132e-01f, 2.35068053e-01f, 2.22594634e-01f, 2.61592388e-01f, -2.07202524e-01f, 7.95763656e-02f, 3.06679029e-02f, 8.85102078e-02f, 9.25333425e-03f,
  5.51420450e-02f, -6.46981522e-02f, 1.31868556e-01f, 2.25563664e-02f, 1.06602736e-01f, -6.18158327e-03f, -2.31133327e-02f, -8.84961430e-03f, -3.99379358e-02f, 6.85071433e-03f,
  6.82183132e-02f, 4.18635346e-02f, -4.62497734e-02f, 1.92239895e-01f, -1.24765551e-02f, 5.09685129e-02f, 8.06547478e-02f, -3.09892520e-02f, -3.26671414e-02f, 1.13010108e-01f,
  -3.70826409e-03f, 1.29000247e-02f, -7.74814095e-03f, 1.01538212e-03f, -1.12953581e-01f, -8.16336721e-02f, -9.98812914e-03f, 1.25028133e-01f, -1.88241675e-01f, -4.71957326e-02f,
  4.11821306e-02f, 2.69671887e-01f, -1.48471519e-01f, -2.00010464e-02f, 3.74719575e-02f, 9.59350392e-02f, -3.47291157e-02f, -1.84576381e-02f, -9.48807448e-02f, -7.42063597e-02f,
  1.43440977e-01f, 4.27494049e-02f, -7.69771263e-02f, -2.53568310e-02f, -1.44385308e-01f, 1.77615926e-01f, -6.75437897e-02f, 1.95243493e-01f, 1.33355558e-01f, 3.48511040e-02f,
  -1.89715609e-01f, 3.37938517e-02f, -1.71245858e-01f, 1.32214904e-01f, 3.39267522e-01f, 3.43405791e-02f, 1.52329698e-01f, 2.12659463e-01f, 2.26210535e-01f, -1.57257512e-01f,
  2.54142910e-01f, -4.69677262e-02f, 2.83355415e-02f, 4.48943637e-02f, 3.60478945e-02f, 1.43238649e-01f, 1.56821236e-01f, -1.91803604e-01f, -1.28886148e-01f, -2.12448351e-02f,
  -5.60445599e-02f, -3.29927579e-02f, -5.66698471e-03f, -1.23262834e-02f, 9.00484174e-02f, 7.19435066e-02f, 7.28472695e-02f, 1.49814472e-01f, -1.53186738e-01f, -9.65538993e-02f,
  7.65798837e-02f, -5.46999015e-02f, 8.20131004e-02f, -5.83927594e-02f, 2.06732471e-03f, 1.31659016e-01f, -4.40227352e-02f, 1.12285294e-01f, -9.67549905e-02f, 2.06851363e-02f,
  1.18807629e-01f, 1.17300861e-01f, -1.05462387e-01f, -3.06211561e-01f, 9.43375006e-02f, -2.13817179e-01f, 2.54266739e-01f, 2.21553430e-01f, -1.94773048e-01f, 1.70265511e-02f,
  -5.70998080e-02f, 3.37119028e-02f, 4.13477495e-02f, -6.25058413e-02f, 7.09260181e-02f, 9.87746939e-03f, 1.38004497e-01f, 2.00959995e-01f, -1.09614573e-01f, -9.14331228e-02f,
  7.61592612e-02f, 1.12014264e-01f, -1.64597899e-01f, -3.23641561e-02f, 1.04541495e-01f, 2.19475091e-01f, -1.89073142e-02f, -2.38174006e-01f, 3.65295619e-01f, 1.69286668e-01f,
  1.24619946e-01f, 2.61496771e-02f, -1.33426368e-01f, -1.54682338e-01f, 7.95433149e-02f, 2.06749067e-01f, 7.20414743e-02f, 1.61979556e-01f, 1.69155344e-01f, 5.15560769e-02f,
  -6.13027178e-02f, 5.78125305e-02f, 6.57945946e-02f, -6.51497208e-03f, -2.71149781e-02f, 6.38115183e-02f, 3.17449158e-04f, -1.21519126e-01f, -3.28315375e-03f, 1.89353243e-01f,
  2.60790080e-01f, -3.02774664e-02f, 1.17775537e-01f, 6.95328712e-02f, 6.71246722e-02f, -8.28906745e-02f, -3.77611108e-02f, -7.42146000e-02f, 6.50932118e-02f, -2.98654079e-01f,
  -1.40112303e-02f, 9.16945562e-02f, -1.69778183e-01f, 1.02785090e-02f, -1.85060740e-01f, 7.04300776e-02f, 8.03893507e-02f, 3.37373346e-01f, -5.62895974e-03f, 2.80406386e-01f,
  1.38233438e-01f, -9.53465253e-02f, -8.97481814e-02f, -6.76247105e-02f, -2.34364420e-01f, -1.55180633e-01f, -5.00316359e-02f, -8.94617513e-02f, -3.63302343e-02f, 1.01768874e-01f,
  1.76393211e-01f, -6.69327527e-02f, 7.52364025e-02f, 8.54272097e-02f, -2.31646132e-02f, 1.55246973e-01f, -6.30744994e-02f, 8.63355696e-02f, -1.81603625e-01f, -3.00106499e-02f,
  3.84803601e-02f, -1.09748356e-01f, 3.56838405e-02f, -3.27104032e-01f, -2.55829841e-01f, -2.30685219e-01f, 1.38230950e-01f, 5.89229912e-02f, 7.18234181e-02f, -1.90355889e-02f,
  -1.19605713e-01f, -1.35509536e-01f, -5.89757673e-02f, -6.52335882e-02f, 8.26060623e-02f, 8.74274448e-02f, -7.84693435e-02f, -5.96364364e-02f, 3.92567553e-02f, 3.66303548e-02f,
  -9.22966525e-02f, 1.58987194e-01f, 5.89085091e-03f, 1.49603084e-01f, -1.14804320e-01f, -1.22114822e-01f, 6.27037436e-02f, 3.29543427e-02f, -1.33301452e-01f, -9.57941040e-02f,
  1.16882883e-01f, 8.29065889e-02f, 5.90168685e-02f, 1.99532926e-01f, -9.31533352e-02f, -7.36029968e-02f, -1.79679438e-01f, 2.10726157e-01f, 1.40658673e-02f, 1.25141501e-01f,
  5.82866333e-02f, 9.64337364e-02f, 6.94784848e-03f, -2.30840012e-01f, 1.35552377e-01f, 6.30120486e-02f, -6.71726465e-02f, 1.33428657e-02f, 8.40013847e-02f, -8.27376693e-02f,
  -1.57127783e-01f, 1.55634061e-01f, -5.82119748e-02f, -9.57709476e-02f, -5.00465333e-02f, 6.35766312e-02f, 1.08079590e-01f, -1.77538067e-01f, -2.21687466e-01f, -1.29198119e-01f,
  2.15148982e-02f, -1.49462342e-01f, 3.14405486e-02f, 9.80407819e-02f, 1.97416797e-01f, -3.60716432e-01f, 1.06664523e-02f, -1.62567981e-02f, -1.38998464e-01f, -5.52210212e-02f,
  -7.35288337e-02f, 1.86857820e-01f, 1.09351252e-03f, -1.58940796e-02f, 4.85169739e-02f, 5.92840835e-02f, -6.32165791e-03f, 7.67193548e-03f, 3.06962598e-02f, -7.20224753e-02f,
  -5.94847016e-02f, 3.34627256e-02f, -6.51006550e-02f, 8.57863054e-02f, -9.56609622e-02f, 3.46625573e-03f, -4.15763855e-02f, 5.02208620e-03f, -1.56745493e-01f, -2.89305914e-02f,
  4.43240665e-02f, 1.85229585e-01f, 9.24586579e-02f, 1.08440444e-02f, -9.50610265e-02f, -2.35717874e-02f, 9.36618149e-02f, -2.01506004e-01f, -2.88985856e-02f, 2.12587476e-01f,
  6.58382699e-02f, 5.11948168e-02f, -1.37243822e-01f, -1.00669190e-01f, -3.95968445e-02f, -2.83820957e-01f, 3.14826593e-02f, 2.34123394e-01f, -5.27481064e-02f, 2.25620136e-01f,
  -1.82432383e-01f, -8.52198750e-02f, -1.04982287e-01f, -1.43666238e-01f, 3.05830804e-03f, 1.55284628e-01f, 2.28449807e-01f, 8.78756791e-02f, -4.83694598e-02f, -7.63426814e-03f,
  -3.30985375e-02f, 4.55352059e-03f, 3.32709844e-03f, 2.57088214e-01f, -1.05854087e-01f, 1.19300760e-01f, 6.05396479e-02f, 2.60271076e-02f, -1.85375139e-01f, 1.93297770e-02f,
  7.77976289e-02f, -2.55784601e-01f, 1.24374621e-01f, -8.93679112e-02f, 4.00216430e-02f, -2.08685786e-01f, 3.31637263e-02f, 9.97279733e-02f, 1.14878625e-01f, -7.65923560e-02f,
  -2.51110017e-01f, 1.15586393e-01f, 9.40139592e-02f, -9.92213041e-02f, 5.00355512e-02f, 2.53391694e-02f, -6.24029823e-02f, 1.05522878e-01f, -2.10056528e-01f, 1.46241084e-01f,
  1.14809923e-01f, 2.28128787e-02f, -1.90472275e-01f, 2.05662891e-01f, 8.31604227e-02f, 1.82932783e-02f, 1.42836692e-02f, 5.92530966e-02f, 3.41914818e-02f, 1.42421544e-01f,
  -1.75723736e-03f, 8.69208351e-02f, -1.86992556e-01f, -4.38197190e-03f, -7.40373656e-02f, -5.54547310e-02f, 8.49564299e-02f, 5.49280755e-02f, 2.47165337e-02f, -1.73276022e-01f,
  9.54313800e-02f, -1.49578601e-01f, 3.29513638e-03f, 1.09733552e-01f, -1.44476099e-02f, 1.40742689e-01f, 8.06430504e-02f, 1.76259324e-01f, -2.46834531e-02f, 5.48222288e-02f,
  -1.69683635e-01f, 1.04609393e-02f, 1.81172699e-01f, 2.34654859e-01f, 1.89481359e-02f, 2.87457649e-03f, 3.16824950e-02f, -1.43024608e-01f, -1.90532625e-01f, -4.20003496e-02f,
  9.19110477e-02f, -2.42542908e-01f, 1.15316026e-01f, 5.54886721e-02f, 9.04408023e-02f, 3.83379608e-01f, 4.55351174e-01f, 1.69735596e-01f, 1.21357925e-01f, -2.10712805e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  3.50166410e-02f, -5.04442900e-02f, 6.75029904e-02f, -5.43757938e-02f, -1.18042946e-01f, -1.53039517e-02f, 4.97896448e-02f, 1.48876205e-01f, 4.53397930e-02f, -1.06188674e-02f,
  1.19250491e-01f, 1.68246493e-01f, 4.63554934e-02f, 1.23726791e-02f, -1.68673158e-01f, 9.31568965e-02f, -1.10084098e-02f, 5.14227971e-02f, 6.14595041e-02f, 2.68526107e-01f,
  -6.66184723e-02f, 1.24775648e-01f, -1.92663376e-03f, 5.27001806e-02f, 3.07312555e-04f, -9.36979651e-02f, 1.56861484e-01f, 9.54473019e-03f, 2.67976940e-01f, 3.98812801e-01f,
  3.97372767e-02f, -1.95520028e-01f, 4.27828953e-02f, -2.90886432e-01f, 1.45688340e-01f, -2.61661351e-01f, -3.71719920e-03f, 2.52823114e-01f, 4.20574658e-02f, -4.37953115e-01f,
  2.27445394e-01f, 3.10628444e-01f, 2.89329499e-01f, 7.64040872e-02f, 1.49750352e-01f, 1.43499196e-01f, -1.05383098e-01f, 7.15390444e-02f, 8.30774233e-02f, 8.52437690e-02f,
  4.75152768e-02f, 6.63138554e-03f, 5.33871762e-02f, -8.37814808e-02f, 1.07585959e-01f, -9.44940075e-02f, -1.42624885e-01f, 3.54191422e-01f, 8.20610002e-02f, -3.74755442e-01f,
  2.95046359e-01f, -3.47530484e-01f, -1.55067801e-01f, -3.25716078e-01f, 1.53274029e-01f, 5.23266010e-02f, -1.07387476e-01f, 6.64852262e-02f, -8.51543397e-02f, 1.13428399e-01f,
  3.50819863e-02f, 9.69469994e-02f, -4.92814742e-02f, 9.19080824e-02f, -8.26815888e-02f, -4.62031364e-02f, -1.22291014e-01f, 1.89989567e-01f, -5.34787849e-02f, 1.85496479e-01f,
  2.48134658e-01f, -5.88388555e-03f, 1.44953936e-01f, -5.44327358e-03f, -4.92325835e-02f, -1.16125405e-01f, 4.04139347e-02f, -1.00055918e-01f, 1.75980269e-03f, 1.05858169e-01f,
  -5.74692525e-02f, 3.57720554e-02f, -2.64004350e-01f, 1.19524393e-02f, 1.01196148e-01f, 1.40210718e-01f, 1.01558708e-01f, 2.44432297e-02f, -4.94081676e-02f, -3.01098347e-01f,
  2.97867239e-01f, 4.44462448e-02f, -6.10720068e-02f, 1.97569598e-02f, -6.73628822e-02f, -1.29876271e-01f, -1.14802672e-02f, -1.13449387e-01f, -1.65148661e-01f, -1.66232914e-01f,
  2.14771271e-01f, 8.74067619e-02f, 4.19310145e-02f, -8.26422051e-02f, 1.58371180e-01f, 7.19354153e-02f, -1.05283245e-01f, 2.00977057e-01f, 1.17136333e-02f, 3.22004914e-01f,
  4.33133692e-02f, -1.20831966e-01f, 3.09854716e-01f, 1.15067422e-01f, -1.60731617e-02f, 8.87306258e-02f, -1.00705914e-01f, 4.85914685e-02f, 7.37367049e-02f, 1.19029723e-01f,
  9.10674110e-02f, 4.02668491e-02f, 2.44048372e-01f, 1.11837126e-01f, 1.02622218e-01f, 5.87483197e-02f, 1.02494985e-01f, 8.90970677e-02f, 6.21872395e-02f, 9.41070318e-02f,
  1.85908094e-01f, 1.86586734e-02f, -4.66602892e-02f, 9.50055420e-02f, 1.93112627e-01f, 4.56066206e-02f, -2.21650545e-02f, -1.41669780e-01f, -3.40465270e-02f, -2.03823633e-02f,
  9.02952924e-02f, -1.87831912e-02f, 2.13284254e-01f, 1.95381075e-01f, 2.72408910e-02f, -2.30084017e-01f, -2.17511728e-02f, -1.90720603e-01f, 9.88891423e-02f, 1.05009072e-01f,
  -4.89340238e-02f, 3.02966923e-01f, 1.73202932e-01f, -1.74502566e-01f, -7.59392455e-02f, -2.35078618e-01f, 1.79896161e-01f, 1.97610930e-01f, 1.31682381e-01f, 5.86939715e-02f,
  -2.31573414e-02f, -2.58092806e-02f, -9.56556201e-02f, 6.05097087e-03f, 4.03415076e-02f, -2.27014571e-02f, -4.04007733e-02f, -2.14767791e-02f, 2.86715448e-01f, -2.57249754e-02f,
  4.57338989e-01f, 1.53612420e-01f, 9.78711843e-02f, -1.13568023e-01f, -1.12271883e-01f, -2.37547196e-02f, -1.61919877e-01f, 3.57396334e-01f, -1.34860948e-01f, 1.62392139e-01f,
  5.63982613e-02f, 1.84908032e-01f, 2.41993129e-01f, 8.89359415e-02f, 7.58107081e-02f, 2.62743924e-02f, 2.02908784e-01f, 1.39501598e-02f, -5.52343130e-02f, -4.46994640e-02f,
  -3.36268693e-02f, 1.76413447e-01f, 1.39304847e-01f, -1.25181079e-01f, 2.06412882e-01f, 5.73010333e-02f, 1.15885064e-01f, 2.85997748e-01f, 2.02518150e-01f, -1.19818710e-01f,
  -6.89014979e-03f, 1.22206144e-01f, 7.09757134e-02f, -5.04558943e-02f, 3.04419696e-01f, 1.13794640e-01f, 2.03027010e-01f, -2.31614307e-01f, 4.68187518e-02f, -4.67934944e-02f,
  -4.49465811e-02f, 1.90479644e-02f, -1.30739838e-01f, -5.71169630e-02f, 1.59488261e-01f, 4.70815189e-02f, -1.11050382e-01f, -1.36833275e-02f, 1.60344720e-01f, 3.71272601e-02f,
  -3.96803409e-01f, -1.92622274e-01f, -1.03603594e-01f, -2.13041902e-01f, -3.13498192e-02f, -1.17221676e-01f, -2.64005698e-02f, -1.30343661e-01f, -1.77376121e-02f, 4.34837639e-02f,
  3.82701494e-02f, -1.27653062e-01f, 1.26266137e-01f, 3.71191651e-01f, 5.31007424e-02f, -2.38161191e-01f, -5.93167692e-02f, 2.37727895e-01f, 6.56436235e-02f, 1.35641396e-01f,
  -6.78692153e-03f, -3.40309232e-01f, -4.54566509e-01f, 2.29976494e-02f, -5.97403720e-02f, 2.59595484e-01f, 2.43733048e-01f, 5.01959175e-02f, 2.00104281e-01f, -3.44431289e-02f,
  -1.65015519e-01f, 5.11187017e-02f, 1.64592817e-01f, 3.83394100e-02f, -4.50145751e-02f, 9.30457842e-03f, -1.20804291e-02f, 1.33608758e-01f, 7.95039833e-02f, 1.69320762e-01f,
  1.08166143e-01f, 1.61864445e-01f, -1.42830648e-02f, 2.14397490e-01f, 1.23700798e-01f, 9.37995911e-02f, -8.00427347e-02f, 1.70814320e-01f, 1.66000545e-01f, 8.73547867e-02f,
  2.69341283e-02f, 5.45857310e-01f, -4.94038351e-02f, -2.55141765e-01f, -4.71858634e-03f, -1.47414833e-01f, 7.06266165e-02f, 2.76100278e-01f, 2.11113900e-01f, -7.85206854e-02f,
  4.95418981e-02f, -4.24594283e-01f, 3.53677422e-02f, 5.14777973e-02f, 9.75851417e-02f, 2.85059482e-01f, 1.38990745e-01f, 2.05780670e-01f, -8.92354324e-02f, 2.17602894e-01f,
  -2.47122765e-01f, -1.97808444e-01f, 1.78937420e-01f, 9.89014804e-02f, 1.70229927e-01f, -1.27047285e-01f, 3.54951434e-02f, 3.62709239e-02f, -1.29723251e-01f, 1.10739909e-01f,
  -5.53954858e-03f, 3.30257177e-01f, 1.72303811e-01f, -2.50602532e-02f, -2.41674900e-01f, 6.07435465e-01f, 8.18410218e-02f, 3.14914942e-01f, -4.40357551e-02f, 3.57345074e-01f,
  7.86187127e-03f, 4.62118089e-02f, -3.82053293e-02f, -2.18957752e-01f, -1.51436359e-01f, -3.22517529e-02f, -1.02091476e-01f, 2.23896615e-02f, -8.47894251e-02f, 2.05719303e-02f,
  -7.96398446e-02f, 3.87832001e-02f, -9.59922448e-02f, 1.12374164e-01f, -1.67125642e-01f, -8.18661973e-02f, 8.52575749e-02f, -2.30388809e-02f, 1.13729194e-01f, -1.44790262e-01f,
  -2.33211964e-01f, -1.73419155e-02f, -1.39759451e-01f, -7.35905617e-02f, 9.80180427e-02f, 1.81427792e-01f, -9.10690725e-02f, -1.14677683e-01f, -1.68899223e-01f, -6.23311475e-02f,
  5.53583764e-02f, 7.69611448e-02f, 9.27932560e-02f, 2.46966258e-01f, 1.15070276e-01f, -7.36819208e-02f, -7.05622137e-02f, -1.25126198e-01f, 1.27508938e-01f, 3.05174664e-02f,
  1.81246832e-01f, 4.37922589e-02f, -9.09262523e-02f, 3.03493198e-02f, 2.25993469e-02f, -1.15015786e-02f, 4.74636024e-03f, 6.58965707e-02f, 3.12170130e-03f, -1.04247183e-01f,
  1.05813019e-01f, 5.97528853e-02f, 2.80732661e-01f, 1.14815705e-01f, -6.72068447e-02f, 8.89697298e-02f, 1.96544871e-01f, -3.31200182e-01f, -1.53849378e-01f, 2.32253730e-01f,
  -3.26288491e-02f, 1.38546243e-01f, 3.45844217e-02f, 1.06995311e-02f, 1.96360230e-01f, 3.84160019e-02f, 9.29060280e-02f, 4.26065661e-02f, -1.50689506e-03f, 1.79358870e-02f,
  1.74059510e-01f, 1.48251951e-01f, 1.82684943e-01f, 3.77244432e-03f, 7.33563751e-02f, -3.67667042e-02f, 1.52102202e-01f, 7.97045790e-03f, 2.30392590e-01f, 2.14628503e-01f,
  2.15161175e-01f, 1.53895050e-01f, -1.58317946e-02f, 3.20528969e-02f, -2.83991061e-02f, -8.20925310e-02f, 5.90476841e-02f, -8.73503238e-02f, 9.80225652e-02f, -1.48976699e-01f,
  -1.03855487e-02f, 3.15771461e-01f, -2.28957444e-01f, 1.24239735e-01f, -4.09534901e-01f, 3.85154068e-01f, 2.05585510e-01f, 2.04519108e-01f, 4.63854801e-03f, 1.90847561e-01f,
  9.48204994e-02f, -1.15721315e-01f, -1.67402908e-01f, -2.28997678e-01f, -2.46753171e-01f, -2.10402280e-01f, -3.88074577e-01f, 2.27171972e-01f, -2.36528993e-01f, -1.59122013e-02f,
  1.22248260e-02f, -2.98575252e-01f, 1.10071331e-01f, -1.88895196e-01f, -2.26321712e-01f, -2.07332987e-02f, 6.36721700e-02f, 4.44654711e-02f, -1.52150556e-01f, 2.78720349e-01f,
  2.59583920e-01f, -4.34458137e-01f, 3.98306817e-01f, -3.10158044e-01f, -2.32122064e-01f, -8.99025276e-02f, -1.13493137e-01f, 2.22401723e-01f, 9.72080156e-02f, 1.99699774e-01f,
  1.73731357e-01f, 2.25672647e-01f, 1.19622588e-01f, 1.41835004e-01f, 2.81334966e-01f, 6.89377114e-02f, 6.95562735e-02f, 2.08444402e-01f, 3.18857491e-01f, 1.60210416e-01f,
  5.78553565e-02f, 3.03164677e-04f, 1.65704489e-01f, 2.14279115e-01f, 2.66393244e-01f, 2.66028702e-01f, -1.52986208e-02f, 7.08489418e-02f, 4.56858054e-02f, 1.57090068e-01f,
  1.79336771e-01f, -4.27319743e-02f, 3.16430688e-01f, 3.28077048e-01f, 2.22149462e-01f, -5.03540993e-01f, -8.99991542e-02f, -2.60605484e-01f, -1.30955860e-01f, 2.64315993e-01f,
  8.90609697e-02f, 2.32770428e-01f, 2.21831188e-01f, 5.85075170e-02f, -1.70330212e-01f, -9.97819006e-03f, 5.20271659e-02f, 1.79472181e-03f, 5.05467772e-01f, 2.39493772e-01f,
  -2.34058902e-01f, -2.42722988e-01f, -2.20666565e-02f, -3.55240315e-01f, 6.86974674e-02f, 1.12798162e-01f, -9.39322338e-02f, 1.16816618e-01f, 1.12409085e-01f, -3.84681344e-01f,
  4.74600196e-01f, -8.17353055e-02f, -7.51396455e-03f, -2.20558494e-01f, 2.32520491e-01f, -5.03349043e-02f, -1.19138844e-01f, 4.24449891e-01f, 1.62500832e-02f, 2.17886090e-01f,
  2.89207101e-02f, 4.05223042e-01f, 1.47772387e-01f, 1.08816423e-01f, 1.26916364e-01f, 9.05329287e-02f, 7.53259882e-02f, 1.33462101e-01f, -6.54283464e-02f, 1.48697585e-01f,
  2.13336349e-01f, -1.10315420e-02f, -4.83931554e-03f, 2.27490947e-01f, 1.33239657e-01f, -2.22759414e-02f, -1.39632344e-01f, -1.04391938e-02f, 2.30540447e-02f, 5.28749079e-02f,
  1.03297114e-01f, 1.37424797e-01f, 8.07900727e-02f, -7.08303526e-02f, -1.38686180e-01f, 1.47151306e-01f, 3.91864106e-02f, -5.25543988e-02f, -3.69724408e-02f, 7.44589865e-02f,
  8.01864192e-02f, 1.97708178e-02f, 1.93935316e-02f, 1.12692647e-01f, 2.44193301e-02f, 1.59899563e-01f, -2.06576869e-01f, 5.27875684e-03f, -1.72973663e-01f, -2.69772083e-01f,
  2.10017875e-01f, 4.38515157e-01f, 1.09388217e-01f, -1.15129188e-01f, -2.58292556e-01f, 1.47717059e-01f, -2.71650195e-01f, 1.61777303e-01f, 7.19927251e-02f, -2.06130818e-02f,
  -2.57163346e-02f, -1.55455368e-02f, -1.01000048e-01f, -2.56574422e-01f, 1.11748733e-01f, 2.99551666e-01f, 6.81871325e-02f, -8.03981796e-02f, 9.30713639e-02f, -1.81728706e-01f,
  -5.87458968e-01f, 5.10574102e-01f, -2.02835843e-01f, 1.85369372e-01f, -1.52741134e-01f, 6.04998209e-02f, 2.12047637e-01f, 4.48498502e-02f, -1.97096560e-02f, 9.54278857e-02f,
  -2.72466928e-01f, 2.36403465e-01f, -3.09007009e-03f, 1.78804755e-01f, 1.84943620e-02f, 2.14955837e-01f, 2.19281048e-01f, 2.06775546e-01f, 1.10427946e-01f, 1.72575101e-01f,
  -2.46501118e-02f, 7.12820068e-02f, -3.45348299e-01f, 2.24986911e-01f, 1.42303165e-02f, 1.06113948e-01f, 1.25840575e-01f, 2.11762920e-01f, -8.91495720e-02f, 5.34536280e-02f,
  -4.53297868e-02f, 1.60122991e-01f, -6.63632900e-02f, 9.56200510e-02f, 3.70217115e-01f, 2.48164073e-01f, 1.38880804e-01f, -2.92834401e-01f, -2.07264274e-01f, -4.21215951e-01f,
  1.36959180e-01f, -1.59702405e-01f, -1.13894083e-01f, 1.59696624e-01f, 5.60003929e-02f, -2.63943076e-01f, 1.39977708e-01f, 4.76551980e-01f, 2.13306800e-01f, 2.02340528e-01f,
  2.12640211e-01f, 1.91613138e-01f, -1.08075105e-02f, 1.51304871e-01f, -8.98391828e-02f, -6.77004829e-03f, -7.61182755e-02f, 2.29031906e-01f, -8.00443888e-02f, -2.55802095e-01f,
  -2.23158732e-01f, 9.03122425e-02f, -6.62091980e-03f, 2.44875655e-01f, 9.64863077e-02f, 8.77460744e-03f, 3.38418484e-01f, -4.86488752e-02f, 6.05570525e-02f, -1.16295777e-01f,
  3.00846733e-02f, 1.12052426e-01f, 2.39819571e-01f, -3.62505764e-02f, 1.56622361e-02f, 1.39242738e-01f, 1.09189034e-01f, -2.27544066e-02f, 5.38187893e-03f, 6.29775673e-02f,
  1.27388299e-01f, 9.75110829e-02f, -1.11072317e-01f, 1.77790616e-02f, 2.53890425e-01f, 1.45212352e-01f, 1.50180265e-01f, 2.62763053e-01f, -6.91661239e-02f, -5.41519257e-04f,
  2.90795434e-02f, 1.18931130e-01f, 4.85362299e-02f, -2.37323046e-02f, 2.25866288e-01f, 1.16653383e-01f, -1.45893052e-01f, -6.30974248e-02f, -1.39960945e-01f, -1.49507612e-01f,
  -3.54884624e-01f, -2.12985024e-01f, -5.38054407e-02f, 3.01812351e-01f, 1.59216389e-01f, 4.99080479e-01f, -3.00550777e-02f, -1.18544959e-01f, -4.31997150e-01f, -2.88784895e-02f,
  -1.53524101e-01f, -3.37917536e-01f, -1.29993945e-01f, -2.92324293e-02f, 1.47413701e-01f, -1.47698864e-01f, -1.12954363e-01f, -2.94314772e-01f, -5.59506379e-02f, 4.19789925e-02f,
  -4.52232808e-02f, -3.27608198e-01f, 3.43938112e-01f, -3.01559925e-01f, -4.19019954e-03f, 2.16499135e-01f, 1.55425802e-01f, 5.99674284e-02f, 4.56778556e-01f, -9.09642354e-02f,
  8.49129856e-02f, 2.29844213e-01f, 3.84148598e-01f, 1.62629560e-01f, -6.87068403e-02f, 1.69017196e-01f, 2.12132603e-01f, 3.18472564e-01f, 1.11212201e-01f, 5.32640778e-02f,
  7.47677032e-03f, 8.25933460e-03f, -1.40486080e-02f, 6.46767393e-02f, 1.26351327e-01f, 1.74634442e-01f, -8.98186564e-02f, 9.46346596e-02f, 7.42249414e-02f, 2.93464009e-02f,
  1.52690396e-01f, 8.00519809e-02f, 2.40467831e-01f, 1.48960426e-01f, 1.34954512e-01f, 2.19836876e-01f, -7.79930651e-02f, 1.21577151e-01f, 1.16008416e-01f, -3.01313967e-01f,
  -1.60555065e-01f, 2.01424792e-01f, 2.03456320e-02f, -2.88621690e-02f, 1.13268137e-01f, -2.87508238e-02f, -1.60180762e-01f, -2.68959790e-01f, -2.56589968e-02f, 1.54481009e-01f,
  -9.64594930e-02f, 1.05148576e-01f, -1.65228799e-01f, -8.65378827e-02f, -1.38375282e-01f, -5.10237664e-02f, 1.36402220e-01f, -1.49971187e-01f, 1.92933321e-01f, 9.66467932e-02f,
  2.46698447e-02f, -1.06934849e-02f, -1.57930836e-01f, 2.65110880e-01f, 2.57721096e-01f, 2.12014824e-01f, -8.66329223e-02f, 6.54392764e-02f, 7.78087452e-02f, -2.28958324e-01f,
  -2.71757185e-01f, 1.99552283e-01f, 2.69360960e-01f, 3.06224406e-01f, 4.84895110e-01f, 1.37106955e-01f, 2.50841022e-01f, -2.79466897e-01f, 2.59363174e-01f, 1.81387812e-01f,
  2.29032543e-02f, -2.82594077e-02f, -6.92594200e-02f, 2.19593525e-01f, 2.39675250e-02f, 1.59773052e-01f, 1.36084706e-01f, 8.42390954e-02f, 9.53518040e-03f, 4.88106534e-02f,
  1.15581155e-01f, 3.63052227e-02f, -3.03071328e-02f, 8.49566907e-02f, 4.67193499e-02f, -7.01735690e-02f, 1.91915557e-01f, 9.22037810e-02f, 1.48123354e-01f, 2.22525019e-02f,
  -3.59911397e-02f, 1.84836179e-01f, 6.01409897e-02f, -7.23660132e-03f, -1.80420011e-01f, 1.77268475e-01f, -2.84819007e-01f, 1.12605765e-01f, -8.31319913e-02f, 1.14180945e-01f,
  1.71535596e-01f, 2.01613665e-01f, -1.29635677e-01f, -2.25397982e-02f, -1.50282420e-02f, -1.26352593e-01f, 8.59458838e-03f, 2.38833368e-01f, -2.11035851e-02f, -1.44327998e-01f,
  -3.00138313e-02f, 8.08652043e-02f, -9.86782089e-02f, 1.92320824e-01f, 1.23760059e-01f, -1.45645857e-01f, 1.00899659e-01f, -1.91111997e-01f, -6.49242774e-02f, -9.16795284e-02f,
  1.57328427e-01f, 2.28983641e-01f, -1.22415394e-01f, -1.15181424e-01f, 2.56587982e-01f, -2.10947216e-01f, -5.97791784e-02f, 4.17838693e-01f, 1.00988790e-01f, 2.49264225e-01f,
  1.46964282e-01f, 2.88941443e-01f, 3.15506846e-01f, 3.88446562e-02f, 2.09012302e-03f, 9.70863476e-02f, 8.12858641e-02f, -6.47707656e-02f, 4.16547917e-02f, 1.39444828e-01f,
  -1.95689932e-01f, 2.66762469e-02f, 1.78154349e-01f, 1.15341514e-01f, 1.96733594e-01f, 2.15507120e-01f, 2.51834691e-02f, 2.41404817e-01f, 8.28511044e-02f, 9.51733068e-02f,
  1.46433875e-01f, 4.94820029e-02f, -1.03873566e-01f, 1.21129677e-01f, 1.74526721e-01f, -7.44389817e-02f, 1.28271967e-01f, 2.95958966e-02f, -1.08423673e-01f, -1.55784145e-01f,
  -2.46721461e-01f, -1.10286839e-01f, 1.96192469e-02f, 2.07750469e-01f, 1.58154786e-01f, -8.99440572e-02f, 2.16678008e-02f, -2.46089205e-01f, 2.19797865e-01f, 2.97335908e-02f,
  -1.00259766e-01f, 3.07315290e-02f, 2.02957734e-01f, 2.72267051e-02f, -2.58259416e-01f, 5.47790155e-02f, -2.96834022e-01f, -1.49410024e-01f, 3.57783539e-03f, -2.08292268e-02f,
  2.10793793e-01f, -1.11538075e-01f, -2.81044729e-02f, 1.36478856e-01f, -2.75600385e-02f, -1.89160973e-01f, -1.65379927e-01f, 3.62347215e-01f, 1.31117985e-01f, -1.10122688e-01f,
  -2.11582258e-02f, 1.17256828e-01f, -1.48308843e-01f, 1.10267445e-01f, -8.05321783e-02f, 3.12033623e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.40684038e-01f, -8.37065056e-02f, 4.61871997e-02f, 8.41927975e-02f, -2.38392241e-02f, -2.66585965e-02f, 7.66553283e-02f, 7.88316280e-02f, 9.38610211e-02f, 1.41869843e-01f,
  2.59133101e-01f, 1.03330024e-01f, -6.84192590e-03f, 2.78481930e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  4.19035591e-02f, -1.64242610e-01f, -9.54745635e-02f, -3.64108421e-02f, -1.47016481e-01f, -1.97698865e-02f, -1.93313420e-01f, 2.17933014e-01f, 6.99212551e-02f, -2.23199185e-03f,
  -1.07017480e-01f, 6.46789968e-02f, 9.97414961e-02f, 4.52543981e-02f, 2.61213243e-01f, -5.25223278e-02f, -9.30286869e-02f, 1.20876595e-01f, -4.89060022e-02f, -1.54949442e-01f,
  1.67193785e-01f, 4.23875228e-02f, -1.10730715e-02f, 2.62578219e-01f, -3.10726240e-02f, 1.08481199e-01f, -1.14025861e-01f, -4.06735912e-02f, 3.75803513e-03f, -1.12130806e-01f,
  7.15162314e-04f, -1.33010997e-02f, 6.21611625e-02f, 1.90957367e-01f, -1.42042816e-01f, -1.52141768e-02f, 2.65488446e-01f, 1.73318446e-01f, 2.18015850e-01f, 3.80024463e-02f,
  1.18409293e-02f, 1.27051666e-01f, 1.18275546e-01f, -1.80982739e-01f, -2.06846654e-01f, 2.54827887e-01f, -2.25841507e-01f, 2.67241802e-02f, 1.91741347e-01f, 1.59159780e-01f,
  1.02356784e-01f, -1.21942684e-01f, -2.63630778e-01f, 3.95664908e-02f, -1.03386799e-02f, -4.94196899e-02f, -7.66032794e-03f, -2.32935205e-01f, 3.57304998e-02f, 1.65521607e-01f,
  -7.12229386e-02f, -6.12606518e-02f, -1.56280309e-01f, 4.46840748e-02f, 4.99294326e-02f, 4.72468697e-02f, -2.21433327e-01f, -1.54400058e-02f, 1.20811611e-02f, 8.41622651e-02f,
  1.86737865e-01f, 1.14579298e-01f, 8.52498785e-03f, 9.02560055e-02f, 1.98908955e-01f, -1.24037676e-02f, 7.39806071e-02f, -1.00999855e-01f, -6.27113134e-02f, -1.72233313e-01f,
  2.62580328e-02f, 1.13698564e-01f, 6.55550091e-03f, 1.07440419e-01f, 8.87190700e-02f, -1.00154132e-01f, 2.58298703e-02f, 3.23173180e-02f, 1.75303575e-02f, -4.99739833e-02f,
  2.86578666e-02f, -1.31773213e-02f, -7.50859976e-02f, -6.25484884e-02f, 2.18028113e-01f, -2.48859599e-02f, -1.84832737e-02f, -7.04186261e-02f, -1.85927413e-02f, -1.55972317e-02f,
  -5.33696450e-02f, -8.68207887e-02f, -1.90321788e-01f, -1.61001191e-01f, 8.35913867e-02f, 1.89701393e-01f, -3.73936333e-02f, -2.28523403e-01f, 9.59823728e-02f, -1.53955698e-01f,
  -1.38940707e-01f, 2.61732310e-01f, -1.57018319e-01f, 4.93922494e-02f, -3.14652734e-02f, 1.00142002e-01f, -7.12591559e-02f, -9.81367379e-02f, 7.74332434e-02f, -9.37839374e-02f,
  1.08807825e-01f, 2.32643187e-01f, 8.27561170e-02f, 2.84633059e-02f, -4.66735475e-02f, -2.99353570e-01f, 1.40071914e-01f, 1.75380766e-01f, -2.25136597e-02f, -2.84628838e-01f,
  -1.12817585e-01f, -1.29477724e-01f, 1.35397360e-01f, -2.87867766e-02f, 8.61153007e-02f, -8.38388354e-02f, -2.79232711e-01f, 2.65532848e-03f, 3.20050210e-01f, 2.22595520e-02f,
  -1.42507255e-01f, -1.06097639e-01f, -2.99188364e-02f, 2.53430068e-01f, -3.49194519e-02f, -4.58866917e-02f, -3.22166383e-02f, -2.21662913e-02f, -7.77879134e-02f, -1.16042390e-01f,
  1.76821783e-01f, -1.21857226e-01f, 1.18886501e-01f, 1.38021288e-02f, -2.37456739e-01f, 1.47087961e-01f, -7.83369839e-02f, -1.30241469e-01f, -4.94824983e-02f, 2.32718855e-01f,
  -3.62722315e-02f, -6.17037527e-02f, -9.99314189e-02f, 1.00559123e-01f, 1.30412757e-01f, -5.40245548e-02f, 1.33966118e-01f, 2.37740651e-02f, -8.65484253e-02f, 1.00424103e-01f,
  2.15884537e-01f, -2.00657114e-01f, -1.74216256e-01f, 1.29993990e-01f, -9.83172804e-02f, 3.67105603e-01f, -1.16793543e-01f, -4.71896604e-02f, -1.34059399e-01f, 1.24190249e-01f,
  6.43171296e-02f, 1.24647237e-01f, 2.24876463e-01f, 1.01661965e-01f, 3.81475762e-02f, -5.11763357e-02f, -5.60857430e-02f, -1.45569742e-01f, -1.44438446e-01f, -1.00311071e-01f,
  -9.13622379e-02f, 2.05931395e-01f, -1.86712649e-02f, 2.17303276e-01f, -1.03826247e-01f, -2.59830028e-01f, -1.76671203e-02f, 6.54798979e-03f, 1.97590858e-01f, -4.40617390e-02f,
  2.76823580e-01f, 8.33120942e-03f, -1.81173474e-01f, -7.35214818e-03f, -1.80682942e-01f, -4.41062115e-02f, 2.95591563e-01f, -1.35495320e-01f, -1.50234863e-01f, 7.51257781e-03f,
  5.44332303e-02f, -2.13331327e-01f, 1.89799786e-01f, -1.78539097e-01f, -7.88973793e-02f, -3.45134959e-02f, -7.89700449e-02f, -1.00539863e-01f, -3.17121372e-02f, -6.91866204e-02f,
  -2.11675093e-02f, 5.73271550e-02f, 2.00348139e-01f, -5.21526821e-02f, -2.25949869e-01f, -8.44176784e-02f, 4.85878587e-02f, 2.07386374e-01f, 7.13215172e-02f, -1.73509762e-01f,
  1.17376760e-01f, -4.18466367e-02f, 2.18565926e-01f, -9.71296728e-02f, 1.71378747e-01f, -2.54812956e-01f, 1.00783683e-01f, 2.24106200e-02f, -8.42750221e-02f, -1.67891130e-01f,
  2.28001520e-01f, 1.15487920e-02f, 1.42538399e-01f, -1.41926080e-01f, -1.05794050e-01f, 5.41624948e-02f, -9.69740003e-02f, -2.18445078e-01f, -1.42494798e-01f, -2.08879095e-02f,
  2.30453480e-02f, 3.16168368e-01f, -2.19158426e-01f, 1.64007187e-01f, -6.05079494e-02f, -5.11702150e-02f, 9.76733281e-04f, 1.72907293e-01f, -9.27711949e-02f, 1.89275891e-01f,
  -2.29272693e-01f, -7.93319792e-02f, -9.31978896e-02f, -1.02736704e-01f, 1.79090410e-01f, 3.23041342e-02f, -8.53387043e-02f, 3.44764590e-02f, 1.73496261e-01f, -2.45811772e-02f,
  4.26987052e-01f, 3.99411358e-02f, 1.11119519e-03f, 1.92352116e-01f, -2.19820696e-03f, -1.43389463e-01f, 2.99461074e-02f, 9.62252691e-02f, 9.22862366e-02f, 1.17951654e-01f,
  1.15163133e-01f, 8.32385570e-02f, -1.00863002e-01f, -4.99766767e-02f, 5.82164861e-02f, 2.66884387e-01f, -1.25804007e-01f, 2.27635011e-01f, 1.79047808e-01f, 8.62498656e-02f,
  -1.43120037e-02f, -3.11034650e-01f, -2.56463587e-01f, 1.76996619e-01f, 2.75315102e-02f, 1.93055019e-01f, 1.78034559e-01f, 3.87465879e-02f, -2.10631296e-01f, -2.48346835e-01f,
  4.44422029e-02f, -1.45074636e-01f, -1.45905823e-01f, 1.86426073e-01f, 2.42502972e-01f, 1.53024346e-01f, 1.72852069e-01f, -1.86655372e-01f, -7.51683265e-02f, 2.48332620e-02f,
  -7.84583390e-02f, -7.93122277e-02f, 1.38419822e-01f, -1.93138063e-01f, 2.16710512e-02f, 1.76380306e-01f, -1.52238384e-01f, -8.44157413e-02f, 3.49657089e-02f, 1.24291545e-02f,
  -1.42392352e-01f, -1.84758335e-01f, -6.23436086e-02f, -1.85925737e-02f, 7.09620565e-02f, 1.48460731e-01f, 1.00200318e-01f, 3.65098901e-02f, -7.00643985e-03f, 1.85285788e-02f,
  7.04726530e-03f, -1.00177802e-01f, 1.78001784e-02f, -1.20956980e-01f, -9.08443555e-02f, 2.54586309e-01f, -1.56717747e-01f, -2.24476948e-01f, 6.97701722e-02f, 1.61503568e-01f,
  1.27886489e-01f, -1.90665219e-02f, 1.02641210e-01f, 4.13544700e-02f, 2.04865009e-01f, -1.76504448e-01f, 9.68142524e-02f, 7.48675913e-02f, 1.10405624e-01f, 5.92028461e-02f,
  -3.01851064e-01f, 1.55991644e-01f, 5.62477857e-02f, 2.10543066e-01f, -8.05836767e-02f, -3.05661470e-01f, 3.79188478e-01f, 2.40720868e-01f, -2.34761640e-01f, 6.16899393e-02f,
  -1.09685682e-01f, 3.29300761e-01f, 4.01352122e-02f, -1.09005317e-01f, -1.22283176e-01f, 1.76402926e-01f, 8.41737390e-02f, 2.51578122e-01f, 6.36711493e-02f, -1.85213268e-01f,
  -2.75526289e-02f, -1.13944687e-01f, -1.24138579e-01f, 9.65166464e-02f, -8.79170671e-02f, 6.44333512e-02f, 1.60916626e-01f, -9.21203494e-02f, -1.63297564e-01f, -2.43093856e-02f,
  -2.92901341e-02f, -1.25835270e-01f, -3.62320384e-03f, 2.01407745e-01f, -2.79187173e-01f, 5.13616875e-02f, 2.47553617e-01f, -7.03503042e-02f, 5.22844374e-01f, -2.06460562e-02f,
  2.77053893e-01f, -9.82832909e-02f, 1.06420100e-01f, -1.99768804e-02f, 1.55712619e-01f, -1.40776619e-01f, -1.58688217e-01f, -8.71196389e-02f, -2.05282554e-01f, -2.75232464e-01f,
  -8.64978433e-02f, -2.46860478e-02f, 1.02348700e-01f, -1.08902775e-01f, 1.85131669e-01f, 4.65858281e-02f, 4.84378748e-02f, 1.39099434e-01f, -9.24816728e-02f, -2.45289370e-01f,
  -2.30466686e-02f, 2.26914823e-01f, 9.31155495e-03f, 3.43349129e-01f, 1.44458011e-01f, 5.00998497e-02f, -3.28109354e-01f, -8.37521255e-02f, 5.34740016e-02f, 1.30768707e-02f,
  -1.82713076e-01f, -7.30940141e-03f, -1.14107728e-01f, 6.49948791e-02f, 1.67765543e-01f, -8.88273194e-02f, 1.80281520e-01f, 1.83077022e-01f, 1.98170781e-01f, 4.01327424e-02f,
  9.71791372e-02f, -2.62842417e-01f, -1.25566289e-01f, -3.84613313e-02f, -1.04863770e-01f, 6.42250245e-03f, 4.65498604e-02f, 1.79307699e-01f, -9.79150534e-02f, -1.77810923e-03f,
  -2.10369527e-01f, 3.66535932e-02f, -1.05124243e-01f, -1.48037091e-01f, -2.07256138e-01f, 1.58830304e-02f, -1.03784390e-01f, -1.12696514e-01f, 8.05398542e-03f, 2.41745949e-01f,
  3.56742442e-02f, -2.31543213e-01f, -3.47987324e-01f, 2.28116840e-01f, 1.35816503e-02f, -5.21438792e-02f, 2.54115045e-01f, 4.14655879e-02f, 1.01957440e-01f, 7.06479102e-02f,
  -1.76187244e-03f, -3.67582291e-02f, 2.47472271e-01f, 5.17894849e-02f, -7.15552494e-02f, 1.57636702e-02f, 5.15520051e-02f, 2.09649652e-01f, 1.48334913e-03f, -7.76807889e-02f,
  -1.26304492e-01f, -2.39170134e-01f, -1.30661339e-01f, -3.52174714e-02f, -1.28002226e-01f, -1.15291469e-01f, -1.73423663e-02f, 8.40018392e-02f, -7.88932815e-02f, 1.85477003e-01f,
  1.46514073e-01f, -2.04014331e-01f, 7.04003870e-02f, 1.56439707e-01f, -2.02607155e-01f, -6.64904267e-02f, 1.29572511e-01f, 1.52166069e-01f, -1.95068702e-01f, -3.85212451e-02f,
  1.32457241e-01f, 7.52211735e-02f, -1.23975798e-03f, -4.47814353e-02f, -1.60655797e-01f, -2.46685848e-01f, 5.75575158e-02f, 1.01228077e-02f, 1.64449677e-01f, 4.93061952e-02f,
  2.00517684e-01f, -8.97813588e-02f, -8.02546088e-03f, 9.95168611e-02f, -2.03600958e-01f, -3.47667374e-02f, 2.70388573e-01f, 1.34227365e-01f, -2.45804757e-01f, 2.28457317e-01f,
  -3.43479798e-04f, -1.37638181e-01f, -1.78043798e-01f, 8.81342031e-03f, 2.11546928e-01f, 1.44711405e-01f, 3.35833102e-01f, 1.66283280e-01f, 6.76919818e-02f, 1.88415498e-02f,
  4.42140212e-04f, -6.61066398e-02f, 2.58264560e-02f, 1.47413298e-01f, -1.19950131e-01f, 3.84576060e-02f, 2.44214702e-02f, 2.41384089e-01f, -2.57157662e-04f, -7.72716627e-02f,
  8.84483680e-02f, 9.27902907e-02f, -9.73794013e-02f, 5.62549569e-02f, -1.24905698e-01f, 2.83707436e-02f, 2.02370718e-01f, -7.81043991e-02f, -5.73526993e-02f, 1.97984055e-01f,
  1.00094371e-01f, -1.42956391e-01f, -4.22509983e-02f, -2.21566986e-02f, -8.06767121e-02f, -3.31838608e-01f, 2.85589665e-01f, 2.16908365e-01f, 1.13893747e-01f, 1.33555429e-03f,
  -8.00507143e-02f, -1.80164754e-01f, -5.55138551e-02f, -3.24147977e-02f, -1.83889613e-01f, 3.22847486e-01f, 1.79294661e-01f, -1.14278130e-01f, 2.29758486e-01f, -1.06212422e-01f,
  -8.86810198e-02f, -2.61133075e-01f, -2.61000782e-01f, -1.09216757e-01f, 4.11779657e-02f, 1.39764413e-01f, -2.19866112e-01f, -1.40507758e-01f, 1.16823658e-01f, 1.93309754e-01f,
  -3.44845653e-01f, -1.76601365e-01f, 1.60085827e-01f, 8.22572783e-03f, -1.10214964e-01f, 1.50358140e-01f, -1.85569718e-01f, -9.99466181e-02f, 5.10230772e-02f, -3.00565869e-01f,
  -8.28243345e-02f, 9.01917294e-02f, -2.64274567e-01f, -5.27493656e-02f, -4.03022859e-04f, -5.00357971e-02f, -1.15168191e-01f, -9.13073048e-02f, -1.31099895e-01f, -8.29280540e-02f,
  3.54153067e-02f, 2.13181093e-01f, -3.06969732e-01f, 7.98480585e-03f, -2.52511092e-02f, -2.81302899e-01f, 5.33737354e-02f, 1.30996360e-02f, -5.25337085e-02f, -1.52173325e-01f,
  -7.02426443e-03f, 5.55038154e-02f, -9.56303731e-04f, 2.93370783e-02f, 1.53906168e-02f, -9.01939571e-02f, 1.11366898e-01f, -2.69415919e-02f, -1.56244680e-01f, 1.12853795e-01f,
  -3.42678605e-03f, 3.99367392e-01f, 1.10990293e-01f, 4.38998826e-02f, 1.05613790e-01f, 1.49945214e-01f, -2.91775744e-02f, 1.37841508e-01f, 1.00122795e-01f, 8.84807631e-02f,
  -5.88786565e-02f, 1.44530445e-01f, -1.00049436e-01f, 3.07444837e-02f, 1.83844194e-01f, -2.12691978e-01f, 9.36300755e-02f, -3.31477448e-02f, 8.90622735e-02f, 1.51663065e-01f,
  -7.94139206e-02f, 1.64872482e-01f, -1.23693094e-01f, -2.30114430e-01f, -4.07824107e-02f, 2.32230965e-02f, -7.87693858e-02f, 1.59226641e-01f, -2.18585908e-01f, -2.64738888e-01f,
  -1.03215240e-01f, -1.80614412e-01f, -2.97515094e-01f, 4.89479862e-02f, -2.73404866e-01f, 7.84159303e-02f, -1.94378316e-01f, 1.39723301e-01f, 3.34668346e-02f, 2.69433945e-01f,
  8.40271562e-02f, -2.84645427e-02f, 3.51010785e-02f, -1.18094742e-01f, -1.00193314e-01f, -1.64251123e-02f, 7.81273246e-02f, -1.59996748e-02f, 4.40101475e-02f, 9.88173932e-02f,
  -2.04306245e-01f, 9.56250057e-02f, 5.94421523e-03f, -6.08231388e-02f, -6.49455413e-02f, 1.41905606e-01f, -1.48862645e-01f, -1.41084075e-01f, -1.08947262e-01f, -1.01619296e-01f,
  2.41246540e-02f, -6.29267395e-02f, 2.35386908e-01f, 1.74149463e-03f, -2.19925195e-01f, 6.97376058e-02f, -1.06766559e-01f, 1.25431851e-01f, 6.68290481e-02f, 1.40099123e-01f,
  5.41272648e-02f, 2.15337679e-01f, -6.72840513e-03f, -3.00099343e-01f, -1.52259484e-01f, 8.93817171e-02f, -3.76479387e-01f, 2.01099589e-02f, -2.11070180e-01f, -4.48629893e-02f,
  4.67969738e-02f, 1.29045382e-01f, 1.68985575e-01f, 6.34480268e-02f, 2.74472922e-01f, 1.32759273e-01f, -1.08549178e-01f, -6.28867745e-02f, 8.54708478e-02f, 7.12633431e-02f,
  -1.64174110e-01f, -1.71925202e-01f, 2.07045097e-02f, 1.92092743e-03f, -1.07196800e-01f, -1.45333111e-01f, -1.19873598e-01f, 6.79701716e-02f, 8.32191408e-02f, -2.09491342e-01f,
  1.78382099e-01f, -3.30527604e-01f, 2.45158598e-02f, -9.00493041e-02f, -4.54483107e-02f, -2.62141645e-01f, 6.83354437e-02f, -8.31089467e-02f, -2.77421549e-02f, -2.63552610e-02f,
  1.10461891e-01f, 1.61732018e-01f, 8.50639865e-02f, -2.90423376e-03f, -6.87008202e-02f, -3.65045853e-02f, -2.50838976e-02f, -7.56826773e-02f, 1.96155131e-01f, 5.88125363e-03f,
  6.31207526e-02f, -1.16203889e-01f, -6.75108135e-02f, -1.49226978e-01f, -1.96096107e-01f, -5.32894880e-02f, -1.17877014e-01f, -1.04353301e-01f, -1.10740684e-01f, -7.24693909e-02f,
  3.37866753e-01f, 1.17975669e-02f, -3.74588147e-02f, -3.43424290e-01f, -5.73115386e-02f, -1.62509248e-01f, -1.34509653e-01f, 1.11119218e-01f, -1.72357023e-01f, -2.59346999e-02f,
  1.62003487e-01f, 1.58630937e-01f, -1.49521574e-01f, -8.33186880e-02f, -1.40042782e-01f, 2.31090352e-01f, -1.58781171e-01f, 7.05070496e-02f, 1.52440861e-01f, -1.06378809e-01f,
  6.37726784e-02f, -3.86642925e-02f, -8.31230208e-02f, -1.81724787e-01f, 1.10887125e-01f, -1.93506107e-01f, 2.39597503e-02f, 9.16936472e-02f, -8.50890279e-02f, -1.77299991e-01f,
  7.18805790e-02f, 2.68073808e-02f, 7.57577345e-02f, -2.22948179e-01f, -5.47419861e-02f, 2.32188985e-01f, 1.33181527e-01f, 1.67573482e-01f, 1.48196891e-01f, -7.76496604e-02f,
  1.52783617e-01f, 1.03253596e-01f, -1.38503179e-01f, 7.37145767e-02f, -2.53194403e-02f, -1.05881896e-02f, 2.87634227e-02f, -3.05070095e-02f, 1.69814572e-01f, 1.20442562e-01f,
  1.07373424e-01f, 2.12845847e-01f, 5.56835271e-02f, 1.10083297e-01f, 5.89000285e-02f, 1.47827985e-02f, -2.30883345e-01f, 1.74892902e-01f, 1.32878989e-01f, -1.13095544e-01f,
  -1.33226886e-01f, 8.60957429e-03f, 1.19668350e-01f, -1.41720816e-01f, -7.27597475e-02f, -1.50230199e-01f, 3.86150833e-03f, 1.42707393e-01f, 4.35381792e-02f, -9.26517844e-02f,
  -1.20988272e-01f, 1.50577754e-01f, -2.77748685e-02f, -4.23557386e-02f, -3.17043453e-01f, 3.96702103e-02f, -2.91476965e-01f, -1.31617188e-02f, 3.27171036e-03f, -2.59874642e-01f,
  -1.25623673e-01f, -8.27960297e-02f, 1.39062228e-02f, -1.67907864e-01f, 5.64188100e-02f, 2.62493461e-01f, -2.55646288e-01f, 1.04911290e-02f, 1.93209648e-01f, -2.11873621e-01f,
  9.08359215e-02f, -1.32656455e-01f, 8.12200829e-02f, 1.62140250e-01f, 8.72369111e-02f, -1.25381872e-01f, 1.11839332e-01f, -5.18103689e-02f, 6.31601587e-02f, -1.09113239e-01f,
  -2.98862867e-02f, -4.02440280e-02f, -6.07686751e-02f, -3.84917222e-02f, -9.14896131e-02f, 2.24021554e-01f, 1.13304473e-01f, 3.58648598e-02f, -5.32694720e-03f, -1.11086711e-01f,
  -6.42292798e-02f, -9.26895514e-02f, 5.90822026e-02f, 7.17016906e-02f, 9.95668173e-02f, 1.24773365e-02f, -5.52438423e-02f, -1.74859911e-01f, 3.57598402e-02f, -3.73732932e-02f,
  3.11946958e-01f, -2.01872692e-01f, 7.70194679e-02f, -3.90301384e-02f, 9.29931775e-02f, 1.00550838e-01f, 1.75039336e-01f, 4.85823810e-01f, -1.32537067e-01f, -3.22593525e-02f,
  -2.44851056e-02f, 1.07655518e-01f, 5.86330034e-02f, 1.13914378e-01f, 1.41758308e-01f, -2.29874089e-01f, -1.51283375e-03f, 2.63856910e-03f, 1.62315860e-01f, 1.13268746e-02f,
  1.28910080e-01f, -6.95777312e-02f, -1.81850329e-01f, 4.17113565e-02f, -1.78714450e-02f, -8.00665617e-02f, -1.33288816e-01f, -1.60094023e-01f, 9.28400457e-02f, -2.10843459e-01f,
  3.23811248e-02f, -1.41279951e-01f, -4.96779159e-02f, 1.94388479e-01f, 1.07267566e-01f, -2.87097264e-02f, -4.75062095e-02f, 1.04507513e-01f, -7.91164264e-02f, 8.82177576e-02f,
  3.74996886e-02f, -2.39565417e-01f, 1.36512563e-01f, -1.01586923e-01f, -5.51906191e-02f, 3.56811769e-02f, 1.14043504e-01f, -1.13715734e-02f, -4.02678698e-02f, 2.46098489e-01f,
  -7.72432378e-03f, 3.10774464e-02f, 4.98509362e-05f, 9.66432542e-02f, 1.02541357e-01f, -6.46380633e-02f, 2.72453338e-01f, 6.16030842e-02f, 7.34870806e-02f, 1.94391310e-01f,
  1.32386133e-01f, -2.77329773e-01f, 7.63945878e-02f, -5.29862903e-02f, -8.57671276e-02f, 6.22935712e-01f, -1.04060121e-01f, 2.16263041e-01f, -4.34604846e-02f, 1.95111960e-01f,
  -2.39883170e-01f, -4.41667765e-01f, 7.79905096e-02f, 1.13174319e-01f, -1.10907376e-01f, -8.73159245e-02f, 2.19562545e-01f, -2.44132541e-02f, 6.54250085e-02f, -9.33356732e-02f,
  -1.13262042e-01f, 9.19179469e-02f, -5.55426665e-02f, 1.18103236e-01f, 1.34079710e-01f, 3.29451710e-02f, 8.50351900e-02f, -1.66688979e-01f, -1.12186514e-01f, 1.11277655e-01f,
  -1.35543928e-01f, -7.16081113e-02f, 1.59621432e-01f, -6.48471341e-02f, -1.37735918e-01f, 1.09775193e-01f, -1.44304916e-01f, -1.05639465e-01f, 5.31970933e-02f, -4.37744595e-02f,
  -1.02732806e-02f, -9.44292247e-02f, -8.79223552e-03f, 3.86335552e-02f, 1.78471029e-01f, 1.75421275e-02f, 5.65594211e-02f, 3.02760787e-02f, 7.41601065e-02f, -5.08035719e-02f,
  -2.51701057e-01f, 2.21127514e-02f, 1.10634714e-01f, 1.90063685e-01f, -1.17317043e-01f, -2.75498211e-01f, 9.44557507e-03f, 4.90411967e-02f, -1.19896732e-01f, -2.03710839e-01f,
  1.44961864e-01f, 2.42398549e-02f, 2.54586160e-01f, 4.71526198e-02f, -2.16568321e-01f, -1.55968055e-01f, 8.89086351e-02f, 5.96033894e-02f, -7.24017248e-02f, 2.99817830e-01f,
  1.78991690e-01f, -1.39704272e-01f, -1.03013158e-01f, -1.18294105e-01f, 1.25398263e-01f, -8.74246657e-02f, -2.30796695e-01f, -2.58578926e-01f, 6.31391406e-02f, 6.55763745e-02f,
  2.51571149e-01f, 2.19767876e-02f, -1.58988521e-01f, 1.46021158e-03f, 9.58941951e-02f, 3.39788967e-03f, -2.54688468e-02f, -2.21556678e-01f, -1.69479772e-01f, 1.47516549e-01f,
  -1.31642684e-01f, 1.55340150e-01f, 2.39630826e-02f, -2.06862032e-01f, 9.07314867e-02f, 1.07124843e-01f, -2.61282623e-01f, 1.47189479e-02f, 1.17898166e-01f, -1.11988977e-01f,
  4.61745523e-02f, 1.27131417e-01f, -1.60115853e-01f, -2.00281769e-01f, -7.41913244e-02f, 1.01666942e-01f, 1.59139663e-01f, 1.46596758e-02f, -1.69293419e-01f, 1.32801130e-01f,
  -1.25537679e-01f, 6.41974956e-02f, 1.96956426e-01f, -7.98933953e-02f, -1.20173573e-01f, -1.28176108e-01f, -7.53439963e-02f, -8.74908119e-02f, -2.62466129e-02f, -1.85936108e-01f,
  1.17864333e-01f, 4.12745923e-02f, -8.63748267e-02f, -7.91154131e-02f, -4.60680760e-02f, 1.55682310e-01f, 9.47554410e-02f, -3.85590866e-02f, -8.65711048e-02f, 1.19266711e-01f,
  -2.97396947e-02f, 1.65400192e-01f, 8.54143649e-02f, -3.94932002e-01f, 6.44452795e-02f, -1.42966807e-01f, 1.96400579e-04f, -2.45928600e-01f, 3.79862517e-01f, 3.44189465e-01f,
  -2.37757608e-01f, 3.65849994e-02f, 8.47294405e-02f, -4.93138246e-02f, 1.08906016e-01f, -7.32873902e-02f, -8.02684352e-02f, 6.84380680e-02f, 6.27304912e-02f, -1.51535064e-01f,
  8.27796310e-02f, -3.52056175e-01f, -9.09254774e-02f, 2.14775782e-02f, -1.68453395e-01f, 2.90828831e-02f, 1.83952034e-01f, -1.90242290e-01f, 9.89779904e-02f, 1.39981762e-01f,
  -2.21571580e-01f, 1.53449895e-02f, 1.37065634e-01f, -4.44466667e-03f, 3.23086395e-03f, 2.40523800e-01f, 4.52856533e-02f, 8.12731311e-03f, -2.02600330e-01f, -1.32863402e-01f,
  1.10387057e-01f, 2.56841987e-01f, -1.40501633e-01f, 5.55563457e-02f, -2.94265263e-02f, -7.69696608e-02f, -6.57634810e-02f, 1.88118502e-01f, -9.56764296e-02f, 1.43826187e-01f,
  1.94653258e-01f, -1.21843867e-01f, -2.49437749e-01f, 2.35922754e-01f, 1.12676032e-01f, -3.80182900e-02f, 1.40066341e-01f, 1.43292308e-01f, 4.88874093e-02f, 1.41839981e-01f,
  8.56484920e-02f, 6.84933439e-02f, 1.09497979e-01f, 1.78820882e-02f, -1.59077823e-01f, 2.78091311e-01f, -2.13565260e-01f, -2.17406824e-02f, -3.35287064e-01f, -4.41209301e-02f,
  1.27472103e-01f, -1.06578320e-01f, 3.80357616e-02f, -2.14421377e-01f, -8.80991742e-02f, 4.96131741e-02f, -4.86902893e-02f, 1.36630997e-01f, -2.63371412e-02f, -5.72885461e-02f,
  -2.84340978e-01f, 3.45151454e-01f, -2.33845606e-01f, -1.05163805e-01f, -1.42829139e-02f, -7.83168245e-03f, -1.51909158e-01f, -1.39867902e-01f, -7.33648911e-02f, 1.14103325e-01f,
  1.77922800e-01f, 5.25409579e-02f, -3.17060240e-02f, 1.12568460e-01f, -9.26147327e-02f, 2.14639992e-01f, -1.35216221e-01f, -3.38355720e-01f, 1.82282314e-01f, 5.36791161e-02f,
  -1.88599899e-01f, -2.88189203e-02f, 2.55493593e-04f, -1.41021386e-01f, -7.73270102e-03f, -1.12281345e-01f, 1.52854040e-01f, -1.18356291e-02f, -2.12480664e-01f, -5.64041473e-02f,
  -3.73373657e-01f, -2.41168112e-01f, 1.02970973e-01f, -1.64356574e-01f, -8.29461813e-02f, 7.04119634e-03f, -1.03816956e-01f, -4.25014552e-03f, -8.73425081e-02f, 1.13016471e-01f,
  7.26567640e-04f, 2.83695273e-02f, -4.01393831e-01f, 1.39824376e-02f, -8.93470421e-02f, -1.59364700e-01f, 2.05475166e-02f, 2.56332010e-01f, 1.30824685e-01f, -1.85940862e-01f,
  3.29848304e-02f, -1.99502468e-01f, -1.88517630e-01f, -1.64930969e-01f, 3.23224872e-01f, 1.12470619e-01f, -1.03520818e-01f, -3.66689898e-02f, 2.46296972e-01f, 7.60028809e-02f,
  -5.88875376e-02f, 3.10043097e-02f, -1.62281826e-01f, 1.32520869e-01f, 1.89690650e-01f, 3.14827450e-02f, -5.34974821e-02f, 1.01783887e-01f, -4.22590002e-02f, 1.22611210e-01f,
  -1.42965674e-01f, -1.31115600e-01f, -2.63763051e-02f, -2.21908763e-02f, -1.01350062e-01f, 1.51996329e-01f, -3.44202407e-02f, 1.05694659e-01f, 1.17572732e-01f, 4.72497754e-02f,
  2.46414840e-02f, -1.63886130e-01f, 1.79460440e-02f, -1.42359912e-01f, 2.30618775e-01f, 1.50678039e-01f, 3.14718299e-02f, -3.78006063e-02f, 2.00191662e-01f, 1.33700013e-01f,
  4.50231075e-01f, -4.02877666e-02f, 1.44144833e-01f, 8.71047080e-02f, 4.28108610e-02f, -1.75233111e-02f, 2.83200324e-01f, -2.48719510e-02f, 1.10047288e-01f, 8.90656263e-02f,
  -2.69292802e-01f, -1.22981286e-02f, 5.97729301e-03f, -1.17376819e-01f, 1.08656794e-01f, 2.58464754e-01f, -3.29612643e-02f, 1.05011500e-01f, 2.03565344e-01f, 1.47582233e-01f,
  -8.77459943e-02f, -3.64551693e-01f, -1.16295725e-01f, 2.95644611e-01f, 7.03982124e-03f, 2.08101332e-01f, -8.42804760e-02f, 3.23388845e-01f, -2.14898825e-01f, -3.71683501e-02f,
  -1.44965183e-02f, 3.24867480e-02f, 1.16098173e-01f, -7.48840794e-02f, -2.56742090e-01f, -3.61729860e-02f, -7.38483891e-02f, 7.44226500e-02f, -3.54882516e-02f, 6.70422167e-02f,
  -8.16515982e-02f, -5.85028492e-02f, 1.39876857e-01f, -1.53294921e-01f, -2.42254794e-01f, -2.53952384e-01f, -2.20001608e-01f, 9.61968303e-02f, 1.33413553e-01f, 1.64300397e-01f,
  -5.79540171e-02f, 7.13738129e-02f, 1.56781808e-01f, 4.37607430e-02f, -3.25597711e-02f, -1.77771524e-01f, -7.83641040e-02f, -7.22571984e-02f, 2.73461286e-02f, 1.00499511e-01f,
  -1.22695491e-01f, -1.38238706e-02f, 1.19584076e-01f, 1.96079865e-01f, 2.75206883e-02f, -8.11559707e-02f, 1.59120306e-01f, -3.30587268e-01f, 2.35709518e-01f, 8.38452354e-02f,
  1.91305920e-01f, -1.58065557e-01f, 1.44736022e-01f, -1.28967930e-02f, 7.64901266e-02f, -7.36535117e-02f, 1.01187438e-01f, 1.58663064e-01f, -9.46747959e-02f, -1.80795938e-01f,
  3.42442130e-04f, 8.64668041e-02f, 7.02760220e-02f, 1.24310881e-01f, -1.60147801e-01f, -1.58394933e-01f, 3.77992280e-02f, 1.26829162e-01f, -2.91689903e-01f, 2.13658273e-01f,
  2.76751798e-02f, -4.08319244e-03f, -4.78138700e-02f, -9.09115002e-02f, -1.99928023e-02f, -9.21455994e-02f, -2.74842709e-01f, -2.13631943e-01f, -1.11898676e-01f, 3.37105319e-02f,
  1.72720537e-01f, -2.52015442e-01f, 5.36137586e-03f, 1.24216862e-01f, -1.03589691e-01f, 2.75264587e-02f, -4.06000055e-02f, -1.61687329e-01f, -2.13470712e-01f, 5.57199828e-02f,
  1.67615153e-02f, 1.21801933e-02f, 1.82433918e-01f, -1.68635801e-03f, -2.08288804e-02f, 4.35168929e-02f, -2.00066864e-01f, 2.09209740e-01f, -1.59676850e-01f, 9.93025117e-03f,
  -3.01446896e-02f, 9.13579315e-02f, -1.21019438e-01f, -2.16325715e-01f, 1.16355933e-01f, -1.02518179e-01f, -2.03841805e-01f, 1.14886805e-01f, 3.80137451e-02f, -7.23087564e-02f,
  -2.87927806e-01f, 7.60266036e-02f, -9.13033187e-02f, -3.62891257e-02f, -2.09114566e-01f, -1.24280132e-01f, -4.78653349e-02f, -2.95512099e-02f, -7.58590922e-02f, -1.98737666e-01f,
  7.69461244e-02f, 1.41627252e-01f, -1.02883644e-01f, -3.57553005e-01f, -1.18471317e-01f, 8.48491024e-03f, 5.25083020e-02f, 2.47223433e-02f, -1.31426498e-01f, 2.10677043e-01f,
  1.74797922e-01f, -1.67322487e-01f, -1.83992982e-01f, 9.88894925e-02f, 4.12741095e-01f, -3.25791419e-01f, 6.30908161e-02f, 7.45401159e-02f, -2.15776097e-02f, -1.67994633e-01f,
  -9.38984007e-02f, -3.81321795e-02f, 1.06872588e-01f, 1.48296252e-01f, 2.64187902e-01f, 9.85279679e-02f, 2.68580407e-01f, -7.94257298e-02f, -9.54386070e-02f, 1.20220393e-01f,
  -1.37590632e-01f, -7.13488180e-03f, -1.79296032e-01f, 8.77147019e-02f, -1.65371727e-02f, 3.51846591e-02f, -3.85675370e-03f, -8.68942067e-02f, 2.97849569e-02f, 6.50902465e-02f,
  -1.08276762e-01f, 2.18705181e-02f, 1.30891547e-01f, 1.15864210e-01f, 1.28279909e-01f, -5.92024997e-02f, -1.81416404e-02f, -1.25519186e-01f, -2.17829496e-02f, 3.97180021e-02f,
  -2.35285573e-02f, -1.64652064e-01f, 1.36106253e-01f, 2.34159261e-01f, 3.44168335e-01f, -4.64055389e-02f, 1.78775698e-01f, -1.21901453e-01f, 6.54202253e-02f, -3.42809930e-02f,
  -5.31778391e-03f, -2.37666383e-01f, 8.06186721e-02f, 1.15383945e-01f, -1.80119440e-01f, -2.00408325e-01f, 6.39428943e-02f, 2.72812754e-01f, -6.91856518e-02f, -7.21611306e-02f,
  2.01059971e-02f, -2.08972991e-02f, 1.68061286e-01f, 5.13618514e-02f, -1.82478949e-01f, -1.58783093e-01f, 2.05127820e-01f, -1.62950933e-01f, -1.47525340e-01f, -4.15171199e-02f,
  -8.75479430e-02f, 9.43925828e-02f, 5.94571270e-02f, 2.73781180e-01f, 9.13379192e-02f, 1.86596647e-01f, -1.09493226e-01f, 6.35150298e-02f, -1.31700179e-02f, 3.20268065e-01f,
  2.10906073e-01f, -1.40560508e-01f, -9.27486718e-02f, -2.04457387e-01f, 2.13008851e-01f, 1.22792520e-01f, -8.26131552e-02f, -1.20953441e-01f, -7.70473257e-02f, -1.93729848e-02f,
  1.05860839e-02f, 1.37492821e-01f, -2.13486388e-01f, -9.24788788e-02f, 1.26923367e-01f, -1.28086731e-01f, 1.80826589e-01f, -9.21371672e-03f, 3.61481160e-02f, -2.08506212e-01f,
  -7.59775117e-02f, 8.54253024e-02f, 9.79677513e-02f, -2.40557313e-01f, -1.56174600e-01f, 1.72399223e-01f, 1.19711012e-02f, 6.45943806e-02f, -2.50805318e-01f, 1.09756321e-01f,
  -1.27531543e-01f, -1.05600640e-01f, -1.30761936e-01f, -1.33988798e-01f, -7.05412701e-02f, -2.22639106e-02f, -2.82716334e-01f, -6.77737519e-02f, -1.48743272e-01f, 5.75008802e-02f,
  -2.94798076e-01f, -9.50996354e-02f, -5.66884689e-02f, -1.90480482e-02f, 1.86962500e-01f, 8.27495828e-02f, -3.18212092e-01f, 2.26033688e-01f, 1.15588596e-02f, -8.22393820e-02f,
  -2.18949884e-01f, 1.42954603e-01f, 4.32118326e-01f, -2.58187532e-01f, 2.10227475e-01f, 5.45083135e-02f, -9.97633785e-02f, -4.50496897e-02f, -1.06790118e-01f, -1.47627488e-01f,
  9.71655250e-02f, -8.17273557e-02f, 9.97343734e-02f, -1.84856094e-02f, 2.39367604e-01f, -5.12343049e-02f, 6.44091517e-02f, 7.67781660e-02f, -2.26316661e-01f, 6.39438331e-02f,
  -2.53437996e-01f, 2.32946888e-01f, -7.38926008e-02f, -5.85452914e-02f, 4.83391806e-02f, -4.02647071e-02f, 1.08516216e-01f, 3.92555743e-02f, -2.04635058e-02f, 1.05681203e-01f,
  -1.17909022e-01f, 1.64272830e-01f, 2.19253041e-02f, -9.37528834e-02f, 4.27782955e-03f, 5.60465045e-02f, 6.51315302e-02f, 2.28939876e-01f, -2.43099302e-01f, 2.18132436e-01f,
  1.26062751e-01f, -1.78989442e-03f, 5.87441139e-02f, 3.57185714e-02f, 1.16931692e-01f, 1.73980579e-01f, 5.23425117e-02f, -1.63912162e-01f, 5.02942391e-02f, 1.82198077e-01f,
  1.45958275e-01f, -2.83214054e-03f, -4.31181155e-02f, -3.53103578e-02f, 1.33858463e-02f, -2.15663370e-02f, 7.53554031e-02f, -5.35981543e-02f, 1.07420564e-01f, 1.56702384e-01f,
  1.41796349e-02f, -1.98299333e-01f, -3.20704654e-02f, -1.69798076e-01f, -1.53214812e-01f, 4.53257918e-01f, 1.25040323e-01f, -1.14914365e-02f, 7.87294209e-02f, 6.94178343e-02f,
  -4.47853915e-02f, -2.44040877e-01f, 1.13564149e-01f, 1.14337124e-01f, 8.65447447e-02f, -2.03056470e-01f, 1.65960923e-01f, 2.84227394e-02f, 1.28083304e-01f, -2.60895878e-01f,
  5.67113124e-02f, -3.64090502e-02f, -2.92853683e-01f, 9.62304883e-03f, 8.17754716e-02f, 5.25541566e-02f, -1.68586206e-02f, -1.80219132e-02f, 1.57724810e-03f, -4.40048873e-02f,
  1.45377442e-02f, -2.24276975e-01f, 1.87782824e-01f, -7.72962645e-02f, 6.19721413e-02f, 2.16221884e-01f, -1.76415965e-01f, -1.19337045e-01f, -1.48031190e-01f, 1.12923905e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -1.78437904e-01f, 1.40620366e-01f, 1.55543804e-01f, -6.95468038e-02f, -1.52235091e-01f, 8.25105533e-02f, 1.77131400e-01f, 1.00866698e-01f, 8.50766301e-02f, 1.21040858e-01f,
  8.93332660e-02f, 2.34133437e-01f, 2.93925013e-02f, 1.55623347e-01f, 1.02759264e-01f, 1.41264915e-01f, -1.17747292e-01f, 6.01537339e-03f, 1.28346696e-01f, 1.31456509e-01f,
  4.28131074e-01f, 3.34597677e-01f, 9.59222615e-02f, 2.07830876e-01f, 2.74078488e-01f, -2.37017170e-01f, -2.61018872e-01f, -4.97485362e-02f, 4.13046703e-02f, 5.08752406e-01f,
  -8.59067664e-02f, 2.06162021e-01f, -1.39706776e-01f, 2.14862302e-01f, -1.47444606e-01f, -2.14949608e-01f, 1.41811952e-01f, 7.86435530e-02f, 1.86433107e-01f, 3.51073205e-01f,
  1.39623433e-01f, -5.39642945e-02f, -4.30759303e-02f, 2.20035966e-02f, -2.05447376e-02f, 1.05912857e-01f, -1.59079701e-01f, -3.09924364e-01f, 4.29456264e-01f, 2.53927596e-02f,
  4.08558458e-01f, -2.15559527e-01f, -4.94725183e-02f, 2.09853053e-01f, -3.00938129e-01f, -7.05638006e-02f, -2.84086615e-01f, 7.51006454e-02f, -1.87686339e-01f, 2.92695612e-01f,
  -2.51678944e-01f, 2.29302421e-01f, -5.49768269e-01f, -5.07599637e-02f, -2.99936309e-02f, 2.44097456e-01f, -7.18489811e-02f, 8.30983743e-02f, 1.60806522e-01f, -1.77595183e-01f,
  2.14145884e-01f, 3.93644199e-02f, -1.60416245e-01f, 2.82282859e-01f, 1.60903439e-01f, 2.85222590e-01f, 4.35715802e-02f, 2.09265783e-01f, -1.54537577e-02f, -7.36429766e-02f,
  7.85412863e-02f, 2.44126290e-01f, 2.70353615e-01f, 2.12264016e-01f, 1.91610560e-01f, 1.05139479e-01f, -1.36297308e-02f, 1.54362857e-01f, 2.42205068e-01f, -1.82080761e-01f,
  8.00980777e-02f, -3.58197540e-02f, -1.79373696e-01f, 2.05954701e-01f, -2.01510862e-01f, 2.46070430e-01f, 1.83106646e-01f, 2.27738500e-01f, -5.39687634e-01f, -6.62715495e-01f,
  5.83772480e-01f, 1.50982112e-01f, 1.77819058e-01f, -3.68871063e-01f, 4.71405173e-03f, -4.62573506e-02f, -2.36457482e-01f, -9.39113051e-02f, 6.83550984e-02f, 3.09705108e-01f,
  -5.40957190e-02f, 3.87994528e-01f, 6.86695147e-03f, 4.11775634e-02f, 1.58934429e-01f, 9.16838273e-02f, -2.22928926e-01f, 3.31141502e-01f, 1.52796090e-01f, 5.16697653e-02f,
  3.11901391e-01f, 2.21054822e-01f, -2.88943648e-01f, 4.98858839e-02f, 6.63384646e-02f, -1.41203001e-01f, -8.31080303e-02f, 2.41916627e-01f, 2.15151921e-01f, -4.33495104e-01f,
  -1.66496232e-01f, -1.41800903e-02f, 3.15830469e-01f, 8.28679204e-02f, 3.20084423e-01f, 4.71742339e-02f, -1.39505863e-01f, -7.74448663e-02f, -7.10266829e-02f, -3.19130540e-01f,
  6.49539158e-02f, -1.07064499e-02f, -1.69398829e-01f, -1.34174332e-01f, -5.46274036e-02f, 4.12661210e-02f, -2.32936397e-01f, -3.31751198e-01f, 9.52168182e-02f, 2.63678938e-01f,
  1.50629431e-01f, 2.72266150e-01f, 7.01312274e-02f, 2.78746686e-03f, 6.36541188e-01f, 2.32167631e-01f, -2.67996192e-01f, -1.31738499e-01f, 3.52693170e-01f, -7.04173684e-01f,
  -3.00230861e-01f, -1.50506467e-01f, 8.67262259e-02f, 2.43086889e-01f, 1.88696943e-02f, -1.25837818e-01f, -4.37501252e-01f, -2.96319157e-01f, 2.00366735e-01f, -7.90159404e-02f,
  4.91942465e-02f, 2.92073071e-01f, 1.79837108e-01f, -8.19360241e-02f, 1.92213461e-01f, -1.91862494e-01f, -6.00214116e-02f, 1.81714557e-02f, -2.38660991e-01f, 1.26007646e-01f,
  1.27939850e-01f, -3.01489350e-03f, -2.12292373e-02f, 1.10021174e-01f, 2.67549545e-01f, 1.66769400e-01f, -2.16627225e-01f, -6.86217919e-02f, 6.35392904e-01f, 2.39410266e-01f,
  3.33670169e-01f, -2.14218184e-01f, 2.16600925e-01f, 7.34287351e-02f, 2.53006846e-01f, -3.17337096e-01f, 2.34670222e-01f, 4.20964092e-01f, -3.71535718e-01f, 3.48529875e-01f,
  -1.30576625e-01f, -4.47407477e-02f, 4.23123837e-01f, -1.37215868e-01f, 3.44959013e-02f, 1.37858033e-01f, -3.74943181e-03f, 8.84978324e-02f, -6.33752206e-03f, -4.36923280e-02f,
  -1.28099576e-01f, 3.39610428e-01f, -2.43215058e-02f, -3.12039778e-02f, 2.42685154e-01f, 1.74170792e-01f, -4.18310553e-01f, 2.54263163e-01f, -2.10458577e-01f, -1.93631411e-01f,
  1.77827522e-01f, -1.59511119e-01f, 2.31455177e-01f, 1.93579063e-01f, 3.75386953e-01f, -8.01123306e-02f, 3.48701686e-01f, 3.93541068e-01f, -5.33393562e-01f, -7.56506994e-02f,
  -9.43514109e-02f, 2.65958816e-01f, -3.13290983e-01f, 1.87167466e-01f, -1.62353650e-01f, -1.65027797e-01f, 3.19906861e-01f, 8.88291150e-02f, -5.02969213e-02f, -4.40912135e-03f,
  -2.66138732e-01f, 1.33619368e-01f, -8.87151659e-02f, -2.51528919e-01f, 1.29883528e-01f, -4.97837663e-01f, 1.47473395e-01f, 5.43693379e-02f, 3.32818665e-02f, 4.41827178e-01f,
  4.14590120e-01f, 5.70318336e-03f, 1.35346815e-01f, 9.62785445e-03f, 4.16113049e-01f, 2.52031475e-01f, 1.83963150e-01f, -4.66388799e-02f, -2.06341725e-02f, 1.39589205e-01f,
  -2.70500958e-01f, 8.67119804e-03f, -4.44889128e-01f, 2.35798463e-01f, -2.68651918e-02f, 2.39714965e-01f, 6.96110055e-02f, 3.91231984e-01f, 8.48034211e-03f, 5.46977809e-03f,
  3.96304205e-03f, 4.85189706e-02f, 1.22169100e-01f, 2.98832923e-01f, 4.66318801e-03f, 1.91019717e-04f, 4.92919534e-02f, 2.27187425e-01f, 6.97274581e-02f, 1.18316866e-01f,
  -2.00535268e-01f, 5.28852828e-02f, -2.28151634e-01f, -1.73003376e-01f, -4.01232362e-01f, 3.41763198e-01f, 2.10969672e-01f, 2.35740960e-01f, 1.69209376e-01f, 3.68571095e-02f,
  -1.75872415e-01f, -3.92490357e-01f, -4.08558071e-01f, -1.58001870e-01f, 3.84647906e-01f, 2.16882944e-01f, 4.95089032e-02f, -2.45170802e-01f, -8.54827538e-02f, -2.26028010e-01f,
  1.95664745e-02f, 3.36986601e-01f, -4.12987232e-01f, -2.77806669e-02f, 8.88607651e-03f, 2.43543997e-01f, 2.18882293e-01f, 3.77009809e-02f, 2.17764154e-01f, -2.96113670e-01f,
  2.94794023e-01f, -8.31531584e-02f, -4.46558118e-01f, 4.15030390e-01f, 1.83191702e-01f, 3.58428597e-01f, -1.24517240e-01f, 1.01936549e-01f, -4.53509204e-02f, 3.57908368e-01f,
  1.67153165e-01f, 2.27565274e-01f, 2.83738494e-01f, -2.78237075e-01f, 2.93118209e-01f, 2.62362748e-01f, 9.02705714e-02f, 1.18924081e-01f, -2.43406817e-02f, -1.27578631e-01f,
  2.78983146e-01f, 1.97023869e-01f, -1.73105165e-01f, 1.45284727e-01f, -1.65018011e-02f, -8.25670883e-02f, -1.42249048e-01f, -1.09564438e-02f, 1.80321500e-01f, 1.66871816e-01f,
  2.57367611e-01f, 1.28147259e-01f, -9.88863502e-03f, 3.21451351e-02f, 1.42279953e-01f, -1.34211212e-01f, -3.43526810e-01f, 1.47958145e-01f, 3.15815695e-02f, 3.87865633e-01f,
  1.48252817e-02f, 4.51263160e-01f, -2.90684849e-01f, 1.75009489e-01f, -1.83946505e-01f, 1.65964514e-01f, -1.35298535e-01f, 5.99912703e-02f, 4.09456789e-01f, 4.70931798e-01f,
  2.70209998e-01f, 1.81427330e-01f, 2.34107673e-01f, 2.10103244e-02f, 1.83632284e-01f, 2.33119324e-01f, -3.52042131e-02f, -5.40523827e-01f, 3.86392861e-03f, 8.28753933e-02f,
  6.71116635e-02f, -1.27309144e-01f, 7.46835247e-02f, -5.07481545e-02f, 7.41152093e-02f, -1.51459083e-01f, -4.36067879e-01f, 3.31646740e-01f, -2.99860332e-02f, 2.74869025e-01f,
  -3.13823402e-01f, 2.55909503e-01f, -1.49366930e-01f, 1.18537903e-01f, 3.36236566e-01f, 3.79384041e-01f, 1.00537874e-01f, 3.01384479e-01f, 1.64450891e-02f, 2.22568437e-02f,
  3.92661184e-01f, 1.41222432e-01f, 2.58605629e-01f, 1.85772389e-01f, -1.07276831e-02f, -1.59515776e-02f, 4.06034082e-01f, 2.72560686e-01f, 4.17865574e-01f, 2.91090041e-01f,
  2.28907138e-01f, 1.26647308e-01f, 2.10584700e-01f, 1.41845614e-01f, -6.54651672e-02f, -3.18228811e-01f, 2.14303568e-01f, 4.29512918e-01f, 1.53663546e-01f, -7.28365630e-02f,
  -3.23006837e-03f, -2.71920472e-01f, 3.75317425e-01f, -3.30198884e-01f, -2.31912941e-01f, 9.38755572e-02f, 3.71909171e-01f, 1.69340476e-01f, 3.18955749e-01f, 3.02440748e-02f,
  6.16247114e-03f, 3.26719880e-02f, -1.63958862e-01f, 8.24928954e-02f, -2.13333830e-01f, 3.30221146e-01f, -1.58548236e-01f, -5.47042251e-01f, 1.05464607e-01f, -2.20519155e-01f,
  2.56335109e-01f, 2.65155286e-01f, 9.03227851e-02f, -2.84640014e-01f, -2.12239027e-02f, -1.71809912e-01f, -3.03428650e-01f, 8.28819126e-02f, -1.25158593e-01f, -5.11057615e-01f,
  6.34368300e-01f, -3.34425896e-01f, 2.15930805e-01f, 5.20492382e-02f, 1.01676047e-01f, -2.64129620e-02f, 2.47777566e-01f, 7.94575810e-02f, -6.31236061e-02f, 1.75003454e-01f,
  3.48032340e-02f, 7.24758729e-02f, 8.11206456e-03f, -2.61422008e-01f, -4.54847254e-02f, 4.14483398e-02f, -1.45617664e-01f, 1.35214701e-01f, 3.54079455e-01f, -5.00907749e-02f,
  1.98733479e-01f, -1.12336285e-01f, 1.54044271e-01f, 2.21958041e-01f, 1.25707090e-01f, 1.66414529e-01f, 1.50859654e-01f, 2.69773304e-01f, -9.21551213e-02f, 3.70312817e-02f,
  -2.02921897e-01f, -1.63947031e-01f, 1.97638378e-01f, 1.97251856e-01f, -1.70541748e-01f, -1.84710622e-02f, 2.01898813e-01f, -5.97347856e-01f, -4.68318522e-01f, 4.12369758e-01f,
  3.58947635e-01f, 6.34780377e-02f, -1.94360673e-01f, -1.88193053e-01f, 3.24318439e-01f, 8.01445097e-02f, 1.94758505e-01f, -3.53129983e-01f, -3.34966123e-01f, 2.34973840e-02f,
  -2.24225447e-01f, 5.69318533e-02f, -8.06155279e-02f, -5.87088279e-02f, 2.73982882e-01f, 4.43417311e-01f, -1.19407177e-02f, -2.87076272e-02f, -1.94660366e-01f, 2.64705241e-01f,
  1.19185276e-01f, 3.50100875e-01f, 4.16866511e-01f, -7.10950233e-03f, 3.11880767e-01f, 1.06309868e-01f, 1.19112842e-01f, -1.16808422e-01f, 3.67408665e-03f, -1.12178102e-01f,
  2.90893108e-01f, 6.32191241e-01f, -1.35858089e-01f, 1.45559117e-01f, 7.33365491e-02f, 2.61945248e-01f, 1.02407359e-01f, 1.37865275e-01f, 4.99193519e-01f, 3.95924337e-02f,
  2.12080851e-01f, 3.48478854e-01f, 1.46794617e-01f, 3.25410396e-01f, 2.14087442e-01f, 3.52719009e-01f, 6.30858466e-02f, 1.42066956e-01f, 4.77150753e-02f, -4.91459109e-02f,
  2.04370290e-01f, 7.50966445e-02f, 3.71000141e-01f, 1.29262060e-01f, -4.20359820e-02f, 2.54408062e-01f, 1.41139150e-01f, -2.60510385e-01f, 1.74901485e-01f, 2.77509004e-01f,
  4.43520844e-02f, 2.59287834e-01f, 5.98620772e-02f, -2.54838709e-02f, -3.35133791e-01f, -3.26134056e-01f, 1.73405185e-01f, -3.17367435e-01f, 1.63248796e-02f, -3.46661806e-01f,
  -2.38219559e-01f, -3.58339280e-01f, 7.57135823e-02f, -4.58640456e-01f, -5.99152327e-01f, 7.55811989e-01f, 3.46701652e-01f, -7.95681104e-02f, 4.23812836e-01f, -2.59117335e-01f,
  1.49505675e-01f, -7.92936683e-02f, 3.50844823e-02f, -1.36783257e-01f, -1.01914600e-01f, 1.57828808e-01f, -2.79204339e-01f, -9.32645276e-02f, 2.20375180e-01f, 2.95149893e-01f,
  -4.45036501e-01f, -1.57024655e-02f, 4.79645282e-01f, 1.09323718e-01f, 1.95498969e-02f, 7.50555322e-02f, 1.22760713e-01f, -9.81364697e-02f, 3.31559777e-02f, 3.00347328e-01f,
  -8.72289017e-02f, 5.80851212e-02f, -1.94122776e-01f, 6.76585212e-02f, -1.01272441e-01f, -8.46059471e-02f, -3.75849120e-02f, 4.84968387e-02f, -7.83711299e-02f, 3.09951662e-04f,
  2.04246104e-01f, 3.86257768e-01f, -2.68475324e-01f, 5.13172783e-02f, -5.69686629e-02f, 1.97334602e-01f, -1.04848444e-01f, 2.58693546e-01f, 1.18139632e-01f, 4.17138413e-02f,
  2.75763899e-01f, -1.78831108e-02f, -2.31758848e-01f, -3.66763771e-01f, 2.75870770e-01f, 1.02236390e-01f, -1.46064460e-01f, 6.65062899e-03f, 1.50830999e-01f, 3.75993609e-01f,
  -4.95308310e-01f, 1.63817871e-02f, 4.56256330e-01f, 4.32302475e-01f, 4.29176450e-01f, 3.96559417e-01f, 1.71587430e-02f, 4.12606180e-01f, 4.16072905e-01f, -2.56720841e-01f,
  -4.84626383e-01f, 2.40363434e-01f, 2.68327538e-02f, 1.98962182e-01f, 1.34704009e-01f, 1.51651040e-01f, 3.69723946e-01f, 2.31996089e-01f, -2.79847048e-02f, 3.47488254e-01f,
  -1.12345479e-02f, 8.22554082e-02f, 1.06075987e-01f, -4.34056133e-01f, -2.33658001e-01f, 3.48714024e-01f, -2.91663051e-01f, 4.12013769e-01f, -1.42533898e-01f, 1.86381280e-01f,
  3.36464077e-01f, -1.20067038e-02f, 1.16295062e-01f, -2.31628073e-03f, -2.13624403e-01f, -3.99075121e-01f, -8.02816302e-02f, -1.38889044e-03f, 2.06793904e-01f, -9.34181735e-02f,
  -3.25900465e-01f, 3.77896205e-02f, 1.32412016e-01f, 1.20946206e-01f, 2.54500836e-01f, 1.29562259e-01f, 1.50425509e-01f, 6.05779923e-02f, -2.64731467e-01f, -5.78611255e-01f,
  -1.33365065e-01f, -3.78280394e-02f, -1.69533625e-01f, -2.08881408e-01f, -2.39966899e-01f, 3.86266172e-01f, 2.77209997e-01f, -4.88552498e-03f, 1.22725442e-01f, -2.42391661e-01f,
  3.68839115e-01f, -6.00926638e-01f, -2.07924709e-01f, 1.75632119e-01f, 4.50125523e-02f, 3.00379306e-01f, 5.84629439e-02f, -3.91331762e-01f, 2.68812835e-01f, 3.13609719e-01f,
  1.73544720e-01f, -2.95865625e-01f, 1.13333628e-01f, 2.04902127e-01f, 4.37150002e-02f, 5.27777746e-02f, -1.63192928e-01f, -2.72441208e-01f, 4.04827625e-01f, 3.63923758e-01f,
  9.65287089e-02f, 5.90525605e-02f, -2.74707466e-01f, -3.30531865e-01f, -6.72952905e-02f, -2.63594627e-01f, -9.84396711e-02f, -1.86727211e-01f, -1.34664670e-01f, 3.58960927e-01f,
  2.46811315e-01f, 3.84106785e-01f, -2.59918217e-02f, -9.14342105e-02f, -4.71856296e-02f, 7.75472075e-02f, 2.19769567e-01f, 1.97544008e-01f, 3.57127100e-01f, 2.19528973e-01f,
  1.26918048e-01f, 3.10446858e-01f, -3.23047936e-02f, 1.43914036e-02f, 1.38030931e-01f, 1.04363844e-01f, -1.46584004e-01f, -4.61455323e-02f, -1.01398021e-01f, 1.40232682e-01f,
  -9.81143489e-02f, 5.63146221e-03f, 1.53686985e-01f, 3.64530951e-01f, 3.35857362e-01f, 5.35536185e-02f, 2.58786052e-01f, 1.99983060e-01f, 4.34079826e-01f, -5.04144967e-01f,
  7.38001466e-02f, 1.47055939e-01f, -1.66288942e-01f, 2.91546613e-01f, 1.77020758e-01f, 1.78791329e-01f, -5.15665591e-01f, -1.75620377e-01f, -1.61376253e-01f, -3.92562509e-01f,
  -2.94007105e-03f, 1.23383634e-01f, 1.15562417e-02f, -1.34681925e-01f, 1.91721499e-01f, 3.27183932e-01f, 3.58055197e-02f, 1.39417415e-02f, -5.85854985e-03f, 1.04554765e-01f,
  8.62093717e-02f, -5.01712561e-02f, 3.95029970e-02f, -4.00514424e-01f, 2.70580322e-01f, -3.74331683e-01f, 1.40937343e-01f, 2.58016288e-01f, -5.47041968e-02f, -2.21066296e-01f,
  1.74760103e-01f, 2.16000274e-01f, -3.67596835e-01f, 2.13580534e-01f, 2.49337330e-01f, -1.60906449e-01f, -1.69038385e-01f, 2.47254949e-02f, 9.09269378e-02f, 3.44928354e-01f,
  1.88571423e-01f, 2.25642145e-01f, 2.30257347e-01f, -1.75027385e-01f, -1.63963102e-02f, -1.85124800e-01f, 2.54137486e-01f, 3.23865563e-01f, -3.34184580e-02f, 9.61606950e-02f,
  5.26583791e-02f, 3.29819679e-01f, 2.14858025e-01f, -2.70196855e-01f, 2.13285640e-01f, 2.09461793e-01f, -1.06192686e-01f, -3.17578673e-01f, 1.57954693e-01f, 7.06553534e-02f,
  -4.06135954e-02f, 1.82112798e-01f, -1.46886617e-01f, -7.74323642e-02f, 7.60242119e-02f, 7.69085437e-02f, -3.63807559e-01f, 3.67535800e-01f, 1.86798424e-01f, -1.83957323e-01f,
  -2.80996710e-01f, -1.01339027e-01f, 2.06109002e-01f, -1.38712868e-01f, -3.38865489e-01f, -3.53472650e-01f, 1.05507135e-01f, 1.23408370e-01f, 3.85289073e-01f, -4.97071356e-01f,
  1.14899337e-01f, 2.48478159e-01f, 3.50699186e-01f, 2.26954192e-01f, -1.31507725e-01f, -3.65236402e-01f, -7.95565620e-02f, 2.49514848e-01f, -5.08908881e-03f, -1.95526242e-01f,
  4.39613611e-02f, -2.07052514e-01f, -9.87759978e-02f, -3.85427773e-01f, -1.80173621e-01f, 2.74154872e-01f, 2.39945464e-02f, 1.32353067e-01f, 2.17692822e-01f, 3.60078573e-01f,
  1.48317264e-02f, -9.48730782e-02f, 1.11023514e-02f, -5.80183566e-02f, 2.27216948e-02f, 2.85910100e-01f, 3.38023573e-01f, -8.66604000e-02f, 1.50531098e-01f, 6.16457500e-02f,
  3.40032637e-01f, 2.98332453e-01f, 7.65988827e-02f, 2.38322809e-01f, 2.33108997e-01f, 1.63367212e-01f, 1.28602520e-01f, 4.15399969e-02f, 2.09734753e-01f, 2.63146877e-01f,
  1.28160983e-01f, 9.57464874e-02f, 4.28248137e-01f, -3.65136154e-02f, 8.52720365e-02f, 2.79182285e-01f, 1.43355027e-01f, -4.10477608e-01f, 2.32983291e-01f, 3.73654127e-01f,
  -3.34100902e-01f, 1.45513907e-01f, 4.12252955e-02f, 1.37527317e-01f, -4.40056533e-01f, -3.28320444e-01f, 3.47885080e-02f, -4.21567053e-01f, -1.77612677e-02f, -3.15581143e-01f,
  -2.38837022e-03f, -3.50244343e-01f, 8.56744722e-02f, -2.33599305e-01f, -3.27872485e-01f, 2.73427039e-01f, -4.17924970e-02f, 9.77863893e-02f, 7.49982446e-02f, -2.65523344e-01f,
  -1.59094203e-02f, 5.19582666e-02f, -1.45985231e-01f, -2.14366645e-01f, -7.57412910e-02f, -4.11725752e-02f, 1.08748578e-01f, -2.57719427e-01f, 1.21328281e-02f, 1.00895569e-01f,
  -3.37365925e-01f, 6.87803421e-03f, 1.19205527e-01f, 2.17147335e-01f, -1.41504720e-01f, 2.15301380e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  2.14059308e-01f, 2.17056677e-01f, 1.62763357e-01f, 1.31165087e-01f, 9.37827602e-02f, 1.04892761e-01f, 1.78281188e-01f, 7.40393698e-02f, 1.14521995e-01f, 1.90111890e-01f,
  2.00067878e-01f, 1.11253642e-01f, 1.19129173e-01f, 1.07945174e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -1.30364522e-01f, -2.33521655e-01f, 2.56671935e-01f, -2.19117075e-01f, -3.24781269e-01f, -7.83345476e-02f, -1.35259494e-01f, -3.95019539e-02f, 1.06594853e-01f, 3.44880819e-02f,
  4.36571121e-01f, 1.34663042e-02f, -3.40664744e-01f, -6.72924370e-02f, -2.41360098e-01f, 1.30026221e-01f, -2.24761397e-01f, -5.98801114e-02f, -2.67835826e-01f, 1.23894326e-01f,
  3.32870215e-01f, -2.15043470e-01f, 9.38952193e-02f, -3.23396921e-01f, -2.92264163e-01f, -1.03372559e-02f, 4.49658558e-02f, -8.26177150e-02f, 1.32583335e-01f, 9.37649757e-02f,
  -1.19697429e-01f, -1.39318213e-01f, -3.97065729e-01f, 2.94258446e-01f, -3.00837886e-02f, -1.36932522e-01f, -2.45777175e-01f, 3.69139999e-01f, -1.47198021e-01f, 2.53818452e-01f,
  6.33291900e-02f, -4.70991917e-02f, 7.45586231e-02f, 6.39391005e-01f, -5.85973412e-02f, 1.46396589e-02f, 2.54115373e-01f, -4.18215711e-03f, 1.59909815e-01f, 2.38374308e-01f,
  8.78565684e-02f, -2.96968639e-01f, 2.71770954e-01f, 4.53742892e-01f, -7.12473989e-02f, -3.31841528e-01f, -2.23206148e-01f, -1.88188747e-01f, -4.07797880e-02f, -2.64593661e-01f,
  -4.12808508e-01f, -9.50266570e-02f, -1.76525205e-01f, -5.82180679e-01f, -8.73062946e-03f, -2.04649642e-01f, -4.35793906e-01f, -3.14813375e-01f, 2.83695310e-02f, 2.16687873e-01f,
  -6.26133308e-02f, 2.82293707e-01f, 4.36379790e-01f, -1.55239049e-02f, -2.87733644e-01f, 1.14883117e-01f, 1.23712666e-01f, -1.91159487e-01f, -3.18569064e-01f, 2.53451556e-01f,
  1.03920132e-01f, -3.42139333e-01f, 2.25542858e-01f, -6.56707436e-02f, 3.21357876e-01f, 1.53122261e-01f, 1.29779562e-01f, 3.74939919e-01f, -9.09172744e-02f, 7.18364790e-02f,
  -2.25434870e-01f, 2.09280819e-01f, 2.45537907e-02f, -5.02098560e-01f, -2.31504709e-01f, -1.68702856e-01f, 3.48207414e-01f, 6.33130670e-02f, 2.47596622e-01f, 2.61621296e-01f,
  3.35079819e-01f, -2.68077314e-01f, -3.33086342e-01f, -5.25739074e-01f, -5.08035123e-01f, 3.13394278e-01f, 3.73997569e-01f, 4.20683503e-01f, 3.04887712e-01f, 1.74342245e-01f,
  -3.00490350e-01f, -2.31124654e-01f, -6.17747717e-02f, -2.55661905e-01f, -8.51612911e-02f, 7.57468939e-02f, -3.46685886e-01f, 1.11841664e-01f, 1.47162348e-01f, -1.07117876e-01f,
  -5.09768009e-01f, 3.75229120e-01f, -3.16942602e-01f, 2.02537462e-01f, -2.54446208e-01f, -6.79532826e-01f, -6.52796865e-01f, -7.92620480e-02f, 5.88512719e-02f, -4.89861071e-02f,
  -4.18005772e-02f, -7.40251467e-02f, 3.57565522e-01f, -2.81698465e-01f, -1.86644211e-01f, -2.26291150e-01f, 5.73385842e-02f, 1.04373671e-01f, 7.68300320e-04f, -7.44242668e-02f,
  -2.70196766e-01f, -7.23881721e-02f, 7.30919838e-02f, -1.59015530e-04f, -7.48167112e-02f, 2.08151191e-01f, 8.39374512e-02f, -1.18396379e-01f, -1.43652409e-01f, 7.50979036e-02f,
  -8.79584923e-02f, -1.99008390e-01f, 2.11202785e-01f, -4.05461162e-01f, 3.05692077e-01f, 2.39846453e-01f, 1.42891958e-01f, -2.83652872e-01f, 8.82394426e-03f, 3.24693471e-01f,
  2.05536500e-01f, -3.36855471e-01f, -6.42044377e-03f, 1.19847894e-01f, -2.47370854e-01f, 2.32644886e-01f, -1.51605168e-02f, -2.89103001e-01f, 1.59962714e-01f, 2.59190083e-01f,
  -4.58204120e-01f, -1.02803148e-01f, 1.52251497e-01f, -6.86572492e-03f, 3.74738902e-01f, -1.19101666e-01f, 3.11979353e-01f, 3.02613437e-01f, -2.91336298e-01f, -3.43408197e-01f,
  -3.42975289e-01f, 4.26249593e-01f, 2.72228360e-01f, 3.81865144e-01f, -3.41393769e-01f, -2.41279051e-01f, -5.91892064e-01f, -3.99533242e-01f, -1.46844879e-01f, -1.87721662e-02f,
  2.33779743e-01f, 5.33361025e-02f, 2.41255075e-01f, 7.72921368e-02f, -1.69471428e-01f, 6.31922111e-02f, 6.05036281e-02f, -7.70401433e-02f, 6.02509864e-02f, 3.76194924e-01f,
  3.31316054e-01f, 1.66328609e-01f, -2.49716461e-01f, 2.58745085e-02f, 1.56062782e-01f, -1.23135239e-01f, -1.47177354e-01f, -1.57774538e-01f, -1.86448380e-01f, 3.09737444e-01f,
  -1.34981871e-01f, 2.07651686e-02f, 1.01845272e-01f, 4.07142639e-02f, -2.62331754e-01f, -1.43123552e-01f, -1.67062938e-01f, -3.80969703e-01f, -2.56741136e-01f, -7.41653740e-02f,
  4.77066875e-01f, -1.19785242e-01f, 1.32011116e-01f, -1.06182337e-01f, -4.70661037e-02f, 3.73345613e-01f, 7.21371323e-02f, -1.53736636e-01f, -2.14082435e-01f, 1.08623922e-01f,
  3.50022793e-01f, -9.69588533e-02f, -1.84119865e-02f, -9.95247718e-03f, -1.09692551e-01f, -1.49391042e-02f, -6.41417801e-01f, -4.48251851e-02f, 1.57434493e-01f, 3.77148278e-02f,
  1.51768446e-01f, -2.36200333e-01f, -2.98420191e-01f, -3.55444491e-01f, 1.29387751e-01f, -1.71020970e-01f, -3.29290003e-01f, -1.65641144e-01f, -2.34832801e-03f, -3.63633841e-01f,
  1.11466333e-01f, -5.05995154e-01f, 6.61615729e-01f, -4.97773618e-01f, 2.25748718e-01f, 1.66224062e-01f, -2.41954774e-01f, 2.09420815e-01f, -4.65003885e-02f, 2.53528416e-01f,
  -1.84786856e-01f, 5.00041768e-02f, 1.28583670e-01f, -8.10755342e-02f, -3.06717455e-01f, -3.14805835e-01f, -2.91803062e-01f, 2.51807958e-01f, 1.58930600e-01f, 1.41459346e-01f,
  1.48111284e-01f, -6.89219609e-02f, -1.58804625e-01f, -1.34313315e-01f, 2.51319468e-01f, -6.10406213e-02f, -3.86736125e-01f, 3.48396152e-01f, 2.32374996e-01f, 3.54353160e-01f,
  1.47502437e-01f, 1.68705881e-01f, 2.84025192e-01f, -5.25032938e-01f, -3.99835199e-01f, 6.75968677e-02f, -2.56007224e-01f, 4.41061676e-01f, -1.66749731e-01f, -4.05399173e-01f,
  -2.96841472e-01f, -2.71758288e-01f, 3.76768351e-01f, 1.77672148e-01f, -2.54837602e-01f, -9.94265601e-02f, 4.42064613e-01f, 2.14717999e-01f, 3.03798407e-01f, -4.19889778e-01f,
  3.17248672e-01f, 1.22425616e-01f, 1.29941502e-03f, -8.40520561e-02f, -1.19110733e-01f, -2.12252378e-01f, -3.75745565e-01f, -3.44178230e-01f, 2.28116572e-01f, -2.76921809e-01f,
  -2.43283093e-01f, -4.34020549e-01f, -2.12159589e-01f, -2.70265549e-01f, 2.22320333e-01f, -1.47103658e-02f, -5.88716805e-01f, 3.36606205e-01f, 1.31780773e-01f, 1.69208914e-01f,
  -5.03205135e-02f, 3.69751304e-02f, 2.07435444e-01f, -6.74977601e-02f, -1.49798855e-01f, 6.77542314e-02f, 2.03469232e-01f, -4.33128595e-01f, -3.96747231e-01f, 7.49577358e-02f,
  3.03544670e-01f, -1.96421772e-01f, 1.59333229e-01f, -9.15357992e-02f, 2.10983559e-01f, -7.68109262e-02f, 2.34187186e-01f, -2.89798453e-02f, 2.56738514e-01f, -1.05281085e-01f,
  2.43743047e-01f, -1.60319477e-01f, 8.19660574e-02f, 1.57656550e-01f, 2.05581576e-01f, -3.44816297e-01f, 1.74576864e-01f, 4.72736955e-01f, -1.25095442e-01f, -2.29333669e-01f,
  5.39951622e-01f, -4.26820099e-01f, -4.13156509e-01f, 1.48001298e-01f, 2.23471925e-01f, -1.70503795e-01f, 4.39297229e-01f, 3.72750014e-01f, -3.68085057e-01f, 5.79939559e-02f,
  -7.03729615e-02f, -4.02495086e-01f, 9.05177593e-02f, 1.42366976e-01f, -1.17489040e-01f, -1.90395221e-01f, -3.04088835e-02f, -5.26208654e-02f, -1.90313179e-02f, -1.44315466e-01f,
  -3.04764599e-01f, 2.91109502e-01f, 5.28463386e-02f, -3.50358278e-01f, -1.86575025e-01f, -2.94631839e-01f, 3.79674248e-02f, 1.94264650e-01f, 2.24564448e-01f, -4.67976987e-01f,
  -1.32303406e-03f, 2.99406707e-01f, -3.90842199e-01f, 2.76196808e-01f, -4.03060645e-01f, 4.24814969e-01f, 2.49984950e-01f, 2.26650611e-01f, -4.69846219e-01f, 3.13493192e-01f,
  -1.83034062e-01f, 9.91860926e-02f, -4.32457536e-01f, 4.03248072e-01f, -2.70984828e-01f, 3.46922949e-02f, 3.71625841e-01f, -2.50474900e-01f, -6.36598617e-02f, 6.69188574e-02f,
  -2.26655886e-01f, 8.49160999e-02f, -1.07654415e-01f, 1.85302213e-01f, 3.25179815e-01f, 3.85839820e-01f, 5.33842087e-01f, 9.24513340e-02f, -3.82300317e-01f, 2.21073985e-01f,
  5.34887016e-02f, 8.31696242e-02f, 3.06719065e-01f, 1.29447788e-01f, 2.34143734e-01f, -4.74947721e-01f, 8.49091485e-02f, -2.20122069e-01f, 4.49578017e-02f, 4.11895454e-01f,
  -1.37477979e-01f, -6.92749862e-03f, -5.38573600e-02f, 3.42790693e-01f, -1.06727578e-01f, -2.84400254e-01f, -8.65520909e-02f, -2.82766998e-01f, -3.04093808e-01f, -1.76637352e-01f,
  2.26867422e-01f, -1.33941650e-01f, 2.36334242e-02f, 1.35102257e-01f, 2.05892295e-01f, 8.32441449e-02f, -2.40056455e-01f, -2.20018134e-01f, 2.57239997e-01f, 7.11003691e-02f,
  6.05290849e-03f, -2.55851477e-01f, -6.31488740e-01f, 1.75911546e-01f, -2.64971644e-01f, 2.80669361e-01f, -3.31390530e-01f, 4.57988605e-02f, 8.19381420e-03f, -4.50271577e-01f,
  -2.69461662e-01f, -2.11700082e-01f, 1.61409020e-01f, -3.39047700e-01f, -1.02076210e-01f, -3.08691382e-01f, -2.05466241e-01f, -3.68885726e-01f, -7.67420828e-02f, 1.22919485e-01f,
  -8.36635828e-02f, 2.18255281e-01f, 7.95643553e-02f, 1.38117030e-01f, 2.80995807e-03f, -4.92426276e-01f, 1.08815908e-01f, -3.04777116e-01f, -3.25096190e-01f, 6.74327537e-02f,
  -1.35318562e-01f, 1.40816599e-01f, 1.24149665e-01f, 2.21498430e-01f, -3.51329863e-01f, -4.72804606e-02f, -2.66665183e-02f, 1.65641099e-01f, -2.39222571e-01f, -1.04052946e-01f,
  1.36300698e-01f, -3.96777421e-01f, 2.80381650e-01f, -1.49115935e-01f, -1.93609118e-01f, -2.22398430e-01f, -1.32947534e-01f, -8.62067193e-02f, -1.54877171e-01f, 8.52988288e-02f,
  -1.30601957e-01f, -2.81867772e-01f, -3.17325562e-01f, 1.60697281e-01f, 3.35362285e-01f, -1.76176056e-01f, 2.50366956e-01f, -1.38505802e-01f, 5.43997996e-02f, -4.52159882e-01f,
  2.62317266e-02f, -5.43276548e-01f, 1.67314738e-01f, -1.71089061e-02f, -2.25462705e-01f, -2.18252927e-01f, -4.28212255e-01f, 2.83748537e-01f, 5.37321508e-01f, -2.75193542e-01f,
  2.86344830e-02f, -4.49950516e-01f, 2.57939011e-01f, 1.29477009e-01f, -8.87662992e-02f, 9.15575475e-02f, 1.48548871e-01f, -1.67600393e-01f, -7.69723430e-02f, 3.24636966e-01f,
  1.79467201e-01f, -5.53493686e-02f, -5.53307757e-02f, -9.17610601e-02f, -2.89433181e-01f, -7.17117339e-02f, 1.52815744e-01f, -2.13673711e-01f, -4.62944210e-02f, 2.64591038e-01f,
  -1.32358506e-01f, 1.66289359e-01f, -5.58435991e-02f, -1.87234804e-02f, -3.07588637e-01f, 8.86526555e-02f, -5.74980527e-02f, 3.08302432e-01f, 4.42011893e-01f, 6.91247880e-02f,
  -2.70985305e-01f, 2.83125103e-01f, 1.71812981e-01f, -2.57335752e-01f, -4.21737581e-01f, -9.07420591e-02f, -5.82624912e-01f, 2.64196217e-01f, 3.02226841e-01f, -4.73608822e-01f,
  3.15761775e-01f, 3.68266910e-01f, 1.39760181e-01f, -3.57463330e-01f, -6.26717448e-01f, 3.22138339e-01f, 1.16640680e-01f, -1.89865112e-01f, -6.15400001e-02f, 3.12341571e-01f,
  -1.95903718e-01f, 5.47769308e-01f, -2.09748343e-01f, 2.81750649e-01f, -8.02376121e-02f, -4.61560726e-01f, -3.35376918e-01f, -3.50438297e-01f, 3.42203289e-01f, 1.62052095e-01f,
  -2.96408623e-01f, 2.94314235e-01f, 8.72291103e-02f, -3.16660851e-01f, -1.98703930e-01f, -4.52702701e-01f, 3.39201868e-01f, 2.46585310e-01f, -9.13288593e-02f, 2.69575752e-02f,
  -1.63122118e-01f, -8.25493690e-03f, 1.85526013e-01f, -2.17146188e-01f, 1.09318584e-01f, 1.60793096e-01f, 2.12651551e-01f, -1.40835941e-01f, 3.52171101e-02f, -1.29159763e-01f,
  -6.35646135e-02f, 1.38177544e-01f, 3.22603971e-01f, 2.41905674e-01f, -3.15111786e-01f, 1.70818418e-01f, -2.94562459e-01f, -1.05805516e-01f, -2.73752213e-01f, 1.20752543e-01f,
  -1.06234290e-01f, 4.97203171e-02f, -2.90855616e-01f, -3.81407171e-01f, 8.46088827e-02f, 4.56831574e-01f, -4.29754794e-01f, 1.51424423e-01f, 1.55632183e-01f, 8.96383747e-02f,
  -1.40660390e-01f, -5.84265925e-02f, -3.48339230e-01f, 2.23203093e-01f, -1.98093414e-01f, 3.87283266e-01f, 1.14872478e-01f, 2.44518947e-02f, 7.52935112e-02f, 8.21266770e-02f,
  -2.26871938e-01f, 1.26573801e-01f, -8.86435658e-02f, -5.31452335e-02f, -1.65707126e-01f, 3.35587919e-01f, 2.54207164e-01f, 1.48631364e-01f, -7.58419931e-01f, -2.87498087e-01f,
  2.48764589e-01f, 7.58928955e-02f, -2.75747180e-01f, -3.54632258e-01f, 4.65607971e-01f, -3.71165156e-01f, -4.75253649e-02f, -4.58053164e-02f, 2.58024067e-01f, 1.91474542e-01f,
  -4.03173678e-02f, 1.71848938e-01f, 2.28089333e-01f, 1.88663289e-01f, 7.96587691e-02f, 1.61267921e-01f, -8.04364383e-02f, 3.25557664e-02f, 2.25622654e-02f, -1.21036805e-01f,
  1.58600554e-01f, 1.65805042e-01f, 1.45452783e-01f, -1.53975978e-01f, -2.42053851e-01f, 1.55566946e-01f, -8.14520270e-02f, 1.48592964e-01f, 1.45584658e-01f, -1.56131059e-01f,
  1.18520461e-01f, -2.67217875e-01f, -9.48995277e-02f, -4.56783593e-01f, 1.17970034e-01f, -2.33210966e-01f, 1.63004845e-01f, -1.77932784e-01f, -2.83651978e-01f, 3.98622751e-01f,
  -1.77590195e-02f, -1.77292481e-01f, 4.74726439e-01f, 2.19553187e-01f, -2.78292149e-01f, -9.31235030e-02f, -3.13541502e-01f, -8.61599669e-02f, 5.51195562e-01f, -4.14966106e-01f,
  -3.10502589e-01f, 2.51465797e-01f, 1.15715548e-01f, -1.02241963e-01f, 1.54552132e-01f, -2.52694130e-01f, -2.16638163e-01f, 4.11911339e-01f, -1.46595523e-01f, -2.46820569e-01f,
  -2.29595736e-01f, -4.73446131e-01f, -3.13887835e-01f, 4.70849723e-01f, -5.98376513e-01f, -7.61652067e-02f, 5.81027329e-01f, 4.65862416e-02f, 3.52080315e-02f, -4.73197430e-01f,
  -2.64559716e-01f, -1.82937235e-01f, -1.69152692e-01f, -1.36379480e-01f, 1.27088472e-01f, -2.79098779e-01f, 8.07971880e-02f, 1.70777842e-01f, 2.55275786e-01f, -7.88375959e-02f,
  5.06766476e-02f, -9.80653614e-02f, 2.68987864e-01f, -8.41672644e-02f, 2.83441275e-01f, 8.44149888e-02f, -2.72192836e-01f, 1.73704222e-01f, 5.17614633e-02f, -1.15695335e-01f,
  9.45062488e-02f, 1.61665261e-01f, 6.03135414e-02f, -6.99823499e-02f, 2.24130098e-02f, -3.06183219e-01f, 4.68081981e-02f, -2.97335982e-01f, 1.57259718e-01f, 2.67935395e-01f,
  -3.85219663e-01f, 6.18115477e-02f, 3.39836508e-01f, -5.95330894e-02f, 2.32644483e-01f, 6.29970610e-01f, 2.64140934e-01f, 1.66267186e-01f, 4.64515448e-01f, -3.50693196e-01f,
  -2.08256319e-01f, -3.71800125e-01f, 2.80520916e-01f, 1.87133759e-01f, -1.75549477e-01f, -1.30751312e-01f, -2.41248086e-01f, -5.14927432e-02f, 3.17872941e-01f, -2.49494001e-01f,
  -3.47588658e-01f, 4.49162126e-01f, -3.00624907e-01f, -4.32601664e-03f, 3.24074388e-01f, 6.05694810e-03f, -2.86637336e-01f, -3.33971411e-01f, -5.09760737e-01f, 3.80067319e-01f,
  -3.57754439e-01f, -1.40046790e-01f, -8.25402886e-02f, 2.14005992e-01f, -3.25017780e-01f, 2.96410650e-01f, -2.11717054e-01f, -1.10706896e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.57208142e-02f, 6.93875328e-02f, -1.02369368e-01f, -5.97390383e-02f, 1.95425227e-01f, -9.03377756e-02f, 1.00554615e-01f, 1.00354858e-01f, -1.08161762e-01f, 5.81105910e-02f,
  4.22015078e-02f, -3.47986631e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    