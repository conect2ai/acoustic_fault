/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.46546006e-01f, 1.33077592e-01f, 1.17162131e-01f, -1.93370972e-02f, -9.50837433e-02f, -1.91017926e-01f, -1.08486027e-01f, -1.17680930e-01f, 2.64216773e-02f, 1.37367651e-01f,
  -2.48629749e-02f, 7.20087439e-02f, 2.05469243e-02f, -4.93910983e-02f, -1.25460774e-01f, 3.90880778e-02f, -8.80291611e-02f, 4.89730483e-05f, 7.02791214e-02f, -2.24867295e-02f,
  -4.35691178e-02f, -6.90433607e-02f, 6.90261647e-02f, 6.22008406e-02f, -4.92755994e-02f, 9.99042094e-02f, 6.12806045e-02f, -8.36315379e-02f, -4.55417447e-02f, -4.02812809e-02f,
  -4.00925167e-02f, 7.52079785e-02f, 4.64823060e-02f, -2.08079051e-02f, -6.92050112e-03f, 2.55295765e-02f, 6.92971274e-02f, 4.09320779e-02f, 4.85490672e-02f, 1.82817709e-02f,
  9.25524980e-02f, -5.01694763e-03f, -6.29430935e-02f, -2.07913504e-03f, -1.06192172e-01f, 4.28363606e-02f, -6.81501329e-02f, -3.29471715e-02f, 6.73222840e-02f, -3.97049822e-02f,
  6.91507608e-02f, -5.42256273e-02f, 7.23394230e-02f, 2.21001301e-02f, 3.56773771e-02f, -4.95729372e-02f, -7.49152079e-02f, -4.81936298e-02f, -6.83155805e-02f, 5.46878278e-02f,
  6.30409690e-03f, 3.06437965e-02f, 1.30706290e-02f, -7.23028183e-03f, -3.14980047e-03f, 7.42386505e-02f, -2.17407327e-02f, -3.77599411e-02f, -3.60694528e-02f, -6.84927925e-02f,
  7.38715306e-02f, -2.73846053e-02f, -3.67176277e-03f, 3.15514207e-02f, 1.52418585e-02f, -4.32353758e-04f, 4.60044034e-02f, 6.33347109e-02f, 9.97893885e-03f, 5.59888482e-02f,
  -3.11138332e-02f, 1.71188880e-02f, 1.76088028e-02f, 6.69127181e-02f, -5.85430488e-02f, -1.72568986e-03f, -5.75378491e-03f, -4.33547683e-02f, -2.20632982e-02f, 3.08614969e-02f,
  -7.02562779e-02f, 3.83025743e-02f, 4.67449911e-02f, -1.24402735e-02f, -3.58567759e-02f, -1.22011388e-02f, -1.07134217e-02f, -5.64026907e-02f, -1.33648922e-03f, -2.98665557e-02f,
  2.64736507e-02f, -2.60864897e-03f, -2.74271611e-02f, 6.12194538e-02f, 5.42320721e-02f, -1.11791287e-02f, 2.56085861e-02f, -5.51907159e-02f, 1.77641604e-02f, 7.36828297e-02f,
  7.32235909e-02f, 4.92563695e-02f, 2.22922694e-02f, 3.06259617e-02f, -2.68517844e-02f, -4.02656430e-03f, 1.65429506e-02f, -5.24296798e-02f, -2.95190457e-02f, -5.68102784e-02f,
  -3.13293114e-02f, -2.87444651e-01f, 9.81942043e-02f, 8.99361819e-03f, -3.46389860e-02f, -2.42182449e-01f, -2.43027776e-01f, -1.01967417e-02f, -2.60105103e-01f, -2.94422418e-01f,
  -9.55491886e-02f, 9.66140032e-02f, -1.31358370e-01f, -2.71282971e-01f, 1.35376811e-01f, -1.21064618e-01f, -1.86939761e-01f, -1.04610458e-01f, -1.74066536e-02f, -1.07396785e-02f,
  3.37782986e-02f, -1.01718634e-01f, 2.91509330e-02f, 3.56318764e-02f, -5.74707985e-02f, 1.30641297e-01f, 1.63635895e-01f, 1.97237417e-01f, 7.44748935e-02f, 1.34921283e-01f,
  -1.03866011e-01f, -1.03420921e-01f, 2.48224176e-02f, -2.76954863e-02f, 1.07829049e-02f, 2.20001452e-02f, 1.37543604e-01f, 8.43870044e-02f, 6.57792091e-02f, -1.60232000e-02f,
  -3.15969884e-02f, 1.02933310e-02f, -2.90091317e-02f, -7.40246335e-03f, 1.31752482e-02f, -1.39915221e-03f, 4.34886925e-02f, 1.12045845e-02f, 3.77020170e-03f, -9.09048542e-02f,
  -4.93503697e-02f, 2.90381499e-02f, -3.12722400e-02f, 6.53630868e-02f, -1.51459277e-02f, -5.09570725e-02f, 2.44870801e-02f, 3.09419427e-02f, -7.11765140e-02f, 1.36265473e-03f,
  -3.74282449e-02f, -2.82538198e-02f, -2.82688346e-02f, -6.75032064e-02f, -1.92539080e-03f, 1.25849340e-02f, -2.76200064e-02f, 1.75878089e-02f, 8.12152028e-02f, -7.00887442e-02f,
  -2.99061369e-03f, 2.46067718e-02f, -6.18921369e-02f, -6.23316988e-02f, -2.61189360e-02f, -1.19212279e-02f, 1.03896052e-01f, -1.54754994e-02f, -3.83057371e-02f, -4.84537892e-02f,
  -3.94052938e-02f, -1.27599435e-02f, -2.17068996e-02f, 3.69760990e-02f, -1.13150058e-02f, 2.32257750e-02f, -3.32845487e-02f, 2.84792185e-02f, 7.44715258e-02f, 3.73835042e-02f,
  -1.66218951e-02f, -6.84568882e-02f, -1.07871555e-03f, 4.99170041e-03f, -2.83591971e-02f, -3.35532464e-02f, -6.41327649e-02f, -9.73674003e-03f, 5.52992709e-02f, 2.10295543e-02f,
  1.91758908e-02f, 3.71595584e-02f, -1.85307208e-02f, 3.01992334e-03f, 5.20987324e-02f, -4.68835123e-02f, -3.81213278e-02f, 6.01404021e-03f, 7.53255142e-03f, 7.84301981e-02f,
  -1.63419880e-02f, -3.73017453e-02f, 2.74450108e-02f, -6.56271353e-02f, 4.96739298e-02f, 2.73124613e-02f, -1.54959047e-02f, 3.93859521e-02f, 2.93661021e-02f, -3.63935158e-02f,
  -2.33018339e-01f, 1.27534702e-01f, -2.09175706e-01f, -1.01016961e-01f, -1.84311286e-01f, -1.44571826e-01f, -1.28412336e-01f, -1.14310421e-01f, -1.13756165e-01f, 6.29247054e-02f,
  -4.18260880e-02f, -4.48040925e-02f, 1.45127863e-01f, -5.27149551e-02f, -1.49935633e-01f, 1.63965642e-01f, -4.24750708e-02f, -1.15352524e-02f, 7.88647681e-02f, -1.40309602e-01f,
  -1.30012408e-01f, 7.74495676e-02f, -5.34233488e-02f, 1.16161734e-01f, -1.49982227e-02f, -9.50214565e-02f, -4.24197391e-02f, 2.48269876e-03f, -7.62258023e-02f, -4.50246446e-02f,
  -1.61873624e-02f, 1.28896043e-01f, 2.38550198e-03f, 2.22681016e-02f, -1.05754942e-01f, -4.24752571e-02f, -7.81078115e-02f, -6.31365031e-02f, 9.31698829e-03f, -2.09138431e-02f,
  -8.64573047e-02f, -1.90826766e-02f, -7.44258836e-02f, -1.71873234e-02f, -1.59696676e-02f, -4.83702570e-02f, -5.85269071e-02f, 2.08982136e-02f, -7.23642781e-02f, 5.84968217e-02f,
  -7.66868331e-03f, -2.97970627e-03f, -5.84844686e-02f, -2.61346493e-02f, -3.18455398e-02f, -3.81986098e-03f, 2.05816124e-02f, 3.94572131e-02f, 5.32097705e-02f, -9.32141840e-02f,
  2.03740341e-03f, 6.51666000e-02f, 1.11264987e-02f, 1.85736120e-02f, 6.15427531e-02f, 2.37267911e-02f, -4.14607003e-02f, 5.33022657e-02f, 1.29029350e-02f, 3.27446163e-02f,
  -4.83045727e-02f, -9.40441340e-03f, -2.85040699e-02f, 4.32116464e-02f, -4.69679153e-03f, -1.19078252e-02f, 8.65670890e-02f, 2.10464653e-02f, -1.02518059e-01f, 2.86890995e-02f,
  -4.44270931e-02f, -9.00097378e-03f, -1.69178247e-02f, 4.68994863e-02f, 4.74881344e-02f, -3.70535906e-03f, 3.15359570e-02f, -2.34903730e-02f, 4.64607254e-02f, 4.75662388e-03f,
  -4.66207378e-02f, 6.86901901e-03f, -3.38075422e-02f, -1.61849875e-02f, 4.32967283e-02f, -3.54556032e-02f, 3.19457278e-02f, 1.01834787e-02f, -7.19669014e-02f, 4.09152284e-02f,
  6.57991087e-03f, 8.35027080e-04f, -5.87390959e-02f, 7.43744671e-02f, -2.67456062e-02f, 2.28356086e-02f, 6.34887069e-02f, -8.95099267e-02f, 1.49486335e-02f, -8.27194285e-03f,
  4.46168371e-02f, -7.16133043e-02f, -2.64437459e-02f, -7.89184272e-02f, -8.03341791e-02f, -2.67108716e-02f, 2.68768761e-02f, -6.65898323e-02f, 3.97547111e-02f, -7.22610950e-02f,
  -6.14707656e-02f, 1.02975175e-01f, 1.41643554e-01f, 3.23985189e-01f, -1.36255771e-01f, -1.98865663e-02f, 1.54730812e-01f, -1.04523478e-02f, 1.03618033e-01f, 1.44586593e-01f,
  9.89552811e-02f, -5.89036010e-02f, -6.02466539e-02f, 2.80293405e-01f, 6.31211475e-02f, 1.06307015e-01f, 3.01816732e-01f, 1.71261758e-01f, 2.29714308e-02f, 2.07178425e-02f,
  5.43043353e-02f, 1.54485345e-01f, 1.51564002e-01f, 2.66139675e-02f, -2.93278638e-02f, -1.03473058e-02f, 1.01876378e-01f, -6.39193058e-02f, 2.35516101e-01f, 4.54582423e-02f,
  -3.90635133e-02f, -5.24908453e-02f, -7.42254080e-03f, 1.65460985e-02f, 3.98269258e-02f, -5.59433177e-03f, 2.54914388e-02f, 2.20657084e-02f, 2.01938543e-02f, -2.50395741e-02f,
  -1.09517135e-01f, -3.92732136e-02f, -2.94207912e-02f, 2.17937864e-02f, -8.04429799e-02f, 2.29208749e-02f, -2.26081442e-02f, 3.30937468e-02f, -3.65673378e-02f, -8.16624239e-02f,
  -1.71225313e-02f, 4.16691564e-02f, 5.11270873e-02f, 2.89422832e-02f, 6.78212661e-03f, 1.44425044e-02f, -4.51736478e-03f, -8.03167224e-02f, -5.37706986e-02f, -1.78082809e-02f,
  -1.77651234e-02f, -5.67923598e-02f, -4.85285074e-02f, -4.03393731e-02f, 7.96144735e-03f, -2.17448436e-02f, 8.11331347e-02f, 3.53272632e-02f, 3.07771564e-02f, 2.73187528e-03f,
  6.18833341e-02f, -1.68462563e-02f, 4.24236283e-02f, -4.31412086e-02f, 5.18526770e-02f, -6.23439997e-02f, -3.97922806e-02f, 4.40463014e-02f, 5.00269085e-02f, 3.10502499e-02f,
  5.41065447e-02f, 4.03113812e-02f, -1.51912645e-02f, 3.87160778e-02f, 3.09743565e-02f, -7.44959107e-03f, 2.92399153e-02f, 5.75386547e-02f, 5.87477572e-02f, 1.59289278e-02f,
  1.08433545e-01f, 1.70674384e-01f, 7.96852261e-02f, -6.74813390e-02f, 5.55861741e-02f, -1.13028571e-01f, 1.38115129e-02f, 6.68996796e-02f, -8.82944930e-03f, -6.76911026e-02f,
  2.74660997e-02f, 9.30400752e-03f, 1.13364840e-02f, -5.81117608e-02f, 6.92299977e-02f, 2.91971583e-02f, 6.91490099e-02f, 5.89668751e-02f, 1.32905200e-01f, 1.19437389e-02f,
  4.41421643e-02f, -7.78562799e-02f, -7.85223320e-02f, 1.64253693e-02f, 8.44533816e-02f, 7.64014572e-02f, -1.55399821e-03f, -2.59534176e-02f, -7.17725307e-02f, 4.39338051e-02f,
  8.38570967e-02f, -9.17826965e-02f, -1.50102928e-01f, -1.80320010e-01f, 1.84128761e-01f, 3.14572570e-03f, -1.27728969e-01f, -6.69869855e-02f, -1.20975733e-01f, -3.68246175e-02f,
  8.64732042e-02f, -1.10734463e-01f, -5.22123054e-02f, -1.73223034e-01f, -1.36271760e-01f, -8.28539953e-02f, -2.21226826e-01f, -1.44602165e-01f, -3.48459072e-02f, 1.07087689e-02f,
  -3.01938597e-02f, 8.35257992e-02f, -6.29935488e-02f, 1.52871192e-01f, 7.87152424e-02f, 4.52448465e-02f, 1.25310361e-01f, 1.55341001e-02f, 3.11472472e-02f, 6.49039298e-02f,
  -5.48209772e-02f, -1.54955331e-02f, -7.79025117e-03f, -1.24824187e-02f, -4.36979234e-02f, 4.51193638e-02f, 8.27945396e-02f, 9.31743234e-02f, -4.36709858e-02f, -1.93953719e-02f,
  3.69565450e-02f, -5.87745896e-03f, 7.77785992e-03f, 5.83159737e-02f, 1.64397724e-03f, -5.42716570e-02f, -6.10316992e-02f, -6.20367005e-02f, -1.18079096e-01f, -8.98126662e-02f,
  -1.08796366e-01f, -7.05468208e-02f, -7.13643283e-02f, -7.77933300e-02f, -1.00168310e-01f, -1.73618328e-02f, -1.30362079e-01f, -5.60794398e-02f, -5.57753183e-02f, -4.04036269e-02f,
  -4.66721095e-02f, -1.44612137e-03f, 2.80495286e-02f, 3.52304541e-02f, 5.89172952e-02f, -1.56337917e-02f, 7.33836293e-02f, -2.93047894e-02f, 1.11464895e-02f, 3.46010625e-02f,
  -1.87098328e-02f, 5.70007786e-03f, -4.25435528e-02f, -8.32051486e-02f, 2.78047491e-02f, 1.57924872e-02f, -1.41736986e-02f, -3.78081203e-02f, 6.56917575e-04f, 8.74706823e-03f,
  2.00918168e-02f, 7.21214339e-03f, 5.18725859e-03f, -2.54711392e-03f, 8.08591545e-02f, -5.73663646e-03f, -2.08579060e-02f, 4.61731404e-02f, 4.97555733e-02f, 6.32763430e-02f,
  -4.70744856e-02f, -8.22911561e-02f, 4.10957858e-02f, 4.93457243e-02f, 6.49335235e-03f, 3.05753965e-02f, 4.33685780e-02f, -9.28332880e-02f, -6.55483827e-02f, -4.79189120e-02f,
  -3.05516031e-02f, 4.81948592e-02f, -8.24455321e-02f, 3.09721399e-02f, 1.72691904e-02f, 4.23523560e-02f, -1.60637442e-02f, 3.33143771e-02f, 5.60272448e-02f, -5.17880172e-03f,
  9.82272625e-02f, 8.04006606e-02f, 1.97333936e-02f, 3.67234787e-03f, 3.40838684e-03f, 2.52404809e-02f, 4.21748795e-02f, 1.13023156e-02f, 6.06573187e-02f, -5.37850298e-02f,
  -1.14132375e-01f, 8.42960458e-03f, 3.77776884e-02f, -6.99622482e-02f, -1.31653706e-02f, -4.84805964e-02f, -1.64538085e-01f, 4.82770130e-02f, -6.64537326e-02f, 7.74645656e-02f,
  -1.01740370e-02f, -9.92719457e-02f, -2.86004916e-02f, 1.14368305e-01f, -1.62273228e-01f, -4.80201393e-02f, 5.68284653e-02f, 4.93560173e-02f, 9.71413702e-02f, 8.90409052e-02f,
  3.87339592e-02f, 1.03499427e-01f, 1.21052243e-01f, 1.82370558e-01f, 1.21200457e-03f, 8.76239687e-02f, 1.01760618e-01f, 9.51531902e-02f, 4.11882177e-02f, -6.05548918e-02f,
  -2.55268812e-02f, 2.39444282e-02f, -3.16415243e-02f, 6.86299242e-03f, 4.78332490e-02f, -2.11212449e-02f, 1.18997963e-02f, 1.86265931e-02f, -5.70879318e-02f, 3.65793556e-02f,
  2.22977977e-02f, -6.48196787e-02f, 5.31323031e-02f, -5.46661317e-02f, -4.38814275e-02f, -3.52279544e-02f, 7.89882019e-02f, 4.82022129e-02f, -5.53357974e-02f, 5.96727915e-02f,
  -5.68864634e-03f, -5.70169091e-02f, -6.68937946e-03f, -2.79834922e-02f, -5.64272888e-02f, -8.53819251e-02f, 9.64903459e-03f, -2.28153951e-02f, -7.83511251e-02f, 6.17865585e-02f,
  -1.44350259e-02f, -2.42237672e-02f, 3.85343917e-02f, 4.66947667e-02f, -6.10379875e-02f, -4.25509624e-02f, 3.29312645e-02f, -4.47656550e-02f, -3.90354842e-02f, -5.23958094e-02f,
  3.80812362e-02f, -5.46930358e-02f, -5.63281290e-02f, -5.88144995e-02f, -4.54204790e-02f, -5.90368398e-02f, -3.42729129e-02f, -3.21802124e-03f, 4.97614732e-03f, 9.45558324e-02f,
  -7.51059353e-02f, -4.19053473e-02f, 9.76361856e-02f, -5.24619184e-02f, 6.52569979e-02f, -7.55957887e-02f, 3.40166874e-02f, -7.19084963e-02f, -3.33391279e-02f, 7.38098845e-02f,
  3.58029008e-02f, -3.26382816e-02f, -2.51986459e-02f, 3.79799381e-02f, -6.38452545e-02f, 1.50618991e-02f, 2.12002676e-02f, -2.37774421e-02f, -7.49078840e-02f, -8.42289999e-02f,
  6.93570450e-02f, 4.19792086e-02f, -1.05035016e-02f, 4.87188622e-02f, 5.27693629e-02f, -3.85909192e-02f, -1.44253056e-02f, -4.84548733e-02f, 1.75507292e-02f, 9.46707055e-02f,
  2.85466071e-02f, 5.03705703e-02f, -7.97203481e-02f, 7.47499242e-02f, -4.61941995e-02f, -1.34093175e-02f, -4.66388687e-02f, -1.33536002e-02f, 8.19491297e-02f, -6.86449260e-02f,
  -1.45901591e-01f, 1.68441281e-01f, 1.70993194e-01f, 1.05599612e-01f, 4.06353623e-02f, -1.32239625e-01f, -1.20224662e-01f, 1.61539435e-01f, -7.90802613e-02f, 3.84264216e-02f,
  5.66085130e-02f, -1.60754904e-01f, 4.59307283e-02f, 9.54864472e-02f, -2.02156782e-01f, -5.89852184e-02f, -2.85278186e-02f, -1.73224926e-01f, 4.65108454e-02f, 1.21469066e-01f,
  1.07421421e-01f, 8.52870047e-02f, 2.10855350e-01f, 7.47328177e-02f, 8.35394114e-02f, 1.42048284e-01f, 1.47517115e-01f, 7.89022446e-02f, 8.53181630e-02f, -1.45015437e-02f,
  -1.01707742e-01f, 3.22597064e-02f, 4.30356190e-02f, 2.60467511e-02f, 3.70217972e-02f, 4.74329628e-02f, -5.28485961e-02f, -7.90107846e-02f, 1.48101561e-02f, 3.17218006e-02f,
  -1.85119156e-02f, 8.13436434e-02f, -1.05324229e-02f, -2.87932567e-02f, 5.72812371e-02f, 1.08171329e-01f, 7.15554655e-02f, 4.42129932e-02f, 6.37677684e-02f, -1.28458468e-02f,
  1.16197132e-01f, 2.14537419e-03f, 3.20128798e-02f, -3.00135296e-02f, 5.37406169e-02f, 3.29878516e-02f, -4.65385914e-02f, 2.96099465e-02f, -4.13535386e-02f, -9.64568555e-03f,
  -3.81099246e-02f, -5.91460895e-03f, 1.77041143e-02f, -1.55609194e-02f, 2.32702792e-02f, -5.05557423e-03f, -1.97052527e-02f, -4.78189699e-02f, 3.02417949e-02f, -2.29712520e-02f,
  5.13440743e-02f, 6.39771968e-02f, 2.47255564e-02f, 2.73909308e-02f, 1.40948370e-02f, 4.77088522e-03f, -7.19167292e-02f, -3.18962075e-02f, 2.39419639e-02f, 3.90888751e-02f,
  3.02920677e-03f, 4.44956198e-02f, -1.28309960e-02f, 1.36684040e-02f, -4.70461026e-02f, 3.64628695e-02f, 2.39421092e-02f, 6.36057779e-02f, -3.17921154e-02f, -4.44341563e-02f,
  -8.59401673e-02f, 4.85547371e-02f, 4.19966085e-03f, -2.34048609e-02f, -4.83324230e-02f, -2.47680563e-02f, -5.31207733e-02f, -2.87149772e-02f, 1.12650089e-03f, 1.48435438e-03f,
  3.16874310e-02f, -2.92438585e-02f, -3.45662385e-02f, -1.82665084e-02f, -5.52805737e-02f, 2.15811282e-02f, 2.72942018e-02f, -6.29469519e-03f, 4.22908086e-03f, 6.09246232e-02f,
  6.43718764e-02f, 3.14874500e-02f, 2.47401628e-03f, 7.37616047e-02f, 2.97345072e-02f, -1.54215833e-02f, -1.18374871e-02f, -6.36488348e-02f, 1.43329557e-02f, 4.55846824e-02f,
  -1.66043341e-01f, 2.63908178e-01f, 7.63933659e-02f, -1.76124319e-01f, -1.04399800e-01f, 2.31199935e-02f, -1.41373530e-01f, 1.03107937e-01f, -2.03400925e-01f, 1.28589645e-01f,
  -5.09738140e-02f, 6.10369481e-02f, 2.04404503e-01f, -1.04833871e-01f, -1.14520200e-01f, 7.82859102e-02f, -2.25825179e-02f, 1.20078195e-02f, 2.93218810e-02f, 8.44175220e-02f,
  -1.01587638e-01f, 1.71819683e-02f, 7.01578408e-02f, -1.87288027e-03f, 2.18501855e-02f, -9.53469984e-03f, 4.60200012e-02f, 3.32617387e-02f, 2.26611998e-02f, 1.16604287e-02f,
  -1.08065590e-01f, -7.15573132e-03f, -5.48395142e-02f, -7.27875754e-02f, 1.44244470e-02f, 3.90812233e-02f, -5.85817965e-03f, 3.31302360e-02f, -6.62233159e-02f, 6.48463741e-02f,
  -1.51645150e-02f, 3.73789035e-02f, -7.08318576e-02f, 3.00757699e-02f, 6.15146896e-03f, -2.36657560e-02f, 6.52163709e-03f, 4.00508605e-02f, -5.24475239e-02f, -2.84069069e-02f,
  6.59169480e-02f, -2.72950213e-02f, -2.79713813e-02f, -3.77015434e-02f, -8.49592462e-02f, 4.01276313e-02f, -6.32237270e-02f, -9.31855757e-03f, 5.69791794e-02f, -5.31770512e-02f,
  5.60470633e-02f, 7.66403088e-03f, 6.39111153e-04f, -3.42506841e-02f, -1.01198582e-02f, 1.91962589e-02f, -2.97240354e-02f, -5.06098084e-02f, -5.75372837e-02f, 5.96470311e-02f,
  -3.14612500e-02f, -4.43645716e-02f, -2.30876300e-02f, 1.88476630e-02f, 6.26563206e-02f, -5.14357127e-02f, -2.43476573e-02f, 1.95367238e-03f, 3.24758850e-02f, 4.35806774e-02f,
  3.39341424e-02f, -1.23251434e-02f, -1.80903263e-02f, -3.11868247e-02f, 7.02582523e-02f, 2.60780286e-02f, 5.20893969e-02f, 7.26674348e-02f, 1.20508261e-02f, -8.69529694e-03f,
  4.95595038e-02f, 2.46250406e-01f, 1.22474777e-02f, 6.97337613e-02f, 5.90949617e-02f, 2.73214467e-02f, -1.40320212e-02f, -5.87186478e-02f, -1.32366344e-02f, -5.34666479e-02f,
  -2.91185826e-02f, -1.15003483e-02f, 1.57752428e-02f, 2.65479200e-02f, 2.25356817e-02f, 3.18094669e-03f, -1.43178087e-02f, 8.54203384e-03f, 6.76784813e-02f, 5.40637225e-02f,
  -1.99652147e-02f, -1.54357804e-02f, 1.26145361e-02f, -1.27949333e-02f, 6.89643696e-02f, -2.08765268e-03f, -5.04032522e-02f, 1.48425130e-02f, -1.36643881e-03f, -1.14378752e-03f,
  2.86549091e-01f, 1.25834033e-01f, -3.34698670e-02f, 1.99851319e-01f, 6.40576854e-02f, 5.87246642e-02f, 1.90210968e-01f, 2.64712833e-02f, 9.73040611e-02f, 3.67316417e-02f,
  1.61016490e-02f, 3.40550095e-02f, -1.24454662e-01f, 1.44999892e-01f, 5.96152432e-02f, -7.19173998e-02f, 1.82646960e-01f, 1.54554501e-01f, 9.12544318e-03f, 1.17482044e-01f,
  8.74002930e-03f, 1.09295361e-01f, -1.04692183e-01f, -1.05005771e-01f, 1.47589192e-01f, -5.53464852e-02f, -3.66192907e-02f, -1.22764289e-01f, 4.40140851e-02f, -3.69327106e-02f,
  1.53629750e-01f, -3.70819382e-02f, 8.33625942e-02f, 4.61494783e-03f, 6.48487136e-02f, 3.01074293e-02f, 5.25334403e-02f, -4.08570431e-02f, -6.95557566e-04f, 2.37231366e-02f,
  2.32155602e-02f, 4.54562232e-02f, 5.06993160e-02f, -6.06057011e-02f, 5.37564978e-02f, -6.73580691e-02f, -7.65619576e-02f, 9.52158272e-02f, -7.69038964e-03f, -5.15262447e-02f,
  2.63886228e-02f, 4.61809279e-04f, 5.08953407e-02f, -1.62894446e-02f, -2.48111598e-02f, 3.86831798e-02f, 1.52344070e-02f, -2.14530714e-02f, -9.62719880e-03f, 8.16022083e-02f,
  -1.32595062e-01f, 6.22279309e-02f, 1.01240203e-02f, 7.73671083e-03f, 4.77625839e-02f, -1.56107210e-02f, 6.97226673e-02f, 1.84038132e-02f, 1.80844944e-02f, 1.84020959e-02f,
  1.07642509e-01f, 3.23578306e-02f, -6.46811724e-02f, -3.94555107e-02f, 3.77277359e-02f, 3.30289565e-02f, 4.99988683e-02f, 6.73758015e-02f, 1.44560328e-02f, 1.96001343e-02f,
  -1.72281880e-02f, -7.16202240e-03f, -4.53008451e-02f, 3.29166390e-02f, -4.17931862e-02f, -1.06684610e-01f, 2.84162704e-02f, 7.15255737e-02f, -6.81224614e-02f, -4.52209860e-02f,
  2.32447222e-01f, 9.47994888e-02f, 9.02625266e-03f, 3.92972976e-02f, 1.20438961e-02f, 1.48011874e-02f, -1.60865765e-02f, -4.45699207e-02f, 7.86711574e-02f, -1.50984311e-02f,
  -5.91315590e-02f, -4.28834222e-02f, 3.54865976e-02f, 2.07885001e-02f, -6.94602132e-02f, 7.06428811e-02f, 2.55887080e-02f, -1.03429453e-02f, 7.72590861e-02f, 4.77259569e-02f,
  -2.67044753e-02f, 2.25664172e-02f, 5.67338802e-03f, -5.38566113e-02f, 5.22709340e-02f, 1.75635947e-03f, 2.66536623e-02f, -5.82010336e-02f, -4.39496106e-03f, 4.12490591e-02f,
  -1.57846600e-01f, 6.46075830e-02f, -1.70942709e-01f, -5.80267534e-02f, 7.31733814e-02f, 1.16200164e-01f, 8.86146277e-02f, -7.81571399e-03f, 4.26182151e-02f, 6.74398690e-02f,
  3.04926671e-02f, -8.94491673e-02f, -1.25427336e-01f, 9.17530134e-02f, -2.09428608e-01f, 3.61418203e-02f, 6.78368360e-02f, 6.51907399e-02f, 1.62849464e-02f, -7.35546499e-02f,
  8.82474612e-03f, 7.50055015e-02f, -1.73123673e-01f, 9.53486655e-03f, 7.05648065e-02f, 8.90515372e-03f, -1.32165208e-01f, -1.57380980e-02f, 2.94788387e-02f, -3.68505567e-02f,
  -3.76014002e-02f, -1.18264563e-01f, -9.60900784e-02f, -5.00885621e-02f, -1.28723338e-01f, -1.08975256e-02f, -6.48051947e-02f, -1.96406264e-02f, -7.20472028e-03f, -7.44956657e-02f,
  -8.16216618e-02f, 7.42548183e-02f, -9.53319599e-04f, 3.28827053e-02f, -5.14929667e-02f, -4.41397093e-02f, 2.08624620e-02f, 4.82599884e-02f, -2.80719958e-02f, -7.93845654e-02f,
  6.83571696e-02f, 6.92026764e-02f, 7.03112632e-02f, 9.16857868e-02f, -7.81633705e-02f, 1.07579358e-01f, 4.82772663e-02f, 4.48786281e-02f, -2.58210991e-02f, 2.72203665e-02f,
  4.18519229e-02f, -1.78117082e-02f, -3.97013202e-02f, 4.45751920e-02f, 4.09822389e-02f, -2.74047069e-02f, -2.54155323e-02f, 5.72652668e-02f, -4.07168083e-02f, 3.83436158e-02f,
  -1.09933149e-02f, 6.01044521e-02f, 6.88794777e-02f, -2.43813209e-02f, -1.30592799e-03f, -2.23701168e-02f, -8.93082395e-02f, -5.94159514e-02f, 3.94619070e-02f, -5.48046492e-02f,
  2.08464712e-02f, -3.26682478e-02f, 6.97496682e-02f, -1.75400137e-03f, -3.49284783e-02f, 3.62372361e-02f, 6.74030557e-02f, 4.80326153e-02f, 4.29134928e-02f, -6.96369857e-02f,
  -5.75317768e-03f, -1.26752809e-01f, 5.72351478e-02f, 6.77750399e-03f, -5.55883460e-02f, -1.43769821e-02f, -9.19322446e-02f, 1.52772767e-02f, 3.94785851e-02f, 5.87723404e-02f,
  -1.00419246e-01f, -6.51101843e-02f, 5.22584515e-03f, 6.04743417e-03f, 3.45664844e-02f, 6.37693405e-02f, -4.57530059e-02f, -2.10458580e-02f, 2.48556416e-02f, -7.59932324e-02f,
  -2.03679744e-02f, 6.77176192e-02f, 6.56288639e-02f, 5.52505068e-02f, 2.69124843e-02f, -6.78263456e-02f, -4.40150537e-02f, -5.15515171e-02f, -6.13403246e-02f, -7.52032921e-02f,
  1.49164483e-01f, -9.68228385e-04f, -7.97243044e-02f, 3.89648676e-02f, -2.85128430e-02f, -2.55293306e-02f, 8.62878114e-02f, -9.82145593e-03f, -5.68221733e-02f, 4.45808843e-02f,
  7.48319924e-03f, 6.87424764e-02f, -6.15441315e-02f, 1.14976786e-01f, -2.24432293e-02f, 3.49517539e-02f, 1.83424070e-01f, 1.15957804e-01f, -4.90207896e-02f, 9.28648338e-02f,
  -9.38242748e-02f, -1.74752511e-02f, -4.02366370e-02f, -9.31958258e-02f, -1.02262206e-01f, -1.08511426e-01f, 1.71564221e-02f, -1.48232564e-01f, 6.50992617e-02f, -6.73851967e-02f,
  4.58083451e-02f, -9.05387625e-02f, -8.56015235e-02f, 4.42924770e-03f, 2.42236108e-02f, -2.50179581e-02f, 7.96881765e-02f, 2.98099704e-02f, -1.28302246e-03f, 6.07975461e-02f,
  6.04819655e-02f, 1.06960190e-02f, -5.68572879e-02f, -7.38690495e-02f, 7.58829042e-02f, -7.47667998e-02f, -8.25871155e-02f, 9.57554486e-03f, -6.66419715e-02f, -7.06876144e-02f,
  4.25968282e-02f, 1.04240038e-01f, 5.67913912e-02f, 5.91363050e-02f, -1.91438524e-03f, -6.48577064e-02f, -3.07728034e-02f, 1.60307381e-02f, 2.94226268e-03f, -3.25005352e-02f,
  -1.61911342e-02f, 2.56768502e-02f, 2.55389661e-02f, 7.01015070e-02f, 2.35251896e-02f, 5.11587299e-02f, -6.11996055e-02f, -6.65897578e-02f, -3.40988375e-02f, -5.08933552e-02f,
  2.65869554e-02f, -6.14278130e-02f, -2.86692642e-02f, 9.05584618e-02f, 6.63019344e-02f, 2.35668141e-02f, 8.19370151e-02f, 6.14254922e-02f, 2.95093860e-02f, -3.08108795e-02f,
  -1.53835779e-02f, 6.28585964e-02f, -3.30091156e-02f, 1.16107538e-02f, 3.37259620e-02f, 1.32588036e-02f, 5.87245375e-02f, -4.62048799e-02f, 7.57687306e-03f, 1.16804177e-02f,
  -2.47176290e-02f, 1.30886929e-02f, 5.70161380e-02f, -4.25487459e-02f, -2.99000815e-02f, 6.04906864e-02f, -4.18797918e-02f, -5.10332510e-02f, -9.52049345e-03f, -7.95492008e-02f,
  5.92332333e-02f, 3.20087411e-02f, 3.56087275e-02f, 5.85814565e-02f, 3.13900113e-02f, -5.70531152e-02f, 8.42475593e-02f, 6.35892758e-03f, 6.62854388e-02f, 1.56953558e-02f,
  8.10694396e-02f, 3.25137302e-02f, 6.65436536e-02f, -5.79012334e-02f, 3.36541701e-03f, -4.08473611e-02f, -2.74510421e-02f, 4.71853912e-02f, 6.24822266e-02f, -1.48139736e-02f,
  8.70650075e-03f, -1.23106480e-01f, -2.68999010e-01f, 1.47775132e-02f, 1.40817076e-01f, 6.58252463e-02f, -8.25212523e-03f, 2.37187836e-02f, -1.42168269e-01f, 1.42499700e-01f,
  1.80570960e-01f, -2.44397849e-01f, 6.16987869e-02f, 1.15037113e-01f, -4.95489016e-02f, -7.10517867e-03f, 9.44592357e-02f, -4.00509164e-02f, -1.51711047e-01f, 3.26464958e-02f,
  4.04343978e-02f, 2.46813074e-01f, -1.13185204e-03f, 7.93590918e-02f, 4.13856916e-02f, 4.62105051e-02f, 2.34223783e-01f, -5.14621809e-02f, 3.25742774e-02f, -8.41252804e-02f,
  -5.63946404e-02f, -8.43626112e-02f, -1.10095059e-02f, -1.05309196e-01f, 4.64992337e-02f, -4.79785092e-02f, 4.68186736e-02f, -3.34969014e-02f, -9.58212912e-02f, 3.78559865e-02f,
  6.10604435e-02f, 4.06694561e-02f, 4.36976850e-02f, -2.04375852e-02f, -2.91051324e-02f, 2.18345262e-02f, 1.09438854e-03f, -4.80870232e-02f, -1.12872340e-01f, -5.35346288e-03f,
  -1.23453796e-01f, -7.96274915e-02f, 3.78214270e-02f, 2.84522027e-02f, -7.86357820e-02f, 5.34421066e-03f, -5.66805601e-02f, -1.53871812e-02f, 1.84074026e-02f, -1.20209968e-02f,
  -1.86011067e-03f, 1.02354065e-02f, 1.22881113e-02f, -6.51451051e-02f, -3.93033475e-02f, -2.33498365e-02f, 3.55712778e-04f, 6.59528673e-02f, -5.32195866e-02f, -1.58248898e-02f,
  6.11209832e-02f, -7.77475089e-02f, 1.59779899e-02f, -8.23579803e-02f, 5.54537065e-02f, -4.98664603e-02f, -4.48843725e-02f, -7.37873614e-02f, 6.46504089e-02f, -3.84035185e-02f,
  6.02284707e-02f, 3.33979949e-02f, -5.16555384e-02f, 3.94881666e-02f, -9.37727932e-03f, -2.49797609e-02f, 7.07899928e-02f, -3.74258496e-02f, -3.66966352e-02f, 4.10884023e-02f,
  6.41203076e-02f, 1.84605226e-01f, -5.29523343e-02f, -7.86176790e-03f, -1.09488955e-02f, 8.80723670e-02f, -6.45055547e-02f, 3.12008150e-02f, -4.24895696e-02f, 4.98712920e-02f,
  -1.85431242e-02f, 3.52709815e-02f, 4.31089178e-02f, 3.13603133e-02f, -5.02714962e-02f, -2.82715075e-02f, -2.72456389e-02f, 8.87532756e-02f, 8.58483315e-02f, -2.95231324e-02f,
  7.27551952e-02f, -1.36294179e-02f, -4.23390456e-02f, 1.58544369e-02f, 1.75563041e-02f, 2.52407454e-02f, 7.88592920e-02f, -5.42919561e-02f, 4.04879600e-02f, -6.06987160e-03f,
  6.14237785e-02f, -7.17194602e-02f, 2.25146428e-01f, -7.34006381e-03f, 1.24567211e-01f, 5.58835939e-02f, 2.09503889e-01f, -6.11238256e-02f, 9.77052450e-02f, -3.92928012e-02f,
  -1.18579850e-01f, -8.73029977e-02f, 1.15179390e-01f, -2.63569713e-01f, 1.21333078e-01f, 5.16676307e-02f, -8.67884979e-02f, -9.65824500e-02f, -4.36058864e-02f, -7.79597238e-02f,
  -7.20442608e-02f, -1.03670374e-01f, -1.59240961e-01f, -1.60884634e-01f, -1.15350828e-01f, 1.18614035e-02f, -6.75517470e-02f, -2.23642103e-02f, -1.30257368e-01f, -9.33546051e-02f,
  2.26880498e-02f, -5.51575311e-02f, 1.26703903e-02f, 9.98893678e-02f, -2.67450362e-02f, 3.22256908e-02f, 9.76472497e-02f, 3.74911502e-02f, 1.22260815e-02f, -3.51204313e-02f,
  6.68271035e-02f, -5.74058332e-02f, -6.62853867e-02f, -2.35638022e-02f, 1.61500685e-02f, -4.51020263e-02f, -1.70980638e-03f, -3.88998687e-02f, -1.05128633e-02f, 3.57024670e-02f,
  5.42553104e-02f, -5.05936779e-02f, 7.16438890e-02f, -7.32180700e-02f, 3.93183492e-02f, 4.29132096e-02f, 3.57646532e-02f, 2.75615975e-02f, -1.68302935e-02f, -8.24868008e-02f,
  -2.24109348e-02f, 3.98716666e-02f, -3.65364226e-03f, -5.67225330e-02f, 5.64319827e-02f, -6.63682818e-02f, -7.83480108e-02f, 3.43894139e-02f, 5.51368184e-02f, 4.48046885e-02f,
  9.31390747e-03f, 2.97409575e-02f, 5.94553500e-02f, 1.89644354e-03f, -2.66573876e-02f, 5.53844236e-02f, -2.59433612e-02f, -3.13024386e-03f, 7.99792930e-02f, -5.51910251e-02f,
  -3.22746634e-02f, 3.20967808e-02f, -3.96589525e-02f, 1.09471772e-02f, -4.29483727e-02f, 4.29071300e-02f, 1.29353311e-02f, -3.28097260e-03f, 1.88669730e-02f, 7.77404383e-02f,
  -3.88868600e-02f, -1.06470205e-01f, 1.75575539e-02f, -8.65516141e-02f, 7.88355097e-02f, 4.78421450e-02f, -9.87884700e-02f, -5.29061188e-04f, -1.13480221e-02f, 1.94573291e-02f,
  5.64001054e-02f, -1.56347640e-02f, -5.94789803e-04f, -7.91090727e-02f, 1.87302865e-02f, 9.93120763e-03f, -4.34753746e-02f, 4.55228263e-04f, 1.58228818e-02f, -4.60549481e-02f,
  5.04476391e-02f, 3.96524519e-02f, 1.80248190e-02f, 8.14784169e-02f, -5.48454970e-02f, -2.57444149e-03f, 6.53019100e-02f, -2.58553587e-02f, -3.39874998e-02f, -3.74294072e-03f,
  -3.58513147e-02f, -1.12512195e-03f, -3.48248966e-02f, -9.08715576e-02f, -1.70498211e-02f, 2.19535232e-02f, 1.47945164e-02f, -1.70724437e-01f, -1.29074588e-01f, 1.45266071e-01f,
  -4.86240201e-02f, 1.69193968e-01f, 8.50748867e-02f, -3.60499024e-02f, -5.10990992e-02f, 8.23238678e-03f, -8.31672549e-02f, -5.80874532e-02f, -8.01060945e-02f, -1.36720955e-01f,
  -1.50102586e-01f, -1.69581957e-02f, -4.05053608e-02f, -1.52960837e-01f, -5.59372641e-02f, 4.34070267e-02f, 1.05634667e-01f, 7.84348100e-02f, -8.20930526e-02f, -2.96017975e-02f,
  -4.16425467e-02f, -5.83481602e-02f, -7.77517110e-02f, -6.37582913e-02f, -5.11815958e-02f, -7.93126002e-02f, 4.46739560e-03f, 7.71338940e-02f, -1.43568395e-02f, 6.48549199e-02f,
  -1.32876970e-02f, -2.77177319e-02f, 2.17898134e-02f, -5.18925227e-02f, -4.86880951e-02f, -6.54711649e-02f, -2.20370889e-02f, -9.75641534e-02f, -2.71787532e-02f, -5.80082387e-02f,
  1.50317512e-02f, 6.84079230e-02f, 3.00917029e-02f, 1.03195399e-01f, -2.39488874e-02f, -1.12382853e-02f, 2.76933629e-02f, 1.13029890e-01f, 6.44925237e-03f, -2.95756143e-02f,
  -3.05152480e-02f, -4.54451330e-02f, 5.44711910e-02f, -2.11734585e-02f, -5.43475747e-02f, -2.51510777e-02f, -5.91554493e-02f, -7.00022504e-02f, 7.74422884e-02f, -3.14109884e-02f,
  -8.52049328e-03f, -5.45124672e-02f, -3.46443281e-02f, -4.36354131e-02f, 6.35835482e-03f, 2.47041471e-02f, -5.28185964e-02f, 3.16705666e-02f, -2.66625430e-03f, 2.11685747e-02f,
  5.50077818e-02f, -3.13696638e-02f, -4.72729765e-02f, -4.07490544e-02f, -5.78706227e-02f, -2.70650815e-02f, -1.43182045e-02f, 2.43628900e-02f, -7.54745230e-02f, 4.43900228e-02f,
  -2.61318292e-02f, 5.57445027e-02f, -5.88560626e-02f, 5.74152172e-02f, -1.53748924e-02f, 5.21875620e-02f, 4.53322865e-02f, -2.48079151e-02f, 7.19987415e-03f, -6.25785515e-02f,
  8.95652082e-03f, 4.30498570e-02f, 8.32509324e-02f, 6.33779019e-02f, -5.61319552e-02f, -7.64527470e-02f, 1.17010795e-01f, 8.27060863e-02f, -1.31211309e-02f, 4.82744128e-02f,
  9.32332277e-02f, 2.89023723e-02f, 7.38663971e-02f, 2.11431552e-03f, -5.21357022e-02f, 6.42460510e-02f, -2.98667345e-02f, -1.95576251e-02f, -6.57270402e-02f, 6.30224422e-02f,
  1.57837451e-01f, 4.45353389e-02f, 2.58190781e-01f, 2.05272049e-01f, -2.75336336e-02f, 1.40699252e-01f, 7.93498904e-02f, 1.40358359e-01f, 2.94242173e-01f, -1.61419690e-01f,
  -1.14179976e-01f, 5.58330230e-02f, -9.06584188e-02f, -5.67981713e-02f, -7.93925598e-02f, 1.15101561e-02f, 6.53429190e-03f, 4.47457694e-02f, 1.67483121e-01f, 3.88381281e-03f,
  7.72155970e-02f, -1.09567650e-01f, 7.94342309e-02f, -1.69097409e-01f, 7.25054219e-02f, 1.41041260e-02f, -2.35902220e-01f, 1.49392430e-02f, -9.31700841e-02f, -1.33264426e-03f,
  1.82304550e-02f, 8.45354423e-02f, 1.20504657e-02f, -6.45358209e-03f, 4.83701341e-02f, 1.40899168e-02f, -5.11474907e-02f, 9.11001023e-03f, 1.07397944e-01f, -7.94223137e-03f,
  -7.19634220e-02f, -5.91960251e-02f, 2.69459058e-02f, 3.45328487e-02f, 3.06828488e-02f, 8.61666724e-03f, 8.77374634e-02f, 7.86411539e-02f, 6.09503686e-02f, 2.01109461e-02f,
  1.04383141e-01f, 6.27500340e-02f, 2.87247095e-02f, 1.39633408e-02f, -3.88484113e-02f, -1.57860611e-02f, -1.36823338e-02f, 5.39749153e-02f, 4.70715612e-02f, 8.25368334e-03f,
  3.85535927e-03f, 8.61636922e-02f, 5.24163432e-02f, 8.16225447e-03f, 2.84070577e-02f, 1.13481460e-02f, -4.83951159e-02f, 3.89127359e-02f, 7.77255148e-02f, -2.90546287e-02f,
  -6.94129169e-02f, -1.94751266e-02f, -2.11559348e-02f, 7.44969621e-02f, -2.10584775e-02f, -9.78561491e-03f, -1.64911486e-02f, 2.23118719e-02f, 6.10373355e-02f, -3.86425145e-02f,
  -2.96985917e-02f, -3.00267879e-02f, 1.00680040e-02f, 6.06039688e-02f, 8.04246888e-02f, -8.71873498e-02f, -1.21497270e-02f, 2.82055624e-02f, -3.97132188e-02f, -5.23572601e-02f,
  -3.26355849e-03f, -8.39580745e-02f, -4.87794094e-02f, -3.05966269e-02f, 4.98116873e-02f, -4.76301946e-02f, 1.18866814e-02f, -1.80656482e-02f, -6.49597272e-02f, -2.13053869e-03f,
  -3.61923920e-03f, -1.99771468e-02f, -3.42935510e-02f, 5.45773730e-02f, 4.74909693e-03f, -2.53822794e-03f, 1.05066802e-02f, -7.96380192e-02f, -3.16796526e-02f, -8.13660324e-02f,
  -4.68851738e-02f, -6.06100122e-03f, -5.92571385e-02f, -7.32871816e-02f, -8.99443105e-02f, 5.38084190e-03f, -2.40459107e-02f, 1.04847678e-03f, 2.88087260e-02f, 1.85836088e-02f,
  2.56390810e-01f, -6.28797244e-03f, 1.97160110e-01f, 1.56318933e-01f, 1.21069681e-02f, 6.48407415e-02f, 1.25277132e-01f, -1.64422859e-03f, 9.90843475e-02f, -2.30943635e-01f,
  -1.73353299e-03f, 8.61883461e-02f, -1.33778661e-01f, -8.26315358e-02f, 1.78778782e-01f, -1.61140382e-01f, -4.23799641e-02f, 2.74475515e-02f, -8.58191550e-02f, -1.21238362e-02f,
  -2.14428781e-03f, -1.91064671e-01f, 4.90936637e-02f, -1.27416715e-01f, 1.27178594e-01f, 9.44840088e-02f, -1.20257661e-01f, -4.46914899e-04f, 4.93135899e-02f, -6.53083771e-02f,
  1.08675212e-02f, -8.51635262e-02f, 4.06890064e-02f, 5.17184883e-02f, 2.37199776e-02f, 7.27657555e-03f, 7.81153888e-02f, 4.67327572e-02f, -3.98153849e-02f, 2.79268026e-02f,
  -4.76490706e-03f, 3.17095518e-02f, 2.20329948e-02f, 1.41003076e-02f, 2.21793782e-02f, 5.77394888e-02f, 4.03891280e-02f, 8.05158168e-02f, -4.27501947e-02f, 5.01092039e-02f,
  4.13140133e-02f, 4.76293080e-02f, -2.88153403e-02f, 3.98376770e-03f, 1.61051657e-02f, 1.77463423e-02f, 3.39310579e-02f, -7.96593633e-03f, 6.43014982e-02f, 4.93604019e-02f,
  1.95158049e-02f, 3.74082215e-02f, 6.62652217e-03f, 4.78611924e-02f, 5.03436709e-03f, -9.01685748e-03f, -1.93745899e-03f, -3.39969359e-02f, 1.39587531e-02f, -2.33446974e-02f,
  -2.98088081e-02f, -1.21413835e-03f, 3.93135846e-02f, -1.56527832e-02f, -1.61694791e-02f, -3.35999206e-02f, 3.60458787e-03f, -9.03424807e-03f, 6.52956814e-02f, 1.59751475e-02f,
  2.82398742e-02f, 3.90351936e-02f, -1.14478571e-02f, -4.62586507e-02f, 4.17832956e-02f, -3.63446921e-02f, -5.70337474e-02f, -8.31224490e-03f, -1.15777384e-02f, -4.40821350e-02f,
  -9.51756164e-02f, -3.72614972e-02f, -2.08012741e-02f, 2.90971640e-02f, -5.58775701e-02f, 1.19687133e-02f, 4.71312441e-02f, 1.79699957e-02f, 3.66738327e-02f, -8.49895552e-02f,
  -3.73402312e-02f, 3.61850150e-02f, 4.18632776e-02f, 3.40796188e-02f, 3.17277126e-02f, 2.11516232e-03f, 1.53716579e-02f, 1.16980253e-02f, -2.42255232e-03f, -2.32887883e-02f,
  2.11445317e-02f, -8.43228027e-02f, 6.90597445e-02f, 3.85634638e-02f, -2.94354055e-02f, -5.47172427e-02f, 5.84849752e-02f, 9.32730138e-02f, -4.31948826e-02f, -1.54582951e-02f,
  -2.97252089e-01f, 3.52584086e-02f, -4.54343073e-02f, -1.15446351e-01f, 3.04154716e-02f, -3.00446767e-02f, 1.07618906e-02f, 2.55276053e-03f, -3.12744379e-02f, 2.05619931e-02f,
  -6.72724703e-03f, -4.64171879e-02f, 2.22651940e-02f, -1.51162252e-01f, -2.35183492e-01f, 1.29169217e-04f, -1.92286924e-01f, -2.85196491e-02f, -8.78495798e-02f, -6.81005698e-03f,
  -1.55732617e-01f, -9.80966538e-02f, -8.07986781e-02f, 1.16246892e-02f, -1.12436913e-01f, 9.37859938e-02f, 4.83199693e-02f, 1.78665355e-01f, 7.62515813e-02f, -3.80347297e-02f,
  -2.29791459e-03f, 2.72736549e-02f, -1.92424022e-02f, 4.72815633e-02f, -5.32546714e-02f, 6.25818074e-02f, 1.86702348e-02f, 8.13902915e-02f, 7.66557753e-02f, -3.75774056e-02f,
  5.83131760e-02f, -5.12991771e-02f, -1.74220297e-02f, 2.35570334e-02f, -6.34607524e-02f, -5.40247522e-02f, -2.75596622e-02f, 4.32537459e-02f, 8.30995962e-02f, 1.86131913e-02f,
  5.29762059e-02f, -5.70839606e-02f, -6.80352701e-03f, -3.80903520e-02f, -1.00325728e-02f, -9.08431690e-03f, 2.01140847e-02f, 4.30983789e-02f, -2.80794036e-02f, -6.72435388e-02f,
  1.02865137e-03f, 8.14848095e-02f, -4.51382063e-02f, -4.97260923e-03f, -6.32590950e-02f, 5.08493669e-02f, -1.58667378e-02f, 2.99757849e-02f, 5.62133119e-02f, -2.43368484e-02f,
  -1.45450449e-02f, 5.05390344e-03f, 3.49578820e-03f, 2.50220355e-02f, -6.61851093e-02f, -6.52163327e-02f, -4.00594696e-02f, 2.83765830e-02f, 4.52680327e-02f, 2.78785359e-02f,
  8.17448422e-02f, -4.58525866e-02f, 4.79812324e-02f, 5.51049672e-02f, -3.94195728e-02f, -5.18407635e-02f, -1.38317309e-02f, -5.78632131e-02f, -1.67139731e-02f, 5.89159280e-02f,
  -6.84858188e-02f, 2.37746648e-02f, 4.39951718e-02f, 2.72402372e-02f, -1.18990252e-02f, 4.40811459e-03f, -2.58323643e-02f, -7.40347803e-02f, -2.84254067e-02f, -6.44160658e-02f,
  -3.84463295e-02f, -5.93776675e-03f, 4.12969664e-02f, -3.74131650e-02f, 5.72981425e-02f, 2.26236079e-02f, -4.59254421e-02f, 7.50450939e-02f, 4.74852845e-02f, 1.45785864e-02f,
  -8.12139809e-02f, -3.38637419e-02f, 8.03911360e-04f, 2.00138185e-02f, 7.89155718e-03f, 4.09607850e-02f, -1.30408797e-02f, 1.58996526e-02f, -6.99148886e-03f, 1.60313770e-02f,
  2.61077672e-01f, 1.96791112e-01f, -3.09413727e-02f, 2.08939776e-01f, 4.31879759e-02f, 3.32463905e-02f, 7.72214904e-02f, 1.51338458e-01f, 1.88201502e-01f, 4.49209623e-02f,
  2.41266377e-02f, 1.65704057e-01f, -1.04879260e-01f, -1.37775415e-03f, -1.76026389e-01f, -1.70153126e-01f, 9.37202349e-02f, 1.11668952e-01f, 6.91600610e-03f, 2.14276880e-01f,
  3.52070369e-02f, 3.11919246e-02f, -1.11081503e-01f, 2.28371415e-02f, 7.09448978e-02f, 1.33705422e-01f, -5.37802801e-02f, -3.80460136e-02f, 7.33646750e-02f, -7.13661909e-02f,
  -1.88382603e-02f, 4.30344231e-03f, -2.94168852e-02f, 4.46011946e-02f, 2.07050405e-02f, 6.44333959e-02f, 5.39793149e-02f, -9.80522186e-02f, 7.47498125e-04f, 4.96751070e-02f,
  3.86211164e-02f, 1.03517110e-02f, 7.66837224e-02f, -8.99285730e-03f, 2.81895138e-02f, 4.46200520e-02f, -2.68984456e-02f, -5.60621731e-02f, -5.25812581e-02f, -7.23780766e-02f,
  2.65768841e-02f, -1.03465803e-02f, 1.88611206e-02f, 3.51576693e-02f, -7.89832044e-03f, -2.84312759e-02f, 2.67552510e-02f, -5.59477229e-03f, 7.01589063e-02f, 3.48805753e-03f,
  6.63455799e-02f, -1.57963559e-02f, 2.33397614e-02f, 1.34389680e-02f, -1.61635745e-02f, 3.31774652e-02f, 3.55401188e-02f, 6.29545702e-03f, 4.44409996e-02f, 4.32142504e-02f,
  1.13769863e-02f, 4.15723473e-02f, 7.43417861e-03f, 2.58203074e-02f, 9.83079709e-03f, 7.27272481e-02f, -8.06685910e-02f, -1.94627400e-02f, -1.04552358e-02f, 7.99405482e-03f,
  -3.32262442e-02f, 4.47841100e-02f, 4.17651758e-02f, -3.67442630e-02f, 3.44772055e-03f, -6.07090294e-02f, -4.50088177e-03f, -6.50824904e-02f, 4.88372706e-02f, 1.59818772e-02f,
  1.43938631e-01f, 2.06685066e-01f, -6.25432506e-02f, 6.15334418e-03f, -6.57258183e-02f, -4.26472425e-02f, -1.01297442e-02f, 6.90549836e-02f, -2.97478009e-02f, 1.48696788e-02f,
  1.79424565e-02f, -2.43402272e-03f, 8.62989947e-03f, -6.25669807e-02f, 1.98759213e-02f, 2.36240532e-02f, -7.36959698e-03f, -2.42360514e-02f, 7.05110878e-02f, 4.43485193e-02f,
  5.34358881e-02f, 2.94834170e-02f, -3.10394131e-02f, 5.06739272e-03f, -1.88790727e-02f, -7.17061525e-03f, 4.79301848e-02f, -5.64736575e-02f, 2.86967158e-02f, -2.81428155e-02f,
  -1.21256486e-01f, -1.05094701e-01f, -2.92028878e-02f, -1.11490324e-01f, 1.44067422e-01f, 2.24951863e-01f, 1.08963117e-01f, -1.26225790e-02f, -1.72903195e-01f, 1.81606915e-02f,
  9.71297622e-02f, -2.31085554e-01f, -9.24037304e-05f, -3.19884792e-02f, 8.88199434e-02f, -7.57263377e-02f, 1.60363421e-01f, -3.61206420e-02f, 8.04929901e-03f, -9.84295756e-02f,
  5.62196784e-03f, 9.48708281e-02f, 5.21930754e-02f, 5.04719652e-02f, 6.89222440e-02f, 1.44737056e-02f, -8.63176212e-03f, 1.99261121e-02f, 1.01331966e-02f, 8.16665590e-02f,
  3.26347873e-02f, 3.06263585e-02f, -1.11734746e-02f, -5.18334396e-02f, 9.32181478e-02f, 7.78750926e-02f, 2.34460384e-02f, 3.88000607e-02f, -5.40892333e-02f, 4.46082801e-02f,
  -8.24539512e-02f, 3.05672269e-02f, 4.11904510e-03f, 2.94822566e-02f, 7.27681890e-02f, -3.60634066e-02f, 4.60234769e-02f, 5.07311374e-02f, -1.89226717e-02f, -1.98150706e-03f,
  1.78066548e-03f, 2.28241701e-02f, 5.37572913e-02f, 4.61326465e-02f, 6.31826892e-02f, 2.38984115e-02f, 5.71893640e-02f, -2.59678140e-02f, -1.27105387e-02f, -1.95744913e-02f,
  -2.90879700e-02f, 3.76727246e-02f, 3.81757356e-02f, 1.75451525e-02f, -3.63070406e-02f, -1.41420411e-02f, -6.34285957e-02f, 2.44575944e-02f, 4.55290377e-02f, 1.99355036e-02f,
  -4.31922115e-02f, 8.83722305e-03f, 4.49193045e-02f, 2.26087049e-02f, 2.11078450e-02f, -1.54833822e-02f, -3.88509780e-02f, 5.86041622e-02f, -3.83455912e-03f, 7.65128061e-02f,
  -2.69563720e-02f, 6.12059087e-02f, 3.36401002e-03f, 3.98096479e-02f, -4.09874879e-02f, -5.39084012e-03f, 1.74660794e-02f, -7.53327310e-02f, -7.30761886e-02f, -4.97594699e-02f,
  -8.05979520e-02f, -1.80652410e-01f, -5.86941019e-02f, -5.92666715e-02f, -1.01117127e-01f, 5.22974692e-02f, -2.04084460e-02f, -3.46583948e-02f, -8.36929977e-02f, 5.71810827e-02f,
  7.97930956e-02f, -2.24932488e-02f, 4.03266586e-02f, -1.26318531e-02f, 4.75586616e-02f, 3.41146328e-02f, -1.54374335e-02f, -9.28314985e-04f, 6.07732423e-02f, -2.97713932e-02f,
  1.65115241e-02f, -6.99433535e-02f, -9.04788671e-04f, -3.62173840e-02f, 2.95628756e-02f, -3.61777842e-02f, -5.73961101e-02f, 3.21382359e-02f, -8.55185499e-04f, -6.61531687e-02f,
  2.10214078e-01f, -1.56256139e-01f, -8.13193917e-02f, 8.66455063e-02f, 7.39723491e-03f, -9.02795494e-02f, -1.60270140e-01f, -4.29287143e-02f, 3.16835605e-02f, -1.65036112e-01f,
  2.47519631e-02f, 5.18701747e-02f, -1.56994686e-01f, 5.83434589e-02f, 6.03763759e-02f, -7.74978893e-04f, 8.49719942e-02f, 7.26600140e-02f, 6.48004040e-02f, 1.45927037e-03f,
  2.29180399e-02f, 6.32732138e-02f, -4.06961963e-02f, -9.22028571e-02f, 3.95569876e-02f, 3.73326354e-02f, 3.64573672e-02f, -9.63545367e-02f, -5.14730215e-02f, 4.36166599e-02f,
  -2.55739447e-02f, -5.67212552e-02f, -7.15863034e-02f, -2.14366578e-02f, 9.07802675e-03f, -5.34000732e-02f, -9.06779692e-02f, -4.28089015e-02f, 2.80896970e-03f, -3.00276466e-02f,
  -5.98883294e-02f, 3.26350778e-02f, -4.52852063e-03f, 2.97809448e-02f, 2.93175764e-02f, -4.24877219e-02f, 4.20571715e-02f, 1.19011821e-02f, -7.94953480e-02f, 7.85194486e-02f,
  -1.66010726e-02f, -6.64925799e-02f, -5.92968380e-03f, 7.11584017e-02f, 8.30724463e-03f, 6.65339828e-02f, -5.46691120e-02f, 2.28580013e-02f, 1.84410475e-02f, 4.91206348e-02f,
  5.73255233e-02f, -2.54850090e-02f, 6.37661964e-02f, 5.33520170e-02f, 7.32701570e-02f, 5.22009358e-02f, -4.31587733e-02f, 4.21509631e-02f, 5.91714680e-02f, 6.39674664e-02f,
  -4.49345410e-02f, 7.22741038e-02f, 7.53776282e-02f, -4.29453403e-02f, 4.63476665e-02f, -3.37866917e-02f, -3.01941056e-02f, -5.25761805e-02f, -4.18837741e-02f, 6.16420656e-02f,
  -7.43931830e-02f, 8.95631611e-02f, 5.05325608e-02f, 7.03516826e-02f, 5.40436134e-02f, 4.96901944e-02f, -5.72295934e-02f, 4.24562208e-02f, 8.39536935e-02f, 8.85675382e-03f,
  6.77691922e-02f, -3.98745537e-02f, -2.26252601e-02f, 7.18483655e-03f, -6.21213242e-02f, 5.97704612e-02f, 1.89820472e-02f, 7.98481479e-02f, -1.75563954e-02f, 2.55602226e-02f,
  -3.50440070e-02f, 4.31199633e-02f, 6.95878118e-02f, 5.76534085e-02f, -6.03345186e-02f, -3.25023048e-02f, 1.54676416e-03f, -3.32527198e-02f, 6.66119019e-03f, 6.36047050e-02f,
  -6.23899372e-03f, -7.98306465e-02f, 7.48518156e-03f, -8.35231990e-02f, 3.06699574e-02f, -7.18632340e-02f, 9.98431221e-02f, -7.64292255e-02f, 6.15469553e-03f, 3.66513222e-03f,
  -8.09443966e-02f, 1.91878572e-01f, 1.38219642e-02f, 4.50157188e-02f, -2.54731238e-01f, -1.68008134e-01f, -4.58669104e-03f, -7.83236176e-02f, 6.77587166e-02f, 2.76311133e-02f,
  3.25051732e-02f, 9.18918774e-02f, 1.22328565e-01f, 1.22153349e-01f, -9.27642211e-02f, 7.43769705e-02f, 9.90378559e-02f, 1.03004724e-01f, -4.50359918e-02f, 2.19992679e-02f,
  -5.02605806e-04f, -4.27805213e-03f, 1.72658056e-01f, -8.59473497e-02f, -1.01164766e-01f, 1.03358984e-01f, -6.61183614e-03f, -5.71464300e-02f, 4.80497330e-02f, 5.73406257e-02f,
  -4.77479957e-02f, -2.28874182e-04f, -5.63740544e-02f, 9.78615582e-02f, 4.31233179e-03f, -1.61508750e-02f, -1.20791858e-02f, -1.89270973e-02f, -1.96490251e-02f, -2.86437478e-02f,
  3.15723121e-02f, -2.46521086e-02f, -2.03818269e-02f, -2.09558960e-02f, 1.69853289e-02f, 3.52559425e-02f, 7.67304972e-02f, 2.60140952e-02f, 8.34100395e-02f, -4.33777284e-04f,
  -1.02675958e-02f, 7.74757490e-02f, -1.28381830e-02f, 1.36172995e-01f, -8.22417252e-03f, 4.58478928e-02f, 9.66673866e-02f, 8.71232301e-02f, -1.62622993e-04f, -8.85742716e-03f,
  -2.88012158e-02f, -3.36826034e-02f, -1.61004458e-02f, 1.83159728e-02f, -1.05590224e-02f, 2.57886853e-02f, -2.49657128e-02f, -5.70499487e-02f, -3.39834690e-02f, 6.14972003e-02f,
  -7.56556988e-02f, 7.65269771e-02f, 1.19276633e-02f, -3.41243649e-05f, 3.76943834e-02f, -4.31195972e-03f, -3.14644575e-02f, 4.13456820e-02f, -3.24761607e-02f, -9.44645517e-03f,
  7.33093545e-02f, 3.23435180e-02f, 2.03321576e-02f, 2.28278134e-02f, -1.33938901e-02f, 8.39232281e-02f, -1.54398521e-02f, 2.83566155e-02f, 5.35274148e-02f, -6.84819147e-02f,
  2.73572262e-02f, 1.69472083e-01f, -1.39189018e-02f, -1.21956784e-02f, 5.36083058e-02f, -8.68503898e-02f, 6.14229143e-02f, 3.74758765e-02f, 4.25643437e-02f, 1.80518664e-02f,
  -6.39152229e-02f, 5.48209473e-02f, -5.98783791e-02f, 2.89910194e-02f, 4.37131710e-02f, -5.23728244e-02f, -1.97700802e-02f, -2.10876632e-02f, -1.88923981e-02f, -4.96419296e-02f,
  4.03230358e-03f, -3.59577760e-02f, -3.56477834e-02f, -5.00609949e-02f, -6.06041513e-02f, 1.04241557e-02f, 2.35040914e-02f, 7.31144380e-03f, 5.13375364e-02f, 5.80155812e-02f,
  2.87103832e-01f, -1.57499090e-01f, 4.25757393e-02f, 2.20850542e-01f, 1.19635783e-01f, 2.06596628e-02f, -9.00007226e-03f, 1.30592465e-01f, 1.16204135e-01f, -1.86914101e-01f,
  -1.49336994e-01f, 5.03553823e-02f, -1.32601410e-01f, -6.22415207e-02f, 2.64653452e-02f, -9.72588211e-02f, 1.19129814e-01f, 3.89138870e-02f, -5.96474707e-02f, 1.19393706e-01f,
  2.01600462e-01f, 3.73079740e-02f, 6.20914064e-03f, 2.08397023e-02f, 1.24539107e-01f, 4.33754399e-02f, -6.53284118e-02f, -1.10811610e-02f, -5.89675689e-03f, -5.28891087e-02f,
  -4.11715992e-02f, -3.23875882e-02f, -6.51830211e-02f, -3.44753638e-03f, -3.21653001e-02f, -1.19643975e-02f, 1.84342302e-02f, 2.32281741e-02f, -9.59642604e-03f, -4.93359044e-02f,
  1.33303879e-02f, 4.10482660e-02f, 1.83328632e-02f, 2.15068106e-02f, 2.84445267e-02f, 2.88895555e-02f, 3.76601666e-02f, 8.67170841e-02f, 2.05273703e-02f, -2.35523693e-02f,
  1.37406979e-02f, -3.72495800e-02f, -1.17224511e-02f, -2.27540713e-02f, 5.63015044e-02f, -4.92088720e-02f, -8.17262679e-02f, -2.12418716e-02f, 7.20556900e-02f, -2.51537678e-03f,
  -3.76010723e-02f, 1.58676796e-03f, -4.98252474e-02f, -4.03639441e-03f, 4.05425541e-02f, -1.73712987e-02f, -1.26890987e-02f, -5.78670315e-02f, -1.85062680e-02f, -6.27339724e-03f,
  5.33740744e-02f, -2.71262345e-03f, -3.80548909e-02f, -3.01005673e-02f, 4.87641618e-02f, 2.32716110e-02f, 5.36715500e-02f, -7.08359033e-02f, -1.57248415e-02f, 7.34960884e-02f,
  2.25175880e-02f, 2.39516841e-03f, -5.49921766e-02f, 6.02745404e-03f, -3.15076001e-02f, 4.38670777e-02f, -6.21937215e-02f, 1.76288059e-03f, -3.03854495e-02f, 4.78293076e-02f,
  3.44503578e-03f, 1.54746491e-02f, 3.47321928e-02f, -1.02762893e-01f, -3.57334316e-02f, 1.58415902e-02f, 1.45173762e-02f, -1.15488721e-02f, -3.62681337e-02f, -5.37752248e-02f,
  -8.07892717e-03f, -4.07131426e-02f, -6.03992008e-02f, 8.98606554e-02f, 2.31744219e-02f, -7.31055364e-02f, -4.98163961e-02f, -5.55086732e-02f, -4.03829757e-03f, -5.78486547e-02f,
  -3.97221819e-02f, -2.86712870e-02f, 6.96510300e-02f, 9.69124511e-02f, -3.80079970e-02f, 1.82159673e-02f, 4.93310764e-02f, 1.91869196e-02f, -2.34176945e-02f, -7.50998780e-02f,
  2.60984171e-02f, 1.47411600e-01f, 8.94822273e-03f, 9.54312757e-02f, -1.54741228e-01f, -1.66722432e-01f, -3.73469549e-03f, 8.55305791e-02f, 2.88666129e-01f, 3.15389261e-02f,
  -7.38436133e-02f, 5.25563695e-02f, 1.11358330e-01f, 1.02009855e-01f, -1.81665346e-01f, 2.21479595e-01f, 3.65952961e-02f, -8.46278444e-02f, 9.54140723e-02f, -1.50994390e-01f,
  5.08896038e-02f, 5.70353214e-03f, -1.25957811e-02f, -2.02464778e-02f, -1.23573706e-01f, -6.60078367e-03f, -1.06516138e-01f, -4.68552522e-02f, -1.58306032e-01f, -1.22604817e-01f,
  -1.39262840e-01f, 1.28088668e-02f, -7.24767148e-02f, 7.14979470e-02f, -1.21488281e-01f, -1.26481978e-02f, -5.35581773e-03f, -7.71121755e-02f, -2.18222779e-03f, -8.50094948e-03f,
  3.11271641e-02f, -3.02810986e-02f, 1.57555211e-02f, 2.14036144e-02f, 9.47619975e-02f, 1.65591501e-02f, 3.03978100e-03f, -2.71681976e-02f, -2.77020689e-02f, -8.33907723e-02f,
  -2.34075859e-02f, -4.29105721e-02f, 6.26069680e-02f, 5.33944219e-02f, -9.88054052e-02f, -6.41244352e-02f, -6.22867560e-03f, -8.16032887e-02f, -3.60421501e-02f, -7.56234676e-02f,
  -2.15322208e-02f, -6.77049905e-02f, 5.97350718e-03f, -4.30064462e-02f, 2.72095134e-03f, -4.63158004e-02f, 1.26687135e-03f, -7.97424838e-02f, -3.58819589e-02f, -8.06840286e-02f,
  -1.19812628e-02f, 5.97125217e-02f, 8.69254470e-02f, -1.80592341e-03f, 4.17411886e-02f, 9.10085812e-02f, -3.93339992e-02f, -8.06025192e-02f, 2.89280154e-02f, 3.54059786e-02f,
  1.76360682e-02f, 2.65265722e-02f, -8.97310004e-02f, -2.42304001e-02f, 4.02463935e-02f, -6.84051290e-02f, -4.95281210e-03f, -2.12722123e-02f, -2.98697650e-02f, -1.85918026e-02f,
  -1.74183264e-01f, 9.16638523e-02f, -7.96184838e-02f, -6.67154938e-02f, 1.51020819e-02f, -4.73355651e-02f, 1.34595558e-02f, 1.84195805e-02f, 2.22352482e-02f, 3.57726365e-02f,
  -1.42255098e-01f, 7.25758728e-03f, 5.81205189e-02f, 4.61839791e-03f, 1.09142736e-02f, -9.13511515e-02f, -3.21911499e-02f, -6.81035295e-02f, 7.99029600e-03f, 1.73198879e-02f,
  -1.04029842e-01f, -7.19369277e-02f, 5.55808097e-02f, -8.15485939e-02f, -1.54156433e-02f, 2.33043842e-02f, 5.42208133e-03f, -7.04731196e-02f, -4.90528420e-02f, 7.17923120e-02f,
  -4.64177132e-02f, 1.76999986e-01f, 5.93136176e-02f, 1.61405057e-01f, -1.16903089e-01f, -2.61598647e-01f, -1.29519641e-01f, -9.83979851e-02f, 5.48525527e-02f, 2.02352360e-01f,
  1.49617679e-02f, 2.62191445e-01f, -4.51488681e-02f, -3.93456928e-02f, -2.82721639e-01f, -1.29039153e-01f, -2.54932009e-02f, -4.64493176e-03f, -7.37599283e-02f, -2.89024077e-02f,
  -8.21652934e-02f, 3.54973376e-02f, -1.19234040e-01f, 8.87498856e-02f, -6.74588904e-02f, 1.29895151e-01f, -1.51310368e-02f, 1.47573510e-02f, 3.18819731e-02f, -3.65177207e-02f,
  -7.37606287e-02f, 1.74576920e-02f, 8.07625875e-02f, 2.08763313e-03f, 4.65349411e-04f, -8.30162782e-03f, -1.95675753e-02f, -3.79159637e-02f, -1.04271717e-01f, 1.63171999e-02f,
  8.77703279e-02f, 2.23830398e-02f, -6.61628395e-02f, -2.97054811e-03f, 3.51068266e-02f, 5.43422587e-02f, -8.33947659e-02f, -5.64601421e-02f, 2.45410707e-02f, -4.17293496e-02f,
  -5.04558459e-02f, 1.70406848e-02f, 4.48895432e-02f, 7.12883398e-02f, 4.44225632e-02f, -4.26896624e-02f, -4.91308384e-02f, 5.67461848e-02f, -2.63839774e-02f, 1.03434678e-02f,
  5.17102927e-02f, 5.27240150e-02f, -4.41955253e-02f, -3.74833457e-02f, 1.22953709e-02f, -4.73519228e-02f, 7.58450525e-03f, -1.09368078e-02f, 6.80353492e-02f, 6.93715690e-03f,
  4.49302271e-02f, 3.28661129e-02f, 5.35737500e-02f, -6.91725537e-02f, -1.03628272e-02f, 2.47477908e-02f, 7.77327493e-02f, -2.14679930e-02f, -2.86303200e-02f, -2.43627876e-02f,
  -2.53328923e-02f, 5.27259335e-02f, -1.08578932e-02f, -5.81197403e-02f, 5.65191172e-03f, -4.97856289e-02f, 3.23015191e-02f, 2.12299190e-02f, -7.38739446e-02f, -3.91111560e-02f,
  2.65803523e-02f, 1.76146567e-01f, -8.11814237e-03f, 1.03830528e-02f, -1.38537856e-02f, 4.36970918e-03f, 4.27532382e-03f, -2.39437576e-02f, 5.07767275e-02f, 1.07890535e-02f,
  2.66341362e-02f, 4.58248099e-03f, 5.25115281e-02f, -4.39569727e-02f, 2.37336997e-02f, -8.82970765e-02f, 2.56265439e-02f, 6.66515827e-02f, 7.15627149e-02f, 2.88833864e-02f,
  -2.63935002e-03f, -2.89844666e-02f, -4.43843054e-03f, -3.88737619e-02f, 7.86285773e-02f, 9.47165489e-02f, 1.64479408e-02f, 4.36167978e-02f, -5.94237782e-02f, 5.98320477e-02f,
  -1.42823145e-01f, -1.77610219e-01f, -1.63559020e-01f, -6.50541633e-02f, 8.71608555e-02f, 1.55622512e-01f, 1.18351877e-01f, -8.22711512e-02f, -1.23842597e-01f, 9.13902223e-02f,
  1.33630589e-01f, -2.54746825e-01f, 1.18773887e-02f, 1.84498519e-01f, 2.32123565e-02f, -7.12801144e-02f, 9.35796574e-02f, 6.37977198e-02f, -1.24134339e-01f, -9.81828570e-02f,
  -1.35844424e-01f, 1.86608508e-01f, -2.10612807e-02f, 7.77272135e-02f, 4.96528447e-02f, -9.17820260e-02f, 5.45957871e-02f, -7.03609809e-02f, 1.51932940e-01f, 4.81846146e-02f,
  8.36480930e-02f, -1.45399824e-01f, -6.47723302e-02f, 1.11184572e-03f, 3.19873542e-02f, 8.26916248e-02f, -4.65636374e-03f, -3.71731855e-02f, 9.43546183e-03f, 3.17209098e-03f,
  3.29434834e-02f, -2.25612354e-02f, -5.37733249e-02f, -1.91149022e-03f, 7.23213423e-03f, -4.36796620e-02f, -8.41969922e-02f, -3.15291365e-03f, -1.89596582e-02f, 6.26860466e-03f,
  -7.36583918e-02f, 3.12314164e-02f, -5.15677519e-02f, -2.74351891e-02f, -5.39626256e-02f, -4.95327786e-02f, 8.07153955e-02f, 2.92236060e-02f, 1.84913464e-02f, -6.44988939e-02f,
  -7.97488075e-03f, 1.62033550e-02f, -2.65832338e-02f, -3.41727361e-02f, 5.12167178e-02f, 7.11496174e-02f, 2.42692363e-02f, -4.55169603e-02f, -1.92292128e-02f, -2.50322260e-02f,
  6.22030087e-02f, 4.93362471e-02f, 2.18653549e-02f, 4.55941707e-02f, -1.58256181e-02f, -5.77472989e-03f, 3.47905867e-02f, 1.23389643e-02f, 2.30194293e-02f, 4.39900048e-02f,
  -6.45304238e-03f, -1.75996143e-02f, 4.36833948e-02f, 1.62255939e-03f, 6.07743077e-02f, -5.34622185e-02f, -5.07565401e-02f, -5.49991503e-02f, 2.28086463e-03f, -2.25098617e-02f,
  7.82931224e-02f, -1.66691735e-01f, 1.53919691e-02f, 3.04156970e-02f, -4.55843918e-02f, -1.63530221e-03f, -5.53630628e-02f, -3.60498652e-02f, -5.06370189e-03f, -2.46166047e-02f,
  4.98757698e-02f, 4.78329360e-02f, 6.21194195e-04f, 3.16716097e-02f, 1.13216154e-02f, 6.98505938e-02f, 4.05192515e-03f, -5.89868810e-04f, 1.46628842e-02f, 4.95489426e-02f,
  -3.26053910e-02f, -3.83881852e-02f, -2.79078223e-02f, 3.65774636e-03f, 7.66985640e-02f, 2.06934325e-02f, -1.47474259e-02f, 2.62953136e-02f, 1.19530205e-02f, -3.01838927e-02f,
  -2.90878445e-01f, -1.84255332e-01f, -1.54952779e-01f, -9.72027034e-02f, 1.90900993e-02f, -2.12880284e-01f, -2.34380171e-01f, 6.21172823e-02f, -1.45012781e-01f, 1.58789642e-02f,
  9.13790315e-02f, -1.44682899e-01f, -3.48856784e-02f, -9.37990546e-02f, -2.04226285e-01f, 2.02915464e-02f, -1.05467483e-01f, -6.60225898e-02f, -1.51951762e-03f, -8.85254517e-02f,
  2.26552766e-02f, 5.36200739e-02f, 3.06961429e-03f, 7.84831122e-02f, -4.02057469e-02f, 5.90424798e-02f, 2.33454838e-01f, 7.94163570e-02f, 1.62918642e-01f, 5.95916323e-02f,
  -1.03780605e-01f, -5.16951084e-02f, 5.82264643e-03f, 3.08414288e-02f, 6.43854123e-03f, 1.20353084e-02f, 5.61620556e-02f, -8.80882330e-03f, 5.56846522e-02f, -5.69201075e-02f,
  -6.25648648e-02f, -2.92580649e-02f, 5.68798557e-02f, -3.44155878e-02f, -8.65167752e-03f, 3.80812287e-02f, -2.00917404e-02f, -9.29143652e-03f, 9.79184266e-03f, 8.88800342e-03f,
  3.17816958e-02f, -6.22320920e-02f, -5.91216050e-02f, 1.71263106e-02f, 8.00782293e-02f, 4.22260538e-02f, -3.21397721e-03f, 3.12967971e-02f, 2.34733932e-02f, -2.48992797e-02f,
  -2.08750125e-02f, 3.37022655e-02f, 4.95805852e-02f, 7.99066871e-02f, -1.07760134e-03f, 6.13810681e-02f, 1.32021438e-02f, -1.94530226e-02f, 2.47351304e-02f, -4.22034562e-02f,
  1.68691967e-02f, -6.67002648e-02f, 5.16648591e-02f, -5.26696332e-02f, -6.58613145e-02f, 8.14399943e-02f, -3.20008099e-02f, 2.38755550e-02f, -4.10164110e-02f, -5.95151074e-02f,
  -2.16642246e-02f, 1.50691401e-02f, -2.66099013e-02f, 7.54880980e-02f, -5.24255261e-02f, -4.43289764e-02f, -3.43665741e-02f, 2.59082559e-02f, -2.85834670e-02f, -1.65003426e-02f,
  -2.90379934e-02f, -1.23419926e-01f, -1.95124689e-02f, -1.18423747e-02f, 2.29655802e-02f, -6.48674443e-02f, -6.11015260e-02f, -1.74855385e-02f, -2.27707941e-02f, -5.56731857e-02f,
  -2.99173445e-02f, 7.25895632e-03f, -4.77149338e-02f, -1.16371168e-02f, 2.44844351e-02f, -9.99930874e-03f, -6.64102063e-02f, -1.87422764e-02f, -2.28387397e-02f, -2.37365868e-02f,
  1.63590740e-02f, -2.53662583e-03f, 4.92650047e-02f, 1.84562933e-02f, -2.92455759e-02f, -1.54494252e-02f, -9.69238207e-03f, -2.80270576e-02f, 4.76793125e-02f, 3.63044366e-02f,
  5.24399728e-02f, -2.68692374e-01f, -4.60901894e-02f, -2.34739378e-01f, 1.93943419e-02f, -1.45570919e-01f, 2.04136968e-02f, -1.21326648e-01f, -4.03968021e-02f, 3.28605697e-02f,
  -6.62377775e-02f, 3.61148193e-02f, 3.01040057e-02f, -2.31071249e-01f, -2.29765877e-01f, -1.03972755e-01f, -2.75985777e-01f, -3.23104598e-02f, -2.24554390e-02f, -1.29658625e-01f,
  -1.35921955e-01f, -2.10805550e-01f, -1.14535078e-01f, -6.58332407e-02f, -1.57091860e-02f, 1.51195684e-02f, -1.37252463e-02f, 1.12248160e-01f, -2.76230928e-02f, -3.65860015e-02f,
  -4.41542901e-02f, 3.36742587e-02f, 8.65911767e-02f, 1.02648810e-02f, 6.24310272e-03f, 3.86535153e-02f, 2.38435925e-04f, 5.87154664e-02f, 6.45605102e-02f, 6.30120933e-02f,
  2.47672871e-02f, -9.29242652e-03f, -8.80313963e-02f, -1.15374550e-02f, -2.08847914e-02f, -9.36085731e-03f, -6.03783876e-02f, -4.47197892e-02f, -6.43305853e-02f, 1.25940628e-02f,
  6.54197158e-03f, 3.86668369e-02f, 5.05190641e-02f, -6.78049028e-02f, 3.15501690e-02f, 1.54756466e-02f, -2.13727988e-02f, -8.64859764e-03f, 2.29331641e-03f, -6.74420595e-02f,
  -5.15708588e-02f, -8.45813472e-03f, 6.78176656e-02f, 2.32320931e-02f, 1.49140060e-02f, -2.77580079e-02f, 8.22780281e-03f, 5.14981821e-02f, 6.67491183e-02f, -3.14252451e-02f,
  -1.00648794e-02f, 2.66127903e-02f, -4.42130752e-02f, 2.76769586e-02f, 2.48934682e-02f, -2.74705272e-02f, 7.45465085e-02f, -2.69509275e-02f, 2.68307999e-02f, -4.78880741e-02f,
  1.52079053e-02f, 3.39247063e-02f, 2.26678443e-03f, 6.95456043e-02f, 6.18946087e-03f, 4.42194417e-02f, -1.44108748e-02f, -9.70704132e-04f, 7.34992623e-02f, -5.06158471e-02f,
  -1.12797417e-01f, -2.12837368e-01f, 2.36734189e-02f, -1.54184252e-02f, -3.10422871e-02f, -2.20584753e-03f, -7.17809424e-02f, 1.18581194e-03f, -8.87119099e-02f, -6.94895610e-02f,
  1.70177743e-02f, 3.09921801e-02f, -2.93442365e-02f, -5.34125902e-02f, -1.03422040e-02f, 1.61170699e-02f, 2.43431740e-02f, 5.33836409e-02f, -2.83654407e-02f, -4.38582487e-02f,
  3.83581966e-02f, 2.42868662e-02f, -3.18092406e-02f, -5.53103574e-02f, 6.47655874e-03f, 6.43836036e-02f, -7.34774116e-03f, 8.79030954e-03f, -5.21043725e-02f, 2.92114224e-02f,
  9.44510475e-02f, -4.26217020e-02f, 5.16715460e-02f, -1.17482983e-01f, 8.73476826e-03f, 1.79571077e-01f, 1.12537384e-01f, -1.78852275e-01f, -3.02652037e-03f, -3.35295461e-02f,
  1.63427554e-02f, 1.05283223e-01f, 1.56527370e-01f, -1.90335438e-02f, 1.32718205e-01f, 5.32801077e-02f, 1.87332109e-02f, -4.29934487e-02f, 2.96257306e-02f, -5.36453761e-02f,
  -1.03880949e-01f, -3.27617824e-02f, -2.00000722e-02f, -1.23294890e-01f, -8.48317966e-02f, -1.38238803e-01f, -1.69654503e-01f, 5.58275059e-02f, -1.49356484e-01f, -4.57078107e-02f,
  8.83194879e-02f, -1.43220220e-02f, 5.29704317e-02f, 2.73199454e-02f, 2.51842272e-02f, -5.80004603e-02f, -5.44482889e-03f, 6.47935793e-02f, -1.69792026e-02f, 3.45143080e-02f,
  9.96393189e-02f, -2.74013970e-02f, 1.32341180e-02f, 5.57001121e-02f, -3.59107964e-02f, 1.81674492e-02f, 1.33593064e-02f, -6.32496104e-02f, 6.21324480e-02f, 1.60475224e-02f,
  8.96141082e-02f, 5.45605831e-02f, 1.60251278e-02f, 1.79861896e-02f, 1.12853025e-03f, -2.78557464e-02f, 1.03608496e-01f, 9.47317854e-02f, -7.57170618e-02f, -4.00694944e-02f,
  5.78341819e-02f, -3.45034641e-03f, -5.75065017e-02f, -7.15060234e-02f, -7.10173771e-02f, 6.64286036e-03f, 1.67972557e-02f, -3.66915017e-02f, -1.43179921e-02f, -1.05650291e-01f,
  3.19200903e-02f, -4.74875942e-02f, -2.46630888e-02f, -3.41458619e-02f, -9.30501148e-03f, -4.66946997e-02f, -6.99296817e-02f, -4.71576676e-02f, -5.26919253e-02f, 2.65398417e-02f,
  -4.58027422e-02f, 8.00144300e-02f, 1.35205798e-02f, 3.76787782e-02f, 7.89957047e-02f, -4.23249453e-02f, -4.16897722e-02f, 3.99393551e-02f, -6.11229353e-02f, 6.86942935e-02f,
  -2.03517522e-03f, -5.37432246e-02f, -2.11198907e-02f, 3.06798499e-02f, -4.14126329e-02f, -9.29297283e-02f, -1.25472546e-02f, 1.20503744e-02f, 1.60863437e-02f, -2.30648890e-02f,
  3.21845263e-02f, 5.84997684e-02f, 3.25778313e-02f, 6.04115240e-02f, 5.44520002e-03f, -2.89937295e-02f, -2.84192376e-02f, 3.03266495e-02f, -4.40721065e-02f, 2.30832081e-02f,
  -8.62635225e-02f, 3.97658534e-02f, -5.37482789e-03f, -8.84236116e-03f, -1.68081783e-02f, 6.46934286e-02f, -3.18147317e-02f, -5.27371652e-02f, 5.41662686e-02f, -5.46177216e-02f,
  -4.86533297e-03f, -4.46046479e-02f, 1.93507016e-01f, 1.49241155e-02f, -4.76252064e-02f, 5.75864613e-02f, -1.12117037e-01f, -6.56009391e-02f, -2.33989045e-01f, -2.27557302e-01f,
  -3.91309708e-02f, 2.73881834e-02f, -7.99538493e-02f, 6.70845136e-02f, 9.53575894e-02f, -1.28430620e-01f, 2.12446786e-02f, 5.18783443e-02f, -2.57240869e-02f, -6.97721392e-02f,
  9.79869366e-02f, -7.06456974e-02f, 2.23081321e-01f, -1.19306892e-02f, 2.38235155e-03f, 6.21471927e-02f, 3.02248858e-02f, 4.73583564e-02f, 6.83030114e-02f, 4.04403470e-02f,
  -2.69267391e-02f, -4.61916961e-02f, 5.86138107e-02f, 1.02277629e-01f, 1.63202602e-02f, 1.26509424e-02f, 5.05077802e-02f, -1.35956481e-02f, -4.10615616e-02f, -3.57662924e-02f,
  6.76351711e-02f, 7.44151557e-03f, -7.44889379e-02f, 1.67213939e-02f, -9.29301456e-02f, 8.07351619e-02f, 3.21934223e-02f, 3.31577323e-02f, -4.92688417e-02f, 4.23680805e-03f,
  1.87298097e-02f, 4.75477092e-02f, 2.49627978e-02f, -2.07435656e-02f, 5.03368117e-03f, -9.40006003e-02f, -1.40539156e-02f, 1.34116244e-02f, -5.41380644e-02f, 3.76317166e-02f,
  2.82843895e-02f, 1.38848543e-03f, -9.95302349e-02f, 3.60953845e-02f, -4.84551452e-02f, 5.63672632e-02f, -5.52387498e-02f, 3.76111157e-02f, -5.56354038e-02f, -3.50929834e-02f,
  5.92395179e-02f, -4.71562184e-02f, -6.25159359e-03f, 5.87514117e-02f, -1.86018404e-02f, -8.84358585e-02f, 9.03784335e-02f, 2.59089749e-02f, -6.06528185e-02f, 3.11711151e-02f,
  -4.20608781e-02f, -5.62295243e-02f, -1.84569471e-02f, 5.01445234e-02f, 2.00003833e-02f, 2.16807835e-02f, -3.77057567e-02f, -8.96280780e-02f, -3.91874164e-02f, -6.82170643e-03f,
  -1.55603010e-02f, -7.97938630e-02f, -6.54281750e-02f, 5.25621399e-02f, 5.47171421e-02f, 8.74356553e-03f, -2.81151142e-02f, -5.26803583e-02f, -5.83635829e-02f, -8.26854631e-02f,
  7.00901775e-03f, 4.23408002e-02f, -1.87151786e-02f, -1.36442017e-02f, 5.22083640e-02f, -3.73156704e-02f, -9.47023556e-03f, 2.66885441e-02f, 2.84512918e-02f, 8.26538876e-02f,
  -4.43797652e-03f, -5.78850694e-02f, 6.93420246e-02f, 1.49719091e-02f, -3.64304744e-02f, 3.19107771e-02f, 9.13809612e-03f, -5.82351647e-02f, 3.67090069e-02f, -4.58095670e-02f,
  -3.60964447e-01f, 2.90624022e-01f, 7.52541795e-02f, -2.38774568e-02f, -1.75414935e-01f, -4.84261364e-02f, 4.83651226e-03f, -1.29340187e-01f, -1.01299904e-01f, 7.20463470e-02f,
  -1.64723039e-01f, 7.63486475e-02f, 1.83569063e-02f, 8.76576602e-02f, -2.04501972e-01f, 6.51961863e-02f, -3.03529762e-02f, 6.00965396e-02f, 6.00931346e-02f, -1.00796849e-01f,
  -1.60523765e-02f, -6.83249608e-02f, 3.31291296e-02f, 8.06561410e-02f, 2.53664255e-02f, -1.41997915e-02f, -6.58783540e-02f, 7.86589086e-02f, 1.02712587e-02f, -3.72169390e-02f,
  4.35286108e-03f, -2.23529115e-01f, -8.01021904e-02f, -5.59743233e-02f, -8.45486149e-02f, -4.40857699e-03f, 1.45163517e-02f, 5.73991910e-02f, -4.91304435e-02f, -4.16167527e-02f,
  2.96153296e-02f, -7.73397554e-03f, 4.68768738e-02f, 1.53103573e-02f, 1.86101031e-02f, 7.89722055e-02f, 3.33964042e-02f, 6.79735988e-02f, -1.82209052e-02f, -3.22906417e-03f,
  7.10080266e-02f, 3.58973555e-02f, -5.79270907e-02f, -7.99130648e-03f, -3.91609706e-02f, 3.05506214e-03f, -2.28563081e-02f, 3.34323174e-03f, -6.23311941e-03f, 1.12740221e-02f,
  2.65533645e-02f, 4.64530066e-02f, 1.71398278e-02f, 3.98701876e-02f, 9.31398273e-02f, -1.43535212e-02f, 4.19577360e-02f, -5.77108329e-03f, -1.88760143e-02f, 9.51535441e-03f,
  -6.30377159e-02f, -5.39997071e-02f, -3.60073149e-02f, -1.71754137e-02f, 3.95540819e-02f, -6.43268898e-02f, -3.49590406e-02f, -5.70639968e-02f, 3.71385999e-02f, 2.75160037e-02f,
  -3.99406068e-02f, -1.15283323e-03f, -3.78844924e-02f, -2.64523346e-02f, -2.24348400e-02f, 9.67707112e-02f, -3.50233391e-02f, -7.76537741e-03f, 4.15884219e-02f, 5.06745372e-03f,
  -7.20106363e-02f, -1.44087508e-01f, -1.58501379e-02f, -9.00075212e-02f, 5.30062988e-02f, 2.53381790e-03f, 2.81594191e-02f, -6.09514304e-03f, 5.46131730e-02f, -1.22564957e-02f,
  9.79187898e-03f, -4.55232337e-02f, -2.75831949e-02f, -3.07470802e-02f, 7.65811875e-02f, -7.01101869e-02f, -5.26471697e-02f, -7.48082325e-02f, -5.79285473e-02f, 1.57802533e-02f,
  -8.12286735e-02f, -8.77493843e-02f, 7.61916041e-02f, 3.11833974e-02f, -3.11806588e-03f, -5.77466860e-02f, 2.64796987e-02f, -5.33837447e-05f, -1.03211617e-02f, 5.10168187e-02f,
  3.75158340e-03f, -3.47984694e-02f, 9.81112346e-02f, 3.82158086e-02f, 1.76605195e-01f, 7.29293562e-03f, 4.19791974e-03f, -1.29148411e-02f, 4.70788144e-02f, -6.47466332e-02f,
  -7.25356415e-02f, 8.33989382e-02f, -1.60899982e-01f, 9.82313305e-02f, -1.86291069e-01f, -1.54064998e-01f, -1.09630793e-01f, -7.33403265e-02f, 6.03971668e-02f, -5.93016259e-02f,
  -9.37296897e-02f, -1.73053313e-02f, -6.91303313e-02f, 6.01749830e-02f, 6.33221446e-03f, 9.95208770e-02f, -6.04473464e-02f, 3.31537277e-02f, -3.54299769e-02f, -2.74444371e-02f,
  2.45305058e-02f, 6.06358275e-02f, 3.89665477e-02f, 1.32912874e-01f, -7.18099624e-02f, 1.00411465e-02f, -6.52427077e-02f, -4.09853691e-03f, 1.29946070e-02f, 6.08172417e-02f,
  -1.01589467e-02f, 2.39891512e-03f, 2.44505536e-02f, -2.81229690e-02f, 5.65133579e-02f, 1.16182350e-01f, 1.16354995e-03f, 7.47611597e-02f, 8.91072229e-02f, -2.56438050e-02f,
  7.01696146e-04f, 8.92279521e-02f, -1.32046500e-02f, 5.34444004e-02f, -3.85253574e-03f, 5.22479266e-02f, -3.68149020e-02f, -1.32638048e-02f, 1.04400869e-02f, -2.47945450e-02f,
  -8.25624317e-02f, -4.58808802e-02f, -1.10821379e-02f, -2.94898953e-02f, -1.00457454e-02f, 6.97063431e-02f, -4.60497057e-03f, -4.13143449e-02f, 5.79587445e-02f, 2.55920063e-03f,
  -5.40012605e-02f, 9.39080045e-02f, 6.10138476e-02f, 1.86225567e-02f, -7.14554861e-02f, -1.85537664e-03f, 4.41831052e-02f, 1.19876405e-02f, 5.18326052e-02f, -2.03456171e-02f,
  7.18227774e-02f, 6.35307580e-02f, -3.98099646e-02f, 3.95574085e-02f, 9.59942862e-02f, 3.63621786e-02f, 6.11175522e-02f, 7.33598396e-02f, -9.32192989e-03f, -4.79227528e-02f,
  -1.21228486e-01f, -2.76796907e-01f, -3.85981723e-04f, 3.98247549e-03f, 2.73589995e-02f, -5.96988648e-02f, 5.13223298e-02f, 4.98310179e-02f, -9.65289995e-02f, -1.30205244e-01f,
  2.72611994e-02f, -2.12881714e-03f, 4.04339172e-02f, 5.36510311e-02f, 4.43021618e-02f, -1.15935020e-01f, -8.82656649e-02f, -4.67329286e-03f, 3.70423310e-02f, 2.61253165e-03f,
  2.32481230e-02f, -8.18660185e-02f, -1.32503882e-02f, -4.43052086e-05f, 2.53058746e-02f, -7.07427710e-02f, 5.43303490e-02f, 7.14026019e-02f, -1.48481289e-02f, -3.46147269e-02f,
  -2.75606126e-01f, 2.00506285e-01f, 5.06754927e-02f, -5.38893491e-02f, 6.19062670e-02f, -1.02475762e-01f, -9.00532380e-02f, 2.03269318e-01f, 8.83159637e-02f, -3.82124446e-02f,
  -1.06072731e-01f, -1.70355797e-01f, 4.44338024e-02f, -8.41977447e-02f, -1.92710429e-01f, -3.31386253e-02f, -3.35962996e-02f, -1.07076734e-01f, 1.37346491e-01f, -4.67698127e-02f,
  -1.98227819e-02f, -1.77166551e-01f, -8.05955902e-02f, 2.62097735e-02f, -1.41808782e-02f, 1.57654777e-01f, -1.12893820e-01f, 1.70821380e-02f, -1.09469190e-01f, -8.55879560e-02f,
  -7.50086689e-03f, 3.70026194e-02f, 8.17359332e-03f, 1.91296153e-02f, 5.26213199e-02f, -9.69846547e-02f, 1.51306903e-02f, -8.93197730e-02f, -2.86355652e-02f, 5.65159954e-02f,
  7.54552782e-02f, -4.05529253e-02f, 6.79573268e-02f, 4.11416069e-02f, 6.92434832e-02f, -4.74935921e-04f, 3.80911231e-02f, 5.08479439e-02f, 5.14233783e-02f, -7.16777593e-02f,
  -4.18748483e-02f, 1.58768743e-02f, 2.04715095e-02f, 2.30459850e-02f, 6.01923428e-02f, 4.94425893e-02f, 3.00145317e-02f, -6.19964115e-02f, -3.72119881e-02f, 5.25925048e-02f,
  -2.06682160e-02f, -3.10237408e-02f, 1.22202830e-02f, -5.11984192e-02f, -7.92367384e-02f, 9.34362486e-02f, -2.93269735e-02f, -2.51000486e-02f, 5.33561558e-02f, -2.59219967e-02f,
  2.66002268e-02f, -4.84044775e-02f, 3.34904827e-02f, -6.89168572e-02f, -4.16764878e-02f, 1.56704541e-02f, -2.69017220e-02f, 4.66647334e-02f, -2.53603999e-02f, 5.24625666e-02f,
  -3.16613656e-03f, -1.40370019e-02f, 2.95174029e-02f, 7.99729768e-03f, 5.76637052e-02f, -3.07858642e-02f, -6.20697439e-02f, 6.12073503e-02f, -4.73183617e-02f, -8.15688968e-02f,
  -1.20031671e-03f, 1.52908236e-01f, -1.16072251e-02f, 1.57480631e-02f, -2.08224561e-02f, -6.52861819e-02f, -2.70607974e-02f, 8.68186206e-02f, 5.89985177e-02f, -5.75571433e-02f,
  -1.87660195e-02f, -3.62698473e-02f, -1.95581913e-02f, 3.92186306e-02f, -8.47374350e-02f, 2.14954168e-02f, -1.14299892e-03f, 2.22302638e-02f, -2.39635203e-02f, -2.45299973e-02f,
  2.18410715e-02f, 4.13717702e-02f, -8.12947676e-02f, 3.49101052e-03f, 1.80788450e-02f, -5.42184487e-02f, 8.75324197e-03f, 2.24537887e-02f, 8.26095790e-02f, 7.36497715e-03f,
  1.07124753e-01f, -2.78610736e-01f, -1.07819922e-01f, 3.75700071e-02f, 1.78235367e-01f, 1.30428299e-01f, 7.20387623e-02f, 6.90896902e-03f, -1.15462177e-01f, -1.35697976e-01f,
  3.21412273e-02f, 3.67081687e-02f, -6.34159893e-02f, 9.39290375e-02f, 2.26988882e-01f, -5.13465926e-02f, 2.15230882e-02f, 8.45147744e-02f, 2.62247156e-02f, 1.05525158e-01f,
  1.39433175e-01f, 2.30219632e-01f, 1.74334720e-01f, 4.44847569e-02f, 1.19470343e-01f, 8.22555972e-04f, 4.72340845e-02f, 8.79479349e-02f, 9.30936337e-02f, 1.36535808e-01f,
  -2.90191993e-02f, -7.45880976e-03f, -5.01469858e-02f, 7.04245595e-03f, 1.77884735e-02f, -6.44926801e-02f, 8.19396004e-02f, 3.67467888e-02f, -9.71378293e-03f, -6.51633739e-02f,
  3.07862670e-03f, 6.16032742e-02f, -3.72680314e-02f, -1.15955295e-02f, 9.11849961e-02f, 2.17723977e-02f, 1.15629670e-03f, 3.66227441e-02f, -6.05070824e-03f, -8.74156505e-03f,
  7.19037428e-02f, -3.18347327e-02f, -6.25828803e-02f, -9.30844769e-02f, -5.49458619e-03f, -7.00503960e-02f, -7.98741356e-02f, -6.99416734e-03f, -8.94299522e-02f, -2.69641671e-02f,
  6.10624813e-03f, -7.30657810e-03f, -3.65244388e-03f, 1.56597029e-02f, -2.85772327e-02f, 4.94286492e-02f, 1.86244845e-02f, -8.03633448e-05f, -3.51734869e-02f, -4.16067604e-04f,
  3.18152606e-02f, 5.00165522e-02f, -2.01314799e-02f, 6.53546602e-02f, -3.43412091e-03f, -7.25244284e-02f, -2.78842519e-03f, 3.10491566e-02f, -4.74514589e-02f, 4.26981524e-02f,
  -3.40192579e-02f, 7.09605590e-02f, -4.63907309e-02f, -1.52094355e-02f, -9.46921017e-03f, -8.49885400e-03f, -5.64612001e-02f, -2.67433114e-02f, 1.64017398e-02f, 5.99486902e-02f,
  -6.89491853e-02f, -1.79195821e-01f, -3.38936523e-02f, 3.25845219e-02f, -8.38656798e-02f, 9.24657378e-03f, -6.55345172e-02f, 4.54436950e-02f, 5.93643486e-02f, 6.23110980e-02f,
  3.96950021e-02f, -9.03492514e-03f, -1.06580472e-02f, 7.66357780e-02f, -4.41871658e-02f, -5.71777523e-02f, -4.22741548e-04f, -6.46802858e-02f, 7.36031681e-02f, -2.08448358e-02f,
  -3.27303857e-02f, 5.90991788e-03f, -3.52007188e-02f, 2.44431607e-02f, 2.78790705e-02f, -3.16788256e-02f, -1.90497246e-02f, 3.05610034e-03f, 5.20311557e-02f, -1.44440625e-02f,
  -1.06450520e-01f, 4.32772301e-02f, 1.26890972e-01f, -2.02272147e-01f, -1.67610031e-02f, 9.10670981e-02f, 6.46094531e-02f, -8.27358738e-02f, -6.62986785e-02f, -2.47484539e-02f,
  4.77766022e-02f, -5.61621524e-02f, 1.56792596e-01f, 5.85612953e-02f, 5.95090329e-04f, 2.09300548e-01f, 1.89009830e-02f, 6.67556524e-02f, -4.64209309e-03f, -1.86309353e-01f,
  -7.20738471e-02f, -1.04964301e-01f, 6.45525604e-02f, -4.62138392e-02f, -7.64996484e-02f, -1.28217250e-01f, -1.23343915e-01f, -4.08623219e-02f, -3.39456499e-02f, 1.04870819e-01f,
  -4.66144420e-02f, -1.98732078e-01f, -8.14792812e-02f, 5.63860647e-02f, 4.36395779e-02f, -2.79389452e-02f, 8.90856236e-03f, -1.70648806e-02f, -3.39925252e-02f, -2.87410989e-02f,
  -1.27922306e-02f, -5.30107005e-04f, 2.12756488e-02f, 7.89448842e-02f, 1.06941573e-02f, -2.15135459e-02f, 2.66142450e-02f, 5.76425157e-03f, 1.77003052e-02f, 3.00679561e-02f,
  6.83225319e-02f, 4.45823185e-02f, -8.11700337e-03f, 6.77469373e-02f, -1.70256644e-02f, -3.84815522e-02f, -3.15408334e-02f, -5.47593506e-03f, 1.73424296e-02f, -2.19509676e-02f,
  -4.18340154e-02f, 3.50252986e-02f, -3.83270830e-02f, 5.67984767e-03f, 4.07763943e-02f, -1.70636121e-02f, 2.58783922e-02f, -1.68617498e-02f, 3.10197361e-02f, -3.08051426e-03f,
  5.12522310e-02f, -6.15295619e-02f, -1.81843247e-02f, 4.03092913e-02f, -3.69921066e-02f, -3.36648636e-02f, 2.22921148e-02f, 1.15490295e-02f, -2.10815463e-02f, 3.08091808e-02f,
  3.64295803e-02f, -4.13720459e-02f, 9.85500589e-02f, -7.13759139e-02f, -5.99503480e-02f, -1.48998655e-03f, 6.45225123e-02f, 5.93978427e-02f, -1.60000660e-02f, -1.10681616e-02f,
  -1.68636441e-01f, -2.13270590e-01f, -5.58786914e-02f, -1.10319048e-01f, -5.05866073e-02f, -2.15572827e-02f, -1.83544178e-02f, 6.83485270e-02f, -8.08819160e-02f, 1.70907248e-02f,
  -5.62130548e-02f, -1.43659180e-02f, -7.64834136e-02f, -1.41513515e-02f, 1.65277999e-02f, -6.74049631e-02f, -1.08183902e-02f, 3.04974262e-02f, -1.20129906e-01f, -4.40203696e-02f,
  -7.63066038e-02f, -9.96792912e-02f, 2.63078567e-02f, -8.49566981e-02f, 1.36632705e-03f, -5.91736753e-03f, -5.35322353e-02f, 4.16699834e-02f, 1.36274621e-02f, 3.18863392e-02f,
  -2.21740246e-01f, 3.08519363e-01f, -9.29418132e-02f, -2.30664775e-01f, -1.06275141e-01f, 2.64923461e-02f, 2.71173939e-02f, 9.75586846e-02f, -3.59403854e-03f, 2.44665310e-01f,
  7.04655498e-02f, -1.36469826e-01f, 1.66141480e-01f, 5.72610013e-02f, -2.16066360e-01f, 9.34864432e-02f, 3.98480296e-02f, 9.48721692e-02f, 1.83313771e-03f, 1.27631411e-01f,
  1.01594133e-02f, 1.14920996e-02f, -1.12528123e-01f, 1.10206135e-01f, -6.61525130e-02f, -3.66509818e-02f, 5.49796820e-02f, 9.14800987e-02f, 7.58520886e-02f, 4.14671935e-03f,
  1.03669986e-01f, 6.04628026e-02f, 1.80988777e-02f, 9.14121494e-02f, -1.19648557e-02f, -4.40012291e-02f, 3.15725207e-02f, 1.23528810e-02f, -2.97613461e-02f, 1.70809962e-02f,
  -1.91441197e-02f, -3.34742442e-02f, -5.46934195e-02f, -5.87822981e-02f, 2.56711543e-02f, -9.25441552e-03f, -1.92655735e-02f, -3.94944102e-02f, 6.58099428e-02f, -2.13144589e-02f,
  -3.54817621e-02f, -5.08278832e-02f, -8.35243687e-02f, 4.69863452e-02f, -5.44826826e-03f, -3.00986366e-03f, -2.79860441e-02f, 1.66927390e-02f, 1.52331805e-02f, -9.51703358e-03f,
  -6.31970018e-02f, 9.01819393e-03f, -4.12103459e-02f, 3.47608440e-02f, 2.20593102e-02f, -6.99179107e-03f, -1.42890662e-02f, -1.23202289e-02f, 4.04815702e-03f, 4.55923155e-02f,
  1.97276957e-02f, -1.91927943e-02f, -2.53987573e-02f, 6.44298643e-02f, -5.08182682e-02f, 3.63239534e-02f, 5.52921444e-02f, 1.09720211e-02f, -6.81104744e-03f, -1.13316782e-01f,
  3.46825980e-02f, 9.70175266e-02f, 4.34551984e-02f, -1.09147211e-03f, 2.27700621e-02f, -1.78780425e-02f, 2.89055263e-03f, 7.03480691e-02f, -1.46675983e-03f, -4.30262536e-02f,
  3.20627719e-01f, 2.52042651e-01f, 5.64298546e-03f, 3.16078700e-02f, 8.30908567e-02f, 5.14163338e-02f, -1.60170309e-02f, -2.69523989e-02f, 7.50664473e-02f, 5.15380548e-03f,
  5.57421707e-02f, -1.29627716e-03f, 1.04508195e-02f, -4.06915769e-02f, 2.31836159e-02f, 3.26340869e-02f, 8.28366503e-02f, 1.17924884e-02f, -3.60832065e-02f, -2.05587596e-02f,
  3.74593511e-02f, 9.10242796e-02f, -4.89978045e-02f, -6.93548918e-02f, -6.07612990e-02f, -2.83852722e-02f, -4.21391204e-02f, 8.10118951e-03f, 2.16356479e-02f, 2.30005309e-02f,
  -9.91313457e-02f, 1.60989285e-01f, 2.50477582e-01f, -3.13686468e-02f, -1.85695022e-01f, -1.01825327e-01f, -5.65081090e-03f, -1.28648117e-01f, 8.40691254e-02f, -9.21401531e-02f,
  -1.31782830e-01f, 2.43654996e-01f, 1.39432684e-01f, 3.56714725e-02f, 1.90239340e-01f, 1.55686587e-01f, -1.03291593e-01f, -2.43174359e-02f, 3.62010300e-02f, -3.21292155e-03f,
  -1.95257310e-02f, -1.24694422e-01f, 2.02962905e-01f, -1.87613860e-01f, -1.40171781e-01f, -5.78494705e-02f, -9.59429815e-02f, 1.19907491e-01f, -1.73357978e-01f, 4.32672501e-02f,
  4.38101031e-02f, 2.07985025e-02f, 5.81285954e-02f, 2.18660031e-02f, -7.82242417e-02f, -9.83813778e-02f, -5.76614775e-02f, 1.01595469e-01f, -3.75759974e-02f, 8.74815434e-02f,
  4.70224619e-02f, 7.19899684e-02f, 1.83362495e-02f, -2.73829792e-03f, -2.83470540e-03f, -8.94243736e-03f, 5.71376039e-03f, 2.98049040e-02f, -1.49102863e-02f, 6.00968823e-02f,
  8.33257958e-02f, 9.45361052e-03f, -8.44499543e-02f, 4.62579280e-02f, 6.84213266e-03f, -1.35388676e-04f, 4.56003137e-02f, 6.81253150e-02f, -7.66451880e-02f, 5.36587983e-02f,
  -6.39259890e-02f, -1.24786459e-02f, -1.87064279e-02f, 3.95969413e-02f, -7.11312890e-02f, -1.13832634e-02f, -4.22238111e-02f, 2.53337845e-02f, -3.78414653e-02f, -1.52298473e-02f,
  -8.39568581e-03f, 1.42257474e-02f, 2.97671128e-02f, -7.43296072e-02f, -6.00780286e-02f, 1.24718342e-02f, -1.58202723e-02f, -3.76342684e-02f, -2.75516994e-02f, 1.45574622e-02f,
  8.68155956e-02f, -1.49762956e-02f, 2.72956640e-02f, 5.11881139e-04f, 6.35201633e-02f, -4.02098475e-03f, -6.66837916e-02f, 3.38227190e-02f, 2.52282284e-02f, -6.77167773e-02f,
  -1.31199360e-01f, -1.04433425e-01f, 3.56204994e-03f, 7.78270140e-02f, 7.05408752e-02f, -7.29891583e-02f, 7.54350722e-02f, 1.32625056e-02f, 4.39653173e-03f, -7.56262988e-02f,
  -1.01720288e-01f, -7.47385621e-02f, -3.85482945e-02f, -8.86318367e-03f, -3.49530689e-02f, 7.83118885e-03f, -5.96103482e-02f, -6.68531880e-02f, -6.29128963e-02f, 6.47440739e-03f,
  -3.59744616e-02f, -1.72384139e-02f, 2.25156602e-02f, -8.30972120e-02f, -9.45539027e-02f, -8.21501613e-02f, -7.19126081e-03f, 2.53355317e-02f, 3.36810127e-02f, 5.48964133e-03f,
  -1.66916832e-01f, -1.04701161e-01f, -1.72152948e-02f, -2.78628375e-02f, -1.04627572e-01f, 5.84674366e-02f, 1.45164549e-01f, -2.27702651e-02f, -3.20341513e-02f, 3.54520194e-02f,
  -8.88111740e-02f, 1.10110315e-02f, 1.29556311e-02f, 7.82580003e-02f, 1.34346604e-01f, 2.37231366e-02f, 4.94891182e-02f, 8.70064348e-02f, -7.65864998e-02f, -1.23035498e-01f,
  -5.53997059e-04f, -5.35871647e-02f, -5.52619761e-03f, -6.77707940e-02f, -1.04688890e-01f, -8.58029202e-02f, -3.73191596e-03f, 2.82374267e-02f, 1.22232381e-02f, -5.09918369e-02f,
  -1.40111046e-02f, -1.71317965e-01f, -4.90447506e-02f, -1.01570757e-02f, -6.48406148e-02f, 8.81916732e-02f, -7.25605874e-04f, 2.87903212e-02f, 3.80059853e-02f, -9.76515636e-02f,
  3.59386876e-02f, 5.71206547e-02f, -9.24075693e-02f, 3.23228911e-02f, 5.72950616e-02f, 1.03319483e-02f, -6.30370621e-03f, 4.49063219e-02f, -2.24965699e-02f, 7.47840330e-02f,
  1.09882867e-02f, -7.12230280e-02f, -5.39682992e-02f, -3.14651232e-04f, -5.13452850e-02f, -3.80818658e-02f, 7.09930260e-04f, -3.56692225e-02f, 3.36880758e-02f, -9.17348191e-02f,
  6.32743686e-02f, -7.07187280e-02f, 6.66509196e-02f, -6.38595223e-02f, -8.42626244e-02f, 3.63225234e-03f, 6.92698956e-02f, 2.32289005e-02f, 5.39439581e-02f, 2.73182280e-02f,
  -1.02657992e-02f, 2.00729575e-02f, 4.94936593e-02f, 4.66975309e-02f, -3.90308425e-02f, 4.71646450e-02f, 3.77627462e-02f, -7.46774450e-02f, 3.35434079e-02f, -6.74455836e-02f,
  -2.61537097e-02f, 3.65920961e-02f, -6.89609498e-02f, -4.10284288e-02f, -3.60110216e-02f, -9.26490799e-02f, -7.57164359e-02f, -1.09076351e-02f, 6.96691349e-02f, 2.43132059e-02f,
  -7.22280145e-02f, -1.48321241e-01f, -7.49473870e-02f, -7.90188313e-02f, 2.26161238e-02f, 5.01964986e-02f, 3.69873419e-02f, 7.21740201e-02f, -1.12834722e-01f, -2.58413907e-02f,
  -1.27417650e-02f, 7.80182984e-03f, 2.22691540e-02f, -3.77915278e-02f, 1.05233416e-01f, -5.20098917e-02f, -3.72980163e-02f, -2.98768487e-02f, 4.28864695e-02f, 1.31241756e-03f,
  3.24512683e-02f, 5.41465543e-03f, 4.79066595e-02f, -3.49737704e-02f, 6.22578077e-02f, 9.11446288e-02f, -2.44168267e-02f, -6.04403429e-02f, -3.91116627e-02f, 5.48299626e-02f,
  7.89776817e-02f, -1.12837709e-01f, -2.44586959e-01f, -1.91132221e-02f, 1.43001899e-02f, -6.74507208e-03f, -1.11604661e-01f, -1.51281536e-01f, 5.18077239e-02f, -8.00392963e-03f,
  1.07058004e-01f, -3.52929980e-02f, -1.22519601e-02f, 1.03966668e-01f, 2.14355141e-02f, -1.00607246e-01f, 5.65578900e-02f, 8.19325969e-02f, -1.09717913e-01f, -1.30084440e-01f,
  6.52695000e-02f, 1.22806519e-01f, -2.92488392e-02f, -2.04034336e-02f, 3.41856144e-02f, -1.03352152e-01f, 8.15416723e-02f, -2.27792218e-01f, -4.13848348e-02f, -7.21604675e-02f,
  5.49083687e-02f, -6.81798011e-02f, -6.21262118e-02f, -6.90814704e-02f, 5.72898909e-02f, 8.03381652e-02f, -8.74457955e-02f, -7.15267807e-02f, -2.14234591e-02f, -6.11815117e-02f,
  1.98198222e-02f, -3.51847224e-02f, 7.11222738e-02f, 9.30797961e-03f, 3.80048491e-02f, -4.20337580e-02f, 2.55983882e-02f, 1.09280765e-01f, -2.35660095e-02f, -1.03421308e-01f,
  9.26372409e-03f, -2.24954705e-03f, 3.37870494e-02f, 7.27211013e-02f, -2.08049249e-02f, -5.19850217e-02f, -1.92783922e-02f, -9.77590233e-02f, 3.68440077e-02f, -7.42896721e-02f,
  6.33012205e-02f, -6.79734722e-02f, -5.12057319e-02f, 1.39052104e-02f, -5.24821691e-02f, 1.04368739e-01f, -4.10506129e-02f, -5.41245900e-02f, 4.31241617e-02f, 4.37512919e-02f,
  -2.41438113e-02f, 1.96952745e-02f, -2.67882459e-02f, -1.02979913e-02f, -3.39602530e-02f, 1.56989903e-03f, -7.20031932e-02f, 1.74729619e-02f, 5.34263812e-02f, 4.91418596e-03f,
  -1.00946547e-02f, 3.73565294e-02f, 2.24396866e-02f, -7.78038707e-03f, 4.52145226e-02f, -5.51581644e-02f, 5.05401306e-02f, -1.38212405e-02f, 3.57237943e-02f, -9.74318162e-02f,
  9.02243257e-02f, -3.58006544e-02f, 6.26367703e-02f, 9.86663103e-02f, 1.03670619e-02f, 2.45674551e-02f, 4.21773009e-02f, 7.73003697e-02f, -3.03485245e-02f, -2.28769705e-02f,
  1.51685048e-02f, 1.99006032e-02f, -2.35984530e-02f, -6.43095151e-02f, -7.55396998e-03f, -2.94799614e-03f, 2.60062404e-02f, 7.28567969e-03f, 3.31127197e-02f, 4.12385836e-02f,
  -2.14282796e-02f, -4.26169448e-02f, -4.68078107e-02f, -4.33170311e-02f, -2.73149949e-03f, 8.69671181e-02f, -1.72403678e-02f, 1.12603260e-02f, 8.23593605e-03f, -6.47063479e-02f,
  -1.30450904e-01f, -4.74950783e-02f, 1.22796789e-01f, 3.99446040e-02f, -4.16559316e-02f, 1.68703318e-01f, 2.19209313e-01f, -3.27640995e-02f, 2.13845268e-01f, -1.24663852e-01f,
  6.52745664e-02f, -8.21931660e-02f, 1.60121053e-01f, -1.26145333e-01f, 2.56006420e-02f, 2.33288690e-01f, -5.12089729e-02f, 1.13429865e-02f, 2.24658456e-02f, -1.09343231e-01f,
  3.14031318e-02f, -2.17314124e-01f, -9.26627405e-03f, -1.69801638e-01f, -1.85942426e-01f, -7.47981369e-02f, -2.43302971e-01f, 1.18983701e-01f, -1.86727807e-01f, -7.75659680e-02f,
  -9.68219042e-02f, 1.59726385e-02f, -4.43465449e-02f, 1.06605351e-01f, -6.52738810e-02f, -9.46207121e-02f, 3.82078551e-02f, 6.10791259e-02f, 1.91265605e-02f, 5.38396202e-02f,
  -2.98626168e-04f, 4.53792699e-02f, -8.10486823e-02f, 2.54845824e-02f, 1.81680843e-02f, -3.40773016e-02f, -2.51393504e-02f, 7.94477016e-03f, -6.66205660e-02f, 3.16753946e-02f,
  9.55488440e-03f, -7.49483332e-02f, -3.82176712e-02f, 3.84311378e-02f, 1.17441542e-01f, -9.17629339e-03f, -4.11290824e-02f, -7.62598729e-03f, -6.45061359e-02f, -8.36088955e-02f,
  1.06038466e-01f, -3.91179323e-02f, -5.06576784e-02f, -6.83656037e-02f, -1.43356146e-02f, 7.75445765e-03f, -2.84637753e-02f, 3.13420407e-02f, -3.77277434e-02f, -8.84509608e-02f,
  -9.30727795e-02f, -2.95111686e-02f, -3.58764231e-02f, 8.54782481e-03f, 8.02614354e-03f, -4.18544523e-02f, -3.04309335e-02f, 1.66165214e-02f, -6.47438839e-02f, -5.42928912e-02f,
  -8.38023610e-03f, 2.45838687e-02f, -6.46624118e-02f, 2.23132838e-02f, -6.63311034e-03f, 4.49873507e-02f, 4.35996801e-02f, 6.02241606e-02f, -3.05280779e-02f, -2.16788165e-02f,
  -1.40126944e-01f, -1.31766155e-01f, -1.89616513e-02f, -4.06323117e-04f, -7.83755928e-02f, 2.76198275e-02f, -4.74870503e-02f, -1.77830532e-02f, -7.16833165e-06f, 6.10386245e-02f,
  -7.26599023e-02f, 4.50478941e-02f, -2.79314835e-02f, 6.43403903e-02f, -6.81718485e-03f, 1.74987111e-02f, 2.85424311e-02f, -2.50728242e-02f, 6.82210224e-03f, -6.24676272e-02f,
  2.51812651e-03f, 2.08959300e-02f, -6.82597533e-02f, -4.48899008e-02f, -4.35839593e-02f, -2.72722100e-03f, -9.78645682e-02f, 2.71204691e-02f, 2.97914036e-02f, -2.12752577e-02f,
  1.62872188e-02f, 1.01256408e-01f, 1.81293502e-01f, 5.63415252e-02f, 9.92442593e-02f, 4.48015891e-02f, -1.38944820e-01f, 9.64560509e-02f, 1.36993691e-01f, -8.83110240e-02f,
  -1.91168413e-02f, 8.27988144e-03f, -7.82006513e-03f, -6.70516957e-03f, -3.29983801e-01f, -1.16578341e-01f, -1.01564355e-01f, -8.34054407e-03f, 6.96096569e-02f, -1.70199275e-02f,
  1.29869908e-01f, -1.31464228e-01f, -5.58537878e-02f, -1.57198980e-02f, 8.09084848e-02f, 1.93153620e-01f, -2.40644887e-01f, 9.28118378e-02f, -3.82178798e-02f, -2.79611461e-02f,
  3.53026912e-02f, 2.80096345e-02f, 1.04927301e-01f, 3.49063911e-02f, -1.20130535e-02f, -2.06318242e-03f, 5.61630912e-03f, -5.72972633e-02f, 7.22699612e-02f, -1.02490536e-03f,
  3.42128649e-02f, -1.23844147e-02f, 5.15866205e-02f, 4.02907245e-02f, -3.60454917e-02f, 7.13754594e-02f, 7.74206743e-02f, -1.19906887e-02f, 1.21512571e-02f, 1.17448181e-01f,
  1.43145040e-01f, 1.28868204e-02f, 5.81365973e-02f, -1.28044531e-01f, -4.63331956e-03f, -9.35923494e-03f, -5.97658157e-02f, 3.55068478e-04f, -4.74712066e-02f, 8.42306390e-02f,
  3.93859744e-02f, 6.28637746e-02f, -6.95033371e-02f, 3.50720361e-02f, -6.55327588e-02f, -2.41850130e-02f, 1.76712163e-02f, -2.69499719e-02f, -4.13557421e-03f, -5.98749369e-02f,
  5.11909910e-02f, -4.32413183e-02f, 7.47958049e-02f, -4.03592512e-02f, 3.17140408e-02f, -1.53543083e-02f, -1.09818891e-01f, -2.74393409e-02f, 5.63733187e-03f, 3.75245251e-02f,
  -8.54020864e-02f, 2.70644799e-02f, -3.33050266e-02f, 5.37241288e-02f, -7.11217448e-02f, 2.70590209e-03f, 1.67506412e-02f, 2.31917221e-02f, 8.57120287e-03f, 1.77612584e-02f,
  -1.91026777e-01f, -2.26824135e-01f, 4.58944179e-02f, -4.98328023e-02f, -3.45409079e-03f, 1.30262896e-02f, -3.29244100e-02f, 9.11418647e-02f, -6.46981969e-02f, 3.55288498e-02f,
  6.70675328e-03f, 1.29397875e-02f, -9.55927297e-02f, -1.70103703e-02f, 1.31206494e-02f, -8.11977759e-02f, -7.81934485e-02f, -3.63430828e-02f, -9.69329029e-02f, -2.82474235e-02f,
  -3.22745480e-02f, -1.26742318e-01f, -4.96851355e-02f, -7.30264708e-02f, -1.95644777e-02f, -5.17530367e-02f, 2.25328077e-02f, 7.09696338e-02f, 1.44877117e-02f, -5.70887253e-02f,
  -7.77088329e-02f, -1.17519751e-01f, 3.64720002e-02f, 7.86670856e-03f, -2.20068514e-01f, 1.64022278e-02f, 6.67606816e-02f, -1.69776440e-01f, -2.54320472e-01f, -4.54623364e-02f,
  -2.83876490e-02f, 1.56504828e-02f, 2.07159653e-01f, -6.74080923e-02f, 2.01221690e-01f, 2.39874229e-01f, -2.41670152e-03f, 1.93529185e-02f, -2.57633179e-02f, -1.36966676e-01f,
  3.11426837e-02f, -1.96784362e-02f, 2.47044414e-01f, -5.66386655e-02f, 5.90078859e-03f, 2.05444712e-02f, 8.81452858e-02f, 5.40567264e-02f, 4.28979658e-02f, 1.01546951e-01f,
  -1.46798745e-01f, -1.80060580e-01f, -8.58754963e-02f, -3.56699489e-02f, -7.48384669e-02f, -3.00074015e-02f, 5.14328443e-02f, 1.09165711e-02f, 6.05343468e-02f, 4.63250913e-02f,
  -4.71254752e-04f, -8.40479136e-02f, -7.61938989e-02f, 1.09708756e-01f, -5.82300015e-02f, -7.62125775e-02f, 1.27327330e-02f, 3.78346816e-02f, -2.16609556e-02f, 2.00588088e-02f,
  -4.04647850e-02f, 3.48354429e-02f, 4.76134242e-03f, 5.29700741e-02f, -3.73516083e-02f, 1.52895646e-02f, -1.36324065e-02f, 5.88825252e-03f, 4.49164025e-02f, -6.36684075e-02f,
  5.06944768e-03f, -3.65518183e-02f, 2.78482791e-02f, 4.49571647e-02f, -2.14983020e-02f, -5.14657609e-02f, 4.36735488e-02f, 3.52588780e-02f, 1.42160170e-02f, 2.90728081e-02f,
  -4.07402255e-02f, 5.53954132e-02f, 2.55402941e-02f, -3.23588289e-02f, -5.77318296e-02f, 1.33061754e-02f, -3.73248160e-02f, 2.34096777e-02f, 5.47375046e-02f, 2.96478663e-02f,
  -3.64799201e-02f, -2.21691020e-02f, 3.28295156e-02f, -3.94289903e-02f, -2.02997532e-02f, 6.46202639e-03f, 4.77783335e-03f, 2.34742947e-02f, -1.27148889e-02f, 1.46053433e-02f,
  -1.81889415e-01f, -3.16229314e-02f, -6.52986243e-02f, -9.00640115e-02f, -7.78636895e-03f, -5.29070795e-02f, 1.71748977e-02f, -4.18486372e-02f, -4.33830172e-02f, 2.11349688e-02f,
  -1.08357079e-01f, 2.08316185e-02f, 4.61449064e-02f, 1.24707790e-02f, -2.33827182e-03f, -3.27576068e-03f, 7.83647001e-02f, 1.54129099e-02f, -8.36176574e-02f, -1.33730173e-02f,
  6.06385916e-02f, -7.89105371e-02f, -3.17871831e-02f, -1.01589605e-01f, 5.16218245e-02f, -4.05646265e-02f, -1.28211426e-02f, 6.82540536e-02f, 3.91231403e-02f, -1.21827666e-02f,
  1.53689444e-01f, 1.51930228e-01f, 6.70313761e-02f, 2.30631590e-01f, -3.08973901e-02f, -2.20047638e-01f, -1.79993138e-01f, -2.25500744e-02f, 5.52190542e-02f, -6.62418753e-02f,
  -1.54045030e-01f, 1.77828237e-01f, -1.50165111e-01f, 1.19461633e-01f, 7.78294802e-02f, -1.39273435e-01f, -2.38940101e-02f, 6.26490414e-02f, 1.02471702e-01f, 9.49706286e-02f,
  4.15696763e-02f, 3.52464467e-02f, 1.38916090e-01f, 3.19223590e-02f, -2.78574824e-02f, 1.36289775e-01f, 9.13864672e-02f, -7.56130889e-02f, 9.42537710e-02f, 3.65734063e-02f,
  -3.86768430e-02f, -2.75935773e-02f, 5.94217628e-02f, 5.47086112e-02f, -8.87193456e-02f, -3.52332741e-02f, 1.74483657e-02f, 2.12637670e-02f, 1.75724104e-02f, -5.01469113e-02f,
  -1.21876402e-02f, 5.75095117e-02f, 6.10126602e-03f, -2.67652515e-02f, 8.05464089e-02f, 7.03773499e-02f, 7.51383370e-03f, -6.30114553e-03f, -1.96503121e-02f, 9.90964547e-02f,
  4.94752750e-02f, 1.33022480e-02f, 3.92496698e-02f, 8.65778551e-02f, 1.01069644e-01f, 5.19319139e-02f, 1.10145919e-02f, 3.72555144e-02f, 1.29756508e-02f, -4.06353772e-02f,
  1.82394125e-02f, -7.91900307e-02f, -6.43860688e-03f, 8.05160627e-02f, 9.79083776e-03f, 4.23661210e-02f, 6.94469688e-03f, 3.35477740e-02f, 1.31922495e-02f, -1.87926237e-02f,
  2.04727706e-02f, 5.19574285e-02f, -1.67682506e-02f, 6.02547042e-02f, 6.18758751e-03f, -8.98414117e-04f, -3.61682475e-02f, 3.92493680e-02f, 1.25019439e-02f, 4.80470713e-03f,
  4.78372090e-02f, -3.99823859e-02f, 2.15366930e-02f, -1.49409166e-02f, 2.42799446e-02f, -1.83029659e-02f, 1.94741841e-02f, 3.21362577e-02f, -5.84947355e-02f, 8.58157873e-03f,
  -2.71874256e-02f, 6.37603775e-02f, 4.02511396e-02f, -5.45972679e-03f, -7.35539419e-04f, -1.63861457e-02f, -2.20545009e-02f, 2.13169195e-02f, -3.72567326e-02f, 2.71562324e-03f,
  -1.73361693e-02f, -1.26237469e-03f, 5.80619313e-02f, 4.57929112e-02f, -7.69737437e-02f, 9.30429716e-03f, -7.01868981e-02f, 1.24172280e-02f, -1.13094114e-02f, -3.09434012e-02f,
  -6.91665560e-02f, 4.64057103e-02f, 2.68784296e-02f, -5.16740642e-02f, -1.73689742e-02f, -3.22875865e-02f, 4.52384539e-02f, -3.63136716e-02f, 4.59681731e-03f, 1.98021401e-02f,
  -1.42607003e-01f, 3.20667885e-02f, 6.04181290e-02f, -1.42841145e-01f, -4.41145040e-02f, -2.02620089e-01f, -2.44485721e-01f, 5.23970351e-02f, 9.12359133e-02f, -8.65217671e-02f,
  -5.61049245e-02f, 1.24668619e-02f, -6.44576456e-03f, -1.70753688e-01f, -4.55328915e-03f, -3.91456597e-02f, -8.62070546e-02f, -1.24250293e-01f, 5.61219268e-02f, -3.04000042e-02f,
  2.94244289e-02f, -2.08133131e-01f, -5.45052029e-02f, 1.50255663e-02f, -3.35689262e-02f, 5.15778847e-02f, -5.37982322e-02f, -4.94281799e-02f, -1.43814459e-01f, -3.27928029e-02f,
  -5.52565418e-02f, 2.48526875e-02f, 4.06212024e-02f, 6.22764528e-02f, -6.05642535e-02f, -2.28291284e-02f, -1.01815142e-01f, -5.10006510e-02f, -4.02024053e-02f, 1.82664040e-02f,
  -6.81412071e-02f, 7.91358724e-02f, -1.31112710e-02f, 1.69237629e-02f, 4.28276993e-02f, -2.60659470e-03f, 5.35776243e-02f, 1.35198375e-02f, -3.50833237e-02f, -5.45120202e-02f,
  -1.75174084e-02f, -1.04316408e-02f, 3.59708630e-02f, 1.68939307e-02f, 9.10501331e-02f, -6.64684828e-03f, 1.15201101e-02f, 8.97431448e-02f, -4.99748252e-02f, 4.21021646e-03f,
  -7.03530908e-02f, -3.45111056e-03f, 2.01333184e-02f, -1.68201514e-02f, -1.52090695e-02f, -2.46337000e-02f, -2.16232277e-02f, -6.11009859e-02f, 9.61491279e-03f, 1.75352190e-02f,
  -5.52140065e-02f, 1.63939875e-02f, -2.27102991e-02f, 6.62889555e-02f, -9.09191817e-02f, -1.23598669e-02f, 1.62183251e-02f, 1.46577528e-04f, 1.15903728e-02f, -3.64179374e-03f,
  -5.33303991e-02f, -3.90947312e-02f, -7.95142353e-03f, -8.03986788e-02f, 3.42851342e-03f, -2.44886801e-02f, 1.50168194e-02f, -4.61472571e-02f, 9.33208764e-02f, 2.77421977e-02f,
  -6.47725686e-02f, 2.64698751e-02f, 3.12536508e-02f, 3.07605490e-02f, -5.87054715e-03f, -6.72531128e-02f, 1.73352193e-02f, -6.25708178e-02f, -1.89638585e-02f, -6.97107315e-02f,
  5.91678917e-02f, -5.40193543e-03f, -6.15909807e-02f, -4.41032723e-02f, -5.70743419e-02f, -5.38388155e-02f, -8.43633115e-02f, 2.95469239e-02f, -2.13868376e-02f, 7.86426142e-02f,
  1.40919965e-02f, -1.64721925e-02f, 3.95516232e-02f, 5.62369786e-02f, 4.43051159e-02f, -2.40359250e-02f, -2.58228704e-02f, -3.47875953e-02f, -3.21610533e-02f, 1.03508784e-02f,
  -3.17734294e-02f, 3.28362025e-02f, -8.65158737e-02f, 1.21933669e-02f, -1.33251920e-01f, 8.55032280e-02f, -1.46707399e-02f, -1.12138785e-01f, -7.14876875e-02f, 1.80414081e-01f,
  9.43268016e-02f, 3.35536748e-02f, 1.30547598e-01f, -7.18637556e-02f, -1.33272246e-01f, 7.08970800e-02f, 7.76705593e-02f, 1.31951585e-01f, -7.01106563e-02f, -1.63434446e-02f,
  -8.29129666e-02f, -1.19578252e-02f, -1.75510213e-01f, -1.55098379e-01f, -3.41443457e-02f, -2.27538366e-02f, 1.12334959e-01f, 4.82071983e-03f, -3.58681530e-02f, 3.07179317e-02f,
  6.58937097e-02f, 5.63113540e-02f, -5.90032935e-02f, -4.81247567e-02f, 4.16705273e-02f, 8.22981074e-02f, -1.62799414e-02f, -1.59604456e-02f, -9.72461700e-02f, -7.48003274e-02f,
  1.21420160e-01f, 6.36671297e-03f, -6.83177635e-02f, -5.64604886e-02f, -1.01710841e-01f, -4.33922298e-02f, 5.82306385e-02f, 9.25869867e-03f, 3.91653273e-03f, -9.16552693e-02f,
  2.66416445e-02f, -8.20177048e-02f, -9.84762236e-02f, -4.82174754e-02f, 1.20136691e-02f, -6.99976012e-02f, 7.50059932e-02f, -1.63988825e-02f, 5.61114289e-02f, 5.32087944e-02f,
  1.46740586e-01f, 5.75869679e-02f, 6.89424574e-02f, -7.52726849e-03f, -5.82931601e-02f, -2.54207924e-02f, 2.43571028e-02f, 1.84563380e-02f, -6.45221025e-02f, -2.59571131e-02f,
  -2.07901541e-02f, -2.63470635e-02f, 3.22554223e-02f, -2.42909975e-02f, -3.43048461e-02f, -6.45561796e-03f, -7.12180138e-03f, 7.33597949e-02f, -7.03624561e-02f, -5.80713600e-02f,
  2.52120942e-03f, -1.01986909e-02f, 6.35086447e-02f, 5.07741682e-02f, -4.72201966e-02f, 3.35098132e-02f, -9.65329446e-03f, -5.97593337e-02f, 2.25835778e-02f, 4.45609763e-02f,
  2.83150151e-02f, 9.78853256e-02f, -7.42407218e-02f, -1.12324050e-02f, 5.29984720e-02f, 2.43418962e-02f, 6.88218549e-02f, -1.20654544e-02f, -2.38869395e-02f, -3.81612815e-02f,
  7.96703771e-02f, -4.06059660e-02f, -3.95406261e-02f, 7.11997598e-02f, 5.92787080e-02f, 2.15120856e-02f, -3.60327400e-02f, 1.12053519e-03f, -2.18066573e-02f, 8.47745091e-02f,
  3.15670408e-02f, 4.23813127e-02f, 4.34561260e-02f, 6.32632524e-02f, 9.90322754e-02f, 5.26535325e-03f, -2.97153406e-02f, 5.56034893e-02f, 7.33665377e-02f, 4.41839322e-02f,
  -6.38359934e-02f, -9.90317948e-03f, -2.25668456e-02f, -1.09521270e-01f, -2.51926538e-02f, 4.98457216e-02f, 1.97766244e-01f, -8.06256533e-02f, -1.51997834e-01f, 1.18651457e-01f,
  1.12475596e-01f, -9.41277072e-02f, 2.05648437e-01f, -1.35029610e-02f, 1.46564409e-01f, 8.90048891e-02f, 1.73168313e-02f, 5.38889281e-02f, -1.11178145e-01f, -3.89770716e-02f,
  -2.61263773e-02f, 1.68649167e-01f, 1.53070046e-02f, -3.68332694e-04f, -8.79502594e-02f, -1.83322936e-01f, 4.82097492e-02f, -1.47481291e-02f, 1.42354169e-03f, -1.06309708e-02f,
  4.73794788e-02f, -1.08930826e-01f, 1.79568387e-03f, 1.27615165e-02f, -4.98781353e-02f, 3.96897085e-02f, 5.35243079e-02f, -2.38807425e-02f, 3.78342159e-02f, 2.46605184e-02f,
  -1.07753277e-02f, -4.34353463e-02f, 5.25585599e-02f, -7.55693996e-03f, -8.99850503e-02f, 3.92412730e-02f, -6.19516708e-02f, -6.92553371e-02f, -7.05529079e-02f, -6.21685460e-02f,
  2.01614965e-02f, -3.71709988e-02f, -7.77817518e-02f, 4.66037132e-02f, -1.03596477e-02f, 2.55230325e-03f, 2.84875706e-02f, 7.40335882e-02f, -6.87335506e-02f, -6.82400540e-02f,
  -6.14950433e-02f, -2.08658837e-02f, 8.02924708e-02f, 3.19366902e-02f, -1.64114907e-02f, -5.83585643e-04f, 2.17606826e-03f, 5.87869249e-02f, -6.42029196e-02f, 8.94103050e-02f,
  -9.17717889e-02f, -5.39912879e-02f, 8.62083770e-03f, 4.64948341e-02f, -4.97176871e-02f, -5.28617725e-02f, 1.93217192e-02f, -7.67845660e-02f, -4.69803102e-02f, -6.93596452e-02f,
  3.65846083e-02f, 4.97267116e-03f, -3.88071388e-02f, 1.06755093e-01f, 1.43162804e-02f, 1.44520923e-02f, -4.04101685e-02f, -5.93787581e-02f, -8.89001042e-02f, 1.04442887e-01f,
  -5.30824885e-02f, 8.14129934e-02f, 2.73751151e-02f, -3.78756970e-02f, -4.65840697e-02f, -3.69233899e-02f, 2.47820336e-02f, 3.27596478e-02f, -2.32339054e-02f, -4.03131992e-02f,
  5.78899197e-02f, -3.87219414e-02f, -2.78608557e-02f, -1.57613046e-02f, -1.24917189e-02f, 8.48884415e-03f, 2.05282960e-02f, -6.96012229e-02f, 4.69445698e-02f, -1.73915289e-02f,
  -5.45394793e-03f, 8.06908682e-02f, 6.16153330e-02f, 1.78514719e-02f, 2.91801756e-03f, -3.63235474e-02f, 6.65088510e-03f, -3.19796279e-02f, 1.76281098e-03f, -5.28473407e-02f,
  -1.31444722e-01f, 1.14673726e-01f, -1.25761062e-01f, -4.60255705e-02f, -8.01138952e-02f, -6.02419861e-02f, -5.69004938e-02f, -2.36656908e-02f, -2.04180777e-01f, 6.60320595e-02f,
  1.03445556e-02f, -4.57359031e-02f, -3.12232878e-02f, 1.26047358e-01f, -6.83021396e-02f, 8.86099637e-02f, -8.28444734e-02f, -3.32945026e-02f, -1.59915730e-01f, 9.61155817e-02f,
  5.50269969e-02f, 1.34031877e-01f, 9.12350491e-02f, 6.62697628e-02f, 5.24298362e-02f, -5.53145856e-02f, 1.16780013e-01f, -7.50881061e-02f, 1.25727773e-01f, -4.44264635e-02f,
  -9.83120408e-04f, -1.02385439e-01f, 2.02747658e-02f, 8.34854469e-02f, -3.79667953e-02f, -5.18307872e-02f, -6.17436916e-02f, 2.26331074e-02f, -1.40374705e-01f, 5.16954847e-02f,
  -2.99799945e-02f, 8.68375525e-02f, 9.03250873e-02f, 3.35501023e-02f, -9.30666998e-02f, 4.71613444e-02f, 2.47519780e-02f, -6.77405894e-02f, 9.95487645e-02f, -3.95970829e-02f,
  3.26052941e-02f, 8.82567242e-02f, 3.42156105e-02f, -6.29400089e-02f, 7.78339654e-02f, -8.18419829e-02f, 7.14868249e-04f, -2.81912461e-02f, -3.83453220e-02f, -9.32336897e-02f,
  -2.38371622e-02f, -9.26795527e-02f, 3.04674488e-02f, -6.58376813e-02f, 6.97729317e-03f, 5.27932756e-02f, 5.12461364e-02f, 5.68862595e-02f, 2.06709150e-02f, -3.11551634e-02f,
  -3.17018554e-02f, -1.01425750e-02f, -9.07979161e-02f, -1.10957995e-02f, 1.18342517e-02f, 2.11413633e-02f, 2.65403092e-02f, 1.93927307e-02f, 5.59403338e-02f, -2.52557807e-02f,
  3.99230421e-02f, -5.78125007e-02f, 9.87625420e-02f, 4.06010784e-02f, 3.34201530e-02f, -5.08812554e-02f, 3.42975417e-03f, 1.50762098e-02f, -4.95128818e-02f, -5.11323586e-02f,
  -1.29914284e-02f, 5.49755096e-02f, 8.68917108e-02f, 6.67903423e-02f, 2.61760019e-02f, 3.26925330e-02f, -6.20377474e-02f, 9.98725966e-02f, -4.31403592e-02f, -1.83854867e-02f,
  -6.72802189e-03f, -5.53540550e-02f, -3.56925279e-02f, -2.40790881e-02f, 4.38240543e-02f, 2.46769171e-02f, 4.25007939e-03f, 3.76007780e-02f, 1.95101611e-02f, 1.36124846e-02f,
  -1.64930392e-02f, -1.11121396e-02f, 8.92134383e-03f, -3.06179319e-02f, -2.14280430e-02f, -5.44148795e-02f, -3.45374830e-02f, 1.95786953e-02f, -4.16345894e-02f, -4.32348624e-02f,
  1.37159377e-01f, -2.28888407e-01f, -9.91329253e-02f, 7.04608560e-02f, 1.51076242e-01f, 5.28107025e-02f, 1.29754364e-01f, -9.33009945e-03f, 2.24708602e-01f, -1.85395300e-01f,
  -6.38776720e-02f, -1.19290687e-01f, -1.49590550e-02f, -2.23107748e-02f, 1.93542734e-01f, 3.66392247e-02f, -1.09579772e-01f, -7.53554851e-02f, 6.19281866e-02f, -8.41488317e-02f,
  2.34513730e-02f, 8.81421193e-03f, -6.44590193e-03f, -4.01083007e-02f, -1.13082655e-01f, -4.92941961e-02f, -5.48506305e-02f, -1.89651754e-02f, -1.97935820e-01f, 5.59382699e-02f,
  -3.56612019e-02f, 4.68811244e-02f, -5.41482568e-02f, -7.81490579e-02f, -2.88997181e-02f, -3.46986577e-02f, -8.64769220e-02f, 9.69277844e-02f, 4.38749650e-03f, 2.18428485e-02f,
  -4.24768329e-02f, 1.33152045e-02f, -1.37314992e-02f, -2.58835014e-02f, 5.44310734e-02f, 8.06069523e-02f, 4.85439450e-02f, -2.47197933e-02f, -8.98323953e-03f, -1.01566687e-01f,
  -7.87930414e-02f, -3.14792544e-02f, 1.03472816e-02f, -1.13794856e-01f, -8.12749788e-02f, -5.88330813e-02f, 2.25984156e-02f, -3.97438928e-02f, 2.82585565e-02f, 3.43957841e-02f,
  -2.19115820e-02f, 8.09087381e-02f, 3.15824300e-02f, 4.95524555e-02f, 4.71790843e-02f, 1.15854383e-01f, -3.42748538e-02f, 3.96212097e-03f, -5.82471266e-02f, 1.87152792e-02f,
  3.92192118e-02f, -5.49322069e-02f, 8.32841150e-04f, 6.15640990e-02f, -1.67961996e-02f, -1.24617331e-02f, 1.80040170e-02f, -7.20524937e-02f, -1.88561026e-02f, -1.66976806e-02f,
  1.22754231e-01f, 4.96964604e-02f, 2.38577127e-02f, -8.90474021e-02f, 9.00251511e-03f, 4.99716885e-02f, -6.52637929e-02f, -2.06275675e-02f, 9.08068940e-02f, 5.61431199e-02f,
  -7.84552693e-02f, -2.42450997e-01f, -8.11724514e-02f, -4.12294967e-03f, -5.66831715e-02f, -1.04326904e-01f, -6.64108843e-02f, -9.47858542e-02f, -1.38433110e-02f, 4.89141941e-02f,
  4.03876300e-04f, 4.30864617e-02f, 1.47279799e-02f, 3.05105411e-02f, 8.87577459e-02f, 2.92957271e-03f, -7.28847161e-02f, -6.22506104e-02f, 1.55408978e-02f, -6.71797022e-02f,
  -6.86926320e-02f, 3.58317830e-02f, -3.09979077e-02f, 1.81485564e-02f, -9.87761170e-02f, -5.91974407e-02f, 1.68960970e-02f, -4.49790396e-02f, -6.44139796e-02f, 3.43597569e-02f,
  2.11297162e-02f, 2.20477842e-02f, 1.68194756e-01f, 8.40370730e-02f, -7.32550174e-02f, 6.55988306e-02f, 1.00617461e-01f, 2.02908907e-02f, 8.06483701e-02f, 9.38854441e-02f,
  -7.60940323e-03f, 1.25383183e-01f, 1.07438460e-01f, 2.15440288e-01f, 1.20634064e-01f, 1.67399749e-01f, 8.13768059e-02f, 9.27749928e-03f, 4.90914611e-03f, -3.40135954e-02f,
  2.56989226e-02f, 3.66912372e-02f, 1.64366663e-01f, 1.03728669e-02f, -6.24346957e-02f, 2.44970769e-02f, 3.93730737e-02f, -4.61333245e-02f, -9.95544717e-03f, -8.38583931e-02f,
  1.01425007e-01f, 6.79749921e-02f, 6.88597411e-02f, 7.21774921e-02f, -7.60214850e-02f, -1.02816008e-01f, 1.23125780e-02f, -1.54420789e-02f, 3.45305912e-02f, 3.57611626e-02f,
  -7.02166408e-02f, -4.26298156e-02f, 2.39934977e-02f, -6.49332404e-02f, -8.80539417e-02f, -6.17779903e-02f, -2.56921947e-02f, 6.49420172e-02f, -3.18597220e-02f, -1.27801793e-02f,
  -3.49427685e-02f, -1.18679674e-02f, 1.25646335e-03f, -4.02687059e-04f, 8.92390907e-02f, -5.45593277e-02f, -1.32804327e-02f, -6.31606877e-02f, 4.31686863e-02f, 4.81440201e-02f,
  1.43309133e-02f, 6.64172620e-02f, -4.61436659e-02f, -1.56584457e-02f, -1.53065920e-02f, -3.81504074e-02f, 7.66011998e-02f, -5.06534576e-02f, 7.73999840e-02f, -1.31341172e-02f,
  -1.20258536e-02f, 2.51427125e-02f, 3.44918109e-02f, -4.39695716e-02f, 4.91759293e-02f, 1.98271573e-02f, -3.12422141e-02f, -2.92124450e-02f, 5.79006597e-02f, -1.80543289e-02f,
  8.22285190e-03f, -4.41137403e-02f, -1.98755823e-02f, -1.99769009e-02f, 9.18222964e-03f, -6.71608001e-02f, 7.38817900e-02f, 6.24483489e-02f, -1.36616919e-02f, -7.25741824e-03f,
  -1.18466839e-01f, -2.32860018e-02f, 5.32905422e-02f, -1.05972253e-02f, 9.98391956e-03f, 4.88541201e-02f, 5.92384674e-02f, -6.98223114e-02f, 2.48260312e-02f, -1.56276003e-02f,
  -1.12893030e-01f, 3.44499424e-02f, -8.08090195e-02f, -1.73820648e-02f, 7.06771016e-02f, 3.64865432e-03f, 3.72289978e-02f, 5.47776325e-03f, -1.01634942e-03f, 2.38182326e-03f,
  -3.82692349e-04f, -8.16988572e-03f, 4.15484458e-02f, -8.55910331e-02f, -9.01414379e-02f, 8.29061866e-03f, 1.06919622e-02f, -5.21869138e-02f, -7.97814429e-02f, 8.31857882e-03f,
  4.67635319e-02f, -1.00251272e-01f, -6.15720488e-02f, -1.43576100e-01f, -2.53073964e-02f, 1.82125747e-01f, 2.20707655e-01f, -9.12645012e-02f, 1.29211351e-01f, -9.86996144e-02f,
  -2.46384982e-02f, 2.21542548e-02f, 1.78363159e-01f, -2.51091067e-02f, 2.03403324e-01f, 1.79206312e-01f, -6.91152513e-02f, -6.61527961e-02f, 4.50057238e-02f, -1.01960734e-01f,
  7.79509265e-03f, -2.85323709e-02f, -4.26272675e-02f, -2.14836851e-01f, -7.51898885e-02f, -1.97168067e-01f, -1.42566934e-01f, -8.75248238e-02f, -1.75991952e-01f, 8.29009414e-02f,
  8.82212296e-02f, -6.27986416e-02f, -1.44925918e-02f, -1.34972716e-03f, -1.07545760e-02f, 1.72508843e-02f, 3.60649563e-02f, 3.30078788e-02f, 7.55388662e-03f, 3.86751890e-02f,
  -3.22140977e-02f, -3.92073940e-04f, 2.42509339e-02f, 5.34734726e-02f, 3.19807269e-02f, 6.08893596e-02f, -8.86896718e-03f, 1.54687418e-02f, 1.87056586e-02f, -2.20307838e-02f,
  2.52586156e-02f, -1.06909044e-01f, -8.56325403e-03f, 2.58800052e-02f, 2.91321632e-02f, 2.90688351e-02f, -4.90573281e-03f, 6.01483583e-02f, -6.68045953e-02f, 6.59626871e-02f,
  -3.06443609e-02f, -1.55523168e-02f, -2.37494577e-02f, 4.38870750e-02f, 5.01596648e-03f, -5.18296622e-02f, 3.19681950e-02f, -1.54572390e-02f, 7.38774016e-02f, 1.69563666e-02f,
  4.54162546e-02f, -3.45575176e-02f, 1.04795787e-02f, -6.17473572e-02f, 1.81082007e-03f, -3.39431986e-02f, 7.78498780e-03f, 5.24106771e-02f, -1.47447279e-02f, 9.56667308e-03f,
  7.94485360e-02f, 3.86960395e-02f, -1.19654264e-03f, 2.45539173e-02f, 8.04460421e-02f, 4.18875068e-02f, -9.11515653e-02f, 5.26672555e-03f, 3.93593265e-03f, -1.96309928e-02f,
  -7.05723092e-02f, -1.77836731e-01f, 4.96308059e-02f, 4.47091199e-02f, 3.30937728e-02f, -1.79060381e-02f, 7.52321854e-02f, -9.12018269e-02f, -9.33635235e-03f, -4.93678451e-02f,
  1.00974208e-02f, -3.54912877e-02f, -4.94571216e-02f, -2.95515377e-02f, -2.62473803e-02f, 3.58483382e-02f, -2.68687103e-02f, 6.02687150e-02f, -3.29195000e-02f, -9.16338712e-02f,
  -7.47927949e-02f, 4.84312996e-02f, 7.70203546e-02f, 3.78739499e-02f, 1.16996989e-02f, 4.16463166e-02f, 2.07788832e-02f, -6.80129230e-02f, -3.95552926e-02f, -8.35125614e-03f,
  2.03647390e-02f, 8.50044787e-02f, -3.10437419e-02f, 1.71564683e-01f, 5.51472120e-02f, 1.29089385e-01f, -8.82083848e-02f, 1.44041762e-01f, 5.07683083e-02f, -4.54021804e-02f,
  1.32349655e-02f, -2.55549029e-02f, -4.63410355e-02f, 1.76332608e-01f, 1.96317598e-01f, 3.85916270e-02f, 2.15143263e-01f, -5.83866835e-02f, -6.28881305e-02f, 6.32219315e-02f,
  1.90396979e-02f, 4.03508507e-02f, -1.17257796e-02f, 7.76999593e-02f, 8.33883062e-02f, 1.11020729e-01f, 9.29787233e-02f, -3.24226469e-02f, 1.34555221e-01f, -8.01222399e-02f,
  9.52410400e-02f, -8.64740536e-02f, -4.50409539e-02f, -2.93831322e-02f, -5.75117394e-03f, 3.40446993e-03f, 9.28411435e-04f, -4.87594940e-02f, 3.07399966e-02f, 2.61801705e-02f,
  -7.61908889e-02f, -7.39739388e-02f, -7.21275806e-02f, 3.53780016e-02f, -5.29869981e-02f, 1.59552954e-02f, 7.58269280e-02f, -6.41050050e-03f, -7.16489032e-02f, -3.68038230e-02f,
  5.96544594e-02f, 7.94621184e-02f, 1.00738015e-02f, 8.74668080e-03f, 8.32854137e-02f, 5.42052872e-02f, 4.66263779e-02f, 3.68186198e-02f, -6.94002658e-02f, 9.38556269e-02f,
  -1.08821047e-02f, 2.35568136e-02f, -3.44009511e-02f, -5.17437235e-02f, 3.19945589e-02f, 7.50021115e-02f, 8.12426209e-02f, 4.15927283e-02f, 4.65097390e-02f, -3.47781219e-02f,
  1.98197104e-02f, 6.70463592e-02f, 4.26506773e-02f, -3.15618776e-02f, 3.94506119e-02f, 4.36103344e-02f, 1.14092547e-02f, -4.56594452e-02f, -5.47736064e-02f, 9.13300365e-02f,
  -8.10155123e-02f, 4.82755713e-02f, -9.94326100e-02f, -9.27942572e-04f, 4.56453860e-02f, 1.64507516e-02f, 4.04496826e-02f, -9.10148621e-02f, 6.05801456e-02f, 6.79791272e-02f,
  5.81662171e-02f, 3.76591235e-02f, -5.91271967e-02f, -4.90746647e-02f, 1.30852237e-02f, -3.57536525e-02f, -4.20609526e-02f, -5.43874269e-03f, -4.12922055e-02f, 6.41489476e-02f,
  -2.39768326e-02f, 8.82628188e-02f, -1.51543515e-02f, 3.95725891e-02f, 2.83743404e-02f, 6.74486533e-02f, -5.13962172e-02f, 1.93880498e-02f, 5.02121188e-02f, 6.01801723e-02f,
  -3.37271802e-02f, -3.95443253e-02f, 1.95506625e-02f, 5.13939299e-02f, -1.79751981e-02f, -2.83728167e-02f, 4.28783102e-03f, 4.83831093e-02f, 1.87956989e-02f, 3.71707119e-02f,
  -3.08354288e-01f, 2.82986075e-01f, 7.22997561e-02f, -3.96045074e-02f, 1.98667217e-02f, -4.82247733e-02f, -9.71528590e-02f, 1.31986156e-01f, 2.28348210e-01f, 1.76351175e-01f,
  1.46047845e-02f, 1.00604473e-02f, 9.04622450e-02f, 7.37617537e-02f, -1.82330519e-01f, 1.06499553e-01f, -2.39142161e-02f, -1.62067059e-02f, 5.36589660e-02f, 1.38161825e-02f,
  -1.06817678e-01f, -8.06578398e-02f, -8.03079829e-02f, 4.84038293e-02f, -2.84889862e-02f, -3.19127999e-02f, -1.48927912e-01f, -8.43924284e-02f, -3.29491273e-02f, 2.31055673e-02f,
  -2.81576291e-02f, -3.89033486e-03f, 4.92199101e-02f, 4.48918296e-03f, -5.37991859e-02f, -2.14435961e-02f, -2.46596746e-02f, -9.08932239e-02f, -1.15883518e-02f, -4.99212965e-02f,
  1.49272792e-02f, -9.47041810e-03f, 2.84442008e-02f, -3.06069292e-03f, 5.19516692e-03f, 1.04937032e-01f, 5.12311123e-02f, 3.46012600e-02f, 3.78747620e-02f, -4.11901437e-03f,
  -6.84392499e-03f, -2.93935416e-04f, -6.58147782e-02f, -2.05462929e-02f, 9.70107038e-03f, 5.78668388e-03f, -3.25788781e-02f, -9.12749320e-02f, 2.25225855e-02f, -6.64720535e-02f,
  -7.78649375e-02f, -6.66240975e-02f, 1.86212379e-02f, 7.64137506e-02f, 2.92116124e-02f, -1.27282355e-03f, 2.40980014e-02f, 6.23110123e-02f, 3.93714011e-03f, 3.07874996e-02f,
  -7.69529417e-02f, 6.92552030e-02f, 2.95045041e-03f, -3.21105756e-02f, -2.69268807e-02f, -2.80390531e-02f, 1.01390239e-02f, 1.30282864e-02f, 2.32660174e-02f, 8.13531689e-03f,
  2.92016920e-02f, 1.83090847e-02f, 8.12022388e-02f, -2.05306169e-02f, 4.78610285e-02f, -1.67018045e-02f, -4.75066639e-02f, 1.04627777e-02f, 4.73741330e-02f, -6.36785552e-02f,
  2.33035386e-02f, 1.18334992e-02f, 9.19384584e-02f, -1.96300987e-02f, 9.29798931e-02f, 5.57824634e-02f, 9.69357556e-04f, -2.63793617e-02f, 4.73256484e-02f, 3.34483273e-02f,
  -7.87906423e-02f, 4.83468138e-02f, 3.49670313e-02f, -7.04214349e-02f, -7.27142468e-02f, -5.23472577e-02f, -4.56181122e-03f, -3.71406972e-02f, -7.44507182e-03f, -6.04945272e-02f,
  8.12263694e-03f, -4.93013263e-02f, 2.48687584e-02f, 1.23290941e-02f, -1.23589197e-02f, -2.34807692e-02f, 1.11531774e-02f, 5.41527197e-03f, -9.82807428e-02f, 6.63259253e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.30619758e-02f, -6.03790283e-02f, -5.59083298e-02f, 6.43380657e-02f, 6.95272014e-02f, 9.35007408e-02f, -4.89050820e-02f, -1.95059888e-02f, -5.95134497e-02f, -5.41903377e-02f,
  -6.67036474e-02f, 3.65039408e-02f, -1.07069738e-01f, -6.76520467e-02f, 1.12620234e-01f, -9.59073678e-02f, 2.30272375e-02f, -7.06202760e-02f, -6.97419122e-02f, -4.93739545e-03f,
  -6.26003817e-02f, -5.71881980e-02f, -4.91317846e-02f, -5.93547821e-02f, -5.40452562e-02f, -1.43560786e-02f, 3.04624662e-02f, -4.72383052e-02f, 1.18594766e-01f, -2.69495491e-02f,
  -4.45851237e-02f, -3.70549560e-02f, 1.71980523e-02f, -4.32056971e-02f, 1.75164565e-02f, 1.29103437e-02f, -2.20134221e-02f, 6.22999854e-02f, -6.68179244e-02f, -9.18949842e-02f,
  5.32811768e-02f, 3.30522992e-02f, 5.45746647e-03f, -7.23104775e-02f, 2.72384416e-02f, 3.16346437e-02f, 6.69990554e-02f, 5.76970205e-02f, -9.47857462e-03f, 6.90718368e-02f,
  4.10568938e-02f, -9.68955574e-04f, -7.32152760e-02f, -4.09323163e-02f, 2.75771860e-02f, 8.06800053e-02f, 6.71136454e-02f, 1.79589335e-02f, -3.22995856e-02f, -3.76804173e-02f,
  4.02558036e-02f, 8.02633464e-02f, -1.94839314e-02f, 1.32396398e-02f, 4.82251123e-02f, -6.88992888e-02f, 9.23340917e-02f, -6.34526415e-03f, 8.23100731e-02f, -2.44942717e-02f,
  -1.48110548e-02f, -1.23657985e-02f, 7.49780536e-02f, 4.24221307e-02f, 4.69041951e-02f, -4.88178916e-02f, 7.47749805e-02f, 3.56252864e-02f, -5.42814191e-03f, 9.24456574e-04f,
  2.54641399e-02f, 8.96070153e-02f, 1.41387964e-02f, 7.84331262e-02f, 3.55847403e-02f, -3.16100456e-02f, 5.14065810e-02f, 3.36768292e-02f, 8.05611089e-02f, -2.07022466e-02f,
  2.11180802e-02f, 1.03969343e-01f, -6.21886440e-02f, 8.94137695e-02f, 8.52714330e-02f, 3.64118591e-02f, 5.09743057e-02f, 8.67280811e-02f, -7.13512450e-02f, -8.56317654e-02f,
  5.08292653e-02f, 5.05043976e-02f, -1.05476826e-02f, 1.33283902e-02f, -4.99401502e-02f, -1.11789361e-03f, 5.59900403e-02f, 9.71431285e-02f, 8.06210861e-02f, 7.03053698e-02f,
  2.80679196e-05f, -3.35058868e-02f, -7.19718337e-02f, -7.50294924e-02f, 2.79163327e-02f, -1.86754353e-02f, -6.50524795e-02f, 6.06764182e-02f, -3.10323969e-03f, -1.55351497e-02f,
  -1.43985339e-02f, -8.72433260e-02f, -1.97626457e-01f, -1.73039079e-01f, -1.25312999e-01f, -1.05190903e-01f, -2.41860777e-01f, -7.76993483e-02f, 1.08061612e-01f, 1.17381118e-01f,
  -4.03351076e-02f, 2.95926793e-03f, -3.74622119e-04f, -6.51997253e-02f, -7.03528449e-02f, 1.32983759e-01f, -2.23829091e-01f, -2.64340844e-02f, -4.74982634e-02f, -4.48165052e-02f,
  6.39222329e-03f, -7.75332451e-02f, -1.43836111e-01f, -8.86870101e-02f, -1.86221302e-01f, -8.42363806e-05f, -1.32670803e-02f, 3.67809124e-02f, -1.48302034e-01f, 1.92996282e-02f,
  1.68613438e-03f, 5.69687188e-02f, -1.14503890e-01f, 3.33881229e-02f, -3.74171212e-02f, -7.95545802e-02f, -6.86118007e-03f, -6.68144673e-02f, -2.66171284e-02f, -9.03980583e-02f,
  9.59052965e-02f, -3.51646770e-04f, 4.86532599e-02f, 7.76196867e-02f, 8.28950107e-03f, 1.02333203e-02f, -9.42138731e-02f, -1.45222172e-02f, 6.14484400e-02f, -2.27320893e-03f,
  -2.08914280e-02f, 2.90673655e-02f, -3.27800252e-02f, 2.75114570e-02f, -5.24456017e-02f, -9.60503370e-02f, -6.45897985e-02f, -1.45336920e-02f, -6.34436086e-02f, 5.76566122e-02f,
  -7.01283514e-02f, -7.43470807e-03f, -5.78861460e-02f, -7.56061524e-02f, 6.45273328e-02f, 5.53253889e-02f, -6.24395646e-02f, 8.26389566e-02f, -4.84843664e-02f, -1.62431430e-02f,
  2.47172229e-02f, 5.59060946e-02f, -4.43719290e-02f, -4.62970436e-02f, -4.68328549e-03f, 8.57693329e-02f, -3.31264660e-02f, 4.43488248e-02f, 6.13889173e-02f, -5.89483790e-02f,
  -5.72900139e-02f, -1.10413134e-02f, 9.99786705e-03f, 7.57452026e-02f, -2.38253698e-02f, -6.05907664e-02f, -3.97823006e-03f, 2.76884623e-03f, 7.97195509e-02f, -7.47371912e-02f,
  -8.59522149e-02f, 3.67824472e-02f, -2.10719854e-02f, 6.53459877e-02f, -4.23602052e-02f, -6.26393557e-02f, -5.61778322e-02f, -1.35906897e-02f, -4.81151268e-02f, -5.62239774e-02f,
  -9.14868787e-02f, -5.14118858e-02f, 7.58011639e-02f, 1.06943417e-02f, 5.05674519e-02f, 4.14253995e-02f, -7.55193084e-02f, 6.25138637e-03f, -1.12250410e-02f, 7.07083568e-02f,
  -3.68589796e-02f, 5.45424856e-02f, 7.50202835e-02f, 9.84231308e-02f, 3.54045182e-02f, -9.90158170e-02f, -7.11910650e-02f, 5.23969196e-02f, 1.81449559e-02f, -3.30591239e-02f,
  2.29631990e-01f, -1.49822384e-01f, -6.85978830e-02f, -8.81528948e-03f, 1.07050434e-01f, 8.90191942e-02f, 8.47950354e-02f, 1.24061026e-01f, 1.33273289e-01f, -4.73855622e-03f,
  -3.71748880e-02f, -1.38934866e-01f, -3.21470983e-02f, 1.28645048e-01f, 5.35409711e-02f, -1.01971030e-01f, 1.43147677e-01f, 6.83286488e-02f, 8.29470437e-03f, 3.76252457e-02f,
  6.48186728e-02f, 1.04022034e-01f, 2.00168509e-02f, -6.61143959e-02f, 1.47985490e-02f, -1.30020250e-02f, -4.20082100e-02f, -4.38627936e-02f, 5.10968156e-02f, 3.85312140e-02f,
  1.53171150e-02f, -6.72614574e-03f, -9.27619822e-03f, 3.36276293e-02f, 3.85310277e-02f, -4.85478602e-02f, 5.20591289e-02f, -2.00901404e-02f, -9.64818150e-02f, 5.42361774e-02f,
  2.72837132e-02f, 8.18842184e-03f, -6.39087427e-03f, 1.95315704e-02f, -3.76639850e-02f, -5.05798757e-02f, -6.71298429e-02f, 1.18751628e-02f, 5.64002097e-02f, -1.78197250e-02f,
  2.87211239e-02f, -3.05049084e-02f, -2.32251603e-02f, 3.32234576e-02f, 3.61362211e-02f, 8.13847259e-02f, -7.59198368e-02f, -3.64753641e-02f, -3.20153385e-02f, 1.49761019e-02f,
  -3.83645445e-02f, -1.15325516e-02f, -6.17370047e-02f, -1.46417636e-02f, -5.10437926e-03f, -4.06302847e-02f, -2.50369161e-02f, -9.01427791e-02f, -1.85836703e-02f, -3.87927033e-02f,
  -1.95479617e-02f, -7.48848021e-02f, 6.84261695e-02f, -8.03261325e-02f, 1.77846830e-02f, -1.08611695e-02f, -2.95038465e-02f, -8.82267766e-03f, -7.46393204e-03f, 4.30851057e-02f,
  -1.54263424e-02f, -6.45046011e-02f, 5.37345593e-04f, -1.56578682e-02f, -6.80679530e-02f, -9.20409858e-02f, 4.87013167e-04f, 7.82928988e-02f, -6.15766011e-02f, 1.55531371e-03f,
  3.62146739e-03f, 5.20682894e-02f, 1.47037711e-02f, -4.72496785e-02f, 1.06277606e-02f, -2.45031924e-03f, 2.45227683e-02f, 1.21829510e-02f, -8.67967606e-02f, -1.37628673e-03f,
  -2.36422475e-02f, -3.66182178e-02f, -8.62882510e-02f, -4.86497544e-02f, 2.31278483e-02f, 5.37531748e-02f, 3.38763036e-02f, -6.12174310e-02f, -7.94298723e-02f, -1.39135867e-02f,
  3.49840112e-02f, -3.93556952e-02f, 1.41984923e-02f, -3.97864804e-02f, 4.04665107e-03f, 1.82529669e-02f, 4.05658819e-02f, -1.10968053e-01f, -4.70478497e-02f, 2.90337633e-02f,
  3.90782431e-02f, 5.17764911e-02f, -1.22804999e-01f, -4.83761244e-02f, 1.99327432e-02f, -2.30723232e-01f, -1.27461344e-01f, -3.47630642e-02f, 1.02677941e-01f, 6.59361184e-02f,
  -7.28983879e-02f, -4.90634330e-03f, 8.95367190e-03f, -1.84978679e-01f, -1.16173662e-01f, 2.22426485e-02f, -2.54268169e-01f, -1.47071078e-01f, 4.79949079e-02f, -1.35722056e-01f,
  -1.19652689e-01f, -2.57128123e-02f, -9.78009477e-02f, -5.75542497e-03f, -1.31275356e-01f, 2.37145443e-02f, -5.77737205e-02f, -2.90461779e-02f, 2.14699414e-02f, -4.29598941e-03f,
  3.51009704e-02f, 3.06107718e-02f, -2.21274309e-02f, -1.63113941e-02f, -5.30389361e-02f, -6.47894815e-02f, 1.25207575e-02f, 4.91514020e-02f, 1.82138085e-02f, -1.19433766e-02f,
  -2.18458157e-02f, 4.69334088e-02f, -1.68150626e-02f, 7.89045021e-02f, -4.77120169e-02f, -1.48992836e-02f, 8.04150999e-02f, 7.15177804e-02f, -2.61916779e-02f, 1.44409928e-02f,
  1.70779484e-03f, 1.89003944e-02f, 3.33672203e-03f, -5.63389398e-02f, -8.23030695e-02f, -4.35334072e-02f, 4.20572907e-02f, -2.41057016e-03f, -2.02192664e-02f, -6.29817322e-02f,
  -4.81116958e-02f, -2.20409073e-02f, 2.26467252e-02f, -5.69329422e-04f, 2.19884496e-02f, 1.36591159e-02f, -5.82369901e-02f, -4.46406193e-02f, 5.11499643e-02f, -3.83280218e-02f,
  2.16448139e-02f, -5.43325692e-02f, -4.92774062e-02f, -1.26328832e-02f, 1.17053138e-02f, -5.83424829e-02f, -1.99690647e-02f, 5.62556200e-02f, -9.46455747e-02f, -2.11171191e-02f,
  9.34593156e-02f, -4.94496748e-02f, -5.76375127e-02f, -9.79578048e-02f, -9.61829722e-03f, -4.47845273e-02f, 7.58984610e-02f, -7.27271810e-02f, -3.92697528e-02f, 1.13934046e-03f,
  1.17151123e-02f, -1.23319365e-01f, -6.93792850e-02f, 4.94983643e-02f, 7.82201886e-02f, -7.29307458e-02f, -1.00940049e-01f, -1.01531252e-01f, 1.57089997e-02f, -6.49242476e-02f,
  3.96367237e-02f, 4.86657694e-02f, 1.40081616e-02f, 7.73404166e-02f, 2.30690725e-02f, 1.46534350e-02f, 6.11554123e-02f, 3.16278860e-02f, 4.35505435e-02f, -2.35186778e-02f,
  -5.32943644e-02f, 7.30631277e-02f, -7.44374990e-02f, 3.30966897e-02f, 2.89547462e-02f, 5.52991778e-02f, 5.57890125e-02f, 4.18227091e-02f, 1.85650904e-02f, 2.06496753e-02f,
  1.00833595e-01f, 1.58874691e-01f, 4.94238622e-02f, 7.33909979e-02f, 5.82208019e-03f, 8.07217672e-04f, -5.55935651e-02f, 3.11932829e-03f, -8.93781486e-04f, 1.79941244e-02f,
  -9.43997800e-02f, 1.76395223e-01f, 1.49996644e-02f, -3.25785466e-02f, -2.50940919e-01f, -2.53148705e-01f, -4.70402688e-02f, -7.67694488e-02f, -1.20644867e-01f, -3.53846177e-02f,
  -5.59321456e-02f, -4.96045733e-03f, -9.90386754e-02f, 8.21131468e-02f, 1.04305774e-01f, 1.77849174e-01f, -1.11212619e-02f, -3.91749442e-02f, 1.69327646e-01f, -1.08816996e-01f,
  2.10150075e-03f, 1.09032774e-02f, 6.89833537e-02f, 3.85185406e-02f, 3.27202231e-02f, 4.71442752e-02f, 1.13783618e-02f, -4.52745445e-02f, -1.01344697e-02f, 7.41356537e-02f,
  -2.78345514e-02f, -2.73309182e-02f, 1.86049938e-02f, 5.18442504e-02f, 4.56163697e-02f, 1.47168888e-02f, -1.96517725e-02f, 1.32686868e-02f, 3.94894034e-02f, -1.57418903e-02f,
  6.33575320e-02f, 5.52221062e-03f, 3.44105950e-03f, 2.80993171e-02f, -5.27226590e-02f, 8.14802796e-02f, 6.41779825e-02f, 4.51551052e-03f, 6.01629950e-02f, -3.96093726e-02f,
  8.72799661e-03f, -5.81417745e-03f, -1.00611465e-03f, -5.34387194e-02f, 1.92659814e-02f, -3.96290943e-02f, -5.61436489e-02f, 4.76292595e-02f, -9.31329280e-03f, -2.48767026e-02f,
  -2.26348937e-02f, 9.40419734e-02f, -8.01011827e-03f, -2.91035846e-02f, -4.75940779e-02f, 2.74850503e-02f, -6.84759766e-02f, -9.50933155e-03f, 1.71748083e-02f, -4.75164279e-02f,
  5.45305237e-02f, -3.38889509e-02f, 5.18833995e-02f, -3.80524620e-02f, -1.08508490e-01f, -2.27736484e-04f, -5.37999645e-02f, 2.78021321e-02f, -5.41885868e-02f, -5.19848615e-02f,
  -1.05935462e-01f, 3.39123830e-02f, 6.95296302e-02f, -8.14403072e-02f, -2.18164129e-03f, -2.13185009e-02f, 3.77047434e-02f, -3.54883112e-02f, -2.83086672e-02f, 3.97602729e-02f,
  1.16658799e-01f, -2.94047967e-02f, 3.63393947e-02f, 3.20206804e-04f, -2.28069047e-03f, 2.28618737e-02f, 6.93980604e-02f, 8.90906379e-02f, -5.73896384e-03f, 9.45679247e-02f,
  -3.19809839e-02f, 1.72241703e-02f, 1.43569184e-03f, -4.22948748e-02f, 4.25627176e-03f, 7.35811219e-02f, -5.60759231e-02f, 4.50593829e-02f, 2.63020992e-02f, -2.58986801e-02f,
  -1.14957765e-01f, 8.52595717e-02f, -9.70800072e-02f, -3.70802358e-02f, -1.53974205e-01f, 4.40861285e-02f, 1.54663190e-01f, 1.82234813e-02f, 5.03668282e-03f, 7.32750222e-02f,
  8.58466551e-02f, -6.58731312e-02f, 4.95434739e-02f, 1.31316125e-01f, -7.17937723e-02f, 1.22615777e-01f, 1.30236253e-01f, 1.68400139e-01f, -5.76942302e-02f, -1.35787129e-02f,
  4.55359556e-02f, 9.55372602e-02f, -6.46686405e-02f, -2.09869891e-02f, -8.39811042e-02f, -1.08737443e-02f, -1.27282059e-02f, -1.30410403e-01f, -1.25795370e-02f, -4.61004116e-02f,
  2.97475178e-02f, -4.78188768e-02f, -3.76591980e-02f, 5.67145944e-02f, -5.51702715e-02f, -1.01108722e-01f, 7.65192956e-02f, -8.55238363e-02f, -2.85612629e-03f, -7.91837722e-02f,
  -2.80494485e-02f, -6.18808232e-02f, 8.14345554e-02f, 4.14954759e-02f, -8.86578783e-02f, 3.08981575e-02f, -7.21755773e-02f, -2.72530480e-03f, -5.56487888e-02f, -6.44262554e-03f,
  -8.46393183e-02f, 1.72548722e-02f, 3.16870064e-02f, 3.83121595e-02f, -8.55770037e-02f, 1.50053231e-02f, 9.92332920e-02f, -1.06793761e-01f, 7.74920508e-02f, 3.54531147e-02f,
  5.65893985e-02f, 6.50492162e-02f, 7.90489465e-03f, 2.44888663e-02f, -7.29004219e-02f, 1.48350457e-02f, -5.69627620e-02f, 6.64156675e-02f, -1.72925480e-02f, -3.90153788e-02f,
  5.72167672e-02f, -8.33974928e-02f, -9.93901584e-03f, -4.03630733e-03f, 5.48665635e-02f, 7.32424706e-02f, 6.77312836e-02f, -6.57037646e-02f, -2.82262284e-02f, 8.78569856e-02f,
  2.32188534e-02f, -7.37485607e-05f, 5.80482110e-02f, 3.13457400e-02f, 2.63849143e-02f, -4.68234383e-02f, -5.38573824e-02f, 7.88505748e-02f, -4.28613834e-02f, -9.05416068e-03f,
  -4.21772674e-02f, -1.06412224e-01f, 7.20860362e-02f, 3.39037366e-02f, 2.32071206e-02f, -4.98356894e-02f, -3.52713875e-02f, 6.34272471e-02f, 1.34606462e-03f, 3.57966796e-02f,
  -9.88256745e-03f, -4.49865423e-02f, 5.42146340e-02f, -2.99089532e-02f, -1.60838775e-02f, -3.00973514e-03f, -5.64989485e-02f, -6.67701429e-03f, 5.82512934e-04f, -8.83076619e-03f,
  -1.79696325e-02f, -5.32536954e-02f, 2.73912009e-02f, 6.76386207e-02f, -1.33473296e-02f, 1.18507603e-02f, -7.94259980e-02f, 4.03876267e-02f, -9.07357037e-03f, 6.54277503e-02f,
  -3.01416963e-02f, -1.48658641e-02f, 2.18350515e-01f, -1.36578798e-01f, 2.31567957e-02f, 7.99218640e-02f, 4.71589305e-02f, 3.06965932e-02f, -1.16459243e-01f, -1.33031309e-01f,
  -6.15897477e-02f, 3.66186202e-02f, 2.80526504e-02f, -7.69460350e-02f, 7.00504472e-03f, -4.91613261e-02f, -2.08306443e-02f, 1.16330036e-03f, -4.09712642e-02f, -5.02868295e-02f,
  -3.61697860e-02f, 1.05026811e-02f, 6.76511824e-02f, -1.51597634e-02f, -5.29740825e-02f, -4.28467877e-02f, -9.29780900e-02f, 5.13787195e-03f, -1.13500822e-02f, 6.12223707e-03f,
  5.31131364e-02f, -5.25706150e-02f, 2.01746877e-02f, -5.87735027e-02f, 9.42811072e-02f, 2.43346598e-02f, -2.82624681e-02f, 6.50023520e-02f, 3.35881375e-02f, -5.43730184e-02f,
  8.32588598e-02f, 9.36552584e-02f, 1.35637904e-02f, -4.80266437e-02f, 6.30158782e-02f, 1.62478127e-02f, 4.83614244e-02f, 4.48040897e-03f, 3.26336361e-02f, 1.14514492e-01f,
  5.40965162e-02f, 6.75781071e-02f, -7.55250752e-02f, -6.81547746e-02f, -2.16761255e-03f, -3.90350334e-02f, 6.49713678e-03f, -4.62459922e-02f, 3.32982205e-02f, -5.21121621e-02f,
  6.92985207e-02f, 3.90804559e-02f, -1.00010145e-03f, -1.72669925e-02f, 8.19028616e-02f, 3.89845185e-02f, -8.94609764e-02f, 8.49900618e-02f, -6.58618510e-02f, -1.27367675e-02f,
  -2.33637262e-02f, -5.12522310e-02f, -1.18427575e-02f, -4.00541583e-03f, 6.41291291e-02f, 5.25809899e-02f, 5.98152801e-02f, 4.79338989e-02f, 2.05494966e-02f, -1.84217766e-02f,
  -6.44212291e-02f, -5.27145900e-02f, 9.28257555e-02f, -6.78022429e-02f, 5.04267700e-02f, -2.73274211e-03f, -2.14790422e-02f, 3.39966244e-03f, 4.14597318e-02f, -3.93967368e-02f,
  2.40599066e-02f, -8.73075351e-02f, 9.84105282e-03f, 2.58945562e-02f, -4.42145802e-02f, -5.25798872e-02f, 4.60342783e-03f, 4.44931909e-02f, 3.29153053e-02f, -4.97527011e-02f,
  9.86807328e-03f, -5.87330014e-02f, 8.32855180e-02f, 4.72541414e-02f, -2.39157118e-02f, -4.88352180e-02f, -4.24278602e-02f, 5.78496139e-03f, 3.77927758e-02f, 7.34959617e-02f,
  2.71665342e-02f, 7.72174960e-03f, -2.89167333e-02f, 4.97698709e-02f, -7.75875077e-02f, 4.46863472e-02f, 4.71724533e-02f, 6.85259327e-02f, 3.59517485e-02f, 8.00503492e-02f,
  -2.25894656e-02f, -8.62756073e-02f, -7.43755028e-02f, -5.47372065e-02f, -1.34076521e-01f, -9.33579355e-02f, -6.81846663e-02f, -1.18035436e-01f, 2.10751314e-02f, -4.49886285e-02f,
  -1.17420271e-01f, 9.42213759e-02f, 1.15537800e-01f, -1.30859107e-01f, 6.74989191e-04f, 1.88898116e-01f, -1.13959514e-01f, 8.35647583e-02f, -3.99180725e-02f, -5.76482415e-02f,
  -2.62254812e-02f, -9.30983573e-02f, -7.85510093e-02f, -8.80218893e-02f, -1.35170400e-01f, -1.54449500e-03f, -2.78018676e-02f, -9.13521200e-02f, -9.05950591e-02f, -1.96022633e-02f,
  -1.23267375e-01f, -1.25416731e-02f, 2.75666453e-03f, -4.76152748e-02f, -4.09520082e-02f, -4.10835259e-02f, 5.88696152e-02f, 7.89406747e-02f, -3.87014076e-02f, -8.25211629e-02f,
  5.95126674e-02f, -7.86589982e-04f, -3.49298008e-02f, 1.41963316e-02f, 4.69182394e-02f, -5.41444905e-02f, -3.29174995e-02f, -9.59355906e-02f, -5.58586381e-02f, -1.03858598e-01f,
  4.37106472e-04f, -2.64277942e-02f, -1.13988016e-03f, -4.80590835e-02f, 3.13063003e-02f, 7.47202896e-03f, -3.76968295e-03f, -2.11611539e-02f, 1.85373351e-02f, 4.94963378e-02f,
  -5.90683706e-02f, 2.29774732e-02f, -4.05219123e-02f, 4.38882671e-02f, -7.26155043e-02f, 5.72207458e-02f, 5.09537831e-02f, 3.17980023e-03f, 1.01231210e-01f, 5.16527295e-02f,
  -1.20800210e-03f, 2.16924828e-02f, -6.32831454e-02f, 4.01337929e-02f, 8.79689753e-02f, -4.87346351e-02f, 7.34413937e-02f, 5.27682789e-02f, -8.67435262e-02f, 5.23681846e-03f,
  5.05732149e-02f, -5.87132713e-03f, 1.35121830e-02f, -3.17325704e-02f, -8.69103074e-02f, 8.28648731e-02f, -4.17667739e-02f, -7.64716119e-02f, -2.63852850e-02f, -6.02902174e-02f,
  -1.40090242e-01f, -1.09804720e-01f, 1.02085657e-01f, -7.17367185e-03f, -3.28998268e-02f, -1.66809857e-02f, 3.88180353e-02f, -2.24581826e-02f, -5.57958905e-04f, -4.29953411e-02f,
  -6.52304757e-03f, -6.06337516e-03f, -6.88926652e-02f, 3.37611847e-02f, 4.02785912e-02f, -5.32073081e-02f, 1.50575452e-02f, -1.74392648e-02f, -3.84012004e-04f, 1.36226416e-02f,
  -6.34626970e-02f, 5.67045212e-02f, 7.57453218e-02f, 4.29526232e-02f, 3.63726579e-02f, -3.31679098e-02f, -5.86864538e-02f, 2.43879501e-02f, -1.56578626e-02f, -2.29489803e-02f,
  -8.39479417e-02f, 6.48943186e-02f, 5.28110899e-02f, -2.52165664e-02f, 6.57681236e-03f, -6.55010641e-02f, 2.25229077e-02f, 3.27408202e-02f, -1.45570515e-02f, -7.17499107e-02f,
  7.88883790e-02f, -5.46345413e-02f, -4.81013171e-02f, -1.04906365e-01f, -1.70891047e-01f, -7.13868514e-02f, -8.46890658e-02f, 6.88555241e-02f, -5.88140413e-02f, 5.50274998e-02f,
  -7.18858317e-02f, 6.33990318e-02f, -7.91218877e-02f, 9.69348177e-02f, 6.67508096e-02f, -1.76741020e-03f, -3.08458600e-02f, 3.23691815e-02f, -5.14884219e-02f, -7.01938197e-02f,
  7.72019709e-03f, -6.90866560e-02f, -1.61120277e-02f, 9.95404720e-02f, -1.18135279e-02f, -8.19138065e-02f, 2.48087365e-02f, 3.17539112e-03f, 1.57176852e-02f, -2.22087279e-02f,
  -5.81691042e-02f, 7.55268931e-02f, -5.88210300e-02f, 6.87384233e-02f, 8.45783204e-02f, -3.36604379e-02f, 3.40508893e-02f, 6.79879412e-02f, 9.07931253e-02f, 5.11180051e-02f,
  -2.32006074e-03f, 5.83586097e-02f, -4.68899310e-02f, -5.87633997e-02f, 1.53274210e-02f, 7.00459480e-02f, -2.46889442e-02f, 3.25704692e-03f, -2.38345768e-02f, 2.18293723e-02f,
  9.18756947e-02f, 8.32387134e-02f, -3.74716744e-02f, 2.03373339e-02f, 6.74513951e-02f, 1.09834736e-02f, 5.09013198e-02f, -5.32620437e-02f, 5.94512559e-02f, 8.04223120e-03f,
  2.48415824e-02f, -2.42848787e-02f, -1.28215905e-02f, 4.81494702e-02f, -7.52407908e-02f, -2.59926058e-02f, -2.36812964e-04f, 8.76094326e-02f, 3.11338045e-02f, 5.31164669e-02f,
  6.27495050e-02f, -6.12790510e-02f, 7.88586736e-02f, -4.08330783e-02f, -7.56529644e-02f, 3.60396579e-02f, -6.08333386e-03f, -4.55283038e-02f, -4.59659062e-02f, -9.30151716e-02f,
  -2.40862593e-02f, 5.09743802e-02f, 3.10602561e-02f, -7.27758408e-02f, 4.83179018e-02f, -6.57880232e-02f, -3.64902951e-02f, -6.90626055e-02f, -5.92781231e-02f, 2.27476023e-02f,
  -2.05093715e-02f, -8.22486803e-02f, -7.37739205e-02f, -1.43208168e-02f, 8.28985572e-02f, -2.49964409e-02f, 7.49900984e-03f, -3.69077064e-02f, 3.58172841e-02f, 3.14069316e-02f,
  2.38917228e-02f, 6.28236979e-02f, -2.97654886e-02f, 7.02716857e-02f, 6.12450391e-02f, -1.89557318e-02f, -6.08654581e-02f, -1.59126744e-02f, -1.80716589e-02f, -6.07172102e-02f,
  -1.36830479e-01f, 9.69713777e-02f, 6.30882457e-02f, -6.12572506e-02f, 8.21975246e-02f, 7.73954168e-02f, -3.55861783e-02f, 9.16799158e-02f, -6.08442277e-02f, -1.55162036e-01f,
  -2.44153198e-02f, -7.11653754e-02f, -4.04907875e-02f, 3.26821730e-02f, 1.76036637e-02f, 8.01034048e-02f, -7.85279125e-02f, -1.00739315e-01f, 3.76022118e-03f, 2.88012344e-02f,
  4.30548117e-02f, -2.03651711e-02f, 8.74055326e-02f, 1.21361807e-01f, 2.22280566e-02f, -8.05887431e-02f, -8.89806151e-02f, 6.37512878e-02f, -3.08121159e-03f, -4.11328375e-02f,
  1.25493690e-01f, -2.38591209e-02f, -2.10191999e-02f, -2.87023350e-03f, 8.56496096e-02f, -7.30881374e-03f, -8.92777294e-02f, -1.15865357e-02f, -6.30893782e-02f, 4.17003445e-02f,
  -2.56365426e-02f, -3.92136350e-02f, -6.89841285e-02f, 5.19618206e-02f, -1.57703087e-02f, 5.75190373e-02f, -6.22944050e-02f, -4.32703272e-02f, -6.59631938e-02f, 6.61400631e-02f,
  6.43900456e-03f, -7.61142150e-02f, -1.40305543e-02f, -5.58770522e-02f, 3.04311514e-02f, 3.00740451e-02f, 5.12575619e-02f, -7.71582797e-02f, 5.14555573e-02f, -2.98931357e-02f,
  -2.48361118e-02f, -6.23849519e-02f, 7.15798065e-02f, -3.69306765e-02f, 7.94064924e-02f, 4.24735323e-02f, 3.35999653e-02f, -8.26679841e-02f, -4.34140004e-02f, 7.08808675e-02f,
  2.53623370e-02f, 3.12975794e-02f, 7.95595869e-02f, -4.87876907e-02f, 6.95656100e-03f, -2.04725601e-02f, 7.51779452e-02f, 3.32359858e-02f, 5.06037921e-02f, 2.36802306e-02f,
  3.59701328e-02f, 5.50702624e-02f, -1.31387182e-03f, 3.37307118e-02f, -5.30202538e-02f, -7.83779994e-02f, 5.88592626e-02f, 7.25578889e-02f, 8.02514255e-02f, -2.29477230e-02f,
  7.47593343e-02f, -1.56677872e-01f, 2.49366071e-02f, -5.37268538e-03f, -6.23641312e-02f, -8.27243775e-02f, 8.21004435e-02f, -7.08877342e-03f, 5.68296947e-02f, -9.86893699e-02f,
  -8.53571296e-02f, 1.28265712e-02f, -2.94688661e-02f, -7.95392543e-02f, -7.46943206e-02f, -4.46995907e-02f, -3.63955311e-02f, -3.30773145e-02f, -4.60202210e-02f, 1.24406777e-02f,
  -4.94947098e-02f, 4.70653884e-02f, -2.74615623e-02f, -4.40300889e-02f, 1.96173936e-02f, -1.09875053e-02f, -8.57210606e-02f, 2.41185557e-02f, -3.70176397e-02f, 3.25469039e-02f,
  -1.01623805e-02f, 1.11454383e-01f, 4.06627171e-02f, 8.38541016e-02f, -3.67752612e-02f, -8.03262442e-02f, 2.49859411e-02f, -9.30945501e-02f, 9.09883305e-02f, 1.05415054e-01f,
  -1.13504650e-02f, 4.34829853e-02f, -8.00750870e-03f, -7.01944828e-02f, 2.68857665e-02f, 9.84463468e-02f, -3.07972804e-02f, 3.87077034e-02f, 1.67990965e-03f, 3.74270766e-03f,
  -3.44682974e-03f, -1.94676388e-02f, 1.71380509e-02f, -4.46380861e-02f, -5.75475655e-02f, -3.98654342e-02f, -2.34728493e-02f, -7.01470226e-02f, 6.76347036e-03f, 9.33531951e-03f,
  -1.73540581e-02f, 1.04915850e-01f, -3.19330879e-02f, -3.55369784e-02f, 5.27133606e-02f, 1.18367095e-02f, 1.99973453e-02f, -3.61773781e-02f, 3.71115953e-02f, 6.44396618e-02f,
  -5.06881513e-02f, 1.61271151e-02f, -5.83839510e-03f, 4.45441641e-02f, 5.12867980e-02f, 3.35897803e-02f, 1.80675052e-02f, 5.08190645e-03f, 8.16409066e-02f, -2.33673379e-02f,
  -1.87436286e-02f, -8.02615285e-03f, -4.29340638e-02f, -3.83012369e-02f, 3.75205576e-02f, -5.01732640e-02f, 6.89076483e-02f, 1.56728867e-02f, 1.01403825e-01f, 6.15838310e-03f,
  -5.16604930e-02f, 1.09613150e-01f, -3.68562005e-02f, -3.88034545e-02f, -3.22198942e-02f, -4.54876684e-02f, 1.64196845e-02f, 3.78323793e-02f, -3.70646007e-02f, 1.43950051e-02f,
  9.40251499e-02f, -5.64035773e-02f, -6.88685849e-02f, -4.07070890e-02f, 5.74142337e-02f, -8.13217461e-02f, -3.58274244e-02f, -1.15837352e-02f, -5.95780388e-02f, 1.91421043e-02f,
  2.04678047e-02f, -3.93052436e-02f, 8.83353278e-02f, -7.58949071e-02f, 3.35722826e-02f, -5.48890159e-02f, -3.84311564e-02f, 7.11315721e-02f, 6.60879463e-02f, 1.57439373e-02f,
  1.89531762e-02f, 1.84060022e-01f, 1.58950370e-02f, -6.07350320e-02f, -4.19274606e-02f, -3.24370675e-02f, 1.16238242e-03f, -5.75836338e-02f, -1.04025537e-02f, 7.07661137e-02f,
  4.29985002e-02f, 5.92729896e-02f, -3.83836776e-02f, 4.22526635e-02f, 4.11947258e-02f, 9.63235646e-02f, -3.72851007e-02f, 2.73752250e-02f, 1.78901087e-02f, 8.93488228e-02f,
  -7.27660283e-02f, -5.44416066e-03f, -6.32041693e-02f, -4.37441655e-02f, 2.49814112e-02f, -4.34175357e-02f, 3.63442563e-02f, -4.93064448e-02f, 5.04183806e-02f, -1.66048445e-02f,
  -9.19607207e-02f, 1.58457309e-01f, 1.08685859e-01f, 5.42560071e-02f, 2.70737279e-02f, 4.72308248e-02f, -1.17084824e-01f, 1.84908230e-02f, -1.24745751e-02f, -5.89503255e-03f,
  -9.00217220e-02f, 1.48245292e-02f, -7.25149363e-02f, 8.98623243e-02f, -1.75536469e-01f, 9.57753509e-03f, 1.23920515e-02f, 5.78802750e-02f, 2.73859538e-02f, 3.01729608e-02f,
  -1.02048151e-01f, 6.31789789e-02f, -9.13485233e-03f, 1.29939750e-01f, -3.92096080e-02f, -1.79154016e-02f, -1.40143663e-01f, 9.62798968e-02f, 1.85998995e-02f, -6.77374005e-02f,
  -9.79149044e-02f, -8.30764417e-03f, -8.33030567e-02f, -2.23523490e-02f, -1.04238056e-01f, -8.01283643e-02f, 8.66324641e-03f, -4.22188714e-02f, -3.22164260e-02f, 1.06872171e-02f,
  -2.68864632e-03f, -1.53141469e-03f, -5.79110384e-02f, -4.03226353e-02f, -4.82595079e-02f, 7.61977136e-02f, 6.69125393e-02f, -6.76338300e-02f, 7.91239515e-02f, -4.44257818e-02f,
  -1.43377176e-02f, 4.28969599e-02f, 3.96779478e-02f, 6.00327216e-02f, -3.57989892e-02f, 2.21972521e-02f, -7.92152807e-02f, -6.93262070e-02f, -3.52321565e-02f, 2.66823452e-03f,
  7.18745142e-02f, -7.69030675e-02f, -1.86889824e-02f, 4.19111811e-02f, 1.93357952e-02f, 6.05913214e-02f, 1.51667604e-03f, -2.35404447e-02f, -4.80739102e-02f, -8.89056548e-02f,
  3.29939090e-02f, -7.39834756e-02f, -5.44915758e-02f, -5.00381067e-02f, 2.63714306e-02f, -2.33174935e-02f, -5.91355413e-02f, 5.03229499e-02f, -4.76819761e-02f, -4.04754579e-02f,
  -3.65378112e-02f, 4.39259261e-02f, -2.51501966e-02f, -3.17304358e-02f, -1.42468642e-02f, -6.04085065e-02f, 9.19143111e-02f, 1.87903866e-02f, -7.35146776e-02f, 4.82654199e-03f,
  -4.91016358e-02f, 1.65143069e-02f, -5.43289222e-02f, 4.88463603e-02f, -4.88982685e-02f, 2.38018818e-02f, -1.09402515e-01f, -5.23523614e-02f, -9.31944475e-02f, -1.30250426e-02f,
  -7.94382393e-02f, 7.69422390e-04f, -4.69199121e-02f, 6.39052168e-02f, -8.00234899e-02f, -6.33038580e-02f, -5.57518937e-02f, -3.76844928e-02f, -7.68412426e-02f, 4.77021746e-02f,
  -3.04654334e-02f, -5.81307784e-02f, -4.36965264e-02f, -5.82625568e-02f, -1.25450576e-02f, -1.03413597e-01f, 1.18243229e-02f, 4.18598130e-02f, 4.43308353e-02f, -1.61554459e-02f,
  -1.83547977e-02f, 7.42951632e-02f, 4.13903706e-02f, -2.10944787e-01f, 4.29163836e-02f, 1.37384385e-01f, 8.81409422e-02f, 6.49360046e-02f, -1.23940840e-01f, -7.66481459e-02f,
  -4.90977094e-02f, -5.23241423e-02f, 6.89546019e-02f, -2.24627554e-02f, 1.43418491e-01f, 6.23604245e-02f, -1.11285050e-03f, -7.55739510e-02f, 1.16432458e-02f, -1.07461996e-01f,
  3.84097062e-02f, -3.75209525e-02f, 1.07422628e-01f, 8.97363052e-02f, 4.04864848e-02f, -6.59237206e-02f, -1.41628692e-02f, 1.19116046e-01f, -9.19916667e-03f, 3.52431424e-02f,
  4.74416092e-02f, 5.00441268e-02f, 6.35126308e-02f, 1.02323201e-02f, -6.63908571e-02f, 7.04788491e-02f, 6.47999020e-03f, 5.99631332e-02f, -3.55052985e-02f, 1.38748381e-02f,
  -8.75336826e-02f, 7.41783381e-02f, 2.60882042e-02f, -7.50775933e-02f, -7.46733621e-02f, -4.39323187e-02f, -6.51787780e-03f, 3.54617499e-02f, 8.12335312e-03f, 8.29963759e-02f,
  3.68259698e-02f, 8.89709741e-02f, -4.13007252e-02f, 1.29805598e-02f, -4.94291522e-02f, -4.61604223e-02f, 2.63310075e-02f, 2.81222095e-03f, -3.83691513e-03f, 1.05357654e-02f,
  3.87336537e-02f, -8.41007978e-02f, -9.39706154e-03f, 2.71366611e-02f, 9.09749418e-02f, 6.37682453e-02f, 3.07707842e-02f, 8.38991702e-02f, -4.08085734e-02f, 7.45676681e-02f,
  -1.66867990e-02f, 1.16125215e-02f, -2.97238287e-02f, -8.08698758e-02f, 3.31990048e-02f, -8.38803407e-03f, -2.23673461e-03f, 1.53649719e-02f, 4.42349017e-02f, -3.31287086e-03f,
  -1.21803274e-02f, 6.72478303e-02f, -8.95047560e-02f, -9.59497876e-03f, 4.14487943e-02f, -4.91253994e-02f, 5.67777455e-02f, -1.07480558e-02f, 8.72014537e-02f, 6.62598461e-02f,
  7.48721734e-02f, -6.10040091e-02f, 4.83955070e-02f, -7.06366971e-02f, 5.79780526e-02f, 7.48609155e-02f, 4.81331274e-02f, 5.35284467e-02f, -8.95329379e-03f, 2.71043014e-02f,
  4.94780578e-02f, -3.43912374e-03f, -7.66356289e-02f, 6.56934381e-02f, -3.62010039e-02f, 6.43409044e-02f, -5.09179980e-02f, -7.47368038e-02f, 3.43241878e-02f, 3.70580554e-02f,
  -6.30404726e-02f, 3.24673466e-02f, -8.09527934e-02f, -9.00576115e-02f, -1.07406467e-01f, -8.10403153e-02f, -6.97204918e-02f, 1.43895335e-02f, 3.74693945e-02f, -4.28761616e-02f,
  -1.98244035e-01f, 1.10967010e-01f, -1.26352623e-01f, 7.01579005e-02f, -1.65297017e-02f, -3.52150500e-02f, 9.97901782e-02f, -4.26835427e-03f, 1.18953353e-02f, 2.22408682e-01f,
  1.86228976e-01f, -1.01595230e-01f, 1.40330255e-01f, 1.57968566e-01f, -4.51409966e-02f, 9.53936204e-02f, -9.92994383e-03f, 4.85880300e-02f, -1.27252653e-01f, -1.24100901e-01f,
  -1.41307354e-01f, 1.02831200e-01f, 6.67816773e-02f, 5.45528084e-02f, -3.23978588e-02f, -1.21788852e-01f, 5.01833893e-02f, 7.73254931e-02f, 2.43043005e-02f, -5.82933389e-02f,
  -1.06539190e-01f, -1.63747314e-02f, -6.27186000e-02f, -2.99556889e-02f, -6.03075996e-02f, -1.21228315e-01f, -3.87691706e-02f, 4.34021652e-02f, -2.02995073e-02f, 1.14041613e-02f,
  -1.61746647e-02f, 1.45001533e-02f, -3.96955535e-02f, 5.59389293e-02f, -2.43926328e-02f, -5.45449043e-03f, 2.77961325e-02f, 6.18956722e-02f, -3.30814347e-02f, 5.97487092e-02f,
  4.88435961e-02f, -7.49080069e-03f, 4.13330691e-03f, 3.76229994e-02f, 7.25891767e-03f, -4.95101772e-02f, 6.76357746e-02f, -7.16571743e-03f, -6.10567182e-02f, 5.05172461e-02f,
  1.61668956e-02f, -8.35808367e-02f, -8.32379051e-03f, 2.31994353e-02f, 7.55042508e-02f, 1.89624075e-02f, 1.87189337e-02f, 4.22179438e-02f, -4.59811790e-03f, -3.56411003e-02f,
  5.33794202e-02f, 3.20423804e-02f, -4.44299914e-02f, 7.50682503e-02f, 5.05958404e-03f, 5.40371202e-02f, -9.12828930e-03f, 2.18353104e-02f, 6.45042062e-02f, -4.10646200e-02f,
  4.68445718e-02f, 2.02697311e-02f, -2.73672361e-02f, 5.47386482e-02f, 7.02711567e-02f, -1.56350415e-02f, -3.98942865e-02f, 1.82658695e-02f, 6.72257841e-02f, -2.52382718e-02f,
  -4.68439683e-02f, -1.04774125e-01f, 3.97431925e-02f, 5.41516840e-02f, 3.57897095e-02f, -8.41082353e-03f, -5.76420315e-03f, -6.58967048e-02f, 1.72949408e-03f, -1.06183691e-02f,
  -7.59918392e-02f, -1.54135171e-02f, -9.43149179e-02f, -5.86471818e-02f, -4.81532626e-02f, -2.42218357e-02f, -6.96953461e-02f, 3.70934652e-03f, -7.08909705e-02f, -5.37940823e-02f,
  -1.30109312e-02f, 5.43669984e-02f, 7.40833580e-02f, -9.21771824e-02f, 5.87448403e-02f, 9.38986987e-02f, -4.04113419e-02f, -2.99762283e-02f, 3.30115929e-02f, 8.30939785e-02f,
  -1.95934787e-01f, 1.83734745e-01f, -1.12527184e-01f, -1.27294045e-02f, 1.50400596e-02f, 2.04231650e-01f, 5.67352884e-02f, 1.14529103e-01f, 6.50086179e-02f, 7.01379552e-02f,
  1.25588939e-01f, 5.42677268e-02f, -5.89100458e-02f, 4.84194867e-02f, -1.13476543e-02f, 6.53235540e-02f, 1.91983506e-01f, 1.26147121e-01f, 1.18419133e-01f, -8.53251889e-02f,
  -3.15260962e-02f, 2.74581220e-02f, -1.68371350e-01f, -2.58129239e-02f, 5.84584698e-02f, -1.51888862e-01f, -8.06608275e-02f, -4.76447865e-02f, -3.65316384e-02f, 1.11854821e-02f,
  3.77074108e-02f, 3.90834268e-03f, -6.74584880e-03f, 1.23426470e-03f, 4.04630937e-02f, 9.19109397e-03f, 3.64057608e-02f, -7.47754890e-03f, -1.31185487e-01f, 6.95593730e-02f,
  7.81579465e-02f, -8.24857689e-03f, -2.17921752e-02f, 5.17641939e-02f, 7.26573691e-02f, 5.62995374e-02f, -2.65037231e-02f, 4.99677807e-02f, -5.78485914e-02f, -1.89106688e-02f,
  1.66291948e-02f, -1.10586826e-02f, -4.96327467e-02f, -3.26078348e-02f, -6.50541261e-02f, -3.32681388e-02f, -2.51398291e-02f, -9.83519480e-03f, -1.02923661e-02f, 9.01577920e-02f,
  1.31290238e-02f, 9.89055037e-02f, -1.60804465e-02f, -7.02557759e-03f, 8.20457414e-02f, -2.84243636e-02f, -7.18293488e-02f, 1.22526884e-02f, 8.37659165e-02f, 2.47628242e-02f,
  -5.41986674e-02f, 3.09366509e-02f, 5.34124970e-02f, 2.26906240e-02f, 1.78532097e-02f, -6.49635345e-02f, -9.31684598e-02f, 4.27642576e-02f, 4.02993523e-03f, -4.39819954e-02f,
  2.51736343e-02f, 3.78615037e-02f, 2.73786131e-02f, 1.80413276e-02f, -1.09756179e-02f, -9.73379705e-03f, 5.45876920e-02f, -4.38950546e-02f, 3.33785303e-02f, 2.89472938e-02f,
  1.24151751e-01f, 8.31611305e-02f, 6.05107993e-02f, -8.26540440e-02f, -4.43931557e-02f, 5.47761582e-02f, 1.14966352e-02f, -5.74731119e-02f, -4.36040051e-02f, 9.18577462e-02f,
  7.60039762e-02f, 7.09721148e-02f, 7.17038438e-02f, 4.36110683e-02f, 9.68398154e-02f, 5.71333542e-02f, -3.74644436e-02f, -2.69697253e-02f, -3.37670371e-02f, 5.37918881e-02f,
  -8.42528492e-02f, 3.15223522e-02f, -3.61566618e-02f, 5.45663610e-02f, -6.99145123e-02f, 8.71902332e-02f, 6.56702220e-02f, -2.07641553e-02f, 6.08476922e-02f, -2.10517570e-02f,
  -3.79897431e-02f, 1.63466141e-01f, 7.63086379e-02f, -7.76133537e-02f, 9.87662077e-02f, -1.07079439e-01f, -2.20863968e-02f, 1.81625355e-02f, 7.23059401e-02f, 5.63622043e-02f,
  6.64054826e-02f, 1.01813450e-01f, 3.08836363e-02f, 7.17742555e-03f, -1.71441838e-01f, -1.18927993e-01f, -1.73353672e-01f, 1.61581170e-02f, 3.91008183e-02f, -8.20587203e-02f,
  -1.45971939e-01f, 3.62817235e-02f, -2.71192715e-02f, 4.57020104e-02f, -4.16423120e-02f, 7.65809510e-03f, -5.75731806e-02f, 3.14314067e-02f, 9.15199742e-02f, 9.39712748e-02f,
  9.03814211e-02f, -1.60543323e-02f, 1.10737652e-01f, -5.46363592e-02f, -9.14228410e-02f, 7.48053044e-02f, 1.52412066e-02f, 4.11879160e-02f, 2.21609958e-02f, -4.95249964e-02f,
  -6.81798458e-02f, 2.27484014e-02f, 2.57142857e-02f, 2.33872905e-02f, 2.85303243e-03f, 1.69763081e-02f, 4.70743440e-02f, 3.78461555e-02f, 6.27805525e-03f, 7.07555190e-02f,
  -2.50593293e-02f, 2.50124671e-02f, -5.48294559e-02f, -6.84104338e-02f, -5.72625063e-02f, -7.10249767e-02f, 6.52405396e-02f, 2.61687860e-02f, 7.93467462e-03f, -2.83968113e-02f,
  -5.99351712e-02f, -5.96759580e-02f, -4.51340573e-03f, 1.16180331e-02f, 5.05977720e-02f, 7.94327781e-02f, 3.53465527e-02f, 7.61150047e-02f, -3.18691805e-02f, 7.43476162e-03f,
  -4.24908325e-02f, -3.60410176e-02f, -4.07966375e-02f, -5.80266826e-02f, 1.23147080e-02f, 7.19913319e-02f, 9.79214069e-03f, -5.14506698e-02f, -1.36171505e-02f, -6.13135509e-02f,
  5.47936037e-02f, 1.08481785e-02f, 3.06917671e-02f, -1.48428334e-02f, -4.63958643e-02f, -6.20992929e-02f, -2.64677405e-02f, 6.45482168e-02f, 5.77830523e-02f, -4.53512929e-02f,
  1.25303352e-02f, -1.39254421e-01f, 1.12793148e-01f, 9.08469781e-02f, -1.93116143e-02f, 4.06933837e-02f, 4.56627598e-03f, -3.53878252e-02f, 4.83019091e-02f, -8.88360292e-02f,
  5.45901023e-02f, -7.09777623e-02f, 2.21355837e-02f, 8.52094963e-02f, 2.19733976e-02f, 4.90560569e-02f, 3.22836228e-02f, -3.83936353e-02f, 1.37598002e-02f, 1.41287344e-02f,
  8.34430009e-02f, -5.90331517e-02f, -4.95022610e-02f, 4.22800817e-02f, 3.56411673e-02f, 3.77710573e-02f, -7.56621286e-02f, -7.06698671e-02f, -3.49542387e-02f, 4.60312255e-02f,
  -4.98098023e-02f, 1.13792881e-01f, 5.11430390e-03f, 8.30430537e-03f, 4.83780578e-02f, -2.35379227e-02f, -1.36519998e-01f, -6.89066872e-02f, -6.65007159e-02f, 4.33923751e-02f,
  -4.47690673e-02f, 1.12389229e-01f, -7.04659373e-02f, -4.26834263e-02f, -2.16413364e-01f, -2.20324144e-01f, -9.32865888e-02f, -1.21064782e-02f, -1.18144918e-02f, -7.81907290e-02f,
  -9.86355171e-02f, -4.28167991e-02f, -1.27411082e-01f, -3.30579951e-02f, 1.13281280e-01f, 1.32457227e-01f, 3.21696810e-02f, 5.11821210e-02f, 6.66669011e-02f, -9.41189937e-03f,
  -9.32696238e-02f, 2.77753901e-02f, 7.51473904e-02f, 1.02982700e-01f, 2.60675959e-02f, 1.15816943e-01f, 9.45375413e-02f, 2.43593212e-02f, -7.02166930e-02f, 7.87908584e-02f,
  5.84207522e-03f, 9.25299805e-03f, 3.27964723e-02f, -2.30039954e-02f, 5.67276701e-02f, 4.19519655e-02f, 9.61160138e-02f, 1.15733400e-01f, 7.39764273e-02f, 8.91874451e-03f,
  4.10385877e-02f, 8.45182687e-02f, -3.64440382e-02f, 1.46629130e-02f, -6.80393353e-02f, -8.18451270e-02f, 7.96575099e-02f, 5.50246164e-02f, 6.34396672e-02f, 3.48423533e-02f,
  -7.27043003e-02f, -9.73655283e-03f, -2.71840636e-02f, -1.76373997e-03f, -2.23933570e-02f, -6.27864301e-02f, 6.86362609e-02f, -5.45750484e-02f, -6.63834289e-02f, -1.69391669e-02f,
  1.02955028e-02f, 2.07473785e-02f, 5.00415489e-02f, 9.83863845e-02f, 6.63753301e-02f, -3.36195193e-02f, -1.74845830e-02f, 5.72883710e-02f, 7.08930343e-02f, 3.16009261e-02f,
  -2.11928673e-02f, 6.61606640e-02f, -7.23702461e-02f, 8.41199011e-02f, -1.79248350e-03f, 4.98389974e-02f, -2.33176779e-02f, 9.97276008e-02f, 4.05970812e-02f, 4.44658063e-02f,
  -3.34422104e-02f, -1.43208960e-02f, -4.54162918e-02f, -5.67577071e-02f, 2.65823994e-02f, 7.44595984e-03f, -7.71910399e-02f, -1.68809649e-02f, -2.14788783e-02f, -5.92210144e-02f,
  1.16402013e-02f, 7.05357343e-02f, 9.20386985e-02f, -5.47767058e-02f, 3.18000540e-02f, 3.91255207e-02f, -9.06299800e-02f, -5.28278202e-03f, 5.98116890e-02f, -3.92205901e-02f,
  2.19021626e-02f, 8.62236768e-02f, 7.88656101e-02f, 1.87328905e-02f, -6.85056672e-02f, 7.00877532e-02f, 2.73939874e-02f, 7.67373899e-03f, 3.95906381e-02f, 4.01842147e-02f,
  3.45661715e-02f, -1.43951356e-01f, 2.48440392e-02f, -5.77108450e-02f, 4.28828150e-02f, -3.23215090e-02f, -1.18327253e-01f, -9.97915491e-02f, -1.87270582e-01f, -1.75311670e-01f,
  -1.84668582e-02f, -2.55743973e-02f, -1.16381623e-01f, 2.63354760e-02f, 9.72969681e-02f, -3.69571708e-02f, -5.08811139e-02f, 9.50199962e-02f, 3.04011833e-02f, 7.08566420e-03f,
  5.79086170e-02f, 1.50872152e-02f, -2.74736304e-02f, -3.91354449e-02f, 1.17641345e-01f, 2.60240510e-02f, 1.08679049e-01f, 7.55202845e-02f, 1.52693704e-01f, 9.32311267e-02f,
  6.35484979e-02f, -6.68996423e-02f, -3.14275324e-02f, -3.09637431e-02f, -4.31172810e-02f, 6.39641881e-02f, -2.94437557e-02f, 1.17612176e-01f, 8.52309242e-02f, 3.88722494e-02f,
  2.77808234e-02f, 2.23625507e-02f, -7.00177625e-02f, -1.72716677e-02f, 4.46815379e-02f, -5.67664728e-02f, -2.62366086e-02f, -1.06875375e-01f, 6.75519034e-02f, 5.23036346e-02f,
  -2.12061759e-02f, -7.27121234e-02f, 6.26213253e-02f, 3.01213618e-02f, -9.64169204e-03f, 2.60926094e-02f, -2.00326405e-02f, 1.09117813e-02f, -2.54740361e-02f, 2.85358168e-03f,
  5.32510430e-02f, 6.00514524e-02f, -1.88299511e-02f, 3.99874672e-02f, 5.45704253e-02f, -8.37765336e-02f, 2.33676862e-02f, 7.61490911e-02f, 1.26273632e-02f, 3.14934961e-02f,
  6.51548570e-03f, -2.13747099e-02f, 6.87688962e-02f, 6.23040050e-02f, 6.85591474e-02f, 3.11011076e-02f, -1.47407642e-03f, -2.49852706e-02f, 6.86453357e-02f, 5.68187376e-03f,
  8.51006731e-02f, 6.66932315e-02f, 3.59434597e-02f, 1.05354726e-01f, -7.57042319e-02f, 4.77179103e-02f, 2.79661622e-02f, 4.72858921e-02f, -7.33223930e-02f, 3.93191539e-02f,
  3.21162231e-02f, -7.19873328e-03f, -8.81702080e-02f, 9.66033433e-03f, -2.57087257e-02f, -4.15351577e-02f, -3.02234739e-02f, -4.73727211e-02f, 4.70618047e-02f, 5.19100018e-02f,
  6.75157532e-02f, 2.76596192e-02f, 4.38581817e-02f, 8.18065181e-02f, -3.84537801e-02f, -5.75767457e-02f, 6.06859028e-02f, 2.37558596e-03f, 3.27655673e-02f, -1.44770546e-02f,
  9.46424231e-02f, -6.54505640e-02f, -6.84211999e-02f, 2.92813703e-02f, 6.87985271e-02f, 8.86792317e-02f, 1.79830268e-02f, 3.69744077e-02f, 6.33363500e-02f, 3.36468332e-02f,
  -1.12611569e-01f, 1.08088613e-01f, -2.61447369e-03f, -1.32366002e-01f, 7.50230625e-02f, -9.78897139e-02f, -1.06723756e-01f, 7.87091628e-02f, -2.02810229e-03f, 1.17243186e-01f,
  -8.52046907e-02f, 9.35354531e-02f, 8.10780302e-02f, -9.17500481e-02f, -1.97647184e-01f, 8.49742163e-03f, -1.98195130e-01f, -4.08121161e-02f, -7.03340098e-02f, -9.68048796e-02f,
  -1.12542927e-01f, 2.43292246e-02f, -1.45384878e-01f, 7.70197809e-02f, -4.88673374e-02f, 1.80478040e-02f, -1.06399516e-02f, -3.13084573e-02f, -7.10164681e-02f, 3.14945579e-02f,
  3.63504961e-02f, -3.16326432e-02f, -1.83267109e-02f, -4.61050794e-02f, 4.18366306e-02f, -7.94224590e-02f, -5.91592453e-02f, 3.98619473e-02f, -9.53265950e-02f, -4.66753244e-02f,
  6.34657741e-02f, -4.56454083e-02f, -5.39623611e-02f, 8.61313120e-02f, 3.40983644e-02f, -7.65969008e-02f, 7.70612583e-02f, -1.03204395e-03f, 2.69749351e-02f, 4.17775437e-02f,
  -4.85786609e-02f, 1.59759689e-02f, -6.92868745e-03f, 1.52274575e-02f, -6.27890453e-02f, -4.66405554e-03f, -3.74372192e-02f, 2.33424976e-02f, 7.13943914e-02f, -7.80842733e-03f,
  3.47614810e-02f, -5.71602061e-02f, -6.87087402e-02f, 4.65855971e-02f, -8.79193023e-02f, -5.94594590e-02f, 9.96438935e-02f, 4.85330634e-02f, 2.90291570e-02f, 4.43455297e-03f,
  -2.71050900e-04f, 4.73060310e-02f, 6.32896721e-02f, -5.91196679e-02f, -9.16245654e-02f, -2.45005991e-02f, -8.18691030e-02f, 7.37256631e-02f, -6.39527738e-02f, 4.97711897e-02f,
  -1.43809188e-02f, 7.67672621e-03f, 8.29666667e-03f, 6.78400025e-02f, 7.45184869e-02f, -1.15971332e-02f, 6.02627397e-02f, -4.37797494e-02f, -8.34593475e-02f, 4.42292690e-02f,
  3.13149090e-03f, 9.06668827e-02f, -7.12084472e-02f, 2.68474072e-02f, -4.08544093e-02f, 3.48397121e-02f, 2.01335587e-02f, 4.26577516e-02f, 2.65569016e-02f, 6.21949062e-02f,
  3.15274782e-02f, -1.26379598e-02f, 4.55927961e-02f, 8.80683064e-02f, -4.93722335e-02f, 5.85770197e-02f, 3.25331762e-02f, -7.20365122e-02f, -6.04550689e-02f, -1.04175005e-02f,
  4.04873937e-02f, -5.66785969e-02f, -3.45556624e-02f, -3.01588625e-02f, -3.11527383e-02f, -6.26725778e-02f, -2.01145038e-02f, -5.69133535e-02f, -1.36005953e-02f, -8.11866447e-02f,
  1.59018397e-01f, 2.49896925e-02f, 5.90421632e-02f, -7.59218335e-02f, -7.78598487e-02f, -1.51807979e-01f, -1.61213487e-01f, -8.39014947e-02f, 9.16900672e-03f, -1.45242482e-01f,
  -4.42876518e-02f, 2.54888516e-02f, -5.41436411e-02f, -1.00176865e-02f, 9.75073203e-02f, -2.43322160e-02f, -1.12278521e-01f, -6.46747574e-02f, 4.43309955e-02f, -5.34657203e-03f,
  -1.04058739e-02f, -8.60614479e-02f, -6.23606853e-02f, -4.00890447e-02f, -4.53524217e-02f, 1.83875009e-03f, -4.82424647e-02f, 4.20943983e-02f, 3.13861407e-02f, -1.12128332e-01f,
  1.14743039e-02f, -5.23120128e-02f, 7.62578696e-02f, -3.01423669e-02f, 6.20113164e-02f, 4.68399115e-02f, -9.12203640e-02f, 2.73384936e-02f, -7.01652467e-02f, 4.37505357e-03f,
  3.90551984e-02f, 6.90464452e-02f, -9.29679349e-03f, 8.73584859e-03f, 2.20595747e-02f, 4.53168713e-02f, 6.70349365e-03f, 8.55300650e-02f, -7.22716376e-02f, -5.77334538e-02f,
  7.68860206e-02f, 6.04661591e-02f, 6.38584346e-02f, 3.30050550e-02f, -3.02098114e-02f, 2.13316977e-02f, 7.89563358e-02f, -4.73894775e-02f, 4.48149778e-02f, 3.46703129e-03f,
  1.67236407e-03f, -6.70027882e-02f, -7.76252151e-02f, 4.57590595e-02f, 8.24158788e-02f, -5.81835918e-02f, 7.65086561e-02f, -5.11793420e-02f, -8.16523656e-03f, -4.62796390e-02f,
  9.52834147e-04f, -7.02864304e-02f, -6.65955245e-02f, -4.69150767e-02f, -3.27063724e-02f, 1.51091274e-02f, 1.15053914e-02f, -3.16725411e-02f, 3.17373574e-02f, -6.24770410e-02f,
  -2.82039680e-02f, 7.40592256e-02f, -8.28582197e-02f, 1.00641631e-01f, -2.48902068e-02f, -9.17641744e-02f, 4.21255119e-02f, -4.46944125e-02f, -4.62247543e-02f, -4.24404331e-02f,
  -2.09729131e-02f, 2.70552803e-02f, -3.59326415e-02f, 2.24202573e-02f, 3.68461050e-02f, 4.05100547e-02f, -5.56761324e-02f, -7.54035786e-02f, 1.57614909e-02f, 7.89962932e-02f,
  -1.01250060e-01f, 5.30463159e-02f, 6.17515743e-02f, 4.80603054e-02f, -3.59719954e-02f, 6.87852800e-02f, 2.43450198e-02f, 6.99370950e-02f, -5.82584888e-02f, 4.07818630e-02f,
  3.31911333e-02f, 3.46520729e-02f, -6.82598352e-02f, -5.66299595e-02f, 8.94540399e-02f, 9.26564783e-02f, -1.41526116e-02f, 5.22001870e-02f, 3.64329964e-02f, -3.52259465e-02f,
  9.83816683e-02f, -9.56054553e-02f, 1.76833004e-01f, 1.42014831e-01f, -1.46763436e-02f, 1.26985190e-02f, 6.22801408e-02f, 4.74753864e-02f, -4.35215980e-02f, 5.03061293e-03f,
  -7.47231841e-02f, -2.86923330e-02f, -1.37014478e-01f, -6.91783726e-02f, -1.08607654e-02f, 1.97346304e-02f, 2.08977330e-02f, -6.01967387e-02f, -8.82284567e-02f, -5.01090474e-03f,
  -7.22832233e-02f, -1.35988384e-01f, 4.61666062e-02f, -1.10405363e-01f, 3.94767076e-02f, 1.23656780e-01f, -1.27661861e-02f, -6.42720461e-02f, 1.89969297e-02f, 6.95459768e-02f,
  -4.29782160e-02f, -6.52004704e-02f, 4.65934426e-02f, -9.23634619e-02f, -4.51041386e-02f, -3.87283340e-02f, 3.21312658e-02f, 4.91866060e-02f, -1.75380409e-02f, 5.05157448e-02f,
  8.46155882e-02f, -4.77512591e-02f, -3.62310149e-02f, -1.10860914e-03f, 7.12309638e-03f, -6.60252869e-02f, 5.21040335e-02f, -2.97853593e-02f, -8.47126916e-02f, -7.97015056e-03f,
  -7.15945959e-02f, -3.93338576e-02f, 3.65602300e-02f, -1.41649069e-02f, -3.03998291e-02f, 2.17328910e-02f, 1.38480291e-02f, 4.45128120e-02f, 2.21647117e-02f, 1.21280057e-02f,
  1.60766896e-02f, 3.92766893e-02f, -6.67295828e-02f, -9.91220959e-03f, -8.15930665e-02f, 8.64229351e-02f, 5.61503284e-02f, -7.43576810e-02f, 3.92693691e-02f, -1.54413581e-02f,
  1.71118304e-02f, 6.11978732e-02f, -7.02835321e-02f, -1.20257018e-02f, -6.54749125e-02f, 3.54915746e-02f, 3.59137580e-02f, 4.46629673e-02f, 4.54285853e-02f, -3.29510719e-02f,
  3.39362361e-02f, 1.19345677e-04f, 5.30451164e-02f, 5.65226004e-02f, 4.67763245e-02f, 2.08980348e-02f, -1.60151701e-02f, 8.39513242e-02f, -7.97244385e-02f, -5.54491617e-02f,
  -1.64473787e-01f, -6.92858770e-02f, -9.39726904e-02f, 5.99279581e-03f, 3.65406871e-02f, -4.04594094e-02f, -1.68335140e-02f, -9.00185034e-02f, 5.86790498e-03f, 4.04528007e-02f,
  -2.24393401e-02f, 6.49878681e-02f, -8.49239603e-02f, 2.75900792e-02f, 4.08132151e-02f, 1.49724763e-02f, -5.18360585e-02f, -3.44229303e-02f, -8.29065219e-02f, 5.93927801e-02f,
  -5.63876629e-02f, 3.74600701e-02f, 4.99315895e-02f, 4.01340239e-02f, -6.07309900e-02f, 2.70298049e-02f, -7.86860064e-02f, -5.56673296e-02f, -3.26732323e-02f, -8.33967626e-02f,
  -2.06146076e-01f, -3.89086567e-02f, 5.45746051e-02f, 2.13540401e-02f, -1.75847847e-04f, -4.95812669e-03f, 2.71115173e-02f, -9.97349098e-02f, -1.16797239e-01f, 1.25167161e-01f,
  2.54512057e-02f, -1.59680583e-02f, 1.34587035e-01f, 1.06468722e-01f, -2.23210156e-02f, 1.30192667e-01f, 1.22325020e-02f, 5.85748963e-02f, 4.53954749e-02f, -8.65286663e-02f,
  7.97601789e-03f, 9.75042209e-03f, 1.37065381e-01f, -8.22704434e-02f, 2.38312222e-02f, -1.18721038e-01f, -2.13023275e-02f, 5.93587868e-02f, -7.98690915e-02f, -6.35626819e-03f,
  6.52287751e-02f, -1.23953976e-01f, -8.04321691e-02f, -4.51753214e-02f, 3.24572995e-03f, 5.59408851e-02f, -4.30049486e-02f, 9.62806717e-02f, -9.96379331e-02f, 2.03556679e-02f,
  -3.26248631e-02f, -1.74874328e-02f, -5.06721474e-02f, -1.50371781e-02f, -1.37743168e-02f, -8.70583057e-02f, -3.67204100e-02f, -3.46076339e-02f, 3.46727116e-04f, 1.50530562e-02f,
  1.17747961e-02f, -3.50853498e-03f, 4.13445309e-02f, 8.81879628e-02f, -7.43002445e-02f, 5.57313673e-02f, 3.43743637e-02f, 4.59801070e-02f, 3.70654208e-03f, -9.44350883e-02f,
  -6.87907487e-02f, -6.21856302e-02f, 3.57303880e-02f, -3.66750769e-02f, 1.06964130e-02f, 1.37050590e-02f, 2.69575007e-02f, 7.18404874e-02f, -7.15209842e-02f, -7.96687752e-02f,
  6.96997121e-02f, -8.40528905e-02f, -4.85976227e-03f, -6.66405167e-03f, 4.04440835e-02f, 6.52978346e-02f, -5.94389923e-02f, -9.27230045e-02f, -4.75351736e-02f, 4.93859127e-02f,
  -8.26837495e-03f, -1.47748310e-02f, -6.15761802e-02f, -1.63287837e-02f, 2.60840561e-02f, 2.24714261e-02f, 4.53051627e-02f, -5.29614203e-02f, -2.31109541e-02f, -5.81153296e-03f,
  2.98078712e-02f, -1.50306404e-01f, 3.33421081e-02f, 7.57936481e-03f, 2.49283621e-04f, -1.97205190e-02f, -6.86954632e-02f, -1.89641584e-02f, -8.98149759e-02f, 5.50228022e-02f,
  -7.81818330e-02f, -7.98104182e-02f, 2.75868885e-02f, 1.46411369e-02f, -7.81017914e-02f, -5.67840822e-02f, 5.93844689e-02f, -7.35484436e-02f, -2.26353947e-02f, -4.91565429e-02f,
  1.64170675e-02f, 1.82676818e-02f, -3.26533765e-02f, -4.64945547e-02f, -5.21812513e-02f, 6.96702376e-02f, 2.18708273e-02f, 9.75747406e-02f, 4.64888066e-02f, -2.03014296e-02f,
  -6.82249218e-02f, 2.06883810e-02f, -1.85702704e-02f, 1.00545265e-01f, -2.78692432e-02f, -1.23091213e-01f, -1.08011745e-01f, 8.95404490e-04f, 3.55504192e-02f, -1.10343222e-04f,
  -9.67716500e-02f, -1.63853038e-02f, -6.47485107e-02f, 1.22303935e-03f, -9.48301330e-03f, -1.59378182e-02f, -1.12793282e-01f, -8.07990804e-02f, 3.82470936e-02f, -1.15750600e-02f,
  -8.16952661e-02f, -2.39692684e-02f, -6.10364228e-02f, 2.85785180e-02f, -4.63926010e-02f, -4.62335199e-02f, -1.00743763e-01f, 3.44966501e-02f, 8.22851509e-02f, 1.69877764e-02f,
  -3.54497097e-02f, -4.65400721e-04f, -1.02199838e-02f, 1.79660078e-02f, 1.03015695e-02f, 3.52067151e-03f, 4.86809276e-02f, -5.67287803e-02f, -6.32008985e-02f, -5.51603846e-02f,
  -2.41296571e-02f, 6.39509922e-03f, 9.72156525e-02f, 4.67471294e-02f, 6.23049773e-02f, 6.40093088e-02f, 6.75838664e-02f, 4.07446362e-02f, -7.53758922e-02f, -1.55540286e-02f,
  6.96278526e-04f, 1.45836994e-02f, 7.37167671e-02f, 3.78205255e-02f, 2.11680066e-02f, 9.61590111e-02f, 4.80625145e-02f, 1.05116758e-02f, -4.41621207e-02f, 8.93795118e-02f,
  -2.24714205e-02f, -4.14404832e-02f, 2.18178239e-02f, 4.37357873e-02f, -4.88151684e-02f, 8.25506728e-03f, 4.97674942e-03f, -1.54672461e-02f, 2.57091988e-02f, 4.40375134e-02f,
  -9.99081880e-03f, 1.63062185e-04f, -8.54661036e-03f, -9.33251604e-02f, 5.33484593e-02f, -2.92269252e-02f, -5.76745346e-02f, -4.89671417e-02f, -3.34854773e-03f, -7.57424459e-02f,
  -2.95832683e-03f, -7.60614499e-02f, 9.08142030e-02f, -2.87749022e-02f, 1.80840064e-02f, 2.04396788e-02f, 8.17470253e-02f, 4.75504175e-02f, 3.71162221e-02f, -7.90806487e-02f,
  -7.35021383e-02f, -1.34118423e-01f, 6.43047467e-02f, -5.58693036e-02f, -1.77745186e-02f, 1.06252441e-02f, -7.90629163e-02f, 5.77794090e-02f, -1.11422084e-01f, 7.15900585e-02f,
  -2.84113679e-02f, 9.83232446e-03f, -4.32927459e-02f, -3.52005176e-02f, -3.18501145e-02f, -9.80509259e-03f, -5.05809411e-02f, 1.56543273e-02f, 5.62005341e-02f, -5.89767545e-02f,
  -6.03489280e-02f, 7.44171217e-02f, -5.63299917e-02f, 1.16676548e-02f, -1.01505630e-01f, 8.00803304e-02f, -7.45219737e-02f, -8.60810187e-03f, -1.42817264e-02f, -7.70742213e-03f,
  -4.01258692e-02f, 1.62882172e-02f, 3.19834389e-02f, 5.47803119e-02f, -1.67859122e-02f, -6.40972853e-02f, -7.56407902e-02f, -3.47943441e-03f, -1.08710073e-01f, -4.31271568e-02f,
  -3.46279480e-02f, 1.08717486e-01f, 7.44285583e-02f, -4.48622033e-02f, -2.34551318e-02f, 7.42140263e-02f, 1.08181424e-02f, 6.95221052e-02f, 9.21380967e-02f, -4.70303223e-02f,
  -7.13862628e-02f, -4.84980829e-02f, 1.07337333e-01f, -9.94207114e-02f, 2.20564846e-03f, 6.88121170e-02f, 5.10409214e-02f, 8.13439339e-02f, 7.09553361e-02f, -6.27268255e-02f,
  3.83166894e-02f, -9.11673456e-02f, 9.93503332e-02f, -7.38052577e-02f, 6.38511851e-02f, 1.81243848e-02f, -1.83986668e-02f, -2.20666230e-02f, -1.01151019e-02f, -4.89934720e-02f,
  5.77053241e-02f, -3.18127088e-02f, 1.83402114e-02f, -5.51025569e-02f, -1.35290064e-02f, 4.32965681e-02f, 3.56242172e-02f, 1.82010643e-02f, 3.38140801e-02f, -5.36438171e-03f,
  -5.11018001e-02f, -2.57776845e-02f, -1.93969402e-02f, -5.01553789e-02f, -6.06042752e-03f, 5.45813097e-03f, -5.69569133e-02f, 3.63844335e-02f, 6.82792962e-02f, -7.33446628e-02f,
  4.74440977e-02f, 5.35368659e-02f, -9.00203437e-02f, -2.72141513e-03f, -3.11069395e-02f, -5.40539064e-02f, 3.93356644e-02f, 3.55302356e-02f, 4.09684964e-02f, 4.48536798e-02f,
  5.10544553e-02f, 9.05980617e-02f, -3.78998332e-02f, -5.29899858e-02f, 8.69919956e-02f, -5.91263399e-02f, -1.78011339e-02f, -7.14726076e-02f, -4.22185026e-02f, 5.02182543e-02f,
  8.63908697e-03f, -2.35892683e-02f, 3.22587341e-02f, -3.41820680e-02f, -8.84618685e-02f, 2.54646260e-02f, 6.49680644e-02f, -7.27901682e-02f, 7.71762654e-02f, 2.00955886e-02f,
  3.86430398e-02f, -8.59913900e-02f, -7.84923732e-02f, -8.33870173e-02f, -1.09070279e-02f, 3.88628450e-06f, 1.12076360e-03f, -5.77948950e-02f, -8.58330652e-02f, 4.47454117e-02f,
  -7.09579838e-03f, 2.47512367e-02f, -6.55825585e-02f, -6.96442276e-03f, -4.54753488e-02f, -8.65702853e-02f, -2.89115701e-02f, 2.15990152e-02f, -5.85867725e-02f, -7.91135803e-02f,
  7.45471492e-02f, -2.85050385e-02f, -5.40648662e-02f, -6.65430054e-02f, 6.84365630e-02f, -3.13157029e-02f, -2.34341789e-02f, 5.25799058e-02f, 6.61916807e-02f, -2.49202847e-02f,
  -1.22643247e-01f, 4.82131541e-02f, -6.61564022e-02f, -5.24573922e-02f, 7.22159594e-02f, -6.09242618e-02f, 5.79840839e-02f, -5.00181783e-03f, 5.49603850e-02f, 6.09415323e-02f,
  7.47804865e-02f, -3.24377231e-02f, -3.10099758e-02f, -8.66305083e-03f, -1.24077328e-01f, 6.87209293e-02f, -5.54520776e-03f, -7.05350712e-02f, -1.13784023e-01f, 1.91552788e-02f,
  3.94659676e-02f, 1.00663975e-01f, 8.75702351e-02f, 7.39013925e-02f, -1.41255064e-02f, 1.00159422e-01f, 1.28416449e-01f, 9.47195217e-02f, 7.58791044e-02f, -8.00373331e-02f,
  -4.43204939e-02f, -2.60190573e-02f, -2.78412085e-02f, 4.80942056e-02f, -5.51235341e-02f, 1.90050583e-02f, -6.04840666e-02f, -7.70631209e-02f, 8.26499835e-02f, -6.85648546e-02f,
  -1.77026466e-02f, 4.67415825e-02f, -9.66031700e-02f, -2.23781657e-03f, 3.80418375e-02f, 2.84541734e-02f, 3.56141552e-02f, 8.71750042e-02f, 3.82765420e-02f, 6.49305508e-02f,
  -1.63757149e-02f, 1.11886207e-03f, 2.48317346e-02f, 2.70192325e-02f, 1.07488129e-02f, -9.10181776e-02f, -7.64128892e-03f, 3.91681604e-02f, 3.31567787e-02f, -3.90474834e-02f,
  2.61949468e-02f, 2.90195961e-02f, 1.07728960e-02f, -4.51434068e-02f, -7.12796152e-02f, 8.12138841e-02f, -3.45510505e-02f, 1.97516847e-02f, -8.33558217e-02f, 6.12854473e-02f,
  -1.74781103e-02f, 3.57890688e-02f, 1.74032710e-02f, 2.85042188e-04f, 7.81563520e-02f, 1.97747089e-02f, 2.56182011e-02f, 7.09915012e-02f, -2.02983487e-02f, -7.88419768e-02f,
  6.17116429e-02f, -3.39661203e-02f, 3.10055036e-02f, -3.94636169e-02f, -2.05922425e-02f, -4.28740010e-02f, 7.87046775e-02f, -4.91162091e-02f, 8.54005339e-04f, -3.67715806e-02f,
  -1.25025231e-02f, -9.67946195e-04f, 2.47643180e-02f, 5.41674607e-02f, 2.56491750e-02f, 8.89068097e-02f, 5.60596138e-02f, 7.49485344e-02f, 4.24240828e-02f, -7.03652203e-02f,
  3.53313424e-02f, 3.93772349e-02f, -3.12277935e-02f, 2.90239565e-02f, 4.30002809e-02f, 4.92243543e-02f, -4.80700918e-02f, -6.31786734e-02f, 3.85899656e-02f, 3.14342938e-02f,
  1.04878001e-01f, -4.60448563e-02f, 5.06086648e-03f, 7.33955055e-02f, -6.93898723e-02f, 4.74175587e-02f, 6.87857270e-02f, 6.18296163e-03f, 3.49368788e-02f, -3.84301096e-02f,
  -2.83157770e-02f, -1.32747605e-01f, 7.24059809e-03f, 4.83054444e-02f, -5.48165999e-02f, -5.73699996e-02f, 8.51392969e-02f, -7.90032521e-02f, 2.83758081e-02f, -9.66024995e-02f,
  8.60698819e-02f, -7.04816580e-02f, 1.31093845e-01f, 7.96310231e-02f, 4.84723262e-02f, 3.63588007e-03f, -5.58784716e-02f, 1.05193079e-01f, -5.98455556e-02f, 3.68824340e-02f,
  1.67519562e-02f, -7.46947005e-02f, 9.42260027e-02f, -6.72231466e-02f, -4.34019454e-02f, -9.75249484e-02f, 2.98101194e-02f, -5.72056882e-02f, -1.07380398e-01f, 8.28991383e-02f,
  -5.02162278e-02f, 3.47975977e-02f, 8.09908137e-02f, 7.43951052e-02f, 1.36101176e-03f, 8.53617564e-02f, 4.46552299e-02f, -1.54766405e-03f, 7.97517970e-02f, -3.94225828e-02f,
  6.56904727e-02f, -3.55412476e-02f, 1.20046632e-02f, 3.97058614e-02f, -2.36865394e-02f, 3.89880650e-02f, 6.86412603e-02f, -3.29445824e-02f, -3.72101627e-02f, 1.02983927e-02f,
  -5.17064938e-04f, -4.49118502e-02f, 4.58217785e-02f, 3.76780219e-02f, -1.30808086e-03f, -6.71368688e-02f, -3.71802039e-02f, 5.02068875e-03f, 5.61475009e-02f, -1.75279903e-03f,
  -6.80287108e-02f, 3.66375409e-02f, 2.62914225e-02f, -2.62349322e-02f, -5.21808676e-02f, 2.97304895e-02f, -7.88797885e-02f, 5.16933836e-02f, 2.63047945e-02f, 6.39390619e-03f,
  -7.19480636e-03f, 1.26650520e-02f, -3.32607292e-02f, -8.99271294e-02f, 6.65341467e-02f, 6.35107234e-02f, 2.70921942e-02f, -6.70156777e-02f, 5.29337749e-02f, 3.87622006e-02f,
  -3.90804783e-02f, 7.59471282e-02f, 7.41060302e-02f, -3.38458195e-02f, 6.29328042e-02f, -3.19432840e-02f, 2.54842471e-02f, -4.29011583e-02f, 8.10297206e-03f, 5.93977794e-02f,
  2.48801932e-02f, -8.74354541e-02f, -5.65321259e-02f, 1.41438311e-02f, -4.12379801e-02f, -1.74386501e-02f, 5.08332029e-02f, -1.11542903e-01f, 6.28143325e-02f, -6.24302514e-02f,
  1.68444887e-02f, 9.28093046e-02f, -7.21081197e-02f, -6.64259419e-02f, 2.55026724e-02f, -1.52172279e-02f, -5.20915492e-04f, -7.32163042e-02f, 7.16699809e-02f, -5.53210787e-02f,
  2.79679857e-02f, -2.94522499e-03f, 2.60588024e-02f, 3.95938195e-02f, 3.71211395e-02f, 4.80104536e-02f, -4.44411151e-02f, -7.28842467e-02f, 1.26420986e-02f, 6.21493980e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.58117314e-02f, 5.06233517e-03f, 2.54809633e-02f, 5.14662750e-02f, 1.62225425e-01f, 8.95574689e-02f, 4.31520976e-02f, 2.64653638e-02f, 7.09385574e-02f, 2.34968923e-02f,
  5.87772876e-02f, 9.53820050e-02f, 9.93145257e-02f, 5.36027625e-02f, 1.34007826e-01f, -6.70828810e-03f, 9.64562781e-03f, 6.75980374e-02f, 4.44212854e-02f, -1.86740514e-02f,
  8.85695964e-02f, 1.28636405e-01f, -2.69314330e-02f, 1.66162327e-02f, 7.95021653e-02f, -5.14595062e-02f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  8.11398774e-02f, 8.09713453e-02f, 2.62418017e-02f, 6.17796183e-02f, -2.24475693e-02f, -3.65479328e-02f, -1.09839767e-01f, 2.42370721e-02f, 6.58555552e-02f, -3.45167741e-02f,
  6.46189675e-02f, 6.98116794e-02f, -7.55590126e-02f, -7.04070926e-02f, 9.49255303e-02f, 1.15848541e-01f, -5.12735061e-02f, 2.78995000e-02f, 4.52447720e-02f, -8.88819993e-02f,
  5.48841879e-02f, 4.22309525e-02f, 4.05600742e-02f, 7.18854144e-02f, 1.23739988e-01f, -3.38246897e-02f, -7.15433657e-02f, -6.18531741e-02f, 7.43932426e-02f, 4.93934266e-02f,
  7.76086673e-02f, -1.67480074e-02f, -3.95149253e-02f, -7.67057911e-02f, 5.14524989e-02f, -4.65131216e-02f, -4.34646197e-02f, 6.26873299e-02f, -5.77667020e-02f, -2.04826724e-02f,
  4.17228863e-02f, 1.06060309e-02f, 5.26822433e-02f, -3.39985713e-02f, -2.99387351e-02f, -4.10320722e-02f, -4.46975902e-02f, -5.61639890e-02f, -6.91780746e-02f, -7.61607215e-02f,
  -4.56773899e-02f, -1.56121003e-02f, 8.70154276e-02f, -5.81847765e-02f, -1.18786745e-01f, -3.01594622e-02f, 1.01372197e-01f, 4.70498279e-02f, 1.75512940e-01f, 1.05868494e-02f,
  2.55085230e-02f, -1.26499236e-01f, 6.23324998e-02f, -5.71257807e-02f, -3.65366675e-02f, 5.12710959e-03f, -1.24220528e-01f, -3.56390588e-02f, -3.89618147e-03f, 6.64539859e-02f,
  -2.82160696e-02f, 6.72974251e-03f, 7.21290484e-02f, 6.69150427e-02f, 1.34488782e-02f, -1.35664552e-01f, 5.67398444e-02f, -1.27376422e-01f, -4.87494655e-02f, -8.17841664e-02f,
  -1.98000465e-02f, -1.29427135e-01f, 1.45348042e-01f, -3.29304673e-02f, -5.28340414e-02f, 4.76617925e-02f, 9.70015228e-02f, 2.63481284e-03f, -1.14295162e-01f, 4.96381670e-02f,
  4.46922408e-04f, -4.47109006e-02f, -4.26654741e-02f, 1.41981378e-01f, -9.73395780e-02f, -1.93317197e-02f, -6.31945208e-02f, -5.47012836e-02f, -9.62757170e-02f, -5.09081744e-02f,
  6.43120930e-02f, -3.81381139e-02f, 4.49802540e-02f, 5.35755008e-02f, -3.58828641e-02f, -9.01004374e-02f, -5.09278551e-02f, -8.15450251e-02f, 7.79350027e-02f, -7.67991915e-02f,
  4.02777605e-02f, 8.16169679e-02f, -1.75087098e-02f, 8.15550685e-02f, 1.36206090e-01f, -3.99257652e-02f, 3.55194905e-03f, -2.45384295e-02f, -3.96157838e-02f, 8.63782596e-03f,
  6.84610531e-02f, -6.40914813e-02f, -1.21628545e-01f, -1.24558425e-02f, -2.41294131e-02f, -3.98112908e-02f, 2.64184661e-02f, -1.01513952e-01f, -4.90840487e-02f, 8.19289759e-02f,
  3.26889493e-02f, 1.56854823e-01f, -8.56485292e-02f, 6.10037297e-02f, 9.80099142e-02f, 1.34863183e-02f, -5.95042892e-02f, 6.08114488e-02f, -5.18826693e-02f, -9.21690166e-02f,
  8.64123031e-02f, 6.05333149e-02f, -1.33564278e-01f, 7.21830055e-02f, -1.10616729e-01f, 8.96849483e-02f, -6.89045042e-02f, 6.59272373e-02f, 4.06645797e-02f, -2.32893787e-02f,
  3.25032976e-03f, -6.16732538e-02f, 7.62332007e-02f, -1.23119736e-02f, 1.18663078e-02f, 2.40183510e-02f, 9.27891210e-02f, -4.94506806e-02f, -6.76145703e-02f, -4.04185094e-02f,
  8.70500412e-03f, 4.22223434e-02f, 1.32067809e-02f, -3.90109457e-02f, -4.85409051e-04f, 1.07833277e-02f, 5.76746836e-02f, -9.08754915e-02f, 8.21666270e-02f, 5.69134802e-02f,
  -3.23946588e-02f, 4.72809974e-04f, 1.96707398e-02f, -3.28181311e-02f, 2.99349590e-03f, 3.09410715e-03f, 8.57963040e-02f, 5.75762689e-02f, 7.51110017e-02f, 5.25532030e-02f,
  -1.50438756e-01f, -2.31428351e-02f, -1.30931437e-01f, 2.59038061e-02f, -5.71510158e-02f, -8.90785307e-02f, -6.62706792e-02f, 1.76717058e-01f, 1.52742326e-01f, -2.31742002e-02f,
  1.94852520e-02f, -3.19134481e-02f, -3.34430523e-02f, 1.06307484e-01f, -6.53860867e-02f, 3.52567546e-02f, 2.27161497e-01f, -1.55319408e-01f, 4.05198298e-02f, 1.83564909e-02f,
  5.65733053e-02f, 1.04610816e-01f, 1.45502523e-01f, -1.49004236e-01f, -1.21440716e-01f, -3.28227761e-03f, -6.33888170e-02f, -1.75791040e-01f, 2.98006530e-03f, 4.17330451e-02f,
  1.47573188e-01f, -1.03794746e-01f, -1.45610660e-01f, 6.05854243e-02f, -1.27155089e-03f, -1.04435176e-01f, -5.97548392e-03f, -1.11194011e-02f, 1.55436277e-01f, -2.58335620e-01f,
  -4.17015590e-02f, -2.24818680e-02f, 1.03646182e-01f, -1.24820650e-01f, -5.64415120e-02f, -3.96276563e-02f, 8.44387396e-04f, -8.64257812e-02f, -7.23556504e-02f, 1.08902268e-01f,
  -3.90799157e-02f, 1.38858808e-02f, -1.73109230e-02f, 8.93921405e-02f, 9.43161771e-02f, -5.73986545e-02f, -1.91850830e-02f, -1.20280229e-01f, 9.14808065e-02f, -6.78603128e-02f,
  -2.28930474e-03f, 7.03678951e-02f, -9.17404965e-02f, -3.38417441e-02f, 1.41357005e-01f, -1.73200499e-02f, 1.23583958e-01f, -1.38683066e-01f, 1.25140294e-01f, -2.29838304e-02f,
  -1.09871905e-02f, -1.06248878e-01f, 3.32554877e-02f, -6.51996657e-02f, -4.72695008e-02f, -5.50546087e-02f, 5.25942892e-02f, 1.19409310e-02f, -4.11293916e-02f, 1.24331199e-01f,
  2.30745692e-02f, -3.48658562e-02f, 5.21594509e-02f, -8.43519494e-02f, 3.64534594e-02f, 1.08193822e-01f, -4.89380695e-02f, 8.99317488e-03f, 1.43729206e-02f, -4.70466949e-02f,
  -1.34403393e-01f, 7.15698302e-02f, -5.86170703e-02f, -3.46611664e-02f, -4.89910357e-02f, -7.55701959e-02f, 7.83197582e-02f, 5.11738472e-02f, 4.46051806e-02f, -2.44659893e-02f,
  4.75501753e-02f, 3.71950679e-02f, -1.36031257e-02f, 7.26325661e-02f, 7.54384249e-02f, -1.01096844e-02f, -8.94351751e-02f, 2.39127297e-02f, -4.29241732e-02f, -1.82528440e-02f,
  -3.98575217e-02f, -1.33775204e-01f, 8.10205471e-03f, 3.67830470e-02f, 1.11229839e-02f, -8.24746583e-03f, 2.04596855e-02f, 1.11040451e-01f, 6.90810233e-02f, -5.41920774e-02f,
  3.30609307e-02f, 7.59866312e-02f, -1.50857037e-02f, -4.54507172e-02f, -1.03193549e-02f, -2.38469932e-02f, 8.95294547e-02f, -4.93926629e-02f, -6.57625422e-02f, -1.90429136e-01f,
  4.79930602e-02f, -7.23706884e-03f, -9.75434855e-02f, 2.57260744e-02f, -3.68288532e-02f, 2.37141550e-01f, 9.95668247e-02f, 6.81043491e-02f, 5.34425676e-02f, 9.65099875e-03f,
  -7.25809261e-02f, 1.03093222e-01f, 1.09136716e-01f, -1.12032399e-01f, 8.82180631e-02f, 1.30938962e-01f, 2.34113671e-02f, -6.90032616e-02f, 1.21412903e-01f, -1.03620671e-01f,
  -6.14278093e-02f, 1.32736787e-01f, -5.76910041e-02f, -1.20497987e-01f, -4.31024330e-03f, 3.63100902e-03f, -1.55131698e-01f, 2.91540567e-02f, 3.63685004e-02f, 4.71535977e-03f,
  -1.16999395e-01f, -1.21324100e-01f, -2.30283499e-01f, 1.93960890e-02f, 1.06638335e-01f, -1.33207828e-01f, 5.94672859e-02f, -2.00071901e-01f, 6.22101016e-02f, -6.27015978e-02f,
  4.04678509e-02f, -1.05801754e-01f, -9.39482078e-02f, -1.33427717e-02f, -3.95886153e-02f, 3.38535197e-02f, 7.89525136e-02f, -5.44549413e-02f, 7.36112371e-02f, -7.21243173e-02f,
  1.21089466e-01f, -7.13695362e-02f, 1.05819397e-01f, -1.63804237e-02f, 2.75244601e-02f, -3.56290005e-02f, -8.71978328e-02f, -1.02668792e-01f, -7.05893561e-02f, 2.35112198e-02f,
  5.72478324e-02f, -1.35295779e-01f, 2.88236188e-03f, -1.10832095e-01f, 1.10154144e-01f, 2.49196943e-02f, -1.28999278e-01f, -5.25991805e-02f, 3.74996439e-02f, -6.80594966e-02f,
  -3.80747765e-02f, 1.25233969e-02f, -3.28024626e-02f, 3.85595043e-03f, 3.48088555e-02f, 1.51504934e-01f, -6.92227036e-02f, 2.19331663e-02f, -4.63982150e-02f, -7.72822127e-02f,
  1.04394881e-02f, -7.32955411e-02f, 1.22595383e-02f, -4.01419513e-02f, 8.09576176e-03f, 6.69370070e-02f, -2.01118011e-02f, -6.03557080e-02f, -1.65006593e-02f, -8.33937153e-02f,
  -4.37313542e-02f, -1.76558737e-02f, -7.54455850e-02f, -3.03447489e-02f, -7.92700723e-02f, -7.81778470e-02f, 4.63496782e-02f, 5.33254002e-04f, 1.40161430e-02f, 5.95982634e-02f,
  2.16379073e-02f, 1.06123602e-02f, -3.37856598e-02f, -1.25879362e-01f, 8.59906524e-03f, 9.67488363e-02f, 3.21307443e-02f, -1.39895240e-02f, 4.81775254e-02f, 1.01556644e-01f,
  -9.97397397e-03f, 7.11329505e-02f, 9.19483379e-02f, -5.44641279e-02f, 1.56772323e-02f, -2.90244576e-02f, -6.45278394e-02f, 2.72740349e-02f, -1.41240275e-02f, -6.47760630e-02f,
  2.61076968e-02f, -1.45504279e-02f, 1.01870270e-02f, 2.22649686e-02f, 7.44870305e-02f, 1.92730382e-01f, -9.76250600e-03f, 4.58860137e-02f, -1.33500174e-01f, -3.94963361e-02f,
  2.30254661e-02f, 1.62248611e-01f, 4.31370810e-02f, -1.86065927e-01f, 5.72500331e-03f, -8.80170986e-02f, -2.21321732e-01f, 3.46283056e-02f, 6.26345426e-02f, 9.84104350e-02f,
  -6.64062724e-02f, 1.14634000e-01f, 4.55681235e-02f, -2.19062269e-02f, -9.08162668e-02f, 1.31495297e-01f, 4.17328179e-02f, 1.62690729e-01f, 4.96801697e-02f, -2.15407938e-01f,
  7.04035461e-02f, 3.49631310e-02f, -7.71752149e-02f, 2.47074347e-02f, 1.64141551e-01f, 1.25105500e-01f, 1.32746637e-01f, -1.91009119e-01f, 3.52306478e-02f, 5.93489818e-02f,
  1.42014980e-01f, -7.28965849e-02f, -3.65556479e-02f, 8.94942731e-02f, 1.87727198e-01f, 8.91229063e-02f, 8.47099796e-02f, 1.31967098e-01f, -1.10905617e-01f, -1.57063499e-01f,
  2.09032744e-03f, -4.76988740e-02f, 4.24240381e-02f, -8.22904631e-02f, -8.94894302e-02f, 1.65976658e-01f, -8.72156620e-02f, -8.47510900e-03f, -4.90516163e-02f, 6.42150873e-03f,
  5.13620414e-02f, -2.92848889e-02f, -5.38626947e-02f, -2.25170166e-03f, 6.57509407e-03f, 1.23009682e-01f, -1.47295250e-02f, 1.25985935e-01f, 4.55261767e-02f, 1.06852397e-01f,
  6.68861484e-03f, 8.51987153e-02f, -2.37075333e-02f, -9.29551646e-02f, 9.44955796e-02f, 2.99837459e-02f, 5.30487821e-02f, -3.50774191e-02f, 9.63120535e-02f, 1.13937244e-01f,
  1.31344466e-04f, 4.05669250e-02f, 4.69125211e-02f, -3.52276042e-02f, -4.36563231e-02f, 5.45893013e-02f, 2.36565713e-02f, -8.33748188e-03f, 6.25319853e-02f, -3.65552008e-02f,
  2.10534465e-02f, -4.37900377e-03f, -1.23630939e-02f, -1.37501610e-02f, -8.49951580e-02f, -2.87729371e-02f, -5.57465479e-03f, -1.33903848e-03f, -8.09683129e-02f, 6.03464954e-02f,
  1.20556150e-02f, 2.59186961e-02f, 6.83593377e-03f, 1.26245767e-02f, 7.00375587e-02f, -7.29770912e-03f, -8.70775357e-02f, -7.48379007e-02f, -3.91881261e-03f, -5.65505251e-02f,
  -9.28777382e-02f, -1.84112061e-02f, 4.30264883e-02f, -8.98377672e-02f, -1.30263090e-01f, 7.36944377e-02f, -3.57401446e-02f, -3.55645977e-02f, 1.69198159e-02f, -4.63528670e-02f,
  5.62130474e-02f, 3.57121304e-02f, -9.81696174e-02f, 1.12348851e-02f, -1.17975138e-02f, -6.61378354e-02f, 5.93897924e-02f, -4.22949642e-02f, 5.47339383e-04f, 1.80686135e-02f,
  -7.03139454e-02f, -1.01550505e-01f, 1.40857538e-02f, -2.68808883e-02f, 1.16367511e-01f, -1.23508856e-01f, 6.88951686e-02f, 4.99120494e-03f, 9.50366035e-02f, -7.35555813e-02f,
  -1.33927077e-01f, -4.81567867e-02f, 5.78613579e-02f, -4.00736593e-02f, 5.20825051e-02f, 2.33225413e-02f, -6.18007071e-02f, -7.04879779e-03f, -4.58873063e-02f, -1.55167542e-02f,
  -2.51399744e-02f, 1.02529749e-01f, 6.01511635e-02f, -1.02117829e-01f, 4.66328040e-02f, -1.94558054e-01f, -5.78352399e-02f, 8.39384645e-02f, 8.15159976e-02f, -1.48782045e-01f,
  2.55124830e-02f, 1.77182764e-01f, 1.35167614e-02f, 5.72581105e-02f, -1.37410402e-01f, 1.44426778e-01f, 7.57058412e-02f, -3.40194702e-02f, 3.44608277e-02f, -9.15285666e-03f,
  1.10098035e-05f, -8.93644840e-02f, -8.11987519e-02f, 9.65264291e-02f, 5.31868488e-02f, -1.22765087e-01f, -7.42402151e-02f, 6.86823130e-02f, 2.08524130e-02f, 5.43588446e-03f,
  -9.23128203e-02f, -5.86177632e-02f, 7.98959360e-02f, -1.40621677e-01f, 6.36769384e-02f, -9.04198065e-02f, 8.12329203e-02f, -8.02101418e-02f, -3.84129547e-02f, 1.02369739e-02f,
  1.04555205e-01f, -5.45025915e-02f, 5.18665873e-02f, -5.55015653e-02f, -5.80418333e-02f, -2.48172991e-02f, -8.54867231e-03f, 1.08015062e-02f, 6.30552918e-02f, 4.55631129e-02f,
  5.96049195e-03f, 3.76206450e-02f, -1.00127719e-02f, -7.97835365e-03f, 2.74893194e-02f, -7.05546141e-02f, -7.21887425e-02f, -6.07711487e-02f, 5.81482286e-03f, -1.67014296e-04f,
  -4.15497944e-02f, 3.59108187e-02f, -5.81403710e-02f, 7.48235583e-02f, 6.10304438e-02f, -5.85967749e-02f, 1.15337878e-01f, -5.79710342e-02f, 8.11157301e-02f, -5.88983931e-02f,
  4.56716493e-02f, -4.38340642e-02f, -7.89568797e-02f, 5.91285527e-02f, 6.27821609e-02f, -3.24643264e-03f, 4.44287388e-03f, 3.09644621e-02f, -1.73558537e-02f, -1.23549523e-02f,
  -6.90515861e-02f, -1.26167536e-01f, -2.16889810e-02f, -3.56099866e-02f, 7.87133500e-02f, 9.56497714e-02f, 1.09794915e-01f, -5.53857200e-02f, -5.59795788e-03f, -4.29531187e-02f,
  9.50871408e-02f, -6.07479364e-02f, -3.82966921e-02f, -3.26819681e-02f, -1.08781015e-03f, 1.03610724e-01f, -7.52277076e-02f, -9.08675194e-02f, -7.96316713e-02f, 1.61431525e-02f,
  -2.22095083e-02f, 5.50575405e-02f, 2.19361344e-03f, 2.10815892e-02f, 7.89701417e-02f, 7.32992962e-02f, 5.35652153e-02f, -1.72418710e-02f, 1.97405070e-02f, 1.03413373e-01f,
  -7.22254589e-02f, -4.58514839e-02f, 6.49243267e-03f, 2.58844364e-02f, 6.36489466e-02f, -1.60793457e-02f, 3.19220833e-02f, -5.17127588e-02f, -8.15307796e-02f, -1.63286105e-01f,
  2.93822140e-02f, -8.20555259e-03f, -3.47530767e-02f, 7.71756321e-02f, 2.40826588e-02f, 6.88860044e-02f, 9.87244919e-02f, -3.50596644e-02f, -1.73071131e-01f, 1.65792629e-01f,
  6.00585006e-02f, -7.49423578e-02f, 2.88770758e-02f, 2.40127929e-02f, -1.02901377e-01f, 7.78091252e-02f, 2.64360551e-02f, 2.23938283e-02f, 8.61722007e-02f, 8.69062319e-02f,
  -1.64121710e-04f, 7.29238428e-03f, -8.57708454e-02f, 7.76544437e-02f, 1.36191651e-01f, -2.33346581e-01f, 1.49584115e-01f, 1.15381755e-01f, -5.26348548e-03f, 1.41508892e-01f,
  9.93132442e-02f, 2.32572347e-01f, -8.81844461e-02f, -1.61128268e-02f, -3.48041505e-02f, 3.28687504e-02f, -6.57067448e-02f, 2.13297650e-01f, 1.37342662e-01f, 1.92989796e-01f,
  1.58552285e-02f, -1.44345090e-02f, -5.39707690e-02f, 1.42857367e-02f, -7.63781816e-02f, 4.06326428e-02f, -5.03762476e-02f, 1.91562418e-02f, 8.38236809e-02f, 5.36714792e-02f,
  -6.11723922e-02f, 8.96653533e-02f, -3.52992564e-02f, -2.05376521e-02f, 5.03537990e-02f, 7.97187090e-02f, -1.18669719e-01f, -1.90660823e-02f, -9.65775475e-02f, 6.40851855e-02f,
  -1.24003455e-01f, -1.18344799e-02f, 7.13904202e-02f, 8.80395994e-02f, 8.19099620e-02f, 2.18986385e-02f, -2.08684374e-02f, 1.26042858e-01f, 8.52821991e-02f, 1.83740202e-02f,
  7.65420198e-02f, -1.48929143e-02f, 1.02196425e-01f, -6.69775754e-02f, -6.43062741e-02f, -5.00726663e-02f, 3.11815478e-02f, 1.07098073e-01f, 4.67033824e-03f, 1.07358046e-01f,
  7.95901269e-02f, 1.45792002e-02f, -1.16185024e-01f, -5.71358725e-02f, 4.98311268e-03f, 4.98663150e-02f, 2.07792744e-02f, -5.72390594e-02f, -8.48129392e-02f, -2.86789536e-02f,
  9.27819684e-02f, 3.74948606e-02f, -3.07078995e-02f, -7.93914273e-02f, 2.11259034e-02f, -5.68515360e-02f, -3.49600539e-02f, 2.94401664e-02f, 5.08527905e-02f, 8.00538510e-02f,
  -2.24583149e-02f, -2.05969699e-02f, 6.65282533e-02f, 1.34037025e-02f, -1.79196410e-02f, -2.87817419e-02f, 1.78664960e-02f, -1.13620888e-02f, 6.63784295e-02f, 5.81781343e-02f,
  8.03348050e-02f, 5.18069267e-02f, 7.74638075e-03f, 3.78776267e-02f, 4.26286682e-02f, -8.10323730e-02f, 3.68465334e-02f, -2.91551780e-02f, 6.02132492e-02f, 4.07929393e-03f,
  -2.75948513e-02f, -1.36828482e-01f, -1.17601849e-01f, -8.30032825e-02f, -1.37456313e-01f, -1.08078343e-03f, -5.81443794e-02f, -5.70042357e-02f, -1.57040641e-01f, -6.30973950e-02f,
  -1.90352812e-01f, 1.92117587e-01f, -6.00636750e-02f, 2.07608804e-01f, 1.81450918e-01f, 4.98190001e-02f, 3.30356136e-02f, -4.65813652e-03f, -9.95994080e-03f, 2.34919526e-02f,
  1.31186530e-01f, -5.12112938e-02f, -7.22369254e-02f, -8.77957195e-02f, -1.58263490e-01f, 3.02996002e-02f, 9.40442458e-02f, -2.93522142e-03f, -2.00261883e-02f, 3.35265021e-03f,
  -6.77494556e-02f, 6.41679987e-02f, 3.17512564e-02f, -1.16545200e-01f, 8.05287063e-02f, -7.59355864e-03f, -1.00803994e-01f, 1.41973495e-01f, 6.00205511e-02f, -4.52764668e-02f,
  -6.48164451e-02f, 5.15064597e-02f, 1.96357202e-02f, -6.77487925e-02f, -8.86734948e-02f, 1.36862397e-01f, 4.18760404e-02f, 7.78264031e-02f, -6.36819527e-02f, -5.88302426e-02f,
  -2.30668467e-02f, 4.72676046e-02f, 2.81114727e-02f, -2.66711116e-02f, 6.39565475e-03f, -1.99550157e-03f, -2.59013176e-02f, 9.96894017e-02f, -1.06051238e-02f, 4.45868336e-02f,
  4.68024649e-02f, -5.10824397e-02f, 2.80479863e-02f, -1.41592175e-01f, -7.53888264e-02f, -2.84726806e-02f, -1.85753796e-02f, 5.98188639e-02f, -4.88334373e-02f, 9.43660662e-02f,
  3.39991003e-02f, 2.51905005e-02f, -4.47135530e-02f, -3.26134334e-03f, -1.13110773e-01f, -4.33373116e-02f, -5.66593856e-02f, -7.82098845e-02f, -1.88083071e-02f, 3.06935143e-02f,
  6.70099854e-02f, -6.23772480e-02f, 8.81378055e-02f, -4.58747149e-02f, 1.23023912e-02f, 1.22650992e-02f, 1.05902225e-01f, -7.19384244e-03f, 4.60262559e-02f, 3.52002531e-02f,
  1.19245641e-01f, 9.21031535e-02f, -9.56697091e-02f, -3.88565771e-02f, 6.59956113e-02f, 6.59021363e-02f, -2.90640015e-02f, 1.26515791e-01f, -4.29238044e-02f, -5.59667610e-02f,
  3.15352827e-02f, 1.08805686e-01f, 4.70350310e-03f, -6.23907037e-02f, 3.18759084e-02f, -5.45716323e-02f, 8.23316276e-02f, -5.68093508e-02f, 3.36460844e-02f, -6.22542538e-02f,
  1.79563276e-02f, -6.25966787e-02f, 1.62462462e-02f, -3.93581018e-02f, 2.18726881e-02f, 8.49663168e-02f, -2.20267810e-02f, -4.05854397e-02f, -4.27173227e-02f, 4.61816005e-02f,
  6.48664087e-02f, 8.12934339e-02f, 3.74643654e-02f, -1.48451561e-02f, -4.89218459e-02f, 3.20596918e-02f, -6.69702841e-03f, 7.75336148e-03f, 4.63357531e-02f, 1.22116081e-01f,
  -1.64369121e-01f, 2.00338438e-01f, -1.73793361e-02f, 3.03803049e-02f, 1.00306660e-01f, -1.29244402e-01f, 3.59399728e-02f, -4.08587009e-02f, 1.43693849e-01f, -8.58685374e-02f,
  7.14513808e-02f, -2.25414440e-01f, -7.74160102e-02f, 4.09734622e-02f, -5.51362522e-02f, 3.24307531e-02f, 1.48654738e-02f, -1.49966031e-01f, -7.82027617e-02f, -1.65966779e-01f,
  -7.46286958e-02f, 5.59862889e-02f, 1.64083406e-01f, 1.02857731e-01f, -1.01631477e-01f, 5.37901483e-02f, -5.84565550e-02f, -8.58172551e-02f, -7.26697966e-02f, 5.21767177e-02f,
  -3.38485576e-02f, 2.25651097e-02f, -1.65884241e-01f, -2.80626472e-02f, 1.22252502e-01f, -1.37376398e-01f, -1.66953355e-01f, 2.00997517e-02f, -7.65799209e-02f, -7.92017356e-02f,
  8.08932558e-02f, 9.97063816e-02f, 6.32485226e-02f, -1.20144047e-01f, -1.78364620e-01f, -1.05972230e-01f, -2.70941984e-02f, -9.32644233e-02f, 8.04455057e-02f, 9.73376259e-02f,
  -6.28579631e-02f, 8.52977112e-02f, 3.64417955e-02f, -1.01645254e-01f, -1.46674123e-02f, 6.93337172e-02f, -3.57669964e-02f, 6.22351654e-04f, -7.08941519e-02f, -4.64270003e-02f,
  4.30602320e-02f, 5.19384034e-02f, -1.03806797e-03f, 1.69940796e-02f, 5.09050190e-02f, 7.93543383e-02f, 9.14799795e-02f, 6.06185421e-02f, 2.85444800e-02f, -7.74750412e-02f,
  -4.92382944e-02f, 7.62502626e-02f, -3.34042087e-02f, -1.71858575e-02f, 6.96907863e-02f, 2.59891916e-02f, -9.18900035e-03f, -1.05272047e-01f, 4.22766665e-03f, 2.16338765e-02f,
  -2.41264189e-03f, -9.37164016e-03f, 4.94598113e-02f, -3.41974609e-02f, 2.05968693e-02f, 7.48882592e-02f, -4.27122824e-02f, 5.15212826e-02f, -3.51051241e-02f, -4.88291197e-02f,
  7.45671466e-02f, -2.55500469e-02f, 2.06130128e-02f, -5.48578650e-02f, 3.01085599e-02f, 8.49341154e-02f, -5.93332089e-02f, 4.86168712e-02f, -1.91355590e-02f, -1.00586452e-01f,
  -9.55238789e-02f, -2.11709496e-02f, -4.07169499e-02f, 1.23316012e-01f, 1.48086092e-02f, -6.94429129e-02f, -9.95072443e-03f, 2.01070216e-02f, -3.72817479e-02f, -1.15881637e-01f,
  -8.30080509e-02f, -1.02818692e-02f, -9.46263149e-02f, 3.59852389e-02f, -5.40611111e-02f, -1.27411224e-02f, -8.64846408e-02f, 4.85688858e-02f, -1.82750337e-02f, -4.84719202e-02f,
  5.21722101e-02f, -5.53450212e-02f, -4.03733887e-02f, -2.36378852e-02f, -1.09431624e-01f, -6.82677841e-03f, 1.62867337e-01f, 1.01981483e-01f, -1.08758457e-01f, 7.17011541e-02f,
  -1.51026798e-02f, -1.79242969e-01f, -4.83081937e-02f, 1.78562123e-02f, -1.03916578e-01f, 8.66852999e-02f, 7.52527639e-02f, 9.13580656e-02f, 1.38017580e-01f, -9.96621326e-02f,
  -1.36411756e-01f, 6.49864897e-02f, -7.95548707e-02f, -1.02062382e-01f, 1.76977627e-02f, 4.17847149e-02f, -5.49373403e-02f, -3.03196907e-02f, -1.55358072e-02f, -1.12505388e-02f,
  9.06386524e-02f, 1.64656147e-01f, 1.12645119e-01f, 1.64787397e-02f, -7.28107914e-02f, -1.45020828e-01f, -9.36269537e-02f, 1.60068870e-02f, -2.89656520e-02f, -1.35039082e-02f,
  4.65616733e-02f, 9.50778797e-02f, 8.14355761e-02f, 6.85513765e-02f, -8.01986232e-02f, 1.58782110e-01f, -8.29892308e-02f, 3.53741236e-02f, 4.29584160e-02f, 1.30919993e-01f,
  -5.81472404e-02f, 8.14473182e-02f, 1.98554434e-02f, 1.27116576e-01f, -1.48653850e-01f, -1.29530892e-01f, -1.40403770e-02f, 1.30239159e-01f, -9.49299559e-02f, 4.66559194e-02f,
  -1.96266733e-02f, 8.03660974e-02f, 2.86425315e-02f, 1.43528894e-01f, 4.97171953e-02f, -8.12992677e-02f, -4.18869071e-02f, -1.19769663e-01f, 2.73394957e-02f, -5.33564873e-02f,
  -2.84276213e-02f, -1.22431897e-01f, -1.06354624e-01f, -2.13054251e-02f, -1.66034717e-02f, 1.94432493e-02f, -2.72125434e-02f, 7.33343093e-03f, -7.69001693e-02f, 7.90282860e-02f,
  -8.78141001e-02f, 1.91226380e-03f, -3.26502277e-03f, -4.24640775e-02f, -2.50980072e-02f, -8.19796249e-02f, 9.32891220e-02f, -8.59564990e-02f, 4.27183174e-02f, -2.71743280e-03f,
  -2.96970853e-03f, 6.15975931e-02f, -1.15657356e-02f, 1.62216518e-02f, 1.25244178e-03f, -3.91080342e-02f, 9.59990770e-02f, 3.65249370e-03f, 7.24741966e-02f, -1.17982857e-01f,
  -1.66361500e-02f, -1.37404185e-02f, 7.62945265e-02f, 1.91341192e-02f, 2.77540684e-02f, -3.29739973e-02f, 5.36023732e-03f, 5.64524978e-02f, 4.30330820e-02f, -7.84948096e-03f,
  -4.74092811e-02f, -3.25869657e-02f, 8.04872531e-03f, 9.27453116e-02f, -2.48391274e-02f, -1.73892882e-02f, 9.88270342e-02f, -3.65879871e-02f, -1.78720262e-02f, -1.89987384e-02f,
  -2.86989706e-03f, -2.45459471e-02f, 7.36602321e-02f, -4.54813056e-02f, 2.67649954e-03f, -5.84950000e-02f, -2.20225081e-02f, -7.56139308e-02f, -1.49871847e-02f, -3.42717431e-02f,
  1.88601799e-02f, 7.54348487e-02f, 2.65576057e-02f, 1.61299795e-01f, 1.24789819e-01f, 7.84491375e-02f, -2.44634394e-02f, -5.23370244e-02f, 1.19743757e-02f, -5.88263944e-02f,
  1.09262928e-01f, -5.74200004e-02f, 6.11922145e-02f, -5.74344844e-02f, -1.37587458e-01f, -1.14031248e-02f, 1.39852971e-01f, -3.72879803e-02f, -5.42690381e-02f, 1.76474124e-01f,
  -3.49734984e-02f, -1.40015274e-01f, -1.26769438e-01f, 7.30700716e-02f, -8.44296589e-02f, 9.66700837e-02f, 1.21805765e-01f, -2.01533847e-02f, 7.39374384e-03f, 1.06844157e-01f,
  5.20147122e-02f, -2.68413424e-02f, 3.80835682e-02f, -2.15821378e-02f, 1.07642025e-01f, -3.27103548e-02f, 4.18009311e-02f, 7.80476406e-02f, 1.48238242e-01f, -1.35829328e-02f,
  -1.28305763e-01f, 1.33628715e-02f, 1.08435094e-01f, 2.57198550e-02f, 3.16006541e-02f, 5.27530201e-02f, -3.03281248e-02f, -7.77417421e-02f, -2.38312092e-02f, -1.79461576e-02f,
  6.97454391e-03f, 5.61096482e-02f, -1.22505493e-01f, 1.79180782e-02f, 4.96122800e-03f, 1.43133909e-01f, -1.18526317e-01f, 2.50321589e-02f, 1.33604137e-02f, 3.05518787e-02f,
  -4.35591824e-02f, 3.56023945e-02f, -1.83672979e-02f, 3.68518978e-02f, 6.99536055e-02f, 4.45062183e-02f, -2.51178239e-02f, -1.24929762e-02f, -5.54150045e-02f, 2.02502273e-02f,
  8.30069035e-02f, -4.55248989e-02f, 7.43311271e-02f, 1.71436146e-02f, 1.55575797e-02f, -4.80294563e-02f, 2.38145664e-02f, 4.92959097e-02f, -1.11988222e-03f, -4.51284871e-02f,
  3.13363709e-02f, 3.58977355e-02f, -2.25246930e-03f, -5.84854446e-02f, 3.78430970e-02f, -5.52061200e-02f, -3.50329168e-02f, 9.50466394e-02f, 1.31966928e-02f, 6.99607655e-02f,
  2.43933424e-02f, -3.06899603e-02f, -3.54468487e-02f, -3.43845524e-02f, 1.00090886e-02f, -5.47896698e-02f, -5.47681451e-02f, -5.80406711e-02f, 9.23442096e-02f, 8.06804225e-02f,
  -8.04600269e-02f, -8.77059922e-02f, -4.45344262e-02f, 1.54787069e-02f, 1.20155886e-01f, 6.38475418e-02f, -3.99400480e-02f, 9.10800397e-02f, -1.06067145e-02f, -3.08333728e-02f,
  3.34018394e-02f, 1.45592086e-03f, -3.18909213e-02f, -8.85999668e-03f, 6.71932995e-02f, 2.91371122e-02f, -2.93381810e-02f, 7.69122839e-02f, 3.78521308e-02f, -6.33458644e-02f,
  5.17274663e-02f, 2.21549440e-02f, -2.88701709e-02f, -5.92711708e-03f, 9.00310799e-02f, -6.97973967e-02f, 7.85286501e-02f, 1.89820621e-02f, -3.74319702e-02f, 3.10852714e-02f,
  -1.23894745e-02f, -6.02987818e-02f, -1.93205252e-01f, 3.85731459e-02f, 4.22716932e-03f, -1.03495963e-01f, -1.19691774e-01f, -4.14577499e-02f, 3.10964696e-02f, 3.66150625e-02f,
  1.19446337e-01f, -4.90911480e-04f, -4.73256670e-02f, 4.21655104e-02f, -9.23471749e-02f, 6.97439164e-02f, 2.10566148e-02f, -2.31069066e-02f, -4.42598611e-02f, -5.39163724e-02f,
  3.75482105e-02f, 8.63658171e-03f, -8.12974125e-02f, 1.82056334e-02f, -6.86893612e-02f, 1.07698508e-01f, -1.40703127e-01f, -1.61949787e-02f, 1.20884307e-01f, -8.13923404e-02f,
  -8.14840794e-02f, -1.53219581e-01f, 1.09050617e-01f, -8.88618082e-02f, 1.11595087e-01f, 1.79734871e-01f, -4.87550050e-02f, 8.25932715e-03f, -7.81485289e-02f, 1.74688950e-01f,
  -5.03546931e-02f, 1.35276346e-02f, -8.99008140e-02f, 5.62685542e-03f, 9.60056558e-02f, 9.15589407e-02f, -8.79449323e-02f, 5.26162833e-02f, -2.12163720e-02f, 2.32197102e-02f,
  -3.70302461e-02f, 3.86824049e-02f, -7.42582306e-02f, -3.09948921e-02f, 4.49159183e-02f, -1.14181556e-01f, -9.24600884e-02f, 5.08329011e-02f, -1.65214147e-02f, -9.52540785e-02f,
  -1.40923224e-02f, -4.37062979e-02f, 1.21648377e-02f, -1.54225351e-02f, 7.53029510e-02f, 3.37002575e-02f, 7.70968571e-02f, -7.13500604e-02f, -7.66872615e-02f, -1.17133170e-01f,
  -1.04357086e-01f, -7.18321651e-02f, -1.01338141e-01f, -1.35581256e-04f, 8.85973405e-03f, -9.63441432e-02f, -4.17324230e-02f, 6.77559748e-02f, 4.00327072e-02f, -2.46734042e-02f,
  -6.56536892e-02f, -1.35786431e-02f, -3.61111164e-02f, -5.03888205e-02f, -2.22329479e-02f, 1.14308886e-01f, 6.30126894e-02f, -4.03199494e-02f, -1.79745257e-02f, -5.48421405e-02f,
  4.41920683e-02f, -8.53242278e-02f, -6.92364275e-02f, 7.46597126e-02f, -8.44912231e-03f, -3.84696871e-02f, -2.79848538e-02f, 5.56541942e-02f, -7.25852475e-02f, 4.54536965e-03f,
  -9.38775018e-02f, -1.41774658e-02f, -1.58756936e-03f, 1.93663575e-02f, -5.29838093e-02f, 5.29718474e-02f, 2.21060589e-02f, -2.67484672e-02f, 8.34151134e-02f, 3.44433524e-02f,
  -9.58003923e-02f, 1.58402734e-02f, 5.59532270e-02f, -5.82744628e-02f, 7.01994076e-02f, -6.52546156e-03f, -7.78211430e-02f, 1.84833165e-02f, 1.11583313e-02f, -1.32607948e-02f,
  -8.31337124e-02f, -2.44665015e-02f, -5.34957089e-03f, 4.87173200e-02f, -2.20214315e-02f, -1.00965336e-01f, -7.69887343e-02f, -1.64806768e-02f, 3.41606624e-02f, 1.25180081e-01f,
  1.24022715e-01f, 1.35134254e-02f, 1.10533005e-02f, 6.61785528e-02f, 1.73603315e-02f, -5.46001866e-02f, 8.74210820e-02f, -2.08503064e-02f, -6.68603033e-02f, -1.21851154e-02f,
  -1.34463713e-01f, 4.78213420e-03f, 1.09670237e-01f, -3.70999239e-02f, 4.18934785e-03f, -2.03402564e-02f, -4.58643548e-02f, -8.51205289e-02f, 4.02700156e-02f, -1.08832922e-02f,
  -2.51567308e-02f, 1.59281436e-02f, 9.18025821e-02f, -1.84636459e-01f, 7.25691766e-02f, 1.23141520e-01f, 2.26804502e-02f, 5.44526987e-02f, 8.76987204e-02f, -9.31938738e-02f,
  4.92952913e-02f, -1.05561510e-01f, 1.03377756e-02f, 8.25302601e-02f, 1.12143517e-01f, 7.43763149e-02f, 7.76676170e-04f, 4.08552848e-02f, -4.80214059e-02f, 1.05243638e-01f,
  7.78658167e-02f, 5.95613569e-02f, 1.47996500e-01f, 2.32216809e-02f, -6.73821196e-02f, -1.51861668e-01f, -8.55337083e-02f, -7.01701194e-02f, -6.39505163e-02f, -1.79889072e-02f,
  3.88183072e-02f, 1.60973161e-01f, -1.33915126e-01f, 5.45762330e-02f, 8.85947272e-02f, 4.14832495e-02f, 1.15196466e-01f, 1.34575039e-01f, -1.18515585e-02f, -5.31263091e-02f,
  8.01068917e-02f, -7.05830380e-02f, 1.37243038e-02f, -3.07909139e-02f, -5.96226342e-02f, -3.71123515e-02f, 1.00922473e-01f, 4.21213061e-02f, 4.66402955e-02f, 8.22009817e-02f,
  7.50022829e-02f, -8.45309906e-03f, -4.71417159e-02f, 8.32316577e-02f, 7.26419985e-02f, -3.28291766e-02f, 5.57544157e-02f, -8.83372799e-02f, -4.00830023e-02f, -4.68376800e-02f,
  3.75082530e-02f, 1.86042693e-02f, 1.55631900e-02f, 9.89335477e-02f, 3.11228856e-02f, -3.26910540e-02f, -2.36749277e-02f, -4.52415645e-03f, -1.21073373e-01f, -6.31671473e-02f,
  1.65658593e-01f, 2.99207512e-02f, -4.72305976e-02f, 3.63026857e-02f, -7.96007067e-02f, -5.55673093e-02f, 3.44135426e-02f, 5.89474887e-02f, -1.10787071e-01f, 1.36604905e-01f,
  -4.28132154e-02f, 2.30950285e-02f, -8.34857821e-02f, -5.28307520e-02f, -5.49706556e-02f, 5.99572025e-02f, 3.79561782e-02f, -4.24784347e-02f, -8.08554962e-02f, -3.83115262e-02f,
  -4.57921177e-02f, -6.54985085e-02f, -1.87041145e-02f, 7.91271031e-02f, 2.29085330e-02f, -3.57181504e-02f, -4.14459519e-02f, -6.39734417e-02f, -1.13224432e-01f, -4.05867882e-02f,
  -4.76559810e-02f, 8.08690786e-02f, 4.17830870e-02f, -6.73028156e-02f, -3.93191166e-02f, 2.88427453e-02f, 5.40693961e-02f, 3.25288251e-02f, 2.15977281e-01f, 1.20179884e-01f,
  2.21090868e-01f, 1.07099367e-02f, 8.33446681e-02f, -3.32456082e-02f, 9.12887752e-02f, -5.84416464e-02f, 4.20123152e-02f, -2.82747801e-02f, 6.98044971e-02f, -5.57759330e-02f,
  8.80213305e-02f, -1.90334499e-01f, -1.22645766e-01f, -1.17673923e-03f, -1.77828029e-01f, -4.66546603e-02f, -7.20718922e-03f, 1.19925305e-01f, -4.92325574e-02f, -6.40404448e-02f,
  3.25365253e-02f, 1.46251125e-02f, 1.77545026e-01f, -1.85912941e-02f, -1.00040898e-01f, 9.24286842e-02f, 9.25892740e-02f, -1.31706119e-01f, -4.65947352e-02f, 2.42017079e-02f,
  -1.84316542e-02f, -7.38587081e-02f, -3.23145427e-02f, 9.93195176e-02f, 1.09188082e-02f, -9.62089673e-02f, -2.11221457e-01f, 1.74696103e-01f, 6.14522723e-03f, -7.94571191e-02f,
  1.00761957e-01f, 5.93970492e-02f, 1.08041301e-01f, 2.94733588e-02f, -3.17000113e-02f, 1.96211860e-02f, 1.68200824e-02f, 5.72145507e-02f, -6.26180470e-02f, 9.41020809e-03f,
  -2.76479982e-02f, 1.07494801e-01f, -1.22887164e-01f, 5.72425760e-02f, -8.96924734e-02f, 1.52551323e-01f, -6.98945224e-02f, -8.26035887e-02f, 1.08025201e-01f, -9.98240784e-02f,
  6.13933466e-02f, 7.02182278e-02f, -6.55286685e-02f, -9.02532414e-02f, -1.89724639e-02f, 7.40474537e-02f, -4.85859849e-02f, -3.30911689e-02f, -3.68954241e-02f, 1.36154739e-03f,
  5.53232953e-02f, -1.59920510e-02f, 8.24828260e-03f, 1.02778643e-01f, 2.38928501e-03f, -1.27395391e-01f, -3.07053067e-02f, -1.04073644e-01f, -4.35250252e-02f, 2.46865954e-02f,
  -1.18969604e-01f, -3.53554206e-04f, 4.82745022e-02f, -5.54999597e-02f, -5.08187748e-02f, -3.67073081e-02f, -9.50286239e-02f, 2.68363468e-02f, 5.70002161e-02f, -3.35143763e-03f,
  3.34516242e-02f, 4.61080298e-02f, 7.81558901e-02f, 3.47600318e-02f, -2.73303818e-02f, 1.15690585e-02f, -2.13333461e-02f, 5.25357481e-03f, -6.29977658e-02f, 2.69192755e-02f,
  3.97170819e-02f, -1.71015542e-02f, 7.60003105e-02f, 1.17224522e-01f, 1.53379329e-02f, -1.54894674e-02f, -6.22951761e-02f, -2.32794601e-02f, 8.14152062e-02f, -7.87755623e-02f,
  3.87408845e-02f, 5.58384843e-02f, -9.53928605e-02f, 2.48053465e-02f, 5.27892448e-02f, 4.43674698e-02f, -5.74101619e-02f, 1.76729802e-02f, 5.76802455e-02f, 2.31858827e-02f,
  1.65278073e-02f, 1.49934944e-02f, -9.94851366e-02f, -2.47722659e-02f, -9.92747098e-02f, 1.75266340e-02f, -6.76547587e-02f, 1.37215538e-03f, 2.15875849e-01f, -4.51161973e-02f,
  -1.39713474e-02f, -8.01296458e-02f, -4.88453694e-02f, 2.01173678e-01f, -4.39435951e-02f, 1.30247295e-01f, 1.42266378e-01f, 3.12694050e-02f, 5.62349185e-02f, -7.06317350e-02f,
  9.75342095e-02f, -1.69296324e-01f, -1.68221649e-02f, -5.31765539e-03f, 3.22186351e-02f, 1.06353693e-01f, 6.25352049e-03f, -1.04094423e-01f, -6.74564540e-02f, 1.09583154e-01f,
  -1.05808184e-01f, -1.42951667e-01f, -2.95246281e-02f, 6.29061088e-02f, -5.97068407e-02f, -7.45262131e-02f, -2.12100416e-01f, 2.40005385e-02f, -1.84481796e-02f, -4.55647968e-02f,
  -9.41015594e-03f, 1.05742082e-01f, 1.02044746e-01f, -1.03593461e-01f, -2.05587819e-01f, 1.28805665e-02f, 2.85757147e-02f, -1.64919689e-01f, -1.64393783e-02f, 6.40245602e-02f,
  3.36183496e-02f, 3.29390317e-02f, 1.10545173e-01f, -3.61484587e-02f, 5.00684567e-02f, -1.49275362e-01f, 2.10034363e-02f, -7.12160543e-02f, 7.74195269e-02f, -1.37778327e-01f,
  -9.61043239e-02f, 1.15417555e-01f, -3.86146754e-02f, 1.69090368e-02f, 1.49665475e-02f, -7.21528288e-03f, -1.79339834e-02f, -1.06740199e-01f, -5.90131506e-02f, 7.42333680e-02f,
  -1.24381986e-02f, -6.53257295e-02f, -5.51495887e-02f, 3.49981561e-02f, -1.33650318e-01f, 2.31763907e-02f, -2.45222002e-02f, 4.56554815e-02f, -7.68402591e-02f, 4.53836583e-02f,
  -8.39153379e-02f, 1.10049397e-02f, 4.83893640e-02f, -6.93770796e-02f, -8.21354687e-02f, -1.55973747e-01f, -1.78404618e-02f, -6.93008751e-02f, 2.53325645e-02f, -6.66808113e-02f,
  -1.06806941e-01f, -1.21413216e-01f, -5.92343800e-04f, 4.63595726e-02f, -3.55229387e-03f, 5.55204041e-02f, 2.29583308e-02f, -3.04937735e-02f, -6.01650365e-02f, -1.00692064e-02f,
  -1.79306660e-02f, 5.96187040e-02f, -6.82403296e-02f, -5.50220720e-02f, -2.02819193e-03f, 9.68910456e-02f, -5.82055897e-02f, 1.11535555e-02f, -1.23795524e-01f, -6.69087842e-02f,
  2.41576862e-02f, -2.44514979e-02f, 7.18569802e-03f, -6.93071028e-03f, 5.75396605e-03f, -8.77019837e-02f, 4.69857715e-02f, -9.98829454e-02f, 3.34172249e-02f, -5.88688329e-02f,
  -1.04371816e-01f, 2.86138486e-02f, -7.71927238e-02f, 8.98035336e-03f, 2.66273171e-02f, -2.63402332e-03f, -1.01527333e-01f, -2.13110354e-03f, 5.35306968e-02f, 2.68384535e-03f,
  -2.80781109e-02f, 2.21303217e-02f, -1.13917373e-01f, -8.04196447e-02f, -1.30595982e-01f, 9.16457549e-02f, 3.09502855e-02f, -5.86921349e-02f, 6.53692707e-02f, -2.48718783e-02f,
  -4.65503037e-02f, 5.43598272e-02f, 1.32695377e-01f, 1.28968507e-01f, 1.50509402e-01f, -1.33461654e-01f, -7.81073570e-02f, -1.53059185e-01f, -1.70043290e-01f, -6.09521531e-02f,
  4.94445004e-02f, 5.04624806e-02f, 4.26790789e-02f, 1.12228863e-01f, -4.88038212e-02f, -7.25000491e-03f, 5.52008040e-02f, 1.54709727e-01f, -3.74208838e-02f, -1.36370286e-01f,
  -4.36979271e-02f, -1.23159215e-01f, 3.08765452e-02f, -6.13989905e-02f, -6.04334176e-02f, 7.23151341e-02f, -4.46394309e-02f, 1.20129749e-01f, -1.06114730e-01f, -4.20017615e-02f,
  1.46992743e-01f, -3.36662717e-02f, -1.85859963e-01f, 2.39017345e-02f, -1.73785593e-02f, -6.83960691e-02f, 4.59980965e-02f, 8.47890601e-02f, 1.10981688e-01f, -8.83721039e-02f,
  -3.03975330e-03f, -4.19814028e-02f, 2.18363088e-02f, 6.90459162e-02f, -6.48833662e-02f, 6.76324517e-02f, 6.22898377e-02f, -3.95300575e-02f, -1.20441459e-01f, 5.82361482e-02f,
  -4.11489643e-02f, 6.39052913e-02f, 7.84308091e-03f, 2.09171046e-03f, 1.76700596e-02f, -4.69686501e-02f, 4.34250850e-03f, 1.27600938e-01f, 1.13181926e-01f, -3.82261947e-02f,
  -1.31285209e-02f, 7.38723278e-02f, 8.30027238e-02f, 7.55059943e-02f, -7.93801695e-02f, 6.57077730e-02f, 5.28880768e-02f, 3.75268469e-03f, -2.36690231e-03f, -9.09062475e-02f,
  1.31449010e-02f, 4.07212339e-02f, -9.91497114e-02f, 3.85164544e-02f, -1.06365278e-01f, -9.45596024e-02f, -5.26254289e-02f, -1.67157874e-02f, -9.89280045e-02f, 2.09877919e-02f,
  -9.39247459e-02f, 1.22891314e-01f, 4.21265811e-02f, 3.75574864e-02f, 2.80268658e-02f, 6.68444484e-02f, -4.02709618e-02f, 8.58599469e-02f, -6.11153096e-02f, -1.18836790e-01f,
  -1.66200381e-02f, -8.54364783e-02f, -8.91917944e-03f, -7.58216381e-02f, 8.29485208e-02f, -4.43385690e-02f, -6.74828067e-02f, 6.20720268e-04f, -6.31288365e-02f, -4.94837351e-02f,
  -1.18996482e-02f, -3.78335640e-02f, -4.15075161e-02f, -2.27281395e-02f, -6.90377057e-02f, -4.53923158e-02f, 3.05803493e-02f, -9.28202420e-02f, -4.72076721e-02f, 7.09374761e-03f,
  -1.40802357e-02f, 2.53219586e-02f, 9.95083302e-02f, -7.05220401e-02f, 1.31234929e-01f, -9.94514450e-02f, -7.87298828e-02f, 4.07411344e-02f, -7.27564171e-02f, 2.51458511e-02f,
  -4.05718433e-03f, -7.53975660e-02f, 7.00562596e-02f, -3.57248150e-02f, 4.61211894e-03f, 6.98449165e-02f, 9.44778398e-02f, 1.31383747e-01f, -6.08322993e-02f, -8.34524110e-02f,
  -1.44365756e-02f, -8.58440772e-02f, -2.84738392e-02f, 4.44740839e-02f, -1.11059114e-01f, 6.70480058e-02f, -6.09943494e-02f, 7.35230371e-02f, -7.51352683e-02f, 6.25172332e-02f,
  -6.87851235e-02f, -7.10839704e-02f, 8.05860758e-02f, 8.50769132e-02f, -8.30107704e-02f, -2.22146977e-02f, 1.14253066e-01f, -9.91292596e-02f, -6.32331222e-02f, -1.42950537e-02f,
  -1.00860395e-01f, 1.01031318e-01f, 1.11625902e-01f, -4.74504679e-02f, -7.41418302e-02f, -6.40070587e-02f, -7.73366839e-02f, -4.99775968e-02f, -5.47218658e-02f, 4.49873880e-02f,
  4.92542125e-02f, -9.23989341e-03f, 5.06462008e-02f, 1.03974082e-01f, -7.53221959e-02f, -1.17142394e-01f, -9.25670639e-02f, 1.01446360e-01f, -4.80240136e-02f, -8.48141164e-02f,
  8.13408270e-02f, -1.31659256e-03f, -6.34282967e-03f, -6.71220869e-02f, -4.13483009e-02f, -1.01376675e-01f, -6.23324066e-02f, -3.49959098e-02f, 3.89284417e-02f, -1.40160039e-01f,
  6.25308752e-02f, 9.93217975e-02f, -4.83875126e-02f, -2.71014459e-02f, 6.93075433e-02f, 3.72955948e-02f, 1.55465901e-02f, 5.77668287e-03f, -1.14481285e-01f, 3.92912365e-02f,
  8.51312205e-02f, -7.11702406e-02f, -3.66095714e-02f, -4.13544960e-02f, 4.86986525e-02f, -7.37694055e-02f, -5.40211685e-02f, 2.20991559e-02f, -9.29200724e-02f, 4.55283597e-02f,
  2.34378297e-02f, 1.07925549e-01f, 3.45427506e-02f, 2.28697304e-02f, 6.13643937e-02f, -1.14349529e-01f, -6.01408444e-03f, 3.73133756e-02f, 4.22808826e-02f, -4.22957316e-02f,
  7.22538903e-02f, -3.63201424e-02f, 2.83214394e-02f, -1.98742431e-02f, 6.19473029e-03f, -4.96576587e-03f, 4.65459703e-03f, -3.95164378e-02f, -6.18186966e-02f, -7.54023716e-02f,
  -5.99286705e-02f, 1.40194474e-02f, -5.92011847e-02f, -8.58701183e-04f, 1.30734608e-01f, 1.33788597e-03f, 1.04130916e-01f, 1.64041501e-02f, -3.75803150e-02f, 3.96168903e-02f,
  -4.51793568e-03f, -6.96597472e-02f, -7.56233037e-02f, -6.47004992e-02f, 2.30931342e-02f, 1.66643038e-02f, 7.20577762e-02f, 2.23332997e-02f, 8.35361630e-02f, 1.76244248e-02f,
  -4.49296795e-02f, -5.46881594e-02f, -3.17243859e-03f, 6.66979887e-03f, -8.28908831e-02f, -7.56706446e-02f, 2.91322172e-02f, 7.78753981e-02f, 7.08443001e-02f, -7.28704557e-02f,
  1.72742665e-01f, -6.84865341e-02f, -1.71803445e-01f, 2.62828302e-02f, -5.76532930e-02f, 5.27964998e-03f, -7.31323063e-02f, -3.12128197e-02f, -7.69835338e-02f, -4.03101258e-02f,
  -9.43525434e-02f, 3.33372988e-02f, -1.44864386e-02f, 6.78209066e-02f, 9.76675376e-02f, 9.17682573e-02f, 3.58403102e-02f, 4.87013943e-02f, 4.02110592e-02f, -1.17210783e-01f,
  1.08577475e-01f, -1.44362420e-01f, 3.45299132e-02f, -5.06064408e-02f, 6.33736029e-02f, 1.81265831e-01f, -8.19352493e-02f, 1.14193864e-01f, 1.77096389e-02f, 1.10283732e-01f,
  1.44791920e-02f, -1.62898295e-03f, -7.21807852e-02f, -1.48435906e-01f, -6.30808175e-02f, 5.17081730e-02f, -1.24532871e-01f, 6.15076069e-03f, 2.14378774e-01f, -8.46576691e-02f,
  2.65417788e-02f, 1.39289737e-01f, -1.38020515e-01f, -1.75865337e-01f, -2.93573327e-02f, 2.18751077e-02f, -5.15008271e-02f, 1.58738613e-03f, -6.21521026e-02f, -5.03291525e-02f,
  5.59307933e-02f, -6.54649287e-02f, 4.06926610e-02f, 9.95315462e-02f, 1.32048473e-01f, -1.32234931e-01f, 3.67415212e-02f, -9.65154544e-02f, 3.94033939e-02f, -7.01935142e-02f,
  -4.93721329e-02f, 4.30076160e-02f, 5.46624772e-02f, -1.49901003e-01f, -1.56567231e-01f, -1.23020485e-02f, 1.62922606e-01f, -3.29546854e-02f, 7.77491853e-02f, -4.81090546e-02f,
  5.41470572e-02f, 2.41969861e-02f, 8.21158811e-02f, 8.08701366e-02f, -3.46995369e-02f, 2.24269275e-02f, -1.17697790e-02f, 5.91200963e-02f, -8.39850828e-02f, 6.44711629e-02f,
  3.16654332e-02f, 2.69189551e-02f, 9.92344469e-02f, 4.11352068e-02f, 2.44038887e-02f, 8.21100324e-02f, 4.07113880e-02f, 5.73101714e-02f, -3.33965458e-02f, 1.29852807e-02f,
  -6.11133128e-03f, -2.45346501e-02f, 3.74248587e-02f, -3.11394036e-02f, -2.14314088e-02f, 1.89686641e-02f, 5.37256077e-02f, -1.71164460e-02f, 1.17213398e-01f, -2.97351107e-02f,
  1.04757726e-01f, 1.23692371e-01f, -9.01600230e-04f, 7.40936324e-02f, 8.74509141e-02f, -9.22162458e-02f, 4.78643849e-02f, -2.81550549e-02f, 1.08561657e-01f, -3.66852432e-02f,
  2.53371112e-02f, 8.95185396e-03f, 7.40160793e-02f, -3.43848169e-02f, -3.80780478e-03f, -2.04252433e-02f, -5.77619299e-02f, 4.05439772e-02f, 2.80047045e-03f, -3.06194625e-03f,
  -2.54970100e-02f, -5.47222123e-02f, -4.82535511e-02f, 7.75602907e-02f, 1.12344064e-01f, 8.76528546e-02f, 3.30261998e-02f, 7.69973397e-02f, -1.04864247e-01f, -3.06721460e-02f,
  -1.88679487e-01f, 5.65651879e-02f, 4.43485100e-03f, -4.38785218e-02f, -1.87932011e-02f, -1.06736362e-01f, 2.85057947e-02f, -7.68439919e-02f, -1.65904745e-01f, 1.05920538e-01f,
  2.04803459e-02f, 1.09426089e-01f, 7.60742277e-02f, 3.51861864e-02f, -1.61370382e-01f, 1.02302574e-01f, -1.36116654e-01f, -7.26067871e-02f, -9.33696255e-02f, 5.42411730e-02f,
  -1.34656087e-01f, 5.07161999e-03f, -1.35347649e-01f, 2.10956261e-01f, 1.87934279e-01f, -6.61920235e-02f, 4.43032011e-02f, 7.87933916e-03f, -5.05933464e-02f, -2.91700326e-02f,
  1.32902518e-01f, -9.60851237e-02f, 1.47181436e-01f, 5.40494509e-02f, -7.25394562e-02f, 2.02358156e-01f, 1.66706204e-01f, 1.27722919e-01f, -1.08520404e-01f, 4.22237962e-02f,
  2.19406970e-02f, -3.73849869e-02f, -1.08729549e-01f, 1.30994335e-01f, 3.92510481e-02f, 2.00496465e-01f, -1.56730086e-01f, 7.68853351e-02f, -1.79231875e-02f, -4.10421155e-02f,
  -5.89946732e-02f, 1.08061053e-01f, -2.39949729e-02f, -3.70603465e-02f, 1.28361627e-01f, 1.74283963e-02f, 4.96207625e-02f, -3.53009440e-02f, -2.02086605e-02f, -7.16496632e-02f,
  4.23497371e-02f, -3.06199342e-02f, -8.15574676e-02f, 1.03952222e-01f, -1.63463317e-02f, -5.79206906e-02f, -7.23741874e-02f, -3.42774801e-02f, 4.19630259e-02f, 9.51193571e-02f,
  2.91435346e-02f, -4.05666381e-02f, -8.67884606e-02f, 9.70056653e-02f, -3.88731435e-02f, 1.28390267e-02f, -1.06980866e-02f, 5.26087219e-03f, -5.66912666e-02f, 1.51811307e-03f,
  -1.27433851e-01f, 7.19464198e-02f, 2.53454093e-02f, -7.53736570e-02f, 3.88473347e-02f, -2.80099083e-02f, -9.22238082e-02f, 8.56208131e-02f, -3.73023078e-02f, 1.89124364e-02f,
  8.48743785e-03f, 1.05354572e-02f, -6.69211000e-02f, 3.33252475e-02f, 6.67827502e-02f, 6.76555634e-02f, 3.50586809e-02f, 1.48212714e-02f, -8.18344876e-02f, 8.25819746e-02f,
  -9.47094858e-02f, -5.65390289e-02f, -4.13120352e-02f, 7.14377016e-02f, -3.38777676e-02f, -6.87622055e-02f, 3.72550301e-02f, -5.02843857e-02f, -2.44126059e-02f, -8.34679231e-02f,
  -5.52179925e-02f, -4.57229987e-02f, -4.93844738e-03f, -7.29432479e-02f, -5.75630888e-02f, -4.74364422e-02f, -6.66293129e-03f, 3.37881744e-02f, -2.70383134e-02f, -2.73078424e-03f,
  7.13584051e-02f, -6.40279874e-02f, -1.23221181e-01f, -1.04555577e-01f, -7.06002023e-03f, 1.04623146e-01f, 1.17114410e-01f, -2.09269859e-02f, 1.00268476e-01f, 7.63745829e-02f,
  1.08603634e-01f, 1.69012666e-01f, 7.91835412e-02f, -8.35867450e-02f, 5.94096109e-02f, -5.57105280e-02f, 1.09119691e-01f, -8.05270821e-02f, 2.05273759e-02f, -8.27115104e-02f,
  -8.05043802e-02f, -1.22517655e-02f, -6.23335037e-03f, -1.16355620e-01f, 1.14572577e-01f, 1.16401732e-01f, -6.40636086e-02f, -9.72705111e-02f, 1.70084342e-01f, -9.12014693e-02f,
  1.81912035e-01f, -7.70903230e-02f, -7.64352158e-02f, 5.25411293e-02f, 5.95632475e-03f, -4.83784825e-02f, 8.98997188e-02f, 1.19684413e-02f, -5.69663532e-02f, 9.21560004e-02f,
  -8.05126280e-02f, -1.14198975e-01f, 1.50102498e-02f, -1.23600267e-01f, -3.88034433e-02f, -6.32894505e-03f, 1.09858654e-01f, -2.05069352e-02f, 6.37760088e-02f, -1.16761088e-01f,
  8.85335263e-03f, -1.40715182e-01f, 9.22490656e-03f, -1.43779099e-01f, -4.04851623e-02f, -8.91875755e-03f, 2.11914741e-02f, 4.48598824e-02f, 3.85115668e-02f, 3.42788510e-02f,
  9.46359709e-02f, 2.57036407e-02f, -8.31089169e-02f, 2.33642329e-02f, 6.36748448e-02f, 3.04567236e-02f, 2.78771874e-02f, 8.60854089e-02f, -2.82213930e-02f, 6.72800690e-02f,
  -9.60605815e-02f, -6.37752414e-02f, 6.66639954e-02f, -6.55173808e-02f, -3.38530876e-02f, 7.49673769e-02f, -4.41512577e-02f, 5.15269749e-02f, 4.67755832e-02f, 4.61239964e-02f,
  9.26184654e-02f, 3.27525288e-02f, -9.67554282e-03f, -1.02012463e-01f, 5.02116419e-02f, 2.07338855e-02f, -4.78416197e-02f, -1.97322350e-02f, -7.65120387e-02f, 6.47005960e-02f,
  -8.56985450e-02f, 2.54978575e-02f, -1.50130969e-02f, -2.41693854e-02f, -5.17577119e-02f, 4.21080627e-02f, 1.35017768e-01f, -2.55389586e-02f, -2.54830830e-02f, -1.03761524e-01f,
  8.26292410e-02f, 4.63315621e-02f, -2.18335222e-02f, 4.09182645e-02f, -8.55448842e-02f, 7.84239992e-02f, -9.43554658e-03f, -9.54997540e-02f, 3.30227539e-02f, -8.24139565e-02f,
  -4.34937067e-02f, -5.23757364e-04f, -5.16643636e-02f, -3.57265049e-03f, -8.62097666e-02f, 2.44775228e-02f, 2.06708312e-02f, -1.18002415e-01f, 5.68757504e-02f, 2.43995693e-02f,
  -5.93331233e-02f, -2.66968086e-02f, 3.12775597e-02f, 1.15699675e-02f, -6.81537762e-02f, -3.58344764e-02f, 4.80460711e-02f, -2.65615787e-02f, 7.34701753e-02f, -1.01340627e-02f,
  -1.12476498e-01f, -3.15910541e-02f, -4.61056940e-02f, 7.62328645e-03f, 2.12026447e-01f, 3.59656811e-02f, -3.40413139e-03f, -1.50549989e-02f, -5.55115677e-02f, -1.49080649e-01f,
  -3.22775468e-02f, -4.03235368e-02f, -1.07279286e-01f, 5.23509271e-02f, -2.29646582e-02f, -1.22085214e-01f, 9.52792987e-02f, -1.46966219e-01f, 6.80243783e-03f, 5.22359535e-02f,
  -1.15607120e-01f, 1.03458362e-02f, 5.75986430e-02f, -6.02987297e-02f, -4.92790602e-02f, -1.61059499e-01f, 2.55143270e-02f, -2.78175678e-02f, 7.95367807e-02f, -3.82657312e-02f,
  4.56488766e-02f, 1.69813018e-02f, -3.31528112e-02f, -7.57870600e-02f, -4.64252941e-02f, -8.85084048e-02f, 6.17085062e-02f, -5.46168536e-02f, 1.03725493e-01f, 4.72654589e-02f,
  -9.91360564e-03f, -1.16313435e-01f, -5.01869991e-02f, 1.51674166e-01f, -4.22197729e-02f, 4.52863015e-02f, 8.09769109e-02f, -1.13306800e-02f, 6.75009862e-02f, 3.38981561e-02f,
  1.29407691e-03f, -1.89371966e-02f, -5.37138544e-02f, -1.02628291e-01f, 1.11867733e-01f, 8.98452401e-02f, -3.79158445e-02f, -2.14811917e-02f, 2.14451132e-03f, -8.91536921e-02f,
  -4.88298573e-02f, 1.27514079e-02f, -1.77774522e-02f, -1.17875092e-01f, 2.19611451e-02f, -2.06292998e-02f, 1.22260358e-02f, -8.77524167e-03f, 3.46029773e-02f, -8.83798487e-03f,
  8.83283019e-02f, 8.57989267e-02f, 7.01667517e-02f, 1.01921558e-02f, -9.54037085e-02f, -4.29437160e-02f, 6.64922148e-02f, -2.33098809e-02f, -7.23533481e-02f, -7.64248818e-02f,
  7.32538104e-02f, -5.11563895e-03f, 2.57983035e-03f, 4.77491738e-03f, -5.83531968e-02f, -3.68779302e-02f, -1.19172759e-01f, -4.53507900e-02f, 9.65615064e-02f, 8.92392024e-02f,
  1.16045796e-03f, 6.03332557e-02f, 5.27044609e-02f, 8.61083716e-02f, -4.35788818e-02f, 3.83660980e-02f, 2.54528765e-02f, 5.74971773e-02f, 2.01446097e-02f, -2.68166722e-03f,
  -1.75049938e-02f, 9.93856788e-02f, -2.71329544e-02f, 1.01180099e-01f, 6.96559474e-02f, -1.17412090e-01f, -5.98816350e-02f, 6.81771617e-03f, 9.26838592e-02f, 1.16211548e-01f,
  -3.38838343e-03f, 3.87209207e-02f, 6.29751608e-02f, 8.99830461e-02f, 4.78132106e-02f, 1.68194976e-02f, -5.74134365e-02f, 8.40396211e-02f, 1.13224760e-02f, 9.41608176e-02f,
  9.33203772e-02f, -9.05288085e-02f, 5.66484332e-02f, 9.44685563e-02f, 6.05818741e-02f, 8.38392004e-02f, 9.26851034e-02f, 1.71592925e-02f, -8.11569840e-02f, 1.27674313e-02f,
  -2.68534338e-03f, -5.09261005e-02f, 1.02408513e-01f, -2.41089873e-02f, 1.33994713e-01f, 7.53535181e-02f, 3.17239165e-02f, -2.29000300e-02f, 1.38591174e-02f, 4.63194065e-02f,
  1.22597879e-02f, 5.84155470e-02f, 1.29021883e-01f, -6.35341927e-02f, -2.44061579e-03f, -7.56470039e-02f, -4.22681347e-02f, -7.21571073e-02f, 1.84506014e-01f, -2.58871950e-02f,
  4.45979834e-02f, -8.61396864e-02f, 7.52185285e-02f, -2.71744113e-02f, 1.74587145e-01f, -1.94741488e-02f, -3.17946039e-02f, -5.33953086e-02f, -1.55637473e-01f, -1.06005773e-01f,
  -2.83302348e-02f, -2.27607377e-02f, 1.01593360e-01f, -7.39908889e-02f, -2.23255619e-01f, 1.15706325e-02f, -7.20479041e-02f, -1.28221020e-01f, 8.09603930e-02f, -2.46611878e-01f,
  -4.26993221e-02f, -1.80605263e-01f, 1.43031940e-01f, 2.82178726e-03f, -6.03076629e-02f, -1.86061598e-02f, -7.10751861e-03f, 2.60659540e-03f, -2.96818186e-02f, -1.87223837e-01f,
  6.46515191e-02f, -6.97505027e-02f, 8.24020803e-02f, -3.98832001e-02f, 1.05992816e-01f, 2.60051768e-02f, 1.40126482e-01f, 5.28963516e-03f, -1.01161912e-01f, -2.67743394e-02f,
  2.07956508e-02f, -7.12999254e-02f, 8.80775303e-02f, -7.21265376e-02f, -8.24386552e-02f, -1.54276535e-01f, -4.50931750e-02f, -3.93769369e-02f, 1.36447415e-01f, 1.08766474e-01f,
  2.46945862e-02f, -2.60029119e-02f, 2.43717842e-02f, -1.17769159e-01f, 4.45513017e-02f, -9.46218371e-02f, 4.61162627e-02f, -1.05645195e-01f, -6.60426766e-02f, -7.97857791e-02f,
  6.56579956e-02f, -7.07203522e-02f, -2.92143337e-02f, 8.98412019e-02f, 1.42388660e-02f, 2.61866413e-02f, 8.88836086e-02f, 4.69448008e-02f, 1.04348762e-02f, 4.25979048e-02f,
  -1.00311399e-01f, -8.92330855e-02f, -1.49359116e-02f, 3.79871763e-02f, 9.10267327e-03f, 6.28317446e-02f, 2.18488649e-02f, -7.20603764e-02f, 5.02781011e-02f, -1.07158475e-01f,
  -4.34255786e-02f, 6.95475489e-02f, 8.16647634e-02f, -3.65821607e-02f, 1.11822248e-01f, -1.51839675e-02f, 1.88094545e-02f, 6.22839965e-02f, 7.07375929e-02f, -1.32786098e-03f,
  1.12932995e-01f, -8.63531828e-02f, -4.16953787e-02f, -4.80205677e-02f, -7.44976029e-02f, 9.33752209e-03f, -9.43790823e-02f, 7.24601448e-02f, 2.30835080e-02f, -5.47326133e-02f,
  9.44667533e-02f, 8.39219647e-05f, -4.35963050e-02f, 1.64352090e-03f, -5.53649552e-02f, 1.55164739e-02f, -4.47625145e-02f, -2.12357920e-02f, 5.61841503e-02f, -2.12505814e-02f,
  -1.02394121e-02f, -1.13984689e-01f, 1.50252163e-01f, -1.49415195e-01f, -6.52360246e-02f, 9.90114510e-02f, -1.39577221e-02f, -1.93761121e-02f, -2.87886057e-03f, -7.08147287e-02f,
  5.50655760e-02f, -4.94924225e-02f, -1.11207031e-01f, 1.04125552e-01f, -1.67493932e-02f, -1.31581560e-01f, 1.22540288e-01f, 1.38468236e-01f, 5.18043265e-02f, -7.65582472e-02f,
  8.88437033e-02f, 7.49732479e-02f, -1.16750076e-01f, 6.04033880e-02f, -8.68193284e-02f, -1.81243032e-01f, -6.34361431e-02f, -1.47880530e-02f, -1.48871779e-01f, -1.28967866e-01f,
  -1.14077337e-01f, 7.93850124e-02f, 2.38807988e-03f, 3.92659083e-02f, -1.09499522e-01f, 3.95977683e-02f, 7.96282757e-03f, -1.58340409e-02f, -5.61437979e-02f, 1.80023946e-02f,
  -6.54868549e-03f, -3.35124247e-02f, -9.17584300e-02f, -3.21179926e-02f, 4.93317209e-02f, 2.33905558e-02f, 7.75836855e-02f, 5.24160713e-02f, 6.39730096e-02f, -6.25394434e-02f,
  5.41904457e-02f, -1.69848919e-01f, 7.26649165e-02f, -1.44872054e-01f, -1.04307443e-01f, -4.99224998e-02f, -2.12634504e-02f, -1.15257345e-01f, -2.30504572e-03f, 9.35807079e-02f,
  2.90063079e-02f, -3.64044942e-02f, -4.26014662e-02f, 4.81267534e-02f, 5.16968146e-02f, -4.24170420e-02f, -6.24605156e-02f, -4.65012789e-02f, -1.50649220e-01f, -1.71461944e-02f,
  -2.12410167e-02f, 1.75488815e-02f, 4.10798518e-03f, -6.72912076e-02f, 8.67010280e-02f, -4.39781807e-02f, -3.89762558e-02f, -3.50673497e-02f, -1.20462567e-01f, 1.65003501e-02f,
  3.31266411e-02f, 5.32379001e-02f, 4.14582789e-02f, 1.72162931e-02f, 3.11129801e-02f, 6.36415109e-02f, -8.73811319e-02f, 7.65642747e-02f, -7.85453096e-02f, -1.02493227e-01f,
  8.57876167e-02f, -1.43087248e-03f, -3.84959877e-02f, -3.19170207e-03f, -1.01935631e-02f, -3.88139188e-02f, -4.96401777e-03f, -6.33858591e-02f, 6.36374438e-03f, -1.40728075e-02f,
  4.18287003e-03f, -4.20089886e-02f, 4.99998182e-02f, 7.31713250e-02f, 1.54997734e-02f, -2.55734529e-02f, 6.33965135e-02f, -6.51896372e-02f, -1.06982805e-01f, 4.27992456e-02f,
  -7.86554590e-02f, -1.44566894e-01f, 1.51654026e-02f, 2.92044692e-03f, -5.52779697e-02f, 4.34466861e-02f, 6.37806505e-02f, 2.82891467e-02f, -4.18564230e-02f, 7.45159760e-02f,
  -1.97457206e-02f, -5.86474985e-02f, -2.91650575e-02f, 2.38612778e-02f, 9.15816873e-02f, 2.12649330e-02f, -2.66496819e-02f, 2.65347566e-02f, 3.35261901e-03f, 8.33507553e-02f,
  -1.49494976e-01f, 2.36697450e-01f, -6.18871525e-02f, -4.80263159e-02f, -1.35318577e-01f, -2.92033069e-02f, 1.15769461e-01f, -6.89355060e-02f, 5.35208210e-02f, -6.70101866e-02f,
  -4.41033486e-03f, -1.75217777e-01f, -1.04746455e-02f, 1.44948766e-01f, -1.10680841e-01f, 2.88398899e-02f, -2.94851996e-02f, -1.80976316e-01f, -6.45429492e-02f, -3.11170220e-02f,
  -9.65660065e-02f, 3.00130006e-02f, 1.80066347e-01f, 7.23610893e-02f, 1.65500436e-02f, -8.54835436e-02f, -1.00160584e-01f, 9.96343642e-02f, -1.38892889e-01f, 8.52036625e-02f,
  -5.75114600e-02f, -1.88203417e-02f, -1.40908867e-01f, 7.22927600e-02f, 1.18633494e-01f, -5.37588000e-02f, 2.38987580e-02f, 2.96078324e-02f, -3.73834446e-02f, 6.02008216e-02f,
  1.15659842e-02f, -6.84942454e-02f, 2.16982625e-02f, 1.33117229e-01f, -1.36543497e-01f, 5.05756959e-02f, -5.93784377e-02f, -9.02815238e-02f, -6.72221333e-02f, 7.52044097e-02f,
  -6.35631904e-02f, 1.06282085e-01f, 2.66715027e-02f, 5.68559300e-03f, 5.01610488e-02f, 2.39862911e-02f, 7.64849782e-02f, -7.83640370e-02f, -9.31425095e-02f, -8.15535430e-03f,
  -9.67610851e-02f, 6.81073070e-02f, -1.37375640e-02f, 2.05091722e-02f, 7.73287788e-02f, 5.24636991e-02f, 1.15326978e-01f, -3.52619402e-02f, 3.50739211e-02f, 7.91944042e-02f,
  4.26795305e-04f, -4.63865474e-02f, -2.02037543e-02f, 1.08888466e-03f, 3.39242592e-02f, -6.86308974e-03f, -2.35131569e-02f, -2.58981716e-02f, 1.50557840e-04f, -4.28225175e-02f,
  -1.36547443e-02f, 6.16821162e-02f, -8.91991928e-02f, 2.42070295e-02f, -6.98505193e-02f, 4.62994725e-02f, -9.02259722e-02f, -7.01449066e-02f, -5.28680384e-02f, 9.54582915e-02f,
  -1.10677555e-01f, 5.53832762e-03f, 2.92622223e-02f, -3.45194824e-02f, 5.10776555e-03f, -4.16868515e-02f, 1.06477208e-01f, -5.00704423e-02f, 5.81502281e-02f, -2.60851085e-02f,
  -6.70210049e-02f, -4.49825302e-02f, 1.26850549e-02f, -4.53167520e-02f, -7.28064850e-02f, 4.25035832e-05f, 8.33512321e-02f, -1.21829256e-01f, -2.98429523e-02f, -4.12338190e-02f,
  8.85934085e-02f, -2.19969749e-02f, 3.81535031e-02f, 5.51147908e-02f, -4.32561059e-03f, 3.94632481e-02f, 7.04744607e-02f, 4.14627939e-02f, 5.64696230e-02f, 2.69041564e-02f,
  -2.77104024e-02f, -4.07100990e-02f, -6.58824965e-02f, -5.85398190e-02f, -5.42213693e-02f, -1.92834064e-02f, 1.43304914e-01f, 7.02864211e-03f, -6.03797324e-02f, 3.38272825e-02f,
  1.34301037e-01f, 1.92590117e-01f, 4.66207564e-02f, -1.75684571e-01f, -1.00465469e-01f, -1.23032682e-01f, 6.48399256e-03f, -1.18565001e-02f, -7.08344728e-02f, -1.07029371e-01f,
  -4.72364537e-02f, 2.09679268e-03f, -6.65809289e-02f, 1.25682177e-02f, 3.01096719e-02f, -3.15321609e-02f, 4.43977714e-02f, -2.47489032e-03f, 9.34352446e-03f, -5.11633158e-02f,
  9.77233872e-02f, -1.12998467e-02f, -2.31217220e-02f, 4.42548208e-02f, -8.88249576e-02f, -4.65606302e-02f, 4.74716350e-02f, -6.73895627e-02f, -8.22307616e-02f, 5.43857701e-02f,
  -9.02659595e-02f, -9.07367989e-02f, -8.70188028e-02f, -4.24995609e-02f, 7.06046894e-02f, -7.62452185e-02f, -4.42318954e-02f, 1.12669796e-01f, -6.57057762e-02f, 3.31800953e-02f,
  4.30490598e-02f, -1.03763575e-02f, 1.68537796e-02f, -1.52365550e-01f, 4.39262241e-02f, 1.78201944e-02f, -4.08201702e-02f, -1.74414611e-03f, 6.20200261e-02f, 8.35462436e-02f,
  3.85467373e-02f, -1.47608165e-02f, 5.87457418e-02f, -3.05490755e-02f, 2.21209954e-02f, 4.00615968e-02f, -5.26550002e-02f, -7.62390643e-02f, -1.25559894e-02f, -5.44123836e-02f,
  8.16571806e-03f, 1.98281650e-02f, 4.76625673e-02f, 2.10562460e-02f, -3.92905958e-02f, 1.42478114e-02f, -6.58354983e-02f, 2.02727262e-02f, -6.18489608e-02f, -2.38550045e-02f,
  7.91121423e-02f, 4.30901907e-02f, 2.18427181e-02f, 1.31640479e-01f, 4.07871651e-03f, 9.24362242e-02f, 4.91908640e-02f, -9.86045673e-02f, 7.48278350e-02f, -3.58152092e-02f,
  -1.19568937e-01f, 7.52099156e-02f, 5.91588877e-02f, 8.87111500e-02f, 3.44538465e-02f, 7.96266366e-03f, 9.31975022e-02f, -5.05800918e-02f, 6.03686050e-02f, -1.17892303e-01f,
  -8.80501568e-02f, -2.43007001e-02f, -1.68199185e-02f, -8.57288837e-02f, 3.76735628e-02f, -1.22935697e-01f, 2.57751532e-02f, 1.05817400e-01f, 2.66281273e-02f, -5.84309027e-02f,
  3.18727680e-02f, -1.15516737e-01f, 2.65188310e-02f, -7.78275207e-02f, -9.14722160e-02f, 2.97306888e-02f, -6.70505017e-02f, 2.01602075e-02f, 6.96957037e-02f, -5.24934977e-02f,
  -8.89105350e-03f, -6.48918524e-02f, -4.94969040e-02f, -6.15064986e-02f, -3.49466726e-02f, -2.15008464e-02f, -2.65367199e-02f, -5.90428431e-03f, 8.07202086e-02f, 1.04837477e-01f,
  1.16043329e-01f, -2.94269025e-02f, -6.55670092e-02f, 3.01175788e-02f, 9.36717987e-02f, 6.66770786e-02f, -2.17765123e-01f, 1.85457505e-02f, 8.40180814e-02f, 7.87265599e-03f,
  2.31831875e-02f, -2.07278535e-01f, 3.26738991e-02f, -1.78244323e-01f, -4.21149433e-02f, 3.71025428e-02f, -4.41339314e-02f, -6.70237020e-02f, -3.43667939e-02f, 1.77357078e-01f,
  -2.29278907e-01f, 5.51826917e-02f, 9.09812376e-03f, 6.82525262e-02f, -7.88698941e-02f, 3.65391932e-02f, -7.80273601e-02f, -1.03629358e-01f, 1.52806103e-01f, 1.36736408e-01f,
  7.52177089e-02f, 4.63805422e-02f, 6.35011494e-02f, 5.10749407e-02f, 2.01170295e-02f, -8.46511945e-02f, 1.70576587e-01f, -1.12057962e-01f, 2.19281793e-01f, 1.00555062e-01f,
  -8.91437158e-02f, 1.17267616e-01f, 1.00621074e-01f, 4.90900278e-02f, -8.05582255e-02f, 8.36696178e-02f, -1.07297003e-01f, -5.80074750e-02f, -2.79005077e-02f, 6.58650547e-02f,
  1.11314226e-02f, 1.33420289e-01f, -1.72731444e-01f, 4.84664738e-02f, -4.82981279e-02f, 9.84110087e-02f, -2.07204800e-02f, 1.22232668e-01f, -1.13532938e-01f, -1.17556661e-01f,
  8.87386426e-02f, 1.18976660e-01f, 7.84429461e-02f, 3.76745574e-02f, 5.79770617e-02f, 8.48663673e-02f, 2.87556350e-02f, -3.78822163e-02f, -7.52248839e-02f, 2.99805515e-02f,
  4.88023385e-02f, -4.15406972e-02f, 2.53613256e-02f, -8.12308416e-02f, -1.23742456e-02f, 1.07847355e-01f, 4.15855050e-02f, 1.17538154e-01f, -4.54420708e-02f, 5.04378928e-03f,
  -7.28239026e-03f, 4.79900055e-02f, -3.23054641e-02f, 2.06690617e-02f, -4.65567410e-02f, -2.29455177e-02f, 1.91093553e-02f, -6.07811473e-02f, -2.23555397e-02f, 9.14604440e-02f,
  8.80894661e-02f, -7.40186349e-02f, -7.89994467e-03f, -5.92813678e-02f, 3.26240924e-03f, 7.80627877e-02f, -9.04822052e-02f, -1.50161209e-02f, -9.21480896e-05f, -2.20619068e-02f,
  5.63042751e-03f, -6.96422998e-03f, -2.97367177e-03f, -1.52666038e-02f, 1.14157267e-01f, 6.14052117e-02f, -7.32469782e-02f, 1.29058389e-02f, 6.94154575e-02f, 7.13410228e-02f,
  -6.40446618e-02f, 4.12382819e-02f, 7.90766813e-03f, 6.64296225e-02f, 1.91113669e-02f, -2.74292212e-02f, -3.48543525e-02f, -1.53962793e-02f, -5.23580611e-02f, -4.26563143e-04f,
  -6.37294054e-02f, -2.65574604e-02f, -1.19623961e-02f, 1.94424372e-02f, 1.05296023e-01f, 3.69270593e-02f, -2.56419908e-02f, -5.98992407e-02f, 7.06434846e-02f, -3.46503826e-03f,
  3.48547772e-02f, -8.83393586e-02f, 8.15409571e-02f, 3.30304168e-02f, -1.79026201e-01f, 2.28319615e-02f, -4.60404567e-02f, -5.40398732e-02f, -1.25398804e-02f, -9.24507305e-02f,
  -5.04256040e-02f, -7.63729140e-02f, -2.70350892e-02f, 3.34709825e-04f, 1.27936676e-02f, -6.69765547e-02f, -7.35312924e-02f, 3.77743691e-03f, -6.83816075e-02f, 5.18285744e-02f,
  9.21634808e-02f, -9.13546905e-02f, -3.96840088e-02f, -5.35737909e-02f, -1.08377635e-01f, -2.57306490e-02f, -6.42889664e-02f, -2.48258444e-03f, 5.99256791e-02f, -2.44460255e-02f,
  -1.18655883e-01f, 1.69270169e-02f, 1.00010261e-02f, 1.08188264e-01f, -5.72297536e-02f, -3.54386345e-02f, -3.55510153e-02f, 1.88957788e-02f, -7.14300126e-02f, 4.13411530e-03f,
  -7.36993086e-03f, -8.52678865e-02f, -3.11273895e-02f, -5.65138087e-02f, -7.09974840e-02f, 4.54181135e-02f, -5.88040277e-02f, 1.09608755e-01f, -9.73795429e-02f, 1.04990400e-01f,
  1.75249614e-02f, -1.03586458e-01f, 1.68568343e-02f, 2.41819918e-02f, 1.97688844e-02f, 3.70229557e-02f, -1.03293709e-01f, -1.09346449e-01f, 8.49376023e-02f, -4.66838330e-02f,
  -4.16246243e-02f, 6.54962584e-02f, -7.95761794e-02f, 1.93252682e-03f, 7.37728328e-02f, 5.09749586e-03f, 5.88691272e-02f, -9.98931825e-02f, -1.06739923e-02f, 9.14484262e-02f,
  1.45724686e-02f, 1.79396775e-02f, -2.99081709e-02f, -5.19439615e-02f, -2.20945328e-02f, -4.68274243e-02f, -6.36382997e-02f, -7.20130280e-02f, 6.44554272e-02f, 2.99897864e-02f,
  -4.23386320e-02f, -7.61119872e-02f, -4.70100231e-02f, -2.89776661e-02f, 1.70111619e-02f, 1.20465904e-01f, 8.14820174e-03f, -9.57273468e-02f, 7.52704293e-02f, -2.26151701e-02f,
  5.26165105e-02f, -2.59070545e-02f, 5.98216094e-02f, -2.91991383e-02f, -2.14138739e-02f, -3.60963978e-02f, 4.87054177e-02f, -6.53947070e-02f, -5.07078692e-02f, 2.97061335e-02f,
  2.17766184e-02f, 1.19551439e-02f, -4.13845144e-02f, 1.36218205e-01f, 2.60132179e-02f, 6.98694512e-02f, -6.10453123e-03f, -1.19387649e-01f, -4.42886092e-02f, -1.06037006e-01f,
  9.12804231e-02f, -1.31046206e-01f, 1.01701073e-01f, 4.34368514e-02f, -9.80004370e-02f, 5.18747494e-02f, -1.56038795e-02f, 2.24631783e-02f, -4.10350338e-02f, -2.34479103e-02f,
  1.41690085e-02f, -4.96053472e-02f, -6.03519939e-02f, -1.44848926e-02f, 2.32841037e-02f, -1.44240279e-02f, 5.50480895e-02f, -1.56257767e-02f, -1.58637203e-02f, 5.49343005e-02f,
  3.30102518e-02f, 3.53877223e-03f, 6.32869601e-02f, 8.21864977e-02f, 2.42245048e-02f, 1.19665638e-01f, 1.62897989e-01f, -6.81417808e-02f, 8.65537301e-02f, -1.00901194e-01f,
  3.09054013e-02f, -1.41953960e-01f, 4.08169292e-02f, -7.35811368e-02f, -1.49112165e-01f, -1.92974638e-02f, -5.66005595e-02f, 1.02973521e-01f, -5.72537743e-02f, 9.63592380e-02f,
  -1.82944074e-01f, -1.12598762e-01f, -4.62191105e-02f, 1.13383159e-01f, 1.51404321e-01f, -1.32145822e-01f, 3.66548188e-02f, 6.50891587e-02f, 1.81054130e-01f, 5.10619320e-02f,
  2.83685606e-02f, -5.71614988e-02f, 8.76435786e-02f, 2.25453287e-01f, 6.00727536e-02f, 3.82903740e-02f, -4.59945649e-02f, 6.68310151e-02f, -1.33007780e-01f, 4.99045476e-02f,
  -5.08743115e-02f, 2.06812005e-03f, -3.83325033e-02f, 1.42120689e-01f, 9.80631933e-02f, -1.46730289e-01f, 7.64935883e-03f, -1.44783840e-01f, 3.09478138e-02f, 1.59024503e-02f,
  -6.97752833e-02f, -1.08772703e-01f, -6.21879958e-02f, -1.17142372e-01f, 1.39478557e-02f, 2.88458951e-02f, 3.69596370e-02f, -1.41416788e-01f, -1.27788857e-02f, 8.81784484e-02f,
  -6.78757578e-02f, 1.39502287e-01f, 1.52705744e-01f, 9.09904242e-02f, 2.40373407e-02f, 2.09698942e-03f, -6.87256828e-02f, 3.60559523e-02f, 2.15439163e-02f, -1.04364820e-01f,
  -9.24528390e-02f, 1.11062281e-01f, 4.04037461e-02f, 8.03836659e-02f, 2.97665186e-02f, -8.02618975e-04f, 1.43786315e-02f, -1.68043375e-01f, -1.86939836e-02f, -6.52798936e-02f,
  4.44350354e-02f, -4.59497981e-02f, 8.62844102e-03f, 3.67670618e-02f, 6.03629425e-02f, 8.45880993e-03f, 1.63299926e-02f, 8.55368599e-02f, -2.20037177e-02f, 1.85828321e-02f,
  3.76033410e-03f, -7.42798969e-02f, 1.02613531e-01f, -6.35062978e-02f, 7.83011201e-04f, 4.90381792e-02f, 3.24606001e-02f, -4.41291332e-02f, 4.24705595e-02f, 7.99655840e-02f,
  -1.34020224e-01f, -4.51762825e-02f, 1.03945043e-02f, -5.28974421e-02f, -1.02002576e-01f, 8.66621211e-02f, 7.63312802e-02f, -7.88584873e-02f, -7.22409934e-02f, -1.80592556e-02f,
  -2.96170358e-02f, 3.92407142e-02f, -4.23525013e-02f, -9.40090120e-02f, -5.46223149e-02f, 6.36959001e-02f, 3.52246016e-02f, -2.89568827e-02f, -2.35825479e-02f, -3.60583626e-02f,
  -1.05466984e-01f, 7.17193782e-02f, 3.99820227e-03f, -6.73791859e-03f, 5.68045788e-02f, -8.66831616e-02f, -1.00823522e-01f, -1.00478463e-01f, 8.27485025e-02f, 7.83061702e-03f,
  1.40042394e-01f, -7.77859166e-02f, -1.09676294e-01f, -3.88774127e-02f, -1.03937939e-01f, 9.54820812e-02f, -6.18358550e-04f, 4.05968390e-02f, 1.07441723e-01f, -1.02349274e-01f,
  7.43696392e-02f, -3.53173502e-02f, -2.74391472e-02f, -1.91793982e-02f, -1.25656858e-01f, 1.46804629e-02f, 5.84873036e-02f, 1.03237666e-01f, -9.28196758e-02f, 3.05671971e-02f,
  -1.16692208e-01f, 1.69788927e-01f, -2.20305491e-02f, -4.13656235e-02f, 1.53780729e-01f, 1.23745985e-01f, 2.08900440e-02f, -9.10572708e-02f, -2.29268298e-01f, 1.37857825e-01f,
  1.08987667e-01f, -9.96816158e-02f, 8.28861669e-02f, 1.63917586e-01f, 3.46017033e-02f, 9.58214700e-02f, -1.81796312e-01f, 2.25791663e-01f, -2.56390367e-02f, -1.44759730e-01f,
  8.15012455e-02f, 1.99139774e-01f, 9.58429873e-02f, -1.81516074e-02f, 1.35371327e-01f, 1.89113572e-01f, 3.64093818e-02f, -4.14550230e-02f, 1.75443031e-02f, -3.49093601e-02f,
  9.67881382e-02f, -1.99181382e-02f, -2.56835446e-02f, 7.98197389e-02f, -1.89735238e-02f, 9.71803293e-02f, -7.58069605e-02f, 1.76062062e-02f, -1.96207855e-02f, -1.21996952e-02f,
  9.18705612e-02f, 3.77313420e-02f, -7.08228946e-02f, -5.13865650e-02f, -3.86361778e-02f, 7.90287629e-02f, -1.23226605e-02f, 3.76900844e-02f, 4.63669933e-03f, 4.55068871e-02f,
  -4.71683405e-02f, -5.11562750e-02f, -2.38709655e-02f, 6.37531206e-02f, -5.99600226e-02f, -6.18247651e-02f, -2.00648364e-02f, -1.37625158e-01f, -5.56708537e-02f, 2.77493685e-03f,
  -1.06898388e-02f, 9.00363270e-03f, -3.40031572e-02f, 2.10126545e-02f, -3.02351881e-02f, 5.39488271e-02f, -1.84220262e-02f, 5.32989427e-02f, 6.85080215e-02f, -5.46478620e-03f,
  6.01820610e-02f, 5.59163317e-02f, -3.33392993e-02f, 7.62564689e-02f, 3.83084570e-03f, -6.17490001e-02f, -2.33923979e-02f, 9.89681259e-02f, 9.26880166e-03f, -9.09074768e-02f,
  -5.43706492e-02f, -6.67257756e-02f, -5.85560091e-02f, 9.08565819e-02f, 6.25170255e-03f, -1.55597962e-02f, 8.60518951e-04f, 1.54835619e-02f, 1.05920024e-02f, 7.64220804e-02f,
  -3.04433126e-02f, -6.53737932e-02f, -1.00757413e-01f, 2.69012414e-02f, 1.76032856e-02f, -4.21063527e-02f, 1.03707518e-02f, 6.67748377e-02f, -1.22799836e-02f, 4.66152728e-02f,
  1.05647661e-01f, -6.20191358e-02f, 7.97559246e-02f, -2.79103890e-02f, -5.52683184e-03f, 1.40133779e-03f, -7.83102680e-03f, 1.27094779e-02f, 1.66970327e-01f, -3.30451541e-02f,
  -5.03779687e-02f, -8.57174397e-02f, 3.61741222e-02f, -3.38666029e-02f, 4.88525070e-02f, -7.84417056e-03f, 5.55501804e-02f, -1.00747474e-01f, 6.65998459e-02f, -7.68295974e-02f,
  -1.72205884e-02f, -4.13714163e-02f, -1.07808448e-01f, 1.31050171e-02f, -4.69316915e-02f, 1.26707777e-01f, -2.01864131e-02f, 1.84944365e-02f, -7.36041665e-02f, 9.96334665e-03f,
  -2.37912964e-03f, -1.42283767e-01f, 9.51060932e-03f, -4.13903520e-02f, 3.64389084e-02f, -1.04004061e-02f, -4.38579964e-03f, -8.27652514e-02f, -2.38290392e-02f, 6.71334267e-02f,
  8.93025175e-02f, 4.40259762e-02f, 1.90384984e-02f, 1.13919429e-01f, -1.02608033e-01f, -1.67882685e-02f, 8.19280222e-02f, -1.70844998e-02f, -3.93820480e-02f, 6.25769794e-02f,
  -4.49281894e-02f, 6.36598170e-02f, 1.17102310e-01f, 1.37111634e-01f, 4.61468622e-02f, 7.81077519e-02f, -4.16874997e-02f, 9.97116342e-02f, 1.33568291e-02f, -8.06379244e-02f,
  -8.40984881e-02f, 6.69815391e-02f, -7.13448524e-02f, 5.29099666e-02f, -7.85668343e-02f, -1.22501180e-02f, 1.75674334e-02f, 2.37313788e-02f, -2.82522105e-03f, 1.21932119e-01f,
  1.27043083e-01f, -3.01056392e-02f, -6.53444082e-02f, 3.30092721e-02f, 3.14088836e-02f, -9.67114866e-02f, -7.90166110e-02f, 6.00611158e-02f, -8.73452947e-02f, 2.48634834e-02f,
  -3.46417874e-02f, 8.76350515e-03f, 3.62099931e-02f, -4.13750298e-02f, -4.44785133e-03f, 7.97061697e-02f, 3.63125615e-02f, 4.67830859e-02f, -3.73823009e-02f, -3.74850556e-02f,
  -9.78187472e-03f, 8.66756067e-02f, -7.70455450e-02f, -7.23590627e-02f, -4.48396876e-02f, -2.29334570e-02f, -3.31143588e-02f, -3.38438004e-02f, -2.23773345e-02f, -3.32876854e-02f,
  5.22619188e-02f, 8.81821886e-02f, 2.65736580e-02f, 4.73101297e-03f, 3.80738406e-03f, -8.26720148e-02f, 7.13112205e-02f, -7.64848515e-02f, -4.43761721e-02f, -8.26425999e-02f,
  -3.68076079e-02f, 6.22659773e-02f, 5.68916611e-02f, 2.91577466e-02f, 1.51994089e-02f, 6.63653761e-02f, 2.95024458e-02f, -1.11129381e-01f, -4.06002514e-02f, -1.63060687e-02f,
  -4.03864086e-02f, 4.39963825e-02f, 4.32420708e-02f, -2.80939066e-03f, -4.28168625e-02f, -3.01047619e-02f, 1.27431266e-02f, -2.06730235e-03f, -1.46757369e-03f, -4.65461798e-02f,
  -5.67862857e-03f, -4.71155643e-02f, 6.99485689e-02f, -1.72860064e-02f, 1.34912252e-01f, -1.25293821e-01f, 7.15855658e-02f, 7.13259503e-02f, 8.02742317e-02f, -8.64250809e-02f,
  1.67648941e-02f, 8.19318220e-02f, 5.24727479e-02f, 9.38263610e-02f, 1.05360381e-01f, 7.77633348e-03f, -1.96954310e-02f, -2.56961044e-02f, 1.01948008e-01f, -3.93189602e-02f,
  9.01258588e-02f, 6.14243783e-02f, -5.98141439e-02f, -4.49290089e-02f, 1.40847147e-01f, -1.96699813e-01f, 8.07972178e-02f, 6.29631802e-02f, 3.06379572e-02f, 1.31656229e-01f,
  -8.95939991e-02f, 5.38901873e-02f, -5.01460806e-02f, 7.51959831e-02f, -8.14465806e-02f, 1.27340609e-03f, -6.23561107e-02f, -8.25753063e-02f, -1.70110896e-01f, -8.77076983e-02f,
  -8.08012730e-04f, -9.41726714e-02f, -6.26742691e-02f, 4.96551245e-02f, -5.11938967e-02f, 1.58192180e-02f, -3.89989726e-02f, -2.78386590e-03f, -2.77494937e-02f, -7.20069259e-02f,
  1.31079797e-02f, -4.70711999e-02f, 9.75800976e-02f, -4.47926074e-02f, 2.58062538e-02f, -1.02695301e-01f, 4.05015051e-02f, -8.60711858e-02f, 9.60736275e-02f, 3.27655822e-02f,
  6.17122054e-02f, -3.47997248e-02f, 3.53251062e-02f, 3.73429689e-03f, -5.90859689e-02f, -1.19235650e-01f, -8.15015510e-02f, -6.44361079e-02f, -2.68201884e-02f, 1.20702647e-02f,
  1.21034928e-01f, 4.52321023e-02f, -8.31900761e-02f, 4.16565910e-02f, 9.13148150e-02f, 6.07371219e-02f, 1.28371203e-02f, 8.76141936e-02f, 8.03993717e-02f, 4.18004207e-02f,
  5.92365563e-02f, 9.10301227e-03f, -2.75583416e-02f, -2.75441706e-02f, -8.01402107e-02f, -5.82601838e-02f, -7.50036985e-02f, 4.99496460e-02f, -3.99788609e-03f, -2.42595021e-02f,
  -4.16981056e-02f, -8.37590173e-03f, 4.54779118e-02f, 4.87754457e-02f, -4.50452864e-02f, -1.62578113e-02f, 6.43380806e-02f, -2.55378019e-02f, -5.83619475e-02f, -3.38223064e-03f,
  3.58529016e-02f, 7.44758174e-02f, -2.30750721e-02f, 8.39999542e-02f, -1.35741215e-02f, 4.59065549e-02f, 4.95654158e-02f, 1.79810580e-02f, -5.88053558e-03f, -5.43460399e-02f,
  -3.37902755e-02f, -5.58784865e-02f, 9.07732323e-02f, 4.78658937e-02f, 8.01183060e-02f, 6.32067770e-02f, -6.18293844e-02f, 1.89261399e-02f, -5.58207519e-02f, 6.06983602e-02f,
  1.07132308e-02f, -4.27560601e-03f, -9.79270041e-02f, -6.69560730e-02f, -5.97154489e-03f, -3.01980209e-02f, -4.48666401e-02f, 8.65339767e-03f, -2.08725762e-02f, -5.78486323e-02f,
  6.36975467e-02f, 2.56757773e-02f, -2.11683393e-01f, 1.16620734e-01f, 3.24931554e-02f, -1.31887287e-01f, -8.75394884e-03f, -8.30358043e-02f, -2.64859535e-02f, 8.20282325e-02f,
  -4.32485603e-02f, -3.39850858e-02f, 4.82674390e-02f, -1.01025542e-03f, 3.78897898e-02f, -7.40285218e-02f, -1.07497267e-01f, -9.24717337e-02f, 4.72120568e-03f, 1.08983785e-01f,
  -6.92329332e-02f, 6.11833483e-02f, -6.80891424e-03f, -8.78021959e-03f, -1.41057476e-01f, 1.84890050e-02f, -1.00423977e-01f, -1.94861278e-01f, -4.05379198e-02f, 2.59086713e-02f,
  8.75781775e-02f, -1.02247715e-01f, -8.77419710e-02f, 2.97030210e-02f, 1.00055188e-01f, 1.82844400e-01f, -6.15137443e-03f, 1.04659684e-01f, 1.53566804e-02f, 1.31932385e-02f,
  -1.13870487e-01f, 2.14128159e-02f, -6.58106282e-02f, -1.51223883e-01f, -9.67577007e-03f, 1.29655987e-01f, 7.00503215e-02f, -1.20234296e-01f, 7.65306205e-02f, 3.71533409e-02f,
  9.66313779e-02f, 9.84322950e-02f, -9.58436504e-02f, 6.10848609e-03f, 2.56368741e-02f, -5.40926456e-02f, 1.91903058e-02f, 1.28940627e-01f, 4.30141948e-02f, -1.13028698e-01f,
  5.11077382e-02f, -6.29881257e-03f, 8.24158266e-02f, -5.65411821e-02f, -1.76451344e-03f, 8.84571671e-02f, 6.13675825e-02f, -6.89039528e-02f, -5.65170720e-02f, -4.32180278e-02f,
  -9.06489789e-02f, -1.06721204e-02f, -8.44085440e-02f, 3.85613851e-02f, -8.50666091e-02f, -7.17330212e-03f, -7.14527220e-02f, 4.60622646e-03f, -9.31778997e-02f, 5.38832415e-03f,
  4.92920447e-03f, -2.24877987e-02f, 5.31763099e-02f, 7.22840130e-02f, -8.97764638e-02f, 7.49082938e-02f, -9.85251367e-03f, -1.50733203e-01f, -1.38354860e-02f, -3.35038528e-02f,
  3.33158709e-02f, -4.23711687e-02f, 3.11800446e-02f, 2.59777457e-02f, -4.28970456e-02f, -2.00421605e-02f, -1.05355434e-01f, 3.05471495e-02f, -2.35356037e-02f, 3.17956023e-02f,
  1.16436817e-02f, 2.05316767e-03f, -7.28439391e-02f, 5.03923036e-02f, -8.37707072e-02f, -4.96414229e-02f, -4.07585166e-02f, -2.42330544e-02f, 2.17970796e-02f, 3.79828103e-02f,
  -4.36355453e-03f, -2.81180460e-02f, -4.94244434e-02f, -2.20432151e-02f, 3.86389950e-03f, -6.36330917e-02f, -1.28348410e-01f, -1.24113522e-01f, -7.26721669e-03f, -8.61149430e-02f,
  -1.60375535e-02f, -1.08585611e-01f, -1.20590374e-01f, -8.22055489e-02f, -6.82939216e-02f, -5.24966270e-02f, -5.45414239e-02f, -3.01612634e-02f, 4.41282764e-02f, 5.07397987e-02f,
  -5.33109978e-02f, 5.56884194e-03f, 1.76071763e-01f, -8.95342007e-02f, 1.28990784e-01f, 1.77039146e-01f, 1.51331589e-01f, 1.40310079e-01f, -6.03692569e-02f, 6.99095204e-02f,
  1.57997664e-02f, -1.49551615e-01f, -9.75740701e-02f, -1.98532417e-02f, 4.10648994e-02f, -3.30409519e-02f, 8.63062125e-03f, -4.99208458e-02f, 9.79482383e-02f, 5.60132228e-02f,
  7.24366829e-02f, -6.73503056e-02f, 8.96488950e-02f, 3.18688564e-02f, -6.91044331e-02f, -1.64843559e-01f, -1.23382717e-01f, 6.03924990e-02f, 1.67454837e-03f, -1.43967420e-01f,
  -4.43375893e-02f, 1.86737883e-03f, -2.98734866e-02f, 5.41187525e-02f, -8.09627548e-02f, -2.25748774e-02f, -6.29202574e-02f, -1.32376254e-01f, -1.13547988e-01f, 4.47932631e-02f,
  2.91673597e-02f, -3.50363329e-02f, -4.83056866e-02f, -3.28379869e-02f, 1.66706413e-01f, -1.57110050e-01f, 2.16233898e-02f, -1.82663590e-01f, 1.37490660e-01f, 9.94583368e-02f,
  -7.27965757e-02f, -1.22041322e-01f, 2.51179338e-02f, -1.48782566e-01f, 3.02771982e-02f, 7.11574033e-02f, -9.79205221e-03f, -9.36455652e-02f, -2.17878819e-02f, -4.33257222e-02f,
  2.08821446e-02f, -4.27257270e-02f, -2.03096382e-02f, -3.39559466e-02f, 4.52673845e-02f, -6.49222881e-02f, 7.56747872e-02f, 1.76874232e-02f, -2.34346241e-02f, 1.02216974e-02f,
  -4.42487560e-02f, 2.25913227e-02f, -1.06937058e-01f, 2.47067157e-02f, -3.84307210e-03f, 3.47524397e-02f, -8.82023796e-02f, 8.49983245e-02f, 1.12738917e-02f, -9.08174142e-02f,
  8.35824665e-03f, 4.84300554e-02f, -8.30643401e-02f, -4.37971167e-02f, -6.99027965e-04f, 2.71629672e-02f, -1.29172094e-02f, 6.59766048e-02f, -1.02335580e-01f, -9.60177742e-03f,
  -6.91862926e-02f, 6.36251047e-02f, -3.79558988e-02f, -8.58095735e-02f, 2.42328327e-02f, -8.70262459e-02f, -4.22514454e-02f, 3.17292027e-02f, -8.36062133e-02f, -1.80408284e-02f,
  -3.67404856e-02f, 2.17827521e-02f, -1.90672223e-02f, -3.69215123e-02f, -3.55538540e-02f, 2.25620326e-02f, -6.83385134e-02f, -8.27668160e-02f, -3.39456312e-02f, 5.84694967e-02f,
  5.65873943e-02f, -1.16452001e-01f, 8.64612758e-02f, -8.28247964e-02f, 1.63714029e-02f, 4.84195463e-02f, -7.88628384e-02f, -5.80610968e-02f, 5.37256002e-02f, 5.88124283e-02f,
  9.78091173e-03f, 5.03592826e-02f, -2.47109775e-02f, 6.01514429e-02f, -1.56710848e-01f, 1.33192204e-02f, -3.39449160e-02f, 5.56428060e-02f, 2.23977461e-01f, -6.77952245e-02f,
  -4.91230264e-02f, 1.13003664e-01f, -1.16878770e-01f, -1.48871407e-01f, -5.85933924e-02f, -5.49547598e-02f, -1.37591794e-01f, -2.40752008e-02f, -3.12836729e-02f, 1.02284148e-01f,
  6.66187406e-02f, -4.88998815e-02f, 1.23208016e-01f, 6.80900365e-02f, -5.95758706e-02f, -8.18282291e-02f, 1.36964127e-01f, 7.68881477e-03f, -3.46467621e-03f, -1.35789573e-01f,
  2.87276451e-02f, -9.45073515e-02f, 1.72237717e-02f, 1.41382083e-01f, 1.16461879e-02f, 5.91860041e-02f, -9.08890367e-02f, 1.81412753e-02f, -8.33987445e-02f, 1.09851018e-01f,
  -4.16509919e-02f, -1.88862801e-01f, 2.31500831e-03f, -9.55587998e-03f, 1.47932181e-02f, -3.49855311e-02f, -1.03348419e-02f, 1.29556000e-01f, -1.50746724e-03f, 8.39765072e-02f,
  3.77958082e-02f, -1.93695386e-03f, -1.55414373e-01f, 1.57440931e-01f, -1.06458046e-01f, 9.44820717e-02f, 5.82313165e-02f, -1.67388126e-01f, -7.03555485e-03f, 1.16966546e-01f,
  4.87695448e-02f, 4.71154004e-02f, -4.67047580e-02f, -1.34050503e-01f, 7.82538429e-02f, 7.47064576e-02f, 1.10452960e-03f, -6.42801970e-02f, -1.36350766e-02f, -7.10117593e-02f,
  -2.41452605e-02f, -3.36901173e-02f, 2.48140842e-02f, 2.11711153e-02f, -3.15375514e-02f, 9.78021026e-02f, -9.43562612e-02f, -5.65337995e-03f, 1.93026643e-02f, -4.58444171e-02f,
  -6.69487864e-02f, 9.55411419e-02f, -2.83830184e-02f, 1.48192188e-02f, 8.48704129e-02f, 2.44230796e-02f, 2.40228251e-02f, -8.55954066e-02f, 8.88964336e-04f, -9.89002455e-03f,
  -2.15509962e-02f, 8.11549351e-02f, 2.94107455e-03f, -9.98510607e-03f, -6.28128871e-02f, 2.64697783e-02f, 2.84020808e-02f, 8.40748195e-03f, 6.25531152e-02f, -2.17939145e-03f,
  3.40012163e-02f, 1.26393540e-02f, -4.49897908e-02f, 6.65614828e-02f, -9.56814066e-02f, 9.52545851e-02f, -4.16667499e-02f, 2.41088755e-02f, -1.02981195e-01f, -3.63492370e-02f,
  -7.10908920e-02f, -5.14608063e-02f, -3.45800780e-02f, -5.81337214e-02f, -8.01331699e-02f, -7.54671544e-02f, 1.02758639e-01f, 6.56734779e-02f, 2.39822976e-02f, 5.50573841e-02f,
  -9.39877480e-02f, 1.24929305e-02f, -5.28052934e-02f, -3.63650545e-02f, -3.05271130e-02f, -9.80149209e-02f, 6.21642545e-02f, -3.84572186e-02f, -6.47026449e-02f, -2.12507118e-02f,
  1.68549847e-02f, -4.99689281e-02f, 2.78037656e-02f, -2.97637973e-02f, 3.99660654e-02f, 5.52534275e-02f, -6.07002079e-02f, 4.76724319e-02f, 7.35115111e-02f, 1.87536161e-02f,
  -9.73627809e-03f, 1.19941518e-01f, 3.62466052e-02f, 4.07164954e-02f, 3.24772187e-02f, 7.96399936e-02f, 1.69236809e-01f, -8.69730413e-02f, 9.57650840e-02f, -1.21527366e-01f,
  -1.20269358e-01f, 7.79096037e-02f, 1.47315592e-01f, 4.46623825e-02f, -2.66863648e-02f, 9.32882056e-02f, 1.83937456e-02f, -2.01859623e-02f, 6.30395859e-02f, 1.07586898e-01f,
  3.63528877e-02f, -4.35372666e-02f, -9.73851085e-02f, -9.89683643e-02f, 9.33736488e-02f, -1.43032506e-01f, 4.24674619e-03f, -5.52458391e-02f, 5.19851735e-03f, 1.83545008e-01f,
  -1.22139722e-01f, 1.65888667e-02f, -2.80269291e-02f, -5.42971231e-02f, -5.06126396e-02f, -5.50711825e-02f, 5.13820797e-02f, -4.97728214e-02f, 1.75879017e-01f, -6.77933246e-02f,
  1.12461068e-01f, -2.17592761e-01f, 3.29537690e-02f, -1.75295308e-01f, 2.64548548e-02f, 5.87141737e-02f, 4.03373949e-02f, -2.28517805e-03f, 7.04628229e-02f, -6.44947402e-03f,
  8.72066543e-02f, -4.95928153e-02f, -4.89020981e-02f, -9.14095193e-02f, -1.94107406e-02f, -4.09277603e-02f, 7.80368671e-02f, 7.85881057e-02f, -5.13796732e-02f, 7.00650662e-02f,
  1.30503580e-01f, 5.34279421e-02f, 3.12305465e-02f, -3.17006074e-02f, 4.52408344e-02f, -7.96665177e-02f, 3.48128118e-02f, -3.97263132e-02f, -7.06850886e-02f, -1.06381373e-02f,
  9.61110890e-02f, 9.12897848e-03f, -7.47163296e-02f, -8.09574649e-02f, 9.04679149e-02f, -5.92327081e-02f, -5.87589666e-02f, -8.00705820e-05f, -1.05572209e-01f, -3.80713604e-02f,
  4.42802608e-02f, -7.69998208e-02f, 6.12110235e-02f, -2.01395191e-02f, 3.19619700e-02f, 4.82855923e-02f, -9.92421880e-02f, -2.05542054e-02f, -4.27943878e-02f, 7.16563836e-02f,
  7.43344203e-02f, -7.32715949e-02f, 4.51338589e-02f, -3.14613469e-02f, -3.42381485e-02f, 5.60355000e-02f, -5.71568273e-02f, -1.01819657e-01f, -5.01775965e-02f, -2.14647222e-02f,
  6.62738681e-02f, 6.56491965e-02f, -3.77715565e-02f, -5.72636202e-02f, -9.34711006e-03f, 5.83144799e-02f, 6.69843378e-03f, -5.45952283e-02f, 2.73961071e-02f, 1.76200233e-02f,
  -1.06000770e-02f, 4.52750362e-02f, 1.19135976e-01f, -2.21030172e-02f, 8.86990502e-02f, -2.93442532e-02f, -5.42164594e-03f, -9.36065614e-02f, -2.20828503e-02f, -9.84955281e-02f,
  3.99337932e-02f, 6.76406026e-02f, -1.20565724e-02f, -6.32336587e-02f, -1.65755153e-02f, -1.05586864e-01f, 7.55944056e-03f, -3.19738761e-02f, 5.22987619e-02f, 1.26121074e-01f,
  1.91883519e-02f, 5.06883301e-02f, 2.12488193e-02f, 3.71585898e-02f, 1.33030370e-01f, 6.19219132e-02f, -1.95383877e-02f, -6.76732287e-02f, -4.15874273e-02f, 1.02908760e-01f,
  2.19702318e-01f, -4.20156159e-02f, -5.03358245e-02f, -5.60144708e-02f, -1.32903298e-02f, 3.23873386e-02f, 1.07909173e-01f, 1.76111925e-02f, -1.71622785e-03f, 4.89036068e-02f,
  -4.43977490e-02f, -1.74338575e-02f, -5.38607463e-02f, 2.75546801e-03f, 3.92780192e-02f, -2.50416882e-02f, -1.96952999e-01f, 1.41538173e-01f, -1.83030277e-01f, -1.05652891e-01f,
  2.52148397e-02f, -2.80105304e-02f, 5.65522239e-02f, -1.37758732e-01f, -2.27760803e-02f, -7.37549588e-02f, 7.89406672e-02f, 1.88502725e-02f, 3.50461863e-02f, -1.56531468e-01f,
  -8.97322074e-02f, -1.98297188e-01f, 2.44049053e-03f, 2.99786385e-02f, 4.12813155e-03f, -9.73613933e-02f, 6.81818053e-02f, -3.52523401e-02f, 4.29859571e-02f, -7.50413686e-02f,
  -1.03045637e-02f, -1.26750171e-01f, 2.38188878e-02f, -1.19834617e-01f, 1.87665247e-03f, -7.55813867e-02f, -1.03563190e-01f, -1.24388821e-02f, 2.29644291e-02f, -9.07421634e-02f,
  2.17619129e-02f, 5.42675378e-03f, 5.24314791e-02f, -9.63863879e-02f, -5.77835329e-02f, -3.13966647e-02f, -7.61113390e-02f, -1.44251287e-02f, -3.73326540e-02f, -1.23411335e-01f,
  -5.30970916e-02f, -3.58044431e-02f, 6.73317537e-02f, -1.03924638e-02f, -9.87180546e-02f, 9.71000567e-02f, -3.47286575e-02f, 1.07470326e-01f, -7.98691437e-02f, -7.87680447e-02f,
  7.89878368e-02f, 2.84204595e-02f, 3.68654095e-02f, 5.10165989e-02f, 7.23968297e-02f, -6.08992800e-02f, -1.51111810e-02f, 4.48936895e-02f, 3.83597240e-02f, 6.86619356e-02f,
  2.04685573e-02f, -3.19086737e-03f, 4.78669778e-02f, 5.74298799e-02f, -9.12648812e-02f, -4.17798646e-02f, -9.27186832e-02f, 2.49755438e-02f, -9.00790766e-02f, -4.63392660e-02f,
  8.11594576e-02f, -8.61676782e-02f, 1.24052994e-01f, -7.55863637e-02f, 7.75801539e-02f, -1.05202906e-01f, 5.10145165e-02f, 1.53332846e-02f, 8.58883560e-02f, 3.17448787e-02f,
  6.87834173e-02f, 3.37535180e-02f, -1.10644244e-01f, 9.11283493e-03f, -5.27593121e-02f, 1.12526856e-01f, 1.03767000e-01f, 2.82308254e-02f, 1.08908601e-01f, -8.30735788e-02f,
  -2.84204050e-03f, -5.07242531e-02f, -7.10488781e-02f, 1.69310510e-01f, -9.42608491e-02f, 7.24873841e-02f, 2.38215812e-02f, -7.75290877e-02f, 1.61127120e-01f, -8.94506201e-02f,
  5.16690873e-02f, -2.12309584e-02f, 1.32297337e-01f, 2.46625971e-02f, 9.18207094e-02f, -2.11594060e-01f, -2.03548968e-01f, 1.54602334e-01f, -2.92912405e-02f, 2.49239504e-02f,
  -1.41334817e-01f, -9.14922450e-03f, -2.13771015e-01f, -1.19162142e-01f, -7.18543306e-02f, 1.84884623e-01f, 1.25395834e-01f, -7.31557608e-02f, 2.89668376e-03f, -1.46603450e-01f,
  1.60174474e-01f, -1.03520431e-01f, -1.72140300e-02f, -1.63520649e-02f, 5.45999520e-02f, 2.72765607e-01f, -1.48141503e-01f, -3.53103057e-02f, 1.14689611e-01f, -2.89443955e-02f,
  -2.24483624e-01f, -1.34177506e-02f, -1.52523130e-01f, -6.53766766e-02f, 1.59953073e-01f, 4.02004980e-02f, 4.32494842e-02f, -5.71939498e-02f, -2.71925461e-02f, 5.42935356e-03f,
  -9.42981690e-02f, -1.79009326e-02f, -6.53498694e-02f, 8.14267769e-02f, -8.83210357e-03f, 1.77888144e-02f, -3.34676504e-02f, 1.09824799e-01f, -7.72522539e-02f, 4.96574380e-02f,
  -4.47708517e-02f, -5.43539552e-03f, -6.00203462e-02f, -6.46554008e-02f, 1.09140128e-01f, 1.72529981e-01f, 1.79360226e-01f, 3.09852622e-02f, -8.21753815e-02f, -8.51721838e-02f,
  6.13142028e-02f, -1.53922271e-02f, -1.54468045e-01f, 6.40826821e-02f, -1.43322232e-03f, -9.58520100e-02f, 5.50550371e-02f, 1.15956860e-02f, 6.76533394e-03f, -2.11486965e-02f,
  5.57464845e-02f, 9.25050899e-02f, -6.20933250e-02f, -8.06454290e-03f, 1.03458643e-01f, 7.21745268e-02f, 7.14386031e-02f, -2.04497185e-02f, 3.12042944e-02f, -1.01302691e-01f,
  4.04866226e-02f, 3.72545756e-02f, 3.97269465e-02f, -4.25695255e-02f, 4.98082824e-02f, 5.02749048e-02f, 5.84705616e-04f, -1.13486443e-02f, 2.47491319e-02f, 2.47537289e-02f,
  -6.59363270e-02f, -3.80522683e-02f, -2.59118341e-02f, -2.29933895e-02f, 3.13303508e-02f, -2.54535452e-02f, -7.38542676e-02f, 4.70183790e-02f, -1.97258759e-02f, -5.39626330e-02f,
  -9.46418196e-03f, 9.39017609e-02f, 2.78269872e-02f, -9.28525329e-02f, -4.11620028e-02f, 4.07458059e-02f, 9.48531181e-02f, -3.61393429e-02f, 1.13398284e-01f, 5.70088811e-02f,
  2.99574304e-02f, -1.25487698e-02f, 2.36414522e-02f, -6.43752962e-02f, 8.33729133e-02f, -4.17308174e-02f, 7.04526454e-02f, -5.60681857e-02f, -5.87287061e-02f, -1.54396906e-01f,
  1.34362318e-02f, -1.64295778e-01f, 1.82149671e-02f, -7.12677613e-02f, 4.40779179e-02f, -7.78505877e-02f, 2.23985314e-02f, 2.19077170e-01f, 4.58778702e-02f, 5.38924523e-02f,
  -1.56232221e-02f, 5.12561649e-02f, 6.44370839e-02f, 1.00628650e-02f, 8.82679671e-02f, -1.80162657e-02f, 2.10905179e-01f, 8.23664069e-02f, -3.75085808e-02f, -5.23483455e-02f,
  5.47481291e-02f, -1.65485740e-01f, 4.27575260e-02f, 9.83557180e-02f, -1.15899235e-01f, -2.09430791e-02f, -1.67037193e-02f, 8.54751170e-02f, -8.83381143e-02f, 6.99771047e-02f,
  -9.59024727e-02f, -2.53571607e-02f, -1.52928665e-01f, -8.04522599e-04f, -1.71233580e-01f, -8.92286748e-02f, -3.49012092e-02f, -3.98675092e-02f, 7.87299946e-02f, -1.06783926e-01f,
  8.77653528e-03f, -1.48871183e-01f, 6.23114232e-04f, -5.38306125e-02f, 1.79651566e-02f, 6.54017611e-04f, -2.06868444e-02f, -5.70978709e-02f, 7.38175809e-02f, -6.01064004e-02f,
  -2.50731762e-02f, -1.02076799e-01f, 6.21069893e-02f, -1.24812707e-01f, 1.43822253e-01f, 5.62353022e-02f, 7.55387694e-02f, -8.86700749e-02f, 4.63272110e-02f, -2.47975420e-02f,
  -3.53809819e-02f, -6.70686811e-02f, -5.85719235e-02f, 1.67055037e-02f, 3.58820222e-02f, 8.11644644e-02f, 3.47972661e-02f, 1.43121677e-02f, -6.41922429e-02f, -7.94457421e-02f,
  -4.88297157e-02f, -3.01106106e-02f, 4.37106192e-02f, -1.79050528e-02f, -2.68870518e-02f, -4.85696495e-02f, 3.34270038e-02f, 1.12834923e-01f, 2.40940675e-02f, 3.30547132e-02f,
  -1.12538107e-01f, 6.86841011e-02f, 2.85727400e-02f, 3.70674245e-02f, 1.64722037e-02f, 5.21464720e-02f, -3.58990878e-02f, -2.89770425e-03f, 1.10789776e-01f, 2.31661345e-03f,
  -2.43958607e-02f, -6.34302646e-02f, -1.22918367e-01f, -2.61998293e-03f, 1.12593803e-03f, 4.92329448e-02f, 9.25112069e-02f, -1.31417317e-02f, -5.99630512e-02f, 4.31484617e-02f,
  -3.29363756e-02f, -9.01040658e-02f, -7.65370205e-02f, 7.36676604e-02f, 4.59852479e-02f, -9.73618999e-02f, -1.70042943e-02f, 4.42585163e-02f, -1.03995748e-01f, -4.35879752e-02f,
  -5.15343472e-02f, -3.92059237e-02f, 3.37517858e-02f, -6.48600534e-02f, 3.89830396e-02f, -2.67203879e-02f, 5.60187362e-02f, -4.14766222e-02f, 2.97766179e-02f, -4.45415266e-02f,
  6.76400065e-02f, 5.12924641e-02f, 4.58161207e-03f, -9.74972267e-03f, -3.56295556e-02f, -4.11873274e-02f, -9.49350744e-02f, 1.18314222e-01f, 7.90017769e-02f, 3.41671780e-02f,
  -1.53539032e-01f, 7.72142736e-03f, -1.13996109e-02f, 1.26803488e-01f, 4.71570604e-02f, -1.60265744e-01f, 1.37592748e-01f, -1.14590660e-01f, -1.00650512e-01f, -4.45794277e-02f,
  6.96568862e-02f, -7.77566573e-03f, 1.25212576e-02f, 1.48339346e-01f, -1.53874848e-02f, -4.33189841e-03f, 2.47278474e-02f, -3.50650437e-02f, 8.47479049e-03f, -6.09531850e-02f,
  3.32748704e-02f, -2.84710026e-04f, 1.16037086e-01f, 9.12166163e-02f, -1.17588803e-01f, 2.90738866e-02f, 3.17288339e-02f, 1.35465220e-01f, 3.48245949e-02f, -1.44937754e-01f,
  2.70263925e-02f, 6.39666393e-02f, -8.35462436e-02f, 4.02526110e-02f, 4.27883677e-02f, -8.39458480e-02f, 1.34799495e-01f, -1.74439587e-02f, 1.60317309e-02f, -2.98684761e-02f,
  -6.82972223e-02f, -2.10684221e-02f, 8.20297673e-02f, -6.63702935e-02f, -1.28688484e-01f, -1.03414252e-01f, -1.23566106e-01f, 1.20038107e-01f, 1.67720839e-02f, -4.54225838e-02f,
  -5.66979349e-02f, 8.24510306e-02f, 1.93611253e-02f, -5.94235063e-02f, 2.38007493e-02f, -1.71784647e-02f, 1.01499245e-01f, 1.51169654e-02f, 2.88430648e-03f, 7.46465251e-02f,
  -8.38534683e-02f, 8.28824267e-02f, 2.37729307e-02f, 1.22148786e-02f, 1.26549572e-01f, -1.43173570e-02f, 2.24066665e-03f, -8.19074437e-02f, 5.06382622e-03f, -5.39245382e-02f,
  2.08946560e-02f, 6.13989606e-02f, -4.94807214e-02f, -6.94369897e-02f, -2.34415494e-02f, -5.62752597e-02f, 6.40759692e-02f, -1.06484834e-02f, -6.90932199e-03f, 2.09628381e-02f,
  3.69527005e-02f, 3.01690437e-02f, -7.64248520e-02f, 1.79482903e-02f, 3.80273163e-02f, -2.89879702e-02f, -7.37622902e-02f, -4.49372157e-02f, 7.65124559e-02f, -3.73543464e-02f,
  3.05609610e-02f, -8.60376954e-02f, -5.90679012e-02f, 3.45495827e-02f, 7.93450624e-02f, -5.12544997e-04f, -1.81344543e-02f, -1.56942066e-02f, -1.03415437e-02f, 7.35411718e-02f,
  5.00369929e-02f, -6.98757395e-02f, -2.65718456e-02f, -7.44033307e-02f, 8.88930634e-02f, -7.75893554e-02f, -9.70360562e-02f, -6.13154434e-02f, 3.35290059e-02f, 2.60273404e-02f,
  2.75070425e-02f, 1.52000608e-02f, -4.36454229e-02f, 7.02049807e-02f, -1.40056377e-02f, 5.15947677e-02f, -6.94776848e-02f, -8.07130411e-02f, -8.46933387e-03f, 3.02813835e-02f,
  -9.78954509e-02f, 2.47702096e-02f, 2.07792111e-02f, -1.80069217e-03f, 2.11726204e-02f, -5.99758029e-02f, 1.53408840e-01f, -5.59408739e-02f, -6.00544587e-02f, 1.74147971e-02f,
  1.72763988e-02f, -8.59425142e-02f, -1.52488410e-01f, 6.74938709e-02f, -1.15196824e-01f, 9.81454551e-03f, 8.77976231e-03f, 1.42114647e-02f, -3.24028917e-02f, -2.39192713e-02f,
  7.46907368e-02f, -1.44486859e-01f, -1.42215759e-01f, 1.26062959e-01f, -2.23126449e-03f, -1.72994405e-01f, 1.29016697e-01f, -1.40029475e-01f, -1.83163702e-01f, -3.49122584e-02f,
  -3.88180278e-02f, 5.08631095e-02f, 1.60746314e-02f, 1.71276852e-01f, -1.28333628e-01f, -4.11636569e-02f, -1.79159820e-01f, 1.32938012e-01f, 1.86796524e-02f, -1.71766579e-01f,
  3.66622172e-02f, 8.69482458e-02f, 5.28891422e-02f, 2.63752770e-02f, 6.58521242e-03f, 7.68934041e-02f, 8.98351073e-02f, 6.06539547e-02f, -1.47346770e-02f, 1.70401074e-02f,
  -1.00625623e-02f, 1.92455128e-01f, 6.10603727e-02f, 1.60435677e-01f, 1.83376875e-02f, -1.37818232e-01f, -2.53116731e-02f, 3.39216255e-02f, -6.16961392e-03f, 4.37341295e-02f,
  -4.60238829e-02f, 2.46122926e-02f, 6.78709298e-02f, -4.11172919e-02f, -3.26827765e-02f, 2.31483765e-02f, -6.94677457e-02f, -1.07050754e-01f, 5.88994697e-02f, -6.55795112e-02f,
  -8.50290880e-02f, -1.25378087e-01f, -1.37673058e-02f, 4.78429943e-02f, -1.19713828e-01f, 7.83135742e-02f, -3.40366317e-03f, 2.57078987e-02f, 3.35993655e-02f, -5.90991415e-02f,
  -2.50463486e-02f, 1.20173417e-01f, -3.07732280e-02f, 3.04857921e-02f, -6.55208305e-02f, 1.03328660e-01f, 7.30514899e-02f, -6.55019581e-02f, -6.35448396e-02f, 1.10118911e-01f,
  -7.89910257e-02f, -3.30662839e-02f, 1.63943432e-02f, -5.62022999e-03f, -1.10120967e-01f, 3.92775051e-02f, 2.31622383e-02f, 5.63228838e-02f, -2.53051575e-02f, 2.83034276e-02f,
  8.96359310e-02f, 8.74739289e-02f, 8.32324997e-02f, 1.18447311e-01f, -4.01165523e-02f, 8.73052627e-02f, -8.76601972e-03f, -5.32184467e-02f, -7.39819929e-02f, -3.73699777e-02f,
  2.43050344e-02f, -6.16498888e-02f, -5.98622449e-02f, -1.47985052e-02f, -5.99220693e-02f, 5.64443059e-02f, 1.16590828e-01f, -1.31590012e-02f, 6.10545911e-02f, -5.52256443e-02f,
  -3.49976420e-02f, 8.27607960e-02f, -6.24589175e-02f, 2.10952610e-02f, -7.34253302e-02f, 4.30451520e-02f, 2.56653018e-02f, 6.42268658e-02f, 9.11666229e-02f, -3.92242335e-03f,
  -2.94258911e-03f, -2.31230669e-02f, -2.68691052e-02f, -1.43281356e-01f, -1.74717978e-02f, 5.04723303e-02f, -1.33001462e-01f, -5.61441183e-02f, -1.58414841e-01f, -1.66009814e-01f,
  9.54361558e-02f, 8.31453279e-02f, -1.16381042e-01f, 5.59853390e-02f, -1.11488447e-01f, 1.15886154e-02f, 7.61045292e-02f, 7.50919208e-02f, -2.23507546e-02f, -5.37776574e-02f,
  1.64229539e-03f, -4.34502847e-02f, 5.20118400e-02f, -5.54167256e-02f, -6.79893373e-03f, -4.37902100e-02f, -9.99725908e-02f, -7.96393827e-02f, -1.69284850e-01f, -6.84681907e-02f,
  1.91876113e-01f, 3.41994911e-02f, -1.07306793e-01f, -9.54495296e-02f, -4.31944430e-02f, 1.34825557e-01f, 1.08549543e-01f, 9.86297056e-02f, 1.41865820e-01f, -6.35824502e-02f,
  -2.35392363e-03f, 1.22954130e-01f, -8.87749717e-02f, 2.07971781e-02f, -7.91597739e-02f, -6.32936582e-02f, 5.34097850e-02f, 3.15898061e-02f, -2.49122176e-03f, -2.48076562e-02f,
  -6.78725690e-02f, 1.64013907e-01f, 3.42954346e-03f, -2.06468944e-02f, 5.18805627e-03f, 3.38874012e-02f, 3.25395130e-02f, 7.48078600e-02f, -1.50523245e-01f, -2.28770003e-02f,
  1.14262477e-01f, -4.27840389e-02f, -7.84904603e-03f, 2.24571209e-02f, 1.54170804e-02f, -4.47480045e-02f, 1.17136732e-01f, -1.27439737e-01f, 3.82168256e-02f, 1.57717534e-03f,
  -7.11401775e-02f, 7.68150017e-02f, 1.90328399e-03f, 1.16595544e-03f, 4.00914252e-02f, 3.80581208e-02f, -6.87499568e-02f, -5.03464490e-02f, -3.28492597e-02f, 6.52668253e-02f,
  1.48718525e-02f, -8.63181949e-02f, 1.23050809e-02f, 7.85352215e-02f, -8.56412277e-02f, 8.36071149e-02f, -1.28316041e-02f, 5.32069765e-02f, 1.88510210e-04f, -1.10671841e-01f,
  -5.78362942e-02f, 9.09542143e-02f, 7.85700381e-02f, 5.33420444e-02f, 5.43509945e-02f, -9.37195960e-03f, -7.32337162e-02f, 1.22510281e-03f, -2.23258752e-02f, -2.19660792e-02f,
  -1.00447565e-01f, 4.59390581e-02f, 2.83914655e-02f, -2.54589729e-02f, 5.68976440e-02f, -7.63192847e-02f, -6.74300827e-03f, 8.52121040e-02f, -6.46413639e-02f, -1.04877755e-01f,
  -3.33201103e-02f, 8.77581909e-03f, 6.64797425e-02f, 4.01339121e-02f, 1.05521522e-01f, 3.36288996e-02f, -8.35694149e-02f, -9.54209045e-02f, -8.35817903e-02f, -6.86314851e-02f,
  5.39623387e-02f, -2.26345919e-02f, -8.22243616e-02f, 4.07978743e-02f, -3.12470384e-02f, 5.63421566e-03f, 4.04456928e-02f, -7.72785991e-02f, 8.18566233e-02f, -2.35145781e-02f,
  7.37610757e-02f, -8.40225145e-02f, -1.30042255e-01f, 1.17227167e-01f, 1.12340331e-01f, -1.25693098e-01f, -6.09458350e-02f, -4.51375991e-02f, -1.17497109e-02f, 9.91374627e-02f,
  8.07210431e-02f, 6.25845641e-02f, 8.62696767e-03f, -5.98001517e-02f, -1.04671843e-01f, -6.03070594e-02f, -4.89410833e-02f, -1.00512974e-01f, -6.22137338e-02f, 5.39250486e-02f,
  -4.96045761e-02f, -3.62730622e-02f, -1.16692863e-01f, 7.10970759e-02f, -8.22657943e-02f, -3.33175957e-02f, -8.79064277e-02f, -1.44271284e-01f, 3.71656641e-02f, -1.23791665e-01f,
  1.12386353e-01f, -1.00755058e-01f, 6.57434687e-02f, 7.16252311e-04f, 8.67807493e-02f, 1.65848300e-01f, 3.42135541e-02f, 5.29174414e-03f, 3.20993029e-02f, 3.78861837e-02f,
  4.68153972e-03f, -5.77693395e-02f, -5.52786440e-02f, 3.24220061e-02f, -4.11869353e-03f, 4.90228124e-02f, 8.09616894e-02f, -8.43154788e-02f, 1.13220446e-01f, 8.01750571e-02f,
  6.31796941e-02f, 1.56803608e-01f, -1.52808083e-02f, 6.66870316e-03f, -3.99091803e-02f, 4.01450787e-03f, -9.50388014e-02f, 6.60475716e-02f, -2.91305613e-02f, -3.00141908e-02f,
  4.01454605e-02f, 5.20699993e-02f, 8.89469609e-02f, 9.85876843e-02f, -1.04663251e-02f, 9.79326945e-03f, 1.60531208e-01f, 4.05202955e-02f, -1.15362339e-01f, -1.05561428e-01f,
  -1.05700754e-02f, -8.95895734e-02f, -4.98545691e-02f, 5.81605919e-03f, 7.47015029e-02f, -1.39418487e-02f, 3.96893509e-02f, 7.77548458e-03f, -2.17859671e-02f, -9.80914086e-02f,
  6.58288971e-02f, -8.02334696e-02f, -6.12115972e-02f, -4.33329865e-02f, -1.39858395e-01f, -1.59650613e-02f, -8.11629649e-03f, -3.88058499e-02f, -3.17582861e-02f, 3.24572735e-02f,
  -1.78072117e-02f, -4.08700928e-02f, -4.64351960e-02f, -7.91525915e-02f, 3.53789963e-02f, 8.65493938e-02f, -4.39724810e-02f, -2.93211397e-02f, -6.35906011e-02f, -7.50254048e-03f,
  -1.07613079e-01f, -1.89953297e-02f, -1.78422015e-02f, -4.62274849e-02f, -8.03680047e-02f, -1.16408244e-02f, 5.09030111e-02f, 3.79261468e-03f, 2.18658848e-03f, -7.47992769e-02f,
  -6.80226609e-02f, 2.57565826e-03f, -8.09624512e-03f, -5.77190928e-02f, -8.74232128e-02f, 6.16563112e-02f, -1.41745219e-02f, 5.75502329e-02f, -2.11373363e-02f, -1.46529516e-02f,
  -2.48087402e-02f, -2.94075310e-02f, 2.10137255e-02f, 5.46047166e-02f, -2.52996515e-02f, -3.78289670e-02f, -1.30377382e-01f, -9.07492042e-02f, -7.33128190e-02f, 2.47305837e-02f,
  1.61849529e-01f, -2.09256206e-02f, 2.32288033e-01f, -3.32278609e-02f, 2.29433831e-02f, 3.93237127e-03f, -3.03903818e-02f, -4.23200876e-02f, -7.08447993e-02f, 2.67646499e-02f,
  1.14301682e-01f, -4.80665751e-02f, -5.03255688e-02f, -1.39642999e-01f, -8.20222944e-02f, -6.50546029e-02f, -5.81169559e-04f, 1.01502035e-02f, 1.24117404e-01f, 2.35165693e-02f,
  6.46747500e-02f, 3.46992426e-02f, 2.45643370e-02f, 2.46380791e-02f, 1.58816114e-01f, -1.93180129e-01f, -8.23459029e-02f, 2.74066739e-02f, -1.35430679e-01f, -1.32391125e-01f,
  -5.72571605e-02f, 1.07679069e-01f, -8.72875676e-02f, 2.19811238e-02f, -1.04908675e-01f, -1.02533977e-02f, -5.48571302e-03f, -1.01221465e-01f, -1.58059344e-01f, 1.00722052e-01f,
  1.01736672e-01f, -1.28135026e-01f, -3.16845700e-02f, 4.79510128e-02f, 2.57151257e-02f, -2.52509583e-02f, 6.48203567e-02f, -2.75574941e-02f, 8.70997831e-02f, -1.43982187e-01f,
  5.56115992e-02f, -7.63168037e-02f, 2.45131757e-02f, -1.12541758e-01f, 1.28775919e-02f, 7.03348294e-02f, -7.22693279e-02f, -5.80525808e-02f, -6.55561462e-02f, -2.47685071e-02f,
  7.11594895e-02f, -6.69712201e-02f, -7.17917574e-04f, 1.75408162e-02f, 1.63270533e-02f, -3.85281779e-02f, -2.98992079e-02f, 5.72007615e-03f, -5.64772710e-02f, -5.93646150e-03f,
  -4.01562732e-03f, -2.88831219e-02f, -7.43324384e-02f, -2.86423024e-02f, 4.68326844e-02f, 5.48814423e-02f, -8.05884600e-02f, 4.51883785e-02f, 5.15670292e-02f, 6.67956322e-02f,
  1.15494996e-01f, -1.00576930e-01f, 2.45973188e-02f, -6.62566349e-02f, 8.37423056e-02f, -7.55632445e-02f, 4.16796878e-02f, -7.42605254e-02f, -8.58967938e-03f, -2.77507957e-02f,
  5.86280972e-03f, -5.07568978e-02f, -6.27178773e-02f, -2.59171356e-03f, 2.54085194e-02f, 7.60967284e-02f, -8.25367048e-02f, 4.09053341e-02f, 8.76293257e-02f, -7.65236914e-02f,
  1.17201973e-02f, -3.84488925e-02f, -1.77814290e-02f, -1.29808769e-01f, -1.20709240e-02f, -3.91914397e-02f, -3.80078480e-02f, -8.49092305e-02f, 5.73185757e-02f, -5.66278845e-02f,
  -6.26327842e-02f, 7.04287663e-02f, -6.56785294e-02f, 3.17494981e-02f, -8.55603069e-02f, 5.66557311e-02f, 2.99640335e-02f, -8.49328041e-02f, 3.99391390e-02f, 1.84566155e-02f,
  -5.80231324e-02f, -6.31525069e-02f, 1.69676319e-02f, 6.34143725e-02f, -1.71188656e-02f, -9.80131030e-02f, -2.55252291e-02f, -5.99843673e-02f, 1.84848309e-01f, -1.44562855e-01f,
  1.37710616e-01f, -1.73644230e-01f, -5.03215529e-02f, 1.36130735e-01f, -1.64009910e-02f, 1.40880600e-01f, -5.71345910e-02f, -4.97672614e-03f, -1.61439441e-02f, 6.37692958e-02f,
  -1.84150692e-02f, 5.27761318e-02f, 1.73007414e-01f, -2.93026548e-02f, 1.76384330e-01f, -1.06431939e-01f, -1.92249392e-03f, -2.99416855e-02f, 1.46656096e-01f, -1.02091394e-01f,
  8.35224316e-02f, -5.81556633e-02f, -8.29415768e-03f, -6.62755519e-02f, 5.90080693e-02f, 1.18187495e-01f, -7.91259259e-02f, -4.95125279e-02f, -1.74919311e-02f, 1.02156423e-01f,
  -1.70828283e-01f, -1.52369350e-01f, 3.42022330e-02f, -9.12276730e-02f, -7.19778016e-02f, -9.73728076e-02f, 3.22601981e-02f, 5.02882525e-02f, 2.08935603e-01f, -3.86081897e-02f,
  -1.27667725e-01f, -4.47936915e-02f, -9.11292285e-02f, -6.40800744e-02f, 4.51268144e-02f, -1.39126316e-01f, 9.80247036e-02f, -1.41713321e-01f, 9.57243964e-02f, -1.13116413e-01f,
  -1.36030177e-02f, 5.57400985e-03f, 3.55574638e-02f, -5.95185198e-02f, 1.80706345e-02f, -2.34939996e-02f, -2.03786753e-02f, 5.38591202e-03f, 3.49066034e-02f, -7.18266368e-02f,
  1.68031044e-02f, -9.60303769e-02f, -1.44071430e-01f, 4.70664203e-02f, 3.61809470e-02f, 7.28392825e-02f, -4.45686840e-03f, 4.20717373e-02f, 6.61063269e-02f, -1.27984792e-01f,
  6.23615161e-02f, 6.88503534e-02f, -6.84194490e-02f, -1.61972307e-02f, -3.55958045e-02f, -1.11824095e-01f, 2.56788954e-02f, -4.59671505e-02f, 3.92631479e-02f, -8.10537189e-02f,
  -1.51969463e-01f, 3.72299924e-03f, -3.07731442e-02f, -1.16313361e-01f, -4.16899808e-02f, -2.16041356e-02f, -1.03953891e-01f, 4.19757366e-02f, 1.49510987e-02f, -1.30564962e-02f,
  8.48180875e-02f, -2.76746316e-04f, -6.69731200e-02f, -3.99723537e-02f, 1.21672098e-02f, 6.65369928e-02f, 4.33623008e-02f, -3.55378836e-02f, 2.45627221e-02f, 8.65917876e-02f,
  -1.05587520e-01f, -6.41507562e-03f, -1.02847274e-02f, 7.46011436e-02f, 4.52688225e-02f, -7.95293301e-02f, -5.35527989e-02f, -8.41953009e-02f, 1.06984124e-01f, -9.99347568e-02f,
  -5.13049327e-02f, 4.91723530e-02f, -9.07744914e-02f, -7.04564974e-02f, -2.22345907e-02f, -4.74716425e-02f, -5.31002600e-03f, -4.67086583e-02f, -4.82272506e-02f, 2.50431523e-02f,
  2.19167322e-02f, -2.42955051e-02f, -7.66881406e-02f, -1.50628509e-02f, 6.99638426e-02f, -9.72993225e-02f, 1.15069486e-01f, -8.52797478e-02f, 1.83450595e-01f, 4.18819971e-02f,
  1.12576000e-01f, 1.20612510e-01f, 9.37733054e-03f, 6.35995120e-02f, -5.03079556e-02f, -5.45635493e-03f, 1.35002986e-01f, -1.64038852e-01f, -1.22022830e-01f, -5.62463999e-02f,
  -1.09270059e-01f, -9.19925198e-02f, -5.03299832e-02f, 9.46992636e-02f, 6.00731820e-02f, 3.55224386e-02f, -2.17372756e-02f, -7.45109245e-02f, -1.00678846e-01f, 1.17207505e-02f,
  9.55431163e-02f, -1.01993352e-01f, -2.92856600e-02f, 6.27904981e-02f, -7.28418604e-02f, -1.44325897e-01f, -9.92028322e-03f, 9.91747454e-02f, -8.72173086e-02f, 3.06383334e-02f,
  -8.80016387e-02f, -6.49198741e-02f, -4.40092646e-02f, -1.74827829e-01f, -1.74886495e-01f, 1.63966611e-01f, 1.12654254e-01f, -5.72956987e-02f, 1.11192903e-02f, 8.24700594e-02f,
  1.50939718e-01f, -1.22377984e-01f, 8.75982493e-02f, -1.49586856e-01f, 2.01533027e-02f, -1.38952702e-01f, 3.48566361e-02f, -1.11728065e-01f, -6.17067181e-02f, -7.96096846e-02f,
  2.16393471e-02f, -5.33822924e-02f, 4.00783978e-02f, -1.05813377e-01f, -5.67127503e-02f, 1.14067877e-02f, -8.86445567e-02f, 1.40424073e-02f, -2.84734811e-03f, 3.34216394e-02f,
  -7.99233243e-02f, 5.11772651e-03f, -8.34342316e-02f, 9.21068341e-02f, 4.14836816e-02f, 5.89521974e-02f, 4.96349297e-02f, -2.83441097e-02f, 4.30295169e-02f, -2.16909423e-02f,
  2.43297499e-02f, -2.67491471e-02f, 4.96311188e-02f, -8.08790475e-02f, 4.58004326e-02f, 1.05677180e-01f, -6.13654666e-02f, 2.45242361e-02f, -1.49976350e-02f, -3.51734459e-02f,
  7.60060623e-02f, 3.62812951e-02f, 1.03735197e-02f, 4.31795530e-02f, 1.93368495e-02f, 3.28591987e-02f, -6.86662039e-03f, 9.90250707e-02f, -5.93762398e-02f, -1.33083882e-02f,
  1.78684201e-03f, 1.26596785e-03f, -7.62568861e-02f, -5.50385378e-03f, 2.01865416e-02f, 1.72765385e-02f, 8.13578069e-02f, -1.79402567e-02f, 1.81725267e-02f, -7.89975375e-02f,
  -5.28157093e-02f, -2.82768570e-02f, -3.76382358e-02f, -6.48287982e-02f, -4.13039103e-02f, -1.09965410e-02f, -4.56053354e-02f, 6.47654524e-03f, 7.49953017e-02f, -7.35530630e-02f,
  -1.46957353e-01f, -1.68096963e-02f, -3.13168019e-02f, -3.37221697e-02f, 4.07236069e-02f, -8.62229466e-02f, 1.07903317e-01f, -4.44203354e-02f, -4.95505221e-02f, -3.63992341e-02f,
  -5.72934784e-02f, 5.48035055e-02f, -3.77171934e-02f, -1.17361300e-01f, -9.75523144e-02f, -1.67362839e-01f, -1.00972271e-03f, 8.15809146e-03f, -2.47696735e-04f, -3.26890708e-03f,
  -1.63740173e-01f, 1.77877456e-01f, 5.55533022e-02f, -3.15301567e-02f, 1.13198645e-01f, 5.08784205e-02f, -1.34407341e-01f, 8.86876285e-02f, 7.46154273e-03f, -1.90108582e-01f,
  -3.05665191e-02f, 1.15491323e-01f, 6.22938238e-02f, -1.66463941e-01f, 1.43888026e-01f, -1.58790108e-02f, -1.89727142e-01f, 5.08919917e-02f, -1.10821947e-02f, -1.27755448e-01f,
  6.20237701e-02f, -6.67397082e-02f, -1.45459831e-01f, -1.11231627e-03f, -1.31846011e-01f, 2.02453241e-01f, -2.75411680e-02f, -1.22476786e-01f, -1.00631908e-01f, -1.10416003e-02f,
  1.57090768e-01f, -7.61464313e-02f, -4.65921946e-02f, -1.62495613e-01f, -5.54814152e-02f, -9.07875597e-02f, -7.50537515e-02f, 2.01450121e-02f, -1.04965501e-01f, 1.69375181e-01f,
  7.03906044e-02f, 1.46882504e-01f, 1.34885624e-01f, -1.31920695e-01f, 1.34211266e-02f, 2.32718606e-02f, 1.58799887e-01f, -1.32628962e-01f, -9.24631357e-02f, 5.99729605e-02f,
  -6.72791749e-02f, -1.18718244e-01f, -1.10059813e-01f, 4.10214961e-02f, -2.95928381e-02f, 2.32773693e-03f, -2.33958233e-02f, 8.13359208e-03f, 3.07779614e-04f, -5.79184070e-02f,
  -8.72941688e-02f, -4.41534705e-02f, -1.13797940e-01f, -7.58074038e-03f, -1.46600362e-02f, -1.69949122e-02f, 1.72851495e-02f, 5.86957578e-03f, -7.95703530e-02f, 3.37568671e-02f,
  -5.35167307e-02f, 5.50120547e-02f, 9.33562964e-02f, 1.77260619e-02f, 3.60220647e-03f, 1.00696450e-02f, 1.58756506e-02f, -3.30545940e-02f, 1.67410001e-02f, 5.14768586e-02f,
  1.66001599e-02f, -6.66212663e-03f, 7.68439397e-02f, 6.08632006e-02f, -5.44538582e-03f, 5.63228615e-02f, -5.19573092e-02f, -8.16216841e-02f, -1.03920407e-03f, 7.80877918e-02f,
  -7.05451816e-02f, 1.09238900e-01f, -3.72817144e-02f, -1.32686170e-02f, 8.36783722e-02f, -4.67281044e-02f, -8.32820013e-02f, -6.16227761e-02f, 1.36591904e-02f, -8.23876485e-02f,
  7.72509957e-03f, -7.34811649e-02f, -7.32973544e-03f, 2.05205437e-02f, 1.14739113e-01f, 5.43383881e-03f, -4.36682925e-02f, 6.07119612e-02f, 7.34105110e-02f, -7.38739222e-03f,
  7.19170645e-02f, -1.23337647e-02f, -5.07856198e-02f, 9.81123820e-02f, 6.78768754e-02f, 4.99268509e-02f, -6.00502230e-02f, 6.89423755e-02f, -3.13669629e-02f, -1.04374737e-01f,
  5.16235009e-02f, 4.86786626e-02f, -1.36017695e-01f, 1.40616521e-01f, -1.05002217e-01f, 8.08570627e-03f, 5.22960871e-02f, -8.48786831e-02f, 1.63249746e-01f, 6.88579455e-02f,
  -5.02507724e-02f, -6.86597154e-02f, 6.62716106e-02f, 6.56002909e-02f, 7.11906329e-02f, -1.10630020e-01f, 1.66807941e-03f, 2.34953891e-02f, 1.00675084e-01f, -3.63893956e-02f,
  -1.94582883e-02f, -4.85570665e-04f, -1.27470195e-01f, -7.70032853e-02f, 1.77419305e-01f, -1.12911947e-01f, -6.52497858e-02f, 7.62838200e-02f, -3.23298760e-02f, -1.19160622e-01f,
  -6.26838654e-02f, 1.04388427e-02f, 3.17009650e-02f, -1.35175020e-01f, -1.43458489e-02f, 2.38561898e-01f, -7.25162327e-02f, -5.40038869e-02f, -9.01783630e-02f, -3.68924849e-02f,
  -7.71620646e-02f, -1.56158924e-01f, 1.27222454e-02f, 4.86313030e-02f, 9.74665061e-02f, -6.52413145e-02f, 3.86368558e-02f, -4.37471494e-02f, 7.69077102e-03f, -1.10336564e-01f,
  1.32828010e-02f, 1.57875046e-01f, -2.18324997e-02f, 1.00619132e-02f, 1.16176624e-02f, -6.00897819e-02f, -1.76630914e-02f, -1.06682638e-02f, 1.53968586e-02f, -8.93367976e-02f,
  6.38620555e-02f, -4.76960875e-02f, 3.69552262e-02f, 3.53359506e-02f, 8.61461982e-02f, -4.09333259e-02f, 3.06623932e-02f, -1.62232388e-02f, 6.62504556e-03f, 5.95417880e-02f,
  1.31700307e-01f, -1.08933914e-02f, -1.34436876e-01f, 2.09261198e-02f, -7.97149390e-02f, -7.83094838e-02f, 6.11932576e-02f, -1.00498147e-01f, -5.43959178e-02f, 6.52772933e-02f,
  -2.94168163e-02f, -3.77187412e-03f, -1.38457334e-02f, -7.79274851e-02f, 5.85680380e-02f, 3.32859270e-02f, 4.81621325e-02f, -4.69610728e-02f, 4.02585454e-02f, -8.57864395e-02f,
  4.00577523e-02f, -2.02735886e-03f, -1.55451605e-02f, -4.28130589e-02f, 1.43085718e-02f, -8.28839317e-02f, 3.84012535e-02f, 8.08655545e-02f, -3.37423719e-02f, 6.57799989e-02f,
  -8.38337392e-02f, -6.19686693e-02f, 8.73321295e-02f, 1.26156658e-02f, 9.10111889e-02f, -7.11992057e-03f, 1.81975458e-02f, -5.65016083e-02f, 1.29289022e-02f, -7.33488873e-02f,
  -4.72078705e-03f, -2.22150330e-02f, 4.40968759e-02f, 5.96046411e-02f, -5.19110635e-02f, 2.04005316e-02f, -6.99549839e-02f, 9.56447795e-02f, 3.19748768e-03f, -6.95744976e-02f,
  -3.27316895e-02f, 1.74497813e-02f, 5.58898337e-02f, 6.52897209e-02f, -3.07566281e-02f, -8.40341970e-02f, 2.33848603e-03f, -1.77479372e-03f, 8.60946625e-02f, 1.05159998e-01f,
  -7.64708593e-02f, 4.86841910e-02f, -1.06746279e-01f, -1.27544776e-01f, -6.41146302e-02f, 1.60345417e-02f, 1.37353450e-01f, -9.85602140e-02f, -4.11822163e-02f, -8.16932321e-03f,
  -4.97252755e-02f, 3.58529054e-02f, 1.68499239e-02f, 6.80339038e-02f, 5.68272136e-02f, 3.52603123e-02f, -1.14236057e-01f, 5.84420376e-02f, -1.17903225e-01f, 1.35528743e-01f,
  -1.33925647e-01f, -8.22658986e-02f, -8.91526639e-02f, -4.46207792e-04f, -1.26501590e-01f, -1.28812180e-03f, 9.42035690e-02f, -2.87364759e-02f, 1.09551691e-01f, -3.66200581e-02f,
  5.33805713e-02f, -5.93215041e-02f, 8.34536031e-02f, -3.53488931e-03f, 7.94902146e-02f, 9.91293415e-02f, -1.49880080e-02f, 8.40407982e-02f, -3.80164571e-03f, 5.09100109e-02f,
  -7.07264617e-02f, 5.81193082e-02f, 8.73655230e-02f, 5.97562045e-02f, -2.00379323e-02f, -8.59999880e-02f, 6.53457195e-02f, 8.05412903e-02f, -9.35492218e-02f, 8.35028570e-03f,
  2.09603272e-02f, 1.85812470e-02f, -3.92629765e-03f, 3.75081971e-02f, -6.38934746e-02f, -5.42685837e-02f, 4.49975878e-02f, -4.99543436e-02f, -5.00058336e-03f, 8.82414505e-02f,
  -3.13620977e-02f, -4.96330187e-02f, -1.09380344e-02f, 3.72119509e-02f, 1.69934649e-02f, -6.36208206e-02f, 6.59307837e-02f, -8.69905725e-02f, 7.62036741e-02f, -9.07816812e-02f,
  -1.79656883e-04f, 1.02637224e-01f, -2.65243035e-02f, 9.82422382e-02f, -8.01550969e-02f, 5.11158518e-02f, -5.94487078e-02f, 2.93633211e-02f, 5.67521155e-02f, -2.36274153e-02f,
  1.50144398e-02f, 4.23150845e-02f, -5.89332283e-02f, 3.01409289e-02f, -9.63406339e-02f, 8.40421766e-02f, 4.49424833e-02f, -1.89048164e-02f, 2.77604675e-03f, -2.29838416e-02f,
  -5.90392249e-03f, -4.84929904e-02f, 6.75213430e-03f, 5.19791283e-02f, 5.12406603e-02f, -7.57134035e-02f, -4.08402197e-02f, 2.43093446e-02f, -3.60723166e-03f, 5.43823466e-02f,
  -2.13299021e-02f, -6.35884330e-02f, -1.13732718e-01f, 2.21273256e-03f, 6.45306483e-02f, -5.92884794e-02f, 3.61392200e-02f, -6.46027178e-02f, 7.86657352e-03f, -3.06596979e-02f,
  1.00080311e-01f, -8.49089995e-02f, 4.08633538e-02f, 2.66147293e-02f, -9.43822786e-02f, -1.06209926e-01f, -3.43724675e-02f, 5.09467945e-02f, -4.58573140e-02f, 1.45420535e-02f,
  -5.36965318e-02f, 3.62671586e-03f, 5.53494468e-02f, -1.96504369e-02f, -1.03733152e-01f, 1.52008533e-02f, 3.09748445e-02f, 2.14916244e-02f, -2.74410639e-02f, -1.32553354e-01f,
  1.08061388e-01f, -1.18418634e-01f, -3.55902058e-03f, -1.36610707e-02f, -7.19143599e-02f, 1.08094454e-01f, -3.67217846e-02f, 5.65596074e-02f, -8.32223222e-02f, -5.21611981e-02f,
  -5.29523827e-02f, 9.83283594e-02f, 1.40585527e-01f, -9.99293178e-02f, 2.06312731e-01f, -1.45960882e-01f, 1.26215473e-01f, 1.22362832e-02f, 2.26483569e-02f, 2.50967611e-02f,
  -5.81391249e-03f, -4.93334271e-02f, -1.35079607e-01f, -9.65560526e-02f, 2.34600324e-02f, -5.42111583e-02f, -1.57558709e-01f, -1.49810286e-02f, -9.03885886e-02f, 1.20175704e-01f,
  -8.16749409e-02f, -6.39164224e-02f, 5.03860526e-02f, 1.13052074e-02f, 9.77504030e-02f, -1.94264650e-01f, 9.81504098e-03f, -6.06444590e-02f, 1.84844956e-01f, 2.97475234e-02f,
  -1.09061480e-01f, -1.46040559e-01f, -4.44211215e-02f, -5.15857525e-02f, 5.05980738e-02f, -3.58295366e-02f, 1.71636194e-02f, -8.10844004e-02f, 2.61318479e-02f, -5.75796366e-02f,
  6.47185296e-02f, 6.91713840e-02f, 9.79650319e-02f, -1.14705823e-02f, -7.95639679e-03f, -2.37706900e-02f, -6.88248649e-02f, -7.17677772e-02f, -5.13660274e-02f, -8.11387412e-03f,
  1.60758421e-02f, -1.59553260e-01f, -7.17723146e-02f, 8.47275928e-03f, -3.89707945e-02f, 4.68002446e-02f, -1.29380962e-02f, 1.11114703e-01f, 1.52073391e-02f, -1.49480134e-01f,
  4.17807549e-02f, -8.03635716e-02f, -3.12323514e-02f, -7.63647929e-02f, 9.27355513e-02f, -2.91610304e-02f, -2.82932911e-02f, 8.68658274e-02f, -1.01230122e-01f, 4.49952781e-02f,
  7.08553940e-02f, 2.63508726e-02f, 9.74862650e-02f, 2.38299500e-02f, 6.38260245e-02f, 2.66132760e-03f, -6.42987341e-02f, 6.55014962e-02f, -1.05684705e-01f, -6.35434538e-02f,
  3.96209583e-02f, 7.05499500e-02f, 8.69796276e-02f, 2.01824531e-02f, 5.90884034e-03f, 2.64446978e-02f, -6.69754073e-02f, 7.76914209e-02f, 4.73738015e-02f, 3.69485579e-02f,
  9.57951248e-02f, 3.77401290e-03f, 5.43585159e-02f, -3.81803960e-02f, 4.88635413e-02f, -4.26749326e-03f, 1.56673059e-01f, 8.54314398e-03f, -4.65904921e-02f, -1.01658717e-01f,
  2.76345052e-02f, -8.15873221e-02f, 9.58293863e-03f, 4.35870029e-02f, 1.23466980e-02f, 9.10081491e-02f, -3.29024978e-02f, -9.81661305e-03f, -1.89606864e-02f, -2.69779540e-03f,
  4.29637805e-02f, 1.61324500e-03f, 6.75167143e-02f, 3.02429777e-02f, -3.47347856e-02f, -1.30336538e-01f, -1.20366126e-01f, -1.21065684e-01f, 1.72209471e-01f, -4.00745757e-02f,
  1.78874861e-02f, -1.69050545e-01f, -1.04697265e-01f, 1.51610717e-01f, 1.49765294e-02f, 8.16203728e-02f, 1.18644379e-01f, 1.20241493e-01f, -9.89340395e-02f, 4.74856384e-02f,
  -4.97968271e-02f, -1.72353163e-01f, 4.16158959e-02f, 1.23173110e-01f, 1.71338581e-02f, -9.70381964e-03f, 7.81353787e-02f, -1.08117715e-03f, -9.11214799e-02f, 1.14004508e-01f,
  -1.53579041e-01f, -4.74760914e-03f, 3.73743549e-02f, -1.90267153e-02f, -1.70864910e-01f, -1.64575547e-01f, -4.78763171e-02f, 2.33082231e-02f, -1.03928767e-01f, 3.04185189e-02f,
  -2.06239790e-01f, 9.45440084e-02f, 1.65555850e-01f, 9.46833566e-02f, -1.36361361e-01f, -2.85726916e-02f, -1.65285170e-01f, -5.27867936e-02f, 1.84687227e-02f, 1.90871879e-02f,
  -1.11101963e-01f, 1.15835220e-01f, -4.68605012e-03f, 1.24303460e-01f, 6.42323047e-02f, -7.70213753e-02f, 7.12381825e-02f, -1.94778536e-02f, 1.05434395e-01f, -4.78275940e-02f,
  -1.15539804e-02f, -3.72739253e-03f, -1.11107089e-01f, 5.35554960e-02f, 4.37016003e-02f, -6.92423284e-02f, 1.29545433e-02f, 1.77694634e-02f, -8.27495754e-02f, -2.80396789e-02f,
  7.93928280e-02f, -1.26972944e-01f, -1.22119188e-01f, -1.37492670e-02f, -9.09251571e-02f, -8.82571638e-02f, 3.62265259e-02f, -1.16101643e-02f, -1.02658555e-01f, -7.18686283e-02f,
  -5.68035729e-02f, -1.99660640e-02f, 4.19878922e-02f, 3.36698368e-02f, 6.67610690e-02f, 6.37184456e-02f, -4.51697297e-02f, 1.45403920e-02f, 1.16960824e-01f, -5.77271357e-02f,
  6.37815297e-02f, -4.71112095e-02f, 4.88446765e-02f, 8.45202804e-03f, 8.18661973e-02f, -3.37596908e-02f, -5.22033200e-02f, 1.89868305e-02f, 1.34816946e-04f, 7.41605014e-02f,
  -7.54728913e-02f, 7.61354640e-02f, -1.32095963e-02f, -1.61055028e-02f, -6.38237875e-03f, -9.37053747e-03f, -1.20048439e-02f, 2.56165396e-02f, 4.82849739e-02f, 8.73404965e-02f,
  -9.72962379e-03f, -1.03298128e-02f, 2.82370187e-02f, 6.14493825e-02f, 7.19138905e-02f, -3.27699184e-02f, 1.58795416e-02f, -3.66005860e-02f, 3.75283957e-02f, 4.51625735e-02f,
  -4.66122031e-02f, 4.46599722e-02f, 8.35756138e-02f, 1.06247738e-01f, 5.73609434e-02f, -8.18579718e-02f, 7.11911544e-03f, -2.47459747e-02f, -3.20216827e-02f, -1.44164534e-02f,
  1.52050361e-01f, 3.54624949e-02f, 1.11155882e-01f, -1.16293654e-01f, -1.18846536e-01f, -8.84394050e-02f, 5.82070239e-02f, 1.34729231e-02f, 1.71383861e-02f, 3.94809358e-02f,
  -1.30379453e-01f, -4.41115499e-02f, 1.01976089e-01f, -1.27299391e-02f, -5.44734038e-02f, 9.53785479e-02f, -1.07625365e-01f, 1.10641316e-01f, 8.92617553e-02f, 1.11780278e-01f,
  3.07597369e-02f, 1.74582601e-01f, -6.28343597e-02f, -3.22746187e-02f, 1.09515674e-01f, -4.20120321e-02f, -3.14435475e-02f, 1.45720378e-01f, -3.85889448e-02f, 4.48950678e-02f,
  6.91353828e-02f, 2.66954992e-02f, 5.11243157e-02f, 1.46269456e-01f, 6.36342317e-02f, 3.16844434e-02f, -4.00252342e-02f, -4.61305901e-02f, -7.92515650e-03f, 9.62017700e-02f,
  1.34910960e-02f, 1.07824460e-01f, 9.42582861e-02f, -4.93385606e-02f, 9.51317511e-03f, -6.12026565e-02f, -1.15311623e-01f, -5.33727147e-02f, -9.95887890e-02f, 1.15036353e-01f,
  -4.50592861e-02f, 3.12104411e-02f, 8.57999697e-02f, -7.43602440e-02f, 5.13560884e-02f, -1.21438958e-01f, 9.52872336e-02f, -6.82059955e-03f, 3.50718759e-02f, 5.26669919e-02f,
  7.65125006e-02f, -1.47745088e-01f, -2.29715835e-02f, 4.81397435e-02f, -7.79496953e-02f, -2.25844719e-02f, 4.40735836e-03f, 3.86748873e-02f, 7.99030215e-02f, -2.17861682e-02f,
  -1.19054597e-03f, -7.43366033e-02f, 9.27815447e-04f, -8.22037980e-02f, 5.68772778e-02f, 1.71002708e-02f, 3.74013820e-04f, -7.38063157e-02f, 5.10813221e-02f, 4.20819484e-02f,
  -3.55125288e-04f, -3.08670625e-02f, -8.39156657e-02f, 9.02417079e-02f, 4.80610877e-03f, 7.03583565e-03f, -2.04483327e-02f, -2.96803135e-02f, -5.17059863e-02f, 1.43241240e-02f,
  -8.70434344e-02f, -5.81137985e-02f, 9.69024152e-02f, 1.51684582e-02f, 3.42120463e-03f, 5.65073155e-02f, -6.06100336e-02f, -4.26513478e-02f, -5.64281307e-02f, 3.48574892e-02f,
  -2.50578802e-02f, -7.32370540e-02f, 6.92654923e-02f, 8.15385580e-02f, 8.70065987e-02f, -3.87622751e-02f, 4.94970083e-02f, -5.90755092e-03f, -1.50907971e-02f, -1.14019498e-01f,
  8.21199417e-02f, -4.69240621e-02f, 3.72059308e-02f, 3.26409265e-02f, -1.64057743e-02f, -6.50056154e-02f, -1.19510163e-02f, -7.25087523e-02f, 1.22312014e-03f, -2.84149796e-02f,
  1.24997646e-02f, 2.82828249e-02f, 4.85036895e-02f, 2.73421984e-02f, -5.92964441e-02f, -5.23684733e-03f, -3.44004147e-02f, -3.92701328e-02f, 2.19733380e-02f, 8.51875022e-02f,
  -3.10347956e-02f, -8.26545805e-02f, -1.34709895e-01f, -3.41487899e-02f, -1.60214961e-01f, 1.73966344e-02f, 7.35087786e-03f, 2.31724679e-02f, 5.21577448e-02f, 3.10185319e-03f,
  9.88196135e-02f, -4.86636162e-02f, 4.95116115e-02f, 9.90545303e-02f, -1.71911381e-02f, 5.27772047e-02f, -5.59012452e-03f, 3.65171768e-02f, 1.03997007e-01f, -3.66398394e-02f,
  -2.89971922e-02f, -1.49136409e-01f, -6.54182583e-02f, 1.15229860e-01f, -1.25157222e-01f, -3.61230858e-02f, -1.13283597e-01f, 7.82814026e-02f, 5.15492484e-02f, -1.87343627e-01f,
  4.68372665e-02f, 1.91737786e-02f, 1.34688199e-01f, -5.57832234e-02f, 5.19024767e-02f, 1.46140873e-01f, 3.50573696e-02f, -2.55772397e-02f, -1.03257239e-01f, 1.66177079e-01f,
  1.17666004e-02f, -1.00601606e-01f, -7.60955215e-02f, -1.63099524e-02f, -3.69762555e-02f, -1.07993782e-02f, -1.31194651e-01f, 1.43183216e-01f, -6.05281582e-03f, 1.49816886e-01f,
  -1.17590707e-02f, 9.41515267e-02f, -3.39969248e-02f, -4.44045439e-02f, 2.63398793e-02f, -4.15184023e-03f, -1.19537935e-01f, -3.39595117e-02f, -3.60933021e-02f, 3.09574604e-02f,
  1.09417280e-02f, 1.01270609e-01f, 4.20239605e-02f, 3.53406882e-03f, 3.65710631e-02f, -8.74841735e-02f, 2.30319444e-02f, 5.36105270e-03f, -1.40460872e-03f, -6.52085170e-02f,
  6.18148316e-03f, -6.30908385e-02f, 4.21488434e-02f, -3.01412437e-02f, -5.82912117e-02f, -6.55115843e-02f, -4.56121098e-03f, -3.92047167e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  -6.58809170e-02f, -5.95898069e-02f, -8.04856569e-02f, -5.70470579e-02f, -7.00695813e-03f, 3.54975127e-02f, -5.93146719e-02f, 2.47062650e-02f, 5.72183579e-02f, 1.87396184e-02f,
  5.22729903e-02f, 5.13028726e-02f, 5.30686416e-02f, -8.02632123e-02f, 7.25930408e-02f, -7.63807893e-02f, 3.21933292e-02f, 6.52101915e-03f, -7.41976574e-02f, -8.09327066e-02f,
  -6.96542189e-02f, -3.53846252e-02f, -3.63303497e-02f, -6.10207766e-02f, 2.64234561e-02f, -2.64086593e-02f, -7.72178918e-02f, -3.38609889e-02f, -1.82559136e-02f, 4.78088520e-02f,
  -3.85784544e-02f, 7.37890080e-02f, 7.41072744e-02f, -6.18656613e-02f, -1.03332680e-02f, -1.22528803e-02f, -8.18982050e-02f, -7.34536350e-02f, 6.37484773e-04f, -3.55910584e-02f,
  -6.24427982e-02f, 5.32818995e-02f, -8.28451142e-02f, 3.96467485e-02f, -5.88753223e-02f, -3.19376066e-02f, -4.00609598e-02f, -8.78584534e-02f, 4.43708450e-02f, -6.43393546e-02f,
  6.21425211e-02f, 7.56512508e-02f, -4.75052334e-02f, -4.46635634e-02f, -1.48822740e-02f, -4.78383005e-02f, 7.88678527e-02f, -1.00277867e-02f, -4.67571691e-02f, 6.62658960e-02f,
  -7.05722626e-03f, -6.88563436e-02f, 3.15303379e-03f, 6.59946427e-02f, -1.40076028e-02f, -8.53016749e-02f, -2.86082365e-02f, 3.67865302e-02f, 5.12228757e-02f, -3.65750715e-02f,
  6.86753541e-03f, -5.30253984e-02f, -7.47086555e-02f, -5.57815991e-02f, -1.69692989e-02f, -7.84158111e-02f, 2.92400215e-02f, -6.91910088e-02f, 5.05757481e-02f, -4.40789871e-02f,
  7.75522739e-02f, 6.51862994e-02f, -2.29957625e-02f, -5.79260886e-02f, -4.26821783e-02f, -5.91829158e-02f, -2.58494634e-02f, 4.24373336e-02f, -1.73734582e-03f, -1.08735189e-02f,
  3.10697872e-03f, 5.49332574e-02f, 5.19892201e-02f, -4.19420423e-03f, 4.87224013e-02f, 7.84560889e-02f, 1.79898255e-02f, -6.63843704e-03f, -4.79067676e-02f, -3.36641036e-02f,
  2.70920154e-02f, 8.83807540e-02f, -1.93081945e-02f, -1.57254059e-02f, 2.47278064e-02f, 7.85295442e-02f, 1.88479275e-02f, 7.73640126e-02f, -4.99004833e-02f, 5.67777120e-02f,
  -5.20702861e-02f, -8.27726349e-03f, -6.02088906e-02f, -1.12515027e-02f, -6.54965267e-02f, -8.64561722e-02f, 8.51938725e-02f, -2.54427269e-02f, -1.67939179e-02f, 5.39665371e-02f,
  -3.41892280e-02f, 4.22844291e-02f, 2.39670575e-02f, -2.25874484e-02f, -8.28017201e-03f, 1.70040745e-02f, 8.38852823e-02f, -2.46236026e-02f, 7.53722042e-02f, 5.93253821e-02f,
  -5.40958308e-02f, -8.44117552e-02f, -1.49727082e-02f, 8.46364871e-02f, 2.82032061e-02f, 6.83262423e-02f, -8.33309218e-02f, -4.97607850e-02f, 4.18221578e-02f, 4.84176688e-02f,
  1.04141692e-02f, 9.32340771e-02f, 1.11210927e-01f, -5.61874993e-02f, -6.32898733e-02f, -2.34602802e-02f, 3.71286683e-02f, 9.23594609e-02f, -5.87434098e-02f, -2.04792432e-02f,
  1.10781319e-01f, 1.53765073e-02f, -1.27271330e-02f, 4.23956141e-02f, -8.49057436e-02f, -2.13751830e-02f, 7.48757459e-03f, -6.30701780e-02f, 8.06855559e-02f, -5.38176261e-02f,
  -1.33739263e-02f, -2.99359392e-02f, 8.39560404e-02f, -3.18703353e-02f, -1.59720164e-02f, -5.12339398e-02f, -6.94316477e-02f, 1.79613978e-02f, 1.00334562e-01f, 1.35512754e-01f,
  7.27757365e-02f, 7.54550919e-02f, 9.97111946e-02f, 1.11993447e-01f, 5.97772561e-03f, 2.49729701e-03f, 1.29178524e-01f, -4.58476273e-03f, -3.82463820e-02f, -2.25883462e-02f,
  -1.66004822e-01f, 3.56188081e-02f, 3.58643197e-02f, 2.47451616e-03f, -3.81679982e-02f, -3.75891514e-02f, -2.43956316e-02f, 7.76521340e-02f, -9.72603261e-03f, 4.94652651e-02f,
  1.63913772e-01f, -1.34463996e-01f, 4.59826700e-02f, -1.39357775e-01f, -3.59908715e-02f, 1.61241349e-02f, -4.43468802e-02f, 4.99678552e-02f, 9.07804966e-02f, -1.89548470e-02f,
  -8.23146403e-02f, 1.96335781e-02f, -3.69700938e-02f, 5.67263216e-02f, 5.17756343e-02f, 2.56468020e-02f, -1.73258805e-03f, -4.54097241e-02f, 2.43633259e-02f, -5.05326018e-02f,
  -3.04867774e-02f, 7.06186518e-02f, 2.31509693e-02f, 1.65965423e-01f, -1.15721747e-01f, -4.00370322e-02f, 1.01641141e-01f, -1.09516583e-01f, -1.30440757e-01f, -1.24897487e-01f,
  6.37132153e-02f, -3.92137542e-02f, 8.01721662e-02f, 6.72574416e-02f, 2.82497332e-03f, -7.02441707e-02f, -4.08578776e-02f, -8.09346139e-02f, -7.46245682e-02f, 2.95824511e-03f,
  -9.65714231e-02f, 1.10178560e-01f, 1.25473052e-01f, 1.03428513e-01f, 2.28318442e-02f, 9.77193862e-02f, -8.85185748e-02f, -6.90322518e-02f, -2.99647059e-02f, -1.98545065e-02f,
  -7.32025430e-02f, 1.14235878e-02f, 2.62695234e-02f, 1.63144302e-02f, 9.16122496e-02f, 2.10250728e-02f, -5.93833476e-02f, -3.11353114e-02f, 8.75520706e-02f, 8.81245732e-02f,
  -7.07442462e-02f, 2.83001876e-03f, 1.51170208e-03f, -6.95773214e-02f, 9.04217064e-02f, -4.71636131e-02f, 1.80621184e-02f, -3.57389376e-02f, -5.27483486e-02f, 3.58107574e-02f,
  1.19592413e-01f, 1.36937603e-01f, 1.08578920e-01f, 2.35093688e-03f, 1.40115514e-01f, 1.24261640e-01f, 7.47883245e-02f, -4.23184186e-02f, 5.48521504e-02f, 3.85744125e-02f,
  1.22855105e-01f, 1.21070035e-01f, 4.75485586e-02f, 6.16377704e-02f, 1.10394850e-01f, 2.63301120e-03f, 1.49929017e-01f, 4.48358059e-02f, 9.71965194e-02f, 5.08552603e-02f,
  1.02584131e-01f, -2.12904997e-02f, 1.27246633e-01f, 1.03126794e-01f, 2.86187008e-02f, 8.40925127e-02f, 9.74282026e-02f, 9.76356938e-02f, -8.03974420e-02f, 1.66251540e-01f,
  -8.45985934e-02f, 4.98366021e-02f, 1.58188596e-01f, 7.23325759e-02f, -7.11760670e-02f, 5.89920506e-02f, 1.61975194e-02f, 3.19345668e-02f, 3.04496568e-03f, 5.72933853e-02f,
  1.58010125e-01f, 4.47119959e-02f, 6.88770264e-02f, 4.95111533e-02f, 4.81771119e-02f, 3.30670737e-02f, 6.00151718e-02f, -7.52408952e-02f, 1.92383483e-01f, -1.35206744e-01f,
  3.87534015e-02f, 1.57004103e-01f, -6.11810386e-02f, -1.16061844e-01f, -1.79290771e-01f, 1.08561225e-01f, -5.06269224e-02f, -4.69709300e-02f, 1.02772713e-01f, 7.54249096e-03f,
  -5.62731102e-02f, 2.96611618e-02f, 1.40807852e-01f, -1.13348544e-01f, 1.09769605e-01f, 1.54527545e-01f, 1.59618855e-01f, -1.76229462e-01f, 1.92936063e-01f, -2.35386744e-01f,
  -1.25968963e-01f, 8.79128426e-02f, -1.21169463e-02f, -5.34904599e-02f, 1.09979827e-02f, 4.21744809e-02f, -2.57252634e-01f, 4.52888664e-03f, -2.32577667e-01f, 2.92296022e-01f,
  -5.68218268e-02f, -2.10819617e-01f, -1.71762988e-01f, 3.53975929e-02f, 1.53594345e-01f, -1.85323015e-01f, -8.79448652e-02f, -7.91042596e-02f, 1.50210604e-01f, -1.53778195e-01f,
  -2.78370939e-02f, -7.05556646e-02f, -2.12974567e-02f, 1.48843616e-01f, -2.99755037e-02f, -2.04430521e-02f, 9.40333605e-02f, -2.49595165e-01f, 1.19432017e-01f, -1.07871898e-01f,
  5.49841262e-02f, 6.30523786e-02f, -5.86214550e-02f, -5.80171607e-02f, -5.16271666e-02f, -7.33078718e-02f, -2.00318992e-02f, 1.75026394e-02f, -2.89759343e-03f, 3.03300396e-02f,
  -3.40777338e-02f, -6.90413639e-02f, -1.55859645e-02f, -6.43499792e-02f, -3.76084745e-02f, 1.55420244e-01f, -2.33000591e-02f, 8.94975588e-02f, 6.72238320e-02f, -9.48291346e-02f,
  4.92771901e-02f, 5.93919447e-03f, 5.52970394e-02f, 5.04450537e-02f, 8.79672356e-03f, 1.29428521e-01f, -6.88667502e-03f, 8.30826163e-03f, -8.46328214e-03f, -2.38166172e-02f,
  9.52809490e-03f, -4.60503101e-02f, 5.24764620e-02f, 6.16340861e-02f, 6.88234121e-02f, 3.18313614e-02f, -3.31324115e-02f, -2.55675931e-02f, -2.94931438e-02f, -3.68079394e-02f,
  5.55489659e-02f, 1.10655241e-01f, -5.97188482e-03f, -1.56170335e-02f, 9.48535800e-02f, 3.53722349e-02f, 5.95336547e-03f, -3.95130105e-02f, 1.55300880e-02f, 2.67096981e-02f,
  3.58108319e-02f, 3.59928645e-02f, 8.35686177e-02f, 1.14131784e-02f, 1.56425871e-02f, 6.49388693e-03f, 8.70540440e-02f, 9.70620811e-02f, -1.62316486e-02f, 1.19381249e-01f,
  7.95445517e-02f, 2.48536468e-02f, 1.09244399e-01f, -3.41953151e-02f, 8.26279912e-03f, -5.07150255e-02f, 1.21297948e-01f, 4.12086509e-02f, 3.76645215e-02f, -2.61129644e-02f,
  6.34237006e-02f, 1.28014356e-01f, -8.41868389e-03f, 1.41840223e-02f, 1.14613455e-02f, 6.47662655e-02f, -9.25441980e-02f, 1.04320519e-01f, -9.45916101e-02f, -7.79349208e-02f,
  2.33559851e-02f, 9.94945914e-02f, 4.79104072e-02f, -7.39896223e-02f, 3.93097587e-02f, -1.53085282e-02f, -4.64706682e-03f, 7.70976022e-02f, -1.31148726e-01f, 1.22534886e-01f,
  -3.66318114e-02f, -1.10176047e-02f, -7.33107552e-02f, 4.98820171e-02f, 1.12295840e-02f, -3.93522941e-02f, 1.34184966e-02f, 1.00844391e-01f, -3.76323052e-02f, -7.30137974e-02f,
  3.84709239e-02f, -2.18837149e-02f, -7.88520128e-02f, 4.00125328e-03f, 6.95922747e-02f, 9.89014134e-02f, 3.30068497e-03f, -3.34494561e-02f, 1.32089674e-01f, -8.83672312e-02f,
  -4.21013050e-02f, -7.31109753e-02f, -8.04019719e-03f, 9.60253626e-02f, 7.66797885e-02f, -7.86626637e-02f, 4.65272777e-02f, 6.40894249e-02f, 3.26248258e-02f, -7.67279938e-02f,
  7.48088807e-02f, -4.62193936e-02f, 1.43571608e-02f, -5.09636886e-02f, 4.20072004e-02f, 8.84004459e-02f, -6.80316538e-02f, 8.88627991e-02f, 1.81408841e-02f, -1.31042730e-02f,
  5.41522764e-02f, 3.02568283e-02f, -7.01515228e-02f, -8.53364840e-02f, 9.65038463e-02f, 3.75373438e-02f, -3.31790373e-02f, 1.19734012e-01f, -4.85257283e-02f, 1.41059337e-02f,
  -1.16909342e-02f, 9.43882391e-02f, -4.08248454e-02f, -1.18915280e-02f, -2.48320978e-02f, 5.70571283e-03f, -3.70961428e-02f, -4.16035615e-02f, -1.26465196e-02f, 6.28030747e-02f,
  -5.22007532e-02f, 1.66623807e-03f, 3.20038795e-02f, 4.41545062e-02f, -1.81401875e-02f, -3.61375324e-03f, -5.84621243e-02f, 9.40046906e-02f, 7.18025714e-02f, -2.11096313e-02f,
  1.22299069e-04f, 4.44468968e-02f, 1.11560933e-01f, 3.81526388e-02f, 8.46153945e-02f, 1.33298412e-01f, 3.71707343e-02f, 7.01072812e-02f, -1.06969464e-03f, 6.92890137e-02f,
  -5.43695688e-02f, -2.42489856e-02f, 2.99621336e-02f, -3.50422673e-02f, 8.62455890e-02f, -2.93988194e-02f, 3.59636592e-03f, -8.21948573e-02f, 2.14651674e-02f, -2.98530073e-03f,
  1.32175302e-02f, 1.33553907e-01f, 1.09133653e-01f, 7.53253102e-02f, 9.28361267e-02f, 1.43519774e-01f, 1.25596836e-01f, 1.30373746e-01f, 2.50680116e-03f, 1.23829089e-01f,
  5.43890484e-02f, -2.89387722e-02f, 8.68170559e-02f, 2.77780797e-02f, 6.07028753e-02f, 1.49200596e-02f, 1.56671517e-02f, -6.84216842e-02f, -1.33464439e-02f, 1.02622919e-01f,
  5.92058599e-02f, -4.28784043e-02f, 5.02921566e-02f, 8.18430930e-02f, -8.08058232e-02f, 3.13922204e-02f, 3.13091800e-02f, -8.92535597e-02f, -9.36509967e-02f, -1.05652779e-01f,
  -1.12629801e-01f, 7.52188414e-02f, -3.73779424e-02f, -1.55709554e-02f, -1.29219934e-01f, -1.02833964e-01f, -6.30119145e-02f, 8.73667449e-02f, 2.76236329e-02f, -6.50977641e-02f,
  7.90202059e-03f, -1.63970426e-01f, 1.34387359e-01f, 1.33493498e-01f, 5.21355011e-02f, 1.50455862e-01f, 6.74069449e-02f, -1.49166793e-01f, -4.09669466e-02f, -1.02134347e-01f,
  3.82609330e-02f, -7.79032186e-02f, -1.06243178e-01f, -2.11670157e-02f, -7.28964480e-03f, -1.06004998e-01f, -8.91114101e-02f, -5.22513911e-02f, 2.12645903e-02f, -3.69332060e-02f,
  9.60731432e-02f, -3.46738435e-02f, 4.10118029e-02f, 4.04730672e-03f, 1.30519301e-01f, -4.51588780e-02f, -3.95338945e-02f, -8.64981934e-02f, -5.44519443e-03f, -2.54841466e-02f,
  7.26609603e-02f, -7.27074444e-02f, 7.38290027e-02f, 2.66760588e-02f, 2.25837938e-02f, 9.73147899e-02f, 3.67541909e-02f, -3.04415636e-03f, -1.34533299e-02f, -5.32199182e-02f,
  -4.50259857e-02f, 4.65213284e-02f, 3.60963913e-03f, -9.01384279e-02f, 2.30316743e-02f, 2.58409735e-02f, -8.73275995e-02f, -7.24718720e-02f, 6.30071610e-02f, -3.58131789e-02f,
  -3.64864455e-03f, 4.38303279e-04f, -6.75985543e-03f, 2.38392800e-02f, -4.95071858e-02f, -4.53252979e-02f, 1.30545087e-02f, -3.59557159e-02f, -8.15338343e-02f, 5.75253600e-03f,
  -1.30707761e-02f, -6.69065863e-02f, 1.90922543e-02f, -1.78923365e-03f, 4.94648665e-02f, 1.57275368e-02f, 1.04359270e-03f, 2.76476089e-02f, -6.27262816e-02f, -1.86512824e-02f,
  5.81723452e-02f, -8.75556283e-03f, 5.81291765e-02f, -4.41061854e-02f, -1.90305449e-02f, -7.02009499e-02f, -1.63358934e-02f, -3.95624340e-02f, 6.70720786e-02f, -6.14870600e-02f,
  2.00732257e-02f, -2.24206597e-02f, -6.52306154e-02f, -3.89675945e-02f, -4.05642949e-02f, -1.53573100e-02f, -7.20344186e-02f, -4.44563217e-02f, 1.71389733e-03f, 8.62115845e-02f,
  5.68924323e-02f, 9.11423936e-02f, -3.75539549e-02f, 1.20667219e-02f, 3.75108607e-02f, -3.92997153e-02f, 5.55232540e-02f, -4.28732932e-02f, -1.56879704e-02f, 5.83974682e-02f,
  -7.08214268e-02f, -6.47107139e-03f, -7.87326097e-02f, 5.64238951e-02f, 1.72611792e-02f, 7.23915324e-02f, 4.14600149e-02f, -2.80153994e-02f, 8.22748542e-02f, -6.56771287e-02f,
  6.31058663e-02f, -8.31001177e-02f, -1.00716181e-01f, -3.75386439e-02f, -2.87216678e-02f, -7.20126703e-02f, 2.03763153e-02f, -4.52825166e-02f, 1.45906080e-02f, 7.05335736e-02f,
  7.46027529e-02f, 7.86039755e-02f, -5.60410619e-02f, 8.36037770e-02f, 4.25070785e-02f, 7.85489902e-02f, -1.83927279e-03f, 4.09171842e-02f, 3.42950635e-02f, -7.84493759e-02f,
  9.63487551e-02f, 6.35323301e-02f, -3.46915871e-02f, 9.57222953e-02f, 3.19369808e-02f, 3.27739604e-02f, 5.86111359e-02f, 1.69093516e-02f, -6.95825294e-02f, -3.87305096e-02f,
  -6.10936852e-03f, -2.11773012e-02f, 4.06632088e-02f, -1.43068898e-02f, 4.94729690e-02f, -2.41460595e-02f, -1.76105890e-02f, -1.76205914e-02f, -7.61740059e-02f, -4.22955537e-03f,
  -1.67677291e-02f, 7.67876133e-02f, 4.24396060e-02f, 3.65960188e-02f, 4.91943508e-02f, 4.37752381e-02f, -1.01142703e-02f, 1.83265563e-02f, -7.03042280e-03f, 9.29750577e-02f,
  6.50041178e-02f, 3.69567461e-02f, 2.52619348e-02f, 4.76131588e-03f, 2.32794080e-02f, -6.38066530e-02f, 6.35607019e-02f, 2.09342572e-03f, 2.66656186e-02f, 3.24017182e-02f,
  -8.69925618e-02f, 2.81072874e-02f, -1.22124003e-02f, -2.49581109e-03f, -4.19068970e-02f, 4.45596762e-02f, -2.93743312e-02f, 6.49202196e-03f, 1.29282158e-02f, -1.83170044e-03f,
  -5.70408329e-02f, -2.50424985e-02f, 6.17747866e-02f, 2.31613982e-02f, -5.60467876e-03f, 3.58100515e-03f, 5.85613288e-02f, -5.36480434e-02f, -2.59080678e-02f, 6.18594773e-02f,
  1.15917452e-01f, 6.54916987e-02f, 8.67709965e-02f, 3.69796529e-02f, 1.94183886e-02f, 1.12963513e-01f, -5.32899462e-02f, -5.89663424e-02f, -2.81316554e-03f, -6.36240765e-02f,
  -3.11307441e-02f, -1.42682660e-02f, 9.22123790e-02f, 1.16600901e-01f, 7.38822892e-02f, 9.66007039e-02f, 1.04651786e-01f, 8.69261194e-03f, 8.25978965e-02f, -3.67892440e-03f,
  -2.12744740e-03f, 4.69704978e-02f, -8.03139433e-03f, -1.48771936e-02f, 2.12775469e-02f, -3.36890630e-02f, 5.25688305e-02f, -4.48408946e-02f, -4.75233234e-02f, 6.05912097e-02f,
  1.12118296e-01f, 1.49580576e-02f, 8.84704739e-02f, 9.09954756e-02f, -5.88601120e-02f, 3.71177346e-02f, -9.40964092e-03f, 9.93481874e-02f, 1.54015198e-02f, -2.86109559e-02f,
  3.03586796e-02f, -6.84977323e-02f, -1.12837618e-02f, 6.68779202e-03f, 8.55176970e-02f, -9.77639295e-03f, 1.32533640e-01f, 6.51215687e-02f, 5.08051142e-02f, -3.56082097e-02f,
  -1.24458417e-01f, 8.80939215e-02f, 2.92255338e-02f, -3.02733481e-02f, 2.52346620e-02f, 4.21077572e-02f, 8.61951560e-02f, -4.63567749e-02f, -4.06697839e-02f, -6.73872530e-02f,
  8.05426165e-02f, 9.09239277e-02f, 7.19683543e-02f, -9.78113562e-02f, 1.76310260e-02f, 2.21716668e-02f, -7.73264617e-02f, 1.42725289e-03f, 2.90250611e-02f, -5.80350831e-02f,
  -8.92665163e-02f, 3.70345972e-02f, -6.96605220e-02f, 7.64730871e-02f, -6.57039434e-02f, 5.39804399e-02f, 6.55946955e-02f, -2.10635997e-02f, 7.90221766e-02f, -1.18054882e-01f,
  -2.48453431e-02f, 2.91792955e-02f, 7.66448230e-02f, 1.53572738e-01f, -6.26924485e-02f, 4.94698025e-02f, 1.36917429e-02f, 3.41462642e-02f, -8.42189416e-02f, 4.86153178e-02f,
  -1.50905266e-01f, -2.03799475e-02f, 4.25769016e-02f, -1.12415850e-02f, 9.90691595e-03f, -9.54483822e-03f, 2.53452007e-02f, 7.81647786e-02f, 1.55687174e-02f, 4.74655218e-02f,
  7.45828003e-02f, -3.21024992e-02f, 6.93336949e-02f, -7.10096061e-02f, -5.76945506e-02f, 9.90239531e-02f, -5.55352960e-03f, 3.58970314e-02f, -1.45559572e-02f, 9.31029916e-02f,
  -5.48412725e-02f, -1.08847823e-02f, 8.75702426e-02f, 7.18596280e-02f, 1.01471804e-01f, -8.75105858e-02f, -2.62994990e-02f, 1.07301120e-02f, -2.69915909e-02f, 3.49960173e-03f,
  6.31576106e-02f, 3.57386358e-02f, -6.92766532e-02f, -4.62035183e-03f, -3.89472358e-02f, 4.28259745e-02f, 1.81820001e-02f, -5.27754426e-02f, 1.00961104e-01f, 3.04347668e-02f,
  -1.03597287e-02f, 1.04926936e-01f, 7.37752244e-02f, 4.67945226e-02f, -7.13089705e-02f, 6.35886118e-02f, -6.10793047e-02f, 4.44473512e-02f, 8.02939832e-02f, 9.24591720e-03f,
  4.96728830e-02f, -2.49834880e-02f, 4.55960631e-02f, 5.83729148e-02f, 4.98087611e-03f, 2.48378068e-02f, -4.62716892e-02f, -5.05686067e-02f, 3.04427906e-03f, -2.07297318e-02f,
  8.91557634e-02f, 9.96114612e-02f, -5.03053479e-02f, -5.77659644e-02f, -1.23264380e-02f, 1.06715681e-02f, 5.61568104e-02f, -2.12212130e-02f, -9.78223681e-02f, 2.79492289e-02f,
  5.74649945e-02f, -8.19291640e-03f, -1.67184491e-02f, 6.48183702e-03f, -4.64937426e-02f, -1.81396212e-02f, 2.01628245e-02f, 8.09685439e-02f, 5.11405058e-03f, -5.43587543e-02f,
  2.85205827e-03f, 4.40179184e-02f, 1.77701060e-02f, 3.06333005e-02f, -7.07142428e-02f, -2.20534895e-02f, -4.54946049e-02f, -7.54019171e-02f, 4.08325577e-03f, -8.26363936e-02f,
  -2.51036603e-02f, 7.28718713e-02f, -6.97797677e-03f, -7.29675442e-02f, -8.94335881e-02f, 3.77225503e-02f, 7.13628083e-02f, 5.00934832e-02f, -5.55485040e-02f, -1.71469469e-02f,
  5.74282296e-02f, -5.03418557e-02f, 3.07038501e-02f, -5.57704121e-02f, -9.71537903e-02f, 6.24187998e-02f, 8.59990865e-02f, -7.67072141e-02f, 1.42241335e-02f, -6.85814247e-02f,
  -5.21729849e-02f, 2.73318146e-03f, 8.29514042e-02f, -2.68085133e-02f, -2.16260552e-02f, 1.03960909e-01f, 2.04213280e-02f, -2.60111652e-02f, -1.06998846e-01f, 5.70122600e-02f,
  -1.96546335e-02f, -9.21437517e-02f, 6.26524687e-02f, 4.26048301e-02f, -2.74530472e-03f, -3.44507731e-02f, -1.12648699e-02f, 9.63719487e-02f, -6.36889488e-02f, 3.59514505e-02f,
  -3.17143090e-02f, -4.63666487e-03f, 8.59195367e-02f, 7.59086609e-02f, -1.49751855e-02f, -1.69445891e-02f, -1.03389146e-02f, -9.03136060e-02f, -1.85198374e-02f, -1.46200852e-02f,
  -4.62966897e-02f, -6.10888675e-02f, 7.07146451e-02f, 6.49283230e-02f, 4.19455133e-02f, -4.74379621e-02f, -6.17768951e-02f, -7.68338442e-02f, 1.76500604e-02f, -7.48573616e-02f,
  1.03051864e-01f, -1.70649756e-02f, 6.72242194e-02f, -2.38036290e-02f, -3.60424258e-02f, 2.92468015e-02f, 6.55899942e-02f, -6.48893928e-03f, 2.63630692e-02f, 1.31411199e-02f,
  2.56175101e-02f, 1.91921946e-02f, 2.91632991e-02f, -3.90703753e-02f, -5.69720007e-03f, -5.11188060e-02f, -2.78851166e-02f, 3.58095877e-02f, -3.16377878e-02f, 7.66132548e-02f,
  -3.76366116e-02f, 7.67503381e-02f, -6.03140146e-02f, 3.81520092e-02f, -8.25268328e-02f, 3.17932740e-02f, -6.61794916e-02f, 6.75348267e-02f, -7.18727931e-02f, -4.61121202e-02f,
  -6.49895892e-02f, 6.93309382e-02f, -3.62922475e-02f, 3.75474952e-02f, 4.84905541e-02f, -4.79944162e-02f, 1.76761039e-02f, -4.73012775e-02f, 5.91935255e-02f, -2.44539138e-02f,
  1.19314799e-02f, 3.11342534e-02f, 2.40036584e-02f, 3.11202407e-02f, 4.75502312e-02f, 2.46228147e-02f, -4.76392638e-03f, 6.48037940e-02f, -6.02423474e-02f, -7.31811598e-02f,
  -1.33012561e-03f, 1.42696444e-02f, -4.93075103e-02f, 8.43571723e-02f, -8.01062882e-02f, -6.44035563e-02f, 1.70079786e-02f, 1.73594896e-02f, -6.42715842e-02f, 2.08867490e-02f,
  -1.39042875e-02f, -5.24427965e-02f, -2.19675303e-02f, 1.08345924e-02f, 3.54199596e-02f, -1.29078394e-02f, -3.35171409e-02f, 8.54738100e-05f, -1.12903472e-02f, -5.40601350e-02f,
  1.86656509e-02f, 2.22227555e-02f, 8.47064182e-02f, -7.93691128e-02f, 1.20979538e-02f, 7.48837963e-02f, -6.14609905e-02f, 7.50643108e-03f, 2.76646707e-02f, -6.84832707e-02f,
  -6.15758002e-02f, 8.84325728e-02f, 6.78399503e-02f, -2.29705218e-02f, 2.86310557e-02f, -2.73826681e-02f, 5.48936725e-02f, 8.04740638e-02f, -4.01399424e-03f, 3.60121438e-03f,
  -6.21281639e-02f, -5.15985526e-02f, 5.69382869e-02f, -3.24342400e-02f, 3.53867896e-02f, 3.64069119e-02f, -4.85620536e-02f, -4.52366993e-02f, 1.64395161e-02f, 3.57563794e-02f,
  6.38207719e-02f, 2.51096878e-02f, 2.84135845e-02f, -2.58450862e-02f, 4.98578362e-02f, -8.00921116e-03f, -5.04890569e-02f, 3.50821130e-02f, -2.33976841e-02f, 8.98976624e-02f,
  -7.09598064e-02f, -8.11372921e-02f, 3.75609030e-04f, 1.08976491e-01f, 6.31700978e-02f, -1.78895853e-02f, -6.70127273e-02f, 2.77916230e-02f, -1.11511821e-04f, -9.71261226e-03f,
  5.83585054e-02f, -8.18989647e-04f, -7.74700344e-02f, -6.71209618e-02f, 1.89486314e-02f, -6.14577346e-03f, -1.18908267e-02f, -5.99993803e-02f, -6.46696910e-02f, -6.87636882e-02f,
  9.06746238e-02f, -7.23247901e-02f, 2.62714364e-02f, 6.25981763e-02f, -4.56942655e-02f, 2.07158457e-02f, -2.37227064e-02f, -1.28608691e-02f, 2.72081606e-02f, -3.87827978e-02f,
  4.67779897e-02f, -3.52903176e-03f, 1.25429466e-01f, 8.45678151e-02f, 1.44381553e-01f, -2.53269300e-02f, 1.28190115e-01f, 1.99816022e-02f, -1.72289666e-02f, 7.20663965e-02f,
  3.03006079e-02f, 8.28223750e-02f, 1.36803370e-02f, -4.54290062e-02f, -3.69181782e-02f, 3.45076062e-02f, -3.78973894e-02f, 1.33614197e-01f, 1.40203789e-01f, 3.84425279e-03f,
  -4.93787900e-02f, 1.05410218e-01f, 7.40304366e-02f, 1.18759215e-01f, 8.68910849e-02f, -1.59581238e-03f, -4.04563406e-03f, 5.70506006e-02f, -5.09039201e-02f, 2.93058902e-03f,
  1.07104760e-02f, 5.07429019e-02f, 1.64726493e-03f, 7.36491010e-02f, 1.13435254e-01f, 1.19346520e-02f, 8.35721195e-02f, -4.23571840e-02f, 1.30759224e-01f, 1.21222576e-02f,
  -7.35102966e-02f, 3.54337208e-02f, 7.98356999e-03f, -7.48992190e-02f, 7.55453855e-02f, 8.17306936e-02f, 4.47944999e-02f, 9.90187228e-02f, 1.68333463e-02f, -1.46030160e-02f,
  -6.86232969e-02f, 1.73727423e-02f, 1.41165867e-01f, 6.94032758e-02f, 8.50704759e-02f, -1.20438553e-01f, -9.72113684e-02f, 4.09049876e-02f, 1.06775343e-01f, 1.16886243e-01f,
  3.09807174e-02f, -1.14672899e-01f, -5.26704709e-04f, -9.14140344e-02f, 1.79849956e-02f, 7.37854540e-02f, 3.38625126e-02f, 6.63646013e-02f, 1.14940755e-01f, 4.07264481e-04f,
  -4.13335785e-02f, 3.11554521e-02f, -1.98111795e-02f, 1.92215852e-02f, -1.13191502e-02f, -6.39934419e-03f, -1.52911358e-02f, -1.46780908e-01f, -2.67139897e-02f, 9.42681283e-02f,
  4.42170538e-02f, 1.30405530e-01f, 2.53891107e-02f, 2.53522638e-02f, -5.07414304e-02f, 8.11333284e-02f, -1.02927469e-01f, -5.91488592e-02f, 6.04457967e-02f, 6.14403980e-04f,
  -5.35263903e-02f, -9.61402506e-02f, 1.53280897e-02f, 7.19069391e-02f, 1.11871399e-01f, 5.18250875e-02f, -5.50530218e-02f, 4.00459021e-02f, 6.69494644e-02f, -5.96476011e-02f,
  -1.66220944e-02f, -9.19999331e-02f, 8.09857398e-02f, -4.88300715e-03f, -3.00887357e-02f, 2.99186148e-02f, -6.03117980e-03f, -6.24336675e-02f, 7.38684461e-02f, -1.27649054e-01f,
  4.61489744e-02f, -7.45711848e-02f, 1.99726373e-02f, -6.05135709e-02f, 8.80754292e-02f, -6.24842234e-02f, -1.41189098e-02f, -3.02039161e-02f, -5.20293415e-02f, 6.15707748e-02f,
  -1.97629188e-03f, 4.68189679e-02f, -5.39518707e-02f, 3.45236287e-02f, 9.67124104e-02f, 1.15496973e-02f, -1.28701292e-02f, 3.40212770e-02f, 5.42726144e-02f, -4.37617935e-02f,
  -3.81697714e-02f, 5.32619469e-02f, 7.61896819e-02f, 1.06906645e-01f, 4.84177545e-02f, 3.58461998e-02f, 6.07070290e-02f, 7.62337595e-02f, 3.92978303e-02f, 5.48775569e-02f,
  6.47956738e-03f, 2.81093586e-02f, -4.40058485e-02f, 1.05546243e-01f, -8.60441849e-03f, 6.05688915e-02f, 2.15122886e-02f, 9.05414596e-02f, -4.92014736e-02f, -4.04933617e-02f,
  2.76115462e-02f, -2.93148309e-02f, 5.01292348e-02f, -2.33741496e-02f, 9.90112349e-02f, 5.32840155e-02f, 2.40028221e-02f, -3.92670147e-02f, 5.94211929e-02f, 1.05353728e-01f,
  8.13172087e-02f, 8.17483589e-02f, -2.30548717e-02f, -4.02133204e-02f, -3.61227095e-02f, -3.67703708e-03f, -2.59906463e-02f, 3.29243182e-03f, -5.66471145e-02f, 9.91977900e-02f,
  7.05154315e-02f, -1.41806984e-02f, 2.92257052e-02f, -2.03103796e-02f, 2.96380483e-02f, 2.06653494e-02f, -2.47932822e-02f, 7.52607593e-05f, -2.28948221e-02f, 2.09443625e-02f,
  9.14791948e-04f, -7.33985677e-02f, 9.49784890e-02f, 2.69660093e-02f, 1.73623562e-02f, 1.10808708e-01f, -6.89347833e-02f, 1.83190708e-03f, 9.68003422e-02f, -8.04732889e-02f,
  -8.70192349e-02f, 8.80833790e-02f, 7.65064806e-02f, 7.48989806e-02f, 6.35682642e-02f, -2.42636204e-02f, -9.26921424e-03f, 9.85828787e-02f, 7.10498691e-02f, 4.44846749e-02f,
  -2.09775586e-02f, -6.88311160e-02f, -4.04486917e-02f, -9.39545259e-02f, -7.09236339e-02f, 6.91150427e-02f, 7.91599378e-02f, 5.74826859e-02f, 6.97912201e-02f, -3.58949862e-02f,
  9.18916799e-03f, -5.71949966e-02f, 5.01231775e-02f, 3.55986953e-02f, 1.55424397e-03f, 6.09205849e-02f, -8.00510868e-02f, 2.33277660e-02f, -1.01490319e-01f, -5.28571941e-02f,
  -9.05982032e-02f, 2.40083002e-02f, -7.28851408e-02f, 1.42866662e-02f, 7.64168501e-02f, 7.88494498e-02f, 4.98174690e-03f, -6.14845045e-02f, 4.93587330e-02f, -2.39504855e-02f,
  3.15761343e-02f, -4.53361869e-02f, -7.32751265e-02f, -4.62719472e-03f, -2.74524689e-02f, -5.43844439e-02f, 2.46820762e-03f, -5.38646244e-02f, 9.63007882e-02f, -1.06839295e-02f,
  2.61942763e-02f, 5.43107241e-02f, -7.90412202e-02f, -1.87530946e-02f, 2.53266394e-02f, 1.47000793e-03f, 6.69590905e-02f, 1.98157690e-02f, 8.51697698e-02f, 6.38104826e-02f,
  1.08445324e-02f, -9.08576697e-02f, -6.65428713e-02f, -2.98209824e-02f, -4.52798679e-02f, 2.71473601e-02f, -2.45064553e-02f, 5.31784035e-02f, 3.57616916e-02f, 5.10348678e-02f,
  -4.90643233e-02f, -3.77861075e-02f, -6.09565675e-02f, 4.88398783e-02f, 7.71868452e-02f, 2.37212721e-02f, -8.29483643e-02f, 8.74693245e-02f, 6.10632822e-02f, 8.05701911e-02f,
  1.07549615e-01f, 1.09709390e-01f, -5.79894939e-03f, 5.28825708e-02f, 8.94912928e-02f, 5.70800118e-02f, 6.17106110e-02f, 9.37406868e-02f, -3.24498005e-02f, 9.72583815e-02f,
  7.71749616e-02f, 1.26124900e-02f, 1.12790644e-01f, -1.39788473e-02f, -3.65423858e-02f, 4.55763303e-02f, -2.54449770e-02f, 6.70767650e-02f, -4.38856892e-02f, -3.78297642e-02f,
  7.57794306e-02f, -1.14268139e-02f, -1.78859271e-02f, 7.47147724e-02f, 4.47254889e-02f, -2.13887449e-03f, 1.27723560e-01f, -6.88602179e-02f, 1.17649689e-01f, 1.05854779e-01f,
  9.52326953e-02f, 7.80174360e-02f, 3.51468660e-02f, -1.40511543e-02f, 1.06580429e-01f, -1.65453134e-03f, 1.03608280e-01f, -3.86868790e-02f, -8.35531577e-02f, -6.72976598e-02f,
  -1.35110095e-01f, 3.00946664e-02f, 5.55893080e-03f, 1.00393277e-02f, 2.44987868e-02f, -5.38687967e-03f, 8.52735266e-02f, 3.80639099e-02f, -2.69173123e-02f, -8.41903761e-02f,
  -3.27611417e-02f, 2.71729585e-02f, 4.45988290e-02f, -3.90362926e-02f, -9.83799845e-02f, 5.97168915e-02f, 1.23083517e-01f, -1.16341069e-01f, 5.43174446e-02f, 8.84909853e-02f,
  -9.12128687e-02f, 1.42528951e-01f, 1.24094747e-01f, -8.57520998e-02f, -8.51163492e-02f, -1.21641776e-03f, 1.87106747e-02f, -5.88832833e-02f, 7.99133405e-02f, -6.19646385e-02f,
  9.89401788e-02f, -9.35482308e-02f, -3.77783179e-02f, 1.42004117e-01f, 3.17855105e-02f, -7.00755194e-02f, -1.00118861e-01f, 5.29170185e-02f, -3.78635190e-02f, 8.14825669e-03f,
  6.51957914e-02f, 4.66370815e-03f, 8.81341696e-02f, 8.18260238e-02f, 1.61527824e-02f, 3.43924239e-02f, 9.04020742e-02f, -2.62536500e-02f, -5.87965958e-02f, 1.03090011e-01f,
  6.62770718e-02f, 1.08604573e-01f, -6.93227500e-02f, 7.68274488e-03f, 1.04797585e-02f, 6.71192631e-02f, 5.80935776e-02f, 8.46212450e-03f, -2.15165205e-02f, -8.07905197e-02f,
  -3.85529175e-03f, 4.64569218e-02f, 4.70062532e-02f, 1.27883125e-02f, 1.29799902e-01f, 8.64267349e-02f, -8.12191889e-02f, -8.74986425e-02f, 5.46660647e-02f, 2.02452149e-02f,
  -4.02372777e-02f, 6.64249510e-02f, 3.59764788e-03f, -9.29209888e-02f, 4.40864153e-02f, -1.03588305e-01f, 9.30536315e-02f, 2.22858340e-02f, -5.57234809e-02f, 7.79313520e-02f,
  8.12824741e-02f, -8.24928507e-02f, -6.04639463e-02f, -8.12309384e-02f, -4.91673611e-02f, -7.69239068e-02f, -7.95026422e-02f, -1.96558852e-02f, -5.19309826e-02f, 6.61348328e-02f,
  -3.89104560e-02f, 4.15707752e-02f, -2.30851304e-02f, 5.98907173e-02f, 2.68333890e-02f, -7.78663084e-02f, 9.97110084e-03f, -3.89698930e-02f, 6.95339590e-02f, -7.07064345e-02f,
  2.73368210e-02f, -2.08627265e-02f, 5.55753000e-02f, -2.41176318e-02f, 4.35312241e-02f, 5.32245524e-02f, -2.85292454e-02f, -8.86734016e-03f, -7.77099431e-02f, -2.03875583e-02f,
  -7.82013014e-02f, -4.88635190e-02f, 3.08876559e-02f, 3.78926173e-02f, 1.81753759e-03f, 2.14766222e-03f, -9.94503871e-03f, -4.98492569e-02f, -7.41217881e-02f, 4.89531942e-02f,
  -7.74332657e-02f, 1.36767514e-04f, 5.75929545e-02f, 2.35279687e-02f, 7.78853148e-02f, 6.88423263e-03f, -5.15809916e-02f, 2.77413824e-03f, -7.50377625e-02f, -6.31126240e-02f,
  2.22012401e-02f, 6.55142143e-02f, -8.56114328e-02f, -6.43123686e-02f, -3.26528922e-02f, -7.24957734e-02f, 4.59029712e-02f, 1.26339905e-02f, -2.49870704e-03f, -2.31888350e-02f,
  9.83219780e-03f, 3.27752084e-02f, -3.79679687e-02f, -4.75483313e-02f, -5.98058067e-02f, -7.79532641e-02f, 7.08266720e-02f, -2.53946669e-02f, 4.21940312e-02f, -6.98816404e-03f,
  7.43989320e-03f, -2.37512868e-03f, 7.56192729e-02f, 3.38311642e-02f, 1.66093558e-02f, 4.00543865e-03f, -6.26871316e-03f, 1.21125616e-02f, 2.78766435e-02f, -6.39914349e-02f,
  -7.55655169e-02f, 3.74757685e-02f, 8.66348967e-02f, -3.08891330e-02f, 4.43739668e-02f, -1.48027781e-02f, 3.47902402e-02f, -4.75096852e-02f, 3.12653892e-02f, 3.02993488e-02f,
  -8.18552524e-02f, 3.78740393e-02f, 4.04288284e-02f, 4.60084341e-02f, 8.62415135e-02f, 2.92190295e-02f, 5.73285781e-02f, 3.40353698e-02f, -3.27776186e-02f, 2.07058955e-02f,
  -8.15199614e-02f, 8.70605260e-02f, 3.32519598e-02f, 5.99840246e-02f, -5.99399097e-02f, -4.42137290e-03f, -3.77547219e-02f, -3.29069309e-02f, -8.05418356e-04f, -7.61629716e-02f,
  -5.10600097e-02f, 4.41323370e-02f, -7.71292746e-02f, 3.83250117e-02f, -5.59733994e-03f, 7.33359829e-02f, 4.83132191e-02f, -7.19252974e-02f, -2.31249235e-03f, -2.49676853e-02f,
  1.91252436e-02f, -2.40197945e-02f, 1.07336752e-02f, 8.77823085e-02f, 4.11833636e-02f, -2.67584976e-02f, 8.45289826e-02f, -1.98727977e-02f, -5.81740635e-03f, -8.17158520e-02f,
  7.16413464e-03f, 6.01186976e-02f, -7.21940547e-02f, 6.95549399e-02f, -5.43193445e-02f, 6.50207326e-02f, 4.01198454e-02f, -5.09406999e-02f, -5.95284775e-02f, 6.38533831e-02f,
  -6.52502999e-02f, -4.76871915e-02f, 3.68312001e-02f, -4.52658050e-02f, 1.78854249e-03f, -1.19175119e-02f, -6.94683492e-02f, -6.35520816e-02f, -8.26476142e-02f, 3.29369269e-02f,
  -2.15104781e-02f, -7.60914907e-02f, -7.44205266e-02f, 6.03859983e-02f, 5.76348156e-02f, -6.71815053e-02f, -7.61938319e-02f, -2.45233532e-02f, -3.21110711e-02f, -4.45332602e-02f,
  -6.33992394e-03f, -4.73435372e-02f, -6.07637204e-02f, 3.05261090e-02f, 1.00536663e-02f, -7.27215484e-02f, -1.93436537e-02f, 1.53643114e-03f, 7.95704685e-03f, -4.46699671e-02f,
  -7.80185238e-02f, -7.89972544e-02f, -3.97645868e-02f, -2.68335138e-02f, 6.93938732e-02f, 4.72018532e-02f, 6.58813566e-02f, 2.84514260e-02f, 1.71403233e-02f, -3.39108473e-03f,
  -3.52599993e-02f, 4.55699936e-02f, -5.05275279e-02f, 7.56914839e-02f, 5.88451102e-02f, -2.84511829e-03f, -3.57785285e-03f, 7.15906844e-02f, 6.41774088e-02f, 3.16537581e-02f,
  7.98244327e-02f, 4.68609942e-04f, 7.46192262e-02f, -8.66374299e-02f, -6.25734851e-02f, -6.41881526e-02f, -4.55278568e-02f, 6.62616938e-02f, -9.25149489e-03f, -8.23425353e-02f,
  4.14916687e-02f, -1.10373143e-02f, 4.90601808e-02f, 8.38914588e-02f, 2.85225529e-02f, 3.19345370e-02f, -2.41187029e-02f, 7.13364556e-02f, -4.90600280e-02f, -1.69715937e-02f,
  -5.51930033e-02f, -9.77452565e-03f, -7.31682405e-02f, 5.88069111e-02f, 5.51248714e-02f, -4.76876274e-02f, 1.23316692e-02f, -2.05829814e-02f, -1.87444221e-03f, 8.81164223e-02f,
  -4.86822277e-02f, 2.19115689e-02f, 3.00323889e-02f, 3.87937538e-02f, -7.47654140e-02f, -9.22687128e-02f, 3.65158282e-02f, 7.63066784e-02f, 2.31307968e-02f, 6.75326493e-03f,
  -5.16333580e-02f, 8.54525492e-02f, 4.24469560e-02f, -1.25827780e-02f, 6.31590486e-02f, -3.43536437e-02f, 8.29680264e-02f, 2.58612465e-02f, 2.80603743e-03f, 5.05903028e-02f,
  4.68790159e-02f, 4.74459790e-02f, -4.37245630e-02f, 7.11908042e-02f, -8.20385069e-02f, -7.64932260e-02f, 1.13108698e-02f, 1.97802018e-02f, -8.21831822e-02f, -3.33114713e-02f,
  -4.41523790e-02f, -4.98856753e-02f, 3.53654288e-02f, -6.53769937e-04f, -4.06856723e-02f, 4.86540236e-02f, -4.18508574e-02f, 3.70166451e-02f, 1.56965062e-01f, 5.95870353e-02f,
  7.10173324e-02f, 6.48758188e-02f, 3.78108583e-02f, 9.09083039e-02f, 1.02269039e-01f, 6.30586520e-02f, -1.80747472e-02f, 3.12018916e-02f, -4.38042767e-02f, 2.92169917e-02f,
  8.73111263e-02f, 8.37048329e-03f, 6.15135655e-02f, 8.35785195e-02f, -3.89169976e-02f, 1.01421185e-01f, 3.39626241e-03f, 9.52913389e-02f, -7.06499489e-03f, 1.06767170e-01f,
  8.50971639e-02f, 3.16219740e-02f, 1.66408275e-03f, 6.69193687e-03f, 5.59832007e-02f, -1.86195485e-02f, -3.12539861e-02f, -1.89930871e-02f, 8.07363391e-02f, -4.14169654e-02f,
  8.31974596e-02f, -2.51502730e-02f, -2.82110423e-02f, 1.09917007e-01f, -8.85420199e-03f, -8.95071216e-03f, 8.79664272e-02f, 9.86200385e-03f, 1.07549176e-01f, -2.43582614e-02f,
  1.18787922e-01f, -2.55478788e-02f, 4.02575657e-02f, 4.08761203e-02f, -2.03440129e-03f, 1.27316445e-01f, -8.73851106e-02f, 1.99292168e-01f, 1.36784837e-01f, 8.15194100e-02f,
  -2.57070158e-02f, -4.78263386e-02f, 1.23982869e-01f, -4.51254435e-02f, 2.04391390e-01f, -8.05209726e-02f, -5.57767227e-02f, -6.39675185e-02f, -1.54099137e-01f, 1.64260313e-01f,
  -1.12353079e-01f, 1.49723917e-01f, -1.06651336e-01f, -1.08168676e-01f, -1.52978614e-01f, -6.85220435e-02f, 4.65539321e-02f, 1.63764045e-01f, 1.88537702e-01f, 5.66533692e-02f,
  -3.41617577e-02f, -1.25750422e-01f, 3.05309501e-02f, 4.49689701e-02f, -2.47586966e-02f, 6.49010539e-02f, 8.18648189e-03f, 3.06907240e-02f, -1.45014346e-01f, 4.38386500e-02f,
  1.36800883e-02f, -8.10741410e-02f, -5.39473854e-02f, -7.90019240e-03f, -1.14056833e-01f, 1.70030836e-02f, -3.56081463e-02f, -1.52383251e-02f, 1.35326207e-01f, -2.14267690e-02f,
  3.94633086e-03f, -1.15327895e-01f, -4.50897776e-02f, 1.03713214e-01f, -8.68508872e-03f, 4.23065796e-02f, 5.03462926e-02f, 8.35148543e-02f, -2.74336487e-02f, -7.77823757e-03f,
  7.22926930e-02f, -6.79989904e-02f, 9.92754474e-02f, 1.27283216e-01f, -2.27289479e-02f, -3.97601575e-02f, 1.21751614e-01f, 1.36586860e-01f, -3.83149609e-02f, 1.29091233e-01f,
  2.60452349e-02f, -3.30175534e-02f, -1.52443759e-02f, -5.72121851e-02f, -9.16748792e-02f, 7.29025975e-02f, 6.86754063e-02f, 9.08696093e-03f, 1.27803266e-01f, -9.88565758e-02f,
  2.61342302e-02f, -5.10196537e-02f, 8.30582753e-02f, -6.88701682e-03f, -7.86521584e-02f, 8.71051177e-02f, 1.62561722e-02f, -5.95580321e-03f, 1.31783798e-01f, 3.16880010e-02f,
  5.20095862e-02f, -7.24263042e-02f, 1.34424195e-01f, 9.07404050e-02f, 9.11134630e-02f, 1.02455273e-01f, 5.36375344e-02f, -3.26821879e-02f, 1.17090665e-01f, 7.46181756e-02f,
  8.66127014e-02f, 1.78443342e-02f, 4.45729792e-02f, 4.83614914e-02f, 5.35636134e-02f, 4.33361903e-02f, 9.16128084e-02f, -2.31195409e-02f, 7.98609201e-03f, 2.49720570e-02f,
  8.47176090e-02f, 1.22944690e-01f, 8.96382239e-03f, 2.48483252e-02f, 3.56263928e-02f, -1.71886124e-02f, -4.32206132e-02f, 2.72015147e-02f, 6.57937005e-02f, 2.99131554e-02f,
  -3.79229002e-02f, -4.22843285e-02f, 1.20456614e-01f, -7.38572553e-02f, -7.38856494e-02f, 7.57649615e-02f, 2.97706164e-02f, -6.18511103e-02f, -2.36742496e-02f, 1.11485809e-01f,
  6.70907795e-02f, 8.38819891e-02f, -6.50500208e-02f, 1.23687526e-02f, 6.89105690e-02f, -4.50963303e-02f, 9.31472853e-02f, 6.67272210e-02f, 4.27921079e-02f, 9.07492936e-02f,
  -3.16884369e-02f, 9.69460756e-02f, 1.05832763e-01f, -3.94692272e-03f, -1.03710834e-02f, -4.07221913e-02f, -5.29415580e-03f, 2.92319674e-02f, 1.25840783e-01f, 2.22519524e-02f,
  -2.06684619e-02f, 1.15772951e-02f, -2.44394988e-02f, -1.12375237e-01f, 1.01812996e-01f, 1.25296861e-01f, 7.99983069e-02f, 6.59479722e-02f, 4.71719690e-02f, 3.04814372e-02f,
  1.20102465e-01f, -3.54079753e-02f, 9.74124148e-02f, -1.35934293e-01f, 3.49999927e-02f, 9.39499810e-02f, -7.86178857e-02f, 1.56280529e-02f, 3.30665708e-02f, -1.01160124e-01f,
  8.08513199e-04f, -8.82798433e-02f, -8.53590784e-04f, -1.19266994e-02f, 1.30693056e-02f, -5.76862916e-02f, -7.05400575e-03f, -1.75812542e-01f, -7.54727889e-03f, -4.14866433e-02f,
  2.18167026e-02f, -1.36646419e-03f, -7.42982551e-02f, 5.38383201e-02f, -9.26263817e-03f, -4.38686386e-02f, 7.50049204e-02f, 1.18965171e-01f, -2.51237489e-03f, -3.14773992e-02f,
  3.70479785e-02f, -9.98211354e-02f, 8.40011835e-02f, 7.32079223e-02f, -2.61054244e-02f, -4.01580706e-02f, -1.98547803e-02f, 9.14831012e-02f, 1.28439050e-02f, -3.60637493e-02f,
  -6.87536448e-02f, -4.57261391e-02f, -2.79505737e-02f, 1.26663595e-03f, -3.25958915e-02f, -6.63082153e-02f, 1.27038863e-02f, -8.48878175e-02f, -1.69610500e-03f, 1.93742737e-02f,
  -9.41189996e-04f, 2.27042977e-02f, 6.80078492e-02f, 4.23093848e-02f, 1.33866012e-01f, -1.26254670e-02f, 3.21623087e-02f, 1.73159670e-02f, -6.37439936e-02f, 3.18655260e-02f,
  -2.24271454e-02f, 9.19143781e-02f, -2.87466161e-02f, -2.41226935e-05f, 5.37286885e-02f, -7.33262673e-02f, 9.37326103e-02f, 8.84685945e-03f, 1.01036713e-01f, 6.07451312e-02f,
  -4.09385413e-02f, -6.30567670e-02f, 6.68458194e-02f, 5.16788587e-02f, 1.88037474e-02f, 8.54623988e-02f, -6.06384054e-02f, 1.07529908e-01f, -2.88163424e-02f, -7.25140516e-03f,
  3.18197832e-02f, 1.00171238e-01f, 4.84111719e-03f, 9.98554379e-02f, 1.92938950e-02f, 1.00444645e-01f, 5.88315018e-02f, -1.03898896e-02f, 3.79645228e-02f, 4.39590067e-02f,
  -2.39504538e-02f, -4.54073586e-02f, -4.73454827e-03f, 1.04298435e-01f, 6.88983053e-02f, 7.73564875e-02f, 1.50893675e-02f, 4.87567019e-03f, -6.87116310e-02f, 2.07778122e-02f,
  7.73222651e-03f, 1.20314039e-01f, -9.10729989e-02f, 1.23498179e-02f, 7.96354935e-02f, -5.81502169e-02f, -8.86221454e-02f, -2.97598448e-02f, 5.16986549e-02f, 1.01192266e-01f,
  -7.74209648e-02f, -1.01610012e-01f, 2.50533540e-02f, -9.83272940e-02f, -4.53564599e-02f, 4.02818695e-02f, -8.22795928e-02f, 3.21605578e-02f, 5.42170480e-02f, -7.25828260e-02f,
  -5.80775179e-02f, 5.83661050e-02f, 1.63535744e-01f, 7.29167089e-02f, 1.55056491e-01f, 3.23748738e-02f, -1.09111674e-01f, -9.51269194e-02f, 1.30029753e-01f, 5.99532351e-02f,
  3.88646610e-02f, -8.70506465e-02f, 1.38689391e-02f, -4.50850576e-02f, -4.60139439e-02f, 5.93527853e-02f, 1.06819548e-01f, -1.79807339e-02f, 6.66487962e-03f, -1.09880842e-01f,
  6.84168041e-02f, 3.55033390e-02f, 8.33963975e-02f, 3.84035036e-02f, 4.88322340e-02f, -4.73295450e-02f, -1.14547439e-01f, -6.18941560e-02f, 1.68477278e-02f, 1.19359598e-01f,
  -3.51816379e-02f, 1.34271532e-01f, -7.20707402e-02f, 4.93875779e-02f, 1.48366258e-01f, 5.87510727e-02f, -2.40217093e-02f, 8.53490233e-02f, -3.46614309e-02f, -5.87974414e-02f,
  -4.29603606e-02f, -4.29644771e-02f, -1.12187602e-01f, -1.23152435e-02f, 2.05930881e-02f, 1.33065626e-01f, 1.23193346e-01f, 3.62474807e-02f, 1.36142492e-01f, -3.71650904e-02f,
  7.03353137e-02f, -1.74661931e-02f, -1.70734003e-02f, 4.82267584e-04f, -1.24927340e-02f, 2.05860231e-02f, 8.18598643e-02f, 1.27704404e-02f, 8.32262933e-02f, -1.78388003e-02f,
  -8.51217583e-02f, 9.02360119e-03f, 5.32177463e-03f, 2.99783181e-02f, 4.06781211e-04f, 6.60907775e-02f, 7.68438652e-02f, 7.63251707e-02f, 2.69251354e-02f, -4.90966588e-02f,
  8.96129534e-02f, 1.09255888e-01f, -8.72111768e-02f, -3.29504575e-04f, 1.02351137e-01f, -3.48373391e-02f, 5.18091545e-02f, -1.41861243e-02f, -1.05614476e-02f, 1.03468277e-01f,
  5.09144031e-02f, 5.73829189e-02f, 6.93287402e-02f, 7.51843899e-02f, -4.32153083e-02f, -5.68975024e-02f, 1.21359259e-01f, -4.21445444e-02f, -3.03635970e-02f, -2.66008824e-03f,
  -4.76276204e-02f, -8.26420486e-02f, 8.35097209e-02f, 2.32146308e-02f, 1.20043010e-01f, 1.47995763e-02f, 1.19163662e-01f, 5.52809648e-02f, -4.83276546e-02f, 6.73866943e-02f,
  7.93144628e-02f, 1.40994992e-02f, 8.04397911e-02f, 1.08118944e-01f, 1.20065197e-01f, -5.35483286e-02f, 3.14911082e-02f, -1.31980702e-02f, 1.09120734e-01f, 6.55720532e-02f,
  -6.53686225e-02f, 1.33979321e-01f, -2.52775215e-02f, 1.34340480e-01f, 4.56103496e-02f, -1.68467596e-01f, 2.98721585e-02f, -1.05771460e-01f, 1.20570928e-01f, -5.02724349e-02f,
  1.69993602e-02f, -1.75149441e-01f, -1.66185096e-01f, 1.09982066e-01f, -8.67944583e-02f, 7.15254024e-02f, 6.69648079e-03f, -1.63536668e-01f, -3.74037959e-02f, -8.23339075e-02f,
  -3.52466889e-02f, 1.08472981e-01f, 2.14793995e-01f, 1.53272763e-01f, -1.12180173e-01f, -4.12874371e-02f, -4.50783223e-02f, -1.23483008e-02f, 1.22892372e-01f, 5.50727062e-02f,
  -5.44777662e-02f, -2.88752168e-02f, -6.31149188e-02f, -3.56651358e-02f, 4.68900725e-02f, -4.19161692e-02f, 6.35255575e-02f, -1.17087200e-01f, -1.44359991e-01f, -6.35702163e-03f,
  -5.07743657e-02f, -2.58083679e-02f, -2.48481277e-02f, 4.33868580e-02f, -1.69096813e-01f, -3.44514810e-02f, -7.06987455e-02f, 7.06444457e-02f, -2.58800276e-02f, 9.26316306e-02f,
  -6.97778687e-02f, 1.22086488e-01f, 5.60734235e-02f, -1.28687723e-02f, -9.88864154e-02f, -1.18861748e-02f, 7.09045306e-02f, 9.87353772e-02f, -1.11004561e-02f, -5.03446646e-02f,
  -4.65836450e-02f, 5.18984310e-02f, -6.70286566e-02f, 3.48103722e-03f, -7.26670586e-03f, 4.30630408e-02f, 7.42138773e-02f, 6.79234695e-03f, -2.62668338e-02f, -7.02542290e-02f,
  5.55658489e-02f, 6.03061095e-02f, 8.38368833e-02f, -5.41586727e-02f, 7.46496394e-02f, -1.06284730e-01f, 1.27070844e-01f, -5.03629558e-02f, -4.20701951e-02f, 3.69672738e-02f,
  -1.43550113e-02f, 5.67773171e-02f, 1.10380717e-01f, 7.09944889e-02f, 2.90162005e-02f, 1.12560764e-02f, 4.98072095e-02f, 8.94813333e-04f, 3.80232446e-02f, -1.40138436e-02f,
  1.46963790e-01f, -1.60618350e-02f, 6.74478412e-02f, 1.45643249e-01f, 1.61393099e-02f, 1.85482781e-02f, 1.56233376e-02f, 1.51905105e-01f, 1.07339129e-01f, -3.66735272e-02f,
  -7.42929522e-03f, -6.08872809e-02f, 5.79635836e-02f, 1.77375391e-01f, 3.52583788e-02f, 1.32918715e-01f, 3.06276456e-02f, -4.27578241e-02f, 5.69074638e-02f, 7.53731700e-03f,
  1.03471585e-01f, 1.12319300e-02f, -3.72038111e-02f, 1.10629223e-01f, 1.25908449e-01f, 2.24650800e-02f, 3.85889725e-04f, 1.35400251e-01f, -1.55321304e-02f, 7.67292455e-02f,
  -3.68883088e-02f, 8.78585503e-03f, 2.56024692e-02f, 8.46453533e-02f, 1.25208259e-01f, 8.81940052e-02f, -7.61644095e-02f, -2.04294175e-02f, 1.28336087e-01f, -2.77145766e-02f,
  -1.07595824e-01f, -1.22975305e-01f, 3.10246050e-02f, 3.71301174e-02f, -3.26918177e-02f, 4.80547867e-04f, -1.05447173e-02f, 3.46409418e-02f, 8.19597617e-02f, 4.38391119e-02f,
  -8.78322646e-02f, 1.14617184e-01f, -2.33363593e-03f, -1.39388777e-02f, -1.03099100e-01f, 1.19892918e-01f, -1.35956883e-01f, 7.52534568e-02f, 1.08095974e-01f, -1.14797644e-01f,
  -1.00790625e-04f, -4.58572432e-02f, 8.79704654e-02f, -1.38758704e-01f, 3.89465280e-02f, -1.95680857e-01f, -8.79008789e-03f, -1.37914091e-01f, -1.15092665e-01f, 1.55546650e-01f,
  -3.89657281e-02f, 7.06699789e-02f, -4.00033146e-02f, -5.39241917e-02f, -1.60182938e-01f, -5.03443070e-02f, 9.44606122e-03f, 6.61027655e-02f, 4.93102856e-02f, 7.01563805e-02f,
  -5.25191687e-02f, -9.12971720e-02f, 6.22218400e-02f, -1.04518384e-02f, -9.52502415e-02f, -3.99946645e-02f, 5.13830334e-02f, 1.01229846e-01f, -7.20674470e-02f, 1.60388909e-02f,
  -6.97790310e-02f, 5.20098582e-02f, -1.91529803e-02f, 6.81310743e-02f, -7.62406588e-02f, -1.13225013e-01f, 1.19290143e-01f, -8.66808817e-02f, -1.18482091e-01f, 2.28820629e-02f,
  1.23716563e-01f, -1.07736304e-01f, -2.25705076e-02f, -4.16188166e-02f, 7.19247907e-02f, 4.77465093e-02f, -2.25972272e-02f, 3.66196483e-02f, -9.38638076e-02f, -4.97108363e-02f,
  5.38006425e-02f, 9.27964672e-02f, -2.48803366e-02f, -7.20107462e-03f, 3.90064456e-02f, 9.35391709e-03f, 1.55926272e-01f, 8.56160559e-03f, 2.36926191e-02f, 1.54382661e-01f,
  1.04840487e-01f, 3.99782397e-02f, 1.13289161e-02f, -2.13506501e-02f, -2.34220689e-03f, 1.20097762e-02f, 3.63401398e-02f, 1.05680645e-01f, 5.22354096e-02f, -1.63358599e-02f,
  4.51896824e-02f, 5.65137621e-03f, 2.92805173e-02f, 4.34642732e-02f, 6.26537651e-02f, 1.00803740e-01f, 1.12562999e-01f, 1.91284362e-02f, 6.76907673e-02f, 1.18317408e-02f,
  -1.25090946e-02f, 4.23410609e-02f, 1.14682600e-01f, 8.26500729e-02f, 4.75279503e-02f, 3.74154262e-02f, 1.34051755e-01f, 2.63695326e-02f, 9.07794945e-03f, 5.03825732e-02f,
  6.34616166e-02f, 2.86239609e-02f, -1.92213878e-02f, 9.97738093e-02f, -1.93265434e-02f, 1.07460372e-01f, -2.16948185e-02f, 5.97898848e-02f, 6.21514618e-02f, 6.85350373e-02f,
  3.97514068e-02f, -1.91848800e-02f, -6.03738204e-02f, 1.17649194e-02f, 5.61121153e-03f, -9.28370133e-02f, 4.84617837e-02f, -1.55345485e-01f, -3.27918828e-02f, 1.74413342e-03f,
  4.90575209e-02f, -8.67507653e-04f, -1.27074376e-01f, -6.06771267e-04f, -1.36735380e-01f, 2.50558998e-03f, 5.29964454e-02f, -1.78002175e-02f, 7.00812787e-02f, 6.65705875e-02f,
  -2.61003524e-02f, 1.04352318e-01f, -6.31078705e-02f, 1.81056131e-02f, -1.05079800e-01f, -7.78923109e-02f, -1.00597292e-01f, 5.54566532e-02f, -1.09954007e-01f, 7.55105342e-04f,
  1.47376016e-01f, 4.07019928e-02f, 8.34473893e-02f, 5.03215715e-02f, -1.01105079e-01f, -2.37160437e-02f, 1.66543230e-01f, 1.92664117e-02f, 1.68972149e-01f, 9.43120345e-02f,
  -1.60480261e-01f, 1.44760311e-01f, -6.22099824e-02f, 1.74411088e-01f, 3.22469287e-02f, -8.40670019e-02f, 9.32840481e-02f, 8.83424357e-02f, -7.52843097e-02f, -1.01870805e-01f,
  2.16090921e-02f, 1.36911169e-01f, -4.89261560e-03f, -8.45142156e-02f, -1.94218419e-02f, -7.70548955e-02f, -4.81365994e-02f, -6.14863299e-02f, -6.22736476e-02f, -3.26719210e-02f,
  5.90333454e-02f, -4.51310948e-02f, 5.87192066e-02f, -3.40591185e-02f, -3.97991203e-02f, -2.82447636e-02f, 8.67125317e-02f, 3.14823315e-02f, 5.88785931e-02f, 3.49641964e-02f,
  3.00655868e-02f, 8.05007592e-02f, 2.07093209e-02f, 4.99247909e-02f, 4.40813676e-02f, 1.27290055e-01f, -8.92782882e-02f, -4.38941009e-02f, -6.48676828e-02f, 2.66391281e-02f,
  -9.18570161e-03f, 2.39234436e-02f, -6.54053241e-02f, 2.10674424e-02f, 6.71018362e-02f, -6.07755780e-03f, 4.53456044e-02f, 4.43723947e-02f, 1.25945697e-03f, -1.22651337e-02f,
  4.50015854e-04f, 8.37883167e-03f, 5.48494868e-02f, 5.92747740e-02f, 8.60968828e-02f, -3.91988941e-02f, 4.35769632e-02f, -6.01990633e-02f, 6.33549839e-02f, 7.75728300e-02f,
  9.95899811e-02f, 8.34357440e-02f, -4.65446189e-02f, 7.79150054e-02f, -5.52919023e-02f, 8.01187158e-02f, 5.72493626e-03f, 2.07030457e-02f, 2.11441815e-02f, 6.39656112e-02f,
  -1.62325799e-02f, 4.67665456e-02f, 3.83996144e-02f, -6.59432635e-02f, 6.48489147e-02f, 1.16330847e-01f, 7.35859573e-02f, 1.02480367e-01f, -2.08148137e-02f, -4.11578566e-02f,
  2.66693253e-02f, 2.23635789e-02f, 1.40721034e-02f, 4.28732717e-03f, -4.79878746e-02f, -2.22802516e-02f, -6.09377921e-02f, 7.60917971e-03f, 7.08338013e-03f, -6.17745779e-02f,
  4.84017842e-02f, 9.00643226e-03f, 9.01965871e-02f, 7.08602294e-02f, 8.31105560e-02f, 1.42224562e-05f, -4.22697440e-02f, 1.38846666e-01f, 1.64746586e-03f, -1.87297482e-02f,
  5.06272279e-02f, -8.62453803e-02f, -4.51229550e-02f, -9.78137627e-02f, -1.63161643e-02f, -2.79762540e-02f, -5.15308380e-02f, 6.35046093e-03f, 3.38956118e-02f, -1.60008557e-02f,
  -4.82992344e-02f, -8.44034832e-03f, 1.11756334e-02f, 8.25050399e-02f, 1.41349360e-01f, -7.97610953e-02f, 8.42950344e-02f, 1.00591004e-01f, -5.60127161e-02f, -5.51964417e-02f,
  2.11956967e-02f, -6.81143068e-03f, -1.37892179e-02f, -7.43485093e-02f, -9.88157652e-03f, 2.95254122e-02f, -3.25219966e-02f, -7.74049014e-02f, 3.75499055e-02f, -1.94665771e-02f,
  9.56927612e-02f, -8.51996839e-02f, 4.46321666e-02f, -1.96017548e-02f, 5.49786864e-03f, -1.07248072e-02f, -3.10746003e-02f, -9.09645781e-02f, -1.69239286e-02f, -2.96676774e-02f,
  -4.23415639e-02f, 2.62725763e-02f, -9.13598314e-02f, -5.35387211e-02f, -3.00969612e-02f, 1.02973051e-01f, 9.99535546e-02f, -8.60471800e-02f, -3.12499795e-02f, 1.04308529e-02f,
  -1.53483236e-02f, -1.01203941e-01f, -3.52953225e-02f, -5.48623428e-02f, -1.26516998e-01f, 1.25706531e-02f, -7.26825073e-02f, 1.87710691e-02f, -3.60376365e-03f, 6.07661083e-02f,
  7.62989372e-02f, 8.38777944e-02f, -2.54056416e-02f, -4.78432849e-02f, 7.88972974e-02f, -2.98426095e-02f, 7.84171745e-03f, 4.54508662e-02f, 1.70517806e-02f, 1.03046916e-01f,
  -1.07876351e-02f, 9.14974287e-02f, 2.02402659e-02f, 1.16233356e-01f, 2.40957737e-02f, 3.53151783e-02f, 9.92940292e-02f, 6.21924251e-02f, 9.47068632e-02f, 3.73756327e-02f,
  5.98240942e-02f, -3.28465775e-02f, 1.05879195e-01f, 8.52506384e-02f, -5.07043339e-02f, 6.89175278e-02f, 1.10301271e-01f, 5.42253479e-02f, -3.92867215e-02f, 7.00352574e-03f,
  -6.49339110e-02f, -5.95346577e-02f, -5.20553067e-02f, 7.55620888e-03f, -5.78702253e-04f, 7.52573833e-02f, 6.16401285e-02f, 5.02424315e-02f, 3.99868712e-02f, -1.16968732e-02f,
  8.31037760e-02f, 9.36955959e-02f, 3.76638062e-02f, -5.41644171e-02f, 1.42074730e-02f, 4.60175872e-02f, 3.27516869e-02f, 7.23859668e-02f, -6.37414828e-02f, 1.20552279e-01f,
  -5.81761487e-02f, 3.92336696e-02f, -4.29658070e-02f, 6.46632584e-03f, 1.08361222e-01f, 2.51595285e-02f, 8.66031945e-02f, 3.26453969e-02f, -5.30477241e-02f, -6.56667631e-03f,
  5.24428226e-02f, 1.08988741e-02f, -5.81835862e-03f, 1.00858159e-01f, 1.11932054e-01f, 1.08642526e-01f, 8.86878893e-02f, -1.15447700e-01f, 8.83625299e-02f, 6.40241941e-03f,
  8.59885141e-02f, -2.25930549e-02f, 6.53678998e-02f, -5.99416979e-02f, -1.52391881e-01f, 1.62218660e-01f, -4.64785770e-02f, 9.84161422e-02f, -1.17303833e-01f, -9.59985852e-02f,
  -9.29551721e-02f, -1.16212443e-01f, 4.13130857e-02f, 1.19762406e-01f, 1.15232810e-01f, 1.45797357e-01f, -6.69485033e-02f, 3.02354875e-03f, 6.79966286e-02f, -5.11174388e-02f,
  3.90008092e-02f, -5.25075234e-02f, -1.78392511e-02f, 1.24574564e-01f, -2.37370990e-02f, 2.54260059e-02f, 7.25204125e-02f, -2.17757933e-02f, -6.07313663e-02f, -4.88874987e-02f,
  -1.82892457e-01f, 2.21219175e-02f, 1.26758471e-01f, 1.35153234e-01f, 2.29899399e-02f, -1.50427207e-01f, -4.70699407e-02f, 4.48148921e-02f, -1.04527371e-02f, 1.10194478e-02f,
  -6.56879842e-02f, 6.06720038e-02f, -1.17544774e-02f, -2.95529962e-02f, 1.71293356e-02f, 8.88950676e-02f, -1.90272294e-02f, 4.35791016e-02f, 6.91357628e-02f, -9.19467676e-03f,
  -7.90032148e-02f, 9.61496904e-02f, 5.19732945e-02f, 1.15150683e-01f, 9.04689357e-02f, 1.06971987e-01f, -2.96918526e-02f, -2.08794624e-02f, 5.54181524e-02f, -7.92668015e-03f,
  -2.34265961e-02f, -1.66688487e-02f, -3.90143022e-02f, -5.61863296e-02f, 5.97535707e-02f, 1.70100760e-03f, 8.33029971e-02f, -4.38803434e-02f, -3.72318067e-02f, -5.33524668e-03f,
  -3.04238312e-02f, 2.88041569e-02f, 9.42011401e-02f, 4.56297211e-02f, 2.88914051e-02f, 9.04736444e-02f, 1.89272268e-03f, -3.60893533e-02f, 3.57118994e-02f, -6.85814545e-02f,
  -1.10116433e-02f, -6.25241697e-02f, 2.61385925e-02f, 5.74698001e-02f, -2.08124556e-02f, 2.42544804e-02f, -5.42983264e-02f, 6.06983081e-02f, -2.84303352e-02f, -1.52942101e-02f,
  -3.23984921e-02f, 6.68180510e-02f, -7.95369893e-02f, 9.85909700e-02f, -1.46505348e-02f, 2.13751905e-02f, -1.57443248e-02f, -7.52722621e-02f, -6.78441226e-02f, -2.79092067e-03f,
  2.46494077e-02f, 5.69310114e-02f, -4.21299674e-02f, -5.29221110e-02f, -1.79321896e-02f, 2.27023475e-02f, -3.07557993e-02f, -6.08955845e-02f, 9.17866006e-02f, 1.88589506e-02f,
  -3.54461931e-03f, 3.43142711e-02f, 9.85421892e-03f, 1.73147507e-02f, 2.66341828e-02f, 3.79202440e-02f, -8.11129287e-02f, 4.50339308e-03f, -2.61904523e-02f, 1.06384349e-03f,
  -7.56889209e-02f, -4.21511494e-02f, 9.80768651e-02f, 6.50351793e-02f, 6.23781458e-02f, 3.71273467e-03f, -4.97810058e-02f, 6.87887520e-02f, 1.08823150e-01f, 2.41559409e-02f,
  2.81436890e-02f, -6.87082410e-02f, -5.56944869e-02f, 8.16673599e-03f, 6.32190332e-02f, 1.53992577e-02f, -1.35335326e-02f, 2.80756373e-02f, -3.36812213e-02f, -6.38999641e-02f,
  -9.19579789e-02f, 3.30706537e-02f, -3.70282792e-02f, 6.72592521e-02f, -6.62428811e-02f, 9.17305201e-02f, 5.32189943e-02f, -4.23651412e-02f, 6.29470423e-02f, 8.72757584e-02f,
  -5.01080863e-02f, 3.37316692e-02f, -8.63618478e-02f, 2.61516795e-02f, 3.80342081e-02f, -9.00065154e-02f, 3.99826020e-02f, 5.40780500e-02f, 5.30958325e-02f, -8.38776603e-02f,
  -1.94989964e-02f, 3.42698805e-02f, -6.76705018e-02f, 2.05863975e-02f, -7.80789107e-02f, -4.72445711e-02f, -8.45846012e-02f, 1.46975406e-02f, -4.08485718e-02f, 4.02899347e-02f,
  1.44941602e-02f, 2.34134626e-02f, 5.88133782e-02f, 4.78777476e-02f, -4.58448119e-02f, 5.74363060e-02f, -7.61761516e-02f, 7.50653744e-02f, 4.73002009e-02f, 2.42926553e-02f,
  -1.21324705e-02f, -4.68674041e-02f, -6.94206031e-03f, 5.36293276e-02f, 5.76512590e-02f, 8.03796053e-02f, 3.40888426e-02f, 8.74819905e-02f, 8.45597237e-02f, -9.83338151e-03f,
  6.93767741e-02f, 5.88846318e-02f, -4.52028923e-02f, -4.33682697e-03f, 1.01769574e-01f, 1.00808054e-01f, 4.50453348e-02f, 9.10150707e-02f, 3.97768989e-02f, 1.03229322e-01f,
  1.61937758e-01f, 7.48649463e-02f, 1.02207907e-01f, -3.54780559e-03f, 7.15338290e-02f, 9.03329812e-03f, 1.28097862e-01f, 9.08148512e-02f, 7.01348856e-02f, 9.20682997e-02f,
  1.24975935e-01f, 6.69637620e-02f, 2.15952247e-02f, 7.94138312e-02f, -2.62446404e-02f, 7.85710588e-02f, -5.32255806e-02f, 2.81448103e-02f, -4.79796976e-02f, 7.56657822e-03f,
  1.17840722e-01f, 5.19970097e-02f, -1.67351775e-02f, -8.43341202e-02f, -4.21354808e-02f, 4.91012931e-02f, -5.84640093e-02f, -6.26967028e-02f, -4.35155965e-02f, 8.57518241e-02f,
  3.75828519e-02f, 1.48979016e-02f, 1.40169952e-02f, -8.07469264e-02f, -2.17255764e-02f, 1.85405705e-02f, 1.05163164e-01f, 1.03524603e-01f, 7.28173628e-02f, 4.11220044e-02f,
  3.80354710e-02f, 9.70615149e-02f, 2.59028492e-03f, 1.26891345e-01f, -3.15676481e-02f, 9.67359766e-02f, 9.20989811e-02f, 1.64273381e-02f, -1.08504398e-02f, -7.22547760e-04f,
  7.44356215e-02f, 1.32522389e-01f, 4.00707088e-02f, -7.60672539e-02f, 1.06758609e-01f, 4.38632704e-02f, -1.50664821e-01f, -1.22792013e-01f, -5.48209548e-02f, 8.21964145e-02f,
  -2.39176117e-02f, 5.83514199e-02f, -1.14832640e-01f, 1.40390486e-01f, -1.22284450e-01f, 7.33200535e-02f, -9.32730734e-02f, -7.11470917e-02f, -2.89674159e-02f, 8.20765644e-02f,
  8.27999264e-02f, 5.57844080e-02f, 8.44018068e-03f, 1.83866084e-01f, 2.33262166e-01f, 1.66989535e-01f, 1.28372088e-01f, -2.34194230e-02f, 1.49099320e-01f, -9.87976044e-02f,
  1.05279282e-01f, 7.38674775e-02f, 3.57676968e-02f, -4.18540165e-02f, 1.68032676e-01f, -3.49465385e-03f, 9.53920782e-02f, 1.20459177e-01f, -1.23673633e-01f, -1.17836207e-01f,
  4.49125357e-02f, -8.99425000e-02f, 6.79807514e-02f, -4.28870842e-02f, 8.97285268e-02f, 1.26460582e-01f, 9.03987288e-02f, -2.63634901e-02f, -6.95208013e-02f, -6.58819601e-02f,
  3.16719376e-02f, 8.87939110e-02f, 9.44099501e-02f, 9.33429692e-03f, -3.83711932e-03f, 1.12480633e-01f, -8.83256793e-02f, 1.11105435e-01f, 1.19400911e-01f, 2.66794525e-02f,
  -2.23197024e-02f, 4.71372642e-02f, 9.00546461e-02f, -6.49792701e-02f, 2.21004300e-02f, -5.02546169e-02f, 1.02752507e-01f, 4.95468713e-02f, 9.21777263e-03f, 4.99669909e-02f,
  4.79410812e-02f, -1.32169621e-02f, 2.30553038e-02f, 9.61572491e-03f, -7.08062872e-02f, -6.74100220e-02f, 3.02557275e-02f, -1.54211754e-02f, 5.56797124e-02f, 7.48031307e-03f,
  4.66196798e-02f, -6.26174212e-02f, -2.87318435e-02f, -3.37381214e-02f, -3.46215181e-02f, -2.20258590e-02f, -6.66266233e-02f, 5.54762408e-02f, -1.65651813e-02f, 7.04462305e-02f,
  3.36169787e-02f, -7.31664822e-02f, 5.65826520e-02f, -2.32848786e-02f, 1.22051062e-02f, -6.57707229e-02f, 5.58388839e-03f, -4.22941335e-02f, 6.19888538e-03f, -7.73459161e-03f,
  1.33940605e-02f, 7.72773027e-02f, -2.52928548e-02f, -9.03687254e-03f, 9.47631523e-03f, -2.52802316e-02f, 1.82753224e-02f, 7.91137367e-02f, 8.26502498e-03f, 1.74380131e-02f,
  5.31768389e-02f, -3.52461338e-02f, -4.39583883e-02f, -1.82969775e-02f, 2.72276308e-02f, 6.49192045e-03f, 2.52567092e-03f, 1.97463389e-02f, -3.87540162e-02f, 4.76135127e-02f,
  1.10139083e-02f, 7.07020238e-02f, 9.65654179e-02f, 2.64601633e-02f, 5.61152473e-02f, 4.12914567e-02f, 2.23755669e-02f, -5.78997694e-02f, 3.76406722e-02f, 5.71440831e-02f,
  5.31240776e-02f, -2.42484454e-02f, -5.34611046e-02f, 4.03480530e-02f, 4.46413308e-02f, -5.77348471e-02f, 5.24695180e-02f, 4.54555787e-02f, -3.78628783e-02f, -5.13475016e-02f,
  -3.60624455e-02f, 3.13614644e-02f, -6.75202580e-03f, 5.42651536e-03f, 5.35731390e-02f, 1.01833485e-01f, 6.66243881e-02f, 6.09961711e-02f, 2.92309262e-02f, 7.10285679e-02f,
  5.71297519e-02f, 7.40647316e-02f, 5.05984854e-03f, -1.99836716e-02f, 9.71039683e-02f, 5.58488853e-02f, 4.94739711e-02f, 2.83245016e-02f, 8.28057677e-02f, 6.44535050e-02f,
  -4.08326648e-02f, -8.45405534e-02f, -7.98985809e-02f, -3.01942863e-02f, 1.09017521e-01f, -5.03278151e-02f, -1.25573883e-02f, -9.19110775e-02f, -1.59380734e-02f, -6.70520812e-02f,
  -5.74315898e-02f, 4.51353826e-02f, -1.57544315e-02f, 7.07602948e-02f, -7.10540041e-02f, -1.73387676e-02f, -8.24070647e-02f, 4.47876453e-02f, 3.23504806e-02f, -1.77602749e-02f,
  8.94557908e-02f, 6.55707791e-02f, 7.62974024e-02f, -4.98464666e-02f, -2.71597859e-02f, -2.80536897e-02f, 1.36245284e-02f, -1.47572793e-02f, 2.24669408e-02f, 9.45202559e-02f,
  7.85338879e-02f, 7.04984218e-02f, 6.14934489e-02f, -7.68411998e-03f, -4.54388037e-02f, 2.05678828e-02f, 2.90660374e-02f, -6.74685016e-02f, -4.54392210e-02f, -6.19121119e-02f,
  2.78095193e-02f, -4.09522420e-03f, 9.18967500e-02f, 6.79497346e-02f, 1.47725679e-02f, -5.81174716e-02f, -4.33070175e-02f, 2.36000679e-02f, -2.96338517e-02f, 3.85482274e-02f,
  4.31602485e-02f, 1.03369348e-01f, 8.90933797e-02f, -3.17921094e-03f, -3.08411047e-02f, 1.02696065e-02f, 7.95573145e-02f, 6.62117526e-02f, 2.38533523e-02f, -1.84728652e-02f,
  2.33268645e-02f, 3.09656598e-02f, 2.48295162e-02f, 1.04712971e-01f, -1.22032603e-02f, 6.63120002e-02f, 2.05855984e-02f, 1.53758693e-02f, 7.62555888e-03f, -1.75389752e-03f,
  -2.36344244e-02f, -3.86345387e-02f, -6.10906743e-02f, 1.11803841e-02f, -4.24455702e-02f, -4.02649865e-02f, 7.38784075e-02f, 1.22913318e-02f, 1.46678071e-02f, -3.44441421e-02f,
  8.58655125e-02f, -4.75564320e-03f, -1.48692355e-02f, -3.54729295e-02f, 6.91794679e-02f, 4.36636284e-02f, 6.39849529e-02f, -5.53111210e-02f, -2.69379355e-02f, 7.02003837e-02f,
  3.10555268e-02f, -7.21164271e-02f, 1.12473242e-01f, -1.47472629e-02f, -8.35688412e-02f, 3.80563810e-02f, -6.51414841e-02f, -3.76047529e-02f, -7.19689056e-02f, -1.63849685e-02f,
  -2.63355412e-02f, 6.12495951e-02f, 6.90174550e-02f, 5.39379828e-02f, 5.71817048e-02f, 2.58642193e-02f, -4.65259440e-02f, -1.27094258e-02f, -6.24374673e-02f, 4.73461440e-03f,
  6.60091564e-02f, -6.93165138e-02f, 7.25904107e-02f, 4.22373824e-02f, 4.28889878e-02f, 3.60436030e-02f, 8.32395777e-02f, 3.66576202e-02f, -8.82374123e-02f, 4.73180786e-02f,
  -6.12466447e-02f, 1.74328778e-02f, -1.00183919e-01f, -3.40260230e-02f, 7.15007782e-02f, -1.12667553e-01f, -2.91103888e-02f, 9.46116969e-02f, 4.04478349e-02f, -4.03724648e-02f,
  -6.32918999e-02f, 4.08892408e-02f, 7.04063401e-02f, 5.86516522e-02f, 3.61521468e-02f, -1.02695622e-01f, -7.97519758e-02f, -3.64178941e-02f, -6.13101386e-02f, -8.58450606e-02f,
  6.55791387e-02f, -6.23658672e-02f, 1.12629637e-01f, 5.47079891e-02f, -8.12684074e-02f, -2.27034148e-02f, 9.62470621e-02f, -3.64381149e-02f, 4.04232554e-02f, 2.85615046e-02f,
  -7.72201419e-02f, 2.03193240e-02f, 2.93929037e-02f, 5.82367033e-02f, 6.13016784e-02f, -4.59961146e-02f, -2.64281426e-02f, 3.99525911e-02f, 8.94492343e-02f, 1.05304725e-01f,
  1.95803344e-02f, 5.07025011e-02f, 7.55379125e-02f, 1.14644235e-02f, -6.29101843e-02f, 2.59628501e-02f, -8.90870765e-02f, 2.65619834e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -8.86140391e-02f, 1.19534329e-01f, 1.07662249e-02f, 8.73964396e-04f, 6.24472313e-02f, 1.01601355e-01f, 1.16649292e-01f, 6.76138178e-02f, 7.37742521e-03f, 6.74429387e-02f,
  -3.39147635e-02f, 4.54034135e-02f, 5.16819358e-02f, 2.96041183e-03f, 3.66715789e-02f, -1.66010548e-04f, 6.14039563e-02f, 4.72905999e-03f, 1.14491276e-01f, -4.40885015e-02f,
  1.61077771e-02f, -4.86419834e-02f, -1.50093418e-02f, 1.39547493e-02f, 9.30676162e-02f, 6.53312057e-02f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  3.77858290e-03f, 6.78464919e-02f, 1.97045412e-02f, 1.43373802e-01f, 6.75246865e-02f, 6.54532714e-03f, -6.39965981e-02f, 7.19399452e-02f, 4.33374047e-02f, 5.49459942e-02f,
  -1.99029502e-02f, 2.83762030e-02f, 2.16068439e-02f, 2.10708752e-02f, -7.93101639e-03f, -1.96574897e-01f, -3.52384329e-01f, 1.45506516e-01f, -3.00971586e-02f, -6.98639676e-02f,
  2.19960466e-01f, -1.93290599e-03f, -4.46411371e-02f, -1.56755105e-01f, 7.98483863e-02f, -8.87970701e-02f, -1.10381082e-01f, -2.00860783e-01f, -6.66183233e-02f, 3.50393020e-02f,
  -1.93024755e-01f, 7.00375587e-02f, -2.23306790e-01f, 4.42978367e-02f, 2.13918164e-02f, -3.33072424e-01f, 9.90218967e-02f, 1.64353494e-02f, -1.47221563e-02f, 1.38202563e-01f,
  -7.91362673e-02f, 1.46571785e-01f, -3.21026266e-01f, 1.62372097e-01f, -1.45382173e-02f, -4.09163162e-03f, 7.18045086e-02f, -2.12236151e-01f, -1.09798133e-01f, 7.03597069e-02f,
  6.45468831e-02f, -2.89604843e-01f, -2.60847926e-01f, -2.20835313e-01f, -8.64835605e-02f, -1.31494358e-01f, 2.16930032e-01f, -1.99816659e-01f, -7.22804889e-02f, 1.00628309e-01f,
  -3.93152796e-02f, 2.28696018e-01f, -4.27834988e-02f, 2.70330966e-01f, 3.26955706e-01f, 3.11424345e-01f, -2.04193100e-01f, -2.60895312e-01f, 1.62378043e-01f, -4.42493446e-02f,
  -7.34139904e-02f, -2.19596848e-01f, 5.60379922e-02f, -2.02636290e-02f, -1.02227278e-01f, -1.23570397e-01f, -2.97097951e-01f, 3.13158453e-01f, 3.33662122e-01f, 2.75783986e-01f,
  -2.08186492e-01f, 2.14154214e-01f, 8.08710977e-02f, -1.28166899e-01f, 2.36719504e-01f, -9.88504142e-02f, 2.11380675e-01f, -1.43807694e-01f, -1.24651656e-01f, -1.55735314e-01f,
  -1.80839628e-01f, 2.85526216e-01f, -8.00126977e-03f, -1.84101999e-01f, -2.19410416e-02f, -8.47599432e-02f, -1.13358080e-01f, 1.24629423e-01f, -2.77673721e-01f, 1.66126654e-01f,
  3.36910337e-02f, -8.23687315e-02f, 8.24738964e-02f, 1.13948688e-01f, -4.15761024e-01f, 3.97443585e-02f, -2.46500038e-02f, 5.43945469e-02f, 2.33791769e-01f, 7.84195308e-03f,
  6.48958609e-02f, -2.26424888e-01f, -3.65865938e-02f, 3.09963487e-02f, -5.83525859e-02f, -2.40686443e-02f, 1.12242125e-01f, 1.65934861e-01f, 6.71418160e-02f, -9.83898938e-02f,
  1.97529957e-01f, 9.00635123e-02f, 1.77793894e-02f, 1.86065421e-01f, -1.20379133e-02f, 6.03462458e-02f, 4.41713929e-02f, -1.47315621e-01f, 1.29355490e-02f, 1.84230387e-01f,
  -1.54467598e-02f, -3.88365030e-01f, 1.47558510e-01f, 4.63517532e-02f, 2.62974296e-02f, -1.21379256e-01f, -1.27502680e-01f, -1.27293527e-01f, 3.84559296e-03f, -1.34775013e-01f,
  1.59680679e-01f, -1.86242554e-02f, -1.47693884e-02f, -1.24814622e-01f, -1.67113677e-01f, 2.15733692e-01f, 4.31763865e-02f, 5.71900932e-03f, -1.26581993e-02f, -8.04972928e-03f,
  1.41965747e-01f, 1.99579075e-02f, -1.55682534e-01f, -4.94043306e-02f, 3.87567915e-02f, 8.43682587e-02f, 1.57646555e-02f, -5.71453664e-03f, -8.29528049e-02f, 1.87283561e-01f,
  -5.94240353e-02f, 2.09426899e-02f, 1.35617852e-01f, -2.45266140e-01f, 4.76049185e-02f, -2.56968476e-02f, 4.49468531e-02f, -1.03487156e-01f, -2.35154759e-02f, 1.57902032e-01f,
  1.87248632e-01f, 5.12504689e-02f, -9.38004479e-02f, 6.74841926e-02f, 1.27848044e-01f, 1.42755121e-01f, -1.65519878e-01f, -2.03356910e-02f, 1.07041769e-01f, -4.79792915e-02f,
  1.08728305e-01f, 1.94428653e-01f, -3.33237022e-01f, 1.32344291e-01f, -2.62121677e-01f, -2.29548320e-01f, 2.85245419e-01f, 2.48561371e-02f, -2.79411256e-01f, 1.44226938e-01f,
  -1.11986361e-01f, -4.52246256e-02f, 3.68778884e-01f, 4.09675121e-01f, -2.10963964e-01f, -2.84150600e-01f, -2.19962910e-01f, 2.30572559e-02f, -1.94970332e-03f, 1.81538925e-01f,
  2.94142608e-02f, -2.20301319e-02f, -2.95320563e-02f, -3.03848088e-01f, 9.38472003e-02f, 1.07748158e-01f, 1.79409400e-01f, 4.24889922e-02f, 9.76189133e-03f, 2.74007678e-01f,
  1.91693738e-01f, -1.43582657e-01f, 1.74861550e-01f, 6.58518299e-02f, 4.67707425e-01f, 2.31495947e-01f, -1.23220146e-01f, 9.53928307e-02f, 3.20387453e-01f, 1.92204744e-01f,
  1.04386188e-01f, -2.18101159e-01f, 2.46467844e-01f, 2.58120298e-01f, 2.17663780e-01f, -2.13048711e-01f, 1.73677668e-01f, 1.50463060e-01f, -1.55183941e-01f, -5.32499589e-02f,
  -1.90618094e-02f, 4.23765808e-01f, 2.62376785e-01f, -1.11701749e-01f, -3.73566337e-02f, -2.04374250e-02f, 1.15090571e-01f, 7.68036768e-02f, -9.35534202e-03f, -1.64102197e-01f,
  4.88230996e-02f, 3.19365188e-02f, -6.46711960e-02f, -9.20468867e-02f, 1.15754358e-01f, 7.17420923e-03f, -7.99466968e-02f, 4.66983439e-03f, -4.26578112e-02f, -3.80789377e-02f,
  -9.41556543e-02f, 7.70211294e-02f, 1.18226036e-01f, -3.85044515e-01f, 1.94861218e-02f, -6.22823015e-02f, -2.26255748e-02f, 1.35230729e-02f, -1.48041978e-01f, -2.26458743e-01f,
  -1.79799914e-01f, -5.29691465e-02f, 1.02104157e-01f, -1.09352851e-02f, 2.70129647e-03f, -1.57182455e-01f, -5.83415404e-02f, -1.25780866e-01f, 1.30925536e-01f, -7.70857334e-02f,
  7.43407607e-02f, 1.32380933e-01f, 1.06999323e-01f, 1.15113981e-01f, 1.80483535e-01f, 1.70494504e-02f, -2.16355890e-01f, -1.30666886e-03f, -5.79098798e-02f, 6.84012324e-02f,
  4.64665815e-02f, -3.70156281e-02f, 6.53714314e-02f, -6.98535293e-02f, -2.59411931e-02f, -9.28105786e-02f, 4.62453067e-02f, 1.68547779e-01f, 1.51207475e-02f, -3.12220585e-02f,
  3.96642722e-02f, 7.76048452e-02f, -1.39362812e-01f, -6.42447080e-03f, -8.11424106e-02f, -3.45355123e-02f, -8.59391987e-02f, 1.07997589e-01f, 8.78291652e-02f, 4.73208306e-03f,
  -1.10847510e-01f, -8.43167529e-02f, -2.22831070e-01f, -4.21147235e-03f, 1.28776869e-02f, -5.27071133e-02f, -1.93194941e-01f, -1.23892240e-01f, -2.61338830e-01f, 2.14697123e-01f,
  -1.35158852e-01f, 3.74111116e-01f, 1.67662665e-01f, -1.30292684e-01f, 2.54474077e-02f, -8.94935578e-02f, -1.65820673e-01f, -2.51986474e-01f, -1.52373463e-01f, 2.29161292e-01f,
  1.96376905e-01f, 6.49150684e-02f, 9.44137126e-02f, 1.04355641e-01f, -3.28648001e-01f, 2.27980707e-02f, 1.42776012e-01f, 7.56070986e-02f, 1.00276768e-01f, 1.73558906e-01f,
  -7.88818151e-02f, -1.76490650e-01f, 5.80055080e-02f, -6.80093169e-02f, 1.75512329e-01f, 6.54071942e-02f, 1.50197014e-01f, -1.48659632e-01f, 9.39458050e-03f, 1.27175689e-01f,
  -1.12454019e-01f, 1.53270885e-02f, -2.52419651e-01f, 1.45698413e-01f, 8.86657834e-02f, 3.11256468e-01f, -2.06920415e-01f, -1.93874091e-01f, 3.25161576e-01f, 1.25413612e-01f,
  2.99807638e-01f, 3.11939985e-01f, -3.11391681e-01f, -2.31597871e-01f, 1.58493012e-01f, 4.49825861e-02f, 1.07755549e-01f, -2.74894327e-01f, 8.53000581e-02f, -4.73548993e-02f,
  6.55004025e-01f, -2.90549602e-02f, 4.95651551e-02f, -1.73578914e-02f, -2.22659454e-01f, 1.65100724e-01f, -3.59693244e-02f, -7.20496327e-02f, -5.18124923e-02f, -2.39152327e-01f,
  -2.29357574e-02f, 2.62432098e-02f, 2.98520979e-02f, -7.62168616e-02f, 6.63644671e-02f, 1.25559688e-01f, -3.09374362e-01f, -7.04783872e-02f, 1.74267776e-02f, -1.20562345e-01f,
  9.17472020e-02f, 1.10394105e-01f, 4.48020026e-02f, 1.84270248e-01f, -8.05540234e-02f, -1.77500531e-01f, -2.38492996e-01f, -2.57002771e-01f, -7.96095878e-02f, 1.03870839e-01f,
  -1.27731794e-02f, 2.34111305e-02f, 6.57630563e-02f, -3.65107916e-02f, 3.98140028e-02f, 5.04463576e-02f, 3.03279776e-02f, -3.49193186e-01f, 5.38774254e-03f, 5.63405752e-02f,
  -3.72056551e-02f, -2.14610659e-02f, -2.80366205e-02f, 5.61809912e-02f, 8.51025879e-02f, -2.26754904e-01f, -2.87984535e-02f, 1.42464647e-02f, -1.60104185e-01f, -2.07374617e-02f,
  3.88241955e-03f, -1.87279597e-01f, 6.70976788e-02f, -9.49723348e-02f, -3.88508514e-02f, -1.86700165e-01f, -9.40783247e-02f, 2.05244161e-02f, 9.08071771e-02f, -1.76337138e-01f,
  1.74503103e-02f, -2.41141185e-01f, -3.63286853e-01f, 8.10969844e-02f, -1.01842266e-02f, -1.70444891e-01f, -1.71629995e-01f, -1.73669547e-01f, -2.52813160e-01f, -2.00918734e-01f,
  8.34189281e-02f, -2.22589388e-01f, -1.03754908e-01f, 1.04641110e-01f, 8.89542699e-03f, 4.87978533e-02f, 1.89736471e-01f, -3.45940083e-01f, 3.27710360e-01f, -1.55754596e-01f,
  -1.01764016e-01f, -1.51737556e-01f, 1.70432761e-01f, -3.66398692e-02f, 2.01606542e-01f, -4.12144847e-02f, -5.25767542e-02f, -1.10643387e-01f, -1.48410544e-01f, -5.95435174e-03f,
  1.30894348e-01f, -3.45266499e-02f, 1.07133485e-01f, 1.13180004e-01f, -1.25860050e-01f, 4.49645370e-02f, -2.28480011e-01f, 2.26198584e-01f, 1.73048913e-01f, 3.18667889e-01f,
  -7.97454640e-02f, 2.11954355e-01f, -1.16238169e-01f, 2.90275668e-03f, -1.62009373e-01f, -2.02178717e-01f, -1.16818853e-01f, -1.52338833e-01f, 1.25780925e-01f, 7.97604173e-02f,
  2.30449840e-01f, -2.19550639e-01f, 2.14126676e-01f, -2.26667210e-01f, -2.29991153e-01f, 2.81430017e-02f, -1.13664322e-01f, -6.63947240e-02f, -6.30568191e-02f, -5.32548279e-02f,
  1.26654819e-01f, -6.03435971e-02f, -1.39738724e-01f, -2.83496737e-01f, -7.18175620e-02f, 1.62049636e-01f, -8.73447731e-02f, 9.08075050e-02f, -3.34872484e-01f, 1.83389321e-01f,
  -5.61837777e-02f, -1.20559655e-01f, -1.12453386e-01f, -9.30680856e-02f, 9.22405906e-03f, -1.59867778e-01f, -3.04037724e-02f, 2.38878563e-01f, 8.26340467e-02f, 5.10392189e-02f,
  3.11749697e-01f, -9.41836238e-02f, 1.95113540e-01f, 3.45428705e-01f, -8.71080607e-02f, -2.46832028e-01f, 1.96740836e-01f, 2.60859072e-01f, 5.99650815e-02f, 1.04631372e-02f,
  4.01980095e-02f, -1.21894240e-01f, -5.40986359e-02f, 1.63637966e-01f, 6.56263009e-02f, 1.13641456e-01f, -1.96080450e-02f, -4.46145423e-03f, 3.54734845e-02f, 1.00643918e-01f,
  7.19756335e-02f, 9.64440033e-03f, -2.63174344e-02f, 1.98655427e-01f, 5.09945117e-02f, -1.53441941e-02f, 9.33097396e-03f, 1.32987827e-01f, 1.35449365e-01f, -2.00085402e-01f,
  -9.85135958e-02f, 1.08634923e-02f, 1.07532620e-01f, 1.71327069e-01f, 1.49233758e-01f, 1.80106610e-02f, -6.21198602e-02f, 1.17701918e-01f, 3.90010923e-02f, 2.40319669e-01f,
  1.17657267e-01f, -6.50176033e-02f, 1.47433639e-01f, 3.79738398e-03f, 1.11649252e-01f, -3.22680455e-03f, -8.57038274e-02f, 1.15399331e-01f, 1.28008768e-01f, 1.30486071e-01f,
  1.58690304e-01f, 1.81539524e-02f, 8.91306475e-02f, -2.03299046e-01f, 2.12717801e-02f, 7.21842945e-02f, 2.55430341e-01f, -2.86865048e-03f, -6.39739782e-02f, -6.24496117e-02f,
  2.38324702e-01f, -8.52586851e-02f, 4.46976237e-02f, 2.68117785e-01f, -1.40579790e-01f, -1.93814218e-01f, 3.80645961e-01f, 7.40320981e-02f, 2.76355982e-01f, 1.35230675e-01f,
  1.55112678e-02f, -2.13784739e-01f, 9.29290503e-02f, 1.35609865e-01f, -1.22110181e-01f, -1.86937243e-01f, -3.44691306e-01f, -7.39190429e-02f, 1.56687438e-01f, 4.33077738e-02f,
  7.20628351e-02f, -1.77924246e-01f, -1.30654752e-01f, -2.90085554e-01f, -5.82047328e-02f, -1.17828690e-01f, 1.06917657e-01f, 3.77195805e-01f, 1.22710645e-01f, 3.54786962e-01f,
  -1.71919107e-01f, -7.23138684e-04f, -2.11025059e-01f, 1.07283831e-01f, -9.48681161e-02f, -2.57147431e-01f, -2.38125622e-01f, -2.28710890e-01f, 6.26810119e-02f, -2.67141879e-01f,
  1.15873374e-01f, 3.85557935e-02f, 1.74931630e-01f, 2.32902750e-01f, -4.76975180e-02f, -1.70929223e-01f, 7.56111816e-02f, -2.39267275e-01f, -1.80997439e-02f, 1.85288951e-01f,
  -2.36133382e-01f, -1.31016180e-01f, 2.17265785e-01f, 2.00448975e-01f, 6.40430376e-02f, -1.11619778e-01f, -2.72531390e-01f, 1.91092744e-01f, -2.23631695e-01f, -1.30544521e-03f,
  1.80455253e-01f, 1.41827799e-02f, -3.24179120e-02f, 9.54611152e-02f, 8.36552866e-03f, -3.43028158e-02f, -2.58498434e-02f, -7.11015239e-02f, 1.32325754e-01f, -1.10413373e-01f,
  -1.42733186e-01f, 1.37257006e-03f, -2.25859344e-01f, 2.15064257e-01f, -1.28987253e-01f, 6.55425489e-02f, 4.23295610e-02f, 4.65935677e-01f, 5.61285354e-02f, -3.29927653e-02f,
  -3.98513814e-03f, -6.77503273e-02f, 6.47610277e-02f, 2.65978396e-01f, -1.96488407e-02f, 1.88180447e-01f, -5.92412520e-03f, -1.09791597e-02f, -2.97384895e-02f, 1.51874542e-01f,
  -1.69609815e-01f, 1.15940221e-01f, 4.47211228e-02f, 1.64366394e-01f, 2.76447207e-01f, -4.57216762e-02f, -2.36049108e-02f, 1.85964555e-01f, -1.50422856e-01f, -5.16511723e-02f,
  -2.29405779e-02f, 1.62487090e-01f, -5.73923141e-02f, -8.34215209e-02f, 1.19608790e-01f, 2.98591405e-02f, 1.47896066e-01f, 1.62844494e-01f, -5.14505943e-03f, 2.84439162e-03f,
  6.91866502e-02f, -5.51437121e-03f, 9.77422521e-02f, 1.90842062e-01f, 1.46887973e-01f, 3.19538742e-01f, 9.63264182e-02f, 5.56140579e-02f, 8.70976150e-02f, -2.10275948e-02f,
  -2.07740273e-02f, -6.19629910e-03f, -1.90514103e-02f, -1.16682336e-01f, 2.24362865e-01f, 1.06072657e-01f, -1.47457572e-03f, 7.72531852e-02f, -1.18469968e-01f, -2.79228631e-02f,
  -1.33241741e-02f, 7.42370188e-02f, 2.98993081e-01f, 5.99955097e-02f, -1.90565243e-01f, -1.38139874e-01f, -1.16955280e-01f, 2.75268614e-01f, -4.24789757e-01f, 6.65689185e-02f,
  2.37937849e-02f, 2.88879752e-01f, -4.70878333e-02f, -2.60972321e-01f, 4.17060815e-02f, -5.43561876e-02f, 7.18893018e-03f, -3.58025998e-01f, 1.22170500e-01f, -2.21725211e-01f,
  1.48125086e-02f, 1.92029789e-01f, 5.96103445e-02f, -2.82016814e-01f, -2.18747884e-01f, -2.85635024e-01f, -2.93359887e-02f, -3.11430275e-01f, -6.24269098e-02f, 2.64566630e-01f,
  -2.00424746e-01f, 1.90970853e-01f, -1.92560270e-01f, -2.34156042e-01f, -7.21198469e-02f, 8.06433484e-02f, 4.61893603e-02f, 1.07669741e-01f, -1.58254877e-01f, -1.52350038e-01f,
  2.33061358e-01f, 2.94153422e-01f, -1.75903738e-01f, -1.54887559e-02f, -2.12835833e-01f, 1.05741285e-01f, 2.45165199e-01f, 3.08032781e-02f, 4.51991707e-02f, 3.61474544e-01f,
  -2.57086493e-02f, 2.51522988e-01f, 7.12587610e-02f, -1.06546149e-01f, -1.21532716e-01f, 4.09842841e-03f, 2.95200914e-01f, 2.57121329e-03f, 1.14596244e-02f, -1.07112117e-01f,
  1.01845793e-01f, -1.88970119e-01f, -7.98311308e-02f, 2.68978000e-01f, 2.65346635e-02f, -7.82045126e-02f, -3.72928977e-01f, -2.81636082e-02f, -8.70926976e-02f, -2.72358745e-01f,
  3.87964129e-01f, 1.12023771e-01f, 1.58412606e-02f, -1.87813982e-01f, -1.34530768e-01f, -1.79123715e-01f, 3.51048820e-02f, -2.54198611e-02f, 5.74491471e-02f, 1.60704926e-01f,
  -1.89269528e-01f, 1.98700309e-01f, 1.65308058e-01f, -1.64086074e-02f, -1.80639520e-01f, 6.19648397e-03f, 3.64188589e-02f, -3.82765606e-02f, -1.06417621e-02f, -1.42929927e-01f,
  -2.65402317e-01f, 7.57922381e-02f, -3.10078543e-02f, 1.69411421e-01f, -3.80198658e-02f, -1.31814461e-02f, -1.09302729e-01f, -2.55470723e-01f, 9.86932218e-02f, 5.91734238e-02f,
  1.56924233e-01f, 5.15785851e-02f, 1.90415069e-01f, 1.08550720e-01f, -2.61087984e-01f, 1.29926652e-01f, 8.61201659e-02f, 1.77241378e-02f, 4.34718616e-02f, -5.04255146e-02f,
  6.98766559e-02f, -5.62832169e-02f, 1.53346300e-01f, -1.92292392e-01f, 9.58220288e-02f, 1.21489316e-02f, 1.27386495e-01f, 6.46868795e-02f, 2.77491659e-02f, -7.26075843e-03f,
  1.84094191e-01f, -5.09264581e-02f, -2.19524264e-01f, -3.06092612e-02f, 6.86068181e-03f, 1.19881267e-02f, -2.23861858e-01f, -2.84666687e-01f, 1.44894183e-01f, -1.18169710e-01f,
  2.50224948e-01f, 2.45010421e-01f, -1.74259972e-02f, -3.97492796e-02f, 3.27843696e-01f, 2.48236552e-01f, -2.46396080e-01f, -2.03321770e-01f, -2.28162870e-01f, 2.07466278e-02f,
  -2.75895447e-01f, -2.75803328e-01f, -3.66758220e-02f, -2.26221949e-01f, 1.96771696e-01f, 1.95092008e-01f, 3.66086513e-01f, -1.80390939e-01f, -2.88619757e-01f, 8.57469440e-02f,
  2.87081927e-01f, 3.15358452e-02f, 2.84633711e-02f, -1.31832153e-01f, 7.64683709e-02f, -3.21442097e-01f, -2.42944717e-01f, -1.75261632e-01f, 1.73395332e-02f, -1.52969450e-01f,
  -2.21299663e-01f, -1.74751803e-02f, -3.01672101e-01f, -7.84272403e-02f, -4.11964357e-01f, 5.63135035e-02f, -1.35752439e-01f, 3.61568272e-01f, -5.80165088e-02f, -2.55562309e-02f,
  -1.01829186e-01f, 5.33941016e-02f, -2.31887981e-01f, 4.08835232e-01f, -1.89710096e-01f, -1.86995149e-01f, 1.52006492e-01f, 1.83967620e-01f, 1.45333812e-01f, 2.56505042e-01f,
  -1.60306264e-02f, -3.31713483e-02f, 3.48779231e-01f, 1.60739586e-01f, 1.22144759e-01f, 6.28951266e-02f, -7.12804273e-02f, -3.33671235e-02f, -3.86483930e-02f, -2.42626555e-02f,
  -1.60901055e-01f, -1.81942865e-01f, 5.84500134e-02f, -8.04744568e-03f, -4.15937901e-02f, -1.60219759e-01f, -1.64166972e-01f, 7.44727030e-02f, -2.11833015e-01f, -2.51716882e-01f,
  2.22785659e-02f, -1.90946504e-01f, 2.56271195e-02f, -1.54125065e-01f, -3.75809781e-02f, -4.24273610e-02f, 2.14351509e-02f, 8.80888924e-02f, -1.75714254e-01f, 1.43276006e-01f,
  -9.56875756e-02f, 7.06946701e-02f, 3.42223560e-03f, -1.18377522e-01f, -2.39334360e-01f, -1.04788803e-01f, -7.93112367e-02f, -1.86602503e-01f, -4.59526666e-02f, 3.73052098e-02f,
  1.45357981e-01f, -5.91207258e-02f, 2.44604470e-03f, -7.85003752e-02f, -1.53723564e-02f, 8.70695636e-02f, 1.30926520e-01f, -2.27229834e-01f, 3.91047597e-02f, 1.16776168e-01f,
  -1.49829149e-01f, 2.25301124e-02f, -2.87741888e-02f, 1.21079281e-01f, 6.17017038e-02f, -1.02978662e-01f, 9.14136395e-02f, -2.31390610e-01f, 6.59306422e-02f, -2.56011840e-02f,
  -1.98481619e-01f, 6.43672645e-02f, -3.87122393e-01f, 1.20661907e-01f, 1.44661158e-01f, -3.65616195e-02f, 1.20008036e-01f, -5.12181111e-02f, -7.80002177e-02f, 3.27730365e-02f,
  -4.91056293e-02f, 1.00009196e-01f, 1.06949791e-01f, 1.57338783e-01f, 8.60106051e-02f, 3.36219333e-02f, -3.25723775e-02f, -6.73945546e-02f, -1.52027458e-01f, -3.07109296e-01f,
  2.17124268e-01f, -2.00313762e-01f, 1.44653723e-01f, 4.18846272e-02f, 1.34164974e-01f, 4.40588176e-01f, 2.31364965e-01f, -9.46945325e-02f, 3.48141611e-01f, 3.10805440e-01f,
  -1.56596258e-01f, 1.43671157e-02f, -1.01884827e-01f, -1.72486454e-02f, 9.33039933e-02f, 4.48704511e-02f, 3.52634877e-01f, -2.66934186e-02f, -2.59373635e-01f, 2.85089046e-01f,
  1.89051256e-02f, 3.52895766e-01f, 1.02408029e-01f, -2.30650261e-01f, 7.79492259e-02f, 1.10533327e-01f, -1.26725331e-01f, -2.24646166e-01f, -1.62212104e-01f, 4.13982421e-01f,
  -2.01144665e-01f, -2.85429567e-01f, 1.63764730e-01f, -3.45597833e-01f, -2.84563913e-03f, 1.22150056e-01f, 1.46812856e-01f, -9.42155644e-02f, -5.44721112e-02f, -1.29133359e-01f,
  -1.62883505e-01f, -2.84967870e-01f, -8.50580819e-03f, 3.55239697e-02f, -8.20389539e-02f, -2.17710957e-01f, -3.21197420e-01f, -5.92956506e-02f, -2.23830398e-02f, 2.65825074e-02f,
  -6.98620975e-02f, -4.70622629e-02f, 1.27752513e-01f, 3.71374972e-02f, -4.16685082e-02f, 8.67692903e-02f, 4.64138426e-02f, 2.98458878e-02f, -9.06509906e-02f, -5.16862003e-03f,
  9.83092189e-02f, 7.14162141e-02f, -8.32942873e-02f, -1.87750265e-01f, 1.21380344e-01f, 1.48675203e-01f, 1.89813182e-01f, -1.06091917e-01f, 6.79023415e-02f, -5.94037920e-02f,
  6.76072463e-02f, -1.14531949e-01f, 1.00894779e-01f, 1.53983653e-01f, 1.47636253e-02f, -3.80191836e-03f, 1.79755658e-01f, 2.01502874e-01f, 5.37789986e-02f, 2.03812383e-02f,
  8.37113261e-02f, 1.25450388e-01f, 7.06747100e-02f, 6.18701708e-03f, 6.42808229e-02f, 9.97245982e-02f, 8.53289813e-02f, -1.22810612e-02f, 1.47019163e-01f, 1.42670184e-01f,
  8.56079832e-02f, -1.54012516e-01f, -1.36977330e-01f, 7.11223343e-03f, -2.93457925e-01f, 5.38753271e-02f, -1.03534050e-01f, 3.14728096e-02f, -1.25482708e-01f, -4.66810763e-02f,
  6.05779439e-02f, 1.42849654e-01f, 1.05215333e-01f, 7.36731589e-02f, 9.76937357e-04f, -2.28860676e-02f, 1.18840098e-01f, 3.72484066e-02f, -4.53732088e-02f, 2.35696435e-01f,
  1.25960022e-01f, 7.71177262e-02f, 1.18662544e-01f, 1.20278418e-01f, 5.18179946e-02f, -3.41084711e-02f, 3.54794599e-02f, -1.89309061e-01f, 8.16759467e-02f, 1.30264647e-02f,
  8.87626503e-03f, -3.82442623e-02f, 2.09642172e-01f, 1.65745571e-01f, -1.48544461e-01f, 3.17615479e-01f, -1.94423288e-01f, -7.81778395e-02f, -8.70833173e-03f, -4.42167856e-02f,
  -2.98437983e-01f, -4.94176485e-02f, 6.66729137e-02f, -1.92529991e-01f, 5.64923063e-02f, -1.76412240e-01f, 4.80298176e-02f, 2.19186082e-01f, 1.81300461e-01f, 5.42957485e-02f,
  -8.01873952e-03f, -1.71042129e-01f, -3.69998246e-01f, 4.14691389e-01f, 4.66876812e-02f, 3.01527474e-02f, 2.82582045e-01f, -3.93095911e-01f, 2.54341811e-01f, -2.28205383e-01f,
  -1.51674762e-01f, 1.39322877e-01f, -1.06502511e-01f, 5.92036694e-02f, 6.61485493e-02f, -3.10166534e-02f, 5.19572914e-01f, -6.73566312e-02f, 2.47195184e-01f, 1.47532716e-01f,
  -1.87114209e-01f, -3.15212458e-02f, -1.12203769e-01f, -4.26624082e-02f, -1.21714532e-01f, -9.55768898e-02f, 3.73908788e-01f, 4.26688641e-01f, 3.71560395e-01f, -7.33061656e-02f,
  4.03781086e-02f, -9.92136300e-02f, 1.98835164e-01f, -1.10082716e-01f, -2.79982686e-01f, -2.49423429e-01f, -5.18302321e-02f, 1.15134250e-02f, 2.83109862e-02f, -4.34990861e-02f,
  1.32081643e-01f, -5.23708481e-03f, -8.90698582e-02f, -4.88837296e-03f, -8.81882682e-02f, 2.62960672e-01f, -7.46287755e-04f, -5.86271994e-02f, 6.25480562e-02f, -5.43869995e-02f,
  -2.03874171e-01f, 5.81200048e-02f, -2.20820636e-01f, -8.01542550e-02f, 1.25012591e-01f, -5.70145436e-02f, 1.72808304e-01f, -1.75396085e-01f, 4.14147973e-02f, -7.92578906e-02f,
  8.36475417e-02f, 7.19798589e-03f, 4.16390039e-03f, -7.37598762e-02f, 2.33554661e-01f, 5.51933758e-02f, 1.19755588e-01f, -3.50007296e-01f, -2.30057880e-01f, 2.00205371e-01f,
  1.04617991e-01f, 6.69220909e-02f, 3.19125429e-02f, 7.73027390e-02f, 1.77900940e-01f, 1.88437566e-01f, -1.79993644e-01f, -3.45687419e-02f, 1.67824656e-01f, -3.37349296e-01f,
  -2.06054300e-01f, 4.47647125e-02f, 6.97718933e-02f, 3.43415849e-02f, 5.76511919e-02f, -3.00403945e-02f, 1.59126535e-01f, 7.89963454e-03f, 7.17162937e-02f, -1.27316028e-01f,
  5.20649180e-02f, -1.78364422e-02f, 3.90261821e-02f, -1.92266420e-01f, 1.27174675e-01f, -1.39198855e-01f, -1.88586801e-01f, 1.16695203e-01f, 1.37277469e-02f, 4.46886718e-02f,
  -1.39814869e-01f, -2.13623419e-01f, 1.04409168e-02f, 6.46020696e-02f, 1.79751158e-01f, 1.91382449e-02f, 1.56191334e-01f, -7.40385801e-02f, -2.21583135e-02f, -1.31337307e-02f,
  4.46706861e-02f, 3.05433422e-02f, 7.82341957e-02f, -1.47130474e-01f, -4.03833210e-01f, -7.85511509e-02f, -2.33268172e-01f, 2.07623631e-01f, 2.33824149e-01f, 1.94681942e-01f,
  1.35422396e-02f, 3.89811039e-01f, -6.19508093e-03f, 3.35679315e-02f, -2.53243726e-02f, -1.08780921e-01f, 1.70962080e-01f, -1.18436433e-01f, -1.37203395e-01f, 4.79962006e-02f,
  2.70779759e-01f, -1.45653427e-01f, 9.96568501e-02f, -3.05397004e-01f, -1.38196917e-02f, 3.70423645e-02f, -1.24540269e-01f, 2.86448479e-01f, 1.25309810e-01f, -1.15973711e-01f,
  3.08780730e-01f, -4.85362252e-03f, 7.88029209e-02f, -8.24784413e-02f, -1.53340444e-01f, 3.43585074e-01f, -1.78733200e-01f, -1.12733297e-01f, -2.06069648e-01f, 1.96347851e-02f,
  -1.97566167e-01f, 3.35323244e-01f, 2.58103877e-01f, -2.43623421e-01f, -1.21759929e-01f, 8.93377289e-02f, -9.21112448e-02f, 1.06876850e-01f, -1.36297807e-01f, 1.78660527e-01f,
  -1.49026692e-01f, 1.99858963e-01f, 6.05873205e-02f, -3.27025168e-02f, 8.18496346e-02f, -2.24193797e-01f, 2.70248830e-01f, -1.78046986e-01f, -1.68613687e-01f, -7.28471428e-02f,
  1.55137051e-02f, 1.13926463e-01f, 4.40602824e-02f, 1.25427365e-01f, 1.39172211e-01f, -1.63134307e-01f, 2.53288355e-02f, 1.62638053e-02f, -1.89407587e-01f, -2.20780268e-01f,
  -2.17958465e-01f, -1.31649941e-01f, 1.66527964e-02f, 4.11948085e-01f, -2.23840401e-02f, -2.07548533e-02f, -3.67338806e-02f, -1.19651943e-01f, -1.00594893e-01f, 6.08802289e-02f,
  1.14273122e-02f, 4.28693602e-04f, 6.61813840e-02f, 1.44108519e-01f, 3.55494656e-02f, -1.26802087e-01f, 5.57860620e-02f, -4.23902422e-01f, 1.34844989e-01f, 8.25819671e-02f,
  6.84684366e-02f, -9.93864518e-03f, 7.91635290e-02f, 6.70398474e-02f, 8.06519836e-02f, -3.80533785e-02f, -2.90437508e-02f, 1.75740823e-01f, 6.95657656e-02f, 3.34248841e-02f,
  -3.25011373e-01f, 7.85536990e-02f, 3.72099578e-02f, -4.11665738e-02f, 1.08554095e-01f, -7.68984575e-03f, -5.04447073e-02f, -1.20973669e-01f, -1.09548345e-01f, -4.99459580e-02f,
  7.21639767e-02f, 1.45488260e-02f, -6.32092431e-02f, -1.44233909e-02f, -1.15607828e-01f, -1.31879076e-01f, 8.43823999e-02f, 4.04725783e-03f, -9.37842876e-02f, -5.80431409e-02f,
  -1.01635344e-01f, 1.29298372e-02f, 7.52784982e-02f, 1.18155792e-01f, 1.03770308e-01f, -1.61683664e-01f, -9.26624388e-02f, -1.39497578e-01f, 1.20718412e-01f, 6.84038401e-02f,
  -1.38699245e-02f, 6.26628995e-02f, 1.71041533e-01f, 1.44165978e-01f, -1.36187986e-01f, -4.90046181e-02f, -3.39756966e-01f, -1.10037558e-01f, 1.40523538e-01f, 8.12382102e-02f,
  5.82063086e-02f, -8.36706311e-02f, 1.07530981e-01f, 1.31758796e-02f, -2.02013314e-01f, -1.95026558e-04f, 7.95339644e-02f, 2.56864697e-01f, -1.90361679e-01f, 1.83866575e-01f,
  8.34240317e-02f, 6.17075153e-02f, -1.57717407e-01f, 2.32387185e-01f, 1.31725311e-01f, -1.99917227e-01f, 8.19604546e-02f, 2.69529466e-02f, -3.21540445e-01f, -1.47658452e-01f,
  2.95154184e-01f, -1.76437557e-01f, -6.73075244e-02f, 1.02293700e-01f, 2.40568131e-01f, 4.16315943e-01f, 3.37122321e-01f, 2.08776489e-01f, 2.25139096e-01f, -1.65415615e-01f,
  -1.42253369e-01f, -1.58052996e-01f, -6.27694204e-02f, -1.25506654e-01f, -1.42016122e-03f, -2.31523171e-01f, 1.40553400e-01f, -7.63794733e-03f, -1.33761644e-01f, 1.34659111e-01f,
  1.24124981e-01f, 1.94162410e-02f, 6.57873601e-02f, 1.21775549e-02f, 3.92097328e-03f, -1.48858458e-01f, -2.67213553e-01f, -1.04132831e-01f, 4.41655777e-02f, -8.25186446e-02f,
  -7.63012934e-03f, 7.59354904e-02f, 2.12891757e-01f, -1.39080852e-01f, -1.51157659e-03f, -2.09315610e-03f, 2.93907464e-01f, 2.45653749e-01f, 9.12498161e-02f, 3.22603583e-01f,
  1.74374536e-01f, -1.81708366e-01f, 6.31160513e-02f, 3.43855560e-01f, 9.23030078e-02f, -8.45186710e-02f, -4.42232285e-03f, 7.11531937e-02f, 2.82227006e-02f, -2.51730412e-01f,
  1.06640749e-01f, -1.08644813e-01f, -1.69536360e-02f, 7.66874030e-02f, 1.18877077e-02f, 1.71627715e-01f, -1.18677333e-01f, 6.90907240e-02f, 2.74560060e-02f, 2.73472592e-02f,
  -1.31667450e-01f, -3.06099616e-02f, -1.65114164e-01f, -1.72945827e-01f, -4.41175960e-02f, -4.68956120e-03f, 7.76393265e-02f, 1.28774596e-02f, 2.13870592e-03f, -2.76333373e-02f,
  -1.63436476e-02f, 5.56680523e-02f, 1.67311385e-01f, 2.25251038e-02f, 2.10392359e-03f, -1.01191476e-01f, -1.75125003e-02f, 1.02960736e-01f, -6.93020150e-02f, 1.80223435e-01f,
  6.14558393e-03f, 7.67215863e-02f, -3.17742676e-02f, 1.11229226e-01f, 1.53865954e-02f, 3.81283439e-03f, 3.44045945e-02f, 8.47454518e-02f, -9.64264572e-02f, -2.78073311e-01f,
  2.17973843e-01f, -1.64094232e-02f, -1.14378527e-01f, 5.16359061e-02f, 8.22505504e-02f, 1.05865873e-01f, 7.21626952e-02f, 5.59631065e-02f, 2.81935539e-02f, -2.14283481e-01f,
  2.66513675e-01f, 6.90826774e-02f, 3.01720798e-01f, -6.41440526e-02f, -2.12501317e-01f, 1.00344174e-01f, -1.66082814e-01f, -2.58250564e-01f, 1.77436739e-01f, -2.11788595e-01f,
  1.48189217e-01f, -2.16660038e-01f, -2.04588011e-01f, -6.82734847e-02f, -1.81606323e-01f, 3.38811815e-01f, 1.14611857e-01f, 3.82396840e-02f, -9.20880586e-02f, 1.62311837e-01f,
  -2.85545528e-01f, -1.64319828e-01f, -1.53690577e-01f, 3.78144644e-02f, -1.94072619e-01f, -1.22328751e-01f, -2.27699637e-01f, -2.44393557e-01f, 5.29249497e-02f, -1.31786764e-01f,
  -1.18229380e-02f, -9.38023254e-02f, 1.88983809e-02f, 3.87194902e-02f, -4.29157525e-01f, 2.14795411e-01f, 1.49157926e-01f, -2.01837182e-01f, -1.42636523e-01f, -9.47368070e-02f,
  -1.49505273e-01f, 2.29123816e-01f, -1.78863049e-01f, -3.42322469e-01f, 8.89486372e-02f, -6.19771425e-03f, 2.56615967e-01f, -3.00670147e-01f, 6.97458684e-02f, -1.38398543e-01f,
  8.12449306e-02f, -1.08264349e-01f, -1.51646316e-01f, 1.14161894e-01f, 1.78454101e-01f, 6.09647818e-02f, -1.15599655e-01f, 1.66107318e-03f, 6.43830895e-02f, 1.53447703e-01f,
  -6.14819080e-02f, 4.12300937e-02f, -5.46764992e-02f, 6.12708703e-02f, -1.93575904e-01f, 1.52322695e-01f, 1.79819196e-01f, -2.92840898e-01f, -5.67314103e-02f, 4.12221290e-02f,
  1.65320009e-01f, -8.47249776e-02f, 3.18309739e-02f, 2.69690424e-01f, 1.38541833e-01f, 5.90680242e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -4.50011715e-02f, -1.64988786e-02f, 3.36822532e-02f, 2.42029540e-02f, 3.27265635e-02f, -5.79977855e-02f, -5.51274270e-02f, 8.35386068e-02f, 5.26363887e-02f, 1.19114399e-03f,
  -1.98522136e-02f, -1.01181706e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    