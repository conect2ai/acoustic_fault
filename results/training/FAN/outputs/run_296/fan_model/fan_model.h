/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.54420477e-01f, -3.59037578e-01f, -2.84203887e-01f, 2.05518007e-01f, 8.90587717e-02f, 3.45486999e-01f, 3.50924522e-01f, -7.67966956e-02f, 2.69791111e-02f, -1.00577623e-01f,
  6.64706454e-02f, -6.13318086e-02f, -1.85778648e-01f, 3.72546054e-02f, 2.80059308e-01f, -1.92116618e-01f, 3.04402113e-01f, 1.46633625e-01f, -1.10987581e-01f, 7.36909956e-02f,
  3.06648929e-02f, 1.21099859e-01f, -1.34586126e-01f, -1.36722684e-01f, 8.50570723e-02f, -8.80795941e-02f, 1.48054287e-02f, -2.11865366e-01f, 6.69242442e-02f, 1.68321431e-02f,
  -3.79035808e-02f, -1.79310396e-01f, -9.63579640e-02f, -2.67180055e-02f, 9.65561494e-02f, 7.59061053e-02f, 3.72020714e-02f, 8.88156891e-03f, 1.28002325e-02f, -3.10314037e-02f,
  7.52617270e-02f, 2.89277490e-02f, -2.59052329e-02f, -4.71161194e-02f, 3.10764518e-02f, -1.24695785e-01f, -5.44375852e-02f, -2.48977151e-02f, -5.50626479e-02f, -4.11459282e-02f,
  -7.88778216e-02f, 5.50721539e-04f, 3.68201323e-02f, 2.55608335e-02f, 1.75055545e-02f, -2.95763183e-02f, 3.61323394e-02f, 3.00267804e-02f, 4.68374565e-02f, 2.77120452e-02f,
  5.73182479e-02f, 9.15577076e-03f, 3.57013545e-04f, -5.01332432e-02f, 1.64754894e-02f, -1.96244512e-02f, -6.11966942e-04f, 3.10642775e-02f, -2.64248904e-02f, -1.93580743e-02f,
  3.49958241e-02f, 3.02092806e-02f, 1.04606897e-02f, 4.39493097e-02f, 2.14048419e-02f, 2.94768531e-02f, 4.27846201e-02f, 3.01340944e-03f, 4.06996645e-02f, -3.15979123e-02f,
  -6.51324838e-02f, 1.26004051e-02f, -4.39262278e-02f, 3.81679460e-02f, -3.03025655e-02f, -1.69999171e-02f, -2.14386880e-02f, -2.57547684e-02f, -2.21095327e-02f, 1.08261578e-01f,
  1.18547261e-01f, 4.67793196e-02f, -3.62201221e-02f, -1.33442823e-02f, -3.44407186e-02f, -2.91686654e-02f, -1.78805087e-03f, -2.09843591e-02f, -2.97052898e-02f, 4.08950634e-02f,
  2.27946006e-02f, 1.94671974e-02f, 7.26449192e-02f, -9.35147330e-03f, 5.69084249e-02f, 7.10565820e-02f, 2.01028269e-02f, 4.98559363e-02f, 1.34745046e-01f, -1.85837485e-02f,
  3.53554972e-02f, 5.25970981e-02f, 3.56721580e-02f, 1.96593851e-02f, 6.56658337e-02f, 4.86282893e-02f, 4.11340185e-02f, -2.64489409e-02f, -1.30284261e-02f, -1.57592986e-02f,
  -1.95658445e-01f, 1.42074719e-01f, -1.10642523e-01f, -4.33347762e-01f, -1.10238723e-01f, 3.19168031e-01f, 4.94644977e-02f, -1.50082916e-01f, -4.98538874e-02f, 1.39176100e-01f,
  1.32293692e-02f, -5.48728481e-02f, 2.44982108e-01f, -9.31731313e-02f, -2.75277253e-02f, 2.50781834e-01f, -5.52629977e-02f, 3.49094495e-02f, -2.57643070e-02f, -1.41222596e-01f,
  -2.54356861e-01f, -2.01979242e-02f, -1.37658909e-01f, -4.12604436e-02f, -1.80825263e-01f, -1.53973550e-01f, -5.35259098e-02f, 8.83369446e-02f, -8.20715502e-02f, 8.53848830e-03f,
  1.42483069e-02f, -7.45699853e-02f, -9.73591432e-02f, 5.80938198e-02f, -3.16104367e-02f, -4.59046364e-02f, -5.66258188e-03f, 5.17867543e-02f, -1.48356734e-02f, -2.32749954e-02f,
  6.69741631e-02f, 1.58881489e-02f, -5.82224019e-02f, 7.19616413e-02f, 1.21257240e-02f, -3.99463028e-02f, -8.40578154e-02f, -2.47838441e-02f, -3.75550911e-02f, -6.31273985e-02f,
  1.01427519e-04f, 8.38960707e-03f, -7.59667605e-02f, 2.54115872e-02f, -1.86471082e-02f, -9.49888024e-03f, 6.96221413e-03f, -1.15360320e-02f, 4.02328596e-02f, -8.37215632e-02f,
  5.48701324e-02f, -2.03519501e-02f, 1.38245774e-02f, -2.51872968e-02f, -3.74778509e-02f, -3.05171385e-02f, 1.38390157e-02f, 5.12502268e-02f, 2.42038611e-02f, 3.74666266e-02f,
  2.18422394e-02f, -3.01273875e-02f, 1.58364177e-02f, 1.37642603e-02f, -6.43680692e-02f, -3.09823118e-02f, -1.16914259e-02f, 3.77793843e-03f, -5.04371673e-02f, -5.38551360e-02f,
  1.15159238e-02f, 3.62337045e-02f, 9.64428298e-03f, 2.15785354e-02f, 8.25837329e-02f, 4.44399081e-02f, -3.84439789e-02f, 3.66718858e-03f, 1.62222539e-03f, 4.61832248e-02f,
  2.52316087e-01f, -5.10219373e-02f, -2.31821723e-02f, 1.03246728e-02f, 5.63369468e-02f, 1.51040861e-02f, 3.28748487e-02f, 2.91206054e-02f, 4.26937230e-02f, -1.83221009e-02f,
  -5.07727787e-02f, -8.79636314e-03f, 5.63389324e-02f, -2.33651847e-02f, 3.98614332e-02f, 4.48162183e-02f, -4.03312333e-02f, -1.94921833e-03f, -7.26068858e-03f, -5.14613315e-02f,
  -8.57162774e-02f, 4.19938676e-02f, -3.38289849e-02f, -1.37101836e-03f, 1.24036083e-02f, 2.09383853e-02f, -4.39517125e-02f, 1.69182308e-02f, -3.58732492e-02f, 1.18956221e-02f,
  2.76369244e-01f, 2.59731919e-01f, 8.34946632e-02f, 5.76783977e-02f, -1.51832283e-01f, -8.30000453e-03f, 5.29728159e-02f, -1.13305040e-01f, 2.61539727e-01f, 9.90638062e-02f,
  -1.72818005e-01f, 2.57942080e-01f, 1.37582608e-03f, 2.61895303e-02f, 4.23068441e-02f, 1.04432479e-01f, 1.61499426e-01f, 9.38836783e-02f, 8.39898586e-02f, 3.19752842e-02f,
  3.61275598e-02f, -1.81487888e-01f, -6.65108785e-02f, -2.36401230e-01f, -3.45520768e-03f, -3.16617116e-02f, -2.36676887e-01f, -1.89800903e-01f, -8.52434710e-02f, -1.06175050e-01f,
  -1.03291973e-01f, 5.26956134e-02f, 3.76490057e-02f, -5.47715165e-02f, -1.77551096e-03f, -5.43098003e-02f, 2.90754642e-02f, -2.31582075e-02f, -4.79794741e-02f, 8.36207159e-03f,
  5.96373715e-02f, 1.58261228e-02f, 2.03137994e-02f, -8.60608667e-02f, -5.31477593e-02f, -1.86559174e-03f, -5.16259223e-02f, -1.79645289e-02f, -2.86151073e-03f, 2.88818832e-02f,
  2.97619235e-02f, -1.33432811e-02f, 3.84624004e-02f, 1.96671523e-02f, 2.75393557e-02f, 3.00614424e-02f, 3.39226201e-02f, 2.70500649e-02f, 4.55978848e-02f, 1.09286411e-02f,
  1.57061554e-02f, 6.82731867e-02f, 4.81166430e-02f, -6.73951730e-02f, -1.68145075e-02f, -5.96611835e-02f, 5.20162210e-02f, -6.27132952e-02f, 7.17004165e-02f, -6.03305502e-03f,
  -2.33663693e-02f, 1.46301137e-02f, -5.47236428e-02f, 2.12608948e-02f, 2.65559759e-02f, 5.81758320e-02f, -9.80945583e-03f, -3.87608297e-02f, 2.71978285e-02f, -5.38670383e-02f,
  -1.77371893e-02f, 4.98563126e-02f, -8.34053941e-03f, 7.43137952e-03f, 3.40942815e-02f, 5.19458018e-02f, 4.55199881e-03f, 4.02966999e-02f, 2.66243108e-02f, -7.00366544e-03f,
  4.54464704e-02f, 1.62696913e-01f, -4.56287004e-02f, -9.49466601e-03f, -5.96701168e-03f, 8.36546300e-04f, -5.15782740e-03f, 4.00005952e-02f, 2.18754299e-02f, -1.60956588e-02f,
  2.43260060e-02f, -7.85520002e-02f, 4.74154577e-02f, -4.73183878e-02f, -1.89708024e-02f, 7.64043182e-02f, 2.95310486e-02f, -4.46124487e-02f, -4.33947109e-02f, -1.59179617e-03f,
  -3.96900997e-02f, 3.59300822e-02f, 5.52907661e-02f, 3.46591952e-03f, -1.08775040e-02f, 2.70813052e-02f, 8.57238472e-02f, 1.82943884e-02f, 7.17447605e-03f, 7.32838586e-02f,
  3.17764550e-01f, -2.41416320e-01f, 2.67721057e-01f, 2.04810828e-01f, 1.12687372e-01f, 1.37230590e-01f, 8.80168155e-02f, -2.42744815e-02f, 4.89079058e-02f, -4.05582100e-01f,
  -1.37240201e-01f, 1.13377450e-02f, -2.13817254e-01f, 2.80641839e-02f, 5.71652472e-01f, -2.49943137e-01f, 1.86023921e-01f, -1.04675174e-01f, 1.85351837e-02f, 7.90065005e-02f,
  1.66569740e-01f, 2.39665527e-02f, 5.73701486e-02f, 1.86077356e-02f, 1.27969503e-01f, 9.36450586e-02f, 4.32719626e-02f, 4.81697470e-02f, 6.94406480e-02f, 5.79975359e-02f,
  -9.29722413e-02f, -1.25944227e-01f, 4.71922159e-02f, -8.32480863e-02f, 4.90790866e-02f, -4.99717332e-02f, 2.49138828e-02f, 3.25705223e-02f, 4.30790596e-02f, -5.64583242e-02f,
  2.95562996e-03f, 2.69769970e-02f, 3.72023173e-02f, -4.58434373e-02f, 4.02304307e-02f, -2.57391091e-02f, -2.72097122e-02f, -3.45178135e-02f, -4.10683006e-02f, 1.90500007e-03f,
  -9.77334939e-03f, -4.29198965e-02f, 7.62883648e-02f, -5.73966429e-02f, 9.79377627e-02f, 2.95732338e-02f, 3.28289680e-02f, 2.79590338e-02f, -6.54096017e-03f, 2.26787254e-02f,
  1.25753200e-02f, -1.68129746e-02f, -4.51586358e-02f, -6.10008202e-02f, 1.43101526e-04f, -6.96933493e-02f, 2.92644068e-03f, -1.66053753e-02f, 2.55903210e-02f, 1.45831769e-02f,
  2.95145833e-03f, 1.65220425e-02f, -5.20338770e-03f, 1.53090451e-02f, -1.56224025e-02f, -6.26777112e-02f, -3.75515851e-03f, -6.91151544e-02f, 3.22328135e-02f, 2.81769317e-03f,
  -1.75929312e-02f, 6.12657964e-02f, -5.56616485e-02f, 3.69774848e-02f, -3.07407957e-02f, 1.51276635e-02f, -3.42523903e-02f, -1.03324687e-03f, 2.38070972e-02f, 8.41508061e-02f,
  1.09858423e-01f, 7.48762190e-02f, -3.01432349e-02f, -9.82514699e-04f, -6.45356998e-02f, 5.67030115e-03f, 3.80003788e-02f, 9.71695688e-03f, 3.67271788e-02f, 1.58180464e-02f,
  -1.14459088e-02f, 3.78742442e-02f, -1.79765765e-02f, 5.50672002e-02f, 4.57196310e-02f, -4.76823412e-02f, -1.00305825e-02f, 6.21805638e-02f, 1.05895527e-01f, -3.00095081e-02f,
  -1.31344767e-02f, -1.89668611e-02f, 3.02329380e-02f, 5.84003702e-03f, -2.62366608e-02f, -5.85971912e-03f, 6.41012564e-02f, 7.47957686e-03f, -1.96613674e-03f, 1.61794033e-02f,
  2.57201555e-05f, 2.27251723e-02f, 1.38872545e-02f, 7.43541196e-02f, 2.31168792e-01f, -2.07156822e-01f, -2.57883877e-01f, 1.75286412e-01f, 4.90531623e-02f, -8.84095486e-03f,
  -5.62534072e-02f, -1.02049209e-01f, -2.59578437e-01f, -1.37253433e-01f, -4.32263911e-01f, -4.22763467e-01f, -2.08762467e-01f, -1.68600306e-01f, -3.89390811e-02f, 1.10969707e-01f,
  7.25294873e-02f, -6.33154123e-04f, -2.97523830e-02f, 2.55472779e-01f, 1.63961887e-01f, 3.36989224e-01f, 2.09691033e-01f, 3.29182930e-02f, 1.42512754e-01f, -5.66508770e-02f,
  -1.43450558e-01f, 4.47477847e-02f, 7.12827072e-02f, -2.83867288e-02f, 4.58922461e-02f, 2.19084714e-02f, -2.72172540e-02f, -6.11128658e-02f, 1.52795250e-02f, -6.75893622e-03f,
  3.79681308e-03f, 3.97415794e-02f, -2.45334599e-02f, -8.65277462e-03f, 1.30829820e-02f, -7.47154560e-03f, -1.23823546e-02f, -3.46365594e-03f, 5.89902513e-02f, -3.47840413e-02f,
  6.17765822e-02f, 5.76715991e-02f, 1.55533920e-03f, 2.09073629e-02f, 7.50606656e-02f, 3.34053189e-02f, -1.25027420e-02f, -2.00617891e-02f, 3.48809846e-02f, 2.44818348e-02f,
  -6.71044167e-04f, -7.32288556e-03f, -5.26871718e-02f, -3.06063090e-02f, -7.25396276e-02f, 6.03245869e-02f, -5.58849722e-02f, -2.33734157e-02f, -1.56184239e-03f, -8.76180071e-04f,
  -1.03240209e-02f, 3.20635848e-02f, -2.83929966e-02f, -1.46459639e-02f, 3.14229471e-03f, -3.18995095e-03f, -5.40323630e-02f, -2.56005339e-02f, 1.80106051e-02f, 2.39747781e-02f,
  -3.24580148e-02f, -7.54089653e-02f, -1.70579553e-02f, 1.14177587e-02f, -8.17085654e-02f, 1.48456325e-04f, 2.31553987e-02f, -2.19104066e-02f, 1.39198983e-02f, -2.01644842e-02f,
  1.05946856e-04f, 4.38526645e-02f, 2.38940082e-02f, 2.55348161e-02f, -3.85492854e-02f, -1.04634902e-02f, -3.50716291e-03f, 6.32129190e-03f, -1.45230899e-02f, -4.44201306e-02f,
  3.69195528e-02f, 1.34227322e-02f, 4.34568338e-02f, -9.42236371e-03f, 1.53041817e-02f, 5.36157330e-03f, -1.09651987e-03f, 5.03632464e-02f, 3.35634425e-02f, 2.46474650e-02f,
  1.00499280e-02f, -4.25232537e-02f, -3.88276912e-02f, 5.82579859e-02f, -2.04356853e-03f, -2.33416092e-02f, 1.76486969e-02f, 3.07304133e-02f, -2.21042503e-02f, -1.45678045e-02f,
  -9.30450018e-03f, 2.70347834e-01f, 2.97719121e-01f, 6.71417564e-02f, -9.10872817e-02f, -1.76503494e-01f, -6.13096580e-02f, 9.92532521e-02f, 3.64486665e-01f, 2.84024496e-02f,
  -1.49699256e-01f, 3.44004333e-02f, 1.61297604e-01f, -1.18203238e-02f, -3.30076069e-01f, 6.91241324e-02f, -9.83547047e-02f, -6.29180297e-02f, 1.96184307e-01f, -8.00208151e-02f,
  -4.45910171e-02f, -3.31586152e-01f, -1.94986723e-02f, -9.32426080e-02f, -4.93497439e-02f, 3.06499284e-02f, -2.89618433e-01f, 1.19862165e-02f, -2.23548368e-01f, -1.77680105e-01f,
  -9.21086967e-03f, 1.15789659e-01f, 9.30594578e-02f, 6.42075315e-02f, -3.43865678e-02f, -5.21266758e-02f, -1.05468072e-01f, -5.26949018e-02f, 3.67570296e-02f, 6.38726801e-02f,
  -2.37632589e-03f, -8.54131356e-02f, 9.70461965e-03f, -2.49027703e-02f, 4.67393361e-02f, 3.85663211e-02f, 3.91278639e-02f, 2.29759272e-02f, 4.93589602e-02f, 4.06811573e-02f,
  8.07056874e-02f, 4.09864150e-02f, 4.91399039e-03f, -5.27117513e-02f, 5.62804053e-04f, 2.08038706e-02f, 2.57457085e-02f, -6.59830496e-02f, 6.80128410e-02f, 3.08798440e-02f,
  -7.58207142e-02f, 1.37316026e-02f, -1.68062560e-02f, 7.38450289e-02f, -4.12937142e-02f, 2.47516148e-02f, -1.29226958e-02f, -2.15995386e-02f, 6.05107099e-03f, 5.31169237e-04f,
  -3.06469016e-02f, 2.92826127e-02f, 1.51286619e-02f, 7.43634347e-03f, -5.71080223e-02f, 5.49301505e-02f, -8.26041475e-02f, -2.10871082e-02f, 2.88135223e-02f, 2.74147745e-02f,
  4.31283265e-02f, -2.48183198e-02f, 8.58619343e-03f, 1.83194876e-02f, 1.91897471e-02f, 9.96016711e-03f, 8.67737271e-03f, 1.49144940e-02f, 3.15244421e-02f, -7.73262978e-02f,
  -6.14674725e-02f, -6.43354505e-02f, 5.23718297e-02f, -1.45718371e-02f, 4.55067419e-02f, -6.80043995e-02f, 7.32870772e-02f, 9.45723092e-04f, -3.85067128e-02f, -1.54567622e-02f,
  -7.54939616e-02f, 4.63568233e-02f, -3.28315832e-02f, -1.12142256e-02f, -4.36715521e-02f, -2.60398798e-02f, -5.21171167e-02f, -3.28489579e-02f, -5.49098141e-02f, -8.22482333e-02f,
  -4.19890508e-02f, -5.82175255e-02f, -2.44809985e-02f, 2.01461371e-02f, -5.04965745e-02f, -2.60791667e-02f, -4.06980999e-02f, 3.78670841e-02f, -9.48261842e-02f, 1.10161006e-02f,
  -9.16796736e-03f, -1.34101063e-01f, -2.31837854e-02f, -1.03975542e-01f, 2.45911062e-01f, 1.41269267e-01f, -5.63192554e-02f, 1.78707138e-01f, -1.23538300e-01f, -2.21555069e-01f,
  5.81984073e-02f, -1.57987699e-01f, -4.60077152e-02f, 8.27143490e-02f, 1.62035078e-02f, -2.03623280e-01f, -6.86941668e-02f, -1.05730899e-01f, -8.25920776e-02f, 1.05910478e-02f,
  7.58874193e-02f, 2.03229651e-01f, 1.13593832e-01f, 2.54067153e-01f, 1.62290871e-01f, 8.42393413e-02f, 7.66185820e-02f, 3.78561430e-02f, 1.97604373e-01f, 1.21733502e-01f,
  3.92959174e-03f, -3.71374749e-02f, 6.14483915e-02f, -4.89054397e-02f, -1.37643768e-02f, 3.19349989e-02f, -3.61280851e-02f, 5.52530475e-02f, 5.43522239e-02f, 2.12114081e-02f,
  -6.21782355e-02f, 7.69438744e-02f, 4.83560674e-02f, 7.58071616e-02f, 4.11489941e-02f, 7.46089816e-02f, -5.50257554e-03f, -3.30981053e-02f, 1.78842142e-03f, 3.35639133e-03f,
  -4.28061038e-02f, 8.19651783e-03f, -5.64143807e-02f, -9.34270024e-02f, -6.10960610e-02f, 4.73544328e-03f, -3.38342087e-03f, -1.87973790e-02f, 4.21670191e-02f, -1.87256765e-02f,
  -6.27248809e-02f, -4.78904247e-02f, -1.16802379e-02f, 9.87979397e-02f, 3.94661240e-02f, 2.97288853e-03f, 2.55129114e-02f, -1.55624154e-03f, -5.02087967e-03f, 1.51775056e-03f,
  1.83929969e-02f, 2.65307352e-02f, -4.20835894e-03f, -6.46208832e-03f, -1.30439803e-04f, 2.21581701e-02f, -6.02765940e-02f, -1.63052790e-02f, -4.48701456e-02f, -2.58532893e-02f,
  -3.35954055e-02f, 5.34544187e-03f, -4.72725257e-02f, -4.66197990e-02f, 7.13523403e-02f, -6.35690093e-02f, 1.73308348e-04f, 2.69295685e-02f, -3.70755829e-02f, -3.28169987e-02f,
  -8.51129666e-02f, -2.80694272e-02f, -2.30919775e-02f, 2.47684084e-02f, -5.07482328e-02f, -1.36738634e-02f, 4.84157726e-03f, 2.61523481e-02f, -6.85148984e-02f, 2.64317226e-02f,
  2.46902816e-02f, -5.71662001e-02f, -9.13231820e-03f, 7.47076198e-02f, -1.66465603e-02f, 3.85667719e-02f, 1.79213509e-02f, -4.21285741e-02f, -4.49783467e-02f, -5.23974095e-03f,
  5.29567935e-02f, -2.12317109e-02f, -5.75360842e-02f, 4.69377227e-02f, -2.29224712e-02f, -4.33245711e-02f, -5.10987155e-02f, 1.99987590e-02f, 2.30905563e-02f, -2.29906254e-02f,
  -1.05048180e-01f, -1.61131918e-01f, 2.78466679e-02f, -3.19939047e-01f, -1.33832112e-01f, -8.09815824e-02f, -9.11379457e-02f, -2.28623658e-01f, -3.73254508e-01f, -7.99209401e-02f,
  -1.65965080e-01f, -2.90552732e-02f, 9.71506462e-02f, -3.36631775e-01f, -3.84560749e-02f, -1.04013933e-02f, -1.75886780e-01f, -5.83834164e-02f, -1.20011240e-01f, -1.66086942e-01f,
  -2.78208070e-02f, -2.04066008e-01f, 6.93888664e-02f, -4.61693928e-02f, -1.33561417e-01f, -3.95873711e-02f, 1.18555896e-01f, 5.77341281e-02f, -9.93171185e-02f, -1.32188052e-02f,
  -1.01662964e-01f, -1.39385924e-01f, -8.70307162e-03f, 6.10578731e-02f, 7.88789764e-02f, 1.25435814e-01f, 7.57504702e-02f, 1.23499837e-02f, -1.58778019e-02f, -4.64643426e-02f,
  8.78567249e-02f, -4.77441847e-02f, 4.50106524e-03f, -9.51418001e-03f, -2.01580748e-02f, -5.02372868e-02f, -5.05002812e-02f, -1.13344565e-01f, -8.25533941e-02f, 3.37127894e-02f,
  6.47502532e-03f, 2.56052287e-03f, -1.24775118e-03f, -2.59769820e-02f, -5.92991859e-02f, -5.97255416e-02f, 2.42783446e-02f, 6.52279332e-02f, 2.88891420e-02f, -8.31327662e-02f,
  3.90049145e-02f, 1.08015656e-01f, 3.59995733e-03f, -2.98695974e-02f, 3.70236225e-02f, -3.86876725e-02f, -4.32074666e-02f, 6.35231957e-02f, -4.81970161e-02f, -7.81123992e-03f,
  -3.55851389e-02f, -8.63809437e-02f, 3.06815514e-03f, -3.49895423e-03f, -6.88639060e-02f, -2.36795694e-02f, 3.12045161e-02f, 6.89854622e-02f, -6.31276444e-02f, 1.68684826e-04f,
  -3.06867827e-02f, -6.67533837e-03f, 2.06583291e-02f, 1.91606060e-02f, -4.04870883e-02f, -4.47236784e-02f, 2.18118355e-02f, -5.19940294e-02f, 6.30749157e-03f, 2.05799900e-02f,
  1.32309645e-02f, 1.28153292e-02f, -6.49740100e-02f, -7.72004994e-03f, 3.27047259e-02f, 2.74292799e-03f, 3.99323665e-02f, -2.50154547e-02f, -6.97413981e-02f, -9.13232658e-03f,
  7.40071684e-02f, 3.81144024e-02f, 7.20937178e-02f, -2.02990118e-02f, 3.90065163e-02f, -8.50920565e-03f, 7.22590834e-02f, 2.01961286e-02f, 1.09170759e-02f, -5.61014330e-03f,
  -1.29553734e-03f, 3.25263739e-02f, -5.01980744e-02f, 1.66544598e-02f, 7.07339942e-02f, 1.31524634e-02f, 1.38426630e-03f, 8.73073004e-03f, 4.91244346e-02f, 2.53897198e-02f,
  -6.01055920e-02f, -6.95621893e-02f, 2.69827008e-01f, -9.51204076e-02f, -1.58674613e-01f, -1.58781454e-01f, 7.18989149e-02f, -1.71003059e-01f, 5.14960811e-02f, -1.50184065e-01f,
  -7.27140233e-02f, 5.82181215e-02f, 1.42274380e-01f, -1.36892974e-01f, 4.32836786e-02f, 3.13033253e-01f, -2.48791546e-01f, -4.95620184e-02f, 1.03426814e-01f, -2.83711374e-01f,
  6.23033419e-02f, -2.18745574e-01f, 2.28145316e-01f, -2.44277537e-01f, -8.62280205e-02f, -3.08758579e-02f, -9.76531133e-02f, 5.78141361e-02f, -1.21192157e-01f, 4.00270373e-02f,
  -1.14579499e-01f, -1.16762333e-01f, 4.03777361e-02f, 7.96895921e-02f, -6.31878078e-02f, -1.48085272e-02f, 4.81747370e-03f, 1.59032479e-01f, 4.87033688e-02f, 4.46198657e-02f,
  4.87600751e-02f, 6.61604339e-04f, -2.80554742e-02f, 6.31772652e-02f, -1.21827669e-01f, 5.78394684e-04f, 3.76490317e-02f, 1.01609984e-02f, 1.00918289e-03f, 3.82876545e-02f,
  3.31882983e-02f, 5.21337800e-03f, 7.81052187e-03f, -2.52947956e-02f, 4.19476815e-02f, 4.18553948e-02f, -8.06289259e-03f, 2.20978688e-02f, -4.89793271e-02f, -2.85006817e-02f,
  -1.48434769e-02f, -2.33575311e-02f, 2.08730809e-02f, 3.31103243e-02f, -3.25234681e-02f, -4.92292596e-03f, -1.88093726e-02f, -5.28890407e-04f, 3.31512205e-02f, -4.74614985e-02f,
  -4.58310582e-02f, -2.62691677e-02f, -3.08169946e-02f, -1.43485563e-02f, 9.59259458e-03f, -1.56457033e-02f, 2.32596118e-02f, -8.12303871e-02f, -1.78113859e-02f, 2.36033462e-02f,
  6.13508187e-03f, -3.80334593e-02f, -2.17189337e-03f, -2.54359469e-03f, 4.21235571e-03f, 3.31079103e-02f, -6.74867406e-02f, -2.03623753e-02f, -1.86808761e-02f, -1.63224619e-02f,
  -3.61810744e-01f, -2.80795455e-01f, 4.58943024e-02f, -5.56019396e-02f, -4.96345982e-02f, -5.20924926e-02f, 4.06064726e-02f, -6.36954084e-02f, -1.16307810e-02f, -1.01935729e-01f,
  -6.08766451e-02f, -1.79022159e-02f, -3.46796773e-02f, -3.58842462e-02f, 4.94490825e-02f, -3.72914597e-02f, 7.16444431e-03f, 2.39812327e-03f, -6.75698295e-02f, -5.29376529e-02f,
  -1.22988401e-02f, -2.64460947e-02f, 5.50114438e-02f, -1.54428286e-02f, -3.09371352e-02f, -3.17661539e-02f, -4.80922312e-02f, 5.71816973e-02f, 2.30727671e-03f, -3.37086245e-03f,
  -3.49028707e-01f, 3.74479741e-01f, 1.31006375e-01f, -2.72314250e-01f, -2.71246508e-02f, -2.37724900e-01f, -3.54399472e-01f, 3.10433637e-02f, -8.05402175e-02f, 4.19000909e-02f,
  -2.64566720e-01f, 6.53015450e-02f, -7.84893483e-02f, -2.93875873e-01f, -4.32981342e-01f, -1.53510273e-01f, -3.42131495e-01f, -1.11793272e-01f, 7.01727346e-02f, -8.02874565e-02f,
  -8.82083401e-02f, -2.27783844e-01f, -7.23053589e-02f, 2.09019184e-01f, -9.34693217e-02f, 2.31192276e-01f, -3.88434678e-02f, 1.28097191e-01f, 9.19648707e-02f, 3.00698243e-02f,
  1.79331265e-02f, -2.24435274e-02f, 5.51461242e-02f, 6.55573979e-02f, -2.56773047e-02f, 9.70996264e-03f, -1.13000767e-02f, -5.37146851e-02f, 2.99217943e-02f, -2.86337584e-02f,
  1.71346217e-03f, 4.08605337e-02f, -1.89900585e-03f, -1.42336600e-02f, 3.07967588e-02f, 7.40686357e-02f, 4.27300259e-02f, 3.11503895e-02f, 3.91381308e-02f, -2.27752961e-02f,
  -5.61893098e-02f, -1.93447515e-03f, -3.19634341e-02f, 1.93713000e-03f, -3.09479870e-02f, -5.49128689e-02f, -1.21483421e-02f, 4.35856581e-02f, 7.95279816e-03f, -1.25890477e-02f,
  -5.14828339e-02f, 1.47651583e-02f, -2.49854736e-02f, 5.18194586e-02f, -1.73615217e-02f, 4.92336899e-02f, -5.30626513e-02f, 3.13808955e-02f, -5.93751203e-04f, -2.18739174e-02f,
  -3.16357538e-02f, 1.34966103e-02f, -4.04177420e-02f, -2.45020818e-02f, -5.79274185e-02f, 1.89954939e-03f, -5.25770616e-03f, -7.91995227e-03f, 7.43318873e-04f, -9.12891515e-03f,
  6.56548655e-03f, -2.92585008e-02f, -8.84653442e-03f, -3.33192176e-03f, -5.30537358e-03f, -1.69938672e-02f, -8.10111687e-03f, 2.65928991e-02f, 1.81487966e-02f, -7.32517242e-02f,
  -1.31993830e-01f, -9.15049240e-02f, 9.22814570e-03f, 2.26913355e-02f, 2.20061466e-02f, -5.48918406e-03f, -1.47931892e-02f, 5.39184399e-02f, -3.32835577e-02f, 5.80760743e-03f,
  -1.57824438e-03f, -3.73400785e-02f, 3.78327370e-02f, -1.02178836e-02f, -4.87301080e-03f, -4.12362330e-02f, -6.80439398e-02f, 2.77907285e-03f, -7.04763010e-02f, 6.64288774e-02f,
  4.38212305e-02f, 2.03779215e-04f, -2.80945785e-02f, 3.28664742e-02f, 2.25632149e-03f, -3.18784453e-02f, 2.56356634e-02f, 8.07806663e-03f, 1.37418893e-03f, 1.83852192e-03f,
  1.95718914e-01f, -1.56155825e-01f, 2.91545868e-01f, 6.56014457e-02f, 3.07455752e-02f, 8.79749432e-02f, 5.85218184e-02f, 3.84666286e-02f, 2.62142450e-01f, -1.56449080e-01f,
  -1.84947953e-01f, 8.24840292e-02f, -3.06852367e-02f, -2.19165295e-01f, -7.56959915e-02f, -1.87081888e-01f, -8.80391747e-02f, -1.33424819e-01f, -2.65004598e-02f, -1.72844585e-02f,
  -1.85618810e-02f, -4.15468037e-01f, -1.23508051e-01f, -1.90594733e-01f, 1.69313736e-02f, 1.03729265e-02f, -2.70921409e-01f, -2.15241835e-02f, -1.56374514e-01f, -2.92730574e-02f,
  -9.18765813e-02f, -1.41903933e-03f, 5.94516322e-02f, 7.62603730e-02f, -4.40996550e-02f, 5.40821999e-02f, -2.58312188e-02f, 1.58819575e-02f, 7.03912452e-02f, 5.87469935e-02f,
  7.17587918e-02f, 4.36151214e-02f, -3.34084174e-03f, 2.74211317e-02f, 1.16655245e-01f, 7.37509727e-02f, 5.11140451e-02f, 2.21962892e-02f, 4.93440358e-03f, 1.42425135e-01f,
  5.76227903e-02f, 3.52662019e-02f, 5.20865023e-02f, 3.88631895e-02f, 6.30046427e-03f, 5.51959127e-02f, 5.51936701e-02f, 5.54065183e-02f, 2.86849421e-02f, -1.61008574e-02f,
  4.34141466e-03f, 9.08862799e-03f, 1.77484602e-02f, -2.07933318e-02f, 7.67140230e-03f, 2.86084414e-02f, 2.85442267e-02f, -3.01947109e-02f, 3.44072133e-02f, -3.26523781e-02f,
  -2.82247066e-02f, 7.03803496e-03f, 1.49444630e-02f, 5.00256568e-02f, -2.06696745e-02f, 1.83934979e-02f, 1.43486308e-02f, -1.63342971e-02f, -3.84836970e-03f, -4.48823124e-02f,
  -3.31299528e-02f, 5.98462187e-02f, -6.94942921e-02f, 4.03495841e-02f, 9.64322407e-03f, -7.97331613e-03f, -9.00169276e-03f, 8.63226876e-02f, 3.79433557e-02f, -4.10944372e-02f,
  -1.78946644e-01f, -2.58708984e-01f, -1.17696717e-01f, 3.29469554e-02f, -5.80730140e-02f, -4.59999256e-02f, 3.26566100e-02f, -1.55751323e-02f, -1.18006483e-01f, -5.20386323e-02f,
  -2.19180491e-02f, 5.55458665e-02f, -2.30671149e-02f, 1.74236242e-02f, -1.19174518e-01f, -7.12480722e-03f, -1.60589591e-02f, -5.09425737e-02f, -4.07197811e-02f, -6.74822554e-02f,
  -2.55698487e-02f, -2.45003179e-02f, -1.69600155e-02f, -5.14635742e-02f, 2.54627434e-03f, 6.11894298e-03f, 3.09131388e-02f, 2.01550387e-02f, -5.39880991e-02f, -6.19344297e-04f,
  3.95705551e-01f, 2.24613547e-01f, 8.95022824e-02f, 2.11612314e-01f, -3.66406366e-02f, 2.85696313e-02f, 1.48588777e-01f, -4.29281592e-03f, 2.50920326e-01f, 6.12014383e-02f,
  -1.30805776e-01f, 9.63086262e-02f, -5.40864579e-02f, -1.36324838e-01f, -8.53570402e-02f, -1.10876828e-01f, 1.08933285e-01f, 7.23077431e-02f, -2.60480028e-02f, 1.57493666e-01f,
  6.47486299e-02f, -1.52845979e-01f, -1.32077664e-01f, -8.53445306e-02f, 2.80204210e-02f, 1.30796179e-01f, -1.16644785e-01f, -8.41471553e-02f, -1.24173768e-01f, -1.92274630e-01f,
  2.01050155e-02f, 1.74201265e-01f, -5.43474592e-02f, 2.88850558e-03f, 5.74271344e-02f, 5.20686023e-02f, 5.30388169e-02f, -1.05077736e-01f, 2.55366713e-02f, 9.44910198e-03f,
  2.48859972e-02f, -3.76733243e-02f, -1.59934498e-02f, -9.39692650e-03f, 8.41571465e-02f, 2.94171907e-02f, -4.73017134e-02f, -3.78194847e-03f, -1.68615617e-02f, -3.31288949e-02f,
  -1.90139767e-02f, -3.58805363e-03f, 4.07040790e-02f, -2.13594344e-02f, -6.23324215e-02f, -3.72259729e-02f, -4.76640463e-03f, -3.56350839e-02f, 4.34591137e-02f, 7.13992491e-02f,
  -3.47148092e-03f, -9.72465985e-03f, -6.71771020e-02f, -1.79405883e-02f, -1.13461250e-02f, -2.78605577e-02f, 3.32916109e-03f, -6.60028979e-02f, 6.01358861e-02f, -5.32093411e-03f,
  -5.51784411e-03f, 4.06907462e-02f, 2.56620208e-03f, 4.30989154e-02f, -4.20847861e-03f, -1.42907770e-02f, -4.01694551e-02f, 3.83181013e-02f, -9.59397666e-03f, 4.00771238e-02f,
  3.13478708e-02f, -2.77081542e-02f, 3.83752175e-02f, -2.10536104e-02f, -1.31744910e-02f, -7.64623359e-02f, 2.81286165e-02f, 1.50759835e-02f, -5.07686734e-02f, 1.11884689e-02f,
  3.07815939e-01f, 4.31481957e-01f, -2.73063239e-02f, 7.34701306e-02f, -1.99760068e-02f, 3.51933502e-02f, -1.74916554e-02f, -1.53057044e-02f, 3.89777571e-02f, 5.86300418e-02f,
  6.06047250e-02f, 7.77405426e-02f, 5.61538758e-03f, 1.00509916e-02f, -2.76393462e-02f, -2.19324208e-03f, 2.19240151e-02f, 1.22121768e-02f, 3.25925736e-04f, 1.59727726e-02f,
  8.86116996e-02f, 6.71700165e-02f, 2.82032043e-02f, 3.46086696e-02f, 1.90511551e-02f, 1.36578493e-02f, 4.48920801e-02f, 4.16226946e-02f, 7.52789387e-03f, -1.72055848e-02f,
  -2.23791995e-03f, 1.12677649e-01f, -3.91285643e-02f, 9.99285132e-02f, 6.76000640e-02f, -1.65421307e-01f, -1.16949096e-01f, 1.74163535e-01f, -1.23368762e-01f, 1.32750019e-01f,
  2.69378513e-01f, -2.46103823e-01f, 8.19391087e-02f, 8.70001540e-02f, -1.97998896e-01f, -3.87144312e-02f, 1.09293394e-01f, 4.27953014e-03f, -1.37045309e-01f, 1.13067500e-01f,
  6.01046607e-02f, 2.03316644e-01f, 1.15224101e-01f, 2.00276211e-01f, 1.48036733e-01f, 6.06174171e-02f, 2.67255515e-01f, 1.99521426e-02f, 6.84987083e-02f, -8.42844620e-02f,
  -6.39830455e-02f, 6.57946542e-02f, -5.80122601e-03f, -6.92986250e-02f, 9.21739265e-02f, 6.52140379e-02f, -1.03533842e-01f, -1.39672503e-01f, -2.90168989e-02f, -8.81217867e-02f,
  -3.07299942e-03f, -6.45493940e-02f, -5.40648848e-02f, -8.55012238e-03f, 4.79955599e-02f, -1.24242790e-02f, 9.63796210e-03f, -4.93567400e-02f, -7.19333738e-02f, 1.25147719e-02f,
  -2.50613671e-02f, -3.50038637e-03f, 3.12771201e-02f, -8.66652653e-02f, -3.94867584e-02f, 2.40983889e-02f, -2.57965531e-02f, -7.45380623e-03f, -5.74665330e-03f, -5.20211868e-02f,
  -2.23012990e-03f, -2.49487869e-02f, 6.76205158e-02f, -2.27880348e-02f, 1.36903450e-02f, 3.04506477e-02f, 2.10078191e-02f, -2.69523691e-02f, -3.21995057e-02f, 5.11814747e-03f,
  -3.00002266e-05f, -2.70682983e-02f, -2.56951689e-03f, 2.21313741e-02f, 1.47267878e-02f, -5.22926077e-02f, -7.07765343e-03f, 1.62080694e-02f, 5.50841866e-03f, -5.14130946e-03f,
  -1.23184407e-02f, 6.18973374e-03f, -1.13995317e-02f, 5.54900467e-02f, -5.45142740e-02f, 6.23749122e-02f, 3.99408489e-02f, 4.45219763e-02f, 3.06563601e-02f, 5.28547205e-02f,
  1.51402066e-02f, 2.18615845e-01f, 3.88909061e-03f, -6.27094209e-02f, -7.27306828e-02f, 2.19277013e-02f, 5.66034727e-02f, 3.21406312e-02f, 3.11684404e-02f, 6.11103438e-02f,
  3.11489590e-02f, -1.44337267e-02f, -4.19013947e-02f, 1.07113784e-02f, -3.42132077e-02f, 9.18541662e-03f, -1.26997465e-02f, 7.01139420e-02f, 6.30191788e-02f, -1.99181447e-03f,
  9.73538458e-02f, -3.22432071e-02f, 9.94181540e-03f, 8.26572403e-02f, 7.55018592e-02f, -1.47501822e-03f, -4.07322608e-02f, 1.07834842e-02f, 3.09409164e-02f, -2.71838084e-02f,
  7.23953173e-03f, 7.48411790e-02f, -2.83738654e-02f, -1.31455278e-02f, -1.47369310e-01f, -1.80393010e-01f, -2.33055934e-01f, -6.49458691e-02f, -3.27860683e-01f, 2.37271309e-01f,
  -8.09846371e-02f, 3.07971388e-01f, -1.79062605e-01f, 9.38845202e-02f, -1.67947531e-01f, -1.70704037e-01f, -3.84471416e-02f, 1.32605687e-01f, -1.84454620e-01f, 5.13710566e-02f,
  -4.07273099e-02f, 1.11448705e-01f, -4.24918905e-02f, 8.39301273e-02f, 1.56744793e-01f, 9.71474424e-02f, 2.60466516e-01f, -8.62729549e-03f, 2.36462623e-01f, 2.79558692e-02f,
  -1.74197294e-02f, -1.74027249e-01f, 9.34553705e-03f, 2.98863482e-02f, -5.10296039e-02f, -2.23928727e-02f, 5.25941998e-02f, -3.97227146e-03f, -1.53115410e-02f, -4.00847569e-02f,
  1.01741925e-01f, -2.70650424e-02f, -1.21005205e-02f, -1.03814018e-04f, 2.60373428e-02f, -7.76505889e-03f, 3.89111117e-02f, 6.79223090e-02f, 3.96840870e-02f, 4.18169387e-02f,
  -2.23919880e-02f, 1.73199419e-02f, 3.98211889e-02f, 1.12402132e-02f, -7.92091265e-02f, -7.24986494e-02f, 2.07927707e-03f, -1.62469018e-02f, 3.54643203e-02f, -7.62320682e-02f,
  2.44367085e-02f, -5.82660502e-03f, 2.51481906e-02f, -3.36866453e-02f, -5.32245450e-02f, -2.10037474e-02f, 3.78829874e-02f, 5.87242248e-04f, -1.89155154e-02f, 7.45840669e-02f,
  -6.60572946e-02f, 5.48441298e-02f, 2.57276406e-04f, -3.77652459e-02f, -4.27230000e-02f, 8.97663925e-03f, 1.27142612e-02f, 4.79471637e-03f, -6.30124211e-02f, -1.70416534e-02f,
  -4.02768590e-02f, 2.09224485e-02f, 4.21426967e-02f, 7.24357963e-02f, -2.34206151e-02f, -2.50178687e-02f, 2.52512023e-02f, 9.40368138e-03f, -5.62974960e-02f, -4.14356962e-02f,
  -2.17713024e-02f, 5.93529362e-03f, -4.93877269e-02f, -9.23703983e-03f, 3.41375992e-02f, 5.70388846e-02f, -1.85585525e-02f, -1.52101219e-02f, -4.72047701e-02f, -7.93503895e-02f,
  4.53730561e-02f, 2.12611482e-02f, 9.21962857e-02f, 1.74481645e-02f, 4.33496833e-02f, -1.66950002e-03f, 7.14542670e-03f, -1.75746288e-02f, 1.30251618e-02f, 8.11759681e-02f,
  3.37536708e-02f, 3.45543884e-02f, 3.27862948e-02f, -3.25951055e-02f, 1.98073760e-02f, 3.25731933e-02f, 2.64080726e-02f, 6.20838702e-02f, 5.76460920e-03f, 4.21035886e-02f,
  1.70438498e-01f, -3.52242708e-01f, -3.09371054e-01f, -7.47098252e-02f, 3.75415117e-01f, 9.72719491e-02f, -9.81788635e-02f, 4.78562899e-02f, 1.25285149e-01f, -2.18526334e-01f,
  -8.70790146e-03f, -1.90227807e-01f, -2.53098726e-01f, -2.44258538e-01f, 1.14364643e-02f, -2.65367180e-01f, -1.39097854e-01f, -9.10108462e-02f, 3.52649316e-02f, -3.72044207e-03f,
  6.67725429e-02f, -6.55093715e-02f, -2.82496631e-01f, 7.42565095e-02f, 6.85472339e-02f, -6.54717395e-03f, 8.97531211e-03f, -1.33839129e-02f, -7.60153122e-03f, -7.01081157e-02f,
  1.05375228e-02f, 8.38993769e-03f, 1.30163692e-02f, -1.98627040e-02f, 1.76228881e-02f, 4.28908058e-02f, -5.05885594e-02f, -6.78903088e-02f, 2.35985909e-02f, 8.45431723e-03f,
  -1.02453686e-01f, 7.88779184e-03f, 5.27423248e-02f, -7.07990630e-03f, 1.43388674e-01f, 1.37085756e-02f, 6.23836853e-02f, 2.07870826e-03f, 2.06008330e-02f, 1.33392895e-02f,
  -5.23636155e-02f, -5.23509309e-02f, 2.87839789e-02f, -1.01058371e-01f, -2.16068737e-02f, 2.66415477e-02f, -6.03238977e-02f, 1.31402044e-02f, -4.30010371e-02f, 5.50938807e-02f,
  7.03270808e-02f, -1.88240539e-02f, 9.49342921e-03f, -2.41803266e-02f, 1.41011979e-02f, 2.03641821e-02f, -4.40231748e-02f, -1.54378526e-02f, -3.41576524e-02f, 2.63532195e-02f,
  5.99575900e-02f, 5.82164992e-03f, 2.90598925e-02f, 6.88200742e-02f, -1.89078357e-02f, 2.52100844e-02f, -2.79794503e-02f, 1.56775713e-02f, -3.94032709e-02f, 6.23881221e-02f,
  -4.52417918e-02f, 3.69091108e-02f, -7.25946426e-02f, 3.05397785e-03f, -5.15828542e-05f, 3.66686955e-02f, -7.21273050e-02f, 6.80177193e-03f, -4.06283550e-02f, 9.95197799e-03f,
  7.53611093e-04f, -1.44783959e-01f, -5.04895598e-02f, -3.30560505e-02f, -6.18350208e-02f, 2.41709277e-02f, -3.68387774e-02f, 3.84110399e-02f, -1.96858235e-02f, 1.20642101e-02f,
  9.16404799e-02f, 6.58042654e-02f, -2.87311152e-03f, -1.02422098e-02f, -4.32279930e-02f, -3.07301269e-03f, -9.82956663e-02f, 1.34213921e-02f, -1.88712329e-02f, 1.28548713e-02f,
  1.52645530e-02f, 2.97273565e-02f, 8.32555350e-03f, 8.21722150e-02f, 4.96236347e-02f, -6.93977671e-03f, 1.01302475e-01f, -5.07743582e-02f, 4.14429866e-02f, -2.33320985e-02f,
  -1.16588818e-02f, 2.91397959e-01f, 1.13976322e-01f, 1.12347804e-01f, 7.29445666e-02f, 1.63214847e-01f, -8.78092051e-02f, 2.79676348e-01f, 4.24380740e-03f, 1.14855640e-01f,
  1.86591223e-01f, -1.09271757e-01f, -1.19609840e-01f, 1.90790832e-01f, -2.10683309e-02f, -3.17090005e-02f, 2.43040666e-01f, 6.26383722e-02f, 1.56342350e-02f, 9.84442756e-02f,
  1.05390802e-01f, 1.07781932e-01f, 1.32496953e-01f, 1.43848315e-01f, 1.87646985e-01f, 4.00498137e-02f, -7.30401417e-03f, -1.49357811e-01f, 1.81858256e-01f, -5.46470098e-02f,
  -8.21282566e-02f, 2.72798445e-03f, -4.27422859e-02f, -4.49667266e-03f, 3.10808383e-02f, -2.37594303e-02f, -5.36208227e-02f, -1.19752757e-01f, -3.35219577e-02f, 6.02202788e-02f,
  -3.16633731e-02f, 3.04106679e-02f, 8.16188976e-02f, -1.29953623e-01f, -9.63624753e-03f, 4.42692898e-02f, 7.56882057e-02f, 6.73146099e-02f, 9.88201518e-03f, 2.63783708e-02f,
  1.05277948e-01f, 1.00943848e-01f, 1.22325301e-01f, 6.79923296e-02f, 4.98490445e-02f, 9.97770801e-02f, -5.74117154e-03f, -4.26785350e-02f, 8.72143432e-02f, -1.86108984e-02f,
  -6.78530037e-02f, 1.63513981e-02f, -7.63708130e-02f, 8.27967450e-02f, -9.23941061e-02f, 3.01403198e-02f, 1.25732701e-02f, -1.45076886e-02f, -5.72892018e-02f, 4.57816720e-02f,
  -9.64040752e-04f, 6.99502081e-02f, -5.35154194e-02f, 4.06186208e-02f, -1.13917803e-02f, -3.77072431e-02f, -1.03617281e-01f, 5.42945564e-02f, 6.93905205e-02f, 1.31117823e-02f,
  -6.51118085e-02f, 1.60724614e-02f, -3.02787516e-02f, -3.28965187e-02f, -3.24153639e-02f, -2.59327367e-02f, 5.62868081e-02f, -8.08408577e-03f, -2.87444610e-02f, -2.90357657e-02f,
  -1.11358821e-01f, -7.04876706e-02f, -4.02437814e-04f, -2.57161316e-02f, -1.19001687e-01f, 6.62279055e-02f, -4.35700342e-02f, 7.93277919e-02f, -4.67712060e-03f, -3.86317074e-02f,
  2.85954494e-02f, 3.75323705e-02f, 1.88709516e-02f, -8.53861868e-03f, 1.02415448e-03f, -4.35053222e-02f, -5.72754908e-03f, -1.25712946e-01f, 3.82806733e-02f, 4.65660840e-02f,
  -1.63174572e-03f, -7.73616433e-02f, -5.78807434e-03f, 4.79454137e-02f, 3.85076590e-02f, -2.01199502e-02f, 1.08224824e-02f, -4.49926667e-02f, -1.76166669e-02f, 1.00278044e-02f,
  -1.48086855e-03f, 1.44081727e-01f, 2.92475671e-01f, -3.70366685e-02f, 1.07568681e-01f, -7.26673380e-02f, -1.26079768e-01f, 1.81884527e-01f, -1.77312508e-01f, -1.46630481e-01f,
  -9.08966586e-02f, 4.97187339e-02f, 1.07192621e-02f, -2.84401298e-01f, 2.37854168e-01f, -1.17854968e-01f, -8.52929801e-02f, -1.29397154e-01f, 6.79449588e-02f, 1.78272784e-01f,
  5.02838939e-02f, -1.72340661e-01f, 4.92852144e-02f, 6.96940646e-02f, 1.08788796e-02f, 1.49218172e-01f, 1.36126876e-01f, 1.36544228e-01f, 5.73367178e-02f, 6.73134532e-03f,
  1.01006227e-02f, -5.45485830e-03f, -8.95596817e-02f, -1.22340983e-02f, 4.59186807e-02f, 3.82149965e-02f, 1.38007179e-02f, 3.35787190e-03f, 1.96194146e-02f, 3.97398472e-02f,
  -2.39754617e-02f, 8.54094848e-02f, -8.29694197e-02f, -6.02873936e-02f, 2.26265900e-02f, 2.07266882e-02f, 9.59251728e-03f, 3.16712148e-02f, -2.21761987e-02f, -1.34059170e-04f,
  1.47140557e-02f, -2.77502835e-02f, -2.48853434e-02f, -6.41966239e-02f, 1.04514398e-01f, -3.55244847e-03f, 7.30987964e-03f, 2.37763692e-02f, 5.64668700e-02f, -3.89187522e-02f,
  -8.98982659e-02f, 2.04767589e-03f, -1.37592535e-02f, -7.53051043e-03f, 3.16283070e-02f, -4.44906466e-02f, 5.82651421e-02f, -5.66060059e-02f, 5.34845553e-02f, -1.95368677e-02f,
  4.96901013e-02f, 2.84087341e-02f, -4.52826470e-02f, -1.57650188e-02f, 5.48298061e-02f, -1.20286038e-02f, 1.14095705e-02f, -3.01310737e-02f, 3.87557819e-02f, -5.67374006e-02f,
  -3.72988507e-02f, -3.01014055e-02f, 1.59061495e-02f, -3.55976373e-02f, -4.21567215e-03f, 2.69645117e-02f, 1.50132235e-02f, 2.17239261e-02f, -3.62127312e-02f, 6.45346940e-02f,
  2.43387252e-01f, 3.82508427e-01f, 1.37310978e-02f, -2.64316648e-02f, 1.01160770e-02f, 1.01292506e-02f, -2.03141980e-02f, 2.98090316e-02f, 7.28435740e-02f, -1.05791409e-02f,
  5.07096685e-02f, -7.31004253e-02f, 1.28650948e-01f, 7.46675814e-03f, -1.12067387e-02f, 6.77132653e-03f, 5.45977093e-02f, -1.58065930e-02f, 4.82716002e-02f, 3.64115462e-02f,
  3.92431617e-02f, 5.67534566e-02f, -3.88757288e-02f, 3.89189348e-02f, -3.57299298e-02f, 9.37203597e-03f, 2.46796142e-02f, -1.95864197e-02f, 5.61300293e-02f, 6.09383658e-02f,
  2.47649059e-01f, 1.68232828e-01f, -8.32882226e-02f, -4.74939942e-02f, 4.52194698e-02f, 2.01213166e-01f, -1.91415120e-02f, 2.58637995e-01f, 4.78898257e-01f, 4.15271856e-02f,
  -6.28919974e-02f, -7.24513531e-02f, -6.12307005e-02f, 3.74247208e-02f, -8.25852379e-02f, 1.03099771e-01f, 1.19918592e-01f, -4.66423482e-03f, 1.73515096e-01f, -3.75949293e-02f,
  2.05160659e-02f, 4.37741429e-02f, -2.41162330e-01f, 1.85317971e-04f, 4.95262742e-02f, -7.53368065e-03f, -2.73016423e-01f, -1.82300374e-01f, -1.82621345e-01f, 3.23902592e-02f,
  1.22505404e-01f, 2.83970069e-02f, -6.07357509e-02f, 1.20711476e-01f, 2.03984864e-02f, 2.73946822e-02f, -1.00592211e-01f, -8.94305408e-02f, -1.64366458e-02f, 6.81636184e-02f,
  2.70246305e-02f, -1.48004759e-02f, 4.97542322e-02f, 5.47142141e-02f, 7.08983913e-02f, -4.28974302e-03f, 9.29803867e-03f, 4.01788130e-02f, 3.22838761e-02f, -6.23632297e-02f,
  6.42934721e-03f, 1.91245507e-02f, 7.24925252e-04f, 5.21323495e-02f, -5.36820441e-02f, 2.52589844e-02f, -1.02772988e-01f, -1.08933441e-01f, 6.78624138e-02f, 6.71105459e-02f,
  3.02574355e-02f, 1.75108649e-02f, -2.69812066e-02f, 2.20095646e-02f, 1.29302656e-02f, -2.11831764e-03f, -4.57502641e-02f, -4.46770824e-02f, -5.31759895e-02f, 3.36778839e-03f,
  -2.61958204e-02f, -1.95023988e-03f, 9.78845656e-02f, 4.45672823e-03f, -2.41086986e-02f, 4.80957702e-02f, -7.16085881e-02f, 1.17857326e-02f, 1.64994355e-02f, -5.23415096e-02f,
  1.18750902e-02f, 8.60895514e-02f, -7.29415789e-02f, -7.20416568e-03f, 5.75586222e-02f, -2.35126410e-02f, 2.56250314e-05f, 1.21700857e-02f, 6.51597744e-03f, -2.72155609e-02f,
  2.20048025e-01f, 1.44522980e-01f, 2.08096597e-02f, -1.76058896e-02f, 2.34049689e-02f, -1.35528492e-02f, 9.35636908e-02f, -1.56576578e-02f, 2.59458590e-02f, -6.91538153e-05f,
  1.96568593e-02f, -4.63234484e-02f, -1.17352232e-02f, -2.92772260e-02f, -2.73698643e-02f, 4.98634726e-02f, -3.05960346e-02f, 5.67605980e-02f, 3.54500003e-02f, -5.17554283e-02f,
  -1.01194173e-01f, -2.85821259e-02f, -2.82920282e-02f, -1.94349419e-02f, -2.37295148e-03f, -1.68014336e-02f, 1.90589903e-03f, 3.70957307e-03f, -3.07144970e-02f, -3.80773693e-02f,
  -1.37157843e-01f, 2.53398627e-01f, -7.09869564e-02f, 7.84568340e-02f, -1.49445295e-01f, 8.77828896e-02f, 1.03230573e-01f, 4.96550091e-02f, -2.00414732e-01f, 2.48405129e-01f,
  9.77607667e-02f, 3.93834412e-02f, -4.62374501e-02f, 4.53250349e-01f, 5.13756685e-02f, 9.65736955e-02f, 3.01937729e-01f, 1.58834204e-01f, -9.22425911e-02f, 3.73829231e-02f,
  -4.00384963e-02f, 2.69000262e-01f, 1.01701222e-01f, 5.81071414e-02f, 1.35742620e-01f, -9.52916071e-02f, 1.33399382e-01f, -2.00372502e-01f, 1.62231311e-01f, 9.58198756e-02f,
  1.42256334e-01f, 3.96209694e-02f, 9.54569026e-04f, -3.84968296e-02f, 3.46626639e-02f, 6.29222021e-02f, -3.28494981e-02f, 1.63507983e-02f, -6.08037859e-02f, -3.35756093e-02f,
  -2.32819952e-02f, 1.41600091e-02f, 3.59226204e-02f, 5.72442682e-03f, 2.24584639e-02f, 1.65674780e-02f, 2.58954037e-02f, -4.08446752e-02f, -3.79024670e-02f, 4.66268919e-02f,
  -2.79786047e-02f, 2.44190893e-03f, -5.16358763e-02f, 1.07333222e-02f, -7.20164478e-02f, -1.25843165e-02f, 4.06641960e-02f, 4.88511622e-02f, 4.48647514e-02f, 2.20993739e-02f,
  1.96674224e-02f, 2.10865419e-02f, -1.73881017e-02f, 6.03301860e-02f, 5.49747434e-04f, -4.19711210e-02f, 1.27356201e-02f, -5.26964897e-03f, 2.39424873e-03f, -4.27939072e-02f,
  9.20273829e-03f, 1.84119120e-02f, 3.05851502e-03f, 6.30272785e-03f, -2.23573726e-02f, -2.19584676e-03f, -3.23262624e-03f, 2.60354225e-02f, -6.84787929e-02f, 1.57723166e-02f,
  -4.17155474e-02f, -4.57055233e-02f, -1.18864747e-02f, -1.09152747e-02f, 2.26328708e-02f, 4.97661047e-02f, -8.38693604e-03f, 9.01475840e-04f, 1.71212740e-02f, -1.66002009e-02f,
  8.21961928e-03f, 1.84784029e-02f, -1.18664242e-01f, 4.02908847e-02f, -2.37863809e-02f, -3.13607305e-02f, 3.29219587e-02f, 8.02154094e-03f, -4.38547656e-02f, 4.02611075e-03f,
  2.28470955e-02f, 1.18561415e-02f, -5.14711812e-02f, 5.14513813e-02f, -2.54752692e-02f, 1.12213390e-02f, 2.62509603e-02f, 2.89739594e-02f, 8.83116573e-02f, 7.27367494e-03f,
  -1.50882383e-03f, -3.49111371e-02f, -1.02202790e-02f, 3.03914119e-02f, 4.76261787e-02f, -4.01435383e-02f, -3.71359028e-02f, -7.52760917e-02f, -2.48458795e-02f, -1.34592457e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.32317597e-01f, 6.10804856e-02f, -2.81405270e-01f, -8.87368694e-02f, 4.29935046e-02f, 1.60187244e-01f, -6.51312843e-02f, 5.74896038e-02f, -1.27184659e-01f, 7.06261024e-02f,
  1.53676048e-01f, 7.26925060e-02f, -1.09107301e-01f, 3.16922396e-01f, 7.27476403e-02f, -5.67204207e-02f, 2.72929758e-01f, 1.36885270e-01f, -8.80475938e-02f, 8.44560042e-02f,
  5.82171381e-02f, 1.38590321e-01f, -8.94381851e-02f, 1.00857325e-01f, 9.93707851e-02f, -1.31858215e-01f, -1.13201022e-01f, -1.93684682e-01f, 1.90270975e-01f, 5.17351739e-02f,
  1.87523678e-01f, 5.25340065e-02f, -2.80256104e-03f, -3.64586860e-02f, -3.85970511e-02f, 3.00658606e-02f, -6.84563220e-02f, 3.22993509e-02f, -1.37749553e-01f, -1.93419289e-02f,
  -6.79098964e-02f, -7.63942313e-04f, 1.21942453e-01f, -9.08439606e-03f, -2.43109018e-02f, -4.24701236e-02f, 1.52661251e-02f, -6.31271303e-02f, -5.22611290e-02f, 1.10197276e-01f,
  -3.63499708e-02f, 3.76586872e-03f, 2.79015508e-02f, 5.51110730e-02f, -4.16012891e-02f, 6.78247362e-02f, 6.29052222e-02f, -1.17459364e-01f, 7.15590194e-02f, 9.76836011e-02f,
  -4.86139394e-02f, 3.14420313e-02f, -3.44105214e-02f, 9.92801413e-03f, -4.45234124e-03f, -2.78537534e-02f, 4.61299606e-02f, -5.03665619e-02f, -8.24275762e-02f, -1.89422574e-02f,
  -1.02997096e-02f, 2.38844641e-02f, -5.11357933e-02f, 5.50453812e-02f, 7.28992373e-02f, 2.89133401e-03f, 5.30894250e-02f, -6.16852194e-02f, -7.10344538e-02f, -1.03731751e-02f,
  -6.08371310e-02f, -2.14253981e-02f, 4.37694825e-02f, 3.95722277e-02f, -4.26879115e-02f, -8.34491625e-02f, 3.50473598e-02f, 7.20184445e-02f, 2.04053447e-02f, -3.91243361e-02f,
  -1.42124323e-02f, -1.45476028e-01f, -3.44237238e-02f, 1.39524490e-02f, -6.16369694e-02f, 3.96620370e-02f, 1.10714110e-02f, -7.00150756e-03f, 2.29184073e-03f, -3.96305434e-02f,
  4.90791872e-02f, 3.07888109e-02f, 1.02386840e-01f, -3.22425663e-02f, 2.76508071e-02f, -1.83419287e-02f, -7.32688457e-02f, -9.85067338e-03f, -5.95366620e-02f, -4.07500714e-02f,
  -9.10627283e-03f, 2.48821620e-02f, -6.76536486e-02f, -7.24643022e-02f, 6.53105974e-02f, -4.03572619e-02f, 6.65584877e-02f, 3.27195041e-02f, 6.63780794e-03f, -9.48951244e-02f,
  -3.15071583e-01f, 2.11185887e-01f, -1.26946986e-01f, -8.49298909e-02f, 8.02840963e-02f, 3.11491221e-01f, 2.34082729e-01f, 1.23853326e-01f, 1.79971218e-01f, 2.76449054e-01f,
  1.12712339e-01f, 6.35910705e-02f, 7.99763016e-03f, 1.50621906e-01f, -2.93714609e-02f, 2.70013101e-02f, 2.76505530e-01f, 1.94425166e-01f, 9.93513986e-02f, -6.45296201e-02f,
  -1.03513040e-01f, 1.26254708e-01f, -1.27029851e-01f, -6.71375096e-02f, -1.31245017e-01f, -2.07279518e-01f, -1.63791925e-01f, -1.48361281e-01f, 3.67493071e-02f, 5.71653880e-02f,
  4.20414954e-02f, -4.46867533e-02f, -1.90522764e-02f, -2.06888448e-02f, -4.36464761e-04f, 4.80160080e-02f, 2.09928118e-02f, -9.18978676e-02f, -3.15116420e-02f, 3.17461812e-03f,
  -7.83586428e-02f, -7.37167746e-02f, 6.51569292e-02f, 4.22965735e-04f, -3.55973132e-02f, -4.32756394e-02f, -9.18943509e-02f, -4.81626997e-03f, -3.76963578e-02f, -3.13196816e-02f,
  -1.03200912e-01f, -1.91692542e-02f, -7.81229436e-02f, 1.63860545e-02f, -4.05822769e-02f, 4.52717729e-02f, 1.26932725e-01f, -4.69347648e-02f, 7.34420344e-02f, 1.17027417e-01f,
  6.21469598e-03f, 1.25014901e-01f, 1.15384655e-02f, 1.17192389e-02f, 7.25184307e-02f, 5.54038137e-02f, -8.90546187e-04f, 6.00531660e-02f, -3.84125412e-02f, 2.51851268e-02f,
  -6.76674470e-02f, -7.52165541e-02f, -7.08022863e-02f, -5.01306653e-02f, 9.65760201e-02f, -1.89124309e-02f, -2.67928932e-02f, -4.99102799e-03f, -3.39532532e-02f, -1.14854582e-01f,
  4.56567295e-02f, -8.28748047e-02f, -2.37361845e-02f, -4.29661833e-02f, 3.26684397e-03f, -6.04406893e-02f, -9.45908390e-03f, -9.48511995e-03f, -1.28870159e-01f, 2.80513614e-02f,
  2.52492994e-01f, 2.75922507e-01f, -7.38874450e-02f, 3.80696990e-02f, -9.30508366e-04f, -4.63574976e-02f, 1.00575119e-01f, 6.90201372e-02f, 1.03744574e-01f, 4.47596461e-02f,
  -6.27250448e-02f, 2.70011392e-03f, 5.94611391e-02f, -6.13328554e-02f, 2.74358410e-02f, 1.45823630e-02f, 3.13831791e-02f, 3.06757167e-02f, 1.04232378e-01f, -2.20842380e-02f,
  -5.03772311e-02f, 2.18686997e-04f, -2.36764010e-02f, 7.67615885e-02f, 6.78164959e-02f, -1.00133538e-01f, -4.08365242e-02f, -1.88526232e-02f, 3.32864635e-02f, 8.06440040e-02f,
  2.41212144e-01f, 4.80216295e-01f, 3.16740245e-01f, 2.80615777e-01f, -1.81175306e-01f, -8.21315795e-02f, -4.32581268e-02f, -5.29321209e-02f, 8.74234959e-02f, 1.55967355e-01f,
  -2.23377779e-01f, 6.49478555e-01f, -2.24537596e-01f, 1.02493279e-01f, -2.42267326e-01f, -2.72214532e-01f, 6.63193408e-04f, 1.87305748e-01f, 9.13024694e-03f, 2.25144133e-01f,
  -1.26884773e-01f, -1.18969642e-01f, -7.32890442e-02f, -8.37693438e-02f, 1.73380181e-01f, 1.83035403e-01f, -1.24704726e-01f, -1.64425373e-01f, 2.01903507e-01f, -8.11283290e-02f,
  -4.34394665e-02f, 6.88264892e-02f, 1.39027208e-01f, 1.10312894e-01f, 2.79646851e-02f, 5.33637917e-03f, 8.31684992e-02f, -8.82683396e-02f, -8.66200477e-02f, 4.84762751e-02f,
  1.33264050e-01f, -2.95975767e-02f, 1.14462994e-01f, 1.18414154e-02f, 5.62510267e-02f, 5.92864752e-02f, 8.50210488e-02f, 6.49365261e-02f, 1.12559967e-01f, -2.31582392e-02f,
  7.27581829e-02f, 1.05295435e-01f, 4.16642725e-02f, 3.81842032e-02f, -3.74314338e-02f, 3.58943492e-02f, 4.23865989e-02f, 1.00431696e-01f, 8.27044100e-02f, 1.05471753e-01f,
  5.20476550e-02f, -1.07370891e-01f, -1.83049720e-02f, -3.77867594e-02f, 5.60771488e-02f, -6.63960055e-02f, -1.53935589e-02f, -1.49420267e-02f, -2.22932529e-02f, -5.83223626e-02f,
  3.24586853e-02f, 9.95576829e-02f, -7.52697438e-02f, 4.81189527e-02f, 3.59741785e-02f, -1.56758316e-02f, -3.20460014e-02f, 2.96650510e-02f, -1.98426675e-02f, 1.55069036e-02f,
  -1.71568133e-02f, 3.15705352e-02f, -9.17887141e-04f, -3.16773094e-02f, 3.64332017e-03f, 3.48563269e-02f, -4.13109586e-02f, 6.61796182e-02f, -1.97151359e-02f, 4.05928083e-02f,
  1.20999981e-02f, 1.77930653e-01f, 2.57322434e-02f, 2.99492516e-02f, 8.90651867e-02f, -3.60482521e-02f, 7.46990042e-03f, 4.52400595e-02f, 1.21936783e-01f, -7.30021372e-02f,
  4.43963595e-02f, 1.26855727e-02f, 3.48978639e-02f, 1.81435365e-02f, 2.32741367e-02f, 2.67032310e-02f, 6.10900596e-02f, 1.00625329e-01f, 4.38628234e-02f, 1.18072949e-01f,
  9.61539224e-02f, -1.61082912e-02f, -5.00574410e-02f, 5.94620928e-02f, 3.58642638e-02f, -7.57548492e-03f, 4.88035847e-03f, 6.26782924e-02f, 7.97368810e-02f, 7.99994022e-02f,
  -1.48927823e-01f, 1.00594595e-01f, -3.74013148e-02f, 9.60390568e-02f, -6.58274889e-02f, -1.26358643e-01f, -2.16561835e-02f, -6.97384253e-02f, -5.73623329e-02f, 3.99715379e-02f,
  2.29193568e-01f, -1.17739946e-01f, 6.15599900e-02f, 1.24371693e-01f, 1.80677492e-02f, 1.70070738e-01f, 1.35627881e-01f, 3.47504765e-02f, 9.86649375e-03f, 1.64312840e-01f,
  -1.02611501e-02f, 2.11701185e-01f, 2.68545896e-01f, 1.88800782e-01f, 7.93373436e-02f, -5.83887063e-02f, 1.09325707e-01f, -5.32726534e-02f, 4.22938578e-02f, 1.29669756e-01f,
  -5.36462776e-02f, -3.62743586e-02f, -1.02434479e-01f, -7.84724802e-02f, -5.59307337e-02f, 1.37963919e-02f, -4.72165160e-02f, 6.06004559e-02f, -4.24381159e-02f, 1.95003916e-02f,
  1.77939814e-02f, -3.05300485e-03f, 4.40994697e-03f, -6.53697252e-02f, -6.78337514e-02f, 4.35887389e-02f, 3.47958691e-02f, 3.40725258e-02f, 8.98846798e-03f, -4.11297828e-02f,
  -1.91678740e-02f, 2.56033204e-02f, -2.74506845e-02f, 6.42834827e-02f, 5.46154082e-02f, 1.57360435e-02f, 4.16751318e-02f, -1.11035807e-02f, 1.22323669e-02f, 5.14720790e-02f,
  -3.66941392e-02f, 5.67363091e-02f, 4.94238399e-02f, -7.45682269e-02f, -2.98242532e-02f, 8.81102309e-02f, 6.77771643e-02f, 5.80839142e-02f, -1.59054324e-02f, 8.23055804e-02f,
  6.37587383e-02f, 4.83318232e-02f, 3.60974781e-02f, -5.00636585e-02f, 1.41483461e-02f, -1.33651430e-02f, -6.65472969e-02f, -3.93997878e-03f, 7.15931132e-02f, -4.80367653e-02f,
  -7.45523069e-03f, 7.08404407e-02f, -5.94213344e-02f, 1.70289306e-03f, 4.55334336e-02f, -5.04403450e-02f, -2.76415031e-02f, 7.23414570e-02f, 2.54958067e-02f, -2.03703940e-02f,
  1.03278041e-01f, 1.46068022e-01f, 5.64053692e-02f, 2.59392243e-02f, 6.96710497e-02f, 5.55572174e-02f, 1.21850809e-02f, -4.13675420e-02f, 1.04558349e-01f, 5.58758974e-02f,
  -2.40739081e-02f, 2.56952364e-02f, -9.51453857e-03f, 7.09512783e-03f, 5.78176714e-02f, 7.73096010e-02f, -1.40306186e-02f, -7.59653896e-02f, -2.52821539e-02f, 4.81692404e-02f,
  7.57630765e-02f, 2.76564006e-02f, 1.21056912e-02f, -8.23391043e-03f, 6.67799711e-02f, 9.38696563e-02f, -4.28504795e-02f, -2.99658980e-02f, -2.19807327e-02f, -2.73540728e-02f,
  6.16657324e-02f, -4.31239977e-02f, 6.80942163e-02f, 2.89798379e-02f, 1.89217478e-01f, 6.20118231e-02f, 1.31486848e-01f, 4.53399867e-02f, -2.81413551e-02f, -2.25648105e-01f,
  -8.94203261e-02f, -6.16417006e-02f, -1.17637552e-01f, -7.69841149e-02f, 3.53362598e-02f, 1.64763182e-02f, -1.96654517e-02f, -1.31476179e-01f, 9.00665522e-02f, 1.63740888e-02f,
  5.59434332e-02f, 3.70626897e-02f, 2.63721328e-02f, -6.56809285e-02f, 2.02836376e-02f, 6.37391061e-02f, -1.66511294e-02f, 7.08582625e-02f, -1.40845791e-01f, 1.15985489e-02f,
  -1.03140716e-02f, -7.43938014e-02f, -3.49146053e-02f, -2.10255813e-02f, 3.76142338e-02f, -6.81659430e-02f, -5.78281097e-02f, 5.10654263e-02f, 9.42331478e-02f, 4.93582971e-02f,
  -4.90543135e-02f, -2.58527100e-02f, -5.65235205e-02f, -5.17587811e-02f, 8.11302885e-02f, 8.97469744e-02f, 8.74321442e-03f, 6.00469410e-02f, 3.94763872e-02f, 3.70869297e-03f,
  4.67189997e-02f, -6.60147518e-02f, 8.65910053e-02f, -1.85722020e-02f, 8.71311799e-02f, -5.60310856e-02f, -2.95503791e-02f, -9.47161540e-02f, -8.53598863e-02f, 9.08685178e-02f,
  8.16055909e-02f, 1.07998960e-03f, 4.01952602e-02f, 6.19629100e-02f, -3.82127501e-02f, 9.95309278e-02f, -1.08869329e-01f, 2.50798222e-02f, 2.14538276e-02f, -2.25224067e-02f,
  -2.02826802e-02f, -3.74194747e-03f, 4.52639200e-02f, -7.08855912e-02f, -8.19291994e-02f, -5.40171824e-02f, 3.16403843e-02f, -5.12863919e-02f, 6.12679720e-02f, -6.28456548e-02f,
  2.38780421e-03f, 4.56766263e-02f, 3.31671769e-03f, -2.64578387e-02f, 6.83965720e-03f, -2.15457436e-02f, -5.72287105e-02f, 6.94196746e-02f, 8.65174234e-02f, 3.85310017e-02f,
  -1.76421762e-01f, -2.09993109e-01f, -1.03339314e-01f, -8.68571624e-02f, 4.84205969e-02f, -7.05959722e-02f, 1.02593191e-02f, 9.49157998e-02f, -4.92657274e-02f, -6.61197379e-02f,
  6.02500848e-02f, -6.10786192e-02f, -6.52432907e-03f, -3.21057774e-02f, 1.54062677e-02f, 3.68520766e-02f, -3.19170728e-02f, -1.22265816e-01f, -9.86658409e-02f, 6.54696450e-02f,
  -3.57340500e-02f, -6.47381544e-02f, -2.58621015e-02f, 8.82833004e-02f, -7.29328692e-02f, -1.01245090e-01f, -3.58541608e-02f, -5.67495525e-02f, -4.42274399e-02f, -5.42610176e-02f,
  8.42079669e-02f, -3.77365291e-01f, -9.61084515e-02f, 2.82577425e-01f, 1.82549134e-01f, 7.87125751e-02f, -1.89830288e-02f, 6.14585914e-02f, -1.00104779e-03f, -3.33404869e-01f,
  -5.96828870e-02f, -1.29706949e-01f, -3.57849896e-01f, 1.77941322e-01f, 8.99606645e-02f, -1.65177450e-01f, 1.86780021e-01f, -5.42957801e-03f, 9.21140984e-02f, -5.56008220e-02f,
  1.28465697e-01f, 1.36759385e-01f, 7.42784664e-02f, 1.46290869e-01f, 1.71647742e-01f, 6.03699945e-02f, -1.28312362e-02f, -1.48574905e-02f, 1.71468407e-01f, -5.52881584e-02f,
  5.42603880e-02f, -4.13711742e-02f, 3.32173929e-02f, 9.05716196e-02f, -5.41390777e-02f, 8.26497152e-02f, 3.82828563e-02f, 2.88295466e-02f, 1.53925255e-01f, -4.67412621e-02f,
  2.80894656e-02f, 2.45087128e-02f, -1.34812966e-02f, 3.45109329e-02f, 5.53041091e-03f, 9.12819207e-02f, 1.80596509e-03f, 6.55830875e-02f, -6.53590634e-02f, -1.94404777e-02f,
  -8.25767145e-02f, 5.52244596e-02f, 9.54290852e-02f, -2.78177224e-02f, -3.58322449e-02f, 5.37339821e-02f, -8.91600624e-02f, -8.87610689e-02f, 2.92528942e-02f, -7.40436884e-03f,
  -2.43651420e-02f, 9.97257326e-03f, 1.93326380e-02f, 5.03142327e-02f, -6.71782298e-03f, 6.41419515e-02f, 6.66025057e-02f, 2.89098304e-02f, 5.71130961e-02f, -1.75889488e-02f,
  7.93609619e-02f, -5.18730134e-02f, 5.63177979e-03f, -1.16721634e-02f, -2.99183447e-02f, 4.06558774e-02f, 5.83106540e-02f, 4.16091792e-02f, 3.58756185e-02f, 1.04776755e-01f,
  1.85119640e-02f, 1.98840704e-02f, -6.62340820e-02f, 1.08410783e-01f, 3.11999582e-02f, -2.25341748e-02f, -8.52527935e-03f, -6.96478486e-02f, 4.63464111e-03f, 6.88046068e-02f,
  -1.26255706e-01f, -2.43928254e-01f, -7.82512650e-02f, 7.95685574e-02f, 6.44810870e-02f, -1.61234122e-02f, 5.68970889e-02f, -1.91754475e-02f, -9.81561914e-02f, -6.55358806e-02f,
  -3.26917805e-02f, -4.72241045e-05f, -7.34877586e-02f, -6.56599924e-03f, 2.53888555e-02f, 1.21402545e-02f, -3.61494869e-02f, -2.26296354e-02f, -2.08736230e-02f, 4.08099107e-02f,
  -2.86031105e-02f, -1.09503139e-02f, 1.06912084e-01f, 8.49727839e-02f, 2.99738208e-03f, -2.00233553e-02f, -4.09706775e-03f, 1.63679081e-03f, -5.57364039e-02f, -2.71489639e-02f,
  -3.22700180e-02f, 4.00566496e-02f, 3.58369909e-02f, 1.44666463e-01f, 7.73719028e-02f, -2.17608169e-01f, -1.01024739e-01f, 8.55266526e-02f, 2.24779826e-02f, -9.16333571e-02f,
  7.69013315e-02f, 6.30197003e-02f, -1.48145437e-01f, 8.05175304e-02f, -6.71988213e-03f, 1.30474456e-02f, -1.43759012e-01f, -1.08518917e-02f, 3.92654240e-02f, 1.10765388e-02f,
  -5.97379468e-02f, 6.18146434e-02f, 8.14930573e-02f, -3.08540650e-03f, 6.08690381e-02f, 4.23209295e-02f, -6.24955595e-02f, -4.20471206e-02f, -3.54393944e-02f, -2.90558394e-02f,
  7.07893819e-02f, 1.68393373e-01f, -2.97778118e-02f, -4.23554890e-02f, -1.29241228e-01f, -6.08484447e-02f, -4.87929322e-02f, -8.66811723e-02f, -7.08829463e-02f, 4.78668436e-02f,
  -9.93639827e-02f, -8.48936616e-04f, 8.49457309e-02f, -3.21065485e-02f, 8.90547857e-02f, -4.63699475e-02f, -6.19396120e-02f, -6.46263361e-02f, 7.00635761e-02f, -6.95838826e-04f,
  3.64999548e-02f, 4.86605093e-02f, -4.00793850e-02f, -3.31577309e-03f, 4.83196713e-02f, -4.27942760e-02f, 6.46534190e-02f, 3.87451006e-03f, -3.41883972e-02f, -5.42966314e-02f,
  -2.40933672e-02f, -3.83144915e-02f, -3.06766517e-02f, 2.47238241e-02f, 8.22363347e-02f, -1.01333819e-02f, 4.38340195e-03f, -3.50705255e-03f, 3.60269435e-02f, -9.53712612e-02f,
  1.18331527e-02f, 1.05936825e-01f, 1.14502512e-01f, 5.38691394e-02f, 7.49066398e-02f, -8.10880512e-02f, 3.78161594e-02f, 6.36900440e-02f, 1.64622329e-02f, -4.68668751e-02f,
  4.98154089e-02f, 8.11984688e-02f, 3.72186787e-02f, -7.85823017e-02f, -2.06448287e-02f, 3.34862545e-02f, 2.66491249e-02f, -4.18178886e-02f, -9.69841257e-02f, 7.80741721e-02f,
  -1.23245373e-01f, 1.19173713e-01f, -9.40351039e-02f, 4.65107411e-02f, -9.97730438e-03f, 6.99006394e-02f, -4.87715192e-02f, -1.85305849e-02f, -2.13433579e-02f, -8.28599483e-02f,
  -1.18279837e-01f, -3.13901789e-02f, -3.58726010e-02f, -1.33911194e-02f, 7.42696971e-02f, -4.96320846e-03f, 4.45483811e-02f, -3.50988805e-02f, -7.66755128e-03f, -8.20492655e-02f,
  5.60773946e-02f, -7.91351274e-02f, -1.00163380e-02f, -9.17210802e-02f, -5.92967458e-02f, -9.42294821e-02f, -2.10213829e-02f, -3.82761806e-02f, -4.99880277e-02f, 4.80745062e-02f,
  5.10730706e-02f, -6.24518245e-02f, 1.17968112e-01f, -2.09398121e-02f, -4.38502431e-02f, -9.35038999e-02f, -1.33974180e-01f, 9.83187929e-02f, 3.84824388e-02f, 2.94275638e-02f,
  -7.71414638e-02f, 5.01171537e-02f, 3.47953737e-02f, -1.66178301e-01f, 3.79840396e-02f, 1.16410226e-01f, -1.79409049e-02f, -1.85210586e-01f, -3.24224718e-02f, -5.08903153e-02f,
  1.38813823e-01f, -1.13612302e-01f, -1.04186754e-03f, 6.22801483e-02f, -9.16576311e-02f, 1.39634255e-02f, 8.24105442e-02f, -1.00862071e-01f, 2.01596413e-03f, -1.39932975e-01f,
  -8.03967640e-02f, -2.51017772e-02f, -1.37985256e-02f, -7.34316856e-02f, 1.59576498e-02f, -2.67696921e-02f, -1.60786102e-03f, -1.43317562e-02f, 3.13304998e-02f, 6.53240681e-02f,
  7.98212215e-02f, -2.16868464e-02f, 1.86691284e-02f, -4.28052731e-02f, -1.55490255e-02f, -7.58140907e-02f, -4.12003733e-02f, 4.28700298e-02f, 8.34038928e-02f, 5.09320050e-02f,
  3.32332216e-02f, -8.32482129e-02f, -2.05829572e-02f, 4.90716472e-02f, -6.11500405e-02f, 4.92357127e-02f, -8.65063146e-02f, 1.87613852e-02f, 6.97799549e-02f, 1.10786311e-01f,
  4.23569381e-02f, 2.44546439e-02f, -8.04285109e-02f, -1.11338235e-01f, -6.28014281e-02f, -5.24985418e-02f, 8.76115635e-02f, -1.40161430e-02f, 5.07806353e-02f, -7.32589960e-02f,
  -6.58863634e-02f, 1.99111737e-02f, -3.59447338e-02f, -5.02585694e-02f, -9.98557173e-03f, 3.21218446e-02f, -1.91093993e-03f, -2.81433966e-02f, -5.87806106e-02f, 2.97507178e-02f,
  -2.05843598e-02f, -6.91404240e-03f, -8.00621584e-02f, -4.90560429e-04f, 1.43721895e-02f, 4.92095537e-02f, 3.68098170e-02f, 7.26251751e-02f, -4.57775407e-02f, 1.20162709e-04f,
  1.60921708e-01f, 1.48837179e-01f, -4.32149954e-02f, 4.39759940e-02f, 3.11272424e-02f, 6.77338839e-02f, 5.21792583e-02f, 2.07101051e-02f, -4.67906380e-03f, 1.58301257e-02f,
  -3.40375081e-02f, -3.52627560e-02f, -6.05563112e-02f, 6.17092364e-02f, -7.46917129e-02f, -1.43487174e-02f, 2.53801011e-02f, -6.88472316e-02f, 4.13808823e-02f, 9.34818611e-02f,
  -5.66883720e-02f, -9.00312439e-02f, 1.25307953e-02f, -4.78305668e-02f, -2.66160574e-02f, -5.28780930e-02f, 1.07052945e-01f, -1.32982600e-02f, -5.86866625e-02f, 1.28094181e-01f,
  -2.13856980e-01f, -1.10309489e-01f, -6.59119114e-02f, 2.14357469e-02f, -1.42433375e-01f, -1.89448968e-01f, -1.48188069e-01f, -8.74306411e-02f, -1.78543434e-01f, -1.13760456e-01f,
  -1.22824527e-01f, -4.62445989e-02f, -1.21273294e-01f, 9.92923975e-02f, 1.23363055e-01f, 1.49389520e-01f, 5.23858927e-02f, 1.63026024e-02f, 1.25863090e-01f, -1.08337298e-01f,
  1.41584352e-01f, 8.55692551e-02f, 9.19825658e-02f, 2.11062595e-01f, -7.14133726e-03f, 1.30437613e-01f, 1.53937802e-01f, -6.63672090e-02f, 2.31862560e-01f, 1.08252175e-01f,
  -5.70337195e-03f, -1.26425788e-01f, -1.15827546e-01f, -6.74680769e-02f, -1.05861194e-01f, -3.73423919e-02f, 1.29893824e-01f, -1.05155259e-02f, 2.54870765e-02f, 4.83747311e-02f,
  -7.70671815e-02f, 6.95554912e-02f, 6.96539804e-02f, 3.89636867e-02f, -1.15343496e-01f, -3.06213484e-03f, -5.20899259e-02f, 1.88075602e-02f, -4.77471538e-02f, -6.83263391e-02f,
  -1.16005652e-01f, -1.06267817e-02f, -7.47102723e-02f, 1.95509028e-02f, 9.81169641e-02f, 7.21997581e-04f, -4.88829650e-02f, -9.09850970e-02f, 5.49066886e-02f, 4.54353839e-02f,
  -8.13131183e-02f, -6.06479719e-02f, -5.85742854e-02f, -1.79810822e-02f, 5.97883761e-02f, 5.95902465e-02f, 6.42660633e-02f, -2.99857277e-02f, -3.74667882e-03f, 8.13234597e-03f,
  2.26572603e-02f, -2.83101276e-02f, 6.26651794e-02f, 4.85654138e-02f, 1.26942601e-02f, 4.46653105e-02f, -2.07937043e-02f, -6.19242787e-02f, 7.40353717e-03f, -4.38888259e-02f,
  -4.85803969e-02f, 7.96776451e-03f, -3.96965146e-02f, 9.43426101e-04f, 4.44478802e-02f, 6.22924641e-02f, -8.28280598e-02f, -1.70817673e-02f, -2.63277744e-03f, 7.36830831e-02f,
  6.74875006e-02f, -7.17268838e-03f, 1.12531232e-02f, 7.41326511e-02f, -4.64758016e-02f, -7.15708733e-02f, 1.01487767e-02f, -1.79489553e-02f, 6.46267906e-02f, -1.13327727e-01f,
  1.36117255e-02f, 8.49082917e-02f, -3.78743634e-02f, -3.95898195e-03f, -1.81016289e-02f, -2.40503550e-02f, -4.63221818e-02f, -2.67170276e-02f, 7.68268853e-02f, -4.65206504e-02f,
  -3.68220583e-02f, -5.94498850e-02f, 6.82812184e-02f, 6.15447350e-02f, 8.52544084e-02f, 3.71674038e-02f, -2.52242875e-03f, 6.60611242e-02f, 1.34866163e-02f, 1.93489902e-02f,
  1.14832506e-01f, -2.10137680e-01f, 3.23531270e-01f, -3.45475376e-02f, -1.05499290e-02f, 1.16751924e-01f, 3.21815521e-01f, -3.09727073e-01f, -3.58455628e-01f, -3.09589982e-01f,
  3.43893766e-02f, 1.27560556e-01f, 2.44251013e-01f, -1.79317474e-01f, 1.49046928e-01f, -2.23736800e-02f, -1.96879640e-01f, 3.74359973e-02f, -1.84774414e-01f, -1.36324584e-01f,
  -8.13121796e-02f, -3.52841139e-01f, 1.04668908e-01f, -2.78966218e-01f, 1.48500185e-02f, -1.61939532e-01f, -3.34231392e-03f, 9.87865701e-02f, -1.55481070e-01f, 3.91446501e-02f,
  -1.23816647e-01f, -1.77345783e-01f, 4.92058843e-02f, 2.87758093e-02f, -5.65875843e-02f, 1.22432970e-01f, 1.39583811e-01f, 6.62898496e-02f, 5.24233058e-02f, -6.52399985e-03f,
  1.03941433e-01f, -5.09221107e-02f, -1.95430249e-01f, 6.76615089e-02f, 8.69651511e-03f, -8.36107358e-02f, -4.60645296e-02f, 8.78579244e-02f, 7.09734261e-02f, 4.41858359e-02f,
  4.17551696e-02f, 7.10455850e-02f, 4.41025477e-03f, 1.77264065e-02f, 3.40791643e-02f, -1.20315710e-02f, -4.94017033e-03f, 1.13695167e-01f, 3.63971543e-04f, -8.93032365e-03f,
  -3.25339437e-02f, 3.43956687e-02f, -3.22851390e-02f, 3.07677463e-02f, -6.21704459e-02f, 4.92951125e-02f, 2.04061866e-02f, 2.04458032e-02f, 6.39793137e-03f, -2.55068131e-02f,
  -2.13307627e-02f, 3.49289402e-02f, -4.43196595e-02f, 1.41559104e-02f, 3.63500416e-02f, 6.47909045e-02f, -9.38824657e-03f, 5.56654437e-03f, 1.66110918e-02f, -6.17071949e-02f,
  9.95909143e-03f, -6.40835091e-02f, -5.64509407e-02f, 1.24783888e-02f, 1.52525660e-02f, 5.60420714e-02f, -6.21931478e-02f, 2.55604219e-02f, -7.29503930e-02f, 1.29017696e-01f,
  -2.47084603e-01f, -3.41036856e-01f, -1.33286849e-01f, -5.86310290e-02f, -9.21696648e-02f, 2.78700478e-02f, -8.45439062e-02f, -2.81862095e-02f, -2.93661151e-02f, -7.25905374e-02f,
  -6.05974607e-02f, -3.46087441e-02f, -1.67094767e-02f, -9.31286216e-02f, -7.06171319e-02f, -1.26730010e-01f, -7.43297711e-02f, -5.74980788e-02f, -1.75498258e-02f, -7.76984170e-02f,
  -7.37935305e-03f, -4.45864089e-02f, 3.26432660e-02f, -2.12711636e-02f, -5.40764257e-02f, -1.29635315e-02f, -9.00972560e-02f, -3.90730649e-02f, 1.48079498e-03f, -1.02130156e-02f,
  3.31097662e-01f, 1.56989291e-01f, -1.55876130e-01f, 5.01364395e-02f, -1.95393518e-01f, -4.33410443e-02f, -9.97678097e-03f, -6.96247742e-02f, 2.22999826e-02f, 1.89803272e-01f,
  9.51410644e-03f, 1.75396428e-01f, -6.41788635e-03f, 2.25004077e-01f, 1.47021338e-01f, -8.16305261e-03f, 6.45685717e-02f, 1.32928893e-01f, -4.75822017e-03f, 7.99780712e-02f,
  -9.95960366e-03f, 2.13144585e-01f, -1.03954755e-01f, 3.89098143e-03f, 9.64308828e-02f, 3.43060419e-02f, 8.47450942e-02f, -4.31212485e-02f, 1.49424821e-01f, 1.50913012e-03f,
  -9.77826584e-03f, 3.82717401e-02f, 2.38012280e-02f, -2.75981389e-02f, -4.69720326e-02f, 5.26986755e-02f, 5.47436327e-02f, 1.00001786e-02f, 3.04865651e-02f, 1.04201153e-01f,
  1.15220258e-02f, -6.84534460e-02f, 4.16012518e-02f, 2.70603299e-02f, -4.06275690e-02f, -1.16302737e-03f, 3.14326882e-02f, -9.61000100e-02f, 1.70943316e-03f, 9.15893093e-02f,
  -4.76209410e-02f, -3.02116014e-02f, -1.56769175e-02f, 5.39229847e-02f, -7.53176957e-02f, -6.72538579e-02f, -9.19758603e-02f, -4.52539772e-02f, 1.02603793e-01f, 6.57398626e-02f,
  9.19832066e-02f, -1.84312854e-02f, 6.87189726e-03f, -7.80104566e-03f, -1.61271971e-02f, 3.24623249e-02f, -8.62118602e-02f, -3.29316854e-02f, -5.73393330e-02f, 9.38751027e-02f,
  -5.47059849e-02f, -1.01125546e-01f, 3.62649672e-02f, 1.27308201e-02f, -2.46083457e-02f, 6.56358302e-02f, -5.86805567e-02f, -3.73735540e-02f, -1.00192487e-01f, -6.72372058e-02f,
  1.03220288e-02f, 9.63856950e-02f, 2.64418703e-02f, -4.04710434e-02f, 5.73485009e-02f, -6.79720491e-02f, 1.13034500e-02f, 8.81801471e-02f, -7.97190517e-02f, 2.17044726e-02f,
  -2.61393450e-02f, 1.77079812e-01f, 9.34667792e-03f, -6.09417073e-02f, -1.56762789e-03f, 6.52641505e-02f, -1.87726680e-03f, 1.11377113e-01f, 5.88533133e-02f, 3.86991613e-02f,
  1.00541592e-01f, 5.32836616e-02f, 7.77668227e-03f, -1.59291662e-02f, -3.08537483e-02f, 5.75071312e-02f, -2.77452990e-02f, 5.37798963e-02f, 4.78537865e-02f, -2.62814667e-02f,
  -5.84670976e-02f, -1.54915580e-03f, -2.15452109e-02f, -6.01740330e-02f, -2.20837910e-03f, 8.70218351e-02f, 4.09669653e-02f, -3.25808376e-02f, 2.81744869e-03f, 6.31636530e-02f,
  -3.03806871e-01f, 4.52918619e-01f, 2.26559833e-01f, -6.14873432e-02f, 2.79613584e-02f, 7.85331577e-02f, -1.64915666e-01f, 2.19212040e-01f, -2.12858915e-02f, -7.49380386e-04f,
  -1.75442230e-02f, 1.97640504e-03f, 1.40590623e-01f, -3.95474918e-02f, -1.29345685e-01f, 1.49188831e-01f, -7.28102103e-02f, -2.22819135e-01f, 9.78991985e-02f, -5.40929325e-02f,
  -3.37767117e-02f, -3.15212607e-02f, 1.09480564e-02f, 2.24217772e-01f, -8.38470235e-02f, -7.74232745e-02f, -2.02038780e-01f, 2.34396711e-01f, -1.27299637e-01f, 2.77360231e-02f,
  -1.38217077e-01f, -6.68540224e-02f, -1.25259280e-01f, -9.57700014e-02f, -1.44254401e-01f, -7.33598620e-02f, -6.05452247e-02f, -5.19216061e-02f, -6.75216913e-02f, -2.92164497e-02f,
  -5.60357049e-02f, -3.18365172e-03f, -3.90723348e-02f, -3.10622174e-02f, 7.56654888e-02f, -8.16795696e-03f, -3.35238576e-02f, 4.02016528e-02f, 1.20583579e-01f, 9.46502313e-02f,
  5.64755425e-02f, 8.24084878e-02f, -1.00773834e-01f, -3.39948088e-02f, -3.79627421e-02f, 5.60509190e-02f, -8.97827223e-02f, 3.16672064e-02f, -5.51639609e-02f, -1.93711948e-02f,
  -5.14592975e-02f, 4.86218650e-03f, -1.43731441e-02f, -8.12745392e-02f, 5.23836948e-02f, -2.76804827e-02f, -5.60557246e-02f, 4.71884161e-02f, -4.79544923e-02f, -7.33507425e-02f,
  -3.76128452e-03f, -1.64848920e-02f, 6.13614684e-03f, -9.14734155e-02f, -9.01624262e-02f, -7.20348135e-02f, -1.32755330e-03f, 2.84960642e-02f, -1.63882598e-02f, -5.14494739e-02f,
  -6.18913248e-02f, -4.60974835e-02f, 8.51206034e-02f, 5.58127500e-02f, -4.84059416e-02f, 4.40587439e-02f, -4.47306894e-02f, 3.33967507e-02f, 2.81984527e-02f, -4.39976379e-02f,
  -1.08567566e-01f, -8.05460066e-02f, -9.55142155e-02f, 1.01771681e-02f, -7.50154704e-02f, -4.07237485e-02f, -6.79995120e-02f, -2.16894522e-02f, 5.23315817e-02f, -4.11253572e-02f,
  -7.29181617e-02f, -1.03751071e-01f, -4.74285372e-02f, -1.06114065e-02f, -2.41535064e-02f, 4.27113809e-02f, -9.75451607e-04f, -4.80449200e-02f, -4.05834876e-02f, -3.16773392e-02f,
  -5.46126291e-02f, -1.95240155e-02f, -5.26060276e-02f, 4.71122786e-02f, -9.79167521e-02f, -5.14093041e-02f, -5.06762899e-02f, 4.81384285e-02f, -3.84639092e-02f, 1.15631841e-01f,
  7.41089135e-02f, -1.32235900e-01f, -2.90609062e-01f, 1.65043026e-02f, -2.59325296e-01f, -4.66184527e-01f, -4.57715780e-01f, -1.46814317e-01f, 2.10797235e-01f, -6.61803856e-02f,
  -1.64370447e-01f, 5.24337869e-03f, 3.81034948e-02f, -1.28834933e-01f, 3.14580590e-01f, 3.18102092e-01f, -6.90306202e-02f, -3.55644547e-03f, 3.17732245e-03f, -1.17125876e-01f,
  1.98784217e-01f, -1.15733370e-01f, 3.76837701e-02f, -2.13930875e-01f, -3.10663462e-01f, -1.28684789e-01f, 2.16068551e-01f, -2.17396557e-01f, -1.32443398e-01f, -7.83267021e-02f,
  -1.06929950e-01f, 2.88272314e-02f, -8.98800939e-02f, 8.90156161e-03f, -1.02323167e-01f, -6.22893348e-02f, -8.37068707e-02f, 2.02441197e-02f, 9.01087746e-02f, -5.55088706e-02f,
  6.00526258e-02f, 7.69059360e-03f, 6.53769672e-02f, 1.01289578e-01f, -3.66125293e-02f, 4.46918271e-02f, 7.08671734e-02f, -6.46439344e-02f, -1.10433042e-01f, -3.81644890e-02f,
  -1.24766201e-01f, 1.38799176e-02f, -1.91066284e-02f, 1.45998020e-02f, 1.08642980e-01f, 1.90307051e-02f, 4.57141921e-02f, 7.65585480e-03f, 3.33112888e-02f, 3.21991295e-02f,
  -1.72946658e-02f, 1.19419629e-02f, -8.20081905e-02f, 4.01454046e-02f, -4.11228240e-02f, -6.82442412e-02f, -6.38085534e-04f, -2.52467375e-02f, -5.96820116e-02f, -2.31348369e-02f,
  -5.01605310e-03f, 5.70114926e-02f, -3.32538486e-02f, -5.13664670e-02f, -4.82827723e-02f, 5.42011559e-02f, -5.89254461e-02f, -7.78909773e-02f, -4.52649258e-02f, 2.43509375e-02f,
  -1.11550642e-02f, 2.91037224e-02f, -3.60129736e-02f, 2.43402813e-02f, -1.00147299e-01f, 1.41769310e-03f, -4.74080183e-02f, -2.29971763e-02f, 2.92160790e-02f, -9.26616788e-02f,
  -6.37557432e-02f, 1.37852222e-01f, -5.33026978e-02f, 4.49957885e-02f, 4.21114229e-02f, -9.62850377e-02f, -3.99701111e-02f, 2.84443963e-02f, -2.04114802e-02f, 4.33621295e-02f,
  -4.68185768e-02f, 6.96869940e-02f, 9.67005361e-03f, 6.17545061e-02f, 2.48968527e-02f, -1.03501230e-01f, -8.80227983e-03f, 1.33205712e-01f, 1.12009188e-02f, -5.72754536e-03f,
  3.18560526e-02f, -5.48720695e-02f, 1.33822402e-02f, 9.45588648e-02f, 3.07524554e-03f, -3.99965197e-02f, -5.06283902e-02f, 4.85965684e-02f, -4.39314730e-02f, 9.41995755e-02f,
  1.21501394e-01f, -1.83128621e-02f, -6.02926351e-02f, -1.12874925e-01f, 7.39219487e-02f, 1.07312709e-01f, -3.31246369e-02f, -9.09990352e-03f, -3.09436083e-01f, 3.74006182e-02f,
  5.68546131e-02f, -5.61488532e-02f, 5.22098467e-02f, 1.95525177e-02f, 9.32812840e-02f, 6.12019151e-02f, 7.83852935e-02f, -3.37026734e-03f, 6.49040863e-02f, 1.33471653e-01f,
  4.64478172e-02f, 4.50424068e-02f, 1.74549669e-01f, 1.32394567e-01f, 2.06399366e-01f, 1.02362223e-01f, -1.76344961e-02f, -3.09468415e-02f, 5.49083166e-02f, -1.80090386e-02f,
  1.24257490e-01f, 5.89780360e-02f, 7.28459656e-02f, 2.44408101e-03f, 2.90993452e-02f, 1.06047705e-01f, -4.35070992e-02f, -8.35357681e-02f, -2.44738460e-02f, -5.60452379e-02f,
  4.55597490e-02f, -4.75609936e-02f, 1.22426655e-02f, -8.85027833e-03f, -4.63365316e-02f, 6.36393949e-02f, -3.39256898e-02f, -1.36841470e-02f, -6.32449985e-02f, 1.96484290e-02f,
  -7.88941160e-02f, 7.40471706e-02f, 6.13456964e-02f, 2.34988425e-02f, -8.12741593e-02f, -1.31958490e-02f, 9.31343716e-03f, 1.09832995e-01f, -3.78025346e-03f, 5.51752225e-02f,
  1.38557255e-01f, -6.93842098e-02f, 1.09812848e-01f, 7.18672574e-02f, -4.42639813e-02f, -4.16126736e-02f, -2.04095282e-02f, -5.13363583e-03f, -7.04528317e-02f, 6.64389208e-02f,
  -9.82915163e-02f, 4.95602712e-02f, 5.07386178e-02f, -4.13180292e-02f, 7.78489932e-02f, 3.46663296e-02f, 5.38591705e-02f, -5.78827374e-02f, 4.13757972e-02f, 9.23360363e-02f,
  2.71592457e-02f, 8.44127983e-02f, -7.02776685e-02f, -3.26298401e-02f, -2.69187372e-02f, 8.92497040e-03f, 8.02451149e-02f, 8.29425827e-02f, -3.59615847e-03f, -1.16767315e-02f,
  7.99296051e-02f, -1.73267797e-02f, 3.26361507e-02f, 4.73489519e-03f, 1.08440354e-01f, 7.03517199e-02f, 7.14420378e-02f, -7.44140744e-02f, -8.42522904e-02f, -7.53431842e-02f,
  2.80068833e-02f, -6.03799410e-02f, 2.51734369e-02f, -4.87438701e-02f, -1.06524058e-01f, 1.10150844e-01f, -8.96904245e-02f, -2.62517352e-02f, -9.44124907e-02f, 1.30721182e-01f,
  5.95112517e-02f, -1.64444558e-02f, -1.17311016e-01f, -4.29662541e-02f, -1.07606992e-01f, -8.09328165e-03f, -4.84436890e-03f, 6.16932549e-02f, 5.30052893e-02f, -3.40701193e-02f,
  9.35271457e-02f, -7.44280452e-03f, -2.07824603e-01f, -1.41469210e-01f, -2.00387120e-01f, -1.60174012e-01f, -1.14933863e-01f, -7.55040944e-02f, -2.38277800e-02f, 2.08353013e-01f,
  6.20572753e-02f, -4.39377204e-02f, 1.74711589e-02f, 1.55576870e-01f, -5.80687672e-02f, 1.27352789e-01f, 2.29965914e-02f, -2.65924875e-02f, -6.63709566e-02f, -5.69930486e-02f,
  -2.98619624e-02f, 1.26208648e-01f, 1.96016934e-02f, 4.96060215e-03f, -9.84582864e-03f, -8.00704733e-02f, 1.07190423e-01f, -2.47179810e-02f, 5.35567850e-02f, 3.81829068e-02f,
  -1.34382471e-02f, 9.78176966e-02f, -3.43979858e-02f, -4.13380787e-02f, 4.87187654e-02f, -6.12570122e-02f, 3.10610980e-03f, -7.46549666e-02f, 4.77049500e-02f, -5.96827418e-02f,
  -1.54710729e-02f, 1.96005143e-02f, 1.45354094e-02f, -2.01083254e-02f, -1.15024280e-02f, -4.92788590e-02f, -8.02082494e-02f, 3.52534233e-04f, -6.45283535e-02f, 6.31847903e-02f,
  -4.77611348e-02f, 6.40997514e-02f, 1.68325882e-02f, 5.06007671e-03f, 5.47209382e-02f, 8.43883771e-03f, -5.20195067e-02f, -8.27307440e-03f, -4.48947884e-02f, -9.01721492e-02f,
  2.76924726e-02f, 2.46553458e-02f, -2.47172862e-02f, -6.50360808e-02f, 8.92410893e-03f, 1.02089159e-01f, -5.42149991e-02f, 1.49306143e-02f, -5.52500412e-02f, 1.94311179e-02f,
  -2.93905661e-02f, 2.98882984e-02f, 1.39166769e-02f, 5.11818333e-03f, -7.98776448e-02f, -5.22977225e-02f, -2.36453600e-02f, -3.98604013e-02f, 5.69644868e-02f, -6.03874736e-02f,
  -7.82747418e-02f, -5.06440140e-02f, 8.53874460e-02f, 2.74722930e-02f, -7.60302842e-02f, -7.31661320e-02f, 2.29609963e-02f, -7.20846653e-02f, 8.04730132e-02f, -9.52859372e-02f,
  -5.59048764e-02f, -6.33646399e-02f, 5.14729694e-02f, 2.01516766e-02f, 3.00518163e-02f, -3.30247357e-02f, -1.38165439e-02f, -9.43093449e-02f, 8.34423862e-03f, -6.71013594e-02f,
  -1.08409129e-01f, -1.02694750e-01f, -8.83580446e-02f, 2.36173682e-02f, -1.05897315e-01f, -7.32236058e-02f, -3.92150059e-02f, -6.40802756e-02f, -7.27435648e-02f, -9.46926232e-03f,
  1.52877802e-02f, -9.71926898e-02f, 2.54328661e-02f, -9.70728323e-02f, 9.31379665e-03f, 2.40480453e-02f, -6.35029227e-02f, -4.44801748e-02f, -6.26528189e-02f, -1.54829735e-03f,
  6.48444295e-02f, 1.39569327e-01f, 1.00365281e-01f, 1.08685359e-01f, -2.13018642e-03f, -1.88598141e-01f, 2.45652138e-03f, 3.17893662e-02f, 1.71011969e-01f, 5.50362766e-02f,
  1.43244918e-02f, 1.25692323e-01f, 4.41643372e-02f, -9.41232145e-02f, -3.34879160e-01f, -2.06761822e-01f, -1.21639982e-01f, -1.61761008e-02f, 4.43071164e-02f, 6.07904568e-02f,
  -1.04182787e-01f, -3.64020728e-02f, -1.03988133e-01f, 6.17215186e-02f, 1.13825411e-01f, 1.33730292e-01f, -1.34753436e-01f, 1.75956711e-01f, -1.14804231e-01f, -5.09913862e-02f,
  -1.10413909e-01f, 1.04816288e-01f, 4.89638261e-02f, -5.71971387e-02f, -7.35238567e-02f, 3.05347368e-02f, 3.02100629e-02f, 7.59883150e-02f, -4.45989296e-02f, 1.18426094e-02f,
  9.52718407e-02f, 6.71231821e-02f, 7.14004710e-02f, -4.31014001e-02f, 9.61398855e-02f, -5.87388277e-02f, 8.49433709e-03f, -6.67064218e-03f, -1.24083273e-03f, -4.77329716e-02f,
  5.17931245e-02f, -5.21801375e-02f, 5.07631525e-02f, -8.33750889e-02f, 4.83555682e-02f, 1.86280012e-02f, -7.69964308e-02f, -6.91089928e-02f, 1.23950001e-02f, -1.51055148e-02f,
  1.01237565e-01f, 3.86009216e-02f, -6.37680665e-02f, -3.31752077e-02f, 1.28721176e-02f, -8.72479938e-03f, 7.71534890e-02f, -1.33769745e-02f, -3.46184708e-02f, -1.82672702e-02f,
  -1.16197066e-02f, -3.93470824e-02f, 8.11346024e-02f, -1.11089624e-01f, -6.76855370e-02f, 5.77281415e-02f, 6.44080043e-02f, 6.90331087e-02f, 4.61054705e-02f, -6.00292422e-02f,
  2.69224774e-02f, -5.47311381e-02f, 7.16086179e-02f, -8.92148241e-02f, 3.30577679e-02f, -3.78178507e-02f, -2.99652647e-02f, 6.53662980e-02f, 3.82529832e-02f, 7.10570393e-03f,
  1.17337238e-02f, 3.74254175e-02f, -2.29629744e-02f, 8.27952176e-02f, -1.34657184e-02f, -7.40656629e-02f, 1.44281415e-02f, -2.53376476e-02f, -1.13189183e-01f, -4.49078530e-02f,
  -6.11252822e-02f, 2.99813543e-02f, -8.01443756e-02f, 3.83972153e-02f, -4.89544943e-02f, -4.63702902e-02f, -2.13086568e-02f, -2.58129952e-03f, 5.73032722e-02f, -1.62748154e-02f,
  1.53880036e-02f, 2.18393989e-02f, -1.83193330e-02f, 8.91037509e-02f, 7.51576871e-02f, -6.00197501e-02f, 3.14947665e-02f, -6.43636212e-02f, -1.27279675e-02f, 1.05516352e-02f,
  -2.62374729e-01f, 9.08675641e-02f, 2.77634412e-01f, -2.60676146e-01f, -1.99691951e-02f, -2.05561202e-02f, -2.85828914e-02f, 9.20458362e-02f, -9.52058062e-02f, -7.65191391e-02f,
  3.77437063e-02f, -6.60551712e-02f, 2.03344226e-01f, -9.89866778e-02f, 1.56743124e-01f, 6.18815757e-02f, -8.19747150e-02f, -7.58944750e-02f, 1.61796361e-01f, -9.64508131e-02f,
  -9.65421200e-02f, -2.33913981e-03f, 1.93822175e-01f, 1.74149916e-01f, -1.56033887e-02f, -5.21487221e-02f, -1.60585746e-01f, 1.41526341e-01f, -1.23707727e-01f, 4.08051088e-02f,
  2.18977556e-02f, 9.36563537e-02f, 8.79527107e-02f, 1.35073945e-01f, 6.99069127e-02f, -3.70691977e-02f, -7.90212527e-02f, -1.37509489e-02f, -9.70305279e-02f, -5.54539710e-02f,
  -1.07598335e-01f, 1.25798509e-01f, 1.75331403e-02f, 2.60721073e-02f, -6.93287849e-02f, -6.94472492e-02f, 1.51517410e-02f, 1.58169288e-02f, -3.76152806e-02f, 1.07106224e-01f,
  9.94419754e-02f, -9.01418924e-02f, -2.16274150e-02f, -1.17217854e-01f, -8.19930341e-03f, -6.84856325e-02f, -5.68017513e-02f, -6.15822114e-02f, -1.58449709e-02f, -2.24962272e-02f,
  1.03619888e-01f, -1.34633943e-01f, 5.16053289e-02f, -5.42450510e-02f, -1.58547033e-02f, -8.10837094e-03f, -7.30983391e-02f, -6.81551993e-02f, 3.40498574e-02f, 4.95513296e-03f,
  -5.98417260e-02f, -5.89069799e-02f, -3.41306062e-04f, -2.95500010e-02f, -7.53795682e-03f, -1.72761753e-02f, -7.96205364e-03f, 7.81242475e-02f, -5.94915822e-02f, 1.33530842e-02f,
  4.99760620e-02f, -2.73443200e-02f, -3.96752730e-03f, -9.05217975e-02f, 1.02207758e-01f, 1.14003371e-03f, 3.72609459e-02f, 9.32338238e-02f, -5.32223433e-02f, -9.22654569e-02f,
  1.20398365e-01f, 2.03057490e-02f, -4.49016457e-03f, 2.71936767e-02f, 4.86083403e-02f, 6.23521581e-02f, -1.09688938e-02f, -5.19953966e-02f, 1.97938294e-03f, 1.08698294e-01f,
  -1.01224974e-01f, -2.95174699e-02f, -1.02013215e-01f, -4.11475897e-02f, 5.53940870e-02f, 6.46211505e-02f, 1.36659322e-02f, -4.71376479e-02f, -5.34643978e-02f, 5.57281896e-02f,
  -1.43033331e-02f, 1.86090209e-02f, 6.14836924e-02f, -5.96564915e-03f, -5.49789071e-02f, -8.24202895e-02f, -6.73765764e-02f, -1.48988422e-02f, 7.04157650e-02f, -3.36832106e-02f,
  1.67251870e-01f, -3.54872853e-01f, 5.13386503e-02f, 9.89636183e-02f, 1.94079250e-01f, 1.04069456e-01f, 1.22446634e-01f, -3.13912556e-02f, 1.09162197e-01f, -2.08455950e-01f,
  -1.33923173e-01f, -2.80423090e-02f, -1.95639133e-01f, -2.21679900e-02f, 1.64291397e-01f, -4.32755649e-02f, -2.12385710e-02f, 2.05169450e-02f, 9.83178318e-02f, -6.46540448e-02f,
  1.17397234e-01f, 2.28183847e-02f, 2.50605145e-03f, -1.65713608e-01f, 7.56414654e-03f, -1.49201183e-03f, -8.52074027e-02f, -1.87290192e-01f, -9.20065120e-03f, 6.72882516e-03f,
  6.45260215e-02f, 6.52525574e-02f, 2.31064353e-02f, -4.35255803e-02f, 1.87483570e-03f, 3.59417871e-02f, -2.65962724e-02f, -5.17161153e-02f, -3.31945457e-02f, 7.02535510e-02f,
  1.75667740e-02f, 3.05852257e-02f, -2.65525617e-02f, -6.34514615e-02f, 8.77742842e-02f, -8.06502551e-02f, 6.33148476e-02f, -6.23590052e-02f, -9.44851711e-03f, 5.59984073e-02f,
  8.91446620e-02f, 3.91275845e-02f, -5.36098108e-02f, -1.11810744e-01f, 7.96644669e-03f, -1.61542147e-02f, -6.18648157e-02f, 2.40321569e-02f, 6.45340001e-03f, 2.38532270e-03f,
  -1.36366615e-03f, 1.32307541e-02f, -6.45916816e-03f, 9.10356417e-02f, -1.51419248e-02f, 1.11454867e-01f, -1.94916371e-02f, -2.93355640e-02f, -1.85453519e-02f, -2.70646028e-02f,
  -6.60823360e-02f, 2.30677985e-02f, 5.19197099e-02f, -2.98550073e-02f, 4.48119640e-02f, -4.68622819e-02f, -2.78043076e-02f, -2.36771330e-02f, 7.05912113e-02f, 6.50015324e-02f,
  -2.36635040e-02f, -3.10169943e-02f, 2.68150233e-02f, -3.92939113e-02f, 6.78678900e-02f, -3.59452777e-02f, 2.77773216e-02f, -4.00538929e-02f, 4.70602326e-02f, -5.81922568e-03f,
  -5.02351522e-02f, -2.70139277e-01f, 2.36378741e-02f, -6.05418719e-03f, -7.47151002e-02f, -6.51404038e-02f, -2.42935978e-02f, 7.02244192e-02f, 1.69552937e-02f, -3.14327404e-02f,
  2.59041265e-02f, -1.24157285e-02f, -3.16889733e-02f, 3.35856639e-02f, 1.69384852e-02f, 4.50278819e-02f, -6.59193248e-02f, -8.91924545e-04f, -1.23258671e-02f, -7.00928867e-02f,
  2.98764370e-02f, 4.88089919e-02f, -5.79903685e-02f, 7.38650560e-02f, 1.76057108e-02f, 5.31654693e-02f, -4.51851301e-02f, -1.10740274e-01f, -1.08336829e-01f, -6.47561699e-02f,
  1.64125860e-01f, -6.19923994e-02f, -8.50646943e-02f, 1.88988000e-01f, 8.06075288e-04f, -1.19820252e-01f, -8.43297690e-02f, -2.04678904e-02f, 9.97415110e-02f, -2.07978949e-01f,
  6.72858581e-03f, -9.40318108e-02f, -1.27904981e-01f, -2.92253606e-02f, 1.89081565e-01f, -3.98825258e-02f, 9.93730649e-02f, -8.92207325e-02f, 7.12978393e-02f, 1.74332082e-01f,
  8.57241750e-02f, 9.76133272e-02f, 1.04088269e-01f, -1.25117645e-01f, -5.29853590e-02f, 1.35915041e-01f, 2.50128172e-02f, -1.24778815e-01f, 1.57296788e-02f, -6.40297830e-02f,
  3.48310545e-02f, 1.60232261e-01f, 5.24265505e-02f, -1.03417374e-01f, 9.16777328e-02f, 6.11234643e-02f, -2.07889341e-02f, -9.24496725e-02f, 4.36318032e-02f, -4.17883322e-02f,
  2.15635984e-03f, 6.31853938e-02f, 3.97116803e-02f, -2.72750780e-02f, 7.58448290e-03f, -1.97617128e-03f, 2.86102854e-02f, 1.17075711e-01f, 1.18685756e-02f, -6.28775801e-04f,
  1.33413039e-02f, 7.30679091e-03f, 1.87139604e-02f, 2.79309787e-02f, -7.77291972e-03f, -7.89092109e-02f, -7.08801448e-02f, -4.63924184e-02f, 6.39483929e-02f, 1.20203048e-01f,
  -1.90874841e-02f, 4.34594341e-02f, 3.49146724e-02f, -9.21734422e-03f, 3.97869125e-02f, -5.05747721e-02f, 2.20054500e-02f, 5.05241230e-02f, -6.49175495e-02f, -4.19282950e-02f,
  4.28164043e-02f, 3.01691759e-02f, -3.00876261e-03f, -5.77746443e-02f, 6.98998943e-02f, 7.45291784e-02f, 3.75870690e-02f, 2.66738678e-03f, -2.82570254e-02f, -1.45249618e-02f,
  -2.27278005e-02f, -6.54952303e-02f, 3.91655155e-02f, 1.85178826e-03f, -1.15390681e-01f, 2.75458582e-02f, 6.76620333e-03f, -5.80687914e-03f, -3.98295298e-02f, 4.51813973e-02f,
  -2.50501907e-03f, 9.01438817e-02f, 3.54586430e-02f, -3.67853902e-02f, -2.05799080e-02f, 8.99820700e-02f, -1.07254155e-01f, -3.11353672e-02f, -5.69823161e-02f, 3.13968286e-02f,
  2.71450151e-02f, 4.55391109e-02f, 3.03695183e-02f, 9.65082087e-03f, -1.03120610e-01f, -1.94552005e-04f, 3.22395451e-02f, -6.39545023e-02f, 1.33526474e-02f, 7.05020875e-02f,
  -5.94340712e-02f, -2.49938071e-02f, -2.05938350e-02f, 2.96328086e-02f, 5.33309840e-02f, -1.91439316e-02f, 1.45407077e-02f, 2.55186893e-02f, -3.43619063e-02f, -4.69618738e-02f,
  -3.37164372e-01f, 1.27544731e-01f, -3.79876345e-01f, -2.15621829e-01f, 6.90937936e-02f, -1.69771984e-01f, 2.55306158e-03f, 2.50658188e-02f, -6.29035980e-02f, 4.72674668e-01f,
  3.13445359e-01f, -2.22108155e-01f, 1.93920776e-01f, -4.78923470e-02f, -6.17285490e-01f, -2.02559844e-01f, -5.60982227e-02f, -8.01049545e-02f, -1.20877206e-01f, -1.13349771e-02f,
  -2.88248837e-01f, 2.29334578e-01f, -2.66711950e-01f, 1.93838388e-01f, 1.24680392e-01f, 6.09623343e-02f, 2.26474956e-01f, 9.67114717e-02f, 9.31270197e-02f, -6.79105744e-02f,
  -2.79351417e-02f, 3.04917502e-03f, -9.08307135e-02f, -7.51048923e-02f, -6.23777471e-02f, -1.28909964e-02f, 3.00441161e-02f, -5.85144348e-02f, -9.83122811e-02f, -8.29073265e-02f,
  1.76863987e-02f, 4.80102189e-02f, 1.92094389e-02f, 2.65552308e-02f, 9.47034732e-02f, -4.49419469e-02f, -9.35853347e-02f, -6.90277070e-02f, -2.52613369e-02f, -1.70886114e-01f,
  -1.01336390e-01f, -1.92067027e-02f, 3.65527943e-02f, -4.44731675e-02f, -6.50070012e-02f, 6.47081360e-02f, -1.26846358e-01f, -1.00654364e-01f, 3.11166160e-02f, -1.14627317e-01f,
  -2.51988899e-02f, -2.98395250e-02f, 4.21382822e-02f, -5.43025136e-02f, -7.99478963e-02f, 7.14467838e-03f, 3.79258096e-02f, 1.65140089e-02f, -2.55664182e-03f, 1.32435001e-02f,
  3.84199508e-02f, -2.24011932e-02f, 3.20933238e-02f, 4.02449407e-02f, 4.82588448e-02f, 5.47051392e-02f, -4.90011424e-02f, -3.93309183e-02f, -3.33778225e-02f, -4.61735986e-02f,
  5.00034355e-02f, 2.12995857e-02f, -2.50011459e-02f, 2.44652014e-02f, 1.70739554e-02f, -6.69991784e-03f, 1.49219297e-02f, -1.86217017e-02f, 4.68944348e-02f, 5.84020233e-03f,
  5.57652414e-02f, 4.48147953e-02f, 7.39621893e-02f, 7.87140653e-02f, 1.65654384e-02f, 4.07922007e-02f, 1.82026830e-02f, -7.32787177e-02f, 1.30004743e-02f, 1.10102687e-02f,
  6.35597259e-02f, 1.06099419e-01f, 4.36632447e-02f, -2.11766120e-02f, -3.34576219e-02f, 4.40425389e-02f, 7.15321451e-02f, -2.84641515e-02f, 5.49478903e-02f, -5.35677969e-02f,
  6.73511103e-02f, 2.49747876e-02f, -1.36004733e-02f, 4.50289361e-02f, -1.00897644e-02f, 8.11089277e-02f, 5.34862839e-02f, 1.46559821e-02f, -9.06925052e-02f, 1.61695275e-02f,
  -5.70135355e-01f, 2.72009701e-01f, 1.37169704e-01f, -1.49820015e-01f, -2.10338086e-01f, 3.64430428e-01f, 2.70948201e-01f, 7.76026724e-03f, -9.74354595e-02f, 1.52487144e-01f,
  4.05949652e-02f, -1.83557302e-01f, 2.94324756e-01f, 7.36707821e-02f, 1.32165894e-01f, 3.38271379e-01f, 2.41315395e-01f, 1.30049437e-01f, -6.63081259e-02f, -1.24849297e-01f,
  -1.57848358e-01f, 2.27114130e-02f, 1.29540995e-01f, 9.79657378e-03f, -2.17324346e-01f, -2.15778902e-01f, -1.83911890e-01f, -2.79123951e-02f, -4.94679585e-02f, -6.79689199e-02f,
  -2.00492069e-01f, -2.47602135e-01f, -1.13869989e-02f, 4.92294841e-02f, 1.66334212e-02f, -5.96862100e-02f, 1.39007543e-03f, -6.03565015e-02f, -2.06560101e-02f, -6.87718093e-02f,
  -4.33275960e-02f, 2.42163148e-02f, -6.64835870e-02f, -3.50563601e-02f, 2.06763782e-02f, -6.16185926e-02f, 4.13945466e-02f, 5.98257259e-02f, 2.70328186e-02f, -5.07984161e-02f,
  4.48712781e-02f, 5.29482812e-02f, 5.01534827e-02f, 6.80278763e-02f, -1.95098035e-02f, 3.77384983e-02f, -2.88742222e-02f, -3.46431322e-02f, 1.35695394e-02f, -6.29878789e-02f,
  -5.89694045e-02f, -1.05901314e-02f, 1.26546500e-02f, -7.22784456e-03f, -1.21822981e-02f, 2.55383886e-02f, 2.19349917e-02f, -5.03013693e-02f, -3.46588083e-02f, 6.10003397e-02f,
  -1.97524596e-02f, -1.81996524e-02f, -2.19099633e-02f, 1.07187763e-01f, 1.51084028e-02f, 7.39386678e-02f, 1.03457961e-02f, -1.03346333e-02f, 7.93495327e-02f, 7.95275196e-02f,
  2.76090391e-02f, -4.94964272e-02f, -1.48603581e-02f, -1.78190246e-02f, -5.85886231e-03f, 1.03450380e-02f, -7.06869215e-02f, 7.27511644e-02f, -1.67405121e-02f, 5.00642657e-02f,
  -6.15329035e-02f, -2.21507445e-01f, -8.64602160e-03f, -1.12327777e-01f, -8.51747394e-03f, -5.39429337e-02f, 5.64731583e-02f, -8.82536918e-02f, -3.43251824e-02f, -4.53022681e-02f,
  4.33028862e-02f, -7.89916739e-02f, 2.46458761e-02f, 5.51310107e-02f, 7.07001844e-03f, -2.78298594e-02f, 1.09583663e-03f, -5.85421957e-02f, -5.86482277e-03f, 6.55061081e-02f,
  -8.75144545e-03f, -6.86801448e-02f, 1.18468031e-02f, 1.18200518e-02f, 7.23833032e-03f, -6.75256699e-02f, 3.27762775e-03f, -2.03506965e-02f, 1.79566769e-03f, 7.34488964e-02f,
  8.33576098e-02f, -1.57548025e-01f, 3.03381886e-02f, 1.08994827e-01f, 4.66900785e-03f, 8.93251300e-02f, -4.18533273e-02f, -5.22146672e-02f, 5.11910021e-02f, -2.24386334e-01f,
  7.91302323e-02f, -3.98674719e-02f, -1.81657732e-01f, 2.53186673e-01f, 1.62553251e-01f, -1.14920564e-01f, 1.55403569e-01f, 1.62915379e-01f, 7.05096722e-02f, -6.10801391e-02f,
  5.83577268e-02f, 3.62779610e-02f, -3.98344593e-03f, -1.53160125e-01f, 7.04848990e-02f, 8.58710557e-02f, 5.54743409e-03f, -5.68349585e-02f, 1.39417052e-01f, 8.54176527e-04f,
  3.57026644e-02f, -1.14195466e-01f, -7.57097900e-02f, 2.75290795e-02f, -4.02585641e-02f, -2.83658169e-02f, -4.90288476e-05f, 6.08172938e-02f, -6.95215911e-02f, 7.07501695e-02f,
  -1.52389482e-02f, -2.36133933e-02f, -5.98947285e-03f, -2.66451086e-03f, 6.02188259e-02f, 8.40769708e-02f, 8.12976956e-02f, 1.10972226e-01f, -1.63153633e-02f, 1.72184203e-02f,
  -2.52595432e-02f, 6.01520203e-02f, -1.15345353e-02f, 1.61902979e-02f, 2.40880009e-02f, -4.10006195e-02f, -2.83993650e-02f, -8.64207074e-02f, 4.27326374e-02f, -5.39474413e-02f,
  2.00715493e-02f, -6.83800578e-02f, -8.12350288e-02f, 2.26831753e-02f, 6.17409609e-02f, 1.16363876e-02f, 2.90456489e-02f, 9.41146985e-02f, -3.82452784e-03f, -4.88542840e-02f,
  7.79684037e-02f, 6.94730282e-02f, -4.16718610e-02f, 1.72782037e-02f, 2.62488704e-02f, 1.86838619e-02f, 4.07083426e-03f, 5.84255792e-02f, 6.72227219e-02f, 5.85244745e-02f,
  -8.96256864e-02f, -1.87435355e-02f, 5.72426282e-02f, 8.27070177e-02f, -4.20906879e-02f, -3.76037695e-02f, 5.00716083e-02f, 1.81047637e-02f, 5.31037524e-02f, -1.32544376e-02f,
  -2.50097632e-01f, -3.29453498e-01f, 6.38834108e-03f, -3.52052301e-02f, -7.75874406e-02f, 6.22570924e-02f, -8.48398134e-02f, -8.58331472e-02f, -1.56222031e-01f, -7.27827251e-02f,
  4.25944105e-03f, 3.89751196e-02f, -5.94111569e-02f, -3.04571912e-02f, -8.10394250e-03f, 1.10238111e-02f, 3.05080996e-03f, -7.54461735e-02f, 3.08963228e-02f, 2.50444449e-02f,
  -3.64200920e-02f, 2.79907435e-02f, -5.27134947e-02f, 2.27466058e-02f, -1.39011513e-03f, 4.81280424e-02f, 4.65975516e-02f, 2.07556393e-02f, 6.92164972e-02f, 4.66727465e-02f,
  -2.37631470e-01f, 7.10890666e-02f, -3.38954628e-01f, -3.74207705e-01f, 1.73099920e-01f, -2.94749886e-01f, -2.78089285e-01f, -9.65717249e-03f, -8.05680156e-02f, 6.18512146e-02f,
  3.61591130e-02f, -9.42249820e-02f, 1.43656597e-01f, -3.03510815e-01f, -4.20393229e-01f, -9.60018933e-02f, -3.50297570e-01f, -2.34439433e-01f, -3.78486663e-02f, -1.32476121e-01f,
  -1.78147852e-01f, -4.85093780e-02f, -2.52520204e-01f, 1.67126015e-01f, -1.87013447e-01f, 6.66123927e-02f, 8.91247168e-02f, 9.45482254e-02f, -1.80550888e-01f, -3.27034853e-03f,
  -9.54554901e-02f, -8.36070627e-02f, -1.21326014e-01f, 3.62323821e-02f, -1.00414306e-02f, -5.76329231e-02f, -6.13192795e-03f, 1.90188698e-02f, 1.37908070e-03f, -1.39106559e-02f,
  5.75445145e-02f, 9.39697493e-03f, -8.86393115e-02f, 9.60753933e-02f, -2.22460851e-02f, -5.20933457e-02f, -8.72423127e-02f, -5.91967665e-02f, -9.26569849e-02f, -1.92297564e-03f,
  -4.77556773e-02f, 2.59797159e-03f, -5.03925700e-03f, 2.28579529e-02f, -7.00098351e-02f, 4.59931158e-02f, -1.85886715e-02f, -1.31169986e-02f, 6.93714619e-02f, 4.72866520e-02f,
  -2.73947325e-02f, -9.09919792e-04f, -4.71274219e-02f, 6.68658540e-02f, -3.32240611e-02f, 4.57553156e-02f, -2.59252451e-03f, 1.21220406e-02f, -1.25912158e-02f, -3.33054177e-03f,
  -3.20372246e-02f, 7.09044114e-02f, 3.32943574e-02f, -8.51386860e-02f, -1.10105155e-02f, 3.54514718e-02f, -6.27877787e-02f, 4.54519056e-02f, -1.97027717e-02f, -4.13490236e-02f,
  7.72328973e-02f, 2.15725470e-02f, 4.17761169e-02f, -5.56550771e-02f, -8.45285058e-02f, -2.14269273e-02f, -3.44395861e-02f, 4.62897830e-02f, 1.10881953e-02f, 2.87472233e-02f,
  -3.63383479e-02f, -2.36981828e-02f, 5.42119332e-02f, 6.64969608e-02f, 5.06738434e-03f, 5.68935648e-02f, -1.32257827e-02f, -7.46393204e-02f, -5.87031543e-02f, -6.08705431e-02f,
  6.09844960e-02f, -6.97971433e-02f, -2.59369649e-02f, -7.67229348e-02f, -2.84199882e-03f, 1.35158785e-02f, 5.42385429e-02f, 6.77972734e-02f, 6.40110746e-02f, 8.63943845e-02f,
  -1.80352910e-03f, -1.14738732e-03f, -1.51829014e-03f, -6.12950400e-02f, 5.98045662e-02f, 4.03027013e-02f, 4.77294996e-02f, -7.86322877e-02f, -6.09905124e-02f, 2.58491226e-02f,
  1.88241065e-01f, -1.49706885e-01f, -1.12342313e-02f, 5.38320765e-02f, 1.51252672e-01f, -6.08410500e-02f, 8.82839784e-02f, -8.36140364e-02f, -8.55666623e-02f, -1.10521704e-01f,
  1.03695832e-01f, -6.23838883e-03f, 4.28014621e-02f, 4.35868874e-02f, -3.15613560e-02f, -7.59668928e-03f, 1.74339209e-02f, 9.71251428e-02f, -3.90920788e-02f, -6.96581155e-02f,
  -4.67046611e-02f, 9.03616846e-03f, -7.76173100e-02f, -6.48096427e-02f, -5.36776520e-03f, -3.91589813e-02f, -4.81278114e-02f, -1.71272587e-02f, -8.98649991e-02f, 8.73714834e-02f,
  -8.12041610e-02f, -4.46515270e-02f, 7.22556338e-02f, -6.48714229e-02f, -6.75043687e-02f, 5.28439768e-02f, -6.85633495e-02f, -1.43886870e-02f, 2.49739625e-02f, 3.25363241e-02f,
  -6.00236207e-02f, 5.61813004e-02f, 3.92474905e-02f, -2.09937207e-02f, -4.69425432e-02f, -7.47368187e-02f, -3.69941641e-04f, -4.54877736e-03f, -7.62051642e-02f, 1.97604727e-02f,
  -9.05395225e-02f, -1.23402037e-01f, -8.69023204e-02f, -1.02418415e-01f, -6.98128864e-02f, -7.98294023e-02f, -1.20807052e-01f, 1.92758050e-02f, 2.88541429e-02f, 2.33427938e-02f,
  -2.06527696e-03f, 2.55101863e-02f, 7.50919357e-02f, 9.93848443e-02f, -4.54129577e-02f, 4.02096100e-02f, -3.06831840e-02f, -5.37857004e-02f, -1.60549823e-02f, 2.29323376e-02f,
  -2.73684151e-02f, 3.33288498e-02f, 7.86584690e-02f, -5.43252192e-02f, 1.86954718e-02f, -2.44812109e-02f, 8.48727487e-03f, -9.33019817e-02f, 4.29490283e-02f, 2.75410153e-02f,
  6.37054816e-02f, 2.39506569e-02f, 7.06858709e-02f, -2.82614492e-02f, -4.24335413e-02f, 7.57668242e-02f, -1.90950725e-02f, -5.89127056e-02f, -4.87214066e-02f, -3.58700976e-02f,
  -1.95198450e-02f, -2.63934024e-03f, 3.78289968e-02f, -1.57997813e-02f, 6.18678741e-02f, -8.03190768e-02f, -1.04256533e-01f, -1.95877142e-02f, -1.37263127e-02f, -6.01527207e-02f,
  -3.53250913e-02f, -1.93844754e-02f, 4.46211398e-02f, 2.57878061e-02f, -6.12199232e-02f, 5.45406379e-02f, 3.27130444e-02f, 7.63892895e-03f, -8.79045501e-02f, -1.17940016e-01f,
  6.61270618e-02f, -5.95257692e-02f, -7.90769607e-02f, -6.72768578e-02f, -3.04118134e-02f, -1.67426001e-02f, -7.68973455e-02f, -7.79500827e-02f, 4.64163758e-02f, -5.80640472e-02f,
  -5.55656776e-02f, 3.54863182e-02f, 8.13456066e-03f, -1.60352271e-02f, -6.13435730e-02f, -6.56319484e-02f, 3.89978029e-02f, 1.20693296e-02f, -2.76566017e-02f, 7.19505996e-02f,
  9.98359919e-02f, 4.84277308e-03f, 1.30702913e-01f, 4.23546471e-02f, -4.02286611e-02f, 1.49928648e-02f, -6.11471348e-02f, -7.15856180e-02f, 7.23364437e-03f, -3.36848013e-02f,
  6.18882962e-02f, 1.23168439e-01f, 4.93746884e-02f, 2.44544428e-02f, 5.03238738e-02f, 6.71899021e-02f, -1.27014313e-02f, 5.38733713e-02f, 9.75322351e-03f, -8.91332477e-02f,
  -3.47846821e-02f, -2.50548888e-02f, 8.60515386e-02f, 2.63649710e-02f, -9.62572172e-02f, -8.40927288e-02f, -1.13670364e-01f, -1.26196176e-03f, -7.34065520e-03f, 6.76732138e-02f,
  -9.97774899e-02f, -1.17279114e-02f, -4.03670734e-03f, 2.44300477e-02f, -3.51573899e-02f, 2.11156216e-02f, 9.37552378e-02f, 8.38304311e-03f, -1.61943156e-02f, 4.02709059e-02f,
  8.23030248e-02f, -2.51983907e-02f, -9.36401486e-02f, -5.76638766e-02f, 8.36205557e-02f, 2.11700741e-02f, -5.97419441e-02f, 1.98605638e-02f, -5.54823875e-02f, -3.38073820e-02f,
  -3.33180539e-02f, -7.68903941e-02f, 7.85522982e-02f, -6.22863546e-02f, -7.25180283e-02f, -3.60918194e-02f, 6.18359558e-02f, 6.70014992e-02f, -3.90999280e-02f, -1.57951545e-02f,
  5.47252260e-02f, -4.96405475e-02f, -8.63475874e-02f, -2.41015386e-02f, -4.43208143e-02f, -8.22313130e-02f, -4.49136198e-02f, 9.00272727e-02f, 7.32493848e-02f, -4.46936041e-02f,
  -1.65133979e-02f, -4.24870551e-02f, -2.93356143e-02f, 6.54780418e-02f, 6.32647052e-02f, 4.41463999e-02f, 8.22351277e-02f, 6.28935918e-02f, 5.96372969e-02f, 8.08764249e-02f,
  3.22821140e-02f, 1.00096256e-01f, -7.80926421e-02f, -1.73714757e-02f, 2.85333861e-02f, 4.73503694e-02f, -1.05234347e-02f, 3.23522021e-03f, -8.70938376e-02f, -6.72138110e-02f,
  -4.83542010e-02f, -5.06770313e-02f, -6.87646642e-02f, -4.05322388e-02f, 5.13560977e-03f, 6.47063693e-03f, -9.62468144e-03f, -7.65864775e-02f, 2.59447414e-02f, -5.28891943e-02f,
  7.71761164e-02f, 1.23609705e-02f, -5.86162731e-02f, -2.62035858e-02f, 4.56297696e-02f, 5.21057993e-02f, -9.25056487e-02f, -1.59512199e-02f, -8.24553892e-02f, -2.53469180e-02f,
  1.27694577e-01f, -1.78071856e-01f, 1.40463442e-01f, 2.74928004e-01f, 9.37747806e-02f, 1.16690457e-01f, 1.58358023e-01f, -9.95932966e-02f, 9.70627472e-04f, -1.59045026e-01f,
  -1.91368252e-01f, 2.49611780e-01f, -2.68921226e-01f, 5.52414283e-02f, 1.64346486e-01f, -2.08796889e-01f, 5.03294449e-03f, -4.62497165e-03f, 8.76218453e-02f, -6.36476427e-02f,
  5.77216670e-02f, -1.00615278e-01f, 1.46335540e-02f, -8.69640335e-02f, 1.01488255e-01f, 7.75156394e-02f, -1.34423599e-01f, 5.15494170e-03f, 7.05405921e-02f, 1.68283641e-01f,
  -2.91442070e-02f, -4.72903401e-02f, 1.31716281e-02f, 4.50977758e-02f, -7.80052841e-02f, 5.11292405e-02f, 1.12999313e-01f, 1.28122687e-01f, 1.10307798e-01f, -6.67120591e-02f,
  7.13326968e-03f, -4.79151495e-03f, 1.25452206e-01f, -6.13273755e-02f, 1.45176305e-02f, 5.90796582e-02f, -5.53764496e-03f, -4.05194163e-02f, 2.82260124e-02f, 2.93936413e-02f,
  6.29056320e-02f, -5.36736920e-02f, 6.52890056e-02f, 5.79041801e-02f, -5.52579239e-02f, 6.20646849e-02f, -2.79092020e-03f, 5.93967661e-02f, 1.11704916e-01f, 1.06075302e-01f,
  -1.06413320e-01f, 2.11444590e-02f, 5.64941391e-02f, -1.90544538e-02f, 5.55344708e-02f, 3.99046466e-02f, 6.43036962e-02f, -5.20259999e-02f, 6.26071393e-02f, -6.87172338e-02f,
  6.35372847e-02f, 2.00068299e-02f, 3.86022031e-02f, -4.13105115e-02f, 3.22642252e-02f, 8.51967856e-02f, 1.57910609e-03f, 1.09744249e-02f, -6.01724796e-02f, -1.90106854e-02f,
  4.13965769e-02f, -3.74717126e-03f, -6.35205358e-02f, 2.87918728e-02f, -6.37068301e-02f, -6.81229457e-02f, 4.63006943e-02f, -6.66223392e-02f, -1.10528329e-02f, -2.35033128e-02f,
  -2.67613493e-02f, -1.17330618e-01f, -5.32505699e-02f, 5.35204560e-02f, -3.15576829e-02f, -2.61001363e-02f, 4.98158298e-02f, -2.67588869e-02f, -6.33877069e-02f, 3.54165249e-02f,
  -6.68047965e-02f, -2.31552264e-03f, 4.64453585e-02f, 7.67436549e-02f, -7.68600851e-02f, -8.16066936e-02f, -7.83808604e-02f, -5.13867624e-02f, -7.59164169e-02f, -1.14138958e-04f,
  -1.45684201e-02f, -3.17555219e-02f, 3.99354473e-02f, -2.01336797e-02f, 5.66066839e-02f, -2.19925083e-02f, -3.81652964e-03f, -1.90083273e-02f, -9.16154608e-02f, -5.54831885e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  9.42499489e-02f, 2.33047292e-01f, 3.21010649e-01f, 1.40179489e-02f, 7.53331482e-02f, 2.31388435e-01f, 7.89920017e-02f, 1.06825680e-01f, 1.39618590e-01f, 3.32831591e-01f,
  1.78213120e-01f, 1.99378178e-01f, 2.69322693e-01f, 1.61098331e-01f, 3.47603038e-02f, 4.97078151e-02f, 1.43740416e-01f, 1.50727585e-01f, 1.05091088e-01f, 3.19729865e-01f,
  2.33451828e-01f, 6.82532415e-02f, 2.11530522e-01f, 4.05788384e-02f, -7.37938210e-02f, 2.23732755e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  2.25318387e-01f, -5.87070659e-02f, -5.47127761e-02f, -3.15498829e-01f, -2.36710310e-01f, 2.92125970e-01f, -5.26292855e-03f, 1.08590983e-01f, 2.20730960e-01f, 1.15529038e-02f,
  -4.90267538e-02f, -1.04287704e-02f, 3.78488228e-02f, 3.67076881e-02f, -3.40526491e-01f, -1.01037420e-01f, -5.65895021e-01f, 2.09458098e-01f, -3.20560038e-01f, -1.57759674e-02f,
  2.80296594e-01f, 1.40693570e-02f, -5.64849079e-01f, -3.47435415e-01f, -4.62346524e-02f, -2.73257941e-01f, -1.32922918e-01f, 1.80177078e-01f, -3.14249873e-01f, -3.78416032e-01f,
  -4.05484855e-01f, 2.00107574e-01f, -1.01866454e-01f, -5.13559997e-01f, 1.10687651e-01f, -4.35315818e-01f, -4.38084640e-02f, 4.07086432e-01f, 1.19553439e-01f, 2.71547824e-01f,
  -2.98206896e-01f, 3.02909940e-01f, -1.77811220e-01f, -1.34639338e-01f, -1.41948342e-01f, -2.12316245e-01f, 1.35790959e-01f, 5.02650253e-02f, 1.55389691e-02f, -6.05251044e-02f,
  -3.48503366e-02f, 4.38014828e-02f, 2.41405502e-01f, -1.64233938e-01f, -7.16613159e-02f, -2.33251080e-01f, -1.43500283e-01f, 3.43000174e-01f, 7.27199495e-01f, 1.51541278e-01f,
  -2.00645179e-01f, -4.47850861e-02f, 9.73600000e-02f, -2.69892842e-01f, -2.67269790e-01f, 3.09059829e-01f, 2.31349021e-01f, 4.88639951e-01f, 1.24971010e-01f, -2.67081171e-01f,
  1.70122117e-01f, -2.84631729e-01f, -4.36311960e-01f, -3.25154334e-01f, -1.60659224e-01f, -1.87928416e-02f, 7.04179034e-02f, 1.39422849e-01f, 2.35709473e-01f, -3.45029145e-01f,
  2.54032582e-01f, 9.67843533e-02f, -2.64205337e-01f, 4.78303075e-01f, 2.00357646e-01f, 1.25907123e-01f, 5.44623584e-02f, -3.25009555e-01f, -6.23943985e-01f, 2.28243113e-01f,
  -2.70439208e-01f, -4.87827033e-01f, -2.94631124e-01f, -5.85282326e-01f, 3.42698558e-03f, 3.11007649e-01f, 8.50892141e-02f, 3.48318331e-02f, 1.77946597e-01f, -1.45117640e-01f,
  4.88853693e-01f, 4.60379332e-01f, 5.66039860e-01f, 3.64363998e-01f, -6.52125627e-02f, 1.70343563e-01f, -2.27503981e-02f, -1.61261812e-01f, -3.20647098e-02f, -1.28485709e-01f,
  -2.05922231e-01f, -1.43056199e-01f, 4.57645804e-01f, -8.51383805e-02f, -1.61005691e-01f, 3.62161696e-01f, 2.28459194e-01f, -2.26918727e-01f, -8.23867694e-02f, 4.25268989e-03f,
  6.47759512e-02f, 3.45752090e-02f, -9.08501521e-02f, 1.03474110e-02f, -1.36232764e-01f, 1.91669986e-01f, -5.96614517e-02f, -8.80288258e-02f, -2.59152293e-01f, -1.60372555e-01f,
  -1.75113067e-01f, -4.80359048e-01f, -1.15761682e-01f, -5.19888282e-01f, -3.19418401e-01f, 4.40633185e-02f, -1.55771906e-02f, 4.45598811e-02f, 1.17644757e-01f, -1.58582225e-01f,
  8.31233039e-02f, 2.84601878e-02f, 1.73769929e-02f, -1.08859189e-01f, 1.84119180e-01f, -1.38642907e-01f, -1.84895340e-02f, 3.82350475e-01f, -3.16881120e-01f, -4.54663217e-01f,
  3.90623182e-01f, 1.96629375e-01f, -3.83648455e-01f, 2.20865682e-01f, -2.74762690e-01f, -1.80087000e-01f, -2.13666767e-01f, -3.04435521e-01f, -5.22751749e-01f, -6.59674928e-02f,
  3.28358322e-01f, 3.53493810e-01f, 7.66977072e-02f, -2.21233293e-01f, -3.04991126e-01f, 2.26665810e-01f, 2.49513134e-01f, -1.01390414e-01f, -1.32090390e-01f, 4.37466353e-02f,
  3.90441678e-02f, 6.18164480e-01f, 7.87990615e-02f, -1.39877409e-01f, 3.75952482e-01f, -2.74102628e-01f, 7.25726085e-03f, -1.73631296e-01f, 1.53351232e-01f, -8.00791290e-03f,
  -2.76672784e-02f, -1.30147547e-01f, -2.25495130e-01f, 1.99298978e-01f, 2.81219129e-02f, -2.97327340e-02f, -1.51490301e-01f, 4.18362051e-01f, -9.01426598e-02f, 2.62118168e-02f,
  -1.62117586e-01f, 4.21931237e-01f, -6.41193092e-01f, 2.97863018e-02f, 7.74624571e-02f, -5.61226308e-01f, 8.22330490e-02f, -2.49866787e-02f, 1.04926877e-01f, 9.16988105e-02f,
  9.39262658e-02f, -3.79258245e-01f, 1.38759062e-01f, -5.53434156e-02f, 1.31407589e-01f, 2.02372726e-02f, -7.20264688e-02f, 6.48723915e-02f, 4.11184691e-02f, -1.25201745e-02f,
  -5.95642142e-02f, -4.63925004e-01f, 1.77824974e-01f, -3.01895469e-01f, -2.86182314e-01f, 4.58092958e-01f, 3.66120130e-01f, 4.33533676e-02f, 4.54744659e-02f, 2.83171982e-02f,
  8.74546021e-02f, 3.11346594e-05f, -2.95490712e-01f, 1.23087853e-01f, -6.86386079e-02f, 4.65469211e-02f, -2.56393790e-01f, -1.72509149e-01f, -7.58143961e-02f, -2.87250906e-01f,
  -1.20205216e-01f, -3.38463411e-02f, -1.20739706e-01f, 1.68243295e-03f, 1.31731806e-02f, -2.47342646e-01f, 2.43019566e-01f, -7.54069015e-02f, -1.04555666e-01f, -2.27436051e-01f,
  -3.86464484e-02f, 4.49314415e-01f, -1.34476215e-01f, -2.20909432e-01f, 6.08293489e-02f, 3.48875254e-01f, 1.61852270e-01f, -2.66021907e-01f, -2.31029913e-01f, 6.36276066e-01f,
  -1.52894154e-01f, -1.61001056e-01f, 5.70676208e-01f, 1.54139817e-01f, 1.19326517e-01f, -5.04389629e-02f, 7.72722736e-02f, 1.18184704e-02f, 1.27663806e-01f, 4.12908524e-01f,
  3.19966763e-01f, 8.64582881e-02f, 2.03122005e-01f, 3.10540777e-02f, 1.16177924e-01f, 3.34249198e-01f, -5.60648702e-02f, 5.71521260e-02f, 9.20432284e-02f, 1.06746413e-01f,
  2.61056542e-01f, 6.35308400e-02f, 9.43172500e-02f, 5.11970818e-02f, 2.46626988e-01f, -8.85448813e-01f, 4.00839537e-01f, -1.85751364e-01f, -1.33968160e-01f, -3.10645550e-01f,
  2.51863837e-01f, 1.79347724e-01f, 1.77076370e-01f, 4.48904037e-01f, 6.53418303e-01f, 1.51508793e-01f, -4.27700788e-01f, -2.09317371e-01f, -3.63905489e-01f, -1.12979831e-02f,
  2.30357245e-01f, 2.37212107e-01f, 4.93623950e-02f, -2.30398014e-01f, -2.38600522e-02f, 1.86829995e-02f, -3.70678186e-01f, 3.47097702e-02f, 1.93166375e-01f, -3.31749208e-02f,
  -5.83096854e-02f, 1.08947530e-01f, 1.63145512e-01f, 2.09275290e-01f, -3.21659684e-01f, 6.02569103e-01f, -3.89071494e-01f, 2.95741796e-01f, -5.83341010e-02f, -2.37992600e-01f,
  5.45349956e-01f, -3.05420682e-02f, -1.30311325e-01f, -3.79770219e-01f, 5.29108107e-01f, -4.20066752e-02f, -1.71737410e-02f, -1.12150207e-01f, -6.01113066e-02f, -1.05745628e-01f,
  2.51000077e-01f, 1.94262043e-01f, -2.41883636e-01f, 2.21509829e-01f, -3.64513025e-02f, 1.91168278e-01f, -9.18799862e-02f, 6.97254762e-02f, 3.14085871e-01f, 3.60274881e-01f,
  3.61206353e-01f, -9.09865424e-02f, 3.20924334e-02f, -5.02031222e-02f, 1.68436795e-01f, 3.13197464e-01f, 1.69695154e-01f, -4.34420317e-01f, 4.47775722e-01f, 5.14991701e-01f,
  3.59886497e-01f, 6.21435463e-01f, 1.74948409e-01f, -3.03568989e-01f, 2.65383482e-01f, -3.73396546e-01f, -2.19862834e-01f, -2.33212590e-01f, -6.22281611e-01f, 1.22142516e-01f,
  5.62921464e-01f, -3.83633733e-01f, -4.58465666e-01f, -3.49580854e-01f, -1.70903698e-01f, -8.32212530e-03f, 5.06318271e-01f, 6.93589002e-02f, -8.28690529e-02f, 5.10541141e-01f,
  2.91836739e-01f, -8.72914195e-02f, -1.62998900e-01f, -3.64505798e-01f, -2.25194674e-02f, 1.34348556e-01f, -4.34793271e-02f, -4.04428959e-01f, 2.08999604e-01f, 8.82876515e-02f,
  6.90590665e-02f, -2.38314256e-01f, -1.75821722e-01f, -3.04669123e-02f, -5.11244126e-02f, -1.18811622e-01f, -1.22878768e-01f, -3.00286204e-01f, 2.31384486e-01f, -2.15798780e-01f,
  -2.60225534e-01f, -7.17236102e-02f, -1.76827148e-01f, 1.38146967e-01f, 8.00419524e-02f, -1.20337948e-01f, 7.51928193e-03f, -1.86997563e-01f, 1.29546970e-02f, 3.70081067e-01f,
  5.32017164e-02f, 1.33025050e-02f, 3.58884066e-01f, -1.03230819e-01f, -2.56715715e-01f, 2.71914959e-01f, 4.69607040e-02f, -2.05651611e-01f, -2.38260940e-01f, 2.18095556e-01f,
  1.76848862e-02f, 1.38101459e-01f, 4.15323302e-02f, 4.74938840e-01f, -4.10226792e-01f, -4.12932038e-02f, 3.49833995e-01f, 2.27861837e-01f, 4.35366750e-01f, 9.30587947e-02f,
  -5.99611998e-01f, 1.26082763e-01f, -2.66851664e-01f, 6.02330208e-01f, 2.65038222e-01f, -5.33791780e-02f, -5.26249290e-01f, 5.62052608e-01f, 1.76894858e-01f, -1.57372519e-01f,
  6.27133608e-01f, -3.78986627e-01f, -1.07410867e-02f, -3.09173614e-01f, -2.99192339e-01f, -1.90631047e-01f, 3.27766389e-01f, 3.58194411e-01f, 9.01088044e-02f, 5.16764708e-02f,
  -2.87065029e-01f, 3.34859118e-02f, -1.56496018e-01f, -1.24304488e-01f, 2.69760955e-02f, -9.42775458e-02f, -9.07942876e-02f, 7.89574757e-02f, -2.12847635e-01f, 4.97743905e-01f,
  2.78706253e-01f, -2.59745687e-01f, -3.34986180e-01f, 3.27076375e-01f, -1.95397303e-01f, 1.57543600e-01f, -6.80798590e-02f, 2.91667581e-01f, 5.36890887e-02f, -2.00375587e-01f,
  -9.70894545e-02f, -2.38057613e-01f, 1.40941575e-01f, 2.61282288e-02f, -3.03603053e-01f, -4.14023876e-01f, -4.09830540e-01f, -5.74188866e-02f, -7.39267021e-02f, 3.70578468e-02f,
  2.01016311e-02f, -2.52865940e-01f, -6.68028668e-02f, -2.68245041e-01f, 7.93768689e-02f, 7.64517412e-02f, -2.97202557e-01f, -2.33695298e-01f, 1.48471996e-01f, 1.61791265e-01f,
  -2.15550750e-01f, -1.51276022e-01f, 1.32850647e-01f, -3.30982506e-01f, 3.52723002e-01f, 3.35992604e-01f, 3.68618757e-01f, -6.35244045e-03f, -1.04540162e-01f, -3.13591719e-01f,
  2.94356886e-02f, 2.94899456e-02f, -4.16852921e-01f, -4.32167090e-02f, 9.62796956e-02f, -9.54195559e-02f, -8.80694836e-02f, -2.96033055e-01f, -1.85466692e-01f, -6.81804866e-02f,
  -1.86825916e-02f, -1.92633808e-01f, 2.62033381e-02f, 2.98499465e-01f, 2.35524014e-01f, 2.59481609e-01f, 2.30219625e-02f, 2.64907219e-02f, 8.76484692e-01f, -1.27435222e-01f,
  2.03796059e-01f, -1.73060641e-01f, 1.08774165e-02f, 6.35732338e-02f, 1.62590742e-01f, -1.53107852e-01f, -4.70231101e-02f, 5.04290499e-02f, 4.79496062e-01f, -5.90872485e-03f,
  -9.00287256e-02f, -1.17379069e-01f, 2.06651971e-01f, -4.18289840e-01f, 5.63554727e-02f, -3.71838100e-02f, 1.62808206e-02f, 1.82997778e-01f, 1.61876697e-02f, 9.14598554e-02f,
  -5.78026213e-02f, 1.26135454e-01f, -3.74285847e-01f, 5.66781014e-02f, -4.77348685e-01f, 3.02829742e-02f, -2.61380095e-02f, 5.32020554e-02f, -4.52691346e-01f, -4.33156313e-03f,
  -3.21467943e-03f, -2.83583581e-01f, -5.67495227e-01f, -1.27715394e-01f, 4.15271342e-01f, 4.68234330e-01f, -2.46566787e-01f, 2.17972517e-01f, -2.65246034e-01f, -3.27810913e-01f,
  -9.16645899e-02f, -4.38408285e-01f, 1.22603767e-01f, 5.37126422e-01f, 2.73777127e-01f, -4.72723544e-01f, 4.36465442e-01f, 5.30229509e-01f, -4.49999928e-01f, 2.88688838e-01f,
  -1.16198711e-01f, -2.15539932e-01f, 3.21887881e-01f, 3.55099767e-01f, -7.24961609e-02f, -5.21650575e-02f, 1.64826006e-01f, 2.14488208e-01f, 2.35795781e-01f, -2.37718999e-01f,
  2.84532934e-01f, 1.28277197e-01f, 2.47539878e-01f, 1.72743902e-01f, 7.91606456e-02f, 2.19541751e-02f, 1.28368929e-01f, -2.54409432e-01f, 2.55924135e-01f, -2.50636697e-01f,
  -2.24151373e-01f, -9.88954082e-02f, -2.38082811e-01f, -1.00046366e-01f, 9.76804197e-02f, -1.04125224e-01f, 9.70663056e-02f, 2.29832932e-01f, 9.62204933e-02f, -9.37218517e-02f,
  -2.30664641e-01f, 2.12142706e-01f, 1.12421848e-01f, 1.19441055e-01f, -1.48535132e-01f, -1.77548155e-01f, 1.74554497e-01f, 1.21094644e-01f, -6.27523800e-03f, 9.79407653e-02f,
  1.44502902e-02f, -2.09728256e-02f, 3.80737223e-02f, -3.17848511e-02f, 5.68442792e-02f, 3.90483588e-01f, 1.24004707e-01f, -1.64173305e-01f, 5.55928409e-01f, -5.49426913e-01f,
  -3.28240782e-01f, -3.08054816e-02f, 2.64137775e-01f, 4.68120605e-01f, -5.19933105e-01f, 3.43440264e-01f, -3.20273817e-01f, -3.84292901e-01f, -1.99234217e-01f, -1.28074467e-01f,
  -5.53258479e-01f, 5.37478104e-02f, -5.80009043e-01f, -2.03968480e-01f, -2.73092270e-01f, -3.99942666e-01f, -2.68520683e-01f, -2.95138694e-02f, 1.24204829e-01f, -1.00077845e-01f,
  -1.19750075e-01f, -1.00507423e-01f, -1.41689599e-01f, 9.01043594e-01f, -7.44061023e-02f, -1.98705584e-01f, -7.62335658e-02f, 6.56980230e-03f, -1.43338650e-01f, 1.12805590e-02f,
  8.20780843e-02f, 1.55225128e-01f, -1.13528498e-01f, -3.73108357e-01f, 8.90530795e-02f, 9.27233100e-02f, -2.74295509e-01f, 2.19530463e-01f, -5.35055734e-02f, 2.94642597e-01f,
  5.04536569e-01f, 1.34968027e-01f, -5.85478023e-02f, 4.16044325e-01f, -2.60738403e-01f, 1.57553241e-01f, 7.50553533e-02f, 2.16481034e-02f, -1.66842058e-01f, 3.18819471e-02f,
  2.50958055e-01f, 1.00935519e-01f, 1.09198324e-01f, 3.01409252e-02f, -1.32141337e-01f, 9.45465863e-02f, 5.93569968e-03f, -1.97157804e-02f, 5.93876205e-02f, 1.62612483e-01f,
  2.40350664e-02f, -2.69629180e-01f, -3.80056977e-01f, 4.60966349e-01f, -4.88576502e-01f, 4.79232632e-02f, 5.92614114e-01f, -6.10723436e-01f, 4.76720303e-01f, -1.77001223e-01f,
  3.10809821e-01f, 3.91864598e-01f, 3.34971488e-01f, 5.47370911e-01f, -1.43418178e-01f, 4.53773588e-01f, -3.10258448e-01f, -3.03294092e-01f, -1.74837247e-01f, 6.24005077e-03f,
  -1.15549862e-01f, -5.81216477e-02f, -1.41065419e-01f, -9.10826474e-02f, -2.39306897e-01f, 1.25588030e-01f, -1.83332560e-03f, -3.77583094e-02f, -9.94865447e-02f, -2.32699499e-01f,
  -2.96497583e-01f, 2.65875999e-02f, -5.71988970e-02f, 5.13325706e-02f, -2.87532419e-01f, -1.15007862e-01f, -5.64505383e-02f, 6.28794014e-01f, -2.69780278e-01f, -2.51363426e-01f,
  4.36014563e-01f, -4.53402251e-02f, -1.07753880e-01f, -1.77312642e-01f, 9.63353515e-02f, 1.91480443e-02f, -1.36377111e-01f, 1.09481618e-01f, 8.73245522e-02f, -1.59751743e-01f,
  -3.35398945e-03f, 1.86245456e-01f, 2.05449328e-01f, -2.37497538e-01f, -1.29199266e-01f, -8.16734210e-02f, 7.95756727e-02f, 1.14204898e-01f, 3.60019207e-02f, 6.26532137e-02f,
  8.22846517e-02f, 1.96647435e-01f, 1.22256748e-01f, -2.32167795e-01f, -2.03470722e-01f, 3.89634401e-01f, -2.68219918e-01f, 4.11203712e-01f, 4.69292104e-01f, -2.24924088e-01f,
  -4.45519425e-02f, 1.57820911e-03f, 5.83403349e-01f, 4.57420558e-01f, 3.41000140e-01f, -1.78077102e-01f, 5.16798079e-01f, -1.46572575e-01f, 1.79280341e-01f, 9.36232805e-02f,
  -9.29624587e-02f, -4.66813445e-02f, 1.28347516e-01f, -1.89708754e-01f, 9.28979933e-01f, -2.51050055e-01f, -2.71224454e-02f, -1.32133335e-01f, 5.29251359e-02f, 1.02631086e-02f,
  -1.54955477e-01f, 2.68219411e-01f, 1.10870078e-01f, 9.15945545e-02f, -2.65023589e-01f, 3.20248641e-02f, -1.70395710e-02f, 3.26612711e-01f, -1.44370288e-01f, -2.79163849e-02f,
  -1.50795922e-01f, -2.33697802e-01f, -3.10300827e-01f, 1.60451829e-01f, -2.29454413e-01f, -4.38648425e-02f, -5.16776145e-02f, 3.58010650e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -5.00036823e-03f, 2.17960905e-02f, -1.06247135e-01f, -1.75364643e-01f, 8.54370520e-02f, 1.60486698e-01f, 7.14616105e-02f, -5.93243502e-02f, -3.22521254e-02f, -1.47899911e-02f,
  4.37703505e-02f, -4.37149331e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    