/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.63234308e-01f, -7.02698603e-02f, -5.72306752e-01f, 1.05109900e-01f, -3.82675566e-02f, -2.83387691e-01f, -2.50720292e-01f, 2.02090424e-02f, 2.69615334e-02f, -1.24559693e-01f,
  2.57977424e-03f, 1.14682794e-01f, -2.22121067e-02f, -1.73277497e-01f, -2.41342947e-01f, -3.97092909e-01f, -3.55926424e-01f, -3.29963803e-01f, -2.44902879e-01f, -6.82924986e-02f,
  2.53030378e-02f, 1.08821712e-01f, 7.52132982e-02f, 3.73666734e-02f, -1.31062903e-02f, 7.44744316e-02f, -1.21125542e-01f, 4.56485972e-02f, 5.05514219e-02f, -1.53397486e-01f,
  -2.95185566e-01f, 5.99335916e-02f, 4.40329984e-02f, 1.61421195e-01f, -2.60605719e-02f, -2.16673408e-03f, -3.59191336e-02f, 7.10970238e-02f, 1.16268441e-01f, 2.97969822e-02f,
  8.47304985e-03f, -9.91349807e-04f, 4.87035550e-02f, 4.53277491e-02f, -3.16302776e-02f, -2.73066238e-02f, -7.24916384e-02f, -3.02931964e-02f, -2.22434402e-02f, -2.06321739e-02f,
  1.45778492e-01f, 1.01949804e-01f, -4.10285331e-02f, 6.02750108e-03f, -4.13787216e-02f, 2.26192083e-02f, 2.08941707e-03f, 5.77885918e-02f, -6.81053922e-02f, 1.28837079e-01f,
  -5.38902991e-02f, -8.22045803e-02f, 1.73425209e-02f, 4.06376049e-02f, 7.85299093e-02f, 8.71792510e-02f, -4.48093843e-03f, 7.12763146e-02f, -3.57809290e-02f, -2.39409599e-03f,
  1.33326882e-02f, -7.61275217e-02f, -5.46774305e-02f, -1.53500838e-02f, -1.13530932e-02f, 7.17073039e-04f, 2.70190351e-02f, 1.96151379e-02f, 5.17136464e-03f, 5.69589920e-02f,
  9.50495712e-03f, 7.16480687e-02f, 1.48319523e-03f, 5.31610884e-02f, -3.68738361e-02f, -1.20852120e-01f, 5.52327149e-02f, -2.23071929e-02f, 3.67130972e-02f, -2.36638058e-02f,
  2.92278469e-01f, -1.22142769e-01f, 6.02921881e-02f, -1.00462828e-02f, -4.34129275e-02f, 5.19374497e-02f, 2.68660970e-02f, 7.49278208e-03f, 6.51680380e-02f, -2.76511367e-02f,
  2.98689939e-02f, 5.51515631e-02f, -3.16619650e-02f, -5.11257984e-02f, -3.30757871e-02f, 8.30874778e-03f, 1.17600247e-01f, -2.45242789e-02f, 4.00760723e-03f, 8.78937077e-03f,
  3.13352682e-02f, 1.62344594e-02f, 9.73587260e-02f, 1.05518205e-02f, 3.25226076e-02f, -4.66120020e-02f, 4.15869989e-02f, 7.15199411e-02f, -9.71838683e-02f, 5.36295325e-02f,
  -3.75155479e-01f, 1.29071921e-01f, 3.13968927e-01f, -3.01087022e-01f, 1.99117243e-01f, 2.68588126e-01f, 4.51381892e-01f, 3.61672305e-02f, -1.15251631e-01f, -7.66387805e-02f,
  -6.48261309e-02f, -2.89321303e-01f, -3.33170354e-01f, -8.02869648e-02f, 3.51342522e-02f, 2.27969989e-01f, 2.81839371e-01f, 1.21521272e-01f, -1.47277294e-02f, -5.74980751e-02f,
  4.42449562e-02f, 2.06380314e-03f, -1.61901247e-02f, 1.46178259e-02f, -1.07756801e-01f, -1.38981685e-01f, 7.69250914e-02f, 7.54692638e-03f, 9.92270634e-02f, 8.61300603e-02f,
  -2.71733671e-01f, 7.88342394e-03f, -4.77468483e-02f, -7.70087168e-02f, 9.66897383e-02f, -1.31704777e-01f, -7.27844909e-02f, -1.08206064e-01f, -1.10819250e-01f, -2.04830170e-02f,
  -5.11427894e-02f, -2.62549743e-02f, -2.38192081e-02f, 5.27377520e-03f, -1.90755446e-02f, 2.88961716e-02f, 4.22299318e-02f, 3.37804593e-02f, 2.40449701e-02f, 1.66255273e-02f,
  3.29887606e-02f, 1.42574474e-01f, 7.02322200e-02f, 2.66539268e-02f, 8.78104940e-03f, 4.53778133e-02f, 6.95672557e-02f, -4.92296740e-02f, 1.75079808e-01f, -1.70415461e-01f,
  1.12555260e-02f, -2.93306075e-02f, 8.10853206e-03f, 2.04387717e-02f, 1.73406247e-02f, 3.62136140e-02f, -2.31148750e-02f, 5.36470264e-02f, -2.67572850e-02f, 6.79531917e-02f,
  4.06733863e-02f, 4.68869926e-03f, -2.10174685e-03f, -1.14119425e-03f, -4.06780690e-02f, 4.91990298e-02f, 3.27983759e-02f, 1.94788590e-05f, 1.27162291e-02f, 3.23810731e-04f,
  -3.59969363e-02f, 2.22519748e-02f, -3.12036872e-02f, 3.58808264e-02f, 7.84084201e-02f, 4.47191671e-02f, -2.77544204e-02f, 4.37125452e-02f, -4.93343174e-02f, 3.89702059e-02f,
  -3.76157314e-01f, 2.53492236e-01f, -2.46287659e-01f, -7.89434016e-02f, 3.78775969e-02f, 2.80968286e-02f, -2.52624378e-02f, 3.09170485e-02f, 6.44293660e-03f, 9.31941438e-03f,
  8.91084671e-02f, -7.68776517e-03f, 2.69687381e-02f, 4.87264097e-02f, -2.52606776e-02f, 5.63847534e-02f, 8.98792371e-02f, -5.08186333e-02f, 1.11255441e-02f, -3.02186068e-02f,
  1.12666309e-01f, -5.39953937e-04f, -1.76528484e-01f, -4.77109477e-02f, -1.18401118e-01f, -1.11623958e-01f, -1.48142306e-02f, -6.38167709e-02f, -6.53783530e-02f, -1.14868805e-01f,
  4.43937778e-01f, -1.80013385e-02f, -1.88198149e-01f, -5.23140877e-02f, -1.42008573e-01f, 2.32613713e-01f, 4.01508510e-01f, 3.36189389e-01f, 1.07753411e-01f, 1.08165003e-01f,
  -1.13356702e-01f, -2.77917355e-01f, -2.78879553e-01f, -3.00784074e-02f, 6.65710494e-02f, 1.59076914e-01f, 4.82480675e-02f, -1.59299582e-01f, 5.06634498e-03f, 1.14695728e-01f,
  -1.12721168e-01f, -4.61714901e-02f, -1.11820344e-02f, 9.58516300e-02f, -1.58891246e-01f, -1.27203777e-01f, -1.25188325e-02f, -2.09092408e-01f, -4.51447815e-02f, -4.25210595e-01f,
  -3.09520721e-01f, 8.60802531e-02f, -1.84163246e-02f, -1.26154814e-02f, -1.86775416e-01f, 1.89883411e-01f, -3.31972842e-03f, 8.46090242e-02f, 6.52449057e-02f, 3.34231257e-02f,
  -1.13887295e-01f, 1.26209259e-02f, -1.58709139e-01f, -4.55703996e-02f, 6.48821965e-02f, 6.98988885e-02f, 6.75831363e-02f, 3.17033008e-02f, 6.87554330e-02f, 8.58411565e-02f,
  -1.95583075e-01f, -2.42169112e-01f, -7.01255575e-02f, 1.65844813e-01f, 5.70886210e-02f, -1.09925710e-01f, 1.42781716e-02f, 6.66545751e-03f, 1.12903155e-01f, 3.43841203e-02f,
  4.10242267e-02f, -2.27305200e-02f, 3.48227248e-02f, -4.00984772e-02f, 5.55603243e-02f, 4.31812070e-02f, -4.38840576e-02f, -4.69423681e-02f, 3.51420641e-02f, 5.10188611e-03f,
  2.89315246e-02f, -2.44657826e-02f, -1.16539253e-02f, 8.45750123e-02f, -4.73970026e-02f, -4.17954773e-02f, 1.68370064e-02f, 4.82758060e-02f, -4.84512635e-02f, 5.99841923e-02f,
  -4.47746105e-02f, -1.95478238e-02f, -5.15297167e-02f, 1.30966762e-02f, 2.71001030e-02f, -5.12329750e-02f, -5.83593212e-02f, 2.17280481e-02f, 5.03033260e-03f, 4.07753652e-03f,
  1.11761265e-01f, -1.47251040e-01f, -1.09610613e-02f, 5.45427427e-02f, -7.73073062e-02f, -4.79022190e-02f, -1.17935434e-01f, -2.57162768e-02f, -1.26268908e-01f, -7.00810633e-04f,
  -3.67876254e-02f, 2.70456783e-02f, -4.23372462e-02f, 1.00739142e-02f, 3.69981565e-02f, 5.08466642e-03f, 1.04414895e-02f, -1.16030082e-01f, 1.66786853e-02f, -1.88014396e-02f,
  4.12414111e-02f, 1.88813582e-01f, 1.40334502e-01f, -2.17042296e-04f, -1.26124322e-02f, -1.81668065e-02f, -1.03396200e-01f, 8.78779963e-02f, 9.89905745e-02f, 3.65172207e-01f,
  -5.18545508e-01f, 1.44764394e-01f, 4.93134977e-03f, -2.23631896e-02f, 6.36210516e-02f, 1.22195311e-01f, 2.56603092e-01f, 1.08457215e-01f, 1.42173290e-01f, 1.34314178e-02f,
  -1.02366731e-01f, -1.35996535e-01f, 4.20703553e-02f, -1.47915743e-02f, 4.12481511e-03f, 2.05778629e-01f, 1.54578462e-01f, -4.42291349e-02f, -2.21614107e-01f, -1.48991361e-01f,
  6.59866109e-02f, 6.78724572e-02f, -1.63258165e-01f, 7.60469213e-02f, 1.29398257e-01f, 3.26949470e-02f, 8.64549875e-02f, -6.54954389e-02f, -5.60198054e-02f, 4.13971506e-02f,
  -2.54922748e-01f, -1.64156348e-01f, -5.18555148e-03f, -8.00371021e-02f, -2.60203723e-02f, 6.59248745e-03f, -1.72396447e-03f, 5.37928799e-03f, -5.52218184e-02f, 4.85719740e-02f,
  -8.71990398e-02f, -1.85397845e-02f, -6.65947469e-03f, -2.51816995e-02f, 4.70133424e-02f, 2.09330618e-02f, 8.01771972e-03f, -3.95935820e-03f, 2.06062533e-02f, 4.90465648e-02f,
  6.87894300e-02f, -1.99918792e-01f, -3.41152251e-02f, 8.88930634e-02f, -3.33171524e-02f, -1.46418303e-01f, 1.11888118e-01f, -8.59650970e-02f, -3.21458373e-03f, 9.88661200e-02f,
  6.31309599e-02f, -2.45679207e-02f, -5.98547235e-02f, 3.35095637e-02f, -3.54678109e-02f, 2.02380698e-02f, 1.96945984e-02f, 5.94364991e-03f, -2.42184978e-02f, 5.80635704e-02f,
  -1.07294153e-02f, -7.05993548e-02f, 4.90764976e-02f, 3.94105278e-02f, 8.11076462e-02f, -2.09578257e-02f, -6.06984533e-02f, 7.01421574e-02f, -1.94130279e-02f, 2.94247549e-03f,
  1.95733700e-02f, -8.99733230e-02f, 2.23842710e-02f, -2.52784975e-03f, -3.75519879e-02f, 6.24148995e-02f, -7.52230436e-02f, -3.91385891e-02f, 2.63493117e-02f, -7.71724284e-02f,
  3.06669921e-01f, -1.47509187e-01f, 1.71114337e-02f, -2.74937646e-03f, -7.56636634e-02f, 2.57185847e-02f, -2.98089739e-02f, -1.49895335e-02f, -7.26269335e-02f, 3.33010741e-02f,
  -1.36644080e-01f, -3.19492444e-02f, 5.95192946e-02f, 3.64672346e-03f, -5.03372438e-02f, -4.51082177e-02f, 8.67369846e-02f, -5.85277379e-02f, -4.47386205e-02f, 6.46716636e-03f,
  1.49592891e-01f, 5.23923561e-02f, -2.51333807e-02f, 1.68663040e-01f, -1.75935379e-03f, -3.57956029e-02f, 3.93501744e-02f, 3.59047502e-02f, -7.54561946e-02f, 3.05754632e-01f,
  -9.62037966e-02f, 1.05609804e-01f, 2.75548428e-01f, 1.67766064e-01f, 6.48741722e-02f, -3.38593731e-04f, 1.31322548e-01f, -1.39554888e-01f, 1.44354219e-03f, 1.10633776e-01f,
  -1.75166115e-01f, -3.06679726e-01f, -2.44981423e-01f, -1.55324757e-01f, -8.77103284e-02f, 3.73447031e-01f, 4.91494209e-01f, 2.07150251e-01f, -4.77807820e-02f, -2.10062135e-03f,
  4.58369032e-02f, 1.06471434e-01f, -2.20830049e-02f, 8.97416547e-02f, 1.46845132e-01f, -3.81415635e-02f, 1.02367818e-01f, 3.64101445e-03f, 8.09531808e-02f, 5.06779969e-01f,
  -8.91270582e-03f, -7.98295438e-02f, -4.96423505e-02f, -1.96987465e-02f, -4.07483280e-02f, -1.27620548e-01f, -2.30637286e-02f, -2.27430779e-02f, -5.07964790e-02f, 1.40624295e-03f,
  -3.01521551e-02f, -8.07565898e-02f, 4.74136211e-02f, 3.37353605e-03f, 1.05732493e-02f, -8.00765976e-02f, 1.15649834e-01f, 1.08671136e-01f, 7.27892220e-02f, 2.94677895e-02f,
  7.81140625e-02f, 1.27566487e-01f, 3.00476123e-02f, 1.70825571e-02f, -7.43902549e-02f, 2.16158628e-02f, 5.87073213e-04f, -5.24795987e-03f, -6.13071769e-02f, 1.48502529e-01f,
  -7.86751322e-03f, 1.47930533e-02f, -3.26847062e-02f, 1.41733615e-02f, -2.88203023e-02f, -1.39565095e-02f, 1.79979727e-02f, 2.46160068e-02f, -3.42509779e-03f, 7.18327537e-02f,
  -4.12609726e-02f, 9.34204608e-02f, 3.60221118e-02f, 4.62013930e-02f, 2.05320027e-02f, 5.54411225e-02f, 2.83352174e-02f, 4.98700440e-02f, -6.55025765e-02f, 3.19709107e-02f,
  -6.34987801e-02f, 2.72462107e-02f, 1.54097779e-02f, 2.52771564e-02f, -7.15545416e-02f, 5.33592775e-02f, -1.14869094e-03f, -1.51605114e-01f, -6.72367960e-02f, -5.33888452e-02f,
  -2.07197830e-01f, -5.95506504e-02f, 2.85914503e-02f, -1.54835390e-04f, 7.32706115e-02f, 7.87520930e-02f, -1.04927085e-02f, 1.57228094e-02f, -6.75838739e-02f, -1.59386657e-02f,
  -8.46631750e-02f, -9.60804895e-03f, 1.57983862e-02f, 1.07753407e-02f, 4.81577478e-02f, 2.35315152e-02f, 5.48650846e-02f, 5.73989041e-02f, -4.68090214e-02f, -2.50352155e-02f,
  -7.25492090e-03f, 2.81980969e-02f, -8.73768851e-02f, -5.51413372e-02f, 1.65996924e-02f, -6.47771880e-02f, -1.11848220e-01f, -2.48237625e-02f, -7.25376084e-02f, 5.29348291e-02f,
  5.64921368e-03f, -4.31884855e-01f, -1.53864715e-02f, -2.61707872e-01f, -2.72622377e-01f, -8.80580470e-02f, -1.27449408e-01f, -1.19128868e-01f, -4.04446572e-02f, -6.04590513e-02f,
  -1.42084196e-01f, 6.99323490e-02f, 1.83238640e-01f, 1.99087054e-01f, 9.80949923e-02f, -7.97120482e-02f, 4.90541346e-02f, 2.74471462e-01f, 3.95912856e-01f, 1.80169702e-01f,
  -4.65962626e-02f, -1.06826015e-01f, 1.28540978e-01f, -1.04507925e-02f, -1.83400482e-01f, -1.83808766e-02f, -1.24914408e-01f, -7.91451186e-02f, -2.67430842e-02f, -2.15433776e-01f,
  1.88866571e-01f, -4.63027000e-01f, 1.82433710e-01f, 1.95523370e-02f, 2.43607480e-02f, 6.74123093e-02f, 1.05679728e-01f, -7.49606490e-02f, 4.53086644e-02f, -4.20118757e-02f,
  -1.06078833e-01f, -5.20241819e-02f, -4.71514054e-02f, -2.66096368e-02f, -4.77521047e-02f, 4.61962074e-03f, -3.10423486e-02f, 1.47463358e-03f, -1.44487238e-02f, 9.04315561e-02f,
  -1.43434152e-01f, -1.01651236e-01f, -6.28110394e-02f, -7.82827884e-02f, -5.47940172e-02f, 2.16236319e-02f, -3.60811725e-02f, -4.71776538e-02f, -1.08669084e-02f, -1.50814295e-01f,
  4.01432626e-02f, -6.32214472e-02f, -4.12316155e-03f, -2.04409137e-02f, -2.06308570e-02f, 4.44481745e-02f, -1.36550730e-02f, -1.34206621e-03f, 6.66682720e-02f, -6.94320071e-03f,
  2.36631650e-02f, -7.97402486e-03f, 4.33513112e-02f, 2.67855488e-02f, 5.68521358e-02f, -8.15900266e-02f, 1.24590695e-02f, 1.76161174e-02f, 1.32471129e-01f, -2.06233934e-02f,
  -7.99877010e-03f, 1.54800266e-02f, -2.28734426e-02f, 3.53462175e-02f, -4.54471670e-02f, 1.18075842e-02f, -2.67669122e-04f, -1.80327203e-02f, -2.96416506e-02f, -2.63587758e-02f,
  1.34526879e-01f, 3.40230674e-01f, -9.14539862e-03f, -6.92635477e-02f, -5.84398545e-02f, 3.86590920e-02f, -6.36271760e-03f, 3.47538143e-02f, -6.49586469e-02f, 3.20249647e-02f,
  2.41146404e-02f, 1.57708465e-03f, -2.93585006e-02f, 3.11106723e-03f, 8.60042274e-02f, 2.79986970e-02f, 3.04739773e-02f, 1.69165991e-02f, 2.65374351e-02f, -4.72960956e-02f,
  -2.41507273e-02f, 9.16069523e-02f, 1.57560512e-01f, 6.53873309e-02f, -5.25163934e-02f, 1.63057208e-01f, 1.59207851e-01f, 1.21607251e-01f, 1.82063267e-01f, 1.70166060e-01f,
  -2.11627901e-01f, -2.11163417e-01f, 1.25308782e-01f, -1.20535664e-01f, -9.83125623e-03f, 3.44139308e-01f, 3.80426794e-01f, 1.22215271e-01f, -1.69963524e-01f, -7.88844079e-02f,
  -9.17219073e-02f, -1.14943109e-01f, -6.34936616e-02f, 1.18494831e-01f, 2.57502466e-01f, 1.18055373e-01f, 2.14851946e-01f, 1.85698196e-01f, 3.01097125e-01f, 1.39179513e-01f,
  -1.71443000e-02f, -4.25398676e-03f, 2.44023409e-02f, 5.13497368e-02f, -2.00031281e-01f, -3.37524377e-02f, -1.42440200e-01f, -2.06775695e-01f, -8.39300677e-02f, -2.86789417e-01f,
  -1.19402245e-01f, -4.17004138e-01f, 1.88624263e-01f, 2.59676669e-02f, -5.69306388e-02f, 1.52342627e-03f, 3.44410501e-02f, -5.90468831e-02f, 9.46760643e-03f, 1.48840817e-02f,
  -3.22362594e-02f, -8.40733275e-02f, -5.82236089e-02f, -3.50536555e-02f, -2.64914613e-02f, 8.42709690e-02f, 2.97158398e-02f, -1.49954297e-02f, 5.70109971e-02f, 7.17576919e-03f,
  -5.98854385e-02f, 2.55786665e-02f, 1.32602200e-01f, 3.58332023e-02f, 8.80073160e-02f, 2.27060402e-03f, -3.21927317e-03f, -1.16674677e-01f, 6.44486099e-02f, -2.04248562e-01f,
  2.73259636e-02f, -2.54029199e-03f, -1.84043366e-02f, -7.10172355e-02f, 2.79616509e-02f, -7.50021562e-02f, 9.79705807e-03f, 5.56984395e-02f, -4.69502583e-02f, 4.30295654e-02f,
  -2.33841818e-02f, -2.04095840e-02f, -2.06025876e-02f, 1.72352605e-02f, -9.31598246e-02f, -8.72256514e-03f, -3.65488455e-02f, 2.74883509e-02f, 2.47435719e-02f, -2.58334242e-02f,
  -3.02667301e-02f, 7.28937984e-02f, -4.21330035e-02f, 1.65543221e-02f, -6.56234771e-02f, -4.33953915e-04f, 3.65968756e-02f, -3.30687463e-02f, -1.83846410e-02f, -6.08928595e-03f,
  6.17781058e-02f, 2.21196026e-01f, -7.45916814e-02f, 7.61304349e-02f, 6.43046992e-03f, -5.55776432e-02f, -5.41594625e-02f, -5.83243556e-02f, -7.82332495e-02f, 7.11561814e-02f,
  8.51997826e-03f, 6.36367276e-02f, -1.33610272e-03f, 1.65946875e-02f, 9.46194865e-03f, 3.75695936e-02f, -1.66759565e-02f, 1.36953834e-02f, 5.27043752e-02f, -3.88451777e-02f,
  1.63169932e-02f, 1.84055626e-01f, 2.37550363e-01f, 1.40104517e-01f, 2.63837539e-02f, 2.04857677e-01f, 1.27053142e-01f, 3.27858329e-02f, 2.95901686e-01f, 9.95401666e-02f,
  5.04650474e-01f, 4.03046310e-01f, -4.10554297e-02f, 2.20580235e-01f, 8.92042741e-02f, 1.12270586e-01f, 1.16685264e-01f, -1.38098076e-01f, -5.74507825e-02f, 3.40911448e-01f,
  3.06600332e-01f, 9.48340818e-03f, 1.39419520e-02f, -1.61634207e-01f, -2.40266711e-01f, 4.94365729e-02f, -9.79378670e-02f, -2.85116106e-01f, -3.83375973e-01f, -1.55102000e-01f,
  -2.15234905e-02f, 9.76807103e-02f, 3.40394117e-02f, -1.19886190e-01f, 1.09983794e-01f, -1.07435621e-01f, 1.53519735e-01f, 1.19640075e-01f, -4.45601568e-02f, 5.00359759e-02f,
  1.96592003e-01f, 2.65619338e-01f, -1.69421121e-01f, 7.91263804e-02f, 4.44294401e-02f, -1.53003544e-01f, 1.17261916e-01f, -1.68564171e-02f, 6.37672516e-03f, 9.71871335e-03f,
  1.29044473e-01f, 1.05166947e-02f, 1.28146661e-02f, 3.14816693e-03f, 3.05169877e-02f, 3.39659490e-02f, -1.96093731e-02f, -2.54533645e-02f, -1.25154406e-02f, -2.09052619e-02f,
  1.24209031e-01f, 1.74848855e-01f, 1.96347252e-01f, -9.53381807e-02f, -9.59845707e-02f, -9.60518941e-02f, 1.00896381e-01f, -8.96678418e-02f, 1.71820149e-02f, 1.72472566e-01f,
  5.63734397e-02f, -9.69278160e-03f, -7.84420744e-02f, 1.02874056e-01f, -6.84321765e-03f, 4.43818513e-03f, -3.97138782e-02f, 7.14613795e-02f, -9.20194015e-02f, 4.51957248e-02f,
  -6.69876561e-02f, 5.06395847e-02f, 2.25862442e-03f, 6.59062937e-02f, -8.80535170e-02f, 6.61467388e-02f, -4.01558280e-02f, 1.29708229e-02f, 1.09395636e-02f, -1.88113954e-02f,
  -1.51730273e-02f, -1.39532173e-02f, 1.71483122e-02f, -8.35442320e-02f, -1.53475022e-02f, 5.47936149e-02f, -6.80503016e-03f, -2.24225949e-02f, 1.00496747e-01f, 9.96758640e-02f,
  1.59008384e-01f, -1.20457478e-01f, 1.07962191e-01f, -8.25079679e-02f, 7.01433122e-02f, -1.27577204e-02f, 3.29585150e-02f, -4.32536472e-03f, 2.26095561e-02f, -7.05158263e-02f,
  1.87269393e-02f, 2.56798360e-02f, 9.28987563e-02f, -6.40640259e-02f, -9.20983963e-03f, -1.00628799e-03f, 2.10786968e-01f, -2.89457329e-02f, -9.98519212e-02f, 7.66809434e-02f,
  9.16393474e-02f, 4.34751250e-02f, 1.30109102e-01f, -7.23711541e-03f, 4.46920395e-02f, 4.99372706e-02f, 1.33594379e-01f, 2.45749708e-02f, 1.12514924e-02f, 1.61690161e-01f,
  -2.67789006e-01f, 5.01163937e-02f, 2.46569097e-01f, 1.25053152e-01f, 3.68578345e-01f, 2.93322146e-01f, 3.28074872e-01f, 4.25470285e-02f, 1.34655356e-01f, 2.29701832e-01f,
  4.59013171e-02f, -2.27292418e-01f, -8.26088861e-02f, -3.13521206e-01f, -3.35458040e-01f, 3.05294544e-01f, 3.12424272e-01f, -1.94233596e-01f, -3.37367535e-01f, -2.22582251e-01f,
  -1.00421458e-01f, -1.63499296e-01f, -4.18547004e-01f, -7.50984699e-02f, 1.18669704e-01f, 1.13143951e-01f, 2.03716010e-01f, 4.93630692e-02f, -5.98527454e-02f, 9.13354382e-02f,
  1.23707339e-01f, -1.88455507e-02f, -7.95882121e-02f, -1.57055661e-01f, 1.90296900e-02f, -4.14832197e-02f, 1.47711441e-01f, -2.28218157e-02f, 1.10407956e-01f, 4.47046943e-02f,
  4.30897214e-02f, -7.34012499e-02f, -3.45382318e-02f, -5.12027405e-02f, 6.35199025e-02f, -6.06753211e-03f, -5.42915054e-02f, -2.22381741e-01f, -8.72604549e-02f, -5.55516183e-02f,
  2.48655323e-02f, 9.15456489e-02f, 5.96964583e-02f, 3.32318805e-02f, -1.31958768e-01f, -1.23225406e-01f, -2.39086617e-02f, -1.28551662e-01f, -3.61353979e-02f, -1.67931418e-03f,
  3.10354810e-02f, 3.10152881e-02f, 6.87019601e-02f, -5.73785827e-02f, 2.22624596e-02f, 2.43027285e-02f, 4.37870473e-02f, 7.97346458e-02f, -7.88924769e-02f, -1.51526807e-02f,
  -5.57005703e-02f, 3.57863046e-02f, -5.93528152e-02f, 3.73613983e-02f, 7.08472654e-02f, 6.95937779e-03f, 6.12578243e-02f, -1.55834593e-02f, 2.10747193e-03f, 1.56347472e-02f,
  -8.25215876e-02f, -2.61729173e-02f, 7.20159151e-03f, 1.19939651e-02f, -4.11327220e-02f, -2.50101811e-03f, 1.79029099e-04f, -5.09968847e-02f, -5.13120666e-02f, 4.59715836e-02f,
  1.26361966e-01f, -1.46292716e-01f, 1.28951877e-01f, -1.35437027e-01f, 1.39504671e-01f, -8.91449004e-02f, 2.96474546e-02f, -6.23785555e-02f, -2.52206419e-02f, -3.98053266e-02f,
  -6.01668730e-02f, -8.91995952e-02f, 6.27845898e-02f, -5.55113107e-02f, -6.24496862e-02f, 4.59379926e-02f, 9.65933315e-03f, 1.39986547e-02f, -1.23172589e-02f, 5.27729541e-02f,
  -1.10290824e-02f, 1.31715909e-01f, 5.62617444e-02f, 1.42379791e-01f, -5.48094586e-02f, 7.57779628e-02f, 1.16312534e-01f, 4.58440408e-02f, 7.48164654e-02f, 3.24982733e-01f,
  4.54320341e-01f, -5.18395245e-01f, -5.04494309e-01f, 5.73890448e-01f, 3.46969485e-01f, -2.35307086e-02f, -3.50882530e-01f, -1.20422192e-01f, 3.91076893e-01f, -8.21775869e-02f,
  -1.24112271e-01f, 2.51155645e-01f, 9.92894173e-02f, -2.66946610e-02f, -2.02849403e-01f, -3.95238370e-01f, -5.87943345e-02f, -5.50535358e-02f, 1.68306142e-01f, -2.02223416e-02f,
  1.56422287e-01f, 1.96008891e-01f, 1.49103403e-01f, 5.75281978e-02f, 1.34613574e-01f, 2.69995302e-01f, -1.31902874e-01f, -9.02795792e-02f, -2.66308218e-01f, -8.39637443e-02f,
  -4.47475255e-01f, -2.26674199e-01f, 1.16105713e-01f, 1.01049453e-01f, -5.46336770e-02f, -4.65731248e-02f, -5.22724539e-02f, -9.19518545e-02f, 4.02566157e-02f, -3.37410495e-02f,
  7.54346028e-02f, 1.41402027e-02f, 1.37988091e-01f, -3.25509012e-02f, 3.23875248e-02f, -1.32028088e-02f, -7.23303482e-02f, -1.58251584e-01f, -3.24755684e-02f, -1.70942575e-01f,
  1.99273340e-02f, 6.72959834e-02f, -6.57053813e-02f, -1.21167690e-01f, -1.05436035e-01f, 1.96192756e-01f, -9.10668671e-02f, -4.93239760e-02f, -7.49503523e-02f, -8.81531164e-02f,
  4.83880788e-02f, -8.74883123e-03f, -3.16962264e-02f, -1.41260985e-04f, 6.89433608e-03f, 2.67328750e-02f, -1.67203788e-02f, 3.06120068e-02f, 8.26092809e-03f, 2.09095119e-03f,
  5.44657139e-03f, 1.38822086e-02f, 3.00655197e-02f, 4.77178767e-03f, 1.98269617e-02f, 6.10715663e-03f, 1.04265707e-02f, -2.86149941e-02f, 1.29463738e-02f, -3.50618772e-02f,
  -2.23823264e-02f, -4.65038605e-02f, 7.17534274e-02f, -2.81279255e-02f, -5.62900230e-02f, 2.73735505e-02f, 1.52743859e-02f, -2.68027913e-02f, -1.30503522e-02f, 2.20156256e-02f,
  1.98973805e-01f, 5.87889459e-03f, 2.27656704e-03f, -1.68596581e-02f, 7.60519579e-02f, -5.43673523e-02f, 5.66349514e-02f, 1.72565505e-02f, 1.19487373e-02f, -1.08314408e-02f,
  -1.53110232e-02f, 7.58377246e-06f, -5.55833988e-02f, -9.55860782e-03f, 1.18635438e-01f, 2.62841545e-02f, 9.15449765e-03f, 1.14595339e-01f, -4.26272452e-02f, 4.17580013e-04f,
  -2.75550075e-02f, 6.40912652e-02f, 7.75873438e-02f, 3.06092445e-02f, 2.60649063e-02f, 1.91443458e-01f, -6.86354488e-02f, -3.72879393e-02f, 4.97896895e-02f, 8.68181288e-02f,
  -3.23016286e-01f, -5.03747106e-01f, 9.60116461e-02f, -6.39686063e-02f, -1.33712605e-01f, -2.66237438e-01f, -6.41819477e-01f, -3.34380537e-01f, -6.84544966e-02f, -1.64320037e-01f,
  4.20221202e-02f, 1.48666337e-01f, 3.00841749e-01f, 2.29518041e-01f, -1.14935234e-01f, -3.61283451e-01f, -2.66773611e-01f, 1.85098782e-01f, 2.34639227e-01f, -8.62114578e-02f,
  -4.48867492e-02f, -8.21330845e-02f, 9.18728707e-04f, 4.12856340e-02f, -7.23204669e-03f, 2.27059796e-01f, 1.91928908e-01f, 3.84048629e-03f, 4.79655005e-02f, 2.06879117e-02f,
  3.19284827e-01f, -2.94984579e-01f, 1.86784580e-01f, 4.30083238e-02f, 1.87754005e-01f, 2.83964891e-02f, 4.18136083e-02f, 3.36373784e-02f, 2.76047792e-02f, -5.20761274e-02f,
  9.97696817e-02f, 5.81292175e-02f, 8.68375879e-03f, 3.50994170e-02f, -7.80210719e-02f, -3.59924622e-02f, -2.79989224e-02f, 2.21645720e-02f, 6.93941116e-02f, 1.89471245e-02f,
  -3.35620381e-02f, -9.79523957e-02f, 4.40987293e-04f, 5.10157086e-03f, -9.20090303e-02f, 8.72541368e-02f, 4.24287282e-02f, -1.10201798e-02f, 1.39686093e-01f, 2.44451389e-02f,
  6.96476027e-02f, 1.49936164e-02f, 3.45083587e-02f, -4.13447060e-02f, 1.21475430e-02f, -3.14110965e-02f, 1.68596432e-02f, -8.31003860e-02f, 4.83645052e-02f, -5.89230023e-02f,
  5.12120947e-02f, -8.68736953e-03f, 3.10080238e-02f, -7.15611922e-03f, 6.93813488e-02f, -1.35268858e-02f, 1.06501514e-02f, -6.37039989e-02f, 3.31819691e-02f, -4.27201539e-02f,
  -3.74076180e-02f, 6.63937628e-02f, -1.82703864e-02f, 8.88596922e-02f, -7.41687417e-02f, 4.86043058e-02f, -5.44447973e-02f, -1.42739965e-02f, 4.35623713e-02f, -9.00753662e-02f,
  1.51489437e-01f, 1.29603505e-01f, -4.97684702e-02f, -4.87982705e-02f, -7.14478688e-03f, -1.28532005e-02f, -2.98863631e-02f, 1.53939649e-02f, 2.22666804e-02f, -8.90706703e-02f,
  -8.06363150e-02f, -6.74977303e-02f, -2.41420586e-02f, 1.77320335e-02f, 6.80569152e-04f, -7.38019794e-02f, -9.42844003e-02f, 6.81954622e-02f, -7.37533718e-02f, -5.68667985e-02f,
  -1.29708247e-02f, -1.00975223e-01f, -9.81921256e-02f, -4.53109853e-02f, -2.19992548e-02f, -7.38387331e-02f, 4.98884581e-02f, 2.39406209e-02f, -1.33216074e-02f, -2.19299689e-01f,
  2.67087817e-01f, 4.76519205e-02f, 2.62623340e-01f, 1.94870085e-02f, -8.43736008e-02f, 5.17388918e-02f, 2.48237133e-01f, -5.31604290e-02f, -6.63600266e-02f, 1.25444336e-02f,
  -2.80894041e-01f, -3.33284885e-01f, -1.02246396e-01f, -1.19665690e-01f, 7.84180611e-02f, 3.70918453e-01f, 2.89428979e-01f, 2.55263597e-01f, 4.13281135e-02f, -1.20139115e-01f,
  -1.66811407e-01f, -2.69020768e-03f, -8.27726815e-03f, 7.09606186e-02f, 5.60721494e-02f, -1.13833202e-02f, 2.95912866e-02f, 2.34813467e-01f, 1.93979248e-01f, 2.83583552e-01f,
  2.17941284e-01f, 1.01740398e-01f, -1.16054647e-01f, -8.64213780e-02f, -5.87925538e-02f, 1.21188208e-01f, 1.17955215e-01f, 3.28399017e-02f, -4.52872775e-02f, 5.04258983e-02f,
  -7.23471045e-02f, -3.08160111e-02f, -6.11254610e-02f, -6.34277835e-02f, 5.65258376e-02f, 2.71892436e-02f, -3.57465399e-03f, 6.23288341e-02f, 6.56209439e-02f, -1.42889600e-02f,
  -1.61681324e-01f, -1.08505964e-01f, 1.24352738e-01f, 2.32244898e-02f, 9.16314870e-02f, -5.07600456e-02f, 5.35175651e-02f, 1.86323076e-01f, 1.09937072e-01f, 3.62964183e-01f,
  -2.45354068e-03f, 3.05799209e-03f, -3.37630771e-02f, -1.11468853e-02f, 1.25323860e-02f, -2.25126632e-02f, 2.59369425e-02f, -6.20629452e-02f, 3.95646729e-02f, 3.22539173e-02f,
  -8.49318597e-03f, -3.35783064e-02f, 5.58185484e-03f, 5.10221645e-02f, 8.46239086e-03f, -2.62869671e-02f, 2.25254465e-02f, -9.31125693e-03f, 1.69145572e-03f, -5.34662157e-02f,
  1.68453231e-02f, 2.96565853e-02f, -1.21340938e-02f, -7.32775405e-02f, 1.64244566e-02f, 2.04062741e-02f, 9.36398655e-03f, -6.94592819e-02f, -6.50173873e-02f, -3.21811251e-02f,
  -7.29670599e-02f, -1.41503021e-01f, 1.31089672e-01f, 9.06098410e-02f, -1.64409392e-02f, 1.22174975e-02f, -2.71108784e-02f, 7.85644539e-03f, -8.65020379e-02f, 2.92978827e-02f,
  -4.90850396e-02f, 8.83462429e-02f, -4.42824587e-02f, -2.93555222e-02f, -5.88187668e-03f, -6.71439692e-02f, -3.58585045e-02f, -5.80905080e-02f, 1.64101627e-02f, 3.79028805e-02f,
  -2.52157990e-02f, 9.98364016e-02f, -1.26011856e-02f, 1.95314419e-02f, 7.79746007e-03f, 6.96044043e-02f, 1.15884036e-01f, 1.72766119e-01f, 2.05376446e-01f, 2.32788175e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.30913746e-01f, 7.47145116e-02f, -1.45236552e-01f, 1.30234271e-01f, -1.67660654e-01f, -2.10108742e-01f, -2.06141487e-01f, 4.35205176e-02f, 1.63226083e-01f, -3.86095420e-02f,
  -5.44778630e-02f, 2.29313642e-01f, 2.18488097e-01f, 6.87867552e-02f, 8.62483531e-02f, -2.51437332e-02f, -1.26671478e-01f, -9.67331454e-02f, -3.44005525e-02f, -1.37135908e-01f,
  -8.22305530e-02f, -1.35040749e-03f, -1.85834207e-02f, 4.02385443e-02f, -1.43873587e-01f, 5.09056747e-02f, -1.03646427e-01f, -8.32554772e-02f, -1.12373695e-01f, -1.21099971e-01f,
  -1.88161686e-01f, -7.47229457e-02f, 4.56133261e-02f, 5.55541134e-03f, -9.10421535e-02f, -1.46677652e-02f, -5.73803633e-02f, 9.03252661e-02f, 5.05418703e-02f, -3.66507582e-02f,
  -3.68246413e-03f, 1.01103121e-02f, -3.27364132e-02f, -1.27407955e-02f, -5.11859134e-02f, 1.33949462e-02f, 2.18889229e-02f, 9.85929072e-02f, 9.17719626e-06f, -3.53193544e-02f,
  -1.66793749e-01f, -1.25680953e-01f, 3.43477614e-02f, 1.00991771e-01f, -2.83272881e-02f, 2.08811350e-02f, 2.54975036e-02f, -2.67263558e-02f, 1.02418065e-01f, 1.70519575e-01f,
  -7.82239661e-02f, 1.26075484e-02f, -5.52747063e-02f, 6.87555522e-02f, 5.69743030e-02f, 6.38038218e-02f, 2.83850897e-02f, 4.05039825e-02f, 8.09921622e-02f, 5.70986308e-02f,
  3.53338942e-02f, -4.62688804e-02f, -2.81022564e-02f, 1.11327663e-01f, -6.79963157e-02f, -1.63621467e-03f, 1.53061897e-02f, 2.53067557e-02f, -5.90360388e-02f, -1.96380615e-02f,
  -4.34868038e-02f, 3.67233087e-03f, -9.04305205e-02f, -1.41158700e-01f, -7.88349509e-02f, -4.79771793e-02f, 2.54370105e-02f, -5.86149916e-02f, 3.65569964e-02f, -6.49965480e-02f,
  1.83178991e-01f, -5.93093745e-02f, 6.74082115e-02f, 6.03116117e-02f, -4.75239642e-02f, -1.26042262e-01f, 8.73546954e-03f, -2.51224544e-02f, -1.38234764e-01f, -4.52692546e-02f,
  -2.00790226e-01f, 2.53237076e-02f, -4.18689996e-02f, -7.99648091e-02f, -6.14804812e-02f, 7.00286105e-02f, 7.32039660e-02f, 1.53389961e-01f, 5.76300696e-02f, -7.04436526e-02f,
  -8.07464123e-02f, 1.57901123e-01f, 9.53040943e-02f, 1.29059196e-01f, 1.23007067e-01f, 1.01155927e-02f, 6.43358678e-02f, -1.14210313e-02f, 1.08476512e-01f, 2.45407239e-01f,
  3.99894379e-02f, -5.60347497e-01f, 5.40194660e-03f, -2.60801911e-01f, -5.08218724e-03f, 2.88299531e-01f, 1.22679584e-01f, -1.45925907e-02f, -1.87078323e-02f, -7.96422735e-02f,
  -1.58231303e-01f, 6.17260858e-02f, 7.29705719e-03f, 8.25085342e-02f, 8.39296132e-02f, 3.50329140e-03f, -7.86177069e-02f, 2.05749661e-01f, 3.89875352e-01f, 1.96421206e-01f,
  2.69818585e-02f, -1.21276192e-01f, -1.01969719e-01f, -9.93037000e-02f, -3.43232781e-01f, -1.90810964e-01f, -2.33735010e-01f, -2.09944591e-01f, -4.59153429e-02f, -3.91669154e-01f,
  -3.30756783e-01f, -9.80019942e-02f, 1.51140988e-01f, 8.19627345e-02f, -8.30947161e-02f, -1.34508368e-02f, 6.02569841e-02f, -9.05572847e-02f, 8.24009255e-03f, -1.04052141e-01f,
  -8.11514407e-02f, 1.70682035e-02f, -1.47326633e-01f, -1.67198312e-02f, -1.37623191e-01f, -5.12558259e-02f, 1.52995288e-02f, -6.58592768e-03f, 3.24791856e-02f, -5.13700210e-02f,
  -8.60336721e-02f, -5.26968623e-03f, 8.15607011e-02f, 8.63890648e-02f, 2.15169281e-01f, 2.60567546e-01f, -1.86379291e-02f, -6.91315020e-03f, 1.17481880e-01f, -1.44698009e-01f,
  2.79867370e-02f, 7.64895976e-02f, 8.80667120e-02f, 7.05273869e-03f, 1.86236680e-03f, -5.28871687e-03f, -5.03687859e-02f, -4.37014922e-02f, 1.60030276e-02f, -1.02407850e-01f,
  -1.42723843e-02f, -3.86840664e-02f, 4.42480482e-03f, -1.02600768e-01f, -6.22529276e-02f, 3.01953685e-02f, 7.15940520e-02f, -7.06605017e-02f, 5.43427793e-03f, 9.22904257e-03f,
  1.40367419e-01f, 1.29788658e-02f, -9.16829929e-02f, 2.49312678e-03f, 8.18221197e-02f, 6.61720634e-02f, -3.92807424e-02f, 3.13710421e-02f, -4.79745260e-03f, 1.18036140e-02f,
  -3.35167527e-01f, 5.13762832e-01f, -7.64436722e-02f, -4.66168448e-02f, -1.83917787e-02f, 2.20696516e-02f, -5.70460260e-02f, 2.14932039e-02f, -1.20647617e-01f, -6.85013756e-02f,
  8.81142467e-02f, -3.57662560e-03f, -6.95518702e-02f, -5.22581786e-02f, 7.06902742e-02f, 5.89839444e-02f, -9.65404138e-03f, 4.01467122e-02f, 1.18495420e-01f, -5.99014387e-02f,
  -5.61144724e-02f, 2.29199767e-01f, 7.30904713e-02f, 1.12237848e-01f, 7.31680691e-02f, 1.72450870e-01f, 5.53152375e-02f, -3.35362181e-02f, 2.12111384e-01f, -1.09538317e-01f,
  -4.35602367e-01f, -2.13553235e-01f, -3.32069159e-01f, -1.74137414e-01f, -1.25652272e-02f, 1.40063807e-01f, 1.33521900e-01f, 1.37837470e-01f, 8.08966234e-02f, 2.28507407e-02f,
  -9.78952944e-02f, -1.27640858e-01f, -3.28243673e-01f, -2.24184871e-01f, -2.87426800e-01f, -8.33718106e-02f, -2.99249768e-01f, -4.19139415e-01f, -2.61088103e-01f, -7.00674579e-02f,
  5.07743191e-03f, -2.94854164e-01f, -3.24615419e-01f, -2.40433395e-01f, 4.04411629e-02f, -2.05319718e-01f, -1.75559387e-01f, -1.59173682e-01f, -4.03658785e-02f, -2.18841866e-01f,
  -1.41211763e-01f, 1.07786223e-01f, -9.84872729e-02f, -1.89232066e-01f, 5.29814921e-02f, 7.51272589e-02f, 6.65116534e-02f, -1.18505888e-01f, 4.70423959e-02f, -7.14191794e-02f,
  -1.51311653e-02f, 4.68032667e-03f, -1.08739696e-01f, 6.84990287e-02f, -6.38928488e-02f, -8.79467428e-02f, -2.43460257e-02f, -2.10391015e-01f, -1.00567080e-01f, 1.14582933e-01f,
  7.93328285e-02f, -8.87236223e-02f, -2.39272758e-01f, -3.78267802e-02f, 1.19756825e-01f, -1.86148733e-01f, -9.67862010e-02f, -1.99759547e-02f, -9.67201442e-02f, -8.89474452e-02f,
  -1.28226010e-02f, -1.34670874e-02f, 6.85900524e-02f, 6.67527243e-02f, -6.26747161e-02f, 4.38860208e-02f, -1.03231110e-01f, -5.07646473e-03f, 3.94690670e-02f, -8.70640427e-02f,
  -1.70769393e-02f, 2.04120073e-02f, 6.31084153e-03f, -8.69377628e-02f, -5.98566458e-02f, -3.30758169e-02f, -3.78302261e-02f, -3.51848267e-02f, -2.00249515e-02f, -8.82847384e-02f,
  -9.81845856e-02f, 2.56097410e-02f, -3.09029315e-02f, -1.11784875e-01f, -3.30110788e-02f, -2.54487973e-02f, 8.91998336e-02f, -1.07229808e-02f, -4.44989242e-02f, 5.13220206e-02f,
  -2.55562961e-01f, -1.12826571e-01f, -6.11386076e-02f, -3.53552066e-02f, -3.88036743e-02f, -3.57000008e-02f, 4.81627695e-02f, -5.57955876e-02f, -1.08575383e-02f, -5.14708981e-02f,
  6.12361282e-02f, -4.88757482e-03f, -5.65381832e-02f, -1.69849601e-02f, -1.06594972e-01f, 6.62961230e-02f, -9.09902006e-02f, -2.74491996e-01f, -6.11012653e-02f, 1.84358895e-01f,
  -3.63517366e-02f, -2.97899336e-01f, -3.88867766e-01f, -1.38890132e-01f, -2.79925950e-02f, -2.70427883e-01f, -1.49413839e-01f, -1.37152746e-01f, -3.16692710e-01f, -3.21101099e-01f,
  5.85373521e-01f, -2.21423715e-01f, -6.97114766e-02f, 1.12161130e-01f, -3.16727050e-02f, 6.75456971e-02f, 3.71070877e-02f, 9.02987719e-02f, 1.16093107e-01f, 9.78997792e-04f,
  9.83442143e-02f, 2.43666872e-01f, 1.21052444e-01f, 1.55414909e-01f, 1.55773893e-01f, -2.01600954e-01f, -1.90313354e-01f, 9.18661878e-02f, 2.10759863e-01f, 1.19305074e-01f,
  -1.95242435e-01f, -2.43279804e-02f, 6.25873804e-02f, 4.33710143e-02f, -1.67080581e-01f, -9.21230614e-02f, -1.14216171e-01f, -1.23399943e-01f, -7.18874857e-02f, -2.82924533e-01f,
  -1.41289979e-01f, 8.80598202e-02f, 1.59196347e-01f, -4.13059033e-02f, -6.02979474e-02f, 6.34501502e-02f, 7.95031860e-02f, -9.20389444e-02f, -5.94774187e-02f, -8.86910111e-02f,
  -5.82097955e-02f, 7.76452664e-03f, 4.38964441e-02f, -5.72964028e-02f, -4.31826673e-02f, -3.64380516e-02f, 2.31152214e-02f, 3.16459462e-02f, 1.21732697e-01f, -4.68000118e-03f,
  -1.56874418e-01f, -2.50566062e-02f, 1.14102982e-01f, -3.61663587e-02f, 1.08543381e-01f, 1.88611224e-01f, -7.08712935e-02f, -8.10465813e-02f, 2.75759343e-02f, -3.58315259e-02f,
  -8.78375940e-05f, 1.26520749e-02f, 1.02844357e-01f, -3.11972369e-02f, 9.44929272e-02f, -4.84213885e-03f, -2.95849983e-02f, 7.50574619e-02f, 1.31738871e-01f, -1.33768041e-02f,
  4.70213406e-02f, 8.19166377e-02f, 5.75930662e-02f, 8.07348788e-02f, -6.01674169e-02f, 5.94688393e-02f, -3.90929170e-02f, -7.09335655e-02f, -3.11289579e-02f, -4.51180935e-02f,
  3.01603861e-02f, 8.13415870e-02f, -2.93386285e-03f, -5.99052049e-02f, -4.10745330e-02f, -5.31804003e-03f, -4.10740227e-02f, 8.28536972e-03f, -3.73637043e-02f, 8.87701660e-03f,
  -2.15691820e-01f, 2.62145847e-01f, -5.06930612e-02f, 1.20812714e-01f, -5.90912811e-02f, 2.31374968e-02f, -8.08774456e-02f, -1.07082173e-01f, -9.18465704e-02f, -8.43475759e-02f,
  -7.78484792e-02f, 6.81891218e-02f, -1.25414180e-02f, -4.44974974e-02f, -2.05863547e-02f, 6.62754774e-02f, -7.90825337e-02f, 5.03052212e-02f, -9.37430635e-02f, -8.30962881e-02f,
  -6.81758001e-02f, 1.94264762e-02f, 7.87669346e-02f, 1.14733577e-01f, -1.45908585e-02f, 1.87819377e-01f, -1.40701532e-02f, 4.80744652e-02f, 1.00046620e-01f, 1.29330615e-02f,
  2.32463591e-02f, 9.85011235e-02f, 7.48744681e-02f, 3.32565218e-01f, 8.85230824e-02f, 8.79500285e-02f, 5.05081601e-02f, 6.08141907e-02f, 8.94396156e-02f, 1.78387180e-01f,
  1.19029924e-01f, 3.08687091e-01f, 3.00538212e-01f, 2.79662609e-01f, 1.86939925e-01f, 1.53084382e-01f, 1.61629617e-01f, 2.13425830e-01f, 1.64109066e-01f, 1.78236008e-01f,
  2.03735009e-01f, 7.51902089e-02f, 1.21494338e-01f, 1.78265169e-01f, 1.71528310e-01f, 2.49310344e-01f, 1.83958456e-01f, 7.61049911e-02f, 1.17434949e-01f, 3.26946855e-01f,
  2.83028223e-02f, -5.79588190e-02f, 7.05689471e-03f, 1.33220538e-01f, -5.93456775e-02f, -1.15574837e-01f, -1.12281941e-01f, -1.07758746e-01f, -6.45379499e-02f, -4.16815914e-02f,
  -2.93515828e-02f, -9.46831610e-03f, 6.94892704e-02f, -6.89142868e-02f, -4.08534147e-02f, -5.78471906e-02f, -1.82457328e-01f, 3.36023644e-02f, 3.22193019e-02f, -9.48547572e-02f,
  8.31626952e-02f, 2.23852936e-02f, -1.14240602e-01f, -5.54667115e-02f, 1.95296016e-02f, 3.95537317e-02f, -1.17019899e-01f, 2.91264076e-02f, -1.04031011e-01f, 6.85458072e-03f,
  1.10701069e-01f, -4.28593196e-02f, 7.79536739e-02f, -2.67619193e-02f, 2.04241220e-02f, 8.48236382e-02f, 1.68422479e-02f, 1.18670247e-01f, 1.13304570e-01f, -2.40217969e-02f,
  3.70311141e-02f, -3.25124040e-02f, 2.53381282e-02f, -2.35163905e-02f, 9.58727002e-02f, 1.86973531e-02f, -9.01762024e-02f, 6.25719950e-02f, -2.62387097e-02f, -9.44497511e-02f,
  -1.31202899e-02f, -6.01017959e-02f, -3.55811305e-02f, -6.19047321e-02f, 8.96385610e-02f, -3.08093596e-02f, 4.40702662e-02f, -3.85577455e-02f, -1.94842555e-02f, -3.54811847e-02f,
  -4.52278256e-02f, -1.74173564e-01f, 1.11278839e-01f, -5.30413799e-02f, 6.98379502e-02f, -8.29415694e-02f, 1.15789622e-01f, -6.97117820e-02f, 5.52217960e-02f, -4.64432202e-02f,
  -5.17971776e-02f, -6.49668723e-02f, -4.02694605e-02f, -1.10727824e-01f, -1.25187337e-01f, -5.61737902e-02f, -1.31782413e-01f, -6.10194169e-02f, 1.42057277e-02f, -1.02023445e-01f,
  2.76709162e-02f, -1.35169223e-01f, -1.04391634e-01f, -1.81558609e-01f, -9.93834659e-02f, -1.19784763e-02f, -2.11098120e-01f, -1.46268532e-01f, -1.66520089e-01f, -1.31648853e-01f,
  7.62386739e-01f, 1.28972590e-01f, 3.34818274e-01f, 1.40495077e-01f, 1.71263039e-01f, 3.94060493e-01f, 3.70238960e-01f, 2.18608364e-01f, -5.45402169e-02f, 2.48399861e-02f,
  2.01897785e-01f, -9.54048056e-03f, 5.46866469e-02f, -6.03241362e-02f, 1.43983737e-01f, -1.27467915e-01f, -1.64684266e-01f, 1.96974836e-02f, 7.15730563e-02f, 4.45113704e-02f,
  -2.39658475e-01f, -4.57657278e-02f, 1.85190558e-01f, -3.62765752e-02f, -1.72445387e-01f, -1.18200503e-01f, 7.87468180e-02f, 8.41344765e-04f, -4.06213105e-02f, -3.45426857e-01f,
  8.53725746e-02f, 5.18437445e-01f, -2.08129674e-01f, -2.42109254e-01f, 3.99512649e-02f, -1.49926186e-01f, 6.98385909e-02f, -7.20190182e-02f, -8.37894715e-03f, -1.62705153e-01f,
  -2.10895501e-02f, -8.79182965e-02f, 8.79950523e-02f, -5.47585674e-02f, 1.38436779e-01f, -2.93376427e-02f, -1.47292931e-02f, -5.03926761e-02f, -6.48129508e-02f, 7.54389018e-02f,
  -1.64876014e-01f, 9.14522707e-02f, 1.68663219e-01f, 6.32484332e-02f, -3.16724530e-03f, -2.71303002e-02f, 1.22866012e-01f, 6.62363172e-02f, 2.75308527e-02f, -1.50394231e-01f,
  -1.01639219e-01f, 1.42726190e-02f, 8.02964792e-02f, -1.89161990e-02f, -2.75269542e-02f, -3.81128788e-02f, 2.15071365e-02f, -7.43733346e-02f, 6.26599342e-02f, 2.40982026e-02f,
  1.41377952e-02f, 8.68828893e-02f, -7.96599034e-03f, 3.03128809e-02f, -1.06010929e-01f, 1.05930734e-02f, -2.48497091e-02f, 3.00235357e-02f, 3.63202915e-02f, 1.17888795e-02f,
  7.33157098e-02f, -6.79015070e-02f, 8.91518667e-02f, -3.48028913e-02f, -6.30489886e-02f, -4.68060449e-02f, -6.00687377e-02f, 1.83135772e-03f, -2.45899218e-03f, -9.94291008e-02f,
  -2.10743457e-01f, 2.58668721e-01f, -1.23766549e-01f, -1.77576065e-01f, 3.56181823e-02f, 1.58535838e-02f, -6.21537194e-02f, 2.35872939e-02f, 6.26014099e-02f, -8.39733705e-02f,
  1.00878976e-01f, -7.07441643e-02f, 8.88824910e-02f, -1.22236349e-01f, 3.29985619e-02f, -2.76875738e-02f, -8.79601240e-02f, -1.74563713e-02f, -9.98156071e-02f, -3.42265740e-02f,
  -2.17920557e-01f, -7.31858015e-02f, 1.33521229e-01f, 6.48477525e-02f, -4.54495996e-02f, -1.23861916e-01f, 1.61994696e-02f, -1.37806702e-02f, 4.44944575e-02f, -2.32434019e-01f,
  -7.94005170e-02f, -2.14048222e-01f, 4.14310582e-02f, -2.99221247e-01f, 3.40692699e-02f, 2.00626493e-01f, 1.73535705e-01f, 6.26004934e-02f, -3.71242985e-02f, -1.13630347e-01f,
  -9.35174674e-02f, -2.06214383e-01f, -2.23098934e-01f, -3.60803269e-02f, 4.96664979e-02f, 9.10160020e-02f, -6.98515326e-02f, 5.63173853e-02f, 2.26806179e-01f, 2.34893873e-01f,
  2.19729003e-02f, 6.06377004e-03f, -7.52441362e-02f, -8.37480277e-02f, -1.30494505e-01f, -1.63029619e-02f, -1.12504646e-01f, -7.23912194e-02f, -2.60171480e-02f, -2.29630172e-01f,
  4.02400732e-01f, -1.02153629e-01f, -3.79066765e-02f, -1.64114505e-01f, -1.30352870e-01f, -1.31758049e-01f, -6.86983168e-02f, -7.38096684e-02f, -8.23554918e-02f, -4.05039005e-02f,
  -6.41097501e-02f, -9.67609137e-02f, -1.24807946e-01f, 9.79999825e-02f, 1.54065728e-01f, 5.96323870e-02f, -1.31378144e-01f, 2.56808326e-02f, -1.59644142e-01f, -4.58711535e-02f,
  -1.43525451e-01f, -8.18039291e-03f, 7.97200873e-02f, -7.78762251e-02f, -1.05601154e-01f, -1.13398597e-01f, 5.80868870e-02f, -9.72510800e-02f, -2.52259318e-02f, 5.06619401e-02f,
  -2.03768369e-02f, 4.82630245e-02f, 6.43513575e-02f, -4.57414240e-03f, 1.09964453e-01f, 1.21885864e-02f, 1.17771506e-01f, 1.16534166e-01f, 1.28508061e-01f, 8.75997990e-02f,
  7.39574358e-02f, 6.13882169e-02f, 2.54275817e-02f, 8.26776698e-02f, -8.25774223e-02f, -4.82795127e-02f, -3.82850133e-02f, 3.09176985e-02f, -2.41558403e-02f, -1.42034739e-01f,
  -4.00654189e-02f, -2.82219425e-03f, -3.23439986e-02f, 7.22977370e-02f, -1.20020799e-01f, -8.18603337e-02f, 9.64350849e-02f, -5.85535355e-02f, -1.03504948e-01f, -3.18641365e-02f,
  1.99918106e-01f, -2.86911130e-01f, 1.51281981e-02f, -9.56148002e-03f, -6.36750832e-02f, -6.29056990e-02f, 3.04092909e-03f, -5.50121367e-02f, -8.58724043e-02f, 1.22845650e-01f,
  3.70889083e-02f, 2.88904738e-02f, 5.48140183e-02f, 1.01119578e-01f, 2.33674362e-01f, 6.61865100e-02f, -1.28127232e-01f, 1.19294561e-02f, -7.64065832e-02f, -2.94789579e-02f,
  2.94269659e-02f, 1.64461732e-01f, 2.45753676e-01f, 5.48959523e-02f, 6.75610155e-02f, 1.00131527e-01f, 2.54313111e-01f, 1.29187748e-01f, 1.29191205e-01f, 2.69027174e-01f,
  2.01988757e-01f, 2.26903960e-01f, 1.21424235e-01f, 2.27275819e-01f, 3.47225666e-02f, -1.55327827e-01f, -1.89966351e-01f, -2.46082842e-02f, 6.57219663e-02f, 1.38447499e-02f,
  -2.57109944e-02f, -1.20518781e-01f, -4.02196273e-02f, -2.02189162e-01f, -3.13257307e-01f, -7.94496164e-02f, -9.14122239e-02f, -1.39631689e-01f, -3.02831382e-01f, -1.76369056e-01f,
  -2.25551471e-01f, -1.47913352e-01f, -5.15939370e-02f, -1.20641664e-01f, 1.18495785e-01f, -7.17007220e-02f, 7.41740614e-02f, 6.52279099e-03f, 6.03471138e-02f, 1.08282626e-01f,
  1.08618610e-01f, 1.72703087e-01f, -1.14151046e-01f, 1.08099300e-02f, 4.12972420e-02f, 1.00428402e-01f, -7.52625763e-02f, 8.41662586e-02f, -3.11782514e-03f, 8.92852098e-02f,
  1.00533009e-01f, 3.05631030e-02f, 1.24360726e-03f, 4.19419631e-02f, 6.43789861e-03f, -6.47930354e-02f, 8.46397951e-02f, 1.73321366e-02f, -5.14964275e-02f, 8.41567591e-02f,
  -2.70599667e-02f, -2.88484041e-02f, 7.72667974e-02f, -1.09661967e-01f, 2.40117554e-02f, -8.65418613e-02f, 5.51009290e-02f, 9.70184803e-02f, -2.61211228e-02f, 1.74517393e-01f,
  -1.01560570e-01f, 6.68048486e-02f, 2.15525702e-02f, 1.53789464e-02f, 2.49893218e-02f, 1.53566049e-02f, 9.81387049e-02f, -4.24153283e-02f, 6.30591288e-02f, -1.88458692e-02f,
  6.69456050e-02f, 6.87252060e-02f, 5.65386452e-02f, 3.11681628e-02f, -3.05343270e-02f, 2.79175509e-02f, -5.33315279e-02f, -6.60174433e-03f, 6.14666529e-02f, -5.90307545e-03f,
  1.94677021e-02f, 2.06584241e-02f, 1.21168084e-01f, 1.59911159e-02f, 1.46965319e-02f, -4.06835824e-02f, -6.01011962e-02f, -9.41134840e-02f, 2.80912090e-02f, 2.98522003e-02f,
  6.26533255e-02f, -3.05084795e-01f, 6.20799586e-02f, 3.61162301e-06f, 7.29617551e-02f, 9.63386446e-02f, 1.46029249e-01f, -6.17100820e-02f, 6.90374151e-02f, -5.49473166e-02f,
  9.09409579e-03f, 3.16507765e-03f, 1.00564048e-01f, 6.68280795e-02f, -8.40327442e-02f, -1.03822134e-01f, -3.41588911e-03f, -6.53701052e-02f, -3.41644627e-03f, 9.91195217e-02f,
  1.22487638e-02f, -1.50799379e-02f, -1.14595354e-01f, -4.40059304e-02f, 7.34664574e-02f, -1.61736473e-01f, -7.84540921e-02f, -3.76162492e-02f, -1.57690629e-01f, 1.03077568e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  3.53236586e-01f, 5.64630389e-01f, 2.40123779e-01f, 2.06891745e-01f, 2.59425998e-01f, 2.43839025e-01f, 3.41684401e-01f, 2.84378380e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -7.14465082e-01f, -1.02340998e-02f, -6.09958433e-02f, -9.10578892e-02f, -5.33424556e-01f, -1.24081112e-01f, 1.32522937e-02f, -6.68965638e-01f, -4.61061597e-01f, -2.18669698e-01f,
  -2.66554207e-01f, -7.42929280e-01f, 1.76838383e-01f, -1.94296956e-01f, 3.71731400e-01f, -3.05858761e-01f, -3.17894965e-02f, -1.28395995e-02f, -1.23524711e-01f, -3.48532230e-01f,
  -7.97113121e-01f, 6.41121328e-01f, 5.44154048e-02f, 1.89780831e-01f, 1.97577178e-01f, 4.22726512e-01f, 7.51394451e-01f, 1.90997377e-01f, -2.78401732e-01f, -1.06080815e-01f,
  2.28991687e-01f, -2.01298043e-01f, -4.51019973e-01f, -2.86337107e-01f, 9.59297568e-02f, -2.84306556e-01f, -3.56311381e-01f, -3.27603340e-01f, 1.02393731e-01f, 2.07294151e-01f,
  5.06340973e-02f, -1.66743845e-02f, 2.47966617e-01f, 2.61198699e-01f, 1.20831519e-01f, -6.36686265e-01f, 3.56891155e-01f, -5.75655520e-01f, -6.32797480e-01f, 4.73863423e-01f,
  4.43994790e-01f, -9.63674784e-02f, -4.70698118e-01f, 6.47492170e-01f, 2.82310128e-01f, -3.26175660e-01f, 5.35302222e-01f, 6.11789405e-01f, -5.03533602e-01f, 7.75201976e-01f,
  4.55376446e-01f, 4.43391442e-01f, -1.79619610e-01f, -3.13282162e-01f, 4.32202727e-01f, 4.10218835e-01f, 1.70827061e-02f, 2.16270447e-01f, 5.42276084e-01f, 1.62093177e-01f,
  5.29823601e-01f, -5.20076275e-01f, -4.29786146e-01f, 1.60259783e-01f, -3.90610337e-01f, 3.43067467e-01f, -2.81058788e-01f, 4.88800824e-01f, -7.13678122e-01f, -2.67493725e-01f,
  2.52932459e-01f, 5.88015437e-01f, -1.26351062e-02f, -8.17306578e-01f, -7.25120962e-01f, 1.95852995e-01f, 7.58105397e-01f, -4.94942039e-01f, -1.26621515e-01f, 3.89233768e-01f,
  -4.08893436e-01f, 3.96970995e-02f, -5.55959828e-02f, -1.75972119e-01f, -2.31211409e-01f, -3.66174757e-01f, 4.69158471e-01f, -4.30796482e-02f, 1.13367016e-04f, -8.38171914e-02f,
  3.78899068e-01f, 8.84707365e-03f, 2.05872491e-01f, -2.14342862e-01f, 9.03415754e-02f, -7.10601568e-01f, 3.53456527e-01f, -4.39783633e-01f, -2.59207878e-02f, 1.07231927e+00f,
  4.30438310e-01f, 4.95098084e-02f, -1.87200867e-02f, 1.85767710e-01f, 8.94362107e-02f, -4.22584385e-01f, 2.55440772e-01f, -1.01099920e+00f, -8.63905698e-02f, -2.44230852e-01f,
  -4.58297074e-01f, 5.69703579e-01f, 6.92346454e-01f, -2.24017024e-01f, -4.33486015e-01f, -2.70509422e-01f, 1.06338330e-01f, -1.95059627e-01f, -2.26191521e-01f, 1.70182101e-02f,
  2.34216988e-01f, 1.10013716e-01f, 5.03536016e-02f, -8.33203644e-02f, -7.87857115e-01f, 8.05976987e-02f, 3.12953413e-01f, 3.71213555e-01f, -5.82551420e-01f, -6.04203284e-01f,
  6.70741737e-01f, -3.18193227e-01f, -1.30490452e-01f, 8.80862623e-02f, -5.39115429e-01f, -3.56949657e-01f, -3.47780496e-01f, 4.92314585e-02f, 5.50198138e-01f, -4.49650884e-01f,
  5.70794977e-02f, -4.43422884e-01f, 1.76575512e-01f, -6.25130296e-01f, 6.59068346e-01f, -2.80601799e-01f, -2.45314777e-01f, -3.90373431e-02f, -3.98181289e-01f, 6.00275874e-01f,
  -4.43535447e-01f, 8.57956484e-02f, -4.51238513e-01f, 1.46725014e-01f, 5.34470439e-01f, 5.27601361e-01f, 6.72907233e-01f, 1.67742833e-01f, 2.99898952e-01f, 3.32101434e-01f,
  3.54779989e-01f, 5.84320843e-01f, 6.89079642e-01f, -4.30957019e-01f, 9.20646966e-01f, 5.46677589e-01f, -5.24624288e-01f, 3.60143542e-01f, 3.76985688e-03f, 6.37926161e-01f,
  2.12610409e-01f, 7.11515129e-01f, -6.13972187e-01f, -2.68606722e-01f, 4.85167593e-01f, -3.47186506e-01f, 4.62766513e-02f, -7.92531222e-02f, 5.94136119e-02f, -2.09124804e-01f,
  5.87618537e-02f, 1.78108215e-01f, 2.87579298e-01f, 2.12780952e-01f, 4.71916974e-01f, 2.84354687e-01f, -2.84865469e-01f, 1.71040207e-01f, -1.76731259e-01f, 3.57336521e-01f,
  -1.57744110e-01f, 5.01014143e-02f, 5.68495035e-01f, -2.72489409e-03f, -4.94556427e-01f, 5.51368035e-02f, -3.79122227e-01f, -3.22403103e-01f, 7.50197232e-01f, -5.74930191e-01f,
  -7.64526725e-01f, 6.71507567e-02f, -4.48952109e-01f, -6.47203684e-01f, -5.16692162e-01f, 1.02197838e+00f, 9.31740087e-03f, -4.21615064e-01f, -5.54508269e-01f, -1.98605299e-01f,
  2.51575500e-01f, -8.99614692e-02f, 1.48229981e-02f, 1.58266500e-01f, -3.97575080e-01f, -6.50185049e-01f, 7.13862553e-02f, -5.72025001e-01f, -6.43551528e-01f, -2.70559728e-01f,
  1.23656265e-01f, -1.40743583e-01f, 1.64834127e-01f, -7.90034309e-02f, -3.70734870e-01f, 5.78531176e-02f, -4.39705819e-01f, 4.52804893e-01f, -4.67641503e-01f, 7.42664397e-01f,
  4.76903886e-01f, -4.76464063e-01f, 3.60919207e-01f, -6.37635589e-01f, 3.81996661e-01f, 2.86351115e-01f, -4.85087931e-01f, -1.16991781e-01f, 1.47492420e-02f, 1.07162148e-01f,
  1.50692591e-03f, -3.16962153e-01f, 6.70762539e-01f, -5.71600914e-01f, -1.91775784e-01f, -3.43856066e-01f, 2.68969834e-01f, 2.38903865e-01f, -1.92786187e-01f, 1.59435317e-01f,
  2.03899875e-01f, 9.72342715e-02f, -5.00303388e-01f, 4.88993153e-02f, -4.01879609e-01f, 8.16230550e-02f, 2.31374521e-02f, -5.09439230e-01f, -5.42644441e-01f, 3.07141244e-01f,
  6.20938480e-01f, 7.24756941e-02f, 5.62763512e-01f, 4.32400554e-01f, 4.74251717e-01f, 1.32834315e-01f, 7.22316742e-01f, 7.84726262e-01f, -5.65243065e-01f, 6.75948381e-01f,
  -9.24675763e-02f, 4.92802650e-01f, -4.47675467e-01f, 1.38403520e-01f, -5.66383460e-05f, 2.30641276e-01f, 5.60858250e-01f, -1.24570243e-01f, 3.22878659e-01f, 3.40731740e-01f,
  -8.00813615e-01f, 1.89477373e-02f, 3.00041229e-01f, 3.15259010e-01f, -5.05406439e-01f, 2.87897348e-01f, 1.57277092e-01f, 1.05847478e-01f, 4.31425184e-01f, 4.18681055e-01f,
  5.47142982e-01f, -3.83268684e-01f, -8.31900239e-01f, -3.53405297e-01f, 3.39485109e-01f, -5.17466187e-01f, -7.01533794e-01f, 3.33860934e-01f, -4.05996665e-02f, 7.21262097e-01f,
  5.09161294e-01f, -4.52396601e-01f, -3.67135048e-01f, -5.07254362e-01f, 3.50486264e-02f, -4.01692837e-01f, 4.89051372e-01f, -3.60221088e-01f, -3.16729426e-01f, 1.72851622e-01f,
  4.46778357e-01f, -1.90358117e-01f, 3.05340409e-01f, 8.73235688e-02f, -1.50618792e-01f, -4.13098067e-01f, 2.17944756e-03f, 1.74952999e-01f, -2.01961235e-03f, -2.43186980e-01f,
  -2.50006676e-01f, 4.22296464e-01f, 5.82058132e-02f, -6.78741217e-01f, -2.01055497e-01f, 4.73032832e-01f, -4.43842828e-01f, 7.04789162e-01f, 4.99063998e-01f, 1.06814869e-01f,
  4.78721142e-01f, -8.86913002e-01f, 5.82919598e-01f, 4.55172658e-01f, 3.73303592e-02f, -3.33001494e-01f, -3.91107470e-01f, -3.61102611e-01f, -2.17947632e-01f, -2.66281366e-01f,
  8.47187281e-01f, -1.13112874e-01f, 1.60509899e-01f, -4.66186136e-01f, 2.61391580e-01f, 1.80356160e-01f, 1.71239763e-01f, -6.05722964e-01f, 2.83922225e-01f, -5.27961791e-01f,
  1.98706970e-01f, -4.77957353e-03f, -4.58555430e-01f, 1.57061920e-01f, -2.58591324e-01f, 5.19148946e-01f, 8.23309571e-02f, -2.76864946e-01f, 2.86901712e-01f, -5.74424267e-01f,
  9.66858417e-02f, 7.57359207e-01f, 3.36987585e-01f, -6.61652267e-01f, -4.11021411e-01f, 1.34592488e-01f, -3.42398524e-01f, -7.79315531e-02f, -9.22188908e-02f, 1.43282264e-01f,
  -1.83228105e-01f, 1.09592092e+00f, -1.46248098e-02f, 1.78792864e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -6.76835626e-02f, -1.42046422e-01f, 1.82507932e-01f, 1.61676314e-02f, 5.02640978e-02f, 7.65703470e-02f, -1.85156494e-01f, 1.71984032e-01f, 8.54197964e-02f, 8.53900611e-03f,
  1.20130435e-01f, -1.10770561e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    