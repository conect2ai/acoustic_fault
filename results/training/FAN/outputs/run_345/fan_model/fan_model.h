/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.78045335e-02f, 1.20536417e-01f, 3.48236635e-02f, 5.52813075e-02f, -1.78045139e-01f, -4.76047024e-02f, -6.55136630e-02f, -1.27744386e-02f, 1.65658593e-01f, 1.10841230e-01f,
  -5.23025803e-02f, 1.47634000e-01f, 8.77562091e-02f, 4.04491206e-04f, -1.09025715e-02f, -6.97139930e-03f, 3.49471010e-02f, -5.16064279e-02f, 1.17993027e-01f, -3.23976316e-02f,
  -1.90031584e-02f, -1.01897866e-01f, -1.00442581e-01f, -1.38510779e-01f, -4.44900431e-02f, -4.00417373e-02f, 3.17821912e-02f, -3.01279337e-03f, -3.93358134e-02f, -1.03983402e-01f,
  -5.75227551e-02f, 1.36150464e-01f, -2.87142694e-02f, -4.19477448e-02f, -4.13878169e-03f, 5.73900975e-02f, -8.25459883e-02f, -5.86562380e-02f, -4.72982489e-02f, 2.75653545e-02f,
  1.02623880e-01f, 1.08386138e-02f, 7.78884441e-02f, -4.28312644e-03f, 3.45551036e-03f, -4.07012627e-02f, 4.25787382e-02f, -1.75840463e-02f, 5.04030101e-02f, 2.27067154e-02f,
  2.47206576e-02f, -6.19500987e-02f, 6.02497868e-02f, 4.43154685e-02f, 7.20833486e-04f, -7.32628405e-02f, -5.05878031e-03f, 2.53400598e-02f, -3.63488905e-02f, 6.70857877e-02f,
  -5.52499406e-02f, 4.61248569e-02f, -5.61613776e-02f, -7.49727413e-02f, 2.11991929e-02f, 1.77194495e-02f, -7.27300346e-02f, -3.34482789e-02f, -2.26052292e-02f, 6.00207672e-02f,
  2.87479465e-03f, 1.27807437e-02f, -2.06701700e-02f, -8.21531266e-02f, 3.46565396e-02f, -6.61740499e-03f, 6.10532165e-02f, -5.14843389e-02f, -5.85519783e-02f, 1.84909720e-02f,
  -6.39447495e-02f, -4.09221202e-02f, -3.96243297e-03f, -5.91675937e-03f, -8.60610418e-03f, 7.23365769e-02f, -2.29515545e-02f, 5.00677451e-02f, -4.82958779e-02f, -5.97476074e-03f,
  4.28531282e-02f, 1.55566884e-02f, -3.83871868e-02f, 6.44579902e-02f, -4.39481698e-02f, -2.66940473e-03f, 5.59623055e-02f, 2.06524041e-02f, -8.92729759e-02f, 1.36276027e-02f,
  6.33912906e-03f, -5.35972863e-02f, -1.07254386e-02f, 2.33223941e-02f, 2.36360766e-02f, 1.26089770e-02f, 8.69426280e-02f, -4.81142588e-02f, -7.65054002e-02f, 4.58094813e-02f,
  -6.10648282e-02f, 5.17725945e-02f, -2.60693282e-02f, -1.60753783e-02f, 1.99532192e-02f, 4.80219461e-02f, 8.11557770e-02f, -1.01418002e-02f, 7.04487786e-02f, 7.82938302e-02f,
  1.67799786e-01f, -1.43260807e-01f, -1.57654546e-02f, 2.33339682e-01f, -1.51742041e-01f, -1.08213775e-01f, 4.22931835e-02f, -8.05119500e-02f, 2.78137445e-01f, 5.21355420e-02f,
  -1.69597007e-02f, 4.94218916e-02f, -1.87628821e-01f, 2.18189731e-01f, -9.12654325e-02f, -1.06649600e-01f, 1.66666701e-01f, 3.34047750e-02f, 8.77809003e-02f, 5.87605238e-02f,
  1.48192465e-01f, 4.59391661e-02f, 4.49506082e-02f, -6.96021989e-02f, 1.18654512e-01f, 1.62704065e-01f, 9.69529524e-02f, -1.64328992e-01f, -4.93954495e-02f, -1.51689574e-01f,
  -5.84775954e-02f, 7.62655064e-02f, 3.98496054e-02f, -3.62884402e-02f, 1.59927458e-02f, 6.14520684e-02f, -5.95734194e-02f, -1.82058513e-02f, -1.93116814e-02f, -6.33335253e-03f,
  -2.14501675e-02f, 5.01234308e-02f, -3.23606022e-02f, 1.09264394e-02f, 8.15283507e-02f, 3.95051464e-02f, -1.10771824e-02f, 1.01669713e-04f, -3.67985107e-02f, 2.23543393e-04f,
  -3.60257216e-02f, 5.80564961e-02f, 1.40016759e-02f, 2.80788969e-02f, 4.06185873e-02f, 6.52880967e-02f, 9.75708291e-03f, -8.86260197e-02f, 4.77367342e-02f, 3.89805734e-02f,
  2.64006723e-02f, -7.38411471e-02f, 1.16336532e-02f, -1.15683172e-02f, -4.96871062e-02f, 6.67110309e-02f, -2.78795138e-02f, -2.36351695e-02f, -2.92665232e-02f, 3.15626822e-02f,
  3.58535834e-02f, 5.75141162e-02f, 3.38121057e-02f, 6.35524243e-02f, 5.33611961e-02f, 8.95400792e-02f, -9.49035957e-02f, -5.03995121e-02f, 1.02721803e-01f, 7.15783760e-02f,
  -5.69250993e-03f, 4.87863794e-02f, -5.91422282e-02f, -6.18994236e-04f, -1.24087691e-01f, 1.73133500e-02f, 7.31291026e-02f, 4.82529327e-02f, 5.28933480e-02f, -5.37536992e-03f,
  -4.19068374e-02f, 1.50218919e-01f, 9.57561098e-03f, -1.47081465e-02f, 9.54097882e-03f, -7.24583864e-02f, -4.93631065e-02f, -5.06429337e-02f, -2.41533015e-02f, 5.47542796e-03f,
  1.44620845e-02f, 2.71066725e-02f, -5.03874496e-02f, 4.21718135e-02f, -4.21560109e-02f, -1.26340566e-02f, 2.68956646e-02f, 7.86078498e-02f, 9.49376449e-02f, -5.25932852e-03f,
  -3.87729481e-02f, -7.46340631e-03f, 5.00901304e-02f, -1.53060379e-02f, 4.61975560e-02f, 3.52605693e-02f, 4.19233702e-02f, 2.47916132e-02f, -2.72236634e-02f, 5.31450510e-02f,
  -4.09519998e-03f, -2.54418045e-01f, 7.87378475e-02f, -1.41945243e-01f, 1.62906140e-01f, 1.16329230e-01f, 7.79581070e-02f, -2.19796821e-02f, -3.31461608e-01f, -2.14707747e-01f,
  6.04460947e-02f, -8.01577270e-02f, -7.70346075e-02f, 5.57779893e-03f, 3.53399292e-02f, -2.79417366e-01f, -1.19727686e-01f, -1.00714408e-01f, -9.04037580e-02f, 6.79569542e-02f,
  -2.12501120e-02f, -1.01010069e-01f, 1.03150330e-01f, 6.25346899e-02f, 1.35198474e-01f, 1.36299536e-01f, 7.87787139e-03f, 1.14361174e-01f, 1.12474307e-01f, 5.44197634e-02f,
  5.34845851e-02f, -1.14588797e-01f, -6.80079386e-02f, 3.07009593e-02f, 1.08297676e-01f, 1.04471706e-01f, 6.03977703e-02f, 4.31746654e-02f, 1.19025288e-02f, -2.08468828e-02f,
  4.07838523e-02f, 5.93722537e-02f, -4.04753443e-03f, -6.54021055e-02f, 2.54396293e-02f, 3.19151506e-02f, 5.40761873e-02f, 4.07079421e-02f, 2.33911499e-02f, 5.27432971e-02f,
  1.96872167e-02f, 5.35781235e-02f, -2.85526980e-02f, -5.97520880e-02f, 4.68710922e-02f, 3.90734263e-02f, 2.88010873e-02f, 1.23633198e-01f, -8.80270004e-02f, -6.34680614e-02f,
  6.80780262e-02f, 3.28891203e-02f, -1.05366914e-03f, -2.66514253e-02f, 1.61397345e-02f, -1.65717900e-02f, -6.38931468e-02f, -2.49148477e-02f, 6.51897937e-02f, -1.44131640e-02f,
  1.59681421e-02f, 3.80680412e-02f, -9.00743678e-02f, 4.62619327e-02f, -1.69752780e-02f, -6.83398321e-02f, 6.12532720e-02f, -4.25796025e-02f, 4.90634814e-02f, -1.65418293e-02f,
  -1.13404999e-02f, -1.63413957e-03f, 2.20723189e-02f, -2.68958881e-02f, 1.56449769e-02f, 1.99090131e-02f, 2.08990928e-02f, 6.52400032e-02f, 5.34810275e-02f, 3.80425826e-02f,
  -5.80170052e-03f, -1.54258266e-01f, -2.19178363e-03f, 2.69080102e-02f, -1.32886559e-01f, 3.13487276e-02f, -8.09278637e-02f, 1.77417614e-03f, -2.10606903e-02f, -4.37268540e-02f,
  3.32290679e-02f, -4.61612903e-02f, -3.99342142e-02f, 5.02844714e-02f, -2.92883161e-02f, -4.12165076e-02f, -4.37111147e-02f, 1.50909927e-02f, 5.52309677e-02f, 3.05379052e-02f,
  -3.54379267e-02f, 4.19153161e-02f, 2.99528334e-02f, 2.59923134e-02f, 2.20474023e-02f, -6.40290082e-02f, 1.59454476e-02f, 4.09850180e-02f, -3.74106877e-02f, -5.59647605e-02f,
  -1.14582799e-01f, 7.53415823e-02f, 2.02181756e-01f, 1.27054006e-01f, 2.26991668e-01f, 1.03142180e-01f, 8.84505510e-02f, 7.18165338e-02f, 2.18675122e-01f, -1.20917112e-01f,
  -5.61939999e-02f, -4.86634374e-02f, 3.84347290e-02f, 1.24706626e-01f, 3.05671468e-02f, -4.03936841e-02f, -4.75380104e-03f, -5.14551699e-02f, 9.74290818e-02f, 5.36493808e-02f,
  -6.31018309e-03f, 2.73025557e-02f, 1.35029983e-02f, -6.65220153e-03f, 4.36296165e-02f, 1.19583495e-02f, -1.34210438e-01f, 7.43313208e-02f, 4.26748721e-03f, 9.74703580e-02f,
  2.85042077e-02f, -3.45430337e-02f, -2.80933119e-02f, -4.78326529e-02f, -7.38239065e-02f, 1.19366739e-02f, -2.91547063e-03f, 4.55046706e-02f, 1.71252787e-02f, 1.15013778e-01f,
  -6.73157498e-02f, -1.31457229e-04f, 3.78836207e-02f, -2.41664350e-02f, -1.98770780e-02f, -3.84110622e-02f, 6.60925061e-02f, 8.00048187e-02f, 1.27364606e-01f, -1.12666544e-02f,
  1.05911061e-01f, -3.76383737e-02f, -1.67744234e-02f, -8.69560428e-03f, -1.27952350e-02f, 2.47638747e-02f, -9.09362286e-02f, -6.14153072e-02f, 5.82063347e-02f, 8.55635032e-02f,
  -7.51007274e-02f, 3.13837193e-02f, 3.54024209e-03f, 5.14361151e-02f, 1.97318085e-02f, -6.23253845e-02f, 5.74187525e-02f, -6.95893690e-02f, -1.65706195e-04f, -6.54671639e-02f,
  -1.76266693e-02f, 7.32263504e-03f, 4.58784327e-02f, -5.61972782e-02f, 3.44180390e-02f, -2.25517452e-02f, -2.17385665e-02f, -1.10616341e-01f, 6.07313141e-02f, -3.85717861e-02f,
  -3.83209041e-03f, 2.70657595e-02f, 2.48335339e-02f, -2.51216092e-03f, 6.74506575e-02f, -2.40732078e-03f, 5.86502105e-02f, 3.44057605e-02f, -3.31124701e-02f, 2.47357972e-02f,
  2.44412338e-03f, -1.42266721e-01f, 4.78084348e-02f, 4.23033610e-02f, -4.48334776e-02f, -1.40187331e-02f, 4.59866263e-02f, -4.75439541e-02f, 4.25676741e-02f, 4.04394884e-03f,
  -6.07519671e-02f, -1.69311035e-02f, -2.02391557e-02f, 5.03023267e-02f, 6.63837492e-02f, 4.33013253e-02f, 4.72153351e-03f, 3.00918054e-02f, 2.32066065e-02f, -3.01210005e-02f,
  -6.56501651e-02f, 1.21355029e-02f, -1.82873011e-02f, -2.33850759e-02f, -7.44604617e-02f, -1.61892679e-02f, -5.24801528e-03f, -3.51980068e-02f, 5.06796539e-02f, 7.09466264e-02f,
  1.14110090e-01f, 1.05665281e-01f, 1.85384393e-01f, 2.06950143e-01f, -9.34380069e-02f, -2.68671066e-01f, -1.63091779e-01f, 5.53583130e-02f, 1.69666857e-01f, -1.11457407e-01f,
  -1.41218439e-01f, 1.53012604e-01f, -5.97696118e-02f, -1.34288579e-01f, 6.03250191e-02f, 2.56511848e-03f, -1.62706509e-01f, -1.00921541e-01f, 1.18185766e-01f, -8.45900830e-03f,
  9.06709805e-02f, -3.23308915e-01f, -1.32708373e-02f, -1.37345865e-01f, -1.03801578e-01f, 1.56693071e-01f, -4.29398706e-03f, -1.91750955e-02f, -5.80861904e-02f, -4.13648076e-02f,
  -3.92225012e-02f, 4.65641059e-02f, -8.92055593e-03f, -2.66005620e-02f, -8.32550526e-02f, 5.75355366e-02f, 4.75486368e-02f, -7.07373908e-03f, -2.12604893e-04f, -1.35019952e-02f,
  2.83840541e-02f, 5.48905209e-02f, 6.73447642e-03f, 4.60376323e-04f, 5.20320646e-02f, 3.99103984e-02f, 1.14451766e-01f, 7.51009732e-02f, 7.42285028e-02f, 9.58419070e-02f,
  1.07965834e-01f, 5.30792736e-02f, 4.86398004e-02f, -2.84678042e-02f, 4.47835959e-02f, -1.23873923e-03f, 3.26436311e-02f, 8.64950866e-02f, 1.77453812e-02f, 8.78791064e-02f,
  4.55265976e-02f, 8.10028613e-02f, -5.94943315e-02f, -2.76491884e-02f, -7.40356892e-02f, -2.86031188e-03f, 7.67266331e-03f, -9.45885386e-03f, -5.07496074e-02f, 2.10369322e-02f,
  -4.99523096e-02f, 9.38560888e-02f, -3.09581850e-02f, -5.41838876e-04f, 4.24540080e-02f, -3.91480662e-02f, -2.54074521e-02f, 1.74406096e-02f, 3.51309106e-02f, 9.97387618e-03f,
  -3.97214442e-02f, -4.42069843e-02f, -5.90384528e-02f, -1.12951379e-02f, -6.79029897e-02f, 5.85752651e-02f, -3.56318825e-03f, 1.08515091e-01f, 5.87885343e-02f, -2.58697700e-02f,
  -1.29134968e-01f, -1.40663326e-01f, 7.58540481e-02f, 2.87522320e-02f, 4.02389182e-04f, -8.92346352e-02f, 3.71073149e-02f, 3.40933464e-02f, -8.07988048e-02f, -3.43905799e-02f,
  2.38799881e-02f, -4.16671373e-02f, 5.49445450e-02f, -2.74104755e-02f, -3.06803323e-02f, -1.92692187e-02f, -7.23303109e-02f, -9.10268724e-02f, -9.84942447e-03f, -5.88027388e-02f,
  -9.39437654e-03f, -6.85955137e-02f, 5.66128269e-03f, 6.38665557e-02f, 1.17509887e-02f, -3.08532584e-02f, -1.03386082e-02f, -2.04419382e-02f, -3.08510591e-03f, -2.37314720e-02f,
  1.92193672e-01f, 1.43299431e-01f, 4.81319502e-02f, 1.08206891e-01f, -1.87013652e-02f, -2.79605627e-01f, -2.95363128e-01f, 1.21400259e-01f, 1.59232020e-01f, -1.69771716e-01f,
  -1.42398030e-01f, 1.81989580e-01f, -1.84218809e-01f, 2.84810793e-02f, -1.77942980e-02f, -1.40413091e-01f, -1.19086348e-01f, -3.60670947e-02f, 1.67162716e-01f, 6.33331016e-02f,
  1.93229560e-02f, 2.95582158e-03f, -4.72172685e-02f, 8.41016173e-02f, 1.16753280e-01f, 1.64688960e-01f, -3.64659689e-02f, -7.19015598e-02f, 5.18760793e-02f, 5.10797910e-02f,
  -5.95177189e-02f, 1.65022627e-01f, 5.38615584e-02f, 4.43190038e-02f, 1.86153594e-02f, -4.72924337e-02f, -8.70806277e-02f, 2.81781536e-02f, 1.16736311e-02f, 2.87529826e-02f,
  -3.28870900e-02f, -5.02599031e-02f, 9.65917483e-02f, -3.61591764e-02f, 1.59881953e-02f, -9.55169741e-03f, 1.76354647e-02f, 5.68932742e-02f, 2.11525615e-02f, -6.51446311e-03f,
  -5.16068749e-02f, -4.45033647e-02f, 3.39362733e-02f, -3.01042944e-02f, -6.22534938e-02f, 3.91405309e-03f, 5.68468217e-03f, -5.22441417e-02f, 1.42350849e-02f, 3.25109921e-02f,
  -2.40897350e-02f, -4.92069200e-02f, -5.66774681e-02f, 8.00806955e-02f, -5.01037315e-02f, 1.27967668e-03f, -3.28025818e-02f, -5.93250506e-02f, 3.67286778e-03f, -8.61866027e-02f,
  8.32008570e-02f, 2.37160549e-02f, 9.50142443e-02f, -7.98154902e-03f, 2.92445216e-02f, 5.69190122e-02f, -1.15808593e-02f, -2.86364462e-02f, -3.75322290e-02f, -2.08798833e-02f,
  5.29538803e-02f, 5.02342992e-02f, 4.16226164e-02f, 1.01385312e-02f, 5.08670807e-02f, -6.61300048e-02f, 6.02850467e-02f, -5.31534143e-02f, 3.50765847e-02f, -9.29278880e-03f,
  -5.93414381e-02f, 1.14950404e-01f, 2.88389735e-02f, 1.68571174e-02f, -4.90366388e-03f, -5.12378551e-02f, 5.93117159e-03f, 6.87185824e-02f, -3.27048078e-02f, -1.61386430e-02f,
  -9.77330562e-03f, -3.72166000e-03f, -4.71591130e-02f, -3.29983197e-02f, 1.32678878e-02f, 3.84083949e-02f, -1.80556886e-02f, 3.67781967e-02f, 2.54978724e-02f, 2.74728853e-02f,
  -5.99584635e-03f, -3.59191447e-02f, -6.28669411e-02f, -5.45646362e-02f, -7.21844193e-03f, -4.11532633e-02f, 1.09994877e-02f, 1.43376878e-02f, -2.17604060e-02f, -1.57183725e-02f,
  -1.17293201e-01f, 4.90966514e-02f, 1.40948161e-01f, -1.27537325e-01f, 6.32946715e-02f, 1.02811620e-01f, 7.67574236e-02f, -4.09204438e-02f, -1.52060717e-01f, -2.54532285e-02f,
  1.01981880e-02f, 1.10750243e-01f, -6.67923614e-02f, -1.18438125e-01f, -2.26110056e-01f, -1.79884672e-01f, -1.69770032e-01f, -5.96886054e-02f, -1.39138550e-01f, -8.74757245e-02f,
  -1.54704168e-01f, -5.48110306e-02f, -1.17808864e-01f, -9.89276916e-02f, 5.28319925e-02f, -5.44048958e-02f, -1.10891126e-02f, 8.42440575e-02f, 5.21623716e-02f, 2.84313336e-02f,
  -6.63749054e-02f, -7.56356791e-02f, 9.91047397e-02f, 3.47943604e-02f, -4.48895665e-03f, -4.68784897e-03f, -2.99831145e-02f, 4.62901918e-03f, -2.51795799e-02f, 3.63317728e-02f,
  -4.96187806e-02f, -6.45463914e-02f, -5.30130323e-03f, -1.80080794e-02f, -1.68910492e-02f, 6.06723055e-02f, -7.70934785e-05f, 8.11416283e-02f, 3.74804549e-02f, 4.67610210e-02f,
  6.04699887e-02f, -3.47368792e-02f, 1.85955279e-02f, 5.90864532e-02f, -7.35526159e-02f, 6.00175560e-03f, -4.56984453e-02f, -9.42148175e-03f, 1.10861734e-01f, 4.64964248e-02f,
  -6.31435812e-02f, -3.35606821e-02f, 6.78488463e-02f, -4.88677435e-02f, -6.67240694e-02f, 2.57617738e-02f, -4.12078314e-02f, -6.70448318e-02f, -3.26845981e-02f, 5.90165369e-02f,
  -8.40222463e-02f, 8.33473355e-03f, 1.50433043e-02f, -6.56244084e-02f, 4.57124598e-02f, -3.34739760e-02f, 5.74397109e-02f, 5.19133769e-02f, 6.03018403e-02f, -8.27865005e-02f,
  3.23772654e-02f, 3.96087999e-03f, -8.65090117e-02f, 5.14228903e-02f, -6.34192973e-02f, -7.78896660e-02f, 1.91263985e-02f, -6.94401264e-02f, 5.73900789e-02f, -4.46631014e-02f,
  3.41742560e-02f, -6.76121116e-02f, -2.99835429e-02f, -5.02565056e-02f, -2.63055675e-02f, 1.02974847e-01f, -6.86476156e-02f, 2.05211807e-02f, -4.11680713e-03f, -8.62571374e-02f,
  1.02087565e-01f, 5.16133793e-02f, -1.39793837e-02f, 3.64664979e-02f, -1.27047701e-02f, 8.32629576e-02f, -4.17883471e-02f, -1.25924498e-03f, 4.60966267e-02f, 9.40594971e-02f,
  -2.83222757e-02f, 4.96618031e-03f, -5.91453575e-02f, -4.48353036e-04f, -9.64032952e-03f, 2.36719497e-03f, -4.69523296e-02f, -5.74722700e-02f, -7.96235073e-03f, 7.26873204e-02f,
  1.88977793e-01f, -1.70069978e-01f, 2.90814072e-01f, 1.64306149e-01f, -3.15275155e-02f, 1.67857930e-01f, 4.76884134e-02f, -8.71835425e-02f, 1.51769826e-02f, -1.82993561e-01f,
  -9.20897126e-02f, 8.75417516e-02f, -9.63373333e-02f, 1.44898975e-02f, 2.33795255e-01f, -2.78592985e-02f, 7.65644829e-04f, 4.65380074e-03f, 2.07639136e-03f, 3.92152835e-03f,
  1.00690871e-01f, -1.28412366e-01f, 9.37601551e-02f, -2.08549768e-01f, 1.43267047e-02f, -4.95908521e-02f, -1.56421155e-01f, 5.08899651e-02f, -3.84949967e-02f, 6.71945140e-02f,
  -2.62932070e-02f, -2.91922800e-02f, 1.28012029e-02f, -1.22940103e-02f, 2.57637519e-02f, -8.07004943e-02f, 2.29531731e-02f, 7.61872306e-02f, -1.93284347e-03f, 6.03348166e-02f,
  -4.87106554e-02f, -4.93183546e-02f, -6.36204481e-02f, -6.74846247e-02f, 5.13017848e-02f, 2.59379782e-02f, 1.49356274e-04f, -6.22532284e-03f, -2.06988081e-02f, 1.10071518e-01f,
  8.13207626e-02f, 3.01630814e-02f, 8.61721635e-02f, 2.85688266e-02f, 1.51567894e-03f, -6.72872216e-02f, -1.20288450e-02f, -2.62640864e-02f, -7.66600436e-03f, 3.57816704e-02f,
  -4.10646349e-02f, -1.57520233e-03f, -5.28253354e-02f, 6.84808418e-02f, -4.74710315e-02f, 3.40910777e-02f, -6.14419905e-03f, -4.52449508e-02f, 3.49611565e-02f, -8.22367240e-03f,
  -2.05487106e-02f, -4.98456880e-02f, -4.96128201e-03f, -2.92200875e-02f, 3.18884440e-02f, -7.49498159e-02f, 3.37046236e-02f, -8.20504352e-02f, -1.71799473e-02f, 7.04320753e-03f,
  2.26276694e-03f, -2.27843095e-02f, 3.18228602e-02f, 2.31523477e-02f, 5.31895235e-02f, 3.78858484e-02f, -2.86237113e-02f, -5.34535162e-02f, 6.63291812e-02f, 6.60876557e-02f,
  -8.49927142e-02f, -2.18710955e-02f, -1.74835753e-02f, 3.61699909e-02f, 1.97620876e-02f, 3.24569941e-02f, -3.90671119e-02f, -3.27320173e-02f, 4.11618687e-02f, 6.08143304e-03f,
  5.55446297e-02f, 2.60482226e-02f, -2.31172629e-02f, 1.97704192e-02f, -4.77135293e-02f, -1.50155704e-02f, 2.11177878e-02f, 4.70436364e-02f, -6.52592704e-02f, -1.07571865e-02f,
  3.45128775e-03f, -3.79812764e-03f, -1.45742549e-02f, -2.08117608e-02f, -5.92722557e-02f, -7.11289875e-04f, 2.12959852e-02f, 6.82966933e-02f, -7.28735626e-02f, 7.66590461e-02f,
  1.42085224e-01f, -1.46732911e-01f, 4.49942164e-02f, 1.68839768e-01f, 1.01455897e-01f, -2.68567711e-01f, -2.78562959e-02f, 6.67079464e-02f, 2.38059461e-01f, -1.21271148e-01f,
  -1.23617001e-01f, 9.95499343e-02f, -3.86321023e-02f, -2.33636379e-01f, -1.28330827e-01f, -5.37053347e-02f, -1.84799805e-01f, -1.18716113e-01f, 5.24402484e-02f, 1.30653596e-02f,
  1.14464849e-01f, -1.84663504e-01f, -1.29531622e-01f, 4.38129622e-03f, -3.00341696e-02f, 1.50145710e-01f, -3.17130722e-02f, -5.29757552e-02f, -1.33508503e-01f, -7.13708401e-02f,
  -1.10253833e-01f, 4.84781154e-02f, 6.48630112e-02f, -3.88299562e-02f, -3.02812504e-03f, 6.58264942e-03f, -1.53734358e-02f, -2.03758273e-02f, 1.13172136e-01f, -3.82049195e-02f,
  -2.89659519e-02f, 3.81809436e-02f, -2.87682861e-02f, -2.39723604e-02f, 9.13106352e-02f, 1.51437917e-03f, -4.95354123e-02f, 5.28265163e-02f, -3.52940857e-02f, -9.99029577e-02f,
  1.52445724e-03f, -4.50242776e-03f, 9.74406376e-02f, -1.18635539e-02f, 6.92854002e-02f, -2.67833788e-02f, -6.80285171e-02f, -2.56667919e-02f, -2.26699915e-02f, -1.49404099e-02f,
  -2.68677231e-02f, -3.37063670e-02f, -5.63046969e-02f, 2.93394155e-03f, 6.98969737e-02f, -1.25827501e-02f, -1.02048339e-02f, -1.85809545e-02f, 9.25496668e-02f, -2.81983125e-03f,
  1.04448609e-02f, 5.52169569e-02f, -2.59597041e-03f, 6.96769953e-02f, -4.31204168e-03f, 1.10146729e-02f, -7.47150229e-03f, 3.54358181e-02f, -1.64038073e-02f, 1.93505045e-02f,
  8.46537016e-03f, -4.73266747e-03f, 5.10506984e-03f, -7.17404261e-02f, -8.15551821e-03f, -6.27264893e-03f, -6.13927580e-02f, -3.15537713e-02f, 5.33293597e-02f, -4.37276736e-02f,
  -5.63712642e-02f, 2.59893900e-03f, -2.63285395e-02f, 3.13825160e-02f, -1.20415231e-02f, 2.00700723e-02f, -2.75587067e-02f, -1.45883171e-03f, 4.74616997e-02f, 1.51431113e-02f,
  -6.72976300e-02f, -2.84970999e-02f, 2.30303854e-02f, 5.11479415e-02f, -3.45993496e-04f, -7.92160537e-03f, 2.85842810e-02f, 1.70773659e-02f, 4.96313274e-02f, -4.74375077e-02f,
  2.96461359e-02f, 6.80391937e-02f, -3.32729928e-02f, 3.40711698e-02f, 2.31319945e-02f, 6.44065142e-02f, 4.19617631e-02f, -3.99515629e-02f, -4.03367877e-02f, 4.55665123e-03f,
  2.31646836e-01f, -1.62364826e-01f, 1.94248483e-02f, -1.01599045e-01f, -5.33463620e-03f, -2.18626857e-01f, -1.54757500e-01f, 6.44763857e-02f, 8.33996683e-02f, -2.17724264e-01f,
  -4.31760261e-03f, -5.74999340e-02f, -3.06593701e-02f, -1.87323153e-01f, 1.00684352e-01f, 5.80168068e-02f, -1.96221963e-01f, -2.28304133e-01f, -2.15012319e-02f, 2.21155975e-02f,
  7.05902204e-02f, -6.57558218e-02f, 1.06163874e-01f, 6.97343051e-02f, -4.11142595e-03f, 5.29845990e-02f, -1.47137081e-03f, 1.41526952e-01f, -1.70113176e-01f, -1.07233956e-01f,
  -9.67335030e-02f, 7.76503682e-02f, -3.35215777e-02f, -6.92913085e-02f, 4.91142133e-03f, -8.10791999e-02f, -8.69109556e-02f, -1.04839159e-02f, 1.24200536e-02f, 2.62989812e-02f,
  8.81951675e-03f, -5.54847941e-02f, -7.69304037e-02f, -3.91219519e-02f, -1.98241286e-02f, -4.52218316e-02f, 3.28365788e-02f, -3.32878307e-02f, -4.62666638e-02f, 8.42805281e-02f,
  -4.12666276e-02f, -7.05109760e-02f, 1.60388090e-02f, -9.49554965e-02f, 4.97012511e-02f, -9.65321530e-03f, 1.03985649e-02f, 3.93244736e-02f, 1.69377699e-02f, 2.47388799e-02f,
  3.34677361e-02f, 1.52713628e-02f, -2.93386495e-03f, 3.64743546e-02f, 4.87916283e-02f, 4.41782624e-02f, -2.21905485e-02f, -1.20499646e-02f, 1.48387281e-02f, 2.02151351e-02f,
  4.53907698e-02f, 2.14504153e-02f, 2.08793511e-03f, 2.77390573e-02f, 6.32229522e-02f, -5.21143377e-02f, -1.57642066e-02f, -4.07855287e-02f, 3.56020741e-02f, 6.04669526e-02f,
  -1.14896921e-02f, 1.54479239e-02f, 1.21900411e-02f, -2.92780140e-04f, 1.12795746e-02f, -9.86141991e-03f, 1.62178092e-02f, 2.88376659e-02f, 8.38226005e-02f, -4.23679799e-02f,
  -4.63408493e-02f, -8.36860090e-02f, 4.86461706e-02f, -1.65716652e-02f, -4.42317836e-02f, 5.01897447e-02f, -3.62016484e-02f, -3.14594842e-02f, 1.38038704e-02f, -4.89477441e-03f,
  -6.15314394e-02f, 6.38470659e-03f, -4.77538407e-02f, 3.57512794e-02f, -2.03318745e-02f, 6.28493801e-02f, 4.44497503e-02f, -1.46129308e-03f, 4.91040833e-02f, -3.07940487e-02f,
  1.26103321e-02f, -7.55900517e-02f, 4.36991677e-02f, -6.12483248e-02f, -3.59965339e-02f, -2.36042663e-02f, -7.63170049e-02f, 2.97853798e-02f, -1.14055853e-02f, 1.69594735e-02f,
  -1.85777750e-02f, -7.52490293e-03f, 6.53929561e-02f, -2.11103618e-01f, -4.82324660e-02f, 3.11860383e-01f, 1.71237782e-01f, 7.78340474e-02f, -2.55731493e-01f, -5.15609339e-04f,
  3.44563723e-02f, -9.32608172e-02f, 1.01087794e-01f, -5.68712465e-02f, 2.40665585e-01f, 1.52518913e-01f, 1.52272256e-02f, -4.17023189e-02f, -5.70086911e-02f, 5.66256717e-02f,
  -2.23704409e-02f, -4.25845273e-02f, 1.51931867e-01f, -5.60965315e-02f, 9.95236710e-02f, -1.16548799e-01f, 3.21277278e-03f, 5.36407195e-02f, -8.11302513e-02f, 9.86035261e-03f,
  8.06283206e-02f, -9.47444066e-02f, 1.46910027e-02f, -1.00561909e-01f, 1.05880186e-01f, 9.82010812e-02f, -1.20829539e-02f, 6.84149191e-02f, -8.31461549e-02f, -1.61412004e-02f,
  3.96352187e-02f, 7.99892098e-03f, -1.21050775e-01f, 3.34826969e-02f, -9.52265598e-03f, -8.19662213e-02f, 2.24065743e-02f, 2.25293972e-02f, 1.24645315e-03f, 3.80363390e-02f,
  8.79113376e-02f, 4.27282043e-03f, 1.14631252e-02f, 8.67534708e-03f, -1.71666685e-02f, -1.13697991e-01f, -4.00127172e-02f, 1.11028738e-01f, 5.46718240e-02f, -3.56769338e-02f,
  5.60442545e-02f, 5.83144929e-03f, 4.58695777e-02f, -8.36333167e-03f, -2.66050510e-02f, -8.44790488e-02f, -3.11325695e-02f, -3.46066803e-02f, -3.34572010e-02f, -1.63525838e-04f,
  -5.29611595e-02f, -3.82353850e-02f, -5.20628616e-02f, -5.89120016e-02f, 5.40554151e-02f, -3.25010419e-02f, 1.17783435e-02f, 3.06143481e-02f, 5.72158992e-02f, -4.72618965e-03f,
  3.00412625e-02f, -1.49452174e-02f, -9.46400315e-03f, 2.04110816e-02f, -9.86978877e-03f, 1.94695219e-03f, -4.49088253e-02f, 5.73538877e-02f, 5.04254065e-02f, 3.95524912e-02f,
  2.21414883e-02f, 9.77832377e-02f, -3.47325876e-02f, -7.11138174e-02f, -2.62870807e-02f, 9.12373420e-03f, 5.50679080e-02f, 1.06180238e-03f, 6.79857880e-02f, 7.10857064e-02f,
  8.36947113e-02f, -8.69559795e-02f, 6.05487041e-02f, -8.92839953e-02f, -5.72126471e-02f, 8.20710883e-02f, -9.93613433e-03f, -5.35961092e-02f, 2.99663609e-03f, -1.32411532e-03f,
  -7.88636040e-03f, 4.51655872e-02f, -2.75323410e-02f, -8.90858173e-02f, -2.15739459e-02f, 6.31105155e-02f, -9.93226748e-03f, 1.10103646e-02f, 3.54998596e-02f, 1.56295262e-02f,
  1.77211128e-02f, 1.60706282e-01f, -2.07744494e-01f, -8.06338042e-02f, -3.98617759e-02f, -1.21655762e-01f, -3.30461375e-02f, 5.17195370e-03f, -3.95085141e-02f, 1.55665740e-01f,
  8.98609087e-02f, 1.18974615e-02f, -2.58695167e-02f, -3.76880653e-02f, -1.85816601e-01f, -7.77815878e-02f, -8.49605948e-02f, 4.25352752e-02f, -5.47620915e-02f, 2.93664765e-02f,
  -1.69912744e-02f, -9.98041108e-02f, -1.96878225e-01f, -6.45423904e-02f, 2.31821537e-02f, -1.61636956e-02f, 7.11710891e-03f, -1.42790630e-01f, 4.38327566e-02f, -4.93055023e-03f,
  6.05814382e-02f, 7.90936127e-02f, 5.41168116e-02f, 5.22674061e-03f, -5.94639741e-02f, -1.25073604e-02f, -4.57174443e-02f, -9.97235104e-02f, -1.79586150e-02f, -3.00709009e-02f,
  9.12237242e-02f, 2.86276378e-02f, -7.56489262e-02f, 1.32538565e-02f, 4.96073328e-02f, 4.93676178e-02f, 5.98896891e-02f, 7.43959025e-02f, -2.83885840e-02f, 8.24973360e-03f,
  -3.19579877e-02f, 4.99127135e-02f, -4.22182791e-02f, -8.97467807e-02f, -1.09559447e-01f, -1.52151929e-02f, 1.78499855e-02f, 5.87025471e-02f, 4.36344519e-02f, -7.73793682e-02f,
  -8.93477350e-02f, -8.44290107e-02f, 1.86888054e-02f, -3.18850316e-02f, 4.31652144e-02f, 5.60241900e-02f, -7.12031052e-02f, 4.10234602e-03f, -1.55282654e-02f, -1.61509588e-02f,
  4.71512005e-02f, 4.08427157e-02f, 3.11082066e-03f, -3.68169099e-02f, -1.16377417e-02f, -3.24245612e-03f, -3.97273190e-02f, 2.90135685e-02f, -6.69573694e-02f, -2.45392025e-02f,
  5.90645708e-02f, 5.31925708e-02f, 3.02127544e-02f, -2.09627561e-02f, 4.75206226e-02f, -5.47507368e-02f, 4.72871736e-02f, 4.94549908e-02f, -7.95504600e-02f, 3.93211702e-03f,
  1.70893922e-01f, -5.50052673e-02f, -5.20377085e-02f, 5.57072572e-02f, 9.89640132e-02f, 6.26163781e-02f, -1.96179040e-02f, 7.11508002e-03f, 5.90017103e-02f, -5.48021868e-02f,
  5.84505610e-02f, 5.68606369e-02f, -2.02539805e-02f, -6.77288324e-02f, -4.93656807e-02f, 1.91094186e-02f, 7.08334669e-02f, -7.71836611e-04f, 2.56287516e-03f, -4.34152745e-02f,
  -3.89869809e-02f, 1.13744951e-04f, -8.37402791e-02f, 4.45805825e-02f, 6.92273229e-02f, -9.30255279e-03f, -8.72636512e-02f, -3.25022750e-02f, -4.90955710e-02f, 5.77421077e-02f,
  6.14641085e-02f, 5.27258851e-02f, -1.13321111e-01f, 1.80567384e-01f, 3.98215204e-02f, 8.62269625e-02f, 1.99027404e-01f, 4.32386212e-02f, -5.10402303e-03f, 7.87649304e-02f,
  1.99070737e-01f, -1.80908039e-01f, 9.53260362e-02f, 3.12665582e-01f, 3.95038426e-02f, 1.94889411e-01f, 2.12244794e-01f, 1.39830247e-01f, 6.50255457e-02f, 3.57768573e-02f,
  1.38732672e-01f, 2.59350359e-01f, 2.26215795e-01f, 6.28825724e-02f, 1.05332769e-01f, -7.18891099e-02f, -8.15250427e-02f, 1.08930450e-02f, -3.53952534e-02f, -7.43256360e-02f,
  1.30742639e-01f, 8.40654820e-02f, -1.65272076e-02f, -2.36188415e-02f, -4.61294577e-02f, 3.65615450e-02f, 6.16555428e-03f, -5.63670136e-02f, -2.68027056e-02f, -1.65936165e-02f,
  -1.04319274e-01f, -5.37874363e-02f, -9.17964987e-03f, -2.49739215e-02f, -5.14443405e-02f, -7.80113563e-02f, -5.62349930e-02f, -6.20650710e-04f, 1.53889973e-02f, -4.69490290e-02f,
  6.07986748e-02f, -2.49162391e-02f, 3.23530450e-03f, -5.65044358e-02f, 2.61391364e-02f, -7.48034054e-03f, -2.73025036e-02f, -6.30918518e-02f, 1.55919874e-02f, 1.10170674e-02f,
  -3.80912833e-02f, -1.37505801e-02f, -4.40023728e-02f, 6.94828480e-02f, 7.55607113e-02f, -2.15777475e-02f, -1.03344703e-02f, 4.90038209e-02f, -1.59765203e-02f, 3.42714936e-02f,
  1.78431012e-02f, 1.67252775e-02f, -1.65460519e-02f, -3.90509106e-02f, 6.05630986e-02f, -8.67471751e-03f, -2.40371795e-03f, 4.58173715e-02f, -1.14283837e-04f, 5.68216741e-02f,
  -3.71004120e-02f, 5.13264025e-03f, -2.38781702e-02f, 5.82072437e-02f, -4.28427868e-02f, -2.09968457e-05f, -2.41767652e-02f, 5.73875234e-02f, -1.94011871e-02f, -4.95751202e-02f,
  -5.66859804e-02f, -1.27665371e-01f, 1.67572070e-02f, -5.61677851e-02f, 3.36954813e-03f, -3.79458256e-02f, -7.86402896e-02f, 4.23788726e-02f, 4.05275449e-02f, 4.86510694e-02f,
  -4.52698618e-02f, 7.86587037e-03f, -4.82836701e-02f, -2.26270910e-02f, -3.28201987e-02f, 9.54127833e-02f, 4.78077270e-02f, -6.23080134e-02f, -3.41719352e-02f, -4.87953350e-02f,
  -3.65441442e-02f, -3.97953726e-02f, 6.51485920e-02f, 2.79699974e-02f, -4.44759615e-02f, 1.81637648e-02f, -4.52495031e-02f, -5.42728417e-02f, -5.16626127e-02f, -2.00516451e-02f,
  1.58490613e-01f, -9.12046060e-02f, -1.16755649e-01f, 1.24426764e-02f, 7.28681162e-02f, 5.53009559e-05f, 1.38205111e-01f, -1.20663397e-01f, 2.37515807e-01f, 5.53851165e-02f,
  -4.35780175e-02f, 5.34829386e-02f, -2.91383918e-02f, -1.68127701e-01f, -1.65244177e-01f, -1.30190164e-01f, -4.38421816e-02f, -3.72643359e-02f, 2.79815961e-03f, -7.31103942e-02f,
  -5.89865819e-02f, -6.06430210e-02f, -1.47743359e-01f, -1.39213815e-01f, -7.42985979e-02f, 6.07737117e-02f, -4.78033237e-02f, 8.15733895e-02f, -1.28010601e-01f, 4.09239717e-03f,
  -7.16539919e-02f, -2.59555876e-02f, -8.99413824e-02f, 7.91252255e-02f, -9.03878734e-02f, 5.40333949e-02f, 3.56461033e-02f, 3.30587178e-02f, 1.90807693e-02f, 5.10023050e-02f,
  2.82882322e-02f, 1.70856453e-02f, 4.81438413e-02f, -6.54504150e-02f, -3.76570933e-02f, 1.82790458e-02f, 1.17003201e-02f, -1.08114267e-02f, 4.99691293e-02f, -1.14660501e-01f,
  5.13976216e-02f, -2.69714147e-02f, -4.11168253e-03f, 1.84067152e-02f, -2.86592785e-02f, 6.28818423e-02f, 3.53646576e-02f, 2.71758139e-02f, 7.25318268e-02f, -5.34369284e-03f,
  -2.75884103e-02f, 1.03768013e-01f, 6.87129470e-03f, 2.76897661e-02f, -4.13680961e-03f, 3.44537161e-02f, -1.49014248e-02f, -5.91457170e-03f, -2.88367011e-02f, -1.15345828e-02f,
  -3.28163467e-02f, -8.89243744e-03f, 5.50869294e-02f, -4.16480713e-02f, -6.10706732e-02f, -1.62620489e-02f, 7.30332732e-02f, 4.67018923e-03f, -3.15827429e-02f, 1.55459465e-02f,
  -3.16789225e-02f, 2.21259687e-02f, 7.80639285e-03f, 1.23080518e-03f, -9.46083143e-02f, -6.82042614e-02f, -2.94325277e-02f, 1.95120983e-02f, -2.06022412e-02f, -5.45524294e-03f,
  -3.72531749e-02f, 7.91345015e-02f, 5.72084710e-02f, -4.01352905e-02f, 3.65138277e-02f, -7.64955282e-02f, -1.34637274e-04f, -6.79348558e-02f, 5.81085831e-02f, 8.53086188e-02f,
  6.48728088e-02f, 6.49722442e-02f, 6.03269264e-02f, -3.55844125e-02f, 3.74865942e-02f, 2.49920674e-02f, -2.47859601e-02f, 2.14956310e-02f, 8.97974744e-02f, -1.09257042e-01f,
  8.87450576e-02f, 1.77054536e-02f, 8.36970583e-02f, -6.05885917e-03f, -5.97720454e-03f, -4.03990857e-02f, 1.71558112e-02f, 5.57713844e-02f, 2.44806409e-02f, 2.27655470e-02f,
  -6.21069632e-02f, -8.57953951e-02f, 3.01430702e-01f, 1.87302437e-02f, -1.44847212e-02f, 1.87628791e-01f, 1.52031615e-01f, 4.61788960e-02f, 8.60988814e-03f, -1.45956397e-01f,
  -5.90211190e-02f, -1.72727048e-01f, -4.05950099e-02f, -8.13737661e-02f, 1.51650021e-02f, 6.74350411e-02f, -1.00469083e-01f, 8.54375307e-03f, 2.68140808e-02f, -5.19611835e-02f,
  7.72739351e-02f, -9.21917260e-02f, 1.97799001e-02f, -7.00350627e-02f, -1.21259026e-01f, -6.79798648e-02f, -2.53001541e-01f, 1.29448220e-01f, -1.33017555e-01f, -7.23716840e-02f,
  -7.42659271e-02f, 1.84489191e-02f, -3.13888714e-02f, 7.60890692e-02f, -1.10898510e-01f, -4.16391417e-02f, 1.66181587e-02f, 7.58967623e-02f, 6.72767535e-02f, 7.85512775e-02f,
  -8.13790932e-02f, -2.54058149e-02f, 1.88790318e-02f, 8.65839142e-03f, 5.09513877e-02f, 6.77481219e-02f, -7.84669071e-03f, 2.28482988e-02f, 5.47287911e-02f, 7.69784749e-02f,
  9.26543400e-02f, 4.52761240e-02f, 3.40623930e-02f, -2.14711111e-03f, -1.54439993e-02f, 4.03621001e-03f, -3.33913863e-02f, 2.86356006e-02f, -7.77834952e-02f, -4.92142811e-02f,
  7.94617236e-02f, -9.12688226e-02f, -4.56741527e-02f, -1.94584280e-02f, -6.48427680e-02f, 7.57918283e-02f, -1.15300655e-01f, -8.63176584e-02f, 3.38341994e-03f, -6.72857612e-02f,
  3.51533182e-02f, -7.89882615e-02f, 8.88571423e-03f, -3.77885327e-02f, -5.17606251e-02f, -3.26392613e-02f, 4.31464277e-02f, -3.31566465e-04f, -2.80414559e-02f, -3.11531276e-02f,
  -5.82329184e-02f, 6.58020377e-02f, 4.49114405e-02f, 5.10076843e-02f, 4.52346727e-02f, -5.21917753e-02f, -6.89864904e-02f, 1.60556845e-02f, 5.70162162e-02f, 2.34964490e-02f,
  -2.63820887e-01f, -2.15327382e-01f, -9.71837938e-02f, -2.59171426e-02f, -1.57139134e-02f, -1.29483244e-03f, 2.10745144e-03f, -2.21467577e-02f, -7.68751949e-02f, -1.50484275e-02f,
  -8.62257034e-02f, 3.41333710e-02f, -1.03523143e-01f, 1.18413125e-03f, 2.60535814e-02f, -2.87145358e-02f, 9.59090330e-03f, -3.66341658e-02f, -1.46469966e-01f, -4.01193090e-02f,
  -2.10871790e-02f, -7.49499798e-02f, -4.21193503e-02f, -7.02723786e-02f, 6.01496510e-02f, -7.16079921e-02f, 2.77407169e-02f, 6.54618964e-02f, 3.20459120e-02f, -2.83211432e-02f,
  2.65133321e-01f, -2.83965409e-01f, -3.15171421e-01f, 1.42488092e-01f, 9.07637030e-02f, 2.17951074e-01f, 1.84221655e-01f, 1.98853761e-02f, 6.88822493e-02f, 6.97661862e-02f,
  1.54952392e-01f, -2.14565113e-01f, -5.99798094e-03f, 1.85459420e-01f, 2.01817572e-01f, 4.08929996e-02f, 1.48906782e-01f, 8.77091363e-02f, -8.55144393e-03f, 8.31557158e-03f,
  7.45309517e-02f, 1.87461317e-01f, -1.79821029e-02f, -1.59634650e-01f, 1.21070325e-01f, -2.15173304e-01f, 1.08949356e-01f, -1.89850345e-01f, -1.31087512e-01f, 1.15211457e-02f,
  1.07814088e-01f, -2.12006941e-02f, -2.27558706e-02f, -7.17801228e-02f, -9.34975874e-03f, 3.98242213e-02f, -2.07029916e-02f, 5.31163253e-02f, -1.91676728e-02f, 4.19723652e-02f,
  4.99034161e-03f, -5.21833971e-02f, 4.37613204e-02f, -6.77985232e-03f, 1.76052749e-02f, -7.05468655e-02f, -1.17488774e-02f, -4.62674312e-02f, -5.58981970e-02f, -1.21391630e-02f,
  -2.41016541e-02f, -2.83461642e-02f, 7.88160414e-02f, -5.83465807e-02f, 3.76412040e-03f, -2.05158927e-02f, -2.80289464e-02f, -3.65862250e-02f, -4.13575694e-02f, -1.02499519e-02f,
  2.97779907e-02f, 3.96283604e-02f, 4.79935557e-02f, 1.08212614e-02f, 2.20809523e-02f, 2.08574757e-02f, 6.38104230e-03f, -2.49930248e-02f, -5.36370873e-02f, 2.99456511e-02f,
  -1.77625436e-02f, 2.83392542e-03f, 7.21860752e-02f, -4.37726453e-03f, 1.10961057e-01f, 2.10793335e-02f, -5.83048649e-02f, -5.29167280e-02f, 8.46688263e-03f, -7.55866989e-02f,
  -3.20749767e-02f, 1.48968259e-02f, 4.31756349e-03f, 3.89162004e-02f, 3.72027308e-02f, -3.31694409e-02f, 3.06951590e-02f, -7.05468133e-02f, 6.57248795e-02f, 3.35081406e-02f,
  -2.83746272e-02f, -1.18975118e-01f, -9.07720774e-02f, -4.07205150e-02f, -3.74407731e-02f, 3.77711430e-02f, 1.10052591e-02f, -6.03237003e-02f, -5.38760945e-02f, -1.99257340e-02f,
  8.95777345e-03f, 5.57817854e-02f, -2.49287151e-02f, -1.41645120e-02f, 1.03741614e-02f, 7.59173632e-02f, 1.71848538e-03f, 5.30688129e-02f, -6.78336294e-03f, 2.44850181e-02f,
  -3.34389135e-02f, 5.76327136e-03f, -4.57130522e-02f, 8.23437609e-03f, 3.87670584e-02f, 1.62001215e-02f, -5.60989156e-02f, -7.00743422e-02f, -1.84771530e-02f, -3.09541519e-03f,
  -3.52171749e-01f, -1.16355773e-02f, -1.11117668e-01f, -3.45144659e-01f, -1.43539965e-01f, -2.02018216e-01f, -3.15717936e-01f, -9.67003554e-02f, -2.96049505e-01f, 1.22979015e-01f,
  6.15877211e-02f, -1.96597040e-01f, 1.74809992e-01f, -2.44299069e-01f, -1.20465368e-01f, 1.14404351e-01f, -2.72399098e-01f, -9.61945802e-02f, -2.39744112e-02f, -1.70529425e-01f,
  -8.73954222e-02f, -1.28928125e-01f, 5.87750264e-02f, 7.46052787e-02f, -1.12354182e-01f, -4.56338674e-02f, 2.32199848e-01f, 1.21977195e-01f, 3.86392213e-02f, 3.02700303e-03f,
  -4.09213789e-02f, 6.36169547e-03f, -4.44422774e-02f, 4.19295020e-03f, -4.43634279e-02f, 2.89927609e-03f, 3.89775448e-02f, -5.58925867e-02f, -7.01816566e-03f, -2.61367541e-02f,
  -1.70700699e-02f, 3.50515288e-03f, -7.04807937e-02f, -2.48805117e-02f, -3.85850072e-02f, -3.48442569e-02f, -3.30357105e-02f, 9.33088479e-04f, -5.01437075e-02f, -1.88352764e-02f,
  -8.24232846e-02f, 9.53633897e-03f, -9.06409230e-03f, 4.53652465e-04f, 4.30966467e-02f, -2.02218555e-02f, -2.68342532e-02f, 4.30707000e-02f, 9.19605605e-03f, -4.23992574e-02f,
  -8.55356362e-03f, -5.67139946e-02f, -1.42960111e-02f, 4.02047262e-02f, -5.01253270e-02f, 4.15744632e-02f, -2.83957832e-02f, 8.39739963e-02f, 9.69413202e-03f, 9.76817589e-03f,
  -2.17748131e-03f, -5.99843748e-02f, -3.79280858e-02f, -5.03585078e-02f, 2.05133762e-03f, -2.62692608e-02f, -1.65142436e-02f, 4.03943546e-02f, -2.92496253e-02f, 4.55637015e-02f,
  3.81796695e-02f, -3.69964875e-02f, 6.74100444e-02f, 5.02161570e-02f, -3.00569106e-02f, 2.35210340e-02f, 5.20447195e-02f, -4.53444384e-03f, 8.18969402e-03f, -1.00445412e-02f,
  -6.52744621e-02f, -6.74397498e-02f, -2.21097637e-02f, -5.78213967e-02f, 4.65140166e-03f, -3.59959714e-02f, -6.25330433e-02f, -1.01058958e-02f, -5.12784021e-03f, -3.77740152e-02f,
  -5.35064377e-02f, -7.78878527e-03f, 4.15590778e-02f, 6.71684090e-03f, -1.52284047e-02f, 8.98936577e-03f, 4.78248447e-02f, 6.11068420e-02f, -6.81020273e-03f, 6.86260611e-02f,
  7.52803497e-03f, 1.25290584e-02f, -2.44036261e-02f, -2.94160582e-02f, -3.56349051e-02f, -7.77646294e-03f, -5.23875616e-02f, -1.78166828e-03f, 6.93325251e-02f, 4.41588461e-02f,
  4.34353650e-02f, 2.14130327e-01f, 5.87411113e-02f, -3.03055733e-01f, -5.45691252e-02f, 2.64478564e-01f, 3.78998071e-02f, 5.15513644e-02f, 9.86173153e-02f, 6.85215443e-02f,
  -1.46858767e-02f, -3.95751931e-02f, 7.32645467e-02f, 1.95228830e-02f, 6.94705695e-02f, 2.50380754e-01f, 7.22651854e-02f, 9.77881998e-03f, 1.29694462e-01f, -1.61467239e-01f,
  -4.02065627e-02f, -7.65634850e-02f, -1.12565123e-01f, -7.84979016e-02f, -1.07453629e-01f, -1.95089296e-01f, -1.53871849e-01f, -4.47494760e-02f, -1.94384351e-01f, 6.80325478e-02f,
  1.41283005e-01f, -2.20286604e-02f, -3.41234356e-02f, 4.16122973e-02f, 4.39528488e-02f, 1.80288181e-02f, -3.11647225e-02f, -3.44123691e-02f, 1.92760229e-02f, 1.57949589e-02f,
  1.35915987e-02f, -2.87598986e-02f, -5.26043624e-02f, -5.67109101e-02f, 4.55560312e-02f, -5.12047447e-02f, 4.80153412e-02f, 8.60303044e-02f, -4.72629145e-02f, -3.57345515e-03f,
  -5.22537939e-02f, -5.45740081e-03f, -6.59462661e-02f, -5.03800660e-02f, -9.63900611e-03f, 1.46835623e-02f, -1.05353515e-03f, -2.24557556e-02f, 5.28661497e-02f, 4.03215699e-02f,
  3.35458778e-02f, 2.36431621e-02f, -2.95225251e-02f, -1.60151180e-02f, -1.34195024e-02f, -1.93704851e-02f, 1.90724060e-03f, -5.95384799e-02f, 3.02088726e-03f, 3.72382216e-02f,
  5.86345652e-03f, 6.35221899e-02f, -2.07095146e-02f, 7.29521960e-02f, -3.15372646e-02f, -4.34569493e-02f, -3.67737538e-03f, -1.10280206e-02f, 2.54396163e-02f, -4.30341363e-02f,
  -3.09781842e-02f, 5.24301343e-02f, -4.71577495e-02f, 1.90995485e-02f, 7.09470585e-02f, 6.10688468e-03f, -3.97687815e-02f, 2.06487607e-02f, 3.74485478e-02f, -1.55403949e-02f,
  2.06957698e-01f, -4.58286107e-02f, -3.02592199e-02f, 2.77786758e-02f, 7.06898561e-03f, 2.06950400e-02f, 6.32033423e-02f, 3.30525227e-02f, -3.64914089e-02f, -4.67094928e-02f,
  4.76211868e-02f, 2.58030910e-02f, 2.85609905e-02f, 3.92498672e-02f, 6.73235431e-02f, 8.28457773e-02f, -1.02911249e-01f, -4.14119884e-02f, -2.46802275e-03f, -6.31269440e-02f,
  8.75235349e-03f, 3.25062964e-03f, -3.83263193e-02f, 3.13987136e-02f, 3.76947187e-02f, -5.76083027e-02f, -6.55697845e-03f, 3.02207991e-02f, 3.25156711e-02f, 2.11134776e-02f,
  2.94104069e-01f, 1.12067595e-01f, 1.61969483e-01f, 4.43410128e-03f, 1.96846370e-02f, -1.49361007e-02f, 1.61857992e-01f, 6.79554269e-02f, 2.80894428e-01f, -7.78849348e-02f,
  -1.15117684e-01f, 2.49120027e-01f, 7.81338513e-02f, -1.18682897e-02f, 1.46529064e-01f, 9.32984129e-02f, -2.28774715e-02f, 8.12473595e-02f, 8.01645443e-02f, 6.94948202e-03f,
  -2.58130301e-02f, -8.65845755e-02f, 1.87783428e-02f, -1.21120252e-01f, -8.93690959e-02f, -3.71248648e-02f, -2.07693070e-01f, 5.12106996e-03f, -1.73024252e-01f, 4.40304540e-02f,
  6.96684991e-04f, 3.56842205e-02f, 4.45758700e-02f, 4.91747558e-02f, -2.70996131e-02f, -6.03993088e-02f, -1.00730255e-01f, -3.57048512e-02f, 4.67812009e-02f, 3.77590880e-02f,
  6.24985360e-02f, -6.22483008e-02f, 5.73842740e-03f, 6.29935935e-02f, -8.57641362e-03f, -5.04454784e-02f, 3.45198438e-02f, -4.44674399e-03f, -7.06498371e-03f, 1.55144343e-02f,
  3.94756459e-02f, -9.65588540e-03f, -1.02432005e-01f, -8.82005692e-02f, 6.94553554e-02f, 3.68569419e-02f, 2.19999421e-02f, 4.39106636e-02f, 1.10964868e-02f, 5.33242412e-02f,
  4.67505753e-02f, 1.00474777e-02f, -9.19000246e-03f, 5.03564961e-02f, 1.58317070e-02f, 1.49814384e-02f, 1.60430036e-02f, 3.22937258e-02f, -7.61111174e-03f, 3.21176387e-02f,
  3.14754574e-03f, 7.61767998e-02f, -1.49233444e-02f, 5.16879074e-02f, 2.96399929e-02f, 5.95720001e-02f, -4.51518260e-02f, -2.66827364e-02f, -6.98807016e-02f, -4.89642844e-02f,
  2.05718484e-02f, -1.05424421e-02f, 5.52354082e-02f, -1.15405628e-02f, -2.76206005e-02f, -1.05565907e-02f, 1.78078134e-02f, -2.56857532e-03f, -5.25158085e-02f, 9.04109143e-03f,
  8.77436658e-04f, 3.63554992e-02f, 5.08541614e-02f, 4.54014875e-02f, -5.29942140e-02f, 4.40803804e-02f, 3.34663913e-02f, 9.41041298e-03f, 5.54317124e-02f, -1.12775909e-02f,
  -1.03055805e-01f, 1.42239267e-02f, -4.52496409e-02f, -1.98734161e-02f, -8.60570930e-03f, 4.34954986e-02f, -5.49537614e-02f, -2.03306787e-02f, -1.90372001e-02f, -4.59808037e-02f,
  -3.87987122e-02f, 6.07143715e-02f, -1.93245001e-02f, -1.39362291e-02f, -9.57211107e-02f, -2.14827042e-02f, 6.00797236e-02f, -7.55514055e-02f, -1.97749902e-02f, -2.34954804e-02f,
  -6.30602017e-02f, 1.11334011e-01f, 2.20754117e-01f, -1.10066094e-01f, -1.76255822e-01f, 4.59917858e-02f, 1.23234749e-01f, -1.62718296e-01f, -3.84327620e-01f, -3.60758565e-02f,
  -5.65039814e-02f, 1.25924379e-01f, 9.89692509e-02f, 8.91527161e-02f, 1.41757280e-01f, 9.71661434e-02f, 6.40714318e-02f, 5.84573559e-02f, -1.29476354e-01f, -3.86786228e-03f,
  -1.32648377e-02f, 2.66823936e-02f, 2.70270675e-01f, -6.19347058e-02f, -3.72179528e-03f, -4.93566729e-02f, -6.77649491e-03f, 9.16287526e-02f, 1.54612422e-01f, -1.18475489e-03f,
  -1.27253942e-02f, -1.67727545e-01f, 1.04047596e-01f, 1.00962177e-01f, 4.14428813e-03f, -1.38178440e-02f, 1.06560588e-01f, 8.27259123e-02f, -8.29318240e-02f, -7.76233524e-02f,
  -2.12545805e-02f, 7.04863220e-02f, -2.37895120e-02f, 5.05099185e-02f, 2.62049735e-02f, -1.58719718e-02f, -1.83329377e-02f, -1.90580375e-02f, -2.83858576e-03f, 7.80306533e-02f,
  8.11199658e-03f, 4.50744852e-02f, -4.65267785e-02f, 1.22211585e-02f, 1.67849287e-02f, -3.51885967e-02f, 6.39086915e-03f, 1.40907541e-01f, 4.08380888e-02f, -9.26415473e-02f,
  -1.40422871e-02f, 1.51999369e-02f, 2.60897502e-02f, -3.75668220e-02f, 2.30004620e-02f, 2.50823349e-02f, 5.31125702e-02f, 3.03375139e-03f, -4.74976040e-02f, -2.54118741e-02f,
  -6.30148351e-02f, -7.66444067e-03f, 1.89559907e-02f, -4.61874390e-03f, -7.16619641e-02f, 3.99616174e-02f, 1.22652417e-02f, -1.99443493e-02f, 1.85947190e-03f, -7.52681866e-03f,
  -6.65123612e-02f, 7.54991733e-03f, 6.29029870e-02f, 6.10777438e-02f, 5.66672720e-02f, -3.38585488e-02f, -2.55253725e-02f, 2.89353207e-02f, -3.26151922e-02f, 3.04925311e-02f,
  3.91931050e-02f, -1.01324156e-01f, -1.29692145e-02f, -2.04722248e-02f, 8.02395716e-02f, -1.64994914e-02f, -4.38416265e-02f, 4.44085011e-03f, -7.38039762e-02f, -7.44464516e-04f,
  3.16052698e-02f, -4.99498844e-02f, 4.18010131e-02f, 1.87736563e-02f, -8.07789434e-03f, -1.92890037e-02f, -2.35060751e-02f, -6.83697611e-02f, -1.67065933e-02f, 6.75629498e-03f,
  4.91835400e-02f, -6.30442938e-03f, 3.22253630e-02f, -5.88028617e-02f, 5.30989692e-02f, 5.17456755e-02f, -3.42468917e-02f, 2.52412315e-02f, 7.14581758e-02f, 8.03517327e-02f,
  -2.29485229e-01f, 1.37612462e-01f, 9.24633518e-02f, -4.51007672e-02f, 1.88794374e-01f, 1.45508274e-01f, -5.76937683e-02f, 3.04536909e-01f, 1.70392156e-01f, -2.24124677e-02f,
  -6.79006279e-02f, -1.83266193e-01f, -8.15034285e-02f, 8.52321759e-02f, -3.33165452e-02f, 2.42645685e-02f, 1.35080665e-01f, -7.32549801e-02f, 1.37182191e-01f, 6.42580539e-02f,
  3.40043753e-02f, 7.96704292e-02f, 2.82673305e-03f, 1.53996348e-01f, -2.77059283e-02f, 7.57859349e-02f, -9.82886553e-02f, 5.33078536e-02f, -4.65883315e-02f, -7.68512301e-03f,
  -1.05651714e-01f, 1.16298206e-01f, -2.98511945e-02f, -4.19430546e-02f, -4.36833575e-02f, -5.84675521e-02f, -1.08722389e-01f, -4.62704673e-02f, 6.59458414e-02f, 1.04187787e-01f,
  -5.91942221e-02f, 6.62772134e-02f, 6.51930124e-02f, -1.86486617e-02f, 9.43097696e-02f, 1.03562735e-01f, -8.68006051e-03f, -1.23233022e-02f, -5.40712550e-02f, 7.02814311e-02f,
  5.52330120e-03f, -2.29856409e-02f, -1.51137135e-03f, 5.98351546e-02f, -2.12925375e-02f, 3.24215628e-02f, 1.35791944e-02f, -1.76770817e-02f, 3.22822225e-03f, 8.42961594e-02f,
  2.16500424e-02f, -2.40956023e-02f, -8.40917975e-03f, 2.16513667e-02f, 6.02633227e-03f, 1.29233068e-02f, -2.97527201e-02f, -7.32996017e-02f, 4.56612073e-02f, -1.73415728e-02f,
  -1.50248902e-02f, 3.76206194e-03f, -1.85604692e-02f, 7.51611888e-02f, -5.84265254e-02f, 5.43343648e-02f, -2.03569327e-02f, 3.11403833e-02f, 5.50335832e-02f, 2.80234125e-02f,
  2.99399402e-02f, 2.28159223e-02f, 2.16308348e-02f, -4.53118561e-03f, -2.98567377e-02f, 3.18243913e-02f, 2.11727247e-02f, 6.21611401e-02f, 3.02430540e-02f, -3.88010740e-02f,
  -8.75425190e-02f, 7.07904696e-02f, 4.97882105e-02f, -6.87845722e-02f, 3.54386531e-02f, -1.08426567e-02f, 2.38800757e-02f, -3.75644565e-02f, 8.42314307e-03f, -2.42851302e-02f,
  -1.36297280e-02f, -4.79852892e-02f, -8.56752917e-02f, -6.56539202e-02f, -2.13464610e-02f, -1.51620982e-02f, 1.22491373e-02f, 3.30111273e-02f, -4.54728305e-03f, 4.89278398e-02f,
  -2.29931902e-02f, -8.56652018e-03f, -6.87666051e-03f, 1.30615490e-05f, 4.96131517e-02f, -1.23931523e-02f, -6.92207227e-03f, -4.71462719e-02f, -9.16144531e-03f, 3.26712132e-02f,
  -8.15800205e-02f, 3.45870703e-01f, -1.31469220e-01f, 1.24254368e-01f, -8.62998292e-02f, -1.22233987e-01f, -6.12437204e-02f, 3.64224464e-02f, -6.69263974e-02f, 1.51032463e-01f,
  4.53120247e-02f, 1.16086282e-01f, -1.11234963e-01f, 3.52524817e-02f, -1.85848683e-01f, -1.56674981e-02f, 1.40837446e-01f, -7.79915601e-03f, -2.52146441e-02f, 1.74774885e-01f,
  4.55751643e-03f, 6.70002028e-02f, 3.04813124e-02f, 1.55730769e-01f, 9.72987246e-03f, 1.46830425e-01f, 1.06723182e-01f, 3.42639955e-03f, 3.77797969e-02f, -1.08379714e-01f,
  1.06308408e-01f, 6.84274361e-02f, 6.16808906e-02f, 8.01166967e-02f, 1.46576781e-02f, 5.00902124e-02f, 1.40366424e-02f, -7.95126557e-02f, 2.98363678e-02f, -5.08120507e-02f,
  -5.45960143e-02f, -4.55218516e-02f, 4.20656614e-02f, -1.42770009e-02f, 5.99821135e-02f, 4.39097583e-02f, -3.21220569e-02f, 5.89439049e-02f, -5.91903888e-02f, -6.00603409e-02f,
  2.95738410e-02f, 2.76904944e-02f, -2.15506852e-02f, 2.22455338e-02f, 4.38940153e-02f, 1.16779422e-02f, -5.44744059e-02f, 2.42747972e-03f, 6.65004551e-02f, -9.89913661e-03f,
  6.78884462e-02f, 5.90839274e-02f, -5.24514937e-04f, -6.74503073e-02f, -3.15776207e-02f, -3.68948616e-02f, 7.46619552e-02f, -5.57388030e-02f, 4.07497883e-02f, -1.33177228e-02f,
  -2.29358915e-02f, 2.81015579e-02f, -1.79038048e-02f, 3.78782004e-02f, -4.36116047e-02f, 3.43538634e-02f, -3.52512673e-02f, -5.98191805e-02f, -1.90878063e-02f, -5.82421385e-03f,
  -2.98793316e-02f, -1.25325480e-02f, -4.56048321e-04f, 5.42880595e-02f, 7.39987940e-02f, 2.66463291e-02f, -1.78340077e-02f, -3.40317860e-02f, 3.97848897e-02f, 3.75167537e-03f,
  3.09507340e-01f, 3.93393010e-01f, 6.84209019e-02f, 5.35547733e-02f, 3.78609858e-02f, 9.19140279e-02f, 5.84903285e-02f, 1.55855538e-02f, 1.07798599e-01f, 2.87633184e-02f,
  5.69774918e-02f, -3.04515939e-02f, 2.11914143e-04f, -2.30721757e-02f, 1.41602252e-02f, -6.83138054e-03f, 7.28809834e-02f, 1.07914597e-01f, 1.24694832e-01f, 5.53519875e-02f,
  1.12622995e-02f, -2.39013620e-02f, -2.71622259e-02f, -2.28634719e-02f, 4.25594039e-02f, 3.43324319e-02f, 9.57797915e-02f, -4.47202437e-02f, -2.13153698e-02f, 5.19054644e-02f,
  -2.28795648e-01f, 2.52147447e-02f, 5.98893967e-03f, 1.17842411e-03f, -1.29089326e-01f, -9.22805965e-02f, -2.38201041e-02f, -4.19165794e-04f, 1.34573266e-01f, 2.06648782e-01f,
  9.27728638e-02f, -5.57591692e-02f, 2.04257160e-01f, -1.33203670e-01f, -3.88077527e-01f, 9.71175805e-02f, -2.00070873e-01f, -3.61742079e-02f, 1.98625885e-02f, -3.93393040e-02f,
  -1.30448788e-01f, -1.58865809e-01f, -6.02993108e-02f, 4.07848544e-02f, -1.25142917e-01f, -9.11135972e-03f, -7.41282254e-02f, 7.17973486e-02f, -2.01926664e-01f, -1.94212869e-01f,
  -1.04625039e-01f, 4.44960892e-02f, 5.95918521e-02f, 8.70239269e-03f, 2.22679581e-02f, -3.89734022e-02f, -3.80885005e-02f, -1.23004150e-02f, -2.33037397e-02f, 4.80249040e-02f,
  1.13308644e-02f, -1.44177657e-02f, 1.31991971e-02f, 2.55938862e-02f, -3.64009961e-02f, -5.95947169e-03f, -7.06314519e-02f, 3.17546651e-02f, 6.69635534e-02f, 5.97137026e-03f,
  5.81153035e-02f, -6.73177317e-02f, 4.38109525e-02f, 1.91339049e-02f, 1.43414661e-02f, -8.52514897e-03f, -1.94689129e-02f, -2.64395270e-02f, -1.87757816e-02f, -9.38503817e-02f,
  -4.18041386e-02f, 2.54124962e-02f, 7.06279874e-02f, -1.30361672e-02f, 2.87372135e-02f, 3.35947727e-03f, 2.18611918e-02f, -1.18572107e-02f, 1.26844980e-02f, 6.33167429e-03f,
  -9.72952321e-03f, 3.06175984e-02f, 6.18640054e-03f, -1.44938780e-02f, 1.99723011e-03f, 5.39692231e-02f, 4.58422564e-02f, 4.18275548e-03f, 2.43619028e-02f, -3.15901712e-02f,
  7.65271708e-02f, -7.53920642e-04f, 5.59352897e-02f, -5.63062616e-02f, 3.97017822e-02f, 1.70256216e-02f, 1.58045045e-03f, -4.18774299e-02f, 1.94109045e-02f, 4.40660641e-02f,
  -6.84474930e-02f, 2.58903503e-02f, 6.93052337e-02f, 1.17254686e-02f, -1.65895000e-02f, 2.23768707e-02f, -2.89091505e-02f, -4.52100523e-02f, -3.00304014e-02f, 1.94881931e-02f,
  2.53830012e-02f, 9.66332667e-03f, -4.10790108e-02f, -7.65826851e-02f, 2.75634155e-02f, -6.81489110e-02f, 1.05296215e-02f, 3.54234055e-02f, -5.31497262e-02f, -8.95043686e-02f,
  -8.08800757e-03f, 2.73956582e-02f, -4.93989214e-02f, 1.49765210e-02f, -3.99319502e-03f, -5.28783677e-03f, 4.93110437e-03f, 9.91579890e-03f, -8.34434703e-02f, -3.08781154e-02f,
  -1.81010932e-01f, 2.70278841e-01f, -2.79574506e-02f, 9.13996100e-02f, -1.13802373e-01f, 2.06851959e-01f, 4.94216979e-02f, 1.04590744e-01f, 1.53130731e-02f, 1.36366099e-01f,
  -1.03104615e-03f, 7.69914016e-02f, -1.35475723e-03f, 2.46984109e-01f, -7.83882067e-02f, 1.86714157e-01f, 2.23189950e-01f, 1.09603226e-01f, 2.89544929e-02f, -1.07175954e-01f,
  -5.95886819e-02f, 7.58017823e-02f, 1.29998162e-01f, -5.75728789e-02f, 4.14592586e-02f, -9.20860022e-02f, -2.31724769e-01f, -9.91360173e-02f, -4.82752081e-03f, 2.16181185e-02f,
  8.94546567e-04f, -1.38217464e-01f, -2.68518105e-02f, -9.46624577e-02f, -1.11024871e-01f, -3.11496444e-02f, -7.82220513e-02f, -2.61004567e-02f, -5.43206669e-02f, 1.50239337e-02f,
  5.46336435e-02f, 2.53572930e-02f, 3.71813960e-02f, -4.49867696e-02f, 1.04904249e-02f, 3.82381454e-02f, 1.11962706e-01f, 7.05926046e-02f, -1.71233714e-02f, 6.23475015e-02f,
  8.84072483e-02f, 5.13485447e-02f, -6.30038185e-03f, 7.82149360e-02f, -4.88687456e-02f, 7.39853755e-02f, 2.31110882e-02f, -4.47004586e-02f, -8.35888553e-03f, -8.47935118e-03f,
  -1.26099465e-02f, 2.00652461e-02f, 2.36799922e-02f, 3.12272441e-02f, 6.78918930e-03f, 1.31995566e-02f, 8.06293264e-02f, 1.29608368e-03f, -3.35162468e-02f, 7.81366080e-02f,
  -1.20754186e-02f, -4.21733456e-03f, 1.67232919e-02f, 5.25326915e-02f, -5.84453829e-02f, -1.91007759e-02f, 1.40628712e-02f, -1.87627543e-02f, 3.85447964e-02f, 8.87708589e-02f,
  -1.15063079e-02f, -6.47807345e-02f, 6.23014569e-02f, -4.30231988e-02f, 4.82487381e-02f, 4.94742440e-03f, -1.60694756e-02f, 3.19274627e-02f, 4.78145704e-02f, -7.60542694e-03f,
  -9.76160765e-02f, -1.79293528e-01f, -7.86031634e-02f, 1.87806804e-02f, 1.75505027e-03f, 2.50213612e-02f, 4.43313830e-02f, -1.88271370e-05f, -1.16913607e-02f, -3.51027511e-02f,
  -1.92275476e-02f, -3.40920836e-02f, -2.09441297e-02f, 7.20618106e-03f, -3.06493398e-02f, 1.20970225e-02f, -1.74342506e-02f, -3.97719294e-02f, 2.46724039e-02f, -2.72986367e-02f,
  -2.50155628e-02f, -4.75479178e-02f, -1.44171016e-02f, -4.22761180e-02f, 1.28397066e-02f, -9.43640247e-02f, -1.69755984e-02f, 2.90961761e-04f, 6.22587930e-03f, 9.20498669e-02f,
  -1.76089942e-01f, 2.91957438e-01f, 4.12188098e-02f, 2.49628928e-02f, -1.86896339e-01f, -4.18961383e-02f, 1.66059464e-01f, -2.66859774e-02f, 2.95406226e-02f, 2.35842720e-01f,
  1.83461040e-01f, 9.39733684e-02f, 1.95999175e-01f, 2.34558940e-01f, -5.53407415e-04f, 2.88532555e-01f, 1.57335773e-01f, 6.23458326e-02f, 3.94216403e-02f, 1.07316390e-01f,
  2.33847126e-02f, 6.15342818e-02f, 1.01188846e-01f, 5.13991565e-02f, -8.92839134e-02f, -8.08155239e-02f, -4.47282847e-03f, -1.87665445e-03f, -3.83545682e-02f, -7.09070936e-02f,
  -1.02163389e-01f, 9.51274633e-02f, -2.77988687e-02f, -3.62831652e-02f, -1.66714918e-02f, -1.72432289e-02f, -5.74791105e-03f, -5.86215705e-02f, -7.88766220e-02f, -5.89182228e-03f,
  8.97836220e-03f, -3.76288444e-02f, -2.93045398e-02f, -1.73700731e-02f, -1.14278786e-01f, -8.55694860e-02f, -1.45755596e-02f, -8.48030820e-02f, -2.01244210e-03f, -4.25246842e-02f,
  -2.45531425e-02f, 5.18797077e-02f, 1.57139786e-02f, 9.29844826e-02f, 4.63358015e-02f, -4.50706147e-02f, 5.72519489e-02f, -2.05745436e-02f, -2.50290316e-02f, -8.36827457e-02f,
  -3.07534020e-02f, -1.21690445e-02f, 6.73808530e-02f, -9.13144872e-02f, 6.18876368e-02f, -3.93623067e-03f, 3.06660086e-02f, -2.47010197e-02f, -1.86990332e-02f, 6.90541463e-03f,
  -4.29578461e-02f, -2.51838677e-02f, -8.06065127e-02f, 1.36621781e-02f, 2.72413921e-02f, -2.48109549e-02f, -5.61460815e-02f, -5.80574386e-03f, -2.31574997e-02f, -1.71017274e-02f,
  -1.67395268e-02f, 5.91054000e-02f, -2.13474836e-02f, 5.74895088e-03f, 1.41478181e-02f, -3.69587156e-04f, 6.36262372e-02f, -2.09679417e-02f, -1.03479935e-04f, -3.65566537e-02f,
  1.71825439e-01f, 3.46916884e-01f, 1.88293569e-02f, -1.00678355e-02f, 3.05195451e-02f, -8.82619247e-02f, 1.00419940e-02f, -6.01368509e-02f, 8.71860236e-02f, 2.78569874e-03f,
  -5.36918640e-02f, 5.21333283e-03f, -4.14946228e-02f, 3.18269916e-02f, 6.11612573e-02f, 9.13272351e-02f, 9.10667554e-02f, -1.34117752e-02f, -8.44866037e-03f, 2.80771218e-02f,
  2.56727096e-02f, -3.59462164e-02f, -1.48701649e-02f, -4.52546813e-02f, -1.06234942e-02f, 6.60303086e-02f, -7.02676550e-02f, 6.43852800e-02f, 3.53326760e-02f, 2.13757530e-03f,
  -7.62756914e-02f, 1.20073967e-01f, -1.87519804e-01f, -1.43039301e-01f, -9.94176269e-02f, -2.19555542e-01f, -1.84278056e-01f, -1.78325221e-01f, -3.33034873e-01f, 1.62172437e-01f,
  1.00029998e-01f, 4.55849618e-02f, 6.88008144e-02f, 1.68019116e-01f, -1.06121533e-01f, 3.54803652e-02f, 7.91978240e-02f, 7.30490237e-02f, -3.28405909e-02f, -6.57386184e-02f,
  -1.62799671e-01f, 1.62518173e-01f, 4.35525812e-02f, 1.60781279e-01f, 2.66848411e-03f, 9.33156312e-02f, 2.22115710e-01f, -3.49022471e-03f, 1.84480488e-01f, -1.64929852e-02f,
  -5.76793663e-02f, 1.83552913e-02f, -3.88302840e-02f, 1.78630166e-02f, -7.51113519e-02f, -5.54715842e-02f, 1.54165998e-02f, 3.43687609e-02f, -3.65345143e-02f, -8.03056881e-02f,
  2.57135220e-02f, 3.04216500e-02f, 5.99992741e-03f, -1.45450765e-02f, -3.18879038e-02f, -4.80146594e-02f, -2.72688679e-02f, 1.72863193e-02f, 1.52644794e-02f, 2.80999057e-02f,
  -7.46176317e-02f, -6.39425218e-02f, -7.35621974e-02f, -1.84400426e-03f, -6.25621602e-02f, 1.57218929e-02f, 3.62911448e-02f, -5.22584133e-02f, -5.13256118e-02f, 2.48298366e-02f,
  -4.81221750e-02f, -2.43642814e-02f, -1.43675664e-02f, -4.24509384e-02f, 4.37940843e-03f, -7.66668245e-02f, 6.45636097e-02f, -2.36713272e-02f, 3.24993394e-02f, 6.56237528e-02f,
  -1.77400727e-02f, -2.04466544e-02f, 1.64304837e-03f, -6.71357512e-02f, 7.62289613e-02f, -7.53615201e-02f, -3.16812657e-02f, 3.58001678e-04f, -5.36228232e-02f, -1.17074791e-02f,
  -3.84966880e-02f, -6.66333959e-02f, 7.00482503e-02f, -3.54982540e-02f, -5.86878508e-02f, -3.00044585e-02f, 3.23459432e-02f, -2.19989549e-02f, -4.77772346e-03f, 6.40769303e-03f,
  4.75069173e-02f, 4.74309810e-02f, 9.26244035e-02f, 3.12099513e-02f, 1.20432772e-01f, 9.39018577e-02f, 4.42992970e-02f, -6.62191957e-02f, -7.98282120e-03f, 2.88161654e-02f,
  1.59406569e-02f, 1.78274270e-02f, 3.95119339e-02f, -4.95493636e-02f, 1.25428736e-02f, -1.67515147e-02f, -2.42095944e-02f, 3.68400104e-02f, 2.46370696e-02f, 3.06326356e-02f,
  6.50655404e-02f, -4.98569757e-02f, -3.36014410e-03f, -8.99636559e-03f, 9.63396393e-04f, -2.09995043e-02f, 2.97477935e-02f, 6.44463487e-03f, 2.46560597e-03f, -2.32867543e-02f,
  -9.39816982e-02f, 4.68288474e-02f, -9.39106718e-02f, -8.32931623e-02f, 4.99196015e-02f, 1.37037545e-01f, -1.29125908e-01f, 1.94172189e-01f, 9.66192558e-02f, 4.34707850e-03f,
  -3.24163102e-02f, -2.42373034e-01f, -1.50683165e-01f, -3.89038548e-02f, 7.06123114e-02f, -7.70115778e-02f, 1.28764153e-01f, 6.01946786e-02f, 5.91328889e-02f, 9.20570418e-02f,
  1.10824153e-01f, 1.28462180e-01f, -9.62715447e-02f, 1.98646918e-01f, -1.01567961e-01f, -6.50387853e-02f, 2.52607130e-02f, -7.93681294e-02f, 6.74534515e-02f, -6.45582825e-02f,
  1.16718933e-01f, -5.77796176e-02f, -1.33143738e-01f, -4.34589051e-02f, 9.56573635e-02f, -4.66436483e-02f, -6.07838668e-02f, -2.96555012e-02f, -1.07730307e-01f, 6.27104416e-02f,
  -5.47261536e-02f, -4.20068614e-02f, 9.05046463e-02f, 4.25095595e-02f, 8.64641070e-02f, -1.37464767e-02f, -1.90474349e-03f, 6.11624159e-02f, 2.00338964e-03f, 3.74660678e-02f,
  -4.44556251e-02f, 2.35688966e-02f, 3.08089722e-02f, 4.61155400e-02f, -3.12027726e-02f, 6.83462899e-03f, -1.97289586e-02f, -4.43396121e-02f, -5.54948347e-03f, 4.15590033e-02f,
  1.08076289e-01f, 9.51929912e-02f, 5.56589440e-02f, 2.51270533e-02f, -9.40844975e-03f, 4.32032458e-02f, 1.84569117e-02f, -2.69311443e-02f, -9.83401462e-02f, 3.77598926e-02f,
  -1.76003277e-02f, -4.47729044e-02f, -1.27475122e-02f, -5.94250001e-02f, 6.65706098e-02f, 3.50548215e-02f, -4.18339707e-02f, 3.47611494e-02f, 6.97440654e-02f, -5.68033941e-02f,
  4.01795991e-02f, 4.14913297e-02f, 1.64165571e-02f, 2.91199349e-02f, 6.39607683e-02f, -2.74742693e-02f, 8.19362178e-02f, -1.02804881e-03f, -8.30466002e-02f, -2.61642523e-02f,
  2.11476371e-01f, 2.59682417e-01f, 5.70252202e-02f, -4.34867069e-02f, -2.24745907e-02f, 8.43765810e-02f, -2.13334654e-02f, 4.14800644e-03f, 1.13298945e-01f, 6.35169297e-02f,
  9.61111020e-03f, 3.58751118e-02f, 3.87926959e-02f, -8.70600790e-02f, -6.10746183e-02f, 7.41094649e-02f, -3.90494205e-02f, 5.64313820e-03f, 9.33562741e-02f, -6.14513457e-03f,
  3.38449972e-05f, -3.71090770e-02f, 1.79843865e-02f, 3.67865451e-02f, 3.24246287e-02f, 3.08284163e-02f, -1.61732845e-02f, -6.40354753e-02f, -7.61712296e-03f, 5.92108890e-02f,
  -3.25489759e-01f, -1.11474115e-02f, -1.91810057e-01f, -2.75625497e-01f, -1.29932344e-01f, 1.06639192e-01f, 2.30016902e-01f, -1.68722019e-01f, -9.29581467e-03f, 1.51248589e-01f,
  7.96997920e-02f, -2.21736893e-01f, 3.22741389e-01f, -3.91312875e-02f, 1.75519870e-03f, 2.22724259e-01f, -3.50632481e-02f, -4.39498434e-03f, -2.18136758e-02f, -1.29591987e-01f,
  -1.58137500e-01f, 1.19335629e-01f, 3.41839939e-02f, -9.27059874e-02f, -1.56960741e-01f, -2.11118892e-01f, 5.19666448e-02f, 2.82901991e-02f, -7.74969980e-02f, 6.89270124e-02f,
  1.23654269e-02f, 2.03148965e-02f, 4.17827815e-02f, -3.89221124e-02f, -5.64924404e-02f, 7.81595148e-03f, -1.13763604e-02f, 8.58322084e-02f, 3.46561000e-02f, 2.68123038e-02f,
  -1.83074307e-02f, -9.41834077e-02f, -8.01019222e-02f, -3.72281969e-02f, 1.44870542e-02f, -6.51393682e-02f, -3.96380499e-02f, 5.67195602e-02f, -5.36362007e-02f, -1.22014433e-01f,
  -8.74510407e-02f, -5.44814877e-02f, -2.82436935e-03f, 3.25200744e-02f, 4.92213340e-03f, -9.20576230e-03f, -5.95246768e-03f, -9.94334463e-03f, -8.52337033e-02f, -9.14450642e-03f,
  -1.77131407e-02f, 4.23262417e-02f, -8.23210478e-02f, -2.61588078e-02f, 5.98341273e-03f, -2.69661145e-03f, -3.28097753e-02f, -4.81389463e-02f, -4.80044484e-02f, 8.53488222e-02f,
  -4.15807590e-02f, 1.56969819e-02f, -5.78159504e-02f, 1.47325443e-02f, 1.61038991e-02f, 5.22486307e-03f, 2.01379750e-02f, -2.84813624e-02f, 6.86850324e-02f, 1.53237544e-02f,
  2.26491671e-02f, -1.33594302e-02f, 4.96567711e-02f, -4.01422307e-02f, 1.49265761e-02f, 3.25300395e-02f, 1.25526229e-03f, -6.20335080e-02f, 1.24169770e-03f, 1.16224112e-02f,
  1.57420486e-01f, 2.22442728e-02f, 3.03474851e-02f, 1.49370711e-02f, 8.56983289e-02f, 3.79352681e-02f, 5.43707749e-03f, -3.46782431e-02f, 3.74907665e-02f, -4.04546522e-02f,
  5.40068233e-03f, 3.57345156e-02f, -2.68960744e-02f, 4.67559174e-02f, 1.09876841e-01f, -5.17660379e-03f, -1.11805694e-02f, -3.50240595e-03f, 1.85386147e-04f, -6.53388873e-02f,
  -2.04075477e-03f, 3.08978185e-02f, -1.51956659e-02f, -3.43474373e-02f, -1.37999076e-02f, -1.02855843e-02f, -1.44788390e-02f, 1.28781796e-02f, -8.14074464e-03f, -6.24398608e-03f,
  1.14206374e-01f, -5.77666946e-02f, 2.83081859e-01f, -1.95877217e-02f, -1.70368716e-01f, -1.50910512e-01f, -1.32395595e-01f, -8.87408257e-02f, -2.01990828e-01f, -1.62439033e-01f,
  -1.24546252e-01f, 9.40342844e-02f, 3.13377604e-02f, -1.39035657e-01f, 1.35557011e-01f, 7.04244077e-02f, -7.15098381e-02f, -8.85785371e-02f, 6.18897751e-03f, -4.47479561e-02f,
  1.99235603e-02f, -2.48177573e-01f, 2.06712738e-01f, -1.35218978e-01f, -1.16790965e-01f, 7.37756267e-02f, 9.56757590e-02f, 6.34506792e-02f, -1.08776011e-01f, 5.95192872e-02f,
  2.64758919e-03f, 1.72136277e-02f, 1.84348207e-02f, -4.23067473e-02f, 4.59177494e-02f, 5.91485761e-02f, 3.74404341e-02f, 1.04259960e-01f, -1.01596294e-02f, -4.14882302e-02f,
  2.21993271e-02f, 3.51156406e-02f, -1.08947136e-01f, 8.63586552e-03f, -1.11255515e-02f, 2.83274129e-02f, -1.97436064e-02f, 7.38808513e-02f, -8.70288163e-02f, 2.07351218e-03f,
  2.76521035e-02f, 5.47025390e-02f, -1.31483283e-02f, 6.64362684e-02f, 6.54327944e-02f, 2.78844237e-02f, -1.87369883e-02f, -1.90218464e-02f, 3.73950694e-03f, 2.28991844e-02f,
  4.22920026e-02f, -6.84282705e-02f, 3.93806100e-02f, 4.33343686e-02f, -3.41002941e-02f, 7.28759766e-02f, -4.99494281e-03f, 2.15488467e-02f, 9.49193835e-02f, -2.79561449e-02f,
  7.22059309e-02f, 2.64506657e-02f, 2.35732808e-03f, -5.36033213e-02f, 7.05385804e-02f, -4.12927382e-02f, 4.62868996e-02f, -7.01485425e-02f, -5.88994659e-02f, 2.48488653e-02f,
  5.31998649e-02f, -3.80662829e-02f, -1.23822261e-02f, -1.94412712e-02f, 5.10701574e-02f, -2.68870387e-02f, -1.10539803e-02f, 4.00496349e-02f, -3.16028781e-02f, 3.82852778e-02f,
  -4.94561754e-02f, -9.50555578e-02f, -2.49263961e-02f, -8.56260657e-02f, 1.76901929e-02f, -5.30533493e-02f, 2.30334867e-02f, 7.64042698e-03f, 5.60469031e-02f, 9.91200190e-03f,
  6.43213987e-02f, 1.06800403e-02f, -4.55608368e-02f, 6.49621710e-03f, -4.64653187e-02f, -3.62287834e-03f, 2.88958345e-02f, 4.27152812e-02f, -4.80503701e-02f, 3.57435159e-02f,
  1.15807271e-02f, -6.26165569e-02f, -1.01910718e-02f, -7.37952888e-02f, -6.35842606e-02f, -1.23182377e-02f, -7.22845644e-03f, -1.22479312e-02f, -3.96130159e-02f, -5.94932511e-02f,
  -2.48914272e-01f, 3.17380130e-01f, -9.32458490e-02f, 5.74182011e-02f, -1.19361319e-01f, -1.12635352e-01f, -2.18475863e-01f, 1.58201665e-01f, 1.02941673e-02f, 2.58840889e-01f,
  -1.04705067e-02f, 7.01296479e-02f, -5.99389337e-02f, 8.82407129e-02f, -1.42339006e-01f, -5.19229472e-02f, 2.12639436e-01f, 1.29745588e-01f, -5.09530716e-02f, 1.56586871e-01f,
  -1.94303170e-02f, 5.13125174e-02f, 2.62270384e-02f, 1.65103763e-01f, 8.88916757e-03f, 6.85576797e-02f, 1.97344616e-01f, -9.79237109e-02f, 2.16551617e-01f, 2.37051751e-02f,
  1.69795752e-02f, -4.71830927e-02f, -1.18792944e-01f, -3.70203480e-02f, -5.18857092e-02f, -2.79949121e-02f, -7.24591613e-02f, -7.89793283e-02f, -2.68315757e-03f, 7.59983249e-03f,
  1.03704566e-02f, -1.35183828e-02f, -1.26063637e-02f, -2.54155137e-02f, 4.97278385e-02f, 1.34320674e-03f, -6.71067983e-02f, -4.81643975e-02f, 8.03207885e-03f, -6.73624314e-03f,
  1.59188844e-02f, 1.87603422e-02f, 3.28292698e-02f, 1.97818018e-02f, -3.29237282e-02f, -2.66945288e-02f, 2.18695849e-02f, -2.34191827e-02f, 8.12022388e-02f, 7.80999362e-02f,
  8.99984539e-02f, 8.34481232e-03f, -3.39334682e-02f, 8.85132293e-04f, -4.65642586e-02f, -5.01984246e-02f, -2.26908922e-02f, -7.71297421e-03f, -3.10756676e-02f, -2.40923297e-02f,
  -1.86076649e-02f, -2.35950053e-02f, 5.03096730e-02f, 2.50328388e-02f, 1.87894758e-02f, -2.40882896e-02f, 2.19055042e-02f, 2.45641991e-02f, 1.77167766e-02f, -3.73531953e-02f,
  4.16847728e-02f, 1.53744929e-06f, -2.11257208e-02f, 2.19828952e-02f, -3.83259803e-02f, 3.77167314e-02f, 1.58455204e-02f, 2.22092438e-02f, 3.73963974e-02f, 1.14234323e-02f,
  1.65667400e-01f, 2.12105110e-01f, 6.50873259e-02f, 6.67212456e-02f, 3.80426981e-02f, -5.79318143e-02f, 5.13662621e-02f, 3.14815789e-02f, 1.68318059e-02f, -6.55149668e-03f,
  3.48675251e-02f, 1.65792257e-02f, 1.92067400e-02f, 4.83600609e-02f, 5.22723906e-02f, 2.02552062e-02f, 6.92079589e-02f, 3.89236547e-02f, -1.68636441e-02f, 4.99116406e-02f,
  -1.57587882e-02f, 4.42749821e-02f, 3.83535540e-03f, -4.03782241e-02f, 3.45966816e-02f, 3.36812660e-02f, 1.40382219e-02f, 5.08448258e-02f, 4.96053249e-02f, 1.80672593e-02f,
  4.45047803e-02f, -1.14526697e-01f, 3.55461121e-01f, 1.16569608e-01f, 3.50793786e-02f, 3.57141122e-02f, 6.68440685e-02f, -9.23810825e-02f, -8.91931430e-02f, -3.77963543e-01f,
  -1.40729263e-01f, 8.63968283e-02f, -2.18478311e-02f, -1.23529390e-01f, 3.59417617e-01f, 3.59227136e-02f, -6.73964545e-02f, -9.82920453e-02f, 5.47258705e-02f, -1.10603638e-01f,
  1.16109386e-01f, -2.62469977e-01f, 2.47552678e-01f, -1.20872527e-01f, 3.92233990e-02f, 8.13958421e-02f, 1.58543345e-02f, 8.46581161e-02f, -5.11404015e-02f, 2.35623978e-02f,
  9.54015329e-02f, -8.51054564e-02f, 1.02349937e-01f, 7.20398352e-02f, -7.77828023e-02f, 3.28068761e-03f, -2.60648616e-02f, 1.27255887e-01f, 7.10982978e-02f, 1.87017815e-03f,
  6.84323534e-03f, 1.79800559e-02f, -4.37637866e-02f, 3.56881134e-02f, -7.32975006e-02f, -1.68238226e-02f, 3.28922570e-02f, 7.56251067e-02f, 2.65519302e-02f, 1.11303881e-01f,
  -8.87584966e-03f, -6.08212575e-02f, 1.75384935e-02f, 3.17812711e-03f, 1.24476172e-01f, 2.48947553e-02f, 5.10424189e-02f, 9.20170825e-03f, -5.16543223e-05f, 5.28698862e-02f,
  -7.03352839e-02f, -2.03665197e-02f, -3.57526168e-02f, 2.31218114e-02f, 5.21926321e-02f, -2.37068031e-02f, -3.29936109e-03f, 1.09668926e-03f, 6.64600581e-02f, -1.89788938e-02f,
  1.18587539e-02f, 1.24984523e-02f, -6.12301528e-02f, 2.34410409e-02f, -3.53339389e-02f, 2.45989356e-02f, 3.33404578e-02f, -2.52030678e-02f, -3.97461392e-02f, 8.34098980e-02f,
  -2.13664640e-02f, 4.49035913e-02f, -5.13452441e-02f, -2.23107710e-02f, -4.73066382e-02f, 2.90741622e-02f, -2.60460805e-02f, 5.35415951e-03f, -4.30753082e-03f, 4.23874669e-02f,
  -1.35073975e-01f, -1.76836982e-01f, -5.13947979e-02f, -5.17731495e-02f, -4.88539226e-03f, -1.18404999e-03f, -8.71447101e-03f, -9.59358588e-02f, -2.03303490e-02f, -6.52215630e-02f,
  -7.27642626e-02f, -3.36737819e-02f, 2.88777538e-02f, -6.60220832e-02f, 9.11185592e-02f, -1.67129131e-03f, -4.85350378e-02f, -3.82751934e-02f, -4.24018577e-02f, -6.73929304e-02f,
  1.19073223e-02f, -4.95550781e-02f, -8.45729187e-03f, 2.92579848e-02f, -1.04711302e-01f, -3.74497324e-02f, 2.10719425e-02f, 6.56055287e-02f, 3.78297158e-02f, -5.53066842e-02f,
  6.78187832e-02f, 2.98256730e-03f, -1.49798229e-01f, 4.16011810e-02f, 6.46334961e-02f, 4.53986377e-02f, 2.03339681e-02f, -3.99055406e-02f, -9.86622870e-02f, 2.11732477e-01f,
  7.60607943e-02f, 1.86772287e-01f, -1.54216602e-01f, 1.30934060e-01f, -1.34314865e-01f, -2.29506791e-01f, 3.33621204e-02f, 1.47392094e-01f, -1.30574435e-01f, 1.52234435e-01f,
  -1.38193429e-01f, 5.25472686e-02f, -9.23328921e-02f, 1.62372850e-02f, 1.85208246e-01f, -3.09836920e-02f, 4.84359004e-02f, -7.31245503e-02f, 2.39016861e-01f, 6.94380477e-02f,
  8.27942118e-02f, 1.81174930e-02f, -2.56685279e-02f, -9.54300538e-02f, -2.42217574e-02f, 5.40668480e-02f, 7.97602683e-02f, 7.72828460e-02f, -5.24869487e-02f, 1.53570892e-02f,
  8.47507715e-02f, -9.77072679e-03f, 1.18749989e-02f, -3.82658020e-02f, 9.52972472e-02f, -8.23646337e-02f, -5.83444871e-02f, -4.80942652e-02f, 2.38416512e-02f, -6.54235631e-02f,
  -3.52481566e-02f, 2.21952442e-02f, -4.10904549e-03f, 5.44357412e-02f, -4.46135104e-02f, 3.95388827e-02f, -7.92915449e-02f, 7.19945729e-02f, 5.93058467e-02f, 5.58166625e-03f,
  6.94902837e-02f, 1.20064467e-02f, -4.52003665e-02f, 2.89016273e-02f, 3.25594507e-02f, 1.50834927e-02f, -1.58023331e-02f, 2.39960756e-02f, -5.65527054e-03f, 6.19642474e-02f,
  9.17215459e-03f, 6.31411597e-02f, -1.74181461e-02f, 3.51296775e-02f, 5.53916991e-02f, 3.74295823e-02f, 3.12339850e-02f, 4.90519404e-02f, 2.18045395e-02f, 3.76846828e-02f,
  -4.33024690e-02f, 1.08681107e-02f, 1.44592952e-02f, 6.36692420e-02f, -3.30758914e-02f, 2.43552011e-02f, -2.45316550e-02f, 1.77493803e-02f, 1.19038830e-02f, 5.15656173e-03f,
  -2.77401991e-02f, -5.16800433e-02f, 4.98077124e-02f, -3.91824506e-02f, 5.39142825e-02f, 3.92057672e-02f, 1.76303852e-02f, -3.10314391e-02f, -5.37517592e-02f, -3.33822072e-02f,
  -7.18883239e-03f, 2.02092752e-02f, -3.79514843e-02f, 5.21722585e-02f, 2.97738705e-02f, 6.42314553e-02f, 1.38130356e-02f, 7.83691779e-02f, 7.99737498e-02f, 9.28466916e-02f,
  -1.65004178e-03f, 7.58640119e-04f, -1.19243432e-02f, 5.47173526e-03f, 8.06785077e-02f, 6.83478117e-02f, 6.68285117e-02f, -7.73994625e-03f, 7.49502406e-02f, 2.42237207e-02f,
  1.82514921e-01f, -2.15753540e-02f, -9.05138440e-03f, 1.60267144e-01f, -1.26917318e-01f, 5.10249883e-02f, 2.21616015e-01f, -7.76908398e-02f, 1.01059139e-01f, -1.09370440e-01f,
  2.60905400e-02f, 8.57789367e-02f, 1.08726345e-01f, -1.09293694e-02f, 3.42320770e-01f, 1.98063880e-01f, 5.07942587e-02f, 8.84133503e-02f, 5.75033203e-03f, 3.13122757e-02f,
  8.14733505e-02f, -1.31827658e-02f, -1.46970665e-02f, -2.60803938e-01f, -7.79482499e-02f, -5.39047942e-02f, -1.16837569e-01f, -3.87703665e-02f, -1.71371937e-01f, -5.64720519e-02f,
  -4.03352976e-02f, -4.48421687e-02f, 8.15038290e-03f, 4.89046797e-02f, -4.43456732e-02f, -7.11079091e-02f, 8.16747695e-02f, 3.22270003e-04f, -5.80040999e-02f, -3.54787670e-02f,
  3.04285102e-02f, -2.65799034e-02f, -5.00120968e-02f, -1.86714511e-02f, 5.18492907e-02f, -5.85716106e-02f, -8.97823945e-02f, -4.66885082e-02f, -8.08038265e-02f, -2.48757396e-02f,
  -6.55432120e-02f, 1.01493429e-02f, -7.00804889e-02f, 1.58989131e-02f, -2.41714343e-02f, -2.27610916e-02f, -2.10405886e-03f, -3.79987317e-03f, -4.86672595e-02f, 5.00848442e-02f,
  1.92438290e-02f, -3.20401713e-02f, 5.44715300e-02f, -4.55692783e-02f, 2.32958235e-02f, -1.04033716e-01f, 3.10528688e-02f, 2.22415607e-02f, 7.68018141e-02f, 3.66944596e-02f,
  2.22368594e-02f, -4.92410623e-02f, 4.04701643e-02f, 6.06963299e-02f, -3.04532647e-02f, 6.11446425e-02f, 2.29845326e-02f, 6.41075522e-02f, -1.14912754e-02f, 1.40945045e-02f,
  6.76126510e-05f, 4.03660014e-02f, -2.53562555e-02f, 2.64384430e-02f, 4.28230502e-02f, 1.68735685e-03f, -3.96490619e-02f, 3.28851910e-03f, -4.60785441e-02f, -1.95821747e-02f,
  -3.94449383e-02f, 1.55313313e-01f, -6.99928701e-02f, -6.99809194e-02f, 5.96436299e-02f, 3.56546305e-02f, -3.41227390e-02f, 7.41292536e-02f, 7.36816600e-02f, 6.85505718e-02f,
  4.68292534e-02f, -7.19680116e-02f, 6.09815866e-02f, 3.63950282e-02f, 1.64080430e-02f, 2.48231664e-02f, 9.31055620e-02f, 4.66210768e-02f, -2.20234953e-02f, -3.85900866e-03f,
  -8.63801762e-02f, 8.64329636e-02f, -4.55552116e-02f, -2.76796892e-02f, -8.71381350e-03f, 2.55852360e-02f, 3.81801836e-02f, 1.83880981e-02f, 1.67749692e-02f, 6.95384890e-02f,
  -2.20803797e-01f, -2.55160809e-01f, -8.72258916e-02f, -2.38912225e-01f, 7.83180073e-02f, -3.73144709e-02f, -5.23501113e-02f, 3.68377753e-02f, -2.89054960e-01f, -2.41732851e-01f,
  2.66038496e-02f, -1.08044438e-01f, 6.39897734e-02f, -2.24584475e-01f, 1.73394814e-01f, -2.53053699e-02f, -1.36877462e-01f, -1.34320915e-01f, 1.56059638e-02f, 1.08432909e-02f,
  -1.88646559e-02f, 8.42724368e-02f, 1.32413954e-01f, 1.47279441e-01f, -7.03873336e-02f, 1.61209293e-02f, 1.39506534e-01f, 2.38473728e-01f, -1.19981263e-02f, 1.68144375e-01f,
  -9.13732871e-02f, -1.25656709e-01f, -9.33261886e-02f, -5.53716831e-02f, 1.66822821e-02f, 5.05041964e-02f, -3.29020396e-02f, 5.82647249e-02f, 5.38775027e-02f, -3.15560699e-02f,
  -1.02304574e-02f, 9.26518142e-02f, 1.81583185e-02f, 1.70562994e-02f, 5.32146022e-02f, -9.08740759e-02f, -6.72037676e-02f, -4.64083739e-02f, 3.52293178e-02f, -1.26561681e-02f,
  -2.62793321e-02f, -6.18999358e-03f, -4.74984460e-02f, 5.45883365e-02f, -2.99393316e-03f, -4.70268391e-02f, 2.39603538e-02f, -1.29367858e-02f, -1.16013005e-01f, -6.28267825e-02f,
  -2.76814774e-02f, -5.10981418e-02f, -1.34646511e-02f, -9.15552229e-02f, 7.82826915e-03f, -2.38403417e-02f, -1.37115736e-02f, 7.76256174e-02f, -1.29963853e-03f, 6.62357882e-02f,
  1.07904579e-02f, -2.79750824e-02f, 6.95333481e-02f, 6.78377412e-03f, -3.80746424e-02f, -4.18334864e-02f, 5.66252843e-02f, -3.42743620e-02f, 1.28348859e-03f, -1.81901865e-02f,
  3.36603522e-02f, -1.95923876e-02f, 3.42682786e-02f, 3.64626944e-02f, -3.16650458e-02f, 2.32990440e-02f, -4.03769016e-02f, 1.60112362e-02f, -5.29908808e-03f, -2.20440980e-02f,
  2.66855471e-02f, 5.48438244e-02f, -9.48067009e-03f, 7.87394643e-02f, -1.40359122e-02f, -5.42776920e-02f, 6.12022839e-02f, 2.94737238e-02f, 8.70360434e-02f, 4.28751335e-02f,
  1.46337622e-03f, 7.89049827e-03f, -3.56212929e-02f, 1.63506495e-03f, -2.53086612e-02f, 1.65595803e-02f, 1.84596572e-02f, -1.78356506e-02f, 1.95474941e-02f, 2.61285659e-02f,
  -2.17630807e-02f, -2.69146804e-02f, -6.99682487e-03f, -5.35075292e-02f, 3.66166942e-02f, -2.16049999e-02f, 4.01551500e-02f, -2.60411929e-02f, 3.44536677e-02f, 3.21107879e-02f,
  -1.65387869e-01f, 7.11362287e-02f, 1.81466341e-01f, -1.37433615e-02f, -7.51908273e-02f, 2.13454361e-03f, 8.01013187e-02f, 4.32026424e-02f, 1.68905079e-01f, -1.15571141e-01f,
  -2.36600652e-01f, 1.17787808e-01f, 1.67472109e-01f, -1.76563770e-01f, -2.08434060e-01f, -3.34129483e-02f, -6.97861239e-02f, -2.74756011e-02f, 1.79579780e-01f, 1.07976338e-02f,
  -7.11552948e-02f, -3.30633849e-01f, -7.33823255e-02f, -1.84596986e-01f, -6.30506054e-02f, 7.04705939e-02f, -1.85446903e-01f, 7.94522241e-02f, -1.91992238e-01f, -4.93733585e-02f,
  1.08058546e-02f, -5.33163026e-02f, 1.10569373e-01f, 6.79922774e-02f, 2.24958602e-02f, 7.01938495e-02f, -9.92220733e-03f, -1.50912758e-02f, 6.75648749e-02f, -1.05481623e-02f,
  4.65775728e-02f, -3.32908519e-02f, -2.13861670e-02f, 8.24411632e-04f, 9.48136598e-02f, 5.46083413e-02f, 4.07086872e-02f, 3.20296474e-02f, 7.82574620e-03f, -7.80773684e-02f,
  -3.59764732e-02f, 3.97681631e-02f, -3.97545062e-02f, 2.15583742e-02f, 2.66701225e-02f, -1.57674886e-02f, 7.45799989e-02f, 6.04533292e-02f, -3.65550406e-02f, 1.79692041e-02f,
  -1.05448570e-02f, 7.32542798e-02f, -2.11466174e-03f, -8.34938213e-02f, 7.99642596e-03f, -5.42169176e-02f, 1.01757012e-02f, 1.26101784e-02f, 5.85990734e-02f, -3.66936787e-03f,
  2.15283427e-02f, -4.44753980e-03f, 3.78990523e-03f, -1.87049545e-02f, -1.39389457e-02f, -4.28939164e-02f, -3.76685075e-02f, -6.42333925e-03f, -1.83404535e-02f, 3.90240587e-02f,
  -6.07544929e-02f, -4.89162318e-02f, -3.05029768e-02f, 8.68193246e-03f, 1.21623734e-02f, 6.05656346e-03f, -1.30293109e-02f, 1.19537143e-02f, 4.43341807e-02f, -9.06711910e-03f,
  -3.52457203e-02f, -1.01857051e-01f, 3.27647440e-02f, -2.11787988e-02f, 3.39657329e-02f, -9.05246511e-02f, 6.42683506e-02f, -1.42022949e-02f, 6.29886612e-02f, -4.90766391e-02f,
  5.14547667e-03f, 6.21683523e-02f, -6.58756196e-02f, -6.16465248e-02f, -3.25915366e-02f, -6.74166977e-02f, -5.04114479e-02f, 4.56783809e-02f, -6.05158769e-02f, 3.91709022e-02f,
  2.82713007e-02f, -8.63452535e-03f, 3.89141813e-02f, -3.89861837e-02f, -2.59079468e-02f, 3.37839164e-02f, -2.78184488e-02f, 2.61586402e-02f, -3.60620432e-02f, 2.23100483e-02f,
  -1.15529820e-01f, 1.63227469e-01f, 2.34353706e-01f, -1.35569796e-01f, -2.11592540e-01f, -1.30160108e-01f, -3.61925997e-02f, -6.03977777e-02f, 3.03893238e-02f, 1.17837213e-01f,
  -4.62943465e-02f, 6.79691806e-02f, 1.36027053e-01f, 1.15767308e-01f, -3.24786901e-02f, 1.68757051e-01f, 2.41534989e-02f, -1.17915375e-02f, 1.24526463e-01f, -8.53021815e-02f,
  -5.10883778e-02f, -1.25194058e-01f, 2.13532731e-01f, -2.69197468e-02f, -9.12462324e-02f, -2.25416757e-02f, -1.72267646e-01f, -1.09448917e-02f, -6.01899587e-02f, 2.62594316e-02f,
  -1.02508567e-01f, -5.79824746e-02f, 7.91685879e-02f, 7.77852833e-02f, -8.64423737e-02f, 8.43066536e-03f, -8.23409557e-02f, 4.57028076e-02f, 6.92365840e-02f, 4.18326963e-04f,
  -3.07956734e-03f, -8.70858282e-02f, 2.99644917e-02f, -1.24115590e-02f, -7.22278783e-04f, 1.11723179e-02f, 9.99280661e-02f, 4.69025336e-02f, 7.51886964e-02f, 3.43416408e-02f,
  5.87459132e-02f, 3.36618200e-02f, 3.65200900e-02f, -4.28101420e-02f, 8.22717045e-03f, -2.87418757e-02f, 1.04938326e-02f, 9.15646087e-03f, -4.73432206e-02f, -4.48737517e-02f,
  -1.04655176e-01f, -3.67426127e-02f, 2.62678638e-02f, -3.25722471e-02f, -5.33163846e-02f, -1.96302142e-02f, -3.55248973e-02f, -1.50559871e-02f, -3.26280370e-02f, -5.54816686e-02f,
  -8.29209760e-02f, -3.91522842e-03f, -1.28203921e-03f, -1.63499322e-02f, 4.59305616e-03f, 3.26761045e-02f, 5.55859925e-03f, -3.50758731e-02f, 4.98602055e-02f, -2.88947467e-02f,
  1.24797188e-02f, -5.00656888e-02f, -1.45211760e-02f, -4.43921238e-03f, -4.72496869e-03f, 4.74577621e-02f, 1.20892627e-02f, 3.62962513e-04f, -8.91511329e-03f, -2.43815091e-02f,
  -2.59437650e-01f, -2.29395971e-01f, -3.18526290e-02f, -5.40421829e-02f, 6.92881364e-03f, -6.67641163e-02f, 9.39829275e-02f, -2.72843540e-02f, -4.19254936e-02f, -9.83784124e-02f,
  -2.85072811e-02f, 5.28765935e-03f, -8.94667357e-02f, -2.25325637e-02f, -8.73887837e-02f, -2.86805686e-02f, -4.82585467e-02f, -4.74371053e-02f, -4.90649566e-02f, 1.37942703e-02f,
  -3.54294740e-02f, -5.69854490e-02f, 3.03749964e-02f, 3.98351736e-02f, -6.45874590e-02f, -4.31927526e-03f, -2.44803075e-02f, 3.44916061e-02f, -2.95616351e-02f, -2.74968497e-03f,
  -1.34219348e-01f, 3.26469332e-01f, 1.88926890e-01f, -5.75279444e-02f, -1.18592128e-01f, 2.01332122e-02f, -7.95417503e-02f, 1.18268199e-01f, 2.26868793e-01f, 1.47941217e-01f,
  -1.71687100e-02f, 3.75816822e-02f, 1.16143800e-01f, -2.35251337e-02f, -1.92306980e-01f, 1.19968867e-02f, -8.28264654e-02f, -2.12444240e-04f, -3.04858596e-03f, -1.36037469e-01f,
  3.43095325e-03f, -1.95266575e-01f, 3.67529765e-02f, -1.48852440e-02f, -2.01927293e-02f, -3.42315137e-02f, -2.70539939e-01f, 4.18555439e-02f, -1.48457661e-01f, -3.17794383e-02f,
  -8.85123163e-02f, 1.88578926e-02f, -6.02606386e-02f, 9.28800628e-02f, -7.07658529e-02f, 2.06697360e-02f, 3.38803604e-02f, -6.54450953e-02f, -4.15633507e-02f, -1.44550586e-02f,
  -3.59557047e-02f, 4.89139408e-02f, 1.32087059e-02f, -4.27438878e-02f, 9.17104557e-02f, 9.48045403e-04f, -6.47628354e-03f, 4.67709377e-02f, 6.61517158e-02f, -1.35529824e-02f,
  2.28597410e-02f, 8.19889531e-02f, 1.63290799e-02f, -1.33012496e-02f, 5.40104732e-02f, 4.60460335e-02f, -4.78970855e-02f, -1.91859566e-02f, -1.45842610e-02f, -2.96685491e-02f,
  6.80773556e-02f, 3.35379913e-02f, -1.69887412e-02f, 2.04605702e-02f, -2.35189255e-02f, -2.51292214e-02f, 6.66624308e-02f, -4.94423471e-02f, 8.39169994e-02f, -3.42371538e-02f,
  -2.55517345e-02f, -5.01501113e-02f, 4.35385667e-02f, 5.48980497e-02f, -2.40779221e-02f, -1.97592452e-02f, -4.04217243e-02f, 2.33070049e-02f, 2.54685301e-02f, 1.50164887e-02f,
  7.60975778e-02f, 1.62060596e-02f, 2.91004796e-02f, 3.14686783e-02f, 1.35983154e-03f, -2.44942419e-02f, 9.20352936e-02f, 6.66224733e-02f, 6.00444805e-03f, -8.73359144e-02f,
  -7.09788278e-02f, 1.28139637e-03f, -3.32638212e-02f, -1.68019440e-02f, 3.69913131e-02f, -4.22790498e-02f, -1.96647607e-02f, 3.36126089e-02f, -1.40967863e-02f, -7.61370698e-04f,
  4.73362729e-02f, -7.05293566e-02f, 8.45136400e-03f, -3.35742198e-02f, -7.13485926e-02f, 1.80840567e-02f, -1.02327894e-02f, 4.80772275e-03f, -5.91634549e-02f, -4.71981727e-02f,
  -7.67908394e-02f, -9.98295173e-02f, 3.30992751e-02f, -1.67576522e-02f, -1.20621324e-02f, 2.52169855e-02f, 3.10065486e-02f, -2.79863775e-02f, 1.64244138e-02f, 1.59296431e-02f,
  -1.87625825e-01f, -9.37945545e-02f, -1.91299781e-01f, -1.16094358e-01f, 4.66445647e-02f, 2.13190727e-02f, 1.70016170e-01f, -4.07851376e-02f, -2.15550065e-01f, 2.37333089e-01f,
  2.31204972e-01f, -2.09346652e-01f, 1.52887031e-01f, 7.46810883e-02f, -2.81963021e-01f, -4.47981507e-02f, -6.50202557e-02f, 1.23614766e-01f, -1.39580458e-01f, -4.81658941e-03f,
  -1.57555699e-01f, 1.91252053e-01f, -1.20236957e-02f, 5.97404987e-02f, 1.37782335e-01f, 2.46950965e-02f, 1.88884914e-01f, 2.06217319e-02f, 5.45639507e-02f, -4.94968519e-02f,
  -6.39330670e-02f, -4.94544692e-02f, 8.46974477e-02f, -4.68739644e-02f, 5.18168509e-02f, 1.31206229e-01f, 1.15257911e-02f, 1.39529472e-02f, 7.69768143e-03f, -2.79003661e-02f,
  -3.53115075e-03f, -2.05967855e-02f, -4.47614342e-02f, -4.77862656e-02f, -3.78404930e-02f, -2.29026396e-02f, -7.65277026e-03f, 4.88194935e-02f, -8.61835480e-03f, 4.54474725e-02f,
  3.15297544e-02f, 1.71503220e-02f, 5.41899502e-02f, 6.12031519e-02f, 7.87598919e-03f, 1.92135964e-02f, 1.89564563e-02f, 2.60092542e-02f, -9.78490617e-03f, -5.53732552e-02f,
  1.04828246e-01f, -1.69225298e-02f, 6.43491670e-02f, 3.92541029e-02f, 4.52452386e-03f, 8.97230357e-02f, -5.01283817e-03f, 4.78469841e-02f, 1.56833557e-04f, 4.75253706e-04f,
  -8.85679503e-04f, -4.05361429e-02f, -5.18813683e-03f, -1.71887390e-02f, 7.19164535e-02f, 1.29116448e-02f, 6.91186488e-02f, -4.33022641e-02f, -7.20667914e-02f, 1.66624673e-02f,
  2.71334089e-02f, -5.39713129e-02f, 2.48666927e-02f, 7.51311630e-02f, -6.21519908e-02f, 2.56031519e-03f, -3.09287943e-03f, -5.00590503e-02f, 7.35515216e-03f, 6.75259829e-02f,
  -5.75837903e-02f, 1.47443581e-02f, -8.05283263e-02f, -7.49719441e-02f, 5.80144720e-03f, -2.21745353e-02f, 1.21163838e-02f, 3.88935320e-02f, -7.42684826e-02f, -4.83008809e-02f,
  8.35434198e-02f, -1.66033711e-02f, -2.10360121e-02f, 4.83297594e-02f, -1.02594607e-02f, 3.18986401e-02f, 1.08276913e-03f, -2.67700553e-02f, -1.85252856e-02f, -4.72955257e-02f,
  2.98323426e-02f, 4.21398133e-02f, -5.38431965e-02f, -5.20575419e-02f, -1.21874211e-03f, 2.13952903e-02f, -1.81912500e-02f, -6.35154694e-02f, 2.85736024e-02f, -2.30983403e-02f,
  -3.93266916e-01f, -3.01909707e-02f, -1.45544499e-01f, -1.97725132e-01f, -1.70997400e-02f, 6.26156405e-02f, -3.35858623e-03f, -2.09071353e-01f, -8.29903409e-02f, 5.16806217e-03f,
  -5.15849106e-02f, -9.35515016e-02f, 1.88698485e-01f, -1.02142312e-01f, 1.28168529e-02f, 1.62602901e-01f, -9.93056595e-02f, -8.25158656e-02f, 1.71093531e-02f, -2.64420092e-01f,
  -2.48562302e-02f, -2.13960893e-02f, -5.32087907e-02f, 3.81665975e-02f, -1.78940862e-01f, -1.32918522e-01f, 8.84746388e-03f, 1.54547617e-01f, -1.46418378e-01f, 1.06144063e-01f,
  -8.80064890e-02f, -2.27586865e-01f, -1.27193198e-01f, -2.49854438e-02f, -1.00401126e-01f, -5.98716103e-02f, -4.92870919e-02f, 1.11063100e-01f, 6.26321509e-02f, -3.95347923e-02f,
  2.94335335e-02f, 2.98151895e-02f, -1.28673967e-02f, 9.05818716e-02f, -8.61283243e-02f, -7.81221092e-02f, 4.21383865e-02f, -6.46982715e-02f, -8.25772062e-03f, -7.32398257e-02f,
  -3.26715522e-02f, -8.38773251e-02f, -7.25066066e-02f, -3.14904600e-02f, -3.20454463e-02f, 7.95381367e-02f, 2.50103399e-02f, 1.89355854e-02f, -3.77474353e-03f, -2.02517658e-02f,
  -1.90703478e-02f, 7.09496439e-02f, -6.75397739e-02f, 4.13726829e-02f, -6.40888978e-03f, -5.32481968e-02f, -2.47717462e-02f, 1.83039270e-02f, 4.75029908e-02f, -5.67655489e-02f,
  4.09902707e-02f, -8.61979797e-02f, -2.73281261e-02f, 5.84132113e-02f, -1.15786698e-02f, -3.78919911e-04f, 2.69079227e-02f, -3.40673402e-02f, -7.57317916e-02f, -1.11199683e-03f,
  5.83187751e-02f, 1.70425382e-02f, -6.76117465e-02f, -3.07564437e-02f, 9.83743649e-03f, 4.00503427e-02f, -3.69816497e-02f, -8.46784189e-02f, 8.75446480e-03f, -2.14350242e-02f,
  -1.55136481e-01f, -2.41965741e-01f, 7.69096464e-02f, -3.52340937e-02f, 7.75799453e-02f, -4.10343520e-02f, 3.56171560e-03f, 3.55150253e-02f, -2.21499614e-02f, -8.98454222e-04f,
  -6.43144697e-02f, -2.11476479e-02f, -3.88671272e-02f, 5.27106933e-02f, 7.69655826e-03f, 1.95163283e-02f, -2.75654923e-02f, 3.14717777e-02f, -2.51307134e-02f, 1.82245206e-02f,
  -1.88760106e-02f, 3.30844186e-02f, 5.22077829e-02f, 8.57708696e-03f, 3.06877643e-02f, -8.07078332e-02f, -1.13900341e-01f, -4.89371344e-02f, -2.24140510e-02f, -1.96149480e-02f,
  2.55347431e-01f, -4.46388096e-01f, -1.77259505e-01f, 1.49412259e-01f, 6.85580596e-02f, 2.57951051e-01f, 2.32459515e-01f, -1.58831552e-01f, 3.23658437e-02f, -1.36266470e-01f,
  4.00173739e-02f, -3.14969756e-02f, -1.12269990e-01f, 4.96221371e-02f, 3.38289112e-01f, 3.63591564e-04f, 1.58602074e-01f, 1.70487925e-01f, -3.41528840e-03f, -1.06043033e-01f,
  2.45602261e-02f, 3.97674106e-02f, -3.84649560e-02f, -1.37958050e-01f, -7.54346326e-02f, -1.07676379e-01f, 7.07864761e-02f, -1.11492343e-01f, 2.33530812e-03f, 3.37045379e-02f,
  -2.87695229e-03f, -4.70065735e-02f, -3.57514210e-02f, -2.23004539e-02f, -3.53466161e-02f, 5.90848066e-02f, 3.55517194e-02f, 9.14244056e-02f, 8.22618976e-02f, -3.55310477e-02f,
  2.83556711e-02f, 4.55370219e-03f, -4.69193272e-02f, -3.20855789e-02f, 1.36384964e-02f, -1.69419162e-02f, -8.25420991e-02f, -2.57911216e-02f, -6.63076118e-02f, -6.64403662e-02f,
  -7.42832664e-03f, -9.95846540e-02f, -5.37724746e-03f, -2.08638012e-02f, 1.51170334e-02f, 3.96792293e-02f, 5.43380529e-02f, 9.83277149e-03f, -2.84617506e-02f, -1.76202394e-02f,
  -8.21267813e-03f, 6.15115799e-02f, -2.76818611e-02f, 5.24509102e-02f, 1.02660153e-02f, -1.33243818e-02f, 2.93880925e-02f, -3.90573554e-02f, -1.75766498e-02f, -1.12284971e-02f,
  -1.58468373e-02f, -4.01909985e-02f, -7.12782517e-03f, 6.74022138e-02f, 4.60966006e-02f, 4.21672799e-02f, 1.86203886e-02f, -5.56523204e-02f, -1.01591619e-02f, 3.10149956e-02f,
  2.93312725e-02f, 1.70361884e-02f, 8.78124963e-03f, 1.64067652e-03f, -1.11588985e-02f, -1.11453282e-02f, -5.30644506e-02f, -1.54239601e-02f, -2.28059348e-02f, 9.22869891e-02f,
  -2.45654993e-02f, -1.01868331e-01f, -7.31794396e-03f, -4.31975126e-02f, 2.92215440e-02f, -6.25252575e-02f, 4.07155678e-02f, -3.28229144e-02f, 2.16088071e-02f, 2.82060727e-02f,
  9.05494206e-03f, 8.73582363e-02f, 6.34391084e-02f, 6.41697273e-02f, -1.39428927e-02f, -1.04154414e-02f, 3.60409096e-02f, 7.93887228e-02f, 9.16293114e-02f, -2.60861740e-02f,
  -7.64854159e-03f, 5.53470589e-02f, 8.89427513e-02f, 4.94230725e-02f, 1.09147690e-02f, 1.85761880e-02f, -2.53529586e-02f, -2.64546126e-02f, 3.21411416e-02f, 4.08065990e-02f,
  -1.49700344e-01f, -1.86083481e-01f, -9.93162021e-02f, -5.03407493e-02f, -1.19927749e-01f, -1.17548108e-01f, 1.08408816e-01f, -2.17926770e-01f, -5.82061671e-02f, -5.27493618e-02f,
  1.96582824e-01f, -1.44754276e-01f, 6.94203004e-02f, -7.77333379e-02f, -8.35029315e-03f, 8.55117440e-02f, -7.60630965e-02f, 4.59023565e-02f, -1.57276228e-01f, -6.61452115e-02f,
  -2.36669276e-03f, 2.67382078e-02f, -6.75088493e-03f, -9.06450525e-02f, -8.50182772e-02f, -4.36492972e-02f, 1.01226583e-01f, 3.12621295e-02f, 1.73294954e-02f, -2.88156904e-02f,
  -1.15107177e-02f, -5.79916202e-02f, -5.44303767e-02f, -8.21746215e-02f, 6.49510100e-02f, 9.23222005e-02f, 6.15989231e-03f, 1.10005237e-01f, 1.13093322e-02f, -1.41452253e-02f,
  7.19237104e-02f, -1.01782382e-01f, -4.04136293e-02f, 1.43820290e-02f, -1.05880648e-01f, 1.13492897e-02f, 7.91458227e-03f, 6.57259077e-02f, -1.87755022e-02f, -1.27200305e-01f,
  -2.11087056e-02f, 3.51407155e-02f, 5.45210242e-02f, 2.49203239e-02f, -1.67747226e-03f, 1.10494299e-02f, -3.09344865e-02f, -1.48829969e-03f, -8.41596648e-02f, -7.28473216e-02f,
  -5.92395253e-02f, 1.66033190e-02f, 6.51512202e-03f, -4.96806316e-02f, -5.12139760e-02f, 8.48613903e-02f, 8.54056105e-02f, -5.03358357e-02f, -3.89825776e-02f, -5.93854561e-02f,
  2.46487483e-02f, -5.06204702e-02f, 5.01487777e-02f, 7.64031783e-02f, 6.71227556e-03f, 6.35260269e-02f, -9.81697440e-03f, 7.53139853e-02f, 1.18485913e-02f, 5.03150299e-02f,
  1.02862790e-01f, -2.97007561e-02f, 7.88232088e-02f, 3.47868018e-02f, 9.64049343e-03f, 1.37349153e-02f, 3.78853641e-02f, 2.66270433e-02f, 9.80436429e-02f, 8.57908130e-02f,
  -7.36942515e-02f, -1.85409561e-01f, 2.44938750e-02f, 2.55150255e-02f, -7.43484348e-02f, -1.09727718e-02f, -1.11048622e-02f, -1.35924578e-01f, -2.74338629e-02f, -5.72350435e-02f,
  4.80383001e-02f, 6.20850362e-02f, -7.27933645e-02f, -3.01455427e-02f, -3.19503783e-03f, -8.20311680e-02f, 4.18224260e-02f, 8.66569653e-02f, -1.31632099e-02f, -7.29068145e-02f,
  6.14360012e-02f, -8.10850039e-02f, 8.24866537e-03f, -2.58746999e-03f, 6.94736093e-02f, 9.41872299e-02f, 3.09489854e-02f, -4.14662585e-02f, -5.72995022e-02f, -6.32796250e-03f,
  -2.74337649e-01f, -2.53474973e-02f, -3.63219976e-02f, -3.78102124e-01f, 1.47493482e-01f, -9.81164873e-02f, -3.94486934e-01f, 5.99488169e-02f, -1.84841141e-01f, -5.77084832e-02f,
  -7.78489709e-02f, -1.68212876e-01f, -9.73378941e-02f, -2.66783863e-01f, -3.11844468e-01f, -1.20163701e-01f, -2.92301744e-01f, -2.45943099e-01f, 3.35482620e-02f, -1.24098048e-01f,
  -6.08925708e-02f, -2.00529307e-01f, -2.10401863e-02f, 1.56722546e-01f, -3.78153101e-02f, 1.35717124e-01f, 8.44062269e-02f, 1.56465143e-01f, -2.58670412e-02f, 1.63148856e-03f,
  1.63212754e-02f, -8.08087960e-02f, -5.25805950e-02f, 3.94316278e-02f, -5.10597266e-02f, 2.12823674e-02f, -2.08851825e-02f, -4.00281372e-03f, 5.33823504e-06f, 3.10189631e-02f,
  -7.69527704e-02f, 5.92760593e-02f, -4.17939462e-02f, 4.48551700e-02f, -2.60352287e-02f, 7.38251135e-02f, 2.40911599e-02f, -1.67242922e-02f, 4.59072441e-02f, -2.05796696e-02f,
  1.22716436e-02f, 2.11098474e-02f, -4.22022007e-02f, -6.84899278e-03f, -6.23247065e-02f, -2.71959621e-02f, -3.65177915e-02f, -3.20112742e-02f, 2.32753716e-02f, -7.11650625e-02f,
  2.92718932e-02f, -2.42167264e-02f, 3.74728516e-02f, 3.49152461e-02f, 4.79253232e-02f, 3.93439867e-02f, -1.15677062e-02f, 7.30554909e-02f, -4.42098714e-02f, 5.04177213e-02f,
  -2.95911152e-02f, -8.12917855e-03f, 2.29784753e-02f, 2.15878151e-02f, -6.80965185e-02f, 3.58673930e-02f, -3.35054733e-02f, -5.88918803e-03f, -4.45619784e-02f, 5.97618558e-02f,
  -4.03580517e-02f, -5.57054626e-03f, -4.70293835e-02f, 2.28650086e-02f, -3.60917822e-02f, 5.25756702e-02f, 3.42109497e-03f, 5.05653359e-02f, 1.79995466e-02f, 2.29790956e-02f,
  -5.62667698e-02f, -5.11495732e-02f, 1.19380681e-02f, -9.56992432e-03f, -1.92389134e-02f, -1.83968619e-02f, -6.52961880e-02f, -4.84418403e-03f, -4.13773209e-02f, -3.85754630e-02f,
  3.05878986e-02f, 1.16279423e-02f, 5.21613657e-02f, 9.88854468e-03f, 4.16652858e-02f, -8.15312639e-02f, -7.55047575e-02f, 4.66869911e-03f, -7.62205496e-02f, 7.82941580e-02f,
  2.98328605e-02f, 3.24479453e-02f, -4.43477891e-02f, -2.41797939e-02f, 2.63615008e-02f, -1.04967225e-02f, 5.71874641e-02f, 7.29361475e-02f, 5.31870052e-02f, 6.12680130e-02f,
  -1.49034886e-02f, 4.66036387e-02f, 4.72999662e-02f, 3.43602486e-02f, 2.99500115e-02f, -6.58323243e-02f, -2.16656536e-01f, 1.59102395e-01f, 1.89551666e-01f, -3.19872797e-02f,
  -3.87889445e-02f, -4.38635200e-02f, -2.20472425e-01f, 1.52311936e-01f, -1.47428259e-01f, 2.87610963e-02f, -1.73198860e-02f, -3.16191092e-02f, 1.56438008e-01f, -3.51312310e-02f,
  1.25094533e-01f, 4.85442095e-02f, 1.37776121e-01f, 7.92393610e-02f, 7.49010295e-02f, 1.09703904e-02f, -1.04130827e-01f, -8.38222131e-02f, 2.06715912e-02f, 4.43646051e-02f,
  2.28267722e-02f, 1.07441247e-01f, 9.89636108e-02f, -2.07325853e-02f, 3.80371176e-02f, -1.18610570e-02f, -1.44560784e-01f, -3.93665135e-02f, -1.03690233e-02f, -4.70829569e-02f,
  -8.03483184e-03f, 9.32707414e-02f, 6.28938675e-02f, 2.33459417e-02f, 7.03572780e-02f, 7.97793567e-02f, 1.20494135e-01f, 6.22947887e-02f, 2.68400516e-02f, -1.99673623e-02f,
  1.29365399e-01f, 2.24257316e-02f, 3.41310315e-02f, 6.74728081e-02f, -2.81400848e-02f, 2.28583068e-02f, -4.42985706e-02f, -1.01374283e-01f, 2.82482021e-02f, 3.06023341e-02f,
  -2.29317024e-02f, -9.13878903e-02f, -2.04032399e-02f, 5.93777746e-02f, 6.20308053e-03f, -1.38029270e-02f, 1.43178981e-02f, -4.16076817e-02f, -1.82363465e-02f, -1.47882197e-02f,
  -6.73128292e-02f, -4.10333574e-02f, 1.10322786e-02f, 5.39003611e-02f, -3.14443074e-02f, -6.42837659e-02f, -7.17961788e-02f, 1.77775323e-02f, 8.27475637e-02f, 2.81840675e-02f,
  -2.78264731e-02f, -1.59566272e-02f, 2.39977613e-02f, 1.12663815e-02f, -4.80337366e-02f, -5.67542063e-03f, -7.42805598e-04f, 7.12748989e-02f, 5.96229695e-02f, -6.33549504e-03f,
  -4.42747353e-03f, -1.29390076e-01f, 5.78448586e-02f, 8.25159252e-02f, -1.09833330e-02f, -8.14967230e-03f, -5.15349880e-02f, 1.02431439e-01f, -7.64530450e-02f, 7.08224177e-02f,
  -5.94706871e-02f, 1.00770907e-04f, -3.48375738e-02f, -2.57331394e-02f, 5.32546975e-02f, 2.30203681e-02f, -1.54567897e-01f, 1.45253027e-02f, -9.67922062e-02f, 2.04469226e-02f,
  -6.59857243e-02f, -2.41300873e-02f, -6.60565346e-02f, 2.91404058e-03f, 2.93671731e-02f, 4.46682535e-02f, -7.66407922e-02f, -1.03052044e-02f, -3.45380828e-02f, -2.60565151e-02f,
  -2.67646700e-01f, 2.06801087e-01f, 1.09188282e-03f, -2.56894380e-01f, -1.98933810e-01f, -1.10390065e-02f, 8.67666453e-02f, -1.09700851e-01f, 1.12056537e-02f, 2.87464797e-01f,
  -7.21867708e-03f, -6.64028898e-02f, 3.17671180e-01f, -2.50023976e-02f, -8.40444639e-02f, 3.98689985e-01f, 3.45396325e-02f, 2.20920034e-02f, 1.76478382e-02f, -1.68488920e-01f,
  -1.42930493e-01f, 3.20787169e-02f, -6.24238141e-03f, -4.49997038e-02f, -1.49697214e-01f, -1.82249129e-01f, -6.82915524e-02f, -2.05360297e-02f, -1.63773566e-01f, 7.09523261e-02f,
  -7.96193704e-02f, -7.85853714e-02f, -5.42882718e-02f, 1.33832311e-02f, -8.71448368e-02f, 2.06260923e-02f, -3.38359401e-02f, 1.11493632e-01f, -8.54648277e-02f, -3.97639014e-02f,
  -3.52036692e-02f, -2.44092252e-02f, 7.72336358e-03f, 4.04125340e-02f, 2.08187494e-02f, 4.86110896e-03f, 1.84805356e-02f, 3.63822132e-02f, 2.76105646e-02f, 1.21225109e-02f,
  -2.70429142e-02f, -3.30045037e-02f, 2.63024699e-02f, 6.13922849e-02f, -5.22114597e-02f, -8.42869934e-03f, -1.83454435e-02f, -4.96268319e-03f, 5.69611788e-02f, -1.10229164e-01f,
  8.82784948e-02f, 1.90708432e-02f, 7.27146789e-02f, 1.05450610e-02f, -1.21191302e-02f, 5.27946930e-03f, 4.51122448e-02f, 1.47283543e-02f, 3.91104147e-02f, -2.01407354e-02f,
  -4.78852652e-02f, -2.42406561e-04f, 1.10299857e-02f, 2.55333949e-02f, -1.96201224e-02f, -2.19377894e-02f, 5.31703494e-02f, -6.33933991e-02f, -3.30984406e-02f, -2.44735591e-02f,
  1.54425912e-02f, -2.34330017e-02f, 5.22461394e-03f, -3.94051559e-02f, 5.10368450e-03f, -4.09705862e-02f, 1.05885463e-02f, 2.54967902e-03f, 1.27219886e-03f, 4.00464758e-02f,
  -7.99989849e-02f, 3.62383835e-02f, 5.34075573e-02f, -1.42457439e-02f, 9.22545344e-02f, -2.61069089e-03f, 7.13515747e-03f, -5.96131533e-02f, 2.09945869e-02f, 2.97769662e-02f,
  -1.77036840e-02f, -1.99992061e-02f, -4.75113578e-02f, -9.22990777e-03f, 1.68809444e-02f, -3.70059200e-02f, -6.65238127e-02f, -2.33710520e-02f, 7.51651637e-03f, -2.08892208e-02f,
  -7.33918473e-02f, -4.43134941e-02f, -2.21539047e-02f, -6.31355941e-02f, 2.29257904e-02f, -3.43629457e-02f, -8.96142647e-02f, 4.18130029e-03f, -2.39070673e-02f, 9.04417560e-02f,
  -7.96005204e-02f, 2.27713391e-01f, -4.43442054e-02f, -1.15770511e-01f, -9.84598175e-02f, 8.69168434e-03f, -3.40200327e-02f, -5.22636902e-03f, 1.16279334e-01f, 1.05784312e-01f,
  -5.82751259e-02f, 1.02640621e-01f, 9.60110128e-02f, -1.60249099e-01f, -2.76984274e-01f, -7.97783062e-02f, -2.06519976e-01f, -2.40499042e-02f, -9.92870703e-02f, -1.12302653e-01f,
  -2.19485566e-01f, -2.82989591e-01f, -1.87910691e-01f, -1.35409102e-01f, -1.75487876e-01f, -1.77125130e-02f, -3.46258283e-02f, -1.09837418e-02f, -3.66263352e-02f, -6.50467724e-02f,
  -1.06832318e-01f, -8.46007913e-02f, -3.40014487e-03f, 9.37808212e-03f, -5.95205575e-02f, -6.17250102e-03f, 2.56182961e-02f, 6.85335621e-02f, -2.24402323e-02f, -7.50607392e-03f,
  -2.08087415e-02f, -2.68507134e-02f, -2.93769687e-02f, 4.52004671e-02f, 6.06327280e-02f, -3.71409878e-02f, 6.02661259e-02f, -6.80006109e-03f, -8.56096949e-03f, 1.26346769e-02f,
  -1.94014572e-02f, -6.50711730e-02f, -7.63541833e-02f, -3.08959000e-02f, -2.80029569e-02f, 7.38699436e-02f, 6.23220578e-02f, -1.39848597e-03f, -1.95070859e-02f, 5.24049029e-02f,
  2.27148756e-02f, -5.11003472e-02f, -1.37067605e-02f, 9.61193629e-03f, -4.78200149e-03f, 4.39620912e-02f, -9.34446044e-03f, -6.72567338e-02f, 1.06864842e-02f, -2.77954154e-02f,
  -4.45166007e-02f, 6.21120334e-02f, -6.68064505e-02f, 6.10227026e-02f, 2.06003878e-02f, 4.71748002e-02f, -4.52942327e-02f, -5.85132418e-03f, 2.02147826e-03f, -6.53082430e-02f,
  9.22609940e-02f, -7.31655285e-02f, 3.66513096e-02f, -1.21536432e-02f, 5.55766560e-02f, 3.63151506e-02f, -5.98805621e-02f, 7.30180517e-02f, -1.29327429e-02f, -6.14297539e-02f,
  -4.11188155e-02f, -8.43314007e-02f, 6.15329705e-02f, 3.11098341e-02f, -2.01778803e-02f, 8.25802796e-03f, -8.42375308e-02f, -6.75778836e-02f, 1.40129672e-02f, -5.68108186e-02f,
  6.57977443e-03f, -1.57347752e-03f, -6.72177970e-02f, -1.14571874e-03f, 5.91457039e-02f, 3.27115953e-02f, -4.36159782e-02f, -1.91306211e-02f, -7.16966242e-02f, -6.10188693e-02f,
  3.11189648e-02f, 2.95874495e-02f, 6.12956956e-02f, -2.23898496e-02f, -8.80419556e-03f, -3.88626605e-02f, 3.50847049e-03f, -2.93376148e-02f, 5.14275208e-02f, -1.45364301e-02f,
  1.42416269e-01f, -2.17629492e-01f, -1.63287759e-01f, -1.99518219e-01f, 1.39219537e-01f, -2.81961143e-01f, -7.29271844e-02f, -6.56049922e-02f, 1.87288716e-01f, -9.24427733e-02f,
  -4.57780063e-02f, -3.45850922e-02f, 1.35476748e-02f, -2.32053354e-01f, -2.22621113e-01f, 8.61266479e-02f, -3.03082913e-01f, -1.08522490e-01f, 1.32907301e-01f, -1.19012341e-01f,
  -3.14400927e-03f, -6.88335672e-02f, -1.23150371e-01f, -1.00302957e-02f, -1.02019131e-01f, -2.62905248e-02f, -4.18244898e-02f, 1.44281805e-01f, -2.53387630e-01f, -6.49538785e-02f,
  -6.91403821e-02f, 1.12466492e-01f, -3.54591236e-02f, 2.04738937e-02f, -5.13227098e-02f, 9.81031079e-03f, -4.54639420e-02f, 4.01376709e-02f, 2.85915304e-02f, -4.13645357e-02f,
  -1.89401899e-02f, -1.60486232e-02f, -5.56085519e-02f, 7.70576298e-02f, 5.60095049e-02f, -3.07841301e-02f, 1.76729504e-02f, -6.36684373e-02f, -2.85948385e-02f, 2.09922269e-02f,
  2.20689233e-02f, -5.70797995e-02f, -6.20268136e-02f, -3.49375755e-02f, 2.37369649e-02f, 3.81216519e-02f, -4.30474319e-02f, 5.61573682e-03f, -1.38488468e-02f, -6.04614802e-02f,
  8.89467634e-03f, 9.75614588e-04f, -1.73879378e-02f, 6.91973642e-02f, -1.48435927e-03f, 2.08966993e-02f, 1.41562885e-02f, -4.30647656e-03f, 8.07986781e-03f, -3.35208811e-02f,
  -7.16392999e-04f, -5.77655025e-02f, 4.03410522e-03f, -5.03965132e-02f, 5.55439107e-03f, -5.85450418e-02f, 1.12469569e-02f, -3.36425076e-03f, 3.13247591e-02f, -1.98909603e-02f,
  7.48533979e-02f, -3.15707661e-02f, 7.56604075e-02f, 6.53656125e-02f, -4.57232147e-02f, 6.86230808e-02f, 3.64299640e-02f, 1.77031979e-02f, 2.56006159e-02f, -5.32881450e-03f,
  -9.42583978e-02f, -1.54183522e-01f, 3.97615135e-02f, -9.32600815e-04f, -2.98055243e-02f, -6.56093806e-02f, 1.09459809e-03f, -3.81136499e-02f, -7.03268871e-02f, 3.76130752e-02f,
  -2.54464592e-03f, -9.63381026e-03f, 3.67955863e-02f, -5.04419692e-02f, -5.85571788e-02f, -3.14402208e-02f, -1.71019118e-02f, -6.26927838e-02f, -2.44571269e-02f, -7.20891694e-04f,
  -5.48021346e-02f, 3.33802053e-03f, 3.54064745e-03f, 1.71471070e-02f, -6.98286816e-02f, 2.38911733e-02f, 1.60316972e-03f, -4.03230339e-02f, -6.37897030e-02f, -1.11651560e-02f,
  3.21263194e-01f, -2.25166246e-01f, -1.67288885e-01f, 1.08682968e-01f, 2.50142127e-01f, 1.91038892e-01f, -1.05523311e-01f, 7.90325776e-02f, 1.06188230e-01f, -1.13672934e-01f,
  -1.52830090e-02f, -1.23330043e-03f, -3.56351733e-01f, 4.07400131e-02f, 1.01430327e-01f, -3.00520062e-01f, 5.41601889e-02f, -1.27798785e-02f, 6.72829710e-03f, 1.22508571e-01f,
  1.20484814e-01f, 1.50233209e-01f, -1.72339007e-01f, 1.19042642e-01f, 1.75243735e-01f, 5.18628955e-02f, -2.31878497e-02f, -9.33101252e-02f, 1.40512168e-01f, 4.87187058e-02f,
  -4.20179442e-02f, -5.27593121e-02f, 1.45225907e-02f, 8.48063361e-03f, 2.19293572e-02f, 1.12338543e-01f, -2.76281964e-02f, -6.12221286e-03f, 3.16646993e-02f, -6.85244380e-03f,
  -5.14317416e-02f, 1.15480293e-02f, 8.56973305e-02f, 9.32486076e-03f, 1.03675388e-01f, 3.59058455e-02f, 8.44527930e-02f, 4.09567729e-02f, -3.74749117e-02f, 1.68089643e-02f,
  -8.18047971e-02f, 1.03942156e-02f, 1.15388269e-02f, -1.57365464e-02f, 1.79046094e-02f, -1.04903560e-02f, -6.31185770e-02f, -1.26791717e-02f, 5.74361645e-02f, -1.33081684e-02f,
  -2.34579351e-02f, -1.75352991e-02f, -8.92442476e-04f, -2.41144951e-02f, -2.99201217e-02f, 1.88699160e-02f, -2.17807442e-02f, 2.92214472e-02f, -3.98667380e-02f, -1.04070324e-02f,
  -3.75134661e-03f, -1.49689494e-02f, 3.43990512e-03f, 7.71056022e-03f, -1.64545421e-02f, 4.98985965e-03f, -2.46089902e-02f, -2.39751060e-02f, -1.92210227e-02f, 2.14934163e-02f,
  -3.85165773e-02f, -1.67136153e-04f, -8.14175308e-02f, -1.84156671e-02f, 1.77231559e-03f, -5.15839830e-02f, 2.90025529e-02f, -5.36123179e-02f, -1.55733917e-02f, 1.65649634e-02f,
  2.50353501e-03f, -8.48552436e-02f, -7.32424483e-02f, -1.85582023e-02f, -5.16341180e-02f, -3.71752530e-02f, 9.51951742e-03f, 2.64013540e-02f, -1.09444140e-02f, 2.46900483e-03f,
  3.57534587e-02f, 4.27689776e-02f, -7.20345369e-03f, 3.69226746e-02f, 1.11506181e-02f, -4.40096110e-02f, -9.61871818e-02f, 6.98708883e-03f, -6.58536609e-03f, 2.03638878e-02f,
  2.39062607e-02f, -6.00978918e-02f, -2.78341193e-02f, 3.79340835e-02f, -3.17070484e-02f, 1.18767850e-04f, 1.05837464e-01f, 5.50965592e-03f, -6.15016930e-02f, -5.07326759e-02f,
  1.82162344e-01f, -1.70487270e-01f, -1.29798248e-01f, 1.44045144e-01f, 8.95619392e-02f, 4.06687744e-02f, 1.52854919e-02f, 6.98527768e-02f, -1.64430708e-01f, -1.10071011e-01f,
  1.59123016e-03f, 4.91007343e-02f, -2.13775337e-01f, -3.50395553e-02f, 1.62686437e-01f, -2.32805550e-01f, 1.60649747e-01f, -5.55974655e-02f, -1.07693359e-01f, 2.20085457e-01f,
  1.02407366e-01f, 2.29792133e-01f, 1.80212799e-02f, 1.04677148e-01f, 1.15341850e-01f, 1.69808827e-02f, 2.03993991e-01f, -3.43523026e-02f, 1.19529620e-01f, 1.17033534e-01f,
  -3.96563597e-02f, -5.80512099e-02f, 3.24600786e-02f, -6.38535172e-02f, 6.29508868e-02f, -3.37156542e-02f, 6.70319274e-02f, 4.36834060e-02f, 4.53814231e-02f, -6.66396401e-04f,
  5.91602288e-02f, 7.56184012e-02f, 2.74638459e-02f, -8.22435990e-02f, -5.72991706e-02f, -4.50341590e-02f, 6.54939935e-02f, 4.32841619e-03f, 4.53536510e-02f, -5.72811030e-02f,
  -8.74776170e-02f, 6.59036785e-02f, 2.32680123e-02f, -3.40968668e-02f, -2.14164294e-02f, -3.02828327e-02f, -1.32398093e-02f, 7.50265643e-02f, 6.03939518e-02f, -5.54632358e-02f,
  -2.20747404e-02f, -2.22562850e-02f, -6.10397682e-02f, -1.07241878e-02f, 1.92695521e-02f, 4.74412255e-02f, 5.34166060e-02f, 4.58945855e-02f, 7.55726323e-02f, 1.09877705e-03f,
  4.35801633e-02f, 4.73247208e-02f, 9.27031226e-03f, 4.54530008e-02f, 6.24949895e-02f, -2.08313949e-02f, -4.52821702e-02f, 6.86015636e-02f, 1.51738692e-02f, -2.22867802e-02f,
  4.10808548e-02f, 6.84446609e-03f, 3.25287320e-02f, 3.05905435e-02f, 2.99717039e-02f, 5.35984375e-02f, 1.59618258e-02f, -8.75264555e-02f, -8.26630667e-02f, 8.17433223e-02f,
  1.16053000e-01f, 1.06644474e-01f, -6.37560561e-02f, 4.29380238e-02f, 2.78811771e-02f, 5.33568934e-02f, -6.57669604e-02f, -2.37799585e-02f, -6.48505287e-03f, -1.17780743e-02f,
  1.23536810e-01f, -4.26130332e-02f, 4.94023301e-02f, -3.89758460e-02f, 2.21880507e-02f, 1.44508602e-02f, 1.08904004e-01f, -3.43913399e-02f, -5.27893798e-03f, -2.67997161e-02f,
  4.58898731e-02f, 2.89882161e-02f, 2.77117714e-02f, 2.00050920e-02f, 6.26474395e-02f, 8.53145346e-02f, 3.30583639e-02f, -4.17423435e-02f, 9.74972546e-02f, 3.59294824e-02f,
  5.83941787e-02f, -2.61166781e-01f, 2.06080928e-01f, 9.94031504e-02f, 2.84148492e-02f, -4.37328592e-02f, 1.53240487e-01f, -4.66785617e-02f, 9.43496153e-02f, -1.62266165e-01f,
  -7.62328729e-02f, 1.09082378e-01f, -7.54806846e-02f, 5.66570573e-02f, 1.75226972e-01f, 4.95493636e-02f, -3.82849947e-02f, -8.29533301e-03f, 8.40689093e-02f, -1.35984886e-02f,
  4.47557978e-02f, -3.60911675e-02f, -7.98941553e-02f, -1.63798079e-01f, -1.52685538e-01f, 1.27355726e-02f, -1.08905070e-01f, 5.05637713e-02f, -4.56970837e-03f, 2.26280699e-03f,
  -1.20857187e-01f, -8.44542217e-03f, -9.42296237e-02f, -7.16783404e-02f, -8.39769989e-02f, -8.87071863e-02f, 9.41208303e-02f, 1.93689708e-02f, 9.15147364e-02f, -2.94620097e-02f,
  6.35941252e-02f, -2.53019501e-02f, 8.82627219e-02f, 5.64013096e-03f, -8.64475369e-02f, -3.42113450e-02f, -1.09924842e-02f, -9.11899731e-02f, 5.83483949e-02f, 4.51804847e-02f,
  -4.48699072e-02f, -1.56629253e-02f, -3.86471022e-03f, 3.10818683e-02f, 2.80406270e-02f, -2.07442641e-02f, 7.70062208e-02f, 4.59560789e-02f, 6.33247867e-02f, 5.50503768e-02f,
  1.05018191e-01f, 7.82226399e-02f, -5.19599915e-02f, 2.84721479e-02f, 3.38975564e-02f, -9.87958089e-02f, -3.65876593e-02f, -3.02506499e-02f, 6.78254962e-02f, -4.12439480e-02f,
  -7.78021291e-02f, -3.89537471e-03f, -1.59455258e-02f, -2.85534225e-02f, 8.77023488e-03f, -3.88658494e-02f, -6.57761376e-03f, 3.96371186e-02f, 2.29894370e-02f, -1.36270598e-02f,
  1.13262668e-01f, -3.40716913e-02f, -6.30468279e-02f, -2.92196944e-02f, 5.45088798e-02f, 8.31456296e-03f, -7.85400271e-02f, -1.14675928e-02f, 2.67884210e-02f, 4.73162979e-02f,
  -1.69767395e-01f, -7.30589926e-02f, -8.51786211e-02f, -3.83092947e-02f, 2.40535121e-02f, -8.34688768e-02f, 1.16595536e-01f, 8.53569508e-02f, -6.09937496e-02f, 6.21269010e-02f,
  -9.67009217e-02f, 4.88414476e-03f, -7.16365874e-02f, 6.01470321e-02f, 5.62304743e-02f, -4.33159573e-03f, -1.94134675e-02f, 6.47846088e-02f, -2.09014080e-02f, -1.30625114e-01f,
  -1.17177881e-01f, 1.80096589e-02f, 8.83595049e-02f, -7.50139803e-02f, -5.27590401e-02f, 4.46755402e-02f, 5.50740436e-02f, 6.15286045e-02f, -3.76531892e-02f, 3.54948826e-02f,
  -6.34180158e-02f, 3.07512939e-01f, 2.09989995e-01f, -5.15128113e-02f, -1.57747075e-01f, -3.11407000e-02f, 1.35953262e-01f, -8.47504660e-03f, -1.86644644e-02f, 1.11787088e-01f,
  4.45583044e-03f, 2.03036562e-01f, 1.25423893e-01f, 1.49692208e-01f, -1.52401567e-01f, 1.19729243e-01f, -4.99171987e-02f, 9.98136960e-03f, 6.20040623e-03f, 8.30442235e-02f,
  -7.17006996e-02f, -7.90788978e-02f, 1.90795846e-02f, 7.24130422e-02f, 6.38212264e-02f, -4.81307916e-02f, -2.22869620e-01f, 1.07735857e-01f, -6.96009398e-02f, 7.73892477e-02f,
  6.85201660e-02f, 1.10772431e-01f, -2.44564246e-02f, 7.60578066e-02f, -1.00248180e-01f, -6.24373741e-02f, 5.16195893e-02f, -1.04754865e-02f, -2.80671380e-02f, 3.12891118e-02f,
  7.14243054e-02f, -6.11573458e-02f, 2.73758769e-02f, 6.67816624e-02f, -9.59284883e-03f, 4.40934934e-02f, 3.87569983e-03f, -2.05742028e-02f, -9.56923701e-03f, -2.15679239e-02f,
  1.25158563e-01f, -8.07636138e-03f, -1.26627516e-02f, 8.39951262e-03f, 4.80414890e-02f, -4.94851731e-02f, -5.95249310e-02f, 1.87427569e-02f, -7.69753307e-02f, -2.74414979e-02f,
  3.29685286e-02f, -6.62349984e-02f, -1.39618171e-02f, -9.52898897e-03f, 3.34426016e-02f, 4.11896110e-02f, -3.85777280e-02f, 2.34179571e-02f, 2.29863869e-03f, 6.02048524e-02f,
  -6.72394559e-02f, 6.24969155e-02f, -3.60483527e-02f, 1.46751422e-02f, -1.77250002e-02f, 1.35583105e-03f, -5.62185943e-02f, -3.66602540e-02f, -7.20819682e-02f, 1.10706408e-02f,
  6.38062656e-02f, 2.39882804e-02f, 4.69416566e-02f, -5.98665178e-02f, 6.26264438e-02f, -4.17320579e-02f, -2.29924303e-02f, 2.79450361e-02f, -6.88601807e-02f, -6.10665344e-02f,
  -8.06258246e-02f, -1.87631939e-02f, -1.28018484e-03f, -7.99081568e-03f, 8.83473009e-02f, -4.11235839e-02f, 1.03843659e-02f, 7.69536495e-02f, 6.14702962e-02f, 6.44355714e-02f,
  -7.85784945e-02f, -5.31140156e-02f, 3.03252563e-02f, 2.45855562e-02f, -7.02896640e-02f, -8.77071843e-02f, 4.96476106e-02f, -2.79995743e-02f, -2.82795075e-02f, 2.53206044e-02f,
  -7.56038427e-02f, 1.24818087e-02f, -3.55644189e-02f, -1.06653757e-01f, -9.28746164e-02f, 2.11739354e-02f, -5.77737279e-02f, -6.10743836e-03f, 5.44028915e-02f, 3.33940759e-02f,
  1.51534110e-01f, -7.20138988e-03f, 1.22727096e-01f, 1.17555149e-01f, -2.67706197e-02f, 2.32282758e-01f, 2.63787478e-01f, -4.81334217e-02f, 1.64024513e-02f, -1.20953538e-01f,
  5.74374869e-02f, 3.38150747e-02f, -2.17482764e-02f, -2.05186866e-02f, 3.23810548e-01f, 1.40940800e-01f, 1.45408690e-01f, 1.07624963e-01f, 4.79835756e-02f, 4.45177145e-02f,
  8.25263187e-02f, 4.20730449e-02f, 8.62897113e-02f, -2.42295787e-01f, 3.74202849e-03f, -1.26687288e-01f, -9.94840413e-02f, -5.16269021e-02f, -4.41596434e-02f, -2.11313763e-03f,
  5.15892878e-02f, 1.64405461e-02f, -5.12745837e-03f, -5.21722957e-02f, 1.07798576e-01f, 6.66917935e-02f, 3.57770547e-02f, -3.27972807e-02f, -5.49881794e-02f, -6.63538501e-02f,
  -2.16770563e-02f, 4.43541184e-02f, 7.85881560e-03f, -3.39703844e-03f, -5.13575636e-02f, -6.96066916e-02f, 2.44717691e-02f, 7.15927184e-02f, 7.43114501e-02f, -2.29804940e-03f,
  1.64569763e-03f, 4.60810773e-02f, -1.05840433e-02f, -2.05106270e-02f, 1.36378510e-02f, 1.63297802e-02f, 2.45007165e-02f, 1.76862758e-02f, -5.08730393e-03f, -7.28671476e-02f,
  -1.74701121e-03f, -1.42944157e-02f, 6.49896488e-02f, -2.62283981e-02f, 1.59661565e-02f, -1.02982089e-01f, 2.32335236e-02f, -2.14525145e-02f, -6.24422207e-02f, -9.14754998e-03f,
  1.20378342e-02f, -5.17757908e-02f, 2.29419637e-02f, 5.24742566e-02f, -1.20955026e-02f, 5.17888181e-02f, 2.26194635e-02f, 1.29934924e-03f, 8.78841355e-02f, 2.40739603e-02f,
  6.21682331e-02f, -1.41197266e-02f, 5.28864674e-02f, 6.30689859e-02f, -5.17936274e-02f, 4.57595997e-02f, -3.90307419e-02f, 4.41647097e-02f, -2.70453896e-02f, 6.62352964e-02f,
  2.64690462e-02f, -4.00224105e-02f, 5.23833185e-02f, -6.57769442e-02f, -7.49741718e-02f, 5.90665452e-02f, -2.26132888e-02f, -1.93977333e-03f, 8.33404958e-02f, 7.86012635e-02f,
  -3.42595484e-03f, -1.14897797e-02f, 3.24369036e-02f, -3.66465971e-02f, -4.74932641e-02f, 2.96981670e-02f, 6.87801540e-02f, 3.62197915e-03f, -4.98013049e-02f, 4.12939265e-02f,
  -3.69795162e-04f, -7.31739029e-02f, 5.72069325e-02f, -2.40434820e-04f, -9.44783166e-02f, 8.00187737e-02f, 2.67137699e-02f, -5.81446700e-02f, 8.77274200e-03f, 1.00652082e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.46780866e-02f, -1.06721692e-01f, -1.66547269e-01f, -1.42118081e-01f, -1.93666339e-01f, -1.35638759e-01f, -1.23651117e-01f, -7.85291418e-02f, 5.17578758e-02f, -6.43808767e-02f,
  -2.48438865e-01f, 4.24410291e-02f, 1.54815927e-01f, -2.46776223e-01f, 2.45883986e-01f, 2.37331659e-01f, -4.63248082e-02f, -4.40293215e-02f, -4.26087081e-02f, -3.11995018e-02f,
  2.06130203e-02f, -2.12656736e-01f, -5.29687945e-03f, -1.54958397e-01f, -3.07117552e-01f, -1.22242942e-01f, -6.86774589e-03f, -1.77581251e-01f, -2.54711717e-01f, -1.05009839e-01f,
  -6.25529215e-02f, -1.36231752e-02f, -1.11499242e-01f, 4.95568514e-02f, -8.04675836e-03f, -1.01417586e-01f, 5.45078609e-03f, 1.17136361e-02f, -9.11091492e-02f, 2.69214120e-02f,
  1.08123831e-01f, -1.29529717e-03f, -7.04600811e-02f, 1.02013372e-01f, -2.89161820e-02f, -5.91454422e-03f, 5.93093559e-02f, -2.91708577e-02f, -5.75630143e-02f, 6.73307180e-02f,
  3.04899812e-02f, 4.97053117e-02f, -1.09158650e-01f, 4.43612263e-02f, -5.51711395e-02f, -1.07215360e-01f, 6.78673834e-02f, 1.89386923e-02f, -5.28624170e-02f, -4.08731289e-02f,
  4.02303077e-02f, 9.22248811e-02f, 3.96678932e-02f, 1.21569270e-02f, -1.43914726e-02f, -6.60801679e-02f, 3.58161293e-02f, -1.52591337e-03f, 6.66745938e-03f, -2.20850334e-02f,
  -5.95042557e-02f, -8.78411606e-02f, -2.39326824e-02f, 3.42040546e-02f, -5.93651086e-02f, 2.90814787e-02f, -3.47558744e-02f, -5.82965724e-02f, 4.03225310e-02f, 3.14580537e-02f,
  4.17446978e-02f, -6.03193976e-02f, 4.54648808e-02f, 2.26469059e-03f, 4.32860591e-02f, 2.96255685e-02f, -6.91160839e-03f, 7.26624057e-02f, 6.86227158e-02f, -1.90672874e-02f,
  -2.00167522e-02f, 7.91006088e-02f, -1.99287273e-02f, -3.86806168e-02f, 6.73269182e-02f, 5.33061363e-02f, -2.09286828e-02f, 3.00752893e-02f, 2.84393430e-02f, -3.62957865e-02f,
  -8.66827518e-02f, 6.89373761e-02f, 2.16573440e-02f, -4.63577099e-02f, 4.35497463e-02f, -8.13297257e-02f, 6.43144324e-02f, 1.02962777e-01f, 8.04188699e-02f, 5.44630326e-02f,
  -3.01627815e-02f, -6.78540468e-02f, -1.25356559e-02f, -6.50837943e-02f, 3.12231109e-02f, 7.86714926e-02f, -1.37552209e-02f, 5.28365299e-02f, 3.84374708e-02f, 4.49331775e-02f,
  -8.17914903e-02f, -1.00906506e-01f, -1.55309290e-01f, 7.09466860e-02f, -1.11624822e-01f, -4.32625376e-02f, -1.32177368e-01f, 2.62290798e-02f, -1.38596576e-02f, 1.42134726e-02f,
  6.86509088e-02f, -4.55526598e-02f, 3.45975421e-02f, 1.30435050e-01f, -8.64412170e-03f, -1.95010789e-02f, 1.59371778e-01f, 4.66105826e-02f, 3.88383642e-02f, -1.14182800e-01f,
  6.16809428e-02f, 7.42748082e-02f, -4.92404550e-02f, 4.97407094e-02f, -1.06244884e-01f, 1.07348310e-02f, 1.26267791e-01f, 1.31697431e-02f, 4.86289300e-02f, 4.03220989e-02f,
  5.48511138e-03f, 5.42091280e-02f, 1.23156523e-02f, 3.56359147e-02f, -8.97382498e-02f, 1.25718554e-02f, 6.03262559e-02f, 3.59104499e-02f, 6.91666827e-02f, 1.41368797e-02f,
  -4.72898148e-02f, -7.67462328e-02f, 5.50938286e-02f, -9.80823301e-03f, -5.12618162e-02f, 5.51290624e-02f, -3.21731530e-02f, -6.26064762e-02f, -3.64392325e-02f, -1.30579636e-01f,
  -9.76604745e-02f, -5.43070510e-02f, -8.85611475e-02f, 1.00834914e-01f, -2.55521704e-02f, -1.38946511e-02f, 6.09677173e-02f, 2.83251591e-02f, 6.01223558e-02f, -8.09451286e-03f,
  1.00302204e-01f, -2.28463728e-02f, -4.25366908e-02f, 1.70862544e-02f, -4.83387671e-02f, 6.55125752e-02f, -4.26141880e-02f, -2.53878930e-03f, 3.93174961e-02f, 2.41493490e-02f,
  -5.92805259e-03f, 6.65055960e-02f, 2.03428194e-02f, 1.46144619e-02f, -1.29278107e-02f, -9.15824994e-02f, 5.61982840e-02f, -3.37521583e-02f, -1.34414015e-02f, -6.46018013e-02f,
  6.39182776e-02f, -7.56108686e-02f, -8.21128786e-02f, 9.88848731e-02f, 6.79675490e-02f, 8.34524781e-02f, 4.40183580e-02f, -3.12267449e-02f, -9.76462907e-04f, 4.40614596e-02f,
  -7.69590843e-04f, 5.08573465e-02f, -4.21858802e-02f, -1.14023872e-02f, 5.44030629e-02f, 2.59016789e-02f, 4.14612032e-02f, 1.99648980e-02f, 1.90527458e-02f, 3.79405130e-04f,
  -1.30306138e-02f, -2.26188023e-02f, 9.09859464e-02f, -7.32502192e-02f, 1.03439607e-01f, 8.39528292e-02f, 5.55375069e-02f, 2.52203308e-02f, 1.97872855e-02f, -1.12401298e-03f,
  -6.68208599e-02f, -4.69805449e-02f, 9.51253101e-02f, 6.58680405e-03f, 3.33237499e-02f, -3.06960531e-02f, 6.92574978e-02f, -4.60501984e-02f, 5.93250208e-02f, -2.92219259e-02f,
  7.33691528e-02f, 2.52736747e-01f, 2.45533194e-02f, 1.32311463e-01f, -9.59882364e-02f, 1.53205410e-01f, 7.96740130e-02f, 3.90141793e-02f, 1.97603732e-01f, 1.04840450e-01f,
  -1.85233742e-01f, 1.54232234e-01f, -1.15329795e-01f, -4.49760631e-02f, -7.87375420e-02f, -6.33971617e-02f, 7.03201666e-02f, 6.28245547e-02f, 4.46184762e-02f, 1.26767322e-01f,
  -9.54382122e-02f, -9.92589444e-02f, -1.76737055e-01f, -1.26568630e-01f, 5.05984984e-02f, -1.13996975e-02f, -1.24923319e-01f, -2.43607014e-02f, 1.95196774e-02f, -1.04049087e-01f,
  -3.75780202e-02f, -3.86082530e-02f, -3.46672423e-02f, 1.01975454e-02f, -6.46702852e-03f, 3.48972939e-02f, 1.18312851e-01f, -3.12424153e-02f, 1.19550480e-02f, 2.74205357e-02f,
  1.39059901e-01f, -1.00635374e-02f, 2.78215893e-02f, -8.32026526e-02f, -1.83455611e-03f, -5.88214844e-02f, 3.17689516e-02f, -5.01683019e-02f, 2.33080015e-02f, -3.44390124e-02f,
  1.01291025e-02f, -6.71506743e-04f, 6.60261586e-02f, 3.08435783e-02f, 5.20396605e-02f, -4.22692075e-02f, 5.40833510e-02f, 3.66692431e-02f, 1.44962063e-02f, 2.76894979e-02f,
  2.07387321e-02f, 2.98219323e-02f, 4.87013236e-02f, -3.69161218e-02f, -1.88795272e-02f, -3.41399759e-02f, -7.71427900e-02f, -3.90491448e-03f, -6.95271417e-02f, 6.87420741e-02f,
  -2.66004615e-02f, 1.03143724e-02f, 7.46761728e-03f, -9.83746350e-03f, 1.18280817e-02f, 5.07099219e-02f, -3.32138501e-02f, 1.09698884e-01f, 8.46210197e-02f, -3.41734029e-02f,
  -3.75364460e-02f, 1.99454091e-02f, 3.93974371e-02f, 5.13175167e-02f, -1.66789163e-02f, 1.31460908e-03f, -2.14626305e-02f, 1.86287276e-02f, 1.29626151e-02f, 1.86640639e-02f,
  1.03550732e-01f, 2.49309227e-01f, -3.37725841e-02f, -5.72330505e-02f, 1.97783764e-03f, 8.59585777e-02f, 1.31352078e-02f, 6.67680353e-02f, 9.70349312e-02f, -2.01146323e-02f,
  5.94208352e-02f, 5.14712743e-02f, 1.33043706e-01f, 4.32016812e-02f, -3.72375548e-03f, 1.00219123e-01f, 8.88762996e-02f, 3.75792235e-02f, 8.34390819e-02f, 1.68144889e-02f,
  9.16657895e-02f, 8.60409811e-02f, 5.67053370e-02f, 9.53112319e-02f, 4.86401096e-02f, -2.71172333e-03f, 4.80088070e-02f, 2.75350958e-02f, -3.17603275e-02f, -2.03106683e-02f,
  -5.26713207e-02f, 2.86821481e-02f, 1.71698496e-01f, 1.19974561e-01f, 2.73767021e-02f, -1.51227027e-01f, 6.41872063e-02f, -6.13060817e-02f, -3.53361256e-02f, 7.53770173e-02f,
  -3.44940126e-02f, 1.34272709e-01f, 4.96848226e-02f, -9.27598327e-02f, -2.40710199e-01f, -1.41646206e-01f, -1.78946376e-01f, 1.97748747e-03f, -7.87848756e-02f, 2.22814810e-02f,
  -2.60004494e-02f, -7.30518848e-02f, -6.65243119e-02f, -6.87982738e-02f, 1.50554910e-01f, 5.01822643e-02f, -2.08249036e-03f, 4.12468053e-02f, 8.12557992e-03f, -8.07643980e-02f,
  5.15112188e-03f, 8.07882771e-02f, 1.00664958e-01f, -4.96679060e-02f, -6.20689988e-03f, 1.14531443e-02f, 9.63071734e-02f, 5.95269464e-02f, -6.97303517e-03f, 2.56457017e-03f,
  6.91729262e-02f, -5.14408015e-02f, -4.49876767e-03f, 6.47467421e-03f, -3.01449616e-02f, -1.31843910e-02f, 1.07672997e-01f, -3.75850648e-02f, -5.18906899e-02f, 5.55704981e-02f,
  1.30958483e-01f, -6.43293485e-02f, 9.70061123e-02f, 1.26590598e-02f, -3.56683843e-02f, 9.36688855e-03f, -1.77286845e-02f, 1.89199590e-03f, -5.52892573e-02f, -3.57075706e-02f,
  -2.34652683e-02f, -2.27478091e-02f, 1.41877066e-02f, 6.57916591e-02f, 3.38487327e-02f, 4.78928117e-03f, 4.42714803e-02f, -8.99037197e-02f, -2.38863751e-02f, 6.57397360e-02f,
  -8.53673555e-03f, -5.35832606e-02f, -1.95538737e-02f, 7.23465979e-02f, 4.90246825e-02f, 7.65891001e-02f, -2.40615965e-03f, 1.05202738e-02f, -5.52151613e-02f, 5.12620062e-02f,
  -7.16590062e-02f, -4.98292334e-02f, -1.26594352e-03f, -2.97239516e-02f, -6.07708618e-02f, -4.02401462e-02f, 2.94759180e-02f, 5.84654994e-02f, 7.27172419e-02f, -2.86370665e-02f,
  -1.05216146e-01f, -7.94155449e-02f, 6.72103763e-02f, -5.33642769e-02f, 2.05910150e-02f, 6.11396618e-02f, -6.34833425e-03f, 2.28981618e-02f, 5.14669456e-02f, -9.02666226e-02f,
  -9.50877275e-03f, 4.53931466e-03f, 5.68530858e-02f, 6.19813986e-02f, 4.57391068e-02f, 3.95792946e-02f, -2.25425381e-02f, -7.88421631e-02f, 6.16642786e-03f, 9.36284140e-02f,
  1.14555441e-01f, -5.29708974e-02f, 4.65310700e-02f, 1.84220970e-02f, 6.76869228e-02f, 6.49898080e-03f, 4.21682227e-04f, 8.03141743e-02f, -2.22756807e-02f, 1.27800899e-02f,
  1.94405824e-01f, -3.76794450e-02f, 9.09674987e-02f, 3.17768529e-02f, 3.06023937e-03f, 1.51017224e-02f, 1.58778697e-01f, -1.11042865e-01f, -1.30864099e-01f, -1.33612037e-01f,
  7.32471719e-02f, 1.16244495e-01f, -7.19690397e-02f, 6.04549833e-02f, 2.27200523e-01f, 7.85609931e-02f, -4.00698893e-02f, 4.05057110e-02f, 2.98419800e-02f, -9.58980061e-03f,
  -1.10951550e-02f, 3.65726352e-02f, -3.14125344e-02f, -2.23422628e-02f, 2.22910922e-02f, -3.64629626e-02f, -2.47298535e-02f, 2.44739614e-02f, 6.46688649e-03f, 1.43166468e-01f,
  -4.28820476e-02f, 7.89676309e-02f, -5.07723726e-02f, -5.68276048e-02f, -4.06217314e-02f, 5.02753817e-02f, -3.71594951e-02f, -1.30341691e-03f, -5.73427938e-02f, 6.33378923e-02f,
  8.83212537e-02f, -2.98959911e-02f, 6.12190692e-03f, -6.74709305e-02f, -2.81353365e-04f, -9.75144804e-02f, -6.49812296e-02f, 4.12594676e-02f, -7.30672181e-02f, -4.97514661e-03f,
  -6.11087456e-02f, 1.19905127e-02f, 8.04494619e-02f, 2.52649076e-02f, -4.15086523e-02f, 7.02694952e-02f, 6.14849143e-02f, 1.08920515e-01f, -6.99558258e-02f, -6.56854883e-02f,
  3.26948762e-02f, -1.14243070e-03f, -4.69901934e-02f, 3.29414047e-02f, 6.06827810e-02f, 4.06094640e-02f, 8.49535540e-02f, 5.95344566e-02f, 2.69698370e-02f, 2.84989532e-02f,
  -7.74848685e-02f, -1.29668443e-02f, -6.11744858e-02f, -3.98001559e-02f, -5.87669648e-02f, -8.45732018e-02f, 4.01414419e-03f, 8.92522037e-02f, -4.25801277e-02f, 3.15925889e-02f,
  -4.43711914e-02f, 3.00931577e-02f, 3.39949457e-03f, -2.79251095e-02f, -1.03144655e-02f, -3.03616375e-02f, 6.44415691e-02f, -4.08943407e-02f, -6.41786307e-02f, -6.41821995e-02f,
  -3.18028554e-02f, -3.28309052e-02f, -3.88883166e-02f, 9.68494788e-02f, 5.51719181e-02f, 5.51504232e-02f, -2.19447725e-03f, -4.80833091e-03f, -4.56775911e-03f, -8.61776844e-02f,
  -5.90476841e-02f, -9.70957894e-03f, 7.32519254e-02f, 2.70293020e-02f, 1.12902662e-02f, -5.85108548e-02f, -5.68561591e-02f, 6.38760924e-02f, 1.80399921e-02f, 1.55158956e-02f,
  5.63753881e-02f, -6.82315379e-02f, -1.90428477e-02f, -9.35541540e-02f, 3.93174738e-02f, -2.30470821e-02f, 4.74589225e-03f, 5.63900061e-02f, -6.57491237e-02f, -3.84571254e-02f,
  7.57750496e-02f, 7.01778308e-02f, -9.58897024e-02f, 3.87647636e-02f, -1.03228003e-01f, 1.23261504e-01f, 6.36574486e-03f, 1.89737231e-02f, -1.55039892e-01f, 6.73234835e-02f,
  1.28520027e-01f, 7.55801871e-02f, -1.15167558e-01f, 2.53625274e-01f, -2.15259716e-02f, -5.23740500e-02f, 2.04172641e-01f, 9.39773619e-02f, 2.76961066e-02f, 7.59457946e-02f,
  5.01807854e-02f, 2.12199390e-01f, -4.46685031e-02f, -2.06328253e-03f, 7.49428049e-02f, -8.42934549e-02f, -6.75079897e-02f, -2.17053127e-02f, 1.83509082e-01f, 1.10776223e-01f,
  5.15809879e-02f, 1.37343323e-02f, 5.24830967e-02f, 6.58820719e-02f, 1.58032700e-02f, 9.30708423e-02f, -4.07027006e-02f, 4.45981510e-02f, 8.26048572e-03f, -6.45058900e-02f,
  -4.55097444e-02f, -6.65226355e-02f, 7.66084343e-02f, -1.61012877e-02f, -5.13911322e-02f, -1.74576994e-02f, 7.64397904e-02f, -6.18764758e-03f, -8.14310238e-02f, 6.04365803e-02f,
  -4.74666767e-02f, -3.59806530e-02f, -8.50334764e-03f, 2.99024861e-02f, 2.33318731e-02f, -1.63390692e-02f, 2.66829338e-02f, -6.78524300e-02f, -8.11335891e-02f, -6.07795306e-02f,
  -7.78431296e-02f, -1.99066475e-02f, -7.31548816e-02f, 9.56077222e-03f, 3.29088680e-02f, 4.12607193e-02f, 4.38215397e-02f, -5.89274056e-02f, 4.00588401e-02f, 9.33713019e-02f,
  5.16903214e-02f, -8.30625370e-03f, -6.44729808e-02f, 1.03733260e-02f, -4.59249020e-02f, -5.65031432e-02f, -5.95068373e-02f, 6.65389597e-02f, -5.76941483e-02f, 8.28721151e-02f,
  1.26660289e-02f, -1.22181587e-02f, -3.65927182e-02f, -3.00213471e-02f, -3.12500559e-02f, -3.15761752e-02f, 6.72626495e-02f, 1.32563962e-02f, 3.03659271e-02f, -4.33831736e-02f,
  -6.61206944e-03f, 3.73169035e-02f, -9.50901806e-02f, -2.04454884e-02f, -6.45237118e-02f, 8.18255395e-02f, 3.33823869e-03f, 2.23255046e-02f, -7.39992484e-02f, 4.79807071e-02f,
  -3.40796411e-02f, -2.85312962e-02f, 2.02661473e-02f, 8.02292451e-02f, -6.62976503e-02f, -5.67301875e-04f, -6.88578784e-02f, 1.68730784e-02f, -5.90565614e-02f, -4.92872410e-02f,
  -8.27992111e-02f, 2.58294381e-02f, 5.12197567e-03f, -3.11009702e-04f, -2.29083840e-02f, 4.45635952e-02f, -3.30446125e-03f, 4.92554121e-02f, 2.90385261e-02f, -2.62943399e-03f,
  8.43024775e-02f, 8.85560960e-02f, 1.43076358e-02f, 6.62887618e-02f, 8.81980918e-03f, 2.56930161e-02f, 3.28119807e-02f, 9.68785211e-02f, 1.58584677e-03f, 9.66782048e-02f,
  1.32164463e-01f, 1.53282844e-02f, 4.62738052e-02f, -3.99828367e-02f, 1.34147936e-03f, -4.18636017e-02f, -6.32671267e-02f, 7.68528953e-02f, -7.51128718e-02f, -6.92436546e-02f,
  -9.44814384e-02f, 1.31008640e-01f, 1.04634063e-02f, 1.02917068e-01f, 9.20596123e-02f, -2.92736497e-02f, 5.87086454e-02f, -8.38209391e-02f, 3.43727171e-02f, 8.28693584e-02f,
  -2.59979200e-02f, -6.61540851e-02f, -5.19053312e-03f, -3.29655148e-02f, 2.18387041e-02f, 1.00913038e-02f, 2.03344561e-02f, 5.36406375e-02f, -2.98773739e-02f, 8.16859026e-03f,
  -6.96383864e-02f, 2.06422955e-02f, 2.71029919e-02f, 2.35167798e-02f, 1.01902112e-01f, -3.25986370e-02f, -3.84042016e-03f, -7.30909593e-03f, 7.05927238e-02f, 5.49078658e-02f,
  -7.61652589e-02f, -4.57498990e-03f, -2.88836975e-02f, 1.32596008e-02f, 6.54286519e-02f, -6.89555779e-02f, -1.15146954e-03f, -7.84896016e-02f, -3.60084437e-02f, 1.59699693e-02f,
  4.56411205e-02f, 7.32335895e-02f, 8.39535072e-02f, 8.49010423e-02f, 7.46823335e-03f, -3.78112011e-02f, 1.79871954e-02f, 8.00285190e-02f, 7.87162259e-02f, -3.93393934e-02f,
  5.42465188e-02f, 5.67156561e-02f, -5.46229891e-02f, -4.54482213e-02f, -4.70614396e-02f, -2.36103572e-02f, -2.18059663e-02f, 7.27965534e-02f, 4.73359786e-02f, 5.19579463e-02f,
  -4.42739278e-02f, -7.91039243e-02f, -5.85936271e-02f, 5.37552349e-02f, -4.96747121e-02f, -2.76360046e-02f, 5.92453703e-02f, 5.62762981e-03f, 3.47248763e-02f, 6.91062436e-02f,
  -6.31429907e-03f, -9.82386619e-02f, -6.86573237e-02f, 1.04313046e-01f, -8.13684165e-02f, -3.70700695e-02f, -8.46967995e-02f, -8.36774558e-02f, 3.19943987e-02f, -7.32688829e-02f,
  -5.96072040e-02f, -5.24202287e-02f, -5.67110963e-02f, -2.55732102e-05f, -9.68104452e-02f, 1.18570728e-02f, 1.40784858e-02f, -5.42579815e-02f, -5.33667579e-03f, -7.59995133e-02f,
  -2.15490256e-02f, 9.55876261e-02f, 3.64249572e-02f, 8.00112858e-02f, -9.86956507e-02f, 4.59706970e-02f, -1.24204010e-02f, -7.05247000e-02f, 6.11143708e-02f, -6.97362572e-02f,
  -9.75745171e-02f, -2.87771195e-01f, -6.12524599e-02f, 6.84387013e-02f, 6.02535568e-02f, -7.99949691e-02f, -1.25804737e-01f, -9.92143974e-02f, -1.29173964e-01f, -2.16537267e-01f,
  4.39590868e-03f, 2.39371080e-02f, -3.09100986e-01f, 2.19443455e-01f, 2.24161729e-01f, -1.48165166e-01f, 7.17519522e-02f, 2.85818521e-02f, -5.81124648e-02f, -3.05558257e-02f,
  1.56797379e-01f, 1.49405092e-01f, 1.60081536e-01f, 2.22588673e-01f, 2.59809699e-02f, 4.19045873e-02f, 2.11670503e-01f, 1.56838764e-02f, 2.14405209e-01f, 1.27152145e-01f,
  6.73199771e-03f, -1.11426249e-01f, 5.06274104e-02f, -4.97269407e-02f, -9.57353488e-02f, 5.11886552e-02f, 1.87394600e-02f, 1.09101005e-01f, -1.63515098e-02f, 1.81503384e-03f,
  -1.06161565e-01f, 7.79291987e-02f, -4.50582802e-03f, 4.24147993e-02f, 2.49832775e-02f, 7.82363713e-02f, 7.42211044e-02f, 7.47358147e-03f, -1.52643099e-02f, -2.39482876e-02f,
  -4.65872586e-02f, -5.54593354e-02f, -3.98233309e-02f, -9.44788381e-03f, 6.55695871e-02f, -3.79225425e-02f, 2.41695065e-02f, 4.05887067e-02f, -5.67634553e-02f, -3.70490104e-02f,
  -9.91074741e-03f, 6.94334134e-02f, 6.40236028e-03f, 1.65504180e-02f, 6.64525107e-02f, 5.09598386e-03f, 8.59768689e-02f, -5.43934442e-02f, -4.54913042e-02f, 1.14272851e-02f,
  -3.67278345e-02f, 6.08765744e-02f, -4.11877483e-02f, -2.26016864e-02f, -5.63618094e-02f, 5.28714731e-02f, 5.25255352e-02f, -4.45150398e-02f, 5.10317013e-02f, -1.23963188e-02f,
  8.28503072e-03f, -5.42265736e-02f, -1.28439581e-02f, 4.27968577e-02f, -2.71716136e-02f, -5.91908619e-02f, 2.58415379e-02f, -6.63898587e-02f, -4.44414131e-02f, -6.16699085e-03f,
  -1.41146421e-01f, 2.03848630e-02f, -5.99918589e-02f, -2.10438985e-02f, -4.23827134e-02f, -4.25055549e-02f, 4.18653116e-02f, 7.79549330e-02f, -4.93006520e-02f, -1.14301197e-01f,
  4.76316735e-02f, 2.35382933e-02f, 2.23861635e-02f, -3.49617526e-02f, 6.44988641e-02f, 3.47665735e-02f, 1.59314591e-02f, -2.53345631e-02f, -4.52212840e-02f, -5.10032959e-02f,
  -4.25610989e-02f, -3.54302749e-02f, -2.53047515e-02f, -1.22015933e-02f, 9.23653692e-02f, 6.45901486e-02f, -5.98562369e-03f, -2.04357039e-02f, 6.31625056e-02f, 2.77463607e-02f,
  -5.69181181e-02f, 6.00100830e-02f, -5.39854541e-02f, -6.25020266e-02f, -2.89543252e-03f, -1.15639918e-01f, -2.15750918e-01f, -5.48208579e-02f, 6.33088825e-03f, 1.48715883e-01f,
  -3.35487910e-02f, 9.62745175e-02f, 1.08859381e-02f, -1.24964252e-01f, -1.41563147e-01f, 3.88649926e-02f, -1.65306270e-01f, 1.61151122e-02f, -4.57377732e-02f, -1.88396901e-01f,
  -6.68988228e-02f, -1.57915488e-01f, -1.19924964e-03f, 6.14168085e-02f, -1.97280594e-03f, -7.87022430e-03f, 2.16831099e-02f, -9.92283374e-02f, -2.09116936e-03f, -2.94958297e-02f,
  1.92766115e-02f, -1.45854220e-01f, -7.98946396e-02f, 6.79577589e-02f, -5.69728464e-02f, -4.01278511e-02f, 7.92312156e-03f, -2.74306480e-02f, 4.86561330e-03f, 6.47081286e-02f,
  7.98495710e-02f, -8.91353339e-02f, -3.46670114e-02f, 3.19737904e-02f, -5.95538132e-03f, 3.92044187e-02f, 5.67229278e-03f, 5.80391437e-02f, 1.18307518e-02f, -7.20054880e-02f,
  6.04870059e-02f, 2.02171206e-02f, 5.60716055e-02f, 5.59932478e-02f, 4.38464321e-02f, -3.41135636e-02f, -4.50309701e-02f, 8.02275687e-02f, 4.03598920e-02f, 4.55813110e-02f,
  8.75057504e-02f, 3.31022143e-02f, -1.97406802e-02f, 8.28295294e-03f, -8.44594911e-02f, -7.44532496e-02f, 9.47813168e-02f, -2.84411479e-03f, 2.79329047e-02f, -5.45339063e-02f,
  -5.78964762e-02f, -5.15899286e-02f, -2.29190616e-03f, -7.05528483e-02f, -4.80763316e-02f, -4.82960604e-03f, -1.09562427e-02f, 5.66835962e-02f, -8.31951350e-02f, -2.61798520e-02f,
  -6.74784631e-02f, 7.31924921e-02f, 7.14147463e-02f, -2.56022792e-02f, -8.12504813e-03f, 2.41072346e-02f, -7.57970810e-02f, -9.45104137e-02f, -8.62857327e-02f, 3.59961651e-02f,
  -1.79351866e-01f, -1.87104702e-01f, -7.43135363e-02f, 3.23154815e-02f, -2.38695648e-02f, 7.73319751e-02f, 4.83755544e-02f, -7.16995746e-02f, -5.54831475e-02f, -4.47715335e-02f,
  6.62733801e-03f, 1.75833572e-02f, -5.93806757e-03f, 8.36819708e-02f, -7.51784369e-02f, -4.17168513e-02f, -4.88033630e-02f, -3.11745517e-02f, -4.89207283e-02f, 7.43669569e-02f,
  2.45240554e-02f, 7.56850839e-02f, -4.00154553e-02f, 6.80529252e-02f, 7.09982514e-02f, 7.60598928e-02f, -8.23137164e-02f, 5.51217198e-02f, -1.57376184e-04f, -7.58702308e-02f,
  -2.17187241e-01f, -1.09496238e-02f, -1.83595926e-01f, -2.18134195e-01f, 9.33914408e-02f, -2.04897478e-01f, -1.57673415e-02f, 1.70272738e-02f, 1.28503116e-02f, 1.77923858e-01f,
  6.65891320e-02f, -5.56533672e-02f, 1.78643212e-01f, -6.98798969e-02f, -3.24470192e-01f, -1.22289017e-01f, -2.37333998e-01f, -1.81193218e-01f, -4.60642986e-02f, 1.88227762e-02f,
  -1.33138269e-01f, 8.59180912e-02f, -5.79188252e-03f, 6.71229139e-02f, -5.28709814e-02f, -1.28254779e-02f, -1.04872081e-02f, 2.15550289e-01f, -1.20649688e-01f, 1.00725368e-01f,
  -6.16915640e-04f, 3.81414816e-02f, -5.17063309e-03f, -4.26828824e-02f, -1.07955210e-01f, -8.00583586e-02f, -4.47004288e-02f, 9.84839723e-03f, -9.68467910e-04f, -7.28353634e-02f,
  -3.73394266e-02f, 7.99717605e-02f, 4.01353799e-02f, 6.06690682e-02f, -3.58183612e-03f, -3.36292423e-02f, -1.80693250e-02f, -9.32998881e-02f, 3.62037867e-02f, 1.70816835e-02f,
  -1.99090987e-02f, 1.35826310e-02f, -1.10995419e-01f, -7.00124949e-02f, -7.34260380e-02f, -5.67946918e-02f, 6.20365329e-03f, -4.40749340e-02f, 1.48814879e-02f, -1.25243440e-02f,
  3.83635126e-02f, 7.26349577e-02f, 3.08274832e-02f, -3.97099219e-02f, -3.76828499e-02f, -3.34350355e-02f, 8.34512413e-02f, 5.69921210e-02f, 3.61876078e-02f, -2.29074564e-02f,
  2.81651057e-02f, 7.30720088e-02f, 4.03849445e-02f, -4.41293828e-02f, -1.54401204e-02f, 5.92465848e-02f, -3.30056809e-02f, 3.12167164e-02f, -5.96130732e-03f, -4.03663181e-02f,
  6.70263842e-02f, -7.93139625e-04f, -3.35328989e-02f, 3.32923271e-02f, 3.40656973e-02f, -1.04620364e-02f, 3.63657624e-02f, 2.84257475e-02f, -1.06063252e-02f, -3.91736962e-02f,
  5.07693663e-02f, 7.29822069e-02f, 8.78774896e-02f, -2.63246032e-03f, -6.14697393e-03f, -8.09936076e-02f, 2.35108007e-02f, -9.83523428e-02f, -1.79538801e-02f, -3.53667401e-02f,
  2.05650721e-02f, 3.48450728e-02f, -5.78597886e-03f, 6.87280968e-02f, -7.68055324e-05f, 3.69014293e-02f, 3.67081948e-02f, 3.61705683e-02f, -7.48306662e-02f, 9.08074342e-03f,
  1.18358567e-01f, 9.96999163e-03f, 3.13272327e-02f, 5.96696185e-03f, 4.76092696e-02f, 2.99605578e-02f, -1.51329497e-02f, 6.21138103e-02f, 6.30776361e-02f, 6.06524423e-02f,
  1.12900309e-01f, 6.19919114e-02f, -1.22570321e-01f, -1.16474472e-01f, -1.17067836e-01f, 1.31809795e-02f, -8.15356150e-02f, -4.23114095e-03f, 9.51879919e-02f, 9.92333665e-02f,
  -1.35488376e-01f, 1.33363664e-01f, 3.72952269e-03f, 1.45259527e-02f, 6.81523457e-02f, 1.24364913e-01f, -3.37518156e-02f, 3.08445841e-02f, 9.20274481e-03f, 4.78024743e-02f,
  -5.46386056e-02f, 6.83230907e-02f, -7.24415183e-02f, -6.03424497e-02f, -1.73318401e-01f, 1.30019262e-02f, 4.95371269e-03f, -1.01858355e-01f, -1.27215847e-01f, -1.32721262e-02f,
  -3.80820855e-02f, 1.19445860e-01f, -8.55470523e-02f, 4.60037440e-02f, 1.85823366e-02f, -1.23846997e-03f, 2.87331194e-02f, 2.34224871e-02f, -3.52195539e-02f, -1.58832707e-02f,
  3.41734886e-02f, 8.65251496e-02f, -1.65599864e-02f, 2.56367382e-02f, -4.67872657e-02f, -6.05383813e-02f, -6.25128523e-02f, -3.67127322e-02f, -8.05855095e-02f, -6.79721087e-02f,
  3.28019150e-02f, -4.02675718e-02f, -7.17155263e-02f, -6.83750138e-02f, -1.14882793e-02f, -3.88631932e-02f, -3.65379415e-02f, -1.05465189e-01f, -4.64984290e-02f, 6.61819354e-02f,
  1.17002010e-01f, -4.82922494e-02f, -5.04198298e-02f, -5.79027878e-03f, -5.89048816e-03f, -9.43833962e-02f, -4.81840186e-02f, 1.99856684e-02f, 1.22308331e-02f, -8.49184841e-02f,
  -3.38461734e-02f, -1.04396760e-01f, -7.92959183e-02f, 6.10515736e-02f, 7.49128014e-02f, 3.16789113e-02f, 2.63520572e-02f, 7.98830763e-02f, -9.08161327e-03f, 6.71863556e-02f,
  -4.49884776e-03f, -3.26695666e-03f, 5.11988662e-02f, 7.18822656e-03f, -7.41956457e-02f, 3.97930853e-02f, 2.38476451e-02f, 3.77056971e-02f, -7.44332299e-02f, 2.41416954e-02f,
  2.59699430e-02f, 1.63713589e-01f, 3.30946520e-02f, 8.04545432e-02f, -2.79724728e-02f, -2.03439407e-02f, -5.02378605e-02f, -1.11601632e-02f, 1.24021647e-02f, 1.15391891e-02f,
  -5.34315929e-02f, -7.02114869e-03f, -4.57119681e-02f, 2.65098196e-02f, 2.05268152e-02f, -5.80033511e-02f, -8.13760608e-02f, 9.63556916e-02f, 1.65491402e-02f, -4.81247827e-02f,
  7.04676583e-02f, 7.26725860e-03f, 9.28378701e-02f, 7.32950643e-02f, -7.60214925e-02f, -6.97792619e-02f, -1.52984904e-02f, 5.16358726e-02f, -7.94737563e-02f, 9.05946568e-02f,
  -6.69145808e-02f, -2.33095642e-02f, -5.85958026e-02f, -1.83023326e-02f, 7.44596869e-02f, 2.08518565e-01f, 1.26436263e-01f, 1.82237908e-01f, -1.60431843e-02f, 2.47119423e-02f,
  1.00020409e-01f, 1.78921334e-02f, -1.29757458e-02f, 1.63630277e-01f, 5.50172059e-03f, 3.18070017e-02f, 4.10004556e-02f, 9.65224057e-02f, -3.51479203e-02f, 3.69226304e-03f,
  -1.88199729e-02f, 1.42103046e-01f, -1.04790591e-01f, 5.15101524e-03f, 1.00380398e-01f, -1.46504626e-01f, 1.74902100e-02f, -8.04001838e-02f, -3.63473669e-02f, 7.52373114e-02f,
  6.02795407e-02f, -4.87625226e-02f, 2.78392434e-02f, -6.06065728e-02f, 1.44177927e-02f, 8.56244639e-02f, -8.92158151e-02f, 7.30966255e-02f, 1.25681311e-02f, 5.11810407e-02f,
  6.11901097e-02f, 7.68927708e-02f, 7.89916664e-02f, -6.02959655e-03f, -1.83703098e-02f, -3.79527174e-02f, 3.55231017e-02f, -1.03487913e-02f, 4.82634008e-02f, -6.20512627e-02f,
  4.11340892e-02f, 5.53155318e-02f, 2.50849547e-03f, -1.02641299e-01f, -5.65953739e-02f, 1.76323969e-02f, 1.92115195e-02f, 4.58959602e-02f, 4.17134278e-02f, 6.48490041e-02f,
  1.00779030e-02f, -5.24590872e-02f, 4.17267065e-03f, -7.35925604e-03f, -7.00447857e-02f, -8.67041387e-03f, 2.63551101e-02f, -8.41113646e-03f, 3.36774020e-03f, -4.82810065e-02f,
  -7.34953070e-03f, -3.26321423e-02f, 2.78266724e-02f, 3.29249948e-02f, 7.20803961e-02f, 5.33643179e-03f, -4.17298861e-02f, 5.86728416e-02f, -5.71499616e-02f, -3.93593870e-02f,
  -6.39888197e-02f, 6.87293708e-02f, -6.64136633e-02f, 1.78689845e-02f, -1.78396590e-02f, 6.77143782e-02f, -6.00322336e-02f, 3.52755934e-02f, -4.93437685e-02f, 3.57452757e-03f,
  1.02335028e-01f, -3.96286547e-02f, 3.68867368e-02f, -5.63007817e-02f, -2.99488176e-02f, -5.08119091e-02f, -5.37570640e-02f, 1.03508167e-01f, -8.76262933e-02f, 6.25859275e-02f,
  -1.20509285e-02f, -6.67094067e-02f, 3.18891853e-02f, 7.39683285e-02f, -4.63896655e-02f, 1.48893937e-01f, -1.64100640e-02f, -4.11273092e-02f, -4.10279669e-02f, 7.63049200e-02f,
  4.65652347e-03f, 8.16567093e-02f, -5.20234220e-02f, -7.26796761e-02f, 6.37577549e-02f, -7.85603970e-02f, 3.64991836e-02f, -1.25065297e-01f, 6.21083826e-02f, -5.54709882e-02f,
  4.40884195e-02f, -4.19925675e-02f, -3.12373012e-01f, -1.49342209e-01f, -1.05141893e-01f, -3.19066532e-02f, -2.92038061e-02f, -5.57081215e-02f, 1.74355246e-02f, 9.41317007e-02f,
  5.93455657e-02f, 9.68721509e-02f, 4.15523089e-02f, -3.24442312e-02f, 1.34473011e-01f, 2.10751638e-01f, 4.51844409e-02f, 5.27933240e-02f, -5.17025143e-02f, -5.64178228e-02f,
  6.47267923e-02f, 1.30172357e-01f, -1.27793103e-01f, -1.29065681e-02f, -1.23727739e-01f, -1.40962675e-01f, 3.59160900e-02f, -1.93718359e-01f, 4.09372970e-02f, 3.89985926e-02f,
  -5.32074198e-02f, -3.97401787e-02f, -1.36564180e-01f, -4.34503593e-02f, -3.96483280e-02f, 2.26769084e-03f, -2.10924866e-03f, -1.04287760e-02f, 2.31823809e-02f, -9.02099460e-02f,
  -8.74447301e-02f, -7.95924440e-02f, 4.05017845e-02f, -5.55980988e-02f, -1.27205132e-02f, -2.97193378e-02f, 4.82136421e-02f, -9.63839144e-03f, -5.29758409e-02f, 1.00470344e-02f,
  -4.32237051e-02f, -7.18779713e-02f, 3.00474521e-02f, 7.75925517e-02f, -1.74050801e-03f, -8.73306468e-02f, 8.15841369e-03f, 3.71175483e-05f, 6.98152632e-02f, 4.52423580e-02f,
  7.67980097e-03f, 5.12983762e-02f, 1.54840713e-02f, 2.06255796e-03f, 1.07439449e-02f, 1.73495039e-02f, -3.45423371e-02f, 9.20741409e-02f, 1.71272848e-02f, 3.92525457e-02f,
  6.62341565e-02f, -1.75530780e-02f, 6.88969269e-02f, -5.98994195e-02f, -1.46480501e-02f, -2.01574340e-02f, 6.93122000e-02f, -3.03613804e-02f, 4.54565622e-02f, 1.02666933e-02f,
  -6.82529956e-02f, 4.68034819e-02f, 3.22269537e-02f, 8.93222541e-03f, 2.20476673e-03f, 4.75271009e-02f, 3.30489427e-02f, -8.35047737e-02f, 6.76590279e-02f, -1.91970132e-02f,
  6.26260489e-02f, 1.00640114e-02f, -1.32726869e-02f, 3.06143127e-02f, -6.97549060e-02f, 2.83914469e-02f, 7.11788982e-02f, 6.70112111e-03f, -8.62238556e-02f, 2.02435628e-03f,
  -8.82739723e-02f, -7.78735057e-02f, 8.78507644e-02f, 2.51243426e-03f, 7.03039914e-02f, 9.37749967e-02f, -6.37996942e-02f, 4.49644513e-02f, -2.52655391e-02f, -4.09714691e-02f,
  4.80290726e-02f, -2.52024084e-02f, -5.43274265e-03f, -4.49982509e-02f, -4.06002142e-02f, 5.49015962e-02f, 8.21211264e-02f, -6.70453310e-02f, 7.35552311e-02f, -5.73563613e-02f,
  3.35112140e-02f, 1.09173998e-01f, 1.20030157e-01f, 1.07803963e-01f, -1.95866991e-02f, -2.63193697e-02f, 9.44697410e-02f, -9.56963524e-02f, 8.33427832e-02f, 1.30505651e-01f,
  5.28513268e-03f, 9.11768973e-02f, -4.67168801e-02f, -1.58706065e-02f, -5.28599583e-02f, -8.64293054e-02f, 5.34481108e-02f, 3.01649105e-02f, -2.60804463e-02f, 9.39746946e-03f,
  -9.99221858e-03f, 4.77791354e-02f, -1.05054080e-02f, -2.68633291e-02f, -7.07066013e-03f, -3.63210700e-02f, 2.68079862e-02f, 3.95850372e-03f, -8.59113690e-03f, -5.05953878e-02f,
  4.97418679e-02f, 2.22118176e-03f, 7.33833248e-03f, 8.48563295e-03f, 3.30018178e-02f, 1.07976995e-01f, 4.57036272e-02f, -1.00176744e-01f, -1.80823114e-02f, -3.86575013e-02f,
  2.81552803e-02f, 4.10612784e-02f, 3.52091230e-02f, 1.62086207e-02f, -1.04811760e-02f, 3.33031118e-02f, 1.90451648e-02f, -6.47770688e-02f, 2.48615611e-02f, 3.76514532e-02f,
  1.68579351e-02f, -7.32414331e-03f, -6.29765317e-02f, 4.79334854e-02f, -8.96107778e-02f, 8.25979784e-02f, 1.04077958e-01f, -5.09273298e-02f, -1.87918544e-02f, -1.18780453e-02f,
  -5.16733974e-02f, 3.20640616e-02f, -3.60649899e-02f, -2.55554412e-02f, -6.00820407e-02f, -1.20559963e-03f, -9.04771760e-02f, 5.74688092e-02f, -4.41603623e-02f, 3.29617336e-02f,
  5.16747870e-02f, -6.01396002e-02f, -6.09368123e-02f, 5.92372417e-02f, 3.42900790e-02f, -9.49635878e-02f, 4.57180515e-02f, 5.44622131e-02f, 1.20042693e-02f, -9.05098245e-02f,
  -3.93198431e-02f, 7.30183572e-02f, 7.94562772e-02f, -7.74914399e-02f, 2.16190480e-02f, -5.17214015e-02f, 3.29120308e-02f, -4.74122725e-02f, 5.33036478e-02f, -5.86551353e-02f,
  1.96900368e-02f, 4.94094491e-02f, -5.58032803e-02f, -3.43570560e-02f, -5.28311320e-02f, 4.41290811e-02f, -6.20516576e-02f, -7.53718093e-02f, -3.00872363e-02f, -1.30467210e-03f,
  -6.39637411e-02f, -4.53581288e-02f, 5.64530790e-02f, 6.66818693e-02f, 8.25076327e-02f, 7.20691234e-02f, 8.11902508e-02f, 7.99378231e-02f, 1.04687043e-01f, 8.09001848e-02f,
  7.12863402e-03f, 2.56255902e-02f, -2.61338037e-02f, -6.31555170e-02f, -7.37682879e-02f, 5.36808046e-03f, 9.14920717e-02f, 7.56057650e-02f, 4.26410176e-02f, 5.01880273e-02f,
  -9.98525918e-02f, -7.39103258e-02f, 2.71764901e-02f, -8.97527486e-02f, 1.40433058e-01f, 1.71972305e-01f, 8.08518380e-02f, 8.48525837e-02f, 5.79728968e-02f, 5.73846363e-02f,
  -2.26797163e-02f, -1.86807767e-01f, 3.56592238e-02f, -1.51547238e-01f, -6.19797744e-02f, -8.47809613e-02f, 2.75261644e-02f, -4.56943326e-02f, 1.38679531e-03f, -7.29556009e-02f,
  -7.83307850e-02f, -2.63740625e-02f, -5.53514771e-02f, 4.99674305e-02f, -7.48698786e-02f, 1.22008562e-01f, -6.80677518e-02f, -3.56198624e-02f, -1.75009610e-03f, 2.36879522e-03f,
  -2.05281191e-02f, -2.54229791e-02f, 7.96324238e-02f, 1.17954731e-01f, 1.64126202e-01f, -1.26859685e-02f, 1.03655770e-01f, -5.76415211e-02f, -5.74455783e-02f, 1.26938671e-02f,
  -1.02103300e-01f, -8.19100663e-02f, 1.65671809e-03f, -2.31809635e-02f, 9.79889035e-02f, 1.06987217e-02f, 5.69111947e-03f, 1.07133642e-01f, 7.47894943e-02f, 2.71981489e-02f,
  1.39232595e-02f, 2.95570344e-02f, 4.40924149e-03f, -2.80677527e-02f, 4.63215783e-02f, 9.44547579e-02f, -2.35952027e-02f, -7.28098378e-02f, 8.17177370e-02f, -6.29247427e-02f,
  -6.31836355e-02f, -3.38036306e-02f, -5.45129962e-02f, -2.48684753e-02f, 4.08482067e-02f, -1.35329645e-02f, 2.55621914e-02f, 3.59436385e-02f, -2.63762902e-02f, -8.31437632e-02f,
  -7.20901461e-03f, -3.46199200e-02f, 3.81425023e-02f, 9.33125988e-02f, -4.36231792e-02f, -5.28855883e-02f, -8.71712714e-02f, -5.51594235e-02f, -2.13046316e-02f, 3.81348953e-02f,
  -2.52714697e-02f, 7.99912810e-02f, 5.24722077e-02f, -8.59922096e-02f, -1.20559186e-02f, -8.22081566e-02f, -6.89799488e-02f, -2.29079518e-02f, -6.25086129e-02f, -7.76909813e-02f,
  7.41593121e-03f, 1.17413290e-01f, -3.48304249e-02f, 1.37752397e-02f, 2.52750758e-02f, 7.20880851e-02f, 3.24161276e-02f, 1.69984065e-02f, 7.26311803e-02f, -8.58329162e-02f,
  1.12012558e-01f, -4.86168191e-02f, 8.95536914e-02f, 3.16335098e-03f, 1.78006236e-02f, 5.44155538e-02f, -4.81427694e-03f, -5.41053079e-02f, -2.79160030e-02f, 3.58323418e-02f,
  -4.46191132e-02f, 4.74982932e-02f, 3.30654532e-02f, 1.06958998e-02f, 3.88490707e-02f, 1.68622714e-02f, 5.27795665e-02f, -3.21345590e-02f, -1.53505523e-02f, 8.51807967e-02f,
  1.51448563e-01f, -2.02486798e-01f, 1.93228036e-01f, 1.46302730e-02f, 7.59408548e-02f, 1.08886153e-01f, 1.52004316e-01f, -1.26172945e-01f, -8.86800215e-02f, -2.17963368e-01f,
  -6.53524650e-03f, 5.56926504e-02f, 1.30024657e-01f, -9.43775550e-02f, 1.98685989e-01f, -2.86254324e-02f, -1.15882225e-01f, 9.13364217e-02f, 3.40810306e-02f, -3.69679928e-02f,
  1.20162703e-01f, -6.82050362e-02f, 9.46721658e-02f, -4.99012507e-02f, 1.08670689e-01f, -1.47632495e-01f, -5.02962023e-02f, 1.12842090e-01f, -5.49382940e-02f, 9.63239670e-02f,
  -1.94618106e-02f, -4.68538180e-02f, 7.57446811e-02f, 5.74168488e-02f, -1.02215104e-01f, -2.12938078e-02f, 3.36933554e-05f, 8.96807251e-05f, 2.78516263e-02f, -4.18890752e-02f,
  -5.39044328e-02f, 7.16241300e-02f, 1.99324358e-02f, 6.50459900e-02f, 4.05184627e-02f, 1.74482614e-02f, -1.56908296e-02f, -4.61172834e-02f, -5.14244027e-02f, -1.81364566e-02f,
  1.07104033e-01f, 2.08805837e-02f, 2.40014791e-02f, -8.62350836e-02f, -1.05856387e-02f, -6.45963177e-02f, -3.33549269e-02f, -3.36776040e-02f, -7.35514089e-02f, -4.82471585e-02f,
  5.99905923e-02f, 4.21088561e-02f, 9.15588513e-02f, -2.48850067e-03f, 7.63027519e-02f, 2.27220917e-05f, -2.60575972e-02f, 2.44220439e-02f, -6.25372157e-02f, -2.31680963e-02f,
  5.61830215e-02f, -3.44518982e-02f, 4.50052135e-03f, 6.44789264e-02f, -2.49828976e-02f, -4.15069014e-02f, 9.08437446e-02f, -1.70384049e-02f, -1.65199693e-02f, -8.88355225e-02f,
  -4.25028205e-02f, -3.93546298e-02f, 3.66963111e-02f, 3.05051729e-02f, -6.25140071e-02f, 6.05029687e-02f, -8.68197083e-02f, -2.64571495e-02f, 4.30709915e-03f, 5.53951003e-02f,
  -1.43256515e-01f, -1.32177979e-01f, -8.45758915e-02f, 6.05472997e-02f, -3.89646478e-02f, -1.02585882e-01f, -4.05186825e-02f, -5.80367334e-02f, -5.10850921e-02f, -6.81297109e-03f,
  -8.41580033e-02f, 6.30635172e-02f, -5.67801073e-02f, 2.49150395e-02f, 7.58891851e-02f, 3.10011767e-02f, 3.16440873e-02f, -1.63547583e-02f, 6.83890060e-02f, -7.76126534e-02f,
  -9.82138589e-02f, -4.32643620e-03f, 5.87342381e-02f, 8.68246309e-04f, 3.95702012e-02f, 5.95392771e-02f, 6.12538541e-03f, -5.13058491e-02f, 9.57716256e-03f, -9.28506851e-02f,
  -8.41881037e-02f, 2.00939372e-01f, 1.00775488e-01f, 1.35081276e-01f, -4.61233221e-02f, -2.55318999e-01f, -1.69705600e-01f, 1.46096230e-01f, 5.82039915e-02f, 7.87525997e-02f,
  1.09113336e-01f, -3.00039351e-02f, 8.46264064e-02f, 5.10527976e-02f, 1.97871234e-02f, -7.26042017e-02f, -1.01316243e-01f, -1.56391680e-01f, -4.15804051e-03f, 1.89420536e-01f,
  1.60771444e-01f, 8.08954239e-02f, 1.42804399e-01f, 9.01382640e-02f, 8.37764442e-02f, 7.64658228e-02f, 1.80215508e-01f, 1.49449304e-01f, 1.36066809e-01f, -1.07712850e-01f,
  -1.77272320e-01f, 1.52724683e-01f, 5.50522618e-02f, 8.76024738e-03f, -1.39569044e-02f, -1.18988324e-02f, -1.99276265e-02f, 3.75051536e-02f, 6.80861920e-02f, -2.22832989e-03f,
  -2.00923383e-02f, 7.29118884e-02f, 2.34597158e-02f, -1.36553003e-02f, -7.68452734e-02f, 7.70650059e-02f, -1.72923096e-02f, -8.78715701e-03f, 5.53220995e-02f, 2.81744823e-02f,
  8.36387798e-02f, -2.75026876e-02f, -2.87882388e-02f, -6.17148951e-02f, -3.19790393e-02f, 6.63181990e-02f, -1.35030821e-02f, 1.28773674e-02f, -2.19596922e-02f, 6.69951364e-02f,
  -7.73530677e-02f, 3.65852602e-02f, -1.83024071e-02f, 6.89365268e-02f, 2.76203547e-03f, 1.44264996e-02f, -2.09995154e-02f, -6.21586107e-02f, 4.12602127e-02f, 4.46207300e-02f,
  -7.10208341e-03f, 5.78732267e-02f, 2.55367942e-02f, -5.67151271e-02f, -3.13947499e-02f, -8.89413729e-02f, 3.29997689e-02f, -3.87064256e-02f, -4.07001264e-02f, -4.33071656e-03f,
  6.32014349e-02f, -1.99821927e-02f, -5.49321324e-02f, -4.83376570e-02f, -7.15093911e-02f, 8.65224004e-02f, 5.95272370e-02f, -7.95945153e-02f, -4.12905216e-03f, -3.83012295e-02f,
  -1.06943864e-02f, 2.70229071e-01f, 1.69992994e-03f, -3.66913131e-03f, 1.58326179e-02f, 2.25915182e-02f, 3.16109210e-02f, 2.65768971e-02f, 1.16017297e-01f, 6.73718750e-02f,
  -5.39437751e-04f, 1.57104284e-02f, 1.49871549e-02f, -6.60016260e-04f, 2.77027376e-02f, 6.74821436e-02f, 6.30152784e-03f, 3.29152844e-03f, 1.00770593e-01f, 3.25031132e-02f,
  3.95340398e-02f, -6.80992454e-02f, 6.84717372e-02f, 2.12723818e-02f, -3.45515423e-02f, -5.10637052e-02f, 7.59455413e-02f, 9.75750089e-02f, 1.03851937e-01f, 2.80304393e-03f,
  -6.69283569e-02f, 1.62830174e-01f, 8.49365294e-02f, 9.51611698e-02f, -4.43301760e-02f, -1.35085672e-01f, 5.67691140e-02f, 1.22292273e-01f, -1.89731587e-02f, 7.74480999e-02f,
  8.73795524e-02f, -7.07033724e-02f, 2.28829850e-02f, 4.17976640e-02f, 2.39875577e-02f, 4.09609005e-02f, 3.97043787e-02f, -2.82717366e-02f, 8.79614577e-02f, -1.35699390e-02f,
  2.27756482e-02f, 1.27613202e-01f, 5.69951162e-02f, 5.26514091e-03f, -2.45338716e-02f, 3.95221775e-03f, 1.76220934e-03f, -2.99970079e-02f, 6.11280315e-02f, -7.20480382e-02f,
  -2.51538381e-02f, 1.27779573e-01f, -7.80022070e-02f, -2.03606077e-02f, -3.25756334e-02f, -3.74836847e-02f, -1.27176633e-02f, -3.04667149e-02f, -7.06433877e-02f, 6.30513649e-04f,
  -9.98681784e-03f, -8.77040252e-02f, 5.38561456e-02f, 2.68012825e-02f, 6.36293888e-02f, 2.00690404e-02f, 7.06171198e-03f, -2.88682673e-02f, 7.79039711e-02f, 1.75255202e-02f,
  1.19026154e-02f, 2.38469616e-03f, -1.61183923e-02f, 6.92973733e-02f, 2.30416637e-02f, -2.81840861e-02f, -2.53739171e-02f, 1.01605937e-01f, -2.42696926e-02f, 1.62359867e-02f,
  1.30862743e-02f, 8.93183947e-02f, 2.86272578e-02f, -2.77238153e-03f, 3.49401496e-02f, 1.43803759e-02f, 6.54621199e-02f, -1.38654709e-02f, 5.29621206e-02f, -7.66575933e-02f,
  5.48026450e-02f, 5.36190271e-02f, -4.17110585e-02f, 6.23096563e-02f, -6.21659216e-04f, -1.68409087e-02f, 2.53264382e-02f, 5.71407415e-02f, -3.66912559e-02f, 7.46212155e-02f,
  7.64263645e-02f, -2.77831666e-02f, 7.65218586e-02f, 5.09598590e-02f, 6.49614558e-02f, -3.75378621e-03f, 2.80485451e-02f, 7.39119574e-02f, 2.14536376e-02f, -5.77363186e-02f,
  1.15046561e-01f, 2.46717751e-01f, -1.72147676e-02f, 3.97658460e-02f, -5.29836528e-02f, -6.26167236e-03f, 4.81505357e-02f, -7.61546716e-02f, 1.84679971e-04f, -3.72407474e-02f,
  4.07919846e-02f, -1.51387081e-02f, -9.48491767e-02f, -8.96113273e-03f, -3.33286934e-02f, 1.15386046e-01f, 5.30189611e-02f, 1.07601382e-01f, -1.44145675e-02f, 1.11149393e-01f,
  -2.58683506e-02f, -6.41240031e-02f, 4.01251279e-02f, -7.76069472e-03f, -7.77185485e-02f, 4.07380424e-02f, 3.41628194e-02f, -2.49015260e-02f, -4.62470204e-02f, 7.12894797e-02f,
  -7.97054172e-02f, -1.89659540e-02f, 5.43693863e-02f, -2.66230889e-02f, 2.91817210e-04f, 1.14695085e-02f, -7.50121325e-02f, 6.34358004e-02f, 8.56715627e-03f, -1.81101412e-02f,
  2.95058489e-02f, -1.20692633e-01f, 6.01868937e-03f, -1.50054678e-01f, -7.06302226e-02f, 1.05136842e-01f, -1.77433610e-01f, -1.87462911e-01f, 7.53483549e-02f, -1.74175754e-01f,
  3.33396979e-02f, -2.87479255e-02f, -1.17388945e-02f, 2.98865102e-02f, -1.14361182e-01f, -2.22952254e-02f, -1.56338513e-02f, -5.90984188e-02f, -8.38900730e-02f, -6.10160381e-02f,
  -1.55552395e-03f, -1.03453912e-01f, 9.07996148e-02f, -2.40988694e-02f, -3.90555896e-02f, -7.66412020e-02f, 2.43291724e-02f, 2.33468059e-02f, -4.96755242e-02f, -6.18337169e-02f,
  1.21555384e-02f, -4.99189459e-02f, -2.45583057e-02f, 7.18008876e-02f, 3.06445379e-02f, 3.84174436e-02f, 8.21898133e-02f, 2.73127798e-02f, -7.43745789e-02f, -7.48902187e-02f,
  1.82534615e-03f, 1.00997411e-01f, 1.12990523e-02f, -8.67223740e-02f, -2.14299969e-02f, 5.45991659e-02f, 5.57243265e-02f, -2.73982491e-02f, 5.56006888e-03f, -4.64360900e-02f,
  -1.04854308e-01f, -1.12273641e-01f, -3.60344090e-02f, 4.73925881e-02f, 3.57221328e-02f, 7.86438491e-03f, -8.22152793e-02f, -2.92416643e-02f, 2.26257587e-04f, -3.26336361e-02f,
  -3.55443284e-02f, 4.41032723e-02f, 4.50088084e-02f, -8.08907002e-02f, 1.90599468e-02f, -9.90967229e-02f, 1.52070436e-03f, 5.55174127e-02f, -3.47744003e-02f, 1.87670393e-03f,
  -3.28756608e-02f, -5.11294901e-02f, 6.05801418e-02f, -2.82771867e-02f, -2.59737298e-02f, -3.24478112e-02f, -8.27073082e-02f, 9.12690163e-02f, -7.48335719e-02f, -7.38709867e-02f,
  1.87586062e-02f, -3.29527259e-02f, -7.57094100e-02f, 7.48973042e-02f, 7.17060715e-02f, -5.98480068e-02f, -3.48951668e-02f, 3.04768588e-02f, -2.93944720e-02f, 8.32623467e-02f,
  1.74937453e-02f, -5.20746782e-02f, 2.49004252e-02f, 7.15676844e-02f, -2.77638473e-02f, 6.71020150e-02f, -3.22990082e-02f, 5.23751564e-02f, 6.05591852e-03f, 8.45463276e-02f,
  1.96904745e-02f, -7.14816153e-02f, 2.43245214e-02f, -1.00647740e-01f, -8.91763866e-02f, -5.64759038e-03f, -6.26660734e-02f, -5.06094024e-02f, -6.08746894e-02f, -5.02681062e-02f,
  7.95651302e-02f, -6.71917051e-02f, -5.93496449e-02f, -8.40923414e-02f, -8.36711079e-02f, -1.62138194e-01f, -1.80215016e-01f, 1.85056310e-02f, 3.12593617e-02f, 1.43919950e-02f,
  4.72278967e-02f, -1.90460570e-02f, 2.44229715e-02f, -1.56526625e-01f, -6.65458590e-02f, -1.72665101e-02f, -1.63195282e-01f, -1.35190591e-01f, -2.59438641e-02f, -9.81689394e-02f,
  -4.97452021e-02f, -7.78368488e-02f, -9.51358974e-02f, 2.29180995e-02f, -9.73664448e-02f, 8.09074864e-02f, -3.17529663e-02f, 3.75633650e-02f, -1.62787270e-03f, -1.06072389e-02f,
  8.11786279e-02f, 1.53719529e-03f, 2.67578550e-02f, -3.35149094e-02f, -4.74727787e-02f, 1.15794420e-01f, -6.48117810e-02f, 2.35455600e-03f, 5.88228032e-02f, -3.70216370e-02f,
  5.49676716e-02f, -1.53036388e-02f, -7.02167600e-02f, 5.54632694e-02f, -9.38564539e-03f, -4.29909192e-02f, -5.53433970e-02f, 1.09594897e-03f, -3.43115814e-02f, 7.23475218e-02f,
  -5.96794412e-02f, 8.66389088e-03f, 8.54946673e-02f, -6.01975098e-02f, -1.37947183e-02f, 7.86007568e-02f, -6.71910867e-02f, 3.54973376e-02f, -3.61038148e-02f, 5.20991199e-02f,
  1.01077417e-02f, 5.32755181e-02f, -6.88765123e-02f, -1.92555171e-02f, -5.26440628e-02f, -2.21273005e-02f, -2.14934396e-03f, -3.78781296e-02f, 4.34642732e-02f, 7.14088008e-02f,
  -2.80405078e-02f, -2.42900457e-02f, -4.23545055e-02f, 1.30590368e-02f, -2.81981919e-02f, 8.78121331e-02f, 6.24248292e-03f, 7.81653374e-02f, 3.26034427e-02f, 8.63692444e-03f,
  -6.10295422e-02f, 5.69864288e-02f, 4.53582965e-02f, -8.15987140e-02f, 2.72873249e-02f, -4.27826792e-02f, -8.08761716e-02f, 8.42512585e-03f, 4.56409827e-02f, 5.49440086e-02f,
  -2.74571665e-02f, -6.47783512e-03f, -6.87669814e-02f, 4.56895912e-03f, 9.58020799e-03f, 4.70829271e-02f, 6.47863522e-02f, 9.82070994e-03f, -3.27581763e-02f, 7.64796585e-02f,
  6.46687672e-02f, -1.08036504e-03f, -6.65206015e-02f, -7.56728509e-03f, 1.93285253e-02f, -2.04618033e-02f, 7.71575607e-03f, 5.09835072e-02f, 3.32227610e-02f, 7.95585196e-03f,
  8.12944323e-02f, 3.61272991e-02f, 9.00288075e-02f, 3.35755795e-02f, 7.18661025e-03f, -4.32924032e-02f, 3.34561579e-02f, 2.11549532e-02f, -3.73387374e-02f, 1.87386735e-03f,
  1.32475689e-01f, 7.07828626e-02f, -1.61347851e-01f, -1.24209426e-01f, 1.34060625e-02f, 6.68182503e-03f, 3.28310505e-02f, 9.12516043e-02f, 6.33871416e-03f, 1.33560210e-01f,
  5.00642844e-02f, 2.93942932e-02f, -5.10102212e-02f, 1.27169937e-02f, 1.57895446e-01f, 1.29688337e-01f, 6.91999570e-02f, 5.10547236e-02f, 6.85147569e-03f, 1.54869482e-02f,
  -4.85163331e-02f, 1.35893747e-01f, -8.08361396e-02f, -1.77389160e-02f, 7.18119293e-02f, -1.24631442e-01f, 4.48291264e-02f, -8.46879780e-02f, 4.21990938e-02f, -3.59549373e-02f,
  -5.27103655e-02f, 1.33211151e-01f, -5.12050353e-02f, 4.66898717e-02f, 7.94837996e-02f, 3.44111421e-03f, -8.51715878e-02f, 3.71606578e-03f, -3.78598310e-02f, -2.70610936e-02f,
  -5.63571788e-02f, -2.90402807e-02f, 5.75152114e-02f, 6.31926134e-02f, -4.14085984e-02f, -7.48054981e-02f, 8.38746037e-03f, 4.31817435e-02f, -3.52077559e-02f, 6.45058304e-02f,
  -9.25953016e-02f, -5.84107675e-02f, 2.44841073e-02f, -5.07163368e-02f, 1.94536522e-02f, 2.99471281e-02f, -4.23085466e-02f, -7.07549676e-02f, 5.36510497e-02f, -8.55745189e-03f,
  2.28397641e-02f, 4.69231717e-02f, 1.48600973e-02f, -4.97067831e-02f, 5.66229373e-02f, -5.00500351e-02f, -1.30852973e-02f, 9.35040473e-04f, -1.83656998e-02f, 4.18575220e-02f,
  -8.88393596e-02f, -1.26096141e-02f, 9.41254422e-02f, 7.22911507e-02f, -2.15373803e-02f, -3.25542726e-02f, -1.36821233e-02f, -2.21049432e-02f, -7.52041861e-02f, -1.24350816e-01f,
  5.13109751e-02f, -4.58306074e-02f, 7.34630749e-02f, -1.16234027e-01f, -4.56851088e-02f, -6.04364872e-02f, -2.20802967e-02f, 6.80695400e-02f, 3.24690565e-02f, -3.80732045e-02f,
  1.22368306e-01f, 1.84070021e-01f, 5.42965606e-02f, -4.65090685e-02f, -1.00841820e-01f, 9.35851112e-02f, -1.59416795e-02f, 7.86445439e-02f, 6.36906847e-02f, 2.23283302e-02f,
  -1.90217234e-02f, 4.88744192e-02f, -8.47171526e-03f, -3.40540260e-02f, -9.72345993e-02f, 1.14691697e-01f, -8.46115351e-02f, -7.47683719e-02f, -1.35060847e-02f, 4.38292697e-02f,
  -8.28963369e-02f, -3.76244150e-02f, -4.80500385e-02f, 7.44009390e-02f, -3.57673727e-02f, -7.37459511e-02f, -8.96415766e-03f, 2.55870353e-02f, -6.55877739e-02f, 4.25981954e-02f,
  1.82749793e-01f, 1.17467456e-01f, -5.81495613e-02f, -1.20382726e-01f, 1.02582183e-02f, -6.41234871e-03f, 8.06967467e-02f, 1.25380114e-01f, -4.73832637e-02f, 7.97349140e-02f,
  -2.64281053e-02f, 1.60620883e-01f, -7.17933849e-02f, -1.29292473e-01f, -3.34036350e-01f, -2.63512611e-01f, -2.55257729e-03f, 5.34674302e-02f, 4.25620265e-02f, 9.93621945e-02f,
  -9.49766412e-02f, -5.78384660e-02f, -1.04170300e-01f, -5.45056015e-02f, 1.63973436e-01f, 1.73860863e-01f, -1.22599062e-02f, 7.11821765e-02f, -3.32051031e-02f, -8.59302208e-02f,
  -7.90258646e-02f, -1.81025155e-02f, 1.04980364e-01f, 6.13631792e-02f, 9.79341120e-02f, 1.11783966e-02f, -3.17867212e-02f, 1.59844384e-02f, -7.26223066e-02f, -3.41136265e-03f,
  8.97605196e-02f, 4.22272198e-02f, 5.28209610e-03f, -5.35790958e-02f, 9.76941958e-02f, 7.52480468e-03f, 5.61334006e-02f, -1.08981756e-02f, -1.10832592e-02f, -1.29888002e-02f,
  5.75470626e-02f, 3.76576632e-02f, 4.56117801e-02f, -1.07466958e-01f, -8.72850344e-02f, 4.42870706e-02f, 2.21404079e-02f, -1.84017289e-02f, 4.13114205e-02f, -5.60240038e-02f,
  -2.08882727e-02f, -3.13916467e-02f, 4.28546630e-02f, 2.40459945e-02f, -1.15689775e-02f, 2.02258695e-02f, 1.71951149e-02f, 4.43743207e-02f, -6.65749535e-02f, -6.70393258e-02f,
  4.04632464e-02f, 4.47229948e-03f, 5.34175597e-02f, 4.85309884e-02f, 1.66875608e-02f, 6.38325512e-02f, -6.75185770e-02f, -2.49132849e-02f, -4.25680876e-02f, 3.31665901e-03f,
  1.70802046e-02f, -4.22226973e-02f, 3.74791250e-02f, -1.35844778e-02f, 4.87545226e-03f, -5.47964424e-02f, -3.62342298e-02f, -5.86034656e-02f, -1.81771796e-02f, -1.96742322e-02f,
  2.74847411e-02f, 1.25543363e-02f, 1.94425285e-02f, 4.18794192e-02f, 3.11848130e-02f, 7.26777166e-02f, 4.30734195e-02f, 1.76579636e-02f, 4.49747294e-02f, -1.04891919e-02f,
  3.78046408e-02f, 7.05216080e-02f, -6.30901977e-02f, -3.84069234e-02f, 4.09796834e-03f, -3.68871205e-02f, 1.96239725e-02f, 6.99030561e-03f, -1.00738943e-01f, 5.84407374e-02f,
  -1.45653849e-02f, -3.47038321e-02f, -2.61662304e-02f, 5.50458953e-02f, -9.37544107e-02f, 9.21835154e-02f, -4.17598384e-03f, 7.53003433e-02f, -7.79901743e-02f, -5.81781492e-02f,
  -4.62550521e-02f, 2.57801898e-02f, 4.86036390e-02f, -1.16296686e-01f, -8.93949419e-02f, 3.11517175e-02f, -1.09262520e-03f, -3.33173871e-02f, 1.23859430e-03f, 1.37730747e-01f,
  -7.16096896e-04f, -9.60368197e-03f, -2.23998167e-02f, -9.17033479e-02f, 1.27306849e-01f, 9.18894857e-02f, 1.98755525e-02f, 3.57573442e-02f, 2.88949143e-02f, 8.31835046e-02f,
  -7.12953582e-02f, 2.69808676e-02f, -1.04329474e-01f, 1.04336459e-02f, -5.29382154e-02f, -7.98943713e-02f, 7.53053799e-02f, -6.58359425e-03f, -3.28724757e-02f, 7.68614700e-03f,
  1.04369950e-02f, 2.49612276e-02f, 8.06709006e-02f, 1.00837477e-01f, -1.77039709e-02f, -9.05064046e-02f, 6.56151325e-02f, 1.47029348e-02f, 1.88728310e-02f, -4.15322110e-02f,
  -1.90589093e-02f, -6.84702545e-02f, 5.64251803e-02f, -8.74892250e-03f, 5.18153794e-02f, -2.59871650e-02f, 4.16978858e-02f, -4.19352502e-02f, 3.45296375e-02f, 8.83939117e-02f,
  7.41059426e-03f, 2.82854009e-02f, 6.18338026e-02f, -6.52748868e-02f, -1.80333164e-02f, -5.00570945e-02f, 9.74658132e-02f, 5.13341986e-02f, 1.18385963e-01f, 9.07584326e-04f,
  2.91501060e-02f, 1.32619888e-02f, 5.04007451e-02f, -4.70072925e-02f, -6.97357357e-02f, -8.66243690e-02f, 9.24562961e-02f, -2.56212708e-03f, 8.01858550e-04f, 1.18023818e-02f,
  4.78639416e-02f, -7.66910836e-02f, -7.72861466e-02f, -9.14714672e-03f, -1.53436121e-02f, 8.41399953e-02f, 9.00676474e-03f, -6.91302493e-02f, -5.91018647e-02f, 1.90066565e-02f,
  1.89470742e-02f, 2.21947767e-02f, -4.52676229e-02f, -4.96149585e-02f, -7.80020058e-02f, -3.68327983e-02f, 4.41705529e-03f, 5.25789559e-02f, -6.69843704e-02f, 6.32390454e-02f,
  7.57907480e-02f, 1.36111632e-01f, 7.95373470e-02f, -8.58206004e-02f, -2.84989215e-02f, -6.51229843e-02f, -2.19965950e-02f, 4.27011736e-02f, -1.35538960e-02f, -3.38297412e-02f,
  2.97296308e-02f, -5.08612134e-02f, -1.01178391e-02f, 3.69893797e-02f, -8.94148722e-02f, 1.14787377e-01f, 6.53535649e-02f, -4.62197401e-02f, 2.88034882e-02f, -4.94829416e-02f,
  2.98719555e-02f, 2.69651990e-02f, 4.41535227e-02f, 2.36575138e-02f, 7.99566209e-02f, -6.27785847e-02f, 8.78008753e-02f, 9.07604489e-03f, -5.94861284e-02f, -8.32449123e-02f,
  1.77059755e-01f, 1.21921822e-01f, 1.89031273e-01f, 9.50816423e-02f, -3.77429686e-02f, -1.30130544e-01f, -2.74721254e-02f, -1.17503993e-01f, 8.35007951e-02f, 9.41073373e-02f,
  -1.90131724e-01f, 2.98317403e-01f, -2.96312068e-02f, 7.65082762e-02f, -8.28616619e-02f, -1.70347288e-01f, 5.57086095e-02f, 2.67702760e-03f, 2.52832007e-02f, 3.15394029e-02f,
  -2.91842595e-02f, -2.12090686e-01f, 6.91192690e-03f, -1.56213030e-01f, 8.81704614e-02f, 8.49717557e-02f, -9.94359702e-02f, -6.78695589e-02f, -2.88670301e-03f, -9.27908868e-02f,
  -5.58471568e-02f, -1.11769680e-02f, 9.86881256e-02f, -1.60072874e-02f, -4.57621999e-02f, 3.41653638e-02f, -2.65496294e-03f, 2.24764384e-02f, 2.24326383e-02f, 2.30005523e-03f,
  4.24603075e-02f, 6.65772855e-02f, 7.10287765e-02f, -1.86083112e-02f, 6.76047355e-02f, 1.91491488e-02f, 5.90679571e-02f, 1.09362550e-01f, 5.32293394e-02f, -3.39230709e-03f,
  1.12560347e-01f, 1.18746646e-01f, 1.06465332e-01f, 7.98182040e-02f, 6.42874986e-02f, -5.89640662e-02f, 3.02142520e-02f, -3.67114507e-02f, 6.80878609e-02f, -2.23142207e-02f,
  -1.08447310e-03f, -6.76952004e-02f, 6.18196046e-03f, 2.28135772e-02f, 5.56575954e-02f, -1.12718074e-02f, 3.21561955e-02f, 3.13008130e-02f, -1.52840151e-03f, -6.30344599e-02f,
  2.77403258e-02f, -3.02601922e-02f, -7.45477229e-02f, -5.50526455e-02f, 3.88132036e-02f, 9.00838748e-02f, 1.93311386e-02f, -4.38565798e-02f, 4.42554913e-02f, 4.40335553e-03f,
  6.86112940e-02f, 2.62750760e-02f, -1.73816606e-02f, -1.03065800e-02f, -1.00841463e-01f, 6.17263205e-02f, 6.44262135e-02f, -3.08958292e-02f, -6.22753948e-02f, -6.75177947e-02f,
  6.44963458e-02f, -5.31328805e-02f, 9.47109535e-02f, 4.24832292e-02f, -3.80530730e-02f, -6.09112978e-02f, -5.37316725e-02f, 7.03427270e-02f, 9.59422253e-03f, 7.95177091e-03f,
  2.44713351e-02f, 6.26772866e-02f, 5.84327057e-02f, -2.44863052e-02f, -1.11940429e-02f, -8.69910326e-03f, -1.83485821e-02f, 7.34389126e-02f, -5.23292087e-02f, 5.11668622e-02f,
  2.80804094e-02f, -4.16396856e-02f, -6.63617477e-02f, -1.49514126e-02f, -2.45804619e-03f, -7.27893636e-02f, 8.32942054e-02f, 2.25728122e-03f, -1.98218469e-02f, 3.98336872e-02f,
  -2.34551746e-02f, 2.15311851e-02f, 1.90608919e-01f, 1.86328322e-01f, -1.18908569e-01f, -3.00880104e-01f, -1.90316021e-01f, 8.57573897e-02f, 5.16195484e-02f, -8.24059546e-03f,
  1.30801806e-02f, -3.06407958e-02f, 2.48253718e-02f, 8.52041915e-02f, 1.29759848e-01f, -5.41105084e-02f, -4.49650176e-02f, 1.65960677e-02f, 1.38637960e-01f, 7.51086697e-02f,
  1.85598254e-01f, 1.40577890e-02f, 2.89777756e-01f, 2.47774124e-02f, 1.54933304e-01f, 1.99512750e-01f, 1.90983325e-01f, 1.02540314e-01f, 6.47829100e-02f, 3.82012152e-03f,
  -1.21939741e-01f, 4.70137633e-02f, -2.93677505e-02f, 8.17578565e-03f, 4.57781665e-02f, -3.90682258e-02f, 3.76055925e-03f, -7.92832673e-02f, 5.55062667e-02f, -1.04159946e-02f,
  -4.40127216e-02f, 2.36641872e-03f, 3.33504193e-02f, 6.62980974e-02f, -6.91502169e-02f, 2.57040188e-03f, 4.66185100e-02f, 4.79311086e-02f, 2.99582686e-02f, 2.51784325e-02f,
  1.93425938e-02f, 3.81828099e-02f, -5.05988114e-03f, -6.57209978e-02f, 8.72320160e-02f, -7.78578147e-02f, -4.90215011e-02f, -2.28323173e-02f, -6.10493012e-02f, 2.76318323e-02f,
  -3.00567113e-02f, 8.62928107e-02f, -2.27656942e-02f, -3.29514481e-02f, -2.72648316e-02f, -6.97915768e-03f, 1.35009671e-02f, -7.24703372e-02f, -1.72760766e-02f, -6.54174387e-02f,
  6.03371523e-02f, -1.36119649e-02f, -3.84747982e-02f, 4.43136469e-02f, 2.72887461e-02f, -4.06350121e-02f, 5.95498495e-02f, -5.90864867e-02f, 1.42171523e-02f, 1.37352301e-02f,
  1.77070796e-02f, 4.40089963e-02f, -4.47341017e-02f, 5.06429635e-02f, 1.52501278e-02f, -6.64504012e-03f, 8.06754380e-02f, -6.06452525e-02f, -1.01697743e-02f, 9.29394439e-02f,
  -3.14180814e-02f, 1.62068665e-01f, 1.00372463e-01f, -1.21037185e-01f, 7.72532076e-02f, 2.41353586e-02f, -6.23091906e-02f, 7.77693316e-02f, 3.29301544e-02f, -1.14046689e-02f,
  2.80904677e-02f, 4.49525304e-02f, 5.82259968e-02f, -6.70122132e-02f, 4.33351323e-02f, -6.61678845e-03f, 5.44105023e-02f, 2.65981443e-02f, -2.99148168e-02f, 4.10891697e-02f,
  2.55294014e-02f, 1.88550483e-02f, -2.25060340e-03f, 7.88641647e-02f, -4.61017191e-02f, -7.41957575e-02f, -6.61037564e-02f, -1.42641682e-02f, 5.76569652e-03f, 7.19426572e-02f,
  1.49127347e-02f, -1.59742713e-01f, 7.48372450e-02f, 1.04661703e-01f, 1.38381407e-01f, 6.75420985e-02f, 1.38612434e-01f, 1.46458939e-01f, 2.42891178e-01f, -1.88877553e-01f,
  -4.18330096e-02f, -1.16883874e-01f, -1.43039729e-02f, -1.26377717e-01f, -1.23973384e-01f, -3.53949964e-02f, -4.34485674e-02f, -6.61806241e-02f, 3.67950536e-02f, 9.62614194e-02f,
  6.19646832e-02f, 6.37590066e-02f, -7.10549429e-02f, -6.54688478e-02f, 3.91262397e-02f, 7.08579943e-02f, -7.05906525e-02f, 7.01902360e-02f, -1.56448528e-01f, -1.92267615e-02f,
  2.51027215e-02f, 9.82953981e-02f, 4.34338599e-02f, -3.78269330e-02f, -8.65824579e-04f, 8.35582539e-02f, -4.66115512e-02f, 4.89963079e-03f, -2.84755025e-02f, -7.80702308e-02f,
  -2.33131591e-02f, -4.08793539e-02f, 1.39244925e-02f, -3.68295833e-02f, 1.21320680e-01f, -6.02304898e-02f, 6.23255521e-02f, 8.69241431e-02f, -7.07334951e-02f, 2.98684295e-02f,
  -1.48614561e-02f, 9.64300707e-03f, 2.19626771e-03f, -3.46327722e-02f, -4.24617715e-02f, -2.77987570e-02f, -6.50682226e-02f, 4.56999280e-02f, -9.11667272e-02f, -1.82452146e-02f,
  6.01852238e-02f, 6.93157837e-02f, 1.35894725e-02f, -8.19366947e-02f, 3.26129911e-03f, 9.23965648e-02f, -8.14586838e-06f, 5.01216128e-02f, -2.28146631e-02f, -4.62104892e-03f,
  4.40365775e-03f, -5.33447675e-02f, 4.03477773e-02f, -8.37890506e-02f, -1.62754953e-02f, 3.57810408e-02f, 2.12415271e-02f, -7.43332878e-02f, 6.72807321e-02f, -2.66234055e-02f,
  7.09709823e-02f, -6.40512258e-02f, -6.29135594e-02f, 6.76855594e-02f, -1.66040044e-02f, -2.74800193e-02f, -6.57862052e-02f, -1.58959944e-02f, 3.67991254e-02f, 2.84834504e-02f,
  -9.14378911e-02f, -1.36352956e-01f, 7.49989003e-02f, -6.92008957e-02f, 4.54730727e-02f, -7.71623552e-02f, -4.08910122e-03f, -7.92482048e-02f, -7.85203185e-03f, 7.87685513e-02f,
  2.75444500e-02f, 5.41630834e-02f, -8.36807564e-02f, -1.55627476e-02f, -1.60192791e-02f, 4.93273214e-02f, 3.81134227e-02f, 5.11110015e-02f, 6.23653159e-02f, -6.30960241e-02f,
  -7.08248094e-02f, -3.44477524e-03f, -2.66647595e-03f, 2.02148948e-02f, 1.46961119e-02f, -7.58009180e-02f, -5.55726588e-02f, -3.11235879e-02f, 2.94862445e-02f, -1.10419048e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.80500145e-02f, 1.58628911e-01f, 2.17612848e-01f, 1.35313302e-01f, 2.80442908e-02f, 8.40082318e-02f, -5.86340353e-02f, 2.66638659e-02f, 1.78880796e-01f, 1.75512895e-01f,
  2.35584136e-02f, 9.20023546e-02f, 1.71817511e-01f, -1.26697160e-02f, 1.06071107e-01f, 5.42168953e-02f, 1.29056256e-02f, 2.04720050e-02f, -2.88625490e-02f, 5.33892252e-02f,
  1.44460604e-01f, 1.01235352e-01f, 4.08333428e-02f, 3.89501788e-02f, 7.69968256e-02f, 1.67819157e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  1.03584744e-01f, -5.29187396e-02f, -8.38900683e-04f, 7.32344165e-02f, -3.49429846e-02f, -2.68501580e-01f, -1.05401769e-01f, 4.43284363e-02f, -1.42286196e-01f, -9.83650312e-02f,
  6.67105019e-02f, -1.93939693e-02f, -2.83161670e-01f, -6.34748936e-02f, 3.34665291e-02f, 5.13873212e-02f, 2.18152598e-01f, -3.91458534e-02f, 1.35398343e-01f, 3.04009672e-02f,
  3.22148316e-02f, 9.72723961e-02f, 2.50758789e-02f, -3.12290579e-01f, -2.78749883e-01f, 1.12999976e-01f, 9.20216590e-02f, -2.47032031e-01f, -1.14060082e-02f, 6.51160255e-02f,
  -1.17719397e-01f, 4.64796610e-02f, 9.28484276e-02f, -8.61241519e-02f, 1.54498979e-01f, -1.56820163e-01f, 8.39745030e-02f, -1.92413196e-01f, -1.66351553e-02f, 3.11658755e-02f,
  -5.11963181e-02f, -1.23118972e-02f, 6.48450777e-02f, -3.90225887e-01f, 7.77267516e-02f, 1.21393930e-02f, -1.39287859e-01f, 2.89790351e-02f, 8.36084560e-02f, -4.24994715e-03f,
  1.94641650e-02f, 2.58609466e-02f, 1.35157347e-01f, -3.22258562e-01f, -1.07421316e-01f, -2.92514473e-01f, -3.52828592e-01f, -7.48514533e-02f, -2.18793690e-01f, -3.36861342e-01f,
  -3.61181825e-01f, 2.87433993e-02f, 2.98452340e-02f, 2.94969589e-01f, -1.07920706e-01f, 3.10370680e-02f, 3.27981055e-01f, 2.31808797e-01f, 8.71712267e-02f, -1.69352025e-01f,
  2.31042966e-01f, -5.90476766e-02f, -2.22596079e-02f, 2.02639684e-01f, 4.06285316e-01f, 3.01436633e-01f, 2.56932229e-01f, -5.49212582e-02f, 4.43396956e-01f, -1.58325046e-01f,
  1.59344718e-01f, -3.16328883e-01f, 3.69084589e-02f, 3.74924801e-02f, -2.46042714e-01f, -1.15002774e-01f, 3.70700866e-01f, 1.65532500e-01f, 3.43402982e-01f, 3.22839260e-01f,
  1.75339624e-03f, 3.77193391e-01f, -3.98591042e-01f, -3.29174437e-02f, 3.45620662e-01f, 5.75737543e-02f, -2.30522126e-01f, -4.33152556e-01f, -3.13625723e-01f, -6.39943704e-02f,
  1.14567496e-01f, 5.38660660e-02f, -6.05885275e-02f, 1.74404204e-01f, -9.34487805e-02f, -6.02635518e-02f, -6.35783151e-02f, 1.75584480e-01f, 3.65917459e-02f, -9.47203785e-02f,
  7.39411637e-02f, -2.66103633e-02f, -7.94448927e-02f, 8.26700702e-02f, 1.58538416e-01f, 8.68873447e-02f, -6.97030351e-02f, -1.16082758e-01f, -8.27867836e-02f, 1.19439214e-01f,
  -1.14773229e-01f, -1.86308786e-01f, 3.57441269e-02f, -9.37061980e-02f, 1.29639609e-02f, -4.61204350e-02f, -1.30510613e-01f, -1.68030366e-01f, 6.49619773e-02f, 2.73993425e-03f,
  8.76071826e-02f, -1.90629154e-01f, -1.48108572e-01f, 7.83211291e-02f, -4.42023873e-02f, 1.17765576e-01f, -6.99149892e-02f, -2.16942355e-01f, 4.85830707e-03f, 9.65397730e-02f,
  -5.77847920e-02f, 6.11429177e-02f, -1.36120126e-01f, -2.27714628e-01f, -4.07823324e-02f, 2.11262420e-01f, 1.08208157e-01f, 3.41090448e-02f, -7.45768175e-02f, 1.00834817e-02f,
  -5.08402511e-02f, 4.32535447e-03f, 5.61532797e-03f, -8.69027749e-02f, -2.44890675e-02f, 2.25337520e-01f, -2.77452379e-01f, -6.10454343e-02f, -5.39144874e-02f, -1.21881232e-01f,
  7.65253454e-02f, 1.05595425e-01f, -2.86597520e-01f, -1.72604337e-01f, -2.60824943e-03f, 1.28695950e-01f, -3.93085647e-03f, 1.21919913e-02f, -1.02219153e-02f, -8.55772495e-02f,
  4.65858877e-02f, 2.89090902e-01f, -5.37905172e-02f, -1.59348503e-01f, 1.53818786e-01f, 5.44468202e-02f, -8.62685218e-02f, 8.16818699e-02f, -7.23425578e-03f, -1.99998356e-02f,
  -3.87628376e-02f, -1.86294857e-02f, -7.19976844e-03f, -4.34340656e-01f, -4.50025387e-02f, -6.35000169e-02f, -1.61772430e-01f, -3.46554786e-01f, -3.69390063e-02f, 2.91192681e-01f,
  2.67733574e-01f, 2.43119612e-01f, -1.08480588e-01f, -3.97910625e-01f, 4.08975452e-01f, -2.13611305e-01f, 2.82837003e-01f, 8.68057013e-02f, -8.07962492e-02f, -2.98220534e-02f,
  1.74362168e-01f, -5.37689090e-01f, 2.63622791e-01f, 1.10696197e-01f, 1.32050902e-01f, 2.34523058e-01f, 1.28223911e-01f, -2.60367632e-01f, 2.13236734e-03f, -4.44712251e-01f,
  2.25380927e-01f, 1.07535243e-01f, -1.36760950e-01f, -4.90839720e-01f, -3.66401672e-01f, -2.52637208e-01f, 2.38835976e-01f, -2.78276831e-01f, 1.37865245e-01f, -1.63064808e-01f,
  -1.42652571e-01f, -8.96413103e-02f, -1.10715302e-02f, -2.18518615e-01f, -1.85844496e-01f, 3.65578204e-01f, 3.55004162e-01f, -3.40825558e-01f, -3.85615118e-02f, 1.12277590e-01f,
  -1.41852889e-02f, 9.16745812e-02f, 3.49290185e-02f, -1.80168465e-01f, 1.34611577e-01f, 3.16531956e-01f, 1.23285413e-01f, -1.50229394e-01f, -1.52534232e-01f, -5.91262914e-02f,
  1.62330911e-01f, 3.85839611e-01f, 2.62701839e-01f, -3.30324732e-02f, -8.78222510e-02f, -6.04290217e-02f, -1.37456313e-01f, 5.34048826e-02f, -1.68464378e-01f, 6.16045296e-02f,
  3.76899153e-01f, 1.32768348e-01f, 1.06431231e-01f, -1.66101098e-01f, -2.59589761e-01f, -1.90633520e-01f, -4.57091108e-02f, 3.14373486e-02f, -1.58428192e-01f, 1.36997059e-01f,
  8.90103262e-03f, 7.70641044e-02f, 5.23680113e-02f, 5.05792834e-02f, 3.01328097e-02f, 5.88315614e-02f, -1.71337407e-02f, -6.72583133e-02f, -1.70502998e-02f, 7.20299184e-02f,
  7.75961205e-02f, 1.04777232e-01f, 2.01486163e-02f, -1.45218387e-01f, -5.03683574e-02f, -1.12878233e-02f, -1.51388720e-02f, 1.02163188e-01f, -3.20462465e-01f, 7.35202208e-02f,
  -1.23846285e-01f, 2.40630865e-01f, -3.12650204e-02f, -4.53095771e-02f, -1.43393716e-02f, 1.12397470e-01f, 8.42365809e-03f, 5.53269871e-02f, -7.69214258e-02f, 5.79582565e-02f,
  -1.29416943e-01f, -5.28043173e-02f, -2.47295678e-01f, -7.78889284e-03f, 8.96303877e-02f, -1.76340982e-01f, 7.32825994e-02f, 7.35831633e-03f, -4.31655534e-02f, -1.92800269e-01f,
  -1.31691501e-01f, -4.50009778e-02f, -3.80797416e-01f, -1.90754786e-01f, -7.81081095e-02f, -4.84706089e-02f, -2.94364970e-02f, -1.74314097e-01f, 1.13414191e-01f, 2.27386683e-01f,
  5.48710041e-02f, -1.38177946e-01f, 1.47560000e-01f, -9.23897400e-02f, 1.70023125e-02f, -7.27345943e-02f, -9.26251188e-02f, -2.77805775e-01f, -1.60478935e-01f, -4.46230546e-03f,
  -8.85762125e-02f, -1.51226940e-02f, 1.74885184e-01f, -1.39448181e-01f, -3.11230928e-01f, -2.39095837e-01f, 3.66307311e-02f, 9.55179892e-03f, -1.30953744e-01f, -3.52704912e-01f,
  -1.20434444e-02f, -3.86694729e-01f, 1.83282524e-01f, 6.43255413e-02f, -2.26919204e-01f, -7.21684098e-02f, 6.95540085e-02f, 1.52104646e-01f, 2.90168464e-01f, -1.77392736e-01f,
  2.48956233e-01f, -2.94646233e-01f, -1.44131646e-01f, -2.73593187e-01f, -1.98455248e-02f, 1.37221031e-02f, 3.09623808e-01f, 4.06790199e-03f, 5.16901836e-02f, 1.56472042e-01f,
  -3.41610700e-01f, -3.00735950e-01f, -2.19706208e-01f, 2.87496090e-01f, 2.30506703e-01f, 2.40022510e-01f, -2.85905182e-01f, -1.02892555e-01f, -1.04567558e-01f, 2.19696909e-01f,
  -1.42395541e-01f, -1.21491201e-01f, 1.39427394e-01f, 1.77221596e-01f, -8.06193706e-03f, 6.54229999e-01f, -2.62630843e-02f, -1.13588519e-01f, -1.18283033e-01f, -8.22281744e-03f,
  3.03326678e-02f, -7.70141035e-02f, -4.33504768e-02f, 1.31792417e-02f, -1.77629858e-01f, -1.50841802e-01f, -5.82178459e-02f, -1.49331108e-01f, -9.20730531e-02f, -1.50417060e-01f,
  -1.21710330e-01f, -1.26998052e-01f, -5.82481585e-02f, -1.07361645e-01f, -7.85835385e-02f, -1.93365347e-02f, 1.87812686e-01f, -4.49159590e-04f, 1.69662178e-01f, 9.87025127e-02f,
  -5.63398898e-02f, -1.86149135e-01f, 6.23861775e-02f, -1.63777135e-04f, -1.51174679e-01f, 6.09026626e-02f, 5.51005229e-02f, -4.05875593e-02f, 1.54192239e-01f, -1.65011778e-01f,
  -6.68459311e-02f, 1.51756912e-01f, 1.74178146e-02f, -1.60309717e-01f, 2.60969065e-02f, 1.33910105e-01f, -3.57243210e-01f, 1.30484894e-01f, 5.91224469e-02f, 1.07609943e-01f,
  -3.99451256e-02f, 5.65540940e-02f, 1.35540441e-01f, 8.58957544e-02f, -1.76580057e-01f, -7.31092878e-03f, -8.81178677e-02f, 5.93849868e-02f, -1.31408781e-01f, 2.95006223e-02f,
  1.48996273e-02f, 1.18421493e-02f, -2.05264851e-01f, -3.69807035e-01f, -1.84097309e-02f, -1.71250790e-01f, 9.14477780e-02f, 2.38119792e-02f, -1.68537259e-01f, -2.74970382e-01f,
  -1.82706341e-02f, -8.64366069e-02f, -3.81111428e-02f, -1.76627655e-02f, -2.22030506e-01f, 4.73011397e-02f, -1.98891938e-01f, -1.72281966e-01f, 8.04960579e-02f, -1.87734645e-02f,
  1.87679350e-01f, 8.63660723e-02f, -2.78076798e-01f, 2.29988456e-01f, 1.02519438e-01f, -3.11477035e-01f, 1.31631017e-01f, -1.08599894e-01f, 1.56697929e-01f, 3.22961062e-02f,
  -1.73158050e-01f, 3.88575971e-01f, -1.48608088e-01f, 5.88970538e-03f, -1.74409121e-01f, 1.06829792e-01f, -3.05354837e-02f, 3.74813229e-01f, -3.35184261e-02f, -2.67717596e-02f,
  1.98168308e-01f, -1.20955162e-01f, 1.45145908e-01f, -1.97101563e-01f, 8.78910124e-02f, -3.13677222e-01f, -2.79460493e-02f, -2.56272852e-01f, 1.24962471e-01f, 1.71175189e-02f,
  1.32902056e-01f, 3.38261813e-01f, 2.65835822e-01f, 3.14525753e-01f, -3.23975950e-01f, 1.52478535e-02f, 3.47622633e-01f, 1.21050104e-01f, 4.22302812e-01f, 3.20796639e-01f,
  4.90897536e-01f, -1.85019284e-01f, -3.16110045e-01f, -6.33171499e-02f, 3.30654055e-01f, -3.08540106e-01f, -1.80809036e-01f, 2.13204958e-02f, -1.64072469e-01f, 1.58956692e-01f,
  -4.18738164e-02f, -8.76230970e-02f, 9.71766338e-02f, -1.58224069e-02f, 1.88137606e-01f, 5.77832282e-01f, 2.64008734e-02f, -2.45473534e-02f, -1.15226626e-01f, -4.60720658e-02f,
  -4.24612053e-02f, -8.01831484e-02f, 1.88302383e-01f, 1.14496604e-01f, 6.54845163e-02f, 7.74097517e-02f, 1.14866719e-02f, 1.97537065e-01f, -8.89021978e-02f, -1.78049967e-01f,
  -6.92210346e-02f, 1.23480275e-01f, 2.97434349e-02f, -1.31499335e-01f, 1.14238165e-01f, -1.00034446e-01f, 3.57390381e-02f, 2.27648113e-02f, -7.13276938e-02f, 1.27105758e-01f,
  1.30384997e-01f, 2.25147963e-01f, -1.03793472e-01f, -1.46290939e-02f, -2.29547196e-03f, -2.58044805e-02f, -2.14719474e-01f, 2.42637172e-01f, 3.15389007e-01f, -1.19333170e-01f,
  6.00944944e-02f, -5.51717393e-02f, -6.11347593e-02f, -1.63131375e-02f, 1.63127840e-01f, -3.38779464e-02f, 2.30146274e-01f, 7.62279257e-02f, 1.25133932e-01f, 1.17011875e-01f,
  1.01204008e-01f, 1.07178062e-01f, 1.58205017e-01f, -5.00827320e-02f, 1.95732400e-01f, -4.52188253e-02f, 6.81497902e-02f, -2.50561126e-02f, -1.56612307e-01f, 4.92243320e-02f,
  -6.45864159e-02f, 2.31147781e-01f, 1.16756164e-01f, 1.75687104e-01f, 2.86531970e-02f, 5.14361300e-02f, -5.11315316e-02f, 2.65871972e-01f, 1.02057628e-01f, -4.30394895e-03f,
  5.30772395e-02f, 3.19212228e-02f, 3.11916500e-01f, -1.14358060e-01f, -4.57258523e-01f, 1.84424132e-01f, 2.08154246e-01f, 7.13451132e-02f, -1.62915528e-01f, 7.97916278e-02f,
  7.50020817e-02f, -2.42988408e-01f, 7.59350434e-02f, 3.28867704e-01f, -2.05419436e-01f, 3.24046961e-03f, -2.81148285e-01f, 3.68188977e-01f, -3.92123222e-01f, 3.67956579e-01f,
  3.49008918e-01f, 1.47726247e-02f, 2.51147330e-01f, 3.83509129e-01f, -3.08050007e-01f, 3.74141522e-02f, 3.95558923e-01f, -4.13277857e-02f, -2.15369672e-01f, 1.39749274e-01f,
  1.16140336e-01f, 1.47858351e-01f, -1.64606363e-01f, 4.31550354e-01f, -3.54606211e-01f, -1.74735382e-01f, 2.17043906e-01f, 2.39816442e-01f, 3.36390585e-01f, 2.28251472e-01f,
  -7.23845661e-02f, 3.77343625e-01f, -4.73184884e-01f, -1.79569840e-01f, 5.56674659e-01f, 1.61001951e-01f, 2.92201459e-01f, -3.81714068e-02f, 2.81500649e-02f, -2.65877157e-01f,
  -2.47139230e-01f, -4.36949097e-02f, 1.53250471e-01f, 7.96590522e-02f, -4.42692488e-02f, -1.73480943e-01f, -8.27586204e-02f, -1.02811433e-01f, -1.45010903e-01f, -4.07547541e-02f,
  -7.41906837e-02f, -5.86671121e-02f, 3.43161151e-02f, -7.21880645e-02f, -5.99453487e-02f, 6.86482936e-02f, -1.04180843e-01f, -1.44266427e-01f, 2.81785756e-01f, 1.10458061e-02f,
  -2.42987890e-02f, 8.34527891e-03f, 1.73076749e-01f, -3.99284512e-02f, -2.25561820e-02f, -1.99469849e-02f, 5.77904209e-02f, -1.48857579e-01f, 1.80543922e-02f, -1.02674700e-02f,
  -4.07611579e-02f, -3.46300453e-02f, -1.25375360e-01f, -9.94951203e-02f, 2.52238005e-01f, 9.06112269e-02f, 6.92740977e-02f, 1.42438799e-01f, 1.25057340e-01f, 2.68747788e-02f,
  -3.36816870e-02f, 1.59957856e-01f, 2.49945730e-01f, 2.07765736e-02f, 7.91942999e-02f, 2.74942309e-01f, -1.30611181e-01f, -1.67293072e-01f, -1.59571931e-01f, -9.77657959e-02f,
  -8.18351135e-02f, 1.31021336e-01f, -5.38082281e-03f, 4.93723452e-02f, 4.68946546e-02f, -7.64666358e-04f, -5.10994531e-02f, 2.03377068e-01f, 4.48829420e-02f, 3.34569365e-01f,
  1.17453910e-01f, 1.18755706e-01f, -1.58790812e-01f, -8.05881470e-02f, 7.74494633e-02f, 1.67751148e-01f, 1.92828346e-02f, 3.75073180e-02f, 7.61758238e-02f, 1.99969232e-01f,
  -5.12565440e-03f, -8.44222605e-02f, -5.96883968e-02f, 4.98473421e-02f, 1.60956129e-01f, 9.14106965e-02f, 1.75144270e-01f, 7.77779594e-02f, -5.22325560e-03f, -2.33308738e-03f,
  5.16612530e-02f, 1.95336074e-01f, 1.09282836e-01f, -4.45327014e-01f, 8.00312907e-02f, -1.12101592e-01f, 1.63692366e-02f, -1.41174823e-01f, 1.13468565e-01f, 3.16395648e-02f,
  -2.49643698e-01f, 2.91918032e-03f, -8.17893595e-02f, -8.14441964e-02f, 2.68832952e-01f, -3.56492028e-02f, 2.82333214e-02f, -5.20785570e-01f, 2.90956259e-01f, 3.45247328e-01f,
  -1.77665114e-01f, 1.01114511e-01f, 1.76275760e-01f, 9.77816954e-02f, 6.57311082e-02f, 4.44244266e-01f, -3.37677062e-01f, 1.99270248e-01f, 1.75937176e-01f, -2.12775767e-01f,
  7.39112943e-02f, -1.46579072e-01f, -1.05197690e-01f, 3.48566830e-01f, -2.40278244e-01f, 2.80854732e-01f, -1.38427004e-01f, 1.64379135e-01f, -3.90782624e-01f, -2.97853313e-02f,
  1.98321208e-01f, -2.64360934e-01f, -4.45476115e-01f, -8.37607905e-02f, 1.97133794e-01f, 1.27030581e-01f, -1.71848074e-01f, -1.23832434e-01f, -2.06326976e-01f, 2.91164249e-01f,
  1.81815490e-01f, 2.16862544e-01f, 2.45881498e-01f, 5.72019853e-02f, 4.37485516e-01f, -1.99313879e-01f, 2.33496334e-02f, -9.69306529e-02f, -1.31426737e-01f, -1.68313473e-01f,
  -2.49493510e-01f, -1.52708098e-01f, 2.40233243e-01f, -5.00960089e-02f, -2.96857394e-03f, 1.24604143e-01f, 1.12347499e-01f, -2.20604807e-01f, -9.13006254e-03f, 1.18135266e-01f,
  -1.54054865e-01f, -1.41569197e-01f, 9.11995471e-02f, -5.79800382e-02f, 1.84139580e-01f, 5.42639606e-02f, -1.49146408e-01f, 1.52220689e-02f, -4.55688573e-02f, -8.31227750e-02f,
  1.48393065e-01f, -5.76806348e-03f, -2.64463574e-02f, 1.23151846e-01f, 1.51983708e-01f, 3.95992072e-03f, -9.57100466e-02f, 6.24211133e-03f, 1.04055382e-01f, -1.57643687e-02f,
  1.10328346e-01f, 3.20067890e-02f, -1.09084681e-01f, -3.99453491e-02f, -3.10767412e-01f, 8.28689411e-02f, 4.84283577e-04f, -6.46882281e-02f, -2.59558521e-02f, -1.52969226e-01f,
  1.80167839e-01f, -1.56721007e-02f, -1.44170105e-01f, -2.73601115e-01f, 1.70781583e-01f, -1.32848155e-02f, 7.98527896e-02f, -4.92176488e-02f, 6.40103547e-03f, 7.64383972e-02f,
  -1.55836428e-02f, 3.05781383e-02f, 1.41332537e-01f, 6.87707141e-02f, 7.62227029e-02f, -2.61393655e-02f, 1.20941631e-01f, 3.72901489e-03f, 1.04374900e-01f, 8.50814953e-03f,
  -1.85312927e-02f, -1.08531117e-01f, 1.07155509e-01f, 1.30502880e-01f, -4.54811864e-02f, 1.49400547e-01f, -1.67069361e-01f, -4.65461463e-02f, -1.86100751e-02f, 4.00406420e-02f,
  3.83476287e-01f, -1.05863120e-02f, 2.49455780e-01f, 2.59878159e-01f, 1.07316427e-01f, -1.52485147e-01f, 2.04747155e-01f, 3.89359623e-01f, 2.69283831e-01f, -1.49669632e-01f,
  -1.13337331e-01f, 3.14790964e-01f, 1.44209385e-01f, 3.21309716e-01f, 3.90035391e-01f, -3.75907332e-01f, -6.53881729e-02f, 2.24401221e-01f, -4.70545799e-01f, 1.68553203e-01f,
  -3.62498313e-01f, -6.72525764e-02f, -9.96381044e-02f, -2.52012610e-01f, -4.44609761e-01f, 5.11495247e-02f, -3.26713234e-01f, -1.11179315e-01f, -5.00823140e-01f, 2.13338062e-01f,
  -2.44733632e-01f, 6.39398843e-02f, -2.77428895e-01f, 1.62527025e-01f, -6.86144307e-02f, -4.52923328e-02f, -1.60606027e-01f, -3.32183361e-01f, 2.63285309e-01f, -1.33005241e-02f,
  -1.02434419e-01f, 2.93460160e-01f, -4.07666475e-01f, -2.21736208e-01f, 2.95457363e-01f, 4.69976842e-01f, -2.18912195e-02f, 1.14660703e-01f, -2.47950330e-01f, 1.33483738e-01f,
  -2.07673043e-01f, -1.23455942e-01f, -7.90356621e-02f, 2.24729627e-02f, 2.56148018e-02f, -9.06641260e-02f, 3.85208018e-02f, -8.77872407e-02f, -1.66232079e-01f, -1.34835199e-01f,
  -1.77891940e-01f, 7.20295087e-02f, -1.48039490e-01f, -4.52564210e-02f, 9.74684134e-02f, 7.13473931e-02f, -4.83929142e-02f, -7.58775473e-02f, 6.16368977e-03f, -5.47925308e-02f,
  -6.27094433e-02f, 4.65516895e-02f, -1.59516275e-01f, -1.82366290e-03f, -1.79856084e-02f, 4.13662553e-01f, -1.08688571e-01f, -1.22459516e-01f, 5.92531264e-03f, -1.76054761e-01f,
  -1.85798571e-01f, -1.16246723e-01f, -1.34278908e-02f, 9.71278772e-02f, -9.93310660e-02f, -1.23572081e-01f, 4.64408472e-02f, 6.56343475e-02f, -1.03705257e-01f, -2.42825635e-02f,
  -1.26042530e-01f, 1.33525431e-01f, -3.77005309e-01f, -1.75843351e-02f, 4.36362848e-02f, 5.77402227e-02f, -5.23096882e-02f, -1.03376850e-01f, -3.19226347e-02f, 3.03979144e-02f,
  7.44303465e-02f, -2.73611173e-02f, 5.14011690e-03f, 9.34971217e-03f, -8.61244500e-02f, -4.37379964e-02f, 1.31571814e-01f, -9.98169035e-02f, -6.97013214e-02f, 8.46723020e-02f,
  -8.58865678e-02f, 5.34942858e-02f, 1.02275871e-01f, -9.21511129e-02f, -2.40320489e-02f, 4.82332595e-02f, -6.97002187e-02f, -1.43123478e-01f, -1.51460646e-02f, -5.83536997e-02f,
  -2.12659702e-01f, -3.22898805e-01f, -1.34310529e-01f, -6.67494088e-02f, 9.21279285e-03f, -1.78026743e-02f, 6.68468848e-02f, 1.69008449e-01f, 4.86060344e-02f, -2.85742164e-01f,
  -3.17353487e-01f, 3.71355623e-01f, 1.26378193e-01f, -1.11691728e-01f, -1.23369731e-01f, 1.76455259e-01f, 2.26807579e-01f, -1.61830559e-01f, 1.23723760e-01f, -3.45616251e-01f,
  7.91479796e-02f, -1.09272011e-01f, -3.26616429e-02f, 2.12906331e-01f, 2.04808742e-01f, 1.35729104e-01f, -1.42094493e-01f, -2.97827810e-01f, -1.41218737e-01f, 3.93353663e-02f,
  -1.73926726e-01f, -1.47935137e-01f, 5.94027378e-02f, -1.22635983e-01f, 3.09151188e-02f, 2.52384692e-01f, -8.60150531e-02f, 1.09444484e-01f, -2.44205505e-01f, 1.17890187e-01f,
  5.23956493e-02f, 4.50473465e-02f, 1.50805667e-01f, 2.83024050e-02f, -2.24216565e-01f, 2.07355946e-01f, -2.73429025e-02f, 1.23241171e-01f, 2.26994917e-01f, -2.31309235e-02f,
  2.27466613e-01f, 8.41698870e-02f, 3.23311329e-01f, -2.02017933e-01f, -1.18339390e-01f, 5.59094436e-02f, -1.58675089e-01f, -1.36330724e-01f, 6.53409004e-01f, 1.29380897e-01f,
  -3.33286524e-02f, -8.44147727e-02f, 1.89091638e-02f, -5.23958914e-02f, -1.02677509e-01f, 2.14168872e-03f, 3.03317934e-01f, 2.69772690e-02f, 2.12306142e-01f, -1.77720487e-01f,
  3.00301462e-01f, -1.22642927e-01f, -1.16680533e-01f, -2.13992111e-02f, -9.86777544e-02f, 1.90651827e-02f, 1.92477196e-01f, 2.00184971e-01f, 7.81281590e-02f, -1.54151902e-01f,
  8.70191380e-02f, 2.25985963e-02f, 4.02211323e-02f, -5.87744378e-02f, 4.55107838e-02f, -1.59965321e-01f, -3.93741988e-02f, 1.18557885e-01f, 7.74773210e-02f, -4.95821759e-02f,
  -8.03632066e-02f, 7.03250989e-02f, -8.65524113e-02f, 1.93047076e-02f, 3.92924696e-02f, 3.20090093e-02f, 6.15420230e-02f, -1.15360044e-01f, -1.21368729e-01f, -8.32679216e-03f,
  9.97966081e-02f, -2.09460199e-01f, 5.55633642e-02f, -2.60470621e-02f, -4.01926190e-02f, -3.18186074e-01f, -3.77179869e-02f, -5.91422245e-03f, -1.37652978e-01f, 4.76375036e-02f,
  4.30898927e-02f, -1.04942769e-02f, -1.08067565e-01f, -1.97890714e-01f, -7.12220222e-02f, -3.20486189e-03f, 4.65958156e-02f, -2.80794967e-02f, -1.76314649e-03f, 1.15701027e-01f,
  1.80892032e-02f, 7.41440952e-02f, -2.02836841e-01f, 3.71081978e-02f, -1.57791618e-02f, 7.80570433e-02f, -9.83525291e-02f, 2.18619835e-02f, -1.73648804e-01f, -1.23270415e-01f,
  1.44825190e-01f, -1.72654897e-01f, 2.55920161e-02f, -6.92938194e-02f, 9.88328159e-02f, 7.32377395e-02f, 2.39350677e-01f, -1.73177347e-02f, -6.63171411e-02f, 1.39314488e-01f,
  3.08113128e-01f, -1.74149618e-01f, -1.66104902e-02f, 2.54325289e-02f, 2.49374628e-01f, -1.60478391e-02f, -1.20891869e-01f, 1.07933350e-01f, -1.80544809e-01f, -1.21056601e-01f,
  -1.90089539e-01f, 6.43170774e-02f, -3.51971775e-01f, -6.86240643e-02f, 6.51068017e-02f, 1.16867028e-01f, 3.69485259e-01f, -1.53606594e-01f, -2.14868709e-01f, 4.14545566e-01f,
  2.26718634e-01f, 9.93997306e-02f, -2.41604879e-01f, 2.24457294e-01f, 3.77609789e-01f, 9.35304984e-02f, -6.96366653e-02f, -1.15001732e-02f, 1.16509549e-01f, -1.61575601e-01f,
  -1.23998970e-01f, -1.59366250e-01f, -6.59531876e-02f, -2.89514393e-01f, -2.64334202e-01f, -1.01619467e-01f, -2.39362910e-01f, 4.61867750e-02f, -2.62396902e-01f, -2.98642874e-01f,
  -2.22675070e-01f, -9.76024121e-02f, 1.91068307e-01f, -6.83468953e-02f, 2.44625472e-02f, -3.60708386e-02f, 1.09959897e-02f, 1.39324620e-01f, 4.09621224e-02f, 2.36373693e-02f,
  1.53938793e-02f, 2.61413474e-02f, -6.69213459e-02f, 1.78317234e-01f, -1.31064788e-01f, -1.91865545e-02f, 2.93311831e-02f, -1.65491045e-01f, -1.44357428e-01f, 3.47549804e-02f,
  -7.78625757e-02f, -9.31314752e-03f, 5.79486012e-01f, 2.79531777e-01f, -3.94685334e-03f, -2.54502837e-02f, 9.18954834e-02f, -1.15325004e-01f, 6.86994940e-02f, -5.57686128e-02f,
  5.49477637e-01f, -1.02651268e-01f, 5.51393293e-02f, 7.92058036e-02f, -3.76831591e-02f, 1.68533120e-02f, 8.77614170e-02f, -1.21762175e-02f, 2.56019626e-02f, -1.21932894e-01f,
  1.07570454e-01f, 8.27423576e-03f, -9.65984389e-02f, 3.54104419e-03f, 1.28608361e-01f, 8.05126876e-02f, -2.36043222e-02f, 1.41821846e-01f, 2.20521837e-01f, 4.79656272e-02f,
  -5.20709762e-03f, -1.47349209e-01f, -7.19685480e-02f, -3.18154961e-01f, 1.68083608e-01f, 5.93053289e-02f, 1.39058605e-01f, 7.58174881e-02f, -1.97550461e-01f, 3.97014804e-02f,
  -9.19633955e-02f, -2.86234111e-01f, -3.52792919e-01f, 8.85028914e-02f, -4.58757952e-02f, 1.30369022e-01f, 1.15754277e-01f, 1.41857937e-01f, -3.34870555e-02f, 1.30485430e-01f,
  1.20853841e-01f, -1.20925754e-01f, -1.19828224e-01f, 3.85443829e-02f, -9.39480662e-02f, 2.26952970e-01f, 1.55840755e-01f, 5.58737516e-02f, 3.11896112e-02f, 4.26983461e-02f,
  -7.78087229e-02f, -1.53232329e-02f, -7.34865069e-02f, -7.99521580e-02f, -2.38305315e-01f, 2.69264042e-01f, 7.56647289e-02f, -6.49819570e-03f, -3.11330199e-01f, 1.05647124e-01f,
  3.38675797e-01f, -4.67876829e-02f, 1.05423182e-01f, 3.38451624e-01f, -2.00795546e-01f, -3.37684527e-02f, 1.03503369e-01f, 1.60754591e-01f, 2.00983062e-01f, -1.13186389e-01f,
  -4.71538454e-02f, 2.13999882e-01f, 3.86107624e-01f, -3.73984903e-01f, -4.12110418e-01f, -1.21145129e-01f, -2.10624278e-01f, -1.51585966e-01f, -1.34584233e-01f, -4.31254238e-01f,
  2.14770719e-01f, 2.57267714e-01f, -4.14023608e-01f, 4.56336796e-01f, -8.91367346e-02f, 3.07655185e-01f, 2.93419927e-01f, 1.32787898e-01f, -1.08572328e-02f, -2.54321486e-01f,
  4.11703251e-02f, 2.42841229e-01f, 3.71357590e-01f, 2.55061537e-01f, -2.45131806e-01f, -3.93250138e-01f, -1.44921159e-02f, -1.05751656e-01f, 7.54135847e-02f, -1.67627588e-01f,
  2.62888968e-02f, 3.55890810e-01f, 5.92763945e-02f, 3.36948812e-01f, 1.43094391e-01f, -8.12193602e-02f, -1.62332684e-01f, 1.02600433e-01f, 2.66158730e-01f, -1.14075094e-01f,
  6.06259657e-03f, -3.87048759e-02f, -1.16709694e-01f, 3.39255529e-03f, -1.17561020e-01f, 1.48521299e-02f, -1.37154564e-01f, -4.50300947e-02f, -1.42362922e-01f, 4.78662491e-01f,
  -1.09852083e-01f, -5.36397658e-02f, -1.10827297e-01f, -4.55395654e-02f, -1.24688014e-01f, -1.43446177e-01f, 3.79891582e-02f, -2.43782885e-02f, -7.98737481e-02f, 4.05900963e-02f,
  4.56874669e-02f, 1.14089146e-01f, -1.39020160e-01f, -3.63223962e-02f, 9.65638980e-02f, -3.37987416e-03f, -8.26647356e-02f, -9.51931328e-02f, 8.23344514e-02f, 1.69958379e-02f,
  9.64353532e-02f, 8.47368985e-02f, -7.63892904e-02f, -1.21013097e-01f, -1.69645865e-02f, 8.34979191e-02f, 7.54124150e-02f, 4.42740619e-02f, -1.61821693e-01f, 3.21389176e-02f,
  8.25927705e-02f, 5.57221621e-02f, 1.24377042e-01f, -1.64814264e-01f, 1.35651737e-01f, 1.04685582e-01f, -7.02995211e-02f, 1.87934265e-01f, 1.35386251e-02f, 3.48289609e-02f,
  -4.37128656e-02f, 5.03815226e-02f, -6.58692420e-02f, -3.87393869e-02f, 1.21206030e-01f, -8.40774029e-02f, 1.25537023e-01f, -1.50667220e-01f, 2.08826363e-01f, 1.37933850e-01f,
  -6.92331651e-03f, -9.15292203e-02f, -9.33155417e-02f, 4.82538231e-02f, 2.27999300e-01f, 2.07299545e-01f, 1.73272148e-01f, 3.63059007e-02f, -1.11864634e-01f, -1.89510286e-02f,
  6.23088423e-03f, -5.35914041e-02f, -4.00175005e-02f, 2.92813122e-01f, -2.19679505e-01f, -1.26168683e-01f, -1.62865296e-01f, 2.67010480e-01f, -2.04732180e-01f, 1.40043601e-01f,
  3.83289647e-03f, 5.83110377e-02f, 1.92641646e-01f, -3.04469138e-01f, 1.62119567e-01f, -2.15050012e-01f, -4.82343622e-02f, 4.30453181e-01f, -1.87416479e-01f, -3.88982743e-01f,
  -2.13445067e-01f, -9.72979367e-02f, 3.04983675e-01f, 2.65785426e-01f, -3.38854074e-01f, -2.52535015e-01f, 1.52502909e-01f, 2.07907230e-01f, 6.78306520e-02f, -1.33313194e-01f,
  1.90374941e-01f, -3.32548767e-01f, 2.46219963e-01f, -2.17711046e-01f, 2.24165022e-01f, -2.17126776e-02f, -5.15001833e-01f, -1.40995681e-01f, 3.61781448e-01f, -7.52208903e-02f,
  -1.15620434e-01f, 1.87316522e-01f, 4.62815762e-01f, -2.58923173e-01f, -1.99523166e-01f, 2.04286531e-01f, 9.83875096e-02f, 2.13143915e-01f, 2.70412445e-01f, -1.95524111e-01f,
  -3.59706342e-01f, -1.94544435e-01f, -1.64177448e-01f, 1.01239540e-01f, 1.71284512e-01f, 1.25692561e-01f, -1.51719853e-01f, -1.21368460e-01f, 1.86902061e-02f, -5.69473393e-02f,
  3.41651849e-02f, 1.86593220e-01f, -1.13205440e-01f, -7.38277435e-02f, -1.21500619e-01f, 8.50827321e-02f, 2.32037857e-01f, -1.72395647e-01f, 4.36695814e-02f, 1.71946827e-02f,
  -7.45079443e-02f, 9.22458246e-02f, -8.17847252e-02f, 2.21840724e-01f, 6.38845861e-02f, -3.04224771e-02f, -1.06060252e-01f, 9.31597501e-02f, 1.01518082e-02f, -2.59498712e-02f,
  6.27669469e-02f, -2.99652964e-02f, -1.60668567e-01f, -5.84203340e-02f, 7.55482167e-03f, 1.18040822e-01f, 2.01513488e-02f, 3.91722545e-02f, -2.19182763e-02f, 8.21264908e-02f,
  3.88074145e-02f, 2.68860441e-02f, 1.34373367e-01f, -1.37778580e-01f, 5.13512306e-02f, 1.33046299e-01f, 9.70095173e-02f, 1.03345867e-02f, -5.12527041e-02f, 9.66949910e-02f,
  6.43532202e-02f, 1.25452027e-01f, -4.22886759e-03f, 1.09529734e-01f, -9.19394046e-02f, -2.55525738e-01f, 3.34810019e-02f, -8.33981298e-03f, 1.36586502e-01f, 2.37372816e-02f,
  5.56476675e-02f, -2.13710144e-01f, -3.89969498e-02f, 1.15388103e-01f, -9.52730328e-02f, 8.57389420e-02f, -5.37663475e-02f, -9.40650776e-02f, 4.28706855e-02f, 2.19824895e-01f,
  -2.88268793e-02f, 5.03935292e-02f, 5.46954647e-02f, 9.11560580e-02f, 1.14118019e-02f, 6.25391677e-02f, 1.13701001e-01f, -8.53880867e-02f, -1.37383984e-02f, 2.11492941e-01f,
  1.31378219e-01f, 1.41434267e-01f, 3.14760171e-02f, 3.56663734e-01f, 3.24563861e-01f, 2.72529244e-01f, 1.30113199e-01f, 1.35975227e-01f, -1.36950180e-01f, -1.70724243e-01f,
  1.77341506e-01f, -2.15767980e-01f, 1.12795793e-01f, 4.38931771e-02f, -4.17197853e-01f, -1.65203810e-01f, -1.43421009e-01f, 1.84951887e-01f, 1.70778558e-01f, -1.62109524e-01f,
  1.40999377e-01f, 1.03721842e-01f, 1.98979586e-01f, -1.67899966e-01f, -4.09826748e-02f, -3.13589215e-01f, -4.52068180e-01f, 9.35837403e-02f, 6.85171261e-02f, 1.13194197e-01f,
  3.10822248e-01f, -1.90980271e-01f, -4.38485503e-01f, 2.99573183e-01f, 2.13663638e-01f, 2.26455078e-01f, -6.36636242e-02f, -4.43747669e-01f, -3.06995094e-01f, -2.25913197e-01f,
  6.70141727e-02f, 1.61995977e-01f, -1.75284535e-01f, 2.88274109e-01f, -1.20874561e-01f, 1.79365389e-02f, -1.39274955e-01f, -2.54466757e-02f, 3.33597571e-01f, -5.22381216e-02f,
  -1.00325361e-01f, -1.42938837e-01f, 3.29689562e-01f, 3.18391949e-01f, 5.42375296e-02f, 8.64780173e-02f, 1.24709560e-02f, -1.70541316e-01f, 1.57759666e-01f, -2.09234968e-01f,
  -3.21861543e-03f, -5.48107661e-02f, -2.33112976e-01f, 1.36802375e-01f, -8.64738449e-02f, -2.95280889e-02f, 6.29308680e-03f, -4.85022403e-02f, -9.76788700e-02f, 2.84114201e-02f,
  -1.30360037e-01f, 3.74432355e-01f, -1.13512147e-02f, 5.06295323e-01f, -4.98317815e-02f, -4.53515463e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  7.08225416e-03f, 5.26301078e-02f, 8.32741261e-02f, 5.16249090e-02f, 7.91592300e-02f, -7.83748478e-02f, 3.99605893e-02f, 5.22249863e-02f, -7.95055479e-02f, -1.91406850e-02f,
  -2.32047569e-02f, -8.50273445e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    