/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.17878854e-01f, -1.25028864e-01f, -9.66232270e-02f, -3.36753547e-01f, 2.52133876e-01f, 2.50441432e-01f, 2.62080967e-01f, 1.46193296e-01f, -9.91852731e-02f, 7.26088956e-02f,
  -6.92464262e-02f, 1.21124342e-01f, -2.29487687e-01f, 7.52789900e-02f, 7.15422109e-02f, 1.44063890e-01f, -8.92657228e-03f, -2.04557821e-01f, 2.57553607e-01f, 4.30409223e-01f,
  1.34198025e-01f, -2.14385912e-01f, -5.15541732e-01f, -1.98887549e-02f, 3.53044532e-02f, 4.37119037e-01f, 3.13385464e-02f, -2.32328236e-01f, 1.30698621e-01f, -7.97698572e-02f,
  -8.88552740e-02f, -1.90419137e-01f, 1.56015664e-01f, -8.06485116e-03f, -2.71951444e-02f, -2.24282816e-02f, 1.29588112e-01f, -3.50224711e-02f, 6.20840043e-02f, -5.69415651e-02f,
  -5.65131903e-02f, 2.08747666e-02f, -9.97900888e-02f, -8.93082377e-03f, -1.28630921e-01f, -8.40632394e-02f, -1.04051149e-02f, -1.08459890e-01f, -6.94575906e-02f, 1.81579720e-02f,
  5.11096008e-02f, -1.39635075e-02f, -1.49179161e-01f, 3.16711701e-02f, 1.04564153e-01f, -9.06365439e-02f, -3.63788046e-02f, -1.07746780e-01f, -2.60339864e-03f, 4.42222841e-02f,
  1.81339998e-02f, -2.69584525e-02f, 6.83126226e-02f, 4.56519797e-03f, 2.84073148e-02f, 1.43839363e-02f, -2.30791029e-02f, 5.31020351e-02f, 3.14267203e-02f, 4.61281557e-03f,
  3.49701196e-02f, -2.39118263e-02f, -3.54914181e-03f, -2.20888220e-02f, -9.52171255e-03f, 1.09791718e-02f, 5.63500915e-04f, -2.11906359e-02f, -2.82420008e-03f, -8.45439211e-02f,
  -6.44341856e-02f, -1.47508802e-02f, -1.22983530e-02f, 2.46274173e-02f, 1.52485976e-02f, 1.07967984e-02f, -3.98888700e-02f, -6.61445037e-03f, -1.35477210e-04f, -4.50095572e-02f,
  4.94177407e-03f, -2.42663547e-03f, -7.59926438e-02f, 2.38978006e-02f, 1.13469241e-02f, -4.67962772e-02f, -1.45861089e-01f, 7.01991422e-03f, -6.18822612e-02f, -4.89962362e-02f,
  3.47179100e-02f, 1.44110480e-02f, -1.64949894e-02f, 1.26415177e-03f, 1.42881319e-01f, 4.41146977e-02f, 2.11600494e-02f, 1.02640748e-01f, 2.20696907e-02f, -1.47044901e-02f,
  -8.09817165e-02f, 1.07106820e-01f, 1.60654604e-01f, 1.01472298e-02f, -3.19555625e-02f, 1.39339775e-01f, 8.46272334e-02f, 4.71227542e-02f, 7.47580081e-02f, 1.39418438e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.52568212e-02f, -1.27113909e-01f, 1.83127016e-01f, 4.22132239e-02f, -7.19041750e-02f, -1.87110677e-01f, -3.77061814e-01f, -1.44766375e-01f, 1.02913611e-01f, -8.73058364e-02f,
  -4.97622006e-02f, 2.31005609e-01f, 1.26979634e-01f, 1.10505685e-01f, -7.24374829e-03f, -4.90936153e-02f, 1.52688801e-01f, 2.78461248e-01f, 1.02755785e-01f, 7.64365792e-02f,
  1.91736713e-01f, 2.85445545e-02f, 1.71322450e-02f, -6.91191703e-02f, 1.96502462e-01f, 3.11356243e-02f, 1.19163347e-02f, 1.28899803e-02f, 2.90740691e-02f, 4.24330920e-01f,
  -3.52443568e-02f, -1.10221051e-01f, 1.15227871e-01f, -4.95949108e-03f, -5.77341067e-03f, -2.09834948e-02f, -7.24692792e-02f, 5.32610416e-02f, 2.45766528e-02f, -5.45705557e-02f,
  4.59168442e-02f, 7.44144171e-02f, -1.28560578e-02f, 2.44877506e-02f, -8.38368610e-02f, -5.03811147e-03f, -3.77922319e-02f, 4.54249978e-02f, 7.40476027e-02f, -6.47072643e-02f,
  -5.40105253e-02f, -1.51862532e-01f, -8.38666111e-02f, -1.44681931e-01f, 1.35442447e-02f, 1.98243499e-01f, 3.27490345e-02f, 1.06608048e-01f, 6.52704900e-03f, 9.27207395e-02f,
  1.50324153e-02f, 8.66362751e-02f, -4.84494703e-05f, -1.49285025e-03f, -2.80988272e-02f, -2.05459371e-02f, 4.48678471e-02f, -2.04933789e-02f, 1.04934670e-01f, -2.00474588e-03f,
  3.20832096e-02f, -3.37185077e-02f, -2.73684412e-02f, 5.21308519e-02f, 1.96551904e-02f, 5.51145449e-02f, 2.07474958e-02f, 4.56962809e-02f, -1.50081655e-03f, 3.57896686e-02f,
  4.62862290e-03f, 8.31395984e-02f, -3.86389904e-02f, 5.55045949e-03f, -1.14155915e-02f, 9.45849791e-02f, 4.90441620e-02f, 3.26890908e-02f, 2.42052367e-03f, 1.69031639e-02f,
  -2.31927738e-01f, 9.20723565e-03f, 1.18649565e-02f, -5.41234501e-02f, -7.01927468e-02f, -1.84299108e-02f, -4.27855551e-02f, 7.93251619e-02f, -2.28294712e-02f, -8.16809461e-02f,
  -4.45733964e-02f, -6.51016682e-02f, -5.89275844e-02f, -7.57175907e-02f, 3.10552735e-02f, -4.63831872e-02f, -6.39010966e-02f, 1.05841428e-01f, 1.84032079e-02f, -4.00652736e-02f,
  -5.64050674e-02f, -1.58325717e-01f, -1.96178228e-01f, -1.45071298e-01f, 1.70672759e-02f, -4.40991782e-02f, 4.55949381e-02f, 3.26892696e-02f, -6.67933896e-02f, -4.37794141e-02f,
  9.36352089e-02f, 3.61769050e-02f, 2.27989778e-02f, -1.63902845e-02f, 1.01028331e-01f, 2.27872916e-02f, 8.89747515e-02f, 1.26188666e-01f, 2.34332047e-02f, 9.19387266e-02f,
  5.11117689e-02f, -3.51004452e-02f, -2.19596010e-02f, 3.82966883e-02f, -6.41267896e-02f, 5.78394905e-02f, 3.72811081e-03f, 2.90666264e-03f, -2.30067354e-02f, -6.06312836e-03f,
  9.29371342e-02f, -5.41972257e-02f, 3.20889130e-02f, -2.28143092e-02f, -3.39998007e-02f, 4.23072791e-03f, 5.01974560e-02f, 3.73839326e-02f, 1.74875949e-02f, 2.21662428e-02f,
  9.59417224e-03f, 1.42164052e-01f, -2.31602155e-02f, 9.52963680e-02f, -2.71864273e-02f, -4.76013236e-02f, 4.31235246e-02f, 7.72019103e-02f, 4.37452048e-02f, 9.68920738e-02f,
  -3.04947477e-02f, 8.74988437e-02f, 1.01554934e-02f, 1.05151467e-01f, -5.97073324e-02f, -5.55633493e-02f, 1.25796556e-01f, 1.35053277e-01f, 1.25092477e-01f, 3.68893594e-02f,
  2.24080961e-03f, 1.15922116e-01f, 6.19185679e-02f, 1.90044735e-02f, 6.40744567e-02f, 6.01502880e-02f, -6.59773406e-03f, 1.43681854e-01f, 6.47395179e-02f, 9.21968464e-03f,
  -4.09911945e-02f, -3.57012488e-02f, -8.91758353e-02f, 3.10489647e-02f, -7.60941580e-02f, 7.51782507e-02f, -3.38917933e-02f, 4.65761125e-02f, -6.79167062e-02f, 6.80275401e-03f,
  -9.65533480e-02f, -5.40911816e-02f, 5.18575609e-02f, -2.46998016e-02f, -2.06375103e-02f, 6.49526715e-02f, 9.38411877e-02f, -8.34566727e-02f, -2.94412207e-03f, 1.21775912e-02f,
  -1.70569366e-03f, 6.24033064e-02f, -3.48282307e-02f, -5.36205694e-02f, 5.87590002e-02f, 5.08007072e-02f, -6.46023005e-02f, -2.80439965e-02f, 2.57962327e-02f, -2.79360525e-02f,
  -3.60522643e-02f, 1.26014248e-01f, 8.59989673e-02f, 6.58501387e-02f, 4.62516584e-02f, 3.00853048e-02f, 6.19792975e-02f, -4.37594503e-02f, -6.34826645e-02f, -5.08561879e-02f,
  1.69197470e-02f, -2.89527811e-02f, -5.65009788e-02f, 6.95920065e-02f, 3.40816416e-02f, -8.41486007e-02f, 1.04116276e-02f, -1.94701608e-02f, 2.38209572e-02f, 4.86909337e-02f,
  -5.47960401e-02f, -8.73364955e-02f, -8.73400271e-02f, 9.18477625e-02f, 7.79201984e-02f, 4.72229421e-02f, 3.32925245e-02f, -1.13313412e-02f, 8.68373364e-02f, -4.94566932e-02f,
  1.51647970e-01f, 2.89925843e-01f, -4.31151874e-02f, 3.48138995e-03f, 7.24320784e-02f, 6.33445680e-02f, 4.09778655e-02f, -1.26010422e-02f, -3.09772305e-02f, -1.41472537e-02f,
  4.21695635e-02f, -6.34691343e-02f, -1.22750424e-01f, -1.70757309e-01f, -5.87009341e-02f, 9.73125845e-02f, 9.63975787e-02f, 9.88189355e-02f, -5.58530837e-02f, 3.12342886e-02f,
  1.23900101e-01f, 3.65221649e-02f, 1.19311795e-01f, -3.02261990e-02f, 2.45253351e-02f, -1.51274456e-02f, 6.23731799e-02f, 1.67385578e-01f, 1.70340970e-01f, 1.93324625e-01f,
  1.66592188e-02f, 2.26571754e-01f, -1.66897699e-01f, -1.00963181e-02f, -2.34490912e-02f, -7.46989623e-02f, 4.45710905e-02f, 2.48092245e-02f, -1.07722864e-01f, -4.29800414e-02f,
  8.38132724e-02f, -4.67077903e-02f, 3.35068107e-02f, 2.31210887e-02f, 4.51739319e-02f, -8.44208747e-02f, -1.13928542e-02f, -2.64001880e-02f, -2.19126567e-02f, 5.26127256e-02f,
  1.25545159e-01f, 1.55244648e-01f, -2.47192867e-02f, -6.25293851e-02f, 1.05157971e-01f, 5.39057218e-02f, -3.34019936e-03f, -1.77722611e-02f, -7.18368962e-02f, -4.87105129e-03f,
  -8.35150778e-02f, -2.89861020e-03f, 3.60446097e-03f, 1.39638865e-02f, -3.14837284e-02f, -2.64164470e-02f, -7.11702555e-03f, 2.37780511e-02f, -6.96382858e-03f, -6.50679274e-03f,
  -1.04900487e-01f, 4.01709639e-02f, -1.01537645e-01f, -9.55585912e-02f, -9.81116742e-02f, -3.02695781e-02f, 6.36228994e-02f, -1.30285108e-02f, -7.11338148e-02f, 3.08722891e-02f,
  -1.40854903e-02f, -5.02611548e-02f, 1.50928972e-02f, 6.63258042e-03f, 2.38237139e-02f, -1.26618281e-01f, 1.34186652e-02f, 2.73470767e-02f, -6.78470582e-02f, -1.12205073e-02f,
  -9.86393690e-02f, -1.96164414e-01f, 1.80010144e-02f, 1.17715463e-01f, 4.41942811e-02f, -1.38718570e-02f, -1.57719068e-02f, -3.63111384e-02f, 7.34008253e-02f, 5.18959910e-02f,
  9.96152610e-02f, -5.44604808e-02f, 9.61871445e-02f, -6.65475950e-02f, 1.76346675e-02f, 2.98402887e-02f, 1.67436767e-02f, 7.16316476e-02f, -3.24086193e-03f, -1.75747629e-02f,
  2.87063699e-02f, -1.02445101e-02f, -1.20810799e-01f, -1.33989304e-01f, -1.18734073e-02f, -4.13912348e-02f, -4.27385755e-02f, -9.81469303e-02f, -1.29501164e-01f, -1.26569539e-01f,
  2.69285262e-01f, -4.62419800e-02f, 8.94391835e-02f, 1.98044464e-01f, 2.93354571e-01f, 2.88947552e-01f, 4.05628175e-01f, 2.70202726e-01f, 2.00689405e-01f, 6.77612647e-02f,
  1.95044801e-02f, -3.58453579e-02f, -7.91790336e-02f, -1.09422661e-01f, 1.63651649e-02f, 2.06376150e-01f, 1.53884426e-01f, 1.73291683e-01f, 9.85166654e-02f, 1.93809196e-01f,
  5.98764345e-02f, -1.06287692e-02f, -7.22736418e-02f, -7.79286250e-02f, 8.41576606e-02f, -5.42810038e-02f, -4.29679938e-02f, 4.93946113e-02f, -8.17982331e-02f, 1.03699841e-01f,
  2.76469979e-02f, 1.75965756e-01f, 7.92861357e-02f, -1.55190840e-01f, -1.83848143e-01f, -8.44754353e-02f, -3.07536740e-02f, -1.94778472e-01f, 3.69346812e-02f, -8.67335722e-02f,
  -1.37546614e-01f, -7.58123025e-02f, 7.16116428e-02f, -1.06237754e-01f, -3.93087678e-02f, -1.20106488e-02f, -8.91143531e-02f, 1.35340959e-01f, 1.07175194e-01f, -4.41889279e-02f,
  9.26042069e-03f, 7.62508297e-03f, -9.78234410e-03f, 5.08038960e-02f, 1.45544067e-01f, 2.62141507e-02f, 3.04624364e-02f, 2.26527173e-02f, 1.10272262e-02f, 3.85519676e-02f,
  1.46599784e-01f, 6.38685673e-02f, -9.42360144e-03f, -4.05433774e-02f, 1.18408650e-01f, 4.31947485e-02f, 8.06196630e-02f, -4.84443791e-02f, 9.50569659e-02f, -3.61871272e-02f,
  -4.19272408e-02f, -7.46959075e-03f, 6.80334568e-02f, 8.26465786e-02f, 1.66986641e-02f, -3.91286872e-02f, 6.65031075e-02f, 1.21387569e-02f, -7.27147087e-02f, -4.44194898e-02f,
  3.62534374e-02f, 8.28523561e-02f, -4.63966057e-02f, 1.41244987e-02f, 6.13407977e-02f, 2.62671392e-02f, 1.28860250e-01f, -1.51992291e-02f, -9.77826566e-02f, 1.14512434e-02f,
  -9.08800215e-02f, 9.17334855e-03f, 1.77642867e-01f, -3.63865644e-02f, -8.22739676e-02f, -1.13114960e-01f, 1.65369026e-02f, -4.55183946e-02f, -2.10560989e-02f, 1.23566082e-02f,
  -8.47214982e-02f, -8.52876380e-02f, -2.04763119e-03f, -4.84486111e-02f, -3.82080451e-02f, -9.46253017e-02f, -8.01057145e-02f, 4.79169935e-02f, 1.46761192e-02f, -2.01118179e-02f,
  1.22517236e-02f, 6.36962354e-02f, 4.79780473e-02f, 2.89230254e-02f, -8.63644201e-03f, -5.38113043e-02f, -4.37223762e-02f, 1.69696026e-02f, -3.09219165e-03f, -1.43830225e-01f,
  -1.99994490e-01f, -8.12424868e-02f, -9.46077183e-02f, 1.79671869e-01f, 2.19887093e-01f, 2.40610801e-02f, -5.79699837e-02f, -1.90635230e-02f, 1.81350380e-01f, 6.01010062e-02f,
  2.59251501e-02f, 1.24924123e-01f, 8.64008516e-02f, 4.02303450e-02f, -1.17520718e-02f, 9.18235034e-02f, 8.95155668e-02f, 1.31386459e-01f, 3.63874696e-02f, 5.37399799e-02f,
  8.10123757e-02f, -6.07805215e-02f, -7.05190301e-02f, 2.20790412e-02f, 1.12192094e-01f, 3.52218337e-02f, 6.00100905e-02f, -4.35613170e-02f, 4.48057763e-02f, 2.26752296e-01f,
  -7.08491057e-02f, -9.60606802e-03f, 1.00646382e-02f, 6.19613416e-02f, -5.98043092e-02f, 3.17453220e-03f, -2.36105057e-03f, -1.74647160e-02f, 3.75909545e-02f, -4.20735739e-02f,
  3.28124464e-02f, -3.26831266e-02f, -6.48242682e-02f, 3.71646509e-02f, -1.24302410e-01f, 1.19966362e-02f, -1.15287557e-01f, -2.72801798e-02f, 9.44609568e-02f, -3.51417996e-02f,
  1.07715346e-01f, 9.09295604e-02f, 7.90315494e-02f, 6.96891695e-02f, 1.04968198e-01f, 8.90490413e-02f, 1.83455937e-03f, 2.72035655e-02f, -8.95876735e-02f, 1.85814723e-02f,
  -1.23238750e-02f, 4.21905611e-03f, -5.77769987e-02f, -5.65711521e-02f, -2.15765033e-02f, 3.67791653e-02f, -4.19704616e-02f, 9.26086772e-03f, -3.35382996e-03f, -1.13315925e-01f,
  -7.15962574e-02f, -9.91224498e-03f, -1.39199169e-02f, 5.61675467e-02f, 9.67008714e-03f, -2.75291707e-02f, 3.36937569e-02f, 7.83769414e-03f, 5.20016253e-02f, 6.49317517e-04f,
  6.48518279e-03f, -2.14408487e-02f, 2.61951871e-02f, -6.51834309e-02f, 2.52382457e-02f, -3.27571318e-03f, -6.06191345e-03f, 3.87877710e-02f, -5.51836565e-03f, 5.88281453e-02f,
  -2.70288233e-02f, 5.44153014e-03f, 1.02412917e-01f, 4.65536043e-02f, -3.48698422e-02f, -8.06462914e-02f, 1.09029375e-01f, -2.15002801e-04f, -2.96279741e-03f, 3.01234722e-02f,
  -2.46717799e-02f, -3.46947871e-02f, -5.75648919e-02f, -5.51979207e-02f, -1.41521581e-02f, -7.75202885e-02f, 4.90115583e-02f, 3.51958349e-03f, 5.54396585e-02f, 1.41235054e-01f,
  1.14011310e-01f, 5.94521686e-02f, -2.26117764e-02f, 9.72883627e-02f, 2.85475105e-02f, 1.04460306e-01f, 7.80926365e-03f, -5.17808693e-03f, 9.26635787e-03f, -3.44227292e-02f,
  6.36059761e-01f, 5.23141503e-01f, 1.64372310e-01f, 6.33015856e-02f, -1.89942613e-01f, -2.06286386e-02f, 1.78205878e-01f, 2.65817523e-01f, 3.93002443e-02f, 1.66309789e-01f,
  -4.43518311e-02f, -1.30586639e-01f, -1.38170674e-01f, -3.35092470e-02f, 2.52802432e-01f, 8.80535021e-02f, 9.16812271e-02f, 1.86209362e-02f, 3.49419825e-02f, -1.73567663e-04f,
  -1.60097048e-01f, 5.52814454e-02f, 2.70465016e-01f, 1.38897285e-01f, 2.62817238e-02f, -7.60646090e-02f, 6.10972345e-02f, 3.76449861e-02f, 8.70686620e-02f, -7.91906565e-02f,
  -5.27321883e-02f, 4.05014336e-01f, -1.72235236e-01f, -1.43485278e-01f, -1.30546004e-01f, 3.16912793e-02f, -1.83176361e-02f, 7.02522248e-02f, -3.09689599e-03f, 3.36863510e-02f,
  -1.17212616e-01f, 4.11493145e-02f, 4.31261659e-02f, 6.97251260e-02f, -7.59592503e-02f, 4.25978750e-02f, 1.03930734e-01f, 2.69242346e-01f, 1.09561667e-01f, 5.70036843e-02f,
  -1.18656747e-01f, -4.08245176e-02f, -9.74712800e-03f, 2.48306198e-03f, 4.20401096e-02f, -1.31392822e-01f, 7.43546262e-02f, 8.37676302e-02f, -2.60660872e-02f, 4.48514670e-02f,
  4.97140214e-02f, 5.51727675e-02f, 1.25362491e-02f, -1.41580049e-02f, 6.09069131e-02f, -7.82955438e-02f, -1.19715966e-02f, 3.16817909e-02f, 2.96898186e-02f, 2.51710974e-03f,
  1.60947815e-02f, 5.43709211e-02f, -1.10136382e-02f, 8.62824023e-02f, 3.02299112e-02f, 3.55589949e-02f, -1.22441556e-02f, -3.14115211e-02f, 2.66127791e-02f, -2.34079640e-02f,
  -4.24198024e-02f, 4.85507920e-02f, -1.02823615e-01f, 4.75789756e-02f, -2.31286753e-02f, 8.20921212e-02f, -1.42220035e-02f, -2.89685838e-02f, 2.82106306e-02f, 1.63881052e-02f,
  -3.73733193e-01f, -2.41390198e-01f, -8.38303044e-02f, 7.78692439e-02f, 2.63286550e-02f, -5.27388342e-02f, -4.14348952e-02f, -4.99493536e-03f, -6.54555708e-02f, 3.73573741e-03f,
  6.94241673e-02f, 5.22941090e-02f, 3.56815606e-02f, 2.35129688e-02f, -3.55399102e-02f, -4.38175425e-02f, -5.54709285e-02f, -5.84380701e-02f, -3.69343497e-02f, -1.05111286e-01f,
  -5.62547073e-02f, -6.62968159e-02f, -6.39492646e-02f, -2.31958963e-02f, -1.36672854e-01f, -1.52901188e-01f, -1.15342356e-01f, -4.69174720e-02f, -1.29712299e-01f, 1.71008898e-04f,
  -2.44910538e-01f, -1.72238857e-01f, -1.59309775e-01f, 1.48013443e-01f, 2.70455629e-01f, -4.33770604e-02f, -2.87515730e-01f, -7.62278587e-02f, 1.18545391e-01f, -9.45289209e-02f,
  -3.32980528e-02f, 1.99097037e-01f, 1.47385418e-01f, 4.98735532e-02f, -7.72557454e-03f, -9.20885429e-02f, 1.95765898e-01f, 1.79930106e-01f, -2.14619935e-02f, -2.68221293e-02f,
  2.31507227e-01f, 6.03406802e-02f, -1.01779915e-01f, -1.49512128e-03f, 1.18797086e-01f, 6.55587465e-02f, -7.62124434e-02f, 1.05843358e-02f, 1.53400851e-02f, 3.00789803e-01f,
  -5.75950332e-02f, -1.55218795e-01f, 2.26875283e-02f, -2.25128978e-02f, 1.21472076e-01f, -1.52413413e-01f, -6.75590709e-02f, -4.95989695e-02f, 4.54919273e-03f, -2.67970469e-02f,
  1.31711205e-02f, -5.31505533e-02f, 6.52836189e-02f, 6.62348941e-02f, 4.43748944e-02f, -1.03806034e-01f, -4.03986350e-02f, 4.31869850e-02f, 5.54371215e-02f, -7.45197982e-02f,
  2.21788153e-01f, 1.49934486e-01f, -1.04050942e-01f, -2.06550360e-01f, -1.60510868e-01f, 5.70112802e-02f, -8.50304365e-02f, -2.10263338e-02f, -1.16515517e-01f, -9.87600684e-02f,
  1.18067257e-01f, 2.29511969e-02f, 1.64170824e-02f, 3.93612497e-02f, 8.85607302e-02f, 4.75664698e-02f, 7.41774123e-03f, 1.03966109e-01f, 5.99955730e-02f, -1.04388379e-01f,
  4.11457457e-02f, 2.12419983e-02f, 2.17429176e-02f, 3.63292806e-02f, -2.07630694e-02f, 8.47175159e-03f, -1.26168774e-02f, 2.16797199e-02f, 5.29674366e-02f, -5.61838448e-02f,
  8.30554031e-03f, 1.90923382e-02f, -6.03950815e-03f, 1.89191341e-01f, -1.05956551e-02f, -3.10475640e-02f, 3.42954695e-02f, 1.19824370e-03f, -9.98186097e-02f, 1.55956363e-02f,
  -1.09601930e-01f, -1.99162625e-02f, 5.40202782e-02f, 3.25044021e-02f, 7.91375861e-02f, -1.45662325e-02f, -6.52867742e-03f, -9.64951366e-02f, -7.21963076e-03f, -3.16361189e-02f,
  -1.06081493e-01f, -2.02032086e-02f, -3.35917845e-02f, 1.27260145e-02f, -1.09695559e-02f, -3.64640839e-02f, 1.10065721e-01f, 6.83529153e-02f, -9.07516479e-02f, -7.48392120e-02f,
  3.69424280e-03f, -9.65800136e-02f, -1.25294834e-01f, -1.03740439e-01f, -5.54332547e-02f, -1.00575797e-01f, -9.36691910e-02f, -1.94923103e-01f, -2.89818645e-01f, -2.43247971e-01f,
  -3.75186890e-01f, 1.15231872e-01f, -2.02142019e-02f, -2.70008594e-01f, 4.41779047e-02f, 1.16333053e-01f, 1.32503107e-01f, 1.52337521e-01f, 5.75873181e-02f, -7.49436170e-02f,
  1.38128549e-01f, 8.67780149e-02f, -8.34919512e-02f, 2.35919170e-02f, -9.14536938e-02f, -5.75152896e-02f, -3.48410867e-02f, -5.53846993e-02f, 6.41432330e-02f, -1.44861741e-02f,
  -7.95343518e-03f, -2.01703951e-01f, -2.28294089e-01f, -1.32746354e-01f, -7.82519057e-02f, -1.29258692e-01f, -9.68468785e-02f, -8.00897554e-02f, -1.18915774e-02f, -1.69624522e-01f,
  -1.21897087e-01f, -1.60336290e-02f, -1.02787064e-02f, 6.42432943e-02f, 5.57267442e-02f, -8.26915726e-02f, -3.77569199e-02f, 7.79851004e-02f, -7.03579858e-02f, 2.99814926e-03f,
  -4.43736054e-02f, 3.91817354e-02f, -6.75341813e-03f, 1.19778067e-01f, -3.43479887e-02f, -4.55148965e-02f, 4.10598144e-02f, -2.71450430e-02f, -9.64959636e-02f, -4.27984074e-02f,
  -9.51744914e-02f, -3.92681547e-02f, -1.52084157e-01f, -6.00840226e-02f, 5.08787632e-02f, -9.86289605e-02f, -1.68458596e-02f, -6.94244131e-02f, -3.96537259e-02f, -1.31673276e-01f,
  4.38664071e-02f, 1.12232724e-02f, -1.24982521e-02f, 1.45113980e-03f, -3.63843925e-02f, -1.64337293e-03f, -4.36008023e-03f, -4.87551205e-02f, -1.50481146e-03f, -4.04633507e-02f,
  2.97467783e-02f, 1.07769281e-01f, 9.04899836e-02f, -5.59475385e-02f, 3.56440097e-02f, -2.22530235e-02f, 6.00914173e-02f, -5.99585995e-02f, -3.28391939e-02f, 8.50805566e-02f,
  5.12154698e-02f, -7.22408667e-03f, -3.79426405e-02f, 7.87916929e-02f, -3.97330485e-02f, -8.55143294e-02f, 7.57761076e-02f, 7.43032992e-02f, -5.86687364e-02f, -1.57119415e-03f,
  -1.32809877e-01f, 1.39894024e-01f, -1.19484663e-01f, -3.32841761e-02f, -3.62679511e-02f, 3.04981507e-02f, 1.34674273e-02f, 6.95103556e-02f, -2.24133953e-02f, 7.33048245e-02f,
  6.70033619e-02f, -2.95142327e-02f, -1.02853790e-01f, 3.55122462e-02f, -9.18100998e-02f, 1.66733768e-02f, -4.59539890e-02f, -3.31698656e-02f, -2.58950237e-02f, -1.12506762e-01f,
  -1.06965594e-01f, -1.70797750e-01f, -2.30008170e-01f, -1.58290535e-01f, -6.84322789e-02f, -7.42557421e-02f, -1.10238895e-01f, -5.92557304e-02f, -1.19524628e-01f, -2.66061574e-01f,
  3.72242272e-01f, -1.27701908e-01f, 3.05448204e-01f, 3.70028108e-01f, 5.26458740e-01f, 4.67600256e-01f, 5.10980427e-01f, 1.70765191e-01f, -7.32560689e-03f, 4.47755828e-02f,
  -1.18458465e-01f, -2.77455986e-01f, -3.92929047e-01f, -2.72024721e-01f, -7.78695866e-02f, 2.01148406e-01f, 9.88002270e-02f, 1.56244887e-02f, 7.93795362e-02f, 1.44587085e-01f,
  -3.64065133e-02f, 1.21468298e-01f, -1.50569916e-01f, -9.22586545e-02f, 4.40681726e-02f, -5.82126260e-04f, -1.90472957e-02f, 3.45611013e-02f, -1.89315572e-01f, -1.12919457e-01f,
  -3.50520819e-01f, 2.13690206e-01f, -4.66930009e-02f, -9.38357636e-02f, -3.82122733e-02f, -1.65654302e-01f, -8.54922384e-02f, -1.35790408e-01f, -9.04620364e-02f, -3.23593318e-02f,
  -2.55789198e-02f, -1.16438940e-01f, 1.16606774e-02f, -1.31222710e-01f, 1.20373577e-01f, -1.84237026e-02f, -8.94286707e-02f, -8.58076438e-02f, -8.78529400e-02f, -7.24397898e-02f,
  -1.56731009e-01f, 4.10344899e-02f, 7.96756148e-02f, 2.17399057e-02f, 2.32277010e-02f, -4.08143401e-02f, 6.13283254e-02f, -7.16220364e-02f, -1.48764312e-01f, -3.81905697e-02f,
  -1.66390315e-02f, -3.35833095e-02f, 3.64061631e-02f, 6.02569841e-02f, 6.21667132e-02f, 2.43751835e-02f, 6.12447876e-03f, -9.50426236e-02f, 3.45432647e-02f, 1.26918242e-03f,
  -4.49499749e-02f, -8.74643624e-02f, -4.64822873e-02f, -5.80037199e-02f, -8.70082229e-02f, 8.07832330e-02f, 7.26098474e-03f, 1.65123791e-02f, -1.16090678e-01f, 7.73347616e-02f,
  6.73303828e-02f, -2.07118969e-02f, 9.89165064e-03f, 2.28664614e-02f, -9.27199144e-03f, 4.13547456e-02f, -6.45943359e-02f, -3.22922096e-02f, 1.74113195e-02f, 1.33323863e-01f,
  -3.24335873e-01f, -1.09540924e-01f, -4.58987691e-02f, -6.53513893e-02f, 6.83301315e-02f, -1.63411111e-01f, -1.24467425e-02f, -7.95443431e-02f, -3.70258503e-02f, -3.95936891e-02f,
  -1.03993444e-02f, -4.92608882e-02f, -1.55850016e-02f, 2.13600546e-02f, 1.35319203e-01f, 3.10502071e-02f, -1.27850279e-01f, 9.26749557e-02f, 1.29402603e-03f, -5.53345382e-02f,
  -2.55656056e-03f, 1.83259711e-01f, 2.63785511e-01f, 1.25003234e-02f, 1.81265865e-02f, 9.20606628e-02f, 7.60769099e-02f, 9.40962955e-02f, 7.00026229e-02f, 9.33817849e-02f,
  -6.85174048e-01f, -2.25280613e-01f, -1.99590847e-02f, -3.87054950e-01f, -5.60608543e-02f, 3.64202703e-03f, -2.31762230e-01f, 1.41988043e-02f, -4.40775082e-02f, -2.40430310e-01f,
  -1.77060843e-01f, -6.32899553e-02f, -2.20037133e-01f, -3.84838469e-02f, -9.44115072e-02f, -3.98692101e-01f, -3.07634950e-01f, -2.94627756e-01f, 3.24113071e-02f, -3.65834422e-02f,
  -1.85227185e-01f, -3.73005539e-01f, -2.11246446e-01f, 5.90145439e-02f, -3.18795778e-02f, -5.50026968e-02f, -1.39435366e-01f, -1.85584724e-01f, 4.88879718e-02f, -3.38189363e-01f,
  -1.70876145e-01f, 1.11554258e-01f, 6.14472367e-02f, -9.69681665e-02f, -2.18468811e-02f, 5.69222355e-03f, -9.04267207e-02f, 1.00966413e-02f, 1.03122406e-01f, 1.81893632e-02f,
  2.70789769e-02f, -4.97540347e-02f, -5.57339974e-02f, 1.10980077e-02f, -1.22533798e-01f, 2.50918437e-02f, 1.82235930e-02f, -2.00965255e-02f, 6.35058805e-02f, 4.45576459e-02f,
  -2.72285212e-02f, -3.28556076e-02f, 4.00008308e-03f, 1.45944923e-01f, 1.94964960e-01f, 3.03164800e-03f, 1.43759713e-01f, 2.82186508e-01f, 2.23994404e-01f, -4.19453308e-02f,
  -5.11251949e-03f, 1.52431866e-02f, 4.27310243e-02f, -2.62877755e-02f, -7.47453049e-02f, 6.79375380e-02f, -7.97994286e-02f, -3.43194939e-02f, -5.87123893e-02f, -4.14288826e-02f,
  3.12013812e-02f, 2.73105851e-03f, -2.01982558e-02f, -8.55650902e-02f, -1.85823324e-03f, -2.99738608e-02f, -1.27244759e-02f, -4.05351259e-02f, 2.42169923e-03f, -5.13368137e-02f,
  6.01639040e-02f, 4.31327596e-02f, 1.39816268e-03f, 9.33400095e-02f, -1.60118565e-02f, -1.61847360e-02f, -3.13447379e-02f, 1.61218390e-01f, 4.51909713e-02f, 3.49298902e-02f,
  -1.89013153e-01f, 9.28110108e-02f, -1.35906368e-01f, 4.32198271e-02f, -2.74437144e-02f, 2.57713553e-02f, -3.45831327e-02f, 9.46770534e-02f, 4.40310016e-02f, -1.41791170e-02f,
  9.43491459e-02f, -6.49863556e-02f, -6.05955496e-02f, 1.11745976e-01f, -2.09034514e-02f, -1.05934264e-02f, -5.59240095e-02f, -6.82472289e-02f, 9.94227380e-02f, 8.48841816e-02f,
  4.51474562e-02f, -7.03572258e-02f, -2.58605659e-01f, -7.17554847e-03f, 2.45758686e-02f, -1.06440559e-01f, -8.46836269e-02f, -2.13859621e-02f, -4.20149341e-02f, -3.25165182e-01f,
  -2.05413893e-01f, 1.72942076e-02f, 1.72939226e-01f, -4.78962511e-02f, -1.01229176e-02f, 4.53993455e-02f, 1.70143604e-01f, 5.04104458e-02f, -6.45872280e-02f, 2.80555002e-02f,
  1.42740400e-03f, -1.31830350e-01f, 1.22559918e-02f, -4.83287908e-02f, -3.07946783e-02f, 9.62654352e-02f, 9.39971581e-02f, -2.03775764e-02f, -5.40102758e-02f, -5.16069867e-02f,
  4.04316634e-02f, -3.51658911e-02f, -5.37368879e-02f, -6.60166293e-02f, 4.97532114e-02f, 3.70389409e-02f, -1.64843388e-02f, 2.81518344e-02f, -5.98864071e-02f, -9.17697623e-02f,
  1.47235557e-01f, -1.08135782e-01f, -1.14777155e-01f, -1.55163407e-01f, -4.71375883e-02f, -5.26839271e-02f, 6.76048622e-02f, -4.73857187e-02f, 5.72282635e-02f, 3.88450734e-02f,
  -4.39862488e-03f, 7.58005083e-02f, -5.38167506e-02f, 5.72575144e-02f, -5.74291125e-02f, -7.45215714e-02f, -3.46247070e-02f, -6.68034405e-02f, 4.46546227e-02f, -1.92140155e-02f,
  -9.37927365e-02f, 1.88392978e-02f, -5.21454625e-02f, -4.54521738e-02f, -5.30004911e-02f, 2.66761631e-02f, -2.31255405e-02f, -7.57544534e-03f, -2.18251441e-03f, 4.53594439e-02f,
  -5.22993691e-02f, -2.56205015e-02f, -7.81801119e-02f, -7.20442161e-02f, 1.44859711e-02f, 7.75715262e-02f, -6.15182426e-03f, -2.37971474e-03f, 5.83633743e-02f, 7.17425421e-02f,
  2.87669152e-02f, 1.39766067e-01f, 8.33583847e-02f, 1.34911001e-01f, -4.69273888e-02f, -1.04842279e-02f, 6.13640584e-02f, -6.90180212e-02f, 2.61244737e-02f, 8.29204693e-02f,
  6.45108595e-02f, 3.60424034e-02f, -1.57134153e-03f, 1.16419539e-01f, 4.61359732e-02f, -1.07797915e-02f, 8.37819278e-02f, 7.47186840e-02f, -8.67264643e-02f, -5.84794730e-02f,
  2.39687264e-01f, -4.74171266e-02f, 9.43869427e-02f, -2.27635801e-02f, -1.43429711e-02f, 2.85036080e-02f, 1.59194916e-02f, 3.74654643e-02f, 8.48612115e-02f, -2.21670140e-02f,
  6.06314130e-02f, -5.25769666e-02f, 5.34347892e-02f, 6.96079805e-02f, -2.00867131e-02f, 2.89616603e-02f, 9.12581235e-02f, -8.30773823e-03f, -5.01011498e-02f, -6.36473969e-02f,
  -1.82433065e-03f, -9.62347258e-03f, 4.85634394e-02f, 5.09497039e-02f, 8.93502980e-02f, 5.69733009e-02f, 1.03386827e-01f, 1.54794186e-01f, 1.08116642e-01f, 1.31564826e-01f,
  4.55602050e-01f, -4.75267589e-01f, -4.13373142e-01f, 1.57566756e-01f, -2.05431566e-01f, -1.28797740e-01f, -4.11950171e-01f, 1.65349320e-01f, 1.03668712e-01f, -3.24528039e-01f,
  -1.14117801e-01f, 3.52184087e-01f, 2.81171322e-01f, 2.35527545e-01f, 2.56822944e-01f, -2.89207608e-01f, -3.86504978e-01f, 2.61821955e-01f, 4.30948973e-01f, 1.15215197e-01f,
  -6.23684339e-02f, -7.51433223e-02f, 3.06197196e-01f, 1.46467924e-01f, -4.09784079e-01f, -2.99491752e-02f, -3.96282732e-01f, -1.14827186e-01f, -1.72423244e-01f, -4.82933998e-01f,
  -2.75539488e-01f, -1.01313554e-01f, 1.04428716e-01f, 5.04705235e-02f, -2.42153317e-01f, -8.60023778e-03f, -6.92134574e-02f, -4.99894358e-02f, -7.86213055e-02f, -1.76732056e-02f,
  -7.72151724e-02f, 4.24733274e-02f, 1.34576606e-02f, -7.64816403e-02f, -6.99971616e-02f, -3.11885774e-02f, -1.14108250e-02f, 2.88200546e-02f, -1.37182623e-02f, -1.50712654e-01f,
  -1.91413999e-01f, -1.32554010e-01f, 8.04453641e-02f, -1.12777598e-01f, 2.48590801e-02f, 8.07828158e-02f, -6.93864077e-02f, -3.10867708e-02f, 1.72574408e-02f, -2.45435461e-01f,
  -1.92590132e-02f, -3.24801989e-02f, 1.46986786e-02f, 3.20957936e-02f, 3.59731726e-02f, 2.36088019e-02f, -7.42166713e-02f, -1.62064179e-03f, 1.05375648e-01f, -6.42021522e-02f,
  8.83615166e-02f, -4.56065089e-02f, 7.97464419e-03f, -9.88251623e-03f, -5.57970814e-02f, -8.98038745e-02f, 4.10476401e-02f, -4.49561588e-02f, 2.06015948e-02f, 6.03295639e-02f,
  1.91024896e-02f, 5.57044148e-03f, -1.09412111e-01f, 6.00944087e-02f, -1.08545147e-01f, 6.16257004e-02f, -9.51777771e-03f, 8.31212774e-02f, 1.83403566e-02f, -6.52099475e-02f,
  1.69190049e-01f, 1.37466192e-01f, -4.12744097e-02f, 1.26093030e-01f, 2.31393352e-02f, 1.66385807e-02f, 2.62743421e-02f, -8.29744525e-03f, -3.71912983e-03f, -2.83849705e-02f,
  1.23195956e-02f, 4.63802814e-02f, -2.68056802e-02f, 2.40217242e-02f, 4.57220487e-02f, 6.28004223e-02f, -5.00783287e-02f, 1.42233565e-01f, 3.53836827e-02f, 1.95402056e-02f,
  2.07235776e-02f, 9.25207138e-02f, 2.49838978e-01f, 5.75052090e-02f, 5.47533529e-03f, 1.80233747e-01f, -8.02376866e-02f, -6.19746298e-02f, 1.84046999e-01f, -6.50672242e-02f,
  -2.76034832e-01f, 1.08458154e-01f, -2.21351579e-01f, 1.56377822e-01f, 9.01454464e-02f, -4.81052399e-02f, -1.12774372e-01f, -2.40205586e-01f, -5.43081388e-02f, 6.45965412e-02f,
  -1.37233632e-02f, 1.82100400e-01f, 6.70036674e-03f, 1.50679536e-02f, -1.71984106e-01f, 3.42992730e-02f, 1.68674797e-01f, -5.09550422e-02f, -2.88702726e-01f, -3.45433056e-02f,
  1.69500023e-01f, 3.52145508e-02f, -2.11289614e-01f, -6.57764450e-02f, 2.28719726e-01f, 1.48364723e-01f, -1.10070497e-01f, 1.06475670e-02f, 5.91804013e-02f, 5.05424261e-01f,
  1.03307217e-01f, -1.16321787e-01f, -1.25552580e-01f, -2.39715204e-02f, 5.13924956e-02f, 6.55120835e-02f, 2.07651015e-02f, -8.65297094e-02f, -8.97286013e-02f, 7.99381956e-02f,
  3.90732661e-02f, 1.82390753e-02f, 1.63070589e-01f, 6.80901557e-02f, -1.65403813e-01f, -6.73753545e-02f, -6.79409727e-02f, -1.54315054e-01f, -2.16024116e-01f, -2.71658618e-02f,
  2.63567895e-01f, 4.84305173e-02f, -2.12763116e-01f, -1.17501266e-01f, -5.72926551e-02f, -4.35184948e-02f, -1.19641036e-01f, -6.30750001e-05f, -2.66230553e-01f, 5.10458872e-02f,
  -5.21893427e-02f, 1.23597113e-02f, 1.50309252e-02f, -1.38367228e-02f, -3.15087587e-02f, 7.29999319e-02f, 4.18400653e-02f, 2.21188646e-03f, 1.13761434e-02f, 1.71414837e-02f,
  3.77200432e-02f, -5.46261072e-02f, 1.50708659e-02f, -8.81788731e-02f, 1.83668900e-02f, 1.59464043e-03f, 2.34115981e-02f, -3.63029316e-02f, -7.07214624e-02f, -3.65467668e-02f,
  4.27589240e-03f, -4.43123057e-02f, -8.13651010e-02f, 2.84528825e-02f, -2.49361228e-02f, 4.38925736e-02f, 1.27348881e-02f, -1.52952239e-01f, -3.11963703e-03f, 1.45684206e-03f,
  -1.80592671e-01f, -3.00119430e-01f, 1.10795245e-01f, -2.22853534e-02f, 2.20262129e-02f, -5.80301918e-02f, 6.20063134e-02f, 1.68405119e-02f, -2.78446376e-02f, -4.35403064e-02f,
  -9.43875611e-02f, 3.88131756e-03f, -6.13545775e-02f, -2.09281705e-02f, -7.04620034e-02f, -3.42585556e-02f, -1.83249600e-02f, 5.24464883e-02f, -1.22825034e-01f, -2.39589764e-03f,
  -6.24271668e-02f, -9.39118788e-02f, -7.88433850e-02f, -1.68536156e-01f, -6.28280640e-02f, -2.09337100e-01f, -1.48245767e-01f, -1.00716598e-01f, -3.11115175e-01f, -2.26557821e-01f,
  -2.22614959e-01f, 1.72205940e-01f, -1.41920328e-01f, -2.63198644e-01f, -2.86584496e-01f, -2.95634747e-01f, 1.24558032e-01f, 4.68915701e-02f, -1.51723996e-01f, 5.18722907e-02f,
  1.23390267e-02f, -1.31626025e-01f, -1.48008928e-01f, -9.49700177e-02f, -1.39480829e-01f, 1.70273989e-01f, -3.62835005e-02f, -2.56613374e-01f, -2.95372158e-01f, -3.08750212e-01f,
  -1.74678996e-01f, -2.21236333e-01f, -2.40657762e-01f, -2.29195222e-01f, -1.52829111e-01f, -1.67780131e-01f, 2.58330293e-02f, -1.69407070e-01f, -1.01166993e-01f, -1.78765580e-01f,
  2.40785982e-02f, -2.45960280e-01f, -4.89793755e-02f, 6.47656806e-03f, 2.14464683e-03f, -3.71510051e-02f, -1.78190619e-02f, 8.17325804e-03f, -1.87657531e-02f, 3.53332460e-02f,
  -1.69462025e-01f, -2.43620966e-02f, -1.25461027e-01f, -1.72665179e-01f, -1.48386985e-01f, -1.33458823e-01f, 7.67856911e-02f, -1.90401182e-01f, -2.02759895e-02f, 5.18493392e-02f,
  -5.87882213e-02f, -2.80093610e-01f, -1.46268606e-01f, -1.19055733e-02f, -2.03402355e-01f, -1.57841042e-01f, -8.94140303e-02f, -2.09373087e-01f, -9.87425819e-02f, 1.18847176e-01f,
  8.05042535e-02f, -3.71618010e-03f, 5.35795875e-02f, 7.47842854e-03f, 7.48012438e-02f, -3.29752192e-02f, 5.14718182e-02f, 5.43341897e-02f, 1.90759394e-02f, -5.57291023e-02f,
  2.90138158e-03f, 3.49951386e-02f, 1.82219259e-02f, -6.30638003e-02f, 5.39024211e-02f, -1.56251743e-01f, 2.15882286e-02f, 1.59131080e-01f, -3.19780409e-02f, -2.27217656e-02f,
  -5.04883230e-02f, 5.00846580e-02f, -2.58209556e-02f, 9.74790454e-02f, -1.61392361e-01f, -2.66269483e-02f, -3.54029424e-02f, 1.51396533e-02f, 5.09823337e-02f, 1.68839730e-02f,
  4.59148616e-01f, -2.36610338e-01f, 1.65252492e-01f, 1.35883540e-01f, -3.71982530e-02f, 6.49723560e-02f, 3.28357588e-03f, 2.59465352e-02f, -2.21409239e-02f, -2.20033526e-02f,
  -1.09934375e-01f, -6.02543429e-02f, 3.57075455e-03f, 4.64829244e-02f, -3.30137834e-02f, -2.53242012e-02f, 1.28373623e-01f, 8.56714472e-02f, -2.29196623e-02f, 7.79642686e-02f,
  9.93446633e-02f, 1.72441527e-01f, 1.37080073e-01f, 1.88069344e-01f, -3.91741209e-02f, 6.87745064e-02f, 1.79134250e-01f, 9.24086422e-02f, 1.10336892e-01f, 5.79062819e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.60192356e-01f, -1.53001621e-01f, 1.28922507e-01f, 2.68456876e-01f, -2.13342786e-01f, 2.61046261e-01f, 2.79213265e-02f, -6.90999404e-02f, 3.94487143e-01f, 2.41513759e-01f,
  7.59205669e-02f, 2.55216658e-01f, 9.97021869e-02f, 6.91249192e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  5.01158237e-01f, -1.09300017e+00f, 4.64722812e-01f, -5.39466441e-02f, -1.16489090e-01f, -4.24021363e-01f, 3.20071355e-02f, 2.14819871e-02f, 6.59622252e-02f, -3.28836709e-01f,
  -3.53489548e-01f, -5.97170182e-02f, 9.72710643e-03f, -3.85276526e-01f, 1.80782333e-01f, -6.51372150e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.39514983e-01f, 3.02032799e-01f, -3.31025004e-01f, -2.12347627e-01f, -1.69244649e-05f, -1.53312748e-02f, -9.14815720e-03f, 4.02747095e-02f, -3.30289543e-01f, -1.09282620e-01f,
  6.89850152e-01f, -3.43398333e-01f, 2.33157381e-01f, 2.17530638e-01f, -2.18149021e-01f, 6.16791546e-01f, 9.12002027e-01f, -7.75301635e-01f, 1.99462220e-01f, -3.79046977e-01f,
  -2.57497966e-01f, -2.31801808e-01f, -2.64649838e-01f, -1.92934170e-01f, 4.27908093e-01f, 4.32759151e-02f, -3.28354716e-01f, 1.02162257e-01f, -1.92644566e-01f, 9.47427511e-01f,
  3.36152432e-03f, 1.37425721e-01f, -2.48615935e-01f, 9.97719020e-02f, -1.30812570e-01f, 2.41767004e-01f, -1.23384416e-01f, 8.64284039e-02f, -2.00614572e-01f, 8.14852025e-03f,
  -1.68268189e-01f, -2.71570534e-01f, 2.61813641e-01f, -2.48135731e-01f, 9.00438130e-02f, -8.69778451e-03f, 4.93355207e-02f, 7.88846910e-02f, 4.25191134e-01f, 7.61980593e-01f,
  -3.22371840e-01f, -2.59021044e-01f, 1.69792607e-01f, -9.96137442e-06f, -2.92047501e-01f, -9.91579145e-02f, -2.50822037e-01f, -2.92944312e-01f, 5.29783070e-01f, -2.46087223e-01f,
  3.65517467e-01f, -3.35198492e-01f, -1.77531496e-01f, 4.62193221e-01f, 6.35372639e-01f, 3.06297094e-01f, 1.94648176e-01f, -1.67917594e-01f, -1.25518829e-01f, 1.29688054e-01f,
  1.76525209e-02f, 3.48203033e-01f, -5.15170880e-02f, -1.08823553e-01f, -2.00536951e-01f, 6.73105597e-01f, 1.03260837e-02f, 9.50077176e-01f, -2.80726582e-01f, 4.30413932e-01f,
  2.43682206e-01f, -2.57037045e-03f, 8.63551721e-03f, 2.74975955e-01f, -9.62831080e-02f, 3.18139851e-01f, 1.17874190e-01f, 8.02701637e-02f, 2.39609316e-01f, -2.58056700e-01f,
  3.53821248e-01f, -4.64874618e-02f, -1.48049116e-01f, 3.00257593e-01f, 1.40760720e-01f, -7.28058144e-02f, -5.25497161e-02f, 5.15430927e-01f, -8.72440636e-02f, -1.41485929e-01f,
  -2.72664487e-01f, -1.30415171e-01f, -1.52808011e-01f, 1.00436464e-01f, -1.37620762e-01f, 2.96048284e-01f, -1.16527610e-01f, 1.00529933e+00f, -7.95714110e-02f, 3.30738515e-01f,
  4.38273624e-02f, 7.27507696e-02f, -2.59193212e-01f, 6.93726540e-01f, 1.20050304e-01f, -1.59469351e-01f, -1.53266013e-01f, 5.61549544e-01f, 3.44358496e-02f, 1.21088371e-01f,
  -1.38325959e-01f, 3.43746573e-01f, 7.22571790e-01f, 1.10067204e-01f, -1.61568392e-02f, 9.13903490e-02f, 5.06131500e-02f, -3.26259956e-02f, -1.12319559e-01f, -5.01292527e-01f,
  1.14011675e-01f, -2.11588055e-01f, 9.13238078e-02f, 4.51758988e-02f, -2.48400554e-01f, 6.22975171e-01f, 2.82806018e-03f, -1.51430145e-01f, 1.12993784e-01f, -1.96368307e-01f,
  -8.12123995e-03f, -2.21716270e-01f, 4.18022322e-03f, -2.58267015e-01f, 5.69368541e-01f, -5.87613463e-01f, -3.31891149e-01f, 5.69612496e-02f, 2.87837386e-01f, 3.10678780e-01f,
  -5.06078005e-01f, 1.02202320e+00f, -5.28125346e-01f, -3.03335369e-01f, 5.08263886e-01f, -1.73897773e-01f, 3.65233943e-02f, 5.44558093e-02f, -4.04347271e-01f, 7.85152435e-01f,
  2.54974868e-02f, -2.85616308e-01f, 4.37975079e-01f, -2.61853904e-01f, 5.05514205e-01f, 3.59350294e-01f, 2.53015701e-02f, 2.09474221e-01f, 5.53233385e-01f, -2.77260631e-01f,
  4.42356080e-01f, -4.11425292e-01f, -1.70736581e-01f, -3.88350010e-01f, 9.93296564e-01f, -1.35034233e-01f, 5.22940233e-02f, 6.48848712e-01f, -3.24704587e-01f, -6.67903200e-02f,
  -2.56239384e-01f, 9.95655730e-02f, -5.85242733e-02f, -1.66990906e-01f, -2.78196067e-01f, 3.00409019e-01f, -1.85550135e-02f, 2.00441316e-01f, 4.00258340e-02f, 1.10635765e-01f,
  -1.29190221e-01f, 2.90229678e-01f, -4.70305197e-02f, 7.15738952e-01f, -6.05059639e-02f, -6.95354640e-02f, -8.80739465e-02f, -7.48862997e-02f, -1.78724632e-01f, 2.54789945e-02f,
  -1.91345036e-01f, 4.46163088e-01f, -2.47141749e-01f, 5.13310432e-01f, 3.37122083e-01f, -8.22183073e-01f, 3.28500867e-01f, 7.78064787e-01f, -1.28812969e-01f, 3.24519068e-01f,
  1.74181461e-01f, -2.35327184e-02f, -1.37733519e-01f, 3.13771009e-01f, 6.96129501e-02f, -4.56087030e-02f, 3.65606308e-01f, -1.88679844e-01f, 6.92870393e-02f, -1.35015741e-01f,
  1.77484199e-01f, -4.68050875e-02f, 3.62288445e-01f, -2.93797910e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.84199053e-01f, 7.57681370e-01f, -1.54133299e-02f, 4.31817055e-01f, 6.87485516e-01f, -1.66036949e-01f, 5.16225219e-01f, -8.88478532e-02f, 7.67214075e-02f, 8.16661477e-01f,
  4.44899976e-01f, 4.58408326e-01f, 4.28840250e-01f, 1.09853126e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  2.85488218e-01f, 2.81536460e-01f, 2.96190172e-01f, -2.03578413e-01f, 2.10197464e-01f, 3.33452910e-01f, -5.06028126e-04f, -3.01054001e-01f, -2.60872424e-01f, -2.95264482e-01f,
  3.60167384e-01f, 4.19412643e-01f, -1.54912487e-01f, -7.71472454e-02f, -9.52167064e-02f, -1.66282415e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -1.98878512e-01f, 4.37933803e-02f, -1.34687200e-01f, 6.19719625e-01f, -5.57685755e-02f, 2.06920788e-01f, 6.76298678e-01f, -8.54666755e-02f, 3.70438844e-01f, 5.89298736e-03f,
  9.81671736e-02f, -4.23519224e-01f, -7.07699880e-02f, 2.21653692e-02f, -1.33509815e-01f, -9.59572420e-02f, 2.59243280e-01f, -8.31519127e-01f, -2.32589513e-01f, -3.16854686e-01f,
  -3.40588152e-01f, 3.09296395e-03f, 5.42546630e-01f, -4.06890184e-01f, 7.13934243e-01f, 9.73569877e-06f, -2.21753657e-01f, -3.04925650e-01f, -3.71782899e-01f, 6.06314898e-01f,
  7.23116875e-01f, 4.53947932e-02f, -3.03914368e-01f, -5.57181835e-01f, 6.31015122e-01f, -5.37148416e-02f, 1.30956277e-01f, 5.76719642e-01f, -1.30779937e-01f, -3.50000352e-01f,
  -1.03672400e-01f, 1.58173107e-02f, -8.03301111e-02f, 2.09899008e-01f, 2.37786829e-01f, 2.52643645e-01f, 3.15758526e-01f, -2.15571418e-01f, -3.07891518e-01f, -7.46686399e-01f,
  2.31522083e-01f, 3.18798900e-01f, 1.04899652e-01f, -1.63448647e-01f, 6.27066731e-01f, 3.64040643e-01f, 2.94096351e-01f, 6.58951223e-01f, -3.29546958e-01f, -1.43956870e-01f,
  2.24863485e-01f, 4.20123965e-01f, -5.72640479e-01f, 3.69739592e-01f, -2.93942422e-01f, 1.05897486e+00f, -3.73504043e-01f, 2.80418217e-01f, -2.29035243e-01f, -4.79376167e-01f,
  4.40030210e-02f, 7.83938393e-02f, -2.49425426e-01f, -5.53209543e-01f, 2.87980497e-01f, -3.11950207e-01f, 1.15978301e+00f, -2.84434855e-01f, -3.65376830e-01f, 1.47241384e-01f,
  -3.61028314e-01f, 3.70521061e-02f, -7.18574002e-02f, 3.24111909e-01f, -2.35299110e-01f, -2.00886607e-01f, 3.98986608e-01f, -1.89296916e-01f, 4.62185293e-01f, -6.05922565e-02f,
  2.23785229e-02f, -3.32282275e-01f, -5.04556112e-02f, 4.31404971e-02f, -1.92204461e-01f, -1.69623315e-01f, -5.97483071e-04f, -4.70964983e-03f, -9.29592997e-02f, 4.95748699e-01f,
  -3.00309896e-01f, -3.89429450e-01f, 5.61533809e-01f, -2.32729539e-01f, 8.35701704e-01f, -1.24469697e-02f, 1.21773645e-01f, -5.07612586e-01f, 2.49465108e-02f, 1.70026928e-01f,
  3.81753258e-02f, -4.42604683e-02f, 6.89106703e-01f, 1.01172876e+00f, -8.21201280e-02f, 1.07439280e+00f, -2.06504375e-01f, -5.71208656e-01f, 6.12861216e-01f, 1.89486772e-01f,
  5.53266928e-02f, -4.47252274e-01f, 8.33550915e-02f, 8.90606225e-01f, 8.70836601e-02f, -3.37530941e-01f, -3.39045435e-01f, -2.27507696e-01f, 3.30734342e-01f, -5.91933072e-01f,
  5.25227726e-01f, -1.51840448e-01f, 7.66384825e-02f, 1.76418617e-01f, 3.82238716e-01f, 2.52240568e-01f, 1.67714790e-01f, 5.11442065e-01f, 3.35899889e-01f, 8.74316096e-01f,
  4.78873640e-01f, -4.60657813e-02f, -5.33652246e-01f, 7.95763358e-02f, 5.94657302e-01f, -7.14642048e-01f, 6.53458357e-01f, -1.34474725e-01f, -7.99288750e-02f, 8.13276827e-01f,
  2.23047301e-01f, -3.52702141e-01f, 2.99338520e-01f, -8.08127690e-03f, -4.21480209e-01f, 5.18280268e-01f, -2.70413637e-01f, 4.49970573e-01f, 9.72631633e-01f, -2.02605113e-01f,
  4.59759474e-01f, 9.47513059e-02f, 1.76107928e-01f, 6.62630439e-01f, -1.77920535e-01f, 1.88644364e-01f, 2.34998643e-01f, -8.39101896e-02f, -2.02530548e-01f, -2.75455505e-01f,
  -1.41338691e-01f, 6.20550394e-01f, -2.66011804e-01f, 1.36653498e-01f, -4.06097829e-01f, -6.73369616e-02f, -8.04274343e-03f, 2.95719177e-01f, -9.05776545e-02f, 2.42457002e-01f,
  -3.99884015e-01f, 1.63489599e-02f, -3.01770985e-01f, 1.41231328e-01f, -2.20615238e-01f, -8.46812725e-02f, -1.99400648e-01f, -4.12535459e-01f, 8.54748905e-01f, -1.34469375e-01f,
  -1.10724129e-01f, 3.77511024e-01f, 6.56667352e-02f, 3.83643001e-01f, -2.07487941e-01f, -4.05644476e-01f, -1.36623740e-01f, -3.39086145e-01f, -9.40903053e-02f, -8.75380337e-02f,
  -2.65064090e-03f, 8.49260762e-02f, 4.03297752e-01f, 6.69418752e-01f, 3.72124135e-01f, 4.81967963e-02f, 2.38177672e-01f, 3.52340154e-02f, -1.53129756e-01f, 1.71396419e-01f,
  -2.71429447e-03f, 6.09068811e-01f, 1.56947628e-01f, 8.76028761e-02f, 2.46304035e-01f, -1.54194489e-01f, 9.40200165e-02f, -3.65808815e-01f, -2.36066148e-01f, 1.41075552e-01f,
  -1.81877717e-01f, 3.03958148e-01f, -1.06751285e-01f, 9.97055508e-03f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.83342636e-01f, 2.28358865e-01f, 2.08744705e-01f, -1.61897212e-01f, 5.71173072e-01f, 1.46964386e-01f, 5.35206534e-02f, 8.54570150e-01f, -1.68229312e-01f, 4.47938144e-01f,
  3.16481739e-01f, 9.88735929e-02f, 3.01939696e-01f, 1.37424871e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -2.67137378e-01f, -3.52204323e-01f, 6.71191454e-01f, 5.19724190e-01f, 1.55416831e-01f, 7.50842929e-01f, -2.78034508e-01f, 5.89398384e-01f, 6.88536406e-01f, -2.43166238e-01f,
  2.39129946e-01f, -4.68318850e-01f, -1.97730690e-01f, -1.46526009e-01f, -3.39656234e-01f, 2.00588360e-01f, 1.94595158e-01f, 1.79674506e-01f, 2.22740531e-01f, -1.22327700e-01f,
  -5.83842576e-01f, 9.11651134e-01f, -4.09953207e-01f, 2.44071692e-01f, 1.17471024e-01f, 5.15184939e-01f, 3.84366870e-01f, -4.69954282e-01f, 5.24441898e-01f, -7.74230510e-02f,
  -9.87835079e-02f, 4.00936484e-01f, 5.62335789e-01f, -5.55815578e-01f, 5.82545161e-01f, -5.39994895e-01f, -3.63456786e-01f, -2.15901792e-01f, 2.03235939e-01f, 3.85931194e-01f,
  4.79697078e-01f, 9.48589921e-01f, -7.18652189e-01f, -8.08054388e-01f, 3.73637050e-01f, -2.88412329e-02f, -7.55046532e-02f, 2.76977807e-01f, -1.70304790e-01f, -4.93454903e-01f,
  7.60444859e-03f, 1.02158797e+00f, 2.07326978e-01f, 3.61110866e-01f, -2.25923821e-01f, 2.19623029e-01f, 4.62742388e-01f, -1.06693101e+00f, -4.40356761e-01f, 3.84150416e-01f,
  -6.25747442e-01f, 6.51159286e-02f, -1.95117965e-01f, 8.65137903e-04f, 1.01236418e-01f, -4.45802540e-01f, 9.06304643e-02f, 7.25858271e-01f, -3.31376016e-01f, -3.26439321e-01f,
  -1.21110760e-01f, -2.37796512e-02f, 4.40722436e-01f, 5.03876030e-01f, -4.71511275e-01f, 3.59452605e-01f, -1.93222329e-01f, -2.83388555e-01f, 2.45775655e-01f, -1.75182316e-02f,
  -2.52586573e-01f, 4.24507052e-01f, -1.84563145e-01f, -4.96919677e-02f, -1.38166666e-01f, 1.64322823e-01f, -1.73682779e-01f, -3.03071558e-01f, -3.07343274e-01f, 6.73803389e-01f,
  1.11766942e-01f, 4.60299313e-01f, 4.82665598e-01f, -8.23838357e-03f, -3.30940008e-01f, 3.13929677e-01f, 1.73057914e-01f, 5.26502073e-01f, -3.91984284e-01f, -3.07389170e-01f,
  -3.28560144e-01f, -5.23928225e-01f, 7.34867275e-01f, -3.47774811e-02f, -5.04670680e-01f, 4.91351455e-01f, -4.84168231e-02f, -8.11538577e-01f, -2.60087937e-01f, -2.96148211e-01f,
  8.34198833e-01f, -4.42160726e-01f, -3.32924664e-01f, -7.24175036e-01f, -2.83622116e-01f, -2.77028859e-01f, 6.61699772e-02f, 1.88088790e-01f, 6.73564136e-01f, 7.52901584e-02f,
  -2.32377321e-01f, -9.33663309e-01f, 1.96351483e-01f, -3.85759115e-01f, -3.45355242e-01f, 8.53285968e-01f, 1.98024765e-01f, 2.83100288e-02f, -1.35894611e-01f, 5.56774795e-01f,
  -3.76108170e-01f, -3.82893801e-01f, 6.33330226e-01f, 4.41627473e-01f, -5.69913924e-01f, -3.76387626e-01f, -4.20206249e-01f, -7.48961806e-01f, 3.58195603e-01f, 5.80906272e-01f,
  2.72558592e-02f, -2.57392466e-01f, -2.20699042e-01f, -3.19410205e-01f, 6.01524293e-01f, -3.97378027e-01f, -7.60219917e-02f, -5.44674277e-01f, 1.10347800e-01f, -4.62625951e-01f,
  1.31367612e+00f, 1.42553940e-01f, -1.24306595e-02f, 1.68405160e-01f, -8.01360428e-01f, -5.82663894e-01f, -3.15272398e-02f, 7.14301884e-01f, -1.75993413e-01f, 4.92034592e-02f,
  -4.37895916e-02f, 6.38574243e-01f, 1.44272491e-01f, 4.89513725e-01f, 5.45889199e-01f, -1.72916487e-01f, -2.94907540e-01f, -1.43159464e-01f, -4.42263067e-01f, -6.24671876e-01f,
  -3.72975737e-01f, 9.24236417e-01f, -7.25296214e-02f, -2.57585436e-01f, -1.05464891e-01f, -6.18250184e-02f, -4.66586441e-01f, 6.25254452e-01f, -5.45735136e-02f, -3.97701651e-01f,
  1.71975836e-01f, -6.84541285e-01f, -5.79339683e-01f, -2.00278789e-01f, -4.54201221e-01f, 2.42149562e-01f, 6.62166774e-01f, -1.32005766e-01f, 4.86399651e-01f, -2.44098887e-01f,
  4.14008558e-01f, -2.33537048e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -5.18534899e-01f, -7.59614483e-02f, 1.66869491e-01f, -2.34347776e-01f, 1.19308732e-01f, 2.65109956e-01f, 3.20723712e-01f, -1.09383993e-01f, 3.08777213e-01f, 3.65843683e-01f,
  -7.42748529e-02f, 3.82675260e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    