/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.13542545e-01f, 1.42601117e-01f, -1.38050839e-02f, 8.35658610e-02f, -7.93050453e-02f, -1.05037026e-01f, -8.24747607e-02f, -9.35581848e-02f, 3.29429917e-02f, 1.46508664e-01f,
  4.85703163e-02f, 4.35196273e-02f, 1.04897574e-01f, -5.84284030e-02f, -1.39979914e-01f, -9.92685482e-02f, -5.37098087e-02f, -1.31955266e-01f, -1.80150777e-01f, -7.38551766e-02f,
  -6.05728216e-02f, 2.02785973e-02f, 1.28698125e-01f, 6.95762709e-02f, -6.75200298e-02f, -8.91987905e-02f, 3.95766459e-02f, -6.71959668e-02f, 3.71812508e-02f, -3.46638784e-02f,
  2.24407047e-01f, 2.83905305e-02f, -5.64806648e-02f, -6.02604300e-02f, 1.00919269e-02f, 4.31332365e-02f, -3.36051434e-02f, 5.77755384e-02f, 9.37161967e-02f, -2.81810965e-02f,
  -1.55150481e-02f, -2.22557299e-02f, -8.81683826e-03f, -1.25780078e-02f, 6.04245253e-02f, 1.05286194e-02f, -2.21194904e-02f, -6.32165885e-03f, -7.43564276e-04f, 2.83961501e-02f,
  3.71210161e-03f, 4.29571494e-02f, -1.44416904e-02f, 6.21159980e-03f, -4.70822081e-02f, -9.05997530e-02f, -1.99733060e-02f, -1.27390809e-02f, 7.05335811e-02f, 1.88297004e-01f,
  7.51040969e-03f, -4.47949693e-02f, -5.59639223e-02f, 4.28970717e-02f, -7.34641217e-03f, -6.77719712e-02f, 1.60891339e-02f, 1.60650760e-02f, 1.29444683e-02f, 1.78907830e-02f,
  5.32402769e-02f, 3.18784975e-02f, -5.15983254e-02f, 1.05743958e-02f, -2.27063824e-03f, 6.08997531e-02f, 5.88892493e-03f, 5.85421249e-02f, -1.72833074e-02f, 8.33031312e-02f,
  2.66978308e-03f, -6.04201742e-02f, 5.34014963e-02f, -5.65103665e-02f, -9.35583189e-02f, -8.87653679e-02f, -4.32989039e-02f, -7.35191926e-02f, -5.41296341e-02f, 1.17695592e-02f,
  2.94403732e-01f, -6.27477244e-02f, 1.68612897e-01f, 2.71712919e-03f, -1.17506934e-02f, 1.44772641e-02f, -2.40838565e-02f, -4.43366952e-02f, -2.49468591e-02f, 5.86878210e-02f,
  1.68289319e-02f, -1.85155962e-02f, 4.66981865e-02f, 2.81696729e-02f, 8.51220712e-02f, -3.07727549e-02f, -1.59849934e-02f, 4.87230113e-03f, 5.55391610e-02f, 2.01788454e-04f,
  5.43090962e-02f, 3.07857040e-02f, 4.55994010e-02f, -2.28887238e-02f, -4.19147946e-02f, -2.66228206e-02f, 3.59981917e-02f, 5.73349297e-02f, 1.83853749e-02f, 1.89934567e-01f,
  1.28617585e-01f, -1.71086133e-01f, -1.68326408e-01f, -8.94156992e-02f, 1.94690358e-02f, 1.07570693e-01f, -2.40212511e-02f, 7.54025877e-02f, -6.99368194e-02f, -1.92408562e-02f,
  1.20279886e-01f, 8.00372958e-02f, 6.91047832e-02f, 5.02475575e-02f, 9.16498676e-02f, -1.32351950e-01f, -1.73938423e-01f, -5.29093817e-02f, 2.45603293e-01f, 2.71751851e-01f,
  4.51314896e-02f, 1.68258436e-02f, 8.71745646e-02f, 3.03112417e-02f, -2.46295497e-01f, -3.58760692e-02f, -2.29906350e-01f, -1.21688589e-01f, -7.85040408e-02f, -2.53143460e-01f,
  -1.67429611e-01f, -7.14588091e-02f, 1.86530843e-01f, 1.31384417e-01f, 5.02561368e-02f, -1.13997757e-02f, 5.24758827e-03f, -1.45912468e-01f, 2.52759680e-02f, -1.17836714e-01f,
  -2.35232189e-02f, 1.43276779e-02f, 5.55232950e-02f, -3.24490629e-02f, -6.07445687e-02f, 1.32690668e-02f, -7.68634081e-02f, -1.03538498e-01f, 4.43497933e-02f, -1.30013421e-01f,
  -5.56756891e-02f, 1.26260877e-01f, -2.22533196e-02f, -1.64882969e-02f, -1.12867476e-02f, 6.70709312e-02f, -1.26705738e-02f, -1.62777584e-02f, 5.69553860e-02f, -1.04978569e-01f,
  -2.18212907e-03f, -5.76957539e-02f, 5.89841753e-02f, 6.59290105e-02f, -1.58319287e-02f, -6.89799935e-02f, -6.41964376e-02f, 8.52876343e-03f, 7.71893561e-02f, -7.20945522e-02f,
  -3.07263620e-02f, -2.22344585e-02f, 6.34486228e-02f, -3.44812088e-02f, 2.89428197e-02f, 3.75758372e-02f, 4.08664607e-02f, -7.45409653e-02f, 4.18290049e-02f, 3.90892513e-02f,
  9.72536206e-03f, -2.47109128e-04f, -2.50655413e-03f, -2.64276061e-02f, 1.00655202e-02f, -2.27291398e-02f, 3.69768031e-02f, 4.60483693e-02f, 7.54116476e-03f, -9.48347598e-02f,
  -8.71267021e-02f, 2.49293476e-01f, -1.23328194e-01f, -5.00740558e-02f, -4.31904308e-02f, -4.23239432e-02f, -1.12052048e-02f, 2.70518661e-02f, -7.48030171e-02f, -5.68378076e-04f,
  8.73485580e-02f, -1.79847814e-02f, -1.27966590e-02f, -1.24634523e-02f, 6.96079805e-02f, 3.94602083e-02f, 2.86948998e-02f, 4.78409417e-02f, -2.12332606e-02f, -9.72893313e-02f,
  -7.81172439e-02f, 4.86813374e-02f, 4.33880910e-02f, 1.25341089e-02f, 9.01219174e-02f, 1.74693748e-01f, 7.77821392e-02f, 2.86787748e-02f, 1.85505539e-01f, -1.01928443e-01f,
  -1.09665185e-01f, 3.29149783e-01f, -2.16520444e-01f, -1.13945551e-01f, -3.38465162e-02f, 4.51764204e-02f, 1.82904854e-01f, 1.35026351e-01f, 2.29827277e-02f, 7.88314044e-02f,
  7.52943829e-02f, 8.05454422e-03f, -3.91262164e-03f, -2.80427523e-02f, -1.57940298e-01f, -5.76195447e-03f, -1.27945036e-01f, -2.02982143e-01f, -2.00577006e-01f, 2.04103850e-02f,
  1.30392648e-02f, 5.37683405e-02f, -1.19646020e-01f, -3.20624448e-02f, -4.52160574e-02f, -1.33197233e-01f, 9.72705137e-04f, 4.38214801e-02f, -6.92563877e-02f, -7.93113112e-02f,
  -1.55899711e-02f, 5.90718053e-02f, -1.17640123e-01f, 3.84489000e-02f, -8.19353107e-03f, 2.28487346e-02f, 4.51455489e-02f, 1.26642222e-03f, -3.81810591e-02f, 2.93868780e-02f,
  4.26039360e-02f, 4.90158089e-02f, 6.69996962e-02f, 1.10729516e-01f, 3.62795107e-02f, 8.91724750e-02f, 7.68804699e-02f, -5.98150752e-02f, -8.06135014e-02f, 2.13165209e-02f,
  2.87507698e-02f, 4.74683754e-02f, -5.38677499e-02f, -8.23879335e-03f, -1.00586444e-01f, -1.32489398e-01f, 7.69058168e-02f, -8.10169578e-02f, -1.63776889e-01f, -1.20204985e-02f,
  3.27782743e-02f, -4.53612693e-02f, 1.82728609e-03f, -4.51063551e-02f, -3.10113039e-02f, 5.34672476e-03f, -6.69599697e-02f, -1.88812073e-02f, -3.00451554e-02f, 4.86642197e-02f,
  -2.82388385e-02f, -2.83448193e-02f, 8.08343515e-02f, -7.60188550e-02f, 1.96107775e-02f, -7.91004524e-02f, -7.07123950e-02f, 1.53972963e-02f, 6.19703270e-02f, 2.16870271e-02f,
  2.75931619e-02f, -8.74071270e-02f, -6.26127748e-03f, 4.38718572e-02f, 3.32201384e-02f, 1.21474415e-02f, 1.84699148e-02f, 1.04592338e-01f, 8.67837891e-02f, -4.87036146e-02f,
  1.10479042e-01f, -8.68109688e-02f, -5.61364964e-02f, -5.31939266e-04f, 2.38077231e-02f, 1.68471541e-02f, -6.02725521e-02f, -6.87238574e-02f, -4.71963622e-02f, 5.05106971e-02f,
  5.35549186e-02f, -7.07248375e-02f, 4.33976687e-02f, -5.23718409e-02f, 3.79072386e-03f, -3.47671695e-02f, -1.12437829e-03f, -2.70879604e-02f, 3.47622521e-02f, 6.46544322e-02f,
  1.34033129e-01f, -4.49621379e-02f, 2.92909220e-02f, -4.58913706e-02f, 3.27641256e-02f, -1.67382270e-01f, -4.19831164e-02f, 3.34332697e-02f, -5.32716885e-02f, 1.00688122e-01f,
  -3.20413470e-01f, -2.43042916e-01f, -3.64058554e-01f, -8.65446925e-02f, 7.63866156e-02f, 9.46383178e-02f, -2.03643329e-02f, -7.63668492e-02f, 5.45457676e-02f, 2.37423237e-02f,
  8.60439315e-02f, 1.63668782e-01f, 8.03225785e-02f, 6.49679743e-04f, -5.50930351e-02f, -1.78527236e-01f, -1.80170566e-01f, -1.10746838e-01f, -1.16522601e-02f, 1.52234063e-02f,
  1.29221871e-01f, -4.76503521e-02f, -8.42610002e-02f, -1.83612686e-02f, 7.19339177e-02f, 1.11473456e-01f, -1.12288304e-01f, -1.29809678e-01f, -7.57074580e-02f, -1.93680286e-01f,
  -2.19025970e-01f, -1.54720694e-01f, 1.05729796e-01f, 1.14792041e-01f, 4.84066345e-02f, -1.61709636e-02f, 1.23745454e-02f, -7.18149841e-02f, 3.57589573e-02f, -7.04049990e-02f,
  1.17533416e-01f, 5.20560443e-02f, -2.41579581e-02f, 6.73381984e-02f, -9.71645024e-03f, -1.35894492e-02f, -3.08788214e-02f, -1.69880986e-01f, -3.51551436e-02f, -6.22603409e-02f,
  3.20052053e-03f, -2.68633123e-02f, -9.02367085e-02f, 1.29914032e-02f, -1.37808800e-01f, 7.61595443e-02f, -5.57448976e-02f, -9.12703946e-02f, -6.65102601e-02f, -9.60992873e-02f,
  -2.17257794e-02f, -5.26150363e-03f, -2.23261099e-02f, 2.96711009e-02f, -2.06663031e-02f, 3.54187600e-02f, -1.08597556e-03f, 8.77582803e-02f, -2.59616282e-02f, -1.40652154e-02f,
  6.84208572e-02f, -5.75420149e-02f, -6.00734092e-02f, -4.66553457e-02f, -1.95122305e-02f, -8.01578816e-03f, 4.18769643e-02f, -4.60134298e-02f, 2.17057206e-02f, 9.68201980e-02f,
  -3.70817706e-02f, -4.64392789e-02f, -1.93144158e-02f, -5.38832732e-02f, 5.65588288e-02f, -4.77151088e-02f, -6.05822988e-02f, -3.72064449e-02f, 5.75684831e-02f, 5.72841913e-02f,
  5.28663397e-02f, 1.29649371e-01f, 1.24159688e-02f, -6.62767217e-02f, 8.49410444e-02f, 4.04223520e-03f, -4.86313552e-03f, 6.88292610e-04f, 4.41872925e-02f, -8.39579329e-02f,
  3.28471102e-02f, -3.28336023e-02f, -9.51236039e-02f, -2.38985308e-02f, 6.39889464e-02f, 9.00621712e-02f, -8.76218155e-02f, 2.42558960e-02f, 4.18560952e-02f, -4.83643487e-02f,
  -7.03276396e-02f, -1.61167681e-02f, -8.90686736e-02f, -4.12938595e-02f, 4.22183610e-02f, 7.40040559e-04f, 1.82618517e-02f, -4.66775149e-02f, 3.36375199e-02f, -8.77952576e-02f,
  1.79688990e-01f, -1.19823895e-01f, 9.37653482e-02f, -3.07586174e-02f, 1.37543142e-01f, 2.93693632e-01f, 2.85178095e-01f, 2.18641207e-01f, -5.83180636e-02f, -2.22878251e-02f,
  5.56182191e-02f, -5.97929303e-03f, -3.12258508e-02f, 2.27191094e-02f, 1.14065498e-01f, 1.42384708e-01f, 7.27976346e-03f, 1.07428797e-01f, 1.62088215e-01f, 1.48073286e-01f,
  4.69237706e-03f, -1.00556403e-01f, -1.09754764e-01f, 3.44847478e-02f, -1.22620568e-01f, -2.90863384e-02f, -1.84320822e-01f, -1.79012850e-01f, -1.11756749e-01f, -2.57040739e-01f,
  -2.51606852e-01f, 4.14459929e-02f, 8.44381377e-02f, 3.22054364e-02f, -1.33232579e-01f, 4.52896543e-02f, -2.61274260e-02f, 8.61041900e-03f, 1.79559388e-03f, -1.12620890e-02f,
  6.15283474e-02f, -3.03156208e-02f, 4.99237422e-03f, -6.05287664e-02f, 6.84909299e-02f, 1.11345597e-01f, 8.88046324e-02f, 2.71073487e-02f, 2.64416682e-03f, -8.25405493e-02f,
  -6.77717328e-02f, 7.55107775e-02f, 1.40367180e-01f, 5.17379604e-02f, -1.60440931e-03f, 5.28964922e-02f, -6.80199417e-04f, -1.04850598e-01f, -1.60681177e-02f, -8.73217732e-02f,
  -8.04087985e-03f, -4.90616001e-02f, 7.13153034e-02f, -2.62091979e-02f, -6.25638887e-02f, 4.76163030e-02f, 3.08935419e-02f, -2.97195967e-02f, 3.99925821e-02f, 3.77500653e-02f,
  3.01471222e-02f, -4.44277748e-02f, -4.36986759e-02f, -5.75057864e-02f, -5.73270768e-03f, -3.67812924e-02f, -2.06771232e-02f, 7.73960399e-03f, 5.63590275e-03f, 1.85054708e-02f,
  -3.58273797e-02f, 6.74178600e-02f, -4.43326496e-02f, 1.85800549e-02f, 5.05965129e-02f, -2.48684511e-02f, -3.29133347e-02f, 3.61092463e-02f, -3.87474000e-02f, -6.87413709e-03f,
  -1.85575843e-01f, 2.31775597e-01f, -6.31834418e-02f, 2.57991608e-02f, 2.26785745e-02f, -3.06151807e-02f, 6.16374286e-03f, -7.21888468e-02f, -9.66887176e-03f, 4.52766642e-02f,
  7.61942491e-02f, 1.15607288e-02f, 2.49870047e-02f, -6.21967092e-02f, 1.08281784e-01f, 1.00419529e-01f, -3.20631787e-02f, 7.69095570e-02f, -3.20674777e-02f, 6.27504587e-02f,
  8.77916999e-03f, 4.24208380e-02f, 1.79298058e-01f, 8.03473890e-02f, 1.40309567e-02f, 1.46202549e-01f, -6.66294396e-02f, 4.14582156e-02f, 2.13228643e-01f, -8.48941877e-02f,
  1.25354016e-02f, -5.75049222e-02f, -1.09352656e-01f, 3.41678895e-02f, -1.47026464e-01f, -2.35826001e-01f, -3.26067120e-01f, -1.84188649e-01f, -1.89062618e-02f, -5.88952117e-02f,
  1.20515585e-01f, 9.65824276e-02f, 9.03478172e-03f, -5.18568344e-02f, -9.02206749e-02f, -1.48359403e-01f, -1.30591273e-01f, -6.16683364e-02f, -1.21021301e-01f, -1.46352887e-01f,
  -1.94933694e-02f, -1.22910403e-02f, -1.02974651e-02f, -1.06149733e-01f, -4.32259105e-02f, 2.29642987e-02f, 4.72829640e-02f, 5.24868481e-02f, -1.31537849e-02f, 1.91698745e-02f,
  6.09514713e-02f, 2.42565963e-02f, -3.56353112e-02f, 3.56962122e-02f, -5.80184069e-03f, 4.02375460e-02f, 2.58335122e-03f, -2.01748088e-02f, 3.83109320e-03f, -2.57801265e-02f,
  -2.59595793e-02f, -9.44744423e-02f, 3.99497710e-02f, -6.93515465e-02f, -5.84218055e-02f, -3.12431566e-02f, -1.02908328e-01f, -6.25368506e-02f, -9.92541760e-02f, -9.49456915e-02f,
  -2.44866274e-02f, 3.22534144e-02f, -1.41659873e-02f, -2.16307994e-02f, 7.26440325e-02f, -1.96580458e-02f, -8.59751925e-02f, -3.00641218e-03f, 6.57724068e-02f, -3.24607198e-03f,
  -1.91945005e-02f, 6.62871823e-02f, -1.74318682e-02f, 2.41781585e-02f, 2.22425554e-02f, 3.60605717e-02f, -7.88206458e-02f, 3.00506912e-02f, 2.10928405e-03f, -4.78244871e-02f,
  -3.69109400e-02f, 7.91920051e-02f, -1.85987372e-02f, -9.22270045e-02f, -3.16040218e-03f, 1.75204277e-02f, -5.41612431e-02f, -5.25478981e-02f, 1.89335961e-02f, -3.30553502e-02f,
  -4.13773432e-02f, -2.13268469e-03f, 9.50493515e-02f, -1.48896175e-02f, -7.28754792e-03f, -1.70555152e-02f, 6.34726658e-02f, 5.80135407e-03f, -1.28265913e-03f, 5.39968908e-02f,
  9.42029357e-02f, 1.47467898e-02f, -1.20566245e-02f, 2.47342349e-03f, -4.16080020e-02f, 6.19821399e-02f, 3.30471918e-02f, -3.11682746e-02f, 1.54041173e-02f, -9.26909447e-02f,
  -2.60447375e-02f, -5.94969802e-02f, 1.00047223e-01f, 5.04980423e-03f, 5.05072111e-03f, -1.02528572e-01f, -1.30806968e-01f, 7.82392267e-03f, 1.70454662e-03f, -6.74518049e-02f,
  -7.45118707e-02f, -1.20752603e-01f, 1.13905882e-02f, 5.62877357e-02f, -4.86934297e-02f, 8.50419477e-02f, 3.05820648e-02f, -3.10513377e-02f, 2.91109346e-02f, -1.82012156e-01f,
  3.24622363e-01f, -1.94528028e-02f, -1.96084261e-01f, 3.12940255e-02f, -8.65372345e-02f, -2.46392623e-01f, -2.87256181e-01f, -1.97944846e-02f, 6.66951993e-03f, 2.50462051e-02f,
  3.57363559e-02f, -2.80048084e-02f, 5.07200919e-02f, -8.65866058e-03f, -1.34643465e-01f, -2.40136579e-01f, -2.62773275e-01f, -1.75292477e-01f, -1.22516692e-01f, -7.63815790e-02f,
  -7.42740929e-02f, -6.77292719e-02f, 7.49445632e-02f, 5.43222539e-02f, -4.01888564e-02f, -3.69799025e-02f, 1.45376595e-02f, 9.93431285e-02f, -3.18153389e-02f, 3.55636515e-03f,
  -1.75724775e-01f, 2.52030432e-01f, -2.45022401e-02f, 3.54501642e-02f, 7.70289674e-02f, 2.51789484e-02f, -4.46226224e-02f, 7.69170970e-02f, 9.28753801e-03f, -2.38241274e-02f,
  7.53869340e-02f, 1.10243618e-01f, -8.35300907e-02f, -4.04216396e-03f, -6.10731542e-03f, 6.54619634e-02f, 6.99230805e-02f, 1.00572422e-01f, -4.40313593e-02f, 2.23153159e-02f,
  -7.69715086e-02f, -5.61937839e-02f, -1.09766927e-02f, -3.42685916e-02f, 1.09651238e-01f, -5.65110259e-02f, 2.33240630e-02f, 1.24337956e-01f, 3.36518511e-02f, 3.82649042e-02f,
  -1.04191333e-01f, 2.19552759e-02f, -7.56850988e-02f, 1.80342998e-02f, -8.58122203e-03f, 6.96257353e-02f, -8.08936954e-02f, 1.56870135e-03f, -1.15447743e-02f, -2.62856372e-02f,
  -4.71679168e-03f, 1.09505737e-02f, 1.39934495e-02f, 3.42864506e-02f, 2.32907347e-02f, -4.61015888e-02f, -3.62423770e-02f, -7.05621317e-02f, 6.52490705e-02f, 2.06964929e-02f,
  -1.40907820e-02f, 2.13404112e-02f, 3.73209417e-02f, 4.55593504e-02f, -2.62576248e-02f, 2.31904220e-02f, -8.78392905e-02f, 5.43855168e-02f, 4.93475385e-02f, 7.36285839e-03f,
  6.92287162e-02f, -1.92983486e-02f, -2.93669626e-02f, 7.75855547e-03f, -5.45654483e-02f, 7.18769506e-02f, 3.42633501e-02f, -3.03353406e-02f, 1.21536411e-01f, 3.16497795e-02f,
  1.54074868e-02f, -9.80851799e-03f, 2.95671765e-02f, -2.51063760e-02f, 3.69670708e-03f, -2.11152043e-02f, 9.94591415e-03f, -1.00433931e-01f, -3.45984958e-02f, 2.51587275e-02f,
  -1.05919810e-02f, -5.52938432e-02f, -2.20920574e-02f, -1.22916661e-02f, 1.52935619e-02f, 5.04196901e-03f, -7.52590224e-02f, -1.23878948e-01f, -1.80417430e-02f, -9.52982455e-02f,
  -1.82171375e-01f, 4.78157599e-04f, 2.81330913e-01f, 1.01163961e-01f, 2.23173890e-02f, 9.40721631e-02f, 5.36478721e-02f, 7.03492314e-02f, -1.21101330e-03f, 1.38161615e-01f,
  4.78224605e-02f, 1.63538739e-01f, 1.79813549e-01f, 1.03528321e-01f, 1.76561400e-01f, 4.91487943e-02f, 1.97474137e-01f, 1.32701084e-01f, 1.36918962e-01f, 2.15449482e-01f,
  1.75809562e-01f, 1.85000181e-01f, 1.58008903e-01f, 1.01345137e-01f, 6.66952273e-03f, 1.27751678e-01f, 7.57334158e-02f, 7.60396123e-02f, 6.23744056e-02f, 1.41991094e-01f,
  2.56412178e-01f, -3.33314054e-02f, 2.66251266e-02f, 2.66467854e-02f, 5.62389381e-02f, 3.59850414e-02f, -1.54457567e-02f, -7.04215914e-02f, -1.42375961e-01f, -4.00738940e-02f,
  2.37193517e-02f, -4.82530519e-02f, 1.50982728e-02f, -3.03138644e-02f, -2.18231995e-02f, 2.29087775e-03f, 5.31424917e-02f, -1.01232175e-02f, 5.52940629e-02f, -4.21474017e-02f,
  8.99419095e-03f, -7.37305060e-02f, 1.21769700e-02f, -2.42330823e-02f, 4.22643410e-04f, -1.05118006e-01f, 1.96708962e-02f, -5.98299094e-02f, -6.31843656e-02f, -7.72926658e-02f,
  2.53046472e-02f, 2.57379133e-02f, 2.92568933e-02f, -7.45588839e-02f, 2.80724782e-02f, -8.00619572e-02f, -4.09355350e-02f, -3.42994221e-02f, 1.70127135e-02f, 2.33331099e-02f,
  9.24557224e-02f, 2.45903078e-02f, 8.67321119e-02f, -5.55649474e-02f, -4.31299163e-03f, 4.51267064e-02f, -5.29603437e-02f, -4.99294698e-02f, -9.35127437e-02f, 3.75186838e-02f,
  2.69837901e-02f, -4.21904996e-02f, 4.92077656e-02f, -8.79405998e-03f, -2.66758376e-03f, -2.74102520e-02f, 5.09061031e-02f, -2.69434173e-02f, -3.42095308e-02f, -3.86070311e-02f,
  -2.96081472e-02f, -3.25548612e-02f, -7.42786229e-02f, -4.18405384e-02f, -1.31143779e-02f, -1.38421312e-01f, -2.45972704e-02f, -1.57407090e-01f, -4.83428054e-02f, 2.64918208e-02f,
  1.66564118e-02f, 6.38389289e-02f, 6.82743266e-02f, 9.51593444e-02f, 8.15145224e-02f, -6.29633591e-02f, -5.54817803e-02f, 4.54599783e-02f, -9.95592307e-03f, 5.07614315e-02f,
  2.46693324e-02f, -9.32131931e-02f, -7.62956217e-02f, -1.29932299e-01f, -7.75634795e-02f, 2.86842460e-05f, -6.58969134e-02f, -4.53649126e-02f, -1.05009742e-01f, -5.74181415e-02f,
  8.83038789e-02f, 9.40055847e-02f, 6.94165826e-02f, -1.81718245e-02f, -4.67566624e-02f, -2.91456431e-01f, -3.32112491e-01f, -2.11048260e-01f, 2.02405434e-02f, -4.22791541e-02f,
  1.60190821e-01f, 3.07847541e-02f, 4.82879654e-02f, 4.84347455e-02f, -7.75671527e-02f, -1.48527876e-01f, -1.73067331e-01f, -9.49198827e-02f, -6.43870309e-02f, -8.09065402e-02f,
  -1.99220274e-02f, 3.98425385e-02f, 1.16687343e-01f, 6.05296753e-02f, 2.61001252e-02f, 7.40725771e-02f, 1.71974003e-02f, 1.18509866e-01f, 1.54169858e-03f, 9.63610858e-02f,
  1.31718919e-01f, 2.12090150e-01f, -1.25500308e-02f, 1.05182670e-01f, 5.35974465e-02f, 5.00729010e-02f, -9.57038701e-02f, 1.29014701e-01f, 3.66710462e-02f, -6.73724413e-02f,
  1.33893713e-01f, 5.32179847e-02f, 5.86345606e-03f, -3.64810377e-02f, -6.57397807e-02f, -9.08427872e-03f, 3.38844582e-02f, 5.98625541e-02f, -4.07558084e-02f, -3.51229459e-02f,
  1.09271102e-01f, 4.01250869e-02f, 3.50113437e-02f, -1.41457975e-01f, 2.65609026e-02f, -4.06153016e-02f, 6.80494308e-02f, -1.50869573e-02f, -1.34794325e-01f, -1.12268910e-01f,
  -3.02725434e-02f, 3.53307873e-02f, 2.37228647e-02f, 3.11008058e-02f, -8.70122090e-02f, -8.47820938e-03f, 7.61353821e-02f, -3.77338640e-02f, 2.60695256e-02f, -6.99171349e-02f,
  3.36656533e-02f, 2.77946256e-02f, 4.61286306e-03f, -3.33593115e-02f, 6.55637383e-02f, -2.77323052e-02f, -1.55332973e-02f, -8.10870249e-03f, -1.39593435e-02f, -2.70594396e-02f,
  3.89044434e-02f, -1.56798288e-02f, 1.51731577e-02f, 3.83307934e-02f, 1.14509249e-02f, -5.47918433e-04f, -7.96223357e-02f, 7.26088434e-02f, 4.86755446e-02f, -2.35920143e-03f,
  -8.07132795e-02f, 6.51326776e-03f, -5.78747094e-02f, -4.50882763e-02f, 1.86098348e-02f, -4.52221604e-03f, 7.85092190e-02f, 4.76800557e-03f, 1.62968412e-02f, 2.31587235e-02f,
  -3.16702724e-02f, -1.64818764e-02f, 9.73176560e-04f, 5.47859743e-02f, -7.47372806e-02f, -5.38813546e-02f, -8.46391171e-02f, 1.66720487e-02f, -2.02125460e-02f, 4.50243689e-02f,
  -7.42843673e-02f, -1.58584669e-01f, -1.70559227e-01f, -1.27521098e-01f, -8.94893408e-02f, -1.36034846e-01f, -1.24228686e-01f, -1.64880231e-01f, -2.42580384e-01f, -2.90591300e-01f,
  -2.43381970e-02f, 2.60555655e-01f, 2.26821173e-02f, 1.19405888e-01f, 1.33130297e-01f, 7.03941956e-02f, 8.84072855e-02f, -6.37272745e-02f, -2.23143697e-02f, 9.33336243e-02f,
  -1.22770276e-02f, -1.40927702e-01f, -1.09578013e-01f, -5.62870577e-02f, 3.36352438e-02f, 2.11658671e-01f, 1.31560549e-01f, 1.14941031e-01f, -1.58171296e-01f, -1.88780800e-02f,
  6.64961189e-02f, 3.40944678e-02f, 7.21976161e-02f, -1.21480823e-02f, 1.68852098e-02f, -8.98407400e-02f, 9.46362391e-02f, 7.75716826e-02f, 1.51092084e-02f, 1.09214932e-01f,
  -1.97251812e-01f, 4.01979219e-03f, -9.38181952e-02f, -3.53730209e-02f, -1.65901147e-02f, 9.28436499e-03f, -1.09588370e-01f, -1.07699856e-02f, 6.69642445e-03f, -5.91046736e-02f,
  2.40130071e-02f, -6.26998320e-02f, 6.83433190e-02f, -7.30081871e-02f, 5.81352040e-02f, 1.82476602e-02f, 7.33095780e-02f, -4.42219377e-02f, -5.08928150e-02f, -1.11201406e-01f,
  1.02690406e-01f, 3.19137499e-02f, -6.78831935e-02f, 1.81610882e-02f, -9.86480713e-02f, 2.99242772e-02f, -8.73067789e-03f, -1.23210326e-01f, -8.86351168e-02f, -5.39855771e-02f,
  3.34776528e-02f, 6.71729743e-02f, -7.98489079e-02f, 1.89611334e-02f, -7.55020790e-03f, 6.28902242e-02f, 3.02023278e-03f, -1.11324321e-02f, 4.07271720e-02f, -4.23128121e-02f,
  2.74011679e-03f, -3.96016166e-02f, 3.95522453e-03f, -2.05210298e-02f, 5.61636761e-02f, -6.63741305e-02f, -2.83697546e-02f, -1.12324650e-03f, 5.81679940e-02f, 2.15578675e-02f,
  -1.92877762e-02f, 9.14250128e-03f, 4.12755944e-02f, 4.51810583e-02f, 3.04271979e-03f, -5.08392155e-02f, -2.86161490e-02f, 1.62970591e-02f, -5.40410131e-02f, 4.77967821e-02f,
  -1.73162043e-01f, 4.73344550e-02f, -8.81311744e-02f, -6.81192847e-03f, -9.97426175e-03f, -3.19265909e-02f, 1.04688655e-03f, 6.98142648e-02f, -3.93435284e-02f, 5.70813045e-02f,
  -6.98359609e-02f, -5.69671057e-02f, 7.60305598e-02f, 7.46599138e-02f, -5.72420023e-02f, -1.98452529e-02f, 5.78528494e-02f, 2.30504442e-02f, -1.55048817e-02f, -4.49086204e-02f,
  9.17268768e-02f, 2.33940054e-02f, -7.11953640e-02f, -9.18415859e-02f, -6.48278520e-02f, -1.77166283e-01f, -7.41594136e-02f, -3.39611545e-02f, -6.37023598e-02f, 1.18008167e-01f,
  -5.31458735e-01f, -2.65017986e-01f, -3.76150876e-01f, -3.30624610e-01f, -2.43115742e-02f, 3.37440148e-02f, -8.28362852e-02f, -3.65924388e-02f, -3.23746726e-02f, -1.46658406e-01f,
  7.18278885e-02f, 1.68262899e-01f, -8.60184839e-04f, 4.94461805e-02f, 9.68965888e-02f, -1.40619427e-01f, -6.03042692e-02f, -1.54496938e-01f, 8.69298279e-02f, 6.08716384e-02f,
  1.07674375e-01f, -1.42904192e-01f, -1.80640921e-01f, 3.90001992e-03f, -1.30346879e-01f, 3.98096628e-02f, -4.24615890e-02f, -1.44719005e-01f, 6.16471097e-02f, -8.85379016e-02f,
  -1.22503586e-01f, -2.99096674e-01f, 4.91145402e-02f, 1.20945713e-02f, -4.85827923e-02f, 4.33955826e-02f, -9.61079970e-02f, -1.42586231e-02f, 1.10199237e-02f, -4.44637053e-02f,
  -7.84801990e-02f, 8.04247111e-02f, -2.68510059e-02f, 7.79832900e-02f, -8.62706266e-03f, -3.71137708e-02f, 5.42513505e-02f, -9.73423123e-02f, 2.02197190e-02f, -8.07084329e-03f,
  1.32525424e-02f, -2.13084649e-02f, -7.70346448e-02f, -1.05665997e-02f, 5.50557971e-02f, 4.20335904e-02f, -6.05525449e-02f, 1.08207194e-02f, 9.39133689e-02f, -9.09594521e-02f,
  6.06721044e-02f, 2.24386659e-02f, 9.85710621e-02f, -2.63943709e-02f, 6.28614277e-02f, -1.36960922e-02f, -3.72834764e-02f, 2.07974985e-02f, 8.24327469e-02f, -3.66935991e-02f,
  5.07155135e-02f, -4.34689187e-02f, -4.01031971e-02f, -9.63497758e-02f, 4.81173582e-02f, 1.01335440e-02f, -2.18194593e-02f, 1.60718765e-02f, 4.38774750e-03f, -2.91588120e-02f,
  5.38059734e-02f, -4.59133089e-02f, 1.68389063e-02f, 7.19820037e-02f, -8.38177949e-02f, 2.40590703e-02f, -9.06864032e-02f, 8.67170021e-02f, -6.32512048e-02f, -3.94620374e-02f,
  1.56569704e-01f, 1.09111108e-01f, -1.28244936e-01f, 5.45597039e-02f, -2.43240898e-03f, 3.02524250e-02f, -2.33008377e-02f, 4.79084626e-02f, -7.70663396e-02f, 2.14381106e-02f,
  8.67810696e-02f, -9.26575810e-02f, -6.84159398e-02f, 4.49709520e-02f, 2.51007103e-03f, -9.31268092e-03f, 5.11106737e-02f, -3.51891220e-02f, 9.81708020e-02f, 8.28484632e-03f,
  -3.99561226e-02f, 1.14398235e-02f, -4.98393085e-03f, 1.79296862e-02f, 4.93082255e-02f, -1.69182557e-03f, 4.86353859e-02f, 8.46111774e-02f, 9.25161317e-02f, 2.34641973e-02f,
  -1.78345755e-01f, -1.58186495e-01f, -9.13831368e-02f, 4.37180279e-03f, 8.85470808e-02f, 1.65837944e-01f, 3.36935408e-02f, 6.35952801e-02f, 1.47128657e-01f, 2.48445440e-02f,
  -7.97967091e-02f, 4.06811312e-02f, 9.12894830e-02f, 1.11968368e-01f, 4.58956044e-03f, -4.02255042e-04f, 6.17011450e-02f, -2.79168673e-02f, 1.77315697e-01f, 1.60612062e-01f,
  2.92534810e-02f, -7.96146225e-03f, -2.36077625e-02f, -8.30914546e-03f, -6.27788678e-02f, 2.76233070e-02f, -1.09290011e-01f, -6.67107254e-02f, -1.15993500e-01f, -1.05697699e-01f,
  -1.43310413e-01f, -2.39383310e-01f, 1.26648366e-01f, -2.08208747e-02f, -1.19674401e-02f, -7.22084343e-02f, 5.50650731e-02f, -7.21965954e-02f, 4.36371192e-02f, 2.18176059e-02f,
  -3.82070951e-02f, -4.88532893e-02f, 5.88649921e-02f, -9.94594246e-02f, -8.44766721e-02f, -8.32831264e-02f, -9.62354690e-02f, -8.58322755e-02f, -7.62918815e-02f, -1.00571699e-01f,
  3.85390362e-03f, -8.10358748e-02f, -1.14148855e-02f, -4.79893498e-02f, -7.33973458e-02f, -4.45196703e-02f, -4.36300710e-02f, -9.09531862e-02f, 1.58285256e-02f, -8.00069422e-02f,
  6.02227040e-02f, -5.08127101e-02f, -2.40667611e-02f, 2.09935326e-02f, -2.57378886e-03f, 4.64361832e-02f, -8.73590261e-03f, 6.32339865e-02f, 2.58536693e-02f, -3.14495936e-02f,
  -3.96152399e-02f, 4.45463508e-02f, -1.76463835e-02f, -3.69360391e-03f, 7.93578401e-02f, -6.38191327e-02f, -4.61640805e-02f, -5.86910620e-02f, 3.89460102e-02f, -1.88111942e-02f,
  1.33439098e-02f, 1.39772091e-02f, -2.61248695e-03f, 2.59094518e-02f, -1.00445136e-01f, -8.39641988e-02f, -2.66473362e-04f, 2.70604528e-02f, 2.34593209e-02f, 3.60288918e-02f,
  2.02112287e-01f, -6.95061386e-02f, 8.53684023e-02f, 8.05258751e-02f, -5.35275787e-02f, -1.02710508e-01f, -1.64616592e-02f, -2.92188264e-02f, 6.52582443e-04f, 9.14949775e-02f,
  6.48414344e-03f, 1.00106392e-02f, -7.93766156e-02f, 2.36579310e-02f, 1.93024408e-02f, -3.07146050e-02f, -1.25340617e-03f, 9.42379050e-03f, 8.91520008e-02f, 9.50854446e-04f,
  -5.95257170e-02f, 1.62462205e-01f, 6.59284890e-02f, 1.52924344e-01f, 1.52909365e-02f, 1.05543949e-01f, 9.40666869e-02f, 4.19508144e-02f, 3.84360775e-02f, 2.18659431e-01f,
  2.25317433e-01f, -9.60575789e-02f, 1.57369748e-01f, -6.28539994e-02f, -6.67292625e-02f, -5.26098460e-02f, 3.76770869e-02f, 5.61470687e-02f, 2.93122288e-02f, -1.00867497e-02f,
  8.80548134e-02f, -2.78603714e-02f, 1.36964515e-01f, -1.70761663e-02f, 9.73413661e-02f, -6.85624704e-02f, -2.07590237e-02f, 1.46660060e-01f, 1.64360195e-01f, -5.45031205e-02f,
  -1.48505956e-01f, -2.74743102e-02f, -3.45848873e-02f, 7.86922947e-02f, -9.48560685e-02f, -1.50212407e-01f, 1.85016133e-02f, 5.07815881e-03f, -8.35235789e-02f, -2.33847365e-01f,
  8.92134532e-02f, 1.82356656e-01f, 5.46000572e-03f, -1.16595775e-02f, 5.55623546e-02f, 7.00783506e-02f, 2.79881954e-02f, 4.74258251e-02f, 4.49221209e-02f, 2.54600979e-02f,
  -6.67254180e-02f, -2.57434286e-02f, -4.52626832e-02f, 2.50933543e-02f, -6.77249953e-03f, -4.42633517e-02f, -5.27375601e-02f, 8.87536630e-02f, 1.10086627e-01f, 7.27816001e-02f,
  -3.75175253e-02f, -9.35242027e-02f, 4.19260599e-02f, 7.34601840e-02f, 1.69298146e-02f, 5.24138771e-02f, -6.17473312e-02f, -2.15599444e-02f, 6.31787255e-02f, -1.21635407e-01f,
  1.44321716e-03f, 3.69442999e-02f, -9.92515162e-02f, -6.45887153e-03f, -7.13919103e-02f, -1.64738540e-02f, 4.48501259e-02f, -1.08993955e-01f, -2.77452432e-02f, 7.41389068e-03f,
  3.60676199e-02f, 6.16277009e-02f, -2.16995310e-02f, -6.02115616e-02f, -6.96346536e-02f, 4.50876355e-02f, -1.00482598e-01f, -8.33031163e-02f, 3.79048996e-02f, -2.82734204e-02f,
  5.95652610e-02f, -1.28078805e-02f, -2.14091130e-03f, -6.47524819e-02f, 3.01480684e-02f, -6.56690449e-02f, -1.85577180e-02f, -3.06959394e-02f, 4.28670645e-02f, 2.67889854e-02f,
  -8.72691274e-02f, 2.13650942e-01f, 1.75380299e-03f, 1.43848583e-01f, -6.81855604e-02f, 3.30295004e-02f, -7.06977770e-02f, 3.82840261e-02f, -6.85552061e-02f, -2.18976121e-02f,
  7.42807612e-02f, 9.65525676e-03f, 6.16903640e-02f, -4.24947143e-02f, -3.57232504e-02f, -1.04383042e-03f, -7.18271211e-02f, -3.48324813e-02f, 9.24786180e-02f, -2.00337190e-02f,
  -1.64472938e-01f, 5.09703085e-02f, 1.51067274e-02f, 6.06604032e-02f, -2.59102769e-02f, 4.76608351e-02f, 1.06914490e-01f, 4.88791764e-02f, 3.20311114e-02f, -1.14980675e-01f,
  -3.60591076e-02f, -1.27340198e-01f, -2.88585812e-01f, -2.52241530e-02f, -1.17321402e-01f, -1.48987114e-01f, -2.26870567e-01f, -1.10308386e-01f, -1.05760969e-01f, -1.17064960e-01f,
  -8.28479826e-02f, 9.37554613e-02f, -7.00256005e-02f, -7.11481422e-02f, -1.13212034e-01f, -3.14083219e-01f, -2.49893516e-01f, -1.54234588e-01f, -1.34079501e-01f, -1.20310880e-01f,
  -9.64741111e-02f, -8.67681503e-02f, -1.14720412e-01f, 8.84431135e-03f, -1.00224964e-01f, -8.41089413e-02f, -1.35462195e-01f, -1.37048990e-01f, -5.25274314e-02f, -1.87939852e-01f,
  -3.43320146e-02f, -1.70339704e-01f, 3.42557803e-02f, -2.74175201e-02f, 9.15624350e-02f, 4.45739925e-02f, -2.88294023e-03f, 1.82263199e-02f, 9.54725072e-02f, -6.03147957e-04f,
  2.81646494e-02f, 8.61030668e-02f, 9.39804018e-02f, 7.69068599e-02f, -5.05730100e-02f, 4.93826810e-03f, 7.42100552e-02f, -9.21077281e-02f, 1.45971552e-02f, -4.60665971e-02f,
  1.02914147e-01f, 2.76416335e-02f, -1.07435875e-01f, 5.68801463e-02f, -3.22904326e-02f, -5.72797619e-02f, 7.08972439e-02f, -5.87040931e-02f, -2.84309443e-02f, -5.26960418e-02f,
  -8.09531510e-02f, -1.78771764e-02f, -5.54693341e-02f, -2.75440812e-02f, 4.10260521e-02f, 2.57731113e-03f, 1.07860407e-02f, -1.08206160e-02f, 1.01678930e-02f, 8.47416967e-02f,
  3.63280214e-02f, -5.84122119e-03f, 5.27044721e-02f, 1.93497296e-02f, 3.45107317e-02f, -5.88069446e-02f, 6.77477419e-02f, -2.37926398e-03f, -1.06487246e-02f, -3.03339679e-02f,
  9.90911759e-03f, 2.98858644e-03f, -8.42955522e-03f, 1.98333468e-02f, -6.17494397e-02f, -6.35285601e-02f, 9.84922890e-03f, 3.51544060e-02f, 6.37736917e-02f, -6.02805316e-02f,
  1.98538214e-01f, -6.16664812e-02f, -3.01099978e-02f, -7.68151060e-02f, -2.67319083e-02f, -1.31905638e-02f, 8.61886591e-02f, -5.66234859e-03f, 6.15241341e-02f, 2.63244249e-02f,
  -7.66596943e-03f, 1.42781446e-02f, -1.08722979e-02f, 7.55805150e-02f, -3.09383292e-02f, -1.14374971e-02f, -2.50745360e-02f, -4.95757572e-02f, 5.92364408e-02f, 1.73887074e-01f,
  1.25091508e-01f, -8.24062675e-02f, -4.36394252e-02f, -1.20331338e-02f, 2.26350054e-02f, -8.21950659e-02f, 4.47048359e-02f, -3.91677842e-02f, -2.19140872e-02f, 6.70732781e-02f,
  1.82440832e-01f, -1.05849236e-01f, 1.50281310e-01f, 8.03145692e-02f, -9.52739455e-03f, 6.24789484e-03f, -1.14905283e-01f, 3.12844142e-02f, -1.42522780e-02f, 1.23179471e-03f,
  -8.83455947e-02f, 6.63535818e-02f, 7.93257058e-02f, 1.13686256e-01f, -5.64956442e-02f, -2.09173992e-01f, -1.57333985e-01f, 1.04893103e-01f, 7.57917240e-02f, -2.68730391e-02f,
  -8.36670101e-02f, -5.44022992e-02f, 1.48670867e-01f, 4.20546308e-02f, -2.54835244e-02f, 4.89718691e-02f, -2.12960858e-02f, -1.27455937e-02f, -1.12908617e-01f, -8.06847289e-02f,
  5.19733801e-02f, 1.92488268e-01f, 7.09536076e-02f, -2.71117333e-02f, 8.51602331e-02f, 2.52136998e-02f, -8.85987468e-03f, 6.59263209e-02f, 4.93453369e-02f, 4.61520813e-02f,
  8.04676414e-02f, -8.07599723e-03f, 8.16100910e-02f, 4.17485386e-02f, -3.03380694e-02f, -3.08055058e-03f, -2.12969854e-02f, -2.61471584e-03f, 5.48912995e-02f, 6.93457052e-02f,
  -1.46061763e-01f, 6.28457069e-02f, 2.10861295e-01f, -1.47706009e-02f, 1.01644523e-01f, 1.38071284e-01f, 5.04328986e-04f, 1.03430085e-01f, 1.77040383e-01f, -7.52926096e-02f,
  -6.53756186e-02f, 6.93382844e-02f, 9.55831783e-04f, 5.77123091e-02f, -5.83452135e-02f, 3.72693799e-02f, -1.75819490e-02f, 6.84177736e-04f, 5.49103832e-03f, -1.37810055e-02f,
  -4.52905037e-02f, 3.60923670e-02f, 1.68504659e-02f, 3.72435786e-02f, -1.05652036e-02f, -4.05971371e-02f, -1.78757943e-02f, -4.57679518e-02f, -3.43870558e-02f, -1.70509852e-02f,
  9.84471813e-02f, 6.72176480e-02f, 1.64697338e-02f, -4.92543653e-02f, 5.04219420e-02f, 2.75749918e-02f, -1.30901001e-02f, -7.98928365e-03f, 1.11225434e-01f, -2.16407105e-02f,
  9.18450132e-02f, -1.89305618e-02f, -4.00651768e-02f, 2.99249347e-02f, -2.55056769e-02f, 7.25136138e-03f, -2.23602448e-02f, -1.65909082e-02f, 1.19135179e-01f, 6.22984320e-02f,
  2.22468767e-02f, 2.20389664e-02f, 6.44256175e-02f, -1.19372159e-01f, -5.84422722e-02f, 1.48129510e-02f, -1.08147494e-01f, 6.63223639e-02f, 9.54780262e-03f, 6.56713173e-03f,
  -1.05552569e-01f, -7.31287971e-02f, 1.36962175e-01f, 2.54428736e-03f, 5.30302748e-02f, 1.42132550e-01f, 1.18512027e-01f, 4.30213250e-02f, 1.14488728e-01f, -1.63941130e-01f,
  6.49520159e-02f, 2.42994726e-01f, 7.18691945e-02f, 2.57881433e-01f, 6.67600483e-02f, 1.74250528e-02f, 6.71921670e-02f, -1.11865073e-01f, 8.75449851e-02f, 1.02131367e-01f,
  -5.05219102e-02f, -1.00985125e-01f, -1.03681415e-01f, -4.21022549e-02f, -8.05722699e-02f, 1.14898831e-01f, 1.55055791e-01f, -6.02864400e-02f, -7.91128874e-02f, -4.48711275e-04f,
  -3.06679867e-03f, 1.61191195e-01f, -4.94948775e-02f, 8.05460033e-04f, 1.93043426e-01f, 1.84477847e-02f, 9.19832960e-02f, 7.43524060e-02f, 9.30958167e-02f, 2.33811095e-01f,
  -9.12107453e-02f, -9.67392921e-02f, -1.33095365e-02f, 9.03339535e-02f, 8.68332088e-02f, -5.44782989e-02f, -6.17243303e-03f, -4.46443297e-02f, 7.76412338e-02f, -6.45629615e-02f,
  1.42645685e-03f, 5.01533151e-02f, 1.91348568e-02f, 2.22283620e-02f, -3.56654413e-02f, -1.11673828e-02f, 6.21004738e-02f, 3.74930203e-02f, -5.77681661e-02f, -6.23405427e-02f,
  7.19226301e-02f, 1.22676142e-01f, -1.11150853e-02f, -1.12370513e-02f, -9.53315478e-03f, 5.22418953e-02f, 2.56978587e-04f, -4.68003191e-02f, -5.47111593e-02f, 1.34124011e-02f,
  -5.44523597e-02f, 4.39995788e-02f, -9.36184749e-02f, 2.72448026e-02f, 5.23638129e-02f, -3.06973606e-02f, -2.02741870e-03f, -7.38682821e-02f, 7.03055877e-03f, 3.46021168e-02f,
  1.55863790e-02f, -5.65496795e-02f, 7.70055801e-02f, -6.42103478e-02f, 6.42769560e-02f, 6.05651699e-02f, -1.11095374e-02f, 2.70531978e-02f, -3.88886631e-02f, 2.60153823e-02f,
  -6.35091215e-02f, -7.99895450e-02f, 6.02940023e-02f, 5.72124384e-02f, -4.89986092e-02f, 2.28958242e-02f, -7.84441978e-02f, -3.93150561e-02f, 3.16972956e-02f, 1.07828513e-01f,
  -3.24200243e-02f, -5.22816479e-02f, -6.05595112e-03f, -6.65877908e-02f, 5.35023995e-02f, -5.48060462e-02f, 8.25149193e-02f, 5.08658774e-02f, 2.75921170e-02f, -7.20495656e-02f,
  6.66512400e-02f, -6.84301928e-02f, 2.51473095e-02f, -2.74929907e-02f, -2.44139880e-02f, -4.58432809e-02f, 1.05807796e-01f, 5.98224849e-02f, 3.04116849e-02f, -3.17406580e-02f,
  7.98070580e-02f, 4.22911271e-02f, -1.35690540e-01f, 1.98397636e-02f, -5.57846352e-02f, 3.15568112e-02f, 2.80991644e-02f, -3.98988428e-04f, -1.56905025e-01f, -1.60595048e-02f,
  -2.28362143e-01f, 3.02477062e-01f, 1.14226677e-01f, -1.60013601e-01f, -7.58613944e-02f, 1.31548092e-01f, 2.95520753e-01f, 3.73804979e-02f, -1.93488985e-01f, 1.07522957e-01f,
  8.76119807e-02f, -1.06719658e-01f, -4.08620276e-02f, -6.36818931e-02f, 1.28672644e-01f, 1.59157977e-01f, 1.62252992e-01f, 4.43462506e-02f, -8.52688551e-02f, -5.50862439e-02f,
  -6.50717132e-03f, -2.28907801e-02f, -1.46341801e-01f, 3.08728740e-02f, -6.36395440e-02f, -1.10326372e-01f, -4.69805487e-02f, 8.24718401e-02f, 1.99869946e-01f, 9.23722833e-02f,
  1.04943313e-01f, 9.44532454e-02f, -9.56935734e-02f, 2.65095439e-02f, 6.02784753e-02f, -6.28227443e-02f, 2.96801459e-02f, -1.19885705e-01f, -3.69054079e-02f, -7.77555928e-02f,
  -6.02982640e-02f, 2.90447567e-02f, -2.23084409e-02f, 4.62751128e-02f, -7.00495765e-02f, 5.08736558e-02f, 1.67680401e-02f, -1.66700929e-02f, 8.40078443e-02f, 5.62958345e-02f,
  1.20405838e-01f, 1.16348928e-02f, 5.90272211e-02f, -3.91899189e-03f, 2.76516769e-02f, -1.00437239e-01f, 1.48967564e-01f, 5.11760786e-02f, 5.39711211e-04f, -4.89792265e-02f,
  -2.54962724e-02f, -1.10133737e-02f, 6.52398020e-02f, 2.52362527e-03f, -5.18917739e-02f, -5.48040159e-02f, -5.13136201e-02f, 8.44594166e-02f, -2.70896461e-02f, -5.17493039e-02f,
  7.41605833e-02f, 1.17801391e-02f, 5.54217733e-02f, 3.82505194e-03f, -6.89878017e-02f, -2.72766477e-03f, 9.36648101e-02f, 4.77664806e-02f, -3.08899656e-02f, -4.66757007e-02f,
  -5.26129492e-02f, 2.62419209e-02f, -8.47609416e-02f, 2.83413846e-02f, 5.96094877e-02f, 6.89196140e-02f, 7.04639964e-03f, -5.78462444e-02f, 5.93121536e-02f, -2.19474360e-02f,
  -2.34337270e-01f, 6.47834688e-02f, -8.24951679e-02f, -8.59142095e-02f, 8.82253982e-03f, 6.81262165e-02f, -3.74920480e-02f, -5.96814826e-02f, 2.44073179e-02f, 9.37690437e-02f,
  4.63272817e-03f, 1.06355157e-02f, 6.73501641e-02f, -2.40244381e-02f, -4.37443666e-02f, -6.68935776e-02f, 4.50656116e-02f, 5.89300971e-03f, -1.24903582e-02f, 9.79423523e-02f,
  9.97135416e-02f, -2.30096169e-02f, -1.76269472e-01f, -3.44946198e-02f, -2.08618101e-02f, -5.44599891e-02f, -7.49678761e-02f, 1.02858311e-02f, -7.82288536e-02f, -1.05343491e-01f,
  -7.46850371e-02f, 3.08991875e-02f, 1.80640489e-01f, -2.03184694e-01f, -8.46757367e-02f, 8.85165930e-02f, 1.63331136e-01f, 1.06155187e-01f, -8.37136731e-02f, -4.18701917e-02f,
  4.50178310e-02f, -4.46630530e-02f, 8.94657988e-03f, -4.29463275e-02f, 1.07167087e-01f, 5.15375324e-02f, 4.15919581e-03f, -4.91410717e-02f, -9.37545951e-03f, -5.03096953e-02f,
  -1.82981547e-02f, -8.71018544e-02f, -1.24767922e-01f, -1.25687644e-01f, -9.89566445e-02f, -7.43477270e-02f, -1.27076507e-01f, -8.56658667e-02f, 5.47147319e-02f, -1.80349290e-01f,
  3.31574841e-03f, 1.11774825e-01f, 4.68258373e-02f, -1.18882572e-02f, -8.41593184e-03f, -1.40827829e-02f, -4.42325370e-03f, 4.15520705e-02f, 4.95804399e-02f, -6.40503615e-02f,
  -3.61530134e-03f, -4.80530411e-03f, 1.96321737e-02f, 1.65709872e-02f, 3.10696587e-02f, -4.49357033e-02f, 8.77914205e-02f, 1.70986149e-02f, -2.04795115e-02f, 1.35444835e-01f,
  -6.69067428e-02f, -2.63748877e-02f, -3.64537537e-02f, -4.43558805e-02f, -4.45830710e-02f, -8.67090970e-02f, -7.84754306e-02f, 4.22803275e-02f, 3.00129913e-02f, -1.71598330e-01f,
  -5.28351367e-02f, -4.19785120e-02f, -1.80825572e-02f, -3.96071188e-02f, 1.74901485e-02f, 4.97059636e-02f, 1.73896330e-03f, -5.00858091e-02f, 8.80144723e-03f, 3.97194438e-02f,
  2.98326258e-02f, 1.90153867e-02f, 7.55566508e-02f, -6.25948533e-02f, 1.05995601e-02f, 4.41523679e-02f, -5.62219024e-02f, -2.50589382e-02f, -1.66511759e-02f, -2.76130950e-03f,
  3.27819772e-02f, -8.11594874e-02f, -4.59535122e-02f, -4.87026945e-02f, 5.74688576e-02f, -5.19813560e-02f, -4.68525179e-02f, 9.85614806e-02f, 9.30303186e-02f, 5.07727489e-02f,
  -1.34958684e-01f, 1.53076202e-01f, -6.68642074e-02f, -8.67872834e-02f, -5.77771403e-02f, -3.39676887e-02f, 4.00639810e-02f, 5.67180179e-02f, 1.56801881e-03f, -7.25557655e-03f,
  2.59975530e-02f, 6.64969087e-02f, 8.69448856e-02f, 2.66517326e-02f, 7.42473379e-02f, -3.53066735e-02f, 2.88889650e-02f, -5.87095618e-02f, -1.62819400e-02f, 8.13060161e-03f,
  1.28465127e-02f, -1.77963331e-01f, -1.43814281e-01f, -6.48662075e-02f, -1.14826471e-01f, -1.78144023e-01f, -1.18214227e-01f, -1.60218552e-01f, -2.51476150e-02f, -1.02024995e-01f,
  -1.23164386e-01f, 1.77595362e-01f, 1.16189554e-01f, 2.37831436e-02f, 5.54717612e-04f, 2.65434589e-02f, -8.89003184e-03f, 6.47732243e-02f, -5.62603287e-02f, 1.15047567e-01f,
  5.83418086e-02f, -3.69110052e-03f, 5.34774140e-02f, -7.43189529e-02f, -1.25043154e-01f, 1.15191966e-01f, -6.03734814e-02f, -1.14654109e-01f, -2.13533998e-01f, -3.00082508e-02f,
  -1.30299807e-01f, -1.31911814e-01f, -2.19736233e-01f, -1.62350029e-01f, 1.16379395e-01f, -6.77792281e-02f, 9.16737225e-03f, -7.31197968e-02f, 9.27129388e-02f, 7.19010532e-02f,
  3.47636670e-01f, 3.98564339e-02f, 1.79501884e-02f, -1.08959608e-01f, -1.54613033e-02f, -4.54328805e-02f, -9.44928918e-03f, -5.79557419e-02f, -5.87329865e-02f, -3.91608141e-02f,
  -1.50649669e-02f, 4.78901416e-02f, 6.54307008e-03f, 1.78666376e-02f, -3.36609483e-02f, 6.87527061e-02f, -6.26096800e-02f, -3.69846597e-02f, 3.90695818e-02f, -3.98887098e-02f,
  3.18295807e-02f, -2.46925112e-02f, -1.91774257e-02f, 1.20686442e-01f, 6.36420259e-03f, -8.45519826e-02f, 5.44961262e-03f, 5.38350977e-02f, 8.53616968e-02f, 4.65839989e-02f,
  3.67381684e-02f, 3.02223396e-02f, 7.39363655e-02f, 3.81787377e-03f, -5.47912307e-02f, 8.64701271e-02f, 4.77997661e-02f, -5.75518087e-02f, -5.64967766e-02f, -3.50359529e-02f,
  4.09705639e-02f, 2.74706036e-02f, -1.56786013e-02f, -6.68671215e-03f, 4.66700792e-02f, -4.35184203e-02f, -2.60064062e-02f, -3.63014936e-02f, -5.15967458e-02f, -2.69462001e-02f,
  8.32059085e-02f, -1.95505600e-02f, -1.41818672e-02f, 4.32042293e-02f, 2.46565975e-02f, -4.86246496e-02f, -5.43847233e-02f, -2.55889241e-02f, 4.07081358e-02f, -3.84842344e-02f,
  1.34441823e-01f, -7.19898790e-02f, 7.87844211e-02f, -2.70005539e-02f, 7.79485479e-02f, -1.22506106e-02f, 5.12533374e-02f, -1.32690808e-02f, 6.23697089e-03f, 3.81063707e-02f,
  1.41311409e-02f, -8.75985529e-03f, 5.51643409e-02f, -2.33552530e-02f, -2.29558963e-02f, -2.36614738e-02f, -2.26706062e-02f, -6.20984659e-02f, -1.63100641e-02f, 1.10080138e-01f,
  -7.14102983e-02f, -1.59325320e-02f, 4.39664535e-02f, 1.65510958e-03f, 1.15424648e-01f, 8.04319903e-02f, 1.61178440e-01f, 3.03436667e-02f, 6.05779476e-02f, 7.22695142e-02f,
  1.05918132e-01f, -2.45693594e-01f, -3.49154621e-01f, -1.61781996e-01f, -1.91975206e-01f, -6.22693300e-02f, -7.22445473e-02f, 6.33950457e-02f, 8.67012963e-02f, -2.04783574e-01f,
  -2.20647007e-01f, -1.05814962e-02f, -7.42265061e-02f, 2.58279555e-02f, 4.57964987e-02f, -5.37723601e-02f, -1.02196775e-01f, -6.70103109e-05f, 2.49954402e-01f, 5.31357117e-02f,
  8.06566253e-02f, 4.92485873e-02f, 3.75394933e-02f, 6.44806307e-03f, -1.30338743e-01f, -3.96690518e-03f, -6.32130578e-02f, -9.54580307e-02f, -1.09386817e-02f, -2.10809335e-01f,
  -3.25764537e-01f, -1.54201403e-01f, 1.32402331e-01f, 8.36148709e-02f, -1.33959144e-01f, 7.76114836e-02f, -4.22580689e-02f, 2.47039832e-02f, 6.46243989e-02f, -5.78027852e-02f,
  -1.17440164e-01f, 2.09958176e-03f, -1.29847944e-01f, 3.65831181e-02f, 9.32229608e-02f, 1.27574712e-01f, 1.28066078e-01f, 8.85001421e-02f, 1.16476238e-01f, -3.13830338e-02f,
  -3.55987288e-02f, -1.15136333e-01f, 6.70106336e-03f, 3.74292694e-02f, 6.68450445e-02f, -1.45131268e-03f, -1.07337117e-01f, -4.49596569e-02f, 5.93449026e-02f, -5.12463972e-02f,
  9.25877038e-03f, -7.14088380e-02f, 2.25886963e-02f, 5.84153980e-02f, -4.66328958e-04f, -5.96943386e-02f, -3.39030214e-02f, -1.60438400e-02f, 6.06203778e-03f, 3.01969592e-02f,
  5.32686524e-02f, 1.24378819e-02f, 8.49690463e-04f, -8.37573782e-04f, -5.59979938e-02f, -9.51455683e-02f, 6.25579711e-03f, 2.95778476e-02f, -1.59744788e-02f, 1.70030184e-02f,
  7.46073350e-02f, -2.79749110e-02f, 5.57816252e-02f, -1.01104993e-02f, -2.21305992e-03f, 9.52916499e-03f, -3.92923616e-02f, -4.31967229e-02f, -1.23250410e-02f, 2.86778957e-02f,
  2.45043058e-02f, 1.35345742e-01f, -2.08024550e-02f, 2.37132367e-02f, -9.79603454e-02f, -8.28561001e-03f, -3.15508619e-02f, 5.51386960e-02f, -1.00649029e-01f, -7.17163458e-02f,
  1.31264068e-02f, 3.95843871e-02f, -1.93039533e-02f, 3.36348936e-02f, 2.18526497e-02f, 7.61631727e-02f, -4.73856702e-02f, -2.14390401e-02f, 1.06913909e-01f, -1.78149827e-02f,
  -1.82063244e-02f, 1.43574044e-01f, 6.75606877e-02f, -1.68268755e-02f, 1.01468429e-01f, 7.83156231e-02f, -3.94411199e-02f, 1.21322833e-01f, 5.49541339e-02f, 1.93560869e-01f,
  1.29247442e-01f, -8.07569250e-02f, 1.79510430e-01f, 9.73020196e-02f, 6.00158013e-02f, 1.94831882e-02f, 9.22892615e-02f, -7.63626844e-02f, -3.14205438e-02f, -8.60925764e-02f,
  -1.35729343e-01f, -1.99490011e-01f, -1.80315733e-01f, 4.17342875e-03f, -2.43999138e-02f, 2.18700450e-02f, 2.58489311e-01f, 1.74354404e-01f, 1.03800721e-01f, 1.13951497e-01f,
  3.02509554e-02f, 1.28520757e-01f, 1.22360393e-01f, 7.44236261e-02f, 3.76471840e-02f, -3.42505425e-02f, 1.25153223e-02f, 1.06995724e-01f, 3.39823067e-02f, 2.52493948e-01f,
  -6.47757798e-02f, -6.89453855e-02f, -3.81122679e-02f, -6.08312637e-02f, -5.98068023e-03f, 6.74743801e-02f, -6.44531995e-02f, -2.80334987e-03f, -3.55461426e-02f, 1.56865418e-02f,
  3.45483087e-02f, 1.48642971e-03f, -1.04368113e-01f, 2.80886535e-02f, 5.86733781e-02f, -4.23319638e-03f, -9.08995792e-02f, -2.37432867e-02f, -8.67977738e-02f, -1.76774859e-02f,
  -1.18608147e-01f, 3.03052329e-02f, 2.60501616e-02f, -8.46476033e-02f, 1.63198560e-02f, -8.91794860e-02f, 2.11371984e-02f, -2.24159425e-03f, 2.33901702e-02f, -4.86423559e-02f,
  7.07436427e-02f, -5.33959689e-03f, -2.12805774e-02f, 1.96981318e-02f, -4.18299586e-02f, 4.99396697e-02f, -3.81568186e-02f, -1.45924138e-02f, -3.84368724e-03f, -1.15352571e-02f,
  -6.90067932e-02f, -1.48225175e-02f, 3.19928788e-02f, 9.10904929e-02f, -1.69348996e-02f, 4.93774787e-02f, 3.44152898e-02f, -1.09032311e-01f, 1.82763841e-02f, -1.21756447e-02f,
  1.52470218e-02f, -6.44174293e-02f, 2.06168089e-02f, 5.94808944e-02f, -7.14621097e-02f, 8.78675804e-02f, -3.97406593e-02f, -4.49038222e-02f, -1.22355474e-02f, -4.84621003e-02f,
  -1.39894024e-01f, -9.35618579e-02f, 1.21462345e-01f, 1.02199890e-01f, -2.87719835e-02f, -5.33164144e-02f, -3.68184336e-02f, 1.97669342e-02f, 3.54607054e-03f, 8.06193277e-02f,
  -8.48950073e-02f, -5.53255342e-02f, -6.86678216e-02f, 7.44918585e-02f, 9.33391824e-02f, -7.19350204e-02f, 9.53468494e-03f, 1.05179407e-01f, 3.19892801e-02f, 2.02344153e-02f,
  -1.91732291e-02f, 4.55989949e-02f, -1.05234049e-02f, -8.27634484e-02f, 4.38042730e-02f, 1.13972125e-03f, 1.21048586e-02f, 8.80639255e-02f, 4.85891476e-02f, 6.74552247e-02f,
  2.69425362e-01f, -2.44662061e-01f, 3.90890911e-02f, 3.82569581e-02f, -1.36230543e-01f, -1.14599004e-01f, -2.08074421e-01f, -1.18491910e-01f, 8.72585922e-02f, -1.33999169e-01f,
  -1.29234493e-01f, 4.00800630e-02f, 1.34627789e-01f, 7.47523531e-02f, -1.60392933e-02f, -1.29849389e-01f, -6.07694201e-02f, 1.91336319e-01f, 1.21177040e-01f, 1.21330239e-01f,
  -2.25168709e-02f, 1.45601451e-01f, 1.48389354e-01f, 1.53767420e-02f, -2.01236140e-02f, -1.93179455e-02f, -9.41939801e-02f, -1.07659893e-02f, -1.55008554e-01f, -1.65838718e-01f,
  1.33814007e-01f, -5.73996417e-02f, 1.23241410e-01f, 1.26082739e-02f, 6.16601333e-02f, -5.56496903e-03f, -8.81066173e-03f, -2.54615750e-02f, 1.57039780e-02f, -5.60021177e-02f,
  -3.66010927e-02f, -4.91604395e-02f, 6.83776587e-02f, -4.83233854e-02f, 1.61279589e-02f, 6.13218993e-02f, 1.16255432e-01f, 1.17996484e-01f, 8.67808610e-03f, -5.07262982e-02f,
  -2.13250685e-02f, -3.86773348e-02f, 6.66920692e-02f, -4.12890613e-02f, 5.52967303e-02f, 3.20652910e-02f, -7.90333070e-06f, -7.43977576e-02f, -7.18013495e-02f, 2.15593558e-02f,
  -8.07596138e-04f, -1.14385970e-02f, -7.32235685e-02f, -4.87556793e-02f, -2.68878620e-02f, 1.18086450e-02f, 1.99164785e-02f, 2.99994629e-02f, 4.91412729e-02f, 1.17966067e-02f,
  -3.22906044e-03f, -2.38835495e-02f, 8.50067884e-02f, 9.47349146e-02f, -5.79806603e-03f, -1.34186512e-02f, -2.83852872e-02f, -9.58173797e-02f, 4.39875498e-02f, 6.14703260e-02f,
  3.22209597e-02f, -6.34763390e-02f, 1.02962526e-02f, 2.72177020e-03f, -8.82395804e-02f, 3.21107730e-02f, 7.62603059e-02f, -1.55200541e-03f, 3.59452739e-02f, 8.79066885e-02f,
  1.51641399e-01f, 4.32271101e-02f, -3.61863035e-03f, 5.55520989e-02f, 4.54854220e-03f, -7.76719376e-02f, -2.60323193e-02f, 2.54439209e-02f, 1.86066963e-02f, 7.55778924e-02f,
  -3.53705250e-02f, 4.60668281e-02f, 3.76377143e-02f, 8.42147171e-02f, 7.38570914e-02f, 9.71699134e-02f, 5.28591201e-02f, 5.78380302e-02f, -3.94048132e-02f, -5.74915260e-02f,
  1.44348561e-03f, 5.27216643e-02f, 1.44020781e-01f, 1.03674911e-01f, 2.02766918e-02f, 1.43090367e-01f, 1.35163777e-03f, 1.02075636e-01f, 7.76221007e-02f, -3.41609977e-02f,
  -4.42431837e-01f, 1.74595803e-01f, 2.71143109e-01f, -9.32546631e-02f, 2.26955995e-01f, 2.93769777e-01f, 4.22950059e-01f, 3.03020491e-03f, -1.30688101e-01f, 1.94325611e-01f,
  -2.99016759e-02f, -1.49550468e-01f, -1.66073620e-01f, -1.46054804e-01f, -1.00769885e-01f, 1.80664912e-01f, 2.38542527e-01f, -1.94225051e-02f, -9.94250551e-02f, -6.64335722e-03f,
  5.37090935e-03f, -1.16760157e-01f, -2.72526473e-01f, -1.04911171e-01f, -5.10843508e-02f, 4.85750847e-02f, 1.49645790e-01f, -3.87534797e-02f, 6.19942844e-02f, 1.42463923e-01f,
  2.61269599e-01f, -1.33038759e-01f, 5.18255569e-02f, -1.23695023e-01f, -1.55683672e-02f, -3.35458554e-02f, -3.75350891e-03f, -1.03741683e-01f, -4.32542805e-03f, -1.44975018e-02f,
  -1.42264776e-02f, -7.32890069e-02f, -6.01069480e-02f, 1.32600321e-02f, 3.04650813e-02f, -4.03652117e-02f, 1.33714732e-03f, -1.11728795e-01f, -1.11343108e-01f, -3.67440209e-02f,
  6.89325854e-02f, 1.01962328e-01f, 1.06599681e-01f, -6.74089640e-02f, -5.06361015e-02f, -3.82032879e-02f, -4.73513678e-02f, -1.42848819e-01f, -5.05359881e-02f, 1.51985567e-02f,
  3.44759412e-02f, 5.77016287e-02f, 8.50502495e-03f, -5.64625151e-02f, -4.08500209e-02f, 2.68481858e-03f, 9.50466692e-02f, 1.76373608e-02f, -7.32287019e-02f, 4.48970944e-02f,
  -5.50252236e-02f, 4.08947356e-02f, -6.12864755e-02f, 2.93439515e-02f, 1.49845574e-02f, -2.29037665e-02f, 2.42507569e-02f, -3.20319906e-02f, -4.73599918e-02f, -4.79600951e-03f,
  -5.15579395e-02f, -2.79555973e-02f, 3.23504545e-02f, -7.11136013e-02f, -1.70730259e-02f, -1.78864505e-02f, 8.76589771e-03f, -5.01944311e-02f, 2.43453961e-02f, 3.60977389e-02f,
  -8.06435496e-02f, 2.84312069e-02f, 4.08204943e-02f, -7.94480667e-02f, 4.46749292e-02f, -5.16242832e-02f, 2.10367702e-02f, -1.44607564e-02f, -4.75235842e-02f, 1.57665100e-03f,
  2.37231422e-03f, -6.43951371e-02f, 4.03456427e-02f, 4.64659892e-02f, -2.86463313e-02f, 5.14609888e-02f, -5.41008189e-02f, -1.98529493e-02f, -7.08801374e-02f, 4.45342474e-02f,
  -2.66369916e-02f, 1.00626729e-01f, -2.38171536e-02f, 8.33949000e-02f, -1.63528323e-02f, 8.01850483e-02f, 2.06205890e-01f, 3.40769114e-03f, 1.26210958e-01f, 2.07229003e-01f,
  -3.16208541e-01f, -2.07842499e-01f, -1.95896387e-01f, 2.22836323e-02f, 2.75735795e-01f, 5.40026054e-02f, 9.49539542e-02f, -7.56573901e-02f, 6.62884712e-02f, 3.06278225e-02f,
  3.58729996e-02f, 5.56110293e-02f, -2.42690649e-02f, 1.82263386e-02f, -9.83049124e-02f, -1.86168224e-01f, -1.70849249e-01f, -7.96189681e-02f, -1.31840017e-02f, 1.45533651e-01f,
  2.20996529e-01f, -4.85926978e-02f, -1.55843332e-01f, -9.89112332e-02f, 1.35450199e-01f, 1.14482112e-01f, -5.44982329e-02f, 9.34495181e-02f, 5.19496538e-02f, -8.33766311e-02f,
  1.96462162e-02f, -1.48648262e-01f, 1.29480129e-02f, 7.23555163e-02f, 4.01751772e-02f, 2.40098760e-02f, 4.39381264e-02f, -7.77817890e-02f, 4.86734929e-03f, -8.52380469e-02f,
  7.56897107e-02f, 3.53176966e-02f, -9.02265310e-03f, -5.30660013e-03f, 5.21019399e-02f, -1.17339278e-02f, -1.74760655e-01f, -1.79902896e-01f, -8.82825181e-02f, 4.18071933e-02f,
  7.57484213e-02f, 1.08587265e-01f, -2.86071543e-02f, -6.03705533e-02f, -1.06074303e-01f, -2.25159973e-02f, 1.18839797e-02f, -1.74966324e-02f, -8.36403146e-02f, -2.62061507e-02f,
  -3.65146057e-04f, 2.87830550e-02f, -7.59345070e-02f, 2.56471289e-03f, 6.03605807e-02f, -4.92061600e-02f, 3.79350148e-02f, 2.38471851e-02f, 2.14168821e-02f, 8.47168209e-04f,
  1.99107323e-02f, -1.10290097e-02f, -5.55696078e-02f, -9.42936074e-03f, -1.38626341e-02f, 5.32774255e-02f, -4.24562730e-02f, 3.50542143e-02f, -5.94655424e-02f, -6.38744161e-02f,
  3.94301526e-02f, -4.60845269e-02f, 4.43734750e-02f, -1.29253475e-03f, -1.04754351e-01f, -7.35810818e-03f, -1.80258956e-02f, -3.77126969e-02f, -2.19891639e-03f, 4.44732867e-02f,
  7.44239464e-02f, -1.47889137e-01f, 2.65959161e-03f, 8.63930769e-03f, 4.16926444e-02f, -3.56300697e-02f, 2.53121760e-02f, -5.25495298e-02f, -3.34445573e-02f, 8.63199010e-02f,
  -2.45200898e-02f, 4.94361520e-02f, 6.39557540e-02f, -2.84922905e-02f, 1.24062181e-01f, 9.64103937e-02f, -5.86164929e-02f, -3.73063050e-02f, 1.16081089e-02f, 7.45854080e-02f,
  -6.62896559e-02f, 2.84250407e-03f, -5.94003946e-02f, -7.21487179e-02f, 4.82100584e-02f, 2.15017702e-02f, 5.50854467e-02f, 4.30681705e-02f, -1.06633008e-01f, 1.19671971e-02f,
  -3.28721076e-01f, -2.94768512e-01f, 3.39392662e-01f, -2.86784232e-01f, -1.78435266e-01f, -7.94037953e-02f, -1.76403433e-01f, -1.99394487e-02f, -1.57759160e-01f, -1.78019673e-01f,
  1.22283846e-02f, 5.23544811e-02f, 7.06473887e-02f, 1.14845224e-01f, 2.00731978e-01f, 8.26252345e-03f, 1.11610748e-01f, 1.41116008e-01f, 2.77630955e-01f, -7.21236765e-02f,
  -1.16893031e-01f, -1.12392806e-01f, -9.20804292e-02f, -6.43402934e-02f, -1.23246267e-01f, -4.42532785e-02f, 7.63561353e-02f, -4.68479618e-02f, 7.65807852e-02f, -1.05530441e-01f,
  2.17185095e-01f, -1.19458206e-01f, 1.29412502e-01f, -9.10964981e-02f, -3.24289985e-02f, -2.67869942e-02f, -2.70959400e-02f, -1.99695230e-02f, -4.89528328e-02f, 4.32701921e-03f,
  2.73928735e-02f, -5.34285046e-02f, 5.89653552e-02f, -6.02387786e-02f, -1.03636369e-01f, -3.37880291e-02f, -5.12060411e-02f, 5.50276861e-02f, 9.19224545e-02f, -2.71823374e-03f,
  -1.38673127e-01f, -4.35299277e-02f, 8.77835155e-02f, 8.57463703e-02f, 1.16361134e-01f, 1.21881232e-01f, -2.84649581e-02f, -2.95025799e-02f, 1.22700162e-01f, -1.61997512e-01f,
  -2.62622833e-02f, 2.53054760e-02f, 7.15985447e-02f, -3.58191542e-02f, -2.87669208e-02f, 6.47122636e-02f, -2.58738585e-02f, 1.91604719e-02f, -6.75914809e-02f, -2.70424373e-02f,
  3.62132974e-02f, -2.17915606e-02f, 5.48499934e-02f, -5.90520017e-02f, 1.38657894e-02f, -8.39152280e-03f, -3.98919061e-02f, -2.44473275e-02f, -2.16741525e-02f, 1.52108883e-02f,
  2.14852132e-02f, 4.73490655e-02f, -5.29021025e-02f, 8.11042115e-02f, 9.30347964e-02f, -4.07329388e-02f, -4.08268832e-02f, 7.60300383e-02f, 3.09594385e-02f, -9.98155549e-02f,
  -1.45879015e-01f, 2.39754364e-01f, -9.18622245e-04f, -3.21885161e-02f, -2.68693231e-02f, -3.66033949e-02f, 2.44749803e-02f, -1.78683680e-02f, 7.83354789e-02f, -7.42868483e-02f,
  -3.52302473e-03f, 2.09316108e-02f, -7.11352080e-02f, 4.87516038e-02f, 3.75702605e-02f, 5.47490604e-02f, -1.40895084e-01f, 7.93354437e-02f, -1.65496822e-02f, -7.08882809e-02f,
  -3.63527164e-02f, -4.80249152e-02f, -1.09732047e-01f, -5.03514037e-02f, -6.85359258e-03f, 1.45922066e-03f, 1.31820877e-06f, -3.74199264e-02f, 4.88826782e-02f, -1.37220055e-01f,
  3.51192653e-02f, 1.01479053e-01f, -4.49824855e-02f, -1.89398170e-01f, 1.13505591e-02f, 1.49651155e-01f, 1.66941673e-01f, 1.60932541e-02f, -1.04332663e-01f, -9.08076763e-02f,
  1.90754645e-02f, 3.14197764e-02f, -3.84090170e-02f, 3.29975598e-02f, 2.00682923e-01f, -6.65680543e-02f, -1.00438409e-01f, 9.90920216e-02f, 1.09649912e-01f, 1.58289611e-01f,
  2.89568715e-02f, -1.26478776e-01f, 7.48380274e-02f, -3.46182473e-02f, -1.04744755e-01f, -6.94827437e-02f, -9.84643251e-02f, -5.17862849e-03f, -4.16543074e-02f, -1.40714437e-01f,
  1.25889247e-02f, 1.11887075e-01f, 2.55485065e-03f, 7.09226876e-02f, -6.51234984e-02f, 2.66525224e-02f, -1.88835543e-02f, -7.31165260e-02f, 5.61347753e-02f, 2.29818970e-02f,
  -1.56101575e-02f, 8.66642967e-02f, 3.26104797e-02f, -7.10192546e-02f, 1.42477257e-02f, 7.32243955e-02f, 6.45668805e-03f, 8.99958536e-02f, -6.92066178e-02f, 7.03813434e-02f,
  -1.69838816e-02f, 1.03866249e-01f, 6.52481392e-02f, -9.24669858e-03f, 7.21118180e-03f, -3.64944227e-02f, 9.90501866e-02f, 4.51987749e-03f, 4.54026945e-02f, -1.29925355e-01f,
  1.11277550e-02f, -4.76119518e-02f, -4.66479957e-02f, -2.16115755e-03f, -2.48596212e-03f, -1.12548865e-01f, 3.22607085e-02f, 7.68975867e-03f, -6.59059510e-02f, -9.94287655e-02f,
  -3.85092907e-02f, 5.09193838e-02f, -8.01866949e-02f, -5.77698424e-02f, 2.99838092e-02f, -2.76171789e-02f, -3.58629152e-02f, 1.16033480e-02f, -6.60724491e-02f, 2.59262361e-02f,
  -3.85191105e-02f, 5.54049574e-02f, -3.64275984e-02f, 4.98138368e-02f, 5.48054948e-02f, 6.04013680e-03f, -6.73168376e-02f, -3.73801924e-02f, 4.64422107e-02f, -4.95364927e-02f,
  -1.50534332e-01f, 1.32755533e-01f, -2.74037216e-02f, 9.32813957e-02f, -5.75514836e-03f, -1.05125119e-03f, -9.62489098e-02f, 1.73393674e-02f, 2.87040845e-02f, -4.31070328e-02f,
  1.07258782e-01f, -1.64950341e-02f, -6.19582571e-02f, 3.58649925e-03f, -5.11016846e-02f, 4.76073585e-02f, -9.11206827e-02f, 6.07291535e-02f, 2.25741994e-02f, -8.80629420e-02f,
  -1.22026158e-02f, 6.12360388e-02f, 1.17997780e-01f, -2.30523990e-03f, -7.45137036e-02f, 6.95036203e-02f, 6.22799210e-02f, -6.33542910e-02f, 5.56874555e-03f, -8.70473981e-02f,
  2.97944218e-01f, 1.54990479e-01f, 7.71273077e-02f, 3.09110135e-02f, -1.17755778e-01f, 3.27134654e-02f, 2.20478132e-01f, 1.34578437e-01f, 6.28551543e-02f, 1.37108058e-01f,
  -5.33809476e-02f, -1.38368875e-01f, -3.90915163e-02f, 5.47457375e-02f, -1.89881623e-02f, 6.48931116e-02f, 9.62393731e-02f, 8.33792239e-02f, 1.07062750e-01f, 3.04113254e-02f,
  -1.25996433e-02f, -2.85709687e-02f, -1.71222650e-02f, -6.54616579e-02f, -1.45170629e-01f, -1.00560270e-01f, -3.97481695e-02f, 4.85097524e-03f, -6.81084767e-02f, 3.02968491e-02f,
  3.04311570e-02f, -5.49385995e-02f, -5.43614402e-02f, -6.72724470e-02f, -1.37247428e-01f, 4.39794324e-02f, 8.71658176e-02f, -7.68080801e-02f, -4.76302765e-02f, -1.36550451e-02f,
  -8.02271888e-02f, -6.79691732e-02f, -1.21099778e-01f, -3.68663371e-02f, -4.70203422e-02f, 1.03942035e-02f, -3.55072953e-02f, -5.51091023e-02f, 1.64581276e-02f, -1.17218867e-01f,
  -1.53418481e-01f, 1.38520803e-02f, -3.51715721e-02f, -1.26163540e-02f, 3.36907990e-03f, -5.86958677e-02f, -8.14484730e-02f, -1.25815213e-01f, 6.90274015e-02f, 2.91150827e-02f,
  3.38454135e-02f, -5.83441406e-02f, -7.19627663e-02f, 1.00553529e-02f, 3.83505858e-02f, -4.14240137e-02f, 1.55203568e-03f, 7.27932155e-02f, 5.96054792e-02f, 2.22041029e-02f,
  6.13876320e-02f, 1.31158056e-02f, 4.64038104e-02f, 1.90391317e-02f, -2.53827013e-02f, -4.47889678e-02f, -5.83097758e-03f, 2.51615345e-02f, -5.76242954e-02f, -2.75403559e-02f,
  -2.48345565e-02f, -5.35361469e-02f, 2.98940833e-03f, 4.15403694e-02f, 2.70563215e-02f, -5.25896139e-02f, -1.26573043e-02f, -9.84887872e-03f, -7.39359781e-02f, 5.80987744e-02f,
  2.44687051e-01f, -5.85801806e-03f, 1.40458658e-01f, 8.14610496e-02f, -6.18260391e-02f, -8.35039243e-02f, -2.77055409e-02f, 5.96867269e-03f, -6.44351766e-02f, 5.17448410e-02f,
  -3.90323810e-02f, 8.41297656e-02f, 1.35761891e-02f, -5.16143031e-02f, 6.35051727e-02f, 2.71512493e-02f, 1.13743111e-01f, 7.10537061e-02f, -2.98113599e-02f, -8.66068974e-02f,
  -2.65767723e-02f, 1.36517391e-01f, 2.47472733e-01f, 1.58396542e-01f, -3.94437723e-02f, 1.44364968e-01f, 1.02139696e-01f, 1.27043143e-01f, 1.14627540e-01f, 4.00031745e-01f,
  1.28404930e-01f, -1.80758715e-01f, 4.88607436e-02f, 7.15907812e-02f, 1.05855964e-01f, 1.00138955e-01f, -3.63758467e-02f, -2.92953998e-02f, -3.89076769e-02f, -2.77610216e-03f,
  1.05121382e-01f, 1.06624648e-01f, 2.24245861e-02f, -9.20579657e-02f, -1.29254207e-01f, -1.45222321e-01f, -6.31952509e-02f, -1.35782555e-01f, -1.42907212e-02f, 2.47676950e-02f,
  -2.92850602e-02f, -2.59075183e-02f, -2.56193336e-02f, -1.08990707e-01f, -1.96369067e-01f, -1.02757268e-01f, -1.27162561e-01f, 3.82709689e-02f, -1.16873942e-01f, -2.08231539e-01f,
  -2.06641614e-01f, 1.68793619e-01f, 1.05122989e-02f, 6.04310296e-02f, 1.05828986e-01f, 9.16509237e-03f, 2.66116410e-02f, 9.99181718e-03f, 8.00267458e-02f, -4.92172018e-02f,
  1.00889683e-01f, -3.06355562e-02f, -5.46287224e-02f, 3.73782329e-02f, 1.35852105e-03f, -2.60692313e-02f, 5.08678295e-02f, 3.77463214e-02f, 9.57865193e-02f, 4.78045978e-02f,
  1.47475973e-02f, 1.27205461e-01f, 1.43188015e-01f, 6.03094213e-02f, -2.94187684e-02f, 7.71902353e-02f, -7.61826932e-02f, 3.46548632e-02f, 6.17808253e-02f, -1.92072511e-01f,
  9.37779434e-03f, -3.50102559e-02f, 5.46525493e-02f, -7.33289272e-02f, -1.51233226e-02f, 9.76822618e-03f, -3.67871560e-02f, -6.24933690e-02f, -9.68342833e-03f, -2.52748444e-03f,
  5.86853828e-03f, -3.09044477e-02f, 2.46460196e-02f, -1.79021936e-02f, 3.63706276e-02f, 2.29403470e-02f, -4.41158712e-02f, -7.23071024e-02f, 1.06695015e-02f, -1.28027275e-02f,
  -1.03412401e-02f, 7.53992647e-02f, -4.78240196e-03f, -4.13228478e-03f, -3.45473480e-03f, -2.91984547e-02f, 4.43821587e-02f, 2.98515391e-02f, -4.27972600e-02f, 3.32399714e-03f,
  -1.02347381e-01f, 2.25949064e-01f, -1.11775838e-01f, -5.76390401e-02f, -1.54021448e-02f, 1.27104353e-02f, 2.03936975e-02f, 6.25932515e-02f, 1.24353115e-02f, -2.86110099e-02f,
  7.85638615e-02f, 2.65114661e-02f, -1.67830754e-02f, 1.12095026e-04f, -1.50593957e-02f, -4.16167676e-02f, -1.65812671e-02f, -4.92749587e-02f, -5.57449795e-02f, 4.70469557e-02f,
  -5.14740795e-02f, -5.81333786e-02f, -3.55829708e-02f, -1.71049953e-01f, -1.51796192e-02f, -1.47466257e-01f, -1.87414542e-01f, -1.20369516e-01f, -2.04690695e-01f, -4.13341373e-01f,
  8.77229199e-02f, 2.74404645e-01f, 1.95628062e-01f, -8.23871568e-02f, 2.00376883e-02f, 7.58395195e-02f, 2.25911692e-01f, 1.06948670e-02f, 2.43208115e-03f, -4.72570769e-02f,
  1.77538712e-02f, -1.03450574e-01f, -6.99695721e-02f, 1.57073792e-03f, -1.68873295e-02f, 1.01226248e-01f, 2.01826170e-02f, 4.63913567e-02f, -9.94405523e-03f, 1.07891643e-02f,
  -1.81900095e-02f, 4.30546552e-02f, 7.67730996e-02f, -9.15794373e-02f, -4.49124426e-02f, -1.07253969e-01f, 8.22160989e-02f, -9.28296987e-03f, 9.32145938e-02f, -1.71414055e-02f,
  -1.17462277e-01f, 3.23232025e-01f, -8.75294134e-02f, -9.34657902e-02f, 7.42943436e-02f, 3.12759131e-02f, -2.80342400e-02f, -2.43709814e-02f, -1.74262319e-02f, -1.49996160e-02f,
  2.95315348e-02f, 1.10697402e-02f, -3.50429397e-03f, -3.65108177e-02f, 9.01771560e-02f, 2.04343144e-02f, -3.59003060e-02f, 6.66201189e-02f, 9.90626216e-02f, 3.09474878e-02f,
  8.25222358e-02f, 8.68184045e-02f, 7.70891085e-02f, 2.01782398e-02f, 1.13785967e-01f, -3.24703380e-02f, 8.88424590e-02f, 3.49652059e-02f, 1.49675533e-02f, -6.84530959e-02f,
  -9.01418626e-02f, -1.51143093e-02f, 1.64738502e-02f, -4.18512486e-02f, -7.77561441e-02f, 1.58951208e-02f, -1.73384193e-02f, -4.53233421e-02f, -4.59005870e-03f, 5.41904233e-02f,
  -3.71921365e-03f, 4.96096388e-02f, -6.45388141e-02f, -6.20352402e-02f, -4.93592843e-02f, 8.72465968e-02f, 2.99667865e-02f, -3.51819731e-02f, -4.40084189e-02f, 6.76300004e-02f,
  6.84231669e-02f, 1.17740603e-02f, 5.61016239e-02f, -5.62718697e-02f, 4.69338372e-02f, 5.86660765e-02f, -2.51364652e-02f, 1.22683821e-02f, -1.99315604e-02f, -4.73382324e-03f,
  -1.50333971e-01f, 1.28681526e-01f, -5.84240258e-02f, 4.98726405e-03f, -2.98580881e-02f, -2.67961454e-02f, -1.11151012e-02f, -7.64318975e-03f, -1.54390717e-02f, 2.81909872e-02f,
  6.64757118e-02f, 4.05837223e-02f, 8.33092183e-02f, -4.64628339e-02f, -7.62865469e-02f, -7.26220384e-02f, 3.25711560e-03f, 3.82685252e-02f, -1.30034415e-02f, -3.85983698e-02f,
  -9.49663520e-02f, -5.70004396e-02f, -1.15617275e-01f, -1.04683593e-01f, 1.78862195e-02f, -1.42082274e-01f, -2.16333847e-02f, -1.28364742e-01f, -7.87839592e-02f, -1.71186656e-01f,
  3.46025944e-01f, 5.82344569e-02f, -1.53740972e-01f, 2.11396138e-03f, 3.23396996e-02f, 4.43717092e-03f, -5.36891147e-02f, 1.81211799e-01f, 1.36468679e-01f, 4.79038879e-02f,
  3.54705937e-02f, -9.25608799e-02f, 3.15076821e-02f, 2.30367165e-02f, 5.19110039e-02f, -7.53023252e-02f, 2.24329606e-02f, -4.35134843e-02f, 4.43900675e-02f, -1.02102362e-01f,
  6.17670361e-03f, -6.74989149e-02f, -7.37932790e-03f, 8.44289735e-02f, -4.57728282e-02f, -1.05969831e-01f, 2.32401434e-02f, -9.08671767e-02f, -2.66990643e-02f, 3.63764178e-04f,
  -2.00828686e-01f, 2.52925247e-01f, -1.51081979e-01f, 8.26019868e-02f, -7.12770969e-02f, 1.05067290e-01f, -2.19135936e-02f, 1.09676989e-02f, -1.24934008e-02f, 6.52490109e-02f,
  3.19715254e-02f, 6.27681985e-02f, 1.05266683e-01f, 9.37541947e-02f, -4.83394377e-02f, 8.18051845e-02f, 1.76311340e-02f, 1.47846743e-01f, 5.49626164e-02f, 7.46017322e-02f,
  5.81216589e-02f, 7.40966126e-02f, 1.36648919e-02f, 3.11742835e-02f, 5.55973798e-02f, 2.01313831e-02f, -5.32658137e-02f, 1.21555952e-02f, 6.40075132e-02f, 5.75162470e-02f,
  -6.34310767e-02f, 6.60212487e-02f, -2.61780154e-02f, 4.74330522e-02f, 7.96882659e-02f, -5.93850799e-02f, -1.35160210e-02f, -7.37041309e-02f, -5.68240173e-02f, -4.55684476e-02f,
  -2.93125696e-02f, -2.94657554e-02f, 3.02280951e-03f, 6.31280318e-02f, -7.42129311e-02f, -2.30328850e-02f, -4.50685658e-02f, 1.59680154e-02f, -3.15323472e-02f, -1.76082272e-02f,
  4.71283495e-02f, -2.96881609e-02f, 2.60303058e-02f, -6.98089823e-02f, -4.44320701e-02f, -5.99842295e-02f, 1.01949871e-01f, 1.00601241e-01f, -1.87531821e-02f, 1.19752839e-01f,
  -6.91227168e-02f, 4.42733206e-02f, -8.98006037e-02f, 3.54847126e-02f, -4.80013303e-02f, -8.02792460e-02f, -1.17192632e-02f, -2.16894187e-02f, -8.16850457e-03f, -7.63420761e-03f,
  6.45999312e-02f, -5.19051291e-02f, -2.86542382e-02f, 1.28541561e-03f, -6.41718041e-03f, 1.11480728e-02f, 3.67415063e-02f, -8.64811689e-02f, -7.57010430e-02f, 8.00048932e-02f,
  -8.98002461e-02f, -8.80947858e-02f, -3.74436043e-02f, -1.38221011e-01f, -6.60861582e-02f, -2.73985527e-02f, -1.05291933e-01f, -1.46359010e-02f, 1.36147281e-02f, -1.15512662e-01f,
  -1.41270265e-01f, -4.16248888e-01f, 2.71717131e-01f, -2.03959197e-01f, -5.01295626e-02f, 1.02386869e-01f, 2.60115713e-02f, -2.45849080e-02f, -2.76909713e-02f, -2.51054317e-01f,
  -2.37194091e-01f, -1.02069400e-01f, 2.88973767e-02f, 1.32534549e-01f, 1.14448592e-01f, 4.38541025e-02f, 1.10371225e-01f, 3.71961147e-01f, 4.21119094e-01f, 1.85151070e-01f,
  -8.98876972e-03f, -9.81829688e-02f, 1.91331524e-02f, -3.46140340e-02f, -1.23868011e-01f, 7.15319859e-03f, -5.13184294e-02f, -1.52838707e-01f, -1.06460907e-01f, -2.66757876e-01f,
  6.73725456e-02f, -1.98202386e-01f, 2.35027120e-01f, -1.06372803e-01f, -2.13302728e-02f, -7.26752356e-02f, -1.00183599e-04f, -4.12097201e-02f, -1.23333760e-01f, -1.43383294e-02f,
  -5.97211979e-02f, 1.48360574e-04f, 1.56716090e-02f, -7.25899935e-02f, -1.81660540e-02f, -1.59959272e-02f, -1.45998616e-02f, 1.05250880e-01f, 9.13412049e-02f, 4.79340144e-02f,
  -1.57535896e-01f, 4.06547487e-02f, 8.98102596e-02f, 1.81232560e-02f, 1.20683827e-01f, 7.92375207e-02f, -4.61652428e-02f, 4.23380621e-02f, 3.98078933e-02f, -1.29362851e-01f,
  -3.22941318e-02f, 1.41128730e-02f, -3.64460722e-02f, -5.47552072e-02f, -1.55438362e-02f, 2.47362014e-02f, -3.38062011e-02f, -2.69936491e-02f, 3.07064243e-02f, -5.12154326e-02f,
  1.49743650e-02f, 1.33011844e-02f, -1.61452498e-02f, -5.59341796e-02f, -4.98293415e-02f, -3.33138034e-02f, 2.93695871e-02f, -8.63375887e-03f, 3.16767842e-02f, -2.05088314e-02f,
  4.93377708e-02f, 6.17335513e-02f, -5.10651506e-02f, -6.99149305e-03f, 3.44586037e-02f, 2.15123333e-02f, 7.13332416e-03f, 3.41259614e-02f, -4.31909487e-02f, -2.42188131e-03f,
  -1.11100189e-01f, 2.61532545e-01f, -1.36887534e-02f, 1.47850299e-02f, -5.29020280e-03f, 3.20746750e-02f, -2.04169285e-03f, -6.22074353e-03f, 4.45033703e-03f, 5.73639609e-02f,
  6.90924153e-02f, 2.14212108e-02f, -1.36495922e-02f, 1.50156347e-03f, 9.62046310e-02f, 2.26948620e-03f, -3.65794525e-02f, 3.01628299e-02f, 1.45106271e-01f, -7.81481266e-02f,
  4.49249037e-02f, 6.72750995e-02f, 7.66356140e-02f, 3.93950455e-02f, -2.06055921e-02f, 1.53720886e-01f, 3.97048779e-02f, 7.71385208e-02f, 1.88356891e-01f, -1.70043588e-01f,
  -5.62033474e-01f, 1.53984100e-01f, 1.87038600e-01f, -1.14779070e-01f, 1.19582184e-01f, 1.76518396e-01f, 1.28533661e-01f, 8.76903906e-02f, -1.20240942e-01f, 9.06601325e-02f,
  -2.40353048e-02f, -1.49879426e-01f, -1.03892706e-01f, -3.29546519e-02f, -9.63534266e-02f, 4.79477569e-02f, -2.71127820e-02f, -1.92081049e-01f, -1.78488597e-01f, -2.37374827e-02f,
  -4.10322100e-02f, -3.90170552e-02f, -2.03488052e-01f, -2.31978297e-02f, 1.44116849e-01f, -5.78959212e-02f, 1.86346322e-01f, 1.00476012e-01f, 9.18932632e-02f, 2.16446482e-02f,
  1.71581849e-01f, 8.36945325e-02f, -7.19478130e-02f, -9.16883424e-02f, 4.49302159e-02f, -9.11625400e-02f, -7.46573657e-02f, -2.03683693e-02f, 6.66201636e-02f, 8.04757699e-02f,
  8.98641199e-02f, 1.28186895e-02f, 2.51584314e-02f, 1.41491070e-02f, -2.78017651e-02f, -1.07382843e-02f, -3.15799518e-03f, 6.44217106e-03f, -9.19458494e-02f, 1.24586150e-01f,
  8.05938095e-02f, 9.95996147e-02f, 2.59875916e-02f, 8.69149268e-02f, -5.32896966e-02f, -7.56092276e-03f, 4.26821597e-02f, 9.45402905e-02f, 4.93633449e-02f, -5.11876028e-03f,
  -8.85511637e-02f, -2.26458255e-02f, -1.43259112e-02f, -4.39631566e-03f, -8.21474474e-03f, -1.20196650e-02f, 3.66112180e-02f, 8.06912035e-03f, 2.32004989e-02f, -2.14560367e-02f,
  -8.78007337e-03f, 7.73064978e-03f, 3.31640616e-02f, -6.70812204e-02f, -3.92350741e-02f, 8.32790434e-02f, -7.22945631e-02f, 4.64073792e-02f, 5.95985837e-02f, -3.99956340e-03f,
  -7.40239695e-02f, 8.72878954e-02f, 9.05377269e-02f, 7.76586682e-02f, -4.67593484e-02f, 2.79813521e-02f, -2.80203242e-02f, -4.78694104e-02f, -3.95000763e-02f, 2.80397348e-02f,
  -3.50901000e-02f, -1.32397071e-01f, 1.11554908e-02f, -6.98230043e-02f, 4.21372382e-03f, -9.02366731e-03f, 3.91377807e-02f, 2.67745759e-02f, 1.68641377e-02f, -8.14689416e-03f,
  2.58469302e-02f, -1.17481882e-02f, 9.10911709e-03f, 6.64260536e-02f, -4.51969728e-02f, -1.23961898e-03f, -4.62874072e-03f, -9.84735042e-02f, 1.33231282e-02f, 2.47453284e-02f,
  1.08953677e-01f, -8.66670385e-02f, -1.76866889e-01f, 1.35915028e-02f, -1.53369065e-02f, -1.01335756e-01f, 1.73726100e-02f, 4.04600017e-02f, -9.03340802e-02f, -1.24054626e-01f,
  -2.52716005e-01f, -1.08307071e-01f, -2.66233627e-02f, -5.95643595e-02f, -1.79996789e-01f, -2.72982448e-01f, -3.55504990e-01f, -1.89751908e-01f, 3.49498391e-02f, -5.33443727e-02f,
  2.05508750e-02f, 2.59517342e-01f, 1.76616579e-01f, 1.93721086e-01f, -9.60987881e-02f, -8.73965025e-02f, -3.34995538e-02f, 1.15537331e-01f, 6.13927422e-03f, -4.96427417e-02f,
  5.80717362e-02f, -5.93876839e-02f, -9.38540325e-02f, 1.07372001e-01f, 1.80673093e-01f, 1.49834096e-01f, 1.00791797e-01f, -4.51538637e-02f, -1.03404350e-03f, 2.18639091e-01f,
  3.21877211e-01f, -1.58529967e-01f, 7.76592046e-02f, 1.09535821e-01f, -4.70874831e-04f, 8.42346251e-02f, 4.85052206e-02f, 1.18032675e-02f, -2.87574772e-02f, 3.22930664e-02f,
  5.46748340e-02f, -5.22529408e-02f, -4.85328212e-02f, 5.00192419e-02f, -1.98794045e-02f, 4.08560410e-02f, -7.76357343e-03f, -9.85678053e-05f, -9.54951942e-02f, -6.64438456e-02f,
  1.19089544e-01f, -1.32369071e-01f, -5.48862964e-02f, -4.59294356e-02f, 1.03353150e-02f, 8.39018524e-02f, -2.28209756e-02f, 8.19819793e-02f, -7.71834627e-02f, -8.68764892e-02f,
  3.95426936e-02f, 7.34840631e-02f, -2.99063027e-02f, 4.17098366e-02f, -2.86243837e-02f, -2.54201703e-02f, -9.30424873e-03f, -3.14613432e-02f, -2.69124936e-02f, 1.24833575e-02f,
  4.53877822e-02f, -2.48479433e-02f, 2.03993171e-02f, -6.52718619e-02f, 1.03876337e-01f, -6.17052652e-02f, -1.56723820e-02f, -2.87693436e-03f, 6.43813163e-02f, -1.89368837e-02f,
  -4.53122742e-02f, 7.85177127e-02f, -2.62974389e-02f, 8.07629451e-02f, -1.58033017e-02f, -4.75436822e-02f, 5.76474369e-02f, 2.86676306e-02f, -2.91324891e-02f, -4.30252515e-02f,
  9.07051265e-02f, -1.53752759e-01f, 5.56374453e-02f, 6.69745356e-02f, -3.17169689e-02f, 4.19361219e-02f, 4.97940071e-02f, -5.41553013e-02f, 2.74785720e-02f, -2.01113038e-02f,
  1.62987597e-02f, 5.79724312e-02f, 4.16519120e-02f, 1.41845783e-02f, -3.18845287e-02f, 1.95022076e-02f, -9.56896842e-02f, 5.49307987e-02f, -2.03523394e-02f, 4.22368012e-02f,
  -1.07670343e-02f, -6.80274218e-02f, -5.79361171e-02f, 2.76170522e-02f, 5.00752181e-02f, -4.93698940e-02f, 3.69350836e-02f, -2.67044511e-02f, -1.20065786e-01f, -1.67441398e-01f,
  -2.41353944e-01f, -6.11465611e-02f, -8.65947362e-03f, 1.16157448e-02f, 5.01426347e-02f, -4.34326418e-02f, -8.87889564e-02f, -5.86422570e-02f, -1.00316927e-01f, -5.25983460e-02f,
  8.82445499e-02f, 2.18470637e-02f, -2.16962304e-02f, -7.90298656e-02f, 9.04877111e-03f, -1.12359725e-01f, -9.31024104e-02f, -4.44101132e-02f, -5.56815416e-02f, -4.55880165e-02f,
  3.70519347e-02f, 1.09687429e-02f, -3.21846195e-02f, 8.06960836e-02f, 1.28797576e-01f, 4.69102971e-02f, 7.70467743e-02f, 1.00002207e-01f, 2.60688756e-02f, 1.45467386e-01f,
  -6.75828680e-02f, 3.19470428e-02f, -5.05663604e-02f, -2.94762030e-02f, 8.48227218e-02f, -7.27600902e-02f, -2.15801187e-02f, 8.84610489e-02f, 8.52198005e-02f, 4.48405296e-02f,
  4.35194187e-02f, 2.73168087e-02f, -1.27316611e-02f, 1.03391930e-01f, -7.32492208e-02f, -3.29499692e-02f, -8.59016031e-02f, -4.14008368e-03f, 4.90892120e-03f, 7.71427155e-02f,
  1.13269709e-01f, 1.41884685e-01f, -1.28046855e-01f, -1.09888330e-01f, -3.40082757e-02f, -3.01822294e-02f, 7.62028843e-02f, -2.22804584e-03f, 8.61589462e-02f, -6.54408382e-03f,
  1.49819050e-02f, 1.78692788e-02f, 5.86742908e-02f, -1.31837709e-03f, -1.22665679e-02f, -1.70928184e-02f, -2.93012410e-02f, 4.52719182e-02f, 4.10370268e-02f, -1.09991357e-02f,
  1.55300470e-02f, -5.58912046e-02f, -1.45338420e-02f, -2.01957803e-02f, -1.04408516e-02f, -2.74540521e-02f, 4.11429927e-02f, -6.03367388e-02f, -3.75109762e-02f, -3.53127122e-02f,
  1.28144156e-02f, 1.99853885e-03f, 2.18014214e-02f, -1.34481648e-02f, 9.59949195e-03f, -2.92597394e-02f, -4.17528600e-02f, -9.56107304e-03f, -4.33678664e-02f, -4.68503200e-02f,
  -2.43353263e-01f, 1.96950510e-01f, -1.24046795e-01f, -7.14167906e-03f, -3.51666845e-02f, -5.13486452e-02f, -4.14753370e-02f, -7.82992691e-03f, 5.37816100e-02f, -7.06298053e-02f,
  3.23244222e-02f, -3.87676433e-02f, -1.40720047e-02f, -5.69040552e-02f, -8.14664140e-02f, 1.64606870e-04f, -7.94594809e-02f, -7.78405890e-02f, 5.59107810e-02f, -6.19673468e-02f,
  -9.21889693e-02f, -1.60995319e-01f, -1.95991322e-01f, -1.07668504e-01f, -3.77089940e-02f, -7.09019154e-02f, -1.47250935e-01f, -1.54567152e-01f, -2.17725232e-01f, -3.44589353e-01f,
  1.55831605e-01f, -9.91991088e-02f, 3.61262076e-02f, 6.99335784e-02f, 9.49101374e-02f, 1.38089731e-01f, 2.11289987e-01f, 1.80754513e-01f, 1.15046818e-02f, 7.72562996e-02f,
  5.11020012e-02f, -2.23509017e-02f, -6.44344371e-03f, -1.03880949e-01f, 6.95852935e-02f, -1.02263905e-01f, -1.36942282e-01f, -1.05552681e-01f, 3.85932960e-02f, 1.31846229e-02f,
  -1.12004697e-01f, 2.81829890e-02f, 4.05773930e-02f, -1.36564031e-01f, -1.46747276e-01f, 3.85568365e-02f, -3.86659466e-02f, -2.39742268e-02f, 3.76331643e-03f, -1.82506308e-01f,
  3.97457555e-02f, 7.91734830e-02f, 8.08224455e-03f, -3.61779407e-02f, 2.11305842e-02f, -5.20086102e-03f, -5.58461947e-03f, -1.09405674e-01f, 6.41529039e-02f, -8.60016868e-02f,
  -8.02755132e-02f, -7.58725554e-02f, -4.91580330e-02f, -8.42793509e-02f, -9.56372079e-03f, 1.11581944e-01f, -9.50092822e-02f, -6.01906553e-02f, 1.02873566e-02f, 5.84240369e-02f,
  -9.37222987e-02f, 8.70353878e-02f, 5.37481830e-02f, 5.25058918e-02f, -6.19824864e-02f, 4.57328670e-02f, -3.44535112e-02f, 3.47469896e-02f, 9.58030373e-02f, 1.92732923e-02f,
  -2.01314576e-02f, 2.40666587e-02f, -6.44079819e-02f, -2.07956508e-02f, -9.21118446e-03f, -4.69757430e-03f, -8.22229087e-02f, -4.07098122e-02f, 5.97328469e-02f, -2.83488166e-02f,
  5.14851473e-02f, 1.46194072e-02f, -4.37905043e-02f, 4.26457524e-02f, -6.07146940e-05f, -3.41955684e-02f, 2.97021214e-02f, 1.90553125e-02f, -4.51478548e-02f, -5.01265116e-02f,
  -5.59601225e-02f, 4.94198427e-02f, -1.72294583e-02f, -2.76512858e-02f, 4.13370207e-02f, -3.90710949e-04f, 4.09615319e-03f, -9.13678110e-03f, -8.82191490e-03f, 7.54598454e-02f,
  4.08309214e-02f, -2.20002905e-02f, 1.17326938e-01f, 3.92636470e-02f, 3.49299214e-03f, 4.42528389e-02f, -2.63945311e-02f, -7.04287812e-02f, 3.58161442e-02f, 5.18723279e-02f,
  6.60329461e-02f, 1.08751245e-02f, 5.95657714e-02f, 1.71338394e-02f, 7.80925155e-02f, -3.98429558e-02f, -2.63646785e-02f, -4.68841307e-02f, -5.85563760e-03f, -1.80633329e-02f,
  -2.32478566e-02f, 1.76844105e-01f, 2.42201120e-01f, 9.98090804e-02f, 1.08595587e-01f, 2.32979313e-01f, 1.59563065e-01f, 7.51366690e-02f, 1.82835773e-01f, 9.87489447e-02f,
  4.44920063e-01f, -2.01147962e-02f, -3.42716306e-01f, 2.92961933e-02f, -6.88351989e-02f, -1.42071187e-01f, -1.57237872e-01f, 1.39072448e-01f, 1.65158555e-01f, 6.17059087e-03f,
  8.94201100e-02f, 1.77822158e-01f, 1.39447674e-01f, 3.07016112e-02f, 7.43010864e-02f, -2.28914127e-01f, -1.03763118e-01f, -1.95923999e-01f, -9.32432339e-02f, 2.72085629e-02f,
  6.63693249e-02f, 1.60388365e-01f, 3.70409526e-02f, 3.20838802e-02f, 5.60973138e-02f, 3.47067975e-03f, -7.75091946e-02f, -9.07988772e-02f, -8.08997080e-02f, -2.23837852e-01f,
  -5.61082512e-02f, 4.67273109e-02f, 2.11798307e-02f, 3.33564915e-02f, -6.95149153e-02f, 3.86357754e-02f, -1.55834276e-02f, 1.64563041e-02f, 6.67014793e-02f, -4.69817333e-02f,
  -8.15863982e-02f, 3.30172386e-03f, 7.53678195e-03f, -1.98184606e-02f, -2.60736747e-03f, 3.46548110e-02f, -1.62974859e-04f, 6.19421573e-03f, -1.11559071e-01f, -1.08313642e-01f,
  2.68573575e-02f, 1.31462310e-02f, -1.00668766e-01f, -5.79114184e-02f, -7.95621648e-02f, -8.07623286e-03f, -8.23656544e-02f, -5.43585839e-03f, -6.37772754e-02f, 7.09315315e-02f,
  1.20621271e-01f, -4.32168953e-02f, -2.06107665e-02f, 2.66128052e-02f, -2.88104964e-03f, 1.85019281e-02f, -1.07806429e-01f, -8.22185539e-03f, 3.79416556e-03f, -6.25578240e-02f,
  1.66105628e-02f, 1.42482342e-02f, 6.74832473e-03f, 2.05394085e-02f, 2.81011388e-02f, -9.00065452e-02f, -5.50278947e-02f, 2.74282880e-02f, -7.94034004e-02f, -6.28524739e-03f,
  2.45801285e-02f, -2.84397453e-02f, 4.89870347e-02f, -5.99093661e-02f, 3.01490165e-02f, -7.26064667e-02f, -6.85388967e-02f, 5.49555942e-02f, -3.77174318e-02f, -2.24786997e-02f,
  2.90005237e-01f, -5.96329905e-02f, 6.17007650e-02f, 1.12198129e-01f, -6.35756180e-02f, -2.60212235e-02f, 6.83456212e-02f, -3.17580509e-03f, 5.34932911e-02f, 1.78948138e-02f,
  5.64360172e-02f, 1.09654732e-01f, -7.50345783e-03f, 3.16053927e-02f, -3.53659913e-02f, 1.11717120e-01f, 4.76482585e-02f, -2.91061196e-02f, -5.17627224e-02f, 6.47156015e-02f,
  6.56256825e-02f, 1.06592447e-01f, 1.39259398e-01f, 6.12454377e-02f, -2.41090935e-02f, 1.50243863e-01f, 1.40215037e-02f, 8.41726288e-02f, 7.00160041e-02f, 2.85259724e-01f,
  -3.69113721e-02f, -1.22230358e-01f, 1.70874268e-01f, 7.98470378e-02f, -6.15403010e-03f, 9.02929083e-02f, 1.24416426e-01f, 1.81208953e-01f, 1.27858579e-01f, 4.11371264e-04f,
  -1.64182469e-01f, 1.03502134e-02f, 6.79590330e-02f, 3.13985087e-02f, 3.23184803e-02f, 8.38328302e-02f, 9.79028270e-02f, 2.35540807e-01f, 1.95167392e-01f, 2.85392608e-02f,
  -5.17173372e-02f, 7.44672418e-02f, 2.87713576e-02f, 1.08510055e-01f, -1.47116575e-02f, -4.54451032e-02f, -2.11931169e-02f, -3.42497863e-02f, -5.76471090e-02f, -6.57489672e-02f,
  -1.37208596e-01f, 1.15594804e-01f, -3.73151638e-02f, -1.19095054e-02f, 2.12309808e-02f, 2.82976590e-02f, -3.07397246e-02f, 1.15635879e-01f, -4.11002971e-02f, -9.98692401e-03f,
  8.73612985e-03f, -4.42916527e-02f, 1.60725582e-02f, 6.08168878e-02f, 6.56063855e-02f, 5.19138649e-02f, -2.87721418e-02f, 1.62521273e-01f, 3.75529472e-03f, -9.22109038e-02f,
  -1.03563085e-01f, 5.23916148e-02f, 1.03286065e-01f, 9.77355689e-02f, 9.54314321e-02f, -3.04161441e-02f, 3.95226479e-02f, -1.74162593e-02f, 1.43407315e-01f, -4.10364680e-02f,
  -1.57530215e-02f, -2.71554217e-02f, 7.48446630e-03f, 4.61465046e-02f, -3.38269211e-02f, -8.74870941e-02f, 6.51990473e-02f, 3.38895470e-02f, 1.57735217e-02f, -4.17822301e-02f,
  3.78724486e-02f, -1.03928121e-02f, 3.70059162e-03f, -3.37821320e-02f, 4.77456152e-02f, 4.66062166e-02f, 2.79193018e-02f, -8.44258443e-02f, -2.67578438e-02f, 2.74706408e-02f,
  -7.04293847e-02f, 2.27569994e-02f, -7.06670284e-02f, -6.37311265e-02f, -8.15005694e-03f, 3.34143229e-02f, -4.01370376e-02f, -7.05919117e-02f, 6.98291510e-02f, 3.77891138e-02f,
  -2.11250782e-01f, 8.38602260e-02f, -1.09677978e-01f, 5.12135848e-02f, 3.17563862e-02f, -8.35154876e-02f, -1.00979127e-01f, -2.90703252e-02f, -7.64472634e-02f, 3.70545797e-02f,
  -1.66192390e-02f, -3.05659473e-02f, -4.86819372e-02f, -3.27218808e-02f, 3.12659740e-02f, -2.14374065e-03f, -1.29213378e-01f, -6.51403368e-02f, 6.58195019e-02f, -2.53710039e-02f,
  -4.42843251e-02f, -4.34034802e-02f, -1.51327953e-01f, -4.51760925e-03f, -3.80187184e-02f, 4.72900346e-02f, -4.67589013e-02f, -6.75204918e-02f, 6.91223368e-02f, -1.63172051e-01f,
  2.18191698e-01f, -2.04890996e-01f, 2.32259370e-02f, 1.37584552e-01f, -2.08876520e-01f, -3.49677324e-01f, -4.93528843e-01f, -1.16037518e-01f, 7.17175677e-02f, -4.62339707e-02f,
  -5.63876936e-03f, 1.62727967e-01f, 1.82511121e-01f, 5.00882454e-02f, 5.21418341e-02f, -1.73107132e-01f, 5.50869247e-03f, 6.47606254e-02f, 1.05502479e-01f, 7.68885389e-02f,
  1.72964670e-02f, 2.06176281e-01f, 2.67326832e-01f, 7.74671957e-02f, 2.60082092e-02f, 1.72402874e-01f, -3.21615897e-02f, -2.03145985e-02f, -6.80965930e-03f, 2.61405319e-01f,
  1.92320153e-01f, 1.03566432e-02f, -3.75680043e-03f, 1.04298636e-01f, -4.76861484e-02f, -4.21961769e-02f, -2.14418396e-02f, -3.28694545e-02f, -8.22189003e-02f, 2.94738566e-03f,
  1.05161414e-01f, 8.68286341e-02f, 8.62857774e-02f, 3.79219018e-02f, 1.56780966e-02f, 2.23384257e-02f, 3.47251222e-02f, 6.14457130e-02f, 4.62623276e-02f, -4.61193547e-02f,
  4.45692912e-02f, -9.34506953e-02f, -1.22249089e-01f, -1.77700683e-01f, -2.84760576e-02f, 4.69523035e-02f, -1.65306516e-02f, 7.01575801e-02f, -9.37701110e-03f, -2.91209724e-02f,
  -6.02304637e-02f, -2.15229895e-02f, 2.86903158e-02f, 2.10147016e-02f, -4.75309528e-02f, 1.07936282e-02f, -1.62968710e-02f, -1.98384710e-02f, -1.53388688e-02f, -2.11702809e-02f,
  3.06556486e-02f, -7.10824355e-02f, -5.51224388e-02f, -5.96867455e-03f, 4.43604868e-03f, -2.23490316e-02f, 5.52733196e-03f, -6.36058003e-02f, 9.73846763e-03f, 3.65981422e-02f,
  8.83044749e-02f, 4.25624326e-02f, -1.74036492e-02f, 5.13840728e-02f, -4.75273356e-02f, 5.81977256e-02f, 2.69776490e-02f, -1.15014780e-02f, 1.40195424e-02f, -1.15549546e-02f,
  4.80379835e-02f, -1.41114622e-01f, 1.23886682e-01f, 1.06594607e-01f, -1.57986749e-02f, 1.87235475e-02f, 3.68554349e-04f, 5.47474697e-02f, 7.00778887e-02f, 4.23042066e-02f,
  -7.78462663e-02f, -3.31182182e-02f, -9.02216882e-03f, -2.74354443e-02f, 5.82093596e-02f, -3.22014006e-04f, 1.83879770e-02f, -1.32285003e-02f, 3.63757722e-02f, -3.49831581e-02f,
  -1.06085852e-01f, -1.12736523e-01f, -4.34865505e-02f, -5.94767630e-02f, -6.07506037e-02f, 1.16846142e-02f, -3.50454301e-02f, -1.39690973e-02f, -9.64342654e-02f, -1.29791185e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.35714382e-01f, 7.38218501e-02f, 5.25880530e-02f, 6.52685538e-02f, 3.48132849e-02f, 1.00964092e-01f, 1.15890533e-01f, 4.36899588e-02f, 1.10417657e-01f, 1.40037730e-01f,
  5.96664883e-02f, 1.99015275e-01f, 2.39681169e-01f, 6.92604259e-02f, 1.43371761e-01f, 8.18854719e-02f, 5.67724742e-02f, -5.45862652e-02f, -5.10232858e-02f, 5.43847866e-02f,
  1.25212431e-01f, -4.20161150e-02f, -7.70362020e-02f, 8.38999525e-02f, -7.77127314e-03f, 1.23692013e-01f, -2.14997716e-02f, -9.11592469e-02f, 4.54739854e-02f, 1.89933646e-02f,
  5.65067567e-02f, -1.54814780e-01f, 9.75523368e-02f, 1.85541380e-02f, -7.84972236e-02f, -8.81063715e-02f, 6.82372749e-02f, -6.02965709e-03f, -6.24743886e-02f, -6.84295446e-02f,
  -2.10873093e-02f, 2.79570818e-02f, -7.48387203e-02f, 5.42356186e-02f, -8.99644510e-04f, -8.07695389e-02f, -2.71611810e-02f, 6.62381724e-02f, 2.79092174e-02f, -2.79891733e-02f,
  -2.23868303e-02f, -1.25283614e-01f, -1.07347548e-01f, -6.38945550e-02f, 2.45682262e-02f, -3.96507345e-02f, 1.32016568e-02f, 4.25605103e-02f, 4.82174084e-02f, 1.16737774e-02f,
  2.74823681e-02f, 5.37686907e-02f, 3.01392321e-02f, -2.44262014e-02f, 2.92688124e-02f, -5.51943071e-02f, 7.57986382e-02f, 1.44739018e-03f, 7.70175979e-02f, -5.29370941e-02f,
  -3.49414051e-02f, 5.93178347e-02f, 3.39022502e-02f, -6.56279698e-02f, -2.32829805e-02f, -6.28986061e-02f, -9.80188400e-02f, 6.09548762e-02f, 3.50771695e-02f, -7.38164410e-02f,
  -7.86998719e-02f, 8.83490406e-03f, -2.54880674e-02f, 6.79924618e-03f, -5.89343682e-02f, 4.45122123e-02f, 3.80652957e-02f, 5.18131182e-02f, 1.75654031e-02f, -4.82530845e-03f,
  1.58734441e-01f, 3.30078695e-03f, -2.86613833e-02f, -4.85524200e-02f, -1.07061006e-01f, 2.74734665e-03f, -2.80430708e-02f, -2.05067899e-02f, -7.00368732e-02f, 2.73444802e-02f,
  -8.88198838e-02f, 4.28369865e-02f, 8.00035447e-02f, 5.19798184e-03f, -7.96872154e-02f, -3.12678590e-02f, -8.05597529e-02f, 4.77842316e-02f, 8.00954327e-02f, 6.83274493e-02f,
  2.93441340e-02f, -9.03226715e-03f, 6.40445948e-02f, 1.33622572e-01f, -5.31862862e-02f, 6.54899552e-02f, 8.15162733e-02f, -1.70300938e-02f, -3.97110097e-02f, -3.26330177e-02f,
  1.93489388e-01f, -3.14691700e-02f, 1.82975471e-01f, 7.25492276e-03f, 2.06031844e-01f, 1.43223569e-01f, 1.29057229e-01f, 1.35993719e-01f, 2.79829577e-02f, 1.62641648e-02f,
  4.70315218e-02f, -1.67145982e-01f, -5.89997917e-02f, -1.77811578e-01f, -2.07230560e-02f, 8.10172334e-02f, 3.55012156e-02f, 6.93692416e-02f, -4.44523916e-02f, -4.16392684e-02f,
  9.65207908e-03f, -6.81944788e-02f, 1.05889313e-01f, 6.64172992e-02f, -1.24304838e-01f, -9.07477364e-02f, -5.67420162e-02f, -5.12434617e-02f, -8.64555761e-02f, 5.47589269e-04f,
  -6.25085831e-02f, 1.33019775e-01f, 6.85702777e-03f, -1.37467593e-01f, 6.42843992e-02f, -4.68584895e-02f, -6.38510287e-02f, -8.20505098e-02f, -3.46947350e-02f, -6.70271367e-02f,
  7.95126557e-02f, -2.71945596e-02f, -1.91260949e-02f, -7.23631606e-02f, -3.57817858e-03f, 7.35564157e-02f, -5.81022352e-02f, -1.17899798e-01f, -5.03839664e-02f, 1.11617707e-02f,
  -1.02618493e-01f, 1.04390636e-01f, 1.12962157e-01f, 7.05930069e-02f, 1.02878185e-02f, -8.30187425e-02f, -4.86326916e-03f, -2.56828275e-02f, 1.15608436e-03f, -5.03517613e-02f,
  -1.27388770e-02f, 8.04109946e-02f, 8.86418298e-02f, -1.68621335e-02f, 2.10878928e-03f, 4.74973693e-02f, -5.88294677e-02f, -6.38469458e-02f, 7.11203963e-02f, -7.49055073e-02f,
  3.95033546e-02f, 4.20894660e-02f, -2.79979184e-02f, -1.07944570e-02f, -9.86022875e-03f, -1.32008716e-02f, 7.26233125e-02f, -8.12066570e-02f, 3.42144929e-02f, -6.21614046e-02f,
  -3.84884179e-02f, 4.31612581e-02f, 6.65533543e-02f, -1.00987196e-01f, -6.89375922e-02f, -5.06285653e-02f, -2.48017367e-02f, -9.17101428e-02f, -8.65501910e-02f, 7.19592646e-02f,
  -1.30018115e-01f, -2.03297306e-02f, -1.17637857e-03f, -4.81069982e-02f, -2.15697549e-02f, -9.39909220e-02f, 1.91116687e-02f, -6.56990930e-02f, -6.77452609e-02f, -5.35318032e-02f,
  -1.05766822e-02f, -5.43869548e-02f, 1.96634326e-02f, -3.81131247e-02f, 6.57633133e-03f, 9.14662331e-02f, -6.95051700e-02f, -3.25587690e-02f, 5.48539013e-02f, 6.56083971e-02f,
  2.23613102e-02f, 1.38116881e-01f, -6.27753139e-03f, -7.84041549e-05f, 5.72062582e-02f, 7.02816481e-03f, 7.32116848e-02f, 9.63569134e-02f, 8.75853673e-02f, 7.53913000e-02f,
  2.59372234e-01f, 2.39103427e-03f, 9.30630118e-02f, 9.93491113e-02f, 5.06503098e-02f, 4.19032797e-02f, -1.16276212e-01f, 6.88863099e-02f, -9.91674215e-02f, 5.14297001e-02f,
  5.28169200e-02f, 8.83486569e-02f, -5.17150089e-02f, -5.67406639e-02f, -1.95102803e-02f, 7.17116743e-02f, -3.36956531e-02f, -4.43807580e-02f, 5.96632808e-02f, 7.00790286e-02f,
  -2.02828478e-02f, 1.23094901e-01f, 1.22773454e-01f, 1.24767601e-01f, 1.56883579e-02f, 2.13364307e-02f, -6.13266118e-02f, 2.45890170e-02f, -2.41775438e-02f, -2.58786548e-02f,
  1.32506832e-01f, 8.66432115e-02f, -9.22637656e-02f, 6.17789105e-02f, -5.89306131e-02f, 5.18281898e-03f, 2.98508257e-02f, -1.30895860e-02f, 6.26188070e-02f, 2.81080659e-02f,
  -4.45789518e-03f, 3.46615501e-02f, -8.91514793e-02f, -4.69500944e-02f, -6.32660016e-02f, 8.25119466e-02f, -8.45917780e-03f, 2.02492834e-03f, -6.64560795e-02f, 2.88263708e-02f,
  -2.44307448e-03f, 8.32049176e-02f, 1.96209154e-03f, -4.06385446e-03f, -7.52300844e-02f, 3.08869369e-02f, 7.51618072e-02f, -3.49621549e-02f, 7.50788301e-02f, -2.77554765e-02f,
  -1.74714401e-02f, 4.99871336e-02f, -5.46191260e-02f, -9.85849723e-02f, -8.01905617e-02f, 1.94514468e-02f, -1.10381112e-01f, 5.18537983e-02f, -1.07788935e-01f, -9.28417444e-02f,
  4.51362915e-02f, -2.97837611e-02f, -4.82488349e-02f, 6.15839064e-02f, -5.73965199e-02f, -3.43169309e-02f, 6.83954805e-02f, 1.66427195e-02f, -7.14267865e-02f, -3.57916541e-02f,
  9.10831057e-03f, 2.40152664e-02f, 7.64444321e-02f, 1.53101673e-02f, -1.01442896e-01f, -8.19488894e-03f, -1.13486372e-01f, -3.68785001e-02f, -8.93915370e-02f, -4.64084670e-02f,
  -1.21544987e-01f, -8.61344934e-02f, -1.59128867e-02f, 8.98146480e-02f, -4.43190133e-04f, 3.40832658e-02f, 7.07115903e-02f, -4.11974341e-02f, -9.94090736e-03f, 6.56135231e-02f,
  -1.98528338e-02f, 4.48331982e-02f, -4.17737924e-02f, -6.45670295e-02f, 7.44622480e-03f, 4.29233089e-02f, 4.48348820e-02f, 6.43910319e-02f, -5.28652743e-02f, 4.14296016e-02f,
  -1.07399039e-01f, 3.54192592e-03f, -7.64722899e-02f, -7.20557198e-02f, 8.75981897e-03f, -9.03950408e-02f, -2.58242749e-02f, -4.98129390e-02f, -3.09203193e-02f, -2.16749683e-02f,
  -1.84887424e-01f, 1.66309439e-02f, -4.63282950e-02f, 7.98762366e-02f, -4.56217416e-02f, 3.46426181e-02f, 5.74156828e-03f, 6.11413419e-02f, 1.39900707e-02f, -7.26548284e-02f,
  -1.39931008e-01f, -1.05102599e-01f, 9.79144126e-02f, 1.34658054e-01f, 9.87838581e-02f, 1.11843251e-01f, 1.98723331e-01f, -7.31932046e-03f, -9.50903445e-03f, -6.74990118e-02f,
  2.96607986e-02f, 3.74087952e-02f, 6.19826578e-02f, 2.45857649e-02f, -9.49253514e-03f, -1.11653237e-02f, 1.21634163e-01f, 2.53437124e-02f, -3.41905281e-02f, -9.38813947e-03f,
  -1.87816650e-01f, -1.39083013e-01f, 6.12805337e-02f, 5.53266555e-02f, -8.31370652e-02f, -5.65782487e-02f, -4.49734973e-03f, 4.56964336e-02f, -1.03435397e-01f, -1.52727338e-02f,
  -1.15020476e-01f, -8.71731937e-02f, 2.60910504e-02f, 1.68333426e-02f, -1.00223094e-01f, -3.12475041e-02f, 9.06170756e-02f, -1.69574320e-02f, 1.18716555e-02f, -1.49991196e-02f,
  -1.09678525e-02f, -2.27342136e-02f, -1.41792864e-01f, -7.37615600e-02f, -6.57013878e-02f, 4.20060344e-02f, 3.14895250e-02f, -6.69098869e-02f, -1.57871023e-02f, -7.81433135e-02f,
  -4.16645482e-02f, -2.37546377e-02f, -6.30796179e-02f, -7.08255023e-02f, 6.58311322e-02f, 9.20243189e-02f, 3.90566140e-02f, 6.43228814e-02f, -4.58876677e-02f, 8.22061226e-02f,
  2.16263160e-02f, -4.85192537e-02f, 1.67084194e-03f, 4.16612849e-02f, -4.08445746e-02f, -7.68440068e-02f, 8.07155594e-02f, -5.56097776e-02f, 9.51036718e-03f, -6.39861673e-02f,
  9.39479272e-04f, -3.24941613e-02f, 3.15927453e-02f, -6.54700771e-02f, 7.25980103e-02f, 9.35858861e-02f, -3.16774137e-02f, -9.13279206e-02f, 3.60326804e-02f, 1.19648939e-02f,
  -6.87851086e-02f, 1.65383145e-02f, 5.83868288e-03f, 1.02783114e-01f, -5.07318601e-02f, 4.45153266e-02f, -1.20853931e-01f, 8.17095116e-03f, -4.19495255e-02f, -5.70765510e-02f,
  -1.09124817e-01f, -1.10163793e-01f, -5.72561175e-02f, 4.41804975e-02f, -4.67045568e-02f, 4.97055799e-02f, 2.90965736e-02f, 5.65368570e-02f, -3.72102857e-02f, -9.23586935e-02f,
  -3.62203158e-02f, -1.05938032e-01f, -1.27084211e-01f, 3.61881778e-02f, -4.47692759e-02f, 4.22550328e-02f, -8.32567513e-02f, -4.84418310e-02f, -1.11116104e-01f, -7.73541927e-02f,
  8.19897428e-02f, 6.61112368e-02f, 1.02113560e-01f, 7.44207799e-02f, 7.93580860e-02f, 1.42139092e-01f, 3.58545966e-02f, 1.40080780e-01f, -3.72751206e-02f, 4.13974002e-02f,
  -7.00674206e-02f, -6.46960735e-02f, 9.66464877e-02f, 9.77527201e-02f, 2.68938057e-02f, 1.33025423e-01f, 1.50934696e-01f, 9.85225439e-02f, -3.68779874e-03f, 6.65164962e-02f,
  9.36979875e-02f, 1.52600752e-02f, -2.04197690e-02f, -2.08142698e-02f, 1.14564657e-01f, -1.27626248e-02f, 4.96773310e-02f, 1.82748735e-02f, 6.76527619e-04f, 5.62610440e-02f,
  1.10444771e-02f, 8.96474719e-02f, -1.25516923e-02f, -8.62988234e-02f, -7.26662576e-02f, -1.44592021e-02f, 2.12932341e-02f, -6.64379448e-02f, -5.28241806e-02f, 5.69498092e-02f,
  -8.02975148e-02f, 6.67055920e-02f, -7.14218691e-02f, -2.03103647e-02f, -2.23763473e-02f, 5.32680303e-02f, -9.40034539e-02f, 4.10831720e-02f, 4.10997905e-02f, -4.36330438e-02f,
  8.90756119e-03f, -1.59042403e-02f, -5.78376539e-02f, 4.66878898e-02f, -5.23348637e-02f, -1.02575868e-01f, 2.27930006e-02f, 7.57038295e-02f, 2.74449997e-02f, -2.39061397e-02f,
  3.25412713e-02f, -6.04398027e-02f, -2.25996990e-02f, -2.40412052e-03f, 1.16692511e-02f, 6.07126541e-02f, -4.62208278e-02f, 7.87731409e-02f, 5.64169213e-02f, -8.78475234e-02f,
  2.77998224e-02f, -5.12298942e-02f, 7.24054128e-02f, -2.07444597e-02f, -4.54594642e-02f, 8.44520628e-02f, -5.45189790e-02f, 3.74792796e-03f, 9.08643007e-03f, 3.57629322e-02f,
  -4.90485951e-02f, 7.99660683e-02f, -7.29762316e-02f, 8.46776068e-02f, -5.48029244e-02f, -8.00742656e-02f, 1.56485531e-02f, -3.30153927e-02f, 1.55585678e-02f, -3.86826731e-02f,
  -8.83654356e-02f, -2.55719256e-02f, 4.22911756e-02f, 3.79293784e-02f, 1.36571331e-02f, -6.84233457e-02f, 9.32067540e-03f, -8.51906762e-02f, 4.06692363e-02f, -1.01981731e-02f,
  1.11686448e-02f, -1.14992121e-02f, 5.04879542e-02f, -5.10740392e-02f, 8.59251432e-03f, -1.09489344e-01f, 2.29308400e-02f, -7.52640981e-03f, -2.94523053e-02f, 6.86159208e-02f,
  -7.20455125e-02f, 3.99137624e-02f, -6.74061328e-02f, 6.60678223e-02f, 2.25713421e-02f, -1.01176165e-02f, 3.50150571e-04f, -1.54411448e-02f, -1.01145111e-01f, -5.14621846e-02f,
  1.15563177e-01f, -9.65934768e-02f, -5.63424267e-02f, 1.74701020e-01f, 1.33083984e-02f, -6.97678402e-02f, -8.00341591e-02f, -3.10663432e-02f, 8.00715163e-02f, 5.57671301e-02f,
  5.32075129e-02f, 2.39036675e-03f, 8.07102919e-02f, -1.01288550e-01f, -1.82936847e-01f, -1.18664280e-01f, -4.94379550e-02f, -1.08952485e-02f, -3.49860936e-02f, -1.03095308e-01f,
  -7.82896206e-02f, 1.19703136e-01f, 1.73147898e-02f, 4.69981134e-02f, 7.92517588e-02f, 6.72711357e-02f, -8.99323821e-02f, -4.33003418e-02f, -9.38859284e-02f, -8.22363496e-02f,
  -4.62997472e-04f, -9.75496992e-02f, 4.53818366e-02f, 3.28171588e-02f, -1.01137096e-02f, -7.66842067e-02f, 4.98369383e-03f, -8.11083429e-03f, -5.85312061e-02f, 7.29926629e-03f,
  -6.89876899e-02f, 2.97651459e-02f, -8.67839083e-02f, 6.59732223e-02f, 3.69292460e-02f, -9.28030908e-02f, -6.04590513e-02f, -1.79194640e-02f, 1.39675718e-02f, 1.28689175e-02f,
  5.13348877e-02f, 5.07513247e-02f, -3.31909815e-03f, -3.60952429e-02f, -5.72880916e-02f, -1.49248792e-02f, 4.09806035e-02f, -1.17051475e-01f, -1.67149771e-02f, -8.03592503e-02f,
  3.98550590e-04f, 8.19474459e-04f, 8.53830054e-02f, 1.22051695e-02f, -1.17266187e-02f, 5.54364659e-02f, 2.88433451e-02f, -6.27100244e-02f, 6.37041777e-02f, 3.52535434e-02f,
  -3.25302407e-02f, -1.02925058e-02f, 1.69885773e-02f, -2.20443048e-02f, -1.20702432e-02f, -1.15001602e-02f, 3.29297632e-02f, -8.32176954e-02f, -3.23365293e-02f, 1.43541638e-02f,
  -6.09163381e-02f, 3.39681171e-02f, 2.48585101e-02f, 4.12807837e-02f, 2.48950832e-02f, 6.37215078e-02f, 1.82757732e-02f, 2.61620190e-02f, 8.79391655e-02f, -1.18230851e-02f,
  1.91717669e-02f, -4.86448519e-02f, 4.81074192e-02f, 2.52135843e-03f, -1.05769895e-02f, 8.55895281e-02f, 7.28756487e-02f, -6.41206056e-02f, -4.96038795e-02f, -3.59087922e-02f,
  -1.03319496e-01f, 2.28316095e-02f, -1.83874760e-02f, -9.07299221e-02f, -5.38901649e-02f, -7.36659914e-02f, -1.90025906e-03f, 6.08400442e-02f, -3.41178067e-02f, -4.31982502e-02f,
  -5.81575669e-02f, -4.58018505e-04f, -3.33287045e-02f, -5.60573302e-04f, -8.29450414e-02f, -6.20619096e-02f, 4.70327474e-02f, -3.27380113e-02f, -1.85799133e-02f, -1.39639610e-02f,
  2.99647618e-02f, -2.36529753e-01f, -3.49801838e-01f, -1.30878478e-01f, -6.10449212e-03f, -1.88462865e-02f, -5.10738790e-02f, 5.23487404e-02f, 6.73547089e-02f, -4.59367558e-02f,
  -8.12965706e-02f, -5.93195623e-03f, -1.11106277e-01f, -9.66275558e-02f, 2.36803759e-02f, -1.10086717e-01f, -2.31547490e-01f, -1.54180661e-01f, -1.67352967e-02f, 1.65745959e-01f,
  1.73516586e-01f, 3.57768834e-02f, 8.32972005e-02f, 7.61448517e-02f, -6.25981763e-02f, -1.28663138e-01f, -2.16322854e-01f, -9.24920216e-02f, -8.90838057e-02f, -8.01559612e-02f,
  -1.72242567e-01f, -4.96138893e-02f, 8.78249630e-02f, -7.39230216e-02f, -1.13075711e-01f, 6.97190985e-02f, -4.85156849e-02f, -7.36593455e-02f, -6.57923147e-02f, -1.07143998e-01f,
  6.29163235e-02f, 5.53858913e-02f, -4.78684157e-02f, 8.35165381e-02f, 2.60213558e-02f, -3.51363011e-02f, -2.34534647e-02f, -1.62320174e-02f, -3.93562838e-02f, -3.76496054e-02f,
  -3.74914706e-02f, 4.33063656e-02f, -7.53351822e-02f, 4.71378081e-02f, 1.11290384e-02f, -1.12827614e-01f, -8.30744058e-02f, -4.35884036e-02f, -9.70340893e-02f, -1.25587955e-02f,
  3.66283320e-02f, -2.61983811e-03f, -3.87243330e-02f, 8.57340544e-03f, 9.40551236e-02f, -2.18988676e-02f, -4.34601307e-02f, 6.65485635e-02f, -4.41598892e-03f, -3.53781395e-02f,
  -5.52275963e-02f, -4.84656170e-02f, 1.00749858e-01f, -5.70007786e-02f, -7.44215101e-02f, 3.20104063e-02f, -4.03421260e-02f, -1.85616277e-02f, -1.23715354e-02f, 7.20199477e-03f,
  1.57611612e-02f, 1.48813445e-02f, -1.01446889e-01f, 7.02545643e-02f, -7.68806264e-02f, -1.17216274e-01f, 3.83006148e-02f, 9.10836533e-02f, 6.59752218e-03f, -7.35891312e-02f,
  -5.41114993e-02f, -3.15997861e-02f, 3.78848799e-03f, 6.79771230e-02f, -9.36685130e-02f, -1.16656953e-02f, -9.08043608e-02f, -2.92758681e-02f, -7.73086995e-02f, 1.48924384e-02f,
  5.20413183e-02f, 6.02926165e-02f, -3.35243754e-02f, 2.81559955e-02f, 1.31082833e-01f, 3.95460911e-02f, 4.16484401e-02f, -1.29674509e-01f, -4.54149134e-02f, 8.47725645e-02f,
  -9.13794935e-02f, -1.25763759e-01f, -1.50697500e-01f, -9.65341479e-02f, -3.19127180e-02f, -1.15595929e-01f, -1.05483770e-01f, -6.79412931e-02f, -3.59594263e-02f, 5.81380539e-03f,
  -1.13190383e-01f, -1.76049680e-01f, -8.44882056e-02f, -1.12778030e-01f, -1.45488083e-01f, -2.41972372e-01f, -2.87264645e-01f, -9.35628265e-02f, -6.71559498e-02f, -1.97991818e-01f,
  -9.79814455e-02f, 1.61402747e-01f, 9.70363095e-02f, 1.02821037e-01f, 1.34744436e-01f, -1.58628836e-01f, -9.34399366e-02f, 8.58117566e-02f, 1.55179381e-01f, -1.09354138e-01f,
  -3.92408110e-02f, -9.41444710e-02f, 3.54836434e-02f, -7.55842850e-02f, -1.25313342e-01f, -9.92358699e-02f, -1.22936785e-01f, -4.53981236e-02f, -1.26058921e-01f, -2.02766255e-01f,
  1.38731822e-01f, -1.85154513e-01f, 1.09319337e-01f, -9.11244471e-03f, 2.70178951e-02f, -4.33028042e-02f, 7.62468576e-03f, 8.08168426e-02f, 5.70933484e-02f, -1.01512477e-01f,
  -2.58376617e-02f, -6.55498952e-02f, -2.01892443e-02f, -7.64666637e-03f, -1.21233806e-01f, -1.22232251e-01f, 1.58854667e-02f, -6.38906881e-02f, -5.73707670e-02f, -4.12996821e-02f,
  -2.78827325e-02f, -9.08594429e-02f, 3.53089347e-02f, -3.70338410e-02f, -4.49926443e-02f, 1.48290731e-02f, -7.65719597e-05f, -7.52332658e-02f, -8.33716318e-02f, -2.48685619e-03f,
  -1.11299381e-01f, -5.28683066e-02f, -2.74674483e-02f, 5.17060012e-02f, 1.11385656e-03f, -2.82644816e-02f, 2.40660440e-02f, 1.12561798e-02f, -3.14542768e-03f, 4.05476987e-02f,
  4.26069535e-02f, -2.16509290e-02f, -1.27080381e-02f, 3.32318954e-02f, -1.94632635e-02f, 1.63123198e-02f, 1.04238074e-02f, 1.21710147e-03f, 6.69124052e-02f, -7.02380314e-02f,
  -4.45193574e-02f, 4.96424958e-02f, 3.87251079e-02f, 3.68237942e-02f, -2.44545378e-02f, -7.05387220e-02f, 2.47599743e-02f, -3.66752520e-02f, 5.46992710e-03f, -8.20165314e-03f,
  2.46581271e-01f, 1.38079196e-01f, -7.14631900e-02f, -2.70986352e-02f, -4.74876091e-02f, -6.69187605e-02f, 3.81932855e-02f, 4.49539460e-02f, 6.76135048e-02f, -7.18605742e-02f,
  1.55430315e-02f, 7.92833418e-02f, -4.90047261e-02f, -7.75469393e-02f, 1.58494618e-02f, -3.75362039e-02f, 2.99405819e-03f, -2.96989046e-02f, 7.13628232e-02f, 2.63028033e-02f,
  -1.03573494e-01f, -5.64710423e-02f, 6.73121884e-02f, 2.30988059e-02f, 4.22976688e-02f, 5.91521617e-03f, 1.02273151e-01f, -2.38117501e-02f, 7.24814907e-02f, 6.02748841e-02f,
  -2.45912969e-01f, 1.40820220e-01f, 1.14911482e-01f, -3.37260519e-03f, 1.13050587e-01f, 6.10964075e-02f, 3.76861021e-02f, 1.87124871e-02f, 6.70864210e-02f, 5.31569086e-02f,
  -8.53340514e-03f, 3.94008346e-02f, -4.91888598e-02f, -1.14128761e-01f, -1.48526683e-01f, 3.56841721e-02f, -1.90203208e-02f, -1.78018227e-01f, -1.17275998e-01f, -1.42461419e-01f,
  -1.84096023e-02f, -1.94691524e-01f, -1.09120697e-01f, -1.64758667e-01f, 6.05375953e-02f, -5.13615496e-02f, 2.68982854e-02f, 4.33684029e-02f, -3.19393836e-02f, 9.78586301e-02f,
  -4.60098013e-02f, -6.05972521e-02f, -9.19070393e-02f, -3.81837711e-02f, -1.94602087e-02f, -5.32554016e-02f, 3.88814732e-02f, -1.70987938e-02f, -4.04679552e-02f, -8.21567315e-04f,
  -5.60927787e-04f, 3.50283347e-02f, -7.18477666e-02f, 8.87851231e-03f, -1.23652838e-01f, 3.76596004e-02f, 3.46293440e-03f, -4.76394966e-02f, -1.18477218e-01f, 4.72071879e-02f,
  -3.73345017e-02f, -2.01366562e-02f, -1.07332185e-01f, 6.18925318e-02f, -2.22874302e-02f, 3.25552821e-02f, 4.59945165e-02f, 2.91986093e-02f, -7.05517530e-02f, 5.28314449e-02f,
  6.49761483e-02f, 8.48705545e-02f, -1.58712342e-02f, -8.50012675e-02f, 5.83302453e-02f, 9.67049152e-02f, -6.02062419e-02f, -2.29997284e-04f, -4.55170274e-02f, 4.02732864e-02f,
  5.71987778e-02f, 5.75644299e-02f, -4.02386449e-02f, -1.67376781e-03f, 2.70898622e-02f, -5.73918559e-02f, 4.27350067e-02f, -3.77996527e-02f, 4.56271917e-02f, -3.01039424e-02f,
  6.01246255e-03f, 5.63460998e-02f, -5.62481023e-02f, 1.89860519e-02f, 7.57157132e-02f, -4.10212539e-02f, -8.13784674e-02f, 6.77097440e-02f, -3.15910280e-02f, 7.50422403e-02f,
  -1.25940964e-01f, -2.55423840e-02f, -4.06639613e-02f, 2.26768646e-02f, 1.06694169e-01f, 5.50817847e-02f, 2.66149733e-02f, -6.09255806e-02f, 1.76540595e-02f, -1.10282235e-01f,
  7.64384568e-02f, -6.87876623e-03f, -2.90726610e-02f, -1.17361121e-01f, -5.76906465e-02f, 3.41041200e-02f, 1.21346591e-02f, -7.37714395e-02f, 5.58116212e-02f, -4.12007980e-02f,
  4.98188026e-02f, -8.94875303e-02f, -1.44202739e-01f, -5.88875376e-02f, -4.42639105e-02f, -1.31504983e-01f, -1.34698469e-02f, 6.82133576e-03f, -3.36848572e-02f, -1.72824338e-01f,
  1.34323671e-01f, -6.71236664e-02f, -3.60670611e-02f, 5.24435043e-02f, 3.00349072e-02f, -5.83615452e-02f, -1.43322706e-01f, -5.85800819e-02f, -7.36824870e-02f, 8.10523808e-04f,
  8.52418318e-02f, 1.09205045e-01f, 8.56616497e-02f, -9.83254835e-02f, -1.12573788e-01f, -1.80225685e-01f, 2.17893813e-02f, -1.38009125e-02f, -9.36371014e-02f, 2.44503878e-02f,
  2.82609593e-02f, 2.77389679e-02f, 5.08750565e-02f, 3.70720401e-02f, -7.11541846e-02f, 1.62819680e-02f, -5.15790619e-02f, -3.59488488e-03f, 4.78871353e-02f, -9.80746597e-02f,
  -5.51723167e-02f, -6.25223964e-02f, 8.66215862e-03f, 9.33718234e-02f, -6.86790096e-03f, 1.21719074e-02f, -1.25945918e-02f, 5.08831441e-02f, 2.78763939e-02f, -8.06905478e-02f,
  1.77078489e-02f, 1.52931446e-02f, -8.66862833e-02f, 3.29329111e-02f, -5.81712164e-02f, -2.07590405e-02f, -2.33782344e-02f, 1.73514672e-02f, 1.09541286e-02f, 3.69299129e-02f,
  -3.23325046e-03f, 9.50991735e-03f, 4.39058011e-03f, -2.88454536e-02f, -1.23736210e-01f, 5.91331348e-02f, 1.76157281e-02f, -1.22283600e-01f, -6.79585114e-02f, -1.12318313e-02f,
  1.01286940e-01f, 5.44675998e-02f, 3.94776985e-02f, 2.12144712e-03f, -8.29568598e-03f, 3.59106399e-02f, -1.96371824e-02f, 4.83515449e-02f, 8.95181000e-02f, 3.91368233e-02f,
  6.20224625e-02f, 8.23646260e-04f, 4.95902672e-02f, 6.70247972e-02f, 8.63918141e-02f, 4.53980416e-02f, 8.17185193e-02f, 7.97119886e-02f, 4.54458036e-02f, -2.59552170e-02f,
  -9.06085130e-03f, -9.48603824e-03f, 8.46648440e-02f, -5.80420047e-02f, -5.48464768e-02f, -4.22448069e-02f, 6.67736977e-02f, -7.82585368e-02f, -1.79614313e-02f, 9.18724686e-02f,
  1.00321159e-01f, -5.01979887e-02f, 2.90641543e-02f, 3.60130928e-02f, -5.96289989e-03f, -3.56543087e-03f, 9.87700671e-02f, -5.77502362e-02f, -4.21296172e-02f, -5.39714061e-02f,
  -1.07611477e-01f, 4.58918735e-02f, -8.84722471e-02f, -1.03192776e-01f, -4.59728437e-03f, -8.64096284e-02f, -4.55398709e-02f, 7.26787001e-02f, -2.44843643e-02f, -2.83627119e-02f,
  -2.50963755e-02f, -7.84844533e-03f, 4.87886667e-02f, -9.27451402e-02f, 5.32717630e-02f, 1.48237394e-02f, -8.10531899e-02f, 2.33915988e-02f, 2.90093552e-02f, -9.77634341e-02f,
  5.26411869e-02f, -6.46299943e-02f, -9.24056545e-02f, 1.38241544e-01f, -4.54533799e-03f, -9.83798597e-03f, 1.42567307e-01f, 3.50346826e-02f, 1.14560671e-01f, 3.94761302e-02f,
  -6.60668835e-02f, 6.52040243e-02f, -8.63223895e-03f, 4.95790550e-03f, 8.61650035e-02f, 5.72753884e-02f, 3.09562553e-02f, 9.12472233e-02f, 4.72353809e-02f, 2.44260784e-02f,
  1.50581403e-03f, 5.01653366e-02f, -4.20112349e-02f, -5.77805080e-02f, 5.36992401e-02f, -5.15943058e-02f, 3.10872439e-02f, -8.27956870e-02f, 3.33219878e-02f, -5.12625389e-02f,
  -1.72406629e-01f, -5.97438402e-03f, 6.60376623e-04f, -1.66885201e-02f, -1.09971657e-01f, -9.43036452e-02f, 1.79437529e-02f, -1.01492815e-01f, 2.69505773e-02f, 6.70647472e-02f,
  7.11439177e-02f, -1.02223806e-01f, 2.56988611e-02f, 5.38447089e-02f, -6.12760521e-02f, 2.53573246e-02f, -6.59938063e-03f, -6.09756783e-02f, -5.46735525e-02f, -2.89865434e-02f,
  7.98703730e-02f, -9.42512080e-02f, -5.90814874e-02f, -7.49671832e-02f, 7.09751621e-02f, -1.98090374e-02f, -2.59675309e-02f, -2.03613602e-02f, 1.42429795e-04f, -7.80878887e-02f,
  -8.05591345e-02f, 4.58939336e-02f, 3.74026336e-02f, -6.11600392e-02f, 6.22393340e-02f, -4.65648808e-02f, 3.29374671e-02f, 1.46423001e-02f, -7.67855644e-02f, -5.29977232e-02f,
  4.50579040e-02f, 1.71045288e-02f, 6.58225566e-02f, 6.99722767e-02f, 5.87956943e-02f, 6.21418171e-02f, 2.64764410e-02f, 1.70161854e-02f, -2.85029374e-02f, 2.42476584e-03f,
  -6.03570603e-03f, -5.60708605e-02f, -1.16338506e-01f, -6.06562803e-03f, 4.63688932e-02f, 2.60937251e-02f, 6.58237115e-02f, -9.08777788e-02f, -4.82053123e-02f, -8.05070400e-02f,
  -5.57530066e-03f, -1.45418346e-02f, 6.54590577e-02f, 9.04250592e-02f, -8.21910985e-03f, 2.60350034e-02f, -1.20715331e-02f, -2.20551547e-02f, 4.95000323e-03f, -2.55769235e-03f,
  -3.51438858e-02f, 2.15202849e-02f, 4.77600284e-02f, 8.76289851e-04f, -8.25417414e-02f, -5.94792813e-02f, -3.32452245e-02f, 5.76650649e-02f, 6.02487586e-02f, -3.91012989e-02f,
  5.04547963e-03f, 3.91546413e-02f, 2.89547653e-03f, 8.88448134e-02f, 6.05276674e-02f, 5.24677671e-02f, 3.99589874e-02f, 5.16465232e-02f, 6.23137765e-02f, -1.24241356e-02f,
  3.47251855e-02f, -4.02512513e-02f, -1.15421452e-02f, -3.96020636e-02f, -9.59459320e-02f, -5.17223477e-02f, -1.09223865e-01f, -1.15302719e-01f, 2.43933089e-02f, -1.28124833e-01f,
  -3.36421207e-02f, 1.13468297e-01f, 3.17012556e-02f, 1.09168038e-01f, 1.28966078e-01f, -5.98079115e-02f, 5.67517243e-02f, 1.11427389e-01f, 1.55955777e-01f, 1.23750623e-02f,
  2.26954166e-02f, -3.17981280e-02f, 5.05467989e-02f, -6.01927452e-02f, -1.22803517e-01f, 7.26839006e-02f, 2.80371699e-02f, 1.76466927e-02f, 5.78648150e-02f, -1.02865100e-01f,
  -1.78675551e-03f, 3.25393081e-02f, 6.46251813e-02f, 5.46322167e-02f, 6.43397197e-02f, 4.42409702e-02f, -9.39109549e-02f, -9.26931575e-03f, 6.56205565e-02f, -7.13962466e-02f,
  -5.25500849e-02f, 2.67524645e-02f, 1.06211603e-02f, -8.75082836e-02f, 2.59969402e-02f, 3.47587466e-02f, 4.67704050e-02f, 1.13852926e-01f, -2.36521475e-03f, 4.25288305e-02f,
  -4.45367098e-02f, -9.06017646e-02f, -4.45122607e-02f, 4.57301028e-02f, -2.17711441e-02f, 3.67657654e-02f, -7.69021288e-02f, 8.94475281e-02f, -2.80089793e-03f, 1.66808385e-02f,
  5.23610748e-02f, -9.60172340e-03f, -7.71180727e-03f, 3.72822881e-02f, 7.17727691e-02f, -2.30494961e-02f, -5.79183809e-02f, -5.00893407e-02f, 2.25162264e-02f, -3.06763668e-02f,
  1.63333602e-02f, 4.85803783e-02f, -1.79140386e-03f, -3.75687797e-03f, 1.41061330e-02f, -3.59453969e-02f, 5.67013063e-02f, -5.96194193e-02f, 2.89623272e-02f, 3.47655476e-03f,
  2.13220362e-02f, 7.52073973e-02f, 4.06815149e-02f, -1.30936317e-02f, -5.29460162e-02f, 2.38576457e-02f, -3.87634933e-02f, 4.70635816e-02f, -4.76853624e-02f, 3.16806138e-02f,
  -9.46486890e-02f, 1.10265672e-01f, 3.17685604e-02f, -2.89827324e-02f, 3.22877653e-02f, -7.18160793e-02f, 3.42787951e-02f, 2.37832498e-02f, -5.12733087e-02f, -1.15619034e-01f,
  4.94773351e-02f, -2.09968090e-02f, 3.30710015e-03f, 1.12577518e-02f, 7.48417675e-02f, 2.58324388e-02f, -3.35175805e-02f, 6.38196543e-02f, 1.82540473e-02f, -9.54609513e-02f,
  1.40085472e-02f, 1.05382334e-02f, -3.25730853e-02f, 8.48224014e-02f, -4.43017483e-02f, 5.49432710e-02f, -1.19646760e-02f, -9.05686095e-02f, 2.25509070e-02f, -6.84267282e-02f,
  1.99498653e-01f, 7.39168515e-03f, 6.68435246e-02f, 4.47714776e-02f, -4.14736271e-02f, -6.86291382e-02f, 6.29607961e-02f, -4.32754010e-02f, -4.43864092e-02f, 5.50086536e-02f,
  7.35132247e-02f, -8.24065041e-03f, 4.67956588e-02f, -1.76374207e-03f, 2.54147816e-02f, 9.51369405e-02f, 4.87696715e-02f, 1.91446878e-02f, -2.35297810e-02f, -2.06019115e-02f,
  1.13393188e-01f, -1.05560459e-02f, 1.71613507e-02f, 2.82934774e-02f, 2.97254305e-02f, 7.56008625e-02f, 4.33624722e-02f, -4.71525826e-02f, 4.85040769e-02f, 1.99255764e-01f,
  1.71333030e-01f, 6.88819662e-02f, 1.27615500e-02f, -7.88315684e-02f, -1.01234727e-01f, 3.21062095e-02f, -2.78051919e-03f, 7.07200915e-03f, -1.43149793e-02f, 9.14691538e-02f,
  7.30979219e-02f, 2.99588088e-02f, 1.77280679e-02f, -9.68676934e-04f, 1.56527683e-02f, 1.16629433e-02f, 5.17095961e-02f, 3.27832974e-03f, -3.69430482e-02f, 5.95758073e-02f,
  3.99696864e-02f, 6.51609004e-02f, -8.61352030e-03f, -9.23243165e-03f, 1.81043837e-02f, -1.14598207e-01f, -3.94723415e-02f, 2.91704033e-02f, -2.86932103e-02f, -3.14240381e-02f,
  -1.77953893e-03f, -3.74789573e-02f, 8.53966698e-02f, 4.30535972e-02f, 5.84036112e-02f, 2.98479740e-02f, -7.65556283e-03f, -4.56818053e-03f, 2.83106230e-03f, 7.04348907e-02f,
  -3.07060629e-02f, -6.70639127e-02f, -3.39103863e-02f, -1.64269432e-02f, 4.45134379e-02f, -2.98292860e-02f, 1.10658169e-01f, 6.34902343e-02f, -6.96421042e-03f, -2.81223655e-03f,
  -4.19785716e-02f, -1.16360616e-02f, -7.47834966e-02f, -2.20467933e-02f, 1.59380753e-02f, -1.52976708e-02f, 9.16513875e-02f, -3.50661799e-02f, -1.49447415e-02f, -3.46545072e-04f,
  -1.56009257e-01f, -1.69966459e-01f, -1.84700955e-02f, 9.80875716e-02f, -8.10962990e-02f, 5.80268390e-02f, 4.40010808e-05f, -3.74057144e-02f, -5.44484444e-02f, -4.14352156e-02f,
  -7.46776909e-02f, -3.48365381e-02f, -1.67263802e-02f, 5.89906313e-02f, -2.78853662e-02f, -3.96189503e-02f, -1.07326068e-01f, 4.14589345e-02f, 4.66032699e-02f, 7.96310231e-03f,
  -7.89887458e-02f, -1.13482900e-01f, -6.73464360e-03f, -5.17238341e-02f, -2.43041031e-02f, -7.95379058e-02f, -5.48137799e-02f, -8.29240531e-02f, 3.40254307e-02f, 7.03752646e-03f,
  -2.99809664e-01f, -1.00306876e-01f, 3.85925062e-02f, -1.70001119e-01f, 8.96315798e-02f, 5.52882142e-02f, 7.88546503e-02f, -6.37262166e-02f, 1.39160035e-02f, 2.69758776e-02f,
  -7.26391375e-02f, -4.06915322e-03f, 7.82057643e-02f, 1.22920856e-01f, 7.09840804e-02f, 1.45073771e-01f, 1.34238362e-01f, 4.52693738e-03f, 2.33749524e-02f, -5.36392294e-02f,
  1.79020856e-02f, 3.25649083e-02f, -1.11796983e-01f, 5.99731281e-02f, -1.06985018e-01f, 6.26268834e-02f, 2.99816523e-02f, -2.72201896e-02f, -6.26523615e-05f, -6.94845766e-02f,
  -7.58195994e-03f, -1.55448467e-01f, -3.39394715e-03f, -8.43684971e-02f, -5.38572147e-02f, 2.32498534e-02f, -7.42422696e-03f, -5.23848869e-02f, -1.88557766e-02f, -9.19298008e-02f,
  -4.12045270e-02f, 2.29362212e-02f, -4.93462570e-02f, -4.00695615e-02f, 2.65716035e-02f, -1.11853503e-01f, -9.66462586e-03f, -1.21782077e-02f, -4.55239601e-02f, -1.05327874e-01f,
  4.39964347e-02f, 5.43617755e-02f, 3.38389017e-02f, -3.70772444e-02f, 7.36264810e-02f, 2.07162350e-02f, 2.23950949e-02f, 1.36003373e-02f, 1.41792884e-02f, -6.87066317e-02f,
  7.50612020e-02f, -3.23618650e-02f, 5.96226715e-02f, 2.13233400e-02f, -1.10120371e-01f, 1.42943216e-02f, -3.59546468e-02f, -5.08262254e-02f, -8.13584030e-02f, 5.95852323e-02f,
  4.40173596e-02f, 8.01225305e-02f, -5.08735999e-02f, -6.63081929e-02f, 1.02181109e-02f, -3.76326665e-02f, 2.82573793e-02f, 8.67784172e-02f, 6.53774589e-02f, 2.85365153e-02f,
  5.08617498e-02f, -4.14044820e-02f, -1.06843486e-01f, 6.67500049e-02f, 7.25886300e-02f, 9.36521515e-02f, 6.90711588e-02f, 8.94386247e-02f, -2.42876969e-02f, -7.90133029e-02f,
  -5.22446111e-02f, 1.85022995e-01f, -3.74214016e-02f, -5.67749292e-02f, -1.23856794e-02f, 5.91073371e-02f, -3.31168585e-02f, 7.57753011e-03f, 5.68694770e-02f, -5.49782552e-02f,
  -2.25630198e-02f, -7.37852305e-02f, -8.78958404e-02f, 3.95329893e-02f, 2.18987968e-02f, -8.50609690e-03f, -1.69928074e-02f, 9.16937366e-03f, -5.92165329e-02f, 2.24969839e-03f,
  -3.80923040e-02f, -2.56868713e-02f, 2.56961603e-02f, -3.34112719e-02f, -3.84781547e-02f, 2.41737962e-02f, 5.55784814e-02f, 4.86961789e-02f, 2.41792183e-02f, -1.20319478e-01f,
  2.38447979e-01f, 8.23050067e-02f, -1.90613568e-02f, 1.04384460e-01f, -9.36611295e-02f, -1.20033480e-01f, -1.26592100e-01f, -7.59490877e-02f, 6.47165067e-03f, 2.20444519e-02f,
  -8.00063983e-02f, 6.20629415e-02f, -6.86288774e-02f, -9.12576690e-02f, -1.95408210e-01f, -3.16782780e-02f, -4.07636687e-02f, -7.25734755e-02f, -2.58010328e-01f, -1.20481126e-01f,
  -5.22418581e-02f, -5.82063105e-04f, 2.50910576e-02f, -1.01387396e-01f, 8.75208303e-02f, 7.77976289e-02f, 1.37690395e-01f, 8.59966502e-02f, 1.51545433e-02f, 6.09814264e-02f,
  2.40604766e-02f, 1.46191463e-01f, -1.29095903e-02f, -3.41563709e-02f, -6.64553493e-02f, -7.72326905e-03f, -5.11982851e-02f, 2.76052468e-02f, -2.64721271e-02f, 3.95787731e-02f,
  2.26745568e-02f, -9.64214951e-02f, -1.14278393e-02f, -4.43330556e-02f, -2.35112477e-02f, -6.39291713e-03f, 1.71134155e-02f, -4.58178297e-02f, -9.47555825e-02f, -4.90922444e-02f,
  6.56677410e-03f, 1.67018082e-02f, 7.76445642e-02f, -1.19153345e-02f, 4.00019139e-02f, 6.53477460e-02f, 1.56215671e-02f, 1.04073081e-02f, -6.13257885e-02f, 1.50594283e-02f,
  2.35157311e-02f, 2.37322059e-02f, -6.58249184e-02f, 1.06010586e-02f, -7.24538937e-02f, -1.46403899e-02f, -8.42448249e-02f, 3.37075144e-02f, -7.82645047e-02f, -4.75716330e-02f,
  2.68659350e-02f, -4.17869501e-02f, 7.90731013e-02f, -3.27146091e-02f, -5.38301095e-02f, 6.00196570e-02f, -8.19044709e-02f, -5.17632887e-02f, -3.06947995e-02f, 4.43669595e-02f,
  3.19215171e-02f, -5.63670658e-02f, 6.87603876e-02f, 5.05657829e-02f, 3.52523550e-02f, 4.34094779e-02f, -8.23267177e-02f, 3.95002477e-02f, 6.28853515e-02f, -1.00661712e-02f,
  9.70366374e-02f, -1.29115254e-01f, -2.20875684e-02f, -1.01884425e-01f, 6.98904097e-02f, 8.36603995e-03f, -1.42914718e-02f, 7.12596113e-03f, -2.48455554e-02f, -2.51443610e-02f,
  -4.28909473e-02f, -3.74351740e-02f, 8.06039795e-02f, -7.00554177e-02f, -6.81942478e-02f, -6.05854653e-02f, -1.06713392e-01f, -5.79868294e-02f, -8.37813988e-02f, 3.46834362e-02f,
  -5.89678362e-02f, -1.14085525e-01f, -8.14270973e-02f, -7.46332780e-02f, 4.03910652e-02f, -8.81741717e-02f, 4.59085358e-03f, 6.12177700e-02f, -7.95243755e-02f, 8.46083015e-02f,
  -3.09379339e-01f, -5.39462082e-02f, 5.71959466e-02f, -1.10598348e-01f, 8.76826942e-02f, 1.13850586e-01f, 1.56553239e-01f, -1.52515741e-02f, -9.47086606e-03f, 6.24296702e-02f,
  -8.28748103e-03f, -6.38996959e-02f, 5.84012419e-02f, -6.93753213e-02f, -8.12465698e-02f, 1.27007559e-01f, 5.90781122e-02f, 5.83112501e-02f, -1.16965957e-01f, -6.64808005e-02f,
  -1.16869099e-01f, -1.89654529e-01f, -1.46082312e-01f, -2.15605125e-02f, -1.11124977e-01f, -1.31151497e-01f, -1.19202957e-02f, -2.60718521e-02f, 4.16136831e-02f, -4.43895087e-02f,
  8.28552544e-02f, -5.87338060e-02f, 1.14744805e-01f, -2.18085181e-02f, -6.08607829e-02f, 1.31183043e-02f, 1.89237799e-02f, 4.27721366e-02f, -3.50276977e-02f, -7.11968839e-02f,
  -1.79280657e-02f, 5.47628216e-02f, -1.03691861e-01f, 6.01576827e-02f, -1.20382637e-01f, -6.51342561e-04f, -2.10684780e-02f, 2.21425984e-02f, -7.42904916e-02f, 1.02656104e-01f,
  5.30392956e-03f, -9.50460732e-02f, -1.01285137e-01f, 8.39006435e-03f, -1.81703381e-02f, -4.57911827e-02f, -1.87897105e-02f, 2.13032700e-02f, -2.66136341e-02f, 3.72281261e-02f,
  6.70096204e-02f, -4.64024730e-02f, -7.38454163e-02f, 4.16956330e-03f, 7.50751719e-02f, -2.07202155e-02f, -5.55027798e-02f, -9.08041522e-02f, -3.60552296e-02f, -3.52264615e-03f,
  -4.11209799e-02f, 7.25122988e-02f, 3.27428132e-02f, -6.69044703e-02f, 9.69501734e-02f, -8.22734460e-02f, 7.40037039e-02f, -6.08434416e-02f, -1.79467525e-03f, 1.67663712e-02f,
  -1.74164250e-02f, 5.37827015e-02f, 8.30098800e-03f, 4.60904427e-02f, 5.82099110e-02f, -2.30836477e-02f, 9.99871492e-02f, 2.63163410e-02f, -5.45887873e-02f, -3.84818278e-02f,
  -9.19371545e-02f, 2.82569043e-02f, -7.41392747e-02f, -7.23042265e-02f, -7.18218237e-02f, 1.74580887e-02f, 2.63352832e-03f, 5.57565354e-02f, -5.36612906e-02f, -8.45082700e-02f,
  -1.63330766e-03f, 5.76835126e-02f, 7.78081417e-02f, 6.31852224e-02f, 8.85513891e-03f, -5.75440051e-03f, 1.66927800e-02f, -1.34016916e-01f, -3.62999272e-03f, -5.74118979e-02f,
  1.67720858e-03f, -8.34605843e-02f, 2.71572452e-02f, -6.42462745e-02f, -3.62365507e-02f, -4.00387570e-02f, 3.32998410e-02f, 2.57192226e-03f, 2.43051685e-02f, -1.36105552e-01f,
  6.99064210e-02f, 2.18306184e-01f, -9.04712155e-02f, 3.63667943e-02f, -6.26325235e-02f, -1.59717843e-01f, -1.75049394e-01f, -8.69286731e-02f, 1.07873484e-01f, 1.20033227e-01f,
  -6.62291944e-02f, 1.20779932e-01f, -3.71668488e-02f, -3.30878757e-02f, -1.13195889e-01f, -8.18710774e-03f, 4.04045247e-02f, 9.64204129e-03f, -1.34622231e-01f, 1.77859589e-02f,
  3.50832939e-02f, 1.16759524e-01f, 1.26396464e-02f, 9.18115526e-02f, 6.73331097e-02f, -3.56245674e-02f, -5.41017577e-02f, 5.66603094e-02f, 8.82697199e-03f, 1.30808756e-01f,
  3.97883728e-02f, 8.99149403e-02f, -1.76510304e-01f, 1.89677160e-02f, 9.38736275e-02f, 9.68737379e-02f, -3.05565801e-02f, -2.75504380e-03f, 7.50626158e-03f, -7.49960542e-02f,
  4.81335558e-02f, -9.13875103e-02f, 2.37187631e-02f, -2.31176764e-02f, -8.10392275e-02f, -2.60977782e-02f, 9.02752951e-03f, -1.00116633e-01f, -9.00506750e-02f, 1.02924965e-02f,
  -3.73070501e-02f, 6.92868512e-03f, -4.74843308e-02f, -1.26435027e-01f, -1.22618377e-01f, -3.57565880e-02f, -2.57536266e-02f, -7.95609802e-02f, -8.71796235e-02f, 9.73172784e-02f,
  -1.10115774e-01f, -7.52342492e-02f, 2.05557123e-02f, 1.48223834e-02f, -2.44350750e-02f, 2.01709624e-02f, 2.42105220e-03f, -8.10824111e-02f, -2.95558525e-03f, 5.64558804e-02f,
  -8.58554468e-02f, 2.14045364e-02f, -4.76315469e-02f, 4.85864356e-02f, 3.51357423e-02f, -3.46771926e-02f, -6.93412125e-02f, -8.44052657e-02f, 1.77456886e-02f, -9.92643759e-02f,
  -4.07208279e-02f, 1.49467997e-02f, -4.38796841e-02f, -3.66382338e-02f, 2.55264882e-02f, -7.39597604e-02f, -1.99528858e-02f, 1.02809550e-04f, 5.42146228e-02f, -6.19681999e-02f,
  -3.89274620e-02f, -2.45234951e-01f, -4.04458120e-02f, 2.84359716e-02f, 8.22496936e-02f, 4.09116410e-02f, -1.35745136e-02f, -2.73367688e-02f, 9.26373601e-02f, -5.80036975e-02f,
  4.16049808e-02f, -5.45800626e-02f, 4.89211902e-02f, -5.12512997e-02f, -7.95365795e-02f, -4.03271057e-02f, 8.06956515e-02f, 4.75059636e-02f, -7.02195168e-02f, 7.45114088e-02f,
  2.52101738e-02f, 3.78139168e-02f, -3.53974886e-02f, -1.55454921e-02f, 5.98097965e-02f, -2.32697371e-02f, -1.14669606e-01f, -6.99919611e-02f, -9.68490839e-02f, -2.74464511e-03f,
  -1.68140754e-01f, -1.27271963e-02f, -3.61091755e-02f, -1.61979925e-02f, 3.88385318e-02f, 2.92564207e-03f, 1.15740441e-01f, 5.45826331e-02f, 9.08573046e-02f, 3.84696461e-02f,
  1.13104604e-01f, -5.42957783e-02f, -4.78806384e-02f, 2.96593383e-02f, 6.01930879e-02f, 3.91488709e-02f, -3.86383235e-02f, -1.16969235e-02f, -2.30074469e-02f, -4.05196426e-03f,
  -6.93866657e-03f, 5.50678046e-03f, -9.20023024e-02f, -3.61885540e-02f, 6.21869303e-02f, 1.14373453e-01f, 2.27387552e-03f, 2.27846168e-02f, 8.87472704e-02f, 5.21882661e-02f,
  -1.23271048e-01f, -1.37541965e-01f, -1.41608901e-02f, -5.34926429e-02f, -9.59007442e-02f, -5.95602840e-02f, -1.00641370e-01f, -7.72076473e-03f, -5.50340600e-02f, 3.95377427e-02f,
  1.07827252e-02f, -4.03599851e-02f, -9.02495384e-02f, 3.27237025e-02f, 5.79638733e-03f, -7.77282193e-03f, -5.15692420e-02f, 4.67733815e-02f, 7.72089288e-02f, 3.18589956e-02f,
  5.65712228e-02f, -2.13787779e-02f, 3.00280582e-02f, 1.79012455e-02f, 9.63045098e-03f, -5.49579747e-02f, 3.58368480e-03f, 8.45523030e-02f, 3.84979099e-02f, 6.21910542e-02f,
  -9.17762965e-02f, -1.04526125e-01f, -6.59766123e-02f, -7.53516182e-02f, 2.89869234e-02f, 1.35709941e-02f, -3.99549901e-02f, -1.83037501e-02f, -2.63011884e-02f, 7.27724731e-02f,
  -3.39117162e-02f, 3.14196646e-02f, -1.56122157e-02f, -4.99096401e-02f, -8.17052275e-02f, 4.84293140e-02f, 9.02076066e-02f, 9.56646726e-02f, -3.55039798e-02f, -1.15523646e-02f,
  8.96285288e-03f, 5.58493845e-02f, 2.87583418e-04f, 1.68869905e-02f, 3.25166248e-02f, -9.89057496e-03f, -6.81749433e-02f, 4.99980599e-02f, 4.92493361e-02f, 6.06564358e-02f,
  9.90120545e-02f, -7.14385435e-02f, 1.65416393e-02f, 5.84710110e-03f, -4.66330387e-02f, 1.84689891e-02f, 8.02891329e-02f, -5.12774277e-04f, 5.59822023e-02f, -6.62968531e-02f,
  -1.81997605e-02f, -1.30822817e-02f, 5.37251346e-02f, -8.49175379e-02f, 6.02497868e-02f, -3.91155630e-02f, 9.29741412e-02f, 2.78370567e-02f, -1.50631135e-03f, 4.42713685e-02f,
  7.05731362e-02f, -3.41632031e-02f, -4.82114106e-02f, 4.39502634e-02f, 9.24413055e-02f, 7.50894770e-02f, 2.20385958e-02f, -6.43468723e-02f, -3.62982228e-02f, -9.37337726e-02f,
  2.45288178e-01f, 4.25037742e-02f, 1.28153786e-02f, 7.80681744e-02f, -6.24716654e-02f, -2.14014519e-02f, -5.45651140e-03f, 1.32961407e-01f, 1.25269994e-01f, 2.91684475e-02f,
  1.25358135e-01f, 3.89417335e-02f, 1.48340151e-01f, 9.21280831e-02f, 3.27323712e-02f, 4.67279553e-02f, -5.47367148e-03f, 6.46845400e-02f, 3.43806185e-02f, 8.95561278e-02f,
  7.18537718e-02f, -8.70272294e-02f, 5.74242650e-03f, 2.73469370e-02f, -4.32378203e-02f, -3.27478908e-03f, -4.18821117e-03f, -9.25207213e-02f, 2.71550585e-02f, -3.87030803e-02f,
  3.75167094e-02f, 9.42673609e-02f, 1.28114158e-02f, 5.13283834e-02f, 5.04789278e-02f, -5.82348444e-02f, 2.39418056e-02f, -5.66957109e-02f, -4.07594219e-02f, -4.30372320e-02f,
  -8.81816745e-02f, 3.67198400e-02f, -4.10617813e-02f, 3.08537427e-02f, -9.58256871e-02f, 9.60171074e-02f, 1.28755730e-03f, -4.54081036e-02f, 4.04173918e-02f, 1.97108602e-03f,
  -5.15638571e-03f, -4.71443497e-02f, 4.10831394e-03f, 3.33802626e-02f, 7.73420185e-02f, -5.51381931e-02f, 1.12147797e-02f, -2.54009329e-02f, 1.74334962e-02f, 6.59652799e-02f,
  8.56642127e-02f, 1.13973804e-01f, -5.54213859e-02f, 6.27932325e-02f, 1.95254758e-03f, 6.37381151e-02f, 5.92334941e-02f, 4.26191278e-02f, 5.43704219e-02f, 3.68841141e-02f,
  -1.91521365e-02f, 3.36074606e-02f, -2.97718514e-02f, 5.01553975e-02f, 5.92858158e-02f, -9.33812633e-02f, 3.59502658e-02f, 4.60314238e-03f, -3.09970137e-02f, -2.06233747e-02f,
  1.05605453e-01f, 5.22769950e-02f, 3.89863513e-02f, 2.03105453e-02f, -4.46760468e-02f, 4.85696532e-02f, -3.73564288e-02f, -2.87934802e-02f, 3.56330313e-02f, -2.25660969e-02f,
  -7.42297918e-02f, -4.99213450e-02f, 4.92078392e-03f, 3.49858329e-02f, -5.31981001e-03f, -8.23459029e-02f, 8.84048343e-02f, -8.06772932e-02f, -8.57210383e-02f, -6.55614510e-02f,
  2.08011139e-02f, -6.12454908e-03f, -7.76535049e-02f, 2.44663320e-02f, 1.82511788e-02f, -5.05589284e-02f, -1.01794004e-01f, 1.73603110e-02f, 5.95646203e-02f, -1.22415908e-02f,
  1.69829896e-03f, -9.72965453e-03f, -2.80148350e-03f, -6.28952757e-02f, -3.12430449e-02f, 1.18993051e-01f, 5.55234514e-02f, 3.73735242e-02f, 1.05695263e-01f, -6.45541251e-02f,
  1.33643880e-01f, 1.70110375e-01f, 6.80470467e-02f, 3.09520401e-02f, -2.70457447e-01f, -9.23556983e-02f, -1.22331046e-01f, 1.01793118e-01f, -1.79289393e-02f, -3.52032334e-02f,
  -7.12419376e-02f, -1.86572209e-01f, -4.24869880e-02f, -1.42157804e-02f, 9.28495303e-02f, 9.30473208e-02f, -1.13892450e-03f, 1.29833296e-01f, 7.24161938e-02f, -1.17690191e-01f,
  -1.24919983e-02f, -5.50457686e-02f, -1.22461030e-02f, 5.72601408e-02f, 1.21782266e-01f, -3.54303084e-02f, 9.03700362e-04f, -1.13988509e-02f, -4.85528782e-02f, 1.58708006e-01f,
  -8.70248526e-02f, -9.28417500e-03f, 1.63385049e-02f, -2.60102432e-02f, 9.56595596e-03f, 4.25730906e-02f, -3.17839384e-02f, 8.11098665e-02f, -1.76836420e-02f, 3.99549827e-02f,
  -1.32060051e-01f, -9.21649709e-02f, 4.81473878e-02f, 1.96333951e-03f, 6.58922046e-02f, -1.06123574e-02f, -5.27255889e-03f, 2.05285355e-01f, 4.26291190e-02f, -5.15951738e-02f,
  -1.58051476e-01f, -9.35527906e-02f, -6.58186749e-02f, -3.91404005e-03f, 6.19270839e-02f, -9.43513513e-02f, 8.28781873e-02f, 2.65186876e-02f, 1.35662004e-01f, 1.60045758e-01f,
  3.22530344e-02f, 1.66040156e-02f, -4.32062373e-02f, 8.43308459e-04f, -4.42491509e-02f, -4.58467565e-02f, 6.81649446e-02f, -4.55241464e-02f, 7.45852813e-02f, -4.74019423e-02f,
  6.62007928e-02f, 1.52382068e-02f, 6.96328878e-02f, -2.32281797e-02f, -4.72259596e-02f, -2.10434962e-02f, 2.38008462e-02f, -4.80114184e-02f, -5.97487204e-02f, -5.88267343e-03f,
  6.13602018e-03f, 2.96966750e-02f, -2.77680140e-02f, 4.50529009e-02f, -1.95514075e-02f, -4.65258537e-03f, 9.15434584e-02f, -4.75000925e-02f, 4.64474745e-02f, -7.16116652e-02f,
  -7.26478472e-02f, -2.26008490e-01f, 3.29391100e-02f, -1.75892245e-02f, -5.64322136e-02f, 7.76989236e-02f, -1.31245941e-01f, 1.64132880e-03f, 3.35123911e-02f, -2.31384579e-02f,
  -8.22479799e-02f, 3.15516740e-02f, 3.60873118e-02f, -3.95534858e-02f, -8.33977386e-02f, -8.29432309e-02f, -7.83317462e-02f, 2.19101971e-03f, 3.24658491e-02f, -2.68477835e-02f,
  -1.10446379e-01f, -5.78515045e-02f, -6.78113624e-02f, 4.64881305e-04f, -7.34938458e-02f, -1.59018070e-01f, -7.77703226e-02f, -7.60542527e-02f, -2.39639971e-02f, -1.92772225e-02f,
  -6.59152940e-02f, -8.80778357e-02f, -7.13047609e-02f, 6.13092855e-02f, 1.65296806e-05f, -1.48388641e-02f, -5.03901765e-02f, -4.49100463e-03f, 5.55789433e-02f, 6.54345527e-02f,
  2.68151592e-02f, -8.05222020e-02f, -1.40761763e-01f, -2.73224432e-04f, -1.41332865e-01f, -1.65444478e-01f, -1.43493220e-01f, -1.87926471e-01f, -4.13348638e-02f, -7.65312761e-02f,
  1.93576571e-02f, -1.23282179e-01f, -1.09780453e-01f, -3.30819450e-02f, -5.17756352e-03f, -1.43792197e-01f, -3.22186202e-02f, -1.27841800e-01f, -1.04881346e-01f, -1.09547533e-01f,
  -1.03637628e-01f, 9.62525327e-03f, 6.92642853e-02f, 6.86651766e-02f, 6.45181313e-02f, 1.55226691e-02f, -7.75522515e-02f, -5.94712310e-02f, -5.06964549e-02f, 1.79416544e-04f,
  1.53965177e-02f, 5.61614940e-03f, -6.83966279e-02f, 3.60010043e-02f, 3.71032208e-02f, 5.33238426e-02f, -1.15659349e-02f, 6.28810301e-02f, 4.38289717e-03f, 1.12968884e-01f,
  8.13338906e-02f, -2.44455952e-02f, -7.13289604e-02f, 3.17938486e-03f, -2.53567714e-02f, -5.18061034e-02f, -2.33108178e-03f, -1.05406165e-01f, -1.29571095e-01f, 1.17882090e-02f,
  -4.50980365e-02f, -1.27379261e-02f, 1.08469814e-01f, 9.23467949e-02f, -8.87479261e-02f, 6.88727275e-02f, 1.72848646e-02f, 2.56966595e-02f, 3.85621488e-02f, 6.63959682e-02f,
  -5.48680611e-02f, -3.09548564e-02f, -5.59280254e-02f, 1.14791030e-02f, -1.05978154e-01f, -8.49428028e-02f, 4.38446850e-02f, 6.89705834e-02f, -9.22569931e-02f, -5.45425899e-03f,
  4.57150303e-02f, -6.80185929e-02f, 1.06121734e-01f, -4.75610867e-02f, -2.25581843e-02f, 7.31362179e-02f, 7.29038343e-02f, -5.64817935e-02f, 1.11700762e-02f, -4.79064556e-03f,
  7.76341110e-02f, -1.61341161e-01f, -5.59583418e-02f, 1.15339443e-01f, 7.38656968e-02f, 5.35898432e-02f, 2.62353774e-02f, 6.52805194e-02f, 5.42775653e-02f, 1.00205034e-01f,
  9.78490859e-02f, 1.33073637e-02f, 5.87397031e-02f, 8.17022547e-02f, 9.73882601e-02f, 2.86547616e-02f, 8.74318704e-02f, -8.94455537e-02f, -7.99734071e-02f, 1.16061762e-01f,
  1.17859781e-01f, -7.93077424e-02f, 1.69864856e-02f, -5.37903346e-02f, 3.86634246e-02f, -1.67633653e-01f, -5.40771671e-02f, 4.93138023e-02f, -1.56166390e-01f, 2.16485653e-02f,
  -6.24047406e-02f, -4.60801944e-02f, -2.15470582e-01f, -1.25424892e-01f, -2.22451556e-02f, -1.38640450e-02f, -5.18554226e-02f, -1.70965977e-02f, 2.35802922e-02f, -1.22376010e-01f,
  5.55199152e-03f, 3.60723510e-02f, -7.60575533e-02f, 7.67562091e-02f, 7.64784738e-02f, -2.72575282e-02f, -1.51672885e-01f, -8.00743699e-02f, 4.03805748e-02f, 2.95896791e-02f,
  2.98631820e-03f, 8.38396773e-02f, 6.71060979e-02f, -3.46118100e-02f, -7.32384771e-02f, -2.59849802e-02f, -3.98610067e-03f, -5.67098567e-03f, -1.63832251e-02f, -1.07971549e-01f,
  2.65644994e-02f, -6.38230890e-02f, 1.00523517e-01f, 7.19458312e-02f, -7.25838244e-02f, -1.18427284e-01f, 4.11987416e-02f, -9.66458917e-02f, -1.04972467e-01f, -3.29652615e-02f,
  -4.13157716e-02f, 6.05605766e-02f, -7.77483881e-02f, 5.70173264e-02f, 6.49967566e-02f, 6.01985231e-02f, -3.82437647e-05f, 1.57717876e-02f, -4.69289422e-02f, 1.67995933e-02f,
  -5.64022139e-02f, -1.08841471e-01f, 1.11255860e-02f, -7.53792599e-02f, 8.51698313e-03f, 2.27256995e-02f, -5.73270209e-02f, -8.03702325e-02f, 6.39031902e-02f, -6.14410490e-02f,
  1.20639335e-02f, -9.42249130e-03f, 8.93158764e-02f, 2.65583880e-02f, 1.06336214e-01f, -5.11934757e-02f, 3.40444297e-02f, 3.54238078e-02f, 1.48105230e-02f, 7.16614872e-02f,
  3.70825194e-02f, 7.27450699e-02f, 3.05992197e-02f, -4.73886803e-02f, 8.04211646e-02f, -4.24766317e-02f, -1.32272923e-02f, 4.44925530e-03f, -6.56708181e-02f, -2.71720719e-02f,
  7.54260197e-02f, 6.53807074e-02f, 6.80350810e-02f, 3.02201044e-02f, -3.75509867e-03f, -1.03532769e-01f, -3.71707529e-02f, 4.10554819e-02f, -2.27365587e-02f, 4.27177362e-02f,
  5.13819940e-02f, -2.55775098e-02f, -4.48056050e-02f, -1.25092510e-02f, 3.96562293e-02f, 3.24697718e-02f, -4.03414369e-02f, 3.67674902e-02f, -8.62764567e-02f, -8.63036439e-02f,
  -7.01666102e-02f, 7.89100379e-02f, 5.46756238e-02f, -5.19393720e-02f, -2.69267578e-02f, -5.55561408e-02f, 1.72936507e-02f, -2.11964343e-02f, -3.16734202e-02f, 7.89191201e-02f,
  5.57779148e-02f, 2.14760713e-02f, 3.83734182e-02f, 9.69025344e-02f, 6.88319234e-03f, -6.96401522e-02f, 3.05231493e-02f, 8.42875391e-02f, -6.08487353e-02f, -4.10711356e-02f,
  1.67408854e-01f, 1.53327897e-01f, 1.33572876e-01f, 4.25024442e-02f, -8.20799917e-02f, -9.84120741e-02f, 6.92266002e-02f, -2.16836445e-02f, -3.74569930e-02f, -8.35785922e-03f,
  1.27841569e-02f, -6.53293803e-02f, 2.59622056e-02f, 1.17570542e-01f, 4.89419550e-02f, 1.20931670e-01f, 6.65810779e-02f, 1.66775212e-01f, -2.44106147e-02f, 7.34435841e-02f,
  -3.89420316e-02f, -3.36944908e-02f, 1.36303827e-01f, 1.82874855e-02f, 8.05149227e-02f, -3.94475274e-02f, -3.42904963e-02f, 6.33842573e-02f, -3.84712256e-02f, -5.54134138e-02f,
  5.82255907e-02f, 1.38493136e-01f, -8.08525980e-02f, -5.70578873e-02f, -1.01295985e-01f, 7.68013522e-02f, 6.87987879e-02f, -4.21547964e-02f, 3.26592736e-02f, 7.45945200e-02f,
  -9.93400589e-02f, -4.89123687e-02f, -2.02159639e-02f, 4.25833538e-02f, 1.89456977e-02f, 8.33528116e-02f, -4.49645333e-02f, 4.71143275e-02f, -4.54499908e-02f, 9.61790383e-02f,
  -1.35363519e-01f, -8.73151943e-02f, -9.23428386e-02f, -4.74898331e-02f, 5.61878495e-02f, 1.67747680e-02f, -4.65261154e-02f, -1.99417286e-02f, 9.07322913e-02f, 8.20982829e-02f,
  -2.69769244e-02f, 6.66529313e-02f, -4.07944955e-02f, 8.08529034e-02f, -3.43782455e-02f, 5.41367233e-02f, -8.27289149e-02f, -8.31068903e-02f, -4.61100861e-02f, 3.92421857e-02f,
  -6.30673096e-02f, -2.43125763e-02f, 4.18371931e-02f, -6.41014576e-02f, 5.81662171e-02f, -9.07951370e-02f, 9.04813129e-03f, -1.90170649e-02f, 2.50142701e-02f, -6.97316136e-03f,
  -1.99803542e-02f, -3.87234869e-03f, 1.83207802e-02f, 8.54990780e-02f, -2.54268292e-02f, 3.64771672e-02f, 4.72893901e-02f, -5.54144830e-02f, -9.54632312e-02f, 5.46163917e-02f,
  -5.83269149e-02f, -1.33082494e-01f, -3.44918258e-02f, 1.25231743e-01f, -1.41875641e-02f, 9.89771169e-03f, 3.97172794e-02f, -2.04039216e-02f, -1.34959109e-02f, 6.09461032e-02f,
  5.63121960e-02f, 6.81855604e-02f, -9.82274562e-02f, -2.89020520e-02f, 1.92131959e-02f, 5.22060730e-02f, -6.21296316e-02f, -4.21072058e-02f, -8.33893660e-03f, -4.02672595e-05f,
  2.88571161e-03f, 3.36007774e-02f, -8.45712572e-02f, -7.82484338e-02f, -9.58750248e-02f, -6.10531457e-02f, 3.71819399e-02f, -1.14658572e-01f, 2.36371718e-02f, 5.49627058e-02f,
  7.04175094e-04f, -4.07351777e-02f, -2.66597718e-02f, 7.79612735e-02f, -7.84728304e-02f, -1.80518046e-01f, -1.68592528e-01f, -9.49885547e-02f, -5.48760705e-02f, 4.85964194e-02f,
  2.17558946e-02f, 1.28701791e-01f, 3.06906011e-02f, 6.26562983e-02f, -6.85324594e-02f, -8.02080333e-02f, 1.10273056e-01f, 1.34587213e-01f, 6.28833566e-03f, -4.64690588e-02f,
  6.55736402e-02f, 2.31699552e-02f, 1.13799326e-01f, 6.44434988e-02f, 8.28809366e-02f, -2.52096858e-02f, 2.75487583e-02f, -1.04596149e-02f, 5.68811372e-02f, 1.33242920e-01f,
  -3.03351320e-02f, -9.23296288e-02f, -1.05842926e-01f, 8.10476914e-02f, 5.13564833e-02f, -3.16991508e-02f, 1.73481442e-02f, 4.16880613e-03f, -7.18238950e-02f, 5.46002090e-02f,
  5.06223254e-02f, -5.56572825e-02f, -1.29596293e-02f, -7.99689367e-02f, 5.99329695e-02f, 2.12282836e-02f, 3.30385342e-02f, -2.27583405e-02f, -9.58554968e-02f, -2.68063694e-02f,
  -3.90194133e-02f, 6.10574409e-02f, -1.10554561e-01f, -1.09184772e-01f, -5.20311072e-02f, -8.32376629e-02f, -6.21565692e-02f, -9.31066349e-02f, -6.31844997e-02f, 2.60218475e-02f,
  4.09326628e-02f, -2.89532244e-02f, -6.80309311e-02f, 2.43281443e-02f, -3.25161181e-02f, 7.51658753e-02f, -3.64324972e-02f, 1.72364479e-03f, -6.58209622e-02f, 3.07733361e-02f,
  -6.33471832e-02f, -1.47976838e-02f, -6.32036254e-02f, -7.78935179e-02f, 1.77355725e-02f, -1.98458880e-02f, -1.35569535e-02f, 6.43236935e-03f, -8.54801163e-02f, 4.36555669e-02f,
  -2.13818792e-02f, -7.99889788e-02f, 7.69806281e-02f, 8.78347531e-02f, -5.48736006e-02f, -6.54056519e-02f, -7.70901069e-02f, 7.31338486e-02f, 5.37976958e-02f, -3.15058557e-03f,
  7.38465860e-02f, -3.74246500e-02f, 4.54095751e-02f, 6.18184805e-02f, 6.55095577e-02f, -8.53014290e-02f, -3.01883128e-02f, -7.55946413e-02f, -3.85689810e-02f, -9.33421254e-02f,
  -2.21385658e-02f, -2.25460697e-02f, 7.28838816e-02f, 6.38875142e-02f, -5.36277480e-02f, -8.39217380e-03f, 3.00631281e-02f, -1.64752696e-02f, 4.93852422e-03f, -6.41389862e-02f,
  8.22624564e-02f, 1.62939075e-02f, -1.31148309e-01f, -1.13867156e-01f, 4.26769257e-03f, -9.37208161e-02f, -7.50295520e-02f, 9.69931297e-03f, -1.25711158e-01f, -8.76885578e-02f,
  -1.97007895e-01f, -1.10114634e-01f, 7.24205151e-02f, -5.47890626e-02f, -1.30207449e-01f, -4.87812646e-02f, -6.47158325e-02f, -9.38094184e-02f, -6.72869906e-02f, -8.10458511e-02f,
  4.83514369e-02f, 5.74057326e-02f, 6.61853477e-02f, 1.08707301e-01f, -5.30050695e-02f, 4.71423641e-02f, -6.44804016e-02f, 7.39760399e-02f, 1.02357402e-01f, 8.99792463e-03f,
  1.07905166e-02f, -6.09138906e-02f, 1.18717067e-02f, -8.04108232e-02f, 6.75775707e-02f, 6.81374979e-04f, 3.79753076e-02f, -3.60709280e-02f, 4.49069366e-02f, 7.29866624e-02f,
  2.40165338e-01f, -1.96037516e-02f, 7.99515471e-02f, -8.52821991e-02f, -4.59132642e-02f, -5.76037839e-02f, 6.63277730e-02f, -3.82856168e-02f, 9.47785005e-03f, 2.95768119e-02f,
  4.68142424e-03f, -6.45881593e-02f, 7.82441571e-02f, -4.24016193e-02f, 3.08271702e-02f, -7.02499375e-02f, -9.00320262e-02f, 7.68695911e-03f, -4.40038368e-02f, 5.94481267e-02f,
  -2.23813131e-02f, -1.16359375e-01f, -6.54643681e-03f, 6.61070123e-02f, 2.06304919e-02f, 7.79071823e-02f, -2.97327191e-02f, 1.13811577e-02f, 7.58894309e-02f, 3.01959384e-02f,
  -7.40049705e-02f, -2.64308788e-02f, -2.74945237e-02f, 3.88222486e-02f, 4.26591448e-02f, -2.06118845e-03f, -6.47867471e-02f, 2.47401781e-02f, -2.81779058e-02f, 3.31118666e-02f,
  -1.94126053e-03f, -7.95670897e-02f, -4.16444317e-02f, 4.38594893e-02f, 5.05209528e-02f, 2.71202996e-02f, -2.30941270e-02f, 4.33006734e-02f, -5.63014345e-03f, -8.34031329e-02f,
  -2.68682465e-02f, -5.29167913e-02f, 1.71422753e-02f, -3.72388326e-02f, -1.89770982e-02f, -6.68589100e-02f, -3.60830352e-02f, 4.81339060e-02f, -5.79858646e-02f, -5.38830981e-02f,
  8.85694027e-02f, 6.03432991e-02f, 6.44389838e-02f, -3.05615682e-02f, 4.59656343e-02f, -5.06773070e-02f, -5.48395030e-02f, 6.18837066e-02f, -6.61331788e-03f, 4.79412153e-02f,
  -4.77368459e-02f, -4.21824753e-02f, 8.89296308e-02f, 3.58459987e-02f, 7.92723596e-02f, 7.17749670e-02f, -6.57775700e-02f, 4.94724438e-02f, -1.51736895e-02f, -1.86783150e-02f,
  -1.01032674e-01f, -4.67239097e-02f, 8.11089426e-02f, 7.10907802e-02f, 4.33919765e-02f, -5.21807335e-02f, 1.11183092e-01f, -2.30947807e-02f, 9.65333432e-02f, 5.29419929e-02f,
  5.68330381e-03f, -3.58590931e-02f, 9.88805592e-02f, 1.45388199e-02f, 2.42488924e-02f, 1.90463558e-01f, 7.35213384e-02f, 1.53578922e-01f, 1.21011756e-01f, 1.15284882e-01f,
  2.73739570e-03f, 1.36963040e-01f, 8.20131898e-02f, 5.53498268e-02f, 3.62656675e-02f, 3.67696024e-02f, 5.09994365e-02f, -5.26976883e-02f, -2.35188827e-02f, 3.24271154e-03f,
  8.58329013e-02f, 4.75774668e-02f, 2.84067150e-02f, 7.97481760e-02f, -1.12503253e-01f, -3.29472423e-02f, 6.90546036e-02f, -6.04005763e-03f, -9.21611637e-02f, -6.38794294e-03f,
  -1.19252577e-01f, 1.24451739e-03f, -1.68732535e-02f, -7.05401748e-02f, -5.64011000e-02f, -8.86867696e-04f, 4.57664654e-02f, -3.11758239e-02f, 7.38316923e-02f, 7.75471423e-03f,
  1.16896583e-02f, -9.39986408e-02f, -3.33524006e-03f, 3.39153782e-02f, 7.47506693e-02f, 1.03959786e-02f, 3.17740738e-02f, -6.82299137e-02f, -8.07915851e-02f, -5.20354919e-02f,
  -8.08568746e-02f, 1.54309545e-03f, -5.28116636e-02f, 3.61740515e-02f, 1.02728710e-01f, 4.69743758e-02f, 3.39902528e-02f, -4.07450199e-02f, 1.04099594e-01f, -5.53211384e-03f,
  -4.17403355e-02f, -7.81849325e-02f, 2.48253942e-02f, 7.74129927e-02f, 8.77520591e-02f, -5.02757318e-02f, -1.98337827e-02f, -7.14145005e-02f, 9.41821188e-02f, -8.21531937e-02f,
  -7.23721506e-03f, 8.58417600e-02f, -6.45897985e-02f, -8.62230361e-03f, 3.52993309e-02f, -3.98573279e-03f, -3.52826007e-02f, -2.83223763e-02f, -4.13790718e-02f, 2.91356840e-03f,
  5.95658161e-02f, -9.23528373e-02f, -1.01715036e-01f, 2.78475471e-02f, -5.89697063e-02f, 5.95642142e-02f, -5.16072996e-02f, 5.33319972e-02f, -3.73778492e-02f, -5.49159013e-02f,
  -2.32566576e-02f, 9.05635357e-02f, -3.17584425e-02f, -4.32733931e-02f, -8.58383551e-02f, 1.44600458e-02f, -4.39107716e-02f, -8.99025947e-02f, 8.05469304e-02f, -8.30056444e-02f,
  6.95923790e-02f, -2.15015616e-02f, 2.68785767e-02f, 3.99068668e-02f, -6.58146590e-02f, 7.35517144e-02f, -1.63876750e-02f, -6.48141727e-02f, 3.09436601e-02f, -6.34575784e-02f,
  -2.89554279e-02f, -5.21511137e-02f, 1.09207995e-01f, -3.57468501e-02f, 1.82339747e-04f, 5.67032956e-02f, -8.38895217e-02f, -3.96714360e-02f, 4.44608182e-02f, -8.48908871e-02f,
  2.35726312e-01f, -1.07214533e-01f, -1.85453430e-01f, 5.35154939e-02f, -2.66819075e-02f, -6.01235926e-02f, -8.43325183e-02f, 5.88533990e-02f, 6.38616458e-02f, -5.33744358e-02f,
  2.77067609e-02f, 1.01371989e-01f, 1.43309608e-01f, 5.54384887e-02f, 1.58503160e-01f, -8.97226334e-02f, -3.27456917e-04f, 4.50749919e-02f, 1.35692090e-01f, -2.32945122e-02f,
  -1.18194103e-01f, -2.73194611e-02f, 4.44633886e-02f, 8.04310068e-02f, -4.35117148e-02f, -3.25307027e-02f, -1.06562488e-01f, -1.36384681e-01f, -1.31424218e-01f, -1.25843048e-01f,
  -2.15665892e-01f, -1.02706164e-01f, 1.20264307e-01f, 1.41623244e-01f, -8.15626874e-04f, 2.13213302e-02f, -6.79336190e-02f, -9.15717334e-02f, -2.46495232e-02f, -9.68754515e-02f,
  -9.06613469e-02f, -1.42273754e-02f, 5.06234691e-02f, 9.70502105e-03f, -2.11484171e-02f, -7.63245597e-02f, 1.81376841e-02f, 7.40832686e-02f, 3.30744758e-02f, 5.17679611e-03f,
  -3.01908012e-02f, 1.71902049e-02f, 4.29364145e-02f, 3.20989564e-02f, 4.42662798e-02f, 1.07250474e-01f, 3.24260108e-02f, 1.59137920e-02f, -1.48920648e-04f, -1.16205767e-01f,
  -6.25256971e-02f, -2.05336250e-02f, 6.32280186e-02f, -5.31056114e-02f, 9.57830697e-02f, 9.30179209e-02f, -5.33849038e-02f, -5.41601032e-02f, -5.42416237e-02f, 6.08130544e-02f,
  5.41744679e-02f, -2.94182841e-02f, -8.04867689e-03f, -3.36393639e-02f, -3.50498669e-02f, -2.09815614e-02f, 2.83112731e-02f, -3.22740749e-02f, -1.67735796e-02f, -9.05759912e-03f,
  -9.90595575e-03f, -4.64842133e-02f, -5.82196936e-02f, 3.42207998e-02f, -5.40982671e-02f, 3.89068946e-02f, 2.38920748e-03f, 1.97385214e-02f, -3.88727151e-02f, 5.44321351e-02f,
  -8.65642726e-02f, 1.54066995e-01f, 7.37145916e-03f, 4.57907803e-02f, -7.46427178e-02f, 2.50614192e-02f, -7.48003200e-02f, -3.53589095e-02f, 2.24366616e-02f, 3.82093228e-02f,
  3.88242081e-02f, 8.03360045e-02f, 2.94733290e-02f, -3.73943746e-02f, -8.86181295e-02f, -1.04995385e-01f, 2.90327873e-02f, -4.26204205e-02f, -7.09182322e-02f, -1.58141684e-02f,
  4.85757627e-02f, 7.43511394e-02f, 8.73223022e-02f, 4.58404906e-02f, 8.49677771e-02f, 1.14369862e-01f, -9.05181617e-02f, 3.72729972e-02f, 1.79749355e-02f, -8.97016376e-03f,
  -8.68913233e-02f, -1.08699113e-01f, -1.34766668e-01f, -8.42443779e-02f, -7.20570758e-02f, 4.13461551e-02f, -5.30944653e-02f, 2.45436914e-02f, 7.26848422e-03f, -5.56892417e-02f,
  8.35678652e-02f, 9.46377143e-02f, -6.06088303e-02f, -7.92200416e-02f, -3.00911758e-02f, -1.29617274e-01f, -1.67638585e-02f, -4.16568713e-03f, -8.65736008e-02f, 8.28008130e-02f,
  8.41717198e-02f, -6.46809489e-02f, 8.60643294e-03f, 3.80278863e-02f, -6.77086338e-02f, 8.39548707e-02f, 4.13439311e-02f, -6.84272349e-02f, 9.94618610e-02f, 4.48977835e-02f,
  -8.65036100e-02f, 1.75942201e-02f, -3.92230339e-02f, 3.71648706e-02f, -2.45021414e-02f, -1.02686077e-01f, -6.25044703e-02f, -9.67398193e-03f, 6.09405451e-02f, -6.68468028e-02f,
  8.69806260e-02f, -1.92848854e-02f, -8.51740874e-03f, -3.96941379e-02f, 4.68377694e-02f, -9.65235159e-02f, -6.74519837e-02f, 8.98105279e-03f, 5.62400557e-03f, -1.98967550e-02f,
  -3.32161374e-02f, 1.10982850e-01f, -3.42381396e-03f, -5.85809276e-02f, 4.88773780e-03f, -5.37872352e-02f, 7.37320259e-02f, 6.13055751e-03f, -1.07214949e-03f, -1.04283385e-01f,
  4.63807397e-02f, 7.20995963e-02f, -4.41855267e-02f, 3.83711718e-02f, -4.71260538e-03f, -7.12743253e-02f, 1.87124815e-02f, 8.60306099e-02f, -7.83403143e-02f, -3.27867046e-02f,
  1.43582793e-02f, -6.46826625e-02f, 5.06876595e-02f, 6.84587806e-02f, -3.03770602e-02f, 3.86489145e-02f, -4.71106358e-03f, -1.00287823e-02f, -5.05439267e-02f, 2.94513758e-02f,
  3.82829159e-02f, -8.33084062e-02f, 6.95895450e-03f, 1.18318731e-02f, 1.88206546e-02f, 7.99987465e-02f, -2.29707696e-02f, 9.00685117e-02f, 7.29489103e-02f, -8.21927004e-03f,
  -1.08982421e-01f, -4.27014381e-02f, 5.39033152e-02f, 3.21383737e-02f, -6.18080534e-02f, 4.44864035e-02f, -2.52075437e-02f, -2.39184014e-02f, 7.56372809e-02f, -2.42247805e-02f,
  2.19908450e-02f, -4.47951164e-03f, -9.50772408e-03f, 1.06786136e-02f, -2.05844045e-02f, 3.53538804e-02f, 5.74828871e-02f, 7.54036941e-03f, -9.77691412e-02f, -9.42238793e-02f,
  -7.40016624e-02f, -1.00743093e-01f, -8.55833106e-03f, -5.51841222e-02f, 5.59004322e-02f, -7.47209862e-02f, 3.38856243e-02f, 4.90620919e-02f, 5.25400154e-02f, -8.93500075e-02f,
  -1.93866670e-01f, -1.02058435e-02f, -1.41713724e-01f, -3.79797369e-02f, 1.08830281e-01f, 9.21965465e-02f, 8.99240524e-02f, -9.38611384e-03f, -2.48654671e-02f, 6.75821211e-03f,
  6.62816912e-02f, 5.48857450e-02f, -3.97914909e-02f, 1.45725030e-02f, -7.50925392e-02f, 1.18414931e-01f, 1.12686910e-01f, -2.13340558e-02f, -1.16547860e-01f, -4.69649173e-02f,
  1.42350644e-01f, -7.55336285e-02f, -7.33436272e-02f, -1.23958118e-01f, 6.93419501e-02f, 8.87964740e-02f, 3.83262560e-02f, 9.02863294e-02f, 1.65754426e-02f, 8.82573277e-02f,
  -8.48261043e-02f, -7.30831698e-02f, 5.32812476e-02f, 2.95086037e-02f, -2.18906719e-03f, 2.82401741e-02f, -2.71161925e-02f, -9.21412334e-02f, 4.93349545e-02f, -5.87581955e-02f,
  2.95754392e-02f, 1.77010316e-02f, 7.71113858e-02f, -3.60261626e-03f, 4.34144447e-03f, -1.56767648e-02f, -6.83078840e-02f, -8.06231499e-02f, -6.31080121e-02f, -4.08310108e-02f,
  -1.57852611e-03f, 3.38228978e-02f, -4.39984798e-02f, -7.18067458e-04f, -1.08062781e-01f, -8.60343203e-02f, -7.93102309e-02f, -1.12016842e-01f, -2.10492890e-02f, -1.89062625e-01f,
  2.86145713e-02f, -9.05156694e-03f, -6.96682408e-02f, 2.99259517e-02f, -5.83016425e-02f, -4.14114520e-02f, 5.08173332e-02f, 1.08672500e-01f, -4.14835177e-02f, -6.05752170e-02f,
  1.19313328e-02f, -8.74130614e-03f, 4.14113030e-02f, 3.73207405e-02f, 3.42940772e-03f, -6.81863129e-02f, 2.97941826e-02f, 3.04125994e-02f, -5.57968803e-02f, 5.54513820e-02f,
  5.47174066e-02f, 4.80339192e-02f, 2.74098665e-02f, -4.29651886e-02f, -2.60790009e-02f, -5.59614860e-02f, -3.00130881e-02f, 3.95140350e-02f, -5.80638982e-02f, -3.30638364e-02f,
  -7.05829263e-02f, 1.17095709e-02f, -3.56196351e-02f, 4.76395078e-02f, -2.99473610e-02f, 8.02147575e-03f, -1.71254873e-02f, -8.38312060e-02f, 5.45603000e-02f, -6.59223795e-02f,
  -5.15947305e-02f, -2.61409711e-02f, -5.14265448e-02f, 6.32375777e-02f, 3.89420167e-02f, -8.82993490e-02f, 8.36239159e-02f, -7.92683065e-02f, -8.53891745e-02f, 1.58951599e-02f,
  -7.09757879e-02f, -3.51333134e-02f, -1.34590089e-01f, -6.58962503e-02f, -2.25054342e-02f, -4.76932190e-02f, -5.99698126e-02f, -6.58688620e-02f, -8.51430967e-02f, -1.19148619e-01f,
  -6.96735166e-04f, 6.62510172e-02f, -4.11840342e-02f, 5.46539994e-03f, 3.39587545e-03f, -7.75702447e-02f, 1.19676860e-02f, 6.17264882e-02f, 4.09541875e-02f, 3.57721783e-02f,
  -7.16485530e-02f, 1.10848136e-02f, -1.15208879e-01f, 3.29685002e-03f, 5.13364971e-02f, 1.00794315e-01f, -8.81110970e-03f, -2.45659240e-03f, -1.72229409e-02f, 5.38669378e-02f,
  2.76655089e-02f, -4.48688343e-02f, 4.02064547e-02f, -8.35997164e-02f, -7.72633925e-02f, -1.15340456e-01f, -4.63978387e-02f, -1.63422544e-02f, 4.44598962e-03f, 5.93384877e-02f,
  -1.47848442e-01f, -4.81997728e-02f, -9.22201201e-02f, -3.65465954e-02f, -2.35973857e-02f, -7.77309164e-02f, -5.46791814e-02f, -1.01790711e-01f, -3.93140912e-02f, -1.11810982e-01f,
  -9.43578109e-02f, -6.98692491e-03f, -5.46748526e-02f, 6.88047782e-02f, -1.66050382e-02f, -8.20749849e-02f, 6.17710575e-02f, 4.86089103e-02f, 6.12274604e-03f, 4.27066647e-02f,
  3.53762880e-02f, -1.25255555e-01f, -7.70222768e-02f, 6.67341277e-02f, 7.96407163e-02f, -9.06151906e-02f, -5.67675494e-02f, -5.46763726e-02f, -1.98191646e-02f, 1.65851286e-03f,
  4.65077236e-02f, 2.84272451e-02f, 9.85572115e-03f, 4.04247865e-02f, 6.91053495e-02f, -6.93518668e-02f, 2.68877186e-02f, -1.69993043e-02f, -1.47781763e-02f, -7.03249946e-02f,
  1.36343930e-02f, -6.32352531e-02f, -2.06559040e-02f, -7.89689720e-02f, 6.09887429e-02f, -5.81934638e-02f, 3.85425240e-02f, -3.14268768e-02f, 3.25162220e-03f, 6.25793487e-02f,
  -8.73862952e-02f, 5.40356264e-02f, -1.57463308e-02f, 7.70506114e-02f, 4.22028564e-02f, 1.64853800e-02f, 4.78132144e-02f, -6.86395839e-02f, 7.61092305e-02f, -4.27699909e-02f,
  -3.29201147e-02f, -1.11359857e-01f, -1.40993893e-02f, 1.28069073e-02f, 2.95786876e-02f, -9.09826085e-02f, -2.55586882e-03f, 1.53786899e-03f, 5.28530180e-02f, 5.47121093e-02f,
  -6.77000871e-03f, 2.53733527e-02f, -1.03464469e-01f, 3.74359004e-02f, 4.39750217e-02f, -7.52264038e-02f, 4.07654652e-03f, 2.46738009e-02f, 7.14066401e-02f, 8.53132270e-03f,
  -2.91992351e-02f, -7.68457130e-02f, -8.23842175e-03f, 1.38106998e-02f, 4.17679362e-02f, -1.09181777e-01f, -1.19563192e-01f, 2.37005241e-02f, 3.71094756e-02f, 1.30658880e-01f,
  4.54083048e-02f, -8.27429667e-02f, 5.28896376e-02f, -9.83966421e-03f, 4.09190543e-03f, 4.12833691e-02f, -9.49276090e-02f, -8.68204907e-02f, 1.45287244e-02f, -9.30389836e-02f,
  -1.52611420e-01f, -1.47863477e-02f, -7.73045495e-02f, -9.31766704e-02f, -4.12268378e-02f, -3.90450321e-02f, 1.38516650e-01f, 1.40252218e-01f, 1.44655496e-01f, 1.40567720e-02f,
  1.03898477e-02f, 1.27613872e-01f, 1.30511791e-01f, 2.74926447e-03f, 4.76683024e-03f, -5.27914315e-02f, 1.30107999e-02f, 9.67516005e-02f, -1.31640686e-02f, 5.07370606e-02f,
  -9.13249031e-02f, -1.13074323e-02f, -5.48154525e-02f, -5.57173789e-02f, -2.14598347e-02f, 3.08796391e-02f, 3.72910388e-02f, 1.08094253e-02f, 6.38276190e-02f, -8.15182552e-03f,
  -1.15069263e-01f, -8.36584643e-02f, -1.15872830e-01f, -1.21350149e-02f, -6.82163239e-02f, 5.07731363e-02f, 1.11559980e-01f, 3.20724491e-03f, 5.37576852e-03f, 2.64856983e-02f,
  -6.37268052e-02f, -8.28934014e-02f, 5.91014996e-02f, 7.31685907e-02f, 7.15929866e-02f, -5.94894253e-02f, 8.95577446e-02f, -6.70827627e-02f, 1.15368791e-01f, 2.03741230e-02f,
  -6.55144528e-02f, 6.94831684e-02f, 5.82548529e-02f, -6.06124029e-02f, 6.33481815e-02f, 3.96741461e-03f, -6.49077892e-02f, 6.04140311e-02f, 4.41028848e-02f, -8.87468755e-02f,
  -1.33636203e-02f, -1.52129540e-02f, -8.94715637e-02f, -7.54758120e-02f, 4.19353954e-02f, 2.23643836e-02f, -3.30353947e-03f, -6.56092539e-02f, -7.56924599e-02f, -7.25082085e-02f,
  2.11244244e-02f, 6.43195526e-04f, -5.74014150e-02f, 1.65001154e-02f, 7.27738515e-02f, 6.32979944e-02f, -2.06685904e-03f, -7.14993030e-02f, -4.88645025e-03f, 1.96738169e-02f,
  3.26093026e-02f, -3.42949666e-02f, -2.99502071e-02f, -4.02210979e-03f, 6.68337792e-02f, 6.29236996e-02f, -1.17799148e-01f, 1.50763066e-02f, -1.06875129e-01f, 1.63700003e-02f,
  -1.04789294e-01f, -7.26443231e-02f, -3.38659845e-02f, -6.70585185e-02f, 6.18546307e-02f, 8.43539461e-02f, -7.46392086e-02f, 9.28397700e-02f, 7.60410074e-03f, 1.66387472e-03f,
  -3.58988233e-02f, -2.21652109e-02f, 2.73097903e-02f, 1.17907766e-02f, -8.70812684e-02f, -9.89417136e-02f, -1.65676679e-02f, 3.62080522e-02f, 3.03111617e-02f, 3.21338698e-02f,
  7.23791346e-02f, 2.97971871e-02f, 4.52018566e-02f, 3.80240120e-02f, 1.28696099e-01f, 1.76617354e-02f, 5.54115623e-02f, -6.36739358e-02f, 4.39254865e-02f, 3.36341262e-02f,
  1.04176253e-01f, 8.29633549e-02f, 8.98179859e-02f, -5.77583909e-02f, -5.08922115e-02f, -4.43144217e-02f, 2.74173226e-02f, -3.80177014e-02f, 3.87820117e-02f, 8.99256170e-02f,
  1.97244324e-02f, 1.18124232e-01f, -1.01533048e-02f, 7.77512640e-02f, 2.08124425e-02f, 1.83459111e-02f, -6.78733364e-02f, -1.61566343e-02f, -7.54034296e-02f, 4.51854139e-04f,
  4.83362190e-02f, 5.35043031e-02f, -2.63402965e-02f, 2.60514747e-02f, -8.02522153e-02f, -8.71893838e-02f, 9.42226127e-03f, -3.18654068e-02f, 6.99919760e-02f, 8.04033875e-02f,
  -5.08369394e-02f, -4.57036775e-03f, 1.08581549e-03f, -2.30871933e-03f, -1.38355829e-02f, -3.00156269e-02f, -1.06145583e-01f, -1.65181421e-02f, -1.07528701e-01f, 1.89280901e-02f,
  -4.14929278e-02f, -7.26099089e-02f, -6.52821437e-02f, -7.40159526e-02f, 4.70751710e-02f, -4.12654355e-02f, -2.72290539e-02f, -7.26941228e-02f, 1.04181678e-03f, -7.04736337e-02f,
  -7.01219589e-02f, -1.12226762e-01f, -3.45791802e-02f, 5.23903081e-03f, -8.05387124e-02f, 3.01491562e-02f, -6.61036149e-02f, 8.94631520e-02f, -7.49702230e-02f, -5.22442497e-02f,
  -2.62315981e-02f, -6.54759035e-02f, -2.01428980e-02f, 1.80809014e-02f, 8.08951035e-02f, -8.61071199e-02f, 4.04013805e-02f, -6.64293543e-02f, 4.54642177e-02f, -8.77918601e-02f,
  4.03402001e-02f, -2.48554144e-02f, -7.29148695e-03f, -2.44468488e-02f, -6.13374189e-02f, 3.73282097e-02f, 2.16989331e-02f, 3.12026609e-02f, 8.38463455e-02f, -6.69411123e-02f,
  4.90671396e-02f, 6.74801506e-03f, 3.85546163e-02f, 1.83607405e-03f, -8.50736722e-02f, -9.19421911e-02f, -1.93495322e-02f, -4.72710133e-02f, -2.58948002e-02f, -6.59517869e-02f,
  -8.52803215e-02f, -2.09440533e-02f, 1.61579140e-02f, 1.21974824e-02f, -4.15730551e-02f, 3.17124464e-02f, -3.11494712e-02f, -6.16974607e-02f, 2.07472946e-02f, 1.60252172e-02f,
  6.45469725e-02f, -2.76312996e-02f, 9.36506763e-02f, -8.92512500e-03f, -7.34157814e-03f, 1.11785494e-01f, 5.12693115e-02f, 8.17083940e-02f, -2.03243885e-02f, 1.28649458e-01f,
  9.81945843e-02f, -1.84772775e-01f, -1.69118628e-01f, 4.92596999e-02f, -1.13369524e-01f, -1.29060715e-01f, -1.74845636e-01f, 9.45812017e-02f, 7.19033629e-02f, -1.48548514e-01f,
  2.50438116e-02f, 8.21892023e-02f, -8.11782107e-02f, 4.03053463e-02f, 7.28265047e-02f, -2.05051661e-01f, -2.10085720e-01f, -6.07292354e-02f, 4.80438098e-02f, 5.82354479e-02f,
  -4.74123247e-02f, -7.36403093e-02f, 1.06427833e-01f, -6.18135184e-03f, -3.51842202e-04f, -9.29789171e-02f, -8.01874101e-02f, -9.62618440e-02f, -1.61490113e-01f, -2.32597142e-01f,
  -2.29298890e-01f, -5.02105020e-02f, 5.19046336e-02f, 7.31782690e-02f, -1.18172593e-01f, 1.23330783e-02f, -9.44140255e-02f, 1.45713389e-02f, 4.78429161e-02f, 4.57118824e-02f,
  1.07008986e-04f, 6.45011142e-02f, 6.13028705e-02f, 3.71601828e-03f, 5.00793122e-02f, 1.34525253e-02f, -1.79841295e-02f, 8.92603118e-03f, 8.41035973e-03f, -1.14512071e-01f,
  3.24611738e-02f, -5.70878945e-02f, -4.73727426e-03f, -5.11676706e-02f, -3.65759283e-02f, -9.25036594e-02f, 8.91014177e-04f, 4.69479430e-03f, -6.25442341e-02f, -8.94324929e-02f,
  5.53691573e-03f, 1.50513630e-02f, 4.00357880e-02f, 2.38925572e-02f, 3.68324593e-02f, -1.05425883e-02f, 3.54109444e-02f, -6.72534630e-02f, 1.92581359e-02f, 8.02260637e-02f,
  4.28451747e-02f, -7.76542202e-02f, -4.14367914e-02f, 9.86731984e-03f, -5.21456450e-02f, -3.60566154e-02f, 6.21140711e-02f, -1.37237944e-02f, -8.33943114e-02f, -1.30715994e-02f,
  6.67557120e-03f, -7.40878955e-02f, -8.66558105e-02f, 6.19348362e-02f, -1.98602714e-02f, 4.69114594e-02f, 4.86762337e-02f, 1.07851112e-03f, 7.08685070e-02f, 2.29325648e-02f,
  8.16535801e-02f, -9.19120982e-02f, -2.83773225e-02f, -3.48122697e-03f, -2.04868000e-02f, -6.03181571e-02f, -8.59455243e-02f, -3.61609235e-02f, -2.51412746e-02f, -7.07434863e-02f,
  4.13551144e-02f, 1.67583246e-02f, -6.58614282e-03f, -5.09810448e-02f, 9.05146240e-04f, 3.29060853e-02f, -9.12317599e-04f, 2.01016273e-02f, -4.76706848e-02f, -1.76564325e-02f,
  -6.42218068e-02f, -1.00262715e-02f, 9.41393673e-02f, -8.26001691e-04f, -6.63095340e-02f, 1.88406911e-02f, -3.51767316e-02f, 3.37361135e-02f, -6.19020425e-02f, 1.59753729e-02f,
  -8.10601860e-02f, -2.42965370e-02f, 7.02828467e-02f, 1.14870340e-01f, 2.81146169e-01f, 3.71245295e-02f, 4.01601009e-02f, -7.83891156e-02f, -3.92807908e-02f, -2.82239635e-02f,
  4.30517681e-02f, 7.76895359e-02f, 5.66375069e-02f, -9.38269496e-02f, -1.44387931e-01f, -1.87898744e-02f, 9.75701809e-02f, -2.45445538e-02f, -7.87388235e-02f, -2.31475197e-02f,
  1.80277810e-01f, 1.74722433e-01f, -1.58702247e-02f, -1.91228632e-02f, 1.14610828e-01f, 4.81568761e-02f, 1.08908206e-01f, 1.16238832e-01f, 1.34817407e-01f, 4.46618609e-02f,
  -1.02284320e-01f, -7.33718723e-02f, 9.89926234e-03f, 2.36626584e-02f, -8.41402356e-03f, -1.23992637e-01f, -9.09227431e-02f, -6.43553734e-02f, -8.33314136e-02f, -6.87983930e-02f,
  4.39035818e-02f, 4.35709246e-02f, 8.82072300e-02f, -5.69490492e-02f, 5.30146100e-02f, -9.23680738e-02f, -8.49273205e-02f, -1.80790443e-02f, -8.38069469e-02f, -1.16906248e-01f,
  1.15024924e-01f, 1.28856361e-01f, 1.37994194e-03f, -3.27951647e-02f, -5.64425960e-02f, -6.45810217e-02f, -1.10269621e-01f, 9.92912333e-03f, -1.14507899e-01f, -7.05171749e-02f,
  -6.28567766e-03f, 2.41783535e-04f, 5.71246967e-02f, -4.22361009e-02f, 2.43086368e-02f, -1.01433638e-02f, 6.94758818e-02f, 1.64221060e-02f, -4.72813286e-02f, -2.07915343e-02f,
  8.12862348e-03f, -2.35165306e-03f, 6.00203089e-02f, -9.19286385e-02f, -7.29091391e-02f, -5.80521226e-02f, 7.07494095e-02f, -9.95533392e-02f, -5.63073978e-02f, -7.63728768e-02f,
  5.38779460e-02f, -5.06794825e-02f, -3.32038887e-02f, -4.15173769e-02f, 6.84075207e-02f, -6.23263940e-02f, -2.31181830e-02f, -4.13708352e-02f, -8.88258517e-02f, -2.00199522e-02f,
  4.34632413e-03f, 9.97031778e-02f, -6.23357780e-02f, 2.27637533e-02f, -3.09151085e-03f, -8.27699900e-02f, -2.61853798e-03f, -7.23669380e-02f, 1.03867337e-01f, 4.43219729e-02f,
  2.38493029e-02f, -7.15928599e-02f, 3.44828106e-02f, -9.10883024e-03f, 2.06120387e-02f, 6.05655052e-02f, 7.10698441e-02f, 3.26064080e-02f, 2.32667141e-02f, 3.44613045e-02f,
  -2.39824671e-02f, 5.39171509e-02f, 2.68556289e-02f, 3.26073878e-02f, -7.54067628e-03f, -4.02580090e-02f, -1.15509689e-01f, -8.71862993e-02f, 2.26332154e-02f, 3.47927548e-02f,
  1.95796013e-01f, -1.18442439e-01f, -1.01073487e-02f, 6.35717213e-02f, -7.81701356e-02f, 3.17215063e-02f, -7.41883218e-02f, -9.70213264e-02f, 1.50414547e-02f, -9.02727842e-02f,
  -4.74878065e-02f, -9.93809924e-02f, 2.43682433e-02f, 1.13305654e-02f, 1.70018023e-03f, -1.10794574e-01f, -1.05658673e-01f, -1.68641992e-02f, 9.18674245e-02f, 1.34480909e-01f,
  -3.39454575e-03f, 1.98099595e-02f, 5.04696136e-03f, 1.32552147e-01f, 6.76292107e-02f, -5.45259453e-02f, -1.18012451e-01f, 1.52345849e-02f, -2.34908443e-02f, 3.15965004e-02f,
  -1.09096371e-01f, -7.02025890e-02f, 7.26569965e-02f, 3.26371901e-02f, -9.24200267e-02f, 3.52354441e-03f, -6.80959597e-02f, 6.39351234e-02f, -9.31182653e-02f, 2.04522666e-02f,
  9.52261966e-04f, 6.44186810e-02f, 3.27142626e-02f, -1.34270741e-02f, -5.94109967e-02f, 2.16016863e-02f, -5.29280980e-04f, -3.66666764e-02f, -1.28602972e-02f, -7.61186779e-02f,
  -5.72632849e-02f, 3.79003473e-02f, -3.82136293e-02f, 5.31217381e-02f, -3.64423804e-02f, 5.48954308e-02f, -3.95311154e-02f, 7.07450584e-02f, -1.00050902e-03f, -8.21784977e-03f,
  8.31104293e-02f, 8.19649920e-03f, -4.50546332e-02f, -5.88715300e-02f, -5.96791767e-02f, 4.87798676e-02f, -6.74841255e-02f, 1.99011490e-02f, 5.83445765e-02f, -4.99798730e-02f,
  3.85007113e-02f, -8.41086879e-02f, -1.94457211e-02f, 6.85684616e-03f, -4.20161337e-02f, 4.16247454e-03f, 5.86157925e-02f, 3.74081843e-02f, 3.76679562e-02f, -1.84320137e-02f,
  8.61257389e-02f, 7.79842734e-02f, 6.96024969e-02f, -2.21834742e-02f, -3.48822363e-02f, 7.24218190e-02f, 8.57052431e-02f, -3.10458373e-02f, 8.43155291e-03f, 6.52369708e-02f,
  -4.00514416e-02f, -1.05841592e-01f, 6.30984679e-02f, 1.16986647e-01f, -3.87511663e-02f, 6.03469126e-02f, -1.24221236e-01f, -4.66473401e-02f, 2.90378109e-02f, -7.54458830e-02f,
  -6.89937323e-02f, -2.64276844e-02f, -7.79962167e-02f, -3.95768955e-02f, 9.16726217e-02f, 1.07606135e-01f, -5.65359509e-03f, 3.14017348e-02f, -8.00744630e-03f, -7.90081769e-02f,
  -2.77200844e-02f, 4.87202108e-02f, -6.58194050e-02f, -7.81498998e-02f, -1.15063218e-02f, -1.06106438e-02f, -1.22196727e-01f, -9.53363776e-02f, 1.97787881e-02f, 3.90287228e-02f,
  -2.90321648e-01f, -3.87865752e-02f, -1.04091249e-01f, -2.17712224e-01f, -9.29894950e-03f, -9.60850064e-03f, 1.59208268e-01f, 9.67853218e-02f, -8.99697244e-02f, -8.55507553e-02f,
  -4.84317131e-02f, -1.75950125e-01f, -1.67030007e-01f, -9.94408801e-02f, -1.11243978e-01f, -1.23279365e-02f, -2.00788468e-01f, -2.55437285e-01f, -1.43378899e-01f, 2.76911282e-03f,
  -1.72594354e-01f, -2.05309361e-01f, -3.31083059e-01f, -2.16050670e-01f, -2.01706424e-01f, -2.13060394e-01f, -2.31237903e-01f, -1.59255549e-01f, -1.69660419e-01f, -1.22030027e-01f,
  7.19966087e-03f, 7.37729818e-02f, -4.40652966e-02f, 2.83415150e-02f, -5.77026792e-02f, -6.74093962e-02f, -3.54225487e-02f, -7.69720599e-02f, 2.76710019e-02f, 6.43303841e-02f,
  -7.33163580e-02f, 3.37736234e-02f, -3.68262008e-02f, -1.55930603e-02f, -4.02904563e-02f, 6.57028006e-03f, 7.37842359e-03f, -1.17545575e-01f, 4.09888709e-03f, 1.42806992e-01f,
  1.16217211e-01f, -2.94545703e-02f, -2.68089380e-02f, -1.65689904e-02f, 1.53478729e-02f, -6.07260875e-02f, 1.06924055e-02f, -7.28689134e-02f, 4.63261008e-02f, -6.08985983e-02f,
  8.23585223e-03f, -4.22938056e-02f, 5.53933159e-02f, 5.85945137e-02f, -6.13582358e-02f, -3.85756195e-02f, 4.15989384e-02f, -5.78726940e-02f, 2.26624850e-02f, 6.94428291e-03f,
  -3.01880203e-02f, 9.22758207e-02f, -2.22777892e-02f, -7.55865574e-02f, -8.93368870e-02f, 3.42877842e-02f, 4.45683189e-02f, -4.21514437e-02f, -2.16585062e-02f, -4.46322300e-02f,
  4.30586450e-02f, -2.26904061e-02f, 4.49751653e-02f, -5.55825271e-02f, 1.07649893e-01f, 4.04451042e-02f, 9.56877768e-02f, 1.06258847e-01f, 6.94194660e-02f, 5.76176047e-02f,
  -2.30749473e-01f, 4.30564098e-02f, -1.38304767e-03f, -8.86287689e-02f, 9.48904827e-03f, -6.08354062e-02f, 4.38095331e-02f, -1.47533761e-02f, 5.98242581e-02f, 7.83871766e-03f,
  -1.00680841e-02f, -8.32821950e-02f, -4.79807593e-02f, -9.30431858e-03f, -5.29324077e-02f, 5.06367236e-02f, -2.35575978e-02f, -8.76018256e-02f, 1.39371026e-03f, 1.25808895e-01f,
  7.43676201e-02f, 2.40125302e-02f, -1.26359100e-02f, -8.88182968e-02f, 2.37175636e-02f, -6.75167888e-02f, -9.84006971e-02f, -7.80068040e-02f, -1.38203382e-01f, -1.99125886e-01f,
  1.67813584e-01f, 1.13203734e-01f, 3.05077657e-02f, 2.00929176e-02f, -1.63528904e-01f, -3.58815538e-03f, -1.03590600e-01f, -1.61289480e-02f, 4.33445945e-02f, -2.82233190e-02f,
  -2.30368953e-02f, -3.18105780e-02f, -3.88947576e-02f, -2.69843880e-02f, 1.06371164e-01f, 7.37708956e-02f, 4.44270484e-02f, 9.43057463e-02f, 5.11513576e-02f, -1.70883834e-02f,
  2.97034308e-02f, -7.81400315e-03f, 9.76134241e-02f, 5.42466603e-02f, 4.11179103e-03f, -3.59373987e-02f, 1.09678559e-01f, 1.20509937e-01f, -6.31593093e-02f, 1.24968164e-01f,
  -5.80010712e-02f, 9.75019410e-02f, 2.43282318e-02f, -7.01444447e-02f, -6.00199923e-02f, 9.06680971e-02f, -7.45229274e-02f, -2.03774571e-02f, -4.47044931e-02f, 4.07122485e-02f,
  -4.61675301e-02f, 8.55457112e-02f, 7.26586431e-02f, -6.45051822e-02f, 6.70805499e-02f, -6.54831082e-02f, 1.13672346e-01f, -7.41586182e-03f, 1.44167319e-02f, 7.35462904e-02f,
  -2.47431686e-03f, -4.76280637e-02f, 9.68556479e-02f, -2.08199099e-02f, 9.33746547e-02f, -1.03755601e-01f, -1.34524312e-02f, 1.06517663e-02f, 7.07862303e-02f, 2.31973119e-02f,
  -8.91491249e-02f, -6.62718564e-02f, 1.91139560e-02f, -6.96217194e-02f, 4.86074351e-02f, -5.22155799e-02f, 3.12551036e-02f, 6.55377060e-02f, -8.41063932e-02f, 2.27871183e-02f,
  7.32208230e-03f, -3.34833562e-02f, -6.20906577e-02f, -5.40588014e-02f, -7.75964335e-02f, 1.14392200e-02f, 9.40572750e-03f, 8.66702721e-02f, -4.62597124e-02f, -3.61534543e-02f,
  7.30834380e-02f, -2.32478082e-02f, -5.54177910e-03f, 6.87208623e-02f, -2.79680844e-02f, -7.13553205e-02f, -6.82869405e-02f, -8.58584698e-03f, -6.62062094e-02f, 8.62157270e-02f,
  -1.04665585e-01f, -5.12431301e-02f, 5.74363917e-02f, 8.82476345e-02f, -5.59904091e-02f, -2.92488690e-02f, 4.02296707e-02f, 9.05690622e-03f, -4.42078747e-02f, 4.58349995e-02f,
  -6.55695945e-02f, 1.13958597e-01f, 6.42047897e-02f, 5.79289347e-02f, 9.79654770e-03f, -2.66792607e-02f, -2.63192151e-02f, -4.76070978e-02f, 8.66451189e-02f, 5.19488342e-02f,
  -6.66088313e-02f, 5.30267544e-02f, -2.45428905e-02f, -1.24448806e-01f, -9.20402706e-02f, -8.60058218e-02f, -3.09925862e-02f, 1.62148420e-02f, -5.93102910e-02f, -5.85533381e-02f,
  -4.44097705e-02f, 7.09874108e-02f, -1.01730034e-01f, 1.27957940e-01f, 3.50040500e-03f, 6.69117691e-03f, 6.08714186e-02f, 5.66499308e-02f, 1.11402944e-02f, 9.38336030e-02f,
  9.01548043e-02f, 1.02669962e-01f, 8.51186067e-02f, 1.94478165e-02f, -2.61978600e-02f, 6.53198287e-02f, 5.94008109e-03f, -5.43677658e-02f, -1.07250221e-01f, -2.21800413e-02f,
  3.99387851e-02f, 8.05329755e-02f, 4.60140370e-02f, 3.62435021e-02f, 1.68790165e-02f, 6.54828101e-02f, 9.99186933e-02f, 3.50669436e-02f, 9.62384802e-04f, 3.22850458e-02f,
  -9.93808135e-02f, -1.47116378e-01f, -1.39545731e-03f, 4.42021200e-03f, -4.27279733e-02f, -3.13205682e-02f, 3.35847260e-03f, -4.76038922e-03f, -5.73516414e-02f, -8.35753698e-03f,
  -4.03332263e-02f, -3.18577588e-02f, -1.13211032e-02f, -3.32864411e-02f, -3.98062021e-02f, -2.22377456e-03f, -6.53480366e-02f, -6.50891513e-02f, 3.32667083e-02f, 1.97106898e-02f,
  8.20705891e-02f, 1.22687314e-02f, 1.51860239e-02f, -6.87508881e-02f, -1.17234342e-01f, 2.78044045e-02f, -7.01143146e-02f, 4.09184396e-02f, -9.84819382e-02f, -6.10619709e-02f,
  -1.50105774e-01f, -9.46284980e-02f, -6.11415133e-02f, 6.93416521e-02f, -6.81894124e-02f, 3.14324349e-02f, -6.82326779e-02f, 5.52282333e-02f, -7.87563846e-02f, -9.11509171e-02f,
  -4.11475785e-02f, -4.17000614e-03f, -9.70596150e-02f, 4.36838157e-02f, 3.92795391e-02f, -7.30236769e-02f, -1.00156730e-02f, -1.11309312e-01f, -4.17884905e-03f, -9.65864360e-02f,
  2.63334643e-02f, 1.87405944e-02f, -8.16675797e-02f, -6.07065074e-02f, 6.65701777e-02f, -5.19099236e-02f, 8.90462566e-03f, -1.00021601e-01f, -8.53152052e-02f, -3.74226645e-02f,
  9.30077955e-02f, -9.36915502e-02f, 1.13813085e-02f, 3.35515775e-02f, -5.17777875e-02f, 4.63132001e-02f, 7.48328939e-02f, 1.83138642e-02f, 6.38328865e-02f, -9.22208466e-03f,
  -2.63942871e-02f, -1.06329322e-02f, 3.07441317e-02f, -5.48047200e-03f, 5.92285730e-02f, -4.79031093e-02f, -1.85566377e-02f, -6.75884485e-02f, -5.15770130e-02f, 2.67876722e-02f,
  4.67588194e-02f, -4.41100486e-02f, 6.00821860e-02f, -6.11605635e-03f, -2.07588095e-02f, 6.09587692e-02f, 4.95331660e-02f, 3.92041244e-02f, -5.36517315e-02f, 3.56615968e-02f,
  9.98272970e-02f, 8.67064856e-03f, 2.27019787e-02f, 1.26710355e-01f, 6.02043420e-02f, -8.27217773e-02f, -2.53437497e-02f, -5.40267676e-02f, 1.49445817e-01f, 5.09449840e-02f,
  3.38403620e-02f, 1.86268404e-01f, 1.37287349e-01f, 1.53127193e-01f, 1.27899960e-01f, 1.06511116e-01f, -4.66612540e-02f, 3.77198048e-02f, -4.48707044e-02f, -2.02431204e-03f,
  2.30948217e-02f, 8.73100609e-02f, 6.60775006e-02f, 1.27924249e-01f, 8.33449587e-02f, 4.76823710e-02f, 1.07869312e-01f, -3.92137691e-02f, 1.08182222e-01f, 1.04731485e-01f,
  6.89619873e-03f, -9.10653993e-02f, 1.25582337e-01f, 5.27744517e-02f, 6.86206147e-02f, -3.49906203e-03f, -1.48137938e-02f, -1.54818513e-03f, -2.31018662e-02f, 4.06828299e-02f,
  -8.00906643e-02f, 1.07724577e-01f, 3.33096348e-02f, -3.71206813e-02f, 2.74336785e-02f, -3.90395671e-02f, -6.50737584e-02f, 1.02886155e-01f, -2.09022276e-02f, 4.16285992e-02f,
  2.58435570e-02f, -8.82579014e-02f, 7.33388960e-03f, 7.64019191e-02f, 8.42426792e-02f, 1.32545959e-02f, 5.80303892e-02f, -4.16674577e-02f, 1.18495151e-01f, 1.13898106e-01f,
  1.40074035e-02f, 1.53492857e-02f, 6.97695604e-03f, 7.26636201e-02f, -3.86650898e-02f, -1.42263621e-02f, 6.28545508e-02f, 6.39179535e-03f, 3.05917654e-02f, 1.97160174e-03f,
  5.77025115e-02f, 7.03307763e-02f, -2.00942419e-02f, -4.52625565e-02f, 5.43679073e-02f, 3.30448411e-02f, -1.44342519e-02f, -6.12067580e-02f, -4.48071323e-02f, 1.42991645e-02f,
  -4.80174534e-02f, -5.35663627e-02f, 5.01461178e-02f, -7.53457695e-02f, 2.35964693e-02f, 2.53416710e-02f, -3.32049727e-02f, -4.38305438e-02f, -9.73366667e-03f, -1.75978467e-02f,
  6.46884218e-02f, 6.35109022e-02f, 1.10577326e-02f, 3.16855758e-02f, 5.71641810e-02f, 7.76954591e-02f, -2.89707500e-02f, 4.14874218e-02f, -5.99758215e-02f, 4.62766923e-02f,
  -4.43429500e-02f, -4.36920710e-02f, -2.74452958e-02f, -7.47599229e-02f, 4.32489514e-02f, -2.18065269e-02f, 6.32070154e-02f, 1.42929773e-03f, 1.54382351e-03f, 7.55639747e-02f,
  2.09299326e-02f, -1.05570748e-01f, -1.10283177e-02f, -8.46952721e-02f, 1.71841066e-02f, -2.03224868e-02f, -1.07664399e-01f, -3.95062007e-02f, 2.22942084e-02f, -1.09771132e-01f,
  3.68401378e-01f, 5.33732995e-02f, -1.40595436e-01f, 1.85639411e-01f, 3.75209562e-02f, -1.44148037e-01f, -1.21375039e-01f, -9.20459256e-02f, 4.70050648e-02f, 1.55854717e-01f,
  2.77560800e-02f, 1.70958981e-01f, 3.67369168e-02f, 8.00971910e-02f, -2.62760669e-02f, -2.40532067e-02f, 2.30985656e-02f, 4.22426127e-02f, 3.13289985e-02f, 1.54630348e-01f,
  1.59874558e-01f, 1.50851712e-01f, 1.16495624e-01f, -8.42776708e-03f, 1.48543626e-01f, 1.56477109e-01f, 5.31320460e-02f, 6.38816059e-02f, 1.60134509e-01f, 3.09092104e-01f,
  2.65917569e-01f, -4.48053442e-02f, 2.69755106e-02f, 1.32414937e-01f, 2.71378569e-02f, -3.03031877e-02f, 9.18693990e-02f, 3.17513756e-02f, 5.00785969e-02f, -2.48239860e-02f,
  7.99548626e-02f, 5.91573417e-02f, -4.93237637e-02f, -5.80906644e-02f, 3.32671665e-02f, -5.42356856e-02f, -2.24586148e-02f, -1.37002662e-01f, -7.01940060e-02f, 6.62432760e-02f,
  1.51422948e-01f, 1.00850910e-01f, -1.34837821e-01f, -1.89045772e-01f, -9.14034843e-02f, 3.70045230e-02f, -1.27451658e-01f, -5.72016612e-02f, -3.15535180e-02f, -1.52680483e-02f,
  1.33882919e-02f, 4.21508923e-02f, -5.70457019e-02f, 5.77555187e-02f, -1.65773816e-02f, 8.21279362e-02f, -3.50741409e-02f, 6.09271675e-02f, -5.29448204e-02f, 4.25475910e-02f,
  -2.73501035e-02f, 6.72756135e-02f, -4.35350947e-02f, -1.02785314e-02f, 5.08431792e-02f, -4.07588184e-02f, 3.12871188e-02f, 1.69102591e-03f, 4.60761935e-02f, 4.12245803e-02f,
  1.02832131e-01f, 1.66728385e-02f, -7.09865242e-02f, -5.11463881e-02f, 7.33272582e-02f, -1.21642537e-02f, 1.07349828e-01f, 2.66654827e-02f, 5.50022200e-02f, 4.16217744e-02f,
  -3.25517207e-02f, -1.60474524e-01f, 6.63879663e-02f, 2.65883701e-03f, -2.60430258e-02f, 3.20579149e-02f, 4.49355245e-02f, -4.33314964e-02f, -4.25871983e-02f, -3.45374271e-02f,
  1.46915372e-02f, 2.83883382e-02f, -5.94230415e-03f, -3.66811864e-02f, -1.66844402e-03f, -3.55801061e-02f, 2.61549447e-02f, 1.11057516e-02f, -5.67387640e-02f, 1.19861038e-02f,
  -1.27338752e-01f, -5.54527789e-02f, -1.14953063e-01f, -1.53274894e-01f, -1.70290228e-02f, -9.12048947e-03f, -1.01589002e-01f, -8.49991366e-02f, -1.78743839e-01f, -1.14277996e-01f,
  -8.30351114e-02f, -6.50886670e-02f, 9.31606442e-02f, -4.55036648e-02f, 7.62736574e-02f, 8.71927440e-02f, 1.57928243e-02f, 6.27777912e-03f, 2.77150385e-02f, 6.04837090e-02f,
  -1.19533278e-02f, -1.23167202e-01f, 3.51550095e-02f, -3.01845688e-02f, -8.70113373e-02f, -6.66382164e-02f, -2.24413350e-02f, 4.82632108e-02f, 3.00602696e-04f, 5.81001118e-02f,
  4.51811552e-02f, 1.07636504e-01f, 3.82757001e-02f, -3.96959111e-02f, -8.69953930e-02f, -3.71456072e-02f, -6.39211163e-02f, -2.99486220e-02f, 1.20745897e-02f, 5.35682775e-02f,
  9.32347998e-02f, -9.80761275e-02f, 7.97940791e-02f, -1.27485752e-01f, 1.75522529e-02f, 4.43226919e-02f, 5.55195697e-02f, 2.03419812e-02f, -3.10914405e-02f, 6.44592196e-02f,
  -3.51505950e-02f, 6.86572567e-02f, 3.78086492e-02f, -1.43579217e-02f, 7.93136209e-02f, 3.78975831e-02f, 1.23566668e-02f, 9.27868113e-03f, -1.85461193e-02f, 3.69010717e-02f,
  1.74613986e-02f, -1.12685524e-02f, 6.66383877e-02f, -3.83367650e-02f, 3.55014578e-02f, 4.46687378e-02f, -5.59426956e-02f, -1.92403439e-02f, 1.38297882e-02f, -6.60060942e-02f,
  -9.18533932e-03f, 2.06740797e-02f, -6.47902396e-03f, 3.91275249e-02f, 4.30672430e-03f, 4.64278311e-02f, 9.77189280e-03f, -7.00814873e-02f, -6.79442734e-02f, 7.92365372e-02f,
  3.43259834e-02f, -4.57535833e-02f, 7.33829737e-02f, -7.21903294e-02f, 2.97604152e-03f, 6.89584538e-02f, -4.58947755e-02f, -7.61817396e-02f, 1.69246420e-02f, -9.79783386e-02f,
  8.42042118e-02f, 3.28547060e-02f, -6.02063127e-02f, -4.49202769e-02f, 7.25374296e-02f, 3.17216180e-02f, 8.90398994e-02f, -4.51935083e-02f, -7.23403767e-02f, -4.80591804e-02f,
  1.40224591e-01f, -5.00328392e-02f, 6.16960786e-03f, -5.95663600e-02f, -8.26710761e-02f, -1.58940405e-02f, 1.96129587e-02f, 3.44604999e-02f, 2.92610638e-02f, -3.06479745e-02f,
  4.53474037e-02f, 2.51667574e-02f, -5.47694508e-03f, 8.47223401e-02f, 6.55847266e-02f, 8.00627396e-02f, -4.86550527e-03f, 9.42567810e-02f, 5.69786206e-02f, -2.29991116e-02f,
  -1.05747599e-02f, -3.63320559e-02f, 1.39698595e-01f, 7.71132708e-02f, 1.53538808e-02f, -8.10630769e-02f, 2.62401327e-02f, 1.25070035e-01f, 6.77940771e-02f, 5.93039468e-02f,
  -1.86416656e-01f, -8.47218037e-02f, 2.57281698e-02f, -4.53839749e-02f, -8.53869915e-02f, -8.88606310e-02f, 4.90693599e-02f, -1.45472381e-02f, -8.34327787e-02f, -2.29136273e-02f,
  -1.08503304e-01f, 1.06587829e-02f, 6.47584870e-02f, -7.18858689e-02f, -2.99603660e-02f, -5.81415109e-02f, 3.43144163e-02f, 9.56956148e-02f, 5.87727353e-02f, 1.51561592e-02f,
  -2.56625637e-02f, -1.48701454e-02f, 8.54975507e-02f, 7.61385784e-02f, 4.64269519e-02f, -1.28329974e-02f, 3.57923210e-02f, -8.16607848e-02f, -3.73103423e-03f, 4.10000160e-02f,
  1.82108536e-01f, -6.72412664e-02f, -1.69847086e-02f, 2.84461025e-02f, 2.42331661e-02f, 4.65910546e-02f, -5.04196547e-02f, 3.45084071e-02f, 4.34606150e-02f, -1.05196554e-02f,
  -4.46916139e-03f, 7.70277530e-02f, -3.29312943e-02f, -1.14114136e-02f, 2.20761057e-02f, -2.78478186e-03f, 2.38188226e-02f, 4.61518019e-02f, 8.98212940e-02f, 1.02613211e-01f,
  -1.44061390e-02f, -2.62248386e-02f, -5.84304668e-02f, 3.06468755e-02f, -6.09350763e-02f, 1.07660575e-03f, -5.10036200e-02f, -2.80885044e-02f, 7.17076883e-02f, -5.89824561e-03f,
  7.77318850e-02f, 9.02921706e-03f, -3.46165597e-02f, 3.08034401e-02f, 5.31037524e-02f, -8.64927918e-02f, -5.24771549e-02f, -7.15047866e-02f, 7.69477636e-02f, -5.93717657e-02f,
  4.68448065e-02f, 6.82007000e-02f, 8.28602463e-02f, -7.73955286e-02f, 3.49145755e-02f, -8.51237103e-02f, -5.44035286e-02f, 7.99063444e-02f, -7.58444592e-02f, -3.09337135e-02f,
  -5.26328273e-02f, 4.08439599e-02f, -2.16658078e-02f, 9.18895528e-02f, -3.80098931e-02f, -1.43168261e-02f, 5.68799973e-02f, -6.69970214e-02f, -6.66350350e-02f, -6.68070391e-02f,
  2.71881595e-02f, 4.93292287e-02f, -9.14991871e-02f, -5.89743517e-02f, -4.11945917e-02f, 2.12325267e-02f, -5.45977280e-02f, 1.82117838e-02f, -4.44534980e-02f, 1.03868231e-01f,
  1.00433275e-01f, -4.35189568e-02f, 8.36498365e-02f, 5.21949679e-02f, 7.57988393e-02f, -3.63827869e-02f, -1.04784176e-01f, -8.84870887e-02f, 6.64851218e-02f, -1.57986581e-02f,
  -7.27314176e-03f, -4.97480929e-02f, -1.84585266e-02f, -7.86023331e-04f, 6.22497797e-02f, 3.72528508e-02f, 1.14793412e-01f, 3.38959731e-02f, 3.59079125e-03f, 4.96150032e-02f,
  -5.88672562e-03f, 1.70988888e-02f, 7.88176358e-02f, -4.68130559e-02f, 7.46312886e-02f, -5.50896563e-02f, 7.48627931e-02f, 8.52971822e-02f, 5.18110860e-03f, -3.96178849e-02f,
  1.00687258e-01f, -4.89864238e-02f, -3.91407236e-02f, -5.85611835e-02f, -1.63901761e-01f, -1.42917380e-01f, -1.41583920e-01f, -1.98871717e-01f, -1.53055474e-01f, -1.11389026e-01f,
  -1.81550175e-01f, -9.09183174e-02f, -9.63122770e-02f, -7.97874928e-02f, -1.73533503e-02f, -7.11602643e-02f, 3.80749293e-02f, 5.27258851e-02f, 3.52341495e-02f, -1.16650820e-01f,
  -1.54238418e-02f, 1.87796280e-01f, -9.46959555e-02f, -5.91204725e-02f, 4.23217602e-02f, 7.43652657e-02f, -4.25273292e-02f, 7.70647749e-02f, 9.36773792e-02f, 6.89903274e-02f,
  -5.15731461e-02f, 4.03652266e-02f, -7.73186535e-02f, 5.34118637e-02f, 3.83891910e-03f, 2.91820802e-02f, -7.00673312e-02f, -3.74285839e-02f, 3.35429907e-02f, -6.48804009e-02f,
  -1.15825526e-01f, 8.71807709e-03f, 1.38367536e-02f, 9.52252671e-02f, -2.69926377e-02f, 8.20864365e-03f, 1.22720320e-02f, 7.54367039e-02f, -9.51607653e-04f, 6.58073872e-02f,
  -1.01087682e-01f, -3.77677903e-02f, -1.71577893e-02f, 8.06693435e-02f, -9.78548005e-02f, -4.27212231e-02f, -7.65268728e-02f, -6.68014660e-02f, 2.87740808e-02f, -1.66353807e-02f,
  1.60914958e-02f, 1.44276964e-02f, -8.83000493e-02f, 6.09840639e-03f, -1.10157458e-02f, -6.46378752e-03f, 6.41136691e-02f, -1.12122320e-01f, -3.48061090e-03f, 6.16040938e-02f,
  1.46244820e-02f, -3.96550409e-02f, -1.42561346e-02f, 6.00099191e-03f, -2.00750958e-02f, 2.75328308e-02f, 9.60766077e-02f, -5.92106096e-02f, 1.01907477e-02f, 8.93858522e-02f,
  3.78939696e-02f, -1.05574109e-01f, 3.16203646e-02f, -2.02448927e-02f, 5.98778157e-03f, 6.62230477e-02f, 2.70983912e-02f, -5.81795871e-02f, -1.42819015e-02f, -1.38826342e-02f,
  -6.13915063e-02f, -1.70181803e-02f, -8.44463706e-02f, -8.88464749e-02f, -4.21954232e-04f, 3.29144448e-02f, -8.36616009e-02f, -1.21898502e-01f, -7.76969455e-03f, -6.83336407e-02f,
  -7.30849057e-02f, -9.53930840e-02f, -7.44278356e-02f, -9.18319374e-02f, -2.26981547e-02f, -4.03684191e-02f, -1.31279543e-01f, -1.04604147e-01f, -1.48475334e-01f, -1.27572075e-01f,
  -2.73376435e-01f, -1.64309312e-02f, 1.12283655e-01f, -1.54714316e-01f, -5.35524860e-02f, 9.01320279e-02f, 8.52660090e-02f, -7.70712867e-02f, -4.92003150e-02f, 3.65792327e-02f,
  -8.80977362e-02f, -1.21055573e-01f, -2.24429052e-02f, 2.10296027e-02f, -2.14009024e-02f, -6.11501373e-03f, 4.77272272e-02f, -3.38909663e-02f, -3.64240445e-02f, 2.75288802e-02f,
  -1.81409568e-02f, -1.61242746e-02f, -1.71538994e-01f, -8.85071903e-02f, -6.54561818e-02f, 5.01818694e-02f, -3.52494717e-02f, -1.15455508e-01f, -4.59154882e-02f, -3.70089710e-02f,
  9.62225199e-02f, -4.19914946e-02f, -7.40437731e-02f, -1.21722326e-01f, -6.12562485e-02f, 5.63291050e-02f, -2.04565264e-02f, -1.18264928e-01f, -1.05037242e-02f, 5.45437001e-02f,
  1.67973153e-02f, -4.83505381e-03f, -2.09873840e-02f, -1.44219752e-02f, -4.17295061e-02f, 4.09420915e-02f, 6.20447323e-02f, -1.36173759e-02f, 2.12616026e-02f, 6.79565519e-02f,
  4.30576643e-03f, 4.41230647e-02f, -1.77127887e-02f, -3.14726271e-02f, 2.02032253e-02f, 8.90455849e-05f, 1.24462992e-01f, -5.43837622e-02f, 5.97853810e-02f, 7.25367814e-02f,
  6.21712469e-02f, 1.25558153e-01f, -2.66238451e-02f, -5.37886061e-02f, 7.59737790e-02f, 3.99470776e-02f, 2.47134753e-02f, 7.66220763e-02f, 3.57941240e-02f, -6.77283779e-02f,
  6.67080330e-03f, -4.14129272e-02f, 4.59554270e-02f, 3.33894677e-02f, -8.17301646e-02f, -1.36642791e-02f, -5.66268899e-02f, -6.90456331e-02f, 4.20637988e-02f, -6.62011653e-02f,
  4.47464474e-02f, -2.68565509e-02f, -5.73807880e-02f, -8.14914107e-02f, -2.83561572e-02f, -5.15428595e-02f, 8.77065361e-02f, 1.68977045e-02f, -4.58996333e-02f, 2.23735031e-02f,
  8.69216472e-02f, -5.33674173e-02f, -3.44553776e-02f, -6.77296966e-02f, -4.98736240e-02f, -1.64935123e-02f, 4.40436788e-02f, -5.60807995e-02f, -8.14403370e-02f, 1.05475329e-01f,
  -4.98395190e-02f, -9.68844146e-02f, 1.31208962e-02f, -5.28860278e-02f, 2.54305881e-02f, -4.47469130e-02f, -1.85774509e-02f, 3.69858518e-02f, 6.30657747e-02f, -3.67705561e-02f,
  -2.78315432e-02f, 2.06353646e-02f, 7.98578486e-02f, -8.54251161e-03f, -3.22127366e-03f, -1.01027153e-02f, 1.23518735e-01f, 9.30060670e-02f, 9.49183553e-02f, 1.93968877e-01f,
  7.98507184e-02f, -1.18154171e-03f, -7.83318058e-02f, 1.80670451e-02f, -1.25902161e-01f, -1.12186879e-01f, -9.83132422e-03f, -1.00319512e-01f, -5.36269601e-03f, -7.24970084e-03f,
  -9.59539711e-02f, -4.92793582e-02f, 8.06178227e-02f, 1.93569027e-02f, 2.44643539e-02f, -1.01674430e-01f, -2.89752223e-02f, 6.59891590e-02f, 5.64619936e-02f, -9.91319045e-02f,
  -4.97701392e-02f, -3.74997370e-02f, 3.17370556e-02f, -2.70531010e-02f, -4.82775383e-02f, -7.68073872e-02f, -1.27096191e-01f, 1.59340836e-02f, -8.17861930e-02f, 1.02193840e-02f,
  -1.14235766e-01f, -3.83752510e-02f, 7.40053281e-02f, 9.56211612e-02f, 8.97173062e-02f, 5.04386872e-02f, 3.73470969e-02f, 4.22519781e-02f, 2.76525486e-02f, 6.34927750e-02f,
  7.10147768e-02f, 8.40280801e-02f, 7.97979310e-02f, -4.94104661e-02f, -2.09237356e-02f, -8.74300674e-02f, 4.18477021e-02f, -2.05920935e-02f, 5.66718308e-03f, -2.03868579e-02f,
  3.74937691e-02f, -2.93023158e-02f, -6.35447875e-02f, -6.95884752e-04f, -6.88122958e-02f, 4.54889759e-02f, 4.39498611e-02f, -3.65986787e-02f, 5.76792136e-02f, -3.48829068e-02f,
  2.43780576e-02f, -1.78857688e-02f, -1.94144361e-02f, 2.74196453e-02f, -3.53622027e-02f, 6.23982809e-02f, 2.89275963e-02f, -3.99211980e-02f, 4.23090868e-02f, 6.40305504e-02f,
  -6.97043389e-02f, -4.12932932e-02f, -5.78827336e-02f, 3.94834839e-02f, -3.68413702e-02f, -7.55198449e-02f, -4.79197949e-02f, 6.71227202e-02f, 7.76918083e-02f, -6.51068091e-02f,
  -4.39826436e-02f, 6.17417097e-02f, 5.13186380e-02f, -1.20581118e-02f, 1.49879530e-02f, 2.94345226e-02f, -7.26013631e-02f, 1.42304739e-02f, 5.28037287e-02f, -1.04132555e-02f,
  -1.24866262e-01f, 5.03843166e-02f, -1.58359408e-02f, 3.60519066e-02f, 6.33343011e-02f, 3.50462296e-03f, 2.19166670e-02f, 9.25673246e-02f, -1.72458366e-02f, -1.19656757e-01f,
  -2.96386629e-02f, -4.27322574e-02f, -7.12918723e-03f, -4.80716936e-02f, -1.69327686e-04f, -1.19840093e-02f, -9.03230719e-03f, -2.39090379e-02f, 6.46111891e-02f, -4.36051562e-02f,
  1.16263308e-01f, 4.01070081e-02f, 1.08870246e-01f, 1.17906243e-01f, -5.02647646e-02f, 3.15158926e-02f, -5.67852370e-02f, 3.08881011e-02f, -1.47593338e-02f, 1.36923864e-01f,
  -1.37351513e-01f, -4.25517708e-02f, 3.22072618e-02f, 1.25384092e-01f, 1.10312462e-01f, 4.25534695e-02f, -8.97784457e-02f, -8.17900822e-02f, 8.63699522e-03f, -3.65675986e-02f,
  5.77842966e-02f, -4.92534228e-02f, 9.01101977e-02f, 3.73135842e-02f, -6.96570352e-02f, -8.46159458e-02f, 3.38923521e-02f, 1.38367778e-02f, -2.03528441e-02f, -1.82588492e-02f,
  -5.33527620e-02f, -7.09244460e-02f, -1.75250899e-02f, 4.28902619e-02f, 7.93111324e-03f, -3.79903093e-02f, 1.83586292e-02f, 6.00215793e-02f, -5.27950302e-02f, 7.43914470e-02f,
  3.58954854e-02f, -6.57899156e-02f, -5.08055603e-03f, -3.73133607e-02f, 1.25326395e-01f, 4.17108648e-03f, 1.40087754e-02f, 8.77382904e-02f, -4.45339009e-02f, -7.09295347e-02f,
  2.01596767e-02f, -6.57995231e-03f, 7.82016069e-02f, -6.14715032e-02f, -7.28435963e-02f, -3.33945081e-02f, 6.97308853e-02f, -8.81294087e-02f, 6.15561977e-02f, -5.15458323e-02f,
  -9.10173729e-02f, -7.14280456e-03f, -2.92789601e-02f, -3.61353857e-03f, -7.63531849e-02f, -9.96539071e-02f, 4.95906807e-02f, -7.29593858e-02f, -6.96345866e-02f, -6.18118048e-02f,
  2.86171995e-02f, -6.93880618e-02f, -2.47387849e-02f, -1.14475368e-02f, -1.15097174e-02f, -6.69862479e-02f, 4.38668653e-02f, 4.02125670e-03f, 4.50266385e-03f, -3.55506204e-02f,
  4.47900873e-03f, 3.97143625e-02f, 4.49714214e-02f, 4.21161503e-02f, 3.70841771e-02f, 2.73146089e-02f, 3.95528749e-02f, -3.39114144e-02f, 1.60053242e-02f, -4.51124981e-02f,
  3.40779908e-02f, 3.97025682e-02f, 8.90301093e-02f, -7.21629634e-02f, 6.69988394e-02f, -7.83065856e-02f, -1.85177270e-02f, -4.87708747e-02f, 5.31866439e-02f, -4.30700183e-02f,
  3.11861001e-02f, 1.05572805e-01f, -7.04379380e-03f, -9.92860878e-04f, 7.61157349e-02f, 3.50751467e-02f, 5.68848569e-03f, -1.24780228e-02f, 1.11793742e-01f, -1.19304247e-01f,
  4.63488959e-02f, 2.03409754e-02f, -4.60856874e-03f, 1.50506105e-02f, -5.47139496e-02f, -6.81482106e-02f, -3.80277894e-02f, 3.40761133e-02f, -8.30284879e-02f, 1.24320411e-03f,
  -2.29726620e-02f, -8.15309435e-02f, -1.26484176e-02f, -2.12475918e-02f, -6.82536140e-02f, 2.30124081e-03f, -7.55601525e-02f, 3.38357352e-02f, -6.15097806e-02f, -7.16696754e-02f,
  -8.09373707e-02f, -3.36288065e-02f, -2.94166952e-02f, 9.33483541e-02f, -4.06918339e-02f, -7.42575675e-02f, -7.99871907e-02f, -1.23186335e-01f, 8.69690999e-03f, 1.47578353e-02f,
  -3.33142430e-02f, -4.87251803e-02f, -4.56276871e-02f, -5.93043603e-02f, -1.80014193e-01f, -1.33011356e-01f, -3.89223620e-02f, -7.77912959e-02f, -3.88265923e-02f, -8.84331688e-02f,
  -4.34141085e-02f, -8.62463843e-03f, 4.86149546e-03f, 7.96246435e-03f, -5.43147465e-03f, -5.12917340e-02f, 4.22350354e-02f, -4.51323427e-02f, -6.07610568e-02f, 8.53421465e-02f,
  1.35297030e-01f, 8.75401422e-02f, -3.51728834e-02f, 3.95545177e-02f, 6.80522099e-02f, -7.53493458e-02f, -7.64438733e-02f, -5.49363457e-02f, -1.26120523e-02f, -3.94785553e-02f,
  8.35803375e-02f, 3.98128014e-03f, 3.70501839e-02f, -5.67306280e-02f, -7.67958462e-02f, -3.09903803e-03f, 8.99360608e-03f, -1.54888183e-01f, -2.51251608e-02f, -5.30673638e-02f,
  -3.77762578e-02f, -4.65844199e-02f, -1.14012860e-01f, -4.96290065e-02f, -9.67536718e-02f, -1.05748661e-01f, 1.40530923e-02f, -1.05744347e-01f, -1.09415658e-01f, 4.61191125e-02f,
  2.38392618e-03f, -5.07100783e-02f, 1.44195799e-02f, 2.31003971e-03f, -5.90330139e-02f, 4.77027893e-02f, 2.48283073e-02f, 5.45961484e-02f, 1.14554521e-02f, -4.95797675e-03f,
  -2.88520902e-02f, -2.27812808e-02f, -6.96832091e-02f, 4.99759503e-02f, 2.77935006e-02f, 2.99179484e-03f, -7.87363853e-03f, -8.13657790e-02f, -5.58970869e-02f, 1.45249199e-02f,
  1.28947813e-02f, 7.50721842e-02f, -3.71217392e-02f, -4.02012765e-02f, 4.04665172e-02f, 1.41789140e-02f, -1.86010171e-02f, -6.04268014e-02f, -8.23400244e-02f, 8.29790086e-02f,
  2.21922472e-02f, -1.00954259e-02f, -4.68316115e-02f, -3.18102352e-02f, 2.85015884e-03f, -4.84125018e-02f, 8.52302834e-02f, -6.22250289e-02f, 4.55936715e-02f, 5.04971705e-02f,
  1.63001046e-02f, -1.57790184e-02f, -4.50649261e-02f, 5.54499850e-02f, -5.74159995e-02f, -7.96244815e-02f, 2.86074635e-02f, 3.59050110e-02f, 3.02425791e-02f, -2.34127138e-02f,
  -1.15694366e-01f, -1.37593582e-01f, -1.57723233e-01f, -7.94062857e-03f, 5.57371229e-02f, -8.08518603e-02f, -1.39483020e-01f, -4.81515937e-02f, -5.87136671e-02f, -1.87055320e-01f,
  3.82176787e-02f, -2.02124640e-01f, 9.85881761e-02f, 9.32090431e-02f, 2.18287095e-01f, 1.61075264e-01f, 1.18323311e-01f, -1.58756156e-03f, 6.59299046e-02f, 5.28523102e-02f,
  -3.90077084e-02f, -1.31070808e-01f, 1.37916915e-02f, -5.51034138e-02f, -1.00147732e-01f, 1.12770885e-01f, 4.85047475e-02f, 1.07258141e-01f, 7.76438937e-02f, 1.03744678e-01f,
  -5.41319959e-02f, 6.88223839e-02f, 8.23553726e-02f, 3.37793236e-03f, 3.14139239e-02f, 1.10925078e-01f, -1.94263235e-02f, 1.38517246e-02f, 5.56624718e-02f, 8.87701511e-02f,
  -8.72503221e-02f, -1.44607620e-02f, 1.24090105e-01f, -3.53857130e-02f, -9.64717660e-03f, 6.51038159e-03f, -2.20815409e-02f, -6.48582727e-02f, -4.42892984e-02f, -8.42404831e-03f,
  2.24273279e-03f, 2.75571435e-03f, -8.31572637e-02f, -7.70309791e-02f, 7.75672719e-02f, 8.24334174e-02f, 3.18068452e-02f, -1.02286540e-01f, -8.18214267e-02f, -1.26569510e-01f,
  -5.84140942e-02f, 2.11999211e-02f, -9.46779177e-03f, -6.87826872e-02f, -9.60078537e-02f, 5.27033489e-03f, 3.61409672e-02f, 3.44696231e-02f, 4.02701795e-02f, 8.54994878e-02f,
  1.02006746e-02f, -7.03025982e-02f, 3.35991308e-02f, -9.70063824e-03f, 6.19770475e-02f, -6.37550652e-03f, 6.31259158e-02f, -7.10464716e-02f, 1.45227583e-02f, 8.86958241e-02f,
  8.50000139e-03f, 7.86853861e-03f, 3.04049794e-02f, 4.60107066e-02f, -1.59761161e-02f, -3.01556638e-03f, -5.59848100e-02f, -6.06433563e-02f, -2.64956392e-02f, 7.39950389e-02f,
  1.53740840e-02f, 8.66861567e-02f, -4.03383411e-02f, -9.35804322e-02f, -2.51029748e-02f, 8.48782365e-04f, 8.47909227e-03f, -2.77837329e-02f, 1.90212429e-02f, 3.23676802e-02f,
  -8.38905666e-03f, 4.66575809e-02f, 4.88570780e-02f, -3.03458851e-02f, 1.11077771e-01f, -2.14516260e-02f, 4.45875898e-02f, 5.32632992e-02f, 1.06680430e-02f, -1.35398721e-02f,
  -1.02793880e-01f, -6.66297739e-03f, -4.51081693e-02f, -6.59540743e-02f, 1.44431487e-01f, -2.31388435e-02f, 3.51423323e-02f, 6.25064299e-02f, 3.19527537e-02f, -2.33359858e-02f,
  -1.39572412e-01f, 1.08735614e-01f, 1.56569093e-01f, 1.01547785e-01f, -2.71958634e-02f, 1.34413928e-01f, -3.55820730e-02f, 1.17215753e-01f, 4.79216746e-04f, 6.37422875e-02f,
  3.76054168e-01f, 2.65355289e-01f, 2.07328439e-01f, 6.40522130e-03f, 3.94564644e-02f, 1.58910349e-01f, 2.26813212e-01f, 7.85431787e-02f, -6.16383888e-02f, 1.12867400e-01f,
  1.30857706e-01f, -1.06185533e-01f, -1.75625216e-02f, -4.22261432e-02f, -5.84069602e-02f, 7.99780264e-02f, -1.04543589e-01f, 9.84250009e-02f, 4.01301906e-02f, 2.78843939e-02f,
  -4.31947131e-03f, 9.15682614e-02f, 4.21873406e-02f, -1.06002325e-02f, 3.45163979e-02f, -5.29195033e-02f, 5.44412360e-02f, 1.59517959e-01f, 1.39470637e-01f, 2.41569988e-02f,
  1.69169590e-01f, 3.31729680e-01f, -2.07349882e-01f, -7.37296045e-02f, 4.89451960e-02f, 2.48677358e-02f, 7.03266338e-02f, -1.98871288e-02f, -4.84304987e-02f, 1.34197930e-02f,
  -6.74032792e-02f, -6.70539513e-02f, 7.18839988e-02f, 5.74864820e-02f, 6.35877531e-03f, 2.78715398e-02f, 2.47013476e-02f, 6.45093992e-02f, 8.84528086e-03f, 5.96179254e-02f,
  -8.70975479e-02f, 1.08054712e-01f, 1.17241964e-01f, -9.97591838e-02f, 8.02028403e-02f, -5.49063161e-02f, 3.93721946e-02f, 9.94848311e-02f, 6.14905730e-03f, -1.99851077e-02f,
  4.08766679e-02f, 2.38641221e-02f, 1.00367643e-01f, -3.47442552e-02f, 7.30431750e-02f, -2.52900068e-02f, -7.71892741e-02f, 7.78123885e-02f, 6.21688291e-02f, 8.16077217e-02f,
  -4.68921140e-02f, 3.88384573e-02f, 3.13807651e-02f, -5.18460758e-02f, -3.70206349e-02f, -1.84756815e-02f, 5.85558265e-02f, -4.07224298e-02f, 1.08364224e-01f, 1.98596511e-02f,
  -1.24111343e-02f, 2.24034917e-02f, -3.78546193e-02f, 7.07732141e-02f, 3.45226973e-02f, 8.72446448e-02f, -1.17098195e-02f, -7.86219444e-03f, 8.42035636e-02f, 7.70150498e-03f,
  -1.32364139e-01f, -4.79668044e-02f, -1.15784392e-01f, -1.17149539e-01f, -3.79996747e-02f, -6.69198763e-03f, -2.00570421e-03f, 3.34222205e-02f, -9.63118523e-02f, 3.11166923e-02f,
  -1.92306545e-02f, -1.75187662e-02f, -1.74848625e-04f, -6.90103928e-03f, 5.50170289e-03f, -5.50501682e-02f, -7.04578534e-02f, 1.80260129e-02f, -3.94850709e-02f, -5.34903258e-02f,
  -6.66194558e-02f, -7.60546401e-02f, -5.72023429e-02f, -3.58237177e-02f, -1.14107784e-02f, -1.21065557e-01f, -7.13370815e-02f, -1.02366313e-01f, 1.58464722e-02f, 7.15201860e-03f,
  -2.29761004e-01f, 3.25530581e-02f, -1.41722307e-01f, 2.60516144e-02f, 1.82496786e-01f, 5.33720925e-02f, 1.15758158e-01f, 7.95245990e-02f, 2.01697066e-01f, 1.39668941e-01f,
  1.42707586e-01f, 1.29380301e-01f, 1.10636480e-01f, 2.19366625e-02f, 4.48931716e-02f, 2.21771616e-02f, 1.84165731e-01f, 6.33272529e-02f, -7.32316775e-03f, 2.73450483e-02f,
  1.61420971e-01f, 9.10135508e-02f, -8.48650932e-02f, 6.35862797e-02f, 8.14919993e-02f, 6.93002120e-02f, 7.53212627e-03f, 4.59613800e-02f, 6.99319020e-02f, 1.36434108e-01f,
  -1.33148134e-01f, -1.11438029e-01f, 4.24770415e-02f, 8.55345428e-02f, 8.08033440e-03f, -7.79377110e-03f, 3.17535028e-02f, -9.51555744e-02f, -3.01509500e-02f, 6.18719086e-02f,
  -6.05515130e-02f, -7.47649297e-02f, 2.39664922e-03f, -2.00173818e-02f, -6.83312714e-02f, 5.84522262e-03f, 1.70375574e-02f, -1.19634293e-01f, 2.31625102e-02f, 3.75618152e-02f,
  9.93203670e-02f, -5.12693822e-02f, -1.09327078e-01f, 9.98896509e-02f, 7.11051002e-02f, -7.35972598e-02f, 1.84126955e-03f, -6.18901253e-02f, 2.12456435e-02f, -1.23778209e-01f,
  5.27892932e-02f, 7.92644098e-02f, 4.72753346e-02f, -2.50047445e-03f, 3.28392051e-02f, -2.31827721e-02f, -3.89134288e-02f, -3.93610857e-02f, 6.33159727e-02f, 7.70277679e-02f,
  -3.07101589e-02f, -1.61617100e-02f, 6.44021928e-02f, 1.48534020e-02f, -2.72772484e-03f, 3.51718105e-02f, -6.54028952e-02f, 1.67048406e-02f, -6.35246634e-02f, 7.78265521e-02f,
  -3.21737602e-02f, 6.13669716e-02f, -1.92685612e-02f, -6.07538521e-02f, -4.47872691e-02f, 1.21146441e-02f, -5.77999577e-02f, 9.11573395e-02f, -4.47527990e-02f, -8.53532255e-02f,
  1.22742236e-01f, 5.40164337e-02f, -1.65695380e-02f, 2.84940545e-02f, -9.27417502e-02f, -4.86818328e-02f, 8.22583064e-02f, -1.04237884e-01f, 5.58132567e-02f, 2.25224774e-02f,
  -9.36259031e-02f, -2.08087750e-02f, 2.05522440e-02f, 1.16656870e-02f, -5.68811633e-02f, 3.56699079e-02f, -8.04972723e-02f, 1.03564583e-01f, 5.22526093e-02f, -6.96711615e-02f,
  8.29268694e-02f, 5.93270175e-04f, -9.61798728e-02f, -6.19179495e-02f, 5.90515509e-03f, 8.84403661e-02f, 1.98897291e-02f, -8.15531388e-02f, -8.83282498e-02f, 5.53184673e-02f,
  1.98064983e-01f, 5.79283126e-02f, 2.30925903e-01f, 1.26493618e-01f, 2.10589215e-01f, 7.91414827e-02f, 1.87663466e-01f, 8.21494386e-02f, 7.20565692e-02f, -3.56457867e-02f,
  1.21250890e-01f, 6.69195727e-02f, -1.14736199e-01f, 6.89291162e-03f, 3.35138291e-02f, 1.48758581e-02f, -6.99645057e-02f, -1.64469481e-02f, 6.75392151e-02f, 4.62642573e-02f,
  2.93841641e-02f, -8.59672427e-02f, 1.47691071e-02f, 8.63584410e-03f, -3.62870879e-02f, -5.74757345e-02f, -3.89264971e-02f, 1.00052550e-01f, -1.42615885e-02f, -3.08365398e-03f,
  1.12221457e-01f, 5.37909418e-02f, -3.98939848e-03f, -1.20524786e-01f, -2.80971639e-02f, -1.06876232e-02f, -4.98046726e-02f, -3.17554135e-04f, -8.19593072e-02f, -2.38124337e-02f,
  -5.24856746e-02f, 6.43888488e-02f, -5.65814115e-02f, -1.56963468e-02f, -3.52235027e-02f, -3.92815135e-02f, -7.84416050e-02f, -1.55462790e-02f, -8.07960629e-02f, 1.13367485e-02f,
  -6.82502938e-03f, 8.28304961e-02f, 4.21857089e-02f, -3.01359463e-02f, 7.64129832e-02f, -1.77293513e-02f, 5.19178398e-02f, -4.39962149e-02f, 8.38620439e-02f, 1.37704350e-02f,
  -2.08296236e-02f, 8.00104737e-02f, 6.97968230e-02f, 3.12622525e-02f, -1.37656052e-02f, 2.14742739e-02f, 1.10997092e-02f, 8.62255469e-02f, 2.32761409e-02f, -3.77571769e-03f,
  2.50550974e-02f, -2.06687115e-02f, -4.55475599e-03f, -2.25140876e-03f, -2.58023646e-02f, -6.44720644e-02f, 6.46915361e-02f, -8.73096287e-02f, 1.02673136e-01f, 9.56417397e-02f,
  2.06829477e-02f, 1.61450226e-02f, 4.78444397e-02f, 3.84930708e-02f, -3.45394691e-03f, -9.46103130e-03f, 6.21602917e-03f, 4.14686725e-02f, -1.91481337e-02f, 9.50822905e-02f,
  -3.67329866e-02f, 1.55086547e-01f, 2.84598954e-03f, 1.69833824e-02f, -7.68470624e-03f, -2.14722566e-02f, 7.18745142e-02f, -5.04858233e-02f, 4.49344963e-02f, -5.64701632e-02f,
  -5.00970855e-02f, -3.73735987e-02f, -4.10915576e-02f, 5.78238256e-02f, 1.34892479e-01f, -4.16255817e-02f, 6.53875619e-03f, 2.66938284e-03f, -2.74724588e-02f, -9.09624174e-02f,
  3.75520103e-02f, 1.08170643e-01f, 7.30582699e-02f, -1.83109157e-02f, -2.55259033e-02f, -3.14459056e-02f, 1.16207115e-01f, 9.27490517e-02f, -3.09130140e-02f, -4.62553538e-02f,
  -3.29868868e-02f, -2.08598092e-01f, -2.41372898e-01f, -1.70063138e-01f, -5.97721562e-02f, -1.12732284e-01f, -1.19662017e-01f, -5.79235442e-02f, -5.94344139e-02f, -1.69156432e-01f,
  -1.15899704e-01f, -4.87251021e-02f, 3.58318016e-02f, -6.79151639e-02f, -6.98638335e-02f, -5.38654737e-02f, -8.18583667e-02f, -1.35937363e-01f, -1.24756936e-02f, 6.63655177e-02f,
  -4.46193926e-02f, -6.02848157e-02f, 1.62175708e-02f, -8.08081254e-02f, -1.07314415e-01f, -1.29008712e-03f, -6.26544505e-02f, 1.17511190e-02f, -1.27322394e-02f, -2.08498761e-01f,
  -7.31621683e-02f, 2.91530583e-02f, -1.55460220e-02f, 1.42505392e-02f, -1.08369328e-01f, 3.10065597e-02f, -1.10373214e-01f, 1.02222547e-01f, 6.31515458e-02f, -1.10324658e-01f,
  -7.41805956e-02f, 2.43187379e-02f, -1.58070903e-02f, -2.68326905e-02f, -8.64180401e-02f, -7.05773681e-02f, 6.59014732e-02f, -1.74455650e-04f, -7.58879706e-02f, 4.16236520e-02f,
  -5.19715659e-02f, -5.21796346e-02f, 4.48406748e-02f, 5.43396808e-02f, 8.76191854e-02f, -3.40579636e-02f, -1.25369951e-02f, -2.26259958e-02f, -4.66044573e-03f, -1.16874985e-01f,
  2.66853143e-02f, 6.11883253e-02f, 7.19999894e-02f, -6.93579093e-02f, -1.39802461e-02f, 4.73996773e-02f, -6.06875643e-02f, 2.75138542e-02f, 3.17403972e-02f, -4.72841151e-02f,
  -2.28136331e-02f, 3.29047702e-02f, 1.90862659e-02f, -4.49797958e-02f, 5.37706465e-02f, -9.04534943e-03f, -3.57460380e-02f, 3.91610339e-02f, -1.34841567e-02f, 6.18713647e-02f,
  -9.33579111e-04f, -1.69132035e-02f, -3.38550285e-02f, -3.11694499e-02f, -9.24248472e-02f, -2.35518143e-02f, 3.30456942e-02f, -3.18708899e-03f, 2.66334694e-02f, -8.12544674e-02f,
  -8.32458436e-02f, 8.92974213e-02f, -4.74283956e-02f, 9.03227478e-02f, -7.81416744e-02f, 4.42498252e-02f, 3.83435972e-02f, 1.63333043e-02f, -5.75696342e-02f, 1.36728659e-02f,
  2.80612148e-02f, -6.74332231e-02f, -1.13608707e-02f, 6.31491765e-02f, -9.24853515e-03f, 4.20655683e-02f, -8.23661983e-02f, -6.86017200e-02f, 8.37253034e-03f, -1.85193140e-02f,
  -4.64751013e-02f, -3.57213914e-02f, 2.88103539e-02f, 2.72995234e-02f, -1.38046993e-02f, 8.73666927e-02f, 4.75088842e-02f, 2.71191988e-02f, 1.35639701e-02f, -1.14708833e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  9.93313938e-02f, 2.09574416e-01f, 2.91644763e-02f, 5.52296266e-02f, 3.26634645e-02f, 9.91010666e-02f, 1.33589497e-02f, 2.60894895e-01f, 1.08312048e-01f, 3.57832387e-02f,
  1.21380717e-01f, 1.39527172e-01f, 5.11573367e-02f, 2.25683019e-01f, 1.49920985e-01f, 4.54046614e-02f, 1.09571725e-01f, -5.13852853e-03f, 7.10049868e-02f, 1.43412113e-01f,
  3.55351381e-02f, 1.06465518e-01f, -1.09598013e-02f, 1.13869026e-01f, 1.26315534e-01f, 9.04735550e-02f, 2.21667632e-01f, -3.24643254e-02f, 9.68314111e-02f, 2.41484679e-02f,
  5.93382642e-02f, 1.15018770e-01f, 1.39261559e-01f, 1.41216874e-01f, 9.37671587e-02f, 1.49533033e-01f, 1.17189199e-01f, -2.30844482e-04f, 5.50081730e-02f, 8.99187103e-02f,
  3.67893539e-02f, 1.34287596e-01f, 6.03722669e-02f, 6.65721670e-02f, -9.55930632e-03f, 1.20332435e-01f, 4.13060635e-02f, 6.52309740e-03f, 7.35303089e-02f, 2.25609932e-02f,
  8.92373919e-02f, 5.37927933e-02f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -5.28643243e-02f, -2.28237435e-01f, -1.77840039e-01f, -3.90053302e-01f, 9.49445665e-02f, -4.93508950e-03f, -2.41212755e-01f, -1.66217387e-02f, 6.65909201e-02f, -2.01661706e-01f,
  -3.42978090e-01f, -1.62893850e-02f, 6.16627969e-02f, -3.00287396e-01f, 6.27255067e-02f, -2.93736458e-01f, -3.72767560e-02f, -1.20028861e-01f, -5.43115884e-02f, -3.87085438e-01f,
  -1.41308889e-01f, 4.19312194e-02f, -3.32944661e-01f, -2.62119085e-01f, 1.36862904e-01f, 9.61191282e-02f, -1.44682810e-01f, -2.75490195e-01f, -1.69926640e-02f, -1.63887837e-03f,
  4.29589339e-02f, 3.74447554e-02f, -8.65484681e-03f, -8.82476121e-02f, -3.82693820e-02f, -4.74263392e-02f, 6.80520684e-02f, -1.32616339e-02f, -1.38567671e-01f, 3.47038209e-01f,
  4.93916944e-02f, 3.46493758e-02f, -2.11346950e-02f, 3.96803580e-02f, 1.91974744e-01f, -1.15896337e-01f, 8.65241885e-02f, -2.51044631e-01f, 1.17139325e-01f, 1.95574671e-01f,
  1.54268723e-02f, 1.94902141e-02f, 1.28402174e-01f, -1.13831684e-01f, -3.09941769e-01f, 1.41978040e-01f, -2.77398318e-01f, 2.94352472e-01f, -5.25730662e-02f, 1.65857479e-01f,
  -4.36970025e-01f, 3.18988591e-01f, -2.56037991e-02f, 1.45012274e-01f, -1.98992729e-01f, 1.74219385e-01f, -1.38894543e-01f, 1.74582586e-01f, 3.89424302e-02f, -1.26064360e-01f,
  3.42508368e-02f, 1.69591770e-01f, 8.26191604e-02f, 2.89051443e-01f, 1.21183366e-01f, 1.69226453e-02f, -4.67486493e-02f, -5.11143692e-02f, 3.77737656e-02f, 1.56279318e-02f,
  -5.55524081e-02f, 1.18533205e-02f, 6.69654310e-01f, 1.65586442e-01f, -1.43720299e-01f, 3.35647538e-02f, -6.72644330e-03f, -1.42777041e-02f, 1.43069755e-02f, -1.34584635e-01f,
  -7.65073076e-02f, -8.52917731e-02f, -1.06141292e-01f, 1.10448366e-02f, 3.53825674e-03f, -1.18622417e-02f, 3.26442122e-01f, 2.14670122e-01f, -8.51958990e-02f, -8.81245825e-03f,
  -2.60333642e-02f, -1.74332764e-02f, 1.90417171e-01f, 1.24515601e-01f, 1.87927298e-02f, 1.02138758e-01f, -4.37596776e-02f, 2.30950378e-02f, 4.33623552e-01f, -2.19188835e-02f,
  1.89686656e-01f, 3.35132301e-01f, 7.76605755e-02f, -1.44029215e-01f, 6.94131926e-02f, -6.01568632e-02f, 9.88857523e-02f, 7.83467442e-02f, 1.93698317e-01f, -1.23615138e-01f,
  -2.32028798e-03f, -5.54703921e-02f, 6.74746782e-02f, 6.87996075e-02f, 6.14000298e-03f, -8.68070498e-02f, -1.43430755e-01f, 3.63949895e-01f, 4.54886369e-02f, -2.04037875e-01f,
  -2.76665632e-02f, -8.29148963e-02f, 5.16311973e-02f, -3.66444588e-02f, -1.33067220e-01f, -3.93657923e-01f, 2.21864522e-01f, 4.77431454e-02f, -1.55213341e-01f, 1.11129515e-01f,
  -4.95276637e-02f, -8.74110833e-02f, -5.34439534e-02f, -8.94246697e-02f, -1.32840797e-01f, 1.51862621e-01f, 2.04422504e-01f, -2.09078833e-01f, 1.21069491e-01f, -8.72665867e-02f,
  2.33927276e-02f, 5.61477197e-03f, 9.44889560e-02f, 2.50282628e-03f, 1.10171854e-01f, 2.48814493e-01f, 4.96490896e-02f, 5.49455658e-02f, 3.27968113e-02f, -3.47148985e-01f,
  1.88106284e-01f, 7.22872317e-02f, 9.40077081e-02f, -4.66909930e-02f, 4.76544984e-02f, 1.16454676e-01f, 4.41510044e-02f, 4.20423359e-01f, -3.02397281e-01f, 1.98330224e-01f,
  3.80358666e-01f, 2.23623171e-01f, 1.68948129e-01f, -6.38986975e-02f, -1.36201203e-01f, -3.57070982e-01f, 6.90658912e-02f, 2.09398180e-01f, 4.22032356e-01f, 7.62983412e-02f,
  3.45525086e-01f, -3.17473918e-01f, -2.75666088e-01f, -6.13410883e-02f, -8.63545686e-02f, -3.46256457e-02f, -1.35539174e-01f, 2.36203566e-01f, -3.36252123e-01f, -2.09078237e-01f,
  2.20319867e-01f, 2.75315940e-01f, 2.99790174e-01f, 9.99906957e-02f, -1.27036110e-01f, 2.03538895e-01f, 3.67258072e-01f, -6.05041862e-01f, -3.94666605e-02f, -2.99107671e-01f,
  3.85065615e-01f, 4.37768430e-01f, 8.56768936e-02f, 1.87212184e-01f, 2.74364740e-01f, 3.82886194e-02f, 4.83468808e-02f, -1.07988000e-01f, 8.17071646e-02f, 2.32858993e-02f,
  -1.37612775e-01f, 4.07168567e-01f, -1.35652080e-01f, 1.16908237e-01f, 1.64667025e-01f, 2.27418736e-01f, 7.57100135e-02f, -3.76167311e-03f, -4.64134105e-02f, -9.91245285e-02f,
  -9.06899422e-02f, -1.37218744e-01f, 3.76701415e-01f, -1.11108981e-01f, -1.96971521e-01f, 7.39249811e-02f, 3.46991420e-02f, -1.12421677e-01f, -5.05475290e-02f, 2.03184754e-01f,
  4.75535721e-01f, -2.13321624e-03f, -1.10820629e-01f, -1.34362057e-01f, -2.00256735e-01f, 9.33576524e-02f, 2.52656072e-01f, -1.58035070e-01f, 6.50054291e-02f, -7.05218986e-02f,
  8.17203149e-03f, 1.47257429e-02f, 2.15069607e-01f, 2.53937691e-01f, -2.19835073e-01f, -1.64953530e-01f, -1.35843754e-01f, -1.81826770e-01f, 1.73582211e-01f, -1.05165794e-01f,
  -1.81176260e-01f, 1.04267979e-02f, 1.53983846e-01f, 9.79132056e-02f, 1.46597713e-01f, 2.77745456e-01f, 6.86176121e-02f, 6.04144931e-02f, 1.63778719e-02f, 2.36771032e-01f,
  1.70395851e-01f, 1.41643696e-02f, 1.41188219e-01f, 1.45617962e-01f, 6.87404573e-02f, 2.38827124e-01f, 3.14419061e-01f, 8.11921805e-02f, 8.30617920e-02f, 2.66996592e-01f,
  1.32071808e-01f, 1.29614562e-01f, 1.43688947e-01f, 9.05044749e-02f, -9.21555609e-02f, 2.55419105e-01f, 1.28095865e-01f, 9.00241584e-02f, -2.18218174e-02f, 6.67213500e-02f,
  -1.92340732e-01f, -4.09700796e-02f, 7.42898732e-02f, 1.58551216e-01f, 1.32956922e-01f, 3.95689197e-02f, -1.33411940e-02f, 2.23520622e-02f, 7.52414986e-02f, 1.04903523e-03f,
  -1.16764076e-01f, 4.97525334e-02f, -4.22060974e-02f, 6.52173087e-02f, -2.45013610e-01f, 1.14538766e-01f, -3.94812793e-01f, 1.67893246e-02f, -1.66190818e-01f, 1.43792853e-01f,
  4.82842065e-02f, 3.55498403e-01f, 3.07612360e-01f, 7.87957832e-02f, 1.13437466e-01f, -1.00716799e-01f, 1.18426345e-01f, 1.02365896e-01f, 5.73674701e-02f, -3.31971943e-02f,
  -1.19657993e-01f, 1.39224485e-01f, -3.63128781e-01f, 2.10424453e-01f, 4.60258052e-02f, 2.02400699e-01f, -3.37845415e-01f, -3.01965892e-01f, 5.77627003e-01f, -4.07272317e-02f,
  -3.00168902e-01f, 2.37747043e-01f, 2.85663083e-02f, -1.35408506e-01f, 5.00198960e-01f, -1.64740115e-01f, 1.77693292e-01f, 2.84412861e-01f, -3.08251679e-01f, -3.54186684e-01f,
  2.08958805e-01f, 3.47476006e-01f, -8.15043002e-02f, -1.99383125e-01f, -7.70646334e-02f, 2.09284946e-01f, -2.09905505e-01f, -1.86801478e-02f, -1.48360401e-01f, 2.30980456e-01f,
  -1.30669996e-01f, 5.26293702e-02f, -8.15596581e-02f, 2.34985635e-01f, -2.09402278e-01f, 1.95087612e-01f, -1.13830313e-01f, -5.02340235e-02f, -1.92335531e-01f, -4.27088812e-02f,
  -1.93581596e-01f, 9.57649425e-02f, -2.06010774e-01f, 4.00676839e-02f, -2.23532096e-02f, 1.64300814e-01f, 5.75775169e-02f, -3.09734438e-02f, 8.09192434e-02f, -6.84065446e-02f,
  -5.27380109e-02f, 2.72265095e-02f, 1.78355172e-01f, -9.43767577e-02f, -1.29180653e-02f, -4.13894206e-02f, 3.20673361e-02f, -3.63806307e-01f, 5.44699542e-02f, -1.13827959e-01f,
  1.14083841e-01f, -2.19361797e-01f, 1.81827018e-05f, 1.25639141e-01f, -1.62443891e-01f, -4.10019085e-02f, 1.08958468e-01f, 8.67325962e-02f, -1.65129043e-02f, -1.40000477e-01f,
  -3.24790180e-01f, -1.05501182e-01f, -8.80001113e-02f, 2.12755818e-02f, 1.13790885e-01f, 5.55310026e-02f, -9.14037451e-02f, -1.36282563e-01f, 1.15302749e-01f, 1.67318717e-01f,
  2.53378391e-01f, 1.21999241e-01f, 1.21816210e-01f, 9.23329499e-03f, -2.43968174e-01f, 1.41337737e-02f, 7.28671253e-02f, 1.46428928e-01f, -2.05423802e-01f, -2.15515320e-04f,
  -2.10937001e-02f, -4.37793970e-01f, 4.33968417e-02f, 1.05503626e-01f, 2.60418635e-02f, -1.74548149e-01f, 9.17300880e-02f, 5.92192970e-02f, -6.71964288e-02f, 7.57307857e-02f,
  5.48451692e-02f, 3.31804119e-02f, 1.63668320e-01f, 6.76300228e-02f, 1.56899681e-03f, -6.54075518e-02f, 1.14517935e-01f, -1.35590479e-01f, -1.07595123e-01f, -7.99862444e-02f,
  3.98144089e-02f, -3.52066487e-01f, -2.91377723e-01f, 1.69663474e-01f, 7.62921497e-02f, 9.41873416e-02f, 8.71379152e-02f, 6.65807128e-02f, -1.23595670e-01f, -1.69175357e-01f,
  -1.59296125e-01f, 1.48646804e-02f, 4.29524809e-01f, -6.47312924e-02f, 8.93369317e-03f, 2.48999327e-01f, -2.81618357e-01f, -2.13760808e-01f, 4.84576792e-01f, 2.18768418e-01f,
  2.01350272e-01f, 1.44964114e-01f, -4.07053493e-02f, -3.62478197e-01f, 5.54834306e-01f, -1.65198359e-03f, 2.90443957e-01f, 2.27405638e-01f, -1.54743060e-01f, 1.26251727e-01f,
  3.79619077e-02f, -7.17245713e-02f, 1.53692439e-01f, 3.25249523e-01f, -7.39976019e-02f, 1.83083609e-01f, -5.74932434e-02f, -4.29922789e-01f, -1.01590222e-02f, -4.61662740e-01f,
  -9.28600729e-02f, 7.84277767e-02f, -6.36750832e-02f, 1.77949958e-03f, -6.63939863e-02f, -2.41326183e-01f, 3.50164808e-02f, -1.09176502e-01f, 3.02604645e-01f, -2.28857785e-01f,
  -6.95639402e-02f, -7.03760237e-02f, 3.99251543e-02f, 2.85167694e-01f, -3.02536070e-01f, 4.54354137e-01f, -2.17398182e-01f, 1.29699767e-01f, -5.47165833e-02f, -7.69843161e-02f,
  8.15901160e-02f, 8.81046150e-03f, 8.12301514e-05f, -1.78043112e-01f, -1.08861804e-01f, -1.81176458e-02f, 2.97006965e-02f, 6.54153377e-02f, 2.07392812e-01f, 4.08181995e-02f,
  2.15701270e-03f, -1.30341560e-01f, -1.80625185e-01f, -8.88743699e-02f, -1.73069924e-01f, 6.96547091e-01f, -7.23098367e-02f, -4.73737717e-02f, -1.69416890e-01f, -1.87643901e-01f,
  -2.43273582e-02f, 6.78344769e-03f, 9.48446393e-02f, 3.03512335e-01f, 1.02764675e-02f, -6.13712147e-02f, 6.78334087e-02f, -1.00749619e-01f, -1.62141383e-01f, -6.29547462e-02f,
  -2.37319786e-02f, 1.25952974e-01f, 2.13726275e-02f, 1.25652388e-01f, -7.67878294e-02f, 1.33975685e-01f, -3.92801344e-01f, -3.62755507e-01f, -2.41396084e-01f, -1.01172872e-01f,
  -1.62861735e-01f, -2.41561737e-02f, 2.71618485e-01f, -4.37436961e-02f, -1.24601638e-02f, -2.85711050e-01f, 6.00672252e-02f, 1.56970009e-01f, 8.69080499e-02f, -1.15138926e-01f,
  -8.84708688e-02f, 3.30799788e-01f, -4.10370342e-02f, -2.63965735e-03f, 2.80555099e-01f, 1.09083265e-01f, 8.43221322e-02f, -4.73882779e-02f, 3.47037278e-02f, -8.65051821e-02f,
  4.49056104e-02f, -1.48571953e-01f, -2.34540865e-01f, 2.14767531e-02f, -1.12437747e-01f, 1.41594484e-02f, -6.06653951e-02f, 1.05197616e-01f, -2.40408396e-03f, 1.95305064e-01f,
  2.00585574e-01f, -4.99217033e-01f, 4.78569753e-02f, 2.35660717e-01f, -2.16149330e-01f, 1.96355209e-01f, 3.82227808e-01f, -3.23972583e-01f, 1.58086210e-01f, -1.54990569e-01f,
  3.12061548e-01f, -2.53276229e-01f, -5.81276603e-02f, 2.70441383e-01f, 1.79561242e-01f, -4.47639674e-02f, -2.16881827e-01f, 1.96616426e-01f, 3.78467798e-01f, -1.27654776e-01f,
  -2.04843357e-01f, -8.79244506e-02f, -8.05134773e-02f, -7.14772660e-03f, -1.83263849e-02f, -3.38843822e-01f, -3.62740308e-01f, 2.72241235e-01f, -1.03049569e-01f, 6.66516498e-02f,
  -3.85609895e-01f, 3.54802281e-01f, 2.14075416e-01f, 1.98078617e-01f, -1.28340483e-01f, -1.16786078e-01f, -1.13629907e-01f, -2.41969544e-02f, 1.89659167e-02f, -6.22619577e-02f,
  -1.89315761e-03f, -5.66180646e-02f, -3.39748263e-02f, 9.88212898e-02f, -1.57271534e-01f, 2.71631069e-02f, 2.99813032e-01f, -1.43752098e-02f, -8.94951969e-02f, -1.20148256e-01f,
  -5.26199974e-02f, -1.88468322e-01f, 4.18403149e-01f, 9.29903314e-02f, 1.52086720e-01f, 9.74882245e-02f, 3.58071215e-02f, 1.67818770e-01f, 2.82927901e-01f, -1.50800496e-01f,
  -6.63003623e-02f, 6.64873142e-03f, 8.41213316e-02f, -1.79533102e-02f, -1.12124257e-01f, -2.57594306e-02f, 1.43417316e-02f, -6.02204092e-02f, 1.29137905e-02f, -1.13255262e-01f,
  -1.73213352e-02f, -7.87266418e-02f, -1.18339606e-01f, 2.90240556e-01f, 1.26275579e-02f, -5.00642434e-02f, 1.43486679e-01f, -1.84820697e-01f, 2.14585159e-02f, -4.53253351e-02f,
  4.35860842e-01f, -9.81122628e-03f, -7.55684525e-02f, 1.64909199e-01f, 3.09684932e-01f, 1.56129729e-02f, -2.85691563e-02f, 1.13003768e-01f, 9.51088220e-03f, 5.42597771e-02f,
  -1.78684313e-02f, 1.99737504e-01f, -1.61020663e-02f, 1.58190101e-01f, 1.90740943e-01f, 1.06412135e-01f, 8.08255970e-02f, -1.52103350e-01f, 3.13056439e-01f, 2.96344012e-01f,
  2.34235227e-01f, 1.18866868e-01f, 7.67158195e-02f, -8.98000151e-02f, 1.82025164e-01f, 1.02142125e-01f, 5.58994450e-02f, 1.55686855e-01f, 1.18917398e-01f, -1.81585383e-02f,
  1.84364822e-02f, 2.65640080e-01f, 2.76966393e-01f, 7.90771320e-02f, -1.43403977e-01f, -7.85848945e-02f, 1.30735468e-02f, 1.55211702e-01f, -6.69778511e-02f, -4.79780585e-02f,
  1.43198103e-01f, 3.69691253e-02f, -6.49613049e-03f, 5.74526601e-02f, 1.71132103e-01f, -2.42485791e-01f, -1.87860996e-01f, 3.04830689e-02f, 3.86680961e-01f, 1.79098379e-02f,
  3.93362612e-01f, 8.49247351e-02f, -1.79994255e-01f, 3.37642767e-02f, 2.56729931e-01f, -3.26173812e-01f, -3.93685788e-01f, 1.57189414e-01f, 7.01474696e-02f, 1.63928881e-01f,
  -2.33533248e-01f, 1.75199136e-01f, -3.38633120e-01f, 5.62579408e-02f, -2.77043819e-01f, -6.15574718e-02f, -7.68902674e-02f, 3.38563740e-01f, -9.71166566e-02f, 5.03109321e-02f,
  -1.56953305e-01f, -1.31993815e-01f, -6.47673607e-01f, -1.98562518e-01f, 4.69583929e-01f, -2.85398215e-01f, -2.27343157e-01f, 1.50062097e-02f, -6.44874156e-01f, -3.81795853e-01f,
  -2.97206372e-01f, -4.31962907e-01f, 1.09374672e-01f, 5.56673408e-01f, -2.91120201e-01f, -2.80178398e-01f, 5.72264791e-02f, 5.10270149e-02f, 1.39938854e-02f, 5.44210598e-02f,
  -1.40906945e-01f, 6.98620528e-02f, 1.17504418e-01f, 1.74534041e-02f, -1.03733584e-01f, 8.31868649e-02f, 3.82730663e-02f, -1.79785386e-01f, -1.61786407e-01f, -1.67554513e-01f,
  1.01758428e-01f, -1.57688826e-01f, 1.45321816e-01f, 5.42554408e-02f, -1.23437800e-01f, 6.94955140e-03f, 2.18447834e-01f, 1.04280896e-01f, 8.09979159e-03f, 9.73832533e-02f,
  -2.09450081e-01f, 4.98916656e-02f, 7.95274153e-02f, -1.12017825e-01f, 1.43086361e-02f, 2.08075449e-01f, -4.57721278e-02f, 1.83893442e-01f, 1.77220240e-01f, 3.79897133e-02f,
  2.99429409e-02f, 5.60925677e-02f, -9.81805101e-03f, 2.46407434e-01f, 6.39830977e-02f, 3.49807180e-02f, 2.80423667e-02f, -1.73078254e-01f, -8.02689940e-02f, 3.26689780e-02f,
  1.77166775e-01f, -1.27020285e-01f, -7.13329092e-02f, -7.45065212e-02f, -1.71030357e-01f, 1.69347107e-01f, -1.15627266e-01f, 1.96099840e-02f, 1.63130481e-02f, -1.78763509e-01f,
  5.80238290e-02f, -4.08570111e-01f, 6.61943108e-02f, 1.46039173e-01f, 1.78776547e-01f, 1.10210873e-01f, -7.99034908e-02f, 9.91297662e-02f, -3.05340677e-01f, -5.87870106e-02f,
  -3.57477702e-02f, -1.61858536e-02f, -2.75070760e-02f, 1.86958127e-02f, -4.53030244e-02f, 9.01575983e-02f, 6.83074147e-02f, 8.94010141e-02f, -1.90514803e-01f, 8.69623795e-02f,
  -4.24591359e-03f, -9.01559964e-02f, 1.08825602e-01f, -2.49323174e-02f, 5.80711477e-02f, 9.61262360e-02f, 2.65709702e-02f, -1.44978598e-01f, 5.50208874e-02f, -8.45096484e-02f,
  1.69786736e-01f, 1.26333043e-01f, -4.83566374e-02f, 2.62561021e-03f, -2.16852408e-02f, -1.72548905e-01f, 8.07137713e-02f, -3.15509886e-01f, -1.63136631e-01f, -5.81852555e-01f,
  -2.45768115e-01f, -1.04606733e-01f, 1.06426381e-01f, 3.75147462e-01f, 1.87566847e-01f, 1.11464731e-01f, -3.09186488e-01f, -3.30627501e-01f, 8.00567716e-02f, -4.08718795e-01f,
  7.47139100e-03f, 6.58163875e-02f, 1.01004660e-01f, -1.00216344e-01f, -1.39425173e-01f, -1.34771243e-01f, 2.98350215e-01f, 2.51003057e-02f, -3.28747392e-01f, -3.80926073e-01f,
  -1.00708857e-01f, 7.68715441e-02f, 1.13323659e-01f, -2.08974019e-01f, 3.31191540e-01f, 2.31391639e-01f, -1.16407007e-01f, -1.81254163e-01f, 8.45727846e-02f, -2.63743242e-03f,
  -2.42256999e-01f, -8.08058381e-02f, 1.62881330e-01f, 4.40040767e-01f, -1.57920688e-01f, -1.55331060e-01f, 2.02928960e-01f, -1.94663871e-02f, 8.99574161e-02f, -1.65806502e-01f,
  -1.42557532e-01f, -1.76423892e-01f, -2.16906592e-01f, -1.84405997e-01f, -4.28313166e-02f, 7.05318525e-03f, 3.17993522e-01f, -2.84076542e-01f, 1.02207974e-01f, -1.36617377e-01f,
  2.36545488e-01f, -1.40629381e-01f, 6.34303316e-02f, 5.32730937e-01f, -1.54788554e-01f, -1.73382327e-01f, 3.47980320e-01f, 1.20857984e-01f, -9.28428173e-02f, -2.01752663e-01f,
  -4.41388600e-02f, -1.31267175e-01f, -2.27409229e-01f, 1.24597229e-01f, 1.19100399e-01f, -1.12140588e-01f, -1.62114650e-01f, -3.40229630e-01f, 1.48953274e-01f, -1.98012143e-01f,
  3.89834166e-01f, -8.90915915e-02f, 9.75555331e-02f, 2.70460457e-01f, -8.66131932e-02f, -4.05738614e-02f, -7.57189617e-02f, -5.92603870e-02f, -9.13812742e-02f, -2.59037048e-01f,
  -7.84834102e-02f, -1.73100531e-01f, 2.38147840e-01f, -2.52609164e-01f, -1.64443299e-01f, -1.55726284e-01f, -3.10202420e-01f, -7.32164085e-02f, -1.10700512e-02f, 1.28090665e-01f,
  4.76649329e-02f, -8.06762353e-02f, -3.32438678e-01f, -2.08153158e-01f, -6.29850430e-04f, -2.51249313e-01f, 1.93577707e-01f, -8.39836076e-02f, -7.05138072e-02f, -1.55588686e-01f,
  -2.13946193e-01f, -2.19531074e-01f, -4.66769561e-02f, -7.40501210e-02f, 2.47132387e-02f, -1.98920500e-02f, -6.94871098e-02f, -3.15940082e-01f, 2.32698657e-02f, -4.65016924e-02f,
  -5.86806722e-02f, -8.34545344e-02f, 1.38252033e-02f, 1.94781907e-02f, 4.37527187e-02f, 1.86640630e-03f, -8.19641398e-04f, 4.06191647e-02f, 1.90816901e-03f, -1.04318365e-01f,
  3.10266716e-03f, -1.54025987e-01f, -1.99152660e-02f, 2.01570630e-01f, -3.41375142e-01f, -1.35064185e-01f, 4.84780073e-02f, 1.06002137e-01f, 1.50178894e-01f, -2.42058009e-01f,
  -2.56460339e-01f, 2.92955428e-01f, -1.09811157e-01f, 2.12771446e-01f, -2.43281610e-02f, 2.66762286e-01f, -2.45769650e-01f, -1.66120052e-01f, -3.19373518e-01f, 1.85196504e-01f,
  2.51580238e-01f, -1.29031748e-01f, -1.15792602e-01f, -2.42312893e-01f, 3.96236256e-02f, -2.67411321e-01f, 2.47293696e-01f, 1.82242751e-01f, -9.03919488e-02f, -6.13427050e-02f,
  -1.06594019e-01f, -1.62770033e-01f, 1.04455657e-01f, -4.23340201e-02f, -8.10986608e-02f, 2.38595128e-01f, -3.83221172e-02f, 1.14128940e-01f, -2.13668063e-01f, -2.04059422e-01f,
  1.46447793e-01f, -1.09017573e-01f, 2.70207554e-01f, -1.24588132e-01f, -2.80082285e-01f, 3.77342254e-01f, 1.73795938e-01f, -6.18161745e-02f, -1.00456759e-01f, -1.28026932e-01f,
  1.53871641e-01f, -3.03287376e-02f, 2.17426583e-01f, -4.89834100e-02f, 2.81920861e-02f, 1.88355550e-01f, -1.02854498e-01f, 6.93678632e-02f, 1.13382511e-01f, 2.30566517e-01f,
  -5.81795685e-02f, 8.90775546e-02f, 3.40610854e-02f, -4.87773865e-02f, -1.63076460e-01f, 1.06498137e-01f, -2.48476584e-02f, 8.61065537e-02f, -4.72002383e-03f, 1.58923529e-02f,
  3.69926929e-01f, 1.68534145e-01f, -1.06355131e-01f, -2.77230470e-03f, -1.09240733e-01f, 2.38643259e-01f, -4.36488315e-02f, -1.47830993e-01f, -4.43249755e-02f, 2.18110010e-01f,
  8.64839554e-02f, -3.19974013e-02f, -3.53450552e-02f, -6.26021177e-02f, 3.97116365e-03f, -5.60185239e-02f, -1.32074505e-01f, 5.36829010e-02f, -7.65860006e-02f, 5.10688871e-03f,
  -2.36734837e-01f, 4.64888960e-01f, -1.09779134e-01f, -4.41844128e-02f, 1.29862562e-01f, 5.33405170e-02f, -3.09135709e-02f, 9.57441330e-02f, -7.24232346e-02f, 6.12497516e-02f,
  2.52063069e-02f, 9.88714918e-02f, -3.19131762e-01f, 9.28837284e-02f, 8.36056545e-02f, 2.20714435e-02f, 7.39403293e-02f, 4.47640009e-02f, 9.51339155e-02f, 6.27921671e-02f,
  -4.19146791e-02f, -1.15474880e-01f, 5.16249724e-02f, 6.95682243e-02f, -2.42258161e-01f, 1.16497286e-01f, -2.13847890e-01f, 9.57309455e-02f, 1.05636261e-01f, 9.61034745e-02f,
  -1.32110909e-01f, 2.78718676e-02f, 7.99627602e-02f, 1.22305490e-01f, -1.60997525e-01f, 6.53140023e-02f, -1.42609552e-01f, -6.14746697e-02f, -7.63535425e-02f, 1.25798434e-01f,
  8.03561583e-02f, 1.21399865e-01f, -6.40760362e-02f, 1.13073617e-01f, -2.67524600e-01f, -1.50692046e-01f, 4.06316400e-01f, -3.36559951e-01f, -3.54674339e-01f, -1.26684070e-01f,
  -4.07956421e-01f, 4.18558940e-02f, -2.38851205e-01f, 2.26631984e-01f, 1.80423539e-02f, -4.16993558e-01f, 1.00067899e-01f, -1.01143634e-03f, -2.60068804e-01f, -1.63438648e-01f,
  -2.97063552e-02f, 1.78197831e-01f, 4.66652751e-01f, 1.60084546e-01f, 4.41392988e-01f, 8.25385302e-02f, -9.84231085e-02f, -3.13126631e-02f, 3.26873302e-01f, -1.83631271e-01f,
  -1.92985952e-01f, -1.49537668e-01f, 4.79555696e-01f, -1.85296133e-01f, -3.61402303e-01f, -2.55254269e-01f, 2.86505342e-01f, -9.34977680e-02f, 2.38438740e-01f, -2.71824181e-01f,
  -1.49086177e-01f, 3.60901594e-01f, -1.81631856e-02f, -3.10826693e-02f, 7.49753788e-03f, 1.50730954e-02f, -1.12027407e-01f, -2.28073865e-01f, -9.48725566e-02f, -4.61809076e-02f,
  8.92346278e-02f, -1.09610379e-01f, -1.42105343e-02f, 5.35315685e-02f, -1.25027314e-01f, 4.66268510e-02f, -1.66054115e-01f, -6.39382899e-02f, 2.15329025e-02f, -6.14339411e-02f,
  -8.77050236e-02f, -9.37053338e-02f, -6.53161258e-02f, -1.07793532e-01f, -8.08120295e-02f, 4.54201475e-02f, -6.48616850e-02f, -8.46446529e-02f, -6.49028048e-02f, -8.48649964e-02f,
  2.24166825e-01f, 1.05799995e-01f, -1.22923926e-01f, 2.12452814e-01f, 1.43144548e-01f, -1.99951261e-01f, -7.46931368e-03f, -9.30170491e-02f, -2.23835111e-01f, -1.03084080e-01f,
  1.56669334e-01f, -1.77535657e-02f, -1.45749792e-01f, 1.23332471e-01f, -8.67020264e-02f, -3.83084267e-02f, -1.06793568e-01f, 4.91045952e-01f, 3.01288031e-02f, -1.58148274e-01f,
  2.25946903e-01f, -6.02175668e-02f, 1.29735321e-01f, 1.38251737e-01f, -4.96597327e-02f, 2.19528511e-01f, -1.63803905e-01f, 5.81414141e-02f, 3.37390341e-02f, -5.13145048e-03f,
  -3.61922830e-01f, -2.11808290e-02f, 2.94250041e-01f, 5.73080070e-02f, 2.22511850e-02f, 2.13941768e-01f, -2.56009027e-02f, -3.33845355e-02f, 1.14001587e-01f, 9.22795907e-02f,
  2.80157123e-02f, -1.48633182e-01f, 8.14643595e-03f, 9.36537385e-02f, 1.15898170e-01f, 1.17641762e-01f, 5.80991954e-02f, -1.37890279e-01f, -8.88929889e-02f, 1.02245599e-01f,
  1.49855554e-01f, 1.09712988e-01f, -1.26501858e-01f, 5.72931021e-02f, -1.29208043e-01f, -1.48359746e-01f, -8.15351084e-02f, 1.71036288e-01f, 5.93061261e-02f, -2.65269518e-01f,
  3.20075154e-02f, -5.64554296e-02f, -1.09992027e-02f, 6.83512315e-02f, -3.83228481e-01f, 3.57946575e-01f, 1.12871505e-01f, -6.63944706e-02f, 4.48068947e-01f, 3.62386368e-02f,
  -3.37691307e-01f, -1.98891163e-01f, -3.33466858e-01f, 2.37454206e-01f, -1.34054497e-01f, 3.04355443e-01f, -9.92344096e-02f, -1.74410775e-01f, -5.97660467e-02f, -3.02571237e-01f,
  1.32744648e-02f, -4.53245752e-02f, -8.04807842e-02f, 3.28798950e-01f, -2.98325032e-01f, -8.93458724e-02f, -2.85246849e-01f, 1.67980790e-01f, -4.20526899e-02f, -6.21552467e-02f,
  -3.92246544e-01f, -8.54908768e-03f, 3.20109367e-01f, 3.08704436e-01f, -2.11579964e-01f, 1.89904124e-02f, -3.68863374e-01f, 3.05387527e-01f, -1.33882791e-01f, -1.31443501e-01f,
  1.37972772e-01f, -1.60877720e-01f, -1.31649628e-01f, 1.41822845e-01f, 8.98966007e-03f, -3.42989326e-01f, -1.42192945e-03f, 2.08785057e-01f, -1.32121980e-01f, -6.90595806e-02f,
  8.33382756e-02f, -7.31839985e-02f, 1.65369794e-01f, -1.66907549e-01f, 3.58979285e-01f, -1.91866215e-02f, -6.04037009e-02f, -2.62082547e-01f, 1.26850663e-03f, -7.72031099e-02f,
  -2.16125906e-01f, 3.36116731e-01f, -1.19834691e-02f, -1.66857287e-01f, -1.94274843e-01f, 1.10466197e-01f, 1.91468865e-01f, -1.17487423e-01f, -1.38221413e-01f, 7.18987435e-02f,
  -1.23616338e-01f, 2.75168151e-01f, 5.02015240e-02f, -1.79206058e-01f, -2.78949775e-02f, 1.62408084e-01f, 1.12360843e-01f, 6.97081864e-01f, -7.81518593e-02f, -5.55400848e-02f,
  8.05797579e-04f, -8.80492330e-02f, -1.88366156e-02f, 4.39308323e-02f, 2.28271574e-01f, -5.79981357e-02f, -5.66252545e-02f, 1.25614961e-03f, -5.73561601e-02f, -2.19285041e-01f,
  -6.46891668e-02f, 1.12589952e-02f, 1.26047522e-01f, 6.72627017e-02f, 5.92615036e-03f, 6.67258203e-02f, 9.59936529e-02f, 2.39942595e-01f, 1.08754411e-01f, -1.11880116e-01f,
  -5.07024787e-02f, -1.05198473e-02f, -1.96481124e-02f, 4.08254638e-02f, 7.08065927e-02f, -7.90153444e-02f, -1.72917992e-02f, 1.21838540e-01f, -1.96723670e-01f, 2.39152104e-01f,
  2.31061503e-02f, 5.32276258e-02f, -9.02996287e-02f, -4.02850136e-02f, 2.16290820e-02f, 9.49464068e-02f, 4.92125973e-02f, -1.99579209e-01f, -9.23986062e-02f, -2.40905762e-01f,
  6.70998767e-02f, 8.19809735e-02f, -5.98835945e-02f, -6.49313629e-02f, 9.74421501e-02f, 1.29669413e-01f, -8.12599733e-02f, 1.42920941e-01f, 1.93963498e-01f, -1.24987029e-01f,
  1.98259801e-01f, 1.06818345e-03f, -2.14121714e-01f, 7.67704695e-02f, -3.00698996e-01f, 5.15291616e-02f, -2.42345825e-01f, -2.60071307e-01f, 2.51275837e-01f, 2.69859105e-01f,
  -5.42733539e-03f, 2.31496960e-01f, 7.90461972e-02f, -2.35682204e-01f, -6.69575110e-02f, -5.60023002e-02f, 3.18583697e-01f, -1.14459105e-01f, -1.45189732e-01f, 2.21127287e-01f,
  4.46855277e-01f, 1.86817095e-01f, 3.33334088e-01f, -1.49556072e-02f, 2.57441044e-01f, -5.05025983e-01f, -2.72545218e-01f, -3.91350299e-01f, 1.89381883e-01f, 2.38673434e-01f,
  4.58701193e-01f, -3.45121831e-01f, 2.04732239e-01f, 6.37253970e-02f, -2.53897637e-01f, -4.52023409e-02f, 1.99984282e-01f, -9.54105332e-02f, -6.06996082e-02f, -1.30746841e-01f,
  -1.23840347e-01f, -1.61565214e-01f, -1.82635888e-01f, 4.20975715e-01f, -1.48201033e-01f, -7.55354464e-02f, -1.26769856e-01f, -5.55673838e-02f, 5.76708280e-02f, 6.08522184e-02f,
  -5.96094318e-02f, 8.18667933e-02f, 2.97897449e-03f, -2.77410895e-02f, -7.02436715e-02f, -1.06033355e-01f, -2.10881792e-02f, 1.37509063e-01f, 2.26451345e-02f, -3.52126732e-02f,
  3.48911256e-01f, -1.25997603e-01f, -2.28633016e-01f, -1.56836763e-01f, -8.76696706e-02f, -5.08668162e-02f, -9.95844230e-02f, 6.21050894e-02f, -1.28444746e-01f, -9.45183486e-02f,
  -1.91385180e-01f, -1.11003146e-01f, -1.60934433e-01f, 4.35821116e-02f, -1.42493933e-01f, -1.28422573e-01f, 1.40559807e-01f, 2.20681056e-01f, -8.81588832e-02f, 3.28346640e-01f,
  -1.52430326e-01f, -2.87478901e-02f, -2.42017955e-02f, -1.57383859e-01f, -3.26126292e-02f, -7.76146278e-02f, 6.15179713e-04f, -6.15800433e-02f, -3.16406861e-02f, 6.34723529e-02f,
  1.66085005e-01f, -1.11177243e-01f, 4.08745930e-02f, 2.91620903e-02f, 1.01306468e-01f, 1.43054977e-01f, 9.14389119e-02f, -4.14284021e-02f, -2.78914779e-01f, 3.21002714e-02f,
  7.45825768e-02f, 5.67570068e-02f, 8.32712203e-02f, 2.61934847e-02f, -1.83265656e-01f, -7.86704477e-03f, 1.63902000e-01f, -1.61999524e-01f, 1.46100461e-01f, 6.52299225e-02f,
  6.82101175e-02f, 8.96251798e-02f, -3.67043205e-02f, 5.47345206e-02f, 1.16917320e-01f, 4.45527211e-02f, -3.91828448e-01f, -4.70654406e-02f, 2.21669357e-02f, 7.12475404e-02f,
  -2.75483996e-01f, 1.22023873e-01f, 1.58590019e-01f, 9.19858515e-02f, 2.05341820e-02f, 8.71295035e-02f, 4.20231074e-02f, 3.14268991e-02f, 1.93031117e-01f, -2.36494228e-01f,
  3.89534473e-01f, -1.60900876e-01f, 5.76064698e-02f, 5.40145263e-02f, 3.50564495e-02f, 2.57442057e-01f, -3.48758459e-01f, -3.79842967e-01f, 2.58037001e-01f, -1.54855892e-01f,
  2.33410910e-01f, 9.89093259e-02f, 3.11966062e-01f, 2.37226710e-01f, -3.67686376e-02f, -3.19891214e-01f, -2.58838870e-02f, -2.53638893e-01f, 1.23431414e-01f, -1.55409217e-01f,
  -1.53901607e-01f, 2.95498550e-01f, 4.63439934e-02f, 3.76156509e-01f, 3.35770428e-01f, 2.18648255e-01f, -1.90414816e-01f, 2.75141209e-01f, -5.37910998e-01f, 5.97638674e-02f,
  2.64622957e-01f, -1.77665547e-01f, 1.87986612e-01f, -4.48888481e-01f, -1.80775940e-01f, 3.02502096e-01f, 1.42698765e-01f, -2.03993350e-01f, 5.87253459e-02f, -9.06824842e-02f,
  -6.04388304e-02f, -1.96268573e-01f, 4.85495664e-02f, -3.84121016e-02f, -3.61594483e-02f, -1.38566773e-02f, 2.02265829e-02f, -5.78318723e-02f, 1.15124390e-01f, -7.06804916e-02f,
  -2.00996306e-02f, 9.52645030e-04f, -3.62122431e-02f, -9.99822095e-02f, -7.04800412e-02f, -9.18052495e-02f, 5.89902066e-02f, -1.33233726e-01f, -1.10982753e-01f, 1.01886772e-01f,
  -1.20217599e-01f, -6.69102296e-02f, 4.93575037e-02f, -3.11680278e-03f, -1.10678978e-01f, 1.61204152e-02f, -1.12743922e-01f, 1.09026879e-01f, -1.85171857e-01f, 3.46230902e-02f,
  1.14642113e-01f, -5.95043078e-02f, -1.34229794e-01f, -1.77257657e-01f, -5.63697182e-02f, -1.10082544e-01f, 1.61053732e-01f, -6.96890056e-02f, -1.84267443e-02f, 4.85006981e-02f,
  -8.93588215e-02f, -6.14695139e-02f, 6.11279905e-01f, -1.24894418e-01f, 2.86651284e-01f, -1.14751965e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -7.18833357e-02f, -5.03130741e-02f, -9.60908383e-02f, 8.40009749e-03f, 7.96957389e-02f, 4.32289019e-02f, 2.14098021e-02f, -9.31776240e-02f, 2.27761827e-03f, 3.96837555e-02f,
  7.08197579e-02f, 1.24068908e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    