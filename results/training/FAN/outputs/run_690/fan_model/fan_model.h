/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.36512700e-02f, -3.08064014e-01f, 6.56350106e-02f, -2.59940356e-01f, -1.81316838e-01f, -2.97835488e-02f, -2.68753886e-01f, -2.00239450e-01f, -1.90498874e-01f, -2.36966342e-01f,
  -1.42396614e-01f, -4.96500246e-02f, 3.66288540e-03f, -1.12956604e-02f, -4.91642393e-03f, -1.40465975e-01f, -2.26029754e-02f, 2.24328890e-01f, 7.54861534e-02f, -1.36840984e-01f,
  -2.72339255e-01f, -2.16979459e-01f, 1.14149405e-02f, 6.15696535e-02f, -1.58241376e-01f, -5.93171513e-04f, -9.68459155e-03f, 5.06599993e-03f, -1.06350593e-01f, -3.01912557e-02f,
  -1.12786017e-01f, -1.27254263e-01f, 2.69520376e-02f, -7.11511746e-02f, 1.30039798e-02f, -4.53007072e-02f, -1.17078587e-01f, -6.21310323e-02f, -1.13739774e-01f, -9.39321071e-02f,
  -9.98351201e-02f, -7.73860589e-02f, -1.11780837e-01f, -8.20171311e-02f, -1.08743280e-01f, -6.56277686e-02f, -5.72338924e-02f, -4.29066364e-03f, -1.02496587e-01f, -6.95932657e-02f,
  -1.91702157e-01f, -5.62455989e-02f, -4.78967875e-02f, -1.68546084e-02f, -1.02168739e-01f, 7.00095370e-02f, -1.21922009e-01f, -2.52742991e-02f, 8.88639502e-03f, -2.01085165e-01f,
  9.97271463e-02f, 1.46901652e-01f, 1.91952020e-01f, 1.12900920e-01f, 1.37490079e-01f, 1.14180781e-01f, 1.59082621e-01f, 1.34409338e-01f, 1.32883087e-01f, 1.51598960e-01f,
  5.53411171e-02f, 1.24422863e-01f, 1.45221740e-01f, 1.39566615e-01f, 1.15660071e-01f, 1.38927996e-01f, 1.01560116e-01f, 1.07886590e-01f, 1.96598798e-01f, 1.62501797e-01f,
  7.87454695e-02f, 1.59500152e-01f, 9.72843096e-02f, 1.37117848e-01f, 1.45836532e-01f, 1.18193753e-01f, 5.75064756e-02f, 1.36629999e-01f, 8.34279880e-02f, 1.24675505e-01f,
  -2.41920292e-01f, 5.49045578e-02f, -1.80601627e-01f, -1.10737897e-01f, -1.06353030e-01f, -8.93046111e-02f, -1.17849790e-01f, -5.89486547e-02f, -2.02409700e-02f, -1.99067160e-01f,
  -1.20368198e-01f, -1.00641303e-01f, -2.95199733e-02f, -1.03968725e-01f, -1.56684920e-01f, -1.61287636e-01f, -3.73213664e-02f, -1.49070933e-01f, -5.74961118e-03f, -2.04700977e-01f,
  -9.08558741e-02f, -1.46412641e-01f, -1.51646197e-01f, -9.33525115e-02f, -1.60322741e-01f, -1.97509229e-02f, -1.51955679e-01f, -7.75705874e-02f, -1.02818683e-01f, -3.32768947e-01f,
  -8.43662992e-02f, -1.32153392e-01f, 2.16067225e-01f, -6.14940971e-02f, 1.30532868e-02f, 2.68278830e-02f, 1.75506294e-01f, -3.33427079e-02f, -4.18445654e-02f, -5.10020889e-02f,
  -1.99732155e-01f, -2.88361490e-01f, -1.85521200e-01f, -1.91169590e-01f, 1.40880945e-03f, 1.50892571e-01f, 2.21764341e-01f, 1.73220128e-01f, -2.96767745e-02f, -1.42881647e-01f,
  -9.67932642e-02f, 4.86834422e-02f, 1.19076788e-01f, 4.60516810e-02f, -4.59779873e-02f, -5.31849675e-02f, 1.98643357e-01f, 4.02140021e-02f, -8.50127935e-02f, 8.64999648e-03f,
  -1.10392950e-01f, -8.23687539e-02f, -4.28231135e-02f, -1.39245436e-01f, -6.86561242e-02f, 4.93556745e-02f, 1.60718933e-04f, 7.41301179e-02f, -1.26798516e-02f, 5.11473864e-02f,
  -9.11927968e-03f, -7.75238946e-02f, -6.38226867e-02f, 5.90718444e-03f, -7.65883923e-02f, -8.66374299e-02f, -4.07967307e-02f, 9.31672528e-02f, -1.32457055e-02f, -8.02544802e-02f,
  -5.31637259e-02f, -1.80798825e-02f, 4.97114798e-03f, -8.24224949e-03f, -8.82247929e-03f, -9.63243172e-02f, -3.92813832e-02f, -3.19887511e-03f, 2.54402403e-02f, 7.26185963e-02f,
  5.29692583e-02f, -1.58047769e-02f, 1.87925401e-03f, 2.95605082e-02f, -2.29819566e-02f, 2.15772055e-02f, 5.26820645e-02f, 2.40884908e-02f, 5.24251796e-02f, -1.04889926e-03f,
  -5.03755286e-02f, 2.56144460e-02f, 1.75904408e-02f, 5.46911173e-02f, -2.16003228e-02f, 6.83153942e-02f, 1.11563248e-03f, -5.75729385e-02f, -6.20051473e-02f, 5.26996665e-02f,
  -3.34985778e-02f, -8.85758456e-03f, -6.54288847e-03f, -4.92364317e-02f, 1.26051623e-02f, -2.98918802e-02f, -9.25844256e-03f, -1.16462693e-01f, 2.05770507e-02f, -3.36013474e-02f,
  -2.27246005e-02f, -6.21149987e-02f, -1.02097593e-01f, -1.41201571e-01f, 8.29842780e-03f, -7.89131597e-02f, -1.63604558e-01f, -1.04177780e-01f, -1.38469800e-01f, -6.89666644e-02f,
  -1.88253894e-01f, -5.80013245e-02f, 1.04924655e-02f, -1.49917426e-02f, 2.24586111e-02f, -1.42140836e-02f, -2.87026595e-02f, -1.17453830e-02f, -7.51742199e-02f, -2.64840247e-03f,
  -1.53601468e-02f, -8.32505003e-02f, -4.58373651e-02f, -9.21650603e-03f, -2.88500376e-02f, -2.25088242e-02f, -4.55608629e-02f, -6.83831871e-02f, 3.67099829e-02f, 9.72412601e-02f,
  2.71204650e-01f, -4.29658331e-02f, 3.71994935e-02f, 7.45735690e-02f, -9.97883156e-02f, 8.35971534e-02f, 9.94502828e-02f, 9.32170749e-02f, 2.56833676e-02f, 3.78699116e-02f,
  -2.19655223e-04f, 1.78099468e-01f, 9.01149958e-02f, 9.05437097e-02f, 3.31641100e-02f, -5.82982339e-02f, -1.12311631e-01f, 3.52553725e-02f, 2.88567513e-01f, 2.38160506e-01f,
  7.80981332e-02f, 6.61319941e-02f, 2.83854268e-02f, 2.92206053e-02f, 5.41667044e-02f, 4.22748029e-02f, -6.21167086e-02f, 5.95776513e-02f, -2.70130951e-02f, -1.32510990e-01f,
  1.57381684e-01f, -2.01758463e-02f, 6.74795918e-03f, -3.46527584e-02f, -7.83986151e-02f, 8.90392661e-02f, -1.92096997e-02f, 3.90910245e-02f, -7.84908384e-02f, -1.76046900e-02f,
  3.36980745e-02f, 4.95336130e-02f, -4.80526276e-02f, -1.08444750e-01f, -3.95453721e-03f, 1.14606293e-02f, -2.91292612e-02f, 9.39378664e-02f, -3.81012750e-03f, -7.96759203e-02f,
  -9.64808837e-02f, 1.90776829e-02f, -1.16368644e-02f, -3.15832719e-02f, -1.54398680e-02f, -9.79971290e-02f, -6.05570339e-02f, -4.39927727e-02f, -1.31832376e-01f, 1.66998375e-02f,
  -7.53942803e-02f, 1.12193171e-02f, 1.21686414e-01f, 4.26723063e-02f, 1.10497862e-01f, 3.42444554e-02f, 1.34636819e-01f, 2.81894207e-02f, 1.63490009e-02f, 4.99577634e-02f,
  6.41650856e-02f, 1.10819012e-01f, 1.47276729e-01f, 1.14123814e-01f, 1.62226677e-01f, 1.53899435e-02f, 3.16740237e-02f, 1.16658928e-02f, 1.09534159e-01f, 5.77650182e-02f,
  8.48266706e-02f, -2.92045213e-02f, 4.78269942e-02f, 1.35641903e-01f, 5.47194714e-03f, 2.34921090e-02f, 6.19169101e-02f, 7.68421069e-02f, 3.86568047e-02f, 3.08181383e-02f,
  2.47908846e-01f, 1.22442897e-02f, 1.12088546e-01f, 1.30269118e-02f, 9.54686552e-02f, 1.27334159e-03f, -4.01206203e-02f, 4.01757471e-02f, -6.13006689e-02f, 5.94309233e-02f,
  6.40226528e-02f, 2.64368560e-02f, -2.90346239e-02f, -4.39603291e-02f, 4.67639901e-02f, -2.56996583e-02f, -4.73910607e-02f, -3.95653993e-02f, 3.88740338e-02f, -3.16501036e-02f,
  -1.17738649e-01f, -2.40616351e-02f, 7.81574175e-02f, 2.06322446e-02f, -3.78953367e-02f, 7.47745112e-02f, 8.48447233e-02f, 1.33389786e-01f, 3.45624350e-02f, 1.73114866e-01f,
  1.30253145e-02f, 6.98111877e-02f, 2.53929317e-01f, -2.47359380e-01f, -2.44709831e-02f, 1.54662713e-01f, 1.38710380e-01f, -3.52576748e-02f, -1.23980746e-01f, 1.42356724e-01f,
  6.70078993e-02f, -1.50967881e-01f, -6.22756891e-02f, -6.17768094e-02f, 1.13310903e-01f, 2.04629466e-01f, 1.32273212e-01f, -4.90438752e-02f, -7.72969574e-02f, -1.86519191e-01f,
  -2.65350312e-01f, -2.38380536e-01f, -2.02450216e-01f, -1.53808519e-01f, -1.42651409e-01f, -1.32696688e-01f, 2.17381231e-02f, -4.58689928e-02f, 1.77831516e-01f, 1.73286676e-01f,
  2.41391316e-01f, 1.71215124e-02f, -1.09061182e-01f, -6.22016639e-02f, -1.63046062e-01f, -1.07856430e-01f, -9.66258124e-02f, -6.35934994e-02f, -9.30530801e-02f, -8.37796926e-02f,
  -1.30421355e-01f, -7.78374597e-02f, -6.79353923e-02f, -6.75304234e-02f, -1.06183186e-01f, -3.04523241e-02f, -3.85475159e-02f, 2.54822522e-03f, -7.09512979e-02f, -7.42861480e-02f,
  -1.14363395e-01f, -6.37602946e-03f, 3.87987196e-02f, -1.58915147e-02f, -8.97029042e-02f, -1.07877806e-01f, -1.17315939e-02f, 5.94223198e-03f, 4.92265634e-02f, 1.13488853e-01f,
  -8.20374265e-02f, 2.04542466e-02f, 2.05010157e-02f, -3.86628397e-02f, -7.65227946e-03f, -1.27639109e-02f, 1.89951137e-02f, 4.47400846e-02f, -4.57744449e-02f, -2.73334831e-02f,
  4.42781933e-02f, 4.51275259e-02f, -8.08049515e-02f, -4.46294114e-04f, -6.31781742e-02f, -3.68376151e-02f, -4.38850112e-02f, -6.12576604e-02f, -1.03033055e-02f, -9.94324405e-03f,
  -6.15053177e-02f, -2.90832259e-02f, -6.81682751e-02f, -6.31722882e-02f, -9.88901313e-03f, -6.75431192e-02f, 3.35505717e-02f, -8.14195201e-02f, -6.74178526e-02f, -2.50138119e-02f,
  -1.61216110e-01f, -1.75410248e-02f, 6.84100986e-02f, -3.27106081e-02f, 1.26299597e-02f, -1.25167549e-01f, 1.83452189e-03f, -1.05763420e-01f, -1.35947853e-01f, -1.11124739e-01f,
  -1.14065655e-01f, -5.42214811e-02f, 2.18260102e-02f, -3.94944735e-02f, -1.46447241e-01f, -1.65803224e-01f, -1.88459769e-01f, 3.59068206e-03f, -2.03018282e-02f, -5.47640212e-02f,
  -1.49774104e-01f, 7.16201738e-02f, 8.41835141e-02f, 6.55369088e-02f, 1.23242371e-05f, -1.67184249e-02f, 9.25190151e-02f, 4.51452360e-02f, 9.65420343e-03f, -1.24444282e-02f,
  -4.80716154e-02f, -1.62247270e-01f, 2.84095526e-01f, 1.65752068e-01f, 1.57066345e-01f, 1.61132157e-01f, 4.91511188e-02f, -5.53825572e-02f, -2.89931241e-02f, 5.48269972e-02f,
  4.92315404e-02f, 1.45570740e-01f, 6.70869350e-02f, 1.41885564e-01f, 2.09962070e-01f, 1.62706286e-01f, 1.76353350e-01f, 2.72194922e-01f, 1.55358404e-01f, 2.32125875e-02f,
  8.48952681e-02f, 2.03294288e-02f, 1.62681073e-01f, 8.43416303e-02f, 1.40433954e-02f, -6.18420057e-02f, 5.67413345e-02f, 2.37169228e-02f, 5.73706962e-02f, 3.34323347e-02f,
  2.38366410e-01f, -9.98313725e-02f, 9.51345712e-02f, -2.88736690e-02f, 6.87484145e-02f, -1.12236897e-02f, 7.36638308e-02f, -2.92435028e-02f, -8.92520025e-02f, 6.63872510e-02f,
  4.30170521e-02f, -4.88502788e-04f, -2.80993641e-03f, -2.32017227e-02f, 1.26998574e-01f, 1.40618995e-01f, 7.98883811e-02f, 5.96798537e-03f, 3.14129926e-02f, -6.62595853e-02f,
  -8.31419155e-02f, 9.55787450e-02f, -2.59930976e-02f, 1.26076331e-02f, -4.75873016e-02f, 9.48403552e-02f, -5.42912818e-02f, -7.11856708e-02f, -5.18160462e-02f, -1.10530354e-01f,
  -3.35572734e-02f, -6.15589730e-02f, -6.77218614e-03f, -1.26800481e-02f, -2.56414581e-02f, 2.91541964e-02f, -1.65419932e-02f, 4.64036921e-03f, -3.26312669e-02f, 1.04494123e-02f,
  -2.87208892e-02f, 1.14545308e-03f, -4.56391908e-02f, -3.32300030e-02f, 3.04507613e-02f, 5.27013801e-02f, -5.10798804e-02f, -4.30548601e-02f, -3.25736627e-02f, 7.38757327e-02f,
  8.91716257e-02f, -3.85009907e-02f, 8.01790413e-03f, -3.24202478e-02f, 1.32035892e-02f, 2.55155098e-03f, -4.51580025e-02f, -3.94714996e-02f, -9.31038335e-02f, 9.07966718e-02f,
  -3.68719362e-02f, 5.80393076e-02f, -3.93669717e-02f, 7.05125695e-03f, -3.23677436e-02f, -7.28818923e-02f, -7.49950409e-02f, -1.19940974e-02f, -3.89493234e-03f, -6.65441677e-02f,
  -9.37347114e-03f, 7.56677194e-03f, 4.58260300e-03f, -1.24491498e-01f, -7.02993292e-03f, 3.61291952e-02f, -3.96018289e-02f, 1.02402069e-01f, 1.71745196e-02f, -7.90201724e-02f,
  -1.43573740e-02f, 6.89633796e-03f, -8.40158388e-02f, -8.50723237e-02f, -9.26627070e-02f, 1.04021437e-01f, 1.69819705e-02f, -7.43735805e-02f, 2.07803026e-02f, -1.82475507e-01f,
  4.07501936e-01f, 2.06284046e-01f, 3.07814986e-03f, 6.46669492e-02f, 1.31092995e-01f, 6.09262586e-02f, 3.25706035e-01f, 9.84640345e-02f, 8.64324421e-02f, 1.06929138e-01f,
  -1.05652571e-01f, -2.26467445e-01f, -7.53507018e-02f, -1.27310202e-01f, 7.81817213e-02f, 1.62949070e-01f, 2.26380974e-01f, 7.93607011e-02f, -4.58910726e-02f, -2.99528819e-02f,
  2.08211131e-02f, 2.15396225e-01f, 1.35871544e-01f, 6.87143579e-02f, -2.40391959e-02f, -7.57510513e-02f, 3.63499410e-02f, 7.26399347e-02f, 3.62864919e-02f, -7.78639987e-02f,
  -2.17303053e-01f, -1.54999748e-03f, 6.60563484e-02f, 7.50913695e-02f, 6.35357946e-02f, 8.29253793e-02f, 3.74920852e-02f, 1.33053556e-01f, 7.24016652e-02f, 1.04489714e-01f,
  2.58126799e-02f, 6.22700006e-02f, 2.50323992e-02f, 7.59790167e-02f, 7.86458254e-02f, 4.79045697e-02f, 3.13422792e-02f, -2.14955825e-02f, 3.17282490e-02f, -5.64109012e-02f,
  5.12756184e-02f, 4.24257200e-03f, 1.09304629e-01f, -4.88767065e-02f, 2.97115259e-02f, -2.56191362e-02f, -4.15759236e-02f, -2.45325714e-02f, 1.06891068e-02f, 5.48509806e-02f,
  9.36765745e-02f, -1.21537875e-02f, -3.67339849e-02f, -2.66007204e-02f, -3.97301503e-02f, 9.29445773e-03f, -1.11364909e-01f, 3.21767144e-02f, -6.25761375e-02f, 7.47700501e-03f,
  -1.13631554e-01f, -9.76683870e-02f, -2.92971954e-02f, -1.24951657e-02f, -1.21997081e-01f, -5.93666965e-03f, 6.20322814e-03f, -1.25326678e-01f, -1.24248385e-01f, -1.77883413e-02f,
  -9.54697654e-02f, -9.80663449e-02f, -7.64643401e-02f, -4.04446498e-02f, -8.16279650e-02f, -6.96729645e-02f, -1.32739380e-01f, -5.92954010e-02f, -4.98972163e-02f, -3.29696275e-02f,
  1.73199385e-01f, -4.26005460e-02f, 4.94963042e-02f, 5.18487804e-02f, 8.80370885e-02f, 8.74675885e-02f, 9.91295651e-02f, -4.33108583e-03f, -2.07086653e-02f, -5.67025207e-02f,
  -5.94022088e-02f, 1.08635612e-01f, 6.42868876e-02f, 3.83086093e-02f, 3.78243700e-02f, 4.66138460e-02f, 9.07974169e-02f, 5.64305186e-02f, 1.39637422e-02f, 4.55061235e-02f,
  1.23689368e-01f, 9.07735005e-02f, 1.24663562e-01f, 7.41385743e-02f, 6.71708807e-02f, 1.04884923e-01f, 9.32114273e-02f, 1.04848117e-01f, 4.37369458e-02f, 2.80832738e-01f,
  -4.99937296e-01f, 2.37069651e-02f, -2.21082270e-01f, -7.16928244e-02f, 1.18517295e-01f, 1.10787988e-01f, 1.58120647e-01f, -1.32063106e-02f, 8.67804047e-04f, -8.46630707e-02f,
  4.70504165e-02f, -4.67287004e-02f, -1.09554924e-01f, 2.21539438e-02f, -1.43683910e-01f, 1.04699373e-01f, 3.60836275e-02f, -6.07405640e-02f, -1.17602624e-01f, 1.85719147e-01f,
  1.37221172e-01f, -6.13551550e-02f, -5.91534711e-02f, -6.48233369e-02f, 6.79619843e-03f, -1.44432709e-01f, -1.01193368e-01f, -1.41048625e-01f, -1.05978502e-02f, -1.04666300e-01f,
  -1.29500031e-01f, -1.43963218e-01f, 8.81363079e-02f, -1.17885265e-02f, 6.95670582e-03f, -1.83679815e-02f, 4.11775224e-02f, 8.49999255e-04f, 7.59297237e-02f, 2.54348051e-02f,
  6.16105571e-02f, 4.05722298e-03f, 6.02385215e-02f, 8.13815221e-02f, 7.65293464e-02f, 1.12506352e-01f, 1.04037493e-01f, -1.24536986e-02f, 5.73321469e-02f, 8.47906321e-02f,
  1.10173203e-01f, 3.88255343e-02f, -1.45687819e-01f, 6.17026724e-02f, -5.06422520e-02f, -5.74722625e-02f, -8.11325163e-02f, -3.85480700e-03f, -1.29315436e-01f, -4.94129471e-02f,
  -4.59685363e-02f, 6.50964975e-02f, 1.08480886e-01f, 6.97228760e-02f, 5.96845858e-02f, -2.69528981e-02f, 8.53216797e-02f, 4.30913828e-02f, 2.46658754e-02f, 4.67780977e-02f,
  9.01172683e-03f, 6.70595393e-02f, 5.95828407e-02f, 1.80188473e-02f, 5.06021008e-02f, -1.07567599e-02f, 4.29882891e-02f, 1.03076614e-01f, 2.73655783e-02f, 3.07565387e-02f,
  3.87531817e-02f, 5.88555671e-02f, 8.94852728e-03f, 1.88218541e-02f, 1.48974005e-02f, 1.23802453e-01f, 5.20606264e-02f, 7.23321512e-02f, 4.58819829e-02f, 1.77368447e-01f,
  -2.40108110e-02f, 4.58283611e-02f, -6.09360598e-02f, 6.16612099e-02f, 4.46732156e-02f, 9.36244875e-02f, 2.76579335e-03f, -5.29299199e-04f, 6.13563769e-02f, 1.01805001e-01f,
  4.22324575e-02f, 5.38498014e-02f, -4.49444838e-02f, 5.79894632e-02f, 6.44929241e-03f, 1.31349504e-01f, 3.70298550e-02f, -1.25452848e-02f, 1.20212197e-01f, 3.17869112e-02f,
  8.07149857e-02f, -6.76105637e-03f, 2.20040344e-02f, -3.66570577e-02f, -3.50131877e-02f, -5.00686206e-02f, 1.71360647e-04f, -4.21829447e-02f, -1.22601375e-01f, -1.21157028e-01f,
  1.88957378e-01f, -3.37144285e-01f, 1.62671804e-01f, -1.03390880e-01f, -1.50223255e-01f, 2.67991889e-02f, -6.66631907e-02f, 1.58155691e-02f, -3.18817496e-02f, -1.69376075e-01f,
  -2.30873115e-02f, -4.14790735e-02f, 1.06060795e-01f, 4.76628132e-02f, 6.75676987e-02f, -1.12822406e-01f, -8.68308917e-02f, 1.90030411e-01f, 3.21023643e-01f, 7.05685988e-02f,
  -1.31401941e-01f, -1.81015342e-01f, 1.23840444e-01f, -7.97594711e-02f, -3.50997239e-01f, -1.05089411e-01f, -1.05815172e-01f, -7.52923936e-02f, -4.12324183e-02f, -3.02859098e-01f,
  -2.58656386e-02f, 8.72706398e-02f, 3.07136513e-02f, -1.14956768e-02f, -3.72800678e-02f, -2.28659553e-03f, -1.84855871e-02f, -2.69313771e-02f, 1.33849755e-02f, -5.53450873e-03f,
  -4.89233807e-02f, -7.30511993e-02f, -6.16599321e-02f, -3.51076536e-02f, 5.51903546e-02f, -8.02768841e-02f, -3.89522612e-02f, 1.06875472e-01f, 7.54313543e-02f, -1.47597238e-01f,
  -1.73346549e-01f, -6.50610328e-02f, 1.89025362e-04f, -2.73030493e-02f, -3.22646126e-02f, 5.15232123e-02f, -2.44336575e-02f, 1.36626698e-02f, -6.13585580e-03f, -1.65952727e-01f,
  -1.29741296e-01f, 6.38782009e-02f, 4.20832336e-02f, 3.73891927e-02f, 4.66090217e-02f, 9.75732282e-02f, 8.07709694e-02f, 1.23898918e-02f, 1.44015715e-01f, -5.59016271e-03f,
  7.70979822e-02f, 1.20901197e-01f, 9.14491862e-02f, 5.22108525e-02f, 1.02100566e-01f, 3.76923159e-02f, 5.19661568e-02f, 9.25698653e-02f, 8.31394717e-02f, 1.21561415e-01f,
  1.89012229e-01f, 5.81554435e-02f, 4.15971950e-02f, 3.56791355e-02f, 7.07436502e-02f, 1.49111927e-01f, 1.50452018e-01f, 9.98822153e-02f, 1.11081138e-01f, 2.54225023e-02f,
  -1.12208590e-01f, 1.72770619e-01f, -1.16092108e-01f, -6.88111782e-02f, -4.05609198e-02f, -5.59032261e-02f, -6.50210157e-02f, 6.42464543e-03f, -3.37986313e-02f, -2.96945423e-02f,
  -7.38170221e-02f, 9.88791510e-02f, -9.78550538e-02f, -1.30677179e-01f, -4.06641103e-02f, 1.81569401e-02f, -1.71513677e-01f, -6.32624030e-02f, -8.37413222e-02f, -1.27456620e-01f,
  -2.24293634e-01f, -7.50600770e-02f, 7.93398395e-02f, -1.03544511e-01f, -1.34998083e-01f, 6.47801161e-02f, -6.17595427e-02f, -1.30682394e-01f, 6.20397516e-02f, -2.27746204e-01f,
  1.61485150e-01f, 1.51504606e-01f, 2.99570888e-01f, -1.34551898e-01f, -2.46889107e-02f, -9.22624618e-02f, -1.09293744e-01f, -4.64759283e-02f, -1.38274848e-01f, 8.79862905e-02f,
  -8.21868405e-02f, -1.82539895e-01f, -5.26709631e-02f, -2.33540237e-02f, -5.83625212e-02f, 1.29079714e-01f, 2.23214373e-01f, 2.25826815e-01f, -1.01328813e-01f, -2.42133081e-01f,
  -1.77023798e-01f, -1.24497386e-02f, 6.07279688e-02f, -1.34393321e-02f, 1.81733221e-01f, -4.64538252e-03f, 1.74263179e-01f, 1.20820843e-01f, 4.78512682e-02f, 3.93997997e-01f,
  2.26442635e-01f, 9.92671028e-02f, -1.45812988e-01f, -9.08901077e-03f, -1.62707716e-02f, 2.55616121e-02f, 4.20655608e-02f, -4.90450487e-02f, -1.01542957e-01f, 3.86011787e-02f,
  -1.96067635e-02f, 1.36695942e-03f, -2.83055492e-02f, -7.47377798e-02f, -1.37798274e-02f, -9.57115274e-03f, 3.78318764e-02f, 2.11206097e-02f, -6.10722043e-02f, -5.66311739e-02f,
  -9.33380127e-02f, 1.91982882e-03f, 6.26622513e-02f, -6.75607473e-02f, 7.11663067e-02f, -1.00441545e-01f, -5.33729009e-02f, 4.83136438e-02f, -5.57045192e-02f, 1.26399502e-01f,
  -1.42793998e-01f, 2.06978805e-02f, 5.28006963e-02f, 7.70622492e-02f, 5.30519756e-03f, 8.83943513e-02f, 2.55734771e-02f, 6.70512542e-02f, -2.88795494e-02f, 7.43105114e-02f,
  -3.78965237e-03f, -5.30784437e-03f, -1.31473097e-03f, -4.76171914e-03f, 2.81370953e-02f, 1.05612159e-01f, 2.68067867e-02f, 5.65927699e-02f, 1.10606635e-02f, 4.90373187e-02f,
  1.91419777e-02f, -1.29115973e-02f, 4.20827717e-02f, 1.68869272e-02f, -2.65012332e-03f, 6.42104298e-02f, 1.18350722e-01f, 9.20212492e-02f, -2.49085925e-03f, 2.99003497e-02f,
  -1.55862868e-01f, -6.78132027e-02f, 1.08099639e-01f, -8.07292014e-03f, 3.00877485e-02f, -2.39314102e-02f, -2.46343133e-03f, -4.56813537e-02f, -1.80230681e-02f, -1.04699306e-01f,
  -9.64038819e-02f, 7.53093809e-02f, 1.66118443e-02f, -5.56616224e-02f, -1.55784965e-01f, 1.28718140e-02f, -3.11533101e-02f, -4.71479371e-02f, -1.16075970e-01f, -1.37473553e-01f,
  -6.22245483e-02f, -1.84658304e-01f, -1.06218562e-01f, -1.02463648e-01f, -1.39745817e-01f, -2.40809530e-01f, -7.60692507e-02f, -5.47163673e-02f, -5.53489812e-02f, -2.14276671e-01f,
  -1.61383256e-01f, -1.76571272e-02f, -2.26787720e-02f, -4.30985214e-03f, 1.69831976e-01f, 4.90619130e-02f, 8.38756654e-03f, -1.21367173e-02f, -3.01030148e-02f, 3.01315859e-02f,
  2.73196816e-01f, 1.80213273e-01f, 7.99489096e-02f, 8.64875391e-02f, 2.34150831e-02f, -1.99784547e-01f, -2.34011747e-02f, 1.52576510e-02f, 6.86067417e-02f, 1.15019925e-01f,
  2.36871131e-02f, -3.44067886e-02f, -6.31638616e-02f, -2.40393225e-02f, -2.13425741e-01f, -5.84714347e-03f, -2.57241614e-02f, -1.06868014e-01f, -4.95708287e-02f, -2.57802099e-01f,
  -4.92275134e-02f, 1.39492363e-01f, 9.79552511e-03f, 1.00742914e-01f, 1.04213478e-02f, 3.45728290e-03f, 1.02750901e-02f, -1.19402763e-02f, -3.13856862e-02f, -9.11556091e-03f,
  7.47548789e-02f, 6.24999590e-02f, 5.83332628e-02f, 5.56279980e-02f, 3.39533389e-03f, -5.69363870e-02f, -7.79836625e-02f, -4.50367592e-02f, -6.46224618e-02f, 6.85667396e-02f,
  6.64697513e-02f, 1.42411768e-01f, 9.13088955e-03f, -8.48698523e-03f, 9.89163220e-02f, -4.46120789e-03f, 2.59580314e-02f, -1.12973168e-01f, -8.26494023e-02f, -2.20992371e-01f,
  -7.75619671e-02f, -3.09290644e-02f, 6.85059801e-02f, 6.16875775e-02f, -1.26554333e-02f, 1.09805642e-02f, -2.02745870e-02f, -3.09826676e-02f, 1.83785066e-03f, -6.58884570e-02f,
  2.35133749e-02f, 6.26934469e-02f, 7.44111687e-02f, -3.53984423e-02f, -2.90991236e-02f, -7.07154125e-02f, 2.67716736e-04f, -7.11852834e-02f, 6.57762066e-02f, 1.52300270e-02f,
  4.07795869e-02f, 1.73329599e-02f, -2.86962632e-02f, -1.70021337e-02f, 7.22380579e-02f, 2.66405921e-02f, -4.31757160e-02f, 1.42147228e-01f, -3.80489156e-02f, 2.29782052e-02f,
  -1.02435574e-01f, 2.41468102e-01f, 8.29865597e-03f, -5.89157157e-02f, -9.60381888e-03f, -3.78571055e-03f, 3.01801413e-02f, 1.04540579e-01f, 5.89938574e-02f, -2.81683933e-02f,
  4.11144793e-02f, -3.87391448e-02f, 4.24576439e-02f, 2.23853551e-02f, 1.45339137e-02f, 6.63772821e-02f, 2.27569602e-04f, 8.94131325e-03f, 4.47125472e-02f, 7.47472867e-02f,
  -1.58236567e-02f, -8.98163766e-03f, -2.51190700e-02f, -5.32930680e-02f, -3.20319459e-02f, 3.05975825e-02f, -3.82079668e-02f, -1.26113951e-01f, -1.10960625e-01f, -2.60225743e-01f,
  -2.91943550e-01f, 3.74036849e-01f, 2.49609649e-02f, -6.70121312e-02f, 3.14511180e-01f, 3.00356299e-01f, 2.89855838e-01f, -9.00874194e-03f, -1.42417476e-01f, 1.69676766e-01f,
  1.75014094e-01f, -2.37666145e-01f, -1.93342552e-01f, -1.78866491e-01f, -2.69023180e-01f, 3.39111164e-02f, -3.10696079e-03f, -2.08613411e-01f, -2.54581213e-01f, -6.96003884e-02f,
  1.09453432e-01f, -9.44338962e-02f, -9.39193591e-02f, -1.21427558e-01f, 1.54134721e-01f, -3.26656811e-02f, 2.23845765e-01f, 1.21762991e-01f, 2.05211312e-01f, 9.33183581e-02f,
  -6.94279000e-02f, 1.05309948e-01f, -1.60358310e-01f, -4.64050062e-02f, 6.63064644e-02f, -3.93145718e-02f, -2.28981469e-02f, -1.22279944e-02f, 9.52705294e-02f, 3.11514456e-02f,
  -1.55351113e-03f, 6.52493834e-02f, 2.62075029e-02f, 3.23020481e-02f, -4.07794863e-02f, -6.21500686e-02f, 5.74774016e-03f, -1.14168666e-01f, -5.74842021e-02f, 8.86442363e-02f,
  1.92303210e-01f, 1.81745484e-01f, 7.34609552e-03f, 5.61500899e-02f, 1.46166785e-02f, -4.32594381e-02f, 1.61933266e-02f, 3.13467011e-02f, 1.06530927e-01f, -1.07944787e-01f,
  6.86149448e-02f, 1.94849167e-02f, 1.92544833e-02f, 2.99287066e-02f, 3.10584009e-02f, 3.77851501e-02f, 1.17478296e-02f, -2.85013430e-02f, -3.52271087e-02f, -4.17822935e-02f,
  -4.11508465e-03f, 2.07318366e-02f, -1.15983579e-02f, -5.27918674e-02f, -7.87998270e-03f, -3.76881063e-02f, -1.48395356e-02f, -4.83744070e-02f, -6.22515157e-02f, 1.76567174e-02f,
  -1.61070582e-02f, -2.61254720e-02f, -5.31682686e-04f, -1.08806223e-01f, 8.80205482e-02f, -2.76699197e-02f, -5.79806864e-02f, -2.32015252e-02f, -6.62426697e-03f, -1.13861719e-02f,
  -2.60750026e-01f, -1.59302745e-02f, -1.09948635e-01f, -1.32806569e-01f, 5.54760806e-02f, 2.57961433e-02f, 6.23671375e-02f, -2.94738114e-02f, -4.33581546e-02f, -2.53560790e-03f,
  8.90762657e-02f, 1.64125506e-02f, -5.26652448e-02f, 2.68223695e-02f, -1.62833892e-02f, -7.68301040e-02f, 4.51937877e-02f, -5.71420938e-02f, -1.64276175e-02f, -1.74991861e-02f,
  9.45025012e-02f, -1.58614963e-02f, -8.29463154e-02f, -4.82158698e-02f, 1.89596713e-02f, -1.04111128e-01f, -7.23679066e-02f, 4.10270840e-02f, -1.67520791e-01f, -5.27422465e-02f,
  -1.80689886e-01f, -1.74607128e-01f, -7.63245225e-02f, 8.48783702e-02f, 3.25637721e-02f, -2.36530960e-01f, -2.24531919e-01f, -6.32888079e-02f, 7.08484948e-02f, 1.46089708e-02f,
  -1.53376823e-02f, 1.89297363e-01f, 1.45011410e-01f, 1.77869387e-02f, 1.71199709e-03f, -7.85718933e-02f, -8.11936508e-04f, 1.16114922e-01f, -2.44339630e-02f, 3.47439013e-02f,
  1.22531213e-01f, 2.03038573e-01f, 1.49499610e-01f, 1.11368254e-01f, 1.39006868e-01f, 6.72027543e-02f, 5.64523861e-02f, 5.62027730e-02f, -3.67784351e-02f, 1.85221344e-01f,
  -1.19518578e-01f, -1.42303601e-01f, 2.31139399e-02f, 2.93128528e-02f, -2.70052105e-02f, -4.51036431e-02f, -1.12552330e-01f, 9.70530286e-02f, -9.11097527e-02f, 4.31779064e-02f,
  -2.03252006e-02f, 9.10467748e-03f, 7.55484700e-02f, -3.88748497e-02f, -7.46584609e-02f, -1.46600055e-02f, 3.95742469e-02f, 3.72146703e-02f, 8.28891695e-02f, -1.02199480e-01f,
  8.84886011e-02f, 4.82606702e-02f, -4.20459025e-02f, -2.95237917e-02f, -4.62383889e-02f, 1.31904230e-01f, -1.37595132e-01f, -7.21389754e-03f, -8.65728557e-02f, -1.22012086e-01f,
  4.21381481e-02f, -6.05145320e-02f, 9.04143788e-03f, 1.97994616e-02f, -6.45376891e-02f, -4.25110571e-02f, -4.23593894e-02f, -9.48774591e-02f, 1.55951381e-02f, -4.46206853e-02f,
  -2.99988464e-02f, -2.76276078e-02f, 6.18001893e-02f, -3.86729129e-02f, 5.55928703e-03f, 3.93475890e-02f, -6.19648695e-02f, -1.17568839e-02f, -1.06707253e-02f, 2.32864954e-02f,
  6.09170739e-03f, -2.60831937e-02f, 7.10415319e-02f, 5.65048344e-02f, -5.18981600e-03f, 5.31145446e-02f, -1.91861726e-02f, -6.47477433e-03f, -3.33726741e-02f, 3.97506319e-02f,
  1.13759503e-01f, 9.95566547e-02f, -7.23809004e-02f, -9.60074961e-02f, -1.18719041e-01f, 3.73397511e-03f, -2.89224871e-02f, 3.20039541e-02f, -6.65318593e-02f, -9.89293382e-02f,
  -3.26056369e-02f, -5.36602288e-02f, 6.26779124e-02f, 2.49084551e-02f, -8.92333835e-02f, -2.22911802e-03f, -6.90772012e-02f, -1.02353230e-01f, 5.42612299e-02f, 1.73242074e-02f,
  -3.77430506e-02f, -6.08538128e-02f, -1.36383876e-01f, -1.48072138e-01f, -1.11175954e-01f, -1.69566870e-01f, -9.79480818e-02f, -1.29344732e-01f, -1.97676808e-01f, -1.99054092e-01f,
  3.58864248e-01f, 2.17289716e-01f, 4.07959819e-02f, 8.22093859e-02f, -7.62003735e-02f, 5.81027605e-02f, 9.27238613e-02f, 1.82813838e-01f, 1.75738595e-02f, 1.99594032e-02f,
  -1.07759446e-01f, -1.43277287e-01f, -1.82448104e-01f, -4.28839028e-02f, -5.06547205e-02f, 6.19767755e-02f, 1.53058216e-01f, 6.06043786e-02f, 3.75840738e-02f, -1.17078960e-01f,
  -1.20193623e-02f, 1.58988517e-02f, 5.40269241e-02f, 5.07559031e-02f, 3.65208872e-02f, -7.61551186e-02f, 5.27894534e-02f, 9.97090787e-02f, -6.79195747e-02f, 1.00895882e-01f,
  -2.22449213e-01f, 1.30806372e-01f, 7.49353133e-03f, -1.92857184e-03f, 6.33225963e-02f, -3.65673229e-02f, 1.43130519e-03f, 9.65219215e-02f, 3.56397927e-02f, 5.15067764e-02f,
  -2.72619277e-02f, 4.67500761e-02f, 5.89662790e-02f, 8.31018947e-03f, 1.60427809e-01f, -3.90772410e-02f, 1.47378653e-01f, 1.29384950e-01f, 1.27412587e-01f, 2.19709482e-02f,
  -5.16380742e-02f, 9.01468098e-03f, 5.81156686e-02f, 6.11612126e-02f, 1.11592390e-01f, -4.29360084e-02f, 9.98529270e-02f, 1.03142172e-01f, 1.29663050e-01f, 1.34228751e-01f,
  -9.38047320e-02f, -4.20335270e-02f, -1.17379175e-02f, 1.05958907e-02f, 3.01408228e-02f, -2.07271706e-02f, -1.86955631e-02f, -3.85309719e-02f, 6.94550434e-03f, -1.76165141e-02f,
  1.80343408e-02f, -8.96269549e-03f, 3.32042724e-02f, 5.93461432e-02f, -1.08661205e-02f, 7.23303631e-02f, 1.41108548e-02f, -4.56929952e-02f, -2.13842187e-02f, -4.96520475e-02f,
  -7.01664295e-03f, -4.23337035e-02f, 4.08342332e-02f, 4.68907394e-02f, -1.28132943e-02f, 3.80830541e-02f, 4.44256403e-02f, -4.43687998e-02f, 7.13281110e-02f, 9.68203414e-03f,
  -1.03169620e-01f, -2.68412642e-02f, -4.15338576e-02f, 1.00146443e-01f, 5.18614687e-02f, 6.64076954e-02f, -2.37379950e-02f, 1.09589770e-01f, 9.23679769e-02f, 2.87224762e-02f,
  1.17419697e-02f, 5.53776436e-02f, -1.20028667e-02f, 5.87233268e-02f, -2.15408932e-02f, -8.52005091e-03f, 8.09385478e-02f, 3.00130453e-02f, 8.03225189e-02f, 4.57703061e-02f,
  1.10472187e-01f, 1.42219335e-01f, -1.54542970e-02f, -5.95188094e-03f, 2.88034752e-02f, 6.01887219e-02f, 3.30330059e-03f, 1.47958351e-02f, 9.26345289e-02f, 2.42418453e-01f,
  5.39463580e-01f, -1.05113797e-01f, -1.35628849e-01f, 9.19469371e-02f, -1.10888546e-02f, 4.37734127e-02f, -5.13150394e-02f, 4.96066846e-02f, -1.13844872e-01f, -3.51701789e-02f,
  8.67184028e-02f, 7.67143965e-02f, -1.63292140e-02f, -8.45775828e-02f, -5.12483232e-02f, -2.39489317e-01f, -1.98572710e-01f, 9.33361612e-03f, 4.92027439e-02f, -9.17842761e-02f,
  -1.09092765e-01f, -6.49185702e-02f, 1.42053273e-02f, -7.05487877e-02f, -2.12774903e-01f, -5.12463413e-02f, -1.96999505e-01f, -8.27247873e-02f, -1.48013309e-01f, -3.46797436e-01f,
  -4.04072776e-02f, 1.22505717e-01f, -2.63089146e-02f, -5.03032058e-02f, -1.16325438e-01f, -2.07717111e-03f, -6.60324544e-02f, -6.44870028e-02f, -8.03695023e-02f, -7.52538741e-02f,
  -6.41400516e-02f, -1.05147029e-03f, -9.51169580e-02f, -1.18316703e-01f, -1.36546791e-01f, -4.82642502e-02f, -1.47531703e-01f, -6.55377507e-02f, -1.46794975e-01f, -1.48362249e-01f,
  -9.09026340e-02f, -1.45348608e-01f, -1.16740875e-01f, -7.32371211e-02f, -9.58377123e-02f, -2.27085315e-02f, -6.89819977e-02f, -3.60810719e-02f, -8.42813961e-03f, -2.08519623e-01f,
  7.07068220e-02f, -7.63170980e-03f, 4.55153324e-02f, 6.83891252e-02f, 3.48398797e-02f, 7.29926955e-03f, -1.93017498e-02f, 9.59235616e-03f, 1.93640497e-03f, 8.20600986e-03f,
  1.58635471e-02f, -1.58930162e-03f, -2.32836008e-02f, 2.87752692e-03f, -2.85896938e-02f, -8.53546057e-03f, -3.60286012e-02f, -5.06884344e-02f, -4.25674543e-02f, 5.24053574e-02f,
  1.35543086e-02f, -6.27963692e-02f, -1.57159530e-02f, -3.27656232e-02f, 2.25857534e-02f, 1.47915287e-02f, -5.00957528e-03f, 3.35194319e-02f, 7.47516677e-02f, -1.94020402e-02f,
  7.17074610e-03f, 9.32426006e-02f, -8.47833529e-02f, -1.34751841e-01f, 9.85583756e-03f, -9.36646238e-02f, -1.56803243e-02f, -7.95600638e-02f, -1.74244784e-03f, -2.13748869e-02f,
  -5.25237545e-02f, -1.13932705e-02f, -2.04734523e-02f, -9.02840197e-02f, -2.00013574e-02f, -3.29564251e-02f, -8.36805999e-03f, -1.63138229e-02f, -1.14839450e-01f, -7.86394700e-02f,
  -8.81680995e-02f, 3.86377424e-02f, 6.24599680e-02f, -1.10374622e-01f, -8.43989551e-02f, 4.44158390e-02f, -2.62928475e-02f, -1.23307295e-01f, 2.02706158e-02f, 7.37415673e-03f,
  -4.38721389e-01f, 3.94505262e-02f, -1.94781736e-01f, -1.82453737e-01f, -7.94608295e-02f, -7.25964978e-02f, -3.56041007e-02f, -5.02580106e-02f, -1.36598110e-01f, 7.35066086e-02f,
  1.70988977e-01f, 1.89621300e-02f, -8.80017802e-02f, -2.76017971e-02f, -1.70800731e-01f, -2.64758378e-01f, -2.16932818e-01f, -3.46895933e-01f, -3.18227619e-01f, 9.68136452e-03f,
  -3.47523578e-02f, -1.15389906e-01f, -2.70947039e-01f, -1.42966032e-01f, -4.89066988e-02f, 2.84951879e-03f, -1.12847917e-01f, -2.55953129e-02f, -7.96372294e-02f, -5.37025966e-02f,
  -2.55054738e-02f, -1.49420261e-01f, -1.47380367e-01f, -5.37048839e-03f, 5.59317088e-03f, -1.25011161e-01f, -5.61476611e-02f, -9.73389596e-02f, -3.96459512e-02f, -4.63095866e-02f,
  1.60222757e-04f, -7.18625914e-03f, -3.94373611e-02f, -7.80349374e-02f, -1.82366669e-02f, -9.28909481e-02f, -8.87597129e-02f, -1.40914276e-01f, -1.50141612e-01f, -3.45761143e-02f,
  5.42099737e-02f, -1.63430914e-01f, -1.09857567e-01f, -6.52760193e-02f, -3.72943021e-02f, -1.35718258e-02f, 4.68672812e-02f, -7.34736621e-02f, -1.15760438e-01f, -4.12244396e-03f,
  4.26824652e-02f, 5.01983911e-02f, 7.32455552e-02f, 5.36970906e-02f, 1.18528821e-01f, 1.49189845e-01f, 3.56040187e-02f, 1.15844645e-01f, 3.03386501e-03f, 8.69739503e-02f,
  9.92699340e-02f, 9.82008874e-02f, 1.88405048e-02f, -4.01939116e-02f, 1.20557107e-01f, 8.98187086e-02f, 2.34734006e-02f, 2.07585186e-01f, 5.04339747e-02f, 3.86589505e-02f,
  6.13434501e-02f, -8.84100504e-04f, 8.12425390e-02f, 4.99356762e-02f, 7.42405728e-02f, 9.52626951e-03f, 1.27278522e-01f, 1.51094958e-01f, 7.97198042e-02f, -9.87216644e-03f,
  7.01436400e-02f, -4.76783924e-02f, -4.70327251e-02f, -1.17659949e-01f, -7.73918703e-02f, -7.79891461e-02f, 2.32296064e-02f, -3.66625711e-02f, 7.22453510e-03f, -7.85463080e-02f,
  -1.03858717e-01f, -6.80844560e-02f, -8.79774615e-02f, -8.48410055e-02f, -1.43027619e-01f, -6.25897422e-02f, 4.79725748e-02f, -9.90743414e-02f, -7.47717321e-02f, 6.59019127e-02f,
  -5.88896349e-02f, -1.58272743e-01f, -1.82240903e-01f, -6.21483997e-02f, -1.07765943e-01f, -1.99201450e-01f, -6.27154335e-02f, -1.12092286e-01f, -1.91665202e-01f, -5.24784327e-02f,
  -3.16278160e-01f, -1.14432663e-01f, -7.54128918e-02f, -1.64575949e-01f, -1.80155989e-02f, 2.30606496e-01f, 9.33884680e-02f, 1.20140411e-01f, 6.83951192e-03f, -3.59839536e-02f,
  7.85124004e-02f, 1.57765791e-01f, -1.29321776e-02f, 1.41646355e-01f, 2.84741949e-02f, -1.64119184e-01f, -4.03985865e-02f, 3.37087624e-02f, 2.66938537e-01f, 2.34668776e-01f,
  8.54132846e-02f, -5.96637875e-02f, -7.69255981e-02f, 2.77882777e-02f, -2.10594833e-02f, 1.46748140e-01f, -4.25786898e-02f, -1.04481697e-01f, 1.08734593e-01f, -2.93868124e-01f,
  -1.09639056e-01f, -1.73314922e-02f, 1.52685076e-01f, 1.15246959e-01f, 4.75396588e-02f, 4.08659205e-02f, 8.25091973e-02f, 2.73823459e-02f, 3.29315588e-02f, -1.20721580e-02f,
  2.50739958e-02f, 3.47500928e-02f, 8.72878283e-02f, 3.42171080e-02f, 3.79240438e-02f, 1.19996846e-01f, 1.09212860e-01f, 2.75723431e-02f, 2.57482380e-02f, 9.98913795e-02f,
  2.50997934e-02f, 8.31515342e-02f, 4.40251529e-02f, 1.34090871e-01f, 1.54762357e-01f, 8.04379955e-02f, 8.85358378e-02f, 5.25614917e-02f, 9.58330110e-02f, -3.80136296e-02f,
  5.39759547e-02f, 2.20968463e-02f, 6.83921501e-02f, -4.88944277e-02f, -4.72488664e-02f, -7.45574683e-02f, 2.50959806e-02f, -1.37845241e-02f, 4.89822775e-02f, -2.25500427e-02f,
  3.02668847e-02f, -1.99246663e-03f, -4.01670672e-02f, -6.68781474e-02f, -1.89842600e-02f, 2.57289223e-03f, 1.76421851e-02f, -2.98038358e-03f, -5.07429504e-05f, -4.74995077e-02f,
  -3.52786593e-02f, -5.66085503e-02f, 4.59916517e-02f, 5.42139523e-02f, -1.52285947e-02f, 3.95847224e-02f, -2.15829443e-03f, 6.62666410e-02f, -3.40909027e-02f, -2.34333836e-02f,
  1.19325723e-02f, 2.33772248e-01f, -7.73461536e-02f, 6.42302334e-02f, 5.17689884e-02f, 2.58156713e-02f, -9.24956799e-02f, 5.12396954e-02f, -1.58755500e-02f, 5.75274676e-02f,
  1.05152003e-01f, 2.40942743e-02f, -3.84352468e-02f, 5.55987358e-02f, 9.71195400e-02f, 1.08590141e-01f, 1.78780463e-02f, 1.85923912e-02f, 1.25203773e-01f, 7.01819360e-02f,
  1.08073041e-01f, 4.40887623e-02f, -1.87140964e-02f, 1.11300103e-01f, 1.10348657e-01f, -5.69203822e-03f, 1.17285952e-01f, 1.40494376e-01f, 2.07634479e-01f, 5.56395948e-02f,
  -6.92065060e-02f, 6.14659339e-02f, -5.63188791e-02f, -7.65214264e-02f, -1.53058782e-01f, -3.69093537e-01f, -4.17139441e-01f, -2.69732982e-01f, -3.93836536e-02f, -6.78345561e-02f,
  -4.99441884e-02f, 2.19746232e-02f, 6.33229986e-02f, 5.93787283e-02f, -2.20958695e-01f, -1.06156327e-01f, -9.28462017e-03f, -8.78813341e-02f, -2.41849348e-01f, -2.20020041e-01f,
  -1.29266515e-01f, -8.33498389e-02f, 5.66515094e-03f, 4.90199251e-04f, 1.10735573e-01f, 5.48895746e-02f, 7.20111355e-02f, 7.03313109e-03f, -5.82622811e-02f, 2.67851889e-01f,
  1.53782308e-01f, -2.47151591e-03f, -1.07847005e-01f, -1.01004047e-02f, -3.21332067e-02f, -2.14209538e-02f, -4.72219512e-02f, 4.92452495e-02f, -3.29086781e-02f, -5.36985323e-02f,
  -3.73207242e-03f, 1.01557616e-02f, -8.57944041e-02f, 7.05078244e-02f, 9.31037217e-03f, -8.72993693e-02f, 2.28399094e-02f, 4.45864201e-02f, -7.31495023e-03f, -7.25994483e-02f,
  4.57039811e-02f, -8.46527442e-02f, -1.13334931e-01f, -4.41825651e-02f, -3.61234546e-02f, -6.15468919e-02f, 3.98204802e-03f, 4.38232869e-02f, -8.37384015e-02f, 6.80361688e-02f,
  3.30510475e-02f, 4.96384539e-02f, 1.11447442e-02f, 2.84225121e-02f, 5.85139766e-02f, -3.51760350e-02f, 7.41774514e-02f, 6.76533803e-02f, -3.56281660e-02f, 4.73461151e-02f,
  -3.83235328e-02f, 4.98844385e-02f, -1.74026247e-02f, 4.33616750e-02f, -2.15653051e-02f, -9.71719436e-03f, 3.11865509e-02f, 4.12866808e-02f, 9.16673765e-02f, 1.96377542e-02f,
  7.04760253e-02f, 2.79711150e-02f, -8.65609013e-03f, 7.00629130e-02f, -4.44535874e-02f, 1.43683364e-03f, -7.14142397e-02f, -2.02292707e-02f, 2.74934880e-02f, -5.85318804e-02f,
  5.08487374e-02f, -1.94447428e-01f, 5.61893322e-02f, -6.63138330e-02f, -2.55410783e-02f, -4.10959683e-02f, -4.74417433e-02f, -9.84090101e-03f, -8.02457482e-02f, 3.41006145e-02f,
  -2.11217199e-02f, -8.18373710e-02f, 5.75431399e-02f, -2.70797536e-02f, -9.31053385e-02f, -5.98340295e-02f, 5.00766858e-02f, -7.20990705e-04f, -9.42690670e-02f, 3.41458768e-02f,
  6.41983300e-02f, -7.62449130e-02f, -9.78766531e-02f, 1.71187439e-03f, 1.69719607e-02f, -1.75471738e-01f, 6.35321513e-02f, 9.66657139e-03f, -1.96478128e-01f, -5.16575426e-02f,
  -1.63002372e-01f, -3.65423173e-01f, -8.41208771e-02f, -1.24489412e-01f, -9.23764799e-03f, 5.85317351e-02f, 4.75826524e-02f, 1.32733837e-01f, -1.23351738e-02f, -2.12917432e-01f,
  -2.41227403e-01f, -6.67546839e-02f, -5.67390360e-02f, 1.25999779e-01f, 9.09476429e-02f, 1.25428308e-02f, -7.36739114e-03f, 2.22019061e-01f, 3.63124877e-01f, 2.31475413e-01f,
  1.79212876e-02f, -2.64251232e-02f, 1.42829627e-01f, 1.55070677e-01f, -1.44922912e-01f, -1.46265710e-02f, -1.41049296e-01f, -3.74700129e-02f, -9.45788324e-02f, -2.33439401e-01f,
  -2.26585507e-01f, -2.25388020e-01f, 9.04324874e-02f, -4.11843732e-02f, -1.11827478e-01f, 3.57756130e-02f, -4.75314865e-03f, -6.39736429e-02f, -2.43737102e-02f, -1.07777701e-03f,
  -1.04673110e-01f, 7.62105435e-02f, -4.82134297e-02f, -3.05755939e-02f, 6.83590323e-02f, 2.87595298e-02f, 2.16661729e-02f, 1.42792508e-01f, 9.10281166e-02f, -4.28156294e-02f,
  1.62623022e-02f, -1.88447237e-01f, -1.09930076e-01f, -1.80966575e-02f, 9.76515636e-02f, -5.24322428e-02f, -6.65184669e-03f, -3.08361859e-03f, 1.06767073e-01f, -1.13886349e-01f,
  -2.00145375e-02f, -5.63973635e-02f, 1.19071994e-02f, 6.61330372e-02f, -6.92647398e-02f, 6.26237423e-04f, -3.71987969e-02f, 1.55435046e-02f, -6.02521701e-04f, 7.46313343e-03f,
  3.88339721e-02f, 3.76047636e-03f, 3.72803211e-02f, -1.17802452e-02f, -6.23204894e-02f, 6.02111826e-03f, 3.02074775e-02f, -2.34949682e-02f, 2.00987514e-02f, 5.01884818e-02f,
  1.11321835e-02f, 6.97048567e-03f, -5.25535904e-02f, 1.76641554e-01f, 6.57482892e-02f, 4.11771685e-02f, -6.19810782e-02f, -1.69833582e-02f, -3.91593091e-02f, -8.16321559e-03f,
  -1.09614313e-01f, 5.36964554e-03f, -1.80709794e-01f, 9.12897661e-03f, 2.12302711e-02f, -2.50841863e-03f, -1.43572375e-01f, 9.84417573e-02f, -8.91855136e-02f, -5.77347577e-02f,
  -3.06307245e-02f, 4.97312583e-02f, -1.33443177e-01f, 4.50659432e-02f, 3.95881981e-02f, 6.13196343e-02f, -7.06845075e-02f, 2.92637367e-02f, -9.38673783e-03f, -1.83538701e-02f,
  -2.96644960e-02f, 4.08625565e-02f, -1.22463144e-01f, -1.00671379e-02f, -1.97015945e-02f, -1.21127805e-02f, -3.29297222e-03f, 4.80570942e-02f, -1.76569931e-02f, -3.08550298e-02f,
  6.19700179e-02f, 1.44333795e-01f, 3.12328666e-01f, 1.34403035e-01f, 3.72562818e-02f, -5.03003076e-02f, -7.66060650e-02f, -8.00848156e-02f, 3.71353105e-02f, 1.07447341e-01f,
  -7.77779594e-02f, -3.27745199e-01f, -1.44556031e-01f, -2.35573173e-01f, -2.30989039e-01f, 1.35548696e-01f, 2.45013192e-01f, 7.99128413e-02f, -1.27451807e-01f, -9.39223021e-02f,
  -4.96185012e-02f, 1.27586588e-01f, 1.12703808e-01f, -3.85403447e-02f, 1.97465986e-01f, -9.00590271e-02f, 2.30546385e-01f, 1.81299016e-01f, -5.38097061e-02f, 3.32248688e-01f,
  1.38418689e-01f, 1.61023781e-01f, -1.46854505e-01f, -6.36088699e-02f, 6.22955523e-02f, 3.27083357e-02f, 1.16245404e-01f, 1.60679698e-01f, -2.90396791e-02f, 1.10643566e-01f,
  9.50713605e-02f, -4.49504405e-02f, 1.08305328e-01f, 9.28028021e-03f, 1.76234528e-01f, 5.73112145e-02f, 3.61668542e-02f, 3.29302512e-02f, 4.55043837e-02f, 8.09866786e-02f,
  6.86964169e-02f, 1.14787817e-01f, 1.14845224e-01f, -1.88913774e-02f, -6.19817749e-02f, -4.56106476e-02f, 8.80915076e-02f, 7.35995173e-02f, -2.07029507e-02f, 1.65863633e-01f,
  -4.18247692e-02f, 1.12770058e-01f, 1.05755031e-02f, 2.74432469e-02f, -1.71409845e-02f, 8.92077666e-03f, 4.45135823e-03f, -5.81831783e-02f, 3.43951695e-02f, 8.88490975e-02f,
  -4.37871292e-02f, -1.24800950e-02f, -1.63046513e-02f, 4.99778464e-02f, 1.02557261e-02f, 9.41973925e-02f, 1.26497690e-02f, -3.48875038e-02f, -2.68985145e-02f, -6.27484173e-02f,
  -1.12693973e-01f, -7.27657601e-02f, 5.14274798e-02f, -1.38029829e-02f, -6.90795034e-02f, -1.57563866e-03f, 1.42682483e-03f, -1.60582531e-02f, -4.48414907e-02f, 7.24428892e-02f,
  -3.43539603e-02f, -1.63381144e-01f, 4.95242067e-02f, 3.82769443e-02f, 9.71023068e-02f, 6.44532591e-02f, 3.06779817e-02f, 5.36150299e-02f, -1.20538129e-02f, 8.09879899e-02f,
  1.79978665e-02f, 7.97140077e-02f, -5.05387336e-02f, 6.11478239e-02f, -3.22363749e-02f, 7.16549158e-02f, -2.54371036e-02f, 5.68268597e-02f, -1.54959746e-02f, 1.04903117e-01f,
  -9.87217762e-04f, 5.38080819e-02f, -1.00320391e-01f, -1.68878157e-02f, -8.92940909e-03f, -6.06097504e-02f, 1.91452913e-02f, 4.73197028e-02f, -1.04470134e-01f, 1.79315940e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.16674232e-01f, -4.75198120e-01f, 4.07525867e-01f, -4.97165143e-01f, -4.05917138e-01f, -1.56308010e-01f, -5.17611742e-01f, -1.01824790e-01f, -1.28255457e-01f, -4.34227437e-01f,
  -3.35042059e-01f, -1.90943733e-01f, -2.43691746e-02f, 1.10574894e-01f, 3.43383461e-01f, -2.52244502e-01f, 2.57551789e-01f, 5.06879687e-01f, 4.49386656e-01f, -2.63631970e-01f,
  -3.56390148e-01f, -2.25806549e-01f, 3.21540803e-01f, 1.55472606e-01f, -4.78293717e-01f, -9.90341306e-02f, 1.52240545e-01f, -1.60020012e-02f, -1.72660816e-02f, -3.02086055e-01f,
  -1.93192571e-01f, -6.12209029e-02f, 1.39567360e-01f, -2.61749662e-02f, -2.23520607e-01f, -8.07228461e-02f, -5.76365255e-02f, -2.93513935e-04f, 7.46612018e-03f, 4.10857722e-02f,
  -1.42164957e-02f, -5.82924969e-02f, -3.60961491e-03f, -4.63315621e-02f, -1.11181572e-01f, -6.37097284e-02f, 2.08531395e-01f, 2.03131050e-01f, 1.34102747e-01f, -8.20434839e-02f,
  -2.71876663e-01f, -2.31965140e-01f, 1.42096400e-01f, 1.25362039e-01f, 6.53427839e-02f, 7.66414329e-02f, 3.31155732e-02f, 1.76121797e-02f, 3.67282420e-01f, -2.12529391e-01f,
  -7.30339512e-02f, -2.52650958e-02f, -4.95508872e-02f, 1.04768969e-01f, 1.00646978e-02f, 7.64383599e-02f, 3.30533385e-02f, -6.22149669e-02f, 8.62256959e-02f, -2.90808603e-02f,
  6.38833046e-02f, -5.17011173e-02f, 2.26591602e-02f, -4.39386554e-02f, 1.29290313e-01f, -4.89194021e-02f, -8.15281644e-02f, 3.57791968e-02f, 3.25168446e-02f, 3.44462506e-02f,
  1.18824216e-02f, -4.14236933e-02f, 1.77017376e-02f, -1.45432847e-02f, 9.12521258e-02f, 1.12980232e-01f, -5.44741675e-02f, 8.39024037e-03f, -1.50959551e-01f, 2.20758840e-02f,
  -2.21074179e-01f, 4.63789135e-01f, -3.06528449e-01f, 8.94037187e-02f, -8.78520161e-02f, 1.41130269e-01f, -3.98569256e-02f, 6.88773245e-02f, -7.76947290e-02f, -7.90122598e-02f,
  8.74383450e-02f, -2.07011342e-01f, 1.64848324e-02f, 3.95499244e-02f, -8.93467441e-02f, -9.82399844e-03f, -2.90754661e-02f, -1.55794799e-01f, 8.60906318e-02f, -9.08655077e-02f,
  8.21938664e-02f, -1.12986371e-01f, -2.21320972e-01f, -1.61819816e-01f, -1.14016250e-01f, -2.51623001e-02f, -5.69959618e-02f, -3.77163254e-02f, 5.68686128e-02f, -5.25939167e-01f,
  2.58193947e-02f, 6.28347322e-02f, 1.52120277e-01f, -5.68380877e-02f, -8.38878006e-02f, -2.17469111e-02f, -1.33632913e-01f, -7.88828060e-02f, -9.24049616e-02f, 1.26942754e-01f,
  3.10433120e-01f, 2.94713199e-01f, 3.02848816e-01f, 2.82482237e-01f, 1.97624773e-01f, 2.23802170e-03f, -1.09777413e-01f, 1.45410225e-01f, 1.52364105e-01f, 7.86779895e-02f,
  -8.15099329e-02f, -1.44709036e-01f, -5.05437106e-02f, -1.17877543e-01f, 4.02848795e-03f, 2.48827249e-01f, 1.29515588e-01f, 1.06335590e-02f, 1.46106958e-01f, 8.78373012e-02f,
  3.63888592e-01f, -7.41951242e-02f, 1.60590112e-01f, -1.10929184e-01f, 2.21029203e-02f, -1.04277335e-01f, 1.35483639e-02f, -1.18999630e-01f, -2.22446948e-01f, -1.41614094e-01f,
  -1.98310450e-01f, -1.04045004e-01f, 1.09861642e-02f, -1.42575294e-01f, -1.91480502e-01f, -1.01250693e-01f, -1.26215622e-01f, -3.17965336e-02f, -3.93566228e-02f, -7.09254621e-03f,
  2.08608601e-02f, -7.92110413e-02f, -8.67179185e-02f, 3.41912098e-02f, 6.82911202e-02f, 4.15416323e-02f, 5.21344990e-02f, 2.10373616e-03f, 3.10822437e-03f, 1.14225067e-01f,
  1.73523709e-01f, 1.99643336e-02f, 1.73528746e-01f, 1.81069300e-01f, 1.17015779e-01f, 1.76728312e-02f, 2.40315851e-02f, -6.77793100e-02f, 8.14403743e-02f, -7.72399548e-03f,
  1.11281008e-01f, 9.54984203e-02f, 1.43903255e-01f, 7.96966702e-02f, 4.82413396e-02f, -1.18869409e-01f, -7.93520361e-02f, 4.10839543e-02f, -8.62048939e-02f, -6.52357191e-02f,
  -3.84843759e-02f, -1.63727924e-01f, -6.46703541e-02f, -1.45691589e-01f, -4.58060578e-02f, -5.11671929e-03f, -1.86760709e-01f, -3.30911726e-02f, -9.40157697e-02f, -1.78370133e-01f,
  2.13875443e-01f, 2.22228944e-01f, 7.67777860e-02f, -9.18868333e-02f, -9.06302407e-02f, -7.09390491e-02f, 2.39477396e-01f, -7.20620975e-02f, -2.27886066e-01f, 6.21341355e-03f,
  -1.00544117e-01f, 2.87381783e-02f, -1.05679058e-01f, -2.28605364e-02f, 9.89668444e-02f, -2.20932681e-02f, -5.16685359e-02f, 1.48984134e-01f, -1.23670548e-01f, -3.93385328e-02f,
  -1.86600938e-01f, -1.08308997e-03f, 2.08048165e-01f, 1.36322945e-01f, 8.10592026e-02f, 1.99034557e-01f, 2.82552898e-01f, 5.21321781e-02f, 1.53011650e-01f, 1.04414642e-01f,
  -7.58159608e-02f, 2.01186091e-02f, -5.21766543e-01f, 2.27126732e-01f, -2.47670291e-03f, -1.45046949e-01f, 5.20041808e-02f, 2.02365100e-01f, 1.48190573e-01f, 1.51304882e-02f,
  1.06281310e-01f, 3.43067586e-01f, 1.05727918e-01f, 2.29100008e-02f, -3.80223244e-02f, -2.30771333e-01f, -2.74969697e-01f, -2.33018860e-01f, -2.83988994e-02f, 5.11738993e-02f,
  3.96601148e-02f, -7.57711902e-02f, -7.50542730e-02f, -8.28055590e-02f, 6.76000584e-03f, -5.68373315e-02f, -2.65528023e-01f, -1.03676550e-01f, -4.37482595e-01f, -3.56998503e-01f,
  -2.15590551e-01f, -5.40552586e-02f, 2.26284899e-02f, -6.73300698e-02f, 5.29610552e-02f, 8.89536664e-02f, 6.52119219e-02f, 3.46798673e-02f, 1.61477670e-01f, 9.10309702e-02f,
  -4.10195515e-02f, 4.79431003e-02f, -1.85698811e-02f, 1.52384847e-01f, 6.00017933e-03f, 6.66860193e-02f, 1.01131119e-01f, 7.10081533e-02f, -1.21333882e-01f, 2.32781861e-02f,
  1.26306787e-01f, -1.06775180e-01f, -3.54087539e-02f, 4.48069684e-02f, -1.03983767e-01f, -5.03905788e-02f, 2.83458438e-02f, -7.52889141e-02f, -2.23714262e-01f, -7.15161860e-02f,
  2.39097625e-01f, -1.04195401e-02f, -1.56911984e-01f, -5.78835569e-02f, -3.97969224e-02f, -4.02515475e-03f, -1.05709761e-01f, -1.35947391e-01f, -1.22544803e-01f, 9.13278088e-02f,
  1.15925804e-01f, -1.79306995e-02f, -5.08633517e-02f, 1.24594614e-01f, -1.37154609e-01f, -2.72560176e-02f, -1.47984937e-01f, -1.13310054e-01f, -1.02865398e-01f, -3.34968045e-02f,
  -1.66093737e-01f, -1.05237309e-02f, -1.20407157e-01f, -1.54106170e-01f, -1.44445375e-01f, -1.07598864e-01f, 8.01261216e-02f, -3.16873640e-02f, 1.68514177e-01f, 4.31918614e-02f,
  2.77208596e-01f, -3.19775313e-01f, 3.13577168e-02f, -9.18077976e-02f, -2.15102494e-01f, 2.97011109e-03f, -1.14546359e-01f, -2.19873279e-01f, -1.26812264e-01f, -8.32388550e-02f,
  -2.25256220e-01f, 2.07817126e-02f, 1.12808652e-01f, 7.89155290e-02f, 1.62900925e-01f, -4.52733003e-02f, 9.42863896e-03f, -3.13152149e-02f, -2.35614270e-01f, 7.70958513e-02f,
  6.63362630e-03f, -1.30359501e-01f, 7.95670748e-02f, 6.47612959e-02f, -4.11373787e-02f, -3.55879329e-02f, 5.40787503e-02f, -8.85654613e-02f, -2.36280531e-01f, 1.97232068e-01f,
  -8.66118222e-02f, -2.03918383e-01f, 2.71157861e-01f, 1.30741507e-01f, -3.88871655e-02f, -1.53280459e-02f, 6.30656630e-02f, -5.78432307e-02f, -4.59769517e-02f, 3.10964193e-02f,
  -1.10353500e-01f, 2.18163691e-02f, 1.94625873e-02f, 9.82219875e-02f, 1.07379034e-01f, 9.38642770e-02f, 4.02064547e-02f, 5.70443682e-02f, 2.87918836e-01f, 1.84845716e-01f,
  4.49909037e-03f, 2.64393777e-01f, 2.19660833e-01f, -1.69289149e-02f, -8.35380331e-02f, 1.39431939e-01f, 8.74406099e-02f, -9.09418520e-03f, -1.99635640e-01f, -1.68509886e-01f,
  2.14881167e-01f, -4.36537445e-01f, 1.44918308e-01f, -2.13171840e-01f, -9.93627235e-02f, -1.44568803e-02f, 4.83301058e-02f, 1.76572893e-02f, -1.58370614e-01f, 6.95396364e-02f,
  -5.49289398e-02f, -1.48961082e-01f, -1.46122187e-01f, 3.03578172e-02f, 8.03821832e-02f, 1.26642250e-02f, -1.69075534e-01f, -8.11213106e-02f, -1.15009487e-01f, -9.88084748e-02f,
  -2.11163253e-01f, -2.36875385e-01f, -7.92427734e-02f, -3.94761264e-02f, -1.74690917e-01f, -9.12297219e-02f, -9.59421992e-02f, -1.99357465e-01f, -1.99118093e-01f, 4.55026366e-02f,
  -3.39062475e-02f, 1.26244143e-01f, -1.52538503e-02f, -7.07525834e-02f, -2.26387717e-02f, -3.43530029e-02f, -3.28561813e-02f, 1.42003391e-02f, 1.14256203e-01f, 1.42580047e-01f,
  -2.00214818e-01f, 1.22534551e-01f, 1.68286785e-01f, -1.02630250e-01f, 1.97910845e-01f, 1.43693732e-02f, 2.35968214e-02f, 3.60915922e-02f, 3.06650735e-02f, 1.27398953e-01f,
  6.45305067e-02f, 2.99773589e-02f, 2.08062366e-01f, 1.74885973e-01f, 5.29765263e-02f, -7.77840894e-03f, 1.93392877e-02f, 9.85724777e-02f, -6.76949099e-02f, -9.69260857e-02f,
  2.13950917e-01f, -1.02443144e-01f, 1.01521894e-01f, -5.75293116e-02f, -1.19562812e-01f, -6.19688183e-02f, -3.47932279e-02f, -4.20079380e-03f, -1.03609726e-01f, -1.20333228e-02f,
  -5.57030663e-02f, -1.83786340e-02f, 1.18054217e-02f, 6.97696805e-02f, 1.53759420e-01f, 3.01476638e-03f, -1.63261950e-01f, -6.82914779e-02f, 6.42038584e-02f, -3.63671444e-02f,
  -1.46811157e-02f, 6.14531226e-02f, 1.41904548e-01f, 8.90771523e-02f, -3.77702005e-02f, 1.57732219e-01f, 1.57896727e-01f, 1.98763952e-01f, -3.81505117e-04f, 2.84846216e-01f,
  -2.89949805e-01f, -3.65184963e-01f, 2.41374716e-01f, 2.27104453e-03f, 1.59368962e-01f, 3.12324882e-01f, 1.62520543e-01f, -3.40834148e-02f, -1.38913398e-04f, -1.04092792e-01f,
  -1.50619954e-01f, -1.24743715e-01f, -7.88928717e-02f, -4.24399115e-02f, -2.85586622e-02f, 1.68430328e-01f, 1.22607604e-01f, 1.79010168e-01f, 3.78372431e-01f, 2.47112975e-01f,
  9.15067941e-02f, 5.39936386e-02f, -1.45309433e-01f, -3.07433382e-02f, -4.32242453e-02f, 5.38106188e-02f, -9.21921432e-02f, -7.36280605e-02f, -3.69438082e-02f, -1.62219286e-01f,
  3.56705397e-01f, -7.23257363e-02f, 1.46759212e-01f, -1.73517689e-02f, -3.69739346e-02f, 3.01288683e-02f, 8.20760950e-02f, -1.14688359e-01f, 1.15145985e-02f, 3.84854302e-02f,
  2.99061704e-02f, -1.49799466e-01f, -5.71019948e-02f, -1.31878242e-01f, -1.34959314e-02f, -1.04322098e-02f, -8.38855878e-02f, -7.63429925e-02f, -5.32401353e-02f, -6.09059557e-02f,
  -1.63278639e-01f, 2.07964517e-02f, 6.81247860e-02f, 4.74247485e-02f, 5.44703528e-02f, 4.50071990e-02f, -5.14701568e-02f, -6.86341431e-03f, -7.94775877e-03f, -1.02498733e-01f,
  -1.67732835e-02f, 2.19523236e-02f, 1.07701316e-01f, -7.75033310e-02f, -8.14305618e-02f, 5.78758791e-02f, 9.57449228e-02f, 1.84197128e-01f, 9.03987363e-02f, -5.43293245e-02f,
  -1.25760227e-01f, 2.52730735e-02f, -7.00738952e-02f, 1.25947163e-01f, 3.27510908e-02f, 1.74624659e-02f, 3.81868556e-02f, 6.29389212e-02f, -1.89792261e-01f, -1.89263925e-01f,
  -6.95537105e-02f, 4.50527947e-03f, 1.19123850e-02f, -7.44436756e-02f, -1.43588096e-01f, -5.91843463e-02f, 2.48103514e-02f, -6.43403754e-02f, -6.78859130e-02f, 1.60545278e-02f,
  1.31520450e-01f, -5.87299913e-02f, 1.11710057e-01f, -3.30981575e-02f, 1.92263648e-02f, -1.99123789e-02f, -3.81109677e-02f, 4.35119271e-02f, 5.04007414e-02f, 1.81997389e-01f,
  8.96874741e-02f, 1.55106736e-02f, -2.93348022e-02f, 2.89782956e-02f, 1.12747177e-01f, 9.91330370e-02f, -1.10384852e-01f, -1.97070558e-02f, -2.86400337e-02f, -1.13017606e-02f,
  -3.61133777e-02f, 1.26980111e-01f, 1.79556012e-01f, 1.34116367e-01f, 1.69955716e-01f, 1.26912341e-01f, 2.05937237e-01f, 1.55288979e-01f, 7.42991865e-02f, 1.53199539e-01f,
  8.92876387e-01f, -1.05885267e-01f, 2.49914482e-01f, 2.35093772e-01f, 1.65204257e-01f, 2.11656600e-01f, 1.79938331e-01f, 6.17146119e-02f, 3.60630825e-02f, 1.61411524e-01f,
  9.51259211e-02f, 1.97736561e-01f, 2.81468891e-02f, 3.75501625e-02f, 4.47073393e-02f, -1.18526101e-01f, -6.41086996e-02f, 2.02853248e-01f, 2.57102191e-01f, 7.03369007e-02f,
  -7.57093802e-02f, -1.27612665e-01f, 1.21968023e-01f, -8.36851597e-02f, -1.17536180e-01f, -6.67628944e-02f, -9.50031057e-02f, -9.12699997e-02f, -1.35901883e-01f, -3.22970927e-01f,
  -5.24664856e-02f, 1.68306664e-01f, 1.06550902e-01f, -1.67127162e-01f, -3.52212577e-03f, 4.56946045e-02f, 9.69115570e-02f, -3.24850269e-02f, -1.40927821e-01f, -1.18712850e-01f,
  -1.18223190e-01f, -7.61356652e-02f, 7.22482204e-02f, 5.54298908e-02f, -4.35601771e-02f, 3.75809930e-02f, -2.59232428e-02f, -2.53146458e-02f, -1.11158714e-01f, 2.93970443e-02f,
  -5.51537015e-02f, -3.75999487e-03f, 3.01099028e-02f, -7.11515453e-03f, 7.41860867e-02f, -1.43587710e-02f, 3.62688489e-02f, -1.17045932e-01f, 8.26721936e-02f, -7.81787634e-02f,
  2.05008518e-02f, 2.21269228e-03f, 3.59540731e-02f, 1.26720339e-01f, 2.74974167e-01f, 1.36289299e-01f, 2.04474144e-02f, -7.22334534e-02f, 1.26726136e-01f, 1.71287566e-01f,
  1.01426300e-02f, 1.16671234e-01f, 1.01178095e-01f, -1.43050449e-02f, 1.18604220e-01f, -2.02358095e-03f, 1.29411137e-02f, 3.04863658e-02f, 5.43792471e-02f, 2.63238847e-02f,
  1.73269182e-01f, 4.85549755e-02f, 3.75412242e-03f, 2.56035551e-02f, -1.38099387e-01f, 7.70972222e-02f, -5.13351373e-02f, -9.24541205e-02f, 3.70085426e-02f, -2.95036510e-02f,
  -2.88732350e-01f, 1.69001371e-01f, 1.04529418e-01f, -7.71487802e-02f, -1.23810530e-01f, -4.02276218e-02f, 1.23029903e-01f, -1.49161890e-01f, -1.73675194e-01f, -2.42041592e-02f,
  2.52788328e-02f, 1.63803028e-03f, 7.35968873e-02f, -6.72480017e-02f, 1.16036713e-01f, 1.18556552e-01f, -9.14739594e-02f, 7.93366954e-02f, -4.42345254e-02f, -1.72996894e-01f,
  -8.34254622e-02f, 1.55220613e-01f, 1.99943691e-01f, 1.73580810e-01f, 8.08781758e-02f, 2.13415563e-01f, 1.00753054e-01f, -2.90107937e-03f, 6.29577190e-02f, 5.02499454e-02f,
  -4.39385772e-01f, -3.35757703e-01f, -1.31168105e-02f, 3.20181876e-01f, 2.60217220e-01f, 2.19687834e-01f, 1.69051260e-01f, 2.25429565e-01f, 1.58852756e-01f, -7.69942859e-03f,
  -4.47284356e-02f, 1.55996665e-01f, 2.48115677e-02f, 4.03316505e-02f, 9.69933793e-02f, 3.61926645e-01f, 4.60056007e-01f, 1.03093021e-01f, 1.34380907e-01f, 1.84002548e-01f,
  1.33095503e-01f, 2.14621410e-01f, -6.04149327e-02f, 2.35391378e-01f, 1.75965488e-01f, 1.71962038e-01f, 2.10831419e-01f, 1.64282277e-01f, 9.88177285e-02f, 2.16694936e-01f,
  -1.02783129e-01f, -1.23130389e-01f, 1.35771513e-01f, -4.88932170e-02f, -1.29049286e-01f, -2.82195449e-01f, -3.07492316e-02f, -5.19165024e-02f, -1.63815916e-01f, 3.11156642e-02f,
  -2.73909811e-02f, -6.18746169e-02f, -1.03416555e-02f, -5.46003468e-02f, -5.20251915e-02f, -1.28322959e-01f, -9.80784670e-02f, 2.26874407e-02f, 4.79611494e-02f, -1.29612759e-01f,
  2.79489998e-02f, -6.93416074e-02f, -4.97820554e-04f, 8.47378075e-02f, -3.96165587e-02f, 8.09350982e-02f, -1.21625647e-01f, -1.72176007e-02f, 1.19360415e-02f, -9.44648832e-02f,
  7.64320642e-02f, 6.93445653e-02f, 6.37016594e-02f, -3.83430626e-04f, 4.33340259e-02f, -5.67514524e-02f, 1.20719247e-01f, -3.21600810e-02f, 1.42194554e-01f, -1.19459003e-01f,
  1.44648328e-01f, 1.87959880e-01f, 3.75332832e-02f, 9.60036367e-03f, 1.23046964e-01f, -3.85933183e-02f, -1.16683580e-01f, -8.97005871e-02f, 1.01609647e-01f, 2.14772001e-02f,
  2.05845356e-01f, 1.36986151e-01f, -8.79513286e-03f, 1.34951938e-02f, -2.60561481e-02f, 4.47205044e-02f, 2.97590680e-02f, 1.59406755e-02f, -2.19857041e-03f, 7.98496604e-02f,
  3.38010073e-01f, 1.20720886e-01f, 2.46139392e-01f, 9.39592049e-02f, -1.52228051e-03f, -1.86601594e-01f, -2.64335182e-02f, -1.11657821e-01f, 9.62219853e-03f, -4.68325010e-03f,
  -1.36487529e-01f, -2.01032639e-01f, -6.60112426e-02f, 2.93364725e-03f, -6.24288693e-02f, -1.69421826e-02f, -1.10691100e-01f, 2.84180660e-02f, 7.95526206e-02f, -3.11357081e-02f,
  3.79266702e-02f, 1.34909868e-01f, 1.09673791e-01f, 1.31970569e-02f, 9.98474956e-02f, 9.01747346e-02f, -7.93432891e-02f, 2.36828253e-02f, -1.36481961e-02f, -8.22900087e-02f,
  4.42716509e-01f, 4.06994641e-01f, 2.46583685e-01f, -9.74195525e-02f, 1.85214624e-01f, 3.00117016e-01f, 5.41210294e-01f, 1.59560442e-01f, -1.36867106e-01f, 1.43832475e-01f,
  3.18755686e-01f, -1.07629277e-01f, -7.34067559e-02f, 5.01448177e-02f, 1.97703362e-01f, 6.07843772e-02f, -1.57381415e-01f, -1.06743336e-01f, 3.94889601e-02f, 6.07598294e-03f,
  -1.40730739e-01f, 4.83769774e-02f, 1.54080048e-01f, -1.02521054e-01f, -1.92832947e-01f, -2.78594941e-01f, 7.47377425e-02f, 1.17729478e-01f, 8.54215175e-02f, -2.99877882e-01f,
  2.11004689e-01f, 3.63631010e-01f, -2.77982235e-01f, -1.46465302e-01f, 6.47829399e-02f, -6.43952936e-02f, -3.66485789e-02f, -5.44254072e-02f, 9.40794498e-03f, -1.00325614e-01f,
  5.75265475e-02f, 8.08095187e-03f, 1.08095169e-01f, 7.10214749e-02f, 1.12091735e-01f, -5.27871354e-03f, 3.65886725e-02f, -9.98761225e-03f, 1.57827392e-01f, 2.74277646e-02f,
  -1.09380558e-01f, 1.21775828e-01f, 1.98780164e-01f, 9.17830039e-03f, 1.40939146e-01f, 3.68521661e-02f, 1.47991031e-01f, -1.49861369e-02f, 1.25299335e-01f, -1.68897480e-01f,
  2.26383824e-02f, 3.42346914e-02f, 1.51490644e-01f, -1.72464515e-03f, 5.99292181e-02f, -2.88752443e-03f, -6.40733093e-02f, 7.53044561e-02f, -4.27096188e-02f, 1.52877821e-02f,
  6.12692758e-02f, 3.00238673e-02f, 6.64727716e-03f, 2.81213038e-02f, -1.25546142e-01f, 1.14759475e-01f, -2.06994768e-02f, 5.67493849e-02f, 1.42677575e-01f, 1.89724583e-02f,
  6.50953203e-02f, 5.44756390e-02f, 3.62655483e-02f, 9.19623151e-02f, -3.43285240e-02f, -5.13617881e-02f, -7.47025609e-02f, 1.20421402e-01f, 7.33871534e-02f, 2.52438486e-02f,
  -1.10488385e-01f, 2.78634787e-01f, -2.54564673e-01f, -2.18917727e-01f, 8.12831223e-02f, -7.27405250e-02f, -2.23462768e-02f, -4.82297093e-02f, -8.31224173e-02f, -1.35600001e-01f,
  1.12171419e-01f, -2.35138331e-02f, 1.16800360e-01f, 5.60360625e-02f, -1.21908784e-01f, -1.31522924e-01f, 3.34885903e-02f, -1.05803855e-01f, -8.71806517e-02f, -9.68381390e-02f,
  -1.07455380e-01f, -6.96221069e-02f, -4.35629413e-02f, -1.45575136e-01f, -9.92045179e-02f, -2.75171608e-01f, -1.14198372e-01f, -1.00020915e-01f, 8.81509557e-02f, -1.09872341e-01f,
  5.77681065e-01f, 3.20989817e-01f, 3.12972330e-02f, 2.66194731e-01f, 2.81844530e-02f, -1.09591931e-01f, -1.93986133e-01f, -1.87277675e-01f, 3.60140838e-02f, 1.95132554e-01f,
  2.11106509e-01f, 1.91369638e-01f, 1.16200574e-01f, 7.04558417e-02f, 1.11971535e-01f, -8.35373104e-02f, 2.94441357e-02f, 1.43379346e-01f, -1.64711103e-02f, -2.34985761e-02f,
  2.66034957e-02f, 2.01098859e-01f, 2.23158658e-01f, 5.79125658e-02f, 2.50597030e-01f, 1.97511271e-01f, 5.40821366e-02f, 2.04360545e-01f, 1.03912383e-01f, 2.83813268e-01f,
  4.00459111e-01f, 2.38119587e-01f, -1.32788479e-01f, 1.75536081e-01f, 1.13191783e-01f, 1.01690583e-01f, 1.07849501e-01f, -1.39542088e-01f, -8.86345729e-02f, -5.33203781e-02f,
  6.01862110e-02f, -1.01422463e-02f, 1.71641586e-03f, -1.16020352e-01f, -6.10628091e-02f, -7.63418013e-03f, -3.54431011e-02f, -4.87960763e-02f, 1.13059711e-02f, 3.42975147e-02f,
  1.15275234e-01f, -1.11791082e-01f, -9.87600833e-02f, -1.91195831e-01f, 2.37332261e-03f, -1.07224844e-01f, -8.75016823e-02f, -2.50982735e-02f, -1.16553187e-01f, -4.19823490e-02f,
  -9.54669155e-03f, 2.28523631e-02f, 6.07725931e-03f, -1.69529498e-01f, -1.14787668e-01f, -9.24320072e-02f, -2.43663285e-02f, -7.09222406e-02f, -8.82809013e-02f, -1.88196838e-01f,
  -1.35684326e-01f, 4.48175222e-02f, -1.08945593e-01f, -4.41873074e-02f, 1.56506389e-01f, 1.98529437e-02f, 6.70137629e-02f, 5.70819527e-02f, -8.78334232e-03f, -5.95411099e-03f,
  1.07033160e-02f, -3.93757150e-02f, -2.88454574e-02f, -8.25717375e-02f, 7.50102103e-02f, -6.65176362e-02f, -1.48884133e-02f, 2.20958367e-02f, -1.00208573e-01f, -2.25478970e-02f,
  -9.64609236e-02f, 1.14934169e-01f, 1.84780657e-01f, 2.61608273e-01f, 1.98783681e-01f, 9.11228135e-02f, 2.90181994e-01f, 9.81953815e-02f, 1.06024735e-01f, 1.29702557e-02f,
  5.00551276e-02f, 1.31837100e-01f, 2.17966139e-02f, -1.06966965e-01f, -1.61340818e-01f, -1.24008060e-01f, 1.52303446e-02f, 7.85613209e-02f, 2.43170820e-02f, 3.53009328e-02f,
  -2.67241858e-02f, -1.24056093e-01f, -2.56214857e-01f, -2.25737393e-01f, -6.95016682e-02f, -1.02141751e-02f, -1.64241880e-01f, -1.14210755e-01f, -4.61158119e-02f, -2.66328067e-01f,
  5.20965159e-02f, 1.72992006e-01f, -4.58219163e-02f, 2.15527385e-01f, -9.94690955e-02f, -2.79569149e-01f, -4.65561897e-02f, -6.56636655e-02f, 1.05706833e-01f, 1.77903414e-01f,
  -3.74506740e-03f, -3.22798938e-01f, 9.30322520e-03f, -1.45663381e-01f, -2.37345397e-01f, 3.48277166e-02f, 1.33410811e-01f, -3.05262387e-01f, -5.87581098e-01f, -5.01849830e-01f,
  -2.64066637e-01f, 5.96261397e-02f, -1.64149776e-01f, -1.01399891e-01f, 2.09630042e-01f, -4.37501073e-02f, 2.64023364e-01f, 5.34231821e-03f, -2.69040674e-01f, 1.53766304e-01f,
  1.50347754e-01f, -4.80004586e-02f, -3.18452895e-01f, -1.78276867e-01f, 3.09239030e-02f, -2.00085923e-01f, -2.41254464e-01f, -1.20292725e-02f, -1.64208114e-02f, 5.83324544e-02f,
  -2.22352341e-01f, -1.59037843e-01f, -2.82910112e-02f, -7.38192946e-02f, -1.38243422e-01f, -1.80411190e-01f, 3.69460024e-02f, -2.38364920e-01f, 4.19489853e-03f, -5.80673665e-02f,
  -1.33053139e-01f, -1.40584052e-01f, -1.42352968e-01f, -3.30348387e-02f, -8.55582431e-02f, -1.65729150e-01f, -1.75491516e-02f, -2.80816406e-01f, -1.10796422e-01f, 3.20575476e-01f,
  3.73315578e-03f, -6.82204068e-02f, 3.07239909e-02f, 1.03821881e-01f, 4.23318632e-02f, 9.03158933e-02f, 1.27530813e-01f, 6.73378035e-02f, -1.36972107e-02f, 3.30901518e-02f,
  3.03967902e-03f, 8.46504569e-02f, -4.79670241e-02f, 9.30998996e-02f, 3.55341472e-02f, -9.31880027e-02f, 1.10965502e-03f, 1.32228106e-01f, -9.12554935e-02f, -2.83214706e-03f,
  -1.86257333e-01f, -1.66252684e-02f, 4.76312153e-02f, -6.38532937e-02f, 2.87344921e-02f, -1.15099680e-02f, -6.25071004e-02f, -9.49577466e-02f, -3.23671964e-03f, -8.29064324e-02f,
  2.16618866e-01f, -3.01432699e-01f, 2.47035921e-01f, -1.07708476e-01f, 2.52212714e-02f, 1.46848671e-02f, 1.31627023e-01f, -2.80850008e-02f, 1.29907712e-01f, -4.44277152e-02f,
  -2.27438539e-01f, 6.51535690e-02f, 1.13120116e-01f, -6.27896488e-02f, -6.52399287e-02f, -1.54371839e-02f, -1.20755844e-02f, 3.93564999e-03f, -1.25331953e-01f, -1.85122117e-02f,
  1.83598533e-01f, 3.41201946e-02f, 9.10886005e-02f, 1.14776745e-01f, 3.31191123e-02f, -5.83107322e-02f, 1.67507157e-01f, 6.21402729e-03f, -8.79804417e-02f, 5.37123322e-01f,
  -8.35320055e-01f, 2.77684480e-01f, -3.73545624e-02f, -5.88680543e-02f, -1.29041687e-01f, -1.65212482e-01f, -1.11700132e-01f, -2.21532032e-01f, -1.62109345e-01f, 1.41918808e-01f,
  6.57568797e-02f, 6.80182427e-02f, 4.67398651e-02f, 1.07997598e-03f, -1.73377424e-01f, 2.76362128e-03f, -6.80643544e-02f, -3.69250178e-01f, -2.81659395e-01f, -1.07802913e-01f,
  -4.63915803e-03f, -2.41537392e-01f, -3.15906614e-01f, -1.97214007e-01f, 2.22452030e-01f, 7.55527020e-02f, 1.51931316e-01f, 7.38231763e-02f, 1.27801627e-01f, 2.52949744e-01f,
  6.53560638e-01f, -1.21034101e-01f, -1.20172724e-02f, -1.07819013e-01f, 7.03202263e-02f, -8.82090032e-02f, -7.77389621e-03f, 7.64573514e-02f, -1.88195501e-02f, 1.89673260e-01f,
  3.59697267e-02f, -1.10668227e-01f, -1.38535634e-01f, -4.09186445e-02f, 3.34932730e-02f, 8.32292140e-02f, 9.36252475e-02f, -1.95138920e-02f, 7.25883022e-02f, 2.53637522e-01f,
  6.99839368e-02f, -3.70253213e-02f, 1.38495862e-01f, 1.06495723e-01f, 2.82308590e-02f, -9.02521461e-02f, 1.94348276e-01f, 1.48398383e-02f, -6.99346438e-02f, 5.65713011e-02f,
  -1.19834304e-01f, 1.03105545e-01f, 8.73827040e-02f, 2.33984385e-02f, 7.08444193e-02f, -3.81787047e-02f, 5.04533537e-02f, 1.30095750e-01f, -2.32106503e-02f, -3.56767997e-02f,
  1.62473872e-01f, 1.21783912e-02f, -4.70901541e-02f, -3.29917669e-03f, 2.82134209e-03f, 3.75522226e-02f, -3.88872586e-02f, 1.52318880e-01f, 9.70401987e-02f, 2.58458722e-02f,
  1.54954363e-02f, 4.34441529e-02f, 3.68513688e-02f, 8.38936046e-02f, 9.16112438e-02f, 1.20093813e-02f, -2.30957232e-02f, 4.92743813e-02f, -1.26269072e-01f, -1.53863415e-01f,
  6.07442439e-01f, -2.77949303e-01f, -1.87588874e-02f, -1.28075302e-01f, -5.54441996e-02f, 6.99049532e-02f, 9.38834250e-02f, -3.44945751e-02f, 1.45325899e-01f, 1.52747646e-01f,
  -5.94114624e-02f, 2.58148964e-02f, 5.12367440e-03f, 1.03570946e-01f, -1.35292947e-01f, -5.22804037e-02f, 5.95654175e-02f, 7.38488957e-02f, 1.46721348e-01f, 3.31398875e-01f,
  3.60495001e-02f, 9.74040106e-02f, 1.17414229e-01f, 1.92101985e-01f, -9.51553211e-02f, 4.63239942e-03f, 1.72922567e-01f, 9.44737867e-02f, -3.44354510e-02f, 8.87043029e-02f,
  7.04918742e-01f, -2.46617451e-01f, 3.34274471e-02f, 2.05014452e-01f, 5.54831848e-02f, 1.59845144e-01f, -1.00241285e-02f, 8.28808993e-02f, 2.19599217e-01f, 6.38448261e-03f,
  1.84179232e-01f, 1.44935906e-01f, 2.15260372e-01f, 1.16158128e-01f, 6.30739555e-02f, -1.25912409e-02f, 7.42762536e-03f, 5.01957685e-02f, 1.48937166e-01f, 2.60576773e-02f,
  -9.64396447e-02f, -2.33693626e-02f, 7.83439577e-02f, -3.35805193e-02f, -3.02306592e-01f, -1.22644091e-02f, -1.18088350e-01f, -7.04482272e-02f, -1.78539142e-01f, -3.26782674e-01f,
  -2.58303374e-01f, 7.52652213e-02f, 9.55327507e-03f, 1.11576930e-01f, 3.04209571e-02f, 7.19896406e-02f, 8.64150375e-02f, -5.62923634e-03f, 9.35666785e-02f, 1.57776587e-02f,
  -3.37100402e-02f, 7.89739564e-03f, -1.36937108e-02f, -3.32185328e-02f, 6.16914267e-03f, 1.08294882e-01f, -3.21676247e-02f, 8.53684396e-02f, 1.13276914e-02f, -5.79781085e-02f,
  -5.36861196e-02f, 9.97285694e-02f, 9.77476165e-02f, 1.41841635e-01f, 9.20243636e-02f, 4.10591438e-02f, 8.97464305e-02f, 6.52578092e-05f, 9.42648202e-02f, 9.95147377e-02f,
  1.21597707e-01f, 1.14560127e-01f, 7.91709051e-02f, 8.22868198e-02f, 2.59149410e-02f, 5.27228303e-02f, -4.70621474e-02f, 1.32038891e-01f, 1.64713129e-01f, -4.64378372e-02f,
  -6.34479225e-02f, -3.94047014e-02f, 1.22505479e-01f, -2.11134441e-02f, -5.61649352e-02f, -1.34530842e-01f, 1.57005545e-02f, -1.04390465e-01f, -6.23004623e-02f, -1.05559118e-01f,
  1.62499286e-02f, -1.02551222e-01f, -8.19405243e-02f, -1.59181938e-01f, 7.12253014e-03f, 1.17766410e-02f, 1.18599003e-02f, -1.02981674e-02f, -7.83302635e-03f, -2.94429343e-02f,
  -1.61457807e-01f, 8.20720196e-02f, -9.96796787e-02f, -1.22826546e-01f, -8.53140354e-02f, -3.60736959e-02f, -2.69733965e-02f, -1.61104932e-01f, -1.47079453e-01f, -5.73191270e-02f,
  -2.77433954e-02f, -2.95987593e-05f, -1.17535882e-01f, -5.36700003e-02f, 1.45763522e-02f, 3.20566096e-03f, -3.12291756e-02f, 1.57631654e-02f, -4.75212336e-02f, -4.97989245e-02f,
  -1.05911113e-01f, 1.17672600e-01f, 1.58296749e-01f, 7.48325586e-02f, 1.15082145e-01f, 1.64369479e-01f, -2.67338157e-02f, -1.36932507e-01f, 7.57881626e-02f, 1.28733173e-01f,
  -5.87944210e-01f, 5.01048639e-02f, 1.42074794e-01f, -3.76610816e-01f, 4.01938781e-02f, 1.90650150e-01f, -2.72702635e-03f, 1.55508071e-01f, 9.91392955e-02f, 9.10788625e-02f,
  7.62431771e-02f, -1.10468514e-01f, -7.70965517e-02f, -6.52291253e-02f, -3.56361508e-01f, 1.48388534e-03f, -1.83318004e-01f, -3.64081949e-01f, -2.67563790e-01f, -2.58447319e-01f,
  -2.79612720e-01f, -3.85768861e-01f, -4.41206515e-01f, -2.40521729e-01f, 7.85577111e-03f, -1.66731879e-01f, 4.53582555e-02f, -1.27003670e-01f, -4.08042036e-02f, -1.21542156e-01f,
  1.87988311e-01f, 1.72363043e-01f, 7.78197050e-02f, -1.67004943e-01f, 3.96072976e-02f, -3.63817848e-02f, 1.13388710e-01f, 1.78260095e-02f, -9.58698466e-02f, 9.24739912e-02f,
  -1.24904662e-01f, -5.58093712e-02f, -1.94214299e-01f, -9.35600176e-02f, -3.98658104e-02f, 5.94724491e-02f, -6.76885620e-02f, -9.35224071e-02f, 6.70475606e-03f, 9.35573876e-02f,
  -2.08900034e-01f, -1.10140823e-01f, -6.79516941e-02f, 6.81503937e-02f, 1.46652266e-01f, -2.32397720e-01f, 1.42492846e-01f, 1.12769097e-01f, 2.29775608e-01f, 1.09092526e-01f,
  7.59680942e-02f, -4.63700630e-02f, -1.92408022e-02f, -1.08907618e-01f, 1.22458870e-02f, 5.67089617e-02f, -9.46375206e-02f, -6.20012321e-02f, 9.84000489e-02f, 5.89403370e-03f,
  1.67827487e-01f, 1.27070054e-01f, 9.41784158e-02f, 6.91837370e-02f, -3.19804288e-02f, -9.26975310e-02f, 1.44743338e-01f, -1.04438521e-01f, -1.67391941e-01f, 8.53458494e-02f,
  -2.89280480e-03f, 6.78556636e-02f, 5.21021262e-02f, 7.03108683e-02f, -8.80589783e-02f, -5.75667769e-02f, 1.29822820e-01f, 5.05836606e-02f, 5.11250943e-02f, 8.70743766e-02f,
  -5.75135462e-02f, -9.22275186e-02f, -1.01522692e-01f, -1.20905742e-01f, -4.11974378e-02f, 7.99577087e-02f, -9.60706268e-03f, 3.69256996e-02f, 1.39900774e-01f, -1.15260214e-01f,
  -5.85719384e-02f, -1.10118821e-01f, -7.74588948e-03f, -7.46491328e-02f, -1.32398367e-01f, -1.08805560e-01f, -3.36907655e-01f, -2.44865254e-01f, -9.83789191e-02f, -6.58735260e-02f,
  -1.08536124e-01f, -2.08063170e-01f, -3.75084698e-01f, -3.75061929e-02f, -2.36213729e-02f, -4.60983723e-01f, 7.44856242e-03f, 9.14393440e-02f, -7.71512613e-02f, -1.99183762e-01f,
  -5.05408227e-01f, 2.08135005e-02f, 3.62781942e-01f, -6.41497374e-02f, 3.19518685e-01f, -2.62726676e-02f, -3.49699438e-01f, -3.93337846e-01f, -1.39104337e-01f, 1.83312185e-02f,
  6.74306452e-02f, -1.11347154e-01f, 1.60310835e-01f, -4.94034514e-02f, -3.43035668e-01f, 3.90383303e-02f, 2.42324859e-01f, -3.94677036e-02f, -2.88762212e-01f, -3.30116034e-01f,
  -1.43875629e-01f, -9.00451317e-02f, -1.64102942e-01f, -5.01143262e-02f, -1.86575968e-02f, -7.57762715e-02f, 2.61049807e-01f, 9.86909643e-02f, 7.23047480e-02f, 9.09831971e-02f,
  1.86607778e-01f, -5.36017418e-02f, 2.08542183e-01f, 8.91620815e-02f, 3.55642498e-01f, -1.31239951e-01f, -1.44258425e-01f, 2.49119252e-01f, -5.93805797e-02f, 9.81623232e-02f,
  1.29318357e-01f, -1.25813559e-01f, -3.01685594e-02f, 4.12888378e-02f, -9.20552537e-02f, -3.15206468e-01f, 7.30245048e-03f, -1.18795358e-01f, -1.87483747e-02f, -2.52497237e-04f,
  2.08175881e-03f, -7.85952359e-02f, 9.13421139e-02f, -9.06915590e-02f, -1.90638024e-02f, -8.11694935e-03f, 1.11478393e-03f, -2.75660634e-01f, -7.36018568e-02f, -2.21297726e-01f,
  -8.33946019e-02f, 8.41405615e-02f, 8.64441246e-02f, -3.01491376e-03f, -3.17708254e-02f, 4.32012640e-02f, 7.47292265e-02f, -8.54166225e-02f, -5.93859842e-03f, -9.83225182e-02f,
  6.52273446e-02f, -5.37281334e-02f, 2.21568383e-02f, -2.57301405e-02f, -1.13603016e-02f, 3.60730174e-03f, -6.35796636e-02f, -3.35015878e-02f, 6.46225596e-03f, -2.37317681e-02f,
  -6.40351176e-02f, 8.46006200e-02f, 2.45162889e-01f, -6.72055641e-04f, -2.77577210e-02f, -7.24231899e-02f, -1.05204552e-01f, -1.80023879e-01f, -8.05360451e-02f, -1.19276606e-01f,
  -1.44494116e-01f, 1.86219946e-01f, -6.89003989e-02f, -6.23762468e-03f, 7.72749782e-02f, 1.54807225e-01f, 5.13327830e-02f, 7.21291602e-02f, 1.10352270e-01f, -1.35710806e-01f,
  -1.03060290e-01f, -8.73318017e-02f, -3.10538840e-02f, -5.67775518e-02f, -1.74977735e-01f, 9.46865082e-02f, -2.14097239e-02f, -4.72050421e-02f, -3.04771177e-02f, -3.58003937e-02f,
  -1.34522006e-01f, -3.84520322e-01f, -3.09815288e-01f, -2.59296566e-01f, -2.69752324e-01f, -3.28090578e-01f, -9.13365185e-02f, -2.37549469e-01f, -3.10468078e-01f, -5.53027213e-01f,
  -4.91615772e-01f, -4.05148059e-01f, 3.76151234e-01f, -3.86854678e-01f, 3.28497857e-01f, 4.31486428e-01f, 5.02595842e-01f, 1.12569313e-02f, -1.58334062e-01f, 2.63570319e-03f,
  -2.46019527e-01f, -3.91115695e-01f, -2.48867482e-01f, -1.98632389e-01f, -4.64153942e-03f, 3.67487609e-01f, 2.77535588e-01f, 8.57841969e-02f, 1.25570834e-01f, 2.00162649e-01f,
  3.02838348e-02f, -1.85031846e-01f, -3.94813240e-01f, -1.42520413e-01f, -1.50923669e-01f, -9.89687741e-02f, 1.46756211e-04f, -1.17072403e-01f, 7.90635347e-02f, -1.41137555e-01f,
  2.26445258e-01f, -2.31628999e-01f, 1.10735536e-01f, -2.78824389e-01f, -8.31647664e-02f, -6.20478652e-02f, -3.50020789e-02f, -1.90750077e-01f, -5.37046082e-02f, 2.15663835e-02f,
  -5.28207496e-02f, -1.25726238e-01f, 3.38235497e-02f, -3.64438705e-02f, -3.97800393e-02f, 4.62144613e-02f, -8.20093900e-02f, -1.60668418e-01f, -1.91165641e-01f, 7.69035667e-02f,
  -4.98426780e-02f, 5.98653518e-02f, 1.32396042e-01f, -5.21299476e-03f, -1.29392999e-03f, -4.35312800e-02f, -8.25489759e-02f, -8.97643641e-02f, -4.50375639e-02f, 8.94641876e-03f,
  1.96624368e-01f, 1.77801717e-02f, -1.08696811e-01f, 3.84621471e-02f, -2.36366205e-02f, 5.03542349e-02f, 5.88654354e-02f, -6.63707405e-02f, 3.40890437e-02f, -1.63442474e-02f,
  3.98267955e-02f, 3.24937887e-03f, -4.52621058e-02f, 2.10548379e-03f, -1.14824414e-01f, -4.29498255e-02f, 2.37940028e-02f, -9.29842740e-02f, 2.74176225e-02f, -8.43591765e-02f,
  -5.11120558e-02f, 4.38198075e-02f, -4.56874818e-02f, 4.10280935e-02f, 2.12387685e-02f, -1.43627925e-02f, -2.13860422e-02f, -4.90060672e-02f, -5.25813662e-02f, 1.74811669e-02f,
  -7.90784284e-02f, 5.81209511e-02f, 4.85688038e-02f, -9.17564631e-02f, -6.97843218e-03f, -1.60573110e-01f, -5.95658720e-02f, -3.12905535e-02f, 3.38585721e-03f, 5.78046553e-02f,
  -2.23735590e-02f, -1.18897185e-02f, 4.08871546e-02f, -9.57729965e-02f, 1.50114328e-01f, 1.22829512e-01f, -3.89362276e-02f, -3.88265140e-02f, -3.10270526e-02f, 3.59062441e-02f,
  -5.83691597e-02f, 9.74371359e-02f, 8.37495551e-02f, 1.29141912e-01f, 7.59868249e-02f, 2.07962573e-01f, 1.68062121e-01f, 1.15772203e-01f, 2.81530857e-01f, 1.89004138e-01f,
  -2.77794302e-01f, 1.84569672e-01f, 3.29191685e-02f, 2.87720829e-01f, 4.35681850e-01f, 3.60477567e-01f, 3.62814873e-01f, 2.84780055e-01f, 1.59371614e-01f, 1.23647571e-01f,
  1.31268919e-01f, 1.86219573e-01f, 1.75340056e-01f, 1.67985499e-01f, 6.87664226e-02f, 3.05294603e-01f, 3.63985419e-01f, 1.36217251e-01f, -3.12644504e-02f, 2.16682151e-01f,
  3.15566897e-01f, 1.41087085e-01f, -9.50585604e-02f, 1.49431705e-01f, 1.23837993e-01f, 1.63579568e-01f, 2.12301031e-01f, 9.52513218e-02f, 1.65037096e-01f, 1.29723594e-01f,
  -1.65882066e-01f, -1.30235165e-01f, 5.64252399e-02f, 2.14910693e-02f, -2.06847172e-02f, -2.09867030e-01f, -1.14555331e-02f, -2.85312682e-02f, -7.28766546e-02f, -4.71037440e-02f,
  -7.21308440e-02f, -9.14384946e-02f, 2.69163046e-02f, -5.02656039e-04f, -3.21415402e-02f, -1.15115859e-01f, -1.38019145e-01f, 1.01847872e-02f, 5.71620204e-02f, 9.05553810e-03f,
  1.33123621e-01f, 1.18767478e-01f, 1.53132752e-01f, 5.56259826e-02f, 1.21089131e-01f, 3.37032378e-02f, -1.34167681e-02f, -1.16387926e-01f, -7.54611716e-02f, -4.70776949e-03f,
  2.47905552e-01f, 8.97349343e-02f, -3.29491310e-02f, -8.68178606e-02f, -1.80850342e-01f, 3.37442011e-02f, 6.41715378e-02f, 7.06986412e-02f, 1.40226692e-01f, -2.45397538e-02f,
  5.60230343e-03f, 8.07733834e-02f, -3.23388726e-02f, -3.29917148e-02f, -1.05016828e-01f, 5.14217839e-02f, -9.28165857e-03f, -1.62865117e-01f, -1.12898052e-01f, -1.61154062e-01f,
  -1.05884120e-01f, 7.25494558e-03f, -5.48715442e-02f, 7.77028129e-02f, -1.14194886e-03f, 1.63570642e-01f, -4.69355844e-02f, 7.67287612e-03f, 6.26128316e-02f, 7.91920722e-02f,
  2.46452704e-01f, 4.26274650e-02f, -1.31818369e-01f, -6.38613775e-02f, -1.17214561e-01f, -1.68740645e-01f, -7.30367675e-02f, -3.73162888e-02f, 1.87744293e-02f, 2.01934148e-02f,
  -1.44103095e-01f, -1.05453096e-01f, -5.81947118e-02f, -7.70351067e-02f, -1.04818836e-01f, -5.62279187e-02f, -1.24542199e-01f, 7.50935823e-02f, 1.04377098e-01f, 4.51864265e-02f,
  5.46916504e-04f, 4.34920192e-03f, -6.78680986e-02f, 7.66464276e-03f, -8.28044489e-03f, 5.78604685e-03f, -1.99409127e-01f, 6.21038023e-04f, -5.56001663e-02f, -4.00678776e-02f,
  4.64465380e-01f, -2.07448944e-01f, -6.68639183e-01f, 4.47541848e-03f, -1.99473426e-01f, -1.16832003e-01f, -1.56696305e-01f, 1.95497766e-01f, 6.31391481e-02f, -2.15520635e-01f,
  -1.23022310e-02f, 2.45672211e-01f, -1.45463914e-01f, -1.06102780e-01f, -3.33219096e-02f, -3.74863505e-01f, -4.63784814e-01f, -1.34301260e-01f, 3.48162830e-01f, 2.85094559e-01f,
  1.44969463e-01f, 9.50933769e-02f, 1.80492178e-01f, 8.76371339e-02f, -1.83054283e-01f, 8.83091614e-02f, -3.25531572e-01f, -8.86369050e-02f, -2.18658566e-01f, -4.19833630e-01f,
  -4.37953532e-01f, -1.29278377e-02f, 1.88902617e-01f, 1.49971172e-01f, -6.10769577e-02f, 1.41345844e-01f, 7.91176856e-02f, 8.56930688e-02f, 1.32383645e-01f, -3.55198607e-02f,
  -1.71827599e-02f, 1.66825578e-03f, 9.60590877e-03f, 1.23861670e-01f, 8.88477564e-02f, 3.16127539e-02f, 6.18528090e-02f, 1.87895432e-01f, -7.35674873e-02f, -1.20619554e-02f,
  -7.70322084e-02f, 2.96750143e-02f, 4.38516252e-02f, 1.27330616e-01f, 4.47637029e-02f, -1.98489167e-02f, 6.73038289e-02f, 1.54670104e-01f, 7.03342408e-02f, 2.48962380e-02f,
  -1.24647439e-01f, 2.97059841e-03f, -3.03143729e-02f, 1.08284496e-01f, 1.31598219e-01f, 3.43993157e-02f, 9.79657769e-02f, 8.71712491e-02f, 6.24099299e-02f, 9.31217149e-02f,
  4.04810123e-02f, -8.74760896e-02f, 1.34007812e-01f, -3.96287888e-02f, -9.86126959e-02f, -9.21823382e-02f, 7.40360096e-02f, -5.22872172e-02f, -7.21629262e-02f, 9.67036188e-02f,
  1.34519503e-01f, -1.64784640e-02f, -1.51765376e-01f, -2.40076855e-02f, -1.14096783e-01f, -7.79157225e-03f, -9.27492678e-02f, -3.14863808e-02f, -1.30773321e-01f, -4.78088036e-02f,
  1.10098332e-01f, -1.15474731e-01f, 2.73630600e-02f, 6.49240986e-02f, -1.17670652e-02f, -1.39298692e-01f, -5.02365269e-02f, 1.31099531e-02f, 9.09329876e-02f, 1.09868541e-01f,
  -4.21520621e-02f, -5.65355495e-02f, -1.22647129e-01f, -2.37427466e-02f, 8.44518691e-02f, 1.15125468e-02f, 7.73298508e-03f, 5.84341064e-02f, -3.72457616e-02f, -1.51799634e-01f,
  -1.79803506e-01f, 1.72451526e-01f, 9.47483703e-02f, 3.09514180e-02f, -1.25635201e-02f, -2.84114275e-02f, -1.69547528e-01f, 8.25527683e-03f, -9.85595435e-02f, 7.12766722e-02f,
  -2.84068435e-01f, 1.97988689e-01f, -5.58284044e-01f, 2.30181277e-01f, 3.58260304e-01f, 1.42428815e-01f, -1.23425396e-02f, -1.46429002e-01f, 1.03287004e-01f, -1.84001997e-02f,
  8.23160782e-02f, 1.80952385e-01f, 1.82719007e-01f, 5.41238859e-02f, -1.95026502e-01f, -3.88432480e-02f, 1.83895886e-01f, -9.57212299e-02f, -1.99857116e-01f, 2.86158230e-02f,
  3.41292977e-01f, 5.89144155e-02f, -2.40946546e-01f, -1.65500715e-01f, 2.38910913e-01f, 1.73484981e-01f, -2.53643058e-02f, 1.13410130e-01f, 2.57537842e-01f, 3.73860985e-01f,
  -9.88785475e-02f, -3.14084172e-01f, -1.93537131e-01f, 1.10339418e-01f, -1.45688295e-01f, -2.07296625e-01f, -1.40638173e-01f, -2.40901977e-01f, -2.02653259e-02f, -1.27256677e-01f,
  2.10557237e-01f, -3.52780074e-02f, 3.30733895e-01f, -1.95707828e-02f, -7.23469183e-02f, -1.32574618e-01f, -3.38802487e-01f, -3.59341562e-01f, -4.46820170e-01f, -2.72563398e-01f,
  3.98905963e-01f, 2.31082737e-01f, -2.97100395e-01f, -2.18043953e-01f, -4.44978833e-01f, -2.19256938e-01f, -2.40834162e-01f, -2.24977404e-01f, -4.71351534e-01f, -2.55248517e-01f,
  -9.02995393e-02f, -6.84563518e-02f, 2.81829596e-03f, -1.60524640e-02f, 1.76409692e-01f, 4.82120290e-02f, 9.69225764e-02f, 1.35441110e-01f, 1.18869565e-01f, -7.25279674e-02f,
  1.94887891e-02f, -1.69574365e-01f, -9.97000858e-02f, -6.34244382e-02f, 1.18220463e-01f, 6.07655235e-02f, 7.68162310e-02f, -5.20378277e-02f, 8.21932703e-02f, 1.34383077e-02f,
  2.08040550e-01f, -6.23110197e-02f, -3.15367319e-02f, 8.91629383e-02f, -1.13362908e-01f, -1.39001355e-01f, 6.48837164e-02f, -7.97003433e-02f, -7.71967173e-02f, 1.80937629e-02f,
  1.57025252e-02f, -5.97510934e-02f, -5.87895326e-02f, -1.15984544e-01f, 4.87799942e-02f, -6.22371510e-02f, 5.13319261e-02f, -5.16358949e-02f, 9.23385322e-02f, -1.26301050e-01f,
  2.12710518e-02f, -7.43361041e-02f, 2.19814852e-02f, -7.03063607e-02f, -1.02084555e-01f, 3.06474455e-02f, 1.38018444e-01f, 2.49092989e-02f, -7.79234394e-02f, -1.09333351e-01f,
  3.68495658e-02f, -7.40103349e-02f, -1.91619411e-01f, -2.86997676e-01f, -2.14712750e-02f, 1.55837849e-01f, -1.21517405e-01f, -9.60340872e-02f, -1.91646993e-01f, -2.15651780e-01f,
  6.23387456e-01f, -3.42643261e-02f, 2.14029044e-01f, 1.04057871e-01f, -2.83062786e-01f, -3.78890246e-01f, -4.97649610e-01f, -1.96264103e-01f, -6.12817742e-02f, 1.45053640e-01f,
  -4.53778319e-02f, 2.08469540e-01f, 1.90337360e-01f, 2.49706626e-01f, 1.73482925e-01f, -1.32791189e-04f, 1.27429128e-01f, 3.77666950e-01f, 3.28927249e-01f, 2.63738155e-01f,
  1.37753606e-01f, 1.14716686e-01f, 3.76162022e-01f, 2.46712297e-01f, 8.86113867e-02f, -3.05782794e-03f, -3.07635088e-02f, 1.33216485e-01f, 9.21693668e-02f, 5.24359882e-01f,
  4.13135380e-01f, 1.53503418e-01f, -1.91367775e-01f, 4.55355868e-02f, 3.21878418e-02f, 7.85639063e-02f, 1.20757073e-01f, 8.39634016e-02f, -2.76523847e-02f, 1.92862060e-02f,
  2.60546114e-02f, 1.40644193e-01f, -1.55138642e-01f, -1.16835050e-02f, -2.70707216e-02f, -4.57234234e-02f, 7.77908564e-02f, 2.55711317e-01f, 1.80799961e-02f, 1.12673782e-01f,
  -2.99950223e-02f, -3.80737446e-02f, -5.18176481e-02f, -2.79674649e-01f, -5.77858537e-02f, -7.22182542e-02f, -1.57370180e-01f, 1.09102964e-01f, -1.23036399e-01f, 1.85339943e-01f,
  7.74322227e-02f, 7.43695274e-02f, 7.09753335e-02f, 1.63788587e-01f, 1.12205356e-01f, 1.52598396e-01f, 7.40465447e-02f, -2.13193614e-02f, 1.54766873e-01f, 6.49261922e-02f,
  2.34893449e-02f, -1.44571280e-02f, -3.85736022e-03f, -1.17259473e-03f, -4.33133990e-02f, -7.90394936e-03f, 1.50108719e-02f, 4.52059787e-03f, -7.35631734e-02f, 9.34321880e-02f,
  -3.03103612e-03f, 1.19123176e-01f, 2.80757900e-02f, 1.48990393e-01f, 6.01369180e-02f, 3.91332135e-02f, 1.91762540e-02f, -5.24668358e-02f, 1.60971042e-02f, 3.84601653e-02f,
  -4.82017785e-01f, -3.19716513e-01f, 1.58779159e-01f, -1.86189543e-02f, -2.84668356e-02f, -1.18599415e-01f, -1.35011636e-02f, -1.64448060e-02f, -5.61831743e-02f, -2.91180424e-02f,
  -1.99453786e-01f, -3.01433634e-03f, -1.04543194e-01f, -1.00502789e-01f, -4.87367548e-02f, -1.11554123e-01f, 6.59959838e-02f, -6.11651428e-02f, -6.75623566e-02f, 3.02545982e-03f,
  -1.19712614e-02f, -2.46111855e-01f, -8.56755227e-02f, -2.39204094e-01f, -1.83168590e-01f, -1.67975485e-01f, -3.01858544e-01f, -1.78826481e-01f, -3.78543079e-01f, -1.75425068e-01f,
  4.55467165e-01f, 1.53257968e-02f, -5.23134172e-01f, 3.43747616e-01f, -6.20509721e-02f, -5.56820706e-02f, 2.88323909e-01f, 2.37161681e-01f, 2.32991606e-01f, 1.13872543e-01f,
  -1.50488809e-01f, -3.62065524e-01f, -3.53483438e-01f, -2.35145897e-01f, 5.62871695e-02f, 1.83291003e-01f, 8.30228180e-02f, -1.84266150e-01f, -2.47975022e-01f, -7.46929459e-03f,
  1.86113641e-01f, 4.48290944e-01f, 3.04763615e-01f, 7.94831067e-02f, -1.20019071e-01f, -4.62290533e-02f, -1.43109597e-02f, -1.14699915e-01f, -1.04029171e-01f, -3.57160240e-01f,
  -4.33476329e-01f, -1.69480219e-01f, -2.23360091e-01f, -1.86802633e-02f, -7.87919536e-02f, 5.84771931e-02f, -7.17588067e-02f, -9.21785459e-02f, -4.83551323e-02f, -4.46497090e-02f,
  -2.09496677e-01f, -5.97536303e-02f, -3.98603052e-01f, -2.04825819e-01f, -3.82809490e-02f, 7.03634229e-03f, 9.68900770e-02f, -3.02871447e-02f, 3.68865877e-02f, -8.26966912e-02f,
  -6.11180030e-02f, -1.49468467e-01f, -3.69623303e-01f, -9.51408520e-02f, -3.25988919e-01f, -1.42812863e-01f, -2.96796203e-01f, -2.58387327e-01f, -2.16294706e-01f, -6.39068186e-02f,
  8.06562379e-02f, -2.99762506e-02f, 1.12208631e-02f, 6.42068759e-02f, 2.13999867e-01f, -2.37959344e-02f, -1.16095603e-01f, 5.94518567e-03f, -2.25860495e-02f, 7.66324177e-02f,
  -4.89866212e-02f, 1.21394947e-01f, -6.00887500e-02f, -2.34817006e-02f, -1.27165345e-02f, -5.06905168e-02f, -1.72897745e-02f, 1.13789447e-01f, 1.57499146e-02f, 1.29256636e-01f,
  -6.00690208e-02f, 3.28587508e-03f, -9.42415148e-02f, -3.25452462e-02f, -4.61979806e-02f, -3.27511579e-02f, 3.56835797e-02f, -3.29925381e-02f, -3.46449539e-02f, 1.17933773e-01f,
  2.36566857e-01f, 3.33746746e-02f, -8.46989602e-02f, -3.27766314e-02f, -1.33525610e-01f, -5.94242364e-02f, -2.05824757e-03f, 2.05519609e-03f, -1.21808074e-01f, -1.15382761e-01f,
  -6.30998462e-02f, -1.28016740e-01f, -1.37123615e-01f, -2.91915536e-02f, 5.57428077e-02f, -2.96531525e-02f, 2.58657217e-01f, -1.43783232e-02f, 4.86775637e-02f, 2.34805092e-01f,
  2.16345936e-01f, 2.95539439e-01f, 7.45339319e-02f, 1.03835382e-01f, 5.07495971e-03f, 4.23923172e-02f, -7.38414153e-02f, 1.81971774e-01f, 1.20097056e-01f, 5.90350091e-01f,
  -6.81314290e-01f, 3.37257326e-01f, 8.57754946e-02f, -3.97548854e-01f, 1.95577905e-01f, 4.26799059e-01f, 6.54002964e-01f, 3.08946986e-02f, -1.43587247e-01f, 1.68806285e-01f,
  1.54527172e-01f, -1.94422945e-01f, -1.81256473e-01f, 8.99600387e-02f, 1.10330969e-01f, 3.12741548e-01f, 1.83632731e-01f, -1.05936185e-01f, -3.38830166e-02f, 1.52729098e-02f,
  1.21200763e-01f, -2.46466130e-01f, -4.13624644e-01f, -1.55468956e-01f, -1.05987020e-01f, -1.33782342e-01f, 2.69768070e-02f, -1.05189271e-02f, 2.13210031e-01f, 1.29246777e-02f,
  -2.96914279e-01f, -2.76097357e-01f, 3.63918021e-02f, -5.16130403e-02f, -1.73484115e-03f, -2.84096450e-02f, 3.59810293e-02f, -5.22822849e-02f, 1.60210967e-01f, 1.94402342e-03f,
  -7.66927600e-02f, 7.79246911e-02f, -1.55859604e-01f, 1.21410480e-02f, -1.13308378e-01f, -2.02966146e-02f, -3.55814919e-02f, -6.73825219e-02f, -9.41116735e-02f, 1.43894568e-01f,
  2.93029338e-01f, -1.76079329e-02f, -2.07735240e-01f, 1.26994908e-01f, 7.63173029e-02f, -2.31576100e-01f, -1.06517039e-01f, -1.53728217e-01f, -1.50382712e-01f, -2.86286384e-01f,
  -1.45180803e-03f, 7.50292763e-02f, 9.48497057e-02f, -2.06277166e-02f, 7.30188638e-02f, -6.09953713e-04f, -3.49886715e-02f, 1.64397627e-01f, 7.88515899e-03f, 3.78267430e-02f,
  3.31382714e-02f, 5.54442182e-02f, -1.90767758e-02f, -5.46404757e-02f, -6.65035024e-02f, -1.25591289e-02f, 7.15989470e-02f, 9.73519683e-02f, 1.29750827e-02f, 1.18509149e-02f,
  -2.15694215e-02f, -2.60938425e-03f, -1.70123294e-01f, 4.05031666e-02f, 7.90171549e-02f, -6.90146610e-02f, -9.28495899e-02f, -4.41307090e-02f, -1.93291768e-01f, -5.28458618e-02f,
  -3.51318389e-01f, 1.92310140e-01f, -2.12712243e-01f, -7.75495917e-02f, -4.30276804e-02f, -7.79236257e-02f, -7.17749745e-02f, -1.15344107e-01f, -8.80737305e-02f, -8.22422281e-02f,
  9.77411345e-02f, -2.73606684e-02f, -1.09733194e-01f, 1.60815030e-01f, 8.19515586e-02f, -1.29186004e-01f, 1.38743222e-01f, -1.43521624e-02f, 7.24960715e-02f, -4.33666958e-03f,
  7.93093294e-02f, -7.30150100e-03f, -3.69734108e-01f, -3.97478715e-02f, -7.96388239e-02f, -2.62949675e-01f, -1.70599610e-01f, -2.18567193e-01f, -9.79904309e-02f, -8.73198509e-02f,
  -7.48933479e-02f, -1.04536697e-01f, -2.78070182e-01f, -5.42259336e-01f, -3.99895251e-01f, -1.04562111e-01f, -1.69034824e-01f, -2.13439390e-01f, -1.73486710e-01f, -1.39353380e-01f,
  -2.28172150e-02f, 8.62298086e-02f, 1.83073785e-02f, -1.35081830e-02f, 1.12113379e-01f, -3.93139608e-02f, -1.55592903e-01f, -1.72446612e-02f, -9.44407135e-02f, -5.57516590e-02f,
  -1.72083929e-01f, -4.57018703e-01f, -2.49630675e-01f, -2.07001671e-01f, -4.38133001e-01f, -3.75462532e-01f, -4.63402122e-01f, -2.77387023e-01f, -1.20868281e-01f, -2.70011246e-01f,
  -1.64172918e-01f, -1.43055126e-01f, -9.67755541e-02f, 1.26539156e-01f, -2.17209190e-01f, 8.12333357e-03f, -1.03770837e-01f, -1.96783498e-01f, -8.23605210e-02f, -1.57521501e-01f,
  -7.78675601e-02f, -4.86776419e-02f, -1.26334891e-01f, -1.59927532e-01f, -1.31043538e-01f, -8.77688453e-02f, 2.04036231e-04f, 6.77444264e-02f, 1.14592105e-01f, 1.67766482e-01f,
  1.71323672e-01f, 1.48594305e-01f, 6.95960596e-02f, 2.00690534e-02f, -3.32722180e-02f, 5.19379340e-02f, -1.74588352e-01f, -2.08897889e-02f, 1.83090121e-01f, 3.00677065e-02f,
  1.53272320e-02f, -2.01465655e-02f, 2.82630287e-02f, -1.04426168e-01f, 8.94497782e-02f, 3.37733701e-02f, -3.74258980e-02f, 4.19002846e-02f, -4.98119853e-02f, 3.19474190e-03f,
  4.27911654e-02f, 1.25534832e-01f, 7.11805299e-02f, 5.21053979e-03f, 1.59339644e-02f, 1.92321375e-01f, 4.16816846e-02f, -3.07028648e-02f, 8.37487504e-02f, 1.13318823e-02f,
  3.64691205e-02f, 3.32177319e-02f, 6.04238547e-02f, -3.99547890e-02f, 7.70597383e-02f, 5.74399903e-03f, 5.35267293e-02f, 5.30549958e-02f, -6.67241365e-02f, 1.24347441e-01f,
  -1.01394773e-01f, 1.11877456e-01f, -1.13619551e-01f, 6.88207150e-02f, -1.02417275e-01f, 9.46859047e-02f, 4.80626859e-02f, 2.20106058e-02f, -4.69287634e-02f, 1.89148691e-02f,
  5.13802841e-02f, 7.65508786e-02f, -8.47990960e-02f, -2.88382508e-02f, -6.02370836e-02f, 5.81107661e-02f, 2.47243479e-01f, 4.12409008e-02f, 2.15252176e-01f, 7.28435144e-02f,
  1.82505414e-01f, 2.06996635e-01f, 2.58785635e-01f, 1.90710738e-01f, 9.55448076e-02f, 2.56796807e-01f, 1.93271898e-02f, 1.43369287e-01f, 2.64495820e-01f, 1.81663454e-01f,
  -3.54101747e-01f, -5.10150671e-01f, -8.44578072e-02f, -5.02051711e-01f, -1.01640679e-01f, 1.57948464e-01f, 2.18529150e-01f, -2.18296032e-02f, -2.91166484e-01f, -1.67552918e-01f,
  -8.71524885e-02f, 1.26608536e-01f, -6.79459497e-02f, 1.37212351e-01f, 1.79366574e-01f, -1.73009001e-03f, -1.80002645e-01f, 1.31902680e-01f, 5.13418913e-01f, 3.01422328e-01f,
  4.43506576e-02f, -2.65460163e-01f, -2.32639730e-01f, -2.27684289e-01f, -3.49503249e-01f, -2.05091164e-02f, -5.01252592e-01f, -2.64781624e-01f, -2.97172070e-02f, -4.73732919e-01f,
  3.66022944e-01f, -3.98611754e-01f, -1.29504371e-02f, -1.02188356e-01f, -1.13109767e-01f, -7.59921670e-02f, 1.13612540e-01f, -2.35268354e-01f, -3.54073904e-02f, -1.18621685e-01f,
  -2.27591515e-01f, -5.42192310e-02f, 8.65766257e-02f, 8.15018639e-02f, 9.27258469e-03f, 1.30619332e-01f, -4.18145172e-02f, -1.03495628e-01f, -1.66937992e-01f, -5.30429631e-02f,
  -1.23324208e-02f, 2.71754861e-02f, 4.15257998e-02f, 3.70323285e-02f, -6.68867230e-02f, 5.77249527e-02f, -1.22066261e-02f, -7.16762096e-02f, -8.04789364e-02f, -1.76093012e-01f,
  -6.15305789e-02f, -6.36541517e-03f, -2.37401631e-02f, 7.23580495e-02f, 9.71359685e-02f, 1.11021876e-01f, -3.41850286e-03f, 6.54487088e-02f, -2.88999658e-02f, 2.57436968e-02f,
  -7.11906403e-02f, 1.36965718e-02f, -4.18843068e-02f, -9.46080461e-02f, -2.79443432e-02f, -1.12526290e-01f, 6.01382889e-02f, -1.61979645e-02f, -1.77232847e-01f, -1.17668867e-01f,
  -1.00346275e-01f, -5.79730645e-02f, -1.32782936e-01f, -1.09816156e-03f, -5.18174134e-02f, -4.83992174e-02f, -3.16162594e-02f, 7.93890841e-03f, 1.19156159e-01f, -2.53141504e-02f,
  2.09953219e-01f, -4.44076955e-03f, -7.77975470e-02f, -6.61772639e-02f, -1.38363361e-01f, -1.32637247e-01f, -1.06395088e-01f, -2.49696672e-02f, -2.40197722e-02f, 1.60743564e-01f,
  -8.91023874e-02f, 3.53214890e-02f, -4.18664739e-02f, -1.16465986e-01f, 2.80726119e-03f, -7.43456930e-03f, -7.45768398e-02f, -1.57028437e-02f, -5.21526672e-02f, -6.48165420e-02f,
  -8.94866288e-02f, 5.79550304e-02f, 2.49000683e-01f, 1.28256410e-01f, 4.23786528e-02f, 3.10155928e-01f, 6.80148751e-02f, 1.34567454e-01f, 3.10366452e-01f, 1.10681020e-01f,
  -4.75238375e-02f, -2.33167008e-01f, -4.96364117e-01f, -1.12464912e-01f, -4.67038274e-01f, -3.21457297e-01f, -4.79111820e-01f, 6.10859953e-02f, -2.61532739e-02f, -4.99989271e-01f,
  -1.76685601e-01f, 2.00729921e-01f, -9.57526192e-02f, 9.56392474e-03f, 1.66484937e-02f, -4.36126977e-01f, -5.21231413e-01f, -1.73670456e-01f, 5.47625534e-02f, 5.24304546e-02f,
  -1.60026923e-01f, -3.16726118e-02f, 1.02725506e-01f, 1.06810160e-01f, 2.04835217e-02f, 1.26227932e-02f, -2.58469254e-01f, -1.49970517e-01f, -9.11213085e-02f, -3.09411585e-01f,
  1.53568834e-01f, -1.01719640e-01f, -9.55401547e-03f, -1.14670381e-01f, -9.85962972e-02f, 3.04343496e-02f, -7.78003484e-02f, -5.38809001e-02f, 2.63088495e-02f, -8.75980109e-02f,
  -4.18321341e-02f, -1.37604207e-01f, 1.03045076e-01f, -7.13366345e-02f, -5.67322858e-02f, -3.63919586e-02f, -1.87817663e-01f, -4.86181080e-02f, -9.98259112e-02f, -9.04534608e-02f,
  -1.96088493e-01f, -2.07799464e-01f, 5.32155223e-02f, -4.36255522e-02f, 3.52509320e-02f, -3.88264060e-02f, -4.09673825e-02f, 5.67387342e-02f, 6.59087673e-02f, 8.81124884e-02f,
  1.55881222e-03f, 1.22065566e-01f, -9.67041925e-02f, 3.12563665e-02f, 3.49052064e-02f, -4.06543128e-02f, 3.45730036e-02f, 6.29611537e-02f, -2.18035430e-02f, 5.22924811e-02f,
  -1.38808608e-01f, -9.27918181e-02f, 6.52480945e-02f, 9.02436301e-03f, -5.65548204e-02f, 2.01427769e-02f, -8.09972286e-02f, 5.95769333e-03f, 1.44820800e-03f, 1.89063810e-02f,
  -1.29466997e-02f, 7.81742260e-02f, 4.11469564e-02f, 1.45637333e-01f, -1.57472014e-01f, -4.70955148e-02f, -5.85673191e-02f, -5.74903889e-03f, 5.89997275e-03f, -1.90930739e-01f,
  4.57716942e-01f, -2.21969426e-01f, 4.33798432e-02f, 1.07578501e-01f, -1.20798342e-01f, -1.57610431e-01f, -1.10592552e-01f, 1.50999222e-02f, 1.23114415e-01f, 3.75338681e-02f,
  -4.99542020e-02f, 9.42488834e-02f, -4.10728715e-02f, -1.18139284e-02f, -1.13981187e-01f, -1.63803086e-01f, -1.72671199e-01f, -4.14023995e-02f, 6.93568140e-02f, -1.03876106e-01f,
  -9.70389396e-02f, -3.57180126e-02f, 1.44577712e-01f, 1.42232999e-01f, 5.86477630e-02f, 1.43468305e-01f, 4.70446534e-02f, 8.81431252e-02f, 1.13124862e-01f, 3.11983898e-02f,
  5.93631566e-01f, 6.97782859e-02f, 3.61964345e-01f, -4.87560630e-02f, -2.06613410e-02f, 2.17455834e-01f, 3.79075438e-01f, 1.06852882e-01f, -1.41876832e-01f, 5.25404550e-02f,
  -3.92255157e-01f, -5.17666042e-01f, -4.21058476e-01f, -2.83772618e-01f, 2.67282315e-02f, 3.38322014e-01f, 2.39587411e-01f, 3.44802052e-01f, 2.12358117e-01f, 1.14989281e-01f,
  -2.16118589e-01f, 9.44363233e-03f, 2.77599335e-01f, 2.23663285e-01f, 6.04814515e-02f, -2.12511167e-01f, 2.40069758e-02f, 1.54540325e-02f, 8.86539295e-02f, 9.23274383e-02f,
  4.47122119e-02f, 2.69020021e-01f, -1.64546207e-01f, -1.69083700e-01f, -1.45841047e-01f, -1.69798881e-02f, -1.03497736e-01f, -1.10621601e-01f, -7.95668960e-02f, 8.08931142e-02f,
  -1.00573592e-01f, 7.93391541e-02f, -5.17722294e-02f, 4.02462762e-03f, 3.24081839e-03f, -1.06890099e-02f, 4.07048911e-02f, 6.57415688e-02f, -3.70619469e-03f, 7.52995014e-02f,
  -2.59211987e-01f, -5.43604828e-02f, 1.48475587e-01f, -9.80628580e-02f, 2.76445784e-02f, -1.78160727e-01f, 6.17813803e-02f, 9.09543857e-02f, 1.75572373e-02f, 7.26534054e-02f,
  -1.40430227e-01f, -5.25960997e-02f, -5.16244508e-02f, -1.51289953e-02f, -2.03741696e-02f, -1.41048834e-01f, -7.00756311e-02f, -5.77413626e-02f, -4.78016548e-02f, 1.00750834e-01f,
  -1.58557490e-01f, -2.22978462e-02f, -3.95603292e-02f, -9.38756019e-02f, -2.39844784e-01f, 5.68200788e-03f, 1.00973006e-02f, -4.62465324e-02f, -2.13781074e-02f, -1.20405883e-01f,
  -1.27006605e-01f, 1.23806514e-01f, -6.50175810e-02f, 4.40386776e-03f, -1.11499116e-01f, -5.15013859e-02f, -1.21839628e-01f, -1.61407858e-01f, 1.51597941e-02f, -4.91806902e-02f,
  -2.22823396e-01f, -3.22410077e-01f, 1.32513093e-02f, 1.01505764e-01f, 7.58958980e-02f, -7.63991997e-02f, -5.27331457e-02f, -1.39285624e-01f, 5.94334677e-02f, 4.04391885e-02f,
  2.40462124e-02f, -6.52303826e-03f, 1.01731261e-02f, -4.26098481e-02f, -1.32505046e-02f, -6.30213460e-03f, -2.07070485e-01f, -8.53435323e-02f, -9.47849080e-02f, 2.76861228e-02f,
  -1.38624802e-01f, -9.52610746e-03f, -2.42910516e-02f, -8.61953720e-02f, -6.96184486e-02f, -9.85261798e-02f, 8.13484099e-03f, -9.33062658e-03f, 5.08156931e-03f, -4.85943034e-02f,
  -3.36310208e-01f, -3.81847888e-01f, -1.63940117e-01f, 5.18407486e-02f, 1.06107593e-01f, -1.30999118e-01f, -3.96563470e-01f, -3.12017798e-02f, 1.94553286e-01f, -2.48456910e-01f,
  -1.53341427e-01f, 6.80752918e-02f, -2.64458716e-01f, -3.15121263e-01f, -4.43457454e-01f, -5.13898551e-01f, -3.58312100e-01f, -1.75324708e-01f, 1.99932903e-02f, 2.76237786e-01f,
  6.01605363e-02f, 1.35506421e-01f, 1.10098585e-01f, 9.63585153e-02f, 2.01237977e-01f, 4.26510610e-02f, -9.36125442e-02f, 5.10790572e-02f, -1.60706833e-01f, -2.62636423e-01f,
  -3.33400011e-01f, -1.75639093e-02f, 2.36718684e-01f, 2.48840195e-03f, 7.20473602e-02f, -3.27089839e-02f, -1.38921645e-02f, -3.34441289e-02f, -1.06863789e-01f, -1.85395837e-01f,
  -7.42151542e-03f, 3.82874720e-02f, 9.92488191e-02f, 1.17773578e-01f, 1.21368118e-01f, 2.71502975e-02f, 7.71100372e-02f, -3.26181352e-02f, -5.27939424e-02f, 1.48882102e-02f,
  -1.90871105e-01f, -1.12804383e-01f, -2.26826593e-01f, 2.79970430e-02f, 1.24698117e-01f, 8.57400298e-02f, 6.29332289e-02f, 2.59540677e-01f, -3.70504782e-02f, -1.81074470e-01f,
  1.21414950e-02f, 1.06236339e-02f, 1.19178437e-01f, -3.21961381e-02f, 9.42408890e-02f, 8.07571262e-02f, 1.41818821e-02f, -1.05218299e-01f, -1.52665554e-02f, -6.56656697e-02f,
  3.05321347e-02f, -3.11030559e-02f, 4.17292900e-02f, -2.36519858e-01f, -1.34423107e-01f, 2.59573315e-03f, -1.63643897e-01f, -1.00780159e-01f, -1.00971818e-01f, 2.55985316e-02f,
  -3.89935300e-02f, 1.78775974e-02f, 4.86573800e-02f, 8.06629956e-02f, -2.23821387e-01f, -4.88801636e-02f, 9.98385400e-02f, -3.86666209e-02f, 6.82992637e-02f, 6.91979975e-02f,
  -1.72739059e-01f, -4.61504012e-02f, -2.68869907e-01f, -1.00839294e-01f, 3.28156017e-02f, 9.29216892e-02f, -1.02571942e-01f, -8.62261802e-02f, -1.90173194e-01f, 8.72727036e-02f,
  -3.55597329e-03f, -2.72456445e-02f, -9.03140157e-02f, 7.76800886e-02f, 5.68975359e-02f, -2.34448817e-02f, -1.51030660e-01f, -1.77528858e-01f, -1.59144342e-01f, 2.78593838e-01f,
  -1.58827305e-01f, -3.69168073e-01f, -5.27244806e-01f, -3.11091512e-01f, 8.40925059e-05f, -8.46489891e-02f, -1.43813536e-01f, -9.24156830e-02f, -3.79058480e-01f, -5.85860193e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.47806358e-01f, 1.65115759e-01f, 3.19179207e-01f, 4.76739734e-01f, 6.26094360e-03f, 2.46207327e-01f, 2.55235821e-01f, 2.04891786e-01f, 2.64203250e-01f, 2.67165184e-01f,
  2.65071720e-01f, 1.05907053e-01f, 1.43149406e-01f, 2.69027084e-01f, 4.67537940e-01f, 1.05839379e-01f, 6.83516040e-02f, 3.38414490e-01f, 1.06971063e-01f, 4.71761554e-01f,
  2.30656371e-01f, 1.94605187e-01f, 4.27666694e-01f, 1.84496313e-01f, 4.18187141e-01f, 2.78024852e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.34019563e-02f, -2.91971788e-02f, 1.15450025e-02f, 3.93141620e-02f, 9.66904163e-02f, 1.85768288e-02f, 7.55340457e-02f, 1.97344013e-02f, -5.65320067e-02f, -1.06103923e-02f,
  2.04355255e-01f, -9.06697512e-02f, -3.90557647e-02f, 3.04988604e-02f, -1.77159980e-01f, -1.18108168e-01f, -1.03755504e-01f, 1.19258165e-01f, -5.57253920e-02f, 5.81797445e-03f,
  6.55004531e-02f, 1.59080297e-01f, -6.35317862e-02f, 4.72609885e-02f, -5.54083027e-02f, -7.43531734e-02f, -1.83280115e-03f, 1.42787322e-01f, -8.93959180e-02f, 3.77065465e-02f,
  -5.11300303e-02f, 1.30026951e-01f, -1.32598132e-01f, -9.22814086e-02f, -1.40472278e-01f, 6.18495531e-02f, -1.26162335e-01f, 2.50744790e-01f, -2.75110960e-01f, -2.24070903e-02f,
  1.28827272e-02f, 1.27509341e-01f, 8.78220126e-02f, -3.01872492e-02f, -1.03046745e-01f, -8.21524952e-03f, -1.01216562e-01f, 2.29044944e-01f, -8.77412036e-02f, -1.05400495e-01f,
  -2.48954639e-01f, -1.96981117e-01f, 2.12135717e-01f, 2.84637138e-02f, -6.31541908e-02f, 1.76004712e-02f, 1.65072173e-01f, 2.27493361e-01f, 6.28063306e-02f, -2.78604001e-01f,
  3.09068501e-01f, -1.15718648e-01f, 1.90381557e-01f, -1.91618308e-01f, 5.43082096e-02f, -7.65199512e-02f, 1.26882643e-01f, 1.86654385e-02f, 1.31526500e-01f, 8.68905783e-02f,
  -8.49185660e-02f, 4.16431949e-02f, 3.96877155e-02f, -4.87132370e-02f, 1.00440256e-01f, -6.12017736e-02f, 1.32884085e-01f, 4.20839377e-02f, -2.50953715e-02f, -9.21128541e-02f,
  1.98827814e-02f, -1.05696030e-01f, 4.65657450e-02f, -6.39721751e-02f, -1.01863138e-01f, -4.25026380e-02f, -8.94713327e-02f, -1.12767570e-01f, -1.13056771e-01f, 9.41392258e-02f,
  -1.31440774e-01f, -4.42929529e-02f, 5.59727848e-02f, 5.15980460e-02f, 5.31711392e-02f, -1.13230430e-01f, -7.56873712e-02f, 1.00100823e-01f, 3.02943382e-02f, 7.05003813e-02f,
  -1.35918073e-02f, 9.38842073e-02f, -4.25725818e-01f, 8.38581249e-02f, 1.38604119e-01f, 4.24282579e-03f, -2.70635504e-02f, -1.26678273e-01f, 1.26700014e-01f, -3.51169527e-01f,
  -6.03652326e-03f, -1.53851092e-01f, 1.39506593e-01f, -2.30742067e-01f, 7.63352290e-02f, -2.32368298e-02f, -7.62820989e-02f, 2.00226545e-01f, 2.09177479e-01f, 3.90680850e-01f,
  -9.43185538e-02f, 1.21180929e-01f, 1.24683522e-01f, 1.32486805e-01f, 1.87282756e-01f, 5.56731261e-02f, -3.95594597e-01f, 2.51171052e-01f, 6.40423521e-02f, -7.53030404e-02f,
  -3.53582576e-02f, 1.08362824e-01f, 9.32778269e-02f, 2.93576606e-02f, -1.51377127e-01f, -7.95800313e-02f, -9.32758376e-02f, 3.04034818e-02f, -7.83949941e-02f, 5.66178672e-02f,
  -1.14144832e-01f, -8.65040421e-02f, 4.41643596e-02f, -1.14054054e-01f, -4.36510295e-02f, 7.34751225e-02f, -8.01887065e-02f, -6.10445859e-03f, -6.04752488e-02f, -2.11882129e-01f,
  2.34585434e-01f, -6.03396036e-02f, -4.69346158e-02f, 1.18293928e-03f, -8.04007053e-02f, -4.91077965e-03f, 1.40218334e-02f, 1.94296569e-01f, -8.70142281e-02f, -7.29329735e-02f,
  2.75683552e-02f, -2.75891796e-02f, 2.33942680e-02f, 2.26350147e-02f, -2.80865431e-01f, -6.57429546e-02f, 1.90155674e-02f, -1.48458093e-01f, -3.53768654e-02f, -2.87274092e-01f,
  -1.51560530e-01f, 1.10480733e-01f, -5.33550903e-02f, 3.02813739e-01f, 1.54990122e-01f, -2.68574834e-01f, -2.55232871e-01f, -3.29692438e-02f, -5.04977815e-02f, 5.83961643e-02f,
  1.83447152e-01f, 1.19634263e-01f, -4.93441056e-03f, 1.60950512e-01f, 1.96088746e-01f, -3.57014865e-01f, 2.82999367e-01f, 2.31023639e-01f, 1.48197249e-01f, -1.62695780e-01f,
  2.17179488e-02f, -1.92602038e-01f, 1.12692108e-02f, -3.50218564e-02f, 1.62009478e-01f, 3.69735248e-02f, -7.76111707e-02f, 8.11792612e-02f, -1.25625804e-01f, -7.77927339e-02f,
  1.62747324e-01f, -8.72613788e-02f, 5.38657941e-02f, 1.40582532e-01f, 1.63065996e-02f, -1.04911737e-01f, 2.75300462e-02f, 8.19710419e-02f, -4.72461209e-02f, -3.26417945e-02f,
  1.49680339e-02f, -1.49319857e-01f, -1.16148964e-01f, 1.26269348e-02f, 9.81550068e-02f, -1.36699587e-01f, -2.73845587e-02f, -9.22643673e-03f, -1.05444945e-01f, -2.16157764e-01f,
  -5.31770848e-03f, 1.75638437e-01f, 6.05189533e-04f, 5.65234832e-02f, 4.45534661e-02f, 1.91534773e-01f, -2.42500696e-02f, -1.61036421e-02f, -1.27084717e-01f, -2.30804071e-01f,
  -2.46345311e-01f, 3.76125537e-02f, -9.33856219e-02f, -2.12079406e-01f, -1.30995452e-01f, 2.95184692e-03f, 1.05982967e-01f, -2.28093013e-01f, 2.10747764e-01f, -1.14186667e-01f,
  9.63228941e-02f, 1.64787725e-01f, 8.39556083e-02f, 3.24544124e-02f, -8.47273320e-03f, 1.43447161e-01f, 1.73813030e-01f, 2.43697286e-01f, -2.21229494e-01f, 1.77998483e-01f,
  2.03078702e-01f, 1.28974929e-01f, -1.90092791e-02f, 1.41037926e-01f, -4.94407147e-01f, 5.62320836e-02f, 1.67582393e-01f, -7.36414921e-03f, -2.73119770e-02f, -4.41350490e-02f,
  3.53555568e-02f, 1.12203889e-01f, 1.54339084e-02f, 6.00079149e-02f, 4.20914218e-02f, -4.35153343e-05f, 8.03999719e-04f, 3.87698114e-02f, -1.80137679e-02f, 1.00349918e-01f,
  -1.70006100e-02f, -8.06818828e-02f, -6.42587095e-02f, 9.37091000e-03f, 1.33326799e-01f, 3.29909213e-02f, -6.57387152e-02f, -1.33253068e-01f, 1.13438219e-01f, 1.46067245e-02f,
  -1.70710720e-02f, -3.79105210e-02f, -8.28038380e-02f, 7.83371776e-02f, -1.33283315e-02f, 6.62345514e-02f, 4.12562303e-03f, 7.80489221e-02f, 1.28456568e-02f, 1.39773622e-01f,
  -2.03271091e-01f, 1.15213737e-01f, -3.15955848e-01f, 1.51573241e-01f, -1.85912207e-01f, -3.19938093e-01f, 8.88078362e-02f, -9.33449343e-02f, -2.98444271e-01f, -6.41758293e-02f,
  -1.00456893e-01f, 2.31238246e-01f, 1.62747458e-01f, 3.12114507e-01f, -3.00429985e-02f, -2.72437036e-02f, 3.78634743e-02f, 8.02738070e-02f, -2.76578009e-01f, -5.22188060e-02f,
  -4.44467217e-02f, 5.09400107e-02f, 2.60694027e-01f, 1.33172378e-01f, -2.69401580e-01f, 1.17268361e-01f, -3.14393491e-01f, -6.43517310e-03f, 8.08033943e-02f, -1.92794986e-02f,
  4.49357219e-02f, -5.25066890e-02f, -7.35813975e-02f, 9.31146294e-02f, -4.52643409e-02f, 1.24656931e-01f, -7.29749203e-02f, -2.55354922e-02f, -3.31134200e-02f, -3.00549138e-02f,
  -1.09300777e-01f, 1.35364443e-01f, 1.51523445e-02f, -6.99035004e-02f, 1.21580083e-02f, -5.36960037e-03f, -1.03456050e-01f, -1.21796124e-01f, -7.43829757e-02f, 1.10898288e-02f,
  -3.19824032e-02f, -3.39210825e-03f, 7.91280121e-02f, -4.69639935e-02f, -3.34926806e-02f, -1.44679114e-01f, 1.39925051e-02f, -2.39539936e-01f, 1.08008429e-01f, 4.55812141e-02f,
  -2.33727500e-01f, -1.03761941e-01f, 2.47502364e-02f, -1.06121980e-01f, 6.13916516e-02f, -1.60805300e-01f, -2.41968390e-02f, -2.53073484e-01f, 5.41451387e-02f, 1.38153750e-02f,
  -9.21371281e-02f, -1.44231785e-02f, -1.71560273e-02f, 2.78615896e-02f, -1.11759856e-01f, 3.46428365e-01f, -2.86830794e-02f, -4.34679985e-01f, -2.31413871e-01f, -4.96959453e-03f,
  5.72289973e-02f, -1.07226446e-01f, 2.72916555e-01f, 7.95509443e-02f, -2.53099222e-02f, -7.34807849e-02f, -3.14121306e-01f, -1.77716136e-01f, 1.36955649e-01f, 2.44936600e-01f,
  3.39991391e-01f, 8.50692950e-03f, 1.85710162e-01f, 4.54811798e-03f, 1.54494032e-01f, -2.08306964e-02f, 1.24281459e-01f, 1.96868107e-02f, 3.03975819e-03f, -6.78166524e-02f,
  -1.22506497e-03f, 1.08549841e-01f, -8.53601247e-02f, -7.44403154e-02f, 5.34988232e-02f, 1.11718401e-01f, -8.23697522e-02f, 1.58124670e-01f, 5.88665046e-02f, -1.55344475e-02f,
  -1.85521301e-02f, 9.00839269e-02f, -3.34469378e-02f, -3.21556814e-02f, 1.10261232e-01f, 6.45798072e-02f, 1.76819302e-02f, -1.25127723e-02f, 1.40300676e-01f, -1.55504227e-01f,
  -7.60265291e-02f, -1.64777394e-02f, -7.59359971e-02f, -1.90159589e-01f, -3.01636141e-02f, 8.80661085e-02f, 1.82839930e-01f, -1.11964777e-01f, -5.76776899e-02f, -1.36288166e-01f,
  2.87642796e-02f, 1.05999699e-02f, -5.21160811e-02f, -2.11855266e-02f, 1.46221817e-01f, 1.56657279e-01f, 7.51988143e-02f, 2.83188373e-01f, 3.23751159e-02f, -3.38434950e-02f,
  4.72277775e-02f, -6.42950181e-03f, -2.18775839e-01f, 1.73327819e-01f, -4.72596623e-02f, -3.12386125e-01f, 3.03680897e-02f, 8.64567906e-02f, 2.87794143e-01f, -2.97689855e-01f,
  -7.88182244e-02f, 4.75835174e-01f, -3.88147950e-01f, -1.77480876e-01f, 1.45317405e-01f, 2.10899457e-01f, 2.38645896e-01f, -1.02170557e-01f, -1.23552941e-02f, 1.57157797e-02f,
  7.08676502e-02f, -1.20160179e-02f, 1.95331469e-01f, 1.13534406e-02f, 1.56440046e-02f, 8.84680673e-02f, -3.98818068e-02f, 4.33425196e-02f, -3.18497606e-02f, -3.50889540e-03f,
  2.07300670e-02f, 9.46912542e-02f, -6.03213124e-02f, 3.64582092e-02f, -1.23398136e-02f, 5.76429442e-02f, 1.06913023e-01f, -4.85031083e-02f, -7.72423595e-02f, -1.20344549e-01f,
  -3.59347137e-03f, -1.78839117e-01f, 4.60652038e-02f, -2.14688368e-02f, -4.86415699e-02f, 1.61164448e-01f, -5.46003208e-02f, 2.69496292e-02f, 2.12575614e-01f, 1.33096073e-02f,
  1.31754922e-02f, 4.52243239e-02f, -1.69219196e-01f, 1.76801100e-01f, -3.43696952e-01f, 2.13571206e-01f, -1.79636672e-01f, -1.79342389e-01f, 1.74099684e-01f, 3.56291533e-02f,
  -1.18159741e-01f, 2.02610511e-02f, -1.27446372e-02f, 9.55529958e-02f, -1.36686191e-01f, 4.44778562e-01f, 6.06955364e-02f, -2.32219324e-02f, -4.72787395e-02f, 1.97437733e-01f,
  -1.04913749e-01f, -1.23813450e-01f, -3.08174007e-02f, 1.46299407e-01f, 9.73822027e-02f, 4.73342203e-02f, -4.00391877e-01f, 6.66671172e-02f, -3.60237092e-01f, -1.60103410e-01f,
  -1.03289612e-01f, -8.62073898e-02f, 1.76240832e-01f, 3.68679725e-02f, 1.40648961e-01f, -5.78068718e-02f, -6.05127662e-02f, -6.42746463e-02f, -2.57032760e-03f, 1.60898089e-01f,
  -7.02228844e-02f, -1.16525583e-01f, -1.10647857e-01f, 1.39193371e-01f, -4.30842862e-02f, -4.66228910e-02f, 1.07700877e-01f, -6.60853833e-02f, 2.04236759e-03f, 6.50171787e-02f,
  1.89973100e-03f, -8.24573189e-02f, -7.46456757e-02f, 4.42045815e-02f, 4.90310602e-02f, -1.80189028e-01f, -7.63469636e-02f, -2.29450613e-02f, 2.42155250e-02f, 6.72002807e-02f,
  1.15548790e-01f, -6.87414110e-02f, 6.01463020e-02f, -7.60058239e-02f, 7.06829643e-03f, -9.25760865e-02f, 7.11128339e-02f, 1.62563369e-01f, 7.50692561e-02f, -3.98832969e-02f,
  -6.72484711e-02f, -4.87245125e-04f, 1.21522747e-01f, 5.03978953e-02f, -1.02019370e-01f, -2.40344301e-01f, -1.82666689e-01f, 1.96378693e-01f, 2.98562925e-02f, 4.34105508e-02f,
  1.97385415e-01f, 3.47509794e-02f, 1.14946127e-01f, -6.08336665e-02f, -2.46535853e-01f, -2.49388397e-01f, -7.40423352e-02f, 1.34601193e-02f, 2.51153380e-01f, -1.71808153e-01f,
  -3.40298377e-02f, 2.56687194e-01f, -7.20329359e-02f, 2.54072368e-01f, -1.12802638e-02f, 3.08409967e-02f, -1.19679999e-02f, 3.21709886e-02f, -6.10505342e-02f, -2.78042222e-04f,
  -1.74898744e-01f, -3.32349278e-02f, 1.65559836e-02f, -7.80412778e-02f, 1.76970903e-02f, -1.52922213e-01f, -3.36943641e-02f, 8.33932236e-02f, -1.07969448e-01f, 1.42427906e-01f,
  -1.87868699e-01f, -1.01314336e-01f, -1.76093891e-01f, 1.26770157e-02f, -4.06673551e-02f, -8.84296838e-03f, 2.07179531e-01f, 1.16244294e-01f, 9.19452682e-02f, -3.48917395e-02f,
  -6.49425164e-02f, -5.07340245e-02f, 1.99201796e-02f, 1.36099473e-01f, 2.27581151e-03f, 5.55668920e-02f, -1.82834521e-01f, 9.91472900e-02f, 1.31272897e-01f, -1.08253866e-01f,
  1.23596750e-01f, -1.16700009e-01f, 1.66613292e-02f, 1.42619476e-01f, 2.79309213e-01f, -2.58318692e-01f, -2.14720413e-01f, 9.83291715e-02f, 1.53810069e-01f, 4.84383404e-02f,
  -2.73334067e-02f, 1.77955136e-01f, -7.30054229e-02f, -1.89576447e-01f, -7.95434117e-02f, 9.79250371e-02f, 1.12923302e-01f, 8.48488808e-02f, 2.07729027e-01f, -1.92038864e-01f,
  -3.98084633e-02f, -3.77580494e-01f, -9.32326466e-02f, -1.48277241e-03f, 1.54879376e-01f, -1.20827504e-01f, -3.37579213e-02f, -2.53449529e-01f, 3.43215972e-01f, -2.66888678e-01f,
  5.57748787e-02f, 4.62932773e-02f, 4.37692627e-02f, -3.35711874e-02f, 2.11861283e-02f, 1.68223143e-01f, 8.22646394e-02f, -3.62689793e-02f, 8.86810105e-03f, 1.52433842e-01f,
  -3.86233144e-02f, 8.38160440e-02f, 1.43905934e-02f, 1.23825416e-01f, -3.19044851e-02f, 6.51623532e-02f, 3.81021947e-02f, 1.89458430e-01f, 4.20075618e-02f, -8.33585951e-03f,
  3.51435281e-02f, -3.55823785e-02f, 1.12305708e-01f, 7.64380582e-03f, -2.16178577e-02f, -1.13434464e-01f, -2.52359509e-02f, -3.74275967e-02f, -6.86470717e-02f, -1.27037717e-02f,
  -8.29188451e-02f, 8.45097154e-02f, 4.46815789e-02f, -3.96699496e-02f, -1.96316168e-01f, -5.78114092e-02f, -1.25488117e-01f, 2.59142444e-02f, -1.48320094e-01f, 9.62253511e-02f,
  -9.73184109e-02f, 2.19009683e-01f, 1.85767949e-01f, 1.29056200e-01f, -1.20154165e-01f, 1.73880607e-01f, 1.16990298e-01f, -4.40748502e-03f, 1.24600708e-01f, 1.17295548e-01f,
  -2.75732070e-01f, -1.12603404e-01f, 1.54147089e-01f, 3.06180157e-02f, -2.61815675e-02f, -1.23087130e-01f, 1.67977549e-02f, -1.04148768e-01f, -3.82330537e-01f, 9.58767757e-02f,
  2.68001944e-01f, 1.10197313e-01f, 6.12295903e-02f, -1.37146756e-01f, -9.73225385e-02f, -1.02834888e-01f, -5.23427837e-02f, 2.93105487e-02f, 3.10373884e-02f, 1.53029650e-01f,
  -1.25817433e-01f, 2.29733121e-02f, 4.88268100e-02f, 1.03072040e-02f, -5.68366870e-02f, 1.84228644e-02f, -6.52391687e-02f, -7.38151744e-02f, 1.82906196e-01f, 5.82050644e-02f,
  1.00519411e-01f, -3.57842818e-02f, -5.32611869e-02f, 5.84854409e-02f, 1.22549251e-01f, -8.33192840e-02f, 4.12791930e-02f, 3.91503163e-02f, -9.45171490e-02f, -9.35142487e-02f,
  5.81693277e-02f, -1.35880262e-01f, 1.03070311e-01f, 5.75772785e-02f, 4.18381505e-02f, 6.06341027e-02f, 1.31657049e-01f, -1.13888169e-02f, 4.74125519e-02f, 2.02755947e-02f,
  1.32982776e-01f, -2.00588092e-01f, 4.03067350e-01f, -4.67737801e-02f, -1.54156953e-01f, -6.12857081e-02f, 1.32714674e-01f, -8.54346007e-02f, 3.36873345e-02f, 3.54677200e-01f,
  1.20658666e-01f, -4.36635464e-01f, -2.13741779e-01f, 1.32400379e-01f, -1.54946655e-01f, 3.24786156e-02f, 1.64185204e-02f, 2.54571766e-01f, -2.27019191e-03f, 1.63560789e-02f,
  -2.92310476e-01f, -1.28635913e-01f, 2.70579576e-01f, 6.33851886e-02f, 1.33838832e-01f, 8.38203132e-02f, 1.08154137e-02f, -9.34737399e-02f, -2.00010445e-02f, -1.02487475e-01f,
  1.18976913e-01f, 6.66550249e-02f, -1.70085691e-02f, -1.19885139e-01f, 8.24261531e-02f, -7.43368594e-03f, 6.39192015e-02f, 1.32726014e-01f, 8.83321390e-02f, -7.62225091e-02f,
  1.57999665e-01f, -7.40969032e-02f, 1.89483110e-02f, 5.37686534e-02f, -3.19394916e-02f, -6.82992535e-03f, -1.32318124e-01f, 2.88466346e-02f, -1.56076461e-01f, -3.96801159e-02f,
  -1.43173024e-01f, -1.65510744e-01f, 4.00401168e-02f, -8.13859031e-02f, 9.77973361e-03f, -7.90292695e-02f, 1.55310720e-01f, -1.51229545e-01f, 2.79748421e-02f, -1.06607661e-01f,
  3.10521990e-01f, 6.19228035e-02f, -7.07303956e-02f, 1.00416616e-01f, -1.02591282e-02f, -3.75626869e-02f, -2.32094005e-01f, 1.56853229e-01f, 1.58029839e-01f, 1.08355574e-01f,
  -7.25118294e-02f, 1.85116399e-02f, 4.58126664e-02f, -2.45320633e-01f, 8.04456323e-02f, 1.27864435e-01f, 1.17712170e-01f, 3.87302935e-02f, -2.38961782e-02f, -8.31999443e-03f,
  -2.97570527e-01f, -3.92239466e-02f, 5.60421273e-02f, 1.22003488e-01f, 5.51973358e-02f, -2.35821586e-02f, -3.66779298e-01f, -6.17040247e-02f, -1.62287712e-01f, 3.34263951e-01f,
  -4.89141524e-01f, 2.30848357e-01f, -1.48796692e-01f, 5.11278845e-02f, -1.05803995e-03f, 2.16930043e-02f, 1.28055423e-01f, -1.52091105e-02f, 5.38439639e-02f, 8.45863149e-02f,
  -1.80980917e-02f, 4.79380339e-02f, -8.01740587e-02f, -2.19375610e-01f, -6.35345876e-02f, 2.33739410e-02f, -4.96267192e-02f, 9.10178106e-03f, 6.44278824e-02f, 2.41794903e-02f,
  6.84990138e-02f, 4.74777296e-02f, -3.00994683e-02f, 1.20042115e-01f, -2.22909381e-03f, 8.00825208e-02f, -6.02899529e-02f, 9.80986562e-03f, 1.23183271e-02f, 1.36403143e-01f,
  -6.69642538e-02f, 9.44408551e-02f, 1.53140470e-01f, -8.28180984e-02f, -6.40496388e-02f, -1.39344871e-01f, -9.55423191e-02f, 9.74155813e-02f, -4.97138277e-02f, 1.44460469e-01f,
  1.84525162e-01f, 7.15846047e-02f, -8.80978480e-02f, -4.64915559e-02f, -1.95710454e-04f, -1.14021316e-01f, -1.89559281e-01f, 9.77846310e-02f, 1.06562868e-01f, 2.98644871e-01f,
  1.82886809e-01f, 2.37179957e-02f, 1.01881236e-01f, 2.58240812e-02f, -2.07438201e-01f, -1.27947196e-01f, -1.51119784e-01f, -2.29740083e-01f, 3.70881468e-01f, -5.60168214e-02f,
  -3.02300453e-01f, -2.37260640e-01f, -2.67884433e-01f, -2.17070237e-01f, 1.60103858e-01f, 5.60726644e-03f, -2.11540405e-02f, 6.35026544e-02f, 5.11148795e-02f, 6.31027296e-02f,
  3.43200914e-03f, 1.32020757e-01f, 1.92210302e-02f, 4.36413325e-02f, 5.35051189e-02f, -2.97848377e-02f, 1.48784285e-02f, 3.16299349e-02f, 4.24917303e-02f, -9.02766883e-02f,
  2.29759160e-02f, -3.38850953e-02f, 6.79942314e-03f, 3.03744003e-02f, -9.73096192e-02f, -1.10671207e-01f, -6.32600784e-02f, 4.78879660e-02f, -1.17413178e-01f, 7.17552304e-02f,
  -6.00929298e-02f, -4.90450747e-02f, 2.58255750e-01f, 2.19928045e-02f, -1.64477918e-02f, 1.83355510e-02f, -1.04472958e-01f, -1.17772996e-01f, 2.98190527e-02f, -5.48346154e-02f,
  2.01135799e-02f, 1.47096813e-01f, -7.50654340e-02f, 7.49183744e-02f, 1.08071696e-02f, 1.57994151e-01f, -8.01979750e-02f, 1.51272133e-01f, 4.21333835e-02f, -1.05901875e-01f,
  -9.32005569e-02f, 9.76087227e-02f, 1.46607026e-01f, -1.05253182e-01f, 1.32645473e-01f, -2.74253935e-02f, 5.42843975e-02f, -1.35870963e-01f, -6.19859211e-02f, -6.97941706e-02f,
  -6.87380135e-02f, -2.50251263e-01f, 3.83908838e-01f, -2.46701300e-01f, -3.91423076e-01f, -1.57360792e-01f, 1.11601353e-01f, 1.62827268e-01f, 2.35925004e-01f, 3.02114040e-01f,
  1.19959451e-02f, -6.87071756e-02f, -4.51914640e-03f, -1.30518258e-01f, -4.44699675e-02f, 2.31177974e-02f, -1.34426802e-01f, 5.40831301e-04f, 1.49182215e-05f, 6.15221672e-02f,
  4.20031957e-02f, 5.16953021e-02f, 3.30947153e-02f, -4.44439240e-02f, 2.08439101e-02f, -5.93616627e-02f, -5.18948585e-02f, -9.96298939e-02f, -1.39928702e-02f, -7.33889863e-02f,
  -1.89308058e-02f, 3.70136462e-02f, 7.99375102e-02f, -1.36088263e-02f, -7.79514536e-02f, -2.18626354e-02f, -2.04124659e-01f, -1.49405867e-01f, 9.48787406e-02f, -1.49934581e-02f,
  -1.76744878e-01f, -4.19080518e-02f, -7.43365064e-02f, 8.90291333e-02f, 1.28885418e-01f, 2.44427305e-02f, 2.00032815e-02f, 3.89186200e-03f, -2.98534185e-01f, 6.53930902e-02f,
  2.55229861e-01f, 8.96959677e-02f, 2.15261262e-02f, 1.48052022e-01f, -2.90248375e-02f, 3.25347453e-01f, 4.40793037e-02f, -2.31587544e-01f, 1.39492363e-01f, -1.35397851e-01f,
  1.23317704e-01f, -8.30037594e-02f, -3.65747213e-02f, -6.22727945e-02f, 2.10645035e-01f, 1.51662618e-01f, -2.38004521e-01f, -1.31033093e-01f, -1.04371756e-02f, 3.30608189e-02f,
  1.44446179e-01f, 1.66227952e-01f, -1.39444351e-01f, 1.16484061e-01f, 7.09888479e-03f, -1.29806191e-01f, 6.38316870e-02f, -1.99351795e-02f, 8.95771459e-02f, -1.39060523e-02f,
  7.34797418e-02f, -2.76530217e-02f, -4.41871472e-02f, 4.48999135e-03f, -1.03053167e-01f, -1.35658830e-01f, 5.30827008e-02f, 5.55715002e-02f, 5.66285476e-02f, -2.99878828e-02f,
  1.85119687e-03f, -1.05646797e-01f, -4.99506369e-02f, -4.58614044e-02f, -1.71485513e-01f, -2.37880182e-02f, -2.76271999e-01f, -9.52222664e-03f, 3.86895016e-02f, 2.91382633e-02f,
  1.13945846e-02f, -6.80440888e-02f, -1.23211622e-01f, -1.14024714e-01f, 2.81441808e-01f, -1.20951734e-01f, -3.68271843e-02f, -1.21230766e-01f, -1.00865841e-01f, 1.13689646e-01f,
  -1.09162591e-01f, -3.81487794e-02f, -2.85316169e-01f, 1.51920542e-01f, 1.59640357e-01f, 1.58240229e-01f, 4.59416211e-02f, -2.51327038e-01f, -5.92503743e-03f, -2.99271494e-01f,
  4.11316305e-02f, -1.09000966e-01f, -3.14269476e-02f, -1.30169271e-02f, -1.31137565e-01f, -3.12700301e-01f, -1.33403942e-01f, -1.30320042e-01f, 2.86081910e-01f, 9.17032361e-02f,
  4.06352639e-01f, 6.63555190e-02f, -3.71222228e-01f, 1.09879129e-01f, 1.77020580e-01f, 1.77431658e-01f, 2.76326761e-02f, 1.43708408e-01f, 1.59513000e-02f, 1.84492506e-02f,
  4.06958275e-02f, -1.29061770e-02f, -4.05258164e-02f, 9.83093604e-02f, -3.35729718e-02f, 2.04852205e-02f, 6.70935214e-02f, 1.18824631e-01f, -1.51122583e-03f, 1.80897266e-01f,
  -9.86475218e-03f, -4.46979888e-02f, -3.28308083e-02f, -1.60103932e-01f, 5.02312519e-02f, 4.56331037e-02f, 8.53131118e-04f, 7.20470492e-03f, -3.14084888e-02f, 9.22743008e-02f,
  1.75494254e-01f, 7.27165565e-02f, 2.24506017e-03f, -1.93332747e-01f, 4.37401608e-02f, -3.99385914e-02f, -1.05818193e-02f, -5.37939258e-02f, -2.78813988e-02f, 1.48049267e-02f,
  1.24377765e-01f, 1.59924310e-02f, -5.58470264e-02f, -2.79479753e-02f, 8.96437094e-02f, -1.12939999e-01f, -9.28385481e-02f, -2.20080819e-02f, -1.21492058e-01f, 1.30974323e-01f,
  2.27872863e-01f, 1.04681008e-01f, -1.23542242e-01f, -3.28637749e-01f, 1.43283486e-01f, -3.63990217e-01f, 1.21041000e-01f, 2.34505255e-02f, -3.71964753e-01f, -3.95159334e-01f,
  1.41251400e-01f, -7.92677328e-02f, -7.42646903e-02f, 1.18138552e-01f, 1.83855727e-01f, -8.60133320e-02f, -7.65313432e-02f, 2.78684825e-01f, 2.01756477e-01f, -4.23700968e-03f,
  -4.62842593e-03f, -2.08163872e-01f, 7.55518675e-02f, -8.12838897e-02f, 2.02801842e-02f, -3.04091051e-02f, -5.46436682e-02f, 6.49572983e-02f, 3.66193876e-02f, -1.33028626e-01f,
  9.02929232e-02f, 4.62810211e-02f, 3.85146705e-03f, 9.68090817e-02f, 9.42059681e-02f, -8.81460309e-02f, -4.81896214e-02f, 8.51329565e-02f, 4.35173512e-02f, -1.21520735e-01f,
  -8.95028636e-02f, -4.33128551e-02f, -3.53351124e-02f, 1.39143720e-01f, -9.66361165e-02f, -9.54639763e-02f, 1.03668965e-01f, -1.84254646e-01f, 5.19207045e-02f, -2.32674748e-01f,
  9.72531959e-02f, -3.88897099e-02f, -6.78079426e-02f, -1.00602865e-01f, 1.51794776e-01f, -1.78584829e-02f, 1.34462520e-01f, -1.41259640e-01f, -6.42179623e-02f, -1.52857944e-01f,
  8.51490870e-02f, -7.38167465e-02f, 1.70714512e-01f, 1.87126115e-01f, -8.15931335e-02f, 1.14659779e-01f, -1.37065873e-01f, 4.01199847e-01f, -6.74466342e-02f, -2.90775388e-01f,
  -1.41036183e-01f, -1.16272964e-01f, -1.68876737e-01f, -2.20464975e-01f, 1.34701803e-01f, -6.63723350e-02f, 1.74632564e-01f, -1.09101109e-01f, -2.33981296e-01f, 1.92162529e-01f,
  1.05494477e-01f, -9.53695970e-04f, 3.60719562e-01f, 1.48569748e-01f, 7.86750838e-02f, -2.92273983e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.43416518e-01f, 1.10213928e-01f, 2.65355617e-01f, 2.36913189e-01f, 1.37709290e-01f, -2.57820878e-02f, 1.31339356e-01f, 8.73705000e-02f, 1.85675815e-01f, 1.31951243e-01f,
  3.09677243e-01f, 4.86604162e-02f, 1.70725077e-01f, 7.13366121e-02f, 1.26361951e-01f, 1.93136916e-01f, 2.89985035e-02f, 1.17849544e-01f, 1.44245103e-01f, 4.87473644e-02f,
  1.85937673e-01f, 2.28585396e-02f, -2.65266329e-01f, -1.01570979e-01f, -9.94151365e-03f, -3.76189463e-02f, -3.59070338e-02f, -1.79342225e-01f, 1.58960626e-01f, -1.73192114e-01f,
  1.16483308e-01f, -2.51837932e-02f, -5.84357381e-02f, -5.29353209e-02f, 7.61251198e-03f, 7.11758360e-02f, 1.25830919e-01f, -5.21681681e-02f, 2.16174424e-01f, 1.33417118e-02f,
  2.99184561e-01f, 4.57518905e-01f, 1.08503900e-01f, 2.78388672e-02f, 1.79540485e-01f, -4.62814629e-01f, -1.61341801e-01f, -9.29251611e-02f, 1.95647299e-01f, 1.37097925e-01f,
  1.64070085e-01f, 1.51312336e-01f, 2.50786960e-01f, -4.68995310e-02f, 2.45184228e-01f, 2.97083408e-01f, -1.26275957e-01f, 3.46236259e-01f, 2.08877698e-01f, 7.04218075e-02f,
  3.66603613e-01f, 1.63496852e-01f, -1.67065114e-01f, 3.65958691e-01f, 3.03737491e-01f, 1.89852104e-01f, -1.11274235e-02f, 4.42754440e-02f, -6.17468655e-02f, 7.06551224e-02f,
  4.20007035e-02f, 7.71221817e-02f, 1.51387244e-01f, 4.36664335e-02f, 1.97713792e-01f, 6.73291534e-02f, 6.67290464e-02f, 4.14933674e-02f, 5.07113859e-02f, 1.18729256e-01f,
  1.68864906e-01f, 7.05970079e-02f, 2.53798008e-01f, 1.64417922e-02f, 1.09915636e-01f, -7.93486983e-02f, -1.86070517e-01f, -1.15712672e-01f, -4.00783606e-02f, 2.20572695e-01f,
  -1.92961842e-01f, -1.32774860e-02f, 6.86666071e-02f, 1.44265056e-01f, -8.58812928e-02f, -3.88601585e-03f, -6.92485720e-02f, 1.34743437e-01f, 1.58421189e-01f, 1.12987002e-02f,
  7.50929415e-02f, 2.67756265e-02f, 1.17493100e-01f, -1.38452044e-02f, 2.95089990e-01f, -1.10428706e-02f, -1.16340250e-01f, -5.09876311e-01f, 2.13928238e-01f, -1.68566540e-01f,
  -7.36876205e-02f, 5.32413960e-01f, 2.40508080e-01f, -6.97138757e-02f, 6.56828105e-01f, 5.72004259e-01f, 5.50300442e-02f, 2.68174142e-01f, 4.97403778e-02f, 4.88243222e-01f,
  -3.37311655e-01f, 4.87656146e-01f, 4.70739752e-01f, 7.49346986e-03f, -4.25553322e-01f, 3.66453291e-03f, -1.98362336e-01f, 6.99361801e-01f, -1.54698193e-02f, -5.72022498e-02f,
  2.04680134e-02f, 7.97388777e-02f, -1.69587299e-01f, 2.36959398e-01f, -5.32355793e-02f, 7.59869302e-03f, 1.18500978e-01f, 1.95267186e-01f, 4.56497967e-02f, 3.49934876e-01f,
  7.94686750e-02f, 2.40828027e-03f, 4.38465811e-02f, 3.05071622e-02f, 7.85062388e-02f, 9.57402736e-02f, 3.02030984e-02f, -4.96760271e-02f, -1.82813182e-01f, -1.27863154e-01f,
  -6.30410314e-02f, -9.68670174e-02f, 4.02763098e-01f, 1.11582421e-01f, 1.26222059e-01f, -1.88578591e-01f, 3.43215346e-01f, -1.62596870e-02f, -8.27006772e-02f, -2.98793111e-02f,
  4.19425637e-01f, -5.92796393e-02f, -4.69004139e-02f, -1.01280138e-01f, -1.37099624e-01f, -3.12654436e-01f, 1.23066746e-01f, 9.91163850e-02f, 2.05056876e-01f, -1.48245037e-01f,
  -2.30930522e-01f, 2.32792169e-01f, 7.00771436e-02f, 4.90349084e-01f, 1.77247450e-01f, 1.23887077e-01f, -3.93562794e-01f, 2.94953231e-02f, -2.76622772e-01f, -1.48317024e-01f,
  -3.27392489e-01f, 7.91786015e-02f, 5.19965827e-01f, 5.64637333e-02f, 5.68812480e-03f, 3.69455695e-01f, -4.29212064e-01f, 2.61690557e-01f, -9.04695019e-02f, 4.62188482e-01f,
  -4.74553965e-02f, -1.66496545e-01f, 1.75418660e-01f, 5.32265864e-02f, 1.80627089e-02f, 2.24335015e-01f, 1.53856382e-01f, 1.77735001e-01f, 1.33225366e-01f, 5.19967675e-02f,
  1.09133467e-01f, 1.57596216e-01f, 2.35203281e-01f, -1.49002358e-01f, 1.10392474e-01f, 2.21856058e-01f, 1.46457791e-01f, 1.04075432e-01f, 1.35677099e-01f, 1.45415753e-01f,
  7.62846172e-02f, -1.35488123e-01f, 2.77144631e-04f, 1.92738786e-01f, -1.88449070e-01f, -1.27365723e-01f, 2.05932006e-01f, 1.85251310e-01f, -1.76020324e-01f, 3.06963492e-02f,
  -1.41570315e-01f, 1.57741114e-01f, -8.44959617e-02f, 1.29934043e-01f, -1.43086031e-01f, 2.42601875e-02f, -3.42440009e-01f, 9.51347351e-02f, -3.02806169e-01f, 1.02502920e-01f,
  -7.47634709e-01f, 9.28348005e-02f, 3.02772105e-01f, 3.11525017e-01f, 1.63251255e-02f, -1.90711752e-01f, 2.08652824e-01f, 8.22924916e-03f, -1.18839756e-01f, 4.36770141e-01f,
  7.96463341e-02f, -1.23467952e-01f, -2.24977463e-01f, 3.98756973e-02f, 2.24392235e-01f, 1.17810741e-01f, 1.31961927e-02f, 5.79356015e-01f, -3.25111523e-02f, 6.24774694e-01f,
  1.19465001e-01f, -1.67756632e-01f, 8.14300701e-02f, -2.83195898e-02f, 2.12993667e-01f, -7.59764686e-02f, 9.30402577e-02f, 2.04238325e-01f, 2.03348845e-01f, 1.35843694e-01f,
  1.50599509e-01f, 2.54262298e-01f, 9.63254198e-02f, 1.17168009e-01f, 2.23263308e-01f, 1.89428553e-01f, 1.51096076e-01f, 5.35192788e-02f, 1.14483260e-01f, 1.84352681e-01f,
  9.84087065e-02f, 8.81456807e-02f, 2.04869032e-01f, 2.13229582e-01f, 4.22758944e-02f, 1.00788325e-01f, 4.70458493e-02f, 3.22127879e-01f, -6.15015998e-02f, 1.98244065e-01f,
  -1.63405433e-01f, -1.91485122e-01f, 3.91287543e-02f, 1.56668499e-02f, -1.47280782e-01f, -4.57377583e-01f, 2.14038387e-01f, -4.58562896e-02f, -7.08839390e-03f, -1.80060267e-01f,
  -4.73314784e-02f, 1.58161163e-01f, 1.67823642e-01f, 1.29025802e-01f, 2.50204921e-01f, 1.44160450e-01f, 3.81366946e-02f, 5.74538648e-01f, 2.52947897e-01f, 1.50769338e-01f,
  -2.66701579e-02f, -3.92961055e-01f, 1.70553550e-01f, -3.51485074e-01f, -3.26425396e-02f, -3.08616161e-02f, -1.51184961e-01f, -2.03036308e-01f, 1.62076175e-01f, -4.16804790e-01f,
  2.73982823e-01f, -2.84146369e-02f, 8.84614348e-01f, -2.02298254e-01f, -3.38136345e-01f, -1.75410867e-01f, 5.26188850e-01f, 1.92630515e-01f, 1.62690893e-01f, 1.09386079e-01f,
  1.88274249e-01f, 1.01099402e-01f, 1.42019376e-01f, -5.68441674e-03f, 4.50050607e-02f, 5.13535812e-02f, -2.52296980e-02f, 7.19533488e-02f, 1.80009022e-01f, 7.46125206e-02f,
  1.93135291e-01f, 2.10622966e-01f, 4.11232375e-03f, 2.21856207e-01f, 1.19207174e-01f, 4.92194742e-02f, 1.06341623e-01f, 1.67886451e-01f, -1.05494484e-01f, -1.60886705e-01f,
  2.58455686e-02f, 1.91907212e-01f, -8.75465572e-03f, -5.37852719e-02f, 1.19021915e-01f, -1.31870573e-02f, -1.80281997e-01f, -2.68798351e-01f, -1.11008108e-01f, -3.92279737e-02f,
  -2.03296036e-01f, 1.30457506e-01f, -1.14484746e-02f, -5.97835239e-03f, 7.93878883e-02f, -1.33797213e-01f, -9.09754708e-02f, -1.36706769e-01f, -1.64187104e-01f, -8.28213990e-02f,
  6.38180748e-02f, 5.85195981e-02f, -1.25040978e-01f, 2.28500664e-01f, -1.48324177e-01f, 7.18460143e-01f, 1.61983430e-01f, -1.10988738e-02f, -1.95715457e-01f, -1.26035631e-01f,
  6.03830293e-02f, -2.78647840e-01f, 2.44821995e-01f, 4.27023582e-02f, 1.04675271e-01f, -8.42771903e-02f, -5.41232377e-02f, 5.52402675e-01f, 3.30609232e-01f, 2.17260569e-01f,
  5.73178887e-01f, 1.27265900e-01f, 5.55404246e-01f, -2.91262299e-01f, 1.12147994e-01f, -1.25074908e-01f, 2.72956520e-01f, -1.84610039e-01f, -1.25240535e-01f, 1.55990779e-01f,
  -8.39436501e-02f, -3.18966694e-02f, -3.98164578e-02f, -7.21988082e-02f, 1.10183463e-01f, 4.39227074e-02f, 2.42545945e-03f, 1.34383708e-01f, -5.56221381e-02f, -1.13090947e-01f,
  2.87858360e-02f, -1.75656691e-01f, -5.15493937e-03f, 7.78152570e-02f, -6.08552173e-02f, 1.73139852e-02f, -2.01251671e-01f, 3.43222059e-02f, -1.17889792e-01f, 1.66935682e-01f,
  -8.70757848e-02f, -3.17420453e-01f, 4.34747674e-02f, 2.75265992e-01f, 1.61558520e-02f, 5.13818786e-02f, -1.23286270e-01f, 1.91321462e-01f, 1.83455437e-01f, -7.89115354e-02f,
  2.94947475e-01f, -1.37940124e-01f, 1.02689639e-01f, -3.15411538e-01f, 4.63605747e-02f, -2.97860503e-01f, 1.72390223e-01f, -1.61019832e-01f, 4.75744419e-02f, -1.06454201e-01f,
  4.86101732e-02f, -2.46546909e-01f, 6.16337396e-02f, 5.06301336e-02f, 1.49295986e-01f, -1.29032433e-01f, 4.06252481e-02f, 1.31288283e-02f, 2.40489006e-01f, 1.34412989e-01f,
  6.31579459e-02f, 3.98052394e-01f, 4.22984809e-01f, 2.61313260e-01f, 1.64644301e-01f, 3.78058292e-02f, 1.17389858e-01f, 2.84132034e-01f, 2.88010091e-01f, 6.89096525e-02f,
  -5.23316935e-02f, 8.74069110e-02f, -8.01991299e-02f, 5.68470806e-02f, 1.40492246e-01f, 5.72871268e-02f, -6.28506811e-03f, 1.79667734e-02f, 1.43865913e-01f, 3.06887150e-01f,
  -1.37984201e-01f, 1.41590834e-01f, -6.68079033e-02f, 5.72031662e-02f, 7.68766254e-02f, 4.45208609e-01f, 2.75843292e-01f, 7.37164170e-02f, 2.28053167e-01f, 2.07109898e-01f,
  4.21906888e-01f, -1.44051481e-02f, 7.43569434e-02f, -1.29562512e-01f, -1.18442075e-02f, 2.80388683e-01f, -2.05408499e-01f, -1.44827783e-01f, -2.56469965e-01f, 3.51799011e-01f,
  -2.28205305e-02f, -2.03236248e-02f, -1.09690093e-01f, 4.54644077e-02f, -2.40440860e-01f, 2.01456755e-01f, 1.94733188e-01f, 5.62564582e-02f, 1.55692607e-01f, 1.76967561e-01f,
  -9.60473567e-02f, 1.63438227e-02f, -7.19034150e-02f, 2.85185069e-01f, -2.70331562e-01f, 5.64741969e-01f, 1.56051561e-01f, -1.50475979e-01f, 1.95228010e-01f, 2.76416708e-02f,
  -4.12121266e-02f, -1.48065522e-01f, -3.80481094e-01f, -2.81141132e-01f, 1.90568045e-01f, 3.16052604e-03f, -2.92076707e-01f, -9.64384992e-03f, 3.36354487e-02f, 2.76380718e-01f,
  5.72303772e-01f, -1.49368286e-01f, 2.98699643e-02f, -8.73917863e-02f, 2.25290298e-01f, 8.64116624e-02f, -2.59414446e-02f, 9.81931016e-02f, -1.27784712e-02f, -3.71667519e-02f,
  1.95399135e-01f, -8.05984437e-03f, 9.21277478e-02f, 1.62968442e-01f, 4.94382866e-02f, 2.96103619e-02f, 1.28045022e-01f, 3.29920165e-02f, 3.03534895e-01f, -4.00206074e-02f,
  5.50370999e-02f, 1.24751516e-01f, -1.82078496e-01f, -1.10555671e-01f, -2.47889474e-01f, 1.46885067e-01f, 3.05792522e-02f, 1.37549132e-01f, 1.94998235e-02f, -2.09585577e-01f,
  2.28585050e-01f, -2.33083479e-02f, 2.08336651e-01f, -1.50041744e-01f, -4.44331504e-02f, -1.26122804e-02f, 1.71094984e-01f, -3.36201549e-01f, 3.09293717e-01f, -5.01472771e-01f,
  5.17518163e-01f, 5.18565327e-02f, 3.25795822e-02f, -1.62201766e-02f, 2.63574570e-02f, 7.15474039e-02f, 1.85162783e-01f, -3.50490659e-02f, -9.66177508e-02f, -5.04467249e-01f,
  -4.32718694e-01f, -7.48216361e-02f, 6.34620190e-02f, 1.30472153e-01f, -3.38181108e-01f, 8.07878450e-02f, 3.12754989e-01f, 2.17476904e-01f, -1.11657985e-01f, 4.72879298e-02f,
  2.06604585e-01f, 1.01308867e-01f, 1.66107103e-01f, 3.94089043e-01f, -2.21576974e-01f, 3.78212094e-01f, 3.03896442e-02f, 1.26009762e-01f, 7.49432445e-02f, 1.04725711e-01f,
  4.69217449e-03f, 2.90786773e-02f, 9.77607220e-02f, 1.28896683e-01f, 1.78038657e-01f, 2.63437778e-01f, -1.40913367e-01f, -1.93192381e-02f, 4.40114364e-02f, -6.31245524e-02f,
  6.00930266e-02f, 4.28588614e-02f, 4.92564104e-02f, 1.07767414e-02f, 7.25467429e-02f, 4.59937155e-02f, -2.10011512e-01f, -4.17164229e-02f, -1.11681618e-01f, -5.44041283e-02f,
  8.98487642e-02f, -4.36259508e-02f, 2.63000596e-02f, 6.56437650e-02f, 1.35562494e-01f, 3.36398721e-01f, 9.02233087e-03f, -3.40539888e-02f, 1.76214367e-01f, -4.24995460e-02f,
  -2.19680458e-01f, -1.24648392e-01f, -3.00209463e-01f, -9.38877314e-02f, -1.53410316e-01f, 7.42933452e-02f, 1.34582818e-01f, -8.80092904e-02f, 1.05145976e-01f, -7.26975575e-02f,
  -7.88008273e-02f, 5.78750730e-01f, 5.66552393e-02f, 3.01479310e-01f, 2.34018639e-03f, 2.37010688e-01f, -2.17141151e-01f, 1.57055676e-01f, -2.20228702e-01f, 2.59777129e-01f,
  2.44228005e-01f, 3.73948216e-01f, -2.31071547e-01f, 1.14255577e-01f, -1.53136939e-01f, 1.99353442e-01f, -4.96676773e-01f, 3.37533414e-01f, 5.85771948e-02f, 1.25974342e-01f,
  1.92179814e-01f, -7.13295788e-02f, 1.15701556e-01f, 5.49901575e-02f, -1.65507928e-01f, 6.85605109e-02f, 8.67104232e-02f, 9.50976312e-02f, 3.96321006e-02f, -4.40181419e-02f,
  -3.69502418e-02f, 2.05013797e-01f, -6.12295524e-04f, 1.48090065e-01f, -5.84391356e-02f, 1.00458995e-01f, 2.66591720e-02f, 2.27654859e-01f, 9.64400992e-02f, 1.93648692e-02f,
  -9.19220224e-02f, 5.31959254e-03f, 7.99236968e-02f, -1.19835241e-02f, -2.32841261e-02f, -6.98638987e-03f, -3.65171060e-02f, -1.12385333e-01f, 6.38294779e-03f, 1.90954749e-02f,
  -1.45325482e-01f, 4.97046560e-02f, -9.65588726e-03f, 1.75734442e-02f, 1.54235542e-01f, 4.95175011e-02f, 2.63689607e-02f, -8.42971262e-03f, -3.02007981e-02f, 3.19488376e-01f,
  2.03531682e-01f, 1.39459133e-01f, -3.08112260e-02f, 2.82912195e-01f, 3.38017225e-01f, -2.99271196e-01f, -1.31076559e-01f, 1.88598588e-01f, 5.78935668e-02f, 2.18591038e-02f,
  3.19724172e-01f, 2.05293670e-01f, 1.33576453e-01f, 3.38795215e-01f, 3.86957116e-02f, -8.04109424e-02f, -2.08632976e-01f, -1.21846899e-01f, -1.81426287e-01f, 3.03508788e-01f,
  3.68875086e-01f, 3.58966053e-01f, -1.94072843e-01f, 1.24039099e-01f, 1.93398312e-01f, 1.47732869e-01f, 1.42019436e-01f, 2.19526291e-01f, -3.96226197e-02f, 1.48188651e-01f,
  2.93281525e-01f, 3.13456804e-01f, 3.80931632e-03f, 1.18194103e-01f, -3.01052146e-02f, 2.05978096e-01f, 3.84611599e-02f, 1.72955543e-01f, 1.53125316e-01f, -4.93300147e-03f,
  -3.26495059e-02f, 4.03241329e-02f, 1.03053026e-01f, 3.85566726e-02f, -6.73455447e-02f, -1.06713846e-01f, 6.88189864e-02f, 1.08696751e-01f, -1.90299988e-01f, 2.60511767e-02f,
  -1.96820423e-01f, 3.12168926e-01f, 8.51594955e-02f, 2.94317991e-01f, -6.93370849e-02f, 9.97943431e-02f, -1.03362590e-01f, -6.43282384e-02f, -3.88176516e-02f, 7.79735446e-02f,
  -3.07584733e-01f, 3.55695873e-01f, 2.78161727e-02f, -2.49458656e-01f, 1.75307319e-01f, -3.31908673e-01f, -2.32500985e-01f, -1.12800814e-01f, -2.90042520e-01f, 6.18119121e-01f,
  2.94314176e-01f, 2.01634452e-01f, 2.61597246e-01f, -2.33017698e-01f, 3.51124465e-01f, 4.61385578e-01f, -1.27042428e-01f, -1.29637867e-01f, -5.12298308e-02f, 5.12511171e-02f,
  3.88056785e-01f, -3.13480228e-01f, -1.15600385e-01f, 5.92134781e-02f, -3.09794098e-01f, 1.58320025e-01f, 4.54659909e-01f, 5.03348768e-01f, 6.93139732e-02f, -7.86572248e-02f,
  1.95973083e-01f, -3.60353012e-03f, -1.35031313e-01f, 1.21452667e-01f, 1.31370783e-01f, -1.05559919e-02f, 1.81079373e-01f, 1.19604692e-01f, 7.09411427e-02f, -2.60650516e-02f,
  2.96143174e-01f, -1.22239790e-03f, 1.36485159e-01f, 2.52994567e-01f, 1.54307246e-01f, 9.66801122e-02f, 1.84263170e-01f, -6.72770888e-02f, -2.18710959e-01f, -1.95340753e-01f,
  -5.08780122e-01f, -2.02816904e-01f, 2.41543174e-01f, -1.31486785e-02f, -3.46557833e-02f, -7.45410547e-02f, 2.46449411e-01f, -2.43244600e-02f, -7.55165890e-02f, -4.04601078e-03f,
  3.76784325e-01f, -3.87675464e-02f, -2.41366178e-01f, -3.97718884e-02f, -2.15473637e-01f, -1.22898914e-01f, -4.55984354e-01f, -1.42745271e-01f, 3.07511598e-01f, 3.85805815e-02f,
  -1.44975513e-01f, 1.23162180e-01f, 1.23134017e-01f, 1.69276342e-01f, -1.66730620e-02f, 1.74867764e-01f, -3.22802573e-01f, 1.77131981e-01f, -1.09890901e-01f, -3.43770050e-02f,
  -4.02182221e-01f, 7.09915757e-02f, 7.36043930e-01f, 5.70004404e-01f, -2.03314563e-03f, 5.52703857e-01f, -3.87921691e-01f, 1.01269417e-01f, -8.99004936e-02f, 3.92852962e-01f,
  -1.45373940e-01f, 1.90595791e-01f, 3.69540113e-03f, 1.39015287e-01f, 2.06221044e-02f, 2.42506385e-01f, 6.55571818e-02f, 2.56713331e-01f, 1.23458114e-02f, 3.35817337e-02f,
  8.29561278e-02f, 2.87637830e-01f, 4.77899164e-02f, 8.75308737e-02f, 1.43468678e-01f, -4.07034643e-02f, 5.61449453e-02f, -2.01469306e-02f, 1.47087485e-01f, 2.08421499e-02f,
  3.71456631e-02f, 5.89863472e-02f, -1.12912670e-01f, -6.39486834e-02f, -4.34217639e-02f, 1.98288560e-01f, -1.11522295e-01f, 1.08704912e-02f, -3.43935750e-02f, 1.94305271e-01f,
  1.01132631e-01f, -9.33436677e-02f, 3.01834196e-01f, -1.34229690e-01f, -1.16732791e-01f, -2.15675771e-01f, -2.42874324e-01f, 5.66558614e-02f, -4.49184701e-02f, 5.11183143e-02f,
  1.50594771e-01f, 4.06785995e-01f, -1.75572693e-01f, -1.71938121e-01f, 3.14326375e-03f, 2.86105294e-02f, 3.15234423e-01f, -2.81864017e-01f, 2.63293087e-01f, 1.52867392e-01f,
  -6.78783730e-02f, -7.78941438e-03f, -2.04407215e-01f, 3.14378679e-01f, -5.69941849e-03f, 1.31226152e-01f, -6.85635433e-02f, 4.75125372e-01f, 6.86954677e-01f, -2.05335245e-01f,
  1.69601798e-01f, 7.52406344e-02f, -2.10730806e-01f, -1.59337327e-01f, -2.65552789e-01f, 9.45792571e-02f, 8.41051638e-02f, 1.77309558e-01f, 2.25573123e-01f, 2.77400374e-01f,
  2.21355751e-01f, 3.72235142e-02f, 1.19897693e-01f, 1.17544152e-01f, 1.14233434e-01f, 1.20027140e-01f, 1.17010295e-01f, 1.79103822e-01f, 1.27769679e-01f, 1.23601228e-01f,
  1.94874838e-01f, 1.70745477e-01f, 1.56814620e-01f, 4.52289246e-02f, 4.15657535e-02f, -1.31939584e-02f, -1.66110191e-02f, -1.96060091e-01f, 1.88235775e-01f, -9.23023894e-02f,
  -3.85388955e-02f, 1.48944944e-01f, -1.25136256e-01f, 1.19572647e-01f, 6.97464496e-02f, 2.17266083e-01f, -1.31163048e-04f, -1.10942952e-01f, -1.32839054e-01f, 6.58681542e-02f,
  6.21781684e-03f, 7.39847049e-02f, -1.72768489e-01f, -4.92379852e-02f, 9.36355442e-02f, 1.99600145e-01f, 1.04706109e-01f, -2.82763857e-02f, 8.98729563e-02f, -2.44439915e-01f,
  -5.91942728e-01f, 4.54547644e-01f, -2.11638004e-01f, 3.82631898e-01f, 5.98716557e-01f, 7.70766959e-02f, 3.88282239e-01f, 3.67680639e-01f, -9.10023693e-04f, -2.40370944e-01f,
  1.66391775e-01f, -3.39745395e-02f, 4.02589217e-02f, 4.48138081e-02f, 2.92269796e-01f, 4.41374362e-01f, 1.66367561e-01f, 2.49289885e-01f, -4.15010303e-01f, 2.58585989e-01f,
  1.12450711e-01f, 3.05871218e-01f, 4.65363190e-02f, 1.49770126e-01f, 3.30366232e-02f, 1.63702071e-01f, 7.34072775e-02f, 2.51068860e-01f, 1.35019675e-01f, 1.84054166e-01f,
  1.31370313e-02f, 2.51621217e-01f, 1.11953534e-01f, 1.44156426e-01f, -2.20478643e-02f, 8.13054889e-02f, -1.45057729e-02f, 1.65027902e-01f, 2.55727116e-03f, -1.47334477e-02f,
  1.03726044e-01f, 1.02512017e-01f, 4.66584675e-02f, -8.87305886e-02f, 2.84673303e-01f, -1.54053286e-01f, 1.12556830e-01f, -2.08873991e-02f, -6.21556044e-02f, 2.38781273e-02f,
  -3.33651185e-01f, -1.78257469e-02f, 1.97632074e-01f, -1.43671766e-01f, 2.15019342e-02f, -2.28753313e-01f, -8.91304687e-02f, 1.09239516e-03f, 2.14792147e-01f, -1.40148640e-01f,
  -1.48115039e-01f, 1.76502392e-01f, -7.41863176e-02f, 1.87635154e-01f, -1.48942679e-01f, 6.02598548e-01f, 5.55390539e-03f, 6.43027499e-02f, -2.76514381e-01f, 1.25848264e-01f,
  -7.42029399e-03f, 1.54207961e-03f, 3.96862715e-01f, -1.16410799e-01f, 1.29459901e-02f, -3.08973730e-01f, 2.28827372e-02f, 4.24198717e-01f, 2.11780012e-01f, 1.72331184e-01f,
  1.53816685e-01f, -1.29307270e-01f, 4.19722766e-01f, -3.04254562e-01f, 1.38085783e-01f, 6.01338074e-02f, 2.12880477e-01f, 1.25755548e-01f, 8.91698599e-02f, 1.82452183e-02f,
  1.86565563e-01f, 6.90069571e-02f, 5.24195051e-03f, 1.04935944e-01f, -7.20082745e-02f, 1.53528690e-01f, 9.22784880e-02f, 3.15621272e-02f, -3.82232144e-02f, 1.23103224e-01f,
  4.96669188e-02f, 1.11025229e-01f, 1.35748446e-01f, 1.61364391e-01f, 1.65557086e-01f, 1.32581368e-01f, 8.90388936e-02f, 1.38021931e-01f, 2.42824078e-01f, -9.72798169e-02f,
  2.14000776e-01f, -3.84555501e-03f, -1.78398296e-01f, 1.04769856e-01f, -1.37583315e-01f, 1.48057371e-01f, 2.98676968e-01f, -2.45540202e-01f, 1.37778491e-01f, -3.13876867e-01f,
  1.94250107e-01f, 1.69781297e-01f, 8.21251512e-01f, -1.31814301e-01f, -3.22346717e-01f, 1.19695002e-02f, -1.04706381e-02f, 3.90150219e-01f, 2.15848193e-01f, 4.58532333e-01f,
  -1.62375227e-01f, -3.42800349e-01f, -3.55580002e-01f, 1.32954359e-01f, -3.42474788e-01f, 1.89474925e-01f, 1.21636584e-01f, 6.08686581e-02f, 4.33813557e-02f, -2.68507689e-01f,
  -7.71724582e-02f, 5.29612936e-02f, -2.39301403e-03f, 1.15313567e-01f, 2.52371252e-01f, -1.01681296e-02f, 3.47899318e-01f, -2.34221101e-01f, 5.27764969e-02f, 1.47939518e-01f,
  7.54640549e-02f, 2.13987485e-01f, 2.12218523e-01f, 9.76806358e-02f, -2.54809018e-02f, -1.42060863e-02f, 8.48274082e-02f, 3.54023390e-02f, -3.22211117e-01f, 3.16251993e-01f,
  1.64072916e-01f, -9.56423115e-03f, 1.26697183e-01f, -1.20293896e-03f, 2.27876499e-01f, 2.84579426e-01f, -4.79859002e-02f, 8.21240097e-02f, -2.05424786e-01f, -1.81265116e-01f,
  1.95925698e-01f, 4.38494273e-02f, -4.84939441e-02f, -2.31294870e-01f, 1.99940413e-01f, 5.45343831e-02f, 2.14214608e-01f, -1.16237730e-01f, -1.75528765e-01f, -6.68756440e-02f,
  -1.21302448e-01f, -1.37583748e-01f, 1.84537455e-01f, -2.08119810e-01f, 1.49541467e-01f, -3.62154245e-01f, 5.04067123e-01f, 1.57417312e-01f, -1.84534803e-01f, -2.77253538e-01f,
  -1.68482184e-01f, 1.51727170e-01f, 6.20123930e-02f, 4.33804691e-01f, 1.33158907e-01f, -4.64977622e-01f, -2.51734018e-01f, -3.68823446e-02f, 8.17316622e-02f, 8.31563547e-02f,
  1.97886676e-01f, 9.43512321e-02f, -1.09571002e-01f, -9.28948820e-03f, 5.54466724e-01f, -5.28560281e-01f, 4.53336418e-01f, 4.64370906e-01f, 3.61671507e-01f, -7.33716935e-02f,
  4.01924700e-01f, -1.04067236e-01f, 9.76958871e-02f, 5.53414114e-02f, 3.88138331e-02f, 3.26802582e-02f, 1.64451927e-01f, 4.45671082e-02f, 9.10230279e-02f, 1.37267336e-01f,
  7.63807371e-02f, 1.01481654e-01f, 2.66656101e-01f, -3.87050733e-02f, 7.67440796e-02f, 1.25163002e-02f, -8.60412046e-02f, 4.23514023e-02f, 8.15088600e-02f, 1.26834348e-01f,
  2.31736094e-01f, -2.17873335e-01f, 7.25973696e-02f, 1.39562950e-01f, 1.78029522e-01f, 4.66910377e-02f, -5.54312468e-02f, 1.00207059e-02f, -1.61195308e-01f, -1.66652292e-01f,
  -2.24237755e-01f, 2.70895958e-02f, -2.55543351e-01f, 3.83692211e-03f, -3.47573794e-02f, 1.21741369e-01f, 1.41350240e-01f, -8.38338397e-03f, -1.03841722e-01f, 1.05463684e-01f,
  -3.13206971e-01f, 8.63470696e-03f, 2.31672436e-01f, 4.96409893e-01f, 1.44633859e-01f, 1.26691505e-01f, 1.72669694e-01f, -2.43382290e-01f, -3.44489604e-01f, 2.97232538e-01f,
  2.10049655e-02f, -4.73452769e-02f, -4.29459140e-02f, -2.27171049e-01f, 4.51750726e-01f, 6.55616671e-02f, 2.51478958e-03f, -6.40238449e-02f, -7.61908144e-02f, 4.13401067e-01f,
  7.37168342e-02f, 1.10718538e-04f, 4.24147040e-01f, 4.68176901e-02f, 2.07506552e-01f, -4.01355684e-01f, -1.34743750e-02f, -1.33933797e-01f, 7.40684345e-02f, 1.36613071e-01f,
  1.53283197e-02f, 2.31676534e-01f, -7.92714059e-02f, 1.80777863e-01f, -8.94289985e-02f, 1.16708934e-01f, -8.69525596e-02f, 1.31307393e-01f, 5.30944504e-02f, -6.54119179e-02f,
  -7.23240077e-02f, 1.49578191e-02f, 1.17593065e-01f, 2.00872764e-01f, 1.46872565e-01f, -3.40609178e-02f, -1.22669190e-01f, 1.23980613e-02f, -1.62612841e-01f, 1.79265037e-01f,
  1.75671667e-01f, -3.51862684e-02f, -2.26229918e-03f, -3.73442546e-02f, -1.32438585e-01f, -7.66050518e-02f, -1.08185619e-01f, 1.58160612e-01f, 1.15395039e-01f, -1.56100020e-01f,
  -1.82592198e-01f, -6.94543645e-02f, -7.34043121e-02f, 1.64214112e-02f, 1.30317183e-02f, 6.60047159e-02f, -8.18282664e-02f, -8.19916576e-02f, 1.41445205e-01f, 9.29877087e-02f,
  2.95852005e-01f, 4.89160717e-02f, 2.24297866e-03f, 1.71210822e-02f, -2.20141426e-01f, 1.26706079e-01f, -1.87149137e-01f, -3.90090078e-01f, -7.69641250e-02f, 3.28368515e-01f,
  1.11735001e-01f, 1.47453010e-01f, 1.40370533e-01f, 3.82185578e-01f, 2.37222344e-01f, 1.43573210e-01f, 6.08296581e-02f, 1.49370000e-01f, 3.47463816e-01f, -3.46367896e-01f,
  -1.72940530e-02f, 2.22367197e-01f, 2.41085943e-02f, 6.84807301e-02f, 3.46098170e-02f, 1.91958055e-01f, 2.36552581e-01f, 8.72016475e-02f, 2.07062706e-01f, 1.03073224e-01f,
  1.20173246e-02f, 1.38707846e-01f, 1.39132112e-01f, 5.84664457e-02f, 2.37574819e-02f, 3.53090763e-02f, 1.98511392e-01f, 2.42572546e-01f, 2.52034694e-01f, -2.03859866e-01f,
  -1.06248073e-01f, 8.07628781e-02f, 1.67838469e-01f, -5.44333830e-02f, 3.28641906e-02f, -1.22170616e-02f, -1.92311600e-01f, -6.24597371e-02f, 1.85965419e-01f, 1.24208815e-02f,
  1.66917108e-02f, -1.45200551e-01f, 7.47608840e-02f, 1.92696869e-01f, -8.63673538e-03f, 1.44187808e-01f, -2.82848537e-01f, -8.37151334e-02f, 4.18112390e-02f, 3.00552785e-01f,
  1.96038663e-01f, 3.73898074e-02f, -8.74922276e-02f, 1.30847856e-01f, -1.54855862e-01f, 2.78311670e-01f, 6.50684312e-02f, 3.76946300e-01f, 3.98094691e-02f, 1.29319236e-01f,
  9.07412395e-02f, 1.53508306e-01f, -2.49949738e-01f, 5.43129966e-02f, -1.28921896e-01f, 8.59785378e-02f, 1.29027799e-01f, -3.79725605e-01f, -2.40688130e-01f, 1.49213165e-01f,
  -2.46332139e-02f, 2.65832990e-01f, -2.45967850e-01f, -2.21680358e-01f, 1.00844488e-01f, 9.00759026e-02f, 1.15818381e-01f, -1.48540838e-02f, -5.48452325e-02f, 5.24137653e-02f,
  -3.90021354e-02f, 1.97939035e-02f, 5.97245544e-02f, -7.88680613e-02f, 1.08750314e-01f, -2.22531818e-02f, 1.00524023e-01f, 2.36971881e-02f, -1.23720296e-01f, 6.57819510e-02f,
  -9.71747562e-02f, 7.77273327e-02f, 6.69195279e-02f, -9.24371332e-02f, 8.59688818e-02f, 9.85906497e-02f, -3.15518603e-02f, 9.48759094e-02f, -1.72546285e-03f, -2.34589074e-02f,
  -9.94662475e-03f, -3.75887975e-02f, -1.03006624e-01f, 1.36463031e-01f, -1.30832925e-01f, 1.77686319e-01f, -4.83979993e-02f, 3.50001752e-02f, 1.10341897e-02f, 5.33251651e-03f,
  -3.56904380e-02f, 1.67533562e-01f, -4.49446589e-01f, -1.94926202e-01f, 2.79419184e-01f, 5.93172014e-02f, 1.51526034e-01f, 2.32459038e-01f, 2.91671306e-01f, -5.02613127e-01f,
  -5.22571281e-02f, 2.39204213e-01f, -3.25539522e-02f, 2.86338538e-01f, -5.11073656e-02f, -1.96862981e-01f, 2.06537679e-01f, 2.57394552e-01f, 2.45547935e-01f, 1.17575966e-01f,
  -4.35397089e-01f, 6.82238400e-01f, 1.45873785e-01f, 1.05463162e-01f, -1.83750108e-01f, -1.06238239e-01f, -8.31332356e-02f, -6.82524592e-02f, -1.19691014e-01f, 1.40892297e-01f,
  2.39609867e-01f, 1.44189134e-01f, -5.14611192e-02f, 1.74846679e-01f, 9.40534398e-02f, -9.31097753e-03f, 1.76874936e-01f, 2.46349514e-01f, 2.68940657e-01f, 1.04040623e-01f,
  3.17601383e-01f, 6.59623519e-02f, 5.79554960e-02f, 3.18888396e-01f, 2.06944540e-01f, 1.54848769e-02f, 1.29296884e-01f, 2.78154284e-01f, 7.65269324e-02f, -1.01238519e-01f,
  -3.89148861e-01f, 1.08314946e-01f, 1.49500936e-01f, -5.09744100e-02f, 1.78099498e-01f, -2.94380248e-01f, -1.22971023e-02f, -4.22411501e-01f, 2.17396796e-01f, 1.21489041e-01f,
  9.00552422e-02f, -1.25412315e-01f, 9.47179571e-02f, 1.14523107e-03f, 2.29104891e-01f, -3.38607341e-01f, 5.82881510e-01f, 1.62072301e-01f, 2.91562647e-01f, 3.97999197e-01f,
  -3.10469031e-01f, 1.18966945e-01f, 1.38675883e-01f, 2.90285656e-03f, -7.88806230e-02f, 1.17867142e-02f, -5.61534703e-01f, 2.40833715e-01f, -5.85560389e-02f, -6.58112988e-02f,
  -5.64796150e-01f, 8.77962559e-02f, 3.91161025e-01f, -2.69702226e-01f, 1.17730394e-01f, 4.78868902e-01f, -3.32336247e-01f, 1.53019696e-01f, 7.65639246e-02f, 2.44112551e-01f,
  -2.68831164e-01f, 1.97899908e-01f, 1.07910477e-01f, 5.67648634e-02f, 6.83569312e-02f, 8.15716982e-02f, 3.64216685e-01f, 2.48251215e-01f, 8.25824067e-02f, 5.41605316e-02f,
  6.01595305e-02f, 4.26355563e-02f, 8.06150287e-02f, 1.58648744e-01f, 2.73569286e-01f, 2.55538255e-01f, 1.79685399e-01f, 7.73534253e-02f, -3.67292343e-03f, 1.90014720e-01f,
  1.67277455e-01f, 9.43390429e-02f, -1.00217545e-02f, -1.64871916e-01f, 9.71496105e-02f, 2.34240964e-02f, -2.54244953e-01f, 1.78691652e-02f, -9.47105661e-02f, 1.36317447e-01f,
  1.20152853e-01f, 9.46307480e-02f, 5.12366369e-02f, -2.86716446e-02f, -2.61451513e-01f, -3.67870256e-02f, 5.34400754e-02f, 1.03834374e-02f, 2.67361589e-02f, 1.85320139e-01f,
  4.17044550e-01f, -6.94793835e-02f, -1.24451935e-01f, -1.84844375e-01f, -2.69168988e-02f, -2.26634189e-01f, 2.28837714e-01f, -2.86105782e-01f, 1.49064898e-01f, -3.71589735e-02f,
  1.05733901e-01f, -1.23046845e-01f, 3.06705564e-01f, 5.20707965e-01f, 2.00051278e-01f, -8.36173743e-02f, -2.44549543e-01f, 1.77929923e-01f, 3.40582281e-01f, -3.71492267e-01f,
  5.99284410e-01f, 2.85697579e-01f, 3.50041240e-02f, -3.51797670e-01f, 1.05358131e-01f, 1.95512518e-01f, 1.46858767e-01f, 1.99558184e-01f, -8.53569657e-02f, 2.15809673e-01f,
  1.70499340e-01f, 1.23138793e-01f, 1.65911943e-01f, 2.78433472e-01f, 1.81602210e-01f, 2.91927636e-01f, 2.05877483e-01f, 2.73069143e-02f, 8.17666501e-02f, 2.57964402e-01f,
  2.16911528e-02f, 1.88602626e-01f, 2.06409305e-01f, 3.04373085e-01f, 4.41449374e-01f, -3.70429978e-02f, 2.40326717e-01f, 1.43798888e-02f, 1.75747856e-01f, -6.98008686e-02f,
  1.02433190e-01f, 1.32611886e-01f, -2.81374723e-01f, 2.51385123e-01f, -1.00398976e-02f, 2.26386666e-01f, -1.14041746e-01f, 4.44237627e-02f, -4.95679304e-02f, 1.65745899e-01f,
  8.65212642e-03f, -2.32266560e-02f, -2.09554285e-01f, 2.56904989e-01f, -2.37231478e-01f, -1.72749028e-01f, -6.92202449e-02f, 5.13135903e-02f, 3.62888887e-03f, -3.44257772e-01f,
  1.76076427e-01f, 3.54288705e-02f, -2.22352132e-01f, 6.07851028e-01f, 1.34703442e-01f, -1.43503085e-01f, 1.46708757e-01f, 2.85917521e-01f, 5.48420429e-01f, 1.64070129e-01f,
  -3.50003451e-01f, 3.00820172e-01f, -5.27564213e-02f, 4.00093913e-01f, 5.72045565e-01f, 6.62987530e-02f, 7.30433911e-02f, -1.98111445e-01f, 1.12993151e-01f, -7.75197567e-03f,
  9.66656208e-02f, -6.03913628e-02f, -4.09171842e-02f, 1.16419338e-01f, -5.86251207e-02f, 1.12225816e-01f, 1.39605746e-01f, 2.74896752e-02f, 1.66198120e-01f, 1.00744911e-01f,
  2.97305584e-01f, 9.69006568e-02f, 7.94562399e-02f, 2.55112618e-01f, 4.13932055e-02f, 1.68213457e-01f, 9.29073915e-02f, 1.62823886e-01f, 2.81872638e-02f, 2.37476211e-02f,
  3.14756215e-01f, 8.16430822e-02f, 1.47042990e-01f, 1.14741430e-01f, 1.59455970e-01f, -1.16595589e-01f, 3.47268209e-02f, 2.14570388e-01f, -1.08822286e-01f, 4.65082489e-02f,
  -1.69690624e-01f, 3.30763489e-01f, 3.29843536e-02f, -1.49235189e-01f, -1.64757803e-01f, 5.99672552e-03f, -9.53396559e-02f, 2.71302044e-01f, 3.08274329e-01f, -2.75276095e-01f,
  -1.46202177e-01f, 1.26353681e-01f, 9.35832411e-02f, -8.99837613e-02f, 1.97721943e-01f, -8.08543414e-02f, 1.85010105e-01f, 2.67700493e-01f, 1.23480082e-01f, -8.50072727e-02f,
  -8.74352902e-02f, -4.71532866e-02f, 1.86220273e-01f, -2.08715955e-03f, -1.39014885e-01f, -8.72710422e-02f, -2.15999447e-02f, 5.28122902e-01f, 4.65789996e-02f, -1.52208611e-01f,
  -5.50321043e-02f, -1.93976268e-01f, 3.78666013e-01f, 1.90205082e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  4.34519276e-02f, 3.69956017e-01f, 1.18648231e-01f, 1.16980247e-01f, 3.89838159e-01f, 2.23277509e-01f, 1.29810348e-01f, 1.28281146e-01f, 1.09876722e-01f, 2.53321677e-01f,
  -5.67025803e-02f, 3.18484068e-01f, 2.24616155e-01f, 3.56982678e-01f, 2.68631876e-01f, 2.68076628e-01f, 2.55400032e-01f, 2.81568170e-01f, 1.30685404e-01f, 1.42772540e-01f,
  4.65190224e-02f, 2.16427922e-01f, 1.34862587e-01f, 3.80394697e-01f, 1.28542900e-01f, 3.13210428e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.05447575e-01f, -3.41580093e-01f, -8.59757587e-02f, -1.28628597e-01f, -5.23547344e-02f, -1.30311564e-01f, 1.65787742e-01f, -1.81366995e-01f, -2.99524039e-01f, -1.53620794e-01f,
  2.33694658e-01f, 2.10965231e-01f, -2.17566282e-01f, -3.73827875e-01f, -6.07605539e-02f, -4.69621122e-01f, -1.06513366e-01f, 2.24166557e-01f, -2.84708589e-01f, 1.06987163e-01f,
  -1.01482697e-01f, 2.03285456e-01f, -1.00730225e-01f, -7.38166869e-02f, 4.24143761e-01f, -5.87837920e-02f, -3.52751046e-01f, 2.60054529e-01f, -1.58884190e-02f, -3.00693572e-01f,
  5.97396754e-02f, 3.53243388e-02f, -8.58586729e-02f, 9.36034098e-02f, -1.13176713e-02f, 2.87393540e-01f, -3.11657280e-01f, 4.15637910e-01f, 2.40423515e-01f, 1.89019248e-01f,
  -7.06340838e-03f, -4.59183335e-01f, -3.10417078e-02f, 1.84957758e-02f, 3.50580305e-01f, -5.04573643e-01f, 3.96659881e-01f, 6.45553991e-02f, -4.54418957e-02f, 1.15646040e-02f,
  1.64329261e-01f, -5.00079870e-01f, 9.10518467e-02f, -3.19604516e-01f, -3.09163064e-01f, -2.15457052e-01f, -3.74171674e-01f, -2.94936627e-01f, -1.44174665e-01f, -5.13708629e-02f,
  2.49848723e-01f, -1.60634413e-01f, -5.52508533e-01f, -1.37570873e-01f, 4.57681939e-02f, 2.90417522e-01f, 2.40623817e-01f, -2.81293929e-01f, 3.22544903e-01f, -1.10981733e-01f,
  -3.27517778e-01f, -1.68520212e-01f, -7.18016103e-02f, -3.13500836e-02f, -3.62611234e-01f, -2.02082947e-01f, 8.50155503e-02f, -7.35777393e-02f, 1.69791564e-01f, 5.88032156e-02f,
  -9.60148349e-02f, -3.41865420e-01f, -1.76526770e-01f, -3.19286764e-01f, 6.42344356e-02f, 2.18596235e-01f, 1.58331081e-01f, -1.92255184e-01f, 1.81397051e-01f, 7.38471523e-02f,
  -2.44964167e-01f, -6.20646123e-03f, -2.11520836e-01f, 7.14069009e-02f, 5.31462371e-01f, 2.51791477e-01f, -1.28969595e-01f, -5.55718429e-02f, -3.27715054e-02f, -1.31771155e-02f,
  5.17997921e-01f, -3.38283405e-02f, -3.62901464e-02f, -7.02518046e-01f, 5.10100603e-01f, -3.04320037e-01f, 7.08177388e-02f, 9.26143955e-03f, -1.11430496e-01f, -1.85921505e-01f,
  1.61150441e-01f, 1.63848639e-01f, 5.30221649e-02f, -5.02158582e-01f, 3.05580825e-01f, 1.08539827e-01f, 3.75315845e-02f, 1.07910730e-01f, 2.41698936e-01f, 3.05702120e-01f,
  -1.51343986e-01f, 1.97450325e-01f, 1.90243512e-01f, 2.98896059e-02f, 2.28119537e-01f, -4.69262123e-01f, -5.74193180e-01f, -3.74361157e-01f, 1.13442406e-01f, 2.46722683e-01f,
  -5.67168817e-02f, -2.44385809e-01f, 1.27165541e-01f, -7.72064626e-02f, -8.81455168e-02f, -7.01140091e-02f, 3.20836127e-01f, 4.55778278e-02f, 1.41995981e-01f, 9.23604667e-02f,
  6.59234822e-02f, 1.87758908e-01f, -3.38396840e-02f, -1.38230652e-01f, 2.63510823e-01f, -2.66664308e-02f, -1.49138600e-01f, -3.50158572e-01f, -4.19230908e-01f, -5.35052776e-01f,
  -3.21696907e-01f, 1.83975021e-03f, -3.32206935e-01f, -2.05591395e-02f, -8.26915801e-02f, -1.44679844e-01f, 1.58537567e-01f, -4.58489478e-01f, 5.97324193e-01f, 8.48992243e-02f,
  4.66283888e-01f, 1.76204339e-01f, -4.87273276e-01f, -5.59836887e-02f, -3.97609174e-01f, -2.62082845e-01f, 1.81499243e-01f, -5.00208177e-02f, -3.28384370e-01f, -4.29576397e-01f,
  2.35106319e-01f, -6.31187856e-01f, -1.76924318e-01f, -1.66416630e-01f, 2.46904865e-01f, -9.40935016e-02f, -3.34081054e-01f, -1.03827305e-01f, -4.34926897e-01f, -1.42999773e-03f,
  -4.15006280e-03f, 1.08736701e-01f, 2.71192878e-01f, 9.01275501e-02f, -1.72669455e-01f, -3.22929978e-01f, 3.44845280e-02f, 3.59646864e-02f, 5.30272365e-01f, 1.66931540e-01f,
  -1.44761130e-02f, 1.92294404e-01f, -3.56561542e-02f, -1.32030189e-01f, -1.59785838e-03f, -1.74294621e-01f, 1.13957673e-01f, -2.54727036e-01f, -8.39461908e-02f, 1.53648073e-03f,
  1.21239923e-01f, 2.64589936e-01f, -6.12451434e-02f, 8.51494297e-02f, 1.25752494e-01f, -1.81818113e-01f, -3.00641987e-03f, 1.38120428e-01f, -2.33660430e-01f, 6.13393150e-02f,
  1.49721250e-01f, -1.09845854e-01f, 2.48171568e-01f, 6.32183552e-01f, 1.82787046e-01f, -1.82136282e-01f, 4.03305948e-01f, -1.95918366e-01f, -2.54574984e-01f, 1.51535526e-01f,
  -2.02059764e-02f, -1.43345043e-01f, 1.85373902e-01f, -6.20646238e-01f, -3.14074904e-01f, -6.54338539e-01f, 1.47187755e-01f, -1.62504658e-01f, -1.11995302e-01f, 2.73673117e-01f,
  -2.18811501e-02f, 1.47737071e-01f, -4.85494614e-01f, -2.94221073e-01f, -5.11752248e-01f, 2.36139551e-01f, 1.04135357e-01f, -2.53096670e-01f, -4.86013368e-02f, -7.79613376e-01f,
  -8.41175579e-03f, -2.44185757e-02f, -6.22323334e-01f, -2.77583957e-01f, 2.75046557e-01f, 2.52435416e-01f, -7.38455951e-02f, 5.04572749e-01f, 3.63214947e-02f, -3.15371722e-01f,
  -8.81654695e-02f, -2.78879762e-01f, -4.51135039e-01f, 3.73347282e-01f, 2.44276956e-01f, -2.52149463e-01f, -3.89036119e-01f, -1.11837154e-02f, 2.00525671e-01f, 5.41527808e-01f,
  1.21237412e-01f, 1.96381226e-01f, 8.87797251e-02f, 3.43821645e-01f, -3.16858858e-01f, -2.12423563e-01f, 2.84105629e-01f, 1.44565210e-03f, -3.66872884e-02f, 4.28643793e-01f,
  1.32183790e-01f, 1.97241962e-01f, 2.86674768e-01f, -3.98043573e-01f, 1.63369089e-01f, -1.48109660e-01f, 4.61465508e-01f, -5.46573877e-01f, 2.62373984e-01f, 4.87860292e-01f,
  -1.42978400e-01f, -4.57599074e-01f, 6.34420097e-01f, 2.52723068e-01f, -2.13174373e-01f, -6.17988966e-02f, -6.58572733e-01f, 1.83064610e-01f, -2.42122263e-01f, 8.39048848e-02f,
  3.69483531e-01f, -2.48165220e-01f, -8.65663663e-02f, -2.25407183e-01f, -5.81395533e-03f, 3.05664301e-01f, -2.09311873e-01f, -3.47514898e-01f, -6.50274277e-01f, -4.83895123e-01f,
  -1.76129282e-01f, 3.92604381e-01f, -4.24859598e-02f, 8.17424878e-02f, 1.69319808e-01f, 3.50891292e-01f, -1.20326377e-01f, -4.81245853e-02f, 7.38077015e-02f, -3.70122969e-01f,
  -1.21825390e-01f, -3.08460742e-01f, -3.14288139e-01f, -5.95364310e-02f, 1.84319347e-01f, 1.30662337e-01f, -2.00825155e-01f, 9.94139584e-04f, 7.45463073e-02f, -2.38176547e-02f,
  3.50677699e-01f, -3.54239643e-02f, -2.43092299e-01f, -1.02077797e-01f, 1.73895463e-01f, 1.28240600e-01f, -1.93494782e-01f, 2.35066548e-01f, 1.93334207e-01f, 4.99382764e-02f,
  3.02645564e-01f, -1.26897246e-01f, 8.79281089e-02f, 4.02834825e-03f, 4.56768610e-02f, 2.45878860e-01f, 1.15427956e-01f, 6.20285988e-01f, 1.23141155e-01f, -2.68777348e-02f,
  2.37338975e-01f, -1.26668558e-01f, 1.80260971e-01f, 1.90541714e-01f, -3.37410569e-01f, 2.77340591e-01f, 5.01203597e-01f, -7.48014897e-02f, -1.62283048e-01f, 4.12956864e-01f,
  -5.54494739e-01f, 3.47142786e-01f, -1.53456241e-01f, -3.12774718e-01f, 5.85764274e-02f, 2.34259412e-01f, -1.66539535e-01f, 4.26015764e-01f, 4.71884981e-02f, 9.81693715e-02f,
  2.94311792e-01f, 3.76882255e-01f, -3.16977561e-01f, 1.60506085e-01f, -8.97919293e-03f, 2.39898339e-02f, -2.35735133e-01f, 1.70533359e-01f, -1.74855992e-01f, -4.16417062e-01f,
  3.83760422e-01f, -2.22676575e-01f, -3.67733394e-03f, 8.84749666e-02f, -4.11159486e-01f, -9.73784804e-01f, 8.62087905e-02f, 7.15262890e-02f, -3.48496884e-02f, 2.09491536e-01f,
  2.55103081e-01f, -5.68082333e-01f, 1.47264078e-01f, 8.30573812e-02f, -1.69020027e-01f, 2.22371936e-01f, 2.11379692e-01f, -1.95098206e-01f, -2.45965287e-01f, -1.10958077e-01f,
  1.64671302e-01f, -6.43627048e-02f, 3.41311902e-01f, 4.44883704e-01f, 6.93084896e-02f, 4.93482538e-02f, 1.65893018e-01f, -4.11173880e-01f, -2.49827772e-01f, -1.09564520e-01f,
  2.61261314e-01f, 3.87325324e-02f, -1.10789411e-01f, 8.84725228e-02f, -4.34979469e-01f, 4.17196117e-02f, -3.17957461e-01f, 1.13543428e-01f, -3.30404460e-01f, 5.40256083e-01f,
  -3.62435319e-02f, 1.56210378e-01f, -2.64890313e-01f, 2.47147515e-01f, -1.31095007e-01f, -2.74599493e-01f, 1.74080133e-01f, 6.86175609e-03f, -2.26435408e-01f, 3.48541677e-01f,
  4.70898569e-01f, -3.19798112e-01f, -5.92888772e-01f, -7.14457870e-01f, -1.47937685e-01f, -1.18609726e-01f, 4.31556642e-01f, 1.23493440e-01f, 1.79611176e-01f, 4.10794765e-01f,
  -6.82059586e-01f, -1.34779885e-01f, -4.91807878e-01f, 2.86011338e-01f, -3.61475676e-01f, 2.31275886e-01f, -8.04646671e-01f, -4.37615905e-03f, -2.47200593e-01f, 1.89670026e-01f,
  -1.49752423e-01f, 9.27903578e-02f, -7.66661763e-02f, -1.87175795e-01f, -1.88685820e-01f, 2.51995891e-01f, -1.79285854e-01f, 3.11909825e-01f, -1.59818660e-02f, -4.29083146e-02f,
  -1.34455293e-01f, -2.71328032e-01f, -1.94609717e-01f, -8.89782682e-02f, 2.41823383e-02f, -9.45293754e-02f, -2.78351992e-01f, -1.23216519e-02f, -1.16601819e-02f, -3.27780366e-01f,
  -5.32072894e-02f, 2.00125545e-01f, -2.27592900e-01f, -5.30145392e-02f, 1.27985165e-01f, -7.46152624e-02f, -1.78232521e-01f, 3.82518908e-03f, 2.93394197e-02f, -1.64970353e-01f,
  3.17574799e-01f, -3.29085775e-02f, -1.17515489e-01f, 5.17350100e-02f, -2.94271577e-02f, -3.78624201e-01f, -6.95132390e-02f, -3.20833832e-01f, 2.33330861e-01f, -1.29476026e-01f,
  -1.34121075e-01f, -1.32472962e-01f, -1.13934554e-01f, -1.84623063e-01f, 3.46880443e-02f, -3.37577194e-01f, 1.25835473e-02f, 4.80818123e-01f, -2.96813130e-01f, 3.06170404e-01f,
  -3.99208933e-01f, -1.50412977e-01f, 2.57906504e-02f, -2.58948147e-01f, 1.21476665e-01f, 1.48797249e-02f, 1.62528697e-02f, -3.68277192e-01f, -6.89000487e-02f, 2.22958490e-01f,
  -7.36569166e-01f, -5.10219991e-01f, -2.98719645e-01f, -1.75386205e-01f, -1.55835124e-02f, 2.02893466e-01f, -1.83366463e-01f, 1.00479692e-01f, -6.10955775e-01f, 1.41990617e-01f,
  3.93940419e-01f, 9.58461389e-02f, -1.12090083e-02f, 1.25146776e-01f, 7.14342147e-02f, 3.20277125e-01f, -2.13149533e-01f, 1.28421947e-01f, -3.54248196e-01f, -1.38378054e-01f,
  -3.73134404e-01f, 1.90302287e-03f, -4.85522673e-02f, 1.98459253e-01f, 1.56902745e-02f, -1.79525558e-02f, 1.20973758e-01f, 6.51686415e-02f, 7.30317384e-02f, -3.04455668e-01f,
  2.51332462e-01f, 5.83151281e-01f, -2.93453395e-01f, -1.88060179e-01f, -4.06928897e-01f, -3.67466331e-01f, 3.48252475e-01f, -2.72071976e-02f, -2.56120205e-01f, -1.68827623e-01f,
  6.36242211e-01f, -1.93044748e-02f, 3.23964745e-01f, -5.80385685e-01f, -3.04391265e-01f, -7.07479715e-02f, -2.49347806e-01f, -1.03449672e-01f, 4.21519242e-02f, 2.07409307e-01f,
  -8.60727683e-04f, -2.51591444e-01f, -4.00571108e-01f, 1.50937453e-01f, 3.07337940e-01f, 1.00202240e-01f, -7.71520808e-02f, 3.12031992e-02f, -4.33826298e-01f, -3.70770782e-01f,
  1.08611450e-01f, -4.74283248e-01f, -8.09383690e-02f, -2.36732632e-01f, -5.88691533e-01f, 3.10836494e-01f, 4.61294025e-01f, -3.50967199e-01f, 3.65192503e-01f, 1.87441185e-01f,
  -3.74536753e-01f, 3.00958008e-01f, -2.52168268e-01f, -2.25821689e-01f, 1.42482743e-01f, 2.03289747e-01f, 2.72530496e-01f, -7.62635022e-02f, -1.42226800e-01f, 3.85615349e-01f,
  -2.63295412e-01f, -1.82999983e-01f, 2.91418940e-01f, -3.65867764e-01f, 2.08594367e-01f, -4.05767083e-01f, 1.54295638e-01f, 2.10831434e-01f, 9.43513140e-02f, 1.26217470e-01f,
  -1.30305752e-01f, 3.21128964e-01f, 8.56498182e-02f, 4.40106839e-02f, -2.09734142e-01f, 3.07237059e-02f, 6.70781791e-01f, 1.55712664e-01f, 2.81004339e-01f, 1.72287554e-01f,
  -1.46747127e-01f, -5.79079986e-01f, 1.60731748e-01f, 3.49848606e-02f, -1.04057886e-01f, 2.12716907e-01f, -2.26617619e-01f, 6.58872902e-01f, 4.97827023e-01f, 3.71717393e-01f,
  -5.79564311e-02f, 4.55916315e-01f, 6.21861778e-02f, -2.65410036e-01f, -1.59492180e-01f, 2.07720529e-02f, -1.70374170e-01f, 2.98895687e-01f, 2.51782089e-01f, -4.85149890e-01f,
  -5.37717283e-01f, -5.20329058e-01f, -4.23545569e-01f, -1.56784337e-02f, -3.20527136e-01f, 2.73546368e-01f, 3.60615253e-01f, 4.10003424e-01f, -1.82482519e-03f, -3.84801239e-01f,
  -6.45899236e-01f, -5.07073179e-02f, -3.13288093e-01f, -2.74923742e-01f, 8.58549476e-02f, -8.29469204e-01f, -4.14652646e-01f, 2.62779415e-01f, 1.87599421e-01f, -6.10734196e-03f,
  1.62828192e-01f, -2.37490043e-01f, -7.31418282e-02f, 2.57524222e-01f, -2.69708276e-01f, 1.52080998e-01f, 1.12079442e-01f, 1.45463981e-02f, 2.22725719e-01f, -1.19315818e-01f,
  -3.06359321e-01f, 1.11304834e-01f, 1.07794970e-01f, 6.03421442e-02f, -1.71966106e-01f, -2.46794030e-01f, -9.51652005e-02f, -1.23192947e-02f, 1.24391645e-01f, 4.11173046e-01f,
  1.66950151e-01f, -2.91770875e-01f, -7.57033899e-02f, -2.30931506e-01f, 1.75273210e-01f, 2.56728858e-01f, -1.99372023e-01f, 1.86389297e-01f, -3.56677532e-01f, 2.46972106e-02f,
  -2.64531285e-01f, 1.37218997e-01f, -1.99366510e-01f, 2.06338614e-01f, 3.73570353e-01f, 1.04742222e-01f, 2.07214132e-01f, 2.45898336e-01f, 1.79620117e-01f, -3.22947204e-01f,
  -3.97117764e-01f, 3.17164123e-01f, 4.04489636e-01f, 1.73221394e-01f, -5.68893969e-01f, 3.63805890e-01f, -2.97824919e-01f, -8.46535742e-01f, 2.38183960e-01f, -4.68917787e-01f,
  -4.83403921e-01f, -2.58929372e-01f, 2.41139084e-01f, -2.37684891e-01f, -4.39960569e-01f, -7.45369047e-02f, 3.60170662e-01f, -3.29394102e-01f, 2.45909736e-01f, -4.44955200e-01f,
  -4.16241884e-01f, -1.97501794e-01f, 1.63673282e-01f, -3.14464927e-01f, 2.08465159e-01f, -8.86847973e-02f, -2.71583825e-01f, 1.93612590e-01f, 3.42879854e-02f, 6.68086261e-02f,
  9.69191045e-02f, 6.00253567e-02f, 1.53576151e-01f, 1.08554557e-01f, -1.66084185e-01f, -2.47243986e-01f, -1.02518082e-01f, 2.74030328e-01f, 2.28870898e-01f, 2.05092728e-01f,
  -2.50507325e-01f, 1.49984583e-01f, 1.13279991e-01f, 9.62328315e-02f, -3.64992023e-01f, 3.04892808e-01f, -1.85151547e-01f, 3.11547756e-01f, 3.16960305e-01f, 2.86224872e-01f,
  6.80827582e-03f, -9.54983607e-02f, 4.24774885e-01f, 2.62171596e-01f, 2.99590796e-01f, -4.26799715e-01f, 2.91901767e-01f, 2.42896929e-01f, 5.68624511e-02f, -4.06768829e-01f,
  -3.33331436e-01f, 4.33917403e-01f, -5.73510289e-01f, -2.06504062e-01f, 1.98238060e-01f, 3.67550924e-02f, -6.14409864e-01f, 3.69383633e-01f, -3.08109045e-01f, 1.57129705e-01f,
  -1.74760416e-01f, 2.98653632e-01f, -3.89708549e-01f, 3.21729898e-01f, 9.29592550e-02f, -2.86603630e-01f, 1.32312253e-01f, 4.24791425e-01f, 3.28147709e-01f, 1.66363433e-01f,
  -2.51282722e-01f, -1.71591826e-02f, 6.50094450e-02f, -5.02031267e-01f, -4.44722831e-01f, -1.52899340e-01f, 1.35997206e-01f, 4.19950895e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.79262340e-01f, 6.50664791e-02f, 8.63810852e-02f, -1.47172203e-02f, -1.14603303e-01f, -1.24712765e-01f, 5.06796967e-03f, -6.40819371e-02f, -3.50416154e-02f, 1.45379245e-01f,
  -1.26691878e-01f, -6.76944256e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    