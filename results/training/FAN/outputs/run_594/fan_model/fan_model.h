/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.09431243e-01f, 1.95939645e-01f, -1.93699405e-01f, 2.08820045e-01f, 2.37780623e-02f, -5.41864149e-02f, 1.06330976e-01f, 7.44001344e-02f, 9.14210230e-02f, 2.00748384e-01f,
  1.27931923e-01f, -1.60247713e-01f, -1.02350965e-01f, -1.70739651e-01f, -2.81146914e-01f, 9.77642611e-02f, 1.25225931e-02f, -3.74956161e-01f, -5.07206857e-01f, -1.14722311e-01f,
  3.38574126e-02f, 2.60452870e-02f, -1.69284269e-01f, 5.22375703e-02f, 8.63042176e-02f, -1.48982912e-01f, 2.70344526e-01f, 4.66097258e-02f, -6.42890483e-02f, 5.44677377e-02f,
  -2.51496166e-01f, 1.87323153e-01f, -1.56565979e-01f, -8.23000744e-02f, -2.38092449e-02f, -8.34237039e-02f, -6.74425364e-02f, -5.33930697e-02f, -9.55997873e-03f, -4.67349961e-02f,
  -8.55816621e-03f, -4.84153517e-02f, 1.42073110e-02f, -2.12959424e-02f, -9.32458192e-02f, 1.75534037e-03f, 4.66771089e-02f, -1.12874009e-01f, -5.19654751e-02f, 4.97320965e-02f,
  -1.31860364e-03f, -5.05536608e-02f, -1.30237177e-01f, -5.72742075e-02f, -1.19504280e-01f, -1.76339254e-01f, -3.87294218e-02f, 3.18650343e-02f, -8.10017660e-02f, -8.00452381e-03f,
  -6.26615807e-02f, 2.39533726e-02f, 4.85016927e-02f, -5.05837472e-03f, -4.10451274e-03f, -7.46772566e-04f, 5.05977012e-02f, 2.00817101e-02f, 3.23312804e-02f, -3.48648080e-03f,
  6.70007721e-05f, 1.04667433e-02f, 3.01475655e-02f, 5.67546189e-02f, 9.23220962e-02f, 2.28496548e-02f, -3.10546588e-02f, 7.57190064e-02f, 4.57890853e-02f, 1.00514134e-02f,
  -2.46572914e-03f, -9.97904409e-03f, 4.64502024e-03f, 3.21404152e-02f, -8.06131121e-03f, -4.73368019e-02f, 7.51704648e-02f, 7.67863467e-02f, 1.01093650e-01f, 8.92018601e-02f,
  1.36824121e-04f, -1.81523263e-01f, -1.15831085e-01f, -8.93859267e-02f, -3.07701919e-02f, -1.18110646e-02f, -1.12679275e-02f, -4.77419458e-02f, -8.75827372e-02f, -3.75694185e-02f,
  -4.91443984e-02f, -6.34614527e-02f, 9.62700509e-03f, 1.19854091e-02f, 1.10519985e-02f, -1.04133645e-02f, -4.26558144e-02f, -1.45762026e-01f, -1.92525126e-02f, 6.76664338e-02f,
  6.43647462e-03f, -6.19905479e-02f, -1.67672232e-01f, -7.15384483e-02f, -8.61919895e-02f, -2.08041683e-01f, -1.16272837e-01f, -1.37525246e-01f, -2.24494785e-01f, -7.01607987e-02f,
  9.90569174e-01f, 1.92015037e-01f, -3.25035721e-01f, 2.49749184e-01f, -3.38123471e-01f, -3.18021894e-01f, 4.68701422e-02f, 2.32436284e-02f, 1.70548707e-01f, 1.34380475e-01f,
  -9.39669758e-02f, 6.40725642e-02f, 5.79099823e-03f, -1.16228208e-01f, 1.46058366e-01f, 1.52189225e-01f, -1.12353422e-01f, 3.60126793e-02f, -1.28899336e-01f, -1.23215757e-01f,
  -1.30979329e-01f, 1.89383969e-01f, 3.02310914e-01f, -2.33686641e-02f, 1.90998092e-01f, 1.34632826e-01f, 1.72417387e-01f, 8.61467421e-02f, -6.41040802e-02f, 2.08928064e-01f,
  7.36549422e-02f, 1.40467547e-02f, -2.11631469e-02f, 4.16634269e-02f, 5.39159449e-03f, 7.82709867e-02f, 8.70628506e-02f, 6.29199669e-02f, 3.32337059e-02f, 7.21315593e-02f,
  -3.96767855e-02f, -1.25649599e-02f, -4.03875764e-03f, -1.97814833e-02f, 1.08700335e-01f, 9.86015126e-02f, 5.35083301e-02f, 3.68651748e-02f, -3.54479142e-02f, -5.23268357e-02f,
  -8.54229331e-02f, -1.09989479e-01f, -4.60543483e-02f, -1.45726800e-01f, -1.40094040e-02f, -1.03300609e-01f, 4.15822305e-02f, 7.86894634e-02f, 1.04446992e-01f, 3.85994136e-01f,
  2.82775629e-02f, 7.07805678e-02f, -8.88933614e-02f, 5.82819283e-02f, 3.65373330e-06f, -1.25121223e-02f, -3.93219069e-02f, -1.05620734e-02f, -8.55794400e-02f, 3.36911678e-02f,
  -4.56343368e-02f, -1.73224676e-02f, 1.99391153e-02f, 5.13488241e-02f, 3.06987436e-03f, 6.81392252e-02f, -1.85631327e-02f, 6.20034523e-02f, -6.86555430e-02f, 2.98142321e-02f,
  -1.41381081e-02f, -4.33719857e-03f, 5.42665645e-02f, 6.98041916e-02f, -5.23902662e-02f, 2.89680343e-02f, -1.86962001e-02f, -4.22517322e-02f, -2.51848511e-02f, -5.00524268e-02f,
  4.51048732e-01f, -2.20683828e-01f, 1.00677304e-01f, 7.01104552e-02f, -2.69698463e-02f, -2.28259899e-02f, -2.55385991e-02f, 1.20175537e-02f, 1.70526300e-02f, 3.35673764e-02f,
  -7.10497275e-02f, 8.92951563e-02f, 2.90121138e-02f, -1.46725420e-02f, -3.55852284e-02f, -2.22385712e-02f, -1.53941503e-02f, 1.03441767e-01f, 1.49532966e-02f, 1.63254756e-02f,
  4.57054600e-02f, 1.13753058e-01f, 1.70395434e-01f, 8.56844634e-02f, 8.81788507e-02f, 9.39455554e-02f, 4.80126143e-02f, 1.05727606e-01f, 2.66036149e-02f, 4.15995508e-01f,
  -2.94036232e-03f, -2.16662601e-01f, -1.04560390e-01f, 9.30376202e-02f, -3.41245010e-02f, -2.56672174e-01f, -5.87620318e-01f, -2.48879194e-01f, 2.45272238e-02f, -2.37482637e-01f,
  2.08021849e-01f, 4.97255564e-01f, 2.71660089e-01f, 1.25450790e-01f, -1.76221594e-01f, -5.18050790e-01f, -4.53529924e-01f, -3.59799787e-02f, -6.70784861e-02f, -1.01154856e-01f,
  9.32388473e-03f, -8.33376646e-02f, 4.69743460e-02f, 1.36912204e-02f, -1.04162499e-01f, 1.33771166e-01f, -1.24765344e-01f, 5.50778247e-02f, 4.09998596e-02f, 5.50897196e-02f,
  6.87829033e-03f, 4.75386642e-02f, 9.04307608e-03f, 4.71087359e-02f, 4.59076427e-02f, 4.13086787e-02f, -6.57028379e-03f, 2.43850201e-02f, 1.29442155e-01f, 2.05526091e-02f,
  2.09549554e-02f, 4.68418635e-02f, 1.08534768e-01f, -1.56295416e-03f, 1.46805858e-02f, 1.26911951e-02f, -9.77131650e-02f, 3.23283151e-02f, -1.02309771e-02f, -2.25953031e-02f,
  5.78906909e-02f, 3.59115899e-02f, 1.52143594e-02f, -2.30264347e-02f, 4.97768819e-03f, 5.08381613e-02f, 4.37403069e-04f, -2.00322326e-02f, 7.54063949e-02f, -1.25722080e-01f,
  -1.04635254e-01f, 8.89569744e-02f, -7.71503011e-03f, -2.41876524e-02f, -6.49727089e-03f, -1.68996230e-02f, -2.95098126e-02f, -1.25930011e-01f, 1.32532176e-02f, -9.44067761e-02f,
  2.21010558e-02f, 5.87409511e-02f, -1.16121601e-02f, 4.76816855e-02f, 5.35686128e-02f, 1.55993109e-03f, -8.43277201e-03f, -7.10239708e-02f, 2.41639660e-04f, 3.40151526e-02f,
  -6.50580898e-02f, -1.67035107e-02f, 1.10380873e-02f, -1.37193110e-02f, -3.49143744e-02f, -6.02227449e-02f, -2.29182374e-02f, -1.12226037e-02f, 6.48175403e-02f, -3.10439970e-02f,
  5.13154045e-02f, 2.00467497e-01f, -6.91824034e-02f, -1.09922208e-01f, -4.34800386e-02f, -4.30197513e-04f, -9.25279781e-02f, -7.86865428e-02f, 5.68556786e-02f, 1.36490157e-02f,
  1.01913877e-01f, -5.48356622e-02f, -5.03560677e-02f, -8.94297510e-02f, -8.83549228e-02f, -1.00338563e-01f, -2.05597028e-01f, -1.08886190e-01f, -7.96399191e-02f, -7.11615458e-02f,
  -1.69141918e-01f, -2.08798021e-01f, -6.38795495e-02f, -6.51013032e-02f, -5.50445803e-02f, -8.39565881e-03f, -1.11149199e-01f, -4.58687395e-02f, -1.16913915e-01f, -3.49370897e-01f,
  -2.23532647e-01f, 3.17573726e-01f, 1.43091977e-01f, -2.90446192e-01f, -1.68954805e-01f, 1.90042704e-02f, 5.08916557e-01f, 6.44931421e-02f, -2.64401972e-01f, 2.35895678e-01f,
  -1.68397784e-01f, -4.87379581e-01f, -3.15998524e-01f, -2.75990605e-01f, -3.52594219e-02f, 4.51241404e-01f, 3.41309994e-01f, 8.06576759e-03f, -2.16053560e-01f, 3.27418335e-02f,
  -6.18319958e-02f, 3.23565351e-03f, -1.12262266e-02f, -4.69965562e-02f, 1.19190767e-01f, -1.89649031e-01f, 2.90102869e-01f, 2.83614583e-02f, 1.43753074e-03f, -6.15738034e-02f,
  6.00636713e-02f, -1.06469944e-01f, -1.47414654e-01f, -1.78277105e-01f, -1.34006619e-01f, -6.68487251e-02f, -2.27462146e-02f, -1.87525824e-01f, -1.00965545e-01f, 5.40319569e-02f,
  -1.47368520e-01f, -8.34474266e-02f, -1.37969881e-01f, -1.23899885e-01f, -7.70635111e-03f, -8.64470527e-02f, -1.76241118e-02f, -3.25544998e-02f, -8.03428665e-02f, 2.76327394e-02f,
  -9.75262895e-02f, -1.22633100e-01f, -1.18034728e-01f, -7.57224411e-02f, -4.61255684e-02f, -2.39808276e-01f, -8.36152732e-02f, -1.79945230e-01f, -3.58334407e-02f, 4.03262451e-02f,
  8.27837214e-02f, 3.03393304e-02f, 4.52067219e-02f, 5.44524603e-02f, 1.38661519e-01f, -2.68379282e-02f, 7.16152787e-02f, 3.09527013e-02f, 5.33186011e-02f, 5.47686517e-02f,
  -2.47659511e-03f, 2.53186934e-02f, 9.02977679e-03f, 3.42788622e-02f, 2.28525456e-02f, 6.35061320e-03f, -1.96005255e-02f, 1.01109207e-01f, -9.24502090e-02f, -2.33025989e-03f,
  -9.55450609e-02f, -4.73042205e-02f, -2.56232843e-02f, 2.11293269e-02f, -5.69597967e-02f, 7.46365357e-03f, 6.15321659e-02f, -2.08466500e-02f, 1.43520022e-02f, -1.72545984e-02f,
  7.49538764e-02f, -3.16086739e-01f, 1.81096382e-02f, -5.87357767e-02f, -4.78527360e-02f, -4.51907702e-03f, 1.14203403e-02f, -9.36912838e-03f, -9.67230275e-02f, 5.36624715e-03f,
  -1.31567895e-01f, 2.52503995e-02f, -9.19524673e-03f, 3.92764136e-02f, -6.36779591e-02f, -2.00882200e-02f, 8.24686363e-02f, -7.69468695e-02f, -4.70107086e-02f, 6.93093464e-02f,
  9.19879675e-02f, 7.04763532e-02f, -6.25325888e-02f, -4.01226291e-03f, -9.29153245e-03f, -7.74424002e-02f, 7.31422529e-02f, 3.33821513e-02f, -4.82614152e-02f, 3.04060251e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.14137816e-01f, 6.13051474e-01f, 5.85019171e-01f, -3.99022728e-01f, 2.87293028e-02f, -8.51378813e-02f, 4.49099213e-01f, 5.74510777e-03f, -3.27034146e-01f, 3.07444900e-01f,
  3.02853286e-01f, -3.76311511e-01f, 1.58223495e-01f, -7.64834583e-02f, -1.30747020e-01f, 4.97046798e-01f, 4.16715324e-01f, -2.40248084e-01f, -6.50189698e-01f, -5.81386507e-01f,
  -3.20951194e-01f, -5.49113512e-01f, -7.17445016e-01f, -1.88434973e-01f, 2.94499308e-01f, -2.30162174e-01f, 5.62583864e-01f, -9.53514576e-02f, 2.02329159e-01f, 1.35774761e-01f,
  4.55185026e-01f, 2.86612928e-01f, -1.92837313e-01f, -2.21076354e-01f, 1.05730385e-01f, -1.16298303e-01f, -6.52441755e-02f, -1.39287859e-02f, 1.99103765e-02f, 2.79014781e-02f,
  1.38144307e-02f, -8.43321979e-02f, 7.44294226e-02f, -4.82560545e-02f, -3.99498120e-02f, -7.15826824e-02f, 5.58674447e-02f, 1.74924657e-02f, 1.38223603e-01f, 1.08373560e-01f,
  1.91404209e-01f, 3.33252549e-02f, 3.10873181e-01f, 1.38036907e-01f, 1.88813776e-01f, -1.55268252e-01f, 2.47601166e-01f, 9.30187702e-02f, 1.84284538e-01f, -1.59130096e-01f,
  -1.03285052e-01f, 2.77242102e-02f, 7.76085556e-02f, 2.31618658e-02f, -2.71992963e-02f, -2.37457566e-02f, 2.25059558e-02f, -4.65885289e-02f, -9.59827229e-02f, -1.08646773e-01f,
  -3.14668752e-02f, 2.24649794e-02f, -2.32564565e-03f, 4.83027883e-02f, 8.69053900e-02f, -4.02002968e-03f, 6.34204522e-02f, 5.96658001e-03f, 9.44134369e-02f, 7.38340318e-02f,
  -9.01035145e-02f, -1.94685385e-02f, -2.96806917e-02f, -8.58702976e-03f, 1.89984173e-01f, 3.33503857e-02f, 1.98129620e-02f, 2.89900205e-03f, -1.03270598e-01f, 3.19240354e-02f,
  -1.18021913e-01f, 8.10853988e-02f, 5.63841313e-02f, 1.04431640e-02f, -2.21711257e-03f, 3.77556272e-02f, 9.25690457e-02f, 2.11047605e-02f, 1.11596584e-01f, 9.11740437e-02f,
  1.29077081e-02f, -1.04221053e-01f, 1.63686350e-01f, -5.93945477e-03f, -3.16026628e-01f, -3.21177132e-02f, 7.57474499e-03f, -4.38018776e-02f, 8.18862692e-02f, 7.11759850e-02f,
  7.67447278e-02f, -6.40599579e-02f, -2.97638297e-01f, 2.01153718e-02f, -1.85633823e-01f, -2.14451700e-01f, -1.07047983e-01f, -4.68420722e-02f, 5.23166545e-02f, -1.20034933e-01f,
  1.33125389e+00f, 6.09260142e-01f, 1.96820930e-01f, 3.42830747e-01f, 1.58211380e-01f, 3.02601699e-02f, -2.75483131e-02f, -1.82948504e-02f, -1.45644024e-02f, 2.21686006e-01f,
  3.90130967e-01f, 3.71692091e-01f, 6.41200095e-02f, 4.59396802e-02f, -6.53379709e-02f, -3.77985597e-01f, -2.91181743e-01f, -4.54333127e-02f, -4.57872078e-02f, 1.13886334e-01f,
  2.45255679e-02f, -2.18634933e-01f, -1.16188534e-01f, -1.21127032e-01f, 1.92791671e-01f, 8.77037644e-02f, -1.72328517e-01f, 1.03618465e-01f, 1.84399709e-01f, 3.52807343e-01f,
  6.03908300e-01f, 5.74318469e-01f, -3.01838815e-01f, 3.34224151e-03f, -4.79234615e-03f, -1.20936215e-01f, -1.15924977e-01f, 7.77130248e-03f, -8.43334123e-02f, -5.74494675e-02f,
  -6.29606238e-03f, 4.34610667e-03f, -2.82707391e-04f, 2.78141927e-02f, -7.28676543e-02f, -1.87040176e-02f, -4.90904562e-02f, 1.16901100e-01f, -2.76978826e-03f, 1.34661626e-02f,
  1.28258124e-01f, 1.14684120e-01f, 1.25121906e-01f, -1.04143076e-01f, 2.85528563e-02f, 1.03827894e-01f, 1.98675692e-01f, 4.96545732e-02f, -3.21082096e-03f, 2.30032116e-01f,
  2.01315522e-01f, 3.65824670e-01f, 7.95074850e-02f, 3.22919898e-02f, 1.08191408e-01f, 5.21311462e-02f, 3.93229462e-02f, -2.76798680e-02f, 7.25935176e-02f, -9.22439545e-02f,
  -9.82791632e-02f, 7.72426277e-02f, 1.41537040e-01f, -1.62970483e-01f, 7.01080337e-02f, 7.21747205e-02f, -2.01304425e-02f, -6.59178495e-02f, -2.83101778e-02f, 9.13739577e-02f,
  2.69140974e-02f, 9.16322842e-02f, 1.15825869e-01f, 2.21730713e-02f, -1.09723814e-01f, 1.09986611e-01f, 2.18446180e-02f, 1.99211109e-02f, -2.05968589e-01f, -1.07235406e-02f,
  -5.76193213e-01f, 8.78673643e-02f, -4.07211594e-02f, 1.56821981e-02f, 3.44911143e-02f, -1.39187977e-01f, 1.53149724e-01f, -8.85549858e-02f, -1.57152385e-01f, -1.75194874e-01f,
  -6.48934245e-02f, -1.46981943e-02f, 3.11543830e-02f, -3.16336122e-03f, -8.94539654e-02f, -1.54236808e-01f, 1.36511385e-01f, 2.02918708e-01f, -1.42542377e-01f, -1.16227120e-01f,
  -1.37255862e-01f, -1.14094183e-01f, -1.24129362e-01f, -1.29143625e-01f, -9.71664041e-02f, -1.70449972e-01f, -2.22616330e-01f, -1.09013453e-01f, -2.64991969e-01f, -2.27138519e-01f,
  7.80315399e-01f, 7.48609543e-01f, 3.26397270e-01f, 2.55752295e-01f, -4.41877097e-01f, -6.05424643e-01f, -6.30544186e-01f, -3.17171276e-01f, -1.74579054e-01f, 1.30987987e-01f,
  -3.08364600e-01f, -2.16245234e-01f, -2.70455718e-01f, -9.61023644e-02f, -1.64846405e-02f, 3.08105275e-02f, 3.18914324e-01f, 6.53260231e-01f, 6.88278005e-02f, 6.30561858e-02f,
  1.41826078e-01f, 5.30326068e-01f, 6.48376584e-01f, 2.22300768e-01f, 3.30928117e-01f, -1.43013686e-01f, -9.41005871e-02f, 3.49817276e-01f, 1.68407619e-01f, 9.77952600e-01f,
  3.85849714e-01f, 3.94043177e-01f, -5.01887739e-01f, -6.26910990e-03f, -2.25964673e-02f, 2.13285565e-01f, -8.37560594e-02f, 2.61034429e-01f, -3.65087017e-02f, 1.02259092e-01f,
  -5.57927676e-02f, 1.30688399e-01f, 1.89156696e-01f, 4.45875749e-02f, -5.34777604e-02f, -1.26313999e-01f, -1.01336371e-02f, 1.34462282e-01f, -7.26556331e-02f, -4.50808351e-04f,
  2.27135852e-01f, 2.22904965e-01f, -1.69414178e-01f, -5.11570454e-01f, -2.66308814e-01f, -6.10165186e-02f, -2.16039300e-01f, 5.56802116e-02f, -3.86625856e-01f, 1.79363787e-01f,
  -2.39055693e-01f, -2.71640960e-02f, -8.79985467e-02f, -1.28761888e-01f, 3.28460820e-02f, -1.65546149e-01f, 5.67138009e-02f, -1.45592585e-01f, -2.63857841e-02f, -3.77238952e-02f,
  -2.39908487e-01f, -1.91919059e-02f, -8.83945152e-02f, -2.08189040e-02f, -5.75685203e-02f, -6.22028522e-02f, 1.35797516e-01f, -2.56316196e-02f, 3.93504947e-02f, -4.24582697e-02f,
  -5.09637147e-02f, 6.61397493e-03f, 6.01467416e-02f, -2.59674191e-02f, -7.09257275e-03f, -1.06173210e-01f, -1.00778386e-01f, -8.65719542e-02f, -5.18500842e-02f, 5.54140806e-02f,
  -1.67246237e-01f, -5.74553847e-01f, 8.82529246e-04f, 5.12333624e-02f, 2.57605433e-01f, 2.07736846e-02f, -5.22804596e-02f, 7.75903761e-02f, 2.91830627e-03f, 1.25086278e-01f,
  3.28041352e-02f, -1.76224604e-01f, 2.33957499e-01f, 2.17916127e-02f, -2.90046190e-03f, -1.84743345e-01f, 1.06683344e-01f, -2.31520347e-02f, 5.02570532e-02f, 3.57431285e-02f,
  9.42241699e-02f, -3.06496561e-01f, -5.46802223e-01f, -4.36918646e-01f, -1.68132976e-01f, -4.60358709e-01f, -3.01748961e-01f, -1.08093716e-01f, -6.38369083e-01f, -4.12445277e-01f,
  -6.80876732e-01f, 1.03431448e-01f, -2.36611396e-01f, 5.44737577e-01f, 5.73362350e-01f, 4.07525033e-01f, 3.26249003e-01f, 7.52310008e-02f, 3.82790267e-01f, 3.19905847e-01f,
  2.36050636e-01f, 4.05598819e-01f, 3.50826204e-01f, 3.62515509e-01f, 9.96281058e-02f, 4.37498897e-01f, 5.23240089e-01f, 3.45562696e-02f, -9.89449173e-02f, 2.08879858e-01f,
  4.15830880e-01f, 1.89458936e-01f, -3.25978637e-01f, 8.01572669e-03f, 3.07238132e-01f, 3.62405777e-01f, 1.92587703e-01f, 9.61681902e-02f, 1.00233465e-01f, 4.06189680e-01f,
  9.11478922e-02f, -3.88707131e-01f, 8.52925405e-02f, 2.89241429e-02f, 5.41303046e-02f, -2.84812629e-01f, -5.97064234e-02f, -3.40696812e-01f, -2.25804240e-01f, 1.08894467e-01f,
  4.99256589e-02f, -1.28715217e-01f, -2.08319840e-03f, 2.11298037e-02f, -1.52979091e-01f, -1.17805749e-01f, -7.15342015e-02f, -8.22210163e-02f, 3.36084403e-02f, 1.38566867e-02f,
  4.20107156e-01f, 1.24207862e-01f, -8.12166259e-02f, -5.64767979e-02f, 1.93974916e-02f, -2.94332244e-02f, -1.98048815e-01f, -5.16053811e-02f, -2.62836009e-01f, -1.04784131e-01f,
  -2.47813798e-02f, -1.78926960e-01f, 5.70451729e-02f, 1.82699356e-02f, -1.99490320e-02f, 8.58958885e-02f, 7.60620739e-03f, 1.01321980e-01f, -3.46807279e-02f, -8.96906853e-02f,
  4.47507910e-02f, 1.71196163e-02f, 8.77387375e-02f, 1.44464582e-01f, 5.22127040e-02f, -8.75091776e-02f, 2.05904152e-02f, 4.61492799e-02f, -3.29351723e-02f, -3.25968713e-02f,
  -1.78155094e-01f, -1.57744989e-01f, -1.57213867e-01f, -3.46994884e-02f, -1.06212713e-01f, -1.05521604e-02f, -7.19126761e-02f, -1.51058406e-01f, -8.75361338e-02f, -7.36309215e-03f,
  1.21169440e-01f, -2.20420673e-01f, 1.99946150e-01f, -1.40463002e-02f, -1.01819247e-01f, -2.49862701e-01f, -2.50591338e-02f, -1.38144270e-01f, -5.55368550e-02f, -1.39689045e-02f,
  -1.17366701e-01f, -1.82221517e-01f, -1.82061628e-01f, -1.35768145e-01f, -1.59409985e-01f, -9.71291736e-02f, 7.28191389e-03f, 8.66245478e-02f, 7.57674500e-02f, -1.07771894e-02f,
  -3.80081162e-02f, 5.19496538e-02f, 2.10833177e-02f, 2.88139582e-02f, -1.57357287e-02f, -3.09268143e-02f, -2.16323555e-01f, -1.56274796e-01f, -2.78915644e-01f, -2.21729845e-01f,
  5.68192303e-01f, 2.42023915e-01f, -1.39697540e+00f, 5.36950231e-01f, -3.84357929e-01f, -9.30122212e-02f, -3.37706834e-01f, 2.24502757e-01f, 7.17074156e-01f, -5.31176031e-02f,
  -1.21829189e-01f, -2.97443066e-02f, -9.65371281e-02f, -1.71513990e-01f, -3.99228573e-01f, -6.99661374e-01f, -6.88468575e-01f, -8.69971097e-01f, -7.15476036e-01f, 8.47699046e-02f,
  1.87563017e-01f, 2.81102974e-02f, 3.70363495e-03f, -1.47065163e-01f, 1.80401951e-01f, 1.82566550e-02f, -1.62661225e-01f, -1.84986040e-01f, -4.27631140e-01f, -3.50089252e-01f,
  -2.53564894e-01f, 3.93089354e-01f, -2.71883339e-01f, -3.99379991e-03f, -2.91869529e-02f, 9.14782062e-02f, -7.51652122e-02f, -1.81787536e-01f, 1.28063381e-01f, -1.81058615e-01f,
  -1.75452888e-01f, -6.73516169e-02f, -3.24604735e-02f, -1.30073532e-01f, -2.67930217e-02f, -9.33924094e-02f, -4.79361857e-04f, -1.67927727e-01f, -2.44084656e-01f, 3.59088220e-02f,
  2.52236123e-03f, -2.45393440e-01f, -2.69001666e-02f, 1.73539594e-01f, -8.44660625e-02f, -3.48928958e-01f, 2.59480059e-01f, 1.75132766e-01f, -1.30088434e-01f, 3.07946622e-01f,
  -1.93348725e-03f, -3.33641376e-03f, 4.25270274e-02f, 2.07151496e-03f, 1.48731947e-01f, 1.84374098e-02f, -2.14413434e-01f, -4.69336025e-02f, -2.17856443e-03f, 5.32820646e-04f,
  -1.23410858e-01f, 3.54879210e-03f, -2.49538440e-02f, -4.12940048e-02f, -9.24888551e-02f, -3.30587439e-02f, 7.79947117e-02f, 6.50074631e-02f, -5.49618267e-02f, 6.45343289e-02f,
  -2.26585999e-01f, -9.27342684e-04f, -2.97122300e-02f, -5.60215227e-02f, -1.05298087e-01f, -1.92779794e-01f, 8.12500790e-02f, 9.82287154e-02f, 6.98487088e-02f, 3.47343273e-02f,
  2.66459823e-01f, -3.88868511e-01f, -1.42692113e-02f, 1.45879999e-01f, -1.14432663e-01f, -6.28782110e-03f, 1.22412220e-01f, 8.00925866e-02f, -2.14441065e-02f, 8.74907449e-02f,
  1.68257818e-01f, -3.49915139e-02f, -2.80130655e-02f, 3.45072486e-02f, -3.20588835e-02f, 6.28689080e-02f, 6.33549914e-02f, -1.74768180e-01f, -1.79071315e-02f, 2.13436365e-01f,
  2.10635081e-01f, -2.00780198e-01f, 1.25887329e-02f, 8.00922737e-02f, 1.04654513e-01f, -1.90415367e-01f, -1.89787120e-01f, 2.62167361e-02f, -3.51640999e-01f, 2.47411951e-02f,
  7.56468534e-01f, -7.27995038e-02f, 7.24854887e-01f, 5.18033579e-02f, 4.87602383e-01f, 6.25080585e-01f, 7.58413732e-01f, 2.69930810e-01f, -1.15481362e-01f, 2.69511968e-01f,
  -7.18868226e-02f, -6.31184220e-01f, -4.07647550e-01f, -2.94657111e-01f, 1.31530240e-01f, 1.16049029e-01f, -2.24493761e-02f, 1.73245072e-01f, 3.44273061e-01f, 1.77974895e-01f,
  -4.49606866e-01f, 1.74797744e-01f, 3.38825941e-01f, 9.10621285e-02f, 4.61292975e-02f, -3.47312599e-01f, 1.07293122e-01f, 2.40531251e-01f, 2.68197116e-02f, -6.37278616e-01f,
  -4.73927222e-02f, 2.71336943e-01f, -2.04758421e-01f, -2.21270472e-01f, 3.51816020e-03f, -2.54314095e-01f, -9.06158686e-02f, -1.17511876e-01f, -1.42980382e-01f, -1.57378048e-01f,
  -5.70375845e-02f, -8.25936124e-02f, -3.68339978e-02f, 7.20890313e-02f, 2.04213932e-01f, 8.72541815e-02f, -9.70065519e-02f, -2.85575781e-02f, -4.04711291e-02f, 3.50632742e-02f,
  -3.88188094e-01f, 1.29004136e-01f, 3.40712994e-01f, 1.42865986e-01f, 3.00629288e-02f, -1.09309666e-01f, 1.61243096e-01f, 1.10945940e-01f, 2.53428910e-02f, -1.77255273e-01f,
  -8.11390877e-02f, -9.20678005e-02f, 9.49525759e-02f, -7.18932003e-02f, 6.32299557e-02f, -7.60214478e-02f, -7.29091242e-02f, -7.08745793e-03f, 7.79089928e-02f, 1.47748783e-01f,
  -1.38784036e-01f, 8.30167383e-02f, -1.48079032e-02f, -8.74922723e-02f, -8.82062390e-02f, 1.75851226e-01f, 6.21564612e-02f, -1.00837156e-01f, 5.10564931e-02f, -3.25303078e-02f,
  -3.64575647e-02f, 8.90216380e-02f, 5.11604063e-02f, 4.20234501e-02f, -6.12680539e-02f, 1.43704358e-02f, -1.40241683e-01f, -7.67371133e-02f, -4.40444238e-02f, -3.49511839e-02f,
  -4.77924049e-01f, 1.33962825e-01f, -1.44731671e-01f, -2.00858358e-02f, 1.62292883e-01f, -8.35653022e-02f, -7.27665722e-02f, -1.41830966e-01f, -6.23267628e-02f, -1.48048893e-01f,
  9.77978483e-02f, -1.00366272e-01f, -2.35542357e-02f, 9.90791395e-02f, 1.50587231e-01f, -6.46444112e-02f, -1.15727715e-01f, -4.80606072e-02f, -1.25150621e-01f, 7.70909637e-02f,
  -2.40564525e-01f, 5.09463139e-02f, -2.30742861e-02f, -8.94003734e-02f, -1.24851309e-01f, -2.09119529e-01f, 1.56698972e-01f, -6.02085367e-02f, 1.30005777e-01f, -4.21538949e-02f,
  -1.09611154e+00f, -6.56264305e-01f, -5.57079315e-01f, -1.28617942e+00f, -9.83709335e-01f, -4.99100506e-01f, 2.96246214e-03f, 1.18316840e-02f, -6.45046473e-01f, -5.17446935e-01f,
  3.98929298e-01f, 7.64340401e-01f, 4.45383906e-01f, 5.42421579e-01f, 4.93488014e-01f, -4.38743711e-01f, -1.10073161e+00f, -1.60288051e-01f, 4.69412237e-01f, 1.13013700e-01f,
  -9.67032611e-02f, -3.75245243e-01f, -1.78202540e-01f, -2.28333902e-02f, -6.44909203e-01f, 9.87429097e-02f, -7.68406272e-01f, -6.68242157e-01f, 1.02702059e-01f, -8.67065191e-01f,
  2.84364790e-01f, -6.28354847e-01f, -1.17858082e-01f, -1.41713351e-01f, -3.73535037e-01f, 6.86611533e-02f, 1.08815506e-01f, -2.19566196e-01f, -5.79035468e-02f, -1.22845672e-01f,
  -3.70695442e-01f, -1.02509178e-01f, -9.38094631e-02f, -5.61322309e-02f, -2.12554574e-01f, -3.30520347e-02f, -1.92993954e-01f, -2.43227467e-01f, -9.75064561e-02f, 6.63009137e-02f,
  -3.17765847e-02f, -2.33731851e-01f, -4.01486233e-02f, 7.70264715e-02f, 1.07878208e-01f, -2.18737386e-02f, 1.59805685e-01f, -7.88841620e-02f, -2.06043795e-01f, -3.42424840e-01f,
  -1.64383665e-01f, 1.49567023e-01f, 2.07285613e-01f, 1.30618408e-01f, 2.48153834e-03f, 6.85799792e-02f, -8.15256834e-02f, -1.65894672e-01f, 1.31477907e-01f, 8.51414874e-02f,
  -1.57300085e-01f, -1.39417261e-01f, 9.30318683e-02f, -6.68919906e-02f, -1.59519520e-02f, -1.01647869e-01f, 2.04719871e-01f, 9.29459333e-02f, -1.08644202e-01f, -2.32844099e-01f,
  -1.38632923e-01f, 2.48298962e-02f, -6.78536296e-02f, 2.87726760e-01f, -2.34622478e-01f, -2.45548964e-01f, -6.63758218e-02f, 2.89464504e-01f, -2.31606551e-02f, -1.78604312e-02f,
  5.73656440e-01f, 1.01944000e-01f, -1.71328872e-01f, 3.48565549e-01f, -3.10278982e-01f, -6.30377010e-02f, -3.97771895e-02f, 1.47786066e-01f, 1.43553372e-02f, 6.68632165e-02f,
  9.51788798e-02f, 8.33622292e-02f, 6.08526077e-03f, 1.62465796e-01f, -8.91473815e-02f, 9.02180895e-02f, -1.02268435e-01f, -9.08732116e-02f, -4.45558801e-02f, 2.50718128e-02f,
  -1.75854489e-01f, -7.03042299e-02f, 3.09766769e-01f, 2.05630541e-01f, -4.20083702e-02f, 9.27228108e-03f, 5.23531616e-01f, 2.28054881e-01f, 2.54380167e-01f, 1.00965776e-01f,
  -9.45480049e-01f, -6.99216545e-01f, 2.52119571e-01f, 3.00780147e-01f, 1.85090631e-01f, -3.03159833e-01f, -7.70468533e-01f, -3.86210650e-01f, 1.68521225e-01f, -4.32635158e-01f,
  -1.18551292e-01f, 2.57123172e-01f, 3.73820662e-01f, 3.79666388e-02f, -3.19716543e-01f, -1.03935704e-01f, 4.96090084e-01f, 2.89126128e-01f, -6.07826635e-02f, -9.44599137e-02f,
  3.78333122e-01f, 3.60724092e-01f, -5.60351126e-02f, 2.01568022e-01f, 1.19219072e-01f, 1.42828584e-01f, 3.74224961e-01f, 1.26435667e-01f, -3.64342362e-01f, 7.31297731e-02f,
  -3.28624815e-01f, -6.73476815e-01f, 2.72407502e-01f, -4.59158886e-03f, 2.13749632e-02f, -3.81603211e-01f, -1.71976000e-01f, 1.04410484e-01f, 5.60132973e-02f, 5.44150099e-02f,
  2.22725034e-01f, -1.91530138e-01f, 3.28767151e-01f, 7.17058107e-02f, 1.28276423e-02f, -7.36168548e-02f, -6.46783337e-02f, -3.81402969e-02f, -2.02263519e-02f, -2.75730193e-01f,
  1.73121378e-01f, 8.63793120e-02f, -2.39250794e-01f, -1.86376661e-01f, -1.25739619e-01f, 2.67055541e-01f, -1.62122518e-01f, -2.59642065e-01f, -5.98207057e-01f, -6.45449519e-01f,
  -3.83675210e-02f, 1.13937251e-01f, -6.03471212e-02f, -1.27933502e-01f, 8.60652998e-02f, -3.09822392e-02f, 1.68247074e-01f, -3.77365276e-02f, 1.23908289e-01f, -4.17179838e-02f,
  9.73836035e-02f, -1.18567357e-02f, -4.47795261e-03f, -5.47644757e-02f, -5.21741807e-03f, 8.40872899e-02f, 1.80504739e-01f, -8.18140730e-02f, 9.64240879e-02f, -1.62716269e-01f,
  -1.30940989e-01f, 1.41101271e-01f, 1.36802450e-01f, 3.37946117e-02f, -1.50216892e-01f, 5.24731539e-02f, -4.47418820e-03f, -2.56221771e-01f, -2.23504044e-02f, -8.85934681e-02f,
  1.47345752e-01f, 1.61241412e-01f, -1.30344331e-01f, -2.65837777e-02f, 9.11003798e-02f, 7.87550807e-02f, 1.06592782e-01f, -9.96244997e-02f, -5.61813079e-02f, -1.20490789e-01f,
  -1.38025805e-01f, -1.19614437e-01f, 4.70828405e-03f, 6.58305511e-02f, -2.33260728e-02f, -1.26811773e-01f, -3.59385386e-02f, 9.86776277e-02f, -1.04555480e-01f, 1.00674488e-01f,
  -4.86290306e-02f, -2.70304203e-01f, -4.97309387e-01f, -2.07021549e-01f, 1.08693011e-01f, -2.71785408e-01f, -2.61644542e-01f, -9.52049568e-02f, -2.22317025e-01f, -6.66235745e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  9.58420992e-01f, 4.32798535e-01f, 5.31922817e-01f, 3.32141876e-01f, 7.35323966e-01f, 8.47892702e-01f, 1.16050088e+00f, 4.49682355e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.56806365e-01f, 2.32130408e-01f, -7.50858337e-02f, -5.91450091e-03f, -8.92110318e-02f, 2.08779886e-01f, 4.36354131e-02f, 1.63439989e-01f, -1.22160330e-01f, 1.27660125e-01f,
  3.98598552e-01f, -4.49881144e-03f, 4.08996433e-01f, 2.12025028e-02f, -3.35689992e-01f, -4.48465139e-01f, 3.61871198e-02f, -2.15367362e-01f, 1.44120872e-01f, -7.46429190e-02f,
  -1.15608618e-01f, 5.04442334e-01f, -3.39155942e-02f, 3.51133496e-01f, -5.08754253e-01f, 7.03174397e-02f, 2.33319834e-01f, -3.95260789e-02f, -4.17798609e-01f, -3.08608204e-01f,
  2.16140792e-01f, -5.39103985e-01f, 2.34448947e-02f, -9.35095176e-02f, -1.80979744e-01f, -1.43131167e-01f, 6.77554831e-02f, -3.87168080e-01f, -1.07356608e-01f, -3.96228075e-01f,
  -4.13873076e-01f, 5.93644120e-02f, -2.74519652e-01f, 2.97446430e-01f, 5.24527848e-01f, -2.05515742e-01f, -5.23701943e-02f, 5.47637651e-03f, 3.21164787e-01f, -5.76809719e-02f,
  2.19026208e-01f, -9.24059283e-03f, 1.30455256e-01f, 3.10368001e-01f, -5.67836761e-02f, 5.67623079e-01f, 3.51685852e-01f, -5.42430758e-01f, 5.46354540e-02f, -1.05905004e-01f,
  -4.69119519e-01f, 6.37657762e-01f, 8.36097598e-02f, -3.67291331e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.45372647e-01f, 1.75775677e-01f, 1.35815054e-01f, 2.59209365e-01f, 1.53435394e-01f, 2.52284378e-01f, -3.14302891e-01f, 1.31019339e-01f, 6.19149923e-01f, -5.65102696e-02f,
  8.44935477e-01f, 7.10464001e-01f, 9.89048600e-01f, -7.44630814e-01f, -9.67187524e-01f, 1.31804144e+00f, 5.92976093e-01f, -1.17977448e-01f, 1.64668038e-01f, 2.80732870e-01f,
  2.59807289e-01f, -1.45080099e-02f, -4.89303619e-02f, 4.52978238e-02f, 3.14009041e-01f, 1.69309795e-01f, -6.12106204e-01f, 7.72475362e-01f, 1.18285000e+00f, -3.44496459e-01f,
  1.10644126e+00f, -3.97126138e-01f, 5.15665650e-01f, 5.97571254e-01f, 2.20309079e-01f, 3.35561454e-01f, -7.51554430e-01f, 2.32687518e-01f, -2.40165144e-01f, -3.16287875e-01f,
  -1.52163398e+00f, -8.16902876e-01f, -3.51629674e-01f, 1.63679644e-01f, 3.34977448e-01f, 6.10524476e-01f, 6.55549824e-01f, 1.39383793e-01f, 4.02500659e-01f, 1.99015707e-01f,
  3.04792702e-01f, 5.16028285e-01f, 2.63497412e-01f, -5.63106835e-01f, 5.83746284e-02f, -4.68807250e-01f, 8.13344836e-01f, 9.98526514e-02f, -1.53450891e-01f, -1.09502470e+00f,
  1.22099221e+00f, 2.02202514e-01f, 5.06465957e-02f, 1.63117170e+00f, 2.27053583e-01f, -5.57842962e-02f, 3.33794653e-01f, -1.78084075e-02f, 1.74165189e-01f, -5.51499873e-02f,
  -2.97428183e-02f, -5.95371239e-02f, 7.81681955e-01f, 1.01268888e+00f, 1.03970885e+00f, -2.76030064e-01f, 2.08231822e-01f, 6.55393183e-01f, -7.82058954e-01f, -1.14282978e+00f,
  6.63468301e-01f, -4.17048275e-01f, 2.05223203e-01f, 5.48152149e-01f, 4.33458418e-01f, 7.73461819e-01f, -4.66283917e-01f, 1.02580059e+00f, 3.36536169e-01f, -4.88746643e-01f,
  2.82240570e-01f, -2.01146916e-01f, 1.04594730e-01f, 1.28524828e+00f, 2.73541272e-01f, -3.64494771e-01f, -1.80293694e-01f, 8.80315483e-01f, -1.93170831e-01f, -1.18497469e-01f,
  -6.21925056e-01f, 3.68462682e-01f, 3.78400721e-02f, -3.38992119e-01f, -2.78969258e-01f, 4.58491713e-01f, -2.83974022e-01f, 1.61754236e-01f, -9.10416126e-01f, 1.15783918e+00f,
  1.06666780e+00f, -7.94597626e-01f, 9.57489610e-01f, 5.48169196e-01f, 4.69625562e-01f, 4.81144071e-01f, -8.35457027e-01f, 1.26401699e+00f, 3.57402295e-01f, -7.92849958e-01f,
  -1.60371542e+00f, 3.01530302e-01f, 1.08028436e+00f, -3.82677287e-01f, 5.34771562e-01f, -6.37490511e-01f, 2.83769280e-01f, -2.56459594e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  4.49267089e-01f, 2.07669571e-01f, 1.20933175e+00f, 1.57529995e-01f, 4.50824976e-01f, -9.59753543e-02f, -4.72671129e-02f, 9.57496107e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -4.89181548e-01f, -7.52597511e-01f, -1.29126871e+00f, -9.98172700e-01f, -7.11324096e-01f, -5.51330984e-01f, -5.77058554e-01f, 5.65340638e-01f, -4.38782692e-01f, 2.55796462e-01f,
  5.50930560e-01f, 2.50475764e-01f, 1.83848098e-01f, -7.74273217e-01f, -5.83790004e-01f, -5.65151405e-03f, 8.33942771e-01f, 5.81604242e-01f, 1.05562918e-01f, 1.59412056e-01f,
  -7.99811423e-01f, 8.53891492e-01f, 8.23547602e-01f, -4.07772720e-01f, -4.72233385e-01f, 9.23541337e-02f, 5.19380569e-01f, -5.91503680e-01f, 4.45565581e-01f, -1.17099321e+00f,
  7.27790177e-01f, 4.78008032e-01f, 1.61453098e-01f, 3.00428510e-01f, 1.08373791e-01f, -5.98464012e-02f, -1.16505992e+00f, -6.93817496e-01f, -1.25031686e+00f, -5.80038726e-01f,
  8.24791193e-02f, -1.33917618e+00f, 5.68111062e-01f, 7.60571659e-01f, -8.75032067e-01f, -1.22510292e-01f, -3.43216658e-01f, 2.53802180e-01f, -1.24365771e+00f, -1.08986521e+00f,
  3.65699410e-01f, 9.06536698e-01f, -9.46960509e-01f, -1.01687014e+00f, -8.63674879e-01f, 6.68491304e-01f, -9.43621278e-01f, 4.44744974e-01f, -1.84928870e+00f, 3.35948795e-01f,
  -1.44028604e+00f, 1.05001378e+00f, -3.49937439e-01f, -1.07372010e+00f, 6.58910930e-01f, -5.23255825e-01f, 2.02362597e-01f, -6.66792214e-01f, 3.98776054e-01f, 6.89725280e-01f,
  1.26801622e+00f, -1.00019574e+00f, -9.99344289e-02f, 4.02605861e-01f, -7.84839511e-01f, 6.82109535e-01f, -4.44664881e-02f, -7.85728514e-01f, -2.56385982e-01f, -1.08090591e+00f,
  7.51091778e-01f, 6.11167848e-01f, 3.34322363e-01f, 5.44076979e-01f, 1.53274965e+00f, -3.32590640e-01f, 1.39159858e+00f, -2.11479053e-01f, -1.15520664e-01f, 1.09778747e-01f,
  4.81042445e-01f, -1.44742310e-01f, -5.72376013e-01f, 6.74611509e-01f, -8.77396822e-01f, 3.05297375e-01f, -3.66223931e-01f, 1.72029778e-01f, -6.83844209e-01f, 1.06697702e+00f,
  -1.97088063e-01f, 1.26100612e+00f, 1.33397570e-02f, 8.78267512e-02f, -7.17704147e-02f, -4.65271235e-01f, -8.12487245e-01f, -1.13162899e+00f, 5.31793177e-01f, 1.79691866e-01f,
  -6.16841018e-01f, 8.35897386e-01f, -5.78060448e-01f, -1.16093099e+00f, 6.22269809e-01f, -3.25696588e-01f, 1.07980333e-01f, 2.83049136e-01f, 3.88411880e-01f, -3.23720336e-01f,
  8.93037200e-01f, -2.67734587e-01f, -2.27001071e-01f, -7.87088096e-01f, -5.21331489e-01f, -2.83706099e-01f, -3.14799070e-01f, -1.48457909e+00f, 5.71267188e-01f, 3.28765750e-01f,
  3.79237652e-01f, -7.64178559e-02f, 7.30460659e-02f, 1.23154871e-01f, -1.90465078e-01f, 3.98889273e-01f, -5.02316594e-01f, -1.26681232e+00f, 1.34600115e+00f, -8.69369566e-01f,
  -6.04005992e-01f, 6.48315609e-01f, 5.95201671e-01f, -4.28293377e-01f, 1.69594869e-01f, 9.41107869e-01f, 8.18208158e-01f, -1.18288326e+00f, 1.06268013e+00f, -4.77035016e-01f,
  -4.67362314e-01f, -5.50818086e-01f, 2.60513008e-01f, -8.39748800e-01f, -1.19229960e+00f, 4.73791324e-02f, 2.48348191e-01f, -9.63872433e-01f, -7.67222106e-01f, 6.70820653e-01f,
  -1.69977701e+00f, 1.90433457e-01f, -6.06998324e-01f, -7.78959215e-01f, -4.15675998e-01f, 3.92741561e-01f, -1.16237390e+00f, 1.05454159e+00f, -1.10708857e+00f, 3.60416561e-01f,
  7.77819976e-02f, -8.20016682e-01f, -1.48867869e+00f, -6.52213842e-02f, 1.01983988e+00f, -4.57619458e-01f, -7.86752522e-01f, -3.95424187e-01f, -4.04164642e-01f, 1.60075516e-01f,
  2.66977370e-01f, -5.22429347e-01f, -2.09376868e-03f, 2.21922249e-02f, -4.95543271e-01f, -8.48951221e-01f, -7.22008348e-01f, 3.42351869e-02f, 6.13263071e-01f, 4.48775202e-01f,
  4.61653620e-01f, -5.19513428e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.65095091e-01f, 1.00605071e-01f, 4.29990053e-01f, -4.44999896e-02f, -1.51567549e-01f, -3.19508016e-01f, 9.84966531e-02f, 1.50266429e-02f, 2.45916963e-01f, 1.78409234e-01f,
  -2.67903119e-01f, -5.94757199e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    