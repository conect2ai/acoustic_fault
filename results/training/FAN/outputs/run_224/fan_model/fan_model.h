/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.44875109e-01f, 2.60069311e-01f, -1.35092601e-01f, 4.14157212e-01f, -1.76887587e-01f, 1.93140373e-01f, 2.32116267e-01f, 3.66575532e-02f, -1.33054582e-02f, 3.10412228e-01f,
  1.22618809e-01f, 3.58436555e-02f, 1.31299525e-01f, 3.15750808e-01f, 1.44716695e-01f, 1.23336688e-01f, 3.10333669e-01f, 1.12797640e-01f, -5.35248443e-02f, 1.30838409e-01f,
  -4.85225134e-02f, 3.17443937e-01f, 2.91464888e-02f, 1.44339530e-02f, -1.51863452e-02f, -1.22197047e-01f, 8.27647299e-02f, -1.36114240e-01f, 8.67810398e-02f, -1.91962440e-02f,
  -7.43585750e-02f, -1.15613066e-01f, -3.90433036e-02f, -2.46139076e-02f, 5.13531268e-02f, 2.16824710e-02f, 3.40999402e-02f, -1.53583579e-03f, -2.62818253e-03f, 2.68289191e-03f,
  -6.34660246e-03f, -5.04585654e-02f, 1.58524010e-02f, -3.80086415e-02f, -2.93879136e-02f, -7.16862977e-02f, -2.24439520e-02f, 3.34853642e-02f, -3.76639292e-02f, 2.17817463e-02f,
  -3.01936269e-02f, 6.67640492e-02f, -3.97810861e-02f, 6.60319999e-02f, -7.08620921e-02f, 2.29785405e-03f, 3.99234220e-02f, -2.53308062e-02f, 2.39663608e-02f, -1.37265678e-02f,
  -7.05832895e-03f, 1.93096381e-02f, 8.31673481e-03f, -2.34338478e-03f, 1.27909956e-02f, 2.32814979e-02f, -6.47065137e-03f, -1.03449952e-02f, -1.62644163e-02f, -3.04889958e-03f,
  3.64699475e-02f, 4.72205365e-03f, -3.56532596e-02f, 1.95328072e-02f, 1.49724679e-02f, 2.60751173e-02f, 1.29495375e-02f, 1.44374638e-03f, 9.75971017e-03f, -1.82624906e-02f,
  1.52959665e-02f, 1.49909556e-02f, -8.48840363e-03f, 2.06341203e-02f, 2.54742131e-02f, 5.50875627e-03f, 2.89422590e-02f, -1.56099331e-02f, 8.54749605e-03f, -1.40149398e-02f,
  2.87016034e-01f, 1.44479141e-01f, 2.22555436e-02f, -1.46367354e-02f, 1.34969447e-02f, -5.08280136e-02f, 1.67671889e-02f, -4.14670557e-02f, -7.17622088e-03f, -5.89697901e-03f,
  -2.80765351e-02f, 3.04369200e-02f, 2.70864312e-02f, -3.59797920e-03f, 3.49118002e-02f, 5.15790097e-02f, 6.18538149e-02f, -6.99123787e-03f, 7.19626173e-02f, -1.31175676e-02f,
  2.75464673e-02f, -4.62451205e-02f, -3.19600441e-02f, -5.14172651e-02f, 4.21040580e-02f, 2.49771331e-03f, -9.63344425e-03f, -2.28771027e-02f, -5.61594889e-02f, 7.70920590e-02f,
  6.56576753e-01f, -9.03910846e-02f, 2.45169669e-01f, -3.48332785e-02f, 1.83564857e-01f, 5.05136549e-02f, 2.41990350e-02f, 1.02188520e-01f, 3.56514513e-01f, -2.61681266e-02f,
  2.89575215e-02f, 2.76515424e-01f, -6.43343180e-02f, -9.37202275e-02f, 2.75814980e-01f, -1.60540104e-01f, 1.29099622e-01f, 2.98711229e-02f, 1.55929988e-03f, 1.37490942e-03f,
  6.37126788e-02f, -1.55599222e-01f, -2.32333643e-03f, -1.38090342e-01f, 4.53056470e-02f, 2.25234926e-02f, -3.34902741e-02f, -9.23980176e-02f, -1.49485106e-02f, -5.08232770e-05f,
  -1.53707027e-01f, -1.55448556e-01f, 2.91894265e-02f, -5.69950964e-04f, 5.22652455e-02f, 6.10117763e-02f, -4.12816890e-02f, -2.06512287e-02f, 3.32573093e-02f, -9.59252939e-04f,
  1.06112650e-02f, 3.61928828e-02f, -3.09028234e-02f, -5.61687723e-03f, 6.93062246e-02f, 3.83317992e-02f, -1.81617010e-02f, -1.16390698e-02f, 4.85265069e-03f, -9.08573866e-02f,
  -1.53049612e-02f, 3.46433977e-03f, 1.58147030e-02f, -3.09010260e-02f, 5.32064699e-02f, -8.55438411e-03f, 4.90267761e-02f, 3.16906050e-02f, 5.15863416e-04f, 1.45390490e-02f,
  -9.64690000e-03f, 6.06284589e-02f, 4.53528576e-02f, -3.58610451e-02f, 9.29584354e-03f, 6.79488177e-04f, 5.50523773e-02f, -2.70865262e-02f, 2.81943250e-02f, 9.71834548e-03f,
  3.63665558e-02f, -2.31460556e-02f, 1.50843496e-02f, 6.91393670e-03f, -2.64414083e-02f, -1.01948930e-02f, 4.72712703e-02f, -1.03131486e-02f, 7.25702383e-03f, -1.30727580e-02f,
  -5.64837195e-02f, 2.83196401e-02f, -1.57458857e-02f, -2.11807042e-02f, 1.32454010e-02f, 1.13227880e-02f, 1.22717610e-02f, -4.19599824e-02f, -1.10274460e-02f, 1.88402459e-02f,
  1.31983999e-02f, 1.22522257e-01f, -5.37316455e-03f, -1.70844011e-02f, -2.46188194e-02f, -2.54253950e-02f, -3.36287473e-03f, 7.53256083e-02f, -1.92067549e-02f, -3.34231183e-02f,
  2.47400589e-02f, 2.59047505e-02f, 3.39532420e-02f, -2.67856568e-02f, -3.32978852e-02f, -1.79196373e-02f, -1.17309401e-02f, 5.45636415e-02f, 5.06940559e-02f, 2.23479401e-02f,
  -2.45498903e-02f, -5.23291274e-05f, 1.20201595e-02f, -3.27230282e-02f, -3.76177579e-02f, 3.01995594e-02f, 1.05131054e-02f, 3.67681473e-03f, 1.91071220e-02f, 4.84168604e-02f,
  -3.20859045e-01f, -3.38502489e-02f, -2.27298424e-01f, 2.10929930e-01f, 6.51387647e-02f, 4.39085752e-01f, 1.61223471e-01f, 6.09991094e-03f, 2.72745579e-01f, -8.74933694e-03f,
  -5.36709912e-02f, 2.74206474e-02f, -1.32067963e-01f, 2.52401143e-01f, 1.54113069e-01f, 1.67380318e-01f, 2.16373757e-01f, 6.06057942e-02f, 9.81509089e-02f, -5.91697171e-02f,
  5.20486645e-02f, -2.90318895e-02f, -4.29733060e-02f, -7.94433504e-02f, -9.68280733e-02f, -9.36231911e-02f, -2.25387543e-01f, -1.35371566e-01f, -1.08718000e-01f, -2.36757714e-02f,
  4.32887003e-02f, 4.36805002e-02f, -1.10908836e-01f, -4.60490175e-02f, -1.22237690e-01f, -1.09112799e-01f, -2.47460213e-02f, -1.47038456e-02f, -3.44607197e-02f, 7.61105418e-02f,
  2.93307528e-02f, 8.17519787e-04f, 1.73459351e-02f, 1.77575592e-02f, 4.71666940e-02f, -1.21819740e-03f, 3.61349657e-02f, 1.19070806e-01f, 6.45850375e-02f, 3.02857645e-02f,
  1.02136254e-01f, 4.69060801e-02f, -6.56795502e-03f, 1.46148475e-02f, -4.43490855e-02f, 2.43166089e-02f, 1.58476608e-03f, 2.02462934e-02f, -5.06228488e-03f, 1.21967405e-01f,
  8.65444541e-03f, -7.42682442e-02f, -6.31817058e-02f, 2.99358973e-03f, -4.60583568e-02f, -1.02912225e-01f, -1.79278683e-02f, -3.82333435e-02f, -3.73105220e-02f, -7.15139322e-04f,
  5.15747480e-02f, 1.63030960e-02f, 4.74623628e-02f, 3.39420289e-02f, 2.31746808e-02f, 1.95943676e-02f, -3.16782966e-02f, 8.58636387e-03f, 8.37679058e-02f, -7.79312290e-03f,
  9.64818057e-04f, 6.31879456e-03f, -7.67217856e-03f, 3.19933817e-02f, 2.76534841e-03f, -3.39757204e-02f, 2.43689269e-02f, 1.45670529e-02f, 1.13178166e-02f, -4.01038826e-02f,
  5.37758954e-02f, -1.82388872e-01f, 7.41367042e-02f, 2.98386160e-02f, -4.78828931e-03f, 4.06939536e-02f, -1.33776134e-02f, 7.83237442e-03f, -3.46150547e-02f, -2.66465750e-02f,
  -2.90561859e-02f, -3.36013027e-02f, -4.36561331e-02f, 4.22132248e-03f, 2.91729113e-03f, 7.93337524e-02f, -7.77356625e-02f, -1.04071453e-01f, -4.37449068e-02f, 7.19271926e-03f,
  -6.57548606e-02f, -3.12501714e-02f, 3.11051328e-02f, -3.28013003e-02f, 3.59093137e-02f, -1.83936805e-02f, 3.71410437e-02f, 2.45291162e-02f, 1.99281680e-03f, -2.50588497e-03f,
  4.86070395e-01f, -5.81375122e-01f, 7.91625008e-02f, -1.55669346e-01f, 1.99085444e-01f, -2.34090853e-02f, 1.50382623e-01f, -1.46616846e-01f, 1.33758932e-01f, -3.22213054e-01f,
  6.35727122e-02f, -1.52050465e-01f, 1.06444531e-04f, -4.19507362e-02f, 2.90543973e-01f, 3.30497436e-02f, 1.15866415e-01f, -3.54572758e-02f, 1.14410326e-01f, -1.05189472e-01f,
  2.97202487e-02f, 7.76934028e-02f, 1.44442722e-01f, -7.35881552e-02f, 6.17912672e-02f, 2.33758502e-02f, -3.25259306e-02f, -5.10566346e-02f, -7.42942318e-02f, 6.63716346e-02f,
  3.41922671e-01f, -8.60998333e-02f, -5.93857840e-02f, -1.43330349e-02f, -6.77294806e-02f, -5.62723577e-02f, -1.84926037e-02f, 2.58728061e-02f, -1.00458544e-02f, 1.96040533e-02f,
  -1.16121769e-02f, -4.39657308e-02f, 7.34291151e-02f, 3.99814770e-02f, 2.06810180e-02f, -4.95290756e-02f, 7.00504854e-02f, 1.23847425e-01f, -3.56003456e-02f, 5.14520705e-02f,
  6.00330681e-02f, 7.36888126e-03f, -5.47941439e-02f, 3.32113355e-02f, -1.90270003e-02f, -1.37244752e-02f, -1.33808320e-02f, -6.00465387e-02f, -1.36740860e-02f, -3.07866391e-02f,
  1.29875252e-02f, -4.00458053e-02f, -9.89611633e-03f, -1.60229094e-02f, -8.74965265e-02f, 2.02424768e-02f, -2.01361179e-02f, 2.65622772e-02f, -1.48827955e-02f, 1.35970616e-03f,
  -1.73421651e-02f, -5.32608666e-02f, 3.49723361e-03f, -2.58662496e-02f, 2.88130548e-02f, 1.34620778e-02f, -2.75907442e-02f, -2.84601115e-02f, 9.14169922e-02f, 2.96032950e-02f,
  7.57185593e-02f, 4.07353137e-03f, 1.62466466e-02f, 1.78314876e-02f, -6.16568513e-02f, -3.38420644e-02f, 1.54289119e-02f, -6.80025714e-03f, 3.68077531e-02f, -2.25238539e-02f,
  -2.50995040e-01f, -2.36237481e-01f, 7.04118609e-02f, 2.40823720e-02f, -4.65886630e-02f, -1.84942689e-02f, 8.67891759e-02f, 6.76905224e-03f, -2.29907930e-02f, 2.54447646e-02f,
  -2.83971708e-02f, -2.70630270e-02f, -6.04155660e-02f, -7.54411928e-07f, 3.12812366e-02f, -2.17720494e-03f, -6.43658340e-02f, -9.51165557e-02f, -1.41981076e-02f, 1.98046081e-02f,
  -3.13560218e-02f, -8.80083721e-03f, -1.10001266e-02f, -2.75818612e-02f, 3.75659019e-02f, -1.98177099e-02f, 1.15295155e-02f, -6.22161198e-03f, -1.82705820e-02f, -1.49855614e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.89542815e-01f, -1.04628645e-01f, -4.50083949e-02f, -4.45288606e-02f, 1.99258719e-02f, -1.42824128e-02f, -3.44547816e-02f, -1.15356751e-01f, -2.70933539e-01f, 2.21653521e-01f,
  -5.72504513e-02f, 4.28524762e-02f, -1.26863107e-01f, -1.52773753e-01f, -3.54701430e-01f, -3.39089096e-01f, -1.13105744e-01f, 7.05446228e-02f, -1.88517332e-01f, -8.12604185e-03f,
  -7.23949596e-02f, -1.54997572e-01f, -7.59682804e-02f, 6.69095889e-02f, 9.63640809e-02f, 2.10493118e-01f, 2.04009265e-01f, 7.73894191e-02f, 1.36776865e-01f, -8.03078413e-02f,
  -1.05045885e-01f, -1.69393733e-01f, 9.67198089e-02f, -5.96265681e-02f, 7.12559521e-02f, 6.33765385e-02f, 9.97366384e-02f, 3.91604408e-04f, -3.29516493e-02f, 9.27371439e-03f,
  5.52920811e-02f, -2.56327279e-02f, -2.17981283e-02f, -1.55734923e-03f, -7.27574481e-03f, -4.84643765e-02f, 2.92641260e-02f, 3.24783917e-03f, 6.34234324e-02f, -1.35376789e-02f,
  -6.31022379e-02f, 6.41319975e-02f, -6.33784570e-03f, 2.45755650e-02f, -1.57396290e-02f, 2.11483445e-02f, 3.30365188e-02f, 1.03334516e-01f, 6.14670012e-03f, 3.46682407e-03f,
  5.54553308e-02f, -3.24594155e-02f, -1.13728039e-01f, -4.46806941e-03f, -3.59749645e-02f, -6.84726983e-02f, -5.68374023e-02f, 2.33984012e-02f, -3.31310108e-02f, 1.56683512e-02f,
  2.31522247e-02f, 8.55749995e-02f, -8.51124227e-02f, 5.13788238e-02f, 1.24722878e-02f, -3.93144675e-02f, 6.54131994e-02f, 5.13941497e-02f, 2.07435824e-02f, -1.28031829e-02f,
  -7.84204453e-02f, -1.14038689e-02f, -1.43446885e-02f, 5.35958298e-02f, -4.53748032e-02f, 1.19022131e-01f, 1.71723048e-04f, 3.24476371e-03f, -2.64704302e-02f, 4.78451094e-03f,
  4.12913933e-02f, -2.11077668e-02f, 1.56911574e-02f, -6.11940213e-03f, -1.28040714e-02f, 5.50365411e-02f, -1.72677055e-01f, -1.25080477e-02f, -5.75611182e-02f, -1.11570597e-01f,
  6.75969496e-02f, 4.74365614e-02f, 5.00347018e-02f, -9.98086669e-03f, -5.83966495e-03f, 1.22547656e-01f, 5.39230108e-02f, -2.22472590e-03f, 8.36576298e-02f, 7.08929673e-02f,
  3.72013114e-02f, 1.27553791e-02f, -6.28493056e-02f, 6.16086312e-02f, 4.81832363e-02f, 4.75647710e-02f, 1.05798896e-02f, 3.50686833e-02f, 8.35504979e-02f, 1.85190979e-02f,
  3.80279332e-01f, 4.88224924e-02f, -1.36295289e-01f, -3.23139988e-02f, -8.20891857e-02f, -3.80114540e-02f, -4.74376380e-02f, 3.69351245e-02f, -6.90069944e-02f, 8.68492946e-02f,
  3.99316736e-02f, 3.30057628e-02f, 7.42697120e-02f, 3.62415798e-02f, 1.18769176e-01f, -1.22813201e-02f, 1.33573368e-01f, 1.01319283e-01f, -3.59018659e-03f, 7.24763721e-02f,
  7.93104023e-02f, 5.99881932e-02f, -6.00476675e-02f, 7.30178691e-03f, 3.03944442e-02f, 8.47385526e-02f, 1.71417624e-01f, 4.10167016e-02f, -1.98137388e-02f, -3.58387120e-02f,
  2.29502078e-02f, 4.06493573e-03f, -6.62157163e-02f, -2.65177973e-02f, 4.49631317e-03f, 9.81667079e-03f, 3.93849099e-03f, 5.39075844e-02f, 5.58439344e-02f, -1.86650008e-02f,
  4.22382280e-02f, -6.24337569e-02f, -4.42567952e-02f, 3.52950394e-02f, -1.97270401e-02f, 3.43470019e-03f, -7.12160617e-02f, 1.62602533e-02f, -1.37395367e-01f, 5.19905146e-03f,
  -6.08502328e-03f, -9.67961624e-02f, 7.88837858e-03f, -7.30704218e-02f, -2.34850496e-02f, -5.19502126e-02f, -7.37181231e-02f, -5.57109155e-02f, -2.75677373e-03f, -4.42773625e-02f,
  4.55760397e-02f, -2.53409584e-04f, -4.93884124e-02f, -6.79830760e-02f, -1.31188810e-01f, -4.75075431e-02f, 3.62963006e-02f, 8.93817190e-03f, -5.01529425e-02f, 2.10022237e-02f,
  1.80323943e-02f, -9.43394825e-02f, 2.72529963e-02f, -1.03331208e-02f, 1.66932754e-02f, 1.60993915e-02f, 2.72597373e-02f, -2.44888216e-02f, -3.41277607e-02f, 5.86362369e-02f,
  -5.63440099e-02f, -4.43066563e-03f, 3.54614817e-02f, 6.06221072e-02f, 6.56021610e-02f, -4.58233021e-02f, 3.71042527e-02f, 3.33519541e-02f, -8.27581510e-02f, 7.47566000e-02f,
  3.58876283e-03f, 9.46235135e-02f, 2.96960287e-02f, -6.74571320e-02f, 1.27500454e-02f, -1.80108547e-02f, 2.20196638e-02f, 5.98561615e-02f, 7.55195972e-03f, 4.03788947e-02f,
  -5.21510206e-02f, 4.02482189e-02f, -9.55318939e-03f, -7.96414167e-02f, 4.21613790e-02f, -4.24250402e-02f, 2.45853700e-02f, 1.26277404e-02f, 3.75559963e-02f, 7.01282080e-03f,
  -3.32117751e-02f, -5.31319827e-02f, 9.45945457e-02f, -1.14581324e-02f, -6.11070963e-03f, 2.43291780e-02f, 1.84401497e-02f, 4.35606949e-02f, 3.04111298e-02f, -8.07932753e-04f,
  6.99183643e-02f, 1.15939073e-01f, -9.54252183e-02f, 7.61205032e-02f, -6.84884638e-02f, 1.23801976e-01f, -1.28566012e-01f, -6.43157912e-03f, 4.78672013e-02f, -1.41060442e-01f,
  -7.76417926e-02f, 3.80836464e-02f, 5.06818667e-02f, -6.37998953e-02f, 1.47828683e-01f, 6.38116077e-02f, 1.32612452e-01f, 1.85043663e-02f, 7.14606792e-02f, -1.69913899e-02f,
  5.92093095e-02f, 6.97234422e-02f, 7.96106011e-02f, -1.69324763e-02f, -1.38645902e-01f, 4.31804396e-02f, 3.06730508e-03f, -6.09287471e-02f, -9.01880115e-02f, -4.61861603e-02f,
  3.09957247e-02f, -1.14738666e-01f, -9.29071233e-02f, -1.09721050e-01f, 7.71669224e-02f, 2.36014649e-02f, 3.70147196e-03f, -5.43626100e-02f, 6.79499507e-02f, -7.62706809e-03f,
  7.55887032e-02f, -1.72965806e-02f, -6.95299357e-02f, 1.53415287e-02f, -5.26233092e-02f, -3.79828624e-02f, 4.24946100e-03f, -1.92148611e-02f, 1.44920452e-02f, 4.36831489e-02f,
  -2.82426588e-02f, -5.30405268e-02f, -6.86743706e-02f, 1.73493978e-02f, -7.15401620e-02f, 6.54218122e-02f, 9.34268460e-02f, -2.58461852e-02f, -8.64378884e-02f, -1.48112690e-02f,
  3.53417844e-02f, 3.88280973e-02f, 5.29854139e-03f, -9.67204347e-02f, 7.77728781e-02f, -5.14027029e-02f, 4.52165082e-02f, -1.43511230e-02f, 5.08671105e-02f, 3.05514727e-02f,
  -5.12658507e-02f, 4.87016467e-03f, -5.34349643e-02f, 3.98324663e-03f, 4.22382839e-02f, -6.47864044e-02f, -2.85144579e-02f, 5.97991161e-02f, -1.13083655e-02f, 1.12320207e-01f,
  4.35798094e-02f, 7.47321919e-02f, -9.44111645e-02f, -1.03652366e-02f, 8.13071579e-02f, -7.21268058e-02f, 8.84738192e-03f, -5.37917763e-02f, -1.37406578e-02f, 7.28299171e-02f,
  3.75335552e-02f, 7.85286650e-02f, -4.27901894e-02f, -1.85906962e-02f, 3.63895707e-02f, 7.54021108e-02f, 1.98327955e-02f, -8.34389254e-02f, 3.49318632e-03f, 8.78035370e-03f,
  8.10611155e-03f, -9.35311094e-02f, -1.32109607e-02f, -2.93304212e-02f, 5.17808460e-02f, -1.32190678e-02f, 3.97305116e-02f, -3.58262472e-03f, 1.23169981e-01f, 2.22278410e-03f,
  -2.41008233e-02f, -6.45782575e-02f, 9.89133790e-02f, -2.10627331e-04f, -3.00662816e-02f, -3.48677672e-03f, -6.00206368e-02f, 9.61882547e-02f, 1.15292231e-02f, -5.38711026e-02f,
  3.36767703e-01f, -1.51720300e-01f, -4.16797936e-01f, 1.04149930e-01f, 2.04588592e-01f, 1.12821981e-01f, -2.80871183e-01f, 6.54696375e-02f, -2.99187392e-01f, -1.14340827e-01f,
  1.21938355e-01f, 1.84201300e-01f, -3.70068967e-01f, 4.87963051e-01f, 3.97173554e-01f, -1.23705007e-01f, 2.47684449e-01f, 7.23359659e-02f, -4.58466336e-02f, 8.29104856e-02f,
  1.90341145e-01f, 4.84569401e-01f, 7.23685920e-02f, 3.25227261e-01f, 2.81983972e-01f, 2.93807220e-02f, 3.07946742e-01f, -1.08528599e-01f, 4.95051056e-01f, 1.96193337e-01f,
  1.05775036e-01f, 4.64571528e-02f, -1.74491648e-02f, -7.11264834e-02f, -3.99981486e-03f, -1.27061326e-02f, -6.78712279e-02f, 3.25634480e-02f, -4.70282249e-02f, -4.00623344e-02f,
  4.36083898e-02f, 7.70353302e-02f, 4.43284065e-02f, 3.10899634e-02f, 3.44541185e-02f, -2.96347141e-02f, -2.49219202e-02f, -4.90944423e-02f, -1.03327572e-01f, -2.43648738e-02f,
  -1.28078565e-01f, 9.33843255e-02f, -1.59849506e-02f, -2.80939415e-02f, -1.55795468e-02f, -4.09558155e-02f, 7.13536065e-05f, -9.23028775e-03f, 2.31894311e-02f, 6.30284250e-02f,
  1.13222100e-01f, -4.37596664e-02f, 1.98026057e-02f, 5.99335432e-02f, 3.73236164e-02f, 3.63989063e-02f, 2.36099381e-02f, 4.43295017e-02f, -4.57519442e-02f, 2.84700673e-02f,
  2.01387089e-02f, -1.51593168e-03f, -2.45998017e-02f, -1.29422052e-02f, -1.41793408e-03f, -2.16760505e-02f, 5.35063036e-02f, 5.63583821e-02f, -8.14644471e-02f, -2.62597594e-02f,
  -1.38169425e-02f, 1.48000419e-02f, 1.12101715e-02f, -4.32876945e-02f, -7.61195458e-03f, 1.70729104e-02f, 6.93689361e-02f, -3.19072455e-02f, -6.74744993e-02f, -6.33398220e-02f,
  1.40634673e-02f, 3.10995746e-02f, -8.06108266e-02f, 7.13032782e-02f, -2.32579131e-02f, 9.22730342e-02f, 2.91007925e-02f, 7.74917752e-02f, -6.27077976e-03f, 1.77635122e-02f,
  -2.05661841e-02f, -2.37923544e-02f, 4.91221920e-02f, 2.14573927e-02f, -1.11640934e-02f, 1.54849151e-02f, -3.83072421e-02f, 6.14061430e-02f, 1.08895533e-01f, 3.76269184e-02f,
  2.54441686e-02f, 1.69214560e-03f, -5.59691973e-02f, -2.49856152e-02f, 2.99919136e-02f, 3.53082791e-02f, -2.02382784e-02f, 3.84261720e-02f, 7.64897913e-02f, -4.16642092e-02f,
  -4.91596729e-01f, 1.47108093e-01f, -1.24148853e-01f, -1.22564279e-01f, -7.01499507e-02f, -2.91854203e-01f, -1.48908094e-01f, -3.30492109e-02f, 1.53637886e-01f, 2.33221501e-01f,
  7.75884986e-02f, 1.08487099e-01f, 3.06770235e-01f, 3.39646786e-02f, -2.18803316e-01f, 9.08354595e-02f, -1.86185703e-01f, -3.68164517e-02f, 2.08915415e-04f, -2.16473490e-01f,
  -1.69028267e-01f, -1.75976738e-01f, -1.28823847e-01f, -9.37765930e-03f, -1.32400274e-01f, 1.84164047e-02f, 5.99917062e-02f, 1.81737856e-03f, 4.98361178e-02f, 7.43302926e-02f,
  -1.16173148e-01f, -4.45248485e-02f, -2.92590144e-03f, -4.83316891e-02f, -1.65451124e-01f, -2.99008265e-02f, -7.26284012e-02f, -6.10979833e-03f, 3.63623425e-02f, -1.57395042e-02f,
  8.40733387e-03f, -6.46045757e-03f, 4.50592712e-02f, 1.61200520e-02f, -1.34371398e-02f, 2.12481562e-02f, -3.11593502e-03f, 2.31418367e-02f, 3.42554487e-02f, -5.00007086e-02f,
  1.92850344e-02f, 1.17194103e-02f, -8.85294750e-02f, 1.73518080e-02f, 4.81399335e-02f, 4.12918143e-02f, 1.57489516e-02f, -7.11534405e-03f, -4.72878888e-02f, -4.55364659e-02f,
  2.41802763e-02f, 1.58980396e-02f, 3.21292393e-02f, -1.22519638e-02f, -6.07911870e-03f, 1.89504270e-02f, 1.92782991e-02f, -3.69949043e-02f, 5.42783458e-03f, -3.80528979e-02f,
  -5.62248453e-02f, -2.16094162e-02f, -2.83910111e-02f, -2.47209370e-02f, -8.58532861e-02f, -3.56735662e-02f, 4.07720469e-02f, -3.71505693e-02f, -3.70307192e-02f, -3.00612617e-02f,
  -2.15726886e-02f, 3.56093235e-02f, -2.38358718e-03f, 8.58235639e-03f, -2.09026225e-02f, 4.65536118e-02f, 6.65433705e-02f, -4.77575622e-02f, 9.96289309e-03f, -7.13221803e-02f,
  -4.19306815e-01f, -3.74165267e-01f, 4.70042452e-02f, -5.52698411e-02f, 2.59795524e-02f, 2.06348374e-02f, 2.95063225e-03f, 1.32247023e-02f, -1.36312693e-02f, -6.85916021e-02f,
  -5.30774705e-02f, -4.11338322e-02f, -1.24500945e-01f, 1.91665709e-03f, 1.69297811e-02f, 2.54174694e-02f, 3.54575366e-02f, -3.16123292e-03f, -4.38719895e-03f, -6.78921640e-02f,
  7.53535377e-03f, -5.23154512e-02f, -1.14958908e-03f, 3.33202211e-03f, -2.26242887e-03f, -2.56111287e-02f, -6.71171471e-02f, 4.42606434e-02f, -9.78549384e-03f, 2.73235701e-02f,
  6.13752156e-02f, -3.45814735e-01f, -1.75897982e-02f, -1.15195818e-01f, -6.33345693e-02f, -2.96906054e-01f, -6.48321509e-02f, -3.86560678e-01f, -7.73965046e-02f, -2.30499491e-01f,
  -2.38837930e-03f, 2.80401677e-01f, 2.10752517e-01f, -3.25492680e-01f, 5.61214924e-01f, 1.81833103e-01f, -3.02040696e-01f, -4.87361997e-02f, -4.92941253e-02f, -2.31901318e-01f,
  -2.96465959e-02f, -3.46396029e-01f, 1.32144272e-01f, -3.85604471e-01f, -2.09367782e-01f, -1.88270286e-01f, 1.78902596e-01f, 5.88519573e-02f, -2.38134459e-01f, 3.62139903e-02f,
  1.63937882e-02f, 1.22015020e-02f, -6.86398819e-02f, 4.43996675e-02f, 2.27812957e-02f, 1.46014160e-02f, 5.25120571e-02f, 1.68193132e-01f, 4.54887841e-03f, 2.44114012e-03f,
  1.89591534e-02f, 3.25003453e-02f, -1.49477080e-01f, 1.02998028e-02f, -9.48950723e-02f, -7.23895729e-02f, 6.18622676e-02f, 3.49560268e-02f, 1.14082899e-02f, 1.02335483e-01f,
  -2.93602627e-02f, 8.62968434e-03f, -6.89990595e-02f, 2.31272746e-02f, -3.65628628e-03f, -7.62333348e-02f, -1.69313531e-02f, 8.69567469e-02f, 6.82231085e-03f, -6.95856810e-02f,
  -7.10936338e-02f, -3.19619998e-02f, 3.82707175e-03f, 1.81955397e-02f, -7.87540972e-02f, -3.44916955e-02f, -2.35108091e-04f, -3.01365880e-03f, 1.55290924e-02f, -9.02669877e-02f,
  4.19010175e-03f, -8.37139040e-03f, -3.58455293e-02f, -8.57499540e-02f, -3.00613628e-03f, -5.45525067e-02f, -6.74201548e-03f, -2.01502759e-02f, -4.54628468e-02f, -2.92894756e-03f,
  8.79902020e-03f, 3.38507048e-03f, 1.02141695e-02f, 3.99999246e-02f, 3.76855507e-02f, 7.15039000e-02f, -4.67650592e-02f, -4.19756211e-02f, 2.41707414e-02f, 3.62563804e-02f,
  -1.27112135e-01f, -1.95887551e-01f, 8.01342539e-03f, -3.73992845e-02f, -3.16146016e-03f, 1.51192141e-03f, -4.06775065e-02f, -1.25358269e-01f, -1.18166003e-02f, -4.01902311e-02f,
  -3.01422812e-02f, 2.29052566e-02f, 2.25516371e-02f, 1.42126419e-02f, 3.18597443e-02f, -2.43026167e-02f, 1.50543097e-02f, -1.97319034e-03f, -7.07469368e-03f, -7.58479461e-02f,
  1.62272956e-02f, -1.19094197e-02f, 7.29168877e-02f, -8.25003013e-02f, -2.84490716e-02f, 8.18754584e-02f, -3.13902050e-02f, 1.24318218e-02f, 4.49911207e-02f, 1.79311205e-02f,
  7.61801422e-01f, 5.64504206e-01f, 5.87740421e-01f, 5.95201492e-01f, -1.65946379e-01f, -5.63579798e-01f, -1.40983552e-01f, 5.51039539e-02f, 4.88366149e-02f, -1.47555262e-01f,
  -2.33713865e-01f, 4.86187011e-01f, -3.00316270e-02f, 2.99927741e-01f, -3.75482477e-02f, -7.87723809e-02f, 1.77727908e-01f, -1.42538063e-02f, 6.52904436e-02f, 2.50868618e-01f,
  1.28464028e-01f, -1.39319912e-01f, 2.76378483e-01f, -2.52822816e-01f, 2.04783753e-01f, 2.88584948e-01f, -2.77692825e-02f, -4.95655537e-02f, 1.75923809e-01f, -4.72812876e-02f,
  -1.61669925e-01f, 1.31461799e-01f, 1.46359324e-01f, 1.97153240e-02f, -7.43726045e-02f, 3.81829813e-02f, -1.22162048e-03f, -7.52402544e-02f, -3.20421867e-02f, 1.88984666e-02f,
  -4.48613390e-02f, -6.39186054e-02f, 2.57840529e-02f, -6.83863685e-02f, 6.46985555e-03f, 3.89057621e-02f, 8.26467574e-02f, 1.23907134e-01f, 5.09164892e-02f, 1.08379409e-01f,
  7.58216232e-02f, 9.49172005e-02f, 3.69996279e-02f, 5.61755262e-02f, 1.68848500e-01f, -4.36705351e-02f, -1.17959292e-03f, 6.04857095e-02f, 4.04782332e-02f, 1.43791996e-02f,
  -1.12753343e-02f, -4.71319258e-02f, 1.49751874e-02f, 3.59430239e-02f, -1.38741927e-02f, -3.55646946e-02f, -7.86201854e-04f, -4.89544608e-02f, 1.03561068e-02f, -4.99324687e-02f,
  -7.26489201e-02f, 3.60671096e-02f, -6.61488175e-02f, -3.43123190e-02f, 3.11730076e-02f, 5.67661189e-02f, -1.07509725e-01f, 3.01986374e-02f, 3.96362394e-02f, 9.46636647e-02f,
  -5.26975840e-02f, 2.62101293e-02f, 6.03584535e-02f, -9.03054141e-03f, -3.14998850e-02f, -3.56052886e-03f, 4.96849418e-02f, 7.35166818e-02f, -1.73056498e-02f, -8.11095461e-02f,
  4.42203972e-03f, 4.01434898e-02f, 4.32183892e-02f, -3.80158685e-02f, -3.66670601e-02f, -9.18008313e-02f, -5.40435966e-03f, 9.98262167e-02f, 4.59776707e-02f, -6.94521517e-02f,
  3.29442769e-02f, 1.45648308e-02f, -7.71110356e-02f, 4.72088866e-02f, -5.32927574e-04f, 6.19780086e-02f, 4.15590504e-04f, -4.98688109e-02f, 1.68053135e-02f, 7.31111914e-02f,
  5.18642403e-02f, -1.30516112e-01f, -1.14148960e-01f, -5.64330928e-02f, -5.81395850e-02f, 4.14422639e-02f, -2.05141287e-02f, 2.91838194e-03f, -2.03299709e-02f, -3.97082493e-02f,
  6.32799342e-02f, -3.48733626e-02f, 2.50395507e-01f, 8.67593102e-03f, 1.78092606e-02f, 1.24980487e-01f, 2.08394676e-01f, 6.18073381e-02f, 2.37703398e-02f, -7.66040236e-02f,
  -3.68188284e-02f, 3.56836207e-02f, 1.03581399e-01f, -1.44369178e-03f, 3.21819991e-01f, 6.95928931e-02f, 6.34530261e-02f, -3.68414707e-02f, -6.53255824e-03f, 4.50355150e-02f,
  2.46929154e-02f, -3.64553966e-02f, -2.50368454e-02f, -1.33643836e-01f, -2.39778105e-02f, -2.31674582e-01f, -1.47922814e-01f, 8.39178171e-03f, -5.76411374e-02f, 4.11656238e-02f,
  -5.94489127e-02f, -1.63738906e-01f, -1.52477577e-01f, -1.12212844e-01f, -8.15588757e-02f, 2.23567858e-02f, 5.12194373e-02f, 6.69183508e-02f, 6.45238608e-02f, -1.54800192e-02f,
  2.39252672e-02f, -2.54713502e-02f, -3.91493700e-02f, -3.07737067e-02f, -3.89481001e-02f, 5.91163756e-03f, 2.12047733e-02f, 4.87800464e-02f, -1.50671154e-02f, -1.34589868e-02f,
  -5.68048935e-03f, 1.07953520e-02f, 6.28688410e-02f, 5.41379750e-02f, 1.94106810e-02f, -8.30187947e-02f, 8.35855864e-03f, 1.07226811e-01f, -8.51105340e-03f, 4.52058837e-02f,
  2.42409613e-02f, 7.20197782e-02f, 5.66707999e-02f, 7.30496421e-02f, 1.15237013e-01f, -2.50013992e-02f, -9.66178551e-02f, 5.21148443e-02f, 2.85845846e-02f, 3.52417864e-02f,
  7.57923946e-02f, 7.92927295e-02f, 8.50183889e-02f, 9.57268476e-02f, 5.27322441e-02f, 6.64680731e-03f, 5.51611669e-02f, 2.93580089e-02f, 4.95789796e-02f, 6.59276396e-02f,
  -7.08518103e-02f, 4.28290442e-02f, 2.86725610e-02f, 4.25120331e-02f, 8.95907506e-02f, 2.83728708e-02f, 6.30775094e-02f, 8.60508531e-02f, -6.74663186e-02f, -2.06845999e-02f,
  3.86933237e-02f, -9.85553116e-02f, 1.79841481e-02f, -2.21550744e-02f, 2.67528668e-02f, -1.18732333e-01f, 9.57118254e-03f, 7.68933538e-03f, -3.29374075e-02f, 4.42489050e-02f,
  -1.18518099e-01f, 3.81500460e-03f, -4.77080867e-02f, 2.81479377e-02f, -8.69959127e-03f, -1.24050155e-02f, 1.16159525e-02f, -9.86270085e-02f, -8.87383148e-02f, -3.14757824e-02f,
  1.77588183e-02f, -9.81364921e-02f, 4.42115478e-02f, -6.08646758e-02f, -6.84420168e-02f, 9.63007007e-03f, 6.06320426e-03f, -3.97779830e-02f, 1.78775713e-02f, 5.38394526e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  9.96468216e-02f, 2.96061467e-02f, 3.91628258e-02f, 1.06693551e-01f, 1.61648303e-01f, -5.53861521e-02f, 1.49342802e-03f, 9.61642191e-02f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.95899177e-01f, -3.98866795e-02f, 6.92152753e-02f, -8.12965482e-02f, -1.69052482e-01f, 3.70456696e-01f, -2.20179349e-01f, 5.66733517e-02f, 4.35680479e-01f, 2.02884495e-01f,
  -1.28914878e-01f, -5.43112874e-01f, -1.92997158e-01f, -3.33769441e-01f, 1.49200335e-01f, 8.49790201e-02f, -4.20715809e-01f, -2.50958592e-01f, -4.23141479e-01f, 2.21945450e-01f,
  5.92735767e-01f, 2.62386769e-01f, 4.92364138e-01f, -3.68396640e-01f, -2.56494194e-01f, 2.07227066e-01f, 2.43634164e-01f, 2.18947545e-01f, -2.60880828e-01f, -4.03075933e-01f,
  9.38955620e-02f, -1.22709788e-01f, -6.97198749e-01f, -3.33525032e-01f, -1.22846216e-01f, -1.02056570e-01f, -3.87983099e-02f, -5.26743829e-01f, -2.03360632e-01f, -1.93737864e-01f,
  -3.93969148e-01f, 2.33322501e-01f, -2.91508585e-01f, 1.04815371e-01f, 5.48969209e-01f, 1.58494949e-01f, 2.12704062e-01f, -2.65400559e-01f, 2.09263116e-01f, 1.78932160e-01f,
  1.19384393e-01f, -2.15896308e-01f, 1.20685078e-01f, 6.32924616e-01f, -1.33930296e-01f, 2.69030094e-01f, -1.29162326e-01f, 1.96381345e-01f, 3.00789680e-02f, 2.62330085e-01f,
  -1.64223179e-01f, 6.62241459e-01f, -6.95935190e-02f, 1.08228229e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -1.38449147e-01f, 3.71112168e-01f, 2.34297767e-01f, -8.75395238e-02f, 3.60999376e-01f, 7.70299137e-02f, 9.29294433e-03f, 1.48239270e-01f, 1.39680237e-01f, 2.00848594e-01f,
  -8.55858326e-02f, 1.60537157e-02f, -2.75996178e-01f, 1.44711509e-01f, 4.28972960e-01f, -7.78359473e-02f, 3.64542037e-01f, 1.09193988e-01f, 3.16240937e-01f, -3.66844833e-01f,
  -1.32652625e-01f, 6.96518183e-01f, 4.99240667e-01f, 4.65248406e-01f, -4.94520329e-02f, -2.42654964e-01f, -1.31394655e-01f, -7.63822868e-02f, -2.39207238e-01f, 1.18298084e-01f,
  4.50123578e-01f, 1.33138463e-01f, -3.43568534e-01f, 6.78499788e-02f, 3.16583067e-01f, 1.93939626e-01f, 3.42285842e-01f, -4.46021378e-01f, 3.54810923e-01f, 8.71512145e-02f,
  -1.53115466e-01f, -1.13703370e-01f, -1.60515323e-01f, 3.82769853e-01f, 3.25086713e-01f, -1.33177534e-01f, -1.73360094e-01f, -7.41347894e-02f, -7.27920830e-02f, 7.25782990e-01f,
  -8.68820250e-02f, 5.61499953e-01f, 5.00246704e-01f, 4.51883107e-01f, -1.46871507e-01f, -1.83448195e-01f, 7.38804042e-02f, 3.23937833e-01f, 1.71626225e-01f, 8.75685930e-01f,
  -3.82349819e-01f, -1.57073408e-01f, 4.20779288e-01f, 1.83568865e-01f, -2.79687107e-01f, 2.18788218e-02f, 1.01391569e-01f, -4.44268668e-03f, 7.41949752e-02f, 6.74250722e-02f,
  -1.08194603e-02f, -3.21332484e-01f, 2.62980253e-01f, -1.99446991e-01f, -2.53698170e-01f, -1.83527380e-01f, 1.29743323e-01f, 1.93534255e-01f, 1.83978945e-01f, -2.23009408e-01f,
  -2.17545718e-01f, 1.92554146e-01f, -1.13502309e-01f, -2.04330429e-01f, -1.90526098e-01f, -3.44459742e-01f, -2.65309095e-01f, -1.68869257e-01f, -1.31298274e-01f, 1.94778711e-01f,
  2.40430027e-01f, 1.58773318e-01f, -1.56977907e-01f, -1.87294990e-01f, 1.88668489e-01f, -1.17272988e-01f, 4.23446506e-01f, 3.54486227e-01f, 5.36160588e-01f, -3.20160151e-01f,
  -1.17002793e-01f, -4.44984920e-02f, -1.11349791e-01f, 9.41619515e-01f, -5.68289636e-03f, -2.11964354e-01f, 1.13502286e-01f, 7.73067653e-01f, 1.61336169e-01f, 7.12226689e-01f,
  -2.39775002e-01f, 2.46116370e-01f, 1.24388643e-01f, -1.09659612e-01f, 2.62532443e-01f, -1.22206658e-02f, -1.97282359e-01f, -6.66719750e-02f, -5.87780654e-01f, -6.83534443e-01f,
  2.27617502e-01f, -4.76850607e-02f, -8.74818489e-02f, -2.23482568e-02f, -4.57918048e-02f, -3.75820279e-01f, 1.24245453e+00f, -2.68445581e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.48437411e-01f, 8.13970342e-02f, -1.01453448e-02f, 4.02977049e-01f, -2.57036120e-01f, 2.90916860e-01f, 2.33250007e-01f, 1.42162353e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.93968505e-01f, -2.92329371e-01f, -2.09306896e-01f, -3.52420926e-01f, 5.43104589e-01f, 4.99332368e-01f, -4.13251072e-02f, 8.76861513e-02f, 2.27369100e-01f, -3.99573982e-01f,
  -2.83385485e-01f, 3.83240193e-01f, 7.80590475e-02f, -1.61349047e-02f, -7.90583134e-01f, 2.47649297e-01f, 2.09171027e-01f, 1.47161745e-02f, 7.56219849e-02f, 3.72090518e-01f,
  -7.53172755e-01f, 7.09833384e-01f, 7.49135375e-01f, -2.25485712e-01f, -8.88897553e-02f, -3.99858057e-01f, 3.98912698e-01f, 1.18733130e-01f, 8.98812264e-02f, 3.25258464e-01f,
  -3.82967651e-01f, -2.78935786e-02f, -1.10947557e-01f, -5.22503376e-01f, -1.36008516e-01f, -5.71898580e-01f, 1.24340385e-01f, -9.58057165e-01f, 3.28897566e-01f, 1.03437178e-01f,
  1.55698687e-01f, -1.07571147e-01f, -7.36326501e-02f, -2.57698685e-01f, -2.05409184e-01f, -3.16795218e-03f, 5.06826282e-01f, -3.09752345e-01f, 3.14477563e-01f, 7.32231364e-02f,
  3.33906226e-02f, 2.92284250e-01f, 7.39654481e-01f, -7.78654456e-01f, -5.39236888e-03f, -2.80173212e-01f, 1.25653639e-01f, 2.26273954e-01f, -2.98593611e-01f, 2.74464153e-02f,
  -1.17062353e-01f, 2.28221789e-01f, -1.67217061e-01f, 5.23852885e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  9.72037673e-01f, 6.50224805e-01f, 2.21872881e-01f, 5.85632384e-01f, 4.73423153e-01f, 1.24254249e-01f, -1.49640620e+00f, 7.95530319e-01f, -7.58211762e-02f, 6.72259271e-01f,
  -2.99885601e-01f, 2.33373940e-01f, -4.66410369e-01f, -3.81841630e-01f, 2.98202008e-01f, -6.63974702e-01f, -3.13760817e-01f, -5.40785074e-01f, 1.84734538e-01f, -3.21420461e-01f,
  -4.59408492e-01f, 5.20869851e-01f, -1.24116093e-01f, 6.28481030e-01f, 3.06145549e-01f, 2.36835759e-02f, 9.45205837e-02f, 8.48496675e-01f, -1.15405276e-01f, 7.36609250e-02f,
  1.01405132e+00f, -3.88506383e-01f, 6.09415829e-01f, 6.75851107e-01f, 3.51172805e-01f, 8.02671134e-01f, -6.06080472e-01f, 7.60696650e-01f, -2.93431699e-01f, -3.66747081e-01f,
  7.33431801e-02f, -5.53112507e-01f, 3.14986229e-01f, 7.73498833e-01f, -2.54231662e-01f, 2.38152206e-01f, 8.81018043e-02f, -2.99215317e-01f, 1.94538444e-01f, -1.34327009e-01f,
  -2.13268999e-04f, 4.85069245e-01f, -6.74655437e-02f, -2.01416761e-01f, 5.21424338e-02f, -6.35149330e-02f, -2.15254530e-01f, -1.86867177e-01f, 7.49326721e-02f, 7.72269443e-02f,
  -5.52887060e-02f, 1.68229476e-01f, -3.31604443e-02f, -5.21893725e-02f, -1.43703401e-01f, 2.51556218e-01f, 2.19960824e-01f, 4.17222172e-01f, 2.86647439e-01f, 7.29171515e-01f,
  1.23849496e-01f, 3.84926826e-01f, 5.59441626e-01f, 3.92519951e-01f, -3.66588950e-01f, 7.67452121e-01f, -1.87639277e-02f, 1.87355414e-01f, -4.94046688e-01f, 1.06038940e+00f,
  -2.36477867e-01f, -9.22871828e-02f, 8.45090225e-02f, -1.29414285e-02f, 2.47385725e-01f, 9.17606205e-02f, -1.98943704e-01f, -5.55810854e-02f, -8.15247297e-02f, 5.22486083e-02f,
  -1.86885044e-03f, -1.61231056e-01f, 4.65206392e-02f, 1.17457815e-01f, -1.41367525e-01f, 4.27114032e-02f, 2.17782542e-01f, -2.63733774e-01f, -2.66355798e-02f, -1.11774012e-01f,
  -5.32617867e-01f, 1.67570964e-01f, 1.59373552e-01f, -9.27783251e-02f, 1.58339873e-01f, -1.92479625e-01f, -6.31083325e-02f, 2.41640862e-02f, -2.13110566e-01f, -1.15094677e-01f,
  4.26043987e-01f, 3.92589644e-02f, -6.41666651e-02f, -3.94544192e-02f, 2.75454819e-01f, 1.81677207e-01f, 1.39850289e-01f, 5.84434092e-01f, -4.25939947e-01f, 3.10005993e-01f,
  2.65743256e-01f, 3.08137298e-01f, -3.98210138e-02f, 4.02304947e-01f, -8.34045634e-02f, -2.25882605e-01f, -1.84340343e-01f, -4.63183790e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  8.38885903e-01f, 2.85169240e-02f, 3.15112561e-01f, 1.34470060e-01f, -6.66224435e-02f, -5.54651767e-02f, -6.23830110e-02f, -6.74355254e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  4.26091760e-01f, -1.18509853e+00f, 1.02327831e-01f, 4.87390548e-01f, -3.01692277e-01f, 8.31415534e-01f, -9.35576379e-01f, -1.10435963e+00f, -1.09072983e+00f, -2.95727223e-01f,
  8.68357122e-01f, -4.60872985e-02f, -4.20664608e-01f, -7.38991722e-02f, 2.58909106e-01f, -1.42174795e-01f, 5.98011494e-01f, -5.20142019e-01f, -1.10361397e-01f, -5.92481978e-02f,
  -3.99139747e-02f, 1.38436007e+00f, -4.14061397e-01f, -2.26012409e-01f, -3.42049599e-01f, 6.52216971e-01f, 4.41728055e-01f, 1.15763903e-01f, 4.51048873e-02f, 7.51276389e-02f,
  5.62011860e-02f, 4.29399788e-01f, -4.05821681e-01f, 1.59207135e-01f, 4.56518590e-01f, -3.16061199e-01f, -8.59612375e-02f, -7.49936938e-01f, 9.17739153e-01f, -4.47138369e-01f,
  1.79088026e-01f, 6.67729080e-01f, 4.13274705e-01f, 3.05622965e-02f, -4.07690108e-01f, 6.20345287e-02f, -5.38783409e-02f, 8.38614106e-02f, 7.52024651e-01f, 1.37495935e+00f,
  1.23400557e+00f, -1.11241220e-03f, -8.38844061e-01f, 7.57330060e-01f, 4.15817976e-01f, 1.16203177e+00f, -9.89692748e-01f, -4.57033634e-01f, -2.94293374e-01f, 2.80845910e-01f,
  -2.69809037e-01f, -8.19147453e-02f, -1.07298911e-01f, -2.93705910e-01f, -7.62968957e-01f, 1.15413320e+00f, 4.48182344e-01f, 6.50539696e-01f, -5.65092862e-01f, -7.52217829e-01f,
  1.77303135e-01f, 8.02158475e-01f, 8.19384873e-01f, -6.80640697e-01f, 6.49382710e-01f, 2.58385569e-01f, -8.26688826e-01f, 1.73900843e-01f, -7.84455687e-02f, -2.93265313e-01f,
  3.81524712e-01f, 6.40489459e-01f, -7.75243938e-01f, 4.93730605e-01f, 1.87169626e-01f, 7.01767266e-01f, -5.93971252e-01f, -3.55221964e-02f, 8.32196057e-01f, -4.16941315e-01f,
  3.94358486e-01f, -9.60722044e-02f, 2.21041828e-01f, 2.61734307e-01f, 4.86635193e-02f, 5.20681977e-01f, -2.52812088e-01f, -9.76746976e-01f, 7.76529908e-01f, -9.00117010e-02f,
  -6.68843567e-01f, -9.66821849e-01f, 3.79506588e-01f, 1.47510171e-01f, 1.26482272e+00f, -2.79962391e-01f, -4.70642686e-01f, -1.11405805e-01f, -1.44244224e-01f, -2.79540028e-02f,
  -3.73692214e-01f, 3.62078190e-01f, -1.12506461e+00f, -8.42814371e-02f, -1.13138270e+00f, -4.72940840e-02f, -9.95617360e-02f, -9.07987237e-01f, 4.49814886e-01f, -1.12198126e+00f,
  -7.08768845e-01f, 8.14016461e-01f, -3.18531513e-01f, -1.67717665e-01f, -3.81730229e-01f, -1.68956026e-01f, 4.43973392e-01f, -3.55314642e-01f, -6.41206145e-01f, -1.17173903e-01f,
  -3.73989463e-01f, -4.43167925e-01f, 7.90128350e-01f, 1.08606040e+00f, -2.65222758e-01f, 3.96037638e-01f, -6.78225636e-01f, 9.31620374e-02f, 3.50095540e-01f, -9.30657052e-03f,
  8.67335856e-01f, -1.66220084e-01f, 2.00720504e-01f, -3.00402433e-01f, -4.61890012e-01f, -1.23061860e+00f, -1.14065695e+00f, 7.09354222e-01f, -3.63353252e-01f, -1.22177079e-02f,
  1.19922268e+00f, 1.52939975e-01f, 7.39518166e-01f, 5.49299240e-01f, -7.68667936e-01f, -2.65462756e-01f, -1.58923343e-01f, 1.52987853e-01f, 8.73020813e-02f, -7.45982379e-02f,
  9.95823264e-01f, 4.49967533e-01f, 1.00155103e+00f, -1.09569120e+00f, 5.57447076e-01f, -1.31938648e+00f, -5.98130465e-01f, 8.15855742e-01f, 3.00871640e-01f, -5.18599033e-01f,
  8.39453191e-02f, 8.54756609e-02f, 2.53878385e-01f, 9.21486244e-02f, -4.27639991e-01f, -3.66937220e-01f, 1.62267432e-01f, 4.81121875e-02f, -3.10906649e-01f, -1.24506645e-01f,
  1.19814003e+00f, -7.24419236e-01f, -5.71718872e-01f, 1.40669361e-01f, -3.18508506e-01f, -3.80934954e-01f, -7.65770137e-01f, -3.90282303e-01f, 1.10518062e+00f, 2.85853118e-01f,
  -1.72549695e-01f, -1.30616561e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  6.78690553e-01f, -3.23749363e-01f, -2.24556014e-01f, 6.88748777e-01f, 2.53911585e-01f, -5.12084246e-01f, -2.71367520e-01f, 3.30517828e-01f, -2.51526743e-01f, -1.98362559e-01f,
  6.55826867e-01f, -2.83031724e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    