/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.96594948e-02f, -2.01988608e-01f, -1.74179226e-01f, 1.34431114e-02f, 1.89155862e-01f, 6.55869860e-03f, -1.99159473e-01f, 1.39697313e-01f, -2.07071617e-01f, 2.75331587e-02f,
  -3.74523178e-02f, 4.41686995e-03f, -2.40582854e-01f, 7.61473775e-02f, 6.04709759e-02f, -2.26181835e-01f, -2.93702260e-02f, -6.60429969e-02f, -1.54734971e-02f, 3.05700768e-02f,
  7.08167255e-02f, 2.41543397e-01f, -2.38898844e-02f, 1.86565563e-01f, 1.64676458e-01f, 8.10743421e-02f, 2.47516617e-01f, -1.24410026e-01f, 3.08695793e-01f, 6.41213730e-02f,
  -3.35052200e-02f, -8.69395286e-02f, 1.82142053e-02f, 1.48078483e-02f, 7.99436793e-02f, -1.70224253e-02f, 5.73480092e-02f, -6.12549260e-02f, -8.35463852e-02f, 3.24839838e-02f,
  -5.06793289e-03f, 2.65721343e-02f, -1.36521456e-04f, 2.23667151e-03f, 5.18922694e-02f, -1.64694004e-02f, 3.37762013e-02f, -1.53702805e-02f, 5.58871822e-03f, -1.06682722e-02f,
  -1.00589566e-01f, 1.83062460e-02f, 5.20217652e-03f, 1.71325393e-02f, 1.42279558e-03f, 1.01180058e-02f, 1.67781841e-02f, -4.45391722e-02f, 4.32152562e-02f, 5.70481457e-03f,
  2.02438701e-02f, 1.64264794e-02f, 2.34562252e-02f, 6.10045679e-02f, 8.80053826e-03f, 2.62638945e-02f, 7.03624915e-03f, 1.32968239e-02f, 2.36708783e-02f, 3.98073271e-02f,
  2.91981827e-02f, 6.57791924e-03f, 1.39240380e-02f, 3.53847328e-03f, 9.30483826e-03f, -7.78277032e-03f, -5.89415804e-03f, 5.07146679e-02f, -2.87499949e-02f, 3.00369225e-02f,
  -3.13591994e-02f, -9.42153111e-03f, 3.36158858e-03f, 1.75301768e-02f, -7.83194695e-03f, -2.95445155e-02f, 2.53382288e-02f, -6.57749735e-03f, -1.22575797e-02f, -2.83061229e-02f,
  8.96929726e-02f, 5.96102923e-02f, -7.11808577e-02f, -2.32615601e-02f, -4.09848951e-02f, 1.85143445e-02f, -4.39048000e-02f, 1.08893178e-01f, 4.99280468e-02f, 2.25590970e-02f,
  4.42515612e-02f, -7.82792494e-02f, 5.69458045e-02f, 1.00769820e-02f, -2.59672850e-03f, 2.79068071e-02f, -1.85828432e-02f, 3.03965844e-02f, 4.50499430e-02f, 1.30728222e-02f,
  1.82898324e-02f, -1.06269796e-03f, 2.53464538e-03f, 3.99921834e-02f, 3.28990743e-02f, -4.61248830e-02f, 3.22530530e-02f, -9.31451935e-03f, 2.42961776e-02f, -1.42501099e-02f,
  1.07356235e-01f, 9.17756706e-02f, 4.14894432e-01f, 6.95089474e-02f, 7.82019645e-02f, 6.53450862e-02f, 5.29120378e-02f, 7.57780224e-02f, 1.48074046e-01f, -2.22171530e-01f,
  -5.20415008e-02f, 1.36652321e-01f, -4.34369268e-03f, -3.00951470e-02f, -4.32486273e-02f, -1.73460934e-02f, -1.21522591e-01f, -3.33115011e-02f, 1.59260452e-01f, -7.92170689e-02f,
  5.80911785e-02f, -2.85153806e-01f, 1.24509133e-01f, -9.69125256e-02f, 1.26731500e-01f, 8.50421712e-02f, -2.78144002e-01f, 1.15691528e-01f, -1.54451072e-01f, 5.08310273e-03f,
  1.50649667e-01f, 2.11601242e-01f, 1.43247262e-01f, -1.21377371e-02f, 3.33340280e-02f, 2.86508687e-02f, -7.57160857e-02f, 2.71604266e-02f, 9.09017175e-02f, 1.56552605e-02f,
  -4.43210732e-03f, -8.15930441e-02f, -3.81875485e-02f, 5.27658965e-03f, 5.20938560e-02f, 7.88508579e-02f, 6.75676018e-02f, 9.72826630e-02f, 4.21199836e-02f, 5.83634451e-02f,
  7.34235793e-02f, 7.91317374e-02f, 5.45972027e-02f, -1.36095569e-01f, -6.61137188e-03f, 1.10906407e-01f, -5.58824465e-03f, -2.39950437e-02f, 5.90308383e-03f, 7.64292255e-02f,
  -6.69579059e-02f, 3.84526476e-02f, -2.45239828e-02f, -3.89631204e-02f, 8.38373508e-03f, -1.88703137e-03f, -4.57637534e-02f, -1.12624399e-01f, 8.26761574e-02f, -9.13814232e-02f,
  1.61650009e-03f, 1.61164999e-02f, -4.65759784e-02f, 1.98631957e-02f, -6.02613874e-02f, -4.07479778e-02f, -2.37809084e-02f, -1.33222333e-04f, -8.61798786e-03f, 2.09132694e-02f,
  -1.61392391e-02f, 5.96418381e-02f, 3.19481082e-02f, 6.26633167e-02f, -1.01703843e-02f, -8.94714706e-03f, -2.09029093e-02f, 1.21025117e-02f, -2.25933399e-02f, -5.88308796e-02f,
  -1.84598133e-01f, -1.93260133e-01f, -4.02843878e-02f, 1.76514015e-02f, -4.86095174e-04f, -2.44448185e-02f, -4.46505211e-02f, -9.48181972e-02f, 4.33099754e-02f, -2.52533890e-02f,
  -5.00376821e-02f, -4.88161109e-02f, 3.38630527e-02f, -3.41468304e-03f, -7.73307215e-03f, -4.38723899e-02f, -6.24153875e-02f, -2.24337205e-02f, -6.23865761e-02f, -4.84861359e-02f,
  1.88304707e-02f, -1.22136965e-01f, -8.46744031e-02f, -2.77234497e-03f, -9.49993879e-02f, -6.34880066e-02f, 5.74540459e-02f, 1.93212070e-02f, 6.47182809e-03f, -1.69514883e-02f,
  5.60518324e-01f, -4.79240716e-02f, 3.24109420e-02f, 4.31905640e-03f, 1.85288936e-01f, 1.40759662e-01f, 6.52811723e-03f, -1.63879078e-02f, 3.19300860e-01f, -1.11342125e-01f,
  -7.44820163e-02f, 1.47577658e-01f, -1.83410332e-01f, -3.70172635e-02f, 1.50564969e-01f, -1.06244400e-01f, 7.62531534e-02f, -2.58107092e-02f, 5.55174835e-02f, -5.58369756e-02f,
  -6.66965032e-04f, -7.21907318e-02f, -1.99261189e-01f, -1.20103672e-01f, 2.67812852e-02f, -4.49396558e-02f, -2.14311898e-01f, -1.04101166e-01f, -6.93002194e-02f, -5.39135300e-02f,
  3.70711125e-02f, -5.36679178e-02f, 1.43949129e-02f, 1.40600590e-04f, -7.48161301e-02f, -3.06385173e-03f, 3.81509028e-02f, -1.04554899e-01f, -1.79888736e-02f, -7.89500214e-03f,
  -2.03407556e-02f, 4.45702448e-02f, 3.04173306e-02f, -3.09031904e-02f, 1.03043012e-01f, 2.79371720e-02f, 2.51128227e-02f, 7.27789178e-02f, 2.75444090e-02f, 4.35007773e-02f,
  4.65224171e-03f, 2.60789692e-02f, 2.76936963e-03f, -3.82939614e-02f, -3.47908176e-02f, -1.35806557e-02f, -2.73492523e-02f, -7.30651170e-02f, -8.37141927e-03f, -2.92355139e-02f,
  -3.24069485e-02f, 1.00090392e-02f, 6.96374848e-03f, 5.36941886e-02f, 9.40808579e-02f, -1.74592156e-02f, 2.93269213e-02f, -3.99941094e-02f, -3.75656574e-03f, 2.61205100e-02f,
  6.23080842e-02f, -5.09580970e-03f, 4.54544686e-02f, 5.08448780e-02f, -1.52004987e-03f, 3.32287326e-02f, 7.67929107e-02f, -1.64634325e-02f, -6.74741436e-03f, 4.27432209e-02f,
  2.63113268e-02f, -4.36182879e-03f, -5.91367297e-02f, -2.92492174e-02f, 1.76583901e-02f, 2.68369876e-02f, -2.83957850e-02f, 4.36547510e-02f, -1.17716379e-02f, 1.09578324e-02f,
  -1.23357996e-01f, -1.26566157e-01f, -3.11935861e-02f, 9.47658494e-02f, 1.13489712e-02f, 3.64159308e-02f, 5.82623556e-02f, 5.24760857e-02f, -4.17670496e-02f, -1.23544401e-02f,
  2.35376917e-02f, -1.76754349e-03f, 9.65048932e-03f, 2.62434054e-02f, -5.97716384e-02f, 2.17738259e-03f, -6.16091229e-02f, -3.81224714e-02f, -2.06910614e-02f, 2.52272058e-02f,
  -2.25047544e-02f, 7.89839588e-03f, 9.95865371e-03f, 5.27450964e-02f, -3.38486023e-02f, -1.86278485e-03f, 1.45999752e-02f, 1.00601763e-01f, 2.47329529e-02f, 1.84328407e-02f,
  -5.65877557e-01f, 5.86937293e-02f, -9.60220620e-02f, -3.99456739e-01f, -6.81391433e-02f, 1.61150709e-01f, -6.73459172e-02f, -1.02974519e-01f, -6.00598976e-02f, 2.23705783e-01f,
  -3.56901134e-03f, 1.17515072e-01f, 4.62516658e-02f, -2.44463086e-02f, -1.64356217e-01f, 2.06141278e-01f, -7.48735294e-02f, 4.92535196e-02f, 2.69735996e-02f, -1.11713387e-01f,
  -9.44695175e-02f, -5.42391092e-02f, -7.56808594e-02f, -7.14359060e-02f, -2.55789254e-02f, -1.21866815e-01f, -9.29405615e-02f, 2.44719852e-02f, -1.44150913e-01f, -1.30301071e-02f,
  5.27124666e-02f, 7.23143741e-02f, -7.21867606e-02f, 6.78761154e-02f, -4.78292368e-02f, 2.73577832e-02f, 4.41520549e-02f, -5.57608418e-02f, 6.18983945e-03f, 6.05833195e-02f,
  3.88983376e-02f, -4.39672265e-03f, -1.06360679e-02f, 9.52003524e-03f, -2.58687213e-02f, -8.53249729e-02f, -1.06773376e-02f, 7.03719407e-02f, 4.08411883e-02f, 4.61433604e-02f,
  6.38456142e-04f, 5.30121438e-02f, -2.34386027e-02f, 2.61305198e-02f, -5.23770787e-02f, -5.07051535e-02f, 1.76141430e-02f, -1.18955653e-02f, 4.28013178e-03f, -4.13557291e-02f,
  -2.27708612e-02f, 1.10538220e-02f, 3.72193977e-02f, -1.80741772e-03f, 3.64307873e-02f, -1.60344522e-02f, -2.08262857e-02f, 7.26054162e-02f, -3.66132217e-03f, 4.60297391e-02f,
  1.09144067e-02f, -3.09213959e-02f, 6.12546913e-02f, 2.25457121e-02f, -6.89253444e-03f, 1.30165424e-02f, -4.10791859e-02f, 2.27573421e-02f, -4.17461544e-02f, -3.73222819e-03f,
  4.36449051e-02f, -1.48289492e-02f, 3.67041714e-02f, -1.72548406e-02f, -1.13518052e-02f, -5.61028421e-02f, -2.35791467e-02f, 1.96041707e-02f, -9.12375841e-03f, -1.36754615e-02f,
  1.03004202e-01f, -3.45298536e-02f, -1.56392120e-02f, -1.82259325e-02f, 4.58772667e-02f, 5.09965122e-02f, -2.29039913e-04f, -1.14315934e-02f, -1.27187902e-02f, -2.71069817e-02f,
  1.69603545e-02f, -4.83003706e-02f, 7.20349476e-02f, -4.99044396e-02f, -3.12974192e-02f, 2.54819673e-02f, -2.58642975e-02f, -4.09255587e-02f, -5.28048873e-02f, -2.07874388e-03f,
  -2.38804631e-02f, 3.45770903e-02f, 7.54865259e-03f, -2.56240964e-02f, -5.28219007e-02f, 6.03413209e-02f, -2.72401087e-02f, -2.36676652e-02f, 1.58358384e-02f, 7.65201217e-03f,
  -1.03750825e-02f, -2.82008313e-02f, -1.99286371e-01f, 5.91423213e-02f, 7.23233446e-02f, -1.58008300e-02f, -6.76814318e-02f, 7.83402547e-02f, -1.66874737e-01f, 4.47185859e-02f,
  5.79480641e-02f, -1.62781909e-01f, -1.23469256e-01f, -2.94231288e-02f, 2.28381470e-01f, -3.04098010e-01f, 1.56081140e-01f, -4.07709926e-02f, -1.56916142e-01f, 1.68582171e-01f,
  4.21382785e-02f, 8.44692737e-02f, 2.05281191e-03f, 6.89366534e-02f, 1.94420353e-01f, 2.36064307e-02f, 2.66946584e-01f, 4.50036768e-03f, 1.91521943e-01f, 7.37418234e-02f,
  -4.14004698e-02f, -8.96411240e-02f, -5.25570773e-02f, -5.81519902e-02f, 8.73020887e-02f, 7.26279169e-02f, -1.76772997e-02f, -1.12599872e-01f, -3.54462638e-02f, -6.62683547e-02f,
  -6.29025400e-02f, 2.51140725e-02f, -3.87089103e-02f, -2.81409174e-02f, 3.24716792e-02f, -2.74085831e-02f, -1.70720946e-02f, -4.15470637e-02f, -1.36795668e-02f, 7.84991682e-03f,
  9.07442067e-03f, 8.17068852e-03f, 1.52794505e-02f, -5.26039638e-02f, -2.85346694e-02f, 4.58914526e-02f, -8.17832649e-02f, -3.50473635e-02f, 8.60281347e-04f, 6.54103328e-03f,
  -4.76557165e-02f, 2.59070173e-02f, -2.05863584e-02f, 7.11778970e-03f, 1.25678210e-02f, 5.51151596e-02f, -3.16496342e-02f, -5.65784425e-02f, 4.23023105e-03f, 1.55716911e-02f,
  7.17846230e-02f, 4.56432700e-02f, 5.31897508e-02f, -2.29278742e-03f, 3.66572365e-02f, 1.25270449e-02f, -5.30328155e-02f, -2.10133847e-02f, 4.31222795e-03f, -1.18682086e-02f,
  2.04220228e-02f, 8.86385664e-02f, -1.53493145e-02f, -1.76065657e-02f, 7.17493705e-03f, 4.18171175e-02f, 3.06925569e-02f, 7.91144965e-04f, -7.87298307e-02f, 7.75401597e-04f,
  4.48142111e-01f, 3.47696215e-01f, 2.11864244e-02f, -6.46540970e-02f, -6.25146627e-02f, 3.96215320e-02f, -6.90577775e-02f, -4.60981652e-02f, 4.56143282e-02f, -5.22015169e-02f,
  2.44535021e-02f, -5.03442157e-03f, 4.85724695e-02f, 1.06933620e-03f, 2.43068431e-02f, 5.17001189e-02f, 8.56830180e-03f, 5.57022281e-02f, 1.02714159e-01f, 7.77870342e-02f,
  9.73958746e-02f, -2.20075659e-02f, -8.27986468e-03f, 3.70737016e-02f, 3.21586579e-02f, 2.92786136e-02f, 9.69002247e-02f, 3.28873494e-03f, 5.98978028e-02f, -3.06970663e-02f,
  1.81387961e-01f, 1.53522864e-01f, -1.85404420e-02f, 4.05081324e-02f, 1.30512476e-01f, 4.50300202e-02f, -1.36306761e-02f, 2.20462114e-01f, 3.98255706e-01f, -2.61721108e-02f,
  -1.25828996e-01f, -1.02993168e-01f, -2.63660997e-02f, -1.68681979e-01f, -1.01654008e-01f, 4.65802215e-02f, 3.72965634e-02f, 1.37046361e-02f, 1.40698373e-01f, 1.15692146e-01f,
  1.18748166e-01f, -5.32467514e-02f, -1.05559826e-01f, -1.31207528e-02f, 9.96339694e-03f, 4.45132628e-02f, -1.35869324e-01f, -2.54217703e-02f, -2.05326125e-01f, -1.39174446e-01f,
  -1.59426332e-02f, 1.40869468e-01f, 4.87424880e-02f, -2.35987036e-03f, 5.06695397e-02f, -3.05268932e-02f, -8.84211287e-02f, -1.06659524e-01f, 4.04634699e-02f, 2.27227919e-02f,
  -1.44095754e-03f, -2.23874040e-02f, -1.62785593e-02f, -2.86979158e-03f, 4.44704033e-02f, 1.65160894e-02f, 5.73676899e-02f, 7.43499212e-03f, 2.09374670e-02f, 2.52784248e-02f,
  7.19152465e-02f, -5.90188131e-02f, 6.02721572e-02f, -4.44275998e-02f, 5.86879849e-02f, 4.81476672e-02f, -5.09337448e-02f, -5.57061471e-02f, 6.43820092e-02f, 5.80588095e-02f,
  1.11691929e-01f, -5.45939803e-03f, -1.67454723e-02f, -1.30281588e-02f, -1.52333130e-04f, 8.99819378e-03f, -2.68995315e-02f, -2.21554786e-02f, 2.65852199e-03f, -1.54370284e-02f,
  3.65189189e-05f, -1.23946210e-02f, 3.74981239e-02f, 5.32173738e-03f, 2.67459359e-02f, 3.36531326e-02f, -2.87101585e-02f, -6.22999780e-02f, 5.28365672e-02f, -7.20514869e-03f,
  -4.82116826e-02f, 2.16134544e-02f, -6.46423502e-03f, -7.63836205e-02f, 1.47357769e-02f, 7.94046838e-03f, -6.50764722e-03f, -3.45782470e-03f, -1.74421091e-02f, -2.98879799e-02f,
  5.04537039e-02f, 1.63720548e-01f, -4.62133773e-02f, -2.53413953e-02f, -9.92832240e-03f, 2.84947176e-02f, 5.64180277e-02f, 4.75482792e-02f, 6.96552023e-02f, -3.81041388e-03f,
  5.74228493e-03f, -2.89784484e-02f, 3.24357972e-02f, -3.95370014e-02f, -1.49840862e-02f, 2.33351607e-02f, -2.26072054e-02f, -4.82290238e-02f, 1.99322253e-02f, -6.92929234e-03f,
  -5.08275107e-02f, 4.03938666e-02f, -1.59225501e-02f, 3.95863801e-02f, 1.55383479e-02f, -6.80538490e-02f, 8.62076953e-02f, -4.36889520e-03f, -7.10955411e-02f, -1.56043535e-02f,
  -4.38492715e-01f, 4.93360132e-01f, 6.66158572e-02f, 1.01392344e-01f, -1.93666518e-01f, -1.85807496e-01f, -1.75722659e-01f, 1.57604277e-01f, 7.11226463e-02f, 3.57543916e-01f,
  5.44764623e-02f, 9.15086791e-02f, 1.05328828e-01f, 1.13807023e-01f, -3.61868531e-01f, 5.43247275e-02f, -9.08824876e-02f, 1.38906464e-01f, 4.14212327e-03f, 6.69223145e-02f,
  -7.45834485e-02f, -2.07145493e-02f, -2.64177956e-02f, -2.75586210e-02f, 3.36655974e-02f, 1.79202412e-03f, -5.84282726e-02f, -5.11019900e-02f, 1.17658630e-01f, -2.60087047e-02f,
  -1.26521751e-01f, 5.10295369e-02f, -2.60004196e-02f, 5.87739684e-02f, 2.88329944e-02f, 3.31532694e-02f, 2.96293311e-02f, -9.48743969e-02f, -4.15382721e-02f, -2.68567353e-02f,
  1.24833593e-02f, -1.98958535e-02f, -4.35546301e-02f, -2.53449492e-02f, 7.29072932e-03f, 4.33559939e-02f, -4.32042126e-03f, 1.66516844e-02f, 9.62270647e-02f, 5.17639890e-03f,
  1.75812114e-02f, 1.30134244e-02f, 2.89250351e-02f, 2.63451654e-02f, -2.84305643e-02f, -8.24689493e-03f, 7.21212942e-03f, 2.36657653e-02f, 1.69751439e-02f, 4.47636470e-03f,
  -5.30227311e-02f, -5.30380048e-02f, 1.02397511e-02f, 3.89977433e-02f, 1.48343537e-02f, 1.58756003e-02f, -3.38436812e-02f, -1.24429408e-02f, -5.76754622e-02f, 3.29649597e-02f,
  -2.07724888e-02f, 2.05040704e-02f, -1.70509964e-02f, 1.66389463e-03f, -1.09380968e-02f, 2.99059656e-02f, 7.39975041e-03f, 2.44088396e-02f, -1.72420349e-02f, 3.67985703e-02f,
  -7.81062851e-03f, -1.90006271e-02f, 2.88671930e-03f, -1.28901443e-02f, 8.79143085e-03f, 2.64741527e-03f, 4.08181883e-02f, 1.26774251e-01f, -3.21646943e-03f, -2.10641585e-02f,
  4.02305536e-02f, 1.18563838e-01f, 6.33159559e-03f, -5.76968258e-03f, 1.58405374e-03f, -3.38473208e-02f, -4.35795225e-02f, 3.30422446e-02f, -9.28514265e-03f, -2.74516828e-02f,
  5.25005953e-03f, 2.65412517e-02f, -3.16749252e-02f, -2.41926145e-02f, 4.49254215e-02f, -2.60468926e-02f, -3.40640731e-03f, -2.45973114e-02f, -4.31796573e-02f, 8.19260553e-02f,
  3.52759808e-02f, 1.54708922e-02f, 3.03919967e-02f, 2.65498483e-03f, -1.44960424e-02f, -2.91594537e-03f, -3.81330922e-02f, 2.91753151e-02f, -1.38378004e-02f, -6.96705747e-03f,
  -3.68218094e-01f, -9.56853777e-02f, -2.33468175e-01f, -2.29248524e-01f, -6.62338808e-02f, -1.46470144e-02f, -5.02926707e-02f, -6.21426962e-02f, -9.12207291e-02f, 1.58917531e-02f,
  1.21138871e-01f, -2.00759023e-01f, 3.80961969e-02f, -1.09700397e-01f, -1.30520821e-01f, -2.28274018e-02f, -1.61696658e-01f, 7.25394522e-04f, -1.89203080e-02f, -6.61049858e-02f,
  -1.62132636e-01f, 1.11710560e-02f, -2.26036489e-01f, -1.25719840e-02f, -4.65378389e-02f, 2.01818682e-02f, 4.23029363e-02f, -1.71621088e-02f, -6.40688539e-02f, -3.72961462e-02f,
  4.37546819e-02f, -6.32691607e-02f, -3.45088169e-02f, 1.15909539e-02f, 1.45805720e-02f, 2.93350648e-02f, 2.38247253e-02f, 5.71290478e-02f, -4.01876196e-02f, 1.39169311e-02f,
  4.31817435e-02f, -3.72277051e-02f, -2.52936296e-02f, 4.74531995e-03f, 5.33634573e-02f, -2.59495992e-02f, -2.16652602e-02f, 6.25217259e-02f, -6.61306083e-02f, -2.62441505e-02f,
  -1.03857089e-02f, -8.59324560e-02f, -1.12543255e-02f, -4.27543707e-02f, -1.82821583e-02f, -1.68512799e-02f, -1.63400583e-02f, -1.44054955e-02f, -7.24288309e-03f, -7.54454806e-02f,
  1.45105773e-03f, 2.34144479e-02f, -1.01293009e-02f, 3.76903685e-03f, 2.17174832e-02f, 4.02371259e-03f, 7.97304064e-02f, -2.70341132e-02f, -2.87599582e-02f, 5.00239246e-02f,
  -2.70204991e-02f, -1.04079414e-02f, -2.39257384e-02f, -7.63860205e-03f, -1.01240519e-02f, 6.76212162e-02f, 5.48033156e-02f, 1.72792897e-02f, -4.85572889e-02f, 5.60212657e-02f,
  -4.38912548e-02f, -2.67450735e-02f, 2.91273966e-02f, 1.09876841e-01f, 1.36583229e-03f, -1.34139201e-02f, -2.11934857e-02f, 1.75577104e-02f, -1.76176857e-02f, 4.04759794e-02f,
  2.58259118e-01f, 5.65031618e-02f, 2.25801729e-02f, 5.07863238e-02f, 7.74962977e-02f, 1.81458984e-02f, 7.31228804e-03f, -7.21047726e-03f, 6.02903739e-02f, -2.67037656e-02f,
  -1.68702938e-02f, 9.12331138e-03f, 1.26855131e-02f, 2.04650289e-03f, -3.34635936e-02f, 7.97543824e-02f, -6.27044216e-02f, -2.58152075e-02f, -2.29845550e-02f, -4.61250246e-02f,
  2.32145153e-02f, -1.96297858e-02f, -4.92226332e-02f, 3.83855775e-03f, -1.62759908e-02f, -4.13515270e-02f, -1.42893652e-02f, -1.62865501e-03f, -1.31102325e-02f, -2.49957684e-02f,
  -1.81888282e-01f, 3.05941105e-01f, 2.20527977e-01f, -1.76965445e-02f, 4.86657061e-02f, -3.43950212e-01f, -2.05290273e-01f, 1.24666870e-01f, -1.84250236e-01f, -1.99594554e-02f,
  -2.09933951e-01f, 1.47093758e-01f, 2.48720474e-03f, -2.80428469e-01f, -2.99557775e-01f, -1.90042436e-01f, -2.56246746e-01f, -1.17679276e-01f, -3.95202003e-02f, 1.34884000e-01f,
  5.04154060e-03f, -1.99452013e-01f, 8.57104361e-02f, 1.02636963e-01f, 7.13285580e-02f, 2.64719516e-01f, 1.30543754e-01f, 1.36699244e-01f, 5.85001372e-02f, -8.31786990e-02f,
  -1.41395748e-01f, 2.93423962e-02f, 9.29878801e-02f, 3.15745510e-02f, 4.27539535e-02f, 8.05164278e-02f, -3.23325321e-02f, -4.98495847e-02f, -2.88382005e-02f, 1.18832057e-03f,
  -4.99637127e-02f, 1.33817494e-02f, -4.94229905e-02f, -4.22748215e-02f, -1.49425874e-02f, 6.07479364e-02f, -1.89926964e-03f, 5.55403829e-02f, 2.63673496e-02f, -2.39608455e-02f,
  -9.09024384e-03f, -3.25904451e-02f, -1.54689234e-02f, 1.69627499e-02f, 6.39522672e-02f, -2.07848717e-02f, -1.51796658e-02f, 1.55365318e-02f, 3.54239307e-02f, -4.60192608e-03f,
  6.92749687e-04f, 3.95418368e-02f, 4.01297025e-02f, -2.36745030e-02f, 1.56269670e-02f, -1.82960592e-02f, 4.61547961e-03f, -4.29292955e-02f, -1.06019322e-02f, 1.59198418e-03f,
  -3.49620245e-02f, 2.08296645e-02f, -4.38550934e-02f, 1.16148926e-02f, -4.54011858e-02f, 3.51344906e-02f, 6.27235463e-03f, -8.94566439e-03f, -3.43335755e-02f, -7.37341680e-03f,
  -3.70727130e-03f, -1.48394750e-02f, 4.13747542e-02f, -2.20629945e-02f, 1.58566535e-02f, 3.49403694e-02f, -2.05863398e-02f, 4.31739688e-02f, 4.78041433e-02f, 1.92143692e-04f,
  3.40750813e-02f, 1.87320888e-01f, -2.98286956e-02f, -7.95917735e-02f, 4.22412343e-03f, -6.02692040e-03f, 4.43699397e-02f, 6.69420417e-03f, 7.62569308e-02f, -1.84736624e-02f,
  9.81981233e-02f, 3.44409049e-02f, 3.98984514e-02f, 2.39396724e-03f, -2.47123949e-02f, 4.13839407e-02f, 1.60291437e-02f, -9.19139851e-03f, 6.35394081e-03f, 2.36057676e-02f,
  7.87974820e-02f, 1.97606180e-02f, -2.56126504e-02f, 4.09440398e-02f, -2.71116700e-02f, -1.08355551e-03f, 3.81660722e-02f, 3.35036740e-02f, -3.58600961e-03f, 3.47287506e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.03713551e-01f, -3.29353958e-02f, 5.93808815e-02f, -3.36196989e-01f, 1.37762353e-02f, -2.45699324e-02f, -1.99785367e-01f, -9.75009054e-02f, -1.60737768e-01f, -3.55843842e-01f,
  -1.59300357e-01f, 4.49538417e-02f, 1.97180301e-01f, -3.00168425e-01f, 3.46974313e-01f, 1.97558030e-01f, -2.47215539e-01f, -1.40379637e-01f, 8.65916163e-02f, -1.96961999e-01f,
  7.26790354e-03f, -1.92975596e-01f, 1.90024182e-01f, -1.28215123e-02f, -7.84686208e-02f, -7.78044090e-02f, 5.51410299e-03f, 1.70799568e-01f, -1.35726064e-01f, 8.79580081e-02f,
  -1.20091170e-01f, -2.46455073e-01f, -9.17451158e-02f, -5.32815829e-02f, -9.43533257e-02f, -2.50635017e-02f, 4.83870879e-02f, 8.95789117e-02f, -3.22260410e-02f, -3.72838159e-03f,
  7.42994100e-02f, 2.35486683e-02f, -4.54384424e-02f, -4.87693809e-02f, 1.23874452e-02f, -4.03535850e-02f, 1.06248781e-01f, 6.90717623e-02f, -1.72798764e-02f, 6.53498173e-02f,
  7.75634423e-02f, -6.79941177e-02f, -8.44398960e-02f, -2.80006020e-03f, 4.70075011e-02f, -3.13303322e-02f, -7.66573548e-02f, 1.03437752e-02f, -6.05383851e-02f, -4.03388254e-02f,
  2.98983492e-02f, 4.83879112e-02f, -2.87198182e-02f, 9.36188549e-03f, -5.15503064e-02f, -6.02621324e-02f, -2.90033687e-02f, -2.67073093e-03f, -8.49064216e-02f, 3.37666199e-02f,
  -2.42637414e-02f, -1.17992293e-02f, -7.50980973e-02f, -4.74123582e-02f, -1.45213800e-02f, -8.17304403e-02f, 1.36085693e-02f, 2.76396386e-02f, -5.26141934e-02f, 6.11548163e-02f,
  -3.11324969e-02f, -3.86388786e-02f, -1.27914539e-02f, 3.78372967e-02f, -8.97915885e-02f, 7.84671605e-02f, -4.37756963e-02f, 6.78974856e-03f, 2.53009815e-02f, 6.82017356e-02f,
  -2.02247426e-02f, -2.68331051e-01f, -3.91628742e-02f, -9.22923312e-02f, 3.94451395e-02f, 3.36448476e-02f, 5.24661578e-02f, 7.03752553e-03f, -3.13456915e-02f, -5.52751049e-02f,
  -4.84718718e-02f, -6.44474700e-02f, -3.82098109e-02f, 5.06394217e-03f, 7.65264928e-02f, 3.69529277e-02f, -5.90024516e-02f, -9.33951586e-02f, 3.26306708e-02f, 4.94611003e-02f,
  -1.42943696e-03f, 1.34153888e-02f, 5.53572476e-02f, 1.76045913e-02f, -6.61822855e-02f, -5.40274568e-02f, -7.46590644e-02f, -1.04580391e-02f, 8.50865841e-02f, -1.83417257e-02f,
  1.24462754e-01f, -2.43198603e-01f, -2.42449000e-01f, -1.93726480e-01f, -5.57057112e-02f, -1.41593263e-01f, -1.64059922e-01f, -2.08838135e-01f, -1.57478034e-01f, -8.82503465e-02f,
  -1.10249758e-01f, -2.07469985e-03f, -2.65983911e-03f, -2.57870615e-01f, 4.89413291e-02f, 4.07825559e-02f, -1.62206352e-01f, -1.38888523e-01f, -1.82419904e-02f, -3.08898967e-02f,
  -2.90851146e-02f, -1.07007630e-01f, -1.74878165e-02f, -2.79090889e-02f, -9.12922695e-02f, 3.12435848e-04f, 1.57324210e-01f, -1.15679735e-02f, -1.44170031e-01f, -1.14138655e-01f,
  1.70441680e-02f, -5.18823154e-02f, -9.71038789e-02f, 4.58233021e-02f, 3.54791656e-02f, 1.69710703e-02f, 2.74366904e-02f, 3.36028524e-02f, -4.23759595e-02f, -6.17515529e-03f,
  1.10694967e-01f, 2.07393188e-02f, -2.95411404e-02f, -4.84185219e-02f, -8.13186690e-02f, 7.73154758e-03f, -1.41072748e-02f, -7.71663114e-02f, -3.28370258e-02f, 4.52926792e-02f,
  -6.57552481e-02f, 2.02874225e-02f, -4.08132263e-02f, 3.23011354e-02f, -7.24752396e-02f, -7.43939579e-02f, 2.22270973e-02f, 5.78370411e-03f, -6.86414167e-02f, 6.84493780e-03f,
  3.83356400e-02f, 1.11847907e-01f, -7.77148176e-03f, -6.13572858e-02f, -8.36672708e-02f, 6.70273090e-04f, -6.61575645e-02f, 1.53244622e-02f, 1.45707130e-02f, -1.10455276e-02f,
  -1.49874054e-02f, -8.74634609e-02f, -1.48073677e-03f, 8.70480761e-02f, 5.63897602e-02f, 9.87421572e-02f, -1.27242669e-03f, -2.29895040e-02f, -4.80076596e-02f, -3.81879359e-02f,
  -4.14827652e-02f, 7.69867515e-03f, -3.80053930e-02f, -1.21445535e-02f, 3.21421549e-02f, 5.73761761e-02f, -5.87233305e-02f, 2.33965088e-02f, -5.10534421e-02f, -2.96424218e-02f,
  -7.18975142e-02f, 5.57569899e-02f, 1.54014314e-02f, -2.81175040e-02f, 2.15425491e-02f, 1.08650930e-01f, 2.37082094e-02f, -4.55901958e-02f, 6.90242201e-02f, 5.76170208e-03f,
  -2.96220332e-02f, -4.57605273e-02f, -1.22875171e-02f, 6.13984354e-02f, -7.54812658e-02f, -1.20008528e-01f, 2.09890381e-02f, 7.02889264e-02f, -8.25549290e-02f, -6.55215904e-02f,
  9.97779444e-02f, 5.96124632e-03f, -2.25434732e-02f, -3.40052918e-02f, 1.20927664e-02f, 7.83013701e-02f, 5.30335084e-02f, 5.27083911e-02f, 2.81730909e-02f, 4.10439782e-02f,
  2.68732339e-01f, -9.95771140e-02f, 1.13497064e-01f, 8.62647370e-02f, 7.88187310e-02f, 1.29831219e-02f, 1.71212465e-01f, -4.15475890e-02f, 1.00026600e-01f, -1.38949826e-01f,
  1.03698097e-01f, -9.35582593e-02f, -4.31816392e-02f, -3.43414247e-02f, 7.89949074e-02f, -2.03026272e-02f, 9.32905357e-03f, -2.15857681e-02f, -2.04115249e-02f, 3.05529181e-02f,
  3.59045118e-02f, -6.71762526e-02f, -3.37558845e-03f, -1.57127187e-01f, 1.33134007e-01f, 1.06435850e-01f, 1.31341383e-01f, 6.69650659e-02f, -1.12449251e-01f, 5.03681973e-03f,
  -4.10860069e-02f, 2.44876873e-02f, -4.59905155e-02f, -1.08599447e-01f, 4.12726961e-02f, 2.79625002e-02f, -1.88197140e-04f, -2.08851490e-02f, 1.23212149e-03f, -4.79147993e-02f,
  -2.13453993e-02f, -8.27626064e-02f, 1.69817694e-02f, 5.17141111e-02f, 1.12625761e-02f, -3.40409428e-02f, 3.19916531e-02f, -3.33582796e-02f, 4.09713164e-02f, 6.30948767e-02f,
  -1.20145511e-02f, -1.01910174e-01f, 8.45555812e-02f, 3.56462697e-04f, 4.79405606e-03f, -8.19950551e-02f, -1.06780328e-01f, 4.08109799e-02f, 4.36248287e-04f, 1.72184836e-02f,
  -3.96259613e-02f, 4.35684854e-03f, 1.03650400e-02f, -1.07295606e-02f, -4.57550678e-03f, 5.57433348e-04f, 1.78907905e-02f, 4.58633490e-02f, -3.45014371e-02f, 8.83325264e-02f,
  1.44766960e-02f, 4.49635163e-02f, 6.61328584e-02f, 3.59466560e-02f, -7.07507804e-02f, 2.28626262e-02f, 6.87096119e-02f, -1.10783666e-01f, 3.83278280e-02f, 9.15219262e-02f,
  -3.97125855e-02f, -3.61988768e-02f, -1.35984346e-02f, 1.85213760e-02f, -1.28215356e-02f, 3.23080458e-02f, -8.50690976e-02f, 2.58432571e-02f, -2.76157241e-02f, 6.08984865e-02f,
  -1.63420886e-01f, -1.56241268e-01f, 4.11444623e-03f, -9.78982672e-02f, -5.98765165e-02f, -4.01853807e-02f, 4.30494770e-02f, -8.97643343e-02f, 4.67850417e-02f, -1.31307021e-02f,
  -4.20966335e-02f, 8.41873735e-02f, -5.77543266e-02f, -5.02933301e-02f, -7.52596185e-02f, 5.72343916e-02f, 8.01869035e-02f, -3.75542566e-02f, -3.68084423e-02f, -6.37700930e-02f,
  -4.11788225e-02f, -1.69603317e-03f, -3.95226926e-02f, -4.98114713e-02f, 4.59916256e-02f, -1.72545258e-02f, 3.64292637e-02f, 1.13488557e-02f, 4.78438661e-02f, -4.84159142e-02f,
  1.79189891e-02f, -2.70704012e-02f, 1.60821423e-01f, -1.20647922e-01f, 2.34380141e-02f, 1.58589751e-01f, 1.96112573e-01f, -4.50054817e-02f, 1.15783960e-02f, -2.29008608e-02f,
  5.79412386e-04f, 6.39404356e-02f, 1.32832080e-01f, -1.82214275e-01f, 3.01610500e-01f, 1.41492575e-01f, -1.34668469e-01f, -2.55262908e-02f, -8.81403536e-02f, -5.96683845e-02f,
  2.56769657e-02f, -1.70689058e-02f, 9.38817300e-03f, -1.85955256e-01f, -1.42601818e-01f, -9.28869247e-02f, -9.17552114e-02f, 1.78845543e-02f, -9.97226536e-02f, 3.02870590e-02f,
  8.91247466e-02f, -5.77653609e-02f, -3.85386311e-02f, 6.37462288e-02f, -1.48128476e-02f, -2.08030455e-02f, 6.73358291e-02f, 7.91090503e-02f, -3.75333615e-02f, -9.05047357e-03f,
  6.36261925e-02f, 4.45022807e-03f, -7.37110674e-02f, -4.41104770e-02f, -8.21270198e-02f, -8.74021649e-02f, -5.25545999e-02f, -6.39606416e-02f, -1.01251956e-02f, -2.85481475e-02f,
  -2.14590430e-02f, -5.93157671e-02f, -2.61815097e-02f, 4.94786426e-02f, -6.36430504e-03f, 5.38920015e-02f, 5.45501001e-02f, 6.13450520e-02f, 1.35282446e-02f, -5.67656681e-02f,
  -4.04746644e-02f, 7.17468113e-02f, 1.38855698e-02f, -5.87223917e-02f, 6.11130260e-02f, -3.34417373e-02f, 4.15641852e-02f, -1.03740059e-02f, 2.77854148e-02f, 1.50676770e-02f,
  -1.29672205e-02f, -2.88375821e-02f, 7.37370690e-04f, -8.38836804e-02f, -3.34248543e-02f, -7.27089681e-03f, 6.47781231e-03f, -6.42180815e-02f, 3.28465700e-02f, 5.26933633e-02f,
  2.65419502e-02f, -3.93587314e-02f, -3.03124208e-02f, -2.93916687e-02f, 6.73870817e-02f, 2.25534588e-02f, -2.63779704e-02f, -3.68641540e-02f, -7.28886854e-03f, -3.83794331e-03f,
  1.13897964e-01f, 1.53722957e-01f, -2.14192811e-02f, 1.94956157e-02f, 3.38044912e-02f, 2.27250885e-02f, -6.31395951e-02f, -6.49492815e-02f, 6.49023429e-02f, 7.29266228e-03f,
  -4.05625664e-02f, 2.38610078e-02f, 2.59446632e-02f, -7.21227303e-02f, 4.85895313e-02f, -4.57852259e-02f, -1.69325597e-03f, -1.38790943e-02f, 4.08806559e-03f, -4.96581756e-02f,
  -3.43027036e-03f, 1.48184896e-01f, 7.01222047e-02f, -1.24377636e-02f, -1.47184078e-03f, -8.35985988e-02f, 6.63564503e-02f, -2.54400168e-02f, -9.06056836e-02f, -1.19372122e-02f,
  -3.59264053e-02f, 4.06043679e-02f, -5.29138222e-02f, 1.02728590e-01f, 9.09542814e-02f, -9.95581523e-02f, -3.13479975e-02f, 4.99900617e-02f, 7.26120546e-02f, 7.89154693e-03f,
  1.92440320e-02f, -7.47073516e-02f, 3.11640538e-02f, -2.60214345e-03f, -1.32067934e-01f, -6.27489537e-02f, -8.21905434e-02f, -2.31198426e-02f, -5.10404222e-02f, 4.13091816e-02f,
  9.03510023e-04f, 7.58848861e-02f, -7.77758136e-02f, -1.08431792e-02f, 2.08163373e-02f, -1.54841493e-03f, -2.41554491e-02f, -2.85030268e-02f, -1.15470216e-01f, -7.66146705e-02f,
  -1.11184366e-01f, 1.05580509e-01f, -2.43308805e-02f, 1.89901702e-02f, 7.70752281e-02f, -2.16206256e-02f, 4.70826700e-02f, 5.23433760e-02f, 4.04128283e-02f, 4.55972776e-02f,
  7.12421387e-02f, -3.63901146e-02f, -6.57852590e-02f, -3.85099724e-02f, 1.19522795e-01f, 6.50536362e-03f, -5.99684417e-02f, -5.90579100e-02f, -7.41231535e-03f, 5.85656278e-02f,
  3.20775807e-02f, 5.49661405e-02f, -7.48295709e-02f, -4.06955518e-02f, -7.93919191e-02f, -9.28269234e-03f, 4.95023727e-02f, 2.82221045e-02f, 2.66397763e-02f, 8.99419561e-02f,
  2.00168304e-02f, 6.91875443e-02f, 2.16042809e-02f, -1.35752326e-03f, 5.18124476e-02f, -1.28400577e-02f, -2.84725297e-02f, 2.22957041e-02f, 2.79529952e-02f, 7.75866359e-02f,
  -5.57290344e-03f, -6.01405427e-02f, 3.30253802e-02f, 4.47809324e-02f, -7.25758262e-04f, 1.37598172e-03f, -3.63310724e-02f, 8.51601064e-02f, 3.18117552e-02f, 8.26988891e-02f,
  -6.88482448e-02f, 4.98685688e-02f, -3.97470854e-02f, 1.67226102e-02f, -1.03988163e-01f, 6.38363063e-02f, -5.06559499e-02f, 4.45099063e-02f, -7.25017413e-02f, -2.74902694e-02f,
  1.11313887e-01f, 5.32226153e-02f, 1.74455810e-02f, -7.92426541e-02f, 7.72220418e-02f, 1.11934275e-03f, 6.34122267e-02f, 2.62763686e-02f, -2.73342561e-02f, -5.54550998e-02f,
  -8.42313915e-02f, -7.23449141e-02f, 4.97924611e-02f, 3.83190364e-02f, 4.13314216e-02f, 3.18123214e-02f, 4.75202799e-02f, 3.29623893e-02f, 4.90359478e-02f, -6.82467371e-02f,
  -9.42592788e-03f, 5.30950315e-02f, -5.02527878e-02f, 6.71048649e-03f, 2.56031044e-02f, -4.55743037e-02f, -1.00575827e-01f, 3.71608622e-02f, 3.72513942e-02f, 3.38715501e-02f,
  -1.39338434e-01f, 2.06961855e-02f, -1.14675082e-01f, -2.42277697e-01f, -9.69706755e-03f, -2.06727758e-01f, -6.83181286e-02f, 2.50686817e-02f, -7.76635706e-02f, 1.41999766e-01f,
  -4.31706570e-02f, -6.31060898e-02f, 6.37012348e-02f, 2.32843217e-02f, -2.41418526e-01f, 8.83075967e-02f, -1.19113579e-01f, -1.20398946e-01f, -9.47170928e-02f, -1.46450534e-01f,
  -2.57068910e-02f, -6.41326904e-02f, -8.07880089e-02f, 5.02687208e-02f, -1.27024606e-01f, -1.09233253e-01f, 5.92253096e-02f, 3.19768698e-03f, -7.49024376e-03f, -4.50636186e-02f,
  1.70580912e-02f, -1.18651092e-01f, 1.52130155e-02f, -7.87600353e-02f, -1.15072317e-01f, -8.18716139e-02f, -4.18378226e-02f, 3.36765945e-02f, -6.88403770e-02f, -9.84551832e-02f,
  -9.28445682e-02f, 1.76129695e-02f, -8.86999071e-02f, 2.77960338e-02f, 5.82304373e-02f, 1.66412387e-02f, 8.73353779e-02f, -9.47600082e-02f, -3.41243669e-02f, -6.01434186e-02f,
  -5.67511916e-02f, 3.46881561e-02f, -1.87819023e-02f, -3.78190167e-02f, -6.76554814e-02f, 3.35289724e-02f, -6.75026253e-02f, -1.85116138e-02f, -6.43217862e-02f, -8.39706790e-03f,
  3.45299728e-02f, 1.15047311e-02f, 2.21297285e-03f, 8.93237889e-02f, -2.96081938e-02f, 2.04855502e-02f, 1.00210411e-02f, 9.41952467e-02f, -5.43249324e-02f, -2.13951208e-02f,
  3.26143540e-02f, 2.17911918e-02f, 5.53877801e-02f, -4.33883443e-02f, -1.02555640e-02f, -1.82184242e-02f, 5.31215370e-02f, -1.18239559e-02f, -3.14123146e-02f, 1.99034810e-02f,
  6.52263463e-02f, 9.57263112e-02f, -2.32549440e-02f, -8.92809480e-02f, -3.52629134e-03f, 3.34389992e-02f, 5.47542088e-02f, -8.94031972e-02f, -1.65208150e-02f, -1.39860976e-02f,
  1.25346007e-02f, -9.11213905e-02f, -6.22855574e-02f, -4.09452505e-02f, -1.94790866e-02f, 5.72392382e-02f, -8.03603008e-02f, -7.95876086e-02f, -8.10875371e-02f, 7.25093707e-02f,
  -4.18101326e-02f, 4.01843488e-02f, 4.20028158e-02f, 1.44711267e-02f, -5.92018701e-02f, -6.93812370e-02f, 5.64312227e-02f, 1.41361821e-02f, -4.17835787e-02f, -6.47555888e-02f,
  1.20732384e-02f, 4.59975610e-03f, -6.27820268e-02f, -5.50485291e-02f, -2.06163246e-02f, 2.27424838e-02f, 3.80495861e-02f, 2.89148334e-02f, 3.83793116e-02f, 8.20612460e-02f,
  -4.38095421e-01f, 2.04299286e-01f, 2.15073377e-01f, -2.69634783e-01f, 4.08064015e-02f, 6.74892217e-02f, -1.11892037e-01f, 1.41413897e-01f, -3.30932364e-02f, -1.34656820e-02f,
  5.88286594e-02f, -3.04083284e-02f, 6.83730319e-02f, 4.64566052e-02f, -9.18530673e-02f, 6.60561305e-03f, -3.90290394e-02f, -1.47478297e-01f, -9.04117827e-04f, -6.65425835e-03f,
  -7.11453632e-02f, -1.06671266e-01f, 1.04132608e-01f, 6.62347302e-03f, -5.70642836e-02f, -4.36144620e-02f, -1.46738708e-01f, 1.11558162e-01f, -4.83865105e-03f, 1.08309746e-01f,
  -9.20924321e-02f, -2.31558055e-01f, -6.00400232e-02f, -2.32256427e-02f, -3.30560021e-02f, -8.31883848e-02f, -7.81601518e-02f, -2.21464355e-02f, -5.48737571e-02f, -6.81338832e-02f,
  -7.28191286e-02f, 9.14549362e-03f, 2.13701930e-02f, 6.21098131e-02f, 1.23406493e-03f, 4.14393358e-02f, 6.65400773e-02f, -2.05228180e-02f, 5.66298254e-02f, 5.03843054e-02f,
  8.44794139e-02f, 6.66289544e-03f, -2.02383194e-02f, 2.92352363e-02f, 7.74680451e-02f, -8.02166667e-03f, -6.63966220e-03f, 6.44151419e-02f, -5.18766884e-03f, 4.52173455e-03f,
  -6.27310053e-02f, -2.97969580e-02f, -2.84860730e-02f, 8.17904845e-02f, -2.59332974e-02f, 6.68522939e-02f, 3.65865938e-02f, -7.18564168e-02f, -7.31430203e-02f, -6.32971451e-02f,
  5.47677204e-02f, -1.07976655e-03f, 1.38829844e-02f, -2.02475451e-02f, -6.28516525e-02f, -3.38786058e-02f, 2.16939021e-02f, -1.07918372e-02f, 6.59883246e-02f, -2.69300994e-02f,
  1.90743189e-02f, 8.04448128e-02f, -2.50076619e-03f, -1.39020815e-01f, 3.75694446e-02f, 2.04239525e-02f, -5.84552251e-02f, 9.74617805e-03f, 2.09368411e-02f, -5.93904965e-02f,
  -2.36448944e-01f, -2.37841621e-01f, -3.96929048e-02f, -5.42846881e-02f, 1.14010628e-02f, -5.75544499e-02f, -5.73312975e-02f, 5.17072678e-02f, -2.56002843e-02f, -4.40163817e-03f,
  -6.90639466e-02f, -2.49722321e-02f, 3.10795698e-02f, 7.46836662e-02f, -3.52817997e-02f, -4.50003594e-02f, -8.73367712e-02f, -7.98184350e-02f, -8.51308331e-02f, 4.05109487e-02f,
  -3.53733846e-03f, -1.34800458e-02f, -7.01458368e-04f, -2.75130384e-02f, 3.60052027e-02f, -1.78172719e-02f, 1.96670406e-02f, -6.93202913e-02f, -6.52227327e-02f, -6.69369381e-03f,
  -2.73346738e-03f, -2.22371131e-01f, -4.51282188e-02f, -1.38761133e-01f, -1.15735285e-01f, -3.14002633e-01f, -2.65313417e-01f, -1.28079817e-01f, 1.11397512e-01f, -1.32576585e-01f,
  -1.89429432e-01f, -5.87192783e-03f, 4.51247953e-02f, -1.84539452e-01f, 9.30677131e-02f, 1.13570258e-01f, -9.71045792e-02f, -1.67618781e-01f, 5.48808649e-02f, -2.15136856e-01f,
  -3.13103795e-02f, -2.44464487e-01f, -1.70235503e-02f, -1.50979042e-01f, -1.68608576e-01f, 2.10759547e-02f, 1.10557750e-01f, -7.64547288e-02f, -1.98230684e-01f, -1.07143089e-01f,
  -1.05076708e-01f, 9.00500715e-02f, -5.09003699e-02f, 3.49729918e-02f, 3.11932974e-02f, -2.61700805e-02f, -4.12983336e-02f, -3.30078341e-02f, 2.51621641e-02f, 5.23331352e-02f,
  -6.22752756e-02f, 2.15777978e-02f, -5.88384792e-02f, 7.12817982e-02f, -8.96697417e-02f, -7.73474574e-02f, 2.59982310e-02f, 4.72249426e-02f, -4.17503119e-02f, -8.97820964e-02f,
  -2.12032832e-02f, -4.11187261e-02f, 1.28432019e-02f, -2.53510512e-02f, 4.14195992e-02f, -8.82896632e-02f, 6.63705617e-02f, 1.82836484e-02f, -1.45624084e-02f, 2.61198282e-02f,
  -3.43337171e-02f, 2.60999613e-03f, 3.25750299e-02f, 7.50788487e-03f, 2.52701826e-02f, -3.93582731e-02f, -6.18225783e-02f, -1.73592903e-02f, 4.19674404e-02f, -6.25856817e-02f,
  -3.91598186e-03f, -1.31618474e-02f, -1.73901878e-02f, 7.69961029e-02f, -8.73301178e-02f, 4.74782996e-02f, 1.82188246e-02f, -2.24038260e-03f, 1.92313266e-04f, 1.08152136e-01f,
  1.90429646e-03f, 6.70538172e-02f, 9.84341465e-03f, 4.43493128e-02f, -2.54320391e-02f, 1.14057939e-02f, 6.31367341e-02f, -2.11599488e-02f, 2.14822534e-02f, -2.32898872e-02f,
  -7.56470859e-02f, -2.61709038e-02f, -6.43013790e-03f, -6.00977801e-02f, 1.08088665e-02f, -5.54896221e-02f, -3.29929462e-04f, -4.48665433e-02f, -5.95147759e-02f, -6.53405041e-02f,
  -3.03365123e-02f, -3.74440406e-03f, 8.04036781e-02f, -3.38919424e-02f, -5.24820946e-02f, 6.85739070e-02f, 1.56911705e-02f, 4.77822945e-02f, -1.48919553e-05f, -4.56341393e-02f,
  -2.73272321e-02f, -4.53395881e-02f, -2.58955043e-02f, -7.39306211e-03f, -3.18221152e-02f, 4.49460037e-02f, -3.24737169e-02f, 7.54545792e-04f, 2.60010045e-02f, 9.37276462e-04f,
  -1.02005444e-01f, 1.38843775e-01f, -1.12672344e-01f, -4.11196314e-02f, 1.12989046e-01f, 2.37147316e-01f, 4.77503948e-02f, 1.77329734e-01f, 3.02083731e-01f, 1.38789162e-01f,
  5.46335056e-02f, 1.71494395e-01f, 3.75265181e-02f, 1.11306254e-02f, 1.39114499e-01f, 2.03189865e-01f, 1.67297404e-02f, 5.29831722e-02f, 1.14671454e-01f, 9.66287218e-03f,
  4.95243352e-03f, -2.56993137e-02f, -1.40951842e-01f, -1.74414486e-01f, -1.90820917e-01f, -1.44197926e-01f, -8.74112248e-02f, -1.40134215e-01f, -7.41193816e-02f, 9.13822725e-02f,
  -1.33919613e-02f, -1.27742514e-01f, -6.65477067e-02f, -9.48375538e-02f, -3.53289396e-02f, -1.14679828e-01f, -1.16421886e-01f, -7.86931589e-02f, 2.81409640e-03f, 1.39945913e-02f,
  -9.28003639e-02f, -9.89423543e-02f, 3.02138664e-02f, 4.94951941e-02f, 5.93517236e-02f, 3.89543511e-02f, -4.95690331e-02f, -6.52006641e-02f, -6.35507479e-02f, -6.48477301e-02f,
  -2.54316758e-02f, 5.01538515e-02f, -1.59962270e-02f, 3.89479585e-02f, -1.27974025e-03f, 4.88819592e-02f, -6.53000027e-02f, 1.80439185e-02f, 6.42788112e-02f, 9.33674425e-02f,
  7.54211545e-02f, -4.32653613e-02f, 3.46531980e-02f, 3.91054414e-02f, -7.11191297e-02f, -7.51913488e-02f, -2.30473150e-02f, 1.82972681e-02f, -2.14374084e-02f, -4.71045412e-02f,
  -8.23199376e-03f, 2.79807709e-02f, 3.17828543e-02f, 6.24455046e-03f, -5.01914099e-02f, -9.27695483e-02f, 4.13016453e-02f, 3.60407308e-02f, 7.61541352e-02f, -3.93271968e-02f,
  4.63239253e-02f, 4.37429324e-02f, -3.98111120e-02f, -5.47779817e-03f, 9.45914537e-03f, -5.47529683e-02f, 4.94586341e-02f, 8.44783187e-02f, 1.77371334e-02f, 3.42435688e-02f,
  2.22965568e-01f, 2.56008774e-01f, -2.19997559e-02f, 4.49181683e-02f, -6.05873531e-04f, -4.78627756e-02f, 2.82121673e-02f, 3.95867079e-02f, 5.91237433e-02f, 1.01722620e-01f,
  1.19950129e-02f, -1.27905980e-02f, 5.18812239e-02f, 2.54404470e-02f, 6.96032727e-03f, 1.66158774e-03f, 3.56650241e-02f, 2.97633801e-02f, 3.18436325e-02f, 9.38392058e-02f,
  -6.37588231e-03f, -3.83181535e-02f, -3.21414322e-02f, 1.91458426e-02f, -5.65009303e-02f, -9.91820097e-02f, 9.34911072e-02f, -3.25342230e-02f, 6.38679713e-02f, 2.05496754e-02f,
  -3.02701890e-01f, 5.06404974e-02f, -1.95941687e-01f, -1.38683408e-01f, 1.42536080e-02f, -2.04713941e-01f, -2.55221017e-02f, 5.51912263e-02f, -2.80795041e-02f, 4.89673577e-02f,
  2.68663485e-02f, -9.06403139e-02f, 6.22092523e-02f, -2.58961529e-01f, -4.12386179e-01f, -9.21405256e-02f, -3.40645313e-01f, -1.63458496e-01f, -9.63560715e-02f, -5.20418175e-02f,
  -1.54187977e-01f, -2.93212663e-02f, -2.35899210e-01f, 1.27849832e-01f, -9.90313366e-02f, -3.76611087e-03f, 5.39238639e-02f, 1.75453842e-01f, -8.03825110e-02f, -4.06694412e-02f,
  -5.53760342e-02f, 1.29358754e-01f, 4.31736857e-02f, 2.83376817e-02f, -1.12193063e-01f, -7.58312736e-03f, 5.48097305e-03f, -3.35291475e-02f, 9.85999964e-03f, -1.68402288e-02f,
  7.84332771e-03f, -6.92563057e-02f, -3.43634039e-02f, 6.05687648e-02f, -4.45906222e-02f, -2.86327135e-02f, -5.88628501e-02f, 1.19025987e-02f, -5.10083176e-02f, -1.87387764e-02f,
  1.70325451e-02f, -3.28474641e-02f, 1.74054950e-02f, 3.96179734e-03f, -9.32892412e-02f, 5.10546044e-02f, -6.07572831e-02f, -9.51388665e-03f, -7.10432231e-02f, -1.11010760e-01f,
  -5.01403632e-03f, -1.12630688e-02f, 5.67213669e-02f, 5.01146866e-03f, -1.34628229e-02f, 1.63775887e-02f, -2.29142942e-02f, -1.77214723e-02f, 5.91735393e-02f, -9.89708025e-03f,
  1.23946154e-02f, 5.03891148e-02f, 5.11388108e-02f, -9.40995850e-03f, 1.87206604e-02f, 2.64720637e-02f, -4.12946055e-03f, 2.32788976e-02f, -5.58502153e-02f, -2.82448679e-02f,
  9.54028293e-02f, -3.31573635e-02f, 3.08435410e-02f, 6.29282370e-02f, 6.37118295e-02f, -4.52157408e-02f, -1.64793655e-02f, -1.85330268e-02f, 3.06562334e-02f, 1.09582755e-03f,
  7.77413249e-02f, 8.37255418e-02f, 5.03810197e-02f, 2.94926222e-02f, 6.17291294e-02f, -4.50028628e-02f, -3.49339284e-02f, -4.11739051e-02f, -8.30926821e-02f, -4.95635569e-02f,
  3.08892801e-02f, 2.96123829e-02f, -3.38358991e-02f, -8.40736553e-02f, -1.64509118e-02f, -8.42620060e-02f, 9.93948877e-02f, 4.12145108e-02f, 4.53781001e-02f, 4.34423462e-02f,
  -2.93447506e-02f, -1.51088750e-02f, -3.40752043e-02f, 4.08920199e-02f, -7.77862454e-03f, -2.07356550e-02f, 1.31705925e-02f, 1.13835614e-02f, -2.45404593e-03f, -1.08814277e-02f,
  1.74448505e-01f, 6.31158948e-02f, 9.71059352e-02f, -1.18897604e-02f, -6.42056316e-02f, -4.45164852e-02f, -1.95025373e-03f, 4.30083312e-02f, -4.46166620e-02f, -1.24504149e-01f,
  4.61938716e-02f, -4.10332084e-02f, -1.31649807e-01f, -1.36404661e-02f, -1.11610450e-01f, -3.20043936e-02f, 2.71551195e-03f, -1.51481666e-02f, -1.55825205e-02f, -2.22321376e-02f,
  4.00606766e-02f, 1.02795456e-02f, 3.50289717e-02f, 6.51842803e-02f, -1.75235625e-02f, 1.44414715e-02f, 4.52596061e-02f, -2.76045352e-02f, -3.56897153e-02f, -1.60341486e-02f,
  7.17152804e-02f, -4.00895625e-02f, -5.84676601e-02f, -1.90337151e-02f, 7.60071203e-02f, -3.11017390e-02f, -6.59282953e-02f, 4.60286140e-02f, -4.98790629e-02f, -5.92106692e-02f,
  -8.45586043e-03f, -3.36655863e-02f, -6.28393963e-02f, -3.92213315e-02f, 6.00493886e-02f, 4.34542401e-03f, -7.66422078e-02f, 6.70929179e-02f, -9.65083297e-03f, -3.44135165e-02f,
  -6.77145049e-02f, 2.80154068e-02f, 6.88665211e-02f, -2.22658422e-02f, 6.68019056e-02f, -4.49443683e-02f, -4.47778627e-02f, 5.61643653e-02f, 6.93889381e-03f, -5.73759153e-02f,
  2.03942340e-02f, 4.77345809e-02f, -1.80953201e-02f, 2.97445841e-02f, 1.94706637e-02f, -2.75529679e-02f, -2.31684726e-02f, -3.27645354e-02f, -4.93606180e-02f, -2.03693006e-02f,
  -2.06501223e-02f, 4.78619412e-02f, -2.08149161e-02f, -7.10584894e-02f, -4.69174422e-02f, 6.47094175e-02f, -8.35260749e-02f, 5.95452972e-02f, 6.71071112e-02f, 2.82104816e-02f,
  1.25971017e-02f, 3.75539460e-03f, -1.75429042e-02f, 5.15912175e-02f, 4.25270535e-02f, -2.72226091e-02f, 6.87421113e-02f, 2.77931076e-02f, -5.02634607e-02f, 4.42023249e-03f,
  -3.92662100e-02f, 1.05677173e-02f, 2.48782374e-02f, -6.92439377e-02f, 3.07130348e-03f, 9.53069925e-02f, 1.15496181e-02f, 3.97788621e-02f, -3.73562947e-02f, -1.05056576e-02f,
  6.12709038e-02f, 6.60230741e-02f, -7.05850869e-02f, 7.38419965e-02f, -7.99363106e-02f, -6.05967380e-02f, -6.92121089e-02f, -7.30777681e-02f, -4.83478978e-02f, -3.46579291e-02f,
  1.90740414e-02f, -4.88910452e-03f, 2.04311740e-02f, 4.42565680e-02f, -3.42599303e-03f, 8.28588456e-02f, 8.24156683e-03f, 7.61978850e-02f, -6.32400513e-02f, -4.63375561e-02f,
  -2.81960517e-01f, -5.84270209e-02f, 1.03343152e-01f, -1.35181040e-01f, 9.64063480e-02f, 5.98567724e-02f, -9.34822261e-02f, 2.83877179e-03f, -1.24461465e-01f, -5.68518266e-02f,
  -7.97641501e-02f, -1.05248883e-01f, 6.50619641e-02f, -1.11526728e-01f, 6.71158731e-03f, 4.36023176e-02f, -1.72028095e-01f, -1.24888562e-01f, 2.40324680e-02f, -4.01106738e-02f,
  -1.75857507e-02f, -5.96016571e-02f, -9.76756308e-03f, 1.68361828e-01f, -3.54499444e-02f, 4.01051417e-02f, -8.04432631e-02f, 6.03262261e-02f, -3.81736383e-02f, 1.03813708e-02f,
  -3.61400992e-02f, 1.12991340e-01f, 7.34191686e-02f, 1.07785083e-01f, 2.35147271e-02f, 1.27336020e-02f, -5.47906421e-02f, -5.69004864e-02f, -3.03619709e-02f, -2.28723288e-02f,
  -1.27016231e-01f, 1.12584367e-01f, -1.08145051e-01f, 3.69046815e-02f, 1.66530125e-02f, 6.59085736e-02f, 5.99390920e-03f, -9.36330482e-02f, 2.57105492e-02f, -1.72168612e-02f,
  2.18877615e-03f, 5.89131266e-02f, 2.49223821e-02f, 2.99175642e-02f, -3.31208520e-02f, 2.61622686e-02f, -1.37304114e-02f, 7.00329840e-02f, 1.30365668e-02f, 4.63583618e-02f,
  1.81927755e-02f, -6.80144280e-02f, 9.84951854e-02f, -2.48025954e-02f, -2.08662096e-02f, -1.54891657e-02f, 4.16489467e-02f, 6.52818158e-02f, -1.18613234e-02f, -2.22282391e-02f,
  1.60439848e-03f, -8.42264742e-02f, 1.19179681e-01f, 4.58186306e-02f, -6.65788725e-02f, -3.64545323e-02f, 6.21127225e-02f, -3.71925384e-02f, -2.53962502e-02f, -5.85493818e-02f,
  -5.99377155e-02f, -8.22521001e-02f, -6.70696516e-03f, 4.94235456e-02f, 8.24105516e-02f, 1.02116250e-01f, 3.10118999e-02f, 7.16919526e-02f, 8.07073899e-03f, 3.12118195e-02f,
  -4.68351655e-02f, -1.11709923e-01f, 5.23146838e-02f, 1.59321465e-02f, -2.20430419e-02f, -3.32758948e-02f, 2.91738920e-02f, -7.37876371e-02f, -7.16048619e-03f, 4.90403175e-03f,
  -1.42221814e-02f, 6.79247752e-02f, -2.72389334e-02f, -5.87262176e-02f, 6.63695335e-02f, -2.50225123e-02f, 2.06526592e-02f, 3.79213355e-02f, -6.54003173e-02f, 2.74126157e-02f,
  -3.82011719e-02f, 1.55559825e-02f, -1.46845477e-02f, -7.73758590e-02f, 2.69155542e-04f, -2.95202676e-02f, -6.27545640e-02f, 4.78445031e-02f, 1.45102534e-02f, -8.61706436e-02f,
  9.87513550e-03f, 9.58659500e-02f, 2.36057900e-02f, 4.16294634e-02f, 9.63838324e-02f, 3.88714410e-02f, 7.25952312e-02f, 3.86010632e-02f, -5.35440408e-02f, 7.35280942e-03f,
  1.95155255e-02f, -2.67267320e-02f, -2.01934669e-02f, -8.56134072e-02f, -2.08319604e-01f, -3.11441496e-02f, -1.08669356e-01f, -1.19709922e-02f, -7.72004342e-03f, -3.34754586e-02f,
  7.48914201e-03f, -1.21780142e-01f, -9.07318145e-02f, 2.08357591e-02f, -7.30382949e-02f, 6.05926216e-02f, -7.59002045e-02f, -6.19451627e-02f, -1.06722524e-03f, -7.91439563e-02f,
  9.47823599e-02f, -5.50508685e-02f, -2.09669508e-02f, -2.93969642e-02f, -5.48852719e-02f, 9.09331217e-02f, -7.64158443e-02f, 9.81996302e-03f, -7.10979477e-02f, 4.02085669e-02f,
  -6.14827499e-02f, 4.66958014e-03f, -1.24454880e-02f, -8.62950981e-02f, 2.46389303e-02f, 2.89569739e-02f, 1.96127524e-03f, -3.92316282e-02f, -2.32890397e-02f, -3.86391431e-02f,
  -5.93172722e-02f, 1.03195347e-02f, 7.15161785e-02f, -6.86644018e-02f, 7.15814009e-02f, -5.88433146e-02f, -8.11788067e-02f, -1.63652971e-02f, -3.63246538e-02f, -4.60009016e-02f,
  -8.43911543e-02f, -1.86339710e-02f, 4.14620191e-02f, -4.81551848e-02f, -4.44652066e-02f, 4.59093638e-02f, 8.34752470e-02f, 7.84511492e-02f, -7.44924918e-02f, -5.47024719e-02f,
  -1.43048139e-02f, -3.46359648e-02f, -4.59835865e-02f, 1.37348790e-02f, 1.82508789e-02f, 5.98998219e-02f, 6.23776577e-04f, -3.74069028e-02f, 2.59439182e-02f, -1.18865417e-02f,
  -6.30087312e-03f, -5.37953712e-02f, -8.77519175e-02f, 2.16249395e-02f, 2.51158979e-02f, -9.03445575e-03f, 4.48334105e-02f, -9.55155483e-05f, -4.85500954e-02f, 1.00355307e-02f,
  5.95913734e-03f, 8.80170707e-03f, 9.07326192e-02f, -2.66564004e-02f, -2.13648509e-02f, 4.56624329e-02f, -5.01618944e-02f, -4.89380956e-02f, -1.09641049e-02f, -4.94687073e-02f,
  -3.49839590e-02f, 8.47299993e-02f, -6.57210648e-02f, -8.85111839e-02f, -4.68053073e-02f, 1.09543344e-02f, 5.67599870e-02f, 5.85003681e-02f, 5.57406880e-02f, 2.23927516e-02f,
  2.52717976e-02f, 7.31475204e-02f, -4.39792238e-02f, 5.21329567e-02f, 1.25437705e-02f, -3.76108997e-02f, 1.27150202e-02f, -2.33846102e-02f, 6.73221350e-02f, 3.34576936e-03f,
  -2.42335815e-02f, 6.69537783e-02f, 7.00111613e-02f, 2.36313030e-01f, -6.61105961e-02f, -2.29918316e-01f, -2.06415012e-01f, 7.29657486e-02f, -8.72255862e-02f, -2.39554811e-02f,
  1.10340593e-02f, 3.20332684e-02f, 1.57411639e-02f, 6.18309639e-02f, -1.03478208e-01f, -9.59999114e-02f, 7.27081345e-03f, -8.88617337e-02f, -1.15529992e-01f, 1.48500338e-01f,
  9.78807285e-02f, 2.21808273e-02f, 1.52784079e-01f, -2.96604652e-02f, 3.82395536e-02f, 1.46597639e-01f, 2.60033399e-01f, 9.61797014e-02f, 1.93232857e-02f, -1.51554048e-01f,
  -2.66484115e-02f, 3.29412967e-02f, -2.10489258e-02f, -2.09482666e-02f, -6.04459131e-03f, 4.88247499e-02f, 2.92295385e-02f, -7.45895356e-02f, 3.51886600e-02f, 2.49506105e-02f,
  3.58147845e-02f, -4.57845256e-02f, -3.92640792e-02f, -4.24701199e-02f, 2.80163605e-02f, 5.13610840e-02f, 1.88300386e-02f, -4.99323644e-02f, 3.02550346e-02f, 8.80721584e-02f,
  9.73961353e-02f, 4.95474599e-03f, 3.73762771e-02f, -3.10158301e-02f, 5.75105995e-02f, 1.98186822e-02f, -1.78889427e-02f, -9.60672740e-03f, 7.39858672e-02f, -1.45992055e-03f,
  -8.59136507e-02f, -1.51357381e-02f, 4.77357814e-03f, -1.13818571e-02f, -5.07438891e-02f, 5.58118662e-03f, 2.04538908e-02f, 6.19704463e-02f, 2.94671934e-02f, -3.61519642e-02f,
  -3.32304686e-02f, -2.67561600e-02f, -2.43747402e-02f, 2.18944736e-02f, 8.89946707e-03f, -3.06064822e-02f, -1.03169940e-02f, 1.37653174e-02f, 5.78642488e-02f, 5.00744730e-02f,
  -4.38523106e-02f, -4.20938209e-02f, 1.46180131e-02f, -5.25575839e-02f, 7.73536367e-03f, 7.15683773e-03f, 5.30885253e-03f, -2.10443474e-02f, 1.05795823e-02f, 2.88721956e-02f,
  8.79595950e-02f, 2.10036367e-01f, 5.44404087e-04f, 3.20187435e-02f, -3.63163464e-02f, -6.85717389e-02f, 2.81927418e-02f, -4.22263937e-03f, 1.35654420e-01f, -5.92066869e-02f,
  -5.50757013e-02f, 9.09026992e-03f, 4.30671722e-02f, 5.20671047e-02f, 1.62471470e-03f, -1.39781097e-02f, 6.96064606e-02f, -4.49609980e-02f, 6.68525603e-03f, 7.77432844e-02f,
  9.13036466e-02f, -7.25954473e-02f, 5.49054369e-02f, -4.54590172e-02f, 7.30376467e-02f, 8.27573892e-03f, 2.00248156e-02f, 7.97768086e-02f, -4.60490137e-02f, 4.60161769e-04f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.62664145e-01f, -1.42261516e-02f, -3.94817488e-03f, 5.70554845e-02f, 8.85181874e-02f, 1.07734799e-02f, 1.23415485e-01f, -1.46251097e-01f, 1.39565945e-01f, 1.01846114e-01f,
  -9.32689011e-02f, 1.31595522e-01f, 8.88383910e-02f, 7.93361943e-03f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  3.15767229e-02f, -1.88993905e-02f, 6.99076876e-02f, 1.60559431e-01f, -2.05847919e-01f, 6.68667853e-02f, -8.66120458e-02f, -6.11287877e-02f, -2.73186445e-01f, 1.86718240e-01f,
  -3.59381318e-01f, -2.81179756e-01f, 2.53720850e-01f, 3.72080177e-01f, -2.58729637e-01f, 1.45299695e-02f, 3.10697377e-01f, 1.76860198e-01f, -3.84595431e-03f, 1.81701124e-01f,
  -1.62881121e-01f, -1.41752809e-01f, -9.71156657e-02f, -3.18060964e-02f, 3.10531706e-02f, -8.18904713e-02f, -5.97317554e-02f, 1.11157909e-01f, -1.11050732e-01f, -1.11141562e-01f,
  -4.54294719e-02f, 9.69170928e-02f, -6.27420396e-02f, 1.02657042e-01f, -1.15092061e-01f, 4.39924709e-02f, 1.21839955e-01f, 7.50370249e-02f, 1.10821761e-01f, 1.57651290e-01f,
  1.13325268e-01f, -1.67569831e-01f, 2.72598088e-01f, -1.36384100e-01f, -5.37929870e-02f, -3.16420227e-01f, 1.90597162e-01f, 2.16422796e-01f, -1.22343466e-01f, 1.13309950e-01f,
  -1.10817313e-01f, -3.19608539e-01f, -7.37344846e-02f, 1.98407769e-02f, 5.66170411e-03f, -1.89109772e-01f, 1.25245422e-01f, -2.74657339e-01f, 1.26384586e-01f, 1.08541481e-01f,
  -1.01468556e-01f, -5.83241507e-02f, -7.03629246e-03f, 2.15527683e-01f, 1.92701414e-01f, 1.77355837e-02f, 5.20904548e-02f, 2.51657963e-01f, -1.43031344e-01f, 5.64022996e-02f,
  3.04147989e-01f, -6.92992732e-02f, 8.32687169e-02f, 1.71956167e-01f, -6.14236183e-02f, -2.25540891e-01f, 6.11449420e-01f, 6.61540627e-02f, 4.80110124e-02f, 1.83583453e-01f,
  3.19588959e-01f, 1.99686468e-01f, 1.53423831e-01f, 1.49554238e-01f, -2.37908170e-01f, -1.51714593e-01f, 4.25143167e-02f, 2.31845304e-01f, 3.46694350e-01f, 2.22921938e-01f,
  -1.82476398e-02f, 1.99666545e-01f, -1.47903606e-01f, 1.82156190e-01f, 4.58555259e-02f, -8.22998360e-02f, 3.82306516e-01f, -6.20237254e-02f, -2.09867805e-02f, 1.02083087e-01f,
  9.09940153e-02f, -7.07367510e-02f, -2.22553536e-01f, 1.87131077e-01f, -1.94405854e-01f, -4.16217655e-01f, 2.32667014e-01f, -7.34141544e-02f, -1.28912495e-03f, -4.45885122e-01f,
  -8.80236924e-02f, 3.72446746e-01f, -3.31894942e-02f, 4.85208593e-02f, -1.81402907e-01f, -1.59225672e-01f, 1.74354136e-01f, 1.65496916e-01f, -8.61545354e-02f, 2.05149412e-01f,
  5.52086681e-02f, -2.43706509e-01f, -2.17158750e-01f, 1.10855460e-01f, -1.18252464e-01f, -1.28541648e-01f, 3.45112495e-02f, -1.14741266e-01f, 4.89786714e-01f, -4.12172638e-03f,
  1.05072491e-01f, 1.77199781e-01f, 2.47677058e-01f, -7.81905875e-02f, -1.77861497e-01f, 1.27568856e-01f, 2.64634490e-01f, -3.51649314e-01f, 4.03881967e-01f, 2.70994216e-01f,
  2.24983364e-01f, -4.79281902e-01f, 3.75280231e-01f, -6.85255229e-02f, -7.90507123e-02f, 3.27886790e-01f, 1.90768838e-01f, -1.86384037e-01f, -4.16713320e-02f, 2.82647368e-02f,
  3.95576768e-02f, -5.12469448e-02f, 2.09590062e-01f, -7.67666325e-02f, -6.45285249e-02f, 1.78305775e-01f, 1.00436792e-01f, 1.67121083e-01f, -1.12327620e-01f, -1.01987697e-01f,
  2.18565166e-02f, -2.84099057e-02f, -1.56401724e-01f, -6.19498380e-02f, -4.48803511e-03f, -3.52762118e-02f, -3.69084477e-02f, -9.64612365e-02f, -1.16080925e-01f, -2.77002249e-02f,
  -1.00311227e-01f, -9.26012173e-02f, -1.43375874e-01f, 1.35382995e-01f, -2.96713114e-01f, 2.94835478e-01f, 1.51993796e-01f, 2.92497069e-01f, -3.14982325e-01f, -6.08109087e-02f,
  -1.37402669e-01f, -2.16769814e-01f, 1.56518072e-01f, 9.55817290e-03f, 1.89635947e-01f, -3.11584234e-01f, -6.74520284e-02f, 2.97010958e-01f, 1.68563083e-01f, 2.29221350e-03f,
  -7.54166022e-02f, 1.63543656e-01f, -1.03832997e-01f, 2.44572852e-02f, 1.20823629e-01f, -5.11016063e-02f, 1.99991584e-01f, -4.34186608e-02f, -1.81014627e-01f, 1.08320557e-01f,
  3.24723482e-01f, -1.91233307e-01f, 1.87352404e-01f, 2.26397380e-01f, -1.60870925e-01f, -7.56072178e-02f, -2.42512912e-01f, -3.45814824e-01f, -5.38779311e-02f, -3.90531868e-01f,
  1.27308607e-01f, 7.40894303e-02f, 1.36197627e-01f, 2.04793438e-01f, -1.05925180e-01f, -5.94732910e-02f, -6.62405370e-03f, 1.57307222e-01f, -1.09442044e-02f, -1.57626748e-01f,
  -1.51264966e-01f, 6.30918965e-02f, 6.90691024e-02f, -1.65534094e-01f, 3.40992659e-01f, -6.57420978e-02f, -1.16388217e-01f, 1.92044303e-01f, 3.17209214e-02f, 1.42746076e-01f,
  3.10252041e-01f, -1.12814821e-01f, 4.98275161e-02f, 1.68640509e-01f, 2.04589412e-01f, -2.95401756e-02f, -8.30761194e-02f, -8.42335895e-02f, 4.85979617e-01f, 1.72420502e-01f,
  4.31301445e-02f, 3.81061941e-01f, -4.51695621e-02f, -1.56208379e-02f, -1.47482693e-01f, -1.95528671e-01f, 7.61689544e-02f, 7.60163441e-02f, 5.00671528e-02f, 2.22691834e-01f,
  1.34287342e-01f, 2.96711951e-01f, -1.82549674e-02f, -6.90473290e-03f, 2.55415410e-01f, 2.79871076e-01f, -1.20554194e-01f, 6.20205095e-03f, -4.20184024e-02f, -5.00265062e-02f,
  2.45262049e-02f, -1.53803984e-02f, 5.78632206e-02f, 1.40165448e-01f, -1.73539311e-01f, -1.05495848e-01f, 2.17139632e-01f, 2.48125985e-01f, -3.55600953e-01f, -6.32637739e-02f,
  -1.18840039e-01f, 5.81573173e-02f, -1.47842869e-01f, 6.17073961e-02f, -1.28886804e-01f, 7.44291842e-02f, 2.43079871e-01f, -1.21884733e-01f, -1.91252455e-02f, -1.82343289e-01f,
  -7.17248246e-02f, -3.72227877e-02f, -1.74993977e-01f, -1.61532372e-01f, 3.29821147e-02f, -2.28680447e-01f, -6.04868978e-02f, 2.25161582e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.78791061e-01f, -4.55868803e-02f, -1.23949023e-02f, -8.28528719e-04f, 3.46412510e-03f, 1.31550908e-01f, -5.84917255e-02f, -1.88603982e-01f, -6.92335740e-02f, 1.88332628e-02f,
  -6.98464736e-02f, 1.01861529e-01f, 1.48140872e-02f, -7.35101551e-02f, -4.82401289e-02f, -8.28919485e-02f, 3.10579017e-02f, -4.45132330e-02f, 9.41008329e-02f, 1.50549158e-01f,
  -3.72889685e-03f, 8.87132883e-02f, -1.77289307e-01f, 1.58639982e-01f, -8.95253271e-02f, 5.48796281e-02f, -9.50253084e-02f, 9.59500447e-02f, 1.61803916e-01f, -7.26561202e-03f,
  -1.12596497e-01f, 9.84867364e-02f, 1.56577602e-01f, -5.43416329e-02f, -1.66788295e-01f, -8.96013621e-03f, -1.09519757e-01f, 1.65368587e-01f, 2.93154959e-02f, 2.42994800e-01f,
  -9.71890911e-02f, -1.19380772e-01f, -7.04818964e-02f, 1.50967211e-01f, -2.93944716e-01f, 4.98109572e-02f, 1.11187465e-01f, -1.52800709e-01f, -2.26500422e-01f, 1.48804009e-01f,
  1.44171536e-01f, -1.98521823e-01f, 6.68952912e-02f, 1.26365945e-01f, 1.06053532e-03f, 5.74189797e-03f, -1.62915140e-01f, -4.95599285e-02f, -1.15973614e-01f, -8.90871957e-02f,
  1.23174772e-01f, -5.27376123e-02f, -4.64530028e-02f, 2.72513926e-01f, 2.91631848e-01f, 9.61462855e-02f, 2.12227345e-01f, 1.36813089e-01f, 9.25506465e-03f, 4.64352936e-01f,
  1.25986710e-01f, -3.35745588e-02f, -9.25371945e-02f, 2.83334590e-02f, -4.31176335e-01f, -4.54006702e-01f, 4.52999383e-01f, -5.68073951e-02f, -1.28131568e-01f, 4.27646846e-01f,
  4.08439964e-01f, -1.37325466e-01f, 6.04371130e-02f, 7.33412728e-02f, -3.23036276e-02f, -2.18598023e-01f, 2.52116192e-02f, 3.10347378e-01f, 1.71138942e-01f, 1.40972957e-01f,
  -3.36707719e-02f, 4.08475518e-01f, -4.85858992e-02f, 1.99069887e-01f, 1.84298411e-01f, 1.00168251e-01f, 1.17148958e-01f, -1.10475279e-01f, -1.67074010e-01f, -1.35567799e-01f,
  -2.32541058e-02f, -1.33582279e-01f, -1.70966581e-01f, 8.51748437e-02f, 6.85616806e-02f, -8.27777609e-02f, 9.65808257e-02f, -1.17742568e-01f, 3.65037546e-02f, 9.74305943e-02f,
  1.11911163e-01f, 8.81052911e-02f, -3.72163169e-02f, 1.25640079e-01f, -9.80909728e-03f, -8.75777900e-02f, 1.94648743e-01f, 1.58579782e-01f, 1.13500260e-01f, -1.59987032e-01f,
  2.77686007e-02f, -7.62757063e-02f, 6.53663129e-02f, 6.66325986e-02f, -9.99853685e-02f, -5.29758558e-02f, 1.66307375e-01f, -1.32585749e-01f, 2.37982705e-01f, 5.30576110e-02f,
  2.49201521e-01f, 4.11364853e-01f, 1.85605839e-01f, 1.46553665e-01f, 4.40044314e-01f, 3.07254106e-01f, 1.98027581e-01f, 1.72231570e-02f, -1.97628871e-01f, -7.04759061e-02f,
  2.98219562e-01f, 1.97828636e-01f, 1.26617193e-01f, 2.83088058e-01f, 4.18120548e-02f, -2.72439290e-02f, -1.27687469e-01f, -2.32066661e-02f, -1.35314763e-01f, 9.15546250e-03f,
  1.69115849e-02f, 1.90600976e-02f, 2.03929782e-01f, -3.08822662e-01f, 1.62202671e-01f, -4.75894995e-02f, -1.28908111e-02f, -5.24258874e-02f, 2.53819406e-01f, 1.47644267e-03f,
  2.31943235e-01f, -1.42495632e-01f, -9.79303345e-02f, 1.60193548e-01f, -9.84832495e-02f, 5.47597967e-02f, -6.79716691e-02f, 5.35942577e-02f, 7.78144747e-02f, 9.87566039e-02f,
  -1.12168647e-01f, 1.70296997e-01f, 2.11478308e-01f, -1.34165157e-02f, -1.56077579e-01f, -1.72809377e-01f, 1.07764132e-01f, 1.68867335e-01f, 1.13145553e-01f, -1.34689808e-01f,
  6.72158003e-02f, -8.18423033e-02f, 2.06149984e-02f, -1.43734142e-01f, 1.44945771e-01f, 1.01107635e-01f, -7.94471651e-02f, -1.01355299e-01f, 1.65112823e-01f, 1.26834124e-01f,
  1.71230167e-01f, -1.46358475e-01f, -6.73258910e-03f, 2.05593202e-02f, 1.42612517e-01f, 1.01451082e-02f, 8.44145715e-02f, 1.58403918e-01f, -1.06568173e-01f, 2.47532412e-01f,
  -6.96427897e-02f, 1.69243455e-01f, -1.69831470e-01f, -2.99252540e-01f, 1.43168837e-01f, 3.87809761e-02f, -1.95775419e-01f, -4.20818292e-02f, -4.99731973e-02f, -2.20835820e-01f,
  -7.31880730e-03f, -2.19108779e-02f, 1.57403518e-02f, -6.79004937e-02f, -1.71504647e-01f, -7.82457814e-02f, -5.04816957e-02f, -5.02801239e-02f, -4.36596833e-02f, -2.00358137e-01f,
  -1.73007146e-01f, -7.77531266e-02f, -8.78994018e-02f, -8.69597867e-02f, -6.64876699e-02f, -1.04686193e-01f, -9.49170217e-02f, 8.66023153e-02f, -3.54023799e-02f, -3.01547330e-02f,
  6.84527978e-02f, -3.76536921e-02f, -7.26079717e-02f, 6.48409352e-02f, -1.83969900e-01f, -1.08218908e-01f, -9.95988399e-02f, 2.33211979e-01f, -9.04780626e-02f, -8.66564959e-02f,
  -2.72655748e-02f, 1.45760149e-01f, 3.84894647e-02f, 1.63077284e-02f, -2.11298987e-02f, -1.40701979e-01f, -3.79882902e-02f, -1.48557797e-01f, -1.40161455e-01f, -1.84638109e-02f,
  -1.38749078e-01f, 9.02166143e-02f, -1.27164483e-01f, 8.95435736e-02f, 3.11037693e-02f, 1.57127250e-03f, 2.61892062e-02f, 3.70370895e-02f, 2.17932343e-01f, -3.68429348e-02f,
  2.34498948e-01f, 4.72670794e-02f, 1.12502046e-01f, 1.63284410e-02f, 3.28217924e-01f, 1.43023664e-02f, 1.12138905e-01f, 4.48652878e-02f, 2.46993586e-01f, -2.36154824e-01f,
  -1.52260706e-01f, -3.83762240e-01f, 2.95542888e-02f, 7.23069832e-02f, 4.95382369e-01f, 7.64441341e-02f, 1.77515790e-01f, 1.15186639e-01f, -1.10923000e-01f, -1.07267156e-01f,
  2.80088872e-01f, 1.78491890e-01f, -2.41261739e-02f, -1.23321101e-01f, 1.05367534e-01f, 1.48659840e-01f, 5.85132046e-03f, -2.16919154e-01f, 3.98654342e-01f, 1.39321685e-01f,
  3.61634731e-01f, 2.29655251e-01f, 2.09480137e-01f, 2.49957427e-01f, -4.80654091e-02f, 2.08465174e-01f, 3.40244859e-01f, -3.94671023e-01f, 2.22777992e-01f, -3.25619340e-01f,
  6.36595845e-01f, -5.24358988e-01f, -3.93656313e-01f, 7.53603429e-02f, -1.07734641e-02f, -3.18871774e-02f, 5.53033292e-01f, 1.48217857e-01f, -1.33412302e-01f, 3.27418089e-01f,
  -1.32365316e-01f, 2.19827816e-01f, 5.01154304e-01f, -6.73999786e-02f, 1.20394137e-02f, 3.72600071e-02f, -1.53776959e-01f, 2.62461156e-01f, -8.69601220e-02f, -1.01983421e-01f,
  -2.12467551e-01f, 1.07015207e-01f, 2.83973336e-01f, 2.80373037e-01f, 6.97396025e-02f, 2.61134982e-01f, 4.70507890e-01f, 9.55415890e-02f, 1.79365069e-01f, -4.71280254e-02f,
  -3.43418956e-01f, 2.17547908e-01f, 1.94710687e-01f, 3.30845237e-01f, 2.94373751e-01f, -1.40930623e-01f, 3.15582216e-01f, -5.06471515e-01f, 3.14802736e-01f, 4.13951457e-01f,
  -2.08798006e-01f, 2.25213200e-01f, 5.20341881e-02f, 3.50725874e-02f, -4.25276533e-02f, 3.92045081e-01f, 5.77186525e-01f, -5.64454794e-02f, -7.92748854e-02f, -1.16428033e-01f,
  -1.52766898e-01f, -1.74552128e-01f, -1.45409346e-01f, 2.36327901e-01f, 1.57536402e-01f, -1.42730713e-01f, 1.55944616e-01f, 1.72033995e-01f, -4.64431532e-02f, 2.91866153e-01f,
  1.59016415e-01f, 4.38803248e-02f, -2.89920151e-01f, -3.61008495e-02f, -2.74503618e-01f, 1.57810181e-01f, -2.33497828e-01f, 2.14750826e-01f, -1.04071638e-02f, -4.51071024e-01f,
  -8.48346949e-02f, -1.63423032e-01f, -1.10789516e-03f, 4.35688533e-02f, -1.79871861e-02f, -2.82973871e-02f, 1.03670852e-02f, 4.09950465e-02f, 3.14754277e-01f, -2.32511088e-01f,
  -1.15041442e-01f, -2.25800499e-01f, -1.22650601e-01f, 5.82175814e-02f, 2.47577980e-01f, 5.14884107e-03f, -9.15053673e-03f, -1.96697131e-01f, -3.71171981e-02f, -7.23385587e-02f,
  -1.67413235e-01f, -1.86065555e-01f, -6.35765269e-02f, -1.05495788e-01f, 9.80438143e-02f, -1.66796833e-01f, 1.81810454e-01f, -2.01444000e-01f, -4.22450230e-02f, 2.76117682e-01f,
  2.41785392e-01f, 1.08117446e-01f, 1.02192201e-01f, -4.27596606e-02f, 4.28747274e-02f, -1.15878813e-01f, 2.00875536e-01f, 1.92798853e-01f, 1.78195909e-01f, -6.89820871e-02f,
  5.88454725e-03f, 3.42675477e-01f, -1.58147633e-01f, -4.91022244e-02f, -1.23236969e-01f, 4.88801636e-02f, 2.47239284e-02f, 1.20696977e-01f, -9.98285934e-02f, -8.56708884e-02f,
  -2.58444417e-02f, -7.08190724e-02f, -1.05690323e-01f, 1.31887823e-01f, 3.60401906e-02f, -6.61439672e-02f, 4.62519489e-02f, -1.04664065e-01f, -1.47651702e-01f, 1.13006957e-01f,
  -1.44898146e-01f, -6.91152513e-02f, -2.52242852e-02f, -1.04512498e-01f, -7.26689100e-02f, 5.38406707e-02f, -5.18817157e-02f, 1.02271616e-01f, -5.37603535e-02f, -1.68066084e-01f,
  8.03012550e-02f, -8.37347507e-02f, -6.19325191e-02f, -3.81978787e-02f, -1.18552640e-01f, -1.65532958e-02f, -1.31245032e-01f, -1.57935202e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -7.83601552e-02f, 6.19629696e-02f, 4.27222788e-01f, 1.30114943e-01f, 1.51401952e-01f, 6.13929071e-02f, 1.40071839e-01f, 6.52541593e-02f, 2.15758383e-01f, 9.55967233e-02f,
  3.30171824e-01f, 2.78166771e-01f, 1.39345765e-01f, 1.08735688e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.73802957e-01f, 1.73388839e-01f, 2.01355070e-01f, -1.76640134e-02f, 3.95209968e-01f, 4.59722150e-03f, -2.15114668e-01f, 7.68936500e-02f, -1.52119463e-02f, -2.56576091e-01f,
  1.68385543e-02f, -3.04715544e-01f, -2.81579733e-01f, -1.91671073e-01f, -2.51779646e-01f, 2.01077208e-01f, -5.36247253e-01f, -4.26484980e-02f, 7.11111759e-04f, -1.16763602e-03f,
  -1.10062510e-01f, 1.39462978e-01f, -2.58376420e-01f, -2.29182571e-01f, 2.49335900e-01f, -1.05950370e-01f, -5.10098673e-02f, 7.10599944e-02f, 2.67008215e-01f, 4.69963372e-01f,
  -8.58017355e-02f, 2.32553333e-01f, 9.84216183e-02f, 2.29038015e-01f, 1.24126755e-01f, 1.48570389e-01f, -2.73066610e-01f, 2.08502710e-01f, -6.58566281e-02f, -1.08682187e-02f,
  1.86279848e-01f, -1.99100062e-01f, 2.81805873e-01f, -3.64405252e-02f, 1.36846259e-01f, 3.77858996e-01f, -7.42972791e-02f, 2.37651497e-01f, -1.68915749e-01f, -4.70814109e-02f,
  7.61596411e-02f, -4.16645259e-02f, -2.38819540e-01f, 1.91033259e-01f, 2.40367628e-03f, 4.52616923e-02f, 1.14776850e-01f, -2.82614138e-02f, 1.70228839e-01f, 4.61149395e-01f,
  -3.84013683e-01f, -6.30525649e-02f, -4.78411578e-02f, -7.34070018e-02f, 2.58673072e-01f, -1.22444583e-02f, -7.91555718e-02f, -6.22378364e-02f, -3.40392619e-01f, -2.22656518e-01f,
  -1.06806576e-01f, 5.80011420e-02f, -2.58574009e-01f, -2.58609414e-01f, -7.47008175e-02f, 2.35207584e-02f, 6.68199137e-02f, 3.56690228e-01f, -1.53077126e-01f, 2.88795650e-01f,
  -2.43331224e-01f, -2.27874592e-01f, -8.89188498e-02f, -1.82940140e-01f, -2.21844643e-01f, -7.69190639e-02f, -2.27673009e-01f, 5.08000851e-02f, 1.74107924e-01f, -8.97258818e-02f,
  3.18602085e-01f, 5.07807970e-01f, -5.89405820e-02f, -1.30512953e-01f, -3.00279595e-02f, 8.50497112e-02f, 2.05966771e-01f, 1.89624265e-01f, 5.42279959e-01f, 2.59587735e-01f,
  1.56564623e-01f, 2.04591855e-01f, 1.12747150e-02f, 2.98984140e-01f, 2.43409589e-01f, -2.00820953e-01f, 2.44746894e-01f, -5.41070886e-02f, 3.35157402e-02f, -1.34267479e-01f,
  1.15820929e-01f, 1.25273421e-01f, 1.25148073e-02f, -8.43116790e-02f, -9.92465839e-02f, -1.65357724e-01f, -2.52777517e-01f, 1.07976027e-01f, 1.65174961e-01f, -1.36471987e-01f,
  6.12240173e-02f, 1.32329792e-01f, -1.46173939e-01f, 1.83265403e-01f, 2.23692562e-02f, 2.96761096e-01f, -2.66739786e-01f, 6.51526079e-02f, -1.66295201e-01f, -1.16068855e-01f,
  -2.72776395e-01f, 9.75441039e-02f, -1.12574220e-01f, -6.15253448e-02f, 1.67491347e-01f, -7.80773312e-02f, 1.83979981e-02f, 3.88537906e-02f, 2.60997564e-01f, 2.94847548e-01f,
  2.77016222e-01f, 1.43283308e-01f, 1.51570603e-01f, -3.76537412e-01f, 4.50757325e-01f, 5.54108582e-02f, -5.09472080e-02f, 2.16975868e-01f, 3.38777453e-01f, 1.15416832e-01f,
  1.68463171e-01f, 3.41732018e-02f, -8.24262109e-03f, -1.47308022e-01f, -2.66207755e-01f, -8.23337585e-02f, -3.92523706e-01f, -1.85256079e-01f, 3.66129316e-02f, -6.64514154e-02f,
  -1.89178899e-01f, 1.60301421e-02f, -5.11703730e-01f, -2.73906350e-01f, 7.30549395e-02f, -2.52493232e-01f, -6.94793463e-02f, -3.28478038e-01f, -2.45302856e-01f, 3.39282900e-01f,
  -8.55005905e-02f, 1.77914098e-01f, -2.57474214e-01f, -2.80052125e-01f, 3.58613759e-01f, -4.00524408e-01f, 3.13422263e-01f, -2.30291799e-01f, -8.46791267e-02f, 1.65674552e-01f,
  1.38576239e-01f, 1.13229360e-02f, -1.87529087e-01f, -5.80969863e-02f, -3.34894098e-02f, 1.72710046e-01f, -1.98520068e-02f, -2.02628523e-02f, -1.85369805e-01f, -1.81398854e-01f,
  2.17553422e-01f, -1.52396962e-01f, 1.70956790e-01f, 1.32481948e-01f, 2.24630818e-01f, 1.77949876e-01f, 1.32748157e-01f, 2.96621770e-01f, 3.63975763e-01f, 1.93259344e-01f,
  -1.04916794e-03f, 2.39284277e-01f, 3.07624787e-01f, 5.12466013e-01f, 1.00542605e-01f, 8.62747431e-02f, -3.42199057e-02f, -1.86939627e-01f, 8.17090943e-02f, -2.46249840e-01f,
  -4.04530391e-02f, -1.91162944e-01f, 7.19976872e-02f, -1.14880547e-01f, 4.40406829e-01f, 1.05631582e-01f, 9.26946923e-02f, -3.78117524e-02f, -2.71389753e-01f, -6.98928684e-02f,
  1.98936716e-01f, 9.10554975e-02f, -2.18445778e-01f, -7.86020607e-02f, 3.29692289e-02f, -2.37948239e-01f, -3.13087344e-01f, 3.65695567e-03f, -4.04893532e-02f, -6.04816414e-02f,
  -1.99876070e-01f, -3.12701344e-01f, -2.41661504e-01f, 2.06349045e-01f, 8.53219721e-03f, 4.68436748e-01f, -2.31675521e-01f, -3.41372162e-01f, 2.96130657e-01f, -3.79332751e-01f,
  -2.64299382e-02f, -2.52019465e-01f, 1.85758099e-01f, -5.18355034e-02f, 2.62764871e-01f, 1.08050145e-01f, 1.70426667e-01f, -4.43552025e-02f, -1.19735427e-01f, 7.34034032e-02f,
  -1.82508096e-01f, 5.63427918e-02f, 2.58796662e-01f, -6.94807395e-02f, 1.71027958e-01f, -1.71078965e-01f, -3.94331366e-02f, 3.18818279e-02f, 4.92183685e-01f, 2.49892712e-01f,
  -3.01921189e-01f, 2.35956311e-01f, -1.00251343e-02f, 7.61001334e-02f, 2.11550996e-01f, -3.61798108e-01f, 3.62407148e-01f, -3.05772722e-01f, 2.47867972e-01f, 1.95883974e-01f,
  -2.19207164e-02f, 5.86078279e-02f, -2.03447249e-02f, 3.99500161e-01f, 8.41835514e-02f, 2.62102008e-01f, -3.60225290e-01f, 1.35928437e-01f, 6.71447441e-02f, 9.00958329e-02f,
  -1.48509875e-01f, -5.99032491e-02f, -5.58773726e-02f, 9.66898873e-02f, -5.50555438e-02f, -1.14086479e-01f, -2.18670145e-01f, 1.28758848e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  5.12001105e-02f, -1.92060508e-02f, -3.82761620e-02f, -1.16740160e-01f, -1.19092681e-01f, -1.58551335e-01f, -1.83077127e-01f, 1.05257258e-01f, -2.05408098e-04f, 8.83500054e-02f,
  1.47895321e-01f, -2.19328746e-01f, 6.30724132e-02f, 1.84523091e-01f, -1.50859028e-01f, 5.92188835e-02f, -2.03504831e-01f, -2.69864919e-04f, 1.14002272e-01f, 3.68909799e-02f,
  -9.65653732e-02f, -1.55931488e-01f, -7.00996220e-02f, -5.06317876e-02f, -3.32013122e-04f, 4.33335267e-02f, 5.21261729e-02f, 1.66846067e-01f, -1.07681505e-01f, 3.14525999e-02f,
  -7.34644756e-02f, -1.61149334e-02f, 1.87808126e-01f, 1.96650714e-01f, 1.67432398e-01f, 2.46352609e-02f, -1.23614177e-01f, 5.53071164e-02f, -7.66542554e-02f, -9.39015895e-02f,
  4.81068809e-03f, -1.61173046e-02f, 6.94806203e-02f, -1.78995475e-01f, -1.56378552e-01f, -2.53892362e-01f, 4.01947536e-02f, 5.35148522e-03f, -3.72503847e-02f, -7.14961290e-02f,
  1.36455357e-01f, 6.51989207e-02f, -6.11039363e-02f, -6.74769729e-02f, 1.34126961e-01f, -1.80546924e-01f, 1.40586972e-01f, 9.46853831e-02f, -6.07983731e-02f, -1.00478940e-01f,
  1.72792733e-01f, 1.36883751e-01f, 7.63203278e-02f, 1.18482187e-01f, 1.35612398e-01f, -2.35146284e-02f, 1.31140083e-01f, 2.50511500e-03f, 3.32905948e-01f, 1.66109614e-02f,
  2.58791417e-01f, 2.49272376e-01f, 1.13868579e-01f, 2.44699925e-01f, 9.17473137e-02f, 3.70565951e-01f, -2.44334772e-01f, -2.45535582e-01f, 1.35830790e-01f, 5.25321215e-02f,
  1.28536075e-01f, 5.60600460e-02f, -2.32392233e-02f, -1.58914268e-01f, 2.62971669e-01f, -8.51721764e-02f, 4.60105032e-01f, -1.13326788e-01f, 2.37359554e-01f, -8.36513713e-02f,
  -2.45996535e-01f, 3.65191475e-02f, 4.60847586e-01f, 4.46305454e-01f, 2.08817255e-02f, 1.58007041e-01f, 3.58529776e-01f, 1.90538004e-01f, -2.13316172e-01f, -2.11289778e-01f,
  -3.15150440e-01f, 1.95909068e-01f, 1.80079341e-01f, -1.18720666e-01f, -1.49095133e-01f, 2.09381152e-02f, 1.64463073e-01f, 4.54643965e-01f, 5.14940798e-01f, 5.72925746e-01f,
  9.75215286e-02f, -7.84369558e-02f, -2.39949793e-01f, -3.73119190e-02f, -1.27046883e-01f, -1.60756573e-01f, 4.68380570e-01f, -5.90375029e-02f, 1.27388760e-01f, 1.65113807e-01f,
  8.31475854e-02f, -1.70514375e-01f, 1.77415565e-01f, 9.92596507e-01f, -4.31251436e-01f, -1.50581107e-01f, 3.57216179e-01f, -4.13427539e-02f, -1.13704458e-01f, -9.77533981e-02f,
  -3.21677685e-01f, -8.51129070e-02f, -8.82283002e-02f, -1.98354170e-01f, 2.16592938e-01f, 1.62226826e-01f, 1.20010898e-01f, -9.78598744e-03f, -1.37057766e-01f, 3.05851161e-01f,
  -3.27460378e-01f, 2.23861322e-01f, -2.59832650e-01f, 3.66711691e-02f, 3.74876529e-01f, -3.28265399e-01f, 1.09534748e-01f, -2.06587419e-01f, 2.24022120e-01f, 6.01169951e-02f,
  1.74653217e-01f, -1.02474377e-01f, -1.17358990e-01f, -1.27654806e-01f, 1.31875888e-01f, 2.18906030e-01f, 5.71655989e-01f, -1.81844264e-01f, -9.66511725e-04f, -1.16326861e-01f,
  -1.67370036e-01f, 1.03159659e-02f, -4.31211945e-03f, 1.42138645e-01f, 1.18130215e-01f, 3.09980005e-01f, 2.91919827e-01f, 1.42694935e-01f, 2.08254710e-01f, -2.66251504e-01f,
  2.73272008e-01f, 1.27366737e-01f, 3.06809872e-01f, 2.75708169e-01f, -2.22678140e-01f, -5.02604693e-02f, 3.32668424e-01f, -1.18388750e-01f, 6.24199659e-02f, 9.89898574e-03f,
  1.45195425e-01f, 1.29757091e-01f, 3.50129604e-01f, -1.70398518e-01f, -1.53263047e-01f, -1.07730485e-01f, -3.74306808e-04f, -1.54382393e-01f, 9.21652019e-02f, -9.88429338e-02f,
  -2.08855331e-01f, -2.06006154e-01f, 8.88258517e-02f, 1.90694243e-01f, -3.03814799e-01f, 1.11649983e-01f, -2.54798830e-01f, 5.68634346e-02f, -2.28145376e-01f, -2.78825909e-02f,
  -1.12003624e-01f, 1.34930480e-02f, -1.07987329e-01f, 3.05646081e-02f, -7.39254057e-02f, 1.51977912e-02f, 1.41037896e-01f, -1.13444760e-01f, -1.67596098e-02f, -4.11317386e-02f,
  6.55396506e-02f, -3.11920960e-02f, 6.16828762e-02f, -1.23142429e-01f, 2.43667051e-01f, 1.55915931e-01f, -8.73687714e-02f, 6.95817247e-02f, 7.67140165e-02f, 4.37651634e-01f,
  1.18199866e-02f, -3.42005700e-01f, -9.30806547e-02f, -1.51039809e-01f, -1.12924613e-01f, 4.04520780e-02f, -8.66412520e-02f, 1.02441937e-01f, -8.70303735e-02f, -1.01835348e-01f,
  1.10789314e-01f, 2.16642767e-01f, 1.22683443e-01f, 2.42195010e-01f, -4.33906585e-01f, 6.43072128e-01f, -2.03423068e-01f, -1.91931754e-01f, -2.51724273e-01f, -4.66801822e-02f,
  1.78121299e-01f, -2.89094627e-01f, 1.07804179e-01f, -1.48867339e-01f, 3.77093881e-01f, -1.60346702e-01f, 8.72039273e-02f, 1.79577351e-01f, 1.76686361e-01f, -4.31919135e-02f,
  2.72159368e-01f, 2.62060344e-01f, 7.14100957e-01f, -1.87635258e-01f, -3.04200321e-01f, 1.38538688e-01f, 1.45199701e-01f, 7.40442649e-02f, -1.73423856e-01f, 3.24475676e-01f,
  -4.36691642e-01f, 7.92881101e-02f, 2.40503594e-01f, 8.03072657e-03f, 1.16299413e-01f, -3.90661776e-01f, 2.08098337e-01f, 1.05680432e-02f, 2.59502709e-01f, 8.83130908e-01f,
  -2.74091631e-01f, 7.22665563e-02f, 2.70834178e-01f, -2.13433579e-02f, -1.26331255e-01f, -8.91840085e-02f, -8.34813528e-03f, 1.07724387e-02f, 8.02307352e-02f, -8.47150907e-02f,
  -3.00289690e-01f, -1.37100443e-01f, 3.20890248e-01f, 4.77641463e-01f, 1.08703777e-01f, -1.13194771e-01f, 1.91110611e-01f, 5.45351319e-02f, 3.75098586e-02f, -1.66336209e-01f,
  -1.07099473e-01f, 1.06061742e-01f, -8.14507827e-02f, 5.59935234e-02f, -2.96552032e-02f, -1.69023454e-01f, 1.22398920e-01f, -1.25088826e-01f, 1.63104832e-01f, 1.88922673e-01f,
  4.25471552e-02f, -9.16001499e-02f, -4.93969619e-02f, -6.58552051e-02f, -6.91296682e-02f, -1.71977207e-01f, -1.74152479e-01f, 7.07286522e-02f, -7.09649175e-02f, 1.24817580e-01f,
  -7.78957829e-02f, 1.80089811e-03f, 9.77202803e-02f, -1.44277811e-01f, -2.49828920e-02f, 1.09591439e-01f, -2.18268670e-03f, -6.24411143e-02f, 1.05119169e-01f, 1.28223598e-01f,
  3.13956589e-01f, 3.00254047e-01f, -1.33920833e-01f, 1.24921344e-01f, 3.42958897e-01f, 4.06366169e-01f, 3.08228433e-01f, -9.88360569e-02f, 2.27596477e-01f, 5.36054969e-01f,
  2.59220928e-01f, 4.16186929e-01f, 4.45661098e-01f, 9.61478353e-02f, 5.97280025e-01f, -6.22327745e-01f, 3.97393763e-01f, 1.90275297e-01f, -6.79601878e-02f, 2.01253042e-01f,
  8.23666334e-01f, -7.38478974e-02f, 1.90597564e-01f, -1.54516593e-01f, -1.54793411e-02f, -2.93598901e-02f, -3.56069893e-01f, 1.87081039e-01f, -5.35264194e-01f, -1.31150469e-01f,
  1.97647214e-01f, -1.54998586e-01f, -8.75627324e-02f, 3.14680725e-01f, 1.07780673e-01f, 2.44362593e-01f, 2.82205909e-01f, -9.37881023e-02f, -9.81568918e-02f, 3.14206809e-01f,
  2.32536897e-01f, -3.59753340e-01f, 1.06985420e-01f, -1.68334961e-01f, 4.77964073e-01f, 6.19188607e-01f, -1.63266808e-01f, 4.01810616e-01f, 1.13672890e-01f, 2.17137203e-01f,
  -2.49583088e-02f, 1.63060218e-01f, 5.36836348e-02f, 2.01397449e-01f, 5.73632009e-02f, -7.81596601e-02f, -1.94681928e-01f, -1.53622180e-01f, -1.43186934e-02f, 1.89023688e-01f,
  1.12098649e-01f, 3.36861750e-03f, 2.21568961e-02f, 6.68197498e-03f, 2.39382740e-02f, 4.02068580e-03f, 9.99430940e-02f, -3.97958681e-02f, 1.30268231e-01f, -1.77654952e-01f,
  3.05824950e-02f, 8.11695009e-02f, -1.20200552e-01f, -9.75109488e-02f, -6.39628768e-02f, -9.01953354e-02f, 1.01815075e-01f, 8.80184525e-04f, 1.45443171e-01f, -1.16625778e-01f,
  -2.55408641e-02f, -1.14817366e-01f, -8.20994899e-02f, -1.55531675e-01f, 1.98540837e-01f, 1.18075877e-01f, -1.46436796e-01f, -4.84622903e-02f, 1.32320553e-01f, -4.67162160e-03f,
  -1.31475434e-01f, -9.33571085e-02f, -1.67271614e-01f, -1.57656297e-01f, 1.69006735e-01f, 5.92954196e-02f, 1.08552501e-01f, -9.59008858e-02f, -1.71171263e-01f, -4.95445132e-02f,
  2.58637100e-01f, -1.97999895e-01f, -2.09610254e-01f, 1.75858691e-01f, 1.69274509e-01f, 2.96281815e-01f, -2.89668828e-01f, 3.90457213e-01f, 1.56854406e-01f, 1.91290826e-01f,
  -6.43445104e-02f, 1.65026724e-01f, -3.46633852e-01f, -2.36033902e-01f, 5.35291880e-02f, -1.44005671e-01f, 4.40958411e-01f, -8.14920142e-02f, 1.49061680e-01f, 5.09858429e-02f,
  1.75515056e-01f, 3.65795977e-02f, 4.12764460e-01f, 5.70917070e-01f, 3.45676214e-01f, -1.15490258e-01f, -1.22366138e-01f, 1.04910560e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -7.89688975e-02f, 8.27286243e-02f, 1.93812802e-01f, 2.18647048e-01f, 3.17883901e-02f, 7.19824433e-02f, -1.25265466e-02f, -5.04246987e-02f, 2.15860307e-01f, -1.35411561e-01f,
  3.11755329e-01f, 6.36286288e-02f, -1.58799529e-01f, -1.07665747e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  2.10555613e-01f, -4.69183326e-02f, 5.21375954e-01f, -1.79883868e-01f, 3.11793685e-01f, 2.43566647e-01f, -2.17210934e-01f, 3.07273537e-01f, -1.02575431e-02f, 4.44323868e-01f,
  1.76407993e-01f, 1.32045165e-01f, 1.09403424e-01f, 1.91070229e-01f, -4.18523073e-01f, -3.28043282e-01f, 3.79273683e-01f, -5.48991680e-01f, 6.60640979e-03f, -4.55413982e-02f,
  1.75759792e-01f, 5.65140605e-01f, -2.33025789e-01f, 6.29764199e-02f, -2.32265219e-01f, -3.51172313e-02f, -3.82332951e-01f, -1.04980446e-01f, 4.18174416e-01f, 1.00738771e-01f,
  1.26390681e-01f, 4.71960694e-01f, 1.69370770e-01f, 4.63122912e-02f, -2.91779060e-02f, -2.22190600e-02f, 3.04472983e-01f, 4.34179790e-02f, -3.49235684e-01f, 4.11139667e-01f,
  2.27582335e-01f, 3.43150198e-01f, -4.94790226e-01f, -7.03015566e-01f, -6.71232790e-02f, -4.78606284e-01f, -4.17501241e-01f, -3.66624221e-02f, 4.31065410e-01f, -6.11255765e-01f,
  1.33979589e-01f, 1.08693860e-01f, 4.74514246e-01f, -6.03469729e-01f, 2.13071182e-01f, 5.87643171e-03f, -1.80284575e-01f, 7.59631217e-01f, -6.87837183e-01f, 1.80023797e-02f,
  -2.07397401e-01f, -2.37014696e-01f, -1.73290983e-01f, 1.53493851e-01f, -4.12334830e-01f, 5.21152198e-01f, 6.81507826e-01f, -2.87978142e-01f, -5.20092189e-01f, -2.55375564e-01f,
  6.43293977e-01f, 3.29893172e-01f, 6.23339236e-01f, 4.44070190e-01f, -5.70019148e-03f, -3.86708170e-01f, 6.70214236e-01f, -5.95541656e-01f, -5.89035749e-01f, 3.64165962e-01f,
  -6.90675437e-01f, 7.51125962e-02f, 9.33080260e-03f, 3.63437980e-01f, 3.09877485e-01f, -4.59634662e-01f, -2.64393002e-01f, -3.23682547e-01f, -2.38335773e-01f, -1.95467144e-01f,
  -5.50616026e-01f, -7.68803582e-02f, -3.94513875e-01f, -2.44742140e-01f, 8.46507251e-02f, -3.33506614e-01f, -3.71059746e-01f, -3.82395796e-02f, 1.92294136e-01f, -6.97599128e-02f,
  -2.76503146e-01f, 2.48784795e-01f, 2.56980449e-01f, -3.82804155e-01f, -2.09944502e-01f, -2.22278759e-01f, 2.02774376e-01f, 1.54874280e-01f, -7.22092450e-01f, 3.30169886e-01f,
  7.36765862e-01f, -4.81579192e-02f, 4.54861164e-01f, -2.84712166e-01f, 1.82192355e-01f, 1.40498251e-01f, -3.72017682e-01f, 6.85023248e-01f, 1.07668802e-01f, -1.50855690e-01f,
  2.12396368e-01f, -4.23232555e-01f, 3.13266605e-01f, 6.19348623e-02f, 4.84855682e-01f, -6.92495853e-02f, 2.34880134e-01f, 1.12115256e-02f, 2.30732068e-01f, -7.58624017e-01f,
  -6.10251844e-01f, 1.12595186e-01f, 2.73560524e-01f, 1.17557019e-01f, -1.16623290e-01f, 3.74626398e-01f, 4.18680191e-01f, -4.11843359e-01f, 1.55943930e-01f, 3.96020383e-01f,
  -2.24431641e-02f, 1.20691478e-01f, -1.68807089e-01f, 1.81534752e-01f, 1.61685988e-01f, 1.14670455e-01f, -9.81805772e-02f, 1.09291174e-01f, -2.24160656e-01f, 5.62436938e-01f,
  3.28339934e-01f, 1.02382161e-01f, 3.66224408e-01f, 2.51637548e-01f, 4.04622525e-01f, 1.63767010e-01f, -3.97964388e-01f, -3.38138819e-01f, 1.16167575e-01f, 1.36898994e-01f,
  4.35528196e-02f, 2.03881368e-01f, 4.39404011e-01f, -4.96996671e-01f, -2.21151579e-02f, -3.35473120e-01f, -8.13294053e-01f, 4.06287551e-01f, 2.05040380e-01f, 3.21929306e-01f,
  2.15867698e-01f, 1.61180541e-01f, 3.38370651e-02f, -2.19529748e-01f, 1.65111855e-01f, 3.15389544e-01f, -7.78239667e-02f, 2.75180548e-01f, -1.35451585e-01f, 7.84031972e-02f,
  2.61878848e-01f, -2.35674307e-01f, 5.36538303e-01f, 3.79651904e-01f, -1.31701529e-01f, 2.82087401e-02f, 4.49681908e-01f, -6.78900443e-03f, -6.20879769e-01f, 3.00507218e-01f,
  -1.24192322e-02f, -9.41412598e-02f, 1.89781219e-01f, -6.29169075e-03f, 4.69981968e-01f, 1.41474277e-01f, 5.26959598e-01f, -4.48064774e-01f, 6.54042482e-01f, -5.94933748e-01f,
  -1.41828984e-01f, 2.45747060e-01f, 4.95709836e-01f, 2.61635721e-01f, 3.44125777e-01f, -1.91480041e-01f, -2.95604646e-01f, -2.77889911e-02f, -4.12493765e-01f, 6.07507110e-01f,
  -3.04110814e-02f, 6.04243651e-02f, -4.98803586e-01f, -6.19598746e-01f, -1.25887478e-02f, 3.62546206e-01f, -2.67107636e-01f, -4.79734570e-01f, 4.43251997e-01f, -6.58762455e-02f,
  -5.84187150e-01f, 7.84272969e-01f, -1.79499954e-01f, -5.08779287e-01f, -1.79055989e-01f, 1.14751942e-01f, -1.81317795e-02f, 2.86765933e-01f, -4.69701052e-01f, 2.07926169e-01f,
  2.73754954e-01f, -2.69075539e-02f, -6.58523142e-01f, 1.83862180e-01f, -2.39983484e-01f, 3.33410293e-01f, -6.36675715e-01f, -4.45559062e-02f, 4.90435176e-02f, -1.08374536e-01f,
  2.88950861e-01f, -4.60540593e-01f, -1.35277599e-01f, -1.93574131e-01f, -1.12108938e-01f, -4.71989736e-02f, 6.45226896e-01f, -2.79976815e-01f, 1.23432269e-02f, 5.90463579e-01f,
  3.33397239e-02f, -9.47635919e-02f, -6.24378622e-01f, -1.51795208e-01f, 1.79528043e-01f, 4.77993935e-01f, 3.47303361e-01f, 4.66163397e-01f, -5.15970170e-01f, -9.22741443e-02f,
  3.75947982e-01f, 5.68938494e-01f, 1.33791074e-01f, 4.43875045e-01f, 4.10561591e-01f, 4.19976376e-02f, -3.10644746e-01f, -7.66313732e-01f, 2.98079729e-01f, 5.93034387e-01f,
  1.98515952e-01f, 4.68065858e-01f, 2.90834695e-01f, 3.87956023e-01f, -1.48678003e-02f, 2.28131056e-01f, 1.85275003e-01f, -5.76817453e-01f, -3.63994777e-01f, -3.94387916e-02f,
  -1.58802122e-01f, -4.15871412e-01f, -3.70653540e-01f, 4.32364717e-02f, 8.49364102e-01f, -1.97083592e-01f, -5.48366010e-02f, -3.75444621e-01f, -4.20587987e-01f, -4.28908706e-01f,
  -5.49987972e-01f, -1.27750069e-01f, -7.28238165e-01f, -4.34636235e-01f, 5.59930921e-01f, -1.65144414e-01f, -4.13447879e-02f, 4.30199295e-01f, 2.64523089e-01f, 6.57747924e-01f,
  3.64237279e-02f, -3.92723948e-01f, 1.05024241e-01f, -2.56345481e-01f, -4.70052361e-01f, 4.41876709e-01f, 2.02879325e-01f, -8.89461413e-02f, -4.89640832e-01f, 3.06312710e-01f,
  -1.56664923e-01f, -3.73617351e-01f, 1.23752855e-01f, 4.39406671e-02f, 2.34979168e-01f, -4.25011180e-02f, -4.56482142e-01f, 4.29836124e-01f, 1.83762740e-02f, 5.35084903e-01f,
  -2.20530882e-01f, -1.67997658e-01f, -4.31323081e-01f, 1.70241922e-01f, 2.77779549e-02f, 2.12674946e-01f, -3.15543234e-01f, -3.58314723e-01f, -3.87239188e-01f, -4.71030772e-01f,
  -4.16700602e-01f, -5.48379421e-01f, -3.63006264e-01f, 4.94734704e-01f, 7.58501947e-01f, 4.53566797e-02f, 3.67266834e-01f, -5.88496804e-01f, -2.53840280e-03f, 5.96233532e-02f,
  7.89631456e-02f, -1.71834290e-01f, 1.80739403e-01f, 1.97365642e-01f, 2.66062975e-01f, 2.97127008e-01f, -3.56876254e-01f, 3.75774577e-02f, 6.37437880e-01f, -2.67387033e-01f,
  -1.32917315e-01f, 1.73251450e-01f, 1.68354809e-01f, -1.75826207e-01f, 4.11442995e-01f, -1.12732075e-01f, 3.18138689e-01f, -6.61652982e-02f, -1.26421139e-01f, 2.78098494e-01f,
  -2.61767358e-01f, -7.91704476e-01f, 1.82289675e-01f, 1.25393823e-01f, 3.17865461e-01f, 6.42861605e-01f, -4.54350978e-01f, 5.77010326e-02f, -4.26299989e-01f, 6.04331672e-01f,
  -1.40851382e-02f, -2.28367209e-01f, -2.58536816e-01f, 5.79294503e-01f, -4.24884081e-01f, 3.60926777e-01f, -1.07952274e-01f, -4.55449700e-01f, 2.57659048e-01f, -6.32922277e-02f,
  5.36380112e-01f, 2.29978815e-01f, 7.15877395e-03f, -4.47006166e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.31915379e-01f, 9.88575444e-02f, 4.54430282e-01f, -2.94779807e-01f, -2.45388895e-01f, 3.84873860e-02f, 1.06503025e-01f, -2.77428389e-01f, 1.51583374e-01f, 1.84564620e-01f,
  -1.32707581e-01f, 3.41663063e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    