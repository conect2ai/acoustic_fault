/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.32790923e-01f, -2.96697803e-02f, 1.25787184e-01f, 9.78626311e-03f, -1.55492991e-01f, 8.16346109e-02f, 1.54849142e-01f, 1.10684045e-01f, 1.01269195e-02f, 1.64041948e-02f,
  4.10268754e-02f, -5.11610806e-02f, 1.29372820e-01f, 6.90673441e-02f, 3.76202881e-01f, 2.61383712e-01f, 1.36134982e-01f, 3.99741471e-01f, 1.77628562e-01f, -1.12156719e-01f,
  -2.06640065e-01f, -8.57699588e-02f, -8.59800577e-02f, 2.58923005e-02f, -1.87535822e-01f, -4.56854254e-02f, -2.02587530e-01f, -2.75940239e-01f, -1.69691816e-02f, -1.09603442e-01f,
  -9.18511078e-02f, 1.48825973e-01f, 1.42126665e-01f, 6.11311831e-02f, 1.31905144e-02f, 5.36024161e-02f, 4.96495813e-02f, 4.35984768e-02f, 2.02853531e-02f, -2.98119169e-02f,
  -4.30272110e-02f, 2.90443674e-02f, 1.15014486e-01f, -1.23979077e-01f, -5.32471351e-02f, 2.71657370e-02f, -3.04053798e-02f, 6.52139410e-02f, 7.20044896e-02f, -6.03385121e-02f,
  5.42956032e-03f, -8.86196923e-03f, 2.60634366e-02f, 7.92992041e-02f, 4.26827967e-02f, 1.57338828e-01f, -7.99528807e-02f, -1.20376516e-02f, 3.12998220e-02f, -5.71398027e-02f,
  5.04539981e-02f, -2.74769384e-02f, -2.82982625e-02f, -2.41257027e-02f, -5.31951431e-04f, -1.47760566e-02f, 4.62257303e-02f, -4.97122295e-02f, -3.94514389e-03f, 4.20458391e-02f,
  7.04015270e-02f, 6.30668029e-02f, -2.91639660e-02f, 8.59287530e-02f, -6.10622577e-02f, -3.65119167e-02f, 6.51014596e-02f, 8.07781890e-03f, -6.64885119e-02f, 1.50555456e-02f,
  2.79019913e-03f, -4.50663222e-03f, 8.89741757e-04f, -4.33269590e-02f, 6.75593764e-02f, 5.09923697e-02f, 5.61311655e-02f, 3.77382501e-03f, -4.18114774e-02f, 1.58709357e-03f,
  -1.44463301e-01f, 2.77948707e-01f, 1.49560431e-02f, -6.50864244e-02f, 1.65543035e-02f, -2.79915836e-02f, -8.21702648e-03f, -1.86726544e-02f, -3.46793584e-03f, 1.90997366e-02f,
  -1.43315992e-03f, -7.79326120e-03f, 5.49517646e-02f, -8.99723247e-02f, 8.61725286e-02f, -3.64476666e-02f, -3.00195329e-02f, -8.47900435e-02f, 1.12690590e-01f, -1.66354731e-01f,
  1.63247567e-02f, 4.68560541e-03f, 4.82906960e-02f, 1.06585091e-02f, 6.41345382e-02f, 5.67612685e-02f, 7.62675777e-02f, -7.25211017e-03f, 1.42831862e-01f, -9.41321626e-03f,
  3.70983258e-02f, -2.84762174e-01f, -2.35221721e-02f, -1.65987670e-01f, -5.53795248e-02f, 1.35827512e-01f, -1.28890827e-01f, 1.01482440e-02f, 3.69369164e-02f, -5.32840341e-02f,
  8.42374787e-02f, 1.55961245e-01f, 1.13541536e-01f, 1.01015151e-01f, -3.58317699e-03f, -1.50671810e-01f, -2.74078280e-01f, 4.32446264e-02f, 1.10170476e-01f, 1.24469571e-01f,
  -6.49349838e-02f, -2.32292190e-01f, -1.30233958e-01f, 2.48790160e-02f, -2.35271305e-02f, 9.07774121e-02f, 5.39177246e-02f, -6.67899996e-02f, 9.65938624e-03f, -2.37034246e-01f,
  2.11379066e-01f, -1.52431792e-02f, -3.21496874e-02f, -4.70511578e-02f, -1.15518823e-01f, 2.48328922e-03f, 4.62596603e-02f, -1.18016221e-01f, -1.72869936e-02f, -6.74520731e-02f,
  -8.42821822e-02f, -7.01931119e-02f, -1.33301914e-01f, -8.54244009e-02f, -1.11158937e-01f, -7.48958811e-03f, -8.14827979e-02f, -7.29259625e-02f, 4.61341627e-02f, 7.92457536e-02f,
  -9.39005837e-02f, -9.55273882e-02f, -6.69612586e-02f, -1.32836970e-02f, 1.01634553e-02f, -1.10804141e-01f, -1.20735779e-01f, -5.07282987e-02f, -3.90278287e-02f, -4.67929728e-02f,
  1.84415355e-01f, -9.07574501e-03f, 9.53226537e-02f, 5.51378839e-02f, 1.26599342e-01f, 1.08560689e-01f, 1.30172476e-01f, 8.90758261e-02f, -5.13816625e-03f, 7.07475916e-02f,
  1.47749096e-01f, 1.10187240e-01f, 1.59770384e-01f, 1.06783688e-01f, 4.63124365e-02f, 1.55746639e-01f, 1.44939780e-01f, 7.07813352e-02f, 5.86172938e-02f, 1.64728478e-01f,
  4.07237187e-02f, 1.14641301e-01f, 1.64367810e-01f, 9.32314172e-02f, 7.58253187e-02f, 1.31941929e-01f, 1.00870088e-01f, 1.42146140e-01f, -4.02316265e-03f, 7.17669949e-02f,
  1.76517256e-02f, 1.17034659e-01f, 9.19279829e-02f, -2.86478437e-02f, 2.15088893e-02f, -2.09778734e-02f, -8.01289305e-02f, -2.85241604e-02f, -1.74675509e-01f, -7.45233074e-02f,
  2.63925996e-02f, -4.85119633e-02f, 9.31976736e-03f, -1.05442412e-01f, -2.91321781e-02f, -1.06143944e-01f, -1.05295718e-01f, -8.62532109e-03f, 4.62599881e-02f, -7.63980746e-02f,
  -6.41806647e-02f, -6.27394542e-02f, 1.05963819e-01f, -5.70946606e-03f, 3.75908352e-02f, -6.41874503e-04f, 7.21664727e-02f, 3.59303802e-02f, -1.14304721e-02f, 9.50209200e-02f,
  -1.87831193e-01f, 3.42450798e-01f, 5.93903940e-03f, -1.57647654e-01f, 1.44090295e-01f, 1.24774165e-01f, 2.14450434e-01f, 9.22178663e-03f, -5.05415834e-02f, 2.54925966e-01f,
  2.87303090e-01f, 8.33155289e-02f, 2.09558289e-02f, -1.22195119e-02f, -1.02261286e-02f, -6.85744286e-02f, -1.46447897e-01f, -3.36347699e-01f, -1.05864674e-01f, 1.82367176e-01f,
  1.76623166e-01f, -1.07430175e-01f, -1.92206606e-01f, -1.99927446e-02f, 8.52220517e-04f, 9.62018073e-02f, 1.17175110e-01f, -7.63511807e-02f, 2.18909428e-01f, -2.57901073e-01f,
  6.79016486e-02f, 2.67550766e-01f, 1.17168665e-01f, 1.01727284e-01f, 2.93807328e-01f, 6.92463592e-02f, 2.17548788e-01f, 8.38170722e-02f, 1.61279261e-01f, 1.41863361e-01f,
  4.56460081e-02f, 1.77362949e-01f, 1.34418169e-02f, 1.49012640e-01f, 9.49601904e-02f, 1.22527629e-01f, -4.59418632e-03f, -3.52020818e-03f, 7.27806985e-02f, 2.79145211e-01f,
  9.70438495e-02f, 7.39845932e-02f, 4.95531969e-02f, 1.08220860e-01f, 3.25447135e-02f, 9.14737061e-02f, 1.23884626e-01f, 5.66047654e-02f, 6.70414418e-02f, 2.05704734e-01f,
  -6.52766079e-02f, -7.21407607e-02f, -6.01492897e-02f, -8.96164626e-02f, -4.37745899e-02f, 1.99902188e-02f, -6.44730404e-02f, -1.85834970e-02f, 4.46078219e-02f, -1.65018775e-02f,
  3.87714244e-02f, -9.49192420e-03f, 1.47203533e-02f, -3.07248477e-02f, 1.77952237e-02f, -4.80228961e-02f, 9.67555586e-03f, -2.61558034e-02f, 4.89281006e-02f, -1.95336211e-02f,
  -3.89701314e-02f, -6.53426275e-02f, -2.30961833e-02f, -3.96582251e-03f, -4.23718467e-02f, -1.24358281e-01f, -4.71709222e-02f, -4.61804122e-02f, 4.44257259e-03f, -7.64435232e-02f,
  1.16500363e-01f, 9.95129943e-02f, 1.22225627e-01f, 1.36698142e-01f, 1.01960331e-01f, 1.67990535e-01f, 7.94838592e-02f, 1.63105428e-01f, 4.15721089e-02f, 5.03398292e-02f,
  1.75993040e-01f, 1.78793333e-02f, 5.82066476e-02f, -7.09625613e-03f, 1.71718374e-01f, 5.12606092e-02f, 1.62314996e-01f, 4.80460860e-02f, 9.26924944e-02f, 8.85555819e-02f,
  5.12385517e-02f, 1.30456671e-01f, 1.33860633e-01f, 1.68223873e-01f, 1.10264219e-01f, 1.32308349e-01f, 1.98644400e-01f, 9.69347432e-02f, 1.52114987e-01f, 3.13299865e-01f,
  -8.60964805e-02f, 1.09118983e-01f, 1.60975710e-01f, -1.34655610e-01f, 8.42555761e-02f, 3.57086509e-01f, 2.85908371e-01f, 1.88084781e-01f, -8.56032521e-02f, -4.51705568e-02f,
  3.24458294e-02f, 2.21340433e-02f, -6.85838424e-03f, 7.36504868e-02f, 1.81849167e-01f, 1.75846845e-01f, 6.51729256e-02f, 3.65766846e-02f, 3.39407772e-01f, 2.46738046e-01f,
  1.40616028e-02f, 7.56541714e-02f, -6.37770072e-02f, 1.56729296e-01f, 7.48551935e-02f, 1.04908563e-01f, -4.34907936e-02f, -8.35289434e-02f, 8.00112933e-02f, 3.87611240e-03f,
  3.04965794e-01f, 1.47900984e-01f, 1.27794281e-01f, -1.07497675e-03f, -8.07575136e-02f, 3.66885262e-03f, 1.01743311e-01f, 2.31473390e-02f, -1.67343579e-02f, 7.43185654e-02f,
  7.25907311e-02f, -1.12074567e-02f, -1.11436332e-02f, 6.45183697e-02f, 9.09198597e-02f, 1.28034905e-01f, -2.37880461e-03f, 1.22877836e-01f, 5.75272702e-02f, 7.66464695e-02f,
  6.19035326e-02f, 7.69784823e-02f, 5.28406985e-02f, 2.07450427e-02f, 1.72928914e-01f, 6.47807028e-03f, 1.65779680e-01f, 7.84892961e-02f, 1.07296064e-01f, 6.11101501e-02f,
  -1.52782276e-01f, -1.00653261e-01f, 6.21529818e-02f, -4.40344289e-02f, -9.70092416e-02f, -6.41250014e-02f, -2.59736516e-02f, -1.92204509e-02f, 7.62479007e-02f, -2.64909230e-02f,
  3.75332520e-03f, 2.56685703e-03f, -2.49405093e-02f, 2.58608814e-02f, 7.36365654e-03f, 4.80417870e-02f, 6.61492720e-02f, 3.50742713e-02f, -2.11447123e-02f, -7.66686257e-03f,
  8.65003392e-02f, 3.12716514e-02f, -3.33708674e-02f, 5.63525185e-02f, 2.26519443e-02f, -6.00310974e-03f, -9.18100774e-03f, -1.69154443e-02f, -6.82357475e-02f, 2.62390386e-04f,
  8.97024386e-03f, 1.69136584e-01f, 3.40004414e-02f, 1.70917884e-01f, 3.16789970e-02f, 6.54479861e-02f, -5.48059680e-03f, 7.39520267e-02f, -4.49424749e-03f, 1.54461682e-01f,
  1.64419994e-01f, 1.40799493e-01f, -1.97674502e-02f, 7.86451921e-02f, 3.05480249e-02f, 3.00611574e-02f, -2.05545910e-02f, 9.27868858e-02f, -5.61336929e-04f, -3.99624445e-02f,
  -2.01545954e-02f, 5.34767099e-03f, 9.46279708e-03f, 1.58494160e-01f, 3.22169065e-02f, 8.19702446e-02f, 1.25167295e-01f, 1.37475476e-01f, 2.51920283e-01f, 1.03150524e-01f,
  -2.78390497e-01f, -3.69865596e-01f, 2.05007240e-01f, -7.05246702e-02f, -3.98678221e-02f, 3.67543437e-02f, -3.07887465e-01f, 8.21172725e-03f, 7.32203992e-03f, -6.69925064e-02f,
  3.63009833e-02f, 1.77156508e-01f, 2.62604833e-01f, 1.90194905e-01f, 3.89632955e-02f, -1.55360371e-01f, -2.17189088e-01f, -3.68297137e-02f, 2.78043747e-01f, 1.58085581e-02f,
  -1.65598094e-01f, -1.74677953e-01f, -1.27181306e-01f, 8.93317163e-02f, -1.27542749e-01f, 1.62072361e-01f, 2.76397336e-02f, -1.84018552e-01f, -2.35084742e-02f, -3.17812592e-01f,
  1.49867490e-01f, -1.31354988e-01f, 5.81333339e-02f, -2.13631932e-02f, 3.61331590e-02f, 3.66282277e-02f, -4.73812595e-02f, 8.32699761e-02f, 3.04162707e-02f, -5.23512363e-02f,
  5.97036518e-02f, -5.60788102e-02f, 7.67171616e-03f, 5.06122038e-02f, -2.38975938e-02f, 1.82216279e-02f, -6.29445165e-02f, 1.48400350e-03f, 6.29533678e-02f, -2.57703401e-02f,
  -2.43209396e-02f, -1.33598536e-01f, -9.22229663e-02f, -6.65595308e-02f, -4.59740385e-02f, 7.40167052e-02f, -5.54524623e-02f, 6.69416785e-02f, 8.34903866e-02f, 1.91838574e-02f,
  6.32508844e-02f, -5.69196194e-02f, 5.80291264e-03f, -9.22456756e-02f, -5.01563996e-02f, 1.52656073e-02f, -1.11686029e-02f, 4.02345834e-03f, 3.42685133e-02f, 7.37439282e-03f,
  4.40738462e-02f, 2.44991272e-03f, -2.98361108e-03f, 3.52910869e-02f, 4.08312455e-02f, -8.17235559e-02f, -7.19658956e-02f, 1.00255467e-03f, 6.36640713e-02f, -1.24784976e-01f,
  4.20204066e-02f, -1.23055372e-02f, 6.48084357e-02f, 1.05414622e-01f, -8.78568515e-02f, 2.28583580e-03f, -8.92859697e-02f, -3.59695517e-02f, -6.58759624e-02f, -4.44699712e-02f,
  1.96803883e-01f, 1.94148049e-01f, 2.40063891e-02f, 1.06667764e-01f, 1.27105981e-01f, 6.36530071e-02f, 2.95984652e-02f, 6.37364388e-02f, -1.53328637e-02f, -1.15902936e-02f,
  1.91601701e-02f, 3.26082669e-02f, -2.44162194e-02f, -1.33179659e-02f, -3.27643119e-02f, -3.99243087e-02f, -1.81379840e-02f, 8.35073367e-02f, 9.06759221e-03f, 6.16609445e-03f,
  -4.96814512e-02f, -3.77803370e-02f, 4.05139551e-02f, 5.19425496e-02f, -4.03843597e-02f, -5.22882752e-02f, 6.84415624e-02f, 8.59609842e-02f, 9.30496007e-02f, 2.34819576e-02f,
  7.40579590e-02f, -2.13472307e-01f, -1.02793843e-01f, 1.61095276e-01f, -3.76856178e-02f, -3.32168192e-02f, -3.18112373e-01f, 1.91833198e-01f, 1.96550801e-01f, -3.80636193e-02f,
  1.27780242e-02f, 2.89149880e-01f, 1.84752271e-01f, 1.60146832e-01f, 2.92925239e-01f, -1.24135941e-01f, -1.05049297e-01f, 9.61396322e-02f, 2.63529181e-01f, 2.37834543e-01f,
  7.33444244e-02f, 9.54066887e-02f, 1.89049289e-01f, 6.56319931e-02f, -1.98212847e-01f, 4.73009571e-02f, 4.14841399e-02f, -4.58257683e-02f, -1.26580313e-01f, -5.99210024e-01f,
  -3.30865324e-01f, -5.03533036e-02f, 8.04526545e-03f, 1.05983265e-01f, -2.78064962e-02f, -5.14869243e-02f, -5.78934141e-02f, -5.64755201e-02f, -4.25507836e-02f, 6.53250609e-04f,
  4.79178987e-02f, 7.16512948e-02f, 2.13640705e-02f, 3.86936180e-02f, -6.06190078e-02f, -3.96699877e-03f, 4.44085933e-02f, 2.18663681e-02f, -5.10406233e-02f, -1.07360175e-02f,
  -2.87911277e-02f, -5.28481230e-02f, -6.12257905e-02f, 6.21772930e-02f, 8.61608461e-02f, 1.96630531e-03f, -4.82933223e-02f, -1.49263237e-02f, -6.96690753e-02f, -2.49287754e-01f,
  2.24708933e-02f, -6.73248172e-02f, -5.18834926e-02f, -1.18014894e-01f, 9.43233445e-02f, -3.31215821e-02f, -2.05945857e-02f, -2.69117635e-02f, 2.73224209e-02f, -2.56339144e-02f,
  1.31863942e-02f, -3.71132977e-02f, -6.95401058e-02f, 2.35176571e-02f, 1.53985405e-02f, -1.53067978e-02f, -5.43790162e-02f, 7.51018757e-03f, 3.17018367e-02f, -5.18924259e-02f,
  3.06378026e-02f, 5.90876415e-02f, 9.86980926e-03f, -2.58935187e-02f, -7.55241364e-02f, -5.81200309e-02f, 3.50665376e-02f, 6.67579919e-02f, 1.32538721e-01f, 8.84257257e-04f,
  1.46400452e-01f, 1.60847992e-01f, -9.78435725e-02f, 7.06878752e-02f, -6.52426528e-03f, 3.12821567e-02f, -6.44836128e-02f, -9.27243605e-02f, -9.02779400e-02f, -2.53491849e-02f,
  1.16995856e-01f, 5.97565062e-03f, -4.55607660e-02f, -3.28193099e-04f, 6.40496835e-02f, -4.70058359e-02f, 5.48432693e-02f, 2.15497315e-02f, -1.67754199e-02f, -1.96313784e-02f,
  1.23781450e-02f, 8.19799230e-02f, 3.06816157e-02f, -1.30526543e-01f, -2.01762728e-02f, 1.12721913e-01f, -2.03313841e-03f, -4.22527976e-02f, 2.52814554e-02f, -9.98993814e-02f,
  6.85403228e-01f, -3.54438990e-01f, 6.47256970e-02f, 1.87516257e-01f, -1.66748822e-01f, 3.84279042e-02f, -1.73258841e-01f, -6.14912547e-02f, 1.86096251e-01f, -1.71029687e-01f,
  -2.27918342e-01f, -1.73649892e-01f, -6.35648593e-02f, -1.18004836e-01f, 3.14048976e-02f, -4.33300808e-02f, 4.38510105e-02f, 1.54066816e-01f, 1.83663681e-01f, -1.09782599e-01f,
  -1.13633692e-01f, 1.39777914e-01f, 3.77986968e-01f, 1.75158143e-01f, -7.18348622e-02f, 1.08248517e-01f, -1.19753659e-01f, -4.30438891e-02f, -2.11786240e-01f, -2.00623363e-01f,
  -6.50298372e-02f, -2.70876795e-01f, 8.05859864e-02f, 6.22151569e-02f, 7.91259203e-03f, 9.89380032e-02f, 1.19909421e-01f, -3.77247855e-03f, 6.72805756e-02f, 1.68794449e-02f,
  2.47563180e-02f, -9.18392539e-02f, 3.83566096e-02f, -1.06392866e-02f, 5.01226857e-02f, -4.99190353e-02f, 1.25659168e-01f, 2.79550925e-02f, 7.44084194e-02f, -7.21121281e-02f,
  -2.14962021e-01f, -9.14553478e-02f, -7.53883570e-02f, -5.82700334e-02f, 4.27668989e-02f, -5.09191863e-02f, 2.17121746e-02f, -2.86536012e-02f, 2.86544021e-02f, 2.39558369e-02f,
  6.06801547e-02f, -3.02573610e-02f, -6.65837675e-02f, -6.55806437e-02f, 1.50964707e-02f, -1.55448876e-02f, -6.06529638e-02f, 2.94771721e-03f, 3.37188989e-02f, 2.37645954e-03f,
  -1.96193885e-02f, -6.92815483e-02f, -2.80770771e-02f, 3.61124873e-02f, -4.50685062e-02f, -1.05607212e-01f, -2.95890160e-02f, 3.58378352e-03f, -1.20102227e-01f, -2.57047662e-03f,
  -2.14757398e-02f, -1.98250003e-02f, 2.48535722e-02f, -2.25386526e-02f, -8.75931978e-02f, 2.21155044e-02f, -5.99128604e-02f, -4.44019958e-02f, 3.84813622e-02f, -8.26089904e-02f,
  2.53008604e-01f, -3.16576734e-02f, 1.14661016e-01f, 5.76938987e-02f, -3.15177254e-02f, 5.32120802e-02f, -9.78337973e-02f, 2.89645921e-02f, -4.05511446e-02f, 2.77879629e-02f,
  3.00051644e-03f, 4.77593429e-02f, -9.56790596e-02f, 8.78524315e-03f, 1.33060843e-01f, 6.16132319e-02f, -1.59739088e-02f, 7.23837167e-02f, -7.60642905e-03f, 1.37062818e-01f,
  6.82156011e-02f, 1.46448016e-01f, 4.13731262e-02f, 6.44069612e-02f, -4.48544286e-02f, 1.40014380e-01f, 5.10018952e-02f, 1.22689471e-01f, 1.00166664e-01f, 3.27339470e-01f,
  2.79808510e-02f, 1.36121184e-01f, 5.12062609e-01f, 3.42841417e-01f, 2.90971398e-01f, 1.29497558e-01f, 3.87617201e-01f, 1.41061246e-01f, -6.45170435e-02f, 5.84122539e-02f,
  -2.87674576e-01f, -3.98718029e-01f, -3.68823081e-01f, -1.64534166e-01f, -1.55419782e-01f, 2.37371892e-01f, 2.37949938e-01f, 2.00425878e-01f, 9.05131400e-02f, 1.23746149e-01f,
  6.12015799e-02f, 2.22606912e-01f, -3.64798144e-03f, 1.15111351e-01f, 7.44763240e-02f, -1.12139694e-01f, 1.48645356e-01f, 8.85814354e-02f, -1.34725049e-01f, 1.77048266e-01f,
  1.86452698e-02f, 2.78200448e-01f, 6.43627252e-03f, -1.16426356e-01f, 7.08156973e-02f, -7.26722702e-02f, -9.68098268e-02f, 5.96469156e-02f, 1.29843401e-02f, 1.33976489e-01f,
  -7.24036843e-02f, -1.16062984e-01f, 1.68524832e-02f, 5.17945960e-02f, 1.01712994e-01f, -4.41751070e-02f, 1.47273997e-02f, 1.08990505e-01f, 1.13248535e-01f, -3.09196096e-02f,
  2.71460488e-02f, -4.45032790e-02f, 8.73328671e-02f, 5.35060205e-02f, 1.10746048e-01f, 8.69002379e-03f, 7.49128684e-02f, 9.21700373e-02f, 3.88992094e-02f, -1.87824760e-02f,
  -1.11908587e-02f, 1.35962637e-02f, -3.01278401e-02f, -4.16988544e-02f, -1.09762490e-01f, -9.44611430e-03f, -3.29789296e-02f, -8.60940367e-02f, -4.01478447e-02f, -3.00549008e-02f,
  -6.66106939e-02f, 2.36452334e-02f, 9.81384888e-03f, 3.37451287e-02f, 2.36131828e-02f, 7.68519863e-02f, 3.92164327e-02f, -3.41813848e-03f, -2.80336253e-02f, -9.62986648e-02f,
  -6.43870980e-02f, 6.76876754e-02f, -3.52248400e-02f, 8.73253420e-02f, -6.00097515e-02f, -3.97131890e-02f, 3.92313749e-02f, -3.98704857e-02f, -6.04203641e-02f, 7.35190092e-03f,
  -6.83760792e-02f, 8.12249910e-03f, -9.43563581e-02f, 1.01401459e-03f, 4.30654548e-02f, -1.24374375e-01f, -1.91929545e-02f, -4.38159779e-02f, -5.75439557e-02f, 5.95805906e-02f,
  8.11455548e-02f, 2.05112938e-02f, 1.43168997e-02f, 3.10297795e-02f, 1.42771173e-02f, 4.71865088e-02f, -7.18283206e-02f, -8.72727111e-02f, 2.32106540e-02f, 1.04755707e-01f,
  2.85699982e-02f, -4.53498401e-02f, -9.63271335e-02f, -4.67130169e-02f, 8.89112242e-03f, -6.81821676e-03f, 8.07730630e-02f, 5.64248413e-02f, 3.00947879e-03f, -8.85171816e-03f,
  8.48837867e-02f, 1.03661798e-01f, -2.74272859e-01f, 1.62678495e-01f, -1.39288127e-01f, -1.76754862e-01f, -4.14730161e-02f, 3.17477673e-01f, 3.06899875e-01f, 8.33003521e-02f,
  -3.43892048e-03f, -3.43354270e-02f, -1.09341845e-01f, -3.08994185e-02f, -7.43621662e-02f, -1.84195444e-01f, -9.99677032e-02f, -3.58925045e-01f, -2.94200718e-01f, -9.12240595e-02f,
  -1.01608954e-01f, -1.31878674e-01f, -3.36478022e-03f, 7.08101541e-02f, 9.39490572e-02f, -9.90381911e-02f, -2.25855876e-02f, -1.02898628e-01f, -1.33852601e-01f, 9.05348957e-02f,
  -2.59925932e-01f, -5.65478578e-03f, 3.83431092e-02f, 4.99739237e-02f, -2.13099942e-02f, 1.69754233e-02f, -5.26689142e-02f, 2.58432068e-02f, -3.26342359e-02f, 2.35832408e-02f,
  -5.19803399e-03f, -1.00111300e-02f, -8.50554258e-02f, -1.29720569e-01f, -1.92468781e-02f, -3.52814309e-02f, 1.33410573e-01f, 3.22580561e-02f, 9.73267630e-02f, 2.24348363e-02f,
  5.67313135e-02f, -1.78974912e-01f, -1.31485134e-01f, 1.15095355e-01f, -2.01665238e-02f, -1.27956972e-01f, 8.76918435e-02f, 7.89737329e-02f, -6.85497746e-02f, 2.70871103e-01f,
  1.77738592e-02f, -1.17560618e-01f, -1.78751945e-02f, 8.53271876e-03f, -5.90859838e-02f, -2.93686558e-02f, -5.12269847e-02f, 2.28564125e-02f, -5.72198667e-02f, 3.87795083e-02f,
  -1.73177049e-02f, -3.66420634e-02f, 4.59512994e-02f, 2.19563488e-03f, -6.44093081e-02f, -1.49299018e-02f, -1.99229480e-03f, 1.77756185e-04f, -2.83217337e-03f, 4.52234671e-02f,
  6.63287193e-02f, -2.92317737e-02f, -7.35593289e-02f, 1.00875974e-01f, -7.52652511e-02f, 2.60421634e-02f, -5.95920496e-02f, -7.95091689e-02f, -2.32895631e-02f, -7.30214640e-02f,
  1.78132012e-01f, -9.00742859e-02f, 4.31891866e-02f, 2.02589437e-01f, 4.79872199e-03f, 7.85724521e-02f, 1.30282030e-01f, 1.03954561e-01f, 5.02669998e-02f, 7.15249106e-02f,
  1.92702543e-02f, -3.44726928e-02f, -3.22360173e-02f, 3.85193713e-02f, 2.44620033e-02f, 4.40781116e-02f, -1.38168167e-02f, 4.73628938e-03f, 5.63741922e-02f, 1.20205417e-01f,
  1.61364928e-01f, 5.67283295e-02f, 4.58654240e-02f, 1.38989493e-01f, -3.95967141e-02f, -8.84607732e-02f, 6.26692995e-02f, 1.37226041e-02f, -2.28759218e-02f, 2.00325072e-01f,
  -3.11157823e-01f, 3.69242907e-01f, -5.39706051e-02f, -2.45112658e-01f, 1.13916308e-01f, 1.85723677e-01f, 5.86894214e-01f, 2.96274070e-02f, -2.28237510e-01f, 2.65027523e-01f,
  -6.13652356e-02f, -3.41232151e-01f, -3.02867681e-01f, -2.22352535e-01f, 1.18098445e-01f, 3.30922782e-01f, 2.93026865e-01f, -1.90531209e-01f, -3.06694895e-01f, 3.22128348e-02f,
  7.80541748e-02f, 4.16507609e-02f, -2.61829048e-01f, -1.95093051e-01f, 1.06437571e-01f, -1.72674835e-01f, 1.52116880e-01f, 3.62442173e-02f, 1.82243481e-01f, 2.42888540e-01f,
  7.83767104e-02f, 1.39188781e-01f, -2.06809923e-01f, -1.44962057e-01f, 4.67057824e-02f, -5.37566394e-02f, 3.35191526e-02f, -3.56910843e-03f, -7.76302665e-02f, -4.17452632e-03f,
  -1.11354077e-02f, 2.68699359e-02f, -5.54912072e-03f, 3.18547599e-02f, 3.53881195e-02f, 4.63322289e-02f, 6.02201968e-02f, -5.12233786e-02f, -2.47429870e-02f, 4.24690992e-02f,
  2.50006709e-02f, 1.53759375e-01f, 1.52754888e-01f, 4.44698781e-02f, -2.49642022e-02f, -3.46412137e-02f, 6.27251938e-02f, 3.83234099e-02f, -6.44079894e-02f, 1.33292362e-01f,
  8.35397001e-03f, 2.16446854e-02f, -3.97934653e-02f, 4.18828502e-02f, 1.54373003e-02f, -4.97199781e-02f, 1.86659154e-02f, 1.92651469e-02f, -6.18982920e-03f, 4.69464250e-02f,
  5.02869347e-03f, 2.08553318e-02f, -1.82009637e-02f, 3.21511663e-02f, -5.72159216e-02f, 1.41183110e-02f, -3.00082713e-02f, 5.84446304e-02f, -4.04359289e-02f, -4.85874303e-02f,
  -2.95066666e-02f, -2.63831448e-02f, 3.89121361e-02f, -4.79885936e-02f, 3.24028954e-02f, -5.20452298e-02f, 6.80493787e-02f, -4.09314297e-02f, -1.36232274e-02f, 1.97900701e-02f,
  -5.49443588e-02f, 3.87074724e-02f, -4.03007083e-02f, 1.37902936e-03f, 8.47797170e-02f, 2.35169698e-02f, -1.29141957e-02f, -5.28229848e-02f, 3.60119157e-03f, -1.53506445e-02f,
  -1.36947539e-02f, -1.03044407e-02f, 3.13337371e-02f, -2.02736177e-04f, 6.03090934e-02f, 1.01520950e-02f, 2.58203596e-02f, -3.05032320e-02f, 1.34021984e-02f, -1.30633526e-02f,
  -4.51101139e-02f, 3.38982791e-02f, 6.51961789e-02f, -1.25905331e-02f, -7.42847994e-02f, -4.95308973e-02f, 1.25738725e-01f, -4.09347750e-02f, 1.16753571e-01f, 1.13587908e-01f,
  6.74109995e-01f, -3.41116577e-01f, -8.36314335e-02f, 2.11373181e-03f, -7.82597959e-02f, 5.22231087e-02f, -1.36166096e-01f, 1.21647485e-01f, 1.29409745e-01f, -2.12426662e-01f,
  -2.92389512e-01f, -1.23998262e-01f, -1.41812637e-01f, -1.85801059e-01f, 6.19459525e-02f, -1.85666129e-01f, -1.62755802e-01f, 1.36812165e-01f, 3.16789418e-01f, 1.52706534e-01f,
  -7.30230883e-02f, 2.11369202e-01f, 4.43082958e-01f, 1.88483015e-01f, -3.58760238e-01f, -3.71543504e-02f, -2.02542618e-01f, 3.91836315e-02f, -1.19470075e-01f, -4.20724094e-01f,
  -4.85082626e-01f, 1.50307659e-02f, 4.55212146e-02f, -4.24595885e-02f, -2.63299067e-02f, 1.56052411e-01f, 1.82095766e-02f, 5.38906753e-02f, 8.33413601e-02f, -4.39665951e-02f,
  -7.42348954e-02f, 1.38540065e-03f, 3.49964872e-02f, 2.88490169e-02f, -6.86704600e-03f, -2.24813297e-02f, 5.30344062e-02f, 1.05804577e-01f, -3.81495245e-02f, -6.99468255e-02f,
  -1.12017252e-01f, -4.10598479e-02f, -5.69859846e-03f, -6.32411242e-02f, 9.70878545e-03f, -7.08880797e-02f, -1.31535530e-01f, -1.38375401e-01f, 2.15534922e-02f, -6.62527978e-02f,
  -1.38051897e-01f, 3.50459851e-02f, 2.69116201e-02f, -1.83127690e-02f, 8.09461251e-02f, -2.39583738e-02f, 1.25094866e-02f, -3.72777767e-02f, 9.15253684e-02f, 7.17132760e-04f,
  7.94063807e-02f, 3.73025378e-03f, 7.51868412e-02f, 5.02195582e-03f, -4.07857858e-02f, 4.77454029e-02f, -2.90175211e-02f, -1.49136372e-02f, -5.04259840e-02f, 9.49328169e-02f,
  5.34981005e-02f, 1.94656011e-03f, 5.07546552e-02f, 4.12582830e-02f, 4.05829139e-02f, -3.30074131e-02f, 9.96521562e-02f, -4.84384038e-02f, 3.28135490e-02f, 1.12784609e-01f,
  -2.14269999e-02f, 1.88993234e-02f, -1.33055985e-01f, -8.91375020e-02f, 1.31140314e-02f, 6.51532114e-02f, -4.78519350e-02f, -4.73296903e-02f, 4.84134257e-02f, -3.26811485e-02f,
  9.04584955e-03f, 5.87182678e-02f, -7.26020113e-02f, 1.71848945e-02f, 3.16482186e-02f, -8.55763331e-02f, -7.71934316e-02f, 9.50688682e-03f, 7.72549808e-02f, -2.51646955e-02f,
  5.06849028e-02f, 8.80221874e-02f, -2.81890295e-02f, -8.47642869e-02f, -3.80120203e-02f, -1.05169564e-01f, -1.37853175e-01f, -8.54785517e-02f, 1.62186194e-02f, -6.77217022e-02f,
  9.91869196e-02f, 1.24788068e-01f, 2.39901856e-01f, -8.28028992e-02f, 3.10663041e-02f, 2.21377343e-01f, 3.72752190e-01f, 1.99282497e-01f, -5.09389006e-02f, -2.18305495e-02f,
  -1.75413981e-01f, -3.15478146e-01f, -1.19684212e-01f, -1.30520701e-01f, 1.81923956e-01f, 1.89596742e-01f, 1.86736941e-01f, 1.86625533e-02f, 1.53680772e-01f, -5.07885776e-02f,
  -9.68364999e-02f, -1.63840577e-01f, -8.64801332e-02f, 3.24097350e-02f, -1.50904596e-01f, -1.80265039e-01f, -1.57498345e-01f, -7.37670660e-02f, -2.64514214e-03f, -1.02108382e-01f,
  -1.76100805e-02f, 2.62791842e-01f, 9.68619660e-02f, -6.82460144e-02f, -1.15779815e-02f, 6.77143857e-02f, 3.45358178e-02f, -7.57323727e-02f, 4.57111709e-02f, -8.07618909e-03f,
  5.42124594e-03f, -3.62843536e-02f, 3.02882064e-02f, -3.95376310e-02f, -4.02692445e-02f, 3.85331586e-02f, 3.68209183e-02f, 2.91209668e-02f, 1.44412234e-01f, -1.55945336e-02f,
  -5.89687340e-02f, -3.51869725e-02f, -5.04387636e-03f, 6.10749796e-02f, 2.16779590e-01f, -6.36212900e-02f, 2.24592574e-02f, 1.17118947e-01f, 1.56625777e-01f, -5.43279238e-02f,
  -3.43494006e-02f, 3.62590551e-02f, 1.40884644e-04f, -1.48331635e-02f, -1.61289852e-02f, -1.85456630e-02f, -4.57175374e-02f, -8.69536176e-02f, 1.30179804e-02f, -9.32764858e-02f,
  -4.03908873e-03f, -2.83030551e-02f, 3.40314060e-02f, -2.21455134e-02f, -1.37615949e-01f, 1.05863258e-01f, 4.46046367e-02f, 4.11790684e-02f, -3.39140072e-02f, 4.14629765e-02f,
  4.65148734e-03f, 4.13191095e-02f, -3.19468044e-02f, 3.72062698e-02f, 3.33764367e-02f, 8.66406783e-02f, -3.46436165e-02f, 4.21799626e-03f, -4.12496105e-02f, 6.23936653e-02f,
  -2.88408458e-01f, 1.49606332e-01f, -4.54384312e-02f, -6.22137776e-03f, -5.44406511e-02f, -8.35872665e-02f, -2.89176535e-02f, 6.01380877e-03f, -3.24761607e-02f, 1.94923803e-02f,
  8.21646079e-02f, -8.43630508e-02f, -8.04469138e-02f, -7.85617530e-02f, -8.56542066e-02f, -2.76667904e-02f, -8.89467001e-02f, -2.79906336e-02f, -1.39027247e-02f, 7.51389414e-02f,
  5.26113261e-04f, -5.81514090e-02f, -7.62498826e-02f, -3.94131849e-03f, 4.64911154e-03f, -6.14876375e-02f, -9.18506458e-02f, -3.36716995e-02f, -2.94732638e-02f, -5.36928996e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.78659475e-01f, -1.84197262e-01f, 4.67402130e-01f, 1.05268089e-02f, -3.41104209e-01f, -3.01046371e-01f, -5.48899353e-01f, -1.96247265e-01f, -1.60872445e-01f, -7.30310157e-02f,
  -2.01312736e-01f, 5.74276932e-02f, 1.89082369e-01f, 3.07117760e-01f, 1.53102994e-01f, -2.91182343e-02f, 2.46187493e-01f, 6.54928029e-01f, 3.35941374e-01f, 7.69622475e-02f,
  5.52571043e-02f, 1.28243238e-01f, 3.59969139e-01f, 1.96847484e-01f, 1.16273977e-01f, 1.02759033e-01f, 6.19851891e-03f, 1.43542737e-01f, 6.09438866e-02f, 5.50887108e-01f,
  2.04298541e-01f, 1.30521417e-01f, 1.40490741e-01f, -9.11377370e-03f, 3.29158455e-02f, -1.94279533e-02f, -1.63088348e-02f, 1.58175215e-01f, -7.74000213e-02f, 2.27120407e-02f,
  -1.15002491e-01f, 2.16780137e-02f, -6.67064218e-03f, -6.27576979e-03f, 7.82782026e-03f, -1.98401082e-02f, 9.37981680e-02f, 1.88510850e-01f, 2.18006968e-02f, -2.07590554e-02f,
  -1.28854528e-01f, -5.70942983e-02f, -1.47825137e-01f, -2.16762945e-01f, -4.53487001e-02f, 1.48924425e-01f, -9.88822728e-02f, 1.09690644e-01f, 4.09542136e-02f, 2.00859904e-01f,
  3.16335857e-02f, 1.14998125e-01f, 8.73455927e-02f, 1.46374121e-01f, 9.80178490e-02f, 7.89401829e-02f, 6.09260388e-02f, -2.27306485e-02f, 3.28442939e-02f, 8.95208791e-02f,
  2.86034700e-02f, -2.51278793e-03f, -5.93615919e-02f, 2.72860080e-02f, -1.02817630e-02f, 6.10220712e-04f, -8.73334035e-02f, 2.36194339e-02f, -4.53145728e-02f, 2.48002224e-02f,
  7.86951259e-02f, -8.58427659e-02f, 8.56120512e-02f, -1.78414711e-03f, -2.71915179e-02f, 1.35381952e-01f, 8.25941116e-02f, 2.85550114e-02f, -3.71850319e-02f, 5.07166497e-02f,
  -6.50758147e-01f, 4.79792804e-02f, 1.73812851e-01f, -3.71684134e-02f, -2.92528849e-02f, -9.73917171e-02f, 3.13051976e-02f, -2.45755240e-02f, -1.12079822e-01f, -1.01556154e-02f,
  -1.68469340e-01f, 9.64983851e-02f, -4.51929346e-02f, 8.73657465e-02f, -6.09116741e-02f, -1.69718996e-01f, -4.95996373e-03f, -7.42496103e-02f, -8.41351971e-02f, -1.30082235e-01f,
  -5.90191111e-02f, -1.01236783e-01f, -2.50587434e-01f, -1.36017784e-01f, -1.13216348e-01f, -3.42120789e-02f, 4.92284484e-02f, -6.43144771e-02f, -1.23244286e-01f, -9.99145880e-02f,
  5.26239872e-01f, 3.21273953e-01f, -6.09407760e-02f, 1.77129507e-01f, 2.59084199e-02f, -1.43127844e-01f, -4.20393646e-02f, 4.71010916e-02f, -9.91393998e-02f, 1.34773210e-01f,
  -8.32457989e-02f, -6.09494485e-02f, -7.38206133e-02f, 4.32488602e-03f, -4.44187373e-02f, 8.37099031e-02f, 1.89812377e-01f, 4.52471785e-02f, -2.32223630e-01f, -2.83420622e-01f,
  -8.00501332e-02f, 1.24221891e-01f, 1.67607442e-01f, -5.66720925e-02f, 1.65366113e-01f, -2.46946678e-01f, -2.03855529e-01f, 1.26385525e-01f, 4.99690585e-02f, 7.68043816e-01f,
  3.60318512e-01f, 1.88192144e-01f, -2.65952379e-01f, -5.50526045e-02f, -1.89025849e-02f, 1.24178305e-01f, 3.09359119e-03f, 7.12476447e-02f, -2.73106620e-02f, -5.74857444e-02f,
  2.63226897e-01f, 6.93889558e-02f, 3.43795568e-02f, -1.24818267e-04f, -2.74155196e-02f, -7.56246895e-02f, 5.08207083e-02f, 9.01035815e-02f, 5.58654964e-02f, 3.72680984e-02f,
  3.26091284e-03f, -9.37358066e-02f, -1.07196875e-01f, -2.30914205e-01f, -1.94725379e-01f, -2.17000738e-01f, -1.23811811e-01f, -2.92018242e-02f, -1.51047990e-01f, 7.96302259e-02f,
  -1.52368069e-01f, 3.57769132e-02f, 4.29851487e-02f, -7.37203136e-02f, 3.17779854e-02f, -2.17959061e-02f, 4.54991423e-02f, -1.62405912e-02f, -8.57025683e-02f, 1.64786056e-02f,
  -1.53259635e-01f, -1.45011410e-01f, -4.06742748e-03f, -1.44576043e-01f, -1.27826750e-01f, 6.66797310e-02f, 7.85671473e-02f, -3.63410152e-02f, -6.97883144e-02f, 2.44827196e-02f,
  2.70792414e-02f, -1.76729094e-02f, 7.61036351e-02f, 1.43821687e-01f, -4.92006168e-02f, -6.37667626e-02f, -2.27558706e-02f, -1.48601398e-01f, -1.24164462e-01f, 3.25810025e-03f,
  8.46706331e-02f, -5.17020822e-01f, 8.59268708e-04f, 2.47493431e-01f, 6.09762408e-02f, 1.18901111e-01f, 6.50609285e-02f, 1.85660589e-02f, -1.97566077e-02f, 2.18458287e-02f,
  1.06181070e-01f, -4.65534478e-02f, 4.70768325e-02f, 7.12838443e-03f, -5.45833446e-02f, -7.69046769e-02f, 6.18767999e-02f, 5.81008792e-02f, -3.50494608e-02f, 1.14177577e-02f,
  -2.15033651e-03f, -1.32381171e-01f, -2.17177704e-01f, -1.83119982e-01f, -1.03515107e-02f, -3.39283019e-01f, -1.47190541e-01f, 3.88797745e-02f, -1.80300802e-01f, -2.46801645e-01f,
  -1.10955429e+00f, 3.15451086e-01f, -2.10229427e-01f, -3.50778371e-01f, 2.49656931e-01f, 2.31351703e-01f, 4.43323672e-01f, 2.05586106e-01f, -1.99900389e-01f, -7.12801563e-03f,
  1.09569564e-01f, 7.77521878e-02f, 1.80531234e-01f, 3.25222939e-01f, 2.03068808e-01f, 3.53708893e-01f, 3.09519500e-01f, -2.18501061e-01f, -8.91364068e-02f, 1.47791803e-01f,
  3.17369282e-01f, -3.10655475e-01f, -6.91369295e-01f, -3.27914536e-01f, -3.86983827e-02f, 9.34480131e-02f, -9.38194990e-02f, -2.75565535e-01f, 1.69112220e-01f, -9.07677598e-03f,
  -7.39513263e-02f, -1.86406597e-01f, 2.83321619e-01f, -8.57745558e-02f, 9.04201064e-03f, -8.36715773e-02f, -6.41114563e-02f, -1.30229786e-01f, -1.92253739e-02f, -1.52016580e-01f,
  -7.72451758e-02f, -8.53503793e-02f, -7.93098733e-02f, 3.62886041e-02f, -1.46524176e-01f, -2.37973079e-01f, -3.98553759e-02f, -7.64844492e-02f, 2.97841430e-02f, 2.44140942e-02f,
  3.40511650e-01f, -1.62032276e-01f, -2.51088828e-01f, -4.60156181e-04f, 1.79683998e-01f, -6.01950986e-03f, 9.87378955e-02f, -1.26490191e-01f, -4.27945033e-02f, -2.66527593e-01f,
  2.03373060e-02f, -1.58027843e-01f, 1.30576454e-02f, 9.42956284e-03f, -8.14304501e-02f, 6.82095885e-02f, -1.65635794e-02f, 5.94619438e-02f, -1.02101043e-02f, -1.25653163e-01f,
  7.49057457e-02f, 2.04676017e-03f, 7.89398775e-02f, -3.21368426e-02f, 1.46111539e-02f, -3.59934159e-02f, -3.84388566e-02f, -4.07156311e-02f, 1.31133134e-02f, -5.85032180e-02f,
  2.03423100e-04f, 1.18702337e-01f, -5.25516532e-02f, 1.13345005e-01f, 8.22405294e-02f, 2.99394522e-02f, -3.11306790e-02f, -1.01069391e-01f, -3.86002362e-02f, -8.39652345e-02f,
  -5.98737830e-03f, 5.49882837e-02f, -1.08196959e-01f, 1.34008452e-01f, -8.71159285e-02f, 6.44716248e-02f, -9.13454518e-02f, -3.10532805e-02f, 1.22061789e-01f, 1.55389989e-02f,
  5.61360195e-02f, -2.38933954e-02f, -7.44574964e-02f, 4.21001352e-02f, -1.70522809e-01f, -7.74989054e-02f, 1.02627240e-01f, 1.23544872e-01f, 2.10440189e-01f, -9.65960622e-02f,
  1.91020831e-01f, 3.35258469e-02f, -1.59402430e-01f, 1.43545449e-01f, 5.42810485e-02f, 3.91345005e-03f, 2.30477774e-03f, 8.86745304e-02f, 3.74446586e-02f, -2.03996953e-02f,
  -2.11407796e-01f, -4.51509297e-01f, 1.79547369e-01f, 3.41787487e-01f, 5.07533431e-01f, 4.15092140e-01f, 3.25014800e-01f, 2.32952356e-01f, 2.71779656e-01f, 1.56068459e-01f,
  -1.00315921e-01f, 1.13318272e-01f, 1.56246498e-01f, 2.10694581e-01f, -2.01009028e-02f, 2.39930719e-01f, 2.25977734e-01f, 8.06191340e-02f, 3.79501522e-01f, 2.33059391e-01f,
  2.62179941e-01f, -7.80047998e-02f, -4.23171818e-01f, 1.06880710e-01f, 5.26484437e-02f, 1.85476586e-01f, -3.86926085e-02f, -8.88371766e-02f, -1.28488079e-01f, 7.71702901e-02f,
  1.02954946e-01f, -2.79733479e-01f, 2.96700299e-01f, -1.79366887e-01f, -9.28355679e-02f, -1.94182187e-01f, 1.44620743e-02f, -1.54685542e-01f, -9.63235423e-02f, -2.19659461e-03f,
  -9.00802463e-02f, -1.05486758e-01f, -6.95488229e-02f, -6.47267923e-02f, 8.82699154e-03f, -1.16853610e-01f, -2.63516158e-01f, 1.44448515e-03f, 8.94239247e-02f, -7.35413730e-02f,
  1.16603881e-01f, -9.27033089e-03f, 9.97516885e-02f, 1.30925909e-01f, 9.31033194e-02f, -1.24322353e-02f, -9.71662179e-02f, -1.36591971e-01f, 5.92068434e-02f, -1.66486437e-03f,
  1.10851765e-01f, 4.33288440e-02f, 7.19138458e-02f, 1.28028736e-01f, -6.07937016e-02f, -7.24012852e-02f, -2.03815047e-02f, 4.57581766e-02f, 4.40311059e-02f, 2.60889679e-02f,
  1.29278526e-02f, 1.51037589e-01f, 7.60616213e-02f, 8.45441371e-02f, -6.92226412e-03f, 4.89710160e-02f, 7.30712190e-02f, -1.16469547e-01f, -1.10393919e-01f, -4.90844846e-02f,
  3.45957577e-02f, 5.45272045e-02f, -1.03713661e-01f, 2.04625186e-02f, -6.61605373e-02f, 8.45908672e-02f, 9.48840939e-03f, -7.47343525e-02f, -1.13640574e-03f, -2.67279744e-02f,
  1.12305641e-01f, 5.74169047e-02f, 1.44498870e-01f, -2.68254866e-04f, -9.19063538e-02f, -2.16290101e-01f, 1.05307065e-01f, -1.40661642e-01f, -1.10136367e-01f, -3.08121406e-02f,
  -2.01343730e-01f, -7.61033595e-02f, -1.07161090e-01f, -6.75328374e-02f, -3.61009538e-02f, 4.90622409e-02f, -1.96121290e-01f, 2.03454301e-01f, -8.30555707e-03f, -9.96120796e-02f,
  -1.39073376e-02f, 1.87107816e-01f, 1.70450181e-01f, 2.62379467e-01f, 7.76203200e-02f, 1.53090283e-01f, 3.77823748e-02f, 3.56465764e-02f, 5.89659773e-02f, 7.02882707e-02f,
  -8.61205995e-01f, -7.94873163e-02f, -8.65417160e-03f, -7.81553447e-01f, -3.62180501e-01f, -1.07772425e-01f, -2.10559830e-01f, -1.55797467e-01f, -4.29878712e-01f, -2.32728183e-01f,
  1.51679561e-01f, 3.53276908e-01f, 1.69135571e-01f, 3.10214043e-01f, 9.37023237e-02f, -3.84713262e-01f, -4.59227115e-01f, -1.66461170e-01f, 3.03689688e-01f, 1.79854229e-01f,
  -2.22839192e-01f, -5.43719113e-01f, -3.90873313e-01f, -9.56471190e-02f, -1.47286922e-01f, -5.30893691e-02f, -2.99257517e-01f, -3.01958442e-01f, 1.49254739e-01f, -4.79565084e-01f,
  2.27617308e-01f, 6.82999492e-02f, 8.86250809e-02f, -2.10698470e-02f, 1.61685869e-02f, -6.65177926e-02f, -9.56112240e-03f, -3.57934162e-02f, -5.22686429e-02f, 9.72229242e-02f,
  1.38790803e-02f, 8.76068231e-03f, -8.76048356e-02f, 3.21092531e-02f, -7.45877773e-02f, 2.30020732e-02f, -1.09600052e-02f, -3.18143927e-02f, -4.53592055e-02f, 2.02747822e-01f,
  1.24025173e-01f, 1.64678246e-02f, 2.22445250e-01f, 1.88862175e-01f, 1.79593608e-01f, 2.04086199e-01f, 2.36283004e-01f, 1.24770537e-01f, 9.94166881e-02f, -1.31933531e-02f,
  -1.12782948e-01f, 1.61441475e-01f, 2.16092333e-01f, -3.16854790e-02f, 1.24909980e-02f, -4.44959439e-02f, 4.15722169e-02f, 4.48620915e-02f, 2.07364559e-03f, 4.92916740e-02f,
  -1.46122547e-02f, -2.52507888e-02f, -1.82660054e-02f, -1.18594967e-01f, 8.16045478e-02f, -6.01540506e-02f, -5.48973680e-02f, 4.35344428e-02f, 1.21020287e-01f, -8.99703242e-03f,
  5.22225350e-03f, -7.50787333e-02f, -1.50065392e-01f, 3.72159258e-02f, -1.53578389e-02f, -6.96415901e-02f, -1.72536972e-03f, 1.41782507e-01f, -6.67657331e-02f, -9.29784402e-03f,
  1.41813001e-02f, 7.10181445e-02f, -6.68179244e-02f, 5.48869893e-02f, -1.14221372e-01f, 1.11665197e-01f, 1.42191961e-01f, -1.03418678e-01f, -5.74127138e-02f, 3.59289981e-02f,
  1.32107645e-01f, 6.96830750e-02f, -1.87556706e-02f, 7.33128861e-02f, -3.71015631e-02f, 8.89119729e-02f, -4.29715542e-03f, -1.39370099e-01f, -5.72117157e-02f, 1.91121884e-02f,
  4.29382827e-03f, 1.57953780e-02f, 1.80804282e-01f, 1.62766889e-01f, 4.46862094e-02f, -4.02990654e-02f, 2.01340616e-01f, 5.55245876e-02f, 4.57378291e-02f, -2.30678216e-01f,
  -4.22286630e-01f, -1.96547180e-01f, -1.61441818e-01f, -5.85153773e-02f, 5.87001778e-02f, -6.17852993e-02f, -4.27374125e-01f, -1.38373584e-01f, 3.97543222e-01f, 7.35098124e-02f,
  2.07293004e-01f, 1.15680836e-01f, -1.54918492e-01f, -1.80503249e-01f, -5.29061317e-01f, -4.34425980e-01f, -3.29694897e-01f, -4.19753134e-01f, -3.08454186e-01f, 2.54077911e-01f,
  3.59901845e-01f, -3.46740894e-02f, -3.43197018e-01f, 7.48694539e-02f, 3.07782590e-01f, 5.22831129e-03f, 6.12709485e-02f, -1.19059622e-01f, -1.23936042e-01f, -3.18002731e-01f,
  -6.53265417e-02f, 1.12977043e-01f, 1.43144831e-01f, 9.59189013e-02f, 1.36112407e-01f, 6.22335970e-02f, 5.74607551e-02f, -3.53210643e-02f, 1.78974330e-01f, -7.45382383e-02f,
  6.37031794e-02f, 1.74713358e-01f, 5.16131632e-02f, 1.35955643e-02f, -7.52276480e-02f, -2.80921403e-02f, -3.53750437e-02f, -1.69909209e-01f, -3.47778462e-02f, -6.96468400e-03f,
  -2.00375363e-01f, -8.12584385e-02f, -2.83959627e-01f, -1.88756689e-01f, -2.21399382e-01f, -1.14324540e-01f, -8.33498240e-02f, 1.73762158e-01f, -1.79192290e-01f, -1.35238335e-01f,
  2.28800047e-02f, 1.32455200e-01f, 5.75198680e-02f, -8.28325152e-02f, -6.64978102e-02f, 6.12205155e-02f, -4.93739843e-02f, -8.29610303e-02f, -3.30298468e-02f, -6.39942288e-02f,
  -7.00425953e-02f, -1.01751305e-01f, 9.12936125e-03f, -6.81057423e-02f, -9.17042792e-03f, 7.32126161e-02f, 1.57528609e-01f, -1.95438474e-01f, -1.99428171e-01f, 2.15859897e-02f,
  -4.74415608e-02f, -5.65332584e-02f, 1.77281480e-02f, 2.05147676e-02f, 1.39687836e-01f, 2.17903733e-01f, 1.14621231e-02f, -1.07633546e-01f, -9.28902477e-02f, 3.02737076e-02f,
  -3.85370225e-01f, 1.19986981e-01f, -2.07609087e-02f, -1.25169158e-01f, -4.66989391e-02f, -2.80436631e-02f, -1.40347749e-01f, -6.76852465e-02f, 8.16489831e-02f, -4.33534682e-02f,
  -1.07627444e-01f, -2.50665754e-01f, -1.02499746e-01f, -1.47233576e-01f, 3.75656784e-02f, -1.02892227e-01f, -2.03641787e-01f, -1.97487012e-01f, 1.48534283e-01f, 1.77340955e-01f,
  -1.42920434e-01f, -2.15203077e-01f, -2.08964199e-01f, -2.96565324e-01f, 9.05174240e-02f, 5.44437300e-03f, -2.68113703e-01f, 8.09011310e-02f, -2.56954551e-01f, -4.63410378e-01f,
  -1.29637256e-01f, -3.75173002e-01f, -3.32849383e-01f, -4.72747803e-01f, -1.77244872e-01f, 8.52989256e-02f, 6.47412390e-02f, 7.38944113e-03f, -1.61775187e-01f, -3.92764241e-01f,
  -2.12986812e-01f, 2.93981910e-01f, -1.45707261e-02f, 8.27292278e-02f, 1.10888392e-01f, -2.67529279e-01f, -4.69855398e-01f, -5.61738620e-03f, 6.48678482e-01f, 5.50838888e-01f,
  9.81770232e-02f, 8.95682871e-02f, 5.26432805e-02f, 5.64549491e-02f, -2.56018072e-01f, 7.09913597e-02f, -4.15013373e-01f, -2.44166493e-01f, -8.56113657e-02f, -5.37926316e-01f,
  8.20564330e-02f, -1.98437229e-01f, -2.75763758e-02f, -9.92940143e-02f, -1.66956797e-01f, -6.57652766e-02f, 8.24132934e-02f, -1.16797090e-01f, -9.01531652e-02f, -9.94496197e-02f,
  -1.84710950e-01f, 1.27637506e-01f, 1.96931344e-02f, 9.53413919e-03f, 1.99991353e-02f, 1.13991566e-01f, -8.24982673e-02f, -1.72656626e-01f, -1.54450163e-01f, 3.00538074e-02f,
  -5.54649420e-02f, 1.96213042e-03f, -7.82177821e-02f, -9.11794156e-02f, -1.69505160e-02f, -8.49889312e-03f, -7.61933997e-02f, -1.49885761e-02f, -1.09724969e-01f, -1.19651668e-01f,
  2.77043716e-03f, -6.65837750e-02f, -6.01505069e-03f, 5.11663035e-02f, 6.99385926e-02f, -2.64759809e-02f, 5.88423125e-02f, 6.35402091e-03f, 3.11988518e-02f, 1.34534072e-02f,
  -5.11850342e-02f, -3.00644524e-02f, 3.31769548e-02f, -1.34222373e-01f, -1.29686236e-01f, -6.90933391e-02f, 1.44411735e-02f, -6.36850521e-02f, -1.31876245e-02f, -7.78682381e-02f,
  5.21134445e-03f, -6.06673844e-02f, -1.10827237e-01f, 7.53636584e-02f, -1.86522931e-01f, 5.99724874e-02f, 1.10347949e-01f, -4.52558585e-02f, 8.80479887e-02f, -1.82469383e-01f,
  2.72641219e-02f, -1.48998484e-01f, -5.69414757e-02f, 1.75795972e-01f, -5.35248592e-02f, -1.16997495e-01f, -1.15186371e-01f, 3.15618999e-02f, 2.09513884e-02f, 1.04269713e-01f,
  1.16505854e-01f, 1.08972788e-01f, 3.19842137e-02f, -1.18048843e-02f, 8.45472217e-02f, 1.41124830e-01f, -2.13620309e-02f, 1.27648294e-01f, 1.03091914e-03f, -1.09609924e-01f,
  -1.70290500e-01f, 5.55817001e-02f, 2.94255614e-01f, 6.64010420e-02f, 9.96106863e-02f, 3.05461466e-01f, 2.94604331e-01f, 1.25776678e-01f, 2.73170710e-01f, 1.02293059e-01f,
  4.11328733e-01f, -2.68214971e-01f, 4.16302949e-01f, 2.98562311e-02f, -5.56946635e-01f, -4.47369725e-01f, -5.05008757e-01f, -1.20190106e-01f, -1.18372217e-01f, -1.59227133e-01f,
  -1.77953631e-01f, 1.55462682e-01f, 1.55774146e-01f, 2.86993504e-01f, 2.77147323e-01f, 1.35961220e-01f, 1.30815849e-01f, 4.07368153e-01f, 3.17077190e-01f, 1.43571394e-02f,
  -1.50589630e-01f, -1.53419644e-01f, 1.91673815e-01f, 1.72867239e-01f, -1.23284727e-01f, 4.07444723e-02f, -5.94090521e-02f, -1.29729480e-01f, -1.43385455e-01f, 3.18560898e-01f,
  2.41579875e-01f, 6.79215267e-02f, 1.37303755e-01f, -1.03602642e-02f, -9.26518068e-02f, -1.17235044e-02f, -1.02962859e-01f, -1.47819193e-02f, 4.00595041e-03f, -9.76800360e-03f,
  1.32102855e-02f, -7.22275004e-02f, -8.02939609e-02f, -1.33313224e-01f, -5.78158870e-02f, -2.85970862e-03f, 7.93445110e-02f, 1.55649066e-01f, 2.39580810e-01f, 8.55213478e-02f,
  -5.72828539e-02f, -2.40454912e-01f, -8.83046240e-02f, -1.77900195e-02f, 1.01032406e-02f, 1.15500152e-01f, 8.62463191e-02f, 7.69493058e-02f, 1.07431747e-01f, 1.33577809e-01f,
  6.36552349e-02f, 1.16734497e-01f, 6.42361343e-02f, -1.57424554e-01f, -1.35891944e-01f, -1.68732703e-02f, -1.96295679e-02f, -3.55904810e-02f, 9.71080661e-02f, -9.69295278e-02f,
  -1.44173518e-01f, 2.22752392e-02f, 4.77914885e-02f, -1.47898039e-02f, -1.66758969e-02f, 4.12659310e-02f, -5.54933846e-02f, 1.23784959e-01f, -3.17633189e-02f, 2.78466493e-02f,
  -6.82620034e-02f, 1.08984876e-02f, -1.53340548e-01f, -6.96331039e-02f, -6.65886775e-02f, -1.50218820e-02f, -2.67297365e-02f, -1.13636494e-01f, -9.09716710e-02f, -4.72447351e-02f,
  -1.19488217e-01f, 2.30273962e-01f, 1.55123502e-01f, 1.39376506e-01f, -2.18111780e-02f, 8.73137265e-03f, 9.70236510e-02f, 9.04970095e-02f, -7.57354423e-02f, 1.78580523e-01f,
  -2.25480255e-02f, 5.55448569e-02f, 2.93057095e-02f, 2.22293045e-02f, -3.39592546e-02f, -8.61385390e-02f, -6.53656200e-03f, 1.68561399e-01f, 2.74751037e-01f, 3.06261238e-02f,
  -6.88431039e-02f, -1.53628103e-02f, 6.06247261e-02f, 6.15562610e-02f, 7.26727024e-02f, -7.05368817e-02f, -9.51334238e-02f, -9.60991485e-04f, -1.91478916e-02f, -1.30382538e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  3.09718609e-01f, 7.04440922e-02f, 8.48169252e-02f, -3.80398259e-02f, 1.94392636e-01f, -2.46859938e-01f, 3.80735874e-01f, 1.17393412e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  5.49776964e-02f, 6.77571371e-02f, -1.11589879e-01f, 8.07661787e-02f, 1.49083540e-01f, 9.02912691e-02f, 1.75138801e-01f, -2.23893300e-01f, -1.11224074e-02f, -2.22072322e-02f,
  -6.67419378e-03f, 1.46441773e-01f, 3.77029419e-01f, -6.14320859e-02f, -1.39162689e-02f, -6.08729273e-02f, 5.53060584e-02f, 3.76504004e-01f, 1.58873722e-01f, 1.84442639e-01f,
  -3.10219705e-01f, -5.25996804e-01f, 5.57932436e-01f, 3.14387858e-01f, 1.71178132e-01f, -1.09593250e-01f, -3.65025818e-01f, -1.69272453e-01f, 9.55862403e-02f, 1.46425948e-01f,
  1.68826908e-01f, 8.56187642e-02f, -4.77829367e-01f, -9.30121019e-02f, -6.44397875e-03f, -6.60031885e-02f, -1.31593019e-01f, -1.55151099e-01f, 9.43659842e-02f, 1.24788135e-01f,
  8.13569278e-02f, -4.35291618e-01f, -1.03653386e-01f, -1.01168416e-01f, 3.00207343e-02f, 6.68499097e-02f, 2.12620258e-01f, 1.05210356e-01f, 2.08641604e-01f, -6.95548998e-03f,
  -3.44996661e-01f, -1.96946308e-01f, 1.39587549e-02f, 2.93271020e-02f, -3.00692290e-01f, -1.62445262e-01f, -1.34841010e-01f, -1.77142590e-01f, 5.55626988e-01f, 2.30075702e-01f,
  2.63385713e-01f, 1.23400435e-01f, -1.92474589e-01f, -1.00974821e-01f, 3.45820710e-02f, -2.75963936e-02f, -2.86253002e-02f, -5.34710661e-02f, 1.43855261e-02f, -8.68871808e-02f,
  -7.49060586e-02f, -1.66731775e-02f, 8.82853195e-02f, -1.70742914e-01f, -4.16523993e-01f, -3.65009997e-03f, 1.62887022e-01f, -8.94526765e-02f, -1.06889829e-02f, 2.83218622e-02f,
  1.10143788e-01f, 1.12085879e-01f, 1.41695961e-01f, -7.68801793e-02f, -2.59894967e-01f, -2.48804241e-01f, 3.54860038e-01f, 2.05901504e-01f, -1.68605372e-01f, 2.31231358e-02f,
  2.14167461e-01f, 3.46664101e-01f, 2.28013083e-01f, -1.94245741e-01f, 3.19755107e-01f, 8.73334929e-02f, -1.38666764e-01f, 1.26110852e-01f, -3.11489217e-02f, 7.87486434e-02f,
  2.12622046e-01f, -1.95728108e-01f, 1.56840578e-01f, -1.40172010e-03f, -3.95128965e-01f, 1.15809366e-01f, 3.07988981e-03f, 1.20787703e-01f, -1.98447630e-01f, -1.71635207e-02f,
  -6.41486496e-02f, -2.35909611e-01f, 1.33084580e-01f, 4.83660936e-01f, 1.28068611e-01f, -8.84370431e-02f, 3.31536859e-01f, -6.54754400e-01f, 2.14149281e-01f, -3.84839177e-01f,
  2.79496741e-02f, -1.59741696e-02f, -2.32225955e-01f, -1.39690533e-01f, -1.83189496e-01f, 3.34946394e-01f, 8.63675699e-02f, -1.49340779e-01f, 6.14667349e-02f, 7.61052147e-02f,
  -5.31592891e-02f, 6.90148845e-02f, 1.14537321e-01f, -5.28960638e-02f, -3.13281417e-02f, 9.46330652e-02f, 3.13799940e-02f, 9.86549035e-02f, -4.76024412e-02f, 1.59128934e-01f,
  2.65288800e-02f, 4.07002792e-02f, -1.20646343e-01f, -4.79754880e-02f, -2.72612963e-02f, 1.67260200e-01f, 1.26072884e-01f, 1.98405847e-01f, -8.27458575e-02f, -3.15176658e-02f,
  1.65138870e-01f, 1.14340670e-01f, -3.08980733e-01f, -2.21361578e-01f, 3.70064497e-01f, 2.38969490e-01f, -1.78825125e-01f, -4.55086604e-02f, 3.37038964e-01f, -1.68026939e-01f,
  -1.70244440e-01f, 7.45504871e-02f, -2.25680135e-03f, 1.00004859e-01f, 1.62181407e-01f, -2.97966748e-01f, 1.26166984e-01f, 2.85062760e-01f, -2.71833301e-01f, 8.12432989e-02f,
  -8.74184370e-02f, 5.82379587e-02f, -4.70901310e-01f, 4.12593922e-03f, -4.18316573e-02f, -1.03391193e-01f, 6.90521970e-02f, 3.28755021e-01f, -2.17487723e-01f, 1.43361479e-01f,
  -8.81465226e-02f, -1.21743113e-01f, -7.11028054e-02f, -7.24108741e-02f, 7.70996660e-02f, -1.80338293e-01f, 3.57887079e-03f, -1.66519850e-01f, 1.68650836e-01f, 3.73095453e-01f,
  -4.39549200e-02f, 1.67275481e-02f, 1.70163259e-01f, 4.10941131e-02f, -4.92459685e-02f, -1.00627661e-01f, 1.26144379e-01f, 1.55178353e-01f, 2.23831199e-02f, -3.39784026e-01f,
  4.58033457e-02f, -2.62383576e-02f, 1.98690698e-01f, 4.42392565e-02f, 3.82680237e-01f, -3.99164036e-02f, 4.42505851e-02f, -1.68143988e-01f, -6.85503781e-02f, -4.71242182e-02f,
  3.97790909e-01f, -1.16427958e-01f, 1.05498835e-01f, -2.38352641e-01f, 4.04772878e-01f, 5.97120188e-02f, 3.52520257e-01f, 1.87268674e-01f, -6.24302864e-01f, 6.35374198e-03f,
  3.64227593e-02f, -2.96372801e-01f, -2.74008244e-01f, -1.35217667e-01f, 9.71867740e-02f, 1.53597981e-01f, -1.27435595e-01f, 7.22571388e-02f, 1.10656306e-01f, 3.16881686e-02f,
  1.98555455e-01f, 1.41432703e-01f, 4.14504975e-01f, 7.40710124e-02f, 1.57942235e-01f, 4.13703695e-02f, -1.38422832e-01f, -7.24845752e-02f, -4.47124615e-02f, -1.24984391e-01f,
  1.26552403e-01f, 1.12733243e-04f, 1.42437813e-03f, 3.02479118e-02f, -5.27225062e-02f, -3.81090462e-01f, -8.27411115e-02f, -1.55151024e-01f, 5.47441542e-01f, 1.67099699e-01f,
  -2.93356981e-02f, -2.64298409e-01f, 1.45119324e-01f, 2.02375308e-01f, -4.70561624e-01f, 2.71733314e-01f, 3.28772843e-01f, 6.39143959e-02f, -7.05314428e-02f, -7.04891607e-02f,
  2.23434642e-01f, 2.02234238e-01f, -1.49125129e-01f, -1.25556245e-01f, 1.49666462e-02f, 3.91299948e-02f, 1.10257499e-01f, 8.65754038e-02f, 6.67262301e-02f, 5.95944896e-02f,
  -1.19417004e-01f, -6.30271481e-03f, -2.76893154e-02f, -1.11760393e-01f, 1.36171907e-01f, 1.37546612e-02f, -1.76104501e-01f, 3.20397466e-02f, 1.28747851e-01f, -1.76463667e-02f,
  4.63293046e-02f, 2.17584729e-01f, -3.21430773e-01f, -1.58134103e-01f, -1.34748757e-01f, -4.88950498e-02f, -4.74960804e-02f, -1.86677668e-02f, -1.40400752e-01f, 1.07707217e-01f,
  -3.03090978e-02f, -8.42128545e-02f, -1.44218326e-01f, -2.54102591e-02f, 4.25861962e-02f, 2.37632226e-02f, 1.81750804e-02f, -2.09794760e-01f, -1.74062680e-02f, -2.82956779e-01f,
  -7.80259743e-02f, 1.12630397e-01f, -1.59258128e-03f, 1.28994286e-02f, -7.87848979e-02f, -2.27432445e-01f, -2.01954082e-01f, 1.10520005e-01f, -1.38196185e-01f, 3.04884732e-01f,
  -2.19531283e-01f, -1.90512404e-01f, 1.35254055e-01f, 3.12694371e-01f, -2.44723484e-01f, -3.08193833e-01f, 9.58483368e-02f, -1.61474705e-01f, -3.29664528e-01f, 3.65256332e-02f,
  -3.07243437e-01f, -8.80928338e-02f, 9.02368948e-02f, 1.82005689e-01f, 1.50814289e-02f, -1.67775050e-01f, 1.10750943e-01f, 1.68808758e-01f, -5.01798503e-02f, -8.42304379e-02f,
  -2.48050824e-01f, 3.10728699e-02f, -2.43998785e-03f, 1.27618089e-01f, 1.02006935e-01f, 1.02606729e-01f, 2.30012402e-01f, 2.15251967e-01f, -1.05698377e-01f, -2.09369421e-01f,
  2.31486157e-01f, -4.98712182e-01f, -6.75867498e-02f, -1.93565756e-01f, -8.64688829e-02f, -6.02327958e-02f, -1.90465763e-01f, -6.61591515e-02f, 2.52719313e-01f, 1.18119471e-01f,
  1.17013939e-01f, -2.26485074e-01f, -1.79614678e-01f, 4.28917892e-02f, -5.73973358e-02f, 5.01140878e-02f, 7.38099441e-02f, 7.36605525e-02f, 1.88291967e-01f, 1.13825789e-02f,
  -3.60027398e-03f, 1.31992072e-01f, -7.33061135e-02f, 4.49100100e-02f, -5.22475317e-02f, 2.09809333e-01f, 1.36354694e-03f, 5.52516133e-02f, 2.78768212e-01f, -9.71274823e-03f,
  2.32053086e-01f, -1.18568741e-01f, 1.83858862e-03f, -3.59408915e-01f, 1.11938650e-02f, 1.16203927e-01f, -1.20557666e-01f, -2.48202533e-01f, -4.13802236e-01f, 5.31943254e-02f,
  -9.88955572e-02f, -1.20489150e-01f, 4.00805384e-01f, 1.84405029e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.21576689e-01f, 1.78033337e-01f, 9.93668512e-02f, 2.85126179e-01f, 3.31033856e-01f, 2.45922312e-01f, 1.75304383e-01f, 3.80955726e-01f, -1.49865419e-01f, 3.27254236e-01f,
  1.02448612e-01f, 3.23488355e-01f, -4.73974973e-01f, 1.39429629e-01f, 1.50813401e-01f, -8.25101286e-02f, -9.31724459e-02f, -9.17753950e-02f, -3.06771815e-01f, -3.49420965e-01f,
  5.67603648e-01f, 5.76795697e-01f, -4.99980384e-03f, 1.37938425e-01f, -3.45516384e-01f, 2.59308070e-01f, 8.31504583e-01f, -2.05212712e-01f, 6.41107738e-01f, 6.36326313e-01f,
  2.15843827e-01f, -4.22538668e-01f, 1.89169079e-01f, -2.20232885e-02f, 1.00461310e-02f, 1.18970424e-01f, -1.37343081e-02f, 2.22373024e-01f, -1.98042914e-01f, -1.52497739e-01f,
  3.44835460e-01f, -1.80785894e-01f, 2.62445062e-01f, -5.62567897e-02f, 1.53707579e-01f, -5.49196452e-02f, -4.61466685e-02f, -8.65252223e-03f, -2.55530119e-01f, -9.78812054e-02f,
  -2.88146734e-01f, 2.16311559e-01f, -2.59221077e-01f, 5.71722150e-01f, -8.24585781e-02f, 2.61123598e-01f, 4.23566401e-01f, 6.53670251e-01f, 3.95544916e-01f, 2.64210701e-01f,
  -1.67023033e-01f, 3.58667374e-02f, 1.22276440e-01f, -8.53431299e-02f, -3.97376381e-02f, 4.43783179e-02f, 8.45831931e-02f, 2.38369629e-01f, -2.73307264e-01f, 1.27660438e-01f,
  2.08230779e-01f, 4.98847365e-02f, 7.62193441e-01f, 9.74165723e-02f, -3.47510129e-01f, 1.77353650e-01f, 3.01452786e-01f, 8.42560828e-02f, 4.19574566e-02f, 2.15970129e-01f,
  4.82748926e-01f, -1.17816664e-01f, 1.65951341e-01f, 7.02379495e-02f, -3.94621521e-01f, -3.27471823e-01f, 7.37828761e-02f, 7.04484209e-02f, 2.64062285e-01f, -5.80369588e-03f,
  -4.90383303e-04f, 2.62056775e-02f, 1.38688087e-01f, -4.63213265e-01f, 4.35351104e-01f, 1.07510671e-01f, 3.13350350e-01f, 1.44036233e-01f, -8.46530125e-02f, 2.01821834e-01f,
  -3.44866775e-02f, 6.33571893e-02f, -7.60487914e-02f, 2.40459703e-02f, 4.03057426e-01f, -2.38132596e-01f, -3.38411517e-02f, 6.80813566e-02f, 2.20893681e-01f, 7.73738697e-02f,
  6.79646339e-03f, 1.72611862e-01f, -9.55952331e-02f, -6.54254630e-02f, -2.64905006e-01f, 1.76139876e-01f, -2.35051706e-01f, 7.08904445e-01f, -1.01393409e-01f, 4.69723672e-01f,
  1.29373938e-01f, -1.78031683e-01f, 6.88425481e-01f, 1.58490073e-02f, 2.32242525e-01f, -8.92053246e-02f, 6.92258105e-02f, -3.94539177e-01f, -4.74445336e-03f, 8.17851499e-02f,
  -9.35810506e-02f, 1.82799011e-01f, 1.73930556e-01f, 1.54705405e-01f, 5.51724359e-02f, 2.31199354e-01f, 6.00283504e-01f, 1.93484306e-01f, -1.07378718e-02f, 3.89937073e-01f,
  8.36785436e-02f, 4.35008630e-02f, -7.34657124e-02f, 9.00472477e-02f, -2.37309281e-02f, -8.95905644e-02f, 5.27255796e-02f, 7.95655474e-02f, 3.27039659e-02f, -3.63343418e-01f,
  -2.51789242e-01f, -4.84560393e-02f, 9.38350439e-01f, 7.16546774e-02f, -2.54918039e-01f, 2.16716558e-01f, 1.78619087e-01f, -3.88653010e-01f, 1.41051244e-02f, 1.32194519e-01f,
  1.65566295e-01f, 1.10533065e-03f, 2.06455719e-02f, 5.41924722e-02f, -2.01502070e-02f, 3.06961052e-02f, 1.49536327e-01f, 4.85887527e-02f, 1.67976320e-01f, 1.03219442e-01f,
  -1.27433389e-01f, 3.12974036e-01f, 2.47722324e-02f, -6.54784068e-02f, 9.94404778e-03f, 1.37860745e-01f, -2.34508619e-01f, 6.98300898e-02f, -1.13678135e-01f, 2.60672152e-01f,
  -1.40316814e-01f, 9.86408070e-02f, 1.17648251e-01f, 2.25626662e-01f, -3.65884930e-01f, 5.10547578e-01f, 4.46294099e-01f, 7.10599199e-02f, -9.50213969e-01f, -5.98423898e-01f,
  -1.67663425e-01f, 1.82866424e-01f, -3.61902297e-01f, 3.74255516e-02f, 7.39077032e-02f, -4.09370437e-02f, 7.70812854e-02f, -1.74712479e-01f, -1.56506106e-01f, 1.34799063e-01f,
  -2.72676647e-01f, 5.42226620e-02f, -1.22465402e-01f, 4.94470261e-02f, -2.28749156e-01f, -8.83215740e-02f, 8.13133344e-02f, -4.11631614e-02f, -6.76022470e-02f, 3.01702619e-01f,
  -1.90047935e-01f, 6.52667359e-02f, -8.14777911e-02f, -9.90187377e-02f, -2.91006058e-01f, -7.46240616e-02f, 3.43427867e-01f, -1.58627573e-02f, 6.95351183e-01f, 3.80980432e-01f,
  -2.04676673e-01f, 1.54521437e-02f, -6.41175985e-01f, 1.81185097e-01f, 4.05668050e-01f, 7.08120465e-02f, 9.09672007e-02f, 9.48366821e-02f, 2.96101630e-01f, 2.07565129e-01f,
  -5.70101254e-02f, 1.22598425e-01f, 2.43061870e-01f, 3.54162514e-01f, 4.46719630e-03f, 3.73872191e-01f, 2.80654579e-01f, 7.01792985e-02f, 2.93353423e-02f, -5.96893579e-03f,
  2.88100004e-01f, 2.37720143e-02f, 5.85012436e-01f, -8.83435681e-02f, -9.69599709e-02f, -2.71572560e-01f, 4.73376721e-01f, -1.51128252e-03f, 5.39252488e-03f, -4.13183659e-01f,
  -2.08531514e-01f, 2.91538835e-01f, 1.04261808e-01f, -5.32506466e-01f, 8.30715656e-01f, -2.09736347e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.81371704e-01f, 1.44785836e-01f, -1.56774059e-01f, -1.04033753e-01f, 4.08790708e-02f, 1.71481922e-01f, 9.53895524e-02f, 1.47676751e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  3.04620355e-01f, -2.24849969e-01f, 4.86724645e-01f, -1.15456961e-01f, -4.02616143e-01f, 4.11472321e-02f, 3.00288767e-01f, -3.76762211e-01f, -3.66960280e-02f, 8.81597027e-02f,
  1.58058703e-01f, 3.44680220e-01f, -8.48148391e-02f, -2.92519689e-01f, 2.68266108e-02f, 2.27850810e-01f, -3.06021422e-01f, 1.59068644e-01f, 3.69539373e-02f, -7.03140140e-01f,
  4.90290463e-01f, -3.06603629e-02f, -2.81573147e-01f, 3.73694718e-01f, -2.20742658e-01f, 1.16539225e-01f, -2.33301207e-01f, -2.39448607e-01f, 7.54724890e-02f, -2.21291050e-01f,
  -1.12674132e-01f, 2.16587365e-01f, -4.90945995e-01f, 4.22359854e-02f, 9.75112489e-04f, -8.15308690e-02f, 3.55204731e-01f, -1.27792954e-01f, 6.49178922e-02f, -3.71443182e-01f,
  1.16721496e-01f, -1.98049501e-01f, -4.12148803e-01f, -3.78300995e-01f, 1.50059223e-01f, 1.31832317e-01f, 2.19917074e-01f, 4.76583987e-01f, -1.74803659e-01f, -7.61820301e-02f,
  1.60475284e-01f, -1.31645977e-01f, -1.29843488e-01f, -4.53894287e-02f, 1.12688236e-01f, 4.95942496e-02f, 5.43914773e-02f, -1.61973938e-01f, 2.15836987e-01f, -3.50860596e-01f,
  9.50846374e-02f, 4.49504077e-01f, 4.39201951e-01f, -1.20037988e-01f, -2.56673813e-01f, 3.39898020e-01f, -9.50749516e-02f, -4.31423992e-01f, 8.97433236e-02f, -1.71796605e-01f,
  5.15803456e-01f, 1.72668368e-01f, -3.12770600e-03f, 7.30687529e-02f, 1.40486360e-01f, 3.51785012e-02f, -5.96764572e-02f, -1.63755536e-01f, 8.88744071e-02f, 6.05786443e-01f,
  3.83182466e-01f, 1.34882033e-01f, 1.51390955e-02f, 8.71886909e-02f, -1.36614829e-01f, -1.78768381e-01f, 3.33364010e-01f, 1.07251942e-01f, 7.01463744e-02f, -2.54588544e-01f,
  -1.86918806e-02f, -4.06570882e-01f, 3.60819101e-02f, -1.40915424e-01f, 4.12017405e-01f, -1.42889190e-02f, 3.12673867e-01f, -1.80024773e-01f, 2.90784597e-01f, 1.26141191e-01f,
  -4.59363721e-02f, 7.84603953e-02f, 3.00591677e-01f, -3.53283674e-01f, 2.44624808e-01f, 2.61176735e-01f, 6.76767111e-01f, 5.40122986e-01f, -4.86133061e-02f, -6.08156249e-03f,
  -5.44135749e-01f, 5.00387967e-01f, -3.94021422e-01f, 3.21213156e-01f, 2.44645894e-01f, -5.06323688e-02f, 3.89948100e-01f, 2.10304484e-02f, 6.06578439e-02f, -1.23660050e-01f,
  1.18618935e-01f, 1.76470846e-01f, -1.66962892e-01f, -1.21863849e-01f, -6.20509149e-04f, -3.17034543e-01f, -1.24663554e-01f, -9.17807370e-02f, -2.52520889e-01f, 3.16831946e-01f,
  3.31283920e-02f, -4.10827667e-01f, -1.76541805e-02f, 2.07682773e-01f, 3.63998979e-01f, -2.53605068e-01f, 1.12658858e-01f, -1.33126214e-01f, -3.52049470e-02f, 3.54650877e-02f,
  2.89373875e-01f, -1.80185094e-01f, -8.50570425e-02f, 3.82468998e-01f, 5.97152635e-02f, 1.82042807e-01f, 1.93192080e-01f, -2.09789857e-01f, -2.86190864e-02f, -4.46243584e-01f,
  -1.92509480e-02f, 3.11089665e-01f, 1.55527383e-01f, -3.34274769e-01f, -1.24867007e-01f, -4.93824154e-01f, 1.74105257e-01f, -1.05619512e-01f, 6.33322373e-02f, -1.39713213e-01f,
  1.22089230e-01f, -2.06198841e-01f, -3.28970179e-02f, -9.53368843e-02f, -3.06583226e-01f, 1.08844839e-01f, 4.09038216e-02f, -4.56268579e-01f, 7.30652064e-02f, 5.76018989e-01f,
  2.03680471e-01f, 2.49349147e-01f, -1.89974889e-01f, 2.73271739e-01f, -4.13846046e-01f, -1.47470430e-01f, -1.02444388e-01f, 3.61172318e-01f, -1.65729716e-01f, -3.72557849e-01f,
  -2.82748882e-02f, -2.74338648e-02f, -1.65029705e-01f, 1.24326922e-01f, -1.05747193e-01f, 7.10522160e-02f, 2.70514674e-02f, -3.79403867e-02f, 2.44893402e-01f, 1.05874613e-01f,
  7.13947266e-02f, -3.61939728e-01f, -1.89256102e-01f, 5.69470413e-02f, 1.22107983e-01f, 2.14835145e-02f, -2.46795174e-02f, -5.11146933e-02f, 1.85377002e-01f, -4.92260665e-01f,
  2.60686010e-01f, 9.41740498e-02f, 2.74945404e-02f, 1.40438661e-01f, 1.98381424e-01f, -3.09854932e-02f, -2.45744675e-01f, 3.92531455e-01f, 8.26302394e-02f, 4.65298772e-01f,
  3.54117006e-02f, -2.03201652e-01f, -1.42336547e-01f, 5.66197708e-02f, -6.62391819e-03f, 8.80155265e-02f, 3.41769636e-01f, -1.07211642e-01f, 8.60572755e-02f, -3.76488298e-01f,
  1.75910696e-01f, -1.22768976e-01f, -6.05886616e-02f, -3.73499960e-01f, -2.99800426e-01f, 1.17689513e-01f, 8.32768995e-03f, -1.90195069e-01f, -1.10485004e-02f, -2.20950723e-01f,
  8.44344199e-02f, -5.10429621e-01f, -8.10678862e-03f, 2.63730854e-01f, -2.62251981e-02f, -3.44522088e-03f, -5.04241362e-02f, -3.38632502e-02f, -3.38559270e-01f, 1.97508901e-01f,
  -7.37790540e-02f, 6.12059832e-01f, -4.12801355e-01f, -1.27120674e-01f, 7.51567772e-04f, 5.88483624e-02f, 1.21113338e-01f, 1.79927296e-03f, 8.65833238e-02f, -2.89136350e-01f,
  7.76746199e-02f, -1.93230689e-01f, -2.62139700e-02f, -3.09203327e-01f, -2.17059061e-01f, -3.43599319e-01f, 3.28553975e-01f, -2.02446431e-01f, -4.20339942e-01f, -1.25492930e-01f,
  -4.66558605e-01f, 1.38700217e-01f, -1.06264791e-02f, -5.82912803e-01f, -5.09544015e-01f, 1.96202263e-01f, 8.72672647e-02f, -1.50792137e-01f, -9.44375545e-02f, 3.43965828e-01f,
  7.92628601e-02f, -3.26320738e-01f, -4.41853367e-02f, 1.66570976e-01f, -4.25988406e-01f, -2.08921134e-01f, 6.06002547e-02f, 3.14560652e-01f, -2.86249608e-01f, 5.18438593e-02f,
  -1.15309775e-01f, 1.55062862e-02f, 1.32148817e-01f, 4.28143889e-03f, 2.84582376e-01f, 8.63086432e-02f, 2.40360692e-01f, -3.10104102e-01f, 1.87860489e-01f, -3.64665657e-01f,
  2.77144700e-01f, 1.50666118e-01f, 8.35462436e-02f, 1.74941704e-01f, -3.83380771e-01f, -6.42425835e-01f, 1.94460992e-02f, 2.48860523e-01f, -1.62250809e-02f, -8.58397596e-03f,
  -1.64830655e-01f, 5.10646880e-01f, -4.19909477e-01f, -1.06209412e-01f, -3.52151304e-01f, 3.10962468e-01f, 4.40460804e-04f, -2.15127796e-01f, 2.90070206e-01f, -1.36078089e-01f,
  1.07161947e-01f, -1.24725491e-01f, 7.36186504e-02f, 2.49552175e-01f, 5.81690669e-02f, 3.88535589e-01f, 1.80170670e-01f, -2.21805468e-01f, -2.09955752e-01f, -1.35341540e-01f,
  -4.18126732e-01f, 1.95900932e-01f, -3.49528521e-01f, -4.02703993e-02f, 2.51336575e-01f, -1.03956282e-01f, -1.56048670e-01f, 4.47935700e-01f, -1.45811588e-01f, -2.62402624e-01f,
  -5.70557266e-02f, -1.62379637e-01f, -1.75801277e-01f, 2.89534330e-01f, 2.93887794e-01f, -6.25479296e-02f, 6.16597116e-01f, 5.68249673e-02f, -9.35908034e-02f, 8.41389522e-02f,
  -3.76693666e-01f, -1.26047656e-01f, 2.95191389e-02f, 2.34293237e-01f, 1.80107221e-01f, -1.59522608e-01f, 1.01889826e-01f, 1.79616556e-01f, 2.75406390e-01f, -2.42818549e-01f,
  5.71628213e-02f, -9.35340114e-03f, 3.89986455e-01f, -4.27562883e-03f, 2.27836013e-01f, -5.10684587e-02f, -3.90031129e-01f, 1.70234531e-01f, -8.92114360e-03f, -4.34409320e-01f,
  -6.60830270e-03f, 3.61346677e-02f, 3.51339310e-01f, 2.29990691e-01f, 1.90669492e-01f, -3.31114054e-01f, -6.64410949e-01f, 3.38172287e-01f, -2.84598231e-01f, 3.98544043e-01f,
  1.15970755e-02f, -4.11626190e-01f, 2.14996532e-01f, 2.48822153e-01f, 2.52373256e-02f, -1.55991152e-01f, 6.32497370e-02f, -1.08122192e-01f, -1.93418950e-01f, -2.65974849e-01f,
  -2.89946925e-02f, 1.27283707e-01f, -1.46458879e-01f, -1.23570785e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -2.29248449e-01f, -5.31769656e-02f, -5.41790389e-02f, 5.18459320e-01f, -9.25631076e-02f, 5.14567196e-01f, 3.21799159e-01f, -1.61053002e-01f, 6.88901126e-01f, 2.54966736e-01f,
  -3.91922981e-01f, 4.11539115e-02f, 4.07985657e-01f, -3.38045388e-01f, 2.31830537e-01f, -2.18816057e-01f, -4.61508155e-01f, -2.24948317e-01f, 8.13468993e-01f, 2.25800648e-02f,
  6.11798942e-01f, 2.09560499e-01f, -7.26313591e-01f, 6.47772849e-02f, -4.50406343e-01f, 7.79739201e-01f, 3.58543426e-01f, 1.76856443e-01f, 6.41441226e-01f, 5.06911457e-01f,
  4.50893492e-01f, 1.40545711e-01f, 9.80172455e-01f, 3.60658854e-01f, 8.85344625e-01f, 2.58626789e-01f, 3.17685217e-01f, 1.07588388e-01f, 6.90701187e-01f, 1.77154362e-01f,
  4.30331171e-01f, 1.59407064e-01f, 8.60185683e-01f, 3.69223833e-01f, 2.84791112e-01f, -7.27800906e-01f, -7.49960780e-01f, 8.92601013e-01f, -2.37735361e-02f, 3.36596161e-01f,
  2.25247845e-01f, 3.34808409e-01f, 5.02069354e-01f, 3.18565927e-02f, 5.64960390e-02f, -7.19499707e-01f, 7.82558918e-01f, 3.10815156e-01f, -8.85773599e-01f, 4.50742513e-01f,
  -3.35624874e-01f, -1.58241764e-01f, -3.94342132e-02f, -2.54168868e-01f, -1.34546503e-01f, -1.43109828e-01f, 1.81325033e-01f, 3.38611096e-01f, 1.37360290e-01f, -8.93882141e-02f,
  -5.83523273e-01f, 1.98926955e-01f, -8.58520120e-02f, -3.03432733e-01f, 1.15695849e-01f, -2.43890267e-02f, -2.37988129e-01f, 2.05771044e-01f, 2.97590852e-01f, 2.63737917e-01f,
  9.19131935e-01f, 3.35798025e-01f, -1.73539311e-01f, 2.38978311e-01f, -1.70032203e-01f, -2.79084027e-01f, 2.07916468e-01f, -3.97963047e-01f, 6.41619563e-01f, 1.39621645e-01f,
  8.42787474e-02f, 5.86765170e-01f, -1.42798275e-01f, -3.45555484e-01f, 1.79206222e-01f, 4.63762507e-02f, 4.62528318e-02f, 1.63290307e-01f, -5.98950274e-02f, -9.59510952e-02f,
  3.57823461e-01f, -7.11406618e-02f, 8.93975422e-02f, 8.60997021e-01f, -5.36718182e-02f, -3.62943619e-01f, -3.12185913e-01f, 1.94053218e-01f, -4.43905704e-02f, 4.91466314e-01f,
  -4.22096625e-02f, 3.54795784e-01f, 5.18238783e-01f, -7.75598958e-02f, -4.11248505e-01f, 6.96942866e-01f, -3.68485540e-01f, -8.95201921e-01f, 4.02745277e-01f, -1.05745178e-02f,
  9.22011554e-01f, 1.12289034e-01f, -2.93584224e-02f, 1.78765431e-01f, 1.25871852e-01f, 3.33776563e-01f, 4.50437248e-01f, 2.42755953e-02f, -3.35839957e-01f, -1.06457710e-01f,
  2.27213994e-01f, -2.17212051e-01f, 3.62511665e-01f, 4.40860957e-01f, 1.78141311e-01f, 5.36732018e-01f, 4.16845053e-01f, 1.65442035e-01f, 2.00724468e-01f, 2.51124687e-02f,
  4.67374325e-02f, -3.88227761e-01f, 7.42884278e-01f, -7.39082694e-02f, 3.86837929e-01f, 1.10010125e-01f, 4.97215271e-01f, -4.18191761e-01f, 2.41175499e-02f, -6.77175760e-01f,
  2.94623762e-01f, 9.15520608e-01f, -1.90826833e-01f, -8.52532536e-02f, 2.74691164e-01f, -3.07401776e-01f, 1.52570993e-01f, -6.30500555e-01f, 7.59302750e-02f, 9.78876352e-01f,
  -8.34080763e-03f, 2.45318770e-01f, 6.60257740e-03f, -3.92721266e-01f, 4.39608514e-01f, -8.12935531e-01f, 7.35379159e-02f, -4.31364998e-02f, -1.58293471e-01f, -2.01654941e-01f,
  -2.88352638e-01f, -3.57188098e-02f, -4.93648201e-02f, 3.11439693e-01f, -5.04712045e-01f, 1.54798433e-01f, -1.84936188e-02f, 2.91318297e-01f, -8.47382486e-01f, 3.24936777e-01f,
  -3.92241925e-01f, 3.29960175e-02f, 3.27731967e-01f, 2.04061359e-01f, 5.32041550e-01f, -1.22754477e-01f, 3.08636427e-01f, -2.24778831e-01f, -4.38450910e-02f, 7.57921487e-02f,
  -6.37780428e-02f, -1.31825164e-01f, 6.72052801e-01f, 7.50827551e-01f, -4.46505323e-02f, 2.38232493e-01f, 4.18169588e-01f, 3.77434701e-01f, 5.73824167e-01f, -2.58531541e-01f,
  4.47941482e-01f, 4.39895779e-01f, 6.04953349e-01f, 3.82292271e-01f, -1.52122736e-01f, -8.66402090e-02f, -4.57911253e-01f, 2.61813313e-01f, -5.79579175e-01f, 5.96001297e-02f,
  2.14062184e-01f, 5.45720279e-01f, -1.90167636e-01f, -4.96244460e-01f, 6.14425719e-01f, 1.01869134e-02f, 2.60064960e-01f, -3.64521588e-03f, -6.72498494e-02f, -5.67357719e-01f,
  3.29218328e-01f, -1.49692520e-01f, 4.31076229e-01f, -1.98914230e-01f, -2.48879731e-01f, 2.27052703e-01f, 9.41111669e-02f, -1.95205614e-01f, 3.28733116e-01f, 9.73839909e-02f,
  -4.06776331e-02f, 1.60789192e-01f, -2.39702553e-01f, -9.22440290e-02f, -9.90527272e-02f, -8.30986649e-02f, 1.34325400e-01f, 5.45057021e-02f, 2.06450075e-01f, 3.28919530e-01f,
  1.18292175e-01f, 3.15274060e-01f, -2.06850067e-01f, -3.20679718e-03f, -4.12402987e-01f, -4.69796389e-01f, 2.26828024e-01f, 4.36228812e-01f, 1.59263179e-01f, -2.90350448e-02f,
  2.18596682e-01f, -2.82711059e-01f, 4.33516502e-01f, -3.29126656e-01f, -5.64120803e-03f, 7.37912953e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  5.30621231e-01f, 4.49650764e-01f, 7.56128633e-04f, 9.83348191e-02f, 4.22972709e-01f, 2.23855034e-01f, 1.28070757e-01f, 1.31511092e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -2.82984257e-01f, -3.59448195e-02f, -4.12473753e-02f, 2.67749727e-01f, 8.18653777e-02f, -6.39822662e-01f, -3.02895755e-01f, 6.21288180e-01f, -3.90471131e-01f, 4.51405108e-01f,
  -6.83249354e-01f, -3.63514543e-01f, -5.75928614e-02f, 8.48307073e-01f, 7.47437418e-01f, -7.26974308e-01f, 5.92307270e-01f, -2.14415684e-01f, 7.89596617e-01f, 3.83974105e-01f,
  2.51770973e-01f, -6.70340419e-01f, -4.29912388e-01f, -4.20594484e-01f, -4.30341482e-01f, -1.64621532e-01f, 2.29453996e-01f, 2.20838964e-01f, -3.03524315e-01f, 4.77838874e-01f,
  -5.74623108e-01f, 1.45075142e-01f, 5.05702734e-01f, -3.45698237e-01f, -6.42848611e-02f, 3.74338597e-01f, -6.46865070e-02f, -5.00799954e-01f, 1.55005336e-01f, -4.78278577e-01f,
  -3.16699028e-01f, -3.16678695e-02f, -5.13657093e-01f, -6.85358047e-01f, -7.65794635e-01f, 8.98702681e-01f, 7.83677340e-01f, -5.03020227e-01f, 6.21423602e-01f, 2.98631281e-01f,
  1.18339837e-01f, 6.10163175e-02f, 1.89580753e-01f, -1.97639585e-01f, 3.38419497e-01f, 3.48739065e-02f, 4.24547717e-02f, -1.28585231e+00f, -2.09954128e-01f, -3.26717347e-02f,
  3.80773813e-01f, -4.12392139e-01f, 3.13107818e-01f, 2.96255261e-01f, -4.25540894e-01f, -1.32455960e-01f, 3.42960030e-01f, -4.88322347e-01f, -1.16568342e-01f, 5.01543045e-01f,
  -6.78828508e-02f, 8.34032476e-01f, -2.46876404e-02f, -9.85545851e-03f, 4.65365678e-01f, 5.32711446e-01f, 5.20535231e-01f, 9.17746067e-01f, 5.47389865e-01f, 3.06635678e-01f,
  6.61633432e-01f, 6.00237608e-01f, 7.59621561e-01f, -3.05907220e-01f, -7.20921576e-01f, 4.05224860e-01f, -2.28290230e-01f, 3.68641734e-01f, 1.26613481e-02f, -2.95303822e-01f,
  -7.44082093e-01f, -1.22083664e+00f, 6.59325540e-01f, -8.37310627e-02f, -2.20848292e-01f, 3.42025697e-01f, -1.10672146e-01f, -8.94842505e-01f, -5.80852032e-01f, 3.62455845e-01f,
  -5.76020539e-01f, -3.24541964e-02f, -4.65158559e-02f, -3.37862581e-01f, 1.86054498e-01f, -6.11664653e-01f, -4.71212715e-01f, -2.06017327e-02f, 5.93526483e-01f, -4.47633207e-01f,
  -5.50599933e-01f, 5.02356291e-01f, -3.89550388e-01f, -2.71883905e-01f, 2.88539916e-01f, -6.02407694e-01f, -2.63039887e-01f, -6.58876240e-01f, 3.11378539e-01f, -4.77938145e-01f,
  -7.88944185e-01f, 3.36968422e-01f, 5.39078891e-01f, 7.07494542e-02f, -1.03083527e+00f, -1.16409563e-01f, -1.63702518e-01f, -7.99735561e-02f, -2.95621037e-01f, 4.07239228e-01f,
  4.86766510e-02f, -3.56241673e-01f, 3.58705521e-01f, 5.38640559e-01f, -5.67800224e-01f, 6.48490041e-02f, 2.59460863e-02f, 6.34625405e-02f, 4.56918627e-01f, 2.64526963e-01f,
  -6.73729956e-01f, -2.38576502e-01f, 4.74519074e-01f, 5.69859147e-01f, 2.18787402e-01f, -1.82175428e-01f, -1.10400118e-01f, 8.32147181e-01f, -1.86708391e-01f, 6.42531574e-01f,
  4.03511494e-01f, 4.70237285e-01f, -3.53960276e-01f, 1.46038502e-01f, -1.43128172e-01f, 1.39048889e-01f, -9.37671363e-01f, 4.68394011e-01f, 5.02987266e-01f, 1.20519049e-01f,
  3.37024510e-01f, 4.24540520e-01f, 3.45382512e-01f, 3.47124636e-01f, 1.68409541e-01f, -2.87205160e-01f, 6.34966135e-01f, -1.45526811e-01f, -6.10473871e-01f, 3.42609167e-01f,
  6.45714045e-01f, 9.20445085e-01f, 4.92000043e-01f, -8.09193730e-01f, 3.41739416e-01f, 4.33840722e-01f, 4.21459019e-01f, -2.82993913e-01f, 2.15177000e-01f, -3.90236378e-01f,
  1.35285437e-01f, -6.63993001e-01f, -2.56807916e-02f, 1.72459334e-01f, -2.44858414e-01f, 3.88590485e-01f, -2.55824268e-01f, -2.29138415e-03f, 1.10265642e-01f, -2.93844342e-01f,
  2.29684561e-01f, 1.08067589e-02f, -9.54584628e-02f, 3.24543007e-02f, -6.34372592e-01f, 1.39206171e-01f, 2.00391263e-01f, -4.74112809e-01f, 3.55322808e-01f, -7.36460268e-01f,
  -5.09934187e-01f, -5.89490592e-01f, -1.62853628e-01f, 4.82877851e-01f, 5.78418970e-01f, 5.02426982e-01f, 2.67513454e-01f, 6.96251571e-01f, -4.96317416e-01f, 3.61551642e-01f,
  9.47914571e-02f, -3.37870240e-01f, 6.73788309e-01f, -5.40283322e-01f, -3.35554063e-01f, 2.96083719e-01f, 5.36463320e-01f, -8.84943545e-01f, -3.68029326e-01f, -4.85569924e-01f,
  -2.97525465e-01f, -3.11943263e-01f, -6.38891757e-01f, -5.35176575e-01f, -4.46200132e-01f, 1.94203686e-02f, -1.67290539e-01f, -5.09327412e-01f, -5.19947231e-01f, 1.83708087e-01f,
  -3.91452640e-01f, -6.93586022e-02f, 1.11071683e-01f, -2.63209373e-01f, 3.70870680e-01f, -7.52748787e-01f, -2.47174829e-01f, 4.66537952e-01f, -2.78011560e-01f, -3.40635926e-01f,
  1.92926273e-01f, 2.29966983e-01f, -5.11170864e-01f, 3.00939143e-01f, 3.01907927e-01f, 3.00910324e-01f, 4.69200671e-01f, -1.53667629e-02f, 1.85156226e-01f, -2.95462698e-01f,
  1.06101364e-01f, 3.93875778e-01f, -4.08106595e-01f, 1.26742758e-02f, -2.34313920e-01f, -4.36890244e-01f, 1.72703728e-01f, 6.85455045e-03f, -5.33073992e-02f, -1.06159575e-01f,
  3.62829417e-01f, 1.93803236e-01f, -6.52083278e-01f, 2.53960546e-02f, 3.32994282e-01f, 5.33917606e-01f, 5.19510508e-01f, -5.76338172e-01f, 6.99189842e-01f, -8.07304144e-01f,
  -8.15974593e-01f, -7.61082232e-01f, -1.00303519e+00f, -5.67202687e-01f, -6.85895801e-01f, 5.78282952e-01f, -6.98380947e-01f, -5.30090332e-01f, 1.83930993e-01f, -4.39300150e-01f,
  2.22291365e-01f, -6.34972572e-01f, -4.17663842e-01f, -4.05184686e-01f, 4.87684876e-01f, -4.18665484e-02f, -7.70822942e-01f, 1.69521675e-01f, -9.93473269e-03f, -2.86104709e-01f,
  3.99520814e-01f, -2.45714292e-01f, 5.85682213e-01f, -5.84148884e-01f, -3.01067889e-01f, 5.92888653e-01f, 3.17902923e-01f, -4.43482757e-01f, -3.24373901e-01f, -4.11774278e-01f,
  5.69402575e-01f, 8.33769366e-02f, -5.42108178e-01f, -4.49078619e-01f, 4.18448031e-01f, 3.79859060e-01f, 5.97520292e-01f, -4.46847856e-01f, 7.93444037e-01f, 2.08538666e-01f,
  -3.50027472e-01f, 1.74523979e-01f, 1.54837504e-01f, 5.63906372e-01f, -4.71019417e-01f, -7.97035217e-01f, -5.85158467e-01f, -3.45944583e-01f, 6.59498036e-01f, -6.11863792e-01f,
  -6.11210644e-01f, -8.49406347e-02f, 2.29603320e-01f, -3.09903383e-01f, -4.47945744e-01f, 4.82009768e-01f, 1.61267206e-01f, -1.27712097e-02f, 7.13350713e-01f, -2.31077433e-01f,
  -6.41684055e-01f, -5.53490818e-01f, -3.54832441e-01f, -1.02258563e+00f, -7.76495099e-01f, -6.24323249e-01f, -9.56858814e-01f, -6.78639472e-01f, -3.30721587e-01f, -8.57194737e-02f,
  -4.49985653e-01f, 8.40420604e-01f, -4.82062176e-02f, 1.39297619e-01f, -1.03655040e+00f, -8.69679868e-01f, 2.16661587e-01f, 1.08140506e-01f, 1.57304108e-01f, 2.66769737e-01f,
  1.05585538e-01f, 3.01418871e-01f, 5.41592717e-01f, 3.12621176e-01f, -4.63187635e-01f, 5.95848680e-01f, -4.16213810e-01f, 7.74855554e-01f, 3.65624338e-01f, -6.32650793e-01f,
  8.57575715e-01f, 2.78030097e-01f, -1.08709089e-01f, 4.85257179e-01f, -7.04632282e-01f, -5.63610911e-01f, -3.95332485e-01f, 4.05911326e-01f, -5.62925458e-01f, -6.95429370e-02f,
  -7.83679724e-01f, -5.10322712e-02f, -2.68457085e-01f, 5.20207644e-01f, -6.29171252e-01f, -6.58783376e-01f, 1.34238794e-01f, 6.09752417e-01f, -4.02514249e-01f, -5.30606806e-01f,
  -3.02333117e-01f, -3.14452648e-01f, 3.31659429e-02f, -5.27946293e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  6.62463754e-02f, -1.05602555e-01f, 3.41584086e-02f, -2.26382673e-01f, -2.52457887e-01f, 2.71402568e-01f, 2.31342942e-01f, 7.01955939e-03f, -3.03413603e-03f, -6.66836351e-02f,
  4.65506921e-03f, 1.69693187e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    