/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.95194483e-01f, -5.23350894e-01f, -4.77287740e-01f, 1.04283886e-02f, 3.07071339e-02f, 2.68678460e-02f, 1.37929559e-01f, -1.00060664e-01f, 9.62050930e-02f, 7.37787411e-02f,
  3.11742008e-01f, 2.96004806e-02f, 3.18732969e-02f, -1.54696247e-02f, 3.68103176e-01f, 1.06671035e-01f, -9.42217857e-02f, -2.51756068e-02f, 5.12021296e-02f, -1.35074914e-01f,
  1.02120675e-02f, 2.25475580e-01f, -3.06952655e-01f, -1.03082001e-01f, -6.36623874e-02f, -1.23484075e-01f, 1.04787573e-01f, 5.62339537e-02f, -4.55768406e-03f, 1.62639573e-01f,
  -5.20581082e-02f, -1.04074121e-01f, -1.11316010e-01f, -3.22744288e-02f, -7.22930878e-02f, -1.33313304e-02f, -2.25090794e-02f, 6.04013801e-02f, 3.60439345e-02f, -2.90386900e-02f,
  2.29712054e-02f, 8.60830024e-02f, 6.55038729e-02f, 9.26382765e-02f, -3.11727971e-02f, -1.17037535e-01f, -7.61840567e-02f, -3.25468518e-02f, -8.99244472e-02f, -1.96102187e-02f,
  -6.96271136e-02f, -6.23845868e-02f, -2.74318526e-03f, 3.37022953e-02f, 1.45896114e-02f, 3.81587520e-02f, -7.10818917e-02f, -1.20879645e-02f, 8.44682846e-03f, -6.47409856e-02f,
  3.50765847e-02f, 1.12651922e-01f, -5.33645041e-02f, 7.61763752e-03f, 5.13467789e-02f, -2.00908314e-02f, 7.02520683e-02f, 5.73703879e-03f, 3.58743258e-02f, -7.10680243e-03f,
  8.06347504e-02f, -7.48871118e-02f, 2.66819261e-02f, 3.79896350e-02f, 5.90930283e-02f, -5.36526889e-02f, 2.84454934e-02f, 1.16397426e-01f, 4.98037450e-02f, -4.65943106e-02f,
  4.82315682e-02f, 9.07600299e-03f, 9.56081524e-02f, -1.40375225e-02f, 7.52695501e-02f, 1.02434196e-01f, 6.95063323e-02f, -7.88233504e-02f, 5.69644459e-02f, 4.25334312e-02f,
  -1.11831380e-02f, -2.88864225e-02f, -2.35991087e-02f, 9.81300697e-03f, 3.15915160e-02f, -2.31695059e-03f, 1.79756023e-02f, -3.53303924e-02f, 2.28715478e-03f, 6.06138445e-02f,
  -4.34916466e-02f, -4.16571163e-02f, 3.63247357e-02f, 1.11126877e-01f, 6.51390776e-02f, 2.15728749e-02f, 7.59183019e-02f, 8.27476457e-02f, 3.80319729e-02f, 1.94217917e-02f,
  -5.22302799e-02f, -1.98013857e-02f, 7.92365521e-02f, -4.70485492e-03f, -2.46654972e-02f, 1.81413591e-02f, 2.83692628e-02f, 6.22074259e-03f, 4.52274121e-02f, 1.50177823e-02f,
  -4.01934236e-01f, 9.86807793e-03f, 2.10236579e-01f, -1.98595390e-01f, -4.11021799e-01f, 8.78051445e-02f, -1.02110669e-01f, -1.91061959e-01f, -1.97858782e-03f, -3.83439809e-02f,
  -1.27903000e-01f, 4.80007157e-02f, 2.18300760e-01f, -3.22184176e-03f, 1.37373418e-01f, 5.34858167e-01f, -1.19050168e-01f, 5.00604324e-02f, 6.53493255e-02f, -3.42839897e-01f,
  -1.03769518e-01f, -3.26872349e-01f, 6.56285963e-04f, -1.99618965e-01f, -1.71972454e-01f, -1.16847195e-01f, -2.31995508e-01f, 5.01161888e-02f, -1.29875392e-01f, 5.47982045e-02f,
  -8.39476809e-02f, -2.28483975e-02f, 1.37879960e-02f, 1.20057128e-01f, -7.69943967e-02f, -1.16786901e-02f, 9.78705846e-03f, 1.24488920e-01f, -1.53100798e-02f, 1.67512093e-02f,
  1.02521166e-01f, -6.23998009e-02f, -1.06555820e-02f, 1.01196796e-01f, -3.87950353e-02f, 6.98867366e-02f, 1.09167710e-01f, 3.65685411e-02f, -1.35229696e-02f, 7.14729950e-02f,
  7.94757605e-02f, 1.00590155e-01f, -2.58487426e-02f, 3.19157243e-02f, -4.62432913e-02f, 7.72884674e-03f, 1.44655965e-02f, -4.23584506e-02f, 8.20607319e-02f, -1.26058340e-01f,
  6.42201081e-02f, -9.58982781e-02f, 1.17708780e-02f, 4.46882881e-02f, -1.82792395e-02f, -1.60372853e-02f, 7.55529106e-02f, -2.87924949e-02f, 1.93054248e-02f, -5.29112853e-02f,
  -6.55995235e-02f, -4.62979451e-02f, 1.85223613e-02f, 2.10608430e-02f, -1.06597394e-01f, -4.95732352e-02f, 5.48124798e-02f, 5.04392982e-02f, -2.98439246e-02f, -2.10825689e-02f,
  3.07551287e-02f, -3.68054621e-02f, -4.80444580e-02f, 1.30258081e-02f, 5.24661578e-02f, 9.40325111e-03f, 3.56237069e-02f, 4.65027988e-02f, -1.46584436e-02f, 9.90408752e-03f,
  -1.69707119e-01f, -1.69346511e-01f, 2.20233080e-04f, -6.77149221e-02f, 4.43347655e-02f, 4.92114713e-03f, 7.06027821e-02f, 1.48152402e-02f, 8.79540201e-03f, 4.17813882e-02f,
  -6.02277145e-02f, -1.86346788e-02f, -1.20174382e-02f, -3.38136181e-02f, 4.09799721e-03f, -4.35365774e-02f, -2.61349119e-02f, -9.85432565e-02f, -9.88619328e-02f, -7.42338896e-02f,
  -1.33124620e-01f, -9.57016181e-03f, 6.38293624e-02f, -1.27555728e-01f, -2.07675230e-02f, -3.17091011e-02f, -7.26704895e-02f, -6.05423935e-03f, 7.47706741e-02f, 5.28224111e-02f,
  -8.91290233e-03f, -8.08018148e-02f, -6.83665648e-03f, 9.22328457e-02f, 7.76882842e-02f, -3.62335980e-01f, -2.34559372e-01f, 1.18001036e-01f, 4.30598915e-01f, -2.17726961e-01f,
  3.23638320e-02f, -4.78024669e-02f, 9.67702866e-02f, -2.30844051e-01f, 1.26328349e-01f, 1.09340623e-01f, -2.17021972e-01f, -2.00603202e-01f, 1.50694415e-01f, 2.03172509e-02f,
  7.37319365e-02f, 6.65620714e-02f, 1.30275832e-02f, 1.99569792e-01f, -1.53246477e-01f, -3.83286513e-02f, 1.12935282e-01f, 3.08287628e-02f, -2.38692433e-01f, -1.33032933e-01f,
  -1.83948457e-01f, 1.44961298e-01f, -7.19590560e-02f, -4.66060964e-03f, -4.13797144e-03f, -6.78198263e-02f, -2.39675969e-01f, -9.34397727e-02f, 2.67346315e-02f, -4.87965252e-03f,
  -4.29961272e-02f, 7.14404657e-02f, -1.65682640e-02f, 4.22966816e-02f, -1.07486211e-01f, 1.97458938e-02f, 8.83010402e-03f, -8.40904599e-04f, 3.77317593e-02f, -3.41844559e-02f,
  4.93086018e-02f, -6.37052506e-02f, 4.56279442e-02f, -1.31354883e-01f, -3.78966592e-02f, 6.60143718e-02f, -2.94933897e-02f, -7.46274143e-02f, -1.22306786e-01f, 9.61286873e-02f,
  -1.02467522e-01f, 4.87439297e-02f, -3.94256301e-02f, 4.13529426e-02f, 7.29125291e-02f, -1.23531334e-02f, -4.96648960e-02f, -4.37836815e-03f, -2.95480527e-03f, 5.50517328e-02f,
  3.42468955e-02f, -3.02166436e-02f, -1.28041534e-02f, -1.08256321e-02f, 6.53473884e-02f, 6.09935552e-04f, 1.50619652e-02f, 2.56974455e-02f, -3.55892815e-02f, 8.27299282e-02f,
  9.81443152e-02f, -1.93529529e-03f, 1.58845484e-02f, -1.22476824e-01f, -6.73316512e-03f, 6.79528341e-02f, 1.40070179e-02f, -6.56760391e-03f, 2.45612562e-02f, -1.39288316e-02f,
  -7.02206697e-03f, 9.31119546e-02f, 4.54606451e-02f, -5.16188592e-02f, 2.27619875e-02f, 3.32099795e-02f, 2.70970501e-02f, -4.17002290e-02f, 6.37853369e-02f, 5.31137325e-02f,
  -3.23025584e-02f, -4.17095125e-02f, -4.20456715e-02f, -3.54954861e-02f, 6.74428791e-03f, 7.77002797e-02f, 1.77642535e-02f, -3.09649296e-02f, -8.27128161e-03f, -2.36069858e-02f,
  -8.51357996e-04f, -8.71677026e-02f, -4.96899448e-02f, 1.68805420e-02f, -7.54875913e-02f, -3.48930396e-02f, 5.08405939e-02f, -3.09320521e-02f, -4.66421694e-02f, -2.61753183e-02f,
  5.58305919e-01f, -4.50307764e-02f, -5.18795066e-02f, 3.83866727e-01f, -5.19202650e-03f, 4.01046872e-01f, 2.63573647e-01f, 9.16808769e-02f, 1.58688471e-01f, -2.35505830e-02f,
  1.68650642e-01f, 5.02579194e-03f, -1.40782192e-01f, 3.97900075e-01f, 3.29057395e-01f, -4.96400967e-02f, 4.41704392e-01f, 1.45359680e-01f, -2.87667699e-02f, 1.08501859e-01f,
  9.72367674e-02f, 2.09394708e-01f, 8.49333704e-02f, -9.13078561e-02f, 8.99663195e-02f, -1.12390563e-01f, -5.06126732e-02f, -2.28671461e-01f, 1.38698429e-01f, -6.61527365e-03f,
  5.87882660e-02f, -4.49727401e-02f, -1.03003578e-02f, 3.88276414e-04f, 8.03909153e-02f, -2.09012087e-02f, 1.65758387e-03f, -6.46922961e-02f, -1.18207196e-02f, 3.35601158e-02f,
  -1.91623494e-02f, 7.59798056e-03f, 4.95372005e-02f, -7.98317939e-02f, 4.63740379e-02f, -7.08925631e-03f, 3.21862064e-02f, 2.79146247e-02f, -2.16726251e-02f, 2.59104501e-02f,
  8.90545707e-05f, 4.56571952e-02f, 9.81217697e-02f, -5.76394890e-03f, -2.93729380e-02f, -1.15068578e-04f, 2.73957718e-02f, -6.31137043e-02f, 1.70424080e-03f, 5.33069223e-02f,
  3.18074338e-02f, 2.38107592e-02f, 3.04112788e-02f, 5.75634884e-03f, 3.01938001e-02f, -2.54185963e-02f, 1.35655720e-02f, -7.89227616e-03f, -1.08973077e-02f, 3.53836305e-02f,
  3.24454270e-02f, 4.25729044e-02f, 3.99114601e-02f, 5.19094877e-02f, 6.48740232e-02f, -1.96572691e-02f, -2.86144074e-02f, -3.75223868e-02f, 4.99274097e-02f, 8.81559588e-03f,
  -4.32412513e-02f, 3.42937708e-02f, -8.67866259e-03f, -8.38833861e-03f, 6.75179577e-03f, -1.78654809e-02f, -9.51410562e-04f, 3.51106785e-02f, 2.03724531e-03f, 4.89943065e-02f,
  3.02204341e-02f, 1.21375928e-02f, -3.05048358e-02f, -1.51406135e-02f, -8.95784199e-02f, 6.04903325e-02f, 1.71337575e-02f, 2.42493320e-02f, -1.03268176e-02f, 2.59073102e-03f,
  6.52086362e-02f, -1.72025338e-02f, -3.05292048e-02f, 8.06104112e-03f, -4.12539318e-02f, 3.58900465e-02f, -1.94412693e-02f, -4.48121615e-02f, 5.39023764e-02f, 4.62142266e-02f,
  1.00217201e-02f, -1.83236487e-02f, -3.05755716e-02f, -3.34948255e-03f, 1.94619279e-02f, 4.58687777e-03f, 3.61647680e-02f, 4.52398229e-03f, -1.07354457e-02f, -1.07082035e-02f,
  6.26750469e-01f, -9.99421477e-02f, 2.18580082e-01f, 5.47924489e-02f, -5.24435565e-02f, -8.80443156e-02f, 7.97702149e-02f, -1.26958251e-01f, 2.55133212e-01f, -1.88199222e-01f,
  -1.42203197e-01f, 2.75254756e-01f, -5.67851448e-03f, -2.23118395e-01f, 2.24608425e-02f, -1.63363919e-01f, -3.63125140e-03f, 9.48295444e-02f, 1.07719146e-01f, 1.74042910e-01f,
  1.61508575e-01f, -4.05562252e-01f, -1.01063699e-01f, -3.86123776e-01f, 7.29734376e-02f, 2.01262906e-01f, -1.14189297e-01f, 1.66348219e-02f, -1.55666053e-01f, -1.50092661e-01f,
  -2.59460866e-01f, -7.46061467e-03f, 1.00091189e-01f, 1.50248511e-02f, 2.12698597e-02f, 9.69225392e-02f, 1.16669483e-01f, 1.59466825e-03f, 4.82377373e-02f, 3.48928459e-02f,
  9.16558728e-02f, 8.60849470e-02f, 2.30710823e-02f, 4.19634804e-02f, -3.27048600e-02f, 5.74631132e-02f, -1.67312678e-02f, -3.70364562e-02f, -5.55382445e-02f, 4.85172309e-02f,
  -1.78998746e-02f, 2.59249862e-02f, 9.01223943e-02f, 2.84096580e-02f, 6.79934695e-02f, -2.26792004e-02f, -2.16515213e-02f, 1.89211145e-02f, 6.79471269e-02f, 3.78419855e-03f,
  3.95026729e-02f, 8.38265494e-02f, -3.04054990e-02f, -1.00274673e-02f, -8.91493782e-02f, -7.94867286e-04f, -5.47717065e-02f, -4.42278050e-02f, 1.50684819e-01f, -3.23292986e-02f,
  8.35828949e-03f, 1.25112934e-02f, -5.37771136e-02f, 2.54944693e-02f, 1.56744160e-02f, -3.33223753e-02f, 6.71507195e-02f, 1.87476072e-02f, 1.12108380e-01f, -4.20676395e-02f,
  -1.00581750e-01f, -5.22927679e-02f, -8.34895298e-03f, -2.99380124e-02f, -7.31134862e-02f, 6.91259466e-03f, 2.74206400e-02f, -5.92321046e-02f, 1.09590953e-02f, 2.79917824e-03f,
  -1.90528557e-02f, 1.60272345e-01f, -4.18866128e-02f, -1.39975935e-01f, -3.38061489e-02f, -4.32786904e-02f, -7.99565837e-02f, -3.76416929e-02f, 3.41124237e-02f, 2.52576865e-04f,
  5.57678193e-02f, -3.86240892e-02f, 1.06050577e-02f, -2.60165073e-02f, -7.25907236e-02f, 2.90534031e-02f, 2.98153255e-02f, 5.23753315e-02f, 6.03378192e-02f, 1.52696241e-02f,
  5.16077317e-02f, 1.17996000e-01f, -5.88144362e-02f, -2.74750013e-02f, 3.11111528e-02f, 1.97982974e-02f, 1.12100907e-01f, 1.21535249e-02f, -3.67219672e-02f, 4.28168513e-02f,
  -4.51639265e-01f, 1.38209477e-01f, 2.30851591e-01f, 1.13152646e-01f, -2.89665580e-01f, 1.02601118e-01f, -9.45195332e-02f, 8.70910287e-02f, -1.66235536e-01f, 1.17711067e-01f,
  -3.38112041e-02f, -7.72688910e-02f, -6.24104682e-03f, 2.55164266e-01f, 2.53093362e-01f, 1.29388899e-01f, 2.97245115e-01f, -2.88062803e-02f, -8.06208253e-02f, -1.87739916e-02f,
  -1.71260145e-02f, 5.60678504e-02f, 2.74418652e-01f, 1.09606730e-02f, -1.42602399e-01f, -2.15389729e-02f, 1.70070380e-01f, -1.51736706e-01f, 2.52357215e-01f, -5.54447286e-02f,
  1.30267382e-01f, -1.02436036e-01f, -1.78318862e-02f, 1.25742316e-01f, -1.19261984e-02f, -2.09355727e-02f, 1.25494441e-02f, -2.22007502e-02f, -2.24694833e-02f, 3.50139216e-02f,
  -8.58182311e-02f, -4.18934338e-02f, 4.19033356e-02f, -1.49156125e-02f, -1.47570059e-01f, -5.64711820e-03f, -1.32236034e-02f, 8.30341876e-02f, 9.57373995e-03f, -9.31243319e-03f,
  -9.83405299e-03f, 2.03861296e-02f, -2.32390426e-02f, -9.23550688e-03f, 1.79980285e-02f, 2.87500070e-03f, 5.28052785e-02f, -2.26197466e-02f, 2.17482122e-03f, -1.92386042e-02f,
  -8.05039927e-02f, -7.60254450e-03f, 2.97715068e-02f, 2.95407418e-02f, -2.69198846e-02f, 2.98613887e-02f, -1.61840413e-02f, 5.52526116e-02f, -8.29590932e-02f, -1.43212837e-03f,
  -1.59302249e-03f, 1.23576226e-03f, -1.96015816e-02f, 4.25405055e-02f, 3.32364514e-02f, 2.23053573e-03f, -8.87385104e-03f, -2.47113407e-02f, -3.11844405e-02f, 7.29614496e-02f,
  -3.02323084e-02f, 2.24675015e-02f, 1.75151434e-02f, -3.60455401e-02f, 4.13131751e-02f, -2.17238441e-02f, -1.06624020e-02f, 1.35154547e-02f, 3.87532823e-02f, -1.46172903e-02f,
  1.76840313e-02f, 1.03912860e-01f, -1.13736885e-02f, -5.75722791e-02f, 4.05751653e-02f, 4.43883538e-02f, 6.81751147e-02f, -1.50067126e-02f, 3.12591083e-02f, -4.97792698e-02f,
  1.17181651e-02f, -5.72118349e-03f, -5.49649522e-02f, 1.38696861e-02f, 4.30575088e-02f, 6.77379891e-02f, 5.79084828e-02f, -4.35287738e-03f, 4.30656970e-02f, -2.34482940e-02f,
  3.30336951e-02f, -1.32096469e-01f, -2.16239113e-02f, -5.16481549e-02f, -2.24401411e-02f, -1.04526080e-01f, -7.87186101e-02f, -2.19124723e-02f, -1.16143106e-02f, 4.48164716e-02f,
  1.33076280e-01f, -4.60280329e-01f, -3.81511837e-01f, 7.92541355e-02f, 3.28987956e-01f, 2.67324299e-01f, 6.42386004e-02f, -4.78594191e-02f, -2.45922700e-01f, -4.43830341e-02f,
  2.03268141e-01f, -2.74510831e-01f, -1.11433022e-01f, 1.80026203e-01f, 2.51804680e-01f, -2.53395647e-01f, 1.23499997e-01f, -5.25502227e-02f, -6.32804260e-02f, -1.05330311e-01f,
  4.72305603e-02f, 1.65480107e-01f, -7.12181479e-02f, -8.48756917e-03f, 4.42591608e-02f, -1.20385274e-01f, 2.20912114e-01f, -4.01623249e-02f, 3.04276466e-01f, 8.16756859e-02f,
  1.41111482e-02f, -1.00535996e-01f, -6.74911439e-02f, -8.93281996e-02f, 1.39694735e-01f, 7.37395883e-02f, 1.18490010e-01f, 9.52899456e-02f, 5.29162548e-02f, -1.10630365e-02f,
  1.60311796e-02f, 9.80335996e-02f, 5.08304732e-03f, -6.26150891e-02f, 1.08152628e-01f, -1.09826587e-02f, 2.55447868e-02f, 2.34895051e-02f, -7.17893243e-02f, 1.89961158e-02f,
  -1.69461995e-01f, -3.60814892e-02f, 7.33249262e-02f, -1.85934268e-02f, -2.11122520e-02f, -2.37066615e-02f, -2.99260300e-02f, -1.51108336e-02f, 1.14019729e-01f, -4.86288331e-02f,
  4.13184948e-02f, -5.00016026e-02f, 1.48225408e-02f, -2.10092664e-02f, 5.65659776e-02f, 5.88581972e-02f, 1.11446567e-02f, 1.01001449e-02f, 2.55221352e-02f, -1.99626684e-02f,
  6.25849664e-02f, 6.44537210e-02f, 9.43742469e-02f, 3.47612239e-02f, 3.94149087e-02f, 1.34101361e-02f, 5.87233528e-02f, -8.21510553e-02f, -7.00023100e-02f, 8.00870061e-02f,
  -3.77457514e-02f, 5.42462468e-02f, -1.25364095e-01f, 2.16092486e-02f, -6.24959990e-02f, -2.21134294e-02f, -6.91088215e-02f, 3.94885466e-02f, -1.21022519e-02f, 2.75271796e-02f,
  -4.48716134e-02f, -1.78371161e-01f, -1.06635213e-01f, 5.05630746e-02f, -7.85883963e-02f, 6.70035854e-02f, -5.21655232e-02f, 2.81347719e-04f, -2.45950241e-02f, 8.91207904e-02f,
  8.67409855e-02f, -6.49981052e-02f, 5.09346835e-03f, 8.89842883e-02f, -1.70771535e-02f, -5.23200892e-02f, -5.10394685e-02f, 5.56022637e-02f, 6.56662807e-02f, -4.37768409e-03f,
  2.10738666e-02f, 6.24764115e-02f, -2.20518634e-02f, 1.76628809e-02f, 3.93406413e-02f, -2.78864000e-02f, -6.80781063e-03f, -2.38120370e-02f, 3.81051600e-02f, -7.62145221e-02f,
  7.03475118e-01f, -4.15386520e-02f, -1.61274225e-02f, 3.29061419e-01f, 2.47472018e-01f, 2.33914360e-01f, 2.65981972e-01f, 1.12791613e-01f, 8.76767412e-02f, -7.04692453e-02f,
  1.18185870e-01f, 1.19845122e-02f, -1.40400916e-01f, 2.76437581e-01f, 2.18487397e-01f, -1.83785781e-01f, 3.01248014e-01f, 1.09304309e-01f, -3.37427631e-02f, 1.87514111e-01f,
  7.56688192e-02f, 1.99697793e-01f, 9.36379060e-02f, -8.32400247e-02f, 2.14395463e-01f, -1.15213618e-01f, -6.54098839e-02f, -2.33531833e-01f, 1.51707396e-01f, 2.19446458e-02f,
  2.50934988e-01f, 6.19044304e-02f, 1.03028333e-02f, -1.03780702e-01f, 1.32553339e-01f, -5.71794510e-02f, 4.20099944e-02f, -7.23464191e-02f, 8.04651249e-03f, 5.66043891e-02f,
  -5.07217534e-02f, 9.36808810e-02f, 1.32502744e-03f, -1.41175970e-01f, -1.62416361e-02f, -1.34081924e-02f, 3.97374555e-02f, 9.77640897e-02f, -1.90135930e-02f, 8.46602395e-03f,
  -4.30096053e-02f, 7.98429921e-03f, -1.63219068e-02f, -1.29488725e-02f, -2.12367252e-02f, -3.63039412e-03f, 2.55945697e-02f, -1.38704088e-02f, 3.85204665e-02f, 4.88104559e-02f,
  4.58274782e-03f, -1.07226916e-01f, -3.75945903e-02f, 1.64947528e-02f, 2.31862417e-03f, 2.12650057e-02f, -8.03805217e-02f, 1.69249717e-02f, -2.80497409e-02f, 7.66651630e-02f,
  3.50377187e-02f, 4.50557880e-02f, -9.65704024e-03f, -4.00445536e-02f, 4.25676443e-02f, -1.54654374e-02f, -3.87820303e-02f, 9.02409013e-03f, 5.48792183e-02f, 3.85226607e-02f,
  -3.79937030e-02f, -4.46071625e-02f, -2.58205878e-03f, 1.42750703e-02f, 3.50538716e-02f, -2.01745573e-02f, -8.90863761e-02f, -1.73954535e-02f, -1.21867601e-02f, 3.34703811e-02f,
  1.24614909e-01f, -9.64424834e-02f, -1.41487252e-02f, 1.12515479e-01f, -3.17352228e-02f, -1.43306358e-02f, -6.10402673e-02f, 2.51486171e-02f, -1.97527222e-02f, 2.30315141e-02f,
  4.74878699e-02f, 1.10525377e-02f, -2.46126176e-04f, 2.01769359e-02f, 2.73327585e-02f, 5.37289716e-02f, -3.13443840e-02f, -1.44099351e-02f, 7.06526637e-02f, 4.65763286e-02f,
  -6.35225559e-03f, -1.36372047e-02f, -2.75915395e-02f, 6.87957034e-02f, 2.58347411e-02f, 5.33687845e-02f, 1.38562834e-02f, -1.35980621e-02f, -2.41640378e-02f, 1.24217209e-03f,
  7.63735712e-01f, -1.48654819e-01f, 1.62427425e-01f, 3.60848606e-01f, -2.26346180e-02f, -4.08158779e-01f, -1.32726431e-01f, 4.40706946e-02f, 3.00988674e-01f, -2.64342725e-01f,
  -9.56891030e-02f, 5.10587692e-02f, -2.06199557e-01f, -5.06137423e-02f, 1.01999171e-01f, -1.39097288e-01f, 8.96063074e-02f, -8.17676410e-02f, 9.79862213e-02f, 1.26032948e-01f,
  1.72098130e-01f, -1.61094740e-01f, 3.08219474e-02f, -1.37061909e-01f, 2.83581354e-02f, 1.65697172e-01f, -1.78097300e-02f, -8.62831250e-02f, 5.55353984e-03f, -3.65499109e-02f,
  6.89525902e-02f, 8.71960372e-02f, 6.73454255e-02f, -4.89114150e-02f, -3.31208557e-02f, 4.38708588e-02f, -5.67948725e-03f, -4.32082452e-02f, 5.54866232e-02f, -7.69431237e-03f,
  -5.50909713e-02f, -4.80136164e-02f, 2.86105201e-02f, 4.31470312e-02f, 3.39117162e-02f, -1.34864282e-02f, -1.75513495e-02f, 2.33330969e-02f, -5.39301746e-02f, 1.51406601e-02f,
  9.06171836e-03f, 2.03211363e-02f, 3.31356958e-03f, -5.76360039e-02f, -5.49065694e-03f, -2.78350078e-02f, 2.81287264e-03f, -1.76601391e-02f, 4.06323408e-04f, 5.84556833e-02f,
  -5.14877141e-02f, -9.97472461e-03f, -2.86942534e-02f, 1.94083881e-02f, -6.12576492e-02f, 6.05821311e-02f, 7.43238721e-04f, -6.10360540e-02f, 1.65436193e-02f, -2.92075984e-02f,
  2.95287911e-02f, 3.00435964e-02f, 2.56218966e-02f, 3.80017459e-02f, 6.90087229e-02f, 5.37437946e-02f, 2.12163590e-02f, -2.03418881e-02f, 6.05721548e-02f, 1.75865851e-02f,
  4.92667966e-03f, -1.56600634e-03f, -1.19111938e-02f, -3.24041694e-02f, -6.54837787e-02f, -9.44082346e-03f, -1.27179746e-03f, 3.70557085e-02f, 5.13149053e-02f, -8.33139289e-03f,
  -1.83846310e-01f, -1.34061232e-01f, 7.90505949e-03f, 5.13332710e-03f, -6.43321034e-03f, -8.84698820e-04f, 2.66157947e-02f, 1.83682106e-02f, -1.00349620e-01f, 2.43505882e-03f,
  -1.16432728e-02f, 3.89429852e-02f, 1.49719818e-02f, -4.36310982e-03f, 1.71661936e-02f, -4.85021323e-02f, 7.11489934e-03f, 2.55676489e-02f, -4.04000245e-02f, 2.25153728e-03f,
  -1.99827235e-02f, -6.92703854e-03f, 1.45616410e-02f, 3.45584638e-02f, -1.29898824e-03f, -9.66380723e-03f, 2.68299822e-02f, 6.80202693e-02f, -7.56129324e-02f, -4.40620817e-02f,
  -3.81078184e-01f, 2.32119169e-02f, -2.83277243e-01f, -3.59306544e-01f, -1.98527396e-01f, 1.37885660e-01f, -4.47468869e-02f, 8.21543485e-02f, -2.14136973e-01f, 3.01290005e-01f,
  5.33168092e-02f, -2.81578302e-02f, 4.48455840e-01f, -1.53985709e-01f, -6.38211966e-02f, 3.24789256e-01f, -1.12727672e-01f, -2.13376246e-02f, -1.08593302e-02f, 3.58991288e-02f,
  -1.32189184e-01f, 6.32919073e-02f, -3.83575447e-02f, 7.91861862e-02f, -1.31482199e-01f, -1.34072691e-01f, -1.48169935e-01f, -1.95970103e-01f, -2.63954520e-01f, -1.12856507e-01f,
  -3.18147941e-04f, 8.48791003e-02f, -7.13792294e-02f, 3.35130543e-02f, -2.30728406e-02f, 7.53883319e-03f, -6.29654452e-02f, 3.62044908e-02f, -4.53028455e-02f, 1.85926277e-02f,
  4.06957790e-02f, 7.94683173e-02f, 2.08872724e-02f, 6.73012203e-03f, -1.21357024e-01f, -8.97699744e-02f, -3.53735872e-02f, -2.60544717e-02f, -4.77554128e-02f, 2.28787004e-03f,
  -5.50833307e-02f, -8.03473778e-03f, -9.16213989e-02f, 6.77854642e-02f, -1.04223769e-02f, -3.63800526e-02f, -5.57952039e-02f, -6.71148626e-03f, -4.74466458e-02f, -4.47073542e-02f,
  1.98901072e-02f, -3.50679234e-02f, -1.33519864e-03f, -8.00612047e-02f, -1.12067964e-02f, -6.75930902e-02f, -4.16202936e-03f, 3.73418629e-02f, -2.88152434e-02f, 5.96020557e-02f,
  -1.02857418e-01f, -1.93928350e-02f, -1.92202833e-02f, -9.35049634e-03f, -4.19669636e-02f, -2.74808295e-02f, 3.35948877e-02f, 5.24223521e-02f, -8.31546485e-02f, 1.69300828e-02f,
  4.56166603e-02f, -6.38262704e-02f, 4.94858064e-02f, 1.86417077e-03f, 4.65830043e-03f, 3.39160748e-02f, -3.70253697e-02f, -3.48301395e-03f, -7.48612583e-02f, -6.81954843e-05f,
  1.02248251e-01f, -3.64565551e-02f, 4.20443118e-02f, 5.54000819e-03f, 4.91169654e-02f, 4.11889441e-02f, 6.56826561e-03f, -6.57302281e-03f, -5.85328564e-02f, 2.50710873e-03f,
  1.05205886e-01f, -3.34066711e-02f, 6.74462318e-02f, -9.92419273e-02f, -8.18536431e-03f, 1.66519582e-02f, 1.46787716e-02f, -2.95447949e-02f, -8.04972425e-02f, -6.27297014e-02f,
  3.83746997e-03f, 1.15566649e-01f, 1.01956911e-01f, 4.15755026e-02f, 7.91897327e-02f, 8.25890750e-02f, -6.30022287e-02f, 1.63626019e-02f, 6.11778768e-03f, -9.81609337e-03f,
  4.52708423e-01f, -6.29715025e-02f, -2.46483758e-02f, 1.77876323e-01f, -9.72496942e-02f, -4.32921946e-01f, -2.19283417e-01f, -4.83263470e-02f, 1.96248442e-01f, -4.04279605e-02f,
  -1.49222434e-01f, 6.83009475e-02f, -2.34636366e-02f, -3.39347571e-01f, -2.14805484e-01f, -1.38323769e-01f, -1.24824122e-01f, -3.50993462e-02f, 6.32778332e-02f, 9.74716842e-02f,
  4.71725538e-02f, -2.25632757e-01f, -1.84231251e-01f, 3.11725419e-02f, -9.56535712e-02f, 1.36906967e-01f, 5.13224266e-02f, 1.24105349e-01f, -1.21335007e-01f, -1.04856543e-01f,
  -9.50841233e-02f, 2.37915277e-01f, -4.03369144e-02f, 1.22371875e-02f, -8.42591226e-02f, 4.69800793e-02f, -1.01670809e-03f, -4.70195785e-02f, 4.44269963e-02f, -3.83883081e-02f,
  -7.03108637e-03f, -5.74778207e-03f, -2.89991242e-03f, 5.54961450e-02f, 2.82452479e-02f, 5.64649366e-02f, -1.18014403e-01f, -7.86942840e-02f, -4.91868071e-02f, -7.08382726e-02f,
  -2.59985682e-02f, -3.44994180e-02f, -1.31869195e-02f, 1.93370264e-02f, 6.56909123e-03f, -5.46752997e-02f, -5.07460460e-02f, -1.07989702e-02f, -8.48780479e-03f, -1.26372837e-02f,
  6.57961667e-02f, 3.96699682e-02f, 3.78767774e-02f, 3.52523364e-02f, -6.76564872e-03f, -2.69598868e-02f, 9.49653517e-03f, -1.18286654e-01f, 7.61190206e-02f, 4.07739496e-03f,
  3.23350052e-03f, -6.73822593e-03f, 6.20366074e-02f, 1.19552109e-02f, 2.14389153e-02f, 6.86938316e-02f, 1.86113138e-02f, -1.93930566e-02f, 8.20898160e-04f, -7.11563677e-02f,
  2.60176044e-02f, -1.51891829e-02f, -5.84551832e-03f, 3.69036123e-02f, -6.93147108e-02f, 3.37766600e-03f, 4.11399975e-02f, -1.54851349e-02f, 5.34758419e-02f, -9.33456142e-03f,
  8.63717198e-02f, 3.59663039e-01f, -2.54544406e-03f, -1.25641795e-02f, -4.46679443e-02f, 7.28312600e-03f, 4.81157713e-02f, 5.22722537e-03f, 3.66029330e-02f, 4.88290563e-02f,
  5.50503694e-02f, 3.12202517e-02f, 7.79077634e-02f, 1.15941316e-02f, -2.59316955e-02f, -7.34658614e-02f, -1.81734804e-02f, 9.63470191e-02f, 4.67276312e-02f, 6.08052798e-02f,
  7.88592994e-02f, 1.05876654e-01f, -3.35944630e-02f, 5.34121543e-02f, -3.60817611e-02f, -1.51892003e-04f, 7.74785951e-02f, 5.99891618e-02f, -2.18988638e-02f, -1.40291313e-02f,
  3.59152049e-01f, -4.60603908e-02f, -6.12997338e-02f, -5.21199554e-02f, 1.62110537e-01f, 4.65928912e-01f, 3.86406809e-01f, 1.54092848e-01f, 9.87542421e-02f, -1.45230060e-02f,
  1.61676742e-02f, -2.97169417e-01f, 1.70715943e-01f, 1.21811785e-01f, 4.15327787e-01f, 2.57668853e-01f, 2.03498036e-01f, 2.34684418e-03f, -2.14683097e-02f, 3.00447457e-02f,
  1.47842363e-01f, 8.60213935e-02f, 1.64475650e-01f, -1.20759748e-01f, 7.60326609e-02f, -3.05622727e-01f, -2.24861026e-01f, -1.35457486e-01f, -2.69907773e-01f, -3.89988236e-02f,
  9.54548046e-02f, 9.40395147e-03f, 7.38215633e-04f, -4.84968014e-02f, 5.02122343e-02f, -2.38224883e-02f, -9.54315141e-02f, -4.73747551e-02f, -1.43359713e-02f, -6.78491127e-03f,
  -8.80062804e-02f, -8.20890535e-03f, -3.57820727e-02f, 1.01651223e-02f, 2.59150472e-02f, -7.48760402e-02f, -6.83223382e-02f, -5.08652674e-03f, -8.08439255e-02f, 7.60970041e-02f,
  7.48829395e-02f, 4.50991355e-02f, -3.40954028e-02f, -1.75409734e-01f, -6.40315935e-02f, -9.35802236e-04f, 1.69216245e-02f, -4.32502590e-02f, -7.14563280e-02f, 2.93397270e-02f,
  -1.07095903e-02f, -1.95249182e-03f, 8.38719606e-02f, -9.69996490e-03f, 3.74344699e-02f, -3.83058302e-02f, 3.74896191e-02f, -3.84441786e-03f, -7.52776638e-02f, -3.84265706e-02f,
  -5.83813190e-02f, 1.17284907e-02f, -6.76914528e-02f, 1.27227589e-01f, 6.66852714e-03f, -1.79381249e-03f, 6.39302805e-02f, -9.89572704e-02f, -3.84256570e-03f, 3.78281064e-02f,
  -2.43514422e-02f, -1.56480446e-02f, -6.22010604e-02f, -3.59703675e-02f, 7.38676339e-02f, 9.37737003e-02f, -1.00340091e-01f, -3.46400887e-02f, -1.28678428e-02f, 4.23494317e-02f,
  -1.50406193e-02f, -2.25960240e-01f, -4.60085012e-02f, -1.05094299e-01f, -3.72867212e-02f, 1.43964160e-02f, 2.44491678e-02f, 3.47297862e-02f, -4.64089066e-02f, 4.01452817e-02f,
  5.33904880e-02f, -9.09174085e-02f, -1.35359362e-01f, -8.92632641e-03f, -1.01308897e-01f, 5.51878512e-02f, -2.29201186e-02f, -1.34712026e-01f, 3.35089900e-02f, -1.38352677e-01f,
  -5.18285893e-02f, 1.25259524e-02f, 3.29949185e-02f, 9.61911120e-03f, -8.14350881e-03f, 7.29416637e-03f, -5.05758151e-02f, 1.72076132e-02f, -1.88886430e-02f, -6.10126033e-02f,
  -2.20728591e-01f, 1.74735159e-01f, -2.39336729e-01f, -2.58749217e-01f, 1.93197638e-01f, 6.84467033e-02f, -3.81703153e-02f, 2.43615478e-01f, 1.26227692e-01f, 1.10222153e-01f,
  2.58148342e-01f, -3.49999905e-01f, 2.93842882e-01f, -1.88866928e-01f, -5.16072452e-01f, 1.44581825e-01f, -2.45186046e-01f, -1.10984422e-01f, 1.75478071e-01f, -5.34292161e-02f,
  -8.15922394e-02f, -1.46113083e-01f, -1.27454638e-01f, 1.85667664e-01f, -7.50541240e-02f, 8.11611712e-02f, -2.36839324e-01f, 1.03666626e-01f, -3.03220570e-01f, -9.82691720e-02f,
  4.04696390e-02f, 1.52986676e-01f, 1.79051533e-02f, -2.27296557e-02f, 2.68506948e-02f, 4.27164659e-02f, -1.24382034e-01f, 2.02429760e-03f, 5.76107949e-02f, -1.52545152e-02f,
  -3.84327881e-02f, -1.07795462e-01f, -2.20163986e-02f, 8.37797895e-02f, 2.73788683e-02f, -1.39868725e-02f, 2.44667791e-02f, 3.16525921e-02f, 1.63397321e-03f, 1.15163752e-03f,
  -5.78843709e-03f, -4.18834388e-02f, -8.46379697e-02f, -9.36160758e-02f, -1.41011670e-01f, 3.94130778e-03f, -4.33172025e-02f, -9.07489434e-02f, -8.75945389e-02f, -5.67750446e-02f,
  3.04564964e-02f, 2.07351781e-02f, 2.89524402e-02f, 6.01936392e-02f, 5.18533513e-02f, 1.67699382e-02f, -1.28275389e-02f, 3.10234036e-02f, -8.27207137e-03f, 2.39125569e-03f,
  -1.43450797e-02f, -1.40865054e-02f, 4.91716079e-02f, 6.17017709e-02f, -2.42002197e-02f, 9.03421640e-02f, -7.15161264e-02f, 4.41041961e-02f, -2.30137501e-02f, 6.11036504e-03f,
  3.24732102e-02f, 2.14567333e-02f, -7.64919119e-03f, -3.33612524e-02f, 8.31349567e-02f, -1.45639237e-02f, 1.62520800e-02f, 2.59385593e-02f, 1.06866650e-01f, -2.05439087e-02f,
  -1.42152712e-01f, -2.18556881e-01f, 1.03473723e-01f, -8.53340924e-02f, -6.32772781e-03f, 5.28557524e-02f, -1.37770036e-02f, -4.34661061e-02f, -4.06249277e-02f, 1.65187679e-02f,
  4.09033000e-02f, 3.38064581e-02f, -7.49241561e-02f, -3.95268537e-02f, -5.85266016e-02f, -2.65360102e-02f, -4.58309501e-02f, -9.49987024e-02f, -1.06002957e-01f, -1.10493474e-05f,
  -1.12115517e-02f, -1.77625623e-02f, 3.96563448e-02f, 1.90801099e-02f, 1.71545576e-02f, -1.77297555e-02f, -3.88932414e-02f, 2.77609676e-02f, -3.12126521e-02f, -3.65619883e-02f,
  -2.45206431e-02f, 3.18655252e-01f, -1.71204939e-01f, 1.79507002e-01f, -2.95691431e-01f, -1.30449340e-01f, 2.05354944e-01f, 1.56164253e-02f, 1.77096471e-01f, 3.59853536e-01f,
  -4.43270020e-02f, 1.20457694e-01f, 1.20388687e-01f, 3.57082970e-02f, -4.30625260e-01f, 7.81862531e-03f, 6.93358704e-02f, 2.79735774e-01f, -8.07138439e-03f, -8.34867433e-02f,
  -8.39873254e-02f, -2.57906616e-02f, -2.18424112e-01f, -1.31886378e-01f, -1.33634120e-01f, 7.34948963e-02f, -2.43372899e-02f, -1.66764066e-01f, 3.25174518e-02f, -5.49061894e-02f,
  -1.19498976e-01f, 1.84333384e-01f, -5.10829613e-02f, 2.31644288e-02f, -2.07852852e-02f, -2.80270167e-02f, 1.16914315e-02f, -4.30216789e-02f, -1.07132204e-01f, 5.78590333e-02f,
  2.09261365e-02f, 1.04307076e-02f, 9.15997922e-02f, -3.50037329e-02f, 6.07087351e-02f, 3.58792394e-02f, -1.16355121e-02f, -4.29922678e-02f, -3.22471664e-04f, -3.22530195e-02f,
  -2.72570364e-02f, 2.03185044e-02f, -4.26236726e-02f, 7.96228051e-02f, -6.42954931e-02f, 3.71806324e-03f, 1.11198518e-02f, -3.31700966e-02f, 1.34899721e-01f, 1.00004941e-01f,
  7.06674233e-02f, -8.45752005e-03f, -1.09307682e-02f, -6.42753989e-02f, -6.46955818e-02f, 1.31990258e-02f, -4.84029204e-03f, 4.18137275e-02f, -2.33215224e-02f, 1.11518009e-02f,
  6.12135138e-03f, 3.53027731e-02f, 7.82949291e-03f, 6.17450178e-02f, 2.88641565e-02f, 5.14878891e-02f, -5.68302907e-02f, -3.21597792e-03f, 1.81854162e-02f, -1.21006690e-01f,
  6.86691701e-02f, -3.75884771e-02f, 2.97758225e-02f, -9.62787773e-03f, 2.29406971e-02f, -4.91143316e-02f, 1.20742256e-02f, 1.69271175e-02f, -7.91801810e-02f, -6.18577637e-02f,
  1.06877320e-01f, 1.93740129e-01f, 5.50294947e-03f, 3.49613689e-02f, 7.33133107e-02f, -8.24951828e-02f, -1.87076628e-02f, -6.86962507e-04f, 4.24003117e-02f, -8.89998488e-03f,
  2.49111429e-02f, 5.10347150e-02f, 1.06424876e-02f, -6.94476739e-02f, -3.58580463e-02f, 5.41791357e-02f, 2.31900532e-02f, 5.24670966e-02f, -3.51546034e-02f, 1.02386065e-01f,
  7.85566196e-02f, 7.51343369e-02f, 3.29701207e-03f, -5.50143309e-02f, -2.50179637e-02f, 6.19767196e-02f, -3.92673388e-02f, 1.18922107e-01f, -7.13557899e-02f, 7.50646368e-02f,
  3.87887955e-01f, 1.43073380e-01f, 6.16466738e-02f, 2.98184365e-01f, 1.50523424e-01f, -1.08480148e-01f, -2.33272105e-01f, 2.49774843e-01f, 2.39302874e-01f, -1.30865708e-01f,
  2.19035745e-01f, -1.72069311e-01f, -1.49290845e-01f, 1.98020622e-01f, -1.27483353e-01f, -1.20270982e-01f, 2.50419497e-01f, -1.08855754e-01f, 1.15120769e-01f, 1.41483769e-01f,
  1.26849756e-01f, 2.31755152e-01f, 3.57338190e-02f, 2.42134452e-01f, 2.28650749e-01f, 1.35672733e-01f, -7.98437297e-02f, -1.44883633e-01f, 4.17825282e-02f, -7.30966404e-02f,
  1.72558278e-01f, 2.94200450e-01f, 2.41696587e-04f, 1.25346454e-02f, 1.14156790e-01f, -1.20886443e-02f, -1.47698507e-01f, -1.37373015e-01f, 1.82013097e-03f, 4.01698053e-02f,
  -6.84787184e-02f, 6.99057654e-02f, 1.59558356e-01f, -1.10878333e-01f, 3.93904410e-02f, 2.73194481e-02f, 1.05152301e-01f, 3.25810798e-02f, 2.50532664e-02f, -2.23646723e-02f,
  1.26005352e-01f, 8.11594948e-02f, 7.56167695e-02f, -3.83382626e-02f, 8.88573974e-02f, 1.31996036e-01f, -1.10453971e-01f, -1.60684660e-02f, -4.71787043e-02f, 8.65923539e-02f,
  -2.98319161e-02f, -1.08323470e-02f, 4.07680720e-02f, 5.33615686e-02f, 4.16843779e-02f, 1.82923675e-02f, -5.33945970e-02f, -7.63736013e-03f, -3.34621854e-02f, 4.33931686e-02f,
  6.53706715e-02f, 1.88071020e-02f, 9.23861787e-02f, 3.07412073e-02f, -2.59425901e-02f, 1.00719780e-01f, -9.24931839e-02f, 4.25725952e-02f, 5.25861867e-02f, 6.30178750e-02f,
  -4.85115275e-02f, -3.25333439e-02f, -4.62235026e-02f, -1.06368951e-01f, 1.56019954e-02f, 7.96473920e-02f, 2.85324603e-02f, -2.20064092e-02f, -4.01915871e-02f, -8.56114402e-02f,
  -1.28735855e-01f, -6.78035989e-02f, -5.40076606e-02f, -8.50422867e-03f, -6.21433258e-02f, -1.22506572e-02f, -1.08987046e-02f, 1.17265694e-01f, -8.82401690e-03f, 6.37933612e-02f,
  8.80822539e-02f, -4.53181081e-02f, 3.12247816e-02f, 2.04547681e-02f, -6.48257583e-02f, 4.91060205e-02f, -7.08129406e-02f, -1.04265511e-01f, -3.82863469e-02f, -2.34193392e-02f,
  -5.99735342e-02f, -2.31700465e-02f, -5.04302271e-02f, 1.17621385e-01f, -2.25363802e-02f, 2.68967804e-02f, -1.11735305e-02f, -5.22172153e-02f, -2.46477369e-02f, -8.41744468e-02f,
  -1.67598739e-01f, -5.79150259e-01f, 1.31320819e-01f, -3.19639027e-01f, -1.89084243e-02f, -2.04177886e-01f, -1.03671700e-01f, -2.05695823e-01f, -3.81954193e-01f, -1.48252919e-01f,
  2.81070210e-02f, 3.18077393e-03f, 9.85632464e-02f, -3.35064888e-01f, 3.67239654e-01f, -6.59716083e-03f, -2.64372379e-01f, -2.90031284e-02f, -1.80285767e-01f, 5.26206419e-02f,
  -8.38052183e-02f, -1.02391005e-01f, 2.01338649e-01f, 1.53496908e-02f, -1.48273021e-01f, 3.65714058e-02f, 3.13127756e-01f, 1.16218835e-01f, 3.40436287e-02f, -1.23696290e-02f,
  -8.04761499e-02f, -1.98575586e-01f, -1.01919368e-01f, 4.44150455e-02f, 4.56293076e-02f, -1.37864919e-02f, 1.12489618e-01f, 1.18391208e-01f, 5.53428195e-02f, -4.71147522e-02f,
  9.60270129e-03f, 5.44190705e-02f, -6.75081983e-02f, -2.36514192e-02f, -1.11031093e-01f, 4.04763892e-02f, -6.64960444e-02f, -6.79718256e-02f, -6.09978065e-02f, 4.79734205e-02f,
  -2.83043049e-02f, -4.07360494e-02f, -8.75250101e-02f, -4.15886194e-03f, 5.45727387e-02f, -2.53927000e-02f, 2.60376707e-02f, 9.94830132e-02f, -1.02403089e-01f, -7.76099414e-02f,
  9.49170068e-03f, -1.14712296e-02f, 1.86572336e-02f, -6.26367107e-02f, -6.73981085e-02f, -3.61679979e-02f, -5.04477136e-02f, 6.34575859e-02f, -5.50306290e-02f, 2.90272757e-02f,
  6.86343238e-02f, -6.96145743e-02f, -9.57026407e-02f, 6.91590086e-03f, 1.54895103e-02f, -7.32274950e-02f, 7.76681155e-02f, -1.49895400e-02f, 8.77358764e-03f, 2.09544804e-02f,
  -4.37575765e-02f, -2.99543645e-02f, 6.43986017e-02f, 2.55025327e-02f, -4.97083738e-02f, 9.12631154e-02f, -2.53013745e-02f, -4.56412323e-02f, 6.28612796e-03f, 6.22267872e-02f,
  -1.71261840e-02f, 2.01543625e-02f, 2.46564709e-02f, -4.75368425e-02f, -2.23859940e-02f, -3.49370437e-03f, -1.01981744e-01f, -5.70585802e-02f, 8.29974785e-02f, -5.83080053e-02f,
  7.29663074e-02f, -2.53600767e-03f, 5.22584058e-02f, -2.52464809e-03f, 6.72430098e-02f, 8.66751075e-02f, 3.68857495e-02f, 3.63642499e-02f, 7.15691000e-02f, 6.72422722e-02f,
  4.83166054e-02f, 8.74775648e-02f, -1.43988207e-02f, -3.06324866e-02f, -3.63978483e-02f, 7.16952831e-02f, 1.07202679e-02f, -1.00269914e-02f, 4.85890321e-02f, 5.10916412e-02f,
  -1.17816888e-01f, 3.92185181e-01f, -4.94184252e-03f, 4.46754992e-02f, -2.50722140e-01f, -4.07211781e-01f, -2.05832064e-01f, -1.22539528e-01f, 1.27457716e-02f, 3.33500504e-01f,
  -2.37495065e-01f, 2.83187360e-01f, 2.70666946e-02f, 1.97956920e-01f, -4.52627271e-01f, 7.86906779e-02f, 1.80673420e-01f, 1.26634106e-01f, 6.52982220e-02f, 1.05982032e-02f,
  -6.79871812e-02f, 4.30910625e-02f, -8.89732689e-02f, 8.18000808e-02f, 8.56619626e-02f, 2.57941447e-02f, 1.58401906e-01f, -2.38762852e-02f, -3.66671905e-02f, -7.21965805e-02f,
  -3.99215743e-02f, 9.18511078e-02f, -4.70721871e-02f, 3.20734605e-02f, -2.37679947e-02f, -2.09874269e-02f, -1.93168614e-02f, 7.95236323e-03f, -9.75347981e-02f, -5.40388860e-02f,
  5.00283539e-02f, -1.26972154e-01f, -5.61667159e-02f, 1.74419694e-02f, -9.15586874e-02f, 1.04820747e-02f, -9.76496413e-02f, -2.92453617e-02f, 2.05256008e-02f, -1.07451439e-01f,
  -5.02664261e-02f, -6.84548244e-02f, -4.06194590e-02f, 6.04630187e-02f, -5.51486062e-03f, -4.51177433e-02f, 1.44666014e-02f, -5.30210175e-02f, -2.92815603e-02f, -9.32589397e-02f,
  -6.38868362e-02f, 2.65641268e-02f, 5.35152480e-02f, 1.22005427e-02f, 5.23590781e-02f, -7.53703490e-02f, 9.69570652e-02f, 2.72295326e-02f, 6.93708360e-02f, 7.24367276e-02f,
  -6.89511606e-03f, 2.25784108e-02f, 3.31476424e-03f, -1.22270681e-01f, -5.02030067e-02f, 3.71773280e-02f, -2.60168016e-02f, 7.43832365e-02f, 5.05180582e-02f, -4.98109125e-02f,
  -1.11184819e-02f, -2.38723848e-02f, 5.61532676e-02f, -2.68352265e-03f, 4.24994305e-02f, -3.41620632e-02f, 3.94807681e-02f, -3.09682041e-02f, -3.10559869e-02f, -4.73917425e-02f,
  1.83370531e-01f, 3.16567630e-01f, 3.04727405e-02f, -8.31638277e-02f, 1.20316535e-01f, 8.44618455e-02f, 1.94558650e-02f, -2.83455532e-02f, 2.43893508e-02f, 7.03760842e-03f,
  3.37805860e-02f, 8.95872489e-02f, 3.35481241e-02f, -1.76172182e-02f, -2.38778088e-02f, -7.31171444e-02f, 2.89261434e-02f, 2.45588291e-02f, 2.77974512e-02f, 1.01006858e-01f,
  2.79397126e-02f, 3.86583991e-02f, -3.16072814e-02f, -2.77648494e-02f, 2.56377589e-02f, 3.27203684e-02f, 1.12496763e-01f, -2.04756781e-02f, -3.05071715e-02f, 8.20294842e-02f,
  3.61411683e-02f, 9.13929269e-02f, 2.95074224e-01f, -1.15123183e-01f, 1.69500321e-01f, 1.40781358e-01f, -1.04729213e-01f, 7.23144263e-02f, -8.49475339e-02f, -1.17161103e-01f,
  -2.52873123e-01f, 1.63415313e-01f, -1.65579900e-01f, -2.66886562e-01f, -3.29572529e-01f, -2.56260604e-01f, -1.43339545e-01f, -1.16589002e-01f, -1.17411558e-02f, -1.95207447e-02f,
  5.48465662e-02f, -2.69960850e-01f, 1.64354309e-01f, 6.17987476e-02f, 1.89369932e-01f, 2.05271557e-01f, -1.44454747e-01f, 2.04779744e-01f, 8.91353190e-03f, 8.83800257e-03f,
  1.87998675e-02f, -9.31162909e-02f, 1.22494146e-01f, 1.86650455e-02f, -5.91269992e-02f, 5.02754264e-02f, 5.37902489e-02f, -3.98558863e-02f, -3.11843660e-02f, 4.02752385e-02f,
  7.37782717e-02f, 5.12238853e-02f, -8.62241611e-02f, -4.22281139e-02f, 9.41240042e-02f, 5.32334857e-02f, 4.28068116e-02f, 1.36789635e-01f, 6.87264055e-02f, 8.43948275e-02f,
  1.19659618e-01f, 8.95417333e-02f, 8.58422220e-02f, -1.63408909e-02f, 8.58953595e-02f, 5.35450364e-03f, 1.12592749e-01f, 6.58797994e-02f, 1.57324336e-02f, -4.35899571e-03f,
  -4.17586379e-02f, -2.32862285e-03f, 5.53956255e-02f, -3.77349532e-03f, -8.34320337e-02f, 5.12980409e-02f, -1.31402444e-02f, 1.81689467e-02f, 1.31057817e-02f, -1.67062655e-02f,
  -9.13242437e-03f, 2.55042017e-02f, 1.93226170e-02f, 4.37564068e-02f, 5.42688817e-02f, 4.62263413e-02f, 7.50373676e-02f, 2.54488420e-02f, 8.62105265e-02f, -1.21197682e-02f,
  -9.36864763e-02f, -1.16399871e-02f, -1.80717986e-02f, 2.68086009e-02f, -8.48753303e-02f, 2.50505414e-02f, 1.54325634e-01f, 7.67520890e-02f, -1.93351489e-02f, 9.59220808e-03f,
  -2.18894497e-01f, -2.14312971e-01f, 2.92608421e-02f, 3.39343697e-02f, -5.72648868e-02f, 3.36488639e-03f, -1.79918315e-02f, 3.27310478e-03f, 1.84262451e-02f, -1.34962767e-01f,
  2.23604515e-02f, 4.46948782e-02f, 4.80098352e-02f, 1.03044305e-02f, -1.80003848e-02f, -9.48072132e-03f, -3.43373306e-02f, -5.13871089e-02f, -4.88405675e-02f, -6.60520718e-02f,
  -3.68073918e-02f, -1.96805224e-02f, 8.11650045e-03f, 5.54527603e-02f, 2.40764022e-02f, 2.25977059e-02f, 4.09326795e-03f, 3.84273045e-02f, -8.96650646e-03f, 8.22565798e-03f,
  -7.63938248e-01f, 3.10869992e-01f, -1.80160522e-01f, -1.63683891e-01f, 4.72039655e-02f, -2.05509275e-01f, -1.49131402e-01f, 1.60628289e-01f, -1.57504424e-01f, 3.72441769e-01f,
  1.41546950e-01f, -1.15049675e-01f, 1.03377067e-01f, 2.10376352e-01f, -3.75761390e-01f, -3.79577428e-02f, -1.70143679e-01f, -1.01654403e-01f, -5.43622710e-02f, 1.55031845e-01f,
  -9.25792679e-02f, 1.97963491e-01f, -2.76415306e-03f, 2.36738354e-01f, -1.17108691e-02f, -1.00542322e-01f, 1.97012722e-01f, -4.39351499e-02f, 1.85978696e-01f, -8.10046680e-03f,
  -8.31797346e-03f, 1.23356521e-01f, 4.21921611e-02f, 2.49426905e-02f, -3.64512093e-02f, 1.10284323e-02f, -2.39649378e-02f, -2.12732721e-02f, -3.88752855e-02f, 1.70425642e-02f,
  -6.34522289e-02f, -9.21821629e-04f, 4.80737612e-02f, -5.31668402e-02f, -4.53982763e-02f, 2.13459413e-03f, -1.08467974e-03f, -9.28891730e-03f, 7.74426060e-03f, -5.73338233e-02f,
  -3.90546098e-02f, -4.65433635e-02f, -8.01838934e-03f, 1.33529967e-02f, -1.20522261e-01f, 1.61042493e-02f, 1.98860113e-02f, -8.12109038e-02f, -6.83602318e-02f, -6.01902320e-06f,
  -2.87874285e-02f, 2.65458319e-03f, -3.94324921e-02f, 7.23123699e-02f, -2.09106319e-02f, 6.49986863e-02f, 2.92823017e-02f, 6.96012676e-02f, -9.02405381e-02f, 2.72890963e-02f,
  1.20758498e-02f, -1.68708321e-02f, 4.20807675e-02f, 1.52372476e-02f, 3.01806740e-02f, 4.06528562e-02f, -2.34812535e-02f, 4.49122302e-02f, -5.61445616e-02f, -1.05554983e-02f,
  2.11917255e-02f, 8.27127416e-03f, 9.62941535e-03f, -3.40865143e-02f, 3.24223451e-02f, -5.08020110e-02f, 3.04762330e-02f, 2.12164931e-02f, 3.99834290e-02f, -7.83303604e-02f,
  2.76411865e-02f, 1.30521104e-01f, 1.24880010e-02f, 4.96169180e-02f, 2.71610487e-02f, 5.57195442e-03f, -2.91665811e-02f, -3.60870399e-02f, -3.00434642e-02f, 2.48553175e-02f,
  1.05259486e-03f, 7.52919614e-02f, -6.59786537e-02f, -8.32766388e-03f, 1.67524666e-02f, 5.73025309e-02f, 5.40474951e-02f, 3.10226008e-02f, -3.51911448e-02f, 6.54784516e-02f,
  2.48481007e-03f, 1.68612767e-02f, -6.04069903e-02f, 1.92354992e-02f, 7.96507373e-02f, -4.29745242e-02f, -3.81176472e-02f, -2.70566903e-02f, 5.52718434e-03f, 1.72323640e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.18907386e-01f, -2.18898028e-01f, 4.39456403e-02f, 9.63318944e-02f, 1.61305174e-01f, 1.21852510e-01f, -4.54934267e-03f, -7.22099617e-02f, -2.19434232e-01f, 8.87632594e-02f,
  -2.15086743e-01f, 8.87406915e-02f, -4.53075945e-01f, -1.57664418e-01f, -4.62064177e-01f, -5.35686553e-01f, -6.32220432e-02f, -2.11599879e-02f, -2.98913926e-01f, 1.40193135e-01f,
  6.11061696e-03f, -1.45435452e-01f, -9.47909355e-02f, 8.34597051e-02f, 2.59447068e-01f, 4.28888857e-01f, 5.49713895e-02f, 4.52910550e-02f, 2.44799897e-01f, -1.66409701e-01f,
  -5.15205413e-03f, -1.98216319e-01f, -4.39243205e-03f, -8.23004916e-02f, 1.30481556e-01f, 1.44582272e-01f, 7.72505030e-02f, -3.41856964e-02f, 4.42190506e-02f, -8.95478856e-03f,
  8.58200639e-02f, -4.02680486e-02f, -1.56230358e-02f, -1.05831869e-01f, -2.67356168e-02f, -8.62838998e-02f, -2.90806331e-02f, 9.48451310e-02f, -4.12720162e-03f, 3.45082805e-02f,
  8.63005519e-02f, 1.26982599e-01f, 1.22240022e-01f, 6.12654202e-02f, 6.23530075e-02f, 3.80681902e-02f, 7.90299997e-02f, 1.38563633e-01f, 2.20050942e-02f, 1.67639717e-01f,
  9.46728978e-03f, 3.22698951e-02f, -7.70845041e-02f, -4.29316312e-02f, -4.29577455e-02f, -4.97227721e-02f, -1.33383140e-01f, -1.23959994e-02f, -7.48571306e-02f, -4.91934158e-02f,
  8.37916359e-02f, -6.95209950e-02f, -1.96516648e-01f, 7.75157511e-02f, 3.02305873e-02f, -7.60404021e-03f, 3.26344706e-02f, 8.37411657e-02f, 8.06863755e-02f, 1.00935185e-02f,
  -1.47199705e-01f, 1.02342516e-02f, 4.03212048e-02f, 1.44528687e-01f, -1.47407055e-01f, 1.28262982e-01f, -1.45188514e-02f, 5.39818518e-02f, -8.10030755e-03f, -8.13374370e-02f,
  1.27739776e-02f, -7.97917396e-02f, -6.34396449e-02f, 1.72281580e-03f, -5.48913032e-02f, 5.94684891e-02f, -1.07154228e-01f, -1.81270503e-02f, -6.92410022e-02f, -5.02347425e-02f,
  2.43070543e-01f, 1.38186306e-01f, 1.85225576e-01f, 3.86526175e-02f, -2.66702212e-02f, -8.06288142e-03f, 7.81991240e-03f, 8.33782554e-02f, 1.01955123e-01f, 5.70691153e-02f,
  1.44187629e-01f, 1.94607496e-01f, -2.07667169e-03f, 1.02101997e-01f, 1.65633470e-01f, 3.27737816e-02f, 1.36405841e-01f, 7.92938173e-02f, -9.44181904e-02f, -1.08757969e-02f,
  4.34668452e-01f, -1.60036117e-01f, -3.30859840e-01f, -5.40113389e-01f, -2.35839054e-01f, -1.83582038e-01f, -4.20152634e-01f, -2.60068923e-01f, -2.37934992e-01f, 9.06265602e-02f,
  -2.77443618e-01f, 1.05539463e-01f, 1.03488140e-01f, -3.93494099e-01f, 2.92758584e-01f, 2.75266260e-01f, -3.59915227e-01f, -2.80371010e-01f, -2.18177870e-01f, -1.27843916e-01f,
  -1.26090497e-01f, -1.47867650e-01f, -1.66089222e-01f, -1.50891766e-01f, -3.11609775e-01f, -1.87930748e-01f, -1.44082252e-02f, -2.08352059e-01f, -3.36942434e-01f, -2.51882970e-01f,
  -1.14812888e-01f, -1.34412386e-02f, -1.13158777e-01f, 8.22650567e-02f, 3.95715199e-02f, -9.47762281e-03f, -1.27982497e-02f, 1.26079088e-02f, -7.34260604e-02f, 2.05987645e-03f,
  1.08071841e-01f, 1.09391607e-01f, -4.49866578e-02f, 1.70468830e-03f, 2.33568680e-02f, -9.70610008e-02f, -2.26828177e-02f, -1.27422325e-02f, 1.86460337e-03f, 3.40108648e-02f,
  -1.85766187e-03f, -5.99335097e-02f, -1.34381756e-01f, -6.53066412e-02f, -7.17086047e-02f, -1.17065467e-01f, 1.68342739e-01f, 2.39981990e-02f, -2.98536774e-02f, 8.77861530e-02f,
  1.36878371e-01f, 2.63613835e-02f, 6.01792447e-02f, -1.12609044e-02f, 2.75519863e-03f, -8.58669803e-02f, 2.60293297e-02f, 6.15444444e-02f, -3.36799622e-02f, -5.74174002e-02f,
  5.07459557e-03f, -1.37048336e-02f, -5.31643210e-03f, 7.28911301e-03f, 3.79307419e-02f, 2.03877956e-01f, 5.22054881e-02f, -3.26432697e-02f, -1.74791232e-01f, 3.59662250e-02f,
  2.22523343e-02f, 4.54471856e-02f, -1.46979928e-01f, -5.75464801e-04f, -4.39686440e-02f, 3.31611298e-02f, 4.07044496e-03f, -1.49362963e-02f, -1.42757475e-01f, 1.48565741e-02f,
  -3.27169448e-02f, 6.97152168e-02f, -6.19759075e-02f, -3.28807347e-02f, 1.92793887e-02f, 8.28428194e-02f, -5.17626293e-02f, -4.64047790e-02f, -1.03589959e-01f, -1.79037489e-02f,
  7.77057111e-02f, 3.25234197e-02f, 6.02726862e-02f, 7.25741833e-02f, 2.29621655e-03f, -9.43675786e-02f, 9.96310860e-02f, -8.02305415e-02f, -6.25326782e-02f, 7.61802495e-02f,
  -1.60289201e-04f, 1.50411949e-01f, 9.22426730e-02f, -1.06671490e-01f, 2.66252309e-02f, 7.62258098e-02f, 1.77386254e-01f, -2.21913103e-02f, 2.76335562e-03f, -1.78355068e-01f,
  6.19422138e-01f, 2.58124202e-01f, 3.87539119e-01f, 7.00375795e-01f, 4.46383506e-02f, -5.39038420e-01f, -1.44328281e-01f, 2.38552287e-01f, 5.36080062e-01f, -5.30700460e-02f,
  -3.07164397e-02f, 1.51922464e-01f, -2.91394204e-01f, 2.87116289e-01f, -6.54094160e-01f, -2.52639323e-01f, -9.32137743e-02f, 5.70216030e-02f, 1.99408806e-03f, 1.92317948e-01f,
  1.65276811e-01f, -1.00969061e-01f, 1.17483558e-02f, -9.29406285e-02f, 3.61033052e-01f, 2.83534765e-01f, -2.42896259e-01f, -8.16284195e-02f, 7.18047619e-02f, -2.70006478e-01f,
  -1.05078444e-01f, 3.76861900e-01f, 2.14838281e-01f, 6.30957931e-02f, -2.04448663e-02f, -7.00349733e-02f, 1.43060768e-02f, -9.66397077e-02f, -8.84765573e-03f, 8.33168551e-02f,
  9.71862487e-03f, -2.22636815e-02f, 6.82973340e-02f, -1.77275464e-02f, 1.67536780e-01f, 2.28696644e-01f, 1.40009463e-01f, 1.13669388e-01f, 1.56089112e-01f, 1.17113262e-01f,
  2.14796126e-01f, 8.39420483e-02f, 5.29958196e-02f, -8.78423899e-02f, 4.64104600e-02f, 1.33024842e-01f, -7.79345855e-02f, -6.22416995e-02f, -5.99073730e-02f, 1.25663564e-01f,
  2.89930776e-02f, -1.47225261e-01f, -5.94811440e-02f, 3.61766666e-02f, 1.34613281e-02f, 8.64161178e-02f, 1.42269582e-02f, -6.69439808e-02f, -3.82384695e-02f, -8.67144167e-02f,
  -7.36990869e-02f, 1.33979321e-01f, 9.68280360e-02f, 6.29909784e-02f, 4.86935526e-02f, 1.02791891e-01f, -1.07863687e-01f, -9.90015045e-02f, -1.28490524e-02f, 7.41927773e-02f,
  1.47565361e-02f, -1.39048725e-01f, 4.01495397e-02f, -1.99392755e-02f, -1.22674495e-01f, -6.36136578e-03f, 1.70438826e-01f, 1.11330919e-01f, 3.00586168e-02f, -1.54415578e-01f,
  -5.53894818e-01f, -2.72657484e-01f, -2.23392993e-02f, -6.05049916e-02f, -4.74053957e-02f, -4.49602418e-02f, 7.40422383e-02f, 5.72665893e-02f, -9.73213464e-02f, -4.52650711e-02f,
  -6.78648204e-02f, 5.04959337e-02f, -9.71579030e-02f, -6.72861934e-03f, -1.08685531e-01f, 1.65807232e-02f, -2.04030313e-02f, -1.33697882e-01f, -1.58034965e-01f, -2.77334470e-02f,
  2.36338470e-02f, -3.17413248e-02f, -7.59117827e-02f, -4.68593696e-03f, -4.34759483e-02f, -4.58107032e-02f, -1.21506052e-02f, 3.41426320e-02f, -7.52208978e-02f, -9.31863859e-02f,
  3.97754312e-01f, -5.38332999e-01f, 4.71174091e-01f, 3.51136997e-02f, 4.46993917e-01f, 2.59046078e-01f, 5.07082939e-01f, -6.15393259e-02f, 6.32408187e-02f, -6.66297317e-01f,
  -7.69718140e-02f, -1.95939362e-01f, 2.95955271e-01f, -3.89338404e-01f, 5.33630073e-01f, 5.11806868e-02f, -2.17481703e-01f, -1.92718282e-01f, 9.18190852e-02f, -1.39664039e-01f,
  5.93473688e-02f, -4.35327530e-01f, 2.58671165e-01f, -4.86066282e-01f, -1.41256349e-02f, -2.65086383e-01f, -1.30889803e-01f, 1.54548556e-01f, -4.39074337e-01f, 5.59846014e-02f,
  -7.58648664e-02f, -1.38342410e-01f, -4.31529023e-02f, -9.82146263e-02f, 4.92296703e-02f, 4.48807254e-02f, 7.29781464e-02f, 1.41865417e-01f, 7.07844421e-02f, -7.13323359e-04f,
  -3.44706886e-02f, 8.58746562e-03f, -2.12762862e-01f, -1.00690462e-02f, 1.63874347e-02f, -5.53840064e-02f, 4.06584516e-02f, 5.46815842e-02f, 5.33418134e-02f, 2.29661793e-01f,
  1.92757234e-01f, 5.35222888e-02f, 1.65191948e-01f, -9.40532982e-02f, 1.32940769e-01f, -7.57189021e-02f, 1.06804401e-01f, 1.31956667e-01f, -3.71812694e-02f, -3.94564420e-02f,
  -2.63489503e-02f, -1.71446428e-02f, 2.90658101e-02f, -3.40119004e-02f, -1.26208866e-03f, -7.29986280e-03f, -4.04668376e-02f, 9.58373118e-03f, 1.50960572e-02f, 6.88135102e-02f,
  2.63905413e-02f, -1.42065482e-02f, 4.52037491e-02f, 2.93581607e-03f, -1.06383134e-02f, 3.72462682e-02f, 3.16668786e-02f, 3.05125769e-03f, 2.87584309e-02f, 4.08639684e-02f,
  5.12474142e-02f, 7.21762702e-02f, 4.78702895e-02f, 4.19638939e-02f, -5.58233485e-02f, 6.69093132e-02f, -1.13442786e-01f, 1.57354265e-01f, 1.04556540e-02f, -2.70857066e-02f,
  -4.77556348e-01f, -6.54457986e-01f, -1.41406402e-01f, -8.03802535e-02f, -1.47163630e-01f, -9.34952125e-02f, -9.48338211e-02f, -1.60152361e-01f, -8.88714716e-02f, 1.34431319e-02f,
  -7.80305415e-02f, 3.60740721e-03f, -1.15369111e-01f, 3.52668390e-02f, -1.39434755e-01f, 8.71714856e-03f, -1.95644833e-02f, -8.65916610e-02f, -9.81059372e-02f, -8.11959580e-02f,
  -4.63121347e-02f, -4.79105897e-02f, -3.00395228e-02f, -5.81503287e-02f, -8.77018422e-02f, -1.88377555e-02f, -8.37987587e-02f, -1.95847377e-02f, -3.43955085e-02f, -3.19356918e-02f,
  -1.65624350e-01f, -1.21232256e-01f, 1.30451638e-02f, 2.96894372e-01f, -4.70791429e-01f, 2.47912958e-01f, 5.40199757e-01f, -2.50728846e-01f, 2.91190058e-01f, 2.37065434e-01f,
  1.08055219e-01f, 1.52233392e-01f, 2.01288566e-01f, 3.04315001e-01f, 2.16180131e-01f, 3.66539508e-01f, 3.14520180e-01f, 2.95488060e-01f, -1.34543166e-01f, 1.51965439e-01f,
  -1.45792812e-02f, 1.31255671e-01f, 1.41136855e-01f, -4.13355231e-01f, -1.45608827e-01f, -3.17492932e-01f, -2.02774540e-01f, -2.31152415e-01f, -8.19099173e-02f, -6.70815706e-02f,
  -1.52935401e-01f, -1.12892270e-01f, 2.99823238e-03f, 1.17341436e-01f, -1.45518571e-01f, -3.75483111e-02f, 6.38826936e-02f, 8.39181915e-02f, -3.14021204e-03f, 1.16138589e-02f,
  1.14774317e-01f, -1.23129986e-01f, 5.08148642e-03f, 5.26839495e-02f, -1.38916336e-02f, -5.81815466e-02f, 4.32086643e-03f, 3.04558631e-02f, -1.21627823e-02f, -9.61875841e-02f,
  2.81999409e-02f, -7.06944540e-02f, 5.50168231e-02f, -3.81755177e-04f, -2.07604300e-02f, 9.61531978e-03f, 1.86568692e-01f, 2.85055693e-02f, -2.04512477e-02f, -1.13883413e-01f,
  8.71587247e-02f, -3.16084288e-02f, -1.22600636e-02f, -6.31969050e-02f, -6.83458708e-03f, -7.76194707e-02f, 1.04339905e-01f, -3.71886045e-02f, 5.23605049e-02f, -2.60285921e-02f,
  6.53483672e-03f, -1.04165822e-02f, -4.91193831e-02f, 1.97062232e-02f, 6.48111925e-02f, 1.10675812e-01f, 6.94859680e-03f, -1.24318533e-01f, -4.33138832e-02f, -3.38221691e-03f,
  5.09535559e-02f, 6.78487271e-02f, -5.48900068e-02f, 2.27390900e-02f, -9.24253836e-03f, -5.66048324e-02f, 1.08166160e-02f, 3.07951923e-02f, 4.06819098e-02f, -1.03931148e-02f,
  -4.02676016e-02f, -2.06057176e-01f, 6.27455786e-02f, 5.49839437e-02f, -4.48054299e-02f, -9.87746939e-02f, 8.98103788e-02f, -2.51976904e-02f, -1.11720413e-01f, 6.17284328e-02f,
  -1.20526172e-01f, 7.21251443e-02f, -1.19479351e-01f, -9.02645960e-02f, -4.44702543e-02f, -4.09084745e-02f, 1.20830923e-01f, -1.12081496e-02f, 7.44207622e-03f, -1.15796208e-01f,
  -1.23070204e-03f, -3.00289765e-02f, -1.59590822e-02f, -4.78583574e-02f, 3.52906473e-02f, -1.66926961e-02f, -3.74508835e-02f, -1.03391698e-02f, -1.27434239e-01f, 4.45660688e-02f,
  3.71351302e-01f, -1.26756832e-01f, -8.65164027e-02f, 8.58704895e-02f, -4.14701216e-02f, 1.44792855e-01f, 5.92030287e-01f, -3.06203783e-01f, -4.28167045e-01f, 3.81200798e-02f,
  2.70527989e-01f, 4.06005122e-02f, 4.51313704e-01f, 2.04350114e-01f, 3.04478645e-01f, 1.91933662e-01f, 5.68623319e-02f, 1.21359557e-01f, -2.36904681e-01f, 1.16150945e-01f,
  -4.64093611e-02f, 2.05114812e-01f, 2.58801669e-01f, -3.74310136e-01f, 2.60947049e-01f, -2.77349770e-01f, 1.51836440e-01f, 1.01884909e-01f, -2.17216030e-01f, 1.08791441e-01f,
  5.45061827e-02f, 4.54754867e-02f, -1.47646489e-02f, -1.18682168e-01f, 7.13430271e-02f, 1.18801340e-01f, 6.25377968e-02f, 1.75595760e-01f, -9.01430473e-02f, -1.47139449e-02f,
  2.62394343e-02f, -1.57980546e-01f, -1.08149126e-01f, 2.67678592e-02f, -3.48469578e-02f, -1.09896824e-01f, -1.47760138e-01f, 2.74664015e-02f, -4.84855473e-02f, 1.13395587e-01f,
  6.51949719e-02f, 1.25497691e-02f, -1.73267480e-02f, -7.51547813e-02f, -3.48800085e-02f, -4.86710295e-02f, -7.19389543e-02f, 1.43107116e-01f, -3.65808308e-02f, -1.03635686e-02f,
  5.00307456e-02f, 3.65377329e-02f, 2.28440408e-02f, -4.96768206e-03f, 7.56713152e-02f, -2.56946515e-02f, -2.95993183e-02f, 1.29611552e-01f, -3.07322964e-02f, 1.28870353e-01f,
  -3.94391865e-02f, -4.53132167e-02f, -1.51587287e-02f, 3.43472809e-02f, 3.74897420e-02f, 5.95262609e-02f, 1.28948003e-01f, -2.44899113e-02f, 3.03740427e-03f, -2.96985619e-02f,
  -2.09601521e-02f, -4.60991561e-02f, 4.56972495e-02f, 5.77349663e-02f, -1.51502192e-02f, 1.03686690e-01f, -2.73148734e-02f, -2.74062864e-02f, -1.13556951e-01f, 9.79837105e-02f,
  -1.73049457e-02f, 3.26208137e-02f, -7.79606849e-02f, -9.13297534e-02f, -1.00656040e-02f, 3.93584631e-02f, 1.14147542e-02f, -1.41692668e-01f, 3.38736586e-02f, 1.41458903e-02f,
  -4.27148007e-02f, -4.28293720e-02f, 8.03417899e-03f, 2.06827056e-02f, -7.27175251e-02f, 9.09743179e-03f, 2.00704038e-02f, -3.34536843e-02f, 7.14767724e-02f, -1.01708412e-01f,
  1.17067732e-02f, -1.65733807e-02f, -4.72542681e-02f, -4.20620739e-02f, -1.18505187e-01f, 1.63606420e-01f, -5.78529537e-02f, -8.00141245e-02f, 1.28971981e-02f, -6.17151409e-02f,
  -3.93017679e-01f, 3.71362925e-01f, 4.19596851e-01f, -7.07462803e-02f, 5.34511209e-01f, 8.05855274e-01f, 2.17874780e-01f, 6.83462203e-01f, 6.82014346e-01f, -4.30923216e-02f,
  -8.57164559e-04f, -1.30073562e-01f, -4.95989472e-02f, 1.53391724e-02f, 2.90278167e-01f, 2.48328283e-01f, 1.56179801e-01f, 7.06565678e-02f, 2.71306127e-01f, 6.53877482e-02f,
  1.37621954e-01f, -1.10797593e-02f, -3.26561183e-01f, -3.87236625e-02f, -1.64009333e-01f, -1.85500592e-01f, -4.34264362e-01f, 1.05757862e-01f, -1.63265377e-01f, 2.28790134e-01f,
  3.40407528e-02f, 5.85778197e-03f, -2.27210477e-01f, 3.16992141e-02f, 6.24202639e-02f, -1.36045953e-02f, -4.66341823e-02f, 5.91919236e-02f, 7.92342331e-03f, 5.42805716e-02f,
  -1.14447452e-01f, -6.27273992e-02f, -1.68445129e-02f, 4.61504646e-02f, 3.07030175e-02f, 3.55778076e-02f, -1.55211072e-02f, 4.78436425e-02f, 6.11634273e-03f, 1.09085336e-01f,
  -3.15341279e-02f, 2.72870287e-02f, -2.69002207e-02f, 4.71441559e-02f, -4.11111489e-02f, -5.47376871e-02f, 6.85384963e-03f, 6.52520806e-02f, 3.60041298e-03f, 1.19576007e-01f,
  5.89469261e-02f, 1.99528873e-01f, -4.33899052e-02f, -3.44686918e-02f, -4.73682210e-03f, -6.47948086e-02f, 3.12671252e-02f, -2.01340448e-02f, -5.70721216e-02f, -7.42761418e-02f,
  -5.55248000e-02f, -3.52002978e-02f, 1.01466171e-01f, 1.41820520e-01f, -7.85353631e-02f, -8.10407177e-02f, -7.98351243e-02f, -2.94488273e-03f, 9.17629674e-02f, 1.48192234e-02f,
  1.50877633e-03f, 6.99517177e-03f, -6.61457479e-02f, -2.71765310e-02f, 1.33747272e-02f, 4.36440706e-02f, 6.48177490e-02f, 6.67893812e-02f, -2.03677192e-02f, -2.25835964e-02f,
  3.36883366e-01f, 4.72244203e-01f, -2.82395203e-02f, -8.58530924e-02f, -1.35284113e-02f, -8.49217735e-03f, 5.50165810e-02f, 1.11424141e-01f, 1.43638402e-01f, 1.21553443e-01f,
  4.18212302e-02f, -4.09268178e-02f, 3.74077521e-02f, -6.11671954e-02f, -1.22314850e-02f, 1.64960295e-01f, -8.37359577e-02f, 4.22662534e-02f, 6.07401319e-02f, 2.68346053e-02f,
  -6.12036884e-02f, -2.79176421e-02f, -4.76215258e-02f, -7.94581398e-02f, -7.05379620e-02f, -7.12295845e-02f, 4.21445630e-02f, -6.47147819e-02f, -4.80006672e-02f, 7.67363682e-02f,
  -8.21806192e-01f, 3.31366301e-01f, -2.20877632e-01f, -2.60943174e-01f, 8.68881345e-02f, -3.44750553e-01f, -2.23746970e-02f, 3.36513132e-01f, -1.25574857e-01f, 3.28828335e-01f,
  1.12305380e-01f, -4.63711530e-01f, 2.87040532e-01f, -1.99814886e-01f, -4.84076291e-01f, -1.70197666e-01f, -2.59140849e-01f, -3.03348243e-01f, -1.39079779e-01f, 1.46946684e-01f,
  -2.42786109e-01f, 8.45539272e-02f, -6.53200522e-02f, 4.80228037e-01f, 5.33492379e-02f, 8.92984867e-02f, 3.87799889e-01f, 3.71686667e-01f, -3.50512937e-02f, -5.41607551e-02f,
  -2.33364627e-02f, 4.72216681e-02f, 7.63081610e-02f, -3.84069141e-03f, 1.76972616e-02f, 3.71442176e-02f, -1.92873571e-02f, -3.81213315e-02f, -5.81569551e-03f, 2.62860190e-02f,
  -9.72755998e-02f, -2.96878591e-02f, -8.61103535e-02f, -9.82463825e-03f, -7.19416738e-02f, -5.43934368e-02f, -4.80791219e-02f, -2.10417770e-02f, 5.34672327e-02f, -1.55248076e-01f,
  -6.11619651e-02f, -1.05430126e-01f, -1.53298497e-01f, -3.68615128e-02f, -7.95537978e-02f, -3.15818675e-02f, -1.80718184e-01f, -6.21209815e-02f, -8.67325962e-02f, -1.46093264e-01f,
  -1.36214092e-01f, -5.57222888e-02f, 1.29517257e-01f, 7.32682720e-02f, 1.44536337e-02f, 4.99670245e-02f, -2.82003209e-02f, -6.30635247e-02f, -7.49236494e-02f, -4.57803048e-02f,
  3.65025178e-02f, -1.10861948e-02f, 4.29350026e-02f, -7.52753615e-02f, -6.49930984e-02f, -1.04024082e-01f, 2.44561546e-02f, 2.52143051e-02f, -1.65575615e-03f, 3.16030197e-02f,
  6.75161406e-02f, -3.37409340e-02f, 3.98043692e-02f, 4.67293803e-03f, -1.30621241e-02f, 6.09274628e-03f, -8.93525407e-02f, -5.47110774e-02f, 1.90282874e-02f, 3.13562825e-02f,
  1.70377523e-01f, 2.26586178e-01f, 9.19379815e-02f, -3.50968279e-02f, 4.83736396e-02f, -2.75968201e-02f, -5.46882711e-02f, -1.08508676e-01f, -2.53866650e-02f, 7.73406550e-02f,
  -1.52148465e-02f, 8.99306461e-02f, 2.17622835e-02f, -1.31026674e-02f, 1.38816619e-02f, 5.89475445e-02f, 8.24018940e-02f, 4.66173552e-02f, 1.50074810e-01f, -2.26118118e-02f,
  1.49001762e-01f, 6.65665567e-02f, -6.42710105e-02f, 1.32261682e-02f, -1.01882815e-01f, 7.17217848e-02f, -5.02295084e-02f, 4.14559543e-02f, -9.60862730e-03f, 4.20690700e-03f,
  2.09780395e-01f, -5.71273230e-02f, -2.62277365e-01f, 1.63057864e-01f, -6.62326254e-03f, 1.29111046e-02f, -1.54809088e-01f, 1.88730642e-01f, -2.33045444e-01f, 9.72258225e-02f,
  3.46694648e-01f, -1.86513409e-01f, -8.93465206e-02f, 4.04584676e-01f, 1.74480870e-01f, 5.40117659e-02f, 4.44555104e-01f, 2.45866105e-01f, -1.42332632e-02f, 1.87835813e-01f,
  1.10996328e-01f, 3.76466602e-01f, 8.45353007e-02f, 2.62105882e-01f, 1.79487586e-01f, 1.27919450e-01f, 1.83640048e-01f, -1.77500471e-01f, 3.11250865e-01f, 7.39780068e-02f,
  5.58731556e-02f, 5.89346141e-02f, -7.47186095e-02f, -1.12591356e-01f, 4.95971628e-02f, -3.34458128e-02f, -1.24490276e-01f, 6.84923008e-02f, -9.59143788e-02f, -3.30777764e-02f,
  -1.76599566e-02f, 4.68615443e-02f, 1.45181805e-01f, -7.03537166e-02f, -2.11193645e-03f, -9.87068340e-02f, -6.35498390e-02f, -5.96185364e-02f, -7.52577931e-02f, 4.15537879e-03f,
  -1.00675218e-01f, 9.46740210e-02f, 2.87895687e-02f, 6.39795437e-02f, 7.23782880e-03f, -2.53473390e-02f, -7.57586583e-02f, -8.85391608e-02f, 9.71276909e-02f, -1.67064667e-02f,
  1.58404052e-01f, 1.55985113e-02f, 4.53638919e-02f, 8.73370543e-02f, -1.30712196e-01f, 9.00776014e-02f, 4.23739776e-02f, 9.39565375e-02f, -9.78518203e-02f, -5.06226793e-02f,
  1.36186883e-01f, -4.92972787e-03f, -5.11316769e-02f, -4.67241667e-02f, 6.47584647e-02f, -4.73864451e-02f, -9.81716812e-03f, 9.34048891e-02f, -5.87532111e-02f, 3.82837057e-02f,
  -3.13942395e-02f, -3.09320968e-02f, -8.42603594e-02f, 3.44017446e-02f, 6.82831630e-02f, -1.09082356e-01f, 5.27915508e-02f, -4.46624644e-02f, -9.46678221e-03f, 3.68353724e-02f,
  7.72395805e-02f, 2.57482063e-02f, -6.98503926e-02f, -3.33933532e-03f, -4.03305702e-02f, -1.84728336e-02f, -6.51468113e-02f, 9.14176330e-02f, 7.44422823e-02f, -2.13183016e-02f,
  2.21729223e-02f, -3.47692594e-02f, 5.81130944e-02f, -2.01021079e-02f, 7.95599073e-02f, -1.08526982e-02f, 1.92754045e-02f, -6.72961622e-02f, -2.96851760e-03f, 6.84087425e-02f,
  5.93267642e-02f, 2.83570476e-02f, 3.37526994e-03f, -5.42566404e-02f, 7.32263923e-02f, -1.86757825e-03f, -2.94439737e-02f, -3.47520150e-02f, 1.30396917e-01f, 7.90360197e-02f,
  -1.46885542e-02f, -7.88296387e-02f, -1.64217770e-01f, -9.15797129e-02f, -5.46971299e-02f, -1.43537745e-01f, -4.54106927e-01f, -8.02419260e-02f, -4.09189045e-01f, 3.30471131e-03f,
  -9.84589383e-02f, -5.62761538e-02f, -3.44667077e-01f, -5.17387921e-03f, 1.97346900e-02f, -4.69147801e-01f, 3.06067109e-01f, -2.26566903e-02f, -1.46445215e-01f, 3.10355663e-01f,
  9.77520645e-02f, 2.16432810e-01f, 5.41511811e-02f, 2.98398674e-01f, 2.29685694e-01f, 2.29783103e-01f, 5.89585841e-01f, 3.79566476e-02f, 4.26255167e-01f, 1.37342095e-01f,
  -2.00028807e-01f, -6.35808706e-02f, -9.38941166e-02f, -8.66250172e-02f, 1.59068733e-01f, 1.26288474e-01f, 1.04799695e-01f, -3.82084250e-02f, -1.80852041e-01f, -6.36813417e-02f,
  1.18324690e-01f, 5.73247718e-03f, 7.71589857e-03f, -7.36509413e-02f, -1.47407632e-02f, 2.81006098e-02f, 1.18108438e-02f, 4.21294868e-02f, -9.01172683e-02f, -3.68503816e-02f,
  -1.56355336e-01f, -4.84537147e-02f, 1.28835723e-01f, 1.79423857e-03f, 5.23413578e-03f, 4.76174019e-02f, 1.12812361e-02f, 1.67837963e-02f, 1.36842772e-01f, 1.93179883e-02f,
  6.37339801e-02f, 1.64085682e-02f, -4.46595997e-02f, -1.67061195e-01f, -4.21439521e-02f, -6.85957819e-02f, 7.06429556e-02f, 4.94761430e-02f, -2.06832755e-02f, -3.42754796e-02f,
  1.11427531e-01f, 1.73858833e-02f, -5.46634197e-02f, 2.37545632e-02f, 2.51351316e-02f, -7.48106763e-02f, -6.85064727e-03f, -2.00202148e-02f, 2.29955073e-02f, -2.20088176e-02f,
  -3.78037207e-02f, 5.15469760e-02f, -1.50921658e-01f, 5.26303947e-02f, -1.11758381e-01f, -8.36039186e-02f, 3.37249078e-02f, -1.08804628e-02f, 1.67626347e-02f, 1.25154838e-01f,
  1.75096422e-01f, 2.88049430e-01f, -7.30485320e-02f, -1.05521239e-01f, -1.67647079e-02f, 5.97939789e-02f, -4.29928638e-02f, 7.70609751e-02f, 4.96378392e-02f, 4.35980894e-02f,
  1.51991785e-01f, 8.38783085e-02f, 1.88121289e-01f, -5.00030667e-02f, 3.38489302e-02f, 5.19787194e-03f, 9.14697051e-02f, 1.45206926e-02f, 1.11440338e-01f, 1.51553035e-01f,
  7.86794573e-02f, -4.60679345e-02f, 8.87219533e-02f, -3.98586579e-02f, 2.36847308e-02f, 6.87597692e-02f, -6.97863922e-02f, -3.40079442e-02f, 1.58952251e-01f, -5.17202318e-02f,
  3.00328553e-01f, 1.76643743e-03f, -2.23042548e-01f, -1.88794747e-01f, 2.38357410e-01f, 2.20279172e-01f, -2.60346174e-01f, 2.05873940e-02f, -2.23645791e-01f, -2.98456103e-01f,
  1.15790896e-01f, -1.70865744e-01f, -5.98179810e-02f, 3.23022395e-01f, 2.93482929e-01f, 8.85407478e-02f, 2.90982425e-01f, 1.86439067e-01f, 2.29373857e-01f, 2.58062750e-01f,
  2.46044531e-01f, 5.48558891e-01f, 3.49902600e-01f, 4.02760953e-01f, 3.99497747e-01f, -2.93749906e-02f, 2.45150495e-02f, -1.50714163e-02f, 8.15724060e-02f, 1.47961646e-01f,
  6.71292171e-02f, 1.12277135e-01f, 1.13431387e-01f, -1.03996582e-02f, 1.55453056e-01f, 1.55312987e-02f, -9.71259177e-02f, -1.28454044e-01f, -1.01833463e-01f, -5.76615147e-02f,
  -6.44614100e-02f, 5.43617606e-02f, 3.25996848e-03f, -1.92658894e-03f, 6.10785857e-02f, -1.06427865e-02f, 8.75707492e-02f, 5.22452919e-03f, -6.07508533e-02f, 3.38782109e-02f,
  -5.03990091e-02f, -6.57001464e-03f, -1.25256330e-02f, -8.04775059e-02f, -1.13039203e-01f, -1.11859329e-01f, -1.37681156e-01f, -9.14320946e-02f, -5.89884520e-02f, 1.94242522e-02f,
  6.65845573e-02f, 2.36402098e-02f, 7.25456357e-06f, 5.40770814e-02f, 6.38276264e-02f, -4.54480089e-02f, -2.56036166e-02f, 1.62856001e-02f, -7.87514448e-02f, 4.40479070e-02f,
  -5.33173457e-02f, -1.04334846e-01f, -5.45037948e-02f, -1.05716661e-01f, 2.50716303e-02f, 7.45298639e-02f, 3.26446258e-02f, 2.51546800e-02f, 4.85163815e-02f, 4.77302410e-02f,
  -2.10832339e-03f, 8.47809687e-02f, 8.15082490e-02f, 1.88631192e-02f, -4.53391811e-03f, -2.72959396e-02f, -6.41257614e-02f, 2.16257125e-02f, -1.44670429e-02f, 7.42454231e-02f,
  1.32554516e-01f, 7.13174418e-02f, -8.24644417e-02f, 3.60181974e-03f, -2.90175807e-02f, 1.61073804e-01f, 5.20564765e-02f, 1.35745257e-02f, 2.63669342e-02f, 1.09581009e-01f,
  -3.82552892e-02f, -8.59168321e-02f, -3.08223423e-02f, 6.56555369e-02f, 1.46435406e-02f, -3.75291258e-02f, -1.02003776e-01f, -2.05676824e-01f, -4.23516780e-02f, 9.02740285e-02f,
  -5.13474690e-03f, 2.59679314e-02f, -1.36482373e-01f, -2.71985563e-03f, -6.94399998e-02f, -9.87566859e-02f, 6.90208524e-02f, -1.05174631e-01f, 2.92156893e-03f, -8.76811445e-02f,
  4.09265101e-01f, -4.30312902e-01f, -4.65230197e-01f, 1.62953854e-01f, 3.03203970e-01f, 4.45793830e-02f, -1.43665954e-01f, 6.83826655e-02f, -3.80102620e-02f, -2.01004356e-01f,
  3.32803838e-02f, 8.99570212e-02f, -4.49021608e-01f, 3.75121534e-01f, 4.96381640e-01f, -2.86685199e-01f, 3.72086108e-01f, 1.63375884e-01f, -2.66524460e-02f, -3.28269452e-02f,
  1.47461578e-01f, 4.85550791e-01f, 1.11693302e-02f, 2.10089132e-01f, 2.03721657e-01f, 4.05689925e-02f, 2.64607191e-01f, -2.55194455e-01f, 2.65837610e-01f, 3.55049938e-01f,
  4.44377363e-02f, -5.48756856e-04f, -1.67641845e-02f, -7.02458154e-03f, -8.02491680e-02f, -1.51437176e-02f, -1.41637372e-02f, 8.42336193e-02f, 5.60249127e-02f, -5.61404079e-02f,
  -9.23721194e-02f, 1.61293060e-01f, 1.44362569e-01f, 3.69208157e-02f, 1.29920933e-02f, 1.20343842e-01f, -2.41973903e-02f, -1.57406271e-01f, 1.03526926e-02f, 6.16527162e-03f,
  -1.81082785e-01f, -4.82370928e-02f, -1.22174406e-02f, 2.75408700e-02f, -1.07035510e-01f, 4.57174890e-02f, 3.00565492e-02f, -9.37309787e-02f, -1.75345540e-02f, 7.62367100e-02f,
  2.40627825e-02f, -2.41900831e-02f, 5.12020215e-02f, 3.32897156e-02f, -6.81871101e-02f, 9.28314030e-03f, -1.09177083e-03f, -6.68134727e-03f, -6.66563511e-02f, -7.16861561e-02f,
  3.52674015e-02f, 2.47847252e-02f, 3.13876607e-02f, 5.54052275e-03f, 8.15569796e-03f, 9.55860838e-02f, 4.40767370e-02f, 1.75746344e-02f, -1.25400826e-01f, -3.60662006e-02f,
  9.11455676e-02f, 5.73394448e-02f, -4.33753394e-02f, -2.92679276e-02f, 9.25777480e-02f, -1.15412779e-01f, -6.40606880e-02f, -7.39436671e-02f, -1.00342199e-01f, -6.79861605e-02f,
  -1.12124532e-01f, -1.30428120e-01f, -4.69683260e-02f, 6.74014241e-02f, -6.67829663e-02f, 1.36155477e-02f, 3.52512933e-02f, 4.38985191e-02f, 7.81038776e-02f, -4.95449156e-02f,
  9.10430215e-03f, 2.47025080e-02f, -1.49360579e-02f, 8.87547582e-02f, -2.59956019e-03f, -5.31533584e-02f, -3.80598418e-02f, 2.66081933e-02f, 1.10141411e-01f, 1.59395393e-03f,
  -4.99083567e-03f, -6.43190816e-02f, 5.16955331e-02f, 4.47130576e-02f, -1.48533555e-02f, -2.06981171e-02f, 1.63629297e-02f, -6.89443666e-03f, -4.18113396e-02f, -1.85920708e-02f,
  1.54939443e-01f, 4.14620429e-01f, 5.55372611e-02f, 1.20199911e-01f, -1.62191942e-01f, 4.35537882e-02f, -2.38641724e-02f, 5.16909882e-02f, -2.60844082e-02f, 8.36407840e-02f,
  2.64992425e-03f, 2.50694275e-01f, -1.26950592e-01f, 3.28018934e-01f, 2.35360831e-01f, -1.74239159e-01f, 2.70940065e-01f, 1.46640956e-01f, -4.39830730e-03f, 3.47923636e-01f,
  -6.70450646e-03f, 2.82148182e-01f, -1.27814207e-02f, 1.46094680e-01f, 2.24818140e-01f, 1.73913658e-01f, 7.60319158e-02f, -5.21275513e-02f, 3.49940151e-01f, 1.55347377e-01f,
  -1.11117475e-01f, 6.23027310e-02f, 3.08161951e-03f, -3.71643975e-02f, -1.08388066e-02f, 1.87113862e-02f, 2.27938332e-02f, -8.96434672e-03f, -4.56561781e-02f, 3.41119803e-02f,
  1.66237503e-02f, 5.05472682e-02f, 8.92234296e-02f, 5.49901985e-02f, 7.28811994e-02f, 1.18068948e-01f, 3.07987295e-02f, 5.80670265e-03f, 8.18269104e-02f, 2.82727629e-02f,
  5.93986772e-02f, -3.81917134e-02f, -2.59305183e-02f, -3.91082605e-03f, 4.10380550e-02f, 2.51898170e-03f, 1.02862917e-01f, 4.53759767e-02f, 8.25219899e-02f, 1.39456034e-01f,
  5.60807809e-02f, -7.64421448e-02f, -1.50529491e-02f, 4.30709869e-02f, 9.83732268e-02f, -2.44574398e-02f, -3.18860188e-02f, -1.69486813e-02f, 2.67729331e-02f, 9.04627293e-02f,
  -5.37714548e-02f, 6.06834888e-02f, 1.30841713e-02f, 4.16936055e-02f, 3.63761671e-02f, 2.97726318e-02f, -1.91290525e-03f, -1.62410960e-02f, -3.18962634e-02f, -9.10201892e-02f,
  -2.89547313e-02f, 2.11585383e-03f, -7.11080572e-03f, -1.23395666e-01f, -6.45825490e-02f, 7.62500465e-02f, 8.29823613e-02f, 8.72698277e-02f, -1.11560978e-01f, 4.27006371e-02f,
  1.65863618e-01f, 4.89031434e-01f, 3.21993008e-02f, 3.21794041e-02f, -2.37267017e-02f, 9.81314331e-02f, 5.32024726e-02f, 7.68342540e-02f, 1.95184574e-01f, 1.03543609e-01f,
  8.95318314e-02f, -1.01311781e-01f, 3.39046754e-02f, 8.00287910e-03f, 2.03123800e-02f, 1.65287599e-01f, 3.41962613e-02f, 5.59403095e-03f, 4.84253764e-02f, 1.02563702e-01f,
  4.73000184e-02f, -1.91751216e-02f, 9.87030379e-03f, -4.21377383e-02f, 2.50324421e-02f, 4.67657372e-02f, 1.42950788e-01f, 3.92622463e-02f, 8.06641430e-02f, -1.45043023e-02f,
  -4.14885953e-02f, -6.07794523e-02f, -1.70643479e-02f, 4.20159519e-01f, -5.72227836e-02f, 1.44038379e-01f, 4.32790607e-01f, -2.18312237e-02f, 5.59314907e-01f, 2.26690713e-02f,
  -7.10390061e-02f, -6.69311285e-02f, -1.23846620e-01f, 2.68482983e-01f, 2.12754738e-02f, 2.04552799e-01f, 3.04777861e-01f, 1.78959355e-01f, 1.71911404e-01f, 7.30376989e-02f,
  1.36982724e-01f, 6.17680103e-02f, -1.50134489e-01f, -1.06084965e-01f, -2.81220376e-01f, 7.75466114e-02f, -3.66797060e-01f, -1.04025036e-01f, -2.55441517e-01f, -3.39777917e-02f,
  1.65559709e-01f, 2.30890527e-01f, -2.25261614e-01f, 7.37543553e-02f, 7.15436041e-02f, 1.66828111e-02f, 1.18027730e-02f, -1.78257301e-02f, 7.14377239e-02f, -5.96308941e-03f,
  -4.36391383e-02f, 1.49420528e-02f, 7.25906566e-02f, -6.23544119e-02f, 1.75559878e-01f, 2.55429838e-02f, 1.11256167e-03f, -6.63322210e-02f, -9.63327289e-02f, -2.45369896e-01f,
  -1.08402416e-01f, -1.46890420e-03f, 9.26123187e-02f, -6.04397559e-04f, -5.21665141e-02f, 2.54792571e-01f, 7.55092874e-02f, -5.91128506e-02f, -2.74613220e-02f, 5.60042150e-02f,
  -1.20182380e-01f, 1.20814189e-01f, 6.10875636e-02f, 8.49141404e-02f, -3.49711478e-02f, 4.63365354e-02f, 8.30938220e-02f, 3.65728959e-02f, 9.46706235e-02f, -2.35281363e-02f,
  6.80506900e-02f, 2.69026891e-03f, 1.71924815e-01f, 4.76245135e-02f, 9.69905630e-02f, 8.70380029e-02f, -4.17033657e-02f, 4.80704978e-02f, 1.58711657e-01f, 1.81896001e-04f,
  -9.99096334e-02f, 3.14811768e-04f, -6.54142424e-02f, 1.03640591e-03f, 4.36785482e-02f, -4.94864136e-02f, -7.41846636e-02f, -1.30225360e-01f, 1.01515792e-01f, -3.51551585e-02f,
  1.82194725e-01f, 1.51023716e-01f, 2.47363765e-02f, 1.25716552e-01f, 7.74784982e-02f, -1.33564442e-01f, 2.32125372e-02f, -2.97340378e-02f, 1.03866771e-01f, -2.28110068e-02f,
  -3.99294123e-03f, 2.07842961e-02f, 6.43108860e-02f, -3.06418091e-02f, 5.96101172e-02f, -7.02258348e-02f, 1.60716131e-01f, 5.67655563e-02f, 9.60809588e-02f, -2.03142136e-01f,
  -9.86186564e-02f, 9.27165672e-02f, 6.55279383e-02f, 1.22485369e-01f, -2.86345705e-02f, 5.32835396e-03f, -5.53442389e-02f, -2.07571257e-02f, -1.39033310e-02f, 8.98421705e-02f,
  -5.30002773e-01f, 1.64008841e-01f, -7.73119986e-01f, -2.49726385e-01f, 3.13782990e-01f, -1.47112310e-01f, 5.43070138e-02f, 1.54411212e-01f, 2.16926001e-02f, 5.63758373e-01f,
  4.85684812e-01f, -1.44366892e-02f, 2.02993318e-01f, 1.24610372e-01f, -6.62595630e-01f, -1.52334228e-01f, -1.13930643e-01f, 5.46623580e-02f, -1.43639594e-01f, 6.61058053e-02f,
  -2.37580717e-01f, 3.62498730e-01f, -4.12177086e-01f, 2.83730507e-01f, 5.83344437e-02f, -1.97303355e-01f, 2.88033843e-01f, 1.84807684e-02f, 4.15360481e-02f, 6.47262260e-02f,
  -6.90028965e-02f, 1.75963029e-01f, -7.12525398e-02f, -1.48856372e-01f, -1.19091719e-01f, 1.69460978e-02f, -5.14630973e-02f, -7.71958977e-02f, -7.74184242e-02f, -5.09545505e-02f,
  1.12966947e-01f, -7.48563632e-02f, 2.64963731e-02f, -2.94986041e-03f, 1.16182148e-01f, 4.29903194e-02f, -1.16055049e-01f, -8.99925008e-02f, 3.31822038e-02f, -8.52304101e-02f,
  -1.25944465e-01f, -1.58784837e-01f, 4.35741730e-02f, -9.83523801e-02f, -1.38058826e-01f, -6.98719099e-02f, -6.23097941e-02f, -9.26953461e-03f, -5.94770610e-02f, -3.88750397e-02f,
  7.44292792e-03f, 4.87674773e-02f, -6.96610212e-02f, 5.47383912e-02f, -9.19615384e-03f, -4.84564938e-02f, 7.08369836e-02f, 5.84841557e-02f, -3.77501287e-02f, 8.47689509e-02f,
  1.32268220e-02f, -1.12505471e-02f, 6.43109381e-02f, -7.20363762e-03f, -8.06050282e-03f, -5.06324768e-02f, -1.85569469e-02f, 7.60819204e-03f, -6.55148700e-02f, -9.17027816e-02f,
  6.19954504e-02f, -3.40621695e-02f, 5.28088287e-02f, 1.33653134e-01f, 6.23872168e-02f, 2.29250211e-02f, 1.23061210e-01f, -8.16261917e-02f, 4.69280593e-02f, 7.38693075e-03f,
  1.62609145e-01f, 1.83467731e-01f, -6.90979091e-03f, 1.03061810e-01f, -6.14982273e-04f, 3.83506082e-02f, -4.00737487e-02f, -8.82252231e-02f, -2.50366293e-02f, 2.47905981e-02f,
  8.90922826e-03f, 6.91638738e-02f, -3.71563323e-02f, 3.41625176e-02f, -7.72979518e-04f, 1.21058077e-01f, 1.03256315e-01f, 9.24364291e-03f, 7.09332898e-02f, 2.45636534e-02f,
  7.77684152e-02f, 7.28091225e-02f, -1.64265156e-01f, 6.42827377e-02f, 1.30413532e-01f, 1.17697142e-01f, 2.03790337e-01f, -8.22702870e-02f, -4.77004535e-02f, 2.01281104e-02f,
  1.54294387e-01f, -4.83149774e-02f, -4.93938327e-01f, 8.92525613e-02f, -2.56629381e-02f, 1.70869321e-01f, 2.13464558e-01f, -1.11155331e-01f, -1.53262004e-01f, 4.68541652e-01f,
  4.84629184e-01f, -3.30956757e-01f, 1.11262225e-01f, 6.02763355e-01f, -2.49379113e-01f, 2.26691321e-01f, 2.33816624e-01f, 3.14439863e-01f, -1.81862935e-01f, -4.28494141e-02f,
  -1.23330437e-01f, 4.15300667e-01f, -6.07383773e-02f, -1.57794446e-01f, 2.58075804e-01f, -2.91882366e-01f, 1.93348274e-01f, -3.21701109e-01f, 1.96844280e-01f, -5.97443059e-02f,
  1.27418891e-01f, 5.51115572e-02f, -8.59376565e-02f, -7.99143538e-02f, 2.77256835e-02f, 7.79394209e-02f, -1.99814909e-03f, -1.39154911e-01f, -8.07193294e-02f, 1.37399957e-02f,
  -6.65007308e-02f, -8.69592279e-02f, 1.32149076e-02f, -2.86234170e-02f, 9.69509687e-03f, -7.97621086e-02f, -1.40813198e-02f, 9.84077305e-02f, -6.78163841e-02f, 8.27477202e-02f,
  1.96145251e-02f, 6.73183575e-02f, 7.78882802e-02f, -1.00353891e-02f, -8.97963867e-02f, -7.20810797e-03f, -1.10589750e-01f, -9.22109485e-02f, -2.95377318e-02f, -4.10694666e-02f,
  1.16680535e-02f, -1.83400325e-02f, 1.41512364e-01f, 9.04128850e-02f, -7.66200572e-02f, 1.05312094e-03f, 5.28106205e-02f, 3.94008979e-02f, -9.82254669e-02f, 1.45481601e-02f,
  -1.65647306e-02f, -3.67138069e-03f, 7.56965624e-03f, 6.64793849e-02f, 1.47206426e-01f, 4.35922369e-02f, -3.32882367e-02f, -3.16564776e-02f, 7.67337382e-02f, -6.13729528e-04f,
  2.17727665e-02f, -2.32675541e-02f, -2.19307374e-02f, 6.26147613e-02f, 3.10287122e-02f, -7.88468942e-02f, 1.22909971e-01f, 9.41849202e-02f, 6.06181249e-02f, -8.91499519e-02f,
  3.87353338e-02f, -1.72876745e-01f, -4.68196832e-02f, -1.24374554e-01f, -1.08893462e-01f, 9.95885059e-02f, -1.45183764e-02f, -7.47920349e-02f, -6.46459609e-02f, 4.50101634e-03f,
  -1.12971580e-02f, 6.00476414e-02f, -1.73034612e-02f, 8.42251331e-02f, -1.15372419e-01f, 1.24301091e-01f, 5.86641431e-02f, -7.52756968e-02f, -4.26785275e-02f, -8.50397348e-02f,
  -1.15265306e-02f, 4.99710627e-02f, -8.29990730e-02f, -4.01922595e-03f, 4.95308265e-02f, 4.47288863e-02f, -1.24231629e-01f, -3.33674364e-02f, 4.15778905e-02f, -4.78178225e-02f,
  -3.84436637e-01f, 5.34006178e-01f, 2.94651479e-01f, 2.73860097e-01f, -5.49889505e-01f, 1.89315438e-01f, 4.54405814e-01f, 7.34569952e-02f, 4.21899676e-01f, 4.64003831e-01f,
  -2.11865351e-01f, 2.94469804e-01f, 6.56715035e-02f, 2.36055434e-01f, -2.14385778e-01f, 2.12429553e-01f, 1.40402257e-01f, 3.18083555e-01f, -5.33521920e-02f, 9.95986909e-02f,
  -1.35598257e-01f, -1.38887197e-01f, -9.70130861e-02f, -1.15203604e-01f, -9.82258767e-02f, 4.90973983e-03f, -3.36678326e-01f, -4.50386340e-03f, -1.40377982e-02f, -1.16200887e-01f,
  -2.27397293e-01f, -9.49314982e-02f, -1.03245355e-01f, 1.24264341e-02f, -8.88929442e-02f, -3.45865488e-02f, 8.01872984e-02f, -8.19948763e-02f, -8.22221711e-02f, 1.97275747e-02f,
  2.20884960e-02f, 1.89307313e-02f, 2.97518466e-02f, 8.97338241e-02f, 7.80922174e-02f, -2.84634270e-02f, -3.80592644e-02f, -8.56389701e-02f, 7.57145137e-02f, -3.76533233e-02f,
  1.61241628e-02f, -2.21036188e-02f, -1.24487855e-01f, 1.25157937e-01f, -1.15450084e-01f, 1.44192381e-02f, 2.87791360e-02f, -5.63405454e-03f, -7.42526129e-02f, 3.40089318e-03f,
  6.26504719e-02f, 5.21392524e-02f, 1.35655478e-02f, 9.25740674e-02f, 8.92278180e-03f, -4.88635376e-02f, 1.34599749e-02f, -1.28290564e-01f, -4.67688683e-03f, -3.62098366e-02f,
  -6.13384182e-03f, -7.23116100e-03f, -1.00692019e-01f, 3.66480350e-02f, 1.00369724e-02f, 1.09624177e-01f, 2.49948855e-02f, -2.51371711e-02f, 3.75394709e-02f, -4.40511219e-02f,
  1.01759076e-01f, 5.03138602e-02f, -5.10360859e-02f, -1.20240062e-01f, -2.14754092e-03f, 2.11715959e-02f, 6.91317255e-03f, 6.68854266e-02f, -4.60482277e-02f, -1.29080936e-01f,
  9.73624587e-02f, 2.64298886e-01f, -6.35826141e-02f, -4.94651683e-02f, 9.32884663e-02f, -2.15222184e-02f, -1.78057328e-02f, -1.04797557e-01f, 2.47479863e-02f, 2.33676694e-02f,
  -4.91985194e-02f, 5.80605790e-02f, -8.70755091e-02f, 3.51622738e-02f, 9.71364900e-02f, -2.79005170e-02f, 1.11476406e-01f, 1.10612236e-01f, -3.74372900e-02f, 1.16553437e-02f,
  -7.39020109e-02f, 1.04607560e-01f, -1.76660717e-03f, -8.51837471e-02f, -6.12873398e-02f, -3.02125290e-02f, 5.59916794e-02f, 1.98784936e-02f, -1.70328707e-01f, 4.15335782e-02f,
  -3.32708299e-01f, -5.14047623e-01f, -1.63769200e-01f, 1.31495729e-01f, 3.68890837e-02f, 1.50027648e-01f, 3.33416939e-01f, -3.20397496e-01f, -4.31500226e-01f, -7.95930550e-02f,
  1.38049766e-01f, -1.46126658e-01f, -7.78108239e-02f, -3.11607551e-02f, 1.53471738e-01f, -9.09994245e-02f, 1.44868314e-01f, 1.28007755e-01f, -2.49507219e-01f, -1.82298467e-01f,
  -6.57317638e-02f, -7.77615458e-02f, 1.52809992e-01f, -1.51553109e-01f, -5.57257198e-02f, 2.44127717e-02f, 2.62040347e-01f, 1.06957696e-01f, 2.32489586e-01f, 2.18948543e-01f,
  7.14520365e-02f, -2.74744183e-01f, -5.26246466e-02f, 6.13874681e-02f, -4.29298729e-02f, 1.72836274e-01f, 1.61214754e-01f, 1.22605778e-01f, 1.56032398e-01f, -1.16222478e-01f,
  7.05891177e-02f, 2.06530336e-02f, -6.63321763e-02f, 1.24988407e-01f, -5.79437912e-02f, -5.37338220e-02f, -4.95182313e-02f, -8.43876898e-02f, -1.02352768e-01f, -6.62105829e-02f,
  -1.66381434e-01f, -1.44186959e-01f, -2.88035721e-03f, -3.23875844e-02f, -7.11441860e-02f, -4.23355661e-02f, 4.15577963e-02f, 6.68610856e-02f, -1.25897348e-01f, -8.08388516e-02f,
  -5.02371304e-02f, 3.96185135e-03f, -7.22020343e-02f, -1.05406903e-02f, -5.46342023e-02f, 2.20914390e-02f, 3.80136333e-02f, 8.52441639e-02f, -1.95956100e-02f, -5.07522710e-02f,
  -1.83201890e-04f, -1.64255556e-02f, 1.08523304e-02f, 1.16648108e-01f, 3.74013111e-02f, -4.91488678e-03f, 1.09542556e-01f, -5.80185205e-02f, -1.50066307e-02f, 1.76727232e-02f,
  2.61074584e-02f, 2.00858209e-02f, 7.26127550e-02f, 4.46128063e-02f, -3.26016061e-02f, 1.94861311e-02f, 3.32770944e-02f, -3.24996486e-02f, 2.75539588e-02f, 5.59257157e-02f,
  1.38341244e-02f, -3.08267862e-01f, -6.47732839e-02f, 9.01189446e-02f, 5.20774946e-02f, -1.64658964e-01f, -6.91823196e-03f, -1.06944814e-01f, 5.73154017e-02f, -1.18400194e-01f,
  7.88206235e-02f, 1.00122891e-01f, -4.00176011e-02f, -1.43691842e-02f, 1.23256966e-01f, 1.23541302e-03f, 1.07430734e-01f, -1.88647434e-02f, 1.79574769e-02f, 1.66555513e-02f,
  -5.46506867e-02f, 1.18127232e-02f, 2.04129871e-02f, -1.48806095e-01f, 2.05521807e-02f, 1.48429563e-02f, -1.06452135e-02f, 3.32712494e-02f, 5.32542206e-02f, -3.98001373e-02f,
  -6.67257011e-01f, -2.85740823e-01f, 3.14312547e-01f, 1.15689836e-01f, -2.73455769e-01f, -2.52491593e-01f, 9.09490511e-02f, -1.43334985e-01f, -4.96589541e-01f, -2.07324386e-01f,
  1.08709656e-01f, -5.22874407e-02f, 1.73614293e-01f, 2.56471127e-01f, 5.15813112e-01f, 1.67965129e-01f, 1.84558123e-01f, 1.30357429e-01f, 1.08793549e-01f, 1.18734781e-02f,
  2.44994447e-01f, 1.46514267e-01f, 6.11428440e-01f, 9.96673033e-02f, -8.52627307e-03f, 1.61719337e-01f, 3.01796526e-01f, 2.72444606e-01f, 1.03602685e-01f, 1.98426753e-01f,
  -2.55539775e-01f, -9.67604294e-02f, 1.35022998e-02f, -1.21441446e-01f, 1.30773745e-02f, 1.35089634e-02f, 1.55216560e-01f, 1.67257532e-01f, 7.20705315e-02f, 7.91943744e-02f,
  -1.34502187e-01f, -4.78628837e-02f, -3.64699177e-02f, 3.95491906e-03f, -2.89842248e-01f, -6.50734305e-02f, -1.31591558e-01f, -6.46730438e-02f, -4.45187837e-02f, -8.76875222e-02f,
  4.28220034e-02f, -6.34353468e-03f, 2.22026110e-02f, 1.15822583e-01f, 5.25492057e-02f, -1.10454723e-01f, 4.64887545e-02f, 2.80571412e-02f, -4.51030247e-02f, -9.50603932e-03f,
  -2.21048184e-02f, 5.28981686e-02f, -5.79368621e-02f, -2.47916430e-02f, -6.35150746e-02f, 2.99376715e-02f, 3.59653831e-02f, 2.70061530e-02f, 5.09535633e-02f, -4.22059260e-02f,
  -4.84746583e-02f, 1.19658457e-02f, -2.12395079e-02f, -8.08882788e-02f, -7.25957006e-02f, -2.16994416e-02f, 1.09869272e-01f, -3.70683521e-02f, -9.24161449e-03f, 4.15005423e-02f,
  7.11657554e-02f, -5.37835993e-02f, -6.89616203e-02f, 6.17893413e-02f, 5.87936630e-03f, 5.05678393e-02f, 1.37814671e-01f, -5.69865182e-02f, 7.05015957e-02f, 2.06209600e-01f,
  -4.33497071e-01f, -1.67605337e-02f, 3.06175835e-02f, -1.41965285e-01f, 1.10339992e-01f, -3.31468396e-02f, 3.21579427e-02f, -7.30399042e-02f, -5.30028604e-02f, -4.68861423e-02f,
  -1.29452467e-01f, 6.43095970e-02f, -7.58775994e-02f, 3.36364321e-02f, 1.11673303e-01f, -7.22035468e-02f, 1.84564684e-02f, 3.19351107e-02f, 6.81294650e-02f, 4.53103557e-02f,
  8.27660188e-02f, 2.94107590e-02f, 4.77462187e-02f, 1.52935262e-03f, 2.68029794e-02f, 7.29550347e-02f, -4.92058247e-02f, -8.45664591e-02f, 1.68086905e-02f, 6.32523894e-02f,
  -2.53190517e-01f, 7.04265893e-01f, 5.34479856e-01f, -1.39841601e-01f, -7.22443536e-02f, 6.13258071e-02f, -1.12481624e-01f, 2.48806179e-01f, 1.48340976e-02f, 2.82199979e-01f,
  -1.29138418e-02f, 4.92877096e-01f, 2.45493855e-02f, -4.18762863e-02f, -4.38923866e-01f, -2.37014025e-01f, -3.25377971e-01f, -1.04043305e-01f, -4.96535823e-02f, -1.79041550e-01f,
  -2.21659213e-01f, -4.96809334e-01f, -1.05443180e-01f, -3.63069549e-02f, 1.44350767e-01f, 2.40737945e-01f, -4.49787736e-01f, 1.80091694e-01f, 6.73798174e-02f, 1.44973934e-01f,
  1.00118563e-01f, 1.63525529e-02f, 1.53349489e-01f, 1.52788535e-01f, -1.09947242e-01f, 2.68989988e-05f, 2.07323302e-02f, -2.00193934e-03f, -6.84054568e-02f, 9.33382064e-02f,
  2.84593068e-02f, 1.08669974e-01f, 1.13223502e-02f, 4.42968532e-02f, 1.07093222e-01f, 2.44510114e-01f, 1.82447866e-01f, 1.14187904e-01f, 1.73615515e-01f, 1.41198814e-01f,
  2.12349981e-01f, 1.38210952e-01f, 1.29052633e-02f, -3.21659707e-02f, 5.37286773e-02f, 1.03458740e-01f, 4.97450400e-03f, 1.64519161e-01f, 6.46308362e-02f, 3.94917578e-02f,
  -6.70153946e-02f, -1.10700317e-01f, 5.93377985e-02f, 5.58003522e-02f, 6.35775784e-03f, 6.89045936e-02f, -1.72054321e-02f, 3.36032137e-02f, 3.67379449e-02f, 3.85077149e-02f,
  -7.48979673e-02f, 8.37138668e-02f, -2.17208602e-02f, -1.08983405e-01f, -7.93122575e-02f, -2.62006111e-02f, -9.66422856e-02f, 2.60260645e-02f, -7.13624135e-02f, -3.13336104e-02f,
  -6.62168488e-02f, -1.20779693e-01f, 9.87647008e-03f, 6.03783294e-04f, 2.43706573e-02f, -3.84418182e-02f, -3.62235494e-02f, 1.21272363e-01f, -7.19007999e-02f, -1.21121407e-01f,
  -3.81637543e-01f, -4.87320691e-01f, -1.10190131e-01f, 9.36573073e-02f, 7.64255524e-02f, 4.63797599e-02f, -8.31916779e-02f, 9.19661522e-02f, -1.20158859e-01f, -5.71477488e-02f,
  6.22854754e-03f, -3.32445242e-02f, -8.49412233e-02f, -2.94840522e-02f, -1.25853166e-01f, -1.17801711e-01f, -9.24756601e-02f, -5.77901453e-02f, -6.49903566e-02f, 1.97266955e-02f,
  7.62033239e-02f, -9.41192135e-02f, -4.04141881e-02f, -1.17368959e-01f, -8.92083123e-02f, 1.44337369e-02f, -3.11763510e-02f, 1.25191018e-01f, -8.66253227e-02f, -4.52401079e-02f,
  6.82111830e-02f, -5.80660939e-01f, -3.67201418e-01f, 1.78247914e-01f, 4.71434206e-01f, 2.44723141e-01f, 1.83872040e-02f, 2.61402190e-01f, -3.10933851e-02f, -1.94749519e-01f,
  6.19064905e-02f, -6.03095412e-01f, -4.64901775e-01f, -1.05234809e-01f, 3.04973312e-02f, -4.18539912e-01f, 1.41884729e-01f, -8.07325393e-02f, -1.46477267e-01f, -3.44652124e-02f,
  1.32362410e-01f, 3.16001356e-01f, -2.82748550e-01f, 2.95243502e-01f, 2.06747994e-01f, 1.34604067e-01f, 2.55477458e-01f, -1.14264548e-01f, 2.31798977e-01f, 2.14896519e-02f,
  -5.33141866e-02f, -5.96344434e-02f, 1.02282867e-01f, -4.99416180e-02f, 1.95034206e-01f, 1.72521487e-01f, 6.46590143e-02f, -1.12530529e-01f, -6.00022376e-02f, -5.42307012e-02f,
  -1.72516137e-01f, -9.88731682e-02f, 7.71467900e-03f, 4.00246345e-02f, 1.14101470e-01f, 1.73486799e-01f, -1.55662780e-03f, 1.19289290e-02f, -9.37646255e-02f, -1.83055669e-01f,
  -1.31843358e-01f, -1.43211722e-01f, -2.70379353e-02f, -3.27471271e-02f, -1.00579932e-01f, 4.93505113e-02f, -2.56508663e-02f, -9.64235067e-02f, 7.70629719e-02f, 2.30211616e-02f,
  2.31127981e-02f, -7.52556920e-02f, -1.00471370e-01f, -7.92378839e-03f, -2.22739931e-02f, 7.88963810e-02f, 5.32347336e-03f, -2.07449608e-02f, 2.03754250e-02f, 8.20033625e-02f,
  8.22624862e-02f, -9.36117396e-03f, 8.70556459e-02f, 4.41966653e-02f, -5.11235744e-02f, 1.22587476e-02f, -1.50616318e-02f, -2.32255142e-02f, 1.48999766e-02f, 2.70706543e-04f,
  2.32898779e-02f, 3.93082462e-02f, -9.68465954e-02f, 2.41595637e-02f, 2.55351290e-02f, -6.63038567e-02f, 1.44624308e-01f, -4.06354703e-02f, -1.65127032e-02f, 2.92318165e-02f,
  -1.09019697e-01f, -1.27702966e-01f, -6.66997433e-02f, 5.01373708e-02f, -1.25323543e-02f, 1.01660863e-01f, -2.19401903e-02f, 5.33767343e-02f, -3.22290920e-02f, 7.28490949e-02f,
  1.20249420e-01f, 4.05673198e-02f, 6.40656278e-02f, -5.75506175e-03f, 4.37872186e-02f, 1.02129720e-01f, -7.53647164e-02f, 7.49836341e-02f, 1.77703515e-01f, 4.11963761e-02f,
  1.25925045e-03f, 3.27682756e-02f, -2.02347878e-02f, 1.29625961e-01f, 1.64483503e-01f, 1.78302094e-01f, 7.93211311e-02f, 1.12493606e-02f, -3.58798467e-02f, 1.05791055e-02f,
  -1.02488816e+00f, 7.78553933e-02f, -2.62910903e-01f, -1.24767043e-01f, -8.19859952e-02f, -1.80258393e-01f, -3.38738382e-01f, -1.12069927e-01f, -1.79839075e-01f, 1.53976023e-01f,
  -2.15651607e-03f, -2.10055843e-01f, -4.91357595e-02f, 2.60553867e-01f, -1.47815868e-01f, 3.29418808e-01f, 1.81782037e-01f, -5.06874882e-02f, 1.46066323e-01f, -2.98967004e-01f,
  9.79204550e-02f, 1.15282282e-01f, 7.96564817e-02f, 1.61104858e-01f, -2.93927282e-01f, -8.29273090e-02f, 6.93339109e-02f, -2.78488714e-02f, 1.64277211e-01f, 5.74365444e-02f,
  -3.77357960e-01f, -4.45484489e-01f, -3.10215682e-01f, -1.52054325e-01f, -1.36386707e-01f, -1.88899830e-01f, -7.81274587e-02f, -2.07485314e-02f, -5.93789518e-02f, -4.02235746e-04f,
  -1.00076489e-01f, 7.33419433e-02f, 7.23776743e-02f, 6.84198067e-02f, -1.14064611e-01f, 3.93005181e-03f, 4.35065106e-02f, 6.86986670e-02f, -5.70353195e-02f, 8.43660161e-02f,
  -2.06315592e-02f, 1.40458837e-01f, -4.35574539e-03f, 1.74750507e-01f, 2.10630242e-02f, 3.47824357e-02f, 1.44550085e-01f, -6.71129152e-02f, -6.58256039e-02f, 2.01446731e-02f,
  5.26569411e-02f, -5.63795827e-02f, -1.16610698e-01f, -4.50937971e-02f, 3.00440751e-02f, 4.05759923e-03f, -6.15322888e-02f, -1.38334837e-02f, 3.40654105e-02f, 2.06776359e-03f,
  9.57641676e-02f, -6.34729043e-02f, -1.48537923e-02f, 1.12748947e-02f, 8.96213949e-02f, 6.27278462e-02f, -2.81936098e-02f, -3.80137227e-02f, 1.16891593e-01f, -4.89935139e-03f,
  -1.37425825e-01f, -4.96777967e-02f, -4.60762437e-03f, 1.10293575e-01f, -4.84334901e-02f, -6.43648803e-02f, -1.36574199e-02f, 4.33705524e-02f, -8.08079466e-02f, -1.50087565e-01f,
  -8.18534017e-01f, -6.40254259e-01f, -1.57407954e-01f, -6.59741685e-02f, -3.44084837e-02f, 3.15156840e-02f, 6.15187921e-03f, 1.15075130e-02f, -1.29938260e-01f, -1.06859773e-01f,
  -6.54365867e-02f, 4.66481447e-02f, -5.93969151e-02f, 5.18832132e-02f, 3.70664038e-02f, 5.29785790e-02f, -6.84672073e-02f, 1.48024885e-02f, -1.02969773e-01f, 2.17149630e-02f,
  -7.58748353e-02f, -3.31799164e-02f, 4.19544131e-02f, 4.58427928e-02f, 4.68749590e-02f, -5.21114934e-03f, -6.19879104e-02f, 8.34504813e-02f, -1.13716507e-02f, 1.14291236e-01f,
  3.02205771e-01f, -1.06206305e-01f, -9.02002864e-03f, 4.14746672e-01f, -5.85451052e-02f, -4.10247624e-01f, -1.76153123e-01f, 1.69808462e-01f, 6.72115862e-01f, -3.93384904e-01f,
  -1.76570714e-01f, 2.15033367e-02f, -2.80617885e-02f, -3.48604113e-01f, 3.79506946e-01f, 2.58318663e-01f, 2.51719147e-01f, -1.39163435e-03f, 4.24140632e-01f, -1.23867363e-01f,
  2.51569241e-01f, -2.96741843e-01f, -1.28400043e-01f, -2.73058206e-01f, -2.77195007e-01f, 1.79747827e-02f, -1.26367643e-01f, -1.21788360e-01f, -4.25024450e-01f, -3.48503888e-02f,
  -7.79027641e-02f, 1.75416380e-01f, -9.53823626e-02f, 6.62976503e-03f, 5.81814051e-02f, -1.07538231e-01f, -1.25387251e-01f, -1.20439447e-01f, 1.39761195e-01f, -1.65659410e-03f,
  6.80411607e-02f, -1.68647636e-02f, -2.91719027e-02f, -9.64391232e-03f, -2.46638861e-02f, -7.90586323e-02f, -2.96949726e-02f, -9.03726444e-02f, -1.22616002e-02f, -7.40163028e-02f,
  -3.71204950e-02f, 2.79877596e-02f, 9.68739539e-02f, 7.18392953e-02f, 8.01554509e-03f, 4.11438793e-02f, -3.00956573e-02f, -4.46885638e-02f, 3.42006199e-02f, 1.27484933e-01f,
  1.26425493e-05f, 1.05784774e-01f, -1.10157333e-01f, -7.59272417e-03f, 6.53971955e-02f, 3.71051393e-02f, -1.30493045e-02f, -5.85535727e-03f, 8.17377046e-02f, -5.96894510e-02f,
  -1.14783291e-02f, -6.89786300e-02f, 1.13431536e-01f, -2.98159160e-02f, -4.78967233e-03f, 5.15472777e-02f, -3.62370722e-02f, -4.38534468e-02f, 8.40579569e-02f, -2.85380017e-02f,
  -4.74691717e-03f, -1.42772347e-02f, -8.36250093e-03f, -2.66452152e-02f, -1.94255356e-02f, 1.79420207e-02f, -3.71950082e-02f, -1.97781846e-02f, 2.02552993e-02f, -6.50561377e-02f,
  5.22269383e-02f, 1.89418539e-01f, 1.26226060e-03f, -1.38219118e-01f, 3.69283520e-02f, -6.33983016e-02f, 4.49834168e-02f, 4.69193831e-02f, 1.81179404e-01f, -4.12509777e-02f,
  -6.12087082e-03f, -1.46943675e-02f, -2.53576357e-02f, 1.69769092e-03f, 1.07073281e-02f, 2.20064949e-02f, 3.97581570e-02f, 1.39375016e-01f, 1.16270050e-01f, 3.44232731e-02f,
  -1.34652287e-01f, 6.33628741e-02f, 7.31044784e-02f, -2.06205458e-03f, 9.09269555e-04f, -6.21508323e-02f, -1.92648321e-02f, 6.22735918e-02f, 3.27799073e-03f, 8.79752636e-02f,
  -1.52474120e-01f, 2.68605500e-01f, 1.35966226e-01f, 4.64664966e-01f, -1.14231430e-01f, -5.84702373e-01f, -2.61134386e-01f, 1.01384282e-01f, -1.28359556e-01f, 1.42854944e-01f,
  3.59149516e-01f, -2.26696610e-01f, 3.47975045e-01f, 3.19226593e-01f, 7.76388943e-02f, 2.77065128e-01f, 1.48161381e-01f, -2.47935653e-01f, -1.42560512e-01f, 1.70996055e-01f,
  8.63669515e-02f, 2.58335382e-01f, 3.25281203e-01f, 5.06412536e-02f, 3.26769054e-02f, 1.11555174e-01f, 3.79375011e-01f, 5.24834655e-02f, 2.35360879e-02f, -1.38739541e-01f,
  -4.28186841e-02f, 3.48037690e-01f, 2.95089725e-02f, -1.15714207e-01f, 9.58359689e-02f, -8.75797048e-02f, -6.95826486e-02f, 1.27168335e-02f, -3.52291204e-02f, -3.04442327e-02f,
  -1.36843771e-02f, -1.19672688e-02f, 1.10845314e-02f, -1.62688419e-02f, -7.40795359e-02f, 8.47392455e-02f, 1.69445463e-02f, -5.64182922e-02f, -2.39026379e-02f, 6.41196147e-02f,
  9.41537786e-03f, 1.74861662e-02f, 9.89056900e-02f, 7.81301633e-02f, 6.60509840e-02f, -2.90102959e-02f, -2.57469639e-02f, 4.77678934e-03f, 2.14966573e-02f, -7.61630153e-03f,
  1.10139467e-01f, -1.09553739e-01f, 2.63626943e-03f, -5.25548831e-02f, -3.81049439e-02f, 3.03610880e-02f, -7.32767731e-02f, -1.05782486e-01f, 1.79299451e-02f, 1.30027145e-01f,
  -2.94377562e-02f, -2.40011234e-02f, -1.64240841e-02f, -1.87779907e-02f, 4.96097058e-02f, -1.67680606e-02f, -6.20365031e-02f, 6.00124383e-03f, 3.75109166e-02f, -4.90375012e-02f,
  6.54167905e-02f, 4.37909365e-02f, -4.89013046e-02f, 7.71116540e-02f, -4.16172743e-02f, 1.48732245e-01f, 1.00662112e-01f, 1.19202230e-02f, 4.53108363e-02f, -4.36559953e-02f,
  1.66191667e-01f, 3.16655636e-01f, 5.41025307e-03f, -7.80030489e-02f, 7.99838826e-02f, -1.20192371e-01f, -1.83348320e-02f, -4.25787084e-02f, 2.62314938e-02f, -4.71372567e-02f,
  7.06449244e-03f, -1.27027184e-01f, -1.37116775e-01f, 7.45179728e-02f, 1.07506029e-02f, 1.60999686e-01f, 4.70225252e-02f, -2.59701312e-02f, 1.89828545e-01f, 4.24724445e-02f,
  9.32182446e-02f, -1.65258185e-03f, 4.91011143e-02f, -1.49299428e-01f, -4.67997342e-02f, 1.46195829e-01f, -4.58463132e-02f, -2.76049245e-02f, 1.46655545e-01f, 2.51820628e-02f,
  4.56627347e-02f, 4.86538023e-01f, -1.12848477e-02f, -2.38218233e-01f, -6.78783953e-02f, -4.44483459e-01f, -3.21603626e-01f, -4.17247191e-02f, 1.30918637e-01f, 1.37925148e-01f,
  -1.12553596e-01f, 4.05358344e-01f, 9.95271131e-02f, -3.69639039e-01f, -4.21436608e-01f, -2.04816721e-02f, -4.82561171e-01f, -2.80948251e-01f, 6.47399873e-02f, -3.34313840e-01f,
  -2.25771517e-01f, -3.29091758e-01f, -3.56127620e-01f, -7.29053095e-02f, -3.29447031e-01f, 9.39823166e-02f, -1.44451365e-01f, 3.53316069e-02f, -2.06965402e-01f, 7.87633732e-02f,
  -2.18795687e-01f, 3.74843478e-02f, 9.78120510e-03f, -5.04665785e-02f, -2.26529345e-01f, -4.52781729e-02f, -1.27603756e-02f, 4.24364582e-03f, -3.00637707e-02f, -2.04359628e-02f,
  5.94044104e-02f, 5.10920659e-02f, 1.68992057e-02f, 7.43311793e-02f, 2.43429765e-02f, 3.82166915e-02f, 2.90073417e-02f, -1.23462453e-01f, 5.41058071e-02f, -4.14564274e-02f,
  -3.76620926e-02f, 1.72981136e-02f, -3.00668422e-02f, -1.79694779e-02f, -2.03108005e-02f, 6.65676519e-02f, -1.10977948e-01f, 3.49708982e-02f, 3.40354033e-02f, -7.16814324e-02f,
  5.01979403e-02f, -5.26083112e-02f, -3.95813249e-02f, 2.41287542e-03f, -5.89339547e-02f, 4.40351889e-02f, 5.01177879e-03f, 1.27042457e-03f, 2.50021890e-02f, -5.70888817e-02f,
  -2.01397073e-02f, 8.15263018e-02f, 4.51082885e-02f, -1.48482040e-01f, -9.00423992e-03f, 1.33101633e-02f, -4.24153171e-02f, 6.10423693e-03f, -4.80913632e-02f, 7.12140230e-03f,
  4.28294204e-02f, -7.33726546e-02f, 3.77746001e-02f, -8.10347274e-02f, -7.46888667e-02f, 5.99891134e-02f, -2.28397772e-02f, -1.48948105e-02f, -2.33178567e-02f, -7.41055533e-02f,
  -3.65051508e-01f, -3.21916968e-01f, -5.93258394e-03f, 1.10221431e-01f, -6.15497213e-03f, 2.21780762e-02f, -4.13836017e-02f, 1.71581879e-02f, -6.67281374e-02f, -2.81654894e-02f,
  -1.77902803e-02f, -7.78370947e-02f, -1.32418171e-01f, 2.52427924e-02f, -6.07911609e-02f, -1.26543418e-01f, -1.04395814e-01f, 2.15516258e-02f, -1.60294801e-01f, -9.46450979e-03f,
  -3.92411426e-02f, 7.83281215e-03f, 4.88765799e-02f, -6.90377355e-02f, -1.22587141e-02f, 3.32610193e-03f, -1.86108481e-02f, 9.57634076e-02f, -2.38161143e-02f, -6.92271488e-03f,
  -2.30515361e-01f, 4.37675923e-01f, -1.70502752e-01f, -1.75159961e-01f, -1.48825094e-01f, 6.96319163e-01f, 2.37028316e-01f, 9.18580741e-02f, -2.62635142e-01f, 4.17420834e-01f,
  2.06375748e-01f, -2.85939366e-01f, 1.35175139e-01f, 7.76337981e-02f, -1.85396343e-01f, 2.15035498e-01f, 4.72741395e-01f, 2.07545325e-01f, -2.14368254e-01f, 1.50515318e-01f,
  -1.39614940e-01f, 8.72374997e-02f, -8.88653249e-02f, 1.54976189e-01f, 5.15107997e-02f, -1.41565129e-01f, -6.99884742e-02f, -2.70050317e-01f, 7.01262653e-02f, -1.67181447e-01f,
  3.41573544e-02f, -1.76386014e-01f, -7.50706121e-02f, 9.34110284e-02f, 1.77962437e-01f, 7.21716434e-02f, 6.92524761e-02f, -1.10230945e-01f, -2.17011675e-01f, -9.38427597e-02f,
  -5.65649308e-02f, -8.37214142e-02f, -5.36436141e-02f, -1.64236203e-01f, -1.42102912e-01f, -4.41603968e-03f, -3.85183282e-02f, 3.94283310e-02f, 1.13188522e-02f, 5.39581701e-02f,
  -3.20537090e-02f, 4.78206538e-02f, 1.50386572e-01f, -1.06943026e-02f, -4.64437604e-02f, 7.00107887e-02f, 9.29401666e-02f, 4.15701978e-02f, 1.16385192e-01f, 3.30484360e-02f,
  -2.42859870e-02f, 1.54937670e-01f, 1.43749028e-01f, -9.42489058e-02f, -8.80258232e-02f, 9.64443907e-02f, -1.34285139e-02f, -1.03549212e-01f, -8.71122256e-02f, 1.21751167e-01f,
  -8.11663084e-03f, -8.64824280e-02f, 4.81014960e-02f, 6.14858381e-02f, 9.14085358e-02f, 2.63311602e-02f, -7.02621639e-02f, 7.28918891e-03f, -1.47713451e-02f, 7.81351477e-02f,
  -1.15498781e-01f, 2.73450017e-02f, 4.72224727e-02f, 1.64155234e-02f, 7.76517540e-02f, -8.97239819e-02f, 1.03549780e-02f, -5.94117073e-03f, 6.47031516e-02f, -3.56531739e-02f,
  2.30858877e-01f, 3.49871516e-01f, -5.04932017e-04f, -6.03901073e-02f, -1.82531998e-02f, 4.50677872e-02f, -2.07151449e-03f, 4.18618917e-02f, 1.21463403e-01f, 3.98186557e-02f,
  6.23407923e-02f, 2.00505480e-02f, 1.94115609e-01f, -1.65333971e-01f, -8.88597295e-02f, 2.47117981e-01f, 8.20898265e-02f, -7.35332146e-02f, 2.51173135e-02f, 3.74228880e-02f,
  7.59742185e-02f, 9.14347619e-02f, 8.09433777e-03f, 5.94358705e-02f, 4.74948324e-02f, 1.24613672e-01f, 7.86204040e-02f, -1.02439485e-01f, -3.55857797e-02f, 2.42341291e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.75726283e-01f, 4.09337550e-01f, 6.21583641e-01f, 5.17225027e-01f, 3.20471674e-01f, 2.93691039e-01f, 2.94223696e-01f, 4.91575003e-01f, 4.62563895e-02f, 4.49562222e-01f,
  2.58747280e-01f, 2.89616913e-01f, 3.33265096e-01f, 1.60716206e-01f, 3.95696908e-01f, 1.01851299e-01f, 3.77083987e-01f, 3.17095906e-01f, 3.33127767e-01f, 2.55077451e-01f,
  4.14515257e-01f, 3.89623523e-01f, 4.05247509e-01f, 6.75220191e-02f, 3.70461226e-01f, 5.93040824e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  2.63328571e-02f, -9.51205269e-02f, -1.78189650e-01f, 7.96303824e-02f, -3.42785209e-01f, -3.49326730e-01f, -9.24962237e-02f, 1.51020646e-01f, -2.09825307e-01f, -3.26829225e-01f,
  -3.29361856e-01f, 7.25339502e-02f, 1.53746635e-01f, -1.17155947e-01f, -1.87020838e-01f, 1.56921819e-02f, -3.02420110e-01f, -3.88362110e-01f, -4.19126034e-01f, -9.94605571e-02f,
  4.03956443e-01f, -3.25290203e-01f, 8.35677385e-02f, -2.90265977e-01f, 3.74069870e-01f, 6.70564175e-02f, -2.60167986e-01f, -2.20916733e-01f, 4.62985598e-02f, -6.97502866e-02f,
  1.21700726e-01f, 2.14288458e-01f, 4.42668557e-01f, -1.44396961e-01f, -2.02289537e-01f, 1.73922196e-01f, -1.37682602e-01f, 4.01713789e-01f, -3.35188806e-01f, -6.50189877e-01f,
  -2.09020495e-01f, -4.67698187e-01f, 5.31189561e-01f, 2.43488505e-01f, -6.14766419e-01f, 1.90276682e-01f, 1.71284810e-01f, -5.05315363e-01f, -2.96319962e-01f, -6.44167960e-01f,
  -3.77309769e-01f, 2.00843617e-01f, 2.88837492e-01f, 6.39332950e-01f, 4.09091830e-01f, 3.09239089e-01f, 2.86836058e-01f, -3.69818598e-01f, -5.39644957e-01f, 6.41043603e-01f,
  -4.00664955e-01f, 2.44772613e-01f, -4.51922655e-01f, 3.86848003e-01f, -3.17858577e-01f, 4.59247194e-02f, -1.13862909e-01f, -4.64148641e-01f, 1.05142184e-01f, 1.18292220e-01f,
  -1.68862835e-01f, -5.76611340e-01f, -2.88671646e-02f, 4.28199232e-01f, -2.22283021e-01f, -1.93696752e-01f, 2.92557955e-01f, 2.17574924e-01f, -9.98040438e-02f, -1.40434250e-01f,
  2.94766575e-01f, -2.90727466e-01f, 8.72658566e-02f, 3.11937839e-01f, -7.30046928e-01f, -3.52988064e-01f, 1.28172994e-01f, -4.07333374e-01f, -6.61822185e-02f, 6.24670386e-01f,
  4.05694515e-01f, -5.26708186e-01f, 2.93966353e-01f, -4.97158736e-01f, 5.12822211e-01f, -5.85287273e-01f, -3.03550400e-02f, 3.54100943e-01f, -4.60276961e-01f, 3.28395180e-02f,
  -3.72929454e-01f, 1.99265584e-01f, -1.03342637e-01f, 1.74828947e-01f, -5.54574668e-01f, -6.45626783e-01f, -9.49768722e-02f, 4.29059654e-01f, 3.35287422e-01f, -6.94143653e-01f,
  4.95736033e-01f, 8.12777877e-02f, 4.36770231e-01f, 2.35509768e-01f, 2.80029505e-01f, -2.75505990e-01f, 4.97630268e-01f, 5.67585826e-01f, -3.13988030e-01f, -3.55232090e-01f,
  -6.78036630e-01f, -4.40846145e-01f, 5.20653352e-02f, -5.58243513e-01f, -5.64855754e-01f, -1.33190334e-01f, -4.10267323e-01f, 2.91891754e-01f, -1.06550664e-01f, 5.53524075e-03f,
  -4.87250574e-02f, -1.94955960e-01f, -6.66775256e-02f, -6.90621510e-02f, -5.23469865e-01f, -1.58266246e-01f, 1.65406428e-02f, -3.27769399e-01f, -1.57273784e-01f, 2.00735688e-01f,
  -3.79264295e-01f, -1.87738851e-01f, 5.59607968e-02f, 6.73009828e-02f, 1.29067793e-01f, -1.27195626e-01f, 9.08633322e-02f, 2.90336221e-01f, -2.50049476e-02f, -2.28252530e-01f,
  1.05564214e-01f, -4.38070029e-01f, 3.05141270e-01f, 1.27045646e-01f, 2.75263995e-01f, 2.19683245e-01f, -2.93598861e-01f, -3.80054235e-01f, -1.99327126e-01f, -1.39106587e-01f,
  -3.09258312e-01f, 1.14452586e-01f, 1.09083593e-01f, -4.12853360e-01f, 1.39308709e-03f, -9.44510847e-02f, 2.93882221e-01f, -4.44591194e-01f, -1.21245742e-01f, -5.71481109e-01f,
  -9.66354087e-02f, -5.50496697e-01f, -6.34490550e-01f, -2.79859930e-01f, 3.32885772e-01f, 3.61137152e-01f, 1.55736431e-01f, 6.60577357e-01f, -3.72320265e-02f, 2.21352763e-02f,
  -3.97787601e-01f, -1.99690595e-01f, -2.95446873e-01f, 5.02674758e-01f, 3.35691363e-01f, -1.84462786e-01f, 6.15711927e-01f, 3.40405375e-01f, -1.93856969e-01f, -6.32001102e-01f,
  -1.74506232e-01f, -7.07532465e-01f, 6.55480176e-02f, 4.03919816e-01f, -2.14051157e-01f, -6.11975491e-01f, 7.53469691e-02f, -1.80289254e-01f, -7.31094368e-03f, -5.04126012e-01f,
  -5.78109268e-03f, -1.01421602e-01f, 2.14186087e-01f, -1.88394144e-01f, -5.91040134e-01f, -2.01912239e-01f, 6.85881600e-02f, 1.82010099e-01f, 1.43387377e-01f, 4.40759659e-02f,
  -5.66572368e-01f, -1.86007991e-02f, 1.14541680e-01f, 4.34869736e-01f, -1.17923571e-02f, -3.95001948e-01f, -4.13392544e-01f, -3.71730208e-01f, -2.36751691e-01f, -3.41227293e-01f,
  2.46709347e-01f, 1.61349237e-01f, -3.42782617e-01f, -1.39291167e-01f, 6.85653742e-03f, 1.33845598e-01f, -2.12797254e-01f, 4.18397397e-01f, -2.62222700e-02f, 3.52266788e-01f,
  -6.34788573e-01f, -2.51590043e-01f, 2.35238582e-01f, -5.94345391e-01f, -5.56197166e-01f, -1.06352709e-01f, -4.16038930e-01f, 6.41213596e-01f, -2.01083645e-01f, -7.25616753e-01f,
  -3.17677915e-01f, -2.35113487e-01f, -1.88284636e-01f, -9.06114280e-02f, 6.87995493e-01f, -3.83738950e-02f, -1.14389688e-01f, -3.31866980e-01f, -3.37109566e-01f, 3.43468040e-01f,
  -4.41456407e-01f, 3.55615824e-01f, -3.15824866e-01f, 3.97437125e-01f, 5.06295204e-01f, -4.93880093e-01f, -3.85949351e-02f, -3.16535592e-01f, 3.77080739e-01f, 4.06848043e-01f,
  9.09300968e-02f, 3.52166861e-01f, 2.18961880e-01f, 1.79838210e-01f, -1.04789667e-01f, 2.65156507e-01f, -1.78982243e-01f, 3.31431866e-01f, -1.48527715e-02f, -6.01629987e-02f,
  2.11231783e-01f, 2.04364210e-01f, 2.50729948e-01f, 2.50124604e-01f, 5.05828619e-01f, -6.76465392e-01f, 5.06890535e-01f, 1.87454354e-02f, -7.26763785e-01f, -4.92439151e-01f,
  4.06751841e-01f, -2.73907214e-01f, -5.57049155e-01f, -4.78599966e-01f, 5.28713465e-01f, -6.69435680e-01f, 6.07502818e-01f, 5.60271084e-01f, -5.38543582e-01f, -1.28348783e-01f,
  5.95288444e-03f, -4.89644259e-01f, 5.77632129e-01f, 1.73881456e-01f, -5.14785945e-01f, -4.61514741e-02f, -3.17364335e-01f, 1.90355822e-01f, -4.82412100e-01f, -2.66834199e-01f,
  5.29980063e-01f, 9.06920135e-02f, -1.14660576e-01f, -9.23794582e-02f, 5.84891081e-01f, -3.98889512e-01f, -1.79600269e-01f, -4.36203539e-01f, -7.42125213e-01f, -5.63642561e-01f,
  -6.19409792e-02f, -1.76922485e-01f, 3.65557104e-01f, 4.77467746e-01f, -1.22466169e-01f, 5.48560500e-01f, -4.53078449e-01f, -3.51175010e-01f, -5.83406212e-03f, 1.59742773e-01f,
  3.95001173e-01f, 2.98974067e-01f, 1.61490977e-01f, 2.28648975e-01f, 4.04776901e-01f, 1.45689338e-01f, 2.46656388e-01f, 5.40492177e-01f, 5.08711398e-01f, -2.38033578e-01f,
  4.97202128e-01f, 2.91421533e-01f, -8.95001516e-02f, 1.08028449e-01f, -1.64557733e-02f, -1.51697189e-01f, 3.32685471e-01f, 7.39536807e-02f, 2.52371460e-01f, 3.54534872e-02f,
  1.95750684e-01f, 5.22381887e-02f, 5.72059214e-01f, 4.56423223e-01f, -3.74934375e-02f, -5.47441423e-01f, 1.55269325e-01f, -7.61129782e-02f, 1.48051322e-01f, 7.68766105e-02f,
  -1.01358257e-01f, -1.83722693e-02f, 6.16657495e-01f, -3.70420158e-01f, -3.23426485e-01f, 2.64067799e-01f, -5.52906454e-01f, -5.50260305e-01f, -2.59533286e-01f, 1.70705572e-01f,
  -3.79882097e-01f, -6.88390076e-01f, 4.14173841e-01f, -2.22013116e-01f, 6.81508303e-01f, -4.91761565e-01f, -4.48979378e-01f, -1.02677949e-01f, -4.92921352e-01f, -2.28692085e-01f,
  2.71049023e-01f, 5.75088143e-01f, -3.98761541e-01f, -4.68844831e-01f, 7.00253069e-01f, -2.88133055e-01f, -4.35175806e-01f, -5.95327675e-01f, -3.47333640e-01f, -5.26975811e-01f,
  4.30880338e-01f, -4.23225790e-01f, -4.28695112e-01f, 2.53630042e-01f, 1.48174539e-01f, -4.86840829e-02f, 1.99102476e-01f, -2.34050885e-01f, -3.64372432e-02f, -4.44981344e-02f,
  2.15391517e-01f, -3.56928915e-01f, -4.97806907e-01f, -1.79796979e-01f, 2.34215438e-01f, -3.05049121e-01f, 2.24083588e-01f, 2.60348052e-01f, -1.74875602e-01f, 1.48848832e-01f,
  -2.31565878e-01f, 7.19148442e-02f, -3.21622819e-01f, -1.24891095e-01f, -5.12838185e-01f, 5.15573800e-01f, 2.89003074e-01f, 8.04080889e-02f, -4.35556382e-01f, 3.25955480e-01f,
  3.28445941e-01f, 5.50771952e-01f, -4.48357135e-01f, 1.48081928e-01f, 5.36890388e-01f, 3.24333549e-01f, -3.75868708e-01f, 7.02133179e-01f, -5.81674457e-01f, -4.10005540e-01f,
  1.53208315e-01f, -2.32490271e-01f, 1.50511071e-01f, -6.59851134e-01f, 6.39142871e-01f, 4.37365741e-01f, 1.19179763e-01f, -1.48806885e-01f, 6.58346713e-02f, 5.49520478e-02f,
  -2.47713760e-01f, -3.83474678e-01f, 1.17487304e-01f, 1.24600105e-01f, -6.86238468e-01f, 4.06067312e-01f, -3.28108788e-01f, 1.79388851e-01f, -5.09848595e-01f, -3.85824084e-01f,
  -7.01300442e-01f, -4.69231009e-01f, 5.41762412e-01f, -2.90290743e-01f, 5.35821319e-01f, -1.50343135e-01f, -4.51415390e-01f, -5.62737644e-01f, -9.17075351e-02f, -1.29945457e-01f,
  -3.37336600e-01f, -1.39561906e-01f, 7.10869506e-02f, 4.79018427e-02f, 9.43297707e-03f, -2.71892071e-01f, -7.14629143e-02f, -3.56270373e-01f, -3.33513826e-01f, -5.58233559e-02f,
  -9.91674662e-02f, 1.17759779e-01f, -1.60868928e-01f, -3.47329155e-02f, -2.88618118e-01f, 1.65503770e-01f, 1.44763187e-01f, 3.88080508e-01f, 1.92734882e-01f, 2.30333090e-01f,
  -3.01326662e-01f, 1.26446173e-01f, -1.66782305e-01f, -2.57669002e-01f, -4.66750972e-02f, 2.49744073e-01f, 1.95781142e-01f, 2.83102155e-01f, -1.36331692e-01f, -2.01528311e-01f,
  1.58506960e-01f, -2.85772294e-01f, 3.00877243e-01f, 1.04775816e-01f, -2.18234360e-01f, -3.52331519e-01f, -2.09478319e-01f, 6.44364297e-01f, -2.22904116e-01f, 5.02220243e-02f,
  -2.65493780e-01f, -2.52963454e-01f, -3.02676797e-01f, -3.27694565e-01f, -3.05042207e-01f, 1.21155336e-01f, -1.02937140e-01f, 2.62303315e-02f, -2.09005207e-01f, -9.61123928e-02f,
  -2.63196141e-01f, -2.13419393e-01f, -2.84471095e-01f, -2.00854138e-01f, -4.29931507e-02f, -3.44210058e-01f, -2.58311868e-01f, 3.04636925e-01f, 5.00333667e-01f, -9.67001542e-02f,
  5.12592494e-01f, -4.62004393e-01f, 1.06342413e-01f, -1.26898229e-01f, -1.26840770e-01f, 5.82618117e-02f, -4.99748215e-02f, -3.42589438e-01f, 7.50658736e-02f, 4.79351617e-02f,
  -4.49976623e-02f, -3.77836674e-02f, 5.03337849e-03f, -1.26445398e-01f, -3.16611588e-01f, -3.07625216e-02f, -2.06508473e-01f, -3.17975916e-02f, -1.79137781e-01f, -1.03570662e-01f,
  -8.64804536e-02f, -3.60529721e-01f, -2.39219919e-01f, 4.81662780e-01f, 9.19597149e-02f, 1.13802701e-01f, 4.16948974e-01f, -1.94152638e-01f, 5.78950681e-02f, 2.50548869e-01f,
  -3.20996761e-01f, 4.54790443e-01f, -3.76828611e-01f, -2.49695092e-01f, -9.41276625e-02f, 3.23249638e-01f, 3.03974211e-01f, 3.14820319e-01f, -1.01354323e-01f, 2.27813765e-01f,
  -3.31923604e-01f, -3.50903243e-01f, 3.18659276e-01f, -2.57996887e-01f, -3.74088734e-01f, -1.83614437e-02f, -1.98675409e-01f, 1.38026506e-01f, 3.62166643e-01f, 4.68161702e-01f,
  1.57487199e-01f, 2.56427359e-02f, 4.42185611e-01f, -3.40812266e-01f, -2.77335942e-01f, -3.68017942e-01f, -8.40089843e-02f, -3.39423180e-01f, 5.11344790e-01f, -3.35344017e-01f,
  -2.82024950e-01f, -3.29564869e-01f, 1.52260110e-01f, 6.83418274e-01f, -3.85405034e-01f, -2.57059187e-01f, 9.65860710e-02f, 1.60372257e-01f, 5.33356033e-02f, 4.78048444e-01f,
  1.97338000e-01f, 2.05735192e-01f, -9.22157690e-02f, 3.97858948e-01f, 3.53314757e-01f, 2.33341262e-01f, 1.03967011e-01f, -1.77705631e-01f, 1.56912461e-01f, -1.07504755e-01f,
  6.35763034e-02f, -4.18463303e-03f, -2.15278983e-01f, 2.52273321e-01f, -4.61756468e-01f, 5.09033024e-01f, 5.14902890e-01f, -2.58585036e-01f, 4.62630428e-02f, 4.89103198e-01f,
  -2.03966871e-01f, 2.04705030e-01f, 2.84491152e-01f, 1.26301140e-01f, -6.46146685e-02f, -2.79256940e-01f, -7.78536499e-03f, -4.83542114e-01f, -4.43641633e-01f, -6.63632214e-01f,
  6.89628899e-01f, -3.07241559e-01f, 1.07021838e-01f, -3.21804851e-01f, -1.76597700e-01f, -1.55118881e-02f, -7.37972796e-01f, 6.29599392e-01f, 3.32040846e-01f, 7.00521052e-01f,
  -3.91524464e-01f, -2.97808170e-01f, -3.21952850e-01f, -3.56112093e-01f, -3.05414498e-01f, -1.40979573e-01f, -3.60742509e-01f, -2.85902381e-01f, -2.29040340e-01f, -3.70060593e-01f,
  -1.95652604e-01f, 6.14067852e-01f, 5.35162270e-01f, -1.82565942e-01f, -3.22026521e-01f, -5.61214447e-01f, -1.44740611e-01f, 2.03253515e-02f, -4.40943599e-01f, -5.00404179e-01f,
  2.11746022e-01f, -1.06178008e-01f, 1.75220490e-01f, -2.17765737e-02f, 3.84458830e-03f, 1.58648901e-02f, 3.10054421e-02f, 2.46255398e-01f, 1.34744719e-01f, 2.68680930e-01f,
  -5.62298410e-02f, -1.71797484e-01f, 2.95514256e-01f, 3.30608040e-01f, 1.36001751e-01f, -1.99699327e-02f, 7.32512102e-02f, 1.50730804e-01f, 1.24369510e-01f, -5.27350977e-02f,
  -4.12664294e-01f, -1.45092741e-01f, -5.42941689e-01f, 2.54335999e-01f, -3.28941673e-01f, 4.40703899e-01f, -3.77920866e-01f, -4.66613412e-01f, 1.02643318e-01f, 3.43993306e-01f,
  -4.51700151e-01f, 5.78416944e-01f, 1.93706647e-01f, -3.35450560e-01f, 5.27853012e-01f, 1.23297153e-02f, 2.57983059e-01f, 3.57824057e-01f, 6.04661167e-01f, -2.53219139e-02f,
  -5.98719358e-01f, -2.98390985e-01f, -3.41394961e-01f, -1.90943033e-01f, -2.47258440e-01f, 5.02914906e-01f, -3.39438081e-01f, 5.41442692e-01f, -5.36918461e-01f, -3.32740605e-01f,
  -9.76564586e-02f, -2.71489292e-01f, 4.59165692e-01f, -2.00199708e-02f, -5.37546635e-01f, 3.10552657e-01f, -3.00325215e-01f, -4.73382235e-01f, 5.55836558e-01f, -5.72442353e-01f,
  -1.57664746e-01f, -2.64514714e-01f, -3.07411253e-01f, 4.30127352e-01f, -2.95751721e-01f, 2.78470218e-01f, -7.16614500e-02f, 2.16926008e-01f, -2.65643269e-01f, 1.22278288e-01f,
  -2.18006931e-02f, 3.07573348e-01f, -3.04730434e-04f, 7.23672956e-02f, 1.60748646e-01f, -1.04895076e-02f, 3.53982538e-01f, 2.36570239e-02f, 2.56415103e-02f, -3.42117921e-02f,
  4.63774018e-02f, -3.62352699e-01f, 1.14025705e-01f, -3.60083729e-01f, -1.01225741e-01f, -4.49121058e-01f, -7.69481733e-02f, 3.54653329e-01f, -1.58492178e-01f, -3.14550251e-01f,
  1.35599002e-01f, 4.75198537e-01f, -4.30637807e-01f, 1.76662758e-01f, -3.34511399e-01f, -8.09354559e-02f, 3.99776131e-01f, 1.67573318e-01f, -4.27076399e-01f, 3.72019380e-01f,
  3.41290146e-01f, -1.67162314e-01f, 5.11541724e-01f, -1.11994006e-01f, 7.50243366e-01f, -3.03368628e-01f, -1.41119614e-01f, -1.13373578e-01f, -4.44965184e-01f, -6.70187891e-01f,
  -1.65888190e-01f, -1.46349538e-02f, -1.73605636e-01f, -2.80856848e-01f, 2.33261436e-01f, -2.34902158e-01f, -3.28390807e-01f, -1.14118969e-02f, 2.81150579e-01f, -6.88048676e-02f,
  -2.71676958e-01f, 6.61158979e-01f, -5.25937676e-01f, -3.73169571e-01f, -2.77190596e-01f, -2.99968034e-01f, 3.02766204e-01f, -1.97871104e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -5.08165993e-02f, -1.44030198e-01f, -9.91487578e-02f, 4.24794899e-03f, 1.16259754e-01f, 7.52026290e-02f, 1.18075408e-01f, 4.68941778e-02f, -6.78680614e-02f, 6.44918978e-02f,
  4.55699116e-02f, 5.95817901e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    