/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.85060620e-01f, 2.60590523e-01f, 2.61650737e-02f, 6.89487085e-02f, -2.23175541e-01f, -9.23111513e-02f, -1.42839089e-01f, 7.32368231e-02f, -1.34738870e-02f, 2.38688096e-01f,
  6.43902346e-02f, 2.19541207e-01f, 4.37589288e-02f, 1.13060050e-01f, -1.21585175e-01f, -1.67801101e-02f, 6.98261952e-04f, 6.98973536e-02f, -5.52250780e-02f, 1.08060934e-01f,
  4.75663086e-03f, -3.03800106e-02f, -7.01882243e-02f, 9.35222507e-02f, 8.11738335e-03f, 7.55363479e-02f, -9.86156166e-02f, 6.53392673e-02f, 6.51859045e-02f, -8.77939165e-02f,
  -9.76378545e-02f, 1.61086284e-02f, 1.70452092e-02f, 1.09933510e-01f, 2.74853427e-02f, 3.99417505e-02f, 2.72625461e-02f, 2.08121818e-02f, -1.03208562e-02f, -2.75612120e-02f,
  1.09375797e-01f, 4.37658094e-02f, -2.51908042e-02f, 6.09563314e-04f, 1.76899042e-02f, -3.51951644e-02f, -7.17993230e-02f, -5.77809848e-02f, 5.29698841e-02f, 6.52241856e-02f,
  9.72713344e-03f, 7.82692432e-02f, 1.57762934e-02f, 7.99801275e-02f, -1.37097891e-02f, -3.26747745e-02f, 5.11447974e-02f, 4.25314680e-02f, -2.01728893e-03f, 6.29122555e-02f,
  2.08725519e-02f, -1.98330767e-02f, -6.80385977e-02f, 1.28416019e-02f, 2.47263946e-02f, -7.50733763e-02f, -7.60607570e-02f, -8.91584496e-04f, -3.01472489e-02f, 2.03335863e-02f,
  -1.99488532e-02f, -5.44442572e-02f, -3.55794132e-02f, -3.92204300e-02f, -3.70631963e-02f, 5.43135079e-03f, -1.62751563e-02f, -7.84069009e-04f, 4.01699124e-03f, -4.44747731e-02f,
  -4.07629013e-02f, -1.39048966e-02f, -5.01411855e-02f, -1.96220018e-02f, 2.17569340e-03f, 7.60550937e-03f, 6.13919161e-02f, 2.14462373e-02f, 2.65753213e-02f, 4.32150513e-02f,
  4.51185703e-02f, 1.62101135e-01f, 4.41273972e-02f, 5.89575917e-02f, 5.04399538e-02f, 4.57687378e-02f, 3.50330733e-02f, -3.43656493e-03f, -2.26871464e-02f, 7.37098828e-02f,
  5.88024855e-02f, 6.39109015e-02f, 6.05556220e-02f, -8.00619349e-02f, -4.52434756e-02f, 3.84756438e-02f, 1.05226478e-02f, 5.60710356e-02f, -1.40792439e-02f, -2.82356627e-02f,
  -2.69308034e-02f, 5.15687577e-02f, 1.27126798e-01f, 5.53926863e-02f, 4.68004420e-02f, -6.84996322e-03f, -4.15961407e-02f, 3.78498398e-02f, 4.99401465e-02f, -5.93790635e-02f,
  2.27684870e-01f, -4.01419587e-02f, 1.26476929e-01f, 9.59651023e-02f, 3.03169433e-02f, 1.92588374e-01f, 1.97194025e-01f, 6.66525736e-02f, -8.29764605e-02f, 1.12422131e-01f,
  1.07958347e-01f, 1.11871283e-03f, 7.35977292e-02f, 1.49271220e-01f, 7.20600635e-02f, -3.89499776e-02f, 2.45404452e-01f, -2.03268602e-02f, -6.96924105e-02f, 9.82130989e-02f,
  7.08320737e-03f, 1.58993021e-01f, -2.75163092e-02f, 8.47616196e-02f, 1.16200358e-01f, -1.20882437e-01f, -1.21577710e-01f, 1.43372528e-02f, 1.21900156e-01f, 7.09522441e-02f,
  1.43700540e-01f, 3.50425835e-03f, 6.05256483e-02f, 7.11696083e-03f, 7.08087832e-02f, 7.67747462e-02f, -2.54065022e-02f, -3.56496163e-02f, -4.87184897e-02f, -4.10721041e-02f,
  -3.19634862e-02f, -6.26275549e-03f, -1.33336298e-02f, 4.90451753e-02f, -1.28207598e-02f, -3.82405035e-02f, -1.89769845e-02f, 2.69588139e-02f, -4.01119590e-02f, 5.53959608e-02f,
  4.36266972e-04f, -2.64542755e-02f, 3.60305496e-02f, -4.34364155e-02f, -5.70345558e-02f, 5.00251912e-02f, -9.21994746e-02f, -2.59700343e-02f, 2.01621503e-02f, -1.66514851e-02f,
  4.46069241e-02f, -1.86105389e-02f, 7.12633645e-03f, 3.58238034e-02f, 2.95637939e-02f, 1.69568975e-02f, 1.06621739e-02f, 1.80349257e-02f, -1.08516430e-02f, 4.64134738e-02f,
  5.81878945e-02f, 1.92913245e-02f, 1.96979567e-02f, -2.81240102e-02f, 5.63251004e-02f, 6.86130226e-02f, 5.51128797e-02f, -2.31339149e-02f, -1.82082281e-02f, -7.02743158e-02f,
  1.30179022e-02f, 8.46533384e-03f, 1.84057504e-02f, 2.74899416e-02f, -2.87114792e-02f, 8.74415599e-03f, -2.75111031e-02f, 1.77727267e-02f, -2.68812873e-03f, 8.60550627e-03f,
  -8.35871324e-02f, -6.36609644e-02f, -3.79952043e-02f, 8.95277411e-02f, -3.81815769e-02f, -1.12278834e-02f, 6.44093975e-02f, 1.35459406e-02f, 6.25011325e-02f, 1.95140566e-03f,
  1.55123044e-02f, -4.28920239e-03f, -8.34189635e-03f, 5.26000001e-03f, -1.03202267e-02f, 1.27495814e-03f, 6.51469529e-02f, -1.34995999e-02f, -1.13520650e-02f, 1.16356900e-02f,
  2.41340585e-02f, -2.03852425e-03f, 3.88436317e-02f, 7.45193753e-03f, 3.25041488e-02f, 1.99054740e-02f, -3.02269161e-02f, -4.13375460e-02f, -4.08927118e-03f, -2.64124870e-02f,
  -3.53791207e-01f, 1.60460562e-01f, 3.67552862e-02f, -5.07072806e-02f, -1.55429408e-01f, -8.65571015e-03f, -6.89624622e-02f, -4.22394574e-02f, 1.68878585e-02f, 1.80007592e-01f,
  -9.80101377e-02f, 5.22715189e-02f, 1.89917088e-01f, 4.66185696e-02f, -7.37855062e-02f, 1.04632095e-01f, -7.39221554e-03f, -2.18110718e-02f, -1.55673837e-02f, -5.79076121e-03f,
  1.01408936e-01f, -6.69702888e-02f, 5.56955598e-02f, -4.35529947e-02f, -1.48190007e-01f, -1.35656282e-01f, -1.30203530e-01f, -1.79737918e-02f, 6.84806320e-04f, -5.26385754e-02f,
  -4.99264263e-02f, 1.15900323e-01f, -8.04379284e-02f, -1.51494695e-02f, 4.47748080e-02f, 4.02853405e-03f, 3.25011276e-02f, -5.03535345e-02f, -5.37293106e-02f, 5.65968193e-02f,
  9.28607732e-02f, 9.92929656e-03f, 1.46981999e-02f, -6.68110549e-02f, -5.94022796e-02f, -4.71194051e-02f, 1.57513644e-03f, -1.14950120e-01f, 8.35147277e-02f, 7.97402263e-02f,
  -2.09824201e-02f, -4.35062647e-02f, -8.13399404e-02f, 1.25792506e-03f, -2.09017191e-03f, -4.37935367e-02f, 2.44836044e-02f, -3.16016451e-02f, -9.27860439e-02f, 1.44498069e-02f,
  -9.99303162e-03f, -6.48035035e-02f, 2.81057749e-02f, 3.48220021e-02f, -2.96528209e-02f, 3.94141348e-03f, 3.59239765e-02f, 2.72204205e-02f, -3.31938937e-02f, 2.78137419e-02f,
  1.78643335e-02f, 4.24101055e-02f, 3.29328217e-02f, -9.12929885e-03f, 1.62500385e-02f, 1.02963494e-02f, -9.33479983e-04f, -6.94590807e-02f, 4.64741886e-03f, -4.91567291e-02f,
  1.10461554e-02f, 8.73097256e-02f, 1.11066606e-02f, 1.60693377e-02f, -5.70984976e-03f, 5.51106520e-02f, 6.20924607e-02f, 5.29512428e-02f, -2.23570988e-02f, 4.97290529e-02f,
  1.06513649e-01f, 8.34729001e-02f, 6.17659204e-02f, -2.08414048e-02f, 2.40395591e-02f, 4.31449339e-02f, 3.66791822e-02f, 1.54587533e-02f, 8.73686895e-02f, -3.42233963e-02f,
  -4.48333323e-02f, -9.14357826e-02f, 5.16183078e-02f, -8.53104424e-03f, -5.02066053e-02f, 1.45946652e-01f, 7.26790726e-02f, -7.68444836e-02f, -4.23942395e-02f, 3.44446376e-02f,
  -6.00674264e-02f, -7.57687092e-02f, -7.98862129e-02f, -7.75861368e-02f, 3.26913670e-02f, 3.66784185e-02f, 1.57603379e-02f, -2.51518115e-02f, -4.71639894e-02f, -1.35265384e-02f,
  -3.56561169e-02f, -1.35933101e-01f, -4.35841680e-02f, -5.05731218e-02f, -4.24319990e-02f, 1.67648401e-02f, 1.33857578e-01f, -1.17181368e-01f, -1.41931891e-01f, -2.25345954e-01f,
  2.91655120e-02f, 3.02451793e-02f, 1.19064584e-01f, 1.54325617e-02f, 3.09861749e-01f, 1.49211839e-01f, 9.20930039e-03f, 8.25626701e-02f, 4.36799042e-03f, -5.83464280e-02f,
  -2.30330769e-02f, 1.10732041e-01f, 2.05364645e-01f, -1.27874061e-01f, 5.47397509e-02f, -9.37682092e-02f, 9.34109390e-02f, 9.83088687e-02f, 5.05223647e-02f, 1.12198241e-01f,
  -3.49561567e-03f, -1.28611639e-01f, -5.92870377e-02f, -1.40072778e-01f, -2.65849940e-02f, 7.51526877e-02f, 1.89692981e-03f, 1.11580215e-01f, -5.90660870e-02f, -5.51167596e-03f,
  7.92211387e-03f, -2.51181386e-02f, -3.98919433e-02f, 1.83838811e-02f, -6.00194223e-02f, -3.61013971e-02f, -6.65634125e-02f, -7.08095655e-02f, -3.52228470e-02f, 7.14046732e-02f,
  4.56597470e-02f, 3.54439802e-02f, 1.98723767e-02f, -2.39208760e-03f, 5.03667183e-02f, -4.91920486e-02f, -1.43068526e-02f, 1.03000604e-01f, 8.27707723e-02f, 7.91985542e-03f,
  5.59908561e-02f, 1.60264987e-02f, -2.03007385e-02f, -1.46737779e-02f, 5.11450367e-03f, -4.44384813e-02f, -4.87494357e-02f, 2.98494902e-02f, -1.93688143e-02f, 2.44770087e-02f,
  -1.16377532e-01f, -7.85318315e-02f, -3.18820104e-02f, 1.64531637e-02f, -4.58847173e-02f, -1.99955739e-02f, -4.34739236e-03f, 2.64256131e-02f, 8.74767639e-03f, -4.70058061e-03f,
  1.23558249e-02f, -2.06160285e-02f, -5.94099909e-02f, 2.43271831e-02f, 1.73250865e-02f, 9.29533392e-02f, -2.44774651e-02f, 1.50953140e-03f, 4.72580753e-02f, 1.67364746e-01f,
  -6.31624013e-02f, -2.76904732e-01f, -3.22823860e-02f, 1.42448805e-02f, -2.05166591e-03f, -7.04402700e-02f, -5.57705909e-02f, -2.28305999e-02f, 1.54686822e-02f, -1.85209922e-02f,
  2.01504659e-02f, -1.64972264e-02f, 1.64002609e-02f, -2.16940977e-02f, -1.22745428e-02f, -1.10060059e-01f, 8.59986767e-02f, -1.30334738e-04f, 2.06736736e-02f, 4.33675684e-02f,
  -8.92198235e-02f, -7.43760839e-02f, 9.99551862e-02f, -2.62939297e-02f, 5.80564775e-02f, 3.59500013e-02f, 3.44357416e-02f, 3.05666775e-02f, 6.76491931e-02f, 1.22483280e-02f,
  2.22637542e-02f, 1.59341663e-01f, 1.27371386e-01f, -1.12587802e-01f, -3.49628180e-02f, 2.66097113e-02f, -3.59813273e-02f, 9.57496651e-03f, 8.96532685e-02f, -2.87951324e-02f,
  -1.42537042e-01f, 1.09622613e-01f, -5.60572073e-02f, -2.06085488e-01f, -1.80991232e-01f, -5.42091690e-02f, -4.86355163e-02f, -1.33524165e-02f, 5.33803925e-02f, -7.38336891e-02f,
  -2.73591164e-03f, -3.40406932e-02f, -1.15160383e-01f, -2.22934410e-02f, 3.53838168e-02f, 7.10301250e-02f, -1.57632336e-01f, 2.25360747e-02f, -1.69900090e-01f, -8.24478397e-04f,
  2.38453690e-02f, -4.09576148e-02f, 9.56319422e-02f, 6.24666698e-02f, -3.84729840e-02f, -5.56251742e-02f, -1.01168789e-02f, 3.84052284e-02f, 3.04611109e-04f, -1.92625988e-02f,
  -2.02449188e-02f, -1.24086197e-02f, 5.81160747e-02f, -7.70371631e-02f, 2.48410413e-03f, -1.12994779e-02f, -2.13213527e-04f, -1.41556561e-02f, 9.95208509e-03f, 5.23675159e-02f,
  -2.52257716e-02f, 2.45380122e-02f, -4.95015271e-03f, -4.82382700e-02f, -1.02247763e-02f, -3.32825147e-02f, -8.01390968e-03f, 1.64728072e-02f, 3.28626968e-02f, -3.53401788e-02f,
  -5.02783165e-04f, -2.93050101e-03f, -3.74756195e-02f, 2.44980566e-02f, -4.50288802e-02f, 7.69774094e-02f, -2.40800582e-04f, -1.63411219e-02f, -2.74719503e-02f, 1.87840145e-02f,
  -4.28407677e-02f, 2.07367446e-02f, -2.41156165e-02f, 3.45507860e-02f, -2.25234646e-02f, 3.83843621e-03f, -2.85683107e-02f, 5.72811812e-02f, -2.31195185e-02f, 4.08588946e-02f,
  6.50223717e-02f, -4.42394130e-02f, 1.60103440e-02f, -1.69093832e-02f, -7.78342539e-04f, -1.92698780e-02f, -2.24928241e-02f, 1.97677910e-02f, 1.81837920e-02f, 4.56496477e-02f,
  -8.85346234e-02f, -1.33425295e-01f, 1.97012406e-02f, 5.57965785e-03f, 3.58697027e-02f, 7.98120573e-02f, -2.94187460e-02f, 5.55737354e-02f, -3.90261710e-02f, -1.63257308e-02f,
  -8.34398791e-02f, -8.73392969e-02f, -3.22597884e-02f, 2.92426031e-02f, 2.97450256e-02f, -5.23298718e-02f, -5.64969927e-02f, 2.63259541e-02f, -1.02759533e-01f, -2.36791298e-02f,
  -1.27927974e-01f, 4.57415842e-02f, -1.31662032e-02f, -8.21162835e-02f, -4.73004654e-02f, 6.44961838e-03f, 9.50128585e-03f, 1.19151352e-02f, -7.70736784e-02f, 4.75813039e-02f,
  1.65324345e-01f, -2.27199256e-01f, -1.78119600e-01f, -2.80481994e-01f, 8.54490101e-02f, -3.68162304e-01f, -2.05524564e-01f, -7.98779950e-02f, -8.64718780e-02f, -5.02772406e-02f,
  -5.72817251e-02f, 6.28011972e-02f, -3.24888304e-02f, -1.38900533e-01f, 2.57981829e-02f, -1.32141396e-01f, -2.03576431e-01f, -9.42133516e-02f, 1.45135997e-02f, -1.18109830e-01f,
  -3.37719619e-02f, -1.14640228e-01f, -1.14042208e-01f, -1.24328388e-02f, -1.28041849e-01f, 7.16741383e-02f, 3.01011633e-02f, -1.19108288e-02f, -1.03467830e-01f, 5.09617925e-02f,
  -1.11984558e-01f, -7.27632269e-02f, 5.56987431e-03f, 4.32732329e-02f, -5.07737026e-02f, -6.26504868e-02f, 2.72006541e-02f, -1.31847849e-02f, 6.92684725e-02f, 3.58115919e-02f,
  4.29259241e-02f, 2.05602814e-02f, 1.44487398e-03f, 4.02890928e-02f, 4.32442874e-02f, 2.13936735e-02f, 1.38379820e-02f, 1.09770754e-03f, -9.39628202e-03f, 5.89243881e-02f,
  3.57665755e-02f, -6.48893937e-02f, 2.54573077e-02f, -2.67273802e-02f, 2.37672739e-02f, 1.61455746e-03f, -9.46628973e-02f, -3.05258436e-03f, -1.68009084e-02f, 4.17580642e-03f,
  -2.23512948e-02f, 2.13554166e-02f, -5.19765429e-02f, 5.67082204e-02f, -1.99529044e-02f, -2.95763202e-02f, -5.52229211e-02f, -2.24679802e-02f, 5.27088381e-02f, -2.89245490e-02f,
  -2.62777023e-02f, -3.48293670e-02f, 1.01849604e-02f, -5.14888428e-02f, -6.66899234e-02f, -2.22709365e-02f, 2.56830547e-02f, 2.25569028e-02f, -1.48719195e-02f, -1.00752164e-03f,
  -8.99303763e-04f, 2.59452779e-02f, -5.21312617e-02f, -1.08237909e-02f, -2.91781146e-02f, 8.08555186e-02f, -3.12773436e-02f, 3.80168408e-02f, 4.06467691e-02f, 2.09965687e-02f,
  -9.39022079e-02f, -3.39595936e-02f, -7.35861287e-02f, 1.77450590e-02f, -2.64433101e-02f, -1.75716972e-03f, -5.41982539e-02f, -4.99420008e-03f, -2.42024548e-02f, -8.49559903e-02f,
  -3.20814811e-02f, 3.39132268e-03f, -7.47262361e-03f, -4.90396582e-02f, -1.00687668e-01f, 2.57075373e-02f, -3.47816721e-02f, 6.86177090e-02f, 4.11707461e-02f, 3.92304733e-03f,
  -1.01807388e-02f, 1.40201831e-02f, -3.72684584e-03f, -6.40823469e-02f, 1.02038845e-01f, 1.93671025e-02f, 7.86898881e-02f, 4.17426974e-02f, 6.69392385e-03f, -5.48106395e-02f,
  6.92154989e-02f, 8.07019975e-03f, 2.20354244e-01f, -1.02743551e-01f, 7.14447051e-02f, 2.51890898e-01f, 2.26989552e-01f, -1.04546465e-01f, 2.08546117e-01f, -9.30611193e-02f,
  -1.64868422e-02f, 1.37733266e-01f, -3.71987335e-02f, -4.80554700e-02f, 1.65575907e-01f, -3.26708369e-02f, 3.17153633e-02f, 8.62688944e-03f, -1.77093837e-02f, -7.01760501e-02f,
  -4.67825904e-02f, -1.51497275e-01f, 5.68372384e-02f, -2.36818846e-02f, 1.24819055e-01f, -7.34427385e-03f, -1.59936175e-01f, -1.61886513e-02f, -4.27470170e-03f, 1.00228049e-01f,
  8.40816647e-02f, 6.83043078e-02f, 8.48761052e-02f, 2.13053748e-02f, 8.33766535e-02f, 6.97209761e-02f, -3.00166905e-02f, 1.76778194e-02f, 2.50560604e-02f, 2.88318601e-02f,
  5.78294694e-02f, -3.78058255e-02f, -1.07987272e-02f, -1.22098485e-02f, 6.20129369e-02f, 6.67043105e-02f, 4.93965000e-02f, -8.10593553e-03f, 2.51445677e-02f, 6.02391735e-02f,
  2.88032517e-02f, -2.67007248e-03f, -3.85210849e-02f, -8.86844471e-02f, 2.49213893e-02f, -6.52100146e-02f, 9.76029113e-02f, -1.49562256e-02f, 1.45802632e-01f, -2.15506274e-02f,
  -3.75985652e-02f, 5.26913814e-02f, 2.00187205e-03f, 3.92826162e-02f, 2.22076885e-02f, -6.44943640e-02f, 2.59751137e-02f, -2.21277252e-02f, 4.21973765e-02f, -8.84640664e-02f,
  6.07290454e-02f, 1.02057715e-03f, -4.76531051e-02f, -4.99661192e-02f, -2.45826021e-02f, -5.84505685e-02f, 2.98414752e-02f, 4.79435502e-03f, 9.43449065e-02f, -4.60301945e-03f,
  2.19091102e-02f, -1.69449225e-02f, 3.23283183e-03f, 4.70066071e-03f, 3.50367911e-02f, -3.14654550e-03f, -3.46526094e-02f, -5.72309457e-02f, 3.52985077e-02f, -5.22870384e-02f,
  -3.06291133e-02f, 4.29842360e-02f, 9.65968613e-03f, 7.60009587e-02f, -2.42936308e-04f, -6.37137145e-02f, 1.87295061e-02f, 5.34344465e-02f, -4.42201793e-02f, 8.74993950e-02f,
  9.80728492e-03f, -4.67648245e-02f, 8.54037479e-02f, -5.03136851e-02f, -7.29204938e-02f, 1.19198719e-02f, -7.21694380e-02f, -6.35759812e-03f, 2.97035910e-02f, -3.60416993e-02f,
  -6.56588376e-02f, 6.53807893e-02f, -6.32617623e-02f, -5.40221576e-03f, -8.04823637e-02f, -5.39841503e-02f, 5.89948073e-02f, 7.29103982e-02f, -7.08703697e-02f, 1.00071311e-01f,
  -3.22681189e-01f, 1.01879090e-01f, 1.05089672e-01f, -8.96090716e-02f, -2.18331188e-01f, -1.75168186e-01f, -1.59422666e-01f, 9.48624685e-02f, 3.13419243e-03f, 8.71690288e-02f,
  -1.50998130e-01f, 1.73159931e-02f, 1.37696773e-01f, -5.31839691e-02f, -1.97835580e-01f, 1.73276797e-01f, -8.38797763e-02f, -7.43316934e-02f, 8.66141692e-02f, -3.99391465e-02f,
  -3.72305810e-02f, 2.56380928e-03f, 1.85487330e-01f, 2.57510152e-02f, -5.70465671e-03f, 2.69761533e-02f, -6.83338344e-02f, 1.79001838e-02f, -5.00658900e-02f, -5.87394126e-02f,
  -6.54805172e-03f, 6.58940226e-02f, -4.23784330e-02f, 3.55085842e-02f, -3.73353902e-03f, -8.79538897e-03f, -3.24318148e-02f, -4.88996692e-02f, -8.57844763e-03f, 8.38647038e-03f,
  1.16769668e-04f, 1.44171738e-03f, -3.17269824e-02f, -1.04418881e-02f, -3.63084003e-02f, 9.34044048e-02f, 6.07391372e-02f, 3.05596995e-03f, 5.84980622e-02f, 4.01473157e-02f,
  4.56161797e-02f, 6.24473300e-03f, 2.43178161e-04f, 8.94756168e-02f, -4.74993251e-02f, 2.82377936e-04f, 4.43948666e-03f, -3.55311222e-02f, 2.90101264e-02f, -1.97535157e-02f,
  -2.02464685e-03f, -1.34806223e-02f, 2.90420298e-02f, 1.05097182e-01f, 1.63591914e-02f, 6.72643036e-02f, -4.92624789e-02f, 4.32728827e-02f, -6.16084486e-02f, 9.09860246e-03f,
  5.28677218e-02f, -4.61168960e-02f, -3.01821101e-02f, -2.01469418e-02f, -3.53078619e-02f, -6.90465942e-02f, 5.93328150e-04f, -4.88491030e-03f, -6.32141542e-04f, -2.87738461e-02f,
  1.95449702e-02f, -1.12457667e-02f, -1.46672232e-02f, 3.63860652e-03f, 2.53389645e-02f, -1.74290892e-02f, -3.49038839e-02f, 3.56356464e-02f, 5.16504571e-02f, -4.61362712e-02f,
  -8.06473603e-04f, -6.12066202e-02f, -1.86369605e-02f, 4.38163653e-02f, 6.62840307e-02f, -7.75557980e-02f, 9.05248597e-02f, -3.50300558e-02f, -4.36812714e-02f, -1.47395972e-02f,
  -7.72445798e-02f, 3.21422592e-02f, -5.75837158e-02f, -1.56006003e-02f, 2.74074879e-02f, 1.01907533e-02f, 1.82399433e-02f, 1.57611985e-02f, 8.25503841e-03f, 7.85075948e-02f,
  -1.03880167e-02f, -2.20507979e-02f, 1.84223596e-02f, -3.46648321e-02f, -4.64090891e-02f, -2.45655291e-02f, -9.71166883e-03f, 8.22851434e-02f, -8.68098214e-02f, -5.50934821e-02f,
  -4.02498335e-01f, 2.45849133e-01f, -1.39914989e-01f, 1.25311211e-01f, 2.30095591e-02f, 4.24803756e-02f, -3.15475501e-02f, -1.38906455e-02f, -5.62151782e-02f, 3.06583103e-02f,
  -2.54284348e-02f, -1.41680896e-01f, -7.58819804e-02f, 2.15303376e-01f, -1.76010326e-01f, 3.94794680e-02f, 1.53559744e-01f, 8.33373815e-02f, 9.88362432e-02f, -5.02811968e-02f,
  7.24637061e-02f, 2.73606807e-01f, 6.65008202e-02f, 1.69797197e-01f, 1.18220389e-01f, -2.97004040e-02f, 6.73113912e-02f, 6.60032183e-02f, 6.81177154e-02f, 1.35020927e-01f,
  1.22456038e-02f, -1.72862574e-01f, 2.92578526e-02f, -6.60813004e-02f, -3.13051194e-02f, 8.68049171e-03f, -8.16610269e-03f, -2.32379287e-02f, -8.59206915e-02f, -4.82789725e-02f,
  -5.90068437e-02f, 2.40775440e-02f, -7.76243657e-02f, -2.76530441e-02f, 5.61318658e-02f, 1.87619645e-02f, 3.71219218e-02f, 1.33655118e-02f, -2.12338753e-02f, -1.75151285e-02f,
  2.51276474e-02f, 2.47873086e-02f, -1.00868158e-02f, -1.51090659e-02f, -7.75699466e-02f, 3.70907076e-02f, 9.91055276e-03f, 3.38696763e-02f, 2.83267442e-02f, -8.41427222e-02f,
  1.99769009e-02f, -1.04969218e-01f, 3.99187803e-02f, 3.17475363e-03f, 1.34895459e-01f, 1.49061531e-02f, -2.79872976e-02f, 2.98079918e-03f, 5.11959195e-02f, 1.39012486e-02f,
  2.65318882e-02f, 3.22695710e-02f, 2.14144643e-02f, -4.35567871e-02f, 6.93735033e-02f, -6.90007210e-02f, -8.05420429e-02f, -2.62938961e-02f, -7.99124092e-02f, -2.11895462e-02f,
  2.25717574e-02f, -8.96901935e-02f, 1.23259977e-01f, -3.73736508e-02f, 4.32574749e-03f, 4.81663533e-02f, -6.25920519e-02f, 8.74762908e-02f, 4.03265320e-02f, -8.91876891e-02f,
  6.69641653e-03f, 8.95922035e-02f, -6.23075701e-02f, 2.18620170e-02f, 7.03016222e-02f, 2.03351378e-02f, -1.93259604e-02f, 6.51655048e-02f, -1.37664974e-02f, 4.96012755e-02f,
  -6.19792156e-02f, -1.07002445e-02f, 1.73769500e-02f, 1.08961761e-02f, 1.13423914e-02f, 5.84236607e-02f, 4.59081912e-03f, -1.79144517e-02f, -6.83956295e-02f, -1.92511622e-02f,
  9.92335454e-02f, 4.20089401e-02f, -8.95425677e-03f, 8.18911642e-02f, 9.20006782e-02f, -4.10343036e-02f, -1.02732398e-01f, 2.22942904e-02f, 2.93552503e-02f, 4.26464602e-02f,
  1.16928831e-01f, 1.66107237e-01f, 1.94473565e-02f, 3.83925259e-01f, -1.18478965e-02f, 9.99250934e-02f, 1.08842984e-01f, 7.98584372e-02f, 1.84577852e-01f, 5.91773465e-02f,
  5.82648888e-02f, 2.76359152e-02f, -4.24568467e-02f, 2.83597648e-01f, 1.11084662e-01f, 2.01896708e-02f, 1.96538955e-01f, 5.27643152e-02f, -8.18400178e-03f, 6.37182668e-02f,
  6.81594759e-02f, 2.55829632e-01f, 3.12657170e-02f, 4.08148021e-02f, 8.97114724e-02f, -1.96007240e-04f, -1.18268654e-02f, -9.66077596e-02f, 1.17537729e-01f, -1.09270535e-01f,
  5.94084784e-02f, 1.48817049e-02f, 5.10480255e-03f, -3.15551274e-02f, 5.57631254e-02f, -2.41217911e-02f, -2.57051233e-02f, -1.21273324e-02f, -6.72359252e-03f, -5.15407436e-02f,
  -2.82657519e-02f, -2.51006614e-02f, 3.01567595e-02f, -3.57696265e-02f, 4.29085642e-02f, 2.33942308e-02f, 4.49212007e-02f, 3.91860157e-02f, -5.72299138e-02f, -2.70411894e-02f,
  4.57226075e-02f, -2.28404496e-02f, 7.13001415e-02f, 4.94990572e-02f, -8.41458794e-03f, 8.65826234e-02f, 5.55890948e-02f, -9.83957499e-02f, 1.35355694e-02f, -3.08635226e-03f,
  -1.76837439e-05f, -3.50069115e-03f, -4.90047336e-02f, 3.70180979e-02f, 5.80025241e-02f, -5.99889159e-02f, 3.62930410e-02f, -3.59064899e-02f, -5.03055677e-02f, 4.21948843e-02f,
  -1.85833089e-02f, -4.29631248e-02f, -6.22431226e-02f, -3.31832655e-02f, 4.33249883e-02f, 1.95552711e-03f, -5.64609878e-02f, -1.30652823e-02f, 4.84096967e-02f, 3.47303003e-02f,
  -3.32664400e-02f, 1.47026535e-02f, -5.69023639e-02f, -5.27331345e-02f, 4.95781861e-02f, 9.70993284e-03f, 5.91379637e-03f, 2.19264179e-02f, -8.98608416e-02f, -2.56626103e-02f,
  1.16806567e-01f, 5.48601337e-02f, 3.61567847e-02f, -1.38154803e-02f, -4.55980040e-02f, 9.28957947e-03f, 3.15459408e-02f, -4.56310483e-03f, -1.24808531e-02f, 7.47545436e-02f,
  3.12018655e-02f, 9.70183965e-03f, -1.65483896e-02f, -3.85120185e-03f, 9.47285444e-03f, 1.86549556e-02f, -3.48196998e-02f, -5.88361397e-02f, 6.99969083e-02f, 6.78293332e-02f,
  -3.07635199e-02f, -3.65462564e-02f, -6.11376166e-02f, 2.20531337e-02f, 2.50876211e-02f, -5.52162081e-02f, -1.67575050e-02f, 3.44548486e-02f, -2.78463084e-02f, 5.69513254e-02f,
  1.27485320e-01f, -7.80128762e-02f, 1.92199424e-01f, 3.41304950e-02f, -1.12215035e-01f, 1.80098891e-01f, 3.31611820e-02f, 1.03286572e-01f, 4.04855646e-02f, -9.64713097e-02f,
  3.57313603e-02f, -4.42403220e-02f, -2.79782228e-02f, 1.45895958e-01f, 1.95064187e-01f, 6.55471683e-02f, 1.42500699e-01f, 6.54011518e-02f, 8.85700211e-02f, 1.23304218e-01f,
  1.67502418e-01f, 2.10043341e-01f, 1.71050817e-01f, 4.13986742e-02f, 7.63375983e-02f, -4.03030403e-02f, -1.89717323e-01f, -7.73343211e-03f, 8.50989968e-02f, -1.65307941e-03f,
  6.78549409e-02f, -5.61523344e-03f, 7.72538409e-02f, 7.34666437e-02f, 2.38702609e-03f, 5.51021425e-03f, -4.81165620e-03f, -9.59538892e-02f, 5.22077344e-02f, -4.40489724e-02f,
  -7.65021294e-02f, 1.00240037e-01f, -1.00324191e-02f, 1.89150330e-02f, -2.22386532e-02f, -1.45081067e-02f, 5.10320142e-02f, -6.88602403e-02f, -4.93763089e-02f, 6.42399192e-02f,
  4.92992103e-02f, -7.98125193e-02f, -4.70161587e-02f, 7.36888498e-02f, 9.16621611e-02f, -2.96896622e-02f, 4.13530059e-02f, -3.51358391e-02f, -8.99906754e-02f, 6.82149753e-02f,
  -2.93610548e-03f, 1.00740828e-02f, 4.56117094e-02f, 2.44650524e-02f, 3.53458226e-02f, -1.52081270e-02f, 9.93072893e-03f, 1.13205919e-02f, -2.81542800e-02f, 6.94053546e-02f,
  9.39420611e-02f, -2.83275302e-02f, 7.18824714e-02f, 7.78803602e-02f, -2.77332552e-02f, 1.35022402e-02f, 6.66416660e-02f, -9.15779546e-02f, 3.43259051e-03f, -4.70424592e-02f,
  8.74491185e-02f, -2.12470125e-02f, 6.88583851e-02f, -3.43937017e-02f, 3.04689445e-02f, 6.21659197e-02f, -2.87389588e-02f, -7.59069668e-03f, 5.14904363e-03f, -1.19149936e-02f,
  -6.83871806e-02f, -3.13941389e-02f, 3.45374607e-02f, -2.83492748e-02f, 2.46220715e-02f, -1.31598311e-02f, -1.03541434e-01f, 6.29381612e-02f, -4.31792848e-02f, 2.58481912e-02f,
  -5.19512706e-02f, -3.07806283e-02f, -2.53679585e-02f, 7.21476749e-02f, 4.19719256e-02f, 4.87524644e-02f, 1.37280785e-02f, -6.01252057e-02f, -3.23028825e-02f, -6.95052892e-02f,
  -8.44153240e-02f, -5.26733957e-02f, -6.85805548e-03f, 7.85162020e-03f, -1.30909970e-02f, -1.24172084e-02f, -1.39147997e-01f, 9.02979076e-02f, 1.51995998e-02f, -6.25883862e-02f,
  -3.24401081e-01f, 2.74118930e-02f, 4.31981906e-02f, -1.93370402e-01f, -6.31826967e-02f, 5.84670044e-02f, 1.73699915e-01f, -2.23396629e-01f, -2.59542149e-02f, 8.58896449e-02f,
  -8.96601155e-02f, 5.71775883e-02f, 3.60016003e-02f, 1.01217972e-02f, -7.12564737e-02f, 1.46489322e-01f, -8.02060738e-02f, -4.74420376e-03f, 4.69803177e-02f, -1.88111022e-01f,
  1.89811736e-02f, -7.54109547e-02f, 1.29706261e-03f, -1.67597026e-01f, -1.00600347e-01f, -1.73723742e-01f, -3.44281248e-03f, -1.59724951e-02f, -1.79852620e-02f, 5.48553914e-02f,
  -8.03267956e-02f, -1.51894420e-01f, 3.97172496e-02f, 1.88429300e-02f, -1.09865880e-02f, -8.74451641e-03f, -2.09542271e-02f, 2.79346444e-02f, -4.39103171e-02f, 5.24741178e-03f,
  -1.38348248e-02f, -9.65251867e-03f, -1.58585347e-02f, 7.75109828e-02f, 1.05129592e-01f, 8.81348848e-02f, -2.36314442e-02f, 7.51761124e-02f, -5.87256141e-02f, 5.37797203e-03f,
  9.38296225e-03f, -2.43366510e-02f, -6.17862307e-02f, -3.22709442e-03f, -8.45863950e-03f, 2.90633049e-02f, -3.72489821e-03f, 9.75728035e-03f, -2.03636009e-02f, -9.05774757e-02f,
  -2.72030942e-02f, -4.13193814e-02f, 2.46530026e-02f, -1.92884095e-02f, -5.33707887e-02f, -6.43664524e-02f, -2.93056369e-02f, 5.51168993e-02f, 9.24100578e-02f, 2.95753125e-02f,
  -1.77494138e-02f, -6.33566454e-02f, -3.20319571e-02f, 2.44055223e-02f, -3.71425301e-02f, -7.92435780e-02f, -3.35153099e-03f, -3.09683895e-03f, -1.73517205e-02f, -7.57470503e-02f,
  -2.43031960e-02f, 7.13214874e-02f, -6.50822744e-02f, 4.26826887e-02f, -1.44747421e-02f, 1.06175683e-01f, 4.20413576e-02f, 3.69262397e-02f, 1.35839859e-03f, -1.53947324e-02f,
  -7.87314177e-02f, -1.59156531e-01f, 5.69786318e-02f, -4.70302328e-02f, 3.21839117e-02f, 1.84219179e-03f, 9.74776745e-02f, -2.66147237e-02f, 3.10848765e-02f, -5.82921095e-02f,
  3.64650078e-02f, -6.76567256e-02f, -9.16023850e-02f, 1.24275889e-02f, -1.45762069e-02f, -3.05158012e-02f, -4.45264988e-02f, -7.24342391e-02f, 1.96567103e-02f, -1.01651132e-01f,
  -2.96226703e-02f, -4.75088097e-02f, 5.64265028e-02f, -9.35659036e-02f, -6.16730079e-02f, -3.33986245e-02f, -1.01743750e-01f, -2.35768016e-02f, 2.88580712e-02f, 6.66792095e-02f,
  -1.10465191e-01f, -1.58084687e-02f, 9.01586413e-02f, -9.91402194e-02f, -1.29775450e-01f, -2.25627925e-02f, 8.50021169e-02f, -1.25276312e-01f, 1.72172070e-01f, -8.55914429e-02f,
  -4.55028191e-02f, 8.47766921e-02f, 7.43217915e-02f, -1.33421719e-01f, -4.64696474e-02f, 1.23494633e-01f, -1.46195322e-01f, 1.67584307e-02f, 1.04832947e-01f, -1.30006492e-01f,
  4.59407941e-02f, -1.52387217e-01f, -6.58759028e-02f, -9.41963643e-02f, -1.39269024e-01f, -1.15244801e-03f, -1.90394104e-01f, -6.36148872e-03f, -1.84000984e-01f, -4.20574695e-02f,
  -1.56986400e-01f, 4.27746885e-02f, -3.62024829e-02f, 1.14013426e-01f, -1.18281163e-01f, 3.68179493e-02f, 5.41163832e-02f, 7.16945976e-02f, 6.81603327e-02f, 3.84943075e-02f,
  6.90656975e-02f, -2.00144183e-02f, -5.51059544e-02f, 1.04745738e-01f, -1.08074332e-02f, -6.50893375e-02f, 5.79787269e-02f, -6.25845045e-02f, 8.80699679e-02f, 6.70173466e-02f,
  2.91452352e-02f, -2.74504852e-02f, 5.72253950e-02f, 3.79458698e-03f, 8.87459442e-02f, 1.74066313e-02f, -4.23374139e-02f, 1.92070082e-02f, -5.78567386e-02f, 3.26947868e-02f,
  -2.90498734e-02f, -1.27155297e-02f, -4.89252545e-02f, -3.95195261e-02f, -4.23565395e-02f, -7.10308775e-02f, -2.72602774e-02f, -5.17220981e-02f, -5.39568812e-02f, -3.56643870e-02f,
  -8.28367323e-02f, -4.54932116e-02f, 5.06672785e-02f, 2.08585244e-02f, 4.70096171e-02f, -2.37006247e-02f, -2.99075712e-03f, -2.88937185e-02f, 5.36697283e-02f, -9.64174687e-04f,
  -2.43998691e-02f, -6.79581314e-02f, -8.61417428e-02f, 4.95072976e-02f, -4.90452955e-03f, 4.37322631e-02f, 9.42473784e-02f, -3.77296545e-02f, -2.10782606e-02f, -3.68737541e-02f,
  -1.52897820e-01f, -1.71941295e-01f, -5.57314381e-02f, -8.74234140e-02f, -4.70678955e-02f, -5.86195700e-02f, 2.23960001e-02f, 8.94394964e-02f, 4.55277339e-02f, -1.45023195e-02f,
  -7.89224207e-02f, 3.13613862e-02f, -3.78974378e-02f, -2.84490790e-02f, 2.33041067e-02f, 3.28409933e-02f, -6.72611371e-02f, 2.50090752e-02f, -1.06738865e-01f, -8.56128633e-02f,
  -9.67974514e-02f, -8.81466176e-03f, -1.62233952e-02f, 3.30586801e-03f, 3.77899893e-02f, -1.87008865e-02f, -3.33810300e-02f, 7.17678294e-02f, 5.43915033e-02f, 1.10463379e-03f,
  -2.79816706e-02f, -1.49630830e-01f, -1.37096450e-01f, -2.53697974e-03f, 1.37018442e-01f, -2.84961704e-02f, -7.85803422e-02f, -8.99008755e-03f, -5.10533974e-02f, 5.10478392e-02f,
  1.02647245e-01f, -1.00192860e-01f, -5.18461317e-02f, -1.08526060e-02f, 5.74408807e-02f, -1.03269883e-01f, 9.35171396e-02f, -9.32046250e-02f, -2.19326597e-02f, 5.36556095e-02f,
  3.92508446e-05f, 8.36769193e-02f, -1.00831188e-01f, -3.49220168e-03f, -3.91410105e-02f, 2.65748948e-02f, 2.05702618e-01f, -4.57320698e-02f, 1.32269859e-01f, 1.62067246e-02f,
  1.03799738e-01f, -4.94215563e-02f, 1.08907690e-04f, -4.50601568e-03f, -2.97237765e-02f, 1.55062517e-02f, -2.64698491e-02f, 1.08609768e-02f, 9.57699493e-02f, 7.00187730e-03f,
  -6.39934912e-02f, 3.92772108e-02f, -2.55222134e-02f, -1.12844430e-01f, -7.31058940e-02f, -2.80339527e-03f, 2.29476877e-02f, 2.56062718e-03f, -6.01694770e-02f, 3.05110794e-02f,
  -1.27955303e-01f, -3.68128531e-02f, -7.91022927e-02f, 3.49644944e-02f, -1.09130144e-01f, -6.95300475e-02f, 4.13127206e-02f, -5.22139147e-02f, -1.27712665e-02f, -7.50165209e-02f,
  -4.70201075e-02f, 6.55142637e-03f, 6.85449690e-02f, 2.03731377e-02f, 3.25393081e-02f, 7.73137733e-02f, 2.65413132e-02f, 4.44975197e-02f, 1.15927551e-02f, 5.20088784e-02f,
  4.06846665e-02f, -2.08577309e-02f, -1.36407437e-02f, 2.03872155e-02f, -4.60470952e-02f, -4.86840457e-02f, 9.22608003e-03f, -1.91793740e-02f, -2.85980329e-02f, 2.30847150e-02f,
  -5.63047603e-02f, -5.11123873e-02f, -4.22113724e-02f, 2.23049633e-02f, -8.22990984e-02f, -6.58491626e-02f, -3.10824551e-02f, -8.21418464e-02f, 3.87959331e-02f, 6.29648045e-02f,
  9.62679461e-02f, 4.02539745e-02f, 5.38750030e-02f, -9.88868251e-03f, 9.24404562e-02f, 1.95506085e-02f, 2.82545108e-02f, 5.04468419e-02f, 2.17237025e-02f, 4.26438749e-02f,
  -3.69271487e-02f, 4.31195758e-02f, 5.59293032e-02f, -1.68122351e-03f, -6.83310553e-02f, 2.89685018e-02f, 5.62717393e-03f, -3.69354971e-02f, 1.12638138e-01f, 8.40232894e-02f,
  1.05769604e-01f, 4.96002100e-02f, 4.08843951e-03f, -2.22654957e-02f, 1.04609460e-01f, -3.11302458e-04f, 9.91805196e-02f, -6.25466555e-02f, 7.73614347e-02f, 4.75174226e-02f,
  -2.37003807e-02f, 2.80811191e-01f, -7.14413300e-02f, 1.18785821e-01f, -1.31732330e-01f, -1.09065004e-01f, -5.76901715e-04f, 3.83190997e-02f, 1.73858434e-01f, 9.22756344e-02f,
  5.38688600e-02f, -3.05294115e-02f, 8.01164433e-02f, 8.68670568e-02f, -6.60953298e-03f, 2.21114472e-01f, 9.35613960e-02f, 4.57515344e-02f, 1.46577507e-01f, 5.27352653e-02f,
  -1.34079261e-02f, 5.22200949e-02f, 3.42916213e-02f, -9.45766494e-02f, -7.90378302e-02f, -6.28198385e-02f, 5.53211607e-02f, -5.42212874e-02f, -2.24783793e-01f, 9.57718957e-03f,
  8.67953598e-02f, 1.51163444e-01f, -1.08873256e-01f, -7.61588141e-02f, -6.33433610e-02f, -2.29187999e-02f, -9.31005254e-02f, -6.59205467e-02f, 2.32572504e-03f, -1.03015482e-01f,
  -6.43838644e-02f, -1.06722772e-01f, -1.37596857e-02f, 3.13399429e-03f, 3.08572799e-02f, -1.19648622e-02f, -1.78827737e-02f, -4.57088500e-02f, -1.13114834e-01f, 6.78889751e-02f,
  -1.33936331e-02f, -1.30930834e-03f, -1.33356629e-02f, -1.65244490e-02f, 3.09744943e-03f, 5.11206454e-04f, 4.36027050e-02f, -1.04931176e-01f, 3.88179831e-02f, 4.21745963e-02f,
  -3.43119837e-02f, 6.53189048e-02f, -2.34374888e-02f, -1.78275499e-02f, 6.00907430e-02f, -4.75700833e-02f, 6.58815503e-02f, -3.51160718e-03f, 1.70293089e-03f, 1.30894482e-02f,
  -4.43810001e-02f, 2.14375649e-03f, 4.36525792e-02f, 8.49864930e-02f, 1.54221635e-02f, 4.70118448e-02f, -1.12245018e-02f, -5.39163016e-02f, -2.66620852e-02f, -3.45846936e-02f,
  6.08854890e-02f, -4.53701708e-03f, -3.78568918e-02f, 1.22344168e-02f, 1.81890819e-02f, -9.93915722e-02f, -1.84363443e-02f, -1.00554109e-01f, -5.82974143e-02f, 6.52475376e-03f,
  5.04533909e-02f, 1.93956316e-01f, -2.19147038e-02f, -1.69679727e-02f, 7.19305919e-03f, 1.25370547e-02f, 1.12623811e-01f, 4.37073857e-02f, 5.60587794e-02f, 3.63797955e-02f,
  -8.52136910e-02f, 2.00241413e-02f, 5.51063344e-02f, -6.47817254e-02f, -2.61742752e-02f, 2.11522691e-02f, 3.20693031e-02f, -5.51693775e-02f, -3.92478071e-02f, -2.49820948e-03f,
  -2.79559642e-02f, 3.85411829e-02f, 4.93250638e-02f, -5.87978102e-02f, -3.00418702e-03f, -4.53668572e-02f, 4.76653911e-02f, -3.11860330e-02f, 1.08708302e-02f, -2.18849257e-02f,
  1.97647095e-01f, 2.68623326e-02f, 8.45379382e-02f, 2.80966848e-01f, -4.35875356e-02f, -1.02964640e-01f, -1.49389923e-01f, 1.83358163e-01f, 2.22729761e-02f, -5.07768393e-02f,
  4.92392061e-03f, 1.81663167e-02f, -1.49629563e-01f, 2.05098480e-01f, 1.11910731e-01f, -1.15787676e-02f, 1.56362966e-01f, 1.32005988e-02f, 8.28626379e-02f, -4.18174565e-02f,
  1.49854407e-01f, 3.19338366e-02f, 9.49839801e-02f, 8.22580904e-02f, 1.00588337e-01f, 4.95530888e-02f, -1.13421185e-02f, -1.90788776e-01f, 1.71753049e-01f, 3.34804654e-02f,
  7.51997828e-02f, 8.47131759e-02f, 1.12787299e-01f, -7.61085674e-02f, -3.40990946e-02f, -5.57706207e-02f, -1.17414720e-01f, -4.08233926e-02f, -4.40488420e-02f, -4.75966446e-02f,
  5.07806987e-03f, -1.88788194e-02f, 4.92832139e-02f, -6.29386166e-03f, 1.21416993e-01f, 9.23785120e-02f, -3.81419696e-02f, -1.86221879e-02f, 8.32272545e-02f, 6.48770994e-03f,
  -8.07874575e-02f, -2.72257347e-02f, 5.98045848e-02f, -6.90285489e-02f, -6.42097145e-02f, 4.89858948e-02f, -5.15171997e-02f, -4.08742204e-02f, 7.59320706e-02f, 3.05849854e-02f,
  -9.15925950e-03f, 8.16958840e-04f, 1.26365470e-02f, 7.66811147e-02f, -3.44053051e-03f, 4.56876084e-02f, 5.34594059e-02f, 5.87574020e-02f, -6.67525083e-03f, -4.81753610e-02f,
  1.91917401e-02f, 7.34404698e-02f, 1.18248850e-01f, -2.09521372e-02f, 1.64435487e-02f, -5.45198135e-02f, -3.91900465e-02f, 2.12551211e-03f, 3.60219032e-02f, -8.96017533e-03f,
  9.09221917e-03f, 7.97800440e-03f, -4.05581072e-02f, -5.94973238e-03f, 7.02458322e-02f, 2.27126218e-02f, 1.24910325e-01f, -1.49737354e-02f, 2.44303308e-02f, -4.01016138e-02f,
  -6.11497574e-02f, 4.22482416e-02f, -8.41991156e-02f, -2.71633249e-02f, -8.98943320e-02f, -1.20004132e-01f, 7.43720755e-02f, 4.25714850e-02f, 1.64219197e-02f, 8.48851725e-03f,
  -5.37273660e-02f, -7.42527563e-03f, -6.24813065e-02f, -4.13106382e-03f, 9.22980458e-02f, -8.80835503e-02f, -7.93685168e-02f, 6.24779314e-02f, 5.74001633e-02f, 7.41447657e-02f,
  -3.78524475e-02f, -1.42609686e-01f, 3.94777320e-02f, -1.02524571e-01f, 3.48297432e-02f, -1.31323025e-01f, -1.25742946e-02f, -3.38084041e-03f, 2.57580932e-02f, 4.27490212e-02f,
  2.20027026e-02f, -3.30328904e-02f, -5.90393171e-02f, -4.61040772e-02f, -1.60208270e-01f, 1.62050173e-01f, 1.39707461e-01f, -1.15035757e-01f, 1.07699022e-01f, 9.54818875e-02f,
  7.90733173e-02f, 1.89973805e-02f, 1.67238116e-01f, 6.92981470e-04f, 1.10912770e-01f, 1.82681888e-01f, 1.55353202e-02f, -2.41628336e-03f, 1.83403734e-02f, -1.10955209e-01f,
  -1.84753630e-02f, 5.11958078e-02f, -9.48724598e-02f, -1.18618175e-01f, -8.20798650e-02f, -1.00032166e-01f, -1.16785191e-01f, -5.71407415e-02f, -1.83070526e-01f, -2.94611696e-02f,
  1.56273276e-01f, 6.12946227e-02f, 2.81668790e-02f, -1.30251702e-02f, -2.00664513e-02f, -4.85540479e-02f, -8.76346044e-03f, -8.28072894e-03f, 6.89252242e-02f, -5.52432686e-02f,
  5.85045740e-02f, -2.38470989e-03f, -2.28606835e-02f, 6.24728017e-02f, -4.78349663e-02f, -6.09223032e-03f, -1.08786844e-01f, 7.05695013e-03f, -8.92610103e-02f, -3.51401381e-02f,
  4.02048081e-02f, 3.30619179e-02f, 3.97014990e-03f, 2.68767979e-02f, -2.18520258e-02f, 5.86190298e-02f, -1.74136162e-02f, 4.10226956e-02f, -3.54107954e-02f, -5.22954296e-03f,
  4.87533845e-02f, -5.54060899e-02f, -2.32231934e-02f, 2.72214413e-02f, -5.51438332e-02f, 5.77682890e-02f, 3.67617089e-04f, 4.39108498e-02f, -2.97034606e-02f, -1.39978444e-02f,
  2.98530459e-02f, -1.95535701e-02f, -4.36830372e-02f, 4.90834229e-02f, 1.15583967e-02f, 8.12579840e-02f, -1.70234945e-02f, -9.72011127e-03f, 1.78250521e-02f, 5.75328916e-02f,
  -2.96382494e-02f, 1.35791684e-02f, -1.21151628e-02f, -9.39505268e-03f, 6.17230199e-02f, 2.73095183e-02f, -2.27568094e-02f, 3.19758132e-02f, -3.42468992e-02f, -4.05257419e-02f,
  9.56141483e-03f, 9.70325992e-02f, -1.82156581e-02f, -4.00690995e-02f, 1.05151497e-01f, 4.56925929e-02f, -4.61765639e-02f, -2.72778142e-02f, 4.31391299e-02f, 4.90180850e-02f,
  6.87805237e-03f, 2.88263373e-02f, -6.78159818e-02f, -2.47440990e-02f, 1.64312571e-02f, 5.68714663e-02f, -2.13239086e-03f, 6.11016192e-02f, 1.23778440e-03f, 4.03908305e-02f,
  -4.14880440e-02f, -3.12758386e-02f, -9.08936188e-02f, -2.10113991e-02f, -9.04985331e-03f, 3.57540441e-03f, 6.02062941e-02f, 4.26454982e-03f, 5.30627510e-03f, 2.46404428e-02f,
  1.47125393e-01f, 3.73550430e-02f, -2.34082699e-01f, -4.45172861e-02f, -4.31836490e-03f, -3.02297533e-01f, -2.54817486e-01f, -2.44398545e-02f, 6.85874596e-02f, 5.95179237e-02f,
  9.10683200e-02f, 5.79438061e-02f, -5.27197197e-02f, -7.25710019e-02f, -1.85546324e-01f, -1.28311500e-01f, -1.75375000e-01f, -4.46047336e-02f, -3.38240750e-02f, -6.00767881e-02f,
  4.89693917e-02f, 2.50296686e-02f, -1.45348415e-01f, 8.64544287e-02f, 1.82720702e-02f, 4.36180606e-02f, 1.13333240e-02f, 4.84552458e-02f, -1.01987228e-01f, -3.45802866e-02f,
  5.47685511e-02f, 1.58327475e-01f, 4.16863412e-02f, -6.92916960e-02f, -4.14925860e-03f, 6.80588707e-02f, -7.41659403e-02f, -1.13026306e-01f, 2.50744028e-03f, -3.20939608e-02f,
  -1.47216413e-02f, 3.20845954e-02f, -9.27882865e-02f, 5.90659566e-02f, 1.72758866e-02f, 6.70939907e-02f, 1.70571655e-02f, -2.16020569e-02f, -4.88774367e-02f, -3.97791192e-02f,
  -6.46170080e-02f, 2.92005390e-03f, -3.32461521e-02f, -3.55200134e-02f, 1.93099037e-03f, 1.47064347e-02f, -2.97792144e-02f, 4.67979908e-02f, -4.45147082e-02f, -4.40916047e-03f,
  -6.13909448e-03f, 5.32042868e-02f, 2.93750670e-02f, 3.64543647e-02f, -4.11658622e-02f, 8.72906297e-02f, -6.55104918e-03f, -4.88219261e-02f, -2.90595903e-03f, 2.11544726e-02f,
  -3.93611938e-03f, -2.51555368e-02f, 9.88385826e-02f, 4.66308221e-02f, -4.60686274e-02f, 6.21774383e-02f, -1.57615282e-02f, 1.06424754e-02f, 2.83787474e-02f, 2.29889387e-03f,
  -4.36179116e-02f, 3.97361256e-02f, -6.88445568e-02f, -2.92161051e-02f, -2.31156368e-02f, -8.21964291e-04f, 4.12558764e-02f, -2.23286655e-02f, -6.87973797e-02f, -7.63736442e-02f,
  1.67458192e-01f, 1.11074895e-01f, 8.19446240e-03f, 8.58452320e-02f, 2.80733760e-02f, 4.13541608e-02f, -3.22797857e-02f, 4.67945822e-02f, 4.25747000e-02f, -2.31039338e-02f,
  8.22630227e-02f, 2.35218070e-02f, 3.39902341e-02f, 1.91079993e-02f, -1.59465673e-03f, -7.02600777e-02f, -1.98771376e-02f, 3.61224683e-03f, 8.08219314e-02f, 8.82786587e-02f,
  1.11714732e-02f, -2.59208004e-03f, -1.94722638e-02f, 2.10208707e-02f, -4.98147421e-02f, 4.92071845e-02f, 5.16188443e-02f, 3.19430828e-02f, 6.50487021e-02f, -1.46219740e-02f,
  -7.39494413e-02f, 9.34735164e-02f, 2.23615080e-01f, 2.10123107e-01f, 1.03988200e-01f, -1.09299056e-01f, 7.13083148e-02f, 2.35719308e-01f, 2.69519538e-01f, -1.37605488e-01f,
  -1.20828085e-01f, -1.96741074e-02f, -6.62623122e-02f, 3.67053226e-02f, -2.01390997e-01f, -1.86446071e-01f, 2.88173221e-02f, -1.05277725e-01f, 1.00439079e-01f, 1.87694907e-01f,
  1.94797423e-02f, -1.45622920e-02f, 2.78308410e-02f, 3.99030522e-02f, 1.34624675e-01f, 1.90017462e-01f, -8.93145204e-02f, 9.18476284e-02f, -1.85052902e-02f, -5.08451238e-02f,
  4.85130548e-02f, 1.75082348e-02f, 3.37078273e-02f, 3.62050906e-02f, -8.08689818e-02f, -2.75721252e-02f, 8.28273362e-04f, -1.11129031e-01f, 2.83175521e-02f, 4.49682623e-02f,
  -1.60104349e-01f, 2.11181473e-02f, -6.68942812e-04f, 8.30175132e-02f, 3.68330777e-02f, 8.31884071e-02f, 3.15682008e-03f, -4.06800434e-02f, 9.96675938e-02f, -2.84201093e-02f,
  1.76601508e-03f, 3.43964957e-02f, -1.50120743e-02f, 2.91574318e-02f, 2.19146889e-02f, 3.44065279e-02f, -8.90171528e-02f, -6.24054521e-02f, -5.43753281e-02f, 1.08794458e-01f,
  -5.45055866e-02f, 1.36014193e-01f, 2.96672489e-02f, 4.33861725e-02f, -3.07409894e-02f, 5.77133149e-03f, -4.82296273e-02f, -2.26299204e-02f, 4.46772203e-02f, -3.53062898e-02f,
  -4.57741413e-03f, 1.08061418e-01f, 5.75977676e-02f, 6.14261860e-03f, 2.93138670e-03f, -1.47260353e-02f, 5.40137663e-03f, 8.07132944e-03f, 7.19193295e-02f, 2.85727661e-02f,
  2.51156278e-03f, -1.16651156e-03f, 2.38106977e-02f, -2.17218287e-02f, 2.09115148e-02f, 3.36590894e-02f, 6.52677640e-02f, 1.60120931e-02f, -3.11528407e-02f, 2.65290551e-02f,
  -9.22804028e-02f, 1.91103533e-01f, -2.38987003e-02f, -2.54949350e-02f, 6.51039109e-02f, -1.94585267e-02f, -1.11909129e-03f, 6.24498799e-02f, 8.17058161e-02f, -4.24630307e-02f,
  7.96931621e-04f, 2.62752175e-03f, 5.73996035e-03f, -4.40307260e-02f, -8.51121992e-02f, -9.80172455e-02f, 4.09054710e-03f, -2.23433897e-02f, -2.21911035e-02f, -8.86398461e-03f,
  -5.74767105e-02f, -2.19574030e-02f, 2.71213856e-02f, 2.15725396e-02f, -2.42184219e-03f, -2.58433931e-02f, -2.96098553e-02f, 1.86539721e-02f, -3.21603417e-02f, -3.32001187e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.83327377e-01f, -1.65021807e-01f, -1.22117497e-01f, -7.91272148e-02f, 6.86291903e-02f, 6.16644546e-02f, 5.74081652e-02f, -7.42174909e-02f, -1.73042595e-01f, 1.62781980e-02f,
  9.82674286e-02f, -6.37197271e-02f, -9.23127607e-02f, 1.81594953e-01f, 1.97263628e-01f, -1.58037663e-01f, 6.05681948e-02f, 6.21029399e-02f, -5.80290742e-02f, 1.34827614e-01f,
  -3.02249733e-02f, 2.67888218e-01f, -4.77377363e-02f, 8.85306671e-02f, -1.35208378e-02f, -9.04518366e-02f, -3.95881012e-02f, -8.07471499e-02f, 5.58125339e-02f, 1.39066622e-01f,
  1.29605472e-01f, 5.31755611e-02f, -5.38235530e-02f, -1.15535147e-02f, 5.34520596e-02f, 8.23612288e-02f, 4.62544076e-02f, 7.60500580e-02f, 4.29678522e-02f, -2.35759355e-02f,
  -2.19534286e-05f, -4.75241132e-02f, 1.23250045e-01f, 5.41073084e-02f, 7.15954080e-02f, 5.67903556e-02f, -7.92427212e-02f, -7.56702498e-02f, -1.22621767e-01f, 3.37414667e-02f,
  -1.06192708e-01f, 9.78294294e-03f, -5.99575303e-02f, -2.20679324e-02f, -5.86855561e-02f, -1.37697011e-02f, -6.74522147e-02f, -3.00478060e-02f, -4.72828792e-03f, 2.99919490e-02f,
  1.73686049e-03f, -4.28673960e-02f, 6.80099130e-02f, 5.21540716e-02f, -3.86260860e-02f, 4.28126752e-02f, 1.20306183e-02f, -4.08155546e-02f, -4.89574783e-02f, -6.06449842e-02f,
  -7.51774162e-02f, 2.05036160e-02f, -9.57592949e-02f, 2.60104309e-03f, 1.51017711e-01f, -8.20922852e-02f, 5.44559807e-02f, 9.63596627e-02f, 6.24423921e-02f, 2.71754544e-02f,
  -1.20889604e-01f, 4.33521792e-02f, 5.69947772e-02f, -4.97230962e-02f, -3.25097255e-02f, -3.80619988e-02f, 8.16477165e-02f, 3.67671773e-02f, -1.24993101e-01f, -3.06696445e-02f,
  1.25970200e-01f, 4.30188477e-02f, -1.39702009e-02f, 5.49014546e-02f, -2.08477899e-02f, 6.62377551e-02f, 1.61647201e-02f, 1.07901737e-01f, -5.37860617e-02f, -3.97947170e-02f,
  -1.84228923e-02f, -4.51245382e-02f, -1.33744488e-02f, -2.51754113e-02f, -3.81686725e-02f, 7.04204664e-02f, -9.02017206e-02f, -4.42599468e-02f, -6.39412850e-02f, -7.95925856e-02f,
  4.64015342e-02f, 3.14682983e-02f, -6.68592900e-02f, -5.33270976e-03f, 4.07597795e-02f, -4.43630777e-02f, 5.46374954e-02f, -9.32835191e-02f, -6.19405769e-02f, -1.30350202e-01f,
  -1.74837694e-01f, 1.48570444e-02f, -1.65999770e-01f, 8.08364525e-02f, -1.24143884e-01f, 2.76116520e-01f, 1.65582940e-01f, -5.86902648e-02f, 1.15089804e-01f, 2.69864589e-01f,
  1.88935086e-01f, -7.81720853e-04f, 1.41613156e-01f, 2.40835786e-01f, -2.71786135e-02f, 1.35097504e-01f, 1.30585462e-01f, 2.39027485e-01f, -1.44332185e-01f, -2.37212982e-02f,
  -1.09252349e-01f, 1.64990038e-01f, 3.06719672e-02f, -3.92201096e-02f, -5.97662069e-02f, -1.13254748e-01f, -1.91303547e-02f, -1.94983184e-01f, 9.04324576e-02f, 8.57437998e-02f,
  7.71171674e-02f, -8.93196166e-02f, -4.53451537e-02f, -2.62686703e-02f, -2.43596788e-02f, -1.00428194e-01f, 1.18877285e-03f, -1.40359685e-01f, -6.08482882e-02f, -2.29156800e-02f,
  -4.78756949e-02f, -9.98123512e-02f, -1.34061743e-03f, -5.74419759e-02f, 7.82472827e-03f, -3.36827226e-02f, -9.63579714e-02f, 8.74325708e-02f, -3.82095948e-02f, -6.93242475e-02f,
  -9.34447628e-03f, -8.65710899e-03f, -3.15025309e-03f, -4.78242990e-03f, -2.79577170e-03f, 9.92006715e-03f, -5.38360365e-02f, -7.52777932e-03f, 2.51469482e-02f, -2.90230475e-02f,
  -2.55939811e-02f, -8.04439001e-03f, -6.03580624e-02f, 2.74849441e-02f, -6.42213054e-05f, 7.15516461e-03f, -2.15146355e-02f, -6.07777797e-02f, -1.69709418e-02f, 6.30189059e-03f,
  3.26206423e-02f, -5.70206940e-02f, 2.56854780e-02f, 1.45434390e-03f, -3.37490588e-02f, -2.47358792e-02f, 2.49844790e-02f, -6.89583048e-02f, 7.59779885e-02f, -1.73441619e-02f,
  -2.79858299e-02f, -5.77586144e-02f, -5.50822616e-02f, 1.25834405e-01f, 3.68604325e-02f, -4.96497229e-02f, 4.68978687e-05f, -1.40416175e-02f, 6.20308593e-02f, -2.05796249e-02f,
  5.78699820e-02f, 8.55516493e-02f, 4.87744547e-02f, -1.36934686e-02f, -3.63151319e-02f, -6.57353550e-02f, -1.71010979e-02f, 6.47354871e-02f, -3.74889895e-02f, -7.00090751e-02f,
  6.72096387e-02f, -5.64771332e-02f, -9.84179378e-02f, 7.90240467e-02f, -1.78006534e-02f, 1.28007242e-02f, -3.81712653e-02f, 5.28350435e-02f, 1.75122097e-02f, -6.41997829e-02f,
  -3.78431939e-02f, -2.07939278e-02f, -8.11077058e-02f, -9.26239230e-03f, 1.50024667e-02f, 3.24623175e-02f, 2.51388773e-02f, -6.38709590e-02f, 7.54064322e-02f, 9.46974456e-02f,
  7.36062676e-02f, 4.78300080e-02f, -5.25015220e-02f, -1.59253329e-01f, -1.81713283e-01f, -2.55232275e-01f, -1.35819048e-01f, -6.54696673e-02f, 1.03556223e-01f, 6.75070006e-03f,
  -8.00640807e-02f, 1.99661478e-02f, 1.15250938e-01f, -7.26166815e-02f, 2.16394234e-02f, 2.35296965e-01f, -1.88444167e-01f, -9.66413394e-02f, 2.54577491e-02f, -1.47296458e-01f,
  -6.41364977e-02f, -7.09564984e-02f, 3.30148265e-02f, -5.05711772e-02f, -1.38482675e-01f, 6.25665439e-03f, -2.55381558e-02f, -9.87626091e-02f, -1.84864074e-01f, 2.51363907e-02f,
  6.98029399e-02f, 1.63867861e-01f, -2.05872562e-02f, 8.32408816e-02f, -6.13422468e-02f, -2.69565899e-02f, -9.46402699e-02f, 1.83056376e-03f, 6.25643581e-02f, -3.83566953e-02f,
  7.50765856e-03f, 3.39808576e-02f, 2.16230936e-02f, 4.29086853e-03f, -6.62742704e-02f, 1.40003907e-02f, -8.23960826e-02f, -1.53109387e-01f, -3.86733972e-02f, -2.09234729e-02f,
  -6.24391846e-02f, -7.88904727e-02f, -3.59735563e-02f, 6.22788966e-02f, 4.62816767e-02f, 1.58527568e-02f, -1.93823129e-02f, 1.73627324e-02f, -2.01223185e-03f, 7.02963443e-03f,
  -1.66623089e-02f, -8.36272836e-02f, 6.25644028e-02f, -2.83239856e-02f, -1.17659122e-02f, -4.91828397e-02f, -7.13644102e-02f, 3.96577157e-02f, -1.45546362e-01f, -7.57231936e-02f,
  9.50803459e-02f, 5.87474145e-02f, 8.71760920e-02f, -8.37572366e-02f, -1.10706158e-01f, -6.37658685e-02f, 3.73498760e-02f, 9.09561962e-02f, -1.50694683e-01f, -5.25155030e-02f,
  1.25109151e-01f, -2.07670941e-03f, 2.84214839e-02f, -7.63481930e-02f, -4.89916764e-02f, 1.55300796e-02f, 2.29732562e-02f, -7.11528026e-03f, 1.11768246e-01f, -4.58465666e-02f,
  -5.46195637e-03f, -2.46538036e-02f, 4.66957055e-02f, 7.11877272e-02f, 1.04959443e-01f, -8.71275440e-02f, -3.71679328e-02f, -2.41913251e-03f, 3.68049089e-03f, -4.83934768e-02f,
  -3.60764167e-03f, 8.97152442e-03f, -9.21216682e-02f, 3.21370661e-02f, -1.40129387e-01f, -6.19261898e-02f, -7.89449178e-03f, -2.31247135e-02f, -3.77322361e-02f, -1.57676376e-02f,
  -7.73897991e-02f, 9.88010019e-02f, 6.70678988e-02f, 1.23628397e-02f, 1.51047893e-02f, 2.44669467e-02f, -4.61633168e-02f, 2.58499640e-03f, -2.86099631e-02f, -5.67435613e-03f,
  -4.08259369e-02f, 1.54941171e-01f, -1.91659585e-01f, 4.70771417e-02f, -1.23548701e-01f, 9.57219452e-02f, 5.79259768e-02f, 3.86883095e-02f, -8.65419209e-02f, 1.38260365e-01f,
  1.07867099e-01f, -1.47879750e-01f, -2.19192598e-02f, 1.97268337e-01f, -1.44552393e-02f, 1.81781501e-01f, 1.64301082e-01f, 1.93948254e-01f, 3.76761556e-02f, 8.99790749e-02f,
  8.47286880e-02f, 2.21338198e-01f, -5.68125173e-02f, -2.71073785e-02f, 1.42039642e-01f, 2.69998107e-02f, 4.94157802e-03f, -7.67263547e-02f, 7.20294937e-02f, 1.04316818e-02f,
  3.29263718e-03f, -1.11071253e-02f, 1.88802835e-02f, 2.94994172e-02f, -2.42991000e-02f, 1.08082043e-02f, -2.77653374e-02f, -3.05277128e-02f, -1.95761546e-02f, 2.28353627e-02f,
  -3.77387032e-02f, 3.99097838e-02f, 6.54813796e-02f, 3.93177904e-02f, 8.72223545e-03f, -1.21760666e-01f, -6.09121770e-02f, -3.73450778e-02f, -6.06137961e-02f, -7.76658058e-02f,
  3.71226780e-02f, -1.29520148e-02f, 1.11539043e-01f, 7.73650259e-02f, -9.32676718e-03f, -6.45816326e-02f, 3.03862914e-02f, -6.53195288e-03f, 7.34854713e-02f, 7.10908696e-03f,
  3.90969077e-03f, -2.83167809e-02f, 7.92599320e-02f, -4.55313735e-02f, -9.67279300e-02f, -6.06340021e-02f, -5.66595756e-02f, -4.55246083e-02f, -3.88754085e-02f, 3.99065800e-02f,
  -1.21518373e-01f, -9.11897980e-03f, -4.92347479e-02f, 9.38032940e-03f, 3.27997212e-03f, 5.89930974e-02f, 2.77088881e-02f, 7.18035027e-02f, -1.07066512e-01f, -8.85873660e-02f,
  -3.14748883e-02f, -6.25171363e-02f, 6.64997548e-02f, -5.68617843e-02f, 3.47827598e-02f, 1.76578818e-03f, -2.91685052e-02f, -7.50163719e-02f, -8.28993022e-02f, 2.67531574e-02f,
  1.40603691e-01f, 1.15958571e-01f, -5.40059768e-02f, 2.27914099e-02f, -1.03200041e-01f, -1.11282337e-02f, -2.68997462e-03f, 8.39457586e-02f, 1.66314363e-03f, 5.76884411e-02f,
  -2.08225530e-02f, 1.17716435e-02f, 9.53135341e-02f, -7.92907476e-02f, -7.51550570e-02f, 1.01825021e-01f, 4.92900051e-02f, -1.22381980e-02f, 1.25821857e-02f, -4.24917974e-02f,
  -1.71649754e-02f, 5.96475750e-02f, 5.14821410e-02f, -1.00952663e-01f, 5.13810618e-03f, 2.62456462e-02f, -3.77046950e-02f, -9.31861401e-02f, -4.44209529e-03f, 2.21838895e-03f,
  1.28437102e-01f, 6.83989003e-02f, 2.35690549e-01f, 2.33151510e-01f, -3.12024150e-02f, 5.70510887e-02f, 6.68471232e-02f, -3.01656630e-02f, 3.01318765e-01f, -1.12891816e-01f,
  -1.55390799e-01f, 1.29612252e-01f, -8.55961740e-02f, 1.36381784e-03f, -1.56689182e-01f, -2.34471224e-02f, 4.24561761e-02f, 9.80823860e-02f, 1.68506667e-01f, 1.48693006e-02f,
  8.59169737e-02f, -1.53531834e-01f, -6.35900572e-02f, -1.95651904e-01f, 5.27386814e-02f, -1.06558233e-01f, -2.91888177e-01f, 2.21401174e-03f, -8.98373947e-02f, -8.63955393e-02f,
  7.60852993e-02f, 1.38504192e-01f, 3.93605120e-02f, 3.41425687e-02f, 4.88240877e-03f, -1.59572735e-02f, -1.07144512e-01f, -1.51684061e-02f, 1.18859097e-01f, 1.72367115e-02f,
  -3.47145237e-02f, -1.98320448e-02f, 9.07817930e-02f, -9.67775583e-02f, 1.12670526e-01f, -2.16365084e-02f, 4.49783653e-02f, 8.00148919e-02f, -2.26402073e-03f, 1.65995434e-02f,
  1.20094992e-01f, 1.63515404e-01f, 3.84835601e-02f, -7.93501437e-02f, 8.78463089e-02f, 4.19535525e-02f, 8.34710300e-02f, 3.77422385e-02f, 3.04481722e-02f, 2.83374153e-02f,
  1.39947291e-02f, -3.16522233e-02f, -3.36604416e-02f, -1.42228827e-02f, -8.64497349e-02f, -3.67043540e-02f, -1.50481658e-02f, 7.01941401e-02f, 9.53305811e-02f, -4.86277752e-02f,
  -7.14530498e-02f, -6.31621256e-02f, 1.24594398e-01f, 3.79183888e-02f, 6.70178086e-02f, -7.35207424e-02f, -8.11097175e-02f, -6.72724703e-03f, 8.68595298e-03f, -1.54610062e-02f,
  1.39183747e-02f, -5.79959247e-03f, -9.07570049e-02f, 6.85865933e-04f, -4.88786660e-02f, 7.08991140e-02f, -7.43614808e-02f, 7.06576183e-02f, 6.32150918e-02f, -4.25392725e-02f,
  2.28148811e-02f, -2.57657655e-02f, -1.85394567e-02f, 4.69749831e-02f, 9.16168094e-02f, 4.04759450e-03f, 5.54217808e-02f, -2.67907437e-02f, -5.26539283e-03f, -7.24863335e-02f,
  -2.98169088e-02f, -1.67982262e-02f, 4.82588597e-02f, -1.43040577e-02f, -1.47467051e-02f, 3.68349105e-02f, 2.55100932e-02f, 1.97219104e-03f, 3.78902592e-02f, 4.22702869e-03f,
  4.89438884e-03f, 1.86359498e-03f, 1.04834009e-02f, -6.91393763e-02f, -6.87790215e-02f, -4.37839143e-03f, 3.66008170e-02f, 2.29297131e-02f, 1.71830431e-02f, 6.15292378e-02f,
  2.23407820e-01f, -2.54958302e-01f, 1.58013701e-01f, 5.06750308e-02f, 2.26313621e-01f, -3.03780697e-02f, 8.82214829e-02f, 6.32658824e-02f, 5.18973507e-02f, -1.36394307e-01f,
  -7.05584288e-02f, 4.07672441e-03f, -6.97203167e-03f, 7.74842277e-02f, 9.63843763e-02f, -4.19072211e-02f, 6.13590553e-02f, -8.62507895e-02f, 8.05352069e-03f, -9.76404548e-03f,
  1.48001835e-01f, 1.94596443e-02f, 1.11764930e-01f, -7.30761588e-02f, -1.55805023e-02f, -5.74837327e-02f, -1.56508788e-01f, 2.07130574e-02f, -1.06450533e-02f, -2.84161549e-02f,
  1.06610641e-01f, -1.91224050e-02f, -5.64555340e-02f, 6.21018596e-02f, -8.24654177e-02f, -9.69478264e-02f, -1.05566964e-01f, 1.36680543e-01f, 1.20650239e-01f, 2.40429137e-02f,
  1.45006292e-02f, -3.17248143e-02f, 6.28570393e-02f, -3.06578670e-02f, 4.37041596e-02f, 1.09345466e-02f, 6.55674469e-03f, -2.70946440e-03f, -6.26280531e-02f, -1.80710051e-02f,
  -4.42508720e-02f, -3.71846780e-02f, 5.67403110e-03f, -4.44401689e-02f, 5.03485240e-02f, -4.09396775e-02f, -6.23023845e-02f, 2.95255929e-02f, -6.75868317e-02f, -1.25246700e-02f,
  -1.14518352e-01f, 5.88758942e-03f, 4.26785313e-02f, -2.50618979e-02f, 5.07996753e-02f, 1.50608361e-01f, 6.10569157e-02f, -2.52348036e-02f, -1.22733489e-02f, 8.35965499e-02f,
  1.80363208e-02f, -7.04609528e-02f, 1.03404056e-02f, 1.40167084e-02f, 7.57489055e-02f, -3.62594835e-02f, -6.85849041e-02f, -2.07768790e-02f, -3.89942490e-02f, 2.42186990e-02f,
  -4.99048047e-02f, -4.23798934e-02f, 1.36245698e-01f, 6.78549637e-04f, -4.59300317e-02f, 9.09725502e-02f, -1.14858747e-01f, 2.38128901e-02f, 3.13060954e-02f, 7.04637840e-02f,
  -7.65242726e-02f, -1.72397256e-01f, -6.71875179e-02f, 1.41276773e-02f, 4.29621711e-02f, -4.97081019e-02f, 1.15737192e-01f, 4.93643200e-03f, -7.22176731e-02f, 6.14350587e-02f,
  1.54497679e-02f, -2.31047277e-03f, -3.95017341e-02f, -9.64561254e-02f, -7.89712220e-02f, 2.83383820e-02f, -5.12727611e-02f, -5.81564568e-02f, 4.57165297e-03f, 4.38381843e-02f,
  2.13028444e-03f, 4.83084917e-02f, 4.49925754e-03f, 6.08557500e-02f, -9.69606116e-02f, -1.21854253e-01f, 6.22951537e-02f, -1.14068590e-01f, -8.79933238e-02f, -7.95191806e-03f,
  -1.57872900e-01f, -4.50234748e-02f, 2.77922720e-01f, -1.57551557e-01f, 9.36905518e-02f, 2.81933159e-01f, 1.69063926e-01f, -6.34053573e-02f, -1.93321869e-01f, -2.43392870e-01f,
  -3.82631011e-02f, 2.27928944e-02f, 2.88155198e-01f, -8.64289254e-02f, 3.59425753e-01f, 2.42051065e-01f, -5.15560955e-02f, -4.54186983e-02f, 1.63406059e-01f, -3.91707458e-02f,
  -5.41342273e-02f, -1.50859997e-01f, 1.19874209e-01f, -1.38717189e-01f, -6.41897693e-02f, -1.10751890e-01f, -4.07596566e-02f, 2.45949864e-01f, -2.21266732e-01f, 5.22739850e-02f,
  4.23104279e-02f, -3.39848772e-02f, 8.13114792e-02f, 5.36930412e-02f, -6.10290542e-02f, -5.91691770e-02f, 2.73361113e-02f, 1.38472438e-01f, 4.86388244e-02f, -1.74992122e-02f,
  -3.34000774e-02f, 2.04637852e-02f, -1.18387647e-01f, -3.35727446e-02f, 1.64828822e-02f, 1.56537711e-03f, -2.28606574e-02f, 7.50494078e-02f, 1.13455258e-01f, 3.27928737e-02f,
  2.14377921e-02f, -1.33168595e-02f, -8.10547639e-03f, 3.24081606e-03f, -5.16362265e-02f, 7.92454705e-02f, 2.96076369e-02f, 1.04305334e-01f, -3.45151424e-02f, -3.73787321e-02f,
  1.24829514e-02f, 1.07433580e-01f, -4.99690175e-02f, -5.86548522e-02f, -2.53946260e-02f, -2.18072701e-02f, -4.57318276e-02f, -7.57278204e-02f, -1.89107116e-02f, -3.55766527e-02f,
  -6.68642223e-02f, -4.83697653e-02f, 1.03323627e-03f, 3.27358618e-02f, -2.50224434e-02f, -1.34930372e-01f, 3.98826823e-02f, -7.82800317e-02f, -8.25114697e-02f, -1.95020270e-02f,
  -8.71271789e-02f, -3.92414071e-02f, -4.29276675e-02f, -7.35101327e-02f, 8.73229373e-03f, 8.14528912e-02f, -1.23297684e-01f, 3.19107100e-02f, 8.01033825e-02f, 7.80350566e-02f,
  2.09963359e-02f, -1.64992377e-01f, 7.42636696e-02f, -4.64678034e-02f, 4.84915860e-02f, -5.20746931e-02f, 9.62830558e-02f, -7.41626397e-02f, -1.85774695e-02f, -5.09603396e-02f,
  -2.39855237e-02f, 4.77048196e-03f, 2.22670101e-02f, -3.89523730e-02f, 7.53124878e-02f, -7.58945942e-02f, -3.30177019e-03f, 1.81619171e-02f, -3.49267758e-02f, -1.37509862e-02f,
  2.83081252e-02f, 2.75983997e-02f, -1.54385185e-02f, -7.29347616e-02f, -6.63901027e-03f, -5.32471798e-02f, -1.62676588e-01f, 8.03768635e-02f, 9.83159095e-02f, 1.03383558e-02f,
  2.56364137e-01f, -2.85239279e-01f, 1.10918105e-01f, 1.55722782e-01f, 1.33298278e-01f, 8.13856199e-02f, 1.58893451e-01f, -1.18314028e-01f, 1.20761126e-01f, -3.83748449e-02f,
  -6.81020841e-02f, 1.19351987e-02f, 4.38825227e-02f, -2.87180711e-02f, 2.35339805e-01f, -9.04557034e-02f, 1.44831203e-02f, 3.91698442e-02f, -1.70788914e-02f, -1.94616895e-02f,
  1.03822574e-01f, 1.07226714e-01f, 6.02816343e-02f, -8.77060145e-02f, -1.12035133e-01f, -1.89031377e-01f, -1.15643956e-01f, 5.03029451e-02f, -1.56497374e-01f, 1.77068971e-02f,
  3.76895145e-02f, -5.41031137e-02f, -4.58594970e-02f, -6.60225227e-02f, -9.78798866e-02f, -3.98191027e-02f, 8.06183070e-02f, 5.80085479e-02f, 4.15927656e-02f, 2.07212679e-02f,
  -4.84550409e-02f, 1.31718859e-01f, 2.83734221e-02f, -5.06384782e-02f, 1.14487559e-02f, 1.52331649e-03f, 4.21697721e-02f, -2.24503633e-02f, 7.47114345e-02f, 7.31766522e-02f,
  1.71874184e-02f, -5.94876856e-02f, -1.85739994e-02f, -1.15086474e-01f, -5.47688901e-02f, -2.70919260e-02f, -4.17217128e-02f, -3.82003784e-02f, -1.62026007e-03f, 7.13297725e-02f,
  -1.29616350e-01f, -2.97711045e-03f, -6.88325539e-02f, -1.70186646e-02f, -1.40388813e-02f, 4.56005819e-02f, -4.11860086e-02f, 8.95121768e-02f, 3.56946327e-02f, 2.40466800e-02f,
  1.15327366e-01f, 3.13775055e-02f, -1.94001030e-02f, -2.15722900e-02f, 4.10308801e-02f, -2.47258856e-03f, 1.35100801e-02f, 9.43691656e-03f, -4.43053879e-02f, 4.41879407e-02f,
  2.19487865e-02f, 5.71294017e-02f, -8.51943120e-02f, -1.79542601e-02f, -5.79245836e-02f, 4.05229069e-02f, -3.09194461e-03f, 1.63238775e-02f, 6.21834164e-03f, -3.94207984e-02f,
  -1.66732088e-01f, -1.11799344e-01f, 3.27471495e-02f, 4.35617305e-02f, -8.33427683e-02f, -1.31634682e-01f, 2.35123653e-02f, 4.25109193e-02f, -2.98530255e-02f, 8.74821395e-02f,
  -6.13249652e-02f, 8.42588618e-02f, -8.87065977e-02f, 3.52177024e-02f, -4.29591015e-02f, -4.82110195e-02f, 5.36694266e-02f, 2.55757943e-03f, -6.45776168e-02f, -3.93945612e-02f,
  5.93756735e-02f, -4.12072465e-02f, 8.51791725e-02f, 5.26588559e-02f, -3.90024967e-02f, -1.46239139e-02f, 2.38471404e-02f, -7.93655291e-02f, -2.59908997e-02f, 6.51456043e-02f,
  1.95027348e-02f, -2.56076783e-01f, 6.58129677e-02f, 9.95841622e-02f, 4.85603027e-02f, -7.93727264e-02f, -2.71356702e-02f, -1.93295613e-01f, -2.85814196e-01f, -1.36560634e-01f,
  6.29484132e-02f, 4.38123234e-02f, -7.90130943e-02f, 5.48820570e-02f, 1.69340014e-01f, -1.56303644e-01f, 6.10073060e-02f, 6.61097839e-02f, -1.53844118e-01f, 4.15369086e-02f,
  5.05253933e-02f, -5.96751459e-02f, 9.44458321e-02f, 1.30758613e-01f, 4.59286459e-02f, 1.34787679e-01f, 2.86458999e-01f, 1.26136392e-01f, 1.53867096e-01f, 1.82261139e-01f,
  6.26050606e-02f, -1.05337530e-01f, -6.24918519e-03f, -7.01227039e-02f, -7.71909580e-02f, 6.53953850e-02f, 5.79679161e-02f, 3.15508172e-02f, 7.56372511e-02f, -6.50696158e-02f,
  -4.36185859e-02f, 6.98112845e-02f, -1.78685002e-02f, 3.44823934e-02f, -2.82958765e-02f, -2.28199493e-02f, 3.04900911e-02f, 5.90019971e-02f, -2.66655777e-02f, -7.30312467e-02f,
  1.58486292e-02f, 4.34893593e-02f, -3.20665054e-02f, 7.15554506e-02f, 3.97479571e-02f, -2.35945433e-02f, 2.16799043e-02f, 1.77809764e-02f, -9.57416967e-02f, -8.85477960e-02f,
  2.54859850e-02f, -5.99245913e-03f, -1.11476280e-01f, -1.94213167e-02f, 4.20662062e-03f, -2.13781912e-02f, -1.06459349e-01f, -1.53484074e-02f, -2.52811871e-02f, -1.01329163e-01f,
  -3.47195938e-02f, -8.52876063e-03f, -1.05898462e-01f, 7.80882221e-03f, 1.67655363e-03f, -8.87894034e-02f, 2.37044729e-02f, 6.27242550e-02f, -2.59778872e-02f, -5.29910401e-02f,
  4.93568033e-02f, 8.28841776e-02f, -4.41426039e-02f, 4.37633768e-02f, -2.09236741e-02f, -2.00000480e-02f, -1.83196627e-02f, 2.18040198e-02f, -3.52205001e-02f, 1.21167470e-02f,
  9.67276320e-02f, -9.58609506e-02f, 5.01022749e-02f, 4.01187949e-02f, 6.72201887e-02f, -4.66249883e-02f, 7.12031126e-02f, 2.90826093e-02f, 1.08187702e-02f, -4.55972590e-02f,
  -5.16197797e-05f, 1.02089569e-01f, -9.93962288e-02f, 5.04052192e-02f, 1.69103500e-02f, -5.97506501e-02f, -8.47726092e-02f, 5.32331765e-02f, 4.16693762e-02f, 5.09791123e-03f,
  -2.33801398e-02f, -1.31112963e-01f, 4.60766703e-02f, -2.20166277e-02f, -2.99341399e-02f, 3.13838758e-02f, 4.36007418e-02f, -7.21227154e-02f, 3.09629296e-03f, -8.67653936e-02f,
  4.80719954e-02f, -2.63255030e-01f, -2.23415926e-01f, -6.70893341e-02f, 9.38865766e-02f, 5.19819558e-02f, -1.02982491e-01f, -5.40786423e-02f, -1.51946127e-01f, 4.68656644e-02f,
  1.33882882e-02f, -1.80203691e-01f, -1.67599678e-01f, -1.60794958e-01f, -8.91381875e-02f, -2.59351850e-01f, 5.74724935e-02f, 5.28553361e-03f, -1.31064197e-02f, -7.90061951e-02f,
  -2.80130673e-02f, 4.59054895e-02f, -1.18773326e-01f, 1.66646048e-01f, 1.56370595e-01f, 3.51560116e-02f, 2.27462888e-01f, -6.97379336e-02f, 2.61336684e-01f, 8.82167965e-02f,
  1.45439897e-02f, -1.39271215e-01f, -7.99141675e-02f, -3.09006795e-02f, 5.56879453e-02f, 7.86436796e-02f, 5.33372462e-02f, 7.51539245e-02f, -2.49010008e-02f, -1.18946530e-01f,
  8.23045895e-02f, -4.61054966e-02f, 3.97145078e-02f, -3.95658761e-02f, 2.77898926e-02f, 8.57929066e-02f, -5.42690605e-02f, -3.65941902e-03f, -1.27495274e-01f, -1.09810427e-01f,
  -1.01138070e-01f, 1.16894273e-02f, 7.86553398e-02f, 7.14815557e-02f, -2.44116988e-02f, -3.53541039e-02f, 3.73300128e-02f, -2.24764738e-02f, 7.35157803e-02f, 8.63914415e-02f,
  4.57086042e-02f, 4.07889858e-03f, 1.13189090e-02f, 4.34160382e-02f, -1.61959633e-01f, -3.63535318e-03f, 3.09857782e-02f, 3.63662243e-02f, -4.17020060e-02f, -7.35649988e-02f,
  4.92411591e-02f, -6.14226377e-03f, 9.12966058e-02f, 1.65111618e-03f, 1.67507194e-02f, -2.36865156e-03f, 5.35173016e-03f, -6.95429295e-02f, 3.12753171e-02f, -4.04813066e-02f,
  5.69014512e-02f, 1.60365682e-02f, -8.77217203e-03f, 1.02992490e-01f, -1.22573068e-02f, 6.44599413e-03f, 3.10281385e-02f, -5.55932410e-02f, -1.14739072e-02f, 8.51252079e-02f,
  3.63422148e-02f, -3.00148372e-02f, -4.92503457e-02f, 6.73852256e-03f, 3.65493782e-02f, 6.59258068e-02f, 7.12730410e-03f, 3.84445228e-02f, 5.61619289e-02f, -2.51038689e-02f,
  7.74757713e-02f, 4.32179607e-02f, 1.28461346e-01f, 5.47605045e-02f, 1.81348377e-03f, -3.45254168e-02f, 6.51041418e-02f, 5.01374975e-02f, 4.48783897e-02f, -6.23026192e-02f,
  1.36484936e-01f, -2.85351314e-02f, -4.56089936e-02f, 3.45667824e-02f, 1.47133544e-01f, 3.36765349e-02f, 1.46976961e-02f, 9.57642272e-02f, 1.71087347e-02f, 3.13597545e-02f,
  -1.20381936e-01f, 6.68026879e-02f, 1.59411959e-03f, -8.84837285e-02f, 1.00462884e-01f, -1.24647275e-01f, -7.30007291e-02f, 2.73191724e-02f, -2.46369820e-02f, 1.54925004e-01f,
  8.76624957e-02f, -1.09324567e-01f, 8.32157135e-02f, -2.93322861e-01f, -4.28290755e-01f, -1.47150621e-01f, -3.49202573e-01f, -2.47513637e-01f, -1.09694026e-01f, 3.08414102e-02f,
  -2.02939600e-01f, -7.33935414e-03f, -3.08938891e-01f, 4.20841016e-02f, -1.85345784e-02f, 4.10447307e-02f, 1.10554293e-01f, 1.91151842e-01f, -1.00186288e-01f, -1.27664360e-03f,
  -5.74948415e-02f, 3.47625315e-02f, 1.08031072e-01f, -4.60075960e-02f, 2.13078186e-02f, 4.90337843e-03f, 1.70365423e-02f, -4.89441194e-02f, 3.16022336e-02f, -4.90467576e-03f,
  2.06192490e-02f, -6.13572598e-02f, 1.42316623e-02f, -2.62580942e-02f, 2.86741685e-02f, -3.06032542e-02f, 1.03224972e-02f, -3.83764170e-02f, -9.70649421e-02f, -2.54377462e-02f,
  -1.55843012e-02f, 3.16740163e-02f, 5.54701127e-02f, 3.09161227e-02f, -9.45073143e-02f, 9.61381942e-02f, -1.12422511e-01f, -5.93321733e-02f, -1.10794306e-02f, -6.17846437e-02f,
  -5.69251329e-02f, -4.44841124e-02f, -1.27092406e-01f, 4.11474481e-02f, -4.11282741e-02f, 1.15345426e-01f, 1.33460769e-02f, 1.97501499e-02f, -4.26413119e-02f, 1.04730703e-01f,
  5.08152433e-02f, -1.04553038e-02f, -2.04294510e-02f, -1.77224893e-02f, -9.75757465e-02f, -4.86095324e-02f, 1.00238711e-01f, -3.46244499e-02f, -1.28633454e-02f, -6.50049374e-03f,
  5.42145595e-02f, -1.32133663e-02f, 4.61363532e-02f, 5.83765656e-02f, -6.27411623e-03f, -7.85175990e-03f, 3.07274237e-02f, -3.68996114e-02f, 7.50529766e-02f, -5.68230636e-02f,
  2.66679693e-02f, 1.80837736e-01f, 1.23977572e-01f, 2.51028361e-03f, -4.19707783e-02f, -2.47421283e-02f, -4.16990779e-02f, 1.87763125e-02f, 2.61011831e-02f, -6.43652901e-02f,
  1.36550844e-01f, -3.02255396e-02f, -3.66259255e-02f, 7.04890862e-02f, 1.90593787e-02f, 3.82286273e-02f, -4.24684510e-02f, 1.31744504e-01f, -3.35579067e-02f, -2.21864861e-02f,
  5.58600612e-02f, 3.50786522e-02f, -5.81087591e-03f, -9.26088616e-02f, -1.03736036e-02f, 7.69713670e-02f, 9.18751135e-02f, 4.41347696e-02f, -4.06589778e-03f, 3.35996822e-02f,
  -6.93658963e-02f, 1.70573398e-01f, 9.59727094e-02f, -1.55125394e-01f, -1.04090229e-01f, -1.05747841e-01f, -6.44993037e-02f, -6.87594935e-02f, 7.54566565e-02f, 2.55738348e-02f,
  -1.82780892e-01f, 1.21406168e-01f, 8.25231746e-02f, -8.26570690e-02f, -2.29103118e-01f, -4.94089834e-02f, -1.24977969e-01f, -1.84039772e-02f, 1.62071809e-02f, 2.15929784e-02f,
  -2.11309306e-02f, -1.44578457e-01f, -1.16812840e-01f, 9.11285579e-02f, 5.73876649e-02f, 6.07472286e-02f, -2.16166660e-01f, -5.05244620e-02f, 2.18062606e-02f, 3.59979086e-02f,
  -1.61051020e-01f, -2.10909829e-01f, -6.83001354e-02f, 1.61282346e-02f, -1.62484311e-03f, -5.16052507e-02f, -6.90556914e-02f, -8.77519697e-02f, -3.14251333e-02f, 4.98571917e-02f,
  5.63329868e-02f, 9.74624082e-02f, -3.48518454e-02f, -1.43419849e-02f, -8.21292773e-02f, 1.59422923e-02f, -1.24777704e-02f, 7.21518919e-02f, -2.05961727e-02f, 6.96777478e-02f,
  1.00149766e-01f, 4.49588848e-03f, 3.23217884e-02f, -5.07027619e-02f, -3.01025342e-02f, -9.59554762e-02f, 5.80536574e-02f, 5.58143519e-02f, 1.22541282e-02f, 2.77003646e-02f,
  -3.52738500e-02f, -1.12677544e-01f, 3.21175158e-02f, 7.20802248e-02f, 3.48955952e-02f, 5.30967787e-02f, 6.51337057e-02f, -3.89884189e-02f, 4.03351784e-02f, -5.68711646e-02f,
  -6.24140650e-02f, -1.77995209e-02f, 1.85893439e-02f, -5.33178821e-02f, 1.38076125e-02f, 5.82930865e-03f, -1.78668927e-02f, 4.71487492e-02f, 4.97156233e-02f, -1.61962491e-02f,
  2.82430872e-02f, -5.38611598e-02f, 2.03038706e-03f, -3.59329693e-02f, -6.08849339e-02f, 6.00233348e-03f, -5.80619788e-04f, 8.58355910e-02f, -6.58112690e-02f, -1.04239069e-01f,
  -1.70787975e-01f, -2.28413358e-01f, -1.87058300e-01f, -9.84092802e-03f, -4.14170735e-02f, -2.80324090e-02f, -1.04624003e-01f, 9.71190110e-02f, -9.62516293e-02f, 5.56819402e-02f,
  6.70460165e-02f, -8.86932984e-02f, -4.45016939e-03f, 2.90121008e-02f, 6.29415885e-02f, -1.14084534e-01f, -9.97544751e-02f, -3.31907510e-03f, -1.44268975e-01f, 5.93023486e-02f,
  -2.63174381e-02f, 3.46950931e-03f, -5.33505641e-02f, 5.38783148e-02f, -4.57416773e-02f, 1.44863119e-02f, -5.65965893e-03f, -5.68836443e-02f, -1.69620197e-02f, -5.18027768e-02f,
  5.68895461e-03f, 4.68598716e-02f, 3.57428938e-02f, 8.17568898e-02f, -1.13856718e-01f, -2.40919873e-01f, -1.73966721e-01f, 9.45683867e-02f, -1.24303520e-01f, -7.65298903e-02f,
  -2.81271692e-02f, 6.32860139e-02f, 1.57767031e-02f, 1.87413201e-01f, 8.41550156e-02f, -2.68530822e-03f, 1.55572161e-01f, -1.34854928e-01f, 8.79852772e-02f, 2.18234912e-01f,
  5.56583665e-02f, 1.97941169e-01f, 6.57203645e-02f, 6.29462078e-02f, 6.69183210e-03f, 1.27044827e-01f, 2.00542867e-01f, 9.71330702e-02f, 8.56784210e-02f, 9.10460576e-03f,
  -9.74147916e-02f, 1.01432964e-01f, -7.37498924e-02f, 4.76329289e-02f, 1.02851257e-01f, 5.51092476e-02f, -4.78283241e-02f, 6.61519915e-03f, 6.95894472e-03f, 1.09688468e-01f,
  -3.32255550e-02f, 3.48315500e-02f, 3.01275440e-02f, 8.34978186e-03f, -6.19122162e-02f, 1.37375407e-02f, -8.77016559e-02f, -4.55207042e-02f, 3.79625745e-02f, -1.52663165e-03f,
  -3.31591628e-02f, -5.30216992e-02f, -4.85980771e-02f, 2.13508215e-02f, 6.39539063e-02f, 4.17692102e-02f, 4.17485051e-02f, 1.70435198e-02f, -6.15731766e-03f, -7.75213242e-02f,
  2.45774314e-02f, -8.65513533e-02f, -4.60980553e-03f, -3.95027250e-02f, 5.65704405e-02f, 8.64254963e-03f, -6.76652119e-02f, -8.09460785e-03f, -1.73337758e-02f, -1.39860641e-02f,
  -2.79867873e-02f, 3.80514339e-02f, -5.09403006e-04f, 7.24931154e-03f, 2.23955102e-02f, -1.08744703e-01f, -7.83647299e-02f, -8.92389333e-04f, 5.50847389e-02f, 4.00748402e-02f,
  -2.32479535e-02f, 5.07307472e-03f, -7.73471147e-02f, 2.19479781e-02f, -1.34275053e-02f, 5.15354834e-02f, -2.07145121e-02f, 7.34675080e-02f, -5.02038300e-02f, -1.98429916e-02f,
  1.08837448e-01f, 2.29775339e-01f, -1.71530601e-02f, -2.83862147e-02f, 2.07689572e-02f, -3.99517268e-02f, -4.47644740e-02f, 7.33930990e-02f, -2.37966944e-02f, -8.59275684e-02f,
  1.00706547e-01f, -7.13504776e-02f, 1.19602410e-02f, 1.09684601e-01f, 3.53133306e-02f, 3.67956758e-02f, 6.22571781e-02f, 1.54350344e-02f, 1.08000994e-01f, 1.24207750e-01f,
  -1.96378818e-03f, 9.15208831e-02f, -2.01543849e-02f, -6.25315085e-02f, -2.78362203e-02f, 1.14836963e-02f, 5.59023283e-02f, 3.36521640e-02f, -1.71261225e-02f, 1.00216806e-01f,
  1.03353299e-01f, 1.05479397e-01f, 5.12231812e-02f, 6.75761700e-02f, -1.24762394e-01f, -1.37450993e-01f, 5.21881431e-02f, -1.00103784e-02f, 1.64565071e-01f, 8.11192095e-02f,
  -9.57985818e-02f, 1.29174814e-01f, -5.91305234e-02f, 3.59695554e-02f, -1.15479991e-01f, -6.73609301e-02f, -9.97746810e-02f, 7.19634145e-02f, 3.34159583e-02f, -7.81503916e-02f,
  -1.25845149e-01f, -2.66691685e-01f, -1.23640828e-01f, -1.68890968e-01f, 3.70359793e-02f, 1.49960458e-01f, -1.70147061e-01f, -5.53632826e-02f, 3.76408510e-02f, 2.98545882e-03f,
  4.62764464e-02f, 8.17571860e-03f, 1.19387589e-01f, -9.39420797e-03f, -9.03698653e-02f, -2.50458624e-02f, 1.59915965e-02f, 9.19987336e-02f, 1.10382766e-01f, 3.50431465e-02f,
  -2.50914842e-02f, -2.88432464e-02f, 3.97266112e-02f, -1.08056413e-02f, -1.92733705e-02f, 6.08679913e-02f, 6.18489198e-02f, 1.22822030e-02f, 1.31727964e-01f, 2.30867397e-02f,
  6.08436465e-02f, -1.63903795e-02f, 1.23071196e-02f, 1.14240393e-01f, -1.00587383e-01f, -2.55606715e-02f, -1.08196251e-02f, -1.67343412e-02f, 1.22323595e-01f, -1.94350854e-02f,
  -1.01064123e-01f, -6.17734157e-02f, -4.24178550e-03f, 3.11031882e-02f, 5.51437177e-02f, -4.68399003e-02f, 2.07136441e-02f, -7.16210976e-02f, 6.76122159e-02f, 6.66991621e-02f,
  1.00295618e-02f, -5.12207113e-02f, -1.91007666e-02f, 7.60937184e-02f, -1.47469491e-01f, 1.15252789e-02f, -7.42014721e-02f, 5.25287613e-02f, -5.18994890e-02f, -4.04865891e-02f,
  -1.12454168e-01f, -1.16541713e-01f, 8.61587003e-02f, -4.93749417e-02f, 6.10123388e-02f, -7.91763514e-02f, -7.46902898e-02f, 1.35110930e-01f, -1.04029318e-02f, -6.72800392e-02f,
  6.04611933e-02f, 2.29358487e-02f, -3.28138322e-02f, -5.64998314e-02f, 3.96658443e-02f, -4.86774594e-02f, -5.69514595e-02f, 1.02800533e-01f, 4.85800579e-02f, 9.51146521e-03f,
  -6.54168949e-02f, -4.79281731e-02f, -7.60943294e-02f, 6.18534014e-02f, -5.02681583e-02f, -4.53648157e-02f, -3.99709726e-03f, -1.01283781e-01f, -7.89191276e-02f, -1.12426035e-01f,
  -2.33565420e-02f, -9.04477760e-03f, 7.00400770e-02f, 5.88107146e-02f, -2.30776845e-03f, 5.13914116e-02f, 9.12817121e-02f, 1.54975235e-01f, -1.70360878e-02f, -3.40285711e-02f,
  -5.78565657e-01f, 2.19611853e-01f, 9.89737958e-02f, 1.89623505e-01f, -1.72705948e-01f, 7.34290704e-02f, 9.75068957e-02f, 2.69125402e-03f, 9.90978852e-02f, 3.05872619e-01f,
  1.30888358e-01f, -1.95533447e-02f, 5.68132140e-02f, 1.85476035e-01f, -2.73994714e-01f, 1.67878494e-01f, -1.10927045e-01f, -3.74630056e-02f, -2.70565022e-02f, -4.70749848e-02f,
  -1.43971264e-01f, 4.88639669e-03f, -2.26530014e-03f, -2.51418874e-02f, -3.30363885e-02f, -7.75347278e-02f, -1.03697792e-01f, 3.26123945e-02f, -9.50195491e-02f, 1.82975195e-02f,
  -3.03654909e-01f, -6.50338531e-02f, -1.27009526e-01f, -4.61259857e-02f, -1.22539200e-01f, -1.06266819e-01f, -4.96431924e-02f, 1.22230850e-01f, 1.19346231e-02f, 7.79933110e-02f,
  -3.64379324e-02f, 6.31759986e-02f, 1.04833789e-01f, 5.14091477e-02f, -7.84296542e-03f, 2.90108435e-02f, 2.36925166e-02f, -7.56553188e-02f, 1.49860019e-02f, -8.40255097e-02f,
  9.23518240e-02f, 8.30657780e-03f, -8.02332256e-03f, 8.29190537e-02f, -8.24719369e-02f, 8.19315910e-02f, 1.57636739e-02f, -1.17002189e-01f, -3.93042341e-02f, 7.30046928e-02f,
  9.55669302e-03f, 1.37024652e-02f, -7.39684387e-04f, 1.17829507e-02f, -3.03148422e-02f, 4.38092314e-02f, 1.38403960e-02f, -4.77301702e-02f, 5.43810911e-02f, -5.36668859e-02f,
  -5.60697056e-02f, 2.07080636e-02f, -3.67944799e-02f, -7.22566992e-02f, -4.56691347e-02f, 4.75598760e-02f, 1.53248943e-03f, 2.89930273e-02f, 9.06716287e-02f, 7.96461031e-02f,
  7.79384971e-02f, 4.43337969e-02f, 5.50677329e-02f, -1.95324458e-02f, -6.57874793e-02f, -5.15701324e-02f, -1.02885105e-01f, -5.68003692e-02f, -4.94523719e-02f, -4.64264750e-02f,
  -3.19298923e-01f, -1.07792348e-01f, 4.17232811e-02f, -1.57661997e-02f, -8.12569335e-02f, -7.82475173e-02f, -6.99019060e-02f, -7.90272877e-02f, -3.37250084e-02f, -7.87348077e-02f,
  -8.68346170e-02f, -8.08087662e-02f, -1.01821795e-01f, 4.85570990e-02f, -3.20749953e-02f, -3.27591859e-02f, -4.81774621e-02f, 1.70062240e-02f, -2.88916449e-03f, -1.08381361e-02f,
  2.48328522e-02f, -3.13552245e-02f, -1.77900121e-02f, -8.22011530e-02f, -2.37078145e-02f, -4.32584584e-02f, -2.32540835e-02f, 1.66516379e-02f, -1.05539352e-01f, -9.64314956e-03f,
  1.02057360e-01f, 5.97218238e-03f, -2.43982598e-01f, -5.41918725e-02f, -1.77211627e-01f, -7.63011053e-02f, -1.08841360e-02f, -9.98740047e-02f, -9.57323760e-02f, 2.10228205e-01f,
  1.75985649e-01f, 7.16626048e-02f, 1.08433194e-01f, 1.47783428e-01f, 1.12389997e-01f, 1.50155351e-01f, 1.85321987e-01f, 3.54187340e-02f, 5.11347279e-02f, 8.11528638e-02f,
  2.25655716e-02f, 1.24492146e-01f, 6.33463785e-02f, 5.84998243e-02f, 1.10679850e-01f, -9.47537124e-02f, 9.07743573e-02f, -1.17077902e-01f, 1.38942868e-01f, 1.17397033e-01f,
  9.25725102e-02f, -2.35997327e-02f, 5.40266559e-03f, -9.83453635e-03f, -1.48954904e-02f, -6.56463057e-02f, 2.99469493e-02f, -9.88527313e-02f, -4.28553708e-02f, -1.65875107e-02f,
  -3.79015505e-02f, -4.82866429e-02f, 2.17502825e-02f, 3.28184851e-02f, -8.59213248e-02f, -1.54176787e-01f, 1.65729970e-02f, -1.02689661e-01f, 2.28423215e-02f, 7.75129646e-02f,
  -9.09686089e-02f, -1.15096308e-02f, 4.63335030e-02f, 8.58302880e-03f, -4.52580415e-02f, 3.77865043e-03f, -7.31130093e-02f, -4.21955734e-02f, -1.17926793e-02f, 8.96724612e-02f,
  4.60541993e-02f, -1.96422245e-02f, 5.89525960e-02f, -2.68319435e-02f, -6.25737756e-02f, -3.57200275e-03f, 5.14954962e-02f, -5.52027021e-03f, 3.04675084e-02f, 5.52480109e-02f,
  -5.68433180e-02f, -4.27859463e-02f, 3.47259119e-02f, 3.50698307e-02f, 1.49485782e-01f, -5.23900390e-02f, -5.00668399e-02f, -8.53169803e-03f, -7.67653659e-02f, 3.77017856e-02f,
  -3.88659164e-02f, 6.90370379e-03f, 5.23484387e-02f, -1.25722373e-02f, 4.27366160e-02f, 5.12530208e-02f, 7.55495131e-02f, 9.62669700e-02f, 6.95483238e-02f, -1.22733235e-01f,
  5.91908731e-02f, -7.46739954e-02f, -3.45435254e-02f, -5.25338463e-02f, 3.53539130e-03f, -3.44833843e-02f, 8.43145028e-02f, 3.67660052e-03f, 2.74693761e-02f, -5.39242625e-02f,
  -1.83644500e-02f, 2.20356453e-02f, 2.50023641e-02f, -2.15980336e-02f, -6.90274232e-04f, -1.80226378e-02f, 1.02890156e-01f, 4.20083031e-02f, 4.79880534e-02f, 8.91984906e-03f,
  -1.22579457e-02f, -1.02833994e-01f, 8.83259624e-02f, -9.89419892e-02f, 6.35858402e-02f, 2.35787909e-02f, -3.50146107e-02f, -1.18622035e-02f, -9.32240933e-02f, 3.86884175e-02f,
  5.02415113e-02f, -2.54256666e-01f, -3.06679189e-01f, -2.51381069e-01f, 4.27372903e-02f, -3.24399889e-01f, -3.51810396e-01f, -1.40176043e-01f, -1.86415017e-02f, 6.39375811e-03f,
  -7.38098845e-02f, -6.10356033e-02f, 4.71154153e-02f, -1.70502573e-01f, -4.49925438e-02f, 1.28144935e-01f, -3.73716980e-01f, -1.31353632e-01f, 1.28116637e-01f, -1.50136739e-01f,
  -4.94280569e-02f, -1.62746891e-01f, -2.23095953e-01f, 8.76796469e-02f, -2.11713508e-01f, 3.36778024e-03f, 1.14581898e-01f, 1.94521472e-02f, -1.03778407e-01f, -1.45000905e-01f,
  -1.56773627e-02f, 1.46856692e-04f, -8.29386339e-02f, 2.49761678e-02f, -1.58398345e-01f, -1.56459175e-02f, -4.24674787e-02f, 3.35207470e-02f, 8.65299553e-02f, -5.17251827e-02f,
  3.37111801e-02f, 1.64914709e-02f, -5.40826172e-02f, 3.82091291e-02f, -4.96229790e-02f, -2.43785232e-02f, -8.27330500e-02f, 3.03623024e-02f, -2.51868386e-02f, 3.63274626e-02f,
  -1.39983565e-01f, -5.65742366e-02f, -7.65195116e-02f, -3.44751962e-02f, 2.57972032e-02f, -1.57802820e-01f, -4.62055244e-02f, -3.74134630e-02f, 5.59845828e-02f, 3.97388590e-04f,
  -6.19672379e-03f, 4.14165631e-02f, 1.00915721e-02f, -4.06319611e-02f, 3.48730981e-02f, -4.55167964e-02f, -3.63156833e-02f, 2.79323347e-02f, -7.75369396e-03f, 3.03774122e-02f,
  -7.77933151e-02f, -3.83821316e-02f, 3.21889594e-02f, 1.50606188e-03f, 4.29887623e-02f, 9.57681313e-02f, -6.61086217e-02f, -1.58838928e-02f, 1.61031093e-02f, 1.09189255e-02f,
  8.96756724e-03f, -7.84560367e-02f, -2.12069508e-03f, -4.30097468e-02f, -3.95093337e-02f, 4.50072996e-03f, 2.55261012e-03f, 4.57984768e-02f, -7.50728175e-02f, -1.28160249e-02f,
  -1.24588393e-01f, 4.20111679e-02f, 1.11474339e-02f, -1.82795841e-02f, -1.72462780e-03f, -5.36787584e-02f, 1.70485657e-02f, 2.72631552e-03f, -3.33754681e-02f, -2.70494297e-02f,
  -7.64718354e-02f, -2.40012649e-02f, 6.92101642e-02f, 5.53025492e-03f, -8.39120895e-03f, -1.00396752e-01f, 7.13737980e-02f, 5.58472937e-03f, -5.27415201e-02f, 1.91580374e-02f,
  2.12106518e-02f, 3.06254555e-03f, 2.54482422e-02f, 6.85729161e-02f, 4.36661672e-03f, 1.61164869e-02f, -5.41039743e-02f, 3.55855078e-02f, 5.67516647e-02f, -2.98318770e-02f,
  1.49220437e-01f, 2.41340488e-01f, 1.00918479e-01f, 1.86000943e-01f, -1.08151369e-01f, -1.44305900e-01f, -8.29217732e-02f, -7.43835121e-02f, 6.26915842e-02f, 1.18327051e-01f,
  -1.46845385e-01f, 2.82754689e-01f, -3.90045010e-02f, 8.61300007e-02f, -3.23083848e-01f, -2.04068616e-01f, -5.41834980e-02f, 1.06220834e-01f, 7.63562247e-02f, 1.36537030e-01f,
  -1.27534896e-01f, -2.08374217e-01f, -8.74441490e-02f, 2.82884352e-02f, 1.00360103e-01f, 2.20232502e-01f, -1.64336517e-01f, -1.63454693e-02f, 1.63916022e-01f, -8.48676711e-02f,
  -8.60598087e-02f, 1.20367393e-01f, 1.15536511e-01f, -4.77939695e-02f, 8.20081215e-03f, 5.48639009e-03f, -6.39049511e-04f, -8.78570676e-02f, -5.55893444e-02f, 3.24986018e-02f,
  6.87767491e-02f, -1.10360436e-01f, -1.22463768e-02f, -8.78276452e-02f, 4.64392826e-02f, -5.37529364e-02f, -3.29698361e-02f, 7.64352456e-02f, 4.84987125e-02f, 5.99332638e-02f,
  3.43153886e-02f, 3.62115055e-02f, 4.28806357e-02f, 9.32860225e-02f, 1.00397363e-01f, -2.23824978e-02f, -3.12987044e-02f, -5.29386662e-02f, 8.76630936e-03f, 3.15682702e-02f,
  5.06747738e-02f, -8.58867764e-02f, -2.38197134e-03f, -2.95650307e-02f, -2.91365795e-02f, -7.11241923e-03f, -5.24838306e-02f, -7.53064975e-02f, 2.00479385e-03f, 6.35806704e-03f,
  -3.40176597e-02f, 5.10755926e-03f, -1.23611577e-01f, 9.00914446e-02f, 5.81264831e-02f, 7.05288276e-02f, 9.38448869e-03f, -9.85377133e-02f, 6.42019138e-02f, 3.16088437e-03f,
  -9.47044343e-02f, 2.75198109e-02f, 6.53895512e-02f, 3.32682393e-02f, -6.05470575e-02f, 1.66134126e-02f, -2.10234392e-02f, 6.13755882e-02f, 2.15929039e-02f, -4.45306022e-03f,
  9.28791240e-02f, 1.19872414e-01f, 1.09999478e-01f, -5.28793558e-02f, -6.93593845e-02f, -8.25204775e-02f, 2.05241349e-02f, 7.90959448e-02f, -1.26339570e-02f, -1.92029402e-02f,
  4.77121621e-02f, 4.78279702e-02f, 6.29849583e-02f, -6.75454587e-02f, -8.54784325e-02f, 3.95935494e-03f, 6.02001697e-02f, 6.00090697e-02f, -5.75192198e-02f, 6.26951605e-02f,
  1.31923705e-01f, -5.82628511e-02f, -5.30482922e-03f, 2.89715677e-02f, -2.28932630e-02f, -4.01173644e-02f, 1.59160234e-02f, 7.22340569e-02f, -5.09005822e-02f, 2.75741122e-03f,
  3.86770815e-01f, -1.81143433e-01f, 1.00210957e-01f, 1.83699623e-01f, 3.83628421e-02f, -1.18827866e-02f, 1.35750905e-01f, -1.15009226e-01f, 1.53745919e-01f, -2.21800223e-01f,
  7.77891353e-02f, -8.17632154e-02f, -1.27578825e-01f, -5.76781631e-02f, 1.45302841e-03f, -1.45439625e-01f, 1.53424628e-02f, 2.20142826e-02f, 6.72309622e-02f, 6.54977784e-02f,
  1.21193103e-01f, -3.45800631e-02f, 6.85757473e-02f, -1.94894835e-01f, 9.19549540e-02f, -1.98418070e-02f, 5.56349792e-02f, -6.01688996e-02f, 5.53027447e-03f, 7.40827397e-02f,
  6.76089451e-02f, -4.48838286e-02f, 4.22629938e-02f, 5.98406009e-02f, 6.05842285e-02f, 2.60236375e-02f, -1.66663583e-02f, -5.83250932e-02f, 5.28581440e-02f, -6.64196238e-02f,
  -5.65517321e-02f, -2.35873554e-02f, -3.21587138e-02f, 5.23194447e-02f, 8.42854977e-02f, 3.24601051e-03f, 2.70923004e-02f, 3.19797709e-03f, -3.09727974e-02f, -3.57535761e-03f,
  -1.42700865e-03f, -7.59035423e-02f, -4.58476469e-02f, -7.94848129e-02f, -1.00740261e-01f, 3.20969075e-02f, -9.86139178e-02f, -8.17288607e-02f, -9.74700888e-05f, -4.64270785e-02f,
  -3.33563387e-02f, -7.94668049e-02f, 1.95052270e-02f, -3.64945121e-02f, -3.02923527e-02f, 3.39602716e-02f, -4.94663902e-02f, 1.95661783e-02f, 5.34283184e-02f, -6.54656291e-02f,
  8.30845088e-02f, 4.92485389e-02f, -9.97426827e-03f, 2.66469792e-02f, 4.02641046e-04f, -1.04985973e-02f, 2.47198958e-02f, -1.26657128e-01f, -4.16438617e-02f, 6.22057356e-02f,
  -1.43447649e-02f, -5.81922382e-02f, -7.31378049e-02f, 3.77136581e-02f, 4.35481500e-03f, -7.20658153e-02f, -1.71175022e-02f, -5.67296594e-02f, 9.69259888e-02f, 9.99702960e-02f,
  -1.52006909e-01f, -2.07820565e-01f, -1.55159589e-02f, -2.12259088e-02f, -9.14879441e-02f, -3.68063524e-02f, -3.59745398e-02f, -1.06315076e-01f, -8.38108826e-03f, -7.52020031e-02f,
  -1.64716050e-01f, -8.87071043e-02f, 2.85556130e-02f, -4.95681092e-02f, -4.00454290e-02f, 3.79666835e-02f, 1.99870281e-02f, -7.01482370e-02f, -4.02941443e-02f, -6.98334277e-02f,
  -1.84531286e-02f, -8.03177953e-02f, -4.72347587e-02f, -8.06952417e-02f, -3.90062593e-02f, 6.61785621e-03f, -8.10037181e-02f, 6.30110875e-02f, -6.46381378e-02f, -1.00093149e-01f,
  -1.41883999e-01f, 1.30365327e-01f, 6.89863935e-02f, 1.59898102e-02f, -1.24394018e-02f, -7.89672360e-02f, -1.23811759e-01f, 2.00312454e-02f, -9.79181752e-02f, 1.25174537e-01f,
  1.37912575e-02f, -1.35779813e-01f, -1.07749082e-01f, -6.59569353e-02f, -1.84027627e-01f, -1.90429166e-01f, -1.22117020e-01f, -1.15594380e-01f, -1.52852256e-02f, 6.61186725e-02f,
  9.58139356e-03f, 1.51030570e-01f, 5.49241453e-02f, 1.88447237e-01f, 5.43566011e-02f, 9.49326977e-02f, 1.05033830e-01f, 1.10123686e-01f, 5.06752282e-02f, -3.63374799e-02f,
  2.47812402e-02f, 5.96587397e-02f, 4.87829372e-03f, -1.74652655e-02f, -1.27911223e-02f, 6.90237582e-02f, -6.51589110e-02f, 2.07579266e-02f, 2.89437510e-02f, -5.85145876e-02f,
  -4.82590161e-02f, -4.27062288e-02f, -6.98022172e-02f, 2.61377841e-02f, -1.02614522e-01f, -1.86422765e-02f, -7.64200315e-02f, 6.26398204e-03f, 2.80320663e-02f, 1.82654876e-02f,
  -2.50971429e-02f, -8.57983343e-03f, 5.64366430e-02f, -6.71384437e-03f, 5.38646244e-02f, -5.18759573e-03f, -2.98730880e-02f, 5.30464686e-02f, 2.12699901e-02f, -3.30245420e-02f,
  -1.03710368e-01f, 1.28405675e-01f, -4.82050627e-02f, -8.83949921e-02f, -4.70868796e-02f, -9.22142714e-02f, 1.13561258e-01f, -4.07880805e-02f, -1.02988165e-03f, -5.78923803e-03f,
  1.11678660e-01f, 7.84638338e-03f, 4.10179347e-02f, 2.37558074e-02f, 6.18155636e-02f, 1.37877958e-02f, 1.08232372e-01f, -7.00967573e-03f, -9.50441323e-03f, 6.82908148e-02f,
  8.54781419e-02f, -9.41782817e-03f, 7.52020478e-02f, 1.77743863e-02f, -6.97851554e-03f, 5.72702810e-02f, 1.01168305e-02f, -2.59886943e-02f, 8.24397989e-03f, -1.91233177e-02f,
  3.79040837e-02f, 1.17127299e-01f, 6.57777190e-02f, -6.97007449e-03f, -9.31661353e-02f, -1.99143644e-02f, -7.34098032e-02f, -3.82472854e-03f, -1.01210065e-02f, 3.71338278e-02f,
  2.05036625e-02f, -6.97411373e-02f, -1.38196955e-03f, 6.62118867e-02f, -1.51329935e-02f, 5.49621731e-02f, 7.53805116e-02f, -4.14506011e-02f, 4.02692147e-02f, 3.20624337e-02f,
  9.77505893e-02f, -5.70660718e-02f, -1.66072268e-02f, -2.90898210e-03f, 1.59482770e-02f, 8.84160213e-03f, 1.66934114e-02f, 2.89172195e-02f, 7.86868036e-02f, -5.81411645e-03f,
  -9.88912582e-02f, 2.78740078e-01f, 2.18777299e-01f, -2.13470701e-02f, 2.95458976e-02f, -1.74912944e-01f, -2.12674424e-01f, 4.77637611e-02f, 5.28642684e-02f, 8.71469751e-02f,
  1.59303732e-02f, 1.88377365e-01f, 5.43941781e-02f, -1.97219681e-02f, -2.66996562e-01f, -2.24361092e-01f, -1.13166168e-01f, 9.55599770e-02f, -4.51723300e-02f, 6.23190887e-02f,
  -1.01066083e-01f, -1.21465281e-01f, -1.69866718e-02f, 8.73630792e-02f, 8.99473056e-02f, 2.30603144e-01f, 4.74307174e-03f, 1.25527112e-02f, 1.96674511e-01f, -5.07520624e-02f,
  4.51170318e-02f, 1.13860466e-01f, 1.54422686e-01f, -1.42463902e-02f, 5.00160493e-02f, 2.54938775e-03f, 2.53552869e-02f, 2.81658098e-02f, -5.73928468e-02f, -7.92659372e-02f,
  7.57463649e-02f, -3.52274626e-03f, 1.06473126e-01f, 8.01729038e-03f, 5.96981533e-02f, 6.58662245e-02f, 8.23259205e-02f, 7.20679909e-02f, 1.12416163e-01f, 3.06516811e-02f,
  1.38250515e-01f, -1.53965019e-02f, -3.14274244e-02f, 3.53400595e-02f, -2.88050137e-02f, 2.57955845e-02f, 9.22803581e-03f, 1.33495852e-02f, 6.81925267e-02f, 2.85149515e-02f,
  -4.40620482e-02f, -3.15435119e-02f, 2.40925066e-02f, -2.26946641e-03f, -1.80800725e-02f, 1.20392136e-01f, 4.41318490e-02f, 6.23658858e-02f, -2.41032932e-02f, -7.04056323e-02f,
  -8.49584956e-03f, 1.90295652e-02f, -2.56966073e-02f, 8.05856138e-02f, -1.36160487e-02f, 8.12356547e-02f, -2.85570417e-02f, -2.09336653e-02f, -9.25260559e-02f, 2.36395150e-02f,
  -6.73995018e-02f, -1.00563161e-01f, 8.28717574e-02f, 5.92320263e-02f, 2.44138781e-02f, 8.18276405e-02f, -3.46761681e-02f, 9.25504118e-02f, -5.23409396e-02f, -3.94908190e-02f,
  2.48907227e-02f, 6.61310181e-02f, 8.33747461e-02f, 1.40068948e-01f, 2.29085088e-02f, 2.48538125e-02f, -7.24942237e-02f, -1.04072411e-02f, 3.14994231e-02f, -3.14352401e-02f,
  1.62892938e-02f, 2.81013735e-03f, -3.96064296e-02f, 2.48624384e-03f, -4.96451892e-02f, -2.85548978e-02f, -1.26348704e-01f, -5.81508828e-03f, 8.24951530e-02f, 5.14447913e-02f,
  1.10871010e-01f, -2.93236952e-02f, -6.92814142e-02f, -5.14154285e-02f, -6.92835525e-02f, -8.72915890e-03f, -7.03288391e-02f, 4.90116514e-02f, 6.23093769e-02f, 4.59953398e-02f,
  -3.59194249e-01f, 4.93278261e-03f, 2.20793501e-01f, -3.19091380e-01f, 1.51328579e-01f, 2.12166719e-02f, 7.78762400e-02f, 4.75948490e-02f, -3.19918126e-01f, -1.63074076e-01f,
  9.33561623e-02f, 5.35428561e-02f, 1.68233544e-01f, -1.90297902e-01f, -1.45596147e-01f, -1.03739344e-01f, -2.09031671e-01f, -9.82274786e-02f, 5.12075163e-02f, 6.60272315e-02f,
  -7.77531266e-02f, -1.86432339e-02f, 8.42899904e-02f, 3.52974199e-02f, -2.58077681e-02f, -1.96995214e-02f, -9.75760967e-02f, 1.75568983e-01f, 3.96296792e-02f, 1.51758447e-01f,
  -2.65778810e-01f, -1.35395393e-01f, -8.68325382e-02f, 3.51093374e-02f, -1.16098277e-01f, 3.11338697e-02f, -6.66770898e-03f, -1.05369985e-02f, -2.15830822e-02f, -1.98552348e-02f,
  -4.18940857e-02f, -6.19899519e-02f, -9.19136330e-02f, -1.50240399e-02f, -1.68130407e-03f, -3.73420045e-02f, 4.75051813e-02f, -4.42382246e-02f, -7.90403485e-02f, 7.91538060e-02f,
  3.48526705e-03f, 2.81115212e-02f, 4.48001139e-02f, -3.60853672e-02f, 7.89073631e-02f, -6.96265027e-02f, -1.71638164e-03f, 1.47378612e-02f, -7.37491101e-02f, -7.12573081e-02f,
  -1.78414602e-02f, 1.29423352e-04f, 2.20890995e-02f, -3.51299252e-03f, 5.94645776e-02f, -2.80834758e-03f, 1.19212037e-02f, 1.70511156e-02f, 4.15845513e-02f, -3.67764607e-02f,
  -2.99794190e-02f, 9.08144861e-02f, -4.05805884e-03f, 1.37818838e-02f, -6.10670224e-02f, 1.14172418e-02f, -1.16242664e-02f, -2.43044570e-02f, 7.08802510e-03f, 7.09764101e-03f,
  3.77260298e-02f, 2.22667847e-02f, -1.10398361e-03f, -5.56598119e-02f, 5.56282252e-02f, -1.99861135e-02f, -1.62823293e-02f, -5.25256284e-02f, -6.77194521e-02f, -3.09649147e-02f,
  -2.90307105e-01f, -2.48012573e-01f, 7.04967678e-02f, -1.11017928e-01f, -2.27616522e-02f, -7.77548179e-02f, -9.38626900e-02f, -2.05674069e-03f, -6.96006045e-02f, -5.29343672e-02f,
  -4.19094712e-02f, -7.81483427e-02f, 8.08698311e-03f, -5.29435314e-02f, 1.00973174e-02f, -8.01839381e-02f, -5.29085333e-03f, 5.96017344e-03f, -6.36860132e-02f, 3.55292000e-02f,
  4.61172387e-02f, -6.19669482e-02f, 4.59373258e-02f, -4.16331924e-02f, 4.87265587e-02f, -9.19968560e-02f, -1.07496502e-02f, -1.17173083e-01f, -4.05576527e-02f, 1.77512448e-02f,
  -9.25536752e-02f, -7.04760430e-03f, -1.53442264e-01f, 8.93873200e-02f, -7.14325011e-02f, 2.84520537e-02f, 1.89655080e-01f, 2.55154502e-02f, -1.47419944e-01f, 1.30830377e-01f,
  2.06107110e-01f, -1.24085687e-01f, 4.19768952e-02f, 2.01364040e-01f, 1.16942041e-01f, 2.89980508e-03f, 2.49699250e-01f, 1.50016561e-01f, -1.43151313e-01f, 2.75614820e-02f,
  -7.74864107e-02f, 2.05629125e-01f, 6.91522509e-02f, -4.30751331e-02f, 6.74108118e-02f, -1.10920742e-01f, 9.18133929e-02f, -1.01736911e-01f, 2.49603763e-01f, 9.90516692e-02f,
  -2.36051865e-02f, -9.51752514e-02f, -5.62182143e-02f, 1.46533009e-02f, -9.76842940e-02f, -9.54399556e-02f, -6.35919794e-02f, 3.27132531e-02f, 1.59708355e-02f, 2.54260153e-02f,
  5.16167097e-03f, 5.69603518e-02f, 8.81429389e-03f, 3.99145521e-02f, -5.93066998e-02f, -9.09245908e-02f, 1.02239266e-01f, -1.95367560e-02f, 4.74094488e-02f, 1.00339822e-01f,
  -2.53863912e-02f, 8.50208774e-02f, 5.25744595e-02f, -4.18091342e-02f, -7.39593655e-02f, 5.22022732e-02f, -6.74386369e-03f, -6.80554360e-02f, -9.54883322e-02f, -6.45522354e-03f,
  -2.51620561e-02f, 3.71924751e-02f, -8.46796110e-02f, 1.57749802e-02f, -1.46298185e-02f, 9.41352360e-03f, 7.18587935e-02f, 7.69429058e-02f, 1.72403466e-03f, 1.18936831e-02f,
  3.65764163e-02f, -3.63805033e-02f, 9.46338996e-02f, 3.73414531e-02f, -1.19667090e-02f, 1.03675529e-01f, -1.36390878e-02f, 2.51768902e-02f, -2.72066891e-02f, 1.29303325e-03f,
  8.90032500e-02f, -1.01022907e-02f, 2.18127598e-03f, 6.73419908e-02f, 4.90168296e-02f, -3.33368927e-02f, -4.67535574e-03f, -2.70531755e-02f, -4.58925366e-02f, 3.71452910e-03f,
  1.08638979e-01f, -2.35413741e-02f, 5.93457632e-02f, 9.30154324e-02f, 3.32622267e-02f, 4.58996594e-02f, -1.14765674e-01f, -9.07332152e-02f, 1.88651159e-02f, -1.21593177e-01f,
  -7.90202767e-02f, -5.95650226e-02f, -9.64687392e-02f, -9.24787968e-02f, 5.14388271e-03f, -3.58339911e-03f, -6.85904874e-03f, -1.75579414e-02f, 3.84918749e-02f, 8.22152495e-02f,
  -2.58590584e-03f, 5.02817295e-02f, -2.92583765e-03f, 4.30670455e-02f, -5.70599288e-02f, 6.49741367e-02f, -1.28316609e-02f, 4.07799259e-02f, 4.81129102e-02f, -2.71983482e-02f,
  1.97245836e-01f, 1.04818016e-01f, 5.20961471e-02f, 2.58699089e-01f, 7.98077416e-03f, 1.15302399e-01f, 2.66411513e-01f, 2.08276033e-01f, 3.53886038e-01f, 2.80995350e-02f,
  -3.24846022e-02f, -1.76906493e-02f, 1.48983123e-02f, 1.31039187e-01f, -5.89477383e-02f, 1.15059629e-01f, 2.41891742e-01f, 4.84555885e-02f, 2.02985033e-01f, 1.45788789e-01f,
  6.53497055e-02f, -1.22053668e-01f, -1.40116334e-01f, -2.35874996e-01f, -7.02294484e-02f, -1.70121059e-01f, -2.72449732e-01f, -3.19546461e-02f, -1.80713415e-01f, -3.22792493e-02f,
  1.82777608e-03f, 7.72005618e-02f, -5.27249724e-02f, 7.86468685e-02f, 4.25373875e-02f, -5.46576865e-02f, 1.75315980e-02f, 7.34577654e-03f, 2.61683315e-02f, 6.97879866e-02f,
  1.09228201e-01f, -6.05403334e-02f, 3.59988883e-02f, -6.66762441e-02f, 6.75220340e-02f, -5.00019789e-02f, 6.13876134e-02f, 8.35322961e-02f, -1.06978333e-02f, -1.36736259e-02f,
  4.63840850e-02f, 5.88217340e-02f, 6.05557896e-02f, 5.00041433e-02f, 5.44126369e-02f, 2.24976707e-02f, 1.05164133e-01f, 1.84324607e-02f, 1.02854250e-02f, -1.46653811e-02f,
  -4.13531959e-02f, 5.74712418e-02f, -7.64814094e-02f, -1.51330292e-01f, 2.37495992e-02f, -8.17341879e-02f, -6.16800152e-02f, -1.10909753e-01f, 6.80320263e-02f, 5.08284988e-03f,
  -2.73645036e-02f, 3.10206190e-02f, 1.51404053e-01f, 1.54370721e-02f, 6.46846667e-02f, 4.68829982e-02f, 1.44923497e-02f, -3.58160660e-02f, 1.75819267e-02f, -8.03840160e-02f,
  5.11302911e-02f, 6.96289400e-03f, -8.31388161e-02f, -9.94068310e-02f, -6.96356893e-02f, 6.51485100e-02f, -5.82743026e-02f, 3.23627107e-02f, -1.96109861e-02f, 2.10828111e-02f,
  1.42315984e-01f, 1.55017246e-02f, 1.13106981e-01f, 3.99553590e-03f, -1.61632169e-02f, -1.05648994e-01f, -5.80377690e-02f, -3.33358571e-02f, 1.04178255e-02f, -4.57657278e-02f,
  1.21745035e-01f, -4.21563722e-02f, 1.86522584e-02f, 1.92414541e-02f, 6.78414851e-02f, -6.55520484e-02f, 3.35192420e-02f, 3.81860184e-03f, 1.03942901e-02f, -1.75686497e-02f,
  8.99252016e-03f, 3.82970013e-02f, -1.70230307e-02f, -4.07541171e-02f, 3.62686627e-02f, -3.70266549e-02f, 4.20355126e-02f, 1.14331730e-02f, -7.08019808e-02f, -4.11096029e-02f,
  -2.28198722e-01f, 2.83502191e-01f, 2.82393515e-01f, 3.24208647e-01f, -1.85930878e-01f, -1.36499748e-01f, -1.61444157e-01f, 6.44596294e-02f, -5.38261123e-02f, -1.97836012e-01f,
  3.00402753e-02f, -4.21657078e-02f, 6.17967744e-04f, 1.44222498e-01f, 5.80908023e-02f, 1.02878667e-01f, 3.73179764e-02f, -3.20832850e-03f, 1.82282835e-01f, 2.11705957e-02f,
  1.33883685e-01f, 5.45496941e-02f, 2.71337420e-01f, 1.47442102e-01f, -1.57166682e-02f, 1.88636988e-01f, 2.11368486e-01f, 3.87299992e-02f, 1.40425250e-01f, 3.42899077e-02f,
  -7.46917203e-02f, 9.66851935e-02f, 3.10168806e-02f, -6.30385056e-02f, -7.08741769e-02f, -1.16988458e-01f, 8.31868779e-03f, -1.52561804e-02f, 4.85354252e-02f, 3.42872478e-02f,
  -7.45015070e-02f, 1.33010903e-02f, -1.35586550e-02f, -8.26623663e-03f, -1.40955836e-01f, 4.55104187e-02f, 2.63918452e-02f, 5.30460663e-02f, 1.41146323e-02f, -8.64600912e-02f,
  2.77015846e-02f, -6.66351318e-02f, 2.29055956e-02f, -4.17166203e-02f, 1.29605770e-01f, -2.52044760e-03f, -1.63082890e-02f, -7.21286889e-03f, 3.72011913e-03f, 7.73138180e-03f,
  -1.19461000e-01f, -2.91052852e-02f, 7.25829601e-02f, -5.57419248e-02f, 5.40312231e-02f, -4.89977673e-02f, 6.21427894e-02f, -6.80122599e-02f, -2.01106654e-03f, -1.02237739e-01f,
  -8.10985491e-02f, -4.17459719e-02f, -3.83395217e-02f, -1.74922775e-02f, 5.03840744e-02f, -1.32105192e-02f, 2.85957865e-02f, -1.39312423e-03f, 3.13708074e-02f, 6.23493381e-02f,
  -3.50380167e-02f, -3.81642617e-02f, 5.46453055e-03f, -1.58189945e-02f, -6.79891706e-02f, 2.61165556e-02f, -7.18206726e-03f, 5.77866705e-03f, 9.65179652e-02f, -3.24483886e-02f,
  -6.43988922e-02f, 2.46518776e-01f, 2.45408271e-03f, -8.16255659e-02f, -3.53151448e-02f, -6.73198402e-02f, 3.79586704e-02f, -7.14533627e-02f, 1.15260854e-01f, -2.25936621e-02f,
  -1.39698014e-01f, 9.49827768e-03f, 4.44538184e-02f, 3.47861648e-02f, -3.42052616e-02f, -7.19155744e-03f, 3.98024507e-02f, 8.92575681e-02f, 7.58801633e-03f, -1.70206241e-02f,
  9.78489872e-03f, -1.52487382e-01f, -8.07812586e-02f, -5.79077899e-02f, 6.32730499e-02f, 3.38298976e-02f, -1.37131438e-02f, -2.15186514e-02f, -2.07699016e-02f, 7.02309748e-03f,
  3.12144041e-01f, -2.94611305e-01f, 1.21905267e-01f, 7.98933357e-02f, 6.57917485e-02f, -2.81054154e-02f, 2.13994876e-01f, 3.38405445e-02f, 1.09626159e-01f, -2.08402202e-01f,
  6.67848662e-02f, 3.58082470e-03f, -1.02277018e-01f, -7.82305300e-02f, 2.33862489e-01f, 2.24761572e-02f, -2.03546025e-02f, -4.63890331e-03f, 4.73270975e-02f, 1.00265898e-01f,
  3.64589356e-02f, -4.38424526e-03f, 6.88534006e-02f, -9.49221551e-02f, 1.00147374e-01f, 4.62803282e-02f, -4.49735187e-02f, -5.04859956e-03f, -1.47978519e-03f, 1.00770637e-01f,
  -1.08904235e-01f, 6.33760691e-02f, -8.50216672e-02f, -1.52216014e-02f, -8.89049768e-02f, -1.90950613e-02f, -1.99731328e-02f, 1.05908643e-02f, 8.21885839e-03f, -5.14752567e-02f,
  -7.07952818e-03f, 1.88721716e-02f, 1.06519699e-01f, 8.37412253e-02f, -9.96838585e-02f, 2.77393796e-02f, 4.55810167e-02f, -9.84218270e-02f, -1.26000000e-02f, -3.56468023e-03f,
  6.06727526e-02f, 2.18267981e-02f, -1.56079549e-02f, 8.13660249e-02f, 3.61578278e-02f, -2.56226417e-02f, -1.09590795e-02f, -4.81727570e-02f, -3.23834009e-02f, -4.10711095e-02f,
  7.32376501e-02f, -7.53379911e-02f, 4.43408936e-02f, 1.16647687e-02f, 6.27270266e-02f, 2.37058438e-02f, -3.98051664e-02f, 5.96314967e-02f, -1.53283328e-02f, 5.44752181e-02f,
  -5.57571873e-02f, -7.88727850e-02f, 2.24376731e-02f, -4.72439229e-02f, -6.90129846e-02f, 8.85334145e-03f, -4.01241565e-03f, -3.90729355e-03f, 3.49542238e-02f, -7.66632035e-02f,
  -3.75648029e-02f, 5.99275678e-02f, 3.82670984e-02f, 1.05967067e-01f, 5.01905344e-02f, -5.96846454e-03f, 6.60057645e-04f, 4.56924736e-02f, 2.18658838e-02f, -4.33029607e-02f,
  -3.58036309e-01f, -2.84304500e-01f, -8.40901509e-02f, -8.32596943e-02f, -3.83356996e-02f, -1.54518047e-02f, 2.08476875e-02f, -3.79199572e-02f, -1.13652281e-01f, 6.19143397e-02f,
  -7.78409392e-02f, 4.38354462e-02f, -5.05410656e-02f, 1.12384073e-01f, -7.94932768e-02f, 3.57495155e-03f, -5.13513833e-02f, -6.31546676e-02f, -8.19192529e-02f, -4.86561507e-02f,
  -5.46300374e-02f, 6.44934326e-02f, 5.80703393e-02f, -4.45123315e-02f, 6.96547776e-02f, -5.43814600e-02f, -3.48470062e-02f, 3.68010849e-02f, 6.39915317e-02f, 9.55539420e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.28917128e-01f, 1.14050269e-01f, 6.77683279e-02f, 7.44858384e-02f, 4.76967022e-02f, 1.00811034e-01f, 8.18255916e-02f, 6.54383302e-02f, 7.07942024e-02f, 1.04537494e-01f,
  -1.58027431e-03f, 1.33921608e-01f, 1.03687756e-01f, 7.79750943e-02f, 1.15639895e-01f, 9.70162526e-02f, 3.12674530e-02f, 9.34882909e-02f, 1.70414329e-01f, 9.89022553e-02f,
  9.88598838e-02f, 2.75558829e-01f, 1.22343795e-02f, 9.79489312e-02f, 1.94272231e-02f, 8.05762336e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -9.43164825e-02f, -6.17288463e-02f, 9.26076174e-02f, -1.99096985e-02f, -1.19401375e-02f, 6.72249869e-02f, 6.99748322e-02f, 9.19455811e-02f, -1.08851030e-01f, 1.85762644e-01f,
  1.89229444e-01f, -4.63712439e-02f, -3.59400250e-02f, 2.05371194e-02f, 2.69030314e-02f, 1.87908202e-01f, -9.47329029e-02f, -1.20575309e-01f, -1.52142808e-01f, 8.14443752e-02f,
  1.56862941e-02f, -4.27047908e-02f, -1.01690620e-01f, 7.57814720e-02f, -9.60401669e-02f, 7.05008507e-02f, 8.92721266e-02f, -1.23179168e-01f, 1.65196061e-02f, 7.22331330e-02f,
  6.92517236e-02f, 3.31169553e-02f, -2.16118336e-01f, -6.46626800e-02f, -5.31491600e-02f, 8.41693357e-02f, -2.08126411e-01f, 1.16015531e-01f, 5.04763387e-02f, 1.17460005e-02f,
  1.43312663e-01f, -7.55631328e-02f, 2.38703132e-01f, -7.17724189e-02f, 2.52507180e-01f, -5.56370579e-02f, 8.15686285e-02f, -1.06358059e-01f, -2.62743801e-01f, 1.65997714e-01f,
  9.44250524e-02f, 4.28884923e-02f, 6.95347041e-02f, 6.83424547e-02f, -2.05630168e-01f, 1.02796689e-01f, 1.23101711e-01f, -1.21737830e-01f, 6.38518259e-02f, -8.57889727e-02f,
  -8.23502839e-02f, 1.29255429e-02f, 4.34176661e-02f, -7.74034634e-02f, -8.20543393e-02f, -4.18057665e-02f, -1.29432186e-01f, -6.36570603e-02f, -6.32864684e-02f, -1.60726234e-01f,
  -7.02737868e-02f, 2.76841745e-02f, -1.11709259e-01f, 7.58293197e-02f, -5.60677201e-02f, -5.96509799e-02f, 9.69812423e-02f, -3.75872105e-02f, -1.07550792e-01f, -3.16002071e-02f,
  -5.07909060e-02f, 3.32261994e-02f, -5.11995628e-02f, -2.89047379e-02f, -1.42616048e-01f, 1.06955685e-01f, 1.62215725e-01f, 1.83773771e-01f, -6.07630536e-02f, 5.58838584e-02f,
  2.29448944e-01f, -2.39574909e-01f, 1.99273527e-02f, 8.71147662e-02f, 1.06666654e-01f, 1.80197448e-01f, -9.24055278e-02f, 1.75781235e-01f, 9.17827189e-02f, -2.34551076e-02f,
  -6.76883459e-02f, 1.74098626e-01f, -1.23628199e-01f, 7.26042036e-03f, 1.86437815e-01f, -1.16030432e-01f, 2.46782988e-01f, 1.42108083e-01f, 1.06089756e-01f, 1.88924205e-02f,
  -2.26335332e-01f, -2.29697034e-01f, -3.09510976e-02f, 7.81430677e-02f, -1.88801661e-01f, 7.19148889e-02f, 7.96560273e-02f, -1.35148242e-01f, 1.20501734e-01f, 5.29764742e-02f,
  1.02234237e-01f, -1.36165068e-01f, -2.85396818e-02f, -5.58123253e-02f, -1.66795433e-01f, 1.95879769e-02f, 2.16884255e-01f, 1.84718430e-01f, 2.83482764e-02f, -4.56841961e-02f,
  -5.14984056e-02f, -2.70295329e-03f, -1.12240046e-01f, 2.78720409e-02f, -1.50904104e-01f, -1.34156719e-01f, -7.37201199e-02f, 8.40485990e-02f, 9.13147107e-02f, -1.55390158e-01f,
  3.10664270e-02f, -1.29804343e-01f, 1.17108852e-01f, -3.73719260e-02f, -1.44149005e-01f, 2.59741992e-02f, 7.35292733e-02f, 1.38311803e-01f, 4.95591806e-03f, -1.64693743e-02f,
  2.79953592e-02f, -1.00204311e-01f, 1.06560644e-02f, -1.47951618e-01f, 9.02569070e-02f, 1.97874144e-01f, -1.44955590e-01f, -1.29540414e-02f, 8.24773088e-02f, -1.50948942e-01f,
  4.84492928e-02f, -1.22015528e-01f, 3.18387114e-02f, -1.62680820e-01f, 1.43544689e-01f, 1.96334556e-01f, 8.28777403e-02f, -7.39748329e-02f, -1.17147446e-01f, -5.56241870e-02f,
  -6.32159337e-02f, 2.51241736e-02f, -1.72480270e-01f, -1.25253856e-01f, 1.20048925e-01f, 4.10124846e-02f, 1.51796788e-01f, 2.61627063e-02f, 6.29589707e-02f, -1.47962257e-01f,
  1.77919604e-02f, -1.28214538e-01f, -1.35085508e-01f, 1.70127794e-01f, 2.64795516e-02f, 1.50850326e-01f, 2.10599601e-01f, 2.23705903e-01f, 3.23950276e-02f, -1.33499399e-01f,
  1.90253332e-01f, -2.03570575e-01f, 6.74701184e-02f, 1.72293007e-01f, 7.11048245e-02f, 1.31012991e-01f, -5.77068329e-02f, -9.78556052e-02f, 1.18178986e-01f, 1.24586940e-01f,
  5.35710678e-02f, -5.06415684e-03f, 3.46996672e-02f, 1.72923043e-01f, 1.03550285e-01f, 3.12878303e-02f, 5.01367897e-02f, 7.78253078e-02f, 6.81226179e-02f, -2.52811890e-02f,
  6.54288307e-02f, 2.29453847e-01f, -1.88018665e-01f, 1.98470801e-01f, -1.29943758e-01f, -2.92145349e-02f, 4.66522910e-02f, -4.65383753e-02f, 5.45916930e-02f, 9.24557522e-02f,
  -7.26738423e-02f, -1.67181045e-01f, 1.27218023e-01f, 9.87959728e-02f, 1.87489595e-02f, 6.41875044e-02f, -1.19220994e-01f, -2.69468855e-02f, 9.12598670e-02f, -2.53680628e-02f,
  2.41296802e-04f, -2.24120915e-02f, 5.49566979e-03f, 1.36374354e-01f, 6.57432526e-02f, -1.53051868e-01f, -8.79402012e-02f, -3.02686006e-01f, -7.44938701e-02f, -9.31173563e-02f,
  1.07769765e-01f, 3.85345705e-02f, 1.61345303e-01f, 9.21433792e-03f, -1.26819566e-01f, 6.99524730e-02f, 8.50611925e-02f, 3.06482494e-01f, -2.00801298e-01f, 1.00009523e-01f,
  2.29317665e-01f, 1.00928187e-01f, -7.87244961e-02f, -9.53551382e-02f, 8.96098092e-02f, -3.66642028e-01f, -6.53374568e-02f, 4.90979180e-02f, -1.32373154e-01f, 1.45969734e-01f,
  8.81392211e-02f, 3.18191089e-02f, 1.16645381e-01f, 2.86010746e-03f, 1.45306606e-02f, 2.96463482e-02f, 3.27888317e-02f, -6.71568811e-02f, -8.17316547e-02f, 3.03751677e-02f,
  -7.43051060e-03f, -3.94342057e-02f, 8.14183354e-02f, 1.06725246e-01f, -8.94565322e-03f, 2.79615410e-02f, 9.72990915e-02f, -8.16144347e-02f, -1.32987231e-01f, 1.52681008e-01f,
  -3.40763144e-02f, 1.85036302e-01f, 2.67870771e-03f, -2.85131574e-01f, 2.07432300e-01f, 1.07145123e-01f, 2.94602066e-02f, -1.06356367e-01f, -1.25167727e-01f, 2.24629343e-01f,
  -1.02362670e-01f, 1.78969398e-01f, 5.32337278e-02f, 1.00455828e-01f, -3.54588442e-02f, 5.55731766e-02f, 4.10016850e-02f, -8.47791731e-02f, 2.63582945e-01f, 1.00146942e-02f,
  4.12530993e-04f, 1.22982055e-01f, -2.64522821e-01f, -3.16063352e-02f, -1.50061011e-01f, -7.75905401e-02f, -1.37160480e-01f, 1.41180187e-01f, -2.38435175e-02f, -4.78052348e-02f,
  1.56064048e-01f, -3.03651579e-02f, 2.01368555e-01f, -1.26963735e-01f, 2.66966969e-02f, -3.37304771e-01f, -1.79150164e-01f, 1.76983804e-01f, -5.84220961e-02f, 9.58940610e-02f,
  9.22198594e-02f, -2.32924637e-03f, 2.06405204e-02f, -3.63159403e-02f, 1.03846170e-01f, -1.38340250e-01f, 3.00604310e-02f, -9.88341868e-02f, -3.12732197e-02f, -1.00914322e-01f,
  1.01243429e-01f, -2.05976386e-02f, 1.04696639e-01f, -1.48054808e-02f, -2.73145037e-03f, 6.32753819e-02f, 1.69641823e-01f, 8.75539184e-02f, 3.69454511e-02f, 1.27429873e-01f,
  -1.93323195e-01f, 1.30467698e-01f, 4.19522338e-02f, -6.10318482e-02f, 6.48024082e-02f, -6.60337089e-03f, 1.86608747e-01f, 4.05751914e-02f, -2.88590729e-01f, -1.58337638e-01f,
  1.87502429e-01f, 6.96953684e-02f, -9.54981148e-03f, -3.30425352e-02f, -1.49568960e-01f, -1.38386283e-02f, 4.91440780e-02f, -1.19930729e-01f, -1.20903052e-01f, 8.79212692e-02f,
  -5.52090034e-02f, 4.43590358e-02f, 7.70664588e-02f, -8.72104838e-02f, -2.26800516e-02f, -2.19340082e-02f, -8.65585636e-03f, 1.54040426e-01f, 1.95412159e-01f, 1.35870844e-01f,
  -2.54598167e-02f, 1.10373169e-03f, -2.00216267e-02f, -3.68052311e-02f, 5.78471720e-02f, -1.06945902e-01f, -1.40993491e-01f, -7.53690954e-03f, -5.88110127e-02f, 1.75434932e-01f,
  -6.27896264e-02f, -8.35392401e-02f, -1.75628252e-02f, -1.34083614e-01f, 1.07809640e-01f, 1.62811458e-01f, -1.38272747e-01f, 2.13407964e-01f, 7.70543292e-02f, 1.42030671e-01f,
  1.54388666e-01f, -4.31048721e-02f, 2.04356834e-01f, -9.52070057e-02f, 1.28331855e-01f, -5.67614026e-02f, 5.27159795e-02f, -7.75705203e-02f, 1.02446385e-01f, -9.55033302e-02f,
  9.68513340e-02f, 1.90471441e-01f, 8.01146179e-02f, 4.79395539e-02f, 4.99581452e-04f, -2.29508236e-01f, -1.88840672e-01f, -7.37498105e-02f, -5.79241216e-02f, 5.94948232e-02f,
  -2.53769040e-01f, -2.18170509e-01f, 6.59768134e-02f, -7.95751140e-02f, -2.42269754e-01f, -1.67830691e-01f, 1.74518377e-01f, -3.17971520e-02f, 2.26041690e-01f, -4.78344318e-03f,
  2.11170495e-01f, 2.93354820e-02f, 5.83896600e-02f, 4.11001313e-03f, -1.13142438e-01f, 8.13299492e-02f, 8.44016820e-02f, 6.50341585e-02f, -2.51697659e-01f, 4.88554314e-02f,
  -5.93465492e-02f, 1.43706217e-01f, -5.72478808e-02f, -9.66094509e-02f, -3.34811211e-02f, 1.44520789e-01f, -2.91761339e-01f, 2.71717012e-02f, -3.47199552e-02f, 2.03099340e-01f,
  1.35630429e-01f, 6.05592020e-02f, -7.49943852e-02f, -2.36972377e-01f, -1.54196844e-03f, 5.55303469e-02f, 1.23689249e-02f, 2.21438985e-02f, 1.28062919e-01f, -1.40382037e-01f,
  4.20237295e-02f, -3.88904512e-02f, -2.52391715e-02f, -1.79002270e-01f, 4.01488505e-02f, -1.65566236e-01f, -7.27678984e-02f, 9.67124570e-03f, -1.95729062e-01f, 8.71013924e-02f,
  -1.30775616e-01f, 3.46523942e-03f, 1.41872525e-01f, 8.84963156e-05f, -1.46609852e-02f, -1.22549161e-01f, -6.58684894e-02f, -1.05993047e-01f, -6.77034706e-02f, 7.01430738e-02f,
  2.93570999e-02f, -6.56960532e-02f, -1.19058982e-01f, -1.55081242e-01f, 7.74593502e-02f, 2.88268805e-01f, -2.30384499e-01f, -7.37427771e-02f, 2.04128653e-01f, -3.69018987e-02f,
  1.11621141e-01f, -1.54966310e-01f, -2.01953620e-01f, 1.00332849e-01f, -4.99567240e-02f, -1.49373159e-01f, -7.75787905e-02f, 6.96576899e-03f, 1.08901329e-01f, 1.26160696e-01f,
  -2.55520731e-01f, 8.49820897e-02f, 1.10607766e-01f, -7.30972886e-02f, 3.55122276e-02f, -4.35081497e-02f, 1.79892078e-01f, -8.32586735e-02f, -1.49125168e-02f, -1.53602555e-01f,
  -3.46103646e-02f, 6.01938367e-03f, 2.81077504e-01f, -1.04633428e-01f, -1.64460495e-01f, 4.82030259e-03f, 8.50708690e-03f, 1.97651520e-01f, 1.28178537e-01f, -2.07639500e-01f,
  -1.72838926e-01f, -5.76384477e-02f, 1.28621876e-01f, -1.28018215e-01f, -1.61993593e-01f, 1.36024393e-02f, -6.73013851e-02f, -9.96134207e-02f, 1.19681712e-02f, -3.05409357e-02f,
  -2.66890489e-02f, -3.08186393e-02f, -1.74522594e-01f, 6.69543073e-02f, -1.18168756e-01f, 7.97302946e-02f, 6.86394125e-02f, -1.16341293e-01f, -3.35493833e-02f, -9.01684314e-02f,
  4.91721407e-02f, -7.33392537e-02f, -1.53150424e-01f, -1.47068962e-01f, -8.43951292e-03f, -3.21891392e-03f, 6.10572845e-02f, 1.56811960e-02f, -2.02816233e-01f, 7.27659613e-02f,
  1.11760892e-01f, -1.43540397e-01f, 3.63832228e-02f, 2.55337893e-03f, 1.93151623e-01f, -9.20915231e-02f, -4.96265925e-02f, 1.06835067e-01f, -1.40935117e-02f, -1.36335775e-01f,
  -3.42920311e-02f, 4.37559411e-02f, 3.84636261e-02f, 8.04053247e-02f, -9.04556215e-02f, 3.98953492e-03f, 4.24403511e-03f, 2.55541354e-01f, 5.41705489e-02f, 2.16112062e-01f,
  2.18864959e-02f, -1.49396345e-01f, -2.01256070e-02f, -1.79059014e-01f, -2.26462036e-01f, 2.25181635e-02f, -4.76655327e-02f, -1.62479609e-01f, -7.78977722e-02f, -4.06543091e-02f,
  -6.64569065e-02f, -1.85283944e-01f, 2.20044538e-01f, -7.31538096e-03f, -1.07503235e-01f, 1.98736303e-02f, 9.69425216e-02f, -1.15674034e-01f, -4.18436453e-02f, 4.03860360e-02f,
  9.18671340e-02f, -7.71572590e-02f, 4.71037775e-02f, 6.72935694e-02f, 2.87341084e-02f, -1.24701627e-01f, 4.76660207e-03f, -1.14861518e-01f, -1.50451526e-01f, -6.46867752e-02f,
  -1.00287296e-01f, -2.08803028e-01f, -9.21609402e-02f, 8.29298124e-02f, 6.25966489e-02f, -2.77904365e-02f, -9.50133353e-02f, 4.70131040e-02f, 7.99029469e-02f, -2.16172993e-01f,
  -6.81481734e-02f, -1.28965408e-01f, -4.74391878e-02f, 1.51726320e-01f, 5.12869693e-02f, -9.42329392e-02f, -1.65289256e-03f, -1.34295776e-01f, 2.00397670e-01f, 2.78445054e-02f,
  4.43056636e-02f, 1.14522219e-01f, 1.05438873e-01f, -7.95525685e-03f, 8.23846925e-03f, 2.36249432e-01f, 2.26468649e-02f, 1.94168374e-01f, -1.79696664e-01f, -1.11752175e-01f,
  -1.92766026e-01f, 8.05767253e-02f, 1.24232769e-01f, 1.61587447e-01f, 1.90312637e-03f, -1.58511534e-01f, 1.50053710e-01f, -1.16113469e-01f, -1.54818352e-02f, 1.11428455e-01f,
  1.21542834e-01f, -1.27279982e-01f, -1.47267669e-01f, 1.20883450e-01f, 4.73980345e-02f, -6.04795069e-02f, 2.72173852e-01f, -9.67414826e-02f, 2.01174423e-01f, -2.30986014e-01f,
  5.82392253e-02f, 3.27800289e-02f, 7.09107816e-02f, 6.03446886e-02f, -1.02775447e-01f, -1.32970482e-01f, -5.96857071e-02f, 1.05902404e-01f, -8.00766945e-02f, -2.08395459e-02f,
  -1.38326719e-01f, -1.01777710e-01f, -2.27867104e-02f, 3.24250869e-02f, 2.73136050e-02f, -6.65239990e-02f, -2.94643026e-02f, 5.91017455e-02f, 4.93038148e-02f, 1.42032772e-01f,
  -5.46326973e-02f, 1.07011013e-01f, -1.85828716e-01f, 1.07679293e-01f, 1.87023878e-01f, -1.32582754e-01f, 1.96776778e-01f, 7.91535303e-02f, -2.10028216e-01f, -1.45265713e-01f,
  -6.64180964e-02f, -2.03506574e-02f, 5.51908612e-02f, -2.77720746e-02f, -1.58397872e-02f, -1.73398748e-01f, 2.27554679e-01f, 1.53616620e-02f, -1.84258968e-02f, -1.76061109e-01f,
  2.61385590e-02f, -6.75579682e-02f, -3.38903293e-02f, -1.01928703e-01f, -6.38521463e-02f, -6.33405596e-02f, -1.01843536e-01f, 1.21539094e-01f, 2.17951730e-01f, 1.20872937e-01f,
  2.90497262e-02f, 5.65983988e-02f, -2.00567931e-01f, -8.74387547e-02f, 2.78391451e-01f, 1.92816824e-01f, -8.17983672e-02f, 7.42344856e-02f, 1.85799539e-01f, 1.18934117e-01f,
  -1.62737846e-01f, -2.43391857e-01f, 1.72322616e-01f, -2.42999449e-01f, -1.63495645e-01f, -5.61844967e-02f, -1.51950881e-01f, 1.14503101e-01f, -1.56974548e-03f, 4.86227050e-02f,
  1.65285885e-01f, 5.52732032e-03f, 3.51016410e-02f, 4.69770506e-02f, -6.42058440e-04f, 6.07725419e-02f, -2.40889788e-02f, 5.54096252e-02f, -1.11515395e-01f, 1.32964412e-02f,
  5.72473221e-02f, 1.03933759e-01f, -5.31551950e-02f, -9.23347771e-02f, 1.22707106e-01f, -2.09534720e-01f, -5.43405674e-03f, -1.39227018e-01f, 2.29947701e-01f, -2.48954240e-02f,
  -2.81506449e-01f, -3.17622632e-01f, -9.52687487e-02f, 3.70751284e-02f, -5.88012002e-02f, -1.75326630e-01f, 8.15106109e-02f, -1.36327609e-01f, -8.07010159e-02f, 1.32374033e-01f,
  1.77823424e-01f, -9.15881991e-02f, 1.48939997e-01f, -9.77111086e-02f, -3.21122035e-02f, 3.21201570e-02f, 2.96443123e-02f, 1.65045485e-01f, -7.92064518e-02f, 2.54548162e-01f,
  7.71868378e-02f, 2.66403675e-01f, -3.97621430e-02f, 2.64683776e-02f, -1.19661443e-01f, -6.18886389e-02f, -3.33920896e-01f, -3.75893107e-03f, 2.07167119e-02f, 4.15921211e-02f,
  3.20202112e-01f, -1.02171786e-01f, -9.77802575e-02f, -1.62424266e-01f, -9.72041711e-02f, -8.82947743e-02f, -4.14822012e-01f, 2.40615875e-01f, 2.03854367e-02f, -1.07736200e-01f,
  2.36456916e-02f, 6.48496747e-02f, 6.84441775e-02f, -8.41170698e-02f, -1.36801749e-01f, 5.90913333e-02f, -1.40476555e-01f, -1.05859473e-01f, 5.35054430e-02f, 6.81460053e-02f,
  -7.35759437e-02f, -4.33634110e-02f, 6.96519241e-02f, 1.20986007e-01f, 1.16298022e-02f, 4.78096679e-02f, -8.50603506e-02f, -2.15747654e-02f, -1.15574799e-01f, 1.17587313e-01f,
  1.72612205e-01f, -4.08101082e-02f, 4.72370535e-02f, -4.62053791e-02f, 2.64726043e-01f, -1.57432631e-01f, -1.61322102e-01f, 7.20435455e-02f, 2.59783715e-01f, -2.33443435e-02f,
  -1.31974608e-01f, 1.80442855e-02f, -8.46044570e-02f, 1.45531088e-01f, 2.77543757e-02f, -1.87252358e-01f, 2.39575077e-02f, -1.54640600e-01f, 2.34305158e-01f, -3.11638489e-02f,
  6.34370698e-03f, -8.53862055e-03f, 2.95569628e-01f, 1.20548330e-01f, -1.25877671e-02f, -1.75654039e-01f, -1.79144949e-01f, 2.25272447e-01f, -9.22450349e-02f, 9.08798203e-02f,
  1.51587173e-01f, 1.02038555e-01f, 2.36932471e-01f, -4.96220887e-02f, 1.04310304e-01f, -5.31334355e-02f, 2.73929294e-02f, 2.32531995e-01f, 1.21148126e-02f, -1.50331542e-01f,
  1.04260491e-02f, 1.23971529e-01f, 3.93779464e-02f, -4.94880741e-03f, -6.26285449e-02f, -1.27097845e-01f, 1.10340290e-01f, 6.76790625e-02f, 1.03926644e-01f, 1.17676720e-01f,
  -9.78778005e-02f, -8.93322006e-02f, 1.00885116e-01f, 1.75332025e-01f, -2.25469619e-02f, 2.27588341e-02f, -1.37443632e-01f, 4.90964688e-02f, -1.55895425e-03f, -8.21916685e-02f,
  -4.86342385e-02f, -2.43718013e-01f, -1.15479395e-01f, -2.10297167e-01f, -8.19453150e-02f, 6.45119026e-02f, 1.77670568e-01f, -2.07355861e-02f, -9.67706889e-02f, -1.57931536e-01f,
  -1.42480567e-01f, 1.60673596e-02f, 8.62568617e-03f, -6.52996227e-02f, 6.93108141e-02f, -2.20827520e-01f, -2.57822089e-02f, 1.30200414e-02f, 1.21870734e-01f, -3.01135108e-02f,
  -1.38865067e-02f, -1.82211578e-01f, -2.32071262e-02f, -1.45715430e-01f, 1.09487750e-01f, 2.05704316e-01f, -2.14591511e-02f, 1.37006611e-01f, -1.99806243e-02f, 2.40435362e-01f,
  -1.26381628e-02f, 9.44661498e-02f, -1.56229809e-01f, -5.35097010e-02f, -1.24669291e-01f, -6.13993667e-02f, 1.42675549e-01f, -7.74327219e-02f, 9.53497216e-02f, -7.50171244e-02f,
  -1.38009608e-01f, 8.30663461e-03f, -1.65969342e-01f, -1.63220242e-01f, -1.95988923e-01f, 2.93589294e-01f, -8.27478766e-02f, -4.68293317e-02f, -9.49814022e-02f, -1.94053128e-01f,
  -2.06414729e-01f, 4.81806993e-02f, 7.31676221e-02f, -2.04620343e-02f, -1.47093192e-01f, 5.14449319e-03f, 2.27831211e-02f, 1.11256205e-02f, 3.95922810e-02f, -2.27700286e-02f,
  -1.18214227e-01f, -2.51099199e-01f, -5.45834452e-02f, -8.05080906e-02f, 5.01572862e-02f, 1.30006492e-01f, -5.38249500e-02f, -6.83992058e-02f, -1.40130118e-01f, -1.56960398e-01f,
  1.15688935e-01f, -3.71869989e-02f, -1.51121721e-01f, 3.33573706e-02f, 6.72833622e-02f, 1.79693267e-01f, -1.79065928e-01f, -2.00365722e-01f, 9.59801376e-02f, -1.95450217e-01f,
  2.04280660e-01f, -2.02184722e-01f, 1.00450329e-01f, 7.83400610e-02f, 4.24519964e-02f, -1.63936377e-01f, -4.93061915e-02f, -8.65342766e-02f, -1.96409762e-01f, -7.81975165e-02f,
  -1.36610061e-01f, -7.68612400e-02f, 1.43812627e-01f, -6.27768487e-02f, -7.18952119e-02f, -1.52083158e-01f, 2.03150034e-01f, -1.92641675e-01f, -2.30388314e-01f, -1.55082280e-02f,
  5.06211072e-02f, 3.87675082e-03f, -1.14315815e-01f, 1.45134255e-01f, 6.86438754e-02f, 3.14997546e-02f, 2.02939305e-02f, -8.53676125e-02f, 2.61573493e-01f, 3.62285227e-03f,
  -6.83752745e-02f, 2.10678861e-01f, -2.44278908e-02f, -6.26011267e-02f, 5.56123927e-02f, 2.55563736e-01f, 1.05464794e-01f, -2.95750350e-02f, 1.43643662e-01f, 1.32580966e-01f,
  -7.15178698e-02f, 1.36245683e-01f, 1.32335499e-01f, -1.03278816e-01f, -6.62513897e-02f, -5.55442646e-02f, -6.48332164e-02f, 4.94279787e-02f, 1.49514675e-01f, -3.64922024e-02f,
  -6.97404891e-02f, -1.85133547e-01f, -1.54970750e-01f, 1.91338379e-02f, 1.31348953e-01f, -5.84815256e-02f, 6.35610595e-02f, 2.57546967e-03f, -1.69439688e-02f, -2.92599425e-02f,
  -9.70196277e-02f, 9.18041617e-02f, 3.46144172e-03f, -2.05026925e-01f, 6.24330975e-02f, -1.47810966e-01f, 1.54558674e-01f, 1.23806328e-01f, -8.26918408e-02f, -1.82542443e-01f,
  -2.08380446e-01f, -1.05971195e-01f, -6.32347837e-02f, -3.60646397e-02f, -1.55683175e-01f, -2.09594861e-01f, 1.51014701e-01f, 4.10910100e-02f, 2.27305382e-01f, 2.24226043e-02f,
  1.25309885e-01f, 5.31259738e-02f, 4.27264944e-02f, -1.50725693e-01f, -1.17105402e-01f, 9.18794647e-02f, 1.55674711e-01f, 2.41854876e-01f, 1.48364946e-01f, 1.63278162e-01f,
  1.93699393e-02f, -6.44198954e-02f, 1.13852367e-01f, -2.59912089e-02f, 2.17362627e-01f, -6.69946074e-02f, -9.65246558e-02f, -1.54526541e-02f, 3.74879641e-03f, 2.96962503e-02f,
  2.41882410e-02f, 9.80131701e-03f, -6.76978603e-02f, -9.46261734e-02f, -9.04055610e-02f, 8.27774182e-02f, 4.27753590e-02f, -1.87307186e-02f, 1.17050990e-01f, -1.30344644e-01f,
  -3.51173952e-02f, 3.71983610e-02f, -2.99455859e-02f, -1.09564789e-01f, -1.25531152e-01f, -1.02118686e-01f, 2.84953229e-02f, -3.37479115e-02f, 1.06616698e-01f, 6.25261813e-02f,
  -1.76124841e-01f, 6.40931651e-02f, -2.23703566e-03f, -1.51672944e-01f, 2.69800723e-02f, -1.16018660e-01f, 1.50488436e-01f, -6.20408803e-02f, -1.40478820e-01f, -2.63466649e-02f,
  8.91726315e-02f, -1.70730472e-01f, 1.82804406e-01f, 1.44101262e-01f, 5.76096773e-02f, 8.46954510e-02f, -7.69956559e-02f, -9.83617306e-02f, -1.44846022e-01f, 9.40527469e-02f,
  9.95463803e-02f, 2.74900377e-01f, -2.65284199e-02f, -5.63806966e-02f, 8.59261900e-02f, 1.05217628e-01f, -1.61146313e-01f, 2.00709820e-01f, 1.98477626e-01f, -1.77435368e-01f,
  -9.68453214e-02f, -4.92813475e-02f, -2.13335007e-01f, -1.90116167e-01f, 1.27343476e-01f, -1.11493990e-01f, -2.64343619e-01f, -1.02162510e-01f, 6.59850314e-02f, 9.79700312e-03f,
  -1.04348294e-01f, 1.11647524e-01f, -6.80015907e-02f, 3.08607537e-02f, 1.12097427e-01f, 8.33606273e-02f, 7.16955110e-04f, 3.08671016e-02f, 2.15674993e-02f, 5.91481738e-02f,
  -6.73172027e-02f, 6.88829571e-02f, 2.70379242e-02f, -5.48230335e-02f, 4.60968614e-02f, 8.48694593e-02f, -3.24436910e-02f, -1.98194245e-03f, -5.82885370e-02f, -8.66687745e-02f,
  9.10938382e-02f, -6.47053355e-03f, 3.53735089e-02f, 6.75944611e-02f, -1.88380763e-01f, -2.41246432e-01f, 1.01109020e-01f, -3.84419262e-02f, -2.43938535e-01f, -5.93094192e-02f,
  -5.85239381e-02f, 2.71021407e-02f, 1.35102943e-01f, -4.84271348e-02f, -2.42535453e-02f, 1.27177499e-02f, -5.38430996e-02f, -1.84523195e-01f, -6.95619881e-02f, -1.29796371e-01f,
  5.99786378e-02f, 6.04463182e-02f, 9.91782472e-02f, 1.10924825e-01f, 1.13860220e-01f, 5.21312356e-02f, -4.11244929e-02f, -3.64034325e-02f, 1.47719443e-01f, 1.00994512e-01f,
  -1.10149346e-01f, -9.39053521e-02f, -1.67905226e-01f, 9.06398967e-02f, 1.55963391e-01f, 9.24038142e-03f, -1.32981092e-01f, -1.69895366e-01f, 3.71982949e-03f, 1.13835774e-01f,
  3.75108384e-02f, 1.30058482e-01f, -2.36439127e-02f, 1.16275072e-01f, -1.02689125e-01f, -1.36724040e-01f, -1.58609286e-01f, -6.90740421e-02f, 3.20544280e-02f, 1.10292815e-01f,
  1.75190531e-02f, -7.34827816e-02f, -1.56381473e-01f, 8.82460847e-02f, -6.57563610e-03f, -9.74036008e-02f, -1.39195636e-01f, -2.05532551e-01f, 7.88661838e-02f, 4.33198325e-02f,
  7.51689449e-02f, 1.92831263e-01f, -1.54152811e-01f, -9.75539535e-02f, -5.37147857e-02f, 1.00425571e-01f, 2.37172306e-01f, -9.92096215e-02f, 1.27925843e-01f, 2.39853427e-01f,
  -2.33538374e-02f, -6.21878915e-02f, -4.75833081e-02f, -1.39796391e-01f, 1.51829198e-01f, -2.29970783e-01f, 1.34125128e-01f, -2.31173962e-01f, 1.90607771e-01f, 2.09196717e-01f,
  5.35344072e-02f, -9.73261893e-02f, -1.70813441e-01f, -1.22795422e-02f, -8.26459751e-02f, -1.54066533e-01f, -3.44714671e-01f, -2.21473873e-02f, -5.58263734e-02f, 7.12516606e-02f,
  1.43188983e-01f, 6.10969774e-02f, 3.53200771e-02f, 3.45650874e-03f, -5.09814471e-02f, -6.24656640e-02f, -9.85255763e-02f, 1.62837848e-01f, 5.15153334e-02f, 1.72305167e-01f,
  2.50105590e-01f, -9.64516425e-04f, -5.34408800e-02f, -1.16680630e-01f, 1.77539796e-01f, -1.03797289e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.42634109e-01f, 1.95905373e-01f, -4.23660241e-02f, -2.21874239e-03f, 6.97825998e-02f, 2.28304774e-01f, 1.70110717e-01f, 1.13575883e-01f, 2.11993784e-01f, 9.16541815e-02f,
  -6.21687807e-02f, -7.80075463e-03f, 1.36245996e-01f, 5.79129271e-02f, -9.62228328e-02f, -5.14781736e-02f, 1.24382563e-01f, -2.97147296e-02f, 2.76299685e-01f, -1.22548111e-01f,
  6.10379539e-02f, -1.54066920e-01f, 2.07967665e-02f, -1.86576322e-01f, -2.20572408e-02f, 6.54201210e-02f, -1.54135257e-01f, 3.22187655e-02f, -2.64739851e-03f, 1.02271855e-01f,
  -2.59863790e-02f, -2.30644196e-01f, 1.15799718e-01f, -1.96475655e-01f, 6.23372085e-02f, -6.18136339e-02f, -1.29501177e-02f, -1.54960364e-01f, 1.78493634e-01f, -1.36188716e-01f,
  -2.18007624e-01f, 1.30358627e-02f, -6.82311058e-02f, 6.36260808e-02f, -4.07693759e-02f, 5.41927814e-02f, 8.53565037e-02f, 1.10458404e-01f, 1.60897940e-01f, -1.46744996e-01f,
  2.65426524e-02f, -1.84506029e-01f, -3.27983856e-01f, 8.51068050e-02f, 2.67780479e-02f, -1.80874184e-01f, 5.76166660e-02f, 5.22734299e-02f, -1.49177015e-01f, 1.57369703e-01f,
  1.83058694e-01f, -1.20670512e-01f, -1.40651226e-01f, 1.10324897e-01f, -1.01166159e-01f, 1.40643552e-01f, 2.03611314e-01f, -1.52972609e-01f, 1.89402714e-01f, 3.10551941e-01f,
  -2.56023463e-02f, 7.18947724e-02f, 6.79092258e-02f, 2.11398616e-01f, 1.64192080e-01f, 1.20242804e-01f, 2.03885406e-01f, -6.62747473e-02f, 6.78040981e-02f, 1.20752461e-01f,
  7.73295164e-02f, 7.28567690e-02f, 2.18787566e-01f, -1.23264931e-01f, 1.86468214e-01f, -1.19453862e-01f, 1.88366905e-01f, 1.66401103e-01f, -1.45307360e-02f, -1.47173954e-02f,
  2.50038225e-03f, -6.67977631e-02f, -1.92602798e-01f, -3.71202230e-02f, 5.46826348e-02f, 1.60294265e-01f, -3.51850092e-02f, -2.32020795e-01f, 4.44876663e-02f, -1.12397186e-01f,
  -1.72496662e-01f, -8.83135870e-02f, 9.08451453e-02f, -8.38208124e-02f, -9.93908793e-02f, -2.03714192e-01f, 1.75576821e-01f, 9.12114456e-02f, 2.08263934e-01f, -2.01849472e-02f,
  2.10507676e-01f, -2.97824927e-02f, 1.51495144e-01f, -2.26147715e-02f, -1.07442483e-01f, 5.28925657e-02f, -1.19147569e-01f, -1.61795095e-01f, -1.86640143e-01f, 1.63568720e-01f,
  5.55093735e-02f, 8.29499215e-02f, 1.23265460e-01f, 2.99678028e-01f, -4.07477617e-02f, 8.31945911e-02f, 1.92583278e-02f, 2.33112276e-01f, 2.56218493e-01f, -9.86017212e-02f,
  2.68858910e-01f, -2.05850415e-02f, 3.57195623e-02f, 3.53339389e-02f, 1.92076623e-01f, -3.00303977e-02f, 9.14634392e-02f, 3.98126878e-02f, 5.12008369e-02f, 1.22149989e-01f,
  1.62748266e-02f, 1.05468243e-01f, 1.02271609e-01f, 2.15829164e-01f, 1.62687764e-01f, -8.75230730e-02f, 1.22556373e-01f, -1.89922184e-01f, -3.16188224e-02f, 1.60548925e-01f,
  1.58000961e-01f, -7.28123561e-02f, -6.83807209e-02f, -1.24305062e-01f, 8.75658318e-02f, 2.52088130e-01f, -1.78048447e-01f, -9.16846916e-02f, 2.05939651e-01f, 1.92301467e-01f,
  -3.24399695e-02f, -1.72398522e-01f, -2.83440411e-01f, -3.78567353e-02f, 3.56525816e-02f, -1.11982226e-01f, 4.72746976e-02f, 7.53106400e-02f, 6.40345588e-02f, 2.13449858e-02f,
  -2.97440235e-02f, 5.37778959e-02f, 3.03310722e-01f, 1.30941486e-02f, 9.01987255e-02f, 1.41543031e-01f, 1.50227517e-01f, 1.16044924e-01f, -7.19464719e-02f, -3.67586501e-03f,
  1.10368237e-01f, -3.58749405e-02f, 1.90658182e-01f, -2.34230146e-01f, -3.33241071e-03f, 4.13456000e-03f, 7.45283887e-02f, 4.11023587e-01f, 7.62766153e-02f, -2.13157520e-01f,
  -7.25993216e-02f, 7.32140290e-03f, 8.65572095e-02f, 2.47976482e-01f, 6.72048852e-02f, 9.68524627e-03f, 1.31208569e-01f, 1.00351080e-01f, 8.64037499e-02f, 1.27035096e-01f,
  4.51721624e-02f, 1.73705921e-01f, 4.52786349e-02f, 2.16091737e-01f, 2.42461696e-01f, 2.90072169e-02f, 7.69935548e-02f, 6.29596412e-02f, 9.31107439e-03f, 2.91128512e-02f,
  1.73572585e-01f, 1.98101968e-01f, -1.10541619e-01f, 4.23061401e-02f, -9.23852846e-02f, 4.58914787e-02f, 1.34474456e-01f, 1.42150089e-01f, -1.87480617e-02f, -8.10107291e-02f,
  5.32809785e-03f, -1.85840711e-01f, -2.32448708e-02f, 1.49333119e-01f, -1.54189348e-01f, -2.54262090e-02f, -6.60186782e-02f, -1.77158281e-01f, 1.34043442e-02f, 7.81109259e-02f,
  3.51958424e-02f, -6.92918822e-02f, 6.88509420e-02f, -1.50322616e-02f, 1.61118716e-01f, -5.43094985e-02f, -6.26167580e-02f, -8.18698779e-02f, -1.10985436e-01f, -6.47283271e-02f,
  1.91928551e-01f, 2.34027490e-01f, -1.34871081e-01f, 3.01732033e-01f, -2.80940137e-03f, -5.78081273e-02f, 7.72067234e-02f, 1.52259842e-01f, 4.70837094e-02f, 2.47038249e-02f,
  2.95806080e-01f, 1.81880906e-01f, -2.23601505e-01f, -2.37902142e-02f, -6.02228902e-02f, -3.38458195e-02f, 1.37189642e-01f, 1.46831525e-03f, 3.06000710e-02f, 1.71309158e-01f,
  6.13668561e-02f, -1.01200067e-01f, 1.27501562e-01f, -4.57768589e-02f, 1.25185652e-02f, -1.10542746e-02f, -9.84068215e-02f, -2.48035789e-02f, -1.21275485e-01f, 5.46747632e-02f,
  1.14137277e-01f, 1.38232291e-01f, 1.13498606e-01f, -1.25588685e-01f, -8.00896212e-02f, 7.30528757e-02f, 4.12503369e-02f, -5.17195985e-02f, -2.00395852e-01f, -7.94416517e-02f,
  9.61826593e-02f, -1.39166713e-01f, 1.28929719e-01f, 1.23670384e-01f, -1.44549057e-01f, -2.04149351e-01f, 1.60486847e-02f, -1.40690103e-01f, 1.03485778e-01f, -5.29739782e-02f,
  -1.28856793e-01f, 2.10561916e-01f, 2.98490465e-01f, -2.32317939e-01f, 1.72488075e-02f, 2.61506945e-01f, -1.92812886e-02f, 2.15252653e-01f, -1.57324106e-01f, -6.02546521e-02f,
  -1.69220209e-01f, -1.30459324e-01f, -8.46747831e-02f, 2.93380380e-01f, 2.21383885e-01f, 1.27510786e-01f, -8.33888650e-02f, 5.19854389e-02f, 1.52107462e-01f, 8.84057432e-02f,
  2.13930458e-01f, 9.58618373e-02f, 3.46735790e-02f, 1.71282694e-01f, -2.88680103e-02f, 2.09470913e-01f, 3.10888350e-01f, -7.24534914e-02f, -8.08587149e-02f, -8.84019211e-02f,
  1.36484101e-01f, 8.76427349e-03f, 3.40729505e-02f, 1.48708969e-02f, -4.62597143e-03f, 5.50969429e-02f, -5.30368499e-02f, 1.84117436e-01f, -6.62139058e-02f, 1.74648613e-01f,
  1.82966024e-01f, 5.94445318e-02f, 4.90927175e-02f, 2.07383201e-01f, 5.89615516e-02f, 1.63264066e-01f, -6.89207837e-02f, 5.39723970e-02f, -3.08461431e-02f, 1.29420534e-01f,
  5.97219588e-03f, 2.35755756e-01f, 1.18254952e-01f, -1.24944523e-01f, -2.58816928e-01f, -2.18925159e-02f, 1.50857225e-01f, 2.53515780e-01f, 7.04339892e-02f, -5.34321517e-02f,
  2.19518960e-01f, 1.23466842e-01f, -4.20366637e-02f, 1.58906221e-01f, -8.80888477e-02f, 1.44607425e-01f, -3.53684247e-01f, 1.12709098e-01f, -2.34617405e-02f, 3.00132245e-01f,
  2.69913971e-02f, 2.07074344e-01f, -4.61962335e-02f, -4.98866476e-02f, 1.79407954e-01f, -2.12449208e-02f, -9.75691080e-02f, -1.05380662e-01f, 1.99829526e-02f, -1.24379255e-01f,
  1.25569224e-01f, 4.87575717e-02f, 2.92754263e-01f, 7.75694624e-02f, -3.07766348e-02f, -2.61488944e-01f, -1.04732186e-01f, -9.32019129e-02f, 5.32886460e-02f, 1.05815388e-01f,
  2.79146522e-01f, 1.30021632e-01f, 1.64285243e-01f, -2.49881878e-01f, 8.74644294e-02f, 2.44393155e-01f, 8.99934992e-02f, 9.13116634e-02f, 8.37451499e-03f, 2.88511783e-01f,
  2.05243602e-02f, 1.81460157e-01f, 2.63231367e-01f, 2.66351014e-01f, 1.57515138e-01f, 1.09525800e-01f, 2.61151075e-01f, -7.06460280e-03f, -1.28848916e-02f, 2.65784532e-01f,
  2.19499633e-01f, 2.19149768e-01f, 1.69770271e-01f, -2.14592636e-01f, 1.26084104e-01f, -1.09707572e-01f, -9.39621404e-02f, 1.65297911e-01f, -3.01310327e-02f, 1.37046114e-01f,
  1.75009575e-02f, -6.80107027e-02f, -2.45801695e-02f, 9.20894891e-02f, -1.91543505e-01f, 1.10471286e-01f, -6.93748519e-02f, -1.71155974e-01f, 8.12982395e-03f, -9.80261937e-02f,
  -2.09932048e-02f, 1.48019016e-01f, 3.65796295e-04f, -4.74198610e-02f, 5.32528237e-02f, -1.05805822e-01f, 9.09748077e-02f, 2.43251622e-01f, 8.82338136e-02f, 1.84899196e-01f,
  1.49519593e-01f, 1.17994733e-01f, 1.40149400e-01f, 5.61994053e-02f, -8.70879069e-02f, 2.60154530e-02f, -1.56892031e-01f, -6.01125732e-02f, -1.16515175e-01f, 2.09601358e-01f,
  2.63109654e-01f, 2.91425791e-02f, 1.85157552e-01f, 1.60394326e-01f, -1.24391899e-01f, 1.39969617e-01f, -1.68175370e-01f, 1.61039785e-01f, 1.84662759e-01f, 2.46531844e-01f,
  3.72524783e-02f, 1.75164148e-01f, 1.15672275e-01f, 1.65726766e-01f, -5.04491962e-02f, -5.72438631e-03f, 2.11358875e-01f, 9.24062729e-02f, 2.51149267e-01f, -4.72966246e-02f,
  3.73002850e-02f, 1.13383837e-01f, 1.35833561e-01f, 8.80904645e-02f, 1.64647698e-01f, 8.61907601e-02f, 1.30668923e-01f, 1.31535098e-01f, 1.75780505e-01f, 2.05690473e-01f,
  -8.55886564e-02f, 1.26596093e-01f, -2.33321965e-01f, -1.27804594e-03f, 1.07727081e-01f, 1.08208172e-01f, 2.85082579e-01f, 1.13462254e-01f, -3.18730436e-02f, 1.05453663e-01f,
  -1.29416734e-02f, 3.52207720e-01f, -3.48860398e-02f, 1.04943000e-01f, -2.32909014e-03f, 2.78056532e-01f, 4.04007472e-02f, 2.67128609e-02f, 1.05652727e-01f, 2.40423992e-01f,
  2.13172793e-01f, -1.89420134e-01f, 2.60564163e-02f, -5.60664833e-02f, 2.43714191e-02f, -2.98985898e-01f, -1.20677277e-01f, -6.85650185e-02f, 8.08073804e-02f, 1.47949278e-01f,
  3.50228637e-01f, 1.20498389e-01f, -1.01995945e-01f, 1.75948292e-01f, -1.51157379e-02f, 1.57759920e-01f, 1.57617524e-01f, -2.00480476e-01f, 1.35117784e-01f, 3.38582128e-01f,
  3.15621644e-01f, -1.77351922e-01f, 4.57516313e-02f, 6.86854720e-02f, 3.27335820e-02f, 2.57817298e-01f, 1.61061376e-01f, -4.14076634e-02f, -5.62607497e-02f, 2.06760809e-01f,
  9.26460996e-02f, 1.90218985e-01f, 2.46649534e-01f, -7.60094225e-02f, 1.05673559e-01f, 1.58875793e-01f, 1.01262555e-01f, 1.43886730e-01f, -6.59952313e-02f, 8.75892341e-02f,
  1.13963135e-01f, 5.41514345e-02f, 3.21613736e-02f, 2.21952468e-01f, -1.01837389e-01f, -4.28240746e-02f, -2.97272652e-01f, -2.41857376e-02f, 3.96290757e-02f, 1.08021483e-01f,
  2.21397325e-01f, 5.26764691e-02f, 1.87700048e-01f, 1.57847449e-01f, -5.76041453e-02f, 2.79891789e-01f, -1.25032412e-02f, 2.21654594e-01f, -1.10158220e-01f, 2.07631197e-02f,
  -1.12518802e-01f, 2.91628748e-01f, 2.14416496e-02f, 2.21213132e-01f, 2.12930903e-01f, -9.98643041e-02f, 9.87075120e-02f, 7.36409947e-02f, -1.07728809e-01f, -1.07323036e-01f,
  -2.27214918e-01f, -2.01803565e-01f, 1.32518858e-01f, -1.94954481e-02f, 7.69604445e-02f, 1.13983452e-01f, -3.10469896e-01f, -1.70258984e-01f, -2.50289351e-01f, -5.29490132e-03f,
  -1.61282167e-01f, -2.01780707e-01f, 3.89039256e-02f, 3.05590332e-01f, 1.82810038e-01f, -1.78674534e-01f, -8.23583975e-02f, 1.17434800e-01f, -6.51375279e-02f, 5.66006042e-02f,
  -4.29801233e-02f, 7.33989850e-02f, 1.93216100e-01f, 2.10781828e-01f, 2.35704958e-01f, 8.05250555e-02f, 1.58018366e-01f, 1.72954768e-01f, -6.26201332e-02f, 1.63980678e-01f,
  -5.84869795e-02f, 8.90560672e-02f, -8.46342742e-03f, 1.72443137e-01f, 3.12312841e-02f, -2.33104993e-02f, 1.88901320e-01f, -1.89905360e-01f, 5.07670194e-02f, -6.69637322e-02f,
  3.27873044e-02f, 7.54142995e-04f, -8.83515850e-02f, -1.17675252e-01f, 2.88194239e-01f, 6.13968857e-02f, -2.79227465e-01f, 1.22033283e-01f, -1.56285688e-02f, 1.56333864e-01f,
  2.18836978e-01f, 2.87644453e-02f, -9.04484913e-02f, 5.91465458e-02f, -8.09159800e-02f, -2.89380271e-02f, 1.68215409e-02f, -1.57655329e-01f, 1.71215951e-01f, 1.02974959e-01f,
  -5.62174208e-02f, 1.46797299e-01f, -5.85136265e-02f, -9.39164087e-02f, -1.87874269e-02f, 3.63129042e-02f, 1.32911634e-02f, 1.01853885e-01f, 3.09976544e-02f, -1.06564932e-01f,
  -2.14777276e-01f, 1.56735390e-01f, 1.60141051e-01f, -8.16854760e-02f, -6.25555888e-02f, -3.64290103e-02f, -9.47979987e-02f, 3.19130242e-01f, 1.18494444e-01f, 7.08612204e-02f,
  5.42798825e-02f, 1.14364348e-01f, -5.37999049e-02f, 2.24481657e-01f, 1.17183074e-01f, 1.37568280e-01f, 2.42917210e-01f, 1.33710995e-01f, 2.41343662e-01f, 1.55087216e-02f,
  3.72611023e-02f, 4.64447476e-02f, 2.75484398e-02f, 4.19309549e-02f, 1.14986263e-01f, -1.83731645e-01f, -1.57395992e-02f, 2.54339486e-01f, 2.21646845e-01f, 2.70596966e-02f,
  -1.32896043e-02f, -2.24298000e-01f, -5.49256010e-03f, -2.01449275e-01f, -3.88638262e-04f, -1.09761611e-01f, -1.85248211e-01f, 7.45697469e-02f, 1.92070752e-01f, 2.03798085e-01f,
  -2.29373246e-01f, -2.00183943e-01f, 6.88947812e-02f, -1.94953278e-01f, 2.64907241e-01f, -1.93079114e-01f, 1.79663450e-01f, 6.46544620e-02f, -1.22954072e-02f, -1.57071739e-01f,
  -5.53213991e-02f, 6.30966350e-02f, 7.73858931e-03f, 7.97548592e-02f, -1.52582198e-01f, 1.53075326e-02f, 1.90152481e-01f, 1.14307396e-01f, 5.00554331e-02f, 5.66614093e-03f,
  2.23409668e-01f, 2.83461809e-03f, -3.44242692e-01f, -1.08163888e-02f, -1.41041219e-01f, 1.07438877e-01f, 1.95216894e-01f, 2.30894178e-01f, 6.24023117e-02f, 1.36888146e-01f,
  1.46698058e-01f, 1.35565609e-01f, 1.98371127e-01f, 2.28315648e-02f, 1.79732189e-01f, 6.54869229e-02f, 1.90727144e-01f, 1.44451737e-01f, 6.28239363e-02f, -1.29385702e-02f,
  5.55703342e-02f, 2.15353489e-01f, 1.51609614e-01f, -1.22292280e-01f, 1.01952635e-01f, 6.26718327e-02f, -3.01838983e-02f, 1.91247508e-01f, 2.11580306e-01f, -1.55503273e-01f,
  8.54705125e-02f, 1.34209424e-01f, 9.83818546e-02f, -4.55396473e-02f, -2.72360861e-01f, 1.84973136e-01f, -1.20257601e-01f, 3.64822820e-02f, 2.46280327e-01f, -2.94915825e-01f,
  2.03800455e-01f, 2.65803456e-01f, -2.72155732e-01f, -4.22142670e-02f, 1.35111853e-01f, -6.02963902e-02f, 9.13969949e-02f, 3.21682878e-02f, -4.09022905e-02f, -1.94884986e-01f,
  1.50179252e-01f, 1.15948327e-01f, -1.46409303e-01f, -5.50916344e-02f, 4.32124652e-04f, -3.02973166e-02f, -5.62654324e-02f, -5.32002859e-02f, -5.47768269e-03f, -5.74581102e-02f,
  2.62448955e-02f, 4.54940386e-02f, 2.73685604e-01f, 8.01300928e-02f, 1.21812977e-01f, 5.86579703e-02f, 3.22924778e-02f, 5.42110950e-03f, 3.79570663e-01f, 2.03068908e-02f,
  -1.63343653e-01f, 1.81743667e-01f, 3.05426922e-02f, 2.30476111e-01f, 6.36444911e-02f, -3.33501250e-02f, 1.51982203e-01f, -1.68676019e-01f, -7.36032128e-02f, -8.24792683e-03f,
  6.94331080e-02f, -1.29570141e-01f, 4.96870466e-02f, 1.38056979e-01f, 9.38455164e-02f, -3.54869664e-02f, -8.18878338e-02f, 1.91533908e-01f, -7.32128471e-02f, 8.69008750e-02f,
  1.07406508e-02f, -1.11425452e-01f, 9.04679224e-02f, 1.59802884e-01f, 1.26362324e-01f, -6.27013966e-02f, 1.56900764e-01f, -6.37049451e-02f, 2.21410096e-02f, 4.34604138e-02f,
  3.54709119e-01f, -1.84707686e-01f, 1.48187950e-02f, 2.47692987e-01f, -1.08231232e-01f, -2.11740881e-01f, -2.07459256e-01f, 2.54171025e-02f, 1.97311908e-01f, 4.69733365e-02f,
  -1.23082206e-01f, -7.00132921e-02f, -2.56728977e-01f, 2.23300382e-01f, -9.23425779e-02f, -3.34541768e-01f, 9.73613709e-02f, 2.65028197e-02f, -6.86084181e-02f, -1.22379940e-02f,
  -2.30207860e-01f, 5.13217933e-02f, 3.56302977e-01f, 2.32252494e-01f, 1.57331899e-01f, -1.74216349e-02f, -1.86961487e-01f, -1.77109525e-01f, 4.30717468e-02f, -5.81133850e-02f,
  1.39195710e-01f, 5.84593751e-02f, 4.73245569e-02f, -2.97725707e-01f, 1.30853593e-01f, -9.10665542e-02f, -1.46344816e-02f, 1.78991467e-01f, 3.24302346e-01f, 2.00653933e-02f,
  -5.72532825e-02f, -4.20018211e-02f, -9.35412794e-02f, 3.69057320e-02f, 1.54279113e-01f, -7.47928321e-02f, -1.10992203e-02f, 2.10396647e-01f, 1.75945759e-01f, 1.31874263e-01f,
  1.02397054e-01f, 1.49705186e-01f, -6.07689247e-02f, 4.37626289e-03f, -4.38483171e-02f, 5.97177669e-02f, 1.34985939e-01f, 1.26543999e-01f, 6.72283918e-02f, 8.15027207e-02f,
  1.97269291e-01f, -2.43894994e-01f, 1.58353552e-01f, -1.18042052e-01f, 1.08449824e-01f, -1.63993761e-01f, 6.27390146e-02f, 1.74543932e-01f, -1.34763852e-01f, -7.08481818e-02f,
  -2.06864357e-01f, -6.52719364e-02f, 1.59504518e-01f, -1.18265204e-01f, 7.48482198e-02f, -1.15812838e-01f, -1.78501830e-01f, -1.18763924e-01f, -1.90873504e-01f, -2.20466986e-01f,
  1.73387617e-01f, 1.08077815e-02f, -4.96460162e-02f, -1.70084074e-01f, -1.70584500e-01f, 8.54925141e-02f, 1.74190983e-01f, 1.50763735e-01f, 1.27020344e-01f, 1.56773493e-01f,
  -1.18149765e-01f, -5.75372279e-02f, -5.71823679e-02f, -1.55557454e-01f, -5.77712283e-02f, 5.17728925e-02f, -4.36063781e-02f, -2.58389622e-01f, 1.31720558e-01f, -9.65486169e-02f,
  1.68262934e-03f, 1.60500303e-01f, 4.31996994e-02f, -4.36907560e-02f, -8.33353251e-02f, 1.45598158e-01f, -1.00345924e-01f, 1.46183684e-01f, 1.45352587e-01f, 1.99728936e-01f,
  1.95559725e-01f, 2.57015288e-01f, 1.99459836e-01f, 1.05414085e-01f, 2.09112331e-01f, 9.10615101e-02f, 1.97253153e-02f, 2.22602159e-01f, 1.17933013e-01f, 4.58041988e-02f,
  5.53036965e-02f, 2.12656304e-01f, 8.05786401e-02f, 1.39179483e-01f, 2.31673673e-01f, -8.07806849e-02f, 3.26729901e-02f, -2.50174589e-02f, 5.39300404e-02f, 2.13193402e-01f,
  5.17736785e-02f, 1.10021807e-01f, -4.59102839e-02f, -1.14590660e-01f, -1.07016601e-01f, 4.25847434e-02f, 3.00423093e-02f, 1.20319806e-01f, -6.67227954e-02f, -2.37435549e-01f,
  4.01422055e-03f, -2.00771287e-01f, -1.57144770e-01f, 1.25244811e-01f, 7.48228803e-02f, -1.35482147e-01f, -1.27189487e-01f, -1.53786689e-01f, 2.60144740e-01f, 1.71615735e-01f,
  -4.42528948e-02f, 1.07590862e-01f, 8.25586691e-02f, 2.94377171e-02f, -5.66599071e-02f, 2.67894089e-01f, -1.60980001e-02f, 2.49571756e-01f, -6.94050193e-02f, -1.30184129e-01f,
  -2.66947597e-01f, 2.22490996e-01f, 1.48428112e-01f, 1.19881377e-01f, 1.56231076e-01f, 9.41480771e-02f, -1.57444760e-01f, -3.22153047e-02f, 9.72542213e-04f, 1.18063353e-01f,
  -9.16440226e-03f, -1.57535616e-02f, -5.58988601e-02f, 1.38506681e-01f, 1.54635996e-01f, -2.65509523e-02f, 1.78246200e-01f, 8.58523231e-03f, 1.59684718e-01f, 1.06353723e-01f,
  5.36596887e-02f, 1.36935845e-01f, -6.88193589e-02f, -1.94425061e-02f, 4.03531641e-02f, 2.85507459e-02f, 1.26859233e-01f, 9.80912298e-02f, 2.06170246e-01f, 7.23078847e-02f,
  1.30319580e-01f, -1.81017905e-01f, -1.80951133e-01f, -5.92690222e-02f, -1.49784341e-01f, -1.16441641e-02f, -1.62779197e-01f, 2.02331737e-01f, 2.11808130e-01f, 5.26709408e-02f,
  -2.25882754e-01f, -2.41664931e-01f, 2.17379361e-01f, -4.80290428e-02f, 2.17219114e-01f, 2.97324657e-02f, 8.53596479e-02f, -4.81511243e-02f, 1.42666325e-01f, 1.25435188e-01f,
  -9.97428522e-02f, 9.56299827e-02f, -2.37454638e-01f, 7.94691145e-02f, -3.14347863e-01f, -4.04902846e-02f, 1.47104606e-01f, 3.11197340e-01f, 3.08506340e-02f, -1.09331876e-01f,
  2.83470213e-01f, -2.38929883e-01f, -1.67437792e-01f, 1.75056353e-01f, 5.14192432e-02f, -7.14769512e-02f, 9.96480733e-02f, 3.14452574e-02f, 7.49858245e-02f, -1.33841159e-02f,
  2.08437786e-01f, -6.95334449e-02f, 2.04860829e-02f, -5.02827503e-02f, 1.34568080e-01f, 2.24886507e-01f, 1.56795040e-01f, 1.69089928e-01f, 1.59684606e-02f, -1.68498289e-02f,
  5.82910329e-02f, 1.28454193e-01f, 7.08655342e-02f, 1.34124503e-01f, 1.30253196e-01f, -4.45705503e-02f, 8.70464742e-02f, 5.71875945e-02f, 2.24450648e-01f, -5.61938249e-02f,
  1.78838432e-01f, 1.82416961e-01f, 5.56840524e-02f, 1.09883025e-01f, -2.27394015e-01f, 2.38457948e-01f, -9.47222635e-02f, 1.30467400e-01f, -7.87566379e-02f, -9.45392922e-02f,
  1.44222692e-01f, 3.06976616e-01f, -8.58564675e-02f, -6.24528453e-02f, 7.49978796e-02f, 1.84198856e-01f, 6.47271276e-02f, 1.16989933e-01f, -2.24963203e-02f, -1.56923771e-01f,
  3.04229446e-02f, 1.58585757e-01f, -1.37093425e-01f, -7.85498321e-02f, 2.33203992e-01f, 1.57467157e-01f, -1.66872106e-02f, -4.73214947e-02f, 1.07027128e-01f, -5.76296560e-02f,
  1.86734274e-02f, -1.20982699e-01f, 3.07953984e-01f, 1.76975846e-01f, 2.11129874e-01f, 1.94737203e-02f, 2.00489834e-01f, -6.19781911e-02f, 1.54796064e-01f, 2.01441064e-01f,
  -1.32493779e-01f, 1.17573060e-01f, 1.10818096e-01f, 2.30512619e-01f, -3.51965576e-02f, -1.52039871e-01f, 2.27095976e-01f, -4.72008437e-02f, -5.14288023e-02f, 2.49667451e-01f,
  1.30155757e-01f, 1.25156760e-01f, 1.22741520e-01f, 1.96203887e-01f, 1.44038096e-01f, 1.05419099e-01f, 2.35954657e-01f, 3.91177647e-02f, 1.36028498e-01f, 5.12461886e-02f,
  1.87877730e-01f, -8.63762572e-03f, 9.15673301e-02f, -8.32276419e-03f, 9.41528007e-02f, 1.98539376e-01f, 1.17177583e-01f, -2.16553271e-01f, 1.07016452e-01f, -1.68365330e-01f,
  -5.97298965e-02f, 6.88773245e-02f, -1.33513644e-01f, 9.85914022e-02f, -6.03439920e-02f, -3.06870282e-01f, 2.14112643e-02f, 1.34744160e-02f, -7.64600337e-02f, -1.41641386e-02f,
  -9.66547057e-03f, 1.13412485e-01f, -4.39581648e-02f, 2.55046599e-02f, 1.92216616e-02f, 1.08707361e-01f, 7.18109906e-02f, -1.14516303e-01f, -5.11166267e-02f, -1.71466351e-01f,
  3.23013693e-01f, 1.91649422e-01f, 2.01538997e-03f, 2.91859686e-01f, -4.77300696e-02f, 3.22462358e-02f, -1.41791210e-01f, 1.50280679e-02f, 5.10603003e-02f, 1.46238938e-01f,
  -1.19439177e-01f, -1.66095570e-01f, -2.35352084e-01f, 1.27776444e-01f, 1.95394605e-01f, -4.47196700e-02f, -7.28758648e-02f, -1.15027711e-01f, -1.34756252e-01f, 3.09669107e-01f,
  -3.73076648e-03f, 3.38976741e-01f, 2.09980354e-01f, -4.95810956e-02f, -1.27590045e-01f, 2.48844057e-01f, 3.46005820e-02f, -2.41452996e-02f, 2.38058772e-02f, -4.26364020e-02f,
  6.44757971e-02f, -2.14501973e-02f, -5.51175289e-02f, 5.23106866e-02f, -3.20986025e-02f, 1.02024652e-01f, 1.58019394e-01f, 3.46549600e-03f, 5.80008328e-02f, 9.94304195e-02f,
  4.08549001e-03f, -2.34242398e-02f, 2.78983235e-01f, -1.70041785e-01f, -4.95620146e-02f, -3.14088129e-02f, 1.72763411e-02f, 4.44983225e-03f, -8.73402804e-02f, 1.61348641e-01f,
  3.32339436e-01f, 2.50865132e-01f, -1.44705266e-01f, -2.14804754e-01f, -3.33824828e-02f, -4.36899140e-02f, 2.89350241e-01f, 9.03400779e-02f, -6.71230927e-02f, -1.82132598e-03f,
  1.84106603e-01f, 1.45096347e-01f, 6.80306852e-02f, 1.41254184e-03f, 6.48185909e-02f, 1.37243733e-01f, -3.37505788e-01f, 1.95156693e-01f, -1.05565220e-01f, 2.07497537e-01f,
  -2.00189114e-01f, -4.94293571e-02f, 9.70294774e-02f, -1.16651721e-01f, -1.31213642e-03f, 1.46214232e-01f, 3.04866340e-02f, -6.80280402e-02f, 1.09606758e-01f, -4.07801569e-02f,
  -1.61416188e-01f, -1.60461023e-01f, 5.75150326e-02f, 2.87980020e-01f, -4.56203595e-02f, 3.95160653e-02f, -3.85513739e-03f, 1.07307360e-01f, 6.57162592e-02f, -1.88835651e-01f,
  1.10318130e-02f, 2.41852716e-01f, 8.48746896e-02f, -6.07806817e-02f, 1.20913148e-01f, 1.52071044e-01f, 1.26319155e-01f, 7.94862136e-02f, -3.15461308e-02f, 2.66124681e-02f,
  1.60008758e-01f, 7.04227313e-02f, 8.66967663e-02f, -6.58756569e-02f, 2.44791299e-01f, -2.40657285e-01f, 2.12596208e-02f, -1.55093208e-01f, 2.64469087e-01f, -1.03853844e-01f,
  9.93582457e-02f, -2.49460572e-03f, -1.15934111e-01f, -2.92801946e-01f, -5.87465316e-02f, 3.35273333e-02f, -2.82722395e-02f, -6.36677966e-02f, 1.27556100e-01f, -1.41326666e-01f,
  -1.17151298e-01f, -1.69089586e-02f, -1.73880517e-01f, -2.24283978e-01f, -6.71444647e-03f, -2.01834235e-02f, -4.45176056e-03f, -2.44619012e-01f, -1.51275352e-01f, 9.26048607e-02f,
  3.13876063e-01f, 2.02027217e-01f, 2.53056318e-01f, 1.80041954e-01f, 6.69867918e-02f, -1.71790987e-01f, -1.17277816e-01f, -9.31660086e-02f, -2.38601267e-01f, -5.00603914e-02f,
  -2.37507373e-01f, -2.26577535e-01f, 1.03318922e-01f, 3.05296890e-02f, -1.77742213e-01f, 2.35661089e-01f, 2.83192042e-02f, -2.10707448e-02f, -2.13441905e-02f, 2.00004578e-01f,
  1.84679911e-01f, 1.31111182e-02f, 4.29548696e-02f, 2.98326284e-01f, 2.00492218e-01f, 1.59044832e-01f, 4.57652621e-02f, 7.78857842e-02f, 2.28991359e-01f, 1.72086254e-01f,
  1.01791307e-01f, 1.36118844e-01f, 4.36776988e-02f, 1.44065022e-01f, -5.88174239e-02f, 3.23547088e-02f, 1.18838973e-01f, 1.85601413e-01f, 1.60060659e-01f, 5.13560735e-02f,
  2.68626302e-01f, 1.30233809e-03f, -1.65302247e-01f, -1.06513366e-01f, -2.99123168e-01f, 2.62092985e-02f, -2.45424137e-01f, 1.13825172e-01f, 2.28201523e-01f, 9.12985802e-02f,
  -1.11203097e-01f, -1.94004215e-02f, -5.21427765e-02f, 9.32417586e-02f, 3.90345007e-02f, 2.08593279e-01f, -4.59548347e-02f, -2.04196889e-02f, 2.32031107e-01f, 2.85911411e-01f,
  -2.37357784e-02f, 2.44054943e-01f, 2.09840685e-02f, 1.95648037e-02f, -2.33990788e-01f, 2.87762396e-02f, 9.77063179e-02f, 7.37959659e-03f, -2.86560804e-01f, -6.61012977e-02f,
  3.44154835e-02f, 1.23329401e-01f, 1.23483129e-01f, 2.24721730e-01f, -6.11146837e-02f, 6.46501258e-02f, 1.65783629e-01f, -4.00729254e-02f, -5.67919090e-02f, -1.19888812e-01f,
  1.10937648e-01f, 3.39156449e-01f, -1.26010865e-01f, -1.15044065e-01f, 1.10565320e-01f, 1.56667694e-01f, -3.12635442e-03f, 2.71916986e-01f, -2.32470129e-02f, 1.39781609e-01f,
  1.35795176e-01f, 1.64442405e-01f, 1.35677084e-01f, 1.35904878e-01f, -2.23441478e-02f, -5.08410260e-02f, -7.05181761e-03f, 2.37614796e-01f, 2.62611777e-01f, 1.25684604e-01f,
  1.96647108e-01f, 7.23140985e-02f, 3.94188333e-03f, 8.25776830e-02f, -1.02873638e-01f, 1.49469316e-01f, 3.71047892e-02f, -1.03502870e-01f, -1.32859096e-01f, -2.09427774e-01f,
  1.86539948e-01f, 5.88997677e-02f, 1.64312422e-01f, -1.02150729e-02f, 4.87840595e-03f, 1.13349162e-01f, -9.46359038e-02f, 4.17246856e-03f, 1.10034697e-01f, 6.91251084e-02f,
  8.45488459e-02f, 1.94827333e-01f, 6.70503534e-04f, 2.39377812e-01f, 1.80834383e-01f, 1.56799912e-01f, 1.26884162e-01f, -6.24957159e-02f, -1.95089728e-01f, -1.37171924e-01f,
  -1.07129499e-01f, -1.95137262e-02f, 1.37630180e-01f, 1.46843538e-01f, 2.03386664e-01f, 1.05494045e-01f, 3.15940052e-01f, 1.08525366e-01f, 8.85748789e-02f, 1.04447864e-01f,
  9.52639282e-02f, 4.55679856e-02f, 2.47845992e-01f, 9.03586000e-02f, -1.17477635e-02f, 1.77954242e-01f, 1.43395320e-01f, -4.00086194e-02f, 4.61962223e-02f, 3.24867904e-01f,
  1.91612676e-01f, 2.98802108e-01f, 2.65577108e-01f, 2.65335977e-01f, 2.99373806e-01f, 2.09507599e-01f, 3.11730474e-01f, 1.77615732e-01f, 1.86260507e-01f, 2.58035511e-01f,
  7.69705623e-02f, 2.88905472e-01f, 1.85163736e-01f, 2.37197146e-01f, 1.83283538e-01f, 2.30502442e-01f, 2.26823717e-01f, 1.28853396e-01f, -7.70039186e-02f, 1.14104144e-01f,
  -1.74547464e-01f, 4.32132483e-02f, -7.48254312e-03f, -2.15326339e-01f, 1.54232845e-01f, -9.01619717e-03f, -9.35924351e-02f, 4.22320962e-02f, 1.78271197e-02f, 2.87666600e-02f,
  -1.75212100e-01f, -5.68660013e-02f, -1.50440559e-01f, -1.44904956e-01f, 6.75746650e-02f, 2.74105161e-01f, -1.03201210e-01f, 2.53723543e-02f, 1.49978220e-01f, 1.56110719e-01f,
  2.81656861e-01f, 1.85913786e-01f, 2.23321050e-01f, -2.30558813e-02f, -7.96392709e-02f, 1.55595332e-01f, 2.32499361e-01f, 2.86929280e-01f, 5.43809049e-02f, 7.33422413e-02f,
  2.47910231e-01f, -1.16218999e-01f, 2.63301115e-02f, 2.79412657e-01f, -4.03392464e-02f, 2.49447241e-01f, 1.74848482e-01f, 2.29602724e-01f, -1.72519177e-01f, 1.07520983e-01f,
  7.90524483e-02f, 7.88113549e-02f, 1.36190742e-01f, 6.64992407e-02f, 8.95763040e-02f, 1.00189231e-01f, 9.07859951e-02f, 1.74652904e-01f, 3.56730185e-02f, 1.60076052e-01f,
  8.71461257e-02f, -3.11096571e-02f, 1.02568083e-01f, -1.10430203e-01f, -8.42023566e-02f, 1.48134068e-01f, -4.96930405e-02f, -1.23100884e-01f, -1.03544280e-01f, 1.16141975e-01f,
  8.15222189e-02f, 1.25972256e-01f, 1.14991240e-01f, -6.56005219e-02f, -1.34259731e-01f, -1.83319330e-01f, 2.43868344e-02f, -2.07168192e-01f, -1.41797885e-01f, 2.32525438e-01f,
  1.31098881e-01f, 2.12191138e-02f, -1.50068656e-01f, -2.23282650e-01f, 1.07316449e-01f, 1.06132045e-01f, 1.92955479e-01f, -1.14525229e-01f, 1.18119549e-03f, 2.33751327e-01f,
  8.72374922e-02f, 5.82477637e-02f, -1.55250683e-01f, -5.53994142e-02f, -1.59293637e-01f, 3.29566486e-02f, -1.09682128e-01f, 7.55827948e-02f, 2.56795764e-01f, -2.17203647e-02f,
  1.49053290e-01f, -6.32940084e-02f, 3.02074254e-01f, -1.94309801e-01f, -1.41031116e-01f, 3.58955413e-02f, -1.10978574e-01f, 1.54675364e-01f, -2.93354522e-02f, -1.09395189e-02f,
  -3.20135131e-02f, -5.15877791e-02f, -8.83249044e-02f, -6.17073476e-02f, 2.58042544e-01f, -3.62714976e-02f, 1.96551114e-01f, 3.07624396e-02f, -9.60815996e-02f, 3.95709351e-02f,
  2.37344503e-01f, 5.54651357e-02f, 5.53290583e-02f, 1.27148658e-01f, -6.53558969e-02f, -4.13443632e-02f, 1.40237853e-01f, -1.75345447e-02f, 1.29311994e-01f, 8.41293707e-02f,
  1.59200460e-01f, 1.47607014e-01f, 8.42304155e-02f, 1.07440956e-01f, 2.00247229e-03f, -2.55143315e-01f, 9.85188186e-02f, -1.39426142e-01f, 1.37754157e-01f, -9.68219712e-02f,
  1.92449950e-02f, -1.13764647e-02f, -2.06456646e-01f, 9.19993967e-02f, 1.19607694e-01f, 1.22907586e-01f, -2.89074425e-02f, 1.05120495e-01f, 1.17586195e-01f, -1.29066110e-01f,
  1.03427716e-01f, -9.26643424e-03f, -2.19370261e-01f, -1.13510214e-01f, 2.55501628e-01f, 2.15725690e-01f, 2.06560120e-02f, 1.87976450e-01f, -7.06001222e-02f, 1.89716160e-01f,
  1.78526774e-01f, 1.15725718e-01f, -1.65667143e-02f, 1.70925379e-01f, -6.28086627e-02f, -1.13958590e-01f, 4.94649410e-02f, -1.18097007e-01f, 1.55997783e-01f, 6.43879771e-02f,
  6.84052333e-02f, -2.96366423e-01f, 2.25001708e-01f, -9.57361609e-03f, -7.90657476e-02f, -1.95416845e-02f, 7.62788728e-02f, 8.19023326e-02f, -9.08820778e-02f, 1.14922643e-01f,
  1.61810338e-01f, 5.36940433e-02f, 1.20648228e-01f, 4.92201373e-02f, -1.87780447e-02f, -2.48735156e-02f, 7.44005293e-02f, 1.53357729e-01f, 8.91015604e-02f, 1.16257742e-01f,
  -2.99453270e-02f, -4.90390882e-03f, -6.77085221e-02f, 9.42157879e-02f, 1.13845244e-02f, -2.66794674e-03f, 1.58371389e-01f, 1.20783754e-01f, 1.14863537e-01f, 1.44330487e-01f,
  1.10564649e-01f, 9.54739153e-02f, -1.56207532e-02f, -1.25117317e-01f, -1.50045007e-01f, -1.84953853e-01f, -6.73463494e-02f, 1.86296120e-01f, 1.37508139e-01f, -4.40337211e-02f,
  4.95927557e-02f, -2.33232617e-01f, 2.77092397e-01f, 6.40352964e-02f, -6.82447627e-02f, -1.18284695e-01f, 1.91775113e-01f, -1.09439589e-01f, 1.90500095e-01f, 2.58380920e-01f,
  -1.35023117e-01f, 2.30452418e-01f, -4.04359549e-02f, 3.61495912e-02f, -1.63514018e-01f, -1.38492703e-01f, 5.02839759e-02f, 2.86149293e-01f, 7.12089688e-02f, -1.92070290e-01f,
  1.26801878e-01f, -1.37330890e-01f, 2.87609957e-02f, 8.42216685e-02f, 1.50270417e-01f, 1.26322314e-01f, -1.52114064e-01f, 1.06293820e-01f, 2.18451279e-03f, -6.76468089e-02f,
  1.56896397e-01f, -1.43853724e-01f, 2.87121721e-02f, -1.46794423e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -1.63222626e-02f, 1.50678888e-01f, 2.25543585e-02f, 1.84468806e-01f, -2.98460461e-02f, 7.59016275e-02f, 1.23065703e-01f, 1.84257418e-01f, 1.68785989e-01f, 1.34101048e-01f,
  1.87765852e-01f, 1.11215614e-01f, 1.13507144e-01f, 1.41552061e-01f, 1.19159790e-02f, 5.63649982e-02f, 1.76965952e-01f, 9.15582553e-02f, 1.28050342e-01f, 1.15700997e-01f,
  2.22784474e-01f, 3.61856855e-02f, 3.06766987e-01f, -3.34579088e-02f, 9.07553360e-02f, 1.31536469e-01f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -4.23805714e-02f, 1.71926901e-01f, 6.42615408e-02f, 1.48693891e-02f, 2.63669863e-02f, 1.26582399e-01f, -6.09891340e-02f, -2.05168739e-01f, 1.48091570e-01f, -6.33233739e-03f,
  -4.00060900e-02f, -1.33774113e-02f, -6.22057021e-02f, 8.75096321e-02f, 4.88460623e-02f, 1.37253106e-01f, 7.54189268e-02f, 3.68303694e-02f, 7.90826306e-02f, 1.46523610e-01f,
  2.08133191e-01f, -2.20389113e-01f, 1.74039692e-01f, 1.88060328e-01f, 4.50255163e-02f, -9.06151012e-02f, 1.60673842e-01f, -6.60843104e-02f, -2.22279623e-01f, -2.88611855e-02f,
  1.24810189e-02f, 5.21299914e-02f, 2.28194594e-01f, -2.65859663e-01f, -4.48418260e-02f, 4.41818535e-02f, -1.06254339e-01f, -2.50543296e-01f, -1.69214740e-01f, -7.67118335e-02f,
  -1.70584340e-02f, 9.51044485e-02f, 2.10113451e-02f, -9.31773782e-02f, 1.29418448e-01f, 6.05498068e-02f, -1.07521765e-01f, 7.21528977e-02f, 7.31403474e-03f, 5.61035946e-02f,
  -4.34042327e-02f, -1.22180663e-01f, 7.93635994e-02f, -2.29863096e-02f, 1.10383041e-01f, 8.45220312e-02f, -3.29448208e-02f, -1.08476400e-01f, 3.30629982e-02f, 1.33161154e-02f,
  -2.22822614e-02f, -2.02129886e-01f, -8.11070725e-02f, -1.61008209e-01f, -1.24572866e-01f, 3.91379520e-02f, -1.32777840e-01f, -5.29867923e-03f, 1.83049887e-02f, 1.34482235e-01f,
  1.52606983e-02f, -6.10620230e-02f, -4.48925607e-02f, 1.43485308e-01f, 1.14000499e-01f, 6.61220178e-02f, 3.35937291e-02f, -4.31536213e-02f, 1.60669144e-02f, -6.76330775e-02f,
  -6.45187125e-02f, -1.26888463e-02f, -1.93780333e-01f, 1.15776703e-01f, 1.00887671e-01f, 2.11215243e-02f, 1.09414898e-01f, 6.61296919e-02f, 6.57963753e-02f, -5.98930940e-02f,
  -1.79761127e-01f, -5.59990071e-02f, -1.55796343e-02f, -2.38613665e-01f, -3.20372172e-02f, 2.30931163e-01f, -2.75797807e-02f, -1.75579521e-03f, 6.84602857e-02f, -1.61327362e-01f,
  9.70185399e-02f, -1.43953934e-01f, -4.35251445e-02f, -1.46979736e-02f, 3.61987390e-02f, 1.20665273e-02f, -2.77055413e-01f, 1.18283711e-01f, 8.46323669e-02f, -3.14518325e-02f,
  1.08303882e-01f, 2.57240087e-02f, -4.41955589e-02f, -2.57146627e-01f, 1.52555391e-01f, 1.45939528e-03f, -4.65436727e-02f, -2.07270205e-01f, 8.00113473e-03f, 1.05370946e-01f,
  -1.43679380e-01f, 1.71647429e-01f, -7.41449147e-02f, -1.55927762e-01f, 5.78736477e-02f, -9.61815864e-02f, -8.53503495e-02f, -1.99970722e-01f, 1.22878902e-01f, 1.44180834e-01f,
  1.25210866e-01f, -7.34027252e-02f, -8.07896256e-02f, 3.62042449e-02f, -8.38550702e-02f, -3.84271480e-02f, 6.65807724e-03f, 2.37186309e-02f, 8.61454606e-02f, 1.84021071e-02f,
  6.15740046e-02f, 1.57854468e-01f, 7.63231888e-02f, 1.98917221e-02f, 6.83432296e-02f, 9.05523077e-02f, 8.55423212e-02f, -3.55723239e-02f, 6.31031021e-02f, -1.01899013e-01f,
  1.54809490e-01f, -2.17936398e-03f, 1.89273745e-01f, 9.33311805e-02f, 7.59971589e-02f, -9.79756415e-02f, -2.10408986e-01f, 6.51694760e-02f, -6.23230189e-02f, -2.14432310e-02f,
  1.25215486e-01f, -2.30632260e-01f, 9.21150073e-02f, 1.41750006e-02f, 9.43733752e-02f, 3.90801067e-03f, -8.44175369e-02f, -8.23082402e-03f, -2.09296606e-02f, 9.99572948e-02f,
  -3.09974654e-03f, 2.22358815e-02f, 7.28557557e-02f, -1.50287747e-01f, 4.74856421e-02f, 7.79149979e-02f, -1.25603706e-01f, 4.17618752e-02f, -2.25506440e-01f, -1.21370621e-01f,
  1.51350185e-01f, -1.26381129e-01f, 4.28183377e-02f, 3.19406576e-02f, 1.06522635e-01f, -1.29681185e-01f, -1.66387305e-01f, 1.22171976e-01f, 1.46699890e-01f, -8.98128003e-02f,
  -8.14874992e-02f, -4.51325364e-02f, 1.08666621e-01f, -3.60796452e-02f, -1.06716994e-02f, 1.46058872e-01f, -2.44910736e-02f, -7.73470178e-02f, -6.79760724e-02f, -1.85760316e-02f,
  1.36932135e-01f, -1.06486201e-01f, 1.68892480e-02f, 2.96708271e-02f, 1.81002300e-02f, -1.61143363e-01f, -1.26127884e-01f, 9.82489735e-02f, -1.93790887e-02f, 1.43351585e-01f,
  -1.09837696e-01f, 1.36568189e-01f, -1.68403834e-01f, 6.26499355e-02f, 1.24312583e-02f, 1.65677860e-01f, -4.20721360e-02f, 1.50394514e-01f, -1.04900271e-01f, 1.15353018e-01f,
  1.92921460e-01f, -6.53946549e-02f, -1.92582265e-01f, -2.09890120e-02f, -1.17773883e-01f, 1.34474978e-01f, -2.86184192e-01f, 5.34975529e-02f, 5.30107357e-02f, -7.55261630e-02f,
  -1.62003592e-01f, -1.59916073e-01f, -1.24319881e-01f, -1.52500063e-01f, 4.06192020e-02f, 1.72580525e-01f, -1.79930627e-01f, 1.77716583e-01f, 1.11758217e-01f, -1.78137626e-02f,
  -3.71987146e-04f, -8.74532610e-02f, 3.62287238e-02f, -1.16835445e-01f, -1.73714951e-01f, 8.98187160e-02f, -3.14102508e-02f, -8.78558587e-03f, -1.48873799e-03f, -1.76425025e-01f,
  1.92737252e-01f, -2.52224561e-02f, -1.01830840e-01f, 2.26699352e-01f, -9.05036777e-02f, 1.92858353e-01f, -5.99810779e-02f, 2.64407191e-02f, 4.63386485e-03f, -8.56159255e-02f,
  -7.34825060e-02f, 1.55093800e-02f, -2.98685580e-02f, -1.69539507e-02f, 1.46775553e-02f, 3.88076231e-02f, 9.92427301e-03f, 1.40759632e-01f, -1.28716737e-01f, -7.90340826e-02f,
  -8.02807957e-02f, 6.09222911e-02f, -4.62088250e-02f, -8.85310769e-02f, 9.80126411e-02f, -1.74470633e-01f, 1.53282061e-01f, -3.02696638e-02f, 1.02721952e-01f, -1.14906050e-01f,
  6.75802082e-02f, 9.47196186e-02f, -1.51150133e-02f, 8.91487580e-03f, 1.59614995e-01f, 1.82116553e-01f, 1.55536234e-01f, -2.40181893e-01f, -5.11014182e-03f, 7.28274211e-02f,
  -9.13864225e-02f, 2.77891755e-02f, 1.30378813e-01f, 1.77942455e-01f, -5.02474792e-02f, 4.50391658e-02f, -5.12509532e-02f, -7.03605264e-02f, 3.22451591e-02f, -1.74962729e-01f,
  2.91204248e-02f, -1.27444789e-01f, -1.64630249e-01f, -3.51179354e-02f, 1.59455314e-01f, 7.59528801e-02f, -2.27155671e-01f, 2.46054474e-02f, -6.04625605e-02f, 1.63427487e-01f,
  1.21747822e-01f, -5.28487302e-02f, 2.35804245e-01f, -1.70740232e-01f, 7.83793330e-02f, 5.77039719e-02f, 3.37948427e-02f, 2.13266447e-01f, -2.68620495e-02f, 2.36814227e-02f,
  -2.93146670e-02f, -1.01907045e-01f, -7.19011873e-02f, 3.52984928e-02f, 7.67901614e-02f, 1.24803089e-01f, -8.91710445e-03f, -1.81418136e-02f, -1.00364320e-01f, -2.30823569e-02f,
  -4.76879813e-03f, -3.99778690e-03f, 5.59645845e-03f, -9.81281251e-02f, 1.83234122e-02f, -1.24728076e-01f, 3.09755635e-02f, 1.26900509e-01f, 1.45490080e-01f, 1.74119979e-01f,
  -7.52059221e-02f, 1.18586145e-01f, 2.39829510e-01f, 1.35646844e-02f, 8.36744756e-02f, 4.58071381e-02f, 1.02183066e-01f, -1.28934845e-01f, 6.30326867e-02f, 2.01850206e-01f,
  -2.39132687e-01f, -5.65358438e-02f, -2.23557547e-01f, -5.41678853e-02f, 6.07711123e-03f, 1.22819906e-02f, 9.55178961e-02f, 5.50967343e-02f, -1.83985263e-01f, -8.90140049e-03f,
  7.88973123e-02f, 1.38271973e-01f, 5.61504252e-02f, -5.51022440e-02f, -4.39723805e-02f, 1.44935504e-01f, 9.82814804e-02f, -1.20610200e-01f, 5.71800768e-03f, 1.26820758e-01f,
  -5.30612050e-03f, -8.95604715e-02f, 5.31979240e-02f, 1.05842538e-02f, 7.39588365e-02f, -3.60131375e-02f, -2.36853696e-02f, -1.13490753e-01f, 1.07281335e-01f, 8.83763880e-02f,
  -5.96417524e-02f, -3.77115235e-02f, -8.21815729e-02f, 1.11365274e-01f, -1.05158858e-01f, -1.29127234e-01f, 1.17293939e-01f, 2.72266474e-03f, 2.03861013e-01f, 1.47826329e-01f,
  5.55805713e-02f, 2.33428642e-01f, -1.51205674e-01f, -1.36310104e-02f, 1.26429750e-02f, 2.74937879e-03f, 1.44277379e-01f, 1.79078475e-01f, 2.15269830e-02f, -1.40885949e-01f,
  -6.44934475e-02f, -4.72557619e-02f, 8.44751894e-02f, -7.61527345e-02f, -1.33125633e-01f, 1.92068413e-01f, 9.21153426e-02f, -2.25161225e-01f, 9.11539271e-02f, -1.84662893e-01f,
  1.01244837e-01f, -2.99397819e-02f, -1.91134229e-01f, -3.79924923e-02f, -5.72528131e-02f, 2.17484310e-01f, -9.58229452e-02f, -3.13711092e-02f, 2.72983611e-01f, -1.55392095e-01f,
  -6.63145483e-02f, 1.88854203e-01f, 1.23266384e-01f, 2.56425381e-01f, 1.17528848e-01f, 1.08810805e-01f, 5.63100837e-02f, 4.21725586e-03f, 1.62245095e-01f, 8.23422447e-02f,
  -2.11447313e-01f, 2.38814368e-03f, -6.44858927e-02f, -6.86617792e-02f, 1.15536764e-01f, 1.52761549e-01f, 1.80400759e-02f, -1.43560886e-01f, -5.29254712e-02f, -8.41038227e-02f,
  -2.36870810e-01f, 1.61459193e-01f, -1.64496288e-01f, -6.92855641e-02f, -6.80283979e-02f, -2.03576863e-01f, -1.12817265e-01f, 7.25496188e-02f, 2.18551513e-02f, 1.31823793e-01f,
  -3.80190052e-02f, -6.58989772e-02f, -1.07848123e-01f, 8.10121596e-02f, 6.93974048e-02f, -7.38406628e-02f, -5.43038286e-02f, -1.63421243e-01f, -6.97669433e-03f, -1.24102943e-01f,
  -7.87440687e-02f, -5.12950420e-02f, 1.23307705e-01f, -6.39283471e-03f, 3.17307040e-02f, -1.10156015e-01f, 6.49233684e-02f, 1.77929819e-01f, -2.91446093e-02f, -1.54540956e-01f,
  -1.05666192e-02f, -3.86708900e-02f, -2.61016916e-02f, -1.43142909e-01f, -1.10439852e-01f, -1.18382283e-01f, -1.58390611e-01f, 8.10081959e-02f, 6.66818991e-02f, 3.27767730e-02f,
  -3.29379775e-02f, -1.84543818e-01f, 2.67558377e-02f, -1.18008561e-01f, -2.15352257e-03f, -1.68346651e-02f, -1.20239772e-01f, 1.75840810e-01f, 6.29960652e-03f, 3.02322768e-02f,
  1.62017211e-01f, 1.40828475e-01f, 1.32299662e-01f, 1.42048681e-02f, 1.02236174e-01f, 6.41738400e-02f, -1.85125425e-01f, -1.50195524e-01f, 4.62609008e-02f, -8.56040940e-02f,
  2.00292706e-01f, -1.75656319e-01f, 1.06288999e-01f, 9.56502110e-02f, -1.16104469e-01f, -6.39114007e-02f, -6.60244599e-02f, -6.44315854e-02f, -6.39727572e-03f, -2.15279937e-01f,
  7.02409521e-02f, -1.44786865e-01f, 1.07980631e-02f, 2.03837112e-01f, -8.66507813e-02f, -3.45510468e-02f, -6.07422926e-02f, -6.78098900e-03f, -9.70065407e-03f, 4.61199470e-02f,
  -1.12872042e-01f, -1.41164958e-01f, 1.44757167e-01f, 1.31061643e-01f, 3.77651602e-02f, 4.32951748e-02f, 2.62061805e-02f, 1.42606199e-02f, 7.91886374e-02f, -1.09445594e-01f,
  -1.60114884e-01f, 2.96992630e-01f, -5.83859393e-03f, -5.40779680e-02f, 5.32307476e-02f, 2.11310610e-01f, -2.73367222e-02f, 6.05197400e-02f, -1.24643981e-01f, -1.76729769e-01f,
  -2.11065099e-01f, -2.27548659e-01f, 1.32695660e-01f, 1.78204134e-01f, 1.44710496e-01f, -1.04119681e-01f, 1.76598839e-02f, -2.55263925e-01f, 1.07830606e-01f, -1.63162857e-01f,
  -1.24858290e-01f, 8.85927826e-02f, -1.10142119e-01f, 1.81878820e-01f, -2.66838700e-01f, -1.05280347e-01f, 6.17403314e-02f, 1.01021513e-01f, 8.63212198e-02f, 2.58251578e-01f,
  -1.45083681e-01f, -1.23770364e-01f, -7.76706412e-02f, 2.01786446e-04f, 1.01002023e-01f, -1.46217540e-01f, -9.00449976e-02f, 1.72117740e-01f, -1.38922557e-01f, 2.39065802e-03f,
  3.14885341e-02f, -2.35877763e-02f, 3.67523567e-03f, -7.50986040e-02f, -6.78728297e-02f, -2.79647619e-01f, 3.80042754e-02f, 6.32804036e-02f, -1.85882464e-01f, 2.39807013e-02f,
  -1.26492053e-01f, -7.07573369e-02f, -1.48480143e-02f, -2.16471583e-01f, -9.88074094e-02f, -5.07245697e-02f, 3.42284217e-02f, 1.30220801e-01f, 1.15726449e-01f, 2.68893111e-02f,
  -4.27478887e-02f, -6.43235967e-02f, -9.30343941e-02f, 1.85668916e-02f, -2.98507586e-02f, 9.49503258e-02f, 3.72061096e-02f, 1.07194349e-01f, -4.05501612e-02f, 5.90241514e-02f,
  2.09036786e-02f, 2.06702217e-01f, -1.97900221e-01f, -1.21069133e-01f, 2.98089217e-02f, 5.87172657e-02f, 2.10970119e-01f, -2.45691612e-01f, 1.50691241e-01f, 6.47213235e-02f,
  2.08727986e-01f, -5.31613044e-02f, 4.64089885e-02f, 1.69312373e-01f, -3.99715938e-02f, -1.34318486e-01f, -2.75386244e-01f, 2.22478621e-02f, -2.22011492e-01f, -2.36525878e-01f,
  3.43714096e-02f, 9.46038291e-02f, -1.84815656e-02f, 1.23895951e-01f, 2.30296150e-01f, 1.45001486e-01f, -1.15983337e-01f, -7.71502033e-02f, -5.44072315e-02f, -5.21689579e-02f,
  -8.15348923e-02f, 1.33353457e-01f, 7.56093627e-03f, -1.58975609e-02f, -3.22730504e-02f, 9.63878781e-02f, -1.23622185e-02f, 1.77628230e-02f, -4.88324761e-02f, 4.83733192e-02f,
  -1.12384476e-01f, 1.54167488e-01f, -1.17899701e-01f, -4.42373604e-02f, -4.79623117e-02f, -2.93262526e-02f, -5.30764274e-02f, -2.26384312e-01f, 6.99592680e-02f, -3.83512564e-02f,
  -1.66177511e-01f, -4.81060259e-02f, 4.01877984e-02f, 3.33394594e-02f, 1.04715833e-02f, 3.31197940e-02f, -6.49930760e-02f, 4.58525196e-02f, 7.55285472e-02f, -7.15487674e-02f,
  1.17635891e-01f, 8.80917609e-02f, -2.09625661e-02f, 2.78337728e-02f, -1.36887908e-01f, 4.36160564e-02f, -3.82052138e-02f, -6.49261922e-02f, 9.04836953e-02f, 1.74330007e-02f,
  -7.08444118e-02f, -3.89012732e-02f, 7.56329596e-02f, 1.13686249e-01f, 8.81196633e-02f, -6.28769919e-02f, 1.60916094e-02f, 1.91312253e-01f, -5.99213950e-02f, -3.56376208e-02f,
  -2.43187711e-01f, 6.32356331e-02f, -1.16312420e-02f, -2.91640889e-02f, 1.07654087e-01f, 9.80242565e-02f, -1.55478671e-01f, 5.09778671e-02f, 1.28683433e-01f, -2.92066596e-02f,
  -2.52926946e-01f, -1.88326284e-01f, 9.29581895e-02f, -2.76332721e-02f, 9.52224284e-02f, 1.30317971e-01f, 5.45423701e-02f, -1.47968784e-01f, -1.18775122e-01f, -2.83929016e-02f,
  3.52902412e-02f, 1.54445916e-01f, -5.63149266e-02f, 4.45659496e-02f, 5.29209636e-02f, 6.21915683e-02f, 1.22330254e-02f, -1.10441796e-01f, 7.11220279e-02f, 1.46324597e-02f,
  1.01549089e-01f, -2.15668194e-02f, 6.83812201e-02f, -1.03648705e-02f, -8.31471533e-02f, 1.44964889e-01f, 8.19965750e-02f, 1.02379009e-01f, 4.55095731e-02f, -1.25924096e-01f,
  -5.09002618e-02f, 1.28482148e-01f, -2.07200423e-02f, -2.08353959e-02f, 4.84087691e-02f, 3.55319008e-02f, 2.51952738e-01f, -4.02356014e-02f, 1.23504825e-01f, 5.97427152e-02f,
  2.30928853e-01f, 3.99064124e-02f, 9.03275609e-03f, 2.61967599e-01f, -8.60294104e-02f, 5.05120754e-02f, 1.96475327e-01f, -9.14018601e-02f, 5.26277125e-02f, -3.71056087e-02f,
  -1.56229898e-01f, 6.84804283e-04f, -6.84915185e-02f, -7.58871958e-02f, 1.69984698e-02f, 7.49394819e-02f, 2.08436415e-01f, -8.41949359e-02f, 5.74976131e-02f, -1.92149296e-01f,
  -1.79002881e-01f, -7.30867237e-02f, -3.89604201e-03f, -1.81258898e-02f, -3.40964980e-02f, 4.46479768e-02f, -3.10845431e-02f, -1.47634342e-01f, 1.24463372e-01f, 7.74725452e-02f,
  -1.04909435e-01f, 1.02619815e-03f, -6.63050339e-02f, 5.21514155e-02f, -2.23348150e-03f, -1.19297788e-01f, -1.88644677e-01f, 1.63187578e-01f, -7.88683370e-02f, 8.31607580e-02f,
  -3.53975706e-02f, -1.33309096e-01f, 7.90049974e-03f, 6.36453461e-03f, -1.17684759e-01f, -1.27760142e-01f, -1.71715021e-01f, -2.17097178e-01f, -9.42468736e-03f, -1.54176548e-01f,
  -2.28541661e-02f, -4.78738956e-02f, -1.05430447e-01f, -1.17901266e-01f, 1.14441868e-02f, -3.66587229e-02f, 1.56548023e-01f, -1.55749142e-01f, 1.08689114e-01f, 3.57723632e-03f,
  -8.04219991e-02f, -1.09732307e-01f, -1.30884111e-01f, 9.06260461e-02f, -1.33301437e-01f, -4.66432869e-02f, -7.00953454e-02f, 1.07510753e-01f, 2.42934488e-02f, -5.58608845e-02f,
  -1.24711819e-01f, 2.18019068e-01f, 1.26079142e-01f, -2.13004038e-01f, 1.56120092e-01f, 4.17435318e-02f, 4.65999730e-02f, -5.10586575e-02f, -2.14771494e-01f, -2.27114893e-02f,
  -1.09875798e-01f, -2.76383102e-01f, 1.59895971e-01f, -3.83777283e-02f, -1.94256589e-01f, 2.25646138e-01f, 1.90278217e-01f, 5.32501303e-02f, -1.09837949e-01f, -5.31071313e-02f,
  2.73206476e-02f, -7.51787946e-02f, -4.89731617e-02f, 4.37979810e-02f, 1.41208991e-01f, -4.10459377e-02f, -9.56294537e-02f, 1.61013305e-01f, -7.37969056e-02f, 2.08168492e-01f,
  -8.06542020e-03f, -8.44607502e-02f, 7.03970296e-03f, 1.56538308e-01f, -9.99911651e-02f, 1.59204617e-01f, -1.73670184e-02f, 8.06064829e-02f, 1.34117171e-01f, -1.46649092e-01f,
  1.49082676e-01f, 3.42217945e-02f, -6.28640652e-02f, -3.33618410e-02f, -6.29328415e-02f, -8.35902989e-03f, -8.58788937e-02f, 4.16288227e-02f, 1.35040194e-01f, -1.31310802e-02f,
  -2.12450430e-01f, 1.94048807e-01f, 3.27697136e-02f, -1.82222500e-01f, 1.58123344e-01f, 1.10946462e-01f, -1.25907501e-03f, -2.70126134e-01f, 4.60404046e-02f, -1.12502389e-01f,
  -1.64828956e-01f, -7.05396533e-02f, -2.26397902e-01f, -4.21727858e-02f, -1.05303332e-01f, -1.39975071e-01f, -1.30185351e-01f, -1.50682494e-01f, -4.03893329e-02f, -9.51347426e-02f,
  9.15569533e-03f, -1.20477460e-03f, 1.44635186e-01f, -1.06673218e-01f, -4.52034920e-02f, 1.74438387e-01f, -1.69253379e-01f, -2.98829582e-02f, 1.78217828e-01f, -2.19326466e-02f,
  -1.23100020e-02f, 1.24890842e-01f, 1.51647866e-01f, -1.41082898e-01f, -1.80197343e-01f, -7.42621198e-02f, 1.40902266e-01f, 8.20930004e-02f, -2.14563325e-01f, -1.74505729e-02f,
  -1.37542352e-01f, -5.16363531e-02f, 2.69505829e-02f, -5.09714074e-02f, -2.62289774e-02f, -2.14943424e-01f, 1.02373697e-01f, 1.12048842e-01f, -1.13864176e-01f, 2.75246557e-02f,
  -1.79108582e-03f, -6.07999042e-02f, -5.89878634e-02f, -5.48026077e-02f, 1.60025761e-01f, 8.20716545e-02f, 8.55903029e-02f, 1.47657380e-01f, -1.00279577e-01f, -1.13416053e-01f,
  4.89993282e-02f, 1.15570322e-01f, 8.77876803e-02f, 1.11275062e-01f, 1.25053272e-01f, -8.81075040e-02f, 7.03940615e-02f, -2.40234405e-01f, 1.49647027e-01f, 2.44633183e-01f,
  -1.16644934e-01f, -1.68101117e-02f, -5.32140359e-02f, 1.03599280e-01f, 8.57431591e-02f, -1.33597031e-01f, -1.65967479e-01f, -1.02886826e-01f, -3.73064615e-02f, -1.03154056e-01f,
  -3.15258801e-01f, 1.21291630e-01f, -7.60171935e-02f, -2.12553173e-01f, -1.34368122e-01f, -2.27757037e-01f, 7.90284351e-02f, 7.27307349e-02f, 6.27540722e-02f, -5.91394380e-02f,
  -1.21879794e-01f, 9.02330056e-02f, 7.55855739e-02f, -3.07450611e-02f, -1.54560044e-01f, -1.28247142e-01f, -1.31228656e-01f, -1.21186055e-01f, -1.28634289e-01f, -1.63194481e-02f,
  -7.39512593e-02f, 5.85607514e-02f, 1.04296923e-01f, -1.34270176e-01f, 1.92305356e-01f, 5.08553758e-02f, -5.87852933e-02f, -1.00535601e-01f, 4.34545726e-02f, -6.30999878e-02f,
  5.05965278e-02f, 4.57875580e-02f, 1.15470923e-01f, 1.60146922e-01f, 2.26981550e-01f, 1.70746744e-01f, 4.31321561e-03f, 3.45199145e-02f, 5.32564856e-02f, -7.70470127e-02f,
  2.11226493e-01f, 3.31027210e-02f, -1.51608631e-01f, 6.02638647e-02f, 1.15750328e-01f, 2.01794758e-01f, -4.46462855e-02f, 1.53896585e-01f, -1.11878544e-01f, 5.37351035e-02f,
  1.05361119e-01f, -2.25245208e-01f, 7.12055489e-02f, -7.76362792e-02f, 7.23830163e-02f, -2.40940765e-01f, 4.45932224e-02f, -7.27951014e-03f, 7.12890830e-03f, -2.44770601e-01f,
  -1.73194721e-01f, 8.40263739e-02f, -1.87608805e-02f, -4.05291170e-02f, -2.78947890e-01f, 9.04507488e-02f, 3.73648107e-03f, -1.62049010e-01f, -4.96474840e-02f, 5.01357429e-02f,
  1.74247742e-01f, -5.16424654e-03f, -2.12140661e-02f, 9.88281146e-02f, -3.07983179e-02f, -2.63422616e-02f, 1.60198078e-01f, -1.64846137e-01f, -6.46265745e-02f, -7.05399588e-02f,
  1.25068858e-01f, 1.11616224e-01f, -1.14771411e-01f, 9.15444922e-03f, -1.20933801e-01f, 2.47460380e-02f, -1.29776657e-01f, 1.43904656e-01f, 4.13819999e-02f, -9.92833525e-02f,
  -1.76064298e-02f, -1.44058362e-01f, 1.13587819e-01f, -1.67416967e-02f, -1.80342168e-01f, -6.79647326e-02f, -2.22266093e-01f, 1.84699837e-02f, 2.42657717e-02f, 3.38016041e-02f,
  1.15908831e-01f, -4.45510671e-02f, 8.45244974e-02f, -9.89914313e-02f, -7.81464763e-03f, 1.44962594e-01f, 3.66247296e-02f, -7.62844384e-02f, -2.19489455e-01f, 2.36556996e-02f,
  -8.62320065e-02f, -5.28293140e-02f, -1.29411593e-01f, -1.02129497e-01f, 5.84834330e-02f, -1.52969267e-02f, 5.98964281e-02f, -3.55450921e-02f, 7.41070835e-03f, 1.54735774e-01f,
  -7.69050494e-02f, 2.78662462e-02f, 1.60209209e-01f, -4.36098091e-02f, 2.18993694e-01f, -1.97634056e-01f, -5.38719296e-02f, 2.59524614e-01f, -1.37880936e-01f, 1.50802732e-01f,
  7.42105022e-02f, 2.36755267e-01f, 1.47245899e-01f, 1.00291491e-01f, -2.55455766e-02f, -1.32478461e-01f, -1.28938198e-01f, -1.09443568e-01f, -3.63506973e-02f, -9.18929372e-03f,
  4.19129357e-02f, 9.18704420e-02f, 3.64929065e-02f, 1.29060894e-01f, 3.20528820e-02f, 4.54962701e-02f, 6.79144785e-02f, 1.37891062e-02f, 3.60671841e-02f, 4.70088562e-03f,
  3.36851180e-02f, 1.59452438e-01f, 6.38129488e-02f, 5.37529178e-02f, -9.27178636e-02f, 1.56955734e-01f, -3.99317741e-02f, -1.10744067e-01f, -1.17666379e-01f, -9.48588029e-02f,
  -2.16888040e-02f, -6.99555278e-02f, -1.57710135e-01f, -1.12846725e-01f, -6.25069439e-02f, -3.58026871e-03f, 6.97359890e-02f, -1.25237675e-02f, -1.89751118e-01f, 1.66954115e-01f,
  -1.61206380e-01f, -6.15714453e-02f, 1.67895425e-02f, 1.07564488e-02f, -7.30814189e-02f, -2.76213679e-02f, -1.85933799e-01f, -1.82899356e-01f, -1.14774229e-02f, -7.92235434e-02f,
  -3.07814311e-02f, 2.89718062e-01f, 1.94400251e-02f, 2.47783080e-01f, -1.01654887e-01f, 8.87717903e-02f, -3.12912762e-02f, -8.40491131e-02f, 2.93969512e-01f, -9.26303789e-02f,
  2.50057936e-01f, 1.82798523e-02f, -8.82340129e-03f, 1.12026185e-01f, 9.79293659e-02f, 8.54562968e-02f, 1.43824354e-01f, -7.97119737e-03f, 3.75609659e-02f, -1.25648268e-02f,
  2.11333274e-03f, -2.31586725e-01f, 4.40563671e-02f, -1.70389451e-02f, -3.77031625e-03f, 7.24107027e-02f, -8.21532756e-02f, -5.89626804e-02f, 8.43295231e-02f, 5.45127541e-02f,
  -1.63092136e-01f, -9.34635662e-03f, -1.38866112e-01f, 7.73319788e-03f, 5.21110557e-02f, 1.02969237e-01f, -4.29836288e-02f, -1.88117832e-01f, -3.49745825e-02f, -5.44592626e-02f,
  -5.66042848e-02f, 8.94851685e-02f, -1.00003719e-01f, 6.14595637e-02f, -2.13506576e-02f, 7.03546852e-02f, 5.48814163e-02f, 1.13248147e-01f, -2.82610045e-03f, -4.26605456e-02f,
  -1.56179275e-02f, -1.26568660e-01f, -6.17367923e-02f, 1.29610309e-02f, 3.53964865e-02f, -6.81695789e-02f, 2.12236255e-01f, 1.96671784e-02f, -3.08285095e-02f, 1.08601384e-01f,
  7.91990235e-02f, 2.43541896e-01f, 8.65650177e-02f, -1.86226025e-01f, -2.62505505e-02f, 1.65947020e-01f, -9.80751291e-02f, 3.23569588e-02f, -1.41723007e-01f, -1.64300919e-01f,
  -2.31297597e-01f, -1.05776966e-01f, 1.12760834e-01f, 2.14425594e-01f, -9.77267474e-02f, -1.05591632e-01f, -1.44422695e-01f, -2.00287327e-01f, 9.38897654e-02f, -1.27947822e-01f,
  -1.53920427e-01f, 1.53855547e-01f, -1.25347540e-01f, 5.37130609e-02f, -4.70791608e-02f, 5.39758522e-03f, 1.56132922e-01f, 1.45135194e-01f, 9.46931690e-02f, 1.01361006e-01f,
  -1.09567747e-01f, -1.78520143e-01f, 1.83658808e-01f, 9.59873646e-02f, 1.42240033e-01f, -1.69380352e-01f, 3.71070504e-02f, 1.07430302e-01f, -1.46637678e-01f, 7.90153146e-02f,
  1.57661475e-02f, -9.57192853e-02f, -5.95779419e-02f, -1.14709914e-01f, -7.98563361e-02f, -1.65080115e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  3.01721934e-02f, -2.47884259e-01f, 1.15468867e-01f, -1.13306239e-01f, 1.27387628e-01f, 5.53243048e-02f, 1.17671899e-01f, 1.42172948e-01f, 6.91732094e-02f, -4.63694334e-02f,
  -6.79837018e-02f, 1.61989048e-01f, -2.23525967e-02f, 1.94374040e-01f, 1.84287623e-01f, 2.85757054e-02f, -6.83376938e-02f, 1.64891049e-01f, -1.65872797e-02f, -5.10777235e-02f,
  -2.27194726e-01f, 5.22736758e-02f, -2.39686333e-02f, -3.98503654e-02f, -7.78382793e-02f, 3.49739283e-01f, -1.03339724e-01f, 1.39433876e-01f, 1.56721607e-01f, 7.33426064e-02f,
  2.70946980e-01f, -2.04085186e-01f, 6.23699883e-03f, 2.65918314e-01f, 2.15924203e-01f, 2.05559179e-01f, 6.96243569e-02f, 2.86427051e-01f, 2.67266244e-01f, 1.79226860e-01f,
  -7.40780011e-02f, -5.35780527e-02f, 1.17276711e-02f, -2.80212432e-01f, 2.08652690e-01f, -1.19965494e-01f, -1.22097746e-01f, 1.70783311e-01f, 2.86017776e-01f, 1.25597298e-01f,
  -1.69290137e-02f, 3.63832861e-02f, 1.64064422e-01f, 2.93521404e-01f, -4.26001251e-02f, 1.79518238e-01f, 1.71745673e-03f, 1.27784818e-01f, 1.29019588e-01f, -2.51463614e-02f,
  1.38398781e-01f, 3.34230632e-01f, 1.18878618e-01f, 1.73536390e-01f, -7.85463601e-02f, 2.25050911e-01f, 1.01884574e-01f, -3.52625191e-01f, -1.42905936e-01f, -1.23628937e-01f,
  -2.19378471e-02f, -2.88437635e-01f, -1.92127168e-01f, -4.47604619e-02f, 8.13348442e-02f, -1.06421500e-01f, 2.24702716e-01f, 5.21866530e-02f, 1.11490123e-01f, -1.65812045e-01f,
  5.71952872e-02f, -8.39593560e-02f, 5.29044122e-02f, 1.15024997e-02f, -5.07405214e-02f, 2.29417652e-01f, 5.33137657e-02f, 2.26794153e-01f, -2.20175549e-01f, 1.46838292e-01f,
  -5.77141680e-02f, -1.45427763e-01f, -1.69385463e-01f, 1.97143227e-01f, 9.67359543e-02f, 6.88991621e-02f, -5.42376637e-02f, -2.51079082e-01f, 3.73122931e-01f, -5.92087284e-02f,
  1.33242905e-01f, 2.58660495e-01f, -7.60578811e-02f, 1.06104806e-01f, -1.03916749e-01f, 1.13496542e-01f, 1.80164814e-01f, -2.11137682e-01f, 1.05165139e-01f, 5.30226231e-02f,
  -2.50721008e-01f, 2.17308208e-01f, 1.16764598e-01f, 7.20004514e-02f, -2.68868327e-01f, -1.06284581e-01f, 2.26349235e-01f, -1.24769665e-01f, 1.88443754e-02f, 2.88497090e-01f,
  3.86076361e-01f, -2.17953652e-01f, 7.23850429e-02f, 2.55746335e-01f, 2.10098475e-02f, -1.21698648e-01f, -5.85720688e-02f, -1.24000087e-01f, 1.43532172e-01f, 1.67635337e-01f,
  4.59072366e-02f, -1.25048026e-01f, 1.07894145e-01f, -9.91828144e-02f, -4.40564081e-02f, 2.42067333e-02f, 7.39419460e-03f, -1.75871864e-01f, 1.48860797e-01f, -1.76394239e-01f,
  1.01515099e-01f, -1.57881416e-02f, -5.37237711e-02f, 1.68126673e-02f, 7.31408745e-02f, -9.71091315e-02f, 6.41585439e-02f, -1.30854836e-02f, -1.24263972e-01f, 4.67914343e-01f,
  2.03372985e-01f, -2.65362233e-01f, 7.78527856e-02f, 2.99191512e-02f, 3.88641246e-02f, -2.68796027e-01f, -8.56338739e-02f, 1.59574673e-01f, -2.95066476e-01f, 1.14718884e-01f,
  -2.96515644e-01f, 1.63138047e-01f, 4.45078343e-01f, -3.82726014e-01f, 7.93503877e-03f, 3.14831734e-01f, -1.49331978e-02f, 1.44346869e-02f, 6.41875789e-02f, 2.81658433e-02f,
  8.79987180e-02f, 5.66816628e-02f, 2.25525424e-02f, 3.97649929e-02f, -1.94676630e-02f, -9.13446490e-03f, 7.13010430e-02f, 1.55909345e-01f, -6.72284812e-02f, -7.90567473e-02f,
  1.12778462e-01f, 4.65832688e-02f, 2.19815135e-01f, 3.58987711e-02f, -2.80239195e-01f, -3.91319916e-02f, -1.83753166e-02f, 6.59746751e-02f, 2.25376755e-01f, 2.20244974e-01f,
  -1.05555892e-01f, 3.24560925e-02f, 1.49341241e-01f, 1.22338571e-02f, 4.08063903e-02f, -1.16539150e-01f, 1.08415946e-01f, -7.23345652e-02f, -2.44220886e-02f, -6.24448135e-02f,
  1.52055562e-01f, 5.99975362e-02f, -1.66483209e-01f, 1.51481256e-02f, 7.01154955e-03f, 1.97484896e-01f, 7.06240209e-03f, 8.94786939e-02f, -3.91561054e-02f, -5.27812354e-02f,
  -6.96324483e-02f, -1.83408752e-01f, -9.04854387e-02f, -1.51105136e-01f, -2.90466845e-01f, 8.98452699e-02f, -1.63556859e-01f, 1.49050161e-01f, -1.06737107e-01f, 9.38225761e-02f,
  6.23405948e-02f, -1.10366054e-01f, 3.61290187e-01f, -6.86211884e-02f, 1.49243653e-01f, -1.98833272e-02f, 2.17813715e-01f, 8.42548087e-02f, 1.83787912e-01f, -5.21613508e-02f,
  9.64033827e-02f, 1.19242944e-01f, 1.09529428e-01f, -5.37986010e-02f, -2.41553739e-01f, -7.00613558e-02f, 1.18166707e-01f, -7.50262588e-02f, -1.43875331e-01f, 1.51002571e-01f,
  2.25262582e-01f, -8.35613012e-02f, 1.97786182e-01f, 6.50902987e-02f, 1.96266800e-01f, -3.88810690e-03f, -1.16362303e-01f, 1.84093848e-01f, -9.05511975e-02f, 2.61189401e-01f,
  -4.08720560e-02f, -1.08523756e-01f, 1.00044452e-01f, 2.48949379e-02f, 1.44496858e-01f, -1.21239983e-01f, -1.42127266e-02f, 3.69663984e-02f, 1.87040165e-01f, -1.05110453e-02f,
  1.18439622e-01f, 9.47878733e-02f, 7.19592348e-02f, 2.41070583e-01f, -4.43556979e-02f, 6.05161078e-02f, 2.60966361e-01f, -4.14474271e-02f, 4.23400067e-02f, 5.78461625e-02f,
  2.29408711e-01f, -1.58486795e-02f, -3.07285748e-02f, 1.31889537e-01f, -1.25263870e-01f, 2.47609615e-01f, -4.74723391e-02f, -3.85574773e-02f, -6.03635497e-02f, 5.29519208e-02f,
  5.80367073e-02f, -3.18520159e-01f, -2.37431750e-01f, -6.05038218e-02f, -3.58931482e-01f, -7.14654699e-02f, 1.57073364e-01f, 2.80476779e-01f, 1.12516999e-01f, -2.11595625e-01f,
  1.92384899e-01f, -2.89516121e-01f, 6.75406381e-02f, 6.49692193e-02f, 8.93433169e-02f, 3.00827771e-01f, 1.26135886e-01f, 3.80826071e-02f, -3.40214908e-01f, -1.09028853e-01f,
  1.30546764e-01f, -3.69722620e-02f, -8.30258615e-03f, 1.51267529e-01f, 8.34222436e-02f, -2.80955620e-02f, 3.16593170e-01f, 3.15310568e-01f, 1.49618849e-01f, -1.15276046e-01f,
  5.13246022e-02f, 6.16656058e-02f, -2.52255321e-01f, 4.05242324e-01f, -4.05675322e-02f, 2.16158517e-02f, 2.22124662e-02f, -1.06053308e-01f, 6.43217638e-02f, -1.61304951e-01f,
  2.75264919e-01f, 2.61034891e-02f, 2.00643748e-01f, 2.41193458e-01f, 1.20982975e-01f, 1.99927092e-01f, 2.08088323e-01f, 1.21649064e-01f, 1.57078803e-01f, 1.25735831e-02f,
  1.36179447e-01f, 1.23501271e-01f, -1.78601698e-03f, 3.64390500e-02f, -1.14517532e-01f, 1.62954703e-01f, 1.77999854e-01f, 2.21436709e-01f, -3.40784937e-02f, 2.14984015e-01f,
  -1.69936016e-01f, -1.71416804e-01f, 2.94674456e-01f, 2.04961989e-02f, 1.78453594e-01f, -1.37875333e-01f, 1.05831720e-01f, -1.69591948e-01f, 1.24689639e-01f, -4.44754735e-02f,
  -2.77344853e-01f, 2.47891769e-01f, -1.94336265e-01f, -2.30181873e-01f, -3.13851446e-01f, 9.73854214e-02f, -2.51202166e-01f, -2.43509516e-01f, -2.77129747e-02f, -1.66282862e-01f,
  2.55932242e-01f, -3.35063376e-02f, 1.66352525e-01f, 2.38056690e-01f, -9.68412980e-02f, 1.30131081e-01f, 2.43150920e-01f, -4.79158685e-02f, -1.16613451e-02f, 2.64594704e-01f,
  -3.93588981e-03f, 9.85950306e-02f, -1.53785110e-01f, 1.03779174e-01f, 2.84394383e-01f, -2.21041366e-01f, 2.17072859e-01f, -2.17785791e-01f, 1.31271824e-01f, 3.06748420e-01f,
  1.91944301e-01f, 2.48068236e-02f, 1.89488947e-01f, 1.61761135e-01f, 1.22850224e-01f, 7.43489191e-02f, -1.36036798e-01f, 1.24585838e-03f, 3.45235504e-03f, 3.25384401e-02f,
  1.05107307e-01f, -6.32714555e-02f, 2.71267109e-02f, -9.03795734e-02f, 1.42385200e-01f, 7.39101470e-02f, 7.42442012e-02f, 2.08615214e-01f, -5.59222847e-02f, -5.25306631e-03f,
  8.12141672e-02f, 1.20260883e-02f, -5.53657394e-03f, 1.23984434e-01f, -8.50330591e-02f, 1.03927024e-01f, -4.24087606e-02f, 4.39756811e-02f, -2.37357870e-01f, 1.69580311e-01f,
  -2.28269190e-01f, -1.12080432e-01f, -1.19851224e-01f, -1.51675284e-01f, 3.98839712e-02f, -1.05582826e-01f, -3.73617411e-02f, -3.45648290e-03f, 9.42247659e-02f, -2.19559252e-01f,
  1.42443627e-01f, -1.10877357e-01f, -2.22218800e-02f, 1.16670847e-01f, -1.87737763e-01f, 1.36050329e-01f, -2.68743247e-01f, 6.40525809e-03f, 7.90753886e-02f, 1.80855334e-01f,
  1.18711576e-01f, 1.81903407e-01f, 2.93904394e-01f, -1.57399520e-01f, -5.39749041e-02f, 1.05878018e-01f, 2.07696170e-01f, 1.22296423e-01f, 1.03708826e-01f, 2.40262628e-01f,
  1.57848984e-01f, 1.47261173e-01f, 1.28229067e-01f, 7.35370293e-02f, 2.02673808e-01f, 2.27424607e-01f, -4.24421160e-03f, -9.43553448e-03f, 1.87594190e-01f, -1.26818433e-01f,
  -7.12888166e-02f, 7.95894414e-02f, 6.18376024e-02f, 3.74829546e-02f, -5.63874990e-02f, 4.75115180e-02f, 2.79693991e-01f, 2.53891647e-01f, -7.52040930e-03f, 6.06680438e-02f,
  2.48558834e-01f, 3.21593806e-02f, 2.12910865e-02f, -1.88615522e-03f, 8.70122164e-02f, 1.66099742e-01f, 1.67288244e-01f, -5.07915206e-02f, -8.36103782e-03f, -1.40851382e-02f,
  1.18938744e-01f, 2.62241006e-01f, -4.66511026e-02f, 3.56453389e-01f, -4.05713208e-02f, -8.19441229e-02f, 1.57806307e-01f, -1.36937767e-01f, 1.08204298e-01f, -2.46678233e-01f,
  -4.15720083e-02f, 1.07929341e-01f, -5.80791645e-02f, 1.09814025e-01f, 1.62948161e-01f, -1.55353382e-01f, 8.95660520e-02f, -2.20214412e-01f, -7.53041133e-02f, -8.25236961e-02f,
  1.34271294e-01f, 2.10356265e-01f, 6.40663952e-02f, 3.03544521e-01f, 2.15078115e-01f, 2.60647267e-01f, 2.26595074e-01f, 1.92199230e-01f, -1.21713310e-01f, -1.63496868e-03f,
  -3.45401540e-02f, 2.92696744e-01f, 1.02874592e-01f, 4.29967120e-02f, 2.74547845e-01f, -1.03667326e-01f, 3.60173732e-01f, 1.55196726e-01f, 1.87186778e-01f, 2.91579336e-01f,
  1.31470099e-01f, 2.93711126e-01f, 6.23191185e-02f, 2.64424205e-01f, 1.52615502e-01f, 7.32971728e-02f, -1.41547814e-01f, 8.55890810e-02f, 1.29792124e-01f, -1.12630963e-01f,
  -8.79905000e-02f, -3.13636996e-02f, 6.80941939e-02f, -9.50337201e-02f, 2.22065955e-01f, 2.10598744e-02f, 1.35114491e-01f, -6.18132530e-04f, -2.14829296e-02f, -1.18178815e-01f,
  1.74469724e-01f, 2.31460765e-01f, 4.40880423e-03f, 1.73754975e-01f, 1.81742057e-01f, 7.91396201e-02f, 1.93754155e-02f, 3.88069674e-02f, -1.23661496e-01f, -3.00341517e-01f,
  -2.97185302e-01f, 2.00740993e-01f, -9.63478014e-02f, 7.45331347e-02f, -2.20379829e-01f, 6.21255040e-02f, 3.46128374e-01f, -3.07854891e-01f, -2.83957385e-02f, 1.83135763e-01f,
  -4.37452942e-02f, 1.70078769e-01f, -1.11204907e-01f, 2.25814104e-01f, -1.50288701e-01f, -6.72898963e-02f, 2.51991123e-01f, 2.90227979e-01f, 1.24789998e-01f, 2.86371082e-01f,
  1.76838294e-01f, -7.86124356e-03f, -2.70591587e-01f, -2.23395348e-01f, 3.13463509e-01f, -6.47223070e-02f, 2.11239651e-01f, 7.57075995e-02f, 1.07027195e-01f, -2.44340569e-01f,
  1.33782476e-01f, 1.77917778e-01f, 2.65758395e-01f, 6.52834326e-02f, -1.47899821e-01f, -7.97736645e-02f, -4.01880220e-02f, 2.76951697e-02f, 7.67574683e-02f, 4.77955565e-02f,
  4.68603112e-02f, 4.51266281e-02f, 1.66824266e-01f, -5.72307855e-02f, -8.29499960e-03f, -4.02614810e-02f, 7.89877102e-02f, 1.05794556e-01f, 2.00093210e-01f, 2.39573553e-01f,
  6.47917464e-02f, 1.00741580e-01f, 9.91460979e-02f, 2.07845762e-01f, 2.33622380e-02f, 2.53880359e-02f, 3.67563288e-03f, -1.21746965e-01f, 3.91191803e-02f, 2.30776593e-01f,
  -1.39646649e-01f, 2.98792779e-01f, -2.45560080e-01f, -1.08690619e-01f, -2.50531644e-01f, -1.81064114e-01f, 3.00498545e-01f, -1.45929148e-02f, 1.93680465e-01f, 5.32081872e-02f,
  2.74133444e-01f, -1.25649482e-01f, 2.09767655e-01f, 4.35737669e-02f, 1.22169629e-01f, 8.89355838e-02f, 5.37895551e-03f, 2.17307687e-01f, -9.72158611e-02f, -1.37672305e-01f,
  3.29784483e-01f, 3.00333817e-02f, 1.43323123e-01f, 1.88505933e-01f, 1.88082337e-01f, -1.31524146e-01f, 1.68961622e-02f, 4.36600558e-02f, 2.81891704e-01f, 1.44489380e-02f,
  -1.46868959e-01f, 3.37294638e-01f, -4.12880853e-02f, 2.86507815e-01f, 2.15760037e-01f, 7.70391256e-04f, 1.99902654e-01f, 8.62274021e-02f, 1.13373451e-01f, -3.49128209e-02f,
  9.72766504e-02f, 1.57676842e-02f, 2.41448164e-01f, 6.12749904e-02f, 1.65973410e-01f, 7.64120221e-02f, 1.37616292e-01f, 9.39557105e-02f, 7.00112432e-03f, -6.73302859e-02f,
  1.49421945e-01f, -1.67205334e-01f, 4.09694761e-02f, -5.03144935e-02f, -5.15581220e-02f, 1.02954857e-01f, 5.73731884e-02f, 1.18828200e-01f, 8.74808133e-02f, 4.47770581e-02f,
  -5.92363849e-02f, -2.37577185e-02f, 9.17102247e-02f, 1.70447260e-01f, -2.67740339e-01f, 1.23314530e-01f, -2.44724657e-02f, -1.09306522e-01f, 2.85748571e-01f, -1.01391831e-02f,
  -1.12498067e-01f, -2.35612188e-02f, -2.95122445e-01f, -1.51583776e-01f, -1.55778468e-01f, -8.29868615e-02f, -1.68531254e-01f, -3.04144118e-02f, 4.78008837e-02f, -1.00914784e-01f,
  -1.24676324e-01f, -2.13459823e-02f, 1.86988398e-01f, 1.88892186e-01f, -7.83436969e-02f, 2.32547119e-01f, 2.72344649e-01f, 2.02285573e-01f, -8.35682601e-02f, 7.33952969e-02f,
  6.05125278e-02f, -3.82561721e-02f, -2.22669199e-01f, 1.23223089e-01f, -3.45220082e-02f, -4.06655483e-02f, 2.22884938e-01f, -1.72436967e-01f, 3.00757051e-01f, 1.50441259e-01f,
  3.71325947e-02f, 2.17741117e-01f, 1.36661291e-01f, 5.20651042e-02f, 1.17255047e-01f, -2.50902660e-02f, 3.58578973e-02f, 8.39516073e-02f, 2.67714351e-01f, 4.45163846e-02f,
  1.26815006e-01f, 1.82664007e-01f, 1.69371277e-01f, -3.71265435e-03f, -1.00883087e-02f, -1.25912085e-01f, -1.12263270e-01f, 3.58024202e-02f, 4.89909053e-02f, 1.49193138e-01f,
  2.47890316e-03f, -1.50802014e-02f, 1.89660728e-01f, -2.09790424e-01f, -8.55080783e-02f, 1.27252638e-01f, 2.54705623e-02f, -8.38093832e-02f, 2.19041660e-01f, 1.43641746e-02f,
  2.77388930e-01f, -8.50170329e-02f, 2.36244306e-01f, 2.66211897e-01f, -9.00168121e-02f, 1.57082647e-01f, -1.68330044e-01f, -1.52757570e-01f, -9.47664455e-02f, 2.38444239e-01f,
  -3.38037938e-01f, -1.33531317e-02f, 3.07055190e-02f, -2.47357845e-01f, 3.28193754e-01f, 4.09791134e-02f, 4.01569575e-01f, 1.22799411e-01f, -1.86292052e-01f, 1.28722817e-01f,
  8.22713971e-02f, -1.42105445e-01f, 2.79381257e-02f, 2.75983214e-01f, 1.77783698e-01f, 4.00201976e-02f, -2.60574102e-01f, 5.62692285e-02f, 2.71936446e-01f, -3.56233656e-01f,
  1.42093107e-01f, -8.55697412e-03f, 6.34793714e-02f, 2.56431311e-01f, 4.22326997e-02f, 6.26328364e-02f, 1.54415637e-01f, 2.39149481e-01f, 3.20469216e-02f, 1.21503152e-01f,
  6.94226772e-02f, -1.92941710e-01f, -1.12723589e-01f, -3.90754156e-02f, 1.19458854e-01f, 9.68867168e-03f, -9.00289118e-02f, -1.04191832e-01f, -8.32303613e-02f, -4.36996818e-02f,
  7.48791248e-02f, 1.95841521e-01f, -3.58334072e-02f, -8.95878077e-02f, -1.49531728e-02f, -1.59196295e-02f, 2.06355855e-01f, 7.15258792e-02f, -1.36676401e-01f, 3.53644222e-01f,
  1.58268332e-01f, -7.96602741e-02f, -1.50678143e-01f, 2.63626486e-01f, -3.82071026e-02f, -1.31136760e-01f, -1.59915492e-01f, 2.63734907e-01f, -1.14419051e-01f, -8.20616484e-02f,
  -6.96997717e-02f, -5.07129990e-02f, 3.70657921e-01f, -2.45216489e-01f, 2.93139424e-02f, 2.94091046e-01f, -6.04404882e-03f, 4.77201417e-02f, 7.70139545e-02f, 2.86961019e-01f,
  1.40707493e-01f, -6.05131462e-02f, 2.31317952e-01f, 1.78143471e-01f, -1.20437503e-01f, 4.34269197e-02f, 2.12256759e-01f, 8.31514597e-02f, -1.74892321e-01f, 4.62189466e-02f,
  9.94504467e-02f, 1.26607632e-02f, 1.59380004e-01f, 1.14993766e-01f, 1.57282650e-01f, -1.84989095e-01f, 1.72936488e-02f, 2.27916747e-01f, 1.84655115e-01f, 4.33470570e-02f,
  -6.25229403e-02f, 1.83742180e-01f, 1.68579131e-01f, 1.49089247e-01f, 2.23528326e-01f, 2.53797114e-01f, 1.88505217e-01f, 6.18217140e-02f, 1.94345698e-01f, 1.16481461e-01f,
  1.09314099e-01f, 8.55216458e-02f, 1.90368488e-01f, 2.11400837e-01f, -9.63327587e-02f, 1.32982299e-01f, 2.07197458e-01f, 2.16183543e-01f, 1.82716385e-01f, 2.03915134e-01f,
  8.74817893e-02f, 1.44912228e-01f, 9.64282900e-02f, -2.52135456e-01f, 2.65352666e-01f, 4.21388522e-02f, 2.29106337e-01f, -1.71237856e-01f, 1.11062355e-01f, -6.46699145e-02f,
  -2.08655864e-01f, 1.77584618e-01f, -2.75625110e-01f, 8.79540369e-02f, 1.63754597e-01f, -1.23658374e-01f, 7.31024742e-02f, -1.87819242e-01f, -2.23766178e-01f, -3.29360038e-01f,
  -6.98042512e-02f, 1.06294341e-01f, 4.32738394e-01f, 1.69979289e-01f, 1.41705155e-01f, 8.05965886e-02f, 1.15708634e-01f, 1.47368625e-01f, 1.35935387e-02f, -1.43617868e-01f,
  -9.05354321e-03f, 1.86355710e-01f, 1.81745619e-01f, 9.73759592e-02f, 1.92968890e-01f, -2.56329924e-02f, 1.45797029e-01f, -4.58532646e-02f, -2.65194446e-01f, -1.56659707e-02f,
  -6.34327307e-02f, 7.43541569e-02f, 1.87055379e-01f, -1.65227696e-01f, 7.36972913e-02f, 9.36284363e-02f, 1.37113020e-01f, 2.19204292e-01f, 2.14534923e-01f, -2.65153721e-02f,
  2.22045496e-01f, 1.23781636e-01f, 1.04308531e-01f, 1.27483606e-01f, -9.00674164e-02f, -8.77775159e-03f, 2.17761770e-01f, -9.89052951e-02f, -6.67011738e-02f, 8.83239955e-02f,
  8.01385939e-02f, 5.86597286e-02f, 8.56090114e-02f, 6.99408501e-02f, 1.31077617e-01f, -2.78841667e-02f, -1.40058309e-01f, -5.83113404e-03f, 8.50262046e-02f, -1.52411804e-01f,
  1.05040267e-01f, -4.75505650e-01f, 1.14751808e-01f, -1.64456576e-01f, -1.85724214e-01f, 3.66810113e-02f, -3.74849916e-01f, 1.83220401e-01f, 2.75687743e-02f, -2.94759750e-01f,
  1.22376025e-01f, -1.35630637e-01f, -1.92307547e-01f, -1.56455249e-01f, -3.37750651e-02f, 1.59214422e-01f, 3.75585586e-01f, 1.67862058e-01f, 1.17870253e-02f, 3.16888332e-01f,
  -1.26369279e-02f, 8.66925493e-02f, -1.10755809e-01f, -8.14316720e-02f, -8.16673227e-03f, 2.47707367e-01f, 4.75186482e-03f, 3.21266651e-02f, 8.62681419e-02f, -2.06532359e-01f,
  1.94573760e-01f, 2.58849990e-02f, -1.09235048e-01f, 6.25978708e-02f, 5.75176738e-02f, 1.89136207e-01f, 2.24852175e-01f, -1.72139585e-01f, 1.12498328e-01f, 5.28065935e-02f,
  1.09434530e-01f, -9.68254581e-02f, 2.88356263e-02f, -7.91576039e-03f, -1.20974900e-02f, 1.07023776e-01f, -4.49520238e-02f, 1.00545533e-01f, 7.76892528e-02f, 1.29636839e-01f,
  -2.10346252e-01f, 2.14002416e-01f, -8.87879580e-02f, 2.24312514e-01f, 1.23940654e-01f, -1.29132912e-01f, 1.47908807e-01f, 1.46229908e-01f, 1.39856160e-01f, -3.57915312e-01f,
  -2.18587056e-01f, -4.85163219e-02f, 7.69144967e-02f, -1.01304598e-01f, 1.16194703e-01f, 1.01083048e-01f, -2.26062406e-02f, 8.27084854e-02f, 1.88830882e-01f, 2.63398111e-01f,
  3.26896429e-01f, -2.31903851e-01f, 1.78144261e-01f, 5.35910986e-02f, 7.53117502e-02f, 3.68860245e-01f, 7.81329572e-02f, 1.64763138e-01f, 2.68144339e-01f, 2.13586334e-02f,
  1.67611957e-01f, 2.18529388e-01f, 1.71571866e-01f, -1.53156117e-01f, 1.39589339e-01f, -1.94259703e-01f, -1.10937998e-01f, -6.10454939e-02f, 1.79058164e-01f, 1.48802251e-01f,
  1.25496060e-01f, 5.42331710e-02f, 6.74220845e-02f, 1.84139341e-01f, 8.38157907e-02f, 8.00576061e-02f, 9.05729085e-03f, 2.18631968e-01f, 7.76062533e-02f, -1.30530596e-02f,
  4.27078754e-02f, -1.31415762e-02f, 2.28714012e-02f, 1.95941404e-01f, -9.72712599e-03f, -2.20574141e-02f, 1.03695400e-01f, -1.47966057e-01f, 3.44687440e-02f, 1.46136627e-01f,
  5.79766789e-03f, 3.11281662e-02f, 1.03032865e-01f, 9.95328575e-02f, 6.52985498e-02f, 2.04765916e-01f, 2.00643659e-01f, 2.00475112e-01f, 5.61083406e-02f, -1.33938894e-01f,
  2.38652937e-02f, 8.46450403e-02f, 5.96440509e-02f, 7.21929688e-03f, -1.32340416e-01f, 1.10581078e-01f, 1.07055597e-01f, -2.22026974e-01f, 2.01873630e-01f, 1.07332073e-01f,
  1.50026172e-01f, -4.29754443e-02f, -3.23873460e-02f, 2.39315048e-01f, -2.75244825e-02f, 2.04346284e-01f, 9.63627100e-02f, -1.83003098e-01f, 3.29000741e-01f, -1.69425592e-01f,
  -1.68808714e-01f, 2.10476458e-01f, -6.76741228e-02f, 2.35643059e-01f, 8.43253881e-02f, 2.72365153e-01f, 2.98657596e-01f, -6.36078790e-02f, 1.97885856e-01f, 4.02491726e-02f,
  -2.15329602e-01f, -2.16230661e-01f, -5.90397827e-02f, 1.60699606e-01f, -1.23944715e-01f, -1.63794756e-01f, 1.76875755e-01f, -1.07351601e-01f, 7.34699368e-02f, -9.64101925e-02f,
  -3.36099356e-01f, -1.94279358e-01f, -1.20626174e-01f, 2.17061177e-01f, 1.53802738e-01f, 8.07622373e-02f, -2.10960537e-01f, 3.88015471e-02f, 1.98134944e-01f, -4.01192196e-02f,
  1.21808328e-01f, 3.24658677e-02f, 1.75208941e-01f, 1.00570560e-01f, 9.69358459e-02f, 8.63167420e-02f, 2.35368058e-01f, -9.62186232e-03f, -2.14313455e-02f, 1.10876590e-01f,
  -1.02364570e-02f, -8.42610374e-03f, 1.81319520e-01f, 1.91016644e-01f, 1.77614138e-01f, -2.67881379e-02f, -8.11158270e-02f, -1.82808667e-01f, -1.40096366e-01f, -1.95175037e-01f,
  -1.96927175e-01f, -6.87127039e-02f, -2.05583856e-01f, 2.16999650e-01f, -2.11080328e-01f, 9.04529318e-02f, 1.48096159e-01f, -4.77241576e-02f, 3.43006521e-01f, 4.75448631e-02f,
  5.86995967e-02f, 4.87961210e-02f, -1.22461744e-01f, 1.97718710e-01f, 2.01190844e-01f, -2.54603736e-02f, 3.28938067e-01f, 9.64633077e-02f, 4.99929488e-03f, -1.53122231e-01f,
  -9.25562233e-02f, -1.58969641e-01f, 2.65697569e-01f, -6.13044202e-02f, -1.27004068e-02f, 1.31965846e-01f, 2.75735140e-01f, 1.01362437e-01f, 1.30242109e-01f, 3.03638041e-01f,
  7.47765750e-02f, 7.83972591e-02f, 3.63632701e-02f, 2.71881521e-01f, 2.97979057e-01f, 2.74993956e-01f, 8.55821893e-02f, -1.36687815e-01f, 5.64640313e-02f, 2.90923238e-01f,
  1.86221704e-01f, -4.13404144e-02f, 1.02449007e-01f, 8.92262459e-02f, -1.02266535e-01f, -5.71337231e-02f, -6.83305487e-02f, 3.82910036e-02f, -5.39600365e-02f, -1.36767209e-01f,
  5.68840653e-02f, -2.76203007e-02f, 5.58775738e-02f, 1.15861505e-01f, 2.30465204e-01f, -2.35812441e-02f, 1.52192950e-01f, -1.00895688e-02f, 1.78778067e-01f, -1.18867308e-01f,
  1.93878058e-02f, 1.39045492e-01f, -1.74558423e-02f, -1.69630766e-01f, -1.76175952e-01f, 2.27347717e-01f, -1.88508645e-01f, 1.35672033e-01f, -2.99455941e-01f, -1.36323586e-01f,
  -9.14620832e-02f, -2.38220379e-01f, 3.18341345e-01f, 6.49575517e-02f, 2.05035090e-01f, -1.24393426e-01f, 2.10206881e-01f, -2.13601753e-01f, 2.83715785e-01f, -5.81804663e-02f,
  1.49353547e-02f, 2.57960290e-01f, -2.40267932e-01f, 1.68771043e-01f, -1.93972766e-01f, -7.46235624e-02f, 2.41644278e-01f, -4.20442186e-02f, -9.68617350e-02f, 2.10046276e-01f,
  5.20257577e-02f, -6.59946352e-02f, -1.60120968e-02f, 1.23825274e-01f, 2.33768508e-01f, 8.03156197e-02f, -6.79648593e-02f, 3.49257648e-01f, 9.03744996e-02f, 8.98412168e-02f,
  8.61667246e-02f, 8.62214044e-02f, 1.03250377e-01f, -8.90141055e-02f, -2.54953150e-02f, -2.14596078e-01f, 2.19661355e-01f, 9.31369960e-02f, 1.70029923e-01f, 1.44830018e-01f,
  1.35645121e-01f, 4.15046066e-02f, 1.45127937e-01f, 6.58701062e-02f, 1.16622545e-01f, 2.13582516e-01f, 2.33959138e-01f, 6.34535924e-02f, -7.30620846e-02f, 2.21536219e-01f,
  7.22052380e-02f, 2.49952793e-01f, 5.33501543e-02f, 2.33403549e-01f, -8.12672973e-02f, 1.65055230e-01f, -1.22667542e-02f, -2.44231507e-01f, -2.39237398e-02f, 9.99611765e-02f,
  -1.21460237e-01f, -8.05575326e-02f, -2.30838403e-01f, 3.49842981e-02f, -1.18433572e-01f, -1.00489654e-01f, -8.03969428e-03f, 1.24701515e-01f, 1.94274381e-01f, -1.93484090e-02f,
  -7.19005540e-02f, 6.14372343e-02f, -5.59210731e-03f, -2.67773747e-01f, 1.15930907e-01f, 6.38495460e-02f, 7.33096525e-02f, 1.46163374e-01f, -1.08298853e-01f, 1.04793794e-01f,
  2.00967982e-01f, -1.05058542e-02f, 1.87470809e-01f, 1.97917119e-01f, 2.42809370e-01f, -5.79421148e-02f, 1.44731462e-01f, 1.09530531e-01f, 1.53487816e-01f, 1.67263016e-01f,
  -6.90247118e-02f, 1.37073934e-01f, 1.83595255e-01f, 3.48707736e-01f, 1.65871292e-01f, -5.96281216e-02f, 1.71017826e-01f, -8.30325484e-02f, 2.68547893e-01f, 1.79681629e-02f,
  1.02387682e-01f, 1.93686754e-01f, 7.71504715e-02f, 5.73930889e-02f, 5.29827029e-02f, 1.32559970e-01f, 2.69093215e-02f, 1.36211917e-01f, 2.51501977e-01f, 1.41932815e-01f,
  2.19093561e-01f, 8.94353390e-02f, 1.28791332e-01f, 9.65513736e-02f, 3.44405286e-02f, 1.09146975e-01f, 1.58601567e-01f, 2.81089604e-01f, -1.29706606e-01f, 2.83867329e-01f,
  -2.28491813e-01f, -2.98632771e-01f, 9.45658684e-02f, 1.21470727e-01f, 1.99086542e-04f, 7.59851933e-02f, -2.47995749e-01f, -1.56240329e-01f, -4.56011817e-02f, -2.01496348e-01f,
  1.33721069e-01f, 1.68052226e-01f, -1.67597368e-01f, -3.81594300e-02f, -1.96885839e-01f, 2.42017824e-02f, 1.88835010e-01f, -1.88150361e-01f, 2.19380900e-01f, 1.55196518e-01f,
  -1.37196764e-01f, 2.18381528e-02f, 8.23137537e-03f, 2.66792148e-01f, 2.82833576e-01f, 1.66559964e-01f, 3.29123467e-01f, 1.35248408e-01f, 4.27777804e-02f, -2.62444198e-01f,
  3.05180997e-01f, 2.07019925e-01f, 2.04931378e-01f, 2.03488857e-01f, 4.64612693e-02f, 3.06096107e-01f, 4.73164581e-02f, 1.04091682e-01f, 3.32862884e-01f, -2.47092769e-02f,
  1.71695173e-01f, -3.77615653e-02f, 2.30422258e-01f, 8.33829269e-02f, 4.03142944e-02f, -2.20072031e-01f, -3.49534564e-02f, -7.74881467e-02f, 8.31550062e-02f, -1.08789034e-01f,
  -9.57742482e-02f, 1.99083462e-01f, 7.45494515e-02f, -1.86226852e-02f, -9.37691033e-02f, 2.16665596e-01f, -8.44714046e-02f, -5.67319393e-02f, 1.15658209e-01f, -4.27080765e-02f,
  1.22725464e-01f, 1.04001686e-01f, 1.65167734e-01f, -2.19552323e-01f, -2.30139285e-01f, 2.35782295e-01f, -1.03595881e-02f, -2.18572780e-01f, -9.84409377e-02f, 1.65780053e-01f,
  -8.71625450e-03f, 1.56779125e-01f, 1.33263141e-01f, 2.55420476e-01f, 1.56509101e-01f, -2.24999741e-01f, 4.82523851e-02f, 3.41512978e-01f, -8.65566730e-03f, 1.04501538e-01f,
  3.68928164e-02f, 1.43274203e-01f, 1.28889725e-01f, 3.64225358e-03f, -1.24365455e-02f, 5.21491133e-02f, 1.65627897e-02f, -1.07797772e-04f, 6.90562204e-02f, 1.14720292e-01f,
  6.60899803e-02f, 7.46775791e-02f, 2.63949394e-01f, 2.12778211e-01f, 1.83702018e-02f, 8.26016217e-02f, -1.05934612e-01f, 2.96121269e-01f, 2.22848788e-01f, -1.12744562e-01f,
  8.20892081e-02f, -5.64708747e-02f, -3.95994931e-02f, -4.30792533e-02f, -4.32455167e-02f, 1.73238844e-01f, 9.19091105e-02f, 1.37499169e-01f, -1.21470429e-01f, -4.13166694e-02f,
  -2.00388562e-02f, -2.02323094e-01f, -6.62759990e-02f, 2.03244877e-03f, 1.53954461e-01f, 8.17491561e-02f, -1.40337190e-02f, 8.62710923e-03f, -6.87743872e-02f, 4.30378802e-02f,
  1.99281633e-01f, -6.92261010e-02f, -1.35524139e-01f, 3.89721207e-02f, 2.54948102e-02f, -3.74706797e-02f, 2.96424348e-02f, -1.88421503e-01f, -1.69407159e-01f, 3.00421268e-01f,
  2.21554145e-01f, -1.59563482e-01f, -1.57114655e-01f, 1.62792623e-01f, 4.52388488e-02f, -1.45571455e-01f, 1.35139063e-01f, 3.52255851e-01f, -4.22660522e-02f, -1.97911799e-01f,
  -9.56870839e-02f, 1.23754226e-01f, 3.46993953e-01f, -1.70563966e-01f, 2.18913257e-02f, 4.37315017e-01f, -1.10851198e-01f, 3.44457850e-02f, -1.85582384e-01f, 2.35186294e-01f,
  -1.86084341e-02f, -1.22023128e-01f, -6.54534698e-02f, 9.90188345e-02f, 2.23411806e-02f, 1.07470304e-01f, 3.13389786e-02f, 2.30013162e-01f, -3.11281055e-01f, -7.19318092e-02f,
  2.81790202e-03f, 2.55442578e-02f, 2.48001218e-01f, 1.54009953e-01f, -1.17793597e-01f, -1.79213867e-01f, -4.81263064e-02f, 5.73224574e-02f, 1.78374633e-01f, 1.74146459e-01f,
  -2.52962530e-01f, 8.36918876e-02f, 1.34942234e-01f, 6.33868575e-02f, 5.93849309e-02f, -6.66260570e-02f, 6.20697588e-02f, 1.32848024e-01f, 8.63388702e-02f, -5.91600798e-02f,
  1.11974336e-01f, 2.23762933e-02f, 1.78484209e-02f, 1.05343945e-01f, 1.59510896e-01f, 1.41378343e-01f, 1.49787199e-02f, 5.97291254e-03f, 1.98275179e-01f, 2.13412568e-01f,
  8.80301967e-02f, -3.73120559e-03f, 5.24276458e-02f, 7.21267760e-02f, 3.41918021e-01f, -8.21506456e-02f, -1.39498403e-02f, 1.16685471e-02f, 5.39231822e-02f, -3.92731801e-02f,
  2.08800975e-02f, 1.58773825e-01f, -2.56818652e-01f, 1.34431003e-02f, -1.68657094e-01f, -9.34381858e-02f, 1.38678089e-01f, -4.75625396e-02f, -4.89186682e-02f, 3.37279914e-03f,
  -1.88589364e-01f, -4.85635735e-02f, 1.53251156e-01f, 1.77145183e-01f, 8.44159350e-02f, 3.92926484e-02f, -5.51255830e-02f, 1.80268720e-01f, 1.80585608e-01f, 1.45489588e-01f,
  9.79237333e-02f, 1.06766850e-01f, -1.08485274e-01f, -1.76664338e-01f, 1.34911031e-01f, 9.22374278e-02f, 1.51363179e-01f, -5.70843369e-03f, -1.15442164e-01f, -1.95655733e-01f,
  1.99696973e-01f, 1.60512939e-01f, 2.55049348e-01f, 7.93465227e-02f, -6.24899678e-02f, 9.74464044e-02f, 9.30973813e-02f, 3.02011967e-01f, -2.76571494e-02f, 1.05277017e-01f,
  -1.07678354e-01f, 1.80750951e-01f, -2.23440360e-02f, -1.02927228e-02f, -2.85697877e-02f, 5.70395291e-02f, 2.75469273e-01f, -6.31645620e-02f, 2.77666330e-01f, -7.96792507e-02f,
  -1.41341567e-01f, 4.08577956e-02f, 2.12862551e-01f, 5.85944131e-02f, 7.80261829e-02f, 3.67773116e-01f, -1.11204409e-03f, -3.64515074e-02f, 2.79953331e-01f, 1.58718601e-01f,
  -9.51023772e-02f, -1.38369963e-01f, -2.90442079e-01f, -1.46370083e-01f, 4.75331023e-02f, -1.35644481e-01f, -3.68027866e-01f, 5.60769327e-02f, -2.60551572e-01f, -6.57598004e-02f,
  8.94571692e-02f, -2.40594432e-01f, 2.67142672e-02f, -9.93322060e-02f, -1.90246239e-01f, 1.03551768e-01f, -1.41634598e-01f, 8.01301599e-02f, -1.59095734e-01f, 1.60787180e-01f,
  1.26785323e-01f, 3.23988736e-01f, 2.13523313e-01f, 1.37644321e-01f, 1.28741875e-01f, 2.81605683e-03f, -1.12248354e-01f, -1.01844497e-01f, 9.00976062e-02f, -8.59638229e-02f,
  2.64653683e-01f, 1.43888861e-01f, 2.78499722e-02f, -2.88064480e-01f, 2.54862875e-01f, 2.47578695e-01f, 8.30700547e-02f, 6.09780289e-02f, -5.86985759e-02f, 1.24747664e-01f,
  1.79968197e-02f, 2.07209826e-01f, 6.61932826e-02f, 2.23347433e-02f, 3.04075301e-01f, 5.69159761e-02f, 8.19519982e-02f, 2.84172505e-01f, -4.33509797e-02f, 1.03493087e-01f,
  1.10929653e-01f, 2.11887993e-02f, -6.21716939e-02f, 3.05275947e-01f, 2.11480811e-01f, -8.00312310e-03f, -4.38598208e-02f, 2.11413503e-01f, -2.15606596e-02f, 3.47179249e-02f,
  -1.03276312e-01f, -1.59155026e-01f, 2.60138780e-01f, -6.29957616e-02f, 3.26713324e-01f, -3.04265261e-01f, 2.44774997e-01f, -1.54621184e-01f, -1.82380632e-01f, 2.87311405e-01f,
  -5.31191155e-02f, 1.42343819e-01f, 1.95441559e-01f, -2.76748836e-01f, 2.77175754e-01f, -5.37582338e-02f, -1.83701381e-01f, -1.57047287e-02f, 1.63784593e-01f, 2.17962146e-01f,
  2.27448180e-01f, 2.61254847e-01f, 4.56621274e-02f, -1.29211888e-01f, 2.65460342e-01f, -9.93305743e-02f, -2.28891581e-01f, -2.64713258e-01f, -5.26459068e-02f, 2.90039152e-01f,
  4.71059643e-02f, 2.53194094e-01f, 1.54871553e-01f, -7.25578144e-02f, 2.80516565e-01f, -5.57730198e-02f, -3.09784263e-01f, 1.74756244e-01f, -1.49488896e-01f, -7.07146302e-02f,
  2.84113020e-01f, -1.13062948e-01f, 2.84959376e-02f, -1.25034228e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.92494065e-01f, -6.53848425e-02f, -1.42037785e-02f, 1.81578740e-01f, 6.31041676e-02f, 4.74179126e-02f, -2.44603655e-03f, 1.64646417e-01f, -4.47917432e-02f, 1.55806497e-01f,
  1.50675952e-01f, 2.36195385e-01f, 1.85962066e-01f, 5.68085499e-02f, 8.23509973e-03f, 1.20106570e-01f, 9.04245898e-02f, 1.75970942e-01f, 1.16727419e-01f, 1.88858241e-01f,
  1.50556475e-01f, -5.81131279e-02f, -2.83396952e-02f, 1.70788288e-01f, -4.42880439e-03f, 1.47972792e-01f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -1.44353271e-01f, 8.48212913e-02f, -7.52348751e-02f, 1.72538124e-02f, -8.93344134e-02f, 2.04772055e-02f, 1.67981595e-01f, -1.11418776e-01f, 8.93815979e-02f, 2.44440269e-02f,
  -3.61327492e-02f, -1.03138112e-01f, -1.17438219e-01f, 8.96668211e-02f, 1.31803721e-01f, 1.17887780e-01f, 4.60144468e-02f, 5.40555939e-02f, 1.52026683e-01f, -1.67296886e-01f,
  -1.94997445e-01f, -1.84546083e-01f, 2.55838960e-01f, 1.49397358e-01f, -1.16198119e-02f, -2.28178352e-01f, 1.72820091e-02f, -2.13305712e-01f, 1.84465796e-01f, 1.02663979e-01f,
  -1.45353571e-01f, 1.99691001e-02f, -1.66592047e-01f, 2.98810210e-02f, -1.52378187e-01f, 7.35700801e-02f, 7.31129572e-02f, -2.17041224e-01f, 1.81607325e-02f, 3.49122360e-02f,
  -3.35506387e-02f, 1.00254714e-01f, 6.03349414e-04f, 1.13736354e-01f, 8.52828380e-03f, -6.14034869e-02f, -4.02393676e-02f, 9.89355892e-02f, 1.37822524e-01f, 1.48438290e-01f,
  1.83658618e-02f, -9.03620198e-02f, -1.32991880e-01f, 1.13705378e-02f, -1.25615522e-01f, 1.26796708e-01f, -1.02155969e-01f, -9.39131230e-02f, -3.85433175e-02f, 3.58270444e-02f,
  1.51661068e-01f, 1.50677964e-01f, -5.96317202e-02f, -2.31450126e-02f, -1.62509978e-01f, -6.72313645e-02f, 9.08755884e-02f, 4.09663655e-02f, -3.65181826e-02f, 5.41551001e-02f,
  8.64357874e-02f, 5.82796410e-02f, 1.00058809e-01f, -6.46203533e-02f, -9.22527090e-02f, -1.58703879e-01f, 3.02126110e-02f, 7.64075965e-02f, 1.34318858e-01f, -1.49627343e-01f,
  -7.02051818e-02f, -4.10388745e-02f, 5.46723567e-02f, -7.06369653e-02f, 7.75509179e-02f, 1.79167818e-02f, -1.29588261e-01f, 1.14503846e-01f, 2.38322094e-02f, 6.93838373e-02f,
  3.08688972e-02f, 5.14152721e-02f, -9.58399847e-02f, -3.49404179e-02f, 9.38972682e-02f, -1.04814291e-01f, 8.14668313e-02f, -1.28621995e-01f, 1.47346139e-01f, 8.84433091e-02f,
  -1.34371027e-01f, -1.78796485e-01f, 2.19049081e-02f, -1.04123794e-01f, -8.59942809e-02f, 1.44952729e-01f, 1.88821536e-02f, -4.18385398e-03f, 8.24548677e-02f, -1.67079672e-01f,
  -1.71936557e-01f, -1.07136264e-01f, -2.08072022e-01f, -8.33439380e-02f, 2.73392294e-02f, 1.74413949e-01f, 8.94281715e-02f, 1.39442503e-01f, 1.58703909e-03f, 1.11825764e-01f,
  -1.45386355e-02f, -1.22067546e-02f, 2.47854013e-02f, 1.09534718e-01f, 6.93503693e-02f, 9.89919715e-03f, -1.67949930e-01f, 6.06968775e-02f, 9.37965512e-02f, 6.79920092e-02f,
  -5.95616214e-02f, -6.07348718e-02f, 3.93071845e-02f, 4.42676730e-02f, -1.71138346e-01f, 3.43525149e-02f, 5.06307371e-02f, -1.09450065e-01f, -9.63902175e-02f, 5.03186509e-02f,
  3.02343592e-02f, 8.45952183e-02f, 1.39833227e-01f, -7.23282322e-02f, -8.88820514e-02f, -7.71259218e-02f, 3.32415104e-03f, 4.58612777e-02f, 3.95398736e-02f, 1.69358954e-01f,
  1.95332188e-02f, 9.19242576e-02f, 1.56887531e-01f, 5.65729849e-02f, 8.24273005e-02f, -8.51376131e-02f, -3.33020426e-02f, 9.29165706e-02f, 1.24099441e-01f, 4.89653014e-02f,
  6.94778413e-02f, 3.77833955e-02f, -6.72158524e-02f, -1.07832327e-01f, 1.23138316e-01f, 2.62551736e-02f, -5.08572944e-02f, 7.99167231e-02f, 1.03628501e-01f, -1.08355269e-01f,
  2.52772658e-03f, 1.58807948e-01f, -7.20762908e-02f, -2.78998557e-02f, -2.24355310e-02f, 6.52067736e-02f, -6.00423589e-02f, 4.32232283e-02f, 2.47259978e-02f, 3.51066366e-02f,
  8.60243440e-02f, 4.95433509e-02f, 1.44864812e-01f, -9.76492185e-03f, -9.73859977e-04f, -1.91612557e-01f, -4.13152836e-02f, 8.25307965e-02f, -3.91618088e-02f, 1.95595399e-02f,
  1.45219907e-01f, 5.06872125e-02f, -8.10008571e-02f, 1.15228966e-01f, -3.26632299e-02f, -5.36893420e-02f, 2.80631445e-02f, 4.27887263e-03f, 2.96862554e-02f, -1.04260780e-01f,
  -7.78868198e-02f, 2.17795335e-02f, -2.48219147e-02f, -1.34110481e-01f, 9.46215168e-02f, -5.39885426e-04f, -8.53829980e-02f, 4.91990931e-02f, -1.04409456e-01f, 9.52993035e-02f,
  -7.64154596e-03f, 7.36122206e-02f, -1.57654762e-01f, 8.26729275e-03f, -1.09355740e-01f, -9.14118439e-02f, -4.75811251e-02f, -5.62021835e-03f, -1.21300779e-01f, -1.26986891e-01f,
  1.92834437e-01f, 3.14330570e-02f, 5.35835251e-02f, 1.18215702e-01f, -1.03030883e-01f, -5.78832440e-02f, -1.96036801e-01f, 5.48844598e-02f, -4.71207220e-03f, 2.33001146e-03f,
  1.05599560e-01f, 1.52222529e-01f, 1.80088609e-01f, 3.95326987e-02f, 6.45578802e-02f, -1.99600756e-01f, -1.26902747e-03f, 6.82498217e-02f, -5.63552231e-02f, 4.80397791e-02f,
  3.66349630e-02f, 1.16463572e-01f, 8.44924375e-02f, -1.45685136e-01f, -5.65198734e-02f, 9.74804014e-02f, -3.07090878e-02f, 9.24100634e-03f, 4.87094335e-02f, -9.31840315e-02f,
  -8.43203664e-02f, 9.29190218e-02f, 3.98371033e-02f, 6.19712344e-04f, -1.99290812e-02f, 7.16848224e-02f, -2.63332520e-02f, -9.24013332e-02f, -3.01714428e-02f, 3.71198133e-02f,
  1.23890989e-01f, 1.36478096e-01f, 1.07119352e-01f, 2.98622604e-02f, 2.33045500e-03f, 1.49013922e-01f, -2.31433064e-02f, -8.30490813e-02f, 5.97794279e-02f, 1.03798188e-01f,
  1.31629324e-02f, 9.94291827e-02f, 1.03209503e-01f, 1.46748245e-01f, 9.05237868e-02f, 4.57121320e-02f, -7.97867998e-02f, -1.58681832e-02f, 1.02231599e-01f, 4.82289493e-02f,
  5.90766184e-02f, -1.68033138e-01f, -1.39216602e-01f, -9.84921753e-02f, -6.43593445e-02f, -7.88367316e-02f, 7.46090636e-02f, -7.84353390e-02f, -1.29493460e-01f, 9.77500901e-02f,
  1.70540795e-01f, -1.26658440e-01f, -4.02275547e-02f, -1.09992512e-02f, 1.07706584e-01f, -1.31840082e-02f, -1.60373107e-01f, -4.86387946e-02f, -1.82677478e-01f, 1.71346828e-01f,
  -8.06583017e-02f, 1.16832484e-03f, 5.44331856e-02f, -1.50912598e-01f, 7.24186972e-02f, 3.33289616e-03f, 2.85235867e-02f, -8.25793855e-03f, -6.02166764e-02f, 1.67710930e-01f,
  -6.45032525e-02f, -6.54528365e-02f, -1.41381264e-01f, 2.52952930e-02f, -2.70914044e-02f, -5.74445985e-02f, -1.18931897e-01f, 2.23779120e-02f, -5.10777384e-02f, -1.06184799e-02f,
  -2.03803945e-02f, 9.81753618e-02f, 4.29580919e-02f, 9.61690098e-02f, 1.08612247e-01f, 1.00638203e-01f, 8.54100473e-03f, -7.81262517e-02f, 1.67105312e-03f, -1.39320930e-02f,
  1.01537071e-01f, -4.89475615e-02f, -9.87755060e-02f, -2.02625301e-02f, -9.63922590e-03f, -7.47374892e-02f, -2.75439229e-02f, -4.29370254e-02f, -7.46449679e-02f, -6.41351938e-02f,
  -1.25635520e-01f, 2.07867488e-01f, -1.92781523e-01f, 2.85648461e-02f, 6.31208941e-02f, 2.83029079e-02f, 6.69638533e-03f, -1.26760691e-01f, -5.53736016e-02f, 5.52285612e-02f,
  1.83401644e-01f, -1.52331278e-01f, 1.07392915e-01f, -4.46546711e-02f, 9.22259539e-02f, -4.22506519e-02f, -1.24308042e-01f, 8.48791525e-02f, 5.31563908e-02f, -1.17690966e-01f,
  -5.05944714e-02f, -1.83009133e-01f, -8.87060165e-02f, -2.57325103e-03f, -2.09226813e-02f, 9.06851795e-03f, 8.47089738e-02f, -1.30209446e-01f, -9.71499830e-02f, 7.02065602e-02f,
  3.71507034e-02f, 1.19517967e-01f, 1.01622321e-01f, -2.00327467e-02f, 1.01893716e-01f, 4.93069552e-03f, -1.81801394e-01f, 1.73693448e-02f, -1.16416842e-01f, 8.40176642e-02f,
  -8.25222507e-02f, -8.22899789e-02f, -1.41503379e-01f, 1.67869195e-01f, 7.27024972e-02f, 1.04826458e-01f, -4.97998223e-02f, -1.44528583e-01f, -1.03437170e-01f, 9.14248377e-02f,
  -1.16058730e-01f, -7.48566166e-02f, 1.25308543e-01f, -4.00983989e-02f, -5.73822111e-02f, 1.69440210e-02f, 1.11417063e-01f, 7.05462918e-02f, -1.24891616e-01f, -4.05260399e-02f,
  1.88449305e-02f, 5.24328463e-02f, 9.39145535e-02f, -5.02690300e-03f, -1.94001809e-01f, 4.81449515e-02f, 2.69707036e-03f, 1.87568343e-03f, 1.71216562e-01f, 1.47705629e-01f,
  -9.68753323e-02f, -1.82183772e-01f, -1.91546947e-01f, -1.17271692e-01f, 1.17878661e-01f, -1.42330483e-01f, 9.45166126e-02f, 6.17875122e-02f, 5.15633747e-02f, -8.56604241e-03f,
  -1.08289480e-01f, -9.24618393e-02f, 3.98605280e-02f, 1.46100014e-01f, -2.25158259e-02f, 5.70966266e-02f, 9.79685783e-02f, 1.28051322e-02f, -1.10464491e-01f, -6.12472259e-02f,
  -1.45039439e-01f, -1.58928841e-01f, 1.71681821e-01f, 1.33609131e-01f, -2.19253190e-02f, 7.48150796e-02f, 7.54613876e-02f, 5.99858165e-03f, -7.46615082e-02f, -7.11900517e-02f,
  -5.95364533e-02f, 4.20708163e-03f, -6.70653954e-02f, 3.20148505e-02f, -5.72794154e-02f, 1.61322430e-01f, 1.46255279e-02f, 2.99137440e-02f, -5.30453920e-02f, 4.38925549e-02f,
  -8.67356434e-02f, 3.18927504e-02f, -3.21562402e-02f, 5.57949580e-02f, 6.87572807e-02f, -2.53827800e-03f, -6.30419515e-03f, -1.13544762e-01f, 2.75106207e-02f, -5.93741089e-02f,
  -4.26595956e-02f, 4.84303273e-02f, -1.74414247e-01f, -1.26768813e-01f, 5.72103774e-03f, -1.07084192e-01f, -1.21224135e-01f, -8.34973305e-02f, 7.01738475e-03f, 1.07342236e-01f,
  -2.73734238e-03f, -2.94730514e-02f, 3.59730795e-02f, -3.10790055e-02f, -1.51458874e-01f, -1.27090007e-01f, 7.43024498e-02f, 3.53499055e-02f, 6.75283149e-02f, 9.54528525e-02f,
  -1.51212071e-03f, -1.02474160e-01f, -5.05387560e-02f, -3.73450331e-02f, -6.66126609e-02f, -1.61095634e-01f, 1.76507961e-02f, 1.18771039e-01f, 1.11005694e-01f, 3.33181657e-02f,
  -1.21669367e-01f, 9.02335867e-02f, -1.73343226e-01f, 4.22415808e-02f, -1.64520666e-01f, -1.81198746e-01f, -5.71998432e-02f, 5.66817708e-02f, 5.80182746e-02f, -1.04012392e-01f,
  -1.66474301e-02f, 1.57778084e-01f, 9.42655951e-02f, -9.04694200e-02f, -8.38238075e-02f, -2.23655626e-02f, -5.49808182e-02f, -2.00954098e-02f, 1.24536663e-01f, 4.99496795e-02f,
  3.55424620e-02f, 4.33560722e-02f, -4.27693240e-02f, 4.68836166e-02f, -9.84812677e-02f, -5.01710512e-02f, -5.28176576e-02f, 6.60867691e-02f, -1.14307985e-01f, 8.50671828e-02f,
  5.54022603e-02f, 2.74234712e-02f, 5.07689780e-03f, 7.25833774e-02f, 7.85206780e-02f, 4.83418480e-02f, -2.47442257e-03f, -1.54984117e-01f, -1.13153130e-01f, -1.20273486e-01f,
  -1.42212108e-01f, 7.87290335e-02f, 1.61273956e-01f, 6.41660243e-02f, -1.62087768e-01f, -2.75358725e-02f, 1.53026180e-02f, 7.70183206e-02f, 1.82873145e-01f, 2.41612464e-01f,
  -1.82988778e-01f, -8.55462328e-02f, -2.44281837e-03f, -1.61100566e-01f, 1.83058038e-01f, -1.00156246e-02f, 7.85446316e-02f, 1.64659284e-02f, -8.34250730e-03f, 8.35977644e-02f,
  -9.36679021e-02f, -4.32927627e-03f, -1.84173703e-01f, 6.59847856e-02f, -6.09963806e-03f, 3.22694331e-02f, -1.18524849e-01f, -1.49676129e-01f, 3.45579013e-02f, 1.29373714e-01f,
  -1.12719677e-01f, 2.92832032e-02f, -7.67624080e-02f, 4.38953899e-02f, 9.57455412e-02f, -1.66318417e-02f, 1.16155200e-01f, -1.19834192e-01f, 1.16476223e-01f, -2.71811262e-02f,
  9.54719037e-02f, 1.68421399e-02f, -3.24270315e-03f, 3.35540511e-02f, -6.23182654e-02f, 1.23159170e-01f, 6.37685433e-02f, 5.15810698e-02f, -1.53262634e-02f, -2.64339428e-02f,
  -9.81878024e-04f, 9.01706889e-02f, 7.78541118e-02f, 8.11203793e-02f, -4.25336398e-02f, -8.37967917e-02f, 4.02774736e-02f, 1.13130704e-01f, -6.93094358e-02f, 1.01768054e-01f,
  -2.05026772e-02f, 1.08735174e-01f, 3.73501442e-02f, 4.40346561e-02f, 8.92315134e-02f, 8.35904852e-03f, 7.41149634e-02f, -8.19764882e-02f, 1.75344944e-01f, -7.63946474e-02f,
  4.15537041e-04f, -2.63856277e-02f, -1.48314172e-02f, 2.13210240e-01f, -6.38689697e-02f, 1.73298642e-01f, -5.44430502e-02f, 9.46297050e-02f, 7.81771354e-03f, 1.47320936e-02f,
  3.82072963e-02f, -5.14202602e-02f, 3.83733097e-03f, 2.46443853e-01f, -1.64124638e-01f, 1.27577186e-01f, 1.86256573e-01f, -1.48569942e-02f, -2.40808744e-02f, 3.32586244e-02f,
  2.73029972e-03f, -8.17748019e-04f, 2.03079149e-01f, -1.05710648e-01f, 8.39082301e-02f, 5.35174198e-02f, -6.49495348e-02f, 9.86274797e-03f, 3.35369557e-02f, -2.91323662e-01f,
  2.37920079e-02f, 6.20308816e-02f, -6.87995329e-02f, -9.03270841e-02f, 1.85693183e-03f, 8.80806819e-02f, -2.68612355e-02f, 1.63575009e-01f, 9.58335027e-02f, 9.91879925e-02f,
  2.39170752e-02f, -1.11298757e-02f, -1.63992718e-02f, -7.23466873e-02f, -1.03611045e-01f, -9.51248780e-02f, -1.34861186e-01f, -1.42519414e-01f, -1.96592100e-02f, -8.53017718e-03f,
  -5.84470369e-02f, -4.95111123e-02f, 8.39361995e-02f, -1.62817948e-02f, -1.23712353e-01f, 9.83699560e-02f, -1.32065490e-01f, -9.15798079e-03f, 1.34742260e-02f, 2.61091236e-02f,
  -9.97946262e-02f, 4.11516465e-02f, 4.40579504e-02f, -6.03588820e-02f, 1.29608825e-01f, 1.19262785e-01f, -2.20436901e-02f, 1.42792374e-01f, 1.02967568e-01f, 1.50219768e-01f,
  8.63673910e-02f, 1.11989841e-01f, -1.09529585e-01f, -1.50847659e-01f, -1.61566526e-01f, -7.81069845e-02f, 6.74231723e-02f, -2.58472059e-02f, -3.91232781e-02f, -2.88632582e-03f,
  1.88470274e-01f, -6.52567819e-02f, -1.16929844e-01f, -1.74899340e-01f, -4.39631082e-02f, 4.22086916e-04f, 8.48330930e-02f, 8.70582182e-03f, -9.21106562e-02f, -9.25702322e-03f,
  1.74223348e-01f, -4.60874252e-02f, -1.30793378e-01f, 1.63451321e-02f, 1.06769852e-01f, -1.13907471e-01f, -1.48123443e-01f, 1.15377214e-02f, -5.57158254e-02f, -2.68271044e-02f,
  1.88432127e-01f, 3.65293771e-02f, 1.02999032e-01f, -5.90776280e-02f, -7.27710575e-02f, -9.05132592e-02f, 9.71691459e-02f, 7.13937031e-03f, -1.10915221e-01f, -9.70512852e-02f,
  2.76688393e-02f, 3.96078564e-02f, 7.98577368e-02f, -1.01371601e-01f, -1.16432756e-01f, -2.55728792e-02f, -1.14356466e-01f, 1.09454736e-01f, 6.81545138e-02f, -1.98283374e-01f,
  8.27744007e-02f, 1.12271808e-01f, -6.58815354e-02f, -1.83778733e-01f, -9.97905359e-02f, -1.12664543e-01f, 1.14292108e-01f, 2.03377023e-01f, 7.08754063e-02f, -8.18607658e-02f,
  3.02842911e-02f, -1.23557113e-01f, -9.76178870e-02f, 3.81300710e-02f, -6.20758459e-02f, -1.23477675e-01f, -1.12042286e-01f, 1.62151515e-01f, -5.88870011e-02f, 1.57376215e-01f,
  9.14867446e-02f, -2.10311919e-01f, 8.82289335e-02f, -2.48042289e-02f, -5.09803705e-02f, -1.30939975e-01f, -6.57453388e-02f, 4.51552346e-02f, -1.78263173e-01f, 1.54873934e-02f,
  -1.66419754e-03f, -1.66074336e-01f, 1.20416194e-01f, 7.49233142e-02f, -6.24717474e-02f, 9.88343880e-02f, -2.69643981e-02f, -6.82485327e-02f, -8.77686143e-02f, 7.61931241e-02f,
  -9.23561975e-02f, 1.47962775e-02f, -1.33800497e-02f, 9.54999328e-02f, 1.45329684e-01f, -1.59038545e-03f, -5.28767183e-02f, -1.42468512e-01f, -7.18990788e-02f, -1.32888276e-02f,
  -1.31020710e-01f, 3.79158696e-03f, 8.30709338e-02f, 1.52262291e-02f, 3.59266587e-02f, -9.16910544e-02f, -1.45698890e-01f, 1.47014216e-01f, 1.45803630e-01f, -6.65199710e-03f,
  7.20185861e-02f, -7.09684715e-02f, 5.91019774e-03f, 1.50025368e-01f, 1.18391864e-01f, 1.01017319e-02f, 2.82247197e-02f, 2.42871661e-02f, -3.41407359e-02f, 1.11456756e-02f,
  -1.70735955e-01f, 1.14385411e-01f, -3.83973345e-02f, -1.93908408e-01f, 2.24390924e-02f, -4.80111316e-02f, 2.51239724e-02f, -1.07524410e-01f, -9.45883244e-02f, -6.80353642e-02f,
  -2.05558956e-01f, 1.92194924e-01f, 3.29824118e-03f, -1.05259404e-01f, 7.89680798e-03f, 1.78671092e-01f, -5.33424430e-02f, -1.34578627e-02f, -5.47161251e-02f, 7.15951473e-02f,
  6.03406923e-03f, -3.64286229e-02f, 1.21503972e-01f, -1.17973335e-01f, 6.96886554e-02f, 6.37096837e-02f, -1.10708922e-01f, 5.14594056e-02f, -5.94828911e-02f, 1.06721774e-01f,
  -9.71481800e-02f, -1.59408972e-02f, 5.17077604e-03f, -1.65058449e-02f, 1.15072101e-01f, 1.29091009e-01f, 8.28980654e-02f, 1.63933150e-02f, -1.42684847e-01f, -4.01782878e-02f,
  -5.48509397e-02f, 3.82294096e-02f, -3.12691331e-02f, -8.15283656e-02f, 1.73130836e-02f, -2.20745779e-03f, -4.50745933e-02f, 9.07831863e-02f, -1.00794896e-01f, 1.58667445e-01f,
  4.95471470e-02f, 7.36202523e-02f, 1.09393299e-01f, 4.74492535e-02f, 7.02873245e-02f, 1.19161345e-01f, -2.27209292e-02f, -5.39428182e-02f, 5.30547239e-02f, 5.00713177e-02f,
  -5.36743812e-02f, 6.21383823e-02f, 1.80765241e-01f, 2.46362120e-01f, -4.09462117e-02f, -1.34141609e-01f, 9.39943716e-02f, 2.14508399e-01f, 5.58019876e-02f, 2.89596856e-01f,
  -8.14205036e-02f, -6.64721057e-02f, 1.37449935e-01f, -1.29588753e-01f, 1.58275306e-01f, 1.26261413e-01f, 9.93866622e-02f, -1.49267584e-01f, -8.94443225e-03f, 1.91664666e-01f,
  -1.08149059e-01f, -1.11963958e-01f, 9.22546908e-02f, -6.20824955e-02f, 1.06929064e-01f, 1.33909479e-01f, -1.58020183e-02f, -3.80293354e-02f, -1.10340342e-01f, 8.24536011e-02f,
  -4.65217307e-02f, 1.92922205e-02f, 1.72168377e-03f, 1.27703488e-01f, -3.63225378e-02f, -1.31056011e-01f, -7.32087251e-03f, 8.48046988e-02f, 1.41041905e-01f, -6.96519613e-02f,
  -1.75301656e-02f, -1.31623909e-01f, -6.30774349e-02f, 1.11391181e-02f, 1.48495689e-01f, 1.49574190e-01f, -1.43802375e-01f, -1.50219137e-02f, -1.32894024e-01f, -1.72856212e-01f,
  7.10223690e-02f, -5.37627563e-02f, -4.15968858e-02f, -1.49436489e-01f, -4.27845307e-02f, 8.48103222e-03f, -7.58794323e-02f, -5.01091518e-02f, -1.44545510e-01f, -1.68636248e-01f,
  2.14670803e-02f, 8.75995262e-04f, 1.25209823e-01f, -2.82522645e-02f, 1.08139038e-01f, -3.25896442e-02f, -1.33712143e-01f, -5.45287766e-02f, 1.89322293e-01f, -2.75191329e-02f,
  1.60233647e-01f, -2.55181134e-01f, 2.60073375e-02f, -7.94110149e-02f, 1.30480543e-01f, -5.91913834e-02f, -6.76820874e-02f, -6.29890114e-02f, -1.26007184e-01f, 8.33307281e-02f,
  -1.46481499e-01f, 4.68221717e-02f, -4.54789288e-02f, -2.37599641e-01f, 1.10776976e-01f, -2.27744579e-02f, -9.90359336e-02f, -1.80459633e-01f, -1.21057004e-01f, -1.51731387e-01f,
  3.35587398e-03f, 6.95634708e-02f, 1.22957848e-01f, 4.81919199e-02f, 1.37553096e-01f, 1.49108246e-01f, 8.42105597e-02f, -5.63633442e-02f, -1.65508851e-01f, 1.79309975e-02f,
  -3.72325704e-02f, 4.28805687e-03f, 9.77877975e-02f, -3.62238698e-02f, -8.85639489e-02f, 1.31875202e-01f, 4.52673212e-02f, 1.71594732e-02f, -4.60841274e-03f, -1.30485758e-01f,
  -3.33075933e-02f, 2.47874279e-02f, 6.47767931e-02f, -5.23906993e-03f, -2.48223860e-02f, -8.14352781e-02f, 5.48288748e-02f, -8.91826376e-02f, 5.74656315e-02f, -3.99676934e-02f,
  7.61085376e-02f, 6.64547533e-02f, 8.89119804e-02f, 3.02527808e-02f, 3.35360877e-02f, -1.50064602e-01f, 8.20660219e-02f, 1.65173896e-02f, -1.71474833e-02f, -4.85623479e-02f,
  -1.07313149e-01f, -1.48385748e-01f, 2.47666508e-01f, 2.11902589e-01f, -9.10176858e-02f, -2.31330052e-01f, -1.23883285e-01f, -2.50780314e-01f, 8.04529712e-02f, 1.04215838e-01f,
  -2.47825626e-02f, 5.40867150e-02f, 1.67869311e-02f, 1.33169472e-01f, -4.24706899e-02f, 2.09721029e-01f, 9.93735269e-02f, -1.80868074e-01f, -1.82761215e-02f, -1.22412115e-01f,
  -8.23943913e-02f, -9.96554345e-02f, -9.95093137e-02f, 1.59574375e-01f, -8.07505921e-02f, 5.93470782e-02f, -1.92103639e-01f, -1.92098890e-03f, 1.42777160e-01f, 1.41646549e-01f,
  6.84584081e-02f, 1.86331454e-03f, 2.98168510e-02f, -3.57093178e-02f, -9.76895466e-02f, -4.65231240e-02f, 1.97190605e-02f, 8.18070546e-02f, -9.56816003e-02f, 7.15320930e-02f,
  -3.27776708e-02f, -4.59460951e-02f, -6.46248041e-03f, -6.35891780e-02f, -5.34668677e-02f, 1.23659766e-03f, 1.27987657e-02f, 8.10756981e-02f, 9.64853019e-02f, 9.21784416e-02f,
  -1.36855021e-01f, 1.70820821e-02f, 6.85270354e-02f, -2.21584607e-02f, -1.38291582e-01f, -8.11450556e-02f, 3.79265100e-02f, 3.32124680e-02f, 2.43073259e-03f, 1.01021096e-01f,
  9.24452022e-02f, -1.86402649e-02f, 3.48435417e-02f, 1.64416552e-01f, -8.88986811e-02f, 1.32496640e-01f, -1.26442418e-01f, 1.69504344e-01f, 1.08048931e-01f, -1.87863298e-02f,
  5.72646968e-02f, -2.20450051e-02f, 1.16616458e-01f, 1.42374849e-02f, 1.45448297e-01f, 1.77902449e-02f, 3.84814069e-02f, -2.35439036e-02f, -1.34366840e-01f, -6.99567646e-02f,
  -3.02913412e-02f, -1.55634508e-01f, 3.82411070e-02f, 3.43842022e-02f, 9.67155099e-02f, 1.37962261e-02f, -6.84428588e-02f, -1.17361933e-01f, -2.23365873e-02f, -7.45403022e-02f,
  9.99860913e-02f, 4.57254425e-03f, 4.06395011e-02f, 1.67683512e-02f, 1.49004615e-03f, -3.86164933e-02f, -4.72736917e-03f, 1.73440039e-01f, 9.71784815e-02f, -7.09901527e-02f,
  3.26826684e-02f, -7.65838698e-02f, -1.37254938e-01f, -6.71134936e-03f, 1.48480862e-01f, 1.23058431e-01f, -5.71529381e-02f, 1.41380159e-02f, -1.88488532e-02f, -2.98076682e-02f,
  -1.09493464e-01f, 1.11034334e-01f, 1.03968866e-01f, -2.74804756e-02f, 8.73871744e-02f, 6.13554865e-02f, 1.33963689e-01f, 3.65877151e-02f, 2.88442019e-02f, -2.53585204e-02f,
  1.39080942e-01f, -7.48827159e-02f, 1.53345272e-01f, 1.94784626e-02f, -9.19635519e-02f, -1.33192316e-01f, 4.07224968e-02f, -3.04332450e-02f, -1.26655176e-01f, -1.40041532e-02f,
  3.68616357e-02f, 3.73019651e-02f, 1.44010216e-01f, 6.30906522e-02f, 1.06324740e-01f, 1.44199478e-02f, -5.00305742e-02f, 6.51071453e-03f, 1.39060482e-01f, -1.33772552e-01f,
  1.56802475e-01f, 1.52220786e-01f, 5.39864451e-02f, -1.14198796e-01f, -8.70754048e-02f, -1.72990169e-02f, 6.03261292e-02f, 6.33482412e-02f, -4.70677391e-02f, -2.33192295e-02f,
  -8.83971825e-02f, 1.50734605e-02f, -8.84011686e-02f, 1.19534582e-02f, 1.27288103e-02f, -6.00814000e-02f, 1.45095542e-01f, 1.15471303e-01f, 7.33905509e-02f, 1.30505368e-01f,
  1.20896116e-01f, -2.75783464e-02f, 4.36569331e-03f, -5.01569510e-02f, -7.15570748e-02f, -2.66544800e-02f, -7.08024157e-03f, -1.40143171e-01f, -1.15722179e-01f, -5.64288460e-02f,
  2.10174848e-03f, 1.41112089e-01f, 7.84107819e-02f, 6.35367557e-02f, 1.00538962e-01f, 1.28958777e-01f, -2.62458678e-02f, 9.03920755e-02f, 1.56044319e-01f, -9.17718709e-02f,
  9.62750465e-02f, -2.15999619e-03f, -6.65572882e-02f, -7.08572753e-03f, -1.86476745e-02f, -4.28674929e-02f, -1.12999506e-01f, 2.18141899e-02f, -7.13237524e-02f, -6.05165511e-02f,
  1.37185425e-01f, -1.99433118e-01f, -1.14844859e-01f, -4.54117171e-02f, 1.56016454e-01f, 1.09608583e-01f, 1.47809446e-01f, -1.28424436e-01f, 8.43021646e-03f, -2.56848216e-01f,
  9.34005305e-02f, 4.24487703e-02f, 2.04548333e-02f, -2.69208942e-03f, 2.04697642e-02f, 6.29829392e-02f, -1.80451795e-01f, 1.74032152e-01f, -1.75846338e-01f, -2.27735922e-01f,
  1.45568550e-01f, -5.89812323e-02f, -6.10466003e-02f, -3.98428040e-03f, -1.12174712e-01f, -4.92347404e-02f, 7.01955929e-02f, -1.30448397e-02f, -1.30126908e-01f, -5.53406589e-02f,
  5.61896935e-02f, 1.80116981e-01f, -2.92643681e-02f, -2.55100504e-02f, -2.05981042e-02f, 1.70629933e-01f, -2.02438748e-03f, -5.50751053e-02f, -1.23653345e-01f, -5.65615743e-02f,
  -2.22664396e-03f, -2.79533118e-02f, 8.99737999e-02f, 1.91322029e-01f, 5.12741879e-02f, -3.77577990e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  1.41284361e-01f, 2.00560734e-01f, 1.22255370e-01f, 2.67957933e-02f, -5.14023937e-02f, 1.37476683e-01f, -1.50996270e-02f, 1.19697936e-01f, 1.57857448e-01f, -8.76814201e-02f,
  1.35382742e-03f, 8.05312321e-02f, 3.37689109e-02f, -7.19981268e-03f, -3.26667093e-02f, 1.40812233e-01f, 1.35160135e-02f, -4.11272019e-01f, -1.44248053e-01f, 2.40062345e-02f,
  7.76556358e-02f, 8.45249593e-02f, 3.97103310e-01f, -2.03779459e-01f, 1.60851344e-01f, 2.08846405e-02f, 1.24414749e-01f, 9.74699706e-02f, 4.20222357e-02f, 6.96396232e-02f,
  -2.72562444e-01f, 1.19423702e-01f, 2.56577522e-01f, 1.83650911e-01f, -1.14418298e-01f, -1.70544878e-01f, -4.28949073e-02f, 2.07115263e-01f, -4.08222787e-02f, 1.22761227e-01f,
  1.64298087e-01f, -1.09838478e-01f, -5.74454367e-02f, 4.10518982e-02f, 1.30490661e-01f, 1.95181325e-01f, 2.52253801e-01f, 7.00310394e-02f, 2.66203016e-01f, -1.39623014e-02f,
  1.69654340e-01f, 1.16447717e-01f, 1.60676986e-01f, -3.33062500e-01f, -2.87623815e-02f, -1.61216244e-01f, 1.02742903e-01f, -4.21594642e-03f, 1.67657390e-01f, -5.42022809e-02f,
  -2.57748403e-02f, 1.23498596e-01f, 4.03170168e-01f, -1.19694419e-01f, 1.51288301e-01f, 7.96878487e-02f, -7.14937970e-02f, 2.98601785e-03f, -6.09183908e-02f, 2.06642114e-02f,
  -1.57039046e-01f, 8.94150604e-03f, 2.31435433e-01f, -1.17155150e-01f, -4.70546372e-02f, 2.75542825e-01f, 4.64886166e-02f, 2.18481228e-01f, -2.03407761e-02f, -2.15769038e-01f,
  1.08096272e-01f, -1.19351454e-01f, 9.80407447e-02f, -9.67616364e-02f, 2.33217075e-01f, -7.60969743e-02f, -1.86851665e-01f, -2.97724634e-01f, -5.17856888e-02f, 3.94763827e-01f,
  1.15509734e-01f, 2.77237333e-02f, -2.56745577e-01f, -3.52095783e-01f, -1.15861952e-01f, -1.31453320e-01f, 1.87646002e-01f, -1.44319713e-01f, 2.74380654e-01f, -1.25869200e-01f,
  -4.92176525e-02f, 2.41413936e-01f, -4.12299633e-02f, -3.32125545e-01f, -3.92687805e-02f, 1.60958022e-01f, 2.43780807e-01f, 7.89804533e-02f, -6.87283790e-03f, -1.95901006e-01f,
  -2.52896339e-01f, -4.10256125e-02f, -1.37502402e-01f, 9.96690318e-02f, -7.51370937e-02f, 1.24659874e-01f, 2.40110725e-01f, 1.04701042e-01f, -5.23749851e-02f, 1.10069737e-01f,
  -1.03806332e-01f, 3.06264848e-01f, 1.21633112e-01f, -1.03739239e-01f, -1.15956418e-01f, -1.20334737e-01f, 7.62843341e-02f, 2.80820727e-01f, -2.32518077e-01f, 1.76039681e-01f,
  1.39332348e-02f, 5.16875088e-02f, 2.24444315e-01f, -3.64613980e-02f, 3.02223623e-01f, -5.71652427e-02f, -5.66126488e-04f, 2.02953164e-02f, 2.29762137e-01f, -1.04778096e-01f,
  -1.70633867e-02f, -1.58594266e-01f, 1.19736478e-01f, 1.89653367e-01f, -6.11491650e-02f, -3.49923857e-02f, -1.02177322e-01f, -9.84090008e-03f, -1.44041061e-01f, 1.52510747e-01f,
  1.56841904e-01f, 1.42249539e-01f, -1.19660608e-01f, -5.82390130e-01f, 9.97749716e-02f, -1.30357519e-01f, 5.03814816e-01f, 3.19410652e-01f, -2.93998897e-01f, 5.09760559e-01f,
  -4.40569818e-02f, 1.30573526e-01f, -1.35682628e-01f, 2.29969963e-01f, -2.23255694e-01f, 8.94542933e-02f, 7.65815899e-02f, 3.12659502e-01f, 4.07549972e-03f, -6.03531301e-03f,
  -1.40685648e-01f, 8.43091607e-02f, 1.54089406e-01f, 2.74313003e-01f, 1.71225905e-01f, 5.37326410e-02f, 1.33683383e-01f, 1.20377308e-02f, 2.07183868e-01f, -1.56591311e-01f,
  -2.49915808e-01f, -1.30391978e-02f, -1.08980998e-01f, 1.77596927e-01f, 2.45759115e-01f, 1.02378651e-01f, 7.10064843e-02f, 1.92290753e-01f, 1.74541920e-01f, 3.81965041e-02f,
  3.33450347e-01f, -3.34000945e-01f, -8.84277448e-02f, -1.33953243e-01f, -1.05480917e-01f, -4.04918864e-02f, -1.38919959e-02f, 1.86566953e-02f, -3.53354178e-02f, -1.35715241e-02f,
  -1.59416065e-01f, 1.96362257e-01f, -5.97839728e-02f, -2.04798341e-01f, 9.18594524e-02f, 5.54782934e-02f, -3.45602743e-02f, 1.45460814e-01f, 4.54262607e-02f, 1.07797734e-01f,
  -2.60791765e-03f, -2.77901977e-01f, -2.22044498e-01f, -2.33669803e-01f, -9.69563276e-02f, 3.27497989e-01f, 1.42980486e-01f, 1.11429282e-01f, -1.61550060e-01f, -3.56782675e-01f,
  2.59064853e-01f, 2.14708000e-01f, 1.72048464e-01f, 1.39770448e-01f, -2.04596981e-01f, -7.71878511e-02f, -3.51657689e-01f, 4.78981808e-02f, -1.90943450e-01f, -1.86270177e-01f,
  3.59779030e-01f, 1.85472861e-01f, 2.76338965e-01f, 3.72204557e-02f, -1.66520938e-01f, -3.54670398e-02f, 2.30949707e-02f, 1.07482664e-01f, 8.91927555e-02f, 7.37175196e-02f,
  1.70699768e-02f, 1.85528640e-02f, 2.63584912e-01f, -2.98562064e-03f, -3.53163555e-02f, 3.98088574e-01f, 3.80073152e-02f, 8.22226480e-02f, -1.62274331e-01f, -1.62675362e-02f,
  -5.37573993e-02f, 3.39320064e-01f, 1.71980336e-01f, 2.09815919e-01f, -9.79570448e-02f, 1.84480418e-02f, 2.13746697e-01f, -9.19258073e-02f, 1.73928738e-01f, 1.34352386e-01f,
  -1.53742969e-01f, -2.32031234e-02f, -4.00917716e-02f, 4.32774536e-02f, -1.66298226e-01f, 2.69813865e-01f, -1.21324599e-01f, 1.11268247e-02f, -1.40474318e-02f, -7.87088275e-02f,
  -1.11039996e-01f, 6.32027164e-02f, 2.71481365e-01f, 1.06993586e-01f, -2.62255520e-01f, 1.67171523e-01f, 2.66773134e-01f, 2.03569680e-01f, 5.27309328e-02f, 6.98299631e-02f,
  8.81881416e-02f, 2.06595719e-01f, 1.33478105e-01f, 3.45644981e-01f, 1.02078654e-01f, -3.03545338e-03f, 1.28278583e-01f, -1.88870341e-01f, -6.96595311e-02f, 1.41124085e-01f,
  -3.19113694e-02f, 3.23751057e-03f, -1.61318943e-01f, 8.94979462e-02f, 1.52774587e-01f, 5.51170334e-02f, -1.10124545e-02f, 7.26806074e-02f, 1.64707422e-01f, -6.11332767e-02f,
  4.01891507e-02f, 2.31061373e-02f, 1.53816104e-01f, 2.24274844e-01f, 2.19497248e-03f, -2.35849008e-01f, 5.31496219e-02f, 4.71287873e-03f, -7.83304349e-02f, 1.70535639e-01f,
  9.53952074e-02f, -5.92916273e-02f, 9.50868651e-02f, 5.20364679e-02f, 1.58425882e-01f, -1.05160773e-01f, 1.86815679e-01f, 1.58672571e-01f, 7.83358663e-02f, 2.69792713e-02f,
  1.76680908e-01f, -1.10555381e-01f, 1.54779837e-01f, -1.04373068e-01f, 4.61157858e-02f, 5.21028079e-02f, -4.47243229e-02f, 1.42874062e-01f, 1.31556913e-01f, -1.11373607e-02f,
  -2.21288726e-02f, 2.12078974e-01f, 1.25199467e-01f, 1.82397231e-01f, -1.38519134e-03f, 7.77908601e-03f, 2.70373151e-02f, -1.78189576e-01f, 1.55862972e-01f, -1.95116192e-01f,
  -8.62745419e-02f, -2.73840696e-01f, 1.98852047e-01f, -5.98350801e-02f, 1.93181306e-01f, 1.51970595e-01f, -2.10805446e-01f, -3.12992990e-01f, -5.78379370e-02f, -2.35814154e-02f,
  -5.99532500e-02f, -5.38429199e-03f, -7.11199641e-03f, -6.40364066e-02f, -4.41682860e-02f, -1.97653621e-02f, 6.36698082e-02f, -2.03029186e-01f, 4.51566242e-02f, -2.97988564e-01f,
  3.00244272e-01f, -2.33670041e-01f, -1.29403368e-01f, 3.15045297e-01f, -6.07661903e-02f, 2.47647047e-01f, 7.76243582e-02f, -2.64973164e-01f, 2.68145621e-01f, 2.87852436e-01f,
  9.97797772e-02f, -3.33437286e-02f, 8.94442424e-02f, 3.67569663e-02f, 7.62654543e-02f, -9.56046209e-02f, -4.42179888e-01f, -3.83692272e-02f, 1.08245499e-01f, 2.44063258e-01f,
  1.61866143e-01f, 7.90018514e-02f, 1.39326498e-01f, -1.29372422e-02f, -4.76932712e-02f, 3.08137964e-02f, 2.14781202e-02f, 1.75236300e-01f, 1.38327837e-01f, 3.52920890e-02f,
  1.15559593e-01f, 1.66266978e-01f, -1.26058049e-02f, 1.68820649e-01f, 7.94659033e-02f, -1.12219512e-01f, 1.05043091e-01f, -1.34853140e-01f, -2.37956848e-02f, 9.34008807e-02f,
  2.15941906e-01f, 2.28487879e-01f, 1.44753247e-01f, -1.00200735e-01f, 2.51650643e-02f, 6.46014586e-02f, -3.52568835e-01f, 1.50513798e-01f, -1.70429975e-01f, -6.42935187e-02f,
  -2.01779634e-01f, -2.52849996e-01f, -1.79543689e-01f, -2.62363106e-01f, 3.86404023e-02f, -2.02728659e-01f, -1.22661904e-01f, -3.64788808e-02f, 1.78089723e-01f, 9.15863886e-02f,
  -3.54199857e-02f, -2.68906295e-01f, 2.93603599e-01f, -4.18976188e-01f, -1.04857951e-01f, 2.31706977e-01f, 1.13563269e-01f, 5.62217385e-02f, 1.76156790e-03f, 8.71388316e-02f,
  -2.55939662e-01f, 2.24348664e-01f, -2.57383764e-01f, 6.03343248e-02f, -1.11290947e-01f, 1.75417364e-01f, -6.25441670e-02f, 3.53681624e-01f, 1.17140315e-01f, 1.64757743e-01f,
  -6.33367077e-02f, 1.50573969e-01f, 1.22858807e-01f, 7.64377266e-02f, -1.45120963e-01f, -3.97767797e-02f, -1.38862044e-01f, 2.85888165e-01f, 8.54697898e-02f, 1.26710847e-01f,
  1.17708631e-02f, -1.04284212e-01f, 4.32825983e-02f, 7.73377419e-02f, -7.46397153e-02f, -5.67364134e-03f, 1.16506904e-01f, -7.41926804e-02f, -7.15169823e-03f, 1.35019198e-01f,
  6.78175762e-02f, 2.25753069e-01f, 1.13497935e-01f, -1.25465915e-01f, 2.39113308e-02f, -1.31246328e-01f, 9.69341546e-02f, 2.08201557e-01f, -2.55816355e-02f, -4.49274257e-02f,
  -2.98737824e-01f, -1.38826191e-01f, 1.01778783e-01f, 4.01752979e-01f, 2.49888480e-01f, -6.83982894e-02f, -3.08361113e-01f, -2.38596827e-01f, 5.74049763e-02f, -4.42772433e-02f,
  1.91884667e-01f, -2.49116495e-01f, 1.36551499e-01f, -1.53340101e-02f, 2.24072468e-02f, 1.57714546e-01f, -2.11673781e-01f, -2.46239379e-02f, 2.54166514e-01f, 2.45395955e-03f,
  3.59113663e-01f, 2.25461245e-01f, -5.63305505e-02f, -2.45349303e-01f, 6.44750670e-02f, -5.91505058e-02f, 4.10137214e-02f, 2.25476056e-01f, 3.81014124e-02f, 1.80402249e-01f,
  3.02512527e-01f, -9.16945040e-02f, 1.35821477e-01f, 6.02978058e-02f, 1.31908776e-02f, 4.77315038e-02f, -1.85777694e-02f, -2.71521062e-01f, -2.68425271e-02f, 8.27350691e-02f,
  -5.06840609e-02f, 2.86109567e-01f, 2.07023486e-01f, -1.08863175e-01f, -1.58067271e-02f, -1.93251386e-01f, 4.32063155e-02f, 1.97299287e-01f, -1.45574078e-01f, 6.71313554e-02f,
  1.66181419e-02f, -1.06251530e-01f, 1.41447648e-01f, 6.09164424e-02f, 1.90314616e-03f, 1.61917642e-01f, 1.20870858e-01f, -3.19199190e-02f, 1.62068695e-01f, -1.38456430e-02f,
  1.27180323e-01f, -7.58647397e-02f, -1.07109450e-01f, -1.84400722e-01f, 6.74753785e-02f, -5.93269467e-02f, 7.86643550e-02f, -9.82228070e-02f, -2.01319799e-01f, -2.88873196e-01f,
  -1.36289418e-01f, -1.85814034e-03f, -2.05883756e-02f, -1.61656067e-01f, -1.53826445e-01f, 4.81486730e-02f, -6.31193817e-02f, -6.66504726e-02f, -6.90803677e-02f, -1.69210080e-02f,
  -6.28508553e-02f, -2.94404566e-01f, 1.75959289e-01f, -2.87509650e-01f, -1.73997521e-01f, 3.22519958e-01f, 5.36530465e-02f, 1.68240979e-01f, 6.51582181e-02f, -2.07000896e-02f,
  2.36907363e-01f, 3.34600061e-01f, -3.65750119e-02f, 3.09127979e-02f, -7.50797859e-04f, -1.01356082e-01f, 3.44828181e-02f, 1.34215131e-01f, -2.02482387e-01f, -3.24768014e-02f,
  1.36024058e-01f, 2.14098319e-01f, 8.89451206e-02f, 1.79657131e-01f, 3.95661332e-02f, -5.17864153e-02f, 1.04893900e-01f, -4.72597824e-03f, 1.05654262e-01f, 1.37804747e-01f,
  -7.58828521e-02f, 9.04477462e-02f, 6.28496036e-02f, -1.14447534e-01f, -3.03048305e-02f, 1.50573060e-01f, 1.93350893e-02f, 1.33445621e-01f, 2.38408342e-01f, 1.68873891e-02f,
  -1.43838476e-03f, 1.14720464e-01f, 1.04785398e-01f, 2.73026228e-01f, -1.02447659e-01f, -2.26853117e-02f, 5.93601391e-02f, -1.59698114e-01f, -1.01301365e-01f, 3.87172662e-02f,
  -2.11190224e-01f, 1.20048627e-01f, -7.17948079e-02f, 3.14850099e-02f, -1.32157311e-01f, -9.54570174e-02f, -1.92964017e-01f, -1.88406706e-01f, -2.12990507e-01f, -2.24796221e-01f,
  1.64602816e-01f, 2.84820437e-01f, 3.98143567e-02f, -4.50943708e-02f, 4.28788960e-01f, -2.11370602e-01f, -4.97485604e-03f, 3.09511900e-01f, 2.99278617e-01f, -9.44713280e-02f,
  2.99907118e-01f, 2.05998793e-01f, -1.13845440e-02f, 2.42489204e-01f, 2.12496873e-02f, -1.53195024e-01f, 5.05267903e-02f, -7.27509102e-03f, -5.60122058e-02f, 2.75695056e-01f,
  -4.55183871e-02f, 4.05020982e-01f, 2.71562994e-01f, 2.76650399e-01f, 1.30652994e-01f, 3.12707514e-01f, -5.08873872e-02f, -7.03312904e-02f, -9.83789712e-02f, 9.39571038e-02f,
  4.27831747e-02f, 1.90581322e-01f, -1.17194451e-01f, 5.58884665e-02f, 9.54124108e-02f, 1.46960720e-01f, -1.27626196e-01f, 5.61168417e-02f, 6.51922524e-02f, 1.71956457e-02f,
  -3.96572836e-02f, 1.43051416e-01f, 1.19556390e-01f, 7.93451220e-02f, 8.45192671e-02f, -4.28721420e-02f, -1.36704668e-01f, -2.31065676e-01f, 2.17130445e-02f, 1.83781087e-01f,
  2.81703144e-01f, -2.43617110e-02f, -9.28266644e-02f, -3.08787167e-01f, 1.97541445e-01f, 1.62092134e-01f, 1.75787941e-01f, 3.28765780e-01f, -1.62490681e-01f, 9.56928208e-02f,
  4.95520867e-02f, 8.07734951e-02f, 6.10244758e-02f, -7.27897063e-02f, -6.71568559e-04f, -2.55809009e-01f, -7.02832639e-02f, 4.20777172e-01f, -1.40297219e-01f, 2.31710717e-01f,
  2.57128745e-01f, -1.87991068e-01f, 1.81050465e-01f, 1.00428142e-01f, 1.10938884e-01f, -5.58957905e-02f, 3.33816469e-01f, 1.69025525e-01f, 7.91499093e-02f, -1.87750205e-01f,
  1.17207900e-01f, 1.88358650e-01f, 2.42449149e-01f, -2.52874970e-01f, 2.03247249e-01f, -1.86930373e-01f, 4.57249023e-02f, 8.09786692e-02f, 2.14537323e-01f, -2.78227895e-01f,
  1.65871114e-01f, 1.42304197e-01f, 1.33027256e-01f, 1.89585641e-01f, -1.14359684e-01f, -1.95642769e-01f, -3.37934382e-02f, 3.43997404e-02f, 1.67114762e-04f, 1.31949455e-01f,
  4.47685495e-02f, -2.15483353e-01f, 3.38542461e-02f, 1.10850744e-02f, 2.43822429e-02f, -1.85498342e-01f, 1.23136654e-01f, -1.57781303e-01f, -9.50703546e-02f, -8.86710640e-03f,
  -1.19408675e-01f, 5.83228469e-02f, 2.01525656e-03f, -3.31781089e-01f, -1.47287756e-01f, -3.61434966e-01f, -5.44932066e-03f, 3.29867929e-01f, 1.00879200e-01f, 4.66288850e-02f,
  -2.58297354e-01f, -2.18926936e-01f, -3.86221223e-02f, 1.50656223e-01f, 4.20423336e-02f, 2.40099598e-02f, -2.15991601e-01f, -3.00230026e-01f, -2.51052678e-01f, 1.78374663e-01f,
  3.55102192e-03f, -3.59618545e-01f, 1.81098148e-01f, 3.20401303e-02f, 6.12686090e-02f, 8.89023170e-02f, 1.44976415e-02f, -1.34438798e-01f, 1.34231210e-01f, 8.94561112e-02f,
  -5.81325628e-02f, 1.06697969e-01f, 8.15633312e-02f, 6.61097690e-02f, 1.39234647e-01f, -9.22686234e-02f, -8.02961644e-03f, 3.77577007e-01f, 1.84968397e-01f, 1.05397969e-01f,
  -2.96987202e-02f, 1.30828336e-01f, 6.53771162e-02f, 3.88099968e-01f, 3.13246280e-01f, 8.87417197e-02f, -2.07578897e-01f, 1.59751266e-01f, 2.29318619e-01f, 6.27663285e-02f,
  9.88346189e-02f, 2.47381497e-02f, 1.81977734e-01f, 1.05880953e-01f, 1.03971556e-01f, -7.12331086e-02f, 5.99913150e-02f, -1.46918232e-02f, 3.85777056e-02f, -2.56601982e-02f,
  -4.83116582e-02f, 2.73283720e-02f, 1.51496017e-02f, 4.15584855e-02f, 1.91610187e-01f, 2.88202614e-01f, 6.16879612e-02f, -1.74385771e-01f, 8.25228989e-02f, -1.12650819e-01f,
  -4.97213304e-02f, -2.93977764e-02f, -2.21550018e-01f, -1.52336627e-01f, -3.74128893e-02f, -1.46264270e-01f, -1.22123994e-01f, -2.66125023e-01f, -1.63296118e-01f, -1.82655156e-01f,
  -2.94722855e-01f, -1.69494584e-01f, 1.82943344e-01f, 7.34653622e-02f, -4.25188690e-02f, -1.87313445e-02f, 2.01263040e-01f, -3.64212133e-02f, -3.92546386e-01f, 3.26605767e-01f,
  5.23010232e-02f, -7.37556815e-02f, 4.81730998e-02f, 1.06654271e-01f, -1.66818395e-01f, 1.64349884e-01f, 4.89051230e-02f, 1.98069513e-02f, -3.23841982e-02f, 5.79997059e-03f,
  -2.70926803e-01f, 2.37401858e-01f, -2.18927816e-01f, 2.94721782e-01f, 2.50355899e-01f, 1.69010878e-01f, 2.31325820e-01f, -1.16872825e-01f, -2.94623107e-01f, -2.18703374e-01f,
  -1.02719821e-01f, -9.52242613e-02f, -1.87003687e-02f, -2.02812806e-01f, -7.61898328e-03f, 6.89545870e-02f, -8.35546553e-02f, 1.24988686e-02f, 1.02500930e-01f, -7.59839863e-02f,
  -9.22885016e-02f, 1.24088369e-01f, 2.72144011e-04f, 3.69617008e-02f, 1.73441261e-01f, -6.86657354e-02f, 5.73072582e-04f, -3.10732201e-02f, -6.37127785e-03f, 1.42673150e-01f,
  -4.54754233e-02f, -2.97589689e-01f, -9.43378061e-02f, -2.21120209e-01f, 2.49470472e-01f, 1.91688046e-01f, 1.51961386e-01f, -1.17254309e-01f, -2.34919965e-01f, -1.65768877e-01f,
  -8.67415369e-02f, -3.61338332e-02f, -3.18158530e-02f, -5.06926216e-02f, -2.17551336e-01f, -1.08967945e-01f, -4.08099592e-02f, 2.37670481e-01f, -1.59198955e-01f, -9.03743580e-02f,
  2.98731595e-01f, -2.82621533e-01f, 2.17318654e-01f, -2.86936350e-02f, -1.70199633e-01f, 1.75837919e-01f, 6.45747259e-02f, 1.49685264e-01f, 8.43015090e-02f, 4.30428199e-02f,
  8.72551426e-02f, 1.09341472e-01f, 1.90764740e-01f, -1.28827929e-01f, -2.31513068e-01f, 1.70600578e-01f, -4.25854661e-02f, -1.11407675e-02f, -2.13850722e-01f, -2.48349924e-03f,
  1.00588284e-01f, 3.65155160e-01f, 2.45859087e-01f, 2.28104696e-01f, 7.41936415e-02f, -1.64030552e-01f, -1.16113737e-01f, 1.72017276e-01f, 1.70945689e-01f, 4.98524234e-02f,
  6.15471043e-02f, 1.43829405e-01f, 1.74540028e-01f, 1.06922612e-01f, 7.03700632e-02f, 9.10804793e-02f, 1.66308641e-01f, 2.39338249e-01f, -8.93736258e-02f, -9.04074684e-02f,
  1.62434235e-01f, 3.48035768e-02f, 5.68657704e-02f, 1.09044127e-02f, 1.03532583e-01f, -3.49723063e-02f, 1.77107025e-02f, 1.07280098e-01f, -4.37936969e-02f, -1.06347449e-01f,
  2.88967699e-01f, -2.83102125e-01f, -1.96274314e-02f, 2.34323088e-02f, -2.94710368e-01f, -2.97121376e-01f, -2.03643274e-03f, -2.63534606e-01f, 3.50715399e-01f, 2.59805143e-01f,
  3.98787677e-01f, -1.89516619e-01f, -2.33504012e-01f, 5.51550202e-02f, -1.54092163e-01f, -4.30709660e-01f, -3.31106603e-01f, -1.72800779e-01f, -1.63937062e-01f, 4.07254368e-01f,
  1.75123233e-02f, 2.76614994e-01f, -5.66668250e-02f, 6.58706948e-02f, 2.83909380e-01f, 1.30755007e-01f, -1.32201582e-01f, 1.76699966e-01f, 1.53233424e-01f, -1.66015923e-01f,
  -1.16371848e-01f, 1.11686312e-01f, -2.31206834e-01f, 1.15009815e-01f, 1.64289340e-01f, -1.77868888e-01f, -2.16842607e-01f, 1.53728276e-01f, 1.64261892e-01f, 1.31475553e-01f,
  -4.95209731e-02f, 2.71718830e-01f, 3.19566317e-02f, 2.01577723e-01f, 1.05392382e-01f, 3.13788056e-02f, 1.93898603e-01f, 1.31534755e-01f, -1.02023587e-01f, 8.55161622e-02f,
  2.32502565e-01f, -9.74322017e-03f, -3.28984112e-02f, -1.22400150e-02f, 6.45055994e-02f, 8.33932832e-02f, 1.56613916e-01f, -1.44541293e-01f, -2.42798284e-01f, 3.41303557e-01f,
  1.47492215e-01f, 3.80285829e-01f, -1.45245586e-02f, -1.23847030e-01f, -1.26195192e-01f, -2.62207091e-01f, 1.59270972e-01f, 3.96533340e-01f, 2.80836850e-01f, 1.53572008e-01f,
  -1.74292207e-01f, 2.48360410e-01f, 1.00283504e-01f, 7.04280436e-02f, 2.39904448e-02f, -1.77974716e-01f, 3.93843874e-02f, 3.41040432e-01f, 2.76694242e-02f, 1.13311343e-01f,
  8.78493115e-02f, 1.76180884e-01f, 6.30566431e-03f, 8.32756683e-02f, 2.39814430e-01f, 1.04028113e-01f, 3.62378299e-01f, 1.11128569e-01f, -1.88124347e-02f, -3.04615021e-01f,
  4.11033109e-02f, 2.84080263e-02f, -9.87237785e-03f, -2.68423289e-01f, 2.20594686e-02f, -1.97907239e-02f, 1.34410515e-01f, 1.67873219e-01f, 1.07763201e-01f, -2.04383850e-01f,
  -5.37248515e-02f, -5.23439795e-02f, 3.57582122e-01f, -1.19896725e-01f, 1.26924917e-01f, 2.15025350e-01f, 9.77480561e-02f, 2.43810304e-02f, -7.71815628e-02f, 2.30359156e-02f,
  1.16954327e-01f, -9.06314775e-02f, 1.60033688e-01f, -5.40534183e-02f, -7.08362833e-02f, 2.96981364e-01f, -6.97265640e-02f, 5.58850206e-02f, 2.04284564e-01f, -3.32145020e-02f,
  1.22981824e-01f, -2.00732604e-01f, 6.51738271e-02f, 1.59594417e-01f, 8.72660056e-02f, -3.49749029e-02f, -6.52219877e-02f, -3.32823098e-01f, -1.80881113e-01f, 1.57728925e-01f,
  2.07135424e-01f, 2.09518328e-01f, -1.33694708e-01f, -7.50706419e-02f, -1.65890649e-01f, 8.55642743e-03f, -5.47818989e-02f, -1.42640159e-01f, 2.60572404e-01f, -1.39124349e-01f,
  -1.06361635e-01f, 3.10584068e-01f, 6.26093969e-02f, -9.18831900e-02f, 8.24772418e-02f, 1.12854727e-01f, 2.70512909e-01f, 1.05405144e-01f, 1.30680412e-01f, 4.06259112e-02f,
  2.12570831e-01f, 2.36088037e-01f, 1.05614819e-01f, -7.41894096e-02f, 4.24091332e-02f, 1.43257827e-01f, 9.07604173e-02f, -2.64036268e-01f, -1.82494596e-01f, 1.92916140e-01f,
  1.94400847e-01f, 2.20495224e-01f, 1.30111963e-01f, -2.71870047e-01f, -2.88786650e-01f, 2.56080050e-02f, 1.42017931e-01f, -3.25259529e-02f, 2.66115040e-01f, 1.02206916e-01f,
  1.88109562e-01f, -1.74268141e-01f, -6.94498047e-02f, 1.20704994e-01f, 1.67944133e-01f, 2.04569861e-01f, -4.28128615e-02f, -7.90748298e-02f, 1.50125489e-01f, 1.45994455e-01f,
  -1.46766886e-01f, 1.60024270e-01f, 7.91011974e-02f, 1.58195227e-01f, 2.09627062e-01f, 5.09265158e-03f, -2.56409571e-02f, 1.35085166e-01f, 8.94338638e-02f, -7.00952187e-02f,
  1.71550810e-01f, -7.89820403e-02f, -1.70512542e-01f, -3.51885855e-02f, 1.07163019e-01f, 1.23934247e-01f, 4.71233241e-02f, -1.54102027e-01f, -2.38652304e-01f, 9.14173722e-02f,
  7.11565763e-02f, 1.70462474e-01f, -5.39980754e-02f, -2.26589777e-02f, 4.74039558e-03f, 2.49247164e-01f, -1.61653608e-01f, -1.11733526e-02f, -6.53286278e-02f, 1.71516195e-01f,
  2.09547147e-01f, 1.31097838e-01f, 8.70021954e-02f, -1.89912058e-02f, 9.17782634e-02f, 2.49388680e-01f, 1.89762414e-01f, 7.30097815e-02f, 5.53070270e-02f, 1.02569282e-01f,
  -4.79268655e-02f, -1.65358096e-01f, -2.14616552e-01f, -1.87035501e-02f, 2.08979502e-01f, 2.17159331e-01f, 2.30683133e-01f, -3.57721776e-01f, -2.06358314e-01f, -6.86303824e-02f,
  6.13497831e-02f, 3.25292759e-02f, 8.08330625e-02f, 1.47739928e-02f, -6.38569742e-02f, -2.11147275e-02f, 2.65873075e-01f, 8.55006427e-02f, 1.06731532e-02f, 2.08233267e-01f,
  -7.81137049e-02f, 1.21376894e-01f, 1.74537390e-01f, 3.05813039e-03f, 3.49685699e-02f, -6.16006646e-03f, 8.98194239e-02f, 1.63298652e-01f, 1.70989558e-01f, 1.65509120e-01f,
  3.11519764e-02f, 2.50746071e-01f, -1.62311658e-01f, 3.52489889e-01f, -3.21967274e-01f, 2.10128918e-01f, 1.11319475e-01f, 1.08306937e-01f, 1.91149581e-02f, 9.62932631e-02f,
  2.40306765e-01f, 2.81652987e-01f, 2.59478748e-01f, 1.28442302e-01f, -2.64851928e-01f, -1.03875145e-01f, -1.24612466e-01f, -2.18584999e-01f, -1.33037150e-01f, -4.79243957e-02f,
  2.18880653e-01f, 5.02510965e-01f, 8.25646073e-02f, -4.84321117e-02f, -9.97974351e-02f, -8.76289159e-02f, -1.22487634e-01f, 2.70598009e-02f, 2.88827240e-01f, 1.42420471e-01f,
  -1.38665438e-01f, 1.99500799e-01f, 3.01107824e-01f, 1.84875920e-01f, 2.07696304e-01f, 2.16656163e-01f, 3.76183599e-01f, -1.00694902e-01f, 1.22561887e-01f, -5.23850322e-02f,
  -1.88073754e-01f, -2.79707052e-02f, 1.58168495e-01f, 2.39429161e-01f, 4.29184036e-03f, 2.53933907e-01f, -2.07908335e-03f, 2.02361457e-02f, -2.19854265e-01f, -1.75223984e-02f,
  1.10586196e-01f, -1.31060285e-02f, -1.21195674e-01f, -2.23399643e-02f, 7.74329379e-02f, 2.00384781e-01f, 1.56134173e-01f, 1.20643705e-01f, 5.07440604e-02f, 2.32961997e-01f,
  8.91008526e-02f, 4.99213189e-02f, 2.02859677e-02f, -2.09195897e-01f, -1.49692446e-01f, 1.20671317e-01f, 9.54666808e-02f, 2.47996122e-01f, -3.17813903e-01f, -1.27151817e-01f,
  2.13525921e-01f, 4.21948612e-01f, 1.51811704e-01f, 1.31928667e-01f, -2.28327215e-01f, 1.39155835e-01f, 2.64604300e-01f, -5.60314097e-02f, -6.86922371e-02f, -2.66378880e-01f,
  -5.94026223e-02f, -2.08128184e-01f, -2.31952202e-02f, 8.41909051e-02f, 3.41907740e-02f, 1.15346506e-01f, 1.60146222e-01f, -1.76837847e-01f, 2.61285365e-01f, 2.41176914e-02f,
  3.36028337e-02f, -4.81357276e-02f, 2.23513782e-01f, -2.75680572e-02f, -1.31417066e-01f, -1.26697645e-01f, 3.28535020e-01f, 3.37046385e-01f, 1.53513744e-01f, 1.50614992e-01f,
  3.34179848e-01f, -1.07717820e-01f, 7.56784305e-02f, 4.49582078e-02f, 7.83212408e-02f, -1.66648030e-01f, 1.78167969e-01f, 1.52061850e-01f, 9.39911380e-02f, 4.40407872e-01f,
  -2.18357891e-01f, 2.19939902e-01f, -2.35207453e-01f, -2.11939454e-01f, 2.09560558e-01f, 9.99214277e-02f, -1.03339925e-01f, -4.58318815e-02f, 2.55619884e-01f, -1.02611911e-02f,
  5.44477664e-02f, 1.22304889e-03f, -9.28104892e-02f, 8.82634372e-02f, 1.52941898e-01f, 1.05697908e-01f, -1.95057839e-01f, -2.60776341e-01f, 2.06656143e-01f, 2.14681953e-01f,
  -2.19549015e-01f, 8.63336250e-02f, -1.85798436e-01f, 6.57752082e-02f, 2.04099789e-01f, 2.33261719e-01f, 2.08286256e-01f, 6.41240878e-03f, -2.09938467e-01f, 2.59871297e-02f,
  2.30969131e-01f, 9.74888951e-02f, 1.14120588e-01f, -1.11153878e-01f, -6.50600996e-03f, -2.47253746e-01f, -1.26833066e-01f, 9.68656614e-02f, -6.80164620e-02f, 1.72176644e-01f,
  3.38106334e-01f, -3.26561928e-02f, 1.36291802e-01f, 2.88596839e-01f, -9.43804160e-02f, -1.28704697e-01f, 2.61545807e-01f, -1.21257901e-01f, 1.22264296e-01f, 2.97238261e-01f,
  1.97105259e-01f, 2.54085958e-01f, 2.47223318e-01f, 1.43232662e-02f, 2.94667453e-01f, -2.24593058e-01f, -1.38328560e-02f, -2.67293975e-02f, -1.67553589e-01f, -9.35410988e-03f,
  1.54889375e-01f, 1.06758691e-01f, 6.26339987e-02f, 2.08779946e-01f, -3.46595272e-02f, -3.60453017e-02f, 5.37867807e-02f, 1.35682344e-01f, 2.11860284e-01f, 2.47931004e-01f,
  2.16464341e-01f, 1.61394179e-01f, -1.17707870e-03f, 1.02307118e-01f, 7.44951889e-02f, 1.59327298e-01f, -8.08994696e-02f, -9.13040563e-02f, 7.15689138e-02f, 9.60153937e-02f,
  1.37817577e-01f, 1.61288366e-01f, 1.19382078e-02f, -8.92942026e-02f, -1.07816294e-01f, 1.53729811e-01f, 1.82039440e-01f, 1.69563308e-01f, 2.68431008e-01f, -4.94058073e-01f,
  -1.23337135e-01f, -9.80191007e-02f, -2.48004898e-01f, -3.61208096e-02f, -6.49636015e-02f, -3.02543104e-01f, -1.05441794e-01f, 4.48155433e-01f, 2.69959033e-01f, 5.13022803e-02f,
  -3.16996992e-01f, -1.19770877e-02f, -1.23687498e-01f, -2.61295408e-01f, -2.52980322e-01f, -2.28150204e-01f, -1.49336815e-01f, 2.98001617e-01f, 1.01308204e-01f, 3.26156169e-01f,
  -2.09314134e-02f, -1.07994191e-01f, 1.94541544e-01f, 2.05174685e-01f, 1.68974604e-03f, 8.26539099e-03f, 7.51510933e-02f, -5.42773865e-02f, -1.83094651e-01f, 7.35528767e-02f,
  -1.24519929e-01f, 1.51968569e-01f, 1.98196545e-01f, 1.03155263e-01f, -1.89316034e-01f, 1.49731949e-01f, 2.15822399e-01f, -8.47423747e-02f, 2.36344561e-02f, -1.11495435e-01f,
  1.80206805e-01f, 8.71181116e-02f, -1.45000502e-01f, 4.04513516e-02f, -1.43185891e-02f, 6.59010336e-02f, -2.84676719e-02f, 2.97126453e-02f, -3.43413502e-02f, -8.15471113e-02f,
  3.65567245e-02f, -7.31485486e-02f, -6.71423748e-02f, 5.22661023e-02f, 2.73878295e-02f, 2.15986833e-01f, -9.66546834e-02f, -1.70151070e-01f, 8.10084641e-02f, -3.26118544e-02f,
  -1.50267154e-01f, 1.07780322e-01f, -9.07607451e-02f, 2.04296470e-01f, -1.06833868e-01f, -1.03838712e-01f, 2.08565876e-01f, 6.09246045e-02f, 8.11987966e-02f, 1.96152419e-01f,
  -1.80036098e-01f, -3.01569223e-01f, -9.76811126e-02f, 2.73443162e-01f, -1.06537275e-01f, -1.32092267e-01f, 3.00451279e-01f, -9.67679396e-02f, 1.58485174e-01f, 2.87790388e-01f,
  2.49857619e-01f, -9.13984030e-02f, 1.44241005e-01f, 2.07437262e-01f, 1.83144674e-01f, 3.37224990e-01f, -2.10366979e-01f, -1.05930448e-01f, 7.51090199e-02f, 9.01751406e-03f,
  -2.02492550e-02f, 2.44663551e-01f, 8.98224190e-02f, 1.55012891e-01f, 2.85963207e-01f, 7.36733973e-02f, 1.01757698e-01f, 2.78809071e-01f, 2.13807940e-01f, -2.17772811e-03f,
  -1.59191880e-02f, 2.30060928e-02f, 5.21817580e-02f, -2.77695339e-02f, 1.20639153e-01f, -1.45544320e-01f, -1.08256355e-01f, -1.56309545e-01f, -6.30065724e-02f, -1.35718077e-01f,
  1.92022752e-02f, -2.42142424e-01f, -2.18006358e-01f, 1.64519683e-01f, -1.33801028e-01f, 2.16580957e-01f, 1.59954399e-01f, -1.85820282e-01f, -6.33429363e-02f, -2.53208399e-01f,
  -2.53549917e-03f, -1.89499006e-01f, -1.94890443e-02f, -1.37337789e-01f, 2.93624133e-01f, -5.44587746e-02f, 1.50154591e-01f, 1.28968852e-03f, -9.26477239e-02f, -1.44708171e-01f,
  2.11467430e-01f, 2.40502074e-01f, -1.34402364e-01f, 3.45528275e-01f, 1.45127162e-01f, -3.38582426e-01f, -1.56300470e-01f, 8.34916160e-03f, -5.41157052e-02f, -1.83445383e-02f,
  9.62927938e-02f, 2.86275715e-01f, 2.90302634e-01f, -1.33419067e-01f, -2.03618437e-01f, 1.11068778e-01f, 1.12357281e-01f, 6.21799286e-03f, 2.47762978e-01f, -4.96350788e-02f,
  1.61726892e-01f, 2.30070382e-01f, 1.80317268e-01f, -3.54900099e-02f, 1.93444565e-01f, -1.02759778e-01f, 1.11835532e-01f, 7.52339140e-02f, -3.06444108e-01f, -7.10257217e-02f,
  -1.85465306e-01f, 5.15216105e-02f, 3.32419902e-01f, 7.86107779e-02f, 1.96137756e-01f, -1.47476673e-01f, 3.39702182e-02f, 4.28918377e-02f, 1.06103450e-01f, 1.23360999e-01f,
  7.14330748e-03f, 1.63130775e-01f, 8.59611183e-02f, -7.70776570e-02f, -1.19266674e-01f, 2.79196471e-01f, 2.63352007e-01f, -1.82240084e-01f, 8.16038325e-02f, -1.05906062e-01f,
  9.26224366e-02f, 1.74891338e-01f, 7.23138228e-02f, 1.40572682e-01f, -8.18665884e-03f, 9.17977244e-02f, -6.59502670e-02f, 1.30167902e-01f, -1.67421803e-01f, -9.19393171e-03f,
  -1.06389053e-01f, 4.49340604e-02f, 4.84945662e-02f, -2.76501216e-02f, 2.10727260e-01f, -6.46717548e-02f, -1.68653280e-01f, -1.65711641e-02f, -2.04357356e-01f, 1.73403900e-02f,
  -1.25043705e-01f, 7.61104152e-02f, -1.30142286e-01f, 5.25235683e-02f, 2.07691923e-01f, 8.14181343e-02f, -1.74099416e-01f, 3.22509378e-01f, -9.52611268e-02f, -3.33319977e-02f,
  1.03431255e-01f, 9.94304568e-02f, 1.50894299e-01f, 2.06180856e-01f, 1.28863975e-01f, -6.62757158e-02f, 6.70252070e-02f, -1.45625591e-01f, -5.74179441e-02f, 3.69030118e-01f,
  -6.36321679e-02f, 1.45866215e-01f, 2.54743695e-01f, 9.87166092e-02f, 1.06479242e-01f, 1.95800632e-01f, -1.40484974e-01f, -1.18496828e-01f, -9.48025584e-02f, 7.57349581e-02f,
  1.01547353e-01f, 2.86220051e-02f, 1.87202469e-02f, 3.38073671e-02f, 9.76286232e-02f, 1.37031347e-01f, 1.05330639e-01f, 2.61574566e-01f, 1.57441065e-01f, 6.94682896e-02f,
  2.80710071e-01f, -6.66209906e-02f, -5.16073219e-02f, 3.54260504e-02f, 8.56063440e-02f, 1.55285418e-01f, 1.28843561e-01f, -8.29533562e-02f, 2.22270623e-01f, 9.69436616e-02f,
  -1.44152850e-01f, 2.37937301e-01f, 1.95961744e-01f, -6.12406135e-02f, 7.09782615e-02f, -1.92856655e-01f, 7.58752897e-02f, -1.29120514e-01f, -3.64563972e-01f, -1.23926990e-01f,
  2.97030825e-02f, -2.19270766e-01f, 2.31188729e-01f, 2.77035773e-01f, 2.44736731e-01f, -1.89933121e-01f, -2.33808190e-01f, -8.77280831e-02f, -2.02268720e-01f, -1.63225323e-01f,
  2.64818911e-02f, -2.37095669e-01f, -1.88198760e-01f, 2.85718262e-01f, -1.09269962e-01f, 2.63614416e-01f, -4.49290872e-02f, 3.52414064e-02f, 1.39241785e-01f, 3.92650604e-01f,
  2.55702157e-02f, 3.60131025e-01f, 1.06307395e-01f, 5.68865128e-02f, 6.93022683e-02f, -4.19610031e-02f, -1.56886324e-01f, 1.53137594e-01f, 3.32869105e-02f, -1.59821659e-02f,
  3.67671065e-02f, 2.83925235e-01f, 1.56086817e-01f, 7.65340626e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  -8.52450728e-02f, 3.44924629e-02f, 3.01739872e-02f, -7.51771871e-03f, 1.28337830e-01f, 7.89051726e-02f, 2.36864109e-02f, 8.58032480e-02f, 3.66758904e-03f, 6.76651746e-02f,
  6.40757084e-02f, 1.53085783e-01f, 1.79881915e-01f, 1.32423729e-01f, 5.47725111e-02f, 5.29295988e-02f, 1.08637072e-01f, 1.50264084e-01f, 1.29667044e-01f, 3.91713232e-02f,
  1.21213622e-01f, 6.96861967e-02f, 3.39751388e-03f, -9.00392085e-02f, 1.51084080e-01f, 1.33938715e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  7.22260550e-02f, -6.74166754e-02f, -3.72763239e-02f, -8.23079124e-02f, 1.54625043e-01f, 1.23009160e-01f, -1.52668357e-01f, 1.25152037e-01f, 1.18539960e-03f, -1.09475804e-02f,
  -1.22593172e-01f, 1.21014886e-01f, 1.01130627e-01f, 3.08991387e-03f, 6.05739057e-02f, -1.43270984e-01f, -1.22047730e-01f, -9.69014913e-02f, 4.35795560e-02f, 2.28640661e-01f,
  -1.07943423e-01f, -1.33807715e-02f, -1.82561442e-01f, 1.46152347e-01f, -1.37016192e-01f, 1.43122479e-01f, -7.75398016e-02f, -1.94483027e-01f, -6.91747442e-02f, 1.46577340e-02f,
  1.68601215e-01f, -1.92693502e-01f, 2.34498441e-01f, -7.93055817e-02f, 1.10637002e-01f, -1.27828166e-01f, 9.84730851e-03f, 2.59164691e-01f, 2.35130489e-01f, 6.24292381e-02f,
  4.92104888e-02f, -2.60521263e-01f, -3.87215734e-01f, 3.00111860e-01f, -3.03389817e-01f, 2.63724122e-02f, 1.84715331e-01f, -4.00298864e-01f, -6.07428737e-02f, -2.77508140e-01f,
  -2.32452303e-02f, -9.38121676e-02f, 1.75164267e-01f, -4.85392064e-02f, 8.28201845e-02f, 1.62719652e-01f, -3.31510395e-01f, -2.39707842e-01f, 4.49119173e-02f, 1.32498339e-01f,
  -5.08052945e-01f, 1.69461012e-01f, -4.28678781e-01f, 1.31063268e-01f, -1.50077581e-01f, 4.14145589e-02f, 8.99581313e-02f, 2.28961483e-01f, -1.06399693e-01f, 5.38890921e-02f,
  2.23620653e-01f, -7.03156516e-02f, -1.91382170e-01f, 1.97265729e-01f, -7.73103982e-02f, 1.27256542e-01f, 6.00659736e-02f, 1.24478869e-01f, -7.60643780e-02f, -1.83868892e-02f,
  -1.25453755e-01f, 4.12615836e-02f, 1.25799149e-01f, 1.17871083e-01f, -9.95488688e-02f, -1.51014343e-01f, 5.07018855e-03f, 1.73006475e-01f, -2.09975705e-01f, 9.81176868e-02f,
  -2.34823793e-01f, -1.35017276e-01f, -1.06990270e-01f, -2.00274158e-02f, 1.88832790e-01f, 2.20651582e-01f, -1.42296910e-01f, 9.82876793e-02f, 1.46040946e-01f, -2.35394731e-01f,
  5.07941097e-02f, 7.44614825e-02f, -1.03630230e-01f, -3.69426496e-02f, 6.83039892e-03f, 8.30760133e-03f, -1.38786495e-01f, 1.37923658e-01f, 1.30334049e-02f, -2.54546970e-01f,
  2.27027342e-01f, 6.80298209e-02f, -3.25009525e-01f, 5.95745705e-02f, 2.00782299e-01f, 2.10168421e-01f, 1.33500606e-01f, -2.89272249e-01f, -3.70355397e-02f, -5.83496913e-02f,
  -2.36383736e-01f, -2.11079791e-01f, -2.57656187e-01f, 2.42640123e-01f, -1.49361402e-01f, -1.43674433e-01f, -1.93313211e-02f, 1.64863467e-01f, -1.11055896e-01f, 5.16589843e-02f,
  -2.11063743e-01f, -1.29705638e-01f, 8.59956816e-02f, -8.45567510e-02f, -1.75581202e-01f, -4.66442443e-02f, -1.87591702e-01f, -1.65306687e-01f, 2.88616065e-02f, 5.76152243e-02f,
  -5.11796623e-02f, -1.78906277e-01f, 6.92272037e-02f, 1.46252885e-01f, 6.97350800e-02f, -6.10841177e-02f, 1.57043606e-01f, 1.39308915e-01f, 1.67563573e-01f, -5.64834401e-02f,
  9.99539346e-02f, -1.70944586e-01f, -1.02521807e-01f, -1.93612471e-01f, -4.43873815e-02f, -1.46931067e-01f, 5.06686345e-02f, -1.29890302e-02f, -1.48422837e-01f, 1.81673363e-01f,
  -9.64121744e-02f, 4.86219451e-02f, 1.67750046e-02f, -1.73048049e-01f, -1.45287633e-01f, 1.13271996e-01f, -2.74798393e-01f, 4.35428135e-02f, 1.76277637e-01f, 1.75781086e-01f,
  -2.32310131e-01f, -4.55087751e-01f, 1.62102684e-01f, -7.86501989e-02f, -1.92535147e-01f, 1.89910799e-01f, -3.74594778e-01f, 2.30419219e-01f, 7.93899596e-02f, 1.05389357e-01f,
  -1.24497265e-01f, -1.84078962e-01f, -1.49493590e-01f, -2.95730740e-01f, -2.79890478e-01f, -3.16768914e-01f, -2.27718651e-01f, -2.03094125e-01f, 2.41919532e-01f, -1.58854619e-01f,
  1.69347689e-01f, -4.40489262e-01f, 1.53051481e-01f, 1.26479447e-01f, 1.24265976e-01f, 1.38715535e-01f, 3.58464420e-02f, -2.28565596e-02f, -9.90420114e-03f, 4.27499413e-02f,
  -2.17243396e-02f, -2.04562992e-01f, -7.12737292e-02f, -5.33114523e-02f, 7.21000656e-02f, 2.23916080e-02f, -7.66439736e-02f, 6.57709762e-02f, -2.21933275e-01f, -1.36218742e-01f,
  1.06167585e-01f, -4.63770851e-02f, 9.50018596e-03f, 3.04865222e-02f, 1.55236572e-01f, -7.44353682e-02f, 4.49615829e-02f, 1.75186902e-01f, 1.79844618e-01f, 1.89881235e-01f,
  8.61346535e-03f, 1.53910711e-01f, -7.82404840e-02f, -2.72269219e-01f, 7.96233937e-02f, -1.25157796e-02f, -1.51890963e-01f, 8.40949863e-02f, -6.90208226e-02f, -9.41664726e-03f,
  -2.04799883e-02f, -1.42750457e-01f, -1.90615699e-01f, 1.60934050e-02f, -1.45812169e-01f, 1.20573387e-01f, -3.40311348e-01f, 2.14111030e-01f, 3.13342102e-02f, -4.28177655e-01f,
  8.82738531e-02f, 3.32353599e-02f, -5.88090308e-02f, -6.57024235e-02f, -3.05429518e-01f, -2.58654505e-01f, -2.87067771e-01f, -3.04852217e-01f, 1.73210010e-01f, 1.89559937e-01f,
  2.08753005e-01f, -3.58230889e-01f, -1.46521792e-01f, 9.59547982e-02f, -3.52802813e-01f, 1.54777318e-01f, -2.01905102e-01f, 9.69823450e-02f, -6.68683350e-02f, 4.77389526e-03f,
  -1.19246848e-01f, 2.51933485e-01f, 2.10663736e-01f, -3.37425880e-02f, 1.59757994e-02f, 2.41567008e-02f, 1.94791630e-02f, -3.45739163e-02f, 5.66712879e-02f, 5.26902564e-02f,
  -2.04580054e-01f, -8.05573016e-02f, 2.22192496e-01f, -5.99422716e-02f, 2.76744948e-03f, -1.90877602e-01f, -1.41396290e-02f, 3.93979698e-02f, -2.45339677e-01f, -1.80214703e-01f,
  3.02531421e-01f, 1.40762627e-01f, -2.71749854e-01f, -3.81424394e-03f, 1.41515613e-01f, -4.06712145e-02f, 6.45415345e-03f, 2.17086837e-01f, -9.34673846e-02f, 8.48008916e-02f,
  -1.34148210e-01f, -7.44610056e-02f, 1.66198239e-01f, -1.72809467e-01f, 7.18422607e-02f, 3.33680987e-01f, -3.99798036e-01f, -2.62134552e-01f, -9.74863246e-02f, -1.04895737e-02f,
  -6.74451888e-02f, 2.45880395e-01f, -3.45730074e-02f, -6.44482449e-02f, 1.80100888e-01f, -2.79046327e-01f, -1.04530558e-01f, -1.95107073e-01f, 9.20951292e-02f, 4.24899459e-02f,
  2.31105149e-01f, -5.60158230e-02f, -4.24307063e-02f, 1.78172290e-01f, 9.47740525e-02f, -2.24149600e-01f, -1.55871466e-01f, -1.16597869e-01f, -1.37671992e-01f, 4.24676612e-02f,
  1.35058448e-01f, 2.45311428e-02f, 1.61956832e-01f, -6.92800730e-02f, 1.76377982e-01f, -8.43406916e-02f, 1.21024966e-01f, -2.05158085e-01f, 1.41398162e-01f, -5.95673025e-02f,
  1.75751548e-03f, -7.47476742e-02f, 3.78604122e-02f, -2.08817735e-01f, 1.02357855e-02f, 2.71474987e-01f, 7.55155832e-02f, 2.32198223e-01f, 1.68444723e-01f, -9.54358578e-02f,
  -1.25392109e-01f, 8.68077762e-03f, -1.45053044e-01f, -2.57239640e-01f, 6.55412534e-03f, -2.85651535e-01f, 1.04237922e-01f, 2.93078199e-02f, 1.73790485e-01f, -1.60748571e-01f,
  -3.01573366e-01f, 1.99199289e-01f, 1.81398407e-01f, -1.26962408e-01f, -1.91694200e-01f, -6.19972683e-03f, 1.01638339e-01f, -1.38954267e-01f, 2.14164048e-01f, -1.65133774e-01f,
  1.20157808e-01f, -1.96349472e-01f, 2.71683633e-01f, -1.35058686e-01f, -1.92990363e-01f, -2.02706262e-01f, -4.23018932e-02f, -5.47667742e-02f, 9.37261805e-02f, -2.55099565e-01f,
  -8.82747546e-02f, -3.21461866e-03f, 1.68190211e-01f, 2.14736208e-01f, 4.77175191e-02f, 2.81023961e-02f, -1.50028840e-01f, 4.10018070e-03f, -2.09658340e-01f, 1.79678351e-01f,
  -1.41917974e-01f, -2.84919828e-01f, -1.65037494e-02f, 1.42119348e-01f, 1.36345908e-01f, 1.96841791e-01f, 1.83046162e-02f, -1.25188291e-01f, -6.61878437e-02f, -5.17400447e-03f,
  -1.87337428e-01f, 1.06115393e-01f, 2.22490668e-01f, 9.20481384e-02f, -8.94231945e-02f, 6.43320084e-02f, -1.15114391e-01f, 2.68818259e-01f, 1.19382828e-01f, -6.88704401e-02f,
  1.40953705e-01f, -1.03785485e-01f, -7.39330202e-02f, 1.69938765e-02f, -1.97346747e-01f, -1.42389998e-01f, 1.53187364e-01f, -2.41598412e-02f, -9.49305370e-02f, 1.45329192e-01f,
  1.12447761e-01f, -9.01863426e-02f, -1.97201639e-01f, -1.06817104e-01f, 3.82199362e-02f, -1.05872415e-01f, 1.75341919e-01f, -1.55503765e-01f, -1.25189638e-02f, -1.63049519e-01f,
  -1.24514796e-01f, -1.67623341e-01f, -2.11573932e-02f, -1.55874774e-01f, 2.34260455e-01f, -1.10607930e-01f, -4.61136624e-02f, -1.76681429e-01f, -4.90032658e-02f, -3.06154549e-01f,
  -2.55437732e-01f, 3.09923179e-02f, -1.19112395e-01f, -1.31829783e-01f, 1.64008155e-01f, -2.97388136e-01f, -2.47705460e-01f, 2.05589339e-01f, 1.01235248e-01f, 1.45386353e-01f,
  1.64567247e-01f, -9.82129276e-02f, -1.69197455e-01f, -1.70493320e-01f, 9.39130932e-02f, -3.35341066e-01f, 1.56681314e-01f, -3.20601970e-01f, 1.35563567e-01f, -1.56226590e-01f,
  -3.75129394e-02f, 1.88793484e-02f, -1.75407201e-01f, -1.92384645e-01f, 1.16683925e-02f, 1.11053623e-01f, 6.95333555e-02f, 2.04833031e-01f, -1.89235717e-01f, 1.86832979e-01f,
  1.35207176e-01f, -5.66001236e-02f, 3.41362483e-03f, 8.56543481e-02f, 1.03750058e-01f, -1.58043534e-01f, 7.69156739e-02f, -2.99372878e-02f, 2.66868770e-01f, 2.32981578e-01f,
  -1.81312695e-01f, 2.29880840e-01f, 7.16261566e-02f, 2.02273697e-01f, 3.32891196e-01f, 2.41366610e-01f, 1.82601333e-01f, -8.41647685e-02f, 1.69773102e-01f, 1.00847997e-01f,
  1.84359506e-01f, -1.38103068e-01f, 1.46345615e-01f, 1.81217372e-01f, 6.33733347e-02f, 1.41437650e-01f, -4.12389785e-01f, 4.84003425e-02f, -7.59089142e-02f, -8.87599140e-02f,
  -2.12825626e-01f, -9.78537127e-02f, 2.97112465e-01f, 1.05968565e-01f, -3.16935815e-02f, -3.00800771e-01f, -9.42282081e-02f, -1.30390167e-01f, -9.51566398e-02f, -2.29086176e-01f,
  3.30234975e-01f, -1.22004136e-01f, -2.80376017e-01f, -2.29119807e-01f, 1.79027051e-01f, 4.41574194e-02f, 2.20051348e-01f, 2.65960842e-01f, -3.60881984e-01f, -3.94718349e-01f,
  -2.39735648e-01f, 3.01811814e-01f, -9.76465046e-02f, -1.00433091e-02f, 7.91485012e-02f, -9.53047723e-02f, 7.31395409e-02f, -3.13541926e-02f, 6.25196379e-03f, 1.29400596e-01f,
  -1.24408968e-01f, -7.20321909e-02f, 2.67626960e-02f, 3.48544978e-02f, -9.41319466e-02f, -1.69576537e-02f, -2.84850015e-03f, 2.95862965e-02f, 1.14992023e-01f, 2.88530998e-02f,
  2.85739675e-02f, 3.33892158e-03f, 3.46426181e-02f, 1.20441288e-01f, 1.52142391e-01f, -2.00175837e-01f, -1.19146876e-01f, -1.24475464e-01f, 1.31012142e-01f, 8.26834217e-02f,
  1.10357687e-01f, 1.98664531e-01f, 2.42679596e-01f, -2.19668373e-01f, -2.25032434e-01f, 5.56022450e-02f, 1.64874792e-01f, 1.18548192e-01f, -1.29488498e-01f, 5.52503578e-03f,
  9.39094499e-02f, -1.77322868e-02f, 2.02801704e-01f, 1.11831866e-01f, -4.11584191e-02f, 2.20212027e-01f, -2.93304831e-01f, -3.54320258e-02f, 9.10788253e-02f, -5.48674539e-02f,
  -1.43066421e-01f, 5.66728041e-02f, -2.40153044e-01f, 2.09008887e-01f, -1.95481285e-01f, 6.53126240e-02f, -1.58211574e-01f, -2.52903521e-01f, -1.33450732e-01f, -1.76285326e-01f,
  -3.67558710e-02f, 5.82630280e-04f, 1.15297802e-01f, 3.28818053e-01f, -2.70139217e-01f, -1.32921845e-01f, 7.35387430e-02f, -2.26326987e-01f, -2.97217201e-02f, 1.16757967e-01f,
  -5.68053275e-02f, -1.25819713e-01f, 1.32912872e-02f, 1.62679777e-02f, -6.43069968e-02f, -9.10461992e-02f, 3.06188222e-02f, -1.72334254e-01f, -1.11199044e-01f, -3.15752923e-02f,
  -2.94538260e-01f, -1.44508198e-01f, 9.59286559e-03f, -1.08834142e-02f, -9.27443802e-02f, -2.06252888e-01f, 2.79471964e-01f, -2.04039291e-01f, -7.23721236e-02f, -5.01277111e-02f,
  -4.17495705e-02f, -2.64691353e-01f, 7.08256811e-02f, 2.42074147e-01f, -2.03606620e-01f, 6.01142757e-02f, -9.97306257e-02f, 1.35176823e-01f, 1.40171602e-01f, -6.52287230e-02f,
  -1.63137913e-01f, -1.04551157e-02f, -2.35283524e-01f, -1.38367623e-01f, -2.65400559e-01f, 3.30901593e-01f, -4.38554466e-01f, -2.30417550e-01f, 1.62496448e-01f, -4.97767627e-02f,
  1.32868692e-01f, 1.85646161e-01f, -2.31406003e-01f, 1.30071357e-01f, -7.43008107e-02f, -1.40402857e-02f, 1.73414007e-01f, -3.07683140e-01f, -1.44398287e-01f, -5.03559075e-02f,
  8.94210115e-02f, 9.93529037e-02f, -2.93537289e-01f, 2.21626237e-02f, -3.12773645e-01f, -3.32741946e-01f, 1.30445600e-01f, 1.08954936e-01f, -9.92630422e-03f, -3.51426095e-01f,
  1.83608547e-01f, 7.58244246e-02f, -7.79318884e-02f, -5.34407757e-02f, 7.14619085e-02f, -2.08268482e-02f, 2.17970148e-01f, -6.31312579e-02f, 5.05401157e-02f, 1.34319484e-01f,
  1.37038797e-01f, 1.58294261e-01f, 5.01686223e-02f, 1.46277964e-01f, 1.32915720e-01f, 1.49605140e-01f, -1.03320628e-01f, 9.78340283e-02f, -6.85010701e-02f, 1.58444837e-01f,
  9.31424797e-02f, 6.63285404e-02f, 1.45181760e-01f, -2.30293293e-02f, 2.86804408e-01f, 1.49974942e-01f, 3.03401053e-01f, -1.71111330e-01f, -4.96554300e-02f, 2.04020590e-01f,
  -1.14040755e-01f, -1.10585332e-01f, -6.02934659e-02f, 1.49527729e-01f, -1.77318618e-01f, 2.16930971e-01f, 1.61251187e-01f, 1.05025679e-01f, -2.99653828e-01f, -1.93728134e-01f,
  -1.62336364e-01f, 1.71904117e-01f, 2.03395128e-01f, 1.09385967e-01f, 2.15688825e-01f, -9.53859985e-02f, 1.72024108e-02f, -4.09194715e-02f, -1.56502217e-01f, 1.64560214e-01f,
  -5.96986376e-02f, 5.36721200e-02f, -1.99129716e-01f, -3.64703149e-01f, -4.00543034e-01f, -3.39882761e-01f, 2.25798994e-01f, 1.17238142e-01f, -1.17633499e-01f, -1.78045914e-01f,
  2.29907215e-01f, -1.27429992e-01f, 1.90788209e-02f, -6.10696413e-02f, 8.08534026e-02f, -4.16270867e-02f, -9.59141999e-02f, -1.06720068e-01f, -3.00229136e-02f, 7.70938722e-03f,
  -1.56636126e-02f, 7.56026246e-03f, 7.40373135e-02f, -7.98614919e-02f, 1.02922000e-01f, -1.21434936e-02f, -3.60142365e-02f, 7.03738481e-02f, 1.25886321e-01f, 4.31192294e-02f,
  1.67392474e-02f, 9.07676667e-02f, 7.13695809e-02f, -1.54232666e-01f, -2.03793377e-01f, 1.75924748e-01f, 3.48952748e-02f, 7.78931230e-02f, -1.03496671e-01f, -1.88038900e-01f,
  -1.80410981e-01f, 5.64270690e-02f, -1.02765530e-01f, 2.02744454e-01f, 1.00618601e-01f, 2.00281739e-01f, 1.66060016e-01f, 2.01050304e-02f, 1.13548785e-02f, 1.97783083e-01f,
  1.78244591e-01f, -1.87084243e-01f, 5.94315305e-02f, -2.98870742e-01f, 8.73050839e-02f, 4.29088883e-02f, 2.17037484e-01f, -3.47453535e-01f, -2.14702576e-01f, 1.56002017e-02f,
  -2.94258624e-01f, -1.34786189e-01f, 1.60840079e-01f, 1.32419271e-02f, -1.89150274e-01f, -1.42546743e-01f, -3.28206927e-01f, 6.60692304e-02f, -8.08546960e-04f, -9.82894376e-02f,
  1.64504930e-01f, 1.77006379e-01f, 1.44362986e-01f, -2.96852529e-01f, 3.04953530e-02f, 1.84850686e-03f, -1.24737017e-01f, -2.82900661e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  7.30945021e-02f, -4.26977240e-02f, -2.97395233e-02f, 1.29817380e-02f, 6.67846799e-02f, 1.22987568e-01f, -2.42914185e-02f, -2.15321779e-02f, -4.19654176e-02f, 4.29568142e-02f,
  6.85463697e-02f, 1.02518564e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    