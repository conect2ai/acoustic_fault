/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.29202351e-01f, -1.59098908e-01f, -1.12989947e-01f, -9.74233970e-02f, -2.33097702e-01f, -1.84223473e-01f, 7.18091205e-02f, -1.57185286e-01f, -3.37255031e-01f, 1.45699739e-01f,
  7.46648163e-02f, -5.75851351e-02f, 2.84046412e-01f, -2.29358897e-02f, 1.82993457e-01f, 2.01157659e-01f, -1.63665280e-01f, 1.23736486e-02f, -1.00217007e-01f, -3.71654965e-02f,
  -4.89360429e-02f, -5.03057102e-03f, 1.71430916e-01f, 1.85213666e-02f, -2.56231502e-02f, -1.60306409e-01f, 2.23310307e-01f, 5.99665157e-02f, 5.23590110e-03f, -2.77310200e-02f,
  -6.31475002e-02f, -6.04442805e-02f, -1.83273796e-02f, -6.41052751e-03f, 2.32523885e-02f, -5.46853915e-02f, 2.66644433e-02f, 2.21362915e-02f, -7.29925185e-02f, -5.63770272e-02f,
  5.50133176e-02f, 1.72589943e-02f, -6.70267195e-02f, 4.98367064e-02f, -6.39845580e-02f, -6.27933722e-03f, -5.93723059e-02f, -9.21789184e-02f, -2.40279436e-02f, -4.88294149e-03f,
  -8.14432558e-03f, -5.89186661e-02f, -2.30949596e-02f, -5.10511510e-02f, -2.11837795e-02f, -9.84169543e-02f, 1.00051137e-02f, 1.42446840e-02f, -1.77629404e-02f, -1.17807277e-01f,
  1.23160835e-02f, -8.25255439e-02f, 2.84868032e-02f, -1.22058613e-03f, 3.92245241e-02f, 8.18643533e-03f, 8.46003741e-03f, 9.08252373e-02f, -6.29332662e-02f, 6.48076981e-02f,
  2.63729803e-02f, -8.87510777e-02f, -8.00085217e-02f, -3.07420157e-02f, -1.17715960e-02f, -8.92356411e-03f, 7.18836337e-02f, 2.33982205e-02f, -4.06731665e-02f, 2.82912701e-02f,
  -2.84153759e-03f, -1.32358260e-02f, 5.85254729e-02f, 1.40599161e-02f, -5.45900688e-03f, 6.15637796e-03f, 1.09583316e-02f, -1.72821898e-02f, 8.79118405e-03f, 2.80299392e-02f,
  -9.01498925e-03f, 1.45590529e-02f, 1.32519780e-02f, -4.25491035e-02f, 8.51231217e-02f, 5.00892960e-02f, -1.18835773e-02f, -5.10326512e-02f, 5.97644690e-03f, -1.26376273e-02f,
  -3.26716565e-02f, -5.84627055e-02f, 3.61575149e-02f, -2.52625123e-02f, -5.33142835e-02f, 4.27843668e-02f, 6.35186434e-02f, -1.15425460e-01f, -1.97289810e-02f, 9.20085609e-03f,
  -3.22965086e-02f, -2.93606762e-02f, -1.43154822e-02f, 2.05269293e-03f, -1.37272198e-02f, 6.90728202e-02f, -5.82186207e-02f, -2.98784003e-02f, 5.70906000e-03f, 7.53465621e-03f,
  -1.46010831e-01f, -1.14558591e-02f, 2.34313728e-03f, -1.63872361e-01f, 9.10949800e-03f, -2.19725728e-01f, -4.36721206e-01f, 6.68055713e-02f, 1.98285729e-01f, -5.89814782e-02f,
  -2.44800225e-01f, 1.64751440e-01f, -5.10667264e-02f, -4.09174711e-01f, -1.67399511e-01f, -1.04980692e-01f, -3.14091086e-01f, -1.39075845e-01f, 1.26186386e-01f, 6.85342997e-02f,
  -8.37339740e-03f, -2.78522313e-01f, -2.14495584e-01f, 7.67971352e-02f, -1.01882294e-01f, 1.88651338e-01f, -3.50969769e-02f, 8.68536755e-02f, -1.60867959e-01f, -1.24688707e-01f,
  -1.88914374e-01f, 1.54169528e-02f, 1.52826132e-02f, 6.80857897e-02f, 1.44056194e-02f, -6.91854805e-02f, -9.39740315e-02f, -7.71745667e-02f, -8.50707665e-03f, -3.94447632e-02f,
  5.26871271e-02f, 1.93717442e-02f, 1.61746163e-02f, 2.14533582e-02f, 3.36557887e-02f, 3.14043462e-02f, 1.15565220e-02f, -2.67352834e-02f, 2.72286329e-02f, -4.14458923e-02f,
  1.35746878e-02f, 3.33958864e-03f, 1.78684574e-02f, -3.29200886e-02f, 3.28701958e-02f, -4.78561129e-03f, -4.31996398e-02f, 3.26621793e-02f, 1.57056078e-02f, 4.99035083e-02f,
  -5.88589720e-02f, 3.08969766e-02f, -6.82441145e-02f, -2.80011557e-02f, -3.46208401e-02f, -2.38668895e-03f, -1.36214914e-02f, -5.94449602e-03f, 1.33014880e-02f, -4.22264636e-02f,
  -2.56874654e-02f, -4.55092862e-02f, -1.88688170e-02f, -5.25613241e-02f, -5.35665303e-02f, -2.68981718e-02f, 2.60581495e-03f, -2.21964642e-02f, -1.69574153e-02f, -4.98775113e-03f,
  -2.25524344e-02f, -1.70571133e-02f, 3.64188105e-02f, -3.00356485e-02f, -2.06155982e-02f, -3.69641595e-02f, 1.77101279e-03f, -9.34490096e-03f, -1.78430192e-02f, -1.90114137e-02f,
  1.27192484e-02f, 1.69957429e-01f, 4.27483507e-02f, -3.31541002e-02f, 8.74030218e-03f, 9.91954282e-03f, -1.44556270e-03f, 1.93698797e-02f, 7.05045313e-02f, 1.21085541e-02f,
  -2.81881243e-02f, -4.25801165e-02f, 4.24627997e-02f, -2.61287503e-02f, -1.15382755e-02f, -2.02358589e-02f, -3.25376987e-02f, 7.81360315e-04f, -8.50571133e-03f, 1.61691627e-03f,
  -1.88083779e-02f, -2.14111339e-02f, -3.17459144e-02f, 1.90100856e-02f, -1.92958098e-02f, -5.14577255e-02f, 9.41784456e-02f, -2.82719592e-03f, -3.89607698e-02f, 3.56766470e-02f,
  -2.50713497e-01f, -1.52770475e-01f, -5.26343465e-01f, -2.24063531e-01f, 9.55324918e-02f, -1.56203106e-01f, -1.26987606e-01f, -5.38230687e-02f, -2.19196841e-01f, 2.10917592e-01f,
  1.31396681e-01f, -1.68745130e-01f, -1.00081051e-02f, -6.56362772e-02f, -2.79868722e-01f, -2.78442949e-02f, -3.10263280e-02f, 2.18008421e-02f, -7.16233999e-02f, 5.97475134e-02f,
  -1.18072420e-01f, 2.01507866e-01f, -2.68821150e-01f, 1.23513155e-01f, -3.20258774e-02f, -7.81614631e-02f, 2.91762650e-01f, -4.69118729e-02f, 8.85422751e-02f, -4.12562788e-02f,
  -9.50331092e-02f, -6.16375543e-02f, -2.93359011e-02f, -1.13737784e-01f, 1.71868037e-02f, 3.82371955e-02f, -9.02760308e-03f, -2.71812361e-02f, -7.19802603e-02f, -4.30214852e-02f,
  4.01734486e-02f, -3.23057175e-02f, 2.46927422e-02f, 2.04387102e-02f, -5.41686378e-02f, -9.59257483e-02f, -1.11596964e-01f, -1.24720177e-02f, -8.33043233e-02f, -4.86700647e-02f,
  -1.40990689e-01f, -9.28753093e-02f, -9.98808630e-03f, -1.82267558e-02f, -7.47915730e-02f, -7.59711042e-02f, -5.18786488e-03f, -7.24450592e-03f, 1.18640615e-02f, 4.03274689e-03f,
  1.36015881e-02f, -9.04872175e-03f, 9.21122357e-03f, -1.60135385e-02f, 2.04786025e-02f, 4.67103235e-02f, -1.82261597e-02f, 6.07818924e-02f, -2.57616490e-02f, 4.45478670e-02f,
  -4.70538484e-03f, -3.24452366e-03f, 5.07720793e-03f, -4.10065753e-04f, 2.16563810e-02f, 6.02248386e-02f, -1.90489925e-02f, 4.05850150e-02f, -3.01469620e-02f, -1.18800132e-02f,
  -9.28229280e-03f, -6.00009188e-02f, -1.98242418e-03f, 6.03461564e-02f, -5.82887195e-02f, -3.38575505e-02f, 1.38629004e-02f, -7.45121390e-02f, 3.16496864e-02f, -2.95876972e-02f,
  1.67031616e-01f, 2.41231591e-01f, 1.54548772e-02f, -1.76502150e-02f, 4.05399948e-02f, 2.20414693e-03f, -5.38256243e-02f, 7.56270513e-02f, 9.55149718e-03f, 1.63806677e-02f,
  6.56210557e-02f, 8.17334931e-03f, 5.24367439e-03f, -2.00965125e-02f, -4.21522185e-02f, 7.28272051e-02f, 2.70395242e-02f, 4.32448685e-02f, 6.31152913e-02f, 5.76030873e-02f,
  7.13461414e-02f, 4.98797223e-02f, -5.33280298e-02f, 4.26909588e-02f, 9.92767885e-02f, 4.42479812e-02f, 6.23505488e-02f, -1.29429996e-02f, 4.16082963e-02f, -4.17870060e-02f,
  -2.27985114e-01f, 3.02963585e-01f, -2.76741564e-01f, 6.34171590e-02f, 2.69386679e-01f, 1.98365733e-01f, 4.76287827e-02f, -1.52687784e-02f, 1.50679192e-02f, 5.59339449e-02f,
  -1.15893530e-02f, 2.14799643e-02f, -8.72714892e-02f, -9.30803362e-03f, 2.65145376e-02f, -5.17707393e-02f, 5.55578060e-02f, -2.25688256e-02f, -5.60701191e-02f, 8.55259970e-02f,
  -9.13561210e-02f, 2.03709990e-01f, -2.57805556e-01f, 2.11101443e-01f, 3.21544968e-02f, -6.16295040e-02f, -2.84356736e-02f, -4.83445227e-02f, -7.78942555e-02f, 4.41978313e-02f,
  -4.82135713e-02f, -4.89559723e-03f, -8.19074288e-02f, -9.27742720e-02f, -6.35829046e-02f, -1.15305725e-02f, 4.31364626e-02f, -4.41870280e-02f, -6.31301031e-02f, 2.96826083e-02f,
  -1.15840975e-03f, 2.36429684e-02f, 1.08913640e-02f, 6.60007522e-02f, 4.50970232e-02f, -1.84914041e-02f, -7.99130723e-02f, -1.06198005e-01f, -2.72939535e-04f, 5.20642847e-03f,
  2.77431030e-02f, 4.54823524e-02f, -3.35539244e-02f, -3.95503966e-03f, 5.69229946e-03f, -2.73947492e-02f, 4.67715981e-05f, 1.29483677e-02f, 7.81165063e-02f, 6.03959858e-02f,
  2.14300081e-02f, -2.44995262e-02f, 5.20528741e-02f, 2.07372736e-02f, 6.03890568e-02f, -1.88685283e-02f, 2.02090181e-02f, -6.76068515e-02f, -6.76579773e-02f, 7.61128366e-02f,
  -5.53135648e-02f, 3.51222511e-03f, -1.32594528e-02f, -5.30806649e-03f, 5.04460000e-02f, 7.89257362e-02f, -1.27625912e-01f, -1.24640167e-02f, -3.96201275e-02f, -5.83260022e-02f,
  1.85099337e-02f, 4.33224589e-02f, -1.50451586e-02f, -5.29421680e-02f, 3.54304127e-02f, -6.76442906e-02f, -1.57232415e-02f, -1.47395432e-02f, -2.92816702e-02f, 1.63914729e-02f,
  1.70505330e-01f, 2.28060961e-01f, 6.51582377e-03f, 1.37644634e-01f, -1.66310668e-02f, 7.86345676e-02f, -3.21491025e-02f, 2.01481115e-02f, 2.76314430e-02f, 4.32222849e-03f,
  1.33756390e-02f, 3.01168300e-02f, 1.40630757e-03f, -2.18510740e-02f, 3.41771618e-02f, 8.92726555e-02f, 6.03797697e-02f, 3.52133736e-02f, 7.16804937e-02f, -1.41219178e-03f,
  6.54226020e-02f, -4.77305986e-03f, 6.35550246e-02f, 6.17595725e-02f, -4.64896858e-02f, 1.77783109e-02f, 9.33168679e-02f, 3.47397327e-02f, -3.19341049e-02f, -1.14962393e-02f,
  -2.35268310e-01f, -3.72621790e-02f, 1.27945721e-01f, -1.44353464e-01f, -1.41765967e-01f, -1.43161491e-01f, 1.92928478e-01f, -2.27908209e-01f, 8.82281810e-02f, -8.25050473e-02f,
  1.37901714e-03f, 9.86400545e-02f, 2.45295256e-01f, -1.45690143e-01f, -1.81781426e-02f, 2.69665658e-01f, -9.68336686e-02f, 3.11289448e-03f, 9.05472562e-02f, -1.40747398e-01f,
  -5.58549799e-02f, -1.30143896e-01f, 4.60488275e-02f, -2.42560029e-01f, -1.10683799e-01f, -7.41073638e-02f, -9.15243477e-02f, 9.14588049e-02f, -2.61546463e-01f, -4.36989628e-02f,
  -4.51355167e-02f, 4.53989878e-02f, 2.02221721e-02f, 3.83311026e-02f, -5.58732785e-02f, -1.86024408e-03f, 3.62676047e-02f, 1.23615891e-01f, 9.47551220e-04f, 2.31031477e-02f,
  5.56403100e-02f, -7.18920678e-02f, -7.21253008e-02f, 3.36242542e-02f, -4.98911552e-02f, 6.69906475e-03f, 3.13785002e-02f, -8.67200084e-03f, 6.33664355e-02f, -8.73734988e-03f,
  2.86147408e-02f, 3.23675424e-02f, -9.44597740e-03f, 4.78153229e-02f, 4.63990085e-02f, 3.82461995e-02f, 1.68776757e-03f, 4.66638282e-02f, -5.08371294e-02f, -1.98287424e-02f,
  1.91947836e-02f, -7.61037506e-03f, 3.41710262e-02f, -5.48360050e-02f, -3.01400498e-02f, -2.00574882e-02f, -3.75888273e-02f, -1.33903436e-02f, -1.89723559e-02f, -2.45529134e-02f,
  -1.13707945e-01f, -3.68125737e-02f, -2.82001272e-02f, 4.09489386e-02f, -2.08189487e-02f, 2.75787078e-02f, 1.49361435e-02f, -3.58864628e-02f, -2.22787783e-02f, 9.42545477e-04f,
  2.98236739e-02f, -3.40219885e-02f, -1.87847316e-02f, 1.51360584e-02f, 4.80502658e-03f, 7.48451240e-03f, 4.29895381e-03f, 5.08124456e-02f, 2.97069252e-02f, -6.99520856e-02f,
  -3.14262837e-01f, -1.82677343e-01f, -2.79846918e-02f, -3.31208147e-02f, -4.98435870e-02f, 2.32657022e-03f, 2.88336948e-02f, 1.80389024e-02f, 2.35324595e-02f, -2.17105038e-02f,
  -3.42300092e-03f, -5.16586332e-03f, -1.09649282e-02f, -1.41939996e-02f, 2.92587411e-02f, -5.09320088e-02f, -1.85454320e-02f, 7.29919877e-04f, -1.16712950e-01f, -1.05079956e-01f,
  -3.95665616e-02f, 3.21520939e-02f, 6.07857332e-02f, -7.11224182e-03f, -1.60321668e-02f, -2.01480668e-02f, -4.64725271e-02f, 8.43630731e-02f, 3.12893875e-02f, -7.59395165e-03f,
  3.38480115e-01f, -1.58817861e-02f, -6.00625128e-02f, 1.68982834e-01f, 1.40105560e-01f, -2.63367862e-01f, -1.75412521e-01f, 8.58893692e-02f, -1.61589250e-01f, -1.09148785e-01f,
  4.15150598e-02f, 1.62395984e-02f, -1.06109567e-01f, -9.25910845e-02f, 1.49186067e-02f, -3.19076985e-01f, 4.57087159e-02f, -9.05576795e-02f, -6.46975189e-02f, 1.74445748e-01f,
  -2.45208247e-03f, 7.47950673e-02f, -4.36492413e-02f, 4.14891280e-02f, 1.56035587e-01f, 1.23786181e-01f, 2.95718879e-01f, -2.68659592e-02f, 2.40890592e-01f, 4.36185822e-02f,
  -1.23490222e-01f, -1.03636481e-01f, 9.32986140e-02f, -4.13857028e-02f, -1.00778863e-02f, 3.35611552e-02f, 2.59967968e-02f, -2.82019973e-02f, 1.12436032e-02f, -4.67376113e-02f,
  4.63137031e-02f, 2.75375135e-02f, -1.82500686e-02f, -2.34257374e-02f, -6.39349269e-03f, -1.77255571e-02f, -3.53602394e-02f, -4.52094618e-03f, -1.99079346e-02f, 2.29676701e-02f,
  -7.13654282e-03f, 6.41966164e-02f, 8.28688666e-02f, 7.77559876e-02f, 7.69106671e-03f, -2.35360372e-03f, -7.47016594e-02f, 3.74006070e-02f, -1.44597329e-02f, -1.36880223e-02f,
  6.98462725e-02f, -8.47565767e-04f, -1.00307763e-02f, 2.18716282e-02f, -2.80809514e-02f, 3.76335643e-02f, -9.34118987e-04f, -2.66971793e-02f, -2.79018227e-02f, -4.69955131e-02f,
  -7.67375249e-03f, 4.22567502e-02f, 7.00879318e-04f, 5.27823484e-03f, 3.08572464e-02f, -1.64394733e-02f, 2.11312156e-02f, -7.59504037e-03f, -1.60476670e-03f, -5.36792502e-02f,
  -9.05555580e-03f, 2.38598417e-02f, -5.96363246e-02f, 6.52470291e-02f, -4.97032888e-02f, 7.96838384e-03f, 1.20290853e-02f, -1.19146183e-02f, -3.29681076e-02f, 5.71188703e-02f,
  -6.93638902e-03f, 1.96437985e-02f, -6.92719221e-02f, -6.52127666e-03f, -3.80959287e-02f, 3.85932275e-03f, -4.60957550e-03f, 4.59319726e-02f, -6.89934473e-03f, -3.52317840e-02f,
  6.48371652e-02f, 2.24067066e-02f, 4.91315424e-02f, 2.22295243e-02f, 3.36084105e-02f, -4.04017093e-03f, 2.72318479e-02f, 5.35086207e-02f, 4.72567342e-02f, -1.86559162e-03f,
  3.35284770e-02f, 3.56190950e-02f, -6.03158958e-03f, 1.60521138e-02f, 7.24893808e-02f, 2.91568656e-02f, 8.51339102e-02f, -3.05073168e-02f, 7.91738555e-02f, -1.54124247e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.15351535e-02f, -5.22400618e-01f, 1.84792563e-01f, 1.27909765e-01f, 3.65747631e-01f, 2.41949961e-01f, 3.95409346e-01f, -4.68389690e-02f, -1.97403535e-01f, -5.86029887e-01f,
  -7.61408210e-02f, -1.10371619e-01f, -1.27237648e-01f, -2.97086108e-02f, 4.39542532e-01f, -1.06976936e-02f, -5.05389124e-02f, -1.23107910e-01f, 1.06771775e-01f, -2.19978336e-02f,
  1.76785767e-01f, 9.91952270e-02f, 2.86783785e-01f, -1.23391367e-01f, 9.38189626e-02f, -1.27608210e-01f, -4.24080193e-02f, 1.31374702e-01f, -6.84594512e-02f, 1.21198885e-01f,
  1.17706232e-01f, -1.65725395e-01f, 1.02970220e-01f, -5.94229512e-02f, -8.88888016e-02f, -1.82516500e-02f, -4.94748959e-03f, 4.27565612e-02f, 5.20968102e-02f, -2.88513415e-02f,
  -8.60148519e-02f, -5.02904365e-03f, -1.27247358e-02f, 6.93432689e-02f, 1.67582221e-02f, 1.88813079e-02f, 3.15914745e-03f, -4.57330048e-02f, 7.04017729e-02f, 1.09395562e-02f,
  4.54997122e-02f, -4.08489257e-02f, 7.19819367e-02f, -1.09634049e-01f, 3.84701900e-02f, -3.31895426e-02f, 4.47175577e-02f, 8.15032423e-02f, -1.20490249e-02f, -1.08060185e-02f,
  -4.95083109e-02f, 4.70678881e-02f, -2.94529386e-02f, 3.63411307e-02f, 2.44658440e-02f, 2.79325005e-02f, -5.35160676e-02f, 5.05732745e-02f, 1.92250218e-02f, 1.81779508e-02f,
  -5.30831590e-02f, -5.11268247e-03f, -1.52822128e-02f, 3.84082906e-02f, 1.30411889e-02f, 1.91419553e-02f, 3.19289416e-02f, -7.29804710e-02f, 3.28691327e-03f, -1.31939333e-02f,
  1.06018959e-02f, -6.05989294e-03f, -2.19101422e-02f, 7.88192526e-02f, -7.39260092e-02f, 1.17997890e-02f, -3.67727391e-02f, -6.83963299e-02f, 4.72587086e-02f, 1.27368003e-01f,
  -1.64758056e-01f, -3.58276099e-01f, -1.16727296e-02f, -6.43058121e-02f, -2.57555172e-02f, -1.09418504e-01f, -8.02438930e-02f, -7.57208690e-02f, -9.99737065e-03f, -4.66413535e-02f,
  -4.75203432e-02f, -2.20119711e-02f, -5.36277965e-02f, 3.52725461e-02f, -2.52006995e-03f, -5.73059171e-02f, -1.93137676e-02f, -4.91598956e-02f, -6.86884532e-03f, -7.05065802e-02f,
  -1.87749732e-02f, -2.66838390e-02f, 1.85049046e-02f, 1.36533519e-02f, -2.43916325e-02f, -4.16207388e-02f, -2.25639418e-02f, -6.03870377e-02f, 5.85779846e-02f, -3.86190899e-02f,
  -1.37559056e-01f, -3.62806097e-02f, 2.39700428e-03f, -1.84536278e-01f, 1.45775616e-01f, 2.44150013e-02f, 3.58752497e-02f, 1.24853455e-01f, -8.26053545e-02f, 1.30794391e-01f,
  -1.20947082e-02f, -1.72153845e-01f, -1.55397914e-02f, -2.62328446e-01f, -2.00800449e-01f, -1.60927072e-01f, -1.04496405e-01f, -7.16827344e-03f, 1.14200123e-01f, -4.82234545e-02f,
  -7.88302347e-02f, 5.41529804e-02f, 2.08381414e-02f, 1.69371039e-01f, 2.18748748e-02f, 1.57928709e-02f, -3.95374969e-02f, 2.07348064e-01f, -7.98886269e-02f, 4.60508764e-02f,
  3.82349007e-02f, -1.78851876e-02f, -7.23393559e-02f, -9.51366946e-02f, -1.30203562e-02f, 3.97520000e-03f, -5.34841977e-02f, -8.93536806e-02f, 4.54377569e-02f, 8.32682401e-02f,
  -1.73210818e-02f, -4.78719594e-03f, -1.52484141e-02f, 6.55980930e-02f, 1.34879977e-01f, 6.18511438e-02f, -9.54591408e-02f, 8.43313802e-03f, -2.47956738e-02f, -3.79327908e-02f,
  -8.40138495e-02f, -4.74701747e-02f, -2.17871964e-02f, 2.85603460e-02f, -8.83042291e-02f, 2.11731475e-02f, 9.40727443e-03f, -5.63345337e-03f, -3.95779908e-02f, -6.24309815e-02f,
  8.10497776e-02f, 1.07837945e-01f, 4.11067009e-02f, -6.67265356e-02f, -4.61952090e-02f, 7.81654492e-02f, -6.63277283e-02f, 7.29341358e-02f, 8.53724554e-02f, 6.51396737e-02f,
  -1.46480286e-02f, 6.08887617e-03f, 3.61711867e-02f, 7.88109079e-02f, -2.52489056e-02f, 1.33467037e-02f, 9.42638591e-02f, 2.64253411e-02f, -4.55574272e-03f, -1.02468923e-01f,
  -8.39426145e-02f, 2.21698098e-02f, -4.94465195e-02f, 1.16388284e-01f, 2.32691020e-02f, 4.04905081e-02f, -1.64283849e-02f, -6.11861311e-02f, -1.70076098e-02f, 6.41058162e-02f,
  -9.79631301e-03f, 4.86528054e-02f, -4.71758172e-02f, 2.65366063e-02f, 6.15407377e-02f, 6.80402741e-02f, 5.95603548e-02f, -6.71560690e-02f, 9.16348547e-02f, -3.76135297e-02f,
  8.51512700e-02f, -5.23290783e-02f, -5.49052544e-02f, -3.93213704e-02f, 2.38422416e-02f, 4.76031564e-02f, 4.47897241e-02f, -4.89164479e-02f, 9.61813796e-03f, 1.63332224e-02f,
  5.99992052e-02f, 1.23060942e-01f, -6.03377298e-02f, 6.40615374e-02f, -8.67576897e-03f, 3.68160009e-03f, 5.39982170e-02f, -2.12662686e-02f, 1.61382724e-02f, 7.17784539e-02f,
  -7.58948401e-02f, -3.62170428e-01f, -2.85118639e-01f, 1.89012587e-02f, 1.29510403e-01f, 3.33001465e-02f, 3.53079364e-02f, -1.29565597e-01f, -1.96407795e-01f, 1.49924038e-02f,
  7.33012557e-02f, 4.87273335e-02f, -2.18474194e-01f, 4.02756296e-02f, 9.94131118e-02f, -2.15116501e-01f, -1.26298582e-02f, 4.28262465e-02f, -9.44763869e-02f, -1.16172366e-01f,
  2.49031223e-02f, 2.25981455e-02f, -7.01391026e-02f, 1.24854557e-02f, -3.99933010e-02f, 4.84376736e-02f, 2.37798274e-01f, -5.91011299e-03f, 2.67928332e-01f, 2.14081511e-01f,
  -1.04028255e-01f, -1.57065377e-01f, -8.09209272e-02f, 1.21280616e-02f, 7.04828799e-02f, 7.33647496e-02f, 2.47628652e-02f, 1.22795150e-01f, 6.84605092e-02f, -4.73205186e-02f,
  4.98867817e-02f, -1.87111422e-02f, 4.94919419e-02f, -5.55289313e-02f, -3.84146981e-02f, -3.15069407e-02f, -7.66001418e-02f, 1.60361882e-02f, 3.93260419e-02f, -3.76847871e-02f,
  -1.26403630e-01f, 5.98217510e-02f, -3.24371159e-02f, -5.19534154e-03f, -4.38059941e-02f, -2.23796684e-02f, -3.53197497e-03f, 1.35258287e-02f, 7.90371671e-02f, -3.80633064e-02f,
  1.68287812e-03f, -1.52516989e-02f, -2.22681407e-02f, -9.21382196e-03f, -1.85180400e-02f, 1.02830090e-01f, 3.22957113e-02f, 2.38758828e-02f, 2.84825880e-02f, 3.56022604e-02f,
  -6.00910075e-02f, 5.47710396e-02f, 9.17904302e-02f, -6.32660314e-02f, 1.76866706e-02f, -5.06306551e-02f, -1.63372066e-02f, 1.04695506e-01f, 1.30778356e-02f, 1.65049583e-02f,
  -7.27523398e-03f, 5.40035181e-02f, 4.98851463e-02f, -5.71054481e-02f, -8.92652720e-02f, -4.18756977e-02f, -1.39265917e-02f, -2.92328931e-02f, -5.46166450e-02f, 5.32936603e-02f,
  -3.09113562e-02f, -7.94011056e-02f, -1.07587632e-02f, -2.09015682e-02f, 7.21006170e-02f, 8.74180421e-02f, 5.06767966e-02f, -5.94165474e-02f, -7.79043436e-02f, -6.15664432e-03f,
  -1.48178125e-02f, 7.64810517e-02f, 8.38645101e-02f, 1.14657529e-01f, 7.80795468e-03f, -7.02028200e-02f, -3.81736085e-02f, 5.51585294e-02f, 3.77474539e-02f, 4.33293693e-02f,
  5.77794667e-03f, -2.90032923e-02f, -4.59831534e-03f, 3.96585837e-02f, 4.63204756e-02f, 9.55034140e-03f, 1.47791347e-03f, -1.34980669e-02f, -1.81617010e-02f, 2.48193927e-02f,
  -3.29013139e-01f, 2.09317401e-01f, -4.18753736e-02f, -4.41348851e-01f, 1.37267366e-01f, -2.41163410e-02f, -1.36060804e-01f, 9.81139243e-02f, -1.56982243e-01f, -2.91163158e-02f,
  -1.00832939e-01f, -8.73623714e-02f, 2.17976630e-01f, -1.58359736e-01f, -7.38157257e-02f, 1.50167728e-02f, -3.16672921e-01f, -2.61505187e-01f, 1.38872817e-01f, -9.52302143e-02f,
  -1.74863741e-01f, -1.02235042e-01f, -1.09785451e-02f, 2.28222862e-01f, -9.49961320e-02f, 1.94851495e-02f, -6.21682443e-02f, 1.24529228e-01f, -7.34605920e-03f, -3.33388597e-02f,
  3.50262932e-02f, -6.73513114e-02f, -1.74700562e-02f, 6.19848967e-02f, -6.69439733e-02f, -5.98215638e-03f, -2.71352828e-02f, 7.27155283e-02f, 2.21802257e-02f, 3.91329601e-02f,
  -1.26666546e-01f, -4.23580855e-02f, 1.52669074e-02f, 1.02573484e-01f, -1.15593337e-02f, -2.40975935e-02f, 7.04260617e-02f, 5.60480878e-02f, 5.94428517e-02f, 1.10884167e-01f,
  2.02665199e-02f, -2.94897463e-02f, -7.98291788e-02f, -1.20020144e-01f, -5.58704361e-02f, -4.33713682e-02f, 7.58104911e-03f, 1.93859152e-02f, -7.70515651e-02f, 4.76477407e-02f,
  4.20213304e-03f, -5.16562797e-02f, 2.41354480e-03f, 7.49595985e-02f, 5.15327044e-02f, -4.01044674e-02f, -8.80108681e-03f, -2.99226418e-02f, 8.76282249e-03f, -1.34876417e-02f,
  -6.96957111e-02f, -7.22276513e-03f, 5.54983579e-02f, -4.97282854e-05f, -9.55801904e-02f, -6.83799386e-02f, -7.63283223e-02f, 3.17431167e-02f, 3.03973798e-02f, 9.82343592e-03f,
  -3.26164477e-02f, -1.13125555e-01f, 2.43527312e-02f, -1.18407479e-03f, 3.97189409e-02f, 1.38899414e-02f, -3.13574709e-02f, -6.60446510e-02f, -1.89864207e-02f, 3.97832431e-02f,
  3.34682949e-02f, -2.51980454e-01f, 1.05506994e-01f, 2.30870191e-02f, 4.33289669e-02f, -1.84092466e-02f, -8.59963074e-02f, 3.25378962e-02f, -6.51404075e-03f, -1.53360292e-02f,
  -6.39781356e-02f, -5.57359774e-03f, 2.54619494e-03f, -4.38107513e-02f, -8.76966566e-02f, 1.87488236e-02f, -8.62333700e-02f, -4.77102175e-02f, -9.39835012e-02f, 7.43698701e-02f,
  -9.07867774e-02f, -6.99576864e-04f, -7.10641220e-03f, -5.21436110e-02f, 4.37904801e-03f, -3.10472678e-02f, -5.93636744e-02f, 2.76976563e-02f, -4.13569957e-02f, -1.76307708e-02f,
  2.26917267e-01f, -2.28298106e-03f, -1.77707106e-01f, -8.23229849e-02f, -7.77394176e-02f, -1.31180197e-01f, -1.94200784e-01f, 3.15027963e-03f, 1.00237712e-01f, -1.07726835e-01f,
  1.09713592e-01f, -7.37377256e-02f, 1.86048783e-02f, -4.51481864e-02f, 8.07420313e-02f, 5.24926260e-02f, -3.30036879e-02f, -6.43990859e-02f, -5.45930304e-02f, 8.15187469e-02f,
  1.14600740e-01f, -2.45252382e-02f, -4.32270095e-02f, 5.27784526e-02f, 7.45263472e-02f, -6.84370920e-02f, 1.82448253e-02f, 2.32619867e-02f, 1.75828096e-02f, 3.03867310e-02f,
  1.66172795e-02f, 7.79598653e-02f, -2.45368015e-02f, -1.01983838e-01f, 1.65664889e-02f, 3.05818859e-02f, -4.97081829e-03f, -1.18980326e-01f, -5.63114025e-02f, 8.98586586e-03f,
  -6.25452399e-02f, -5.48388250e-03f, -3.05399951e-02f, 7.78906047e-02f, -4.34641540e-02f, -6.56718165e-02f, 7.58709610e-02f, -4.42038365e-02f, -5.79373725e-02f, 8.84707943e-02f,
  -6.05880655e-02f, -7.57156592e-03f, 1.76750273e-02f, 2.60531604e-02f, 2.23025996e-02f, 5.20513505e-02f, -1.01794183e-01f, 4.02664952e-02f, 1.08150281e-02f, 1.89471487e-02f,
  -1.26538677e-02f, 1.12075098e-02f, 4.15191725e-02f, 3.09476461e-02f, -4.52660844e-02f, -6.85667768e-02f, 6.40772656e-02f, -9.84890908e-02f, 8.40863213e-02f, -4.80443761e-02f,
  8.31684023e-02f, -8.70429352e-02f, -3.47272716e-02f, 9.70374569e-02f, 4.86495234e-02f, 3.67934294e-02f, 4.30848561e-02f, 6.43444657e-02f, -7.21806660e-02f, 7.31655434e-02f,
  2.63074934e-02f, -6.62672392e-04f, -3.60274836e-02f, 9.54167321e-02f, -6.83862045e-02f, -8.00923631e-03f, 2.20227800e-02f, -8.78645554e-02f, -4.02884483e-02f, 1.06460154e-02f,
  -1.82909761e-02f, 3.57102193e-02f, -6.26472309e-02f, -1.06068484e-01f, 4.24400195e-02f, 1.12588637e-01f, 5.62381558e-02f, -2.23504081e-02f, 5.61412014e-02f, 6.43120408e-02f,
  -1.97129231e-02f, -4.12496217e-02f, 7.30355084e-02f, 9.00645256e-02f, -9.99354497e-02f, 2.65313257e-02f, 8.22460949e-02f, -6.99043795e-02f, -2.69498280e-03f, 1.97922587e-02f,
  -7.64992610e-02f, 1.80219356e-02f, 9.81526263e-03f, -6.45370036e-02f, 5.50789014e-02f, 2.89277360e-02f, 1.32111479e-02f, -2.40290612e-02f, -2.30014827e-02f, 8.44540000e-02f,
  -3.20341259e-01f, 2.10736722e-01f, -4.07500789e-02f, 9.73669253e-03f, -8.73599350e-02f, 8.76821876e-02f, 9.60965529e-02f, 5.78979664e-02f, -5.97475320e-02f, 1.93527807e-02f,
  5.17118769e-03f, -9.95774940e-02f, 3.24925818e-02f, 1.62536457e-01f, -1.63991541e-01f, 1.45617336e-01f, 5.17680235e-02f, 1.27195060e-01f, -3.62143032e-02f, 3.14449216e-03f,
  4.82954681e-02f, 2.15299129e-02f, 1.28333375e-01f, 1.12661190e-01f, -1.02804691e-01f, -1.68088153e-02f, -1.02097154e-01f, -8.14523175e-02f, -1.56677812e-02f, -3.27642774e-03f,
  -1.35013506e-01f, -9.58978012e-02f, -3.62631790e-02f, -1.86566859e-02f, 2.65298393e-02f, -5.36202826e-03f, -7.76441544e-02f, -9.79759842e-02f, -5.43401651e-02f, -2.65531447e-02f,
  -2.27137841e-02f, 4.54467423e-02f, -6.16266727e-02f, -4.99563590e-02f, 3.37290205e-02f, -8.40376914e-02f, -1.54510057e-02f, 6.44397065e-02f, 8.49228539e-03f, 5.38655072e-02f,
  1.75078381e-02f, 3.29275727e-02f, 8.28859806e-02f, 5.36678694e-02f, -7.13889673e-02f, 5.67380898e-02f, -1.81824528e-02f, -6.58784583e-02f, 1.63712576e-02f, 3.90656292e-02f,
  -1.06151491e-01f, 1.99210420e-02f, -5.93343638e-02f, -3.23889218e-02f, -4.08268720e-02f, 1.26640114e-03f, -1.32022202e-02f, -3.57586630e-02f, -1.78829264e-02f, 3.23721953e-03f,
  -8.00048411e-02f, 1.63644999e-02f, 2.25774758e-02f, 3.02213039e-02f, 2.63660178e-02f, 6.44511357e-02f, -7.81985279e-03f, 2.28238832e-02f, -1.61151048e-02f, -4.39769961e-02f,
  -2.01873388e-02f, -4.20079418e-02f, 2.61573326e-02f, -2.95699649e-02f, 1.27878441e-02f, 4.51648533e-02f, -3.51053998e-02f, -8.05026095e-04f, -9.82332528e-02f, -6.34252131e-02f,
  1.01954606e-03f, -3.60374674e-02f, -6.27753884e-02f, -9.03190449e-02f, 5.30714691e-02f, 4.75070514e-02f, -6.92358315e-02f, 5.37479594e-02f, 3.63168423e-03f, 4.36264556e-03f,
  -4.84540127e-02f, -5.22473529e-02f, 5.75708486e-02f, 3.69957797e-02f, -5.22461645e-02f, 5.85666671e-02f, -3.94443013e-02f, 3.65107916e-02f, -3.35011049e-04f, -3.51106077e-02f,
  4.09286842e-02f, -2.52877083e-02f, -8.38231519e-02f, -7.20242336e-02f, 1.96404364e-02f, -8.36656839e-02f, 1.59443393e-02f, -6.05667643e-02f, -3.43360677e-02f, -3.44672153e-05f,
  3.41256738e-01f, -3.83372545e-01f, -6.47653490e-02f, -2.48400941e-01f, -3.11616845e-02f, -3.00576180e-01f, -1.53124645e-01f, -4.07698691e-01f, -1.88687593e-01f, -3.30488056e-01f,
  -1.56782404e-01f, 1.10087983e-01f, 2.26644844e-01f, -4.43582177e-01f, 3.42703134e-01f, 1.35476738e-01f, -3.33911180e-01f, -8.17089900e-02f, -5.41365147e-03f, -3.43507797e-01f,
  5.37696518e-02f, -3.52587283e-01f, -5.74644692e-02f, -3.67914259e-01f, -2.61930615e-01f, -1.75688028e-01f, 4.41245474e-02f, 6.23210929e-02f, -2.61237711e-01f, 9.89655182e-02f,
  -1.54535517e-01f, -9.60953757e-02f, -1.06206089e-01f, -6.74890354e-02f, -5.72367199e-02f, -3.11187655e-03f, 1.38955802e-01f, 1.21134028e-01f, -4.24224185e-03f, 2.45905109e-02f,
  2.82572415e-02f, -5.09175248e-02f, -1.66727751e-01f, 5.72551489e-02f, 2.28808261e-04f, 2.44660722e-03f, -1.10797975e-02f, 3.73156220e-02f, -1.62518233e-01f, -2.37520672e-02f,
  -8.79369751e-02f, -2.57495567e-02f, -3.60355452e-02f, -1.60339940e-02f, 5.45822158e-02f, -6.90348297e-02f, -4.60013660e-04f, 6.32485747e-02f, -9.77313519e-03f, -5.84212691e-02f,
  -8.37661792e-03f, 5.30174822e-02f, 3.82095352e-02f, -5.86904138e-02f, -1.30319176e-02f, -2.79774591e-02f, 4.92639169e-02f, -1.17227361e-02f, 4.40174416e-02f, -3.00588980e-02f,
  -1.90305132e-02f, -1.01730498e-02f, -2.65904218e-02f, -2.54305871e-03f, 2.43721325e-02f, 4.74037156e-02f, 3.68161611e-02f, -4.16585524e-03f, -5.62224463e-02f, -3.28207724e-02f,
  1.54752024e-02f, 2.58595459e-02f, -2.21415721e-02f, 2.90968567e-02f, 4.48528491e-02f, 1.83054502e-03f, -3.53855938e-02f, -8.86508450e-03f, -2.22376548e-02f, 1.45616174e-01f,
  -6.69048131e-02f, -1.67735398e-01f, -1.22953385e-01f, 1.16890492e-02f, -4.42419089e-02f, -7.60962022e-03f, -2.98005100e-02f, -4.29533720e-02f, 1.25638638e-02f, -1.68057270e-02f,
  5.42369299e-03f, 7.96865448e-02f, 3.89523022e-02f, -2.04309393e-02f, 6.25484297e-03f, -1.42681345e-01f, 1.08655812e-02f, 9.31860879e-02f, -2.92854756e-02f, 2.00332270e-05f,
  4.41788547e-02f, 2.09392235e-02f, 9.67074409e-02f, -5.09450734e-02f, -8.03839341e-02f, 5.68227060e-02f, -4.16613892e-02f, 1.59543846e-02f, 4.12013382e-02f, 4.35840413e-02f,
  1.15215369e-01f, 1.35132790e-01f, -1.83878154e-01f, 2.18131602e-01f, 1.26491144e-01f, 2.68253148e-01f, 3.57509434e-01f, 1.97653145e-01f, 4.21477556e-01f, 4.18791249e-02f,
  8.63977075e-02f, 3.79878245e-02f, -4.01574820e-02f, 2.33347490e-01f, 1.67001545e-01f, 1.53657094e-01f, 2.89810330e-01f, 1.40878767e-01f, 2.03336105e-01f, 1.10637255e-01f,
  1.77722588e-01f, 1.80623084e-01f, -2.43454292e-01f, -1.40705660e-01f, -4.07332517e-02f, -1.47465184e-01f, -2.35970452e-01f, -2.22639188e-01f, -1.60372719e-01f, 2.02808753e-02f,
  5.15000559e-02f, 8.30562487e-02f, -4.82422076e-02f, -1.41242919e-02f, 1.36486394e-03f, -1.01637863e-01f, -5.05732521e-02f, -1.09596647e-01f, 3.11597134e-03f, 4.85742688e-02f,
  -1.17447581e-02f, -1.18107870e-01f, -2.86187348e-03f, -2.54815221e-02f, 1.52689386e-02f, -3.99191603e-02f, 1.27981044e-02f, 1.65219940e-02f, -6.57671690e-02f, -2.05919929e-02f,
  -9.93185788e-02f, -7.34119713e-02f, 3.59244831e-02f, -3.34315784e-02f, -4.57122996e-02f, 2.87591256e-02f, -2.72452775e-02f, -3.96098569e-02f, 4.55208123e-02f, 1.01850100e-01f,
  1.56770408e-01f, 1.10748813e-01f, -6.98865429e-02f, -1.71576217e-02f, 3.54678184e-02f, -6.04241528e-02f, 2.07009399e-03f, 4.58276970e-03f, 5.84040098e-02f, -3.27272750e-02f,
  7.42639750e-02f, 3.74839567e-02f, 5.79829961e-02f, 6.39926866e-02f, 6.92833290e-02f, -3.23733129e-02f, 1.52381379e-02f, 5.88359982e-02f, 2.01752316e-02f, -1.12282336e-02f,
  -3.55174951e-02f, 1.10374959e-02f, -1.46745536e-02f, -1.04194125e-02f, -7.13412464e-02f, 2.69362628e-02f, 5.89419231e-02f, -4.51864768e-03f, -4.28962409e-02f, 3.58762480e-02f,
  1.66904539e-01f, 3.54943931e-01f, 2.38802712e-02f, -2.51289755e-02f, -1.33889258e-01f, 6.14323840e-02f, -5.50337583e-02f, 1.02865532e-01f, -5.29711787e-03f, 8.00602585e-02f,
  -3.03478483e-02f, -2.54364628e-02f, 4.75532375e-02f, -5.02047613e-02f, -1.07208304e-01f, 5.07066622e-02f, -3.30259129e-02f, 3.02701369e-02f, 1.53736649e-02f, -2.81633735e-02f,
  -6.19853623e-02f, 8.27857181e-02f, -3.71241011e-02f, 3.27490754e-02f, 4.65843678e-02f, -7.80434385e-02f, -2.45259255e-02f, -1.75654981e-02f, -2.86532883e-02f, -7.03516463e-03f,
  5.60842633e-01f, -1.55125037e-01f, 6.64433166e-02f, 2.41147608e-01f, 7.07191378e-02f, -6.70114707e-04f, 6.92041293e-02f, 7.81544000e-02f, 2.88316935e-01f, -3.96599993e-02f,
  -5.74891455e-02f, 8.51054583e-03f, -3.54143590e-01f, 1.35954425e-01f, -1.97157890e-01f, -2.01256201e-01f, 2.03369139e-03f, 1.81516726e-03f, 3.59254070e-02f, 2.55136918e-02f,
  1.65845364e-01f, 3.99878733e-02f, -1.34979695e-01f, -3.76368389e-02f, 2.17645228e-01f, 8.82483274e-02f, -1.32875413e-01f, -2.23870456e-01f, 2.55518164e-02f, -2.13819340e-01f,
  7.61935860e-02f, -3.46775167e-02f, 1.86701231e-02f, -3.45624238e-03f, -1.42309992e-02f, 6.73857555e-02f, 5.01186922e-02f, -2.75119375e-02f, -6.82450607e-02f, 9.37449839e-03f,
  -2.14232653e-02f, 5.29370941e-02f, 8.46302286e-02f, -6.24501444e-02f, 7.71550462e-02f, 3.11601460e-02f, 2.95031220e-02f, 2.43034568e-02f, -9.12708119e-02f, 2.02169679e-02f,
  3.34073193e-02f, 8.17498118e-02f, 8.86551440e-02f, -1.03713967e-01f, -2.86874846e-02f, -4.58502211e-02f, -6.35793433e-02f, -8.16358179e-02f, 1.27352476e-02f, 7.30826345e-04f,
  -2.40497403e-02f, -3.51268426e-02f, -6.68777898e-02f, 7.35132396e-02f, 1.18885841e-02f, 3.74665335e-02f, 7.80571476e-02f, -6.27139881e-02f, -1.20741930e-02f, -1.71405133e-02f,
  -1.30927376e-03f, -1.95381343e-02f, -6.35024458e-02f, 3.75882313e-02f, 1.59823638e-03f, 1.14348173e-01f, 2.62368582e-02f, 6.21269383e-02f, 3.88420299e-02f, 4.92065288e-02f,
  -2.54837964e-02f, 2.64931284e-02f, -6.21523932e-02f, 2.20654365e-02f, 2.47745402e-02f, -5.59430271e-02f, 8.07155073e-02f, 9.20018777e-02f, 3.21606249e-02f, 1.70262568e-02f,
  -7.07790405e-02f, -1.85409710e-01f, -2.81518865e-02f, -3.72406542e-02f, -2.42900336e-03f, 6.32144362e-02f, -8.36121961e-02f, 3.63620706e-02f, 1.02524310e-02f, 2.51389798e-02f,
  -4.45932075e-02f, 7.41453022e-02f, -4.55702568e-04f, 2.71509439e-02f, -7.92672411e-02f, 6.47104830e-02f, -2.48569883e-02f, 2.13674624e-02f, -4.74248976e-02f, -9.27929729e-02f,
  -2.33998317e-02f, -2.95787081e-02f, -2.40379721e-02f, 2.31268927e-02f, 8.40497017e-02f, 1.81351695e-02f, -2.90169846e-02f, -9.49183106e-02f, -4.96641994e-02f, -3.10452171e-02f,
  -6.80853724e-01f, 2.16773406e-01f, -1.12248942e-01f, -1.79930225e-01f, -6.65781870e-02f, -2.83809632e-01f, -8.79746303e-02f, 2.97570229e-02f, 8.90155509e-02f, 7.18972906e-02f,
  5.15307039e-02f, -5.54476492e-02f, 2.52402514e-01f, 4.75131832e-02f, -2.46643975e-01f, 3.00793111e-01f, -1.56272307e-01f, -8.72534886e-02f, 1.23897575e-01f, -1.09479122e-01f,
  -7.71529451e-02f, 9.13341567e-02f, 8.83933604e-02f, 1.82523310e-01f, -1.05957754e-01f, -1.95935875e-01f, -9.96529162e-02f, 1.34191126e-01f, -1.34673148e-01f, 5.47991470e-02f,
  -1.82897866e-01f, -1.25930563e-01f, -2.03301415e-01f, -3.06637231e-02f, -1.54990852e-01f, -1.83747709e-01f, -1.00701861e-01f, 2.40387041e-02f, -7.13205636e-02f, -6.10047318e-02f,
  -4.45326008e-02f, 6.72214478e-02f, -5.20350374e-02f, 4.76389565e-02f, -1.11022420e-01f, -1.58787873e-02f, -9.79085919e-03f, -3.90125364e-02f, -2.75986213e-02f, 2.24706642e-02f,
  6.16748817e-02f, -2.57455669e-02f, 1.29720829e-02f, 4.14993577e-02f, 2.75068358e-02f, -3.30278873e-02f, -6.93040639e-02f, -9.28888544e-02f, -7.44664520e-02f, -1.05604604e-01f,
  4.86773923e-02f, -2.52821166e-02f, -4.78714630e-02f, -6.16644789e-03f, 2.14918852e-02f, 1.03638984e-01f, 4.93284874e-03f, 6.28365874e-02f, -5.47438711e-02f, 3.36656719e-02f,
  2.30743270e-02f, -9.99171752e-03f, 1.86498798e-02f, -7.29831308e-02f, 3.91147248e-02f, 2.38392353e-02f, -1.21271005e-02f, -8.39747768e-03f, -2.09712926e-02f, 3.44225280e-02f,
  1.46084214e-02f, 6.56394586e-02f, 3.76410596e-02f, -3.03512774e-02f, 5.83325839e-03f, -1.85653809e-02f, -1.33742029e-02f, 4.08717804e-02f, 1.04734423e-02f, -3.80534679e-02f,
  -3.36401463e-01f, -2.80062556e-01f, -7.16087073e-02f, 1.25638107e-02f, -6.66424409e-02f, -5.83686568e-02f, 6.01236895e-02f, -7.22050518e-02f, -1.09659858e-01f, 1.98461376e-02f,
  -4.81184423e-02f, -1.03814844e-02f, -1.56286228e-02f, -9.51527059e-03f, 3.02809849e-02f, -4.11780700e-02f, -4.57860976e-02f, -2.09190138e-02f, -1.13384992e-01f, -4.57630679e-02f,
  1.34790447e-02f, 1.31853083e-02f, -8.38722195e-03f, 1.68942045e-02f, -5.63011728e-02f, -1.66402720e-02f, -3.61304022e-02f, 1.98566541e-02f, -9.25225392e-02f, -3.64089664e-03f,
  2.04073876e-01f, 2.08007365e-01f, 1.70835424e-02f, 9.23092961e-02f, -1.11599557e-01f, -1.36213750e-01f, -4.31617424e-02f, -3.40098739e-02f, 5.70107736e-02f, 1.19706532e-02f,
  -1.59470394e-01f, 1.57604292e-01f, -5.52338809e-02f, -7.25566177e-03f, -2.17622399e-01f, -2.10236311e-01f, -1.20697707e-01f, -3.39949764e-02f, -7.03706369e-02f, 1.65637195e-01f,
  -8.87837932e-02f, -1.53398812e-01f, -1.45328552e-01f, -4.59766351e-02f, 6.56004949e-03f, 1.97384208e-01f, -4.89031635e-02f, -4.52332012e-02f, 1.43693015e-01f, -2.06232518e-02f,
  -1.18794688e-03f, 1.07688671e-02f, 8.34058374e-02f, -1.03809834e-02f, 6.33111075e-02f, 8.18826724e-03f, 1.06745608e-01f, -8.77169073e-02f, -1.13298498e-01f, 4.30146344e-02f,
  1.30999684e-01f, -3.26791070e-02f, -2.94492487e-03f, -1.13656586e-02f, 1.88625846e-02f, 7.07323179e-02f, 2.30922271e-02f, 8.54327753e-02f, 1.11602850e-01f, -3.55572067e-02f,
  2.17315517e-02f, 6.35038130e-03f, 6.02460206e-02f, 1.65066496e-02f, 2.49243230e-02f, 2.42127646e-02f, -2.86307912e-02f, 1.13133512e-01f, 7.84270093e-02f, 6.51605278e-02f,
  5.93911856e-02f, -9.53921117e-03f, 9.32367798e-03f, -1.11761503e-01f, 3.86257395e-02f, 4.57977317e-02f, -7.82716051e-02f, -7.65714869e-02f, -2.65357085e-02f, -6.60255253e-02f,
  4.62305099e-02f, -4.13400382e-02f, -1.12950064e-01f, -5.30377887e-02f, 6.51503727e-02f, 3.59396003e-02f, 4.82617281e-02f, -8.25702623e-02f, 7.41071329e-02f, -2.04477347e-02f,
  -4.81512286e-02f, 4.70653176e-02f, -5.14361002e-02f, 6.70855194e-02f, -8.18307623e-02f, 8.89118314e-02f, 1.67899020e-02f, 5.31533137e-02f, 4.46013138e-02f, -1.91940553e-02f,
  -2.87389308e-02f, 3.19464281e-02f, 1.03784733e-01f, 7.61580765e-02f, 2.15907581e-02f, 5.53893819e-02f, -7.26439282e-02f, 1.46222506e-02f, 5.69972135e-02f, -9.14645568e-03f,
  1.49588704e-01f, 5.78028485e-02f, -3.06218546e-02f, 4.02104259e-02f, -6.31307960e-02f, -2.17323229e-02f, 5.93190864e-02f, 3.50981541e-02f, -2.66258623e-02f, 7.92474374e-02f,
  1.13464795e-01f, -1.76139250e-02f, 4.77629341e-02f, 4.53801118e-02f, -2.58020423e-02f, 3.02103106e-02f, -8.86696205e-03f, 5.39653711e-02f, 7.29148835e-02f, -7.12150186e-02f,
  -5.34660323e-03f, -4.99339476e-02f, -1.72174484e-01f, -2.58809533e-02f, 4.45263162e-02f, 4.47821803e-03f, -1.44936368e-02f, 3.49656902e-02f, 7.60827884e-02f, 9.07761157e-02f,
  6.81973398e-02f, -3.33103091e-02f, 1.10804401e-02f, 9.64401737e-02f, -1.65800035e-01f, -1.28458381e-01f, 2.40538344e-02f, 5.38271433e-03f, 1.20161936e-01f, -3.21676722e-03f,
  -1.42006874e-01f, 1.38678372e-01f, -3.39231752e-02f, 3.24965194e-02f, 9.20884907e-02f, 3.46088894e-02f, -4.98329066e-02f, 2.63512209e-02f, 4.77333479e-02f, 1.18934840e-01f,
  -2.66521312e-02f, -3.84376645e-02f, -3.44149070e-03f, -3.23597454e-02f, -1.39923552e-02f, -1.88948102e-02f, 2.75981221e-02f, -5.20095462e-03f, 2.41056830e-02f, -2.60852408e-02f,
  -2.36828756e-02f, 5.47345392e-02f, 1.31492645e-01f, -5.17265908e-02f, -4.08076867e-02f, 4.29289304e-02f, 4.92142811e-02f, -9.44639891e-02f, -7.10593164e-02f, -5.13691902e-02f,
  -8.14119428e-02f, -1.33526668e-01f, -1.03084721e-01f, 9.33287218e-02f, -3.91479731e-02f, 9.24219042e-02f, 3.37958448e-02f, 3.84981632e-02f, -3.57502885e-02f, 8.49856734e-02f,
  8.93407166e-02f, 8.00745487e-02f, -3.75720672e-02f, -4.23412770e-02f, -9.26362816e-03f, -3.19418646e-02f, -5.70725184e-03f, 2.34803651e-02f, -5.09832762e-02f, -3.79843405e-03f,
  -3.27809788e-02f, 4.97558527e-02f, 4.75112237e-02f, 7.89200440e-02f, -6.01870269e-02f, -9.41735208e-02f, -1.30416639e-02f, 1.03576846e-01f, 6.27100393e-02f, -3.95126678e-02f,
  -4.01011147e-02f, -8.23567342e-03f, 6.98500276e-02f, -2.86313444e-02f, 7.42577910e-02f, 9.18513611e-02f, 1.09495133e-01f, -9.24829394e-02f, 6.30304664e-02f, 5.41635007e-02f,
  -7.56837875e-02f, 7.19115324e-03f, -3.16624790e-02f, 5.47260679e-02f, -3.04250959e-02f, 1.54688321e-02f, 3.16262469e-02f, -1.78067964e-02f, -5.13300821e-02f, -5.50398454e-02f,
  8.73736013e-03f, -5.44626005e-02f, -7.51209483e-02f, 8.75030085e-02f, -7.07967505e-02f, 3.17694023e-02f, 4.47131842e-02f, -3.88953928e-03f, -6.31929860e-02f, -4.16775383e-02f,
  -8.61982480e-02f, 7.72774918e-03f, -5.57712652e-02f, -1.06530689e-01f, -6.83839023e-02f, 3.38525772e-02f, 1.15463405e-03f, -3.38812284e-02f, -2.30739191e-02f, 3.99733521e-02f,
  1.93755284e-01f, 3.22059821e-03f, 1.01206124e-01f, 3.83747041e-01f, 8.64180550e-03f, -1.36102065e-01f, 3.84823829e-02f, 1.81705400e-01f, 2.91995823e-01f, -1.32895976e-01f,
  7.60203004e-02f, -9.14549679e-02f, -3.84615660e-02f, -6.03702106e-02f, 1.35898203e-01f, -5.21980934e-02f, 5.92787424e-03f, -4.17812541e-02f, 8.08215588e-02f, 1.42175898e-01f,
  1.70775369e-01f, -4.05653426e-03f, 1.36949280e-02f, -6.37043417e-02f, 7.59926662e-02f, 7.92147741e-02f, 6.34229481e-02f, 1.06033925e-02f, -5.34253046e-02f, -1.14281155e-01f,
  -2.82106046e-02f, 1.58334717e-01f, -6.37706667e-02f, -1.26696760e-02f, 8.92451033e-02f, -9.29412842e-02f, -1.14982061e-01f, -9.98739749e-02f, 1.04859471e-02f, 1.24512231e-02f,
  -3.57827805e-02f, -3.58095430e-02f, -5.15203178e-02f, 1.43120103e-02f, 5.05014323e-02f, 7.77390748e-02f, -6.86737746e-02f, -2.24232376e-02f, -1.61696970e-02f, -2.12458186e-02f,
  1.11466199e-01f, -9.72019881e-02f, -2.20198464e-02f, -6.06573559e-02f, 1.88176949e-02f, -4.84800860e-02f, 1.81667581e-02f, -6.39247447e-02f, -7.72146657e-02f, 4.85857613e-02f,
  -3.10612582e-02f, -5.85310832e-02f, 4.44674455e-02f, -1.32020591e-02f, 7.34461397e-02f, 5.42824119e-02f, -3.35358456e-02f, 7.02755153e-02f, 4.75202873e-02f, -3.64259370e-02f,
  3.37609649e-02f, 1.76523272e-02f, 7.08812848e-02f, 5.15544973e-03f, -6.66755112e-03f, 5.08313440e-03f, -7.99733028e-03f, -2.52838414e-02f, -2.45373435e-02f, 4.97370996e-02f,
  6.09037057e-02f, 6.40643388e-02f, 3.86780277e-02f, -5.85343838e-02f, 2.17018481e-02f, -1.25003438e-02f, -1.41560510e-02f, -3.43642309e-02f, 1.07495129e-01f, -3.10403630e-02f,
  -9.16856453e-02f, 5.74515909e-02f, -3.67436111e-02f, -1.12607732e-01f, -3.91835123e-02f, -7.52073452e-02f, 2.93511413e-02f, -5.96719533e-02f, 1.08242892e-01f, 7.04678297e-02f,
  5.49725816e-02f, 7.93965012e-02f, -1.22287299e-03f, 2.36836486e-02f, -4.94331568e-02f, 4.37811725e-02f, 1.93878487e-02f, -3.14053148e-02f, 4.77541378e-03f, -7.95016438e-02f,
  2.15097982e-02f, -5.07993344e-03f, -1.91884153e-02f, -2.24183667e-02f, -7.90984556e-02f, -1.22220535e-02f, 8.02868903e-02f, 8.86329636e-03f, -1.93152414e-03f, -1.92536376e-02f,
  -2.31852368e-01f, 3.43106627e-01f, 9.18577313e-02f, 3.42348129e-01f, -1.07631095e-01f, -3.29178780e-01f, -1.57102197e-01f, 1.21703245e-01f, 1.03072591e-01f, 4.67436612e-02f,
  1.01163745e-01f, -2.42383424e-02f, 9.05929282e-02f, 2.11573556e-01f, 1.09501153e-01f, 1.94557428e-01f, 8.73028412e-02f, -6.51593283e-02f, 8.09824318e-02f, 9.73693058e-02f,
  1.63445041e-01f, 2.29900613e-01f, 1.72680840e-01f, -1.23730469e-02f, 6.63270205e-02f, 8.69413167e-02f, 2.09279805e-01f, 8.99080113e-02f, 7.22240135e-02f, -5.00080474e-02f,
  -1.27678052e-01f, 1.53550729e-01f, -6.50348887e-03f, -5.65337911e-02f, -4.12138402e-02f, -4.85934652e-02f, -4.46043722e-03f, -5.24288602e-02f, -6.83656782e-02f, 1.14787556e-01f,
  -2.11554002e-02f, -6.97204396e-02f, 3.09814438e-02f, 8.40718970e-02f, -4.86204363e-02f, 2.93778926e-02f, -8.48194584e-02f, -7.04214945e-02f, -3.72455362e-03f, 6.92541245e-03f,
  1.68742500e-02f, 2.79032183e-03f, -4.34596427e-02f, -1.24989888e-02f, -1.50435455e-02f, 5.72649157e-03f, 2.34435629e-02f, 3.98096658e-04f, 1.86704413e-03f, 4.21582721e-02f,
  -1.16580322e-01f, 6.26829043e-02f, -2.88214311e-02f, -2.68993583e-02f, 8.06557313e-02f, -3.36359367e-02f, 1.96465440e-02f, -2.78457981e-02f, -2.41021011e-02f, 1.12116694e-01f,
  1.53014772e-02f, 5.84657416e-02f, -1.43064484e-02f, -3.00036222e-02f, 3.72595228e-02f, 4.30116542e-02f, -1.28975678e-02f, -2.92342603e-02f, 3.36882994e-02f, 4.20981534e-02f,
  3.41184884e-02f, -3.18871476e-02f, 5.68134189e-02f, -4.96030562e-02f, -1.83206238e-03f, -1.72062106e-02f, 1.12846643e-01f, 3.12716775e-02f, -4.04526815e-02f, -5.82319824e-03f,
  7.38340020e-02f, 4.95619833e-01f, 1.88105204e-03f, -1.01010188e-01f, 1.00340083e-01f, -1.21332318e-01f, -3.34153287e-02f, -6.41523823e-02f, 1.13585830e-01f, 1.63671095e-02f,
  -5.47395200e-02f, 3.79818194e-02f, -1.06695518e-02f, 1.26257492e-03f, -3.21702212e-02f, 1.87211353e-02f, 6.29044995e-02f, 5.90062067e-02f, 8.64972398e-02f, -7.55182374e-03f,
  -4.39928211e-02f, -6.54677227e-02f, 8.40785724e-05f, -2.63446718e-02f, 7.02445358e-02f, -4.50564995e-02f, -8.38777944e-02f, -1.01417685e-02f, 7.74035901e-02f, 7.17273280e-02f,
  -3.10831040e-01f, 6.97648376e-02f, -2.11763188e-01f, -1.60928696e-01f, -2.68013123e-02f, -1.79135054e-01f, -5.81031069e-02f, -4.84052263e-02f, -4.24591079e-02f, 3.12991530e-01f,
  2.34991565e-01f, -1.76657125e-01f, 2.05377698e-01f, 3.66454385e-02f, -4.38819647e-01f, -2.26389375e-02f, -1.65078074e-01f, -7.15580285e-02f, -4.17067073e-02f, -1.24929547e-01f,
  -1.24480739e-01f, 1.43166006e-01f, -2.01918796e-01f, 1.09824799e-01f, -6.70205280e-02f, 4.50375602e-02f, 1.18809208e-01f, 6.19409904e-02f, 6.76932558e-03f, -1.03342392e-01f,
  -1.77926160e-02f, 2.54577249e-01f, 4.29843217e-02f, -4.69960161e-02f, -1.02723025e-01f, -6.09053634e-02f, -8.15628935e-03f, -5.90973608e-02f, -4.50706035e-02f, -5.22993393e-02f,
  2.21775379e-02f, 6.32751212e-02f, 1.60060022e-02f, -5.58373220e-02f, 8.16696957e-02f, -4.94393334e-02f, 4.79784189e-03f, -1.90235991e-02f, -1.73210315e-02f, -1.28258672e-02f,
  -8.37428868e-02f, -1.00750662e-03f, -4.60486524e-02f, 2.27870159e-02f, -9.87637639e-02f, 8.38921443e-02f, -3.16545479e-02f, -1.95416957e-02f, -4.02806513e-02f, -5.93708754e-02f,
  -5.18837292e-03f, 3.51901874e-02f, 2.60309409e-02f, 1.15477458e-01f, -8.74103308e-02f, 1.08444449e-02f, 1.57492086e-02f, 5.46310395e-02f, 4.39133756e-02f, 2.66003772e-03f,
  -4.00835974e-03f, -5.63334338e-02f, 4.35894020e-02f, 3.13152447e-02f, -4.20991182e-02f, -1.97061710e-03f, 1.81547664e-02f, 1.47547610e-02f, -7.89120346e-02f, 1.45684555e-03f,
  1.50061011e-01f, -9.36229806e-03f, -1.82223134e-02f, 7.57707879e-02f, 2.21140706e-03f, -1.81668326e-02f, 3.70282270e-02f, 7.43084177e-02f, -1.20524541e-02f, -1.19588962e-02f,
  7.01309927e-03f, 8.07266757e-02f, 7.16726929e-02f, 3.15405913e-02f, -3.04242596e-02f, -6.82408735e-02f, -5.97900487e-02f, -3.42692845e-02f, -3.49992849e-02f, 5.43822870e-02f,
  -8.82771537e-02f, 6.40941132e-03f, -9.67387334e-02f, 6.12506680e-02f, 4.54648165e-03f, -1.67728476e-02f, 8.84424970e-02f, 2.72757895e-02f, -4.55339514e-02f, -8.95219222e-02f,
  6.74693957e-02f, 2.96227783e-02f, 3.47159021e-02f, -3.92552689e-02f, 5.97987249e-02f, 1.73388626e-02f, -6.49259463e-02f, -6.20313063e-02f, 2.73915157e-02f, -2.29021385e-02f,
  -1.18369684e-01f, 4.67928261e-01f, 4.01712865e-01f, 2.82281339e-01f, -2.74631500e-01f, -3.38202178e-01f, -1.67239189e-01f, 9.08428356e-02f, 1.55663686e-02f, 1.90987512e-01f,
  -2.00845867e-01f, 4.37057406e-01f, -3.62334773e-02f, 1.99769169e-01f, -3.12318832e-01f, -1.01925924e-01f, -5.95940426e-02f, 1.18177988e-01f, 5.68736643e-02f, -2.12716348e-02f,
  4.13179472e-02f, -1.75753474e-01f, 1.11996703e-01f, -1.34627819e-01f, 6.16416000e-02f, 2.60726690e-01f, -1.19150922e-01f, 2.94082258e-02f, 5.19000106e-02f, -6.28381968e-02f,
  -5.53563312e-02f, 1.90006539e-01f, 8.05586874e-02f, -1.01902317e-02f, -1.08741112e-01f, -5.47757782e-02f, -6.50131050e-03f, -3.94479185e-02f, 2.70741209e-02f, 3.19932438e-02f,
  -4.47828807e-02f, 3.16787884e-02f, 6.35267049e-02f, 1.02262106e-02f, 5.98173728e-03f, 9.46383476e-02f, 8.86489451e-02f, 4.30536866e-02f, 1.21836014e-01f, 3.09478994e-02f,
  1.30191324e-02f, 8.51001814e-02f, 8.33839253e-02f, 1.36901140e-02f, 5.04862852e-02f, -3.96898501e-02f, 3.79992872e-02f, 8.53770748e-02f, 8.77634138e-02f, 2.07966473e-03f,
  2.93335970e-02f, -6.88637570e-02f, -2.67540514e-02f, -7.37439189e-03f, -2.23542061e-02f, 1.49293719e-02f, 9.69710201e-03f, -9.07905959e-03f, 3.89862917e-02f, -5.54553866e-02f,
  -3.64430100e-02f, 8.67459252e-02f, 4.31350730e-02f, -7.82244932e-03f, 1.28277838e-02f, -4.24897531e-03f, -4.88651805e-02f, -1.07999835e-02f, 1.21458182e-02f, 2.41469825e-03f,
  4.45205644e-02f, 6.06730068e-03f, -2.61953883e-02f, -3.67732644e-02f, -7.76929185e-02f, -1.12384930e-02f, 5.73562756e-02f, 3.07322703e-02f, 2.11753007e-02f, 2.15958264e-02f,
  -1.45492241e-01f, 7.78256804e-02f, 4.58864309e-03f, -1.20466864e-02f, -9.98812541e-03f, 9.23193712e-03f, -9.27161425e-03f, 4.52593453e-02f, 4.65862639e-03f, -9.05441418e-02f,
  -7.17036352e-02f, -4.56493273e-02f, -1.21715302e-02f, -7.54827857e-02f, -3.80655788e-02f, -1.27611812e-02f, 3.25957127e-02f, 8.72244909e-02f, 1.26274647e-02f, 4.65422720e-02f,
  8.46219882e-02f, -8.65857080e-02f, -4.75539118e-02f, 2.32123528e-02f, 8.20752291e-04f, 2.97675580e-02f, 2.53386311e-02f, 6.23354921e-03f, -5.72310239e-02f, 1.21737262e-02f,
  2.45835066e-01f, -2.72082984e-01f, -2.56597042e-01f, 1.13313131e-01f, 7.07746893e-02f, -7.81860109e-03f, -1.95307404e-01f, 5.78304045e-02f, -1.31736964e-01f, -8.62722844e-02f,
  3.29261497e-02f, 2.06049178e-02f, -3.07783514e-01f, 3.35760832e-01f, 3.27241302e-01f, -1.02405593e-01f, 1.76610708e-01f, 1.75463911e-02f, -1.06994146e-02f, 1.32886872e-01f,
  2.01307684e-01f, 3.43629807e-01f, 9.48378220e-02f, 2.64854968e-01f, 1.97867274e-01f, 1.60150394e-01f, 3.51908207e-01f, 7.12228054e-03f, 4.03377295e-01f, 2.44329363e-01f,
  -2.58538574e-02f, 2.12239902e-02f, -8.93741325e-02f, -3.05629577e-02f, -1.22861750e-03f, -1.04677215e-01f, -5.59295528e-02f, 3.83754298e-02f, 3.77575569e-02f, 2.58050277e-03f,
  -2.19179597e-02f, 2.85126567e-02f, 8.82082134e-02f, -1.49408486e-02f, 4.62378040e-02f, 4.00982499e-02f, -2.09510922e-02f, -3.57216150e-02f, 1.91893931e-02f, -6.92776311e-03f,
  -1.20077819e-01f, -5.61601855e-02f, 4.10922075e-04f, -5.17219938e-02f, 5.50296865e-02f, 6.74168319e-02f, 2.17260607e-02f, -7.42375012e-03f, -2.30228975e-02f, 8.23134258e-02f,
  2.95346621e-02f, -9.63378325e-03f, -1.25573706e-02f, 1.86837290e-03f, -4.37186472e-02f, -9.86561086e-03f, -3.02611049e-02f, 7.52437636e-02f, -1.71231274e-02f, 1.13832457e-02f,
  5.71228517e-03f, -3.72559279e-02f, 1.64477173e-02f, -4.82069328e-02f, 1.10341208e-02f, 1.70566735e-03f, 7.12995678e-02f, 1.56682823e-02f, -2.96719056e-02f, -2.02727458e-03f,
  6.73506632e-02f, -7.99979956e-04f, 2.58630817e-03f, -7.54527841e-03f, 5.44305332e-02f, -2.37783063e-02f, 5.19521162e-02f, 1.58749465e-02f, -2.59403549e-02f, -3.88792530e-02f,
  3.88471223e-02f, 1.38145715e-01f, -2.75691822e-02f, 5.84145673e-02f, -9.96625647e-02f, 5.08089438e-02f, -2.63354518e-02f, 1.17211945e-01f, 1.64670162e-02f, 1.07931597e-02f,
  2.25636065e-02f, -5.77071263e-03f, -1.00467086e-01f, 6.22616932e-02f, 7.24482015e-02f, -2.79605910e-02f, -2.06263047e-02f, -2.78946124e-02f, 1.95848383e-02f, -3.12923901e-02f,
  2.43883729e-02f, -4.64195721e-02f, 8.81192759e-02f, -9.77088660e-02f, -4.48907586e-03f, 2.79863481e-03f, -8.66961759e-03f, 3.67559902e-02f, -1.48169314e-02f, 3.36017758e-02f,
  -2.46876589e-04f, 1.03953473e-01f, -9.06117037e-02f, -2.64934152e-02f, -1.75418302e-01f, 3.35083157e-01f, 3.12105924e-01f, -6.72586560e-02f, -3.40688452e-02f, 2.78353214e-01f,
  1.15230195e-01f, 1.79458410e-02f, 1.36203527e-01f, 3.00738335e-01f, 2.42280990e-01f, 2.44347692e-01f, 3.05005848e-01f, 1.72099724e-01f, -3.45365666e-02f, 3.29702348e-02f,
  -5.34913167e-02f, 2.21746281e-01f, -4.51113768e-02f, -1.42518833e-01f, 5.72018791e-03f, -1.66247532e-01f, -3.45857218e-02f, -1.60255507e-01f, -9.14556459e-02f, -7.40480572e-02f,
  8.69598314e-02f, -3.68116051e-02f, 2.31894739e-02f, -6.12571388e-02f, 3.56054343e-02f, -7.93791376e-03f, -9.59444791e-02f, 8.33758563e-02f, -4.09697108e-02f, 1.64605044e-02f,
  7.31901601e-02f, -4.10771221e-02f, 4.95495368e-03f, 3.22078988e-02f, -8.35569501e-02f, -7.01445937e-02f, -6.43107295e-02f, -5.54047450e-02f, 4.55377959e-02f, -6.32202253e-03f,
  -3.21277976e-02f, 1.60884038e-02f, 2.04494372e-02f, -2.51910500e-02f, 1.43018281e-02f, 4.35601212e-02f, 7.94963762e-02f, 1.17990291e-02f, -3.63190286e-02f, 1.71034876e-02f,
  -4.12433930e-02f, -9.24352091e-03f, 7.26566911e-02f, -6.24657720e-02f, 5.10616824e-02f, -4.93790694e-02f, -2.82248650e-02f, -6.59438148e-02f, -7.45638013e-02f, -4.52602096e-03f,
  -9.01069865e-02f, -1.16336802e-02f, 5.04960567e-02f, 1.94254294e-02f, -3.01041324e-02f, 5.43145537e-02f, 3.98190469e-02f, -6.54231682e-02f, -5.54046780e-03f, -1.37129873e-01f,
  5.81841618e-02f, 6.00377209e-02f, 5.33908000e-03f, -6.22924976e-02f, 2.49402858e-02f, -7.90964812e-02f, 2.82719713e-02f, -9.06844914e-04f, -5.35080433e-02f, 5.83671033e-02f,
  1.36694431e-01f, 1.93799343e-02f, -5.92403337e-02f, 7.48155564e-02f, 1.06446994e-02f, 6.25160336e-02f, 8.22712556e-02f, -7.81294182e-02f, 4.42743562e-02f, 5.22643467e-03f,
  2.18343381e-02f, -9.42909624e-03f, 3.54352705e-02f, -7.64709413e-02f, 3.52079645e-02f, 5.94494753e-02f, -4.58551571e-03f, -5.11025190e-02f, -1.15267344e-01f, -4.28153649e-02f,
  -1.08108064e-02f, -1.40508208e-02f, 5.14695346e-02f, -2.99412627e-02f, -3.57350633e-02f, 3.29201035e-02f, 5.58255464e-02f, -6.19441345e-02f, -3.69935483e-02f, 5.49716502e-02f,
  -1.72307894e-01f, 5.23440838e-01f, 1.35854870e-01f, 3.19998771e-01f, -1.02614194e-01f, 3.33176106e-02f, 1.13456540e-01f, 1.14940330e-01f, -3.69962715e-02f, 1.55935913e-01f,
  -1.03128716e-01f, 1.79866120e-01f, 3.69402468e-02f, 2.56935090e-01f, 4.70616519e-02f, 7.00131506e-02f, 3.10549468e-01f, 1.20547980e-01f, 5.00465892e-02f, 1.28026441e-01f,
  -1.65358428e-02f, 1.50481284e-01f, 1.22840650e-01f, 6.66487664e-02f, 5.10702766e-02f, -4.76827547e-02f, -1.22935914e-01f, -1.45120874e-01f, 1.45023867e-01f, -4.36484367e-02f,
  -9.92288962e-02f, -3.11687030e-02f, -2.46886071e-02f, 4.28935848e-02f, -7.31493309e-02f, -3.94054577e-02f, 3.53082120e-02f, -7.37136006e-02f, -4.34132032e-02f, 1.40420469e-02f,
  -6.92949295e-02f, -2.26360392e-02f, 2.16435618e-03f, -6.33889735e-02f, 5.83486073e-02f, 1.75922774e-02f, -4.47969958e-02f, -1.65865496e-02f, 5.73072918e-02f, -7.16967881e-02f,
  1.15387524e-02f, 1.06367245e-01f, 2.85039656e-02f, 8.10009241e-02f, -5.49506210e-02f, -1.77269448e-02f, 9.42693129e-02f, -5.67235500e-02f, 7.08920229e-03f, 5.51739074e-02f,
  1.35327615e-02f, -9.85674560e-04f, 2.19347570e-02f, -2.91669648e-03f, 5.74192917e-03f, 4.93478328e-02f, 5.52271232e-02f, -5.56730963e-02f, 3.32379639e-02f, -9.14360061e-02f,
  -8.59093741e-02f, -6.48112893e-02f, -5.54359853e-02f, 7.38308728e-02f, -3.81328166e-02f, 2.19214335e-02f, -3.57141602e-03f, -2.34120600e-02f, 4.63206843e-02f, 1.47387581e-02f,
  -1.76644884e-02f, -4.51232046e-02f, 1.72156207e-02f, 3.18945497e-02f, 9.11094472e-02f, -6.05188310e-02f, 1.26084704e-02f, -1.85314063e-02f, 4.29056548e-02f, -8.00645724e-02f,
  1.15882076e-01f, 1.77519381e-01f, 1.46321505e-02f, -9.72817168e-02f, 2.45176684e-02f, -3.36455442e-02f, 8.62020776e-02f, -1.13270583e-03f, 1.01901844e-01f, -5.10962792e-02f,
  2.98809279e-02f, -3.24877687e-02f, -8.38230252e-02f, 4.26019393e-02f, 2.50069350e-02f, -4.87819053e-02f, 7.58497119e-02f, -4.61439118e-02f, 5.21545298e-02f, 9.67241451e-03f,
  8.59026518e-03f, -6.84682503e-02f, -8.27490818e-03f, -3.50645557e-02f, -5.25419787e-03f, -2.47474574e-02f, -9.56807751e-03f, 1.84060298e-02f, 2.32449025e-02f, 1.64112598e-02f,
  5.98520301e-02f, -3.32986526e-02f, 1.83186039e-01f, 1.38911039e-01f, 1.72091931e-01f, 6.66430891e-02f, 2.02330589e-01f, -6.73306547e-03f, 2.26432383e-01f, -1.35294199e-01f,
  -6.61254674e-02f, -1.08980440e-01f, 2.51860879e-02f, -2.11322792e-02f, 1.23732060e-01f, 1.13344759e-01f, 1.65296987e-01f, 1.07301429e-01f, 8.47054273e-02f, -8.89213085e-02f,
  8.52742493e-02f, -3.90212703e-03f, -7.11680502e-02f, -5.37687168e-02f, -8.97363722e-02f, -5.73695311e-03f, -1.27345756e-01f, 6.57689478e-03f, -1.02530941e-01f, -2.02899277e-02f,
  5.67741832e-03f, 4.29798216e-02f, -8.57263654e-02f, -5.06581143e-02f, 4.61695418e-02f, -8.01356975e-03f, 6.73857182e-02f, 4.14037853e-02f, 4.98510972e-02f, 4.35516201e-02f,
  -8.13300014e-02f, -3.74214873e-02f, -5.25825471e-03f, -1.23607758e-02f, 1.01263866e-01f, -5.52998623e-03f, 2.21104058e-03f, 7.87611865e-03f, -6.50516227e-02f, 1.46789178e-02f,
  -9.79074910e-02f, -4.25961800e-02f, -3.65302004e-02f, 5.28199784e-02f, 4.83213365e-02f, 4.48219385e-03f, 2.60664392e-02f, 3.86316180e-02f, -2.03482658e-02f, 5.49706034e-02f,
  8.39148238e-02f, 1.05841599e-01f, -3.07620857e-02f, -4.61502895e-02f, -4.60059494e-02f, -2.20296159e-02f, 6.20592199e-02f, -3.35639976e-02f, 8.46825391e-02f, -1.02976054e-01f,
  -2.63526943e-02f, -5.03235264e-03f, 1.03466459e-01f, 4.33975607e-02f, 4.39598523e-02f, 3.15379426e-02f, -1.09341964e-01f, -4.89793606e-02f, 1.05554666e-02f, 1.25473691e-02f,
  8.51019695e-02f, -2.37367433e-02f, -3.96597758e-02f, -5.09441867e-02f, 5.21645248e-02f, -6.85784742e-02f, -9.91944149e-02f, 1.03003820e-02f, -2.51387842e-02f, -7.43620172e-02f,
  2.31359545e-02f, 1.25679761e-01f, 7.23338599e-05f, -5.93094528e-02f, 5.14187478e-02f, -5.70530966e-02f, 9.53817964e-02f, 3.69041637e-02f, -2.76171584e-02f, -1.60185471e-02f,
  -6.02028035e-02f, -2.53397338e-02f, 2.60812230e-02f, 6.26964420e-02f, 7.46847242e-02f, -1.09623410e-01f, -1.71637107e-02f, 1.56886708e-02f, 9.80838239e-02f, 5.72089991e-03f,
  -6.74247742e-02f, 1.29499724e-02f, 1.04802586e-02f, -5.64666726e-02f, -3.29134054e-02f, -4.65612020e-03f, 5.53274974e-02f, -7.42521435e-02f, 1.22798085e-02f, -2.83322576e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  3.52770537e-01f, 2.92438269e-01f, 1.94744214e-01f, 1.95257157e-01f, 3.46464068e-02f, 1.15354620e-01f, 3.45321447e-02f, 2.72804946e-01f, 2.03778058e-01f, 2.37768725e-01f,
  1.56084105e-01f, 1.55397028e-01f, 3.04429650e-01f, 2.24097937e-01f, 2.34116256e-01f, 3.85567635e-01f, 9.29549932e-02f, 3.13478619e-01f, 4.56726700e-01f, 7.57352486e-02f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  6.28628358e-02f, 4.58113611e-01f, 2.20630821e-02f, 3.81337285e-01f, -4.16946858e-02f, 3.43105346e-02f, -2.35586613e-01f, 2.94650674e-01f, -3.36930424e-01f, -8.33117589e-02f,
  2.95283616e-01f, -1.18632920e-01f, 3.58926833e-01f, -3.00790695e-03f, 1.00923441e-01f, -2.86076851e-02f, -1.83270443e-02f, -1.94983765e-01f, -1.09703779e-01f, 1.68454722e-02f,
  1.86428294e-01f, -5.86613603e-02f, -2.10234709e-02f, 1.25652269e-01f, 2.07341671e-01f, -2.13550806e-01f, -2.79690117e-01f, -3.11705768e-01f, -1.19321056e-01f, 9.89331864e-03f,
  -3.74730021e-01f, 2.71761447e-01f, -2.92105856e-03f, 2.58284807e-01f, 1.34435982e-01f, 2.10082904e-01f, 3.41991097e-01f, 2.91988760e-01f, -4.30000901e-01f, 3.71985972e-01f,
  -4.04350549e-01f, -1.45125061e-01f, 7.99073279e-02f, -2.71583855e-01f, 8.47120807e-02f, 1.56093806e-01f, 5.58108762e-02f, 3.20234716e-01f, 4.00622375e-03f, -1.26000270e-01f,
  -2.57435590e-01f, -2.34453037e-01f, 2.69808978e-01f, 8.85780603e-02f, 9.37957093e-02f, 6.93020374e-02f, -5.54595999e-02f, -2.98733115e-01f, -6.74041286e-02f, 2.06332337e-02f,
  -1.93386540e-01f, -4.24296856e-02f, -1.32871330e-01f, 8.76919031e-02f, 1.47631332e-01f, 8.47309753e-02f, -5.45382174e-03f, -6.75358176e-02f, -1.50316149e-01f, -1.10080086e-01f,
  -1.33590922e-01f, -8.80699605e-03f, -2.55203038e-01f, -2.63719082e-01f, 4.93079536e-02f, 2.38468811e-01f, 3.79963964e-01f, -5.39447367e-02f, 5.45582250e-02f, 1.00217156e-01f,
  4.60209362e-02f, -2.47663587e-01f, 4.73260134e-01f, -3.35179359e-01f, 1.47128209e-01f, -4.85899262e-02f, 1.59052927e-02f, -4.26765680e-02f, 4.33086939e-02f, -1.19493000e-01f,
  -1.63665295e-01f, -9.43992939e-03f, 2.73293316e-01f, -3.16720337e-01f, -2.06194356e-01f, -9.46285482e-03f, -2.51363337e-01f, 5.60050011e-02f, -4.06400524e-02f, -1.58528358e-01f,
  1.88385814e-01f, 9.91498306e-03f, -1.60797164e-01f, -2.65281219e-02f, -3.90408635e-01f, -1.33514866e-01f, -2.35945448e-01f, -1.47836298e-01f, -6.56319633e-02f, 3.70714106e-02f,
  -3.08061302e-01f, 8.83767977e-02f, 1.43208429e-01f, -1.15262130e-02f, 2.98773736e-01f, 2.80588925e-01f, 2.71618932e-01f, -1.87498942e-01f, 5.33045717e-02f, -1.79545820e-01f,
  1.13318294e-01f, -1.49285989e-02f, -3.07085067e-01f, -4.70758900e-02f, -8.74919444e-02f, 1.96756735e-01f, 5.31957448e-02f, -6.60435632e-02f, -1.70946404e-01f, -3.47541988e-01f,
  9.31780711e-02f, -1.27096251e-01f, 4.21426296e-02f, 1.59990221e-01f, 3.20010111e-02f, 3.48276123e-02f, 4.12199169e-01f, 2.75226891e-01f, -9.58564430e-02f, -2.72883594e-01f,
  -3.13536763e-01f, 6.83695972e-02f, 6.55646920e-02f, 1.07300803e-01f, -1.70700416e-01f, 1.91606417e-01f, -2.36103371e-01f, 2.98462242e-01f, -1.05874643e-01f, 2.23109454e-01f,
  4.39289436e-02f, 8.00388381e-02f, -1.49419099e-01f, -1.61919564e-01f, 3.64621133e-01f, 6.79789782e-02f, 3.69569212e-02f, 1.18671153e-02f, 1.53166533e-01f, -1.57064885e-01f,
  -4.88296300e-02f, -8.50313902e-02f, -2.59751558e-01f, 1.21221401e-01f, 2.43572351e-02f, 3.23379934e-01f, -2.26963544e-03f, 4.77286637e-01f, 1.38535053e-01f, -9.93995741e-03f,
  3.41019481e-01f, -3.17342758e-01f, 5.07719368e-02f, -2.48264577e-02f, -5.37364483e-02f, 6.43580779e-02f, 1.94734354e-02f, -6.93714619e-02f, 1.19306736e-01f, -5.83578199e-02f,
  -6.72491491e-02f, 1.28450468e-01f, 3.11767459e-02f, 6.77901506e-02f, 2.47328624e-01f, -1.91630393e-01f, 6.43101484e-02f, -3.01102027e-02f, -3.96413565e-01f, -1.28163740e-01f,
  -2.63395160e-01f, -3.16796005e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.61038899e-01f, -2.61161439e-02f, -8.12318362e-03f, 4.01740596e-02f, 1.56064928e-01f, 3.91318291e-01f, 2.50277698e-01f, 5.35790622e-01f, -2.38424595e-02f, 6.20932644e-03f,
  3.20321590e-01f, 5.19958250e-02f, 1.77377909e-01f, 2.28903458e-01f, 1.53590396e-01f, 5.27634382e-01f, 1.02436513e-01f, 4.11273018e-02f, 6.88097239e-01f, -2.74374336e-01f,
  -1.82890862e-01f, 1.23527527e-01f, 6.00466132e-02f, 2.11194251e-02f, 3.03655136e-02f, -1.86223462e-01f, 1.66601181e-01f, 2.40396991e-01f, 3.66221108e-02f, -3.09001774e-01f,
  -7.24191666e-02f, -1.13871306e-01f, 5.32416925e-02f, 1.94693152e-02f, 1.79621831e-01f, 1.07766844e-01f, 1.71037734e-01f, 2.18529552e-02f, 1.31784990e-01f, -2.90186435e-01f,
  8.59508067e-02f, -8.49214196e-02f, -1.51152119e-01f, -1.74644217e-01f, -6.80270940e-02f, 2.13449658e-03f, 2.22356305e-01f, -1.50559232e-01f, -1.92738190e-01f, 1.95716262e-01f,
  -2.60054227e-02f, -3.35068218e-02f, -2.36228630e-01f, -2.97805499e-02f, -2.89456453e-02f, 1.52254507e-01f, -7.84644186e-02f, 2.62285918e-01f, -9.26104113e-02f, 1.99916437e-01f,
  2.81308591e-01f, 3.69173437e-01f, 4.65089440e-01f, 1.53107971e-01f, 1.74357355e-01f, 2.82241553e-01f, -1.50438294e-01f, 5.24935246e-01f, 2.63922244e-01f, 3.14186126e-01f,
  -2.91867584e-01f, -3.33359614e-02f, -5.37838697e-01f, -3.52799833e-01f, 1.99536860e-01f, 1.18939653e-02f, 5.83001494e-01f, 1.83587030e-01f, 2.74222642e-01f, -3.51188667e-02f,
  -7.20424950e-02f, -6.66782930e-02f, -1.54582739e-01f, -2.04741761e-01f, 4.53113675e-01f, -1.69225618e-01f, 2.20195562e-01f, -4.42174412e-02f, 6.43320978e-02f, -2.93242216e-01f,
  -7.34628737e-02f, 3.63040805e-01f, 1.94421075e-02f, -1.22599244e-01f, 1.24662392e-01f, 7.52013475e-02f, -8.69468749e-02f, 2.55020022e-01f, 1.30350024e-01f, 2.04520747e-01f,
  7.44306147e-02f, 2.89875101e-02f, -9.89563912e-02f, -5.75532839e-02f, -2.20595285e-01f, 1.03295356e-01f, -2.30084166e-01f, 1.42765760e-01f, -2.64745951e-01f, -1.81875199e-01f,
  5.97165711e-03f, -1.84777483e-01f, 5.57537489e-02f, -8.20706971e-03f, -8.79623517e-02f, 1.62196502e-01f, -6.03337912e-03f, -2.93123096e-01f, 3.86346668e-01f, 1.20830022e-01f,
  -5.93504868e-02f, 3.16777110e-01f, -5.43500036e-02f, 4.43433046e-01f, 2.12641865e-01f, -2.13987418e-02f, 2.40231127e-01f, 3.73273715e-02f, -5.31541631e-02f, -1.25847548e-01f,
  -1.22310974e-01f, -3.64125744e-02f, -3.27832736e-02f, 6.21970817e-02f, 3.94128449e-02f, 5.56316040e-02f, -1.46883547e-01f, -7.71989375e-02f, 1.67708029e-03f, -6.34703040e-02f,
  -3.70964669e-02f, 5.35729602e-02f, 1.00283332e-01f, -1.39403954e-01f, 1.28707998e-02f, 1.44207492e-01f, -1.53495282e-01f, -6.99057728e-02f, -1.33673817e-01f, -4.13174033e-02f,
  -1.23196080e-01f, -5.52951247e-02f, -9.94262099e-02f, -1.55669361e-01f, -1.16641365e-01f, -3.98158282e-02f, -1.28452003e-01f, 8.00553933e-02f, -3.70462909e-02f, 1.64235786e-01f,
  2.08126783e-01f, -2.22889632e-01f, -9.71343368e-02f, 7.46389851e-02f, -1.92483701e-02f, 1.43172890e-01f, -3.15707996e-02f, -4.95651990e-01f, 4.31970567e-01f, 9.01481137e-02f,
  -4.18752879e-01f, 5.57265319e-02f, 1.43312618e-01f, 1.73626915e-01f, 3.62127125e-01f, -1.98299319e-01f, 1.52719200e-01f, 1.75487369e-01f, 1.79530039e-01f, 3.00082237e-01f,
  2.95429498e-01f, -1.93994716e-01f, -8.16743299e-02f, 2.80472547e-01f, -5.56715764e-02f, -2.08010092e-01f, 2.68389016e-01f, -3.30153495e-01f, 1.47206783e-01f, 3.22764546e-01f,
  1.80294961e-01f, 1.94310457e-01f, -8.29194784e-02f, -9.94386598e-02f, 8.08703676e-02f, 1.29877433e-01f, 2.15365455e-01f, -5.38583659e-02f, 9.26124211e-03f, -7.49875978e-02f,
  -1.03447005e-01f, -5.36930300e-02f, 1.40609846e-01f, 2.34240871e-02f, 1.43414006e-01f, -8.42846707e-02f, 7.37281656e-03f, 7.39468336e-02f, -1.18855469e-01f, -7.70446733e-02f,
  -1.76149048e-02f, 1.30026797e-02f, -1.29592031e-01f, 6.42584190e-02f, 1.66787446e-01f, -6.07837513e-02f, 7.47992992e-02f, 1.02872327e-01f, 1.51477203e-01f, 1.35976225e-01f,
  -1.97605968e-01f, 2.64305532e-01f, -9.97464061e-02f, -1.65784489e-02f, -7.41307288e-02f, -2.29677185e-01f, 1.86616883e-01f, 9.34977606e-02f, -2.15583518e-02f, 2.25022867e-01f,
  5.65126017e-02f, -1.54934362e-01f, 4.65313643e-02f, 2.25838766e-01f, -1.32077605e-01f, -2.18328759e-02f, -1.07855387e-01f, -8.42453390e-02f, -1.20140381e-01f, 6.01066044e-03f,
  1.41639084e-01f, -2.00656001e-02f, 1.97457075e-02f, 8.55710655e-02f, 7.29417577e-02f, -1.32640556e-01f, -6.15550578e-02f, 2.06922740e-01f, -1.41106412e-01f, 1.70582980e-01f,
  -8.12383741e-02f, -1.93679124e-01f, -1.56065412e-02f, 2.65862435e-01f, -4.33606803e-02f, -7.15788007e-02f, 1.02316640e-01f, -1.35932028e-01f, 1.68025091e-01f, -7.18557090e-02f,
  -1.30388260e-01f, -6.39855266e-02f, -2.35897258e-01f, -1.37504816e-01f, -8.87195095e-02f, 6.29953369e-02f, -1.26381591e-01f, -4.94632944e-02f, 1.86100900e-01f, 1.57387003e-01f,
  1.48989007e-01f, 2.30140969e-01f, -5.85804367e-03f, -1.81826707e-02f, -1.38551980e-01f, -6.57828227e-02f, -1.61773060e-03f, 1.14601709e-01f, -6.69521168e-02f, 1.96863309e-01f,
  6.73934668e-02f, 1.12578392e-01f, 2.07652390e-01f, 1.04121409e-01f, 2.39140883e-01f, -2.29735464e-01f, -1.59348562e-01f, -5.64528331e-02f, 1.53403446e-01f, -9.31572691e-02f,
  -9.09705088e-02f, 1.59210607e-01f, -1.26472071e-01f, -1.82597503e-01f, 1.74196780e-01f, -2.13806387e-02f, 1.62186082e-02f, -1.09136604e-01f, 6.11139946e-02f, 8.26404095e-02f,
  1.83901221e-01f, -6.27507316e-03f, 1.99698061e-01f, -8.74456912e-02f, -7.14391991e-02f, -8.49800929e-02f, 3.50563735e-01f, -1.68923169e-01f, 4.83910777e-02f, 5.86782433e-02f,
  6.29198253e-02f, -1.77061543e-01f, -3.82833630e-02f, -9.08702984e-02f, 8.19052681e-02f, 1.88011318e-01f, -1.08429961e-01f, -6.63057715e-02f, 1.78141017e-02f, -1.18071251e-01f,
  2.30207726e-01f, 6.22658670e-01f, 4.61350441e-01f, 2.94887900e-01f, 3.90377343e-01f, -3.17462496e-02f, -3.27648669e-01f, 2.00868964e-01f, -5.83674014e-01f, 2.83718020e-01f,
  5.83414733e-01f, -7.87292242e-01f, 4.49574172e-01f, 3.03393662e-01f, -4.43561822e-01f, 2.26429641e-01f, 7.42948428e-03f, 1.06727004e-01f, -3.43862087e-01f, 4.40424204e-01f,
  -1.50630057e-01f, 5.77306628e-01f, -2.50733137e-01f, 7.79099986e-02f, 5.57489283e-02f, -4.26675659e-03f, 8.95308405e-02f, -2.00800791e-01f, -3.35451275e-01f, 2.03676566e-01f,
  1.17866427e-01f, 4.68174487e-01f, 1.67753533e-01f, 3.20087194e-01f, 2.10072994e-01f, 1.22752404e-02f, 1.57822102e-01f, -8.76735374e-02f, 4.63152453e-02f, 1.82849437e-01f,
  -2.86791176e-01f, 3.85321751e-02f, 1.55305669e-01f, 1.43143376e-02f, -3.72248024e-01f, -9.50621814e-02f, -2.66675115e-01f, -1.02817543e-01f, -8.06030259e-03f, 2.07693219e-01f,
  4.52054106e-02f, 2.46893361e-01f, 1.09555773e-01f, 2.04123080e-01f, 2.58343786e-01f, 2.20423695e-02f, 2.39231721e-01f, 5.11569977e-01f, 6.58138003e-03f, 6.16805077e-01f,
  4.48804237e-02f, 1.65871173e-01f, 5.39848745e-01f, -2.19223704e-02f, 1.46445617e-01f, 1.29729897e-01f, -2.48218238e-01f, 1.15014628e-01f, 2.47755155e-01f, -1.90252066e-02f,
  -6.26908243e-02f, -4.59418818e-02f, 9.07130018e-02f, -3.69700305e-02f, -1.16952956e-01f, 1.65884241e-01f, -5.42420782e-02f, 2.49004334e-01f, -1.25187859e-01f, 1.23823225e-01f,
  1.07501872e-01f, 5.58903739e-02f, -1.17266491e-01f, 8.09125900e-02f, 1.22847527e-01f, -4.75083850e-02f, 1.37159927e-02f, 4.41634692e-02f, 2.82039374e-01f, 2.37939820e-01f,
  8.37321058e-02f, -9.05133113e-02f, 1.09209813e-01f, -2.12776706e-01f, -1.71351656e-01f, -1.23868762e-02f, 3.36904764e-01f, 1.36925429e-01f, 2.99994200e-01f, 2.27769464e-01f,
  -1.38881328e-02f, 1.44465156e-02f, -4.05730680e-02f, -6.53248250e-01f, -4.03527409e-01f, -8.34888071e-02f, -3.96564126e-01f, 1.58896282e-01f, 7.20146477e-01f, -2.22970471e-01f,
  1.32429004e-01f, -3.74208540e-01f, 1.54676780e-01f, -2.53029823e-01f, 4.43407744e-01f, 4.37043309e-01f, 1.03748679e-01f, -2.58390933e-01f, -9.30486806e-03f, 9.59610045e-02f,
  3.27146232e-01f, -2.04618182e-02f, -2.61461049e-01f, -2.51871407e-01f, 6.71506286e-01f, 3.46011460e-01f, 8.72595385e-02f, 2.98223998e-02f, 1.92479759e-01f, -3.76014560e-01f,
  1.37863740e-01f, 2.11297020e-01f, -2.19628587e-01f, -2.80163623e-03f, 6.28974557e-01f, -3.55945706e-01f, 2.01442942e-01f, -3.69677454e-01f, 4.15829003e-01f, -4.66227591e-01f,
  5.31925410e-02f, -3.97762619e-02f, 8.33896548e-02f, 1.37736261e-01f, 1.44758821e-01f, 8.49033054e-03f, 6.40517116e-01f, 1.78299509e-02f, -2.83144236e-01f, 6.35714293e-01f,
  -1.42280832e-01f, -1.97574832e-02f, 7.16012418e-02f, 3.54246348e-01f, 3.22291106e-01f, 2.73247898e-01f, -4.88833059e-03f, 2.66204804e-01f, 1.13920830e-01f, -3.11333314e-02f,
  1.93970516e-01f, -2.95097500e-01f, 1.99468397e-02f, 1.65665686e-01f, 1.87733889e-01f, 3.50411475e-01f, 3.11485585e-02f, 1.21524602e-01f, 4.85382140e-01f, 2.43273139e-01f,
  -1.08568460e-01f, -1.68053228e-02f, -3.62084031e-01f, 3.24066877e-01f, 1.89528435e-01f, 5.59374020e-02f, 6.75423965e-02f, -1.36760563e-01f, 2.26883575e-01f, 7.90850669e-02f,
  2.11027309e-01f, 3.24669480e-02f, 1.52468070e-01f, 2.55407423e-01f, -1.56095907e-01f, -3.11759654e-02f, 2.52656847e-01f, -1.03511386e-01f, 1.90171942e-01f, -6.39138743e-03f,
  4.01957817e-02f, 5.16587086e-02f, 1.09975658e-01f, -2.32753620e-01f, 2.45067090e-01f, 2.29800060e-01f, 1.49224564e-01f, -5.55799678e-02f, 9.98281166e-02f, 2.62674302e-01f,
  -9.34015810e-02f, -1.49213359e-01f, 2.40188152e-01f, -1.86662767e-02f, 2.60137208e-02f, -7.64967576e-02f, -5.64789586e-02f, 2.60199100e-01f, 9.35962051e-02f, 2.96572924e-01f,
  -1.06046252e-01f, -3.29318076e-01f, -1.28345504e-01f, 4.46882635e-01f, 2.17806384e-01f, 1.30055919e-01f, 1.73400193e-01f, 4.01552826e-01f, 2.94759214e-01f, 5.26587427e-01f,
  9.61422622e-02f, -3.38624090e-01f, 2.98516899e-01f, -1.94806010e-01f, -3.81954089e-02f, 3.26368839e-01f, 6.15661554e-02f, 3.47614974e-01f, 6.79425597e-02f, 9.19272900e-02f,
  -5.59423625e-01f, 1.40329257e-01f, -2.81917274e-01f, 1.29102454e-01f, -4.10130858e-01f, 2.45471194e-01f, -1.86156735e-01f, 8.27497840e-02f, -1.15060369e-02f, -2.57648021e-01f,
  2.64104426e-01f, -1.50530308e-01f, -2.72164732e-01f, 6.12651587e-01f, 6.57420814e-01f, -3.50806892e-01f, 2.58970350e-01f, 9.12682638e-02f, 4.63570386e-01f, 1.82931498e-01f,
  -1.36407226e-01f, 1.96927711e-01f, 3.97366166e-01f, 4.40439442e-03f, 2.64097989e-01f, 1.82529017e-01f, 1.93318278e-01f, 2.56818026e-01f, 8.59036669e-02f, -1.03090018e-01f,
  1.85969379e-02f, 2.94399112e-02f, 1.42877147e-01f, -1.04354665e-01f, -2.01780513e-01f, 2.58849915e-02f, -1.18573569e-02f, -2.66777247e-01f, 1.82256997e-01f, 7.16875354e-03f,
  -4.88658436e-02f, 2.05065638e-01f, -1.11250624e-01f, 1.17874481e-01f, 2.94673830e-01f, -1.88897535e-01f, 6.49465844e-02f, 5.94680011e-02f, -5.03397398e-02f, -1.43726245e-01f,
  -2.39719108e-01f, -1.35683209e-01f, -5.34513220e-02f, -1.55203998e-01f, -9.04169604e-02f, 5.42591400e-02f, 2.21093267e-01f, -4.28027734e-02f, 2.92709649e-01f, 2.39292651e-01f,
  -1.03493519e-01f, 1.61936864e-01f, 8.08741227e-02f, 7.31705176e-03f, -2.05371305e-02f, 3.71819794e-01f, 5.43840766e-01f, 3.77673209e-01f, -2.56056339e-01f, 2.75070280e-01f,
  -1.16164722e-01f, 3.81740123e-01f, 1.17623411e-01f, 3.53716671e-01f, 1.91351995e-01f, -5.65549284e-02f, 1.60371959e-02f, 1.73782334e-02f, -3.13857235e-02f, 1.89031735e-01f,
  2.21195683e-01f, 1.25185978e-02f, 2.98388064e-01f, 2.94258565e-01f, 4.11529958e-01f, -1.79530576e-01f, 1.95717722e-01f, -1.66092645e-02f, 2.42191162e-02f, 1.77416906e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  4.13205177e-01f, 2.33563140e-01f, 4.05237794e-01f, 3.70301679e-02f, -6.24405183e-02f, 2.18462184e-01f, -5.76876476e-03f, 4.06529978e-02f, -2.57174168e-02f, -7.64048994e-02f,
  3.51744145e-01f, 1.14872807e-03f, -8.83659124e-02f, 1.96391568e-01f, 2.69639671e-01f, 1.11697547e-01f, 1.63897261e-01f, 3.54424566e-01f, 1.02768444e-01f, 7.40837306e-02f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -1.94424555e-01f, 1.22649133e-01f, -5.48558712e-01f, -6.72198683e-02f, -4.44227308e-01f, 1.60262272e-01f, -5.60738802e-01f, -5.22307158e-01f, -5.55397153e-01f, -2.71763861e-01f,
  3.12221855e-01f, -2.88921267e-01f, -5.76822102e-01f, 4.74094570e-01f, -1.57276794e-01f, -2.52291173e-01f, -7.54487514e-02f, 3.38944435e-01f, 2.21814245e-01f, 4.62246612e-02f,
  -3.79421450e-02f, 7.02139810e-02f, 1.55994132e-01f, 1.86607674e-01f, -5.14766052e-02f, -3.51932377e-01f, 8.39701891e-01f, 4.37749065e-02f, 1.94237739e-01f, -4.63984013e-01f,
  1.27955109e-01f, -3.36867720e-01f, -1.08830325e-01f, -5.04847169e-02f, -1.25706524e-01f, -2.92338915e-02f, -1.76786378e-01f, -2.76009947e-01f, -7.68061340e-01f, -6.97068214e-01f,
  -5.45539021e-01f, 4.03276652e-01f, 3.52211982e-01f, -4.90546227e-01f, -1.33489102e-01f, 4.61539030e-02f, -7.70111322e-01f, 1.80803984e-01f, 9.68990102e-02f, 7.53591955e-01f,
  -2.42506534e-01f, 4.40725118e-01f, -1.92649096e-01f, 7.30272308e-02f, -3.16170216e-01f, -8.77015144e-02f, -1.00296907e-01f, 5.34147382e-01f, -9.93139893e-02f, 2.93963879e-01f,
  -4.63421643e-01f, 3.12401801e-01f, 7.74650648e-02f, 1.05104968e-01f, 2.16442689e-01f, 1.50117055e-01f, -2.15575397e-01f, -8.98717046e-02f, 1.46771207e-01f, -6.34167790e-01f,
  3.07159930e-01f, -2.50947103e-02f, 5.45219004e-01f, -3.45161736e-01f, -1.69887498e-01f, -1.81625858e-01f, -2.99075365e-01f, 2.17820674e-01f, 2.73595244e-01f, 4.96990867e-02f,
  4.63367961e-02f, 3.54442835e-01f, -4.60380092e-02f, -1.56182855e-01f, 4.02639121e-01f, 7.92199299e-02f, -6.44823253e-01f, -4.94547546e-01f, -1.48146734e-01f, 7.66971767e-01f,
  -4.78927344e-01f, 5.52435331e-02f, -2.17563838e-01f, 2.85675049e-01f, -1.28351271e-01f, -1.90317482e-01f, -4.20439579e-02f, -1.42654493e-01f, 2.85869166e-02f, -3.06743652e-01f,
  -7.08131969e-01f, -2.85820775e-02f, 6.05234876e-02f, 2.31646612e-01f, -2.73360014e-01f, -5.27733564e-01f, 2.62365758e-01f, 3.98251474e-01f, 3.24108273e-01f, -3.97420198e-01f,
  -4.06545132e-01f, -1.25952750e-01f, -8.11722726e-02f, -3.68501782e-01f, 1.40138984e-01f, 9.55409557e-02f, 3.41460228e-01f, -1.42890677e-01f, 2.67625988e-01f, 2.66653467e-02f,
  -9.47501918e-04f, -6.40537679e-01f, 2.78374225e-01f, 3.78260642e-01f, 5.35943985e-01f, -4.49060202e-01f, -2.87219107e-01f, 4.49722141e-01f, 2.25568339e-01f, -1.46667033e-01f,
  3.96712840e-01f, 3.38964999e-01f, 4.05939847e-01f, 1.59537777e-01f, 4.50072676e-01f, 5.33730328e-01f, 5.81637286e-02f, 8.90448093e-02f, 8.68657976e-02f, 9.05689597e-02f,
  3.16415340e-01f, -1.42302230e-01f, 2.21693084e-01f, -3.38885427e-01f, -1.14445083e-01f, -3.76380920e-01f, -5.53644300e-02f, 1.24217281e-02f, 4.55273204e-02f, -2.00516596e-01f,
  1.12059915e+00f, 4.36993502e-03f, -8.47700387e-02f, -4.89040494e-01f, -1.36112021e-02f, -3.80087465e-01f, 2.44078368e-01f, -4.84613657e-01f, 4.44053769e-01f, -1.62384734e-01f,
  6.75480515e-02f, 2.92438656e-01f, -2.46615782e-01f, 8.34243223e-02f, 9.60959792e-02f, 4.40674648e-02f, 3.95363659e-01f, 2.18587905e-01f, -7.04715073e-01f, 1.41857743e-01f,
  2.15106800e-01f, -1.69970363e-01f, -5.55691242e-01f, 1.95361063e-01f, -1.42827302e-01f, 3.79470497e-01f, -1.78501323e-01f, -2.34412238e-01f, 1.11329339e-01f, -1.20336533e-01f,
  -7.51139298e-02f, -3.91851030e-02f, 8.66381109e-01f, 4.85484630e-01f, -1.22925602e-01f, -6.55713491e-03f, -4.41396415e-01f, 1.55989118e-02f, -5.83503366e-01f, 5.22836804e-01f,
  8.45605955e-02f, 1.00956768e-01f, -6.36020601e-01f, -2.32705697e-01f, 2.38565609e-01f, -1.28876135e-01f, -1.71705365e-01f, 2.78605700e-01f, 3.90934825e-01f, 3.39368314e-01f,
  3.13212574e-01f, 5.59748590e-01f, -5.03397346e-01f, 2.13301107e-01f, -3.41451466e-01f, -5.52428782e-01f, 5.20702124e-01f, -2.62345642e-01f, 8.33373442e-02f, 7.00700432e-02f,
  6.41889796e-02f, 2.13038959e-02f, -7.61387572e-02f, -2.35684186e-01f, 4.20538485e-01f, -2.83007830e-01f, 2.44120508e-01f, 3.93318713e-01f, -5.18725872e-01f, -2.10875213e-01f,
  -2.83515513e-01f, 7.42367506e-01f, -2.55625814e-01f, -2.01658428e-01f, -1.21722922e-01f, 6.45174831e-03f, -2.34688044e-01f, 2.97653209e-02f, 1.06514484e-01f, 1.55485839e-01f,
  -7.72290230e-02f, -2.26885840e-01f, 4.35813844e-01f, 1.04054429e-01f, -1.24563621e-02f, 4.72712994e-01f, 6.81115031e-01f, -2.01806873e-01f, -4.10324067e-01f, -5.90172522e-02f,
  -1.68674484e-01f, -9.34461653e-02f, -1.07980363e-01f, 8.81317332e-02f, -9.37687904e-02f, 2.98515260e-01f, -6.22093618e-01f, -1.74753144e-01f, -1.99795607e-03f, -2.97385573e-01f,
  7.76316464e-01f, 2.75629044e-01f, 7.76288733e-02f, -3.13934326e-01f, 1.21140689e-01f, -1.01288237e-01f, -1.83419704e-01f, -3.47559303e-01f, 3.90892178e-02f, -5.65989390e-02f,
  -2.30486870e-01f, -4.71740693e-01f, -4.91323143e-01f, -5.26057899e-01f, 1.81553349e-01f, -1.85107626e-02f, -3.38074535e-01f, -7.62663484e-02f, -2.73134112e-01f, 1.93353608e-01f,
  -2.60107368e-01f, 4.81266886e-01f, 1.16989248e-01f, -3.48026782e-01f, -1.79708108e-01f, -2.17915580e-01f, -3.90042178e-02f, 4.75259759e-02f, -5.61831057e-01f, 5.86027741e-01f,
  2.24454060e-01f, 2.67997056e-01f, 9.28221419e-02f, -3.68003726e-01f, 4.54345107e-01f, 4.32251275e-01f, -5.77833913e-02f, 1.04008235e-01f, -2.04025418e-01f, 2.45642796e-01f,
  -1.65772408e-01f, 2.39932731e-01f, -3.84467483e-01f, 3.45784366e-01f, 4.36473846e-01f, 1.72155350e-01f, 4.48636264e-01f, 1.31621296e-02f, -5.82739592e-01f, 8.50144029e-02f,
  2.54276723e-01f, -6.11113645e-02f, 4.09010440e-01f, -1.80035084e-01f, -1.10481232e-01f, 1.10425599e-01f, 2.36332566e-01f, -1.49924904e-01f, -1.29142866e-01f, 9.72406790e-02f,
  8.59086290e-02f, -4.03495818e-01f, -4.57047345e-03f, 7.05228448e-01f, 3.17006409e-01f, -2.88623661e-01f, -3.18999588e-01f, -7.66390800e-01f, 1.61010429e-01f, -5.63408732e-01f,
  4.14696157e-01f, 4.37794477e-01f, 4.40390676e-01f, 1.57611102e-01f, 1.95486009e-01f, 5.39869606e-01f, -6.52354360e-02f, 3.45488340e-02f, -1.36389911e-01f, -6.14150345e-01f,
  4.69823062e-01f, 1.61653578e-01f, 4.30272698e-01f, -5.71582913e-02f, 9.06668454e-02f, -9.00741518e-02f, 4.78569344e-02f, 3.99241656e-01f, -1.13580577e-01f, -2.22125068e-01f,
  -1.07151665e-01f, -3.47939762e-03f, -6.02552354e-01f, -4.47315335e-01f, 3.59177291e-01f, -5.36195219e-01f, -4.11608249e-01f, 5.51461577e-01f, -1.71670169e-01f, 1.09123133e-01f,
  -1.62044838e-01f, 7.56843388e-01f, 1.78847417e-01f, -3.54942292e-01f, 2.66776115e-01f, 1.07243702e-01f, 1.47325084e-01f, 9.47938785e-02f, -3.95668065e-03f, 5.79136252e-01f,
  9.54230055e-02f, 2.93186605e-01f, -8.21950808e-02f, 6.37166798e-02f, 1.27725422e-01f, -6.34544194e-02f, 7.73383677e-01f, 4.61065829e-01f, 1.69137940e-01f, -3.01588714e-01f,
  1.22686677e-01f, -1.79380011e-02f, -1.14678018e-01f, 7.96598941e-02f, -4.40093338e-01f, 4.36094522e-01f, -1.09564573e-01f, -4.46663529e-01f, -5.01519322e-01f, -6.90231770e-02f,
  3.64508957e-01f, 4.52138305e-01f, -2.00408138e-02f, -4.54236835e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.57742918e-01f, 1.54148489e-01f, -6.94174096e-02f, -4.55552191e-02f, 6.57286346e-02f, -9.99449044e-02f, -7.67918676e-02f, -1.06882893e-01f, -3.16507727e-01f, -1.20646298e-01f,
  1.71850726e-01f, 4.70566452e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    