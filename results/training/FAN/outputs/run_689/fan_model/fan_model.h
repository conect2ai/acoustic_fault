/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.45335931e-01f, -2.11045787e-01f, -1.90842003e-01f, -2.71607697e-01f, -2.90322565e-02f, -2.32713465e-02f, -1.20933898e-01f, -5.30929603e-02f, 2.10804362e-02f, -1.83175415e-01f,
  -1.21610098e-01f, 1.03373729e-01f, 5.61402552e-02f, 4.78536263e-02f, 1.13172680e-01f, -3.70268300e-02f, -1.25680670e-01f, 3.87357101e-02f, 1.76952451e-01f, 2.12317809e-01f,
  8.04988071e-02f, 6.13454357e-02f, -1.91649441e-02f, 1.09697334e-01f, -1.02325734e-02f, -8.46147910e-03f, -1.63025051e-01f, -1.11315846e-01f, 1.03474461e-01f, -1.29387215e-01f,
  -1.20677218e-01f, -1.42844439e-01f, 1.56580225e-01f, 6.96902797e-02f, -6.34315908e-02f, 5.38960844e-02f, 2.01837514e-02f, -4.52995561e-02f, 2.39678733e-02f, -7.15452805e-02f,
  -6.87411726e-02f, -2.36333739e-02f, 1.19720846e-02f, -1.64904036e-02f, -5.70192412e-02f, 4.18941714e-02f, 5.61187305e-02f, -4.63855788e-02f, -4.30454053e-02f, -5.06781600e-02f,
  5.94153628e-02f, -3.92676182e-02f, 1.83255598e-02f, 4.77772934e-04f, -6.63436055e-02f, -2.94916686e-02f, -3.84416245e-02f, 8.02354701e-03f, -1.12809226e-01f, -1.09101661e-01f,
  6.02064356e-02f, -7.94553682e-02f, 2.02005543e-02f, -7.54230516e-03f, 5.80331217e-03f, -6.84932694e-02f, 1.74766108e-02f, -2.25698892e-02f, 1.53719097e-01f, 1.56201646e-02f,
  -2.59612147e-02f, -3.55985798e-02f, 2.48624049e-02f, -1.26974985e-01f, -2.40271967e-02f, -1.00052327e-01f, 2.58078612e-02f, -3.28696296e-02f, 7.94699974e-03f, 1.61259193e-02f,
  1.28371622e-02f, 3.15122157e-02f, -6.97461963e-02f, 3.51483352e-03f, 3.72450054e-02f, -9.39662755e-02f, 3.21164727e-02f, -5.39688095e-02f, -1.06967174e-01f, -7.55363926e-02f,
  -1.11894153e-01f, -7.11947754e-02f, -1.66893035e-01f, -3.56866457e-02f, -1.73652153e-02f, 3.17922793e-02f, -1.05098486e-01f, 9.82944109e-03f, -9.52036679e-02f, 3.23903896e-02f,
  3.61442678e-02f, -3.21795717e-02f, -7.12386966e-02f, 1.27337188e-01f, 6.96948469e-02f, 7.31426058e-03f, -7.65502751e-02f, 5.25788479e-02f, 1.62156299e-02f, 2.23116037e-02f,
  7.20000789e-02f, 1.28734624e-02f, -6.84840530e-02f, -6.83085248e-02f, 5.17712981e-02f, 4.94941277e-03f, 2.19281763e-02f, -6.99239299e-02f, -1.15879670e-01f, -8.53233710e-02f,
  1.50294617e-01f, -1.72128469e-01f, -1.14007592e-01f, -1.74922541e-01f, -3.80501226e-02f, -1.74020603e-03f, 1.06334925e-01f, 6.63324585e-03f, 1.05877686e-02f, -3.27799208e-02f,
  -1.15580462e-01f, -8.41655433e-02f, -1.12180762e-01f, -3.68291326e-02f, -3.41295227e-02f, -4.41772081e-02f, -1.73847765e-01f, -5.67615591e-02f, 2.77752932e-02f, -3.74834123e-03f,
  -1.24215372e-01f, -9.89865363e-02f, -5.82454801e-02f, -5.29985465e-02f, -5.65329120e-02f, -7.81562775e-02f, -1.28245264e-01f, -7.83013627e-02f, -4.16084006e-02f, -2.07610741e-01f,
  -5.74234836e-02f, -1.33405492e-01f, -6.92234486e-02f, -7.79721439e-02f, -1.19692475e-01f, -2.17703544e-02f, -7.81153515e-02f, -1.59269020e-01f, -6.16798773e-02f, -1.23057850e-01f,
  -1.87349796e-01f, -1.11418098e-01f, -1.32567540e-01f, -1.29971206e-01f, -1.49593845e-01f, -1.47822583e-02f, -1.11470960e-01f, -3.90448794e-02f, -1.10653602e-01f, -6.99580312e-02f,
  -2.07058325e-01f, -1.23911127e-01f, -1.09576106e-01f, 3.16678956e-02f, -9.91503447e-02f, -9.61713046e-02f, -5.37262857e-02f, -1.05001308e-01f, -3.35027874e-02f, 1.12528829e-02f,
  -6.56566024e-02f, 3.38950865e-02f, 1.54169559e-01f, 1.70302287e-01f, 1.63491428e-01f, 1.08803406e-01f, 9.99987498e-02f, 1.13677546e-01f, 1.35711864e-01f, 1.11777745e-01f,
  1.62745625e-01f, 6.49656132e-02f, 2.42111627e-02f, 1.63835045e-02f, 9.85173229e-03f, 5.70880212e-02f, 1.00389287e-01f, 8.96737203e-02f, 3.89786214e-02f, 1.31758675e-01f,
  1.62052840e-01f, 9.89766195e-02f, 1.12740874e-01f, 1.53064787e-01f, 5.25504574e-02f, 4.13289517e-02f, 1.53911740e-01f, 1.38925269e-01f, 1.37396395e-01f, 6.38827533e-02f,
  1.61196217e-01f, -4.23900113e-02f, -9.06152874e-02f, 1.48292044e-02f, -1.46275923e-01f, -1.25344187e-01f, -1.57520428e-01f, -8.17343965e-02f, -7.05390647e-02f, -1.19958438e-01f,
  -3.26369628e-02f, -9.83982831e-02f, -8.68143588e-02f, -1.09455995e-01f, -8.15460160e-02f, -9.88646224e-02f, 1.18208649e-02f, -9.95736271e-02f, -7.33971074e-02f, -2.66063008e-02f,
  -1.03204787e-01f, 1.88861210e-02f, 5.40731922e-02f, 5.99846356e-02f, -3.65961306e-02f, -4.34141643e-02f, 6.54229522e-02f, -7.09594861e-02f, 6.27196804e-02f, 1.04512691e-01f,
  2.31659248e-01f, 4.54029329e-02f, 2.46687979e-01f, 3.05007193e-02f, -9.44233015e-02f, -5.50258011e-02f, 7.98186474e-03f, -5.04360460e-02f, -3.35668996e-02f, -2.64077373e-02f,
  -1.51052892e-01f, -1.88081235e-01f, -1.64756864e-01f, -1.34001210e-01f, 3.95169668e-03f, 1.44650593e-01f, 1.09667666e-01f, 1.97995037e-01f, 4.54489961e-02f, -1.08663768e-01f,
  -1.16072319e-01f, 8.52123424e-02f, 2.36652479e-01f, 4.04389463e-02f, -7.42198303e-02f, -7.54439160e-02f, 1.78715542e-01f, 5.82751781e-02f, 6.96696490e-02f, 2.94444486e-02f,
  1.08492918e-01f, 7.01382682e-02f, -9.42376722e-03f, -1.06025063e-01f, -4.55011502e-02f, 4.76009324e-02f, 9.42722335e-03f, 2.70952024e-02f, -7.70972520e-02f, -7.77983740e-02f,
  4.55445796e-03f, -5.07614166e-02f, -2.94538252e-02f, -1.37013659e-01f, 5.15360832e-02f, 3.39847095e-02f, -2.16461252e-03f, 1.05974659e-01f, 6.68131048e-03f, -6.19246438e-02f,
  -1.16041131e-01f, 1.75751857e-02f, -1.09936278e-02f, -4.77979444e-02f, -2.08630990e-02f, -1.43581480e-01f, -7.68111728e-04f, 3.08241118e-02f, 7.93691725e-02f, 1.59881637e-01f,
  1.08004682e-01f, -8.73462111e-02f, 2.31456589e-02f, -6.63418183e-03f, 2.23575216e-02f, -3.67296711e-02f, -1.94101725e-02f, 3.54305357e-02f, 3.25700529e-02f, 2.89501548e-02f,
  -1.39183998e-02f, -7.43033888e-04f, 4.95552924e-03f, -5.02068140e-02f, -3.05770263e-02f, -4.71633747e-02f, -1.04983188e-01f, -1.24623635e-04f, 2.89707799e-02f, 2.49309037e-02f,
  -7.06564039e-02f, 7.64349895e-03f, -7.90411839e-04f, -7.87473749e-03f, 3.00921705e-02f, 2.60061566e-02f, -6.47827983e-02f, -7.48875290e-02f, 2.73321159e-02f, -2.57215165e-02f,
  -9.12474468e-02f, -3.16171832e-02f, -1.04090884e-01f, -4.57117260e-02f, -7.47379735e-02f, -1.21341862e-01f, -6.60672858e-02f, -4.16599251e-02f, -5.87035865e-02f, -9.44754630e-02f,
  8.31686147e-03f, -1.37021756e-02f, -1.79695264e-02f, -2.75246203e-02f, -1.12234622e-01f, -1.47594944e-01f, -2.13131513e-02f, -4.56862003e-02f, -1.43873200e-01f, -1.42220408e-02f,
  -1.38898278e-02f, -3.69823352e-02f, 4.01583426e-02f, -9.80689749e-02f, -4.46381383e-02f, -7.39182830e-02f, -6.03912137e-02f, -4.09640931e-03f, 1.66703165e-02f, 3.03493105e-02f,
  -1.85771286e-01f, 8.06030184e-02f, -2.08386004e-01f, 7.70688057e-02f, 5.49882464e-02f, -6.77469149e-02f, -1.06270261e-01f, -4.94308695e-02f, 2.15194002e-02f, -9.57063735e-02f,
  -9.54139233e-02f, -3.93903740e-02f, 2.94812769e-02f, -2.07447587e-03f, -1.64045379e-01f, 4.70481347e-03f, 5.61133213e-02f, 1.67383032e-03f, -1.89975485e-01f, 1.78871691e-04f,
  8.76249000e-02f, 1.59814805e-02f, -1.54560611e-01f, -1.39562925e-02f, 1.49586434e-02f, -4.03655507e-02f, -2.71534789e-02f, -5.09720296e-02f, -1.55879296e-02f, 1.71364054e-01f,
  4.12451625e-02f, -4.38798964e-02f, -1.41918883e-01f, -2.22231317e-02f, -1.65383741e-02f, -1.11454107e-01f, -1.09720387e-01f, -5.37833758e-02f, -6.83611259e-02f, -1.67120509e-02f,
  -7.49186352e-02f, -9.52960029e-02f, -2.83012912e-02f, -8.11381266e-02f, -7.21425861e-02f, -1.48563506e-02f, -3.60479653e-02f, -5.79419918e-02f, 1.61444000e-03f, -9.77429599e-02f,
  1.09695926e-01f, -6.40309155e-02f, -7.16724023e-02f, -1.11711696e-01f, -3.36287469e-02f, -1.04271904e-01f, -8.34773332e-02f, -7.97701180e-02f, -1.95358738e-01f, 5.92425540e-02f,
  5.50736114e-02f, -5.88996336e-02f, 1.02569550e-01f, 9.73988846e-02f, 4.32514250e-02f, 4.21991386e-02f, 2.63243020e-02f, -1.37696564e-02f, 1.19023947e-02f, 4.71867472e-02f,
  5.83055057e-02f, -5.76635972e-02f, 4.12096381e-02f, 1.04522161e-01f, 5.35833575e-02f, 5.53806350e-02f, 4.88367081e-02f, 4.00428809e-02f, -1.39205195e-02f, -3.98568314e-04f,
  -1.52507210e-02f, 2.17113942e-02f, 1.92755759e-02f, -1.72704849e-02f, -4.92397100e-02f, -5.69195300e-03f, 1.03115909e-01f, -4.04043980e-02f, 6.09837100e-02f, 6.99980780e-02f,
  -1.73484370e-01f, -1.82780713e-01f, -3.24670412e-02f, -7.88642019e-02f, -6.99797198e-02f, -3.99422981e-02f, -2.72494406e-02f, -1.27327025e-01f, 2.68922020e-02f, -9.52671021e-02f,
  -3.79757509e-02f, -1.19862124e-01f, -3.45041901e-02f, -1.37388468e-01f, -1.02257825e-01f, -1.06499426e-01f, -1.04303978e-01f, -7.68409669e-02f, -4.97593507e-02f, -1.31721750e-01f,
  -1.13675453e-01f, -1.33331820e-01f, -8.20311606e-02f, -1.62986666e-01f, -6.62314966e-02f, -1.95920795e-01f, -1.07202314e-01f, -7.78917000e-02f, -1.93278953e-01f, -2.41895884e-01f,
  2.68500954e-01f, 1.18029498e-01f, 4.19053696e-02f, 7.45302141e-02f, -1.23754457e-01f, -5.28109893e-02f, 7.75104538e-02f, 2.00929325e-02f, -4.43259776e-02f, 1.42758805e-02f,
  -1.22866146e-01f, -9.61532071e-02f, -1.37089178e-01f, 1.62316468e-02f, 5.90629876e-02f, 1.72383741e-01f, 1.27174199e-01f, 1.92498177e-01f, 1.16336793e-01f, -3.96950953e-02f,
  -2.62264442e-02f, 5.22304326e-02f, 1.68621153e-01f, 3.54838856e-02f, 2.74485964e-02f, -4.78798598e-02f, 1.48567129e-02f, 6.31272271e-02f, -4.85926941e-02f, 5.10734543e-02f,
  -8.51422623e-02f, 5.15202433e-02f, 3.74368764e-02f, 8.80804192e-03f, -7.59251788e-02f, 1.73207372e-01f, -6.41864119e-03f, 7.09011331e-02f, 8.69869515e-02f, -4.82748449e-02f,
  -9.12186056e-02f, 4.68367971e-02f, 1.91627014e-02f, 3.84262688e-02f, -1.30094038e-02f, 1.35181427e-01f, 1.61187440e-01f, 2.02305138e-01f, 5.97093292e-02f, 1.83423609e-02f,
  8.80945995e-02f, 7.02725053e-02f, -4.61231694e-02f, 7.24179596e-02f, 1.46341637e-01f, -6.50620386e-02f, 4.31399047e-02f, 1.66267008e-02f, 1.24169243e-02f, 1.35000080e-01f,
  7.20075667e-02f, -8.09931979e-02f, -3.14479284e-02f, 7.36017711e-03f, -7.77008832e-02f, -6.08024448e-02f, -5.28852008e-02f, -5.59948571e-02f, 1.07667886e-03f, -8.93060875e-04f,
  -7.71778524e-02f, -6.43455088e-02f, -4.59836088e-02f, 1.60084348e-02f, -4.91721593e-02f, -5.94586041e-03f, -5.72970100e-02f, -7.19477097e-03f, 6.11745864e-02f, 2.66115442e-02f,
  -6.57878071e-02f, -2.21302249e-02f, 2.74070557e-02f, 9.19562241e-04f, 9.50046442e-03f, -6.61268190e-04f, -2.83438116e-02f, -1.77934971e-02f, -2.07484849e-02f, -3.27387056e-03f,
  -5.94422743e-02f, -1.55150294e-01f, 1.16818048e-01f, 2.08620653e-01f, 5.32702021e-02f, 3.18809040e-02f, -3.80963795e-02f, 2.04696581e-02f, 3.07041351e-02f, 1.19720735e-01f,
  -7.84037784e-02f, 1.19000278e-01f, 2.06958354e-02f, -1.17914006e-02f, 1.26269823e-02f, 6.19360842e-02f, 1.18203223e-01f, 7.24951997e-02f, -1.42197451e-03f, 1.06835403e-01f,
  1.12748109e-01f, 2.47013308e-02f, 9.18908790e-02f, 8.38981848e-03f, 3.67168784e-02f, 6.83758110e-02f, 3.60137713e-03f, 6.44198284e-02f, -1.77196898e-02f, 4.16703001e-02f,
  2.77801678e-02f, 1.47237048e-01f, 1.78678948e-02f, 1.32367581e-01f, -1.03303492e-01f, -1.88521937e-01f, -7.83546828e-03f, -1.55939057e-01f, -4.93883435e-03f, 3.61985154e-02f,
  -1.28246561e-01f, -8.01090673e-02f, -4.78522442e-02f, 1.63297504e-02f, 1.38985151e-02f, 1.24765277e-01f, 1.67989165e-01f, 3.92899327e-02f, -1.52882963e-01f, -4.20590453e-02f,
  5.42424321e-02f, 1.20809607e-01f, 8.78298059e-02f, 1.32237822e-01f, 2.30563253e-01f, 1.30105510e-01f, 1.65333584e-01f, 1.15758315e-01f, 1.25408784e-01f, 2.42365584e-01f,
  -6.66717067e-02f, -1.29116699e-01f, -1.19763687e-01f, -1.10144228e-01f, -5.55994809e-02f, 5.96773438e-03f, -7.60789821e-03f, 3.33161466e-02f, -4.76852544e-02f, 1.63141415e-02f,
  3.39679345e-02f, -6.79380633e-03f, 5.40526547e-02f, -1.83425564e-02f, 5.73346540e-02f, -7.15796500e-02f, 5.37384953e-03f, -1.90705433e-02f, 4.84594516e-03f, -8.61789212e-02f,
  1.34049460e-01f, 1.02544144e-01f, 8.69566109e-03f, 9.33582801e-03f, -6.38417900e-02f, -3.05411965e-02f, -3.88802476e-02f, -4.19804379e-02f, 3.65466607e-04f, 7.02771172e-02f,
  7.90575817e-02f, 1.38700930e-02f, 8.71374533e-02f, -8.03290401e-03f, 1.05078809e-01f, -4.09554578e-02f, 1.95827298e-02f, 1.87975802e-02f, -9.31120303e-04f, 4.41253781e-02f,
  -5.74267209e-02f, -1.70568451e-02f, -5.87809319e-03f, -5.57165174e-03f, 8.20881128e-02f, 2.22305898e-02f, 4.22333293e-02f, 1.36056557e-01f, 1.48256039e-02f, 1.47442240e-02f,
  5.05568981e-02f, 6.94440454e-02f, -4.24973108e-02f, 5.68783879e-02f, -1.78821962e-02f, 5.12323007e-02f, 1.00119822e-01f, -7.31628835e-02f, -3.10509335e-02f, 1.93532538e-02f,
  -9.77170616e-02f, -1.82369366e-01f, -2.75532044e-02f, -1.14481812e-02f, -1.96894985e-02f, -4.77110296e-02f, -6.27244264e-02f, -3.67551260e-02f, -5.97316213e-03f, -3.35430354e-02f,
  -5.71082756e-02f, -1.07846312e-01f, -4.73533981e-02f, 4.87942435e-02f, -9.62288603e-02f, -3.72038521e-02f, 2.84017473e-02f, 4.79254499e-02f, 3.29807326e-02f, 2.79038344e-02f,
  3.80667746e-02f, -3.69563997e-02f, 3.80446762e-02f, -2.15862337e-02f, 8.68293419e-02f, -1.02142103e-01f, 3.97242866e-02f, 2.75751036e-02f, -1.73954174e-01f, 1.17812149e-01f,
  -4.64018762e-01f, -1.71438530e-01f, -1.57565758e-01f, -1.48754224e-01f, 1.47040099e-01f, 5.63019402e-02f, -1.53552487e-01f, -1.71817064e-01f, -8.50796103e-02f, -3.48099731e-02f,
  7.13609457e-02f, 1.23116843e-01f, -4.39431460e-04f, 8.92694667e-02f, -1.19619891e-01f, 3.45123728e-04f, -2.79592779e-02f, -1.61948279e-02f, 5.93915470e-02f, 4.16426063e-02f,
  2.34865785e-01f, 2.35964675e-02f, -9.79530141e-02f, -8.50006938e-02f, 1.13543272e-01f, 6.75580353e-02f, -7.89064507e-04f, -3.09630316e-02f, 1.56292319e-01f, 6.63665384e-02f,
  9.21083465e-02f, -1.62891954e-01f, -7.83019066e-02f, -7.17914430e-03f, 1.87571943e-02f, -1.15270630e-01f, -5.30249588e-02f, -5.44608943e-02f, -1.17779166e-01f, -7.16503412e-02f,
  5.70102558e-02f, 6.27028495e-02f, -5.58274277e-02f, -1.76308751e-02f, 4.11615911e-04f, -7.95720965e-02f, -3.60279977e-02f, -1.77914545e-01f, -2.48671956e-02f, 8.59947409e-03f,
  1.17816463e-01f, 2.71795725e-04f, -1.00597329e-01f, -2.04948410e-02f, -4.04809192e-02f, 5.49553372e-02f, -6.19340241e-02f, -2.18596663e-02f, -4.41924334e-02f, -1.60016194e-01f,
  -2.37948522e-02f, 9.71082002e-02f, 4.66791280e-02f, -6.06442280e-02f, 4.14719656e-02f, 1.20922081e-01f, 4.52731214e-02f, 1.34463057e-01f, 1.12440579e-01f, 4.68465574e-02f,
  5.56056574e-02f, 1.42717892e-02f, 1.31512970e-01f, -4.36096601e-02f, 8.16770643e-02f, 1.05091564e-01f, 7.86331668e-02f, 3.80831473e-02f, 8.74470621e-02f, 5.48105016e-02f,
  9.90432948e-02f, 9.06086490e-02f, 1.24144599e-01f, 1.53355151e-01f, 6.43891916e-02f, -5.72365569e-03f, 5.75354174e-02f, 1.43025205e-01f, 2.65193135e-02f, -1.11179426e-02f,
  -1.55252501e-01f, -7.47878477e-02f, -6.23344146e-02f, -2.87324879e-02f, -9.05772001e-02f, -9.88967568e-02f, -3.78690124e-03f, -8.40043947e-02f, -2.67420113e-02f, -9.29310620e-02f,
  2.06490923e-02f, -1.44201174e-01f, -7.86779821e-02f, -4.05462496e-02f, -8.12180936e-02f, -9.24088508e-02f, -5.79468086e-02f, -1.04637727e-01f, -5.21829166e-03f, -3.08667421e-02f,
  -7.17344508e-02f, -1.07544109e-01f, -4.86570671e-02f, -9.74427611e-02f, -1.79236736e-02f, -1.76553234e-01f, -1.74234420e-01f, -7.44262785e-02f, -1.82386503e-01f, -3.65999460e-01f,
  4.77000065e-02f, -3.27201858e-02f, 1.15528516e-01f, -5.09851649e-02f, 1.00191526e-01f, 6.44869059e-02f, 1.63291886e-01f, 8.56354386e-02f, -1.07023045e-01f, -4.96748835e-03f,
  -1.02139316e-01f, -2.55217940e-01f, -8.15033168e-02f, -4.51067872e-02f, 8.02919269e-02f, 9.26547647e-02f, 1.00673147e-01f, -7.62257213e-03f, 4.83241752e-02f, 6.99842116e-03f,
  -8.85442272e-02f, -1.65560395e-02f, -1.37718976e-01f, -3.79333496e-02f, -5.97943701e-02f, -1.51253743e-02f, 5.64794950e-02f, 8.68795160e-03f, -5.41948751e-02f, -7.48993829e-02f,
  -8.84452909e-02f, 4.06225435e-02f, -7.60080479e-03f, -5.32471389e-02f, -3.64423729e-02f, 4.32811975e-02f, -4.29197438e-02f, -5.35622798e-03f, -1.85018573e-02f, -6.09729253e-02f,
  -3.09100561e-02f, -9.42236781e-02f, 4.53386605e-02f, 1.58967040e-02f, -8.54558051e-02f, -7.69652277e-02f, -5.70567288e-02f, 6.44921735e-02f, 6.81154430e-02f, -9.79941636e-02f,
  -3.98961604e-02f, 8.67047235e-02f, 9.43792686e-02f, 9.53257754e-02f, -3.88362519e-02f, -3.58574614e-02f, 3.24034900e-03f, 4.24459912e-02f, 8.59727561e-02f, -3.84927839e-02f,
  -3.91686372e-02f, 2.21858248e-02f, 9.89135168e-03f, 4.74460702e-03f, 3.84737253e-02f, 4.53096740e-02f, 2.84337010e-02f, 3.68288532e-02f, 4.14460003e-02f, 2.04318743e-02f,
  -3.62566225e-02f, 3.30017507e-02f, -2.56507602e-02f, -2.72072777e-02f, 3.83080100e-03f, 8.43270272e-02f, 1.21227317e-02f, 5.92549331e-03f, 2.99303588e-02f, 7.84482248e-03f,
  5.72007112e-02f, 1.87319480e-02f, -2.41863169e-02f, -4.56680730e-02f, -1.90922916e-02f, 4.04474838e-03f, 6.50435090e-02f, -5.78632094e-02f, 6.06334433e-02f, -3.11024785e-02f,
  -6.94302619e-02f, 1.23411171e-01f, 7.39195198e-02f, -2.97527928e-02f, -5.51921874e-02f, 1.78258549e-02f, 1.55745260e-02f, -1.26249507e-01f, -2.75151804e-02f, -2.63863858e-02f,
  -5.18866852e-02f, -4.96239886e-02f, 5.33114821e-02f, -7.22583309e-02f, 5.55849187e-02f, 2.11506300e-02f, -1.22204646e-01f, -7.78209744e-03f, -5.88214695e-02f, -1.13112196e-01f,
  1.80043373e-02f, 6.67951182e-02f, -6.32395893e-02f, 2.77822986e-02f, -3.78111154e-02f, 6.42293170e-02f, -6.68718666e-02f, -9.64191854e-02f, -2.66240444e-02f, -7.13474527e-02f,
  3.67443889e-01f, -3.39776278e-02f, -1.04662053e-01f, 6.84325173e-02f, -1.24300480e-01f, -1.12634964e-01f, -2.50756115e-01f, 1.02788627e-01f, 5.18935695e-02f, -8.66645500e-02f,
  8.98526236e-02f, 1.77580163e-01f, 1.16562665e-01f, 1.45034820e-01f, 4.88085374e-02f, -2.33638436e-01f, -1.56775028e-01f, -6.44978583e-02f, 1.02101550e-01f, 2.54744124e-02f,
  -5.86259738e-02f, -6.15110015e-03f, 1.79390267e-01f, 1.03441276e-01f, -6.21857718e-02f, -2.31002181e-04f, -1.14486508e-01f, 3.30020860e-02f, -9.09570158e-02f, -2.22200111e-01f,
  -3.60176042e-02f, -2.37089936e-02f, -9.82699320e-02f, 1.26047656e-02f, 1.44483913e-02f, -3.29874977e-02f, -6.99328557e-02f, 3.66179412e-03f, -4.50786389e-02f, -9.46902335e-02f,
  -3.05578560e-02f, 3.61515284e-02f, -3.66661996e-02f, -4.80622053e-02f, 6.91609606e-02f, -5.66376327e-03f, -2.86187623e-02f, -1.82104036e-02f, -2.99712010e-02f, 4.51062024e-02f,
  -3.30382176e-02f, 2.89322156e-02f, -8.31382573e-02f, -5.62654808e-02f, 2.31050365e-02f, 3.53163294e-02f, -6.39647171e-02f, 7.39422962e-02f, -2.04070006e-02f, 2.67974194e-02f,
  -7.52703026e-02f, 6.20022379e-02f, 1.25580266e-01f, 3.42026725e-02f, 2.50206552e-02f, 9.09743086e-02f, -4.26452979e-02f, 8.15025866e-02f, 2.51085702e-02f, 1.00699082e-01f,
  5.54397590e-02f, 4.10646461e-02f, -3.09945680e-02f, -1.47937322e-02f, 5.25882989e-02f, -3.63609707e-03f, 9.39584598e-02f, -9.59897693e-03f, -9.52959247e-03f, 3.06078363e-02f,
  4.51238230e-02f, -2.32701395e-02f, 9.30074304e-02f, -1.84232835e-02f, -2.86190715e-02f, 7.70271122e-02f, 7.66320676e-02f, 4.95641977e-02f, 9.53554586e-02f, -6.50465712e-02f,
  1.87976718e-01f, -6.67107431e-03f, -1.32616162e-02f, -1.71535350e-02f, -5.82496785e-02f, -2.82835383e-02f, -7.72501454e-02f, 1.14309229e-03f, -5.64524718e-02f, -6.42321631e-02f,
  3.48259695e-02f, -1.87649336e-02f, 3.40361632e-02f, 4.61537689e-02f, 9.01291054e-03f, -5.28413765e-02f, 3.02517582e-02f, -5.18890508e-02f, 3.39950174e-02f, -2.27710418e-02f,
  -4.02300842e-02f, -1.01794815e-02f, 4.92568575e-02f, 2.28341222e-02f, -5.12483437e-03f, 9.84713528e-03f, -4.15875427e-02f, 4.40198183e-02f, -3.36755067e-02f, -1.18306942e-01f,
  -8.28463119e-03f, -3.47197920e-01f, 1.78615019e-01f, 1.12160243e-01f, -3.21282372e-02f, 5.74422348e-03f, -6.04399741e-02f, -8.70173946e-02f, -5.36695756e-02f, -8.26110393e-02f,
  -1.81721002e-01f, -1.27728671e-01f, 7.39387423e-02f, 9.92784053e-02f, 2.76910603e-01f, 1.40863687e-01f, 3.45378697e-01f, 3.86576146e-01f, 2.84758657e-01f, 8.58124420e-02f,
  -7.25208595e-02f, 2.57112850e-02f, 1.83536574e-01f, 8.28436986e-02f, -9.32030454e-02f, 2.52606161e-02f, -9.90465377e-03f, 8.79530013e-02f, 2.73325015e-02f, 1.38010994e-01f,
  1.22241937e-02f, -1.36519000e-01f, 6.91635609e-02f, 5.03089018e-02f, -8.62288699e-02f, -8.61362962e-04f, -5.20893559e-02f, 5.21239862e-02f, -4.18134928e-02f, 3.57206576e-02f,
  6.35535121e-02f, 5.81402704e-02f, -2.02878788e-02f, -8.25078879e-03f, 1.85257141e-02f, 7.04782316e-03f, 1.21011920e-01f, 1.35235935e-01f, 8.13802257e-02f, 3.40490304e-02f,
  -7.42365569e-02f, 1.46239186e-02f, 3.59775983e-02f, 3.48438621e-02f, 1.22002056e-02f, 9.24568698e-02f, -9.44213793e-02f, -1.28368158e-02f, 8.81941244e-02f, -6.05701879e-02f,
  -1.77262798e-02f, 9.13079828e-02f, -4.72572446e-03f, 1.94928031e-02f, 5.95086662e-04f, 5.46668172e-02f, 1.31983217e-02f, -5.23453904e-03f, 7.33938590e-02f, -2.52006873e-02f,
  5.48648275e-02f, 2.47342717e-02f, 1.04829557e-02f, 5.80617823e-02f, 4.16291924e-03f, 1.08685024e-01f, 5.38917258e-02f, 8.88681635e-02f, 8.02606419e-02f, -3.55929248e-02f,
  -3.70975025e-02f, -4.46737483e-02f, 5.21695353e-02f, -1.18585024e-02f, 8.25550258e-02f, 7.75575414e-02f, 8.92440379e-02f, 2.06181109e-02f, -4.49583400e-03f, 1.63935430e-04f,
  -1.58416003e-01f, 1.00311115e-01f, -1.28456056e-02f, 2.58355550e-02f, 7.72057660e-03f, -3.16374265e-02f, -7.05072805e-02f, 3.81598286e-02f, -2.96679847e-02f, -1.79909766e-02f,
  -1.72747105e-01f, -3.15366872e-02f, -6.40932797e-03f, -2.29303055e-02f, 4.69396040e-02f, -5.06250113e-02f, 5.23032574e-03f, 6.71468154e-02f, 3.94592136e-02f, -3.66074480e-02f,
  -5.53592443e-02f, 7.17574283e-02f, 1.75769046e-01f, 9.12016556e-02f, 1.75054222e-02f, 1.50893554e-01f, 3.33550503e-04f, -4.29525860e-02f, 1.13821372e-01f, -7.11892322e-02f,
  -2.49327049e-01f, 2.94904057e-02f, -2.41086334e-01f, 3.06105427e-02f, 1.25270009e-01f, 1.04202956e-01f, 2.17930272e-01f, 1.49794489e-01f, 7.05198124e-02f, 7.99305886e-02f,
  7.13794753e-02f, -7.03174993e-02f, -2.25128278e-01f, -2.00303540e-01f, -1.31854057e-01f, -1.29063725e-01f, -1.65249005e-01f, -3.06790233e-01f, -2.17051595e-01f, 1.32404208e-01f,
  1.23107329e-01f, 9.96334553e-02f, 2.93498561e-02f, -9.18607339e-02f, 4.92851213e-02f, 3.80533002e-02f, 2.23036297e-03f, -3.33498174e-05f, 1.30353391e-01f, -9.54087228e-02f,
  -2.91382134e-01f, 3.06045376e-02f, -4.01061475e-02f, 9.53638256e-02f, 1.49232866e-02f, -4.10755277e-02f, -5.13603874e-02f, 3.75312045e-02f, -4.38224040e-02f, -4.92878072e-02f,
  8.39553401e-02f, -6.79238560e-03f, -5.65531552e-02f, -4.61025871e-02f, 2.26683114e-02f, 4.11988273e-02f, -4.87682084e-03f, -1.58629417e-01f, 6.23811502e-03f, -2.24253871e-02f,
  5.35134487e-02f, -1.81985311e-02f, -8.14687610e-02f, -1.79286618e-02f, -2.69050105e-03f, 2.73310654e-02f, 2.76165046e-02f, 4.33386303e-04f, -7.68284872e-02f, 4.39632498e-02f,
  3.28394808e-02f, 7.26328045e-03f, 5.67293838e-02f, 4.07175235e-02f, 4.91381213e-02f, -1.61212906e-02f, -8.93925503e-02f, -4.05956147e-04f, -3.02448329e-02f, -2.05385732e-03f,
  -7.89162666e-02f, -2.46559223e-03f, -4.20384035e-02f, -1.31113352e-02f, -1.11287767e-02f, 8.34532082e-03f, -1.26019279e-02f, -9.76280868e-03f, 1.12072527e-02f, 5.19423969e-02f,
  2.46465225e-02f, -5.29595725e-02f, 8.96621719e-02f, -1.05217732e-02f, -3.65226232e-02f, -1.12202398e-01f, -4.84336317e-02f, 3.82444523e-02f, 7.25171864e-02f, 5.36797419e-02f,
  4.28558402e-02f, 3.34596746e-02f, -1.71003733e-02f, -1.01657875e-01f, -2.67570019e-02f, -2.88944263e-02f, -4.92650382e-02f, -5.99392653e-02f, -1.93248075e-02f, 3.49362195e-02f,
  -2.37473454e-02f, -3.45527641e-02f, 1.64521765e-02f, 5.04983682e-03f, 3.99760865e-02f, 3.32897226e-03f, 3.92898219e-03f, -4.89583388e-02f, 2.68802345e-02f, 9.92751941e-02f,
  1.08503439e-02f, -8.31849873e-02f, -1.64261922e-01f, -1.31321982e-01f, -1.16077755e-02f, -1.09813854e-01f, -1.19099021e-01f, -6.67738467e-02f, -3.70662101e-02f, 3.94357368e-02f,
  -8.39551464e-02f, -1.83132924e-02f, -1.26656964e-01f, -2.20507588e-02f, 5.84711656e-02f, -1.00183353e-01f, -3.28475498e-02f, 2.58986000e-03f, -7.31328502e-02f, -5.22004515e-02f,
  -1.42305821e-01f, -2.44623467e-01f, -2.13239729e-01f, -1.31430373e-01f, -1.71245635e-01f, -7.66270142e-03f, 2.12616641e-02f, -2.42770091e-01f, -1.71001866e-01f, -4.93346602e-02f,
  7.44061768e-02f, -7.39269406e-02f, -9.46067423e-02f, -7.98246339e-02f, 1.96911022e-02f, -7.64789507e-02f, -7.84496740e-02f, -7.08263963e-02f, -1.27260357e-01f, -6.06983081e-02f,
  -3.94180834e-01f, 1.83232985e-02f, -1.03285827e-01f, -8.90067890e-02f, -1.48932010e-01f, -1.87999189e-01f, -1.76109761e-01f, -7.74001777e-02f, -3.54226232e-02f, -1.42720655e-01f,
  -7.90861994e-02f, -9.14140604e-03f, -5.72277158e-02f, -7.33627975e-02f, -8.19245204e-02f, -4.33937944e-02f, -8.54695812e-02f, -1.55051053e-02f, -1.02748349e-01f, -3.41016948e-02f,
  2.66134329e-02f, -8.36108625e-03f, -1.44854411e-01f, -1.01179086e-01f, -1.08231731e-01f, -1.38437510e-01f, -7.34701976e-02f, -5.47448620e-02f, -7.77632594e-02f, -1.50652185e-01f,
  -2.15367228e-02f, 2.49503683e-02f, 1.44131230e-02f, 2.14312691e-02f, 9.30082723e-02f, -5.72394859e-03f, 5.12831248e-02f, 5.56896776e-02f, 9.34908316e-02f, 8.74660760e-02f,
  5.48311695e-02f, -7.94954598e-03f, -2.68614013e-02f, -3.83178852e-02f, -2.78992373e-02f, -3.89213078e-02f, -3.71139757e-02f, 1.82936108e-03f, 1.55380964e-02f, -2.54071672e-02f,
  7.38808960e-02f, 6.74989149e-02f, -4.52021696e-03f, 8.39627534e-03f, -7.92207271e-02f, 1.84511282e-02f, -1.72810536e-02f, 1.13840904e-02f, -2.53050327e-02f, -3.25851552e-02f,
  -2.69260317e-01f, -1.35205030e-01f, -5.46017773e-02f, -6.34748489e-02f, -9.93580446e-02f, -4.98504415e-02f, -5.76329567e-02f, -8.88898745e-02f, -1.04357302e-01f, -4.80749458e-02f,
  -4.09772433e-02f, -5.45444675e-02f, -1.43837750e-01f, -2.98043005e-02f, -9.19004753e-02f, -6.29777508e-03f, -1.95169728e-03f, -1.40430152e-01f, -7.70967603e-02f, -4.20280322e-02f,
  -7.17267394e-02f, -1.51973441e-01f, -1.28370345e-01f, -1.27329901e-01f, -5.35808764e-02f, -1.10956632e-01f, -8.74704942e-02f, -6.75609633e-02f, -9.10301507e-02f, -1.76499307e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.40280151e-02f, -2.09918052e-01f, 3.72975096e-02f, 4.39016104e-01f, 3.28758955e-01f, 3.37604731e-01f, 2.51336813e-01f, 1.27444848e-01f, 1.93901241e-01f, 6.75161108e-02f,
  -7.20012886e-03f, 1.07318051e-01f, 1.46020362e-02f, 2.47955211e-02f, -2.96918908e-03f, 1.45965800e-01f, 2.60004729e-01f, 4.91114594e-02f, 1.05938874e-01f, 1.66184932e-01f,
  8.85860622e-02f, 1.13765709e-01f, 4.60983776e-02f, 5.64321540e-02f, -3.71955000e-02f, 1.84800774e-01f, -2.92912219e-02f, -4.90552336e-02f, -9.82007459e-02f, 6.32559508e-02f,
  -2.40287706e-01f, -1.80492103e-01f, 1.02524146e-01f, -1.18047908e-01f, -2.07884476e-01f, -1.60118416e-01f, 3.61111481e-03f, -2.47226339e-02f, 2.43379623e-02f, -4.46472093e-02f,
  -1.04854092e-01f, -2.03524515e-01f, 3.09206787e-02f, -3.03620882e-02f, -3.31207924e-02f, -3.67177129e-02f, -1.63432837e-01f, -9.26777348e-02f, -1.01713538e-01f, -1.95698723e-01f,
  -5.34686036e-02f, -4.71080430e-02f, -3.40531580e-02f, 1.82865188e-02f, -8.37225839e-02f, 2.96088308e-03f, -1.93805158e-01f, -1.75421417e-01f, -4.52622958e-02f, -1.24837890e-01f,
  9.93940160e-02f, -2.91506629e-02f, -1.37467068e-02f, -8.08727294e-02f, 5.41549455e-03f, 1.00567743e-01f, -3.73041667e-02f, -7.08312392e-02f, 7.96787739e-02f, -4.80894782e-02f,
  -8.84491876e-02f, 6.68543652e-02f, -8.76068100e-02f, 3.42542790e-02f, 4.20608632e-02f, -1.32294754e-02f, -7.16685206e-02f, -1.47909507e-01f, -1.18465848e-01f, 9.26708877e-02f,
  3.62656042e-02f, -7.86864609e-02f, -5.54505624e-02f, -5.59310131e-02f, -9.07720923e-02f, -4.19784859e-02f, -2.89611472e-03f, -2.37585045e-02f, -8.87493566e-02f, -8.31890330e-02f,
  -3.92364711e-02f, -2.96688024e-02f, 1.02246985e-01f, -9.17793512e-02f, -6.59465045e-02f, -1.31787956e-01f, 5.40252663e-02f, 2.93059088e-02f, -5.40955104e-02f, 2.43881457e-02f,
  -4.47902782e-03f, -5.26553094e-02f, -1.36960879e-01f, -7.56928772e-02f, 2.39459909e-02f, 1.09186247e-02f, -6.30344730e-03f, -6.83031678e-02f, -4.86527272e-02f, -1.19889081e-01f,
  -6.94122761e-02f, 1.13284416e-01f, 1.49626672e-01f, 7.48561397e-02f, 3.98778059e-02f, 2.30725959e-01f, 1.06396645e-01f, 9.26876515e-02f, 3.96534838e-02f, 1.74026594e-01f,
  5.67816615e-01f, -1.80138558e-01f, -2.89988875e-01f, 2.24613115e-01f, -2.08111778e-01f, -1.69930413e-01f, -2.29157344e-01f, 1.18725598e-01f, 1.30623534e-01f, -2.09910572e-01f,
  -5.30290566e-02f, 3.38707477e-01f, 1.25893325e-01f, 1.18474074e-01f, 1.51897445e-01f, -2.64441252e-01f, -3.19779843e-01f, -1.24579906e-01f, 1.00908965e-01f, -2.28125304e-02f,
  -1.08241521e-01f, -3.87870446e-02f, 7.41870552e-02f, -5.42271398e-02f, -1.58290550e-01f, 3.01030502e-02f, -3.17193955e-01f, -1.97653413e-01f, -2.82930642e-01f, -3.90789568e-01f,
  -6.53418712e-03f, -1.54912416e-02f, -7.30004832e-02f, 2.10621823e-02f, -3.53513099e-02f, 1.66002840e-01f, 2.48062156e-06f, -1.44765601e-01f, -7.67342886e-03f, -4.29941267e-02f,
  -3.81995626e-02f, -3.88647406e-03f, 3.99027914e-02f, 5.77962771e-02f, -3.59072722e-02f, 3.52944434e-02f, -3.12359948e-02f, -1.00015901e-01f, -4.61015776e-02f, -8.13987106e-02f,
  -1.63497657e-01f, -1.17725365e-01f, -1.05305903e-01f, -1.22073047e-01f, -9.54765454e-02f, -3.88791859e-02f, -1.67402834e-01f, -1.41226485e-01f, -1.18061483e-01f, -2.61653453e-01f,
  -1.36917839e-02f, -6.94742128e-02f, -7.34579414e-02f, -5.81787042e-02f, -6.67806715e-03f, -3.90314795e-02f, 2.95880958e-02f, -3.71477082e-02f, -8.98138806e-02f, -7.38717709e-03f,
  6.76496923e-02f, -8.92413873e-03f, 3.71264922e-03f, -4.25899476e-02f, -8.55121315e-02f, -1.05741680e-01f, -4.75411862e-02f, -8.40901285e-02f, -7.86984637e-02f, -3.19562443e-02f,
  1.47677986e-02f, -1.81552917e-02f, 6.80541843e-02f, 1.21042058e-02f, -8.48802924e-02f, -3.73648331e-02f, 5.97571395e-02f, -4.98228967e-02f, 6.42511770e-02f, -1.96375623e-02f,
  3.30117971e-01f, 2.48890799e-02f, 7.07461983e-02f, -1.13084264e-01f, -7.97451846e-03f, -5.08147888e-02f, -3.99838388e-02f, -1.08680204e-01f, 1.03619784e-01f, 4.40456495e-02f,
  -8.96300003e-02f, 1.57889679e-01f, 2.38520484e-02f, 2.17811298e-02f, -3.65405865e-02f, 3.47011932e-03f, 2.12404262e-02f, -6.35185912e-02f, -1.22531593e-01f, -4.72250059e-02f,
  -6.94660619e-02f, -2.64443662e-02f, 1.51760355e-01f, -4.10555415e-02f, -2.39472706e-02f, 1.85870767e-01f, -1.19316749e-01f, -8.38886276e-02f, 8.98203105e-02f, -6.14810698e-02f,
  3.79249454e-01f, 1.37443990e-01f, 1.83887109e-01f, 1.23174317e-01f, 4.55643311e-02f, 1.77508980e-01f, 2.26415694e-01f, 1.21747054e-01f, -6.99526519e-02f, 1.41718462e-01f,
  1.49504915e-01f, 4.85230498e-02f, 7.95741156e-02f, -2.91381571e-02f, -5.26961647e-02f, -4.05255668e-02f, -9.25846025e-02f, -3.34138254e-04f, -1.08796895e-01f, -7.57634044e-02f,
  -8.65095928e-02f, -2.74666660e-02f, 1.59058183e-01f, 1.16834594e-02f, -1.07894637e-01f, -3.26061249e-02f, 1.16631746e-01f, 7.00311810e-02f, -9.73546039e-03f, -2.90800393e-01f,
  -1.66839510e-01f, 2.49873370e-01f, -2.01782808e-01f, -1.34679645e-01f, 4.06316556e-02f, -6.42412454e-02f, 4.86345179e-02f, -5.84134758e-02f, -2.19780710e-02f, -6.53347522e-02f,
  5.85200377e-02f, 3.29764150e-02f, 3.51868235e-02f, -4.43422847e-04f, 3.10679916e-02f, 1.03945322e-01f, 1.49755016e-01f, 7.23053813e-02f, 7.82263577e-02f, 6.19409755e-02f,
  4.97894213e-02f, 9.43101048e-02f, 7.51373768e-02f, -8.15627351e-02f, 2.12487020e-02f, -3.38879302e-02f, -3.55978101e-03f, 5.29303448e-03f, 1.51521722e-02f, 7.04391301e-02f,
  -5.12015410e-02f, 5.38998470e-02f, -4.01085848e-03f, 5.69346733e-02f, -1.20282751e-02f, 1.48009628e-01f, 1.25678638e-02f, -2.02341322e-02f, 3.46100964e-02f, 1.00979187e-01f,
  1.02620073e-01f, 5.18025570e-02f, 1.45192087e-01f, 7.38002956e-02f, 1.05001800e-01f, 8.54614228e-02f, 5.30068502e-02f, 2.13452778e-03f, 3.26051675e-02f, 1.42903673e-02f,
  2.92521864e-02f, 1.55829294e-02f, 1.74283698e-01f, 9.03523341e-02f, 3.21806371e-02f, 1.38617888e-01f, 7.32360000e-04f, 3.67732011e-02f, 1.46083891e-01f, 5.18229604e-02f,
  -1.87649161e-01f, 1.29343554e-01f, -1.60067961e-01f, -1.43075744e-02f, -6.37567602e-03f, 8.81832540e-02f, 7.89803565e-02f, -3.94450836e-02f, -1.43682972e-01f, 1.82227995e-02f,
  -1.48586035e-02f, 2.85341218e-02f, 1.30226225e-01f, 2.06585377e-02f, 8.60353634e-02f, -1.68668255e-02f, 4.61621117e-03f, -5.84910512e-02f, -1.15023986e-01f, 9.00720712e-03f,
  2.83595212e-02f, -2.47009434e-02f, 6.68408442e-03f, 1.77652556e-02f, -1.99288763e-02f, -1.85157079e-02f, -6.19110763e-02f, 9.66685172e-03f, -3.51492572e-03f, 4.98870295e-03f,
  4.70048249e-01f, -4.56856847e-01f, 2.51420075e-04f, 5.14995120e-02f, 1.06532365e-01f, 2.06546754e-01f, 4.56604585e-02f, 2.53478345e-02f, 1.30231589e-01f, -1.20191641e-01f,
  -5.38129918e-02f, 1.24910466e-01f, 3.00299730e-02f, 8.05622041e-02f, 8.48788396e-02f, -9.90922973e-02f, -1.25544861e-01f, 1.98375762e-01f, 4.48966205e-01f, 1.82931408e-01f,
  5.97211495e-02f, -1.32970110e-01f, -7.95349404e-02f, -2.69258413e-02f, -2.64299363e-01f, -8.74387249e-02f, -3.60908568e-01f, -1.69046968e-01f, -2.04744413e-01f, -2.96997517e-01f,
  -5.37015125e-02f, -1.82767566e-02f, 7.41078034e-02f, -1.31208599e-01f, -1.77633762e-01f, 6.99181408e-02f, 7.12565184e-02f, -1.46844313e-01f, 3.86161692e-02f, -2.88220644e-02f,
  7.84686022e-03f, 4.22030389e-02f, 3.55136697e-03f, -1.07085541e-01f, -1.15134910e-01f, 7.60429129e-02f, -2.71951854e-01f, -7.57431760e-02f, -2.22542137e-02f, -7.17807412e-02f,
  -1.50747910e-01f, -4.08117063e-02f, -6.15506759e-03f, -9.43575278e-02f, 2.47048642e-02f, 1.15871869e-01f, -1.72750354e-01f, 2.58153602e-02f, -3.60693969e-02f, -8.94713700e-02f,
  -5.42114303e-02f, -2.62047853e-02f, 6.73286170e-02f, 1.55737568e-02f, -1.30045470e-02f, 5.22558726e-02f, -1.97716542e-02f, 8.35120585e-03f, 5.80257475e-02f, -5.49666472e-02f,
  -4.09121178e-02f, 3.53520773e-02f, 1.77876651e-02f, 1.64731778e-02f, -5.14408238e-02f, 7.27969036e-02f, 7.06445947e-02f, -9.41029415e-02f, 6.25153929e-02f, 1.14671998e-01f,
  1.20817594e-01f, 2.49849949e-02f, 1.80154387e-02f, -1.62893068e-02f, 7.10170642e-02f, 8.13695565e-02f, 6.50477186e-02f, -1.11407237e-04f, -8.97944421e-02f, 1.79050714e-02f,
  -1.15492292e-01f, 1.02823123e-01f, 1.73506942e-02f, -7.37062236e-03f, -2.63223909e-02f, -3.71880047e-02f, 4.43133302e-02f, -6.25967458e-02f, -7.53142536e-02f, -2.48817410e-02f,
  -1.24100104e-01f, -5.58835603e-02f, -7.89226592e-02f, -6.13252893e-02f, 1.18063845e-01f, 4.61260974e-02f, -1.60656422e-01f, 5.59538864e-02f, 3.50340270e-02f, -1.94067508e-02f,
  -1.00586846e-01f, 1.65246904e-01f, 2.25341454e-01f, 1.11211106e-01f, 2.83505358e-02f, 1.78115994e-01f, 2.17504222e-02f, 1.55729532e-01f, 2.35306948e-01f, 9.39790830e-02f,
  -3.32891762e-01f, -5.56655414e-02f, 2.70539280e-02f, -4.02457356e-01f, -1.70723125e-01f, -1.00752851e-02f, -8.72683711e-03f, -9.37433615e-02f, -2.03833044e-01f, -5.90905994e-02f,
  2.59283092e-02f, 1.58729315e-01f, 1.23442769e-01f, 1.72214106e-01f, 1.45976931e-01f, -5.81225976e-02f, -1.35137811e-01f, 7.06403106e-02f, 2.69770861e-01f, 7.66967982e-02f,
  5.57597429e-02f, -1.59905672e-01f, -1.22587748e-01f, -8.85517001e-02f, -1.52715951e-01f, 7.05188960e-02f, -7.96494707e-02f, -2.01632977e-01f, -4.00546379e-02f, -1.73126072e-01f,
  3.61734211e-01f, -1.77882776e-01f, -3.68660726e-02f, -6.51670098e-02f, -6.14312217e-02f, 1.49127860e-02f, -1.56144081e-02f, -9.13942903e-02f, -9.54023898e-02f, -6.24392107e-02f,
  -1.14634089e-01f, -3.42835002e-02f, 5.49096614e-02f, 8.31836611e-02f, -1.20673031e-02f, 5.15164435e-02f, -1.02924153e-01f, -2.52671335e-02f, -4.90951389e-02f, 6.76888674e-02f,
  -6.32123873e-02f, -7.11685941e-02f, 1.55618403e-03f, 3.02189793e-02f, 7.66695477e-03f, -6.07193671e-02f, 1.08685801e-02f, -1.07419945e-01f, -3.43534313e-02f, 1.17674668e-03f,
  -2.82771569e-02f, -6.47805184e-02f, -7.55019039e-02f, 1.24782026e-02f, 5.74613456e-03f, -2.77889874e-02f, 4.64159762e-03f, 8.66950899e-02f, 1.45521415e-02f, 2.98501048e-02f,
  -9.78688337e-03f, -4.44793813e-02f, -4.87140119e-02f, -5.25381602e-02f, -7.56684840e-02f, -8.02144483e-02f, 1.10321902e-02f, -2.52246321e-03f, -4.42402326e-02f, -6.30618259e-02f,
  -3.72781008e-02f, -9.43440273e-02f, -5.61434356e-03f, 3.57765816e-02f, -3.55461128e-02f, 1.96870286e-02f, -6.60197139e-02f, 1.36325404e-01f, 1.06372960e-01f, -3.99467200e-02f,
  2.37928227e-01f, -1.19515546e-01f, 4.65858867e-03f, 1.42520508e-02f, -5.92362974e-03f, 1.34357353e-04f, -7.09757581e-02f, -1.56079531e-02f, -4.94186096e-02f, 5.55010550e-02f,
  -1.54317701e-02f, 7.18650594e-02f, -6.16546860e-03f, -5.26274219e-02f, -1.85863879e-02f, 4.37581427e-02f, -3.50916870e-02f, 6.59055412e-02f, -3.34717706e-02f, -1.94548909e-02f,
  -1.49917528e-01f, 2.53524967e-02f, 1.11805633e-01f, 9.33323875e-02f, -1.55053986e-02f, 5.35842851e-02f, 1.43732652e-01f, 1.39792562e-01f, 1.37780681e-01f, 1.32722840e-01f,
  -9.85596105e-02f, 2.12281093e-01f, -1.00500196e-01f, 1.77903503e-01f, 4.35453244e-02f, 1.36296274e-02f, 2.36173738e-02f, 3.90444510e-02f, 9.96191129e-02f, 4.44540344e-02f,
  -3.58387157e-02f, 6.08128496e-02f, 1.87991709e-01f, 2.14928314e-01f, 8.10575560e-02f, 1.65870234e-01f, 3.25031132e-01f, 1.62044168e-01f, 1.41684059e-02f, 4.95040379e-02f,
  2.27936357e-01f, 5.99714033e-02f, -7.81901553e-03f, 1.30003557e-01f, 2.27649570e-01f, 1.07659772e-01f, 8.04178715e-02f, 1.33483335e-01f, 1.64605245e-01f, 3.41649473e-01f,
  -3.06953155e-02f, -4.76396047e-02f, -1.63677737e-01f, -1.10077180e-01f, -1.02074124e-01f, 6.93761408e-02f, -2.69460049e-03f, 3.88522595e-02f, -1.06726773e-02f, 1.03206806e-01f,
  -3.81384864e-02f, -4.85759005e-02f, 1.13517992e-01f, 1.08792059e-01f, -7.86686596e-03f, 7.82714970e-03f, 3.44237089e-02f, 6.05498776e-02f, -1.16004236e-01f, -1.41254449e-02f,
  3.07427257e-01f, 3.76828276e-02f, -1.66135028e-01f, -7.11958632e-02f, -1.35586947e-01f, -1.19558126e-01f, -2.02287138e-01f, -7.02988505e-02f, -1.81465492e-01f, 6.69717789e-02f,
  -2.27969810e-02f, -6.59577399e-02f, -2.81780958e-02f, 8.70751739e-02f, 2.79131788e-03f, -5.69893885e-03f, 5.31238168e-02f, -7.77540915e-03f, 6.72241533e-03f, 1.79168768e-02f,
  8.23648050e-02f, -1.51499808e-01f, 2.33674492e-03f, 1.29257459e-02f, -3.55394930e-02f, 2.26286799e-03f, -1.93770416e-02f, -8.81914888e-03f, -1.82899415e-01f, -1.80833787e-01f,
  -9.35054570e-02f, -1.26565853e-02f, -6.54294118e-02f, 7.42537901e-02f, -3.82161490e-03f, -1.39477715e-01f, -9.30517316e-02f, -6.48605302e-02f, -5.61823649e-03f, 7.43628442e-02f,
  -1.35563556e-02f, -2.34447286e-01f, -1.22764997e-01f, -9.25333332e-03f, -9.54062045e-02f, -7.77740031e-02f, 2.72443257e-02f, -4.65924926e-02f, -3.95254865e-02f, -7.03753904e-02f,
  -1.60064504e-01f, -6.56661540e-02f, 2.51604524e-02f, 2.12616045e-02f, -7.74373254e-03f, -9.91230384e-02f, 4.70888130e-02f, -6.25618093e-04f, -6.58033937e-02f, -1.24770124e-02f,
  6.96871504e-02f, -1.07089616e-01f, -1.24892451e-01f, -5.85785061e-02f, -3.04281674e-02f, -1.74951538e-01f, -1.50407135e-01f, -1.58191204e-01f, -3.09624642e-01f, -1.17084779e-01f,
  6.17452599e-02f, 1.34807721e-01f, 3.74633342e-01f, -1.18455559e-01f, -3.75299007e-01f, -3.07547539e-01f, -2.29895398e-01f, -1.16201445e-01f, -8.71148482e-02f, 1.91225875e-02f,
  -9.09597501e-02f, -2.30122656e-01f, 7.26247728e-02f, -8.81748199e-02f, -2.01181695e-03f, 8.42362046e-02f, 2.36360803e-01f, 2.01830700e-01f, -1.69994608e-01f, -2.90104985e-01f,
  -3.38557273e-01f, -1.14066206e-01f, 5.47168031e-02f, 5.33305220e-02f, 1.32648706e-01f, 6.91718934e-03f, 2.22955748e-01f, 5.45254909e-02f, 1.38242483e-01f, 3.26183021e-01f,
  1.53475940e-01f, 3.24159354e-01f, -1.69157699e-01f, -1.89061224e-01f, -1.12962142e-01f, 1.49113968e-01f, -5.04187215e-03f, 1.00520648e-01f, -4.57914220e-03f, 1.03999734e-01f,
  -1.87025204e-01f, -3.69925648e-02f, -9.48745757e-02f, -9.11639556e-02f, -1.24088377e-01f, -3.28118056e-02f, 1.66875884e-01f, 1.35195896e-01f, 1.56583771e-01f, 7.12983832e-02f,
  -3.06177109e-01f, -1.50333002e-01f, -1.94460358e-02f, 2.84264144e-02f, 2.30375618e-01f, -6.72538280e-02f, -1.75476773e-03f, 8.79499689e-02f, 1.30191639e-01f, 2.93735981e-01f,
  -2.40251403e-02f, -2.49445215e-02f, -8.94065201e-02f, 5.83007298e-02f, -4.53673340e-02f, 1.69606716e-03f, 1.20050050e-01f, -9.45312157e-02f, -1.35466997e-02f, 3.48001905e-02f,
  4.99855727e-02f, 4.89763059e-02f, -7.27756321e-02f, 9.47714970e-02f, -1.45278787e-02f, -9.57866199e-03f, -1.36874691e-02f, 6.70382902e-02f, 3.01483134e-03f, 9.23715625e-03f,
  -5.91104887e-02f, 4.42620590e-02f, -8.22929218e-02f, 9.85957682e-02f, 5.75050227e-02f, 8.78838822e-02f, 5.01379631e-02f, 1.21294511e-02f, 1.44273918e-02f, 6.01437725e-02f,
  -2.65478700e-01f, -1.92842156e-01f, -5.52496910e-02f, 2.54057944e-02f, -8.50710869e-02f, -7.18939006e-02f, 3.01976241e-02f, -9.43543017e-02f, -7.32684731e-02f, 2.60176789e-02f,
  -1.46974064e-03f, 6.52972013e-02f, 8.76032636e-02f, -5.13828360e-02f, -1.56291902e-01f, -1.43365875e-01f, -2.64875889e-01f, -1.06972963e-01f, -1.74392924e-01f, -4.07540053e-02f,
  -6.98469728e-02f, -3.29023063e-01f, -4.45942730e-01f, -1.98097885e-01f, -1.03018031e-01f, -3.20469588e-01f, -1.44250140e-01f, -2.18522698e-01f, -1.74295723e-01f, -1.27707094e-01f,
  -2.07212538e-01f, -2.94047803e-01f, -2.78019726e-01f, -4.00450230e-01f, -2.07494304e-01f, 1.16595831e-02f, -6.79668412e-02f, -1.11666851e-01f, -1.73617482e-01f, -2.82515615e-01f,
  -7.40171596e-02f, -6.94223195e-02f, -1.36562482e-01f, -8.95369276e-02f, 3.13423946e-02f, -1.95187673e-01f, -1.68093100e-01f, 4.07463498e-02f, 2.61863410e-01f, 2.29367524e-01f,
  5.82312308e-02f, -2.73170341e-02f, -2.32012607e-02f, 7.87958801e-02f, -2.43896708e-01f, -8.05877224e-02f, -2.50327229e-01f, -1.71712473e-01f, -4.88309711e-02f, -3.12245429e-01f,
  -1.18666857e-01f, -1.42601803e-01f, -2.51823999e-02f, 1.63488761e-02f, -1.26932979e-01f, -5.40730730e-02f, -3.16694379e-02f, -1.20029151e-01f, -5.22209704e-02f, -7.69735873e-02f,
  -1.15619652e-01f, 5.73138557e-02f, -9.60740671e-02f, -1.68365210e-01f, -8.46680701e-02f, -5.38378693e-02f, -8.13138857e-02f, 2.63101608e-02f, 2.95375381e-02f, 4.78664823e-02f,
  1.38232941e-02f, 5.08737378e-02f, 5.38160726e-02f, -2.74803936e-02f, 4.36799563e-02f, 2.58849724e-03f, 5.37248701e-02f, 8.09035078e-02f, 1.22457691e-01f, -4.64518107e-02f,
  7.72852600e-02f, -1.78925470e-02f, -1.41977647e-03f, 1.65626907e-03f, 8.46261537e-05f, 3.57668027e-02f, -5.47439270e-02f, -6.49289861e-02f, 1.25696212e-01f, 1.74222905e-02f,
  2.01143958e-02f, 6.09006584e-02f, 7.76796862e-02f, -1.68447923e-02f, -1.73399951e-02f, -1.93982385e-02f, 9.86810625e-02f, 4.71754447e-02f, 5.36723584e-02f, 3.64915607e-03f,
  -1.09096523e-03f, 8.95153545e-03f, -7.25469738e-02f, 5.33720590e-02f, 8.10123906e-02f, 4.27764542e-02f, -2.06213128e-02f, 7.65769631e-02f, 8.34553316e-03f, -3.37306745e-02f,
  -1.53783664e-01f, 7.90341944e-02f, -1.00774772e-01f, 2.55870596e-02f, 1.18025616e-02f, 2.24875752e-02f, -1.31807104e-01f, -6.24556094e-03f, -2.13513717e-01f, -5.77647984e-02f,
  5.17249182e-02f, 3.75128421e-03f, -7.73559734e-02f, -4.19415906e-02f, 8.25620070e-02f, 5.13835736e-02f, 1.02314599e-01f, -3.48416530e-02f, 3.19912732e-02f, 7.64554068e-02f,
  4.71266769e-02f, 1.36182249e-01f, 6.66164011e-02f, 8.46826751e-03f, 7.19104484e-02f, 1.28567353e-01f, 2.96982657e-02f, 1.64036930e-01f, 1.37855440e-01f, 5.86845875e-02f,
  -1.62923545e-01f, -8.60523880e-02f, -2.06517652e-01f, -1.46153957e-01f, -3.40657588e-03f, -6.31263107e-02f, -2.79068589e-01f, -1.16396852e-01f, 1.22258112e-01f, -3.90835106e-02f,
  7.61732534e-02f, 8.91463980e-02f, -1.32920578e-01f, -1.88948229e-01f, -3.87907177e-01f, -4.02295291e-01f, -3.66787225e-01f, -3.31060022e-01f, -1.42522469e-01f, 1.34736687e-01f,
  1.22897364e-01f, -4.04991694e-02f, -1.07959628e-01f, -9.17418599e-02f, 2.76604947e-02f, -4.10546847e-02f, -1.21635348e-01f, -7.40578696e-02f, -9.60826278e-02f, -1.95560649e-01f,
  -1.03313932e-02f, -1.70796569e-02f, 9.94169191e-02f, -9.56031010e-02f, 2.99302675e-02f, 4.93789911e-02f, 4.12967503e-02f, 6.94510564e-02f, 6.92039952e-02f, -7.58090466e-02f,
  -6.01737686e-02f, 7.17646256e-02f, 8.21666233e-03f, -2.28378195e-02f, 3.19484696e-02f, -2.63936128e-02f, -1.21304214e-01f, -1.15290992e-01f, -1.10834830e-01f, 5.33756576e-02f,
  -2.09942516e-02f, -4.07909602e-02f, -2.00246543e-01f, -1.70977518e-01f, -8.21435004e-02f, -1.24785900e-01f, -1.39019210e-02f, 2.97346599e-02f, -1.78443283e-01f, -2.03668565e-01f,
  5.34927621e-02f, 3.87998782e-02f, 3.17466110e-02f, 2.63318326e-02f, 4.49803937e-03f, 1.74081121e-02f, 1.42511278e-02f, -8.00688863e-02f, 1.86947808e-02f, -2.71780975e-02f,
  1.13924712e-01f, -2.59349160e-02f, 6.69440031e-02f, -8.73390883e-02f, -9.98299792e-02f, -1.04165800e-01f, 8.60241533e-04f, -7.69252181e-02f, -3.72687541e-02f, -4.14820425e-02f,
  -2.84095258e-02f, 2.27519218e-02f, 9.78579670e-02f, -3.23437005e-02f, -4.66345921e-02f, -1.34382239e-02f, 7.60701522e-02f, 3.92210372e-02f, -1.44214742e-02f, 2.96892524e-02f,
  -7.22005069e-02f, -2.19100118e-02f, 8.00750498e-03f, -1.53349683e-01f, -8.90445039e-02f, 6.40221313e-02f, -4.49907297e-04f, 1.36098417e-03f, 1.03331402e-01f, 7.73845613e-02f,
  -3.73213962e-02f, 9.61886719e-03f, 3.65053341e-02f, -1.08644910e-01f, -1.93606652e-02f, -5.51477447e-02f, -2.15727523e-01f, -1.79976925e-01f, -1.58974826e-01f, 1.36785522e-01f,
  -1.80695429e-01f, -3.06250483e-01f, -3.32316279e-01f, -2.56652802e-01f, -8.25167969e-02f, -2.32542083e-01f, -1.79730311e-01f, -5.58469258e-02f, -2.42761657e-01f, -3.52429420e-01f,
  3.40675056e-01f, 8.68857503e-02f, 2.15245277e-01f, -1.17315408e-02f, 7.18951225e-02f, 1.40416905e-01f, 1.20520741e-01f, 4.83347028e-02f, 1.33745894e-02f, 5.21963537e-02f,
  1.52368069e-01f, 6.26272038e-02f, 2.43345015e-02f, 1.39092818e-01f, 6.75989985e-02f, 4.82559844e-04f, 2.57874709e-02f, 1.63409233e-01f, 1.34078890e-01f, 2.20390558e-01f,
  2.03528497e-02f, 5.41047715e-02f, 1.52952954e-01f, -5.04845171e-04f, -6.06214851e-02f, -1.61890183e-02f, 7.06548467e-02f, 7.95309693e-02f, 4.62952293e-02f, 1.37951905e-02f,
  3.34682733e-01f, 1.36000261e-01f, 6.48002774e-02f, -7.31818154e-02f, -9.08850804e-02f, 1.87844001e-02f, -2.41240021e-02f, -5.26784696e-02f, -1.08581901e-01f, 4.99096140e-02f,
  9.85464826e-03f, -4.14524786e-02f, -1.72991902e-01f, -1.12874294e-02f, -1.06558036e-02f, 1.43425046e-02f, -6.09122403e-02f, 8.97366554e-02f, -1.24822473e-02f, 1.00630797e-01f,
  -1.33111104e-01f, -8.79499391e-02f, 2.22563669e-02f, 5.03765466e-03f, -1.17889509e-01f, 1.65697280e-02f, 4.51443829e-02f, -6.25094306e-03f, 9.20294821e-02f, -4.49638851e-02f,
  4.92459498e-02f, 3.63326222e-02f, -2.04281807e-02f, -3.96174416e-02f, 2.06340943e-02f, 8.03663954e-02f, -1.16132917e-02f, 3.84339131e-02f, 5.77924885e-02f, -3.09585799e-02f,
  -2.75464933e-02f, 7.07553178e-02f, -1.02962460e-02f, 4.74336632e-02f, 3.08620767e-03f, 4.22879085e-02f, -3.80610935e-02f, 2.10094033e-03f, -5.61711639e-02f, 3.27012055e-02f,
  7.27568492e-02f, 8.85796472e-02f, -8.07495043e-03f, -9.22042970e-03f, 4.80477661e-02f, 5.50693944e-02f, -6.03692569e-02f, -1.48704201e-01f, -9.09298211e-02f, -2.66957227e-02f,
  6.68974519e-02f, -1.72044244e-02f, 1.20417438e-01f, -1.97818987e-02f, -3.58419009e-02f, -9.72526446e-02f, 2.62681972e-02f, -9.94655341e-02f, -5.07424362e-02f, 1.48058251e-01f,
  6.43587410e-02f, 6.42507151e-02f, -7.40883201e-02f, -9.84022170e-02f, 5.66626899e-02f, -3.42395976e-02f, -1.34328842e-01f, 9.41046774e-02f, 7.56143779e-02f, -6.99456930e-02f,
  -1.04093790e-01f, 3.02647203e-02f, 9.31360275e-02f, 1.07293919e-01f, -5.10172546e-03f, -4.26754318e-02f, 1.21043570e-01f, 6.82722544e-03f, 6.93830252e-02f, 4.72835377e-02f,
  -2.90427268e-01f, -4.97624695e-01f, 1.85301200e-01f, -1.57541946e-01f, 2.88970351e-01f, 2.23591417e-01f, 3.13599497e-01f, 1.38577700e-01f, -4.74935491e-03f, -2.08844632e-01f,
  -3.57276112e-01f, -3.33908975e-01f, -3.71392012e-01f, -2.06741527e-01f, -1.74814180e-01f, 1.08848259e-01f, 1.86839759e-01f, 1.20280378e-01f, 3.29359472e-01f, 3.33359033e-01f,
  5.57147227e-02f, 3.92792337e-02f, -1.93493187e-01f, -6.33547008e-02f, -8.53899941e-02f, -8.88475403e-02f, -1.55203417e-01f, -1.25605822e-01f, -1.18763752e-01f, -2.12600246e-01f,
  1.48512408e-01f, -2.85388887e-01f, 1.13305762e-01f, -2.11868778e-01f, -5.61686419e-02f, -9.31660607e-02f, 2.59550549e-02f, -5.70076779e-02f, -1.35556400e-01f, -6.23044483e-02f,
  -1.73888147e-01f, -5.62460162e-02f, -1.10502332e-01f, -3.68685601e-03f, 4.36090529e-02f, 1.14713693e-02f, -6.83755726e-02f, -1.85191602e-01f, -1.01564154e-01f, -1.53131843e-01f,
  -1.62577689e-01f, -5.77422678e-02f, 2.21348982e-02f, -5.88430930e-03f, -1.68611467e-01f, 2.52270270e-02f, 4.85409833e-02f, -5.88748232e-02f, -1.50540574e-02f, -2.68169306e-02f,
  2.06829160e-01f, 6.44384474e-02f, -1.33020908e-01f, 1.51404785e-02f, 3.01356427e-02f, 5.41572385e-02f, 4.12767716e-02f, -2.10273415e-02f, -3.55862901e-02f, 2.04451177e-02f,
  -2.91145165e-02f, -1.27333134e-01f, -3.34104002e-02f, 5.32385036e-02f, -1.38854221e-01f, -9.98017937e-02f, -4.17622887e-02f, -1.41309977e-01f, -8.56134295e-02f, -7.73116276e-02f,
  -1.03487343e-01f, -8.39172676e-03f, 6.06278703e-03f, -1.27347112e-02f, -9.27293301e-02f, -1.01047829e-01f, -2.78508421e-02f, -4.95671555e-02f, 8.71150419e-02f, -7.77063370e-02f,
  5.94957806e-02f, -2.10037842e-01f, 9.44229141e-02f, -1.22780897e-01f, 1.99412648e-02f, -9.04192030e-02f, -1.97237462e-01f, 2.97563225e-02f, -1.18023068e-01f, 9.36628506e-02f,
  -6.87988773e-02f, 4.61006351e-02f, -8.37919861e-02f, 1.86074283e-02f, 1.67476788e-01f, 1.97729766e-01f, -7.01131299e-02f, 2.41508912e-02f, -3.75984460e-02f, 9.04107019e-02f,
  1.95465125e-02f, 1.85002580e-01f, 2.10575700e-01f, 6.29425794e-02f, 9.81205627e-02f, 1.53667703e-01f, 2.47419357e-01f, 1.97524965e-01f, 2.55190551e-01f, 2.69605756e-01f,
  3.25896353e-01f, -3.03118844e-02f, 2.14923337e-01f, 3.29105914e-01f, -1.40323699e-01f, -3.87700289e-01f, -6.25624597e-01f, -3.22237939e-01f, 7.46377110e-02f, -1.42362434e-02f,
  1.32351577e-01f, 8.70359540e-02f, 6.64487779e-02f, -1.30177900e-01f, -2.44108349e-01f, -1.17423020e-01f, 6.06763177e-03f, 3.96482982e-02f, -1.67754948e-01f, -1.36200786e-01f,
  -1.19360968e-01f, 1.11612447e-01f, 1.69838369e-01f, -1.25691695e-02f, 1.80230141e-01f, 4.12008949e-02f, 1.35310441e-01f, 1.87824085e-01f, 3.52964252e-02f, 3.83130074e-01f,
  3.30320120e-01f, 1.86595142e-01f, -2.97391355e-01f, 6.50439188e-02f, 2.44043112e-01f, 3.80088240e-02f, -8.93127471e-02f, 2.41231427e-01f, -2.68531442e-02f, -3.65612432e-02f,
  1.77010387e-01f, -2.81058718e-03f, 1.16275162e-01f, -1.80098619e-02f, -9.96448696e-02f, -2.27142408e-01f, -1.17086381e-01f, -6.76838309e-02f, -1.96263753e-02f, 6.02124743e-02f,
  2.29909811e-02f, 1.40236184e-01f, -3.41244750e-02f, -2.04381436e-01f, -1.04081079e-01f, -1.00743666e-01f, -2.00426161e-01f, 6.13174820e-03f, -2.37830997e-01f, -2.92563662e-02f,
  -9.90736187e-02f, 4.13302071e-02f, -9.04995278e-02f, -7.57654831e-02f, -9.17871818e-02f, -3.61161418e-02f, -2.68097338e-03f, -8.02058354e-02f, 2.19660029e-02f, 1.30376425e-02f,
  -9.65403691e-02f, 3.50685529e-02f, -3.76883075e-02f, -1.65935662e-02f, -2.83214543e-02f, -6.45944476e-02f, -7.11762682e-02f, -8.39188993e-02f, -1.83476545e-02f, 3.39981429e-02f,
  4.59128665e-03f, 5.41110151e-03f, 1.07467443e-01f, -7.92873204e-02f, 4.53548320e-03f, -2.54943371e-02f, -8.12990740e-02f, -6.11064881e-02f, -5.86737022e-02f, 2.68092472e-02f,
  -1.44196108e-01f, -2.20096633e-01f, -1.47878770e-02f, -1.37034029e-01f, 8.49980116e-02f, 2.07158606e-02f, -1.18620358e-02f, -7.57608265e-02f, 1.26196161e-01f, -4.91914265e-02f,
  -3.71592939e-02f, -8.91364366e-02f, 1.15075380e-01f, -1.15832090e-01f, -1.09041236e-01f, 1.98465288e-02f, -1.56069443e-01f, -5.38442917e-02f, -4.90969382e-02f, 5.24287373e-02f,
  -7.45164603e-02f, -2.28428468e-01f, -1.46662101e-01f, -2.37786248e-01f, -5.61405085e-02f, -2.59758860e-01f, -2.30629429e-01f, -1.79280758e-01f, -3.74586552e-01f, -3.82371694e-01f,
  -4.44011956e-01f, 5.57003856e-01f, 1.14810199e-01f, -3.05305094e-01f, 1.78746581e-01f, 3.47313523e-01f, 6.14274204e-01f, 1.88700855e-01f, -6.39424026e-02f, 2.41009310e-01f,
  2.83951551e-01f, -2.09155336e-01f, -4.19808589e-02f, -6.32605851e-02f, -5.10938698e-03f, 2.91741014e-01f, 8.54673833e-02f, -2.13888094e-01f, -3.44889909e-01f, -9.03750956e-02f,
  5.10992259e-02f, -2.10150391e-01f, -4.14280802e-01f, -2.60272533e-01f, -2.46809632e-01f, -3.26876909e-01f, -1.71180665e-02f, -1.19175361e-02f, 1.43276632e-01f, -1.52641281e-01f,
  -1.79217488e-01f, 8.58962908e-02f, -1.06947266e-01f, -1.51316404e-01f, 4.30405289e-02f, -1.57748654e-01f, 1.32436246e-01f, -3.38225216e-02f, 8.37747380e-02f, -2.53613316e-03f,
  -9.00708698e-03f, 2.41314434e-02f, 1.38024678e-02f, -1.21371269e-01f, -1.62970647e-01f, -1.29088327e-01f, -2.04666004e-01f, -1.40796214e-01f, -5.66651039e-02f, 1.18758753e-02f,
  2.09914267e-01f, 7.37491325e-02f, 3.60222557e-03f, 7.61495531e-02f, 1.25667021e-01f, -5.10208979e-02f, -1.66063011e-02f, -1.26807496e-01f, -7.88066089e-02f, -3.23554605e-01f,
  -4.39258432e-03f, -3.72499377e-02f, 3.00184507e-02f, 4.65056021e-03f, -6.69780374e-02f, 2.01830212e-02f, -7.08699524e-02f, 2.10542455e-02f, -2.05557910e-03f, -6.08161986e-02f,
  8.84755235e-03f, 6.64387345e-02f, -6.90020919e-02f, 7.16506317e-02f, -1.29616246e-01f, -8.57406035e-02f, 8.75214785e-02f, -1.51655721e-02f, -3.49152833e-02f, 9.93755534e-02f,
  -3.40067595e-02f, -4.11532335e-02f, 5.02887778e-02f, -1.10155940e-01f, 6.27387911e-02f, -1.81102362e-02f, -2.98826285e-02f, -3.69353965e-02f, -9.85684097e-02f, 9.73691270e-02f,
  -2.60283619e-01f, 1.87796429e-01f, -2.82242239e-01f, -1.96979232e-02f, -1.64290499e-02f, -7.52071515e-02f, -4.02816245e-03f, 1.34699149e-02f, 8.37131813e-02f, -7.43099600e-02f,
  2.95564961e-02f, -2.77853459e-02f, 1.24089099e-01f, -4.78368737e-02f, -1.37948200e-01f, -9.96947661e-02f, 2.22005416e-02f, -1.07058629e-01f, -3.23494375e-02f, 2.19928194e-02f,
  -6.84044138e-02f, -7.29236826e-02f, -2.65588462e-01f, -4.92956340e-02f, -4.76655364e-02f, -1.45933539e-01f, -2.44048163e-01f, -1.95013255e-01f, -9.13395286e-02f, -2.51091480e-01f,
  -2.34964207e-01f, -1.99498624e-01f, 2.18680143e-01f, -2.81783581e-01f, -1.28378525e-01f, 8.59048814e-02f, 1.25949681e-02f, -8.28551427e-02f, -9.94552150e-02f, -6.88868538e-02f,
  -8.61992501e-03f, 8.96582603e-02f, 1.22839220e-01f, 1.15369841e-01f, 1.44784227e-01f, 1.01617396e-01f, 6.30060881e-02f, 1.20400235e-01f, 1.99259818e-01f, -1.21785678e-01f,
  -1.26043826e-01f, -9.84252021e-02f, -1.96963236e-01f, -1.58732191e-01f, -2.07650706e-01f, -5.81993386e-02f, -1.29307322e-02f, -9.31432322e-02f, -1.94272604e-02f, -1.21887706e-01f,
  1.83723658e-01f, -2.71228924e-02f, -1.42668439e-02f, -1.11363873e-01f, -2.59434488e-02f, -5.02129048e-02f, 1.74276773e-02f, -9.70694870e-02f, -9.56465229e-02f, -1.05293691e-01f,
  6.61187395e-02f, -2.96669547e-02f, -4.64169830e-02f, -1.49334639e-01f, -3.57597731e-02f, -4.94026951e-02f, -1.87798455e-01f, -5.91340847e-02f, 7.93275386e-02f, -3.84682380e-02f,
  -1.18053101e-01f, 2.70165410e-02f, 1.81431040e-01f, 6.89994022e-02f, 1.93585586e-02f, 9.36789438e-02f, -1.84498485e-02f, -1.37227461e-01f, 1.84494630e-03f, -1.23094603e-01f,
  -6.18520081e-02f, 9.13109689e-04f, 5.81622012e-02f, 5.02096377e-02f, 8.49790722e-02f, 8.49641562e-02f, 1.19202837e-01f, 1.18154936e-01f, 7.83440545e-02f, 4.94865701e-03f,
  -6.39819950e-02f, 9.15016457e-02f, 6.65875971e-02f, -8.44038744e-03f, 7.44961649e-02f, 2.78667305e-02f, -1.45051805e-02f, -5.72785549e-02f, 6.60773292e-02f, -1.89320501e-02f,
  6.06691316e-02f, 2.92750038e-02f, -8.37517083e-02f, -1.91288665e-02f, -1.29599124e-01f, 1.49038378e-02f, 3.71464863e-02f, 2.64027603e-02f, -1.06524922e-01f, -9.35454741e-02f,
  2.13092640e-01f, 3.82496744e-01f, 1.12301044e-01f, 3.04288156e-02f, 4.93192971e-02f, -8.01148489e-02f, 1.19245611e-01f, -5.63809387e-02f, 8.08673799e-02f, 8.94676447e-02f,
  1.28952302e-02f, -3.85430753e-02f, 1.16639249e-01f, -1.80029236e-02f, -7.98968747e-02f, -2.95415632e-02f, 2.16842946e-02f, -3.37825343e-02f, 6.58595562e-02f, -8.90268758e-03f,
  -3.56986523e-02f, 2.18101069e-01f, 2.06979051e-01f, 1.80060029e-01f, 1.62070375e-02f, 1.75400257e-01f, 1.10011913e-01f, 1.15540050e-01f, 2.21763194e-01f, 7.59650469e-02f,
  -3.84887099e-01f, -2.11165413e-01f, -2.28762597e-01f, -3.58597606e-01f, -2.49142051e-01f, -1.54518262e-01f, -1.81940198e-02f, -8.54399651e-02f, -1.76975459e-01f, -1.48201451e-01f,
  9.28819459e-03f, -1.66333809e-01f, -1.27479225e-01f, -1.51908219e-01f, -1.88164383e-01f, -3.18076611e-01f, -3.98312032e-01f, -3.81247103e-01f, -2.75520772e-01f, -5.59412688e-02f,
  -1.94903389e-01f, -2.50653654e-01f, -1.63817540e-01f, -1.96428344e-01f, 1.98061038e-02f, -2.38600541e-02f, -7.66970739e-02f, -1.64766237e-01f, -6.18420541e-03f, -2.31989071e-01f,
  6.91732988e-02f, -5.13298623e-03f, 9.97995064e-02f, 2.15963405e-02f, 1.18129961e-01f, 7.21627399e-02f, 4.94284630e-02f, 1.08525082e-02f, 1.21539816e-01f, 1.09646678e-01f,
  -4.29447517e-02f, 3.95514406e-02f, 1.03221871e-01f, 1.79623857e-01f, -7.67776603e-03f, 1.19399838e-01f, 5.39454296e-02f, -2.19040341e-03f, 5.95721006e-02f, 1.09700292e-01f,
  1.29606545e-01f, 7.20326304e-02f, 6.02321252e-02f, 2.78769165e-01f, 1.31763190e-01f, -3.14770155e-02f, 1.82078734e-01f, 1.14189379e-01f, 1.71899170e-01f, 1.38143241e-01f,
  3.31504387e-03f, 3.16632651e-02f, 1.48986220e-01f, 1.24229699e-01f, 1.31000161e-01f, 1.63066268e-01f, 1.08908445e-01f, 3.75547111e-02f, 4.62154523e-02f, 9.72973853e-02f,
  1.68416034e-02f, 7.34052435e-02f, 7.71968216e-02f, -2.45474651e-02f, 1.07859389e-03f, 2.46038996e-02f, -5.19396961e-02f, 1.91430062e-01f, 1.70186415e-01f, 7.47565702e-02f,
  4.52617109e-02f, 1.11781888e-01f, -4.47832495e-02f, 7.92794079e-02f, 3.73988673e-02f, -1.44291995e-03f, 6.39909655e-02f, 8.85345321e-03f, -8.23308825e-02f, -1.11998409e-01f,
  1.10999078e-01f, -4.39613611e-02f, -1.35706104e-02f, -3.97713669e-02f, -4.94445525e-02f, -4.71156500e-02f, 6.74649104e-02f, 7.79427215e-02f, -1.13506220e-01f, -5.10863997e-02f,
  2.72614397e-02f, 4.67192009e-02f, 7.09597021e-02f, 1.65690437e-01f, 5.30821867e-02f, 1.87031493e-01f, 1.50511026e-01f, -6.81801140e-02f, -5.96119016e-02f, 9.27485377e-02f,
  3.93317826e-02f, 3.64993066e-02f, -1.29840784e-02f, 1.91900775e-01f, 7.18576238e-02f, -2.72948598e-03f, 1.65767908e-01f, 1.29354790e-01f, 9.44353715e-02f, 2.18098953e-01f,
  6.78771555e-01f, 1.53391892e-02f, -4.48094100e-01f, 1.86645418e-01f, -3.71067487e-02f, -1.20155506e-01f, 3.65215614e-02f, 1.90614015e-01f, 7.06604719e-02f, 5.67188077e-02f,
  -9.00469348e-03f, 8.08762237e-02f, 7.36710504e-02f, -9.58698392e-02f, -6.09501004e-02f, -2.26930395e-01f, -2.76829362e-01f, -2.39898399e-01f, -1.92828607e-02f, 6.41471818e-02f,
  7.26041794e-02f, 4.87895757e-02f, 4.97158766e-02f, -1.00022666e-01f, -1.66879684e-01f, -1.79660395e-01f, -2.68936008e-01f, -2.28721440e-01f, -2.15447560e-01f, -4.23078030e-01f,
  -4.78632569e-01f, -9.29357037e-02f, -2.35403627e-02f, -5.17943092e-02f, -1.81370713e-02f, 1.31476358e-01f, 9.61968526e-02f, 4.14364189e-02f, 1.65262923e-01f, 4.26756516e-02f,
  -1.21108346e-01f, -3.40114646e-02f, -8.04185644e-02f, -2.37637982e-02f, -3.78813967e-03f, 6.34359494e-02f, 8.47070441e-02f, 9.08218995e-02f, -1.19919315e-01f, -8.84524826e-03f,
  3.26106511e-02f, -1.65998843e-02f, 1.28259016e-02f, -5.60283847e-03f, 3.48579884e-02f, -6.51949346e-02f, 5.70012350e-03f, -7.75539363e-03f, -9.61590111e-02f, 6.53747246e-02f,
  2.30260734e-02f, 1.85712182e-03f, -1.00155257e-01f, 1.12792201e-01f, 1.31059080e-01f, 1.06425680e-01f, -5.81405647e-02f, 7.75283501e-02f, -3.98368463e-02f, 5.63263930e-02f,
  -5.09208553e-02f, -9.72305685e-02f, -8.61119255e-02f, -2.65592914e-02f, -5.96740693e-02f, -1.40764147e-01f, -1.00009786e-02f, -8.29464346e-02f, -1.43977016e-01f, -7.08580241e-02f,
  -1.18911341e-02f, -6.16417192e-02f, -1.12253554e-01f, -1.26926124e-01f, -1.57864466e-01f, -1.19194165e-01f, -1.18691958e-01f, 3.22810709e-02f, 2.02416489e-03f, -6.07055500e-02f,
  -7.28433803e-02f, -9.74870920e-02f, -4.91858758e-02f, 8.06549415e-02f, -7.73238763e-02f, 4.98068929e-02f, -4.18722257e-02f, 1.56583190e-02f, 3.28835659e-02f, -1.56980958e-02f,
  -1.23712821e-02f, 8.28202590e-02f, -6.05419315e-02f, 9.72245410e-02f, 1.03986479e-01f, 1.05717070e-01f, 6.50637224e-02f, 6.70635477e-02f, -7.73729682e-02f, -4.72486652e-02f,
  1.50114046e-02f, 1.84985101e-01f, 1.64439246e-01f, 6.65406287e-02f, 1.30490705e-01f, 5.18777557e-02f, 2.47335583e-02f, 2.31022859e-04f, 1.06378227e-01f, 2.28582203e-01f,
  3.49279761e-01f, 1.64903224e-01f, 2.59946108e-01f, 2.45994329e-01f, 6.53650910e-02f, 1.91992953e-01f, 2.29262531e-01f, 2.23826632e-01f, 1.62350357e-01f, 6.66588545e-02f,
  6.54994994e-02f, 1.32082969e-01f, 1.07118048e-01f, 2.35093310e-01f, 2.83519834e-01f, 2.46754393e-01f, 1.92221045e-01f, 2.05923185e-01f, 1.99245960e-01f, 1.78540543e-01f,
  1.40231162e-01f, 6.55999407e-02f, 1.92472324e-01f, 2.07155898e-01f, 1.14071928e-01f, 4.86583337e-02f, 8.19992051e-02f, 1.14516176e-01f, 1.20628923e-01f, 2.22119123e-01f,
  1.72834590e-01f, 7.97865260e-03f, -1.16487250e-01f, -8.82873982e-02f, -1.46671712e-01f, -1.04712799e-01f, -6.72376305e-02f, -6.80026188e-02f, -1.29229710e-01f, -1.42004400e-01f,
  -5.99770322e-02f, -6.74832240e-02f, 1.68771278e-02f, -6.24820031e-02f, -1.41678303e-01f, -2.99822576e-02f, -1.02794645e-02f, 1.01576932e-01f, 2.02032700e-01f, -3.28773931e-02f,
  2.21099723e-02f, -3.53380404e-02f, 6.80322722e-02f, 1.10791653e-01f, 6.33025914e-02f, -1.15482882e-01f, -3.06673180e-02f, -5.81500009e-02f, 7.34098852e-02f, 7.94692338e-03f,
  7.45360181e-02f, 1.16922095e-01f, 1.20596729e-01f, -3.43917892e-03f, -9.17165261e-03f, -1.33753046e-01f, -8.88464972e-02f, 7.78556541e-02f, 1.47806883e-01f, 2.05838736e-02f,
  -1.04766138e-01f, 3.52827869e-02f, 6.28179535e-02f, -1.02996891e-02f, 2.32783724e-02f, -3.81387994e-02f, 6.35952055e-02f, 3.09852473e-02f, -2.64259130e-02f, -4.67706285e-03f,
  6.49297535e-02f, -3.48189846e-02f, -1.52757928e-01f, -2.56288145e-02f, -1.57750905e-01f, -1.45002445e-02f, -1.50178059e-03f, -4.79738899e-02f, -2.81710140e-02f, -5.77103235e-02f,
  6.38381988e-02f, -3.37049961e-02f, 1.01270817e-01f, 6.21372350e-02f, 1.15899090e-02f, -2.85750572e-02f, 4.36329208e-02f, -7.40847960e-02f, -1.24650076e-01f, 5.49944825e-02f,
  -5.08114696e-02f, -1.46758289e-03f, -7.21021667e-02f, -4.14720960e-02f, -7.88505524e-02f, -5.60461096e-02f, 1.90680996e-02f, 1.10727303e-01f, 1.07554405e-03f, -2.45922413e-02f,
  -7.56039396e-02f, 3.73228677e-02f, 4.12184037e-02f, 3.90363745e-02f, -4.22544824e-03f, -1.02732189e-01f, -1.10248461e-01f, 4.51240782e-03f, 6.01703022e-03f, -1.54256076e-01f,
  -2.82340467e-01f, -6.82870522e-02f, 3.01417649e-01f, -2.52915114e-01f, -1.06771812e-01f, -3.97496950e-03f, -3.22167762e-02f, -4.14315648e-02f, -1.85594544e-01f, -1.02919757e-01f,
  -1.11745209e-01f, -2.19731152e-01f, -1.47655934e-01f, -2.04931330e-02f, 1.68602109e-01f, 2.31012538e-01f, 2.01813594e-01f, 2.83328027e-01f, 1.08629681e-01f, 6.85913935e-02f,
  8.55794996e-02f, -5.29218279e-02f, 7.27678742e-03f, 1.49805084e-01f, 3.33065800e-02f, -1.38443291e-01f, 4.92621306e-03f, -3.47481878e-03f, 1.54898986e-01f, 1.77845538e-01f,
  -2.34442409e-02f, -1.04842775e-01f, 9.74154323e-02f, -1.02877758e-01f, -1.24049475e-02f, 1.03827447e-01f, 7.62615055e-02f, 9.89757106e-02f, 2.64884382e-02f, 8.95093679e-02f,
  6.06400054e-03f, 8.24655816e-02f, -1.65175438e-01f, -4.84220916e-03f, -1.33937448e-01f, 1.36125740e-02f, 1.18317410e-01f, 1.06746010e-01f, -5.57999536e-02f, 1.26015842e-01f,
  1.26841590e-01f, -1.33093536e-01f, -1.52335167e-01f, -1.18079670e-01f, -7.69743845e-02f, -1.14448451e-01f, -5.76341115e-02f, -3.98657918e-02f, -1.24240192e-02f, -9.50579867e-02f,
  -7.87455365e-02f, 5.97377159e-02f, 2.23722719e-02f, 1.23408549e-01f, -7.81377405e-03f, 5.78281134e-02f, 1.22891523e-01f, 4.22772244e-02f, 3.49669755e-02f, -1.20386640e-02f,
  1.34430071e-02f, 2.36002225e-02f, 1.44495487e-01f, -4.30185022e-03f, -4.11123745e-02f, -8.75500292e-02f, -8.69280770e-02f, 8.02823603e-02f, 3.48031595e-02f, -4.35555317e-02f,
  -5.08677550e-02f, 7.37605169e-02f, 5.38211353e-02f, 5.72640114e-02f, 1.02798129e-02f, 1.30184457e-01f, -8.39897897e-03f, -8.22205544e-02f, -9.91450474e-02f, -5.31499051e-02f,
  -2.34016418e-01f, 2.03592569e-01f, -9.69485715e-02f, 1.15620695e-01f, -8.01660120e-02f, -5.26950285e-02f, 4.11794102e-03f, -1.64887626e-02f, -7.06077069e-02f, -3.05851339e-03f,
  8.04695114e-02f, 5.84514532e-03f, -1.16023548e-01f, 1.35983840e-01f, -1.63480230e-02f, -1.06998555e-01f, 2.57740472e-03f, -9.30553228e-02f, -1.32997900e-01f, -3.95141393e-02f,
  -5.44400886e-02f, -9.70631316e-02f, -3.61790717e-01f, -1.47341698e-01f, -2.04553068e-01f, -2.74399042e-01f, -1.59914583e-01f, -1.77203104e-01f, -1.00194491e-01f, -1.94300368e-01f,
  1.60691500e-01f, 2.19116509e-01f, 9.45924968e-02f, 1.59968317e-01f, 2.85116732e-01f, 3.07641536e-01f, 3.03555429e-01f, 2.45851755e-01f, 1.12475067e-01f, 7.43060559e-02f,
  -5.57998754e-02f, -2.82754749e-01f, -2.02662185e-01f, -1.69164464e-01f, -1.34414017e-01f, 5.46916649e-02f, 4.20316719e-02f, -1.43002689e-01f, -1.21359512e-01f, 7.91176781e-02f,
  -2.09402945e-03f, 1.84299201e-02f, 2.68818513e-02f, 5.01361378e-02f, -1.10173821e-01f, -2.61108249e-01f, 6.13468662e-02f, 1.55821927e-02f, -1.08813263e-01f, -2.13035092e-01f,
  -1.15511030e-01f, -9.18679289e-04f, -6.02787025e-02f, -1.56578962e-02f, 1.59901548e-02f, 6.47068471e-02f, 2.04254258e-02f, 1.01437680e-02f, 1.28310367e-01f, 1.28582105e-01f,
  2.28766836e-02f, -3.82442516e-03f, -1.40739875e-02f, 8.83700773e-02f, 4.75639217e-02f, 2.90948413e-02f, 1.45810977e-01f, 7.08591118e-02f, 1.82649922e-02f, 1.47053611e-03f,
  7.80656294e-04f, 1.56922802e-01f, 1.05696619e-01f, 1.49579674e-01f, 5.85501678e-02f, 8.30418691e-02f, 1.09502539e-01f, 1.09650776e-01f, 3.86414640e-02f, 1.93561181e-01f,
  1.67304084e-01f, 8.28434750e-02f, 2.06352025e-02f, 7.95407034e-03f, -4.60011326e-02f, 1.60923004e-01f, 3.36554646e-02f, -3.22390348e-02f, 1.12919971e-01f, 1.34380355e-01f,
  6.37057126e-02f, 7.01447949e-02f, 4.27968577e-02f, 8.83131921e-02f, -7.39229172e-02f, 2.42064893e-02f, 1.37667984e-01f, 7.55203664e-02f, -5.63250147e-02f, 3.06497104e-02f,
  -6.56315312e-02f, 7.96133056e-02f, -7.19248131e-02f, -1.31511185e-02f, -2.23086104e-02f, 1.27669290e-01f, 2.43275594e-02f, 7.12687820e-02f, -3.01015284e-02f, -2.36239508e-02f,
  6.72966465e-02f, -3.66486274e-02f, -2.02160224e-01f, -1.35406837e-01f, -1.09650746e-01f, -1.92631502e-02f, -1.47171915e-01f, -1.38232727e-02f, 3.71973291e-02f, 4.02563624e-02f,
  -1.55381048e-02f, -1.61842868e-01f, -3.36664803e-02f, 7.69623220e-02f, 7.78652877e-02f, -7.24063516e-02f, 1.10061597e-02f, 6.14017472e-02f, -4.39216532e-02f, 1.00818142e-01f,
  1.07251965e-01f, 2.09806368e-01f, 7.99174905e-02f, 1.39442891e-01f, 3.82707864e-02f, -1.29623055e-01f, -6.48662969e-02f, 1.17578492e-01f, 3.43029089e-02f, 2.71293730e-01f,
  -7.23158777e-01f, 2.94952095e-01f, 1.70176804e-01f, -5.24402559e-01f, -1.87061489e-01f, 1.86763659e-01f, 2.88838565e-01f, -1.13684967e-01f, -1.87429279e-01f, 7.88506642e-02f,
  2.35250384e-01f, -9.09316316e-02f, 5.66839986e-02f, 1.44012138e-01f, 8.33176002e-02f, 1.98920622e-01f, 5.76326177e-02f, -1.06104419e-01f, -1.60903871e-01f, -8.89910199e-03f,
  -3.34613733e-02f, -3.58416796e-01f, -4.53555822e-01f, -3.05610657e-01f, -1.11839153e-01f, -1.01877190e-01f, -6.06004484e-02f, -2.19361886e-01f, 5.49396090e-02f, -4.71391678e-02f,
  3.06397676e-01f, -2.44682476e-01f, 8.28960612e-02f, -1.47396132e-01f, -2.98735071e-02f, -1.28143504e-01f, -5.66413403e-02f, -8.60461071e-02f, -8.86690468e-02f, -1.65995155e-02f,
  -2.45061908e-02f, 1.38535602e-02f, -3.35552134e-02f, -2.71220575e-03f, -1.15273833e-01f, -3.52880284e-02f, -1.39684882e-02f, -8.15760493e-02f, 4.75062989e-02f, 2.00644344e-01f,
  1.38229266e-01f, -7.96499327e-02f, 8.46570507e-02f, 1.83697209e-01f, 7.45193064e-02f, -3.94548737e-02f, 3.95372175e-02f, -4.69950251e-02f, 2.49882042e-02f, -1.08476391e-03f,
  -2.25582137e-03f, 2.00305227e-02f, 7.64290914e-02f, -2.48699971e-02f, -9.56193805e-02f, 5.56808859e-02f, -5.71265519e-02f, -2.80247312e-02f, -9.93366167e-03f, -5.84607273e-02f,
  -1.96866662e-04f, 8.05576891e-02f, -3.97506803e-02f, -1.51961908e-01f, -3.14074121e-02f, -3.03869601e-02f, -4.99819517e-02f, -3.12616117e-02f, -4.51998375e-02f, -1.30266160e-01f,
  -2.11722497e-02f, 4.93612178e-02f, 1.83861535e-02f, -5.26471660e-02f, 1.27270028e-01f, -7.13950768e-02f, 3.60496975e-02f, 9.74612162e-02f, -1.86142903e-02f, -3.25223953e-02f,
  4.37602103e-02f, -2.37921346e-02f, 5.74398637e-02f, -3.00185755e-02f, -8.23441818e-02f, 8.00719187e-02f, -2.19034553e-02f, -4.41492759e-02f, -8.40249658e-02f, -1.56108430e-02f,
  9.55215469e-02f, -1.60885099e-02f, -4.71804217e-02f, 1.52257681e-01f, -1.15812778e-01f, -4.13496122e-02f, 9.67179760e-02f, -2.23919470e-02f, 1.06575854e-01f, 1.82507947e-01f,
  8.84576589e-02f, 1.75001789e-02f, -5.77681996e-02f, 2.04415843e-01f, -2.31465530e-02f, -2.22538728e-02f, 4.47780378e-02f, 1.85605526e-01f, 7.77511075e-02f, -8.74223933e-02f,
  4.58990097e-01f, 1.03204988e-01f, 6.90021366e-02f, 3.96429487e-02f, -1.68254413e-02f, 4.60501621e-03f, -9.98535156e-02f, 8.94790217e-02f, 7.99565539e-02f, 1.68756261e-01f,
  2.00120851e-01f, 3.33417892e-01f, 2.62280911e-01f, 3.06945443e-01f, 1.33418784e-01f, 1.02913892e-02f, -9.31760520e-02f, 1.05515286e-01f, 9.26408693e-02f, 5.66700920e-02f,
  -5.41763231e-02f, 1.13021601e-02f, 7.17315301e-02f, 4.56724949e-02f, -1.09188266e-01f, 3.19139138e-02f, -5.28598949e-02f, 5.69573324e-03f, -1.88857112e-02f, -1.65059224e-01f,
  8.28285888e-02f, 3.25630009e-02f, 1.54977649e-01f, 4.69978526e-02f, -1.83401167e-01f, -9.65477154e-02f, -7.50107318e-02f, -9.51539949e-02f, -6.29412681e-02f, -1.70696437e-01f,
  -1.33087590e-01f, -1.14936881e-01f, -1.32282302e-01f, -1.66251838e-01f, -8.70964155e-02f, -3.74458618e-02f, -5.77943400e-02f, 5.39674088e-02f, 1.01007298e-01f, -3.24585964e-03f,
  3.37281972e-02f, -1.34635076e-01f, -1.01112656e-01f, 6.03105500e-02f, -4.46865298e-02f, 8.63518864e-02f, 3.35675590e-02f, -1.08958460e-01f, -3.96419168e-02f, -4.41449434e-02f,
  7.61625469e-02f, 1.14767686e-01f, 1.50052151e-02f, 4.46533747e-02f, 5.19094691e-02f, 4.79480997e-02f, 2.95284931e-02f, 1.08136997e-01f, 1.12032011e-01f, -8.58773887e-02f,
  -1.01269549e-02f, 3.78939696e-02f, 9.53670368e-02f, 5.70339011e-03f, 4.40211110e-02f, -7.78148621e-02f, -6.47735745e-02f, 2.59505492e-02f, 3.59933674e-02f, -5.03058219e-03f,
  -5.42452410e-02f, -1.18854485e-01f, -1.13680758e-01f, -4.75194678e-02f, -8.12453330e-02f, 4.30415981e-02f, -1.32982001e-01f, -6.28535375e-02f, -1.15104215e-02f, -8.42616409e-02f,
  3.28545123e-02f, 1.86345369e-01f, 1.50308624e-01f, 1.00993916e-01f, -1.09335184e-01f, -5.56897148e-02f, 7.67542198e-02f, 2.46502887e-02f, -7.13370368e-02f, -6.64257705e-02f,
  -4.08581533e-02f, 3.84683795e-02f, 2.79528070e-02f, -4.99281809e-02f, -9.09648240e-02f, 3.27456817e-02f, 1.43885715e-02f, 1.23878635e-01f, -2.89045721e-02f, -6.21657595e-02f,
  1.98227707e-02f, 3.23940068e-02f, 2.27170870e-01f, 1.12085700e-01f, 9.38246325e-02f, 5.16088605e-02f, 1.29335582e-01f, 5.80220595e-02f, 3.57096530e-02f, 9.25468281e-02f,
  3.08582336e-01f, -2.05428436e-01f, -4.61252183e-01f, -2.15368435e-01f, -4.01154429e-01f, -2.62108862e-01f, -1.97449371e-01f, 5.73205715e-03f, -1.56281292e-01f, -3.19391906e-01f,
  -8.04472789e-02f, 1.41326383e-01f, -1.01893283e-01f, -5.98923452e-02f, 1.70608252e-01f, -2.51521826e-01f, -3.46793383e-01f, -1.00328870e-01f, 2.18423545e-01f, 2.33035743e-01f,
  5.47281429e-02f, 7.58633576e-03f, 1.03199229e-01f, -3.43355834e-02f, -2.28075296e-01f, 4.85689379e-03f, -4.27895933e-01f, -2.39347205e-01f, -1.28639013e-01f, -3.01918387e-01f,
  -2.40431085e-01f, -1.23508744e-01f, 3.76479924e-02f, 1.04034573e-01f, -1.67686597e-01f, 1.38415530e-01f, 7.47234896e-02f, -6.12139851e-02f, 9.96439606e-02f, -7.26886243e-02f,
  -3.95664014e-02f, 1.04277752e-01f, -5.10134548e-03f, -4.10855152e-02f, 3.43815796e-02f, 1.21081695e-01f, -3.44785191e-02f, 8.11863095e-02f, -5.73608512e-03f, 2.89471587e-03f,
  -3.19324024e-02f, -3.91651541e-02f, -8.79581049e-02f, -4.97465394e-03f, 2.03729272e-02f, 5.12412190e-03f, -1.15477413e-01f, -3.47231776e-02f, -5.74902743e-02f, -1.00257643e-01f,
  -2.81193899e-03f, 1.86249777e-03f, -4.04098146e-02f, 5.03022224e-02f, 6.98973313e-02f, -4.13120389e-02f, 2.62178294e-02f, 5.36430962e-02f, 4.84444527e-03f, -3.86116244e-02f,
  -6.06954210e-02f, 1.09442882e-02f, -1.94414295e-02f, 4.67856377e-02f, -1.37457037e-02f, -3.27204727e-02f, -7.85891805e-03f, 9.12923664e-02f, 9.68333520e-03f, 2.62091178e-02f,
  4.72172275e-02f, -2.38456000e-02f, -7.71710724e-02f, 7.29725286e-02f, -4.42743078e-02f, 3.76963243e-03f, -3.11070103e-02f, 8.19827169e-02f, 9.79838893e-03f, 9.17785149e-03f,
  1.94916964e-01f, -2.99717076e-02f, -7.50369728e-02f, 1.19881615e-01f, -6.86618760e-02f, -7.81159401e-02f, -6.06500283e-02f, 3.54987662e-03f, -5.15467972e-02f, -2.78128940e-03f,
  9.55701843e-02f, 1.03671640e-01f, -1.22782014e-01f, 9.46423505e-03f, 5.36465161e-02f, -4.38140938e-03f, 8.91121402e-02f, 3.83855291e-02f, 3.44771631e-02f, 6.78638043e-03f,
  -2.95012053e-02f, 1.72675267e-01f, 1.56589285e-01f, 3.56390849e-02f, 7.04312548e-02f, 9.22902301e-02f, -4.97218929e-02f, -3.46094333e-02f, 1.84120163e-01f, 9.22108144e-02f,
  1.57387946e-02f, -9.81406942e-02f, 2.39860266e-01f, 5.37999794e-02f, -1.88700914e-01f, -2.17995167e-01f, -2.99624234e-01f, -2.30896071e-01f, -4.32074778e-02f, -1.30968302e-01f,
  -1.00558370e-01f, 9.38876495e-02f, 7.62052760e-02f, 1.88099921e-01f, 1.61118865e-01f, -7.45286345e-02f, 1.41839042e-01f, 2.87858844e-01f, 1.54393852e-01f, -1.51733875e-01f,
  -1.69653594e-01f, -9.95970238e-03f, 8.77265856e-02f, 4.56136502e-02f, 9.70788579e-03f, 2.33547874e-02f, 7.47953728e-02f, -1.25323944e-02f, -3.32308710e-02f, 3.18069644e-02f,
  3.16992730e-01f, 1.29980832e-01f, 3.91992740e-02f, 6.41909540e-02f, 1.15102373e-01f, 6.13042116e-02f, -2.26831939e-02f, -4.17079851e-02f, -1.22790098e-01f, -8.18429887e-02f,
  2.04290021e-02f, 8.99588689e-03f, 7.34890252e-02f, -9.01272744e-02f, -3.50470617e-02f, 8.55363905e-03f, 2.52870731e-02f, 9.78244543e-02f, 7.69171193e-02f, -3.31815556e-02f,
  4.76791225e-02f, 6.93956274e-04f, 5.99466562e-02f, -1.14459194e-01f, 1.94366593e-02f, 7.09299743e-02f, -4.13978100e-02f, -2.70964876e-02f, 1.21417068e-01f, -5.94331836e-03f,
  -1.02061622e-01f, -8.15016478e-02f, -1.01525821e-02f, -4.79349606e-02f, -1.19866937e-01f, -1.56386301e-01f, -8.39185528e-03f, -1.35839051e-02f, -3.59805636e-02f, -1.38514102e-01f,
  -1.67256907e-01f, -4.22533788e-02f, -7.87158683e-02f, -3.39357778e-02f, -4.71440982e-03f, 6.42836168e-02f, -3.22273001e-02f, 9.70122963e-02f, -1.08595707e-01f, -4.58373018e-02f,
  -7.05577657e-02f, 7.62618799e-03f, 4.88579534e-02f, -1.00886583e-01f, -1.41222522e-01f, 2.14878116e-02f, -5.96922648e-04f, -3.01958863e-02f, -1.18909493e-01f, -4.85561602e-02f,
  6.41999170e-02f, 3.05853575e-01f, 1.25699401e-01f, 1.54919133e-01f, 5.99852875e-02f, 1.85246825e-01f, 1.68326512e-01f, 1.42958164e-01f, 1.12293884e-01f, 5.94835989e-02f,
  6.25685453e-02f, 1.73775166e-01f, 9.05131623e-02f, -1.07247613e-01f, 3.98370624e-02f, 1.10561624e-02f, 7.61950165e-02f, 1.52627394e-01f, 1.23491608e-01f, 1.24867007e-01f,
  4.35891375e-03f, 2.68241055e-02f, 5.14360070e-02f, 9.28139687e-02f, 4.35340218e-02f, 9.75181311e-02f, 1.54192999e-01f, 5.83340824e-02f, 1.50902033e-01f, -1.59983993e-01f,
  2.25354787e-02f, 2.91494094e-02f, 3.13341111e-01f, 2.27384157e-02f, -5.70553653e-02f, -7.30042756e-02f, -1.43591702e-01f, -1.31754369e-01f, 2.62871739e-02f, 9.42458585e-02f,
  -5.37328124e-02f, -1.44917458e-01f, -3.58528532e-02f, -1.23977318e-01f, -2.10154220e-01f, -1.97428595e-02f, 9.47762374e-03f, -5.97147122e-02f, -9.54699218e-02f, -8.63148570e-02f,
  -2.71014292e-02f, 8.85407925e-02f, -7.49658272e-02f, -1.52662635e-01f, 1.12567954e-01f, -3.13132778e-02f, 1.36243954e-01f, 1.70510501e-01f, 7.28325471e-02f, 3.13575715e-01f,
  3.79426301e-01f, 3.82043496e-02f, -5.39371036e-02f, -2.70259082e-01f, 9.37070977e-03f, 7.28779957e-02f, 5.33101298e-02f, 4.10840288e-02f, -9.51345824e-03f, 8.01118165e-02f,
  3.79294604e-02f, 2.81619690e-02f, 6.86750608e-03f, 1.00430258e-01f, 1.10222571e-01f, 9.34308919e-04f, -8.06687996e-02f, -3.33789997e-02f, -1.15026042e-01f, 1.18570730e-01f,
  -1.41756281e-01f, 7.15931356e-02f, 3.36603932e-02f, -1.21896930e-01f, 3.36857997e-02f, -8.51489827e-02f, 1.10193444e-02f, -3.23511921e-02f, -9.47371051e-02f, 1.69597834e-01f,
  -4.31378447e-02f, 4.76896949e-02f, -4.32724096e-02f, 1.16165102e-01f, 1.42926365e-01f, 1.07530683e-01f, 2.07676470e-01f, 1.37092054e-01f, -1.01583609e-02f, 1.98898599e-01f,
  -1.13370623e-02f, 9.68801603e-02f, 2.02394783e-01f, 7.21504018e-02f, 1.07550204e-01f, 1.71900541e-01f, 1.92134529e-01f, 8.17990750e-02f, 1.14411555e-01f, 8.55894238e-02f,
  1.09763980e-01f, 1.35590300e-01f, 1.27138644e-01f, 8.52225572e-02f, 1.82767995e-02f, 8.74967054e-02f, 1.21552914e-01f, 2.89176740e-02f, 3.66543792e-02f, 1.47669413e-03f,
  1.75223038e-01f, -2.67929465e-01f, 2.75513381e-01f, 6.94901496e-02f, 2.96250544e-02f, 1.18157558e-01f, 2.04991400e-01f, -1.65474452e-02f, 1.57388821e-01f, 7.15481862e-02f,
  -1.22901909e-02f, 6.09763786e-02f, 1.04070224e-01f, 7.52715319e-02f, 4.02224585e-02f, 4.62273359e-02f, -1.05227798e-01f, -6.78778216e-02f, -1.13657035e-01f, 1.73170075e-01f,
  -1.37577489e-01f, -1.86856035e-02f, 8.38256329e-02f, -4.10240777e-02f, -1.74288340e-02f, 5.10225184e-02f, 9.06530917e-02f, 7.67667452e-03f, -6.91090971e-02f, 2.72805020e-02f,
  -3.79183561e-01f, -2.84012794e-01f, -1.27185032e-01f, -2.93795615e-01f, -1.36832356e-01f, -1.39146522e-01f, -2.75642484e-01f, -1.14355303e-01f, -7.77218193e-02f, -3.76994044e-01f,
  -1.56570345e-01f, -1.18886515e-01f, -1.55211598e-01f, -2.14124799e-01f, -3.04820955e-01f, -4.68150228e-01f, -3.14323932e-01f, -2.98522741e-01f, -1.56812668e-01f, -1.24478780e-01f,
  -2.04731673e-01f, -2.86730915e-01f, -1.97054461e-01f, -4.21538576e-02f, -4.53949496e-02f, -8.23518708e-02f, -7.77943879e-02f, -1.48758203e-01f, -3.36171761e-02f, -1.47146195e-01f,
  -2.31109753e-01f, 2.15229198e-01f, 6.31177947e-02f, -9.89775639e-03f, -5.48556969e-02f, 1.40681535e-01f, -7.52995834e-02f, 1.28277421e-01f, 1.15723014e-01f, 3.19434702e-03f,
  6.20353967e-02f, -1.00209378e-02f, 4.21528667e-02f, 3.01272776e-02f, -6.13281950e-02f, 1.75917447e-02f, -7.60039985e-02f, -7.12132826e-02f, 6.42663985e-02f, 1.06482267e-01f,
  3.28657962e-02f, -8.64134580e-02f, 2.11344920e-02f, 1.58685133e-01f, 2.67792016e-01f, 3.91957983e-02f, 1.58090815e-01f, 1.85415223e-01f, 2.24901542e-01f, -5.76028489e-02f,
  -1.74745843e-02f, 2.89754737e-02f, -5.68730347e-02f, -5.60984500e-02f, 1.29396999e-02f, -3.12130582e-02f, -1.12542864e-02f, 5.93860671e-02f, -3.33786644e-02f, -6.97620362e-02f,
  -8.56812447e-02f, -6.43664449e-02f, 6.57015890e-02f, -6.63076043e-02f, 6.69667125e-03f, -7.58124068e-02f, -4.25500721e-02f, -5.61533459e-02f, -1.55291669e-02f, -1.07018553e-01f,
  5.60134798e-02f, 4.48429286e-02f, -4.73579280e-02f, 3.84669751e-02f, -5.18815257e-02f, -1.50645804e-02f, 2.41360478e-02f, -1.94127001e-02f, -3.90404686e-02f, -1.52798686e-02f,
  -1.36604086e-01f, 6.80117905e-02f, -8.91411379e-02f, 1.06984802e-01f, 1.84775293e-02f, 7.42351189e-02f, 9.38922241e-02f, 4.61850651e-02f, 9.13783982e-02f, 2.00191494e-02f,
  7.12677017e-02f, -9.75314677e-02f, -1.59114853e-01f, 6.19223639e-02f, -2.44923607e-02f, 1.88059621e-02f, -1.43733397e-01f, -9.27350745e-02f, 1.16682805e-01f, 6.81712329e-02f,
  -9.71829593e-02f, -5.66227622e-02f, -1.57329574e-01f, -7.27364421e-02f, 8.16389024e-02f, -8.99096727e-02f, -1.20162517e-01f, 9.00682956e-02f, -9.24423710e-02f, -3.03409219e-01f,
  2.96166420e-01f, 3.43134433e-01f, 1.54236451e-01f, -4.89465743e-02f, 4.87900227e-02f, 2.75700539e-01f, 3.65528733e-01f, 1.83804512e-01f, -1.70117050e-01f, 1.37911096e-01f,
  -1.30126864e-01f, -3.22302610e-01f, -2.06048399e-01f, -2.15235978e-01f, 3.88401039e-02f, 1.37577221e-01f, 9.30786803e-02f, -2.34904140e-02f, -6.68650046e-02f, 6.62598237e-02f,
  -1.34432241e-01f, 1.58862665e-01f, 1.34214327e-01f, 8.36625546e-02f, -4.68799286e-02f, -2.87517726e-01f, 1.11986130e-01f, 1.92585573e-01f, 1.67332485e-01f, -1.19030446e-01f,
  6.80572093e-02f, 3.96458149e-01f, -4.24575835e-01f, -2.37533927e-01f, 6.38996065e-02f, -1.64641980e-02f, -1.80337243e-02f, -6.85818493e-03f, -8.86758119e-02f, -1.23820389e-02f,
  -7.04696774e-02f, -2.54568830e-02f, -2.04549637e-02f, 1.16244748e-01f, 1.45038679e-01f, 6.66501820e-02f, 1.00556418e-01f, 1.47367790e-01f, -2.93761883e-02f, 2.01235637e-02f,
  -1.78538978e-01f, 6.88855201e-02f, 1.86369985e-01f, -4.11314182e-02f, -2.18351055e-02f, -2.35972494e-01f, 4.80445549e-02f, 4.57294099e-02f, -4.38292436e-02f, 8.14760756e-03f,
  -2.83806503e-01f, -5.42115271e-02f, 7.58789033e-02f, -4.78405207e-02f, -2.98409835e-02f, -6.88561946e-02f, -8.76933485e-02f, 1.39266383e-02f, -5.82356155e-02f, 2.13799812e-02f,
  -1.84308127e-01f, -4.87071760e-02f, 2.75018234e-02f, -5.86148128e-02f, -2.50641942e-01f, 6.42577931e-02f, 1.03754632e-01f, 3.47569734e-02f, 3.92052978e-02f, 5.65076955e-02f,
  -3.45865116e-02f, 3.71277556e-02f, 1.48145724e-02f, -9.86503996e-03f, -7.33559057e-02f, -8.04780126e-02f, -5.49727231e-02f, -5.57144322e-02f, -7.90515170e-02f, 5.85516728e-03f,
  -8.24675784e-02f, 1.22986473e-01f, -1.21573895e-01f, -5.32264933e-02f, 1.12825096e-01f, 1.11682143e-03f, -1.36660203e-01f, -6.30971566e-02f, -1.11660697e-01f, 2.04667524e-02f,
  1.33366272e-01f, -8.85173902e-02f, 7.65171871e-02f, 5.32318950e-02f, -2.72963643e-02f, 4.23735045e-02f, -2.29760874e-02f, -7.13095143e-02f, -2.66613089e-03f, 5.73535524e-02f,
  -8.90161246e-02f, 9.50491354e-02f, -7.47570544e-02f, -2.19082639e-01f, -2.19150499e-01f, -3.80312890e-01f, -1.48222357e-01f, 3.92229185e-02f, 8.75810236e-02f, -1.23285707e-02f,
  -5.68080172e-02f, 1.59031563e-02f, -1.63410857e-01f, 1.51089534e-01f, -8.17124695e-02f, -2.35695630e-01f, -4.00889106e-02f, -8.87140483e-02f, 1.20847531e-01f, 2.82015383e-01f,
  9.90184955e-03f, -2.72048146e-01f, -1.71707481e-01f, -2.61467934e-01f, -2.78947890e-01f, 9.53726396e-02f, 7.36369044e-02f, -2.92675227e-01f, -4.59730536e-01f, -3.29860598e-01f,
  -9.73227099e-02f, -6.26214370e-02f, -2.73917824e-01f, -1.77656561e-01f, 9.70639512e-02f, -8.85473043e-02f, -1.66765954e-02f, -7.87821040e-02f, -2.11616024e-01f, 1.09444641e-01f,
  1.10193610e-01f, -2.44942099e-01f, -9.65865552e-02f, -1.35636926e-01f, -1.84289850e-02f, -4.23356853e-02f, -3.30339111e-02f, 2.70157512e-02f, 7.20070750e-02f, 1.35679364e-01f,
  -1.64554089e-01f, -8.72208923e-02f, -2.44799312e-02f, -9.87185612e-02f, 3.48590016e-02f, -9.31256711e-02f, 1.08343460e-01f, -4.17222641e-03f, 4.07703668e-02f, 2.45733298e-02f,
  2.09811740e-02f, -1.97356582e-01f, -7.17036277e-02f, 7.44400593e-03f, -1.52514890e-01f, -1.88660353e-01f, -3.15992273e-02f, -2.36685663e-01f, -1.40385658e-01f, 3.46826077e-01f,
  1.85181443e-02f, 1.11873202e-01f, -7.79831484e-02f, 2.13206559e-02f, 4.77636792e-02f, 3.84036973e-02f, -2.85115615e-02f, 7.31358975e-02f, -1.20639995e-01f, -1.13069220e-02f,
  3.17851156e-02f, 2.95465495e-02f, 1.10089639e-02f, 9.93916318e-02f, -4.34063561e-02f, -2.75576133e-02f, -1.12710103e-01f, 8.26294124e-02f, 4.59541865e-02f, 9.89364609e-02f,
  -6.39807507e-02f, -3.55745964e-02f, 5.72257526e-02f, -3.52378562e-02f, -8.82140771e-02f, -2.91552721e-03f, 7.83302821e-03f, -1.16065942e-01f, -7.95106292e-02f, -5.54992519e-02f,
  1.68615341e-01f, -2.14049920e-01f, 2.19200879e-01f, 1.08155776e-02f, 7.12005347e-02f, 1.05619252e-01f, 8.55809599e-02f, 1.55214081e-02f, 1.07638189e-04f, -1.14229741e-03f,
  -1.40597731e-01f, -2.42111534e-02f, 4.96943854e-02f, 7.04890639e-02f, 5.47262318e-02f, -2.17297729e-02f, 1.82861209e-01f, 1.10348918e-01f, -3.95996682e-02f, 1.07301280e-01f,
  1.81803018e-01f, 9.52082947e-02f, 1.86663479e-01f, 2.67158270e-01f, 1.30055239e-02f, 5.25220782e-02f, 8.37860927e-02f, 7.46255592e-02f, -3.66826472e-03f, 4.13795352e-01f,
  -1.20162457e-01f, -4.99904389e-03f, -5.56169674e-02f, 2.61667550e-01f, 1.30143777e-01f, 2.60966364e-02f, -1.25302048e-02f, -9.74695608e-02f, -1.83782652e-02f, 9.99886543e-02f,
  -1.24641294e-02f, 1.74015641e-01f, 8.29651281e-02f, 6.34777695e-02f, -7.13292807e-02f, -2.90934835e-02f, 1.31049335e-01f, 8.92553478e-02f, -1.61461998e-02f, 5.65479398e-02f,
  2.37014055e-01f, 6.72518685e-02f, -4.72626425e-02f, 1.25564039e-01f, 2.37027198e-01f, 1.06428780e-01f, 9.78048742e-02f, 1.51514933e-01f, 1.42040402e-01f, 3.34128797e-01f,
  -9.09028500e-02f, -4.04194836e-03f, 1.29224166e-01f, 7.38844424e-02f, 1.42179281e-01f, -1.12488806e-01f, 8.36323109e-03f, -9.33416337e-02f, 4.27792706e-02f, -3.75673734e-02f,
  1.27045155e-01f, -2.63499320e-02f, 9.32175666e-02f, 9.76114720e-02f, -7.28546269e-03f, -8.28173384e-02f, -1.77578162e-02f, -1.01159215e-01f, -2.90792119e-02f, -1.84052568e-02f,
  2.35922903e-01f, -2.34000981e-04f, -1.54325217e-01f, -5.29330149e-02f, 8.09991285e-02f, 1.01215586e-01f, -1.21210492e-03f, 2.18612775e-02f, -3.82196158e-02f, 4.74341661e-02f,
  7.25475550e-02f, -3.40357088e-02f, 1.20598607e-01f, 6.57763630e-02f, 8.26964304e-02f, 3.14920992e-02f, 5.62356748e-02f, 9.69529748e-02f, 5.86022884e-02f, 5.63935675e-02f,
  1.88277190e-04f, -4.16278280e-02f, 5.62662035e-02f, 7.26526882e-03f, 6.78259358e-02f, 1.50880501e-01f, 5.78433871e-02f, 3.18782357e-03f, 9.03968066e-02f, -1.11925110e-01f,
  -1.55206316e-03f, -4.19646762e-02f, 2.45726854e-03f, 7.93413073e-02f, 1.14084847e-01f, 9.84769464e-02f, 1.60034865e-01f, 3.87466587e-02f, 2.39463188e-02f, 1.18546732e-01f,
  -3.87082845e-01f, -8.45323503e-02f, 1.57175645e-01f, 6.19657189e-02f, 1.15810469e-01f, -7.96543434e-02f, 1.56842940e-03f, 5.35882916e-03f, 2.37449706e-02f, -1.07982025e-01f,
  -1.32485151e-01f, 2.94645373e-02f, -3.13226543e-02f, -3.80637124e-02f, -9.93506461e-02f, -7.79478624e-02f, 4.95003834e-02f, 7.72818178e-02f, -7.54283518e-02f, -1.16274334e-01f,
  -3.74079272e-02f, -7.81495869e-02f, -1.69045731e-01f, -7.84755126e-02f, -7.89138600e-02f, -6.94656093e-03f, -1.41013399e-01f, -3.81445065e-02f, -1.37317181e-01f, -1.38067722e-01f,
  1.84080556e-01f, 3.62399429e-01f, 1.33565679e-01f, -4.08186635e-04f, 1.30563095e-01f, 2.52125293e-01f, 5.03927767e-01f, 1.79237396e-01f, -1.48970842e-01f, 1.74419045e-01f,
  4.47053090e-02f, -4.05760765e-01f, -1.96758389e-01f, -2.11737111e-01f, 4.77643274e-02f, 1.70811385e-01f, 6.13784343e-02f, -6.67546317e-02f, -1.50257379e-01f, 3.32987420e-02f,
  -1.41629696e-01f, 7.41785467e-02f, -2.68173516e-02f, 2.22980734e-02f, 7.48336911e-02f, -1.19204201e-01f, 2.24874824e-01f, 1.36418387e-01f, 1.06784970e-01f, -7.81794265e-02f,
  -1.14612356e-01f, 3.58047217e-01f, -2.94320464e-01f, -1.64193630e-01f, 9.86398105e-03f, -8.21688473e-02f, 7.76740117e-03f, -1.76532030e-01f, -3.44998203e-02f, 7.52694011e-02f,
  7.19029680e-02f, -6.46729022e-02f, -5.67059033e-02f, -1.64132863e-02f, 2.36426871e-02f, -4.11829613e-02f, 2.29169521e-02f, -1.39428005e-01f, -1.83840990e-01f, -1.55245811e-02f,
  -8.72819275e-02f, 1.76069751e-01f, 2.86551625e-01f, 1.06982984e-01f, -5.92492335e-03f, -2.08087161e-01f, 2.46336952e-01f, -3.41286100e-02f, 1.06304176e-01f, 6.32006899e-02f,
  -1.09998873e-02f, 1.56833306e-01f, 7.21823126e-02f, 5.57538085e-02f, 3.71173471e-02f, -2.35108975e-02f, 1.02982298e-02f, 2.08337642e-02f, -1.10933594e-04f, 1.35322258e-01f,
  -1.58013962e-02f, 5.01159094e-02f, -1.05598057e-02f, 1.29361197e-01f, -8.22089091e-02f, 9.89351720e-02f, 8.06324929e-02f, 6.14132471e-02f, 6.29465133e-02f, 1.06206974e-02f,
  -6.41427934e-03f, 3.30794156e-02f, -4.39241305e-02f, 1.66579727e-02f, 6.95477724e-02f, -6.13884442e-02f, -7.18712294e-03f, 5.84765375e-02f, 3.49828154e-02f, 1.17923833e-01f,
  -2.35438704e-01f, 5.06317616e-02f, -2.25902453e-01f, 3.77834141e-02f, 8.69587287e-02f, -7.54440129e-02f, -7.27296844e-02f, -8.05780012e-03f, 1.10481337e-01f, -4.04370464e-02f,
  1.14951953e-01f, -4.97958809e-02f, 4.47533876e-02f, -1.05622029e-02f, -1.05418585e-01f, -4.14651558e-02f, -1.48251224e-02f, -1.25056699e-01f, -1.21267162e-01f, -7.37938806e-02f,
  -8.05785973e-03f, -2.93647107e-02f, 4.92392480e-03f, 3.65714505e-02f, 1.92859806e-02f, -2.37724185e-01f, 3.90775651e-02f, -1.11248963e-01f, -3.13836336e-02f, -2.41170991e-02f,
  6.03004061e-02f, 1.72809318e-01f, -2.29891375e-01f, -9.07992199e-03f, -1.70780256e-01f, -2.61409253e-01f, -9.96300131e-02f, 1.81027539e-02f, 1.73192784e-01f, 1.95480928e-01f,
  8.43116343e-02f, -1.07836470e-01f, -4.38846387e-02f, -1.04830049e-01f, -1.79569498e-01f, 2.33999384e-03f, -1.22754939e-01f, -3.53947282e-01f, -4.86587673e-01f, -3.25816631e-01f,
  -1.58717901e-01f, -1.08340994e-01f, -1.84270307e-01f, -2.10622743e-01f, 2.08663791e-01f, 7.59313330e-02f, 1.50895730e-01f, 6.34178370e-02f, -8.45687538e-02f, 1.80311486e-01f,
  -3.05479090e-03f, -3.21416631e-02f, -1.37304097e-01f, -1.09309554e-01f, 7.17154965e-02f, -5.41018993e-02f, -5.59842065e-02f, 1.00798551e-02f, -7.21026957e-02f, -3.48663256e-02f,
  -1.18577808e-01f, -1.26727164e-01f, -1.05723687e-01f, -2.47602835e-02f, -1.46010429e-01f, -1.02429599e-01f, -3.54159810e-02f, -1.65583238e-01f, -8.29294175e-02f, -2.78081596e-02f,
  -1.58972248e-01f, -1.35186136e-01f, -7.97291771e-02f, -2.73364224e-02f, -3.44427712e-02f, -7.34904110e-02f, 2.44857781e-02f, -5.45199811e-02f, -2.79861242e-02f, 2.37242863e-01f,
  5.41144237e-02f, 1.74753126e-02f, -3.54900490e-03f, 1.11321807e-01f, 7.51322657e-02f, 1.06926665e-01f, -3.22016962e-02f, 7.23437294e-02f, -2.01473553e-02f, 8.54235899e-04f,
  4.76490473e-03f, 2.91938074e-02f, 2.10388619e-02f, 5.00641540e-02f, -9.04904008e-02f, -7.89795518e-02f, 1.74391605e-02f, -5.27901947e-03f, -8.52113962e-02f, -8.70046839e-02f,
  -8.88105333e-02f, -5.09752706e-02f, 3.44230048e-02f, -9.78394505e-03f, 3.44388932e-02f, 1.27455229e-02f, -4.80879880e-02f, -1.04245571e-02f, -4.04086187e-02f, 3.35406438e-02f,
  2.94845909e-01f, -1.03764534e-01f, 2.06830740e-01f, -3.80382799e-02f, 1.88421886e-02f, -3.41079980e-02f, 8.74705017e-02f, -1.33135498e-01f, -8.45225807e-03f, -9.55133960e-02f,
  -1.79922521e-01f, 7.14201108e-03f, -8.49791057e-03f, -1.03638276e-01f, -1.47255331e-01f, -4.46471013e-02f, -6.70126528e-02f, -5.62316589e-02f, -6.03076778e-02f, 5.36793023e-02f,
  3.10532153e-02f, -3.57421227e-02f, 8.74573216e-02f, 6.66304827e-02f, 3.72600593e-02f, 2.24054214e-02f, 7.88331851e-02f, 3.34521383e-03f, -4.12308760e-02f, 3.67378265e-01f,
  -3.78270864e-01f, 9.76976231e-02f, -9.37978923e-02f, 2.06939533e-01f, 2.06074983e-01f, -1.42615698e-02f, -3.46281864e-02f, -7.20043257e-02f, 1.52432457e-01f, 2.94338781e-02f,
  -1.05828069e-01f, 7.60587528e-02f, 5.70552461e-02f, 1.54368386e-01f, 8.43719915e-02f, 1.59738526e-01f, 3.00546318e-01f, 6.26535788e-02f, -5.73536381e-02f, -4.22539143e-03f,
  2.34895959e-01f, 2.17334658e-01f, 7.04022273e-02f, 8.20579827e-02f, 1.27484292e-01f, 1.52965084e-01f, 1.78910971e-01f, 1.68680802e-01f, 7.63971284e-02f, 1.80321142e-01f,
  -4.00962740e-01f, -1.93723977e-01f, 7.81241152e-03f, 1.02785110e-01f, -1.97993800e-01f, -2.51681030e-01f, -1.86878473e-01f, -1.27696753e-01f, -1.04287647e-01f, 1.00768236e-02f,
  -5.03135100e-02f, -8.15376714e-02f, 4.10418510e-02f, 1.40725613e-01f, -3.60783376e-02f, -6.46442994e-02f, 3.00436113e-02f, -1.00673161e-01f, -1.27338603e-01f, -3.01144123e-01f,
  1.13325126e-01f, -7.64045194e-02f, -2.80517995e-01f, -6.54372433e-03f, -1.61639646e-01f, 2.27509513e-02f, -1.39426172e-01f, -1.63704187e-01f, -1.81954831e-01f, -1.44727126e-01f,
  -1.92492485e-01f, -5.87307587e-02f, 1.03778794e-01f, 2.95279231e-02f, 1.85436122e-02f, 3.62509415e-02f, 6.51846007e-02f, 1.01085842e-01f, 1.62885785e-01f, -8.66239443e-02f,
  -3.51484939e-02f, -7.36255348e-02f, 9.17975698e-03f, -4.12023142e-02f, 1.59714371e-01f, 4.17009443e-02f, -9.75722298e-02f, 4.90686670e-02f, -4.02864292e-02f, 1.62277650e-02f,
  2.23593391e-03f, 2.15368718e-02f, 1.27613693e-01f, -2.84660831e-02f, 2.58412957e-02f, -3.72064225e-02f, 8.39416124e-03f, 2.49640029e-02f, 1.89956464e-02f, 6.75482526e-02f,
  2.47475043e-01f, 2.42829129e-01f, -1.47847593e-01f, 1.23551106e-02f, -1.49436742e-02f, 7.56062493e-02f, 1.07722305e-01f, -8.03244114e-02f, -1.38159133e-02f, -6.83943406e-02f,
  -9.84936729e-02f, -9.69016701e-02f, 6.29695132e-02f, 1.47422120e-01f, -2.10676957e-02f, -4.07889113e-02f, 8.36434960e-02f, -3.34211858e-04f, 1.29540905e-01f, -1.19616799e-01f,
  1.77766010e-01f, 9.19199511e-02f, -1.24980479e-01f, -9.94641632e-02f, -7.53978342e-02f, 6.28186017e-02f, 4.54679057e-02f, -8.93993229e-02f, -8.32024515e-02f, -1.33325830e-01f,
  -5.75652480e-01f, -1.02336265e-01f, -6.53960556e-02f, -1.26400933e-01f, 2.39511579e-01f, 1.57407731e-01f, 6.06964231e-02f, -1.44634321e-01f, -1.41753569e-01f, -7.84317628e-02f,
  -1.99595257e-03f, 7.65061602e-02f, -8.52958709e-02f, -1.42586203e-02f, 6.79646060e-02f, 3.70879285e-02f, 2.07957253e-01f, 1.00675844e-01f, 8.70910883e-02f, 1.34266540e-01f,
  1.96678787e-01f, 3.21906805e-02f, -5.98774850e-02f, 7.17776567e-02f, -5.98153658e-02f, 3.98769230e-02f, 2.55447105e-02f, -1.52909011e-02f, 1.31519169e-01f, 3.90190706e-02f,
  -2.69924939e-01f, -2.20025301e-01f, 6.38079420e-02f, 4.82180491e-02f, 2.25872509e-02f, -1.06663257e-01f, -4.07761671e-02f, -8.96384045e-02f, 3.03057339e-02f, -1.21372484e-01f,
  3.44551131e-02f, -5.72904386e-02f, 2.96813007e-02f, 1.06657017e-02f, -1.19352795e-01f, -6.53419420e-02f, -1.03889383e-01f, -6.04764111e-02f, -1.67362556e-01f, -3.36751565e-02f,
  1.47717014e-01f, 2.56060790e-02f, -1.59062639e-01f, 2.55747288e-02f, -1.26926467e-01f, -1.02886483e-01f, -7.14560822e-02f, -1.22324578e-01f, -1.83645725e-01f, -2.43510365e-01f,
  1.78583185e-04f, 3.33761610e-02f, -2.61214506e-02f, -2.08962616e-02f, 4.84643020e-02f, -4.46020998e-03f, -5.72414044e-03f, 6.89237267e-02f, 4.42211330e-02f, -7.39517808e-02f,
  6.88261464e-02f, -7.76889324e-02f, 8.98510516e-02f, -6.19817935e-02f, 2.33510360e-02f, -4.40151170e-02f, 6.81787357e-02f, 8.90578553e-02f, 4.02960815e-02f, 2.77027600e-02f,
  -2.74586091e-05f, -3.57118249e-02f, -3.13460417e-02f, 2.30063293e-02f, -2.66580451e-02f, 3.81529629e-02f, -4.21577431e-02f, -2.68997159e-03f, -1.08678661e-01f, -6.04613386e-02f,
  -1.63794935e-01f, 3.12452763e-01f, -2.02801496e-01f, -7.31898323e-02f, 6.14173561e-02f, 4.29569967e-02f, 2.83497646e-02f, -6.60198182e-02f, -3.77252288e-02f, -1.21005856e-01f,
  -4.95598046e-03f, -1.25398710e-01f, -8.37819949e-02f, 3.14202197e-02f, -1.35481969e-01f, -1.19762376e-01f, 3.70761007e-02f, 4.02260385e-02f, 1.84733178e-02f, 4.38266853e-03f,
  -5.65294363e-02f, -7.34809786e-02f, -1.63406253e-01f, -1.34890825e-01f, -8.72350410e-02f, -1.00897834e-01f, -1.30060673e-01f, -1.04236625e-01f, -1.46575421e-01f, -3.59528750e-01f,
  7.17368484e-01f, 1.05614878e-01f, 4.01050001e-02f, 8.09478760e-02f, 6.61237910e-02f, 1.15908356e-02f, 1.35842571e-02f, 7.48240054e-02f, 1.60820872e-01f, 1.44086152e-01f,
  1.11099124e-01f, 2.37388387e-01f, 1.28039613e-01f, 7.50695616e-02f, 1.42788291e-01f, -9.71036591e-03f, -6.20482787e-02f, 1.31834224e-01f, 1.75479278e-01f, 7.24023804e-02f,
  9.15094465e-02f, -2.22914312e-02f, 2.07615569e-01f, 1.20357320e-01f, 2.06977390e-02f, 1.33776382e-01f, 1.03761017e-01f, 1.20581947e-01f, 6.84429184e-02f, -5.16907871e-02f,
  5.75853288e-02f, 3.81926358e-01f, 9.50282663e-02f, 3.37523669e-02f, -3.02454159e-02f, -5.88060953e-02f, 4.79682721e-02f, -1.43507823e-01f, -1.47223592e-01f, -1.89154118e-01f,
  -8.72504525e-03f, -1.93909388e-02f, -3.19833346e-02f, -1.43971562e-03f, 6.38591349e-02f, -5.09796776e-02f, 6.03727140e-02f, -2.83245575e-02f, -4.49009687e-02f, 3.87942903e-02f,
  -8.88491720e-02f, 4.26946618e-02f, -1.87196340e-02f, 3.78270000e-02f, 2.63305078e-03f, 1.29215553e-01f, 2.65806410e-02f, 5.70513457e-02f, -1.45208249e-02f, 4.91930991e-02f,
  2.37947300e-01f, 1.06220789e-01f, 1.75031379e-01f, 7.87011310e-02f, 9.91573334e-02f, 8.04411843e-02f, 3.61053161e-02f, -3.88409197e-02f, 5.95470518e-02f, -3.75314802e-03f,
  -1.99168306e-02f, 1.13550117e-02f, -3.20484005e-02f, 1.62871387e-02f, 3.00888345e-02f, -4.82291169e-02f, -6.78763390e-02f, -2.92959996e-02f, 6.47552460e-02f, 9.67892818e-03f,
  1.02646694e-01f, 2.24496927e-02f, 9.15492773e-02f, -1.68937650e-02f, 4.33215499e-02f, 1.29271939e-01f, 2.68640462e-02f, 8.40226188e-03f, 1.19367927e-01f, 7.69049451e-02f,
  -5.00823975e-01f, 2.39734799e-01f, 5.12095429e-02f, -9.44867060e-02f, 1.81740467e-02f, 2.09904481e-02f, 8.25516507e-02f, -1.55970439e-01f, -1.35947078e-01f, -4.42287698e-02f,
  -4.59546447e-02f, -4.03418466e-02f, -2.15197541e-02f, 1.06366584e-02f, 5.14399679e-03f, -1.34619594e-01f, 5.90614043e-02f, -1.08866759e-01f, -9.38115269e-02f, -1.64306507e-01f,
  -1.29901230e-01f, -6.32528141e-02f, -7.94207156e-02f, -5.85317276e-02f, 2.06640158e-02f, 1.54683068e-02f, -1.35265261e-01f, -2.04200055e-02f, 2.68327575e-02f, -5.83221540e-02f,
  -4.84873772e-01f, 1.01718754e-01f, 2.29196742e-01f, -4.48270530e-01f, -1.67459100e-01f, -4.78121266e-02f, -1.88088045e-02f, -1.45928279e-01f, -1.54419675e-01f, -3.56215728e-03f,
  1.95689827e-01f, 9.84993502e-02f, 1.98683828e-01f, 1.15913615e-01f, 2.59251408e-02f, 5.74953817e-02f, -1.54440582e-01f, -1.30941764e-01f, -1.68981597e-01f, -2.92107433e-01f,
  -1.75698742e-01f, -2.80800104e-01f, -2.96724141e-01f, -1.45751968e-01f, -7.69584030e-02f, 1.53399892e-02f, 2.40480527e-02f, -1.70267090e-01f, 4.93638441e-02f, -1.80459861e-02f,
  2.46799186e-01f, -1.08485356e-01f, -1.50111448e-02f, -1.47920460e-01f, -8.45192671e-02f, 4.80454369e-03f, -4.62712571e-02f, -5.43093607e-02f, 2.59600915e-02f, -9.30502191e-02f,
  -2.54755467e-02f, -1.02074213e-01f, -2.96793878e-02f, 2.09885184e-02f, -1.32112548e-01f, -1.20941006e-01f, -8.19865987e-02f, -9.18226764e-02f, -6.21840451e-03f, 1.87123735e-02f,
  -4.07544822e-02f, -3.10195349e-02f, 6.43204749e-02f, 4.91567515e-02f, 1.34578589e-02f, -3.89369689e-02f, 7.33485371e-02f, -1.20076917e-01f, -9.54631567e-02f, -3.58976983e-02f,
  -4.67511080e-02f, 7.07741901e-02f, 8.06896389e-03f, -1.88807063e-02f, -6.00912161e-02f, 2.23772060e-02f, 1.00764586e-02f, -9.81109217e-03f, -8.79967883e-02f, 6.24983534e-02f,
  5.53428270e-02f, 8.68860781e-02f, -4.63596545e-02f, 5.42016514e-02f, 8.31472203e-02f, 3.19844112e-02f, -5.27787767e-02f, 7.22189918e-02f, 9.07175522e-03f, -3.65784019e-03f,
  -3.79675180e-02f, -7.21342191e-02f, -3.56075764e-02f, 7.25642517e-02f, 1.89804304e-02f, -7.49351904e-02f, 2.34820526e-02f, 1.99751314e-02f, -4.93881032e-02f, -2.46246830e-02f,
  2.35732332e-01f, -1.06510511e-02f, 1.16615422e-01f, -7.97947869e-02f, 1.50158266e-02f, 1.12849167e-02f, 3.84771489e-02f, 2.55268086e-02f, 3.98372225e-02f, 4.47267760e-03f,
  -2.96780374e-02f, -6.61126897e-02f, 2.50140447e-02f, 1.75935924e-02f, 3.25215841e-03f, -7.96487182e-02f, -9.68225673e-02f, -6.69774488e-02f, -7.46387541e-02f, -1.44379856e-02f,
  -3.36388983e-02f, -1.18338324e-01f, 5.96399568e-02f, 1.11259453e-01f, -2.12012623e-02f, 3.46194617e-02f, 2.28374690e-01f, 6.39249682e-02f, 1.09730080e-01f, 9.08323005e-03f,
  3.34934741e-01f, 1.84195951e-01f, 6.57566264e-02f, 1.25491321e-01f, -1.06531411e-01f, 6.96644783e-02f, 1.94671378e-02f, 1.24373302e-01f, 1.49832845e-01f, 1.63225129e-01f,
  9.40422714e-02f, 1.14342704e-01f, 1.45562559e-01f, 4.92380783e-02f, 1.50338724e-01f, 1.86055034e-01f, 1.35471806e-01f, 1.89946234e-01f, 1.78810239e-01f, 4.37765159e-02f,
  6.18572868e-02f, 1.08197108e-01f, 1.61521822e-01f, 9.80601385e-02f, 1.91358730e-01f, 5.27538434e-02f, 1.09702177e-01f, 1.59717381e-01f, 7.12150410e-02f, 2.36746833e-01f,
  7.02421889e-02f, 2.57688105e-01f, -8.17960203e-02f, -1.13198943e-01f, -9.70713142e-03f, 9.83515941e-03f, -7.37085342e-02f, 3.05458922e-02f, -6.15556091e-02f, 7.00297654e-02f,
  -1.52572850e-02f, 8.03450346e-02f, -4.50221039e-02f, -4.88671176e-02f, 6.31005678e-05f, -9.03842505e-03f, -1.36080319e-02f, 1.45713642e-01f, 1.62316731e-03f, 1.47916814e-02f,
  -7.41512105e-02f, -3.25597152e-02f, -1.70166492e-01f, -1.41903594e-01f, 1.21379383e-01f, -1.37748033e-01f, 3.96284238e-02f, 6.09343983e-02f, -2.25578099e-02f, 5.69552667e-02f,
  7.21129999e-02f, 5.86225055e-02f, 3.89180854e-02f, 1.11679018e-01f, 2.37300754e-01f, 2.82080323e-02f, 7.05266818e-02f, 1.07708693e-01f, 5.65433362e-03f, 3.89357433e-02f,
  1.18344389e-02f, 3.04455459e-02f, 3.24103758e-02f, 6.79621696e-02f, 4.01178724e-04f, -1.81953628e-02f, 1.39948470e-03f, 3.39983813e-02f, 4.76949150e-03f, -1.31674325e-02f,
  6.14903830e-02f, -1.61806997e-02f, -6.99965730e-02f, 1.32484749e-01f, -3.90999466e-02f, 1.19674802e-01f, 2.76371222e-02f, -2.00700779e-02f, 1.27087338e-02f, 2.11856421e-02f,
  -4.05451685e-01f, -1.27689764e-01f, 7.09921047e-02f, -3.84246334e-02f, -5.55174462e-02f, -6.40633255e-02f, -2.94711459e-02f, -3.67650017e-02f, -7.79523104e-02f, -3.50727849e-02f,
  -1.24352261e-01f, 6.95794821e-02f, -1.16704069e-02f, 1.14124548e-02f, 3.42476778e-02f, -6.03537299e-02f, -9.21015907e-03f, -1.32836863e-01f, -1.45662978e-01f, -1.52251631e-01f,
  -1.43831551e-01f, -1.28913239e-01f, -2.83371150e-01f, -1.51029363e-01f, -1.24599345e-01f, -1.59775004e-01f, -1.52801305e-01f, -5.69479503e-02f, -2.25042462e-01f, -1.74405500e-01f,
  -1.44535154e-01f, -4.67451304e-01f, 1.86331287e-01f, -1.17583998e-01f, -1.89631119e-01f, -2.65342295e-01f, -5.70502639e-01f, -2.33095556e-01f, -3.68789546e-02f, -4.68301237e-01f,
  -2.54449338e-01f, 1.49375200e-01f, 2.21317932e-01f, 1.17179379e-01f, 6.46011978e-02f, -4.11309510e-01f, -5.62863722e-02f, 3.30202043e-01f, 2.89625436e-01f, -2.70819813e-01f,
  -3.28780532e-01f, -6.90417271e-03f, 2.68062294e-01f, 1.92656338e-01f, -2.93421835e-01f, 1.10399961e-01f, 7.80278891e-02f, -6.84590712e-02f, -1.86515927e-01f, -2.76578814e-01f,
  -2.32504800e-01f, -8.06506351e-02f, 1.63814798e-01f, 1.39412627e-01f, 4.26723622e-03f, 4.36504371e-02f, -6.42791167e-02f, 1.37369022e-01f, 5.22926869e-03f, -6.28060773e-02f,
  -3.29043455e-02f, -5.33548407e-02f, 7.49456137e-02f, 2.83089634e-02f, -9.11784694e-02f, -4.86266315e-02f, 1.18416108e-01f, 1.11786738e-01f, 4.27282974e-02f, -1.90728486e-01f,
  -2.74235636e-01f, -8.33682343e-02f, 1.45380080e-01f, -1.52677512e-02f, 4.02585790e-02f, 2.30049372e-01f, 5.24235293e-02f, 3.81865166e-02f, 1.38092592e-01f, -2.81082213e-01f,
  -3.58593166e-02f, 1.42153844e-01f, 5.10942610e-03f, -1.00463191e-02f, -6.86449790e-03f, 2.67951787e-02f, 3.41938101e-02f, -9.51741040e-02f, 2.48033926e-02f, 4.09901552e-02f,
  1.70440096e-02f, -3.37859839e-02f, 4.59844358e-02f, -5.10268807e-02f, -5.54077439e-02f, -2.76324637e-02f, -6.65419027e-02f, 1.12971459e-02f, 4.11023162e-02f, -6.97410628e-02f,
  8.87714103e-02f, -1.96732525e-02f, 8.04359838e-02f, 4.34867553e-02f, -3.33525836e-02f, 6.04579262e-02f, -4.70227748e-02f, 3.75558957e-02f, -2.09159255e-02f, -3.02538127e-02f,
  5.51832095e-02f, 2.76028305e-01f, -1.94693118e-01f, 3.32218558e-02f, -3.60889509e-02f, -1.13127213e-02f, -1.96164921e-02f, 6.33338615e-02f, 6.30513057e-02f, -4.63130958e-02f,
  -4.69186418e-02f, -1.23653248e-01f, -5.70357405e-03f, -3.66929057e-03f, -1.07021607e-01f, -1.16995154e-02f, -1.68626159e-01f, 8.88399500e-03f, 6.90947399e-02f, -1.41466320e-01f,
  -6.71496913e-02f, -1.24380328e-01f, -9.04807672e-02f, -4.35945839e-02f, -1.29527539e-01f, 1.24366835e-01f, 2.70413365e-02f, -5.37523925e-02f, 9.82616320e-02f, -3.92653733e-01f,
  3.98403496e-01f, 1.22599527e-01f, -5.40951908e-01f, 9.42379609e-02f, -2.84118146e-01f, -2.76592493e-01f, -1.37755156e-01f, -7.57806189e-03f, 8.16326290e-02f, 8.17509368e-03f,
  -1.18419945e-01f, 8.92440137e-03f, 3.31434719e-02f, 1.41170360e-02f, 3.74213196e-02f, -7.01600015e-02f, -1.58024937e-01f, -1.81901678e-01f, -2.47503325e-01f, -1.85300022e-01f,
  5.87964170e-02f, 2.01446429e-01f, 8.85291994e-02f, -4.46652621e-02f, -1.07443323e-02f, -7.15964809e-02f, -1.31893605e-01f, -8.38195756e-02f, -2.16553181e-01f, -2.16045856e-01f,
  -1.70838252e-01f, -2.33237460e-01f, -6.82001561e-02f, 4.30589579e-02f, -3.84458490e-02f, 1.25824637e-03f, 2.06196867e-03f, 1.18609481e-02f, -3.99988070e-02f, -6.34106696e-02f,
  -8.30813274e-02f, -1.43757284e-01f, -9.66037735e-02f, -7.45725408e-02f, -1.39215559e-01f, -1.07124016e-01f, -6.62286952e-02f, -8.90662149e-02f, -1.73989199e-02f, -1.18449330e-01f,
  1.18053183e-02f, -1.62754640e-01f, -1.97193205e-01f, -5.60168624e-02f, -1.33707196e-01f, -1.98550243e-02f, -1.69695213e-01f, -2.05325440e-01f, -1.53873578e-01f, 7.57128671e-02f,
  5.68622351e-02f, 4.67652343e-02f, -5.93492687e-02f, -6.26626564e-03f, 9.50664729e-02f, -1.46246143e-02f, -5.99087141e-02f, 5.17414697e-02f, 3.58614442e-03f, 8.22404474e-02f,
  -4.27039660e-04f, -9.71812755e-02f, -6.02072924e-02f, 3.88867110e-02f, 3.59681901e-03f, 9.39146988e-03f, 3.38923372e-02f, 4.29978929e-02f, 1.48784995e-01f, 2.98236813e-02f,
  3.03002391e-02f, -5.13231680e-02f, 4.98072356e-02f, 2.79667880e-02f, -1.01042747e-01f, -1.39141744e-02f, 4.06488180e-02f, 2.68325186e-03f, 8.19155872e-02f, 3.46245035e-03f,
  3.45244676e-01f, -1.02994964e-01f, 1.25165135e-01f, -1.72211900e-02f, -4.82684933e-02f, -6.12868182e-02f, 1.45786181e-01f, 5.21753170e-02f, 3.43475714e-02f, -4.63036299e-02f,
  -1.83417380e-01f, 4.73338030e-02f, 5.30944020e-03f, -5.48908338e-02f, -4.02232148e-02f, -9.38577726e-02f, 8.09271187e-02f, -1.01280712e-01f, 5.36327846e-02f, 3.97592708e-02f,
  1.25667036e-01f, 9.18861181e-02f, 1.55000016e-01f, 1.44120410e-01f, -2.28171516e-02f, 4.95365262e-02f, 2.82519609e-02f, -1.72793530e-02f, 9.85187143e-02f, 3.68168473e-01f,
  -4.20572132e-01f, -2.63921708e-01f, 6.23547994e-02f, 2.29453102e-01f, 2.44707257e-01f, 2.66429722e-01f, 3.03169012e-01f, 2.24008232e-01f, 1.43956736e-01f, -6.18339563e-03f,
  -1.38750449e-01f, -1.21349014e-01f, -1.36568069e-01f, -5.19169644e-02f, -8.65086168e-02f, 1.44610584e-01f, 2.23120168e-01f, 2.73479670e-02f, 9.79727879e-02f, 1.59073204e-01f,
  2.28102997e-01f, 3.87571864e-02f, -8.94179940e-02f, -8.26136395e-03f, -1.67227741e-02f, 1.25735179e-01f, 7.42508993e-02f, 2.63273697e-02f, 2.87544895e-02f, 1.60798803e-02f,
  -2.46894360e-01f, -3.28404158e-01f, 8.66679773e-02f, -7.99632519e-02f, -1.58388048e-01f, -5.40457219e-02f, -6.83932081e-02f, -1.63069889e-01f, -9.86008570e-02f, 5.06063104e-02f,
  -3.73250023e-02f, -1.15670629e-01f, -7.67131671e-02f, -9.22630131e-02f, 6.05391636e-02f, -4.46027257e-02f, -1.61070656e-02f, -7.44792670e-02f, 3.14600691e-02f, -1.33584365e-01f,
  -9.52414572e-02f, -3.70200500e-02f, 6.47032037e-02f, 5.38815372e-02f, 4.84925993e-02f, 2.14705262e-02f, 7.63564557e-03f, -5.09906001e-02f, 5.99860996e-02f, -3.39341499e-02f,
  1.92304060e-01f, 6.03804924e-02f, -6.44172803e-02f, -3.32242362e-02f, 6.81298748e-02f, -1.78615358e-02f, 5.81573769e-02f, 7.18851164e-02f, 1.10816173e-01f, 3.43898460e-02f,
  2.76470389e-02f, 2.18866281e-02f, 5.54331243e-02f, 2.68216967e-03f, -5.28392568e-02f, -5.56382202e-02f, 4.85886224e-02f, -8.95164981e-02f, -1.31787345e-01f, -1.24906071e-01f,
  4.49269973e-02f, 6.50028884e-02f, -4.13640626e-02f, -2.64417864e-02f, -6.80333748e-02f, -4.05268418e-03f, 4.38678227e-02f, -3.96041907e-02f, -2.31614485e-02f, 1.37675442e-02f,
  1.36006564e-01f, -3.79495360e-02f, 6.93036243e-02f, -4.78233323e-02f, 7.39255399e-02f, -6.89676180e-02f, -2.16961838e-03f, -1.08184427e-01f, -2.53958385e-02f, 1.07102804e-01f,
  -2.15184577e-02f, -1.57400202e-02f, -1.06808029e-01f, 8.31050053e-02f, 1.31281629e-01f, 9.63245928e-02f, -6.43771738e-02f, -3.86936814e-02f, 1.15139239e-01f, -4.10989597e-02f,
  2.25860756e-02f, 1.48578599e-01f, 1.42806023e-01f, 1.30221799e-01f, 1.82337925e-01f, 1.88582584e-01f, 1.27884731e-01f, 3.01809888e-02f, 5.20638414e-02f, 1.01090401e-01f,
  -2.04785503e-02f, 3.55914980e-02f, -1.80431440e-01f, 3.87113690e-02f, 8.11203867e-02f, -2.15005666e-01f, -5.08881450e-01f, -5.32609224e-01f, -7.63747469e-02f, 2.96240915e-02f,
  2.01060921e-01f, 2.49774992e-01f, 6.71452209e-02f, -3.08292825e-02f, -2.58613020e-01f, -2.62153447e-01f, -1.39725372e-01f, -1.13101244e-01f, -2.18561947e-01f, 3.36389318e-02f,
  2.53749073e-01f, 1.03420965e-01f, 6.39615953e-02f, -7.49050975e-02f, 2.22807184e-01f, 2.52450407e-01f, 9.15823430e-02f, 2.85301387e-01f, 1.79738581e-01f, 3.96667868e-01f,
  3.32086295e-01f, 1.40649891e-02f, -2.39980578e-01f, 1.07401662e-01f, 1.49044812e-01f, -1.97716020e-02f, 1.73042230e-02f, -7.28969574e-02f, -6.25114813e-02f, 6.49787113e-02f,
  2.17538044e-01f, 3.48524936e-02f, -1.09478263e-02f, 1.34769529e-01f, -2.24099271e-02f, 3.38432901e-02f, -2.72249449e-02f, -2.75456935e-01f, -2.63563871e-01f, 8.61255974e-02f,
  1.84037447e-01f, 2.80019045e-01f, -2.62880940e-02f, -3.01280826e-01f, -1.57564774e-01f, -1.86144356e-02f, -1.46631086e-02f, -4.65634093e-02f, -1.73081562e-01f, 1.28828719e-01f,
  -6.59406930e-02f, 7.52549917e-02f, 3.29589960e-03f, -1.78611111e-02f, -7.35517591e-02f, 2.99527626e-02f, 1.07906550e-01f, 2.90334709e-02f, 1.59787573e-02f, 8.92750733e-03f,
  -6.85430318e-02f, -4.39470746e-02f, -2.10007820e-02f, -6.20871335e-02f, 5.21485768e-02f, 5.92019707e-02f, 2.94996407e-02f, 4.65052798e-02f, -3.22199352e-02f, -4.01589237e-02f,
  -2.90423054e-02f, -2.56322734e-02f, 1.21530302e-01f, -1.20967068e-01f, -2.26322748e-02f, 4.04838519e-03f, 9.97159183e-02f, 2.66358983e-02f, 8.15108120e-02f, 1.47897005e-02f,
  2.02567190e-01f, -2.03742146e-01f, 5.53128757e-02f, -1.41421288e-01f, 9.74765867e-02f, -1.03626063e-03f, 7.86329657e-02f, -7.77223930e-02f, -1.82529837e-02f, -5.32792918e-02f,
  5.60298981e-03f, 1.55701563e-02f, 5.53109162e-02f, -1.48481093e-02f, -4.78009768e-02f, 8.32799524e-02f, 7.04168975e-02f, -3.20955878e-03f, -2.18138203e-01f, 1.18611664e-01f,
  -7.64522478e-02f, -1.77251279e-01f, -1.71149313e-01f, -2.22466111e-01f, 8.44214484e-02f, 2.71743201e-02f, 3.01542338e-02f, -2.35759355e-02f, -2.14638308e-01f, -1.35990784e-01f,
  -5.40101111e-01f, -1.47523239e-01f, 3.15793574e-01f, -3.03955644e-01f, -1.05863258e-01f, -2.76545528e-02f, -1.74647048e-01f, -1.08922713e-01f, -9.61456373e-02f, 3.40324230e-02f,
  1.36907520e-02f, -1.86412990e-01f, 1.66619960e-02f, -8.57863426e-02f, -1.23546600e-01f, 3.74029428e-02f, 1.12935521e-01f, 4.50203307e-02f, -7.47578144e-02f, -1.86008066e-01f,
  -1.85404956e-01f, -1.80863664e-01f, -9.48821828e-02f, -4.31428105e-02f, -1.03395343e-01f, -7.24893957e-02f, 1.76749140e-01f, -6.42525703e-02f, 7.00646192e-02f, -5.94019964e-02f,
  -3.48067470e-02f, -1.60160542e-01f, 1.19022608e-01f, -2.50353441e-02f, 1.24966446e-02f, -2.49303114e-02f, -5.84647851e-03f, 8.16498026e-02f, 1.26357852e-02f, 9.29281041e-02f,
  -8.47792532e-03f, 1.50356814e-02f, -9.35561284e-02f, -7.24757975e-03f, -5.12623079e-02f, 2.01722607e-02f, 1.25440627e-01f, 8.06775391e-02f, 4.70567830e-02f, 9.64472368e-02f,
  -7.03308359e-02f, -3.48348380e-03f, -6.19141012e-02f, 1.10122479e-01f, 1.77419931e-02f, -4.39006202e-02f, -1.11827236e-02f, 8.65194015e-03f, 1.31751537e-01f, -6.51619881e-02f,
  1.01179376e-01f, 9.46192965e-02f, 7.34647363e-02f, -2.44692396e-02f, -2.98062433e-02f, 1.41426390e-02f, 1.95834860e-02f, -4.46907990e-02f, 1.15773678e-02f, -8.55969340e-02f,
  6.62370250e-02f, -4.05272283e-02f, -1.56577083e-03f, -3.50885876e-02f, 9.71440300e-02f, -3.24856862e-02f, -3.82285155e-02f, 1.82416029e-02f, 8.35205391e-02f, -1.14821354e-02f,
  -4.77805249e-02f, -2.15233434e-02f, 2.98364530e-03f, -3.14953811e-02f, 1.30180955e-01f, 9.71561149e-02f, -1.40741551e-02f, 3.43428925e-04f, 1.47320069e-02f, -5.42735197e-02f,
  -2.05852672e-01f, 2.88581759e-01f, -1.50168747e-01f, 8.73288959e-02f, -2.24956535e-02f, 1.11598507e-01f, -7.85272792e-02f, 8.10860544e-02f, -1.02539964e-01f, -1.01288728e-01f,
  -1.13124810e-02f, -1.14918575e-01f, -5.21180369e-02f, 9.13620368e-02f, 8.59393738e-03f, 4.45548333e-02f, 9.03315619e-02f, -2.61694882e-02f, 5.13996854e-02f, -1.65535714e-02f,
  3.71286720e-02f, -3.78978215e-02f, -2.19484478e-01f, -1.13877445e-01f, -4.71630469e-02f, -1.46159932e-01f, -1.82560414e-01f, -5.43962009e-02f, -8.02158657e-03f, -3.34813148e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  3.87032032e-01f, 3.79233152e-01f, 1.84368998e-01f, 4.77388561e-01f, 2.08608642e-01f, 2.04123855e-01f, 3.62020284e-01f, 2.28628188e-01f, 3.17539155e-01f, 2.38924846e-02f,
  5.37010968e-01f, 3.41096044e-01f, 4.12091166e-01f, 1.38857380e-01f, 3.00507337e-01f, 1.93549380e-01f, 1.44928873e-01f, 3.19367021e-01f, 1.19159676e-01f, 2.66664118e-01f,
  1.71982586e-01f, 1.04101896e-01f, 8.83331150e-02f, 2.26015195e-01f, 2.08720520e-01f, 3.16505522e-01f, 3.83045137e-01f, 9.89911929e-02f, 3.85541916e-01f, 3.87088716e-01f,
  3.61955941e-01f, 3.78778249e-01f, 1.94890544e-01f, 2.44191512e-01f, 2.66139001e-01f, 3.47951561e-01f, 3.34463298e-01f, 1.60636500e-01f, 2.31371284e-01f, 2.79622555e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.55887395e-01f, -2.36503407e-02f, -1.22188024e-01f, 1.01919882e-01f, -1.12400971e-01f, -9.79449823e-02f, 8.70217681e-02f, 9.40200686e-02f, 9.86080915e-02f, -1.81099683e-01f,
  8.19856301e-02f, -2.41552386e-02f, -1.68317929e-01f, 5.07468022e-02f, -6.99094124e-03f, -2.05587159e-04f, 1.21084221e-01f, 5.91002665e-02f, -1.24034271e-01f, 8.34386647e-02f,
  2.95043904e-02f, 7.85699785e-02f, -1.21824190e-01f, -1.31402075e-01f, 5.00806458e-02f, -2.05687985e-01f, -7.91242905e-03f, -2.18671970e-02f, 5.52439243e-02f, -1.18875448e-02f,
  2.68322349e-01f, -2.02104509e-01f, 1.11727633e-01f, 3.69575955e-02f, 6.76720515e-02f, 9.24990326e-02f, -6.22075330e-03f, -4.35333736e-02f, 1.36840820e-01f, -2.03362736e-03f,
  2.78364271e-02f, 4.57710922e-02f, -1.12579174e-01f, 6.71321079e-02f, -1.74708888e-01f, -2.37102956e-01f, -4.73814905e-02f, 1.12264372e-01f, 7.71794701e-03f, 3.45004089e-02f,
  2.15293795e-01f, -1.75278127e-01f, -3.77316698e-02f, 1.08471490e-01f, -1.21859409e-01f, -2.03337342e-01f, -2.41859332e-02f, 1.91803679e-01f, 3.82679924e-02f, -5.72272800e-02f,
  -8.10700580e-02f, -1.22376382e-01f, -8.79355371e-02f, 2.96583138e-02f, -2.93086972e-02f, 8.16750452e-02f, 3.59820649e-02f, 7.73070231e-02f, -6.02710359e-02f, 1.31898895e-01f,
  3.03486399e-02f, -8.33528489e-02f, -4.76415977e-02f, -9.95173603e-02f, 1.26663014e-01f, -1.35559577e-03f, -1.42840877e-01f, 5.76654337e-02f, -1.80914644e-02f, 7.42056370e-02f,
  1.02359466e-02f, 2.19537946e-03f, -6.90784305e-02f, -7.69910589e-02f, 2.64471583e-02f, -1.02430187e-01f, 1.25983283e-01f, -1.10920826e-02f, 1.45171046e-01f, 1.54828995e-01f,
  5.19393533e-02f, 6.68025017e-02f, -1.07943274e-01f, -1.05119862e-01f, -4.70718741e-02f, -4.02034260e-02f, 1.54583246e-01f, 8.34502578e-02f, -1.15469828e-01f, 2.70874411e-01f,
  -1.41567647e-01f, -6.37984425e-02f, -1.95497796e-02f, 2.25546926e-01f, 8.12609196e-02f, -2.02294394e-01f, 2.36833021e-01f, -2.97357202e-01f, -2.59304140e-02f, -4.80356365e-02f,
  5.49220666e-02f, 1.54221073e-01f, -3.93477269e-03f, -8.32794141e-03f, 1.55453965e-01f, -1.39382645e-01f, 7.92219788e-02f, 2.10493967e-01f, -4.36078012e-02f, -1.58597007e-01f,
  1.20843157e-01f, -4.49094214e-02f, -4.73242812e-02f, -2.13668764e-01f, 1.54432058e-01f, 8.60372633e-02f, 2.07253128e-01f, -8.91486034e-02f, -7.52450377e-02f, 1.53034329e-02f,
  -1.98687479e-01f, 8.38911459e-02f, -6.03081472e-02f, -1.58755276e-02f, 9.05280635e-02f, 5.14511429e-02f, -1.06784128e-01f, -1.94577575e-02f, -5.21818139e-02f, 6.59430772e-02f,
  -1.51497304e-01f, -2.76951622e-02f, 1.04364216e-01f, -2.24117432e-02f, 4.87951413e-02f, -8.05777013e-02f, -9.14351493e-02f, -2.42421981e-02f, 4.04726788e-02f, 2.49163322e-02f,
  -4.82995063e-02f, 6.93933964e-02f, -1.94807574e-01f, 2.77124047e-01f, 3.51570956e-02f, 7.19900280e-02f, -2.67987861e-03f, -8.04964378e-02f, 1.54046178e-01f, 9.85653847e-02f,
  -4.94711101e-02f, 1.32927194e-01f, -3.15397620e-01f, 3.20667922e-02f, -1.37065232e-01f, -6.45596534e-02f, -1.86942741e-02f, 8.71747732e-02f, 2.35037208e-01f, 3.36482725e-03f,
  6.79201409e-02f, -2.22728640e-01f, 2.76636798e-02f, 1.56833425e-01f, -1.09123606e-02f, -3.41347493e-02f, 1.30584165e-01f, 2.23598048e-01f, -1.22809373e-01f, -9.05878246e-02f,
  2.63272561e-02f, -6.11315779e-02f, -1.68633610e-01f, -1.73134923e-01f, 8.77428353e-02f, -1.19820371e-01f, 1.89300086e-02f, 1.79571494e-01f, -1.15750264e-02f, -2.22582862e-01f,
  -1.42197117e-01f, -1.03935249e-01f, 9.53807607e-02f, 1.87683124e-02f, -2.93160025e-02f, -9.86092631e-03f, -7.72364959e-02f, 4.76003848e-02f, 8.88604224e-02f, 4.27477844e-02f,
  1.11675553e-01f, -4.30684201e-02f, -4.13602730e-03f, 2.58732331e-03f, 3.32139172e-02f, -1.29344659e-02f, 7.52145723e-02f, 1.90968582e-04f, 9.63349715e-02f, 1.58881992e-01f,
  1.99551079e-02f, -1.53448865e-01f, 9.43610519e-02f, 2.64607202e-02f, -9.35705230e-02f, -4.20758314e-02f, -8.81984532e-02f, -1.14584051e-01f, -1.03830107e-01f, -2.76618451e-01f,
  5.49614877e-02f, 1.07462265e-01f, 2.21248016e-01f, -1.81126788e-01f, 6.92933053e-03f, 8.21619947e-03f, -1.02584437e-01f, 1.22162923e-01f, -1.98380589e-01f, -1.70921013e-02f,
  1.51246443e-01f, -1.26214266e-01f, -4.60002348e-02f, 1.74533261e-03f, -1.29805326e-01f, 1.33336976e-01f, -2.76697278e-02f, -2.03701347e-01f, -1.26896920e-02f, -3.28053348e-02f,
  -1.03955835e-01f, -9.75809526e-03f, 9.11553502e-02f, -9.59908292e-02f, -2.26959378e-01f, 1.57513797e-01f, -1.36231691e-01f, -2.04518065e-01f, 6.70169741e-02f, 1.71514317e-01f,
  1.61858767e-01f, 4.91709299e-02f, 9.28291902e-02f, -2.36625403e-01f, 4.43638861e-02f, 5.01663331e-03f, -4.87872362e-02f, -3.88742089e-02f, 1.86449997e-02f, -1.40473153e-02f,
  6.35988489e-02f, 4.16529104e-02f, -1.14865005e-02f, 9.11435392e-03f, 6.85935318e-02f, 5.43030538e-03f, -3.06375939e-02f, 3.03546712e-02f, -4.71240468e-02f, 2.77162734e-02f,
  8.21144283e-02f, 3.42892557e-02f, -2.19819210e-02f, 1.09701790e-01f, 3.92163061e-02f, -8.52901340e-02f, -2.45460439e-02f, 2.00796197e-03f, -4.31160107e-02f, -2.41270941e-02f,
  3.21863554e-02f, 3.28626335e-02f, -1.51825115e-01f, 7.80376419e-02f, -1.18289940e-01f, -2.44482942e-02f, 1.77571908e-01f, -7.05122650e-02f, -1.18662164e-01f, 2.22528651e-01f,
  1.53901204e-01f, 3.19881856e-01f, -2.83703297e-01f, -1.50200417e-02f, -5.46426177e-02f, -2.39745318e-03f, -2.26139780e-02f, -1.04212992e-01f, 8.34580511e-02f, -3.83560061e-01f,
  2.97212042e-02f, 6.35445863e-02f, 6.64243326e-02f, 1.46583661e-01f, -3.78271863e-02f, 8.36834684e-02f, 4.69094850e-02f, 7.85410479e-02f, 4.39498015e-02f, 2.00178444e-01f,
  -2.26305336e-01f, -2.08151042e-01f, 7.84125328e-02f, -2.57614180e-02f, -2.27648094e-02f, -7.44101405e-02f, 8.31891596e-02f, -5.91313560e-03f, 1.57749131e-01f, -2.17396632e-01f,
  -1.05459444e-01f, -7.38199428e-02f, 8.46899152e-02f, -6.54608617e-03f, -6.17698394e-02f, -4.96382965e-03f, -6.84320405e-02f, -2.89520286e-02f, 9.86452326e-02f, 1.33765593e-01f,
  -6.08032718e-02f, -7.36013874e-02f, 1.80221777e-02f, -9.56814438e-02f, -1.80439413e-01f, -1.09586511e-02f, -7.20021948e-02f, 1.60715688e-04f, 7.82524869e-02f, -8.24804753e-02f,
  -4.76473086e-02f, -8.08101073e-02f, 1.79519147e-01f, 1.46665365e-01f, -1.64887577e-01f, -4.01908569e-02f, 1.78277552e-01f, 3.20473947e-02f, 7.91869760e-02f, 2.83175278e-02f,
  -7.33262375e-02f, 1.79280713e-01f, 1.14743061e-01f, -3.95132564e-02f, -1.27895921e-01f, 5.79521991e-02f, 3.41134816e-02f, 1.18066207e-01f, 1.13887593e-01f, 3.30085158e-02f,
  -1.61073804e-01f, -9.69737172e-02f, -7.78821856e-02f, 1.21105649e-01f, -1.94455013e-01f, 1.63645700e-01f, -6.89664250e-03f, 9.52647179e-02f, 7.75602907e-02f, 3.85369882e-02f,
  9.75707620e-02f, -2.14776900e-02f, 5.64796664e-02f, 8.58792439e-02f, -1.34588435e-01f, -6.07416481e-02f, -1.16070472e-01f, 1.40663773e-01f, -6.40390888e-02f, -3.57946157e-02f,
  4.32579704e-02f, -1.55972749e-01f, 2.09676445e-01f, -4.68988828e-02f, 1.22814022e-01f, -3.45945219e-03f, 2.30400097e-02f, -5.15988329e-04f, -7.95911700e-02f, -9.42175165e-02f,
  8.69352371e-02f, 1.53647065e-02f, 1.84189767e-01f, -8.92459303e-02f, 6.13036677e-02f, -2.00190395e-02f, -7.80981928e-02f, 7.46398941e-02f, 7.39214569e-02f, -3.82365659e-02f,
  8.87370855e-03f, -1.98548846e-02f, -5.94305769e-02f, 5.43534495e-02f, 4.20229463e-03f, 7.91987479e-02f, -5.36312014e-02f, -9.45102870e-02f, 6.09832350e-03f, -1.24249525e-01f,
  -2.81610131e-01f, 1.52853370e-01f, 1.68538585e-01f, -1.02835298e-01f, 2.30092689e-01f, -8.94613340e-02f, -1.07725292e-01f, 9.15410966e-02f, 1.79696083e-01f, -5.24628423e-02f,
  -2.45093226e-01f, 1.65294632e-01f, 9.76525322e-02f, -1.09616123e-01f, 2.78102909e-03f, 5.16330637e-02f, 7.58487806e-02f, 2.23287225e-01f, 4.94129248e-02f, -1.91375896e-01f,
  2.03146078e-02f, 4.93682437e-02f, -7.31419027e-02f, -6.63445592e-02f, -6.89041195e-03f, -1.91900581e-01f, -1.02931723e-01f, 3.79026942e-02f, 8.20301194e-03f, -1.11318678e-01f,
  -1.18755989e-01f, 1.24528475e-01f, 1.46719376e-02f, 2.35387441e-02f, -1.24285124e-01f, 1.32060200e-01f, 4.54977527e-02f, 1.07888617e-01f, -2.46254429e-02f, 5.70474677e-02f,
  5.10164835e-02f, 6.91294000e-02f, 1.34375067e-02f, 1.40288591e-01f, 1.65352058e-02f, -3.35781686e-02f, 4.38815467e-02f, -1.38635766e-02f, -2.00373344e-02f, -5.75397871e-02f,
  -4.09500524e-02f, 7.82539770e-02f, -2.84083094e-03f, -9.35268104e-02f, 3.54129784e-02f, -3.81665677e-02f, -1.23370685e-01f, -3.46635059e-02f, 5.23236729e-02f, 2.57653803e-01f,
  -1.42040029e-01f, -8.11658874e-02f, 2.03368306e-01f, 1.95094481e-01f, -2.14454476e-02f, 2.27622703e-01f, 1.63473696e-01f, -5.08177467e-02f, 5.52456118e-02f, 9.01479647e-02f,
  -1.52315688e-03f, 1.02323398e-01f, 7.87877291e-02f, -1.31552622e-01f, -2.11876705e-01f, 1.56563222e-01f, -5.75975748e-03f, -7.56457970e-02f, -1.61267355e-01f, -1.29470602e-01f,
  1.19191036e-01f, -2.24150002e-01f, 1.54522896e-01f, 1.62971422e-01f, 1.53735846e-01f, -9.03035477e-02f, -1.45883963e-01f, -8.21654946e-02f, -2.96174679e-02f, -1.26303568e-01f,
  -9.39767733e-02f, -1.50448084e-01f, -1.94512922e-02f, -1.28371075e-01f, -6.56429008e-02f, -1.81100350e-02f, 6.88664243e-03f, 1.76588327e-01f, 7.95787200e-02f, 1.38402939e-01f,
  -2.31136456e-01f, -8.43638331e-02f, -6.85919449e-02f, -1.00352895e-02f, 4.45303172e-02f, 5.77992899e-03f, -2.93015353e-02f, 7.81825706e-02f, -3.46630365e-02f, 3.77371944e-02f,
  -1.51840180e-01f, 6.09787442e-02f, -6.63861856e-02f, -9.99713168e-02f, -4.94797714e-03f, 1.25062600e-01f, -4.31317426e-02f, -1.92080870e-01f, -5.29500954e-02f, -7.19256997e-02f,
  -6.55878112e-02f, -5.88588417e-03f, 5.78075722e-02f, -4.70759906e-02f, -3.50460038e-02f, -9.66222361e-02f, -1.58733323e-01f, 1.57750636e-01f, -1.81493422e-04f, 2.09307536e-01f,
  1.02285311e-01f, -9.59091261e-02f, -1.89957619e-01f, 1.05662964e-01f, -2.80456822e-02f, -1.46310583e-01f, 1.63497940e-01f, -1.69263124e-01f, -1.73790589e-01f, 1.13628037e-01f,
  -7.40863457e-02f, 2.55455047e-01f, -2.31058940e-01f, -1.13517307e-01f, -8.93456936e-02f, -1.51249707e-01f, -7.16091245e-02f, 2.49015003e-01f, 5.80717549e-02f, 4.20958251e-02f,
  -4.95509729e-02f, -1.52544547e-02f, -1.24591798e-01f, -8.99285525e-02f, -8.26808885e-02f, -9.80440304e-02f, -2.02034205e-01f, -6.58554509e-02f, -1.46712676e-01f, -1.40140891e-01f,
  -1.57363921e-01f, 1.59650415e-01f, 1.54677257e-01f, 1.15189783e-01f, -5.50207645e-02f, -1.32503271e-01f, -1.02326386e-01f, -4.19716584e-03f, 8.81562456e-02f, 3.37019414e-02f,
  1.48104727e-02f, 8.13380629e-02f, -1.33540258e-01f, -3.24355252e-02f, 2.91682910e-02f, 1.80692819e-03f, -3.80674675e-02f, 1.49036013e-03f, 1.20747074e-01f, 2.80145686e-02f,
  -1.83313832e-01f, -3.94855030e-02f, -1.33328035e-01f, -5.43073863e-02f, 2.61911936e-02f, -3.46857794e-02f, 6.14515170e-02f, 4.15874235e-02f, 4.67916578e-02f, 8.21823429e-04f,
  6.07224852e-02f, 7.83087090e-02f, -2.06362158e-02f, -1.52973145e-01f, 1.09475993e-01f, 7.63420090e-02f, -2.29249805e-01f, -9.85587854e-03f, 5.09282686e-02f, -1.02346294e-01f,
  1.20887207e-02f, -2.24389017e-01f, 1.56417802e-01f, -2.04818207e-03f, 1.56289637e-01f, -3.44441682e-02f, -9.01991427e-02f, -8.10228810e-02f, -1.05460145e-01f, 1.35478497e-01f,
  1.04287311e-01f, 1.27910033e-01f, -7.11537972e-02f, -4.97362465e-02f, 9.91224125e-02f, -1.80019096e-01f, -5.97798731e-03f, -4.06659208e-03f, -6.07760251e-02f, 7.75987357e-02f,
  2.55811632e-01f, 1.63413107e-01f, -1.05263300e-01f, 8.04236382e-02f, -1.45104159e-05f, 1.15619153e-01f, 1.25812858e-01f, -8.00813660e-02f, 7.26609752e-02f, 2.37557795e-02f,
  2.21372452e-02f, -1.63804162e-02f, 8.01709071e-02f, 3.16285416e-02f, 6.16126172e-02f, -9.37118679e-02f, -1.24138929e-01f, -4.07969020e-02f, 1.98692560e-01f, -6.61470667e-02f,
  1.42598599e-02f, 4.14837301e-02f, -3.93437333e-02f, 4.24649455e-02f, -1.30199164e-01f, 1.33980766e-01f, -5.38668148e-02f, 1.16738461e-01f, 8.12839866e-02f, -8.18184987e-02f,
  -1.20439284e-01f, -1.29662529e-01f, 1.61056340e-01f, 3.66909765e-02f, 1.50929600e-01f, -2.23095328e-01f, -1.26657292e-01f, 9.24597960e-03f, -1.12178043e-01f, 8.08796063e-02f,
  -2.36256376e-01f, -3.67671661e-02f, 1.78661570e-01f, -1.25730738e-01f, 3.05760354e-01f, -6.12926669e-02f, 1.25881925e-01f, -1.55172363e-01f, 3.00428066e-02f, 5.11724018e-02f,
  -1.30334020e-01f, 7.04289898e-02f, 7.67335221e-02f, 1.00372009e-01f, -2.19592556e-01f, -8.78300071e-02f, -1.63503692e-01f, 2.85983924e-02f, 2.58457623e-02f, -1.33085564e-01f,
  1.28332987e-01f, 1.90906703e-01f, -2.31417418e-01f, 1.39661625e-01f, 1.13634557e-01f, 1.60404950e-01f, 4.10719663e-02f, -1.22555621e-01f, -1.81300435e-02f, -3.48410279e-01f,
  6.23000264e-02f, 9.12725851e-02f, 3.13967496e-01f, -9.01746005e-02f, -2.98051741e-02f, -1.51031734e-02f, 3.73300239e-02f, 6.08658940e-02f, -1.35047019e-01f, 5.24691269e-02f,
  9.93015766e-02f, 2.27909535e-02f, -2.31608972e-02f, 1.82769254e-01f, -2.13440787e-03f, 1.71973780e-02f, 1.17372563e-02f, 7.33113382e-03f, 1.28614038e-01f, -5.68025708e-02f,
  -3.36180888e-02f, -4.75379303e-02f, 1.06770181e-04f, 1.28993139e-01f, -2.80087460e-02f, 5.18853031e-02f, -1.63481042e-01f, 9.24845599e-03f, -2.70218968e-01f, 6.33097142e-02f,
  9.85671431e-02f, 5.64231463e-02f, 1.33291155e-01f, -5.71305119e-02f, 1.78423077e-01f, 4.35996316e-02f, -2.07923025e-01f, 1.91183940e-01f, 8.82234499e-02f, -1.74288207e-03f,
  1.19028144e-01f, 1.44163296e-01f, 1.48250209e-03f, 9.87767279e-02f, 6.13336451e-02f, 7.66167715e-02f, 9.00630131e-02f, 1.80486381e-01f, 1.11128561e-01f, -2.69996990e-02f,
  2.33484387e-01f, -1.35118529e-01f, -3.48285884e-02f, 1.73380047e-01f, -2.04189345e-01f, -3.06327008e-02f, 1.72081754e-01f, -2.30935723e-01f, -2.57167429e-01f, -8.61721784e-02f,
  1.06134593e-01f, 2.40790769e-01f, 1.57984227e-01f, 5.48107140e-02f, -2.71486007e-02f, -1.17152601e-01f, -1.60092190e-01f, -2.97494698e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -1.30823717e-01f, -1.18665732e-01f, 2.13353947e-01f, -2.56357435e-02f, 1.74611077e-01f, 9.62980539e-02f, -1.80213064e-01f, -5.91802187e-02f, -2.15944380e-01f, -1.61300659e-01f,
  -6.02176413e-02f, -5.99823482e-02f, 9.72886011e-02f, 4.42174785e-02f, -1.71000227e-01f, 6.24347106e-02f, -2.40829542e-01f, -1.03524432e-01f, 1.09351873e-01f, -7.55926371e-02f,
  1.20867893e-01f, -1.33112788e-01f, 1.20268822e-01f, -2.24837624e-02f, 2.35623568e-01f, 3.51514250e-01f, 1.55970715e-02f, 1.00266568e-01f, -1.83104854e-02f, 7.11058602e-02f,
  -2.99054295e-01f, -4.59400378e-02f, 3.60977083e-01f, 4.60187718e-02f, -1.21992849e-01f, 4.58107680e-01f, -1.61628649e-01f, -1.24826245e-01f, 7.91718811e-02f, 6.05163053e-02f,
  -2.57786065e-02f, -2.13094965e-01f, -1.34049743e-01f, -2.25877240e-01f, 1.53546244e-01f, 2.43723959e-01f, 5.19547472e-03f, 1.28743589e-01f, 2.55962402e-01f, -2.41741389e-01f,
  -3.10182236e-02f, 1.42994300e-01f, -1.23332843e-01f, 1.30311072e-01f, 1.30272150e-01f, 6.82961866e-02f, 1.88290820e-01f, -1.09347880e-01f, 5.22378460e-02f, 9.08501912e-03f,
  1.17290571e-01f, 4.48074229e-02f, 4.10574943e-01f, -2.41674691e-01f, 2.10701495e-01f, -1.95070636e-02f, 1.18906431e-01f, 2.05206275e-01f, 1.72803253e-01f, 2.87768722e-01f,
  1.19248196e-01f, 1.53703213e-01f, 5.21897785e-02f, 2.49645337e-01f, 1.55982882e-01f, 8.47306252e-02f, 2.85530910e-02f, 8.96128267e-02f, 8.13367143e-02f, -9.36538577e-02f,
  -5.43281995e-03f, 4.23658527e-02f, -8.26493800e-02f, -1.32646054e-01f, 5.76291643e-02f, -3.71647514e-02f, -3.38824242e-01f, -1.17018156e-01f, 2.10107192e-01f, 2.96144068e-01f,
  2.89434642e-02f, 2.52037257e-01f, 1.49860039e-01f, 1.80064097e-01f, -4.32924405e-02f, 9.44486037e-02f, -8.26132745e-02f, 1.29488543e-01f, 5.81301153e-02f, 2.55000204e-01f,
  -4.97340679e-01f, 2.24644635e-02f, 8.36415309e-03f, 5.70674650e-02f, 3.87277454e-02f, -1.07711203e-01f, -1.86633140e-01f, 5.31922281e-02f, 1.54095992e-01f, 3.11946481e-01f,
  -1.03267446e-01f, 1.69325277e-01f, -2.08618045e-01f, -3.04148227e-01f, 8.61931741e-02f, 1.07656419e-01f, -4.50807005e-01f, 7.89627507e-02f, 1.36563599e-01f, -1.02275200e-01f,
  3.02798361e-01f, 2.00197071e-01f, 1.02133714e-01f, 4.97272238e-02f, 3.35717618e-01f, -8.75187293e-02f, 3.18402022e-01f, -2.18444586e-01f, 2.31770203e-01f, 1.21144302e-01f,
  9.21384171e-02f, 2.19941765e-01f, 1.70294166e-01f, 2.09157184e-01f, 8.71390775e-02f, 6.21147528e-02f, 2.72706121e-01f, 2.53735930e-02f, 1.74461201e-01f, 8.98867026e-02f,
  1.10183410e-01f, 6.04912564e-02f, 1.31442267e-02f, -6.11983985e-02f, -1.29104033e-01f, -1.15648303e-02f, 5.27905934e-02f, 2.46676560e-02f, -9.10126567e-02f, 1.46219745e-01f,
  5.33051677e-02f, 1.94306895e-02f, 7.23267347e-02f, -1.21861070e-01f, 1.03728890e-01f, 1.02672473e-01f, 1.41694337e-01f, -1.07496768e-01f, 2.19268575e-01f, 1.57680407e-01f,
  -2.79675964e-02f, -7.91905914e-03f, 4.67235088e-01f, -1.52647763e-01f, 1.78623185e-01f, -9.33976471e-02f, -3.32767628e-02f, -4.36283648e-02f, 1.36364475e-01f, 1.36801645e-01f,
  2.27735475e-01f, 1.36243105e-01f, -1.08326308e-01f, -1.38947770e-01f, 2.66587827e-03f, 9.84567106e-02f, 9.95720252e-02f, -8.42918456e-02f, 1.64368272e-01f, -7.50231594e-02f,
  7.96795189e-02f, 1.74351856e-01f, 2.55846918e-01f, 1.80237159e-01f, -1.48783177e-01f, 1.39526263e-01f, -8.99064317e-02f, 2.97181338e-01f, -4.40128818e-02f, 2.06029937e-01f,
  -1.99246287e-01f, 3.43719423e-01f, 1.07528195e-01f, 1.16282567e-01f, 1.35949980e-02f, 1.68753386e-01f, -2.58209445e-02f, 2.57578224e-01f, 1.27357468e-01f, 2.37887025e-01f,
  3.04454833e-01f, 4.01229411e-02f, 2.03083158e-01f, 1.71127692e-01f, -1.67335913e-01f, 7.84456506e-02f, 1.64526984e-01f, -1.94097608e-02f, 4.68346365e-02f, -3.88457589e-02f,
  -1.50334165e-01f, 3.91726717e-02f, 1.94384716e-02f, 5.99554777e-02f, 1.10142473e-02f, 3.88751775e-02f, -2.26412371e-01f, 3.83409373e-02f, 1.20687284e-01f, -1.78109482e-01f,
  -1.46736577e-01f, -3.59709002e-02f, 4.37902302e-01f, -7.22021237e-02f, -6.99597597e-02f, 5.15615940e-02f, -2.59719670e-01f, 1.77042410e-01f, 2.32806236e-01f, -6.54988289e-02f,
  1.48190960e-01f, -1.53368592e-01f, -9.40456614e-03f, 1.82605952e-01f, 7.19712973e-02f, 1.17288537e-01f, -1.07431328e-02f, -2.81287581e-01f, -9.47175473e-02f, 1.04030497e-01f,
  8.83669555e-02f, 4.48896527e-01f, 2.11360395e-01f, -3.38914663e-01f, 3.01335871e-01f, 2.70095170e-01f, 1.57654211e-02f, -9.49549899e-02f, 6.51300997e-02f, 9.81951877e-02f,
  1.62866607e-01f, 3.10661197e-01f, 8.74088779e-02f, -2.82250404e-01f, -2.25237891e-01f, 2.52061218e-01f, -9.09949243e-02f, 8.75760466e-02f, 1.53593114e-02f, 1.43797144e-01f,
  -2.81114355e-02f, 3.78739089e-02f, -6.05251268e-02f, 2.68353093e-02f, 5.86190745e-02f, 1.05680317e-01f, 4.63255355e-03f, 1.55724853e-01f, 8.95384699e-03f, 8.65407586e-02f,
  9.44129005e-03f, 7.29243457e-02f, -3.30250077e-02f, -8.13066065e-02f, 7.13664995e-05f, -1.28777415e-01f, 1.81762338e-01f, -2.13258207e-01f, 3.31822515e-01f, 2.17567235e-02f,
  -7.95758236e-03f, 2.09586486e-01f, 7.73513913e-02f, -5.94930314e-02f, -2.59591043e-01f, -7.93252438e-02f, 1.57420058e-02f, 1.01849601e-01f, 4.08363074e-01f, -1.18945897e-01f,
  1.18369581e-02f, -7.27057680e-02f, 3.71437997e-01f, -2.84130663e-01f, 3.85376513e-01f, 1.17434315e-01f, -2.10627347e-01f, 3.99526395e-02f, 3.30126315e-01f, 1.15617216e-01f,
  -1.53500646e-01f, 1.37872636e-01f, -2.67306894e-01f, -2.21515894e-01f, 1.52434886e-01f, 1.92167506e-01f, 2.34059617e-01f, -4.79545929e-02f, 3.34854752e-01f, 2.37740219e-01f,
  -6.83125108e-02f, 1.15087628e-01f, 1.06370412e-01f, -5.96772395e-02f, 5.01311757e-02f, -2.40448430e-01f, 1.94461092e-01f, -1.07600830e-01f, -2.93703284e-02f, 8.67090300e-02f,
  1.18690468e-01f, -1.37999281e-02f, 1.47473961e-01f, 1.14906698e-01f, 5.96563220e-02f, 1.13263644e-01f, 1.43600509e-01f, 1.80819139e-01f, 2.31846683e-02f, -1.16673857e-01f,
  1.14483818e-01f, -3.15473042e-02f, -9.55787152e-02f, -6.85507357e-02f, 1.67689174e-01f, 6.91894665e-02f, -6.75011128e-02f, 1.79344416e-01f, -1.03657711e-02f, -1.79335773e-02f,
  2.80891024e-02f, -5.87400943e-02f, 3.95268388e-03f, 2.53483336e-02f, -2.39652738e-01f, 5.37127145e-02f, 1.94116831e-01f, -1.49304196e-01f, -2.63830960e-01f, -6.16081692e-02f,
  2.97545999e-01f, -2.05813587e-01f, 1.35412887e-01f, -1.58748440e-02f, -1.78318575e-01f, 4.60115224e-01f, 1.02909043e-01f, -9.37284082e-02f, -1.32750973e-01f, 8.09606444e-03f,
  1.15070537e-01f, 1.59468967e-02f, 8.46346989e-02f, -3.75532880e-02f, 7.89464936e-02f, -2.09194005e-01f, 2.63624400e-01f, 1.72016114e-01f, 1.77927285e-01f, 2.49053314e-01f,
  1.97173804e-01f, 1.14155099e-01f, 2.38987416e-01f, 7.56952688e-02f, -9.45280343e-02f, 4.07613330e-02f, 1.33352309e-01f, -4.99797948e-02f, 8.91046971e-02f, 1.67906910e-01f,
  -3.71475890e-02f, -3.46251011e-01f, 1.96309745e-01f, 1.64016843e-01f, 5.76143945e-03f, -2.26911567e-02f, 1.27274707e-01f, 4.54407148e-02f, 2.21626475e-01f, 1.72093362e-01f,
  -1.49357498e-01f, 1.13893770e-01f, 2.01951370e-01f, 1.20676689e-01f, 4.34520990e-02f, 1.92701399e-01f, -3.95083092e-02f, 2.58411840e-02f, 6.62506670e-02f, -3.34261619e-02f,
  1.30440563e-01f, 8.56320783e-02f, -8.04818198e-02f, 1.39203191e-01f, -1.98618606e-01f, -5.39823659e-02f, 2.43700311e-01f, 1.30608112e-01f, 3.00803781e-01f, -5.60383163e-02f,
  -1.20567098e-01f, 2.15616927e-01f, -2.32318323e-02f, 1.59379676e-01f, -3.35840851e-01f, 2.77003586e-01f, 1.44684672e-01f, 2.12013237e-02f, 4.14451778e-01f, -3.08688492e-01f,
  3.86699766e-01f, -1.15927301e-01f, 1.21877722e-01f, 1.37654960e-01f, -1.15684725e-01f, 1.98742107e-01f, 1.17867649e-01f, 1.72866378e-02f, -2.25424573e-01f, 2.28496775e-01f,
  -3.12505394e-01f, -1.53511211e-01f, 2.81316898e-04f, 3.81786913e-01f, 2.11563885e-01f, 5.78048676e-02f, 3.74967247e-01f, 9.36565455e-03f, 3.24396133e-01f, 2.32444972e-01f,
  -1.79986537e-01f, -1.74818516e-01f, 2.23130081e-02f, -3.82443041e-01f, 8.64832103e-02f, 3.00660402e-01f, -1.17101520e-01f, 2.82172039e-02f, -3.10424715e-03f, 1.86123978e-02f,
  -9.07378942e-02f, 7.01648071e-02f, 3.31465378e-02f, -9.89516228e-02f, 1.44351825e-01f, 9.86932032e-03f, 4.40237112e-02f, 2.35011727e-01f, 2.79660635e-02f, -6.70667971e-03f,
  -1.64764374e-01f, -1.51397690e-01f, 5.03491908e-02f, -3.93519998e-02f, 7.14855865e-02f, -3.50323319e-02f, -3.93807143e-02f, 2.14639120e-02f, 9.03485268e-02f, -8.03732947e-02f,
  6.83688074e-02f, 3.56941223e-02f, -1.36782567e-03f, 6.53234720e-02f, -1.62336007e-02f, -1.34127751e-01f, 2.15209392e-03f, 2.38520950e-01f, 1.86891496e-01f, -1.29859284e-01f,
  -1.95481673e-01f, -3.56847141e-03f, -2.58891523e-01f, -2.13838533e-01f, 2.61510551e-01f, -2.85482630e-02f, -2.37054273e-01f, -1.56442504e-02f, 3.16105127e-01f, -9.31609571e-02f,
  1.65770516e-01f, 2.32786223e-01f, 1.76316917e-01f, -1.61877908e-02f, 1.09929241e-01f, -2.28699505e-01f, -6.85306266e-02f, 2.72105455e-01f, -1.49407744e-01f, -4.45017666e-02f,
  2.56170332e-01f, 9.11135040e-03f, 1.15683407e-01f, -3.79078425e-02f, 6.93072006e-02f, -1.68463569e-02f, 1.97040617e-01f, -9.38898474e-02f, 1.91242397e-02f, 6.51683360e-02f,
  -1.46027863e-01f, -5.20900860e-02f, 2.34542992e-02f, 1.18280761e-01f, 9.08035338e-02f, 3.89646031e-02f, 1.20141715e-01f, 1.17109224e-01f, -1.94146242e-02f, 5.25280647e-02f,
  6.57936931e-02f, 6.16038404e-02f, 8.26048106e-02f, 1.95952319e-02f, -1.85285732e-01f, -3.80864479e-02f, 8.84894133e-02f, -7.69811645e-02f, 1.73418477e-01f, 2.40159367e-04f,
  -1.36311367e-01f, 1.56513542e-01f, -1.48270398e-01f, 1.61195338e-01f, -8.15304667e-02f, -9.18523446e-02f, 1.47454485e-01f, -5.82127124e-02f, 2.63363600e-01f, 2.01977670e-01f,
  -1.30220260e-02f, 6.45756945e-02f, 3.92322578e-02f, 5.45294164e-03f, -1.43634388e-02f, -7.62011856e-02f, 3.62774968e-01f, 2.71151304e-01f, -2.79847030e-02f, 3.59611958e-02f,
  2.33476833e-02f, 2.03393828e-02f, 1.36147678e-01f, 1.30548514e-03f, 1.58137754e-01f, -1.59473002e-01f, -1.21390931e-01f, -1.40260249e-01f, -1.93393901e-01f, 3.62845778e-01f,
  -7.53050670e-02f, 5.11092067e-01f, -9.70257744e-02f, 1.17255345e-01f, 2.75457859e-01f, -1.96348533e-01f, -1.23638630e-01f, -4.95254211e-02f, 2.59525508e-01f, -1.40850544e-01f,
  1.84858158e-01f, -1.91850528e-01f, -1.80459842e-01f, 3.20579112e-02f, -1.35962546e-01f, -1.46826908e-01f, 1.51953653e-01f, 1.10486232e-01f, 1.00381702e-01f, 1.50939971e-01f,
  2.22317636e-01f, 1.30665436e-01f, 1.33159995e-01f, 4.92665637e-03f, 3.95999141e-02f, 7.00818077e-02f, 1.53813988e-01f, 1.61106929e-01f, 2.19299138e-01f, 1.02285258e-01f,
  -4.39434163e-02f, -1.48436632e-02f, -3.99163663e-02f, -6.75936490e-02f, -7.01088458e-02f, 4.69190031e-02f, 7.97373578e-02f, 2.83971190e-01f, -9.27828178e-02f, 3.40890139e-02f,
  2.70556182e-01f, 3.19648474e-01f, 8.90254602e-02f, 2.88652241e-01f, -2.46323403e-02f, -4.92148809e-02f, -2.38885805e-02f, 2.19733745e-01f, 1.03562035e-01f, 5.10823950e-02f,
  1.39378116e-01f, -4.03142869e-02f, -1.83961585e-01f, -1.82724427e-02f, 1.53140694e-01f, 1.39339358e-01f, -3.50323059e-02f, 7.84395561e-02f, 1.09538041e-01f, -1.47616997e-01f,
  8.87603536e-02f, 2.68754274e-01f, -1.31317023e-02f, -2.24856406e-01f, 2.10116178e-01f, -3.72657955e-01f, 5.44669107e-03f, 2.40518264e-02f, -3.09829175e-01f, -1.07706301e-02f,
  1.07363760e-01f, 8.75260383e-02f, 3.16008270e-01f, -2.11784206e-02f, 8.72167125e-02f, 4.65227634e-01f, 1.53640047e-01f, -3.76425497e-02f, -1.85299382e-01f, 1.28806427e-01f,
  2.84315407e-01f, 9.94511321e-03f, 1.18708931e-01f, 1.07343681e-01f, 9.45795998e-02f, 2.26739928e-01f, 1.15977172e-02f, 5.70578836e-02f, 2.60164171e-01f, 2.63384908e-01f,
  1.69611305e-01f, 8.15170854e-02f, -2.22137928e-01f, 1.01450428e-01f, -6.94254339e-02f, 8.55942890e-02f, -8.75785127e-02f, 1.89940035e-02f, -5.03327772e-02f, -4.63795811e-02f,
  -1.14050806e-02f, -4.27356958e-01f, 2.85668552e-01f, 8.41561407e-02f, 6.41663596e-02f, -2.85744704e-02f, 8.73736199e-03f, -3.51104289e-01f, 9.78091210e-02f, 2.23025680e-01f,
  7.22097605e-02f, -5.94446063e-02f, 1.20723188e-01f, -1.36631742e-01f, -1.30184188e-01f, -1.16109066e-02f, 4.45461273e-01f, 6.43988103e-02f, 1.73348039e-01f, 4.66029309e-02f,
  -5.77046461e-02f, -2.09977284e-01f, 8.95070657e-02f, 4.32149172e-01f, 8.71026330e-03f, -1.11771733e-01f, -2.04890311e-01f, 1.63210526e-01f, -1.05867729e-01f, 2.09655255e-01f,
  4.92196351e-01f, -8.13656822e-02f, 3.54722619e-01f, 4.30756420e-01f, 1.52123541e-01f, -3.03436592e-02f, -8.73085558e-02f, 1.98163986e-01f, 1.43359661e-01f, -4.49469149e-01f,
  2.68804044e-01f, -9.33832601e-02f, 2.57598907e-01f, -2.36999206e-02f, 3.01999211e-01f, 7.21462592e-02f, 2.96138916e-02f, 1.32243782e-02f, -2.97287442e-02f, 8.13747719e-02f,
  5.62664084e-02f, 1.88878357e-01f, 2.87756532e-01f, -7.95562752e-03f, 2.36849308e-01f, 1.18626378e-01f, -1.12030163e-01f, 2.78424527e-02f, 8.27137530e-02f, 1.73573382e-02f,
  4.54539061e-02f, 1.00188069e-01f, 1.64758936e-02f, -1.04732998e-01f, -8.23239703e-03f, -1.76607326e-01f, 8.12151134e-02f, 4.56641838e-02f, -1.18053429e-01f, -1.32695720e-01f,
  2.65419334e-02f, -1.97508946e-01f, -2.48725444e-01f, 1.15108341e-01f, 2.99508154e-01f, -1.92492798e-01f, 1.06167942e-01f, -9.54736099e-02f, -1.69619307e-01f, 2.81086177e-01f,
  8.56504440e-02f, -1.76014062e-02f, -2.24602446e-02f, 1.21691553e-02f, -1.09439731e-01f, 1.50626212e-01f, -1.16558790e-01f, 1.38074383e-01f, -8.76904279e-02f, -1.93999231e-01f,
  1.87125504e-02f, 3.33118647e-01f, 2.78378185e-02f, 7.43859485e-02f, 4.39702064e-01f, 2.02247500e-02f, 2.38549232e-01f, 2.88219720e-01f, 9.25422460e-02f, -1.04120456e-01f,
  -7.27318367e-03f, 1.04169786e-01f, 1.53075546e-01f, -3.56064811e-02f, 4.21693884e-02f, -1.84375837e-01f, 3.23532313e-01f, 2.12470964e-01f, 2.50196010e-01f, -1.03215622e-02f,
  6.60574138e-02f, 3.18592265e-02f, 1.78923354e-01f, 1.42907411e-01f, 8.88371393e-02f, 1.80632114e-01f, 1.86538175e-01f, 9.05448496e-02f, 1.82911038e-01f, 3.04803438e-02f,
  -9.95222852e-02f, -1.88775025e-02f, 1.02325790e-02f, 8.20459500e-02f, 1.05771814e-02f, 8.66047144e-02f, 1.76362619e-02f, -1.58165675e-02f, -4.02054116e-02f, -2.07910731e-01f,
  -1.66307956e-01f, -3.28859277e-02f, -4.36081439e-02f, -2.96848845e-02f, -1.42340153e-01f, 3.84721234e-02f, 1.82867140e-01f, 1.31893918e-01f, 9.84626263e-02f, -1.34150818e-01f,
  2.65182182e-02f, 1.09162107e-01f, 3.03968340e-01f, 4.26062107e-01f, -3.31476033e-01f, 2.30957456e-02f, -9.85420346e-02f, 8.85528252e-02f, 1.09957373e-02f, 5.02554551e-02f,
  -3.34945560e-01f, 6.61889911e-02f, 5.77086024e-02f, -1.32631600e-01f, 1.83627844e-01f, 3.75463814e-01f, -1.39096439e-01f, 1.35851175e-01f, 3.25247347e-01f, 7.04767406e-02f,
  2.78405994e-02f, 1.73331633e-01f, -5.21477163e-02f, -7.42680803e-02f, 4.14804108e-02f, 3.23635161e-01f, -1.88153074e-03f, -2.53657997e-01f, 1.71163425e-01f, -1.26511574e-01f,
  3.33261818e-01f, -2.47321993e-01f, -4.56326306e-02f, -1.02842830e-01f, 1.05012842e-01f, 2.64453795e-02f, 6.09310530e-02f, -2.69210972e-02f, 2.11797915e-02f, 8.57652947e-02f,
  -2.53566783e-02f, -6.11954145e-02f, 1.50548201e-02f, -1.54200091e-03f, 1.12297200e-02f, -3.68730281e-03f, -9.69173387e-02f, 7.84840137e-02f, -8.71991441e-02f, -1.22555923e-02f,
  1.23980358e-01f, -1.03927501e-01f, 1.50217507e-02f, -7.83056691e-02f, -6.31213039e-02f, 7.74740726e-02f, 8.28571916e-02f, 3.26982617e-01f, -8.31320882e-03f, 3.42192352e-02f,
  -1.11648411e-01f, 1.23585798e-01f, 5.65604195e-02f, 1.93277225e-02f, 3.35603058e-01f, 8.35661516e-02f, -2.16529950e-01f, 4.53422725e-01f, -2.41318300e-01f, -2.46870607e-01f,
  5.51159531e-02f, 2.15747058e-01f, 1.36664510e-01f, -1.22884713e-01f, -2.32868269e-01f, -3.06537002e-01f, 1.26789361e-01f, 1.91761747e-01f, 5.32363309e-03f, 1.09858580e-01f,
  3.38867068e-01f, -2.87188441e-01f, 3.81129943e-02f, 3.15725416e-01f, -2.87753284e-01f, 1.67724490e-01f, -6.42716587e-02f, -4.35809456e-02f, 2.83428699e-01f, -1.38138279e-01f,
  2.19575435e-01f, 9.27411690e-02f, 1.53829142e-01f, -1.43422291e-01f, 4.64065105e-01f, -2.27737933e-01f, 1.13522626e-01f, -3.01719941e-02f, 1.58001021e-01f, 1.23414546e-01f,
  1.83714762e-01f, 2.11698875e-01f, 2.41620392e-02f, 9.88430902e-02f, 1.32725850e-01f, 2.78920084e-01f, 1.72225177e-01f, 8.75550359e-02f, -1.76283672e-01f, 1.30182266e-01f,
  5.84112927e-02f, -7.39361793e-02f, -1.40496358e-01f, -1.00681327e-01f, -1.63977779e-02f, 4.46931608e-02f, 1.90831751e-01f, -1.50641158e-01f, 6.00423589e-02f, -2.26077288e-02f,
  1.16493009e-01f, 1.44652829e-01f, 7.25985393e-02f, -8.46262872e-02f, 5.34255803e-02f, -5.42054623e-02f, -9.95387882e-03f, 1.61556387e-03f, -1.95516884e-01f, 7.07000792e-02f,
  -1.50798693e-01f, -2.28943765e-01f, 1.22258462e-01f, -1.14990398e-02f, 1.30651534e-01f, 2.05181599e-01f, 5.29484078e-02f, -2.67914236e-01f, 3.46243754e-02f, 7.92908818e-02f,
  3.03653479e-02f, 5.79150841e-02f, -1.34538576e-01f, 1.20596662e-01f, -5.93862608e-02f, 3.57054025e-01f, 2.32059523e-01f, -3.32387239e-01f, 2.67213732e-01f, 3.06231439e-01f,
  9.53177139e-02f, -1.12355396e-01f, 1.03700638e-01f, 1.75314054e-01f, 8.73654485e-02f, -1.47067994e-01f, 2.97970384e-01f, 4.09147702e-02f, 1.12592680e-02f, -3.45844664e-02f,
  1.01852477e-01f, -2.97900662e-02f, 1.02679096e-01f, 1.07773244e-02f, 9.22893733e-02f, 1.03796825e-01f, 6.66804463e-02f, 4.30881828e-02f, 5.03216758e-02f, -4.05852683e-02f,
  -1.86137091e-02f, 4.18514200e-02f, -2.17871219e-02f, 3.17203626e-02f, -4.42779437e-02f, 2.10749898e-02f, -1.53239667e-01f, 8.64313729e-03f, 6.97071552e-02f, -1.66747540e-01f,
  1.17492549e-01f, -2.10476592e-01f, 1.07210591e-01f, -5.92737831e-02f, 1.08908616e-01f, 1.14706494e-01f, -2.09837798e-02f, -1.14755169e-01f, 1.07356451e-01f, 9.41640064e-02f,
  -1.13755584e-01f, -1.35159478e-01f, 2.39775702e-01f, 3.81506793e-03f, 6.26057535e-02f, 1.70076802e-01f, -1.37060538e-01f, -1.12784334e-01f, 2.24606067e-01f, 1.72151819e-01f,
  7.56855530e-04f, -2.00321749e-01f, -3.40406187e-02f, 4.63235043e-02f, -1.97853614e-03f, 8.67773294e-02f, -2.31834561e-01f, 2.79142976e-01f, 1.36519372e-01f, -1.35016546e-01f,
  2.40891635e-01f, -1.07563570e-01f, -1.14223786e-01f, 2.74341941e-01f, 1.93652019e-01f, -5.01571186e-02f, -1.22154476e-02f, 1.06013834e-01f, 4.78963256e-02f, -1.06517918e-01f,
  2.19539747e-01f, -5.48532121e-02f, 3.34834874e-01f, -9.20373052e-02f, 9.31905955e-02f, 8.48650634e-02f, 1.92424342e-01f, 1.00256413e-01f, 8.10526907e-02f, -8.69488157e-03f,
  7.82177038e-03f, 7.59669766e-02f, 2.19380423e-01f, 9.81432572e-02f, 1.41093597e-01f, 7.34289214e-02f, 2.32778694e-02f, -5.76999560e-02f, 6.09064773e-02f, 2.26809472e-01f,
  1.04571961e-01f, 2.53457427e-01f, 1.09991720e-02f, -2.85343472e-02f, 4.57445681e-02f, -7.21677914e-02f, 7.13120624e-02f, 1.19058013e-01f, 3.01173013e-02f, 1.15117105e-02f,
  -1.86297655e-01f, 2.10607741e-02f, 1.52590021e-01f, 2.85333633e-01f, 2.47690994e-02f, -2.54444350e-02f, 1.57405868e-01f, 8.22991952e-02f, 4.02158648e-01f, 2.44840682e-01f,
  -3.39105010e-01f, -9.16779488e-02f, -7.84159172e-03f, 2.19255626e-01f, -1.12155519e-01f, 1.44934818e-01f, -6.29434222e-03f, 3.99790928e-02f, 3.20061930e-02f, 9.93817896e-02f,
  2.22677980e-02f, 3.50524008e-01f, -2.92310357e-01f, -7.13814944e-02f, 1.52711034e-01f, 1.04897372e-01f, -1.75991818e-01f, 1.27629772e-01f, 3.49994540e-01f, 4.59532104e-02f,
  -7.00191483e-02f, -3.03252637e-02f, 1.38671264e-01f, -2.08233193e-01f, 2.45733097e-01f, -1.22286178e-01f, 4.41009641e-01f, -1.35661557e-01f, 1.56289011e-01f, 8.45557004e-02f,
  5.14737144e-02f, 9.07222331e-02f, -8.75739101e-03f, 1.38347432e-01f, -3.79624106e-02f, 9.79272798e-02f, 3.55936140e-02f, 1.71637520e-01f, 3.60253081e-02f, 3.66224274e-02f,
  -3.46620381e-02f, 8.86578560e-02f, 6.19794205e-02f, -4.76971827e-02f, 5.78765348e-02f, -3.84831498e-03f, -7.27042630e-02f, -1.19807143e-02f, 2.30104759e-01f, -1.30062982e-01f,
  4.76795658e-02f, 1.09716609e-01f, 2.05451045e-02f, 4.26011950e-01f, 2.41291150e-02f, 1.47078305e-01f, -6.48055002e-02f, 4.38822210e-02f, -1.37988841e-02f, -7.09154680e-02f,
  1.25308171e-01f, -4.88566905e-02f, -3.77594769e-01f, 3.95029366e-01f, -3.01339895e-01f, -1.05350047e-01f, 1.16786979e-01f, 4.25941616e-01f, 3.16585712e-02f, -3.57814848e-01f,
  -3.03074885e-02f, -9.45635810e-02f, 1.45277351e-01f, 2.80075580e-01f, 5.57140373e-02f, -8.50436091e-02f, 1.74255565e-01f, -2.56371409e-01f, 2.30002671e-01f, 1.12442493e-01f,
  -3.06790203e-01f, 3.70903522e-01f, 1.24862179e-01f, -1.85456678e-01f, 1.31142810e-01f, 4.36451249e-02f, 2.69670010e-01f, -2.16382910e-02f, 4.02209252e-01f, -2.45326832e-02f,
  3.69005978e-01f, -1.86623409e-01f, 1.33962091e-02f, 9.44455992e-03f, -7.72562027e-02f, 3.22178677e-02f, -3.97951938e-02f, -1.48623377e-01f, 1.23424813e-01f, 1.73459053e-01f,
  -2.73627155e-02f, 2.00030535e-01f, -3.54077816e-02f, 1.01168267e-01f, 9.97745693e-02f, -1.46650061e-01f, -5.81057072e-02f, 1.52873993e-01f, 1.26508474e-01f, 7.87848085e-02f,
  -7.02650249e-02f, 2.61754598e-02f, -8.61021280e-02f, 9.72019657e-02f, -1.50507599e-01f, -6.03525527e-02f, 1.30469091e-02f, -2.18676165e-01f, -2.13627666e-01f, -1.88070592e-02f,
  1.96610317e-01f, 2.48485267e-01f, 2.58609563e-01f, 1.56982526e-01f, -5.26811965e-02f, -5.21375313e-02f, 2.54541606e-01f, -1.12898476e-01f, 1.90999851e-01f, 1.21477947e-01f,
  -6.19187243e-02f, -2.11289287e-01f, 2.20136836e-01f, 2.47160599e-01f, -6.60375953e-02f, 5.54654956e-01f, 8.36678147e-02f, 9.96251553e-02f, -4.25715968e-02f, 5.41503318e-02f,
  2.05852278e-02f, -1.04524810e-02f, -6.95326999e-02f, 1.61601856e-01f, 2.99869981e-02f, -8.79128277e-02f, 8.90272260e-02f, 5.84621467e-02f, -1.72646996e-02f, 2.33667791e-01f,
  2.46332526e-01f, -2.71097481e-01f, -1.59777388e-01f, 1.38866156e-01f, -1.56214073e-01f, 4.00952250e-02f, -8.32639709e-02f, 1.19092567e-02f, 1.44093305e-01f, -3.97612602e-02f,
  9.73452702e-02f, -1.14946283e-01f, -9.74175856e-02f, 7.02711418e-02f, -3.18021998e-02f, -1.28391773e-01f, 1.50622632e-02f, 1.20087154e-03f, 2.28979155e-01f, -6.15503080e-02f,
  -2.15247780e-01f, 1.02411479e-01f, -1.17062956e-01f, 2.35842746e-02f, 1.24469206e-01f, -8.86726305e-02f, -3.91609967e-02f, -8.19782466e-02f, 2.31824681e-01f, 6.87988922e-02f,
  1.08922925e-02f, -2.26588808e-02f, -2.28668794e-01f, -6.29985556e-02f, -1.32230744e-01f, 2.15070590e-01f, -1.40287831e-01f, 1.54341131e-01f, 3.00991207e-01f, -2.66597569e-01f,
  7.02687204e-02f, 2.31375143e-01f, 3.73723507e-01f, -2.51772821e-01f, 7.48667419e-02f, 3.19294780e-02f, -9.53091532e-02f, 1.49963245e-01f, -7.58624822e-02f, 1.82975620e-01f,
  -1.61066622e-01f, 1.48513973e-01f, -1.31607920e-01f, -6.52543455e-02f, 3.19271564e-01f, -1.80406377e-01f, -2.50993639e-01f, 3.46373856e-01f, -1.26421273e-01f, -1.39607221e-01f,
  3.36266994e-01f, 4.97597784e-01f, -6.49857819e-02f, -6.75666109e-02f, 1.23381563e-01f, 1.99243367e-01f, -1.74527720e-01f, 9.14645419e-02f, 2.79815346e-01f, 1.64663583e-01f,
  -1.53719857e-01f, 2.07432732e-02f, -2.03010291e-02f, 1.36489496e-01f, 2.05693677e-01f, 1.14529535e-01f, -6.20477796e-02f, 5.74391708e-02f, 8.42810841e-04f, 2.37902045e-01f,
  1.02033913e-01f, 1.52622715e-01f, -7.82164484e-02f, -1.91439427e-02f, -7.48746693e-02f, -1.61511004e-01f, -5.73848709e-02f, -2.19004080e-01f, -1.25815585e-01f, 9.00482684e-02f,
  4.78895642e-02f, -3.32614928e-02f, 6.77534267e-02f, -4.95667867e-02f, 8.02181810e-02f, 4.62065279e-01f, 2.97316730e-01f, 2.31652334e-01f, -1.45370245e-01f, -1.74904481e-01f,
  -1.14316486e-01f, 2.75113553e-01f, 1.64337471e-01f, -1.77431945e-02f, -3.83709401e-01f, -1.74562365e-01f, 2.96696514e-01f, 1.15428492e-01f, 2.84284770e-01f, 3.26467425e-01f,
  1.44007921e-01f, -1.32731348e-01f, 9.10020843e-02f, -2.03320216e-02f, -2.00224146e-02f, 3.64924341e-01f, -1.42810643e-01f, -3.37514579e-01f, 4.53934431e-01f, 4.56618726e-01f,
  -4.33958583e-02f, 3.97307090e-02f, 3.11615855e-01f, 2.38966625e-02f, -1.43175190e-02f, 1.10299975e-01f, 3.09782594e-01f, -9.41864308e-03f, 6.26778528e-02f, 1.81676418e-01f,
  2.17407286e-01f, -1.18251041e-01f, -2.12037340e-01f, 8.07583705e-02f, 7.80296922e-02f, 3.94966602e-02f, 2.10743040e-01f, 8.67927298e-02f, 1.80147529e-01f, 3.30599368e-01f,
  -3.95703651e-02f, 5.44199683e-02f, 1.26494095e-01f, 1.51623115e-01f, 1.39811903e-01f, 1.38197958e-01f, -2.65114129e-01f, 1.61356091e-01f, 1.23853326e-01f, 4.52842861e-02f,
  1.76968962e-01f, 7.51739666e-02f, -1.72923282e-01f, 1.29700691e-01f, 2.98445746e-02f, -2.43590578e-01f, 3.86414289e-01f, 1.67794243e-01f, 2.23919079e-01f, 8.76044929e-02f,
  8.28365237e-02f, -5.06100804e-03f, -2.10928470e-01f, 7.91380703e-02f, -2.55902857e-01f, -1.17353639e-02f, 5.44830337e-02f, -8.70897807e-03f, 2.48320520e-01f, -1.06675282e-01f,
  1.89072862e-01f, -2.44484052e-01f, 3.86031680e-02f, 2.16254443e-01f, -3.37592661e-02f, -2.92879462e-01f, 1.49920076e-01f, -2.96499163e-01f, -1.49533562e-02f, 1.72786176e-01f,
  -1.30560175e-01f, 8.93877000e-02f, -1.00756966e-01f, 3.66732359e-01f, 2.81665921e-01f, -1.11412272e-01f, 2.46064469e-01f, 2.63945103e-01f, 3.09939057e-01f, 1.57781959e-01f,
  4.93416637e-02f, -2.42625266e-01f, -8.33500698e-02f, -2.92995512e-01f, 3.69863003e-01f, 1.99067131e-01f, 5.05959988e-02f, -1.04602396e-01f, 2.43938953e-01f, -7.55826849e-03f,
  1.62120368e-02f, 6.40374273e-02f, 1.85739264e-01f, 2.57562190e-01f, 9.98822749e-02f, 1.43529147e-01f, 1.03566848e-01f, 3.90666479e-04f, 6.99914619e-02f, 1.19981289e-01f,
  -1.50264516e-01f, 1.81335568e-01f, 1.58655271e-01f, -7.76044205e-02f, 1.10060035e-03f, -8.05816501e-02f, -1.28630221e-01f, 1.65060312e-02f, 1.67235006e-02f, 1.70771331e-01f,
  -1.82799041e-01f, 5.56516042e-03f, 3.00601304e-01f, 1.34478852e-01f, 3.00085992e-01f, 2.99182951e-01f, -4.60597910e-02f, -7.62622356e-02f, -1.57241132e-02f, 1.26747731e-02f,
  -1.66577727e-01f, -8.29565004e-02f, 3.57348859e-01f, 1.18464351e-01f, -1.09431393e-01f, 1.41587332e-01f, 5.53836972e-02f, 1.60872400e-01f, 1.19242258e-01f, -2.18324766e-01f,
  -1.50689324e-02f, -2.61868566e-01f, 7.83251673e-02f, -9.23798128e-04f, -5.20345978e-02f, 1.35204747e-01f, 1.18446663e-01f, 2.05491241e-02f, 2.42529333e-01f, -3.66119035e-02f,
  1.57194629e-01f, 1.79800346e-01f, -5.13995178e-02f, -3.39784771e-02f, 1.70010954e-01f, 1.14537276e-01f, -9.93193462e-02f, 1.16189219e-01f, 1.35334775e-01f, 2.79180050e-01f,
  -2.95286868e-02f, -3.11680660e-02f, 3.42522375e-02f, 1.37555465e-01f, -9.37502310e-02f, 1.05094709e-01f, -2.86779087e-02f, -1.11065902e-01f, 2.16960296e-01f, 5.67578152e-02f,
  9.89623666e-02f, 1.42944336e-01f, 1.21318683e-01f, 4.80743721e-02f, -1.56550989e-01f, -4.49088104e-02f, 1.36741683e-01f, 4.17991169e-02f, 2.22411841e-01f, 1.18273176e-01f,
  -1.44218773e-01f, 1.34558436e-02f, -1.53594688e-01f, 1.02901019e-01f, -1.11824378e-01f, 2.42104754e-02f, 5.08075431e-02f, -1.73657164e-02f, -1.15041924e-03f, -1.67752560e-02f,
  -9.58783627e-02f, 2.64119536e-01f, 2.43517831e-01f, -3.78115289e-02f, -1.68274611e-01f, -3.03561110e-02f, -4.96873148e-02f, -2.03626212e-02f, -8.95656794e-02f, -7.88902044e-02f,
  -1.40190095e-01f, 1.15512423e-01f, 1.90749332e-01f, 1.48340359e-01f, -1.54741332e-01f, -6.18299842e-02f, 1.34100959e-01f, -3.10016479e-02f, 1.58292353e-01f, -3.06379441e-02f,
  -7.18609318e-02f, 7.89886937e-02f, -1.37849629e-01f, -3.31493467e-02f, 4.33154404e-02f, -3.34206857e-02f, 1.03370287e-01f, -8.90660360e-02f, 9.49411169e-02f, -5.93979210e-02f,
  3.24440122e-01f, -1.70608357e-01f, -3.33101712e-02f, 1.04133196e-01f, -1.39703199e-01f, -4.36885804e-02f, -3.28510366e-02f, -8.91456828e-02f, 2.48593926e-01f, 2.61102244e-02f,
  -6.04032725e-03f, 1.04822174e-01f, -6.03216104e-02f, 1.47006929e-01f, 3.45417075e-02f, -4.87863459e-02f, 1.63628981e-02f, -2.92801950e-02f, 3.06753695e-01f, 3.38286087e-02f,
  -1.86623380e-01f, 1.76252853e-02f, -2.10771501e-01f, 5.08115366e-02f, 2.64372140e-01f, -1.41999111e-01f, -5.05061336e-02f, -2.71276794e-02f, 8.25264528e-02f, -2.41846349e-02f,
  -2.75959689e-02f, 8.54070410e-02f, -4.75032888e-02f, -7.72097036e-02f, 1.22567594e-01f, -1.19396243e-02f, 1.35762226e-02f, 2.95994841e-02f, 3.21763903e-01f, 1.37536347e-01f,
  -2.10431386e-02f, 2.43146271e-01f, 1.06605388e-01f, 1.35891363e-01f, 1.72174692e-01f, -2.68693388e-01f, 8.86075795e-02f, 2.61722170e-02f, 1.08849965e-01f, 2.96270430e-01f,
  1.64208859e-01f, -3.17382701e-02f, 1.49106830e-01f, -1.27186691e-02f, 1.09891608e-01f, -4.36882466e-01f, 2.39795540e-02f, 4.26452458e-02f, -1.94361240e-01f, 2.50110775e-02f,
  1.70521483e-01f, 2.99486071e-01f, 6.86501786e-02f, 1.25464141e-01f, 7.01729953e-03f, 2.65444368e-01f, -1.08217925e-01f, 7.45877996e-02f, 3.14751536e-01f, 1.38600543e-01f,
  1.17162906e-01f, 1.70643196e-01f, 1.79374188e-01f, 2.65399367e-01f, 2.15126559e-01f, 3.86928082e-01f, 8.99126828e-02f, 1.02342710e-01f, 3.04650158e-01f, 5.00614941e-02f,
  1.57277346e-01f, 2.18807548e-01f, -7.34727234e-02f, -3.99777200e-03f, 2.34749287e-01f, -7.36149922e-02f, 8.40258896e-02f, 5.71440496e-02f, -1.36952922e-01f, 1.96908921e-01f,
  -7.38732666e-02f, 2.33525664e-01f, 1.53640462e-02f, -3.03586572e-03f, 1.88101113e-01f, -2.69841105e-01f, 1.02152660e-01f, 2.41194308e-01f, -4.84227315e-02f, -1.56062528e-01f,
  1.34195507e-01f, 6.45882487e-02f, 5.23119047e-02f, 2.77229305e-02f, 5.14519036e-01f, 2.96722025e-01f, -9.66239572e-02f, -5.23668602e-02f, 7.71587566e-02f, 6.28019050e-02f,
  -2.22738475e-01f, 4.03057843e-01f, 1.09108001e-01f, -3.99692327e-01f, -2.70098358e-01f, -2.39304379e-01f, 1.10918358e-01f, 1.51583448e-01f, -3.56327087e-01f, 5.10628760e-01f,
  -3.98490652e-02f, 8.65861867e-03f, 2.46493027e-01f, -2.56463349e-01f, -3.33389975e-02f, 1.89573273e-01f, -5.23298047e-02f, -2.16220662e-01f, -2.95685306e-02f, 4.00795907e-01f,
  -1.36302814e-01f, 4.08193544e-02f, -5.14365509e-02f, 5.19966744e-02f, 4.60165665e-02f, 2.14329466e-01f, -4.34734188e-02f, 8.72907043e-02f, 3.82472463e-02f, -6.95430562e-02f,
  1.83881208e-01f, 2.40308568e-01f, 7.66486898e-02f, 1.20233640e-01f, 1.04766451e-01f, 1.15763158e-01f, 1.79620594e-01f, -1.21095963e-01f, 2.49575041e-02f, -1.11898407e-01f,
  -3.68354667e-04f, -7.88038671e-02f, 5.22691980e-02f, -6.95619509e-02f, -9.82426479e-02f, 2.31891975e-01f, -2.67303646e-01f, -6.86356574e-02f, 7.92745221e-03f, 1.53628871e-01f,
  1.17498897e-01f, 1.75501332e-01f, 1.15358539e-01f, 1.69283852e-01f, 2.95156658e-01f, 3.90747815e-01f, 8.16349313e-02f, -1.76809579e-01f, 4.59847711e-02f, -1.53522924e-01f,
  2.19743073e-01f, 2.47864440e-01f, 1.02404997e-01f, -3.13595325e-01f, 8.34485516e-02f, 3.58175248e-01f, -1.33987978e-01f, 3.47689480e-01f, 1.96185708e-02f, 1.96796358e-01f,
  1.86521351e-01f, -1.02015913e-01f, 2.46675074e-01f, 6.38053566e-02f, -3.22875679e-01f, -3.78151089e-02f, 1.10881496e-02f, -2.63701260e-01f, 1.44363850e-01f, 2.72476226e-01f,
  -6.88486844e-02f, 1.16402201e-01f, 4.63542119e-02f, 6.14387274e-01f, -2.67341644e-01f, 1.56548977e-01f, -2.79211074e-01f, 2.67427117e-01f, 5.84746450e-02f, -1.07686460e-01f,
  2.68746942e-01f, -1.41127288e-01f, 1.70536280e-01f, 1.62125811e-01f, -1.44122452e-01f, 5.22746556e-02f, 4.42913733e-02f, 2.22132057e-01f, 1.35507211e-01f, 7.63108116e-03f,
  -1.87553726e-02f, 5.25508970e-02f, -1.76588632e-02f, 1.71056494e-01f, -8.77200719e-03f, 8.66337121e-02f, 5.06253280e-02f, 8.78322348e-02f, 6.42346218e-03f, -1.08518917e-02f,
  2.33373880e-01f, 1.90280989e-01f, 2.44400740e-01f, -7.49657378e-02f, 1.81362554e-02f, -4.33819108e-02f, -3.03925239e-02f, 2.13516414e-01f, -2.61630386e-01f, -1.05124854e-01f,
  8.28599930e-03f, 9.41944644e-02f, 3.85208935e-01f, -3.23050097e-02f, 3.33824128e-01f, 2.14781776e-01f, 3.42589319e-02f, -1.60592590e-02f, 5.74980229e-02f, -7.62238121e-03f,
  1.07613847e-01f, 1.90745238e-02f, 2.96847876e-02f, 4.71822098e-02f, -1.64318699e-02f, 1.47690922e-01f, -1.88492700e-01f, 1.00579537e-01f, 3.15640807e-01f, 2.31379922e-02f,
  2.94099391e-01f, 1.51365250e-01f, 3.12365949e-01f, 3.24122161e-01f, -1.11475766e-01f, -3.04453168e-02f, -1.72689497e-01f, -2.07912043e-01f, 1.58788010e-01f, 2.92857319e-01f,
  2.06306223e-02f, 5.65053802e-03f, 1.57700658e-01f, 2.05323830e-01f, -2.03695726e-02f, 4.15446237e-02f, -1.14051364e-01f, 6.41823746e-03f, 1.87088490e-01f, 1.07570589e-01f,
  2.60518104e-01f, 4.29299809e-02f, 1.32386267e-01f, 5.13237752e-02f, -2.02886000e-01f, 9.32375789e-02f, 7.44964331e-02f, -5.91599904e-02f, 1.24543168e-01f, -5.64403422e-02f,
  -7.99855888e-02f, 9.54811946e-02f, -2.26289123e-01f, 2.59817131e-02f, -1.57427385e-01f, -2.27455702e-02f, 1.23353684e-02f, -2.58973122e-01f, -8.75982735e-03f, -3.68686765e-02f,
  2.30974734e-01f, 2.03282908e-01f, 5.09085298e-01f, -7.06354752e-02f, 9.80027243e-02f, -1.27948865e-01f, 4.93970513e-01f, 1.22646965e-01f, 3.20164233e-01f, 1.24541163e-01f,
  6.47300184e-02f, -2.09830523e-01f, -2.95519009e-02f, 2.06289276e-01f, -2.36910284e-01f, 5.79984009e-01f, -5.77771962e-02f, -3.73861253e-01f, 8.59655738e-02f, 2.95630246e-01f,
  5.14048524e-02f, 4.91774172e-01f, 1.62807152e-01f, -2.58002970e-02f, 4.40900177e-01f, 2.25069031e-01f, -1.12578429e-01f, -1.53289258e-01f, -7.48335570e-02f, 3.31448048e-01f,
  1.07384622e-01f, -1.65823877e-01f, -2.45330691e-01f, 1.73812006e-02f, -4.91612405e-02f, 1.34837747e-01f, 1.05803579e-01f, 1.65397227e-01f, 4.74081449e-02f, 1.51098520e-01f,
  -9.60907489e-02f, 2.35269908e-02f, 1.93791240e-01f, 1.21858291e-01f, 2.46620655e-01f, -6.40644282e-02f, 1.07747756e-01f, 1.02115095e-01f, -1.16142154e-01f, -9.55414772e-03f,
  1.49208575e-01f, 1.36627421e-01f, 6.23388514e-02f, 1.12484023e-01f, -4.48232330e-02f, 7.58232875e-03f, -1.13524087e-01f, -1.28917679e-01f, 3.05295158e-02f, 2.21709479e-02f,
  -1.53424010e-01f, -1.39043674e-01f, 1.65589571e-01f, -2.20766902e-01f, -1.63007975e-01f, 1.74783438e-01f, 5.34828544e-01f, -2.92080998e-01f, 6.39892220e-02f, -2.62097437e-02f,
  -2.29804501e-01f, 4.50504005e-01f, 2.76358247e-01f, 4.28115800e-02f, 1.35734245e-01f, -2.92686552e-01f, -6.01737313e-02f, 1.61853150e-01f, -1.64667126e-02f, 3.18321377e-01f,
  -2.43569657e-01f, -3.78081381e-01f, 2.14624051e-02f, 2.09019676e-01f, 1.60774678e-01f, 4.91184682e-01f, 1.09074324e-01f, -8.65190774e-02f, 2.54302204e-01f, 2.11574405e-01f,
  -1.45197585e-01f, -1.67792007e-01f, 5.05903736e-02f, 2.78828561e-01f, 2.55532533e-01f, 9.70050171e-02f, -2.51510203e-01f, -3.52372050e-01f, 8.06026757e-02f, 2.11100370e-01f,
  -1.34096481e-03f, 1.29929155e-01f, -1.89236905e-02f, 2.59353197e-03f, -1.06267758e-01f, -9.67245698e-02f, -4.35675308e-03f, 4.78975102e-03f, 1.03339374e-01f, -1.49130553e-01f,
  1.12436479e-02f, 4.29600589e-02f, 1.01468079e-01f, 7.58828819e-02f, -9.44183096e-02f, 1.31119406e-02f, -1.89401746e-01f, -1.64472207e-01f, 1.89778134e-01f, -4.74080704e-02f,
  -8.71952325e-02f, -3.82711589e-02f, 1.26848817e-01f, 3.08255153e-03f, -4.98272851e-02f, -1.02667421e-01f, -1.83259115e-01f, -2.62008011e-02f, 1.40919596e-01f, -2.12911785e-01f,
  1.89732358e-01f, 1.11321241e-01f, 3.67987722e-01f, -1.77846588e-02f, 2.44140416e-01f, -1.22139715e-01f, 2.69456178e-01f, 4.29690443e-02f, 2.57725716e-01f, -2.10527942e-01f,
  -1.06584698e-01f, 1.22294731e-01f, -3.27408835e-02f, 4.34817225e-01f, -1.18706249e-01f, -1.43832475e-01f, -1.61245447e-02f, 1.04021449e-02f, 3.24066103e-01f, -8.40863511e-02f,
  1.02101557e-01f, -1.71190754e-01f, 1.99615285e-01f, 1.48261115e-01f, -1.19442739e-01f, 8.36692005e-02f, -4.28374112e-02f, 2.28533551e-01f, -1.03403395e-02f, 3.28448936e-02f,
  -1.97716042e-01f, 1.05714902e-01f, -4.89236191e-02f, 2.79795825e-01f, 1.27225280e-01f, 1.52579337e-01f, 2.39834607e-01f, 1.29397765e-01f, 1.47076502e-01f, 1.00701995e-01f,
  1.76927179e-01f, 1.74757719e-01f, 1.21446207e-01f, 1.41222566e-01f, 1.45030037e-01f, 1.39891952e-01f, 2.57422850e-02f, -4.69960347e-02f, 7.61618242e-02f, 1.67436153e-01f,
  1.49167955e-01f, 2.04606026e-01f, 3.98972332e-02f, 7.32986405e-02f, 1.10401325e-01f, 3.97396926e-03f, -1.38394356e-01f, 5.88158704e-02f, 2.12224275e-02f, 3.60525176e-02f,
  -5.19275703e-02f, -5.06624617e-02f, -9.32779238e-02f, 2.50126541e-01f, 1.51079670e-01f, 1.25432108e-02f, -2.03285962e-02f, -1.56644434e-01f, -3.63168754e-02f, 3.24498117e-01f,
  -1.91136688e-01f, -1.81517348e-01f, -7.01197833e-02f, 4.08144891e-02f, -7.48559088e-03f, 1.65429309e-01f, -2.67337739e-01f, -2.34355479e-01f, 3.29481512e-02f, 8.71125683e-02f,
  2.38676205e-01f, 7.09409267e-02f, -1.91575021e-01f, -1.38893828e-01f, 4.76475284e-02f, 3.03488195e-01f, -2.15527847e-01f, -7.80578777e-02f, 3.92034292e-01f, 2.25740984e-01f,
  9.02696699e-02f, -1.27835751e-01f, 8.33860040e-02f, 1.79534554e-01f, 1.78169191e-01f, -9.24314633e-02f, 1.21807292e-01f, 1.06487819e-03f, -5.19038327e-02f, 1.86773613e-02f,
  1.22127356e-02f, 1.26004696e-01f, 4.96299565e-02f, -5.52577339e-03f, 4.94449064e-02f, 5.44485897e-02f, -5.41768335e-02f, 3.07221543e-02f, -9.11418349e-02f, 1.92282721e-02f,
  1.14399768e-01f, 6.60946369e-02f, -1.22187674e-01f, -9.81678963e-02f, 1.98251083e-02f, -4.99981605e-02f, -1.71520319e-02f, -9.55768600e-02f, 7.40955025e-02f, -1.89021319e-01f,
  -2.48498074e-03f, -1.14055179e-01f, 5.71732484e-02f, 1.12002790e-01f, -5.94032854e-02f, -5.23084169e-03f, 2.23997071e-01f, 4.99214940e-02f, -1.93476349e-01f, 1.71732947e-01f,
  2.03637332e-01f, 2.38119755e-02f, 5.18843457e-02f, -1.08234316e-01f, -1.37014121e-01f, 3.87737677e-02f, 1.53590441e-01f, 2.45747179e-01f, -1.94295034e-01f, -6.49755821e-02f,
  -5.20906225e-02f, -9.39826295e-03f, 1.04619384e-01f, 1.65177420e-01f, 1.53256938e-01f, -1.33615986e-01f, 5.53052574e-02f, -2.82233357e-02f, -9.10022333e-02f, -1.08123496e-02f,
  -1.44256279e-01f, 6.54918477e-02f, 3.17099839e-02f, -4.07691374e-02f, -5.65542318e-02f, 1.35099128e-01f, 6.90090135e-02f, 2.39706431e-02f, 2.32494205e-01f, -1.93453223e-01f,
  1.78810358e-01f, -2.36868352e-01f, 1.37282446e-01f, -2.62171309e-02f, 2.24489242e-01f, 3.00189331e-02f, 1.88079998e-01f, 1.49491295e-01f, -5.42104617e-02f, 1.00580551e-01f,
  1.53781086e-01f, 3.37046422e-02f, 1.70343637e-01f, 7.87891746e-02f, 1.06602095e-01f, 3.99526730e-02f, -1.58466414e-01f, 1.27185872e-02f, -1.44599497e-01f, 6.66892976e-02f,
  8.45938772e-02f, 4.43628952e-02f, -4.56502885e-02f, -8.51460099e-02f, 2.00536236e-01f, 5.89127615e-02f, 1.41733661e-01f, -1.59901679e-01f, -1.12110615e-01f, -1.37875021e-01f,
  -3.72348055e-02f, 2.68431783e-01f, -6.97194040e-02f, 3.92865390e-02f, 1.74180657e-01f, -2.86927342e-01f, -2.79642008e-02f, 6.29121531e-03f, 3.44749540e-01f, -5.06429225e-02f,
  3.45555879e-02f, -2.90280860e-02f, -4.94586490e-02f, 1.36778876e-01f, 8.94030407e-02f, 3.53693336e-01f, -7.10433573e-02f, -1.11919850e-01f, -4.31655459e-02f, -6.25341311e-02f,
  2.94991564e-02f, -2.60542959e-01f, 1.75042495e-01f, 2.00815886e-01f, -2.48237164e-03f, 1.75044879e-01f, 4.46313053e-01f, 3.72572660e-01f, -7.29301497e-02f, 1.42212212e-01f,
  -9.48228836e-02f, 5.23511954e-02f, 8.34846124e-02f, 2.32444286e-01f, 1.32580906e-01f, 3.05872202e-01f, 1.17371030e-01f, 1.02153882e-01f, -1.09064274e-01f, -8.91997069e-02f,
  4.29553501e-02f, -1.39423907e-01f, 1.10851578e-01f, 3.18132527e-03f, -5.13641583e-03f, 5.86616024e-02f, 1.21436611e-01f, 7.42855594e-02f, -2.35624939e-01f, -8.45182836e-02f,
  9.16309357e-02f, 9.38516557e-02f, 1.73869371e-01f, 3.64956595e-02f, -1.18004397e-01f, 1.66112199e-01f, -2.53963061e-02f, 1.08877108e-01f, -9.91843641e-02f, 2.37388965e-02f,
  1.91689581e-01f, -7.82966539e-02f, -3.31564248e-02f, -3.61278020e-02f, -1.03008553e-01f, 2.35503957e-01f, 1.89128369e-01f, -1.56183437e-01f, -2.69424945e-01f, 1.27006933e-01f,
  1.56027406e-01f, -5.65918609e-02f, 1.70504287e-01f, 4.29843701e-02f, -2.94844389e-01f, -7.28844404e-02f, 2.70514846e-01f, 7.96507895e-02f, 5.86660206e-02f, 4.02170569e-02f,
  1.55558929e-01f, -6.95006847e-02f, 1.42002732e-01f, 7.77341872e-02f, -2.37601414e-01f, 1.75200179e-01f, -7.50697330e-02f, 1.47798643e-01f, 1.86861470e-01f, -6.40085787e-02f,
  2.02464983e-01f, 4.59040608e-03f, -1.27946675e-01f, -1.62608445e-01f, 2.13569313e-01f, -2.00492159e-01f, -4.87043224e-02f, 2.90963709e-01f, -2.26860777e-01f, -5.32966927e-02f,
  -1.56267043e-02f, 5.35530001e-02f, 5.39533384e-02f, 1.19149044e-01f, 6.60514832e-03f, 6.96513802e-02f, 5.95990866e-02f, 1.03025727e-01f, 7.11903870e-02f, -9.50536206e-02f,
  -1.29121039e-02f, 5.15329316e-02f, 2.02161640e-01f, -5.97648658e-02f, 1.86262876e-02f, -1.89761035e-02f, -1.00710101e-01f, -6.00318946e-02f, 1.05880558e-01f, 4.20477390e-02f,
  4.66787256e-02f, 4.14735265e-02f, 1.42430350e-01f, 9.96814445e-02f, -5.06404042e-02f, 1.57570347e-01f, -6.31495640e-02f, 9.85659882e-02f, -1.15327775e-01f, -1.77099288e-01f,
  1.38571084e-01f, 2.35896930e-01f, 3.92065465e-01f, -2.05233753e-01f, 4.82446402e-02f, 1.17374800e-01f, 2.10264936e-01f, 1.65978014e-01f, 4.38129693e-01f, -9.54368860e-02f,
  -2.80122250e-01f, 1.72606841e-01f, 7.72801861e-02f, 4.03490774e-02f, -2.74411172e-01f, 1.31208926e-01f, 1.22586295e-01f, -1.56892791e-01f, 3.08272988e-01f, -2.19658818e-02f,
  -1.49099410e-01f, -3.87859084e-02f, 4.10298519e-02f, -6.53520375e-02f, -6.95896372e-02f, 2.10332736e-01f, 5.03643900e-02f, -8.81425804e-04f, 1.07408203e-02f, 4.35305834e-01f,
  -1.86870977e-01f, -2.12751091e-01f, 1.17744148e-01f, 2.96066850e-01f, 2.14642927e-01f, 1.29912451e-01f, 5.05571403e-02f, 2.01405779e-01f, 1.66198581e-01f, 9.35414582e-02f,
  1.30905405e-01f, 1.18947901e-01f, -2.83446070e-02f, 1.13394134e-01f, 1.90499410e-01f, 1.99503839e-01f, -7.14892596e-02f, -8.51391722e-03f, 1.34406805e-01f, -2.65348870e-02f,
  -2.92601921e-02f, -1.26926556e-01f, -7.67191425e-02f, -5.88969290e-02f, 5.22826687e-02f, 2.27462023e-01f, -3.57882947e-01f, -1.00962564e-01f, 2.26242781e-01f, 3.29690754e-01f,
  1.59225792e-01f, 2.53822237e-01f, 1.78453252e-01f, -5.55023141e-02f, 2.46708363e-01f, 1.98932905e-02f, -9.38365906e-02f, 6.69144914e-02f, 1.09349765e-01f, 6.26028553e-02f,
  -2.88930655e-01f, 1.72740817e-02f, 1.28159687e-01f, 1.98882937e-01f, -1.55221671e-02f, -1.54600531e-01f, -6.41674623e-02f, -5.56381233e-02f, 1.42632037e-01f, 2.33909622e-01f,
  -2.70552319e-02f, -5.31249121e-02f, 1.62095547e-01f, -3.08920264e-01f, 4.48566712e-02f, 6.79929927e-02f, -2.92019725e-01f, 8.15202221e-02f, -4.12128195e-02f, -1.98349297e-01f,
  3.43689173e-01f, 1.15241669e-01f, 2.18556523e-01f, 4.00853693e-01f, 2.13823110e-01f, 1.34448009e-02f, -1.76875323e-01f, -5.16788289e-02f, -1.21230043e-01f, 5.41653074e-02f,
  -8.37186445e-03f, -1.22018084e-01f, 2.08776951e-01f, 1.41948424e-02f, 8.60484410e-03f, 1.76769614e-01f, 6.04494801e-03f, 1.15099862e-01f, 2.83123534e-02f, 3.20562460e-02f,
  8.66356120e-02f, -9.88513008e-02f, -2.88203090e-01f, -1.11845247e-01f, 3.46091799e-02f, -1.29062563e-01f, 5.53506911e-02f, 1.68687493e-01f, -2.11880058e-01f, 1.96537226e-01f,
  -1.65992767e-01f, -2.11912498e-01f, 3.26589078e-01f, 1.86952874e-01f, -3.21232229e-02f, 4.30835515e-01f, 2.55258888e-01f, 3.66017707e-02f, -2.08428934e-01f, 4.15170461e-01f,
  -8.76837149e-02f, 2.03903913e-02f, 2.04350904e-01f, -4.75294620e-01f, 2.40666747e-01f, 2.74077415e-01f, 1.76919192e-01f, -1.47845030e-01f, 1.21307507e-01f, 1.12853706e-01f,
  -2.75581256e-02f, 2.53185719e-01f, 2.36099865e-02f, 2.35874534e-01f, -6.96347505e-02f, -2.49643788e-01f, 1.29840031e-01f, -1.47400036e-01f, -1.57646239e-01f, 1.32949486e-01f,
  -4.30166163e-03f, -2.08982110e-01f, -7.60579258e-02f, 2.60324717e-01f, 1.83066338e-01f, 2.47340903e-01f, 1.52507082e-01f, -4.52707261e-02f, -1.84478685e-01f, 3.04394543e-01f,
  -3.22598308e-01f, 9.68105644e-02f, -1.06207132e-01f, 7.86998793e-02f, 2.22054720e-02f, 1.92767978e-01f, 2.26406157e-02f, -8.78001377e-02f, 5.32435514e-02f, 1.51873259e-02f,
  1.00261442e-01f, 2.16373295e-01f, -4.87829596e-02f, 2.02357955e-02f, 1.27471238e-01f, -9.06624459e-03f, 4.94379438e-02f, -5.33120148e-02f, -3.22431102e-02f, -1.04753733e-01f,
  4.44422327e-02f, 1.78108662e-02f, 1.18890338e-01f, -1.52090967e-01f, 1.70410752e-01f, 1.80196371e-02f, -6.19575717e-02f, 1.23041116e-01f, -7.61324912e-02f, 1.79234207e-01f,
  1.15156859e-01f, 9.75785330e-02f, -1.67523578e-01f, 2.50479519e-01f, 1.82657942e-01f, -4.45142165e-02f, -4.19999883e-02f, -2.76599973e-01f, 1.27362952e-01f, 1.05899669e-01f,
  2.66357034e-01f, 2.58320928e-01f, -4.19715270e-02f, -3.72817740e-03f, 2.19436318e-01f, 1.26338184e-01f, 6.96369708e-02f, 2.37660095e-01f, -1.06826745e-01f, -3.10009062e-01f,
  6.40006214e-02f, -1.45038059e-02f, -1.62209406e-01f, -1.02141455e-01f, -5.65638877e-02f, -7.94054195e-03f, 1.19716726e-01f, 1.44717485e-01f, 1.41755072e-02f, 3.49892341e-02f,
  1.40957430e-01f, -2.24516392e-02f, 1.70516297e-01f, 2.16649589e-03f, 3.85801792e-02f, 2.20633252e-03f, -1.68771539e-02f, 3.88245191e-03f, -4.62380005e-03f, 4.73489352e-02f,
  1.61475509e-01f, -1.43095246e-02f, 1.15484521e-02f, 9.44317281e-02f, -9.45116132e-02f, 9.14620906e-02f, 1.55008361e-02f, -5.11295386e-02f, 2.56135128e-02f, 9.74558964e-02f,
  -1.96494341e-01f, -4.06717472e-02f, -1.53727323e-01f, -1.65052906e-01f, -5.59224328e-03f, -1.36167690e-01f, 1.01009021e-02f, 1.10304002e-02f, -2.05626249e-01f, -1.97153524e-01f,
  1.51304364e-01f, 2.01138437e-01f, 2.75223441e-02f, 3.19846630e-01f, 4.28724408e-01f, 1.55531973e-01f, -2.11056665e-01f, 2.36918733e-01f, -2.96591558e-02f, 9.32994410e-02f,
  1.40803948e-01f, -1.29854187e-01f, -1.93273768e-01f, 1.68731779e-01f, 1.75911859e-01f, -4.81696911e-02f, 8.05539265e-02f, -1.32573903e-01f, -3.93008441e-01f, 1.20469481e-01f,
  2.57631660e-01f, 3.32425117e-01f, -9.98186991e-02f, 1.44462124e-01f, 1.30754739e-01f, -8.26011598e-02f, -1.62718877e-01f, -8.73517916e-02f, -1.83431819e-01f, -5.62837012e-02f,
  -1.84004441e-01f, -5.22954427e-02f, 9.75686163e-02f, 2.20296785e-01f, -2.09171865e-02f, 1.03503130e-01f, -3.38341575e-03f, -6.02961518e-02f, 2.54902914e-02f, -2.12157518e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  9.99677628e-02f, 2.86433131e-01f, 1.18661173e-01f, 1.48594767e-01f, 5.75066730e-02f, 2.52930641e-01f, 2.26031348e-01f, 1.21847913e-01f, 1.62307680e-01f, 1.79224983e-01f,
  1.06472224e-01f, 2.16151610e-01f, 2.76335299e-01f, 1.12469539e-01f, 1.99041918e-01f, 9.10808891e-02f, 2.36774281e-01f, 2.10187986e-01f, 1.31292135e-01f, 9.10192728e-02f,
  1.24462642e-01f, 5.31666987e-02f, 1.83569118e-01f, 1.25298783e-01f, 2.26721957e-01f, 1.98220149e-01f, 2.21942440e-01f, 1.86891496e-01f, 2.56787360e-01f, 2.48223260e-01f,
  8.58094171e-02f, 1.99998319e-01f, -3.09640896e-02f, 2.06093714e-01f, 1.83810264e-01f, 8.92772749e-02f, 1.19674988e-01f, 2.33610362e-01f, -8.02120194e-02f, 5.55876568e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  2.14734278e-03f, 6.56346828e-02f, -5.59548624e-02f, -4.51162718e-02f, -6.16401359e-02f, -1.16682820e-01f, -2.71182656e-01f, 3.15918386e-01f, -3.46700149e-03f, -1.17528662e-01f,
  1.29752547e-01f, -7.59009831e-03f, -2.48669043e-01f, 1.31450951e-01f, 2.29407907e-01f, -6.59683272e-02f, -7.62027055e-02f, 2.94331019e-03f, -2.12181792e-01f, 9.04747564e-03f,
  4.14403439e-01f, -5.61476499e-02f, 2.08514675e-01f, -3.07186246e-01f, 3.29396844e-01f, -1.12650044e-01f, -1.56664684e-01f, -3.07734787e-01f, 2.98093706e-01f, -1.54623508e-01f,
  1.55633643e-01f, -4.28513922e-02f, -7.40439147e-02f, 1.23406984e-01f, -3.41710716e-01f, -3.65492344e-01f, -4.38928992e-01f, 1.95336387e-01f, -2.12069601e-01f, 1.58660889e-01f,
  1.40799051e-02f, 6.61400184e-02f, -6.68897629e-02f, 3.98377448e-01f, 1.97514132e-01f, -4.66673858e-02f, -4.56803262e-01f, -4.02216375e-01f, 9.97696295e-02f, 8.70272368e-02f,
  9.01156887e-02f, -1.69601694e-01f, -4.78587002e-01f, -5.09513557e-01f, 1.03612661e-01f, -1.85809359e-01f, 2.35999331e-01f, -8.35695416e-02f, -1.37788340e-01f, 3.10907304e-01f,
  -1.62733018e-01f, 3.48192863e-02f, 2.54951298e-01f, 1.59168661e-01f, -6.66864291e-02f, 2.78122753e-01f, -8.48936439e-02f, 7.55521283e-03f, 6.71825036e-02f, -2.29966149e-01f,
  2.51735091e-01f, -3.06215763e-01f, -2.09181175e-01f, -9.76439044e-02f, -2.49178126e-01f, -5.36633283e-02f, -1.59158051e-01f, -4.96466085e-02f, 4.43537921e-01f, -2.47289792e-01f,
  1.34412467e-01f, 7.78430626e-02f, -1.85211763e-01f, 2.88399577e-01f, -5.08144200e-02f, -4.14080694e-02f, -5.38638115e-01f, 3.05849254e-01f, 2.41360486e-01f, 3.63109171e-01f,
  -1.74654812e-01f, -1.51067525e-01f, -2.82208860e-01f, -8.93946961e-02f, -3.80687892e-01f, 9.11247432e-02f, 1.08471073e-01f, 2.75751978e-01f, -5.65446913e-01f, -4.82288688e-01f,
  -1.99531555e-01f, 2.13259906e-01f, 7.08968416e-02f, -1.05915710e-01f, -2.60658681e-01f, 2.88223863e-01f, 3.55297029e-02f, -3.82145315e-01f, 4.15386379e-01f, -9.14850533e-02f,
  1.56172916e-01f, 5.61269708e-02f, -5.61225116e-02f, -3.47100407e-01f, 5.93544059e-02f, -1.60682470e-01f, -5.17024219e-01f, -2.73807764e-01f, -4.85345483e-01f, -8.76911134e-02f,
  1.16078988e-01f, -5.55131793e-01f, 3.25732753e-02f, 2.47865133e-02f, 2.92287469e-01f, 2.51438171e-01f, 1.34477973e-01f, 4.38689679e-01f, 1.97536826e-01f, 3.42674442e-02f,
  1.76912118e-02f, 5.24534211e-02f, -2.49122847e-02f, 1.37968525e-01f, 7.47826276e-03f, 1.31606907e-01f, 1.48139775e-01f, 1.04150213e-01f, 9.16095674e-02f, 2.08460376e-01f,
  -1.34601757e-01f, -5.63237369e-01f, 5.97449020e-02f, 1.33827299e-01f, -9.31746364e-02f, -2.28329107e-01f, 5.30217886e-02f, -1.60365328e-02f, -3.33992928e-01f, -7.96344597e-03f,
  -3.71815652e-01f, 4.83164284e-03f, -2.32930109e-01f, 1.32561326e-01f, 2.70222247e-01f, 2.95380741e-01f, -3.92160714e-01f, 1.49534196e-01f, -2.54668146e-01f, -2.15741783e-01f,
  -2.83303022e-01f, 3.05562228e-01f, -5.52787840e-01f, 5.95990308e-02f, -1.62472129e-01f, -1.30818695e-01f, -2.04022020e-01f, -3.29670578e-01f, 1.17314294e-01f, -1.39638424e-01f,
  -7.69176632e-02f, 2.02286303e-01f, -1.40047938e-01f, -2.83018231e-01f, -4.75530932e-03f, -1.86835915e-01f, 1.79596171e-01f, 3.59267801e-01f, 4.58679229e-01f, -1.39544323e-01f,
  -1.93397015e-01f, 5.79165556e-02f, -1.33593813e-01f, 3.01261038e-01f, -1.71189204e-01f, 2.50984013e-01f, -3.23122442e-01f, 2.17918038e-01f, 7.86904320e-02f, -1.58711970e-01f,
  -5.31753525e-02f, -2.31234461e-01f, 1.23237528e-01f, -8.50448105e-03f, -2.32011676e-01f, 9.31802243e-02f, -2.23682120e-01f, -2.32776329e-02f, 1.69455260e-01f, -2.23788336e-01f,
  -3.12574096e-02f, -2.09645648e-02f, -2.05431908e-01f, -7.43737295e-02f, -1.83488745e-02f, -5.04362464e-01f, -3.41382593e-01f, -1.90799937e-01f, 1.75397962e-01f, 9.66695771e-02f,
  2.19595104e-01f, -8.18163306e-02f, 1.52938692e-02f, -2.50533223e-02f, 3.26924086e-01f, 1.50293916e-01f, -3.54740500e-01f, -3.10890019e-01f, 2.01202348e-01f, 7.51609802e-02f,
  1.94669977e-01f, -1.94134504e-01f, 2.79147625e-01f, -2.17111543e-01f, -1.48629650e-01f, -5.61021864e-02f, 1.72760755e-01f, 9.44245830e-02f, -4.66247112e-01f, -4.63602543e-01f,
  -6.08395040e-02f, -2.66281903e-01f, -4.47279751e-01f, -4.51360941e-01f, 2.61261761e-01f, 1.84165448e-01f, 8.29474404e-02f, -3.01030010e-01f, -3.79953235e-01f, -2.25241855e-01f,
  4.54041995e-02f, -1.09691948e-01f, 2.67343462e-01f, -6.35830089e-02f, 2.41776675e-01f, 7.62227327e-02f, 2.98461854e-01f, -3.98902953e-01f, -2.20904350e-01f, 2.75593907e-01f,
  -4.73679632e-01f, 1.56327739e-01f, -4.39966798e-01f, 3.81709635e-01f, 1.90978825e-01f, -1.09778866e-01f, -2.83140928e-01f, -1.10602165e-02f, 1.00792035e-01f, 6.98831677e-02f,
  2.02364773e-01f, -4.90070172e-02f, 2.19673105e-02f, 1.20744705e-01f, 1.77512616e-01f, 1.61728300e-02f, 9.80956107e-02f, -8.36900342e-03f, 4.11003351e-01f, 3.79225880e-01f,
  -1.92016765e-01f, 3.29820603e-01f, -4.71783489e-01f, 3.51879656e-01f, 2.70993114e-01f, -3.13890904e-01f, -1.57128721e-01f, 2.05594555e-01f, -2.18242574e-02f, -2.42428601e-01f,
  1.09869704e-01f, -2.76796401e-01f, 1.31547645e-01f, 2.98423737e-01f, 1.44966215e-01f, 2.53947139e-01f, -4.84325260e-01f, 1.72300667e-01f, -3.52600574e-01f, 5.75788803e-02f,
  2.08907261e-01f, 3.51911813e-01f, -1.87881708e-01f, 1.01616338e-01f, -6.29283581e-03f, 1.47451952e-01f, -2.29235962e-01f, 1.34714693e-01f, -5.52318156e-01f, 3.11763026e-02f,
  3.03530395e-02f, -1.26047418e-01f, 6.54532714e-03f, -9.60221514e-02f, 1.48650199e-01f, -5.67072690e-01f, -1.11159764e-01f, -8.40753019e-02f, 1.83687210e-01f, 3.28949004e-01f,
  2.02256411e-01f, -4.54653949e-01f, -1.43954396e-01f, 9.92868245e-02f, 2.64386982e-02f, 1.44972384e-01f, -9.32108909e-02f, -4.57771629e-01f, -1.27982840e-01f, -2.13942483e-01f,
  4.17749621e-02f, -2.31112674e-01f, 9.08688903e-02f, 2.22761095e-01f, 1.45650923e-01f, 9.39935371e-02f, 1.17592424e-01f, 4.29178506e-01f, 2.07796901e-01f, 2.23345812e-02f,
  2.80246139e-01f, 1.63118139e-01f, 1.21355457e-02f, 1.16612516e-01f, 4.15339228e-03f, 7.31638819e-02f, -1.41408192e-02f, 2.07066536e-02f, -6.30006269e-02f, 2.31774464e-01f,
  3.34069282e-01f, 2.59041667e-01f, 4.23089057e-01f, -4.01305646e-01f, -2.87160315e-02f, 2.25443095e-01f, 3.01434975e-02f, 5.05452864e-02f, 2.95166373e-01f, -1.79595441e-01f,
  3.03778350e-01f, 9.43591297e-02f, -2.50853270e-01f, 7.93313906e-02f, 4.63430911e-01f, 6.31979853e-02f, -4.46403138e-02f, -8.73727575e-02f, 3.23993683e-01f, 2.42721811e-01f,
  3.15940857e-01f, 2.75037736e-01f, -2.48108804e-01f, -3.07994336e-01f, 8.86577219e-02f, 5.82989693e-01f, 4.75482270e-02f, -2.93453559e-02f, -1.54805377e-01f, -8.08641911e-02f,
  -7.08411872e-01f, 1.82099506e-01f, -6.07138693e-01f, -5.84808111e-01f, -2.85690159e-01f, 4.80896644e-02f, 7.75937513e-02f, 1.02399893e-01f, -4.37837690e-02f, -2.84562975e-01f,
  -4.99783270e-02f, -4.59045410e-01f, 1.65492535e-01f, -1.76934883e-01f, -7.63986930e-02f, 1.11359321e-01f, -5.26588000e-02f, -1.24911919e-01f, -4.11804430e-02f, 6.42651990e-02f,
  2.97308415e-01f, 1.39260367e-01f, -8.30774233e-02f, -2.64331460e-01f, 1.52957842e-01f, -6.90762848e-02f, 2.48906180e-01f, 1.10915907e-01f, 4.79317248e-01f, 1.85724542e-01f,
  2.26830602e-01f, -3.40251774e-01f, -1.24752214e-02f, 9.99917835e-03f, 1.18361846e-01f, -1.66990429e-01f, -2.99061984e-01f, 1.94881931e-01f, -4.95799094e-01f, -3.56554762e-02f,
  -4.26251650e-01f, 2.05543399e-01f, -3.21062386e-01f, 2.41745427e-01f, -4.15121973e-01f, 1.30268335e-01f, 9.17665511e-02f, -2.35938579e-01f, -1.67308554e-01f, 2.47664392e-01f,
  2.33167902e-01f, 1.33141473e-01f, -2.76208311e-01f, -3.40832353e-01f, 1.76596284e-01f, 1.02036268e-01f, 2.28191063e-01f, -2.64335573e-01f, -4.90346849e-01f, -4.59105223e-01f,
  -3.17608654e-01f, 3.30934048e-01f, -2.97591537e-01f, -3.55595909e-02f, 8.80844668e-02f, -5.35341084e-01f, 3.41660231e-01f, 3.26329172e-01f, -1.40685424e-01f, 2.22819149e-01f,
  2.07388103e-01f, -5.26098907e-01f, 2.10563734e-01f, -4.81927842e-01f, -2.66864095e-02f, -2.59419978e-01f, -1.37447760e-01f, -1.68918386e-01f, -2.10528895e-01f, -2.36969348e-02f,
  -1.02813259e-01f, -2.73553878e-01f, -9.08853635e-02f, -1.18128873e-01f, -2.24531040e-01f, -2.61537015e-01f, -7.23851696e-02f, -5.57770580e-02f, -1.10641830e-01f, 8.76787957e-03f,
  -3.34825724e-01f, -2.50240147e-01f, -9.06715989e-02f, -2.66395181e-01f, -8.75086784e-02f, -3.04303318e-01f, -9.66240093e-02f, -1.99312449e-01f, -5.87985963e-02f, -2.57934630e-02f,
  1.93435565e-01f, -1.73457757e-01f, -1.13434583e-01f, -3.52124035e-01f, -7.39852041e-02f, -3.89021456e-01f, -2.30782598e-01f, -1.16781175e-01f, 3.12751293e-01f, 1.88360944e-01f,
  -2.12900773e-01f, -1.54912084e-01f, 1.25246197e-01f, -7.63130337e-02f, -1.77023157e-01f, -1.16631947e-01f, -3.44159275e-01f, -1.29086241e-01f, -6.19297884e-02f, -2.57868648e-01f,
  2.28206277e-01f, 4.48721796e-01f, -2.94076920e-01f, -1.04784789e-02f, -1.49990752e-01f, 2.59445384e-02f, 7.06044734e-02f, -4.72904325e-01f, 3.26241255e-01f, 2.60966510e-01f,
  6.31274953e-02f, -3.02061856e-01f, -1.97054178e-01f, 4.79389913e-02f, -2.82735735e-01f, 4.65863496e-01f, 2.59285659e-01f, -3.93225282e-01f, -1.69882804e-01f, 2.91572392e-01f,
  -1.60634488e-01f, -2.38160834e-01f, 1.08410776e-01f, -9.58318710e-02f, 6.27993867e-02f, -2.68134981e-01f, -3.24149877e-02f, -1.04411468e-01f, -4.42188308e-02f, -1.41024485e-01f,
  -1.53744027e-01f, -7.38613214e-03f, 9.74907652e-02f, 2.20642313e-01f, 1.78053841e-01f, 1.86554700e-01f, -3.15098464e-01f, -1.95075929e-01f, 1.80891857e-01f, -1.65809691e-01f,
  3.20448071e-01f, 8.59062448e-02f, 2.44321436e-01f, -3.11961114e-01f, 3.33792835e-01f, 8.20827708e-02f, -2.55610019e-01f, 1.93809196e-02f, 2.45460078e-01f, -3.68346244e-01f,
  -2.46322453e-01f, -2.61197537e-01f, 4.70523149e-01f, -3.25138718e-01f, 3.71734977e-01f, 6.74200505e-02f, -4.48963761e-01f, -2.68553615e-01f, 8.68971944e-02f, -3.04373503e-01f,
  -1.24086067e-01f, -1.79354951e-01f, 1.36748195e-01f, -4.24128741e-01f, -6.06056191e-02f, -2.42309242e-01f, -1.34303734e-01f, 2.22994030e-01f, 3.48568976e-01f, -5.09583158e-03f,
  -3.74145687e-01f, 4.92242336e-01f, -1.74419031e-01f, 1.12488620e-01f, 1.38657898e-01f, -2.58407593e-01f, -8.93963501e-02f, -1.28333867e-01f, -2.10729718e-01f, -1.40198529e-01f,
  8.62947851e-02f, -8.89818743e-02f, 5.20224199e-02f, 1.96362868e-01f, -3.61902356e-01f, 3.10140047e-02f, 2.42906973e-01f, -4.76725511e-02f, 1.36654645e-01f, 1.80964127e-01f,
  -1.55528367e-01f, -5.18237837e-02f, 8.18392262e-02f, -3.62146944e-01f, -8.02460611e-02f, 3.32301825e-01f, -1.56117991e-01f, 2.06664026e-01f, -9.53120068e-02f, 1.82417631e-01f,
  -2.97563434e-01f, 1.77666619e-01f, 3.53941530e-01f, 4.42232996e-01f, -2.19983473e-01f, -2.69844264e-01f, -9.98680592e-02f, -2.52699554e-01f, 4.30436224e-01f, -2.57336378e-01f,
  4.91554797e-01f, 1.58996284e-01f, -5.35092473e-01f, -2.68915743e-01f, -1.29708752e-01f, 2.48219252e-01f, -1.66682124e-01f, -3.26537490e-01f, -1.05025945e-02f, -2.36838266e-01f,
  3.68692353e-02f, 2.54909724e-01f, 3.03434134e-01f, 3.28985512e-01f, -3.80599350e-01f, 1.06947094e-01f, 2.71346271e-01f, 2.21750498e-01f, -1.04161620e-01f, 3.38174433e-01f,
  -4.65238661e-01f, -1.07193410e-01f, -1.50203303e-01f, -1.70966372e-01f, 2.32291430e-01f, -1.00066058e-01f, -3.16876560e-01f, 4.79254089e-02f, -1.59418941e-01f, 6.87523633e-02f,
  -5.19270003e-01f, 2.15840966e-01f, 4.70281206e-02f, 1.10521644e-01f, -2.12577015e-01f, -6.51764721e-02f, -3.07020932e-01f, -9.15930495e-02f, -4.19107407e-01f, -1.80743054e-01f,
  -9.13866758e-02f, 4.65747267e-02f, -1.97816610e-01f, 3.84172723e-02f, 1.40358150e-01f, -1.01482563e-01f, -2.55232900e-01f, 6.91083893e-02f, 4.70818579e-02f, -1.02750823e-01f,
  8.98621753e-02f, -4.03921343e-02f, 1.89343289e-01f, -1.69547722e-01f, -1.71433389e-01f, 2.58016378e-01f, -1.23188764e-01f, 1.40039206e-01f, 1.19120546e-01f, 2.26885408e-01f,
  1.49067104e-01f, 2.30023980e-01f, 6.92734644e-02f, 1.47991329e-01f, -1.09679133e-01f, 3.14302623e-01f, 5.50808832e-02f, -1.92876235e-01f, -3.94658625e-01f, -4.27364767e-01f,
  -2.88608015e-01f, -4.81255502e-02f, -2.81390518e-01f, -1.27780288e-01f, 3.21988821e-01f, -9.05967280e-02f, 3.61336559e-01f, -2.85836041e-01f, 1.72107488e-01f, 2.22171873e-01f,
  2.31365472e-01f, -1.10954747e-01f, 3.22304934e-01f, -3.27511698e-01f, -4.56463188e-01f, -2.79550612e-01f, -5.63333258e-02f, -1.46137208e-01f, 1.46279424e-01f, -3.41104984e-01f,
  7.40521308e-03f, -6.23733662e-02f, 4.51917708e-01f, -3.27616446e-02f, 1.43989071e-01f, -1.54130533e-01f, 2.32764423e-01f, 7.65121728e-02f, -3.58988523e-01f, -2.74297804e-01f,
  4.71817143e-02f, 9.68104154e-02f, -4.39415164e-02f, 4.23616946e-01f, 6.37256950e-02f, 1.65628809e-02f, -7.05228001e-02f, 1.91659197e-01f, 1.38769671e-01f, 7.50502124e-02f,
  -1.19015455e-01f, 1.23539895e-01f, -6.09342456e-02f, -5.49725294e-02f, -3.32909115e-02f, -3.24431509e-01f, -8.72384384e-02f, 2.53156245e-01f, 2.15126008e-01f, -2.80238062e-01f,
  1.64181113e-01f, -4.33131903e-02f, -2.71543682e-01f, -1.79410174e-01f, -1.68287829e-01f, -1.81519926e-01f, -2.92647123e-01f, 1.94509506e-01f, -1.43799871e-01f, -4.90028799e-01f,
  -1.72457159e-01f, 3.19049686e-01f, 1.65122673e-01f, 1.76638812e-01f, 1.97695404e-01f, 2.10859165e-01f, 2.21512407e-01f, -5.06849945e-01f, 3.17091674e-01f, 3.03503964e-02f,
  -7.91897550e-02f, -3.13248307e-01f, 2.77714401e-01f, -1.93599656e-01f, -3.80710244e-01f, -4.08691466e-01f, -2.14226648e-01f, -1.82175517e-01f, 4.23857003e-01f, 3.10458690e-01f,
  -1.67517122e-02f, -6.96735159e-02f, -4.48794991e-01f, 1.93296522e-01f, 1.24084763e-03f, 5.42616732e-02f, 1.40404969e-01f, 2.38123998e-01f, -1.49381652e-01f, -2.09383711e-01f,
  -1.87153652e-01f, -2.30912015e-01f, 1.25404019e-02f, -5.98554173e-03f, -3.39726567e-01f, -1.75408483e-01f, -1.07848920e-01f, -7.45393634e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.12799875e-01f, 5.49452081e-02f, -6.05069567e-03f, -1.76645517e-02f, 4.78027500e-02f, 4.03535254e-02f, 9.24190804e-02f, -2.55037118e-02f, 3.41611877e-02f, -1.82715934e-02f,
  -7.25185052e-02f, -5.49115874e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    