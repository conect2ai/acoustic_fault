/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.33770603e-01f, -3.00551683e-01f, 1.38580620e-01f, 2.92806417e-01f, 1.17346942e-01f, -1.59141853e-01f, -1.68454751e-01f, -1.48309350e-01f, -6.83567598e-02f, -1.62027925e-01f,
  -4.17447463e-02f, 3.37660685e-02f, 4.26151454e-02f, -2.03392312e-01f, -1.57549873e-01f, -1.09477103e-01f, 1.24588139e-01f, 1.91024810e-01f, 1.20170526e-01f, 3.33371237e-02f,
  9.20536593e-02f, 3.63996059e-01f, 2.17472211e-01f, 1.14179276e-01f, 1.21127434e-01f, 1.38625816e-01f, -6.01999462e-03f, 2.02096254e-01f, 3.89582617e-03f, 2.60488391e-01f,
  6.39021695e-02f, 1.95164651e-01f, -5.34615293e-02f, -2.32051667e-02f, -2.67581269e-02f, -6.23304658e-02f, 9.98673439e-02f, 1.33566812e-01f, -7.48507604e-02f, 4.57717218e-02f,
  4.84620454e-04f, -5.83386384e-02f, 4.40966301e-02f, 2.54786778e-02f, 1.34739410e-02f, 4.39440981e-02f, 6.90349261e-04f, -9.27572176e-02f, -1.86008975e-01f, -4.88808230e-02f,
  2.69302558e-02f, 8.49463269e-02f, 1.34278879e-01f, -2.20742226e-01f, -2.02227563e-01f, 9.47902501e-02f, -5.17288372e-02f, 2.56877877e-02f, -1.23158567e-01f, -9.90564600e-02f,
  -9.62044597e-02f, -7.52655193e-02f, -6.26688972e-02f, 4.24615666e-02f, -1.57717422e-01f, 4.18066699e-03f, 5.23346588e-02f, -2.12336257e-02f, -9.87744108e-02f, 8.99946988e-02f,
  3.07537317e-02f, -1.12582535e-01f, -1.78652927e-02f, 7.63370544e-02f, -6.13719039e-03f, 9.17416364e-02f, -2.04960420e-03f, -8.13308209e-02f, 2.69442033e-02f, -1.03274453e-02f,
  7.17187999e-03f, -1.15520641e-01f, 1.14783375e-02f, 3.44531126e-02f, -1.88988131e-02f, -3.54903704e-03f, 5.47546558e-02f, 3.09122410e-02f, 2.86067952e-03f, 1.42078191e-01f,
  9.37842727e-02f, -1.31595626e-01f, 5.00872768e-02f, -2.01405920e-02f, -5.53480349e-02f, -8.75649527e-02f, 2.78409850e-02f, -1.10428721e-01f, 1.32139111e-02f, -6.46075383e-02f,
  -5.21832146e-02f, -1.65503114e-01f, -6.10760786e-02f, -4.79560234e-02f, 3.92874330e-02f, -2.70592445e-03f, -1.67757004e-01f, -7.16066658e-02f, -9.17332694e-02f, -1.00029923e-01f,
  -1.67326406e-01f, -4.32514548e-02f, -2.60555139e-03f, -1.26455218e-01f, -2.38908324e-02f, 2.44195722e-02f, -4.93999757e-02f, 2.16068923e-02f, -6.53849766e-02f, -2.01911569e-01f,
  -4.80537146e-01f, 3.96867722e-01f, -2.51713634e-01f, 7.37777427e-02f, -1.69669352e-02f, -7.61458129e-02f, 4.37765233e-02f, 1.69478968e-01f, 1.18576847e-01f, 1.08815826e-01f,
  1.16952613e-01f, -2.53337603e-02f, -5.88698834e-02f, -7.82458037e-02f, -1.49733961e-01f, 8.45646933e-02f, -1.35380626e-01f, -2.23639116e-01f, -4.43875998e-01f, -1.38032883e-01f,
  1.18277967e-01f, 1.14446945e-01f, 3.29966396e-02f, 7.24639297e-02f, 1.53767824e-01f, -6.05773218e-02f, 1.68565348e-01f, -5.31557836e-02f, 1.72223151e-02f, 4.43207957e-02f,
  -9.87119526e-02f, -1.02390856e-01f, -1.69939101e-01f, -3.46582523e-03f, -2.11192705e-02f, -7.50139728e-02f, -1.68124378e-01f, -7.88519755e-02f, -1.24556748e-02f, -3.13114561e-02f,
  -4.84419875e-02f, 7.22642196e-03f, -6.96999580e-03f, 7.58152083e-02f, 5.34486584e-02f, -9.03251842e-02f, 1.22509681e-01f, -1.02728181e-01f, -2.72354260e-02f, -7.74601176e-02f,
  -2.42264234e-02f, -4.44070511e-02f, -1.01819299e-01f, -6.28328994e-02f, -3.82216908e-02f, -1.70660913e-01f, 3.43978964e-02f, 3.12479585e-02f, -1.19254611e-01f, 1.59854680e-01f,
  -1.13841996e-01f, 1.59903988e-02f, 3.83146740e-02f, 1.20700411e-01f, 1.23428784e-01f, 1.05030291e-01f, -1.00450935e-02f, 3.01355515e-02f, -1.09860040e-02f, 9.49986652e-02f,
  5.98130338e-02f, 1.14987353e-02f, 3.89721096e-02f, 3.10291518e-02f, 8.45539123e-02f, -7.24991113e-02f, 5.31323664e-02f, 7.30212033e-02f, -6.17473898e-03f, 1.31568849e-01f,
  1.04177982e-01f, 2.07126769e-03f, 1.03983790e-01f, -3.01862205e-03f, -7.36406967e-02f, -3.43762971e-02f, -6.43628538e-02f, 3.70585993e-02f, 3.76354307e-02f, 1.67103950e-03f,
  2.76925653e-01f, -1.27642140e-01f, -2.68463213e-02f, 2.07202565e-02f, 1.16993324e-03f, -5.06054945e-02f, 2.40403954e-02f, 9.38549414e-02f, -4.61618453e-02f, -5.86709678e-02f,
  -1.42387552e-02f, -2.28443742e-02f, 3.84419747e-02f, 3.58158499e-02f, -1.24745846e-01f, -4.36277129e-02f, 1.66491762e-01f, 1.16296075e-02f, -4.91894260e-02f, 8.85171220e-02f,
  7.31297508e-02f, -6.29866049e-02f, -1.73400670e-01f, -2.61481516e-02f, -1.55473379e-02f, -1.50097474e-01f, -7.19328076e-02f, -7.47926310e-02f, -1.57227561e-01f, 1.12776391e-01f,
  -2.38432184e-01f, -3.95363003e-01f, 9.11872908e-02f, 1.68644756e-01f, 5.47858961e-02f, -1.57648772e-02f, -3.83176893e-01f, -6.12982549e-02f, 4.60059904e-02f, -1.69294506e-01f,
  6.73656538e-03f, 3.42069983e-01f, 3.59169990e-01f, 7.34752715e-02f, -4.41016704e-02f, -1.86548606e-01f, 4.23684828e-02f, 1.99508354e-01f, 2.66983807e-01f, 2.84351893e-02f,
  1.20395057e-01f, 1.60606444e-01f, 1.70281768e-01f, 1.05739325e-01f, -2.33664200e-01f, 2.38073483e-01f, -1.61947772e-01f, -2.65892707e-02f, -7.84773845e-03f, -2.12957367e-01f,
  -2.59020209e-01f, -1.91201210e-01f, 1.90670893e-01f, -4.56318110e-02f, -1.14358412e-02f, -4.50377353e-02f, -3.36694606e-02f, 6.26538098e-02f, 5.26489802e-02f, -7.21831694e-02f,
  2.40177400e-02f, -1.84572358e-02f, 6.65644258e-02f, -4.24390696e-02f, -1.60919353e-01f, 7.37869963e-02f, 1.22131675e-03f, -9.75631103e-02f, -8.47736150e-02f, -8.59528109e-02f,
  7.03889951e-02f, 7.33676478e-02f, 1.01409994e-01f, 3.99227627e-02f, -9.38589498e-02f, 6.42551854e-02f, -5.56026250e-02f, -1.63086802e-01f, -2.87373774e-02f, -2.64306545e-01f,
  3.94282071e-03f, 3.63022313e-02f, 3.91985144e-04f, -5.74640334e-02f, -2.58993525e-02f, -4.73653600e-02f, -3.01640537e-02f, -3.05621494e-02f, 4.09756042e-02f, -2.85523385e-02f,
  6.49659187e-02f, -1.27653986e-01f, -2.25584041e-02f, -8.73190835e-02f, 6.57061487e-02f, 7.39887133e-02f, -3.33011639e-03f, -6.09820224e-02f, 3.59749347e-02f, -1.42195728e-02f,
  -5.24567179e-02f, 1.61579400e-02f, 2.42835679e-03f, -4.88676801e-02f, -2.06635334e-02f, -4.48575616e-02f, -1.60529017e-02f, -1.50591910e-01f, 7.81323481e-03f, -3.96750271e-02f,
  1.00625180e-01f, 3.08042794e-01f, -6.38032630e-02f, 2.02622563e-02f, 4.34645116e-02f, 2.80882847e-02f, 9.25477222e-02f, -4.15125350e-03f, 4.59156260e-02f, -1.00730043e-02f,
  7.57270902e-02f, -1.30764088e-02f, 7.72037208e-02f, 1.80430133e-02f, 1.16854839e-01f, 6.73486888e-02f, -2.73040552e-02f, 8.77957046e-02f, 8.29064474e-02f, -1.30537441e-02f,
  -2.49348581e-02f, 3.20786647e-02f, 1.09421320e-01f, -4.04906981e-02f, 1.27614038e-02f, 1.92760915e-01f, 5.27617615e-03f, -1.57057554e-01f, -1.69885426e-03f, -2.72583306e-01f,
  -2.35324591e-01f, -1.71555132e-01f, 2.25351274e-01f, -1.08689308e-01f, -4.91658822e-02f, 2.65224073e-02f, -1.04928970e-01f, -6.26597852e-02f, -5.23247931e-04f, -1.89551920e-01f,
  1.09419882e-01f, 1.91821635e-01f, 2.27194831e-01f, 1.30095661e-01f, 1.30410239e-01f, -9.03778374e-02f, -1.48139730e-01f, 7.94831291e-02f, 8.04597661e-02f, -1.22601084e-01f,
  -1.32433876e-01f, -2.34068409e-01f, -3.33003514e-02f, -2.98925419e-03f, -1.54738799e-01f, -3.33823971e-02f, -2.72854399e-02f, -1.65296450e-01f, 3.90711501e-02f, -1.08236171e-01f,
  8.82944688e-02f, 1.00057274e-01f, 1.83085844e-01f, -5.05013987e-02f, 1.61848694e-01f, 1.07296549e-01f, -3.61892357e-02f, 3.66212637e-03f, 1.25403568e-01f, 7.40870908e-02f,
  1.05076931e-01f, 3.25561647e-04f, 1.35404274e-01f, 3.82697359e-02f, -7.53607089e-03f, -8.40304978e-03f, -9.96329077e-03f, -2.33988687e-02f, 4.43220958e-02f, 1.80294104e-02f,
  -1.98667459e-02f, -4.60999161e-02f, -2.28611138e-02f, -5.97503921e-03f, -5.75073659e-02f, 1.78167462e-01f, -9.73538868e-03f, 2.30059884e-02f, 1.38604864e-01f, -8.84590968e-02f,
  -1.43156350e-01f, -1.19568393e-01f, -1.18169347e-02f, -1.53785691e-01f, -9.49980989e-02f, -8.79606605e-02f, -3.47455814e-02f, -1.02666974e-01f, 8.93357384e-04f, -3.04419994e-02f,
  9.11996737e-02f, -7.80749694e-02f, -7.89984465e-02f, -4.08535358e-03f, -2.35451036e-03f, 2.61551216e-02f, 4.15504575e-02f, -1.07412584e-01f, 4.63605337e-02f, 2.72800028e-02f,
  -7.77442679e-02f, 5.07292934e-02f, -8.55988637e-02f, -5.70226647e-03f, -1.15609325e-01f, 2.18358245e-02f, -7.57113770e-02f, -1.37970531e-02f, -2.96005420e-02f, -6.71559572e-02f,
  -4.36740294e-02f, 2.42489949e-01f, 1.31423827e-02f, -1.91649012e-02f, 4.98009846e-02f, 1.00994445e-01f, -2.94040088e-02f, 1.45778302e-02f, 1.23552484e-02f, 8.12290758e-02f,
  -2.40730699e-02f, 2.90313568e-02f, 7.50570223e-02f, 4.35928367e-02f, -3.75726707e-02f, 9.09678545e-03f, -1.16224319e-01f, 7.13999709e-03f, -8.73297378e-02f, 5.24375662e-02f,
  -1.50044831e-02f, -1.41740113e-01f, -3.43355015e-02f, 2.10809503e-02f, -5.11725470e-02f, 2.18671001e-02f, 7.77082145e-02f, 7.77632818e-02f, 4.35369685e-02f, -1.97771102e-01f,
  -4.65567596e-02f, -2.47359157e-01f, -1.59691826e-01f, 4.10162695e-02f, 8.47624764e-02f, 2.43209049e-01f, 1.03814945e-01f, 1.30759150e-01f, 1.32387072e-01f, 2.36040559e-02f,
  -9.34954584e-02f, 1.17074527e-01f, -1.07706599e-01f, 1.71065778e-02f, -2.46692561e-02f, -4.98876795e-02f, -4.19976637e-02f, -7.40272477e-02f, 2.15838030e-01f, 2.04642996e-01f,
  1.97155654e-01f, -1.30894603e-02f, -4.91852500e-02f, 9.21045318e-02f, -1.12178974e-01f, 4.41494808e-02f, -1.76775351e-01f, -1.58492520e-01f, -1.05572619e-01f, -5.05747795e-01f,
  -2.82582492e-01f, -1.77875221e-01f, 2.05637850e-02f, -1.08949795e-01f, -8.75577703e-02f, 6.79346249e-02f, -2.61416985e-03f, -8.63102898e-02f, 2.85087302e-02f, 1.16785651e-03f,
  -1.33628339e-01f, 4.95805666e-02f, -4.33595218e-02f, -1.14404261e-01f, 9.94090550e-03f, 9.28177834e-02f, -1.10243827e-01f, -1.16799966e-01f, -1.01101220e-01f, -5.15758768e-02f,
  -7.59892240e-02f, -9.94721055e-02f, -1.60493821e-01f, -6.05232194e-02f, -5.79369217e-02f, -8.00868422e-02f, -2.61572972e-02f, -1.44364506e-01f, 4.26660758e-03f, -2.08207816e-01f,
  -2.60564573e-02f, -8.12670067e-02f, -1.13467127e-01f, 1.43609717e-02f, 7.85274617e-03f, -2.60441806e-02f, -8.30583721e-02f, -4.88626473e-02f, 9.66462791e-02f, -4.81043458e-02f,
  -4.92048301e-02f, 9.71669052e-03f, 6.57747015e-02f, 3.75500470e-02f, -4.55741100e-02f, -1.45103619e-01f, -8.98802504e-02f, -4.27267402e-02f, -1.42975822e-01f, -5.94793260e-02f,
  1.77039597e-02f, -4.04625796e-02f, -1.03804074e-01f, -9.17515978e-02f, -7.05007911e-02f, -5.26814722e-02f, -1.15818707e-02f, -1.63731910e-02f, 4.67988141e-02f, -2.56007351e-02f,
  6.51665702e-02f, 4.72891741e-02f, -8.62470716e-02f, -1.60656199e-01f, -1.25839934e-01f, -3.42732780e-02f, -4.82052043e-02f, -5.58097698e-02f, -5.23217134e-02f, 1.64372977e-02f,
  5.45533514e-03f, -5.97535893e-02f, -6.64959103e-03f, 4.62034829e-02f, 1.58783212e-01f, 9.16434228e-02f, -1.05009556e-01f, -7.10486025e-02f, 3.29440483e-03f, 5.71617438e-03f,
  1.11570749e-02f, 3.23275407e-03f, -6.87751500e-03f, 4.61975224e-02f, -3.03582419e-02f, 7.15976954e-02f, -5.76959178e-02f, 4.83500399e-02f, 8.50596726e-02f, 1.37060776e-01f,
  -2.55731553e-01f, 3.24939191e-01f, -1.28907919e-01f, -1.85555220e-01f, 1.20171949e-01f, 1.87787026e-01f, 1.87285528e-01f, 1.06965356e-01f, 4.45475727e-02f, 1.25234321e-01f,
  7.03038201e-02f, -1.87305510e-01f, -1.64757952e-01f, -1.37773650e-02f, -3.52994390e-02f, 1.58896804e-01f, -1.81655526e-01f, -3.15852553e-01f, -1.23646371e-01f, 1.11987896e-01f,
  -1.18989289e-01f, -3.29929382e-01f, -3.74121815e-01f, -3.54259834e-02f, 1.28934503e-01f, -2.12510809e-01f, -1.58876464e-01f, -1.19828485e-01f, 3.10752410e-02f, -2.49546003e-02f,
  -5.80045674e-03f, 2.23442838e-01f, 9.40930843e-02f, 7.46136978e-02f, 1.62267134e-01f, 1.00563996e-01f, 1.54908836e-01f, 1.64739683e-01f, 1.90006763e-01f, 1.64773703e-01f,
  8.49990267e-03f, 8.36066753e-02f, 1.46405339e-01f, -8.64876807e-03f, 5.42160794e-02f, 1.37322053e-01f, 1.02281608e-01f, 8.10190365e-02f, 9.87933278e-02f, 1.11841522e-01f,
  1.46794664e-02f, 7.48939142e-02f, 8.43100920e-02f, 1.70038879e-01f, 1.87183246e-01f, -8.46847985e-03f, 1.50413811e-01f, 2.51048714e-01f, 1.14626914e-01f, 1.68176413e-01f,
  1.38719857e-01f, -1.55551612e-01f, -8.15672949e-02f, -5.48964068e-02f, -5.44541813e-02f, -3.00619546e-02f, -2.06270851e-02f, -1.12790294e-01f, -1.05548851e-01f, 5.26696295e-02f,
  -1.19996897e-03f, -5.77876233e-02f, -1.12153381e-01f, -7.67672360e-02f, -1.12179257e-01f, -2.49354485e-02f, -1.29538298e-01f, -5.76732121e-02f, -6.64277300e-02f, -5.92807159e-02f,
  -6.17713109e-02f, -6.46457672e-02f, -1.63223684e-01f, -1.29215166e-01f, -5.32970615e-02f, -1.03332840e-01f, -1.14794031e-01f, 1.23239858e-02f, -7.03912973e-02f, -1.21828631e-01f,
  -8.80059041e-03f, 1.35752723e-01f, 1.68343142e-01f, 1.01442441e-01f, 1.31528184e-01f, 1.14370666e-01f, -6.43637264e-03f, 2.00486109e-01f, 1.50189683e-01f, 1.60792589e-01f,
  1.36563167e-01f, 2.20317319e-02f, -1.36916982e-02f, 1.03362709e-01f, 2.65479870e-02f, -1.69212371e-02f, 3.67078856e-02f, -3.93509604e-02f, 4.67376113e-02f, 1.74345806e-01f,
  1.51181877e-01f, 1.60892420e-02f, 6.93091303e-02f, 9.42619368e-02f, 1.41654253e-01f, 4.56486158e-02f, 7.74258077e-02f, 6.20258115e-02f, 1.01296268e-01f, 2.44266540e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.59720540e-01f, 1.63895816e-01f, -1.90596301e-02f, -2.35149741e-01f, 2.34364226e-01f, 1.26226202e-01f, 1.61760867e-01f, -1.37655765e-01f, -1.21048667e-01f, 1.36445239e-01f,
  1.49631813e-01f, -1.23031348e-01f, -7.98252076e-02f, -3.29287276e-02f, -1.27360046e-01f, 1.29460588e-01f, 9.42310467e-02f, -9.68609750e-02f, -4.29796934e-01f, -6.83756843e-02f,
  2.75687367e-01f, -5.57395183e-02f, -3.09097528e-01f, -1.69438168e-01f, 5.81096523e-02f, -6.61468878e-02f, 7.80530870e-02f, -4.26775180e-02f, 2.23001584e-01f, 4.01010036e-01f,
  -1.44040108e-01f, -3.26500796e-02f, 3.49291898e-02f, -8.48727021e-03f, 2.68889535e-02f, -1.96747378e-01f, 4.35318835e-02f, -4.27844301e-02f, -1.00731673e-02f, -6.16217591e-02f,
  8.36494714e-02f, 1.39044911e-01f, 1.58929422e-01f, -3.11679542e-02f, -1.24009065e-01f, -1.54267415e-01f, -1.60048261e-01f, -3.75780344e-01f, -2.45134324e-01f, -7.33755752e-02f,
  2.89704829e-01f, 1.90013945e-01f, 4.93036024e-02f, -1.21922707e-02f, -1.52079657e-01f, -6.48532212e-02f, -1.12297870e-01f, -3.04474175e-01f, -2.41366148e-01f, -2.61185706e-01f,
  8.66680965e-02f, 1.16507739e-01f, 1.72015116e-01f, 2.82655824e-02f, 4.36279066e-02f, 4.96708341e-02f, 7.39360228e-02f, 1.30062908e-01f, 3.58893648e-02f, -1.27810389e-01f,
  -3.63998599e-02f, -1.57207884e-02f, -8.10460970e-02f, -6.90402761e-02f, -5.48006445e-02f, 8.12223703e-02f, 1.29397893e-02f, -7.84446895e-02f, -1.72135774e-02f, -3.27594131e-02f,
  -1.80640183e-02f, -4.49235924e-02f, 9.56469867e-03f, -1.65628895e-01f, 9.15855840e-02f, -4.88937125e-02f, 7.01951534e-02f, -8.33367407e-02f, -2.89691761e-02f, -9.41995438e-03f,
  -2.94101328e-01f, 2.13420078e-01f, -9.00410339e-02f, 7.21561313e-02f, 9.41058546e-02f, -9.61310342e-02f, 6.23421706e-02f, 1.72235295e-02f, 2.50351410e-02f, -8.52944180e-02f,
  -6.48018345e-02f, 1.19794337e-02f, -5.09227924e-02f, -6.04789481e-02f, -2.24621788e-01f, -9.70418155e-02f, 5.08110449e-02f, -1.30230337e-02f, -7.44704902e-02f, -1.24897830e-01f,
  -8.39552954e-02f, -1.77074909e-01f, -2.84569353e-01f, -1.80026442e-01f, -6.51044697e-02f, -2.02984884e-01f, -1.62345067e-01f, -1.90736264e-01f, -2.50544906e-01f, -2.61434495e-01f,
  2.29043700e-02f, -1.49461553e-01f, 1.46462172e-01f, 1.08178265e-01f, 2.20249295e-01f, 2.88802654e-01f, 2.25969672e-01f, 7.09654391e-02f, 8.55906084e-02f, -3.96784656e-02f,
  -1.62507758e-01f, -3.00007723e-02f, -4.99588624e-02f, 3.40951122e-02f, 1.19276546e-01f, 1.59143493e-01f, 2.24983007e-01f, 5.68274967e-02f, 2.06675276e-01f, 8.75856131e-02f,
  -5.47083244e-02f, -2.88071707e-02f, -8.67221057e-02f, -8.70538577e-02f, -8.90675187e-02f, 9.06707719e-02f, 3.16539343e-04f, -5.33439703e-02f, -4.12533469e-02f, -9.56443045e-03f,
  1.10586956e-01f, -1.10683087e-02f, 1.96481109e-01f, 9.49732959e-02f, 9.63024646e-02f, -5.95593872e-03f, 1.41016349e-01f, -1.66127816e-01f, -1.05507597e-01f, 7.99932256e-02f,
  -1.82459261e-02f, -1.38984127e-02f, 8.09766129e-02f, 3.45923402e-03f, 1.80896337e-03f, 5.52695878e-02f, -1.07210413e-01f, 6.78562745e-02f, 1.03735343e-01f, 1.93695668e-02f,
  5.68593778e-02f, 1.39027666e-02f, 5.73114604e-02f, 1.01140723e-01f, 1.16110958e-01f, 3.51248942e-02f, -1.04629453e-02f, 7.89673813e-03f, 8.71610865e-02f, 4.61704731e-02f,
  2.03308295e-02f, -4.20774594e-02f, 5.93916401e-02f, -3.96368690e-02f, -1.13828778e-01f, 5.53874038e-02f, -2.62393412e-04f, 1.00117795e-01f, 1.42311364e-01f, -1.32061392e-01f,
  -1.20362073e-01f, 1.08921915e-01f, 6.36016503e-02f, 8.88527185e-02f, 3.34267505e-02f, 2.02405304e-02f, 4.20691296e-02f, -8.63067657e-02f, -5.25762215e-02f, -8.18204805e-02f,
  6.61992375e-03f, 1.23047434e-01f, 4.04559560e-02f, -3.58662345e-02f, 7.95007497e-02f, -3.70577537e-02f, -4.58762385e-02f, -5.66717237e-02f, -2.29139719e-02f, -1.42584652e-01f,
  2.99707174e-01f, 1.20194033e-01f, -2.60749198e-02f, -2.28534285e-02f, 3.67023982e-03f, -1.76262587e-01f, 1.04748681e-01f, -7.51106441e-02f, -7.68718272e-02f, 7.29184300e-02f,
  8.69082063e-02f, -2.59553250e-02f, 3.51692475e-02f, 4.96315360e-02f, 3.71653400e-03f, 2.32551005e-02f, 1.60143599e-02f, 1.27647519e-01f, 8.55998695e-02f, -3.15321609e-02f,
  -1.31903052e-01f, 2.03804132e-02f, 7.70901963e-02f, -1.07847536e-02f, 3.49183357e-03f, 4.38685566e-02f, 2.64579430e-03f, 8.39280337e-02f, 1.32685885e-01f, -4.85363193e-02f,
  1.34591490e-01f, -1.58303484e-01f, -2.12292410e-02f, 2.28388801e-01f, 3.75752561e-02f, -2.57084202e-02f, 1.21250646e-02f, 3.74125689e-02f, 2.48122752e-01f, 1.53160870e-01f,
  2.54250407e-01f, 4.54101086e-01f, 4.32392091e-01f, 2.05551803e-01f, 1.88995257e-01f, 3.49226929e-02f, -1.80616319e-01f, 1.55671626e-01f, 1.36260197e-01f, 4.03100699e-02f,
  1.10882990e-01f, -1.21270001e-01f, -7.72716701e-02f, 1.56906787e-02f, -8.24633017e-02f, 1.53409988e-01f, -6.44121245e-02f, -3.19386363e-01f, -1.54409453e-01f, -2.20986977e-01f,
  2.15189010e-01f, -1.59771338e-01f, 2.18037307e-01f, -2.94028707e-02f, -1.03905216e-01f, 5.18571027e-02f, 8.97774249e-02f, -3.00234910e-02f, -1.57084703e-01f, -6.65668696e-02f,
  -1.05735242e-01f, -7.74752945e-02f, 2.69312635e-02f, -2.30355784e-02f, -1.77400246e-01f, 3.13220732e-02f, -1.21412024e-01f, 5.82253821e-02f, -9.63782705e-03f, 1.13106497e-01f,
  8.45470726e-02f, 6.46804199e-02f, 2.84142829e-02f, 1.20065004e-01f, 1.40629232e-01f, 1.38914868e-01f, 7.55025595e-02f, -4.84521501e-02f, -1.76682863e-02f, -8.49438459e-03f,
  1.14022955e-01f, 1.12857163e-01f, 7.01013803e-02f, 3.49868499e-02f, 6.79476336e-02f, -2.01096907e-02f, -5.39707020e-02f, -7.56652802e-02f, -1.87739159e-03f, -6.31390661e-02f,
  2.66677365e-02f, 1.58626199e-01f, 6.99569583e-02f, 1.30650416e-01f, 1.98112607e-01f, -1.20394856e-01f, -2.46971011e-01f, -5.07644936e-02f, 1.25915110e-02f, 3.12473718e-02f,
  -6.92400411e-02f, -5.40072322e-02f, -8.92113224e-02f, -1.57183558e-01f, -1.73115462e-01f, 5.23756444e-02f, 6.83944225e-02f, 5.82145564e-02f, 2.07565166e-02f, 4.65690643e-02f,
  1.43194467e-01f, 1.38982207e-01f, 1.19726151e-01f, -9.73786116e-02f, -2.91770130e-01f, -9.36975777e-02f, 7.13454336e-02f, -1.02150023e-01f, -1.19486742e-01f, -3.48092876e-02f,
  -6.57203570e-02f, -6.61591291e-02f, -1.13251403e-01f, -1.53021351e-01f, -6.66097775e-02f, -3.91461737e-02f, -1.59192920e-01f, -4.00465429e-02f, -6.44497126e-02f, -8.29783529e-02f,
  -4.49471325e-02f, -1.56697202e-02f, 1.46729141e-01f, 6.13817349e-02f, -5.89566752e-02f, 1.01240762e-02f, 1.05602719e-01f, -4.97717746e-02f, -1.07228979e-02f, 9.59259272e-02f,
  2.98295647e-01f, -2.45581985e-01f, 2.11287707e-01f, 5.38818352e-02f, 2.03035712e-01f, 4.46568549e-01f, 5.83901286e-01f, 2.56454110e-01f, -5.42688332e-02f, 1.46970242e-01f,
  -1.82847172e-01f, -5.59462249e-01f, -4.93529469e-01f, -3.46931756e-01f, -7.61445537e-02f, 3.21692675e-01f, 2.14330748e-01f, -3.78804542e-02f, 1.24605559e-01f, 2.14146614e-01f,
  -4.77912277e-02f, 1.36037722e-01f, 1.12153739e-02f, -2.95812860e-02f, 4.84605096e-02f, -1.29509360e-01f, -1.38243111e-02f, -4.46807444e-02f, -1.48071960e-01f, -1.50258765e-01f,
  7.98275396e-02f, -6.36244491e-02f, 2.74883751e-02f, -2.39519984e-01f, -1.49009302e-01f, -1.09037600e-01f, -5.79382330e-02f, -7.37380311e-02f, -1.05539307e-01f, -1.22345798e-02f,
  -1.80160701e-01f, -2.67771184e-02f, -7.18767568e-02f, -1.13292314e-01f, 1.07064985e-01f, 3.13715860e-02f, -1.38733443e-02f, -7.34391212e-02f, -1.23475879e-01f, -6.27201200e-02f,
  -2.74264872e-01f, 8.89097974e-02f, 1.80117995e-01f, 1.14558756e-01f, -6.76180720e-02f, 3.98601890e-02f, 1.78606045e-02f, 2.38565449e-02f, 2.36136187e-02f, -7.31899962e-02f,
  3.51651534e-02f, 1.05734535e-01f, 1.28493324e-01f, 3.08448486e-02f, 1.07519679e-01f, -1.62376333e-02f, -1.03152022e-02f, -7.64613003e-02f, 1.46370446e-02f, 1.22172959e-01f,
  -6.70770928e-02f, 8.06520060e-02f, -1.04662068e-01f, -5.30410074e-02f, -1.24664521e-02f, 4.69207466e-02f, -1.64472358e-03f, -4.33808193e-02f, -2.41570659e-02f, -6.71222955e-02f,
  -7.94460550e-02f, 2.43487339e-02f, -4.18491252e-02f, -1.29464164e-01f, 1.29182294e-01f, -5.05168773e-02f, -1.54066328e-02f, -1.41000986e-01f, -7.19629526e-02f, 2.07828563e-02f,
  -2.94440001e-01f, -7.37852454e-02f, -6.14296608e-02f, -9.52955857e-02f, -4.13068905e-02f, -1.54389828e-01f, -1.84521005e-01f, -2.76975594e-02f, -1.01385154e-02f, -9.57875848e-02f,
  -4.47766632e-02f, -4.10797521e-02f, -8.71939808e-02f, 1.33754443e-02f, -4.71046641e-02f, 7.23710507e-02f, -2.02486470e-01f, 3.47573459e-02f, -1.71808619e-02f, 1.09551892e-01f,
  -4.20877673e-02f, 1.92566499e-01f, 1.30904540e-01f, -2.76209470e-02f, -4.51411158e-02f, 7.64985085e-02f, 1.32880911e-01f, 7.14215711e-02f, 8.70585665e-02f, 2.24697459e-02f,
  5.06312847e-01f, -4.10265215e-02f, 3.20310146e-01f, -2.57604662e-02f, 2.96932846e-01f, 1.94130301e-01f, 3.99474055e-01f, 1.19885348e-01f, -7.53711164e-02f, 1.01348430e-01f,
  -7.97520056e-02f, -4.56608415e-01f, -3.70505452e-01f, -3.04786325e-01f, -1.77580751e-02f, 1.91185921e-01f, 4.09244969e-02f, 7.99600706e-02f, 1.33593798e-01f, 9.19198766e-02f,
  -3.03844035e-01f, 6.35654107e-02f, 1.18901469e-01f, -2.80579329e-02f, -1.17860027e-01f, -1.54269829e-01f, 4.07104380e-02f, 1.92390993e-01f, -7.21341968e-02f, -2.89546579e-01f,
  -3.05310655e-02f, 3.66720945e-01f, -1.54014975e-01f, -1.08705379e-01f, -4.30822298e-02f, -1.37062311e-01f, -8.91409069e-02f, -8.59539956e-02f, -1.74296439e-01f, -1.35016039e-01f,
  -5.60218096e-03f, -7.11521506e-02f, 9.63728875e-03f, -1.21226728e-01f, 2.30233163e-01f, 6.52456135e-02f, -5.39228395e-02f, -1.62372053e-01f, -1.71455860e-01f, -1.29626375e-02f,
  -2.33885571e-01f, 9.62256789e-02f, 2.64881551e-01f, 3.85623202e-02f, 3.97729920e-03f, 4.04873081e-02f, 2.31391024e-02f, -5.20021208e-02f, 1.14217410e-02f, -2.73412585e-01f,
  1.35952886e-02f, 1.09312341e-01f, 1.53016672e-02f, -9.82292346e-04f, -8.41929764e-02f, -5.15626706e-02f, 2.03044098e-02f, -1.80713683e-02f, -1.92229003e-02f, 4.37622517e-02f,
  5.40607460e-02f, -3.74197215e-02f, -5.85300773e-02f, 1.05479909e-02f, -1.83152370e-02f, -5.99697456e-02f, -4.06781025e-02f, -8.87261182e-02f, 8.54715705e-02f, 2.34611109e-02f,
  -8.41913372e-02f, 1.21913239e-01f, 1.02676496e-01f, -3.05741075e-02f, 6.99127391e-02f, -1.44063905e-02f, -1.84581894e-02f, -9.92669314e-02f, 6.86049163e-02f, 1.22801661e-01f,
  -3.53967965e-01f, 1.20505571e-01f, -1.06768139e-01f, -1.94528028e-01f, 9.39232782e-02f, -2.88368035e-02f, 5.24152592e-02f, 9.87568721e-02f, -1.89906370e-03f, -3.70234773e-02f,
  1.26538500e-01f, -5.70091279e-03f, 7.45026916e-02f, 6.61389455e-02f, 5.26018664e-02f, 2.70301085e-02f, -1.60121575e-01f, -9.42676663e-02f, -9.71707865e-04f, -4.19623069e-02f,
  -1.27236471e-01f, -3.44772786e-02f, 1.08868510e-01f, 1.25842348e-01f, -8.69039819e-02f, 1.17835395e-01f, 5.97819872e-02f, 8.80863219e-02f, 8.36889148e-02f, -5.31030856e-02f,
  6.66633070e-01f, -3.55796158e-01f, -4.51395512e-01f, 3.45658064e-01f, -1.09681726e-01f, -1.23754658e-01f, -2.11616129e-01f, 1.38686392e-02f, 2.10616335e-01f, -1.45952359e-01f,
  -3.38011622e-01f, -1.88599870e-01f, -1.98393449e-01f, -3.11776102e-01f, 3.32738385e-02f, -5.42643182e-02f, -1.80082233e-03f, -1.54671311e-01f, 4.37566042e-02f, -3.48893218e-02f,
  6.54893890e-02f, 2.77693570e-01f, 2.29160517e-01f, 7.94489011e-02f, -7.01730549e-02f, -4.35617170e-04f, -1.19525440e-01f, -2.06893221e-01f, -2.90699273e-01f, -1.78955734e-01f,
  -3.11555445e-01f, -2.49757111e-01f, -4.13146503e-02f, 1.81410015e-02f, -7.41806701e-02f, 4.80947420e-02f, -3.15593071e-02f, -7.73009881e-02f, -5.55793568e-02f, -8.57688934e-02f,
  -2.40584493e-01f, -1.76733553e-01f, -1.69009656e-01f, -1.80896401e-01f, -1.90435186e-01f, 6.80575296e-02f, 1.24562748e-01f, 9.04248189e-03f, 2.76448969e-02f, -2.24708676e-01f,
  -8.05753097e-02f, -1.94360867e-01f, -1.95944116e-01f, -1.56953737e-01f, -1.96190849e-01f, -1.14789158e-01f, -2.41472438e-01f, -1.93358257e-01f, -2.28469193e-01f, 1.09517321e-01f,
  1.11591749e-01f, -1.48305595e-01f, -7.35661536e-02f, 1.65697634e-02f, 1.66452616e-01f, -4.05097567e-02f, -9.35076997e-02f, 5.92807718e-02f, 1.51981119e-04f, 1.26339914e-02f,
  -1.26402617e-01f, -6.19850866e-02f, -4.26707678e-02f, 1.40770063e-01f, -9.52358097e-02f, -1.16178609e-01f, 3.25870290e-02f, 3.90566587e-02f, -3.33248191e-02f, 9.24808979e-02f,
  2.21964307e-02f, -7.36268833e-02f, 3.48646380e-02f, 3.68136987e-02f, 9.32452269e-03f, -7.71313161e-02f, 3.39143686e-02f, -3.22710089e-02f, -2.71864440e-02f, 5.13848588e-02f,
  2.85262138e-01f, -1.50973305e-01f, 1.28401071e-01f, 2.77396105e-02f, -3.08994390e-02f, -4.04923186e-02f, -4.22177613e-02f, -6.00922212e-04f, -1.83522496e-02f, -1.24687418e-01f,
  -9.28442329e-02f, -1.25823110e-01f, -4.94969264e-02f, -1.20411500e-01f, 5.52246980e-02f, 4.37165163e-02f, 1.48804307e-01f, 1.16048204e-02f, 1.22764863e-01f, 8.98216385e-03f,
  1.84134245e-01f, 1.79670632e-01f, 1.64004862e-01f, 6.80218861e-02f, -1.12723196e-02f, 8.99094343e-02f, 1.07118711e-02f, 4.51078117e-02f, -1.72943864e-02f, 4.33884352e-01f,
  -7.85451233e-01f, -3.53764653e-01f, 1.94804206e-01f, -6.48111999e-01f, -6.81810021e-01f, -3.34478140e-01f, -3.21628392e-01f, -2.09924266e-01f, -3.59570086e-01f, -4.62990165e-01f,
  -1.29917726e-01f, 2.09709242e-01f, 3.14399958e-01f, 3.44064415e-01f, 2.92032272e-01f, -2.71895081e-01f, -3.14707071e-01f, 2.13437811e-01f, 2.06287548e-01f, -3.17452252e-01f,
  -3.69982570e-01f, -2.24212617e-01f, 1.40326272e-04f, 9.61876707e-04f, -3.05824280e-01f, 1.64094731e-01f, -5.75066544e-02f, -7.89523125e-02f, -1.92952767e-01f, -3.81235629e-01f,
  2.73150116e-01f, -1.22070268e-01f, -9.46763977e-02f, -8.40738416e-02f, -1.37760103e-01f, 4.26034406e-02f, -1.26032948e-01f, 2.75761518e-03f, -3.04672439e-02f, -9.02224258e-02f,
  -9.45279673e-02f, 4.88265418e-03f, 1.28196761e-01f, 1.44883841e-01f, -5.93378916e-02f, -4.23054732e-02f, 3.20201665e-02f, -2.15022415e-02f, -1.23174815e-02f, 8.49161744e-02f,
  -1.94224134e-01f, -4.46243398e-02f, 1.39563248e-01f, 2.15163946e-01f, 5.56538105e-02f, 1.09132811e-01f, -9.40013118e-03f, 7.79518858e-02f, 8.29265416e-02f, -1.08948246e-01f,
  -1.86112523e-02f, 1.71340615e-01f, -4.71537448e-02f, -3.60311829e-02f, 1.11571541e-02f, 1.04369946e-01f, 3.34455483e-02f, -5.59872203e-02f, -3.94115634e-02f, 1.34298712e-01f,
  7.49737993e-02f, -1.01153903e-01f, 2.51154192e-02f, -5.48553653e-02f, 6.11587688e-02f, -8.80979523e-02f, 2.17186362e-02f, 3.95718813e-02f, -5.71946912e-02f, -9.02897045e-02f,
  3.41281258e-02f, -2.77328538e-03f, 3.67923863e-02f, 1.69436961e-01f, -6.93651214e-02f, -1.16635390e-01f, 4.19116728e-02f, 6.26984844e-03f, -1.46319391e-02f, -1.21790446e-01f,
  7.11046830e-02f, -8.38261023e-02f, -1.07813448e-01f, 9.06010643e-02f, 9.57413763e-02f, 9.34468433e-02f, -3.73776257e-02f, -1.02886163e-01f, -5.17096370e-02f, -1.50594905e-01f,
  -1.31034281e-03f, -2.05414947e-02f, -8.72046966e-03f, -1.96810113e-03f, -2.94997059e-02f, 5.56463189e-02f, -1.41814366e-01f, -2.95963660e-02f, 1.37623781e-02f, -4.47851559e-03f,
  1.70479212e-02f, -7.46713206e-02f, -2.34166370e-03f, 1.46093607e-01f, 1.64906532e-02f, 8.86247307e-03f, 1.48948997e-01f, 1.11750320e-01f, 1.93964809e-01f, -2.01760512e-02f,
  1.94619149e-01f, -4.46154982e-01f, 2.33528838e-01f, 2.83669382e-01f, 3.80768061e-01f, 3.03301632e-01f, 1.43203318e-01f, 1.56043828e-01f, 2.67156512e-01f, 1.10306181e-01f,
  -1.00529701e-01f, 3.91642377e-02f, 8.08858797e-02f, 3.09106316e-02f, -6.27520680e-02f, 1.05437912e-01f, 2.82405138e-01f, 2.09983438e-01f, 1.22186743e-01f, 2.56520212e-01f,
  7.87537917e-02f, 1.18814632e-01f, 2.61924379e-02f, -3.67115624e-02f, 6.69265762e-02f, 1.86941713e-01f, -1.59823056e-02f, 5.10867462e-02f, -4.72294278e-02f, -1.74779389e-02f,
  3.35201584e-02f, -1.09077044e-01f, 2.80645132e-01f, -1.62934903e-02f, -1.48667827e-01f, -1.67018220e-01f, -6.50987029e-02f, -1.35451734e-01f, -1.79926872e-01f, 3.28719877e-02f,
  -5.38845845e-02f, -7.81876966e-02f, -7.38936290e-02f, -4.48435880e-02f, -1.44331738e-01f, -1.41931444e-01f, -9.37595963e-02f, 1.62444822e-02f, 1.79330662e-01f, -4.68914621e-02f,
  -1.54183850e-01f, 2.10234225e-02f, 2.11109534e-01f, 1.92609921e-01f, -1.34559916e-02f, 9.30568129e-02f, 3.34001482e-02f, 2.07661502e-02f, 8.13938156e-02f, -2.72827279e-02f,
  1.47576749e-01f, 1.52645737e-01f, 1.68343052e-01f, 1.95229873e-02f, 1.01684213e-01f, 1.71938941e-01f, 1.89371686e-02f, 1.00405008e-01f, 1.00852288e-01f, -1.41653746e-01f,
  1.43817207e-02f, 1.72678158e-01f, 1.48707092e-01f, 9.68289748e-02f, -1.89953465e-02f, 8.19600448e-02f, -9.76775885e-02f, -8.50252658e-02f, 5.71985506e-02f, -2.11827923e-02f,
  1.50940986e-02f, -3.27833393e-03f, -1.34647965e-01f, -5.16099967e-02f, -2.03569792e-02f, -8.03254247e-02f, 2.85271686e-02f, -5.58101237e-02f, -1.12064295e-01f, 4.84453253e-02f,
  -1.79879274e-02f, 2.78568566e-01f, 1.03972994e-01f, 1.15371041e-01f, -5.37645780e-02f, -2.51092821e-01f, 1.60095409e-01f, 8.82942230e-03f, -1.35680348e-01f, -1.25297457e-01f,
  -9.62963998e-02f, -1.83554709e-01f, -1.76770184e-02f, -1.12082131e-01f, 2.72732624e-03f, -1.52697235e-01f, -2.95169324e-01f, 9.20905769e-02f, 1.54262662e-01f, -6.49632290e-02f,
  -8.05291533e-02f, 4.16695029e-02f, 1.23047441e-01f, 1.14623412e-01f, 1.83152780e-03f, 1.48386672e-01f, -2.73849554e-02f, 2.27587726e-02f, -7.63206789e-03f, -7.23064095e-02f,
  2.72574872e-01f, -4.67365116e-01f, -2.28959337e-01f, -1.08134329e-01f, -4.13110018e-01f, -3.30711037e-01f, -5.24634600e-01f, 9.39266831e-02f, 1.89895347e-01f, -3.58765185e-01f,
  -6.61376193e-02f, 3.61733615e-01f, 1.54370308e-01f, 1.27213299e-01f, 2.79261529e-01f, -4.27037358e-01f, -2.60559112e-01f, 1.04585931e-01f, 4.12717670e-01f, 9.59061161e-02f,
  5.30291796e-02f, 5.65429032e-02f, 3.14307719e-01f, 8.23270977e-02f, -3.39004576e-01f, -1.40326098e-02f, -3.94728631e-01f, -1.76879570e-01f, -1.07682154e-01f, -3.47131848e-01f,
  -3.00228745e-01f, -1.77901015e-01f, 6.51600808e-02f, 1.76037356e-01f, -1.28798157e-01f, 2.45613512e-02f, -1.08357608e-01f, -4.58734781e-02f, 3.42000388e-02f, -5.99912256e-02f,
  7.17254207e-02f, -1.60212058e-03f, 7.86786452e-02f, -6.96396157e-02f, -1.08367726e-01f, 1.45108597e-02f, 2.99847946e-02f, 1.08787872e-01f, 1.95188634e-02f, -8.15795735e-02f,
  -7.45864958e-02f, -3.81654017e-02f, 6.96662888e-02f, -6.39636368e-02f, 1.22434041e-02f, 7.41598010e-02f, -1.22215368e-01f, -2.86941063e-02f, 9.34689026e-03f, -2.72947192e-01f,
  -7.39512295e-02f, -8.61441419e-02f, 1.18869552e-02f, 1.30342051e-01f, -1.87020358e-02f, 3.46857384e-02f, 2.12906953e-02f, 1.40884062e-02f, 6.37199134e-02f, -3.03634144e-02f,
  -4.75531109e-02f, -3.17261331e-02f, 5.83843179e-02f, -8.61908272e-02f, 1.85592715e-02f, -3.02609429e-03f, 2.08227942e-03f, 6.06387965e-02f, 5.12990244e-02f, 6.85990229e-02f,
  8.72506350e-02f, 4.81714495e-02f, -3.31181362e-02f, -6.72053471e-02f, 3.15473303e-02f, 3.30655486e-03f, 2.88614742e-02f, 1.69836171e-02f, 1.13006607e-01f, 7.23450780e-02f,
  1.11473911e-01f, 2.55591393e-01f, -1.61687657e-01f, 8.81405547e-02f, 5.29160574e-02f, -5.09570017e-02f, -1.04161836e-01f, 6.56833779e-03f, 6.78712130e-02f, 7.63189122e-02f,
  1.01039253e-01f, 9.22024902e-03f, -1.68865696e-01f, -1.00328788e-01f, 5.30207008e-02f, 5.85131757e-02f, 1.84686016e-02f, 8.54611024e-02f, 1.39979541e-01f, -9.26591754e-02f,
  8.06906819e-03f, 8.79333392e-02f, 1.20291352e-01f, -4.01122309e-03f, 1.08056283e-02f, 1.17768355e-01f, -1.21334791e-01f, -2.17504445e-02f, 1.02647379e-01f, -3.88616994e-02f,
  2.08720013e-01f, 5.01188397e-01f, 2.66286910e-01f, -9.40690190e-02f, -1.63737163e-01f, -8.84058699e-02f, 1.82343964e-02f, -5.56812920e-02f, -3.16377401e-01f, 2.17655245e-02f,
  -8.02587569e-02f, -8.07782933e-02f, 1.14333937e-02f, 1.04502045e-01f, 1.60030112e-01f, 1.11552425e-01f, 1.27547741e-01f, 1.33965418e-01f, 1.30647132e-02f, -1.05703631e-02f,
  -1.64350178e-02f, 4.49855886e-02f, -2.10375600e-02f, 5.25287427e-02f, 2.67608583e-01f, -1.67686850e-01f, -4.13908064e-02f, 2.79978067e-01f, 1.06781736e-01f, 4.32605237e-01f,
  7.23869801e-02f, 1.26273021e-01f, -2.51380503e-01f, 5.25674820e-02f, 7.07845911e-02f, -4.95996065e-02f, -2.70010024e-01f, 8.33464507e-03f, -1.17856413e-01f, 5.81559278e-02f,
  1.28907740e-01f, 1.04165144e-01f, 1.28905162e-01f, 5.56838140e-03f, -1.14895161e-02f, -6.24665432e-02f, -4.42768028e-03f, 2.29472920e-01f, 1.57484770e-01f, 9.85470973e-03f,
  8.40881765e-02f, -3.70388501e-03f, 6.72824010e-02f, -9.61220078e-03f, 1.21984884e-01f, -8.98323432e-02f, 1.46995589e-01f, 2.35395387e-01f, -7.25581124e-02f, 1.15050219e-01f,
  -1.44636407e-01f, 1.41293809e-01f, 2.37792134e-02f, 3.17463093e-02f, 1.39698973e-02f, -9.93031915e-03f, -8.87324195e-03f, 7.69189000e-02f, 7.84618333e-02f, 8.38894546e-02f,
  -5.54923974e-02f, -6.73106238e-02f, 1.02349585e-02f, -8.38690028e-02f, -1.41447270e-02f, 2.31524110e-02f, 1.54274050e-02f, -3.52541097e-02f, -1.33249894e-01f, -2.64126584e-02f,
  6.36069104e-02f, 1.76939722e-02f, -1.03989206e-01f, -2.36533750e-02f, 3.48419361e-02f, -1.48523003e-01f, -6.90950304e-02f, -1.05166726e-01f, -1.09387711e-01f, -6.86457381e-02f,
  -2.14870378e-01f, -1.18356273e-01f, -2.71524251e-01f, -2.52120420e-02f, 9.03023034e-02f, 1.57462899e-02f, -6.71345964e-02f, 4.64669652e-02f, 7.98809249e-03f, -1.20729376e-02f,
  7.01756403e-02f, 7.13451765e-03f, -5.23192286e-02f, -9.30970982e-02f, -1.05435690e-02f, -1.69857860e-01f, 3.41600664e-02f, -1.95039548e-02f, -1.20941266e-01f, 8.50082561e-02f,
  8.23068470e-02f, -2.31747538e-01f, -2.58386910e-01f, -1.35693297e-01f, -1.83839008e-01f, -3.72203350e-01f, -2.69619823e-01f, -1.22112244e-01f, -2.89184302e-01f, -3.88946861e-01f,
  -2.84134179e-01f, -3.04360807e-01f, -1.48149461e-01f, -5.54678403e-02f, 1.06348753e-01f, -1.14641704e-01f, -5.13210654e-01f, -1.45706981e-01f, 3.68493795e-02f, -3.04503143e-01f,
  -3.43819559e-02f, 8.90629441e-02f, -1.81835771e-01f, -1.35313526e-01f, -5.26212454e-01f, -5.25046706e-01f, -2.32838750e-01f, -1.08930431e-01f, 1.84179679e-01f, 2.46390104e-01f,
  3.42401683e-01f, 2.25064263e-01f, 1.22521892e-01f, 2.20265836e-01f, 1.96779862e-01f, 1.67860776e-01f, -3.88321392e-02f, 2.55116858e-02f, 4.61466312e-02f, 1.11361735e-01f,
  -5.34279235e-02f, -1.14608541e-01f, 3.08135292e-03f, 7.13692009e-02f, 6.62426353e-02f, -1.41673744e-01f, -4.91410261e-03f, -2.98853088e-02f, -5.25233857e-02f, -2.28988379e-01f,
  6.58288747e-02f, 1.31888837e-01f, -3.81942792e-03f, 1.90645963e-01f, 1.41011858e-02f, -6.18644357e-02f, 7.74975121e-02f, -3.50611098e-02f, -7.70097524e-02f, -1.46998286e-01f,
  4.64211963e-02f, 1.30917534e-01f, -2.09600151e-01f, -1.31532922e-01f, -1.92282960e-01f, 5.64325675e-02f, 4.99626175e-02f, 1.25508159e-01f, -1.62123650e-01f, -3.78875136e-01f,
  8.97677615e-02f, -3.83977871e-03f, -7.87596777e-02f, 1.08080529e-01f, -5.25710769e-02f, -3.98040824e-02f, -1.14685819e-02f, -1.93124823e-03f, 7.18887821e-02f, -1.08960301e-01f,
  -4.79548937e-03f, -3.56439538e-02f, 2.13259540e-04f, -1.82694450e-01f, 4.44127433e-03f, 3.74502875e-02f, -7.32832879e-04f, -3.43109071e-02f, -8.52149632e-03f, -4.89129499e-02f,
  7.28608295e-02f, 2.12662499e-02f, -8.86243358e-02f, 6.75764680e-02f, -1.38396546e-01f, -2.37595662e-02f, 1.27846757e-02f, -4.92936559e-03f, -8.71248171e-02f, 7.22704381e-02f,
  -4.40277196e-02f, 1.54227421e-01f, -1.65164515e-01f, 7.16384128e-03f, -1.26187503e-01f, 8.11642222e-03f, 9.97026563e-02f, 8.26000124e-02f, 4.99178544e-02f, -5.07537872e-02f,
  -5.61276153e-02f, -1.23613641e-01f, -1.64989620e-01f, 7.34062642e-02f, -1.36739798e-02f, -3.75337265e-02f, -3.69637720e-02f, -6.36944845e-02f, 3.40878144e-02f, 6.40716553e-02f,
  -1.39889847e-02f, -2.08911851e-01f, -2.91197568e-01f, -4.03409421e-01f, 2.43597105e-02f, -1.81280077e-01f, -8.06112587e-02f, 3.68795283e-02f, -2.78013170e-01f, -5.41627526e-01f,
  -1.02135587e+00f, 1.24757979e-02f, 3.61452729e-01f, -3.32590342e-01f, -1.04272276e-01f, -1.55907631e-01f, -7.24833384e-02f, -3.54043126e-01f, -2.87228554e-01f, 6.20198995e-02f,
  1.55225530e-01f, 1.00355633e-01f, 7.32893795e-02f, 9.08949077e-02f, -8.62045512e-02f, 1.02970809e-01f, 9.02294964e-02f, 1.70603041e-02f, -2.96344906e-01f, -1.54159874e-01f,
  -6.01442270e-02f, -1.25469595e-01f, -2.27794111e-01f, -2.19285280e-01f, 2.56068800e-02f, 4.06544656e-02f, 3.27790350e-01f, 1.23812720e-01f, 2.73036033e-01f, 1.50513619e-01f,
  3.57596844e-01f, -1.45612046e-01f, 4.76525957e-03f, -2.04024628e-01f, 1.88267045e-02f, -1.30640656e-01f, -5.94597906e-02f, -4.04712707e-02f, -9.07074437e-02f, -7.16582090e-02f,
  -5.37410453e-02f, -1.14573784e-01f, -1.59064695e-01f, -9.06011164e-02f, -6.99713230e-02f, -1.51039720e-01f, 2.10505351e-02f, -3.14075267e-03f, 5.43773137e-02f, 8.26304853e-02f,
  -5.93605414e-02f, 4.23946194e-02f, 4.71587218e-02f, 2.73757055e-02f, 1.00032665e-01f, -7.66964853e-02f, 1.96633503e-01f, -3.28525007e-02f, 1.69536650e-01f, 7.06325322e-02f,
  -6.36645854e-02f, -2.56631263e-02f, -3.84548679e-02f, 3.73927765e-02f, -4.10394855e-02f, -1.61398381e-01f, -8.53206515e-02f, -3.34705338e-02f, -3.15435641e-02f, -1.52591988e-02f,
  -6.59769326e-02f, 1.05363943e-01f, 8.64987299e-02f, -6.95465207e-02f, 5.77889308e-02f, -8.80704522e-02f, -9.32454988e-02f, -3.40414457e-02f, 1.12148955e-01f, -1.49473995e-01f,
  2.46414430e-02f, -5.26894927e-02f, -3.37420665e-02f, 1.98304132e-02f, 8.08783621e-02f, 7.29481969e-03f, 3.01773124e-03f, -4.52963309e-03f, -4.07012664e-02f, -1.69132035e-02f,
  2.11157709e-01f, 1.38136655e-01f, -8.50787461e-02f, -1.20156936e-01f, 4.34611319e-03f, 1.73910195e-03f, 1.73772931e-01f, -5.32425456e-02f, -2.48391349e-02f, 5.37208170e-02f,
  7.17836395e-02f, -1.01462618e-01f, -4.61906716e-02f, 5.42650297e-02f, -4.19359840e-02f, 1.09931037e-01f, 6.66348860e-02f, 3.46598066e-02f, 1.78627640e-01f, 2.12298810e-01f,
  -2.21612807e-02f, 1.64576113e-01f, 4.35829312e-02f, 9.72670093e-02f, 1.91558581e-02f, -1.16105434e-02f, 1.62693292e-01f, 5.78652732e-02f, 1.50762275e-01f, -5.15714251e-02f,
  -4.72560644e-01f, -3.75539750e-01f, -4.21985865e-01f, -1.84338227e-01f, -8.82006064e-02f, -4.39153239e-02f, -2.58233339e-01f, 1.06627114e-01f, 8.09225142e-02f, -1.64514512e-01f,
  -1.95682466e-01f, -1.03025362e-01f, -2.21071482e-01f, -1.69016957e-01f, -2.63877600e-01f, -4.24238175e-01f, -3.83825749e-01f, -3.12989920e-01f, -6.59408197e-02f, 1.76374093e-01f,
  -3.18777934e-02f, -2.82841086e-01f, -1.69675708e-01f, 1.32525936e-01f, 6.55511469e-02f, 8.13310519e-02f, -1.93040252e-01f, -1.10309906e-01f, -4.28687371e-02f, -3.93280834e-01f,
  -2.62691200e-01f, 1.33096546e-01f, 1.47931531e-01f, 9.25667807e-02f, -2.78775897e-02f, 8.51657540e-02f, -4.95356061e-02f, -1.07517624e-02f, -3.78601556e-03f, -4.91741560e-02f,
  -2.27869097e-02f, 3.31189893e-02f, -8.38548169e-02f, -4.36508581e-02f, -7.79452454e-03f, 3.80283967e-02f, 1.44863576e-01f, 2.13886853e-02f, -4.38910946e-02f, 1.56366467e-01f,
  -3.53516079e-02f, 1.41040906e-01f, 6.99132755e-02f, 2.86698937e-01f, 2.33882606e-01f, 4.77377065e-02f, 2.75121897e-01f, 3.21942985e-01f, 2.98823088e-01f, 2.12677330e-01f,
  -2.38401800e-01f, -8.72813091e-02f, 9.19004306e-02f, 6.51709661e-02f, 3.90673876e-02f, 4.34781015e-02f, -2.82528438e-02f, -8.25859830e-02f, -4.55580354e-02f, -3.46598774e-03f,
  8.51476565e-02f, -1.22437410e-01f, -1.97934695e-02f, -8.24404582e-02f, -9.31968167e-02f, -7.49759525e-02f, -4.05052267e-02f, -2.27265675e-02f, 1.11457221e-01f, 1.78651616e-01f,
  4.24108356e-02f, 6.84152767e-02f, -8.11301544e-02f, 1.23296417e-01f, -1.24871675e-02f, 1.87401026e-02f, -1.23250708e-01f, 4.02421877e-02f, -1.27066985e-01f, -6.04224578e-02f,
  -1.07145660e-01f, 1.21626079e-01f, -2.18678683e-01f, -9.76893492e-03f, -6.20904192e-02f, 4.63817082e-02f, -7.35684484e-03f, 8.94283801e-02f, -1.28157407e-01f, 1.64787993e-02f,
  1.09065473e-01f, -8.28244984e-02f, -6.78497404e-02f, 4.11340706e-02f, 1.54663756e-01f, 8.62681046e-02f, -2.65504792e-03f, -5.99528365e-02f, 3.29890251e-02f, 1.65594071e-01f,
  -4.34749052e-02f, -2.16697380e-02f, 6.12516180e-02f, 8.28491151e-02f, -4.94272783e-02f, -1.36088908e-01f, -7.10532442e-02f, -4.56160837e-04f, -2.53452566e-02f, -7.13056652e-03f,
  -5.70704974e-02f, 2.53031969e-01f, 1.04618408e-01f, 1.72121584e-01f, 2.81555504e-01f, 2.85880685e-01f, 5.29581428e-01f, 2.33209640e-01f, -1.79703340e-01f, 1.23728225e-02f,
  1.11300841e-01f, -3.69785689e-02f, -5.14525920e-02f, -1.09496862e-01f, 2.48785928e-01f, 1.39341295e-01f, 1.69296533e-01f, -1.38207734e-01f, -1.56668037e-01f, -1.26464531e-01f,
  -1.47221714e-01f, -1.86335240e-02f, -1.37580797e-01f, -1.27223179e-01f, 1.42898247e-01f, -2.01152071e-01f, 3.70530505e-03f, 2.30812460e-01f, 2.72726752e-02f, 5.88732660e-02f,
  1.57590374e-01f, 4.03515160e-01f, -1.47795022e-01f, -1.13637090e-01f, -9.69832018e-02f, -2.71626383e-01f, -9.26990360e-02f, -1.29151225e-01f, -1.31133720e-01f, -1.75661057e-01f,
  9.77362320e-03f, -2.50740275e-02f, 1.44570097e-01f, 8.93575400e-02f, 1.62728012e-01f, 5.33478335e-02f, -1.59617444e-03f, 1.33444861e-01f, 1.30186841e-01f, 3.67800221e-02f,
  -6.39674738e-02f, 2.79663987e-02f, 1.80650011e-01f, 1.51929528e-01f, 1.52013466e-01f, -2.22588569e-01f, 6.91762641e-02f, 1.59625784e-01f, -7.65490383e-02f, -5.89033663e-02f,
  -2.41859511e-01f, -7.99978301e-02f, 4.09185067e-02f, -8.25477988e-02f, 3.01723797e-02f, -9.29443911e-02f, 1.47744268e-03f, 6.17300309e-02f, -1.13572674e-02f, 2.11671623e-03f,
  -8.45425278e-02f, 7.96635225e-02f, 7.73974583e-02f, 4.96020392e-02f, -1.01125374e-01f, 7.64973462e-02f, 1.50161058e-01f, 4.95560281e-02f, 2.96543948e-02f, -5.15063666e-02f,
  3.97463329e-02f, 5.22123044e-03f, -7.59180933e-02f, 6.51780069e-02f, -1.17956154e-01f, 7.42004672e-03f, -5.52222319e-02f, 1.01851951e-03f, -1.67332143e-02f, -3.89734246e-02f,
  -9.84100997e-02f, 5.16271926e-02f, -2.21223205e-01f, -1.54027909e-01f, 5.31909317e-02f, -1.36899561e-01f, 5.39336260e-03f, 8.10538977e-02f, 7.66407400e-02f, -7.76302516e-02f,
  -1.62637290e-02f, -7.44595677e-02f, 5.60211502e-02f, 1.45973966e-01f, -1.75746307e-01f, -1.88175142e-01f, 6.24640398e-02f, -6.76200539e-02f, -4.94072661e-02f, 2.59632580e-02f,
  7.00963587e-02f, -4.49359305e-02f, -6.14703223e-02f, 8.71892944e-02f, -8.98708925e-02f, -2.77286828e-01f, -1.23427674e-01f, -1.20907836e-02f, -1.46945596e-01f, -4.15346801e-01f,
  -4.95730132e-01f, -1.50942087e-01f, 4.14819866e-01f, 8.27235952e-02f, 1.19194157e-01f, -2.48010188e-01f, -4.49898571e-01f, -4.22766298e-01f, 5.38100265e-02f, -1.96921676e-01f,
  -3.02882469e-03f, -5.82875907e-02f, 1.46659657e-01f, 1.40901759e-01f, -5.58780611e-01f, -1.67280450e-01f, 9.02108252e-02f, 1.40374735e-01f, -1.54798985e-01f, -4.10045683e-01f,
  -1.93584278e-01f, -8.35307091e-02f, -4.27280627e-02f, -1.64185673e-01f, -5.74914962e-02f, 1.76385909e-01f, 3.21499527e-01f, 2.43698746e-01f, 2.18249395e-01f, 3.79522026e-01f,
  1.09164432e-01f, -2.17935428e-01f, 1.78889092e-02f, -5.57461269e-02f, 1.69932023e-01f, 8.82977899e-03f, -1.08305678e-01f, 1.07994817e-01f, 1.52171366e-02f, 4.92286980e-02f,
  8.90272856e-02f, -2.16846794e-01f, -5.16962148e-02f, 8.86685923e-02f, -1.10435449e-01f, -1.56271800e-01f, 2.36211158e-02f, 7.64684193e-03f, -2.08269842e-02f, -2.35612124e-01f,
  -1.24179907e-02f, -4.89420071e-02f, -1.24911740e-01f, -5.06770760e-02f, 1.13019282e-02f, 2.17111573e-01f, 5.66670299e-02f, -9.40051228e-02f, 3.82924937e-02f, 3.75849865e-02f,
  -4.08605598e-02f, -4.24300954e-02f, -4.04801294e-02f, -2.78076585e-02f, 5.49911819e-02f, 4.37106229e-02f, 4.87777330e-02f, 3.21101327e-03f, 6.12917803e-02f, 5.88826947e-02f,
  5.14862090e-02f, 6.44859448e-02f, -9.75313634e-02f, -2.32707765e-02f, 7.53248297e-03f, -1.21747493e-03f, 4.15714681e-02f, -8.04060772e-02f, -7.00016916e-02f, 8.87831002e-02f,
  -6.42114431e-02f, -2.27369443e-02f, 5.53659648e-02f, -7.14460537e-02f, 2.26395279e-02f, -5.34795448e-02f, 1.77155272e-03f, -6.31488562e-02f, -1.42771909e-02f, 1.74760614e-02f,
  4.36457805e-02f, 1.52825609e-01f, -1.61604248e-02f, -9.84894410e-02f, 4.50179912e-02f, 1.80030931e-02f, 7.88516924e-02f, 2.27727629e-02f, 1.44198701e-01f, -6.52574599e-02f,
  -1.40329584e-01f, -5.41976281e-02f, 4.33381237e-02f, 5.89499399e-02f, -8.12982619e-02f, 2.21254071e-03f, -3.82376947e-02f, -3.71251628e-02f, -1.00358829e-01f, 5.72222844e-03f,
  -2.20004171e-01f, -2.22006276e-01f, -1.46414638e-01f, -5.23119457e-02f, -2.01394349e-01f, -7.30716810e-02f, 9.13777873e-02f, -5.59352003e-02f, -2.05475181e-01f, -1.66180730e-01f,
  6.56341851e-01f, 4.83747907e-02f, 2.95789361e-01f, -4.19329526e-03f, 1.76953971e-01f, 2.74785906e-01f, 2.95580536e-01f, -1.35377729e-02f, -7.70484284e-02f, 9.50908661e-02f,
  1.69664919e-02f, -1.06055044e-01f, -5.13199903e-02f, -1.29123345e-01f, 3.42083238e-02f, -9.24803689e-02f, -3.98431532e-03f, 7.58595765e-02f, 1.30175933e-01f, 1.81237403e-02f,
  -2.05673054e-01f, -3.74649353e-02f, 2.56248564e-02f, -3.90555896e-02f, -2.30057850e-01f, -1.53950661e-01f, -1.05436966e-01f, 2.04164479e-02f, -5.11903837e-02f, -2.53352702e-01f,
  3.01741600e-01f, 4.14062142e-01f, -2.00793874e-02f, 9.25743580e-02f, -2.44469494e-02f, -5.31601459e-02f, 1.20603018e-01f, -4.79290262e-02f, 3.22945900e-02f, 3.96470129e-02f,
  3.74521203e-02f, 5.58569953e-02f, 5.14857173e-02f, -1.30794626e-02f, 4.02987227e-02f, -1.34699792e-01f, -2.12862864e-02f, -6.46767614e-04f, 2.35108323e-02f, -2.32176166e-02f,
  -9.39610153e-02f, 1.58292055e-01f, 3.09683621e-01f, 7.16830567e-02f, 1.17578015e-01f, 9.12922099e-02f, 5.88255115e-02f, 1.95935369e-01f, 4.09008861e-02f, 9.30068120e-02f,
  -1.65889770e-01f, 1.91384293e-02f, 8.74023959e-02f, 7.83080608e-02f, -5.19194128e-03f, 1.86091810e-01f, 2.66392231e-02f, -5.62882200e-02f, -5.58104850e-02f, -1.04270965e-01f,
  -1.08619191e-01f, 1.30728319e-01f, 2.21153125e-01f, -3.19790915e-02f, -4.38346453e-02f, 1.40035003e-01f, 3.41686457e-02f, -7.87786916e-02f, -6.88079000e-02f, 9.69985034e-03f,
  -5.54972701e-03f, -1.17527060e-02f, -6.76543936e-02f, -1.73053965e-01f, -4.18968014e-02f, -2.07443237e-02f, -5.71491159e-02f, -1.48304135e-01f, -8.90156254e-02f, -8.77415761e-02f,
  -3.14829536e-02f, 3.10412109e-01f, -4.84986678e-02f, -1.81773454e-01f, -1.27708301e-01f, -1.32013083e-01f, -5.25668487e-02f, -2.56325770e-02f, -1.40005071e-02f, 4.85926569e-02f,
  -4.98455018e-02f, 3.08281574e-02f, -7.33079165e-02f, -1.83242962e-01f, -7.97905475e-02f, -1.52004227e-01f, -1.82120223e-02f, 9.93279442e-02f, 3.79681475e-02f, -8.50341469e-02f,
  -1.51362330e-01f, -2.00035721e-02f, 2.54727229e-02f, 1.07512228e-01f, -1.10130116e-01f, 1.07740067e-01f, 6.18397668e-02f, 1.06756948e-02f, 1.09263621e-01f, -1.74971327e-01f,
  7.63489962e-01f, -9.47324634e-02f, 1.32218093e-01f, 1.11963108e-01f, -1.41423017e-01f, -1.81807071e-01f, -2.62197286e-01f, -7.01378584e-02f, -3.26380953e-02f, 4.00525928e-02f,
  1.02566294e-01f, 1.18160874e-01f, 2.36596882e-01f, 2.51701117e-01f, 1.38097197e-01f, 2.13442724e-02f, 1.49476379e-01f, 3.97072107e-01f, 2.94162542e-01f, 6.36381730e-02f,
  4.77549769e-02f, 7.94487074e-02f, 2.28264555e-01f, 1.47192806e-01f, 3.66566842e-03f, 9.50794592e-02f, 2.62182821e-02f, 1.17306359e-01f, 1.74747389e-02f, 2.06637770e-01f,
  3.24450582e-02f, 3.32977921e-01f, 1.48024544e-01f, -1.51857426e-02f, 1.06557973e-01f, -3.05743515e-02f, -3.69931408e-03f, 1.39593678e-02f, -1.53718084e-01f, -2.21710339e-01f,
  -1.36371821e-01f, 6.02693334e-02f, -5.29728867e-02f, -3.71026173e-02f, -4.52388711e-02f, -5.81084378e-02f, 2.41503268e-02f, 1.56427279e-01f, 6.31229207e-02f, -1.00540832e-01f,
  -8.18474740e-02f, -1.36431847e-02f, -6.52035773e-02f, -1.80495813e-01f, 4.68433574e-02f, 1.54306367e-01f, 7.42080808e-02f, 9.58264694e-02f, 3.04305293e-02f, -8.27845335e-02f,
  1.70401022e-01f, 1.96634591e-01f, 1.53357178e-01f, 1.34643033e-01f, 1.47259161e-01f, -2.33092327e-02f, 8.77028853e-02f, 5.73781133e-02f, 7.18793720e-02f, 3.24127376e-02f,
  6.60651252e-02f, -1.40275573e-02f, -1.15441568e-01f, 4.37025838e-02f, -6.69090375e-02f, 1.78791117e-02f, -4.75156792e-02f, -5.56055419e-02f, 3.07358596e-02f, 1.93660725e-02f,
  1.08710099e-02f, -3.59543301e-02f, 3.44778746e-02f, 7.34902620e-02f, -2.17530020e-02f, 8.92136097e-02f, -3.39055695e-02f, -1.74882971e-02f, 6.96167052e-02f, -2.40031704e-02f,
  -6.44628882e-01f, 2.10149959e-01f, 6.88980520e-02f, 2.04522721e-02f, 7.42052495e-02f, -6.52527586e-02f, 9.68432650e-02f, 6.94758222e-02f, -1.55819938e-01f, -5.55480905e-02f,
  -1.47708997e-01f, 5.14715873e-02f, -9.27431807e-02f, -8.28703344e-02f, -5.59279695e-02f, 1.60658434e-02f, 7.59972483e-02f, 1.05815858e-01f, 7.39500001e-02f, -1.06531017e-01f,
  4.87675630e-02f, -1.17927484e-01f, -2.46758610e-01f, -1.34908259e-01f, -1.02842329e-02f, -7.11675137e-02f, -2.31642127e-02f, -1.05958678e-01f, -9.56052765e-02f, -2.58075327e-01f,
  -5.05343616e-01f, -2.34051824e-01f, 9.80681106e-02f, -2.05334470e-01f, -8.94755200e-02f, 8.90913308e-02f, -4.25419249e-02f, 1.32619575e-01f, 8.34231004e-02f, -1.64151341e-01f,
  -6.97319135e-02f, -1.03352331e-01f, -1.91209376e-01f, -4.53631431e-02f, -9.28010494e-02f, -2.26201952e-01f, -3.14006984e-01f, -9.91133600e-02f, 2.17275009e-01f, 1.09240793e-01f,
  9.30197686e-02f, -8.50497410e-02f, -4.99875732e-02f, 3.67405340e-02f, -3.60229969e-01f, -1.51573077e-01f, -2.59424657e-01f, -1.45182207e-01f, -1.47106245e-01f, -6.35944307e-01f,
  -2.36923113e-01f, 1.75288916e-01f, 1.97502151e-01f, -2.03273550e-01f, -7.83827007e-02f, -8.72747507e-03f, -5.72603010e-02f, -3.11776008e-02f, 7.24696964e-02f, -6.18225411e-02f,
  -8.07545036e-02f, 1.81529030e-01f, -1.14342786e-01f, 9.74611044e-02f, 1.05580091e-01f, -1.30474180e-01f, 4.25185123e-03f, 4.41700034e-02f, 4.23510857e-02f, 1.24415934e-01f,
  -1.56101882e-01f, -1.68777525e-01f, -2.26425782e-01f, -1.37084842e-01f, 1.46295980e-01f, -2.77433358e-02f, -5.32359816e-02f, -3.22601721e-02f, -8.45779851e-02f, -4.49169546e-01f,
  4.91223000e-02f, 4.27921154e-02f, 4.90636900e-02f, 4.04374348e-03f, -4.61210124e-02f, -6.29938766e-02f, -7.97040667e-03f, -1.03289545e-01f, -2.04436369e-02f, 3.48018780e-02f,
  1.27726495e-01f, 6.48017675e-02f, 1.40383071e-03f, -3.09759490e-02f, -1.21609993e-01f, -1.20279389e-02f, -2.73661241e-02f, 1.64931025e-02f, -7.01186061e-02f, 4.04361775e-03f,
  -9.63175856e-03f, 5.79447811e-03f, 1.00804210e-01f, 1.17230512e-01f, 2.02518259e-03f, 7.93617815e-02f, 6.90177903e-02f, 1.36785179e-01f, -3.97305191e-02f, 8.68478790e-02f,
  -2.55786389e-01f, 1.63345695e-01f, -1.67992786e-01f, 5.00105247e-02f, 7.90342987e-02f, -5.62172346e-02f, -6.31916076e-02f, 1.33161489e-02f, 3.30567881e-02f, -6.79611564e-02f,
  -8.95592496e-02f, -7.79012591e-02f, -1.62872672e-01f, -1.01393417e-01f, -3.40442061e-02f, -1.27893770e-02f, -1.27030626e-01f, -9.42387208e-02f, 8.85320231e-02f, 1.83237329e-01f,
  -1.33609846e-01f, -1.85024604e-01f, -2.04320461e-01f, -1.26601949e-01f, 1.06340172e-02f, -1.88488618e-01f, -1.21922165e-01f, -1.39468029e-01f, -2.24494725e-01f, -3.14416915e-01f,
  3.60284626e-01f, -1.01310208e-01f, 1.60118341e-01f, 7.02672452e-02f, -5.29183865e-01f, -6.50602460e-01f, -6.87827647e-01f, -3.27985495e-01f, 9.04696435e-02f, -1.77507117e-01f,
  -2.87409097e-01f, -8.38543475e-02f, -7.73587730e-03f, -2.04045754e-02f, -1.10437699e-01f, 2.71354839e-02f, 1.88021094e-01f, 2.46482894e-01f, -1.62250791e-02f, -2.53852248e-01f,
  -1.37516618e-01f, 6.42531142e-02f, 2.30665743e-01f, 2.02795580e-01f, 2.84668595e-01f, -2.35131495e-02f, 1.48670197e-01f, 1.46351740e-01f, -1.67009588e-02f, 3.79995793e-01f,
  1.39252737e-01f, 7.90988505e-02f, -1.88144907e-01f, 3.48061733e-02f, -4.60541137e-02f, 7.93698952e-02f, -1.00717090e-01f, 2.63733476e-01f, -1.19888365e-01f, 1.81342155e-01f,
  -9.83544141e-02f, -1.55774355e-01f, -1.08539753e-01f, -1.20962616e-02f, -2.62063801e-01f, -7.20859692e-02f, 2.43500978e-01f, 2.27742374e-01f, 1.33958504e-01f, 5.34592532e-02f,
  -1.16269641e-01f, -1.61631957e-01f, -2.57533461e-01f, -2.08391413e-01f, 1.38641953e-01f, 1.03921570e-01f, -4.15659398e-02f, 1.06453754e-01f, -1.35108322e-01f, 1.00319825e-01f,
  -3.49350311e-02f, 7.25110471e-02f, -1.18706651e-01f, -6.76540285e-03f, -9.13509727e-02f, 5.01391403e-02f, 1.05775855e-01f, -9.34170634e-02f, -9.74328890e-02f, -2.18963921e-02f,
  -1.12066746e-01f, -3.90455090e-02f, 3.28150243e-02f, 1.19797148e-01f, -4.62172516e-02f, -1.19169407e-01f, -2.15017851e-02f, -1.47965457e-02f, -6.01678938e-02f, -2.85451412e-02f,
  -6.33544773e-02f, -1.42931387e-01f, -1.61408409e-02f, 2.76679243e-03f, 9.99540910e-02f, 4.32683751e-02f, 9.99824330e-03f, -1.31747618e-01f, 1.56485915e-01f, 4.71545644e-02f,
  -1.79024726e-01f, -2.57242411e-01f, 7.77260363e-02f, 4.90217321e-02f, 2.47964412e-02f, 8.55355337e-02f, -6.79312423e-02f, -3.30114923e-02f, -9.16743279e-03f, -1.06379621e-01f,
  -9.77821574e-02f, -7.83525482e-02f, -4.07409929e-02f, -4.70263325e-02f, -6.73523098e-02f, -1.14370465e-01f, -1.68852299e-01f, -2.87813604e-01f, -2.18728617e-01f, -2.79381741e-02f,
  1.00083398e-02f, -2.83011407e-01f, -2.12345332e-01f, -3.08068871e-01f, -4.76642363e-02f, -2.39799187e-01f, -3.35546881e-01f, -1.78582996e-01f, -4.73061860e-01f, -3.75350565e-01f,
  -9.05390918e-01f, -1.24066554e-01f, -2.97320783e-01f, -3.63468379e-01f, 3.24298263e-01f, 3.76317352e-01f, 2.73051649e-01f, 6.80713505e-02f, -1.48849666e-01f, 2.51610111e-02f,
  1.53238531e-02f, -5.48131354e-02f, 4.52494174e-02f, 1.78683177e-01f, 9.41689759e-02f, 1.80767670e-01f, 3.26189071e-01f, 1.00145303e-01f, -3.42047140e-02f, -1.99384876e-02f,
  2.42802888e-01f, -1.62689477e-01f, -3.95133018e-01f, -2.01476198e-02f, 3.04903043e-03f, -3.07932012e-02f, 4.31465320e-02f, -2.29409225e-02f, 1.43760249e-01f, 1.89812571e-01f,
  -4.53603715e-01f, -4.30094093e-01f, 1.32659629e-01f, 4.49479669e-02f, -1.78663418e-01f, -1.57921657e-01f, -1.62083834e-01f, -1.10060319e-01f, -7.98923671e-02f, -7.91728944e-02f,
  -5.60288839e-02f, -9.98900905e-02f, 1.10625671e-02f, -5.09055071e-02f, -1.07766204e-01f, -1.65319685e-02f, -6.38945475e-02f, -8.88135359e-02f, -1.40331343e-01f, -1.11482896e-01f,
  4.68989491e-01f, 1.59477040e-01f, -1.50285289e-01f, 2.05717057e-01f, 7.78248608e-02f, 9.45862159e-02f, -7.36319879e-03f, -1.05425537e-01f, 3.18973437e-02f, -2.45131075e-01f,
  1.87694281e-01f, -1.78025030e-02f, -6.58695847e-02f, -7.64293447e-02f, 3.14061530e-02f, -1.53780002e-02f, 6.19648397e-02f, 1.29957601e-01f, 1.92573816e-02f, -1.09987706e-01f,
  -4.83125262e-02f, 6.52612769e-04f, 9.67308804e-02f, -1.63686741e-02f, 5.86755425e-02f, -4.65895124e-02f, 1.48237571e-01f, 5.18523296e-03f, 4.15470302e-02f, -7.43110627e-02f,
  -7.73316771e-02f, -6.33431301e-02f, -6.45577759e-02f, 8.42275843e-02f, 8.21614414e-02f, 2.98120715e-02f, 3.37056443e-02f, -2.68750042e-02f, -3.83126996e-02f, 4.13948037e-02f,
  -4.17479753e-01f, 1.35520384e-01f, -2.41858467e-01f, -3.80248167e-02f, -8.74979198e-02f, -2.02700011e-02f, -6.83283955e-02f, -4.45391200e-02f, -2.67878789e-02f, -5.59408590e-02f,
  -7.89576992e-02f, -1.88227892e-01f, -3.83695252e-02f, 6.90488592e-02f, 2.94080488e-02f, -1.81160904e-02f, 9.19333771e-02f, 2.62539871e-02f, 2.25969136e-01f, -6.78517818e-02f,
  1.19687319e-01f, 4.24942821e-02f, -1.48248911e-01f, 1.16157733e-01f, 9.40696821e-02f, -5.62036119e-04f, -3.62928137e-02f, -3.33908759e-03f, -5.44621237e-02f, -3.31846535e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  3.25037628e-01f, -8.55117962e-02f, 3.87789309e-01f, 2.71434188e-01f, 5.93257658e-02f, 2.59693712e-01f, 3.97968620e-01f, 2.89877236e-01f, 8.36795196e-02f, 1.64005131e-01f,
  9.25333798e-02f, 1.96443096e-01f, -9.31681842e-02f, 6.56267107e-02f, 2.01488197e-01f, 5.10756969e-02f, 5.01667500e-01f, 6.98259920e-02f, 2.03568950e-01f, 2.38424271e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -7.02200318e-03f, 6.85308278e-02f, -5.83326407e-02f, -6.63570091e-02f, -1.06134050e-01f, 3.10991681e-03f, -1.86826717e-02f, -6.03321083e-02f, -2.23397896e-01f, 1.92018449e-02f,
  -1.72770068e-01f, 1.08655006e-01f, -1.43558234e-01f, 9.10414904e-02f, 1.29112033e-02f, 6.78825900e-02f, 1.99115634e-01f, 7.56440908e-02f, -5.89174815e-02f, 5.25281616e-02f,
  -2.94212013e-01f, 1.35708258e-01f, -3.76050174e-01f, -8.62679705e-02f, -1.02162912e-01f, -2.49406528e-02f, -1.98264614e-01f, 2.02576637e-01f, 2.55855583e-02f, -1.05076551e-01f,
  1.93607450e-01f, -5.18052101e-01f, -2.84239314e-02f, 1.29667357e-01f, 2.71851346e-02f, 7.08973184e-02f, -6.90791756e-03f, 7.29052490e-03f, -6.90747723e-02f, 1.92846939e-01f,
  -1.33865565e-01f, -2.82764584e-02f, 5.21830190e-03f, -2.73112999e-03f, 4.05468382e-02f, -1.20788567e-01f, 2.08419472e-01f, -4.50800717e-01f, -3.43037069e-01f, -8.14706981e-02f,
  3.90418291e-01f, -1.24544404e-01f, 8.12412649e-02f, -2.32258767e-01f, -8.38520527e-02f, 1.61196202e-01f, 1.22015111e-01f, -1.95781097e-01f, 8.66644830e-02f, 1.43693179e-01f,
  8.68346468e-02f, 2.39649385e-01f, -1.17058814e-01f, 2.33494535e-01f, 1.81118980e-01f, 5.32074347e-02f, -1.47238914e-02f, 7.41849244e-02f, 1.23866811e-01f, 4.13900055e-02f,
  -5.98253123e-02f, -1.38866022e-01f, -1.42815635e-01f, -6.26363838e-03f, -8.26076865e-02f, 7.20706657e-02f, -2.52602726e-01f, -2.00563282e-01f, -1.77351385e-02f, -1.80258140e-01f,
  2.01181948e-01f, 3.22338194e-02f, 1.55312777e-01f, 1.18330754e-01f, 1.04650401e-01f, 1.19618192e-01f, -3.49949673e-02f, -2.17576221e-01f, -2.76003569e-01f, 2.43746221e-01f,
  3.92680950e-02f, 9.78007913e-02f, 2.72930533e-01f, -4.44725044e-02f, 1.80927575e-01f, -5.02002239e-01f, -1.17178209e-01f, 2.14924235e-02f, -1.26038805e-01f, -1.66711614e-01f,
  -4.90656076e-03f, -1.66083530e-01f, 9.71229933e-03f, -4.85850573e-02f, 1.54719636e-01f, 1.47019178e-01f, 2.16705173e-01f, 2.09715050e-02f, 8.45133737e-02f, -1.35130689e-01f,
  1.16847955e-01f, -2.53823221e-01f, -1.36991039e-01f, -2.90322959e-01f, 2.31523591e-04f, 8.37277621e-03f, 1.31720990e-01f, -3.43886316e-02f, 1.93147764e-01f, -1.24161020e-01f,
  1.64445639e-01f, -1.00264855e-01f, -5.61078731e-03f, -2.23526478e-01f, 1.15557171e-01f, 3.16963613e-01f, -2.36670092e-01f, 5.60634077e-01f, 2.12408945e-01f, 9.35608298e-02f,
  1.95620656e-02f, 5.68325669e-02f, 1.42423421e-01f, 1.22765794e-01f, 1.34125710e-01f, -1.11805871e-02f, 2.61848550e-02f, 1.53780878e-02f, -1.43035188e-01f, 7.00908676e-02f,
  4.00046140e-01f, 1.06582493e-01f, -2.76109338e-01f, -1.24184035e-01f, 2.03298107e-01f, -2.43693367e-01f, 3.65148671e-02f, -8.50143284e-02f, -1.89159438e-01f, 2.66068906e-01f,
  -1.75608993e-01f, 2.48598903e-01f, -1.08312763e-01f, 1.70893982e-01f, 3.66180032e-01f, 1.67294294e-01f, 1.57343388e-01f, -8.57911929e-02f, 2.51844406e-01f, 3.45446058e-02f,
  -1.23807095e-01f, 7.21582398e-02f, -1.12102076e-01f, 6.62929416e-02f, -6.99804276e-02f, -5.65216653e-02f, 6.48421422e-02f, -1.06778257e-01f, -2.99773932e-01f, -5.68826310e-03f,
  -1.71791077e-01f, 2.24728361e-02f, -1.81720525e-01f, -1.24998234e-01f, -2.49565337e-02f, 3.83401141e-02f, -1.83179453e-01f, -3.53833169e-01f, 1.44310042e-01f, 2.74692252e-02f,
  -2.24197790e-01f, 2.98976332e-01f, 1.62843347e-01f, 5.10213256e-01f, 5.93322841e-03f, -1.28850713e-01f, 1.90362558e-01f, -2.34025002e-01f, 8.96146372e-02f, 1.94398731e-01f,
  4.40613061e-01f, -1.26465540e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  4.55680966e-01f, 1.75186619e-01f, 2.77561009e-01f, 1.66140959e-01f, 1.71213865e-01f, 2.54039943e-01f, -1.88652396e-01f, -4.13055032e-01f, 3.56802046e-01f, 2.44718760e-01f,
  3.01187396e-01f, -2.12669402e-01f, -1.45599321e-01f, -1.09180272e-01f, 5.88518903e-02f, 4.64404523e-02f, 1.66223943e-01f, -1.44548833e-01f, 4.92683142e-01f, 2.19355389e-01f,
  1.75586194e-01f, -7.36657232e-02f, -5.39919555e-01f, -8.09572190e-02f, -1.99444517e-01f, 1.85793072e-01f, 9.51428246e-03f, -8.34858641e-02f, 2.03230128e-01f, -1.90694958e-01f,
  -4.66139138e-01f, -5.39975986e-02f, -4.71862331e-02f, 1.79994509e-01f, 2.22367406e-01f, 1.18033350e-01f, 1.44509912e-01f, 1.58600822e-01f, -1.89341515e-01f, 1.88489988e-01f,
  -5.82198977e-01f, 7.21852630e-02f, 2.25302223e-02f, 4.81866360e-01f, 9.29491073e-02f, -4.12315547e-01f, 3.33443254e-01f, 2.61503160e-01f, -1.55533105e-01f, -2.95906901e-01f,
  4.56571460e-01f, -2.00368799e-02f, -4.28075612e-01f, -2.04363063e-01f, -6.22495497e-03f, 4.70679373e-01f, 1.26126736e-01f, -1.07877143e-01f, 1.67455509e-01f, -3.01434964e-01f,
  -4.30934459e-01f, 1.63517281e-01f, -1.04437463e-01f, -6.22547455e-02f, 3.15492362e-01f, -5.94525971e-02f, -3.34533602e-02f, -2.55765729e-02f, 9.96804163e-02f, 3.07517331e-02f,
  -1.50273830e-01f, 2.27504611e-01f, 1.49560615e-01f, -1.06698424e-01f, -5.25601059e-02f, 1.00369364e-01f, 1.09032318e-01f, -1.80155426e-01f, -5.15497565e-01f, -3.09001226e-02f,
  9.37625542e-02f, -1.04971416e-01f, -1.08557709e-01f, -2.35880800e-02f, -2.56694257e-02f, 9.39671546e-02f, 2.10971072e-01f, 6.15039989e-02f, 2.64606506e-01f, -9.36691687e-02f,
  3.52131635e-01f, -3.41433078e-01f, -1.29453346e-01f, 2.21159339e-01f, 1.28838524e-01f, -2.15732172e-01f, -4.28326204e-02f, 3.82040828e-01f, 2.17666738e-02f, 4.89063747e-02f,
  3.09227288e-01f, -8.34497213e-02f, 8.57065022e-02f, 1.33686438e-01f, -2.18553945e-01f, 2.45051615e-05f, -8.70331600e-02f, -1.54349923e-01f, -5.30166686e-01f, -4.31835353e-02f,
  1.95748195e-01f, -1.71171650e-02f, -1.60603821e-01f, 3.60864460e-01f, 3.47335249e-01f, 1.19210228e-01f, -7.67607167e-02f, 1.34109408e-01f, -4.39392179e-01f, -2.81179380e-02f,
  -1.12140467e-02f, -3.57804410e-02f, 2.23586500e-01f, -1.62820774e-03f, 4.32816923e-01f, -7.75898397e-02f, 2.19536662e-01f, -5.03661036e-01f, 9.45946574e-02f, 2.17274114e-01f,
  2.01791108e-01f, 9.00945663e-02f, 1.27030775e-01f, 1.55998886e-01f, -1.18465133e-01f, 4.58978027e-01f, -1.03096671e-01f, -3.47582102e-01f, 2.22578853e-01f, 5.52898347e-02f,
  1.63007513e-01f, -1.14376366e-01f, -2.23216325e-01f, 4.72536176e-01f, 1.19304173e-01f, 6.08688176e-01f, -4.97258976e-02f, 3.75134617e-01f, -4.41098958e-02f, -3.51950824e-01f,
  1.44056249e-02f, -3.17662597e-01f, 2.86241800e-01f, -2.48318061e-01f, -2.02476770e-01f, -1.67892799e-01f, -2.60751635e-01f, 8.86814967e-02f, -4.70291115e-02f, 4.93781455e-02f,
  1.32436067e-01f, -1.49795581e-02f, 8.92528072e-02f, -7.84750506e-02f, 1.95070021e-02f, -3.47688496e-02f, -5.09188287e-02f, -2.22241804e-01f, 3.52135658e-01f, 2.51371562e-01f,
  -7.22821578e-02f, -2.06462875e-01f, -5.41436858e-02f, 5.31772664e-03f, 2.95534521e-01f, -4.04009998e-01f, -1.81631252e-01f, 6.38566539e-02f, 3.66481125e-01f, 3.75179142e-01f,
  4.36150521e-01f, 2.01319829e-01f, -9.30821225e-02f, -1.05499746e-02f, -2.66694874e-01f, 1.59738988e-01f, 3.27903062e-01f, 8.19801614e-02f, 3.24612468e-01f, -1.51602939e-01f,
  3.80901322e-02f, 2.78018296e-01f, -3.76303345e-01f, 1.01879314e-01f, 1.16963960e-01f, 1.22529417e-01f, -1.92824364e-01f, -1.29856810e-01f, 3.40956002e-01f, -2.77918130e-01f,
  -1.33240312e-01f, -7.14167207e-02f, -3.92466575e-01f, -1.12506911e-01f, -2.45553717e-01f, -1.28798202e-01f, -2.15400472e-01f, -2.08064720e-01f, -3.98348153e-01f, 8.96373540e-02f,
  -4.15292948e-01f, -1.13548324e-01f, 1.10535607e-01f, 1.98483482e-01f, 1.71183050e-01f, 3.88721585e-01f, 4.09752764e-02f, -4.68321629e-02f, 9.46087092e-02f, -1.97201878e-01f,
  3.77780825e-01f, -5.27445197e-01f, 4.12441164e-01f, -3.20594162e-01f, 5.12145400e-01f, 1.04606329e-02f, 1.62931710e-01f, 2.82871574e-01f, 1.31703258e-01f, 2.51105368e-01f,
  -1.36843264e-01f, -3.00110519e-01f, 3.94638598e-01f, 2.49404371e-01f, 1.53494596e-01f, 2.44689193e-02f, -6.90027550e-02f, -2.33473003e-01f, 1.25200480e-01f, 1.07377293e-02f,
  5.47526330e-02f, 2.69527256e-01f, 2.21321404e-01f, 1.96204871e-01f, 4.96043473e-01f, -6.05183607e-03f, 3.21872830e-01f, -5.67234337e-01f, 2.58351280e-03f, 1.30028635e-01f,
  1.13672890e-01f, 1.33043956e-02f, 1.94343477e-01f, 1.99692935e-01f, 7.73214698e-02f, 3.11007828e-01f, 1.83304906e-01f, 1.12630017e-01f, 3.79847527e-01f, 1.39596254e-01f,
  3.91382575e-02f, 2.37765267e-01f, 4.48366970e-01f, 1.22967161e-01f, -2.65993744e-01f, -1.98330507e-01f, -2.54982859e-01f, 1.97268613e-02f, 3.15966398e-01f, -1.17080882e-01f,
  -1.35968387e-01f, 4.35600132e-02f, 3.25755894e-01f, -4.74793762e-01f, -6.47375405e-01f, -3.12633842e-01f, -4.55437481e-01f, 4.03605133e-01f, 1.62466481e-01f, -8.38386640e-02f,
  -3.58278990e-01f, 3.91407996e-01f, 1.17435932e-01f, 9.62659121e-02f, 5.14526442e-02f, -2.78059125e-01f, 1.85035363e-01f, 2.21184954e-01f, 8.33243430e-02f, 3.46833497e-01f,
  1.18908836e-02f, 1.56842932e-01f, -5.79306260e-02f, 4.02914844e-02f, 2.72960719e-02f, -1.31268818e-02f, 7.83177540e-02f, 1.75371870e-01f, 1.29681289e-01f, 1.28141806e-01f,
  6.68811873e-02f, -3.22008133e-01f, -6.65526390e-02f, -3.84202711e-02f, 1.54604262e-03f, -4.05512452e-01f, 1.49617970e-01f, -2.08063170e-01f, 2.19646379e-01f, -2.12526053e-01f,
  1.13686487e-01f, -2.93504950e-02f, 1.75318301e-01f, -8.34730119e-02f, 1.33607551e-01f, -6.41850308e-02f, -4.11581323e-02f, 2.64090538e-01f, 8.88195261e-02f, 1.86182603e-01f,
  7.01815113e-02f, 1.87036872e-01f, 9.87427682e-02f, 1.18084282e-01f, 1.27010673e-01f, 6.86912462e-02f, 4.72727746e-01f, -2.44412363e-01f, 3.76387388e-01f, 5.34029976e-02f,
  -3.26787740e-01f, -2.33220205e-01f, -5.40182255e-02f, -4.66353521e-02f, -3.01824659e-01f, -3.48184824e-01f, -1.01169035e-01f, -9.08123925e-02f, -1.79222837e-01f, -2.31102541e-01f,
  1.06856316e-01f, 2.96839476e-01f, 2.48639300e-01f, 2.76343942e-01f, 4.49179811e-03f, 2.08593875e-01f, 4.76304859e-01f, -2.29936838e-01f, 3.48602980e-01f, -1.23539507e-01f,
  4.80919063e-01f, -1.40092671e-01f, 9.60273370e-02f, 1.87778734e-02f, 6.19714744e-02f, 1.98694512e-01f, 3.35960090e-01f, 2.51482636e-01f, -8.20941254e-02f, 4.04985137e-02f,
  1.89162001e-01f, 1.88040757e-03f, -1.53253511e-01f, -1.01531737e-01f, 4.88183439e-01f, -8.58706683e-02f, 3.06714445e-01f, -2.50610590e-01f, -1.69304848e-01f, -5.24068512e-02f,
  3.62357825e-01f, 3.20861727e-01f, 3.49324830e-02f, 5.76917455e-02f, 2.89508581e-01f, 3.89027625e-01f, 1.13959596e-01f, -1.50450971e-02f, 5.37712157e-01f, -5.74805029e-03f,
  8.59766081e-02f, 2.67375112e-01f, 3.25465858e-01f, 5.34507215e-01f, -4.14034605e-01f, -3.65607440e-02f, 1.01732716e-01f, 1.13030165e-01f, -1.92067191e-01f, -2.30652496e-01f,
  -7.83794448e-02f, -2.25599721e-01f, 1.30313545e-01f, 1.45596385e-01f, 2.60943681e-01f, 1.08458377e-01f, 4.20104742e-01f, -7.89006054e-02f, 7.45832548e-02f, 1.55642122e-01f,
  1.13356739e-01f, -5.04363537e-01f, 1.78469181e-01f, 2.14261502e-01f, 7.75082931e-02f, 1.08153827e-01f, 2.15717748e-01f, 8.48622173e-02f, 3.22115779e-01f, 1.26196966e-01f,
  8.63143206e-02f, 7.90735185e-02f, -2.51129389e-01f, 4.93798971e-01f, -1.02015346e-01f, 5.61007977e-01f, 2.42782887e-02f, 2.17416108e-01f, 2.11736605e-01f, 1.04786776e-01f,
  -3.89982760e-02f, 1.63878143e-01f, -2.07949933e-02f, 4.43912506e-01f, -1.38136983e-01f, -1.77369311e-01f, -5.47457114e-02f, 1.25597790e-01f, 1.18411742e-01f, -2.08140403e-01f,
  2.98823595e-01f, -1.16234235e-01f, -3.48952055e-01f, 4.35337692e-01f, 7.44394064e-02f, 8.01142231e-02f, 1.11035258e-01f, 1.56019837e-01f, 1.73335001e-01f, -3.59096646e-01f,
  2.26258427e-01f, -1.56831130e-01f, 2.56973296e-01f, -1.07550159e-01f, 2.62919128e-01f, -5.09978272e-03f, 5.06520331e-01f, -3.87331069e-01f, 2.26907596e-01f, -2.68491451e-02f,
  2.66201526e-01f, 2.87097991e-01f, 2.49078408e-01f, 5.90717494e-02f, 1.78668901e-01f, -4.36713010e-01f, -3.17946263e-02f, -7.78743997e-02f, 1.05389252e-01f, -1.24287501e-01f,
  -2.76499718e-01f, -1.85143292e-01f, -6.54263124e-02f, 4.53921407e-01f, 4.98678148e-01f, -1.91750806e-02f, -2.64710307e-01f, 1.16293535e-01f, -1.93552300e-02f, 2.23426238e-01f,
  -2.94278473e-01f, -1.53433964e-01f, 2.17027918e-01f, 1.85709655e-01f, -1.77977368e-01f, 1.62906379e-01f, 3.91585603e-02f, -2.82456726e-01f, 2.10649846e-03f, -3.58030170e-01f,
  4.90268856e-01f, 6.33674115e-02f, 8.38251784e-02f, 1.03024207e-01f, 3.15197520e-02f, 8.45075399e-02f, -3.04912120e-01f, 3.20502520e-01f, 4.53262776e-01f, 1.47809982e-01f,
  2.73608357e-01f, 3.82780544e-02f, -3.92145097e-01f, -3.27275723e-01f, 3.23572248e-01f, -3.40491951e-01f, -1.52584270e-01f, 4.39176351e-01f, 1.51929066e-01f, -3.60888481e-01f,
  3.36796135e-01f, -1.28678337e-01f, 1.87539205e-01f, -1.84765875e-01f, 1.20116711e-01f, -2.46039871e-03f, 4.27595638e-02f, -3.00195932e-01f, 4.70291078e-02f, -1.59687921e-02f,
  7.89933652e-02f, -2.12458625e-01f, 2.74519235e-01f, 1.42955869e-01f, 1.99914515e-01f, -9.54729617e-02f, 2.58650780e-01f, 2.37975851e-01f, 2.07150541e-03f, 1.82582602e-01f,
  -2.12790836e-02f, -4.01217490e-02f, 8.53849351e-02f, -2.10875139e-01f, 4.06533599e-01f, 1.85123950e-01f, 7.01537961e-03f, 4.18708563e-01f, 1.36405006e-01f, -1.54405519e-01f,
  -1.83345348e-01f, 4.10452753e-01f, -4.07627374e-01f, 1.48439109e-01f, -2.29406267e-01f, 7.96775445e-02f, -3.73668969e-01f, 2.42721975e-01f, 3.25246365e-03f, 4.82417643e-02f,
  -7.80249238e-02f, -9.49397013e-02f, -3.03896457e-01f, 4.84922886e-01f, -9.99390259e-02f, 3.72939676e-01f, 2.46796995e-01f, 1.17561139e-01f, 1.91874564e-01f, 2.30594561e-01f,
  2.75520235e-01f, 3.05518895e-01f, -1.47148520e-01f, -3.97570478e-03f, -7.77621940e-02f, 2.41785511e-01f, 3.76111060e-01f, -1.22702785e-01f, -3.10641229e-01f, 3.74815673e-01f,
  1.64745793e-01f, 1.54287934e-01f, -1.74921170e-01f, -2.54055619e-01f, -1.56825818e-02f, 6.68191910e-02f, 1.36934534e-01f, -2.04619750e-01f, -1.01249088e-02f, 4.45824981e-01f,
  8.66134390e-02f, 1.62483051e-01f, 3.07809934e-02f, -2.97190964e-01f, -1.51542306e-01f, 1.94760561e-01f, 3.36537659e-01f, -5.10323532e-02f, -2.45597102e-02f, 2.31258143e-02f,
  8.68684351e-02f, 1.80216692e-02f, -9.93289053e-03f, -3.00237447e-01f, 4.16789442e-01f, 1.53562486e-01f, 5.66917770e-02f, -1.60355225e-01f, -3.58382374e-01f, 1.20819405e-01f,
  2.50232935e-01f, -4.13240075e-01f, -1.55255467e-01f, -3.88827994e-02f, 4.00145799e-01f, 1.65931329e-01f, 4.65610325e-01f, 1.76579282e-02f, 6.77570403e-02f, -9.19887498e-02f,
  3.77342016e-01f, 7.91451782e-02f, -1.21280856e-01f, 2.58155137e-01f, 1.89397097e-01f, 5.77242523e-02f, -8.15666988e-02f, -2.40023106e-01f, -4.70358953e-02f, 6.86695576e-02f,
  3.35683852e-01f, 1.77148581e-01f, -1.63239121e-01f, 1.56049266e-01f, 1.87997922e-01f, -2.67178595e-01f, 1.32364407e-01f, -9.36767906e-02f, 2.77892143e-01f, -1.88153628e-02f,
  -3.68779004e-01f, -2.42470787e-03f, -1.37268692e-01f, 1.99661523e-01f, 1.83473364e-01f, 2.80428678e-01f, -8.68643168e-03f, 2.08785474e-01f, 4.31250066e-01f, 7.82905594e-02f,
  9.96181667e-02f, -5.39423943e-01f, 3.13676476e-01f, -7.62773864e-03f, -3.67093682e-01f, -2.41838954e-02f, 2.65853465e-01f, 8.76051858e-02f, 1.11559436e-01f, -4.17136878e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  -4.89267036e-02f, 1.38702542e-01f, 1.32616386e-01f, 3.59646231e-01f, 1.91990018e-01f, 3.18199508e-02f, 1.74684748e-01f, 1.90488949e-01f, 1.02333240e-01f, 2.71473646e-01f,
  2.75423706e-01f, 1.11135721e-01f, -2.88701952e-01f, 3.82485449e-01f, 8.93632993e-02f, 3.52592111e-01f, -5.22737280e-02f, 3.12534183e-01f, -1.29662184e-02f, -3.14533375e-02f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -6.83950856e-02f, 2.61709332e-01f, 1.49637908e-01f, 2.54421204e-01f, 1.85190607e-02f, -1.55342370e-01f, -3.43263328e-01f, 2.59169251e-01f, 2.68685997e-01f, 1.93677753e-01f,
  -2.26576149e-01f, 4.44668800e-01f, -1.39556140e-01f, -1.22404747e-01f, 1.36677772e-01f, 6.40206486e-02f, -1.39787599e-01f, 5.17192185e-02f, 5.19751757e-02f, 1.26729235e-01f,
  2.30976194e-02f, 2.23051533e-01f, 2.55470052e-02f, -8.02644864e-02f, 1.01819010e-02f, 2.50464976e-01f, -1.29221588e-01f, 2.20621422e-01f, -8.41319710e-02f, -2.56495327e-01f,
  2.67800719e-01f, 1.10202365e-01f, 3.81632358e-01f, 1.90337315e-01f, 2.08680242e-01f, 5.93577698e-02f, -3.43373008e-02f, -1.93615302e-01f, 1.31019935e-01f, -6.75900504e-02f,
  2.25295022e-01f, -1.44271672e-01f, 4.76907164e-01f, 7.32304603e-02f, -9.27668437e-02f, -2.47980401e-01f, -3.18954177e-02f, 9.07159895e-02f, -2.28679657e-01f, 1.09185025e-01f,
  2.56619543e-01f, -1.34607688e-01f, -2.32729375e-01f, -1.47831410e-01f, 2.25680426e-01f, -3.71873192e-02f, -3.42136025e-02f, 2.66153246e-01f, -1.21352740e-01f, 3.09037697e-02f,
  -2.74600416e-01f, -1.91860855e-01f, -1.12701230e-01f, 9.38525721e-02f, -2.51581669e-01f, -3.17530707e-02f, -3.24122161e-01f, -1.98343471e-01f, 1.59168124e-01f, -1.29378259e-01f,
  5.32175243e-01f, -1.91284359e-01f, 1.69442624e-01f, -2.60560036e-01f, -2.45241687e-01f, -4.76659685e-01f, -1.96784884e-02f, -2.36717194e-01f, 1.37988940e-01f, 1.85041383e-01f,
  1.25100642e-01f, -1.97466016e-01f, -5.20216785e-02f, 1.30589500e-01f, 8.93886313e-02f, -1.76829427e-01f, -1.07729673e-01f, -2.46442631e-01f, 1.08084016e-01f, -8.47438723e-02f,
  3.45304817e-01f, 2.81201333e-01f, -1.29048498e-02f, 7.29035288e-02f, 1.72007486e-01f, 4.28993046e-01f, -6.51175007e-02f, -3.15516412e-01f, 3.48654002e-01f, 1.06289051e-02f,
  2.06429631e-01f, -2.69553084e-02f, -8.44434574e-02f, -1.16203189e-01f, 1.53076291e-01f, 1.19419463e-01f, -5.07018983e-01f, -1.51762202e-01f, -2.73418240e-02f, -2.42507562e-01f,
  -4.60232347e-02f, -1.59407735e-01f, 2.59389788e-01f, -8.09714198e-02f, -1.40061870e-01f, 2.15246484e-01f, -1.24138586e-01f, 8.62340704e-02f, -2.72730201e-01f, -1.92945272e-01f,
  -6.01804480e-02f, 1.59496948e-01f, -7.04306439e-02f, -7.09298626e-02f, 4.35447618e-02f, -1.26933679e-01f, 1.50855780e-01f, 1.99692652e-01f, -4.05053496e-02f, -1.20675400e-01f,
  -5.21240644e-02f, 1.05939783e-01f, 2.13482261e-01f, -1.42102525e-01f, 1.70663908e-01f, -4.10077095e-01f, -2.59699851e-01f, -4.25807834e-01f, 4.28525209e-01f, 1.76491830e-02f,
  -5.32711446e-02f, 2.15986595e-01f, -1.97067708e-01f, 2.56417871e-01f, -7.22065419e-02f, 2.93278601e-03f, 1.54995710e-01f, -6.11621961e-02f, 1.75330248e-02f, -1.05992123e-01f,
  -1.03147529e-01f, 1.51857704e-01f, -6.61517084e-02f, -1.24083728e-01f, 2.02726915e-01f, -3.17397356e-01f, 3.02337378e-01f, -1.28783500e-02f, -2.58925319e-01f, 5.71638308e-02f,
  1.52039781e-01f, -1.60865694e-01f, 3.06249261e-01f, 5.73168918e-02f, -1.31928131e-01f, -8.93329456e-02f, -1.53659433e-01f, 2.69596845e-01f, 7.95114934e-02f, 8.76625329e-02f,
  5.24225086e-02f, -2.31408268e-01f, 4.26082432e-01f, 4.50606532e-02f, 4.71744537e-02f, 5.61148562e-02f, -4.03766751e-01f, 1.50561497e-01f, -3.49653900e-01f, 9.22694430e-02f,
  2.76015460e-01f, -5.74234277e-02f, -1.74531400e-01f, 5.63540384e-02f, -1.82007328e-01f, -2.57421792e-01f, 1.42938554e-01f, 1.08667254e-01f, 1.77880004e-01f, 1.04648024e-01f,
  2.01891720e-01f, -1.08578652e-02f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -3.24850343e-02f, -4.11290228e-01f, 5.36961198e-01f, -3.82781476e-02f, 2.88488686e-01f, -1.63649797e-01f, -1.86075404e-01f, 2.56900460e-01f, 1.69755134e-03f, 8.30192715e-02f,
  -1.08764887e-01f, -1.88425910e-02f, 3.53612036e-01f, 2.37679482e-01f, 2.66306490e-01f, -1.60441417e-02f, -3.96154910e-01f, 1.75924540e-01f, -2.43273303e-01f, 1.15870826e-01f,
  -1.26213744e-01f, 3.10580939e-01f, -2.44040921e-01f, 2.15153590e-01f, 9.26222950e-02f, 1.26931816e-01f, 8.10138807e-02f, 1.57554537e-01f, 1.71483923e-02f, -5.87216794e-01f,
  4.08557445e-01f, 3.85606259e-01f, -2.22809985e-01f, -1.45832494e-01f, 1.93199798e-01f, 6.74625579e-03f, -6.04370981e-02f, 1.28941610e-01f, 6.50507957e-03f, 7.15069771e-02f,
  2.34259263e-01f, -8.10592324e-02f, 4.75630522e-01f, -1.87647551e-01f, 3.59338492e-01f, -3.49807084e-01f, -2.26358607e-01f, -4.96234484e-02f, -6.11721516e-01f, 3.46128970e-01f,
  -1.10490568e-01f, 3.94455671e-01f, 4.57434416e-01f, 5.56808785e-02f, 1.48547828e-01f, 2.12626979e-01f, 3.68358791e-02f, -1.87202692e-01f, 1.26295850e-01f, 5.27378805e-02f,
  -4.56878655e-02f, -5.73805235e-02f, 4.12285626e-01f, 1.39117211e-01f, 1.64238274e-01f, 3.07527453e-01f, 1.39125402e-03f, 1.90278664e-01f, 3.08239907e-01f, 2.16366813e-01f,
  4.15970802e-01f, -8.78769606e-02f, 3.42939585e-01f, -1.55667379e-01f, 2.41643712e-01f, -7.83756495e-01f, -2.74922550e-02f, -2.65922368e-01f, -7.19086602e-02f, -1.26378447e-01f,
  1.05236694e-01f, 1.68789789e-01f, -8.28353539e-02f, 1.02531634e-01f, 3.77196372e-01f, -2.91937798e-01f, 2.88650580e-02f, 7.84295127e-02f, -1.27207741e-01f, 8.83920416e-02f,
  1.01196483e-01f, 1.36328146e-01f, 2.90366173e-01f, 2.82811254e-01f, -6.51946738e-02f, 5.49892299e-02f, 1.42718807e-01f, 2.16422081e-01f, 4.01088744e-01f, 3.97600353e-01f,
  -1.87768396e-02f, -1.25744253e-01f, -3.52478504e-01f, 2.95276493e-01f, 4.00684834e-01f, 1.65336728e-01f, 5.65590143e-01f, 4.25767630e-01f, 3.06680351e-01f, 1.30862787e-01f,
  2.39800662e-01f, 2.28305846e-01f, -5.18724799e-01f, 3.35952230e-02f, 2.67591983e-01f, 2.06697211e-01f, -1.94073185e-01f, 3.45695531e-03f, 3.13436151e-01f, 8.23149011e-02f,
  -3.15861315e-01f, 1.92777574e-01f, -4.29880992e-02f, 2.21254557e-01f, -1.05833188e-01f, -3.67644519e-01f, 2.83720642e-01f, -7.92143568e-02f, 1.02285199e-01f, 3.50317389e-01f,
  3.71463060e-01f, 1.79055393e-01f, -1.07627437e-01f, 8.61364231e-02f, 2.82561988e-01f, -3.40302914e-01f, 2.61746913e-01f, -1.89919665e-01f, 5.04856229e-01f, -3.50945219e-02f,
  6.21473081e-02f, -5.81181765e-01f, -1.84997618e-01f, -1.93468705e-02f, -6.69894993e-01f, 8.58102441e-02f, 2.44772866e-01f, -8.41371492e-02f, 5.42978406e-01f, -3.01730812e-01f,
  4.10400182e-01f, 2.32988685e-01f, 7.65310833e-04f, 1.42066225e-01f, -2.22379137e-02f, -5.24456874e-02f, 7.66348615e-02f, 3.88369083e-01f, -5.50472327e-02f, -1.67571753e-01f,
  3.06138486e-01f, -1.01773083e-01f, 3.27846944e-01f, 4.93016481e-01f, 3.44784468e-01f, 8.40148255e-02f, -1.90949216e-01f, 3.12992364e-01f, 3.95680964e-01f, -2.06030980e-01f,
  5.53172547e-03f, -5.31331658e-01f, 3.43802124e-01f, 1.94072589e-01f, -1.50640726e-01f, 2.10109219e-01f, -2.76874483e-01f, 5.24276681e-02f, -4.82338250e-01f, 2.25490555e-01f,
  -1.29694000e-01f, -7.62164146e-02f, -8.34324956e-02f, 1.02739505e-01f, -1.90970346e-01f, -9.37849730e-02f, 1.41475439e-01f, 2.90859133e-01f, 1.72153652e-01f, -2.80852944e-01f,
  1.33995011e-01f, -2.62054871e-03f, -7.32173324e-02f, 1.86966226e-01f, 3.39803815e-01f, 8.80762115e-02f, 1.03466511e-01f, 4.81275022e-01f, 1.96311578e-01f, 2.19881892e-01f,
  2.92908907e-01f, 3.33913900e-02f, -3.61631900e-01f, -5.34300804e-01f, -1.79048538e-01f, -1.24539360e-01f, 5.73070608e-02f, -1.58550262e-01f, 3.07466328e-01f, 2.51223892e-02f,
  -5.60275555e-01f, 3.64720613e-01f, -3.64952795e-02f, -3.57398130e-02f, -2.29742229e-02f, 1.06372014e-01f, 2.19573155e-01f, 3.76882292e-02f, 3.28524381e-01f, 3.72187227e-01f,
  -7.93123692e-02f, 1.66474193e-01f, 3.33772033e-01f, 4.13599014e-01f, -1.63336888e-01f, 1.47032633e-01f, -2.31565088e-01f, -2.57109612e-01f, 1.29858265e-03f, 1.07567757e-01f,
  -2.98572063e-01f, -3.21298748e-01f, -4.75708544e-01f, 7.31661096e-02f, 2.48422563e-01f, 1.78298369e-01f, 1.24343283e-01f, -8.79878849e-02f, -2.20227346e-01f, -6.93511367e-02f,
  -1.34353489e-01f, 2.12817743e-01f, -2.06240248e-02f, 4.63990234e-02f, 4.97866422e-01f, 2.03313589e-01f, 2.54950345e-01f, 2.33165801e-01f, 2.22035959e-01f, -2.53715515e-01f,
  -4.76258108e-03f, -2.21622959e-01f, 7.22945333e-02f, 3.41444522e-01f, 5.65811768e-02f, -1.87592447e-01f, -2.06078831e-02f, -2.79380441e-01f, -2.75673628e-01f, -6.25236854e-02f,
  3.10757738e-02f, 3.11586648e-01f, 2.23358899e-01f, -7.66315833e-02f, -1.61203519e-02f, -4.09418762e-01f, -1.06810115e-01f, -4.76098090e-01f, 1.92070454e-02f, -2.70622224e-01f,
  -2.65845023e-02f, -7.45064840e-02f, 6.12571716e-01f, -4.24226075e-02f, -2.75506139e-01f, -5.11242040e-02f, 1.16995312e-01f, -1.42222866e-01f, -2.29878798e-01f, 2.66923636e-01f,
  -2.18139723e-01f, 1.53133655e-02f, 2.16635093e-01f, 1.55486409e-02f, 3.58287752e-01f, 3.41228783e-01f, 5.04581220e-02f, 2.41260946e-01f, 1.90169245e-01f, 1.88072361e-02f,
  -2.11922571e-01f, 1.48376778e-01f, -1.27491519e-01f, 1.36335075e-01f, 4.97328699e-01f, -2.69464463e-01f, -2.15471864e-01f, -4.87897575e-01f, 5.96663713e-01f, 1.86403319e-01f,
  3.34755965e-02f, -1.55383810e-01f, -3.09725493e-01f, 7.07331598e-02f, -1.45828158e-01f, -8.22684243e-02f, 2.66993910e-01f, 1.47080362e-01f, 3.48493367e-01f, -3.85185599e-01f,
  1.61334351e-01f, -1.21802531e-01f, -4.10193384e-01f, -3.14111449e-02f, 2.43373036e-01f, -5.55080414e-01f, 1.89531103e-01f, 1.86759129e-01f, -1.58306599e-01f, 7.36202747e-02f,
  3.54301155e-01f, 1.78253353e-01f, 4.02585864e-01f, 1.35391727e-01f, 3.86395715e-02f, -1.32367499e-02f, -4.64092165e-01f, 2.29173958e-01f, -8.44116732e-02f, 3.39718670e-01f,
  5.66537678e-01f, 5.09852052e-01f, 1.62621886e-02f, 2.45774657e-01f, 2.83048689e-01f, -1.20420434e-01f, -3.06116790e-01f, 1.85083404e-01f, -1.73179731e-02f, 1.28754154e-01f,
  6.96996599e-02f, 1.39679894e-01f, 3.23330611e-02f, 3.27308297e-01f, 1.65135682e-01f, 1.27132656e-02f, -9.07445103e-02f, -1.92031890e-01f, 2.01957837e-01f, 2.19501704e-01f,
  -1.80970803e-01f, -5.86836219e-01f, 2.64812820e-02f, 4.19934422e-01f, -2.75874257e-01f, 3.95556539e-02f, 1.72678202e-01f, -2.13633150e-01f, 3.97611558e-01f, -5.23828447e-01f,
  3.22624713e-01f, -1.96784243e-01f, 3.11148643e-01f, 4.73031282e-01f, -1.05100721e-01f, -2.36181647e-01f, -2.05690682e-01f, 3.36539865e-01f, -6.22551441e-01f, 2.19344184e-01f,
  6.50352657e-01f, -4.03634049e-02f, 2.72046268e-01f, -6.36359379e-02f, 4.61630106e-01f, -2.45475750e-02f, -5.18154442e-01f, 2.83798814e-01f, 2.03202769e-01f, -4.17339683e-01f,
  -2.28060812e-01f, 9.29512009e-02f, 4.58969101e-02f, 2.32501850e-01f, 2.89295912e-02f, 2.41093189e-01f, 9.00965333e-02f, -6.21068217e-02f, -1.29173100e-01f, -1.18275300e-01f,
  -3.04575384e-01f, -3.36938351e-01f, 4.87745665e-02f, 2.88709909e-01f, 3.84420484e-01f, 2.67662048e-01f, -1.06487289e-01f, -4.49474096e-01f, -4.65898439e-02f, 4.29142006e-02f,
  -5.01693666e-01f, 1.57468483e-01f, 1.78607777e-01f, 7.22772181e-02f, 3.31917077e-01f, -1.43375650e-01f, 2.47541592e-01f, 3.14853996e-01f, 2.61706084e-01f, -1.53362989e-01f,
  -5.63713983e-02f, -1.56486899e-01f, 2.28418127e-01f, 4.28667188e-01f, 1.61791906e-01f, -1.82916895e-01f, 5.46099186e-01f, -1.68570355e-01f, 4.64537501e-01f, 4.71531600e-01f,
  4.47034061e-01f, 1.58864155e-01f, 2.88973689e-01f, 3.70542966e-02f, 1.96319327e-01f, -6.95841789e-01f, -8.19985941e-02f, -1.22275785e-01f, 3.55175525e-01f, 4.10931379e-01f,
  -4.84688610e-01f, 4.31391060e-01f, -5.03836237e-02f, 6.89512789e-02f, -3.73367608e-01f, -5.76308295e-02f, -1.73390687e-01f, -7.14459568e-02f, -4.00147408e-01f, 1.39732361e-02f,
  -4.05268312e-01f, 8.32281820e-03f, 2.17001200e-01f, 1.21717997e-01f, -1.01409547e-01f, -3.94158959e-02f, 8.40825662e-02f, 1.98274970e-01f, 2.92241186e-01f, 3.76109272e-01f,
  2.93207407e-01f, 5.56596577e-01f, 4.09101278e-01f, 5.22244275e-02f, -3.18150878e-01f, 2.69157410e-01f, 6.19052351e-01f, 1.11041330e-01f, -2.57788897e-01f, -4.52740878e-01f,
  -1.14590682e-01f, -2.32158452e-01f, 1.44889250e-01f, 4.03287292e-01f, 3.48021388e-01f, 2.61226863e-01f, -3.10617298e-01f, 3.11409652e-01f, -3.60454291e-01f, -5.94907962e-02f,
  1.86983589e-02f, 2.46666819e-01f, -4.08059299e-01f, 5.51610351e-01f, 6.27983212e-02f, 6.29681885e-01f, 7.83190578e-02f, -9.91474241e-02f, 2.51555413e-01f, 1.31090447e-01f,
  1.56553358e-01f, 1.26548447e-02f, 4.67160285e-01f, 3.92511666e-01f, 2.84750730e-01f, -1.08410515e-01f, -4.32039887e-01f, 1.75606251e-01f, 5.88790178e-01f, 3.27412993e-01f,
  6.47754371e-01f, 4.12455052e-01f, -1.42696783e-01f, 5.20756878e-02f, 2.32912213e-01f, 1.01031996e-01f, -1.99166387e-02f, 1.20790526e-02f, 2.39834622e-01f, -9.03913565e-03f,
  7.40464404e-02f, -9.31045339e-02f, 5.02891481e-01f, 2.12251127e-01f, -1.64209276e-01f, 9.67084691e-02f, -1.69660568e-01f, -1.32272616e-01f, -4.20361519e-01f, -4.31773402e-02f,
  -4.95084189e-02f, -3.16663206e-01f, 5.08464873e-01f, 2.43767813e-01f, -1.10409960e-01f, 2.84766972e-01f, 2.52930820e-01f, 2.27131099e-01f, 6.39001846e-01f, -3.95074159e-01f,
  -7.34319389e-02f, -7.39727437e-01f, 3.78368020e-01f, -2.98691332e-01f, 1.05237709e-02f, 4.16493192e-02f, -2.11645931e-01f, 8.91017392e-02f, 3.80791575e-01f, -1.58933267e-01f,
  2.97304749e-01f, 9.63962898e-02f, 4.02851403e-01f, -4.57456440e-01f, 2.92778790e-01f, -2.47751504e-01f, -4.69521731e-01f, 2.28394151e-01f, 4.17257696e-01f, -4.00737762e-01f,
  -3.89637388e-02f, 2.37821862e-01f, -2.49008775e-01f, 2.60186225e-01f, 2.21675992e-01f, 1.34094223e-01f, 2.97994256e-01f, -1.18727565e-01f, 3.04776013e-01f, 8.18248540e-02f,
  -4.47157025e-01f, 1.85860544e-01f, 1.94925927e-02f, 2.17307732e-01f, -1.90916225e-01f, 4.60513204e-01f, -4.29452568e-01f, 4.64587122e-01f, 4.17512894e-01f, -2.69809961e-01f,
  3.07130188e-01f, -3.62705052e-01f, 1.40037446e-04f, 3.35073173e-01f, -3.77418436e-02f, 4.68774378e-01f, 1.25639901e-01f, 4.66798306e-01f, 3.68274480e-01f, 4.08748448e-01f,
  -2.49736637e-01f, 2.48013034e-01f, -7.19225705e-02f, 5.27627647e-01f, -4.34411280e-02f, -1.06073119e-01f, -1.68625876e-01f, -7.88478479e-02f, 6.91661760e-02f, -7.97081217e-02f,
  -1.12529270e-01f, 8.52327496e-02f, 8.32419991e-02f, 3.93915810e-02f, 3.60228866e-01f, -1.26468360e-01f, 2.77749658e-01f, -2.01829582e-01f, 2.75398523e-01f, -7.11054087e-01f,
  -2.11385980e-01f, 1.08929381e-01f, -3.21114898e-01f, 2.32705832e-01f, -7.10741570e-03f, 1.27546132e-01f, 4.39335644e-01f, 5.77697605e-02f, 3.31881613e-01f, 1.56381041e-01f,
  -5.64852357e-02f, -1.39829576e-01f, 1.17958859e-01f, 6.20338693e-02f, 1.14190884e-01f, 3.32571208e-01f, -1.42783429e-02f, 3.05499375e-01f, 1.36868685e-01f, -3.52166630e-02f,
  2.57064909e-01f, 2.96120141e-02f, 2.55031139e-02f, 2.55982608e-01f, 2.25181192e-01f, -2.23740503e-01f, 3.48927304e-02f, -4.06301081e-01f, 1.02119774e-01f, -1.54351266e-02f,
  9.00589302e-02f, 6.52135313e-02f, -2.42036730e-01f, -2.19449326e-01f, 1.93287104e-01f, -1.48190081e-01f, -2.67957449e-01f, 6.35845959e-02f, -1.40628844e-01f, -1.82352304e-01f,
  -2.62787733e-02f, -1.12613507e-01f, -2.52731889e-01f, -3.94530356e-01f, 4.66935992e-01f, -5.82335353e-01f, 5.95088713e-02f, 3.01065028e-01f, -7.97057003e-02f, 1.01737981e-03f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  9.39067304e-02f, -1.06932737e-01f, 1.22637026e-01f, 3.37818041e-02f, 1.08505376e-01f, 2.82120585e-01f, 2.07654834e-01f, 1.45945951e-01f, 8.77073854e-02f, 4.20147091e-01f,
  2.42042705e-01f, 1.06961966e-01f, 1.18948936e-01f, 2.02758268e-01f, 2.33347595e-01f, 7.57075474e-02f, 3.62021685e-01f, 2.01625794e-01f, 1.04876764e-01f, -4.10099812e-02f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  2.07559705e-01f, -7.80968666e-02f, -4.33201939e-02f, -1.68487823e-04f, 5.74965589e-02f, 3.80189210e-01f, 2.30929963e-02f, 7.42997676e-02f, -1.30334452e-01f, -1.89446345e-01f,
  9.45239142e-02f, 3.21073294e-01f, -7.53510818e-02f, -6.13172799e-02f, 1.62934333e-01f, -6.24299608e-02f, 1.38247192e-01f, 3.12614404e-02f, -1.55392155e-01f, 2.53986772e-02f,
  5.25414050e-02f, 2.54537389e-02f, 2.05131233e-01f, -2.81488925e-01f, 6.08729981e-02f, 1.63882270e-01f, 1.05005383e-01f, -1.14204563e-01f, -4.16898765e-02f, -3.23131345e-02f,
  3.38486545e-02f, -1.93024814e-01f, 1.91663235e-01f, 3.48052308e-02f, 1.36288526e-02f, 1.31091461e-01f, 2.42682621e-01f, 2.55366806e-02f, 2.08780095e-01f, -5.33233345e-01f,
  -2.07931548e-01f, -1.65142179e-01f, 1.09182499e-01f, -3.42600159e-02f, -1.22311249e-01f, -6.31813928e-02f, -9.71070454e-02f, -1.81178659e-01f, -2.40137707e-02f, 1.49360910e-01f,
  -1.95527822e-01f, 2.44756401e-01f, 1.85950145e-01f, -7.87120610e-02f, 3.15307289e-01f, -2.85953283e-01f, -9.85081270e-02f, 2.02311441e-01f, -4.11777720e-02f, 1.77151933e-02f,
  5.43253198e-02f, 4.77472022e-02f, -1.06963448e-01f, -3.67088914e-02f, -1.62965596e-01f, 1.50659189e-01f, 4.32574116e-02f, -2.53152609e-01f, 6.32263115e-03f, 1.15356646e-01f,
  -4.13483769e-01f, -3.83800507e-01f, -3.88115436e-01f, 2.07909960e-02f, 5.40035069e-02f, -2.30878055e-01f, 2.03749314e-01f, -3.47657837e-02f, 3.94304423e-03f, 1.05559193e-02f,
  -2.00591296e-01f, 9.05134901e-02f, -1.07269287e-01f, 9.68203694e-02f, 1.42708033e-01f, -1.86634604e-02f, 1.34309560e-01f, -9.47012007e-02f, -8.93278047e-02f, -2.99092174e-01f,
  -9.27063972e-02f, -8.53762627e-02f, -2.31102899e-01f, 7.54821077e-02f, -1.10672005e-01f, 2.72317231e-01f, 1.64141059e-01f, -1.00777723e-01f, -1.43305480e-01f, -2.85451766e-02f,
  1.25250101e-01f, 2.05952048e-01f, 3.12253088e-01f, 1.31243676e-01f, -1.60284743e-01f, 1.91162750e-01f, -4.97893512e-01f, -1.58665910e-01f, -8.85176361e-02f, -2.62541920e-01f,
  -3.65941375e-02f, -5.87574905e-03f, -1.07704692e-01f, -6.34073019e-02f, -7.90802091e-02f, -2.71905869e-01f, -3.12509499e-02f, -2.21873283e-01f, 1.76224262e-01f, 1.01801775e-01f,
  4.45499318e-03f, -2.76914500e-02f, 1.52319580e-01f, 2.26059586e-01f, -3.89055870e-02f, 2.06697538e-01f, -2.10263412e-02f, -1.37370691e-01f, -1.39880076e-01f, 3.72544602e-02f,
  -7.15787783e-02f, -6.08847067e-02f, -2.03678057e-01f, -9.30660740e-02f, 2.29727551e-01f, -5.17257750e-01f, -1.41329452e-01f, 4.33921397e-01f, -2.39410564e-01f, 2.50023957e-02f,
  1.97106674e-01f, 7.57800043e-03f, -4.02701646e-02f, 5.69226854e-02f, -1.16083875e-01f, 3.74567062e-02f, -5.39478362e-02f, -6.86562732e-02f, 1.81041479e-01f, -1.59318402e-01f,
  1.40690729e-01f, -2.79215068e-01f, 1.98464900e-01f, -2.76404351e-01f, 2.55934954e-01f, -8.81001577e-02f, -1.70627773e-01f, -5.50877973e-02f, 1.86588854e-01f, -3.61001104e-01f,
  -1.28811568e-01f, 1.48151457e-01f, -1.58068448e-01f, 9.21542868e-02f, 9.30414200e-02f, 3.73922646e-01f, -1.18069135e-01f, -4.45988514e-02f, -1.27251312e-01f, -1.34512827e-01f,
  -2.42722586e-01f, -1.67850643e-01f, -2.61821568e-01f, 1.97099913e-02f, 2.82642432e-02f, -1.43815547e-01f, 7.61149377e-02f, -1.97969645e-01f, -4.73911688e-02f, 1.69142380e-01f,
  1.21479452e-01f, 8.44114274e-02f, 1.31952301e-01f, -1.98306605e-01f, 1.74365729e-01f, 4.41928729e-02f, -6.58133999e-02f, 3.20734173e-01f, -6.23402186e-02f, 1.59485057e-01f,
  -4.47338708e-02f, 1.21687055e-01f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  5.04374094e-02f, -3.98007810e-01f, 1.47745550e-01f, 1.70688331e-01f, 5.00437059e-02f, -9.41930413e-02f, 2.53166199e-01f, -5.06113470e-01f, -1.72433183e-01f, 4.71573383e-01f,
  -2.65283555e-01f, -2.57955521e-01f, 2.56772906e-01f, -2.34086066e-01f, -2.30447322e-01f, -5.65833896e-02f, -3.20534497e-01f, -1.57609731e-01f, 2.75836110e-01f, 2.38857597e-01f,
  -7.12417364e-02f, -2.59989798e-01f, 1.27753451e-01f, -4.97877002e-01f, 1.28255978e-01f, -5.31284153e-01f, 2.00745240e-01f, -2.78825641e-01f, 9.05230567e-02f, 2.94205964e-01f,
  -2.36372620e-01f, -6.06898628e-02f, 3.80330086e-01f, -3.69083732e-01f, 5.21835573e-02f, 1.93368524e-01f, 2.36981764e-01f, 3.79548706e-02f, 1.85245723e-01f, 1.46397622e-02f,
  -1.46594271e-01f, -3.33761454e-01f, 5.10814190e-01f, 1.08960057e-02f, -1.91161588e-01f, 3.35137658e-02f, 2.41286337e-01f, -2.39672646e-01f, 4.43412870e-01f, -2.47974828e-01f,
  -1.10645391e-01f, 1.67956412e-01f, -2.64048614e-02f, 4.53218102e-01f, 3.21537375e-01f, 3.16594958e-01f, 1.82047069e-01f, -5.79682216e-02f, -6.61765635e-01f, -1.10522322e-01f,
  3.91726643e-01f, 2.69200355e-01f, 1.10816307e-01f, -3.32205594e-02f, 3.69197190e-01f, -3.12988788e-01f, 3.98802131e-01f, -4.37036157e-02f, 2.26440579e-01f, -1.56932801e-01f,
  6.28210306e-02f, 9.07444805e-02f, 2.89757609e-01f, -6.84612244e-02f, 5.80484152e-01f, -2.42277294e-01f, 1.36067435e-01f, 2.10934088e-01f, 2.71741927e-01f, -1.42844155e-01f,
  6.12396412e-02f, 1.11973077e-01f, -1.83256000e-01f, 2.18494415e-01f, 3.52935672e-01f, 4.75696892e-01f, 4.64278758e-02f, 2.24954709e-01f, 2.00757831e-01f, 2.30202734e-01f,
  1.69287294e-01f, -2.23149091e-01f, 4.82847691e-01f, -4.53322202e-01f, 2.31188126e-02f, -2.95326430e-02f, 2.31306255e-01f, 3.16058367e-01f, 2.15468905e-03f, 3.96463908e-02f,
  -4.07280140e-02f, 8.56328607e-02f, -1.03225827e-01f, 9.03911293e-02f, 4.36481088e-01f, 3.17969263e-01f, -4.76693884e-02f, 3.61372352e-01f, 6.70876727e-02f, -1.44163951e-01f,
  3.76854509e-01f, -1.40943974e-01f, -9.13688317e-02f, 3.65281522e-01f, 2.34478757e-01f, -2.15279520e-01f, 3.36819172e-01f, -4.47813310e-02f, -1.84654027e-01f, 9.68931615e-02f,
  -3.22295368e-01f, 5.37524045e-01f, 3.88640165e-01f, -4.14569467e-01f, 2.40920931e-01f, 3.72192562e-02f, 9.41822380e-02f, 1.76700026e-01f, 1.56671003e-01f, -6.30173236e-02f,
  -4.31765258e-01f, -1.28103271e-02f, 2.10194543e-01f, 1.15131132e-01f, 3.62202108e-01f, -3.04362088e-01f, -3.29977423e-01f, -2.54787415e-01f, 2.87717823e-02f, -1.89357758e-01f,
  8.39179605e-02f, -3.72670591e-01f, -2.99460232e-01f, 1.31932721e-01f, -4.03158844e-01f, 2.49468744e-01f, -2.02475786e-02f, -1.36072457e-01f, -9.05072764e-02f, -2.52376288e-01f,
  4.70014423e-01f, -2.76057750e-01f, -2.80908436e-01f, 3.01291584e-03f, -6.09860420e-02f, -1.55467503e-02f, -4.45996374e-02f, 4.10291880e-01f, -5.03521919e-01f, -7.91370794e-02f,
  -2.05926508e-01f, 8.98348093e-02f, -2.60312617e-01f, -8.63096938e-02f, -8.91847685e-02f, 1.31162986e-01f, 2.92637106e-02f, -5.27997352e-02f, -4.75350440e-01f, -2.25254506e-01f,
  -2.56917626e-01f, -2.57979721e-01f, 3.81277770e-01f, 3.63837332e-01f, 3.23703256e-03f, 2.38851383e-01f, -8.37542936e-02f, -5.96597679e-02f, 3.00606728e-01f, 3.13734472e-01f,
  1.46384968e-03f, -2.26928100e-01f, 5.64915299e-01f, -1.64243191e-01f, 2.06775516e-01f, -3.28888565e-01f, -8.90925527e-02f, 1.69928193e-01f, -2.93095261e-01f, 6.34633303e-01f,
  1.14633024e-01f, -1.37886405e-01f, -8.02523643e-02f, -7.39758760e-02f, -1.46270931e-01f, -2.21124515e-01f, -2.23928824e-01f, -5.60932398e-01f, -6.01722896e-01f, -1.54303849e-01f,
  5.65255396e-02f, -2.46442899e-01f, 6.32422447e-01f, 2.20745951e-01f, 1.83314607e-01f, 3.05781215e-01f, 2.65739232e-01f, 6.69749156e-02f, 2.46029913e-01f, 2.81540900e-01f,
  1.40826460e-02f, 2.46554941e-01f, 2.05379531e-01f, 2.14381978e-01f, 8.65413100e-02f, -3.94211084e-01f, 7.27072032e-03f, 2.02399313e-01f, 1.85162462e-02f, -5.01045763e-01f,
  -1.49631277e-01f, -3.11706811e-01f, 2.13103145e-01f, 3.18199903e-01f, 1.99830428e-01f, 3.58820468e-01f, -1.06486760e-01f, -3.76581680e-03f, 3.96270126e-01f, 2.43148401e-01f,
  3.10368180e-01f, -4.35143203e-01f, 1.37912199e-01f, 5.38089931e-01f, -4.09261733e-01f, 2.41262808e-01f, -6.71283007e-02f, -3.27697068e-01f, 1.46684140e-01f, -1.30512640e-01f,
  -3.44298869e-01f, 1.21710263e-01f, 3.18680793e-01f, -7.89815784e-02f, 3.32188487e-01f, -2.40875959e-01f, -1.34344712e-01f, -4.93768513e-01f, -2.58917361e-01f, 3.70258540e-01f,
  3.61014068e-01f, 1.14365287e-01f, 3.09382141e-01f, 8.63893926e-02f, -1.75032586e-01f, -1.41668886e-01f, -2.73479015e-01f, 1.25749573e-01f, 6.62503392e-02f, 6.71505257e-02f,
  -2.37970412e-01f, 4.67763655e-02f, -1.47806123e-01f, 1.76657557e-01f, 4.75014865e-01f, 3.62542003e-01f, -2.63855457e-01f, 3.78197968e-01f, 9.27166864e-02f, 2.70616114e-01f,
  3.50054860e-01f, -6.83377832e-02f, 1.40036732e-01f, 2.19738960e-01f, 4.85374689e-01f, 1.37021011e-02f, 9.62102041e-02f, 9.35541019e-02f, -3.78636330e-01f, -6.49958700e-02f,
  -1.26297902e-02f, -8.06158315e-03f, 3.39164048e-01f, -4.18954104e-01f, 1.95579469e-01f, 1.16133034e-01f, 1.36395261e-01f, 9.76912081e-02f, -1.98690463e-02f, 2.14958072e-01f,
  2.96104066e-02f, -3.68888490e-02f, 1.02543086e-01f, 5.86149143e-03f, -3.93375874e-01f, -1.17235770e-02f, 2.14427918e-01f, 1.07878231e-01f, -5.25173955e-02f, 4.53126729e-01f,
  -3.03123325e-01f, 1.45800382e-01f, 4.63536263e-01f, -4.70269948e-01f, 6.17225766e-02f, 2.93276101e-01f, 1.34423465e-01f, 1.02585629e-02f, 5.28697312e-01f, 6.85528293e-02f,
  1.84381567e-02f, -5.51988065e-01f, 1.24696791e-01f, 3.12596738e-01f, 2.64649302e-01f, -3.89976799e-01f, 1.82932332e-01f, -9.47113484e-02f, 2.67307550e-01f, 1.71233416e-01f,
  4.62834477e-01f, -4.80300695e-01f, 1.49722725e-01f, -1.83788747e-01f, -2.25610480e-01f, 2.56826222e-01f, -5.66389263e-01f, -2.41843060e-01f, 1.72491893e-01f, 3.37334201e-02f,
  6.10884309e-01f, -3.05373259e-02f, 2.48558030e-01f, 6.15553968e-02f, 1.31176323e-01f, -3.46237689e-01f, 1.68197721e-01f, -7.24779367e-02f, 2.55201072e-01f, 3.55615586e-01f,
  7.75769576e-02f, 5.01607895e-01f, -1.05444854e-02f, -6.69826195e-02f, 1.13531858e-01f, -1.72904357e-01f, -2.77081579e-01f, -2.69709647e-01f, 3.63608420e-01f, 2.12620169e-01f,
  4.85488363e-02f, 2.77843356e-01f, 1.41149461e-01f, 3.87760587e-02f, 2.04059985e-02f, 2.00549498e-01f, -1.52692050e-01f, 2.01100752e-01f, -2.84761012e-01f, -1.09799430e-01f,
  5.91715574e-01f, 2.18667127e-02f, 1.79974958e-01f, 3.21946800e-01f, -5.29896975e-01f, 5.39716966e-02f, 5.87572753e-02f, -2.01832458e-01f, 1.95623830e-01f, -1.19610153e-01f,
  7.75679052e-02f, 7.04387873e-02f, 2.06703037e-01f, 4.37967092e-01f, -4.49449033e-01f, 2.69754767e-01f, -1.13891430e-01f, 8.14030617e-02f, -3.56651753e-01f, -3.93103004e-01f,
  4.13878739e-01f, -7.64853597e-01f, 2.72389710e-01f, 2.62132317e-01f, 2.27129105e-02f, 2.33904332e-01f, -2.89752637e-03f, 2.19014242e-01f, 3.51685658e-03f, -2.36347899e-01f,
  4.26629692e-01f, 3.71859632e-02f, 5.42413518e-02f, 1.67938992e-01f, -3.32668535e-02f, 5.78969240e-01f, 3.39583665e-01f, 1.18652172e-01f, -3.74778919e-02f, 5.06671965e-01f,
  -1.52374595e-01f, 1.48042828e-01f, 1.13383517e-01f, -3.78547400e-01f, -3.50821823e-01f, -5.47169924e-01f, 1.48929097e-02f, 4.27299440e-02f, -1.46198139e-01f, 4.51786697e-01f,
  4.53211546e-01f, 9.69158337e-02f, -5.90366013e-02f, 1.44000128e-01f, -2.28051990e-01f, -4.62534398e-01f, -3.11343044e-01f, 2.18196273e-01f, 1.70276478e-01f, 2.38764748e-01f,
  2.25411654e-01f, 5.57748318e-01f, 2.80942172e-01f, -2.08197609e-01f, 8.41297731e-02f, 4.03321892e-01f, -3.30319107e-01f, -3.57229024e-01f, 3.87022831e-02f, -5.67888439e-01f,
  2.28331730e-01f, 4.63377237e-02f, 1.46440072e-02f, -1.19557597e-01f, 7.32189491e-02f, -5.31064868e-01f, -1.62992179e-02f, -7.97471926e-02f, 2.78550051e-02f, 8.74671414e-02f,
  -2.47584686e-01f, -2.34790653e-01f, 2.02487722e-01f, 1.89182669e-01f, 2.89937079e-01f, 3.22605819e-01f, -3.93289208e-01f, -2.85892993e-01f, -7.02191843e-03f, 1.23908564e-01f,
  2.58031428e-01f, 1.72642432e-02f, 2.68041402e-01f, 4.24411833e-01f, 4.00935411e-01f, 3.84189546e-01f, -4.72818971e-01f, -3.88288349e-01f, 1.88696668e-01f, -5.92763841e-01f,
  -2.80818403e-01f, -1.60991810e-02f, 3.79714102e-01f, 2.72086442e-01f, 5.60926795e-01f, -1.31854013e-01f, -1.66362837e-01f, 4.02267873e-01f, -3.71494800e-01f, 2.88043469e-01f,
  2.56156445e-01f, 7.24400520e-01f, 3.84398162e-01f, -2.82905221e-01f, 1.28190249e-01f, 4.74313319e-01f, 5.37148416e-01f, 1.56057402e-01f, 2.41361886e-01f, -2.03739628e-01f,
  6.39342098e-03f, 1.08216003e-01f, -1.88168988e-01f, -1.45929798e-01f, -7.91638494e-02f, -2.11156204e-01f, -9.25437808e-02f, -1.83993012e-01f, -1.53700903e-01f, -1.83776349e-01f,
  4.47446823e-01f, 4.75178510e-02f, 3.00680101e-02f, -7.42463842e-02f, 2.79092550e-01f, -1.31128341e-01f, -6.95164651e-02f, 3.72945786e-01f, 1.85958773e-01f, 3.53609808e-02f,
  -2.08170842e-02f, -1.88532650e-01f, 2.09796354e-01f, -6.13391221e-01f, 1.93388060e-01f, 3.41391236e-01f, 1.06611773e-01f, -2.09077969e-01f, -1.10560440e-01f, -1.92110866e-01f,
  8.14755857e-02f, -2.75215972e-02f, -6.76694885e-02f, -1.51412964e-01f, -2.66847620e-03f, -2.69565880e-01f, -6.59662664e-01f, -2.05570877e-01f, -3.18367869e-01f, -3.32042485e-01f,
  5.83572328e-01f, 4.62856352e-01f, 3.64221931e-01f, 1.41026914e-01f, 8.88666511e-02f, 2.05271300e-02f, 2.81694680e-02f, -2.02647150e-01f, -2.32988179e-01f, -2.64826387e-01f,
  2.73712069e-01f, -1.95511118e-01f, 1.44480035e-01f, 3.46650660e-01f, -1.52182236e-01f, 1.75106466e-01f, -1.62285104e-01f, -2.17503041e-01f, -8.10081288e-02f, -3.53724837e-01f,
  4.69842464e-01f, 2.26611823e-01f, 3.38600762e-02f, 5.36146760e-01f, 4.47927564e-01f, 2.66149849e-01f, 7.73840100e-02f, 2.42049843e-01f, 4.77602243e-01f, 5.88203907e-01f,
  7.30799496e-01f, -3.32054466e-01f, -2.75400490e-01f, -1.05469503e-01f, -3.28640103e-01f, -2.17892572e-01f, -1.25370264e-01f, -7.78823197e-01f, 1.09009027e-01f, 3.34350727e-02f,
  -2.10380018e-01f, 8.77480581e-02f, 9.57266614e-02f, -1.92352802e-01f, 5.48292696e-02f, -9.86828580e-02f, 3.01891118e-01f, -1.24667354e-01f, -2.18373671e-01f, 3.42507929e-01f,
  4.31905724e-02f, 2.59766489e-01f, 3.86437237e-01f, 2.97691613e-01f, -5.57666659e-01f, -3.99812251e-01f, 3.05450499e-01f, -6.71076477e-02f, -2.36678883e-01f, -4.05921526e-02f,
  -3.73500973e-01f, -4.34810460e-01f, -1.76485375e-01f, -1.01904728e-01f, 1.04990132e-01f, -2.88439125e-01f, 6.64636016e-01f, 3.63961816e-01f, 5.16951919e-01f, 2.85108715e-01f,
  3.83412875e-02f, 2.19120368e-01f, -6.39252886e-02f, 3.16664219e-01f, -1.08137198e-01f, -1.13554463e-01f, -2.47321218e-01f, 3.99912834e-01f, -6.79430217e-02f, 1.37892559e-01f,
  -4.11793798e-01f, 4.11874145e-01f, -1.97780013e-01f, -8.78866911e-02f, 2.44746640e-01f, 2.36821491e-02f, -6.19745404e-02f, 3.31894755e-01f, -1.28137365e-01f, 4.47207928e-01f,
  1.87696099e-01f, 1.33090541e-01f, 1.19198337e-01f, 2.80872405e-01f, 1.68694511e-01f, 1.35453388e-01f, -2.32369781e-01f, -2.38369495e-01f, -2.82929599e-01f, 4.79192622e-02f,
  4.51553538e-02f, 3.14296186e-01f, -2.84260549e-02f, 6.34239137e-01f, 1.83701038e-01f, 1.69278607e-01f, 1.42171979e-01f, 1.26791835e-01f, -1.16966516e-01f, -1.88944146e-01f,
  3.00581336e-01f, 8.18589926e-02f, 2.31725559e-01f, -6.84777647e-03f, 4.66728300e-01f, 4.97454613e-01f, -3.70007455e-01f, -1.66314662e-01f, 5.89514971e-02f, -5.91993272e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  2.82664031e-01f, 8.76175240e-03f, 2.58179873e-01f, 2.21052423e-01f, 1.00443050e-01f, 8.38429853e-02f, 4.09964360e-02f, 1.45720124e-01f, -1.03837512e-01f, 1.20342053e-01f,
  1.96357295e-01f, -2.07871068e-02f, 3.64475623e-02f, 1.05895586e-01f, 1.69493929e-01f, 1.27662033e-01f, -8.72292370e-02f, 4.14586127e-01f, 1.79729477e-01f, 2.62333572e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -3.02816451e-01f, -2.70793915e-01f, -3.77242826e-02f, -2.73470193e-01f, -1.40934259e-01f, -2.33099520e-01f, -3.69782478e-01f, -3.56359243e-01f, 1.16191745e-01f, 1.57297477e-01f,
  3.11153308e-02f, -3.97905320e-01f, 2.59365678e-01f, -4.89447653e-01f, -3.90305459e-01f, 8.96212738e-03f, 1.27688786e-02f, 1.24567866e-01f, -1.11087359e-01f, -4.82173972e-02f,
  2.71435618e-01f, -4.69952941e-01f, 3.47450078e-01f, -2.38754824e-01f, 4.47271168e-02f, 2.98726350e-01f, -3.22684258e-01f, -2.14247763e-01f, 5.24684846e-01f, -1.23982586e-01f,
  1.49114475e-01f, -2.88270950e-01f, -4.15472826e-03f, -7.84527510e-02f, -1.63322344e-01f, 2.21074745e-01f, 1.03388257e-01f, -4.29589987e-01f, -1.61011666e-01f, -3.36018324e-01f,
  -9.96469557e-02f, -3.20786059e-01f, 9.26528033e-03f, 2.88105346e-02f, -5.16404733e-02f, -1.34931386e-01f, -3.45889702e-02f, 2.46002749e-01f, -2.21315652e-01f, -1.01724550e-01f,
  2.45510280e-01f, 5.94659708e-02f, 2.70163327e-01f, 1.20996229e-01f, -4.26630884e-01f, -3.21477801e-01f, 1.48868099e-01f, -5.20207584e-01f, -1.98600128e-01f, 1.66774303e-01f,
  -3.27964067e-01f, -6.24354243e-01f, 2.08844557e-01f, 9.53942165e-02f, 4.12561327e-01f, 1.45486385e-01f, 3.96533251e-01f, 1.25089213e-01f, 6.47355169e-02f, 1.13041729e-01f,
  -2.22274140e-01f, -2.72353351e-01f, -5.07282436e-01f, 1.82574362e-01f, 5.50412536e-01f, 3.97096090e-02f, -4.13575917e-01f, -7.76880980e-01f, -8.87366891e-01f, -1.93019956e-01f,
  -5.96698940e-01f, 3.22637767e-01f, -5.76291323e-01f, -1.61269695e-01f, 2.51857061e-02f, -3.11533272e-01f, -6.25047982e-01f, -2.81670660e-01f, 8.89239162e-02f, -3.62711012e-01f,
  1.71828091e-01f, -3.85056615e-01f, -1.73118457e-01f, -7.86433101e-01f, -2.24010974e-01f, 4.74269092e-01f, 1.44629881e-01f, -2.91576296e-01f, 1.34347240e-03f, -3.24765861e-01f,
  4.91913557e-02f, -6.39850348e-02f, -4.01085280e-02f, 7.16453269e-02f, 2.51670778e-01f, 4.11504209e-01f, 2.70997196e-01f, 1.58289552e-01f, 3.70651782e-01f, 5.24265468e-01f,
  -6.52093709e-01f, -1.64904013e-01f, 1.92966387e-01f, 2.45542467e-01f, -5.11876047e-01f, -5.84074080e-01f, -4.18786943e-01f, -4.50752944e-01f, 2.82186538e-01f, -8.25893730e-02f,
  -2.66739547e-01f, -4.63214479e-02f, -5.46549894e-02f, -3.13807756e-01f, 2.74500512e-02f, 1.25672385e-01f, 1.01293899e-01f, -5.10623693e-01f, 1.21226847e-01f, 2.99165696e-01f,
  3.05106118e-02f, -1.40922949e-01f, -3.57501537e-01f, -1.53202310e-01f, -2.18174130e-01f, 2.69828647e-01f, 3.99726421e-01f, -2.53234684e-01f, -2.66124994e-01f, 1.46162808e-01f,
  1.23216167e-01f, -5.76918423e-01f, 3.38106938e-02f, -5.59282422e-01f, 2.96930879e-01f, 2.34549403e-01f, 1.93073019e-01f, -4.88400906e-02f, -2.52800584e-01f, -1.10302962e-01f,
  -5.16211092e-01f, -2.22752139e-01f, 2.66516414e-02f, 4.32750851e-01f, 3.99676785e-02f, -3.05107106e-02f, -1.14426248e-01f, 3.20210665e-01f, -2.44744912e-01f, 1.25240564e-01f,
  1.14628166e-01f, 2.61187524e-01f, -8.68553296e-02f, 1.56191751e-01f, -1.45709351e-01f, 3.53088468e-01f, 1.79485425e-01f, 2.20943779e-01f, -2.59398341e-01f, 3.27604294e-01f,
  2.36066535e-01f, -4.56801593e-01f, 9.57780983e-03f, -2.41939157e-01f, -1.40231818e-01f, 2.94993848e-01f, -1.85450301e-01f, -2.34168962e-01f, -4.41793025e-01f, 4.65933740e-01f,
  1.61125526e-01f, 2.88014770e-01f, -3.86189103e-01f, -2.86901116e-01f, 1.92461517e-02f, 1.70633152e-01f, -1.51075736e-01f, 4.72299568e-03f, -3.06857705e-01f, 4.33236808e-01f,
  -5.29378891e-01f, -1.50281623e-01f, 1.59716487e-01f, 2.16381177e-01f, 5.68136215e-01f, 3.74231249e-01f, -1.41532511e-01f, 2.16425210e-01f, -9.06942040e-02f, 6.00303233e-01f,
  -1.64565951e-01f, -5.03088772e-01f, 2.89187171e-02f, -3.60359326e-02f, 1.38180047e-01f, 8.80364701e-02f, 3.11353385e-01f, -3.76956344e-01f, -4.30769891e-01f, -7.31890202e-01f,
  -4.07312781e-01f, 1.42809913e-01f, -1.73721448e-01f, -4.16614443e-01f, 1.11488916e-01f, 3.25327814e-01f, -2.31809407e-01f, -2.66476929e-01f, 2.44301707e-01f, -1.56875387e-01f,
  1.16801813e-01f, 2.42953643e-01f, 1.71628892e-01f, 1.56532694e-02f, -4.67670262e-01f, -4.73238155e-02f, 4.47603613e-02f, -5.40306307e-02f, 1.98018163e-01f, -1.90745711e-01f,
  8.20675865e-03f, 3.05004269e-01f, -1.12804443e-01f, -2.01380774e-01f, 4.22065735e-01f, 1.25146389e-01f, -1.86910406e-01f, 1.25581458e-01f, -7.46462867e-02f, -4.59599763e-01f,
  -5.09726226e-01f, 7.23060444e-02f, 2.81056285e-01f, -4.01801646e-01f, -8.71191844e-02f, 2.37080455e-01f, 2.12539807e-01f, -2.73785144e-01f, -4.38959837e-01f, 3.55083868e-02f,
  4.41164151e-02f, 2.91882783e-01f, -1.84149623e-01f, -3.98961782e-01f, -2.53319860e-01f, 1.18117280e-01f, 1.42276451e-01f, 1.62418440e-01f, 3.86020362e-01f, -3.44542772e-01f,
  1.77276760e-01f, 6.55802935e-02f, -3.44326273e-02f, 1.13635622e-01f, 7.28311762e-02f, -3.27411473e-01f, -6.86001122e-01f, 2.32257489e-02f, -5.18330753e-01f, -4.37779605e-01f,
  7.88913667e-02f, 2.59256124e-01f, -2.82665312e-01f, -2.22140670e-01f, 2.67785192e-01f, 2.38195404e-01f, 2.59382427e-02f, 2.68710822e-01f, 1.18431650e-01f, 1.23641700e-01f,
  -5.61604202e-01f, -1.04978845e-01f, -4.44273770e-01f, 2.08634496e-01f, 3.83776665e-01f, -3.48952174e-01f, 1.33191124e-01f, -2.97710270e-01f, 2.34937638e-01f, 3.01451981e-01f,
  -3.79226655e-01f, 5.50107807e-02f, 2.51671046e-01f, 2.19535217e-01f, -3.33141834e-02f, -4.00296658e-01f, 2.70264484e-02f, 4.99262452e-01f, -8.58421862e-01f, 4.24323022e-01f,
  -4.63920861e-01f, 2.72825360e-01f, -5.47459386e-02f, -1.13089671e-02f, -1.54919147e-01f, -1.13662973e-01f, -3.75099808e-01f, -1.87913910e-01f, -2.74671078e-01f, -1.80902779e-01f,
  -1.60238117e-01f, -5.30602276e-01f, -4.14044172e-01f, 1.34815916e-01f, 4.79089081e-01f, -3.20275813e-01f, -4.72367376e-01f, -1.29138350e-01f, -5.46185255e-01f, 1.33618847e-01f,
  -2.82457352e-01f, -5.67838907e-01f, 1.38385490e-01f, 1.15926102e-01f, 1.38043985e-02f, -1.19916193e-01f, 2.87793994e-01f, 1.73209444e-01f, 3.03688377e-01f, 3.63457650e-01f,
  8.93225074e-02f, -1.88173488e-01f, -7.55382121e-01f, -3.20632100e-01f, -2.86513180e-01f, -1.11340983e-02f, 3.27567101e-01f, -1.97543167e-02f, 1.34016022e-01f, 2.83116251e-02f,
  -7.14229047e-01f, -3.58747840e-01f, -3.92408818e-01f, 1.65768638e-02f, 3.39626759e-01f, -5.04477918e-01f, -3.48341793e-01f, 2.44860575e-01f, -1.13650143e-01f, 2.83482850e-01f,
  7.63063490e-01f, 9.29879323e-02f, -1.11765061e-02f, -7.68897776e-03f, -6.13663375e-01f, -1.97109669e-01f, -2.53314167e-01f, -9.30487812e-02f, 8.21091831e-02f, -4.26720589e-01f,
  -2.16763899e-01f, 3.24685484e-01f, -3.98471445e-01f, 2.09430054e-01f, -1.76797822e-01f, 2.78521836e-01f, -4.42127511e-02f, -5.35361096e-02f, 1.93138614e-01f, -3.63508195e-01f,
  1.87360480e-01f, -7.71342933e-01f, 2.42198482e-01f, 1.99885473e-01f, 9.49196070e-02f, 4.41512138e-01f, -2.96817273e-01f, 1.84235483e-01f, -4.62935567e-02f, -1.27710223e-01f,
  1.87394083e-01f, -3.53073984e-01f, 2.10681468e-01f, -4.56054956e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  3.86930779e-02f, -3.96728925e-02f, 1.73027087e-02f, 1.09616984e-02f, 6.47075176e-02f, 4.55487482e-02f, 2.12473214e-01f, -1.59769580e-01f, 3.37572093e-03f, 2.63388932e-01f,
  -4.31725271e-02f, -4.70069386e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    