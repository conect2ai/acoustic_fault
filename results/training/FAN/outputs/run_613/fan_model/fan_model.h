/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.99624074e-01f, 4.06907529e-01f, 9.23506320e-02f, 4.75620560e-04f, -2.45689438e-03f, -1.75253496e-01f, 3.59636396e-01f, -8.35165605e-02f, -5.72287887e-02f, 2.78203428e-01f,
  -3.73058207e-02f, -3.70058626e-01f, -1.80306599e-01f, -2.16784015e-01f, -2.25519732e-01f, 4.86807883e-01f, 4.93629128e-01f, 1.32445376e-02f, -5.69773257e-01f, -4.48146313e-01f,
  -1.81179345e-02f, 9.72451046e-02f, -1.43722415e-01f, -1.29948065e-01f, 2.33350277e-01f, -1.01188265e-01f, 4.15430099e-01f, 1.21047668e-01f, 2.02714533e-01f, 7.63191521e-01f,
  7.41746798e-02f, 7.73537392e-03f, -9.52292159e-02f, -7.83499777e-02f, 1.04166500e-01f, 3.99513580e-02f, -3.11024161e-03f, 5.61214052e-02f, 1.77102610e-02f, -1.32596549e-02f,
  -2.11921497e-03f, 9.65331157e-04f, -4.09248881e-02f, 4.33656946e-02f, -7.27902129e-02f, -1.37686143e-02f, 1.18799582e-01f, -5.88590428e-02f, -2.70061214e-02f, 1.06323576e-02f,
  1.57810703e-01f, -1.18391113e-02f, 3.74082066e-02f, -2.56646518e-02f, -6.95523471e-02f, -3.36509012e-02f, 9.34038386e-02f, -9.91642009e-03f, -6.61704689e-02f, 2.53485739e-01f,
  -2.06189416e-02f, 6.61247736e-03f, 1.12318685e-02f, 3.63809355e-02f, -3.20033506e-02f, -1.98545167e-03f, 7.17082322e-02f, 2.45819502e-02f, -1.34541476e-02f, 3.77089903e-02f,
  -1.60239358e-02f, 2.67823413e-02f, 1.73565350e-03f, -1.79116428e-02f, 2.24991962e-02f, 2.79465728e-02f, 2.06321254e-02f, 4.04704921e-02f, -9.70956460e-02f, 5.54577522e-02f,
  -2.85160504e-02f, -3.32528427e-02f, 6.63512573e-02f, -6.57498315e-02f, 7.73531273e-02f, -1.77715421e-02f, 5.27342735e-03f, -5.24592698e-02f, 1.66294891e-02f, 9.28591844e-03f,
  -3.58233340e-02f, -6.49643689e-02f, 6.11629486e-02f, -3.93423773e-02f, -8.69966745e-02f, -8.61330703e-02f, 6.24274611e-02f, -5.09472862e-02f, -8.29493534e-03f, -5.23011014e-02f,
  -1.17901400e-01f, 1.09614637e-02f, 1.01431534e-01f, 4.05887887e-02f, -8.45526829e-02f, -7.00407177e-02f, -1.31990723e-02f, -3.20639722e-02f, -5.30834608e-02f, -5.48668811e-03f,
  8.24067071e-02f, -4.51438455e-03f, -1.45030975e-01f, 3.05217803e-02f, -6.50802776e-02f, -2.08855122e-01f, -1.00670487e-01f, -9.64411646e-02f, -1.96760640e-01f, 8.95066857e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.02065885e-01f, 5.92865832e-02f, 4.60588127e-01f, 2.25696728e-01f, 3.97060335e-01f, 5.26434183e-01f, 5.69289625e-01f, 3.76355797e-01f, 1.15282804e-01f, 2.38311008e-01f,
  -9.01196711e-03f, -3.74926001e-01f, -3.79360020e-01f, -3.15329254e-01f, -1.66850522e-01f, 1.49192307e-02f, -2.03790125e-02f, -9.73405465e-02f, 7.08542615e-02f, 3.25381935e-01f,
  -9.83923897e-02f, 2.65962362e-01f, 1.40946388e-01f, 7.90948197e-02f, -1.16774686e-01f, -1.94305778e-01f, 1.53317839e-01f, 2.54678540e-02f, -1.00347675e-01f, -4.99646962e-01f,
  -1.80226058e-01f, 2.73515284e-01f, -3.00834388e-01f, -2.19668165e-01f, -4.65471484e-02f, -1.76131889e-01f, 6.86488152e-02f, -4.09174301e-02f, -1.55113405e-02f, 2.64474116e-02f,
  -1.05988771e-01f, -3.02165020e-02f, 7.25483103e-03f, 6.62226602e-02f, 3.53471488e-01f, 1.43198028e-01f, -2.34984364e-02f, 7.68884122e-02f, 2.81984452e-02f, -1.31899221e-02f,
  -1.87830329e-01f, 1.76648363e-01f, 2.49509409e-01f, 1.40183549e-02f, -8.19243044e-02f, -1.33053541e-01f, -1.16540805e-01f, -1.12144157e-01f, -6.42003678e-03f, 1.01358831e-01f,
  4.41132039e-02f, -1.26846403e-01f, -8.74168798e-02f, 2.23534837e-01f, -5.30021898e-02f, 5.96303977e-02f, -2.00828575e-02f, -1.97743014e-01f, -3.26622627e-03f, 4.60082963e-02f,
  -7.90325180e-02f, 2.24634446e-02f, 1.56198591e-01f, 1.59496605e-01f, -1.39526650e-01f, 1.70080259e-01f, 1.09479904e-01f, -8.71090442e-02f, -1.05287403e-01f, -4.80679907e-02f,
  3.68820205e-02f, 1.70921192e-01f, 5.84261045e-02f, -7.79458955e-02f, 1.57033615e-02f, 3.24597061e-02f, -2.12970655e-02f, -2.66227741e-02f, 6.75029680e-02f, 3.38369161e-02f,
  3.93467769e-02f, 2.50031482e-02f, -1.01971067e-01f, -8.83593261e-02f, 4.42446209e-02f, -2.42042840e-01f, -6.91823363e-02f, -2.00329408e-01f, -1.71658710e-01f, 1.10490732e-01f,
  5.68566211e-02f, 5.11381775e-03f, 2.27150484e-03f, 5.42492978e-02f, 4.61881608e-02f, 1.93015635e-02f, -5.91270700e-02f, 1.97848640e-02f, -8.67532492e-02f, -5.97151369e-02f,
  -1.27793504e-02f, 2.65210986e-01f, 2.38912359e-01f, 1.43137937e-02f, 1.26458213e-01f, 5.86133115e-02f, -6.21941313e-02f, 1.42055854e-01f, 1.32208809e-01f, 2.26655662e-01f,
  1.25615084e+00f, 5.31153738e-01f, 2.63948947e-01f, 6.43799379e-02f, -3.33392531e-01f, -9.91498381e-02f, 1.46062106e-01f, 1.97282508e-01f, -9.80446488e-02f, 7.48206452e-02f,
  8.88945982e-02f, 6.50230050e-02f, 9.68972296e-02f, 1.26880873e-02f, 3.21280837e-01f, 1.04727179e-01f, -8.77374560e-02f, 1.34848401e-01f, -7.08773434e-02f, -2.17577398e-01f,
  -3.84976178e-01f, -1.81167051e-01f, 2.31421590e-02f, 6.71591312e-02f, -3.98189463e-02f, -1.58444732e-01f, -3.78083885e-02f, 1.88870668e-01f, 2.51058042e-01f, 2.37314880e-01f,
  3.74198139e-01f, 4.63198125e-01f, -2.43316099e-01f, -3.66674624e-02f, 1.05245179e-02f, -1.00616001e-01f, -6.12294637e-02f, -1.11279316e-01f, -1.50160357e-01f, 3.68001033e-03f,
  1.03603618e-03f, -9.60414335e-02f, -3.34115000e-03f, -1.35069829e-03f, 5.39358407e-02f, -2.44250894e-02f, 1.04031421e-01f, 2.30668604e-01f, 2.06922665e-01f, 1.52293354e-01f,
  -8.32849834e-03f, 2.86414344e-02f, 1.97999492e-01f, 1.17246300e-01f, 2.67319947e-01f, -1.10224284e-01f, 8.09348822e-02f, 1.76921159e-01f, 2.31244624e-01f, 2.05762282e-01f,
  -1.56196773e-01f, 6.48504943e-02f, 6.18369021e-02f, -1.21571682e-01f, -8.09173062e-02f, -1.05671138e-02f, 1.12069985e-02f, -9.08517241e-02f, -5.34830764e-02f, -6.60038963e-02f,
  -3.90596054e-02f, 8.73892754e-02f, 1.05349317e-01f, -1.33551119e-04f, -3.57566364e-02f, 1.24957681e-01f, 1.29858106e-01f, -7.55330771e-02f, -1.29884019e-01f, 9.61410813e-03f,
  2.71514561e-02f, 2.26105794e-01f, -3.91439954e-03f, 5.03749438e-02f, -4.92992625e-03f, 6.99414909e-02f, 9.56955999e-02f, -1.09182596e-01f, -9.53194275e-02f, -1.24109522e-01f,
  7.00079426e-02f, 1.11514837e-01f, 6.19474500e-02f, 5.37224934e-02f, 4.03128192e-02f, -2.72006430e-02f, 8.57635289e-02f, -1.76879868e-01f, -1.36806518e-01f, 6.92790374e-02f,
  8.63366276e-02f, 2.48773657e-02f, 5.58424704e-02f, 4.15008701e-02f, -1.70995593e-01f, -8.49991292e-02f, -5.78438602e-02f, 4.19504344e-02f, -5.48137166e-03f, -1.17510406e-03f,
  -8.75565261e-02f, 6.48395740e-04f, 2.97468696e-02f, 4.41287681e-02f, 4.33224849e-02f, -5.48706315e-02f, -1.89256474e-01f, -4.99349423e-02f, 2.17779260e-02f, -2.78102010e-01f,
  5.34620464e-01f, 5.79899773e-02f, -2.68092871e-01f, 4.22058791e-01f, 1.76221773e-01f, 2.50336956e-02f, -3.29182558e-02f, -8.10409039e-02f, 2.06428111e-01f, 3.98435891e-02f,
  1.92021489e-01f, 3.45177144e-01f, 1.34594247e-01f, 1.28584271e-02f, -1.11392617e-01f, -7.72600695e-02f, 1.48054019e-01f, 5.14779240e-02f, -3.39305773e-02f, 1.78144410e-01f,
  2.56830543e-01f, 7.79873356e-02f, -1.34014845e-01f, -7.65582100e-02f, 1.46267533e-01f, 1.86291128e-01f, 9.69586801e-03f, 1.41255751e-01f, -1.58403605e-01f, 2.35474259e-01f,
  -3.28142904e-02f, 1.03910200e-01f, 1.92828998e-01f, 1.48836315e-01f, -3.26039977e-02f, 2.23991573e-02f, 1.01795062e-01f, -1.86792046e-01f, -9.99414474e-02f, -1.51470408e-01f,
  3.74407060e-02f, 3.69613841e-02f, -6.93237931e-02f, -1.25280740e-02f, -1.01281628e-02f, -3.52189839e-02f, 2.88244579e-02f, -6.88000098e-02f, -6.17812723e-02f, 1.58526115e-02f,
  1.06722474e-01f, -1.00299694e-01f, -3.17204177e-01f, 3.83560769e-02f, -4.12310436e-02f, 1.35913283e-01f, 9.02934074e-02f, 9.56564993e-02f, -7.31752887e-02f, 4.80681360e-02f,
  4.11696509e-02f, 1.49569334e-02f, 1.63045242e-01f, 1.17922828e-01f, 2.01779023e-01f, -1.36821896e-01f, 1.73104420e-01f, 1.68987419e-02f, 4.90946546e-02f, 1.18537351e-01f,
  1.33981735e-01f, -1.89227685e-02f, -5.58052249e-02f, 3.98956686e-02f, 1.48976237e-01f, -7.99441785e-02f, -9.80767980e-03f, -6.72527179e-02f, 1.55303264e-02f, -1.15559511e-01f,
  1.53811455e-01f, -9.21575949e-02f, -8.86715874e-02f, -1.66799486e-01f, -1.29542172e-01f, 1.79225489e-01f, 2.82744337e-02f, 6.89767152e-02f, 4.06502886e-03f, 1.02550648e-02f,
  -1.24640185e-02f, 1.11046113e-01f, 1.89799964e-01f, -1.85364857e-01f, 6.13944978e-03f, -1.00797899e-02f, 2.54318714e-01f, -5.22818901e-02f, -1.20995469e-01f, 6.07530922e-02f,
  -1.25269443e-01f, 8.85624215e-02f, -1.93761319e-01f, -9.79261026e-02f, -1.05654052e-03f, -1.70426682e-01f, 3.84706073e-02f, 8.23965669e-02f, -2.31467877e-02f, -1.45377338e-01f,
  -9.12424177e-02f, -2.90033817e-01f, -2.28493378e-01f, -9.08442289e-02f, -9.23283324e-02f, 8.36982727e-02f, -9.83091444e-02f, -1.21238083e-01f, -2.12961674e-01f, -7.90815353e-02f,
  2.03924671e-01f, -7.90621713e-02f, 2.79736519e-01f, 1.10549897e-01f, -2.92703956e-01f, -3.87744457e-01f, -2.58584589e-01f, -1.03216097e-01f, -1.24651939e-01f, -4.52347770e-02f,
  -1.97652414e-01f, 5.58669008e-02f, 7.91107044e-02f, 9.11742672e-02f, 2.11437941e-01f, 6.35378957e-02f, 1.55519664e-01f, 5.17895699e-01f, 2.70288169e-01f, -2.46608946e-02f,
  5.86106591e-02f, 9.94759575e-02f, 3.76187623e-01f, 5.37514836e-02f, 8.32502320e-02f, -2.40765489e-03f, -1.07783973e-01f, 3.02872993e-02f, -3.74423862e-02f, 5.26864648e-01f,
  -3.15906443e-02f, 1.01243153e-01f, 1.47606693e-02f, -7.58673996e-02f, -1.44971490e-01f, 7.00431224e-03f, -7.46932551e-02f, 1.05723001e-01f, -2.08425224e-01f, -7.54959881e-03f,
  -4.59368229e-02f, 1.48416474e-01f, -9.17375684e-02f, 6.78176731e-02f, 2.03624256e-02f, 8.32526013e-03f, -9.38979536e-02f, 2.62328655e-01f, 2.02850983e-01f, -1.16631396e-01f,
  -6.92142323e-02f, -9.59218964e-02f, 2.44185813e-02f, -2.70011276e-01f, -1.64027318e-01f, 2.72784233e-02f, -1.42558336e-01f, -9.98370349e-03f, -2.13734120e-01f, 1.43869951e-01f,
  2.65272427e-02f, -1.17755011e-01f, -1.45588256e-02f, 6.09795796e-03f, 5.03041819e-02f, -1.20363548e-01f, -1.56596988e-01f, 7.85479322e-02f, -3.97530757e-03f, -1.31034553e-01f,
  -8.14855546e-02f, 1.34462565e-01f, 8.95542130e-02f, 1.33993533e-02f, -1.03252999e-01f, 2.28616633e-02f, -2.41173312e-01f, 5.51237576e-02f, 1.19574837e-01f, -1.61464781e-01f,
  4.55552749e-02f, 1.01237454e-01f, -7.12587237e-02f, 1.33248404e-01f, -1.43439490e-02f, 7.27479085e-02f, -1.34640723e-01f, -1.64821059e-01f, -2.67859455e-02f, 4.65552062e-02f,
  -5.70287228e-01f, -1.30108714e-01f, 6.17089448e-03f, 1.47592157e-01f, 6.46107793e-02f, -1.51243657e-01f, -2.40394369e-01f, -7.12771341e-02f, -1.26673937e-01f, -1.51411220e-01f,
  -8.22652280e-02f, -3.29930782e-02f, -9.29172412e-02f, 2.07221553e-01f, 8.96190926e-02f, 6.16501085e-03f, -2.08681479e-01f, 1.20789804e-01f, 9.45022777e-02f, 1.85990985e-02f,
  9.87017341e-03f, -3.29116017e-01f, -1.99287474e-01f, -1.24526456e-01f, -1.53477907e-01f, -3.50611687e-01f, -8.10301378e-02f, -2.55340576e-01f, -4.60684091e-01f, -2.56317854e-01f,
  -6.97672486e-01f, -2.38505960e-01f, -7.17247054e-02f, -2.50765502e-01f, 3.51401716e-02f, 4.30252403e-02f, -1.32019594e-01f, 2.44205728e-01f, 5.92975654e-02f, -2.93946832e-01f,
  -8.23677406e-02f, -1.51755884e-01f, -4.42027509e-01f, -2.52262205e-01f, -2.29700729e-01f, -4.64186311e-01f, -5.30303836e-01f, -3.56538981e-01f, 2.68994927e-01f, 5.44982076e-01f,
  1.77991718e-01f, -2.64519572e-01f, -1.66092202e-01f, 2.39579275e-01f, -9.72428843e-02f, -2.08934590e-01f, -2.13950574e-01f, -1.42145663e-01f, 1.80726245e-01f, -6.48998618e-01f,
  -1.39788061e-01f, 3.05817544e-01f, 7.51733035e-02f, -1.08238176e-01f, 1.35915369e-01f, 1.95273951e-01f, 1.60440977e-03f, -2.84778420e-02f, 2.28952207e-02f, 6.22001439e-02f,
  -6.52797148e-02f, 3.35123867e-01f, 6.04364201e-02f, 1.50639683e-01f, -3.16984057e-02f, 6.10302426e-02f, -1.23431096e-02f, 9.85139608e-03f, -3.07116091e-01f, 2.15980306e-01f,
  1.33964047e-02f, -6.45877644e-02f, -2.35349908e-02f, 1.66567579e-01f, 1.66952282e-01f, -1.49265707e-01f, 8.08875710e-02f, 3.20242852e-01f, -9.84948799e-02f, -3.18067908e-01f,
  2.83016469e-02f, -1.16318762e-01f, 5.03995232e-02f, -1.71010047e-02f, -9.84910224e-03f, -8.88735950e-02f, 1.16295079e-02f, 2.49918886e-02f, 1.26932725e-01f, -2.58786201e-01f,
  -9.05134082e-02f, 1.16456421e-02f, 2.91448794e-02f, -7.05277920e-02f, -1.17872246e-02f, -3.44586559e-02f, 6.80055469e-02f, 1.42443264e-02f, 5.86439669e-02f, -4.78039682e-02f,
  -1.10523902e-01f, 1.40202478e-01f, -1.24024056e-01f, 9.22958255e-02f, 5.45976423e-02f, -5.95383085e-02f, 5.88641539e-02f, 1.50711119e-01f, 1.62577301e-01f, 6.92035407e-02f,
  -4.20907706e-01f, -1.12372696e-01f, -1.89225554e-01f, 4.60529961e-02f, -1.60627216e-01f, -1.13339201e-01f, -1.30942270e-01f, 8.13379362e-02f, -1.49590224e-01f, -3.63322385e-02f,
  8.31445754e-02f, -1.58639863e-01f, -2.39971019e-02f, 8.73862654e-02f, -3.41349691e-02f, 7.49429241e-02f, -9.35689881e-02f, -2.38938555e-01f, 2.25836895e-02f, 1.85585469e-01f,
  -1.35972351e-01f, -2.13515475e-01f, -4.30360198e-01f, -3.11123013e-01f, -9.59517136e-02f, -1.11904807e-01f, -8.69658440e-02f, -5.39880283e-02f, -1.65280521e-01f, -4.10439074e-01f,
  -1.17092468e-01f, -3.11062872e-01f, -1.80581093e-01f, 5.03210425e-01f, 5.67795634e-02f, -1.37858808e-01f, -6.21504366e-01f, -2.64029473e-01f, 2.62038231e-01f, -3.63750793e-02f,
  -8.12284201e-02f, 1.04081839e-01f, -2.66896039e-02f, -1.14716075e-01f, -2.36426935e-01f, -3.02878916e-01f, 2.12463140e-01f, 6.68221638e-02f, -5.44838421e-03f, -4.23979163e-02f,
  2.55401850e-01f, 2.66064823e-01f, 1.57527238e-01f, 4.00975393e-03f, 1.53041139e-01f, 1.64515540e-01f, 3.56159769e-02f, 8.74620453e-02f, -1.71124354e-01f, 2.24138170e-01f,
  -7.85268694e-02f, -1.73381433e-01f, -2.86275558e-02f, 4.13832031e-02f, -6.67621046e-02f, -8.12693164e-02f, -6.35898635e-02f, -1.94652174e-02f, -4.57061641e-02f, -9.00540426e-02f,
  1.18662752e-01f, -1.01529442e-01f, 3.99687707e-01f, -6.45092204e-02f, -7.34011382e-02f, 3.18442285e-02f, -5.15538119e-02f, -1.02615125e-01f, -1.43799201e-01f, -5.88105880e-02f,
  1.46308497e-01f, -1.09889887e-01f, -3.02036822e-01f, -2.53351063e-01f, -2.73342460e-01f, 8.39853436e-02f, -1.58016741e-01f, -5.39647117e-02f, -3.44965428e-01f, -2.39821211e-01f,
  -1.85613975e-01f, -7.23336115e-02f, -1.93323001e-01f, -1.40813857e-01f, 1.61445960e-01f, 7.91941285e-02f, -3.85480351e-03f, -6.59564957e-02f, 5.96722104e-02f, -9.99358073e-02f,
  9.16194916e-02f, 1.04385123e-01f, 1.64425924e-01f, 4.12933752e-02f, 6.68951273e-02f, -4.95505482e-02f, 2.17414364e-01f, -1.19682267e-01f, 1.70059819e-02f, -8.55620950e-02f,
  -3.32550555e-02f, -1.54894710e-01f, 4.06017490e-02f, -2.50469148e-02f, 7.22726434e-02f, -1.86902490e-02f, 5.90282641e-02f, -4.78648581e-02f, 3.43885086e-02f, -2.25158200e-01f,
  3.35959136e-01f, 9.39754024e-02f, -1.67941853e-01f, -2.07934752e-01f, -1.12326834e-02f, -6.67192489e-02f, -8.74852389e-02f, 1.86178889e-02f, 7.76095465e-02f, -1.77055687e-01f,
  -6.32383153e-02f, -2.14816108e-01f, 3.57977152e-02f, -5.36860563e-02f, 3.19212675e-02f, -1.43382937e-01f, -7.94352815e-02f, 1.14685996e-02f, 3.88333723e-02f, 6.58508167e-02f,
  9.92738605e-02f, -1.65844306e-01f, -1.26239255e-01f, -2.24681854e-01f, 2.92375945e-02f, -1.05112433e-01f, -1.27763808e-01f, -1.54817268e-01f, -1.94232270e-01f, -3.10111284e-01f,
  1.09368384e-01f, 1.77070156e-01f, -1.75567474e-02f, 4.93335664e-01f, 2.70922631e-01f, -5.97961769e-02f, -1.83780983e-01f, -2.55216062e-01f, -5.45692667e-02f, 1.15473174e-01f,
  9.39514190e-02f, 2.62931764e-01f, 3.02315019e-02f, 2.61468776e-02f, -3.04450423e-01f, 2.43809018e-02f, 2.20876947e-01f, -8.06691349e-02f, -1.69726551e-01f, 6.68664053e-02f,
  4.16848123e-01f, 1.07158497e-01f, -1.96616307e-01f, -6.72134534e-02f, 2.99155146e-01f, 1.95804000e-01f, -1.55595049e-01f, 3.65123898e-02f, -2.85181161e-02f, 5.65780699e-01f,
  2.89180309e-01f, 1.40142694e-01f, -9.66541991e-02f, -3.32095381e-03f, -1.09330937e-02f, -5.81336357e-02f, 4.61369827e-02f, -4.26417496e-03f, 3.14166285e-02f, 3.89245898e-02f,
  1.60352990e-01f, 9.00433809e-02f, 3.50025599e-03f, -4.15062048e-02f, 2.26784050e-02f, 6.70171008e-02f, -1.75483637e-02f, -1.16548419e-01f, -3.96652743e-02f, 5.16357198e-02f,
  2.84899592e-01f, 1.89952701e-01f, -4.42259125e-02f, -1.15351714e-01f, -1.52989179e-01f, -1.28649995e-01f, -1.37737766e-01f, 5.10272346e-02f, -1.48671299e-01f, 1.49532005e-01f,
  1.56845376e-02f, -8.09003413e-02f, 2.84435377e-02f, 6.33596862e-03f, 7.69762173e-02f, 9.70999375e-02f, 1.91531524e-01f, -1.30339544e-02f, -9.44291204e-02f, 6.49325401e-02f,
  -2.07221514e-04f, -1.66667193e-01f, -2.59105060e-02f, 1.46628143e-02f, 1.71620548e-01f, 5.88083565e-02f, 1.04518972e-01f, -3.36293317e-02f, 6.11251369e-02f, -8.51828456e-02f,
  2.76895277e-02f, -1.09237932e-01f, -5.26481681e-02f, -2.86262501e-02f, -9.58892331e-02f, 4.73294780e-02f, 8.82042870e-02f, 7.75276497e-02f, 1.59952361e-02f, 5.79771623e-02f,
  -3.15433234e-01f, -3.23638350e-01f, 8.28578472e-02f, -1.16616495e-01f, 1.21479347e-01f, -1.09950472e-02f, 1.03268728e-01f, -3.32101621e-02f, -8.68381113e-02f, -3.59829776e-02f,
  -7.62287877e-04f, 2.20332481e-02f, -1.47787914e-01f, -9.20854434e-02f, -1.77202877e-02f, -5.78569286e-02f, 7.82894865e-02f, 8.64081308e-02f, -2.05489084e-01f, -1.16538918e-02f,
  2.62154937e-02f, 2.18792018e-02f, -9.51223671e-02f, -3.40991355e-02f, -1.62579976e-02f, -9.48674232e-02f, -3.01110268e-01f, -2.33699784e-01f, -2.44602457e-01f, -1.95652008e-01f,
  -8.24530780e-01f, 3.62081051e-01f, 2.84102648e-01f, -2.48615518e-01f, 2.45167539e-01f, 3.01896155e-01f, 3.78301442e-01f, 4.20114771e-02f, -1.04189001e-01f, -4.65857238e-02f,
  2.78575718e-01f, -1.41262248e-01f, -3.65745537e-02f, -9.76271182e-03f, 7.19386665e-03f, 2.14888245e-01f, 8.12281668e-02f, -2.48825356e-01f, -2.82442957e-01f, 2.25117639e-01f,
  1.85199827e-01f, -4.18423444e-01f, -5.63937008e-01f, -1.24348037e-01f, -1.72981799e-01f, -2.56749660e-01f, 1.19965643e-01f, -6.86782748e-02f, 5.83093390e-02f, -3.47893327e-01f,
  -2.33122017e-02f, 8.03019479e-02f, -3.14981900e-02f, -2.87895054e-01f, -3.61422822e-02f, -1.13516666e-01f, -7.09450170e-02f, -7.22936075e-03f, 2.82318890e-03f, -1.00738458e-01f,
  -3.87485176e-02f, 9.17132199e-03f, -3.18305823e-03f, -3.51705737e-02f, -8.99800360e-02f, -2.21129302e-02f, -2.44274512e-01f, -1.03327960e-01f, -5.37945665e-02f, -1.77555496e-03f,
  3.33349794e-01f, 2.43510500e-01f, -1.98946983e-01f, 1.79309338e-01f, 9.31405127e-02f, -3.96559894e-01f, -3.00332382e-02f, -1.60149097e-01f, -1.88316151e-01f, -7.16851592e-01f,
  -8.66257325e-02f, -4.86799004e-03f, 5.14636338e-02f, -5.38951792e-02f, -1.38791054e-01f, 1.00636669e-01f, 4.36507612e-02f, -4.21218164e-02f, -8.53911787e-02f, -2.41544783e-01f,
  8.60117301e-02f, -8.49782750e-02f, -1.42118819e-02f, 9.89525672e-03f, -7.43738934e-02f, 1.48013443e-01f, 6.22418299e-02f, -9.61319506e-02f, -1.15040950e-02f, -1.51473671e-01f,
  -8.15220028e-02f, 9.47937462e-03f, 2.95944847e-02f, 8.96519795e-03f, -2.29103956e-02f, -6.24985062e-03f, -1.79440659e-02f, 1.05880886e-01f, 6.88784348e-04f, -2.16682479e-02f,
  -2.74930626e-01f, 2.32120678e-01f, -2.47780755e-01f, 1.42581612e-01f, 1.26374990e-01f, -9.16514620e-02f, 5.16863503e-02f, -6.02915175e-02f, 1.50904074e-01f, 2.35046092e-02f,
  6.83745295e-02f, -6.18178323e-02f, 7.47475252e-02f, 1.65369567e-02f, -2.13826224e-01f, -1.24630034e-01f, -1.18285216e-01f, -6.59868419e-02f, 1.38354465e-01f, -1.69954106e-01f,
  7.47456327e-02f, -2.39310518e-01f, -5.82009315e-01f, -1.46005154e-01f, -1.46032661e-01f, -3.55950266e-01f, -2.13245183e-01f, -2.57097244e-01f, -3.33363026e-01f, -7.63476849e-01f,
  1.23804533e+00f, 3.03771589e-02f, -8.64752710e-01f, 4.46781099e-01f, -1.76158056e-01f, -2.93042243e-01f, -6.15046501e-01f, 1.46154583e-01f, 4.61556047e-01f, -4.14303601e-01f,
  -1.40638530e-01f, 2.01931641e-01f, 1.38354041e-02f, -2.29817331e-01f, -3.18160921e-01f, -6.86593115e-01f, -4.89161223e-01f, -2.73358792e-01f, -3.57185185e-01f, -3.88908803e-01f,
  -1.55677974e-01f, -2.87373289e-02f, 2.41797626e-01f, 1.24151483e-02f, -1.56411201e-01f, 1.80314686e-02f, -5.17615974e-01f, -2.41223842e-01f, -4.81136411e-01f, -4.36922014e-01f,
  -7.04567909e-01f, 2.98182905e-01f, -2.97334731e-01f, 2.77616888e-01f, -7.36521184e-02f, 1.89000800e-01f, -5.83377630e-02f, 7.54138082e-02f, 1.76153377e-01f, -2.28041679e-01f,
  1.23384610e-01f, 1.04602361e-02f, 7.99738839e-02f, -3.04804798e-02f, -2.09881127e-01f, 5.60355373e-02f, -3.28956433e-02f, -3.62658277e-02f, -1.83458418e-01f, -1.95576563e-01f,
  5.81486337e-02f, 1.48402140e-01f, 1.26964137e-01f, -1.89839691e-01f, -2.66026765e-01f, -1.24251254e-01f, -4.54948753e-01f, -1.96381137e-01f, -4.70750064e-01f, -1.01556465e-01f,
  -1.41044348e-01f, -7.03142062e-02f, -1.11543566e-01f, -5.29705510e-02f, 2.48229480e-03f, 1.40783370e-01f, 6.20831884e-02f, -1.43350139e-01f, -3.77901085e-02f, 9.47018936e-02f,
  -2.45353598e-02f, -1.58227578e-01f, -2.55952105e-02f, 1.38244703e-01f, -1.57904983e-01f, 5.14247641e-02f, 9.37177688e-02f, -1.84139952e-01f, -3.25899422e-02f, 4.99710590e-02f,
  3.14041488e-02f, -1.13483116e-01f, 7.91847184e-02f, -2.56611165e-02f, 1.69992030e-01f, -2.29171221e-03f, 2.11349945e-03f, -8.41485243e-03f, -2.29938067e-02f, 8.47347379e-02f,
  6.34744111e-03f, -7.22993463e-02f, 4.01820429e-02f, -1.12362094e-02f, 6.67621731e-04f, 1.51358172e-01f, 1.10809892e-01f, -2.10752711e-02f, 2.13133112e-01f, -6.24202285e-03f,
  -4.99701686e-02f, 1.55696765e-01f, -8.28700662e-02f, 2.91121360e-02f, -5.21571077e-02f, 7.45860487e-02f, 7.22314492e-02f, 1.66752636e-01f, -1.62955791e-01f, -4.49949279e-02f,
  -9.80631635e-02f, 1.10188842e-01f, 2.09081560e-01f, 1.37732834e-01f, 3.70236710e-02f, 3.64590622e-02f, -1.49012357e-01f, 6.76359236e-02f, 1.87987417e-01f, 4.39132266e-02f,
  -8.52230251e-01f, -2.02642500e-01f, -3.79787326e-01f, 1.01780795e-01f, 2.33106688e-01f, 2.12205630e-02f, 2.09791213e-01f, 6.74861446e-02f, -3.69906761e-02f, -4.56475690e-02f,
  -7.98192546e-02f, 2.08516438e-02f, -1.85424641e-01f, 7.84226432e-02f, 2.82436647e-02f, 9.67562273e-02f, 2.35265121e-01f, -2.02308431e-01f, -3.57841760e-01f, 1.47657961e-01f,
  5.33923566e-01f, -4.54621799e-02f, -1.02237068e-01f, 9.74516198e-02f, 1.87264681e-01f, -3.28658484e-02f, -2.03574020e-02f, 1.80989668e-01f, 1.97315618e-01f, 4.75387841e-01f,
  -2.36237437e-01f, -2.56711394e-01f, -6.47509471e-02f, 6.42656758e-02f, -8.88421088e-02f, -1.44129589e-01f, -1.78420439e-01f, -1.65970325e-01f, 1.42211281e-02f, 7.21996948e-02f,
  7.66864195e-02f, -1.24688923e-01f, 1.26987156e-02f, 8.35852847e-02f, -4.16490100e-02f, -7.66952382e-03f, 1.05700873e-01f, -5.61385229e-02f, -6.99875429e-02f, -2.30427403e-02f,
  3.39687109e-01f, 2.76754618e-01f, 6.20009042e-02f, 1.49851903e-01f, 6.90973699e-02f, -3.35542783e-02f, -2.34690998e-02f, 1.59748673e-01f, -5.83661199e-02f, 4.30020951e-02f,
  5.39547354e-02f, 8.08938686e-03f, -6.16729520e-02f, -1.15465246e-01f, 1.49688482e-01f, -4.14211564e-02f, -1.94445662e-02f, -3.92094590e-02f, 1.03826910e-01f, -1.67253673e-01f,
  -6.75489604e-02f, -2.03976274e-01f, -6.45076036e-02f, -1.07293479e-01f, 5.30058444e-02f, -4.90193851e-02f, 1.69856902e-02f, -2.00674590e-02f, 1.53026909e-01f, 4.98918295e-02f,
  -6.04244471e-02f, 9.21500549e-02f, 4.07898799e-02f, 8.21322352e-02f, 1.13887280e-01f, -1.48990378e-01f, 2.90437546e-02f, -2.39520222e-02f, -1.39256746e-01f, 1.40843034e-01f,
  -3.18867832e-01f, -2.14120284e-01f, -1.35488987e-01f, -4.25518267e-02f, -1.59936473e-02f, 3.52183990e-02f, -1.28238440e-01f, -9.00194347e-02f, -7.84719139e-02f, 3.08616124e-02f,
  -1.28519060e-02f, -1.19943805e-01f, -1.08316571e-01f, -5.18207513e-02f, -6.43168241e-02f, -7.38122910e-02f, 2.58099753e-02f, 5.09644635e-02f, 1.41014278e-01f, 9.49843451e-02f,
  1.15938075e-01f, 1.39872611e-01f, -1.38249055e-01f, -1.05875291e-01f, 6.91756606e-02f, -5.64575158e-02f, -1.63951516e-01f, -3.53407525e-02f, -2.36235902e-01f, -1.98676005e-01f,
  2.64057398e-01f, -4.89183292e-02f, 6.33616686e-01f, -1.05149917e-01f, 2.18796536e-01f, 1.38839677e-01f, 4.49738830e-01f, 4.92882393e-02f, -1.66764468e-01f, 3.96686308e-02f,
  -7.14089721e-02f, -5.51588655e-01f, -3.81926715e-01f, -2.63039798e-01f, 1.24524623e-01f, 2.32375920e-01f, 2.30849266e-01f, 2.87235469e-01f, 2.16345951e-01f, 4.20550164e-03f,
  -3.90449494e-01f, 1.63064659e-01f, 2.85632998e-01f, 6.38608485e-02f, -2.94087023e-01f, -1.23594105e-01f, 4.24091876e-01f, 9.60191265e-02f, 8.54100361e-02f, -3.32816392e-01f,
  2.81702280e-02f, 2.02268779e-01f, -1.33516015e-02f, -3.46907042e-02f, 6.40564337e-02f, -1.10868394e-01f, 2.99834125e-02f, -6.89211711e-02f, -1.18491352e-01f, -2.03593224e-01f,
  -5.74432537e-02f, -8.74215811e-02f, -5.45553714e-02f, -5.16203903e-02f, -1.41461231e-02f, 4.90606986e-02f, 1.14808522e-01f, 1.48502961e-01f, -2.41806768e-02f, -1.19088829e-01f,
  -3.61764997e-01f, -1.91908013e-02f, 1.51408181e-01f, -2.58553177e-02f, 8.51133764e-02f, 8.29606131e-02f, 2.01999798e-01f, -1.32298812e-01f, 1.42000258e-01f, -2.05064565e-01f,
  -1.17508499e-02f, 2.14446820e-02f, 5.88128865e-02f, -8.05449635e-02f, 4.13166769e-02f, 8.10181256e-03f, 2.86906790e-02f, 8.72210599e-03f, 4.23836224e-02f, 8.99203941e-02f,
  -1.05533704e-01f, 1.03618115e-01f, -1.41947255e-01f, -4.94361855e-02f, -3.57059464e-02f, 7.88436383e-02f, 2.27643400e-02f, -4.47622873e-02f, 1.93100758e-02f, 3.96797322e-02f,
  -2.15929840e-02f, 1.97867490e-02f, -7.34834522e-02f, -3.65363806e-02f, 6.04491271e-02f, 5.10544069e-02f, -4.00766581e-02f, -7.63149187e-02f, -3.03520691e-02f, -9.46633443e-02f,
  -4.59308296e-01f, 6.94882497e-02f, -1.85113072e-01f, -3.51242498e-02f, 1.89464036e-02f, 1.81922227e-01f, -1.44255941e-03f, 7.58794099e-02f, -1.78321339e-02f, -4.64889705e-02f,
  -1.14121642e-02f, -2.30716273e-01f, -9.36445314e-04f, -6.11914657e-02f, -6.21940717e-02f, 2.02811174e-02f, 5.50427241e-03f, -7.65565783e-02f, 3.37100513e-02f, 1.13128282e-01f,
  1.24345394e-02f, -3.63840163e-02f, -1.23014726e-01f, -5.07014282e-02f, -2.56870031e-01f, -1.21029243e-01f, -3.13271359e-02f, -4.04925086e-02f, 1.42769590e-01f, -6.06674701e-02f,
  1.21884191e+00f, 5.63400090e-01f, -5.41878305e-02f, 3.92031461e-01f, 2.31859982e-01f, 3.51167113e-01f, 3.70810717e-01f, 2.56350875e-01f, 1.33228689e-01f, 3.09315890e-01f,
  1.63332000e-01f, 1.37135968e-01f, 3.43830585e-01f, 3.06393325e-01f, 3.00754666e-01f, 2.05223382e-01f, 7.90506229e-02f, -1.14877503e-02f, 1.91961210e-02f, 9.40180570e-02f,
  1.59684405e-01f, 3.88301164e-03f, -2.70876605e-02f, 4.79957238e-02f, -6.16098642e-02f, 5.18936887e-02f, -9.34303179e-02f, -2.51579657e-03f, -1.30248263e-01f, -2.42337689e-01f,
  -4.33988035e-01f, 4.50328201e-01f, 5.76930605e-02f, 1.30450651e-01f, -3.64423506e-02f, -1.16217650e-01f, -5.89380488e-02f, -7.52773508e-02f, -1.71633228e-03f, -1.38280034e-01f,
  -2.98264116e-01f, -2.05146167e-02f, 7.00355321e-03f, -1.35221437e-01f, -8.54695514e-02f, -4.48881164e-02f, 1.46913648e-01f, 1.10598793e-02f, 4.13678167e-03f, -1.13910601e-01f,
  -5.69286617e-03f, -1.29434569e-02f, -7.20730573e-02f, 3.94161306e-02f, 2.67393216e-02f, 5.25531620e-02f, 5.31229638e-02f, -6.06645495e-02f, 4.02096957e-02f, 1.52403742e-01f,
  3.13769691e-02f, 3.82780842e-02f, 1.22072123e-01f, 2.49392495e-01f, 1.92451432e-01f, -8.68332461e-02f, -3.78946550e-02f, -1.69822760e-02f, 4.34948914e-02f, -5.54461256e-02f,
  6.29583150e-02f, 3.55524234e-02f, -1.14102378e-01f, 4.61441837e-02f, 4.76414822e-02f, -7.37547725e-02f, -5.66179417e-02f, -4.26788256e-02f, 6.45870790e-02f, -1.51553452e-02f,
  4.80564423e-02f, -2.54660755e-01f, -8.49944875e-02f, 2.87144165e-02f, 2.93087661e-02f, 1.49239078e-01f, -5.15636131e-02f, -6.60785148e-03f, 4.49318960e-02f, 1.14692517e-01f,
  -3.37952048e-01f, 1.67032808e-01f, 1.00950532e-01f, -1.12546265e-01f, -2.25632921e-01f, -8.80081132e-02f, 1.22950397e-01f, -3.72801125e-02f, -2.82738000e-01f, -1.44354641e-01f,
  -1.85612068e-01f, -6.04868792e-02f, 9.12939981e-02f, -1.17980517e-01f, -1.11818470e-01f, -1.43608868e-01f, -2.23000441e-02f, 1.20361306e-01f, -5.79269370e-03f, -1.94562256e-01f,
  7.82575235e-02f, -9.07769948e-02f, -1.00740239e-01f, 1.85880102e-02f, -1.25813246e-01f, 7.24502876e-02f, -1.30706340e-01f, -1.86683416e-01f, -8.36769640e-02f, 1.15963556e-01f,
  -6.28737882e-02f, 9.31366161e-02f, -5.20429850e-01f, 1.21237978e-01f, -3.87196511e-01f, -3.98099720e-01f, -4.72005576e-01f, 3.08801591e-01f, 4.97618735e-01f, -2.47810051e-01f,
  -1.07188798e-01f, 1.03670456e-01f, -4.36362475e-02f, -3.24177712e-01f, -3.55693191e-01f, -3.57072413e-01f, -1.94856673e-01f, -5.75716138e-01f, -4.50060159e-01f, -1.64270222e-01f,
  -4.24391091e-01f, -6.13758445e-01f, -2.27038011e-01f, 1.03763387e-01f, -5.57133220e-02f, -7.01301768e-02f, 4.17550690e-02f, -1.44702762e-01f, -1.32466629e-01f, -3.58069181e-01f,
  -5.42539060e-01f, 3.06244902e-02f, -1.58973798e-01f, -1.99905802e-02f, -1.62046909e-01f, 9.48323533e-02f, -6.31958619e-02f, 1.00456454e-01f, 2.42068231e-01f, 1.61801010e-01f,
  4.49619181e-02f, 1.28307730e-01f, -3.41435112e-02f, -7.57397264e-02f, -1.47135377e-01f, -1.30641907e-01f, 2.72349805e-01f, 4.87546809e-02f, 8.30016732e-02f, 1.96313947e-01f,
  1.84798278e-02f, 2.79280636e-02f, 5.85368648e-02f, 3.19292873e-01f, 9.65177789e-02f, -9.71259251e-02f, 1.31510288e-01f, 2.77460814e-01f, 2.68266857e-01f, 2.60965824e-01f,
  -1.64524809e-01f, 4.51097898e-02f, 6.52189483e-04f, 4.43524048e-02f, 1.13295007e-03f, 1.70069799e-01f, 4.75411154e-02f, -3.84591036e-02f, -3.46747749e-02f, -7.36310706e-02f,
  7.90968314e-02f, 1.27939984e-01f, 1.12694521e-02f, -3.43687125e-02f, 1.43351881e-02f, -4.66825031e-02f, -4.19835299e-02f, 1.18844792e-01f, 4.44916822e-02f, -9.21647064e-03f,
  -5.86886927e-02f, 1.29594281e-01f, -4.38910238e-02f, -4.11626250e-02f, -2.74011083e-02f, 1.22380042e-02f, 5.72775602e-02f, 7.63613582e-02f, 1.18494127e-02f, 4.05600853e-02f,
  2.88768917e-01f, -1.90826312e-01f, -1.17719278e-01f, 5.85834049e-02f, 1.52642369e-01f, 8.59374106e-02f, 3.30443168e-03f, 1.07118510e-01f, -8.18745792e-02f, 9.38369951e-04f,
  3.10159232e-02f, 6.36434928e-02f, -1.94751114e-01f, -2.54892372e-02f, -7.49685541e-02f, -4.75222692e-02f, 1.36086285e-01f, -4.69097383e-02f, 8.65579098e-02f, 2.25428455e-02f,
  1.65451378e-01f, -1.26535762e-02f, -3.63675244e-02f, 1.61393404e-01f, -3.53483446e-02f, -1.68477446e-01f, -7.58757219e-02f, 1.89028848e-02f, -8.35008994e-02f, 1.58961475e-01f,
  8.58028829e-01f, 2.58876652e-01f, 5.54890335e-01f, -4.48745042e-02f, -4.14688170e-01f, -3.46517801e-01f, -1.45359889e-01f, -2.15337217e-01f, -3.44300717e-01f, 6.15290739e-02f,
  -2.29086615e-02f, -3.31523836e-01f, -1.47346660e-01f, -1.12989798e-01f, 1.89622387e-01f, -5.40178232e-02f, 8.43948051e-02f, 4.27885652e-01f, -9.13217664e-02f, -2.24185318e-01f,
  -1.79057091e-01f, 2.66286612e-01f, 4.37355548e-01f, 7.27119222e-02f, -1.22087941e-01f, -2.83855319e-01f, -6.10596426e-02f, 1.43761083e-01f, -1.84403453e-02f, 3.00971001e-01f,
  2.28699625e-01f, 2.99619019e-01f, -3.02372068e-01f, -2.22055435e-01f, 7.56894872e-02f, 1.14466354e-01f, -6.69195950e-02f, 2.98312724e-01f, 1.33999484e-02f, 8.73375908e-02f,
  3.81040834e-02f, 7.89733827e-02f, 1.27302706e-01f, -5.31381443e-02f, 4.74604070e-02f, -1.52787089e-01f, 1.09325536e-01f, 2.19465822e-01f, 1.97897851e-01f, -1.76788941e-02f,
  -1.49829751e-02f, 6.12252578e-02f, 1.35514930e-01f, -1.96357906e-01f, -9.39179771e-03f, 5.79034723e-02f, 1.46186408e-02f, 1.68865733e-02f, 1.56450775e-02f, 6.99100411e-03f,
  -1.39688432e-01f, 5.30575737e-02f, -4.91106557e-03f, 4.68655638e-02f, 2.01713201e-02f, 1.44189131e-02f, 1.11323288e-02f, -1.25449030e-02f, -1.14632756e-01f, 1.19344026e-01f,
  -1.13112964e-01f, 3.47641706e-02f, -7.25822225e-02f, 6.73473924e-02f, 9.27746817e-02f, 1.44616356e-02f, -7.57598281e-02f, 1.77960187e-01f, 3.09375077e-02f, -4.87237759e-02f,
  -1.72465425e-02f, 1.69917904e-02f, -1.22361816e-02f, 1.98466659e-01f, 3.69743109e-02f, 8.77501518e-02f, -8.76971409e-02f, -5.84507510e-02f, 7.13471621e-02f, 1.10323511e-01f,
  -3.85199219e-01f, -1.75231621e-01f, -2.70234466e-01f, -9.36824307e-02f, 1.07054509e-01f, -1.29999563e-01f, 4.52691615e-02f, 1.36612847e-01f, 1.87130556e-01f, 7.53820613e-02f,
  -5.36261126e-03f, 4.74913344e-02f, 1.96265385e-01f, -8.29044804e-02f, -5.34562096e-02f, -4.15803976e-02f, -5.78584895e-03f, -1.33291662e-01f, 3.08822766e-02f, 5.17471088e-03f,
  1.05861969e-01f, -1.95388913e-01f, -4.23473597e-01f, -2.19659761e-01f, -2.54614651e-01f, -3.52258652e-01f, -2.19332099e-01f, -2.16176748e-01f, -3.27145427e-01f, -2.74048507e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  8.73810127e-02f, 4.37673360e-01f, 4.47952807e-01f, 3.72237295e-01f, -2.74467349e-01f, 7.06395328e-01f, 3.84636149e-02f, 2.16198042e-01f, 5.32137930e-01f, 3.43817705e-03f,
  5.30082583e-01f, 6.51090860e-01f, 5.20929754e-01f, 5.92475772e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.08626345e-01f, 6.17401302e-02f, -1.12176254e-01f, -2.12686390e-01f, -4.24321592e-02f, -2.25828514e-01f, 2.08718628e-01f, 2.62255222e-01f, 1.55191058e-02f, 2.84251124e-01f,
  -2.05246493e-01f, 4.41101372e-01f, -2.06642836e-01f, 8.63171741e-02f, 1.48570478e-01f, -3.66517544e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -5.97827017e-01f, -7.52156377e-01f, -1.82071224e-01f, -1.22634694e-01f, 5.07177532e-01f, -1.64979473e-01f, 4.91785377e-01f, 3.64405036e-01f, 3.90815288e-01f, 9.08654034e-02f,
  6.11778140e-01f, 8.90483037e-02f, -4.55271065e-01f, 3.82134706e-01f, 9.79791507e-02f, -3.08509946e-01f, 7.12732412e-03f, -2.15320230e-01f, 2.94438422e-01f, -1.33458609e-02f,
  5.90809345e-01f, 7.00884283e-01f, -3.27719569e-01f, 3.08681965e-01f, 3.06526929e-01f, 7.12040300e-03f, 3.57456177e-01f, -2.64082253e-01f, 1.06625128e+00f, 3.23419690e-01f,
  -2.33120933e-01f, 5.59476495e-01f, 3.37723374e-01f, -8.81020799e-02f, -2.42670223e-01f, -1.96455345e-01f, 4.18353796e-01f, 5.72657108e-01f, -1.89584821e-01f, 4.77565974e-01f,
  9.67266038e-02f, -3.79340649e-01f, 5.83236158e-01f, -4.21351731e-01f, -7.88303465e-03f, -2.37703532e-01f, 1.08029437e-03f, 4.98113394e-01f, 1.26799572e+00f, 7.95154214e-01f,
  1.25574723e-01f, -3.19794327e-01f, -4.28495370e-02f, -4.52753335e-01f, 2.76727110e-01f, -2.82938808e-01f, -4.92284745e-01f, 7.31687903e-01f, 1.84475541e-01f, -1.15670180e-02f,
  3.82873446e-01f, 8.82650763e-02f, 2.48178677e-03f, 7.56862834e-02f, 1.73532099e-01f, 2.07206473e-01f, -2.72506982e-01f, -2.06483617e-01f, 3.20609152e-01f, 2.94349521e-01f,
  4.72708076e-01f, 6.58290446e-01f, 1.36019647e-01f, 1.05843616e+00f, 4.56205547e-01f, 4.74366158e-01f, 4.65376705e-01f, 3.48015696e-01f, 4.16158378e-01f, 4.26889986e-01f,
  5.27202845e-01f, -4.40900289e-02f, -3.21207553e-01f, -2.65944630e-01f, 2.52566993e-01f, -3.53605683e-05f, 1.55629203e-01f, 8.04449558e-01f, 3.65922451e-01f, 2.05823723e-02f,
  8.12912881e-01f, -3.73756625e-02f, -4.35444504e-01f, 1.04541853e-01f, 5.28884768e-01f, -7.56364167e-02f, 1.89485148e-01f, 7.09681883e-02f, 7.29885161e-01f, 1.59546092e-01f,
  -9.16384310e-02f, 9.17615667e-02f, 1.37942329e-01f, -2.72715032e-01f, 2.53910441e-02f, 3.13591242e-01f, -4.02498245e-02f, 5.44245951e-02f, 7.07429945e-01f, 4.27585512e-01f,
  1.83192864e-01f, 4.52549428e-01f, 7.47381210e-01f, 7.07378030e-01f, -7.10990906e-01f, -2.35675886e-01f, 1.62935033e-02f, 4.64896679e-01f, -6.34138525e-01f, 4.36675251e-01f,
  3.95008594e-01f, 2.76517384e-02f, -2.86989480e-01f, 1.29223153e-01f, -1.12293683e-01f, -2.09077090e-01f, -5.77043235e-01f, 6.94550157e-01f, -1.91198736e-01f, 8.96584034e-01f,
  -4.76979882e-01f, -3.28688860e-01f, 2.23257154e-01f, -4.24881428e-02f, -7.10670769e-01f, 1.11391172e-01f, 5.63534737e-01f, 1.06559619e-01f, 1.28734514e-01f, 4.86390471e-01f,
  -3.70720148e-01f, -8.31784159e-02f, -1.10771477e-01f, 1.34980589e-01f, -2.23548070e-01f, 1.49563313e-01f, 6.87947124e-02f, 4.25142854e-01f, 5.29300213e-01f, 4.22551721e-01f,
  -3.74978393e-01f, 1.64527401e-01f, 2.38405690e-01f, 4.09373045e-02f, 3.40372294e-01f, 1.59823969e-01f, -9.41867605e-02f, 3.34467858e-01f, 5.81818968e-02f, 4.91842955e-01f,
  1.06747186e+00f, 6.50999129e-01f, 3.02160323e-01f, -3.57692987e-01f, 2.07164004e-01f, 1.42261907e-01f, 1.69073213e-02f, 4.73581925e-02f, -2.15909079e-01f, 4.84090537e-01f,
  -3.18327174e-02f, 3.33453506e-01f, 8.53018820e-01f, -1.29618630e-01f, 2.72070438e-01f, 2.51259506e-01f, -5.78639030e-01f, -3.63863915e-01f, -1.27739400e-01f, -8.74918848e-02f,
  1.34102955e-01f, -2.81021744e-01f, 3.67228150e-01f, 2.65477687e-01f, 2.69754469e-01f, 6.09600127e-01f, 1.96115047e-01f, 3.72492224e-01f, -3.20828170e-01f, 4.19010311e-01f,
  4.10169423e-01f, -3.58509749e-01f, 1.40064359e+00f, -2.71143407e-01f, 3.86233479e-01f, -7.57820010e-01f, 5.56606986e-02f, -1.31808847e-01f, -2.13833556e-01f, 4.16084677e-01f,
  -2.34794140e-01f, -1.91604033e-01f, 8.59033912e-02f, -3.71125370e-01f, 5.64634800e-01f, 1.17107838e-01f, 1.66431502e-01f, -1.88210517e-01f, 6.55166581e-02f, -2.33601242e-01f,
  3.94542038e-01f, -6.18638359e-02f, 3.33929271e-01f, -1.86968595e-01f, 6.85324520e-02f, 4.89813834e-02f, 1.71448812e-01f, -2.29190111e-01f, 5.94530821e-01f, -1.43973127e-01f,
  -2.68491596e-01f, 4.48455274e-01f, 7.69578040e-01f, -5.83168507e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.65003704e-02f, 3.87361377e-01f, 3.68691981e-01f, 9.57876295e-02f, 8.48785713e-02f, 9.31385636e-01f, -2.23130465e-01f, 3.88415307e-01f, -6.07447848e-02f, 2.22013235e-01f,
  5.00757992e-01f, -3.42955776e-02f, 1.83486179e-01f, 3.66238147e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.52997315e-01f, -4.61207807e-01f, -3.01310182e-01f, -2.08722297e-02f, -1.21641323e-01f, 1.29755437e-01f, 1.10827155e-01f, -3.99027728e-02f, 2.25059465e-01f, -3.21934849e-01f,
  -2.72282422e-01f, 3.51855338e-01f, 5.98773472e-02f, -9.12370011e-02f, 5.31947851e-01f, -1.04185060e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.31866693e+00f, -6.01424992e-01f, 6.36157990e-02f, 1.58179119e-01f, 9.78957713e-01f, -3.23039860e-01f, -2.01743826e-01f, 5.01614571e-01f, -4.37884450e-01f, 5.63237011e-01f,
  1.25894025e-01f, 1.07421003e-01f, 2.15451822e-01f, -1.21343240e-01f, 9.63648915e-01f, 4.66485113e-01f, 6.14211082e-01f, 1.32155228e+00f, 5.33338606e-01f, -3.37122917e-01f,
  -1.20219812e-01f, 5.84996045e-01f, 4.72179234e-01f, 9.13664758e-01f, -5.96022487e-01f, -6.47969320e-02f, 9.21099544e-01f, -1.63700834e-01f, 4.30850506e-01f, 6.90580904e-01f,
  2.98748910e-02f, 2.45599244e-02f, -9.48837638e-01f, 3.10970098e-01f, -9.04667377e-02f, -2.38816619e-01f, -6.23455048e-01f, 5.09258926e-01f, 2.81543195e-01f, 2.23433286e-01f,
  1.85094193e-01f, -2.41811723e-01f, 2.01946676e-01f, -5.32814264e-02f, 6.33623660e-01f, 3.17797095e-01f, -2.56308466e-01f, -5.07736998e-03f, -2.12208390e-01f, -6.30334437e-01f,
  3.62589687e-01f, 1.06184825e-01f, 2.36496240e-01f, -4.61461008e-01f, 1.04192533e-01f, 4.49409366e-01f, -3.63609940e-01f, 6.08492136e-01f, 7.73391962e-01f, 2.59903282e-01f,
  -2.35696450e-01f, 2.47351781e-01f, -4.92743433e-01f, -7.16770217e-02f, -9.25010264e-01f, -4.55795765e-01f, 3.83573771e-01f, 6.09141476e-02f, 2.79807001e-01f, 3.39117110e-01f,
  4.37486440e-01f, 7.29100034e-02f, -1.31208763e-01f, 2.93933481e-01f, 6.67753577e-01f, 4.18176234e-01f, -6.67414293e-02f, 9.58863795e-02f, -5.55604160e-01f, 5.55333234e-02f,
  -4.45624364e-17f, 2.74829021e-18f, -1.26519170e-13f, -4.09219352e-16f, 4.92608258e-40f, -2.09654609e-15f, -5.44856438e-10f, -1.87436351e-11f, -2.12043539e-15f, 4.94075418e-40f,
  4.92657304e-40f, -1.24159243e-15f, -3.85068831e-26f, -9.12427385e-16f, -2.54069425e-41f, -9.15116714e-16f, -9.87661242e-01f, -7.09942758e-01f, 3.47336799e-01f, 3.65570873e-01f,
  3.04251641e-01f, 1.47015065e-01f, 5.85471570e-01f, 2.15468585e-01f, 1.51527479e-01f, 7.98421577e-02f, 4.03558582e-01f, 3.00258636e-01f, 8.28967895e-03f, 1.06179036e-01f,
  -2.52865702e-01f, -8.44079182e-02f, 1.40683115e-01f, 6.31563902e-01f, 6.25513256e-01f, -3.64185572e-01f, -2.82546788e-01f, 4.03081179e-01f, 2.67953545e-01f, 4.99780208e-01f,
  -2.10114807e-01f, -2.29378149e-01f, -6.24077082e-01f, -6.49690449e-01f, 7.39658624e-02f, 3.36409867e-01f, 1.43825218e-01f, 4.22738105e-01f, -2.18399882e-01f, -6.63461208e-01f,
  6.52293861e-01f, 3.96101147e-01f, 2.41084039e-01f, -5.14379382e-01f, 1.07833393e-01f, 1.91608623e-01f, 1.48492754e-01f, 6.96545660e-01f, 7.72249699e-01f, 1.17089652e-01f,
  -2.56950080e-01f, -4.06522863e-02f, -7.12045491e-01f, 2.16480996e-02f, 1.15227318e+00f, -5.43903470e-01f, 4.42457587e-01f, -2.44634934e-02f, 6.18136048e-01f, -6.60117790e-02f,
  2.51934499e-01f, 7.22287595e-01f, -3.21537316e-01f, 4.55018252e-01f, 1.60809547e-01f, -1.00795813e-01f, -1.84746116e-01f, -6.73384294e-02f, 8.97893131e-01f, 1.73159048e-01f,
  -1.98552862e-01f, -3.71408053e-02f, -2.45671958e-01f, -5.52779078e-01f, 2.70023812e-02f, -1.29174441e-02f, -2.15499327e-01f, -2.82408535e-01f, -1.50677383e-01f, -2.23849807e-03f,
  -4.57038432e-02f, 2.32484221e-01f, -1.37447879e-01f, 1.26863182e-01f, -2.83111725e-03f, 2.41362318e-01f, 2.60114610e-01f, -5.99274516e-01f, -3.43254715e-01f, 3.37887973e-01f,
  1.61742255e-01f, 5.70274234e-01f, 2.31369168e-01f, 9.89692882e-02f, 3.45229059e-01f, -1.52570829e-02f, -6.81909800e-01f, -2.14104697e-01f, 9.75350440e-01f, -4.99436945e-01f,
  9.62234259e-01f, -2.16521218e-01f, -6.44682944e-01f, -9.62981105e-01f, 2.68014640e-01f, 3.89022529e-01f, 5.18704653e-01f, -1.56495064e-01f, 1.36054009e-01f, 1.46338686e-01f,
  -1.29619867e-01f, 7.54083276e-01f, 4.70261842e-01f, 2.17838183e-01f, 9.88234393e-03f, 5.67313693e-02f, -6.58979475e-01f, -2.93730587e-01f, 2.20103804e-02f, 2.07239509e-01f,
  6.23774350e-01f, 2.72365391e-01f, -2.47026086e-01f, 3.68670136e-01f, 2.32817084e-01f, 3.84848952e-01f, 3.32817525e-01f, -8.94566655e-01f, -4.68958229e-01f, -8.06935802e-02f,
  2.34882459e-01f, 8.82812798e-01f, 7.70628273e-01f, 9.80445266e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  6.48600757e-01f, 4.39316511e-01f, -1.88196644e-01f, -2.24064570e-02f, 2.49104321e-01f, 4.22584655e-18f, -5.64625710e-02f, 4.10893820e-02f, 3.43995653e-02f, 5.07885873e-01f,
  9.76101384e-02f, 4.57324386e-01f, 6.43235892e-02f, -2.28930503e-01f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -7.33596802e-01f, -2.36496091e-01f, -4.87013161e-02f, 4.91205305e-02f, 7.87088461e-03f, 2.43469968e-01f, 2.30054349e-01f, -2.88103044e-14f, 1.56744003e-01f, 1.14056900e-01f,
  2.56196521e-02f, -2.84726441e-01f, 4.34000611e-01f, -4.02488977e-01f, -7.63110025e-03f, -8.92001763e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -2.44566295e-02f, -1.53735935e-04f, -1.04613928e-02f, -3.14449221e-02f, -2.56566020e-35f, -5.50219417e-02f, -3.92765552e-02f, 4.97659939e-40f, 5.71690649e-02f, -6.57682680e-03f,
  -1.25535056e-01f, 5.80511522e-04f, -4.92892722e-40f, -2.73212069e-03f, -2.63191890e-02f, -9.46404263e-02f, -2.49057293e-01f, 3.74087766e-02f, 8.94635841e-02f, -4.66015399e-01f,
  -6.08004093e-01f, -2.56479502e-01f, -1.46558091e-01f, -1.32403108e-14f, 2.65597045e-01f, -2.33407486e-02f, 2.09906489e-01f, 4.91825603e-02f, -3.05705428e-01f, -2.20137119e-01f,
  -1.69446871e-01f, 5.70626318e-01f, 7.57139146e-01f, 5.17412126e-01f, 1.04685295e+00f, 3.35770816e-01f, -7.01755285e-01f, -1.99020859e-02f, -3.51144940e-01f, -2.03178078e-25f,
  -5.69531143e-01f, -4.89403643e-02f, -2.50781238e-01f, 9.08621132e-01f, 1.79526210e-01f, 4.73595709e-01f, -2.21308559e-01f, 8.23147371e-02f, -8.93088460e-01f, -7.02076852e-01f,
  3.56183767e-01f, -9.91654024e-02f, -3.58479321e-01f, 4.63556409e-01f, 2.76319087e-02f, -2.32554183e-14f, 4.23963033e-02f, 2.19705433e-01f, 1.34600597e-02f, 3.49022210e-01f,
  6.91363364e-02f, -7.47344673e-01f, -9.94518623e-02f, 2.48814210e-01f, 2.65954554e-01f, 5.94650447e-01f, 8.22260439e-01f, -1.12018764e-01f, -3.47878397e-01f, -3.35799098e-01f,
  -4.63523775e-01f, -4.93115528e-40f, -3.01820397e-01f, -9.62826908e-02f, -3.80157977e-01f, 3.29345584e-01f, -1.06484806e-02f, 6.04830265e-01f, -3.08776379e-01f, -5.83921513e-03f,
  1.07210541e+00f, 9.56803858e-02f, -2.43180051e-01f, 6.13032043e-01f, 2.30975017e-01f, -3.22510481e-01f, 1.53395206e-01f, 2.45104653e-14f, 2.60033846e-01f, 2.95487285e-01f,
  -2.31707811e-01f, 1.64774388e-01f, -3.30006868e-01f, 1.57859847e-01f, -6.29002824e-02f, 3.04372787e-01f, -3.46688747e-01f, -2.05793828e-01f, 7.71910727e-01f, -1.20535698e-02f,
  -3.68263155e-01f, 9.50787008e-01f, 5.51385641e-01f, 9.35751432e-15f, 5.13171673e-01f, -1.96058840e-01f, 7.48946905e-01f, 7.77535737e-01f, 1.40053123e-01f, -4.75996256e-01f,
  8.36062789e-01f, -3.35674882e-01f, -8.78006279e-01f, 5.13670668e-02f, -3.92140478e-01f, 3.56726229e-01f, 6.70892656e-01f, -1.59160778e-01f, 2.62703270e-01f, 1.22017468e-14f,
  2.32237354e-01f, 4.76517648e-01f, -3.11067581e-01f, -4.13076542e-02f, 2.57623076e-01f, 8.61897916e-02f, -1.76881090e-01f, 5.41559935e-01f, -3.65132797e-14f, -1.84215002e-13f,
  -3.40755214e-04f, -4.23896126e-03f, -1.05738633e-04f, -1.35589435e-05f, -1.07246591e-03f, -6.06554843e-40f, -2.28083530e-03f, -1.59598724e-03f, -9.41351100e-05f, -1.48674438e-03f,
  -4.91609132e-40f, -8.40042121e-05f, -8.81360320e-05f, -8.21523555e-03f, -4.29743528e-01f, 5.43687165e-01f, 2.86929697e-01f, -3.33972752e-01f, -1.84793502e-01f, 3.31388772e-01f,
  4.65993762e-01f, 6.97008716e-15f, 5.59096217e-01f, -3.98263991e-01f, 3.18961143e-01f, -1.34036556e-01f, -2.71157920e-01f, 2.12647691e-01f, 3.02543670e-01f, 2.91772842e-01f,
  9.58464324e-01f, 7.25807071e-01f, 3.01731765e-01f, -1.92889720e-01f, 2.19478458e-01f, -4.73522156e-01f, -4.62458469e-02f, 1.27761283e-14f, 1.48902163e-02f, -1.19434811e-01f,
  -4.20869619e-01f, -1.54322395e-02f, -4.28768367e-01f, 9.36051369e-01f, -2.86588401e-01f, 3.60233456e-01f, -4.46727812e-01f, 4.03057128e-01f, 4.21468802e-02f, -7.42290497e-01f,
  1.93518743e-01f, -2.57340223e-01f, 1.11410938e-01f, -1.53692095e-14f, 2.81928867e-01f, -2.93594182e-01f, 2.50822864e-02f, -2.42989421e-01f, -9.11978558e-02f, 7.36189067e-01f,
  1.72896087e-01f, 2.41676390e-01f, 3.92153293e-01f, -4.91477340e-01f, -4.37785462e-02f, 6.63450778e-01f, -1.78989008e-01f, 3.87956649e-01f, 1.18343115e-01f, 7.49996345e-15f,
  -2.82185096e-02f, 2.73446232e-01f, 1.20449826e-01f, -1.45572657e-02f, 3.51108052e-02f, -5.59698522e-01f, -2.45123401e-01f, 4.03753579e-01f, -8.03181529e-01f, 1.70975000e-01f,
  -3.99917036e-01f, 2.10902020e-01f, 1.17017023e-01f, 8.52694511e-02f, 1.69538379e-01f, 5.25522449e-15f, 8.65004808e-02f, 4.11813051e-01f, 4.97769890e-03f, 7.21940920e-02f,
  1.51339039e-01f, -5.14838576e-01f, -1.34575963e-01f, 5.51731408e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  -4.86177355e-02f, 1.68629512e-02f, 5.23259342e-01f, 1.61850415e-02f, 2.30920628e-01f, 3.84116918e-01f, 2.41371974e-01f, -9.17033851e-02f, 2.56556609e-10f, -3.15690339e-01f,
  3.88214111e-01f, -2.80976921e-01f, -1.28974065e-01f, -9.97631326e-02f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -1.04200029e+00f, 1.28828347e-01f, 4.93367762e-40f, -2.53799617e-01f, -5.95368385e-01f, 3.18138421e-01f, -3.46286297e-01f, -1.23654321e-01f, -1.14745766e-01f, 2.52456516e-01f,
  -1.91059802e-03f, -4.07995790e-01f, -1.06172323e+00f, -2.21189499e-01f, 3.18839192e-01f, 2.86161959e-01f, 2.91444033e-01f, 1.01391368e-01f, -6.14268471e-28f, 5.00320971e-01f,
  3.04093827e-02f, 4.94692445e-01f, -1.01888335e+00f, -1.58063740e-01f, 5.34698851e-02f, -4.45103705e-01f, -1.07002983e-04f, -1.16286531e-01f, -6.75190687e-01f, 2.09418923e-01f,
  7.50195310e-02f, -3.71338353e-02f, -8.39302897e-01f, -1.28659215e-02f, 3.37260962e-02f, -4.23315108e-01f, 1.72338679e-01f, -3.16743851e-01f, 1.72881410e-01f, -5.30961931e-01f,
  1.88938275e-01f, -3.73357743e-01f, -1.79259939e-06f, 1.42995894e-01f, -9.94576737e-02f, -1.85744315e-02f, -5.59438348e-01f, -1.91513598e-01f, 1.94412079e-02f, 2.47382864e-01f,
  -4.94315040e-40f, -1.12931144e+00f, -6.96189463e-01f, -7.33056188e-01f, -5.73179452e-03f, 4.57876742e-01f, -1.19303763e+00f, 2.86514133e-01f, 1.22503461e-02f, -4.98367727e-01f,
  9.73274484e-02f, -3.65415335e-01f, 9.46253538e-02f, 2.12765634e-01f, 4.16218638e-01f, 3.66312176e-01f, 4.92917945e-40f, -1.50418626e-02f, -3.21886055e-02f, -2.33659565e-01f,
  -8.08438480e-01f, 3.51569861e-01f, -3.98218572e-01f, 1.85892656e-02f, 3.83535262e-05f, -8.63566920e-02f, -1.23095643e-02f, -6.20452583e-01f, 2.96128720e-01f, -2.50943340e-02f,
  -2.23497435e-01f, 1.99810222e-01f, -4.92597048e-40f, 1.68682009e-01f, 3.26844126e-01f, 2.21836641e-02f, 2.16495946e-01f, -1.23055011e-01f, -1.48966074e-01f, 1.03403047e-01f,
  5.70317556e-04f, -5.67151047e-02f, -1.35491893e-01f, -3.57023358e-01f, -3.05531889e-01f, -1.33781768e-02f, -1.66182831e-01f, -1.46925971e-01f, -1.92445908e-02f, -6.33775234e-01f,
  -1.06654251e+00f, -2.59011328e-01f, -1.03409266e+00f, -1.04536879e+00f, 3.89241904e-01f, -6.62449718e-01f, -4.10159584e-04f, 1.49561673e-01f, -4.11154985e-01f, 3.33655655e-01f,
  -5.20701408e-01f, -7.65197456e-01f, 7.29999483e-01f, 2.75249273e-01f, 4.95117984e-40f, -4.94306266e-01f, -1.39113259e+00f, -3.91549736e-01f, -4.52765614e-01f, 1.45081952e-01f,
  1.98750407e-01f, -8.76983628e-02f, 3.01909680e-03f, 8.58684555e-02f, -1.97719216e-01f, -2.49757379e-01f, 2.58709013e-01f, -4.87122461e-02f, 3.63924168e-02f, -5.54274917e-01f,
  -1.43537135e-12f, 3.46588284e-01f, 4.16442901e-01f, -1.01120138e+00f, 4.62688446e-01f, -6.83725715e-01f, -6.90288603e-01f, -3.71422678e-01f, 1.93418440e-04f, 2.33806968e-01f,
  4.11558449e-01f, 6.68547228e-02f, -2.39524305e-01f, -2.13981435e-01f, 6.66871488e-01f, -2.25764751e-01f, 1.53876962e-02f, -2.40601122e-01f, 3.48864682e-02f, 4.96935509e-02f,
  -8.69765401e-01f, -5.76573312e-01f, 3.80304784e-01f, -1.05367458e+00f, -6.11563097e-04f, -2.61686109e-02f, -5.90403557e-01f, -3.81399453e-01f, -8.51955339e-02f, -7.03803957e-01f,
  -4.44455087e-01f, -5.67759752e-01f, -4.92402267e-40f, -7.45340526e-01f, 7.50529587e-01f, -5.53100824e-01f, 7.39685118e-01f, 1.79291591e-01f, -2.96142191e-01f, -5.66813588e-01f,
  4.55989690e-11f, -1.82846320e+00f, 3.12921911e-01f, -1.04924238e+00f, -3.11123937e-01f, -5.49001336e-01f, -2.10411936e-01f, -5.57503760e-01f, 2.54449118e-02f, -4.49231118e-01f,
  -7.29923487e-01f, -3.75055969e-01f, -8.72849450e-02f, -3.05169970e-01f, -3.91895294e-01f, 8.56057703e-02f, -7.22437049e-04f, 1.66948065e-01f, 3.44016135e-01f, 4.96007711e-01f,
  -9.00295019e-01f, -5.33167243e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.53767669e-01f, -3.53053123e-01f, 1.73032850e-01f, 2.49084324e-01f, 2.52501480e-02f, -1.46882430e-01f, -2.37618852e-02f, -2.02551916e-01f, 1.23473264e-01f, -2.10199654e-02f,
  4.63236839e-01f, -7.76279941e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    