/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.41091061e-01f, -1.95814103e-01f, 1.09963007e-01f, 4.22484308e-01f, -1.32182032e-01f, -8.52684826e-02f, 3.73348072e-02f, -1.09974399e-01f, 3.40506434e-01f, -2.25376964e-01f,
  -2.28759032e-02f, 2.25575659e-02f, -4.15438786e-02f, 2.92321220e-02f, 2.88745612e-01f, 1.22874409e-01f, 2.27047533e-01f, 7.90625066e-02f, 9.84944329e-02f, -2.69085122e-03f,
  8.04488882e-02f, -5.29809855e-02f, -1.47875734e-02f, -1.94518536e-01f, -9.02371332e-02f, -3.10367849e-02f, -1.03232034e-01f, -1.10848263e-01f, -8.53801072e-02f, -1.55093214e-02f,
  -1.87063999e-02f, 6.87057525e-02f, -1.16772324e-01f, 1.17626963e-02f, -1.25383274e-04f, -9.73535851e-02f, -2.96437014e-02f, -1.26433633e-02f, 9.24889520e-02f, 7.10363388e-02f,
  1.46676684e-02f, -6.64262241e-03f, 5.49427345e-02f, 5.11276238e-02f, 3.89179066e-02f, 6.84721097e-02f, 7.10534528e-02f, 1.27150975e-02f, 4.42014076e-02f, 3.11542163e-03f,
  6.73874421e-03f, 2.17532758e-02f, 2.72532515e-02f, 1.32476613e-02f, 3.40358019e-02f, 8.75794739e-02f, -6.94735795e-02f, 2.61843903e-03f, 1.71376988e-02f, 1.77453235e-02f,
  -1.37764076e-02f, 2.26185340e-02f, 1.13250557e-02f, -5.27878329e-02f, 3.45923044e-02f, -8.06609318e-02f, 1.83609147e-02f, -6.40154630e-02f, 7.49974027e-02f, -1.25256348e-02f,
  1.29402597e-02f, 2.53634099e-02f, 2.31149867e-02f, -8.28116015e-02f, 1.45589537e-03f, -7.78158754e-02f, 1.17893172e-02f, -5.04838154e-02f, 1.11048482e-01f, -2.25265622e-02f,
  -1.72206722e-02f, 8.82345624e-03f, 1.43548939e-02f, -2.03493680e-03f, -4.03067842e-02f, 4.14892929e-05f, -2.75062956e-02f, 3.29193585e-02f, 1.51903983e-02f, -2.58447733e-02f,
  -3.78741398e-02f, -1.06717192e-01f, 1.63051039e-02f, 4.53500375e-02f, 7.72704855e-02f, 3.05275503e-03f, 5.35570160e-02f, -9.91263986e-03f, -6.78595826e-02f, -3.07392720e-02f,
  -2.38858443e-03f, -4.53981943e-02f, -1.10785007e-01f, 4.19497117e-02f, 4.15977724e-02f, -8.35746825e-02f, -2.86322869e-02f, -4.24427576e-02f, -3.42284702e-02f, 1.58122983e-02f,
  1.24914842e-02f, -2.23438255e-02f, 1.30211357e-02f, -4.92109694e-02f, -6.21632934e-02f, -2.52087452e-02f, -2.08971631e-02f, 3.56407054e-02f, -5.98228872e-02f, -2.31764819e-02f,
  -4.90684688e-01f, -7.09714070e-02f, 7.13800918e-03f, -1.60320476e-01f, -2.00550899e-01f, -1.12626500e-01f, 4.56392914e-02f, -1.86224803e-01f, 4.46067005e-02f, 5.75251654e-02f,
  -7.24061206e-02f, 8.02274868e-02f, 3.12672079e-01f, -1.52310118e-01f, -1.73816711e-01f, 2.36443281e-01f, -2.05590174e-01f, 7.62604077e-06f, 4.46001589e-02f, -1.59343392e-01f,
  -8.28275681e-02f, -1.69669166e-01f, -2.98715718e-02f, -1.23789735e-01f, -1.71419710e-01f, -2.61320192e-02f, -1.42161638e-01f, 1.83988601e-01f, -2.95589834e-01f, -3.46629098e-02f,
  -1.34031519e-01f, 1.12797379e-01f, 4.73448168e-03f, 6.54777214e-02f, -1.51504293e-01f, 1.42396651e-02f, -2.53838226e-02f, 1.06970444e-01f, 5.99529408e-02f, 2.03673467e-02f,
  8.21894705e-02f, -5.99462390e-02f, -8.16960707e-02f, 1.59532771e-01f, 6.50879219e-02f, 8.34159628e-02f, 1.09970057e-02f, -9.46904495e-02f, -1.02291945e-02f, 3.53714302e-02f,
  6.19716533e-02f, -1.81582593e-03f, 6.63363785e-02f, -2.58005410e-02f, -2.18926929e-02f, -9.92582273e-03f, 3.39797027e-02f, -3.76361050e-02f, -2.81745791e-02f, -8.65852758e-02f,
  -3.63944359e-02f, -2.78242049e-03f, 3.47667150e-02f, 4.46459912e-02f, -1.46294304e-03f, -5.41124046e-02f, 9.22806039e-02f, 5.43553336e-03f, 3.30703706e-02f, -4.90340069e-02f,
  -6.11030906e-02f, -7.39375129e-02f, 2.46672705e-02f, 4.88181263e-02f, -3.16840000e-02f, -5.31769246e-02f, -4.58505703e-03f, -2.93612406e-02f, -5.97023182e-02f, -9.39394608e-02f,
  4.60449122e-02f, -1.89779401e-02f, 9.58084501e-03f, 1.20718079e-02f, -4.07008976e-02f, 3.07685323e-03f, 6.39402866e-02f, 7.93335810e-02f, -5.39296716e-02f, 3.27221192e-02f,
  -1.76743194e-01f, -1.80031523e-01f, -1.14673059e-02f, -6.76137805e-02f, 1.88479684e-02f, -2.88570710e-02f, 4.58442494e-02f, -5.56645952e-02f, 7.45198280e-02f, -2.24528722e-02f,
  2.35727727e-02f, -2.67327167e-02f, -6.81915646e-03f, 2.06370419e-03f, 2.90998463e-02f, -4.40544933e-02f, -6.51789680e-02f, -2.94321943e-02f, -9.94571522e-02f, -1.29911155e-01f,
  -8.63906555e-03f, 9.48399492e-03f, 1.12705922e-03f, -5.19117340e-02f, -7.93056265e-02f, -7.84371942e-02f, -7.81430751e-02f, 4.52800430e-02f, 9.20561422e-03f, 4.17887792e-02f,
  1.73642203e-01f, 9.65184197e-02f, -1.51571646e-01f, 2.83775389e-01f, 8.71055275e-02f, -2.63890803e-01f, -2.67069906e-01f, 1.48728058e-01f, 3.78822386e-01f, -1.38349552e-03f,
  -9.61124822e-02f, 6.50988743e-02f, -1.75869778e-01f, -1.34765198e-02f, -3.76944602e-01f, -9.16788578e-02f, -7.42126554e-02f, 4.43534628e-02f, 1.99706420e-01f, 4.46058102e-02f,
  2.80032717e-02f, 2.87756231e-02f, -2.15924278e-01f, 1.68267414e-01f, -4.69512865e-02f, 1.59029216e-01f, -6.72808569e-03f, -3.55366729e-02f, -4.04572375e-02f, -9.10874009e-02f,
  -1.49571925e-01f, 2.05334768e-01f, 1.62347816e-02f, -7.84561690e-03f, 2.20429748e-02f, -5.79012446e-02f, -1.00332387e-01f, -8.47863704e-02f, 3.99769880e-02f, 4.78512123e-02f,
  -2.95457803e-02f, -1.16834633e-01f, 7.64264017e-02f, 1.13991201e-02f, 7.51852542e-02f, 4.27915156e-02f, -1.00271800e-03f, -1.89145263e-02f, -3.34077179e-02f, -3.68356332e-02f,
  -4.20625806e-02f, 1.69030055e-02f, -3.26595828e-03f, 3.15813236e-02f, -4.07691635e-02f, 1.20670758e-01f, -2.15099305e-02f, -5.41717112e-02f, 1.11185582e-02f, 1.50411323e-01f,
  -6.67943582e-02f, 8.97295922e-02f, -1.37585346e-02f, 8.42319503e-02f, 1.85511224e-02f, 5.29591441e-02f, 1.64835826e-02f, -3.63925621e-02f, 9.00653973e-02f, 3.72589417e-02f,
  5.38449101e-02f, 7.12771192e-02f, 6.08460829e-02f, 3.12780850e-02f, 4.01670225e-02f, 3.10628749e-02f, -6.48745969e-02f, 6.75940737e-02f, 5.13537601e-02f, 3.08178421e-02f,
  -6.16361052e-02f, -1.57665778e-02f, -1.85090024e-02f, -1.02897435e-01f, -1.04287758e-01f, 2.88334191e-02f, 1.14441151e-03f, 1.19658047e-02f, 6.36590645e-02f, -6.22622035e-02f,
  -1.64524734e-01f, 2.54455097e-02f, 7.30223907e-03f, 8.14115535e-03f, 3.62693854e-02f, 5.69789149e-02f, 2.11686194e-02f, 1.08351624e-02f, 3.99128422e-02f, -5.54937422e-02f,
  -6.51304871e-02f, 2.17421707e-02f, -3.73649821e-02f, -1.14291422e-02f, -1.97286624e-02f, -1.69504266e-02f, -7.77919665e-02f, -5.36649637e-02f, -8.21616650e-02f, -3.63662355e-02f,
  -4.71788347e-02f, 2.92423740e-02f, 7.60017410e-02f, 7.18998313e-02f, -5.98386489e-02f, -2.40821522e-02f, 1.49324104e-01f, 5.00394925e-02f, -3.98896113e-02f, 6.91362470e-02f,
  9.27471817e-02f, -1.65090770e-01f, -5.11107631e-02f, -5.94411604e-02f, -4.75991741e-02f, 1.85110867e-01f, 2.04940349e-01f, -3.58777642e-02f, -1.33405074e-01f, 2.54818127e-02f,
  1.68024585e-01f, -1.90702796e-01f, -9.91628692e-02f, 3.07820618e-01f, 2.39542291e-01f, 2.40839466e-01f, 2.38364130e-01f, 1.01723604e-01f, 4.56737680e-03f, -1.73329711e-01f,
  -2.03201063e-02f, 3.05699885e-01f, 1.18450299e-01f, -1.60186552e-02f, 3.18931974e-02f, -1.97185278e-01f, -9.42403898e-02f, -8.54712278e-02f, 1.12045407e-01f, 1.93280205e-01f,
  7.08812475e-02f, -6.61041737e-02f, 1.08533250e-02f, 9.18548107e-02f, 6.63888976e-02f, 2.05015019e-02f, 7.54619297e-03f, 4.04554084e-02f, -3.14561836e-02f, 9.24249813e-02f,
  -4.00821790e-02f, 6.04922883e-02f, -2.37900596e-02f, 7.62079805e-02f, -4.18732576e-02f, -2.75687128e-02f, 1.78171489e-02f, 1.42339552e-02f, -1.11951500e-01f, 3.19449194e-02f,
  -1.52015518e-02f, -4.86736260e-02f, -3.52669135e-02f, 2.24023797e-02f, 1.13324607e-02f, -6.48989305e-02f, 3.22465948e-03f, 1.95252746e-02f, 1.72207057e-02f, -1.03138918e-02f,
  9.58835408e-02f, -4.47540022e-02f, 7.59126097e-02f, 6.52578101e-02f, 4.12126184e-02f, 4.59523052e-02f, 5.98924197e-02f, 6.38502166e-02f, 2.37805452e-02f, 8.02682564e-02f,
  -4.66267392e-02f, -2.21509002e-02f, 5.56100272e-02f, -3.50511856e-02f, -6.19655708e-03f, 8.04365799e-02f, -2.96627078e-02f, -2.51567140e-02f, -4.70849872e-02f, -3.82509944e-03f,
  -1.56875417e-01f, -2.72237174e-02f, -6.68717176e-02f, -2.54259873e-02f, 7.50489607e-02f, -6.55739456e-02f, -2.79626288e-02f, 3.72831970e-02f, -1.07159540e-02f, -4.22474705e-02f,
  -1.20078310e-01f, -1.59576535e-01f, -9.14110318e-02f, -4.68282141e-02f, 1.17287440e-02f, 2.44736727e-02f, -2.40893643e-02f, 2.21141148e-03f, -8.87837932e-02f, 4.40492518e-02f,
  1.41728781e-02f, -1.15885092e-02f, -1.13258712e-01f, 1.43412044e-02f, 4.05647373e-03f, -4.37131664e-03f, -6.66723847e-02f, -6.95299208e-02f, -3.18864435e-02f, -1.81805883e-02f,
  -1.07773645e-02f, 2.88563868e-04f, -3.47407684e-02f, 3.68560292e-02f, -2.57116053e-02f, 8.80219042e-03f, -9.16812755e-03f, -1.09403461e-01f, -9.30547467e-05f, 1.98159367e-02f,
  -1.03904612e-01f, -2.60508180e-01f, 3.51690575e-02f, -8.77836999e-03f, -6.03448153e-02f, 8.46834108e-02f, 2.83255965e-01f, -2.39824519e-01f, 2.29755826e-02f, -8.44606906e-02f,
  -1.00641936e-01f, 9.60052311e-02f, -1.60965361e-02f, -1.14946067e-01f, 3.04744184e-01f, 5.79785295e-02f, 5.38151115e-02f, -6.68971625e-04f, 6.64690956e-02f, -6.51854798e-02f,
  4.56055440e-02f, -8.43292922e-02f, 1.13578498e-01f, -1.87454782e-02f, 2.42659412e-02f, -1.37065444e-02f, -4.77514155e-02f, 1.75629091e-02f, -2.60635987e-02f, 8.31508785e-02f,
  6.02403395e-02f, -4.55997400e-02f, 5.85102029e-02f, -1.60171576e-02f, -9.66681633e-03f, 8.01241677e-03f, 1.17708921e-01f, 2.26938166e-02f, 4.56282757e-02f, -7.69932242e-03f,
  8.63186419e-02f, 1.28861014e-02f, -6.20613340e-04f, 9.65081342e-03f, -2.49263570e-02f, -1.79372486e-02f, -1.37438625e-02f, 4.22948748e-02f, -2.48888209e-02f, 1.37156263e-01f,
  3.07400385e-03f, 2.33007204e-02f, 1.48850605e-02f, 6.76596388e-02f, -2.82442644e-02f, 7.97183067e-02f, 7.10140467e-02f, 1.03431910e-01f, 3.76847722e-02f, 4.87223640e-03f,
  5.42952009e-02f, -3.27141344e-04f, 2.26699021e-02f, -1.09589837e-01f, 5.74285630e-03f, -6.31348863e-02f, 6.01592399e-02f, -2.69751679e-02f, 1.11484034e-02f, -6.09334819e-02f,
  -7.75290728e-02f, -8.13345611e-02f, 3.00816074e-03f, -3.39699835e-02f, 8.68669525e-03f, -1.48359137e-02f, 1.14873145e-02f, -2.51168478e-02f, 1.04682492e-02f, 2.74362359e-02f,
  -1.11431526e-02f, 3.95781882e-02f, -7.62056978e-03f, -7.12831412e-03f, -2.66011674e-02f, -4.50274721e-02f, -5.30494899e-02f, -2.76160520e-03f, -2.85810214e-02f, 1.57997105e-02f,
  -2.73793846e-01f, -2.35564739e-01f, 9.18540265e-03f, -7.68494839e-03f, -5.45053147e-02f, 5.83925471e-03f, 8.55463147e-02f, -3.79175209e-02f, -2.39419155e-02f, -2.29470599e-02f,
  6.59800842e-02f, 1.56775936e-02f, -3.85708846e-02f, -3.98765616e-02f, 3.10364198e-02f, -2.09155828e-02f, -1.31593486e-02f, -9.28328245e-06f, 5.92315458e-02f, -3.72241624e-02f,
  -9.10812765e-02f, -3.15877423e-02f, 1.51096657e-01f, 3.04679498e-02f, 1.90519926e-03f, 3.77356238e-03f, 2.31304653e-02f, 2.78808903e-02f, -2.98209172e-02f, 7.28314891e-02f,
  4.68563288e-01f, 1.38372362e-01f, -6.00350201e-02f, 3.32332909e-01f, 1.34190163e-02f, -3.72864902e-02f, -9.34538841e-02f, 1.56921536e-01f, 2.82509506e-01f, 6.97676539e-02f,
  -1.89707041e-01f, 1.32390141e-01f, -2.39137232e-01f, 4.89924438e-02f, -9.92745906e-03f, -2.27594823e-01f, 2.58906484e-01f, 1.88158259e-01f, -5.50626516e-02f, 2.77307868e-01f,
  6.03460819e-02f, 1.13014497e-01f, -2.06169173e-01f, -3.36506069e-02f, 2.05759048e-01f, 2.75583006e-02f, -5.09271771e-02f, -9.11332965e-02f, 4.58756872e-02f, -1.50025949e-01f,
  1.21966757e-01f, 8.28718767e-02f, -3.69257182e-02f, 2.28450950e-02f, -3.02455444e-02f, 3.25874835e-02f, -5.05393632e-02f, -1.96247414e-01f, -7.81310573e-02f, -5.60697466e-02f,
  4.45397478e-03f, 1.01680517e-01f, -5.26971966e-02f, 3.35155018e-02f, 9.85930935e-02f, -4.40081302e-03f, 3.95208821e-02f, 1.10816201e-02f, -9.18339491e-02f, 4.67739021e-03f,
  -2.50516757e-02f, -4.55394052e-02f, 3.82516459e-02f, 3.46056446e-02f, 2.12673247e-02f, 1.30696446e-02f, -2.37389375e-03f, -3.11217308e-02f, 9.52866003e-02f, 1.57580003e-02f,
  -1.77929271e-02f, -5.55698127e-02f, -5.90203479e-02f, -1.37465512e-02f, -3.94378882e-03f, 2.62436103e-02f, -3.91341709e-02f, -6.89849779e-02f, 6.47823364e-02f, 3.25169824e-02f,
  7.57992566e-02f, 7.94990435e-02f, 7.25883842e-02f, -1.63528975e-02f, -4.11526784e-02f, -2.00136062e-02f, -7.72980899e-02f, 1.21737950e-01f, 7.38813207e-02f, 2.94599477e-02f,
  2.51400955e-02f, 6.01701885e-02f, 3.84607725e-02f, -3.74808796e-02f, -2.60102516e-03f, -7.59911835e-02f, 7.85078667e-03f, 6.65244609e-02f, -1.33821905e-01f, -6.64600581e-02f,
  2.79952854e-01f, 3.51660222e-01f, -1.00034833e-01f, 9.57469270e-03f, -2.28100438e-02f, 1.99500248e-02f, -5.53346388e-02f, 7.63072493e-03f, 1.55258859e-02f, -1.49208950e-02f,
  5.60660921e-02f, 7.98414275e-02f, 9.38661024e-02f, 1.92308500e-02f, -5.52536286e-02f, -3.29990499e-02f, -4.36946228e-02f, 1.28244748e-02f, 8.04637969e-02f, 7.96835497e-02f,
  5.82052954e-02f, 4.42506224e-02f, 9.55882482e-03f, 1.11597635e-01f, 3.22451666e-02f, -1.25380248e-01f, 1.82976648e-01f, -1.85186453e-02f, -8.27983841e-02f, 6.25734255e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.70230830e-01f, 3.79304975e-01f, -1.08428067e-02f, -3.41603041e-01f, 1.26576543e-01f, -2.69452095e-01f, -1.49979174e-01f, 8.02308917e-02f, -4.44530547e-02f, 2.83507258e-01f,
  6.75320700e-02f, 2.41939239e-02f, 2.51424342e-01f, 2.30808891e-02f, -3.92704308e-01f, 1.29206568e-01f, -2.50887126e-01f, -1.33492380e-01f, 1.30271897e-01f, -1.85820967e-01f,
  -1.70348316e-01f, 3.98730114e-02f, -7.24349543e-02f, 2.67638922e-01f, -1.19405448e-01f, -5.30887954e-02f, -1.91114590e-01f, 2.01131105e-01f, -1.31107941e-01f, 6.72128052e-02f,
  -2.59992719e-01f, 1.05400302e-01f, -8.38088468e-02f, -2.92865541e-02f, -1.74866185e-01f, 5.81205487e-02f, -2.16045558e-01f, 6.91888481e-02f, -9.78749841e-02f, 5.40344324e-03f,
  -3.63007071e-03f, 1.30311728e-01f, -4.24004197e-02f, 3.44637074e-02f, 2.50276458e-02f, 1.42707855e-01f, 4.61431965e-02f, -1.18276343e-01f, 6.07770160e-02f, 5.48378043e-02f,
  7.94695131e-03f, 7.00960085e-02f, -6.08608164e-02f, -3.84229943e-02f, 1.67789441e-02f, 7.99869746e-02f, -2.95057539e-02f, -6.31757546e-04f, -9.54496339e-02f, -2.49823686e-02f,
  1.43973514e-01f, -1.31066948e-01f, -4.78050373e-02f, 7.07490072e-02f, 4.09356691e-02f, 5.43407500e-02f, -1.26821980e-01f, -7.99434781e-02f, -4.34908667e-04f, 1.13941275e-01f,
  -2.78042089e-02f, 6.45788619e-03f, 4.78250794e-02f, -4.51656245e-02f, -2.95393970e-02f, -4.06602733e-02f, -1.21000715e-01f, 2.83103399e-02f, -1.06391497e-01f, 1.30071836e-02f,
  1.08358391e-01f, 1.23368958e-02f, 5.23859411e-02f, -6.96150288e-02f, 5.23079149e-02f, -6.05379306e-02f, -1.94940213e-02f, -2.00557377e-04f, -4.47073113e-03f, -1.42917320e-01f,
  -5.73586643e-01f, -2.74350852e-01f, -4.26504761e-02f, 3.79122756e-02f, -8.69390368e-02f, 2.51388531e-02f, -2.45924690e-03f, -2.79325992e-02f, -1.18326612e-01f, -4.55143349e-03f,
  -5.24306111e-02f, -1.40022216e-02f, -1.87979385e-01f, -6.81799948e-02f, -1.17108494e-01f, 1.01092586e-03f, -9.50886533e-02f, -6.31787479e-02f, -2.56316364e-01f, 2.36504406e-04f,
  -6.99925274e-02f, -4.45995517e-02f, 4.93716523e-02f, 4.61023711e-02f, -7.31229782e-03f, -1.17510945e-01f, -4.40227091e-02f, 5.07444851e-02f, 1.99160036e-02f, 7.33825704e-03f,
  -5.16517498e-02f, 1.06585948e-02f, -4.35964286e-01f, -2.82581478e-01f, -2.30794996e-01f, -6.21283412e-01f, -3.34203184e-01f, -1.50591493e-01f, 2.57010221e-01f, 2.39697024e-01f,
  5.74771613e-02f, 9.29080844e-02f, 2.40661100e-01f, -2.17486888e-01f, -1.02319345e-01f, 3.52256835e-01f, -4.64918375e-01f, -2.53339291e-01f, 7.57099539e-02f, -3.31846476e-01f,
  -6.63439557e-02f, -2.17852473e-01f, -3.32371205e-01f, -1.81601122e-01f, -3.55131567e-01f, -1.56028926e-01f, -5.07177636e-02f, -1.33095384e-01f, -2.17394814e-01f, -6.96718832e-03f,
  -9.44689754e-03f, 2.67709613e-01f, 3.27258022e-03f, 4.85522747e-02f, -1.63257346e-01f, -1.18156023e-01f, -1.27617538e-01f, -2.66866107e-02f, 2.75860820e-02f, 2.94204485e-02f,
  1.68056134e-02f, 9.40993950e-02f, -5.90128116e-02f, 1.15300819e-01f, 3.36199813e-02f, -1.42976968e-02f, 5.27011454e-02f, -3.88596132e-02f, 4.15446684e-02f, -1.95520762e-02f,
  7.19245300e-02f, -3.77448276e-02f, -1.03858456e-01f, 5.68878874e-02f, -6.70757890e-02f, 3.51814590e-02f, -1.20288372e-01f, -1.20255642e-01f, -1.25595636e-03f, -1.17733106e-02f,
  3.41570340e-02f, -3.84090394e-02f, 3.60976048e-02f, -3.54800820e-02f, 6.61761558e-04f, 2.91179847e-02f, 7.80895799e-02f, -1.72663741e-02f, -7.15890015e-03f, -5.77648245e-02f,
  -3.06107569e-02f, 5.07761631e-03f, -7.21916556e-02f, -8.26682001e-02f, -4.40694131e-02f, 1.08611330e-01f, -4.75444943e-02f, -2.60826722e-02f, -2.88342796e-02f, -3.28254104e-02f,
  3.97862419e-02f, -9.56513733e-02f, 7.08960369e-02f, -4.63203564e-02f, -1.98356677e-02f, 7.14371875e-02f, -4.56364080e-03f, 7.70035535e-02f, -8.99745971e-02f, -8.82897899e-02f,
  -6.85656816e-02f, -8.39475989e-02f, 4.77711260e-02f, 1.03999421e-01f, 3.79089862e-02f, -7.90351033e-02f, -2.46662311e-02f, -6.35847449e-02f, 2.43461281e-02f, 4.09114398e-02f,
  -2.08371542e-02f, -6.44598082e-02f, -1.58058673e-01f, 3.39079015e-02f, 5.86813577e-02f, -7.48160034e-02f, -6.13591038e-02f, 3.18546295e-02f, -7.82383606e-02f, -4.90502454e-02f,
  -8.92185122e-02f, 5.67660965e-02f, 3.11764535e-02f, -4.08730060e-02f, -1.17736049e-01f, -1.94170270e-02f, -1.12445690e-01f, 1.27581686e-01f, 5.52922860e-03f, -3.62286344e-02f,
  -4.70941961e-01f, 2.99777597e-01f, -1.30622327e-01f, 8.06665644e-02f, 8.76485109e-02f, 4.22761887e-01f, 3.77425402e-01f, 1.52575180e-01f, 2.92646646e-01f, 3.27836782e-01f,
  8.08588117e-02f, -1.00089826e-01f, 6.93712384e-02f, 2.17209101e-01f, -1.82349011e-01f, 2.33921334e-01f, 2.89839119e-01f, 2.12655097e-01f, 1.48429036e-01f, -6.21420145e-02f,
  -1.39655396e-01f, 9.84540954e-02f, -2.12023839e-01f, -5.31591848e-02f, -5.38906269e-02f, -1.87463880e-01f, -2.32111767e-01f, -1.29091471e-01f, -4.01383489e-02f, 1.78618908e-01f,
  5.89693896e-02f, -2.40882626e-03f, -1.75923765e-01f, -1.13801686e-02f, -5.16652316e-02f, -1.94605380e-01f, -3.00646294e-02f, -5.58814965e-02f, -1.04609586e-01f, 2.31468324e-02f,
  2.09459048e-02f, -3.05556110e-03f, 8.89482163e-03f, -7.17047974e-02f, 3.88900787e-02f, -2.10410133e-02f, -1.86141953e-02f, 2.73813531e-02f, 2.06567403e-02f, -6.31717667e-02f,
  -1.19110882e-01f, 1.96317807e-02f, -4.60481737e-03f, 1.14639103e-01f, -4.98696268e-02f, 1.56124741e-01f, 9.62143242e-02f, -7.06804991e-02f, 1.45666450e-01f, 3.36676277e-02f,
  -9.05704424e-02f, 2.75323037e-02f, -4.33218032e-02f, -5.36761321e-02f, -1.02844447e-01f, 1.03368210e-02f, -2.10802834e-02f, -4.60406393e-02f, -3.24786715e-02f, -5.22748865e-02f,
  5.69004193e-02f, -2.83199996e-02f, 2.92125046e-02f, -5.45658264e-03f, 1.46999359e-01f, 6.87451363e-02f, -4.26233709e-02f, 3.20654698e-02f, 9.04518366e-02f, 3.80633324e-02f,
  -5.36521105e-03f, -4.90942486e-02f, 1.84782385e-03f, -1.13104070e-02f, 8.24046582e-02f, -1.53253432e-02f, 5.32438457e-02f, -3.70863304e-02f, -8.96683778e-04f, 6.44252496e-03f,
  1.80392101e-01f, 3.11416775e-01f, 5.28227203e-02f, 7.28708953e-02f, -4.04687971e-02f, -1.05559647e-01f, -2.19864100e-02f, 4.99744527e-02f, 1.23411015e-01f, 2.25930624e-02f,
  -3.83019820e-02f, 4.00007106e-02f, 1.29082007e-02f, -5.04406430e-02f, 1.10279754e-01f, 3.17691378e-02f, 5.79421818e-02f, 5.25933169e-02f, 1.75290152e-01f, 1.96285229e-02f,
  -9.80226398e-02f, 4.41906266e-02f, 6.20819218e-02f, 6.65729493e-02f, 2.40779426e-02f, -2.91724093e-02f, 9.97223929e-02f, -5.75974472e-02f, -1.12722479e-02f, 3.36673670e-02f,
  1.53573483e-01f, -1.08135752e-02f, -5.32451756e-02f, 7.94078112e-02f, -1.00277893e-01f, -2.34023333e-01f, -3.10596645e-01f, 5.33761717e-02f, -3.28512818e-01f, 2.53715203e-03f,
  1.08073778e-01f, -1.45485356e-01f, 1.04354933e-01f, -1.97372243e-01f, -1.52234569e-01f, -9.75455567e-02f, 7.97058269e-03f, -9.62856784e-02f, -9.74139944e-02f, 2.27132216e-01f,
  1.38216481e-01f, 9.57984999e-02f, 1.69620335e-01f, 1.83072582e-01f, -1.28053334e-02f, 2.67769367e-01f, 2.53565043e-01f, 1.41617507e-01f, 1.39909312e-01f, -1.39734000e-01f,
  -1.05756424e-01f, 4.20875028e-02f, -4.04096060e-02f, -7.85597712e-02f, 9.44381058e-02f, 4.27145921e-02f, 2.46144831e-03f, -8.84294659e-02f, 4.58982121e-03f, -6.48067519e-03f,
  7.12306350e-02f, 7.65680969e-02f, -5.97552694e-02f, -1.43277511e-01f, -2.64572538e-02f, -4.98157786e-03f, -2.86631715e-02f, -7.63107240e-02f, -1.01514205e-01f, 7.58633614e-02f,
  4.18563485e-02f, 3.52918766e-02f, 3.64455134e-02f, 7.45976269e-02f, 4.50799093e-02f, -5.85083431e-03f, -4.98610921e-02f, 1.27689600e-01f, -8.38274285e-02f, -3.18944007e-02f,
  8.97123143e-02f, -2.24193353e-02f, -1.66266523e-02f, -1.19883597e-01f, -3.52658331e-02f, -8.74243956e-03f, -1.17260367e-02f, 2.77458155e-03f, -1.34700447e-01f, -5.18974550e-02f,
  1.89636815e-02f, 7.53087457e-03f, -6.39153495e-02f, 6.19106255e-02f, 8.85430500e-02f, 3.87812629e-02f, 1.47685315e-02f, -5.45099378e-03f, -4.61109821e-03f, -7.79185817e-02f,
  -1.13465942e-01f, 3.66777107e-02f, -3.29820588e-02f, -1.01148449e-02f, -1.30544320e-01f, 1.37492120e-02f, 4.86321226e-02f, 8.49017967e-03f, -1.44636855e-02f, 8.20022635e-03f,
  4.10333909e-02f, 2.53305942e-01f, 4.65555154e-02f, -1.60222083e-01f, -9.95612442e-02f, -2.70024315e-02f, -4.11117598e-02f, 3.44589502e-02f, 9.99575406e-02f, -3.31467427e-02f,
  2.04554826e-01f, 1.04725976e-02f, 5.24590984e-02f, 5.18559217e-02f, -4.59376872e-02f, 7.42304102e-02f, 7.19565675e-02f, 1.09318784e-02f, 2.60153469e-02f, 9.62896720e-02f,
  1.30779073e-01f, 1.78271178e-02f, 1.57796536e-02f, -7.41575807e-02f, 3.89079414e-02f, 1.24713786e-01f, -7.80302212e-02f, 1.16952024e-01f, -2.04687528e-02f, -9.06854868e-03f,
  -2.07280278e-01f, -3.78426537e-02f, 8.18652734e-02f, 4.13612813e-01f, -1.21867493e-01f, -4.02956814e-01f, -4.37472373e-01f, 3.37998942e-02f, -1.88239023e-01f, -2.99332172e-01f,
  -1.55744657e-01f, 2.92641781e-02f, -2.93428093e-01f, 3.07387292e-01f, 3.99016500e-01f, -1.91735271e-02f, 2.21143857e-01f, 2.82870550e-02f, 1.62091717e-01f, 1.31366342e-01f,
  4.33790833e-01f, 2.53900975e-01f, 4.56228107e-01f, 3.18248898e-01f, 1.35574803e-01f, 2.47589767e-01f, 4.19097543e-01f, 1.77519888e-01f, 3.70554477e-01f, 1.08784035e-01f,
  -2.60227501e-01f, -9.34231207e-02f, -3.55907902e-02f, -7.27281943e-02f, -2.56694499e-02f, -1.62901148e-01f, -9.12414193e-02f, -1.03823496e-02f, 4.27674837e-02f, -2.42559277e-02f,
  -3.15949470e-02f, 9.46311057e-02f, 8.51268619e-02f, 4.48120609e-02f, -9.10278708e-02f, 2.40011290e-02f, 6.42899275e-02f, -1.17606148e-01f, -7.97034428e-02f, -3.30423974e-02f,
  -1.27437897e-02f, -7.30339736e-02f, -4.72765561e-04f, -1.07153347e-02f, 7.96086043e-02f, -4.25753631e-02f, 1.21182024e-01f, -4.04825136e-02f, 5.23997005e-03f, 2.90468410e-02f,
  -1.28285214e-01f, 1.24013675e-02f, 2.15423778e-02f, 1.25015946e-02f, 6.48370609e-02f, 1.31435907e-02f, 1.15218898e-02f, -4.29616962e-03f, 3.49888243e-02f, -6.74127787e-02f,
  9.34774708e-03f, 2.38244608e-02f, -1.02985077e-01f, -3.20187993e-02f, 2.82541122e-02f, -6.99373260e-02f, -1.61109567e-02f, 2.44456716e-02f, -6.60795346e-02f, 1.21824004e-01f,
  -1.55534979e-03f, -3.71798612e-02f, 1.09789800e-02f, -4.13676240e-02f, -1.24022901e-01f, 3.65973264e-02f, 2.08499618e-02f, -8.23540911e-02f, 5.32343723e-02f, 8.43443349e-02f,
  -9.51033738e-03f, 3.34945798e-01f, 3.56726646e-02f, -1.17461935e-01f, 2.02678703e-03f, 2.43909620e-02f, 9.88060981e-02f, 2.89747771e-02f, 6.66308254e-02f, 1.17589743e-03f,
  3.47621017e-03f, -7.44898468e-02f, 5.73781226e-03f, -3.76453698e-02f, 9.12179649e-02f, 4.03129077e-03f, 2.58584358e-02f, 3.13843600e-02f, 8.57305378e-02f, 7.07265958e-02f,
  3.45794335e-02f, -7.82663748e-02f, 4.34815995e-02f, -4.11370955e-02f, -6.25391752e-02f, 4.91111632e-03f, -8.72965530e-02f, -4.88450788e-02f, 1.45771295e-01f, 3.85881476e-02f,
  -2.56015271e-01f, 3.02298814e-02f, 5.24307787e-01f, -6.46321401e-02f, 3.50999445e-01f, 5.01569867e-01f, 2.25520805e-01f, 3.39588314e-01f, 4.59393442e-01f, -3.57103735e-01f,
  -2.50256091e-01f, -3.04006219e-01f, -4.00497671e-03f, -1.88622519e-01f, 2.57219851e-01f, 2.95857787e-01f, 1.65357172e-01f, -1.28989682e-01f, 3.01894635e-01f, -3.31366882e-02f,
  1.98118702e-01f, -1.20808847e-01f, 1.40385851e-01f, -5.64687066e-02f, -1.29455388e-01f, -6.13626651e-02f, -3.90435010e-01f, 1.99327558e-01f, -2.85936773e-01f, 2.83421646e-03f,
  2.87514478e-02f, -9.29322373e-03f, 1.86598711e-02f, 5.73448464e-02f, -1.16838412e-02f, -3.92960757e-02f, 4.11322340e-02f, -3.47541849e-04f, -3.71198170e-02f, -3.60690169e-02f,
  -1.61295369e-01f, 1.55515540e-02f, -5.22993468e-02f, 6.26848862e-02f, 1.06544673e-01f, -1.56412786e-03f, 1.16691113e-01f, 1.01199821e-01f, 3.92888188e-02f, 7.41256028e-02f,
  4.78872955e-02f, 6.11439385e-02f, 4.81912792e-02f, -3.72172445e-02f, 2.52065416e-02f, 2.81930389e-03f, 5.84790073e-02f, -1.01661123e-01f, -5.08344397e-02f, -2.16694013e-03f,
  6.17422089e-02f, 1.65242404e-01f, 8.94659851e-03f, -4.04195786e-02f, -6.32070154e-02f, -4.09368090e-02f, -6.02908619e-03f, -5.36154211e-02f, 4.30562682e-02f, -1.90798622e-02f,
  -9.78266820e-02f, -7.79997483e-02f, 6.65812120e-02f, -9.82864667e-03f, -4.51765731e-02f, 1.52543513e-03f, -1.88021343e-02f, -7.72897005e-02f, -1.00708073e-02f, -3.74624208e-02f,
  -7.51423240e-02f, 4.88949344e-02f, -1.74332917e-01f, -7.16431662e-02f, 1.18093528e-01f, 2.74276938e-02f, -1.00817308e-01f, 7.73072243e-02f, -2.89193541e-02f, 3.80251110e-02f,
  1.44648105e-01f, 6.81366995e-02f, -2.17039809e-02f, -1.04003564e-01f, -8.63407832e-03f, -2.86838375e-02f, 1.41712785e-01f, -4.78433259e-02f, 1.58997044e-01f, 3.80252786e-02f,
  -9.75643378e-03f, -1.23257674e-01f, -3.01811728e-03f, 8.76662284e-02f, 4.68282662e-02f, 9.62295309e-02f, -9.05146375e-02f, -4.97648567e-02f, -2.03720685e-02f, -2.57303193e-02f,
  -1.71609327e-01f, -7.29938224e-02f, -7.01502711e-02f, -1.03432521e-01f, -1.51816443e-01f, -1.67062327e-01f, -4.69072051e-02f, 3.41622196e-02f, -2.00245231e-02f, 4.19841409e-02f,
  -1.22846931e-01f, -2.29905143e-01f, 3.48337144e-01f, -7.33658671e-02f, 2.85306215e-01f, 3.98937523e-01f, 2.23852605e-01f, 2.50462115e-01f, -5.09805642e-02f, -2.95937270e-01f,
  -4.61944006e-02f, -1.34239241e-01f, 1.44836232e-01f, -9.80425179e-02f, 4.71688181e-01f, 6.96394965e-02f, 2.30720751e-02f, -1.40782073e-01f, 6.56588450e-02f, -3.31676230e-02f,
  -1.28792776e-02f, -1.43667892e-01f, 2.62631834e-01f, -1.38762161e-01f, 8.13302845e-02f, -1.65396065e-01f, -2.36022756e-01f, 1.94851458e-01f, -1.24065004e-01f, 8.96977782e-02f,
  7.25022852e-02f, -1.81266576e-01f, -1.61653101e-01f, -7.54853562e-02f, 8.61843303e-02f, 3.88733484e-02f, -1.74220446e-02f, 6.63082153e-02f, -1.99541021e-02f, -1.29465815e-02f,
  -1.30073726e-01f, 8.90072659e-02f, -4.90794592e-02f, -2.83714682e-02f, -3.57206538e-02f, 3.82547602e-02f, 7.00846389e-02f, 3.65351327e-02f, 4.77846488e-02f, 1.18343629e-01f,
  1.67688608e-01f, 8.20640698e-02f, 3.03322654e-02f, -4.41848114e-02f, 1.76988188e-02f, 3.83721925e-02f, 9.96414106e-04f, 8.11471865e-02f, 6.64395019e-02f, 1.06489034e-02f,
  -1.30788490e-01f, -5.40837506e-03f, -6.33605644e-02f, 5.37804104e-02f, 5.33561110e-02f, 5.07832952e-02f, -1.00750402e-01f, 2.87901331e-02f, -2.23493166e-02f, 1.20207123e-01f,
  4.47911583e-02f, -2.57842299e-02f, -5.89243509e-02f, -6.02506893e-03f, -2.39948239e-02f, -1.27980769e-01f, -8.37471485e-02f, 1.11362664e-02f, 3.25383767e-02f, 2.62894407e-02f,
  -3.10602542e-02f, 4.08075228e-02f, 3.24104168e-02f, -4.41797636e-02f, 1.26023563e-02f, 3.08729522e-02f, -8.54891911e-02f, 7.47811273e-02f, -2.27425992e-02f, 4.98254895e-02f,
  -9.80090871e-02f, -3.33333910e-01f, -9.08377618e-02f, -1.38980970e-01f, -2.21866325e-01f, -2.34251413e-02f, -1.60713121e-01f, -4.79548275e-02f, -2.12237961e-03f, -2.38129068e-02f,
  -3.35537344e-02f, 3.45448367e-02f, 8.79653264e-03f, -8.68829191e-02f, -7.17774555e-02f, -2.77836365e-03f, -1.05792701e-01f, -1.99300319e-01f, -1.38120875e-01f, -5.92253879e-02f,
  7.12663168e-03f, -6.83156848e-02f, 1.03575096e-01f, -2.89479140e-02f, -1.55652225e-01f, -1.02098193e-02f, -2.47952398e-02f, 1.33991586e-02f, 8.82477909e-02f, 7.32842162e-02f,
  -7.43600309e-01f, 1.73595861e-01f, -2.91455358e-01f, 1.91557869e-01f, -2.25795582e-01f, -1.57422334e-01f, 1.09843850e-01f, -1.00945644e-01f, -1.96397811e-01f, 5.27311742e-01f,
  3.50651085e-01f, -5.01959562e-01f, 2.64004022e-01f, 4.26612616e-01f, -3.05407524e-01f, 2.25720331e-01f, 2.32066408e-01f, 1.77271426e-01f, -1.58233866e-01f, -7.72740738e-03f,
  -1.25127092e-01f, 2.08944008e-01f, 1.93409026e-01f, 7.91715458e-02f, 7.92416185e-03f, -1.15198456e-01f, 3.53806078e-01f, -1.50752649e-01f, 2.15370923e-01f, -2.46681690e-01f,
  1.05317391e-01f, 7.31052533e-02f, -4.52128351e-02f, -1.67250857e-01f, -3.82095086e-03f, -9.83217508e-02f, 6.40707463e-02f, -1.79072469e-01f, -9.37679037e-02f, -1.01624116e-01f,
  -1.67384580e-01f, -1.34696484e-01f, -7.05328360e-02f, -1.21450268e-01f, -1.32357970e-01f, -5.89785166e-02f, 1.84758159e-03f, 3.80951576e-02f, 4.24538106e-02f, -4.46833577e-03f,
  -6.46886751e-02f, -1.15594910e-02f, 1.29335150e-01f, 9.19581428e-02f, -4.22059968e-02f, 7.14476332e-02f, 8.09447393e-02f, -9.45073068e-02f, -5.27642779e-02f, -7.63808638e-02f,
  -6.35714754e-02f, -1.98129099e-02f, -4.65351641e-02f, 5.28038405e-02f, -3.21258120e-02f, 1.80714265e-01f, 3.11973281e-02f, 5.75050004e-02f, -3.81734893e-02f, 8.28494281e-02f,
  -1.83754954e-02f, 3.11337039e-02f, 4.79706526e-02f, -3.97832133e-03f, -5.22601940e-02f, -1.62975956e-02f, -1.07277334e-01f, 7.42926747e-02f, 5.32362796e-02f, 9.05180797e-02f,
  8.33990425e-02f, -3.96239124e-02f, 8.19314793e-02f, 9.03872624e-02f, -1.28937596e-02f, -2.17314232e-02f, 5.53644672e-02f, 7.19024390e-02f, 8.31544399e-02f, -9.30000693e-02f,
  2.02786744e-01f, -8.51338357e-03f, -4.37752791e-02f, -7.56566413e-03f, 1.40660778e-02f, -4.72538471e-02f, -5.60850874e-02f, -1.09086983e-01f, -2.10555326e-02f, -1.18658524e-02f,
  1.77752450e-02f, -5.63362688e-02f, 1.24909412e-02f, 2.33816747e-02f, 4.99489857e-03f, 1.26107365e-01f, 1.72278538e-01f, -5.15342243e-02f, 6.60161525e-02f, 8.17389861e-02f,
  8.23264942e-02f, -9.89922732e-02f, -1.13629483e-01f, 3.44863418e-03f, 9.43326112e-03f, 8.48215148e-02f, -6.35362193e-02f, 2.28590611e-02f, 2.45119585e-03f, 7.34327361e-02f,
  -5.93372881e-01f, 6.52351737e-01f, 3.07146341e-01f, -3.00935507e-01f, 1.37301281e-01f, 8.47349837e-02f, -1.96062878e-01f, 2.36883685e-01f, -3.03792924e-01f, 1.14499442e-02f,
  -1.67090595e-01f, 9.09493566e-02f, -2.44175997e-02f, -3.92098911e-02f, -5.42167842e-01f, -6.44193590e-02f, -3.36490870e-01f, -1.72995672e-01f, -3.95952314e-02f, -5.44374883e-02f,
  -8.69386122e-02f, -1.96122780e-01f, 1.36838377e-01f, 3.18061411e-01f, 1.92413390e-01f, 1.56341702e-01f, -2.54605770e-01f, 2.19537482e-01f, 6.47653863e-02f, -1.97923165e-02f,
  -9.83060151e-02f, 6.50331900e-02f, 9.30408910e-02f, 8.99893939e-02f, -9.05561075e-02f, -6.97016716e-02f, -6.71441257e-02f, -5.49765266e-02f, -5.95764518e-02f, -2.76364610e-02f,
  -3.81235108e-02f, 3.11446618e-02f, -4.19586748e-02f, 9.44954436e-03f, -1.01985039e-04f, 7.37231746e-02f, 8.25529695e-02f, 1.50328115e-01f, 1.31411567e-01f, 6.80476427e-02f,
  1.16036825e-01f, 2.98661124e-02f, 6.68371767e-02f, -3.65576670e-02f, 4.10793945e-02f, 1.10346442e-02f, -2.82302164e-02f, -2.11782102e-02f, 8.50676075e-02f, -7.32592121e-02f,
  -2.03298777e-02f, -7.58147016e-02f, 1.39780328e-01f, 2.40218639e-02f, -3.09644919e-02f, 5.40105812e-03f, -5.84592903e-03f, -7.21701533e-02f, 5.25943674e-02f, -8.58044922e-02f,
  -1.60396576e-01f, 3.38885784e-02f, 2.91237161e-02f, -3.72091159e-02f, 4.79922183e-02f, -3.02300863e-02f, 7.78266713e-02f, 5.39754108e-02f, -5.37944995e-02f, 1.59891360e-02f,
  -9.49920341e-02f, -7.54718482e-02f, 2.17567850e-02f, 5.98061010e-02f, -4.40693386e-02f, -4.01554964e-02f, -5.06517962e-02f, 2.39493344e-02f, -5.17948419e-02f, -7.96317458e-02f,
  -2.08368316e-01f, -7.18247965e-02f, 2.10169945e-02f, 6.29572710e-03f, 5.65901287e-02f, -1.01449892e-01f, 7.24751949e-02f, 3.46967876e-02f, -4.06532735e-02f, -7.62442648e-02f,
  -5.33843553e-03f, -4.71118800e-02f, -4.15096395e-02f, -1.12001546e-01f, 4.35729846e-02f, -1.31769627e-01f, -1.46402523e-01f, -9.98495370e-02f, -4.42620628e-02f, 4.78632785e-02f,
  1.55586600e-02f, -5.49921468e-02f, -4.05827761e-02f, -1.82122923e-02f, -6.98857605e-02f, -9.43390876e-02f, -3.33244167e-02f, -2.33819671e-02f, -3.87183912e-02f, 2.01268261e-03f,
  -8.64438936e-02f, -1.59561276e-01f, -2.13501334e-01f, -7.30386078e-02f, 3.28127325e-01f, -4.33163159e-02f, 1.21950306e-01f, 1.14047557e-01f, -3.10425144e-02f, 1.67979613e-01f,
  1.72290057e-02f, -2.87595719e-01f, -1.10333405e-01f, -4.84607309e-01f, -5.83594978e-01f, -4.64382440e-01f, -3.69850695e-01f, -2.63122410e-01f, -2.40211934e-01f, -3.29541764e-03f,
  -4.90986183e-02f, 8.23560134e-02f, -2.49969155e-01f, 2.37254232e-01f, 2.53248930e-01f, 3.06169152e-01f, 4.12483811e-01f, 2.95068920e-01f, 8.90115425e-02f, -8.69350433e-02f,
  -1.53033182e-01f, -9.56353769e-02f, 8.31968151e-03f, -4.80570942e-02f, 7.02652186e-02f, 2.17106342e-01f, 5.31356819e-02f, -2.31558438e-02f, 2.02034954e-02f, -5.30024245e-02f,
  2.04581004e-02f, -1.25178816e-02f, -1.32065073e-01f, -8.08927491e-02f, 1.75280288e-01f, -1.87493060e-02f, -9.09847841e-02f, 3.07558943e-02f, -1.89244673e-02f, -1.90167829e-01f,
  -9.70562398e-02f, -5.91694005e-02f, 1.13276787e-01f, -9.71036479e-02f, -2.43940856e-02f, 2.13794038e-02f, -1.04710953e-02f, -4.77461182e-02f, 7.91700110e-02f, -4.55376692e-02f,
  2.57532150e-02f, 1.27916187e-01f, 1.30358664e-02f, -1.18830115e-01f, 1.72575004e-02f, 8.40581022e-03f, 9.74676386e-02f, 9.58268568e-02f, 9.78378206e-02f, 9.06014256e-03f,
  4.46228683e-02f, 3.36641744e-02f, -2.48307623e-02f, 2.13977378e-02f, -5.31034209e-02f, 8.13283492e-03f, 4.30751219e-02f, -7.22176358e-02f, 1.08280731e-02f, 2.55583860e-02f,
  3.53771634e-02f, 1.48140127e-02f, -5.26641123e-02f, 8.46095458e-02f, -4.30420414e-02f, 1.76156592e-02f, 1.71593223e-02f, -2.49605980e-02f, -2.33092755e-02f, 8.66200551e-02f,
  -2.67891847e-02f, 8.02827533e-03f, 8.17890977e-04f, -1.23788435e-02f, -3.60838808e-02f, -5.62201394e-03f, -2.41830852e-02f, -3.86563018e-02f, 1.14801005e-04f, -1.91850737e-02f,
  1.49238810e-01f, 1.49751455e-01f, 8.89942572e-02f, -4.96672541e-02f, 5.58302179e-02f, -9.12978780e-03f, 2.17155125e-02f, 1.00234911e-01f, 1.51833192e-01f, 1.69313159e-02f,
  1.37365684e-01f, 7.02952519e-02f, 1.93677157e-01f, 1.04347013e-01f, 1.00375809e-01f, 1.19433567e-01f, 5.29009253e-02f, -3.75701836e-03f, 6.02565929e-02f, -5.01591265e-02f,
  2.02438056e-01f, 3.97182703e-01f, 1.85284212e-01f, 2.72567749e-01f, -9.41954479e-02f, 4.35508192e-02f, -2.20647857e-01f, 2.07653805e-03f, -9.34048207e-04f, -6.12488538e-02f,
  1.09718172e-02f, 2.32117593e-01f, -1.55573770e-01f, 3.41699958e-01f, 3.17105204e-01f, -1.17906719e-01f, 1.83582932e-01f, 7.84073584e-03f, -3.41106416e-03f, 2.12442756e-01f,
  1.41929582e-01f, 2.79427052e-01f, 1.23786457e-01f, 9.62869897e-02f, 7.90438429e-02f, 1.51491910e-01f, 1.76259041e-01f, -5.45107983e-02f, 3.14435542e-01f, 1.48192763e-01f,
  1.08794607e-02f, 7.90990815e-02f, -4.37132567e-02f, -8.47790092e-02f, -4.10597920e-02f, -7.26252422e-02f, -5.43906167e-02f, 8.07207748e-02f, -8.98458734e-02f, 2.51148082e-02f,
  -3.03328540e-02f, 9.48727727e-02f, 2.50975452e-02f, 3.50746885e-02f, 5.66912293e-02f, 7.13163614e-02f, -2.27496345e-02f, -3.25810499e-02f, 8.02151784e-02f, 9.00044963e-02f,
  5.21233380e-02f, -5.41129448e-02f, 5.59247062e-02f, -7.20392168e-02f, 1.18675694e-01f, 5.34809753e-02f, -9.69769526e-03f, -4.00260687e-02f, 1.06339723e-01f, 1.43416196e-01f,
  1.09411456e-01f, 1.99379995e-02f, 1.43917268e-02f, -8.25951546e-02f, 9.35669020e-02f, -4.76514250e-02f, 1.07227638e-01f, 1.09508075e-02f, -3.45517360e-02f, 7.78887048e-02f,
  -1.18033690e-02f, -7.21735973e-03f, 5.17782234e-02f, -8.96195788e-03f, 7.13918209e-02f, 4.12380174e-02f, -1.02253206e-01f, -1.84564218e-02f, -7.98787102e-02f, -8.77165198e-02f,
  -4.57865819e-02f, 6.53049126e-02f, 4.22779918e-02f, -4.71088365e-02f, -2.03445051e-02f, 7.98118487e-03f, 5.41702732e-02f, 7.00732693e-02f, -1.51423037e-01f, -1.51551459e-02f,
  2.12690011e-01f, 4.52984989e-01f, -5.15527837e-02f, -5.55239245e-02f, -7.39187002e-02f, 8.82951245e-02f, 1.73298698e-02f, 1.34041026e-01f, 1.39270186e-01f, 9.75606143e-02f,
  -9.29699373e-03f, -1.26654163e-01f, -1.01693375e-02f, -8.58725514e-03f, 7.78031573e-02f, 1.57155573e-01f, -1.22536265e-03f, -1.34963796e-01f, 1.12472437e-01f, 4.56096604e-02f,
  -5.58613567e-04f, -7.47724995e-02f, 1.40291394e-03f, -8.58424380e-02f, -3.12425084e-02f, -8.70249495e-02f, 7.55796582e-02f, 2.23847609e-02f, 3.74934413e-02f, 4.54943031e-02f,
  -7.71987736e-02f, -2.69288272e-01f, 8.28061923e-02f, -1.74153551e-01f, -1.65853545e-01f, -1.63480312e-01f, -2.77094506e-02f, -3.29240054e-01f, -2.11157933e-01f, -1.60460755e-01f,
  -1.51421458e-01f, 2.53421664e-01f, 2.72172451e-01f, -3.36316377e-01f, 5.64839780e-01f, 2.62147814e-01f, -3.07390600e-01f, -3.43088619e-02f, -1.42786786e-01f, -2.39278495e-01f,
  -2.04943135e-01f, -4.22689587e-01f, 1.50816664e-01f, -4.07171339e-01f, -3.60147804e-01f, -2.58177489e-01f, 1.68630570e-01f, -1.58896130e-02f, -2.02159151e-01f, 7.14267269e-02f,
  -1.21351302e-01f, -2.87156135e-01f, -4.30369899e-02f, -1.24519030e-02f, -1.82501063e-01f, 5.67071959e-02f, -7.01138051e-03f, 1.87074736e-01f, -2.12700721e-02f, -1.05782901e-03f,
  5.79730347e-02f, -4.06092852e-02f, -1.76184684e-01f, -2.22699624e-02f, -1.41320005e-01f, -9.69476327e-02f, -4.68832962e-02f, -2.65466068e-02f, -5.85397147e-03f, 8.39008987e-02f,
  2.49321796e-02f, -4.25513424e-02f, -3.72822657e-02f, 5.78986667e-02f, 1.00258462e-01f, -1.41964704e-01f, 1.45884722e-01f, 1.66143641e-01f, 1.89732052e-02f, -4.60033901e-02f,
  1.82588063e-02f, 2.04777066e-02f, -2.91959066e-02f, -4.67025116e-02f, -6.32897019e-02f, -1.59654796e-01f, -4.98689450e-02f, 3.76601852e-02f, 1.98216606e-02f, 1.05767827e-02f,
  -2.92757414e-02f, 8.62571131e-03f, -1.61139090e-02f, -1.96819101e-02f, -4.61639576e-02f, -4.84810844e-02f, 4.94476371e-02f, -2.97574643e-02f, -1.18928842e-01f, 1.81722157e-02f,
  -2.74618343e-03f, -6.61450718e-03f, -1.52348774e-02f, 6.30222112e-02f, -8.72135386e-02f, 1.51422396e-01f, -1.56097010e-01f, -1.75917502e-02f, -8.75737965e-02f, 1.13201745e-01f,
  -1.90163761e-01f, -2.71299034e-01f, -8.17786753e-02f, -1.10826477e-01f, 1.02780923e-01f, -3.54391783e-02f, -8.12785402e-02f, -2.21002698e-02f, -8.40994492e-02f, -1.62867203e-01f,
  -1.87346295e-01f, 9.18300077e-02f, -4.31846641e-02f, -6.79930896e-02f, 1.65036749e-02f, 3.52134630e-02f, 3.15215923e-02f, -4.44089584e-02f, 2.46899389e-02f, -6.78826272e-02f,
  -5.92398718e-02f, 4.50762212e-02f, 1.38454318e-01f, -7.10914508e-02f, 1.18406966e-01f, 6.01147413e-02f, -4.50627431e-02f, -3.86365801e-02f, 6.35446087e-02f, 7.39087723e-03f,
  5.21832228e-01f, 8.00654069e-02f, 3.66904974e-01f, 4.52166378e-01f, -6.81801606e-03f, -3.17192614e-01f, -9.81888697e-02f, 5.74235767e-02f, 3.45845550e-01f, -2.69092266e-02f,
  -9.81667563e-02f, 3.01514685e-01f, -2.18298033e-01f, 1.00932397e-01f, -1.92895427e-01f, -9.95526761e-02f, -4.29201685e-02f, 2.90442575e-02f, 3.05855591e-02f, 1.66761130e-01f,
  1.20192178e-01f, -3.60695064e-01f, -1.53947487e-01f, -3.21629196e-01f, 1.47346124e-01f, 1.05008647e-01f, -3.17316055e-01f, -3.20377618e-01f, -4.45889262e-03f, -2.20760986e-01f,
  1.91919936e-03f, 9.75262299e-02f, 9.98504534e-02f, -8.79294872e-02f, 1.92422140e-02f, -1.37194753e-01f, -2.26307232e-02f, -5.93330525e-02f, -2.21849214e-02f, 1.04708575e-01f,
  4.07869145e-02f, -2.56703049e-02f, -6.77366331e-02f, 6.32910617e-03f, 5.83830997e-02f, 8.25946480e-02f, 8.84576440e-02f, 1.30368948e-01f, 6.82825521e-02f, 7.49101192e-02f,
  1.25384048e-01f, 8.52951258e-02f, 8.07096139e-02f, -5.70623018e-02f, 9.96958092e-02f, 3.50049362e-02f, -1.95361059e-02f, 2.67974157e-02f, 7.97512159e-02f, 9.18387845e-02f,
  2.44902726e-03f, -9.49560925e-02f, -3.72222289e-02f, 8.17058161e-02f, -3.16633396e-02f, -4.09643836e-02f, -1.04621477e-01f, -2.66325548e-02f, -5.20380214e-02f, -4.31561060e-02f,
  1.25020714e-02f, 5.73587269e-02f, 2.85808668e-02f, 4.04148139e-02f, 1.17702633e-01f, 1.04123324e-01f, 1.51451270e-03f, 2.55112685e-02f, 4.60064746e-02f, 1.05762154e-01f,
  6.16272092e-02f, -1.11625113e-01f, 3.47709395e-02f, 2.26868913e-02f, -6.07561506e-02f, -7.75641948e-02f, 6.65371045e-02f, 1.97804078e-01f, 5.33130951e-02f, -4.77064960e-02f,
  -3.27427685e-01f, -3.73104274e-01f, -2.63202917e-02f, 6.90410659e-02f, -2.01859958e-02f, 9.99402404e-02f, -2.51085553e-02f, 1.40988305e-01f, -1.27241328e-01f, 1.02542406e-02f,
  -1.61899310e-02f, -2.92203631e-02f, -3.93877998e-02f, 1.14319488e-01f, -8.02522153e-02f, 3.74892652e-02f, -6.35104924e-02f, -1.37886629e-01f, -1.05169453e-01f, -5.63397631e-02f,
  1.50870429e-02f, -8.33206326e-02f, 3.90349329e-02f, 2.88370289e-02f, 8.94152373e-02f, -4.94616888e-02f, 6.45316914e-02f, 7.63734505e-02f, -6.93779737e-02f, -7.23037124e-02f,
  4.26401794e-01f, -4.98479098e-01f, -1.72569975e-01f, 6.24720044e-02f, 4.08177853e-01f, 2.81369388e-01f, 2.60629386e-01f, -1.97168067e-01f, -2.04580009e-01f, -2.86186486e-01f,
  1.88649476e-01f, -1.36977360e-01f, -1.63116023e-01f, 7.88351521e-02f, 4.49293554e-01f, -2.25752041e-01f, 1.06975555e-01f, 1.60386533e-01f, -1.63672537e-01f, 3.62667032e-02f,
  1.09140668e-02f, 3.16556871e-01f, -1.08134098e-01f, -1.49353981e-01f, 2.13759214e-01f, -1.61824420e-01f, 9.33033694e-03f, -2.69452576e-02f, 6.74143387e-03f, 1.79698303e-01f,
  7.33562484e-02f, -9.01471898e-02f, 5.56193013e-03f, -1.75510701e-02f, -1.49348959e-01f, 3.14111300e-02f, 5.77156320e-02f, 1.68615520e-01f, 6.25811741e-02f, -5.72887547e-02f,
  3.66611108e-02f, 3.59057146e-03f, -3.78165022e-03f, 4.91289906e-02f, 2.65858928e-03f, 1.96922831e-02f, -8.31582323e-02f, 3.27979960e-02f, -2.79708952e-01f, -3.32570192e-03f,
  -2.34404039e-02f, -3.43031660e-02f, 8.70167539e-02f, -1.04908094e-01f, -1.08305506e-01f, -5.74190468e-02f, -1.23641463e-02f, -1.55454651e-01f, -3.78239825e-02f, -1.99987032e-02f,
  -3.50150876e-02f, -1.42207183e-02f, -1.65729057e-02f, 1.75402174e-03f, 6.29071333e-03f, 8.47619772e-02f, 7.92185739e-02f, -4.20958214e-02f, -4.19973582e-02f, 1.62089784e-02f,
  6.19583465e-02f, 6.49394244e-02f, -3.54862623e-02f, 2.05974225e-02f, 6.27110824e-02f, 3.76671292e-02f, 5.42711951e-02f, 2.93338317e-02f, -6.26670420e-02f, -4.40911129e-02f,
  5.88048808e-02f, -3.71568203e-02f, 1.00128492e-02f, -9.22575146e-02f, 5.39859459e-02f, -5.10111861e-02f, -7.60879070e-02f, 4.17005457e-03f, -4.18462530e-02f, 1.37739480e-01f,
  -1.84683017e-02f, -2.65126467e-01f, -1.15627550e-01f, 5.97437173e-02f, -1.11667469e-01f, -7.21591711e-02f, 3.43866162e-02f, -8.24806392e-02f, 2.03759447e-02f, 4.99631763e-02f,
  -4.90742587e-02f, 7.51209706e-02f, 4.09490056e-02f, -1.28715923e-02f, 5.31944074e-02f, -3.00740320e-02f, -2.61159129e-02f, -4.26285081e-02f, -4.37240042e-02f, -1.49109224e-02f,
  3.63284647e-02f, 8.75197798e-02f, 1.58912480e-01f, -2.59097256e-02f, -8.26127306e-02f, 2.87839286e-02f, -3.97384092e-02f, 3.96439619e-02f, 3.91394831e-02f, -3.84293944e-02f,
  -9.54778418e-02f, 3.21250498e-01f, -2.00189576e-01f, 3.63546424e-02f, -2.76952207e-01f, 5.45129836e-01f, 4.78630722e-01f, -1.46663934e-01f, 1.44332558e-01f, 4.36389506e-01f,
  2.27637440e-02f, 1.67667389e-01f, 2.99846262e-01f, 3.67373765e-01f, 2.33374342e-01f, 3.57169598e-01f, 3.10399771e-01f, 3.69904935e-01f, -9.12541598e-02f, 4.14712913e-02f,
  -5.29401042e-02f, 2.78244674e-01f, -1.08251281e-01f, -8.45865607e-02f, -1.31488323e-01f, -3.70911866e-01f, -2.48830900e-01f, -3.20507884e-01f, -9.27829370e-02f, -1.04610495e-01f,
  9.85138640e-02f, -2.52301991e-02f, -8.99327248e-02f, -1.22568784e-02f, -5.60813472e-02f, 5.35898022e-02f, -2.18815375e-02f, -6.68651015e-02f, -2.06190050e-01f, 4.14149016e-02f,
  7.85704628e-02f, -3.85502614e-02f, 1.26208782e-01f, -8.40698183e-02f, -4.33534272e-02f, -6.96607083e-02f, -7.07566068e-02f, -8.63992125e-02f, 3.77309462e-03f, 4.70544584e-03f,
  -3.95981409e-02f, -7.41252080e-02f, -3.07386462e-02f, 2.96373889e-02f, -1.19948201e-01f, -5.50031140e-02f, 7.20792785e-02f, -4.89131063e-02f, 6.26944900e-02f, 1.04826756e-01f,
  4.59131226e-02f, 6.70216754e-02f, 1.43003494e-01f, -3.95409800e-02f, 8.65954757e-02f, -7.45788515e-02f, 3.23325917e-02f, -5.70691284e-03f, -8.46072659e-02f, 9.88756269e-02f,
  -5.41014411e-02f, -2.56386083e-02f, -2.52110213e-02f, 3.70484926e-02f, 1.74166057e-02f, -2.55164802e-02f, -7.20327571e-02f, 3.33961248e-02f, -9.05906484e-02f, -3.13597359e-02f,
  7.26473108e-02f, 9.34943333e-02f, 3.30272615e-02f, 2.17707502e-03f, -2.98568215e-02f, -1.85571481e-02f, 5.17573692e-02f, -8.32091346e-02f, -4.66504581e-02f, -2.87372842e-02f,
  1.27299726e-01f, 2.67300397e-01f, -1.26836700e-02f, 2.93532964e-02f, -7.05727637e-02f, -2.95177344e-02f, 8.40829238e-02f, 8.30085799e-02f, 2.52498724e-02f, 9.19742808e-02f,
  2.33162642e-02f, 4.10276651e-02f, 2.67686453e-02f, -6.32088333e-02f, -4.26882617e-02f, 3.77130471e-02f, 1.37352586e-01f, -6.04157634e-02f, -5.10791317e-02f, -9.51974168e-02f,
  2.39756200e-02f, 2.42164619e-02f, 6.68034703e-02f, -1.79891642e-02f, 1.05814207e-02f, 3.47119868e-02f, -6.28954321e-02f, -1.16275534e-01f, -4.24643271e-02f, 1.07261099e-01f,
  3.64624918e-01f, -3.51377018e-02f, -3.93152803e-01f, -3.48855793e-01f, 1.07859842e-01f, 3.24995577e-01f, -3.22210267e-02f, 6.59546107e-02f, -2.80210137e-01f, 1.59839794e-01f,
  2.54187316e-01f, -1.32304564e-01f, -1.46320939e-01f, -3.69274504e-02f, 1.03313245e-01f, -1.63546190e-01f, 1.35053560e-01f, 5.90065233e-02f, -1.03942275e-01f, 2.61910677e-01f,
  1.42527670e-02f, 4.03076023e-01f, -1.80199385e-01f, 1.69469982e-01f, 1.81317270e-01f, -1.36584714e-01f, 5.61885312e-02f, -8.38068500e-02f, 9.81781781e-02f, 1.11828536e-01f,
  8.19429904e-02f, 6.60821274e-02f, 4.33354452e-02f, -5.41694649e-02f, 1.39237955e-01f, 1.69497967e-01f, -3.43149677e-02f, -6.04499206e-02f, -6.96071610e-02f, -4.45678132e-03f,
  3.59802581e-02f, -5.25627136e-02f, -8.88597406e-03f, -1.31376162e-01f, 9.35310423e-02f, 2.36870791e-03f, -5.35504054e-03f, -8.26205388e-02f, -5.07475398e-02f, 6.76085576e-02f,
  -4.09816541e-02f, -8.57946947e-02f, -9.99601111e-02f, -2.10858390e-01f, -8.50991607e-02f, -5.14017381e-02f, -3.70233394e-02f, 2.85880640e-02f, -3.91457975e-02f, 4.25330251e-02f,
  1.55642584e-01f, 1.39599210e-02f, 1.26685098e-01f, -1.36144552e-02f, 6.10721149e-02f, -6.26109540e-03f, -2.05859747e-02f, -3.22403572e-02f, 1.24645429e-02f, 6.39834702e-02f,
  -2.54060794e-02f, -3.29674482e-02f, -2.70953681e-02f, 2.85123065e-02f, 1.23999745e-01f, -4.40964326e-02f, 1.54593559e-02f, 7.61025865e-03f, -9.34306160e-02f, -7.18966797e-02f,
  -8.47307593e-02f, 8.58944934e-03f, -1.97310001e-02f, -3.25921625e-02f, 4.04961295e-02f, -1.47600379e-02f, 1.19543232e-01f, -8.00014138e-02f, -5.15603237e-02f, -2.30390485e-02f,
  7.23653957e-02f, 1.39312893e-01f, -4.58605252e-02f, -8.95952731e-02f, -9.69583541e-02f, 1.63125038e-01f, -6.43176436e-02f, 6.28103539e-02f, -1.23792868e-02f, 2.44033188e-02f,
  1.26261637e-01f, -1.19782910e-01f, 8.68071169e-02f, 6.02833973e-03f, -9.96783301e-02f, 1.44812614e-01f, -3.86770517e-02f, -1.01409256e-01f, -1.15169464e-02f, 1.91360395e-02f,
  -1.12411929e-02f, 1.25991017e-01f, -8.15809220e-02f, -2.76868585e-02f, 1.58719812e-02f, 3.12402248e-02f, 1.26964033e-01f, -6.21427037e-03f, -8.84098746e-03f, -5.52017204e-02f,
  2.62840003e-01f, -1.61467180e-01f, 1.80654958e-01f, 2.72231013e-01f, 1.33525357e-01f, -1.99143618e-01f, -1.10590905e-01f, 2.11385284e-02f, 3.28729659e-01f, -3.00852180e-01f,
  -7.76260048e-02f, 1.49197325e-01f, -2.67435551e-01f, 1.42442241e-01f, -1.93086267e-01f, -2.58289397e-01f, 1.36597291e-01f, 7.72604346e-03f, 1.49485141e-01f, 2.70517985e-03f,
  1.36624053e-01f, -1.51594100e-03f, 5.94212823e-02f, -1.92168187e-02f, 1.61469564e-01f, 1.80992901e-01f, -1.54876620e-01f, -9.67357680e-02f, -1.57266855e-02f, -1.92333979e-03f,
  1.03178166e-01f, 6.98497221e-02f, -1.14684463e-01f, -5.78105077e-02f, -1.05992146e-03f, -1.17032547e-02f, -9.57457125e-02f, -1.28665820e-01f, -1.27833523e-02f, -1.10788159e-01f,
  2.32408009e-02f, -5.38392924e-03f, 1.17377594e-01f, -1.04196435e-02f, -2.24899203e-02f, 1.27120942e-01f, 1.63233876e-01f, 1.22045074e-02f, 1.71526998e-01f, 1.54975981e-01f,
  1.71658784e-01f, -3.91432717e-02f, 1.14625208e-01f, -4.74230349e-02f, 3.68879586e-02f, -1.34504661e-01f, 4.91992384e-02f, -1.09805033e-01f, 6.26919642e-02f, 2.08771732e-02f,
  -1.89117953e-01f, 3.07669141e-03f, 3.55936810e-02f, 1.77658759e-02f, 5.92364818e-02f, 9.45172310e-02f, 6.01685382e-02f, 2.82348059e-02f, 7.45479912e-02f, -1.23010660e-02f,
  -5.49213104e-02f, -8.35194886e-02f, 1.55130640e-01f, 1.35028377e-01f, -4.52191606e-02f, 7.40052909e-02f, -1.25986919e-01f, -2.88237818e-02f, -8.97944719e-03f, 1.92624796e-02f,
  -6.37579418e-04f, 5.42371832e-02f, 5.39944135e-03f, 7.41091147e-02f, -9.86930951e-02f, 4.64298949e-02f, 1.08794272e-01f, -5.78843579e-02f, -6.49862140e-02f, -5.77395819e-02f,
  -1.31375849e-01f, -3.84896308e-01f, -1.60273686e-01f, -2.37959754e-02f, -8.75621662e-02f, -8.88002068e-02f, 2.09304672e-02f, 3.04035959e-03f, -1.08572155e-01f, 2.93470360e-02f,
  2.52891704e-03f, 8.05045217e-02f, -3.22528556e-02f, -1.47312984e-01f, -1.36380926e-01f, -2.96898186e-02f, 2.18255427e-02f, -8.82298276e-02f, -7.47216195e-02f, -4.10131738e-02f,
  5.04801795e-02f, -6.42239153e-02f, -5.30819707e-02f, 6.31177612e-03f, -7.66803976e-03f, -1.01707503e-01f, 5.19322678e-02f, -1.12125657e-01f, -2.84596309e-02f, 2.83208825e-02f,
  2.61752129e-01f, 5.56162298e-01f, 4.56761450e-01f, -6.16737315e-03f, -3.85905415e-01f, 1.61800340e-01f, -8.10534786e-03f, 1.02059841e-01f, 2.75459558e-01f, 1.65473163e-01f,
  -3.03471595e-01f, 5.45444191e-01f, -2.38032124e-04f, 1.29316792e-01f, -1.42169714e-01f, -2.40866974e-01f, 2.62094103e-02f, 1.12635054e-01f, -3.14647448e-03f, 8.78035352e-02f,
  -1.77666083e-01f, -5.28906107e-01f, -1.68538332e-01f, -2.72676229e-01f, -9.20734648e-03f, 2.25195244e-01f, -3.42539400e-01f, -1.09050393e-01f, 7.91056603e-02f, -5.77894598e-02f,
  -5.36835305e-02f, 4.77629639e-02f, 1.26745179e-01f, 2.06924722e-01f, 8.66159506e-04f, 4.59063165e-02f, 2.88278107e-02f, -5.07768355e-02f, 2.36474331e-02f, 1.10371947e-01f,
  2.16322625e-03f, -7.62981996e-02f, 8.07875171e-02f, -3.23561765e-02f, -2.02978961e-02f, 5.74908219e-02f, 9.87931713e-03f, 5.06702773e-02f, 2.41044238e-02f, -1.40389903e-02f,
  -4.32259776e-02f, 1.85537383e-01f, -6.33735359e-02f, 6.83110580e-02f, 1.91966426e-02f, 4.12284806e-02f, 7.15004206e-02f, 1.61345564e-02f, 2.54093446e-02f, 7.10013732e-02f,
  -1.02296183e-02f, -8.02026242e-02f, -7.65932426e-02f, -6.63100854e-02f, -4.47266065e-02f, 5.99815361e-02f, -1.90082248e-02f, -6.19019978e-02f, 8.43914822e-02f, -4.19791304e-02f,
  1.67504288e-02f, 4.14883271e-02f, -1.12731822e-01f, 4.64039929e-02f, -9.03449133e-02f, 5.02782762e-02f, 2.81868353e-02f, 5.58422245e-02f, 1.15634594e-02f, 1.73504762e-02f,
  1.86044630e-02f, -3.03460918e-02f, -7.28905052e-02f, -6.49835467e-02f, 2.13421267e-02f, 5.39059415e-02f, 4.93308483e-03f, 4.95311990e-02f, -6.90746233e-02f, -8.40947852e-02f,
  1.21212289e-01f, 2.94674426e-01f, 1.32697104e-02f, 2.52949148e-02f, 1.16844289e-02f, -5.27604595e-02f, 2.75717843e-02f, 1.31449163e-01f, 1.08440213e-01f, -4.64140363e-02f,
  -5.34853479e-03f, -1.64988954e-02f, 4.66165915e-02f, -9.61498022e-02f, 1.69105530e-02f, 2.28441358e-02f, -2.39826757e-02f, 1.46642268e-01f, 1.54538974e-02f, 8.90472159e-03f,
  -2.52543017e-02f, -1.07087918e-01f, 3.05365995e-02f, -4.89387661e-02f, -4.93339933e-02f, -2.16499995e-03f, 1.00850770e-02f, 1.26026109e-01f, -1.01566255e-01f, 1.71672385e-02f,
  -1.22297533e-01f, -4.41295385e-01f, -3.50292563e-01f, 7.01689646e-02f, 2.95491934e-01f, 2.74434686e-01f, -2.15740457e-01f, 1.50959551e-01f, -1.91383347e-01f, -2.77268626e-02f,
  1.97824150e-01f, -1.96338929e-02f, -4.26701725e-01f, 4.19163764e-01f, 3.33086073e-01f, -2.96253920e-01f, 3.29078257e-01f, 2.33875513e-01f, -6.57439977e-02f, 3.36661972e-02f,
  1.88870743e-01f, 5.61185360e-01f, 9.87310335e-02f, 4.10553306e-01f, 1.98392078e-01f, -6.58200309e-02f, 4.29480746e-02f, -1.82510734e-01f, 3.61000121e-01f, 3.30330551e-01f,
  1.34733319e-01f, -1.37273118e-01f, -4.62110527e-02f, 6.78607896e-02f, -7.46465176e-02f, 3.49502079e-02f, -4.02816795e-02f, 6.16923124e-02f, 3.87642812e-03f, 1.27214435e-02f,
  -9.48948115e-02f, 1.38787299e-01f, 1.49925947e-01f, -2.40473426e-03f, 7.47855678e-02f, 6.15093037e-02f, -2.16124114e-02f, 3.65448482e-02f, 5.14132567e-02f, -3.83187905e-02f,
  -1.52288288e-01f, 4.26735431e-02f, -2.68872492e-02f, 8.38929638e-02f, -4.39106487e-02f, 7.24616274e-03f, -2.16835756e-02f, -4.83823344e-02f, -6.38324162e-03f, 5.88058420e-02f,
  6.55685887e-02f, -8.26354772e-02f, -8.83061439e-02f, 2.14124881e-02f, -1.04147062e-01f, 6.94985762e-02f, -1.27037158e-02f, 3.16503383e-02f, -5.23336791e-02f, -9.48652904e-03f,
  9.01178196e-02f, -1.19700318e-03f, 2.17111558e-02f, 2.78405682e-03f, -2.03716904e-02f, -6.51224554e-02f, -6.16018176e-02f, 8.60752761e-02f, -2.53260974e-02f, 8.35337564e-02f,
  1.78549029e-02f, 1.55020617e-02f, -4.28852513e-02f, 2.20393427e-02f, 4.30381075e-02f, -2.23879260e-03f, 7.27251545e-02f, -3.23446863e-03f, -6.89853504e-02f, 3.40612084e-02f,
  -5.72432652e-02f, -2.48267680e-01f, -3.98762375e-02f, 1.28654718e-01f, -9.04837437e-03f, 2.30038352e-02f, 2.29607280e-02f, 1.18697025e-01f, -5.97000159e-02f, -9.69304815e-02f,
  1.47206172e-01f, -1.12356665e-02f, -5.80401942e-02f, 1.64566621e-01f, 9.63664204e-02f, -1.91111751e-02f, -8.13827291e-02f, -2.29346156e-02f, 1.51149839e-01f, 8.49044845e-02f,
  -7.36994520e-02f, -1.06227525e-01f, 6.58905506e-02f, 3.24740484e-02f, 9.54098776e-02f, -6.33096099e-02f, 2.30910536e-02f, -1.61744170e-02f, 2.47958843e-02f, -2.25306768e-02f,
  3.70828032e-01f, -4.20574844e-01f, 6.92627206e-02f, 3.88836741e-01f, 3.95634979e-01f, 1.01933271e-01f, 5.30468702e-01f, -2.42060050e-02f, 2.41933256e-01f, -4.09788698e-01f,
  -8.48836303e-02f, -1.01593874e-01f, -2.66016006e-01f, -5.88118359e-02f, 2.85821557e-01f, -9.87328663e-02f, 3.25840861e-02f, 2.77658030e-02f, 8.07186291e-02f, -6.43905848e-02f,
  1.94118634e-01f, 5.88262267e-02f, 7.28782415e-02f, -2.23261908e-01f, 3.45393606e-02f, -1.76728144e-02f, -1.75568927e-02f, 8.32072869e-02f, -6.93606511e-02f, 1.23897560e-01f,
  1.89180505e-02f, 1.84409976e-01f, 1.37958735e-01f, -8.43715221e-02f, -9.80796739e-02f, -1.19492095e-02f, 4.03428636e-02f, 3.67194973e-02f, 1.06606431e-01f, -1.52867232e-02f,
  -8.17627609e-02f, 2.28403732e-02f, 4.02849503e-02f, 4.84352633e-02f, 1.38756797e-01f, -5.49503267e-02f, 1.72623084e-03f, -9.54815149e-02f, 1.84601936e-02f, -7.88772628e-02f,
  -7.57368729e-02f, -5.40032163e-02f, 2.95489142e-03f, -4.44199070e-02f, 5.19721918e-02f, 8.39486420e-02f, 7.82611668e-02f, 4.81842719e-02f, 4.13615368e-02f, 4.28159088e-02f,
  2.85599250e-02f, 9.79236979e-03f, 3.22068259e-02f, 9.76627972e-03f, -4.17453423e-02f, 2.62888446e-02f, 4.59923968e-02f, -7.43112899e-03f, -1.51890870e-02f, -4.39572558e-02f,
  5.59263676e-02f, 8.39780197e-02f, -9.32353176e-03f, 4.44623232e-02f, 8.69565234e-02f, 1.25134420e-02f, 4.88672964e-02f, -5.11467941e-02f, -1.36308779e-03f, 3.87357958e-02f,
  -6.90573966e-03f, 2.65955832e-02f, -6.80289119e-02f, 3.42644118e-02f, -1.45072266e-02f, 3.32736447e-02f, -3.93077657e-02f, -1.62984133e-01f, 4.30686027e-02f, -5.28656356e-02f,
  -3.47647071e-01f, -2.51079440e-01f, 5.33406958e-02f, -3.09749432e-02f, -8.29489529e-02f, -8.97471309e-02f, 3.32970172e-02f, -3.44806514e-03f, -2.55879834e-02f, 5.02279848e-02f,
  -9.88169201e-03f, -3.98010807e-03f, -8.75889510e-03f, 2.04709210e-02f, 3.52130271e-02f, 1.61203854e-02f, 4.62074764e-02f, -4.87644337e-02f, 9.70115215e-02f, -9.01924893e-02f,
  -1.33393198e-01f, 6.20343769e-03f, 7.29273586e-03f, 8.64033252e-02f, 4.51996457e-03f, 2.00426634e-02f, 1.56041537e-03f, -2.75092684e-02f, -1.72335543e-02f, 1.87501416e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  3.24619383e-01f, 3.74027044e-02f, 3.80829453e-01f, 2.70650536e-01f, 1.60358518e-01f, 4.09533530e-01f, 3.75181526e-01f, 3.04862559e-01f, 5.14656961e-01f, 4.23600584e-01f,
  2.37101659e-01f, 2.59820968e-01f, 2.52407104e-01f, 2.04865769e-01f, 4.24577177e-01f, 2.24635497e-01f, 3.69081527e-01f, 3.54351342e-01f, 1.63692847e-01f, 2.99162239e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -8.70320275e-02f, 7.52993301e-02f, -1.28422394e-01f, 1.81213334e-01f, -5.90045378e-02f, 3.91985662e-02f, 3.18261683e-01f, -1.64543107e-01f, 2.73288310e-01f, -1.50826931e-01f,
  1.29004091e-01f, 9.95130911e-02f, -5.21771088e-02f, 1.98402599e-01f, -2.64753878e-01f, -2.04211950e-01f, 5.17268665e-02f, -4.32161428e-02f, -8.15557316e-02f, -3.85805011e-01f,
  -1.92056894e-01f, 7.63490796e-02f, -2.55493168e-03f, 1.36688784e-01f, 2.51672119e-01f, 1.42548695e-01f, -1.10187151e-01f, -1.88000247e-01f, 1.60918027e-01f, 3.58660445e-02f,
  1.42418342e-02f, 2.74339080e-01f, 3.37288320e-01f, 9.90393981e-02f, -1.12387575e-01f, 2.99989954e-02f, 5.39319497e-03f, 3.46436794e-03f, 2.23314941e-01f, 2.15745300e-01f,
  -3.09556425e-01f, 5.39042838e-02f, 1.07468314e-01f, -2.77952403e-01f, -7.63356760e-02f, 6.07178509e-02f, 1.44084990e-01f, 2.63681114e-02f, -9.22141522e-02f, 1.29039109e-01f,
  1.98584840e-01f, 4.27996553e-02f, -2.15178296e-01f, -3.06635737e-01f, -1.66653991e-01f, 3.15073699e-01f, -2.85095155e-01f, 7.45135248e-02f, 2.68062770e-01f, -2.30731778e-02f,
  -1.55814722e-01f, -8.98687541e-02f, -1.86493620e-01f, -6.51106536e-02f, 1.94366857e-01f, 4.84745130e-02f, 6.40344322e-02f, -9.24803242e-02f, 1.31954163e-01f, 2.10395139e-02f,
  -1.41260237e-01f, -7.97623992e-02f, 1.44851487e-02f, 8.34410861e-02f, -9.35757011e-02f, 1.31246686e-01f, -2.83954442e-01f, -3.40877116e-01f, 2.02422500e-01f, 1.00486614e-01f,
  1.81696460e-01f, -6.90424666e-02f, -6.64967671e-02f, 2.17969865e-01f, 1.36525929e-01f, -1.91711187e-02f, 2.06327066e-01f, -1.37795523e-01f, 1.63222738e-02f, -2.54921049e-01f,
  2.91781574e-01f, 1.03385143e-01f, -1.25821531e-01f, 2.53302068e-01f, 2.93564051e-01f, -3.27416271e-01f, -1.42486766e-01f, 1.09599739e-01f, 1.30475327e-01f, 6.83326125e-02f,
  1.05035361e-02f, 1.51594654e-01f, 3.58005345e-01f, -2.77093887e-01f, 1.74295753e-01f, -5.02251238e-02f, -1.58974111e-01f, 3.39918882e-01f, -3.63902420e-01f, -1.94721982e-01f,
  8.37998316e-02f, 2.74310023e-01f, 5.58543652e-02f, -6.92427307e-02f, -1.36679888e-01f, -7.97128603e-02f, -5.12033589e-02f, 1.60454556e-01f, 2.46480137e-01f, -2.68076450e-01f,
  1.71675384e-01f, 6.54157177e-02f, 1.40165165e-01f, -3.13994549e-02f, 1.11269213e-01f, 1.69950947e-01f, 4.63082902e-02f, 5.83014339e-02f, -3.14724669e-02f, 1.40892923e-01f,
  1.09100007e-02f, 1.22705445e-01f, 1.69618487e-01f, 8.89457986e-02f, 2.96599090e-01f, -1.21067189e-01f, 1.88321277e-01f, -1.02761671e-01f, 2.05888256e-01f, 1.26605824e-01f,
  -1.63859844e-01f, 2.22298160e-01f, -1.08869135e-01f, 1.56128490e-02f, -1.14852235e-01f, 1.26327157e-01f, 2.05053613e-02f, -1.44813940e-01f, -2.83054173e-01f, -1.28527479e-02f,
  -2.30424643e-01f, 1.04288496e-01f, 1.41502887e-01f, -2.63846722e-02f, 2.40035459e-01f, -6.28890619e-02f, 1.56392843e-01f, -7.24603385e-02f, -3.22985142e-01f, 2.67763704e-01f,
  1.48552924e-01f, -2.27790266e-01f, -1.24594681e-01f, -1.19678959e-01f, -1.13600604e-01f, 7.05727562e-02f, 2.08760500e-01f, -6.24362864e-02f, -1.65266514e-01f, 1.23151220e-01f,
  -9.77379084e-02f, -3.17612626e-02f, -1.88652426e-01f, 3.99137335e-03f, -1.00057729e-01f, -6.12959489e-02f, 1.41686440e-01f, -2.24933356e-01f, -5.74712753e-02f, 1.89508796e-01f,
  -2.59230793e-01f, -6.21371716e-02f, 2.06660584e-01f, 3.70836735e-01f, -2.20734719e-02f, 2.05093920e-01f, 2.09423095e-01f, -6.26857355e-02f, -1.80863172e-01f, -2.63308525e-01f,
  1.80842698e-01f, -2.75019221e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  4.19117361e-01f, 7.53600821e-02f, 2.29251366e-02f, 1.03782989e-01f, -6.81032538e-02f, -1.17951691e-01f, -5.14066778e-02f, 1.05201155e-01f, -3.11439008e-01f, -1.27970919e-01f,
  2.19928652e-01f, -2.96677351e-01f, 1.37558013e-01f, -7.39592826e-04f, -3.57804537e-01f, 1.82564035e-01f, 6.09402001e-01f, 5.74476086e-02f, 5.35806835e-01f, -1.14486739e-01f,
  3.97333652e-01f, -3.29898983e-01f, 2.18540691e-02f, 3.99109483e-01f, 4.00923669e-01f, 7.75788873e-02f, -4.69088376e-01f, -7.31562311e-03f, 2.54103154e-01f, 4.62988198e-01f,
  4.01303053e-01f, 4.58197109e-03f, 9.03372616e-02f, -1.89264596e-01f, 3.31875831e-02f, -3.11023686e-02f, 1.73924938e-01f, 2.30358839e-02f, -3.99537176e-01f, 1.65874615e-01f,
  2.53220379e-01f, -6.56727925e-02f, -4.54465300e-02f, -2.37319767e-01f, 6.07000530e-01f, 5.95079660e-01f, -2.46975687e-03f, -1.59609914e-01f, 1.14272103e-01f, 6.73677027e-02f,
  5.77739254e-03f, 8.96970555e-02f, 6.86890543e-01f, 1.70652986e-01f, -1.20757967e-01f, -6.08494841e-02f, 3.43413055e-01f, -1.22739807e-01f, -4.05659139e-01f, -2.33961456e-02f,
  3.79610747e-01f, 2.93819815e-01f, 4.19553876e-01f, 4.31457832e-02f, 4.79977876e-02f, -1.38869375e-01f, 4.28104103e-02f, 1.38629943e-01f, 9.25518945e-03f, -1.02445573e-01f,
  -2.61051059e-01f, 9.19702426e-02f, 8.05625841e-02f, -5.43146543e-02f, 3.91315877e-01f, -3.04338425e-01f, 4.31510359e-01f, 3.54346156e-01f, -2.97187984e-01f, -2.54792869e-01f,
  2.79809117e-01f, 3.46197903e-01f, 4.45806295e-01f, -2.76763678e-01f, 5.29775918e-01f, -1.12605356e-01f, -2.38812968e-01f, 2.47485995e-01f, 3.89000267e-01f, 5.02950810e-02f,
  -4.43174541e-01f, 1.89755619e-01f, 3.77341598e-01f, 1.52085319e-01f, 4.76704746e-01f, 2.14122146e-01f, 2.39334092e-01f, 3.96521240e-02f, 4.37091589e-01f, 1.24061711e-01f,
  2.72892654e-01f, 9.67234075e-02f, -1.84914321e-01f, -2.91621357e-01f, -8.68272930e-02f, 3.96150261e-01f, -2.25140452e-01f, 4.78846014e-01f, -1.28569439e-01f, 3.45831305e-01f,
  5.46260417e-01f, 8.37454274e-02f, -4.82553542e-01f, 2.67360836e-01f, 1.58911616e-01f, 2.88009375e-01f, -2.14911491e-01f, 4.93588038e-02f, 1.59740835e-01f, -1.80652142e-01f,
  1.01161174e-01f, 8.58118311e-02f, 6.40023351e-01f, 5.77064455e-01f, -1.26485303e-01f, -2.36089136e-02f, -7.70688802e-02f, -2.00143844e-01f, 2.70480782e-01f, -2.37550080e-01f,
  1.07917979e-01f, 5.15277386e-02f, 1.61948323e-01f, 4.40378748e-02f, -2.42738668e-02f, 1.33198285e-02f, -1.27379790e-01f, 4.03122604e-01f, -1.80062413e-01f, 3.20946157e-01f,
  1.74757332e-01f, -7.76998177e-02f, 4.44653660e-01f, 2.41661504e-01f, 5.53888023e-01f, 2.05204740e-01f, -3.57952267e-02f, 4.66050863e-01f, 1.89930320e-01f, 1.80916395e-02f,
  4.33752090e-01f, -1.45432115e-01f, -4.07449633e-01f, 3.85667346e-02f, 4.51375067e-01f, 1.14142194e-01f, -1.95453182e-01f, 1.06947877e-01f, 6.24553382e-01f, -2.27365747e-01f,
  3.17069799e-01f, 3.21583152e-01f, -1.98228478e-01f, -1.04733147e-02f, 4.41646650e-02f, -9.63670388e-02f, 1.62844434e-02f, 6.26337230e-01f, -4.34643924e-01f, 7.01505914e-02f,
  4.70497131e-01f, -6.52342081e-01f, 5.55091977e-01f, 2.62501895e-01f, 8.13001171e-02f, -1.59482099e-02f, 1.13922447e-01f, -1.11179493e-01f, 1.89620435e-01f, 7.15722084e-01f,
  2.67845541e-01f, -2.71785557e-01f, -3.47848743e-01f, 7.39734411e-01f, -2.88916737e-01f, 1.43852159e-01f, 2.26276800e-01f, -2.28183508e-01f, -1.82492584e-01f, -1.13251232e-01f,
  6.20570034e-02f, 4.30892520e-02f, 4.73352261e-02f, -4.29342687e-01f, -2.57922739e-01f, -1.62866220e-01f, -2.02911079e-01f, -1.31480590e-01f, 3.53419572e-01f, 1.56136835e-02f,
  4.10189301e-01f, -1.81286395e-01f, -3.56604636e-01f, -1.02095984e-01f, 5.28252065e-01f, 7.15102375e-01f, -1.90869674e-01f, 1.35011494e-01f, 4.12873656e-01f, -4.68933344e-01f,
  -3.59551847e-01f, 9.00791511e-02f, 4.02030319e-01f, -2.86843590e-02f, 4.39298242e-01f, 2.35375732e-01f, 3.15165997e-01f, -8.81892368e-02f, -3.11229080e-01f, -4.69113514e-02f,
  3.49039078e-01f, 1.64421484e-01f, 1.53492615e-01f, -5.80707900e-02f, 1.25237823e-01f, -1.89943835e-01f, 4.38100696e-02f, 1.56253830e-01f, 1.47467092e-01f, -1.37609273e-01f,
  -4.42926101e-02f, 3.89217019e-01f, -2.21115910e-02f, -8.87153223e-02f, 2.13293191e-02f, -3.30513656e-01f, 5.31120658e-01f, 4.75893885e-01f, 4.80530202e-01f, 2.47445807e-01f,
  6.16067111e-01f, 4.39508766e-01f, 9.45813209e-03f, 6.05726302e-01f, 9.84428376e-02f, -1.74134389e-01f, 1.67920053e-01f, 1.51939809e-01f, -2.99065500e-01f, -5.20406306e-01f,
  2.91481555e-01f, -2.39855915e-01f, -6.09111078e-02f, 8.20530578e-02f, -4.08690646e-02f, -2.39158064e-01f, -4.62194206e-03f, 4.33637649e-01f, 1.57279015e-01f, 5.63896168e-03f,
  1.31642644e-03f, 1.31345406e-01f, -2.38214493e-01f, -1.11445524e-01f, 5.63147515e-02f, -2.33998135e-01f, -3.38319302e-01f, 3.13867092e-01f, -1.79555818e-01f, -2.52831340e-01f,
  -1.19182162e-01f, 2.64639318e-01f, 2.72442102e-01f, -3.43428493e-01f, -1.64164424e-01f, 1.83229238e-01f, 3.05267990e-01f, 4.82197911e-01f, 3.40727180e-01f, -3.19050215e-02f,
  2.86434799e-01f, -2.59639144e-01f, -1.99597582e-01f, 1.54042140e-01f, 1.03371978e-01f, 3.64885330e-01f, -8.59901458e-02f, -3.69144052e-01f, 1.12316281e-01f, 3.54516834e-01f,
  1.73331872e-01f, 6.98636994e-02f, 3.50053221e-01f, 4.99391146e-02f, -4.58736181e-01f, 4.02110696e-01f, 2.59177357e-01f, -3.24964672e-01f, -9.22231749e-02f, -1.02523066e-01f,
  6.07343435e-01f, 2.00924039e-01f, 2.07194433e-01f, 1.96135178e-01f, -8.15537274e-02f, 2.51136303e-01f, 7.90113285e-02f, 1.80216581e-01f, 6.72981143e-01f, 3.83765399e-01f,
  -2.57399559e-01f, -1.77466229e-01f, 1.84313864e-01f, -3.90741557e-01f, 1.41340373e-02f, 8.89340565e-02f, 2.19709337e-01f, 5.20309567e-01f, -1.59189418e-01f, -1.30283505e-01f,
  2.56525218e-01f, 4.13689315e-02f, 1.33941665e-01f, 2.23225564e-01f, 2.41140798e-01f, 3.41327093e-03f, 4.18407619e-01f, 8.40269960e-03f, 2.55714148e-01f, -3.60734254e-01f,
  5.25260391e-03f, 3.30968559e-01f, 6.14702422e-03f, 5.41819930e-01f, 3.03424716e-01f, 1.16579562e-01f, 3.11013401e-01f, 1.07996754e-01f, -1.98484167e-01f, -3.67994815e-01f,
  -1.49151847e-01f, -2.30834648e-01f, 4.88695294e-01f, 4.06969070e-01f, 3.04641783e-01f, -4.70467687e-01f, 4.78918493e-01f, -1.12499006e-01f, 1.27726868e-01f, 4.77837443e-01f,
  -3.05150717e-01f, -2.05175743e-01f, -1.81959629e-01f, 1.11459561e-01f, 3.30291927e-01f, 1.10591337e-01f, 2.75258124e-01f, 3.01283449e-01f, -1.87532246e-01f, -5.92941821e-01f,
  1.80651456e-01f, 5.27000502e-02f, -1.68334574e-01f, 6.07547760e-01f, -2.95933157e-01f, -1.98452502e-01f, 1.91352338e-01f, 4.22194421e-01f, 1.20219640e-01f, 1.11679696e-01f,
  6.62343502e-02f, 3.51463169e-01f, -8.76772329e-02f, 5.06548762e-01f, 1.02783345e-01f, -4.99418497e-01f, 4.19496596e-01f, 1.47629306e-01f, 2.62473226e-01f, 3.96497458e-01f,
  2.17577353e-01f, -2.38619447e-01f, 1.53668776e-01f, 7.29244202e-02f, 3.88301969e-01f, -3.04329604e-01f, 7.37408996e-02f, 2.07471922e-02f, 1.68577015e-01f, 5.21843955e-02f,
  4.71696228e-01f, -2.75048703e-01f, 1.13138556e-01f, 1.91311195e-01f, -1.72665522e-01f, 2.85488009e-01f, -1.28005743e-01f, 3.46538424e-01f, 2.56030589e-01f, 1.94642425e-01f,
  4.92493719e-01f, 1.38360575e-01f, 2.23891065e-02f, -3.94437820e-01f, -3.22355986e-01f, -1.43209875e-01f, 3.20264697e-01f, 4.01437014e-01f, -1.87505752e-01f, 3.19336444e-01f,
  3.23888361e-01f, 2.90247947e-01f, 1.00047193e-01f, -1.75487697e-01f, 4.59466249e-01f, 2.26082176e-01f, 3.35980177e-01f, 1.91406071e-01f, 4.91368286e-02f, 3.81251574e-01f,
  2.28280917e-01f, 1.24393515e-01f, 1.06768042e-01f, -8.30588713e-02f, -5.30705214e-01f, 4.36982691e-01f, 3.47102344e-01f, -3.36685956e-01f, -9.09081250e-02f, -1.79924205e-01f,
  3.61207932e-01f, -6.73892871e-02f, -2.39738554e-01f, 4.88831758e-01f, 6.53390467e-01f, 1.38557538e-01f, -1.33866951e-01f, -1.83680486e-02f, -4.42501828e-02f, 3.89136314e-01f,
  -1.18894018e-01f, 7.58323491e-01f, 5.03363073e-01f, 4.85226631e-01f, -7.62980292e-03f, -2.33807072e-01f, 2.84106493e-01f, 6.61541998e-01f, 5.74651826e-03f, 2.43465617e-01f,
  1.03949115e-01f, 1.52476609e-01f, 1.26845598e-01f, 2.16920704e-01f, -1.96241081e-01f, 3.07853252e-01f, -1.78167760e-01f, -1.03178822e-01f, 1.50806829e-01f, -4.42600459e-01f,
  3.69434714e-01f, 8.68570060e-02f, 3.60159189e-01f, -5.64651191e-03f, -1.37391044e-02f, 3.38911712e-01f, 2.08407432e-01f, 5.68377554e-01f, 1.60411865e-01f, 3.71176273e-01f,
  -2.98662126e-01f, 1.85138717e-01f, -2.36418709e-01f, -7.19106197e-02f, 2.79880643e-01f, 7.74988011e-02f, -5.53953461e-02f, -8.45552757e-02f, -2.22031295e-01f, -6.83134608e-03f,
  3.47387165e-01f, 3.37108195e-01f, 2.25822791e-01f, 4.83386129e-01f, 1.05589218e-01f, -1.87861640e-02f, 4.01351541e-01f, 1.49314895e-01f, -9.29418430e-02f, -2.83295065e-01f,
  4.07505572e-01f, -1.62811391e-02f, -1.25014350e-01f, 7.73387328e-02f, -1.53524160e-01f, 2.46639520e-01f, 4.70961034e-01f, 7.73232281e-01f, 5.14815331e-01f, -4.04462367e-01f,
  1.37701795e-01f, -3.12336653e-01f, 1.19668998e-01f, 5.22489071e-01f, 5.61887860e-01f, -1.87242866e-01f, 6.71774596e-02f, -1.92744017e-01f, 4.18340653e-01f, 5.95396698e-01f,
  -2.85754740e-01f, 3.14053565e-01f, 2.51191318e-01f, 2.52280623e-01f, 3.42597395e-01f, 5.54410398e-01f, 2.00907454e-01f, -3.71435620e-02f, 1.93873212e-01f, 4.80011627e-02f,
  1.05984457e-01f, -1.11015745e-01f, 1.55039996e-01f, 1.97229743e-01f, 1.01241730e-01f, -1.75413579e-01f, 1.72622144e-01f, -1.75394848e-01f, 1.62215217e-03f, 6.76366985e-01f,
  4.59824950e-01f, -5.15324354e-01f, 2.10078105e-01f, -2.64437586e-01f, 3.12498420e-01f, -2.20681846e-01f, 5.06215215e-01f, -5.48298471e-02f, 2.10044742e-01f, 1.74499854e-01f,
  3.80374789e-01f, 7.06012070e-01f, -2.21010476e-01f, 3.75997871e-01f, -3.50647032e-01f, 1.75739929e-01f, 3.24322075e-01f, 8.03363994e-02f, 2.82542050e-01f, 2.63997406e-01f,
  -5.37916310e-02f, -3.40253487e-02f, 4.54865813e-01f, -3.28883201e-01f, 5.33244982e-02f, 1.59583017e-01f, 2.51865566e-01f, -1.50455544e-02f, -1.64774358e-02f, 1.75134242e-02f,
  -1.77985832e-01f, 1.80644076e-03f, -7.07384339e-03f, -2.70056963e-01f, 1.57790333e-01f, 7.77486861e-01f, 3.35715562e-02f, -3.23631555e-01f, 3.44528377e-01f, 2.14557588e-01f,
  1.57135427e-02f, -1.33859292e-01f, 5.34999251e-01f, 4.12925571e-01f, 1.46300644e-01f, 3.87587786e-01f, -5.32079823e-02f, -1.38937354e-01f, 1.12773851e-01f, 8.93037096e-02f,
  -1.46104498e-02f, 1.79375648e-01f, 2.08556578e-01f, -7.76016340e-02f, 3.09669435e-01f, -1.63859338e-03f, 4.10905987e-01f, 2.00845972e-02f, -7.81921111e-03f, 3.58335257e-01f,
  -3.98126841e-01f, -3.32840115e-01f, 5.36586121e-02f, 1.11710034e-01f, 2.30010524e-01f, -2.11293176e-01f, -1.94311544e-01f, 3.31807673e-01f, -1.69013515e-01f, 2.46622384e-01f,
  4.04039115e-01f, 4.13426369e-01f, -2.80677825e-01f, -1.40916765e-01f, 3.61308664e-01f, -2.66792089e-01f, 5.22099555e-01f, 5.25292754e-01f, 1.13929454e-02f, 1.69364616e-01f,
  1.71911523e-01f, -1.28630456e-02f, -3.67166996e-02f, 1.07527755e-01f, -3.13300848e-01f, -2.33328268e-01f, -7.39686713e-02f, 3.65859978e-02f, -3.68592352e-01f, 2.87267596e-01f,
  -1.30673662e-01f, -2.22261384e-01f, -7.13814870e-02f, 5.01886249e-01f, 3.25682878e-01f, -2.12140277e-01f, 1.71218500e-01f, 2.29048818e-01f, 2.82923043e-01f, 5.30635059e-01f,
  2.69338280e-01f, -2.24221289e-01f, -2.34381333e-01f, 3.46156746e-01f, -8.16018060e-02f, 4.78065610e-01f, -1.83009520e-01f, -2.51657873e-01f, 5.19490540e-01f, -1.88108951e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  8.33953023e-02f, 2.24375308e-01f, 2.41050065e-01f, 2.24703372e-01f, 5.66039458e-02f, 3.66412282e-01f, -7.67464340e-02f, 7.40692690e-02f, 2.26395577e-01f, 3.00386220e-01f,
  1.38554871e-01f, 2.06322715e-01f, 2.17030764e-01f, 4.43778396e-01f, 2.23631009e-01f, 1.77177235e-01f, 1.69210613e-01f, 3.28470767e-01f, 2.00335711e-01f, 1.89301729e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -2.64568239e-01f, -1.49648890e-01f, -5.99155873e-02f, 2.45362282e-01f, 1.26071438e-01f, 1.23166613e-01f, 3.02482378e-02f, 2.45087922e-01f, 2.23495051e-01f, -1.59636006e-01f,
  4.59872782e-02f, 4.25178587e-01f, -6.03978157e-01f, -2.50351250e-01f, -6.56903684e-01f, 1.82411611e-01f, 2.33871683e-01f, 7.21316338e-01f, -2.41005376e-01f, 5.60025036e-01f,
  -2.94011235e-01f, 2.88735013e-02f, -2.68436968e-01f, -1.10179827e-01f, -3.59927118e-01f, 1.44986942e-01f, 5.45593917e-01f, -7.88777590e-01f, -8.16215575e-01f, -6.31277084e-01f,
  -6.45040302e-03f, -3.21314484e-01f, -2.54239112e-01f, 3.00485820e-01f, 4.40207608e-02f, 6.05675913e-02f, 7.78005645e-02f, -7.09776729e-02f, -5.12111962e-01f, 5.24021573e-02f,
  7.26319477e-02f, 3.84622276e-01f, -1.82666779e-01f, 4.44676101e-01f, -4.68690425e-01f, -5.31860471e-01f, -5.54502666e-01f, 6.74715579e-01f, 4.10028040e-01f, -4.92810577e-01f,
  -8.99322852e-02f, -2.68959790e-01f, -7.15977624e-02f, -6.16773486e-01f, -2.90891260e-01f, 2.96860516e-01f, 3.97981614e-01f, 4.28677946e-01f, -3.38977069e-01f, -8.99937212e-01f,
  -1.53844804e-01f, -5.52116215e-01f, -4.08519179e-01f, 3.41215909e-01f, 1.07640028e-01f, 8.37261006e-02f, 2.20960319e-01f, -7.03414604e-02f, -9.77703631e-02f, -3.23171645e-01f,
  3.44245791e-01f, -1.95708022e-01f, 4.27284300e-01f, 2.24772885e-01f, -3.00269097e-01f, 2.69161671e-01f, 2.29603618e-01f, 4.68782410e-02f, 2.51276523e-01f, -6.78329647e-01f,
  3.07951540e-01f, -2.86092550e-01f, 8.35387558e-02f, -2.92790264e-01f, -2.63328761e-01f, -3.84793758e-01f, -5.73807418e-01f, -1.09133713e-01f, 4.38093096e-01f, 5.61730564e-02f,
  -4.11807537e-01f, -4.64421690e-01f, -3.42249990e-01f, 2.11340994e-01f, 5.16318738e-01f, 1.88339204e-01f, 3.21207009e-02f, -2.54470594e-02f, 1.28456086e-01f, -2.76043694e-02f,
  4.65853289e-02f, -2.44775012e-01f, -2.92859763e-01f, -4.58184063e-01f, -3.59451294e-01f, -3.97457600e-01f, -3.61615539e-01f, -2.20874026e-01f, -4.54521447e-01f, 5.46737194e-01f,
  1.04930423e-01f, -4.70266491e-01f, -9.38546732e-02f, 1.41300336e-01f, 6.82477951e-01f, 3.20926845e-01f, -2.13086590e-01f, 4.37671989e-01f, -2.49694988e-01f, -5.87808728e-01f,
  -5.11912942e-01f, -7.73784876e-01f, 1.82306588e-01f, -7.63824642e-01f, -2.79497832e-01f, 2.00171292e-01f, -7.27677196e-02f, -1.74821377e-01f, -5.91385737e-02f, 2.92019159e-01f,
  3.82123888e-01f, -1.63952366e-01f, 3.99473727e-01f, -1.22688487e-01f, -6.18058562e-01f, 4.97524828e-01f, 1.10932067e-01f, -5.19998729e-01f, -3.81429940e-01f, -6.05056703e-01f,
  3.52603704e-01f, 1.20231085e-01f, 4.61420536e-01f, -1.83646053e-01f, -9.76710096e-02f, 1.89097196e-01f, -6.84094846e-01f, 2.91682065e-01f, -4.09592986e-01f, 2.67469317e-01f,
  -3.69766504e-01f, -4.94778931e-01f, -4.40635771e-01f, -1.38259577e-02f, 2.46504381e-01f, 1.23591423e-01f, 2.12290794e-01f, -4.53586131e-01f, -2.32457608e-01f, -7.41052404e-02f,
  2.35218957e-01f, 9.97820962e-03f, 8.43498856e-02f, 7.95813501e-02f, -7.68128559e-02f, 2.61362463e-01f, -5.45139425e-02f, 2.17120096e-01f, 5.79548359e-01f, 2.04888985e-01f,
  5.81798375e-01f, -3.46981019e-01f, -6.65340483e-01f, -6.79138899e-01f, -6.56221092e-01f, 1.35216832e-01f, 1.33211166e-01f, -3.06164294e-01f, -5.23505211e-01f, 2.14788258e-01f,
  -2.37043157e-01f, 1.76131874e-02f, 6.32413208e-01f, -2.59431154e-01f, 2.60234445e-01f, -1.01556256e-02f, 1.04253776e-01f, 3.37626696e-01f, 5.34284532e-01f, 7.65507622e-03f,
  -3.56666833e-01f, -7.37819791e-01f, -2.48662099e-01f, 3.47950637e-01f, 1.87092200e-01f, 8.56876671e-02f, -4.49560374e-01f, 1.12971805e-01f, 2.93993294e-01f, -2.79075444e-01f,
  -5.72662294e-01f, 4.97827977e-01f, 3.27242315e-01f, -4.40539032e-01f, -2.51338750e-01f, -8.39369968e-02f, 2.35844895e-01f, 1.55081805e-02f, -7.55111396e-01f, -8.93922985e-01f,
  -4.78409499e-01f, -4.56108481e-01f, -5.33815682e-01f, -1.99787468e-01f, -3.67771298e-01f, 3.71747792e-01f, -1.73045382e-01f, 1.47860706e-01f, -3.30768526e-02f, 1.44029617e-01f,
  3.32212806e-01f, 4.67977941e-01f, 5.29573262e-01f, -2.37065181e-01f, -1.65113911e-01f, -3.59815434e-02f, -8.55774730e-02f, 6.93529099e-03f, -2.64192790e-01f, 4.29414921e-02f,
  1.88905314e-01f, 1.31382093e-01f, -1.94881022e-01f, 8.66006315e-02f, 3.02340060e-01f, 3.38726759e-01f, 9.60119739e-02f, 8.81381407e-02f, 2.78332621e-01f, -1.27100542e-01f,
  -4.44409966e-01f, 2.12897584e-01f, 5.46546400e-01f, 2.63406336e-01f, -3.75020057e-01f, -1.10864051e-01f, 4.92420793e-01f, -3.72880608e-01f, 3.11627865e-01f, -4.58732575e-01f,
  -1.05080120e-01f, 1.86375324e-02f, -5.51872194e-01f, -4.06253755e-01f, 2.79477388e-01f, -2.28708893e-01f, 9.80796739e-02f, -1.26867592e-01f, -5.49546331e-02f, -2.68942297e-01f,
  4.08866629e-02f, -1.29110888e-01f, -1.77196845e-01f, -2.07413390e-01f, 8.42318833e-02f, 8.14955402e-03f, -2.34169707e-01f, 1.29394621e-01f, 3.41884434e-01f, -2.93900549e-01f,
  -3.04550201e-01f, -4.16092038e-01f, 2.55729288e-01f, -2.76371926e-01f, 4.07990426e-01f, 4.27963644e-01f, 4.11359578e-01f, -3.07972342e-01f, 1.13139950e-01f, 1.40821651e-01f,
  1.33796573e-01f, -6.84349835e-01f, -4.00464624e-01f, 2.58894742e-01f, -1.22843631e-01f, -4.43287462e-01f, -4.36316192e-01f, 3.07381243e-01f, 2.17878684e-01f, -3.47218752e-01f,
  -6.76493421e-02f, 4.17124122e-01f, 3.41345556e-02f, 2.52733082e-01f, 4.93194431e-01f, 4.44091976e-01f, -3.49231035e-01f, -3.94600302e-01f, 2.42058128e-01f, 4.81173098e-01f,
  2.59008825e-01f, -8.43377173e-01f, 7.29036033e-02f, -7.05800474e-01f, -6.67552233e-01f, 5.70287585e-01f, -1.69340834e-01f, -3.82750094e-01f, -4.60375398e-02f, -6.78210258e-01f,
  -4.05230552e-01f, -7.37353861e-01f, -3.09320353e-02f, 6.11301601e-01f, 1.33363128e-01f, 2.97795594e-01f, 8.43068808e-02f, -2.56618321e-01f, 2.07071051e-01f, -2.38342091e-01f,
  -1.53319752e-02f, -5.58795594e-02f, 6.06392436e-02f, 1.78487420e-01f, 1.62208185e-01f, -3.75754349e-02f, -2.81078756e-01f, -3.98538440e-01f, 2.22477153e-01f, 3.69001061e-01f,
  -2.03147069e-01f, -3.04500520e-01f, -4.81578887e-01f, -1.95588335e-01f, -5.10635614e-01f, 5.79273961e-02f, -1.35221258e-01f, -2.89525598e-01f, -6.45708382e-01f, -2.87589341e-01f,
  5.79080343e-01f, 4.39798713e-01f, -5.24013638e-01f, 4.44710284e-01f, -4.37752038e-01f, -2.84112632e-01f, 3.42686355e-01f, -4.85565066e-01f, -5.18879235e-01f, 4.55626428e-01f,
  -2.18959227e-01f, 5.84237695e-01f, 2.39782840e-01f, -1.89621493e-01f, -3.82064730e-02f, 6.02246486e-02f, 6.59553707e-02f, -7.11082220e-02f, 2.63883054e-01f, -2.33627096e-01f,
  3.06961596e-01f, 2.34162048e-01f, 1.96691394e-01f, -1.97997913e-01f, 3.50002229e-01f, 1.71218947e-01f, 4.14221473e-02f, -2.81697065e-01f, -5.06960690e-01f, -3.08930755e-01f,
  1.55800819e-01f, -6.25831366e-01f, 3.95801693e-01f, 3.59613985e-01f, 2.83485085e-01f, -2.30628133e-01f, -6.50533319e-01f, -7.46785402e-01f, -4.43708241e-01f, 2.07632914e-01f,
  3.30206454e-01f, 3.06633234e-01f, -6.49597943e-02f, -2.15177655e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  6.03284016e-02f, -9.53361690e-02f, -1.17647260e-01f, -2.65918337e-02f, -5.85439019e-02f, -4.49737459e-02f, 1.73381999e-01f, 2.78703533e-02f, -1.36672661e-01f, 1.09927721e-01f,
  1.28930897e-01f, -8.85735303e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    