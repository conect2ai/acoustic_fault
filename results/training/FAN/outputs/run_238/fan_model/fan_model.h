/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.11520869e-01f, 4.44443315e-01f, -3.46428379e-02f, 1.31119475e-01f, -1.46543950e-01f, 9.20577496e-02f, -3.39761414e-02f, 1.63581178e-01f, 9.97028127e-02f, 1.41699284e-01f,
  6.06678128e-02f, -4.14299406e-02f, 7.63809308e-02f, 1.47716925e-01f, 8.39117616e-02f, 2.53454745e-01f, 7.62465037e-03f, 2.28743255e-02f, 2.61063166e-02f, 2.90822536e-02f,
  4.84934337e-02f, 2.20350593e-01f, -4.18702736e-02f, -1.81854796e-02f, -8.40994567e-02f, -8.85948539e-02f, 2.51745731e-02f, -5.48661612e-02f, -9.83011797e-02f, 8.49597529e-02f,
  7.28895608e-03f, -1.63987949e-01f, -1.38124779e-01f, -1.59412045e-02f, -2.11198325e-03f, -3.80502082e-02f, -4.51576971e-02f, -7.44382590e-02f, -6.60274103e-02f, 2.49836706e-02f,
  1.94359366e-02f, -4.90895770e-02f, 3.27981263e-02f, 2.13581957e-02f, -7.12187290e-02f, -5.74884787e-02f, -6.10609315e-02f, 2.90951487e-02f, -6.27127066e-02f, -2.20855419e-02f,
  1.65415113e-03f, -3.25585455e-02f, -7.27236494e-02f, 3.76375616e-02f, 1.30916331e-02f, 1.00524435e-02f, -3.76182445e-03f, -7.91011751e-03f, 3.70816849e-02f, 6.30048737e-02f,
  -5.68625517e-02f, -1.15800984e-02f, 7.08360448e-02f, -2.09786799e-02f, -2.05504266e-03f, -9.43849387e-04f, 9.18395631e-03f, -1.24129036e-03f, 4.06072475e-03f, -2.02354249e-02f,
  -5.90041056e-02f, -3.22546586e-02f, 1.65077504e-02f, -2.23364402e-02f, 9.35328833e-04f, -4.48775431e-03f, -2.45048963e-02f, -2.41591949e-02f, -5.36808278e-04f, 6.95870630e-03f,
  1.33054042e-02f, -4.94221523e-02f, -1.13606695e-02f, 3.67921479e-02f, 2.44968720e-02f, -5.76599389e-02f, -6.16278965e-03f, 1.75649021e-02f, -2.31175479e-02f, 1.16747979e-03f,
  2.21589461e-01f, 3.05758953e-01f, 9.23968330e-02f, -4.24629189e-02f, 3.91526408e-02f, 1.89388413e-02f, 5.03139347e-02f, 2.46348139e-02f, 3.56155559e-02f, 4.04993631e-02f,
  1.29890144e-02f, 2.84231063e-02f, -2.04768181e-02f, -2.38077771e-02f, 7.22086653e-02f, 6.29192069e-02f, -7.01671652e-03f, -3.83341499e-02f, 2.56079901e-02f, 2.61918008e-02f,
  -1.51240742e-02f, 1.13019152e-02f, 2.42864378e-02f, -6.06272742e-02f, -5.80380820e-02f, -9.26813111e-02f, 1.48346066e-04f, -2.12531164e-02f, 1.00725591e-02f, -2.43520085e-02f,
  4.19296414e-01f, 2.06429392e-01f, -6.61722273e-02f, 3.34625458e-03f, -1.54538555e-02f, -2.88258910e-01f, -1.94509879e-01f, -1.76873729e-02f, 1.11445375e-02f, 1.13439836e-01f,
  -6.10210299e-02f, 2.10548639e-01f, -4.30373475e-02f, -1.00428507e-01f, -3.64531487e-01f, -2.36563176e-01f, -1.42355517e-01f, -5.70304394e-02f, -1.72034558e-02f, -3.52358110e-02f,
  -7.54152909e-02f, -1.68242916e-01f, -1.41921073e-01f, -7.97564089e-02f, -4.17114235e-02f, 1.11719437e-01f, -1.98817216e-02f, -2.12625060e-02f, 1.03461780e-01f, -6.28719628e-02f,
  1.70946255e-01f, 2.47319922e-01f, 9.05229673e-02f, -7.47230351e-02f, -1.42794028e-02f, 6.63445517e-02f, -3.52407172e-02f, -4.37645502e-02f, 3.04229762e-02f, 7.33416826e-02f,
  -2.80363695e-03f, 2.01843842e-03f, -8.36840551e-03f, 7.95360748e-03f, 9.50517319e-03f, 8.73566270e-02f, -2.64305696e-02f, 9.29746777e-03f, -6.97829388e-03f, -2.05723830e-02f,
  -1.14519764e-02f, 3.21470909e-02f, -2.24714950e-02f, 5.16281556e-03f, -4.72705737e-02f, 4.83585224e-02f, -2.92275567e-02f, 3.55347283e-02f, 2.12384202e-02f, 5.15504442e-02f,
  -9.58557129e-02f, -7.14054257e-02f, 3.74993891e-03f, -9.86454543e-03f, -3.42578180e-02f, 7.72001268e-03f, -2.73303241e-02f, 9.96721350e-03f, 4.93862927e-02f, -3.47720869e-02f,
  2.29600035e-02f, -1.33742047e-02f, 1.33226961e-02f, -2.61545833e-02f, 1.87553447e-02f, 3.69782448e-02f, -4.90274504e-02f, 3.81821021e-02f, -2.53222156e-02f, -2.44991332e-02f,
  2.19493136e-02f, -3.55074331e-02f, 1.30119892e-02f, 6.73289783e-03f, -4.23848704e-02f, -4.85998169e-02f, 6.61919592e-03f, 2.47723777e-02f, -4.48539760e-03f, -3.00491601e-02f,
  -1.23813361e-01f, -2.65375897e-02f, -1.83696207e-02f, 1.73699800e-02f, 5.48615083e-02f, 5.14927506e-02f, -8.90863389e-02f, 5.31808997e-04f, -1.79968514e-02f, -8.08399245e-02f,
  7.50785172e-02f, 1.43143348e-02f, -2.92829480e-02f, -2.69193910e-02f, -2.83370949e-02f, -3.35498415e-02f, -4.29248363e-02f, 6.98416010e-02f, -2.39534304e-02f, 3.44570051e-03f,
  3.50822434e-02f, -2.18261890e-02f, 2.66492963e-02f, -2.27946769e-02f, 3.16055529e-02f, -4.76066247e-02f, 2.15786565e-02f, 2.23867949e-02f, -3.31523679e-02f, -6.07081205e-02f,
  -3.12060833e-01f, 4.12119217e-02f, 7.21864998e-02f, -2.89619472e-02f, -1.78234115e-01f, 3.26784074e-01f, 2.45075554e-01f, -9.34597850e-02f, 6.08781651e-02f, 6.83502778e-02f,
  -6.73225820e-02f, 4.17601541e-02f, -5.12214229e-02f, 1.28286228e-01f, 1.24094142e-02f, 2.59059548e-01f, -1.00083053e-01f, 1.21480621e-01f, 2.91749854e-02f, -2.58189201e-01f,
  8.64905268e-02f, -7.01471120e-02f, 8.32402408e-02f, -1.23314008e-01f, -1.13211513e-01f, -6.64932132e-02f, -2.01949164e-01f, -1.38466042e-02f, -1.14130124e-01f, -4.13997546e-02f,
  6.35592416e-02f, -1.49006873e-01f, 6.58752397e-02f, 1.80068389e-02f, -3.25957313e-02f, -2.74376497e-02f, 7.63425678e-02f, 1.86520685e-02f, -4.23267484e-02f, -4.22023796e-02f,
  -7.87350535e-03f, -2.04255618e-02f, 7.15679005e-02f, -4.56020847e-04f, 2.14086343e-02f, 1.13145150e-02f, 2.44777668e-02f, -4.18427866e-03f, 3.75561565e-02f, 4.94264029e-02f,
  4.55951169e-02f, 6.67304965e-03f, 1.46272853e-02f, -1.89674273e-03f, -1.69848204e-02f, 9.96392407e-03f, 4.82434221e-02f, -8.25178437e-03f, -2.68076576e-04f, 3.78343761e-02f,
  -7.19359443e-02f, -2.40782909e-02f, 1.47335865e-02f, -1.69339329e-02f, -1.29102832e-02f, -5.94082363e-02f, 1.52001493e-02f, -1.38901100e-02f, -1.71513704e-03f, 1.21587450e-02f,
  1.92595157e-03f, 1.85063351e-02f, -7.47991353e-02f, 2.83346698e-02f, 1.02888867e-02f, -3.85595462e-03f, 3.77775691e-02f, -2.97758263e-02f, 1.15371961e-02f, -3.39075848e-02f,
  -2.56090779e-02f, -2.42965911e-02f, 3.79634723e-02f, -1.96908042e-02f, -2.17830818e-02f, 1.15321055e-02f, -3.64355035e-02f, -1.45289358e-02f, 1.54963229e-02f, -1.43222390e-02f,
  -1.98759288e-01f, -2.90343434e-01f, -7.94849638e-03f, -5.98141598e-03f, 1.89395677e-02f, 4.67979684e-02f, 5.46594150e-03f, -2.49835979e-02f, -3.67142409e-02f, -2.63362890e-03f,
  -1.48892757e-02f, 2.41357163e-02f, -1.25797689e-01f, -5.82146598e-03f, 3.70168947e-02f, -1.84775311e-02f, -2.14467905e-02f, -2.43903883e-02f, -3.39086168e-02f, -1.79315992e-02f,
  -3.83603349e-02f, -5.26830554e-02f, 3.75551209e-02f, -2.13770308e-02f, -1.85433328e-02f, -6.21419437e-02f, -2.99871080e-02f, 4.79711927e-02f, 2.00616219e-03f, 3.84361371e-02f,
  -3.01868141e-01f, -1.22479133e-01f, -3.51962388e-01f, -7.43535683e-02f, -2.67810281e-03f, -3.89145650e-02f, -3.20381403e-01f, -3.63620860e-03f, -3.19411695e-01f, 1.37981862e-01f,
  1.94568396e-01f, -1.96804062e-01f, -8.16013515e-02f, 1.13309287e-01f, -1.05675265e-01f, -9.43972990e-02f, 4.25718762e-02f, -2.98123639e-02f, -1.81424767e-01f, 2.90563274e-02f,
  -9.60170664e-03f, 2.06060171e-01f, 1.63109414e-02f, 2.73627549e-01f, 1.84703525e-02f, -1.13293398e-02f, 2.73385733e-01f, -5.06762527e-02f, 3.03588718e-01f, 1.76102873e-02f,
  -4.62891650e-04f, -1.26281768e-01f, -5.40516116e-02f, 3.85036692e-02f, 9.66326371e-02f, 5.53871877e-03f, 3.35394219e-02f, -3.99377756e-02f, -5.30037060e-02f, -2.70505715e-02f,
  -6.25858456e-02f, 6.91482797e-02f, -3.47951874e-02f, 2.75543444e-02f, -4.11591716e-02f, 4.24716808e-02f, 2.19394751e-02f, -1.33522619e-02f, -1.78304911e-02f, -6.66166320e-02f,
  -3.66491452e-02f, -2.70613357e-02f, -1.92635376e-02f, -9.18051694e-03f, -8.33884254e-02f, 2.85124220e-03f, -6.44736663e-02f, -4.20214084e-04f, -3.18293236e-02f, -8.34408849e-02f,
  1.73507705e-02f, 4.32941178e-03f, 2.25117570e-03f, 7.82869682e-02f, 1.07553629e-02f, 5.35516664e-02f, 7.85508603e-02f, -7.64144212e-03f, -5.02080582e-02f, 8.13704357e-02f,
  5.00710569e-02f, -2.64295209e-02f, -1.12383375e-02f, -1.70425642e-02f, 1.42238138e-03f, -2.94543989e-03f, -4.35323827e-02f, 6.19072430e-02f, 9.05173831e-03f, -5.00082597e-03f,
  2.56644990e-02f, -1.61611866e-02f, 2.67687906e-02f, -1.22864088e-02f, 5.81399016e-02f, -2.52585541e-02f, 8.07595998e-02f, -4.11153324e-02f, -3.39138024e-02f, 3.19274552e-02f,
  1.29150048e-01f, 4.30335663e-02f, 4.55532735e-03f, 2.92397924e-02f, -5.96519262e-02f, 2.84059625e-02f, -2.69313045e-02f, 2.02702843e-02f, 1.83071997e-02f, 6.89820619e-03f,
  1.48801450e-02f, -5.02312221e-02f, 3.57472822e-02f, 2.60767974e-02f, -1.31854939e-03f, -3.73938493e-02f, 6.24985946e-03f, -2.58973725e-02f, 2.93277744e-02f, 3.17284018e-02f,
  3.08546908e-02f, 4.78889002e-03f, 3.74861853e-03f, 4.00863849e-02f, 8.56777057e-02f, 2.89330836e-02f, 4.85732127e-03f, -7.30148256e-02f, 8.02027509e-02f, 5.08286804e-02f,
  5.11258543e-01f, 1.72104642e-01f, 1.46017358e-01f, 2.68467665e-01f, -1.62412986e-01f, 3.71426612e-01f, 2.20318228e-01f, 2.26105060e-02f, 8.38141739e-02f, 2.57119276e-02f,
  3.57135013e-03f, 2.69449204e-01f, -5.14485426e-02f, 1.37837023e-01f, 5.65286689e-02f, -6.08203150e-02f, 7.87351057e-02f, 9.55279022e-02f, -1.06175944e-01f, -5.25833480e-03f,
  1.24637494e-02f, -5.75176924e-02f, -3.54828895e-03f, -1.93256497e-01f, 1.97507665e-01f, -4.16589417e-02f, -6.51117936e-02f, -3.72926332e-02f, 3.98777425e-03f, -4.67475969e-03f,
  1.81232080e-01f, -1.21180147e-01f, 1.93192028e-02f, -3.49716954e-02f, -1.40764192e-02f, 6.38953550e-03f, 8.33287612e-02f, -3.08294693e-04f, -5.23837889e-03f, 1.09579246e-02f,
  6.97774813e-02f, -6.85375975e-03f, 4.68655564e-02f, -4.28526290e-02f, 2.10758522e-02f, -5.08756842e-03f, -7.32441316e-04f, -3.84035595e-02f, -1.85264684e-02f, 5.85245229e-02f,
  2.23513115e-02f, 3.91596183e-02f, 2.86530424e-02f, 2.82134339e-02f, 3.44550656e-03f, 1.00782309e-02f, 7.57975355e-02f, -2.08263900e-02f, 6.07364438e-02f, 1.91321876e-02f,
  -6.70898845e-03f, -1.24775544e-02f, 4.24093427e-03f, -5.36141219e-03f, -4.96984608e-02f, 3.42675397e-04f, -5.31884236e-03f, 7.13160168e-03f, 4.62421663e-02f, -5.51843178e-03f,
  1.10213188e-02f, 1.27713727e-02f, 1.54611571e-02f, 5.33558726e-02f, 1.49008939e-02f, 3.43771093e-02f, 9.87268053e-03f, 1.60665456e-02f, 4.57647368e-02f, 1.01412907e-02f,
  4.42310423e-03f, 2.31472701e-02f, -1.93327144e-02f, 4.53424593e-03f, 4.11061011e-02f, 1.92953937e-03f, -3.44401002e-02f, 9.59268305e-03f, 4.90124077e-02f, 1.75521784e-02f,
  -4.96799573e-02f, -9.57517698e-02f, -4.48919982e-02f, -1.91826429e-02f, 7.57682556e-03f, 3.76571678e-02f, -3.19923684e-02f, -2.11287215e-02f, 2.75321472e-02f, 1.28238639e-02f,
  3.88938822e-02f, 9.15580988e-02f, -6.26857160e-03f, 8.05810466e-02f, -7.90933594e-02f, 4.51439805e-02f, -3.43338251e-02f, 7.24349096e-02f, -1.84202399e-02f, -4.11780663e-02f,
  -2.40000002e-02f, -1.15633197e-02f, 5.19702211e-03f, -1.16932541e-02f, 1.50976265e-02f, -4.41772044e-02f, 3.28637362e-02f, -4.41005512e-04f, -1.03060361e-02f, -2.81602386e-02f,
  3.11714113e-01f, 1.95485353e-01f, 1.48379117e-01f, 3.40851307e-01f, -1.26608923e-01f, -7.88085833e-02f, 8.82555917e-02f, 1.26114702e-02f, -1.82282925e-02f, 1.26305610e-01f,
  1.42575443e-01f, -1.13058709e-01f, 1.30890146e-01f, 1.63275957e-01f, 1.56668961e-01f, 1.26730531e-01f, 3.67261291e-01f, 5.02501950e-02f, 2.70544924e-02f, 1.36323437e-01f,
  5.59296347e-02f, 1.52115002e-01f, 1.61739007e-01f, 8.34740989e-04f, 7.69882277e-03f, -3.61950360e-02f, 8.65781829e-02f, -3.20565514e-02f, -1.62192769e-02f, -4.70316857e-02f,
  -1.30560890e-01f, 2.11656373e-02f, 2.65070926e-02f, -4.86570969e-03f, 3.46820131e-02f, 1.64564848e-02f, -6.36518747e-02f, 2.77916733e-02f, -5.15633076e-02f, 3.28706898e-04f,
  -3.96023244e-02f, -5.29171191e-02f, 3.64747159e-02f, 4.78391815e-03f, -5.07713333e-02f, 1.30348783e-02f, -7.20669031e-02f, -8.62313583e-02f, -8.15484524e-02f, -4.90459949e-02f,
  -1.70698911e-02f, -3.07433549e-02f, 2.15884726e-02f, 2.60815248e-02f, -6.30821288e-03f, 6.07301714e-03f, 3.03206369e-02f, -5.51168956e-02f, -3.66909280e-02f, -1.52711617e-02f,
  1.84114445e-02f, -1.33101717e-02f, -4.96106930e-02f, -1.36212842e-03f, 3.24550420e-02f, -1.10354461e-03f, 1.10701388e-02f, 2.86935978e-02f, 2.42093522e-02f, 5.24522997e-02f,
  -1.30886026e-02f, 9.59513243e-03f, 1.49909668e-02f, -2.44470984e-02f, 2.28389315e-02f, -1.78403612e-02f, 7.09450105e-03f, 2.06576940e-02f, -5.89665724e-03f, 1.13969892e-02f,
  2.87291929e-02f, 2.08750064e-03f, 2.48102341e-02f, 3.25812437e-02f, 2.02897657e-02f, 2.90151443e-02f, -4.31874245e-02f, -2.65851635e-02f, 1.14539107e-02f, -2.13739611e-02f,
  1.65796623e-01f, 1.64665788e-01f, 6.34907261e-02f, -4.77501601e-02f, 4.53339815e-02f, -3.62033062e-02f, 7.92551935e-02f, -2.99268905e-02f, 6.54113293e-02f, 4.91412245e-02f,
  -3.50616388e-02f, 1.45409927e-02f, -3.22762392e-02f, -2.33732611e-02f, 7.27698579e-02f, 3.10438424e-02f, 1.07802115e-01f, 6.08825423e-02f, 1.06194653e-01f, 4.30782177e-02f,
  -1.20824445e-02f, 1.11997547e-02f, -5.12753287e-03f, 1.12475175e-02f, -4.58042026e-02f, 7.59222582e-02f, -3.48443687e-02f, 1.32566988e-02f, 1.27734542e-02f, 3.25902291e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.40219340e-01f, -2.21007153e-01f, -3.07167202e-01f, 2.12997086e-02f, 1.65927842e-01f, 1.13868304e-01f, -1.06612131e-01f, 8.56345668e-02f, 3.23868776e-03f, -5.98278306e-02f,
  1.91168196e-03f, -1.75123259e-01f, -1.96655363e-01f, -1.13369122e-01f, 2.71030832e-02f, -2.71757752e-01f, 1.83400419e-02f, -3.04918364e-02f, -8.59963745e-02f, -4.18740185e-03f,
  7.30040446e-02f, 1.26268268e-01f, -1.58250853e-01f, 2.45873705e-01f, -3.03119626e-02f, 2.49972701e-01f, 9.76508260e-02f, -3.72813456e-02f, 1.01541698e-01f, 1.28677040e-02f,
  -6.31179707e-03f, 1.40328370e-02f, -1.20786808e-01f, -4.78207618e-02f, 7.93643817e-02f, 1.55930325e-01f, 6.52251169e-02f, -9.53346714e-02f, 2.53186617e-02f, -4.06719884e-03f,
  3.36061744e-03f, -5.29865697e-02f, 2.92523822e-04f, -2.48566922e-03f, 2.56729852e-02f, 3.29752937e-02f, -7.07445145e-02f, -2.43724771e-02f, 1.97576117e-02f, -5.76055683e-02f,
  1.19778572e-03f, -4.55563404e-02f, 4.23270315e-02f, -1.54661422e-03f, 2.95233191e-03f, -3.98761034e-02f, 8.16352367e-02f, 2.39899312e-03f, -6.20958321e-02f, 9.56481993e-02f,
  -9.99024361e-02f, 4.60367016e-02f, 6.45439625e-02f, -9.05055404e-02f, 2.68562678e-02f, -8.78394693e-02f, 1.79752875e-02f, -1.44220768e-02f, 3.47096287e-02f, -2.63686236e-02f,
  3.30512342e-03f, 3.81334759e-02f, -1.92775857e-02f, -2.26566140e-02f, 5.00978269e-02f, 6.47285432e-02f, 6.66890219e-02f, 1.41955810e-02f, 4.75379303e-02f, 3.51340659e-02f,
  -6.66146204e-02f, 5.78064620e-02f, 7.04266429e-02f, -9.84284934e-03f, -6.94110990e-02f, 5.87534495e-02f, -3.05940155e-02f, 1.61462538e-02f, 4.01569493e-02f, 6.76612929e-02f,
  3.50290090e-02f, -2.17989963e-02f, 1.55157596e-02f, -3.47151275e-04f, -5.97520061e-02f, 3.89530584e-02f, -4.81806286e-02f, 3.22113708e-02f, 9.30042192e-03f, -5.60298227e-02f,
  6.11428767e-02f, 1.06556229e-01f, -8.17051530e-03f, 2.37493427e-03f, -1.72860771e-02f, 2.81047840e-02f, -4.66676764e-02f, 7.99972564e-02f, 2.95686051e-02f, 1.20894331e-02f,
  6.23948388e-02f, 4.32770811e-02f, 9.41190794e-02f, 5.55597544e-02f, 5.68169616e-02f, 5.21739200e-02f, 7.24700689e-02f, 7.35616535e-02f, 1.43492678e-02f, -4.57116216e-02f,
  4.25954700e-01f, -9.49229896e-02f, -2.09759668e-01f, 8.66417512e-02f, 2.25587398e-01f, 1.94500804e-01f, 1.33488417e-01f, 1.28493980e-01f, 2.57100791e-01f, -3.76945212e-02f,
  1.07070595e-01f, -6.49771318e-02f, -1.00418761e-01f, 1.67915568e-01f, 2.83887744e-01f, -1.09557982e-03f, 1.08875491e-01f, 8.70623663e-02f, 9.90661308e-02f, -2.00077258e-02f,
  9.19811204e-02f, 1.85316563e-01f, -1.16172306e-01f, -4.80577379e-04f, -1.33977421e-02f, -1.08312875e-01f, -5.78238033e-02f, -1.06828921e-01f, -2.05136240e-02f, 6.87303767e-02f,
  1.10520847e-01f, 7.97107220e-02f, -4.20589298e-02f, -2.48779505e-02f, -7.51584172e-02f, -4.27771583e-02f, -1.81953609e-02f, -2.14577420e-03f, 8.10958911e-03f, -7.74213150e-02f,
  4.20669443e-04f, 7.19087757e-03f, 6.71990067e-02f, -1.53999887e-02f, 7.54413754e-02f, -1.81909166e-02f, 4.14677821e-02f, 1.03567662e-02f, -5.15920948e-03f, 2.62996741e-02f,
  -1.21876886e-02f, -2.04204465e-03f, -4.81342636e-02f, -5.92643544e-02f, 3.09207849e-02f, 6.65858239e-02f, -4.80353497e-02f, -7.91975185e-02f, 5.94226224e-03f, 6.61774129e-02f,
  4.81407754e-02f, 3.12886946e-02f, -4.06039916e-02f, 5.39461933e-02f, -2.04930864e-02f, 2.31181383e-02f, 2.96299104e-02f, -3.30297872e-02f, -5.32303266e-02f, -2.60101445e-03f,
  9.92888212e-03f, -3.55101675e-02f, -4.21881909e-03f, 3.61365303e-02f, -1.01390146e-02f, -7.30238948e-03f, -1.40745323e-02f, -2.90326085e-02f, -2.60716621e-02f, -3.80423764e-04f,
  8.04456417e-03f, 1.58641990e-02f, -9.46189463e-02f, -1.58845745e-02f, 5.44490367e-02f, 1.26585020e-02f, 6.72275797e-02f, -2.78280918e-02f, -3.47160548e-02f, -6.59467373e-03f,
  -1.05089374e-01f, -3.43282111e-02f, -3.66204622e-04f, 2.99989060e-02f, -1.38812559e-02f, 2.80608628e-02f, 4.73942943e-02f, 6.74348231e-03f, -5.55187799e-02f, 2.74851546e-03f,
  -3.34409252e-02f, -4.02233936e-02f, -3.04767340e-02f, 1.51031744e-02f, -1.98045615e-02f, 6.93585873e-02f, -7.97745585e-03f, -6.18106797e-02f, 5.36253043e-02f, -4.97734314e-03f,
  -6.77856207e-02f, -2.02545896e-02f, 1.99047811e-02f, 3.62342596e-02f, -2.20115134e-03f, -1.42859519e-01f, 6.98404899e-03f, 1.42806228e-02f, -1.13166207e-02f, 1.23925637e-02f,
  3.67604256e-01f, -2.59239614e-01f, 9.40526351e-02f, 2.61466324e-01f, 1.35175839e-01f, -4.53028679e-02f, 6.27162531e-02f, 3.44240032e-02f, 1.41534507e-01f, -2.10346028e-01f,
  4.21579229e-03f, -9.91021320e-02f, -1.73946410e-01f, -3.83735858e-02f, 1.15833648e-01f, -1.29382074e-01f, -4.06141654e-02f, 1.33723253e-02f, 8.53069499e-03f, -2.00550966e-02f,
  1.53231248e-01f, 5.36239371e-02f, 1.40056377e-02f, -8.82540420e-02f, -1.94242671e-02f, 2.80591771e-02f, -5.43065593e-02f, -1.00317247e-01f, -1.01831049e-01f, 4.02330607e-02f,
  2.62288507e-02f, -2.86758021e-02f, -1.18423048e-02f, -5.99386096e-02f, 6.23242818e-02f, -4.01830859e-02f, -4.85218503e-02f, -4.13428620e-02f, 1.37039600e-02f, 5.06751090e-02f,
  -3.51105705e-02f, -5.40694296e-02f, 5.59253357e-02f, 8.89142305e-02f, -3.39168236e-02f, 1.36195747e-02f, 9.97762457e-02f, 8.76429398e-03f, -1.59603381e-03f, -5.19311838e-02f,
  -1.05184531e-02f, -8.91956221e-03f, -2.44882354e-03f, -5.28629720e-02f, -4.99428958e-02f, -4.89218906e-03f, -1.60184950e-02f, 1.37727065e-02f, 1.65926089e-04f, -3.47961998e-03f,
  -8.06034282e-02f, -7.78543716e-03f, 7.59683996e-02f, 3.00388858e-02f, 9.11382437e-02f, 6.53438270e-02f, 5.44271618e-03f, 7.29782581e-02f, 7.55884573e-02f, 3.76349762e-02f,
  -7.65715446e-03f, 4.28962596e-02f, 4.57201228e-02f, -1.33114615e-02f, -9.73686948e-03f, 2.87687667e-02f, -1.60541199e-02f, -8.43568798e-03f, 3.15253250e-02f, 2.37500537e-02f,
  -3.13963066e-03f, -6.63102716e-02f, 5.24308765e-03f, 4.71417308e-02f, -5.81172034e-02f, -3.82701196e-02f, -3.88255306e-02f, -3.56744393e-03f, -2.66937036e-02f, 6.40919851e-03f,
  -2.74193645e-01f, -2.70057052e-01f, -4.00185771e-02f, 6.95962980e-02f, 1.47249433e-03f, -5.80335706e-02f, 5.09840362e-02f, 5.67836277e-02f, -7.42942691e-02f, -1.97623565e-04f,
  4.59366627e-02f, 5.94771095e-02f, -4.36604358e-02f, -2.50789952e-02f, 5.93262948e-02f, -1.01027355e-01f, -4.17036377e-03f, -8.71978849e-02f, -3.77997421e-02f, 1.68949924e-02f,
  8.89125913e-02f, -2.60804724e-02f, -3.07182828e-03f, -3.43521051e-02f, -1.81895420e-02f, 2.21593119e-02f, 3.68207544e-02f, -2.75263526e-02f, 1.12724165e-02f, -1.82646941e-02f,
  4.63299379e-02f, -5.70272729e-02f, -3.86149853e-01f, -1.75081491e-01f, -8.33728239e-02f, -3.28235596e-01f, -2.88671136e-01f, -1.19090118e-01f, 1.24575920e-01f, -1.01104282e-01f,
  -1.27625093e-01f, 3.74470949e-02f, 2.89529897e-02f, -1.87806666e-01f, 1.14867970e-01f, 2.38862187e-02f, -2.67079055e-01f, -1.76792696e-01f, -6.22373670e-02f, -2.54473925e-01f,
  2.99144816e-02f, -1.26899630e-01f, -2.63044447e-01f, 5.22007383e-02f, -1.42745346e-01f, -9.30275023e-02f, 8.38596523e-02f, -6.58552125e-02f, -4.10366729e-02f, 6.88382536e-02f,
  -1.29161462e-01f, -1.83415800e-01f, -6.88645840e-02f, -8.72485861e-02f, -1.10282466e-01f, 6.71309279e-03f, 5.63283041e-02f, -2.11056527e-02f, -1.34923011e-02f, -2.47898102e-02f,
  8.94842446e-02f, -1.86507404e-02f, 1.78443789e-02f, 4.48040627e-02f, 2.01868359e-02f, 2.24929824e-02f, -5.20979846e-03f, -1.34031670e-02f, -6.76139370e-02f, 3.33286524e-02f,
  -4.96943593e-02f, -5.55994846e-02f, -1.22655429e-01f, 5.05047031e-02f, -4.90875468e-02f, -8.71933438e-03f, -5.56839630e-02f, -6.55833855e-02f, -2.60446984e-02f, 4.66059744e-02f,
  -4.03723679e-02f, 7.53465220e-02f, -2.54753008e-02f, -1.69249158e-02f, -1.02514267e-01f, 1.63598638e-02f, 3.07554416e-02f, 1.20385382e-02f, -2.11750679e-02f, 3.36883701e-02f,
  -5.49704805e-02f, -2.35850085e-02f, 2.33463496e-02f, -2.31155194e-02f, 5.11891488e-03f, 5.58063276e-02f, 4.55462933e-03f, -2.17185933e-02f, 1.52024459e-02f, 4.09172066e-02f,
  -1.46786105e-02f, -1.19296387e-02f, 1.08558685e-02f, -5.43562090e-03f, 1.56036159e-02f, 7.63064548e-02f, 1.88722685e-02f, 1.70955919e-02f, -1.66605096e-02f, 3.00630908e-02f,
  -1.08632021e-01f, -2.54777014e-01f, -1.93600692e-02f, -5.41106658e-03f, 2.36054026e-02f, -4.09265310e-02f, 4.96172570e-02f, -1.34050203e-02f, -5.25175892e-02f, 3.94358449e-02f,
  -7.82189965e-02f, 1.07879430e-01f, -7.54074082e-02f, 3.37449647e-02f, -6.90083802e-02f, -3.45082693e-02f, -1.96095649e-02f, -3.57768945e-02f, -2.98165269e-02f, -1.45038171e-02f,
  -1.35316944e-03f, 8.75493288e-02f, 1.34772867e-01f, 1.03777722e-02f, 2.29407158e-02f, -6.62237108e-02f, 8.39621574e-02f, -5.54359658e-03f, 1.46508487e-02f, 2.50787456e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.18617661e-01f, 2.26260468e-01f, -1.55599294e-02f, -2.61734337e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.86012581e-01f, 4.53299254e-01f, -3.76602054e-01f, -2.34150980e-02f, 3.08474272e-01f, -3.11664753e-02f, 2.45701388e-01f, -5.78119680e-02f, -4.86910373e-01f, 5.67124128e-01f,
  -2.44059041e-01f, -1.24370111e-02f, 4.16810781e-01f, 3.40275466e-01f, -2.26562351e-01f, -1.74877554e-01f, 3.04387242e-01f, 2.82259937e-02f, 3.41056973e-01f, -2.47277021e-01f,
  1.50567248e-01f, 3.63969982e-01f, -4.33861554e-01f, 2.44103640e-01f, -1.08586125e-01f, -1.12364292e-01f, 1.58775821e-01f, 7.86111653e-02f, 3.39637160e-01f, 2.39892155e-01f,
  4.02994275e-01f, 1.90748185e-01f, -4.58246395e-02f, -1.34872019e-01f, -2.28010938e-01f, -8.77363160e-02f, 4.01535183e-02f, -3.34389806e-02f, 7.69606279e-03f, -7.32937306e-02f,
  1.16569854e-01f, 3.30109239e-01f, 1.01190850e-01f, -1.27131760e-01f, 1.47273004e-01f, -2.75260583e-02f, 7.85039086e-03f, -2.12947994e-01f, -3.98925096e-02f, -1.52958393e-01f,
  3.44519675e-01f, -1.70398638e-01f, 2.51443863e-01f, 1.07812464e-01f, -2.90952086e-01f, -2.75279254e-01f, 2.72058934e-01f, -1.15022309e-01f, 6.47207975e-01f, 4.52681184e-01f,
  5.14015183e-02f, 4.16019499e-01f, 3.31748933e-01f, -4.52626169e-01f, 2.01706402e-03f, -3.73342603e-01f, -1.22662470e-01f, -1.67391330e-01f, -1.99306667e-01f, 1.87334970e-01f,
  5.15086874e-02f, -1.84994578e-01f, 4.30819094e-01f, -1.02748662e-01f, -1.42607510e-01f, -1.06989704e-01f, -3.92333448e-01f, -3.97850782e-01f, -2.04590112e-01f, 3.52475375e-01f,
  3.29976156e-02f, 1.20683856e-01f, -2.60378321e-04f, 1.15413330e-01f, 4.42127466e-01f, -3.69917303e-01f, 5.06067753e-01f, -4.61401135e-01f, 2.25390285e-01f, 1.79876819e-01f,
  3.04391868e-02f, 9.61358994e-02f, 5.93825523e-03f, -6.39721155e-02f, -2.55971313e-01f, -3.64076853e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.67986643e-01f, -3.22830975e-01f, 3.06211829e-01f, 1.77225366e-01f, -9.02661979e-02f, 4.88534868e-01f, -1.08044378e-01f, 5.82104266e-01f, -1.03029869e-02f, 7.63710290e-02f,
  -3.06975812e-01f, -5.85603893e-01f, -1.94493040e-01f, -3.18243772e-01f, -1.42815456e-01f, 5.06760836e-01f, 4.40714182e-03f, -1.25743700e-02f, -3.33711058e-01f, 4.04204398e-01f,
  -7.02715963e-02f, -2.65221506e-01f, 2.16656595e-01f, -1.70243338e-01f, 1.22437060e-01f, 3.38577509e-01f, 8.14633220e-02f, 3.39099765e-01f, 3.39267135e-01f, -1.61254466e-01f,
  -2.98931122e-01f, 1.69899583e-01f, 2.17144877e-01f, -7.41899684e-02f, 5.20774797e-02f, 3.22675198e-01f, 5.73645011e-02f, 2.60861386e-02f, -1.78998709e-01f, -4.62099351e-02f,
  1.43865710e-02f, -4.39141035e-01f, -1.28140211e-01f, -1.70988873e-01f, -2.31197774e-01f, -1.74620189e-02f, 1.41476855e-01f, 2.14144498e-01f, -1.50893345e-01f, 1.30568936e-01f,
  -1.60844505e-01f, -2.75853932e-01f, 2.46204153e-01f, -1.65757135e-01f, 1.79229721e-01f, 1.52117789e-01f, -1.13559449e-02f, -1.09950006e-01f, -1.09362878e-01f, 1.09196581e-01f,
  5.67838661e-02f, 1.55863971e-01f, -1.97510958e-01f, 1.85964122e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  4.55211014e-01f, 1.68424845e-01f, 4.19226568e-03f, -6.84193671e-02f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  2.25483820e-01f, 4.20121133e-01f, 3.31351101e-01f, 2.60271281e-01f, 4.97410335e-02f, 2.29673788e-01f, 5.28316021e-01f, -3.17239724e-02f, 1.65765770e-02f, -1.11443475e-01f,
  -7.26885349e-02f, 3.60868424e-01f, -1.65452823e-01f, 3.99669677e-01f, -1.92620352e-01f, 2.17126980e-01f, 1.73229292e-01f, 3.83928299e-01f, 4.89924669e-01f, 3.59646976e-01f,
  3.07412535e-01f, 2.78522432e-01f, 3.98258656e-01f, 2.38163862e-02f, 1.05378434e-01f, 1.20751478e-01f, -1.89468533e-01f, 4.67298150e-01f, -3.48246247e-01f, 3.30273360e-01f,
  -6.86815977e-02f, -8.21363926e-02f, 1.26940608e-01f, -5.60443819e-01f, -1.50709048e-01f, -3.13660800e-01f, 2.95965616e-02f, -5.84364831e-02f, 2.52981395e-01f, -5.53262345e-02f,
  2.85621971e-01f, 6.76585972e-01f, -2.11895540e-01f, -2.26457026e-02f, -6.21446550e-01f, -1.87527806e-01f, 2.72867400e-02f, 1.29112944e-01f, -2.47455567e-01f, 5.43869793e-01f,
  1.85856953e-01f, 5.92467785e-01f, 3.78227711e-01f, 6.71497807e-02f, -7.38758072e-02f, -2.43915215e-01f, -1.92085113e-02f, 5.02193689e-01f, 1.61756083e-01f, 4.61783469e-01f,
  -4.55166042e-01f, 4.89518136e-01f, -9.46712345e-02f, -1.11260198e-01f, 3.54067177e-01f, 2.46726245e-01f, -1.57091692e-01f, 2.56241769e-01f, 2.16303542e-02f, -2.49998927e-01f,
  -3.66103053e-01f, -7.15616867e-02f, -1.75200269e-01f, -4.29246098e-01f, 4.26848263e-01f, -5.03547862e-02f, 4.91646528e-01f, -2.70765841e-01f, 4.00529355e-01f, 1.62047386e-01f,
  -3.10425311e-01f, 4.26253170e-01f, 2.75901198e-01f, 2.69654810e-01f, 1.80208996e-01f, 9.93782282e-02f, 3.09874833e-01f, -3.49611551e-01f, 3.04102480e-01f, 2.14613751e-01f,
  -2.43255332e-01f, 5.60443759e-01f, -4.45367366e-01f, 3.83990020e-01f, -2.46738970e-01f, -2.27184072e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -5.90706646e-01f, 3.95950191e-02f, 3.90995085e-01f, 1.35580543e-02f, -1.99590012e-01f, 4.16025043e-01f, 7.23160744e-01f, 2.32520759e-01f, 2.50378013e-01f, -6.67539895e-01f,
  -7.53013492e-01f, -1.96917355e-01f, 1.87841251e-01f, -7.81999603e-02f, -4.08343852e-01f, -1.25953713e-02f, 2.07823306e-01f, 3.23996007e-01f, 2.99736381e-01f, 5.17733349e-03f,
  1.58186600e-01f, 2.50509799e-01f, 2.07727581e-01f, -1.39964938e-01f, -1.21972390e-01f, -6.91600144e-01f, -5.17569110e-02f, -3.23723964e-02f, 3.78266931e-01f, 2.21936673e-01f,
  1.54544219e-01f, -5.94613701e-02f, 3.07073981e-01f, 3.62662256e-01f, 2.13767782e-01f, 6.11677945e-01f, 2.67482042e-01f, 3.54157478e-01f, -6.31370246e-01f, 1.14747748e-01f,
  -8.94446746e-02f, 3.13126892e-02f, 6.54835522e-01f, 1.40793115e-01f, 7.79060304e-01f, -2.10926116e-01f, 2.30168641e-01f, -1.92068312e-02f, 2.56706506e-01f, -1.95878565e-01f,
  1.55151397e-01f, -4.23994452e-01f, -4.99432087e-02f, 3.83605123e-01f, 1.39376625e-01f, 4.82526809e-01f, -1.42701373e-01f, 5.98405302e-01f, -2.28500113e-01f, -2.95504004e-01f,
  -1.66068912e-01f, 6.55673146e-02f, -2.24953098e-03f, 3.30291726e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  3.33854765e-01f, 2.53789514e-01f, 2.59000719e-01f, 1.35103270e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -1.35331064e-01f, -4.44920957e-01f, 5.90070486e-02f, -4.28083748e-01f, -4.78449285e-01f, -3.04548234e-01f, -1.43021271e-01f, -1.13704927e-01f, 5.96472383e-01f, -1.42139837e-01f,
  -6.21788800e-01f, 5.90991437e-01f, 4.77926344e-01f, -5.79199230e-04f, -6.06886506e-01f, 4.74483639e-01f, -5.31747818e-01f, -4.50978041e-01f, -4.05635387e-01f, -3.55486333e-01f,
  -2.29011998e-01f, -4.31704789e-01f, -8.19081161e-03f, -6.94296360e-02f, -4.16477650e-01f, 1.72693189e-02f, 1.82777196e-01f, 8.78374279e-02f, 4.75361377e-01f, 3.98682117e-01f,
  7.57124349e-02f, -3.62681746e-01f, 2.79390872e-01f, -8.51706043e-02f, 3.88448179e-01f, 3.67401242e-01f, 1.39827386e-01f, 5.98049164e-01f, 2.26299807e-01f, 6.29008234e-01f,
  -8.59627724e-02f, 5.10299683e-01f, -5.37634254e-01f, 1.75564080e-01f, 6.03897870e-01f, -1.93638951e-01f, -2.16367275e-01f, 1.92400232e-01f, -4.88682091e-01f, -4.42577392e-01f,
  -5.76505721e-01f, -5.93322635e-01f, -4.91636217e-01f, -4.72503215e-01f, 2.53748178e-01f, -1.94196478e-01f, -1.40761584e-01f, 1.11044578e-01f, -2.75298536e-01f, 5.73993564e-01f,
  1.48395509e-01f, -1.04761729e-02f, -2.73749292e-01f, -5.43729186e-01f, 2.23208591e-01f, 2.50296444e-01f, -1.63872242e-01f, -7.50065148e-02f, -2.29322687e-01f, -3.23886611e-02f,
  -3.15948039e-01f, -3.59811395e-01f, 1.21501677e-01f, -5.19441783e-01f, 2.73045182e-01f, -5.19834757e-01f, -4.03084457e-01f, -3.36095132e-02f, 3.39640498e-01f, -9.96251330e-02f,
  2.80750751e-01f, 1.97819814e-01f, -6.72677457e-02f, -4.33817059e-02f, -2.17276797e-01f, -9.58906636e-02f, -5.89495659e-01f, -2.95465082e-01f, 3.34176809e-01f, -1.87648550e-01f,
  3.32043141e-01f, -1.91356555e-01f, -7.05106676e-01f, -4.11719859e-01f, 2.74016082e-01f, 3.54567438e-01f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  2.23830223e-01f, 3.78025293e-01f, -5.65278113e-01f, 2.78974444e-01f, -2.46851593e-01f, -3.14538509e-01f, -3.33840519e-01f, -5.80568552e-01f, -6.97959542e-01f, -1.08193561e-01f,
  5.86869478e-01f, -6.18537068e-01f, -3.49019095e-02f, 3.04513246e-01f, 9.01676357e-01f, -3.84009093e-01f, 3.99058610e-01f, 6.55625224e-01f, -1.89837322e-01f, 3.60395163e-01f,
  4.02895212e-01f, 3.15692484e-01f, -4.57603857e-02f, 9.06108022e-02f, 2.61070698e-01f, -1.27676022e+00f, -1.06639445e-01f, -8.08663785e-01f, 6.24696076e-01f, 4.58738387e-01f,
  -1.45449862e-01f, 2.45356262e-01f, 3.98082912e-01f, 2.78743714e-01f, 4.27914351e-01f, 5.10521412e-01f, 5.41149318e-01f, 6.66433632e-01f, 2.96189398e-01f, 6.07088208e-01f,
  -3.76828671e-01f, 4.95483637e-01f, 6.10954881e-01f, -4.87848967e-01f, -7.84704745e-01f, 1.18299156e-01f, 6.86608732e-01f, 6.48189411e-02f, 5.73874973e-02f, -1.71444610e-01f,
  -3.12456161e-01f, -2.30562985e-01f, -5.68821132e-01f, -6.15422539e-02f, 2.59320050e-01f, 4.58722487e-02f, -2.72452146e-01f, -1.33046120e-01f, 1.69324189e-01f, 6.63040876e-02f,
  -1.37074769e-01f, 5.75401485e-01f, 5.44006348e-01f, -3.57945234e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  2.86916077e-01f, 2.19961181e-01f, 4.14199352e-01f, 3.22573073e-02f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  1.03812778e+00f, 2.89073437e-01f, 8.44635129e-01f, 8.11597466e-01f, 9.48107243e-03f, -1.34569958e-01f, -1.42871946e-01f, 6.51465535e-01f, 6.09708369e-01f, 5.14638841e-01f,
  -1.02457380e+00f, -7.61239231e-01f, -4.09850478e-01f, -3.52533937e-01f, 2.49853522e-01f, 1.41085252e-01f, -6.40749216e-01f, 7.17083275e-01f, -7.00586379e-01f, 1.13299894e+00f,
  -1.06828845e+00f, -1.02131855e+00f, 7.12163270e-01f, 2.24942759e-01f, 5.92244491e-02f, -3.04572254e-01f, -3.12309057e-01f, -7.58023381e-01f, -2.01836765e-01f, -4.72471237e-01f,
  -5.05791485e-01f, -1.95203125e-01f, -3.63356680e-01f, -2.66864330e-01f, -6.43003464e-01f, -5.30813336e-01f, 3.60437840e-01f, 6.30498007e-02f, 1.07889104e+00f, -7.27112830e-01f,
  -4.49168622e-01f, -7.47538805e-01f, -5.25640070e-01f, -8.53618085e-01f, -2.17291519e-01f, 6.87612474e-01f, -8.03817451e-01f, 8.82556140e-02f, -1.02849162e+00f, -2.07577959e-01f,
  1.82496905e-01f, 2.33957600e-02f, -2.65057594e-01f, 2.47954682e-01f, -3.68037492e-01f, 4.28081483e-01f, -7.14378893e-01f, -6.11043513e-01f, 4.83891755e-01f, -1.02739297e-01f,
  6.77272141e-01f, 2.64322877e-01f, -2.36099795e-01f, 4.07809377e-01f, -9.46832657e-01f, 8.91350955e-02f, 6.34896994e-01f, -5.86826466e-02f, 3.67711306e-01f, 3.28668177e-01f,
  1.22225635e-01f, 1.79832743e-03f, 3.32349241e-01f, -2.89635837e-01f, 4.46845852e-02f, -1.54236168e-01f, 1.16495989e-01f, -9.60676074e-01f, 8.08524847e-01f, 6.28538132e-01f,
  4.64722991e-01f, 7.24473596e-02f, -5.30431926e-01f, -4.95438278e-01f, -4.80507053e-02f, 5.32473862e-01f, -7.09543586e-01f, -7.10791051e-01f, 6.51720643e-01f, -5.54044664e-01f,
  -4.22420889e-01f, -9.10070837e-01f, -7.49442279e-01f, -6.51663184e-01f, 9.93167937e-01f, -4.16659623e-01f, 1.02861536e+00f, -5.26155591e-01f, 6.07164085e-01f, -6.36265218e-01f,
  6.89539373e-01f, 4.64815766e-01f, 4.18297380e-01f, -2.73784339e-01f, 4.37387109e-01f, 3.70797634e-01f, 2.90048748e-01f, 3.81253898e-01f, -7.23710299e-01f, 8.74533057e-01f,
  -9.77509767e-02f, -1.75805390e-01f, 1.09583616e-01f, -2.84096092e-01f, -4.32556331e-01f, 5.85820615e-01f, -2.92699644e-03f, 8.03583190e-02f, -5.37794590e-01f, 4.75990355e-01f,
  -7.50305831e-01f, 7.40892172e-01f, 5.44455647e-01f, 8.58636796e-01f, 7.75045216e-01f, -6.36775076e-01f, -5.05405247e-01f, 5.92434347e-01f, 4.12475139e-01f, -9.06981289e-01f,
  -7.34304607e-01f, 3.76112223e-01f, -9.43033874e-01f, -4.95237857e-01f, 9.57722902e-01f, 4.57762718e-01f, 5.29134989e-01f, 7.77640343e-01f, -1.88707620e-01f, 9.14321005e-01f,
  -3.79219919e-01f, -1.91605955e-01f, -2.68006325e-01f, 4.47321348e-02f, -4.92252976e-01f, -5.77079356e-01f, 1.26468569e-01f, -2.15284795e-01f, 5.14135897e-01f, 3.72494102e-01f,
  -1.07876682e+00f, -5.87743759e-01f, 4.95077908e-01f, 6.56385243e-01f, 6.84743881e-01f, 5.60031354e-01f, -4.00657535e-01f, -5.01546152e-02f, 9.84971821e-01f, -2.83286542e-01f,
  3.25735778e-01f, 2.10385114e-01f, -4.70210522e-01f, -5.77347994e-01f, 5.69842272e-02f, -9.09929872e-01f, -8.44515145e-01f, 4.59213406e-01f, 4.07071225e-02f, -5.20040572e-01f,
  -3.72392535e-01f, 8.68136510e-02f, 3.34067829e-03f, 8.00604522e-01f, -9.40475613e-02f, 3.82179283e-02f, -7.34408677e-01f, 3.01739514e-01f, 8.34505081e-01f, -2.78103739e-01f,
  -1.50594682e-01f, 2.01950058e-01f, 1.93442598e-01f, -4.25739110e-01f, -8.18578720e-01f, 4.42286521e-01f, 8.01281929e-01f, 8.24994087e-01f, 8.41637731e-01f, -2.81361759e-01f,
  4.19606000e-01f, -4.96336281e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  3.34481150e-01f, 5.56380928e-01f, 1.87971499e-02f, -5.11867762e-01f, -1.26370201e-02f, 2.80684769e-01f, -1.26823947e-01f, -3.27125579e-01f, 4.78910267e-01f, -8.11694339e-02f,
  -2.23000601e-01f, -1.02952577e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    