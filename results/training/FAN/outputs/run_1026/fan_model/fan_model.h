/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.81928867e-01f, -1.12790428e-01f, -2.61934698e-01f, -3.50372568e-02f, -1.59058888e-02f, -4.23783474e-02f, -3.19279730e-01f, 1.24769276e-02f, 2.20010102e-01f, -2.21175551e-01f,
  8.78691003e-02f, 3.71463805e-01f, 1.89657167e-01f, 3.12377810e-01f, 1.69188768e-01f, -3.84898692e-01f, -1.80210486e-01f, 8.64505470e-02f, 5.13718091e-02f, 1.08079026e-02f,
  7.49269035e-03f, -3.50737795e-02f, 2.32607484e-01f, 8.75166804e-02f, -5.01694120e-02f, 1.91724405e-01f, -1.51446521e-01f, 1.48319369e-02f, 9.56605375e-02f, -1.87924653e-01f,
  -1.99414626e-01f, -6.29927665e-02f, -8.48897081e-03f, -2.12311260e-02f, -1.28241494e-01f, -6.03234358e-02f, -5.80085218e-02f, -7.70646483e-02f, -8.76182020e-02f, -2.82862298e-02f,
  -5.73829859e-02f, 1.09580535e-04f, 3.50528806e-02f, 7.52800610e-03f, -2.16951687e-02f, -4.97155711e-02f, -6.39724284e-02f, -9.87393931e-02f, -1.57958269e-01f, -7.86410421e-02f,
  -1.02214776e-01f, -1.50557443e-01f, -1.59633607e-01f, -7.13012926e-03f, -7.22729713e-02f, 1.14724142e-02f, -3.76816541e-02f, -2.95979157e-02f, 1.04401879e-01f, -1.28429338e-01f,
  -1.35332003e-01f, -7.19648078e-02f, 8.45998451e-02f, -6.24942360e-03f, 4.85047465e-03f, -1.79573726e-02f, -4.56495434e-02f, -2.99768187e-02f, 4.26524356e-02f, -1.02326952e-01f,
  6.03834763e-02f, -1.20285586e-01f, 2.56208088e-02f, -8.39970708e-02f, 2.05281880e-02f, 4.25296230e-03f, -6.86303899e-02f, 3.60186473e-02f, 1.34577584e-02f, 2.98048407e-02f,
  2.01783329e-03f, 3.33875790e-02f, -1.23978651e-04f, 4.12168243e-04f, -1.00419279e-02f, -5.13899513e-02f, -6.95285499e-02f, 6.44030124e-02f, 4.97219712e-02f, -3.66183482e-02f,
  5.71852960e-02f, 7.06585944e-02f, -2.13766992e-01f, 7.68631650e-03f, -5.75558059e-02f, -1.59443811e-01f, -5.45505770e-02f, -1.05158299e-01f, -5.15255630e-02f, -1.37166560e-01f,
  -4.61246595e-02f, -4.02139835e-02f, -1.09406531e-01f, -1.39994994e-01f, -1.06574342e-01f, -1.23078085e-01f, -7.23533705e-02f, -6.85364977e-02f, -4.39631976e-02f, -9.09010917e-02f,
  -1.10247485e-01f, -1.38438016e-01f, -5.75055145e-02f, -4.50031050e-02f, -7.80697167e-02f, 3.96951512e-02f, -1.69861615e-01f, -1.70452759e-01f, 1.05863931e-02f, -2.95275986e-01f,
  9.48693380e-02f, -2.91414261e-01f, -6.99651465e-02f, 1.12043181e-02f, -1.71750411e-02f, 1.00747444e-01f, -9.48419645e-02f, 5.18454835e-02f, 5.52052818e-02f, -2.00707406e-01f,
  2.11240612e-02f, 2.11112797e-01f, 9.37990099e-02f, 1.71504721e-01f, 2.75508851e-01f, -1.52477667e-01f, -7.32027367e-02f, 1.24946848e-01f, 3.71844530e-01f, 2.30094552e-01f,
  -6.04037791e-02f, 7.96125829e-02f, 2.25162059e-01f, 1.63850173e-01f, -3.45907032e-01f, -3.53815518e-02f, -1.69157803e-01f, -1.77948594e-01f, -1.36492416e-01f, -6.08256042e-01f,
  -1.47726029e-01f, -1.70815557e-01f, 1.09769866e-01f, -2.43837330e-02f, 1.10593112e-02f, 4.03436646e-02f, 2.72911675e-02f, 1.34004038e-02f, -3.01187653e-02f, -5.31451590e-03f,
  4.36989293e-02f, 1.35929435e-01f, 1.50926942e-02f, -1.85710508e-02f, -1.61620546e-02f, 1.32367257e-02f, -4.74853404e-02f, 8.77704471e-03f, 6.78876415e-02f, 4.06558514e-02f,
  -4.61209789e-02f, -1.52242124e-01f, 2.65420526e-02f, 1.27238268e-02f, 4.34699096e-02f, 6.08918220e-02f, -8.72063115e-02f, -1.19796485e-01f, 4.10075001e-02f, -2.25483641e-01f,
  1.83676537e-02f, 2.68661752e-02f, -6.16749227e-02f, -4.81032878e-02f, -1.32104814e-01f, 1.59563757e-02f, -1.03856042e-01f, -8.77613351e-02f, 8.90977308e-03f, -4.67046872e-02f,
  5.60974004e-03f, -3.67791243e-02f, -2.63236463e-02f, -4.84781154e-02f, -3.62759344e-02f, -1.13669783e-02f, -8.44315067e-02f, -1.08718053e-01f, -4.11622301e-02f, -1.10486865e-01f,
  -3.07282265e-02f, -5.56499250e-02f, -7.97489285e-02f, -2.07772385e-02f, -1.05621487e-01f, -5.90367801e-02f, -2.28175782e-02f, -1.50747765e-02f, 4.28489223e-02f, -6.03202432e-02f,
  8.67442414e-02f, 2.65675783e-01f, -6.04617316e-03f, 9.42353979e-02f, -2.63905302e-02f, -4.95498115e-03f, -8.17302521e-03f, 3.26986648e-02f, 3.53395753e-02f, -2.23627947e-02f,
  9.99640953e-03f, 1.31075997e-02f, 2.77824746e-03f, 1.82143841e-02f, 5.68194389e-02f, 1.94139052e-02f, -7.15745836e-02f, 3.35893072e-02f, 2.19886471e-02f, -1.09484963e-01f,
  -2.06617694e-02f, 9.83753353e-02f, 1.87381089e-01f, 8.51260647e-02f, -3.14273648e-02f, 1.29971743e-01f, -1.00142427e-01f, -1.05874259e-02f, 1.04406945e-01f, -4.71956618e-02f,
  5.45453489e-01f, -5.04279673e-01f, 1.72496244e-01f, 1.87777907e-01f, -8.53961408e-02f, 2.32236646e-02f, -2.73687243e-01f, 7.96006247e-02f, 1.16047710e-01f, -1.46347791e-01f,
  -1.78599328e-01f, 6.45149201e-02f, 6.64713234e-02f, -6.42798143e-03f, 8.23993534e-02f, -2.34017611e-01f, -1.05368122e-01f, 2.20294535e-01f, 2.11464971e-01f, 1.67076625e-02f,
  -2.09674150e-01f, -7.41340145e-02f, 3.02860796e-01f, 2.84446329e-02f, -3.44194800e-01f, 3.17317955e-02f, -2.19995528e-01f, -1.30258664e-01f, -2.93721080e-01f, -3.96818697e-01f,
  -1.49676278e-01f, -1.81036025e-01f, -3.32418941e-02f, -5.73215894e-02f, -1.51435390e-01f, 8.61857366e-03f, -1.46695282e-02f, -1.25756366e-02f, -3.83442268e-02f, -8.43315125e-02f,
  -1.83541358e-01f, -8.72075558e-02f, -5.35232238e-02f, -1.12456866e-01f, -6.25833645e-02f, -1.33600518e-01f, -1.18400648e-01f, 1.87330209e-02f, -1.92990061e-02f, -1.61408991e-01f,
  -2.23165020e-01f, -9.83424485e-02f, -3.49574499e-02f, -1.42295569e-01f, -8.13345164e-02f, -5.76795675e-02f, -2.46138826e-01f, -1.89461291e-01f, -8.58793780e-02f, -1.40194595e-01f,
  2.61340030e-02f, 7.39103407e-02f, 7.95236602e-02f, 9.36285034e-02f, 1.39633417e-01f, 1.14483714e-01f, 5.36277331e-02f, 9.42649245e-02f, 1.04762249e-01f, 3.45600881e-02f,
  1.30368456e-01f, 5.08862101e-02f, 1.11069240e-01f, 1.19883209e-01f, 8.45445916e-02f, 6.35926202e-02f, 1.11371063e-01f, 2.28821747e-02f, 3.91987786e-02f, 1.14284702e-01f,
  1.06423311e-01f, 6.72092754e-03f, 9.85439494e-02f, 5.88699989e-02f, 2.10246928e-02f, 1.12769164e-01f, 4.94235121e-02f, 5.04629910e-02f, 1.81151807e-01f, 5.08319810e-02f,
  3.07816509e-02f, -8.90386999e-02f, -4.32657711e-02f, -1.82403341e-01f, -8.08743462e-02f, -1.28347754e-01f, -1.07211567e-01f, -1.52111605e-01f, -1.19748451e-01f, -1.17478915e-01f,
  -1.16261289e-01f, -1.82186291e-02f, -8.41138214e-02f, -4.09988947e-02f, -4.92782481e-02f, -1.12914346e-01f, -1.61586404e-01f, -5.72512932e-02f, -6.26988560e-02f, -1.45205662e-01f,
  -7.81273916e-02f, -5.46599552e-02f, -3.95832583e-02f, -2.46682744e-02f, -9.53883454e-02f, 9.74332541e-02f, -8.61015767e-02f, -7.52380416e-02f, 6.96583837e-02f, -3.25486623e-02f,
  6.32017136e-01f, 4.17265236e-01f, 2.57630408e-01f, 2.08996683e-01f, 3.96268852e-02f, 2.00199753e-01f, 3.63511980e-01f, 2.91232020e-01f, 5.56017924e-03f, 1.08059876e-01f,
  -2.63355047e-01f, -2.00841144e-01f, -5.44596575e-02f, 5.32840416e-02f, 2.33573556e-01f, 4.27333027e-01f, 3.07983041e-01f, 3.40575039e-01f, 1.58003092e-01f, -5.97380437e-02f,
  -8.03742930e-02f, -2.38222945e-02f, -3.74207869e-02f, 1.01239458e-01f, 1.41954824e-01f, 8.67345482e-02f, 1.47417590e-01f, 1.63120642e-01f, 1.72486201e-01f, 3.26559186e-01f,
  2.08415329e-01f, 3.63302410e-01f, -9.74554196e-03f, 4.90734428e-02f, 5.26224449e-02f, 1.26663119e-01f, 1.07955329e-01f, 1.49144009e-01f, 1.34331435e-01f, 8.25313255e-02f,
  3.31446007e-02f, 1.33611098e-01f, 1.12435363e-01f, 1.05068035e-01f, 8.41848627e-02f, 1.68388739e-01f, 6.99314848e-02f, 1.90101653e-01f, 1.54741719e-01f, 1.58084273e-01f,
  1.05034485e-01f, 3.41717415e-02f, 2.18996570e-01f, 2.07590267e-01f, 1.67523310e-01f, 2.44466849e-02f, 2.30621666e-01f, 2.59350866e-01f, 2.13906363e-01f, 3.76857758e-01f,
  1.41420274e-03f, -1.09796770e-01f, -1.69703498e-01f, -2.86689848e-02f, -9.01307985e-02f, -8.61382186e-02f, -1.70797389e-02f, -1.47909999e-01f, -7.44924545e-02f, -6.64504543e-02f,
  -8.37044939e-02f, -9.43053514e-02f, -9.37106311e-02f, -8.06094408e-02f, -1.87741563e-01f, -1.02649584e-01f, -1.23283565e-01f, -1.30114615e-01f, -1.43367618e-01f, -1.76874340e-01f,
  -1.27492085e-01f, -1.74779370e-01f, -1.68983012e-01f, -1.41825706e-01f, -1.18176997e-01f, -9.61320102e-02f, -1.81305781e-01f, -2.40439430e-01f, -1.06967598e-01f, -1.37935892e-01f,
  -1.12753570e-01f, 1.89066026e-02f, 1.53571606e-01f, 8.66207853e-02f, 1.52953789e-01f, 1.08027913e-01f, 1.37922749e-01f, 7.37130269e-02f, 4.56565022e-02f, 1.62117913e-01f,
  1.03288464e-01f, 1.49473950e-01f, 1.30313233e-01f, 1.47874221e-01f, 9.51957777e-02f, 6.05354980e-02f, 1.30546838e-01f, 1.34174362e-01f, 1.15591004e-01f, 7.23243952e-02f,
  6.00454323e-02f, 1.99635848e-01f, 1.98371306e-01f, 9.08210650e-02f, 1.46644115e-01f, 1.28167927e-01f, 9.70215797e-02f, 1.53482318e-01f, 2.69191831e-01f, 3.25665206e-01f,
  -3.05531383e-01f, -1.24123849e-01f, 9.53217596e-02f, -1.97185427e-01f, 1.65511236e-01f, 2.87355542e-01f, 3.63739043e-01f, 3.74125205e-02f, -1.22809947e-01f, 1.36933103e-01f,
  2.39058822e-01f, 6.63358048e-02f, 1.38342738e-01f, 1.87065318e-01f, 1.97313026e-01f, 1.37992308e-01f, 5.19372337e-02f, 1.34640224e-02f, 2.82133609e-01f, 1.71665087e-01f,
  9.81742442e-02f, 5.19233420e-02f, -1.02203429e-01f, 1.38383906e-03f, -1.01047166e-01f, 2.37546745e-03f, 1.16499245e-01f, 4.96946648e-03f, 1.55162290e-02f, -3.75858068e-01f,
  1.59774274e-01f, -1.52686730e-01f, 2.90616930e-01f, 1.13488697e-01f, 1.06565036e-01f, -3.00825406e-02f, 8.27616081e-02f, -4.61043082e-02f, -1.54686589e-02f, 6.08556122e-02f,
  2.57191155e-02f, -4.17848825e-02f, -2.45596934e-02f, 8.65542796e-03f, -1.77842509e-02f, 3.73984650e-02f, -6.09356463e-02f, -1.59671139e-02f, -6.68710396e-02f, 1.49295880e-02f,
  1.20329624e-02f, 9.67271179e-02f, 1.34953946e-01f, -2.74633747e-02f, 2.81068068e-02f, 1.19393151e-02f, 5.81067093e-02f, -5.22645526e-02f, 6.44439161e-02f, -2.82589458e-02f,
  -2.48028664e-03f, -2.04224244e-01f, -2.01057438e-02f, -6.46746531e-02f, 7.04363286e-02f, -6.88655153e-02f, -1.64611116e-02f, -8.85550771e-03f, -1.03008620e-01f, -1.43554958e-03f,
  -9.36053973e-03f, 8.87506902e-02f, -8.61927420e-02f, 1.93635914e-02f, 5.07188700e-02f, -3.58885899e-02f, -4.05857638e-02f, 5.67470789e-02f, 1.14427850e-01f, 3.49109992e-02f,
  2.21776254e-02f, -2.08291747e-02f, -6.62933290e-02f, -2.72068083e-02f, -9.19287130e-02f, 3.31544206e-02f, -4.92938124e-02f, -6.21291958e-02f, 4.43435973e-03f, -3.49543653e-02f,
  8.15416500e-03f, 2.18482062e-01f, 1.59712464e-01f, -7.63373822e-03f, -5.03739761e-03f, 3.14930789e-02f, -2.72461344e-02f, 8.46153647e-02f, 6.76828101e-02f, 8.15168768e-02f,
  1.39840364e-01f, 1.04911812e-01f, 6.49075955e-02f, -4.70545180e-02f, 4.84167337e-02f, 1.59110889e-01f, 8.13889429e-02f, 9.06041488e-02f, 1.35087788e-01f, -6.87388554e-02f,
  6.12081252e-02f, 1.75409034e-01f, 2.96597362e-01f, 2.31282398e-01f, 2.92156488e-02f, 2.42766231e-01f, 2.64839768e-01f, 1.29907623e-01f, 2.74153858e-01f, 2.81622857e-01f,
  2.41300911e-01f, -3.95785362e-01f, 1.32987946e-01f, 5.36751226e-02f, -8.30591992e-02f, 1.15278207e-01f, -3.33720595e-01f, -3.11574675e-02f, 8.23180601e-02f, -2.81927794e-01f,
  -1.13985330e-01f, 1.64662614e-01f, 5.64202145e-02f, 1.37250632e-01f, 2.34480560e-01f, -2.45377749e-01f, -1.18077442e-01f, 2.80942231e-01f, 5.35263121e-01f, 5.34465350e-02f,
  -1.02144472e-01f, -8.48076940e-02f, 3.03321272e-01f, 1.78687602e-01f, -3.65701586e-01f, 5.13592139e-02f, -1.23699553e-01f, -1.13207072e-01f, -1.99322119e-01f, -3.99163753e-01f,
  1.17116570e-02f, -1.20676532e-01f, 2.30493277e-01f, 1.16851717e-01f, 5.30117452e-02f, 8.51757675e-02f, 3.30031328e-02f, 6.66847453e-02f, 8.96116421e-02f, 2.70332005e-02f,
  7.24875480e-02f, 5.91535904e-02f, 1.36919886e-01f, 1.01408064e-01f, 4.87157889e-02f, 1.39668241e-01f, -3.38753983e-02f, 2.20142543e-01f, 3.46286856e-02f, -3.40784527e-02f,
  -3.77730168e-02f, 2.08488964e-02f, 7.73503259e-02f, 4.25765626e-02f, 1.79647684e-01f, 9.01005194e-02f, 6.86910525e-02f, 1.02359310e-01f, 2.52238959e-01f, -1.05142638e-01f,
  9.60164145e-03f, 2.25449484e-02f, 5.67329600e-02f, -3.06103770e-02f, 3.32529098e-02f, 1.24127558e-02f, 9.22242925e-03f, -9.86386687e-02f, 8.13377127e-02f, -2.23706588e-02f,
  4.16625962e-02f, -1.57450121e-02f, -2.38692611e-02f, -4.43076575e-03f, -7.11024329e-02f, -3.88842486e-02f, -2.09928192e-02f, -7.02210292e-02f, -2.71831658e-02f, 1.32870639e-03f,
  2.06754003e-02f, -1.32235289e-02f, -5.67939244e-02f, -2.67669018e-02f, -4.25278023e-02f, 3.47893802e-03f, -4.81038839e-02f, 3.34435627e-02f, -1.46648986e-02f, -6.72240369e-03f,
  1.02615923e-01f, 2.50011593e-01f, -5.84199913e-02f, 4.68607806e-02f, 5.70976436e-02f, 5.13669476e-02f, 9.62266326e-03f, 7.74328038e-02f, 7.88746253e-02f, -2.32256632e-02f,
  3.76723111e-02f, 6.01963066e-02f, 6.71750605e-02f, 4.87390533e-02f, 1.19342797e-01f, 5.31619303e-02f, 2.81951483e-02f, -1.25190513e-02f, 1.17382035e-01f, 1.10682072e-02f,
  -8.46911967e-02f, 7.03513622e-02f, 9.79452580e-02f, 2.13304441e-02f, 1.31602343e-02f, 7.31135830e-02f, 6.27783015e-02f, 5.59771992e-02f, 1.04312189e-01f, -9.77956727e-02f,
  -1.99848302e-02f, 1.41370386e-01f, -6.68047741e-02f, -1.46208048e-01f, -9.08957701e-03f, 1.81220993e-01f, 2.26950973e-01f, 1.36423528e-01f, -5.47028631e-02f, 1.70779958e-01f,
  1.15692258e-01f, 7.71190748e-02f, -7.09826946e-02f, -9.63643268e-02f, -7.97377452e-02f, -1.25907466e-01f, -1.45031154e-01f, -1.80275291e-01f, -7.92818367e-02f, -9.81166586e-02f,
  4.44745421e-02f, -9.82778966e-02f, -2.09930480e-01f, -1.39500543e-01f, -4.78925146e-02f, 4.95405309e-02f, -6.53680936e-02f, 3.21237817e-02f, 1.48478538e-01f, -1.10892057e-01f,
  1.25557646e-01f, 2.26304501e-01f, 1.56491324e-01f, 1.85437351e-01f, 2.47188255e-01f, 1.85952738e-01f, 1.95611849e-01f, 1.62694842e-01f, 2.11548820e-01f, 2.06852064e-01f,
  2.34370232e-01f, 1.10827640e-01f, 1.06709726e-01f, 1.71849072e-01f, 1.79174706e-01f, 1.08282223e-01f, 7.17824548e-02f, 3.81322801e-02f, 1.49926305e-01f, 2.29192287e-01f,
  9.05483738e-02f, 1.27215326e-01f, 2.72946745e-01f, 3.02490801e-01f, 1.08269572e-01f, 1.91527307e-01f, 2.68486768e-01f, 2.43454665e-01f, 2.45446995e-01f, 1.21777266e-01f,
  -1.51959166e-01f, -1.87506780e-01f, -8.93272534e-02f, -1.32403031e-01f, -6.96111619e-02f, -7.82419890e-02f, -1.26862556e-01f, -8.41058046e-02f, -9.96310636e-02f, -9.53994989e-02f,
  -8.60053897e-02f, -1.09710336e-01f, -6.80272579e-02f, -1.47207797e-01f, -1.23380743e-01f, -9.35033113e-02f, -7.15125445e-03f, -1.33707926e-01f, -1.51115730e-01f, -3.11923977e-02f,
  3.65081653e-02f, -3.36756185e-03f, -6.92781955e-02f, -4.01938185e-02f, -9.12907720e-02f, -1.29266366e-01f, -7.14539811e-02f, -7.11798966e-02f, -1.57151029e-01f, -6.45417348e-02f,
  4.13649201e-01f, 2.69501984e-01f, 1.39675751e-01f, 8.77198279e-02f, 2.13635609e-01f, 1.42517865e-01f, 1.75611213e-01f, 1.52497977e-01f, 2.51810104e-01f, 1.74017668e-01f,
  2.40892678e-01f, 1.03320397e-01f, 1.80461600e-01f, 1.62219450e-01f, 2.00480685e-01f, 1.45155892e-01f, 2.12165713e-01f, 1.59060597e-01f, 2.41248265e-01f, 2.20064119e-01f,
  2.89999872e-01f, 2.57526904e-01f, 1.99056149e-01f, 2.19224185e-01f, 2.60622263e-01f, 1.64926440e-01f, 1.79837868e-01f, 3.11015368e-01f, 2.75636703e-01f, 2.19320878e-01f,
  -3.95513922e-01f, 7.88744241e-02f, 2.31070563e-01f, -1.37522727e-01f, -1.68131173e-01f, 1.68843657e-01f, 2.25305125e-01f, 1.99602604e-01f, -3.91822569e-02f, 5.04958583e-03f,
  -2.97386169e-01f, -4.36508834e-01f, -3.60716254e-01f, -4.25530560e-02f, 8.93971398e-02f, 2.11745501e-01f, 3.56354475e-01f, 8.60695913e-02f, 3.67503986e-02f, 6.60962164e-02f,
  1.03103071e-01f, 4.38985303e-02f, 8.15711915e-02f, 3.26853186e-01f, -4.02931347e-02f, -8.04620609e-02f, 1.43090576e-01f, -2.66869757e-02f, 9.99616235e-02f, -1.33818313e-01f,
  -3.07276070e-01f, 5.87535575e-02f, 8.84886533e-02f, -7.37223625e-02f, 3.34844813e-02f, 4.40550297e-02f, 4.62759696e-02f, 1.16233587e-01f, -1.97908487e-02f, 9.07118097e-02f,
  -5.78298680e-02f, 4.19844165e-02f, -1.27063140e-01f, 6.31808788e-02f, 5.82015105e-02f, 8.47630426e-02f, 2.06498951e-01f, 1.48783833e-01f, 8.70950818e-02f, 1.23989582e-01f,
  -3.95915424e-03f, -1.33974068e-02f, 8.04394037e-02f, 1.17267162e-01f, 1.13277130e-01f, -5.66429831e-02f, 1.11381605e-01f, 1.36149451e-01f, 2.45651588e-01f, 1.15472429e-01f,
  1.03005365e-01f, 5.26312133e-03f, -2.96117160e-02f, 2.34909300e-02f, -8.07129368e-02f, 1.68380309e-02f, -8.32489878e-02f, -2.06776541e-02f, -2.21532993e-02f, -2.85309311e-02f,
  -3.79132777e-02f, -8.97461250e-02f, -6.45931587e-02f, -1.14501957e-02f, -6.27409667e-02f, 2.67507453e-02f, -4.82588895e-02f, -3.99763249e-02f, -1.87210850e-02f, -2.92536020e-02f,
  -7.68741593e-02f, -1.77657176e-02f, -1.09291866e-01f, -3.40644158e-02f, -5.05575649e-02f, 1.23699021e-03f, -3.81106213e-02f, -1.83185972e-02f, 5.66984750e-02f, -8.09511170e-02f,
  -1.10516615e-01f, 2.81551275e-02f, -1.37234777e-01f, -3.00420392e-02f, -8.79848935e-03f, -1.72606334e-02f, -1.15966588e-01f, 1.43946325e-02f, -5.17003015e-02f, -3.50906625e-02f,
  7.28425849e-03f, -4.17710021e-02f, -8.03317428e-02f, 5.38917370e-02f, -7.04470351e-02f, 1.45961195e-02f, -1.51327578e-02f, -8.54482874e-02f, 2.38820608e-03f, 1.83688325e-03f,
  1.05528332e-01f, 4.02310938e-02f, -7.41094053e-02f, -4.01563905e-02f, -4.64112386e-02f, -6.94267377e-02f, -4.91423532e-02f, -2.78710220e-02f, -4.66721021e-02f, 1.20618358e-01f,
  -7.44940400e-01f, 1.69305712e-01f, 1.74701016e-03f, -2.95343399e-01f, 2.89800465e-01f, 1.22172318e-01f, 2.28350207e-01f, -1.76629797e-01f, -2.43444800e-01f, 8.88000708e-03f,
  2.21071407e-01f, 7.00525194e-02f, 7.73588335e-03f, 8.37022513e-02f, -2.17981357e-02f, 1.61895618e-01f, 1.21748839e-04f, -9.83639881e-02f, -1.80180073e-01f, 1.95880476e-02f,
  1.63023561e-01f, -1.55415803e-01f, -3.04678172e-01f, -2.06910715e-01f, 2.23421156e-02f, -8.55048653e-03f, -2.93028988e-02f, 1.23978844e-02f, 1.81941047e-01f, 2.46119872e-01f,
  2.09493294e-01f, -5.34157753e-02f, 5.93529455e-02f, 1.51361063e-01f, 7.21516758e-02f, -4.19657454e-02f, 5.90131395e-02f, 1.79441075e-03f, 4.57272083e-02f, 7.87201971e-02f,
  1.16609417e-01f, 5.13207056e-02f, 7.57323205e-02f, 1.12805113e-01f, 1.06556036e-01f, 6.38806596e-02f, 4.50525694e-02f, -1.06976032e-02f, -5.73593751e-02f, 1.03304684e-01f,
  2.27212772e-01f, 7.53226057e-02f, 9.22279246e-03f, 3.52496258e-03f, 1.91324037e-02f, 3.80106568e-02f, 1.56996980e-01f, -2.94027496e-02f, 1.52937761e-02f, -1.21442586e-01f,
  -2.51088701e-02f, 4.12053280e-02f, -8.09413847e-03f, -4.65419851e-02f, -5.53954206e-02f, 6.49543852e-02f, 5.90462312e-02f, 4.67139035e-02f, -5.32832444e-02f, -2.97638010e-02f,
  5.87987825e-02f, 2.32998282e-02f, 5.10761794e-03f, -3.96794900e-02f, 5.46178035e-02f, 3.85054797e-02f, 1.35548823e-02f, 4.00881357e-02f, -1.15314107e-02f, 1.14595341e-02f,
  8.17957669e-02f, 3.42668369e-02f, -2.24716514e-02f, 1.12496674e-01f, 1.06142694e-02f, 3.70754884e-03f, -3.16483974e-02f, 1.09134614e-02f, -2.43814606e-02f, -1.87391210e-02f,
  -2.29610741e-01f, 1.19639784e-01f, 2.06336919e-02f, -3.07204407e-02f, -8.86855926e-03f, 2.36820132e-02f, 6.44377694e-02f, 1.92881972e-02f, 3.90604436e-02f, 5.66130355e-02f,
  1.15263142e-01f, -6.61945567e-02f, 6.22260049e-02f, -1.09800361e-02f, 7.55891055e-02f, 9.69794467e-02f, 6.65864795e-02f, 8.33717175e-03f, 1.04856960e-01f, -8.57225340e-03f,
  -7.47255981e-03f, -4.74958234e-02f, -1.35071486e-01f, -3.88335325e-02f, 5.21144420e-02f, 3.21518779e-02f, 6.07517222e-03f, 1.34835178e-02f, -1.09848445e-02f, -2.47520566e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.22191823e-01f, -2.91643471e-01f, 4.30060297e-01f, 1.19610645e-01f, 2.14498997e-01f, 3.69689912e-01f, 4.22013968e-01f, 1.29373759e-01f, 5.24925739e-02f, 1.42446935e-01f,
  9.76892412e-02f, 1.06240273e-01f, 2.22531080e-01f, 1.46652505e-01f, 1.80820540e-01f, 2.29701713e-01f, 2.37288445e-01f, 2.32844397e-01f, 3.23745847e-01f, 2.99543440e-01f,
  2.00848818e-01f, -2.44033132e-02f, -2.23262429e-01f, 7.07118809e-02f, 2.71574613e-02f, 9.15221125e-02f, 3.49191539e-02f, 1.51709635e-02f, -9.27830786e-02f, 3.80468257e-02f,
  4.73499268e-01f, -2.32501969e-01f, 3.58833447e-02f, -2.71219611e-01f, -1.56748205e-01f, -1.77450866e-01f, 1.16732970e-01f, -1.19638897e-01f, -4.32324335e-02f, 2.40412634e-02f,
  7.99432117e-03f, -1.18797839e-01f, -6.07726499e-02f, 1.43605261e-03f, -2.13252194e-03f, 9.44353268e-02f, -1.40692621e-01f, 7.00350553e-02f, 2.04114988e-01f, 1.84552409e-04f,
  -3.03243864e-02f, -3.47833522e-02f, 2.80095845e-01f, 2.19027832e-01f, 1.95146669e-02f, 1.06194615e-02f, -1.08144144e-02f, -6.52717873e-02f, -6.64515719e-02f, -1.47852423e-02f,
  1.71754628e-01f, 1.91805467e-01f, 9.42818150e-02f, 9.47842002e-02f, 9.64522511e-02f, -4.62180190e-02f, 1.66829501e-03f, 1.61158249e-01f, 1.87453032e-01f, 8.71835649e-02f,
  8.86068419e-02f, 2.15858921e-01f, 1.57657400e-01f, -2.05545854e-02f, 5.45724593e-02f, 9.28058550e-02f, 5.80939045e-03f, 5.64056970e-02f, -7.23297447e-02f, -4.13682982e-02f,
  -7.74982944e-02f, 6.89295754e-02f, -9.22664106e-02f, -4.00526673e-02f, -1.97860464e-01f, 5.57873696e-02f, 3.27903545e-03f, -9.02423821e-03f, -5.62015027e-02f, 5.79042025e-02f,
  1.81282386e-01f, -1.06227666e-01f, 1.97650287e-02f, 6.53434768e-02f, -1.03151411e-01f, -1.65422693e-01f, 5.09927869e-02f, -5.81157021e-02f, -1.23106495e-01f, 1.21345446e-01f,
  -8.74594897e-02f, -6.99333251e-02f, -2.04524435e-02f, 9.13317036e-03f, 2.67619863e-02f, -8.83141086e-02f, -2.78802663e-01f, 6.38912991e-02f, -5.03364801e-02f, -1.74108204e-02f,
  -1.25632808e-01f, 4.20857221e-02f, 3.02699476e-01f, 1.33508876e-01f, -5.33512346e-02f, 5.71217909e-02f, 1.52355924e-01f, -1.36006055e-02f, 1.27580240e-01f, 4.58602328e-03f,
  5.89680552e-01f, -5.30746996e-01f, 4.95638669e-01f, 3.19985837e-01f, 3.99050742e-01f, 3.98707300e-01f, 5.03648937e-01f, 1.44771487e-01f, -2.60564387e-02f, -3.77615541e-02f,
  -1.75180376e-01f, -4.02569443e-01f, -3.03159744e-01f, -2.89278001e-01f, -2.57800281e-01f, 4.40595821e-02f, 2.24578276e-01f, 2.10764155e-01f, 1.85935020e-01f, 1.37503957e-02f,
  -2.53478676e-01f, 4.39356603e-02f, -1.08842492e-01f, -5.04009165e-02f, -1.38113976e-01f, -3.70548815e-02f, 3.40468064e-02f, 7.93612525e-02f, -1.49824113e-01f, -2.89420575e-01f,
  -9.07679200e-02f, 1.36399373e-01f, -1.22247614e-01f, -2.41234913e-01f, 4.09850068e-02f, -1.28115684e-01f, 4.72824834e-02f, -1.14775680e-01f, -7.17885420e-02f, 2.60323891e-03f,
  2.01001181e-03f, -1.31114200e-01f, 3.48337367e-02f, 5.48422746e-02f, 2.00680763e-01f, -6.21286221e-02f, -2.74960827e-02f, -6.31683692e-02f, -1.70508310e-01f, -1.41085535e-01f,
  -1.48527846e-01f, 4.11086790e-02f, 1.87559351e-01f, 1.55840337e-03f, -6.61691874e-02f, -1.31211266e-01f, 7.49944244e-03f, -2.77707484e-02f, -6.97523309e-03f, -1.04336247e-01f,
  -4.57292758e-02f, 6.87726885e-02f, -3.37426439e-02f, 2.90381927e-02f, 1.09736681e-01f, 8.00109431e-02f, 2.97878180e-02f, -2.39221137e-02f, 9.81799364e-02f, 3.63391116e-02f,
  1.70487780e-02f, 8.17311853e-02f, 3.91078405e-02f, -3.42848189e-02f, -1.43381774e-01f, 6.38232604e-02f, 1.21531218e-01f, -1.65856212e-01f, 9.95442644e-02f, 2.80931555e-02f,
  3.09924241e-02f, 4.91538569e-02f, 4.22302186e-02f, -9.09160357e-03f, -1.35879546e-01f, 3.56769599e-02f, 8.49009082e-02f, -1.55431926e-01f, -2.89270766e-02f, -1.81133635e-02f,
  -3.99247468e-01f, 2.47736007e-01f, -5.11265099e-02f, -1.16017178e-01f, 1.38525084e-01f, -9.44490656e-02f, 3.75271551e-02f, 6.05343245e-02f, 1.29971625e-02f, -1.67119931e-02f,
  1.45268654e-02f, 4.22210433e-02f, 7.65692163e-03f, -5.49413599e-02f, 2.97035217e-01f, 2.32920274e-01f, -9.05959979e-02f, 3.40721831e-02f, -1.68418452e-01f, 2.09710002e-02f,
  -1.30421653e-01f, 1.02071889e-01f, 2.60114998e-01f, 1.98967755e-01f, 3.39936316e-02f, 1.19953670e-01f, 9.75960717e-02f, 9.00460929e-02f, 1.76141739e-01f, 1.70199603e-01f,
  5.80151603e-02f, -3.36813360e-01f, 3.73239458e-01f, 7.64495209e-02f, -1.90454781e-01f, -4.54083443e-01f, -7.36708343e-01f, -2.93193966e-01f, -1.05311602e-01f, -1.36349902e-01f,
  -1.65302724e-01f, 1.04827449e-01f, -1.41373158e-01f, 1.81424282e-02f, -2.06815582e-02f, -2.03673139e-01f, 2.01837882e-01f, 4.73379344e-01f, 3.80018651e-01f, 1.74591795e-01f,
  1.73666343e-01f, 1.57534733e-01f, 4.26796407e-01f, 1.86135575e-01f, 5.07549308e-02f, -1.54717743e-01f, -1.15921954e-02f, 1.79960281e-01f, 8.63205940e-02f, 4.96517301e-01f,
  1.33853573e-02f, -1.51543409e-01f, -4.69515026e-02f, -2.90030241e-02f, 2.03061566e-01f, -3.82581784e-05f, -3.85579355e-02f, 2.47341171e-01f, 2.44142879e-02f, 7.30118603e-02f,
  8.41145590e-02f, 7.93523863e-02f, 3.70676699e-03f, 8.39389414e-02f, -9.25041884e-02f, 6.03440031e-02f, 1.75049379e-01f, 1.49846807e-01f, 1.92381591e-02f, -1.11941710e-01f,
  1.24035507e-01f, 5.88200316e-02f, -1.19588666e-01f, -3.01202089e-01f, -2.97317773e-01f, 3.36479731e-02f, -1.45915151e-01f, 1.10986546e-01f, -1.74942091e-01f, 2.55737919e-02f,
  -7.81014636e-02f, 1.50939450e-01f, 7.62370303e-02f, 8.93661156e-02f, 1.17320362e-02f, 5.61167944e-05f, 1.64001018e-01f, -1.07747437e-02f, 3.41183618e-02f, 5.31254448e-02f,
  2.08476763e-02f, -6.89596916e-03f, 4.20336686e-02f, -7.06193820e-02f, 6.14988618e-02f, 1.52480841e-01f, 4.44270633e-02f, 8.57068226e-02f, 5.87084703e-03f, 1.94337703e-02f,
  2.04389822e-02f, 3.95802874e-03f, 1.23971127e-01f, 2.00545073e-01f, -1.19766362e-01f, 4.51892503e-02f, 1.68855507e-02f, 1.25788655e-02f, 4.38354015e-02f, -1.07977375e-01f,
  -2.57203281e-01f, -1.23094060e-01f, 7.45193809e-02f, 1.27721401e-02f, 4.07347344e-02f, -2.56016869e-02f, 1.64370164e-02f, 6.07733354e-02f, -7.82614425e-02f, -4.90418524e-02f,
  -1.95119888e-01f, -1.33569598e-01f, -6.75394833e-02f, 8.07498395e-02f, -9.52262431e-02f, -1.05948381e-01f, -6.10143021e-02f, -5.47257811e-03f, -1.40444934e-01f, 2.19125718e-01f,
  1.10363565e-01f, -3.02165180e-01f, -3.65325123e-01f, -3.86658221e-01f, -3.08168024e-01f, -3.34795266e-01f, -2.46495172e-01f, -2.90847421e-01f, -5.84761918e-01f, -5.91924727e-01f,
  -1.26368225e+00f, -4.15367670e-02f, 9.57892649e-03f, -4.01458085e-01f, 2.28343070e-01f, 2.96299577e-01f, 6.58632755e-01f, 1.27403513e-01f, -1.35687247e-01f, 1.67121023e-01f,
  -3.18703771e-01f, -3.32692593e-01f, -1.74159452e-01f, -3.10252663e-02f, 9.97250676e-02f, 6.23409271e-01f, 4.75610524e-01f, -1.64660215e-01f, -4.99810325e-04f, 1.21445224e-01f,
  3.80993545e-01f, -6.32136166e-02f, -7.33421087e-01f, -2.38821536e-01f, 1.18436320e-02f, 5.12183085e-02f, 2.98100989e-02f, -2.01691464e-01f, 8.59240741e-02f, 6.63534552e-02f,
  2.22974531e-02f, -5.85964799e-01f, 1.61707386e-01f, -2.84303546e-01f, -1.27311483e-01f, -1.63749710e-01f, 7.29001686e-02f, -2.11808100e-01f, -1.75374329e-01f, -9.93041545e-02f,
  -1.78434417e-01f, -6.22931086e-02f, -2.22276095e-02f, 1.14199959e-01f, -2.14351285e-02f, -7.90851265e-02f, -1.30486205e-01f, -1.79231092e-01f, -3.16358395e-02f, -3.36805619e-02f,
  2.23744288e-01f, -9.80221629e-02f, -3.13512981e-01f, 4.25878912e-02f, -2.64145602e-02f, -1.59712404e-01f, -1.40399098e-01f, -1.81661367e-01f, -9.82293040e-02f, -1.35507599e-01f,
  6.17506243e-02f, 3.85628268e-02f, 5.29849418e-02f, 4.24966365e-02f, 2.54615303e-02f, 4.35717590e-02f, 2.68514510e-02f, -3.89021225e-02f, 3.21242064e-02f, -1.03433616e-01f,
  3.58144171e-03f, -1.60519909e-02f, -1.79160256e-02f, -8.67042989e-02f, -8.99610892e-02f, -1.15646176e-01f, 4.75256182e-02f, -2.39492096e-02f, -1.33147091e-01f, -5.39084375e-02f,
  -1.24313079e-01f, 6.07830137e-02f, 6.87738806e-02f, 6.93971291e-02f, 2.33179536e-02f, -1.30966693e-01f, 4.57725301e-03f, -7.68907368e-02f, -8.98502581e-03f, -1.71652518e-03f,
  2.00956941e-01f, -7.62802958e-02f, 1.36040419e-01f, 7.71379843e-02f, 1.07079316e-02f, -4.73722331e-02f, -1.08193330e-01f, -9.50100198e-02f, -3.76140177e-02f, 9.03146900e-03f,
  -7.84642324e-02f, -4.72587682e-02f, -3.39871482e-03f, -4.52521741e-02f, 4.67656031e-02f, -5.06934198e-03f, 3.47414166e-02f, 5.35050705e-02f, 7.89839774e-02f, 2.42392961e-02f,
  1.07978739e-01f, 8.94685388e-02f, 8.00510570e-02f, 2.10871473e-01f, 1.11574076e-01f, 2.00126112e-01f, 1.31997153e-01f, 1.62820280e-01f, 1.84601068e-01f, 3.68671536e-01f,
  -7.74689794e-01f, -6.85775101e-01f, -5.11435449e-01f, -2.56036073e-01f, -1.76672131e-01f, 4.62193303e-02f, -3.93556356e-01f, 4.56658125e-01f, 5.22744842e-02f, -7.56287396e-01f,
  -1.95059106e-01f, 8.60239863e-02f, -2.70576507e-01f, -2.11416811e-01f, -2.17595086e-01f, -6.77343607e-01f, -6.18661106e-01f, -3.24135333e-01f, 4.27583426e-01f, 4.64501411e-01f,
  -4.84260693e-02f, -1.56395197e-01f, 4.36573662e-03f, 2.30356157e-01f, -2.52224118e-01f, -1.11821800e-01f, -4.66839284e-01f, -2.89630443e-01f, -3.09522539e-01f, -9.04882312e-01f,
  -7.28728712e-01f, 2.57888669e-03f, 2.49333307e-01f, -3.26941222e-01f, -1.46246657e-01f, 9.10932198e-02f, 3.93241271e-02f, -1.46679267e-01f, 7.78772309e-02f, -1.36997074e-01f,
  -1.86812162e-01f, 2.85823923e-02f, 3.37096214e-01f, -3.29584591e-02f, 3.72754782e-03f, 6.14884980e-02f, 1.78483538e-02f, 1.06646111e-02f, -2.99197823e-01f, 4.22123373e-02f,
  -6.85389489e-02f, -1.90617517e-01f, -2.01182097e-01f, 1.54575348e-01f, 5.23487389e-01f, 3.65124308e-02f, 4.28914689e-02f, 2.49643505e-01f, 2.46046986e-02f, -7.48012900e-01f,
  -7.29903877e-02f, -7.12259812e-03f, 1.09004013e-01f, 7.48203024e-02f, 5.39392158e-02f, 1.06111139e-01f, -4.99768257e-02f, -1.36858672e-01f, 1.23334311e-01f, -7.15475082e-02f,
  3.08084991e-02f, 4.29143980e-02f, 9.43132937e-02f, -9.47854295e-02f, -1.22296726e-02f, -8.17921907e-02f, -1.25482500e-01f, -2.81506982e-02f, -8.50364640e-02f, -1.40537918e-01f,
  -4.85912114e-02f, 5.82496822e-02f, -7.13570742e-03f, 2.15896383e-01f, -7.08914176e-02f, -1.33461818e-01f, -3.64843532e-02f, 2.07404763e-01f, -2.38286052e-02f, -6.72582388e-02f,
  4.80899662e-02f, -3.64002995e-02f, -3.09934020e-01f, 1.15122892e-01f, -1.50477901e-01f, -1.49769858e-01f, -1.36255726e-01f, 2.07551435e-01f, -1.59687012e-01f, -1.50272056e-01f,
  1.65677704e-02f, 6.91830926e-03f, -1.14801988e-01f, 7.12153539e-02f, 1.03130646e-01f, 6.64245114e-02f, -7.18792453e-02f, -1.86026916e-01f, -8.32363740e-02f, 1.94108739e-01f,
  -2.10439451e-02f, -2.47290939e-01f, -3.23462784e-01f, -1.48845419e-01f, 6.53274264e-03f, -2.21304428e-02f, -1.84975445e-01f, -1.02466933e-01f, -1.58384755e-01f, -5.50585806e-01f,
  3.11314225e-01f, -1.42068595e-01f, 2.05061853e-01f, 3.06391656e-01f, -4.14205007e-02f, 5.51970378e-02f, -4.16235738e-02f, -8.94724056e-02f, 1.45105109e-01f, 2.09808797e-01f,
  2.37497136e-01f, 3.11690092e-01f, 3.58881742e-01f, 2.87704885e-01f, 3.11154962e-01f, 3.93743329e-02f, 1.01791658e-01f, 2.22537249e-01f, 2.38840133e-02f, -2.01105550e-02f,
  -3.99184451e-02f, -3.03426385e-01f, -4.53736596e-02f, 9.38293189e-02f, -4.19455916e-02f, 1.40525088e-01f, 5.77639639e-02f, -8.36302042e-02f, -7.59091675e-02f, 5.61056621e-02f,
  5.36216021e-01f, 1.80343032e-01f, 2.37148732e-01f, 6.76479712e-02f, 3.43467556e-02f, -3.36781219e-02f, -6.47083819e-02f, -3.17377150e-02f, -2.88348994e-03f, -8.95292088e-02f,
  1.13292607e-02f, -9.10448283e-03f, -2.83554524e-01f, -2.99381584e-01f, -1.20580673e-01f, -1.09610688e-02f, -6.50680289e-02f, -6.14721663e-02f, 1.25439286e-01f, 1.76630244e-01f,
  -6.67613894e-02f, -4.26445119e-02f, 3.25350910e-02f, -5.35328612e-02f, -6.85345456e-02f, 1.03325866e-01f, 2.67086346e-02f, 3.22436355e-02f, 9.57634822e-02f, 1.12274429e-02f,
  4.04529035e-01f, 2.61121869e-01f, 1.32085562e-01f, 1.53977191e-02f, -1.37319956e-02f, 7.06130862e-02f, -9.71167833e-02f, -3.55256759e-02f, -2.35826913e-02f, -2.08844379e-01f,
  -1.39043063e-01f, 1.38616532e-01f, 2.08122227e-02f, -2.01516896e-02f, 1.23803966e-01f, 4.27985117e-02f, 5.94873801e-02f, -4.76292847e-03f, -2.67687030e-02f, -1.55632198e-01f,
  -5.87400459e-02f, -5.82465455e-02f, -8.72401446e-02f, -1.14551514e-01f, -1.80779204e-01f, 1.03212886e-01f, 3.00614126e-02f, -7.65800625e-02f, -1.11866258e-01f, -1.73326060e-01f,
  -4.28298302e-02f, 2.67497182e-01f, 1.61420584e-01f, 6.02126792e-02f, -7.49530783e-03f, 9.23926383e-02f, 2.26203814e-01f, -1.32044181e-02f, 1.10604778e-01f, 1.16967507e-01f,
  4.94230650e-02f, 2.36824844e-02f, -1.62535012e-01f, -7.79700205e-02f, -1.91351101e-01f, -8.21332261e-02f, 1.24331862e-01f, 1.55916288e-01f, 2.35028297e-01f, 1.15087390e-01f,
  -4.80132643e-03f, 1.06807120e-01f, 1.62765056e-01f, 6.93422556e-02f, 1.16667122e-01f, 1.81352392e-01f, -6.96401298e-02f, 7.04938695e-02f, -2.44798865e-02f, -1.14249423e-01f,
  3.62072848e-02f, 6.13792777e-01f, -1.08440816e-02f, -1.42389998e-01f, 1.73844218e-01f, 2.35286415e-01f, 5.71060479e-01f, 2.63079107e-01f, 1.60326734e-02f, 3.73479605e-01f,
  1.38298601e-01f, -3.94855231e-01f, -2.14034587e-01f, -2.65530825e-01f, -1.10992230e-01f, 1.23171031e-01f, -1.50499299e-01f, -3.98606956e-01f, -3.82259518e-01f, -6.71749488e-02f,
  -2.33503342e-01f, -1.13843873e-01f, -1.07274577e-01f, -2.35363916e-01f, -1.71602741e-01f, -3.76024723e-01f, 2.28842851e-02f, 5.11451624e-02f, -4.79335524e-03f, -3.53184193e-01f,
  -3.26099336e-01f, 1.28397509e-01f, -2.55647749e-01f, -1.31638097e-02f, 1.35426432e-01f, 4.61919121e-02f, -6.62053674e-02f, 5.05548110e-03f, 1.84269294e-01f, -6.60160705e-02f,
  -5.43436443e-04f, 7.92305991e-02f, 5.47765195e-02f, 1.26152650e-01f, 1.21859841e-01f, 1.62002847e-01f, 1.52437285e-01f, 6.20371476e-02f, -6.35022447e-02f, 2.65208725e-02f,
  1.04721515e-02f, 1.91544756e-01f, 2.03541547e-01f, 1.99331477e-01f, 1.00128345e-01f, -5.86738847e-02f, 1.68041080e-01f, 6.04831986e-02f, 8.54816660e-02f, 1.34933323e-01f,
  -1.54432938e-01f, 4.83380817e-02f, 5.65727465e-02f, 3.52659039e-02f, 1.22109972e-01f, 1.00013994e-01f, -2.42788941e-02f, 1.26699761e-01f, 4.77238074e-02f, 1.06282189e-01f,
  1.34266213e-01f, -6.28642067e-02f, 9.40058529e-02f, -4.12132144e-02f, -6.28492534e-02f, 7.16933887e-03f, 6.13137558e-02f, 6.01084754e-02f, 4.32634354e-02f, 6.57277182e-02f,
  -2.52178460e-02f, 5.45696132e-02f, -6.13629520e-02f, 5.32355346e-02f, 3.61985750e-02f, 6.92133680e-02f, -1.69180304e-01f, -6.80044517e-02f, -1.50887556e-02f, -1.56388059e-01f,
  -7.61521608e-02f, -6.37415349e-02f, -2.79581189e-01f, -1.12085424e-01f, 5.12884893e-02f, 4.30231318e-02f, -1.61661014e-01f, -1.30841881e-01f, -2.69398298e-02f, 3.79670523e-02f,
  -1.84838064e-02f, -2.45624911e-02f, -3.17420135e-03f, 6.50669485e-02f, 1.87706929e-02f, -1.06724240e-01f, 2.12747440e-01f, -7.26838857e-02f, -1.08354144e-01f, 4.26512212e-03f,
  1.65983751e-01f, 1.70297876e-01f, -6.43878281e-02f, 3.41603272e-02f, -1.37142614e-01f, -1.95643857e-01f, 5.67121282e-02f, 5.62387332e-02f, 9.12648812e-02f, 2.96354443e-01f,
  -1.73395380e-01f, -3.88009816e-01f, -6.49156630e-01f, -4.76982862e-01f, -2.95680314e-01f, 3.32405344e-02f, 1.49804512e-02f, 1.93708509e-01f, -8.33415687e-02f, -2.55387664e-01f,
  -3.88364457e-02f, 1.15338005e-01f, -2.55034119e-01f, 1.60901338e-01f, 4.15644079e-01f, -1.53016686e-01f, -1.40519768e-01f, 4.87284400e-02f, 4.67445731e-01f, 3.50893289e-01f,
  2.35624537e-01f, -5.30567281e-02f, 2.35704154e-01f, 2.45905057e-01f, -4.36352402e-01f, -1.18476413e-01f, -4.72502023e-01f, -2.23589957e-01f, -3.83370109e-02f, -7.73315966e-01f,
  -5.71954310e-01f, -6.08044624e-01f, 7.89957941e-02f, 2.81406760e-01f, -2.31830940e-01f, 9.99382660e-02f, -2.80182287e-02f, -3.66320521e-01f, -2.95292567e-02f, -5.73328175e-02f,
  -1.90622166e-01f, 1.98556371e-02f, -2.26646557e-01f, -3.35745811e-02f, -1.14245631e-01f, 1.76167600e-02f, -1.15062885e-01f, 5.01391478e-02f, -8.73048306e-02f, -8.84697512e-02f,
  9.87694710e-02f, 6.52676299e-02f, -1.70579821e-01f, 1.42619237e-01f, 6.61703870e-02f, 6.82476386e-02f, -3.39600667e-02f, 2.93212943e-02f, 1.25350609e-01f, -3.15553993e-01f,
  2.06478104e-01f, -9.10971016e-02f, -8.53152350e-02f, 6.78728148e-02f, 6.46611601e-02f, -5.33871278e-02f, -1.87212788e-02f, 1.00296199e-01f, 6.87052310e-02f, -8.01543072e-02f,
  3.89903747e-02f, -1.12104066e-01f, 8.36766697e-03f, -1.05378166e-01f, 9.61192325e-03f, -1.20665386e-01f, 3.86316143e-02f, 6.56148493e-02f, -4.33129445e-02f, 9.18774083e-02f,
  1.42304331e-01f, -5.44877583e-03f, -9.33500677e-02f, 2.00774595e-01f, 3.51245888e-02f, 1.61436740e-02f, -1.07829213e-01f, 1.43562019e-01f, -2.16376912e-02f, 4.66754027e-02f,
  -2.05479786e-01f, 5.50552964e-01f, -2.91955292e-01f, 1.47221591e-02f, -1.47986859e-01f, 3.54698412e-02f, -9.73923132e-02f, 1.31221488e-01f, 2.34148707e-02f, 8.31275210e-02f,
  2.03580055e-02f, -8.23560730e-02f, -2.36004889e-01f, -4.69930610e-03f, -1.18941367e-02f, 6.57128990e-02f, 2.17876658e-01f, 3.36069171e-03f, 1.94613069e-01f, -2.94329114e-02f,
  1.31284326e-01f, 2.15409338e-01f, 8.63030925e-02f, 3.58778574e-02f, 1.45163536e-02f, 1.79073691e-01f, -1.97658300e-01f, -9.31329951e-02f, 1.86668888e-01f, 1.46450654e-01f,
  -7.27000594e-01f, -1.17231230e-03f, 3.23549747e-01f, -2.62317676e-02f, 1.09933712e-01f, -3.30030590e-01f, -7.83443451e-01f, -5.43753326e-01f, -1.09814614e-01f, -6.59118444e-02f,
  1.66509420e-01f, 3.61984879e-01f, 2.93178141e-01f, -9.92191732e-02f, -8.36152136e-01f, -6.17416143e-01f, -2.72410065e-01f, -4.22620535e-01f, -5.49558342e-01f, -4.67356324e-01f,
  -1.64686203e-01f, -2.39940122e-01f, -3.94481510e-01f, -2.91909695e-01f, 3.52023125e-01f, 2.48145267e-01f, 3.22792381e-01f, 2.04782963e-01f, 1.42724171e-01f, 4.03692096e-01f,
  3.01366687e-01f, 6.52422011e-02f, -1.32995561e-01f, -1.97268277e-01f, 4.23033059e-01f, 2.16505304e-02f, -1.91742793e-01f, -1.07965022e-01f, 8.01837891e-02f, -5.14444970e-02f,
  2.73583710e-01f, -3.93362194e-02f, 1.90272495e-01f, 1.97916597e-01f, -1.95332244e-01f, -4.47418839e-02f, 4.13942523e-03f, -1.01235472e-01f, 5.05803414e-02f, 1.72719061e-01f,
  1.76208600e-01f, 7.49111101e-02f, 1.96901888e-01f, -2.50251219e-02f, -1.45587072e-01f, 2.44168505e-01f, 2.34749526e-01f, 8.62842202e-02f, -6.04976900e-03f, -8.04505311e-04f,
  5.14353253e-03f, -1.70261636e-02f, 6.09182240e-03f, -4.53239307e-02f, 1.92265324e-02f, 1.42099366e-01f, 7.46147940e-03f, -3.26770768e-02f, -1.21288851e-01f, 1.11529017e-02f,
  -9.04785586e-04f, 9.00058150e-02f, -4.49485220e-02f, 7.63131306e-02f, 3.48048322e-02f, 4.63475659e-02f, -5.51869161e-02f, -1.28418738e-02f, -1.63713079e-02f, 2.66065504e-02f,
  -8.49211216e-02f, -8.28060228e-03f, 2.34363779e-01f, -1.78494975e-02f, 9.31564420e-02f, -9.59221870e-02f, 6.69785663e-02f, 1.52840419e-02f, 6.97731152e-02f, -2.16915365e-02f,
  1.61379606e-01f, -1.82635292e-01f, -4.52896357e-02f, -1.92986742e-01f, -3.61291654e-02f, 2.47680709e-01f, 3.76755923e-01f, -1.01825073e-01f, 1.40545622e-01f, -8.08459073e-02f,
  -1.50957227e-01f, -7.52220005e-02f, 1.10402882e-01f, 3.73013392e-02f, -1.50317565e-01f, -7.67898858e-02f, -1.75339833e-01f, 7.24345446e-03f, -9.70025584e-02f, 3.76536310e-01f,
  -1.03488550e-01f, -2.05688968e-01f, -2.12492600e-01f, 6.30372316e-02f, 1.11521825e-01f, -1.16262129e-02f, 2.50835717e-01f, 3.11825752e-01f, -1.52166784e-01f, -1.06634110e-01f,
  -3.70071352e-01f, 2.51882523e-01f, -3.86584193e-01f, 2.03074589e-01f, 7.38143146e-01f, -6.12021610e-02f, -2.72028446e-01f, -4.92185026e-01f, 9.89249721e-02f, 1.22779801e-01f,
  3.32811534e-01f, 4.38998848e-01f, 3.48115236e-01f, 1.81938723e-01f, -5.11374950e-01f, 1.02314819e-02f, 3.82582039e-01f, -2.53024310e-01f, -6.63652718e-01f, -2.74325192e-01f,
  4.21390712e-01f, 2.18691528e-02f, -4.58775789e-01f, -2.42311060e-01f, 2.75237352e-01f, 2.50884444e-01f, 9.11952853e-02f, 1.69744909e-01f, 1.48367658e-01f, 5.04830301e-01f,
  -1.92136139e-01f, -2.15271458e-01f, 5.49133122e-02f, 4.14191097e-01f, 5.51368780e-02f, -1.84761569e-01f, -3.41923207e-01f, -5.09906709e-02f, -1.66613865e-03f, -1.71026453e-01f,
  2.27261767e-01f, -2.29046717e-01f, 2.85831094e-01f, 1.46296233e-01f, -5.60998805e-02f, -2.80180931e-01f, -7.87917450e-02f, -3.11653376e-01f, -4.82290626e-01f, -4.86445308e-01f,
  5.26235342e-01f, 4.09652829e-01f, -2.51038611e-01f, -1.15731992e-01f, -2.44578049e-01f, 1.67332396e-01f, -3.49133849e-01f, -4.53485757e-01f, -7.32586324e-01f, -3.35535377e-01f,
  2.05162037e-02f, -7.47073442e-02f, 4.57622707e-02f, 3.78618129e-02f, 3.21949297e-03f, 1.30837440e-01f, 9.40885618e-02f, 1.95866349e-04f, 6.12138435e-02f, -1.67726018e-02f,
  -5.43289445e-02f, -1.28196791e-01f, -1.82774261e-01f, -4.21113074e-02f, 3.54372598e-02f, -9.64121222e-02f, -6.43023551e-02f, -3.33612524e-02f, -4.82576415e-02f, -3.48045789e-02f,
  -4.24288064e-02f, -1.23532396e-02f, 7.56223202e-02f, -1.87894791e-01f, 7.90403187e-02f, -6.07072338e-02f, -2.27308292e-02f, 2.38631992e-03f, -3.81272174e-02f, 6.61137924e-02f,
  -3.06841791e-01f, 2.49949023e-01f, 5.35076782e-02f, -1.20796107e-01f, -3.00446507e-02f, -3.73393781e-02f, -3.90149541e-02f, 3.83193046e-02f, -1.25748351e-01f, -2.68762916e-01f,
  -1.08697608e-01f, -1.33566275e-01f, 1.08821101e-01f, -1.34960204e-01f, -2.17114110e-02f, 8.47627372e-02f, 2.18413904e-01f, 9.51221585e-02f, -1.35505736e-01f, 3.89387123e-02f,
  1.42511055e-01f, -2.22720474e-01f, -1.62508011e-01f, -6.48540780e-02f, 1.58019871e-01f, -1.44297332e-02f, -2.26409182e-01f, -2.40179077e-02f, -3.42261195e-01f, -3.59449297e-01f,
  -6.55804873e-01f, 3.94464254e-01f, 1.95480019e-01f, -5.84973156e-01f, 4.97330844e-01f, 3.99135441e-01f, 4.41076308e-01f, -4.05809209e-02f, -4.16963875e-01f, 6.92821443e-02f,
  6.34760737e-01f, 1.00115137e-02f, -1.23021886e-01f, -3.55938263e-02f, -2.34903753e-01f, -1.52944047e-02f, -3.21590304e-01f, -5.28386354e-01f, -4.62629497e-01f, 5.67516312e-02f,
  1.95016563e-01f, -2.68648356e-01f, -6.09126389e-01f, -3.02743763e-01f, -1.37644991e-01f, -2.69290388e-01f, -1.50788622e-02f, -1.77045494e-01f, 2.66907990e-01f, 1.57516554e-01f,
  2.23578617e-01f, 2.18533173e-01f, 6.26280755e-02f, -6.76982328e-02f, 7.06064850e-02f, -1.93775669e-01f, 5.25475740e-02f, 8.63788836e-03f, 1.21438347e-01f, -7.00421035e-02f,
  1.90768406e-01f, 1.41222104e-01f, 3.18245478e-02f, -2.80415751e-02f, -1.12420850e-01f, -1.17510058e-01f, -2.73309678e-01f, -2.27206618e-01f, -1.72516316e-01f, 5.11833951e-02f,
  2.47824624e-01f, 3.63366306e-01f, -7.01462254e-02f, 5.98157682e-02f, -1.12710670e-01f, -3.85443196e-02f, 9.54201743e-02f, -2.12206557e-01f, -6.34911656e-02f, -4.07091796e-01f,
  -8.46690126e-03f, 2.17038393e-02f, 2.83903211e-01f, -3.50980051e-02f, -7.93771073e-02f, -5.40698739e-03f, -2.19608080e-02f, 1.45460782e-03f, 2.94903899e-03f, -1.90857247e-01f,
  4.83604521e-02f, 2.27013364e-01f, -6.02519177e-02f, 1.58473074e-01f, -1.00338861e-01f, 6.22564964e-02f, -6.93818228e-03f, -5.24357967e-02f, -3.52884969e-03f, -7.95262903e-02f,
  -9.41847116e-02f, 1.11773787e-02f, -3.34062949e-02f, -2.45327547e-01f, 1.23185419e-01f, -8.36159661e-02f, 7.17429519e-02f, 6.41597658e-02f, -1.31490484e-01f, 7.15355054e-02f,
  -7.40700006e-01f, 2.25801945e-01f, -2.57978439e-01f, -1.71393856e-01f, 2.61692163e-02f, -1.07637100e-01f, 1.24569148e-01f, 9.85463262e-02f, 9.71088633e-02f, -1.67155370e-01f,
  1.88526750e-01f, 1.64947249e-02f, -8.02198350e-02f, -5.74869327e-02f, -7.48694539e-02f, -9.00060841e-05f, -8.28567147e-02f, -2.28202697e-02f, -3.19329798e-02f, 2.32062303e-02f,
  -3.05462629e-01f, -4.91749853e-01f, -2.96611309e-01f, -2.05917463e-01f, -2.43907377e-01f, -4.23424393e-01f, -1.70677304e-01f, -3.16206127e-01f, -2.00327590e-01f, -7.27470875e-01f,
  3.02498013e-01f, 2.68666834e-01f, -1.01729655e+00f, 1.05420657e-01f, -4.83858317e-01f, -4.13236469e-01f, 9.10068676e-03f, 2.01034576e-01f, 1.66386470e-01f, 9.53150168e-02f,
  1.39920846e-01f, 2.82612324e-01f, 3.66441905e-01f, -3.84312160e-02f, -7.37861395e-02f, -3.21366847e-01f, -4.56729710e-01f, -4.66141850e-01f, -3.40436578e-01f, -1.88779429e-01f,
  -9.60181095e-03f, -1.59926638e-02f, -7.26299956e-02f, -4.17860262e-02f, 2.00499967e-02f, 1.55826375e-01f, 2.42417529e-02f, -2.70703882e-01f, -3.98536026e-01f, -3.87631804e-01f,
  -1.89061329e-01f, -2.17658848e-01f, -8.87811631e-02f, 5.00520021e-02f, -5.54780141e-02f, 3.44985351e-02f, -5.17555699e-03f, 6.71444461e-02f, 1.30800396e-01f, 7.25852847e-02f,
  -7.12370649e-02f, -2.13307701e-02f, 3.68038975e-02f, -5.37546352e-02f, -5.46207801e-02f, -5.12698926e-02f, 3.11958678e-02f, -7.45700523e-02f, 5.22346608e-02f, 3.47365513e-02f,
  4.20667492e-02f, -1.78741559e-01f, 2.94996221e-02f, 1.65216327e-01f, -1.05849937e-01f, -3.99421453e-02f, 6.80020005e-02f, -1.71168000e-01f, -1.58521265e-01f, 1.29844412e-01f,
  -1.27062917e-01f, 1.47662386e-01f, 7.51791820e-02f, 1.51600078e-01f, 1.66510373e-01f, 2.53981382e-01f, 5.79892583e-02f, 2.57374108e-01f, 1.06259584e-01f, 1.24591589e-01f,
  1.51026160e-01f, -1.75258219e-01f, 4.19727266e-02f, 5.42973205e-02f, -1.15503281e-01f, -4.55038808e-02f, -6.61460608e-02f, 2.34222449e-02f, -1.25417113e-01f, 1.55812642e-02f,
  -4.62070405e-02f, 1.31996544e-02f, -7.76817203e-02f, -6.27948865e-02f, -2.69478619e-01f, -1.01528510e-01f, -2.11293042e-01f, -6.26933649e-02f, 8.34871754e-02f, -9.28027555e-02f,
  5.20210624e-01f, -3.98425609e-01f, 1.75422326e-01f, 5.59189469e-02f, -1.62112564e-01f, -1.22688096e-02f, -1.03368655e-01f, -1.59845084e-01f, -2.54743136e-02f, -5.32491580e-02f,
  -1.81193978e-01f, -3.94321755e-02f, -1.64572289e-03f, 1.46372676e-01f, 6.38942942e-02f, -8.89402330e-02f, 5.02867028e-02f, 1.00517288e-01f, -4.48693372e-02f, -7.92149827e-02f,
  9.54156891e-02f, 1.54140919e-01f, 3.40704650e-01f, 2.18648762e-01f, 1.24509752e-01f, 1.16383165e-01f, 2.04055965e-01f, 1.07981987e-01f, -8.23676959e-02f, 4.20029789e-01f,
  -1.85654029e-01f, 3.82884413e-01f, -2.19940096e-01f, 1.88466638e-01f, -1.82218626e-01f, -4.45350796e-01f, -2.95262001e-02f, 1.51402444e-01f, 1.84167892e-01f, 4.40462977e-01f,
  8.56021866e-02f, -4.42941397e-01f, -1.18629210e-01f, -4.03792024e-01f, -5.46467900e-01f, 1.66566610e-01f, -9.18044597e-02f, -4.55939323e-01f, -9.90392685e-01f, -6.74698651e-01f,
  -3.34493369e-01f, -1.72470406e-01f, -3.12995255e-01f, -2.48470485e-01f, 3.60292852e-01f, -1.38751224e-01f, 2.74561942e-01f, -1.47810861e-01f, -2.03984857e-01f, 1.44197002e-01f,
  -6.45648763e-02f, -1.46883041e-01f, -3.04928601e-01f, -7.40803108e-02f, 2.74908125e-01f, 5.05625643e-02f, -2.73517162e-01f, 7.42058232e-02f, 6.69645146e-02f, -1.21757440e-01f,
  -2.55299080e-02f, -3.58273357e-01f, -4.43821341e-01f, -1.19456854e-02f, -1.09282561e-01f, -1.13343194e-01f, -1.67350359e-02f, -4.43886817e-01f, -2.53717363e-01f, 6.83577061e-02f,
  -3.33655238e-01f, -4.73377615e-01f, -3.68850708e-01f, -1.45247012e-01f, -3.23919237e-01f, -3.98348123e-01f, -1.63367525e-01f, -3.34555119e-01f, -4.27191287e-01f, 4.24974680e-01f,
  1.99529424e-01f, 5.94021194e-02f, -7.51678273e-02f, 1.48239788e-02f, 6.28995672e-02f, -3.36683020e-02f, -1.02452204e-01f, -9.19254422e-02f, -1.22065105e-01f, -6.12177551e-02f,
  -1.30261138e-01f, 1.69632792e-01f, 2.30043307e-02f, 8.01660120e-02f, 1.31349623e-01f, -1.30511642e-01f, 6.25336394e-02f, -4.00197804e-02f, 9.92422849e-02f, -5.59518971e-02f,
  -1.07812636e-01f, -7.05165714e-02f, 7.42916092e-02f, 3.67589965e-02f, 4.30709682e-04f, 8.02672580e-02f, 2.14453842e-02f, -1.05379246e-01f, 2.51148902e-02f, 3.93297859e-02f,
  2.04253867e-01f, -4.04638797e-01f, 4.43664551e-01f, -8.85351226e-02f, -1.63583271e-02f, 6.91386312e-02f, 1.77288994e-01f, 2.72206694e-01f, 1.23266600e-01f, 1.40492544e-01f,
  -2.83353269e-01f, 2.17974946e-01f, 1.69552594e-01f, 1.21163465e-01f, -6.81583807e-02f, 2.59017628e-02f, 1.33356392e-01f, -1.60525396e-01f, -1.86003432e-01f, 2.54482865e-01f,
  3.15327764e-01f, 6.00282773e-02f, -1.55874481e-02f, 9.44068953e-02f, -8.67806375e-02f, -1.75655112e-01f, 6.35485202e-02f, 1.56196222e-01f, -1.74446836e-01f, 5.91245115e-01f,
  7.89762139e-01f, 3.60577554e-01f, 5.79925776e-02f, 1.95961207e-01f, 1.78912878e-01f, 3.26474935e-01f, 5.18234491e-01f, 2.10482866e-01f, 5.88567629e-02f, 3.07807773e-01f,
  3.64351034e-01f, 1.53234765e-01f, 1.48175821e-01f, -5.55435754e-02f, 1.55137762e-01f, -2.28323881e-02f, -5.05263843e-02f, -1.69728935e-01f, -2.32664328e-02f, 2.13686913e-01f,
  1.22484550e-01f, 2.55060405e-01f, 2.36352682e-01f, 6.25481308e-02f, -1.82803515e-02f, -3.01415399e-02f, 1.19706407e-01f, 1.74887165e-01f, 1.41432568e-01f, -2.90021062e-01f,
  -2.65354186e-01f, 4.64120090e-01f, -1.73653603e-01f, -3.77208255e-02f, -5.72107099e-02f, 2.58401744e-02f, 4.58576940e-02f, -5.92434108e-02f, -1.53711345e-02f, -7.59191290e-02f,
  -9.52833146e-02f, 7.20637366e-02f, 7.23623112e-02f, 8.20944160e-02f, -2.73207966e-02f, 7.23820254e-02f, 5.09207807e-02f, -1.09915622e-01f, -5.69499247e-02f, -8.02352875e-02f,
  -9.50573161e-02f, -1.24949338e-02f, 1.68732945e-02f, 1.00593769e-03f, -7.04982504e-02f, -9.84372720e-02f, 2.84832194e-02f, -1.80995204e-02f, 4.82639037e-02f, -8.61910954e-02f,
  -1.71270669e-01f, 7.52192398e-04f, 3.02635152e-02f, 5.82909510e-02f, 1.66017145e-01f, -8.55681822e-02f, -5.19431457e-02f, 5.64425439e-02f, 8.75462219e-03f, 2.06803188e-01f,
  -7.66168684e-02f, -1.12971589e-02f, -6.91007674e-02f, -2.95338556e-02f, -7.25598261e-02f, -2.31749993e-02f, -1.08952865e-01f, -1.35728687e-01f, 7.28317872e-02f, -7.70349428e-03f,
  -2.85200626e-02f, -6.93000555e-02f, 1.21986344e-01f, 1.97568722e-02f, 2.14509014e-02f, -6.61499575e-02f, -6.81326240e-02f, 1.43543512e-01f, 7.79692754e-02f, 1.38249084e-01f,
  -2.92585641e-01f, 4.59523708e-01f, -9.71524231e-03f, -6.59370720e-02f, -2.53456309e-02f, -5.64330854e-02f, 1.78141236e-01f, -1.45520821e-01f, -1.43529043e-01f, -3.13981026e-01f,
  -3.46053578e-02f, -1.04595110e-01f, 1.73823923e-01f, 5.75557835e-02f, -1.00080460e-01f, -6.03341684e-02f, 4.56899367e-02f, -1.03017278e-01f, -1.57286510e-01f, -1.54966965e-01f,
  -5.46344556e-02f, -1.40642300e-01f, -3.24139893e-01f, -1.45128384e-01f, -1.07453339e-01f, -1.06641345e-01f, -8.66094157e-02f, -1.09703280e-01f, -1.03491515e-01f, -7.80988559e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.23600173e-01f, 5.85386217e-01f, 5.56106508e-01f, 7.40138769e-01f, 2.10292205e-01f, -1.47768617e-01f, 4.79703158e-01f, 6.60666227e-01f, 6.15687490e-01f, 1.63916469e-01f,
  4.97178048e-01f, 7.68743753e-01f, 5.75429559e-01f, 8.93361628e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  7.08469842e-03f, 1.41991097e-02f, 4.13187817e-02f, -1.17946297e-01f, -4.46226373e-02f, -7.17333183e-02f, 1.08966365e-01f, -7.85944760e-02f, -7.51634091e-02f, -1.40044361e-01f,
  -4.38522786e-01f, -3.49324524e-01f, 2.51894891e-01f, -1.02599658e-01f, -1.88421473e-01f, 5.80177307e-02f, 5.96440472e-02f, -5.64706186e-03f, 1.73562825e-01f, 2.96318203e-01f,
  1.41487690e-02f, -1.98987145e-02f, -2.23527580e-01f, 1.14512928e-01f, 1.90815762e-01f, -3.76126289e-01f, 1.65885508e-01f, 3.05215061e-01f, 2.77669251e-01f, -3.71103138e-01f,
  2.05783665e-01f, -1.20159186e-01f, 3.30156460e-02f, -2.40535870e-01f, -1.36757657e-01f, -5.30242547e-02f, 9.18090343e-02f, -2.18219310e-01f, -5.72794005e-02f, -2.15487123e-01f,
  7.24333301e-02f, 2.53480375e-01f, 2.25421160e-01f, 4.36974823e-01f, -1.77117884e-01f, 1.44748509e-01f, 3.04444164e-01f, -1.97531253e-01f, -5.09916723e-01f, -1.79001078e-01f,
  -2.59788930e-01f, -2.00702891e-01f, 4.10798728e-01f, -6.42936110e-01f, 1.65408701e-01f, 1.05545059e-01f, -3.78362626e-01f, 2.82101631e-01f, -1.44751696e-02f, 1.03143476e-01f,
  -1.14842862e-01f, 1.14254318e-02f, -2.76998043e-01f, -7.28705078e-02f, -7.71386325e-02f, -2.26378381e-01f, 4.79374528e-02f, 5.14131561e-02f, -1.21402524e-01f, 8.30892995e-02f,
  1.07101880e-01f, -7.21059740e-02f, 1.42400309e-01f, 2.82781512e-01f, -8.82488117e-02f, -2.37003192e-01f, 1.14002295e-01f, 1.64109524e-02f, 7.83116594e-02f, -4.24397029e-02f,
  -1.76391438e-01f, -3.43701839e-02f, 1.32191647e-02f, 7.04587325e-02f, 4.20979708e-01f, -4.77751464e-01f, 2.67892122e-01f, 1.76852822e-01f, -1.77343026e-01f, -8.86540562e-02f,
  4.50340778e-01f, 9.71614048e-02f, 5.25370538e-02f, -1.08142719e-01f, -2.70177454e-01f, -3.79137933e-01f, -9.72539634e-02f, -2.04876050e-01f, -2.40601167e-01f, -3.93703543e-02f,
  -1.58544540e-01f, -9.78055689e-03f, 1.03976037e-02f, -2.87431628e-02f, -1.41355902e-01f, -8.82748421e-03f, -1.12992190e-01f, -1.07795902e-01f, 1.06767923e-01f, 8.07913952e-03f,
  -2.25999430e-02f, 8.80994126e-02f, -2.00259715e-01f, 1.57796308e-01f, -1.40525833e-01f, 2.47498244e-01f, -3.95619199e-02f, 1.43680573e-01f, -1.01937000e-02f, -6.09598355e-03f,
  -1.97120935e-01f, 1.82750225e-01f, -5.73091023e-02f, 3.20380390e-01f, 2.09604442e-01f, -2.18232825e-01f, -4.20886010e-01f, 1.28519610e-02f, -4.73480718e-03f, -6.94751367e-02f,
  -1.66248187e-01f, 3.67503874e-02f, -9.69499536e-03f, -1.26522072e-02f, -2.19005975e-03f, 5.54966852e-02f, -1.70094017e-02f, 2.95606488e-03f, 2.75186300e-01f, 3.25411439e-01f,
  7.99754411e-02f, 4.43884507e-02f, 2.22427666e-01f, -1.65058181e-01f, -1.44977290e-02f, -4.94809039e-02f, 2.93145608e-02f, 9.89009291e-02f, 3.44269276e-01f, 1.19815797e-01f,
  3.62948515e-02f, 2.19207302e-01f, -2.24705830e-01f, 1.40376523e-01f, -5.09886928e-02f, -4.42636572e-02f, -3.54671389e-01f, -8.88170451e-02f, -2.75268465e-01f, -3.62866431e-01f,
  -1.57904655e-01f, 2.95945746e-03f, 3.93366404e-02f, -2.45030031e-01f, -1.83148190e-01f, 4.74238023e-02f, 4.86580953e-02f, 6.05762713e-02f, 8.11899677e-02f, -2.60951985e-02f,
  -5.94488271e-02f, -1.74009398e-01f, 8.80833492e-02f, -4.98548299e-02f, 3.99486646e-02f, 7.71668777e-02f, 7.11120963e-02f, 3.06574162e-02f, 2.77438581e-01f, -4.39498574e-03f,
  -1.09599195e-01f, 4.31622297e-01f, 3.56876254e-01f, -5.03630862e-02f, -2.19788209e-01f, -2.39224538e-01f, 7.13155046e-02f, -3.61252695e-01f, -7.64892399e-02f, -1.79182552e-02f,
  -2.07729816e-01f, -3.12850207e-01f, 2.82252841e-02f, 2.01325804e-01f, 2.98161283e-02f, 9.87884179e-02f, 1.19243510e-01f, 2.96515878e-02f, 8.38532150e-02f, 6.82190955e-02f,
  -4.04346436e-02f, -8.21332932e-02f, -7.65049383e-02f, -2.58434385e-01f, 2.47192383e-03f, -9.95034575e-02f, 6.14742637e-02f, -5.78952208e-02f, 4.21852887e-01f, -1.80126633e-02f,
  -1.91375956e-01f, -1.11795120e-01f, 1.60784960e-01f, 2.13155597e-01f, -1.58262014e-01f, -2.22446725e-01f, 1.84026495e-01f, 3.69488262e-02f, -1.36374041e-01f, -7.69325048e-02f,
  3.99650902e-01f, -3.12424302e-01f, -5.01577556e-02f, 1.70560151e-01f, 3.75874676e-02f, 1.61904112e-01f, -2.05035247e-02f, 1.13499247e-01f, -1.42573401e-01f, 3.79921794e-02f,
  7.46412501e-02f, 4.97728772e-02f, -2.99102198e-02f, 2.05688011e-02f, -2.15427279e-02f, -2.57746786e-01f, -2.13297387e-03f, 4.93913777e-02f, -1.40260041e-01f, -1.24102004e-01f,
  -1.17242739e-01f, 7.17646182e-02f, 1.16542511e-01f, 1.39762342e-01f, -1.92122951e-01f, 3.97532135e-01f, -2.98152834e-01f, 2.18755662e-01f, 3.03226672e-02f, -3.48559469e-01f,
  7.98978135e-02f, 3.69098037e-01f, 3.72116387e-01f, -1.23553492e-01f, 7.70006478e-02f, 3.30076143e-02f, 5.35492711e-02f, 1.14043958e-01f, -4.37802225e-02f, -1.91211700e-02f,
  -1.34715363e-01f, 8.90405327e-02f, 4.04272601e-02f, -6.08929843e-02f, 4.43820879e-02f, -2.72572249e-01f, -1.08446173e-01f, -2.84886044e-02f, 9.06398594e-02f, 1.92948565e-01f,
  5.32399938e-02f, -6.85141794e-03f, 7.94670582e-02f, 1.96599782e-01f, 2.39746466e-01f, -3.65805417e-01f, -4.12967741e-01f, 3.27285528e-01f, 1.64053425e-01f, -2.88930144e-02f,
  -1.20439261e-01f, 2.60536939e-01f, -7.82242045e-02f, -1.34153098e-01f, -5.98522946e-02f, 1.89229265e-01f, 2.06779853e-01f, 7.10308179e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.01903952e-02f, 6.16461635e-01f, 5.55747747e-01f, 3.13228488e-01f, 3.39041799e-01f, 4.03714716e-01f, -7.33681470e-02f, 1.57251388e-01f, 1.35783628e-01f, -4.73870784e-01f,
  -5.32618575e-02f, -3.90654087e-01f, -1.80457383e-01f, 1.38133094e-01f, -3.16308498e-01f, 2.09925756e-01f, 5.65172553e-01f, 2.99480259e-01f, -2.14248478e-01f, 6.45236894e-02f,
  -9.53468442e-01f, 1.05871904e+00f, -4.83954370e-01f, -4.90455419e-01f, 6.92404687e-01f, -2.42255237e-02f, -1.08742543e-01f, 5.42197563e-02f, 5.36947608e-01f, 2.48068735e-01f,
  4.86459970e-01f, 5.37504017e-01f, 2.04593346e-01f, 2.21105233e-01f, 3.07325497e-02f, 2.07381114e-01f, 1.63944736e-01f, 2.68063486e-01f, 1.52952671e-01f, 1.63000792e-01f,
  -3.33309248e-02f, -3.94304916e-02f, 3.75825435e-01f, 6.89435720e-01f, 4.28729504e-02f, 4.06025946e-01f, 1.77761301e-01f, 1.08587228e-01f, -7.16442645e-01f, -1.06317475e-01f,
  2.42177531e-01f, 5.29155314e-01f, -7.10360527e-01f, 5.74895144e-01f, 3.05590201e-02f, -1.85840979e-01f, -3.19473147e-01f, 5.17679870e-01f, -1.44497439e-01f, 6.51635379e-02f,
  -9.07093287e-01f, 6.03339493e-01f, 2.64915854e-01f, 5.72677195e-01f, 5.26743531e-02f, 2.57492155e-01f, 3.06559145e-03f, 1.55761868e-01f, 1.20543510e-01f, 3.98447275e-01f,
  1.97074160e-01f, 3.97312790e-02f, 6.51497692e-02f, 1.70477498e-02f, -2.32020736e-01f, -4.77608323e-01f, -1.07651249e-01f, 5.84125407e-02f, -4.65591967e-01f, 8.53342488e-02f,
  -3.23337585e-01f, 4.02593642e-01f, -5.22563607e-02f, -4.46229398e-01f, 2.95793060e-02f, 5.40750921e-01f, -2.46280655e-02f, -1.93057835e-01f, 3.96108717e-01f, 1.71703368e-01f,
  3.45254004e-01f, 7.00191915e-01f, 5.93056381e-01f, 9.01025906e-02f, 4.30314720e-01f, -4.96724285e-02f, 1.11143440e-02f, 2.62098491e-01f, 1.67344734e-02f, 9.83756781e-02f,
  3.11408252e-01f, -1.34233415e-01f, -1.10942118e-01f, 2.03136012e-01f, 8.81310925e-02f, 1.78343430e-01f, 3.52219015e-01f, 5.18845022e-01f, -1.43822998e-01f, -1.76186159e-01f,
  3.60413373e-01f, -2.02372074e-01f, 6.14290476e-01f, -1.84871793e-01f, 3.97225559e-01f, 6.59599006e-01f, -1.51115935e-02f, 1.22881186e+00f, 8.99925292e-01f, -4.49673049e-02f,
  7.57474452e-02f, 7.09087372e-01f, 1.41690359e-01f, 4.10138100e-01f, -1.83474703e-03f, 5.26718915e-01f, 4.17323589e-01f, -4.17843610e-01f, 1.87094167e-01f, 3.05480301e-01f,
  1.84011720e-02f, 5.02098687e-02f, 3.15600544e-01f, 8.64403602e-03f, 7.96370134e-02f, 1.15629248e-01f, 2.80814737e-01f, 3.79374385e-01f, 5.81165135e-01f, -1.64043248e-01f,
  -3.48942727e-01f, -1.15745507e-01f, 5.06813109e-01f, -1.44996375e-01f, 2.70064883e-02f, 2.06826672e-01f, -8.96063671e-02f, 2.49560848e-01f, 3.60466957e-01f, -5.28872311e-01f,
  7.74916172e-01f, -6.76846355e-02f, 4.68250334e-01f, 7.21221507e-01f, 7.25795627e-01f, 2.34162614e-01f, 1.06370473e+00f, -5.42455137e-01f, -1.07508779e-01f, 1.80795893e-01f,
  2.97186404e-01f, 3.91129613e-01f, 3.23866874e-01f, -3.50191779e-02f, -1.53267071e-01f, 2.45624796e-01f, 2.06186816e-01f, 3.67508054e-01f, 3.46675903e-01f, -3.26445043e-01f,
  -4.04057622e-01f, -5.78212477e-02f, 4.15923208e-01f, 1.08522713e-01f, -2.98509896e-01f, 5.78021929e-02f, 2.20121145e-01f, -1.98507726e-01f, 3.50578755e-01f, 7.84183145e-01f,
  1.13831744e-01f, -2.20518578e-02f, -1.27081573e-01f, -3.24087322e-01f, 4.39423978e-01f, -6.95459425e-01f, 2.50164956e-01f, -3.65675449e-01f, 2.23842487e-01f, -1.33965701e-01f,
  4.92861450e-01f, 5.05298615e-01f, 1.33284315e-01f, 1.57838106e-01f, 5.91051280e-01f, -1.73299313e-01f, 6.21052273e-02f, 4.64239180e-01f, 4.26988164e-03f, 3.54995608e-01f,
  2.39129752e-01f, 1.79321058e-02f, -9.71704274e-02f, -3.26635718e-01f, 2.92363614e-01f, -4.65084732e-01f, -1.54066086e-01f, -9.68678519e-02f, 7.50194252e-01f, -1.60227776e-01f,
  -4.07432675e-01f, -6.36615098e-01f, 5.52304089e-01f, 6.76766396e-01f, 4.50257927e-01f, -7.46566430e-02f, 3.27607781e-01f, -1.11611068e-01f, 7.59080565e-03f, -6.30054921e-02f,
  3.25368345e-01f, 1.23418808e-01f, 3.69579464e-01f, 2.24140123e-01f, 1.96380690e-02f, -1.85680494e-01f, 1.09296188e-01f, -1.47015333e-01f, -3.00274938e-01f, -2.31885508e-01f,
  -3.07867646e-01f, 2.20848178e-03f, -1.32093906e-01f, 1.53180495e-01f, 1.99082434e-01f, -3.40357989e-01f, -3.75178665e-01f, 1.95618734e-01f, 4.37846363e-01f, 2.92133868e-01f,
  -4.40607667e-01f, -1.93408504e-02f, 3.37207645e-01f, -5.06081522e-01f, 3.68593745e-02f, 3.85323465e-01f, -9.75831077e-02f, 8.48667771e-02f, -5.48246622e-01f, -5.79466879e-01f,
  6.70025527e-01f, 4.00970429e-01f, -5.33356182e-02f, 2.29692876e-01f, 1.89091161e-01f, -1.83939263e-01f, 1.56435370e-01f, 3.89817320e-02f, -2.15242624e-01f, 4.99514258e-03f,
  2.20265538e-01f, -1.31182428e-02f, 4.53490652e-02f, 1.12331018e-01f, 3.03417519e-02f, 3.85787375e-02f, -1.15397543e-01f, -8.26848447e-01f, -3.43144923e-01f, 1.45625651e-01f,
  -3.24009180e-01f, 1.80031002e-01f, -9.00468305e-02f, 7.59976387e-01f, 2.59806693e-01f, -3.58674526e-01f, 1.00552462e-01f, 9.52976823e-01f, -1.16237506e-01f, -8.49466920e-02f,
  -5.95901869e-02f, 2.64653891e-01f, 6.41020715e-01f, 9.44889009e-01f, 6.86799109e-01f, -1.00483879e-01f, -4.56733555e-02f, -3.64359289e-01f, 1.48881376e-01f, -5.22150286e-02f,
  -4.40076701e-02f, -1.08973786e-01f, 1.24215215e-01f, 1.08619235e-01f, 2.15791807e-01f, 5.31068631e-02f, -7.77192563e-02f, 2.60344654e-01f, 1.34132773e-01f, -7.87286013e-02f,
  7.78014259e-03f, 1.14488788e-01f, -4.66066822e-02f, 2.79255778e-01f, -3.41786444e-01f, -2.48215586e-01f, -1.81277305e-01f, -2.21594218e-02f, -8.14337075e-01f, -1.02178454e+00f,
  1.08219969e+00f, 6.14940636e-02f, 4.69773382e-01f, 8.44328761e-01f, 2.78847247e-01f, -2.65012890e-01f, 2.39839748e-01f, 7.40040660e-01f, 9.10754800e-01f, 8.50578904e-01f,
  4.12465930e-01f, 2.42134646e-01f, 8.14388454e-01f, 2.25397468e-01f, -2.62738645e-01f, 3.95887494e-01f, 5.96990287e-02f, 4.48786110e-01f, -7.93880597e-02f, -3.43710691e-01f,
  -6.29445195e-01f, -4.35512513e-01f, -1.46680340e-01f, -2.95296490e-01f, -5.65029025e-01f, -6.82272166e-02f, -4.30062354e-01f, -4.39028703e-02f, 1.86685354e-01f, -2.43020818e-01f,
  6.89729571e-01f, 4.21888828e-01f, -4.24412191e-01f, -5.54607771e-02f, -6.79114282e-01f, -5.19925416e-01f, 4.93049800e-01f, 7.61974752e-01f, -7.28838295e-02f, 3.25913548e-01f,
  4.24165606e-01f, -2.70566493e-01f, 1.41069531e-01f, 4.75984484e-01f, 4.40425426e-01f, 5.08356392e-01f, 2.99198002e-01f, 3.03938925e-01f, 3.49418104e-01f, 6.53715283e-02f,
  1.70560956e-01f, 2.31100738e-01f, 5.06052792e-01f, 5.61057031e-01f, -5.59877515e-01f, -1.69485256e-01f, -6.86394647e-02f, -1.80377975e-01f, -6.82712972e-01f, -1.36993617e-01f,
  -3.46757360e-02f, -4.10010248e-01f, -3.12858378e-03f, -8.32951963e-01f, -3.06940973e-01f, -2.17808560e-01f, -8.06337893e-02f, -1.01179868e-01f, 6.06638193e-01f, 6.13368034e-01f,
  -3.40126306e-01f, 5.16610265e-01f, 7.54422903e-01f, 3.02360326e-01f, 3.93427789e-01f, 4.16336477e-01f, 2.82699555e-01f, 1.85492739e-01f, 1.24665290e-01f, 1.77436963e-01f,
  -2.05073908e-01f, 2.39033177e-01f, 3.37736696e-01f, 3.76283601e-02f, -4.73472387e-01f, 2.35580623e-01f, 6.21239841e-02f, -1.20679818e-01f, 4.10527736e-02f, -3.33414793e-01f,
  6.02342427e-01f, -2.03352258e-01f, -2.42419839e-02f, -2.53719956e-01f, 7.47054040e-01f, 3.58292401e-01f, -6.29593730e-02f, 2.23887697e-01f, -5.31442583e-01f, -2.04582080e-01f,
  -3.56769443e-01f, -5.11077680e-02f, -7.04889834e-01f, -2.04607174e-01f, -5.55852532e-01f, 3.52645755e-01f, 1.48745224e-01f, 1.55913219e-01f, -1.76944118e-02f, -6.80624647e-03f,
  7.61234984e-02f, -5.70695288e-02f, -1.09770983e-01f, -1.20834872e-01f, -2.60828882e-01f, 1.28594235e-01f, -1.50009617e-01f, -1.77226499e-01f, 2.48802662e-01f, -4.16648500e-02f,
  -1.14914231e-01f, -3.19011360e-01f, 5.24289720e-02f, 2.64177397e-02f, 4.50477898e-01f, -3.37652229e-02f, -5.65953739e-02f, 3.89564782e-01f, -4.33316678e-01f, 4.99049984e-02f,
  -1.86490729e-01f, -5.68004012e-01f, -8.58076692e-01f, 8.54155123e-01f, 2.55866438e-01f, -3.06243688e-01f, -4.01421964e-01f, 9.29558039e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.45362476e-01f, 1.46606490e-01f, -8.59396234e-02f, 2.40292221e-01f, 7.92951286e-02f, 2.52951771e-01f, 2.22843289e-01f, 4.46834654e-01f, 1.14736460e-01f, 8.18959847e-02f,
  5.07703424e-01f, 1.03761509e-01f, 5.32318115e-01f, 1.20617084e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -4.32065457e-01f, 1.10099152e-01f, -3.67644578e-01f, -4.92964536e-01f, -1.52276456e-01f, -7.15654671e-01f, 1.33206546e-02f, -4.31497544e-01f, -2.74370074e-01f, -6.50862515e-01f,
  5.46348751e-01f, 4.09130007e-02f, -7.54850209e-02f, -4.07328486e-01f, 9.56065953e-01f, 4.47573178e-02f, -7.25422680e-01f, 1.92242250e-01f, -7.40456522e-01f, -3.46460253e-01f,
  9.82277170e-02f, 1.52508676e-01f, 2.95072407e-01f, -1.02987278e+00f, 4.57920104e-01f, -5.23325503e-01f, -2.89307445e-01f, 3.74412060e-01f, -9.32790160e-01f, -3.75234246e-01f,
  -5.66405416e-01f, -4.14633542e-01f, -7.17407823e-01f, 1.49973944e-01f, 7.22961068e-01f, 2.82286275e-02f, 7.16021240e-01f, 2.26220340e-01f, -5.01333714e-01f, -6.52935505e-01f,
  2.64873117e-01f, -2.13121489e-01f, 6.50840580e-01f, 1.63020305e-02f, -3.12375039e-01f, 7.02906370e-01f, -2.43915990e-01f, -6.35252357e-01f, -5.78017473e-01f, 5.69537520e-01f,
  -1.10677397e+00f, 5.00118911e-01f, -6.34575009e-01f, 1.00828052e-01f, -4.88521345e-02f, -4.25599366e-02f, -1.02183032e+00f, -2.05119446e-01f, -6.11592829e-01f, 5.22025287e-01f,
  -7.63557434e-01f, 2.70903260e-01f, 5.15546575e-02f, 2.90468931e-01f, -2.16161355e-01f, -1.12542577e-01f, -6.03016205e-02f, 6.74284935e-01f, -3.18895467e-02f, 2.13889912e-01f,
  -4.14954126e-02f, -2.16692626e-01f, -1.39531448e-01f, -7.46859729e-01f, 4.55239475e-01f, 7.59872437e-01f, -5.63479602e-01f, 1.01411390e+00f, -6.87210202e-01f, 6.63381517e-01f,
  -7.39836335e-01f, -6.47148609e-01f, -6.01025403e-01f, -4.96690899e-01f, -2.52968699e-01f, 2.85044491e-01f, 5.60745239e-01f, -5.58813751e-01f, 2.19004452e-01f, -3.09761494e-01f,
  -4.50662404e-01f, -3.69696289e-01f, -1.36645868e-01f, 1.60778359e-01f, 1.55803621e-01f, -6.90263271e-01f, 1.23679534e-01f, -1.80494428e-01f, 3.30078155e-01f, 4.87491250e-01f,
  -1.48511812e-01f, 1.55919328e-01f, -4.56914306e-01f, 6.00368194e-02f, -6.51900053e-01f, 5.16319415e-03f, -2.63726711e-01f, -1.82324022e-01f, 4.75319743e-01f, 1.92871347e-01f,
  5.59765339e-01f, 7.46590912e-01f, 2.38884225e-01f, 3.38990927e-01f, 6.58902526e-01f, -4.48890775e-01f, 2.83334106e-01f, 1.17861427e-01f, 1.55693457e-01f, -5.96000671e-01f,
  1.64131716e-01f, -7.72902489e-01f, 6.20397329e-01f, -2.01704025e-01f, -6.98293090e-01f, -1.01776934e+00f, -1.04915452e+00f, -1.04927421e+00f, 6.50900364e-01f, 1.53252453e-01f,
  -3.63845944e-01f, -7.93965518e-01f, -2.76256233e-01f, 2.38164380e-01f, 5.24672866e-01f, 8.10016155e-01f, 4.31862622e-01f, 4.97221828e-01f, -6.28049910e-01f, 3.60835910e-01f,
  -2.66525805e-01f, -1.35368034e-01f, 3.09475988e-01f, -2.72893608e-01f, 3.82414967e-01f, 8.10504258e-01f, -2.31853232e-01f, -9.05924559e-01f, 5.31479828e-02f, 3.26831304e-02f,
  -6.46025781e-03f, 1.09724715e-01f, -2.08200458e-02f, 1.70305327e-01f, 5.90243191e-02f, 1.95818171e-01f, -1.62076876e-01f, 3.19110662e-01f, -1.53223291e-01f, 8.56009871e-02f,
  1.24458320e-01f, 3.62393558e-01f, -5.38613141e-01f, -5.80369294e-01f, -2.21507534e-01f, -5.24029322e-02f, 3.52936566e-01f, 5.57143152e-01f, -2.42040828e-01f, -7.70914495e-01f,
  -6.56207383e-01f, -7.29532659e-01f, -2.13324845e-01f, -9.54012752e-01f, -3.64422292e-01f, 9.65644196e-02f, -3.91408414e-01f, 2.50009894e-01f, 5.81632197e-01f, 2.28575155e-01f,
  -3.90237905e-02f, 1.18545987e-01f, -5.78634918e-01f, -1.65550888e-01f, -2.95536518e-02f, -5.34638405e-01f, -9.38714683e-01f, 2.17756972e-01f, -5.82774282e-02f, 5.33400297e-01f,
  -4.53425869e-02f, 1.85133033e-02f, 5.49885511e-01f, 5.78211010e-01f, 2.66677022e-01f, 4.97801453e-01f, 6.02476835e-01f, 4.80390906e-01f, 1.48888767e-01f, 7.48122036e-01f,
  2.19668731e-01f, 5.33037305e-01f, 4.88379747e-01f, 4.33715612e-01f, -1.54216192e-03f, 6.69406876e-02f, -5.05469143e-01f, 4.10735160e-01f, -4.61881533e-02f, -4.13676411e-01f,
  -8.57845306e-01f, -5.48492670e-01f, -5.34958959e-01f, -9.65728521e-01f, -7.07971990e-01f, 4.53786910e-01f, 6.08468533e-01f, 4.05713096e-02f, -9.30841208e-01f, -3.04450035e-01f,
  3.62045139e-01f, -4.86336559e-01f, 6.12573922e-01f, -2.10306332e-01f, -3.74802083e-01f, 1.15445465e-01f, -2.04000279e-01f, -4.55796391e-01f, -4.04776245e-01f, -2.51429349e-01f,
  -2.40672633e-01f, -1.92906946e-01f, -9.38467011e-02f, -1.33866504e-01f, -3.05370152e-01f, -3.42142105e-01f, 7.08907396e-02f, -5.12477271e-02f, 1.61388546e-01f, 4.59879369e-01f,
  -5.97678304e-01f, -3.65686230e-02f, -5.75888790e-02f, -1.00811891e-01f, 2.23775059e-02f, 2.50750840e-01f, -3.97971660e-01f, -4.56140250e-01f, -2.80610435e-02f, 2.27552235e-01f,
  4.31883544e-01f, -5.65152705e-01f, 8.99896994e-02f, -6.12586558e-01f, -4.25272621e-02f, 5.36667883e-01f, -2.14529768e-01f, -1.31676331e-01f, 2.12960631e-01f, 5.47002494e-01f,
  -2.17054620e-01f, 5.46387881e-02f, 2.23594591e-01f, 1.40537918e-01f, 1.75208256e-01f, 6.36907637e-01f, -3.87780130e-01f, -2.36868620e-01f, 9.64656234e-01f, 7.79293358e-01f,
  5.69768071e-01f, -5.48235714e-01f, 1.06613837e-01f, 1.91165432e-01f, 3.05741727e-01f, 4.88491744e-01f, -8.78329635e-01f, 6.00497127e-01f, -3.54445904e-01f, 7.15786755e-01f,
  -7.01704621e-01f, -3.65912616e-01f, -4.11453545e-01f, -8.68363440e-01f, -1.04406334e-01f, -7.54813015e-01f, -3.13034832e-01f, -1.74644947e-01f, -4.06079106e-02f, 2.76441365e-01f,
  -4.58815157e-01f, 4.87217188e-01f, -1.84562951e-01f, -5.67165725e-02f, 1.71063438e-01f, -2.95096427e-01f, 7.47316735e-05f, 5.64359546e-01f, 7.95387328e-01f, 5.30492425e-01f,
  4.80198026e-01f, 3.15380156e-01f, -3.05073231e-01f, 1.03939110e-02f, 9.29264009e-01f, -3.89340669e-01f, -1.04188669e+00f, -4.90084976e-01f, 4.74941701e-01f, -1.22419620e+00f,
  -1.88406594e-02f, -2.96647310e-01f, -3.02517891e-01f, 3.42374861e-01f, 5.97252965e-01f, -5.95146775e-01f, 6.11219168e-01f, 5.26416063e-01f, -1.87843695e-01f, -1.55849978e-01f,
  4.36183095e-01f, -3.71869415e-01f, 2.25634620e-01f, -2.56701440e-01f, 2.74109393e-01f, -5.73694885e-01f, -1.75649509e-01f, -2.68675268e-01f, -5.40821254e-01f, -3.65318924e-01f,
  -2.30725914e-01f, -8.61705318e-02f, -5.85047543e-01f, -2.45675400e-01f, 8.40448797e-01f, -3.46476048e-01f, 3.36774200e-01f, 1.16619989e-01f, 3.56318593e-01f, 2.85593450e-01f,
  2.45718230e-02f, 9.85423941e-03f, -9.01351213e-01f, -7.66877159e-02f, -2.15542436e-01f, 8.93278182e-01f, 3.11095357e-01f, -7.90991664e-01f, 5.31240225e-01f, -1.94544896e-01f,
  -1.17867219e+00f, -1.09439194e+00f, -5.87667935e-02f, -2.98093915e-01f, 3.46441120e-01f, 8.92261565e-02f, -3.74448895e-01f, -2.47379228e-01f, 7.26138204e-02f, -1.44777119e-01f,
  6.19629733e-02f, 7.52304614e-01f, -3.39680731e-01f, -5.31227708e-01f, 4.08860356e-01f, -5.20432532e-01f, -3.03672493e-01f, 4.46309924e-01f, 4.40099269e-01f, -6.38870239e-01f,
  7.69592881e-01f, -1.45851433e-01f, -4.17734832e-02f, -1.02235854e+00f, 3.59940082e-01f, 6.74433529e-01f, -3.30866158e-01f, -6.49134219e-01f, -5.38699627e-01f, 1.00806383e-02f,
  -6.77566350e-01f, -1.19125158e-01f, -6.37212574e-01f, 7.76002556e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -4.49162364e-01f, 6.32441416e-02f, 2.44214311e-01f, -3.49880159e-01f, -3.71342123e-01f, -2.04003809e-04f, 2.83627480e-01f, -1.96798220e-01f, 1.37463033e-01f, 2.74031330e-02f,
  -1.45260140e-01f, -1.50433108e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    