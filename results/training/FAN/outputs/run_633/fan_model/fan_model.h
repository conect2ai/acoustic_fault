/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.97097644e-01f, -1.85629368e-01f, -4.26377684e-01f, 1.89607143e-01f, -1.37807027e-01f, -2.28137761e-01f, -5.55566251e-01f, -1.01987876e-01f, 3.07490230e-01f, -2.03178674e-01f,
  2.91428547e-02f, 3.45469594e-01f, 2.14340448e-01f, 1.03585050e-01f, -2.54017979e-01f, -5.15857935e-01f, -4.65487361e-01f, -1.89775452e-01f, -1.87798217e-01f, -1.89127728e-01f,
  4.06091008e-03f, 7.36323446e-02f, 1.85780239e-03f, 4.62939963e-04f, 2.27734104e-01f, 1.74598083e-01f, -5.98109923e-02f, 8.79314914e-02f, -7.78920725e-02f, -7.94181377e-02f,
  -2.06296161e-01f, -5.25127444e-03f, 4.60029952e-02f, 1.05997473e-01f, 1.00830540e-01f, 6.73802868e-02f, -1.34771841e-03f, 7.60009289e-02f, 1.78831458e-01f, 4.77435291e-02f,
  1.24225885e-01f, -6.36119209e-03f, 1.81870237e-02f, 4.62628268e-02f, 6.97130635e-02f, -3.55393961e-02f, -6.24101982e-02f, -2.25354936e-02f, 1.83531884e-02f, 3.59830484e-02f,
  -3.29650473e-03f, -6.60320818e-02f, -7.70856962e-02f, -7.35935941e-02f, -5.71422279e-02f, 8.98088813e-02f, 9.15530045e-03f, 9.01146978e-02f, 6.19949326e-02f, -9.99745447e-03f,
  -9.69935432e-02f, 3.54970060e-02f, -9.98860598e-02f, -1.28432605e-02f, -5.68403527e-02f, 1.22527024e-02f, -5.18699437e-02f, -1.06374457e-01f, 3.27418447e-02f, -4.61412705e-02f,
  -1.06712446e-01f, -5.41504733e-02f, -2.15964187e-02f, -9.42489728e-02f, -6.34719580e-02f, -4.05269377e-02f, -7.17176357e-03f, -2.28892174e-02f, 2.08273605e-02f, -2.25429386e-02f,
  -7.64690340e-02f, 9.13030002e-03f, 4.49741483e-02f, -1.41058704e-02f, -6.90010041e-02f, -1.00401096e-01f, 4.06298377e-02f, -7.34773651e-02f, 2.89764144e-02f, -6.72101825e-02f,
  4.05078560e-01f, -8.44674557e-02f, 1.31393135e-01f, 5.69567978e-02f, 7.67267793e-02f, 9.97372717e-02f, 8.96841511e-02f, 4.02731150e-02f, 1.97940275e-01f, 6.88172877e-02f,
  5.76566812e-03f, 4.24428955e-02f, 1.46768717e-02f, 7.42423907e-02f, -2.20047459e-02f, 6.58241436e-02f, 7.59120006e-03f, 1.02082685e-01f, 4.28403653e-02f, 1.41388774e-01f,
  2.62917560e-02f, -8.59753974e-03f, -5.76908626e-02f, 4.64513972e-02f, 1.54231489e-01f, 5.77164143e-02f, 3.61081697e-02f, 1.22278899e-01f, -7.99299255e-02f, -1.07239559e-01f,
  7.24712014e-01f, 2.74667859e-01f, 1.48516502e-02f, 1.44487381e-01f, 2.24710312e-02f, 7.76832476e-02f, 2.75282025e-01f, 1.34129539e-01f, 6.28764331e-02f, 1.18532032e-01f,
  7.32687637e-02f, -2.80440529e-03f, -6.63214996e-02f, -1.46383598e-01f, 5.39177023e-02f, -8.20421129e-02f, -2.89222360e-01f, -9.91670638e-02f, 1.26857474e-01f, 3.49110030e-02f,
  -1.55122355e-01f, 2.55227406e-02f, 2.13557750e-01f, 1.27111590e-02f, -1.37045115e-01f, -1.80868223e-01f, -1.37002259e-01f, 9.89153632e-04f, -1.45852789e-01f, -3.26334983e-01f,
  1.80422723e-01f, 3.66924942e-01f, -2.22037863e-02f, -3.18686739e-02f, 2.96475627e-02f, 7.65520288e-03f, 1.11828730e-01f, -2.90310960e-02f, 5.74929640e-02f, 7.64779896e-02f,
  5.72980382e-02f, 2.07320210e-02f, -5.11951745e-03f, -1.53938279e-01f, 4.38020267e-02f, 2.38815416e-02f, -5.44484481e-02f, -6.51951283e-02f, -4.92988266e-02f, -2.09592190e-02f,
  -1.13690339e-01f, 5.31976745e-02f, 8.73530954e-02f, -2.19194796e-02f, -3.18746269e-02f, -3.38334516e-02f, 5.48975654e-02f, 4.90287431e-02f, 6.53892606e-02f, 1.11356460e-01f,
  4.47959863e-02f, 6.74687326e-02f, -1.11025818e-01f, 5.28249331e-02f, 9.05223843e-03f, 4.00359463e-03f, -7.08020553e-02f, 3.10860910e-02f, -4.65887934e-02f, 1.25059932e-01f,
  -4.41819988e-02f, 2.92918347e-02f, 4.49685054e-03f, 1.66499153e-01f, -2.41111647e-02f, -5.56825381e-03f, -2.01278049e-02f, 9.77274179e-02f, 1.70804337e-02f, -3.60680073e-02f,
  1.11188620e-01f, 8.45453143e-03f, -1.82862617e-02f, -3.29391547e-02f, -8.94361436e-02f, 1.75731648e-02f, -4.82698000e-04f, 6.60540760e-02f, -6.33389456e-03f, 1.20060496e-01f,
  9.59355459e-02f, -1.38687372e-01f, 9.21350941e-02f, 8.54513869e-02f, 1.35331720e-01f, 2.74310019e-02f, -7.78381713e-03f, 8.98343325e-02f, 6.69254502e-03f, 1.21031724e-01f,
  1.07301004e-01f, 1.71546116e-01f, 8.10266063e-02f, -1.90683920e-02f, 8.31733048e-02f, 5.34873679e-02f, -4.66084965e-02f, 7.16282651e-02f, -1.85737386e-02f, -1.37767363e-02f,
  1.41185278e-03f, 1.50826991e-01f, 2.37975746e-01f, 1.77754611e-01f, 1.88372098e-02f, 1.50533915e-01f, 1.82907164e-01f, 2.19075590e-01f, 2.49909416e-01f, 4.26632971e-01f,
  2.18278334e-01f, 5.69416344e-01f, -6.29319370e-01f, 1.77391797e-01f, 2.64134258e-01f, -6.55605318e-03f, 3.30760539e-01f, 7.49971047e-02f, 1.82705358e-01f, 5.05049452e-02f,
  3.35675269e-01f, 1.99845910e-01f, 7.53277615e-02f, -7.34476447e-02f, -5.80066666e-02f, 9.91904885e-02f, -6.47276193e-02f, -3.93754601e-01f, -5.09684741e-01f, -2.14821294e-01f,
  1.03946686e-01f, -1.29409404e-02f, -7.18797073e-02f, -1.44896209e-01f, 1.19685449e-01f, 3.57690081e-02f, 4.84290905e-02f, 2.43736468e-02f, 1.02536976e-01f, -4.47918475e-02f,
  -4.83512610e-01f, 1.03661932e-01f, -2.09162951e-01f, 1.45624936e-01f, 2.35908758e-02f, -1.31894186e-01f, -5.84041141e-02f, -1.12094760e-01f, 1.30105898e-01f, -8.52787495e-02f,
  1.14297912e-01f, 1.53465429e-04f, 1.66815298e-03f, 2.34613139e-02f, -3.33546139e-02f, -5.03740646e-02f, 4.98057529e-02f, -7.54095539e-02f, 5.74121810e-02f, -4.13669236e-02f,
  1.89756691e-01f, 1.53027192e-01f, 4.15331591e-03f, 1.49652407e-01f, -1.80788822e-02f, -3.61454152e-02f, -1.04000784e-01f, -3.24130617e-02f, 2.58839410e-02f, -5.19254208e-02f,
  -2.78482679e-02f, -5.49604036e-02f, -1.57695487e-02f, -4.06412743e-02f, 3.78537029e-02f, -1.34272426e-02f, 1.72591582e-02f, -8.59318953e-03f, -5.35192341e-02f, -6.55334517e-02f,
  1.48388650e-02f, -1.71639360e-02f, -6.72831759e-02f, 5.98963648e-02f, -2.20043994e-02f, 3.04962625e-03f, 3.40432189e-02f, 2.36100983e-02f, 5.66801988e-02f, 1.01430558e-01f,
  -1.09925410e-02f, 1.33515084e-02f, 2.48356871e-02f, -4.09270301e-02f, 4.68076579e-02f, -9.47875679e-02f, 5.63306920e-02f, 1.33145526e-02f, -1.65747013e-02f, 4.26998474e-02f,
  1.44521713e-01f, 1.73257545e-01f, -5.18765897e-02f, -4.73172553e-02f, 5.11551462e-03f, 2.40695011e-02f, 4.18780781e-02f, 2.48524807e-02f, 6.78768903e-02f, 2.19393913e-02f,
  -8.60308018e-03f, -5.57527207e-02f, 8.64748731e-02f, -1.24100432e-01f, -3.34936790e-02f, -2.04328168e-02f, 1.16060212e-01f, 1.90281477e-02f, 7.30116814e-02f, -3.44226360e-02f,
  5.11491522e-02f, 2.74035428e-02f, 4.05247658e-02f, 2.73553021e-02f, -5.06603951e-03f, 8.30092952e-02f, -5.59708178e-02f, -1.46492854e-01f, -1.18286759e-02f, -9.06838279e-04f,
  -6.32547855e-01f, 1.53911605e-01f, 3.72309893e-01f, -5.75532675e-01f, 1.85723573e-01f, 4.57449317e-01f, 5.56699991e-01f, 5.60239889e-02f, -3.84612590e-01f, -7.59619251e-02f,
  2.73816139e-01f, -7.76446387e-02f, -6.16444647e-02f, 1.68806687e-02f, 1.95102662e-01f, 1.91480264e-01f, -1.22969769e-01f, -1.01833835e-01f, 2.49519318e-01f, 1.40548289e-01f,
  -6.65762499e-02f, -2.95271903e-01f, -1.82913810e-01f, -1.08513378e-01f, -4.03321266e-01f, -7.01004192e-02f, -3.81542407e-02f, -7.25118667e-02f, 3.88907284e-01f, -4.49555844e-01f,
  1.03518918e-01f, -2.97144218e-03f, 4.99804504e-02f, -2.62638424e-02f, 2.85564996e-02f, -1.28263310e-01f, -2.81453207e-02f, -1.27470881e-01f, 5.41321281e-03f, -4.52205241e-02f,
  -6.14808053e-02f, -1.82016883e-02f, -6.88636750e-02f, 7.02625839e-03f, 1.05003398e-02f, -1.77569743e-02f, -8.41872469e-02f, -2.06324775e-02f, -2.54909284e-02f, 9.26487297e-02f,
  3.57079948e-03f, 6.20863661e-02f, 1.09154120e-01f, 1.47934824e-01f, 1.24231458e-01f, 9.57576558e-02f, 2.18851164e-01f, 5.30664735e-02f, 2.10610017e-01f, -1.11299500e-01f,
  -4.93039563e-02f, 9.98807177e-02f, 5.05608432e-02f, -5.65596782e-02f, 3.86505723e-02f, -1.32667627e-02f, -2.19734460e-02f, -4.49022884e-03f, 4.95385900e-02f, -5.33503368e-02f,
  -5.78989536e-02f, 1.78975035e-02f, -3.31191160e-02f, -4.52505425e-02f, -1.97031274e-02f, -3.27283032e-02f, -3.21887247e-02f, 3.91380861e-02f, -1.35303866e-02f, -1.15363151e-02f,
  8.60398170e-03f, 2.11759880e-02f, -1.47552893e-01f, 1.06033757e-02f, 5.21125197e-02f, -1.10881254e-02f, -1.39203638e-01f, 2.25543845e-04f, -7.90507495e-02f, -5.68298548e-02f,
  -2.44857118e-01f, 3.10611993e-01f, -1.64607763e-01f, 7.46732671e-03f, -1.80249177e-02f, -1.17716137e-02f, 5.04661500e-02f, 3.07885911e-02f, -5.12200184e-02f, -1.41910072e-02f,
  9.38353166e-02f, 1.91556420e-02f, 3.60895768e-02f, -2.50033252e-02f, 4.57535591e-03f, 6.47734702e-02f, 5.78332730e-02f, 1.29691893e-02f, 6.46231249e-02f, -5.69675639e-02f,
  1.31077059e-02f, 7.80299306e-03f, -3.61243263e-02f, 8.35709646e-02f, -1.01984076e-01f, -8.17032009e-02f, 7.23234713e-02f, -7.88094476e-02f, 8.02025422e-02f, -1.70963973e-01f,
  2.42605120e-01f, 5.49925804e-01f, 1.46454394e-01f, 3.91355120e-02f, 1.19794562e-01f, 2.18743607e-01f, 5.17074645e-01f, 3.15762192e-01f, 4.69709039e-02f, 1.16258711e-01f,
  -1.20821707e-01f, -2.95393527e-01f, -2.96397358e-01f, -1.80234745e-01f, 9.06282961e-02f, 2.77264953e-01f, 2.94113040e-01f, -4.54056226e-02f, -2.26178199e-01f, -8.64797384e-02f,
  -1.51644498e-01f, 5.15535362e-02f, -1.31342351e-01f, -1.78735871e-02f, 7.97376558e-02f, -1.77564487e-01f, 1.63523123e-01f, -9.76243615e-02f, -1.38764635e-01f, -3.16380002e-02f,
  -2.55937845e-01f, 3.06378812e-01f, -7.39485174e-02f, -1.21480487e-01f, 1.90285947e-02f, -4.28962894e-03f, -1.08454293e-02f, 5.63845821e-02f, 7.15433955e-02f, 1.81055322e-01f,
  3.62991691e-02f, -3.85147035e-02f, -4.78700325e-02f, -6.71657026e-02f, 6.67310581e-02f, -9.22544748e-02f, 2.69056074e-02f, -4.24832664e-02f, -1.76910106e-02f, -6.14705263e-03f,
  9.92822740e-03f, 7.01157004e-02f, 1.81143239e-01f, 9.03039798e-02f, 8.15403387e-02f, -4.79946397e-02f, -2.19668373e-02f, 1.89101603e-02f, 1.13769911e-01f, 1.57250822e-01f,
  1.28593847e-01f, 1.96403936e-01f, -1.90284066e-02f, 1.75196566e-02f, -1.84797551e-02f, -5.99676045e-03f, 4.81396802e-02f, 2.64643952e-02f, -2.10101772e-02f, 8.77377540e-02f,
  -7.28530530e-03f, -6.89959824e-02f, -5.29850461e-03f, 1.99373141e-02f, -1.12224869e-01f, 3.84995490e-02f, -1.63787194e-02f, -3.68788093e-02f, -9.68772322e-02f, 5.43547943e-02f,
  -4.41225693e-02f, -6.27716025e-03f, -2.37245075e-02f, -8.39283392e-02f, -4.20930050e-02f, -4.25854698e-03f, -2.79694181e-02f, -2.34494880e-02f, -5.07426597e-02f, 1.13094859e-01f,
  -3.31318945e-01f, -7.15231225e-02f, -1.47537857e-01f, -1.47659704e-02f, 5.07331565e-02f, -9.44176689e-02f, -9.70853567e-02f, -8.68305936e-02f, 3.07582226e-02f, 4.15426157e-02f,
  -1.74499974e-02f, -3.52680893e-03f, 2.25489866e-02f, -1.16131986e-02f, -2.84750201e-02f, 4.89394478e-02f, -3.95390503e-02f, 5.15922531e-02f, 6.06029034e-02f, 1.07325748e-01f,
  4.76940088e-02f, 1.68854430e-01f, 5.81592172e-02f, 1.13356106e-01f, -1.98920052e-02f, -1.71600922e-03f, -7.15868175e-02f, -3.03093926e-03f, -4.58524823e-02f, 8.85179341e-02f,
  -1.25136152e-01f, 2.65618265e-01f, 3.27430576e-01f, 2.11594388e-01f, 4.46149632e-02f, -4.11735415e-01f, -2.47267812e-01f, -1.92830995e-01f, 3.44477668e-02f, 8.33733231e-02f,
  -4.33298461e-02f, -2.02162459e-01f, 7.20768571e-02f, -1.26107171e-01f, -2.55136043e-01f, 1.29974544e-01f, 3.32922369e-01f, 6.48364276e-02f, -3.14222842e-01f, -3.62708420e-01f,
  -1.35712381e-02f, 1.38483062e-01f, -1.02530904e-01f, 5.71547821e-02f, 3.20245713e-01f, 4.73340191e-02f, 3.53202105e-01f, 1.82769090e-01f, -6.26546219e-02f, 7.37675607e-01f,
  6.20910041e-02f, 1.85555607e-01f, -1.15750909e-01f, -6.40536798e-03f, 8.27925280e-02f, -8.20699185e-02f, -8.67575854e-02f, 1.05291754e-01f, -3.25609781e-02f, 8.51737149e-03f,
  1.39833882e-01f, -6.63879812e-02f, 6.61907047e-02f, 6.28251508e-02f, 4.76959236e-02f, -6.00225898e-03f, 1.51715711e-01f, 5.73927239e-02f, 3.27494778e-02f, -2.16878690e-02f,
  1.68395400e-01f, 3.06276679e-02f, 2.06855331e-02f, 1.29904160e-02f, -8.32045972e-02f, 3.34889479e-02f, -1.01891002e-02f, 1.17320437e-02f, -7.83944800e-02f, 1.15182959e-01f,
  -1.40483737e-01f, -1.20946439e-02f, -1.08831720e-02f, 3.33661474e-02f, 7.16064218e-03f, 6.60406351e-02f, 7.85407871e-02f, 1.68909281e-02f, -1.08404299e-02f, 1.88757442e-02f,
  9.04915482e-03f, 1.63842160e-02f, 4.06907462e-02f, 7.58178765e-03f, 1.99752371e-03f, 8.03998783e-02f, -4.05987166e-02f, 2.42239647e-02f, 1.17001114e-02f, 5.07152416e-02f,
  2.39489414e-02f, -3.11432611e-02f, 9.16846693e-02f, 3.86506505e-02f, 1.43778548e-02f, 7.22296983e-02f, 1.05169388e-02f, -8.85403007e-02f, 1.62500292e-02f, 4.41545025e-02f,
  -7.28055239e-02f, -1.56585366e-01f, 7.90657401e-02f, -2.18448769e-02f, 7.78495381e-03f, 2.52511725e-02f, 3.59961018e-02f, 1.59474332e-02f, -8.95126350e-03f, -3.85612212e-02f,
  -1.67395070e-01f, -7.74082839e-02f, 3.39225382e-02f, 3.97282606e-03f, -8.79775286e-02f, -9.38023999e-02f, -6.48292154e-02f, -1.87214836e-02f, -1.00429341e-01f, 1.28641380e-02f,
  5.16694970e-02f, -1.74626932e-01f, -2.65394062e-01f, -1.01429813e-01f, 4.60704044e-02f, -2.75684357e-01f, -1.06260382e-01f, -9.55262110e-02f, -3.22783172e-01f, -1.85587630e-01f,
  -3.10025841e-01f, 2.71051109e-01f, 5.05489945e-01f, 1.71920478e-01f, 2.24020355e-03f, -5.11885285e-02f, 1.20155528e-01f, -3.53062525e-02f, 5.64497225e-02f, 9.07821283e-02f,
  -6.40147328e-02f, 7.74652660e-02f, 3.00920814e-01f, 2.26303756e-01f, 2.33466178e-01f, 3.35900903e-01f, 4.00291204e-01f, 1.74680263e-01f, 8.39308947e-02f, -1.45247698e-01f,
  -1.48481846e-01f, 4.34707031e-02f, -9.89829749e-02f, 2.54457816e-02f, 2.64324769e-02f, 1.91299822e-02f, 1.98804617e-01f, -6.34975508e-02f, -2.04122335e-01f, 2.43633494e-01f,
  2.96415389e-01f, 1.46950245e-01f, -1.86943705e-03f, 1.38683468e-02f, 1.85248926e-01f, 1.15412831e-01f, 4.79195528e-02f, 1.27084970e-01f, 4.33481634e-02f, 1.09367684e-01f,
  5.97423241e-02f, 1.04218468e-01f, 1.24600828e-01f, 1.86994776e-01f, 1.11829475e-01f, 5.62258326e-02f, 1.83193862e-01f, 1.69720322e-01f, 2.23282889e-01f, 1.43931091e-01f,
  1.46322802e-01f, -6.11252189e-02f, 8.20533708e-02f, 6.02749884e-02f, 9.28930938e-02f, 1.23712994e-01f, 5.86004183e-02f, -4.38940478e-03f, 1.13225989e-01f, 7.59709850e-02f,
  -1.48582399e-01f, 1.90036613e-02f, -7.87494481e-02f, -5.19554839e-02f, -6.73275292e-02f, -5.79782836e-02f, 1.03014000e-01f, -4.28855466e-03f, -5.29181398e-02f, -6.07268773e-02f,
  1.63475666e-02f, 7.55596906e-02f, 2.42533330e-02f, 6.67331591e-02f, 6.27645925e-02f, -3.61512713e-02f, -1.19559780e-01f, -3.88668082e-03f, 2.11378150e-02f, -2.78330836e-02f,
  2.52854191e-02f, -3.01234405e-02f, 4.74582277e-02f, 1.24687972e-02f, -6.68621510e-02f, 8.46069232e-02f, -5.04506901e-02f, -9.02712867e-02f, 4.75670211e-02f, -5.90852760e-02f,
  -8.10382441e-02f, 1.17623016e-01f, 1.53302044e-01f, 1.58607125e-01f, 3.04257199e-02f, 1.83256604e-02f, 1.26190841e-01f, 1.00443609e-01f, 1.64412290e-01f, 4.87073809e-02f,
  7.39680380e-02f, 6.65575638e-02f, 1.88058704e-01f, 2.60437932e-03f, 6.95000812e-02f, 7.52810715e-03f, 4.88444185e-03f, 1.55033261e-01f, 1.04027852e-01f, 3.25490460e-02f,
  1.81446075e-02f, -3.15024219e-02f, 1.78123210e-02f, 1.16574094e-01f, 1.15929497e-02f, 1.98673010e-02f, 3.17839421e-02f, -1.53679699e-02f, 7.65232369e-02f, -4.59118001e-02f,
  -3.54350656e-01f, 2.92386055e-01f, -2.51870632e-01f, -2.18276563e-03f, -3.40295881e-02f, -1.81830734e-01f, 7.09567741e-02f, -9.43435878e-02f, -1.98608696e-01f, -1.40580505e-01f,
  -8.04646760e-02f, -2.91403651e-01f, -2.72388309e-01f, -1.89035252e-01f, -1.13983124e-01f, -8.53373483e-02f, 1.06574304e-01f, -3.21059115e-02f, -2.83589751e-01f, -1.69652417e-01f,
  2.75626481e-01f, 2.11319998e-01f, 1.63758382e-01f, 5.51357530e-02f, 1.12909243e-01f, -1.76870629e-01f, 1.37771860e-01f, 1.96098894e-01f, -1.38601679e-02f, 3.76426056e-02f,
  -4.37077284e-01f, -1.66257203e-01f, -1.36566728e-01f, 3.73733044e-02f, -6.87972382e-02f, -2.29297772e-01f, -8.95269364e-02f, -1.69621646e-01f, -8.62688646e-02f, -7.08667263e-02f,
  -7.26833642e-02f, -1.41441494e-01f, -1.81349277e-01f, -1.46699116e-01f, -1.57609642e-01f, -2.04183012e-01f, -7.55691230e-02f, -1.76580846e-01f, -1.10080004e-01f, -1.13009937e-01f,
  3.83407511e-02f, -9.56719145e-02f, -1.39160082e-01f, -2.06481099e-01f, -1.95327207e-01f, -6.97493777e-02f, -5.68233319e-02f, -2.51452833e-01f, -2.65015632e-01f, -1.73337176e-01f,
  -5.50340489e-02f, 2.12917067e-02f, 7.91703910e-02f, 2.09085047e-01f, 1.54478058e-01f, 8.17239881e-02f, 6.73826709e-02f, 1.03303269e-01f, 1.28859311e-01f, 1.91726591e-02f,
  5.44324145e-02f, 2.81882156e-02f, 7.31683522e-02f, 1.00162506e-01f, 4.38804924e-03f, 4.61510010e-02f, 4.15547490e-02f, 1.68856859e-01f, 6.69039041e-02f, 9.37293097e-02f,
  9.11803544e-02f, 4.12147539e-03f, 1.29123688e-01f, 1.03404894e-01f, 3.56767476e-02f, 1.07560784e-01f, 6.01906516e-02f, 1.90116651e-02f, 7.45576844e-02f, 1.15773920e-02f,
  2.50424948e-02f, 1.58750415e-02f, -2.29971573e-01f, -1.15283884e-01f, -1.30760998e-01f, -5.11184298e-02f, -4.28196229e-02f, -9.47261229e-02f, -1.45946175e-01f, -8.07574242e-02f,
  -7.92666748e-02f, -6.42184690e-02f, -1.88368365e-01f, -1.06802464e-01f, -2.19440356e-01f, -1.24758773e-01f, 3.43931019e-02f, -1.19494908e-01f, -1.05178915e-01f, -1.65719241e-01f,
  -5.11584658e-05f, -1.82931811e-01f, -2.13656753e-01f, -2.71046579e-01f, -9.78839695e-02f, -2.56135404e-01f, -1.83968097e-01f, -1.73586875e-01f, -2.73685336e-01f, 1.97939239e-02f,
  -4.36654866e-01f, -3.17588061e-01f, 3.53363812e-01f, -2.98306793e-01f, -1.84389725e-01f, 1.25274390e-01f, -6.31488338e-02f, -2.64355779e-01f, -2.65382025e-02f, 7.07132509e-03f,
  -2.76398689e-01f, -3.09580397e-02f, 1.00597315e-01f, 1.81927323e-01f, 1.19524531e-01f, 3.24767768e-01f, 4.00182158e-01f, 4.73649412e-01f, 3.44932199e-01f, -1.33361276e-02f,
  -7.97455609e-02f, -2.25804314e-01f, -2.08102524e-01f, 7.32984245e-02f, 4.20938171e-02f, 3.40954751e-01f, 1.89064384e-01f, 3.44491526e-02f, 1.50187567e-01f, 4.88432437e-01f,
  1.66061729e-01f, -3.13775659e-01f, 1.41487524e-01f, 3.38863097e-02f, -3.28237340e-02f, -4.43576388e-02f, 2.86616907e-02f, -1.12423174e-01f, -6.29193932e-02f, -3.33044790e-02f,
  2.38571689e-02f, 4.85052764e-02f, 8.04662481e-02f, -2.45384760e-02f, -1.04556575e-01f, 4.27456871e-05f, 5.09045366e-03f, -2.93307938e-02f, 8.12117830e-02f, -3.44390087e-02f,
  -1.07359104e-01f, -5.99167757e-02f, 4.41766456e-02f, 6.38462156e-02f, -2.04428900e-02f, 1.06251784e-01f, 8.57930854e-02f, 1.34191483e-01f, 1.93531156e-01f, 4.46963273e-02f,
  1.09162368e-01f, 4.03372496e-02f, -7.11606890e-02f, -4.50021960e-02f, -7.08921850e-02f, 8.56098253e-03f, 6.86229989e-02f, 3.14467475e-02f, -1.26115736e-02f, 1.90190822e-02f,
  -2.45878305e-02f, 5.86655224e-03f, -7.00870063e-03f, -6.34414554e-02f, 2.65040454e-02f, 1.21590132e-02f, 1.91638321e-02f, 1.55398110e-02f, 1.28419725e-02f, -2.03469601e-02f,
  3.87283936e-02f, 8.67248625e-02f, -2.31837463e-02f, 1.87331513e-02f, -3.95698845e-02f, 4.26786691e-02f, 3.41092423e-02f, -1.15382917e-01f, -1.20467491e-01f, -5.51289991e-02f,
  -9.58906040e-02f, 1.23393640e-01f, 8.85181576e-02f, -5.16100321e-03f, 5.70400730e-02f, 8.43237266e-02f, 4.47257608e-03f, 2.38486640e-02f, -2.39776801e-02f, 6.59791380e-02f,
  -1.95686873e-02f, -5.50080203e-02f, -4.83105890e-03f, -1.28255412e-03f, 1.15617909e-01f, -1.58339664e-02f, -5.33382669e-02f, 1.30611628e-01f, 5.33053651e-02f, -1.17012918e-01f,
  -1.94592383e-02f, 1.30738392e-01f, 3.42463702e-02f, 1.40241757e-01f, 4.94602956e-02f, 2.20338136e-01f, 6.87550008e-02f, 1.68320343e-01f, 1.55154496e-01f, 1.00663632e-01f,
  4.81208354e-01f, 5.71807846e-02f, 7.07176268e-01f, 7.82085955e-02f, -1.87914699e-01f, -1.00468718e-01f, -2.07931921e-01f, -3.21916677e-02f, -1.40469208e-01f, 1.78183112e-02f,
  -3.41203600e-01f, -4.32182223e-01f, -8.48345309e-02f, -1.50679961e-01f, 1.52464017e-01f, 8.96314085e-02f, 1.33281767e-01f, 3.81483912e-01f, 9.16233063e-02f, -4.20963049e-01f,
  -4.53070492e-01f, -1.81359239e-02f, 1.13535248e-01f, 5.50703853e-02f, -1.25501350e-01f, -1.55500144e-01f, 7.27530569e-02f, 2.76500899e-02f, -1.31571636e-01f, 2.60129482e-01f,
  2.81677127e-01f, 3.20961565e-01f, -7.01893494e-02f, -1.20078802e-01f, 4.16477473e-04f, 1.10568583e-01f, -2.57159900e-02f, 1.59709930e-01f, -3.72770876e-02f, 7.80990571e-02f,
  -6.02285266e-02f, 2.26016976e-02f, -2.65826415e-02f, -1.24354824e-01f, -5.57728149e-02f, -4.60163504e-02f, 1.00752778e-01f, 2.76454121e-01f, 1.37615010e-01f, -9.32428911e-02f,
  -1.88217446e-01f, -1.06927700e-01f, 2.00856030e-01f, 6.95414618e-02f, 1.68297499e-01f, -6.79008849e-03f, 1.17238089e-01f, 8.84399042e-02f, 1.62770659e-01f, 1.44575074e-01f,
  -5.28064072e-02f, -1.63335782e-02f, 8.63101482e-02f, 1.44133896e-01f, -4.36644778e-02f, 5.50130988e-03f, 2.74651814e-02f, -1.09997191e-01f, -9.18845367e-03f, 6.92911297e-02f,
  4.57473807e-02f, 3.89676914e-02f, 1.38697932e-02f, 9.83068347e-02f, -3.17240991e-02f, 1.51443452e-01f, 5.89040220e-02f, 3.15985121e-02f, 1.04940729e-02f, 6.92060888e-02f,
  1.75342839e-02f, 8.05951059e-02f, 4.00833301e-02f, 9.59941931e-03f, 6.83047920e-02f, 1.32223561e-01f, 6.53332099e-02f, 4.08413410e-02f, 3.46685499e-02f, 1.42008960e-02f,
  -1.41936839e-01f, 1.83120295e-02f, 3.19025740e-02f, -3.48293930e-02f, 4.57157604e-02f, -9.68971550e-02f, -8.04810226e-02f, -5.33284359e-02f, 2.90087145e-02f, 2.02981047e-02f,
  -9.81075242e-02f, -2.66167372e-02f, -6.65123239e-02f, -7.08434433e-02f, -6.04131967e-02f, -1.30360071e-02f, -6.34418577e-02f, -9.57528129e-02f, -7.33401775e-02f, -7.50350505e-02f,
  -1.12446927e-01f, -1.49876282e-01f, -8.57620016e-02f, -6.40893495e-03f, -7.59571493e-02f, -6.56057894e-02f, 7.69092068e-02f, -9.49311033e-02f, 8.46764296e-02f, 8.34037215e-02f,
  -1.82520792e-01f, 3.28516096e-01f, 3.98593217e-01f, 7.78186992e-02f, -2.41369717e-02f, 1.73945278e-01f, 3.39181840e-01f, 6.54051006e-02f, -1.54336229e-01f, 5.24166971e-02f,
  -3.68757218e-01f, -4.33852196e-01f, -1.52913168e-01f, -1.34346396e-01f, 1.15161963e-01f, 4.03034627e-01f, 5.64951837e-01f, 1.78552687e-01f, 4.62826006e-02f, -9.96857211e-02f,
  -1.61517993e-01f, -4.53490689e-02f, -1.34804517e-01f, -1.61526769e-01f, 8.27559456e-02f, -6.73873723e-02f, 3.24234664e-02f, -4.07594480e-02f, -4.87636738e-02f, 2.09641397e-01f,
  1.87285051e-01f, -5.67853637e-02f, -1.26095206e-01f, -2.49879077e-01f, -1.76495105e-01f, -4.65418249e-02f, -4.91793938e-02f, -4.14871387e-02f, -5.92601858e-02f, -2.34965663e-02f,
  -1.17019549e-01f, -6.93901554e-02f, -8.06510746e-02f, -7.54010351e-03f, -1.23195974e-02f, -4.27980274e-02f, -7.11576722e-05f, 5.05730845e-02f, -1.29531203e-02f, 1.52109116e-02f,
  -2.07543731e-01f, -3.00289933e-02f, -3.74557674e-02f, -4.91111353e-02f, -2.39352267e-02f, -1.40599951e-01f, 4.03833017e-02f, -4.18816023e-02f, -4.98373248e-02f, 1.45769238e-01f,
  -1.33056015e-01f, -2.96273880e-04f, 1.02628646e-02f, 8.68141949e-02f, 4.06344682e-02f, -1.20788776e-04f, 6.50308132e-02f, -1.96726117e-02f, -1.46453623e-02f, 6.39394969e-02f,
  7.12249521e-03f, 5.47064096e-02f, -2.72924844e-02f, 1.67217582e-01f, -3.77393663e-02f, 7.87183568e-02f, 8.05341154e-02f, 9.28141624e-02f, -5.12221409e-03f, 1.73649320e-03f,
  6.30806163e-02f, 5.37960092e-03f, 9.62008238e-02f, -3.90418172e-02f, 8.34917352e-02f, 1.04471348e-01f, 5.01291379e-02f, -1.80227067e-02f, 3.41602825e-02f, 5.45888171e-02f,
  -5.04542030e-02f, -2.01353475e-01f, 1.35950074e-01f, 1.03058852e-02f, -1.43652633e-02f, -8.35892260e-02f, -4.66280095e-02f, -3.75954024e-02f, -9.43468586e-02f, 3.57236378e-02f,
  -8.57689306e-02f, -6.20897599e-02f, -6.67512417e-02f, -1.13447689e-01f, -4.39287955e-03f, 1.15559679e-02f, 5.14772162e-02f, -3.00688352e-02f, -3.35783958e-02f, -3.92653383e-02f,
  -6.64250851e-02f, 4.46820371e-02f, 7.97028467e-02f, 8.65908116e-02f, 2.69641299e-02f, -3.61676626e-02f, 1.03517756e-01f, 9.06210616e-02f, 3.02301515e-02f, 2.44578317e-01f,
  -7.88271964e-01f, 6.32370915e-03f, 3.09981912e-01f, -3.45559925e-01f, 1.65322766e-01f, 3.93305153e-01f, 6.17747068e-01f, 6.25382066e-02f, -6.59398288e-02f, 4.99518402e-02f,
  -9.14829895e-02f, -2.53775924e-01f, -8.67178813e-02f, -3.97858620e-02f, 3.44640091e-02f, 3.74059767e-01f, 1.89101547e-01f, -1.45190895e-01f, 2.46320181e-02f, 2.97129974e-02f,
  -3.17357033e-02f, -1.77750170e-01f, -4.05863672e-01f, -5.15054725e-03f, -1.51621878e-01f, 1.58587489e-02f, 9.42019299e-02f, -2.86071181e-01f, 2.75188722e-02f, -3.28189462e-01f,
  -1.35303408e-01f, -3.34233761e-01f, 1.30305424e-01f, -1.61698580e-01f, 4.13963236e-02f, -3.74883227e-02f, 9.75969508e-02f, -2.27390416e-02f, 6.11807369e-02f, 1.81392785e-02f,
  -2.94005591e-02f, -5.78204468e-02f, -1.02672547e-01f, -1.68116800e-02f, -5.66593818e-02f, 4.60451357e-02f, -1.02300353e-01f, -7.12536871e-02f, 4.85932492e-02f, 3.83918360e-02f,
  -3.25935408e-02f, -1.40658677e-01f, -5.93210123e-02f, 2.18216166e-01f, 3.72785889e-02f, -1.94731504e-02f, 2.57154536e-02f, -1.56209441e-02f, -2.13279836e-02f, -8.10957626e-02f,
  1.92490220e-03f, 6.72746263e-03f, -3.78215089e-02f, 5.28189465e-02f, 2.71381103e-02f, -2.64037959e-02f, 3.90331522e-02f, -9.88933723e-03f, 9.55472607e-03f, 3.00885011e-02f,
  4.96292673e-02f, 5.27985021e-02f, -1.25256926e-02f, -1.54007804e-02f, 2.49067377e-02f, -4.90798168e-02f, -4.36557829e-02f, 1.19280918e-02f, -6.21194653e-02f, -4.35356684e-02f,
  -1.07730284e-01f, -1.80190559e-02f, -1.11573040e-02f, -1.05326157e-02f, 1.50850683e-03f, 1.92420166e-02f, -5.39219417e-02f, 1.45264203e-02f, 1.30628282e-03f, 9.86263156e-03f,
  1.56780314e-02f, 1.32122084e-01f, -6.82966709e-02f, -6.43556714e-02f, 1.45457080e-02f, -2.30726842e-02f, 1.02315173e-02f, 3.76501530e-02f, -2.21072529e-02f, 5.34676947e-02f,
  9.55106318e-03f, -3.38539518e-02f, -9.39236302e-03f, 6.57356158e-02f, 1.45111859e-01f, 6.36397377e-02f, 2.59281397e-02f, 2.72499565e-02f, 2.40690801e-02f, 4.53276969e-02f,
  1.49013221e-01f, 1.20697610e-01f, -7.37340655e-03f, 9.52635631e-02f, 2.34476123e-02f, -3.35200839e-02f, 1.01030737e-01f, 1.25594124e-01f, 1.77684143e-01f, 3.28198314e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.44670084e-01f, -8.37356806e-01f, -8.03826690e-01f, -4.03819650e-01f, -1.11305714e+00f, -4.30311561e-01f, -6.95387423e-01f, 4.56307024e-01f, 2.71641114e-03f, -1.00618398e+00f,
  -5.30490637e-01f, 1.27121568e-01f, -2.61355609e-01f, 3.56809705e-01f, 1.01080465e+00f, -7.22702384e-01f, -4.88488972e-01f, 5.12202501e-01f, 1.25701582e+00f, 7.03957200e-01f,
  -2.71861583e-01f, 2.55183786e-01f, 9.62248623e-01f, 5.25470972e-01f, -8.96605730e-01f, -3.87599587e-01f, -8.15000653e-01f, -4.22274947e-01f, -3.09859186e-01f, -1.22890353e+00f,
  -7.03685939e-01f, -3.40873376e-02f, 2.07316056e-01f, 2.73426861e-01f, -4.56900716e-01f, 7.45153800e-02f, 1.34317666e-01f, -1.00397266e-01f, -6.58570826e-02f, -1.60425901e-01f,
  -2.99059331e-01f, 2.33981386e-01f, -2.70696968e-01f, -3.27723436e-02f, -9.28106681e-02f, 1.41695499e-01f, 3.22901100e-01f, 3.57907414e-01f, 2.68344525e-02f, -1.83917731e-01f,
  -6.26306772e-01f, -5.36952198e-01f, -2.14043170e-01f, -6.72220886e-02f, 5.25086403e-01f, -1.80085264e-02f, 5.35298809e-02f, 3.77061456e-01f, 4.18178111e-01f, -8.04184437e-01f,
  -7.79437125e-02f, -1.03687361e-01f, -5.31762764e-02f, 7.58391842e-02f, 3.15797031e-02f, -5.66014908e-02f, -3.53163294e-02f, -3.48699130e-02f, 7.92498514e-02f, -2.36573666e-02f,
  3.06759298e-01f, -1.08790435e-01f, 1.22203819e-01f, -1.72219560e-01f, -7.76494220e-02f, -1.76219165e-01f, -1.03208430e-01f, 9.41189229e-02f, 2.99285203e-02f, 1.32471723e-02f,
  7.04678297e-02f, -1.94864050e-02f, -1.78634167e-01f, 1.62353262e-01f, -2.92028692e-02f, 1.01675488e-01f, -2.19266824e-02f, 1.71540499e-01f, 1.16871014e-01f, 6.88665733e-02f,
  4.55226451e-02f, 4.34191585e-01f, -6.58530176e-01f, 1.39083833e-01f, -1.50582701e-01f, -1.50228471e-01f, -4.66552258e-01f, 1.77946240e-01f, -1.09872594e-01f, 7.26835132e-02f,
  5.67528754e-02f, 1.03880055e-02f, -2.92108297e-01f, 1.25592679e-01f, 8.79328847e-02f, -2.62359437e-02f, 7.52255321e-03f, -1.57942533e-01f, 5.35262600e-02f, -2.03136757e-01f,
  3.58177698e-03f, -1.17395394e-01f, -8.10303017e-02f, -2.77734518e-01f, -2.23002166e-01f, -2.01042250e-01f, -4.46979523e-01f, -4.09926683e-01f, -7.56475627e-02f, -7.06060827e-01f,
  -1.00436938e+00f, 4.75214660e-01f, 7.45859087e-01f, -2.62443513e-01f, 1.06492233e+00f, 3.19758892e-01f, -5.30656993e-01f, -1.03986764e+00f, -4.43885058e-01f, 1.30544215e-01f,
  7.66860545e-01f, -1.71306022e-02f, 1.28717020e-01f, -2.49646768e-01f, -8.45652223e-01f, -2.61666417e-01f, -1.16654076e-01f, -4.92618173e-01f, -8.53778422e-01f, -4.71179038e-01f,
  -2.43795857e-01f, -4.59140211e-01f, -4.38334346e-01f, -4.00072545e-01f, 1.90516844e-01f, -1.05842268e-02f, 5.21913588e-01f, 3.67602021e-01f, 5.55901587e-01f, 4.44600523e-01f,
  1.81565374e-01f, -6.03054613e-02f, -2.33067319e-01f, 1.04932323e-01f, 2.81558841e-01f, -3.23274255e-01f, -3.44891727e-01f, 3.07343006e-02f, 5.44204190e-02f, -4.79941852e-02f,
  4.40704882e-01f, 1.82422936e-01f, 1.25302389e-01f, 9.07309428e-02f, -1.76059306e-01f, -2.75920302e-01f, -2.48635247e-01f, -4.50358659e-01f, -4.91195321e-01f, -3.17384720e-01f,
  2.07557887e-01f, 3.76733452e-01f, -7.33194128e-02f, 5.55673055e-02f, -3.22406799e-01f, 1.89406767e-01f, 1.48974180e-01f, -1.31761760e-01f, -1.48595080e-01f, -4.53480959e-01f,
  -1.86371412e-02f, 1.29709780e-01f, 1.59750521e-01f, 2.37032235e-01f, -5.13989069e-02f, 1.99761093e-01f, 9.80013385e-02f, 1.31086305e-01f, 1.12736844e-01f, -3.84643786e-02f,
  1.52228549e-02f, 5.14380075e-02f, 5.77207133e-02f, -1.77534893e-01f, -8.10681507e-02f, 4.34575900e-02f, -3.18011343e-02f, -1.90271869e-01f, 5.80292232e-02f, -5.89219911e-04f,
  -2.56380409e-01f, 5.40147573e-02f, 1.47690967e-01f, -2.23660871e-01f, 1.18286364e-01f, 1.27152368e-01f, 1.53461874e-01f, -2.86382232e-02f, -1.72738358e-01f, 1.37116238e-01f,
  -6.90532446e-01f, 7.27837145e-01f, -5.89604259e-01f, -2.32885674e-01f, -9.66506824e-02f, 1.40060022e-01f, 9.63186622e-02f, 1.04592241e-01f, 3.24468017e-02f, -4.62844342e-01f,
  9.46655571e-02f, -3.55959237e-01f, -8.79343972e-02f, -4.06973623e-02f, -8.72266367e-02f, 8.55514407e-02f, 1.06954373e-01f, -1.42234266e-01f, -3.03673565e-01f, 2.59679556e-03f,
  -3.40558171e-01f, -6.16564691e-01f, -9.25866961e-01f, -4.31233585e-01f, -4.83638495e-01f, -7.76853859e-01f, -5.76767743e-01f, -4.39493418e-01f, -6.24101162e-01f, -1.39523304e+00f,
  1.48068202e+00f, 7.86826730e-01f, 6.14760876e-01f, 2.92327881e-01f, -2.74638254e-02f, -5.59251383e-02f, 9.15757492e-02f, 7.24802539e-02f, -6.73305988e-02f, 2.46027857e-01f,
  3.02913487e-01f, 1.59384191e-01f, 2.13483442e-02f, -3.69632244e-02f, 1.08530194e-01f, -1.70383565e-02f, -4.02280271e-01f, 2.15204120e-01f, 1.64358035e-01f, 1.33423701e-01f,
  -2.38063022e-01f, 4.98985648e-02f, 4.39614475e-01f, 9.22167450e-02f, 2.29442623e-02f, -2.12124631e-01f, 1.02340981e-01f, 2.60397464e-01f, 1.27919108e-01f, 3.36521745e-01f,
  8.95223022e-01f, 7.58102834e-01f, -5.92612743e-01f, -1.90747574e-01f, -2.22213361e-02f, -3.19124311e-02f, 1.71361188e-03f, -4.38375548e-02f, -1.75432749e-02f, -1.46824285e-01f,
  2.81116292e-02f, 6.22271821e-02f, 3.54125202e-02f, -8.79119411e-02f, 3.32423635e-02f, -1.31964982e-01f, -5.42665385e-02f, 7.83016980e-02f, 1.12614445e-01f, -2.84351837e-02f,
  -1.42035425e-01f, -3.21053783e-03f, 9.57816765e-02f, -1.08997568e-01f, 1.61235705e-01f, -1.34311980e-02f, 9.42164883e-02f, 5.49415760e-02f, 1.03168562e-01f, 3.33973765e-01f,
  1.56531438e-01f, 2.27642551e-01f, 1.57641351e-01f, 8.11315626e-02f, 1.69943631e-01f, 9.95412022e-02f, -1.07156634e-01f, 3.18877697e-02f, 1.97445545e-02f, -3.67626734e-02f,
  -9.10444707e-02f, 6.74336255e-02f, 1.86893046e-01f, -1.27617285e-01f, -1.05520397e-01f, -2.50957254e-02f, -3.67463455e-02f, -9.09316763e-02f, 6.24808809e-03f, -5.37279248e-02f,
  1.24662399e-01f, -5.08001149e-02f, -5.11605740e-02f, 8.90543610e-02f, -1.10821806e-01f, 1.10923059e-01f, 7.64991492e-02f, 4.89378385e-02f, 1.04113288e-01f, -1.27601430e-01f,
  -6.57395303e-01f, -2.43163183e-01f, -1.39139488e-01f, -9.34061557e-02f, 3.49220857e-02f, 3.45305055e-02f, 1.74218774e-01f, -5.11537716e-02f, -1.46915868e-01f, -1.37387201e-01f,
  2.81880740e-02f, 1.32273644e-01f, 6.08891547e-02f, 9.01723374e-03f, -1.86077192e-01f, -7.48152286e-02f, 5.60734468e-03f, -2.18712306e-03f, -1.03786960e-01f, -7.06059858e-02f,
  -2.02942461e-01f, -2.53609687e-01f, -2.90429801e-01f, -2.52192259e-01f, -1.29312217e-01f, -3.43929887e-01f, -2.77755052e-01f, -1.85501158e-01f, -1.56679437e-01f, -2.16400594e-01f,
  1.12102044e+00f, -1.04580700e+00f, -6.30427003e-02f, 3.87619495e-01f, 1.04148991e-01f, 2.27900669e-01f, -2.16871411e-01f, 5.70651777e-02f, 2.06415117e-01f, 8.25314596e-02f,
  -4.72942330e-02f, 1.88871548e-01f, 1.98036462e-01f, -2.78646387e-02f, -1.95681211e-02f, -1.96671635e-01f, -1.40876859e-01f, 1.49277851e-01f, 4.36527938e-01f, 1.26324385e-01f,
  1.04389545e-02f, -8.65472332e-02f, 1.51614845e-01f, 3.30999214e-03f, -3.37582052e-01f, 2.51606535e-02f, -1.14424571e-01f, -3.28389794e-01f, -2.87836820e-01f, -4.37378496e-01f,
  -5.73616803e-01f, -1.71450913e-01f, 2.73236871e-01f, -6.55251835e-03f, -8.16057771e-02f, -1.01903742e-02f, 1.79464612e-02f, -5.12779094e-02f, -9.92288440e-02f, -1.45416602e-01f,
  -7.37068132e-02f, -7.49232993e-02f, -1.09783739e-01f, -7.45251104e-02f, -4.26111631e-02f, 5.81778288e-02f, 1.01795681e-02f, -1.88703351e-02f, 4.93981764e-02f, -4.50408347e-02f,
  -1.20103516e-01f, 1.14735171e-01f, 8.44538584e-03f, 1.42684639e-01f, 7.93659762e-02f, 2.67061770e-01f, -5.65829836e-02f, -4.00269404e-02f, 1.33512825e-01f, 9.06278789e-02f,
  7.02039897e-02f, 2.35329848e-02f, -6.77811652e-02f, 8.86138007e-02f, 1.30814001e-01f, 1.39707774e-01f, 2.39621084e-02f, 7.68383592e-02f, 3.13030750e-01f, 5.56054413e-02f,
  -3.44123803e-02f, 8.61781016e-02f, 6.45849928e-02f, 6.16304949e-02f, -6.79028258e-02f, -7.98392966e-02f, -1.57176569e-01f, -1.07051462e-01f, -5.03790565e-03f, 5.83110452e-02f,
  1.69549391e-01f, -3.47213410e-02f, -9.06287506e-02f, -1.36583090e-01f, -2.17083782e-01f, 1.34866247e-02f, -1.76531021e-02f, -9.77621078e-02f, -4.63837385e-02f, 3.37399058e-02f,
  -4.67417777e-01f, 4.28162128e-01f, 1.65748149e-01f, -1.17834054e-01f, 3.05996984e-02f, -7.53095970e-02f, 8.03498402e-02f, -9.60925296e-02f, -2.91270971e-01f, -1.33857861e-01f,
  -1.50057763e-01f, -4.31150943e-02f, -1.31794170e-01f, -9.04855505e-02f, 2.28576884e-01f, 6.91352263e-02f, -2.36877576e-02f, 1.22421458e-01f, -1.53497219e-01f, -2.72809714e-01f,
  -1.86116561e-01f, 2.32898176e-01f, 2.94107974e-01f, 1.91832900e-01f, 7.92576671e-02f, 3.68430644e-01f, -2.14637835e-02f, -7.07892776e-02f, 2.61376649e-01f, 1.65236622e-01f,
  -1.41494763e+00f, 5.94975591e-01f, -5.67228019e-01f, -7.23041117e-01f, -6.42787993e-01f, -5.51040649e-01f, 1.74707800e-01f, 2.80482084e-01f, 2.61459559e-01f, 7.25701809e-01f,
  2.47028664e-01f, -5.73863029e-01f, -6.48162216e-02f, -1.36664107e-01f, -4.05668736e-01f, 2.07057074e-01f, -3.80239129e-01f, -1.13835955e+00f, -1.24245429e+00f, -3.77494365e-01f,
  -6.74628615e-02f, -6.65216088e-01f, -1.03791630e+00f, -4.45649385e-01f, 3.24713230e-01f, -2.37288490e-01f, 2.43796706e-01f, -4.69639480e-01f, -1.91315085e-01f, -1.49329349e-01f,
  2.50881016e-01f, -3.35382044e-01f, -8.37163255e-02f, -3.26141030e-01f, 1.08844347e-01f, 3.18014175e-02f, -1.86498463e-02f, 3.16229463e-02f, 8.45957324e-02f, 2.15614811e-01f,
  -1.78683192e-01f, -8.69893134e-02f, -1.53236449e-01f, 3.47644910e-02f, -2.32319385e-01f, -1.76471308e-01f, 6.97611421e-02f, -1.20631903e-01f, -4.70695551e-03f, 3.66316676e-01f,
  2.23255262e-01f, -2.21092045e-01f, -1.07249297e-01f, 2.83398211e-01f, 1.89787522e-01f, -3.72661531e-01f, 4.16252971e-01f, 6.24303408e-02f, 4.31367680e-02f, 4.05268401e-01f,
  4.65680845e-02f, 1.57228380e-01f, -1.56366825e-02f, -6.13145083e-02f, 9.37096402e-02f, 4.00382280e-02f, -6.22742176e-02f, 9.89249796e-02f, -1.28071383e-01f, 1.18511200e-01f,
  1.58881158e-01f, 1.40973762e-01f, -4.51697186e-02f, 2.12067924e-02f, -2.23547709e-03f, -1.22149646e-01f, -2.18718842e-01f, 1.98084071e-01f, 6.17598742e-02f, -1.27594486e-01f,
  -5.32693267e-02f, 4.80537936e-02f, -2.52540689e-02f, 4.81789932e-02f, 1.72480829e-02f, 3.87042128e-02f, 6.44003646e-03f, -3.06284763e-02f, -1.37941986e-02f, -1.22534476e-01f,
  3.59750152e-01f, -5.36331713e-01f, 1.78338081e-01f, -7.96683654e-02f, 5.08306064e-02f, 1.65062487e-01f, -4.06344868e-02f, 2.32176911e-02f, -4.40261848e-02f, 5.83931617e-03f,
  -2.25709811e-01f, 4.27978784e-02f, -4.59806435e-02f, 1.83042139e-01f, -1.78006873e-01f, -5.85644320e-02f, 1.94081649e-01f, -1.03744857e-01f, -9.89975780e-02f, 2.16407657e-01f,
  2.43503839e-01f, -1.00703035e-02f, -4.17464487e-02f, 6.97759390e-02f, 1.28860340e-01f, -4.45972770e-01f, 1.30174711e-01f, 1.36466682e-01f, -8.54199827e-02f, 7.18916893e-01f,
  9.26722288e-01f, 3.36822957e-01f, -4.49413359e-01f, 6.53526783e-01f, 2.58991539e-01f, 3.59862357e-01f, 8.62826169e-01f, 5.15092850e-01f, 5.15726246e-02f, 2.93767661e-01f,
  -4.22875524e-01f, -9.33033109e-01f, -7.93624341e-01f, -7.78500319e-01f, -2.72349417e-01f, 3.29070985e-01f, 7.74365515e-02f, -3.43436897e-01f, -2.38208756e-01f, 1.92459390e-01f,
  1.59718975e-01f, 6.45028651e-01f, 6.44153237e-01f, 4.82604355e-02f, -8.40806663e-02f, -3.87619317e-01f, 1.47276089e-01f, 9.46917683e-02f, -2.11739287e-01f, -5.85606337e-01f,
  -3.04938406e-01f, -1.49016857e-01f, -2.43208438e-01f, -2.63880491e-01f, -2.02256709e-01f, 5.78193404e-02f, 1.53026417e-01f, -9.30657163e-02f, -6.72548935e-02f, -1.25564158e-01f,
  -2.68889695e-01f, -2.33836427e-01f, -2.89328665e-01f, -1.15598097e-01f, 3.51455986e-01f, 5.40971085e-02f, 3.22277583e-02f, -7.35995248e-02f, -2.95537680e-01f, -3.21907640e-01f,
  -4.28536803e-01f, -2.27304220e-01f, -1.07491136e-01f, -7.98703209e-02f, -3.15186411e-01f, -3.55042994e-01f, -1.13147326e-01f, -2.93682337e-01f, -2.99323291e-01f, 1.17274113e-01f,
  -1.13376468e-01f, 7.16632828e-02f, -8.90388563e-02f, 8.11349750e-02f, 1.36365727e-01f, -3.72387655e-02f, -3.74172777e-02f, 5.55806048e-02f, 1.34423345e-01f, 2.00833887e-01f,
  -1.16120294e-01f, 6.51480258e-02f, 2.91038863e-02f, 6.42046630e-02f, -2.36723144e-02f, -6.45767376e-02f, -3.18288952e-02f, -5.59712434e-03f, -8.18358883e-02f, 4.69886400e-02f,
  -8.28902051e-02f, -5.52160032e-02f, 1.00902326e-01f, -8.09410214e-02f, -5.84366359e-02f, -1.66758999e-01f, -7.47443587e-02f, -4.03114185e-02f, 7.91470893e-03f, 8.95599499e-02f,
  7.33197629e-01f, -5.03442228e-01f, 1.21211231e-01f, -1.88269950e-02f, 2.80934349e-02f, -1.09418653e-01f, -5.73373735e-02f, -1.25873208e-01f, -9.90759674e-03f, -2.61733364e-02f,
  -8.34929198e-02f, -8.91564600e-03f, -2.26090904e-02f, 9.54710618e-02f, 2.12344170e-01f, 1.28620481e-02f, 4.13741209e-02f, -1.30631596e-01f, -3.40708420e-02f, 4.69287038e-02f,
  1.77245244e-01f, 3.37727070e-01f, 3.33184958e-01f, 2.10096300e-01f, -1.37106646e-02f, 1.29871607e-01f, 2.84438103e-01f, 8.89163762e-02f, 1.36641994e-01f, 8.57429028e-01f,
  -1.22536910e+00f, 1.12056114e-01f, -3.91629726e-01f, 2.28940353e-01f, 4.91826206e-01f, 2.40578979e-01f, 2.71269143e-01f, -1.80108361e-02f, 1.34905964e-01f, 1.51376784e-01f,
  1.62521824e-01f, 3.74642581e-01f, 4.19149280e-01f, 3.30190182e-01f, 1.53985217e-01f, 3.45549941e-01f, 4.69794393e-01f, -2.06239074e-01f, -2.70180374e-01f, 1.47607535e-01f,
  5.33787608e-01f, -3.34607586e-02f, -4.69299406e-01f, -1.05506964e-01f, 2.39862144e-01f, 4.30410922e-01f, 1.37655050e-01f, 1.48123264e-01f, 3.22960794e-01f, 3.59089136e-01f,
  1.15843549e-01f, -3.11100334e-01f, 2.15632051e-01f, 2.27644071e-01f, -1.37060553e-01f, -2.23922253e-01f, -5.70018552e-02f, -3.28623831e-01f, -1.22913018e-01f, 1.24932028e-01f,
  8.19569826e-02f, -1.85613394e-01f, -1.09420735e-02f, -1.11256078e-01f, -2.06167445e-01f, -1.90870076e-01f, -1.95844099e-01f, -1.03982650e-01f, 2.44585127e-02f, 6.45958781e-02f,
  1.34684563e-01f, -3.73041369e-02f, -1.47793636e-01f, -1.92994103e-02f, 5.95017746e-02f, 1.52400583e-01f, -9.57682654e-02f, -8.58240202e-02f, -1.21266373e-01f, -1.99973360e-01f,
  1.47936001e-01f, -9.07112882e-02f, 4.06080298e-02f, 5.90080544e-02f, 1.73324630e-01f, -7.14748073e-03f, 5.38811870e-02f, 2.08575249e-01f, -2.55228020e-02f, -1.78328529e-01f,
  5.05998619e-02f, 1.93539068e-01f, -1.82037592e-01f, -2.75531989e-02f, 2.73065418e-02f, -2.30553210e-01f, -1.76613331e-01f, 1.37021979e-02f, -1.78787522e-02f, -1.67351123e-02f,
  2.75969505e-02f, -9.20931399e-02f, -3.20206642e-01f, -6.81422278e-02f, -5.25625572e-02f, -4.15189974e-02f, 1.77265219e-02f, -3.97434980e-02f, 5.62257580e-02f, -6.35979325e-03f,
  2.76057154e-01f, -2.35501826e-02f, 2.34482542e-01f, -3.65032554e-02f, -1.04186691e-01f, -2.52905428e-01f, 2.15839520e-01f, -4.79046814e-02f, 5.92840500e-02f, 3.94601375e-02f,
  -6.03742860e-02f, -1.54092357e-01f, -7.40284249e-02f, -1.09639503e-01f, -1.83437318e-01f, -1.05926096e-01f, 3.99313605e-04f, -5.87833188e-02f, 2.14237906e-02f, -8.33167657e-02f,
  -7.26276636e-03f, -8.90568197e-02f, 3.69119295e-03f, 4.33790348e-02f, 1.41572729e-01f, 1.20690115e-01f, -7.78679829e-03f, -7.47706294e-02f, -1.68643862e-01f, -1.02786884e-01f,
  6.00323081e-01f, 5.00169583e-02f, -8.77661072e-03f, 1.55311115e-02f, -5.29570162e-01f, -7.92643905e-01f, -1.13344479e+00f, -5.36197782e-01f, -2.28942379e-01f, -6.14921451e-01f,
  -4.87634540e-02f, 9.60974336e-01f, 1.19138563e+00f, 6.11549318e-01f, 2.61101037e-01f, -6.96456313e-01f, -9.87538576e-01f, -9.10936575e-03f, -1.16941981e-01f, -6.43771231e-01f,
  -5.27436495e-01f, -2.03022704e-01f, 5.21486551e-02f, -6.87086210e-02f, -1.61641255e-01f, 3.99573296e-01f, -1.41364992e-01f, -1.27733946e-01f, -3.84788573e-01f, -2.56029278e-01f,
  6.59029901e-01f, -2.32625186e-01f, -1.51123241e-01f, -3.90779413e-02f, -3.99832055e-02f, -1.09430768e-01f, -1.52727764e-04f, -5.34777269e-02f, -1.58451229e-01f, -2.31938869e-01f,
  3.46026309e-02f, -6.41761720e-02f, 1.56882908e-02f, 1.37915641e-01f, -2.70637255e-02f, 3.59436795e-02f, -5.75384349e-02f, -2.22719073e-01f, -2.44300485e-01f, -1.00812711e-01f,
  -5.88919409e-03f, -1.90933809e-01f, 2.50598907e-01f, -5.86518198e-02f, -1.19637981e-01f, 2.32332900e-01f, -3.56493369e-02f, -2.44762897e-01f, -1.96868271e-01f, -2.64543779e-02f,
  -1.18921027e-01f, 1.87856078e-01f, -8.20296481e-02f, -7.41781443e-02f, -3.25908810e-02f, 1.51960939e-01f, 1.45960506e-02f, -1.34225227e-02f, -5.34473658e-02f, 1.70175388e-01f,
  -9.79583338e-03f, 4.96093445e-02f, -7.37136677e-02f, 6.05445504e-02f, 9.06325504e-02f, -7.73112252e-02f, -5.29160015e-02f, -1.32616416e-01f, 1.91347182e-01f, -1.28702700e-01f,
  -5.47247194e-02f, -6.96236193e-02f, 6.92453310e-02f, -2.18231138e-02f, -2.67807633e-01f, 5.68169169e-02f, 2.26328764e-02f, 5.70967831e-02f, 1.49462625e-01f, -1.69305593e-01f,
  8.74382675e-01f, -1.86221495e-01f, 2.21627876e-01f, -3.84040475e-02f, -1.31050065e-01f, -1.19554281e-01f, 1.69202238e-02f, -2.04626009e-01f, 1.73774406e-01f, -2.31394861e-02f,
  -2.69195884e-01f, 6.57187253e-02f, 8.47305730e-03f, -1.52801290e-01f, -2.18476072e-01f, 6.82051107e-02f, -1.31988019e-01f, 4.87611666e-02f, -4.03998673e-01f, -1.49557799e-01f,
  -2.33472705e-01f, -1.39223143e-01f, 5.81914663e-01f, 1.76637024e-01f, -2.46983524e-02f, 2.55636841e-01f, 3.34237307e-01f, 7.17665702e-02f, 1.79976374e-01f, 1.69234440e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.02691376e+00f, 1.01208496e+00f, 9.36047077e-01f, 8.44013691e-01f, 1.18065560e+00f, 1.46955216e+00f, 5.16179860e-01f, 6.86131418e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -5.90534449e-01f, 9.22712162e-02f, 1.61631703e-01f, 1.18043069e-02f, -4.97512281e-01f, -5.69659531e-01f, -4.62549716e-01f, -8.92922096e-03f, -7.08251715e-01f, -9.40870583e-01f,
  -8.06832373e-01f, 2.12775230e-01f, 1.05524570e-01f, 1.40881673e-01f, -1.13814630e-01f, 7.27462471e-01f, -3.64539921e-01f, -7.54776657e-01f, 2.80677736e-01f, -2.08775520e-01f,
  -3.04777455e-02f, 1.41941145e-01f, -2.69903302e-01f, -4.84348424e-02f, 1.04855871e+00f, -4.48330879e-01f, -6.62110388e-01f, 1.67370588e-01f, -1.45766735e-01f, -5.98544061e-01f,
  -1.03696537e+00f, -2.74053425e-01f, -2.42465243e-01f, -2.36486532e-02f, 2.12873012e-01f, 2.34608069e-01f, 1.94200352e-01f, -4.50614482e-01f, -1.99726358e-01f, -1.10363357e-01f,
  2.54109144e-01f, 2.20222592e-01f, -8.38344544e-02f, 1.64643824e-01f, 1.18292928e-01f, 4.36445117e-01f, 3.78626615e-01f, -2.65467670e-02f, -3.18428427e-01f, -4.88656729e-01f,
  4.86900657e-02f, -5.39984465e-01f, -2.41059050e-01f, -1.25001237e-01f, -2.75494635e-01f, -1.89172253e-01f, 7.28250921e-01f, -2.40211415e+00f, 5.37432492e-01f, 7.57977307e-01f,
  -1.07950425e+00f, -8.97369802e-01f, 6.20695464e-02f, 1.15614951e+00f, 4.23606277e-01f, -3.51484805e-01f, -8.61776546e-02f, 8.60204875e-01f, -1.93461284e-01f, 1.91613823e-01f,
  4.49652135e-01f, 2.57329971e-01f, 4.42482121e-02f, 4.39038515e-01f, 3.17034543e-01f, 4.52626526e-01f, 4.44834419e-02f, -4.33622867e-01f, -6.63440108e-01f, -5.22972941e-01f,
  -5.50268888e-01f, 3.81184608e-01f, 3.03723633e-01f, 1.47737443e-01f, 7.84882188e-01f, 5.34803629e-01f, -2.78609067e-01f, -1.97083414e-01f, 9.27427113e-01f, 1.42894676e-02f,
  -6.38001382e-01f, 1.23534478e-01f, -1.86103094e+00f, -1.39052629e+00f, -9.22292888e-01f, -1.02937430e-01f, 5.25369942e-01f, 3.83236283e-03f, 3.22673887e-01f, -2.37249494e+00f,
  2.95825183e-01f, 2.32526749e-01f, 4.70306128e-01f, 1.15282737e-01f, 5.80369115e-01f, -1.72981262e-01f, 9.24234614e-02f, -7.96872735e-01f, -4.48845476e-01f, -2.72717625e-01f,
  -5.97224869e-02f, 7.19142914e-01f, 3.49858582e-01f, -7.63149321e-01f, -3.02422553e-01f, -2.10977480e-01f, -2.70034224e-01f, -3.79850537e-01f, 9.23094526e-02f, 8.92353415e-01f,
  -2.63904333e-01f, 5.34570813e-01f, -1.46606624e+00f, -5.03794968e-01f, 6.29541039e-01f, -1.18899834e+00f, -2.57810593e-01f, -1.18851924e+00f, -2.10193783e-01f, 1.24655388e-01f,
  -2.75408834e-01f, 1.52023721e+00f, -2.33369917e-01f, 3.68827760e-01f, 2.18579210e-02f, -1.92035317e-01f, -4.72483188e-01f, 3.51438820e-01f, 1.81164950e-01f, 4.82886612e-01f,
  3.30438167e-01f, -1.32459000e-01f, 5.76805137e-02f, -1.23514988e-01f, 2.29741350e-01f, 9.06329095e-01f, -5.83461583e-01f, -1.71688825e-01f, -1.07798778e-01f, -2.34381273e-01f,
  -3.16746235e-01f, 4.73807603e-02f, -8.54741216e-01f, 3.74483019e-01f, -9.35862139e-02f, -2.25166008e-01f, 5.68427622e-01f, -1.01564300e+00f, -2.10712790e-01f, 5.05698472e-02f,
  6.70865700e-02f, -3.56110223e-02f, -2.58358330e-01f, 1.75368845e-01f, 4.27877754e-02f, 3.44896466e-01f, -1.37319088e-01f, 1.91199750e-01f, 1.71391830e-01f, -1.24268390e-01f,
  2.10096151e-01f, 4.68746394e-01f, 1.79948479e-01f, 3.14291179e-01f, 1.23910701e+00f, -1.54872751e+00f, 9.69678015e-02f, -3.60605806e-01f, -4.33527499e-01f, 4.78502095e-01f,
  -8.01939666e-01f, -5.26826143e-01f, -1.09184131e-01f, -9.73373652e-02f, -3.16355407e-01f, -1.50604999e+00f, -1.01396811e+00f, -7.83167779e-04f, 3.42297316e-01f, 9.76549149e-01f,
  -1.31556904e-02f, -6.82275444e-02f, -4.17191125e-02f, 4.86505657e-01f, 3.26120377e-01f, -1.26228786e+00f, 7.82106400e-01f, -6.79975986e-01f, 2.75071889e-01f, 8.58798102e-02f,
  5.58817565e-01f, -8.11506510e-01f, 2.26827443e-01f, -4.25830752e-01f, -8.18355143e-01f, -1.49147585e-01f, -7.11113334e-01f, -1.31435478e+00f, 7.86689103e-01f, 3.46478283e-01f,
  3.86731058e-01f, 1.36379495e-01f, 1.13958992e-01f, 9.68214691e-01f, 5.68331420e-01f, -5.33699751e-01f, 1.89201400e-01f, -5.48868537e-01f, 7.02469409e-01f, -1.22666645e+00f,
  -1.08499777e+00f, -2.16985047e-01f, -8.09517503e-01f, -5.13785005e-01f, -3.67134959e-01f, -3.86942208e-01f, -4.01449502e-01f, 1.72472939e-01f, -1.37257099e-03f, -1.29206032e-01f,
  -1.22761630e-01f, -5.94541669e-01f, 1.10005988e-02f, -1.24673687e-01f, -1.11110523e-01f, 1.31937474e-01f, 1.63542911e-01f, -3.91009808e-01f, 4.30035710e-01f, 2.66223967e-01f,
  5.60968280e-01f, 5.67609608e-01f, 1.79671064e-01f, 2.94652492e-01f, 1.36815071e-01f, -4.43361372e-01f, 5.27260482e-01f, 3.42484862e-01f, -1.05665505e+00f, 4.94421393e-01f,
  -8.65010202e-01f, -5.85902274e-01f, -7.61969566e-01f, 7.89863020e-02f, 9.92590249e-01f, -4.23857301e-01f, -4.05550078e-02f, 1.89793855e-01f, 2.41599366e-01f, 4.31796759e-01f,
  -1.61795884e-01f, 4.36475724e-02f, 2.30271034e-02f, 3.36688943e-03f, -2.65288413e-01f, 2.96633244e-02f, -3.44616145e-01f, 2.24737793e-01f, -3.86607677e-01f, 1.44815147e-01f,
  -9.88677144e-01f, 6.63247779e-02f, 3.19997847e-01f, -4.02195543e-01f, 9.72340479e-02f, -2.07748860e-01f, 6.91914141e-01f, 5.19452870e-01f, 3.95712286e-01f, 5.44486940e-01f,
  -9.34463263e-01f, -2.48756036e-01f, -9.00737107e-01f, 3.62168163e-01f, -1.37312806e+00f, 1.44144762e+00f, -3.88701826e-01f, -6.33261919e-01f, 2.92316049e-01f, -4.49169613e-02f,
  5.00965118e-01f, -8.22221398e-01f, 3.72541368e-01f, -3.36553633e-01f, -1.65598020e-01f, 3.62578779e-01f, 6.60081953e-02f, 9.88919437e-01f, -2.53715873e-01f, -6.72913909e-01f,
  6.56856000e-01f, -5.09913623e-01f, 3.47915411e-01f, -1.38330805e+00f, -1.03325856e+00f, 6.03332579e-01f, -4.24638033e-01f, 2.41110340e-01f, -2.19679400e-01f, -1.09795749e+00f,
  -4.98009652e-01f, -6.24149978e-01f, -1.07814431e+00f, 8.20516467e-01f, 1.58798561e-01f, -1.20491028e+00f, -1.32836330e+00f, -1.07493842e+00f, 1.00736052e-01f, 3.30721676e-01f,
  4.75688696e-01f, -2.98695955e-02f, -7.91355073e-01f, -2.46404186e-01f, -4.63087022e-01f, 1.90307170e-01f, 3.14060636e-02f, -5.35077043e-02f, -4.18953039e-03f, 3.31869960e-01f,
  1.93151563e-01f, -2.05658704e-01f, 3.34801078e-01f, 5.96129447e-02f, -1.12077236e+00f, 1.35152042e+00f, -5.35024226e-01f, -3.90062898e-01f, 1.16472617e-01f, -2.85404444e-01f,
  7.42569029e-01f, -4.20492858e-01f, 4.81828868e-01f, 4.67007339e-01f, -1.39198124e+00f, -1.37548161e+00f, -5.57177365e-01f, -1.22874188e+00f, 3.46285909e-01f, -5.01523167e-03f,
  2.27024749e-01f, 1.15796936e+00f, -2.55067497e-01f, -3.24294120e-01f, -3.09088260e-01f, 5.83892822e-01f, -8.76056075e-01f, 5.90607822e-01f, -1.86888874e-02f, 1.88083842e-01f,
  -1.71233252e-01f, -1.79766908e-01f, 3.40416551e-01f, 3.29136878e-01f, -2.17289016e-01f, 7.43075073e-01f, 9.08503771e-01f, 2.10656118e+00f, 1.00236781e-01f, 1.21097220e-03f,
  1.26699030e-01f, -1.09644376e-01f, -6.46884501e-01f, 4.87004429e-01f, 2.76219517e-01f, -2.00502723e-02f, -1.13903165e+00f, 3.03211361e-01f, 7.51913071e-01f, -1.29513860e+00f,
  -1.12739658e+00f, 4.28674638e-01f, -7.49899149e-01f, -4.44011122e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.73719817e-01f, -5.69048226e-01f, 4.33495283e-01f, -8.08442891e-01f, 5.01704402e-02f, 2.90883511e-01f, 5.77605546e-01f, 4.64326292e-02f, -1.54470235e-01f, 1.31973913e-02f,
  -7.39431739e-01f, 2.93760836e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    