/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.75793514e-01f, -9.09067094e-02f, -1.99379504e-01f, 2.18805730e-01f, 6.96990639e-02f, -1.31532043e-01f, -2.49613196e-01f, -1.51792258e-01f, 1.11252211e-01f, -9.47650820e-02f,
  -8.09363723e-02f, 1.70086354e-01f, 7.66387284e-02f, 1.93946570e-01f, -2.01309677e-02f, 2.15076488e-02f, 1.71870604e-01f, 1.61806405e-01f, -3.91183347e-02f, 8.88576880e-02f,
  2.22077250e-01f, 2.05207035e-01f, 1.67238340e-01f, 1.81301877e-01f, 1.79785535e-01f, 1.92207947e-01f, 4.23968993e-02f, 2.25063756e-01f, 1.21952944e-01f, 3.49312693e-01f,
  -1.31394252e-01f, 1.79929379e-02f, 6.34046644e-02f, 1.86777055e-01f, -2.38197725e-02f, 1.68555558e-01f, -1.41531797e-02f, 1.42250374e-01f, 8.02740157e-02f, 4.62240577e-02f,
  1.62933841e-01f, 1.31629556e-01f, 1.07453510e-01f, 1.59309193e-01f, -3.56157906e-02f, 1.71864375e-01f, 7.76539519e-02f, 1.07552156e-01f, -7.53503665e-02f, 4.84470837e-02f,
  1.12137578e-01f, 1.20099589e-01f, 6.90885037e-02f, 6.54133558e-02f, 6.80657150e-03f, 2.22511768e-01f, 9.15447157e-03f, 9.94950831e-02f, -7.03932568e-02f, 1.44103408e-01f,
  -3.48212719e-02f, 5.84146939e-03f, 1.25152711e-02f, -1.18775621e-01f, 1.94836711e-03f, -1.35531183e-02f, 1.91768467e-01f, 5.11272140e-02f, -6.61328360e-02f, 5.22415061e-03f,
  1.33267706e-02f, -1.45930424e-01f, -7.91342929e-02f, -1.83638260e-02f, -6.70415089e-02f, -6.35724962e-02f, 2.72335089e-03f, -3.73649038e-02f, -1.09634669e-02f, -4.24980298e-02f,
  2.36609876e-02f, -4.05283161e-02f, -2.88449489e-02f, 1.16404472e-02f, -1.00185322e-02f, -3.53564247e-02f, -6.04445525e-02f, 6.60059825e-02f, -1.92176625e-02f, 8.71666595e-02f,
  -1.39555037e-01f, 5.94580434e-02f, 6.41748533e-02f, -1.05936065e-01f, 5.10359220e-02f, 2.70671062e-02f, 5.78677049e-03f, -1.21237757e-02f, 8.07414763e-03f, -7.61646181e-02f,
  -2.06975713e-02f, 6.39618486e-02f, 3.87454033e-02f, 8.53902102e-03f, -1.51958466e-02f, 5.68057895e-02f, 1.66480709e-02f, 1.20760743e-02f, -1.04450464e-01f, 1.30601116e-02f,
  3.63811068e-02f, -1.76408529e-01f, -1.01340570e-01f, -9.52227563e-02f, 4.35730852e-02f, -4.66214865e-03f, 2.94775013e-02f, -9.00111049e-02f, -5.83329275e-02f, -2.06443548e-01f,
  5.46370558e-02f, -3.66286188e-01f, -1.14552088e-01f, -1.09174646e-01f, -1.09464325e-01f, 3.60721420e-03f, -1.05197653e-01f, 5.73759340e-02f, 1.98621497e-01f, -1.13914512e-01f,
  -1.10312022e-01f, 9.04216617e-02f, 1.55277073e-01f, 1.86848015e-01f, 7.81530216e-02f, -1.18779376e-01f, -7.71537647e-02f, 4.42521274e-02f, 2.94222623e-01f, 2.33340904e-01f,
  2.65131500e-02f, -3.21447216e-02f, 3.09568141e-02f, 1.70483857e-01f, -9.39578265e-02f, 1.25492409e-01f, -1.19117133e-01f, -6.32650256e-02f, -9.85469222e-02f, -4.58146036e-01f,
  -8.55649486e-02f, -2.09187791e-01f, 1.37706861e-01f, 5.45036644e-02f, -2.92574670e-02f, 1.05631009e-01f, 7.11530969e-02f, -4.24287561e-03f, 1.66448161e-01f, 8.94912556e-02f,
  4.10771593e-02f, 2.48412527e-02f, 9.73687544e-02f, -3.70212644e-02f, -4.28407490e-02f, 4.42842804e-02f, 2.83453446e-02f, 5.57190068e-02f, 6.52917055e-03f, 7.05844313e-02f,
  -1.46147251e-01f, -8.25135261e-02f, 1.35015491e-02f, -7.96127543e-02f, 9.01627541e-03f, 8.69669318e-02f, -1.11758634e-01f, -1.02714904e-01f, -3.61692655e-04f, -1.45119324e-01f,
  -5.07023884e-03f, 2.00407882e-03f, 2.66581643e-02f, -1.43949781e-03f, 5.47000729e-02f, 1.55284395e-02f, -2.46501397e-02f, 2.86896564e-02f, 1.40232937e-02f, -3.21223810e-02f,
  4.15948518e-02f, 7.64328688e-02f, -8.06572568e-03f, 7.40595832e-02f, -5.72035052e-02f, -1.53005007e-03f, -3.35693918e-02f, 3.05047221e-02f, 1.13720469e-01f, 6.98680803e-02f,
  1.04411431e-01f, -6.14514500e-02f, -9.11966488e-02f, 1.31485639e-02f, 2.03937889e-04f, 5.47956936e-02f, -5.77463545e-02f, 1.19141787e-01f, 1.07068628e-01f, 1.23826414e-02f,
  2.34963834e-01f, 2.83235162e-02f, 1.05615459e-01f, -3.67817171e-02f, -3.60405166e-03f, 1.45047814e-01f, -3.75397969e-03f, 6.38844743e-02f, 1.69963669e-03f, 1.25976074e-02f,
  3.55913676e-02f, 1.04132742e-01f, -9.66851041e-03f, -8.59527662e-02f, 1.46364704e-01f, 4.30448428e-02f, 8.39188546e-02f, -2.38081925e-02f, 6.84509007e-03f, -4.54490408e-02f,
  -1.63946394e-02f, -3.28877345e-02f, 4.07392941e-02f, 6.50798231e-02f, 1.92852151e-02f, 1.31816089e-01f, 7.15456381e-02f, -2.86266650e-03f, 1.43819809e-01f, 1.20614819e-01f,
  3.03793550e-01f, -7.44410157e-02f, 8.49456564e-02f, -5.80642670e-02f, -9.91800353e-02f, -1.59939185e-01f, -7.43685588e-02f, 4.86135110e-02f, 4.32941131e-02f, 1.12210080e-01f,
  -9.07434970e-02f, -1.54891104e-01f, 6.63509918e-03f, -1.61361799e-01f, -1.65930055e-02f, 6.57109842e-02f, -7.49248490e-02f, 6.73927292e-02f, -5.98300584e-02f, -1.49486706e-01f,
  -2.11180449e-01f, 1.47304460e-01f, 1.59451142e-01f, 5.69247827e-02f, 1.15262374e-01f, 6.13440871e-02f, 4.79790159e-02f, 9.63598415e-02f, -1.60406064e-02f, 1.40172821e-02f,
  9.60196033e-02f, 3.45486701e-02f, -1.92468673e-01f, -1.15442574e-01f, -8.53246301e-02f, -4.06851321e-02f, -1.02354646e-01f, 1.38987703e-02f, -1.54800825e-02f, 2.87734270e-02f,
  -4.58041951e-02f, 1.65121094e-03f, 2.95847971e-02f, 5.95370308e-03f, 3.05941910e-03f, 2.27539684e-03f, -7.28262737e-02f, -1.41792297e-02f, -9.31881294e-02f, -2.17422638e-02f,
  -1.57570273e-01f, -5.83249927e-02f, -1.00179642e-01f, -8.76343548e-02f, -6.64324919e-03f, -1.09484240e-01f, -5.30777276e-02f, 5.01409322e-02f, -7.02316836e-02f, 2.35009879e-01f,
  -1.06438948e-02f, 8.15264694e-03f, 5.23195043e-02f, 7.91388452e-02f, 1.39181480e-01f, 9.70979035e-02f, 2.14452017e-02f, 3.49897556e-02f, 1.04362443e-01f, 1.51307449e-01f,
  -4.05961461e-02f, 8.63399133e-02f, 1.37367934e-01f, 5.31353578e-02f, 5.67910448e-02f, 1.12092704e-01f, 6.15113229e-02f, 4.19676490e-02f, 2.85463315e-02f, 1.95887331e-02f,
  6.99758821e-04f, 5.75389527e-02f, -1.28391599e-02f, 1.49795294e-01f, 1.47686689e-03f, 1.21031366e-01f, 1.66791007e-01f, 1.36596963e-01f, 6.45960867e-02f, 8.53069350e-02f,
  -1.78497331e-03f, -2.77260363e-01f, 1.04507938e-01f, -5.09720296e-02f, -7.93541372e-02f, -1.13374181e-01f, -9.61418748e-02f, -1.02876686e-01f, -1.20443404e-02f, -8.80546570e-02f,
  -1.42563265e-02f, 1.09290024e-02f, -6.87383786e-02f, -1.86407454e-02f, -9.68090966e-02f, 4.79942486e-02f, 5.89666935e-03f, 4.97819419e-05f, -1.10771835e-01f, -1.18830018e-01f,
  -4.13816161e-02f, 6.34357780e-02f, -1.60381440e-02f, -1.34686176e-02f, 7.78274834e-02f, 4.76286672e-02f, -5.68521172e-02f, -1.60822077e-04f, 2.00963393e-02f, 3.27628821e-01f,
  3.66854638e-01f, 8.03064629e-02f, 3.07691216e-01f, 1.53932348e-01f, -1.38072848e-01f, -1.13380909e-01f, -5.12130652e-03f, -6.60005510e-02f, -8.56663063e-02f, 1.76098213e-01f,
  -9.98427868e-02f, -8.12196955e-02f, -8.18115426e-04f, -7.73740634e-02f, -4.62910607e-02f, 7.71929920e-02f, 1.76295072e-01f, 2.01133177e-01f, -2.30610017e-02f, -1.08789168e-01f,
  -2.31777057e-01f, 5.80859296e-02f, 3.94814946e-02f, 3.07165664e-02f, 1.01619102e-01f, -6.31052554e-02f, 9.60887000e-02f, -1.40664075e-02f, -2.06512795e-03f, 2.66680449e-01f,
  1.02597900e-01f, -2.56805141e-02f, 1.70683973e-02f, 7.70490095e-02f, 8.29757284e-03f, 1.64146036e-01f, 6.83790669e-02f, 2.28429716e-02f, -5.65170236e-02f, 8.17318335e-02f,
  6.98626190e-02f, -1.03196185e-02f, 8.44261944e-02f, 3.36705297e-02f, 1.13310263e-01f, -3.20720859e-02f, -2.61005666e-02f, 1.00419797e-01f, 3.65080200e-02f, -3.19320597e-02f,
  -1.26947433e-01f, -3.88921760e-02f, 1.07728578e-01f, -8.98946375e-02f, 2.21556239e-02f, 1.29846618e-01f, 6.82784319e-02f, -2.90831290e-02f, 4.04146947e-02f, 9.96878818e-02f,
  -4.74992354e-04f, 7.27177262e-02f, -1.25599792e-02f, -1.17270187e-01f, 1.97980087e-02f, -3.55274789e-02f, -5.13523910e-03f, 6.68841898e-02f, -9.86143723e-02f, 5.94814308e-03f,
  -2.96471957e-02f, -3.44724990e-02f, -1.55713754e-02f, 2.98595764e-02f, -1.26154378e-01f, -2.68115886e-02f, -7.69872293e-02f, 3.84225888e-04f, -1.08644627e-01f, -2.88386946e-03f,
  -4.66302373e-02f, -2.16823742e-02f, -1.90903209e-02f, -5.26044657e-03f, 4.08344902e-03f, 2.98256073e-02f, 3.51793366e-03f, -7.48925507e-02f, -7.63016790e-02f, 2.67411172e-02f,
  5.44827012e-03f, -2.70051509e-01f, 1.42509118e-01f, -7.81456195e-03f, 8.52938145e-02f, 2.33990815e-03f, 6.85008243e-02f, 3.19853425e-04f, 2.17875782e-02f, 1.20914951e-01f,
  9.21091586e-02f, 1.27168685e-01f, 5.50964102e-02f, -4.19346988e-03f, 8.80964398e-02f, -3.41720171e-02f, -1.42986000e-01f, 6.39953613e-02f, -3.82770342e-03f, 1.05975689e-02f,
  -2.13375781e-02f, 2.69335741e-03f, -2.75285151e-02f, 1.23745114e-01f, 4.64218594e-02f, -3.64466645e-02f, 1.30007222e-01f, 1.41168192e-01f, -5.11453599e-02f, 1.56208783e-01f,
  -5.50325572e-01f, 8.34614858e-02f, 9.91781652e-02f, -1.26441568e-01f, -9.51889902e-03f, -1.34119779e-01f, -7.31332004e-02f, -1.26650512e-01f, 1.54034086e-02f, 1.65110439e-01f,
  1.34353206e-01f, 2.09258586e-01f, 2.72582203e-01f, 1.18618220e-01f, -7.83905610e-02f, 1.24337129e-01f, 4.62966077e-02f, -4.07041330e-03f, -1.38921544e-01f, -4.25413251e-02f,
  1.11593753e-01f, -3.06197995e-04f, -4.17842194e-02f, -8.03752765e-02f, 2.09265560e-01f, 1.50121927e-01f, 1.98836684e-01f, -2.05214322e-02f, -2.52429061e-02f, 1.99271843e-01f,
  2.36728221e-01f, 2.15913355e-03f, 2.41490796e-01f, 1.58087671e-01f, 2.71955937e-01f, 1.05929986e-01f, 6.50955141e-02f, 5.13175055e-02f, 1.89393580e-01f, 1.78524539e-01f,
  1.32081926e-01f, 1.58792630e-01f, 1.99861035e-01f, 2.21936733e-01f, 1.41446918e-01f, 1.66979432e-01f, 9.28543955e-02f, 1.17197841e-01f, 1.13230929e-01f, 2.60132492e-01f,
  2.38711044e-01f, 1.32573098e-01f, 1.52361646e-01f, 1.95061207e-01f, 1.63002178e-01f, 9.08699930e-02f, 2.35725805e-01f, 1.41401708e-01f, 9.79969427e-02f, 1.40040621e-01f,
  -2.68102158e-02f, -8.30543488e-02f, -1.23890102e-01f, -2.23525390e-02f, -1.27646595e-01f, -1.27660081e-01f, -1.03209205e-01f, -1.25511726e-02f, -1.04043171e-01f, -1.48742959e-01f,
  -7.25513101e-02f, -1.52923778e-01f, -1.29723445e-01f, -1.29080281e-01f, -1.58802494e-02f, -5.80925792e-02f, -2.18979895e-01f, -1.42398566e-01f, -1.90357625e-01f, -7.31869563e-02f,
  -1.28034502e-01f, -1.57991961e-01f, -2.53644269e-02f, -3.43430080e-02f, -1.02309451e-01f, -5.09202480e-02f, -1.09225214e-01f, -9.38863158e-02f, -4.56627458e-02f, -1.28616944e-01f,
  2.18462527e-01f, 1.92716077e-01f, 1.80596367e-01f, 1.55544952e-01f, 8.60212296e-02f, 1.85292780e-01f, 1.38538718e-01f, 2.07151935e-01f, 1.98590919e-01f, 7.43657798e-02f,
  1.20540589e-01f, 1.03696294e-01f, 1.93609759e-01f, 1.74646124e-01f, 1.31461695e-01f, 4.33299839e-02f, 1.61960915e-01f, 8.32573846e-02f, 2.05574527e-01f, 2.63804197e-01f,
  1.85576648e-01f, 7.09800199e-02f, 9.72926840e-02f, 1.22576378e-01f, 9.94523764e-02f, 8.60698074e-02f, 1.93855301e-01f, 1.74936563e-01f, 7.02676848e-02f, 1.80214673e-01f,
  2.96764672e-01f, -4.64457244e-01f, -1.76565908e-02f, -4.15002033e-02f, -1.07212253e-01f, 8.50250572e-03f, -1.71026587e-01f, -6.18364774e-02f, 1.69756869e-03f, -1.72689840e-01f,
  -1.45732149e-01f, 7.72500187e-02f, -2.44710557e-02f, 1.05782934e-02f, 7.37881884e-02f, -1.46977410e-01f, -6.23607375e-02f, 1.65544376e-01f, 2.64556646e-01f, 5.24155870e-02f,
  3.47733591e-03f, 1.12365119e-01f, 9.77491587e-02f, 3.58970352e-02f, -1.99728040e-03f, 1.11269355e-01f, -1.10492498e-01f, -1.06090479e-01f, -6.59714937e-02f, -2.11243004e-01f,
  -4.44000363e-02f, -7.23023713e-02f, 5.58444709e-02f, -5.92391901e-02f, -1.68978244e-01f, -5.25039248e-02f, -1.05193704e-02f, -6.87345117e-02f, -9.31511000e-02f, 4.47551981e-02f,
  -1.69158712e-01f, -8.24848637e-02f, -1.06866032e-01f, 4.32751700e-02f, 2.38006227e-02f, 4.18106429e-02f, -2.28397604e-02f, 4.41886745e-02f, 2.20024418e-02f, 9.89938155e-04f,
  -2.08169878e-01f, -8.22555795e-02f, -1.83239743e-01f, 2.52790004e-03f, 2.93482258e-03f, 3.21664512e-02f, -1.25114128e-01f, -1.26903087e-01f, -5.88118657e-03f, -1.35255978e-01f,
  4.38028984e-02f, 3.65213193e-02f, -6.98859617e-02f, -2.36837845e-02f, 1.56954639e-02f, 2.64058984e-03f, 3.57474461e-02f, 1.08826935e-01f, 5.99162206e-02f, 2.41107270e-02f,
  2.87806503e-02f, 3.69397551e-02f, 1.17375210e-01f, -1.29391125e-03f, 3.81759927e-02f, 4.28398773e-02f, 1.34406179e-01f, -1.82430800e-02f, 6.57800734e-02f, 3.18759121e-02f,
  4.02261391e-02f, 8.72851524e-04f, 3.92851159e-02f, 8.17435607e-02f, -7.25072771e-02f, 6.14700355e-02f, 3.00137587e-02f, 1.06285345e-02f, 2.22510919e-02f, 6.44030571e-02f,
  2.89216638e-02f, -6.15357347e-02f, 1.33871242e-01f, -6.12992868e-02f, 5.89649118e-02f, 6.18588068e-02f, -1.79354334e-04f, 3.28432918e-02f, -8.11795797e-03f, -6.83060512e-02f,
  5.78230526e-03f, 4.15282175e-02f, -1.63810272e-02f, 1.95974391e-02f, 1.07301369e-01f, 6.65288642e-02f, -4.38113064e-02f, 6.88180029e-02f, 8.16492736e-02f, -9.62257311e-02f,
  -1.58199146e-02f, 7.73646915e-03f, 1.21333055e-01f, -6.96924999e-02f, -9.84617919e-02f, 7.86421150e-02f, -4.15543765e-02f, 7.71444812e-02f, 1.12922616e-01f, 1.44625649e-01f,
  2.49297857e-01f, -1.41987232e-02f, 1.01208963e-01f, 1.04318373e-01f, -4.03558277e-03f, 2.30578892e-02f, 2.00851575e-01f, -2.35500280e-04f, 2.83097234e-02f, 3.86667214e-02f,
  -7.86474347e-02f, -2.82247365e-01f, -1.10782169e-01f, -4.00992157e-03f, 6.35088095e-03f, 1.96027994e-01f, 3.00167859e-01f, 1.09938033e-01f, 2.91997120e-02f, 2.12690867e-02f,
  -8.32916200e-02f, -3.74651514e-02f, 3.25307697e-02f, -1.36655178e-02f, -1.93800285e-01f, 4.03650990e-03f, 1.28991634e-01f, 3.48290056e-02f, -9.20209736e-02f, -1.32189587e-01f,
  -1.26022741e-01f, 3.37248705e-02f, 1.74963206e-01f, 1.41769052e-01f, -6.93748891e-02f, 1.29805490e-01f, -3.53273712e-02f, -7.05730170e-02f, -3.82375047e-02f, 7.81991258e-02f,
  7.62604102e-02f, 4.42328975e-02f, -1.18204936e-01f, 1.13404160e-02f, 4.44435030e-02f, 5.84271066e-02f, 6.58289492e-02f, 5.09383641e-02f, 1.12206325e-01f, 1.02382964e-02f,
  -4.45818827e-02f, 5.82232513e-02f, 6.43527657e-02f, 1.21012755e-01f, 4.25524674e-02f, 1.29940853e-01f, 6.54392242e-02f, 1.79386660e-02f, 1.24682240e-01f, 1.23799518e-01f,
  9.55900475e-02f, -8.05011168e-02f, -1.04277253e-01f, -4.47712764e-02f, -5.59501797e-02f, -6.72162995e-02f, -1.89245954e-01f, -1.36085842e-02f, -3.77140380e-02f, -5.73755354e-02f,
  -2.58377362e-02f, -6.70669079e-02f, -1.74799740e-01f, -5.21931387e-02f, -8.78785998e-02f, -1.49239898e-01f, -1.32826224e-01f, -1.08364828e-01f, -5.70654217e-03f, -1.34136558e-01f,
  -1.19963782e-02f, 4.17296030e-02f, -1.79588184e-01f, -2.19706729e-01f, -6.93878084e-02f, -1.48198038e-01f, -1.12751171e-01f, -1.70443773e-01f, -2.02380002e-01f, -4.60557193e-02f,
  -1.57393157e-01f, 1.13322832e-01f, 1.69354662e-01f, 1.57128870e-01f, 1.87315866e-01f, 1.97777405e-01f, 4.95519862e-02f, 1.64702520e-01f, 2.06617340e-01f, 7.24779963e-02f,
  8.19439813e-02f, 1.48896500e-01f, 5.05472831e-02f, 8.98954924e-03f, 1.40091464e-01f, 1.83398589e-01f, 6.19891398e-02f, 8.87125954e-02f, 1.83900610e-01f, 2.00903296e-01f,
  2.30226129e-01f, 2.81112552e-01f, 2.22827107e-01f, 1.87954709e-01f, 5.70838191e-02f, 1.52263284e-01f, 8.64161775e-02f, 6.41559064e-02f, 1.04286052e-01f, 1.72374010e-01f,
  -5.81144691e-02f, -2.22289294e-01f, 9.14462432e-02f, -4.31644544e-02f, 2.32873093e-02f, -1.64973028e-02f, -1.44158557e-01f, -1.48925081e-01f, -2.16881111e-02f, 2.34167818e-02f,
  -7.24477097e-02f, 1.51177704e-01f, 1.26964003e-01f, 9.91139263e-02f, -2.68432423e-02f, 5.25174849e-02f, 2.37714410e-01f, 2.16368988e-01f, 6.39538914e-02f, 1.31228883e-02f,
  1.28873333e-01f, 3.07225101e-02f, 5.83440810e-02f, 3.27128582e-02f, -1.63897295e-02f, 1.91134468e-01f, 1.96336851e-01f, 5.37819229e-02f, 4.73046601e-02f, 2.82893687e-01f,
  4.99775052e-01f, -2.13201642e-01f, 7.04969689e-02f, -2.98319906e-02f, -2.16500442e-02f, 1.34503487e-02f, 1.98420249e-02f, -1.49696823e-02f, -6.20816797e-02f, -2.77266223e-02f,
  3.03124189e-02f, -6.33790866e-02f, -3.34329866e-02f, 2.28235945e-02f, -3.18965949e-02f, -1.11445755e-01f, -1.14894092e-01f, -5.98768927e-02f, -7.76791200e-02f, -7.11292624e-02f,
  5.36025092e-02f, -7.24183843e-02f, -3.47313657e-03f, -1.74899757e-01f, -1.43300280e-01f, -4.97282632e-02f, -1.25511840e-01f, -6.73157424e-02f, -1.42368153e-01f, 5.88222258e-02f,
  3.42288800e-02f, -7.35287741e-02f, -2.88946647e-02f, -7.67531693e-02f, -6.07804433e-02f, 5.88511862e-02f, 1.30627245e-01f, 8.06626752e-02f, 1.97852794e-02f, -4.10580747e-02f,
  2.86655128e-02f, 3.03052347e-02f, 3.77086140e-02f, -4.99010533e-02f, 7.32682198e-02f, 1.62266977e-02f, -5.85380383e-03f, -3.04359617e-03f, 7.37360271e-04f, 1.89548004e-02f,
  1.13168433e-02f, 9.11171548e-03f, 6.60590455e-02f, -1.25546847e-02f, -2.61971466e-02f, 3.60148586e-02f, -3.13540571e-03f, -1.08916230e-01f, -1.02828048e-01f, -8.75480473e-02f,
  1.17600098e-01f, -3.85687873e-02f, 1.90321267e-01f, 4.82244324e-03f, -2.25857925e-02f, -8.26519057e-02f, -3.22176255e-02f, -6.39156029e-02f, -8.93768743e-02f, -4.29092236e-02f,
  -8.10321271e-02f, -3.24819572e-02f, 1.09554395e-01f, 9.05492809e-03f, 6.41263649e-02f, 2.77870409e-02f, -7.85329342e-02f, 1.67251617e-01f, -3.16598378e-02f, -4.50655296e-02f,
  1.88961122e-02f, -7.67272711e-02f, 1.75330371e-01f, 7.55922347e-02f, -4.54790667e-02f, 2.70716269e-02f, 1.07839838e-01f, 5.94125427e-02f, -5.57633266e-02f, -5.87398279e-03f,
  -3.14569384e-01f, 1.37069285e-01f, -2.51345873e-01f, 1.14579044e-01f, 1.37161687e-01f, -6.56806864e-03f, 2.36842819e-02f, 2.27493253e-02f, 1.00103252e-01f, -1.71660874e-02f,
  8.40599313e-02f, 1.23828217e-01f, -4.41561043e-02f, -7.43029267e-02f, -2.38290250e-01f, -2.46642977e-01f, -3.09873849e-01f, -3.41845185e-01f, -2.19318986e-01f, 4.75109788e-03f,
  2.08038926e-01f, -1.06987096e-01f, -2.03539327e-01f, -6.07751422e-02f, 1.13880530e-01f, 1.17965333e-01f, -1.44788027e-01f, 1.83595359e-01f, 9.92055386e-02f, 1.32869467e-01f,
  -1.37116060e-01f, 1.85339287e-01f, -1.50684327e-01f, 8.76717195e-02f, 1.20118216e-01f, -2.84622703e-02f, -1.57591216e-02f, -1.81649458e-02f, 8.14984217e-02f, -1.06758893e-01f,
  9.89575684e-02f, -1.16677312e-02f, 1.24757499e-01f, 3.79387662e-02f, 2.10343469e-02f, 1.87812727e-02f, 2.91180760e-02f, -2.41735503e-02f, -9.69618484e-02f, -5.43674827e-03f,
  8.69307518e-02f, 4.31919657e-02f, 5.63786924e-02f, -3.81753892e-02f, 7.02143237e-02f, 7.95526206e-02f, 2.05256324e-02f, 5.60699850e-02f, -5.03838472e-02f, 2.88396105e-02f,
  1.54776582e-02f, -1.00957520e-01f, -1.57928129e-03f, -5.22181801e-02f, -3.77919301e-02f, 1.31305046e-02f, 3.96183394e-02f, -1.19222803e-02f, 3.18648219e-02f, -3.92656680e-03f,
  -9.10766721e-02f, 4.31674197e-02f, 1.14468923e-02f, 6.02517650e-02f, -3.60789336e-02f, 4.86512892e-02f, -4.31622937e-02f, -4.18251902e-02f, 4.10576165e-02f, 3.64752556e-03f,
  -1.08175986e-02f, 8.24631676e-02f, 1.21888435e-02f, 7.74979889e-02f, 5.82893267e-02f, -3.82610643e-03f, 2.76747197e-02f, 1.02759302e-01f, -2.62783598e-02f, 1.15631737e-01f,
  6.53100833e-02f, -3.17823254e-02f, -1.90134030e-02f, 3.70867774e-02f, 8.71611014e-02f, 6.60183802e-02f, 1.30660221e-01f, 9.73472074e-02f, 1.63656309e-01f, 1.00446329e-01f,
  1.14780053e-01f, -3.91673893e-02f, 2.41002440e-02f, 4.72999476e-02f, 7.73536265e-02f, 2.65914109e-02f, 6.26368914e-03f, 1.00544393e-01f, 4.62641977e-02f, 1.87990472e-01f,
  5.55231981e-02f, -9.15843323e-02f, -1.26708046e-01f, -4.84186113e-02f, 2.81288121e-02f, -7.40259662e-02f, -1.61564555e-02f, 9.42774341e-02f, -1.13601722e-01f, -8.06105658e-02f,
  1.11503929e-01f, -2.27371097e-01f, 9.42147747e-02f, 1.73627853e-01f, -1.13807008e-01f, -1.64185297e-02f, -1.62596956e-01f, -9.78478640e-02f, 7.77082220e-02f, -6.82361275e-02f,
  -1.12208970e-01f, 1.56622902e-02f, 5.63190971e-03f, 1.11795463e-01f, 2.76168197e-01f, 2.69688159e-01f, 3.68014544e-01f, 2.65853852e-01f, 3.73764694e-01f, 1.31448984e-01f,
  -1.01998799e-01f, 1.99324384e-01f, 2.47969732e-01f, 1.70617178e-01f, -5.84312640e-02f, 1.23561767e-03f, 6.55996799e-02f, 9.29825529e-02f, -5.38281612e-02f, 7.39242136e-02f,
  1.78471543e-02f, 6.56349957e-02f, 1.69240788e-01f, 2.50787020e-01f, -2.88251657e-02f, 1.82384830e-02f, 4.29377183e-02f, 6.81905746e-02f, 1.08668789e-01f, 9.63027850e-02f,
  -2.29569292e-03f, 7.65146762e-02f, 7.79571012e-02f, 5.97995482e-02f, 1.68910265e-01f, 5.92179038e-02f, 2.62634337e-01f, 2.70694643e-01f, 1.82065278e-01f, 7.03469887e-02f,
  1.34062052e-01f, 1.60387248e-01f, 2.40585163e-01f, 2.67821588e-02f, -4.79521649e-03f, 1.59818515e-01f, 7.42950588e-02f, 3.31088156e-03f, 1.77994892e-01f, -2.30852123e-02f,
  1.71586629e-02f, -9.92780402e-02f, -1.64936125e-01f, -1.11145705e-01f, -9.56111252e-02f, -8.22462514e-02f, -7.27321953e-02f, -4.43874747e-02f, -3.67727131e-02f, 2.63648108e-03f,
  -6.84783086e-02f, -6.35998249e-02f, -1.04548939e-01f, -4.80386019e-02f, -1.96391549e-02f, 1.45280570e-01f, -2.96150111e-02f, -1.08760975e-01f, 3.10739763e-02f, -6.33482412e-02f,
  -3.20638753e-02f, -9.51339006e-02f, 4.08238396e-02f, 2.25484353e-02f, 4.35161451e-03f, 8.89775867e-04f, 2.18238086e-02f, -1.25600323e-01f, 6.74199015e-02f, 7.94232935e-02f,
  7.66185448e-02f, 1.02910645e-01f, 8.35134760e-02f, 1.82569101e-01f, -1.00296631e-03f, 1.99946798e-02f, -3.71489041e-02f, 1.42420441e-01f, -1.96212670e-03f, -8.67980998e-03f,
  -1.07831143e-01f, -8.37237313e-02f, 3.51795107e-02f, -1.83213223e-02f, -8.38659406e-02f, 7.04444945e-02f, 2.25496888e-02f, 1.14322193e-01f, 2.09453627e-01f, 4.36916109e-03f,
  7.22846314e-02f, -5.41653037e-02f, -1.12217749e-02f, 7.42358193e-02f, -5.87587245e-03f, 1.02817148e-01f, -8.11814070e-02f, 6.37471378e-02f, 1.35289729e-01f, -7.28558525e-02f,
  -2.86548942e-01f, 1.49299756e-01f, 2.74326831e-01f, -1.00826912e-01f, 9.84205864e-04f, 1.07739987e-02f, 1.22290403e-02f, -1.27114594e-01f, -1.09704159e-01f, 2.07470462e-01f,
  2.01325808e-02f, -1.16181299e-01f, -5.74246645e-02f, -1.96950007e-02f, -9.51263458e-02f, 1.16432428e-01f, 3.06891412e-01f, 3.33152786e-02f, -2.12393597e-01f, -2.72491843e-01f,
  1.13489088e-02f, 2.87611969e-02f, -1.06337450e-01f, -7.98565075e-02f, -1.17132649e-01f, -1.48134306e-01f, 1.11450054e-01f, -7.05452636e-02f, 7.40322098e-02f, 3.22934300e-01f,
  6.33460954e-02f, -9.07491744e-02f, -1.56196952e-01f, -2.26753414e-01f, -7.15992153e-02f, -6.65097609e-02f, 8.42887163e-02f, 1.20358944e-01f, 7.51535818e-02f, 2.14398149e-02f,
  -8.78200084e-02f, 6.14468753e-02f, -4.81566973e-02f, -8.90644863e-02f, -1.62498847e-01f, -6.18966557e-02f, 5.36264628e-02f, -1.00827469e-02f, 1.98973231e-02f, -7.87437856e-02f,
  2.50770804e-02f, 5.06055653e-02f, -1.47331417e-01f, -1.39073461e-01f, -1.13057956e-01f, -6.25511333e-02f, -1.71318814e-01f, -1.26557887e-01f, -3.47977616e-02f, -5.68516329e-02f,
  -3.82780842e-02f, 5.39447404e-02f, 9.32649970e-02f, 1.20822355e-01f, 5.84751228e-03f, -6.80158585e-02f, 1.57930274e-02f, -5.54889068e-02f, -2.36112978e-02f, -7.18057528e-03f,
  -7.36581301e-03f, 7.88429752e-02f, -6.63750768e-02f, 1.35682588e-02f, 4.19086777e-02f, -2.01986860e-02f, -4.56154533e-02f, -8.40408280e-02f, -1.68010462e-02f, 3.40691432e-02f,
  -1.53488398e-01f, -9.32566915e-03f, -1.01250604e-01f, -8.95734038e-03f, -6.59870058e-02f, -1.91090554e-02f, 1.44543033e-02f, 3.92133221e-02f, -7.10345358e-02f, 2.93201879e-02f,
  -3.20975900e-01f, -4.95390892e-02f, -1.48701677e-02f, -7.33847693e-02f, -3.08688767e-02f, -3.41228060e-02f, 1.26209483e-01f, 8.08198527e-02f, 9.32068471e-03f, 6.78182691e-02f,
  -8.67299214e-02f, 8.66813064e-02f, 4.54671681e-02f, 7.88440630e-02f, -1.03079103e-01f, -6.50061443e-02f, -1.07496783e-01f, 6.95609152e-02f, -1.38197625e-02f, -1.92274805e-02f,
  7.06011057e-02f, -4.24707159e-02f, -2.06478655e-01f, -5.90295680e-02f, -4.90662679e-02f, -1.47392154e-01f, -4.78526875e-02f, -1.74496993e-01f, -8.48842934e-02f, 8.06104168e-02f,
  2.12067649e-01f, -2.53200442e-01f, 4.46426915e-03f, 1.39863223e-01f, -1.14443950e-01f, -1.06910832e-01f, -3.21767390e-01f, 1.73237659e-02f, 1.98607802e-01f, -1.18759267e-01f,
  -8.31830427e-02f, 2.46747687e-01f, 7.11253360e-02f, 1.13971069e-01f, 2.48962198e-03f, -1.04620107e-01f, -1.90899357e-01f, -2.59769410e-02f, 1.37050524e-01f, 1.80122852e-01f,
  2.96320375e-02f, -3.46818231e-02f, 1.08330138e-01f, 3.94011475e-03f, -9.52570885e-03f, 9.24078450e-02f, -1.49188548e-01f, -8.93435851e-02f, -1.08919717e-01f, -1.36770219e-01f,
  -9.55865160e-02f, -7.22354427e-02f, 2.38083169e-01f, -5.85136004e-03f, 5.74347302e-02f, 8.75924751e-02f, 4.27164808e-02f, 9.11612511e-02f, 3.56438458e-02f, -4.24195267e-03f,
  -9.56361517e-02f, 2.69481018e-02f, 3.61933780e-04f, -3.50306146e-02f, -6.55251741e-02f, -8.34239349e-02f, 1.18247420e-02f, 1.29431849e-02f, 6.67263791e-02f, 5.34026064e-02f,
  -8.80585685e-02f, 3.37181576e-02f, -5.63230999e-02f, -7.35839233e-02f, 1.16728470e-02f, -1.09973876e-02f, -4.06685704e-03f, -8.83145332e-02f, -1.10220527e-02f, 1.16878197e-01f,
  -3.94498035e-02f, -5.47759002e-03f, -8.75236541e-02f, -3.65760177e-02f, -3.47298458e-02f, 5.52605800e-02f, -2.95360740e-02f, -1.27099575e-02f, -1.12982601e-01f, -5.98776676e-02f,
  7.08575696e-02f, -3.11779790e-02f, -3.96504439e-02f, 6.42393995e-03f, -2.56010555e-02f, -1.16518453e-01f, -5.08397520e-02f, -8.96413438e-03f, -8.71963203e-02f, -4.83921170e-02f,
  8.62320513e-02f, -1.67209469e-02f, -4.53082286e-02f, -1.00388862e-01f, 5.26456274e-02f, 2.49964539e-02f, -1.82324369e-02f, -1.22704938e-01f, -1.32011529e-02f, 3.48592587e-02f,
  1.60464704e-01f, 1.07322335e-02f, 1.05412543e-01f, 5.82019649e-02f, 1.68184545e-02f, 6.28703237e-02f, 2.20083613e-02f, 4.57073841e-03f, 2.89148949e-02f, 5.36680371e-02f,
  2.14635786e-02f, -5.90591708e-06f, -4.29451577e-02f, 7.04611465e-02f, 7.87429437e-02f, -1.46549009e-02f, 1.44925835e-02f, 1.58497110e-01f, 1.60097331e-01f, 5.40148243e-02f,
  5.36064953e-02f, 1.00947179e-01f, 2.99115807e-01f, 1.11944422e-01f, 1.44295201e-01f, 2.06398621e-01f, -3.74634266e-02f, 5.42358346e-02f, 1.36438131e-01f, 8.79449025e-02f,
  -4.22740504e-02f, 3.97014469e-01f, -4.87763911e-01f, -6.52113855e-02f, -1.34776026e-01f, -2.55026013e-01f, -3.75039726e-02f, -1.22956447e-01f, -8.25832486e-02f, 1.40463606e-01f,
  2.54356831e-01f, 3.19674611e-01f, 2.27575555e-01f, 8.85427371e-02f, -1.28283545e-01f, -9.69045684e-02f, -2.06416801e-01f, -3.91528785e-01f, -3.51321608e-01f, -6.57890290e-02f,
  7.67377093e-02f, -4.46662679e-02f, -1.56929836e-01f, -1.37792096e-01f, 2.08669230e-02f, 1.29635900e-01f, -3.61821465e-02f, 1.37649970e-02f, 3.02586127e-02f, -5.00715226e-02f,
  6.58025593e-02f, -2.40913406e-01f, -7.11752847e-02f, 6.47455454e-02f, -7.98649620e-03f, -2.17052586e-02f, -1.28849642e-03f, -4.12836261e-02f, 9.85382944e-02f, -7.56610651e-03f,
  3.44818719e-02f, 6.72142431e-02f, -5.39334118e-02f, 7.98505098e-02f, -2.65550092e-02f, -3.69533934e-02f, -2.65375022e-02f, -1.23311274e-01f, -1.40264675e-01f, -4.52849530e-02f,
  1.28930241e-01f, -5.85820936e-02f, -1.69442758e-01f, -4.80275899e-02f, -1.25616103e-01f, -5.61367683e-02f, -8.33806023e-02f, -1.11963421e-01f, -1.08537056e-01f, 8.45405236e-02f,
  -2.35537775e-02f, -1.17922500e-01f, 3.85396592e-02f, 8.65017902e-03f, 9.58027691e-02f, 7.60632679e-02f, -1.35423206e-02f, 5.32608815e-02f, 7.07397144e-03f, -1.41716082e-04f,
  -5.01844333e-03f, -5.14352992e-02f, -1.84625169e-04f, 3.14417407e-02f, 1.47331608e-02f, 1.67442895e-02f, -7.59761455e-03f, 3.07995565e-02f, 1.01882078e-01f, 7.55230859e-02f,
  2.67335139e-02f, -6.38767481e-02f, 1.26341462e-01f, -6.62070289e-02f, 3.73287462e-02f, 7.13445246e-02f, 4.42344584e-02f, 2.21274607e-02f, 2.00256575e-02f, -3.32619883e-02f,
  2.15819523e-01f, -1.67078614e-01f, 2.00660124e-01f, 8.51344690e-03f, -2.07894370e-02f, 8.82897228e-02f, -4.72145639e-02f, -3.82863656e-02f, 2.24460289e-02f, 5.09000719e-02f,
  -3.78866307e-02f, 2.12753359e-02f, 1.17832776e-02f, -4.93994914e-02f, -9.93669927e-02f, -3.47041227e-02f, 9.16675553e-02f, -1.10247293e-02f, -3.32605094e-02f, -7.45579600e-03f,
  -1.11562638e-02f, -5.24373073e-03f, -4.14559692e-02f, -1.10992081e-02f, 9.86498129e-03f, -1.54401772e-02f, -4.18437608e-02f, -5.42013422e-02f, -8.52200165e-02f, 1.61461696e-01f,
  -8.29073042e-02f, 4.56626453e-02f, 2.21454561e-01f, 1.01327680e-01f, -4.76003438e-02f, 3.47201787e-02f, 1.66275561e-01f, 5.57981990e-02f, 1.24951929e-01f, 1.82261735e-01f,
  -1.07600383e-01f, -3.03396106e-01f, -7.59301111e-02f, -2.03339294e-01f, 3.67547497e-02f, 1.86506003e-01f, 1.74305052e-01f, 1.39796808e-01f, -1.73194528e-01f, -2.90454388e-01f,
  -2.00424105e-01f, 1.01651281e-01f, 7.14944601e-02f, -7.26623610e-02f, 5.29032387e-02f, -6.16387650e-02f, 2.62702048e-01f, 5.13932966e-02f, -4.11737524e-02f, -5.58949541e-03f,
  -1.34613682e-02f, 6.01701997e-02f, 2.27150582e-02f, 8.50184262e-03f, 3.92976254e-02f, 4.63238135e-02f, -1.67987309e-02f, 2.45620497e-02f, 8.63551944e-02f, -5.64871803e-02f,
  -1.28426045e-01f, -4.63492945e-02f, 3.78409214e-02f, -1.98738053e-02f, -1.04601646e-03f, 9.80952531e-02f, 1.40974492e-01f, 8.11648518e-02f, 5.86940385e-02f, 5.48223406e-02f,
  4.22653509e-03f, -8.58361050e-02f, 6.61923259e-04f, 7.08875209e-02f, -1.99497472e-02f, -6.01832848e-03f, -7.49062225e-02f, -1.65025156e-03f, -1.11529879e-01f, 9.58145484e-02f,
  6.83370382e-02f, 6.07184358e-02f, 2.42866911e-02f, 1.16395526e-01f, 7.59783387e-03f, -8.27976875e-03f, -1.37472441e-02f, -3.00803012e-03f, 5.59915714e-02f, -6.43097758e-02f,
  -3.31342802e-03f, -6.25537429e-03f, 3.34252082e-02f, -6.10125158e-03f, -1.61782447e-02f, 4.43381853e-02f, -3.15583460e-02f, -5.19543216e-02f, -6.40058145e-02f, 6.18383624e-02f,
  -1.74775701e-02f, -1.79995000e-02f, -4.36388068e-02f, -4.26700301e-02f, -5.72430082e-02f, 5.78631498e-02f, 3.48627493e-02f, 5.44479638e-02f, -7.41844103e-02f, 3.26647796e-02f,
  1.53497636e-01f, -6.09241165e-02f, 7.50913396e-02f, 5.38582206e-02f, 6.90759569e-02f, 2.08583265e-03f, -1.34569602e-02f, 8.80171508e-02f, 2.73098182e-02f, 6.44848496e-02f,
  -4.65776250e-02f, 8.76706399e-05f, -1.96787287e-02f, 7.43420422e-02f, -1.81539450e-02f, -8.24347362e-02f, 5.85388169e-02f, 7.59350955e-02f, 4.02127542e-02f, 3.84677909e-02f,
  9.85818803e-02f, -2.00554561e-02f, -2.00932170e-03f, 4.58167270e-02f, -4.61507253e-02f, -4.53139842e-02f, 7.55312219e-02f, -8.12000707e-02f, -5.17061492e-03f, 8.19615051e-02f,
  -2.85287648e-01f, -2.25382671e-01f, 3.74108367e-02f, 1.59977794e-01f, 8.25297907e-02f, -1.22490458e-01f, -2.99282640e-01f, -1.38012260e-01f, 7.76943862e-02f, -9.23556313e-02f,
  -8.97736996e-02f, -4.60325666e-02f, -1.29242554e-01f, 2.07616785e-03f, -1.85416073e-01f, -1.68438196e-01f, 6.16395660e-02f, 7.00002238e-02f, -3.26523073e-02f, -1.18813649e-01f,
  6.91498071e-02f, -3.71813141e-02f, 4.68648747e-02f, 6.06006198e-02f, -2.40063649e-02f, -1.12389989e-01f, -1.14051662e-01f, -1.20695025e-01f, -1.39734551e-01f, 6.51924387e-02f,
  -1.92266032e-01f, -1.37175843e-01f, -5.37032150e-02f, -2.12628782e-01f, -4.21610922e-02f, -8.21830034e-02f, -1.54252961e-01f, -2.49430630e-02f, -1.39276147e-01f, -1.88881680e-01f,
  1.60402879e-02f, -7.26855099e-02f, -1.29325330e-01f, -3.05171739e-02f, -3.42069343e-02f, -1.49827525e-02f, -6.27226532e-02f, -4.17701155e-02f, -1.41696855e-01f, -1.50589779e-01f,
  -7.44390190e-02f, -1.07588418e-01f, -2.43123695e-01f, -1.68779761e-01f, -7.19094947e-02f, -1.48359954e-01f, -1.84612036e-01f, -1.09877288e-01f, -9.51868966e-02f, -1.07509650e-01f,
  1.87310223e-02f, 1.48388982e-01f, 1.72753453e-01f, 3.32015753e-02f, -2.93767750e-02f, 7.72343948e-02f, 4.13276963e-02f, -1.14948656e-02f, 1.21409230e-01f, 1.39337122e-01f,
  1.30018309e-01f, -2.80751735e-02f, 8.27426687e-02f, 9.65491757e-02f, 1.25258774e-01f, -2.07624324e-02f, 8.17649215e-02f, -1.96147133e-02f, 3.06948312e-02f, 9.22422111e-03f,
  2.52397601e-02f, 6.11128807e-02f, 1.15637586e-01f, 7.95739144e-02f, 1.18569590e-01f, 2.14450344e-01f, 1.08919322e-01f, 1.68615710e-02f, 2.20093980e-01f, 1.72091112e-01f,
  -1.39514998e-01f, 8.28790963e-02f, -1.95391983e-01f, -1.82308033e-01f, -1.32432610e-01f, -7.88525715e-02f, -1.23862974e-01f, 3.82495136e-03f, -1.94622383e-01f, -2.52164602e-01f,
  -1.76881149e-01f, -2.25185886e-01f, -1.01511382e-01f, 5.70748933e-03f, -1.81971386e-01f, -8.04560184e-02f, -5.25090136e-02f, -1.44629627e-01f, -2.03358740e-01f, -1.12497881e-01f,
  1.16124256e-02f, -2.30407402e-01f, -2.43155241e-01f, -2.33627260e-01f, -2.37676203e-01f, -2.68632978e-01f, -2.67079622e-01f, -1.95016772e-01f, -2.36428112e-01f, -3.80055666e-01f,
  -9.61540714e-02f, 4.58370559e-02f, -1.07229188e-01f, -2.78522391e-02f, -8.47654231e-03f, -3.63322049e-02f, -1.92165554e-01f, -1.43074602e-01f, -5.44849262e-02f, -1.39563918e-01f,
  1.97658598e-01f, 3.56922954e-01f, -2.47623480e-04f, 1.76473871e-01f, -4.01074626e-02f, -2.57429421e-01f, -4.27993357e-01f, -1.80638775e-01f, 1.16438493e-01f, 5.75233623e-02f,
  5.40751144e-02f, -1.50411874e-01f, -5.17269745e-02f, -8.51518884e-02f, 2.63464171e-02f, 1.70812264e-01f, -1.79715529e-01f, 4.41044085e-02f, 7.61980861e-02f, -5.77991344e-02f,
  9.89429653e-03f, 3.49117965e-02f, 2.02973157e-01f, 5.57992719e-02f, 3.57189588e-02f, 4.52731289e-02f, 8.75464082e-02f, -7.05114082e-02f, -2.22557262e-02f, 8.46979097e-02f,
  7.70689398e-02f, 5.94473518e-02f, -7.24341720e-02f, 9.09111053e-02f, -1.10111028e-01f, 5.82985729e-02f, 1.97645687e-02f, -3.61088067e-02f, -5.95930107e-02f, -7.21404925e-02f,
  8.31338540e-02f, 1.19260907e-01f, 1.00980073e-01f, -2.06775796e-02f, -4.18086872e-02f, 1.13558307e-01f, 3.90283205e-02f, 1.36832535e-01f, 6.91853836e-02f, 2.65245847e-02f,
  -7.34383287e-03f, 3.64113376e-02f, -2.68486086e-02f, 2.44795941e-02f, 5.21739433e-03f, -9.24510434e-02f, -1.12517625e-02f, -3.81116830e-02f, -5.54843359e-02f, -6.75899088e-02f,
  1.02039702e-01f, 7.57741854e-02f, 5.69217242e-02f, 4.56411950e-02f, -7.40766153e-02f, -1.00230955e-01f, -2.96836905e-02f, -1.20697699e-01f, -1.85212377e-03f, 6.79133460e-02f,
  1.32677123e-01f, -1.03592882e-02f, 3.88174690e-02f, 1.43589973e-02f, 3.97198014e-02f, -3.76616530e-02f, -1.42008876e-02f, -1.16491318e-02f, -4.30661328e-02f, -3.34527157e-02f,
  -2.34826375e-02f, 1.04040310e-01f, 3.81431431e-02f, 1.27377018e-01f, 1.00547455e-01f, 1.44353276e-03f, 9.33323614e-03f, -1.03004009e-01f, -5.08328713e-03f, 2.36133803e-02f,
  5.68892993e-02f, 4.34091762e-02f, -3.60165238e-02f, 5.14800288e-02f, 3.64723131e-02f, -7.23580867e-02f, -2.72680894e-02f, 1.92332398e-02f, 2.03334633e-02f, -4.40990925e-02f,
  -4.95176539e-02f, -6.05891421e-02f, -1.21171866e-03f, 2.36997604e-02f, 9.18940753e-02f, 1.34204440e-02f, 2.23131385e-02f, 1.31777465e-01f, -3.85087989e-02f, -3.06485556e-02f,
  -1.11574791e-01f, 1.15909502e-01f, 3.20262492e-01f, 1.53631061e-01f, 1.81491226e-01f, -1.44491032e-01f, -1.62620887e-01f, -2.27748930e-01f, -3.05707678e-02f, 9.79784206e-02f,
  8.05250183e-02f, -5.53993322e-02f, -4.98850271e-02f, -6.30625931e-04f, -2.19889775e-01f, -3.35531868e-03f, 9.03745890e-02f, 8.27810541e-02f, -1.63305685e-01f, -1.83089748e-01f,
  -2.36028820e-01f, -7.64734820e-02f, -1.68804992e-02f, -6.43247291e-02f, 9.00323763e-02f, -4.47045229e-02f, 2.61649430e-01f, 1.95406824e-01f, 3.60103920e-02f, 4.19541806e-01f,
  8.88864174e-02f, 1.35301620e-01f, -3.26366979e-03f, 4.40955274e-02f, 1.61377817e-01f, -3.88777554e-02f, -1.02313623e-01f, 2.10581183e-01f, 1.63969666e-01f, 1.24542236e-01f,
  1.52920678e-01f, -3.32298130e-03f, 5.80466054e-02f, 1.64206043e-01f, 3.36134546e-02f, -1.58902574e-02f, 1.35737494e-01f, 4.59733903e-02f, 3.76176760e-02f, 1.42987475e-01f,
  7.84627944e-02f, 1.49924355e-02f, 4.23688926e-02f, -3.91660593e-02f, 1.48001257e-02f, 4.60895337e-03f, 1.11720137e-01f, 2.67759897e-02f, 8.89993981e-02f, 1.21629432e-01f,
  -1.18076444e-01f, -2.26908270e-03f, 7.69786313e-02f, -1.76900681e-02f, -1.05321109e-01f, 5.67124560e-02f, -7.33116129e-03f, -2.52919830e-02f, -5.34750596e-02f, -9.04408023e-02f,
  4.03829552e-02f, 1.92633886e-02f, -2.88673919e-02f, 1.76669713e-02f, -4.58311103e-02f, 3.69502651e-03f, -4.95863594e-02f, 6.08936958e-02f, 4.70436849e-02f, 5.47888316e-02f,
  -5.38816527e-02f, 1.30388394e-01f, 1.13923028e-01f, -8.55117366e-02f, -2.08709445e-02f, 4.84431051e-02f, 3.15823033e-02f, -8.82137846e-03f, -8.02022293e-02f, -1.87319715e-03f,
  -1.35338366e-01f, 8.94347802e-02f, 4.34404844e-03f, -6.87422082e-02f, 1.29161969e-01f, 9.32443962e-02f, 9.38457549e-02f, 5.56790158e-02f, 8.03434849e-02f, -1.37755796e-01f,
  4.30590361e-02f, -3.87761965e-02f, 3.68766934e-02f, 1.48244351e-01f, -1.18632019e-01f, -7.60782808e-02f, -4.69371527e-02f, 6.40796050e-02f, 7.02275485e-02f, 7.52185658e-02f,
  -6.52967915e-02f, 2.21064538e-02f, -1.95296526e-01f, -5.69222234e-02f, -1.61015287e-01f, -1.10834718e-01f, -5.43371448e-03f, -1.03768393e-01f, -1.95020273e-01f, -7.92098120e-02f,
  -4.29674238e-01f, 7.73948729e-02f, -2.76579648e-01f, -4.55723345e-01f, -4.43551362e-01f, -2.02962130e-01f, -7.82740265e-02f, -1.31420612e-01f, -7.10527673e-02f, -4.82299700e-02f,
  -9.80419014e-03f, 3.97305638e-02f, 4.01313268e-02f, 1.13921449e-01f, 1.98016949e-02f, -6.35720268e-02f, -1.09784715e-01f, -3.88572514e-02f, -2.57172763e-01f, -2.83935606e-01f,
  -1.00363702e-01f, -3.45485240e-01f, -2.58035362e-01f, -1.56104445e-01f, -8.10211077e-02f, -7.92466179e-02f, -1.25462279e-01f, -1.44855767e-01f, -1.48933250e-02f, -1.10237122e-01f,
  -1.17055759e-01f, -1.29532352e-01f, -8.64606816e-03f, -5.59108369e-02f, -2.36464012e-02f, 3.36704031e-02f, -5.76265380e-02f, -4.14513871e-02f, 3.91496904e-03f, 1.67077198e-03f,
  -8.61637145e-02f, 1.16240308e-02f, -8.36247578e-02f, -1.14217743e-01f, -4.54345159e-02f, -1.30657136e-01f, 6.99971989e-02f, -9.63956118e-02f, 1.21924561e-02f, -4.99875098e-02f,
  5.88871948e-02f, -1.19797558e-01f, 2.12994367e-02f, 2.00810134e-02f, 4.97618280e-02f, -4.24880683e-02f, 5.55202812e-02f, -2.91690193e-02f, 8.27277824e-02f, 6.36878982e-02f,
  1.14040956e-01f, 1.33053679e-02f, 3.14498000e-04f, 2.81986129e-02f, -6.24687076e-02f, 1.11994982e-01f, 3.80979888e-02f, -9.08256769e-02f, -5.81233986e-02f, 3.65541726e-02f,
  2.61838492e-02f, -3.50682512e-02f, 2.80762203e-02f, -3.53095867e-02f, -7.26921931e-02f, -7.93820173e-02f, 2.08462011e-02f, -7.82509614e-03f, 6.77289767e-03f, -6.58283606e-02f,
  -6.97080866e-02f, 2.44050939e-02f, -4.36500609e-02f, 2.26805601e-02f, -4.75272499e-02f, -8.37590694e-02f, -1.69265028e-02f, 2.91822702e-02f, -4.88301031e-02f, 3.16209644e-02f,
  -1.35951489e-01f, 1.64657041e-01f, 6.98773637e-02f, 4.79817837e-02f, 3.79228108e-02f, 8.97444487e-02f, 5.17714620e-02f, 8.81845579e-02f, -4.82413135e-02f, -2.06929706e-02f,
  -1.30417040e-02f, 8.59815069e-03f, -4.73729633e-02f, 5.27093820e-02f, -7.70652369e-02f, -6.32652640e-02f, 4.18707356e-02f, -7.53301457e-02f, 6.23165455e-04f, -1.03457877e-02f,
  1.50759369e-02f, -8.10090266e-03f, 4.31224629e-02f, 2.40149070e-02f, 9.29323398e-03f, 7.83938840e-02f, 9.95610505e-02f, 3.74311805e-02f, 1.06945917e-01f, 7.14246631e-02f,
  -6.37013674e-01f, 9.51012969e-03f, -4.91297320e-02f, -1.47393554e-01f, -2.83971187e-02f, -1.13932751e-01f, -1.85385078e-01f, 3.04809045e-02f, 1.05151623e-01f, 4.11651507e-02f,
  3.56009081e-02f, 2.37554371e-01f, 2.39335686e-01f, 1.25357732e-01f, -2.99648792e-02f, -1.17360726e-01f, -5.48012331e-02f, -7.30521977e-02f, -1.50243312e-01f, 1.28019616e-01f,
  5.44755086e-02f, -1.66943520e-01f, -2.04561830e-01f, -1.22604124e-01f, 7.91590661e-02f, 3.22378278e-02f, 2.72727367e-02f, -1.32656634e-01f, 2.78445128e-02f, 7.24949017e-02f,
  -8.81842226e-02f, -1.01837240e-01f, 1.66891024e-01f, 1.57877684e-01f, -4.52869534e-02f, -9.44434572e-03f, -6.42980561e-02f, -7.71234035e-02f, -2.02819216e-03f, 8.97099376e-02f,
  -3.39206979e-02f, 7.45497569e-02f, -1.08125903e-01f, -1.94784254e-02f, -1.33334458e-01f, -4.01901379e-02f, -3.99193959e-03f, -1.26938773e-02f, 4.41350862e-02f, 7.61048868e-03f,
  1.86275616e-01f, -1.38786575e-03f, -1.00604661e-01f, 4.29633707e-02f, -4.26115543e-02f, -2.08948497e-02f, 1.69026665e-02f, 1.55138327e-02f, 1.18273273e-01f, 2.36426834e-02f,
  4.65064235e-02f, 8.80666152e-02f, 3.44178430e-03f, -1.10210583e-01f, -5.84627874e-03f, -5.67363352e-02f, -5.77093773e-02f, 3.64600378e-03f, 5.99681959e-02f, -1.28886193e-01f,
  2.69300435e-02f, -7.72069693e-02f, 6.38498440e-02f, 4.06465642e-02f, 8.69540032e-03f, 5.50979041e-02f, -1.13833234e-01f, 4.58095036e-02f, -1.77912414e-02f, -6.50160313e-02f,
  6.92845322e-04f, -2.17867699e-02f, -6.09902851e-02f, 2.76577938e-02f, 6.66675204e-03f, 2.38368064e-02f, 7.64256790e-02f, 1.02864794e-01f, -6.57093152e-02f, 2.46696044e-02f,
  -5.78155257e-02f, 7.18297586e-02f, 6.32414222e-02f, 1.15809292e-01f, 1.05963536e-01f, 1.42167322e-02f, 3.03362273e-02f, 6.04579225e-02f, -1.00009693e-02f, -1.35057699e-02f,
  6.43268153e-02f, -6.58181906e-02f, 6.43734634e-02f, 3.35874259e-02f, 9.74015445e-02f, -1.28252208e-02f, 1.97169054e-02f, -2.74126939e-02f, 8.85979980e-02f, -5.64856194e-02f,
  2.83376072e-02f, 6.92361817e-02f, -1.36673003e-01f, -1.27660977e-02f, 2.36711446e-02f, 5.62604815e-02f, -5.75646944e-02f, 1.75785460e-02f, -2.48242379e-03f, -1.03705406e-01f,
  -5.47213554e-01f, -1.33691758e-01f, 8.29290599e-02f, -1.95029944e-01f, 4.23648693e-02f, -1.20044975e-02f, -7.49106631e-02f, -1.24242127e-01f, -4.30893712e-02f, -1.44063625e-02f,
  -1.60582244e-01f, -1.75313838e-03f, -5.36422571e-03f, 1.08564004e-01f, -1.75448820e-01f, 4.39504460e-02f, 1.61007628e-01f, 1.86924085e-01f, 5.15301898e-03f, -3.57385501e-02f,
  6.91152140e-02f, -1.47695383e-02f, 8.65527522e-03f, 4.89553772e-02f, 3.02846372e-01f, 1.93933010e-01f, 3.20310205e-01f, 1.23187818e-01f, 4.99684364e-02f, 4.83032852e-01f,
  3.22080404e-01f, -2.76991785e-01f, 3.76387760e-02f, -1.86516419e-01f, -4.10338193e-02f, 4.84816059e-02f, -7.61238411e-02f, 4.64028493e-02f, -1.06181763e-01f, -7.32979178e-02f,
  1.14210015e-02f, 4.81391326e-02f, -2.76519079e-02f, 8.72830823e-02f, -1.18704282e-01f, 1.69312283e-02f, -9.48513597e-02f, 4.23997380e-02f, -1.14423260e-01f, 3.26935425e-02f,
  7.58887529e-02f, 2.46582460e-02f, -5.55877648e-02f, -7.16510713e-02f, -5.87605350e-02f, 5.50366975e-02f, 7.71879926e-02f, 4.65686396e-02f, -7.98266232e-02f, 2.61994928e-01f,
  7.08796531e-02f, 3.93726304e-02f, -1.04314074e-01f, -8.63256007e-02f, 3.21717076e-02f, 1.87990647e-02f, 2.16557402e-02f, 5.28353592e-03f, 7.54001588e-02f, -1.52407577e-02f,
  -2.24402472e-02f, -3.47167440e-02f, -5.92102893e-02f, 1.47833945e-02f, 8.60349163e-02f, 1.34649396e-01f, -4.53289319e-03f, -1.04654906e-02f, 2.96917371e-02f, -2.61539370e-02f,
  3.83308940e-02f, 2.44917977e-03f, -1.22042214e-02f, 5.85696148e-03f, -1.07308272e-02f, 2.33902466e-02f, 8.62160176e-02f, 1.42846489e-03f, -7.76661187e-02f, -2.60605067e-02f,
  -9.87780392e-02f, -1.46587536e-01f, 4.37301137e-02f, -6.15520775e-02f, 7.55017847e-02f, -4.92056869e-02f, -5.75123914e-02f, -1.82921495e-02f, -3.55081353e-03f, -4.40413021e-02f,
  -1.53228924e-01f, 1.64035540e-02f, -3.41152609e-03f, 1.19619615e-01f, -5.61741069e-02f, -2.33653169e-02f, -1.05362713e-01f, 2.45123245e-02f, 3.54290605e-02f, 1.56093910e-02f,
  -7.33749568e-02f, -1.22732511e-02f, 3.53754349e-02f, -9.69907828e-03f, -6.12241961e-03f, -1.12144932e-01f, 7.40117729e-02f, 7.99950361e-02f, -1.23673663e-01f, -6.72753379e-02f,
  1.72955189e-02f, 4.43479083e-02f, 1.11738123e-01f, -1.25396892e-01f, -2.79615913e-02f, 1.79002404e-01f, 1.81401163e-01f, -1.69571012e-03f, -1.58638954e-01f, 5.34518249e-02f,
  -1.56890884e-01f, -2.72005349e-01f, -1.25554964e-01f, -5.69220819e-02f, 1.15720004e-01f, 1.75229460e-01f, 2.92964101e-01f, 2.02431038e-01f, 1.20915256e-01f, -1.78050637e-01f,
  -7.77439028e-02f, -2.25184616e-02f, -6.80494159e-02f, -5.79997227e-02f, -2.13213027e-01f, -1.38827279e-01f, 5.05418293e-02f, -6.52958527e-02f, -2.82294247e-02f, -4.82501499e-02f,
  -1.33227587e-01f, 1.08883075e-01f, 9.65935960e-02f, 8.62926431e-03f, 9.23399180e-02f, 8.39025807e-03f, 2.66757067e-02f, 6.17291071e-02f, 2.69729216e-02f, -4.01838198e-02f,
  -7.30873197e-02f, 5.01889773e-02f, 3.96244526e-02f, -1.56026185e-01f, 5.09802774e-02f, -3.13066803e-02f, -1.94197819e-02f, -5.16530685e-02f, 3.59343812e-02f, 3.80291753e-02f,
  2.65577785e-03f, 2.55586598e-02f, 1.05411932e-01f, 6.92791566e-02f, 7.60345086e-02f, 6.38709217e-02f, 5.10342307e-02f, -2.14145985e-03f, 1.81112345e-02f, -1.08732156e-01f,
  -4.89851832e-02f, 6.86537251e-02f, 4.53722998e-02f, 7.21932948e-02f, -7.30262743e-03f, 5.69473617e-02f, -1.82483159e-02f, 3.85043770e-02f, 1.86858177e-02f, -2.37317979e-02f,
  -5.18139116e-02f, -2.86957193e-02f, 1.40865147e-02f, -8.86555761e-02f, -1.28943846e-01f, 3.83909084e-02f, -7.85953179e-02f, -5.58905564e-02f, -1.36107132e-01f, 4.94874045e-02f,
  1.40002407e-02f, 3.63394208e-02f, 1.00740306e-02f, 1.20946141e-02f, 5.88431470e-02f, 1.73373092e-02f, 1.74231885e-03f, -7.27529526e-02f, -7.71981776e-02f, 2.65048407e-02f,
  -2.21427158e-01f, 3.37217897e-01f, -4.10357006e-02f, -2.72956062e-02f, 1.44416139e-01f, 1.78070329e-02f, -4.26929444e-02f, 6.74098209e-02f, 1.58400595e-01f, 8.10324699e-02f,
  3.03967465e-02f, -2.94368491e-02f, -2.09811516e-03f, 4.24007550e-02f, -9.64639895e-03f, 7.60636711e-03f, -7.39977881e-03f, 5.22649623e-02f, 8.00344869e-02f, -3.45488377e-02f,
  4.11856510e-02f, 1.39017195e-01f, -3.80295627e-02f, -6.02153502e-02f, 7.67710879e-02f, 1.04874894e-01f, -3.67601328e-02f, 3.47026139e-02f, 1.68198988e-01f, 6.57968819e-02f,
  -4.96976107e-01f, -1.89938024e-02f, 5.48686013e-02f, -2.62031168e-01f, 1.80333510e-01f, 1.01307698e-01f, 1.65024400e-01f, -1.03273429e-01f, -1.47988036e-01f, 7.53326267e-02f,
  -5.94556555e-02f, -4.80462052e-02f, -6.39980705e-03f, -1.70837536e-01f, -5.21658622e-02f, -1.21335099e-02f, -1.54494345e-02f, 8.68013594e-03f, -1.36733353e-01f, -3.46209109e-02f,
  5.52432761e-02f, -5.35430722e-02f, -1.94199681e-01f, -2.30670735e-01f, -5.36959656e-02f, -2.31227353e-01f, -4.84194467e-03f, -8.57442021e-02f, 3.05699222e-02f, -7.31814206e-02f,
  1.67634770e-01f, -2.58210957e-01f, -3.72970030e-02f, -1.29313201e-01f, -9.27547291e-02f, -2.01802433e-01f, -1.48999736e-01f, -1.56436116e-02f, -6.63848072e-02f, -4.57779579e-02f,
  8.42651818e-03f, -9.35101286e-02f, -1.78857997e-01f, -1.19103745e-01f, -1.09549046e-01f, -1.43279925e-01f, -1.86728284e-01f, -1.82926700e-01f, -1.95949212e-01f, -1.96489587e-01f,
  -1.19444564e-01f, -4.56976518e-02f, 1.75198913e-02f, -1.29275396e-02f, -1.77127868e-01f, -5.57117164e-02f, 3.13406289e-02f, -1.35639176e-01f, -7.23564029e-02f, -1.29739299e-01f,
  5.63418902e-02f, 1.44681245e-01f, 1.08443201e-01f, -6.28835186e-02f, -1.05121240e-01f, 1.40800076e-02f, 6.28483817e-02f, 9.14345980e-02f, 1.55661151e-01f, -1.62677597e-02f,
  -1.19540459e-02f, 7.73894116e-02f, -2.96891574e-02f, 3.77084687e-02f, 8.09526592e-02f, 1.72257587e-01f, 8.86041224e-02f, -2.28717998e-02f, 3.09780464e-02f, 2.72409525e-02f,
  -1.35576259e-02f, 5.72103038e-02f, 1.01693161e-01f, -6.06224164e-02f, -3.07438765e-02f, 5.28104603e-02f, 2.03343090e-02f, -1.82081033e-02f, 1.24865234e-01f, 5.61427996e-02f,
  -5.57040088e-02f, -6.23839013e-02f, -1.56611577e-01f, -1.49696887e-01f, -5.27780280e-02f, -6.93298578e-02f, -1.18926302e-01f, -5.61981872e-02f, -6.09307326e-02f, -1.36637405e-01f,
  -8.64880383e-02f, -1.47858128e-01f, -1.66440159e-02f, -1.37074292e-01f, -1.67721301e-01f, -3.08891386e-02f, -5.67773618e-02f, -6.50678799e-02f, -1.28968462e-01f, -1.82166472e-01f,
  -5.26354760e-02f, -1.45206833e-03f, -8.70761350e-02f, -8.19627568e-02f, -1.05124563e-01f, -1.16212890e-01f, -1.78823583e-02f, -1.59706026e-01f, -1.31046936e-01f, -8.06320980e-02f,
  -2.01565728e-01f, 1.10262163e-01f, -1.21609703e-01f, -1.02613509e-01f, 4.63158302e-02f, -1.17218383e-01f, -3.11879635e-01f, -1.05414405e-01f, 8.99858549e-02f, 5.87195009e-02f,
  7.05375746e-02f, 2.84721404e-01f, 1.97017327e-01f, 2.27128148e-01f, -9.96388793e-02f, -1.44877732e-01f, -2.02566624e-01f, -1.08248144e-01f, -1.11973524e-01f, 8.69083777e-02f,
  1.59327731e-01f, -2.28900998e-03f, -1.27015471e-01f, -1.86676770e-01f, 1.54634610e-01f, 3.97934131e-02f, -1.75402299e-01f, -6.06892966e-02f, -2.41113789e-02f, 2.08967939e-01f,
  1.03077352e-01f, -8.97785425e-02f, 2.05210447e-02f, 3.42493467e-02f, -9.12837591e-03f, -2.00606361e-02f, 1.66224316e-02f, 6.20988123e-02f, -3.35742980e-02f, 1.37066506e-02f,
  7.58630559e-02f, -6.15564212e-02f, 7.71990418e-03f, 1.04574986e-01f, -8.28915536e-02f, -7.10925236e-02f, -1.01228327e-01f, -5.19339330e-02f, -2.02841777e-02f, 9.56268683e-02f,
  1.02154717e-01f, 7.44520593e-03f, -8.38176161e-02f, -2.41025835e-02f, -8.01166967e-02f, 1.39280245e-01f, 3.40324566e-02f, 1.12356447e-01f, -6.42114952e-02f, 6.82594031e-02f,
  5.61743102e-04f, -4.65276018e-02f, -1.17979955e-03f, 2.20776871e-02f, 5.65837324e-02f, -5.15841506e-02f, 5.52952364e-02f, -5.64574376e-02f, -2.70396080e-02f, 2.52424944e-02f,
  -5.66948727e-02f, -7.85875022e-02f, 2.49212384e-02f, 3.87404300e-02f, -1.54708950e-02f, -1.10586351e-02f, 3.67489047e-02f, -8.10794607e-02f, -5.83062023e-02f, -6.20053299e-02f,
  -6.69724345e-02f, -3.67314368e-03f, -6.49640486e-02f, -4.99948114e-03f, -4.82833721e-02f, 1.92408059e-02f, 1.66948140e-02f, 2.97019947e-02f, -1.69815570e-02f, 7.26384297e-02f,
  1.06274463e-01f, -2.01097474e-01f, -5.30795753e-03f, 1.09898239e-01f, 3.77682708e-02f, 6.62344545e-02f, -7.00680166e-02f, -5.95690571e-02f, 7.24461451e-02f, 2.89445817e-02f,
  2.91117746e-02f, 7.97530077e-03f, 6.00402169e-02f, -3.65033001e-02f, -6.67070374e-02f, 3.76740806e-02f, -5.74342608e-02f, -5.04319482e-02f, -3.43444385e-02f, -6.26839465e-03f,
  -5.71642444e-02f, -1.74107105e-02f, 1.24162007e-02f, -4.31001335e-02f, 8.64851177e-02f, 1.09033920e-01f, -6.15961030e-02f, 1.14016887e-02f, -4.83330935e-02f, -5.66366240e-02f,
  1.49635732e-01f, -1.38612941e-01f, 1.00700231e-02f, 3.00570559e-02f, -9.63091701e-02f, 1.47605032e-01f, 9.57158953e-02f, -7.70745275e-04f, 7.35981092e-02f, -5.24962880e-02f,
  -1.01552501e-01f, -8.78147706e-02f, 3.88274863e-02f, -2.19618902e-02f, 6.10933900e-02f, 2.43894476e-02f, -2.61506308e-02f, -1.88392997e-02f, 2.34714195e-01f, 1.22495383e-01f,
  2.59340741e-02f, 9.01690871e-02f, 8.71698633e-02f, 8.31526145e-02f, -3.19564492e-01f, -7.65421912e-02f, -8.78108293e-02f, -9.57289264e-02f, -8.14731047e-02f, -3.79865468e-01f,
  -2.16718242e-01f, -1.07786432e-01f, 2.40707815e-01f, 2.48425394e-01f, 3.45394574e-02f, 4.62522358e-03f, 1.36882007e-01f, -4.83253412e-02f, 9.22071487e-02f, 5.13224564e-02f,
  3.43927857e-03f, 1.09137714e-01f, 8.48888755e-02f, -2.30083149e-03f, 1.07326560e-01f, 1.40363630e-02f, 1.16918132e-01f, 1.18096344e-01f, 7.25694969e-02f, 5.91015145e-02f,
  -3.60679477e-02f, -4.97598536e-02f, -8.61230269e-02f, 5.50032817e-02f, -3.04403100e-02f, 2.85436343e-02f, 2.85948180e-02f, -1.16825970e-02f, -4.56882082e-02f, -1.76269785e-02f,
  6.20138124e-02f, 6.23201020e-02f, -1.01676650e-01f, -3.97395603e-02f, -4.22439389e-02f, -4.23941016e-02f, -1.52308689e-02f, -7.01125665e-03f, 1.48333600e-02f, 2.24706735e-02f,
  -5.49112931e-02f, -3.00781261e-02f, -4.03146520e-02f, -1.63553506e-01f, -1.65731922e-01f, -9.85763967e-03f, -4.69226539e-02f, -1.12483418e-02f, -1.13826796e-01f, 4.49740514e-02f,
  -5.24482951e-02f, -1.10204875e-01f, -2.32552569e-02f, -4.69586812e-03f, -1.14607982e-01f, -1.03580005e-01f, -4.20155972e-02f, -8.34747627e-02f, -1.42611796e-02f, -4.30717580e-02f,
  2.91407824e-01f, 1.69023037e-01f, 2.78914925e-02f, 9.61945280e-02f, 2.12543607e-02f, 1.31651312e-01f, 3.77026387e-02f, -4.79838289e-02f, -1.89956911e-02f, 3.56393494e-02f,
  4.69675623e-02f, 3.79198082e-02f, -1.66008435e-02f, 3.50068472e-02f, 3.31783853e-02f, 1.16806924e-01f, 1.70505732e-01f, 1.18781835e-01f, 1.02258816e-01f, 1.31739229e-01f,
  1.51819780e-01f, 2.53954958e-02f, 6.31724223e-02f, 1.29481256e-01f, 1.19298510e-01f, 8.02545920e-02f, -3.63253914e-02f, 9.06981900e-02f, 1.53918620e-02f, 3.10876697e-01f,
  -3.72444659e-01f, 2.46766895e-01f, 1.67443708e-01f, 1.95754599e-02f, 4.17650081e-02f, -1.55513987e-01f, -1.52573302e-01f, -6.94956109e-02f, -5.22821471e-02f, -4.31001037e-02f,
  -9.30766612e-02f, -1.53955877e-01f, 1.76077168e-02f, -3.26310694e-02f, -6.73428103e-02f, 1.27999097e-01f, 3.36425394e-01f, 7.10941628e-02f, -2.81139761e-01f, -2.75816321e-01f,
  -1.34289535e-02f, -3.42128240e-02f, -1.03053913e-01f, -1.08272076e-01f, 7.47772530e-02f, -2.20708281e-01f, 1.03303604e-01f, 1.88194942e-02f, -1.06811918e-01f, 1.75018921e-01f,
  -1.44977689e-01f, -1.23328775e-01f, -4.11194414e-02f, -3.20171379e-02f, 4.97440575e-03f, 6.68313056e-02f, -7.24632964e-02f, 7.05391094e-02f, -1.14754468e-01f, -4.12406698e-02f,
  5.44869062e-03f, -1.25392079e-01f, -7.53106773e-02f, -1.50407255e-01f, -1.02558620e-01f, -1.88308991e-02f, 9.26343277e-02f, 7.64696226e-02f, -1.02435239e-01f, 3.53036709e-02f,
  1.20871045e-01f, -2.34404821e-02f, -1.37397065e-03f, 1.50728866e-03f, -3.69430333e-02f, -6.35080934e-02f, -9.54137072e-02f, -2.94059329e-02f, -1.22739144e-01f, -1.43681541e-01f,
  8.78956690e-02f, -9.06022731e-03f, -3.87465768e-02f, -6.74592182e-02f, 1.38600424e-01f, 7.31709003e-02f, 7.02659562e-02f, 2.05193404e-02f, -4.91009392e-02f, -2.95312628e-02f,
  9.81296450e-02f, 4.91831191e-02f, -4.48542200e-02f, 1.19292356e-01f, -7.07798898e-02f, -1.78842265e-02f, 1.34044699e-02f, 5.45949675e-03f, 4.80248071e-02f, 5.51647283e-02f,
  -2.14211345e-02f, 9.58595946e-02f, 7.66522214e-02f, -2.16725422e-03f, 1.21299200e-01f, 2.01634467e-01f, -3.06894127e-02f, -9.63146910e-02f, -3.31823924e-03f, 4.28364202e-02f,
  -1.96070522e-01f, 1.33879274e-01f, -9.89720225e-03f, -6.74350262e-02f, 1.89087354e-02f, 3.11509930e-02f, -1.09031044e-01f, 5.39964363e-02f, -1.80849191e-02f, -2.17812825e-02f,
  -3.51963565e-02f, -4.71638106e-02f, -1.29771221e-03f, -1.22164218e-02f, -9.13579315e-02f, -8.14400837e-02f, 1.19187251e-01f, 5.79192229e-02f, -8.46087188e-02f, 3.19055840e-02f,
  1.12600289e-01f, -1.39171720e-01f, -1.56155020e-01f, -2.68981233e-02f, -1.56218305e-01f, -1.44541159e-01f, -2.24097043e-01f, -1.67614251e-01f, -2.52877414e-01f, -1.09812044e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.90315977e-01f, 2.27561802e-01f, -4.69489843e-02f, 2.55708694e-01f, 1.86931461e-01f, 9.57097672e-03f, -2.73579136e-02f, 8.51486027e-02f, 6.11484423e-02f, 7.52378702e-02f,
  1.86043531e-01f, 2.82974631e-01f, 1.68227538e-01f, 2.10548326e-01f, 1.74958259e-01f, 8.58906358e-02f, 2.07030382e-02f, 1.45319663e-02f, -5.63449264e-02f, 1.16866147e-02f,
  6.30656555e-02f, -1.69102803e-01f, -1.68521821e-01f, -1.86008051e-01f, -7.62294680e-02f, -3.55963670e-02f, -1.33210510e-01f, 7.37756770e-03f, 9.93453562e-02f, 2.00820267e-01f,
  2.58399725e-01f, 8.59409124e-02f, -7.55195469e-02f, 1.04698248e-01f, -2.93129310e-02f, -1.94671042e-02f, -2.06499379e-02f, 7.78502226e-02f, -1.27602536e-02f, -1.37438089e-01f,
  -1.00475393e-01f, -1.97728928e-02f, -2.98198331e-02f, -2.13615689e-02f, -2.16417238e-02f, -1.79594025e-01f, 1.87339801e-02f, 6.55987039e-02f, 1.34325668e-01f, 8.80796835e-02f,
  1.00430757e-01f, 1.28903911e-01f, 1.16933644e-01f, 4.12964188e-02f, 6.75860494e-02f, 5.63608482e-02f, -9.99169145e-03f, 2.22878475e-02f, 1.02207199e-01f, -3.86090130e-02f,
  7.20007345e-02f, 6.94260001e-02f, 1.75139621e-01f, 8.67502913e-02f, 5.82613098e-03f, 7.18765929e-02f, -4.30510901e-02f, -2.69191824e-02f, -2.88473424e-02f, -6.72474578e-02f,
  1.81084171e-01f, 2.57539183e-01f, 1.87747255e-01f, -7.42534772e-02f, 8.43315646e-02f, 2.40554698e-02f, 9.04734284e-02f, 6.56524524e-02f, 1.56190380e-01f, -5.85894659e-02f,
  1.56933978e-01f, -6.54037446e-02f, -2.44403146e-02f, -9.54166427e-02f, 3.45297195e-02f, 1.49122998e-01f, 6.85805529e-02f, 8.46558064e-02f, -4.00938839e-02f, -5.30038290e-02f,
  1.45100504e-01f, 2.07561046e-01f, 8.75691026e-02f, 9.07673538e-02f, 4.42983657e-02f, 6.17248341e-02f, 1.78833425e-01f, 9.95812640e-02f, 3.78662497e-02f, 5.51446341e-02f,
  1.87688470e-02f, -5.00319377e-02f, 6.94441915e-05f, 2.10126508e-02f, -1.12163313e-01f, -1.62619874e-01f, 8.27953964e-02f, 1.03208169e-01f, 1.37002364e-01f, 8.68992433e-02f,
  9.25131291e-02f, 3.79495174e-02f, 9.51305330e-02f, 6.81244284e-02f, 8.51859227e-02f, 5.10799773e-02f, -8.78047496e-02f, -3.61171812e-02f, -1.14181009e-03f, -1.61136284e-01f,
  1.06330387e-01f, 2.61533797e-01f, -2.16337323e-01f, 3.59582901e-01f, 2.57406831e-01f, -3.54836956e-02f, 1.27090946e-01f, 1.02206185e-01f, 1.00881532e-01f, 1.42758816e-01f,
  1.39980048e-01f, 2.52339333e-01f, 1.83060721e-01f, 2.07612529e-01f, 1.03268571e-01f, 1.65662080e-01f, 2.13150188e-01f, -1.47530539e-02f, -3.17504331e-02f, 9.28631052e-02f,
  2.44417429e-01f, 6.85612559e-02f, 2.74826046e-02f, 4.82439250e-02f, 3.25642169e-01f, 2.62532562e-01f, 5.36240004e-02f, 2.84738183e-01f, 2.12624371e-01f, 4.81204718e-01f,
  -1.39877513e-01f, 8.83269459e-02f, 5.14362492e-02f, 5.16666062e-02f, -7.98764750e-02f, -1.61151081e-01f, -4.70364876e-02f, -1.26210898e-01f, -1.47082269e-01f, -1.76922023e-01f,
  7.82138333e-02f, -1.20578282e-01f, 1.70875430e-01f, 9.56769884e-02f, -6.48404285e-02f, -9.66132730e-02f, 2.80251857e-02f, -8.55441317e-02f, 5.87648060e-03f, -1.39058679e-01f,
  1.84143960e-01f, 1.45158634e-01f, -2.55882256e-02f, -1.31066114e-01f, 4.29514647e-02f, -2.95446962e-02f, -5.23024276e-02f, -5.13590090e-02f, 9.19662230e-03f, 1.07650928e-01f,
  2.26318240e-02f, 1.53363660e-01f, -2.76291883e-03f, -5.24137095e-02f, 3.37095037e-02f, 9.43676978e-02f, 1.06981648e-02f, -8.46598204e-03f, 4.69258092e-02f, -9.46101695e-02f,
  -4.87359241e-02f, -7.41067082e-02f, -4.55024391e-02f, -3.57973091e-02f, -8.23318027e-03f, 6.56131953e-02f, 1.17678985e-01f, 4.27570157e-02f, -1.04864128e-01f, -5.34516275e-02f,
  -6.23144656e-02f, -9.36068967e-02f, -4.60075364e-02f, -1.88033544e-02f, 3.52149643e-02f, 1.36444522e-02f, 3.20051052e-02f, -4.82281633e-02f, -2.92176809e-02f, 6.51729777e-02f,
  -4.72426526e-02f, -5.24018183e-02f, 2.77658433e-01f, 1.81605816e-01f, 1.22917645e-01f, 3.78026590e-02f, 6.53393269e-02f, -1.76763255e-02f, 4.77291681e-02f, -6.84510991e-02f,
  -6.38846532e-02f, -2.31821109e-02f, 1.06413029e-01f, -1.04614303e-01f, -1.53414369e-01f, -2.23385945e-01f, -1.96047104e-03f, 8.40235725e-02f, -3.68027277e-02f, -9.15022194e-02f,
  -6.28546998e-02f, -1.25181019e-01f, -2.34741662e-02f, -1.36470094e-01f, -1.38809060e-04f, 5.86804980e-03f, -1.79520771e-01f, -1.29812852e-01f, -1.23978771e-01f, -1.36046678e-01f,
  2.95387298e-01f, -2.68623292e-01f, -3.38619620e-01f, -6.51518777e-02f, -1.97963476e-01f, -2.52003014e-01f, -3.45691442e-01f, -8.99945870e-02f, 2.49271356e-02f, -3.50209445e-01f,
  -1.56601876e-01f, 1.80742830e-01f, -6.62568510e-02f, -1.02688223e-01f, 1.64593920e-01f, -3.48019570e-01f, -2.96414286e-01f, 3.39325853e-02f, 2.72797734e-01f, 1.33521467e-01f,
  -7.02230483e-02f, -4.80336957e-02f, 1.34174973e-01f, 2.60077063e-02f, -3.26025367e-01f, -3.51282805e-02f, -2.83322126e-01f, -1.96446806e-01f, -1.93426505e-01f, -4.26663250e-01f,
  -2.98768252e-01f, 5.74116185e-02f, 4.17161696e-02f, 1.24775656e-01f, -2.01981906e-02f, 4.06031087e-02f, 6.39295876e-02f, 9.22324359e-02f, 6.03706203e-02f, -7.38523304e-02f,
  -7.31911361e-02f, 8.42076018e-02f, 1.46040305e-01f, 9.53117013e-02f, 1.56682823e-02f, -1.18583873e-01f, -1.89104732e-02f, 1.45809636e-01f, 7.90716410e-02f, -5.81324585e-02f,
  -4.19513993e-02f, 1.34284779e-01f, 1.28493980e-01f, -9.65044368e-03f, 9.11227837e-02f, 3.31333876e-02f, 4.12354879e-02f, 9.86391008e-02f, 2.38608960e-02f, -1.41162887e-01f,
  -1.65728956e-01f, -6.96608648e-02f, -3.06164771e-02f, -3.27689424e-02f, 5.15860878e-02f, 4.51980792e-02f, -3.60965095e-02f, -1.69443823e-02f, 9.66541395e-02f, -4.65371832e-02f,
  -2.66770963e-02f, -5.39996698e-02f, 6.72632903e-02f, 1.57425168e-03f, -5.46722002e-02f, -5.23965582e-02f, -1.76015887e-02f, 1.97516456e-02f, 8.30865726e-02f, -6.68732857e-04f,
  1.70211308e-02f, 8.50868691e-03f, 8.24556965e-03f, 9.38664898e-02f, -7.31737092e-02f, 5.43119051e-02f, 2.78207362e-02f, -7.17193559e-02f, -4.58132476e-02f, -1.39833521e-02f,
  -7.37201720e-02f, 5.79229929e-02f, -9.34069008e-02f, 7.46069252e-02f, 6.11645952e-02f, 5.26545122e-02f, 5.07114418e-02f, 1.02922089e-01f, -2.50899903e-02f, 1.73720513e-02f,
  4.07528765e-02f, -2.33565364e-02f, -1.30224100e-04f, -1.05750449e-02f, -3.61613855e-02f, 1.74006466e-02f, 4.89815371e-03f, 2.69414894e-02f, 1.06555790e-01f, -1.70888200e-01f,
  4.70245890e-02f, 1.12087525e-01f, 1.76527441e-01f, 9.42871533e-03f, -4.65354323e-02f, 1.98630826e-03f, -1.17679223e-01f, -1.21058598e-01f, 8.28637779e-02f, -2.69487679e-01f,
  5.26310146e-01f, 6.12511784e-02f, 2.48121426e-01f, -3.81255299e-02f, -3.29672962e-01f, -4.90683287e-01f, -5.68082094e-01f, -3.18638772e-01f, -2.02776819e-01f, 1.95492133e-02f,
  -1.91241175e-01f, -1.12649472e-02f, 3.37395929e-02f, -2.32159272e-02f, -8.82885680e-02f, -8.43153149e-02f, 3.22890244e-02f, 2.44007543e-01f, 7.13130534e-02f, 3.01845819e-02f,
  -8.21039751e-02f, 2.37813875e-01f, 2.77475685e-01f, 8.79910439e-02f, 5.21707833e-02f, -7.53768682e-02f, -2.90249358e-03f, -5.97826876e-02f, 4.25904384e-03f, 5.81902921e-01f,
  2.97964543e-01f, 2.55628079e-01f, 6.20216317e-02f, 1.62463322e-01f, 7.58302510e-02f, 1.51729211e-01f, 1.10727072e-01f, 8.45809877e-02f, -3.75941768e-02f, 8.25566873e-02f,
  7.16430554e-03f, 7.85079971e-02f, 1.94662763e-03f, 4.82024951e-03f, 7.17297345e-02f, 4.88223359e-02f, 2.47022193e-02f, 2.17642456e-01f, 6.10045530e-02f, 4.36201170e-02f,
  3.94258983e-02f, 5.43588772e-03f, -5.30653335e-02f, -1.78979218e-01f, -1.27164990e-01f, -9.98816788e-02f, -1.42501831e-01f, -1.62508879e-02f, -7.02100322e-02f, 8.45017433e-02f,
  -4.83197011e-02f, 3.90700474e-02f, -6.23511989e-03f, -3.25070992e-02f, -8.09216648e-02f, 3.17355841e-02f, 8.22608173e-03f, -1.59092531e-01f, -1.73585098e-02f, 9.48045105e-02f,
  -9.22288522e-02f, 5.35513051e-02f, 4.56896164e-02f, -2.74480339e-02f, 7.27172345e-02f, -3.18659544e-02f, -5.57738822e-03f, -4.13435549e-02f, -5.61804734e-02f, 4.16704230e-02f,
  4.44033323e-03f, -2.68291496e-02f, 7.88238272e-02f, 2.61057913e-02f, 6.47184178e-02f, -1.19369496e-02f, -1.13261836e-02f, -3.49924676e-02f, 9.94559191e-03f, -3.17669325e-02f,
  -2.36139506e-01f, -1.04117505e-01f, 9.09372494e-02f, 1.52809978e-01f, 9.16868821e-02f, 9.36255008e-02f, 1.66536137e-01f, 1.21073991e-01f, 9.74012837e-02f, 5.51093034e-02f,
  -5.15161045e-02f, 7.69437179e-02f, 1.45953093e-02f, 4.93214242e-02f, 2.95263231e-02f, 1.95481814e-02f, 4.40959744e-02f, 1.70543138e-02f, -2.98246313e-02f, 6.45976290e-02f,
  4.21668999e-02f, -1.83831230e-01f, -2.67587066e-01f, -2.84633279e-01f, -7.26196691e-02f, -1.91008165e-01f, -2.34109536e-01f, -2.65240576e-02f, -2.69032627e-01f, -2.47992501e-01f,
  -6.35748327e-01f, 1.76133573e-01f, -8.09595510e-02f, -4.45237845e-01f, 1.84453294e-01f, 3.80708337e-01f, 6.03949249e-01f, 8.44331682e-02f, -1.61902636e-01f, 1.50361046e-01f,
  6.44818395e-02f, -1.17238708e-01f, 2.28646360e-02f, 2.12342203e-01f, 1.82677984e-01f, 2.75639445e-01f, 1.85332656e-01f, -1.50899002e-02f, -1.91608876e-01f, -5.90552986e-02f,
  1.34492576e-01f, -2.21781537e-01f, -3.59932035e-01f, -2.31244370e-01f, -5.47113009e-02f, -1.98479652e-01f, -9.46896747e-02f, -4.68341783e-02f, 1.59529015e-01f, 1.05295785e-01f,
  2.77644712e-02f, -2.79144108e-01f, -7.26720458e-03f, -1.34701803e-01f, -5.63842617e-02f, -1.17202207e-01f, -3.79144028e-02f, -1.98644057e-01f, -2.30879690e-02f, -1.08260512e-02f,
  -2.07274467e-01f, 5.96135631e-02f, 3.00025716e-02f, -1.05498377e-02f, -9.00772288e-02f, -2.98943780e-02f, -5.36234230e-02f, -1.06695063e-01f, -6.08257130e-02f, 5.05942255e-02f,
  2.36389220e-01f, -3.36611085e-02f, -7.74098188e-02f, 1.34241790e-01f, 1.45417601e-01f, -1.05159573e-01f, -5.04211783e-02f, -1.42040804e-01f, 2.58648992e-02f, -1.44191489e-01f,
  6.89628348e-02f, -2.34502312e-02f, -1.76913124e-02f, -7.60641173e-02f, -5.02107143e-02f, 1.77988224e-02f, 3.62027921e-02f, 1.70648489e-02f, 7.40153939e-02f, -1.52011111e-01f,
  9.03392397e-03f, 1.94112509e-02f, 7.40873888e-02f, -2.55141854e-02f, 9.94926225e-03f, 8.83217826e-02f, 2.33589206e-02f, 3.51357199e-02f, -4.96215411e-02f, -4.84824814e-02f,
  -7.24883527e-02f, 4.29532081e-02f, -4.62634712e-02f, 8.46271142e-02f, 1.20524332e-01f, 6.35703560e-03f, -3.66189629e-02f, -1.14843026e-02f, -1.43871367e-01f, 5.77005446e-02f,
  -2.69727945e-01f, 6.84750006e-02f, -1.00242779e-01f, -4.08399105e-02f, -2.25673858e-02f, -6.08839206e-02f, -1.92755330e-02f, 4.81487326e-02f, 1.26303593e-02f, -5.51815592e-02f,
  4.43768948e-02f, 1.77956012e-03f, 5.60485981e-02f, 6.41936734e-02f, -7.35446364e-02f, 1.40428558e-01f, 8.22066292e-02f, 4.27431688e-02f, 4.97938916e-02f, -4.11077552e-02f,
  9.46651176e-02f, 1.37922287e-01f, -1.32446378e-01f, 2.35020705e-02f, 6.22429214e-02f, 6.32414818e-02f, -2.65008025e-02f, -1.24377906e-01f, 8.53017345e-03f, 6.54201061e-02f,
  -4.95514333e-01f, -2.06202000e-01f, 1.95761755e-01f, -1.25837445e-01f, -9.96743329e-03f, 7.75909126e-02f, 9.88643710e-03f, 2.66012773e-02f, -5.37256859e-02f, -6.93253055e-02f,
  8.78914744e-02f, 1.89967439e-01f, 2.24766567e-01f, 1.62746847e-01f, 1.90336868e-01f, -4.35451493e-02f, -1.14835367e-01f, 7.85217732e-02f, 3.50876689e-01f, 1.97064891e-01f,
  -4.31634188e-02f, -1.14193611e-01f, -1.71548247e-01f, 9.58950911e-03f, -6.31005466e-02f, 8.46513510e-02f, -1.08705819e-01f, -6.27209842e-02f, -3.43539082e-02f, -2.68275529e-01f,
  5.90428412e-01f, -1.73536807e-01f, 1.54591903e-01f, -3.78160477e-02f, -5.62495068e-02f, -1.27659058e-02f, 4.91629913e-02f, 1.01175364e-02f, -1.97217576e-02f, 1.36464790e-01f,
  4.71422635e-02f, -1.05742864e-01f, -1.09308988e-01f, -3.46036293e-02f, -1.00002877e-01f, 1.90993920e-02f, -1.66431472e-01f, -9.30349380e-02f, 6.73083495e-03f, 7.45575652e-02f,
  -6.66358694e-02f, -3.82352881e-02f, 7.43473992e-02f, 6.81066960e-02f, 6.55125361e-03f, 1.45390317e-01f, 8.16491470e-02f, -7.08611682e-02f, 8.37530661e-03f, 1.66916717e-02f,
  1.03803322e-01f, 9.01196525e-02f, -4.31882404e-02f, 9.64298844e-02f, -7.91659877e-02f, 2.97206137e-02f, 3.84971574e-02f, -3.81481089e-02f, -7.54236206e-02f, -1.66729107e-01f,
  -1.30491585e-01f, 1.13373073e-02f, 1.80009492e-02f, -2.05077939e-02f, -9.73108262e-02f, -1.43464804e-01f, 1.17543228e-02f, 7.84926936e-02f, -1.12583250e-01f, -1.52711868e-01f,
  -5.92614710e-02f, 8.54212791e-03f, -6.07049428e-02f, -1.15739316e-01f, -1.78451315e-01f, -6.64126948e-02f, 2.88118441e-02f, -6.97892904e-02f, -2.42233891e-02f, -1.00173019e-01f,
  2.81914741e-01f, -2.18858067e-02f, 1.80568501e-01f, 9.63000115e-03f, -5.85372001e-02f, -1.82477027e-01f, -1.94981485e-03f, 4.17781174e-02f, 1.34354994e-01f, 1.78540185e-01f,
  5.35230711e-02f, 4.76510935e-02f, -6.11691624e-02f, 1.39864460e-02f, 1.05262011e-01f, -1.91557854e-02f, -9.95185003e-02f, 4.24699411e-02f, 1.72159653e-02f, 2.27450058e-02f,
  -1.26282185e-01f, 9.83148697e-04f, 2.55557805e-01f, 1.80107787e-01f, 1.99710667e-01f, 1.89145997e-01f, 3.13226134e-01f, 1.97848350e-01f, 2.38501310e-01f, 1.57895967e-01f,
  -1.19711913e-01f, -1.00448020e-01f, -1.98129341e-01f, 1.04190279e-02f, 7.54394755e-02f, 3.68762836e-02f, -1.94905743e-01f, 2.59881411e-02f, -5.71845286e-02f, -2.74540424e-01f,
  -6.71272054e-02f, 5.71679734e-02f, -1.09920822e-01f, -3.17641981e-02f, -7.82306790e-02f, -2.67537445e-01f, -1.91270038e-01f, -1.10447384e-01f, 1.63132370e-01f, 3.12789291e-01f,
  5.11201769e-02f, -2.74156046e-04f, 8.28235000e-02f, 2.45513972e-02f, -4.72181253e-02f, -5.26735336e-02f, -1.94570452e-01f, 2.34310050e-02f, -1.04304388e-01f, -1.90065935e-01f,
  -4.17480133e-02f, -5.73326759e-02f, 8.81000683e-02f, 8.31787512e-02f, -6.89997151e-02f, 1.38464227e-01f, -4.98003177e-02f, 3.88290808e-02f, 1.16414294e-01f, -1.06749579e-01f,
  4.50233296e-02f, -2.01928783e-02f, 6.08783029e-02f, 4.85831648e-02f, -4.32760492e-02f, 7.68025443e-02f, 1.13119230e-01f, -4.17127721e-02f, -8.23175609e-02f, 3.96368429e-02f,
  9.43844095e-02f, 1.13080785e-01f, 1.62361160e-01f, -8.69343951e-02f, 4.07523438e-02f, 2.09388323e-02f, -1.15075167e-02f, 1.47007689e-01f, -8.54592994e-02f, -2.16527984e-01f,
  -1.54388130e-01f, -3.82829942e-02f, 2.38013528e-02f, -3.33205126e-02f, 1.18394522e-02f, 9.99064222e-02f, -9.39077362e-02f, 7.51989111e-02f, -3.59896384e-02f, 3.10668740e-02f,
  -1.56135357e-03f, -1.75995350e-01f, -9.65166464e-02f, -1.79976240e-01f, -6.94899037e-02f, 5.36807254e-02f, -8.24609324e-02f, -1.71506077e-01f, 3.61633487e-02f, 4.55418006e-02f,
  1.33715421e-01f, 1.89747483e-01f, 1.98752340e-02f, 1.05564237e-01f, 6.90417066e-02f, -1.14116855e-01f, 5.38463891e-02f, 6.93595186e-02f, -7.77536407e-02f, 1.08338177e-01f,
  -1.38254479e-01f, -5.67447320e-02f, -1.83404610e-01f, 9.86919105e-02f, -6.47798777e-02f, -1.35671552e-02f, -9.77242142e-02f, 1.20812252e-01f, 7.89737999e-02f, 6.07553199e-02f,
  1.29345864e-01f, -1.13046870e-01f, 3.04513089e-02f, 7.98228160e-02f, -2.72076149e-02f, 5.41792884e-02f, -1.50638176e-02f, 6.57366589e-02f, 3.75081040e-02f, 1.52480572e-01f,
  1.32507607e-01f, -1.08642414e-01f, 5.11240214e-02f, -7.96687156e-02f, -5.78361563e-02f, -8.13776627e-02f, -7.69626349e-02f, -6.87799156e-02f, -5.47152571e-02f, -3.41070354e-01f,
  6.58879161e-01f, 5.64258277e-01f, 4.60867941e-01f, 1.47431478e-01f, -4.40594777e-02f, 1.10348724e-01f, 4.93734539e-01f, 2.10223049e-01f, 1.15383312e-01f, 1.54617608e-01f,
  1.14102356e-01f, -2.30388612e-01f, -6.51850551e-02f, -4.41294424e-02f, 1.69181257e-01f, 7.32141137e-02f, 5.37128933e-03f, -2.03532800e-02f, 1.12003721e-01f, 6.73008040e-02f,
  -2.21986517e-01f, 8.11756551e-02f, -2.04994902e-02f, 1.23900147e-02f, 7.73567110e-02f, -1.82477400e-01f, -6.49076179e-02f, 7.04097748e-02f, 2.39025373e-02f, 2.14781892e-02f,
  1.83284387e-01f, 6.07188940e-01f, -1.17465034e-01f, -8.64560083e-02f, 6.09243885e-02f, 4.12690565e-02f, -2.99965087e-02f, 4.01336439e-02f, -1.42595381e-01f, -5.15579730e-02f,
  -7.59817362e-02f, -6.24778122e-02f, 5.52177988e-02f, 9.26483646e-02f, 6.76594004e-02f, 4.72641997e-02f, 5.87155111e-02f, 1.90668061e-01f, 2.26904582e-02f, 5.46640493e-02f,
  -2.41930485e-02f, 6.50429726e-02f, 2.21348867e-01f, 1.33278538e-02f, 1.47516996e-01f, -1.03257626e-01f, 1.13952598e-02f, 1.47868335e-01f, 7.38514662e-02f, 7.56889284e-02f,
  -2.17173710e-01f, -1.73205853e-01f, -5.63421436e-02f, -1.33653939e-01f, -9.89597756e-03f, -1.90226346e-01f, -1.49444798e-02f, -4.17231470e-02f, 5.31249447e-04f, -4.98202890e-02f,
  -1.12914471e-02f, 2.38202009e-02f, 1.72787160e-01f, -4.25916389e-02f, -1.13630757e-01f, -2.80340612e-02f, 1.54749751e-01f, 5.22455685e-02f, -4.99536507e-02f, -6.00312883e-03f,
  6.88891336e-02f, 9.91227031e-02f, 8.20593014e-02f, 8.88445005e-02f, -2.07082462e-03f, 4.54673683e-03f, 2.66216695e-03f, -2.76750345e-02f, -1.13464482e-01f, -4.25048806e-02f,
  -1.30709410e-01f, -2.27028485e-02f, -7.24944621e-02f, 4.98842932e-02f, -1.28335471e-03f, -4.27198112e-02f, -2.65125856e-02f, -6.02439977e-02f, -1.99822318e-02f, 2.12796722e-02f,
  1.27927899e-01f, 2.35305876e-02f, 2.04256494e-02f, 1.16576552e-01f, -9.24487114e-02f, -1.88127726e-01f, -8.15719143e-02f, 3.60889151e-03f, -3.08748218e-04f, 4.53265570e-02f,
  -1.30322704e-03f, -8.47472548e-02f, -2.76517086e-02f, -2.64255442e-02f, -7.37367421e-02f, -2.58025825e-01f, -1.89416453e-01f, 2.02388857e-02f, 5.92950098e-02f, -1.15129709e-01f,
  8.74826968e-01f, -3.60990852e-01f, 2.30844524e-02f, 7.77443200e-02f, -7.20271915e-02f, -3.52127291e-02f, -1.78543791e-01f, 4.07376699e-02f, 1.24303341e-01f, -5.01211323e-02f,
  2.51528025e-01f, 3.44492316e-01f, 3.26529562e-01f, 3.39190304e-01f, 3.58179629e-01f, -1.31271496e-01f, -2.02425495e-01f, 2.76475102e-01f, 3.21722984e-01f, 7.17922449e-02f,
  -8.71670432e-03f, -1.75249666e-01f, 1.07524507e-02f, -7.17993453e-02f, -3.61248612e-01f, 4.28653136e-02f, -3.09211433e-01f, -3.10588926e-01f, -1.10951364e-01f, -2.60175407e-01f,
  -8.88239406e-03f, -1.38297370e-02f, 1.02815680e-01f, 4.01123874e-02f, -1.28503844e-01f, 5.80118131e-03f, 7.00768037e-03f, -3.90081853e-02f, -3.51448841e-02f, -8.59392136e-02f,
  1.80796850e-02f, 2.58053355e-02f, 8.96868482e-03f, -1.10505931e-01f, -1.57966211e-01f, -1.01803161e-01f, -1.64551511e-01f, 1.14588983e-01f, 1.52337596e-01f, -7.26228505e-02f,
  -6.94443583e-02f, 7.24293292e-02f, 4.49192114e-02f, -2.02649552e-02f, 1.23320654e-01f, 1.21004201e-01f, -1.70620665e-01f, 6.31962270e-02f, 4.51588780e-02f, -1.74896732e-01f,
  -2.15567946e-02f, 1.16593875e-01f, -4.04817797e-02f, -2.63786153e-03f, 3.42864394e-02f, 6.12069890e-02f, 3.35341156e-03f, 1.55812351e-03f, -2.05349717e-02f, -5.43944836e-02f,
  -6.94423309e-03f, 8.47314298e-03f, -8.46406519e-02f, 2.50807330e-02f, -4.25141528e-02f, 6.44496456e-02f, 3.60380746e-02f, -9.42035392e-02f, -5.22827283e-02f, 6.26086071e-03f,
  -5.85838500e-03f, 7.29367137e-02f, -4.84692901e-02f, -2.67962292e-02f, -4.69055437e-02f, 9.56548899e-02f, 5.63844070e-02f, 4.69163768e-02f, -8.96573663e-02f, 4.36854810e-02f,
  -1.01931788e-01f, 3.14799696e-01f, 7.40961283e-02f, 3.88370678e-02f, 4.90622688e-03f, -1.25956908e-01f, 9.22189131e-02f, -3.56042199e-02f, -6.52719289e-02f, -3.89971510e-02f,
  -1.52064145e-01f, -1.07422182e-02f, -9.15867686e-02f, -5.13114817e-02f, -6.74111173e-02f, -3.96683849e-02f, -6.96063191e-02f, 1.59597754e-01f, -3.27539816e-02f, -1.42986447e-01f,
  -1.05485320e-01f, 7.21804872e-02f, 1.61564171e-01f, 1.20165408e-01f, -8.71031135e-02f, 2.93545485e-01f, -5.78240268e-02f, -1.44303620e-01f, 2.15557322e-01f, -1.30571902e-01f,
  6.58356071e-01f, -1.25307232e-01f, 7.43464231e-02f, 2.48331308e-01f, 1.94291174e-01f, 2.64053375e-01f, 3.96352917e-01f, 2.20166102e-01f, 2.03813940e-01f, 2.43616387e-01f,
  1.09262787e-01f, -1.38236478e-01f, -1.14586644e-01f, -1.67077780e-01f, -8.03164542e-02f, -4.97766547e-02f, -8.03633630e-02f, 2.44123861e-02f, 1.16276279e-01f, 1.77032679e-01f,
  -6.31428063e-02f, 2.25202926e-02f, 8.99816155e-02f, 4.65604141e-02f, -1.04164332e-01f, -3.49435993e-02f, -1.70373935e-02f, -1.31135657e-01f, -2.09751457e-01f, -3.04505348e-01f,
  -3.19171309e-01f, -1.46566316e-01f, 8.23524818e-02f, -1.58420637e-01f, 4.24806997e-02f, 1.41408235e-01f, 3.76321748e-02f, 1.04603380e-01f, 1.07289165e-01f, 1.53413966e-01f,
  -2.17983186e-01f, -1.44183844e-01f, 9.58085060e-02f, 1.73639841e-02f, 2.79427413e-02f, 4.41614948e-02f, -6.60981163e-02f, -1.18757643e-01f, -1.15954812e-04f, -7.49827847e-02f,
  -1.35968953e-01f, 2.81392019e-02f, 1.30797222e-01f, 1.05917297e-01f, -4.06849347e-02f, -1.00211993e-01f, -2.07910389e-02f, -1.27920240e-01f, -1.02167204e-01f, 2.68893354e-02f,
  1.00339286e-01f, 1.10653214e-01f, -5.02083898e-02f, 1.04500763e-01f, 6.13139849e-03f, -1.09367836e-02f, -2.20233425e-02f, -9.76470113e-02f, -1.85140502e-02f, 5.27079366e-02f,
  -5.73014505e-02f, 5.19759133e-02f, 1.00112826e-01f, 3.68124768e-02f, -9.48686246e-03f, 5.19460887e-02f, -1.71892550e-02f, -6.89936727e-02f, -4.17555310e-02f, -4.78328392e-02f,
  -9.73947570e-02f, -1.81772299e-02f, -6.15661591e-02f, -1.14432216e-01f, 6.47810176e-02f, -3.55186872e-02f, -5.11170886e-02f, 8.13489109e-02f, 5.97338937e-02f, 1.37155488e-01f,
  -9.60117802e-02f, -3.57827358e-02f, -3.66735980e-02f, -2.11120367e-01f, -1.14871122e-01f, 2.70063849e-03f, -1.81503184e-02f, -1.34489283e-01f, -1.37362987e-01f, 1.04382131e-02f,
  -8.44131038e-02f, -5.48271798e-02f, 4.28949483e-02f, 5.80828302e-02f, 2.26484537e-01f, 1.50633514e-01f, -5.93690835e-02f, -1.15079343e-01f, -8.31167549e-02f, -6.90630544e-03f,
  -2.82460470e-02f, 2.79746026e-01f, 5.98620623e-02f, 2.04752032e-02f, -1.07510284e-01f, 4.35501821e-02f, 6.69648498e-02f, 3.68952914e-03f, 1.21041961e-01f, 2.87227243e-01f,
  -1.05803132e-01f, -1.83476239e-01f, -1.47997215e-01f, 3.14732157e-02f, 1.77372366e-01f, 9.75706801e-02f, -2.07139030e-02f, 2.03859448e-01f, 1.59316108e-01f, -6.61084354e-02f,
  6.76246211e-02f, 9.40525308e-02f, -1.28198668e-01f, -5.79452962e-02f, -1.31689072e-01f, -3.63499790e-01f, -3.21199238e-01f, -1.16039991e-01f, 1.90415874e-01f, 1.89303711e-01f,
  1.45817295e-01f, -5.85624017e-02f, -8.75263587e-02f, 3.57763022e-02f, 5.57078198e-02f, -3.89398485e-02f, -3.50665063e-01f, -9.91427302e-02f, -1.40284672e-01f, -2.75129259e-01f,
  -1.55438766e-01f, 7.47501552e-02f, 2.55958475e-02f, 3.13460529e-02f, -4.02947776e-02f, -1.43489158e-02f, 1.04161985e-01f, -7.10493922e-02f, -1.99679304e-02f, -1.00592248e-01f,
  -1.73115447e-01f, 6.70128018e-02f, 4.79032025e-02f, 9.78391021e-02f, 7.30814040e-02f, -9.33309644e-03f, 2.00514290e-02f, 5.17271943e-02f, -1.28335357e-01f, 6.70928806e-02f,
  9.26836208e-02f, 1.17801718e-01f, 1.03836199e-02f, 7.10237250e-02f, -1.37890220e-01f, -1.21591829e-01f, -4.08615023e-02f, 7.31297806e-02f, -2.37846211e-01f, -2.92746156e-01f,
  2.16938257e-02f, 6.92611486e-02f, 2.41263025e-02f, 4.51274402e-02f, -2.55733114e-02f, 4.83310558e-02f, -1.48891443e-02f, 4.24697157e-03f, 7.10343197e-02f, 1.39659410e-02f,
  1.51551589e-02f, 6.36342987e-02f, 2.62843575e-02f, -1.68985054e-01f, -1.26559066e-03f, -3.42623075e-03f, -2.55746823e-02f, -1.12981215e-01f, -1.24392301e-01f, -5.55973090e-02f,
  -4.07480896e-02f, 2.73891054e-02f, 2.03829408e-02f, 2.21086051e-02f, -7.89293796e-02f, -1.19878173e-01f, -4.18698974e-02f, 1.05103264e-02f, -9.13680568e-02f, -5.29308431e-02f,
  -7.73825794e-02f, -7.42740035e-02f, -1.18769698e-01f, -1.39913231e-01f, 5.36962673e-02f, -6.87907934e-02f, -1.68068677e-01f, 1.93430018e-02f, -2.95695825e-03f, 1.41020902e-02f,
  -4.11174670e-02f, -1.30686969e-01f, -1.48653448e-01f, 6.49743974e-02f, 3.94442901e-02f, -1.17352478e-01f, 2.56625470e-04f, -6.69160783e-02f, -1.36790901e-01f, 8.97359028e-02f,
  -8.03729221e-02f, -2.12197334e-01f, -1.58187822e-01f, -1.13113858e-01f, -8.45221058e-02f, -6.61110207e-02f, -2.12950379e-01f, -8.78365934e-02f, -2.72499889e-01f, -3.76242489e-01f,
  1.88350424e-01f, 2.36963749e-01f, -3.45197380e-01f, 1.67373493e-01f, -1.99947074e-01f, -1.35706007e-01f, -9.96461734e-02f, 2.75374800e-01f, 3.48597735e-01f, -1.56177999e-02f,
  -1.01103723e-01f, 4.66419570e-02f, 1.05234884e-01f, -9.18798894e-02f, -2.35553637e-01f, 2.02081930e-02f, -3.55049185e-02f, -2.82340765e-01f, -2.11299554e-01f, -2.92198956e-01f,
  -1.58959731e-01f, 6.81214258e-02f, -9.04299915e-02f, 5.41111687e-03f, -5.64775197e-03f, -1.47679802e-02f, 9.12723988e-02f, 2.33147740e-02f, -2.20911443e-01f, -2.23531246e-01f,
  -2.30227321e-01f, -2.16367275e-01f, -1.72566682e-01f, -1.34477153e-01f, -6.50788695e-02f, -6.06847890e-02f, -1.76599383e-01f, -2.18759757e-02f, 1.03819659e-02f, -1.91817116e-02f,
  -2.08894104e-01f, -1.23542406e-01f, -3.58866863e-02f, -1.37330117e-02f, 7.44906887e-02f, -9.35309827e-02f, 2.08506305e-02f, -9.35795531e-03f, -1.58438683e-01f, -1.48636922e-01f,
  -1.69527888e-01f, -1.92136928e-01f, -2.12050438e-01f, -1.53065339e-01f, -1.51966825e-01f, -3.35238487e-01f, -1.01590611e-01f, -1.16761200e-01f, -2.15855747e-01f, 2.63542771e-01f,
  3.69089730e-02f, -1.48270428e-02f, -6.14967868e-02f, 4.84455787e-02f, -9.46325622e-03f, 2.45822053e-02f, -6.84077591e-02f, -3.52434814e-02f, -3.61591242e-02f, 3.62823457e-02f,
  5.70870563e-02f, -8.00947472e-02f, 7.48877302e-02f, 4.52904217e-02f, -1.92891341e-02f, -3.64864096e-02f, -2.74252295e-02f, 2.91302130e-02f, -6.73108026e-02f, -4.79577715e-03f,
  4.85919192e-02f, -8.12778249e-02f, 1.10095961e-03f, 6.36237161e-03f, -5.35801128e-02f, 6.97087571e-02f, 6.31248653e-02f, -7.08333701e-02f, -3.31441164e-02f, -1.04474626e-01f,
  3.45641285e-01f, -2.11728305e-01f, 1.10611238e-01f, 6.20542690e-02f, 1.20965779e-01f, 1.41153960e-02f, -2.19352022e-02f, 2.64853686e-02f, 5.96369617e-02f, -9.80925858e-02f,
  -1.24679893e-01f, 7.43548945e-02f, -2.88892742e-02f, 3.68815996e-02f, -7.44684935e-02f, -4.65829372e-02f, 7.33178109e-02f, 6.64424822e-02f, 5.26559167e-02f, 5.05394489e-02f,
  2.38119334e-01f, 1.79635495e-01f, 1.64687365e-01f, 6.79572001e-02f, 2.30139837e-01f, -1.26754597e-01f, 3.69932093e-02f, 1.21919326e-01f, 6.51840633e-03f, 3.53097856e-01f,
  -4.11776155e-01f, -1.66249990e-01f, -1.18638396e-01f, -2.25874200e-01f, -4.23378199e-02f, 1.34399399e-01f, -5.57439998e-02f, 1.76943000e-02f, 1.17359206e-01f, -2.60270536e-01f,
  -5.99601120e-02f, -2.49399850e-03f, -2.56840736e-01f, -1.23635769e-01f, -1.63841069e-01f, -2.53572226e-01f, -3.14747810e-01f, -1.79254055e-01f, 1.53792083e-01f, 2.55681843e-01f,
  -3.75510450e-03f, -1.40099555e-01f, -7.38713592e-02f, 5.79060838e-02f, -1.41569674e-02f, 3.04677561e-02f, -2.11802065e-01f, -3.61394435e-02f, -3.30060758e-02f, -2.11860538e-01f,
  -1.64077595e-01f, 1.75358862e-01f, 1.57385886e-01f, -3.00968532e-02f, -6.37506694e-02f, 6.12446479e-02f, 6.00554943e-02f, -1.25690266e-01f, 7.93201476e-02f, -8.95179510e-02f,
  -7.55203813e-02f, 8.52846280e-02f, 6.53657541e-02f, 8.35689902e-03f, 1.36258425e-02f, 3.54380533e-02f, -3.10755819e-02f, 1.63161978e-02f, -1.07311942e-01f, 7.91987479e-02f,
  -1.21743962e-01f, -8.44269022e-02f, 7.74724223e-03f, 7.47876242e-02f, -1.80551913e-02f, 3.70020159e-02f, 1.36120841e-01f, 2.15182349e-01f, 1.67643458e-01f, 7.75109604e-02f,
  4.89703715e-02f, 9.68171433e-02f, 1.33488387e-01f, -3.26509923e-02f, 1.68778151e-02f, 5.69960028e-02f, -3.52655202e-02f, -2.16505434e-02f, 9.73872393e-02f, -9.51679945e-02f,
  1.29813716e-01f, 3.13561708e-02f, 6.20021299e-02f, -1.01832710e-01f, 5.59227988e-02f, 7.73893669e-02f, -3.75271514e-02f, -5.98203465e-02f, 2.72744484e-02f, 1.11448755e-02f,
  4.47116084e-02f, 6.40346557e-02f, 3.10679302e-02f, 4.87180650e-02f, -1.32498145e-02f, -7.45724770e-04f, 3.27079967e-02f, -9.54477191e-02f, -9.82262567e-03f, -6.79404140e-02f,
  -8.40406641e-02f, 6.35186806e-02f, -2.38546237e-01f, 1.48338769e-02f, 2.22526770e-02f, -1.31058246e-02f, -2.21361704e-02f, -1.35334313e-01f, -6.01294190e-02f, -1.43913567e-01f,
  2.01666161e-01f, -4.03142087e-02f, -1.08644806e-01f, -1.59965940e-02f, 7.50228250e-03f, 1.32743809e-02f, -6.07454740e-02f, -7.90722966e-02f, 7.36033022e-02f, -2.52853297e-02f,
  -6.16290420e-02f, -2.20805064e-01f, -2.72515684e-01f, -8.87326226e-02f, -3.20801213e-02f, -2.27996409e-01f, 7.09439721e-03f, 2.67678630e-02f, -1.22234374e-01f, -2.54841596e-01f,
  -3.62777412e-01f, 1.90282971e-01f, -3.25895920e-02f, -1.94864392e-01f, 1.73020075e-04f, 4.71397117e-02f, 2.73535669e-01f, 2.39588302e-02f, -1.17161144e-02f, -6.20810129e-02f,
  -1.32582545e-01f, 7.36497417e-02f, 2.91813966e-02f, 6.70617595e-02f, 2.29219630e-01f, 2.39764854e-01f, 2.79284358e-01f, 1.83887064e-01f, -5.19442260e-02f, -2.19503101e-02f,
  1.41271204e-01f, -1.60675179e-02f, -2.65213996e-01f, -5.19807115e-02f, -2.15019975e-02f, -3.76709141e-02f, 8.31487700e-02f, 9.01796073e-02f, -1.47308707e-02f, 1.70618191e-01f,
  5.90275005e-02f, -1.06951125e-01f, -3.59111745e-03f, 5.79854660e-02f, -1.19108357e-01f, -5.44546843e-02f, -1.31572336e-01f, 2.24024765e-02f, -7.20042512e-02f, 1.37490228e-01f,
  3.67897898e-02f, 2.79077571e-02f, 4.33484279e-02f, 7.98294842e-02f, -5.79783432e-02f, -4.73861732e-02f, 6.72172979e-02f, -4.32457626e-02f, -5.61982021e-02f, -1.64441556e-01f,
  1.96738377e-01f, -6.16790429e-02f, -5.00671864e-02f, 8.84176511e-03f, -1.00874372e-01f, -4.31018248e-02f, -1.27442241e-01f, -6.63249120e-02f, -9.04985145e-02f, 9.17444378e-03f,
  -3.35280076e-02f, 7.82109499e-02f, 4.91088768e-03f, 1.19987600e-01f, 2.09624663e-01f, 8.54108855e-02f, 9.71442834e-02f, -2.73096305e-03f, 7.54710808e-02f, 2.83428635e-02f,
  -8.65575820e-02f, -6.04033619e-02f, -3.09922025e-02f, 1.87498499e-02f, -6.32661059e-02f, 3.31065692e-02f, -3.04351337e-02f, 2.98003433e-03f, -1.38431964e-02f, -5.43166287e-02f,
  1.78881697e-02f, -3.19107100e-02f, -1.54443935e-01f, 8.74822773e-03f, -8.21879432e-02f, 1.09055780e-01f, 4.73251939e-02f, -9.23310518e-02f, -3.39550264e-02f, 1.57527847e-03f,
  -1.31898656e-01f, 5.12010455e-02f, -3.64193227e-03f, 5.49289398e-02f, 1.11444136e-02f, -3.71734574e-02f, -1.05278574e-01f, 2.96335928e-02f, -2.16686130e-02f, -9.41324607e-02f,
  -1.84434086e-01f, -1.99145917e-02f, -1.19044028e-01f, -4.91601340e-02f, -2.38694679e-02f, -1.30265772e-01f, -6.97997659e-02f, 6.17660694e-02f, -1.09510727e-01f, -2.86813136e-02f,
  4.60840482e-03f, -3.03899087e-02f, -6.27047345e-02f, 4.77874167e-02f, -1.00602180e-01f, -1.31869227e-01f, -1.04601339e-01f, -8.91112909e-02f, -1.52910620e-01f, -1.23284854e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -6.15283549e-02f, 5.89619987e-02f, -1.26436442e-01f, 1.72097892e-01f, 1.68164134e-01f, -5.98026402e-02f, -7.36554991e-03f, 7.15283900e-02f, 1.06065854e-01f, 1.86783627e-01f,
  3.13585042e-04f, 1.08599596e-01f, -1.27980243e-02f, -1.95799172e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.18330687e-01f, 4.84831911e-03f, 1.74548794e-02f, 1.80355981e-02f, -1.06248178e-01f, -6.02092445e-02f, -6.13205172e-02f, -1.31305754e-01f, 2.11746749e-02f, 1.58920065e-01f,
  -2.59513557e-02f, -1.43962443e-01f, 2.94200871e-02f, -2.78897528e-02f, -6.44780416e-03f, -1.09056056e-01f, -3.17959338e-02f, 4.58274642e-03f, 2.58792993e-02f, -5.79003841e-02f,
  -1.24535942e-03f, -9.49762911e-02f, -3.63083780e-02f, 1.29767120e-01f, 1.27861246e-01f, 1.74422801e-01f, 1.15750559e-01f, -7.09109530e-02f, -1.58413485e-01f, 5.56599116e-03f,
  9.07233730e-02f, -1.42602608e-01f, -3.28921601e-02f, 1.30677789e-01f, -7.49278739e-02f, -1.88541234e-01f, 2.19482407e-02f, 1.29338160e-01f, -1.98399555e-02f, 1.31034702e-01f,
  2.13036016e-02f, -1.07282631e-01f, 1.96497992e-01f, -2.38184985e-02f, -1.75416231e-01f, 5.91807999e-02f, 2.71880534e-02f, 1.24971747e-01f, 5.69802783e-02f, 4.12355736e-02f,
  1.18179042e-02f, -1.39531001e-01f, 2.43169352e-01f, -3.86265367e-01f, 2.59149950e-02f, 7.39836786e-03f, 2.24899828e-01f, 1.50413364e-01f, 2.19652608e-01f, 8.77376273e-02f,
  -2.76263412e-02f, 1.05503341e-02f, 1.58303291e-01f, -1.42342180e-01f, 6.43242821e-02f, -1.78040173e-02f, 1.45230293e-01f, 3.94203104e-02f, 5.29988036e-02f, -7.60766268e-02f,
  -5.44571020e-02f, -6.08753935e-02f, -1.89022064e-01f, 1.82007924e-02f, -2.74016540e-02f, 1.47422791e-01f, 3.05689108e-02f, -3.80893052e-02f, -3.80756408e-02f, 4.46989313e-02f,
  1.82044301e-02f, -5.94712123e-02f, 3.60551849e-02f, -8.87680575e-02f, 3.16547677e-02f, -1.84643343e-02f, 1.31152838e-01f, -2.86248356e-01f, -1.98523089e-01f, -1.22713029e-01f,
  -1.82154119e-01f, -2.71805637e-02f, -4.52522561e-02f, -3.99386622e-02f, -2.54320502e-01f, 2.61640153e-03f, -4.67343517e-02f, 1.37920335e-01f, 2.08416566e-01f, 1.02011450e-01f,
  -8.46849307e-02f, 2.55463809e-01f, 3.67352962e-02f, 8.11044220e-03f, 9.05439705e-02f, 3.89036357e-01f, 2.65464522e-02f, -1.00671547e-02f, -3.13048810e-02f, 6.07193075e-03f,
  3.90027128e-02f, 1.98326185e-02f, 8.13935511e-03f, 1.08860150e-01f, 9.90833342e-02f, -1.05512746e-01f, 1.38102137e-02f, -6.09601587e-02f, -8.82073268e-02f, 6.35137334e-02f,
  4.80214357e-02f, -2.52738267e-01f, -2.40615487e-01f, -2.24990815e-01f, 2.40532845e-01f, 5.15076481e-02f, 2.54072905e-01f, -1.92044929e-01f, -6.32517831e-03f, -1.35424778e-01f,
  -1.03262134e-01f, -9.31929424e-02f, 4.97456416e-02f, -1.29274324e-01f, -2.94680074e-02f, 1.09372728e-01f, 1.32651463e-01f, -8.77818018e-02f, 1.29300579e-02f, -1.23792648e-01f,
  -5.80771193e-02f, -7.70957321e-02f, 3.05937063e-02f, 2.32412573e-02f, -1.18740179e-01f, -1.69371307e-01f, -7.30202571e-02f, -9.37928930e-02f, -1.62980676e-01f, -1.51424021e-01f,
  -6.10893182e-02f, -3.98321748e-02f, 1.61575764e-01f, -9.36454013e-02f, -1.25929555e-02f, 2.38395974e-01f, 2.39399612e-01f, 2.95960531e-02f, 7.04723373e-02f, -8.90088547e-03f,
  -1.13686949e-01f, 1.50395587e-01f, -1.07959695e-01f, 1.98572744e-02f, -3.13436724e-02f, -4.08201888e-02f, -1.89421873e-03f, -1.86908394e-01f, -1.10822998e-01f, -2.20401213e-01f,
  1.67010799e-02f, -3.32214743e-01f, -5.92356063e-02f, -1.65725295e-02f, 1.83954183e-02f, -6.33486658e-02f, -4.67437878e-02f, -9.62380022e-02f, -9.12906602e-02f, -1.32494792e-01f,
  1.59987181e-01f, 7.47577325e-02f, -1.19431354e-01f, 5.29928654e-02f, -2.52883524e-01f, 2.03238264e-01f, 1.01527117e-01f, 4.24952447e-01f, -2.57984221e-01f, 1.98657781e-01f,
  -4.78651613e-01f, -9.82457101e-02f, 6.25450909e-02f, -1.65188015e-01f, -1.05606817e-01f, 8.94781426e-02f, -8.62962455e-02f, 3.20170186e-02f, -3.69446054e-02f, 3.42942178e-02f,
  -1.16836689e-01f, -4.47792634e-02f, 3.95945534e-02f, -9.59737599e-02f, -4.98274043e-02f, -5.99851017e-04f, 1.00203842e-01f, -5.96700385e-02f, 4.60155457e-02f, -1.30314305e-01f,
  4.37530577e-02f, 8.25747401e-02f, -8.78104046e-02f, 1.15491431e-02f, -3.77788730e-02f, -1.31057903e-01f, 6.75322413e-02f, -4.82478586e-04f, -7.62765631e-02f, 6.51718080e-02f,
  -8.93329829e-02f, 1.57840565e-01f, -1.82066768e-01f, -1.10270157e-01f, 7.74419075e-03f, 2.00628191e-01f, -7.30307922e-02f, 8.80523995e-02f, 5.60560413e-02f, 3.22646201e-01f,
  -5.73067702e-02f, -5.15588522e-02f, 4.88777794e-02f, -1.90265626e-02f, 8.70191306e-02f, -1.70210451e-02f, 1.64522827e-01f, -1.22578621e-01f, 5.76053858e-02f, 1.60181299e-01f,
  -1.25941843e-01f, -1.01088576e-01f, 1.34463713e-01f, 1.11916758e-01f, -3.00555546e-02f, -6.91602752e-02f, -2.37972364e-02f, 1.84262082e-01f, 1.98610246e-01f, -8.64558816e-02f,
  1.53365031e-01f, -3.02411854e-01f, 2.10521951e-01f, -4.36731428e-02f, 7.24293143e-02f, 8.24311301e-02f, 1.91304132e-01f, 1.00474715e-01f, 3.68853286e-02f, 1.72688007e-01f,
  4.67038117e-02f, 1.59764543e-01f, 1.13564208e-01f, 4.32026200e-02f, 5.79564311e-02f, -4.72274609e-02f, 1.74660161e-01f, 8.37779939e-02f, -6.79967254e-02f, 1.27789423e-01f,
  -2.18264051e-02f, 1.46450326e-01f, -1.47435784e-01f, 1.26652449e-01f, 5.23236468e-02f, 1.66925460e-01f, 2.64966160e-01f, 5.17110787e-02f, 6.99093044e-02f, -4.75121778e-04f,
  -5.60438707e-02f, -7.60884732e-02f, 2.62108129e-02f, 1.34856343e-01f, 8.83858353e-02f, 1.82572696e-02f, -1.02652662e-01f, -2.69982964e-02f, 7.63002187e-02f, -1.63132101e-01f,
  3.26096155e-02f, 4.40506972e-02f, 1.44766599e-01f, -8.82761627e-02f, 1.57630712e-01f, 3.73532474e-02f, -5.59095591e-02f, -1.72524229e-01f, 2.86650211e-01f, 1.22831389e-02f,
  -2.88158171e-02f, -1.72335114e-02f, 9.72657427e-02f, -9.91526470e-02f, 1.65209606e-01f, 1.32557437e-01f, -1.37572840e-01f, -8.75795484e-02f, -5.44727445e-02f, -2.34686106e-01f,
  -1.52894691e-01f, 1.66117907e-01f, -1.45515457e-01f, -1.59444556e-01f, -1.10346705e-01f, 2.71529764e-01f, -7.10637718e-02f, 2.45068818e-01f, -7.76397064e-02f, -1.10234804e-01f,
  -8.05892572e-02f, 5.90896271e-02f, 2.54319757e-02f, -8.15604106e-02f, -3.31879146e-02f, 4.64211479e-02f, -4.31091711e-02f, -2.52011158e-02f, 2.99523231e-02f, -1.39353424e-01f,
  3.13001722e-02f, -6.45641237e-02f, -2.98563600e-01f, 6.82046711e-02f, -8.58278126e-02f, 5.67163974e-02f, -4.84964103e-02f, 7.48903453e-02f, 5.91286346e-02f, -5.43863792e-03f,
  -5.95341846e-02f, 8.29563588e-02f, -5.51022738e-02f, -1.36652635e-02f, -6.29213750e-02f, 5.17202877e-02f, 2.01962404e-02f, 9.95919853e-02f, 1.12954542e-01f, -7.27013126e-02f,
  -1.00210346e-02f, -1.12091452e-01f, 7.64102042e-02f, 7.31745129e-03f, -1.41378328e-01f, -1.11008845e-01f, 1.25777245e-01f, -8.10411200e-02f, -2.83716824e-02f, -6.96648508e-02f,
  -2.46610623e-02f, -2.50645280e-01f, 4.30545546e-02f, -2.20365494e-01f, -1.31615782e-02f, -1.11323344e-02f, 3.37806903e-02f, -1.17724314e-01f, 4.50511836e-02f, -1.36853889e-01f,
  6.77292496e-02f, 9.09074917e-02f, -3.30945812e-02f, -6.33851439e-02f, 1.54654667e-01f, -1.82204425e-01f, -4.57915179e-02f, -9.86065567e-02f, -1.57190859e-01f, 2.12042019e-01f,
  -2.60070831e-01f, 1.55578122e-01f, -2.50607848e-01f, -1.12796649e-01f, 1.09916978e-01f, 5.95318824e-02f, -8.32357332e-02f, -5.44713289e-02f, -2.69038286e-02f, 5.73047772e-02f,
  -3.07620913e-02f, -1.59837112e-01f, -4.62071821e-02f, -4.47353348e-02f, -1.84244011e-02f, 2.03568581e-03f, -2.54267361e-02f, -1.01652034e-02f, -2.59500444e-02f, -1.46356702e-01f,
  -3.11513580e-02f, -1.78029358e-01f, -6.64240420e-02f, -1.91063896e-01f, -1.19721413e-01f, -1.34127866e-02f, 2.42497250e-02f, 1.72645703e-01f, 8.71610418e-02f, 6.52349042e-03f,
  3.76801491e-02f, -5.46337515e-02f, -9.43972170e-02f, -2.08706692e-01f, 9.71935689e-02f, 6.05669543e-02f, -3.39585811e-01f, -4.86437837e-03f, 2.54499875e-02f, -7.72655243e-04f,
  -3.22960713e-03f, 9.34272856e-02f, -1.01905413e-01f, 9.37647298e-02f, -1.72522485e-01f, -1.85102627e-01f, 8.61060321e-02f, 9.18034688e-02f, -2.22555578e-01f, -1.07202791e-01f,
  -1.46039605e-01f, -1.50317043e-01f, 1.81220740e-01f, 3.53634357e-02f, 3.81518900e-02f, 1.75694138e-01f, 1.86829373e-01f, -3.86730939e-01f, -1.63923070e-01f, -6.24328963e-02f,
  4.06960398e-02f, 1.43230319e-01f, 3.83248553e-02f, 8.32069442e-02f, 1.57512695e-01f, 3.36713865e-02f, 5.14449030e-02f, -2.15344131e-01f, -2.09930420e-01f, 2.33063120e-02f,
  -9.45284218e-02f, -5.72536178e-02f, 1.32682174e-01f, 1.25559241e-01f, -2.29895823e-02f, 1.92056280e-02f, -1.00789703e-01f, -7.53091201e-02f, 7.81698450e-02f, -1.43960230e-02f,
  -3.76471244e-02f, 7.84653425e-02f, -5.29167093e-02f, 1.25954114e-02f, -3.58044505e-02f, 1.81577772e-01f, -4.70758695e-03f, 7.53647983e-02f, -1.23930976e-01f, -1.33870896e-02f,
  7.23488480e-02f, 3.97159569e-02f, 4.46892455e-02f, 2.31991112e-02f, 1.35226950e-01f, -4.87432815e-02f, -2.08100423e-01f, -7.38208368e-03f, 3.61816548e-02f, 3.70012075e-02f,
  1.44692941e-03f, 7.02800304e-02f, -1.69128522e-01f, 5.95965460e-02f, 1.60134152e-01f, -7.34695494e-02f, -2.76276618e-02f, -2.25730166e-02f, 1.70773998e-01f, -5.67082800e-02f,
  -8.88870135e-02f, 1.80999264e-01f, 1.84933275e-01f, 7.01461434e-02f, -1.19033605e-01f, -1.88225526e-02f, 2.94390954e-02f, 1.43401846e-01f, 8.04237425e-02f, 1.75750479e-01f,
  -9.40809920e-02f, -2.29867950e-01f, 4.79381949e-01f, 4.00212146e-02f, -5.82074560e-03f, -2.26352260e-01f, 4.12806943e-02f, -1.15049362e-01f, 7.35034347e-02f, -1.68863118e-01f,
  7.86004439e-02f, 6.36257380e-02f, -2.63506204e-01f, -1.14200905e-01f, -1.24046225e-02f, -1.73368871e-01f, 9.89234373e-02f, -2.36955369e-04f, -6.52068853e-02f, -2.88382918e-01f,
  2.46977457e-03f, -1.32980170e-02f, 1.04045369e-01f, -7.09361881e-02f, -5.94815239e-02f, -1.30313277e-01f, -2.60271858e-02f, -2.10426942e-01f, -9.67390761e-02f, 1.26700550e-01f,
  -1.02855235e-01f, -6.41530827e-02f, -1.17864069e-02f, 5.49363997e-03f, 5.25061041e-03f, 9.30622071e-02f, 9.46187302e-02f, 1.27360731e-01f, -1.42611280e-01f, -2.54173446e-02f,
  -1.66803434e-01f, -2.23430023e-01f, -9.49826390e-02f, 1.37239426e-01f, -1.48038790e-02f, 1.28625959e-01f, -2.13903468e-02f, -7.66389817e-02f, -6.48877546e-02f, 9.63976011e-02f,
  -9.94026437e-02f, 2.57113371e-02f, 7.86809623e-02f, -1.33864820e-01f, -6.92126006e-02f, -5.25996974e-03f, 2.58348525e-01f, -1.31684959e-01f, 7.34698698e-02f, 1.71047628e-01f,
  9.71486568e-02f, -7.68648311e-02f, -9.08564553e-02f, -2.06751786e-02f, -4.40545045e-02f, 2.78779510e-02f, 2.77723193e-01f, 2.45335311e-01f, 1.84368402e-01f, -9.09490436e-02f,
  -2.60050178e-01f, -2.88705111e-01f, 2.22209096e-01f, -2.32889280e-02f, 1.70389578e-01f, 1.63370714e-01f, 9.35147330e-02f, 4.65110168e-02f, 1.85053237e-02f, -5.16701005e-02f,
  -3.79949771e-02f, 6.23050407e-02f, 4.51165847e-02f, -3.11610941e-02f, -6.17711991e-02f, -4.97969277e-02f, -3.50889713e-02f, 1.23630688e-01f, -1.02575190e-01f, 9.38487351e-02f,
  1.66073039e-01f, 1.32866994e-01f, 9.04190466e-02f, 2.25618035e-02f, -5.14288135e-02f, 5.37967980e-02f, 1.32581592e-01f, -2.35625007e-03f, -7.32381269e-02f, -1.41053483e-01f,
  -1.17010735e-01f, -9.75057203e-03f, -8.73814672e-02f, 1.05764233e-01f, 1.01936884e-01f, -6.57833181e-03f, -2.12696299e-01f, -3.38307209e-02f, 1.98957890e-01f, -3.83274406e-02f,
  -1.20411618e-02f, 2.14525163e-01f, -2.98937839e-02f, -1.45814061e-01f, 1.19991727e-01f, -7.71017596e-02f, -1.40991539e-01f, 6.80817142e-02f, -3.17150623e-01f, -6.58293664e-02f,
  -1.33980811e-01f, -7.51507143e-03f, 1.59687120e-02f, -5.70426397e-02f, -1.05162412e-01f, -2.24383362e-03f, 9.73077640e-02f, 1.89907238e-01f, -2.18326509e-01f, 1.72712207e-02f,
  1.92871928e-01f, -7.79089555e-02f, -1.82654276e-01f, 1.53458223e-01f, -2.93282419e-02f, 1.81430861e-01f, -1.70991078e-01f, 2.02374142e-02f, -2.25479901e-01f, 3.23474258e-02f,
  1.51011884e-01f, 3.05522457e-02f, 1.43636405e-01f, 1.37839049e-01f, 1.52510311e-02f, 5.93422279e-02f, -1.34078099e-03f, 8.81823376e-02f, 9.32003781e-02f, 5.68671487e-02f,
  3.69683020e-02f, 2.20640704e-01f, -4.47643474e-02f, 1.88136213e-02f, 5.37055321e-02f, 2.88398117e-01f, 3.76642421e-02f, 2.79965729e-01f, 1.68546259e-01f, 2.18019977e-01f,
  1.97257593e-01f, 8.98916870e-02f, -8.53188187e-02f, -9.54637080e-02f, -4.02701506e-03f, 1.04256421e-01f, -9.72866789e-02f, 1.32172689e-01f, 6.22016750e-02f, -1.12741426e-01f,
  1.43496841e-01f, -2.71520652e-02f, -9.30160210e-02f, -6.85175369e-03f, -2.66062673e-02f, -1.55429646e-01f, -6.05854355e-02f, -1.38330504e-01f, -2.52236761e-02f, -5.32263108e-02f,
  6.38789609e-02f, 1.58236921e-01f, 2.19916761e-01f, -2.37856239e-01f, -3.02160475e-02f, -7.69563019e-02f, -1.55445449e-02f, -6.28354028e-02f, -1.06949598e-01f, -2.73658540e-02f,
  -5.38871102e-02f, -1.86711147e-01f, -4.89015691e-02f, 3.88667345e-01f, -4.80329126e-01f, 3.69521230e-02f, -2.59977821e-02f, 9.51074958e-02f, -3.73068526e-02f, 2.36844063e-01f,
  5.11988476e-02f, 1.80435345e-01f, -1.41303062e-01f, -2.24378794e-01f, 1.07217386e-01f, -1.94308251e-01f, -4.64130230e-02f, -2.07395926e-02f, 3.66430543e-02f, -1.71043083e-01f,
  5.77236637e-02f, -8.24949667e-02f, -2.66350266e-02f, -3.52910794e-02f, 1.12632446e-01f, -2.65828013e-01f, 1.52285963e-01f, -7.11065531e-02f, 2.70549655e-02f, -4.67484221e-02f,
  -6.89642280e-02f, -1.15228549e-01f, -3.95531394e-02f, -9.38709453e-02f, -8.51807371e-02f, -5.91696575e-02f, -1.30957857e-01f, -1.03311874e-01f, -3.07982769e-02f, -8.24976712e-03f,
  5.66201806e-02f, -2.14935556e-01f, -1.13767572e-01f, -1.18662834e-01f, -3.45447734e-02f, -1.43200206e-02f, -6.77584410e-02f, 1.24680415e-01f, 3.02032419e-02f, -1.98584899e-01f,
  1.59578979e-01f, -1.04101993e-01f, 9.52507183e-02f, -5.20980097e-02f, -5.15239052e-02f, -8.93902406e-02f, -1.83419853e-01f, -2.81853676e-01f, -3.66607666e-01f, 1.68252766e-01f,
  6.28824756e-02f, -5.68676628e-02f, 7.03804567e-02f, -9.21585783e-02f, -9.28092897e-02f, 6.06706478e-02f, 1.59902096e-01f, -3.48691374e-01f, -5.67900911e-02f, -1.63128376e-01f,
  -6.86095282e-02f, 2.34863788e-01f, 3.95822346e-01f, 3.82584095e-01f, -1.34710133e-01f, 2.61926465e-02f, -2.74383575e-02f, 4.60080579e-02f, -6.37488216e-02f, 6.06174357e-02f,
  -1.26717184e-02f, -2.94545374e-04f, 1.19084790e-02f, 5.24503328e-02f, 6.43024370e-02f, -1.78229883e-02f, 1.87016353e-02f, -6.48390278e-02f, 1.78619996e-02f, 5.90872541e-02f,
  6.87472373e-02f, 3.48853394e-02f, 1.08630754e-01f, 8.36226270e-02f, -4.16336581e-02f, 9.79766026e-02f, 1.12283230e-01f, -3.77260223e-02f, 9.85195041e-02f, 1.87717658e-02f,
  2.07407139e-02f, -1.49286340e-03f, -1.45040587e-01f, -1.23132043e-01f, 3.52360487e-01f, -8.01908672e-02f, -1.37184009e-01f, -9.51947644e-03f, 3.61830831e-01f, 7.08670691e-02f,
  2.24282920e-01f, -1.09187447e-01f, 2.04835549e-01f, -3.06174308e-01f, 2.41036341e-01f, -6.51761070e-02f, 3.58357490e-03f, 5.92219969e-03f, 2.36480646e-02f, -1.28358364e-01f,
  2.00425565e-01f, 2.02980563e-01f, 2.95368135e-01f, 1.91738546e-01f, 1.61380276e-01f, -1.32851392e-01f, 1.51747137e-01f, -5.27533963e-02f, -5.66053540e-02f, -2.09486589e-01f,
  2.88824290e-01f, -2.54448831e-01f, 4.95002717e-02f, 1.60366684e-01f, 4.65078764e-02f, -2.10098460e-01f, 2.31606975e-01f, 1.83021814e-01f, 2.36455295e-02f, -1.15793326e-03f,
  2.71437019e-01f, -6.26913682e-02f, -1.54332638e-01f, -9.13633183e-02f, -1.26048233e-02f, 4.01920043e-02f, 6.40530586e-02f, -1.58691466e-01f, -7.05586821e-02f, -2.49232844e-01f,
  5.92099167e-02f, 7.44606927e-02f, -1.61361936e-02f, -2.27855854e-02f, 2.40816787e-01f, -1.85277730e-01f, -3.99676599e-02f, 1.35535339e-03f, -1.12945341e-01f, 5.04283085e-02f,
  1.03752472e-01f, -1.44825280e-01f, 7.25521445e-02f, -6.94304183e-02f, 4.50101262e-03f, 1.60534699e-02f, -1.70091987e-01f, -9.98971015e-02f, 8.19578320e-02f, -3.21930610e-02f,
  -2.75085986e-01f, -1.37110157e-02f, -2.25262448e-01f, -1.60507336e-01f, 1.04427621e-01f, 2.96191406e-03f, 1.87152233e-02f, -1.68713018e-01f, -1.12138480e-01f, 2.56074756e-01f,
  -5.03805727e-02f, -4.10678796e-02f, 2.48774976e-01f, -1.60336077e-01f, 1.82911098e-01f, -6.53079748e-02f, 1.66563034e-01f, -2.04818130e-01f, 9.48776230e-02f, 1.92068651e-01f,
  1.03824206e-01f, -2.14950517e-01f, 2.44103558e-02f, 1.26384497e-01f, -2.29211032e-01f, -4.86094728e-02f, 1.43552974e-01f, 1.72549769e-01f, 5.61614893e-02f, -5.41985296e-02f,
  -1.44699812e-01f, -1.00880794e-01f, 1.38120532e-01f, -1.60557896e-01f, 1.02801457e-01f, -2.96377577e-02f, -1.15289979e-01f, 1.46176130e-01f, -2.16063336e-02f, 1.09589845e-01f,
  -4.96988818e-02f, 3.76040302e-02f, -1.17420547e-01f, 1.27511546e-02f, 1.18776739e-01f, -1.40592754e-01f, -3.56697068e-02f, 5.96799739e-02f, -8.03741813e-02f, 8.37926641e-02f,
  7.69766420e-02f, 1.74296811e-01f, 4.78299670e-02f, 1.90779626e-01f, 9.82869193e-02f, 2.77185231e-01f, 2.91281819e-01f, 1.70192152e-01f, 3.12212370e-02f, -1.36418656e-01f,
  -3.96567211e-02f, -1.08321272e-01f, -7.62746483e-02f, -7.36682490e-02f, 6.57176748e-02f, 9.57607701e-02f, -4.89946529e-02f, 6.28571659e-02f, 3.79851051e-02f, -8.88590962e-02f,
  7.19142035e-02f, 2.91580439e-01f, -3.09156608e-02f, 9.43461582e-02f, 2.60772323e-03f, 1.84076149e-02f, -1.31088778e-01f, 2.76542068e-01f, -3.74412019e-04f, 1.17474891e-01f,
  9.71242264e-02f, 2.68316865e-01f, 9.87242460e-02f, -5.70275709e-02f, -1.00408802e-02f, 3.10548335e-01f, 1.05675878e-02f, 1.38004094e-01f, -2.63967454e-01f, 3.60620231e-03f,
  3.63682270e-01f, -1.90112427e-01f, -7.10889399e-02f, -1.03705794e-01f, -2.36760840e-01f, -5.44993207e-02f, -2.07307324e-01f, 1.77669123e-01f, -9.81294438e-02f, 1.54027134e-01f,
  -2.95946915e-02f, 4.83043008e-02f, 1.10177770e-01f, 1.01108491e-01f, 8.76027867e-02f, -2.70261038e-02f, 5.51403128e-02f, -5.65065332e-02f, 5.86702526e-02f, 5.65900840e-02f,
  2.01389417e-02f, 7.43888468e-02f, 4.18721326e-03f, -6.65416569e-02f, 4.78049414e-03f, 1.29630566e-01f, -8.15635398e-02f, -4.09822166e-03f, 5.92019595e-02f, -2.26983670e-02f,
  -4.70163822e-02f, 1.06679797e-01f, -2.26705521e-02f, 2.03314915e-01f, 8.49921256e-02f, -1.03728756e-01f, -4.48978357e-02f, 4.95835766e-03f, -8.70320126e-02f, -1.25207659e-02f,
  -9.02819112e-02f, 4.36187647e-02f, -1.59702003e-02f, 1.82513133e-01f, -1.19002707e-01f, 1.01519031e-02f, -2.53842007e-02f, 3.05066556e-01f, -6.24086894e-02f, -6.71396479e-02f,
  8.08942616e-02f, 1.98725581e-01f, 1.84130982e-01f, 7.86821842e-02f, -7.70447180e-02f, -1.58768788e-01f, 6.56761155e-02f, 2.47856855e-01f, -8.73004273e-03f, -7.38851279e-02f,
  6.07786141e-02f, 5.98932393e-02f, -3.65436524e-02f, -2.19832748e-01f, 3.17813791e-02f, 1.92099139e-01f, 1.09288380e-01f, -1.42531872e-01f, -1.20385312e-01f, -6.21629283e-02f,
  1.46150529e-01f, 1.61303161e-03f, 1.53441831e-01f, -6.70671538e-02f, -4.85406145e-02f, -5.44033460e-02f, -2.88657825e-02f, 2.97682807e-02f, 2.25804839e-02f, 1.52674109e-01f,
  -4.72653583e-02f, 5.22089079e-02f, 3.40512581e-02f, -1.31991118e-01f, 7.86463842e-02f, -1.35356814e-01f, -1.42017156e-01f, 2.09355708e-02f, -4.53488454e-02f, -7.32545555e-02f,
  -1.41525239e-01f, -1.32611006e-01f, 9.19696689e-02f, 8.46129060e-02f, -5.49915731e-02f, -1.15253672e-03f, 9.37580913e-02f, -3.33045535e-02f, -6.83268085e-02f, -2.40815684e-01f,
  2.28376418e-01f, 1.02082267e-01f, -3.16324383e-02f, -9.39407852e-03f, 1.86164200e-01f, 9.86260027e-02f, 2.24606171e-01f, 7.94663876e-02f, 9.59543064e-02f, -2.71989226e-01f,
  3.27854365e-01f, 1.14511870e-01f, -5.89773152e-03f, -3.25952955e-02f, -6.48287265e-03f, -4.79404062e-01f, -1.50485188e-01f, -1.12283535e-01f, 5.04777990e-02f, -3.63657996e-02f,
  1.18080191e-01f, -1.67515516e-01f, 9.59566534e-02f, -8.14848244e-02f, 6.60107061e-02f, -8.99076462e-02f, 1.10476129e-01f, -2.31449649e-01f, -1.63328364e-01f, 2.33435169e-01f,
  1.29454955e-01f, -2.22258970e-01f, 3.34744364e-01f, 1.40748724e-01f, -8.37390572e-02f, 2.69690305e-01f, 3.87336537e-02f, -7.39093050e-02f, 4.27287444e-02f, 7.62948096e-02f,
  -2.37421282e-02f, 1.29274085e-01f, 1.21412762e-01f, 3.57229039e-02f, 1.30995855e-01f, -1.28870402e-02f, 7.59461597e-02f, 2.13937927e-02f, 8.28522630e-03f, 1.25056617e-02f,
  -1.90198496e-01f, 1.47257030e-01f, -8.03382024e-02f, -2.72765402e-02f, 4.31558415e-02f, 4.23287880e-03f, 5.75887449e-02f, -5.77009507e-02f, 1.18786052e-01f, -6.38712645e-02f,
  -5.27546220e-02f, -4.12214510e-02f, -1.61269262e-01f, -1.75443232e-01f, 5.70467040e-02f, 1.43784136e-01f, 2.09013879e-01f, -2.42155250e-02f, -9.80957672e-02f, -2.28830520e-02f,
  1.91446394e-02f, -1.11003637e-01f, 9.87239406e-02f, -5.87993581e-03f, 7.85737485e-02f, -1.94956060e-03f, 1.63964450e-01f, -7.92703703e-02f, -1.74990848e-01f, -9.87243187e-03f,
  1.57945752e-01f, -1.22520782e-01f, -8.58120434e-03f, 4.86791581e-02f, 1.79658253e-02f, -1.37705326e-01f, 9.49009042e-03f, -4.94851060e-02f, -1.13122873e-01f, -2.29161412e-01f,
  5.96461035e-02f, -1.57237221e-02f, -7.55423754e-02f, 1.39004305e-01f, -1.17340066e-01f, -6.75216541e-02f, 5.32442294e-02f, 2.22411945e-01f, -2.52385736e-01f, 2.13545099e-01f,
  -4.37043272e-02f, -5.20840511e-02f, 3.49709531e-03f, -1.57177411e-02f, 4.77196611e-02f, 5.04011065e-02f, -1.11643851e-01f, -8.46432969e-02f, 2.27915552e-02f, 6.13406636e-02f,
  1.24136634e-01f, 1.00653179e-01f, 3.28688584e-02f, -1.41305283e-01f, -2.28291228e-01f, 1.06361575e-01f, 3.64931375e-02f, -1.56909421e-01f, -1.98614062e-03f, -1.69122472e-01f,
  -3.01779777e-01f, -1.75611246e-02f, -1.88697800e-01f, 2.92527135e-02f, -3.50818746e-02f, -5.57270944e-02f, -1.58501104e-01f, -1.51733488e-01f, -2.06000153e-02f, -1.52291015e-01f,
  -1.04726605e-01f, -3.04144640e-02f, -2.69720763e-01f, -2.23032683e-02f, -1.93196192e-01f, 1.52527794e-01f, -4.02550632e-03f, 6.11592196e-02f, -1.05333887e-01f, 1.62791647e-02f,
  2.71196440e-02f, -2.79803455e-01f, -3.27492431e-02f, -1.28597870e-01f, 3.29016261e-02f, 6.24311529e-02f, -1.32784575e-01f, 2.40126237e-01f, 6.35760799e-02f, -8.24059099e-02f,
  5.05209789e-02f, 7.26576149e-02f, -1.37846261e-01f, 1.49696618e-01f, -1.23742267e-01f, -1.21282078e-01f, 5.43886006e-01f, -2.84006655e-01f, -8.02874938e-02f, -6.47540092e-02f,
  -2.55482256e-01f, 2.50421345e-01f, -1.06438704e-01f, 1.56769738e-01f, -1.46778196e-01f, 4.24191542e-02f, -2.75130887e-02f, -1.45307943e-01f, -7.71182626e-02f, -7.81358406e-02f,
  -5.65742655e-03f, 3.34913395e-02f, 3.77305970e-02f, -5.70001677e-02f, -4.37985733e-02f, -3.66579108e-02f, 1.14982881e-01f, -1.24105802e-02f, 1.11567773e-01f, -2.06223950e-02f,
  -5.27946576e-02f, -2.00406298e-01f, 3.35030146e-02f, -1.15582876e-01f, 3.11203301e-02f, 5.74871153e-03f, -4.85426672e-02f, -1.04129106e-01f, 8.03300589e-02f, -7.53594339e-02f,
  -9.18052495e-02f, -5.29280640e-02f, -9.77150872e-02f, 3.23630907e-02f, 5.30164391e-02f, 2.92787310e-02f, 5.88925043e-03f, -9.60602611e-02f, 2.49329910e-01f, -1.30019397e-01f,
  -1.01296585e-02f, 8.51702504e-03f, 2.33555902e-02f, 1.35711879e-01f, -4.44203615e-02f, -7.47001022e-02f, 5.52271456e-02f, -2.14038044e-02f, 1.44287392e-01f, 6.95038661e-02f,
  1.30868092e-01f, -2.05281287e-01f, 5.94489723e-02f, 8.78370926e-02f, -6.01553209e-02f, -6.03820421e-02f, 1.72811672e-01f, -1.04812905e-02f, 1.57488883e-01f, 2.70085275e-01f,
  -3.17574859e-01f, -4.27917279e-02f, 7.64021575e-02f, -6.58994168e-02f, 2.42809445e-01f, 8.95671360e-03f, 1.92630783e-01f, -8.95171613e-02f, 1.44507959e-01f, -4.96483818e-02f,
  3.45923044e-02f, -9.44001302e-02f, 8.51172879e-02f, 8.27189311e-02f, 1.91510007e-01f, 5.58950799e-03f, 1.02103002e-01f, 2.33444884e-01f, 2.84981858e-02f, 7.62421563e-02f,
  6.63612783e-02f, -1.14154242e-01f, 2.92713135e-01f, -4.45488980e-03f, 1.11111529e-01f, 1.38208386e-03f, 2.16388896e-01f, -1.21553488e-01f, -2.80786362e-02f, 1.52279869e-01f,
  1.25833362e-01f, 5.13723604e-02f, 1.09178066e-01f, 1.12826280e-01f, 1.25405341e-02f, -1.00391604e-01f, 5.72478436e-02f, 4.97740693e-04f, 5.12308776e-02f, 1.10484287e-01f,
  -1.31046087e-01f, -2.80759223e-02f, -1.03194766e-01f, 1.00844651e-01f, -1.04363866e-01f, -6.70185089e-02f, -4.56553660e-02f, 2.34139889e-01f, 1.56112639e-02f, -4.81532738e-02f,
  -5.01208827e-02f, -1.06084533e-01f, -1.42481223e-01f, -1.11756451e-01f, -6.01342954e-02f, -2.23536268e-01f, 2.55333073e-02f, 1.65118977e-01f, -5.73498346e-02f, -8.78123045e-02f,
  1.88622472e-03f, 2.52857447e-01f, 4.03448800e-03f, -1.14948563e-01f, 3.19117337e-01f, -9.16771144e-02f, 8.60677287e-02f, -2.82065477e-03f, -2.45828703e-02f, -1.25998303e-01f,
  2.37953097e-01f, -8.72869194e-02f, 1.66307017e-01f, 1.98133588e-02f, 1.65172182e-02f, -8.34261030e-02f, -1.71356037e-01f, 2.61395648e-02f, -8.75038356e-02f, -9.59808845e-03f,
  1.77004382e-01f, 1.53694106e-02f, -5.52740172e-02f, 5.09579368e-02f, -1.18451543e-01f, -5.32924607e-02f, -2.75861211e-02f, -3.44738364e-02f, 1.14288546e-01f, 5.61547279e-03f,
  2.05962509e-02f, -1.50807649e-01f, 2.48355120e-02f, -1.45525411e-01f, 5.09936698e-02f, -1.94391623e-01f, 1.02893993e-01f, -8.10649768e-02f, -1.46843046e-01f, -2.57197082e-01f,
  1.62118211e-01f, 1.17474936e-01f, -6.78182915e-02f, 1.82422996e-01f, -1.91631466e-01f, -9.73188430e-02f, -2.25614727e-01f, 1.96305037e-01f, -1.09152839e-01f, 4.60549928e-02f,
  2.03629844e-02f, 3.32169652e-01f, -4.15523862e-03f, -1.73539296e-01f, 1.22884586e-01f, -1.84045494e-01f, 2.05061272e-01f, 2.53517658e-01f, -2.71886766e-01f, 2.46701241e-02f,
  5.46964770e-03f, 9.28848833e-02f, -8.88847485e-02f, -4.56334315e-02f, -3.58425975e-02f, -1.81975812e-01f, -9.44831669e-02f, -2.83658445e-01f, 2.20077008e-01f, 1.51749298e-01f,
  1.49353772e-01f, -9.61621106e-02f, 2.17994750e-01f, -2.22706774e-04f, -5.07627092e-02f, 1.07707955e-01f, 1.21498972e-01f, -1.85685411e-01f, 2.80864388e-01f, -1.07018717e-01f,
  8.07724148e-02f, -2.57023554e-02f, 2.90416405e-02f, -2.48623360e-02f, -3.23718563e-02f, -4.43351679e-02f, -1.66907981e-02f, 1.04232517e-03f, 1.06163695e-01f, -1.11648664e-02f,
  2.77159512e-01f, -2.62491461e-02f, 1.35236055e-01f, -8.51196423e-02f, -5.11221290e-02f, -1.03101976e-01f, 1.75731748e-01f, -6.16533980e-02f, -1.08402967e-01f, 1.66510977e-02f,
  1.87521726e-01f, 1.93614915e-01f, -8.23298395e-02f, -1.48846447e-01f, 2.29382977e-01f, -1.56131610e-01f, -1.84537202e-01f, 1.02180019e-01f, 1.72726437e-01f, -8.90242010e-02f,
  -1.95943668e-01f, -1.52296079e-02f, 1.07447408e-01f, -1.97809517e-01f, -3.43578644e-02f, -2.06342831e-01f, -1.67567283e-02f, 6.45836592e-02f, 7.38016516e-02f, 1.71063803e-02f,
  1.25088587e-01f, -8.07798468e-03f, -1.33846521e-01f, 1.20217122e-01f, 5.13412096e-02f, -1.51438296e-01f, -2.01038476e-02f, -1.30541131e-01f, -1.82226136e-01f, -2.37719208e-01f,
  3.32340002e-01f, -2.30536222e-01f, 2.86283419e-02f, -2.63865367e-02f, 1.12075783e-01f, -1.27249047e-01f, 9.23248827e-02f, -3.71429836e-03f, 1.69794291e-01f, 7.76614994e-02f,
  2.64077514e-01f, 7.69499689e-03f, -8.58674869e-02f, 5.54206632e-02f, -8.60721692e-02f, 1.04645960e-01f, -7.15024620e-02f, 1.95498522e-02f, -5.12440875e-02f, -5.23243099e-02f,
  6.70657232e-02f, -3.80334519e-02f, 1.45838354e-02f, 8.63129422e-02f, -1.28208324e-01f, 2.89873146e-02f, 2.31155828e-02f, -5.38054970e-04f, 5.76348081e-02f, -4.80117686e-02f,
  -3.30958478e-02f, 2.10766450e-01f, -4.72139195e-02f, 5.03823049e-02f, 1.99961767e-04f, -2.65366584e-03f, -5.12235239e-02f, 1.49346003e-02f, -7.63500556e-02f, 3.00608948e-02f,
  1.88374259e-02f, 1.25399008e-01f, -1.74008440e-02f, 1.75037235e-01f, -1.13177150e-01f, -1.25964597e-01f, 1.45489201e-01f, 6.21572733e-02f, -2.46484317e-02f, -2.58776546e-01f,
  -3.61969471e-02f, 5.15398122e-02f, -1.28980363e-02f, 1.38972551e-01f, 1.61798656e-01f, 2.97996607e-02f, 1.51737079e-01f, 4.00885969e-01f, 1.47899181e-01f, -1.26054336e-03f,
  -1.98088381e-02f, 1.72887668e-01f, 2.19244268e-02f, -1.22814015e-01f, -2.52511978e-01f, -1.97324723e-01f, 4.66104001e-01f, 1.15319811e-01f, -1.41675413e-01f, 5.61209880e-02f,
  -2.53044844e-01f, 1.52301088e-01f, -2.41264865e-01f, 1.83058251e-02f, -1.17287681e-01f, 1.43535942e-01f, -3.94260604e-03f, -2.69865505e-02f, 8.00153315e-02f, 3.10194306e-02f,
  6.58978447e-02f, 3.40622365e-02f, 8.00336078e-02f, 2.35243086e-02f, -8.48419964e-03f, 1.91267692e-02f, 6.27770498e-02f, -1.87812112e-02f, 3.46718393e-02f, 3.80879082e-02f,
  -4.46783416e-02f, 7.39656563e-04f, -2.87304204e-02f, -1.57025442e-01f, -1.99372345e-03f, -9.73516181e-02f, -7.20551908e-02f, 1.14627443e-02f, 1.03197649e-01f, 3.16696092e-02f,
  1.30421698e-01f, 8.64114165e-02f, 2.51281466e-02f, -1.01250611e-01f, -2.04546019e-01f, 5.15311994e-02f, -7.63135701e-02f, 1.87460836e-02f, -1.06669523e-01f, 2.36324415e-01f,
  -2.11625814e-01f, -1.40922531e-01f, 9.48279053e-02f, 3.91026348e-01f, -1.94593176e-01f, -5.38682640e-02f, 1.70015961e-01f, -6.11909442e-02f, 3.15595150e-01f, 1.28835350e-01f,
  -8.50071758e-02f, -2.56762236e-01f, 7.42101744e-02f, 2.63302803e-01f, 8.05191845e-02f, -3.35427783e-02f, 1.78909630e-01f, 1.24836504e-01f, 3.23948205e-01f, -3.73443887e-02f,
  -1.19306624e-01f, -3.71385142e-02f, 1.50133029e-01f, -9.73528326e-02f, 3.03747892e-01f, -4.29361239e-02f, -1.86855849e-02f, 1.60686672e-01f, -1.64105803e-01f, -2.33488873e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.19526967e-01f, 3.11281711e-01f, 1.85753241e-01f, 2.63703197e-01f, 5.30451462e-02f, 1.77767932e-01f, 1.57421544e-01f, 1.84329614e-01f, -1.75667062e-01f, 8.63426030e-02f,
  5.44880796e-03f, 2.68400282e-01f, 7.04106167e-02f, 1.82963923e-01f, 4.97570448e-02f, 1.71812251e-01f, 7.84837306e-02f, 7.04892129e-02f, 7.49039650e-02f, 4.62798215e-02f,
  2.15961516e-01f, 2.44846642e-01f, 2.16747820e-01f, 2.71034222e-02f, -8.58778059e-02f, -6.92891777e-02f, -9.05781463e-02f, -3.52585375e-01f, -2.36935988e-01f, -5.80689721e-02f,
  -1.92543790e-01f, 4.98440908e-03f, -2.80126095e-01f, 6.12761974e-02f, 2.47618705e-02f, 2.29306400e-01f, 7.57766739e-02f, 1.53356791e-01f, 1.96975887e-01f, 2.75324702e-01f,
  -7.90113881e-02f, 2.49186650e-01f, 3.17992389e-01f, 3.00343513e-01f, -2.02105567e-01f, -1.17610134e-02f, -3.10581088e-01f, -8.09669122e-02f, 2.05641553e-01f, 2.30602711e-01f,
  2.18696687e-02f, -1.26567200e-01f, -1.85018107e-01f, 8.33846405e-02f, 6.77062869e-02f, -4.60225731e-01f, 1.06056087e-01f, -4.57400471e-01f, -1.52886271e-01f, 4.52065580e-02f,
  3.58210027e-01f, 3.86337161e-01f, 1.23740621e-01f, 4.15302105e-02f, 1.57424808e-01f, 1.87627096e-02f, 1.15763746e-01f, 1.75843462e-01f, 6.12485111e-02f, 1.37935370e-01f,
  1.11468658e-01f, 1.52014568e-01f, 2.04836518e-01f, -6.37152139e-03f, 1.08557492e-01f, 1.01080716e-01f, -9.09757316e-02f, 1.35726511e-01f, 8.23101103e-02f, 7.05393776e-03f,
  1.77143998e-02f, -5.24956435e-02f, 1.30165145e-01f, 1.61248803e-01f, 2.00191036e-01f, 1.15780868e-01f, 1.90899521e-02f, 7.61606321e-02f, 1.57105848e-01f, -1.74826220e-01f,
  1.70244142e-01f, 2.04435155e-01f, 1.32437468e-01f, -1.51450217e-01f, 3.37908864e-01f, 4.45226207e-02f, 1.65458828e-01f, -5.97601086e-02f, 1.26707733e-01f, -7.88773149e-02f,
  1.70885295e-01f, -6.97395802e-02f, -3.02498657e-02f, -6.66940436e-02f, -1.28231511e-01f, -3.06508154e-01f, -1.75884739e-01f, -1.76095828e-01f, -2.18544691e-03f, 1.36740521e-01f,
  1.00820981e-01f, -1.37119591e-02f, 4.03734334e-02f, -1.13498405e-01f, -1.66014344e-01f, 6.47277236e-02f, -1.19986452e-01f, 1.72173828e-01f, -2.89085478e-01f, 1.43654853e-01f,
  -9.31685865e-02f, -8.29909667e-02f, 3.12761515e-01f, 1.94743484e-01f, -3.43751103e-01f, 8.44427273e-02f, -2.70147771e-01f, 6.58013225e-02f, 1.95798710e-01f, -2.53673717e-02f,
  1.75618440e-01f, 5.02366908e-02f, 2.24550053e-01f, 1.34217273e-02f, -2.23294180e-02f, -4.40941863e-02f, 2.20446773e-02f, 2.59991158e-02f, 1.63304687e-01f, 9.47048590e-02f,
  -1.87377706e-01f, 1.37074701e-02f, 3.86709124e-02f, 1.37483582e-01f, 5.67097776e-02f, -9.78930146e-02f, 2.17235342e-01f, 1.04393117e-01f, -1.48931025e-02f, -1.18674137e-01f,
  1.71632506e-02f, -2.57833283e-02f, -9.37538743e-02f, -1.70669351e-02f, 2.37876505e-01f, -2.46656183e-02f, -4.49069440e-02f, -1.47564575e-01f, 2.64244407e-01f, 1.78775281e-01f,
  3.96344364e-02f, 7.01070279e-02f, -1.14515359e-02f, -3.07865404e-02f, 1.44415334e-01f, 5.55968508e-02f, 1.21901810e-01f, 7.68412128e-02f, -2.66721517e-01f, -2.11000472e-01f,
  3.84250104e-01f, -1.16979428e-01f, -1.78657454e-02f, -2.64801681e-01f, -2.25285366e-01f, -6.70710299e-03f, 1.16952851e-01f, -6.23373687e-02f, -1.55609578e-01f, -1.16963223e-01f,
  1.49138555e-01f, -2.41028890e-01f, 3.48161906e-02f, -4.25225534e-02f, 1.83236733e-01f, -1.02295123e-01f, 7.62964860e-02f, 3.08544964e-01f, 2.27240384e-01f, 3.12194943e-01f,
  1.58194080e-01f, -1.01175584e-01f, 1.14177600e-01f, 1.23356417e-01f, 1.49486125e-01f, 8.09044689e-02f, 1.47294298e-01f, 1.72624718e-02f, 1.79677203e-01f, -3.99374776e-02f,
  5.48756449e-03f, 8.52297395e-02f, 8.98570344e-02f, -1.07600689e-01f, 1.58659771e-01f, 1.13609008e-01f, -7.70815685e-02f, 3.51189589e-03f, 2.02348128e-01f, 1.37700900e-01f,
  1.05107807e-01f, 2.48031199e-01f, 9.04711857e-02f, -4.06086212e-03f, 5.59445005e-03f, -4.56355363e-02f, 5.49727753e-02f, 1.98539063e-01f, -5.84448949e-02f, -8.97839442e-02f,
  -1.55021951e-01f, 6.05122484e-02f, -1.58490941e-01f, -1.72283128e-01f, 4.27553430e-03f, -4.30549420e-02f, 2.05780473e-02f, 3.08825761e-01f, -1.13015912e-01f, -1.60967812e-01f,
  -8.62233415e-02f, 7.47174546e-02f, -9.94525328e-02f, 2.15905026e-01f, -1.85338125e-01f, 5.85544556e-02f, 9.72843096e-02f, 3.22243989e-01f, 1.06840961e-01f, -9.42401960e-02f,
  -1.53424710e-01f, 2.32948303e-01f, -1.84454471e-01f, 3.16198776e-03f, -1.28808111e-01f, -7.94858038e-02f, 3.16016972e-01f, -5.78025803e-02f, -2.61747018e-02f, 6.66452618e-03f,
  9.76140201e-02f, -1.24656275e-01f, -1.17810845e-01f, -2.92146564e-01f, 1.37228876e-01f, 2.61339277e-01f, 1.30111307e-01f, -1.06435113e-01f, -4.46401834e-02f, 5.97327463e-02f,
  -4.18505184e-02f, -4.86799888e-02f, 8.45559090e-02f, -1.23009058e-02f, -9.94336456e-02f, -3.99856679e-02f, 2.39548057e-01f, -2.37959009e-02f, 2.23702133e-01f, 1.22680061e-01f,
  1.41964078e-01f, 8.28146655e-03f, 5.67389354e-02f, -8.34588110e-02f, 1.28483132e-01f, -2.17261493e-01f, 1.42319858e-01f, 5.55457473e-02f, 1.13510482e-01f, 1.32165015e-01f,
  -1.11722216e-01f, 2.57849451e-02f, 8.72202367e-02f, -9.28129777e-02f, -8.70253220e-02f, 8.56362954e-02f, -3.05288862e-02f, -9.86361057e-02f, -1.73602134e-01f, 1.05330236e-01f,
  -1.96734041e-01f, -3.36498916e-01f, -4.00780365e-02f, 1.81605056e-01f, -3.53820845e-02f, 1.74664315e-02f, -3.27698886e-02f, -1.68564051e-01f, 1.82370543e-01f, 9.04624984e-02f,
  -2.31575131e-01f, -3.15066993e-01f, -2.26377502e-01f, 1.45296425e-01f, -7.35554025e-02f, -2.64893025e-01f, -3.92440595e-02f, -1.92609336e-02f, 1.14268407e-01f, -2.36695141e-01f,
  -2.68630266e-01f, -5.76967150e-02f, -2.74952780e-03f, -1.29154146e-01f, 1.17287762e-01f, -9.08707529e-02f, 1.13016285e-01f, 3.39031696e-01f, 1.34209305e-01f, -9.02943779e-03f,
  1.48147598e-01f, -1.57553226e-01f, 1.38885565e-02f, 1.94574930e-02f, 1.00240558e-01f, 4.28876514e-03f, 1.59842119e-01f, 8.97278544e-03f, -2.65382626e-03f, 1.25168487e-01f,
  2.02202629e-02f, 2.33238991e-02f, 3.15342695e-01f, 4.99697626e-02f, -2.88246479e-02f, -9.68809798e-02f, 8.31275582e-02f, -4.11480869e-04f, -1.01869576e-01f, -7.35104904e-02f,
  -1.09337933e-01f, 2.00153012e-02f, 1.26754403e-01f, 1.58801243e-01f, 9.87776220e-02f, 3.93770263e-02f, -2.29973812e-02f, -1.41507685e-01f, -4.89138998e-02f, 2.71952376e-02f,
  1.20324083e-01f, -2.37413682e-02f, -9.46668312e-02f, 1.65900335e-01f, 2.87056360e-02f, -2.22852886e-01f, 8.39508027e-02f, 2.34875269e-02f, -1.57083690e-01f, -4.65219514e-03f,
  6.50015920e-02f, -1.22862987e-01f, -7.64361545e-02f, 2.31991149e-02f, -8.06507245e-02f, -3.82902324e-02f, -8.82164389e-02f, 7.84679689e-03f, -1.21870108e-01f, -9.39410925e-02f,
  2.80956901e-03f, 3.83696586e-01f, 2.35916615e-01f, -6.95722774e-02f, -1.64034124e-02f, -1.19340695e-01f, 1.23913310e-01f, 7.73022920e-02f, 4.27983344e-01f, -4.40863483e-02f,
  2.58389354e-01f, -6.05687685e-02f, 1.68022484e-01f, 1.92361146e-01f, 1.71511481e-03f, -1.49116427e-01f, 9.16752368e-02f, 2.11226773e-02f, -3.08633465e-02f, 2.50115152e-02f,
  1.39799401e-01f, 1.52820140e-01f, 2.73741186e-01f, 9.18428525e-02f, -3.93418260e-02f, -6.67126328e-02f, 6.38264343e-02f, -7.90942982e-02f, 5.25503755e-02f, 6.60902262e-02f,
  1.90678298e-01f, -7.69573599e-02f, -1.19110562e-01f, 1.55685648e-01f, 9.14467424e-02f, 1.71109840e-01f, 3.04292142e-03f, 2.18935832e-01f, 2.02893630e-01f, 7.80678866e-03f,
  -9.46066305e-02f, -1.46478072e-01f, -2.58117728e-02f, -1.14805706e-01f, -1.22865491e-01f, 1.46953300e-01f, -3.26697916e-01f, 1.02855265e-01f, -9.00645182e-02f, -8.23182799e-03f,
  -1.99070767e-01f, -5.02015688e-02f, -7.95310661e-02f, -2.90643811e-01f, 1.90624774e-01f, -1.60870597e-01f, -1.76436275e-01f, -1.09787211e-02f, -3.46290439e-01f, 3.92450154e-01f,
  -1.84008349e-02f, -9.38729644e-02f, -7.78436810e-02f, -1.10803537e-01f, -8.86372998e-02f, -7.86104053e-02f, 2.55958855e-01f, -3.33436102e-01f, 1.96105063e-01f, -2.27638856e-01f,
  7.11380914e-02f, 2.28019670e-01f, 2.07858589e-02f, -1.57612935e-02f, -1.30754158e-01f, -5.64893708e-02f, -8.32758620e-02f, -3.44163156e-03f, 1.66149184e-01f, -3.34958546e-02f,
  -1.08314835e-01f, -4.81540486e-02f, -8.56813714e-02f, -5.46496622e-02f, -3.69819514e-02f, 1.84112623e-01f, 9.78593305e-02f, -2.32324842e-03f, -6.13265373e-02f, -3.68024036e-02f,
  1.35912448e-02f, 3.99285220e-02f, -8.58056545e-03f, 4.62778006e-03f, 1.08926706e-01f, -1.10157453e-01f, 7.05297813e-02f, 8.60828161e-03f, -3.35510122e-03f, -2.96393018e-02f,
  -4.20473516e-03f, 4.99877334e-02f, 2.76632756e-02f, -1.51140317e-01f, 6.01500645e-02f, -5.76511249e-02f, 1.17617220e-01f, -1.32830992e-01f, 1.09151632e-01f, 4.23636176e-02f,
  -1.31200358e-01f, -1.59767553e-01f, 8.68573189e-02f, 1.00532450e-01f, -1.79228172e-01f, -1.36910349e-01f, 3.74217406e-02f, -1.01203494e-01f, 6.15399070e-02f, -4.17238288e-02f,
  -3.36306125e-01f, -1.73511609e-01f, -1.14248887e-01f, 2.11978987e-01f, -4.22585905e-02f, -1.54155910e-01f, -6.52286261e-02f, -7.66487643e-02f, 2.36541137e-01f, -5.04519511e-03f,
  1.33325264e-01f, -1.19317926e-01f, -2.93514907e-01f, 1.88195139e-01f, -1.98588204e-02f, 2.93541461e-01f, 3.34126681e-01f, -1.32955173e-02f, -1.45506561e-01f, -1.98280588e-01f,
  -2.86885709e-01f, 2.38657556e-03f, 6.52315468e-02f, 1.60431027e-01f, 4.24181335e-02f, 2.27401294e-02f, -8.31232686e-03f, 1.25920415e-01f, -4.71480982e-03f, 2.03437760e-01f,
  -3.04460456e-03f, 5.54574141e-03f, -6.78722784e-02f, 5.10577485e-02f, 4.61720675e-02f, 7.43416175e-02f, 2.11781319e-02f, -9.42570418e-02f, 6.68919906e-02f, 1.09377550e-03f,
  -1.19185433e-01f, -5.31424955e-02f, 7.12854043e-02f, 5.96600957e-02f, 4.21659835e-02f, -2.28679087e-02f, -2.96641272e-02f, -3.03991009e-02f, 5.78485802e-02f, 6.56773001e-02f,
  2.01284051e-01f, -1.21510044e-01f, 1.56578287e-01f, 1.51804298e-01f, 5.44176027e-02f, -2.30417237e-01f, 2.15845659e-01f, -4.38066311e-02f, 4.38799374e-02f, -1.82726517e-01f,
  8.91434103e-02f, -7.76356377e-04f, -7.55852833e-02f, 7.01186955e-02f, -2.89519988e-02f, 1.97682567e-02f, -1.19290605e-01f, 2.19514742e-01f, -1.40282318e-01f, 5.99204265e-02f,
  1.21905953e-01f, 2.56085098e-02f, 1.05363719e-01f, 3.98968086e-02f, 2.78659821e-01f, 1.58159971e-01f, -3.75133514e-01f, -1.59020647e-01f, -1.93233609e-01f, 1.84425399e-01f,
  2.99233049e-01f, 2.00869679e-01f, -2.38600031e-01f, -8.30277056e-02f, -8.63072723e-02f, -3.61382142e-02f, 1.74022913e-02f, 3.20557132e-02f, 1.01486921e-01f, 1.03832409e-01f,
  1.94215328e-01f, 1.12079509e-01f, 7.73322433e-02f, 1.05577208e-01f, 3.81216072e-02f, 6.67837188e-02f, 2.64517844e-01f, 4.26223455e-03f, 7.27723688e-02f, 1.85674176e-01f,
  9.27837715e-02f, 6.98760673e-02f, 2.07462803e-01f, -2.75613405e-02f, 1.77593172e-01f, 1.49525791e-01f, 7.36555904e-02f, 1.99768648e-01f, 1.26450241e-01f, 1.85135901e-01f,
  1.79933593e-01f, 1.53529227e-01f, -4.10234518e-02f, -2.45578125e-01f, 4.01855111e-02f, 2.92816479e-03f, -3.38547654e-03f, -6.23232238e-02f, 6.99561238e-02f, -1.13350637e-02f,
  -6.61133602e-03f, 6.83166385e-02f, -1.36988893e-01f, -2.54557341e-01f, -1.31952111e-02f, -1.13554187e-02f, -6.14962913e-02f, 9.44560245e-02f, -2.00536832e-01f, -8.20842683e-02f,
  -6.97884262e-02f, 1.77891955e-01f, -1.07028149e-01f, 2.75004166e-03f, -3.91854346e-03f, -9.03096646e-02f, -6.08903170e-03f, -1.37761440e-02f, 1.21541843e-02f, 2.58456230e-01f,
  -8.20522681e-02f, 1.50180876e-01f, -4.07831594e-02f, 3.72768492e-02f, 1.62005275e-01f, -3.23188007e-01f, -5.77624217e-02f, -2.94589609e-01f, -1.08943567e-01f, 2.35210091e-01f,
  1.30438268e-01f, 1.09888844e-01f, 1.91706657e-01f, 1.21783555e-01f, 3.70621905e-02f, 1.36782169e-01f, -8.90352391e-03f, -1.69800565e-01f, -7.47096613e-02f, 2.01953240e-02f,
  9.52613503e-02f, 1.19683176e-01f, 1.85762327e-02f, 1.41613379e-01f, 1.45939082e-01f, -5.47126122e-02f, 3.84619497e-02f, -7.71499798e-02f, 1.41139448e-01f, 4.13417816e-02f,
  1.26525298e-01f, 2.72272881e-02f, 3.25519070e-02f, -1.46834970e-01f, -1.10455500e-02f, -9.31716990e-04f, -3.52599137e-02f, 1.57630146e-01f, 1.36190817e-01f, 3.54971066e-02f,
  -5.36744520e-02f, -1.37794703e-01f, 1.32246792e-01f, 1.07854672e-01f, -3.03876568e-02f, -5.34891002e-02f, 7.39728212e-02f, 3.47613603e-01f, 6.00826927e-02f, 5.88936806e-02f,
  8.95870179e-02f, 1.04778387e-01f, 2.25638062e-01f, 6.65170327e-03f, -3.24884281e-02f, -3.12387854e-01f, -2.87398379e-02f, 5.17934635e-02f, 2.42819209e-02f, 1.07587926e-01f,
  1.75772477e-02f, 9.03711170e-02f, 2.26735044e-02f, 1.81698218e-01f, -3.70900333e-01f, 1.87323719e-01f, -1.34152519e-02f, -8.38432387e-02f, 1.82116792e-01f, 1.65112272e-01f,
  -9.36182961e-03f, 4.29148912e-01f, -1.11641496e-01f, -1.03726089e-01f, 9.28082243e-02f, 1.38140395e-01f, 1.17505357e-01f, 2.22254574e-01f, 5.20222783e-02f, -1.21158706e-02f,
  3.98746915e-02f, 1.33467093e-01f, 2.31591135e-01f, 1.72984585e-01f, -2.68933997e-02f, -4.13300171e-02f, 1.83908552e-01f, 3.62917259e-02f, 1.52683118e-02f, -6.37188554e-02f,
  1.52690619e-01f, -7.66446143e-02f, -1.13725595e-01f, 3.67000215e-02f, -5.15366867e-02f, -3.24498676e-02f, -5.57391718e-02f, 3.19157213e-01f, -8.61916840e-02f, -5.40773049e-02f,
  5.81899583e-02f, -2.42471676e-02f, 2.38096695e-02f, 9.65806469e-03f, -4.92898300e-02f, -1.56364232e-01f, -4.77939770e-02f, 1.49475679e-01f, -1.17729455e-01f, -4.32853103e-02f,
  -1.95056617e-01f, -7.37822726e-02f, -8.61807838e-02f, -1.35658458e-01f, 3.01040113e-02f, -1.64166346e-01f, -9.63786840e-02f, -1.65439233e-01f, -2.45588943e-01f, 3.30537975e-01f,
  2.18946248e-01f, -1.77607998e-01f, -4.05156128e-02f, -2.39473239e-01f, 1.87446997e-01f, -6.19466230e-02f, -7.85583034e-02f, -3.12808424e-01f, 4.89139080e-01f, -8.11594278e-02f,
  6.15844317e-03f, -7.66904205e-02f, -1.99861839e-01f, 1.09851152e-01f, -3.87707353e-02f, -2.80637950e-01f, 1.56949073e-01f, -4.78610769e-03f, 2.24231202e-02f, -9.30139944e-02f,
  2.06197263e-03f, 1.06289580e-01f, -1.70507431e-02f, 1.77821234e-01f, -8.62447172e-02f, -1.36831284e-01f, -2.61629581e-01f, -2.37304047e-01f, -1.35415047e-02f, 4.80001085e-02f,
  1.47170991e-01f, -8.24899971e-02f, 9.93414447e-02f, -6.51220158e-02f, -1.88273396e-02f, 1.13822050e-01f, 1.48396686e-01f, 1.59038886e-01f, -2.80724838e-02f, 8.79258439e-02f,
  -9.17517915e-02f, -2.55886223e-02f, 3.82168740e-02f, 1.34307355e-01f, -1.98269084e-01f, -1.71705365e-01f, 1.69639379e-01f, -1.42508307e-02f, 5.09576797e-02f, -1.41926453e-01f,
  3.46281044e-02f, 1.71742260e-01f, 4.23010513e-02f, 2.81581342e-01f, -1.15687206e-01f, 1.64042369e-01f, 9.32169110e-02f, 1.10564008e-01f, -1.53558493e-01f, 3.26747477e-01f,
  -2.15400413e-01f, 6.41931817e-02f, 2.65574187e-01f, -1.60707131e-01f, -1.60046950e-01f, 2.00538203e-01f, -1.09387100e-01f, 2.03718752e-01f, -2.92563960e-02f, 1.89047039e-01f,
  7.58028962e-03f, 1.28282070e-01f, -1.37225717e-01f, -9.31621119e-02f, -1.19923977e-02f, -1.29788771e-01f, 6.76699728e-02f, -3.54811758e-01f, 1.53862610e-01f, -3.78022753e-02f,
  1.94838494e-01f, -1.42749241e-02f, -1.09683089e-01f, 6.79620951e-02f, 6.87451065e-02f, 3.84946279e-02f, 4.35663499e-02f, 7.23483935e-02f, 7.27240592e-02f, -4.72713821e-03f,
  3.98554020e-02f, -5.83331138e-02f, 2.20341738e-02f, -6.38573989e-02f, 1.16130218e-01f, 4.66909893e-02f, 7.06911683e-02f, 1.11023739e-01f, 1.09482326e-01f, 7.42784236e-03f,
  2.37117521e-02f, 1.75114106e-02f, -1.53988943e-01f, 1.23096965e-02f, 1.31169811e-01f, -1.66104034e-01f, -1.25591010e-01f, -2.88245920e-03f, -1.41315266e-01f, -6.22839555e-02f,
  -1.87555365e-02f, 6.45044148e-02f, -7.66488239e-02f, -7.91170746e-02f, -1.11180067e-01f, 1.51164353e-01f, -1.66007448e-02f, 2.12037995e-01f, -1.20449647e-01f, 5.13560846e-02f,
  6.05362281e-02f, -6.80536544e-03f, 8.57434422e-02f, 5.41367717e-02f, -1.94335148e-01f, 1.15902677e-01f, 3.68755087e-02f, -1.72815710e-01f, 1.60334751e-01f, -1.96123798e-03f,
  -1.23757184e-01f, 1.29907981e-01f, 1.81065857e-01f, -6.21101633e-02f, -1.60544276e-01f, -1.96799502e-01f, 4.57166970e-01f, 1.02201603e-01f, -1.69146761e-01f, 6.84360340e-02f,
  -1.94579333e-01f, -1.01133183e-01f, 1.13957241e-01f, -1.43191427e-01f, 1.21165723e-01f, 9.31870192e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.46336207e-01f, 1.21691138e-01f, 1.95804745e-01f, 5.67958914e-02f, 3.90179344e-02f, 2.83443928e-02f, 3.56599279e-02f, 3.66838649e-02f, 8.86120424e-02f, 3.79002392e-02f,
  3.41775976e-02f, -3.95117179e-02f, 7.87707120e-02f, -6.87582940e-02f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.57519519e-01f, -7.51291439e-02f, -1.50924146e-01f, -1.07314670e-02f, -2.44853020e-01f, -8.62975866e-02f, -7.36711621e-02f, 4.97946814e-02f, 1.86112836e-01f, 3.01337242e-01f,
  7.31452778e-02f, -9.24301594e-02f, 1.09038152e-01f, -7.68517086e-04f, 1.81472711e-02f, 1.17926501e-01f, 1.40918314e-01f, -9.78564247e-02f, 2.21676230e-01f, -1.10995464e-01f,
  -4.92767394e-02f, -4.99281287e-02f, 2.62815237e-01f, 2.37695813e-01f, 1.51834369e-01f, 7.91417900e-03f, 3.17886397e-02f, 3.59714068e-02f, 1.13771610e-01f, 3.04971579e-02f,
  1.45336911e-01f, -3.45185623e-02f, 1.20170563e-01f, 6.30724877e-02f, 2.80634072e-02f, 6.13725744e-02f, -1.47009611e-01f, 2.12188050e-01f, 3.25964540e-01f, 5.34364022e-02f,
  2.12581411e-01f, 1.00038022e-01f, 1.70948476e-01f, 1.42764553e-01f, -2.37219155e-01f, -2.51492858e-01f, 2.38640346e-02f, 2.53307313e-01f, 1.42757669e-01f, -5.70439808e-02f,
  5.47844656e-02f, 2.48501189e-02f, 1.65233672e-01f, 1.47365611e-02f, -3.79568934e-02f, -2.38087431e-01f, -1.86008781e-01f, -1.76924512e-01f, -1.11901157e-01f, 1.37865515e-02f,
  1.07800648e-01f, -2.13764966e-01f, 1.00182928e-01f, -9.36470404e-02f, 9.48563665e-02f, 9.68654379e-02f, -2.17994288e-01f, 9.17949528e-02f, -1.75266460e-01f, 9.96191278e-02f,
  6.08018832e-03f, 2.16271147e-01f, 4.97201011e-02f, -7.37441182e-02f, 4.68795523e-02f, -7.60962069e-02f, -1.30757600e-01f, -2.00388446e-01f, 1.51830271e-01f, -2.00270742e-01f,
  -5.08281328e-02f, -6.69697523e-02f, -4.24164645e-02f, 1.45093501e-01f, 1.60927162e-01f, -2.88156927e-01f, 3.49108092e-02f, -1.23738805e-02f, -6.67083189e-02f, -1.94126293e-01f,
  -6.66881055e-02f, 5.16753905e-02f, 6.90415427e-02f, 1.50512546e-01f, 1.15617462e-01f, -1.77758813e-01f, 9.54171494e-02f, -4.44873534e-02f, -7.58892074e-02f, 1.92572311e-01f,
  -2.46864259e-01f, 2.55312443e-01f, -9.24790800e-02f, 1.62077159e-01f, -1.18249051e-01f, -1.14067569e-01f, 2.09868982e-01f, -1.75862372e-01f, -5.23280315e-02f, -1.25987306e-01f,
  -2.38333945e-03f, 1.25164017e-01f, 1.01068303e-01f, -2.22378835e-01f, -1.45953998e-01f, 2.28439480e-01f, 1.03995942e-01f, -1.34220645e-02f, -1.64020553e-01f, -6.71011433e-02f,
  -8.36600140e-02f, -9.21876729e-02f, -7.66376257e-02f, -1.98602583e-03f, 5.23548713e-03f, -2.87816405e-01f, -7.53050521e-02f, -1.98130324e-01f, 4.88955453e-02f, 1.30546838e-01f,
  -3.82346250e-02f, -1.12995720e-02f, -7.75489584e-02f, -1.22040711e-01f, 8.77141580e-02f, -1.67736679e-01f, -1.79235619e-02f, 2.76650161e-01f, -2.41124853e-01f, 1.78515445e-02f,
  -1.67196959e-01f, -2.44027674e-01f, 1.05339535e-01f, -1.08070575e-01f, 7.87657127e-02f, 1.26764864e-01f, 9.97568760e-03f, 2.32764725e-02f, -3.27249765e-02f, -7.37329647e-02f,
  -2.47424379e-01f, 2.20983908e-01f, 9.07538682e-02f, -1.73665017e-01f, -2.48080269e-01f, 6.53064698e-02f, -9.54391360e-02f, 1.01620164e-02f, 2.67705500e-01f, -5.40543981e-02f,
  -1.06027193e-01f, 4.02082801e-02f, -3.21598835e-02f, 6.40590042e-02f, -2.81197764e-02f, 8.63644332e-02f, -6.03317879e-02f, 1.88544124e-01f, -9.14324895e-02f, 5.41465878e-02f,
  8.47014189e-02f, -4.28103209e-02f, -1.16866626e-01f, -1.70781687e-01f, -1.33320034e-01f, -1.35572841e-02f, 9.80458260e-02f, -3.04610610e-01f, -1.05508678e-01f, 1.70449764e-01f,
  -2.06985418e-02f, 6.41539320e-02f, -2.32477441e-01f, -2.01703578e-01f, 6.07832596e-02f, 8.65461752e-02f, 1.78162139e-02f, 9.48338956e-02f, 5.57622984e-02f, 4.70818430e-02f,
  -4.02895398e-02f, -4.02806140e-02f, 6.63113371e-02f, -1.28260210e-01f, 1.27046956e-02f, 1.64098009e-01f, 5.40538430e-02f, -1.32809311e-01f, 4.87160077e-03f, -7.03272596e-02f,
  -2.25843892e-01f, -2.78550051e-02f, -2.47802272e-01f, -1.15903214e-01f, -1.46731630e-01f, 1.10684298e-01f, 8.81620497e-02f, -1.28690064e-01f, -1.68111101e-01f, -1.61662549e-02f,
  -1.31296992e-01f, 2.46787854e-02f, -4.08654392e-01f, -1.78237930e-02f, 3.37896449e-03f, 1.65279612e-01f, 6.76066652e-02f, 7.48835579e-02f, -1.86154872e-01f, 1.29376367e-01f,
  5.38646281e-02f, -5.37937805e-02f, 1.36410490e-01f, -9.22105089e-02f, 2.30123326e-01f, 3.58346887e-02f, 6.91663399e-02f, -2.28100851e-01f, 1.24577723e-01f, -3.12560797e-01f,
  -9.22834054e-02f, 7.05769211e-02f, 2.31223963e-02f, -4.25773337e-02f, -1.23901054e-01f, 1.75775483e-01f, -5.26356101e-02f, -4.69353460e-02f, 1.99789941e-01f, 7.75317326e-02f,
  1.26279652e-01f, -4.00749855e-02f, -2.21085981e-01f, -2.46830564e-02f, -1.78256258e-01f, 7.21306130e-02f, -7.64693096e-02f, -8.45749080e-02f, 1.73500970e-01f, 1.82429835e-01f,
  1.41176227e-02f, 3.60873133e-01f, 6.82797655e-02f, -1.03130154e-02f, -4.29811329e-02f, 2.37185046e-01f, -1.19792715e-01f, -1.13079250e-01f, 9.60458592e-02f, -2.17798706e-02f,
  1.76940799e-01f, -1.16999499e-01f, -1.78911537e-01f, 4.51272763e-02f, 1.65054761e-02f, -2.96484828e-01f, 1.15265653e-01f, -1.04211234e-01f, -6.91472217e-02f, 1.32846743e-01f,
  -9.95843858e-02f, 1.46920398e-01f, 7.46410415e-02f, -1.01968013e-02f, -3.05882897e-02f, 1.47156175e-02f, 1.67545408e-01f, 8.63101520e-03f, -3.38637233e-01f, -9.43919718e-02f,
  -5.69937937e-02f, 2.28509158e-02f, -7.24689141e-02f, 1.69710323e-01f, 2.56052226e-01f, -6.38429895e-02f, -3.27710479e-01f, 2.13489339e-01f, -1.19602673e-01f, 1.14411555e-01f,
  6.66887164e-02f, 8.41450468e-02f, -6.45257086e-02f, -2.68059045e-01f, -2.37520039e-01f, -1.82223037e-01f, -1.42243013e-01f, -1.04516104e-01f, -3.72522712e-01f, 3.77888530e-02f,
  4.16221887e-01f, 3.25889960e-02f, 6.28394037e-02f, -3.81083846e-01f, -2.82317579e-01f, 2.16372445e-01f, 8.18488672e-02f, -7.15144947e-02f, 2.93334965e-02f, -1.40667349e-01f,
  -4.64052968e-02f, 2.16579989e-01f, 2.61688288e-02f, -1.21757360e-02f, 7.71295838e-03f, 3.99765000e-02f, -3.21570076e-02f, -1.95350334e-01f, 1.21809207e-01f, 4.33939360e-02f,
  -9.04266462e-02f, 5.69589809e-02f, 3.81857641e-02f, 2.25205021e-03f, 5.43904155e-02f, -1.94781259e-01f, -1.27429545e-01f, -4.11760574e-03f, -2.48442829e-01f, -4.28867899e-02f,
  1.88034073e-01f, -8.46573636e-02f, -2.99294442e-01f, 1.52808130e-01f, 1.01097517e-01f, -2.31676865e-02f, 2.05014087e-02f, 2.69012041e-02f, 1.86095431e-01f, 1.05190247e-01f,
  1.33266300e-01f, -7.84120464e-04f, -6.82627037e-03f, -1.01415455e-01f, 1.62869990e-01f, 6.71831369e-02f, 3.33391801e-02f, -5.48387915e-02f, 1.72218129e-01f, -2.30011225e-01f,
  -1.79788128e-01f, 9.95340943e-02f, -1.15978204e-01f, 2.22303435e-01f, -3.98891233e-02f, 2.56888986e-01f, -2.00869560e-01f, -2.27423802e-01f, 3.61041516e-01f, -8.91210698e-03f,
  -8.08652043e-02f, -1.96291149e-01f, 9.14284438e-02f, -1.18497424e-01f, 1.27936453e-01f, -1.19553218e-02f, -4.48446237e-02f, -3.87584627e-01f, -2.41169602e-01f, 1.70666084e-01f,
  -1.50942162e-01f, -9.23891887e-02f, 2.49813702e-02f, -2.63281018e-01f, -9.46064889e-02f, -1.12572759e-01f, -1.70879558e-01f, -2.02182129e-01f, -2.27836505e-01f, -9.09618884e-02f,
  -2.57914420e-02f, -5.47007471e-02f, -1.29215539e-01f, -3.01773436e-02f, 1.13057561e-01f, -1.69635102e-01f, -1.58359315e-02f, -3.40097509e-02f, -2.59930015e-01f, 2.18410969e-01f,
  1.10240072e-01f, 1.22700192e-01f, -1.73768364e-02f, -4.17782366e-02f, 8.54025260e-02f, 6.21406175e-02f, -1.33255213e-01f, -1.32414490e-01f, 3.14277858e-01f, -4.77834605e-02f,
  8.05387869e-02f, 2.03781411e-01f, -9.49294306e-03f, 7.20510930e-02f, 1.37421057e-01f, 1.02695957e-01f, -6.02806658e-02f, 2.09903926e-01f, 6.60652518e-02f, 2.45467797e-02f,
  -3.92762013e-02f, 1.69929132e-01f, -4.48038615e-03f, 2.37505063e-01f, -8.24709088e-02f, -1.68786898e-01f, -1.22914813e-01f, -5.04547775e-01f, -1.51146412e-01f, 4.00049806e-01f,
  1.29173473e-01f, 4.53311689e-02f, -2.08361983e-01f, -2.65450310e-02f, -2.67072953e-03f, -1.64922461e-01f, 2.28811055e-01f, -4.71858144e-01f, 9.74281281e-02f, 9.38824415e-02f,
  -4.78149857e-03f, 4.30211574e-02f, -1.74148947e-01f, -8.09801519e-02f, -5.64102503e-03f, 2.09874451e-01f, -1.49494469e-01f, 5.16122803e-02f, -5.84272854e-02f, -1.30219534e-01f,
  1.06768124e-01f, 6.92137852e-02f, 1.73085719e-01f, 1.61946028e-01f, -5.35373539e-02f, 3.35149211e-03f, -1.17051281e-01f, -9.22186077e-02f, -9.71329585e-02f, -1.63227469e-01f,
  1.46004170e-01f, -3.70401442e-02f, 2.70791519e-02f, 6.51860237e-02f, -1.19122624e-01f, -6.09596036e-02f, -1.91432163e-01f, -1.03461415e-01f, 4.71927524e-02f, 1.89282149e-02f,
  -1.69627190e-01f, -5.36924787e-02f, 1.96272328e-01f, -2.77870208e-01f, 1.37450518e-02f, 1.12504020e-01f, -1.65277615e-01f, 3.13198492e-02f, -1.56759337e-01f, -1.53532282e-01f,
  -2.70798028e-01f, -3.36373150e-02f, 1.46534070e-02f, -2.03936517e-01f, 2.07101822e-01f, -1.55529112e-01f, 1.38520330e-01f, -1.73846111e-01f, -1.52697042e-01f, -1.21231340e-01f,
  -2.59705156e-01f, 2.56290495e-01f, -2.20863029e-01f, 1.66873142e-01f, -2.06369594e-01f, 2.56707296e-02f, 1.46815050e-02f, 6.74993871e-03f, 2.03433231e-01f, 1.02265291e-01f,
  6.46767393e-02f, -3.06459039e-01f, 2.50049978e-01f, 3.15416865e-02f, 3.36106658e-01f, -1.66239142e-01f, -2.31995463e-01f, 9.25424024e-02f, -5.75584471e-02f, 1.12558566e-01f,
  -5.05569763e-02f, -1.89042121e-01f, 2.74146814e-02f, -1.12072125e-01f, -2.33532429e-01f, -6.32642359e-02f, -4.91617657e-02f, 2.00716868e-01f, 1.42991930e-01f, -3.14047575e-01f,
  1.69374242e-01f, -1.31046489e-01f, -3.16882372e-01f, -1.20464116e-02f, 7.30252489e-02f, -7.50861987e-02f, 2.60844350e-01f, -2.21616536e-01f, -2.49241948e-01f, 9.73492488e-02f,
  7.30119227e-03f, -5.27507365e-01f, -1.63427532e-01f, -2.89185662e-02f, -3.50893885e-01f, 1.14232741e-01f, -3.06531489e-01f, -1.49365202e-01f, -1.58480510e-01f, 4.11150716e-02f,
  -8.49205703e-02f, -1.15587458e-01f, -1.88238248e-01f, 5.39659569e-03f, -2.40682751e-01f, -2.44851649e-01f, -5.67386299e-02f, -3.58767435e-02f, -5.82766980e-02f, 1.21677853e-01f,
  1.45005003e-01f, -1.08346138e-02f, -4.36239950e-02f, -3.25295106e-02f, -1.06801756e-01f, 1.77233279e-01f, 1.97068051e-01f, 6.98539242e-02f, 2.51089007e-01f, -3.18370819e-01f,
  -1.13729164e-01f, -1.83116764e-01f, -1.02588996e-01f, -1.59144253e-01f, -3.49348873e-01f, -1.27960607e-01f, 1.49535760e-01f, 3.14571969e-02f, -6.88171014e-02f, -1.66238829e-01f,
  -2.36694455e-01f, 5.74981645e-02f, -1.49895057e-01f, 1.38229607e-02f, -7.62546211e-02f, -1.26549363e-01f, -5.45629039e-02f, 2.27126434e-01f, 1.36223182e-01f, 2.50854850e-01f,
  -1.72479209e-02f, 1.20138019e-01f, -2.46017929e-02f, 3.75188515e-02f, -9.21043232e-02f, 1.01514496e-01f, 1.90098211e-02f, 6.32452741e-02f, -1.03609256e-01f, -7.66196176e-02f,
  -7.34860003e-02f, 3.51315551e-02f, 3.01208328e-02f, -1.11245573e-01f, 1.93465557e-02f, 1.96178313e-02f, 2.90207583e-02f, -1.31763428e-01f, 1.39917314e-01f, -9.75681841e-02f,
  -5.14809527e-02f, -4.15094458e-02f, 2.31318712e-01f, -1.79411322e-01f, 7.50844851e-02f, -1.31437019e-01f, 1.69989660e-01f, 1.23760685e-01f, 2.35752147e-02f, -5.97344972e-02f,
  -2.04434842e-01f, 1.64752454e-01f, 1.71797797e-01f, 7.89348334e-02f, 2.12919325e-01f, -1.68049652e-02f, 4.93959300e-02f, 1.29400626e-01f, 8.85457844e-02f, 6.99073002e-02f,
  -2.96010286e-01f, -1.33475870e-01f, -8.53479505e-02f, 3.39785248e-01f, 2.51421124e-01f, -6.37351573e-02f, 3.41601640e-01f, 2.54956692e-01f, 3.11702132e-01f, 1.60375327e-01f,
  -2.56988965e-03f, 1.55018508e-01f, 2.52183884e-01f, 9.39278528e-02f, -3.44262319e-03f, 2.29770809e-01f, 5.18776961e-02f, -6.02218397e-02f, 1.51471838e-01f, -1.07905656e-01f,
  2.59266049e-01f, 1.76963627e-01f, 1.10525019e-01f, -1.43011943e-01f, 2.43493095e-02f, -3.07981938e-01f, -4.75317165e-02f, 1.42268836e-01f, -2.15799287e-01f, -5.64486235e-02f,
  -2.63891906e-01f, 9.19036567e-02f, -5.29384352e-02f, -8.10457394e-02f, 2.07677811e-01f, 1.79742575e-01f, 2.57079024e-02f, 3.63871232e-02f, -1.38394594e-01f, -1.75624847e-01f,
  3.19821276e-02f, -5.47669791e-02f, 2.22281381e-01f, 1.03404224e-01f, -6.55028671e-02f, 7.41417632e-02f, 6.52329847e-02f, 1.39309600e-01f, -5.59830107e-02f, 9.94250178e-02f,
  -5.86053915e-02f, -1.16328806e-01f, -2.30237022e-01f, -1.99434787e-01f, -1.11470185e-01f, -1.03904217e-01f, 5.91263436e-02f, -3.21834013e-02f, 1.85777202e-01f, -2.48032752e-02f,
  9.11818519e-02f, 1.70470089e-01f, -1.63897023e-01f, 2.19459385e-01f, -7.58955330e-02f, -3.46769132e-02f, -6.87499791e-02f, 5.31292520e-03f, 1.33621916e-01f, -1.32597074e-01f,
  1.14406161e-01f, -3.58996205e-02f, 1.37972325e-01f, -1.22120909e-01f, 2.24519506e-01f, 1.23753764e-01f, 6.62094727e-02f, -2.25102916e-01f, -1.59658074e-01f, 3.85455161e-01f,
  1.13002695e-01f, 3.38739455e-02f, 5.06210364e-02f, -1.85335577e-01f, 1.10045701e-01f, 1.44045353e-01f, 9.01687443e-02f, -2.49463134e-02f, -1.30335882e-01f, -2.32172683e-02f,
  1.62820160e-01f, -2.75666535e-01f, 1.43838450e-01f, -5.05039133e-02f, -1.71116114e-01f, 2.36605760e-02f, -9.24415588e-02f, 9.47047547e-02f, 1.25992447e-01f, -9.97417793e-02f,
  -1.66417927e-01f, -1.41195878e-01f, -2.49605089e-01f, -1.62343942e-02f, -1.25734881e-01f, 3.54604758e-02f, 2.05744207e-01f, 1.65504944e-02f, -1.00951202e-01f, 3.66214663e-02f,
  -1.10491104e-02f, -2.01757755e-02f, 3.58905569e-02f, -1.56803682e-01f, -6.58123717e-02f, 5.86906914e-03f, -9.96114593e-03f, -1.35133460e-01f, -3.01555116e-02f, 2.36947745e-01f,
  -1.29620686e-01f, 1.31286502e-01f, -8.71763974e-02f, 1.66113153e-02f, 2.79337585e-01f, 2.38706723e-01f, -1.02816753e-01f, 1.00555107e-01f, 5.63833453e-02f, -1.24760583e-01f,
  3.84295374e-01f, 9.99726579e-02f, -1.06739394e-01f, -1.30583107e-01f, -5.92716560e-02f, 3.36796194e-01f, -4.35585380e-02f, 1.96119860e-01f, -1.79014847e-01f, -9.50366780e-02f,
  1.38986006e-01f, -8.00580904e-03f, 1.69047773e-01f, 9.73986313e-02f, -3.34599055e-02f, -1.98424961e-02f, 5.03664836e-02f, -4.06626612e-02f, 2.58269496e-02f, -3.40491310e-02f,
  2.28807434e-01f, 2.28389993e-01f, -1.24859445e-01f, 5.97554855e-02f, 7.04861432e-02f, 2.41773680e-01f, -2.11435452e-01f, 1.82537302e-01f, -9.31952372e-02f, -1.49965048e-01f,
  7.53012951e-03f, -1.66249037e-01f, 1.65792853e-01f, 8.36975724e-02f, -4.84552458e-02f, -2.10407764e-01f, -3.86220701e-02f, 1.93914518e-01f, -1.67243704e-01f, 8.39568395e-03f,
  9.94375870e-02f, 4.64389734e-02f, 8.48421231e-02f, -3.24246027e-02f, -5.18333949e-02f, 1.10442743e-01f, -7.66856670e-02f, 8.93892795e-02f, 8.88761654e-02f, 1.35024078e-02f,
  -1.03615960e-02f, -4.29288745e-02f, 1.00401431e-01f, -1.60344526e-01f, 5.99537604e-02f, -2.20601022e-01f, 1.23824894e-01f, -7.44225532e-02f, -3.66237313e-02f, -1.86337084e-01f,
  1.60988212e-01f, -1.47731174e-02f, -1.94962978e-01f, 1.04319416e-01f, -3.62673551e-01f, -2.34433591e-01f, -5.50600663e-02f, 2.26128027e-01f, -1.56702623e-01f, -7.86827691e-03f,
  4.93602678e-02f, 3.96503955e-02f, 2.66692430e-01f, -1.21049141e-03f, -1.09501323e-02f, -1.43397495e-01f, -1.14413194e-01f, 9.57481191e-02f, -5.81357516e-02f, -1.16367400e-01f,
  -1.81166291e-01f, 7.02973381e-02f, -1.48692578e-02f, -6.18917644e-02f, -9.98982638e-02f, 1.66809410e-01f, 4.11267690e-02f, -6.88729435e-02f, 5.43608144e-02f, -1.24224842e-01f,
  1.68711796e-01f, 2.45451570e-01f, -1.36037301e-02f, 9.10599828e-02f, 1.86077386e-01f, 2.50352919e-01f, -1.95563987e-01f, 1.19256206e-01f, 1.05780557e-01f, -7.25528598e-02f,
  1.91560134e-01f, 5.82317337e-02f, -3.27304602e-02f, 1.65486455e-01f, -6.07916787e-02f, 3.76927517e-02f, 1.80463448e-01f, -3.67850028e-02f, 4.73439917e-02f, -9.33853611e-02f,
  -2.21421748e-01f, 1.94068432e-01f, 2.03228109e-02f, -1.44973740e-01f, 1.70015886e-01f, 3.64752039e-02f, -2.69621909e-02f, 1.64676066e-02f, -2.19621643e-01f, 1.61346458e-02f,
  1.28691480e-01f, -1.34777166e-02f, 1.87336266e-01f, -3.72016281e-02f, 2.15874210e-01f, -1.96835414e-01f, 6.78677484e-02f, 9.43011865e-02f, -8.78583565e-02f, -7.68708065e-02f,
  1.03189088e-01f, 1.18054949e-01f, -8.58367309e-02f, -1.12736814e-01f, 1.00749411e-01f, -1.58369645e-01f, -1.01925254e-01f, 1.90089658e-01f, -7.05942065e-02f, 3.35954688e-02f,
  1.85242109e-02f, 1.07054122e-01f, -1.22791201e-01f, 2.75432765e-01f, -1.62362188e-01f, 9.04950052e-02f, -8.70043412e-02f, -1.13545135e-01f, -4.65126596e-02f, 1.98775634e-01f,
  -1.08021177e-01f, 2.12226525e-01f, 1.14708900e-01f, -1.36627408e-03f, -1.02792300e-01f, 3.39324363e-02f, -2.40222096e-01f, -3.93542014e-02f, -1.80693582e-01f, 1.12946674e-01f,
  -1.97107285e-01f, 1.40435593e-02f, 3.25380750e-02f, -3.37233357e-02f, -8.40522051e-02f, -5.66820940e-03f, -2.99900115e-01f, 1.10082468e-02f, 2.22362857e-02f, -1.27265915e-01f,
  5.43482602e-02f, 3.10380626e-02f, 1.13566466e-01f, -7.63482228e-03f, -1.44028947e-01f, -2.08328545e-01f, 3.99804115e-02f, -9.75323468e-02f, 1.27144232e-01f, -1.01120118e-02f,
  -1.63946167e-01f, 9.41031799e-02f, -5.65238595e-02f, -2.03508064e-01f, -2.52981693e-01f, -3.68183926e-02f, 1.34418175e-01f, -2.23551895e-02f, -3.19410418e-03f, -2.51325339e-01f,
  -1.70326710e-01f, 1.33436918e-01f, 1.97231360e-02f, 1.21736959e-01f, -3.04429829e-01f, 2.87801325e-01f, -2.74584204e-01f, 8.39862898e-02f, 1.36210412e-01f, 1.91155802e-02f,
  -2.27567539e-01f, -1.94774285e-01f, -2.13551342e-01f, 1.49660036e-01f, 2.01848745e-02f, -2.15887263e-01f, 1.89223543e-01f, -1.04444362e-01f, 1.01844877e-01f, 2.93307528e-02f,
  3.70211415e-02f, -1.89749077e-01f, -2.52649225e-02f, 1.59806445e-01f, 2.01458514e-01f, 1.58880487e-01f, 2.14143917e-02f, -2.88525701e-01f, -7.96815380e-02f, -5.33416271e-02f,
  -2.84007918e-02f, 3.63591267e-03f, 3.80006917e-02f, -2.02067450e-01f, 1.97857395e-01f, -1.12893529e-01f, 1.42620370e-01f, -8.76731426e-02f, 3.00076995e-02f, 1.26850113e-01f,
  -9.84081551e-02f, -2.51015842e-01f, -6.11564033e-02f, 1.04559315e-02f, 2.15089515e-01f, 1.90024003e-01f, 3.14878672e-02f, -1.46635428e-01f, -2.84354001e-01f, -2.55791634e-01f,
  -1.36277542e-01f, -1.54742347e-02f, -5.14275804e-02f, 1.43335566e-01f, 2.26070322e-02f, -2.05388278e-01f, -2.11714208e-01f, 1.43388793e-01f, 5.34357280e-02f, -3.18482816e-01f,
  2.50546515e-01f, -2.84516841e-01f, 9.59053636e-03f, 1.56994954e-01f, 2.72503793e-01f, 4.32877317e-02f, -3.57321724e-02f, -1.91785574e-01f, 5.75052127e-02f, -1.75200645e-02f,
  7.34452680e-02f, -1.28842905e-01f, -1.68681756e-01f, 1.33578563e-02f, 2.07679078e-01f, -6.03315420e-02f, -2.76861936e-01f, -1.76564440e-01f, -6.94626048e-02f, -2.57561766e-02f,
  -1.55029565e-01f, 1.15060605e-01f, -2.86970615e-01f, -1.80523805e-02f, -1.95087254e-01f, 7.48664290e-02f, -1.38171837e-01f, 6.23865649e-02f, 9.57012028e-02f, 1.33357763e-01f,
  -4.92136665e-02f, -1.30148768e-01f, 7.35441744e-02f, 1.08566806e-01f, -1.18660986e-01f, -6.59385175e-02f, -8.95903271e-04f, -1.14719838e-01f, 2.46878430e-01f, 2.06093624e-01f,
  -2.99619194e-02f, 6.27627522e-02f, -8.53596851e-02f, 9.80990529e-02f, 1.57596037e-01f, -3.86721008e-02f, 4.52500582e-02f, -3.93557325e-02f, 3.91993858e-02f, 1.32043317e-01f,
  6.31481782e-02f, 8.28229114e-02f, -1.86956991e-02f, -1.90428108e-01f, -3.00313942e-02f, 1.12963961e-02f, -4.28751744e-02f, -1.40167829e-02f, 6.06038570e-02f, -3.46997567e-02f,
  2.64442176e-01f, -3.79047930e-01f, 6.37079626e-02f, -1.43157676e-01f, 1.20290861e-01f, -3.33737992e-02f, 3.54010127e-02f, 1.59014791e-01f, -7.84094110e-02f, 7.10218027e-02f,
  -9.04608890e-02f, -2.88915671e-02f, 1.93387076e-01f, -1.19333722e-01f, 2.83940107e-01f, 5.70574962e-02f, 1.93157624e-02f, -1.11804247e-01f, 7.76944831e-02f, -1.17758838e-02f,
  8.12616795e-02f, -1.87858343e-02f, -3.69930357e-01f, 3.80679578e-01f, -1.08967058e-01f, -4.14918438e-02f, 6.04977384e-02f, -1.21021882e-01f, 1.50963813e-01f, 3.99131291e-02f,
  4.80373465e-02f, -1.54754892e-02f, 1.08363621e-01f, 9.50888693e-02f, 1.63744181e-01f, -2.73032784e-01f, -1.02302050e-02f, -5.17309383e-02f, 2.42019475e-01f, -1.34350419e-01f,
  -2.93594599e-02f, 8.83123428e-02f, -6.44375905e-02f, 1.51525646e-01f, 4.50150929e-02f, 1.73142944e-02f, -5.80317080e-02f, -6.94284029e-03f, 1.44421473e-01f, -6.65585101e-02f,
  -2.06138104e-01f, 1.36600748e-01f, -1.88990636e-03f, -3.19355465e-02f, -1.57586448e-02f, -3.80746927e-03f, 5.85805699e-02f, -1.73670668e-02f, -9.56938118e-02f, -3.28770690e-02f,
  -2.94805262e-02f, -1.58738598e-01f, 1.73010826e-01f, -2.19384760e-01f, 2.62639016e-01f, -4.31571126e-01f, 2.57813722e-01f, -1.01389803e-01f, -1.94036201e-01f, -2.17077047e-01f,
  4.35435534e-01f, 3.94528776e-01f, -1.08009443e-01f, -1.66907549e-01f, -3.26873839e-01f, -1.40799031e-01f, 2.86842346e-01f, -1.22920372e-01f, 1.39879584e-01f, -2.00547185e-02f,
  -5.65419979e-02f, 9.82942358e-02f, 5.98954037e-02f, 1.19478993e-01f, 1.28181323e-01f, -7.63421282e-02f, -4.75975610e-02f, 1.41441405e-01f, -2.12781299e-02f, -1.59132674e-01f,
  -4.70238253e-02f, 1.45441756e-01f, 3.45744006e-02f, -3.90834175e-02f, -1.38305098e-01f, -1.07804850e-01f, -3.04805994e-01f, 9.18746889e-02f, 4.14919108e-03f, -3.88082266e-02f,
  7.00680837e-02f, -1.02279522e-01f, -1.10504836e-01f, -9.10963714e-02f, 1.17044255e-01f, -9.05341655e-02f, 2.72938788e-01f, 8.17853510e-02f, -1.27214581e-01f, -2.97039419e-01f,
  1.61200538e-01f, -7.28111044e-02f, -2.64482617e-01f, 5.41910864e-02f, 5.25772758e-02f, 2.12888885e-02f, -2.16238931e-01f, -8.94244984e-02f, 8.43741670e-02f, -1.29358694e-01f,
  -1.43835947e-01f, 8.05411895e-04f, -2.98223719e-02f, 1.91210628e-01f, -8.74596313e-02f, 1.16059603e-02f, -2.32689772e-02f, 5.20962141e-02f, 1.05949298e-01f, 3.38958576e-02f,
  1.55131638e-01f, -2.16473281e-01f, -8.67605582e-02f, 1.24102764e-01f, 1.40988141e-01f, 1.99280351e-01f, -7.69096334e-03f, -1.94147274e-01f, 1.35767952e-01f, -3.07601154e-01f,
  8.92253220e-02f, -7.86049962e-02f, 2.43125543e-01f, -5.69621064e-02f, -3.29163730e-01f, 2.15701908e-01f, -1.40855284e-02f, 7.24623799e-02f, -1.04224067e-02f, -2.87085414e-01f,
  -5.61722815e-02f, 1.04394834e-02f, -3.63112800e-03f, -2.20448196e-01f, -9.79252011e-02f, 7.02296868e-02f, -1.12357608e-03f, 1.41939968e-01f, 2.07259059e-01f, 1.13478340e-01f,
  1.40384704e-01f, -1.51192054e-01f, -9.35866237e-02f, 2.05787987e-01f, 6.67840391e-02f, 1.63444206e-02f, -2.10213989e-01f, 8.16446543e-02f, -1.03681237e-01f, 7.15536177e-02f,
  1.81166276e-01f, -1.90049440e-01f, 7.22469613e-02f, -1.22863920e-02f, -9.76162311e-03f, 1.05031021e-01f, -9.51070189e-02f, 9.05792266e-02f, 2.84873862e-02f, 7.25353733e-02f,
  -1.35624595e-02f, -7.91184008e-02f, -5.06556891e-02f, 2.34356850e-01f, 6.17797710e-02f, 2.88800508e-01f, -5.08178063e-02f, -1.76583603e-01f, -1.18057981e-01f, 1.87977180e-02f,
  5.65544777e-02f, 1.34773385e-02f, -2.67973632e-01f, -5.03168479e-02f, -2.04608276e-01f, -1.04588963e-01f, 1.58640921e-01f, -3.83996731e-03f, 1.07546985e-01f, 1.29252091e-01f,
  1.92532271e-01f, -1.92593187e-02f, -4.21393178e-02f, 1.28903344e-01f, 9.04110353e-03f, 2.89560318e-01f, -1.62560686e-01f, -1.32147983e-01f, -7.64734894e-02f, 2.70286918e-01f,
  5.89128621e-02f, -1.63168818e-01f, 7.48068839e-02f, -2.08023041e-02f, 1.96057603e-01f, -2.50186801e-01f, -1.10184349e-01f, 5.86610176e-02f, -3.88301425e-02f, 2.07140073e-01f,
  -1.58191532e-01f, -3.08168590e-01f, 9.02502090e-02f, 8.95504057e-02f, -4.29917984e-02f, 2.57759959e-01f, 9.08811856e-03f, 1.21877724e-02f, -1.11933567e-01f, 1.92144498e-01f,
  2.72037392e-03f, 3.02674234e-01f, -2.21168920e-01f, -2.27563724e-01f, -1.03603490e-02f, 7.35063255e-02f, -4.55304869e-02f, 1.04009397e-01f, 1.09696917e-01f, 1.24021858e-01f,
  2.31807068e-01f, -3.31493095e-02f, 2.86722064e-01f, -3.36625315e-02f, -1.95984691e-01f, 2.33988613e-01f, 3.16657424e-01f, 2.54710633e-02f, 8.96290764e-02f, -1.18879139e-01f,
  1.28690898e-01f, -1.51278614e-03f, 1.05162144e-01f, -2.54524387e-02f, 2.03952104e-01f, 1.52061775e-01f, 2.41478384e-01f, -1.95205227e-01f, 3.35251987e-01f, 8.57206732e-02f,
  -2.13706434e-01f, 1.00840330e-02f, 1.49216220e-01f, 6.60989583e-02f, -2.01357007e-01f, 6.81944042e-02f, -2.33388141e-01f, 2.61775970e-01f, 2.31007174e-01f, -2.37206072e-02f,
  3.54470909e-01f, 9.61936936e-02f, -2.68011615e-02f, 2.99338065e-02f, 1.93730608e-01f, -3.26949880e-02f, 2.59536207e-02f, -6.87850341e-02f, -2.98743367e-01f, 4.61488783e-01f,
  1.81086645e-01f, 3.12440619e-02f, 2.42166758e-01f, -4.69848327e-02f, 1.01557381e-01f, 1.90786719e-01f, -1.23927452e-01f, -1.44555584e-01f, -5.61019257e-02f, -6.54303655e-02f,
  1.12402581e-01f, 2.41874941e-02f, 3.73905152e-02f, -5.27233556e-02f, -6.44089794e-03f, 3.34094614e-01f, -8.90965089e-02f, 4.67439508e-03f, 2.18322471e-01f, 5.28949499e-02f,
  -2.79685911e-02f, -3.73042151e-02f, 2.53856406e-02f, -6.98821917e-02f, -2.02237740e-01f, 6.19710796e-02f, 1.54994905e-01f, 4.28858027e-02f, -2.49363501e-02f, 1.28908977e-01f,
  -7.24600106e-02f, 6.55867234e-02f, -2.23314494e-01f, 1.34158522e-01f, -4.50755395e-02f, -1.30279720e-01f, 9.43032950e-02f, -4.44989093e-02f, 9.03610736e-02f, -4.47243005e-02f,
  1.28322050e-01f, -7.10740015e-02f, -9.84587986e-03f, 5.21407463e-04f, 7.62566775e-02f, 1.68497071e-01f, 1.35214135e-01f, 1.27153412e-01f, -3.59120853e-02f, -6.26712218e-02f,
  -6.07355908e-02f, 1.09437004e-01f, 3.81417647e-02f, -1.41725247e-03f, 1.57440335e-01f, -1.61928877e-01f, -2.29128283e-02f, 1.97460666e-01f, -3.06190640e-01f, -9.73687172e-02f,
  -2.82810032e-01f, 1.83677468e-02f, 2.27291975e-02f, -1.84066042e-01f, 7.55229294e-02f, -1.33470148e-01f, -1.10952616e-01f, 2.60824203e-01f, 2.93082893e-02f, 1.14256844e-01f,
  2.28367016e-01f, -8.86084810e-02f, -1.51326552e-01f, 2.92092208e-02f, -3.21893156e-01f, 5.23610264e-02f, -1.10261902e-01f, -1.55342728e-01f, -6.34193867e-02f, -2.21760795e-01f,
  -1.80157676e-01f, 6.22603074e-02f, 1.27674744e-01f, 9.62956548e-02f, 3.26227099e-02f, -5.43583930e-02f, 1.25037283e-01f, -4.46707457e-02f, -5.31768315e-02f, -9.12551116e-03f,
  -3.54064316e-01f, 1.80260211e-01f, 7.47917816e-02f, -7.42750568e-03f, 1.47049963e-01f, -9.83389840e-02f, 1.40373588e-01f, 1.33374825e-01f, -5.69357611e-02f, -2.21660823e-01f,
  -1.63844109e-01f, -2.67832223e-02f, 1.05053149e-02f, -2.73900449e-01f, 1.92180380e-01f, -4.43958402e-01f, 1.20153613e-01f, 2.62257792e-02f, -1.57966211e-01f, -2.51297653e-01f,
  2.50844777e-01f, 1.49343684e-02f, -2.95822412e-01f, -1.73134208e-01f, -8.32629949e-02f, -3.30213942e-02f, 2.91005392e-02f, 1.72420159e-01f, -1.02944225e-01f, -1.42427653e-01f,
  -1.57970026e-01f, -1.79971620e-01f, 1.39843971e-01f, 3.68357897e-02f, -1.76453471e-01f, -1.11755781e-01f, 9.53603238e-02f, -3.47835496e-02f, 1.66858867e-01f, -2.05554947e-01f,
  1.30986452e-01f, 1.79163888e-01f, 9.61399823e-02f, 1.44270748e-01f, -2.26014674e-01f, -2.16364682e-01f, 2.42453571e-02f, 5.96034899e-02f, -1.84999481e-01f, -2.89084643e-01f,
  2.29746327e-01f, -1.60885245e-01f, 2.84901019e-02f, 1.52258063e-02f, -3.13681811e-02f, 9.51720849e-02f, 3.13172825e-02f, -2.11848747e-02f, 1.46541029e-01f, -2.58161187e-01f,
  -1.56158283e-01f, 9.98241678e-02f, -3.12485605e-01f, 5.75082451e-02f, 2.75823493e-02f, 4.94264415e-04f, -3.72773930e-02f, 2.46657625e-01f, 7.10212514e-02f, -3.47665995e-02f,
  -8.38492438e-02f, -6.31572455e-02f, -1.28906757e-01f, -5.79506084e-02f, 2.85989661e-02f, 2.59789139e-01f, 1.84758410e-01f, 1.09217234e-01f, 2.82918178e-02f, -1.34406826e-02f,
  -6.52077496e-02f, -1.51091039e-01f, 3.80579308e-02f, 2.06390359e-02f, -6.24060538e-03f, -1.16784804e-01f, 7.15064555e-02f, -2.43974492e-01f, 6.27978742e-02f, -1.81965604e-01f,
  1.14424825e-01f, 3.34618613e-02f, 3.47449630e-02f, -1.40473098e-01f, -4.52727042e-02f, 3.40733677e-01f, -3.66543144e-01f, -5.74771874e-02f, -1.34043917e-01f, 2.54225791e-01f,
  1.09792732e-01f, -1.26808107e-01f, 6.44411594e-02f, -2.80076832e-01f, -1.63841546e-02f, 1.19099557e-01f, -2.44233981e-01f, -5.42054996e-02f, 1.96336582e-01f, -1.13530084e-01f,
  -2.83174440e-02f, -1.81703437e-02f, -2.63777971e-01f, 2.40215316e-01f, -1.05323404e-01f, 3.05137988e-02f, 2.12403685e-01f, -9.16689187e-02f, -3.15028578e-02f, 6.87275901e-02f,
  2.11188897e-01f, -1.72757104e-01f, 2.10894778e-01f, 1.04694948e-01f, 6.66193292e-02f, 1.88641474e-01f, -1.09445184e-01f, 1.28815204e-01f, 1.50150165e-01f, -4.58952785e-02f,
  1.84913099e-01f, -8.64637867e-02f, 7.53718913e-02f, 2.42664024e-01f, -1.05006464e-01f, 2.45416760e-01f, 9.16921534e-03f, -4.89077158e-02f, 1.72452763e-01f, 2.87008770e-02f,
  1.64943814e-01f, 2.66222768e-02f, -1.50226608e-01f, 7.74842724e-02f, 4.69162082e-03f, 7.41614848e-02f, 1.22308083e-01f, 7.74583146e-02f, 6.80439919e-02f, -1.51483074e-01f,
  2.91142225e-01f, -6.56802440e-04f, -4.20779027e-02f, -2.16994584e-01f, -2.25552738e-01f, 1.29261494e-01f, -2.29777664e-01f, -1.34124607e-01f, 1.28470147e-02f, 2.56039619e-01f,
  -5.22683449e-02f, -1.93685992e-03f, 9.27397329e-03f, -1.92612584e-03f, -4.23277393e-02f, -2.53688931e-01f, 2.98078768e-02f, -1.07093863e-02f, 1.48017202e-02f, 3.46204340e-02f,
  -2.15595886e-01f, -3.16471100e-01f, -6.71308413e-02f, 1.30730271e-01f, -1.60379007e-01f, 6.54739281e-03f, 7.25057274e-02f, 4.45192531e-02f, 9.19744372e-02f, 2.06620306e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -6.92483559e-02f, 3.01328022e-02f, 4.39300388e-03f, -1.44028112e-01f, -1.25226408e-01f, -2.49798037e-02f, 7.00410232e-02f, 1.36919096e-01f, 1.71768516e-01f, 6.97809905e-02f,
  1.72497213e-01f, 9.29002836e-03f, 3.62317771e-01f, -1.10835873e-01f, 2.19846591e-01f, 1.47969455e-01f, 9.11035910e-02f, -4.47444133e-02f, 7.77691836e-03f, 1.06038786e-01f,
  5.36059029e-02f, 8.01838487e-02f, -2.46493556e-02f, 3.42175737e-02f, 5.73720373e-02f, 7.03018531e-02f, -2.10953012e-01f, 5.73461279e-02f, -1.08536191e-01f, 3.41493070e-01f,
  2.13713199e-01f, 1.63346902e-01f, -1.04932897e-01f, -4.33162391e-01f, 1.26316234e-01f, 3.51342738e-01f, 3.22691530e-01f, 3.04398060e-01f, -1.80621505e-01f, 1.43138170e-01f,
  -2.72673786e-01f, 1.08593360e-01f, 2.28034258e-01f, 1.35873541e-01f, -9.75301787e-02f, 3.16885561e-02f, -1.31999210e-01f, 3.15980837e-02f, -2.19246715e-01f, -2.69424945e-01f,
  1.32836506e-01f, 2.53792942e-01f, 1.46221071e-01f, 1.24946162e-01f, 5.45426384e-02f, 4.03523929e-02f, 1.04991920e-01f, 8.00957307e-02f, 2.50094026e-01f, -5.00965193e-02f,
  9.39224064e-02f, 4.08775732e-02f, 3.50658409e-03f, -3.62652428e-02f, 3.44018728e-01f, 9.68328118e-02f, -4.93542058e-03f, 2.24643368e-02f, 3.89989823e-01f, 1.35902092e-01f,
  1.24009006e-01f, -2.60322094e-01f, 1.11381344e-01f, -2.97465045e-02f, 7.47072995e-02f, 1.69998705e-01f, 2.06836239e-01f, 3.00022334e-01f, -2.86465228e-01f, 1.86366573e-01f,
  1.35362567e-02f, -3.65978219e-02f, -5.12209572e-02f, 1.47964165e-01f, -5.06121106e-03f, 1.98524352e-02f, 5.94448522e-02f, 2.68659648e-02f, 7.09871501e-02f, 8.41439515e-02f,
  2.55776405e-01f, -8.13166425e-03f, 1.05752140e-01f, -2.96768956e-02f, -4.08252478e-01f, 1.47637501e-01f, 4.63329434e-01f, 2.22887188e-01f, -9.76126418e-02f, -3.06760937e-01f,
  -2.07767010e-01f, 2.04796754e-02f, -8.90636593e-02f, 1.00590944e-01f, -4.13689539e-02f, -1.09699786e-01f, -2.81188518e-01f, 3.33160549e-01f, 6.54044896e-02f, 1.45396546e-01f,
  9.65844318e-02f, 2.06438333e-01f, 3.88340764e-02f, 1.02124002e-03f, 2.53233910e-01f, -3.60406041e-02f, 8.93562287e-02f, 2.70841151e-01f, -8.19198564e-02f, 1.27881765e-01f,
  1.41636431e-01f, 8.97105038e-02f, -1.81025371e-01f, 1.85874969e-01f, 6.63841795e-03f, 1.93675220e-01f, 7.67935663e-02f, 1.67813808e-01f, 1.08400643e-01f, 2.69163042e-01f,
  8.52439404e-02f, 1.95395976e-01f, 1.05726600e-01f, 3.05522531e-01f, 1.41168004e-02f, -8.36180747e-02f, 1.77405089e-01f, -1.08989693e-01f, -2.28474572e-01f, -2.29997318e-02f,
  -3.25536579e-01f, 3.05477917e-01f, 2.48458385e-01f, 7.55810589e-02f, 7.34725827e-03f, 7.71546066e-02f, 8.78115892e-02f, 1.51300535e-01f, 1.65578559e-01f, 6.55189976e-02f,
  -8.53701774e-03f, 2.19489187e-01f, 6.63240030e-02f, -6.49574958e-03f, -4.84821573e-02f, 9.32263732e-02f, 1.78163033e-02f, -1.07877105e-01f, -7.43572041e-02f, -8.76091123e-02f,
  9.18378308e-02f, 1.40274644e-01f, 2.98819751e-01f, -1.16490155e-01f, -4.99819666e-02f, -4.52880442e-01f, -2.72849858e-01f, 1.18937530e-01f, -1.43067166e-01f, -4.72541958e-01f,
  -5.07778108e-01f, 1.03519097e-01f, -6.11952096e-02f, 5.69239184e-02f, -4.98701632e-01f, -2.10799687e-02f, -4.11753776e-03f, -1.24349654e-01f, 7.84454942e-02f, -1.00168556e-01f,
  -7.65026435e-02f, 2.12025374e-01f, -1.80869535e-01f, 1.98911577e-02f, 3.08799237e-01f, 7.38439262e-02f, 7.25305080e-02f, 2.28209168e-01f, -2.50285745e-01f, 2.16308579e-01f,
  1.82929143e-01f, -3.37339826e-02f, 2.22773731e-01f, -9.24623534e-02f, -7.60721117e-02f, 6.85466379e-02f, 2.02819631e-01f, 1.49405584e-01f, 2.01660410e-01f, 5.35980752e-03f,
  1.08854242e-01f, 2.78720438e-01f, 2.56074816e-02f, 1.01836167e-01f, 2.96850890e-01f, 2.07990795e-01f, -3.27216871e-02f, 2.41559982e-01f, 3.36918712e-01f, 7.54092038e-02f,
  2.00837165e-01f, 6.73759580e-02f, 1.00088462e-01f, 2.90943742e-01f, 6.03640452e-02f, 3.85222286e-02f, 7.92186111e-02f, -1.13587782e-01f, 2.46318519e-01f, -2.54579365e-01f,
  -9.36421566e-03f, -8.45047310e-02f, 3.94250639e-02f, -2.89241541e-02f, -4.12357897e-02f, -1.64347440e-01f, 9.17327553e-02f, 1.49632186e-01f, -1.97132260e-01f, -6.28899038e-02f,
  -1.41349047e-01f, 8.83508250e-02f, 2.01416910e-01f, -8.37669075e-02f, -9.21275839e-02f, -7.52324611e-02f, 2.65902709e-02f, 1.72534242e-01f, 3.83038782e-02f, -2.32658926e-02f,
  -2.73583859e-01f, 4.37428772e-01f, 3.54550421e-01f, -3.20395641e-02f, 3.68153043e-02f, 2.16370195e-01f, 1.16666675e-01f, 3.27486634e-01f, 6.01012707e-02f, -1.01206206e-01f,
  8.61358047e-02f, 3.76605280e-02f, 9.73310098e-02f, -1.87336564e-01f, 1.95004806e-01f, -3.67693836e-03f, -7.32638538e-02f, 7.96300769e-02f, 1.53438285e-01f, 7.82553703e-02f,
  3.21343511e-01f, 2.35752299e-01f, 7.42117614e-02f, 9.78063568e-02f, 1.08222172e-01f, -4.51782763e-01f, 7.93434903e-02f, 8.26977938e-02f, -2.40188584e-01f, 1.50193706e-01f,
  1.19306549e-01f, 1.23721123e-01f, -6.73807636e-02f, 5.20513877e-02f, -1.59288839e-01f, 1.33956403e-01f, -5.26373759e-02f, -1.97353229e-01f, -1.51140630e-01f, -3.25345062e-02f,
  -2.28554860e-01f, 2.87291110e-02f, -3.12581420e-01f, 3.84767264e-01f, 2.54283249e-01f, -1.28280982e-01f, -2.71946639e-01f, -6.58118427e-02f, 1.44559592e-01f, -2.29382768e-01f,
  4.55797799e-02f, -9.24345553e-02f, 2.97974467e-01f, 2.88558174e-02f, -1.56185284e-01f, -3.52592617e-01f, -3.04125905e-01f, -1.04301898e-02f, -2.80974787e-02f, -2.18373954e-01f,
  2.53691733e-01f, 1.00068308e-01f, -1.35684103e-01f, -1.49157777e-01f, -5.05674146e-02f, -1.80058137e-01f, -3.04414868e-01f, 1.21146306e-01f, 6.90358877e-02f, 7.84291551e-02f,
  -7.10634142e-02f, 4.23651904e-01f, 2.36536339e-01f, 2.47633934e-01f, 2.37407446e-01f, 1.75223082e-01f, -1.61239564e-01f, 1.74830958e-01f, -3.36243510e-02f, 2.00832933e-02f,
  1.59202233e-01f, 2.44006976e-01f, -3.99229005e-02f, 4.87613641e-02f, -3.10811818e-01f, 1.30965784e-01f, 3.55226435e-02f, 2.99558401e-01f, 1.29087299e-01f, 2.88176328e-01f,
  7.92129040e-02f, 1.65914789e-01f, 1.35568440e-01f, -8.46241415e-02f, 1.22310385e-01f, 1.77200407e-01f, 1.70829520e-01f, -1.41989039e-02f, 2.31044278e-01f, 1.71807602e-01f,
  2.45351568e-01f, -1.11168131e-01f, 2.66548097e-01f, 2.69196946e-02f, 1.89538393e-02f, 1.30805120e-01f, 4.79764789e-02f, 7.87621066e-02f, -1.42285451e-01f, 3.25325072e-01f,
  2.69013435e-01f, 1.70608982e-02f, -6.52272701e-02f, -4.75514889e-01f, -2.42360458e-01f, 3.55396926e-01f, -9.58779007e-02f, 2.21723661e-01f, -2.31219828e-01f, 1.14210308e-01f,
  -2.55591899e-01f, -5.00269383e-02f, 2.16584966e-01f, -9.48947668e-02f, -4.26290222e-02f, 7.77447894e-02f, -1.17452823e-01f, 6.59724325e-02f, 7.78601617e-02f, -8.76934156e-02f,
  1.64997324e-01f, 2.72103369e-01f, 1.33665398e-01f, 1.40563816e-01f, -4.84108180e-02f, -1.07118353e-01f, 1.22913405e-01f, -1.36429980e-01f, -2.83918958e-02f, 1.62216090e-02f,
  2.13625595e-01f, -5.03491126e-02f, -3.77211496e-02f, -4.84373011e-02f, -5.05311340e-02f, 1.47422716e-01f, -4.78636809e-02f, -1.63170714e-02f, -4.48876806e-02f, 5.87814935e-02f,
  1.26565158e-01f, 1.34825036e-02f, 1.03298277e-02f, -2.23978106e-02f, -5.33282638e-01f, -6.16953745e-02f, -4.76172715e-02f, 9.24589261e-02f, -1.56670734e-01f, 5.53739034e-02f,
  2.07160302e-02f, -7.26151541e-02f, -3.12878817e-01f, 9.63154435e-02f, 1.19036678e-02f, 1.53545499e-01f, -4.68286201e-02f, 1.10722758e-01f, 2.58658051e-01f, -3.79891872e-01f,
  -2.68745810e-01f, -2.22768977e-01f, 6.61561266e-02f, -1.54046297e-01f, -4.86846529e-02f, -1.29361957e-01f, 1.46651804e-01f, 1.02853194e-01f, -3.20488177e-02f, -2.12328099e-02f,
  -4.99896519e-02f, -2.20329463e-01f, -5.65847196e-02f, -5.79624549e-02f, -5.87823801e-02f, -2.72918105e-01f, -3.99990290e-01f, -2.55777836e-02f, -4.70731966e-02f, 1.27353072e-01f,
  -5.91944456e-01f, -2.32887909e-01f, 6.40560687e-02f, -4.10587229e-02f, 1.51869103e-01f, 1.46283776e-01f, -6.48016706e-02f, 1.70218006e-01f, -1.87355801e-01f, 1.67117193e-01f,
  -8.69375318e-02f, -1.45722657e-01f, -1.17404632e-01f, 2.77357578e-01f, -8.99690390e-02f, 3.31626013e-02f, 2.10404560e-01f, -5.60556352e-03f, -1.04528172e-02f, 9.45637375e-03f,
  3.86467925e-03f, 6.70435186e-03f, -2.15240583e-01f, -1.44994101e-02f, -1.27726763e-01f, 6.52686656e-02f, 1.37664601e-01f, 9.48971417e-03f, -3.34406286e-01f, -1.32666931e-01f,
  -1.55614719e-01f, 1.48670986e-01f, -1.79391846e-01f, 1.46233737e-01f, 9.50756595e-02f, -3.69720124e-02f, 2.59818826e-02f, -5.28285503e-02f, 9.65625718e-02f, -8.97039846e-02f,
  -7.34510124e-02f, 2.05853298e-01f, 3.09945457e-02f, -4.89519209e-01f, -1.86002985e-01f, -7.84025192e-02f, 2.23329086e-02f, -2.32980266e-01f, -3.66817191e-02f, -2.57816374e-01f,
  1.84738219e-01f, 2.67879546e-01f, -1.23041190e-01f, -1.78101081e-02f, -2.83789992e-01f, -2.29100615e-01f, -6.91207796e-02f, 3.57272893e-01f, -3.81138846e-02f, -1.11265481e-02f,
  -2.75922924e-01f, -3.25432390e-01f, 3.83464724e-01f, 7.47805312e-02f, -8.54596347e-02f, -2.98761934e-01f, -1.42617330e-01f, 9.65266749e-02f, -8.06455389e-02f, 2.14397460e-01f,
  -6.66138083e-02f, 8.46717209e-02f, -1.12738959e-01f, -1.69927832e-02f, -1.86834797e-01f, -3.06513291e-02f, 7.59350881e-02f, 2.23512530e-01f, 1.80679575e-01f, -1.93965822e-01f,
  6.26442805e-02f, -3.77954450e-03f, -2.08445325e-01f, 2.60331422e-01f, 8.22252110e-02f, 1.84498265e-01f, -9.80708674e-02f, 6.33829013e-02f, -2.02148497e-01f, 2.85524186e-02f,
  -3.65106091e-02f, -3.25282395e-01f, 1.73118878e-02f, -1.91147164e-01f, -4.10607815e-01f, -8.37443769e-02f, -1.12987384e-01f, -1.10470444e-01f, -6.62541986e-02f, -1.75818622e-01f,
  -1.77705258e-01f, 7.99050927e-02f, 3.91179090e-03f, -1.38984844e-01f, 1.02841184e-01f, -1.46221936e-01f, 1.38548717e-01f, 1.68255553e-01f, -3.42125669e-02f, -8.02377984e-02f,
  1.40199766e-01f, 3.64176035e-02f, -2.46893018e-02f, -1.11707926e-01f, 4.48654681e-01f, 4.65743870e-01f, -2.81105727e-01f, 4.81066965e-02f, -1.90026566e-01f, 1.95809260e-01f,
  5.77934921e-01f, -3.85039598e-01f, 2.41571307e-01f, 1.66562662e-01f, 2.20592424e-01f, -3.21465045e-01f, 7.71191791e-02f, 1.03267938e-01f, 2.81033278e-01f, -2.70412534e-01f,
  1.67754874e-01f, -9.29943286e-03f, -2.05153953e-02f, 1.41806096e-01f, 1.97874039e-01f, -2.40306389e-02f, 1.91905275e-01f, 1.09717194e-02f, -1.03703193e-01f, -1.00216597e-01f,
  -1.19186990e-01f, -9.69357491e-02f, -7.48228207e-02f, 2.96366751e-01f, -6.59185722e-02f, 2.72738729e-02f, 2.60773152e-01f, 2.78640598e-01f, 1.22585155e-01f, -1.25144841e-02f,
  1.34608580e-03f, -3.08951773e-02f, 8.84250551e-02f, -1.31317461e-02f, 1.01212919e-01f, -2.66940501e-02f, 1.71470419e-01f, 1.95839271e-01f, -1.82264000e-01f, 1.11899748e-01f,
  6.11898638e-02f, 6.75579906e-02f, -1.17013693e-01f, 6.30473569e-02f, 5.67360297e-02f, 2.06579924e-01f, -4.71050590e-02f, 1.45893738e-01f, 3.62422988e-02f, 1.44710496e-01f,
  2.56757647e-01f, 1.85997188e-01f, -1.65821631e-02f, 3.18325520e-01f, -2.39754375e-02f, -5.01593500e-02f, 3.60861681e-02f, 1.41128242e-01f, 5.50577380e-02f, -1.58594310e-01f,
  1.41693592e-01f, -9.89635438e-02f, 3.08276594e-01f, -2.22644638e-02f, 9.58442390e-02f, -1.08078294e-01f, -3.53118964e-02f, -1.43762618e-01f, 1.11583928e-02f, 3.33383024e-01f,
  -6.50305688e-01f, 1.47846878e-01f, -1.74269840e-01f, 2.44541578e-02f, 2.70102262e-01f, -3.21179628e-01f, -4.35597785e-02f, -1.83065191e-01f, -4.77429368e-02f, 2.02342913e-01f,
  -2.27949888e-01f, -5.56216463e-02f, 3.87612969e-01f, 6.22493820e-03f, 1.12083759e-02f, -2.06893712e-01f, -2.72096574e-01f, 5.20433128e-01f, -1.25786811e-01f, 2.62411714e-01f,
  1.03729337e-01f, -8.86133611e-02f, 4.22604233e-02f, 1.69240721e-02f, 9.24788322e-03f, 7.02123493e-02f, 1.55976012e-01f, 1.21963158e-01f, 2.14380190e-01f, 3.84303004e-01f,
  1.57296881e-01f, 3.65402200e-03f, 2.60676235e-01f, 3.38577092e-01f, 2.43010566e-01f, 1.87050700e-01f, 2.60259122e-01f, -1.28585799e-02f, 2.02126369e-01f, 1.95727065e-01f,
  1.84501931e-01f, -1.03605457e-01f, 6.12207688e-02f, 1.36230737e-01f, 3.47724319e-01f, -7.90627226e-02f, 3.01761001e-01f, -4.31243926e-01f, -2.88235545e-02f, 1.27231613e-01f,
  -4.16252315e-02f, -5.30798435e-02f, 2.52783567e-01f, -1.23224715e-02f, -1.14804909e-01f, -9.97801200e-02f, -4.68994975e-01f, 2.62520552e-01f, 1.85425043e-01f, 3.22137117e-01f,
  2.21508980e-01f, -1.32499531e-01f, 7.66334124e-03f, -6.18933118e-04f, 6.28047585e-02f, 3.21940124e-01f, 3.06799859e-01f, 1.00275286e-01f, 4.16226089e-02f, 2.73734182e-01f,
  3.10420245e-01f, 5.99863008e-02f, 3.05350367e-02f, 3.17211971e-02f, 3.60733867e-02f, -1.04857899e-01f, 1.40368938e-01f, -3.63454282e-01f, -1.27198145e-01f, -7.77414441e-02f,
  -3.41228507e-02f, -1.02078922e-01f, 8.12677070e-02f, 2.14376077e-01f, -9.28975344e-02f, 2.49893561e-01f, 1.71178252e-01f, -2.21498072e-01f, -8.92969072e-02f, 1.67871922e-01f,
  9.66345295e-02f, 1.82120681e-01f, 1.17130958e-01f, 3.86040993e-02f, 1.24558128e-01f, -2.25167368e-02f, 1.00301690e-01f, -5.17798811e-02f, 1.84814721e-01f, 2.52879411e-01f,
  -3.45710702e-02f, -9.89829842e-03f, 1.05180889e-01f, -3.50021175e-03f, -6.58580987e-03f, -3.24915238e-02f, 8.32722262e-02f, 5.35480306e-02f, -5.26733510e-02f, 3.32213521e-01f,
  -2.28070542e-01f, 2.22132564e-01f, 1.48885831e-01f, 1.69645056e-01f, 2.98119187e-01f, 1.86888114e-01f, 1.08211540e-01f, -1.39369130e-01f, -5.37341796e-02f, 8.75505432e-02f,
  1.97514802e-01f, 2.57263362e-01f, 2.08530948e-01f, -1.94594920e-01f, 1.09951966e-01f, 2.54358768e-01f, 3.23360980e-01f, 8.41402411e-02f, 1.89012662e-02f, -1.97240144e-01f,
  -3.82727198e-02f, 1.38884261e-01f, -1.81581471e-02f, 1.65696904e-01f, -2.42547318e-01f, 3.10657591e-01f, 1.36471450e-01f, 3.92508833e-03f, 5.15412539e-02f, -3.84196192e-02f,
  1.80438623e-01f, 2.32357189e-01f, 1.34560809e-01f, -1.04986034e-01f, 1.70072451e-01f, 1.18078016e-01f, -2.81973839e-01f, 3.23765427e-02f, 5.92721775e-02f, 2.45862314e-03f,
  9.31088328e-02f, 2.19405964e-02f, 1.02242760e-01f, 1.00154318e-01f, 1.03553616e-01f, 2.69306023e-02f, -6.53668121e-03f, 7.12317787e-03f, 1.07767768e-01f, 3.77505571e-02f,
  4.30890888e-01f, 2.16167986e-01f, 1.16295576e-01f, 1.62980318e-01f, 1.12980314e-01f, 2.77141899e-01f, 3.78156081e-02f, 1.09655790e-01f, -1.75593346e-01f, 1.53731778e-01f,
  -2.54414350e-01f, -2.25580156e-01f, -7.49444366e-02f, 2.34178007e-01f, 2.53125101e-01f, -6.03993014e-02f, 1.69899404e-01f, 1.45171866e-01f, 8.62378534e-03f, 2.43732184e-01f,
  -3.67729645e-03f, -3.14984739e-01f, -3.51441205e-02f, -1.01561368e-01f, 2.86154389e-01f, 3.65922451e-01f, -2.59369542e-03f, -2.16518536e-01f, 3.18677247e-01f, 2.85425335e-01f,
  2.93117553e-01f, 1.49131835e-01f, -7.75440643e-03f, -3.02451290e-02f, 4.85924184e-01f, 2.21997246e-01f, -1.97148234e-01f, 3.06471378e-01f, 1.43886328e-01f, -8.15910026e-02f,
  2.96850026e-01f, -1.25550970e-01f, 3.88056338e-01f, 2.51933753e-01f, 3.45746905e-01f, 2.12786719e-01f, 3.15410532e-02f, -1.61370412e-01f, 3.06880847e-02f, 1.98181090e-03f,
  -7.96499476e-02f, 2.27177933e-01f, 1.69754736e-02f, -9.08040032e-02f, -1.63288862e-02f, -4.38881256e-02f, -2.79465280e-02f, 8.95709321e-02f, 3.66176032e-02f, 1.43939048e-01f,
  8.76462311e-02f, 4.30064052e-01f, 2.68480122e-01f, 9.59953368e-02f, 3.16753596e-01f, 1.58147439e-01f, 1.44663483e-01f, 1.67559817e-01f, 3.18757415e-01f, 8.34893808e-02f,
  3.96636397e-01f, -1.02161035e-01f, 1.97563484e-01f, 3.51892412e-02f, 1.00237712e-01f, 7.76453391e-02f, 1.71567127e-01f, 1.31342322e-01f, 4.53963667e-01f, -1.39537007e-01f,
  -4.98628430e-02f, 1.60108536e-01f, 8.66028368e-02f, 5.34496121e-02f, -8.62523392e-02f, -1.94384545e-01f, 1.64700486e-02f, 2.66518593e-01f, -3.46213728e-01f, -1.00006133e-01f,
  -1.69104621e-01f, 2.27787122e-01f, 1.60329208e-01f, -1.08548276e-01f, -1.93318725e-01f, 4.60036211e-02f, 2.25633979e-01f, 2.00358763e-01f, -1.90019514e-02f, 5.31217898e-04f,
  -2.63192236e-01f, 2.62394607e-01f, 4.26397473e-01f, -1.17793337e-01f, 2.22305164e-01f, -1.26410499e-01f, 2.17270255e-01f, -4.29049581e-02f, -4.15961593e-02f, -3.26935381e-01f,
  -2.10622922e-02f, -1.51499882e-01f, 2.26498172e-01f, -2.55776703e-01f, 1.50717482e-01f, 1.64591763e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -5.83165847e-02f, 1.59195200e-01f, 8.51139650e-02f, 3.79200503e-02f, -1.44056818e-02f, 1.18916258e-01f, 9.17412937e-02f, 1.10696957e-01f, 1.93095822e-02f, 1.46508873e-01f,
  1.97333425e-01f, 1.71382308e-01f, 2.21170276e-01f, 1.32091060e-01f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  1.21714324e-02f, -6.32998571e-02f, 2.03764603e-01f, -3.98493838e-03f, 1.45054922e-01f, -1.03743754e-01f, 1.90557584e-01f, 1.88485578e-01f, -9.08444673e-02f, 1.01027563e-01f,
  1.31640330e-01f, -1.21483691e-01f, -1.65000051e-01f, 1.31999239e-01f, -4.05516811e-02f, 1.74682692e-01f, -8.18754286e-02f, -8.81875306e-02f, 9.92947072e-02f, -4.65231575e-02f,
  7.20971152e-02f, -1.56727821e-01f, -1.76256612e-01f, -1.55762777e-01f, 1.05688281e-01f, 1.21475644e-02f, 6.90094531e-02f, 1.25040993e-01f, -8.39112401e-02f, 3.62269580e-02f,
  1.06547423e-01f, 1.91539705e-01f, 3.80334817e-02f, -2.37070769e-01f, 8.13755393e-02f, 1.68329135e-01f, 3.01907863e-02f, 1.22656360e-01f, -9.91388410e-02f, 2.26100549e-01f,
  3.18348221e-02f, 6.80177882e-02f, -2.97880203e-01f, -1.11336663e-01f, -7.23025724e-02f, 2.20079571e-01f, -1.61218777e-01f, -1.32236555e-01f, -2.95436889e-01f, 1.98612381e-02f,
  2.13682294e-01f, 1.23436891e-01f, -2.42238060e-01f, 4.93534356e-02f, 8.95571616e-03f, 2.70268098e-02f, -2.55695283e-01f, 6.88216556e-03f, -3.07097018e-01f, -1.95022181e-01f,
  -7.91559219e-02f, 1.54423326e-01f, 8.95223767e-02f, 1.56470805e-01f, -2.53472873e-03f, 1.67135790e-01f, -1.46338847e-02f, -1.48759574e-01f, -1.83228880e-01f, -8.45128372e-02f,
  -2.15183541e-01f, -1.59738734e-01f, 1.19758144e-01f, 1.67313546e-01f, -7.84425661e-02f, 2.76842833e-01f, -8.62730518e-02f, -5.57524860e-02f, 1.33734763e-01f, 1.66730329e-01f,
  4.62111942e-02f, 9.37096551e-02f, -5.76385595e-02f, -1.48135886e-01f, 4.51237187e-02f, 1.31380200e-01f, 1.61739588e-01f, -1.45066604e-01f, 7.13604614e-02f, -3.41905542e-02f,
  1.19857810e-01f, -1.01474017e-01f, 5.25297150e-02f, -4.51112725e-02f, 6.14219066e-03f, 4.10389975e-02f, -1.91584885e-01f, 1.24443956e-01f, -5.73686920e-02f, 2.18840074e-02f,
  1.04594819e-01f, -3.15169901e-01f, -4.52190358e-03f, 4.86806296e-02f, -2.00424101e-02f, -1.56771690e-01f, -2.64415175e-01f, -6.47839829e-02f, -1.84201807e-01f, -3.46722454e-02f,
  7.60319307e-02f, -3.70210618e-01f, -1.24315165e-01f, -7.32467175e-02f, 5.55850081e-02f, -1.62474036e-01f, -8.52653831e-02f, -7.88947567e-02f, 8.60306099e-02f, -6.27806410e-02f,
  -4.25986126e-02f, -4.32859436e-02f, 1.02089591e-01f, 2.83677757e-01f, -9.50641334e-02f, 1.11536071e-01f, 1.04547024e-01f, -1.36248574e-01f, -1.64595321e-02f, 2.91227669e-01f,
  -4.94892560e-02f, -5.10766089e-01f, 1.91729575e-01f, 1.36082554e-02f, -8.45472440e-02f, -1.37361243e-01f, -4.27784063e-02f, 8.01169500e-02f, 1.05145559e-01f, 1.00501746e-01f,
  3.08164954e-02f, 2.07910657e-01f, 1.39952496e-01f, -1.18510544e-01f, 1.80822805e-01f, 1.03081234e-01f, -1.07044794e-01f, -2.70764410e-01f, 4.98774759e-02f, -5.44257052e-02f,
  3.87604386e-02f, -2.29210243e-01f, -4.49671634e-02f, -1.41948789e-01f, -2.38686383e-01f, 4.84985709e-02f, 2.00928733e-01f, -1.05009405e-02f, -3.25835556e-01f, 3.39626595e-02f,
  1.19561013e-02f, 1.89429238e-01f, -1.10512368e-01f, 1.71807304e-01f, 3.45917761e-01f, 1.23163581e-01f, 1.30840540e-01f, 1.74737468e-01f, 6.78944960e-02f, -7.23952875e-02f,
  -1.48032814e-01f, -2.10591674e-01f, -1.11736484e-01f, 5.89869209e-02f, -1.80797577e-01f, -2.92426348e-01f, -1.13945138e-02f, 1.00539245e-01f, 2.26829618e-01f, 3.35646309e-02f,
  -2.65399337e-01f, -6.23552501e-02f, 1.29799992e-01f, 1.10398129e-01f, -1.27753198e-01f, -1.05863921e-01f, -1.11616090e-01f, 8.52184743e-02f, -1.47891715e-01f, 3.90704684e-02f,
  2.04218868e-02f, 3.05769201e-02f, 1.08903065e-01f, 3.86080183e-02f, -6.12351708e-02f, 7.49363080e-02f, -5.18091917e-02f, 1.68110266e-01f, 7.56420344e-02f, -1.27305567e-01f,
  -9.91139114e-02f, 4.49984074e-02f, -9.51090753e-02f, -2.57627554e-02f, 1.92185119e-01f, 2.04211473e-01f, -5.08505367e-02f, 2.46276572e-01f, -5.26131410e-03f, 2.53748894e-01f,
  -4.20919210e-02f, 4.39164378e-02f, -1.10645056e-01f, 1.00307547e-01f, 2.53543817e-02f, 7.17211589e-02f, 9.91184860e-02f, 4.58377838e-01f, 1.16811447e-01f, 1.34010822e-01f,
  3.63756903e-02f, -1.41908005e-01f, -7.62551203e-02f, -1.33516431e-01f, -2.08506480e-01f, -3.21456879e-01f, -1.30606562e-01f, -1.29862577e-01f, -2.70370334e-01f, -7.56448582e-02f,
  -1.11093260e-01f, 3.40606496e-02f, 1.91034004e-01f, -1.48640245e-01f, 2.45633438e-01f, 6.76209629e-02f, 1.39135376e-01f, -1.14395671e-01f, 2.16422394e-01f, 1.57975644e-01f,
  2.43150458e-01f, 1.31261021e-01f, 1.11248545e-01f, 1.59691751e-01f, 1.65911883e-01f, 5.89622464e-03f, -1.43178683e-02f, -4.23388183e-02f, 2.81593144e-01f, -8.64612460e-02f,
  -1.03579439e-01f, 1.98247984e-01f, 8.65011662e-02f, -1.61446184e-01f, -2.08648205e-01f, -1.21406000e-02f, 4.90691103e-02f, 7.04654381e-02f, 6.46266341e-02f, -2.21580163e-01f,
  -1.62883401e-02f, 2.21468523e-01f, 8.22539069e-03f, -1.10135578e-01f, -6.64981781e-03f, -1.87206224e-01f, 1.77476704e-01f, -2.39152804e-01f, -1.42664865e-01f, -3.77840638e-01f,
  -2.28141636e-01f, -5.56516759e-02f, -7.09573328e-02f, 6.71730116e-02f, 1.38499020e-02f, 5.78051247e-02f, 1.93975806e-01f, -1.65328264e-01f, -1.14550881e-01f, -1.09498970e-01f,
  -6.87540472e-02f, 1.67413846e-01f, -1.17088236e-01f, 7.03602955e-02f, -2.50432014e-01f, -2.40020320e-01f, 2.49028116e-01f, -6.41590953e-02f, 2.50699162e-01f, 3.39447647e-01f,
  -2.54759908e-01f, -3.16219814e-02f, -9.58158970e-02f, -2.71810051e-02f, -3.40231657e-02f, 2.99107172e-02f, 8.43403116e-02f, 1.31182924e-01f, 1.91599399e-01f, 9.07578096e-02f,
  1.40684441e-01f, 6.75778389e-02f, 5.83298542e-02f, -1.08986638e-01f, -9.91785079e-02f, -2.03491673e-02f, -2.34572694e-01f, -7.16953585e-03f, -1.71395332e-01f, 1.10851288e-01f,
  -2.03554571e-01f, -1.28580421e-01f, 1.71388000e-01f, 2.00356856e-01f, 1.72346011e-01f, -3.70295763e-01f, -1.34410366e-01f, -2.66814474e-02f, -1.65446252e-01f, 3.60802338e-02f,
  9.98525247e-02f, 1.75567828e-02f, -2.75030911e-01f, -3.11470807e-01f, -8.94510970e-02f, -1.66942924e-01f, -1.11427180e-01f, 1.14063755e-01f, -1.50650308e-01f, 1.19677208e-01f,
  -3.46817896e-02f, 1.48243889e-01f, -1.14497937e-01f, 7.05331191e-02f, -6.56871311e-03f, -1.54190198e-01f, 5.01389243e-02f, 2.55242512e-02f, -6.94642514e-02f, -2.11655647e-01f,
  1.52875530e-02f, -3.98520008e-02f, -8.68406147e-02f, -4.30054218e-02f, -2.73109466e-01f, -1.00168519e-01f, -1.84544161e-01f, 1.21480420e-01f, 6.71368092e-02f, -2.33839154e-02f,
  4.25793454e-02f, 1.07492462e-01f, 3.27191129e-02f, 3.56442660e-01f, 8.31662938e-02f, -1.59205690e-01f, 2.90322065e-01f, 3.47601958e-02f, -1.13315687e-01f, 2.35119432e-01f,
  3.01071778e-02f, 9.72398445e-02f, -3.04211468e-01f, -1.70656770e-01f, -4.81660143e-02f, -3.22142020e-02f, -1.59328386e-01f, -2.03826278e-01f, -2.85284638e-01f, 1.41843438e-01f,
  1.02807313e-01f, -5.95211936e-03f, -3.14020127e-01f, -6.93953931e-02f, -2.09622588e-02f, -1.78108439e-01f, -1.69239268e-01f, -9.43992138e-02f, 2.39435062e-02f, -1.68940768e-01f,
  -2.53672730e-02f, 1.03030257e-01f, 1.52349696e-01f, 8.13351050e-02f, -7.55035952e-02f, -7.90812373e-02f, -1.89651595e-03f, -1.56377733e-01f, 8.43874514e-02f, -8.30379352e-02f,
  -1.67607784e-01f, -4.08839844e-02f, -6.01965189e-03f, -1.61677346e-01f, -7.71857873e-02f, -2.06541866e-01f, -1.01262890e-01f, -8.03190023e-02f, -1.93461612e-01f, -2.20272839e-01f,
  7.22723305e-02f, -1.54979199e-01f, 8.41186754e-03f, -1.41156584e-01f, 1.32896192e-02f, 3.45664769e-02f, 1.61663100e-01f, -5.98395132e-02f, 5.74286208e-02f, 2.27863520e-01f,
  -3.45775038e-02f, -9.39379632e-02f, -2.81832099e-01f, -5.15454672e-02f, -5.95620275e-02f, 1.66769207e-01f, 1.37754455e-01f, -1.27305195e-01f, 1.96768194e-01f, 1.81351155e-01f,
  -2.89191544e-01f, -1.00949012e-01f, -2.54851192e-01f, 5.41198701e-02f, 8.25021300e-04f, 1.16364926e-01f, 2.63713866e-01f, -1.65550798e-01f, -1.13235451e-01f, 3.32684219e-02f,
  -1.09837331e-01f, 8.97392854e-02f, -3.66650485e-02f, -8.40196311e-02f, 5.58519885e-02f, -1.28904879e-01f, -2.65598804e-01f, 5.68634197e-02f, -8.67428817e-03f, 2.61630323e-02f,
  -1.45092279e-01f, 1.47562221e-01f, -2.11136654e-01f, -1.57563761e-01f, 2.05416366e-01f, -2.92379819e-02f, 6.51635006e-02f, 9.42915604e-02f, 2.61660635e-01f, -2.47524772e-02f,
  2.00380966e-01f, -3.52416843e-01f, -1.53256506e-02f, 9.74555127e-03f, 2.67884791e-01f, 3.04336403e-03f, -2.06857082e-02f, -1.12206154e-01f, 5.72689213e-02f, 1.18157670e-01f,
  -5.03925188e-03f, 1.33836269e-01f, 6.83774129e-02f, -5.37590347e-02f, -1.81237489e-01f, 1.37399081e-02f, 4.97623272e-02f, 1.15673430e-01f, 2.33764723e-01f, 1.84991628e-01f,
  1.68930367e-01f, 1.21402852e-01f, 1.94721937e-01f, 3.88046324e-01f, 1.11945167e-01f, -1.03742797e-02f, 7.31091425e-02f, -1.00919202e-01f, 3.69390845e-02f, 3.19527745e-01f,
  -1.76392466e-01f, -3.90551567e-01f, -2.52452828e-02f, 3.59385312e-02f, -2.20257905e-03f, -1.70609072e-01f, 2.61043072e-01f, -1.02175027e-03f, -3.66710015e-02f, -3.28851081e-02f,
  -4.98774834e-02f, -1.89616248e-01f, -1.75652161e-01f, 1.62664577e-01f, -9.12214443e-02f, -2.71353811e-01f, -1.72279626e-01f, 8.44049901e-02f, 1.27514705e-01f, -8.15935433e-02f,
  -1.46099970e-01f, -4.55832295e-03f, -1.53486893e-01f, 1.47572443e-01f, -2.31072083e-02f, -2.70376746e-02f, 7.17384145e-02f, 2.04832889e-02f, 3.25703025e-02f, 1.89892694e-01f,
  -7.03174025e-02f, 2.91015916e-02f, 2.18568042e-01f, 2.83367354e-02f, -5.58594018e-02f, -2.58267730e-01f, 1.48622274e-01f, -1.92606211e-01f, -9.57518257e-03f, 7.77994767e-02f,
  -3.38308215e-01f, -1.96987972e-01f, -1.04437076e-01f, -2.45368630e-01f, 5.63177094e-02f, 3.14260018e-03f, -8.85798559e-02f, -1.60097122e-01f, 6.06205687e-02f, -1.54114775e-02f,
  -4.55296896e-02f, -2.03792334e-01f, 1.09469771e-01f, -2.02233329e-01f, 2.49637142e-01f, 6.14394955e-02f, 5.56748621e-02f, 3.04394290e-02f, -6.91173365e-03f, -7.58465752e-02f,
  -2.32794732e-01f, -2.85609692e-01f, -1.29818946e-01f, 1.48517126e-02f, 5.95265850e-02f, -1.03411414e-01f, 1.65995762e-01f, -4.78120334e-02f, 2.55713630e-02f, 1.98805958e-01f,
  4.66698110e-02f, 1.30600408e-01f, -1.70941681e-01f, 1.98041931e-01f, 1.07322730e-01f, -8.10105577e-02f, -2.15132341e-01f, 2.85025989e-03f, -1.68288663e-01f, 1.29374176e-01f,
  -2.39878848e-01f, -2.47412950e-01f, 6.06615469e-02f, -4.20459695e-02f, -1.35524333e-01f, 1.32048666e-01f, -1.14857174e-01f, 1.52196720e-01f, -7.56766424e-02f, 8.23944733e-02f,
  -1.81684434e-01f, -1.56772688e-01f, 2.50541657e-01f, -6.33191504e-03f, 6.81613237e-02f, 2.34211504e-01f, 4.46911082e-02f, -1.23288454e-02f, 6.28341660e-02f, 1.57577097e-02f,
  -9.06787291e-02f, 1.80461764e-01f, 1.17189802e-01f, -1.44187704e-01f, 4.04695362e-01f, 1.32023945e-01f, 2.46187970e-02f, 7.54391402e-02f, 2.80808002e-01f, 9.06139705e-03f,
  3.03988874e-01f, 1.09149799e-01f, -1.14156820e-01f, 9.56208631e-02f, 1.24509692e-01f, 2.95051374e-02f, -3.88232842e-02f, 1.81760881e-02f, -1.08665666e-02f, 1.56838059e-01f,
  -1.57097373e-02f, 3.69972587e-02f, 4.23178673e-02f, 2.27110639e-01f, 3.86818379e-01f, 1.97247833e-01f, 4.29995842e-02f, -6.07027560e-02f, 3.58522683e-02f, 1.35484874e-01f,
  -1.41765922e-01f, 1.43395901e-01f, -1.12170756e-01f, 1.14509642e-01f, 5.63440248e-02f, -2.10793093e-01f, 8.75255913e-02f, -2.36672144e-02f, 4.24372964e-02f, 2.04378441e-01f,
  1.66945994e-01f, 5.11287190e-02f, -3.96125168e-01f, 7.07211196e-02f, -1.19685434e-01f, 2.34805420e-01f, -2.35982791e-01f, -9.34093669e-02f, 1.64318293e-01f, -7.57359490e-02f,
  1.32729486e-01f, 5.71585782e-02f, -8.72017071e-03f, -2.33400334e-02f, -7.34914653e-03f, 1.43848760e-02f, -2.04406708e-01f, -2.94376183e-02f, -2.59223521e-01f, -6.85744509e-02f,
  -3.80190164e-02f, -1.30774736e-01f, 4.03078087e-02f, 5.45850322e-02f, -2.66419388e-02f, -6.97547793e-02f, -6.91886544e-02f, 1.01450384e-01f, -2.13129609e-03f, 1.93566680e-01f,
  1.67446747e-01f, 1.28287122e-01f, -1.06792592e-01f, -1.05089784e-01f, 1.18441910e-01f, 1.27889857e-01f, 4.40991707e-02f, 4.98366468e-02f, -8.38122964e-02f, 8.50406811e-02f,
  6.93913996e-02f, 3.72445099e-02f, -5.39430603e-02f, -1.33844227e-01f, 1.22830488e-01f, 1.95071071e-01f, 2.25361958e-01f, 2.86925454e-02f, -2.03971239e-03f, -2.19293952e-01f,
  -7.11553246e-02f, 3.62815470e-01f, 3.51333879e-02f, -2.28020594e-01f, -1.24069691e-01f, -1.18162706e-02f, -1.08200394e-01f, -4.11166362e-02f, 2.21641317e-01f, 3.48344207e-01f,
  -8.20087492e-02f, -7.46034756e-02f, -2.56003112e-01f, -1.14230588e-01f, 3.27320248e-02f, -5.26688509e-02f, -1.14910871e-01f, -3.10825314e-02f, -6.62972778e-02f, 1.30717248e-01f,
  2.14878529e-01f, 1.10307775e-01f, -1.35269225e-01f, -1.74689770e-01f, 1.95249066e-01f, 2.26745903e-02f, -7.76334181e-02f, 8.80166367e-02f, -7.71828890e-02f, -6.18273951e-02f,
  -1.48868635e-02f, 2.73346186e-01f, 2.15330161e-02f, -5.91947585e-02f, 3.31894644e-02f, -2.28808939e-01f, -1.83316320e-01f, -1.72039077e-01f, -1.12410814e-01f, 1.16078667e-01f,
  -2.25309238e-01f, -1.54239655e-01f, -6.13503866e-02f, -8.19394737e-02f, -1.65802151e-01f, -1.51653811e-01f, -5.61547428e-02f, -1.90648258e-01f, -1.06195077e-01f, 8.09373707e-02f,
  5.31613640e-02f, 2.39934120e-03f, -5.55659011e-02f, -5.92379048e-02f, -1.39115959e-01f, 9.24274474e-02f, 1.60396740e-01f, 5.28571382e-02f, -1.11226998e-01f, 2.19843224e-01f,
  3.73904198e-01f, 2.03776628e-01f, -2.66088456e-01f, -1.88461691e-01f, -4.42422740e-02f, 2.03355312e-01f, 4.19900455e-02f, 3.90703417e-02f, -1.89160481e-01f, -2.66307682e-01f,
  -8.94995183e-02f, -8.86334255e-02f, 2.56431818e-01f, 9.96718258e-02f, -2.06936058e-02f, -3.17994393e-02f, -1.08515427e-01f, 2.72028781e-02f, 2.47454643e-01f, -2.90627897e-01f,
  2.09959254e-01f, 1.72295526e-01f, -1.07044727e-01f, 9.59842205e-02f, -3.91772799e-02f, -1.43124014e-01f, -2.00238526e-02f, -1.48914590e-01f, 8.86970907e-02f, 1.32253289e-01f,
  1.58095390e-01f, 3.88764553e-02f, 2.73375958e-01f, 4.18351442e-02f, 1.69638041e-02f, -4.46016602e-02f, -1.15299843e-01f, -1.57672226e-01f, 1.95754573e-01f, 4.97557148e-02f,
  -1.34951070e-01f, -2.39785075e-01f, -1.32414669e-01f, 2.59577274e-01f, 1.90665767e-01f, -2.34218791e-01f, -6.87038079e-02f, -2.31942814e-02f, 7.18189403e-03f, -1.12831056e-01f,
  -1.49587631e-01f, -2.10841164e-01f, -1.51216000e-01f, -1.02646969e-01f, -2.11985037e-01f, -8.46144632e-02f, -9.59799662e-02f, -1.19599953e-01f, -2.59701777e-02f, 1.05326474e-01f,
  -1.60430893e-02f, 1.08218737e-01f, 1.06423914e-01f, 3.55085701e-01f, 1.57626495e-01f, 1.07403211e-01f, -1.73253104e-01f, -7.27190822e-02f, 1.55054733e-01f, 3.41156095e-01f,
  1.35687590e-01f, -2.85274297e-01f, 4.01591286e-02f, 5.23844808e-02f, -6.10558055e-02f, -3.18408338e-03f, -2.54379269e-02f, 7.33289272e-02f, 9.00437236e-02f, -6.96420521e-02f,
  3.32747251e-01f, -1.94913015e-01f, 1.67182505e-01f, -1.10632246e-02f, -2.18075871e-01f, 9.06031132e-02f, -1.84292346e-01f, 1.79001108e-01f, 1.76283326e-02f, -1.13807909e-01f,
  -1.53972611e-01f, -1.03033774e-01f, -2.31172517e-01f, -5.58597371e-02f, -1.51584037e-02f, 1.75826401e-01f, 1.37478849e-02f, 6.42351732e-02f, 1.41093060e-02f, -1.31744165e-02f,
  -1.32348597e-01f, 9.57074314e-02f, 5.49003389e-03f, 2.35983171e-02f, -1.41166106e-01f, 7.09355101e-02f, -4.21541072e-02f, -6.43505082e-02f, 7.49990940e-02f, 3.27246487e-02f,
  -1.43303007e-01f, -4.85303858e-03f, -3.18919532e-02f, -3.19367379e-01f, 8.11429694e-02f, -1.09627275e-02f, -6.96138963e-02f, -1.51734114e-01f, -3.38035747e-02f, -2.19647530e-02f,
  -1.89324678e-03f, -1.32196486e-01f, 9.27155837e-02f, -3.87525298e-02f, -3.49880359e-03f, 1.35807544e-01f, -4.40876074e-02f, 2.00110991e-02f, 5.26440851e-02f, 7.68017843e-02f,
  1.19729647e-02f, -1.28194198e-01f, 1.78136393e-01f, 9.11236480e-02f, -6.34023920e-02f, -1.71220958e-01f, 1.15426213e-01f, 3.36207747e-02f, -1.71614632e-01f, 1.27725065e-01f,
  -5.55118322e-02f, -1.55536234e-01f, -2.78100550e-01f, 9.56353173e-02f, 1.88277647e-01f, -1.47340178e-01f, -2.39465773e-01f, 2.43782982e-01f, 1.05508987e-03f, 3.72315884e-01f,
  -2.41335377e-01f, -1.80022478e-01f, -6.75221160e-02f, 1.53780216e-02f, -2.76002642e-02f, -1.47110615e-02f, -1.17583372e-01f, 6.48331046e-02f, 9.01542138e-03f, -1.01913609e-01f,
  -2.40889080e-02f, -2.74580598e-01f, 2.05131292e-01f, -2.07261264e-01f, -5.27982190e-02f, 2.13382423e-01f, -3.20780501e-02f, 9.19057727e-02f, -4.53820303e-02f, 2.53089845e-01f,
  -1.59910053e-01f, 1.56951725e-01f, -6.50422797e-02f, -7.73345605e-02f, 6.78946543e-03f, 1.28153145e-01f, -7.68442973e-02f, 2.71343797e-01f, 2.49726564e-01f, 2.44047686e-01f,
  1.43833488e-01f, -1.08881280e-01f, 2.65839696e-02f, -1.31952628e-01f, 1.58731684e-01f, 1.47658974e-01f, 4.06953432e-02f, 3.68896909e-02f, 5.77731989e-02f, 3.57945800e-01f,
  3.98042262e-01f, 6.11122511e-02f, 1.59472734e-01f, 6.54932410e-02f, 9.77746770e-02f, -5.28548285e-03f, 1.22207582e-01f, 3.49104613e-01f, -1.47470161e-02f, -1.18772142e-01f,
  5.36940284e-02f, 1.76359341e-02f, 1.08122803e-01f, 9.72085521e-02f, 9.03846473e-02f, 1.60517558e-01f, -2.61513352e-01f, -2.90975702e-04f, -2.55515456e-01f, 8.66701901e-02f,
  2.56488402e-03f, 1.63194254e-01f, 1.32506331e-02f, -2.85872519e-01f, 3.36176679e-02f, 2.69193560e-01f, 6.58801645e-02f, -1.86805144e-01f, 1.75853729e-01f, -4.59765829e-02f,
  3.64571139e-02f, 8.29492211e-02f, -2.33257189e-02f, 2.66666096e-02f, 9.90523398e-03f, 1.31611273e-01f, 1.24437988e-01f, -4.60172743e-02f, -1.46717563e-01f, 1.02461465e-01f,
  -1.64538473e-01f, 2.33574552e-04f, 2.19125509e-01f, 2.49817073e-01f, -5.61589636e-02f, 1.47112822e-02f, -1.97815865e-01f, -8.57801735e-02f, -6.52304366e-02f, 4.32064682e-02f,
  1.23874396e-02f, 1.89514048e-02f, 2.14588586e-02f, 7.83526599e-02f, -2.60738820e-01f, 2.76978761e-01f, -1.11798264e-01f, -6.67143613e-02f, -1.46532118e-01f, 3.28451723e-01f,
  8.27157497e-02f, 2.08581343e-01f, -1.43743172e-01f, -2.96172742e-02f, 1.64139315e-01f, 6.61465451e-02f, 7.84220248e-02f, -5.97941056e-02f, -5.09172045e-02f, -5.97898383e-03f,
  1.64108813e-01f, -3.14324163e-02f, 4.00918946e-02f, -3.58047664e-01f, 1.41074527e-02f, -8.07909518e-02f, -3.21269155e-01f, -6.15753829e-02f, -1.96709976e-01f, -4.74335440e-02f,
  -1.85733482e-01f, 9.87637937e-02f, 3.34996879e-01f, 8.56698230e-02f, 1.23050988e-01f, 2.00161994e-01f, 3.77182484e-01f, 3.40082288e-01f, 3.72672021e-01f, -1.94851160e-01f,
  -3.21650133e-03f, -1.14392109e-01f, 1.53014734e-01f, 5.27796298e-02f, -2.28936821e-01f, -8.68927240e-02f, 3.03896308e-01f, -6.70470074e-02f, -3.28116864e-02f, 1.11394882e-01f,
  1.03116624e-01f, -2.37793222e-01f, -1.79835677e-01f, -1.39438454e-02f, 3.85657959e-02f, 2.16965765e-01f, 2.09342048e-01f, -2.04685047e-01f, 1.01260059e-01f, 6.41635358e-02f,
  -1.13688976e-01f, -8.01547915e-02f, 2.81762689e-01f, 8.46786797e-02f, 1.44022599e-01f, 2.37745047e-02f, -4.02565263e-02f, 2.68380851e-01f, 1.15026079e-01f, -1.05508976e-01f,
  1.11728676e-01f, -7.38037154e-02f, -2.91534979e-02f, -1.19632743e-01f, 1.90316126e-01f, 5.14765568e-02f, 5.63001074e-02f, -2.69147586e-02f, 1.63343549e-01f, -2.41479248e-01f,
  -3.99580359e-01f, -1.43020079e-01f, 1.51226491e-01f, 2.16919497e-01f, 5.43956086e-03f, -2.08927393e-01f, 1.40508160e-01f, 1.06917739e-01f, 4.69075851e-02f, 1.13355190e-01f,
  9.84382182e-02f, 1.44453198e-01f, 8.35974887e-03f, -1.58840939e-01f, 1.84077203e-01f, 1.11352980e-01f, 4.40066680e-02f, 1.75210625e-01f, 6.28061891e-02f, 2.05889553e-01f,
  -1.73779309e-01f, 7.43332133e-02f, 2.77638346e-01f, -2.31141105e-01f, -4.86487057e-03f, 7.27450401e-02f, 1.55957341e-01f, 1.78132877e-02f, -1.30106851e-01f, -5.90028279e-02f,
  4.78095710e-02f, -1.77764744e-02f, -2.66848058e-01f, 4.11786400e-02f, -1.13176525e-01f, -1.54164657e-01f, 1.37133515e-02f, -3.99653018e-02f, 5.17280102e-02f, -1.06973253e-01f,
  -7.14904889e-02f, 1.54237345e-01f, -1.83953866e-01f, -1.16681103e-02f, -8.29739049e-02f, 5.31436205e-02f, -7.46810064e-02f, 1.00282699e-01f, 1.88838914e-02f, -2.97497325e-02f,
  -2.32215136e-01f, -3.08122128e-01f, 7.37378448e-02f, 9.19517130e-02f, 9.95215178e-02f, 3.77895236e-02f, -1.29379928e-01f, -2.08808452e-01f, -1.67437345e-01f, 1.43492250e-02f,
  4.38741036e-02f, -2.46373340e-01f, -1.83485582e-01f, -1.90340608e-01f, 1.21932469e-01f, 1.41840965e-01f, 9.99189690e-02f, 2.20302064e-02f, 6.69682175e-02f, -3.28175902e-01f,
  3.21500808e-01f, 2.42125139e-01f, 6.40249327e-02f, -2.04471834e-02f, -1.72450706e-01f, 4.56021987e-02f, -1.05156131e-01f, -3.21193278e-01f, 1.74996350e-02f, -2.11186148e-02f,
  2.22153291e-01f, 7.47333467e-02f, 1.82512596e-01f, -4.69291136e-02f, -1.00422204e-01f, 2.85334736e-01f, -9.05101188e-03f, -3.57123017e-02f, -2.41731644e-01f, 1.19742572e-01f,
  -3.20031587e-03f, -1.73056930e-01f, 6.97541460e-02f, -1.73458263e-01f, 3.01492158e-02f, 1.03532128e-01f, 1.67097986e-01f, -6.61436021e-02f, 4.22647670e-02f, 3.56997852e-03f,
  -6.21597953e-02f, -6.61514848e-02f, 1.53103277e-01f, -4.33872268e-02f, -3.13402265e-01f, 9.51640531e-02f, -7.59622874e-03f, 3.41875188e-04f, -8.72243643e-02f, 7.51950294e-02f,
  -2.63356209e-01f, 1.08152619e-02f, 2.30287444e-02f, -1.19318753e-01f, 2.01807901e-01f, 2.53769923e-02f, -9.24457014e-02f, -1.52493328e-01f, -1.29675120e-02f, 1.46791846e-01f,
  1.51074171e-01f, -1.65369481e-01f, -2.27466032e-01f, 7.44810626e-02f, 1.76993772e-01f, -5.89085072e-02f, -9.09203738e-02f, -2.02007636e-01f, -1.62634403e-02f, 1.35116011e-01f,
  1.46305924e-02f, -7.58704543e-02f, -1.32127553e-01f, 1.41530400e-02f, -1.66959569e-01f, 1.30250193e-02f, 3.14092904e-01f, 1.00899860e-01f, -9.14987177e-02f, 2.31179193e-01f,
  -3.20229083e-01f, 1.80580571e-01f, -3.14872235e-01f, -2.46957675e-01f, -2.29642406e-01f, -1.60603195e-01f, 2.95688603e-02f, -1.94007367e-01f, 3.58666643e-03f, 3.26218933e-01f,
  -1.66972861e-01f, 1.03772812e-01f, -6.08662926e-02f, -1.56324312e-01f, 1.64281160e-01f, -8.63205548e-03f, -7.76614547e-02f, -2.62524895e-02f, -2.10823745e-01f, -1.49537042e-01f,
  -2.68690467e-01f, 1.65223077e-01f, 1.60434246e-01f, -2.97221214e-01f, 1.12894483e-01f, 1.36844859e-01f, -1.14438765e-01f, 1.51581122e-02f, 5.76529540e-02f, 6.66674748e-02f,
  -2.44659837e-02f, -1.18329898e-01f, -6.60085231e-02f, 1.35150045e-01f, -2.96640862e-03f, 1.47394583e-01f, -9.49080139e-02f, 2.24763885e-01f, 2.67953444e-02f, 4.95847538e-02f,
  -6.90404698e-02f, -1.81242883e-01f, -3.22974287e-02f, -9.98832434e-02f, 6.60263002e-02f, -1.14690587e-01f, -4.91183251e-02f, 3.35110873e-02f, 2.89077252e-01f, -9.76234488e-03f,
  -4.23848256e-02f, 2.55972832e-01f, 1.90420538e-01f, -5.05555943e-02f, -2.36153677e-01f, 1.44608587e-01f, 4.67468873e-02f, 7.23025277e-02f, 5.65077886e-02f, -6.31949529e-02f,
  3.58070731e-01f, 1.47606447e-01f, -2.52268851e-01f, -3.42028439e-01f, -2.87689090e-01f, 9.56000537e-02f, -2.26109594e-01f, -1.22510836e-01f, -1.08368941e-01f, -2.24504769e-01f,
  -9.73075256e-02f, -9.46013816e-03f, -8.62923115e-02f, -1.69405788e-01f, -2.27305591e-02f, -2.58992016e-01f, 1.83064520e-01f, 1.63955927e-01f, 3.83905164e-04f, -5.91864958e-02f,
  8.06585029e-02f, 1.51924998e-01f, -1.09043159e-01f, 9.72340778e-02f, -2.97186792e-01f, -1.26122609e-01f, 1.22144617e-01f, 2.14041770e-02f, 2.28509247e-01f, 1.47451255e-02f,
  -3.26527841e-02f, -2.48659849e-02f, 1.47377327e-01f, -2.89062280e-02f, 5.44425566e-03f, 2.33761683e-01f, -1.66299678e-02f, -1.18757822e-01f, 4.07199115e-02f, -3.83224972e-02f,
  -6.79318383e-02f, -2.89658427e-01f, -4.63759862e-02f, -2.53946245e-01f, 2.46446654e-02f, -1.05689913e-01f, -1.58615522e-02f, 1.60864338e-01f, -8.04485679e-02f, -1.35330305e-01f,
  -1.92708462e-01f, 1.16000578e-01f, -2.77216733e-01f, -9.57349986e-02f, -1.68960337e-02f, -8.03986192e-02f, -1.41237527e-01f, -1.91766080e-02f, -2.10333951e-02f, 7.25405961e-02f,
  2.02236310e-01f, -2.77634442e-01f, 3.15035850e-01f, 1.78790614e-01f, -5.72792254e-02f, 2.62210052e-02f, -9.30011198e-02f, 1.06182575e-01f, -2.54106522e-01f, -6.20727278e-02f,
  2.23350987e-01f, 1.48949444e-01f, 2.59042710e-01f, 1.22621171e-01f, 8.09679180e-02f, -5.03235310e-02f, 2.00308084e-01f, 9.03826654e-02f, 1.06670201e-01f, 1.09458491e-02f,
  -1.49914861e-01f, 1.01532653e-01f, -2.42103562e-02f, 8.16808194e-02f, 3.08744628e-02f, -2.63213873e-01f, 1.57498062e-01f, 9.33817029e-02f, -9.49317515e-02f, -1.52334487e-02f,
  2.40359176e-02f, -1.77323624e-01f, 2.99360808e-02f, -1.22896321e-02f, 4.08210494e-02f, 2.53808759e-02f, 1.91965863e-01f, 4.42929156e-02f, 2.86723971e-02f, -7.55485892e-02f,
  2.20421441e-02f, -5.67560010e-02f, 3.76311690e-02f, -2.39999723e-02f, 1.22524589e-01f, 2.42125317e-01f, -5.42943552e-03f, 8.13765079e-02f, 9.76700336e-02f, 2.71210402e-01f,
  2.01535989e-02f, -2.08835490e-02f, -5.18226549e-02f, 4.00821194e-02f, -2.39362881e-01f, 7.96959549e-02f, -5.39565757e-02f, 1.15475021e-01f, -1.02769993e-02f, 2.47228295e-02f,
  1.66891307e-01f, -2.17431057e-02f, -1.23052187e-01f, 5.71353510e-02f, -1.46705180e-01f, 6.54427847e-03f, -1.52049780e-01f, -1.08793616e-01f, -5.46849854e-02f, -2.40770578e-01f,
  -1.29363358e-01f, -1.11704566e-01f, -1.06254490e-02f, 1.07149243e-01f, 1.17956743e-01f, -2.61997849e-01f, -1.67906702e-01f, 1.41183048e-01f, 2.07518548e-01f, -2.32340157e-01f,
  1.73500627e-01f, -2.31051445e-01f, 2.32916206e-01f, 1.79791078e-01f, 4.38954681e-02f, -3.88164073e-02f, 7.02664629e-02f, -7.15734586e-02f, -2.36767028e-02f, -1.06124535e-01f,
  4.86031882e-02f, -7.51420017e-03f, -1.57708853e-01f, 2.08417833e-01f, -1.68650597e-01f, -8.91477466e-02f, 2.64289556e-03f, -1.84047535e-01f, 1.07401349e-01f, -1.24574408e-01f,
  9.26651135e-02f, -1.90052420e-01f, -5.47501557e-02f, -1.00675248e-01f, 1.15995347e-01f, 1.75743833e-01f, -1.89714313e-01f, -6.78740591e-02f, -1.11905210e-01f, 4.51310799e-02f,
  -1.98841050e-01f, -5.99207506e-02f, -1.59281984e-01f, 1.86928421e-01f, -3.36309075e-02f, -2.57766228e-02f, -1.26960143e-01f, -7.22239166e-02f, 6.15546294e-02f, 8.97922292e-02f,
  -2.31695130e-01f, -7.44561777e-02f, -1.73559099e-01f, 2.04809695e-01f, 8.54502246e-02f, 1.71449974e-01f, -2.37138167e-01f, -1.83211967e-01f, -1.91940799e-01f, 2.09890585e-02f,
  -3.09118629e-01f, -3.50749008e-02f, -2.24172547e-01f, -1.73608854e-01f, 4.64528799e-02f, -3.60295117e-01f, 1.14901423e-01f, 1.78977162e-01f, 9.34361741e-02f, -1.91683814e-01f,
  -2.10734874e-01f, 6.10573925e-02f, 4.41937633e-02f, -3.11230123e-01f, 3.70505780e-01f, -6.24641143e-02f, 2.16257185e-01f, 1.69305533e-01f, 1.16985351e-01f, 5.55930473e-02f,
  3.72403823e-02f, -5.09399213e-02f, -4.08068858e-02f, -4.20493409e-02f, 1.11032948e-01f, -2.18281567e-01f, 1.50619254e-01f, 5.25668636e-02f, 3.51971132e-03f, 6.69053122e-02f,
  9.25569981e-02f, -8.06663036e-02f, 2.29055122e-01f, -5.07381633e-02f, 2.07425077e-02f, -4.00235020e-02f, -1.15562171e-01f, 2.13256359e-01f, 2.44164661e-01f, 4.67339680e-02f,
  1.39620930e-01f, -7.26566315e-02f, -2.74400711e-01f, 7.75237158e-02f, 7.49689341e-02f, 1.54175386e-01f, 4.76405993e-02f, 6.74319826e-03f, -6.49334416e-02f, -8.35758001e-02f,
  -5.67679144e-02f, 3.05705704e-02f, 1.32937104e-01f, 2.96992600e-01f, -1.55564800e-01f, 2.22622424e-01f, 2.43704543e-02f, 1.70652702e-01f, 1.81343883e-01f, 9.24403667e-02f,
  4.59758230e-02f, 1.96677938e-01f, -5.72066158e-02f, 2.28637993e-01f, -1.87944889e-01f, -6.42837361e-02f, -3.40163797e-01f, -1.66628312e-03f, 1.17656305e-01f, -2.58216739e-01f,
  1.69379234e-01f, -1.27956364e-02f, 1.16741598e-01f, -1.17138907e-01f, -1.81190491e-01f, -6.95807785e-02f, -1.63189545e-01f, -6.61417618e-02f, -3.26693982e-01f, -1.59971386e-01f,
  -4.08441931e-01f, 1.42367721e-01f, 1.04138464e-01f, -1.24273255e-01f, 8.74388739e-02f, -9.56269652e-02f, -9.89621971e-03f, 2.52364278e-01f, 1.86643898e-01f, -5.68841398e-02f,
  9.65841580e-03f, -3.61260585e-02f, -1.06316626e-01f, -1.05662756e-01f, -1.90193355e-01f, 1.85623080e-01f, -1.11312233e-01f, -6.07141666e-02f, -1.44513980e-01f, 1.35528043e-01f,
  -8.79323781e-02f, -1.05919741e-01f, 1.00345463e-01f, 1.31555926e-02f, -4.60353643e-02f, -1.32557586e-01f, 8.28726590e-02f, 1.06522493e-01f, -1.18064240e-01f, 3.88612524e-02f,
  -2.58428082e-02f, -1.83188319e-01f, -7.27323964e-02f, 5.28116003e-02f, 6.65797591e-02f, 1.05091274e-01f, -2.47474432e-01f, -2.66494453e-02f, 1.99677646e-01f, -2.30933521e-02f,
  6.54199868e-02f, 9.68900248e-02f, 1.20403253e-01f, 2.77513079e-02f, -4.16661203e-02f, -4.45046276e-02f, 8.94128010e-02f, 3.97993296e-01f, 8.09234828e-02f, -2.61061370e-01f,
  -4.75732014e-02f, 8.38968828e-02f, -2.87174791e-01f, 8.40513259e-02f, 4.01530452e-02f, 1.91080421e-01f, 1.45616427e-01f, -5.71514256e-02f, -1.27343982e-01f, -3.03227067e-01f,
  -2.79055387e-01f, -1.62506908e-01f, -2.25049183e-01f, -9.10175666e-02f, -3.70360285e-01f, 8.83281380e-02f, 2.48280108e-01f, -1.37867272e-01f, -6.44786516e-03f, 1.47381267e-02f,
  3.34685668e-02f, 1.90144688e-01f, -9.51434746e-02f, 1.06977485e-01f, -5.62611632e-02f, 4.13789228e-02f, 1.12485010e-02f, 2.01990560e-01f, 9.51012690e-03f, 9.13112089e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -1.30595088e-01f, 1.79222345e-01f, -2.57259477e-02f, 2.46029228e-01f, -6.30124360e-02f, 1.66090474e-01f, 1.84695795e-02f, 7.34934583e-02f, 5.32200694e-01f, -5.52911460e-02f,
  -5.84264174e-02f, 9.81488377e-02f, -3.11713040e-01f, -3.61322761e-02f, 2.96640277e-01f, -4.52258199e-01f, -9.03425366e-02f, -1.46070063e-01f, 3.70006889e-01f, -5.03388792e-02f,
  5.02349027e-02f, 1.76656488e-02f, -2.10889146e-01f, -1.62300318e-01f, -3.62503864e-02f, -5.81624985e-01f, -4.95855063e-01f, -5.27738854e-02f, 2.74766892e-01f, 4.88885164e-01f,
  5.25346473e-02f, 2.03312561e-02f, 4.31300431e-01f, 2.76597798e-01f, 4.80215065e-03f, 2.64258862e-01f, -9.97850820e-02f, 1.50531277e-01f, -3.59795475e-03f, -2.28433385e-01f,
  3.02697301e-01f, 2.47870713e-01f, -5.91413453e-02f, 1.17856830e-01f, -2.31810942e-01f, -4.16103043e-02f, -2.51467437e-01f, 2.01821432e-01f, -3.38735342e-01f, -2.52210982e-02f,
  7.70761743e-02f, 1.24677375e-01f, 2.76780516e-01f, 2.05810204e-01f, 4.33750987e-01f, -2.01264635e-01f, 1.86744809e-01f, 2.43242756e-01f, -1.74114361e-01f, -1.83454126e-01f,
  -1.16173483e-01f, 2.68933419e-02f, 3.24984014e-01f, 3.09944339e-02f, 1.92019403e-01f, -8.63525867e-02f, 3.01321428e-02f, 2.21148029e-01f, 4.10958473e-03f, 1.18167967e-01f,
  2.63562530e-01f, -1.09457999e-01f, 5.65602724e-03f, 8.32539424e-02f, 1.49762109e-01f, 3.67290854e-01f, 3.10432255e-01f, 1.68919519e-01f, 2.51215756e-01f, 1.13786692e-02f,
  5.00752926e-02f, 2.41976932e-01f, 1.25250816e-01f, 1.67517751e-01f, -9.85919461e-02f, -1.53987471e-03f, 3.64815779e-02f, 9.56273973e-02f, 3.23040694e-01f, 4.71668214e-01f,
  -1.38852671e-01f, -1.83524460e-01f, -5.09023201e-03f, -3.42160761e-02f, 1.13409989e-01f, -1.08964026e-01f, 1.88060910e-01f, -8.23386535e-02f, 5.34932792e-01f, 1.67350158e-01f,
  -2.98801571e-01f, 1.52340069e-01f, -1.35275632e-01f, -4.29761559e-01f, -2.87086874e-01f, 2.84246832e-01f, 4.17855322e-01f, 6.94443807e-02f, -2.07254693e-01f, 2.75642663e-01f,
  -3.92011739e-02f, 1.69800326e-01f, 1.04851574e-01f, -1.17955562e-02f, -3.37845594e-01f, 3.42197597e-01f, -1.62186325e-01f, 1.92873433e-01f, -6.38484895e-01f, -2.23644689e-01f,
  -3.77936512e-01f, -1.33400127e-01f, 4.00753021e-01f, 1.83058843e-01f, 4.42999363e-01f, -9.34032872e-02f, 2.19559833e-01f, 3.12796295e-01f, 3.68110955e-01f, 2.69948810e-01f,
  9.73153263e-02f, 4.20689695e-02f, 1.94329694e-01f, 1.07034102e-01f, 5.36810040e-01f, 2.33940378e-01f, 1.69548597e-02f, 1.88400939e-01f, 1.41060576e-01f, 1.78458747e-02f,
  -9.19200853e-02f, 3.06283623e-01f, 1.64661869e-01f, -1.02863282e-01f, 1.14951782e-01f, -1.26719195e-02f, 2.63889343e-01f, 1.95563048e-01f, 2.26651847e-01f, 3.77589107e-01f,
  -3.84636790e-01f, 3.48442674e-01f, 1.53573528e-01f, 3.34895879e-01f, -2.06353649e-01f, 8.90209824e-02f, -7.02267140e-02f, 4.94607314e-02f, -9.98440683e-02f, -1.07148983e-01f,
  -1.99186280e-01f, -2.63718396e-01f, -5.82867377e-02f, 1.08642928e-01f, 2.12733433e-01f, 4.41989005e-02f, -5.76330684e-02f, -1.96755990e-01f, 5.69903627e-02f, 1.47930369e-01f,
  2.70567238e-02f, -5.49152009e-02f, 8.40478577e-03f, 3.05425704e-01f, 9.88267884e-02f, 1.10748140e-02f, -1.96459055e-01f, 1.25400111e-01f, -9.69430730e-02f, 2.47954637e-01f,
  1.77662924e-01f, 3.38415980e-01f, -4.32184577e-01f, 1.35889664e-01f, 6.47354275e-02f, -6.66428357e-02f, -2.76102901e-01f, 6.75637200e-02f, 3.50940466e-01f, -8.13171640e-02f,
  6.88168034e-02f, 4.74970192e-01f, 9.98644307e-02f, 4.70650159e-02f, 2.30218202e-01f, -9.09377635e-02f, 3.48809302e-01f, -8.44881013e-02f, -5.32589741e-02f, 2.18112946e-01f,
  1.94686353e-01f, 2.50848562e-01f, 2.01816007e-01f, -2.37517029e-01f, -1.97175499e-02f, 3.62922162e-01f, 1.64256737e-01f, -1.09135032e-01f, 7.84708112e-02f, -2.63940275e-01f,
  4.10121903e-02f, 7.92275518e-02f, 2.67473608e-01f, -2.00397477e-01f, -1.23016253e-01f, -1.56556234e-01f, 3.38923544e-01f, -6.94218874e-02f, -4.31350559e-01f, -3.05953771e-01f,
  9.40097570e-02f, 3.10628682e-01f, -3.11460853e-01f, -2.03579858e-01f, -6.84137270e-02f, -1.95762992e-01f, 7.29845390e-02f, 4.13779557e-01f, 2.68998325e-01f, 9.05692875e-02f,
  8.55035931e-02f, 2.10816711e-01f, 1.52396346e-02f, 2.85884082e-01f, -9.15276706e-02f, 1.88141018e-01f, -1.73388630e-01f, 3.09942365e-01f, -1.02458425e-01f, -1.70863979e-03f,
  2.83094138e-01f, -1.00401737e-01f, -4.99198847e-02f, 1.59577444e-01f, -1.39612436e-01f, 2.65313774e-01f, 1.51434258e-01f, 6.84315935e-02f, 1.59863368e-01f, 4.30946313e-02f,
  -5.47137737e-01f, -2.60944277e-01f, 9.96854901e-02f, 1.92406416e-01f, 1.46823719e-01f, 1.17054380e-01f, 7.56211281e-02f, -1.97823107e-01f, -1.32618800e-01f, -9.14922580e-02f,
  1.31723017e-01f, -1.57791167e-01f, 4.00075951e-04f, 2.39113033e-01f, -2.77613014e-01f, -1.38072535e-01f, -9.99637414e-03f, -4.52199787e-01f, -6.80108517e-02f, -5.93901053e-03f,
  -7.59521797e-02f, 7.20978603e-02f, -3.04407924e-02f, -1.26653209e-01f, -1.18423840e-02f, 2.19371691e-01f, 4.61508572e-01f, -1.81790501e-01f, -3.17978263e-01f, 5.48030213e-02f,
  1.19850062e-01f, -4.73755375e-02f, -9.23834927e-03f, -6.73867986e-02f, -2.57576644e-01f, 9.13791880e-02f, -1.61550775e-01f, -2.72916347e-01f, -8.37534443e-02f, 8.86808261e-02f,
  -3.55738223e-01f, -1.19580410e-01f, 5.59512377e-02f, 2.38005400e-01f, 1.38460875e-01f, 1.56448722e-01f, 1.96233299e-02f, 2.14518815e-01f, 4.71665636e-02f, 2.49177441e-01f,
  2.07798973e-01f, -2.25814302e-02f, 2.42527097e-01f, 6.83521107e-02f, 9.49890241e-02f, 2.34285966e-01f, -5.92754781e-02f, 2.25800991e-01f, 1.91782758e-01f, 2.21635848e-01f,
  -8.61641541e-02f, -3.33675668e-02f, 1.62557829e-02f, 1.63579926e-01f, -6.10723734e-01f, -1.75154567e-01f, 2.16098264e-01f, -1.26837254e-01f, -4.09983704e-03f, -1.10268285e-02f,
  -1.36530057e-01f, 4.20953147e-02f, 3.93453427e-02f, 4.08350706e-01f, -5.43089621e-02f, -2.02955335e-01f, -1.55748725e-01f, 6.24726862e-02f, 2.66120374e-01f, 7.82061294e-02f,
  -2.37310067e-01f, 2.83329815e-01f, 3.99953336e-01f, 8.62709805e-02f, 2.44614497e-01f, 1.10950015e-01f, -5.58088273e-02f, -1.80386141e-01f, 1.13006614e-01f, 9.01114270e-02f,
  1.40050292e-01f, 1.02893665e-01f, 4.82672118e-02f, 5.95287010e-02f, -1.56259105e-01f, -5.03574073e-01f, -3.70686710e-01f, -1.01943992e-01f, 2.84541905e-01f, 7.52374157e-02f,
  -6.55497760e-02f, -2.27498725e-01f, -3.21682245e-01f, 3.32639575e-01f, -4.66213822e-02f, -3.53899435e-04f, 1.06090739e-01f, -2.04896256e-01f, -2.28368510e-02f, -3.63035947e-01f,
  -9.99900177e-02f, -2.10975222e-02f, 1.86155736e-02f, 9.89013165e-02f, -3.06636184e-01f, 2.59061545e-01f, 2.73608476e-01f, -1.93093628e-01f, 5.24863243e-01f, -9.63259339e-02f,
  -7.42870942e-02f, 1.70111820e-01f, 4.82304811e-01f, 6.81978092e-02f, 3.78963232e-01f, -1.05790235e-01f, 2.00226381e-01f, -3.08983713e-01f, 1.63656250e-01f, 4.19419020e-01f,
  -5.16124554e-02f, 1.43280709e-02f, 1.22781977e-01f, -6.45143315e-02f, 2.10873261e-01f, 2.71916151e-01f, 6.18426763e-02f, -8.67898613e-02f, 1.04893856e-01f, -1.76225901e-01f,
  -1.26999110e-01f, 9.27203745e-02f, -7.72819892e-02f, 3.91222984e-01f, -2.17025056e-02f, 2.58196920e-01f, 1.18647888e-02f, 1.35552704e-01f, 1.39923245e-01f, 2.48282194e-01f,
  1.90993175e-01f, -7.94799924e-02f, -1.76062569e-01f, 1.34488001e-01f, 5.87427653e-02f, -9.64241251e-02f, 1.69930041e-01f, -1.40065730e-01f, 1.67857319e-01f, 1.53451860e-01f,
  1.13642484e-01f, 4.95024659e-02f, -7.96547979e-02f, -3.79860461e-01f, -2.93070197e-01f, 4.02923822e-01f, -1.71937540e-01f, -2.90144175e-01f, -3.16101313e-02f, -4.70356131e-03f,
  2.92193919e-01f, -2.17064410e-01f, 4.18277025e-01f, 2.08804131e-01f, -2.58029759e-01f, 1.05411403e-01f, -1.98520318e-01f, -4.58382785e-01f, -2.90373296e-01f, 3.52242172e-01f,
  -2.75187403e-01f, -4.17778462e-01f, -3.04001868e-01f, -2.61647403e-01f, 4.25119251e-01f, 5.97370835e-03f, -1.37088478e-01f, 1.08978666e-01f, 2.47885287e-01f, 4.04660940e-01f,
  -2.03047276e-01f, -2.41558373e-01f, 3.86939019e-01f, 2.13357165e-01f, 2.08233714e-01f, 4.40033346e-01f, 3.77871305e-01f, 8.91030282e-02f, 8.64736363e-02f, 1.19434185e-01f,
  5.60572743e-02f, -3.43241394e-02f, 2.85256833e-01f, 3.10902740e-03f, -1.98354751e-01f, 2.75327265e-01f, -1.65026426e-01f, -1.23766072e-01f, 3.02537084e-01f, -1.99170738e-01f,
  -4.08235304e-02f, 1.39443092e-02f, 1.83783069e-01f, -2.21275494e-01f, 2.57835060e-01f, 1.81604967e-01f, -8.37406144e-02f, -2.27341428e-01f, 1.34896278e-01f, -5.80177363e-03f,
  3.43883671e-02f, -1.38198495e-01f, 3.38743664e-02f, -2.17932582e-01f, 2.31847838e-01f, 7.87151456e-02f, 9.99527499e-02f, 2.14525774e-01f, -3.54496062e-01f, -2.06205145e-01f,
  2.64083743e-01f, -8.46506935e-03f, -2.15952337e-01f, -1.18122935e-01f, -2.26902008e-01f, 5.72757304e-01f, 2.83838511e-01f, 3.77535254e-01f, 3.46605957e-01f, 2.82339025e-02f,
  -1.47389948e-01f, -3.57695259e-02f, 1.27983436e-01f, -2.84465939e-01f, -9.02959406e-02f, 1.87240839e-01f, -2.93703020e-01f, 2.46101171e-01f, 5.87130664e-03f, 3.58247431e-04f,
  2.38945097e-01f, 3.37277144e-01f, 1.91271871e-01f, 2.64336616e-01f, 5.48987925e-01f, 5.65905035e-01f, -4.73533273e-01f, -2.52741516e-01f, -6.91327453e-02f, -1.67980939e-01f,
  -3.40899348e-01f, 7.63857588e-02f, 2.01012790e-01f, -2.38206878e-01f, -1.45416424e-01f, 2.08156511e-01f, -2.95582771e-01f, -9.78150964e-03f, -1.53117731e-01f, 1.06706753e-01f,
  -7.69888386e-02f, -2.49100029e-01f, 6.14614971e-02f, 1.24720179e-01f, -2.84772553e-02f, -3.09101313e-01f, -1.57803729e-01f, -2.09121570e-01f, -7.64981434e-02f, 1.30915359e-01f,
  4.52003852e-02f, -4.28195894e-02f, -7.08250701e-02f, -2.36288056e-01f, -1.05743147e-01f, -9.05924384e-03f, -3.52001399e-01f, -4.62501317e-01f, -8.64996538e-02f, -6.96108267e-02f,
  -1.41676310e-02f, -1.28232658e-01f, 6.14210926e-02f, -3.90091270e-01f, 6.10301569e-02f, 4.87689227e-01f, -8.54817107e-02f, -1.52254164e-01f, 2.63753504e-01f, 6.37464151e-02f,
  -1.47902504e-01f, -1.72056526e-01f, -1.80415604e-02f, 2.09323138e-01f, -5.16032912e-02f, 1.79690957e-01f, 1.90685943e-01f, -1.59297138e-01f, 2.91823477e-01f, -3.07932496e-02f,
  -2.16755852e-01f, 2.19106957e-01f, -3.60313058e-01f, 1.18286714e-01f, 8.27086419e-02f, 1.03309462e-02f, 7.88170770e-02f, -2.81103790e-01f, 2.77343336e-02f, -2.61756331e-01f,
  4.62405980e-01f, 1.71984360e-01f, 1.06866099e-01f, 1.21643417e-01f, 2.15161026e-01f, 1.34628817e-01f, -1.62168010e-03f, -3.10528815e-01f, 3.62477273e-01f, -3.77396531e-02f,
  3.82648975e-01f, -2.47762442e-01f, 6.21873625e-02f, 2.56206274e-01f, 1.12345554e-01f, 5.01362868e-02f, 3.98640037e-01f, 6.90739155e-02f, 9.84306484e-02f, 1.88347220e-01f,
  5.45313060e-02f, 3.63970459e-01f, 3.80756706e-01f, 1.05062261e-01f, -2.15712488e-01f, 5.32788001e-02f, 7.56274760e-02f, -1.78681388e-01f, -8.71398076e-02f, 2.30061617e-02f,
  1.11463986e-01f, 1.10647164e-01f, -1.49165750e-01f, -1.61939204e-01f, -5.13088256e-02f, 1.28466263e-01f, -2.08113074e-01f, -3.74335051e-01f, -5.11191249e-01f, -3.46960425e-01f,
  4.90359683e-03f, -5.71573377e-02f, -1.60675302e-01f, 6.09758124e-02f, -2.49615274e-02f, -1.21518955e-01f, -8.81819725e-02f, -1.63280323e-01f, 9.36256126e-02f, 3.00745487e-01f,
  3.71096462e-01f, 1.29891679e-01f, 4.26766008e-01f, 9.00759473e-02f, 6.32652283e-01f, 3.39314073e-01f, -1.55535623e-01f, 3.93811315e-01f, 4.65351529e-02f, 2.38160081e-02f,
  1.29062355e-01f, -1.77093782e-02f, 2.22330645e-01f, -1.61875248e-01f, -1.81405917e-01f, 2.90755779e-01f, 2.43977696e-01f, -5.33752665e-02f, 5.58121540e-02f, -1.66335225e-01f,
  1.81875661e-01f, -1.62933290e-01f, 1.85125262e-01f, -1.40002131e-01f, -8.80947933e-02f, -2.66654730e-01f, 7.22850859e-02f, 1.89513057e-01f, -2.52468646e-01f, -3.68724316e-02f,
  7.55822510e-02f, -1.11128867e-01f, -2.63587926e-02f, 1.21073887e-01f, -6.91358149e-02f, -2.47142036e-02f, 2.73127705e-01f, 1.34588227e-01f, -7.94762373e-02f, 1.90045666e-02f,
  2.32115969e-01f, -1.09413594e-01f, 2.54656263e-02f, 8.10225261e-04f, 1.49482757e-01f, -3.44175771e-02f, 1.66001990e-02f, 2.07210213e-01f, -2.44773492e-01f, -6.05066456e-02f,
  -2.34415948e-01f, -4.29060131e-01f, -2.13573530e-01f, -6.97513074e-02f, -3.95721883e-01f, -8.99319798e-02f, 1.00678504e-01f, 1.17580280e-01f, 4.61654272e-03f, 8.98822546e-02f,
  1.16909787e-01f, -4.01910134e-02f, 1.29656255e-01f, 1.78468078e-01f, 2.98333138e-01f, 1.28452346e-01f, 3.64989758e-01f, 1.63963109e-01f, -8.33763704e-02f, 1.56325981e-01f,
  -1.99578226e-01f, 2.94876903e-01f, 2.20197231e-01f, 6.21176921e-02f, -5.31378947e-02f, -3.09163351e-02f, 2.80666322e-01f, 2.12250277e-01f, -1.91972956e-01f, -7.19435588e-02f,
  9.50344726e-02f, -1.01683728e-01f, -1.81753397e-01f, 4.53455821e-02f, 2.76332736e-01f, 1.19249843e-01f, 1.61475435e-01f, 3.81636433e-02f, 1.46389250e-02f, 1.07672974e-01f,
  2.76244253e-01f, 1.28723711e-01f, -4.58414480e-03f, 9.17683765e-02f, 1.69515982e-01f, -1.18909568e-01f, 1.57924682e-01f, 2.00943008e-01f, 5.40067814e-02f, -1.20990857e-01f,
  -4.23117056e-02f, 3.08440216e-02f, -5.34366965e-02f, 2.61255980e-01f, -8.79506990e-02f, 2.76054621e-01f, 3.65047045e-02f, 1.09753452e-01f, 3.69241297e-01f, 1.03102967e-01f,
  -7.55876899e-02f, -2.38650873e-01f, -1.65187523e-01f, -1.03033930e-01f, 6.30894154e-02f, 1.88622981e-01f, 2.75739491e-01f, -2.67150670e-01f, 4.05739963e-01f, 1.54687598e-01f,
  -2.80289859e-01f, -5.76979853e-02f, -2.17082083e-01f, -7.75444601e-03f, -3.49179447e-01f, 2.20504060e-01f, 4.25518513e-01f, -2.62172192e-01f, -4.51637357e-01f, 4.55460966e-01f,
  -9.11488198e-03f, 2.49499485e-01f, -7.23495707e-02f, -3.28147858e-01f, 1.02477297e-01f, 9.68719944e-02f, -1.91414487e-02f, 4.10612136e-01f, -2.49130473e-01f, 1.39285892e-01f,
  -6.40628189e-02f, -1.02368876e-01f, -1.12956606e-01f, -1.85859337e-01f, 5.61947167e-01f, -1.40342399e-01f, 1.59565628e-01f, 5.57818592e-01f, 2.54570454e-01f, 1.39463931e-01f,
  1.16643272e-01f, -4.59928252e-02f, 1.25807062e-01f, 7.74998143e-02f, -8.87759104e-02f, -9.83084142e-02f, 1.06235426e-02f, -2.14472264e-01f, 1.16811626e-01f, 1.28820911e-01f,
  2.26614356e-01f, 1.71675757e-01f, -7.59377331e-02f, 3.25127035e-01f, 2.21882910e-01f, -4.52375337e-02f, -4.53627072e-02f, 1.55915305e-01f, -2.35970557e-01f, 2.42709741e-01f,
  -1.59831736e-02f, 3.53949010e-01f, -2.68096831e-02f, 3.55046727e-02f, -4.44475040e-02f, 6.68731183e-02f, -8.86473060e-02f, -2.56463826e-01f, -1.19996957e-01f, 3.58333170e-01f,
  -4.74185288e-01f, 7.89119378e-02f, -2.91763365e-01f, -3.01267684e-01f, 9.92187485e-02f, -1.73257947e-01f, 4.01080400e-02f, 3.99650842e-01f, 1.34765729e-01f, -3.57493490e-01f,
  -3.84076953e-01f, 4.34604511e-02f, 1.45144999e-01f, -3.26775685e-02f, 3.87351841e-01f, -1.47690624e-01f, 2.95035601e-01f, 1.29278779e-01f, 2.04854220e-01f, 1.41996935e-01f,
  4.10794079e-01f, 4.08414528e-02f, -6.01788163e-02f, 2.86416888e-01f, 8.81823599e-02f, -1.61608547e-01f, -3.20563406e-01f, 4.65611935e-01f, -7.99092129e-02f, 3.66177037e-02f,
  -4.13549282e-02f, 1.76692590e-01f, 6.83329720e-03f, -1.00172870e-01f, -7.22184181e-01f, -4.48153824e-01f, -2.65640765e-01f, 2.54824013e-01f, 1.34939983e-01f, -1.54082969e-01f,
  -2.01852098e-01f, -2.99844861e-01f, -2.46303707e-01f, -2.70450115e-01f, 8.77578836e-03f, -1.38722971e-01f, -1.33128554e-01f, -2.61843055e-01f, -3.61648738e-01f, 1.90749437e-01f,
  1.95674419e-01f, -4.40745324e-01f, -1.13381319e-01f, 1.67730436e-01f, -1.06551625e-01f, 2.08930507e-01f, -4.32573646e-01f, -1.53910117e-02f, -2.53269017e-01f, 1.68359168e-02f,
  -2.57338464e-01f, 1.30849048e-01f, -6.43433183e-02f, 1.63777739e-01f, 1.90138429e-01f, 1.20067947e-01f, 8.52929205e-02f, -4.50000539e-02f, -2.16766536e-01f, -1.07183456e-01f,
  -3.41070890e-01f, -1.30787089e-01f, -5.41701242e-02f, 1.13442749e-01f, 5.12613617e-02f, -2.57820964e-01f, -2.37383544e-01f, -1.36158228e-01f, -5.88490404e-02f, 3.67200822e-01f,
  -4.08625722e-01f, 1.46865845e-01f, -9.00055692e-02f, -5.82749583e-03f, -1.83472291e-01f, 2.83363611e-01f, -1.74194440e-01f, -4.32821140e-02f, -2.47872308e-01f, -1.80186644e-01f,
  -8.26816112e-02f, -2.58388013e-01f, 9.17251334e-02f, -8.62896815e-02f, 1.48169622e-01f, 2.74626911e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  1.82421535e-01f, 2.18170092e-01f, 3.78730446e-02f, -2.46564951e-02f, 1.36255100e-01f, 7.54899159e-02f, 3.37120473e-01f, 2.44388491e-01f, -8.36229026e-02f, 1.32242739e-01f,
  8.72182846e-02f, 1.38515726e-01f, 2.06191868e-01f, 3.01502674e-04f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -1.84041522e-02f, 1.97187886e-01f, 2.33715922e-02f, -1.98292181e-01f, 1.77185625e-01f, -2.33441427e-01f, 2.34482735e-01f, -9.09878090e-02f, -6.88650757e-02f, -1.60488021e-02f,
  -1.84252217e-01f, 2.18156338e-01f, -1.42737463e-01f, 1.16059095e-01f, -3.06550087e-03f, -1.87583715e-01f, -2.54351180e-02f, -1.65083617e-01f, 1.06903449e-01f, 3.67266126e-02f,
  5.32935746e-02f, -9.48496237e-02f, 2.33149245e-01f, -1.51009241e-03f, -4.50076908e-02f, -2.65018344e-01f, -3.85383852e-02f, -1.56004921e-01f, -2.39731386e-01f, 1.28751770e-01f,
  2.80993938e-01f, 1.53031319e-01f, -3.08860958e-01f, 3.26813728e-01f, -2.07962543e-01f, -2.28429392e-01f, -1.17068507e-01f, -1.82164058e-01f, 1.38742313e-01f, -3.45315486e-01f,
  2.21733768e-02f, -2.60172755e-01f, 3.74983460e-01f, 2.33346835e-01f, 2.79285014e-01f, 5.80180958e-02f, -1.07353330e-01f, 8.49522725e-02f, -2.07444981e-01f, -2.81312555e-01f,
  1.98260680e-01f, 1.47794887e-01f, 5.47352694e-02f, -2.62546778e-01f, -1.34410262e-01f, 6.40865415e-02f, -1.22881755e-01f, -2.83871502e-01f, 4.49435562e-01f, -4.32340175e-01f,
  -2.99223512e-01f, -5.16179726e-02f, -3.93711925e-01f, 2.10422188e-01f, -2.48387992e-01f, -2.57019140e-02f, -2.88551509e-01f, -1.73574060e-01f, -4.55698043e-01f, 8.08804203e-03f,
  3.58468816e-02f, 2.37067297e-01f, 1.11203283e-01f, 2.35910923e-03f, -2.39349097e-01f, -1.73316315e-01f, -3.63412917e-01f, -4.20835540e-02f, 2.94459671e-01f, -2.72044003e-01f,
  2.38937631e-01f, -4.01387662e-02f, -9.41218138e-02f, 1.09585542e-02f, -1.28076851e-01f, -1.00498252e-01f, 1.61504328e-01f, 1.74620748e-01f, -2.70917509e-02f, 1.02420054e-01f,
  1.19588733e-01f, 1.22510903e-01f, -4.86315461e-03f, 8.84488896e-02f, 2.32834399e-01f, -3.19173113e-02f, 9.82601643e-02f, 2.59082615e-01f, -1.46420434e-01f, 4.94526175e-04f,
  -2.36777887e-01f, 2.07537234e-01f, -3.24372619e-01f, 5.68231083e-02f, 1.39779836e-01f, 9.46561340e-03f, -2.66904324e-01f, -6.90874681e-02f, -2.24110022e-01f, -1.30565584e-01f,
  -2.00891152e-01f, -2.04300657e-01f, -9.12931859e-02f, 1.28055036e-01f, 1.97805569e-01f, -3.33282381e-01f, -7.29300559e-01f, 2.69398659e-01f, -1.75199006e-02f, 2.91475058e-01f,
  2.17663899e-01f, -7.04673231e-02f, -1.57504722e-01f, -1.28941283e-01f, -1.17278501e-01f, -5.54997586e-02f, -4.46096539e-01f, -1.30888730e-01f, 1.05502814e-01f, -1.30874708e-01f,
  -3.64113562e-02f, -3.50993872e-01f, 6.64465874e-02f, -1.76525101e-01f, 2.25945413e-01f, 1.30624130e-01f, -3.83027554e-01f, 1.86614648e-01f, -3.57598886e-02f, -5.05225994e-02f,
  1.49875686e-01f, 5.92748374e-02f, 1.27771139e-01f, -1.73173249e-02f, 1.80669174e-01f, -9.24988687e-02f, 1.40721917e-01f, 2.96936668e-02f, 1.51941076e-01f, 2.58632302e-01f,
  2.54289418e-01f, 1.21408708e-01f, -3.56765538e-02f, 2.57289171e-01f, -2.88973987e-01f, -4.52107750e-02f, -1.02701567e-01f, 2.34919582e-02f, 7.13811368e-02f, -4.03569676e-02f,
  1.04582489e-01f, 2.69252807e-01f, -4.57470804e-01f, 3.29751104e-01f, 3.12336385e-01f, -1.62841335e-01f, 2.75130004e-01f, -4.36755866e-02f, 4.87378687e-01f, -3.79019231e-01f,
  -2.11809725e-01f, 4.78016362e-02f, -1.05488770e-01f, -1.75095648e-01f, -4.65925783e-02f, 2.07598880e-01f, 7.59354085e-02f, 2.13927120e-01f, -4.91440088e-01f, -5.12584925e-01f,
  -1.05438696e-04f, -1.83221735e-02f, 2.21269131e-01f, -4.69538122e-01f, -7.85769820e-02f, 2.93061078e-01f, 1.92170814e-01f, -1.73939943e-01f, 3.41508269e-01f, 2.11187657e-02f,
  2.27231055e-01f, -3.40525687e-01f, 1.42808735e-01f, -8.50223526e-02f, -3.49849649e-03f, -1.63098320e-01f, -2.66593188e-01f, -5.23616895e-02f, 2.51449943e-02f, 2.23265681e-02f,
  -6.25975579e-02f, -1.20942995e-01f, 1.16688818e-01f, -2.13488370e-01f, -2.31070429e-01f, 5.24496250e-02f, 7.36496970e-02f, 1.75095290e-01f, 9.50030833e-02f, 3.85072269e-02f,
  2.37665419e-02f, -1.30477577e-01f, 7.80683905e-02f, 1.16000332e-01f, 9.67525840e-02f, -4.53331888e-01f, -1.87055189e-02f, -2.58714199e-01f, 2.11800169e-03f, -2.05933422e-01f,
  1.14931569e-01f, -2.19305605e-02f, -3.75727654e-01f, -4.64213602e-02f, -1.35325506e-01f, 1.99127436e-01f, -2.22758278e-01f, -2.37801865e-01f, 3.88079882e-02f, -2.71502119e-02f,
  1.47200987e-01f, 5.33232205e-02f, 3.94429624e-01f, 3.56807947e-01f, -3.75489406e-02f, 2.36582652e-01f, 1.95597544e-01f, 2.90481374e-02f, 1.03093348e-01f, 1.28435483e-02f,
  -2.04216048e-01f, -5.27843118e-01f, -2.80848145e-01f, 2.16057435e-01f, 1.34121433e-01f, 6.05277345e-02f, 1.97605267e-02f, 1.68014750e-01f, -2.27332056e-01f, -7.77864218e-01f,
  1.22058101e-01f, 4.24816459e-01f, -5.30988630e-03f, 5.02089970e-04f, -1.43004209e-01f, -3.48607689e-01f, -1.93581164e-01f, -1.75896749e-01f, 2.79402912e-01f, 3.04551065e-01f,
  2.22651735e-01f, 3.36082876e-01f, -2.11932346e-01f, 3.01513463e-01f, 5.56859337e-02f, -1.29977778e-01f, 4.37947065e-02f, -2.35666499e-01f, 8.23114291e-02f, -3.86605680e-01f,
  2.43050028e-02f, 1.47997350e-01f, 3.41003090e-02f, 1.11587502e-01f, -2.79870719e-01f, -1.63299754e-01f, 3.30490977e-01f, 1.47416338e-01f, -4.06645030e-01f, 9.33745876e-02f,
  2.14973956e-01f, 2.75856733e-01f, -5.78395836e-02f, 1.05456859e-01f, -2.01330826e-01f, -2.88315445e-01f, 1.86707973e-01f, 1.28388731e-02f, 6.42197803e-02f, -5.09471178e-01f,
  -2.38976792e-01f, -1.79045230e-01f, 1.31534934e-01f, -4.56643850e-02f, -1.30920947e-01f, -1.99524030e-01f, -3.01555961e-01f, -2.12729480e-02f, -1.57176420e-01f, 7.71176666e-02f,
  7.59383813e-02f, 2.04526275e-01f, 3.44881475e-01f, -1.40990332e-01f, -2.03926176e-01f, 3.81341130e-01f, 1.00355797e-01f, 2.46708125e-01f, 1.65140301e-01f, 1.60428777e-01f,
  1.25853885e-02f, -3.42990071e-01f, -1.26739398e-01f, -2.63365895e-01f, -2.80516356e-01f, 2.46734414e-02f, -2.97975481e-01f, 1.36259824e-01f, -1.65496081e-01f, 1.67387545e-01f,
  -1.88567489e-01f, 2.96316534e-01f, -2.06083342e-01f, -7.24420836e-03f, -1.41212016e-01f, 1.60158783e-01f, -2.42316931e-01f, -3.68699700e-01f, -1.57207444e-01f, -2.18410254e-01f,
  -1.79033667e-01f, 1.71138316e-01f, 1.92950577e-01f, 2.99094766e-01f, -4.37512361e-02f, -1.99025393e-01f, 1.30335614e-01f, -1.02841407e-01f, 2.93985367e-01f, -1.42303884e-01f,
  -6.44327328e-02f, 9.65502933e-02f, 2.50782847e-01f, -5.22638597e-02f, 4.68535796e-02f, 5.10483570e-02f, 1.56220809e-01f, 3.58113050e-01f, -4.21821833e-01f, -1.84270129e-01f,
  3.55535805e-01f, 2.21324787e-01f, -1.84876621e-01f, -1.20617552e-02f, 3.62495273e-01f, 2.63354599e-01f, -3.20931315e-01f, -3.41060638e-01f, -5.20136841e-02f, -8.03657249e-03f,
  -2.73535848e-01f, -9.59671810e-02f, 2.49036655e-01f, -3.94890979e-02f, -1.57393157e-01f, -3.10062319e-02f, -1.43047258e-01f, 2.10934088e-01f, 1.58494279e-01f, -2.70139873e-01f,
  -1.82850629e-01f, -9.47583690e-02f, 2.21959218e-01f, 1.28066003e-01f, -3.48676234e-01f, -3.94266874e-01f, 2.30633050e-01f, -1.68277353e-01f, -2.85181731e-01f, -3.79112422e-01f,
  -4.29825753e-01f, 1.00983828e-01f, 7.74868503e-02f, -1.30823374e-01f, 1.71756759e-01f, 2.75906652e-01f, 3.56156558e-01f, 1.77694365e-01f, -1.11943565e-01f, -1.76230948e-02f,
  6.56355843e-02f, -6.26802742e-02f, 2.29466945e-01f, -3.92099530e-01f, 7.85355270e-02f, 1.46901950e-01f, 6.82327002e-02f, 1.33879572e-01f, 1.00463480e-01f, 1.20134883e-01f,
  6.52986616e-02f, 2.47719232e-02f, 1.21700205e-01f, 1.05033286e-01f, 2.12114900e-01f, 2.87952214e-01f, -1.76775992e-01f, -4.21992391e-02f, -1.50276542e-01f, -2.82590151e-01f,
  -3.64164591e-01f, -5.40506579e-02f, 2.59597510e-01f, -1.42613977e-01f, -1.95636049e-01f, -2.08719030e-01f, -1.65301353e-01f, -2.78317899e-01f, 3.18510145e-01f, 1.96983621e-01f,
  2.64383942e-01f, -9.99625400e-02f, -3.25116158e-01f, 3.58686149e-01f, -3.41677576e-01f, 1.21547140e-01f, 1.49998680e-01f, 3.34005654e-01f, 9.05315299e-03f, 1.81147382e-01f,
  5.49556725e-02f, -3.36190373e-01f, 2.10438505e-01f, 2.91251153e-01f, 3.19378018e-01f, -1.72883764e-01f, -5.27736545e-01f, -3.26981843e-02f, -1.43714964e-01f, -1.50469884e-01f,
  -4.02348727e-01f, 3.54625493e-01f, -2.93336391e-01f, -6.16861165e-01f, -8.17274302e-02f, -6.37701929e-01f, -1.23521529e-01f, -1.79237023e-01f, -2.95211196e-01f, 4.21028771e-03f,
  -6.50773644e-02f, -4.82180677e-02f, 3.00839543e-01f, 1.10943660e-01f, -7.34176487e-02f, 3.54536227e-03f, -5.78525923e-02f, 1.51226148e-01f, -5.20970561e-02f, 7.66741708e-02f,
  -1.84047326e-01f, -2.26949424e-01f, 9.39278603e-02f, -1.89177200e-01f, -2.50416070e-01f, 5.71025275e-02f, -2.41540343e-01f, -3.16259414e-01f, -1.01225764e-01f, -7.14133233e-02f,
  1.79494381e-01f, 2.21323371e-01f, -1.51643530e-01f, 1.15682356e-01f, -5.28591834e-02f, 1.73087157e-02f, -1.01480812e-01f, -2.48512134e-01f, 8.33013430e-02f, -9.86853689e-02f,
  -2.25030705e-01f, -3.61580789e-01f, 1.79107457e-01f, -2.40414202e-01f, -1.82181716e-01f, -8.57011750e-02f, -2.29104370e-01f, -5.07458031e-01f, 2.50102609e-01f, 1.97231725e-01f,
  3.72895867e-01f, -2.90661305e-01f, -3.02415252e-01f, 2.13037536e-01f, 1.48751616e-01f, 1.34221807e-01f, -2.64207244e-01f, -4.35919225e-01f, -7.79969022e-02f, -2.56486505e-01f,
  -1.63790956e-01f, 1.51078895e-01f, 4.23871242e-02f, 4.79855351e-02f, -3.23449939e-01f, 4.93848734e-02f, 1.43557832e-01f, 4.72549707e-01f, 2.84914434e-01f, -5.76442063e-01f,
  -2.18716990e-02f, -1.83977470e-01f, 3.49589765e-01f, -1.09864965e-01f, -4.90595326e-02f, 3.02405596e-01f, -3.38700324e-01f, 2.42474452e-01f, 2.06279561e-01f, -3.81961673e-01f,
  4.46305484e-01f, 5.31266965e-02f, -2.68022150e-01f, -2.37387210e-01f, 2.86875725e-01f, -1.42979786e-01f, -8.63146484e-02f, -1.16334669e-01f, -4.21403795e-01f, -2.68176138e-01f,
  1.24348439e-01f, -4.14390005e-02f, -1.74929783e-01f, 1.63087279e-01f, -3.37002903e-01f, -3.10039729e-01f, -2.82623351e-01f, 3.95954847e-01f, 2.67090768e-01f, 2.87463754e-01f,
  4.98564333e-01f, 2.42221206e-01f, 2.24152151e-02f, -5.20021439e-01f, 2.78819323e-01f, -3.75795305e-01f, -2.82251120e-01f, -9.01857391e-02f, 4.48788106e-01f, 2.89205778e-02f,
  -2.51234829e-01f, 1.12478785e-01f, -1.79001570e-01f, -2.61282083e-02f, -2.17477664e-01f, -2.00963706e-01f, 2.94914663e-01f, 2.72968173e-01f, 2.69309342e-01f, 2.22970232e-01f,
  9.52702761e-02f, -2.44431257e-01f, -4.22082514e-01f, -2.72720784e-01f, -2.30856836e-02f, -4.93610531e-01f, -5.63108325e-01f, -3.97658199e-02f, 3.59357715e-01f, -2.58466661e-01f,
  1.15788959e-01f, -1.24986500e-01f, -9.74736065e-02f, -4.74285901e-01f, 1.55888602e-01f, -1.35218248e-01f, 4.84042726e-02f, -3.10686678e-01f, -4.11613882e-01f, 1.52539581e-01f,
  5.38513251e-02f, -2.53693849e-01f, 1.16562627e-01f, 1.67150393e-01f, 2.72503644e-01f, 1.00082502e-01f, 6.01072125e-02f, 4.78451252e-02f, 1.44088864e-01f, 1.18620604e-01f,
  2.61511683e-01f, 9.41008255e-02f, -5.21046333e-02f, 2.30204657e-01f, 1.02532044e-01f, 6.95653856e-02f, -2.84731030e-01f, -2.50425875e-01f, -2.53210068e-01f, -2.20377132e-01f,
  2.86958367e-01f, -3.14163715e-02f, -7.73894712e-02f, -2.01977730e-01f, 3.54170442e-01f, 2.73619354e-01f, 1.68725342e-01f, -8.64627138e-02f, -8.27858970e-02f, 1.89156294e-01f,
  4.75343049e-01f, -3.53227854e-01f, -4.21147048e-01f, 7.17987642e-02f, 3.00915658e-01f, 3.66972946e-02f, 4.57852185e-01f, 3.85635078e-01f, -2.70283334e-02f, -3.29072684e-01f,
  -2.43082270e-01f, 7.54447877e-02f, -7.95175582e-02f, -1.29988357e-01f, 3.89459550e-01f, -1.78868249e-01f, 2.46444821e-01f, -2.05905363e-01f, 2.87876993e-01f, 1.54963270e-01f,
  1.47337213e-01f, -1.91396009e-02f, -4.97217357e-01f, 1.85808334e-02f, -3.89179438e-01f, -5.36097527e-01f, 6.20877780e-02f, 1.44308887e-03f, -1.78028777e-01f, -2.65016258e-01f,
  5.10370016e-01f, 1.89580932e-01f, 2.88007455e-03f, 1.45465776e-01f, 2.90767938e-01f, -1.27870977e-01f, -4.89770770e-02f, -3.52926433e-01f, -2.81006694e-01f, 2.37199500e-01f,
  -2.36604139e-02f, 3.34079474e-01f, 6.39037788e-02f, 1.40846923e-01f, -7.26992860e-02f, 3.56588811e-01f, -3.35353673e-01f, 4.58415270e-01f, -9.19613317e-02f, -2.70992089e-02f,
  1.30219504e-01f, -4.75791335e-01f, -3.30076143e-02f, 2.62158781e-01f, -1.99303046e-01f, 9.67471823e-02f, -3.30336124e-01f, -6.09387338e-01f, -1.99167818e-01f, 6.41106591e-02f,
  -4.79111880e-01f, 4.29622352e-01f, 2.16903538e-01f, 2.37756833e-01f, -4.28740919e-01f, 1.97395220e-01f, 2.82478362e-01f, 4.28754210e-01f, 5.85522652e-01f, 2.10009798e-01f,
  1.19074106e-01f, -2.51706004e-01f, -8.15570280e-02f, -3.84960443e-01f, 3.51799905e-01f, -3.00030380e-01f, -2.33627573e-01f, -3.94753605e-01f, -6.79458976e-02f, 1.36217907e-01f,
  -6.33223891e-01f, 2.60572821e-01f, -1.82172894e-01f, -2.47541174e-01f, -3.30976069e-01f, -2.52207726e-01f, 2.02441648e-01f, -3.71332109e-01f, -1.63449019e-01f, -3.31692457e-01f,
  -2.57975370e-01f, 1.78425267e-01f, -5.13312519e-01f, -5.77408254e-01f, -2.60526091e-02f, -1.32065222e-01f, -8.24764594e-02f, -1.39984518e-01f, -1.34572089e-01f, -8.49413499e-03f,
  -3.70747119e-01f, 2.54921079e-01f, -3.56006652e-01f, -4.87180203e-02f, 1.79340020e-01f, 1.13180302e-01f, -3.81169736e-01f, -1.03184305e-01f, -3.40822935e-01f, 8.13823789e-02f,
  2.53309309e-01f, -2.58557349e-01f, 9.73139256e-02f, 2.86749572e-01f, 1.35862797e-01f, -1.18141025e-01f, 1.29879326e-01f, 5.32077104e-02f, 4.68437701e-01f, -5.33121169e-01f,
  2.32440650e-01f, 1.66687831e-01f, 1.87263712e-01f, 2.00409904e-01f, -3.50849003e-01f, 4.33339849e-02f, -8.53880644e-02f, -2.19451040e-01f, 2.44866431e-01f, 2.83689111e-01f,
  -4.08092625e-02f, 3.87972444e-02f, 9.28285718e-02f, 1.92888707e-01f, -1.83308259e-01f, 2.70697296e-01f, -3.49068761e-01f, 5.10778017e-02f, -3.92749578e-01f, -3.40659440e-01f,
  1.98479906e-01f, 1.59071356e-01f, 4.32595581e-01f, 2.25647882e-01f, -7.92605802e-02f, -2.64157534e-01f, -2.89719224e-01f, -1.76484138e-01f, -1.49627313e-01f, 4.35983092e-01f,
  -1.68472633e-01f, -2.29612470e-01f, -2.13826343e-01f, 2.01344863e-02f, -1.50814414e-01f, -3.14748317e-01f, 4.25571024e-01f, -5.57385795e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.75610483e-02f, 6.20496459e-02f, -4.41558398e-02f, -2.52207279e-01f, -3.80389243e-02f, -8.82901251e-02f, 1.74550548e-01f, 2.11844053e-02f, 1.58014819e-01f, -2.73285154e-02f,
  -5.07978816e-03f, -2.36717314e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    