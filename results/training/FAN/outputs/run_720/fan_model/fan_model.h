/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.86354169e-02f, 2.98174042e-02f, 7.08190128e-02f, 1.84147894e-01f, 1.71454608e-01f, 8.43426138e-02f, -1.07885301e-02f, -9.51619819e-03f, 1.13179602e-01f, 1.32421628e-01f,
  -3.57500985e-02f, 8.94962400e-02f, 1.38611019e-01f, 4.31102775e-02f, -5.53293414e-02f, 7.65696121e-03f, 1.24200627e-01f, 3.95458862e-02f, 1.35276854e-01f, -2.97001768e-02f,
  1.06473625e-01f, 1.30957097e-01f, 1.99620593e-02f, 7.93282911e-02f, 1.62793741e-01f, 1.08618811e-01f, 1.05540499e-01f, 8.11914057e-02f, 6.37938231e-02f, 2.20788136e-01f,
  -9.46858525e-03f, -9.20999050e-02f, 3.43747064e-02f, -4.07524556e-02f, 5.91247380e-02f, -9.58530456e-02f, -1.34488583e-01f, -4.84867431e-02f, 4.57084663e-02f, -9.03139710e-02f,
  1.02503700e-02f, -5.73260756e-03f, 5.86314835e-02f, 6.62828097e-03f, -1.06679304e-02f, -1.97068024e-02f, 5.85228167e-02f, 1.06064029e-01f, -2.00830586e-02f, -9.85914096e-02f,
  6.57443479e-02f, 2.65747570e-02f, -1.18021546e-02f, 4.59856261e-03f, -5.43919094e-02f, -5.55154309e-02f, 8.09630379e-02f, -8.33476335e-02f, -7.38242874e-03f, -3.97622213e-02f,
  -1.94200762e-02f, -1.10456338e-02f, 7.92180747e-03f, 3.70002165e-02f, 7.00728372e-02f, -1.79848634e-02f, 9.03466493e-02f, 8.73911232e-02f, 1.31684104e-02f, 8.39599669e-02f,
  3.67579572e-02f, 6.66369572e-02f, 1.01028673e-01f, 7.49747455e-02f, 1.56037994e-02f, 8.33406895e-02f, 9.95304808e-02f, 1.09297954e-01f, -2.05594189e-02f, 7.38996565e-02f,
  6.55643791e-02f, -6.75229914e-03f, 8.46749991e-02f, 2.24218555e-02f, 1.20941214e-02f, 2.03578789e-02f, -2.46771369e-02f, 9.99284089e-02f, 4.45358194e-02f, 8.74013603e-02f,
  5.78893498e-02f, -1.48877159e-01f, -8.56982172e-02f, -4.11876477e-02f, -3.34656350e-02f, -6.29869029e-02f, -5.46320225e-04f, -1.26774728e-01f, -2.36841943e-02f, -7.23001137e-02f,
  -1.42796010e-01f, -6.84626326e-02f, -3.84163745e-02f, -7.05013499e-02f, -2.83409972e-02f, -9.02561173e-02f, -4.96253259e-02f, 3.20202820e-02f, -9.41866040e-02f, -3.41133811e-02f,
  -3.85444053e-02f, -1.07394420e-01f, -5.28929383e-02f, -9.60481465e-02f, -1.18289553e-01f, -3.21830995e-02f, -1.24628551e-01f, -2.85720546e-02f, -1.70188978e-01f, -6.06741458e-02f,
  1.21000677e-01f, 2.44156748e-01f, 8.83056670e-02f, -1.16434209e-01f, -1.06397033e-01f, 3.02155707e-02f, 3.24491978e-01f, 2.13743553e-01f, -1.05526358e-01f, 4.75636907e-02f,
  -9.92767587e-02f, -2.14466587e-01f, -8.24838653e-02f, -8.72390345e-02f, 1.12856090e-01f, 1.37694627e-01f, 2.43602525e-02f, 7.90501535e-02f, -9.22417641e-02f, 5.48376776e-02f,
  4.19471301e-02f, 1.23133369e-01f, 1.09057002e-01f, 2.76345070e-02f, 6.15161993e-02f, 1.11800330e-02f, 6.57318309e-02f, 7.49791265e-02f, 1.47571877e-01f, 1.51389420e-01f,
  -2.68388670e-02f, 5.29256128e-02f, -8.71753693e-02f, -1.51897132e-01f, -1.07156590e-01f, 5.29456735e-02f, 3.97188775e-02f, -7.18558803e-02f, -8.13172385e-02f, -2.41307132e-02f,
  -1.80410817e-01f, -1.52821735e-01f, 9.49424971e-03f, 4.25613001e-02f, 1.82692111e-02f, 8.35057814e-03f, -1.24532031e-02f, 2.39832164e-03f, 3.79404649e-02f, 4.19824049e-02f,
  -6.93355501e-02f, -7.10052699e-02f, 3.22369151e-02f, 5.50599657e-02f, 6.93284497e-02f, -1.73445001e-01f, 4.13289294e-02f, 1.12469032e-01f, 1.37010098e-01f, 2.79978931e-01f,
  5.54851331e-02f, 4.81881900e-03f, -2.50194501e-02f, 1.70548763e-02f, 7.57232383e-02f, -3.91810313e-02f, 5.65260872e-02f, 4.78195138e-02f, 1.20698940e-02f, 1.09487705e-01f,
  -4.64847125e-02f, -3.38850394e-02f, 5.33124479e-03f, 2.83965971e-02f, 5.34919985e-02f, 5.31932004e-02f, 9.29525420e-02f, 7.77500421e-02f, -6.61145523e-02f, 7.32499063e-02f,
  9.77615453e-03f, 1.83167160e-02f, -2.20075459e-03f, 1.35613242e-02f, -6.60385052e-03f, 7.90776387e-02f, -9.94985364e-03f, -2.78435480e-02f, 1.42610981e-03f, 6.25835285e-02f,
  -8.06134492e-02f, -1.51496306e-01f, -1.56928152e-02f, 1.43041210e-02f, -9.18110758e-02f, -1.10765688e-01f, -1.06651820e-01f, -9.08568278e-02f, -6.85207322e-02f, -6.63686320e-02f,
  7.83688761e-03f, 2.31026486e-02f, -9.18031484e-02f, -8.89801458e-02f, 2.92161293e-02f, -1.21948525e-01f, 7.60989060e-05f, -5.31626530e-02f, -8.39207843e-02f, -6.72055557e-02f,
  3.52213308e-02f, -3.54248472e-02f, 6.77511394e-02f, 9.61606670e-03f, -7.00554848e-02f, -1.48866579e-01f, 1.34482995e-01f, 2.59133112e-02f, 8.97704139e-02f, 1.71933725e-01f,
  3.55398022e-02f, -3.26999016e-02f, 4.67720665e-02f, 6.23809397e-02f, -1.16491606e-02f, 5.02814502e-02f, -1.34210652e-02f, 5.78810973e-03f, -6.08818419e-02f, -8.03222880e-02f,
  -1.06746614e-01f, -2.57454127e-01f, -1.57743603e-01f, 1.22408941e-02f, 4.97906841e-02f, 5.41079305e-02f, 1.49486184e-01f, 4.62772697e-02f, 6.34910539e-02f, 4.35697734e-02f,
  4.94852848e-03f, 8.53307098e-02f, -3.28842290e-02f, 7.96134174e-02f, -2.88359150e-02f, -6.68578446e-02f, 3.66705726e-03f, 1.39874360e-02f, 3.00152972e-02f, 5.66401482e-02f,
  -3.59118655e-02f, -5.23154475e-02f, -1.99399106e-02f, -1.61265761e-01f, -1.90616418e-02f, -1.60690635e-01f, -8.57144892e-02f, -1.70711577e-01f, -8.47342387e-02f, -8.97799879e-02f,
  -3.48588191e-02f, -1.74917817e-01f, -9.46894735e-02f, -5.40720113e-02f, -6.38332590e-02f, -6.46429285e-02f, -1.10808715e-01f, -1.52332410e-01f, -1.38187408e-01f, -1.32305771e-01f,
  -8.75083953e-02f, -5.82856722e-02f, -6.86527789e-02f, -1.08850531e-01f, -7.19639286e-02f, -7.39351586e-02f, -1.58702984e-01f, -1.01660892e-01f, -1.82652343e-02f, -5.70265949e-02f,
  6.74022436e-02f, 1.34419724e-01f, 1.14501357e-01f, 4.43423353e-02f, 6.27520829e-02f, 1.23323631e-02f, 8.29620212e-02f, 1.62481859e-01f, 9.42576975e-02f, 1.22520067e-01f,
  2.46318076e-02f, 4.41456474e-02f, 1.13133736e-01f, 1.19103953e-01f, 1.30825296e-01f, 2.01671734e-01f, 4.46056947e-02f, 1.72805116e-01f, 3.86472121e-02f, 1.46952376e-01f,
  1.14435703e-01f, 8.19505677e-02f, 1.15978114e-01f, 1.40414327e-01f, 9.59664658e-02f, 1.52896404e-01f, 1.83550328e-01f, 8.22309777e-02f, 3.97660136e-02f, 7.18199685e-02f,
  -3.67643833e-01f, -2.34178994e-02f, -1.53275862e-01f, -1.08102962e-01f, -7.79248178e-02f, -9.33462530e-02f, -1.16718881e-01f, -3.89145426e-02f, -1.53315321e-01f, -1.01746842e-01f,
  -2.01532021e-01f, -1.29902055e-02f, -1.42949969e-01f, -1.42620102e-01f, -4.68275845e-02f, -1.50023311e-01f, -1.61701232e-01f, -1.40697765e-03f, -7.19002634e-02f, -9.68340859e-02f,
  -6.45962059e-02f, -1.33046582e-01f, -1.53176203e-01f, -1.79750711e-01f, -1.64677307e-01f, -4.41119149e-02f, -5.56354932e-02f, -1.79485306e-01f, -2.82657631e-02f, -1.38027281e-01f,
  -1.17826231e-01f, -8.91783163e-02f, 1.38910979e-01f, 9.92768705e-02f, 5.18394709e-02f, 5.93859032e-02f, -8.63924176e-02f, 7.47466879e-03f, 1.65950686e-01f, -3.79800238e-02f,
  9.30545032e-02f, 1.06754802e-01f, 1.96902417e-02f, 5.18173985e-02f, 4.68702987e-02f, 1.64180905e-01f, 2.14234367e-01f, 1.81419536e-01f, 4.23498871e-03f, -8.31668824e-03f,
  1.07367225e-01f, 3.98721769e-02f, -2.82033626e-02f, 1.74783155e-01f, 2.20445141e-01f, 1.37558505e-01f, 2.17058688e-01f, 1.66202366e-01f, 8.13417137e-02f, 3.40644300e-01f,
  9.77131873e-02f, -2.78399419e-03f, 1.86741930e-02f, 1.13811389e-01f, 6.47041649e-02f, 6.95487559e-02f, 9.05960500e-02f, 9.10943002e-02f, 8.44301730e-02f, 4.66506332e-02f,
  3.30967940e-02f, 5.22621349e-02f, 1.16223738e-01f, 1.14142127e-01f, 1.51041314e-01f, -9.78834555e-03f, 9.35766026e-02f, 1.43208072e-01f, 1.35149345e-01f, 6.24114238e-02f,
  1.73403531e-01f, -1.88424382e-02f, 5.47077954e-02f, 8.89754295e-02f, 8.92933980e-02f, 1.35213166e-01f, 7.97685608e-02f, 1.89703200e-02f, 4.96011823e-02f, 1.06599011e-01f,
  5.68673573e-02f, -4.09218073e-02f, -6.72102049e-02f, -8.62136558e-02f, -1.87793374e-01f, -1.20234475e-01f, -1.20875046e-01f, -1.42993823e-01f, -1.08853899e-01f, -1.75128356e-01f,
  -1.37330294e-01f, -9.23250541e-02f, -7.88801387e-02f, -1.31730378e-01f, -1.24781549e-01f, -1.63014233e-01f, -7.71953985e-02f, -6.75006360e-02f, -8.85554627e-02f, -6.95832446e-02f,
  -1.02889985e-01f, -1.36197716e-01f, -1.20813742e-01f, -1.70821756e-01f, -5.19169681e-02f, -1.02448300e-01f, -1.45351276e-01f, -1.78093642e-01f, -1.16984494e-01f, -1.72578350e-01f,
  -2.96718441e-02f, -1.07261986e-02f, 6.26528338e-02f, 6.52343929e-02f, 6.20977022e-02f, 1.00785382e-01f, 4.45501581e-02f, 1.38061672e-01f, 1.05622187e-01f, 7.16337636e-02f,
  7.02164415e-03f, 3.94640341e-02f, 3.88846174e-02f, 3.61672826e-02f, 2.55064736e-03f, 1.27497092e-01f, 1.45785147e-02f, -2.71157268e-03f, 1.90621521e-02f, 3.20394598e-02f,
  5.35792299e-03f, -9.07913968e-02f, -6.55335784e-02f, 5.95866516e-02f, 8.56147185e-02f, 7.72855356e-02f, -5.54007255e-02f, -9.94361378e-03f, -3.10715698e-02f, -1.07638873e-01f,
  -1.37577504e-01f, -3.47186811e-02f, 7.26278052e-02f, -1.57301035e-02f, 9.68352258e-02f, 1.59519702e-01f, 1.50956333e-01f, 2.34967798e-01f, 1.42499417e-01f, -7.79438540e-02f,
  -1.92020666e-02f, 1.73954535e-02f, 1.98059753e-01f, 1.74807027e-01f, 2.69800901e-01f, 1.08875625e-01f, 1.45705506e-01f, 1.86527714e-01f, 2.32395262e-01f, 7.48171806e-02f,
  5.48294634e-02f, 6.02372400e-02f, 1.31867096e-01f, 7.32390210e-02f, 4.84855585e-02f, 5.74097671e-02f, 4.67341766e-03f, 4.61534299e-02f, 1.02981992e-01f, 2.76217535e-02f,
  -1.04826964e-01f, 1.13868289e-01f, 1.37017965e-01f, -1.23187632e-03f, 3.82632539e-02f, 1.72960833e-02f, 1.19456038e-01f, 8.13460201e-02f, 1.04625091e-01f, 1.33984625e-01f,
  3.24737281e-02f, 3.55427898e-02f, 9.33514461e-02f, 1.15383286e-02f, 1.32089136e-02f, -1.34914676e-02f, 1.32056281e-01f, 3.04877907e-02f, 1.20222203e-01f, 8.47995572e-04f,
  -3.71293686e-02f, 9.30124894e-02f, 1.06957071e-01f, 1.81591243e-01f, 1.65597707e-01f, 8.70549530e-02f, 1.18714042e-01f, 8.32325295e-02f, 1.14596933e-01f, 2.91241128e-02f,
  -1.01962179e-01f, 1.09464908e-02f, -6.81410432e-02f, 8.10339767e-03f, -2.73425542e-02f, -1.48200002e-02f, 1.93840154e-02f, -4.76403162e-02f, -3.65607589e-02f, -1.34479165e-01f,
  -8.86831284e-02f, -5.97530566e-02f, -5.05159944e-02f, 1.86551909e-03f, -2.49103699e-02f, -7.51294009e-03f, 1.46406945e-02f, -5.69722764e-02f, -2.49180067e-02f, 2.37075854e-02f,
  -7.60218129e-02f, -5.21144830e-02f, -9.06631798e-02f, -4.49659885e-04f, -1.03631549e-01f, 1.33852456e-02f, -6.25816435e-02f, -1.03767984e-01f, -9.73068550e-02f, -1.41145259e-01f,
  6.04828596e-02f, 1.56585172e-01f, -7.50482306e-02f, 3.74908224e-02f, -2.47041434e-02f, 3.26951444e-02f, 8.15938339e-02f, -7.30306888e-03f, 1.55147672e-01f, 9.10597593e-02f,
  4.89631726e-04f, 9.50734764e-02f, 5.29393330e-02f, -3.02857999e-02f, -2.79560890e-02f, -4.68329489e-02f, 2.78996546e-02f, 9.51028541e-02f, 1.12114035e-01f, 2.55016680e-03f,
  5.68739176e-02f, -3.17672379e-02f, -1.22226842e-01f, -5.84569934e-04f, -7.79704154e-02f, -6.80363104e-02f, -3.51710878e-02f, -7.07096681e-02f, 3.48898163e-03f, -1.28302127e-01f,
  -1.48193866e-01f, -4.58858348e-02f, -2.27509558e-01f, -1.05702020e-01f, -3.84082198e-02f, -2.50725877e-02f, 8.03651009e-03f, -6.39785156e-02f, -7.72519410e-02f, -5.05913161e-02f,
  -4.77365358e-03f, -1.02790020e-01f, -5.05212583e-02f, -9.57734436e-02f, -1.32511422e-01f, -1.81975976e-01f, -1.99022427e-01f, -2.73301750e-01f, -1.42072603e-01f, -1.84205592e-01f,
  -1.70558006e-01f, -1.31617039e-01f, -2.18367055e-01f, -2.09116116e-01f, -1.37247428e-01f, -1.14961281e-01f, -7.71170706e-02f, -1.69130161e-01f, -1.48918450e-01f, -8.52818862e-02f,
  -1.68777853e-01f, -9.55420211e-02f, -5.54399937e-02f, 4.44820412e-02f, -5.76806776e-02f, -6.98684156e-02f, 2.79886648e-02f, 1.13552138e-02f, 3.65855685e-03f, 2.90181711e-02f,
  -2.40999926e-03f, -6.27894253e-02f, -8.47075507e-02f, -5.60620949e-02f, -6.47538453e-02f, 5.33966981e-02f, -4.72625084e-02f, -1.02453358e-01f, -9.51144099e-02f, -8.35925639e-02f,
  -3.04538682e-02f, 8.37893113e-02f, 7.47185796e-02f, 8.05509314e-02f, 1.76335927e-02f, 9.43633448e-03f, 4.63010743e-02f, 8.00854191e-02f, 5.43601625e-03f, -8.71361978e-03f,
  1.60578266e-02f, 3.50820692e-03f, 4.95172702e-02f, 1.18785076e-01f, 1.86945014e-02f, 1.22436292e-01f, 1.41859613e-02f, 3.47536430e-02f, 4.04904373e-02f, -1.17490012e-02f,
  2.48613600e-02f, 6.15600906e-02f, -7.11356774e-02f, -9.72304568e-02f, -1.60424586e-03f, 2.70165373e-02f, 8.76027197e-02f, 1.52642955e-03f, -3.37353274e-02f, 6.97868597e-03f,
  1.47265093e-02f, 3.65655906e-02f, 8.32015723e-02f, 8.22140649e-02f, -5.11178225e-02f, 3.29833999e-02f, 7.21502900e-02f, 2.97967363e-02f, 9.09643918e-02f, 7.89701194e-03f,
  4.24540192e-02f, 4.82855365e-03f, -7.26030692e-02f, -1.17211103e-01f, -2.47414298e-02f, 1.92881003e-02f, -3.22959721e-02f, -1.12583406e-01f, -1.84118748e-02f, -4.36189398e-02f,
  -5.83488904e-02f, -1.10664673e-01f, -1.19092107e-01f, -2.07874086e-02f, -3.41234803e-02f, 1.09081259e-02f, -2.73978524e-02f, -9.66602415e-02f, -5.88744171e-02f, 7.97138661e-02f,
  -5.47181591e-02f, -1.74792577e-02f, 1.05822638e-01f, 1.14489004e-01f, 6.38506711e-02f, 4.99384515e-02f, -2.76719015e-02f, -2.32449565e-02f, 9.52095315e-02f, -6.59477487e-02f,
  -3.09403867e-01f, -5.97181171e-02f, 5.74761303e-03f, -1.41377002e-01f, 7.73329958e-02f, 6.10616952e-02f, 6.86651617e-02f, -9.99423712e-02f, 6.30693063e-02f, 6.48318604e-02f,
  1.45900205e-01f, 1.28778353e-01f, 1.48243815e-01f, 8.61590803e-02f, -4.49357275e-03f, 6.32463470e-02f, 1.74767803e-02f, 8.37455466e-02f, 9.76781622e-02f, 1.65331572e-01f,
  8.02567229e-02f, -8.23501050e-02f, -1.99622259e-01f, 8.00444335e-02f, 1.08940937e-01f, 1.10579677e-01f, 1.55507391e-02f, 9.41286050e-03f, 1.03196748e-01f, 2.61317968e-01f,
  9.53943580e-02f, -2.05913514e-01f, 1.18451379e-01f, 3.60926520e-03f, -1.35338241e-02f, 1.03883356e-01f, 4.72977012e-02f, 2.05179229e-02f, 1.10695988e-01f, 1.08875833e-01f,
  1.14434101e-01f, 1.08669631e-01f, 1.57000661e-01f, 5.07577471e-02f, 3.80654186e-02f, 1.63889751e-02f, 3.86164226e-02f, -5.63044287e-02f, -2.96900366e-02f, 1.51570484e-01f,
  6.16851859e-02f, 8.39163084e-03f, -5.81337921e-02f, 5.96527271e-02f, 6.18619425e-03f, 2.10311376e-02f, 5.12789525e-02f, 7.27525800e-02f, -3.97194177e-02f, 1.52687291e-02f,
  8.52162542e-04f, 2.45215800e-02f, -9.87458602e-02f, -7.02661052e-02f, -7.73123652e-02f, -6.58227429e-02f, 4.63248827e-02f, -6.66005164e-02f, -5.67991398e-02f, -6.42940775e-02f,
  -1.02626324e-01f, -1.03420369e-01f, -7.90626034e-02f, 1.45988939e-02f, -2.62811016e-02f, -3.31587978e-02f, 9.16115195e-02f, -6.03748560e-02f, -9.39941555e-02f, -4.20808233e-02f,
  -2.66625080e-02f, 7.46994242e-02f, 3.74125876e-02f, 5.94620481e-02f, -2.23052688e-02f, -6.66406304e-02f, -2.49063615e-02f, -3.38392705e-02f, -7.85514265e-02f, -1.98522974e-02f,
  -5.45458235e-02f, -1.48139641e-01f, 1.85023829e-01f, 1.40310511e-01f, 7.21387044e-02f, 1.15168452e-01f, 8.28337576e-03f, 1.23138145e-01f, 1.13478526e-01f, 8.37621838e-02f,
  1.02900051e-01f, 2.52010990e-02f, 6.69305772e-02f, 1.23206474e-01f, 5.92854582e-02f, 9.69574824e-02f, 2.43105497e-02f, 7.56632462e-02f, 9.95846912e-02f, 3.19085196e-02f,
  1.34112430e-03f, 1.25507070e-02f, -1.77196022e-02f, 4.64601740e-02f, -1.23297842e-02f, -1.03791822e-02f, 1.43332541e-01f, 7.13890195e-02f, 2.59679500e-02f, 2.98964493e-02f,
  1.98999539e-01f, -1.04530267e-01f, 1.92153770e-02f, 3.98065150e-02f, -2.36043446e-02f, 1.06648155e-01f, 1.34958237e-01f, 1.64055794e-01f, 2.95333415e-02f, -3.56032252e-02f,
  -1.80890888e-01f, -1.23955309e-01f, 8.32335353e-02f, 9.65826437e-02f, 1.58441618e-01f, 1.33044854e-01f, 2.19660759e-01f, 2.40788668e-01f, 2.27683455e-01f, 9.84805152e-02f,
  9.42741055e-03f, -2.43308507e-02f, 6.27796128e-02f, 6.35633841e-02f, 2.74197385e-03f, 3.09244134e-02f, 1.52159100e-02f, -8.82294476e-02f, 5.82065098e-02f, -1.52042601e-02f,
  -7.97944665e-02f, -1.04154907e-02f, 1.39580136e-02f, -6.12682477e-02f, -1.16299823e-01f, 1.19092187e-03f, 2.86978073e-02f, 2.70403214e-02f, 1.58964433e-02f, -2.67431810e-02f,
  -5.86453639e-02f, -1.69854437e-03f, -7.15917423e-02f, -1.03719784e-02f, -5.79172075e-02f, -1.11993201e-01f, -7.95102194e-02f, 7.75387436e-02f, -7.91343674e-02f, 1.75154768e-02f,
  -1.26748160e-01f, 4.95305583e-02f, 5.12650721e-02f, -7.41248764e-03f, -5.34686446e-03f, 1.94010455e-02f, -1.81535427e-02f, 3.25655863e-02f, 5.39098307e-02f, -8.31526220e-02f,
  -3.40868235e-02f, 7.43881837e-02f, 5.73481917e-02f, 6.55543879e-02f, -2.41435692e-02f, 4.55331914e-02f, 2.41034869e-02f, 7.84570500e-02f, 4.30802219e-02f, 1.92691237e-02f,
  4.18393873e-02f, 1.45826396e-02f, 8.41292888e-02f, 1.14425473e-01f, 1.00183375e-01f, 5.35801165e-02f, 1.90621272e-01f, 5.32624498e-02f, 1.07022673e-01f, 8.01538974e-02f,
  1.20910950e-01f, 1.08208835e-01f, 5.78892939e-02f, 1.19652934e-01f, 6.92645162e-02f, 1.16420098e-01f, 6.67128712e-02f, 1.46274894e-01f, 9.82674062e-02f, 7.02463090e-02f,
  -1.60583243e-01f, -1.33816630e-01f, 4.14462723e-02f, 4.56967726e-02f, 3.71430814e-02f, -1.05648428e-01f, -8.56830552e-03f, 8.80447961e-03f, -1.07838854e-01f, 1.27907079e-02f,
  3.14051509e-02f, -6.09471649e-02f, -4.41248752e-02f, -3.51727940e-03f, 3.76786999e-02f, 1.13809993e-02f, 3.58080938e-02f, 1.01775140e-01f, -2.68962444e-03f, -1.18020818e-01f,
  7.23703811e-03f, 1.03825055e-01f, 5.59460074e-02f, 4.66799103e-02f, 9.87075344e-02f, 3.68855931e-02f, 4.68709208e-02f, 1.31097630e-01f, 3.58149074e-02f, 9.96642634e-02f,
  3.02146167e-01f, 2.20481440e-01f, 1.15830518e-01f, 1.75924301e-01f, 3.32461521e-02f, 8.72129947e-02f, 2.35691890e-01f, 2.05800548e-01f, 5.17016836e-02f, 2.26616755e-01f,
  7.34067708e-02f, 4.82008271e-02f, 7.31025413e-02f, 1.14128016e-01f, 2.32566506e-01f, 2.28286192e-01f, 1.91851556e-01f, 2.41614848e-01f, 1.04487248e-01f, 8.94273818e-02f,
  7.43410513e-02f, 1.63005397e-01f, 1.13179162e-01f, 1.63722441e-01f, 4.75258231e-02f, 1.94827840e-02f, 2.06236225e-02f, 1.40145626e-02f, 1.45547152e-01f, 7.61780664e-02f,
  -1.28802642e-01f, 2.14112140e-02f, 8.24597199e-03f, 1.35275021e-01f, -6.29567803e-05f, 1.09777242e-01f, 8.19443446e-03f, -2.23789848e-02f, 3.84668149e-02f, 8.10159594e-02f,
  -3.95985097e-02f, 1.22553639e-01f, -2.73056813e-02f, 7.59515241e-02f, -4.75033335e-02f, 9.56693888e-02f, -7.75926281e-04f, 7.98479468e-03f, 3.23401317e-02f, 8.71295780e-02f,
  6.14791624e-02f, 1.50278807e-01f, 2.05891915e-02f, -3.46279144e-02f, -5.64806908e-02f, 2.99623292e-02f, 3.77233364e-02f, 1.63040310e-02f, 8.75941664e-02f, 1.43565893e-01f,
  -5.73634990e-02f, -8.51227418e-02f, -1.19230449e-01f, -8.05575624e-02f, -3.38199474e-02f, -7.63748959e-02f, -1.45851523e-02f, -6.15571737e-02f, -3.66420448e-02f, -5.00868373e-02f,
  -6.24348670e-02f, -1.05374768e-01f, -1.10204466e-01f, -1.90305468e-02f, -1.40269160e-01f, 1.27111506e-02f, 6.97312802e-02f, -4.40224297e-02f, 1.45036401e-02f, -1.58110224e-02f,
  -4.90237437e-02f, -2.30656043e-02f, -2.36753765e-02f, -1.16173483e-01f, -2.35555116e-02f, -1.49754420e-01f, -3.85791548e-02f, -1.41508728e-02f, -8.03384855e-02f, -6.21825270e-02f,
  -8.15098435e-02f, 9.55602899e-02f, 4.04771380e-02f, 6.91858754e-02f, 7.59307444e-02f, 3.55278179e-02f, 1.34889022e-01f, 1.03049591e-01f, 3.99113446e-02f, 2.31980532e-02f,
  1.02159299e-01f, 6.61437362e-02f, 1.35743052e-01f, 3.10308002e-02f, 2.71578711e-02f, 3.25682387e-02f, 1.71026886e-01f, 7.11296797e-02f, 1.10986024e-01f, 9.84422788e-02f,
  1.03981808e-01f, 2.26504147e-01f, 9.41587314e-02f, 1.92756414e-01f, 1.28876552e-01f, 1.04698457e-01f, 1.22437790e-01f, -1.67244975e-03f, 1.19734399e-01f, 1.43058017e-01f,
  -2.42826179e-01f, 1.05565384e-01f, 9.37086716e-02f, -1.43983051e-01f, 1.96637344e-02f, 9.03598219e-02f, 2.01332778e-01f, 1.78641289e-01f, 1.15869626e-01f, -6.57934844e-02f,
  1.72258131e-02f, 1.09981738e-01f, 1.80968672e-01f, 1.15398623e-01f, 1.94895864e-01f, 1.50001690e-01f, 8.08186457e-02f, 4.84040156e-02f, 1.64753228e-01f, 7.06477370e-03f,
  1.18407004e-01f, 5.62922470e-02f, -5.55775277e-02f, 7.24460259e-02f, 5.90954572e-02f, 1.15550496e-01f, -9.13029537e-03f, 4.40662839e-02f, 9.01295170e-02f, -1.06274560e-02f,
  -8.78847539e-02f, -1.13057114e-01f, 1.38801888e-01f, 6.94476590e-02f, 6.57480434e-02f, 2.34266594e-02f, 7.94308111e-02f, -3.24098481e-04f, 3.01275216e-02f, 9.09974724e-02f,
  4.38717343e-02f, 7.17709437e-02f, 1.05530713e-02f, 3.40874121e-02f, -3.05197611e-02f, 6.75977245e-02f, 2.21223617e-03f, 1.08417220e-01f, 4.48819995e-02f, 5.05257733e-02f,
  3.02884653e-02f, -1.64487101e-02f, 2.63488907e-02f, 1.29316941e-01f, 3.29712518e-02f, -3.79981995e-02f, 6.65046573e-02f, 8.82457495e-02f, 1.02196209e-01f, 1.81334075e-02f,
  -4.25919369e-02f, 3.39848432e-03f, 4.11692038e-02f, -5.53155728e-02f, -3.67915630e-02f, 3.80833708e-02f, -2.19500740e-03f, 3.82137322e-03f, -1.43748876e-02f, 1.25896418e-02f,
  1.89119168e-02f, -4.49692756e-02f, 2.37994883e-02f, -1.08839534e-01f, 3.14068794e-02f, -2.87269801e-02f, 1.49481418e-02f, -2.23128814e-02f, 2.80492958e-02f, -6.22572899e-02f,
  -9.65148136e-02f, 6.68558255e-02f, 4.24318053e-02f, 2.50549410e-02f, -3.83807123e-02f, -1.31308017e-02f, -9.78308991e-02f, 6.15805797e-02f, -6.22208342e-02f, -6.30653724e-02f,
  5.59550114e-02f, 1.28209084e-01f, -6.76919371e-02f, -1.20482892e-02f, 5.16773621e-03f, 1.49114192e-01f, 3.85450907e-02f, 5.80345728e-02f, 1.27196193e-01f, -5.14892209e-03f,
  2.87497714e-02f, 6.75417408e-02f, 7.00496417e-03f, 6.36147801e-03f, -1.68945007e-02f, -1.70107558e-02f, 4.95826267e-02f, 1.68451015e-02f, 4.52705063e-02f, 4.50143442e-02f,
  1.45709679e-01f, 8.06453675e-02f, 2.02599093e-02f, -1.02642002e-02f, 7.90278614e-02f, 5.78976497e-02f, 1.13863591e-02f, 1.24889709e-01f, 5.52951209e-02f, 9.46003273e-02f,
  7.93711096e-02f, 1.89322740e-01f, 1.73568755e-01f, 3.78627307e-03f, 6.17351942e-02f, -8.24938789e-02f, -6.64285868e-02f, -3.04556396e-02f, -1.10527642e-01f, 7.67350942e-02f,
  -5.33407517e-02f, -1.58347785e-01f, -5.19083366e-02f, 1.04976017e-02f, 1.55241443e-02f, 7.18734115e-02f, 2.01238737e-01f, 6.53714836e-02f, -1.66649908e-01f, -9.64107439e-02f,
  -9.06550735e-02f, 2.70478725e-02f, 5.39030805e-02f, 3.01233749e-03f, 1.18773133e-01f, 5.28187640e-02f, 6.78062215e-02f, 8.05329755e-02f, 5.71592003e-02f, 2.74267793e-01f,
  1.62022635e-01f, 1.11251369e-01f, -8.95731151e-02f, -6.48012534e-02f, 1.13514759e-01f, 4.45248149e-02f, -5.18676490e-02f, 5.34156114e-02f, 3.45453285e-02f, -5.63270710e-02f,
  -5.54908486e-03f, 2.72647315e-03f, -3.18443030e-02f, 4.73842695e-02f, 1.23993242e-02f, 4.43508960e-02f, -7.79392850e-03f, 5.64351492e-03f, 5.71913980e-02f, 1.82350297e-02f,
  9.96768847e-02f, 7.06808418e-02f, 6.74992874e-02f, 6.38896003e-02f, -1.59966331e-02f, 6.05465621e-02f, 9.46701989e-02f, 7.40704909e-02f, -7.69615024e-02f, -4.80087660e-03f,
  -1.33097827e-01f, 2.47970968e-02f, 1.00628331e-01f, 6.91159591e-02f, 8.66162926e-02f, 1.99380387e-02f, 1.07368067e-01f, 4.92339768e-02f, 3.67975309e-02f, 8.18552524e-02f,
  8.91467556e-02f, 4.83947881e-02f, 4.69652265e-02f, 5.98802082e-02f, 3.57832834e-02f, 7.49126673e-02f, 1.34755760e-01f, 4.57013212e-02f, 1.01008542e-01f, 9.65782180e-02f,
  8.89725983e-02f, 1.22269757e-01f, 1.09004892e-01f, 3.79187614e-02f, 5.14958948e-02f, 1.07736982e-01f, 4.15059105e-02f, 4.02506106e-02f, 5.98286428e-02f, 1.02411956e-01f,
  -2.04875097e-01f, -1.06291607e-01f, -1.27864450e-01f, -1.04781941e-01f, -3.01573258e-02f, 3.93704996e-02f, 3.48170251e-02f, -3.84454131e-02f, 2.83843298e-02f, 2.10188869e-02f,
  2.09165108e-03f, -6.37745038e-02f, -3.94102037e-02f, -6.59363046e-02f, -5.13235033e-02f, -1.04236640e-01f, -1.52473561e-02f, -5.47357574e-02f, 5.06753698e-02f, -2.95080780e-03f,
  -5.19336499e-02f, -6.17514290e-02f, -1.43252522e-01f, -9.98349115e-02f, -8.69005099e-02f, -1.63842633e-01f, -1.33225787e-02f, -9.64809209e-02f, -5.56474291e-02f, -6.24211095e-02f,
  2.01092958e-01f, -2.32128933e-01f, -3.78519595e-02f, -4.10194807e-02f, 2.56720018e-02f, 6.03663130e-03f, -1.60092413e-01f, -5.31729534e-02f, 7.34249726e-02f, -2.95030754e-02f,
  -6.44405261e-02f, 8.50874484e-02f, 2.06667274e-01f, 9.36417505e-02f, 1.88254118e-01f, -3.02528180e-02f, -7.68595785e-02f, 1.80559397e-01f, 2.09458336e-01f, 1.78422302e-01f,
  3.71776111e-02f, 1.15051053e-01f, 8.00832808e-02f, 9.68621820e-02f, -1.23225771e-01f, 1.29203558e-01f, -3.74085978e-02f, 3.76517735e-02f, -4.63095773e-03f, -1.10243291e-01f,
  -8.73808488e-02f, -9.11315754e-02f, 1.76978558e-01f, 1.13226779e-01f, 3.93412113e-02f, 4.43174727e-02f, 2.34836768e-02f, 7.94225186e-02f, 2.62303147e-02f, 1.33892510e-03f,
  6.30739937e-03f, 5.28433286e-02f, -5.76191209e-02f, -3.05682775e-02f, -9.06799268e-03f, -1.30998082e-02f, -1.57292224e-02f, 1.39645964e-01f, -2.38815742e-03f, 4.77859601e-02f,
  8.03709123e-03f, -1.04715772e-01f, -1.02479868e-01f, -5.00551891e-04f, 5.33542782e-03f, 1.53753042e-01f, -8.24262574e-02f, 4.84959260e-02f, 9.17711779e-02f, -1.34071946e-01f,
  -6.62936345e-02f, 4.45054332e-03f, 5.88142537e-02f, -3.35336737e-02f, -6.21806495e-02f, 2.90157124e-02f, -2.09643189e-02f, -7.27354363e-02f, 6.42781928e-02f, -6.43215775e-02f,
  4.98072281e-02f, -9.76344198e-02f, 2.16112155e-02f, -4.85565700e-03f, -4.86279046e-03f, 6.72010006e-04f, -3.39963436e-02f, 2.99255028e-02f, -6.08679652e-02f, -1.14619225e-01f,
  2.54261773e-02f, -2.73735225e-02f, 5.27333580e-02f, -1.10500129e-02f, -1.84802823e-02f, -5.32203764e-02f, -1.15338704e-02f, 5.24878986e-02f, -8.48975440e-04f, -4.59672287e-02f,
  1.31124314e-02f, 9.73933935e-02f, 6.12999536e-02f, 8.70394856e-02f, -1.17961280e-01f, 7.27655962e-02f, -4.55878973e-02f, -1.61189586e-02f, -2.80316304e-02f, -7.14995191e-02f,
  -4.51840535e-02f, 6.10322170e-02f, 5.56536503e-02f, -6.38019219e-02f, 3.00275311e-02f, -2.92689502e-02f, 3.89495715e-02f, 8.04159343e-02f, 1.15619577e-01f, -1.02039076e-01f,
  2.33067386e-02f, -1.61359925e-02f, 1.27901407e-02f, 1.83321126e-02f, 7.23033622e-02f, 9.94696394e-02f, 4.40783091e-02f, -1.04661137e-01f, 2.45782826e-02f, -7.71316290e-02f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.64537871e-01f, -2.26102039e-01f, 5.65341376e-02f, 1.77724734e-01f, 2.70824730e-01f, 1.83860466e-01f, 4.95822281e-02f, 2.02912628e-03f, 1.62710726e-01f, 6.83298185e-02f,
  -1.88795105e-01f, -1.33958802e-01f, -6.17473423e-02f, -7.23917112e-02f, -1.57385934e-02f, 1.71493396e-01f, 2.45738089e-01f, 6.90309256e-02f, 1.20117720e-02f, 9.83340964e-02f,
  2.04328597e-01f, 8.73402506e-02f, 1.04628064e-01f, 8.68697558e-03f, 1.27241924e-01f, 1.40088692e-01f, 5.64364865e-02f, 7.30087906e-02f, 5.13445213e-02f, 1.68707117e-01f,
  -2.27683172e-01f, -2.35700935e-01f, 8.83349217e-03f, -7.11350143e-02f, -6.32255226e-02f, -1.51717052e-01f, 8.92649032e-03f, -8.19626600e-02f, -1.23795673e-01f, 3.14577855e-02f,
  -2.96500400e-02f, -1.03889637e-01f, -1.85884032e-02f, -4.71476279e-02f, 1.50139350e-02f, -1.19367987e-01f, -7.59121403e-02f, -2.67472006e-02f, -1.42688736e-01f, -2.02292085e-01f,
  -1.28751650e-01f, 1.04196565e-02f, -5.10260239e-02f, -8.82784352e-02f, -1.53853983e-01f, -9.27438885e-02f, -1.52367041e-01f, -1.90757196e-02f, -8.62933472e-02f, -3.13375192e-03f,
  3.39188101e-03f, -3.10319364e-02f, 7.97781814e-03f, 1.20970346e-02f, 6.95428997e-02f, 6.16711564e-02f, 1.67023003e-01f, 5.07279336e-02f, 6.35583177e-02f, 1.49744749e-01f,
  1.35629192e-01f, -2.19138600e-02f, 6.85679168e-02f, 1.60844699e-01f, 1.09877385e-01f, 1.05920136e-02f, 5.59565201e-02f, -5.45580946e-02f, 2.88157910e-02f, 2.80717164e-02f,
  5.70428856e-02f, 1.07501648e-01f, 9.07097906e-02f, 6.83951676e-02f, -1.08158374e-02f, -1.59016345e-02f, 1.39706805e-01f, 1.00665964e-01f, 3.47212963e-02f, 7.59586021e-02f,
  3.35908055e-01f, -5.03804535e-02f, 1.54302180e-01f, -3.24980989e-02f, 8.92222971e-02f, -6.23708032e-03f, 7.95198679e-02f, 7.91302696e-03f, -1.67707130e-02f, 1.13393560e-01f,
  -7.03488812e-02f, -4.44786251e-02f, 3.63321509e-03f, 3.34687717e-02f, 8.26462954e-02f, 8.40432122e-02f, -2.37621460e-02f, -2.49658842e-02f, -4.00039181e-02f, 1.43520227e-02f,
  9.21851993e-02f, 1.39891073e-01f, 1.39029011e-01f, 9.76905301e-02f, 6.46046028e-02f, 1.20791085e-01f, -4.92000300e-03f, 7.93607309e-02f, 3.19548734e-02f, 8.24044868e-02f,
  5.63629210e-01f, 2.71505117e-01f, 1.80618599e-01f, 1.09448455e-01f, 1.39058620e-01f, 2.19697431e-01f, 2.33617932e-01f, 2.21588939e-01f, 1.51672587e-01f, 1.28885642e-01f,
  1.82370290e-01f, 5.05280569e-02f, 4.40926217e-02f, 1.12018973e-01f, 1.65529996e-01f, -1.93093214e-02f, -5.20014465e-02f, 9.19368863e-02f, 1.62916690e-01f, 5.41589484e-02f,
  7.85701629e-03f, 8.26970786e-02f, 6.52933642e-02f, -1.88225508e-02f, -8.54562074e-02f, 4.37427573e-02f, -3.47288176e-02f, -2.10736673e-02f, -7.11926296e-02f, -2.25767761e-01f,
  -2.45061606e-01f, 2.19490737e-01f, -5.18524684e-02f, -5.02158031e-02f, -2.02579405e-02f, -7.34852627e-02f, 1.88991055e-02f, -1.42141730e-01f, -1.86328351e-01f, -1.40187249e-01f,
  -6.72580376e-02f, -9.31118801e-03f, -7.66165480e-02f, -5.85427694e-02f, -2.21619606e-02f, -2.74659656e-02f, 5.41388057e-02f, 3.94236967e-02f, -7.60356337e-02f, 3.87726612e-02f,
  -1.85672659e-02f, 4.21403050e-02f, 4.50328849e-02f, -2.28917859e-02f, 8.63261297e-02f, -6.20061532e-02f, -3.22985984e-02f, 3.15543376e-02f, 3.03487387e-02f, -6.59042820e-02f,
  8.50018486e-02f, 2.54069939e-02f, 1.06140450e-01f, 1.91827789e-01f, 5.83555028e-02f, -1.20374691e-02f, -9.10929590e-03f, -6.04099259e-02f, 1.61350340e-01f, 1.02133051e-01f,
  -3.44297625e-02f, 2.19396409e-02f, 6.63072895e-03f, -1.29270637e-02f, 3.53702717e-03f, 3.36743258e-02f, 7.64959073e-03f, 2.95889354e-03f, -1.59283534e-01f, -2.07536910e-02f,
  -4.68421802e-02f, -1.22180209e-01f, -3.09106661e-03f, -1.01314574e-01f, -3.65835615e-02f, -2.77852127e-03f, -7.53065795e-02f, -1.09574229e-01f, 1.99991260e-02f, -1.19596802e-01f,
  -1.13320276e-01f, 1.42989665e-01f, -1.04729183e-01f, -2.44742855e-02f, -8.89907926e-02f, 2.57436093e-02f, 1.71230491e-02f, -8.46860036e-02f, -9.11477730e-02f, -3.87922078e-02f,
  3.90798934e-02f, 5.01356870e-02f, -3.44593748e-02f, 9.06060040e-02f, 2.00690399e-03f, -5.18987924e-02f, 7.61763677e-02f, 1.23445444e-01f, -8.33741426e-02f, -2.62696780e-02f,
  -5.78122661e-02f, 1.14438273e-02f, 1.31864801e-01f, -5.29872207e-03f, -3.75857926e-04f, -2.91367080e-02f, -1.95602179e-02f, -7.70897865e-02f, 5.20018041e-02f, 1.25245169e-01f,
  5.39509952e-01f, 1.40966758e-01f, -7.90356100e-02f, 2.69537121e-01f, -2.08394915e-01f, -2.70785093e-01f, -4.80673015e-02f, 9.74688902e-02f, 5.43008670e-02f, 6.57631233e-02f,
  -1.74272493e-01f, -2.89175838e-01f, -1.35682628e-01f, -1.88219607e-01f, -2.20239367e-02f, 1.44604117e-01f, 1.08400129e-01f, -5.29843979e-02f, -2.86057442e-01f, -2.02783570e-01f,
  -1.63478881e-01f, 4.74525839e-02f, 2.04765290e-01f, 7.87228867e-02f, 1.23794213e-01f, -1.20945901e-01f, 1.00793332e-01f, 8.00214484e-02f, -1.31971389e-01f, 1.56957507e-01f,
  1.09660849e-02f, 2.02763736e-01f, -1.88492447e-01f, -5.98238930e-02f, 1.33493114e-02f, -1.99670121e-02f, -1.49925455e-01f, -1.37866184e-03f, -8.71852934e-02f, -4.67944294e-02f,
  -1.46854654e-01f, -1.66233838e-01f, -6.42618984e-02f, -9.55620781e-02f, -4.21577729e-02f, -1.77616905e-02f, 7.43076019e-03f, -5.10290917e-03f, -5.30450419e-02f, -5.87977357e-02f,
  -2.01499760e-01f, -1.49498165e-01f, -3.95572698e-03f, -6.25891909e-02f, -5.94367925e-03f, -1.33338451e-01f, -1.01668267e-02f, 1.35997348e-02f, -1.74953863e-02f, 1.90383092e-01f,
  -1.27631426e-01f, -7.75618702e-02f, -7.81746730e-02f, 8.33500829e-03f, 3.61556225e-02f, -4.98416424e-02f, 6.62335800e-03f, -5.55122122e-02f, -9.89668667e-02f, -8.26690793e-02f,
  -9.64974761e-02f, 5.02847992e-02f, -7.62942135e-02f, 2.02902500e-02f, -6.79850802e-02f, -5.15717156e-02f, 1.27142519e-02f, 1.30613402e-01f, -2.34818216e-02f, 5.14638163e-02f,
  1.01003358e-02f, 4.22970206e-02f, -2.61687022e-02f, -2.39236243e-02f, 1.37591548e-02f, -5.38360365e-02f, 2.69720294e-02f, -1.24855720e-01f, -3.34903002e-02f, 4.75449525e-02f,
  1.47045702e-01f, -2.02511191e-01f, -5.25779203e-02f, 1.58449207e-02f, 1.14900582e-01f, 1.40487282e-02f, -2.35869903e-02f, 4.81735542e-02f, -3.86381708e-02f, -2.04436984e-02f,
  -1.49043247e-01f, 1.00048501e-02f, -5.92588969e-02f, 1.16347391e-02f, -9.59833991e-03f, 3.12489574e-03f, -6.85281307e-02f, 6.07348084e-02f, -7.67112747e-02f, 5.97490172e-04f,
  1.05272979e-01f, 1.61026746e-01f, 1.35337532e-01f, 1.53806314e-01f, -3.33344601e-02f, -1.14879999e-02f, 2.03620736e-02f, -4.77032512e-02f, -5.34752719e-02f, 2.36414507e-01f,
  -4.53679025e-01f, 2.08056748e-01f, -1.02598764e-01f, -5.54733217e-01f, -2.61493027e-01f, 2.52333712e-02f, 2.78714985e-01f, -1.17170505e-01f, -3.30700248e-01f, 7.12095201e-02f,
  1.63002029e-01f, -6.92552105e-02f, -9.53227058e-02f, 8.94880071e-02f, 2.30539605e-01f, 2.73660541e-01f, 3.45417112e-02f, 1.83385760e-02f, 1.91160962e-02f, 5.05993925e-02f,
  8.73160064e-02f, -1.66254684e-01f, -1.82701081e-01f, -1.71595991e-01f, -2.36347765e-01f, -1.29483089e-01f, -1.38559565e-01f, -1.26753882e-01f, 1.22533582e-01f, -1.01814739e-01f,
  1.91821277e-01f, -1.78257167e-01f, 1.34254163e-02f, -1.33683369e-01f, -1.26092315e-01f, -2.96223722e-02f, -3.31116728e-02f, -1.54030830e-01f, -3.70684788e-02f, -3.17890719e-02f,
  -1.09625891e-01f, -5.15850261e-02f, -1.33129120e-01f, 1.66624524e-02f, -9.93788540e-02f, -1.05018184e-01f, -1.13407001e-01f, -4.19828855e-02f, -9.37477872e-02f, 4.87397797e-02f,
  7.03218281e-02f, 1.37453843e-02f, -2.29904242e-02f, 2.48515252e-02f, -1.52347134e-02f, 3.40456050e-03f, 2.90701371e-02f, 5.20025231e-02f, 3.09606805e-03f, -9.24572051e-02f,
  -3.19206575e-03f, 5.68246469e-02f, -5.73175289e-02f, -9.61346403e-02f, 3.93399894e-02f, 6.98977485e-02f, -4.82952408e-02f, 4.34400514e-02f, -2.03374587e-03f, -1.74731463e-02f,
  -6.41890690e-02f, 1.04841381e-01f, 3.89984883e-02f, -6.39368733e-03f, 6.74774579e-04f, -3.71743105e-02f, 1.35067508e-01f, 3.50678526e-02f, -1.06310174e-02f, 1.24668572e-02f,
  -2.61183623e-02f, -2.67119966e-02f, -7.44757429e-02f, 9.11973864e-02f, 8.68996009e-02f, -2.29186434e-02f, 3.14405165e-03f, 4.78300788e-02f, -7.63246343e-02f, -8.21179338e-03f,
  -6.68879375e-02f, 9.06808376e-02f, -7.37663731e-03f, -1.04266321e-02f, -8.07657018e-02f, -4.24466804e-02f, -4.80126627e-02f, -6.08278718e-03f, -3.78042199e-02f, 1.09370635e-03f,
  2.77186334e-02f, 3.86725441e-02f, 6.79588411e-05f, 5.90772135e-03f, -4.74380050e-03f, -3.35978754e-02f, 7.86380321e-02f, -4.59717102e-02f, 2.16137432e-02f, -3.05783912e-03f,
  1.37848765e-01f, 1.01858340e-01f, 1.43520057e-01f, 1.24456145e-01f, 7.41878450e-02f, 4.62576225e-02f, 1.54041663e-01f, 1.31833017e-01f, 1.48180991e-01f, 1.75293028e-01f,
  -3.69636975e-02f, -4.25211698e-01f, 3.36509407e-01f, -7.63064399e-02f, 1.70924217e-02f, -1.37995094e-01f, -2.86257446e-01f, -2.23345235e-01f, -1.66035146e-01f, -1.48764327e-01f,
  3.93703245e-02f, 3.49950314e-01f, 3.80259454e-01f, 2.11753085e-01f, 1.60867929e-01f, -8.50342810e-02f, 5.92746958e-03f, 3.57915848e-01f, 4.63203758e-01f, 2.35566664e-02f,
  -9.51530933e-02f, -6.15018569e-02f, 4.01368961e-02f, 2.72129085e-02f, -2.31414974e-01f, 8.54999274e-02f, 4.04031016e-03f, 1.85040031e-02f, -1.29256502e-01f, -2.39255261e-02f,
  1.77127510e-01f, -4.04089630e-01f, 1.77395374e-01f, -2.35860683e-02f, -6.58495398e-03f, -9.84213576e-02f, -1.33600235e-01f, 1.75228864e-02f, -6.13269284e-02f, -1.01069108e-01f,
  1.79933496e-02f, -3.52967903e-03f, -2.33634394e-02f, -1.73497498e-01f, -1.88654408e-01f, -9.41811129e-02f, -1.45009473e-01f, -8.09198841e-02f, -1.55314073e-01f, -1.07141107e-01f,
  -1.80398107e-01f, 9.44424700e-03f, 1.08156681e-01f, -6.24110363e-02f, -1.42706722e-01f, 2.24583641e-01f, -1.13798641e-01f, -1.06334209e-01f, -6.24398962e-02f, -1.35434330e-01f,
  -1.75248925e-02f, 9.56019834e-02f, -7.52673373e-02f, -5.33978408e-03f, 1.13548646e-02f, -3.73006873e-02f, 1.43012311e-02f, -9.46715623e-02f, 4.69017541e-03f, 6.07120134e-02f,
  3.14604230e-02f, 5.02478853e-02f, -3.54235582e-02f, -5.81056401e-02f, -1.01631852e-02f, 6.59835637e-02f, 1.78628135e-02f, 1.19180707e-02f, -5.67283854e-02f, -2.99351811e-02f,
  1.08751453e-01f, 4.93112244e-02f, 2.12079957e-02f, -4.86289673e-02f, -3.82673671e-03f, 7.91096985e-02f, -3.15525830e-02f, 5.11486307e-02f, 6.74448535e-02f, -6.79341629e-02f,
  1.17595896e-01f, 8.10306668e-02f, 4.93488088e-02f, 3.11365649e-02f, -1.72570497e-02f, -1.36046767e-01f, -4.45486009e-02f, -2.09484473e-02f, -8.70080143e-02f, -8.47104341e-02f,
  2.43474413e-02f, 8.35756510e-02f, -9.22941417e-02f, -5.84363267e-02f, 1.03431642e-01f, -5.68023995e-02f, -3.43915820e-02f, 2.76117697e-02f, -3.95445786e-02f, -1.06420495e-01f,
  -5.86267523e-02f, -7.94752538e-02f, 3.43470007e-01f, 1.01735383e-01f, -1.32976368e-01f, 2.06514940e-01f, 1.49400860e-01f, 5.66571206e-02f, 1.94828629e-01f, 1.99929997e-02f,
  3.56314898e-01f, -8.65442529e-02f, -1.77239984e-01f, 3.04426640e-01f, -7.89564103e-02f, -2.04869121e-01f, -2.21693337e-01f, -1.32380977e-01f, 1.53994769e-01f, 1.74315929e-01f,
  1.54174119e-01f, 1.10567525e-01f, 1.58536568e-01f, 1.87760051e-02f, -1.44109324e-01f, -3.96495163e-02f, 4.37918529e-02f, -1.78570509e-01f, -2.80116439e-01f, -2.67758399e-01f,
  -3.30820084e-02f, 1.76678121e-03f, -2.12352201e-02f, -3.59730199e-02f, 3.87798040e-03f, 7.37184286e-02f, 4.19902653e-02f, 4.63946834e-02f, -3.49047640e-03f, 7.37973675e-02f,
  2.64049787e-02f, -1.90867320e-01f, 7.16478750e-02f, 4.69312724e-03f, 4.35746834e-02f, 1.14627682e-01f, 4.96384837e-02f, -3.41604376e-04f, 1.25565037e-01f, 4.33553234e-02f,
  -3.84071134e-02f, -9.70306993e-03f, 3.73325514e-04f, -1.20491713e-01f, -3.80656794e-02f, -7.01690614e-02f, -1.53193489e-01f, -2.47953579e-01f, -8.84785354e-02f, -8.69787782e-02f,
  -3.95837389e-02f, -9.06062722e-02f, -7.93389976e-02f, -8.88217837e-02f, -2.46265978e-01f, -8.57128128e-02f, -1.27997026e-01f, -2.83852875e-01f, -8.23581517e-02f, -4.56405524e-03f,
  1.11553311e-01f, 2.47985840e-01f, 1.69198066e-01f, 7.50864372e-02f, 8.56534019e-02f, 1.04298271e-01f, -2.85295658e-02f, 1.31302420e-02f, 5.32625653e-02f, -3.28140222e-02f,
  3.89485843e-02f, 6.55494109e-02f, -1.13575779e-01f, -2.15799157e-02f, 6.65242597e-02f, 2.92276032e-02f, 7.33232051e-02f, 2.81642806e-02f, 8.08783695e-02f, 7.45091289e-02f,
  4.38120738e-02f, 7.24965241e-03f, 8.68894234e-02f, -2.19965968e-02f, 3.25274356e-02f, -7.20122457e-02f, 3.34455334e-02f, 2.26317327e-02f, 4.87305224e-02f, -3.55884470e-02f,
  1.94812253e-01f, -6.82450384e-02f, 3.00463736e-01f, -2.39547156e-02f, -9.31265857e-03f, 3.13355289e-02f, 1.78054243e-01f, 1.42905675e-02f, 1.39784608e-02f, 6.66312799e-02f,
  -9.52155665e-02f, -1.27453916e-02f, 5.32923825e-02f, -3.58034261e-02f, 5.34607731e-02f, 1.18191354e-01f, 1.96591184e-01f, -6.87488616e-02f, 1.35652674e-02f, 1.68101233e-03f,
  1.03439294e-01f, 7.34043792e-02f, 1.38231978e-01f, 4.21678573e-02f, -1.02350965e-01f, 1.37180224e-01f, 2.61949487e-02f, -3.68012814e-03f, 2.61319019e-02f, 2.52323031e-01f,
  -5.74561208e-02f, -9.29623321e-02f, -3.15200508e-01f, -6.43995628e-02f, -4.75284196e-02f, 2.54917145e-02f, 6.87409416e-02f, 1.20198302e-01f, -2.86771939e-03f, -5.01671694e-02f,
  6.04010979e-03f, -6.38852769e-04f, -1.79687783e-01f, -7.72761554e-02f, -2.41215546e-02f, -9.67672691e-02f, -1.89585954e-01f, -1.43840104e-01f, 6.11375980e-02f, 2.44034231e-01f,
  1.19505629e-01f, -1.05978586e-02f, -2.24915519e-02f, 1.48756970e-02f, -5.04718497e-02f, -7.91031197e-02f, -2.12429509e-01f, -1.29977196e-01f, -9.25236419e-02f, -2.03924939e-01f,
  -1.27427995e-01f, -6.23713387e-03f, 5.40692545e-02f, -4.73749414e-02f, -5.50178550e-02f, 1.14636168e-01f, 9.90754962e-02f, 4.40849029e-02f, 5.72224148e-02f, -4.23410498e-02f,
  1.96294505e-02f, 8.36541653e-02f, 4.80306037e-02f, 3.34996544e-03f, 6.32270202e-02f, 9.05854851e-02f, -2.93097831e-02f, -4.15208526e-02f, -1.00526944e-01f, 1.25742806e-02f,
  -2.42926832e-02f, -3.18082646e-02f, -8.90941545e-02f, 3.29053402e-02f, 7.13755712e-02f, -7.72930458e-02f, -2.62974552e-03f, 6.65234700e-02f, -1.13175828e-02f, -5.42189740e-02f,
  8.40574577e-02f, -6.11788884e-04f, 3.26818824e-02f, 2.17415746e-02f, 1.25187477e-02f, -3.44018266e-02f, -2.89262962e-02f, -3.49446572e-02f, -2.44720448e-02f, 1.19829527e-03f,
  3.56357843e-02f, -5.34998588e-02f, -1.99119169e-02f, 3.65252867e-02f, 1.36035187e-02f, -5.02778068e-02f, -5.76036535e-02f, 1.83306541e-02f, -4.66051931e-03f, -2.79391631e-02f,
  -2.91648787e-02f, -4.25714366e-02f, -6.56656921e-02f, 2.81130541e-02f, -5.98465055e-02f, -6.26791865e-02f, -8.31482280e-03f, 8.63614399e-03f, 3.85777690e-02f, -1.24093238e-02f,
  -1.84525698e-02f, -5.73191345e-02f, -9.08395424e-02f, -1.83477271e-02f, -5.59796840e-02f, 7.68818473e-03f, -4.93067764e-02f, 4.03040927e-03f, -1.09388210e-01f, 2.38804542e-03f,
  1.37452204e-02f, -4.31127788e-04f, -4.75624949e-03f, -9.98275820e-03f, 3.87653038e-02f, -8.01339687e-04f, -4.81677940e-03f, -1.31847903e-01f, -4.97739986e-02f, -1.42610325e-02f,
  -4.64169942e-02f, -1.02105951e-02f, -6.77516237e-02f, -6.73604608e-02f, 8.19837395e-03f, -9.38212425e-02f, -5.52016646e-02f, -9.32036992e-03f, -3.61453593e-02f, -5.15951589e-03f,
  -2.57669926e-01f, -2.16517553e-01f, -3.81235987e-01f, -5.71899831e-01f, -2.64753103e-01f, 4.81281467e-02f, 1.06308125e-01f, -1.78388339e-02f, -2.66400248e-01f, -2.53989875e-01f,
  -2.05420984e-05f, 1.04833454e-01f, -1.67312279e-01f, 1.18714161e-01f, 2.96281189e-01f, -1.62132084e-01f, -2.83107877e-01f, 6.00515567e-02f, 3.16670984e-01f, 3.63900512e-01f,
  1.22723453e-01f, -1.22456290e-01f, -3.80306430e-02f, -2.14771610e-02f, -2.93628901e-01f, -1.34654930e-02f, -4.12587255e-01f, -2.41824508e-01f, -1.99876004e-03f, -3.71770203e-01f,
  -1.09496810e-01f, -1.80044532e-01f, 5.88175133e-02f, 6.07806854e-02f, -1.39093995e-01f, -9.41278355e-04f, -3.78761590e-02f, -1.33064628e-01f, -3.92049588e-02f, -1.60029769e-01f,
  -1.73216879e-01f, 7.40885064e-02f, -6.31416515e-02f, 8.38769134e-03f, -3.20845433e-02f, -4.79793884e-02f, -1.14954136e-01f, 9.07344446e-02f, -2.45900266e-02f, 4.55711596e-02f,
  9.47327018e-02f, 6.14806823e-03f, -1.77500937e-02f, 6.98135793e-02f, 5.02102226e-02f, 8.79117474e-02f, 4.47065346e-02f, 1.50477290e-01f, 7.42103010e-02f, -3.02426428e-01f,
  -5.67478575e-02f, -4.28295620e-02f, 1.00236438e-01f, 7.41748661e-02f, 1.29600599e-01f, 2.23847502e-03f, -6.03287630e-02f, 6.30990788e-02f, 1.12618931e-01f, 8.84894952e-02f,
  -3.96575704e-02f, -3.88709493e-02f, 7.14002624e-02f, 6.48917723e-03f, -4.12567705e-02f, 1.81814078e-02f, -6.15918776e-03f, 2.71292869e-03f, -1.23966113e-02f, -3.04100476e-02f,
  9.99277830e-02f, 5.36726117e-02f, -7.46955797e-02f, 5.90671562e-02f, -1.40604004e-02f, -5.18284366e-02f, -2.85563003e-02f, 7.78376311e-02f, -8.93789716e-03f, -3.00053488e-02f,
  -1.03115730e-01f, 1.78156137e-01f, -1.61013588e-01f, 1.54956639e-01f, -7.20056295e-02f, -5.32924421e-02f, -8.12447369e-02f, -3.09242378e-03f, -1.25747308e-01f, -3.53877284e-02f,
  1.89056788e-02f, 1.12102129e-01f, -4.95256819e-02f, 3.54620302e-03f, 9.14575085e-02f, -2.68358998e-02f, 7.67057836e-02f, -4.16082852e-02f, 9.53182131e-02f, -1.48286670e-02f,
  -3.32356151e-03f, 1.49987996e-01f, 6.28265142e-02f, 2.84134690e-02f, -7.51149142e-04f, 1.82082281e-01f, 7.89344683e-02f, 6.14969172e-02f, 1.58889875e-01f, -1.22974671e-01f,
  -6.59869492e-01f, -4.35975522e-01f, 3.84143949e-01f, -4.87068981e-01f, 1.84046239e-01f, 3.40623707e-01f, 2.09561810e-01f, -7.67328814e-02f, -3.18956047e-01f, -1.65669993e-01f,
  -2.11031079e-01f, -3.58397752e-01f, -4.02009040e-01f, -1.00910649e-01f, 3.32634430e-03f, 2.12993979e-01f, 2.69543648e-01f, 2.22677812e-01f, 2.22077817e-01f, 3.06292802e-01f,
  1.64608415e-02f, -1.21220879e-01f, -1.44240484e-01f, -1.54091313e-01f, -2.18318999e-01f, -2.32254177e-01f, -1.48794288e-03f, -3.44455950e-02f, 7.84726739e-02f, -2.38533914e-01f,
  1.19468078e-01f, -3.90247941e-01f, 1.03735149e-01f, -5.96889704e-02f, -6.86195344e-02f, -1.30724072e-01f, -1.30243192e-03f, -1.54514521e-01f, -2.04599291e-01f, -1.41291901e-01f,
  -7.08816946e-02f, -1.18696541e-01f, -8.22935030e-02f, -8.14351160e-03f, -1.21871792e-01f, -6.29342794e-02f, -1.77203268e-02f, -2.84847189e-02f, 4.41130102e-02f, 1.30859643e-01f,
  -6.55995980e-02f, -4.08170000e-02f, -3.19162942e-02f, 7.64866322e-02f, -4.70195450e-02f, 6.85667694e-02f, 8.28410760e-02f, -1.26531357e-02f, 4.28046137e-02f, -1.96609780e-01f,
  2.62419671e-01f, 1.85082015e-02f, -1.06702849e-01f, 9.34751891e-03f, -3.90687063e-02f, 3.19111198e-02f, -7.90504441e-02f, -1.04608305e-01f, -1.23004235e-01f, -1.10563710e-01f,
  -6.24384396e-02f, -1.01235686e-02f, -6.91118985e-02f, -1.15000345e-01f, -3.31481472e-02f, -1.54259220e-01f, -3.35615724e-02f, -1.30387126e-02f, -4.81372746e-03f, -8.78783092e-02f,
  -6.83742538e-02f, -6.17021546e-02f, 1.76797528e-02f, -3.29715870e-02f, 1.72497947e-02f, -4.74098772e-02f, 3.37710455e-02f, -4.13217619e-02f, -5.05762883e-02f, -5.82958423e-02f,
  -1.28538191e-01f, 1.78349540e-01f, -1.84891611e-01f, -9.53742564e-02f, -2.05546478e-03f, -6.01253733e-02f, -1.33051291e-01f, 9.53571275e-02f, -1.28973767e-01f, 9.56883281e-02f,
  1.58394035e-02f, -3.34757529e-02f, 1.72450803e-02f, 7.68255219e-02f, 1.15446724e-01f, 9.76775587e-02f, -3.37378308e-02f, 3.89343724e-02f, 5.51238693e-02f, 3.82482857e-02f,
  1.53323442e-01f, 8.94826949e-02f, -6.65614847e-04f, 2.09718682e-02f, -2.54698414e-02f, 3.77819650e-02f, 2.00215787e-01f, 1.33316040e-01f, 2.91691869e-01f, 1.85830429e-01f,
  2.56773293e-01f, 1.32646024e-01f, 3.65792625e-02f, -1.33299068e-01f, 8.47793892e-02f, 9.56033021e-02f, 1.53643131e-01f, 6.47802129e-02f, -7.09557012e-02f, -9.06196386e-02f,
  1.10445559e-01f, -1.46462098e-01f, -1.22642055e-01f, -1.75991982e-01f, -2.90653408e-01f, -2.85099566e-01f, -2.94707447e-01f, -1.95024624e-01f, -7.53117576e-02f, -1.78472221e-01f,
  -2.32967123e-01f, -2.37904906e-01f, -1.82364181e-01f, -1.93522900e-01f, -2.41083294e-01f, -2.46451363e-01f, -1.75993979e-01f, -1.46631449e-01f, -1.40069708e-01f, -4.30074722e-01f,
  -1.58093750e-01f, 2.92357117e-01f, -1.08328350e-01f, -3.76841761e-02f, 2.95323133e-02f, 2.74300370e-02f, -5.75896204e-02f, -7.26651102e-02f, 6.66031428e-03f, -3.50701027e-02f,
  9.47253313e-03f, -2.48947423e-02f, 1.25809625e-01f, 6.07161336e-02f, 6.06003627e-02f, 1.41104713e-01f, 2.07604364e-01f, 1.78247213e-01f, 9.15856734e-02f, 1.89913772e-02f,
  1.62094176e-01f, 3.12368155e-01f, 2.05893353e-01f, 2.40362659e-01f, 2.01682597e-01f, 2.27590486e-01f, 1.86020985e-01f, 2.53523737e-01f, 1.99953750e-01f, 1.76329419e-01f,
  2.55833659e-02f, 8.09439868e-02f, 3.61920670e-02f, 1.61113992e-01f, 2.31422678e-01f, 9.96439531e-02f, 1.60565805e-02f, -2.82024704e-02f, -4.77196872e-02f, -1.80917438e-02f,
  -9.27675888e-02f, 2.83795712e-03f, 5.13245501e-02f, -5.97851872e-02f, -2.01327026e-01f, 6.57868832e-02f, -2.64413450e-02f, 3.98707688e-02f, -1.52646694e-02f, 2.72075348e-02f,
  -1.78070478e-02f, 3.26572433e-02f, -4.35305350e-02f, 5.37248030e-02f, 1.58762738e-01f, 6.27150536e-02f, 3.03935315e-02f, 2.39598993e-02f, -9.03045610e-02f, -6.55972958e-02f,
  -9.45425108e-02f, 2.69192487e-01f, -1.77169397e-01f, -2.12002009e-01f, 9.75780711e-02f, -2.93255374e-02f, -7.76411220e-02f, -5.57001829e-02f, -9.76614207e-02f, -4.71339561e-02f,
  5.73038030e-03f, -1.75076827e-01f, 9.75958258e-02f, 3.45087387e-02f, 2.44236235e-02f, -4.23059007e-03f, 8.42521042e-02f, -3.94324325e-02f, 5.03526479e-02f, -9.66971144e-02f,
  9.11629051e-02f, 1.70035198e-01f, -2.42498820e-03f, 1.89572163e-02f, 1.73492450e-02f, -9.23832059e-02f, -7.52091706e-02f, 8.00093338e-02f, 4.41493317e-02f, -6.08353913e-02f,
  1.51738793e-01f, -2.21464057e-02f, -3.01466465e-01f, -1.95110142e-01f, -2.16338485e-01f, -1.88318178e-01f, -1.58498600e-01f, -1.71686336e-01f, -1.00086622e-01f, -8.10305253e-02f,
  -3.09659075e-02f, -3.13242860e-02f, -3.68797742e-02f, -7.39783421e-02f, -8.35621655e-02f, -7.03365207e-02f, -9.41208303e-02f, -1.36715010e-01f, -2.24511623e-01f, -1.53695256e-01f,
  -5.97092994e-02f, -1.40242502e-01f, -1.01960614e-01f, -1.07813731e-01f, -9.08691585e-02f, -9.15619507e-02f, -1.33499458e-01f, -9.16929618e-02f, 4.38113278e-03f, -4.55557602e-03f,
  -2.04759657e-01f, -8.41352716e-02f, -1.01023838e-01f, 4.02132459e-02f, -1.14951909e-01f, 6.85773836e-03f, -4.27898131e-02f, -5.90114892e-02f, 8.56545046e-02f, -9.09650922e-02f,
  -1.03410574e-04f, -2.39241011e-02f, -2.23530158e-02f, -7.10365102e-02f, -1.39647782e-01f, -6.77556247e-02f, -8.09753239e-02f, -3.98908108e-02f, 3.10324244e-02f, 6.40634745e-02f,
  1.85323089e-01f, 1.01885773e-01f, -2.52747033e-02f, 1.22779096e-02f, -1.42833143e-02f, -1.42051722e-03f, -6.22611195e-02f, 2.92834663e-03f, 6.13204844e-04f, 1.86279546e-02f,
  3.17302905e-02f, 2.96693351e-02f, -4.61891703e-02f, -5.56821488e-02f, -3.20249125e-02f, 1.17678307e-01f, -7.10823573e-03f, -5.92751242e-02f, 2.43038181e-02f, -5.25031821e-04f,
  -6.17669933e-02f, -3.25572938e-02f, -3.18280086e-02f, 8.68551955e-02f, -1.72088090e-02f, 2.97769401e-02f, 3.96791808e-02f, -3.91426571e-02f, 2.26802938e-02f, 2.88636573e-02f,
  1.96753759e-02f, 1.95335094e-02f, -2.76172105e-02f, 1.38815921e-02f, 2.38726027e-02f, -4.04427610e-02f, 1.02273747e-02f, -5.47800176e-02f, -1.06867999e-01f, 8.53618830e-02f,
  -1.48163363e-01f, 1.27026234e-02f, -3.46306413e-02f, 7.46567082e-03f, -5.98592386e-02f, -2.70471741e-02f, -1.32153230e-03f, -2.02037264e-02f, 2.70865001e-02f, -6.42623529e-02f,
  9.37354285e-03f, -5.72587848e-02f, -4.11038920e-02f, 2.36201677e-02f, -7.41976276e-02f, 3.95908058e-02f, 1.95511933e-02f, -3.59181426e-02f, 1.22239582e-01f, 6.20513372e-02f,
  6.99740127e-02f, 1.01895079e-01f, 8.76837894e-02f, 2.91575994e-02f, 7.47644976e-02f, 2.51581166e-02f, -3.36119533e-02f, -2.81120166e-02f, 1.05912365e-01f, 5.23842908e-02f,
  1.12719923e-01f, 3.04829746e-01f, -2.73471892e-01f, 1.85739622e-01f, 9.34324414e-02f, -1.33272663e-01f, 2.62399577e-02f, -3.83681022e-02f, 1.99558865e-02f, 1.28430113e-01f,
  -1.25018822e-03f, -3.27845328e-02f, -4.37150076e-02f, -3.41973500e-03f, -4.35639620e-02f, 7.62466043e-02f, 1.35541007e-01f, -1.36153176e-01f, -1.61548078e-01f, 1.20993974e-02f,
  2.09563687e-01f, 2.11256549e-01f, 1.20514058e-01f, 1.13782585e-02f, 1.20948806e-01f, 3.15280966e-02f, 2.52530314e-02f, 1.01020738e-01f, 5.21134064e-02f, 1.48523569e-01f,
  -2.04984576e-01f, -9.17643085e-02f, -1.74478933e-01f, 9.05732661e-02f, 1.02013387e-02f, -1.22027703e-01f, -1.03697620e-01f, -1.23346440e-01f, -9.84375775e-02f, -1.57441609e-02f,
  3.17531861e-02f, -6.10182844e-02f, -7.55184293e-02f, 4.15780619e-02f, -3.99652012e-02f, -1.52005404e-01f, 6.91893920e-02f, -1.12169452e-01f, -8.72240961e-02f, -1.69980705e-01f,
  1.46977946e-01f, 3.83400507e-02f, -6.58392087e-02f, -6.75864667e-02f, -1.98055267e-01f, -1.05888985e-01f, -8.68504867e-02f, -1.12770647e-01f, -1.97751135e-01f, 1.90847684e-02f,
  -9.26228836e-02f, -2.20285263e-02f, 1.26765028e-01f, 9.74761844e-02f, 1.61458880e-01f, 4.55526970e-02f, 2.68994551e-02f, -3.54568474e-02f, 5.44895455e-02f, 3.02252602e-02f,
  -4.70435694e-02f, -1.02894947e-01f, -1.59754887e-01f, -1.59361079e-01f, -6.48120567e-02f, 7.62475003e-03f, -1.05284965e-02f, 7.33020231e-02f, 2.80909650e-02f, -1.03738382e-01f,
  -1.11089060e-02f, -4.32045385e-02f, -1.87582467e-02f, -3.85621712e-02f, 1.56352166e-02f, -2.67389473e-02f, -7.12621659e-02f, -9.47493762e-02f, -8.41381680e-03f, 1.20249595e-02f,
  4.22627963e-02f, -1.41922325e-01f, -7.25575984e-02f, 2.71106604e-02f, 7.46614039e-02f, -2.99656540e-02f, -2.35480126e-02f, -1.11625582e-01f, -4.09492813e-02f, -6.36305213e-02f,
  -7.12396484e-03f, -1.14439219e-01f, 2.45380476e-02f, -7.89296702e-02f, -1.71880588e-01f, -9.33815017e-02f, 1.74033657e-01f, 1.01042695e-01f, 3.32167670e-02f, -1.59938887e-01f,
  2.16760814e-01f, 1.44288957e-01f, 6.18920773e-02f, -5.17905168e-02f, -2.51601618e-02f, 5.91798611e-02f, 2.88575906e-02f, 1.19885395e-03f, -1.59523100e-01f, 1.60290822e-01f,
  5.61992407e-01f, -9.64439660e-02f, -8.14060196e-02f, 1.63672447e-01f, 8.10848325e-02f, 1.30408078e-01f, 1.78990915e-01f, 1.38603151e-01f, 1.95731089e-01f, 8.72643217e-02f,
  1.01818919e-01f, 2.60131836e-01f, 2.07713231e-01f, 2.52176616e-02f, 1.37414962e-01f, -8.68639201e-02f, -1.13017775e-01f, -8.48940685e-02f, -6.00558519e-03f, -5.02357669e-02f,
  3.46464887e-02f, -3.26823704e-02f, 4.11618911e-02f, -2.85568703e-02f, -1.16088510e-01f, 5.58344387e-02f, -3.76430042e-02f, -1.06480651e-01f, -1.42382354e-01f, -2.36536890e-01f,
  -2.81294644e-01f, -7.68681020e-02f, -5.01628518e-02f, -8.63222033e-02f, -4.51528132e-02f, 8.35703313e-03f, 1.47601543e-02f, -1.92180708e-01f, 9.88353491e-02f, 3.08098756e-02f,
  -2.66964585e-02f, -5.12764826e-02f, -4.18190025e-02f, -1.07062079e-01f, -1.00410931e-01f, -6.72096461e-02f, -9.91028175e-02f, -1.33063018e-01f, -1.62028268e-01f, -1.16335645e-01f,
  -1.01553105e-01f, -5.45077398e-02f, -8.96539167e-02f, 1.00518800e-01f, 1.16019592e-01f, 1.15617320e-01f, -5.93937151e-02f, -6.85465559e-02f, -4.28971499e-02f, 1.18147545e-01f,
  -2.84548730e-01f, -2.61917128e-03f, -9.05484706e-02f, 8.58424306e-02f, 5.75140081e-02f, 1.07506767e-01f, -4.09832550e-03f, -1.86842605e-02f, 2.04395670e-02f, 4.21436727e-02f,
  -2.99434569e-02f, 4.73343208e-02f, 4.30582948e-02f, 9.06463340e-03f, -4.15780880e-02f, -1.66916952e-01f, -3.58855091e-02f, -2.63827518e-02f, -4.28873897e-02f, -3.61175314e-02f,
  9.03900042e-02f, -1.86830521e-01f, -7.69888684e-02f, -2.17980474e-01f, -1.65688634e-01f, -1.31753862e-01f, -3.16364877e-02f, -1.02718540e-01f, 4.24357131e-02f, -6.45025298e-02f,
  -9.62542817e-02f, 4.49869633e-02f, 3.64771374e-02f, 2.05452926e-02f, -2.33180262e-02f, 3.00961360e-02f, -9.62281898e-02f, -7.92785734e-02f, 4.13366146e-02f, -3.00584510e-02f,
  7.67450854e-02f, -7.81079680e-02f, -6.77901655e-02f, 1.29074872e-01f, 2.31901687e-02f, -5.08550834e-03f, 5.55735007e-02f, -8.65147822e-03f, -9.26766545e-02f, -1.17911436e-01f,
  -2.25256942e-02f, 3.56951505e-02f, 2.02747017e-01f, 2.00412586e-01f, 9.16655362e-02f, 1.07065395e-01f, 4.89333048e-02f, 3.54294106e-03f, 3.05058286e-02f, 1.27711326e-01f,
  6.82790279e-01f, -1.44524619e-01f, -3.43276590e-01f, 1.23372585e-01f, -3.86182070e-01f, -2.02882186e-01f, -2.55593568e-01f, -2.05122419e-02f, 9.76771638e-02f, -1.53805375e-01f,
  -1.12503469e-01f, 2.09784582e-01f, 1.05949633e-01f, 1.43419936e-01f, 3.94668758e-01f, -1.89530805e-01f, -2.36691564e-01f, 1.36348948e-01f, 2.98771650e-01f, 6.46287873e-02f,
  1.81546304e-02f, 1.27756819e-01f, 3.44170094e-01f, 1.99085578e-01f, -2.20907465e-01f, 5.52315004e-02f, -3.20544153e-01f, -1.50190845e-01f, -8.98517519e-02f, -2.51971275e-01f,
  -1.95986275e-02f, -1.00346666e-03f, -1.04175158e-01f, 1.14583746e-01f, -1.64997876e-01f, 1.65860370e-01f, 4.15652208e-02f, -8.42324346e-02f, -3.13120522e-02f, -2.75092013e-02f,
  -1.71579450e-01f, -4.40138653e-02f, -9.32977721e-02f, 4.69745253e-04f, -1.15489475e-02f, 1.12627819e-02f, -9.24877152e-02f, 7.35716373e-02f, 5.24251163e-02f, -1.31482303e-01f,
  -2.50065804e-01f, -2.36167237e-01f, -2.20899776e-01f, -1.85898185e-01f, -7.73507804e-02f, 2.08146218e-03f, -2.14316562e-01f, -7.74846151e-02f, 3.41235325e-02f, -9.48802531e-02f,
  3.36308628e-02f, -8.68882090e-02f, -1.20218433e-01f, -4.84520942e-02f, -1.17765255e-02f, -1.61961928e-01f, -2.85258815e-02f, -1.24329515e-03f, -5.80391055e-03f, -6.52549192e-02f,
  6.06077164e-02f, 9.90437903e-03f, -2.99580134e-02f, -1.20042264e-01f, -7.82610998e-02f, -1.77158535e-01f, -6.73684925e-02f, 7.63036683e-02f, -5.82383424e-02f, 7.58562163e-02f,
  9.27882120e-02f, -1.37075558e-01f, -5.75229377e-02f, -4.50391043e-03f, 2.22043637e-02f, 2.03282125e-02f, 3.16818506e-02f, 4.89660501e-02f, 1.36899878e-04f, -8.31395164e-02f,
  2.99242854e-01f, 1.50517449e-01f, 1.60068553e-02f, 7.54597336e-02f, -8.58795047e-02f, -6.45655021e-02f, 4.76752929e-02f, 1.21070541e-01f, -3.45700458e-02f, 1.04740366e-01f,
  -1.01981414e-02f, 1.81183934e-01f, -1.23468377e-02f, -8.86402726e-02f, -8.31106454e-02f, -6.76113367e-02f, 6.85662311e-03f, -6.93559647e-02f, -2.64522135e-02f, -7.94831291e-02f,
  -1.16981447e-01f, 4.70656678e-02f, 1.10680573e-01f, -4.36093584e-02f, -5.92336617e-02f, 1.33329034e-01f, -1.35995299e-01f, -1.25654995e-01f, 1.82428330e-01f, -4.42832010e-03f,
  -1.98883891e-01f, -1.29159421e-01f, -4.47392792e-01f, 2.02555344e-01f, 2.34033138e-01f, -1.21776938e-01f, -2.85716444e-01f, -1.49491593e-01f, 1.90802395e-01f, -6.57405704e-02f,
  1.10477842e-01f, 2.28235081e-01f, 2.78858878e-02f, -3.91492766e-04f, -1.96966797e-01f, -2.12313086e-01f, -8.46659988e-02f, -2.20338061e-01f, -1.49667978e-01f, 1.47586569e-01f,
  2.62918651e-01f, 1.50653109e-01f, -1.60329714e-02f, 1.62741914e-02f, 2.76650161e-01f, 1.21455602e-01f, -4.59749736e-02f, 7.28813633e-02f, -6.01385422e-02f, 6.92422315e-02f,
  -2.35512421e-01f, -1.81992427e-01f, -4.00222763e-02f, 1.99719951e-01f, 5.95221743e-02f, -1.36033297e-01f, -5.91662750e-02f, -1.23617612e-01f, -5.35291396e-02f, -1.09441243e-01f,
  9.89876986e-02f, 3.34408432e-02f, 1.09783426e-01f, 1.68772135e-02f, 3.65200788e-02f, -1.28343642e-01f, -1.02860793e-01f, -2.45939404e-01f, -2.57229507e-01f, -1.27251983e-01f,
  1.65534601e-01f, 1.06380507e-01f, -1.89627990e-01f, -1.47907138e-01f, -1.54268011e-01f, -5.17355278e-02f, -1.39847025e-01f, -1.00439668e-01f, -2.74101287e-01f, -1.25699356e-01f,
  2.03540418e-02f, 1.40117509e-02f, -2.76391804e-02f, -8.80838335e-02f, 9.27415192e-02f, 6.69228807e-02f, 2.30325107e-02f, 1.15567753e-02f, 6.95809955e-04f, -3.34341675e-02f,
  1.25707323e-02f, -8.67995992e-02f, 3.42030115e-02f, 4.66328152e-02f, 7.26273060e-02f, 4.77587152e-03f, 4.29086573e-02f, -2.42246110e-02f, -2.60544494e-02f, -1.73236877e-02f,
  2.80019525e-03f, -3.17120291e-02f, 1.39931098e-01f, -2.90328618e-02f, -9.54448506e-02f, -8.73381272e-02f, -2.27840282e-02f, -5.68841631e-03f, -6.31181430e-03f, -4.81983684e-02f,
  1.39892995e-01f, -1.33817032e-01f, -3.89477126e-02f, -2.25959178e-02f, 2.16069482e-02f, 6.88272417e-02f, 2.87683457e-02f, -3.36130857e-02f, -8.00671428e-02f, -5.84678575e-02f,
  -8.45756829e-02f, -5.18062860e-02f, 7.18744025e-02f, -1.44422404e-03f, -4.27859575e-02f, -6.19721264e-02f, 3.03455815e-02f, -5.76315038e-02f, -7.76349157e-02f, 8.18615183e-02f,
  3.41217108e-02f, -1.05240896e-01f, -1.95869401e-01f, -1.84432849e-01f, -1.92412958e-02f, -1.11905962e-01f, -1.80516109e-01f, -9.21980441e-02f, -2.94260591e-01f, -1.87788948e-01f,
  1.89570189e-01f, -1.08274095e-01f, -1.45796552e-01f, -4.78116907e-02f, -2.92222470e-01f, -2.75591344e-01f, -2.35597789e-01f, -6.08130619e-02f, 5.59151880e-02f, 3.40222288e-03f,
  -5.51781729e-02f, 5.68279475e-02f, 9.54756886e-02f, 3.92031372e-02f, 7.17400908e-02f, 6.44635782e-02f, 3.83694395e-02f, 1.59764066e-02f, -1.79737285e-01f, -2.76325285e-01f,
  -1.41768679e-01f, -1.37689665e-01f, 1.49843916e-02f, -4.32744175e-02f, -1.68499142e-01f, -1.47421211e-01f, -3.93979251e-02f, -1.44593343e-01f, -1.15974300e-01f, -1.46271855e-01f,
  -1.89200014e-01f, -1.33473262e-01f, -5.74935302e-02f, 8.48025549e-03f, -8.18249071e-04f, -4.09145840e-02f, -8.06370974e-02f, 3.61703113e-02f, 3.67910489e-02f, -5.97650073e-02f,
  -6.95992820e-03f, -3.39753255e-02f, 7.18324855e-02f, -7.81980306e-02f, -1.29672319e-01f, -1.11049347e-01f, 4.12594341e-02f, 3.25866640e-02f, 9.16933715e-02f, 5.35751544e-02f,
  1.99257899e-02f, 7.59776086e-02f, -2.82864831e-02f, -1.20181004e-02f, -8.83895457e-02f, -4.27917428e-02f, -1.14788830e-01f, -1.02323785e-01f, -5.43364286e-02f, -7.44287595e-02f,
  1.07240789e-01f, 4.85165715e-02f, 2.08994597e-02f, -7.81968120e-05f, 1.03254346e-02f, 1.81546107e-01f, 4.89842631e-02f, 4.24277671e-02f, -2.96487343e-02f, -3.06707043e-02f,
  1.32699860e-02f, 1.53959934e-02f, 3.62158194e-02f, 4.05025370e-02f, 5.11066569e-03f, 6.11960515e-02f, -2.22010389e-02f, 8.39139894e-02f, 6.20829239e-02f, 4.51389812e-02f,
  8.38299021e-02f, 9.38347578e-02f, 4.33521196e-02f, -6.58160308e-03f, -5.17401397e-02f, 6.84956163e-02f, 2.55291332e-02f, 8.18454176e-02f, 2.38719233e-03f, -3.24195772e-02f,
  2.71861851e-02f, 1.21806085e-01f, 3.17904018e-02f, 4.21506632e-03f, 2.20419057e-02f, 2.58656945e-02f, 8.84081610e-03f, 1.29010677e-01f, -4.14766483e-02f, -9.52447355e-02f,
  -3.34911160e-02f, 1.05400033e-01f, 9.36831608e-02f, -8.04482773e-02f, 1.37304170e-02f, 2.63313167e-02f, 8.43423456e-02f, 7.08814412e-02f, 1.49548024e-01f, 1.58592965e-02f,
  1.13765076e-01f, 2.07216486e-01f, 1.83419585e-01f, 3.90321426e-02f, -2.32022745e-03f, 5.21665849e-02f, 5.33011518e-02f, 4.25083488e-02f, 8.56872201e-02f, 1.91286087e-01f,
  3.19426447e-01f, 3.71256679e-01f, 1.13026932e-01f, 8.34363848e-02f, 9.46085081e-02f, 1.05411261e-01f, 1.69958025e-01f, -9.59360600e-02f, -2.11451828e-01f, 2.10049778e-01f,
  2.65424728e-01f, 4.02080864e-02f, -1.86854452e-01f, -1.64889589e-01f, -4.43327725e-02f, -6.01858608e-02f, -9.27835032e-02f, -4.11668569e-02f, -1.18330933e-01f, 1.87464595e-01f,
  2.07033783e-01f, 2.23705009e-01f, 1.62246361e-01f, -6.69921190e-02f, 1.83582962e-01f, 3.80911073e-03f, 7.36469105e-02f, 2.15163916e-01f, 2.32274532e-01f, 2.79963344e-01f,
  2.74154454e-01f, 2.26129800e-01f, -3.40568304e-01f, 4.46167998e-02f, 8.96885172e-02f, -1.15190126e-01f, -5.69519401e-02f, -1.62735209e-01f, -3.82325351e-02f, -1.87181141e-02f,
  4.52122912e-02f, 1.39524378e-02f, 9.65017602e-02f, 7.64536932e-02f, 7.62550533e-02f, -2.24381797e-02f, -1.69928923e-01f, -6.56119063e-02f, -1.65152833e-01f, -2.64571365e-02f,
  -3.47010000e-03f, 2.82310754e-01f, 3.87887396e-02f, -1.16130531e-01f, -6.35756403e-02f, -1.02423027e-01f, 6.39236271e-02f, -1.32988589e-02f, -5.57916537e-02f, 8.47903788e-02f,
  -1.77319482e-01f, 2.19084527e-02f, 1.58970989e-02f, -4.42717085e-03f, -4.58821505e-02f, -2.07751021e-02f, -3.59515101e-02f, 1.86217427e-02f, 4.58756983e-02f, -7.06255659e-02f,
  -1.34926885e-01f, -8.71516913e-02f, -1.31247669e-01f, -1.00821465e-01f, -1.71657726e-01f, 1.16802998e-01f, 1.78419389e-02f, -2.74807438e-02f, 4.11330946e-02f, -3.38903926e-02f,
  1.69553247e-03f, -2.06093900e-02f, -4.61430810e-02f, -7.93881528e-03f, -1.12722345e-01f, -1.20271690e-01f, -7.25671723e-02f, -3.51747461e-02f, -8.13750774e-02f, 8.02837685e-03f,
  -5.38515598e-02f, -1.43356070e-01f, -7.48129338e-02f, -4.50283028e-02f, 1.04655862e-01f, -7.33976588e-02f, -2.39966195e-02f, 4.75183055e-02f, 5.52389137e-02f, 4.46511023e-02f,
  1.40647843e-01f, 1.69378109e-02f, -4.29338925e-02f, -3.08212079e-02f, -1.06046572e-01f, -1.38941959e-01f, 1.05033191e-02f, -1.56866666e-02f, -1.54114574e-01f, -1.87748414e-03f,
  -1.04888983e-01f, -1.04260609e-01f, -1.13874525e-01f, -2.91368097e-01f, -2.33318612e-01f, -2.90674597e-01f, -1.99172795e-01f, -1.68272212e-01f, -2.18050912e-01f, -2.58319557e-01f,
  -2.15994462e-01f, 2.67169654e-01f, -2.53221035e-01f, -2.48170029e-02f, -1.44814119e-01f, -1.87361985e-01f, 1.00823238e-01f, 1.24459818e-01f, 2.45793462e-02f, 2.20756054e-01f,
  6.26613796e-02f, -1.65025115e-01f, -1.17343538e-01f, -1.06461473e-01f, -1.32455647e-01f, 2.41152793e-02f, -1.40234038e-01f, -2.76975602e-01f, -2.87843704e-01f, -1.16112560e-01f,
  -7.68095776e-02f, -7.43633285e-02f, -1.38424069e-01f, -9.30302665e-02f, 5.44628948e-02f, -1.33497179e-01f, -1.99133195e-02f, -1.20791718e-01f, -1.48536712e-01f, -6.59523010e-02f,
  1.24186665e-01f, -5.26833646e-02f, -7.30287433e-02f, -1.53894722e-01f, 3.59479152e-02f, -3.79867703e-02f, -2.67066583e-02f, -4.21369895e-02f, -1.34436693e-02f, 4.67465483e-02f,
  -1.03966147e-01f, -1.67233218e-02f, -6.43727928e-02f, -8.00649971e-02f, -1.13065518e-01f, -2.52881497e-02f, -1.07711077e-01f, -1.26543269e-01f, -1.11446157e-01f, 3.43963094e-02f,
  -5.48170134e-02f, -1.88365564e-01f, -5.78909181e-02f, 2.10392494e-02f, 4.85654995e-02f, -1.74996600e-01f, 1.14499345e-01f, 4.88550821e-03f, -4.86820079e-02f, 2.41941527e-01f,
  5.95130660e-02f, 3.17010172e-02f, -5.54618649e-02f, 9.17757526e-02f, 1.64142713e-01f, -1.59727968e-02f, 4.48749997e-02f, 1.01816237e-01f, -1.22267958e-02f, 4.89147119e-02f,
  7.66099542e-02f, 1.32548794e-01f, 5.50574884e-02f, 3.06239165e-02f, 2.27508210e-02f, -4.62838896e-02f, 1.31884869e-02f, 7.47685432e-02f, 6.86695194e-03f, -1.61053389e-02f,
  -4.97116484e-02f, -8.59463662e-02f, -8.14201459e-02f, 1.10278204e-01f, -4.41400781e-02f, -1.32188750e-02f, -3.27458531e-02f, -1.41161000e-02f, -1.64520042e-03f, -1.34000227e-01f,
  2.02988952e-01f, -1.84247449e-01f, 5.07091284e-02f, -4.72285934e-02f, 2.15418860e-02f, -2.09380314e-02f, 3.42937596e-02f, 2.42460445e-02f, 1.68153550e-02f, 8.45566019e-02f,
  -3.63782011e-02f, 8.82145911e-02f, -1.33621795e-02f, -1.36339776e-02f, -4.11636233e-02f, -3.90549600e-02f, 7.36437854e-04f, -1.12682275e-01f, -1.16750419e-01f, 1.88645311e-02f,
  1.39618181e-02f, 3.14991586e-02f, -4.35631722e-03f, 8.49616006e-02f, 8.55468139e-02f, -1.40797809e-01f, 1.13215379e-01f, 1.39796555e-01f, -2.24912483e-02f, 3.70345116e-01f,
  9.78003442e-02f, -5.73128089e-02f, -4.88006115e-01f, -1.19563445e-01f, -2.23604277e-01f, -2.02702016e-01f, 2.61414074e-03f, 4.56677452e-02f, -8.35369080e-02f, -1.15136825e-01f,
  -3.63187343e-02f, -5.42334355e-02f, -1.61470920e-01f, -8.54780823e-02f, -8.64630681e-04f, -1.44395858e-01f, -1.75202921e-01f, -1.94084525e-01f, -8.29971284e-02f, 2.77190264e-02f,
  2.35152151e-02f, -8.67399648e-02f, -4.34788540e-02f, -7.35459775e-02f, -1.38093174e-01f, -1.50053248e-01f, -2.44330093e-01f, -1.32959366e-01f, -8.82196575e-02f, -1.80002436e-01f,
  -2.29949683e-01f, -1.08987957e-01f, -1.70626864e-02f, 5.58103584e-02f, -1.11659683e-01f, 5.89636043e-02f, -2.41110045e-02f, -1.07520996e-02f, 8.88706967e-02f, -9.44812521e-02f,
  -1.23453207e-01f, -5.72857149e-02f, -3.64653282e-02f, -1.00390799e-01f, -1.62999094e-01f, -7.11042583e-02f, -1.44484460e-01f, -9.27101001e-02f, -2.16234867e-02f, 3.58478092e-02f,
  1.42955005e-01f, 8.78082290e-02f, -8.17864090e-02f, 2.90589221e-02f, 3.58208120e-02f, -1.04013801e-01f, -3.81058455e-02f, -3.80774699e-02f, -9.65510011e-02f, 6.76460564e-03f,
  2.21067015e-02f, -1.48480516e-02f, 1.20261041e-02f, 1.41386250e-02f, 4.04402018e-02f, 2.76428480e-02f, -6.33258075e-02f, -2.55237781e-02f, 2.56390721e-02f, 3.99522819e-02f,
  -2.19169296e-02f, 2.55155265e-02f, 3.77051234e-02f, 3.72596867e-02f, -1.34224733e-02f, -3.10398340e-02f, 4.03747074e-02f, 1.70340091e-02f, -3.26843746e-03f, -7.46372566e-02f,
  -5.13522290e-02f, 2.71183439e-02f, -8.38813856e-02f, 3.50893214e-02f, 8.85047391e-03f, -2.11491436e-02f, -1.04736665e-03f, -1.66342426e-02f, -6.69095758e-03f, -4.43613948e-03f,
  -1.28101572e-01f, -2.23621409e-02f, -2.57415324e-02f, 1.19045628e-02f, -1.06346965e-01f, -5.40409312e-02f, -5.59122227e-02f, -2.70798951e-02f, -6.33805320e-02f, -4.25704606e-02f,
  3.93482037e-02f, 5.10090664e-02f, -4.86244224e-02f, 4.05360609e-02f, -6.08252659e-02f, 6.53364062e-02f, 1.03232898e-01f, -1.16966613e-01f, 5.07201999e-02f, -2.83334311e-02f,
  1.16841100e-01f, 1.71159714e-01f, 1.60162434e-01f, 2.49532387e-02f, 1.03474163e-01f, 5.55370525e-02f, -2.37301458e-03f, -6.47914037e-03f, 7.63241798e-02f, 8.19733143e-02f,
  1.15270419e-02f, 7.48450458e-02f, -9.95502621e-03f, -1.45006284e-01f, -3.04720062e-03f, -8.20141733e-02f, -5.36062829e-02f, -1.07310966e-01f, -8.91748816e-02f, 3.87258641e-02f,
  8.56207311e-02f, 1.90407753e-01f, 5.88198528e-02f, 9.62334201e-02f, 2.99399137e-03f, -1.54607564e-01f, -1.56379402e-01f, 3.72124687e-02f, 5.83970845e-02f, 6.08429052e-02f,
  8.39661211e-02f, -2.62512248e-02f, 3.02028563e-02f, -9.62110907e-02f, 1.35967471e-02f, 1.19631939e-01f, -3.44614941e-03f, 4.32912558e-02f, -2.38563027e-02f, -6.18776940e-02f,
  3.09299171e-01f, -1.05274208e-01f, -5.39964698e-02f, -7.47808143e-02f, 3.49824354e-02f, -8.88150483e-02f, 2.07190588e-02f, -1.37595937e-01f, -5.13651520e-02f, -6.11024871e-02f,
  1.60500910e-02f, -6.70103952e-02f, -1.55736636e-02f, 7.12555572e-02f, -8.93673450e-02f, 5.98584637e-02f, -2.54166853e-02f, -1.56847715e-01f, -6.64251745e-02f, 7.62197226e-02f,
  5.19487448e-02f, -5.19951358e-02f, 3.55741791e-02f, -2.84839533e-02f, -4.58892807e-02f, 2.26559205e-04f, 3.64778265e-02f, 3.22692543e-02f, 5.54264290e-03f, -9.68415514e-02f,
  -2.44732182e-02f, 1.05738066e-01f, 7.95017481e-02f, 4.35197316e-02f, 2.69487556e-02f, 1.06176911e-02f, -4.52197716e-02f, 7.18927290e-03f, 2.89465990e-02f, 2.11776458e-02f,
  -4.08336520e-03f, 6.03953423e-03f, -9.89102107e-03f, -7.00002611e-02f, 1.02427020e-03f, 4.14851345e-02f, 7.39649460e-02f, 3.63183431e-02f, 4.10390720e-02f, -2.60935165e-02f,
  2.94998894e-03f, -3.57094333e-02f, 7.63170868e-02f, -2.53660623e-02f, -3.77097689e-02f, -6.39795465e-03f, 3.05470675e-02f, 1.13051318e-01f, 1.09604277e-01f, -8.90957471e-03f,
  1.20543405e-01f, -8.91711861e-02f, 9.55179334e-03f, -9.30710882e-02f, -9.23751295e-02f, 8.83848500e-03f, 1.34059461e-02f, -3.24120745e-02f, -9.09785628e-02f, 2.96180304e-02f,
  -7.39992186e-02f, -7.24795386e-02f, 2.04985738e-02f, 4.02427204e-02f, 5.79442456e-02f, 3.27899791e-02f, 4.18011770e-02f, -3.97252850e-02f, -9.75361988e-02f, 4.34759073e-02f,
  -9.45023447e-02f, -3.30684707e-02f, 1.67836230e-02f, -6.36310726e-02f, -2.27687564e-02f, 1.00376457e-01f, 1.18588492e-01f, 8.52939710e-02f, -4.00565304e-02f, 2.39920877e-02f,
  1.62147611e-01f, 3.38658392e-02f, -6.75510541e-02f, 1.79879352e-01f, 1.82734519e-01f, 2.13604242e-01f, 1.58449858e-01f, 9.77800488e-02f, 1.41972080e-01f, 7.13499933e-02f,
  3.96288671e-02f, 6.52728826e-02f, 4.71484587e-02f, -2.65869033e-02f, 8.58053342e-02f, -6.91363646e-04f, 3.31613906e-02f, 1.80419851e-02f, -1.38574243e-02f, 2.17822082e-02f,
  -2.54103243e-02f, 5.10418229e-02f, 1.21991131e-02f, -3.06017157e-02f, -1.53297350e-01f, -5.89400018e-03f, -1.14693446e-02f, -1.29121728e-02f, -6.29594699e-02f, -2.05166250e-01f,
  -1.98457420e-01f, -8.10196921e-02f, -1.57995801e-02f, -8.33482370e-02f, -6.32533133e-02f, -6.50163889e-02f, 2.36089285e-02f, -4.33711335e-02f, -7.09492760e-03f, -1.31106721e-02f,
  -4.54276428e-03f, -4.98190038e-02f, -1.25594418e-02f, -3.66394818e-02f, -9.99046937e-02f, 2.08962057e-02f, -1.00971282e-01f, -5.51929101e-02f, -6.52196258e-03f, -3.99867296e-02f,
  -4.03878130e-02f, 3.74742076e-02f, -7.27030784e-02f, -2.86795627e-02f, 7.33844340e-02f, -2.33436301e-02f, -7.41770864e-02f, -1.46626355e-02f, 3.78898792e-02f, -2.74406374e-02f,
  -3.05492729e-02f, -9.18817744e-02f, -3.57673988e-02f, 3.47362235e-02f, 1.97746069e-03f, 5.07719815e-02f, 2.76376549e-02f, 3.65866791e-03f, -5.71866669e-02f, 2.53432468e-02f,
  -3.79968882e-02f, -1.63282901e-02f, -1.65787749e-02f, -4.87784445e-02f, 1.62023194e-02f, -5.99252470e-02f, 9.65492218e-04f, 8.42376146e-03f, -6.35990202e-02f, -3.66366729e-02f,
  -1.25300838e-02f, -1.03580639e-01f, -4.62801419e-02f, -1.40423365e-02f, -3.90053354e-02f, 5.43730892e-02f, -5.21768369e-02f, -7.25169852e-02f, -5.06484434e-02f, -6.24095537e-02f,
  -1.03732266e-01f, 1.07924275e-01f, -2.26656105e-02f, -7.35352412e-02f, -1.06411785e-01f, -8.72564614e-02f, -7.84876868e-02f, -6.25653341e-02f, 1.21024922e-02f, 6.30742162e-02f,
  4.58184816e-02f, -5.98336272e-02f, 4.25774269e-02f, 3.81470397e-02f, 5.31156585e-02f, 6.40996546e-02f, -8.57763141e-02f, -1.18610193e-03f, 2.26809550e-02f, 1.33027812e-03f,
  -1.76715925e-02f, 2.19684411e-02f, -4.26179916e-02f, 9.82675981e-03f, 2.96717659e-02f, 1.60120987e-06f, -2.30439194e-03f, 1.58160143e-02f, -3.12169492e-02f, 5.83145097e-02f,
  2.81575263e-01f, -3.18966001e-01f, 1.02508254e-01f, -1.04735024e-01f, -1.28177196e-01f, -2.06951022e-01f, -2.72722870e-01f, -2.07885087e-01f, -3.65214199e-02f, -1.86821431e-01f,
  6.70904219e-02f, 6.41019881e-01f, 4.69674379e-01f, 4.86948222e-01f, 3.43719840e-01f, -3.38593215e-01f, -1.80578142e-01f, 4.06162888e-01f, 3.81350577e-01f, -9.55583304e-02f,
  -2.94238091e-01f, -1.57829091e-01f, 1.38276398e-01f, 8.12281296e-02f, -3.59776318e-01f, 1.64905936e-01f, -1.78530514e-01f, -1.64442316e-01f, -1.82445481e-01f, -2.81342506e-01f,
  1.41496286e-01f, -6.49531856e-02f, 2.49740332e-01f, 9.40390080e-02f, 2.75299102e-02f, 2.02486292e-02f, -1.65910982e-02f, -8.55802372e-02f, -2.93322653e-03f, -1.31228030e-01f,
  2.19244510e-02f, -1.65564362e-02f, -4.36283499e-02f, -1.01961553e-01f, -2.53454655e-01f, -1.99710540e-02f, -5.06934971e-02f, 1.09235514e-02f, 3.52039747e-02f, -5.65439723e-02f,
  -2.32914641e-01f, -5.15129976e-02f, 2.11048238e-02f, -5.11400923e-02f, 1.09891072e-01f, 2.39471406e-01f, 2.71083023e-02f, -1.18472748e-01f, 1.60656512e-01f, -3.09338003e-01f,
  6.16581999e-02f, 7.98994377e-02f, 6.24161288e-02f, 1.01721540e-01f, 1.10926747e-01f, 7.39990473e-02f, -6.30451813e-02f, -4.09263931e-02f, 1.00324098e-02f, -4.82009612e-02f,
  -1.72718856e-02f, 9.48249325e-02f, -4.84923162e-02f, -1.14189655e-01f, 1.32177979e-01f, 1.09595014e-03f, 4.06885333e-03f, -6.49036234e-03f, 1.12483986e-01f, 1.47648845e-02f,
  1.57374457e-01f, 2.25400494e-04f, 1.03396304e-01f, -2.38168407e-02f, 6.01945892e-02f, -9.31503996e-03f, 1.65391415e-02f, 1.47583663e-01f, 7.00600892e-02f, -1.31910175e-01f,
  1.07039921e-01f, 3.30690235e-01f, -4.32341732e-02f, 7.96006247e-02f, -2.04006687e-01f, 2.54330132e-02f, 5.59362136e-02f, -1.03042766e-01f, 8.35007206e-02f, -9.14139375e-02f,
  7.63451383e-02f, 1.49199277e-01f, 5.05432449e-02f, -4.22020555e-02f, -5.82588650e-02f, 8.14778358e-02f, -1.14523396e-01f, 1.60040751e-01f, 8.40527490e-02f, -3.60217281e-02f,
  -7.70696476e-02f, -6.15554452e-02f, 1.22315370e-01f, 4.32104543e-02f, 1.92035083e-02f, 1.60337731e-01f, 7.64888525e-02f, -2.24143993e-02f, 1.40488446e-01f, -1.92272663e-01f,
  1.42912753e-02f, 8.83257613e-02f, -3.68957698e-01f, 3.53374600e-01f, 3.64184529e-01f, 8.90840515e-02f, -2.40668226e-02f, -5.56040704e-02f, 1.26881376e-01f, 9.58101228e-02f,
  2.45344132e-01f, 3.00578862e-01f, 2.44350746e-01f, 1.57862023e-01f, -1.21728756e-01f, -9.46147069e-02f, -7.49365911e-02f, -8.78659189e-02f, -1.46098405e-01f, 1.88239768e-01f,
  2.21361443e-01f, 1.70124069e-01f, 7.91093931e-02f, 2.05587950e-02f, 7.57276043e-02f, 1.69186503e-01f, -3.41571271e-02f, 9.54277590e-02f, 3.24357748e-02f, -4.35375534e-02f,
  -1.93890274e-01f, -2.03351513e-01f, 9.48943272e-02f, 2.47639135e-01f, -7.50447856e-04f, -1.63057763e-02f, 4.12575677e-02f, -1.72739886e-02f, 1.17594883e-01f, -7.65327364e-02f,
  5.19468635e-02f, -7.36654177e-02f, 1.38109118e-01f, 2.62927227e-02f, -8.07532445e-02f, -4.91929203e-02f, -2.23262116e-01f, -2.10721865e-01f, -2.43915170e-01f, -1.71741024e-01f,
  3.06944698e-01f, 1.53106004e-01f, -1.83289915e-01f, -3.62082273e-02f, -2.37850294e-01f, 3.92348357e-02f, -2.07182765e-01f, -2.22875014e-01f, -1.31972298e-01f, -2.20291480e-01f,
  5.88119887e-02f, -4.18195054e-02f, 3.36221009e-02f, -5.23923412e-02f, -9.42877680e-03f, -6.19368069e-02f, -3.01550925e-02f, -7.01758340e-02f, 2.43370738e-02f, -9.32958443e-03f,
  1.70470234e-02f, -5.14138713e-02f, -1.37219787e-01f, 1.41084238e-04f, 1.88634083e-01f, 6.89052492e-02f, -5.52636757e-02f, -6.10253699e-02f, -3.50738764e-02f, -9.51491967e-02f,
  -7.30747432e-02f, -1.70657068e-01f, -7.76946545e-02f, -1.65458322e-01f, -1.32957473e-01f, -1.74562894e-02f, 9.07142006e-04f, 5.91050759e-02f, 8.69626999e-02f, 9.05002579e-02f,
  1.81604743e-01f, 1.39335617e-01f, -1.60863400e-01f, -1.30927518e-01f, -9.92137194e-02f, 7.66400173e-02f, 1.82042390e-01f, 2.26354450e-02f, -1.52730886e-02f, -3.74282412e-02f,
  -1.07463039e-01f, -8.26192945e-02f, 2.10238025e-02f, -5.08420393e-02f, -8.21739212e-02f, -1.06724277e-01f, -1.71405561e-02f, -8.17101598e-02f, -1.52648583e-01f, -1.15041368e-01f,
  8.08577612e-03f, -5.71574317e-04f, -1.14816278e-01f, -5.60554117e-03f, -2.93715186e-02f, 2.06834778e-01f, -1.92230567e-01f, -1.65318444e-01f, -1.31943196e-01f, -8.61336589e-02f,
  6.30590737e-01f, -1.36748672e-01f, 5.59896119e-02f, -2.68821642e-02f, -1.05661027e-01f, 6.37752563e-02f, -5.94980270e-02f, -1.92738138e-02f, 1.12389050e-01f, 1.41453594e-02f,
  1.27514377e-01f, 1.85780585e-01f, 1.32975519e-01f, 9.74470004e-02f, 6.97958767e-02f, -1.00703195e-01f, 4.73099574e-02f, 2.54593253e-01f, 1.85188428e-01f, 3.13395783e-02f,
  -6.37049526e-02f, 8.53242353e-02f, 1.53409660e-01f, -3.77375353e-03f, 7.48220272e-03f, 1.73291229e-02f, -3.36126052e-02f, -4.81419787e-02f, -2.31092200e-02f, -8.68501887e-02f,
  1.22056901e-01f, 6.33325279e-02f, 4.08559479e-02f, -9.29645300e-02f, -2.94156577e-02f, 4.04109806e-02f, -1.17367022e-02f, -5.34227630e-03f, -5.02774864e-02f, -1.00185752e-01f,
  -5.05385362e-02f, 1.70448031e-02f, 3.06889508e-02f, -1.40189901e-02f, -3.90183628e-02f, -5.65493070e-02f, 8.78028721e-02f, 2.91905459e-02f, 2.46936865e-02f, 2.25746743e-02f,
  3.58025953e-02f, 5.03357616e-04f, -1.92122962e-02f, -9.54698622e-02f, 9.87267569e-02f, 1.22078903e-01f, 3.19785345e-03f, -3.26186083e-02f, 6.65665939e-02f, -2.97138635e-02f,
  1.11721240e-01f, 2.54981995e-01f, 2.20786527e-01f, 1.68960303e-01f, 1.73302770e-01f, 2.02680841e-01f, 4.80466262e-02f, -9.81036797e-02f, 1.27024829e-01f, 1.87161833e-01f,
  3.85929085e-02f, 2.25379411e-02f, -5.94029296e-03f, 5.98045476e-02f, 1.23134449e-01f, 4.14895639e-02f, 6.50601760e-02f, 6.28347993e-02f, 1.10042810e-01f, 5.46468161e-02f,
  8.91551897e-02f, 8.54474604e-02f, 1.55746877e-01f, 4.78577837e-02f, -5.35552986e-02f, 4.58547361e-02f, 1.58839285e-01f, 7.45311305e-02f, 4.60275486e-02f, 6.81240186e-02f,
  -2.59166270e-01f, 1.71647787e-01f, 2.11732119e-01f, 3.38054262e-02f, -7.26168277e-03f, -7.93193746e-03f, 4.55228239e-02f, -2.78354138e-02f, -1.74968749e-01f, -6.83961362e-02f,
  -9.14619640e-02f, 1.08772650e-01f, 1.83561556e-02f, 9.37517732e-02f, 1.38755471e-01f, -5.24187312e-02f, 4.83568758e-02f, 1.05431385e-01f, -1.32981017e-01f, -8.80909786e-02f,
  -3.47734950e-02f, -7.85486493e-03f, -7.66244624e-03f, 6.55282363e-02f, 7.59197474e-02f, 2.23306462e-01f, 3.29034589e-02f, -2.71978378e-02f, -4.26692981e-03f, 1.26733348e-01f,
  5.52924573e-01f, 2.12863401e-01f, 2.25336164e-01f, 3.64859053e-03f, -1.89380869e-01f, 2.04258949e-01f, 2.64507890e-01f, 1.46494508e-01f, -7.28153288e-02f, 7.23675257e-05f,
  -9.38696638e-02f, -1.49911135e-01f, -1.34708971e-01f, -6.21689931e-02f, 1.51705265e-01f, 2.16736153e-01f, 1.20991707e-01f, 1.39331266e-01f, 1.68283656e-01f, 1.19503468e-01f,
  -1.00404009e-01f, 6.84154853e-02f, 1.48609295e-01f, 1.47195965e-01f, -5.15571609e-02f, -1.46672696e-01f, -7.93254003e-02f, 1.94147509e-02f, 5.60511611e-02f, 4.82684840e-03f,
  -6.86640292e-02f, 1.99562594e-01f, -3.81073393e-02f, -1.14408836e-01f, -2.08509434e-02f, 7.31075928e-02f, 1.06261186e-01f, -2.39385534e-02f, -1.24440461e-01f, 6.65016659e-03f,
  5.32859797e-03f, -2.17783302e-02f, -1.06755450e-01f, -6.39969409e-02f, -1.21975318e-01f, 1.72344758e-03f, -7.55279604e-03f, 1.37421470e-02f, -4.55575697e-02f, -6.34898394e-02f,
  -1.84331611e-01f, -4.60681468e-02f, 5.20455539e-02f, 2.68314481e-02f, 3.69585417e-02f, -1.27930492e-01f, -1.80137455e-02f, 9.50309485e-02f, 7.65523762e-02f, 8.58632922e-02f,
  -2.26873562e-01f, 7.64957145e-02f, -2.72376500e-02f, -1.30965665e-01f, -8.00458863e-02f, -9.34728384e-02f, -3.04594077e-02f, 6.84726238e-02f, 3.35680991e-02f, 5.26531190e-02f,
  -9.51973796e-02f, -4.93760221e-02f, -9.01865512e-02f, -5.10371290e-02f, -1.27353609e-01f, -2.59600691e-02f, -8.25411081e-03f, -4.74409610e-02f, -1.22184895e-01f, -9.30688307e-02f,
  -2.28665806e-02f, -9.15430188e-02f, -1.73673689e-01f, -8.62492844e-02f, -4.19122614e-02f, -1.51299641e-01f, -1.03752658e-01f, -9.38867107e-02f, -4.38039452e-02f, -1.13525294e-01f,
  -3.91709238e-01f, 6.64762706e-02f, 6.34629801e-02f, 1.85788557e-01f, 5.92617877e-02f, -4.74721827e-02f, 9.38326344e-02f, -4.41399589e-02f, -2.07695514e-02f, 7.70862922e-02f,
  -1.61032639e-02f, 1.08333126e-01f, -7.00632334e-02f, -9.96086448e-02f, -7.04996660e-02f, -2.71055177e-02f, -1.01510651e-01f, 9.54145752e-03f, -9.88013819e-02f, -1.32670924e-01f,
  -9.35155079e-02f, -1.32882252e-01f, -1.60846204e-01f, -1.52967021e-01f, -4.04595509e-02f, -2.60649949e-01f, -1.94150209e-01f, -2.88251583e-02f, -2.65139863e-02f, -1.17748968e-01f,
  1.32941753e-01f, 3.92201245e-01f, 2.01057762e-01f, 5.55757657e-02f, 6.05856664e-02f, 4.53027897e-02f, 1.13039136e-01f, 8.30245297e-03f, 4.26358311e-03f, 4.90418002e-02f,
  1.19054452e-01f, -7.47936890e-02f, -6.42192438e-02f, 5.12862690e-02f, 4.73147482e-02f, 8.93945843e-02f, 6.49600774e-02f, -7.53533542e-02f, -2.87959695e-01f, -2.22300366e-01f,
  -1.14405103e-01f, -4.85371761e-02f, -1.49295837e-01f, -1.80442080e-01f, 1.64367706e-01f, -4.79833260e-02f, -4.55398764e-03f, 8.11882913e-02f, 4.27452251e-02f, 2.71433622e-01f,
  4.42207754e-02f, 3.45945984e-01f, -4.40601140e-01f, -1.34134457e-01f, 1.34246454e-01f, 1.63642522e-02f, -9.15062204e-02f, -7.76852444e-02f, -5.18586785e-02f, -9.36608703e-04f,
  3.61763723e-02f, 8.20227936e-02f, 9.47893262e-02f, 3.89568210e-02f, 4.19311486e-02f, -8.26951936e-02f, -8.93882364e-02f, 6.97393622e-03f, -2.45480016e-02f, 1.56787455e-01f,
  5.35770878e-02f, 3.03723291e-02f, 4.21293788e-02f, -2.58637127e-02f, 9.44709033e-02f, -1.97892830e-01f, 2.92674303e-02f, 8.47921446e-02f, -1.30980417e-01f, -3.14593241e-02f,
  -2.61624843e-01f, 7.80144632e-02f, 3.72632220e-02f, -5.83635829e-02f, -1.38400897e-01f, -1.91286743e-01f, -4.05301759e-03f, 7.33574033e-02f, -6.20217435e-02f, -1.06469452e-01f,
  -6.04772978e-02f, -1.15146719e-01f, -1.14376722e-02f, -7.05773979e-02f, -1.06885247e-01f, 3.40385304e-04f, -3.29552293e-02f, -8.83392170e-02f, -6.65399879e-02f, -1.30213141e-01f,
  3.60599160e-02f, -6.88874125e-02f, -1.99388582e-02f, -4.59236465e-02f, -1.86672524e-01f, 1.67353842e-02f, -1.42648891e-01f, -9.38825011e-02f, -1.17579237e-01f, -1.93531618e-01f,
  -1.95111603e-01f, -8.07703510e-02f, -1.23451456e-01f, 1.53125405e-01f, 1.82570532e-01f, 1.41005859e-01f, 1.17628723e-01f, 1.20000988e-01f, 8.04394707e-02f, -1.32762687e-02f,
  -1.57291163e-02f, 4.10866700e-02f, 1.55663639e-01f, -9.72876325e-03f, -1.25810936e-01f, -1.41038895e-01f, 8.76303483e-03f, 7.61784911e-02f, -1.19683832e-01f, 1.98192131e-02f,
  -1.60216335e-02f, -2.09568471e-01f, -2.41811678e-01f, -3.23043950e-02f, -1.98517725e-01f, -3.28616709e-01f, -2.70104289e-01f, -2.20283836e-01f, -2.55085349e-01f, -2.57783413e-01f,
  -1.45830020e-01f, 3.22556756e-02f, -2.06073243e-02f, -7.11151809e-02f, -6.59083799e-02f, -9.06514004e-02f, -6.37816414e-02f, 2.47107185e-02f, 1.20836064e-01f, 1.18638590e-01f,
  3.62733752e-03f, -8.91798884e-02f, -2.20316686e-02f, -6.30218312e-02f, -1.32922098e-01f, 5.31201623e-02f, -7.48114521e-03f, -1.73700318e-01f, -2.97336310e-01f, -2.30796561e-01f,
  -1.44719303e-01f, -1.62306875e-01f, -1.99576676e-01f, -1.15728445e-01f, 7.05120489e-02f, -7.57259801e-02f, 6.81023672e-02f, -8.38990957e-02f, -6.69644028e-02f, -7.90145248e-03f,
  7.84344450e-02f, 2.56574582e-02f, -5.13991229e-02f, -1.13314457e-01f, 5.76023981e-02f, 1.58426166e-02f, -1.18766550e-03f, 1.82610881e-02f, -3.03604417e-02f, 2.13003457e-02f,
  -7.66831338e-02f, -4.33908030e-02f, -1.16162170e-02f, -7.08772913e-02f, -6.27069175e-02f, -3.45709771e-02f, -4.89015728e-02f, -1.12590514e-01f, -9.62927379e-03f, 1.64304525e-02f,
  -6.90799057e-02f, -9.96586755e-02f, -3.08042932e-02f, 3.83267589e-02f, 8.13657120e-02f, -8.33566487e-02f, 2.44221911e-02f, 2.50650919e-03f, 4.64188196e-02f, 1.05739169e-01f,
  1.19124517e-01f, 9.02928263e-02f, -5.69700785e-02f, 1.50682619e-02f, 4.23032977e-02f, 3.75628769e-02f, 2.59901676e-02f, -2.48646829e-02f, 1.12244785e-02f, 5.13918363e-02f,
  8.88992921e-02f, 1.18154027e-01f, 7.01957494e-02f, 8.98750722e-02f, 1.65879335e-02f, -7.28045329e-02f, -2.54998468e-02f, -2.68517658e-02f, -3.04339873e-03f, -3.06713115e-02f,
  -4.24606837e-02f, -4.25346233e-02f, -4.90448959e-02f, 3.59527394e-02f, -2.84790881e-02f, 3.61276902e-02f, 1.95301771e-02f, -3.17181088e-03f, -2.06203125e-02f, -6.42871782e-02f,
  7.67662227e-02f, -8.21663216e-02f, 3.44913490e-02f, -8.18545446e-02f, 5.48040643e-02f, 7.14627802e-02f, 1.06851859e-02f, -9.25227068e-03f, 5.13360910e-02f, -4.37870733e-02f,
  -1.09681204e-01f, 1.44893592e-02f, 1.33204311e-02f, -6.65464625e-02f, -5.90521917e-02f, 1.71255283e-02f, -7.33478963e-02f, -1.19831845e-01f, -6.07110970e-02f, -1.20733939e-02f,
  -2.47054622e-02f, -6.86993152e-02f, -9.29404497e-02f, 1.49898836e-03f, 2.81186290e-02f, -1.23610593e-01f, -1.22517943e-02f, -1.48129938e-02f, 4.96487413e-03f, 1.36345789e-01f,
  1.95960309e-02f, -6.84663206e-02f, -1.32779688e-01f, -1.40621901e-01f, 3.48902456e-02f, -7.03129992e-02f, -2.22068414e-01f, -2.72714913e-01f, -7.63055012e-02f, -1.03356957e-01f,
  1.59929141e-01f, 2.64217943e-01f, 4.33852263e-02f, 1.19695142e-02f, -2.46077746e-01f, -3.38285863e-01f, -4.26493317e-01f, -2.64174074e-01f, -3.79366353e-02f, 1.79231584e-01f,
  1.85951352e-01f, 2.19372334e-03f, -1.20978519e-01f, -7.88572878e-02f, 6.44088387e-02f, 1.23513229e-01f, -1.27006352e-01f, 1.44298431e-02f, 3.87323722e-02f, 5.17139994e-02f,
  1.33374408e-01f, -1.13468617e-01f, -1.76694542e-02f, 3.24281305e-02f, 6.12763055e-02f, -2.61509661e-02f, -3.07025686e-02f, -8.39782208e-02f, -7.00410642e-03f, -9.11961272e-02f,
  8.60392302e-02f, 8.67732465e-02f, -2.13200860e-02f, 2.13637948e-02f, -1.24656089e-01f, -4.74244878e-02f, -1.68487787e-01f, -1.59832790e-01f, -1.13589808e-01f, -5.27327554e-03f,
  8.71625319e-02f, 5.09362109e-02f, -7.27731884e-02f, -1.46753967e-01f, -1.65025190e-01f, -2.95448862e-02f, -7.35861138e-02f, -1.70146693e-02f, -1.73642650e-01f, -2.16228440e-02f,
  -8.43774527e-02f, -1.66871045e-02f, -4.70191166e-02f, -1.38823101e-02f, 6.17555380e-02f, -3.75281926e-03f, -5.54008782e-03f, 1.39360758e-03f, 3.58849987e-02f, 7.77537003e-03f,
  -8.10105447e-03f, 2.39965301e-02f, 4.49504294e-02f, -1.26937985e-01f, 4.07082848e-02f, 1.78152658e-02f, -9.75809060e-03f, -1.14908844e-01f, -3.62030044e-02f, -4.37714569e-02f,
  -4.58562709e-02f, -5.72637990e-02f, -6.04300015e-02f, -7.40292594e-02f, -1.05170280e-01f, -1.39449775e-01f, -1.91467553e-02f, 6.41098022e-02f, 1.42720994e-02f, -9.26325843e-03f,
  6.03072383e-02f, -4.85600308e-02f, 1.08434573e-01f, -6.58594519e-02f, -1.23999231e-02f, 3.74853872e-02f, 9.45247561e-02f, -3.26614492e-02f, 7.58969598e-03f, 6.31148219e-02f,
  -3.39704193e-02f, 9.18373279e-03f, -1.13885932e-01f, 1.79687664e-02f, 2.28909682e-03f, 3.58726196e-02f, -1.58266723e-01f, 2.82305256e-02f, -4.86316532e-02f, 4.63122427e-02f,
  -2.38168880e-01f, -1.67702198e-01f, -2.18215939e-02f, -5.31008421e-03f, -6.68464452e-02f, -6.61152527e-02f, -9.05551575e-03f, 6.89020529e-02f, -1.15801767e-01f, -6.16250299e-02f,
  1.17739983e-01f, -5.08903973e-02f, 3.31231277e-03f, -2.34535858e-02f, -1.75653473e-02f, 7.01779723e-02f, 2.34035283e-01f, 1.15900867e-01f, -1.08033931e-02f, 1.88182294e-01f,
  1.32539039e-02f, -3.86771038e-02f, -4.89164516e-02f, -1.03767905e-02f, 6.29273206e-02f, 1.46035835e-01f, 4.98159230e-03f, -2.07001083e-02f, -3.79695781e-02f, -5.78006264e-03f,
  -1.77670810e-02f, -2.37098467e-02f, 2.59688795e-02f, -7.66415000e-02f, -4.81687635e-02f, -7.63739794e-02f, 2.07490977e-02f, -3.77830714e-02f, -6.00312501e-02f, -1.14062726e-01f,
  1.73981071e-01f, -8.71176049e-02f, -5.81432041e-03f, -1.99370995e-01f, 2.57600402e-03f, 3.65954265e-02f, 4.71920930e-02f, 7.70944804e-02f, -2.22110935e-02f, 3.16182859e-02f,
  -1.31974310e-01f, -2.72752643e-02f, -3.23541611e-02f, 2.10168716e-02f, 8.19481164e-03f, 3.42694856e-02f, -9.65754464e-02f, -1.01927124e-01f, -1.08409718e-01f, -6.81041181e-02f,
  -1.60887510e-01f, -1.29118770e-01f, 4.80613206e-03f, -1.25116308e-03f, -6.49168119e-02f, -5.84190264e-02f, -2.98605487e-02f, -9.40896571e-02f, -4.35386784e-02f, 1.37950340e-02f,
  8.86115525e-03f, -5.20247733e-03f, -1.03678495e-01f, -6.92277998e-02f, -7.66130835e-02f, -1.14954770e-01f, -3.99808362e-02f, -1.19268894e-02f, 2.01355517e-02f, 5.89517765e-02f,
  3.39846835e-02f, 1.68911323e-01f, 1.54590294e-01f, 8.17133635e-02f, -3.01728025e-02f, -2.32588649e-02f, 2.39322670e-02f, 3.58071253e-02f, 5.04524447e-02f, 9.81159955e-02f,
  1.26581639e-02f, -7.10299122e-04f, 1.58578306e-02f, 6.97408393e-02f, 7.04862550e-02f, -6.51505683e-03f, 5.29424138e-02f, 5.42712808e-02f, -2.79593337e-02f, 4.57407646e-02f,
  1.95017636e-01f, 7.74344206e-02f, 8.82774889e-02f, -1.52232006e-01f, -2.06238357e-03f, -1.10361381e-02f, 2.61675697e-02f, 6.74169809e-02f, -7.33574806e-03f, 1.53560806e-02f,
  -7.47864395e-02f, 4.82769869e-03f, 3.23276855e-02f, 8.38951245e-02f, 6.37004822e-02f, 6.98210374e-02f, -6.54234318e-03f, -5.54592200e-02f, -8.33114907e-02f, -6.60180226e-02f,
  -1.91546027e-02f, 2.44036652e-02f, 1.07940182e-01f, 7.80244321e-02f, -9.32484046e-02f, 7.55862668e-02f, 9.23624188e-02f, 6.74489960e-02f, 8.81761685e-02f, 1.95259124e-01f,
  4.28459831e-02f, 1.56091690e-01f, 7.20855892e-02f, 5.40138297e-02f, 4.79652220e-03f, 8.44717324e-02f, 1.58703357e-01f, 1.03194535e-01f, 7.11009577e-02f, 6.68498641e-03f,
  -8.38296488e-02f, -3.84142250e-02f, 9.27660055e-03f, -6.14843657e-03f, 7.81657994e-02f, 1.96498916e-01f, 1.78348869e-01f, 9.74673629e-02f, -2.40004845e-02f, -3.31972763e-02f,
  5.19104563e-02f, -6.76873848e-02f, -1.13897674e-01f, 3.58112119e-02f, 1.59492463e-01f, 2.86656152e-02f, 1.84198841e-02f, 3.56983989e-02f, -7.93176424e-03f, 2.45913967e-01f,
  -1.17220916e-01f, -7.27474131e-03f, -7.52507523e-02f, -7.64088482e-02f, -5.10003902e-02f, 5.17686233e-02f, -4.86298613e-02f, -2.34098919e-03f, 3.19197103e-02f, 3.58675979e-02f,
  -7.31474757e-02f, -3.90011370e-02f, -2.36202795e-02f, 3.57950032e-02f, -3.10333520e-02f, 9.51699261e-03f, 3.69857177e-02f, 6.97596446e-02f, 2.51683388e-02f, 2.94776866e-04f,
  2.38059089e-02f, -7.11714774e-02f, -3.12275980e-02f, 1.80647057e-02f, 2.65434701e-02f, -9.74465832e-02f, -4.02138419e-02f, -1.40056871e-02f, -1.51115417e-01f, 4.36828323e-02f,
  -3.57367173e-02f, -4.18043211e-02f, -4.97733355e-02f, 1.90590117e-02f, 1.63984410e-02f, 4.69846502e-02f, 6.36583567e-02f, -2.61332188e-02f, -2.72856876e-02f, 6.08224086e-02f,
  7.22685903e-02f, -1.10342931e-02f, 5.17737232e-02f, 2.31109019e-02f, 2.50566155e-02f, -2.36610253e-03f, 4.35049720e-02f, 1.11365691e-02f, -7.08130300e-02f, 1.10770401e-03f,
  2.91923117e-02f, 7.99629241e-02f, 3.77981588e-02f, 1.28051981e-01f, 2.81787980e-02f, -5.13267890e-02f, -6.88545778e-02f, -3.63969877e-02f, -8.70786086e-02f, -3.61146405e-02f,
  -1.83304697e-01f, -2.40104109e-01f, 6.52468065e-03f, 3.07356808e-02f, -2.08792929e-02f, -8.18235204e-02f, -6.70572892e-02f, -5.16834334e-02f, -2.94707380e-02f, -7.07800407e-03f,
  -8.82327855e-02f, -1.77565515e-02f, -2.95067057e-02f, 4.73546162e-02f, 4.24672104e-03f, 7.86247477e-03f, 7.38397473e-04f, 4.65845466e-02f, 5.22274803e-03f, 3.66016626e-02f,
  4.13280763e-02f, -7.46899322e-02f, -9.24438238e-02f, -6.90622954e-03f, -1.86631270e-02f, -1.37378141e-01f, -7.42552653e-02f, -2.49893442e-02f, -1.53218493e-01f, -7.74119794e-02f,
  -2.67773062e-01f, 1.19273961e-01f, -9.54932999e-03f, 1.41192555e-01f, -1.69530045e-02f, 6.48984388e-02f, 1.63553298e-01f, 1.73410147e-01f, 1.45649850e-01f, 1.09274819e-01f,
  1.04462028e-01f, 1.82921901e-01f, 7.83280656e-02f, 1.33730620e-01f, 6.38031289e-02f, 2.14100361e-01f, 1.89120889e-01f, 2.72413045e-02f, -1.16551787e-01f, 5.95758334e-02f,
  1.18673235e-01f, -1.03393286e-01f, -1.01779178e-01f, -6.08299822e-02f, 1.03242919e-01f, -2.51865163e-02f, -4.22061495e-02f, 6.64663315e-02f, -1.11793475e-02f, 1.64822191e-01f,
  -6.37120456e-02f, -7.46752508e-03f, 7.49381259e-02f, -4.04571034e-02f, -9.10598785e-02f, -4.02130969e-02f, -3.59350592e-02f, 4.31632064e-02f, 1.04799710e-01f, 1.80629522e-01f,
  -1.86934266e-02f, -7.45289251e-02f, 2.78224777e-02f, -6.78242370e-02f, 6.38629571e-02f, 5.03246523e-02f, 1.81303501e-01f, 6.44557253e-02f, 1.50091857e-01f, 9.40234438e-02f,
  2.01317891e-01f, 7.21335411e-02f, 9.29747522e-02f, 8.71876255e-02f, -3.06541659e-02f, 2.84758415e-02f, 1.21957914e-03f, -4.35002614e-03f, 8.04360807e-02f, 1.26880184e-01f,
  1.26936644e-01f, 2.84509748e-01f, 5.49859703e-02f, 7.95604214e-02f, -7.36168073e-03f, 1.23864599e-01f, 9.92166772e-02f, -3.65777947e-02f, -8.70083570e-02f, -1.10272616e-01f,
  2.43380535e-02f, -5.81976585e-03f, 5.28915524e-02f, -1.42168388e-01f, -1.27139449e-01f, 7.45074898e-02f, -9.36395023e-03f, 5.27831912e-02f, -1.86156426e-02f, 1.13364384e-01f,
  2.14733034e-02f, 1.32564098e-01f, -2.14370154e-03f, -2.76927749e-04f, 5.96809722e-02f, 1.07117429e-01f, 1.02423981e-01f, -1.75871216e-02f, 7.46688014e-03f, -4.43981495e-03f,
  1.71228155e-01f, -2.32442454e-01f, -2.29328740e-02f, -8.65031127e-03f, -7.18551204e-02f, 1.34375447e-03f, 2.98535987e-03f, 2.50042435e-02f, 6.32647723e-02f, 1.62098318e-01f,
  6.56002015e-02f, -4.68723029e-02f, 5.49200177e-02f, -5.71768060e-02f, -2.13921964e-01f, -1.54848741e-02f, 1.28119916e-01f, 1.12512723e-01f, 1.80396289e-01f, 1.07908763e-01f,
  7.73732439e-02f, 1.26157209e-01f, 8.35122690e-02f, 4.89044972e-02f, -1.18113108e-01f, -3.01006138e-02f, -1.41810244e-02f, -3.69191132e-02f, -6.03602268e-02f, -1.63464591e-01f,
  4.42335755e-01f, 2.50075817e-01f, 4.17440832e-02f, 2.04021797e-01f, -7.10871629e-03f, -2.01323450e-01f, -2.58672982e-01f, -1.79378703e-01f, 1.28842846e-01f, 1.43001482e-01f,
  1.43938720e-01f, 7.09941536e-02f, 3.60302590e-02f, -2.21096858e-01f, -3.42897445e-01f, -7.46241808e-02f, -1.75030708e-01f, -2.37989217e-01f, -2.85471827e-01f, -2.53198385e-01f,
  -7.88370222e-02f, 1.77195128e-02f, -4.29808311e-02f, -1.06430858e-01f, 3.20197582e-01f, 5.40591106e-02f, 2.01798335e-01f, 2.57828146e-01f, 1.54543594e-01f, 2.22434387e-01f,
  2.19371110e-01f, 4.32505429e-01f, -3.23024482e-01f, 2.74632182e-02f, 1.61030591e-01f, -2.00035106e-02f, -7.20194206e-02f, 3.14882584e-02f, -4.47896495e-02f, 2.14895308e-02f,
  3.84927578e-02f, 4.97681051e-02f, 4.81040888e-02f, -8.70846510e-02f, 4.44573127e-02f, -8.32860395e-02f, -7.19136521e-02f, -1.29185289e-01f, -1.18122242e-01f, 1.12942815e-01f,
  -1.81117386e-01f, 1.48051530e-01f, 1.40889138e-01f, -1.51756778e-01f, 7.02123269e-02f, -6.95562363e-02f, 1.37630746e-01f, 1.42358676e-01f, 7.58301243e-02f, 2.17130199e-01f,
  -6.08663522e-02f, 6.92015663e-02f, 3.38410884e-02f, 3.62339281e-02f, -1.01014584e-01f, -5.02647879e-03f, 6.80685416e-02f, -8.38976353e-02f, -3.81665826e-02f, 1.82627849e-02f,
  -1.45878062e-01f, -3.89935710e-02f, -1.98100582e-02f, 7.06936121e-02f, -7.27385953e-02f, 8.91126245e-02f, -1.04635715e-01f, -1.21284507e-01f, -2.18366198e-02f, -5.46079762e-02f,
  -9.45418105e-02f, -1.16657548e-01f, 7.55974129e-02f, -1.59170732e-01f, 7.93138072e-02f, -3.95662263e-02f, -5.69941029e-02f, -8.62423156e-04f, 5.96299060e-02f, 1.75177976e-01f,
  1.32750675e-01f, -2.82728821e-01f, 1.34933561e-01f, -1.17271423e-01f, 4.11229506e-02f, -6.89572142e-03f, 1.10446149e-02f, -1.05706170e-01f, -2.42303871e-03f, -2.94377990e-02f,
  -2.91861109e-02f, -1.16187476e-01f, 1.07578993e-01f, -1.24261707e-01f, -1.38296559e-01f, -1.12868629e-01f, -2.31132790e-01f, -8.73486474e-02f, -1.70008436e-01f, 2.18044613e-02f,
  -1.25808746e-01f, -1.93208680e-01f, -1.89967737e-01f, -1.53819367e-01f, -5.49026765e-02f, -1.65234685e-01f, -4.76652980e-02f, 2.24383734e-02f, -2.18574733e-01f, -1.89840972e-01f,
  6.26902819e-01f, -5.01577437e-01f, -1.93619221e-01f, 7.49463364e-02f, -1.22098997e-01f, -5.59840538e-02f, -3.50900531e-01f, -1.22401774e-01f, -3.58181186e-02f, -1.73763111e-01f,
  -1.47208929e-01f, 9.66905989e-03f, 8.15391764e-02f, -8.07077810e-02f, 5.87694794e-02f, -2.53710836e-01f, -1.32024556e-01f, 1.16815932e-01f, 8.08287039e-02f, -1.24217361e-01f,
  -6.45322278e-02f, 4.69035245e-02f, 2.01101318e-01f, -5.30182123e-02f, -2.16836482e-01f, -1.57089357e-03f, -1.44481212e-01f, -2.09927678e-01f, -3.38151813e-01f, -2.28964657e-01f,
  -3.40513706e-01f, -6.50370419e-02f, 1.71963215e-01f, -3.88531946e-02f, -1.44838514e-02f, 8.57535079e-02f, 3.22920904e-02f, 6.81956038e-02f, 1.11159973e-03f, -1.86832137e-02f,
  -7.23402947e-03f, -2.70677302e-02f, 1.26576843e-03f, -5.80714121e-02f, 8.31610113e-02f, -6.71598539e-02f, 6.00135848e-02f, -6.10226095e-02f, -1.04120828e-01f, -1.13442846e-01f,
  -1.87893987e-01f, 3.48747671e-02f, -7.71620795e-02f, 1.00406684e-01f, 1.71031922e-01f, 1.35705173e-01f, 5.46393320e-02f, 5.30241989e-02f, 7.23710656e-02f, 4.26370725e-02f,
  -8.55887830e-02f, -2.30790712e-02f, -4.63917814e-02f, 1.64901316e-01f, 1.21579617e-01f, 7.33078644e-02f, 7.31214285e-02f, -3.25162932e-02f, 4.57375906e-02f, 8.56188983e-02f,
  -5.30289784e-02f, 9.85386409e-03f, -2.67253798e-02f, -3.84298116e-02f, -8.03020895e-02f, -1.51423588e-01f, 1.05603747e-02f, -5.84496222e-02f, 2.30509955e-02f, 5.17258747e-03f,
  3.85213159e-02f, -1.93085447e-01f, -1.33991525e-01f, -2.06587732e-01f, -1.11312561e-01f, -8.09529424e-03f, -7.59448260e-02f, -1.55147361e-02f, -6.21254034e-02f, -1.18193291e-01f,
  -2.00742751e-01f, 2.70904452e-01f, 4.56064232e-02f, 8.63429084e-02f, 2.99414825e-02f, 2.89233569e-02f, 3.33291441e-02f, 2.44170874e-02f, -7.00596571e-02f, -1.21685177e-01f,
  -5.27082197e-03f, 1.43730333e-02f, -5.78690842e-02f, -3.20625911e-03f, 2.12372422e-01f, 1.21195547e-01f, 7.00777918e-02f, 1.30401999e-01f, -1.11967213e-01f, -1.33070394e-01f,
  -1.16168894e-01f, 1.75991118e-01f, 1.43211603e-01f, 1.40687555e-01f, 1.14551112e-01f, 1.11146867e-01f, 7.23470822e-02f, -4.82006446e-02f, 1.15948863e-01f, 2.65832096e-01f,
  1.98084697e-01f, -2.96890587e-01f, -3.84936631e-02f, 1.43573284e-01f, -9.26402211e-02f, -2.40371510e-01f, -4.54226613e-01f, -1.06920995e-01f, 1.60404742e-01f, -2.42047757e-01f,
  -1.67432338e-01f, 1.05501600e-01f, 1.30747348e-01f, -4.74028550e-02f, -1.96195930e-01f, -3.82124454e-01f, -1.84900433e-01f, 2.07657684e-02f, -7.58661330e-02f, -3.11939478e-01f,
  -1.78809807e-01f, -9.13583674e-03f, 1.45154491e-01f, 8.83824676e-02f, 3.88100259e-02f, 9.58190486e-02f, 7.06058741e-02f, 2.91225761e-02f, -1.73902094e-01f, -5.24442755e-02f,
  -1.66639045e-01f, -9.61908326e-02f, -8.03357065e-02f, 3.64973098e-02f, -2.99337949e-03f, -3.08022927e-02f, -9.95320454e-02f, 9.76309702e-02f, -2.08667088e-02f, -1.14662595e-01f,
  -2.31415150e-03f, -1.00622922e-01f, 7.21295848e-02f, -1.10617816e-01f, -3.31428237e-02f, -7.68330395e-02f, 6.25181645e-02f, -3.78852412e-02f, 4.05940861e-02f, -9.73864198e-02f,
  -1.85293496e-01f, -6.30792156e-02f, 3.60626057e-02f, -3.66446674e-02f, 1.85468644e-02f, 1.22180872e-01f, -3.62406485e-03f, -5.07780863e-03f, 7.96475038e-02f, -4.54999022e-02f,
  6.67747334e-02f, 1.24423347e-01f, 9.36325360e-03f, -1.50867272e-03f, -3.62388045e-02f, 7.35116228e-02f, 7.21042901e-02f, -8.22730884e-02f, 8.82622693e-03f, -1.57660712e-02f,
  1.89568736e-02f, 4.98996042e-02f, 3.20205055e-02f, -5.95328845e-02f, -1.81275234e-02f, 6.92269281e-02f, -5.77202514e-02f, -5.50350957e-02f, 7.92023726e-03f, -2.31271740e-02f,
  -2.35983897e-02f, -9.33735259e-03f, 1.59565970e-01f, 4.17500250e-02f, -4.13232632e-02f, -5.96766220e-03f, 5.24268951e-03f, 8.39577056e-03f, 8.41611773e-02f, -1.42606199e-02f,
  1.86547980e-01f, -5.60157560e-02f, -8.83294642e-02f, -7.10094273e-02f, -1.47693269e-02f, 3.93944867e-02f, -1.70527156e-02f, -3.74267995e-02f, 3.18614095e-02f, -3.92782874e-02f,
  -1.49959922e-01f, -4.92938748e-03f, 8.82355422e-02f, -6.53394684e-02f, -9.60609838e-02f, -6.07711747e-02f, -1.64625525e-01f, -4.79452871e-02f, -2.94114165e-02f, 1.09442025e-02f,
  -2.16160566e-02f, -1.67700604e-01f, -1.80883277e-02f, 1.42776482e-02f, 3.90843414e-02f, 8.72539729e-02f, 2.04700772e-02f, -4.11418639e-02f, 5.79101592e-02f, -1.43049002e-01f,
  6.35988712e-01f, 2.89661080e-01f, 2.85323977e-01f, 2.20248297e-01f, 1.58042625e-01f, 8.42960626e-02f, 1.05276801e-01f, 5.85852973e-02f, -4.70261164e-02f, 1.32652476e-01f,
  1.64996222e-01f, -2.39400659e-02f, -3.16386744e-02f, -4.30185646e-02f, 5.03967889e-02f, -3.43298912e-02f, -4.38563563e-02f, 1.23328917e-01f, 1.38194010e-01f, 2.12931365e-01f,
  -1.43854488e-02f, 1.77516684e-01f, 2.00235263e-01f, 1.15348436e-01f, 4.48952578e-02f, -4.40449193e-02f, 9.08145756e-02f, 2.27683872e-01f, 1.85922101e-01f, 1.62161231e-01f,
  3.04597080e-01f, 3.19736481e-01f, -1.14456572e-01f, -9.55733806e-02f, 1.01419769e-01f, -6.07163087e-02f, -1.47663187e-02f, -1.93065275e-02f, -2.90752910e-02f, -5.85104078e-02f,
  -1.13996044e-01f, 9.45094898e-02f, 8.00221860e-02f, 6.90221936e-02f, 1.27689511e-01f, -1.35828499e-02f, 6.90471008e-02f, 3.34469825e-02f, -1.61086515e-01f, 2.97357235e-02f,
  3.15417387e-02f, 1.83389023e-01f, 1.02946810e-01f, -1.15180202e-01f, -4.40464877e-02f, -4.23726961e-02f, 6.79518133e-02f, 1.24102049e-02f, 5.88219576e-02f, 9.18482617e-02f,
  -1.64932422e-02f, 1.80610508e-01f, 2.43987858e-01f, 1.80391788e-01f, 1.09774925e-01f, 8.33044052e-02f, 1.02219991e-01f, 5.92132285e-02f, -3.82659100e-02f, 1.29212335e-01f,
  3.84739190e-02f, 1.18424177e-01f, 1.69431806e-01f, 1.74501136e-01f, 1.30796665e-02f, 2.72952080e-01f, 3.12389553e-01f, 1.30739465e-01f, 8.27575028e-02f, -2.29284987e-02f,
  1.34918779e-01f, 9.06461701e-02f, 1.42900020e-01f, -4.70414646e-02f, 1.62354276e-01f, 1.96461365e-01f, 2.04657167e-01f, 9.21135619e-02f, 1.27065003e-01f, 2.45818108e-01f,
  -3.35036874e-01f, -1.14508413e-01f, -1.09799439e-02f, -1.75230168e-02f, -1.26204286e-02f, -4.56015021e-02f, -5.42788282e-02f, -5.19797876e-02f, -6.39298484e-02f, -3.04503646e-02f,
  2.01847404e-02f, 1.12414248e-01f, 5.60151339e-02f, -3.15927938e-02f, -2.43422519e-02f, -1.16362333e-01f, 5.08855507e-02f, -2.24795025e-02f, -8.15944672e-02f, -1.33568689e-01f,
  -7.56834745e-02f, 5.41605242e-03f, 1.25537822e-02f, -2.32053444e-01f, -1.87831279e-03f, -3.46490219e-02f, -4.78796214e-02f, -1.23419836e-01f, -8.54931213e-03f, -5.52198663e-02f,
  6.13384187e-01f, 3.09489995e-01f, 3.73880446e-01f, 2.24731296e-01f, 1.43860146e-01f, 2.62574852e-01f, 3.00388336e-01f, 2.69554019e-01f, 5.01197018e-02f, 2.12879583e-01f,
  1.47801101e-01f, -5.95182404e-02f, 2.45444272e-02f, 9.91864428e-02f, 1.99006751e-01f, 1.13655202e-01f, -1.02636395e-02f, 2.17623934e-01f, 1.09709211e-01f, 4.81098928e-02f,
  2.96523962e-02f, 7.78075382e-02f, 1.30004540e-01f, 1.63832292e-01f, 2.09131297e-02f, -4.26542535e-02f, 5.54609708e-02f, 2.63044727e-04f, -1.90047976e-02f, -5.46361804e-02f,
  -6.67647719e-02f, 1.87636226e-01f, -1.83295935e-01f, -1.20664552e-01f, -3.37665938e-02f, 1.77670717e-02f, 3.16990688e-02f, -1.12043567e-01f, -8.76553729e-02f, -4.88468148e-02f,
  -3.06013823e-02f, -5.67972735e-02f, -4.78692725e-02f, -8.91841352e-02f, -2.43889331e-03f, -5.48334531e-02f, -7.22720334e-03f, -2.17966940e-02f, -6.77820742e-02f, 3.82633656e-02f,
  -1.59136862e-01f, -2.85043065e-02f, -4.52382863e-02f, 5.74593246e-02f, 5.05218022e-02f, -3.94550525e-02f, -1.56150097e-02f, 5.01597673e-02f, 2.14536879e-02f, -2.99345958e-03f,
  -5.01222163e-02f, 5.70026822e-02f, 2.80860048e-02f, 1.11358881e-01f, 1.65541694e-02f, -2.38812976e-02f, -2.96310820e-02f, -2.28399131e-02f, 2.93374900e-02f, 5.56754284e-02f,
  6.18060753e-02f, 1.32139802e-01f, 1.09090671e-01f, 1.37947559e-01f, -4.74565737e-02f, 4.59323004e-02f, -3.49202305e-02f, -1.53019140e-02f, 7.00262040e-02f, 4.80682887e-02f,
  -8.85648746e-03f, -2.34198477e-02f, -3.00170500e-02f, 1.61849521e-02f, -8.83050933e-02f, 4.05790210e-02f, 5.66261485e-02f, 5.33470791e-03f, -2.71946583e-02f, -4.23325859e-02f,
  -2.35241577e-01f, -7.99246952e-02f, 8.12320784e-03f, -9.18777660e-02f, 2.83547696e-02f, 7.98327615e-04f, 1.13471813e-01f, -1.25330433e-01f, -1.11352853e-01f, 8.01469237e-02f,
  -3.49379592e-02f, -3.49692791e-03f, -3.67078707e-02f, -7.75227547e-02f, -1.28975049e-01f, -9.16665569e-02f, -7.76990727e-02f, -1.52210295e-01f, -1.13555439e-01f, -6.41310140e-02f,
  -9.97561067e-02f, 2.65544448e-02f, -1.99534534e-03f, -7.68476501e-02f, -9.48089659e-02f, -1.20170064e-01f, -4.64725941e-02f, -6.49164841e-02f, -4.10067197e-03f, -2.34259311e-02f,
  -2.89621264e-01f, -3.97229157e-02f, 1.81131676e-01f, -2.57216603e-01f, -2.68694293e-02f, 4.85686101e-02f, -8.36110674e-03f, 2.26877211e-03f, -3.49299498e-02f, -5.95826656e-03f,
  1.96356568e-02f, -1.01322755e-01f, -4.71005626e-02f, -7.75580108e-02f, -4.99375947e-02f, 5.33486269e-02f, -1.31833153e-02f, -8.93460810e-02f, -1.28605291e-01f, -6.11612163e-02f,
  -1.22161016e-01f, -1.45847112e-01f, -1.87821046e-01f, -1.04440778e-01f, -1.42490044e-01f, -2.02548847e-01f, -2.57542748e-02f, -1.29309297e-01f, -9.37002078e-02f, -2.03934774e-01f,
  2.42197607e-02f, 2.80325878e-02f, 1.10903032e-01f, -5.80102913e-02f, 2.90962122e-02f, -5.84675744e-02f, -3.84301059e-02f, 5.52922599e-02f, -2.50136908e-02f, 3.86457220e-02f,
  -2.84871180e-02f, 2.10952014e-02f, -2.98756175e-02f, -2.86458284e-02f, -1.28590586e-02f, -4.53975722e-02f, 2.18787417e-02f, 1.96330715e-02f, 9.78012662e-03f, 8.83882716e-02f,
  -5.38806804e-02f, -9.80751365e-02f, -1.05678245e-01f, 3.52575332e-02f, 4.34443243e-02f, -6.82153851e-02f, -4.47413586e-02f, -8.42301920e-02f, -2.59913206e-02f, -2.19525427e-01f,
  2.57864241e-02f, 9.33638290e-02f, 8.07116032e-02f, -2.33250689e-02f, -6.28042370e-02f, 4.34980094e-02f, -1.38519090e-02f, -3.97564843e-02f, -1.41603351e-02f, -4.02691886e-02f,
  8.92838389e-02f, 2.43516508e-02f, -9.11751296e-03f, -2.56593572e-03f, -1.17160603e-01f, -4.32304032e-02f, -6.34086803e-02f, -5.24223223e-02f, -3.93284485e-02f, -5.02187386e-03f,
  -5.06306514e-02f, -8.37841537e-03f, -2.94695497e-02f, -3.86432409e-02f, 7.10262880e-02f, 2.92231739e-02f, 2.24716170e-03f, -6.08809218e-02f, -5.82882538e-02f, -2.27911826e-02f,
  -8.94274712e-02f, 1.10732950e-01f, -1.07667193e-01f, -7.56697804e-02f, 4.73889406e-04f, 2.69782320e-02f, -5.90123497e-02f, 4.08462994e-02f, -1.17528634e-02f, -1.17425686e-02f,
  6.33916780e-02f, -3.50570157e-02f, 1.70798361e-04f, 4.08036932e-02f, 1.79826338e-02f, 2.34358832e-02f, -7.04426505e-03f, -6.25444204e-02f, 1.64088365e-02f, 1.62984245e-02f,
  -7.17010051e-02f, -1.68051243e-01f, -2.34982982e-01f, -9.91217494e-02f, -1.05819084e-01f, -2.30879128e-01f, -2.11892024e-01f, -1.84958696e-01f, -1.70607030e-01f, -2.86277056e-01f,
  -3.02196443e-01f, -2.21074656e-01f, 1.39901331e-02f, 2.60555167e-02f, 1.51149735e-01f, 1.07148238e-01f, 1.60159692e-01f, -8.43074620e-02f, 2.63964329e-02f, 2.01010574e-02f,
  -9.66070294e-02f, -2.10973918e-02f, -1.05155580e-01f, -1.50509939e-01f, -3.47145274e-02f, 1.13111369e-01f, 4.12230752e-02f, 6.89053088e-02f, 1.11816965e-01f, 1.92343220e-01f,
  5.94563261e-02f, 1.45334318e-01f, -9.70221609e-02f, -1.98619105e-02f, -1.05259810e-02f, -3.76144121e-03f, 4.94562015e-02f, 7.26144165e-02f, 6.35836422e-02f, 1.16187565e-01f,
  1.39653444e-01f, -3.66319388e-01f, -1.13589689e-01f, -1.69140294e-01f, -5.79508282e-02f, -1.25482216e-01f, -3.99536267e-03f, 5.02467761e-03f, 9.00361165e-02f, 1.35499254e-01f,
  -3.93005796e-02f, -8.24689046e-02f, -1.11906879e-01f, 4.64409590e-02f, 1.49177179e-01f, 7.33357370e-02f, -3.98907550e-02f, -1.38669973e-02f, -3.84574495e-02f, -8.37573856e-02f,
  -1.72042415e-01f, -7.65562430e-02f, -5.93948327e-02f, -8.78103599e-02f, -3.46838273e-02f, -4.22512256e-02f, 5.38639128e-02f, -4.29594405e-02f, -1.17383808e-01f, -2.66820509e-02f,
  2.20535640e-02f, -1.54324574e-02f, -1.25911966e-01f, -3.68831791e-02f, -1.15014136e-01f, 2.73707770e-02f, 4.52378131e-02f, -6.24132389e-03f, -1.07588910e-01f, 8.34892169e-02f,
  6.49766251e-02f, -1.26614958e-01f, -2.18071733e-02f, 1.31300902e-02f, -1.37593016e-01f, -7.60575235e-02f, -4.54246327e-02f, -1.31559342e-01f, -1.24584511e-01f, -1.99836180e-01f,
  -1.33117661e-01f, -1.09371329e-02f, -4.76030745e-02f, 1.49599388e-02f, 1.11909742e-02f, -8.34045745e-03f, 1.63116418e-02f, -1.46966651e-01f, -4.70993891e-02f, 6.18136115e-02f,
  1.31240860e-01f, -4.10323888e-01f, 2.14334410e-02f, -1.30361632e-01f, -6.16439022e-02f, -1.66453481e-01f, -1.60932675e-01f, -9.15862247e-02f, -3.08132786e-02f, 7.44928047e-02f,
  -9.90407541e-03f, -4.00544591e-02f, -4.12605628e-02f, -2.90369876e-02f, 1.70322970e-01f, 1.26563340e-01f, -9.80387628e-02f, 6.99866042e-02f, 4.50132340e-02f, 9.38774571e-02f,
  -7.81782269e-02f, 6.57966137e-02f, 1.71175063e-01f, 9.72414166e-02f, 6.80415705e-02f, 1.10528134e-01f, 2.04003096e-01f, 6.34137392e-02f, 1.67397752e-01f, 2.92126596e-01f,
  2.29244549e-02f, 1.10683694e-01f, 3.04311365e-01f, -6.71260729e-02f, -4.15512860e-01f, -3.02695721e-01f, -2.26616472e-01f, 2.55524255e-02f, 4.57984358e-02f, 1.10305220e-01f,
  -2.11808085e-01f, -2.65577108e-01f, 7.85082877e-02f, -6.03727587e-02f, 6.31109439e-03f, 2.95063466e-01f, 2.62488246e-01f, 1.38430446e-01f, -2.67048240e-01f, -4.95063603e-01f,
  -3.30663860e-01f, -1.39099851e-01f, -5.81760705e-02f, 7.91235790e-02f, 2.37928614e-01f, -1.36279106e-01f, 2.70027161e-01f, -2.58462485e-02f, 6.79980367e-02f, 4.20726001e-01f,
  2.45258436e-01f, 1.82384714e-01f, -8.51393119e-02f, -1.98990047e-01f, -1.66053265e-01f, 1.60560548e-01f, 6.82506198e-03f, 1.47376031e-01f, -4.12963182e-02f, 1.08878620e-01f,
  -1.94467202e-01f, -1.54646849e-02f, -6.24295995e-02f, 2.77407579e-02f, -8.62265006e-02f, -1.04785986e-01f, 1.47033826e-01f, 1.39444932e-01f, 1.31039754e-01f, -4.07282449e-02f,
  -2.83692241e-01f, -2.60049790e-01f, 3.34766461e-03f, 5.82336746e-02f, 1.81235000e-01f, -1.43250257e-01f, 4.67641689e-02f, 6.94096684e-02f, 1.45907834e-01f, 3.08124721e-01f,
  1.01798736e-01f, 1.81769002e-02f, 1.06884167e-02f, 1.41684011e-01f, -4.21708226e-02f, 4.93073016e-02f, 3.12581621e-02f, -7.70741403e-02f, 2.24838257e-02f, 4.20926185e-03f,
  1.17473558e-01f, 4.90037501e-02f, 1.61509141e-02f, 7.17770532e-02f, 4.93011437e-02f, -9.75583494e-03f, -8.38977918e-02f, 5.69148548e-03f, 6.15965948e-02f, 6.53088465e-02f,
  -7.41511360e-02f, 1.69941899e-03f, -7.32586309e-02f, 6.07698038e-02f, 9.94993299e-02f, -2.93215096e-04f, 1.04577448e-02f, -8.73873457e-02f, -4.60505672e-02f, -5.33388294e-02f,
  -1.29896715e-01f, -1.09198578e-01f, 1.36045441e-01f, 5.56876175e-02f, 4.67556715e-02f, -2.77472362e-02f, 2.89487019e-02f, -1.04695715e-01f, -8.11821520e-02f, -1.11902459e-02f,
  -8.61207619e-02f, 7.84627199e-02f, 1.00607052e-01f, -1.35493828e-02f, -1.66341677e-01f, -2.13080794e-02f, -8.79968703e-02f, -1.77040115e-01f, -1.04149014e-01f, -1.06514595e-01f,
  -8.34807158e-02f, -2.31656313e-01f, -3.08288962e-01f, -1.66950926e-01f, -1.23131551e-01f, -2.57290572e-01f, -4.25439999e-02f, -1.52300611e-01f, -1.62140623e-01f, -6.33258522e-02f,
  -2.64753520e-01f, 3.49431783e-02f, -2.48320431e-01f, 8.25105328e-03f, 1.40388072e-01f, 2.45195508e-01f, 2.27903187e-01f, 1.28068700e-01f, 4.83687036e-02f, 8.42107162e-02f,
  3.78636569e-02f, 1.40791565e-01f, 5.07510044e-02f, 1.21884540e-01f, 1.02491744e-01f, 5.51196672e-02f, 1.00535758e-01f, -5.15710823e-02f, -1.30502256e-02f, 5.56151792e-02f,
  1.42934278e-01f, -1.56242758e-01f, -3.02382618e-01f, -5.58744743e-02f, -3.40365209e-02f, -2.37244833e-02f, -1.56006992e-01f, -2.02758044e-01f, 1.31228000e-01f, -6.66229194e-03f,
  -1.40926063e-01f, -1.54792100e-01f, 9.29529369e-02f, -2.35777218e-02f, 8.57585017e-03f, 3.72003205e-02f, -8.40170775e-03f, -1.50117412e-01f, 5.51050305e-02f, -4.25223559e-02f,
  -5.04017472e-02f, -7.68499598e-02f, -1.66818742e-02f, -9.36815217e-02f, -1.71074599e-01f, -8.35084468e-02f, -2.11341143e-01f, -1.80880979e-01f, -9.16972533e-02f, 1.05985496e-02f,
  2.94645093e-02f, -3.95738594e-02f, -1.31042197e-01f, -5.83914146e-02f, 5.27164713e-02f, -2.71052364e-02f, -1.18846074e-01f, -1.34657696e-01f, -6.37144297e-02f, -1.51406020e-01f,
  -2.79375277e-02f, -2.71039419e-02f, -3.99764217e-02f, -1.49432048e-01f, 5.15186079e-02f, -1.10939384e-01f, 1.10052325e-01f, 1.02167249e-01f, 1.38684772e-02f, -7.27839991e-02f,
  4.67720181e-02f, -5.75732812e-02f, -1.14349782e-01f, -4.59665470e-02f, -4.84065153e-03f, -2.19146516e-02f, 9.10705850e-02f, 3.69372480e-02f, -1.04773067e-01f, -1.29642978e-01f,
  -4.30487618e-02f, -1.13778584e-01f, -1.82466194e-01f, -7.42375627e-02f, -5.36905006e-02f, -1.26578227e-01f, -5.95606714e-02f, 6.37867898e-02f, -1.57526195e-01f, -1.24143243e-01f,
  -1.41302437e-01f, -1.51272875e-03f, 2.94349827e-02f, -4.73548435e-02f, -3.94570418e-02f, -1.20080732e-01f, 7.79328048e-02f, 8.35485756e-02f, -2.22625900e-02f, -4.14577611e-02f,
  -1.53353736e-02f, 3.19988802e-02f, -1.41745165e-01f, -1.03023037e-01f, -4.81372066e-02f, -7.94473216e-02f, -7.57503062e-02f, -2.69859433e-02f, 2.26307791e-02f, -1.55557290e-01f,
  8.32424760e-02f, 2.50840448e-02f, -5.56162186e-02f, 7.15554925e-03f, -8.86325538e-03f, 8.99801552e-02f, -1.86450422e-01f, -9.76997837e-02f, -1.12605006e-01f, -1.22261606e-01f,
  -2.62012362e-01f, 1.95449829e-01f, -1.76637948e-01f, 1.29634082e-01f, 2.31191725e-01f, 8.10087286e-03f, -7.15121403e-02f, -4.88159619e-02f, 1.37151629e-01f, 5.28173372e-02f,
  1.40888855e-01f, 9.06085297e-02f, 1.12076394e-01f, -1.03695374e-02f, -1.72371238e-01f, 3.41170318e-02f, 6.61016777e-02f, -2.52375096e-01f, -4.12349135e-01f, -2.08348140e-01f,
  1.41004220e-01f, -4.50847559e-02f, -2.65348226e-01f, -1.12524010e-01f, 2.07953751e-01f, 4.18802872e-02f, 1.15597069e-01f, 1.03883661e-01f, 2.28398331e-02f, 1.57250270e-01f,
  -1.62699819e-01f, -1.44603640e-01f, -1.09711938e-01f, 4.65018004e-02f, 3.28777209e-02f, -1.87990040e-01f, -8.84956419e-02f, -6.02401271e-02f, -3.10124806e-03f, -9.70847681e-02f,
  1.34348348e-01f, -6.09271750e-02f, 1.24675743e-01f, -6.47371039e-02f, -4.39646691e-02f, -1.41851291e-01f, -3.31674702e-02f, -2.77037859e-01f, -1.95970163e-01f, -1.88053593e-01f,
  1.42663285e-01f, 6.16573244e-02f, -8.00252780e-02f, -1.14111222e-01f, -1.45678133e-01f, -1.17711782e-01f, -2.01641724e-01f, -2.10401759e-01f, -2.97699541e-01f, -1.96805269e-01f,
  -4.80154622e-03f, 7.22304657e-02f, 6.09479658e-02f, -2.88237967e-02f, 1.58548951e-02f, 8.72668922e-02f, 6.75107539e-02f, -2.42902935e-02f, -7.42415804e-03f, -2.27155574e-02f,
  4.02368940e-02f, -1.78945884e-02f, -8.03250745e-02f, 1.60064101e-02f, -3.62820663e-02f, 4.01466973e-02f, -4.78971750e-02f, -5.90485670e-02f, -2.81442832e-02f, -1.09067068e-01f,
  -7.53739625e-02f, -7.70758651e-03f, 1.30342230e-01f, -2.02563740e-02f, -3.40582393e-02f, -3.13327834e-02f, 2.97512710e-02f, -5.44931032e-02f, 2.12996341e-02f, 1.02639012e-02f,
  1.51151828e-02f, -1.10712357e-01f, -5.69164567e-03f, -3.26820500e-02f, -1.15802670e-02f, 7.17799366e-03f, 1.61616933e-02f, -5.29511161e-02f, 5.63400052e-02f, -1.54297918e-01f,
  -1.25404850e-01f, -2.98342854e-02f, 1.54438958e-01f, -6.27247617e-02f, -1.11886933e-01f, 2.42586154e-02f, 1.24534391e-01f, 1.05626183e-02f, -5.65172471e-02f, 1.38103694e-03f,
  8.51816908e-02f, -1.29541501e-01f, -1.13148540e-01f, -1.13471650e-01f, 2.24817935e-02f, -1.31042093e-01f, -1.51673511e-01f, -2.08074018e-01f, -2.73740470e-01f, -2.23971337e-01f,
  -1.57144502e-01f, 3.53213727e-01f, 8.03095326e-02f, -2.28704631e-01f, 2.00230792e-01f, 3.36367518e-01f, 3.02470535e-01f, 2.00494193e-02f, -2.21794918e-01f, 1.43468037e-01f,
  2.14645475e-01f, -1.02567963e-01f, -8.00351277e-02f, 8.37569237e-02f, 1.63814664e-01f, 7.62911141e-02f, -8.92022848e-02f, -7.84296393e-02f, -7.84262121e-02f, -6.16193898e-02f,
  -1.11432485e-02f, -7.50035653e-03f, 4.86828480e-03f, -5.91203682e-02f, -1.83719069e-01f, -1.15449749e-01f, 1.23115227e-01f, 2.02431515e-01f, 2.63942480e-01f, -2.92715937e-01f,
  1.22817747e-01f, 9.14508849e-02f, -1.48618042e-01f, -1.07553363e-01f, 1.15173593e-01f, -1.25674173e-01f, -1.10392682e-01f, -1.03443742e-01f, 7.11700134e-03f, -6.48252144e-02f,
  2.31979098e-02f, 3.44177932e-02f, -2.54007969e-02f, 3.22810635e-02f, 7.22206533e-02f, 9.14048553e-02f, -1.17424622e-01f, 1.42611386e-02f, -7.25033344e-04f, 2.43969671e-02f,
  -9.44027491e-03f, 4.67966078e-03f, 1.71799138e-01f, -3.36985551e-02f, 7.38403425e-02f, -1.38531011e-02f, 1.54791012e-01f, -3.25196162e-02f, 4.56372611e-02f, -1.71339720e-01f,
  -4.59539741e-02f, 2.04546424e-03f, 7.65525103e-02f, -1.44047454e-01f, 4.68708295e-03f, -4.52075573e-03f, 1.31484233e-02f, 6.22284897e-02f, 4.34180424e-02f, 8.77097771e-02f,
  -4.29080091e-02f, -1.11325048e-01f, -9.82630178e-02f, -8.02637190e-02f, -1.98287934e-01f, 4.10397574e-02f, -3.01389620e-02f, 6.96923137e-02f, 5.31911664e-02f, 5.54437600e-02f,
  -6.64151758e-02f, 2.48405095e-02f, -7.14994371e-02f, -3.88842612e-03f, -6.82611316e-02f, -7.68254176e-02f, -7.80534446e-02f, 2.93246042e-02f, -9.04868469e-02f, -7.52835497e-02f,
  -4.56169322e-02f, 1.88117981e-01f, -2.08741054e-01f, -6.30620867e-02f, 5.71815893e-02f, -7.70879956e-03f, -4.53687133e-03f, -5.81651405e-02f, 1.27130123e-02f, -1.54340699e-01f,
  9.87660885e-02f, -1.56918675e-01f, -1.34894531e-03f, -1.02268420e-01f, -1.48682132e-01f, -1.09414823e-01f, -3.17099839e-02f, -8.80904868e-02f, -5.50782122e-02f, 5.50708733e-02f,
  -9.39904433e-03f, -6.32670103e-03f, -1.04638949e-01f, -1.70725688e-01f, -3.72854322e-02f, -2.44000226e-01f, -2.16571949e-02f, -4.79949638e-02f, -8.26262031e-03f, -1.59273028e-01f,
  -1.59038961e-01f, 6.93103522e-02f, 1.42280400e-01f, -1.53037190e-01f, 1.51875556e-01f, 3.90563644e-02f, -2.08469599e-01f, -2.68832862e-01f, 1.83709655e-02f, 1.71486475e-02f,
  1.16278179e-01f, 2.97864843e-02f, -4.40475121e-02f, -1.54415473e-01f, -4.55337465e-01f, -2.48931184e-01f, -1.59676760e-01f, -3.34837168e-01f, -3.84327590e-01f, -1.79730281e-01f,
  -4.02927287e-02f, -1.63528144e-01f, -2.62296200e-01f, -8.92059654e-02f, 1.50646761e-01f, 1.18309982e-01f, 1.73348203e-01f, 1.32462502e-01f, 1.27235070e-01f, 2.57015616e-01f,
  3.28981020e-02f, -3.15565281e-02f, -2.28616036e-02f, 2.41655745e-02f, 8.45608339e-02f, -7.32597988e-03f, -1.40466318e-01f, 3.77379917e-02f, 1.35952272e-02f, -4.72278483e-02f,
  6.06415644e-02f, 4.49077552e-03f, 2.34338623e-02f, 2.72403639e-02f, -1.07505754e-01f, -1.30851731e-01f, -1.08652733e-01f, -2.29308039e-01f, -8.31888765e-02f, -1.89060941e-02f,
  9.04442742e-02f, 5.18024601e-02f, -1.05333880e-01f, -5.40309027e-02f, -8.86604935e-02f, -3.00200414e-02f, 4.44809273e-02f, 5.40815033e-02f, 1.09253628e-02f, 3.33721898e-02f,
  6.66832598e-03f, 3.17049138e-02f, 1.03920931e-02f, 4.50076312e-02f, -2.90547386e-02f, 8.88119936e-02f, 1.95225012e-02f, -8.51227939e-02f, -1.18882945e-02f, -5.17403968e-02f,
  6.77421642e-03f, 4.56614234e-02f, -3.63665372e-02f, -2.58859619e-02f, 2.34102383e-02f, -9.47556868e-02f, 1.44139938e-02f, -3.93969566e-02f, -1.47722187e-02f, 4.18221094e-02f,
  -9.70909148e-02f, -4.13649194e-02f, 6.35986850e-02f, -8.97148922e-02f, 1.61472172e-01f, 5.38366735e-02f, 2.99758278e-02f, 6.34464761e-03f, -4.60546687e-02f, 4.32958491e-02f,
  -1.03048928e-01f, 6.45051524e-02f, 1.41862489e-03f, -1.60352722e-01f, -5.98445237e-02f, 1.66842803e-01f, 1.39081880e-01f, 2.24290416e-02f, 1.08096480e-01f, -3.37070562e-02f,
  -2.54468583e-02f, -6.04506843e-02f, 2.51575280e-02f, -3.32382740e-03f, -1.33777782e-01f, 5.54059632e-03f, -1.08895607e-01f, -1.34911621e-03f, -4.67753559e-02f, 7.39108324e-02f,
  -6.08621538e-02f, -2.23117843e-01f, -3.16917926e-01f, -1.59648180e-01f, -1.12732098e-01f, -2.03220531e-01f, -8.70088711e-02f, -9.24467389e-03f, -1.48942634e-01f, -1.70713723e-01f,
  4.01226550e-01f, 7.09215552e-02f, -6.43400028e-02f, 1.29500881e-01f, -3.94585021e-02f, 6.02139533e-02f, 9.38914418e-02f, 2.05714211e-01f, 7.38273188e-02f, 5.79878613e-02f,
  3.59031595e-02f, 3.86286676e-02f, 7.60306716e-02f, 4.84903157e-02f, 2.41438430e-02f, -5.23986593e-02f, -4.42390218e-02f, 1.12169664e-02f, -6.04157057e-03f, -4.43184972e-02f,
  2.66292077e-02f, 1.48899674e-01f, 1.71517253e-01f, 1.26343668e-01f, -5.25283776e-02f, 8.15880671e-03f, 1.23603344e-02f, -4.56803702e-02f, -9.80166942e-02f, -2.38112405e-01f,
  -1.08773440e-01f, 1.05977558e-01f, 2.71118302e-02f, -7.04322234e-02f, -1.12674840e-01f, 2.88993418e-02f, 1.01710379e-01f, -1.15697160e-02f, 6.44689947e-02f, 1.15042217e-02f,
  -1.77466005e-01f, -7.42401108e-02f, -9.90495179e-03f, -1.72823202e-02f, 8.49292427e-03f, 2.54990649e-03f, 5.01203127e-02f, 3.41605954e-02f, 6.32945122e-03f, -5.72186150e-02f,
  -3.77811454e-02f, -4.12307791e-02f, 1.52191576e-02f, 2.98217982e-02f, -5.31161278e-02f, -1.00739099e-01f, -8.71421546e-02f, -5.26379386e-04f, 6.94476515e-02f, -4.69798967e-02f,
  -3.84923667e-02f, -9.12522897e-02f, 4.04376630e-03f, 8.32332671e-02f, 5.53817898e-02f, -2.76316218e-02f, -8.17449689e-02f, -1.48681805e-01f, -1.01233706e-01f, -1.80659033e-02f,
  -4.80286591e-02f, -4.08791602e-02f, -1.65178571e-02f, 2.65509617e-02f, 4.14196514e-02f, 3.63949127e-03f, -3.05554029e-02f, -1.60688944e-02f, -3.59079875e-02f, 3.72369997e-02f,
  6.54407591e-02f, -1.14373185e-01f, -2.91483197e-03f, -2.01026374e-03f, 5.20734675e-02f, 4.26589660e-02f, 4.90608215e-02f, 1.51734520e-02f, -1.81934442e-02f, 7.05140680e-02f,
  7.17578083e-02f, 1.42848819e-01f, -4.01351340e-02f, 7.61434529e-03f, -1.36360750e-01f, -3.38208638e-02f, -1.20813213e-03f, 4.84326971e-04f, -1.03766650e-01f, -9.30730850e-02f,
  -7.20652714e-02f, -5.10239974e-02f, -5.18835746e-02f, -2.59749983e-02f, -1.15315467e-01f, -1.05792589e-01f, -2.38325093e-02f, -1.41677428e-02f, 6.77970890e-03f, -6.47399873e-02f,
  -6.25957698e-02f, 3.58726270e-02f, -4.71759401e-03f, 4.03864384e-02f, 3.08525078e-02f, 5.15130125e-02f, -1.90979820e-02f, -1.06735881e-02f, 1.09012648e-01f, 1.51233748e-01f,
  -3.49061698e-01f, 7.73679689e-02f, 4.05757613e-02f, 9.50493142e-02f, 2.71287799e-01f, 1.76579356e-01f, 1.98841795e-01f, 1.84451938e-01f, 1.02671959e-01f, 7.36902133e-02f,
  1.47907943e-01f, 1.71268687e-01f, 1.38682932e-01f, 1.10689059e-01f, 1.58906117e-01f, 1.97511405e-01f, 1.75703943e-01f, 8.22440311e-02f, -1.39159169e-02f, -2.62297597e-02f,
  2.28186503e-01f, 1.68471783e-01f, -6.49826750e-02f, 1.00199282e-01f, 8.18886831e-02f, 8.48022997e-02f, 1.67199448e-01f, 1.95657194e-01f, 2.14874938e-01f, 1.12893827e-01f,
  -1.34792747e-02f, 5.47026880e-02f, -8.08959454e-02f, 4.28694449e-02f, 6.56202361e-02f, -2.39271089e-01f, -6.64069206e-02f, 2.36731227e-02f, -3.70975807e-02f, -4.10582237e-02f,
  1.14630163e-01f, -9.33006555e-02f, 1.20290056e-01f, 6.66547120e-02f, 8.34467337e-02f, -7.03116879e-02f, -1.32097632e-01f, 5.88689707e-02f, 1.25522658e-01f, 6.83519617e-02f,
  1.07359692e-01f, 1.08330235e-01f, 5.51642925e-02f, 5.12994006e-02f, -1.37230428e-02f, -5.73026799e-02f, -2.14402638e-02f, 3.42953554e-03f, -6.56464696e-02f, -4.67475355e-02f,
  -1.26138655e-02f, -1.59007564e-01f, 1.04121961e-01f, 7.54531398e-02f, 4.43153530e-02f, 3.58977690e-02f, -2.01255251e-02f, 5.08624353e-02f, 2.76198890e-02f, -1.00709245e-01f,
  1.35015041e-01f, 2.01679319e-01f, -1.82413787e-03f, -1.53353782e-02f, 4.55812272e-03f, -3.44806537e-02f, 6.29418120e-02f, -5.70520423e-02f, 3.58345993e-02f, 1.03897840e-01f,
  9.63405296e-02f, 1.44216502e-02f, -9.09336731e-02f, -1.24415755e-02f, 4.17800210e-02f, 8.97624642e-02f, -2.32159477e-02f, -3.74791771e-02f, -2.27598334e-03f, -4.66810875e-02f,
  3.08695465e-01f, 2.41595432e-01f, -3.01268026e-02f, -1.06620807e-02f, -7.81415403e-02f, -1.82101741e-01f, -6.49455041e-02f, -6.76342770e-02f, 8.25681314e-02f, -3.39689665e-02f,
  -5.12193143e-02f, -2.48939186e-01f, 1.64759494e-02f, 2.51750089e-02f, -1.50008038e-01f, -6.37144893e-02f, -4.04867455e-02f, 5.82676791e-02f, 9.75567326e-02f, 6.14006706e-02f,
  -1.14688883e-02f, -2.90600527e-02f, -9.32524540e-03f, -6.81941491e-03f, -4.24203277e-02f, -1.18497610e-01f, -1.18767276e-01f, -1.43235669e-01f, 1.33092096e-02f, -2.17251286e-01f,
  2.62231082e-01f, 2.76888013e-01f, -3.11984807e-01f, 1.19414568e-01f, -9.13973898e-02f, -3.38309616e-01f, -1.31532043e-01f, 6.51106015e-02f, -6.29031972e-04f, 4.14855219e-02f,
  -1.50906235e-01f, -9.95630696e-02f, 5.55151850e-02f, -9.94974375e-02f, -1.19415142e-01f, -6.26269951e-02f, -1.22671939e-01f, -2.16221541e-01f, -3.05822074e-01f, -3.11046094e-01f,
  -1.91071317e-01f, -8.11659321e-02f, -1.17151313e-01f, -7.94221014e-02f, 1.16179332e-01f, -2.29510795e-02f, -4.18410040e-02f, -1.47400364e-01f, -2.62360841e-01f, -9.97839049e-02f,
  5.56554645e-02f, -1.47602707e-01f, 1.24337934e-02f, -6.25269637e-02f, 1.16120659e-01f, -3.80408652e-02f, -7.32777715e-02f, 1.01007298e-01f, 3.55742536e-02f, 1.06155351e-01f,
  2.44738609e-02f, -8.94669443e-02f, 6.30599037e-02f, 3.70021611e-02f, -4.98271137e-02f, 6.73999637e-02f, 1.69283561e-02f, 5.73102608e-02f, -3.04430407e-02f, -5.02945185e-02f,
  -5.20794317e-02f, -2.03144893e-01f, 4.45042402e-02f, -2.73007937e-02f, 8.78165569e-03f, -1.11651756e-01f, 1.01489909e-01f, -8.20865631e-02f, -4.10189182e-02f, 2.44876653e-01f,
  6.66533709e-02f, 1.07820429e-01f, -9.11491737e-02f, -9.34955776e-02f, -5.78006788e-04f, 5.99284992e-02f, 2.97989938e-02f, 8.00309107e-02f, -3.14775519e-02f, 2.00180382e-01f,
  9.05829519e-02f, -1.07803009e-01f, -7.39413500e-02f, -1.59326904e-02f, -9.95617509e-02f, -6.12149835e-02f, 2.79287174e-02f, -2.11297236e-02f, -9.97302160e-02f, -5.20677343e-02f,
  4.84528653e-02f, -8.76058917e-03f, -7.82600418e-02f, -3.08338404e-02f, -1.29412681e-01f, -1.70563050e-02f, 3.18292226e-03f, -4.03130352e-02f, -4.24489491e-02f, -1.00445546e-01f,
  2.47721896e-01f, -2.05098093e-01f, 1.66890517e-01f, 1.19073860e-01f, -4.21767235e-02f, -4.57690209e-02f, -2.12154835e-01f, -2.04569221e-01f, -2.37448253e-02f, -2.32240647e-01f,
  -2.19120875e-01f, -1.42280623e-01f, 8.75808448e-02f, 1.45123005e-01f, 7.16849938e-02f, -1.41187936e-01f, -4.09262404e-02f, -1.94406174e-02f, -1.21482439e-01f, 7.03070033e-03f,
  1.34977385e-01f, 3.42680626e-02f, 2.41267383e-01f, 1.87959746e-01f, 3.04122791e-02f, -5.44153340e-02f, 9.15518850e-02f, 7.06198439e-02f, -1.75260684e-05f, 2.20780432e-01f,
  4.56387758e-01f, -3.58865857e-01f, -3.97785872e-01f, 4.49193493e-02f, -1.44506851e-03f, 1.43871650e-01f, 1.20107174e-01f, 1.81219742e-01f, 1.04243420e-01f, -1.89915657e-01f,
  -1.20219208e-01f, -1.55701246e-02f, -2.36350030e-01f, -1.31458074e-01f, 9.85066965e-02f, -2.54731178e-01f, -2.31698766e-01f, 4.43329290e-02f, 3.05216074e-01f, 3.61424655e-01f,
  1.03429489e-01f, 1.22184701e-01f, 8.48319679e-02f, -8.84518400e-03f, -1.93281010e-01f, -1.07998475e-01f, -3.72713089e-01f, -1.78280413e-01f, -2.71129429e-01f, -3.46461266e-01f,
  -2.03085393e-01f, -2.81057030e-01f, 9.90875214e-02f, -7.15774447e-02f, -5.50924800e-02f, -1.00839930e-02f, 5.53206466e-02f, -1.18990950e-01f, 2.62001287e-02f, -1.19081236e-01f,
  -9.00432989e-02f, 4.53412719e-02f, -4.00151499e-02f, -3.30217853e-02f, 4.60395496e-03f, 8.74009803e-02f, -1.00104203e-02f, -2.38489565e-02f, -7.48568177e-02f, -1.74732476e-01f,
  -2.18367741e-01f, 3.80674191e-02f, 7.62283802e-02f, -5.55926263e-02f, -1.11815654e-01f, 7.79055804e-03f, -1.07294850e-01f, 1.92994718e-02f, -2.56641302e-02f, -9.03388951e-03f,
  5.33614792e-02f, 1.95351560e-02f, 8.33343118e-02f, 1.63590405e-02f, 2.20685545e-03f, -8.36490765e-02f, 3.82725592e-03f, -8.49800278e-03f, 8.24428275e-02f, -2.58327667e-02f,
  -3.49771162e-03f, -6.25766590e-02f, -8.79090428e-02f, 4.75681853e-03f, -1.17878623e-01f, 2.82134227e-02f, 2.12704763e-02f, -9.55835059e-02f, 1.51309408e-02f, -1.95265096e-02f,
  1.05833896e-01f, 2.66655069e-02f, 1.75451580e-02f, -8.73430818e-03f, -1.19744271e-01f, -8.73522609e-02f, 6.04880005e-02f, 5.93409799e-02f, -9.58829187e-03f, -2.37544570e-02f,
  1.21759444e-01f, -1.13049254e-01f, 1.00830279e-01f, 1.19151346e-01f, 1.47156902e-02f, -3.57348546e-02f, -7.92744458e-02f, -2.35087350e-02f, -1.39605790e-01f, -1.09009696e-02f,
  -5.16351592e-03f, 3.36526521e-02f, -1.22204855e-01f, -6.99329898e-02f, 2.12990612e-01f, 1.16895229e-01f, 2.09763888e-02f, -4.02444117e-02f, 1.98598206e-02f, 8.15546140e-02f,
  -1.43269151e-01f, 1.05645090e-01f, 1.93060994e-01f, 7.92661533e-02f, 7.93934390e-02f, 1.38946921e-01f, 1.02426223e-01f, 5.64939082e-02f, 1.92091763e-01f, 1.37811810e-01f,
  -2.08450228e-01f, -8.97292644e-02f, 9.05623063e-02f, -2.61272669e-01f, -2.80726999e-01f, -4.45517935e-02f, -1.09213278e-01f, -2.24540204e-01f, -1.57998160e-01f, -1.67168722e-01f,
  5.59296906e-02f, 1.15537263e-01f, 1.35792106e-01f, 4.56031226e-02f, 4.38588150e-02f, -2.46349536e-02f, -1.58906668e-01f, -8.17129165e-02f, -1.24028854e-01f, -2.77666211e-01f,
  -2.79074788e-01f, -2.38794655e-01f, -2.91472316e-01f, -2.14416072e-01f, -2.28588536e-01f, 1.95266791e-02f, -7.46527314e-02f, -1.61546737e-01f, -1.39335208e-02f, -6.14133477e-02f,
  1.61844835e-01f, -9.02658477e-02f, 2.77207680e-02f, -5.79612069e-02f, -6.82995990e-02f, 5.96015528e-02f, -6.32775649e-02f, -1.33093998e-01f, -7.37532005e-02f, -8.51695836e-02f,
  -1.22966148e-01f, -3.71804796e-02f, -4.25195657e-02f, 1.97009761e-02f, -1.12414360e-01f, -5.00924513e-03f, -1.43293053e-01f, -1.32997423e-01f, -6.79123029e-02f, -9.83260497e-02f,
  -2.91798450e-02f, -4.98846881e-02f, 1.13640629e-01f, 1.89877357e-02f, -8.68616104e-02f, 4.05402631e-02f, 8.17407742e-02f, -5.92737831e-02f, 1.02391012e-01f, -8.78444314e-03f,
  -3.72672118e-02f, 3.55850123e-02f, 6.80003017e-02f, -8.74183252e-02f, 1.61290057e-02f, 8.36332738e-02f, 9.90298763e-02f, 6.71949089e-02f, 2.93123610e-02f, 7.83612430e-02f,
  -6.03084601e-02f, 6.90660179e-02f, 9.68564488e-03f, -2.68825386e-02f, 6.06629439e-02f, -7.41422847e-02f, -1.71702653e-02f, 5.72557412e-02f, -5.12196608e-02f, 1.42640723e-02f,
  -3.21809947e-02f, -7.22263604e-02f, 7.99107365e-03f, -1.47827268e-02f, -5.66489212e-02f, 5.01192361e-02f, -5.76220639e-02f, 9.29829925e-02f, -5.95772639e-02f, 2.11810973e-02f,
  1.48445904e-01f, 1.59921154e-01f, 4.33776043e-02f, 1.29173407e-02f, -1.03263833e-01f, -1.04893245e-01f, -1.13923075e-02f, -1.14860043e-01f, -1.74148865e-02f, 3.43595222e-02f,
  -1.74589492e-02f, -4.85183224e-02f, 6.99870512e-02f, -1.26473624e-02f, -2.38006078e-02f, -3.56582440e-02f, -1.56854734e-01f, -1.06171984e-02f, -1.40195619e-03f, -1.37182444e-01f,
  -7.37701729e-02f, 5.48963174e-02f, 3.60779166e-02f, 1.43867776e-01f, 4.21001157e-03f, 1.20062187e-01f, 9.61416513e-02f, 1.79301910e-02f, 1.69869065e-01f, -1.14789009e-01f,
  1.37994975e-01f, -2.60217249e-01f, -8.62812102e-02f, 7.74637684e-02f, -1.18072852e-01f, -2.68228650e-01f, -4.35696065e-01f, -1.24776885e-01f, 3.06187402e-02f, -2.65317649e-01f,
  -2.27830425e-01f, 7.69478455e-02f, -5.40996492e-02f, 7.86949415e-03f, -9.89047587e-02f, -3.48010719e-01f, -2.01004311e-01f, 1.35487214e-01f, 3.28910142e-01f, 1.80584997e-01f,
  -8.81521218e-03f, 1.67866454e-01f, 3.34612161e-01f, 2.22459137e-01f, 5.18416278e-02f, 6.59349486e-02f, -1.00210160e-01f, 7.64877126e-02f, -1.48832247e-01f, 2.00499082e-03f,
  -6.29540160e-02f, 1.01911038e-01f, -7.76698217e-02f, 1.57876745e-01f, -5.12958802e-02f, -1.47023397e-02f, -9.23303589e-02f, 4.84436266e-02f, -2.95164268e-02f, -3.45128253e-02f,
  -4.57259566e-02f, -9.98636615e-03f, -6.12702891e-02f, -3.12258769e-02f, -3.31047666e-03f, -1.25808176e-02f, 2.76188757e-02f, 8.46295357e-02f, -5.22440253e-03f, -2.05377553e-04f,
  -8.43742117e-02f, 2.24780198e-03f, -4.39408235e-02f, -8.00245255e-02f, 2.06822585e-02f, -8.99814069e-03f, -2.35320814e-02f, 1.28651410e-01f, -8.32167268e-02f, -3.81545722e-02f,
  -1.60878277e-04f, 2.72539235e-03f, -7.93984160e-02f, -2.94178408e-02f, -3.74656357e-02f, -6.90991357e-02f, 7.75670707e-02f, -6.20887906e-04f, 7.90938064e-02f, 9.87919793e-03f,
  -2.77876034e-02f, -1.45809157e-02f, 5.07768318e-02f, 6.87956363e-02f, 1.13653690e-01f, 4.18827534e-02f, -9.44835506e-03f, 6.70102751e-03f, 3.88916098e-02f, 2.84929499e-02f,
  1.10075831e-01f, -3.09479181e-02f, -9.08567291e-03f, 1.10430773e-02f, -7.49811381e-02f, 4.04716749e-03f, 7.27108344e-02f, 2.30631772e-02f, 9.56296641e-03f, -1.47593999e-02f,
  -1.60784379e-01f, -1.70988962e-01f, -2.20491052e-01f, 6.31272048e-02f, -8.01904649e-02f, 5.21704964e-02f, -4.51299623e-02f, -4.06272188e-02f, -3.26295197e-02f, 5.06419363e-03f,
  -3.00592557e-02f, -6.95084557e-02f, -1.49289042e-01f, -3.09676938e-02f, -8.22798982e-02f, -5.89045845e-02f, -1.95972651e-01f, -5.61617538e-02f, -4.14787903e-02f, -6.95948824e-02f,
  -8.15946609e-02f, -1.03170156e-01f, -2.18818679e-01f, -2.69720554e-01f, -9.08944607e-02f, -1.88120931e-01f, -1.70116261e-01f, -1.33335054e-01f, -3.52116555e-01f, -4.19184387e-01f,
  -1.10981174e-01f, 7.41000399e-02f, -4.83601280e-02f, 5.20403646e-02f, 1.32671282e-01f, -3.25596929e-02f, -9.83140320e-02f, -2.28946090e-01f, -1.14722453e-01f, -1.05027650e-02f,
  2.62243450e-02f, 1.02555245e-01f, 1.03702964e-02f, 6.83329627e-02f, -2.90811695e-02f, 2.36937851e-02f, 1.46541968e-01f, 9.69235227e-02f, -1.19626075e-02f, 1.18565254e-01f,
  1.78624898e-01f, 6.17919639e-02f, -2.67206337e-02f, 4.87998649e-02f, 1.80824086e-01f, 1.17389932e-01f, -1.65919643e-02f, 1.36339650e-01f, 1.72069147e-01f, 3.65103096e-01f,
  5.09614684e-03f, -2.01237097e-01f, -9.50565338e-02f, 2.61871144e-02f, 4.13950160e-02f, -6.04897924e-02f, -5.80919385e-02f, -3.71562093e-02f, 1.10094910e-02f, -1.31164575e-02f,
  1.10948041e-01f, 2.65796129e-02f, 1.30898813e-02f, 3.29522640e-02f, -4.33487929e-02f, -1.01451069e-01f, -4.38451171e-02f, -1.40128985e-01f, -1.18697435e-01f, 1.53159897e-04f,
  2.77173519e-01f, 1.05920844e-01f, -1.29225701e-01f, -1.05268113e-01f, -9.64340270e-02f, 1.01025917e-01f, -2.97895502e-02f, 2.99673527e-02f, -1.57077372e-01f, -1.09419189e-02f,
  -2.51142420e-02f, 3.00864913e-02f, -1.18887806e-02f, -1.56390686e-02f, -9.19048116e-03f, 4.32666577e-02f, 1.87246557e-02f, 8.16139057e-02f, 4.51054499e-02f, -6.18630052e-02f,
  -5.15275486e-02f, -4.30461802e-02f, -1.38626829e-01f, -3.11883055e-02f, 5.58955446e-02f, -3.74231637e-02f, 7.19195306e-02f, 1.27764065e-02f, 3.62488702e-02f, -1.04273744e-01f,
  1.33239897e-03f, -1.61712263e-02f, -4.82374914e-02f, -4.21106480e-02f, -3.42495926e-02f, -4.09244969e-02f, 5.74602075e-02f, 1.94284394e-02f, -6.03231275e-03f, -1.06972903e-02f,
  -2.64377266e-01f, -1.06079102e-01f, -1.00231767e-02f, -2.77104657e-02f, -2.29474381e-02f, 5.40199727e-02f, -5.03361691e-03f, 9.35397968e-02f, 1.07720820e-02f, 1.29716110e-03f,
  -5.73518462e-02f, 1.08632846e-02f, -4.31155935e-02f, -2.14247126e-03f, -3.68684344e-02f, -9.80286151e-02f, 6.16569109e-02f, -3.77006456e-02f, -1.31965771e-01f, -1.87600814e-02f,
  8.41374397e-02f, -1.06947035e-01f, -1.08456776e-01f, -7.68327713e-02f, -3.92303132e-02f, -9.55470949e-02f, -6.49461821e-02f, -1.13500051e-01f, -2.22071946e-01f, -1.62736267e-01f,
  -2.15519518e-01f, 1.12154923e-01f, 4.57846262e-02f, -2.34155267e-01f, 2.36261055e-01f, 9.29872319e-02f, -1.09127864e-01f, -1.67006820e-01f, -8.79412368e-02f, -5.44106551e-02f,
  2.42142856e-01f, 1.32776290e-01f, -1.13008842e-01f, -2.50973273e-02f, -1.74859047e-01f, -2.36895770e-01f, -2.18642280e-01f, -1.56236589e-01f, -5.72796073e-03f, 2.76903093e-01f,
  1.65321842e-01f, -9.16768834e-02f, -1.46891460e-01f, -7.94708580e-02f, -1.02052875e-02f, -2.75420155e-02f, -1.72093719e-01f, 2.71559646e-03f, 7.45875761e-02f, 9.20799002e-02f,
  -3.64944823e-02f, -9.25237965e-03f, -1.62345897e-02f, 7.94876441e-02f, 9.12519395e-02f, -1.27305135e-01f, -8.25808346e-02f, -9.41638201e-02f, 1.29798558e-02f, -8.37738290e-02f,
  1.14245005e-01f, 1.16379060e-01f, 2.94733956e-03f, -1.21338228e-02f, -9.63340476e-02f, -4.19220328e-02f, -1.23694673e-01f, -1.49153367e-01f, -1.95952341e-01f, 5.30070923e-02f,
  1.07114509e-01f, 7.82751217e-02f, -1.08329996e-01f, -6.96049780e-02f, -1.99041411e-01f, -1.61037058e-01f, -7.41333067e-02f, 1.37652382e-02f, -1.72279686e-01f, -1.21412307e-01f,
  1.78073216e-02f, 2.64344588e-02f, 8.18782952e-03f, -2.03244127e-02f, -1.94238089e-02f, -3.44798118e-02f, -6.97107315e-02f, -1.22497883e-02f, 5.93216624e-03f, 2.07050927e-02f,
  1.06294081e-02f, 9.20188576e-02f, -1.57928038e-02f, 1.54089490e-02f, 7.99152851e-02f, -3.38326879e-02f, 2.73448639e-02f, -4.47988184e-03f, -1.07972790e-02f, 1.98515654e-02f,
  -3.28057148e-02f, -5.67805283e-02f, 2.51650009e-02f, -5.70537858e-02f, 6.38219640e-02f, -7.32909590e-02f, -1.55184446e-02f, 9.25887972e-02f, 1.84779018e-02f, 2.27133576e-02f,
  -2.22430497e-01f, -2.67648231e-02f, -1.42689854e-01f, 3.86833102e-02f, -5.95474318e-02f, 5.77164702e-02f, 1.18516171e-02f, 9.36358422e-03f, -4.13575806e-02f, -3.88115868e-02f,
  8.20290521e-02f, -4.12847772e-02f, -1.22234419e-01f, -1.82148591e-02f, -1.10594444e-01f, -4.97975014e-02f, -5.79595864e-02f, -6.55718595e-02f, -7.14048073e-02f, 1.99780837e-02f,
  -1.65846646e-01f, -1.54952079e-01f, -2.69138247e-01f, -1.93249017e-01f, -1.68657944e-01f, -2.20582381e-01f, -2.03120798e-01f, -1.02987424e-01f, -2.58109242e-01f, -3.74331743e-01f,
  1.28900543e-01f, -3.04490536e-01f, -3.60580146e-01f, -1.29408717e-01f, 1.36245405e-02f, 1.27125457e-01f, 1.95143968e-01f, 1.44736201e-01f, 2.99438424e-02f, -1.10592274e-02f,
  -8.33427608e-02f, -1.86555937e-01f, -3.48040670e-01f, -1.63658872e-01f, -1.14519987e-02f, 4.81503503e-03f, -7.96095952e-02f, -1.20984927e-01f, 1.35393038e-01f, 2.60993540e-01f,
  1.37008667e-01f, 4.57375403e-03f, -3.85289639e-02f, -4.08752449e-02f, -1.04363158e-01f, -1.25757888e-01f, -2.46422842e-01f, -1.75507203e-01f, -8.95338953e-02f, -2.66704261e-01f,
  -1.52393118e-01f, -1.64650679e-01f, 2.65669171e-02f, -7.59936199e-02f, -3.14151272e-02f, 4.74587530e-02f, 4.24908437e-02f, -1.25492319e-01f, -5.70228957e-02f, -3.22074480e-02f,
  -9.83733013e-02f, 5.81145547e-02f, -9.33753848e-02f, -6.14884533e-02f, -2.38098428e-02f, 5.50558306e-02f, -9.86158624e-02f, -2.00053826e-02f, -7.53816292e-02f, -9.00120586e-02f,
  -6.21767938e-02f, -2.86183208e-02f, -3.24385762e-02f, 6.93343729e-02f, 5.34054413e-02f, -2.31955536e-02f, -2.16695871e-02f, 5.16368113e-02f, 6.11491175e-03f, -5.06212749e-02f,
  8.57462958e-02f, 5.45128696e-02f, 1.04931645e-01f, 3.72806638e-02f, 8.51842314e-02f, -1.54226844e-03f, 1.31863973e-03f, 5.14994822e-02f, 4.89676334e-02f, -6.20513819e-02f,
  -2.22598575e-02f, 3.23763653e-03f, -4.25659679e-02f, -2.57395189e-02f, -5.44571579e-02f, -4.68114242e-02f, 4.37396839e-02f, 1.09014660e-02f, -7.95887113e-02f, 3.23512778e-02f,
  1.94892175e-02f, 6.25815764e-02f, -4.75688428e-02f, -3.13401339e-03f, -4.43017390e-03f, -2.67966129e-02f, -3.61475674e-03f, 1.34655396e-02f, -2.33432483e-02f, 4.56904992e-02f,
  -1.11870781e-01f, -9.41210762e-02f, -2.86850166e-02f, 2.17005232e-04f, -5.13316952e-02f, -1.30429510e-02f, -2.64050979e-02f, 4.35036328e-03f, -1.24742709e-01f, -1.83491949e-02f,
  -3.65263708e-02f, -5.84533997e-02f, -1.70459598e-01f, -8.34828336e-03f, 6.89345300e-02f, 3.23412679e-02f, 3.34269181e-02f, -1.23022154e-01f, -5.48146777e-02f, 2.56050471e-02f,
  8.15757271e-03f, 1.27614737e-01f, 1.64231613e-01f, 2.99030878e-02f, 7.34930485e-02f, 1.23265885e-01f, 3.05560343e-02f, 7.65294358e-02f, 8.18869099e-02f, 1.28095135e-01f,
  5.24339795e-01f, 7.03430027e-02f, 3.86930108e-02f, 1.75169006e-01f, -1.00841634e-01f, 3.36348712e-02f, 1.30295947e-01f, 1.48750812e-01f, 1.45693719e-01f, 8.53323564e-02f,
  1.03496611e-01f, 2.43673012e-01f, 1.14564098e-01f, 1.87456399e-01f, 1.00423649e-01f, 8.29828084e-02f, 7.24366978e-02f, 2.08459869e-01f, 4.32153158e-02f, 1.95104435e-01f,
  2.05671430e-01f, 5.90315387e-02f, 5.81873395e-02f, 1.15386970e-01f, 2.06968769e-01f, 1.58799648e-01f, 3.93210463e-02f, 7.74858445e-02f, 1.10481471e-01f, 2.71989167e-01f,
  9.10014063e-02f, 2.46938705e-01f, -1.20568074e-01f, -1.04989549e-02f, -5.14918305e-02f, -4.27651815e-02f, 1.45768914e-02f, -9.33518261e-03f, -3.22103463e-02f, -2.96579953e-02f,
  -1.28904030e-01f, 1.29204821e-02f, -2.62186695e-02f, -3.30390222e-02f, -7.08495080e-02f, -2.06707492e-02f, 7.70402253e-02f, 1.49631009e-01f, -4.06882241e-02f, -8.95937532e-03f,
  -3.08086667e-02f, -5.32699600e-02f, -2.14301765e-01f, 3.65817025e-02f, 3.11554335e-02f, -6.96756244e-02f, 2.48030201e-02f, 7.33179972e-02f, -3.74067686e-02f, 1.63404182e-01f,
  1.33532181e-01f, 2.99488474e-02f, 2.03097835e-01f, 1.56358942e-01f, 2.75084168e-01f, 1.22310922e-01f, 7.48273777e-03f, -1.21528246e-02f, 1.19248688e-01f, 9.93363112e-02f,
  3.95174176e-02f, 6.73135146e-02f, 1.11860875e-02f, 7.39130238e-03f, 9.96199548e-02f, -4.22395952e-02f, -9.90790576e-02f, -1.52937755e-01f, 4.96446993e-03f, -1.55618101e-01f,
  8.62350315e-02f, 8.09028093e-03f, -1.27524555e-01f, -7.18832423e-04f, -3.54026607e-03f, -1.25273922e-02f, 5.72918132e-02f, -6.64190724e-02f, -1.04790837e-01f, -1.27359219e-02f,
  -4.86949772e-01f, -1.30495474e-01f, 1.06206499e-01f, 4.70443349e-03f, -6.79578781e-02f, -2.74069654e-03f, 5.60677648e-02f, -8.46328735e-02f, -1.29626274e-01f, -1.01223409e-01f,
  -1.03261985e-01f, 8.27703103e-02f, 2.10974924e-03f, -2.52719335e-02f, -6.29742369e-02f, -1.74402422e-03f, 1.54244266e-02f, 1.82814803e-03f, -1.50794700e-01f, -1.49486318e-01f,
  -1.25146493e-01f, -2.10669756e-01f, -2.28588462e-01f, -1.23553671e-01f, 3.85169163e-02f, -2.50292867e-02f, -1.19891219e-01f, -9.78244022e-02f, -9.78062898e-02f, -1.45919487e-01f,
  -5.19373178e-01f, 1.14502557e-01f, -1.87198758e-01f, -3.02261204e-01f, 9.64136645e-02f, 2.57404715e-01f, 4.29656029e-01f, 1.71147212e-01f, -9.71344560e-02f, -5.45387827e-02f,
  4.93883528e-02f, 1.98110826e-02f, -6.28361627e-02f, 1.32832125e-01f, 2.09558547e-01f, 2.08327428e-01f, 3.67291160e-02f, -5.71058020e-02f, 1.17014572e-01f, 1.90906495e-01f,
  1.04512811e-01f, -1.35352612e-01f, -3.30742687e-01f, -9.36269239e-02f, -1.93503082e-01f, -8.38193521e-02f, -1.91658124e-01f, -1.61240309e-01f, 1.09382771e-01f, -9.03585926e-02f,
  -2.59083420e-01f, -2.14366794e-01f, 1.30524948e-01f, -9.95372385e-02f, -9.90287960e-02f, -4.48516048e-02f, 2.36293450e-02f, -1.78499773e-01f, -3.34367119e-02f, -8.11445192e-02f,
  -7.12263733e-02f, 2.12737769e-02f, -8.55950192e-02f, 5.56002669e-02f, -5.21663725e-02f, 3.93408872e-02f, -6.43289313e-02f, -1.01098521e-02f, -7.80404434e-02f, 4.67443652e-02f,
  2.02848628e-01f, -8.71054605e-02f, -1.96391582e-01f, 9.91713777e-02f, 4.51750644e-02f, -1.23074383e-01f, -6.98368102e-02f, -2.66620722e-02f, -8.73970762e-02f, -2.14524046e-01f,
  -4.09076773e-02f, -1.64804943e-02f, 5.72906882e-02f, -1.69943068e-02f, -4.85745557e-02f, -1.05220769e-02f, 1.11771165e-03f, 6.75642565e-02f, -6.78534955e-02f, -1.44613220e-03f,
  9.47562829e-02f, 1.18884826e-02f, 4.03571427e-02f, -1.16351426e-01f, -3.44591658e-03f, -1.14554852e-01f, 8.81794468e-02f, -1.44276293e-02f, -9.00831521e-02f, 3.92988371e-03f,
  1.51312165e-02f, 3.25372964e-02f, -8.41087401e-02f, 8.66723359e-02f, 1.47241140e-02f, -1.62342321e-02f, -9.19752717e-02f, 5.48117645e-02f, -2.14196388e-02f, 1.35866320e-02f,
  -2.01443866e-01f, 4.87603769e-02f, -1.24344639e-01f, 6.21703863e-02f, -1.20924048e-01f, -7.44947651e-03f, -1.03123792e-01f, -2.94416174e-02f, -9.23302919e-02f, 1.59489401e-02f,
  3.96462977e-02f, -5.25208004e-02f, -9.69888121e-02f, 1.31537840e-01f, 1.60138495e-02f, -3.14432979e-02f, 2.95841955e-02f, 1.26426630e-02f, 2.84971129e-02f, -3.69133353e-02f,
  4.42678705e-02f, 6.57908991e-02f, -1.80457652e-01f, 5.95634729e-02f, -5.73017448e-02f, -1.42727286e-01f, -1.34114280e-01f, -2.77566649e-02f, -7.97528774e-02f, -1.59831822e-01f,
  -1.35843351e-01f, -1.46927744e-01f, 1.23464018e-01f, 1.53364584e-01f, 1.29086271e-01f, 3.61648314e-02f, -6.01742268e-02f, -5.63447587e-02f, 2.28935741e-02f, 1.93124954e-02f,
  3.06418501e-02f, 5.98940887e-02f, 4.67679873e-02f, 2.79735047e-02f, 1.67495888e-02f, 6.34772852e-02f, 1.86657697e-01f, 1.81414172e-01f, 1.53310478e-01f, 7.19880462e-02f,
  1.24948688e-01f, 6.87020719e-02f, 3.86608131e-02f, 3.66656929e-02f, 8.93140435e-02f, 1.53739348e-01f, 1.14552617e-01f, 3.67926955e-02f, 6.39613718e-02f, 1.86981440e-01f,
  9.23997313e-02f, -2.06244603e-01f, 9.63061526e-02f, -1.16961272e-02f, 5.79950260e-03f, -2.61089182e-03f, -4.06540446e-02f, -7.79792145e-02f, -5.49757779e-02f, 3.58920242e-03f,
  1.37418136e-03f, -6.29827008e-02f, -7.23316446e-02f, -8.12194347e-02f, 1.24739681e-03f, -7.74462596e-02f, -7.40607381e-02f, -1.41906030e-02f, 2.95594102e-03f, -9.20705870e-03f,
  6.51995540e-02f, -4.66820039e-02f, -4.54562940e-02f, -8.01179186e-02f, 2.96553168e-02f, 5.70840761e-02f, -5.60508519e-02f, -5.57972901e-02f, -6.54979125e-02f, -2.96566505e-02f,
  2.47094169e-04f, -3.07916999e-02f, -7.45514855e-02f, -1.11117676e-01f, -3.73397507e-02f, -7.86297396e-03f, 2.45241988e-02f, 1.54017925e-03f, -1.63867008e-02f, -4.75502620e-03f,
  4.63914983e-02f, 9.70847234e-02f, 6.93926439e-02f, -1.30600566e-02f, -1.71785671e-02f, -5.35536818e-02f, 4.10047658e-02f, -1.78509261e-02f, -8.37305933e-02f, -8.56213868e-02f,
  -4.85431775e-02f, 6.79780869e-03f, -3.77720669e-02f, -2.34350879e-02f, -8.50702822e-03f, -3.53065170e-02f, -9.12727509e-03f, -2.31100041e-02f, 1.84283275e-02f, -9.77545530e-02f,
  -4.22456227e-02f, -1.00815549e-01f, 3.17056179e-02f, -3.22551392e-02f, 4.70639616e-02f, 8.36158730e-03f, -4.04189304e-02f, -6.44313097e-02f, -2.21473183e-02f, 2.33661067e-02f,
  -6.12831041e-02f, -1.80429146e-02f, -7.07262829e-02f, -1.82517599e-02f, 4.19534147e-02f, -4.56739170e-03f, -5.47912456e-02f, 2.27099452e-02f, -1.05898201e-01f, 2.69693919e-02f,
  4.94914204e-02f, -6.36457577e-02f, 5.33000790e-02f, 8.09131712e-02f, 3.75680849e-02f, 5.83259612e-02f, 8.07445794e-02f, 9.66681018e-02f, -8.49557742e-02f, -5.96674450e-04f,
  2.26780042e-01f, 1.42747074e-01f, 1.86646551e-01f, 1.22986268e-03f, -3.71498019e-02f, 2.23602310e-01f, 3.26982290e-01f, 1.87257662e-01f, -1.35919318e-01f, 1.46938665e-02f,
  -1.40788272e-01f, -2.30376929e-01f, -2.57116973e-01f, -1.89668253e-01f, 4.15292159e-02f, 2.91203469e-01f, 1.60466120e-01f, 1.22403294e-01f, 3.69154848e-02f, 9.24703553e-02f,
  -7.76249766e-02f, 3.55220102e-02f, 5.81226982e-02f, 6.09726757e-02f, -1.06562041e-01f, -2.07375780e-01f, 1.63686052e-02f, -2.40293033e-02f, 9.80320647e-02f, -8.75822678e-02f,
  2.14994159e-02f, 1.24475308e-01f, -1.51600406e-01f, -2.23904788e-01f, -1.55144632e-01f, -8.44098255e-03f, -5.84759489e-02f, -9.74640623e-02f, 3.85716259e-02f, 6.69712424e-02f,
  -5.70551045e-02f, -1.07858263e-01f, 1.84637867e-02f, 6.00876771e-02f, -4.83627245e-02f, 3.07592656e-02f, 8.84094741e-04f, 9.17029334e-04f, 4.00816984e-02f, 3.78319062e-02f,
  -6.04972094e-02f, 1.03614666e-01f, 7.08425837e-03f, 9.76820514e-02f, 1.08484209e-01f, -2.13851072e-02f, -5.38675673e-02f, 2.16617938e-02f, 1.92821715e-02f, 4.57585715e-02f,
  -1.78049237e-01f, -3.39104398e-03f, -5.09117059e-02f, -4.25281301e-02f, 1.10963993e-01f, -7.68603534e-02f, 7.74178952e-02f, 4.39123018e-03f, 1.66021995e-02f, 8.86117890e-02f,
  1.13206491e-01f, 2.24749416e-01f, 2.64575869e-01f, 1.13790840e-01f, -8.60802606e-02f, 1.33133590e-01f, 2.21781299e-01f, 9.72830802e-02f, -5.71431266e-03f, 1.09968945e-01f,
  4.39665429e-02f, 1.38373703e-01f, -2.90396474e-02f, -8.70596804e-03f, 4.25361171e-02f, 7.71954730e-02f, 2.77543906e-02f, 3.26295346e-02f, -3.66873220e-02f, 1.18926384e-01f,
  -2.39489973e-01f, 3.29506397e-02f, 1.51773943e-02f, -7.60332048e-02f, -1.09859392e-01f, -1.00963123e-01f, -1.38439894e-01f, -1.66755155e-01f, 7.45551568e-03f, 6.80983439e-02f,
  2.78018098e-02f, -3.39374803e-02f, 4.99999300e-02f, 3.30381840e-02f, 9.79924127e-02f, -8.07556957e-02f, -1.48981869e-01f, -3.80366296e-02f, -1.17024072e-01f, 8.30999389e-03f,
  -1.75702870e-02f, 1.07655846e-01f, 1.46804914e-01f, 9.33488309e-02f, -6.06262647e-02f, 2.54428796e-02f, 2.74812635e-02f, 6.47771284e-02f, 1.05616510e-01f, 7.69732147e-02f,
  4.18261439e-01f, -7.30402321e-02f, 2.43790537e-01f, 1.07595280e-01f, -1.06788583e-01f, -2.93987900e-01f, -3.94711494e-01f, -3.28042388e-01f, -2.57694442e-02f, -1.28427118e-01f,
  -8.01255647e-03f, 2.12581486e-01f, 1.41155809e-01f, 1.02580041e-01f, 1.21002838e-01f, -1.40810460e-01f, 1.43325940e-01f, 3.98557663e-01f, 2.75617778e-01f, 8.88260752e-02f,
  9.84948799e-02f, 2.27933913e-01f, 3.63483846e-01f, 2.26000324e-01f, 8.06401819e-02f, 2.29582056e-01f, 1.55453369e-01f, 2.24547446e-01f, 9.11224410e-02f, 3.29501748e-01f,
  4.79427129e-02f, -4.27451618e-02f, -5.82694262e-02f, 2.23114595e-01f, 2.02212051e-01f, -6.71142619e-03f, -2.72677634e-02f, 7.06039071e-02f, 1.04840891e-02f, 3.58731523e-02f,
  2.26255339e-02f, 1.34656683e-01f, 5.22767305e-02f, 7.49926046e-02f, -8.18673670e-02f, -1.31101698e-01f, -3.98684628e-02f, 7.23450556e-02f, 1.19954057e-01f, 9.91865098e-02f,
  1.78461283e-01f, 1.16077587e-01f, -1.57986041e-02f, -2.25196972e-01f, -5.55428565e-02f, 1.28620863e-01f, -1.25141457e-01f, 2.32519470e-02f, -1.21775180e-01f, -1.41388352e-03f,
  6.42691180e-02f, 1.38042092e-01f, 1.19709715e-01f, 6.75246119e-02f, 1.10352956e-01f, -4.90877032e-02f, 1.59350988e-02f, 9.30856168e-03f, 6.27646595e-02f, -5.99116609e-02f,
  2.35532802e-02f, 4.08355296e-02f, 5.56389019e-02f, -4.14271019e-02f, 1.18845239e-01f, 6.22431152e-02f, -2.12355517e-02f, 2.40270253e-02f, 7.35475048e-02f, 7.97104910e-02f,
  6.72603995e-02f, 3.52470502e-02f, 9.22913253e-02f, -7.94999860e-03f, 5.22138178e-02f, 5.58182895e-02f, 2.69406606e-02f, 3.15261073e-02f, 5.10061421e-02f, 5.32490425e-02f,
  -2.17599481e-01f, -1.32687800e-02f, -1.84731241e-02f, -1.01181380e-01f, -3.63332145e-02f, -4.86387834e-02f, 1.58481691e-02f, -2.54034391e-03f, 2.30250247e-02f, -4.81040729e-03f,
  -1.45787165e-01f, -1.00161090e-01f, -1.09282814e-01f, -9.31613594e-02f, -2.02866234e-02f, -1.12192884e-01f, 3.82444747e-02f, 2.66036149e-02f, -5.20767942e-02f, -1.03626743e-01f,
  -5.55305742e-02f, -2.34716684e-01f, -1.01423316e-01f, -2.14732721e-01f, -2.08254412e-01f, -1.05730347e-01f, -9.60263833e-02f, -1.30034089e-01f, -1.62660763e-01f, -2.51180589e-01f,
  -1.16500638e-01f, -2.80248672e-01f, 3.16916376e-01f, 8.08970444e-03f, -1.44153982e-01f, -3.10899645e-01f, -4.70947951e-01f, -2.65875041e-01f, -2.02758312e-01f, -1.65967971e-01f,
  -1.51571244e-01f, -5.69858700e-02f, -6.21372610e-02f, 1.26092266e-02f, 8.42426263e-04f, 7.06515042e-03f, 2.70061731e-01f, 4.21351731e-01f, 2.81428337e-01f, -9.69580840e-03f,
  -2.02857275e-02f, 2.56969184e-01f, 4.04981613e-01f, 2.36797839e-01f, 1.08626276e-01f, 1.24670416e-01f, 1.99500412e-01f, 1.99146464e-01f, 7.61278123e-02f, 3.43279034e-01f,
  5.78313097e-02f, -2.00165108e-01f, 3.57406624e-02f, 7.92082250e-02f, 4.13774960e-02f, -4.80683185e-02f, 2.79894024e-02f, 9.27660242e-02f, -8.52932110e-02f, 7.06154387e-04f,
  2.13609599e-02f, -3.22577842e-02f, -1.04696780e-01f, 1.39628481e-02f, -3.22148688e-02f, -1.51032701e-01f, 1.05424114e-01f, 1.16650902e-01f, 9.88118234e-04f, -7.98681900e-02f,
  -9.40002725e-02f, 3.72875072e-02f, -9.45416167e-02f, -1.21389858e-01f, -1.26330033e-01f, 8.63908306e-02f, -7.10755438e-02f, -2.05922611e-02f, -5.13013676e-02f, -4.28424254e-02f,
  -6.26406595e-02f, 3.24603505e-02f, -2.90313363e-02f, -2.23538280e-02f, 5.12330444e-04f, 6.67130016e-03f, 7.56938905e-02f, 2.11380515e-02f, 2.87355017e-02f, 6.29993975e-02f,
  -8.68464410e-02f, 5.38820699e-02f, 4.52481471e-02f, -3.70422117e-02f, -1.32497707e-02f, 7.04168603e-02f, -1.24849435e-02f, 5.51500618e-02f, 4.10700291e-02f, -4.81109619e-02f,
  -1.84915699e-02f, -2.25598011e-02f, 4.44929898e-02f, 1.42390160e-02f, -2.65532620e-02f, 6.50371313e-02f, -9.58482269e-03f, -3.51900719e-02f, -2.68692411e-02f, -4.42228988e-02f,
  -2.11556733e-01f, 1.18755035e-01f, -9.41537097e-02f, 9.86737385e-02f, -1.12344250e-02f, -1.91900656e-02f, 2.12752894e-02f, -3.36437337e-02f, -4.38678116e-02f, -1.38292671e-04f,
  -7.84619451e-02f, -1.21733114e-01f, -6.04163110e-02f, 1.19491266e-02f, 1.12581542e-02f, -7.02627897e-02f, 2.36880966e-02f, -1.44273480e-02f, 1.59347542e-02f, -5.23462854e-02f,
  -4.66889441e-02f, -8.14507753e-02f, -1.82036027e-01f, -2.58455276e-01f, -1.09344989e-01f, -1.32604450e-01f, -5.30143529e-02f, -5.39109819e-02f, -2.19732627e-01f, -3.31888288e-01f,
  -1.46413893e-01f, -3.99788879e-02f, -5.47515154e-02f, 7.47569778e-04f, -3.48214447e-01f, -1.61651999e-01f, -7.47921914e-02f, 1.98179990e-01f, -1.92150730e-03f, -7.37456679e-02f,
  -3.49534601e-01f, -1.86952382e-01f, -5.35061993e-02f, -6.37166016e-03f, 1.95186526e-01f, 6.42604306e-02f, 2.06346586e-01f, 2.43315905e-01f, 2.62031734e-01f, 1.11556917e-01f,
  2.59264261e-02f, 2.12394059e-01f, 1.92699879e-01f, 2.99984068e-01f, 1.96937211e-02f, -9.72836539e-02f, 3.18998173e-02f, -1.44693762e-01f, -1.62319019e-01f, 3.35527547e-02f,
  -4.47467327e-01f, -1.39092624e-01f, 2.16249190e-02f, -2.92734392e-02f, 6.29046112e-02f, 3.18325549e-01f, 9.26535428e-02f, 3.29889148e-01f, 1.40583618e-02f, 1.82432055e-01f,
  -9.51907337e-02f, 1.03184385e-02f, -3.97161990e-02f, 1.08275853e-01f, -5.55759668e-02f, 1.70306896e-03f, 3.00506771e-01f, 1.85369313e-01f, 1.28827825e-01f, -3.92227657e-02f,
  -6.39611781e-02f, -2.57625371e-01f, -3.31243455e-01f, 1.34069193e-03f, 1.10929407e-01f, -2.42204487e-01f, -5.31343743e-02f, -1.38638681e-02f, -1.53363068e-02f, 3.12182400e-02f,
  7.08224773e-02f, 3.02186757e-02f, 7.06396401e-02f, 1.01177759e-01f, 1.15503155e-01f, 8.15336555e-02f, -9.14140418e-03f, -1.36412293e-01f, -8.02786872e-02f, 6.99553043e-02f,
  4.29457314e-02f, -7.90877715e-02f, 8.51887539e-02f, -3.03889997e-02f, -9.65451598e-02f, 5.55458777e-02f, -1.25080124e-01f, -1.06782921e-01f, -1.24792874e-01f, 6.79503987e-03f,
  -3.60660218e-02f, -5.22339083e-02f, -2.48664636e-02f, 7.34159350e-02f, 2.21499894e-02f, 8.60770047e-02f, 9.25220475e-02f, 9.20081511e-02f, 1.87118694e-01f, -4.24485141e-03f,
  5.10518886e-02f, -1.19170118e-02f, -1.35715250e-02f, 6.10038079e-02f, -1.61486939e-01f, -3.52936499e-02f, -1.24564670e-01f, 1.98184233e-02f, -1.04456834e-01f, 1.11754470e-01f,
  4.25361730e-02f, 7.61334784e-03f, 1.53524615e-02f, 1.92934170e-01f, 4.33138795e-02f, -4.07196619e-02f, -1.25443310e-01f, -2.13287026e-01f, -4.28340174e-02f, 3.87749001e-02f,
  8.76992010e-03f, -1.97806761e-01f, -3.55655372e-01f, -2.20876947e-01f, -5.91266826e-02f, -2.75872141e-01f, -1.74926087e-01f, -1.18089356e-01f, -2.05186307e-01f, -6.93328679e-02f,
  4.97854680e-01f, -1.23988613e-01f, -2.65073866e-01f, 3.24883342e-01f, -1.28784955e-01f, -3.08459580e-01f, -3.75424057e-01f, -7.62060061e-02f, 1.58815682e-01f, -1.28285334e-01f,
  -1.87847733e-01f, 3.21825370e-02f, 2.76451129e-02f, -6.12389818e-02f, -1.11044183e-01f, -1.76541820e-01f, -7.72971585e-02f, -2.66988482e-02f, -7.49619156e-02f, -1.50184616e-01f,
  -2.67850254e-02f, 1.95226043e-01f, 2.19524965e-01f, 1.24964770e-02f, 9.14209187e-02f, 8.19819048e-03f, -5.48648834e-02f, 7.10898219e-03f, -1.97149262e-01f, 1.07516274e-01f,
  3.63963586e-03f, 3.00769936e-02f, -2.25914940e-01f, 5.36283106e-02f, -6.05801567e-02f, 2.39285845e-02f, -1.24707438e-01f, 5.06020449e-02f, -5.23688309e-02f, -1.63010344e-01f,
  -1.28038093e-01f, -1.49040490e-01f, -1.20523234e-03f, -5.80660291e-02f, -3.27530056e-02f, -6.81943521e-02f, 1.24193626e-02f, 9.44529381e-03f, 2.40731835e-02f, -3.42326351e-02f,
  -1.21167272e-01f, -8.44574794e-02f, -5.31173795e-02f, -9.62434560e-02f, -6.75497428e-02f, 1.19053456e-03f, -1.07655920e-01f, -5.66929579e-02f, -1.17077909e-01f, 7.80444294e-02f,
  -1.53002918e-01f, -7.14134648e-02f, -5.60717508e-02f, -3.82775739e-02f, 5.08214310e-02f, -2.87030488e-02f, -8.49520508e-03f, -3.05813700e-02f, -4.12314758e-02f, -9.88633707e-02f,
  -8.18222836e-02f, -1.81596261e-02f, -3.22052576e-02f, 2.88900323e-02f, 7.17172250e-02f, -1.22889839e-02f, -7.42651299e-02f, -1.44395810e-02f, 1.54940803e-02f, 4.58274856e-02f,
  3.92313600e-02f, -6.80957958e-02f, -1.90902464e-02f, 3.14994669e-03f, -6.70469701e-02f, -8.53203237e-02f, 8.09768289e-02f, 1.35508394e-02f, 6.02224171e-02f, -3.06833163e-02f,
  1.32117137e-01f, -1.82771683e-01f, -9.00096912e-03f, -1.19913414e-01f, -5.01828417e-02f, -1.35124490e-01f, -1.19494982e-01f, -1.88907981e-02f, 4.39066887e-02f, -1.24768846e-01f,
  -1.72699362e-01f, -1.11556172e-01f, 2.41739545e-02f, -6.58427477e-02f, -8.13922361e-02f, -1.09694719e-01f, -9.59016979e-02f, -4.05868813e-02f, -5.81203736e-02f, 1.63044799e-02f,
  5.06795235e-02f, -8.70733261e-02f, 7.98640400e-02f, -1.63570326e-03f, 3.76163609e-02f, -1.85759757e-02f, -9.87179279e-02f, -9.31740850e-02f, -1.74913779e-01f, -1.91555433e-02f,
  3.35109979e-02f, 2.72772878e-01f, -2.32940763e-01f, 6.65620016e-03f, -6.37256876e-02f, -1.43928602e-01f, 1.25826567e-01f, -7.20759407e-02f, -1.83643788e-01f, 1.05922580e-01f,
  1.32792778e-02f, -1.25721619e-01f, -1.66145936e-01f, -6.12265095e-02f, -1.52363226e-01f, 1.18296593e-01f, 1.30033970e-01f, -5.38841002e-02f, -1.14075512e-01f, 1.06926464e-01f,
  2.55240649e-01f, 2.04254612e-01f, 9.82471108e-02f, -6.03305735e-02f, 3.11702210e-03f, 5.08158244e-02f, 6.10529073e-02f, 5.26957996e-02f, 4.06606644e-02f, 1.29275903e-01f,
  2.33151525e-01f, -1.41262591e-01f, -1.88298061e-01f, -1.04207657e-01f, 4.03170772e-02f, -1.60502624e-02f, 3.01427227e-02f, -1.25706688e-01f, -8.25561881e-02f, -1.00565866e-01f,
  -1.12071432e-01f, -5.99870570e-02f, -1.69624925e-01f, -2.90881116e-02f, -3.13029587e-02f, 9.74215474e-03f, 1.04827229e-02f, -1.06237799e-01f, -1.57191008e-01f, -4.01810147e-02f,
  4.89305407e-02f, 4.05016094e-02f, -8.31610188e-02f, -7.14865178e-02f, -2.43608147e-01f, -1.55159682e-01f, -1.20638929e-01f, -1.77247092e-01f, -2.22031012e-01f, 1.62476256e-01f,
  7.71826878e-02f, 1.20635152e-01f, 5.30991256e-02f, 8.58777985e-02f, 9.70894694e-02f, -4.20774985e-03f, 4.15740609e-02f, 3.96391302e-02f, -9.32987407e-02f, -2.18809769e-02f,
  -4.99967411e-02f, 1.72977485e-02f, -5.99896982e-02f, -4.29041423e-02f, 2.31560152e-02f, -2.63285358e-02f, -4.18216549e-02f, 8.72226506e-02f, -3.98508534e-02f, -7.30464235e-02f,
  -6.84008971e-02f, -1.59187138e-01f, -1.33581003e-02f, 7.90204331e-02f, -6.21788986e-02f, -1.10906534e-01f, -3.96418199e-02f, -3.56533448e-03f, -2.85554631e-03f, 3.56607772e-02f,
  2.78614640e-01f, -2.35165134e-01f, 1.14240855e-01f, -2.68560946e-02f, -3.42757218e-02f, -1.18558876e-01f, -3.71133499e-02f, -6.57976344e-02f, -1.50512531e-01f, -8.69556591e-02f,
  -1.09623730e-01f, -1.43153921e-01f, -3.88091505e-02f, 2.18937360e-02f, -4.72656498e-03f, -1.81250982e-02f, 1.96875855e-01f, 1.03243753e-01f, 5.95938079e-02f, 1.27710521e-01f,
  9.39183086e-02f, 1.84342608e-01f, 2.15395018e-01f, 4.06875350e-02f, 3.83489169e-02f, 6.40482083e-02f, 1.33966431e-01f, 5.81570938e-02f, -2.72342432e-02f, 4.22821164e-01f,
  1.27172813e-01f, 3.78450751e-01f, 3.50520551e-01f, -5.41635491e-02f, -3.38743888e-02f, 1.34984687e-01f, 1.91294938e-01f, 4.18109931e-02f, 3.90104018e-02f, 1.08965881e-01f,
  2.90178042e-02f, -1.17057450e-01f, -1.54210180e-01f, -1.30010396e-02f, -6.07352853e-02f, -3.06345075e-02f, -5.61277010e-02f, 5.85525148e-02f, 2.32338775e-02f, -4.46063615e-02f,
  -1.99552119e-01f, -4.89002131e-02f, 1.27491012e-01f, 3.32115544e-03f, 3.33056711e-02f, -1.34557500e-01f, 1.89366173e-02f, 7.80729726e-02f, -2.98748575e-02f, -1.58723250e-01f,
  2.20258549e-01f, 1.08526178e-01f, -1.26619503e-01f, 2.50769388e-02f, 2.30364025e-01f, 1.92717642e-01f, 7.89295733e-02f, 1.63119137e-01f, 1.01896279e-01f, 3.76416221e-02f,
  1.43451288e-01f, 1.27306879e-01f, 8.44953880e-02f, -1.59116276e-03f, 1.84089184e-01f, 7.87811726e-02f, -9.44147259e-03f, -5.13527356e-02f, 2.36979406e-02f, 1.63804665e-01f,
  1.70683069e-03f, 3.05042770e-02f, 1.05545662e-01f, -8.02951977e-02f, -1.01650141e-01f, -8.63139927e-02f, 2.44682971e-02f, 6.54421300e-02f, -7.50512024e-03f, -1.93096429e-01f,
  -2.32356470e-02f, 1.01320013e-01f, 1.02782369e-01f, -2.07445517e-01f, -2.27017049e-02f, -2.27954928e-02f, -6.58531338e-02f, -1.38273686e-01f, -1.35076851e-01f, 6.90315068e-02f,
  -8.98259133e-02f, -1.29171997e-01f, -2.72337650e-03f, -1.24800876e-01f, 1.30193189e-01f, 1.59205943e-01f, 1.60785858e-02f, -9.79590137e-03f, 3.68897989e-02f, 6.64417818e-02f,
  -3.40996236e-02f, 1.25537977e-01f, 1.53486192e-01f, 1.75240129e-01f, 1.76591091e-02f, 9.97698158e-02f, -1.38908494e-02f, 1.03037998e-01f, 1.23598985e-01f, 3.51730809e-02f,
  -1.79353252e-01f, -5.84135577e-02f, -2.00776190e-01f, 2.38096025e-02f, -3.68026942e-02f, 2.13011190e-01f, -5.34805208e-02f, 1.38414307e-02f, 1.28909111e-01f, -5.18738627e-02f,
  1.25174358e-01f, 9.27328840e-02f, 7.68868849e-02f, 4.44473028e-02f, 2.76171248e-02f, 5.83070796e-04f, 5.93972355e-02f, -1.74828902e-01f, 7.51153231e-02f, 7.66031370e-02f,
  2.06283748e-01f, -2.80276760e-02f, -2.26573795e-02f, -5.92069514e-02f, -9.67274830e-02f, -7.16106221e-02f, -1.16808735e-01f, -9.53793526e-02f, -1.13667563e-01f, -1.78313121e-01f,
  -3.73362064e-01f, 5.46244979e-02f, 3.03436279e-01f, -4.27407511e-02f, 1.46092176e-01f, 1.56661883e-01f, 3.59868910e-03f, -3.26581776e-01f, -2.71724671e-01f, -4.77461219e-02f,
  -5.29560857e-02f, -3.11756283e-01f, -1.82726845e-01f, -2.81682909e-01f, -3.58204961e-01f, -2.36112345e-02f, 3.56456749e-02f, -1.09551452e-01f, -3.43792588e-01f, -3.22142869e-01f,
  -1.36108205e-01f, -1.42642468e-01f, -2.90917605e-01f, -1.09633222e-01f, 8.43261853e-02f, 3.99801806e-02f, 7.41652772e-02f, 1.03256285e-01f, 1.41531929e-01f, 1.19530894e-01f,
  2.96646893e-01f, 9.59484875e-02f, -1.05217338e-01f, -9.33453366e-02f, 6.46454394e-02f, -5.78942597e-02f, 1.10320849e-02f, -5.05705141e-02f, -1.13192819e-01f, -5.69385514e-02f,
  -1.06432671e-02f, 2.63509583e-02f, 6.98280055e-03f, 9.89860371e-02f, -1.49068143e-03f, 8.40063319e-02f, 2.76247654e-02f, -1.04085676e-01f, 1.02644162e-02f, 5.90922982e-02f,
  6.97564706e-02f, 6.73347041e-02f, 5.03054559e-02f, 7.24809021e-02f, -9.34289210e-03f, 6.65284917e-02f, 3.59640568e-02f, 6.92622438e-02f, 1.46008685e-01f, 1.22390315e-03f,
  1.02321997e-01f, 1.32755358e-02f, 2.05694120e-02f, 1.03738047e-01f, 4.08442244e-02f, 1.73177049e-01f, 2.08287567e-01f, 1.60009563e-01f, -3.48725580e-02f, 5.19237109e-03f,
  6.77687302e-02f, 1.01626456e-01f, 5.56113012e-02f, 1.85046256e-01f, 1.79653794e-01f, 9.47340801e-02f, 2.18716264e-01f, 6.76982030e-02f, 8.90980437e-02f, 2.06081286e-01f,
  1.20684259e-01f, 6.38610870e-02f, 8.66555572e-02f, 6.50337040e-02f, 1.72524616e-01f, 1.03005737e-01f, 2.56301790e-01f, 2.19771951e-01f, 2.27177322e-01f, 1.79533526e-01f,
  -1.02596544e-01f, -3.49254757e-02f, -4.70180549e-02f, -4.27770764e-02f, 1.12269185e-01f, 3.65317427e-02f, 5.24973087e-02f, -1.49927974e-01f, 1.65525116e-02f, 1.60605814e-02f,
  8.91007632e-02f, 1.07982188e-01f, 4.08049710e-02f, 9.92209315e-02f, -2.46011727e-02f, 1.09948881e-01f, -4.51277643e-02f, -7.26563949e-03f, 4.31165062e-02f, 7.82324895e-02f,
  -1.23557691e-02f, -1.25698159e-02f, -2.79329997e-02f, 2.20664721e-02f, 7.21293166e-02f, 1.13624029e-01f, 1.01468973e-01f, 7.62374923e-02f, 9.06744599e-02f, -1.07986487e-01f,
  -3.13774534e-02f, -3.19860965e-01f, -9.96455550e-02f, -1.13807840e-03f, -4.68487181e-02f, -1.05863489e-01f, -3.01579148e-01f, -7.35256895e-02f, 1.81134511e-02f, -2.59672757e-02f,
  7.23960176e-02f, 1.68439403e-01f, 2.30428353e-01f, 1.08231463e-01f, 9.85952541e-02f, 8.98640081e-02f, 5.19051310e-03f, 1.90107554e-01f, 1.10320300e-02f, -1.04468260e-02f,
  -1.25156511e-02f, -6.44780472e-02f, 7.79528320e-02f, 1.58701152e-01f, -3.69618796e-02f, 1.22920774e-01f, 1.07623592e-01f, 5.74766435e-02f, -8.18441957e-02f, 3.27864178e-02f,
  -6.32472262e-02f, 1.91061068e-02f, 1.61785826e-01f, 1.85672432e-01f, -4.85916482e-03f, 9.95468721e-03f, 1.10198662e-01f, -7.74691533e-03f, 4.35566120e-02f, 2.66343988e-02f,
  1.20251492e-01f, 2.73095686e-02f, 1.36648342e-01f, -9.91699174e-02f, -5.76877296e-02f, 1.13215679e-02f, -5.83018223e-03f, -1.08168926e-02f, -4.99853306e-02f, 1.24280840e-01f,
  3.14562693e-02f, -4.83924476e-03f, -6.27331287e-02f, -3.16726565e-02f, 1.09384850e-01f, 3.45704816e-02f, -9.08409990e-03f, 3.37452367e-02f, 1.26116812e-01f, 8.56069103e-02f,
  4.06374000e-02f, -1.27323642e-01f, 9.56242159e-02f, 3.99302691e-02f, 2.68180631e-02f, -1.34049669e-01f, -1.75697990e-02f, -2.51259971e-02f, 5.00279143e-02f, 5.39431572e-02f,
  -9.07372683e-02f, 5.35239875e-02f, -3.50295566e-02f, 1.51851743e-01f, 2.31076822e-01f, -4.64574397e-02f, -1.28415570e-01f, 2.61602569e-02f, 1.34352744e-01f, 2.52745040e-02f,
  3.96518484e-02f, -3.37490290e-02f, -5.91262989e-02f, 4.90381010e-03f, -6.23890534e-02f, 9.88883898e-02f, 5.24364188e-02f, 1.05780311e-01f, -4.48377766e-02f, -4.81797606e-02f,
  -1.68638214e-01f, 3.46771687e-01f, 9.97468680e-02f, -6.97471499e-02f, 4.72066961e-02f, -5.70624992e-02f, 9.42760706e-02f, -4.62321751e-02f, -9.96492878e-02f, -8.34759474e-02f,
  -3.27610746e-02f, -4.24587019e-02f, -2.07831897e-02f, 8.05993378e-02f, -4.18874342e-03f, 1.64012630e-02f, -9.21161473e-02f, -8.45254660e-02f, 4.59329635e-02f, -5.29499389e-02f,
  -7.85474330e-02f, 2.13474333e-02f, 3.04936357e-02f, 1.27858430e-01f, 9.21956152e-02f, 1.75599590e-01f, -2.89372429e-02f, 3.82996462e-02f, 2.26645041e-02f, 4.31953967e-02f,
  3.15310538e-01f, -2.46025100e-01f, -4.94768441e-01f, -2.43784413e-01f, -1.41719058e-01f, -1.21034838e-01f, -1.78281903e-01f, -4.44689468e-02f, -7.47134238e-02f, -1.43728688e-01f,
  1.19624943e-01f, 4.00563717e-01f, 1.25974551e-01f, 2.78592020e-01f, 3.03105086e-01f, -1.54573306e-01f, -2.26569161e-01f, 1.30741924e-01f, 3.25088263e-01f, 2.51759768e-01f,
  1.70733079e-01f, 7.74989352e-02f, 2.11952999e-01f, 4.18313220e-02f, -3.28484267e-01f, 1.89675409e-02f, -3.71147186e-01f, -1.50290474e-01f, -5.16108982e-02f, -1.75893486e-01f,
  -1.84422061e-01f, -1.27470255e-01f, 9.05114487e-02f, 1.08957998e-01f, -3.50880399e-02f, -1.96269322e-02f, -9.88871381e-02f, -1.38323873e-01f, 6.06210753e-02f, -1.61216959e-01f,
  -3.68539542e-02f, 3.96019518e-02f, 1.28289819e-01f, 1.96836120e-03f, -5.58375232e-02f, 1.55453784e-02f, -6.10635914e-02f, 4.77685779e-02f, -8.33042935e-02f, -4.34472673e-02f,
  1.18313013e-02f, -9.34410095e-03f, -2.22993046e-01f, -6.03450648e-02f, -1.87828049e-01f, -1.24240601e-02f, -2.66838759e-01f, -8.74411687e-02f, -6.97550252e-02f, -2.14460313e-01f,
  9.51393098e-02f, 6.74127713e-02f, -6.51986897e-02f, -1.27982125e-01f, 4.54389192e-02f, -8.47365335e-02f, -2.30671447e-02f, 1.57678828e-01f, -2.44287848e-02f, -8.99481773e-02f,
  6.02551214e-02f, 2.63077933e-02f, 1.49141520e-01f, -3.02733835e-02f, -2.17333045e-02f, -8.51640180e-02f, 3.46292630e-02f, -1.16130523e-02f, 1.14258220e-02f, 1.15532935e-01f,
  1.16252683e-01f, -8.10789317e-02f, -6.12176359e-02f, 1.60487428e-01f, 5.63476272e-02f, 1.00858077e-01f, -2.59971805e-02f, 3.31734866e-02f, 3.21500003e-02f, 1.22750867e-02f,
  2.19272822e-02f, 2.02703580e-01f, -4.01336588e-02f, 1.00398436e-02f, -3.21527314e-03f, -9.59661137e-03f, -5.24712428e-02f, -2.25196332e-02f, 1.25647308e-02f, -1.17088147e-02f,
  -1.10957557e-02f, 3.39519721e-03f, -7.93194920e-02f, 3.51468660e-02f, 8.10348988e-02f, -1.05462335e-01f, 9.08231512e-02f, 1.79739878e-01f, 1.08407632e-01f, -1.96799085e-01f,
  -2.24437058e-01f, 7.30885044e-02f, 1.38441131e-01f, 6.74018562e-02f, 7.21577974e-03f, 1.31558850e-01f, -1.97816908e-01f, -1.08589865e-01f, 1.09876201e-01f, -9.38803628e-02f,
  -4.71610337e-01f, -2.07503065e-01f, -1.63111374e-01f, -1.86425537e-01f, -1.64361298e-02f, 1.12865269e-01f, 1.45285159e-01f, 1.09698594e-01f, -3.00810747e-02f, -1.40219882e-01f,
  -1.25946581e-01f, -4.39814217e-02f, -2.14973520e-02f, 6.20619692e-02f, 1.54249996e-01f, 4.76197265e-02f, 1.33392662e-01f, 9.20105577e-02f, 1.91335380e-01f, 1.11881435e-01f,
  9.73128229e-02f, -4.78747226e-02f, -3.02665569e-02f, 8.54578689e-02f, -1.45433217e-01f, -3.35666165e-03f, -1.12137184e-01f, -7.36928433e-02f, 4.59439009e-02f, -1.47358879e-01f,
  -3.22630703e-01f, -2.65363812e-01f, 9.16442499e-02f, -2.95301098e-02f, -3.26555893e-02f, -3.19561437e-02f, -8.25466297e-04f, -5.86388968e-02f, -3.09882052e-02f, -8.48420262e-02f,
  -5.77250831e-02f, -3.45510244e-02f, -8.73171836e-02f, 1.13707446e-02f, -1.02863088e-01f, 2.34799087e-02f, 1.76731851e-02f, 2.21841168e-02f, -1.40975816e-02f, -2.01089270e-02f,
  9.94250327e-02f, -1.31833553e-01f, -2.16096729e-01f, 9.12877321e-02f, 2.34472044e-02f, 5.53952307e-02f, -4.21055630e-02f, -3.01335827e-02f, 2.69328896e-02f, -2.64238238e-01f,
  -7.37889186e-02f, -2.59141233e-02f, -5.08346222e-03f, -5.18852472e-03f, 7.50459060e-02f, -4.88444082e-02f, 1.61618069e-02f, 6.59645498e-02f, -2.93483250e-02f, -3.92857939e-02f,
  5.36137186e-02f, -2.43165363e-02f, 1.38235372e-02f, -4.28138785e-02f, 2.34799217e-02f, -5.81009835e-02f, 4.60331626e-02f, 8.43357369e-02f, 1.92741118e-02f, 3.51693071e-02f,
  3.26629309e-03f, 2.57266685e-02f, -5.11060730e-02f, 5.58498614e-02f, 1.78805385e-02f, 3.84870023e-02f, -2.68742517e-02f, -7.52679165e-03f, -5.75739034e-02f, -1.64189469e-02f,
  -1.37740076e-01f, 2.32556775e-01f, -2.13016152e-01f, 2.72435211e-02f, -5.23086004e-02f, 4.84603532e-02f, -5.38186766e-02f, 1.20460279e-02f, -6.34726584e-02f, -3.68492752e-02f,
  4.23311349e-03f, -1.12588862e-02f, -1.11134551e-01f, 4.53769453e-02f, -4.57720011e-02f, -6.74429908e-02f, -6.28097281e-02f, -2.75233388e-02f, 3.91160995e-02f, -3.66559513e-02f,
  -1.17888646e-02f, -3.54598127e-02f, -2.86831290e-01f, -9.85410362e-02f, -1.22252204e-01f, -7.56744295e-02f, -1.20268360e-01f, -5.31498045e-02f, -3.68759558e-02f, -1.99385330e-01f,
  -3.66339833e-01f, -3.09691608e-01f, -1.00459240e-01f, -2.72998571e-01f, -1.79945841e-01f, -8.41333866e-02f, -1.60941139e-01f, -7.60338306e-02f, -1.25332162e-01f, -2.15545923e-01f,
  -1.11931421e-01f, -5.56217544e-02f, -1.00592203e-01f, 6.91041537e-03f, 7.46196732e-02f, -7.56784752e-02f, -2.37197988e-02f, 3.03684473e-02f, 1.27946466e-01f, 1.72569919e-02f,
  -6.24733083e-02f, -1.15285590e-01f, 1.70260202e-02f, 6.79105520e-02f, -2.09392577e-01f, -9.02222022e-02f, -1.14694417e-01f, -1.20810911e-01f, 2.14777403e-02f, -2.37172693e-01f,
  -1.87421575e-01f, -8.64827037e-02f, 6.93279132e-02f, 4.06925641e-02f, -2.40225457e-02f, -5.07401768e-03f, -2.72414982e-02f, -2.47699441e-03f, -1.54787824e-02f, -2.59999279e-02f,
  -6.43173009e-02f, -1.33354720e-02f, -5.13759628e-02f, -5.75655513e-02f, -6.69535846e-02f, -4.26282994e-02f, -3.01912241e-03f, 3.26170661e-02f, 2.54307594e-02f, 6.29427955e-02f,
  -2.14874931e-02f, -6.24584220e-02f, -9.60240886e-03f, 7.06926286e-02f, 7.39652589e-02f, 8.50368962e-02f, 1.02761416e-02f, 2.15008240e-02f, 8.86090174e-02f, -2.10936382e-01f,
  1.85655151e-02f, -2.01648418e-02f, 1.34356401e-03f, 4.20408411e-04f, 5.51567115e-02f, -3.72885633e-03f, 7.92393461e-03f, -7.06940563e-03f, 4.34943335e-03f, -5.82804568e-02f,
  3.02628782e-02f, 5.38057908e-02f, 1.66206516e-03f, -5.95206432e-02f, -2.25509685e-02f, -3.09441295e-02f, -1.18691707e-02f, 6.32931665e-02f, 2.97573339e-02f, 6.58039236e-03f,
  -2.90664770e-02f, -2.62436289e-02f, -9.77417827e-03f, -4.79495060e-03f, 4.41756248e-02f, 3.49542052e-02f, 1.99792630e-04f, 3.30066085e-02f, -5.38072772e-02f, -1.51919518e-02f,
  -1.49586454e-01f, 2.17974424e-01f, -1.89040363e-01f, 2.45655775e-02f, -2.66657900e-02f, 2.33821087e-02f, -5.85379489e-02f, 4.52526212e-02f, -1.01295188e-01f, -1.18757561e-01f,
  -1.88076757e-02f, -8.06496814e-02f, -5.11027724e-02f, -3.04537266e-02f, -2.20501795e-02f, -4.77398559e-02f, 3.95966992e-02f, -1.33405805e-01f, 8.42651427e-02f, 7.92511851e-02f,
  2.28066798e-02f, -3.03937849e-02f, -7.27259070e-02f, -7.97626749e-02f, -5.35922311e-02f, -2.46939100e-02f, -9.97033194e-02f, -8.14910159e-02f, 8.65108892e-03f, -2.14487761e-01f,
  -4.24665391e-01f, -2.97655612e-01f, -8.40016231e-02f, -4.94576007e-01f, -1.81791708e-01f, -1.92808267e-03f, -1.64435714e-01f, -5.13073280e-02f, -1.30331919e-01f, -3.64287347e-01f,
  3.17985713e-02f, 2.40869477e-01f, 1.08432531e-01f, 1.40587807e-01f, 1.60223134e-02f, -4.51516628e-01f, -4.17717338e-01f, -1.24669969e-01f, 1.74074367e-01f, 6.77225739e-02f,
  -1.37377277e-01f, -2.15334803e-01f, -1.31396696e-01f, -8.57246518e-02f, -2.17279509e-01f, 2.54986174e-02f, -1.72234192e-01f, -2.17831880e-01f, -8.29719603e-02f, -2.99031734e-01f,
  7.93927908e-02f, 1.69755500e-02f, 1.77090287e-01f, 1.17730558e-01f, -1.07546709e-01f, 1.09783299e-02f, 3.70448716e-02f, -3.73941325e-02f, 3.66707072e-02f, -5.92461303e-02f,
  -2.37879716e-03f, 2.91449074e-02f, 2.28468850e-02f, 7.23380223e-03f, -1.18586898e-01f, 3.84284928e-02f, -1.51408181e-01f, -2.32502427e-02f, -1.10332444e-01f, -1.23916045e-02f,
  -7.44976401e-02f, -1.03846863e-01f, 9.20165926e-02f, -5.51513061e-02f, 6.56561181e-02f, 1.80209819e-02f, 1.22174732e-01f, 1.26021862e-01f, 5.69686247e-03f, -1.88183576e-01f,
  -9.38149467e-02f, -3.33188996e-02f, -6.70193136e-02f, 8.42311010e-02f, 6.43059388e-02f, 7.86354765e-04f, -1.77788828e-03f, 2.02716532e-04f, 5.33069372e-02f, 6.70776377e-03f,
  -3.41017582e-02f, -9.94733302e-04f, 1.06322333e-01f, -5.06658629e-02f, 8.57894793e-02f, -1.10899046e-01f, -1.09279193e-01f, 2.06323396e-02f, -8.74798279e-04f, -6.88387230e-02f,
  5.13564721e-02f, -6.30416870e-02f, -7.94209242e-02f, -4.16461639e-02f, -3.89184766e-02f, -9.83990431e-02f, 3.19501944e-02f, 7.21053630e-02f, 2.04124395e-02f, 4.35976386e-02f,
  1.79914564e-01f, 1.36189666e-02f, -4.07430008e-02f, 9.99084860e-02f, -7.04146177e-02f, 7.15901004e-03f, -5.72368130e-02f, 4.08368707e-02f, 2.08283104e-02f, -5.48127331e-02f,
  5.47905639e-02f, -8.05184767e-02f, -4.48778942e-02f, -3.18989232e-02f, -4.49385354e-03f, 1.50898203e-01f, -1.83551759e-01f, -4.11101058e-02f, 8.16036612e-02f, -5.25188111e-02f,
  -2.48415172e-01f, -5.58437966e-02f, 4.12110146e-03f, -1.89102162e-02f, 3.66790616e-03f, 6.81136474e-02f, 1.35614738e-01f, 1.32869527e-01f, 5.27347364e-02f, -2.00342119e-01f,
  3.72895211e-01f, -1.96338147e-02f, -4.32107419e-01f, 1.09642848e-01f, -1.72974229e-01f, -2.51059294e-01f, -1.43510878e-01f, 1.09848743e-02f, 1.05528690e-01f, 8.28379579e-03f,
  -9.57387462e-02f, 5.29384129e-02f, -5.12900800e-02f, -2.37553164e-01f, -1.58729017e-01f, -3.30132216e-01f, -3.09829056e-01f, -3.50070000e-01f, -2.62184888e-01f, -2.38357186e-01f,
  -2.20389605e-01f, -1.14003636e-01f, -2.22312704e-01f, -1.24934278e-01f, -8.23399946e-02f, -2.12038592e-01f, -2.66514659e-01f, -1.55434027e-01f, -2.43705899e-01f, -3.40429068e-01f,
  -3.12095404e-01f, 7.88034648e-02f, 1.19879007e-01f, 5.28689809e-02f, 5.62334880e-02f, 6.37271106e-02f, 4.68836948e-02f, 1.29544646e-01f, 1.37537837e-01f, 1.13244668e-01f,
  4.99130376e-02f, 3.37907821e-02f, 3.93575756e-03f, 2.11630929e-02f, -2.48389300e-02f, -6.59620687e-02f, 7.42387399e-02f, 1.75363887e-02f, -3.58350649e-02f, -8.89391918e-03f,
  -1.42630488e-02f, -1.55604389e-02f, 1.04964964e-01f, 1.64008439e-01f, 5.09181432e-02f, -4.74370122e-02f, -2.47221775e-02f, -2.06231866e-02f, -7.16941804e-02f, 8.46231803e-02f,
  -5.96072525e-02f, 1.71490148e-01f, -2.67262831e-02f, 4.95601222e-02f, 1.39598995e-01f, 7.84222856e-02f, 1.66082140e-02f, 1.20083205e-01f, 2.13442408e-02f, 5.88516109e-02f,
  1.78998575e-01f, 6.09454215e-02f, 1.24756351e-01f, -4.06757519e-02f, -9.67198089e-02f, -6.55096918e-02f, 6.52841479e-02f, 4.39583510e-02f, -1.30372783e-02f, 5.20248711e-02f,
  5.99355735e-02f, -2.15009823e-02f, -7.76779428e-02f, 4.28547757e-03f, -1.16664566e-01f, -3.34343873e-02f, 3.12746800e-02f, -4.02329043e-02f, -1.63609404e-02f, 1.49448300e-02f,
  1.85514227e-01f, -2.42271423e-01f, 1.74868461e-02f, 8.57980251e-02f, -6.51707873e-02f, 5.65433726e-02f, -1.24808280e-02f, -2.31338032e-02f, -6.74130133e-05f, -3.81930149e-04f,
  -1.53303474e-01f, -9.24773067e-02f, -9.21986550e-02f, 1.28046453e-01f, -9.61053669e-02f, 1.89957581e-02f, 1.96426548e-02f, -2.21709888e-02f, -2.96886228e-02f, 9.45766270e-02f,
  9.28362980e-02f, 4.11378592e-02f, 1.73966080e-01f, 7.01703504e-02f, 1.74010210e-02f, -3.03854272e-02f, -1.17228545e-01f, 1.92052603e-03f, -2.14064732e-01f, 1.31498933e-01f,
  -3.25598419e-01f, 5.57358302e-02f, 8.25229362e-02f, 1.09454632e-01f, 2.02087164e-01f, -8.45949575e-02f, -3.26160848e-01f, -1.68330431e-01f, 1.30055159e-01f, 6.43281415e-02f,
  5.80177419e-02f, 1.32459760e-01f, 1.65489793e-01f, 9.27023531e-04f, -2.01711923e-01f, 3.25037795e-03f, 1.07527904e-01f, -1.39422014e-01f, -2.91522771e-01f, -3.61469448e-01f,
  -1.39523968e-02f, -6.65930137e-02f, -1.54431686e-01f, -7.17259794e-02f, 2.53919840e-01f, 1.10920645e-01f, 2.46697620e-01f, 1.74037531e-01f, 4.92423289e-02f, 2.68043756e-01f,
  1.89206458e-03f, -9.53199416e-02f, -8.23404267e-02f, 8.50604475e-02f, 1.42735511e-01f, -1.32152975e-01f, -1.34446204e-01f, 4.82885689e-02f, 1.85828581e-02f, -7.99761489e-02f,
  6.77264184e-02f, 1.66554172e-02f, 1.20335214e-01f, -5.62081337e-02f, -5.33659533e-02f, -2.05189794e-01f, -7.76452720e-02f, -2.64914036e-01f, -9.02971774e-02f, -1.80651844e-01f,
  6.20679297e-02f, 2.32704394e-02f, -6.71792077e-03f, -9.09200460e-02f, -5.07246889e-02f, -3.56902108e-02f, -1.07998334e-01f, -1.06607832e-01f, -1.87825754e-01f, -3.97763103e-02f,
  2.75457557e-02f, 5.58008328e-02f, 7.59364888e-02f, 1.00802528e-02f, -3.06816902e-02f, 7.90186077e-02f, 1.47151992e-01f, -1.26182074e-02f, 1.97651796e-03f, -1.83657631e-02f,
  -2.52040457e-02f, -2.20268872e-02f, -3.93934362e-02f, -3.02799735e-02f, -2.88385395e-02f, -5.28730685e-04f, -4.62141000e-02f, -5.87464944e-02f, 1.15641914e-02f, -8.37222487e-03f,
  -4.28348109e-02f, 1.15494290e-02f, 1.54256508e-01f, -5.58117591e-02f, 6.73090294e-02f, 3.34218778e-02f, -3.12555901e-04f, -6.47122413e-02f, 1.22068282e-02f, 8.38873442e-03f,
  -1.33518374e-03f, -4.30335738e-02f, -4.53696214e-03f, -8.09159130e-02f, 5.79985641e-02f, 5.21149747e-02f, 1.45443575e-02f, -2.14372743e-02f, 4.44069915e-02f, -1.35314837e-01f,
  -1.02050543e-01f, -7.82828107e-02f, 1.08911507e-01f, -1.21318419e-02f, -1.15443401e-01f, -9.78841539e-03f, 2.69990712e-02f, -4.70547155e-02f, -1.00605369e-01f, -1.40389726e-02f,
  8.68222788e-02f, -2.60632217e-01f, -1.67619944e-01f, -6.19922467e-02f, 2.14159377e-02f, -1.59560591e-01f, -9.49631929e-02f, -1.54475585e-01f, -1.93326965e-01f, -2.40956858e-01f,
  1.20434813e-01f, -2.14153365e-03f, 1.62253439e-01f, 1.62034079e-01f, 1.93225145e-01f, 2.60143340e-01f, 2.04738840e-01f, 1.86064154e-01f, 2.59363651e-01f, 1.07333325e-01f,
  1.34655416e-01f, 7.48088509e-02f, 9.03280601e-02f, 6.21884242e-02f, 1.65962409e-02f, 1.34632677e-01f, 1.17958717e-01f, 1.24829955e-01f, 5.12399040e-02f, 1.57541066e-01f,
  7.60469064e-02f, 9.47602093e-03f, -2.51664668e-02f, -1.56524417e-03f, 6.55043051e-02f, 1.11020304e-01f, 4.12760153e-02f, -1.12401955e-02f, 5.33405021e-02f, 1.59071773e-01f,
  -1.39238201e-02f, -8.80807713e-02f, 3.08619086e-02f, -5.50730117e-02f, -8.82412717e-02f, -9.32352990e-02f, 4.62736301e-02f, -3.72246578e-02f, -1.24858722e-01f, -2.30393112e-02f,
  7.97216687e-03f, 1.33024519e-02f, 3.71098034e-02f, -1.19759075e-01f, -1.15864649e-01f, -6.44110590e-02f, -2.87449062e-02f, 8.47933739e-02f, 7.41259828e-02f, 2.91468427e-02f,
  6.05704673e-02f, -4.31520231e-02f, -1.92240942e-02f, 5.78750968e-02f, 1.12127647e-01f, 5.06169125e-02f, 1.36746475e-02f, -1.01374745e-01f, -7.53092915e-02f, 1.14911802e-01f,
  1.95286974e-01f, 1.25056624e-01f, 1.15864947e-01f, 2.16221079e-01f, 1.37358289e-02f, -4.99864705e-02f, 1.00227511e-02f, 4.06447686e-02f, 7.17426240e-02f, 4.94855493e-02f,
  -4.48972285e-02f, 1.57918066e-01f, 1.20237298e-01f, 3.16461101e-02f, 1.34382963e-01f, 9.28158313e-02f, -3.84796672e-02f, 4.16391231e-02f, 3.72747704e-02f, -7.32529387e-02f,
  -3.68813388e-02f, -7.18786493e-02f, -3.52555700e-02f, 1.77082028e-02f, 3.92062264e-03f, 7.72327259e-02f, -6.48712963e-02f, 1.94747583e-03f, -4.48294878e-02f, -6.84420243e-02f,
  -3.82741839e-02f, 1.25231519e-01f, 1.15527578e-01f, -4.04517818e-03f, -9.92796198e-02f, -1.20665886e-01f, 1.50620028e-01f, -1.25672176e-01f, -1.46806374e-01f, -1.54814810e-01f,
  -6.88118935e-02f, -2.25540586e-02f, -5.16686514e-02f, -1.95037443e-02f, -1.30917743e-01f, -8.17017555e-02f, 4.21724506e-02f, 1.84970975e-01f, 1.88232269e-02f, -1.11713499e-01f,
  -1.27537949e-02f, 5.26462682e-02f, 8.02805275e-02f, 1.01433704e-02f, 9.54693705e-02f, 5.34186512e-02f, -7.10359716e-04f, -3.66998315e-02f, 3.82244699e-02f, -8.06234404e-02f,
  5.24323642e-01f, 1.88518744e-02f, 1.93251431e-01f, 1.48341864e-01f, 1.60900816e-01f, 1.62223354e-01f, 7.81408921e-02f, -3.92085165e-02f, 4.87486534e-02f, 8.97373185e-02f,
  1.53755650e-01f, 1.00333400e-01f, 1.92636684e-01f, 1.94240324e-02f, 1.36017531e-01f, -1.15806282e-01f, -1.01974502e-01f, 7.50927776e-02f, 1.96120843e-01f, -6.13420270e-02f,
  -7.47252405e-02f, 6.19179197e-03f, 1.60004809e-01f, 1.19989514e-02f, -1.98578000e-01f, -5.31398598e-03f, 3.11514847e-02f, 6.04304783e-02f, -1.03972383e-01f, -2.57055879e-01f,
  -2.22577676e-01f, 1.80370554e-01f, -4.87936065e-02f, -4.06909697e-02f, 4.20640521e-02f, -5.51602989e-02f, 3.27741019e-02f, 1.79451855e-03f, -1.53975457e-01f, -1.41467154e-01f,
  -6.99296668e-02f, -2.70884437e-03f, -1.43226888e-02f, -5.94633929e-02f, -3.23268510e-02f, -7.58849084e-02f, 6.00278750e-02f, -2.48954426e-02f, 2.28146352e-02f, -2.00137496e-03f,
  1.88548751e-02f, 1.49715682e-02f, -1.90220140e-02f, 9.13813934e-02f, 5.48051372e-02f, 1.48026988e-01f, 7.29281008e-02f, 1.41773717e-02f, 1.02411494e-01f, -8.97643641e-02f,
  5.70371281e-03f, 9.19284299e-02f, 1.06261745e-01f, 1.52096990e-02f, 6.32323548e-02f, 7.41517022e-02f, -7.79268742e-02f, 1.30779734e-02f, 1.18070692e-01f, 1.15160480e-01f,
  -6.20521829e-02f, 1.01223879e-01f, 7.61257783e-02f, 4.72940207e-02f, 9.79600195e-03f, 3.10049877e-02f, -2.60459222e-02f, -3.23788449e-02f, 1.46589443e-01f, 5.77685609e-02f,
  7.11356178e-02f, -1.20314069e-01f, 7.13745356e-02f, -1.06746003e-01f, -1.00924008e-01f, -4.21880791e-03f, -9.16521177e-02f, 3.56707536e-02f, 3.81601006e-02f, 4.87778671e-02f,
  -3.16215724e-01f, 3.29034775e-01f, -1.09977171e-01f, -6.61749765e-02f, -8.76683649e-03f, -2.60123517e-02f, 1.24726616e-01f, -5.78010343e-02f, -2.08491668e-01f, -2.17831463e-01f,
  -6.85708551e-03f, -3.91187258e-02f, 5.32477722e-02f, -4.84542036e-03f, 1.05472282e-01f, 4.42333333e-02f, 5.53060211e-02f, 7.47015178e-02f, 7.19468482e-03f, -1.52740896e-01f,
  -2.90775262e-02f, 5.56470677e-02f, 6.88258782e-02f, -1.62525959e-02f, 7.57362545e-02f, 5.71960472e-02f, 5.97090125e-02f, -4.69506681e-02f, 1.79166079e-01f, -3.24742198e-02f,
  5.04366420e-02f, 2.68461704e-01f, 1.47126436e-01f, -1.23585939e-01f, 2.99767911e-01f, 2.36417070e-01f, 3.20600331e-01f, 5.48118316e-02f, -6.94437176e-02f, 1.11571036e-01f,
  2.53824264e-01f, -7.50567615e-02f, -1.74474254e-01f, -2.92161494e-01f, -4.00850803e-01f, -2.41131946e-01f, -2.34079584e-01f, -3.69870186e-01f, -2.85923809e-01f, 7.29796535e-04f,
  -3.01123429e-02f, -1.47266805e-01f, -1.61821857e-01f, -1.75776631e-01f, -5.86222187e-02f, -2.92571008e-01f, 2.51729216e-04f, 1.10904448e-01f, 6.10455349e-02f, -2.51331747e-01f,
  1.75454095e-02f, 2.98884034e-01f, -1.73572734e-01f, -1.69492438e-01f, 9.79212001e-02f, -1.06059514e-01f, 2.58046631e-02f, -6.29824027e-02f, 3.68804410e-02f, -1.15448855e-01f,
  2.52182707e-02f, -2.69576013e-02f, 3.26125436e-02f, 6.24553151e-02f, 5.90081774e-02f, -2.78754979e-02f, 4.61040251e-02f, -1.17427669e-01f, -1.06975719e-01f, 2.17508644e-01f,
  1.97055250e-01f, 1.61765739e-01f, 1.63546845e-01f, 1.12904618e-02f, 2.09391769e-02f, -1.62015468e-01f, 4.10153568e-02f, -2.09189896e-02f, -8.80423561e-02f, -2.55713344e-01f,
  -6.22311942e-02f, -1.33131549e-01f, -2.74843164e-02f, -3.38565186e-02f, -1.02457754e-01f, -9.62448940e-02f, -1.60855632e-02f, 6.04508184e-02f, -9.25514176e-02f, -2.18565539e-02f,
  6.83006942e-02f, 6.08286038e-02f, -5.35790250e-02f, -1.14704661e-01f, -1.78552628e-01f, 7.92336911e-02f, 4.24756594e-02f, -1.06727323e-02f, 6.81517348e-02f, 2.91664973e-02f,
  -1.44623895e-03f, 1.10652328e-01f, 1.41460732e-01f, -3.60969380e-02f, -2.12353673e-02f, -1.37587637e-01f, 6.21390976e-02f, 3.87315601e-02f, 7.25437030e-02f, 1.47474492e-02f,
  -2.52043426e-01f, -3.27062123e-02f, -1.34081542e-01f, 6.74683973e-02f, 9.21702161e-02f, 7.79207274e-02f, 2.08496168e-01f, 7.31751844e-02f, 1.06829397e-01f, 5.77217974e-02f,
  1.81060344e-01f, 3.96833904e-02f, 9.25410017e-02f, 4.28832322e-02f, -5.47052659e-02f, -1.43824499e-02f, 1.36896849e-01f, -6.70907926e-03f, -1.60781629e-02f, 3.32624376e-01f,
  1.75850078e-01f, -1.79716706e-01f, -2.33155265e-01f, -5.73504753e-02f, 3.71062271e-02f, -2.51508653e-01f, -1.73639372e-01f, -1.20360993e-01f, -1.12195067e-01f, -4.39713985e-01f,
  -3.80761594e-01f, 1.00813933e-01f, 2.05038846e-01f, -2.66265690e-01f, 5.56988269e-02f, 1.07347846e-01f, 8.22669268e-02f, -1.65293347e-02f, -1.07448064e-01f, -8.21986236e-03f,
  2.61792373e-02f, -3.19258124e-02f, -5.56573831e-02f, -1.06205605e-01f, -1.67450324e-01f, -5.64248227e-02f, -9.21950340e-02f, -7.01069385e-02f, -1.13730002e-02f, -5.10352179e-02f,
  -8.75321999e-02f, -1.08152382e-01f, -1.34415105e-01f, -1.20305777e-01f, -1.99071933e-02f, -9.64280218e-02f, -7.24389032e-02f, -5.17645776e-02f, 3.85992490e-02f, -5.77920787e-02f,
  2.83419341e-01f, 7.29990005e-02f, 3.99379060e-02f, -1.06019378e-01f, -7.91391507e-02f, -1.25717759e-01f, 3.86357792e-02f, -4.03822726e-03f, -6.61192834e-02f, 3.46830077e-02f,
  5.96348792e-02f, 3.54946777e-02f, -3.72403339e-02f, 8.96325409e-02f, 9.49200019e-02f, 8.69908035e-02f, 3.63273770e-02f, -1.33632362e-01f, -3.90160307e-02f, -1.49330320e-02f,
  8.95105526e-02f, 1.37961507e-01f, 1.11738712e-01f, 6.53275251e-02f, -3.44270188e-03f, -2.84812823e-02f, 5.09825796e-02f, 1.44370601e-01f, 1.10243313e-01f, -4.68198434e-02f,
  -2.11226679e-02f, 2.20775660e-02f, 6.37861341e-02f, 1.30760536e-01f, 7.06773400e-02f, 3.63929458e-02f, -7.89856911e-03f, 5.34607703e-03f, -4.41308729e-02f, 8.04530457e-03f,
  5.75444698e-02f, 1.43747881e-01f, 4.67849523e-02f, -8.85294229e-02f, -2.20730193e-02f, 2.71863602e-02f, 1.76074747e-02f, 3.33480053e-02f, 6.39978945e-02f, 9.40861031e-02f,
  7.95054734e-02f, 1.23371027e-01f, 1.11868039e-01f, 2.14476641e-02f, 1.12780459e-01f, -3.49955298e-02f, 6.67568892e-02f, 1.52891517e-01f, -1.42883381e-03f, -6.33220328e-03f,
  3.81020382e-02f, 6.76792637e-02f, -7.57172406e-02f, -5.18587194e-02f, -1.20497122e-01f, -9.15531740e-02f, -1.30612344e-01f, -4.75061499e-02f, 4.34780866e-02f, 1.60412546e-02f,
  1.10517301e-01f, -5.18102944e-02f, 8.35477933e-02f, 7.71392509e-02f, -6.00698814e-02f, 9.90507454e-02f, -5.30167520e-02f, -2.09414344e-02f, -7.48468563e-02f, 1.80227458e-02f,
  1.68656092e-02f, 1.79115627e-02f, -1.52250146e-02f, -6.60539418e-03f, -5.59629872e-02f, -6.33154884e-02f, 6.71609864e-02f, 9.95595977e-02f, -6.35069311e-02f, -1.79004028e-01f,
  -5.16566396e-01f, -3.65605354e-01f, 2.06098445e-02f, -1.70480743e-01f, -1.18601680e-01f, -7.55817592e-02f, -1.28174931e-01f, -4.51269932e-02f, -1.03789665e-01f, -1.45318612e-01f,
  -8.12994987e-02f, -9.57090929e-02f, -1.01889163e-01f, -1.06871407e-02f, 4.94015962e-03f, -1.52240321e-03f, 6.31433874e-02f, 7.50687644e-02f, 1.30375579e-01f, 5.09916432e-02f,
  3.63492181e-05f, 3.18415575e-02f, 3.19670290e-02f, 7.60764256e-02f, -1.59995168e-01f, -3.11277881e-02f, 1.50585705e-02f, -1.18733428e-01f, -6.94102719e-02f, -2.70731151e-01f,
  -1.44640237e-01f, -1.64431959e-01f, 1.92906484e-01f, -3.50062065e-02f, 4.06882428e-02f, -4.19189967e-02f, -3.47207971e-02f, 5.55679649e-02f, -6.90389425e-02f, -5.69439568e-02f,
  -2.92365775e-02f, 3.20460908e-02f, -1.02838054e-01f, -2.44750865e-02f, -1.98410135e-02f, -2.24807393e-02f, 1.22366071e-01f, 6.03592321e-02f, 1.93099640e-02f, 1.13975629e-02f,
  -8.18696320e-02f, -1.33246481e-01f, -1.90058902e-01f, 5.09811789e-02f, 3.07210162e-02f, 8.82132277e-02f, 1.18945800e-02f, -5.95078953e-02f, 4.08922508e-02f, -2.71657467e-01f,
  -1.67068932e-02f, 4.45147790e-02f, 4.95530255e-02f, -9.65226814e-03f, -1.90268271e-02f, -7.87431281e-03f, 6.20478652e-02f, -1.77040938e-02f, -3.53882127e-02f, -7.23038837e-02f,
  1.64621323e-02f, 2.61155553e-02f, 1.48332845e-02f, 2.27065347e-02f, -7.85725787e-02f, 4.34301235e-03f, -2.78847385e-02f, 8.35395604e-02f, 5.81677677e-03f, 1.15594836e-02f,
  -1.80244085e-03f, 1.78877488e-02f, 5.96797690e-02f, 4.53148484e-02f, 8.82595498e-03f, 1.19084544e-01f, -2.70178933e-02f, -3.58363725e-02f, -5.03761508e-02f, -6.14189580e-02f,
  -4.32361923e-02f, 3.04551482e-01f, -1.59249678e-01f, -8.46642442e-03f, -7.59335235e-02f, 1.04298852e-01f, -3.13998945e-02f, 4.23081815e-02f, -5.97942732e-02f, -4.69597615e-02f,
  -2.70441677e-02f, -7.99258333e-03f, -1.05154902e-01f, 2.74311136e-02f, -3.56587172e-02f, -4.25836630e-02f, -4.39834706e-02f, -1.21841528e-01f, 3.00058187e-03f, -4.32083830e-02f,
  -9.21841636e-02f, -1.58896923e-01f, -3.26171339e-01f, -1.56371102e-01f, -1.73220769e-01f, -1.35962382e-01f, -1.46311924e-01f, -9.55592245e-02f, -8.95923376e-02f, -3.15013707e-01f,
  -4.16280270e-01f, -3.48399550e-01f, 4.51427810e-02f, -1.58368505e-03f, 7.62851909e-02f, 9.69046801e-02f, 1.77351445e-01f, -4.86443425e-03f, -1.20456137e-01f, -1.02190435e-01f,
  -1.46416277e-01f, 7.11729145e-03f, -1.81804691e-02f, 9.27760452e-02f, 7.86639303e-02f, 2.31350988e-01f, 2.08670184e-01f, 8.58645812e-02f, 1.99428946e-01f, 1.67920217e-02f,
  8.50497186e-02f, 3.51794660e-02f, -1.59523740e-01f, -1.98129956e-02f, -3.01052313e-02f, 1.09727703e-01f, -2.38795113e-02f, -3.04976273e-02f, 1.96619611e-02f, -2.98445113e-02f,
  3.80758017e-01f, -1.09233223e-01f, 1.21353596e-01f, -2.14100942e-01f, -9.87858847e-02f, -2.20695078e-01f, 2.03942750e-02f, -6.80731088e-02f, -1.51539966e-01f, -3.38911600e-02f,
  2.72639878e-02f, -1.50537774e-01f, 8.49134251e-02f, -2.85162264e-03f, -4.52466644e-02f, -5.58154657e-02f, -1.25819564e-01f, -4.86524813e-02f, 1.86229125e-02f, -4.50653285e-02f,
  -1.59654066e-01f, -1.25363730e-02f, 1.03198670e-01f, -7.59574724e-03f, -4.81440872e-02f, -4.40679863e-02f, -7.47751296e-02f, -1.11114256e-01f, 2.06705313e-02f, 3.89631055e-02f,
  -1.98635608e-01f, -2.58470010e-02f, 2.34579388e-02f, 8.27850774e-02f, 7.38012269e-02f, -3.53464335e-02f, 9.27130207e-02f, 1.55235648e-01f, 5.37586063e-02f, -1.03270700e-02f,
  1.22301318e-01f, 1.26292199e-01f, -1.26903933e-02f, 3.28990370e-02f, -3.07561476e-02f, 3.20059806e-03f, -1.90478545e-02f, 6.36893436e-02f, 8.21858793e-02f, -1.35770496e-02f,
  1.65519342e-01f, 7.14687705e-02f, -1.44950405e-01f, -2.85870396e-02f, -9.48218182e-02f, -3.82935181e-02f, 1.61246248e-02f, 4.84221391e-02f, -9.30333585e-02f, -9.47116874e-03f,
  3.44100416e-01f, 6.53639063e-02f, 1.85412899e-01f, 7.62976483e-02f, 6.00571856e-02f, -1.14530481e-01f, 1.89366098e-02f, 1.01584755e-01f, 9.78795290e-02f, 1.09743625e-01f,
  -1.01290997e-02f, 2.59158816e-02f, 1.38253614e-01f, -2.02008840e-02f, 1.06927969e-01f, 9.71575901e-02f, -1.46646753e-01f, 1.55830719e-02f, 4.75635156e-02f, 3.80064882e-02f,
  -4.17781882e-02f, 1.62982661e-02f, 2.09936842e-01f, 1.90076381e-01f, 6.65991455e-02f, 6.44437522e-02f, 1.66491151e-01f, 4.35361303e-02f, 1.01706952e-01f, 7.67831281e-02f,
  7.37558484e-01f, 3.64511371e-01f, -2.97716945e-01f, 9.81891975e-02f, -2.29343176e-01f, -2.66520441e-01f, -2.68748645e-02f, 7.75084496e-02f, 2.84474976e-02f, 1.17714934e-01f,
  -1.42276485e-03f, 2.37697475e-02f, 1.15120098e-01f, 5.48673086e-02f, 1.32714406e-01f, -2.00126171e-02f, -3.72417225e-03f, 3.48977372e-02f, -1.78171601e-02f, -6.76424429e-02f,
  -2.26776805e-02f, 1.88826680e-01f, 2.66459703e-01f, 1.15468688e-01f, -2.63361670e-02f, -7.93527588e-02f, -8.40718374e-02f, -1.86578706e-01f, -1.29400417e-01f, -5.71693964e-02f,
  -2.98127651e-01f, -1.63056746e-01f, 8.07561427e-02f, 1.48319259e-01f, 1.01148792e-01f, 9.00228024e-02f, -2.65762617e-04f, 1.24987839e-02f, 1.19241133e-01f, -6.61356673e-02f,
  -2.16223281e-02f, -1.08583026e-01f, -1.04002252e-01f, 1.82735566e-02f, -9.68111083e-02f, 5.05471975e-02f, 9.58806947e-02f, 8.99446309e-02f, -8.78983662e-02f, -2.01108176e-02f,
  -3.18946056e-02f, -1.40879974e-01f, -1.61345556e-01f, 5.34728318e-02f, 2.16025431e-02f, 3.99837792e-02f, -8.43530148e-02f, -9.14589688e-02f, -7.92273358e-02f, 4.67958935e-02f,
  -4.94187884e-02f, 1.97163671e-01f, -8.44243914e-02f, -1.44262448e-01f, -2.20728889e-02f, 5.85328862e-02f, 6.37082160e-02f, 1.13314815e-01f, 8.15062821e-02f, 7.21309409e-02f,
  -7.13615268e-02f, -1.34903163e-01f, -9.66314524e-02f, -1.88595988e-02f, 7.22972825e-02f, 1.87742407e-03f, -8.91987458e-02f, 5.17841801e-02f, -8.78080949e-02f, -9.85964388e-02f,
  -1.47367805e-01f, -3.80016826e-02f, 6.00831620e-02f, -7.96227530e-03f, -1.03121161e-01f, -1.04357369e-01f, -1.04296468e-01f, 5.58231287e-02f, 2.82244533e-02f, 1.03566542e-01f,
  -1.27427340e-01f, -4.77349073e-01f, -1.87129807e-02f, 6.39786869e-02f, -5.05997166e-02f, 6.19997829e-02f, 7.66399642e-03f, 4.99979444e-02f, -4.97571304e-02f, -1.23340197e-01f,
  -9.45055485e-02f, 1.05725296e-01f, 9.48994830e-02f, 6.37642890e-02f, 1.82935931e-02f, 2.83680428e-02f, 1.97127804e-01f, 1.21762954e-01f, 5.12891216e-03f, 9.77883674e-03f,
  1.51965365e-01f, -2.59415098e-02f, 6.10020757e-02f, 5.17387129e-02f, 1.15368500e-01f, -3.93638238e-02f, -3.63057591e-02f, 6.59579933e-02f, -2.58845557e-02f, 2.05461159e-01f,
  3.14670205e-01f, 1.33585557e-01f, -4.11283791e-01f, 3.34737629e-01f, -7.75917694e-02f, -2.37931341e-01f, -1.29981682e-01f, 3.34862992e-02f, 2.11868882e-01f, 1.04730740e-01f,
  -1.99299101e-02f, -1.44459262e-01f, -2.43120626e-01f, -3.08049053e-01f, -3.92689258e-01f, -3.06918800e-01f, -2.94069886e-01f, -4.00019377e-01f, -4.11162347e-01f, -5.21697290e-02f,
  3.87426615e-02f, 7.67212585e-02f, -2.84108035e-02f, -3.64902779e-03f, 2.63516843e-01f, -9.81644094e-02f, -7.89025277e-02f, -5.15879095e-02f, -1.49893582e-01f, 1.13330865e-02f,
  -1.63353801e-01f, 2.54718140e-02f, -9.57755372e-02f, 4.33678403e-02f, 6.57332167e-02f, -5.11065032e-03f, -9.83444005e-02f, -5.98435476e-02f, 2.88153463e-03f, -1.09916423e-02f,
  -4.85134758e-02f, 8.82109031e-02f, -6.34316429e-02f, -5.81478663e-02f, 3.78585048e-03f, -3.85469869e-02f, -6.59345910e-02f, -1.66262552e-01f, -8.65950584e-02f, 5.14100455e-02f,
  -1.24885282e-02f, -1.60627007e-01f, -2.17274249e-01f, -4.09615934e-02f, -4.95338552e-02f, -1.37853712e-01f, -1.67151727e-02f, 3.22203115e-02f, -1.45477518e-01f, 1.90535694e-01f,
  1.29940182e-01f, -2.73978543e-02f, 1.62662659e-02f, 1.92888193e-02f, 8.43408331e-02f, -9.55808386e-02f, 1.43178264e-02f, 1.66490674e-02f, 8.32918473e-03f, 3.96770909e-02f,
  9.82446689e-03f, -1.53974192e-02f, 2.23084316e-02f, 3.47079933e-02f, -5.80205694e-02f, -5.73323574e-04f, 6.87731281e-02f, 3.64285782e-02f, -2.76534352e-02f, 2.06303410e-02f,
  -3.49225402e-02f, -3.32483202e-02f, -1.73396859e-02f, -1.12405289e-02f, -5.77515587e-02f, 1.73019599e-02f, 5.82214631e-02f, 3.36849801e-02f, 1.48731554e-02f, 3.42376791e-02f,
  1.06130183e-01f, -2.85449952e-01f, 9.82178003e-02f, -6.27670288e-02f, -1.52132828e-02f, 2.76695471e-02f, 7.36689791e-02f, 9.59916785e-02f, 5.46109974e-02f, 9.90025848e-02f,
  -9.45580937e-03f, 8.46461728e-02f, -6.32441640e-02f, -4.33358103e-02f, -7.13620707e-02f, -1.56753119e-02f, 1.28075369e-02f, -4.28001322e-02f, -1.46624207e-01f, 1.65680230e-01f,
  6.92354292e-02f, -1.28100052e-01f, -1.14921160e-01f, -6.73879869e-03f, 3.36269550e-02f, -1.97539285e-01f, -9.79429856e-02f, 7.39635527e-02f, -2.62805432e-01f, 1.55454770e-01f,
  -1.75081953e-01f, 1.44626528e-01f, -1.18184827e-01f, 1.00297958e-01f, -8.86049122e-02f, -2.89194077e-01f, -1.21000297e-01f, -6.99745044e-02f, -9.64434445e-03f, 1.97179362e-01f,
  1.03307664e-01f, 4.38371524e-02f, -2.92083267e-02f, -7.60280490e-02f, -1.05386734e-01f, -2.79737730e-02f, -6.76322877e-02f, -3.05981457e-01f, -2.87498742e-01f, -1.91937461e-01f,
  -2.82639358e-02f, -1.72407061e-01f, -1.85669199e-01f, -8.44698176e-02f, 1.69269100e-01f, -2.75947619e-02f, -3.13591445e-03f, -1.95124950e-02f, -9.91382077e-02f, 9.54709575e-02f,
  1.44148871e-01f, -2.61825204e-01f, -8.73549208e-02f, -1.10053532e-01f, 5.85917234e-02f, -4.56208289e-02f, -1.91040225e-02f, -3.29193771e-02f, -2.33139121e-03f, 1.53538629e-01f,
  -4.55373526e-02f, 7.97351182e-04f, -8.75217561e-03f, 9.04622972e-02f, -5.48107922e-02f, 4.20073085e-02f, 8.87091234e-02f, 9.79634561e-03f, 7.49839423e-03f, 3.60155664e-02f,
  4.05106694e-03f, -9.39556956e-02f, -9.87493061e-03f, -1.08163223e-01f, -6.61407188e-02f, -1.01286709e-01f, -6.77423403e-02f, -5.56162223e-02f, -5.90844862e-02f, 7.42732435e-02f,
  -2.58184914e-02f, 1.45828336e-01f, 6.15829341e-02f, 5.52714197e-03f, 3.07480935e-02f, 1.01545170e-01f, 6.97294325e-02f, 6.15574196e-02f, 1.44495042e-02f, 5.99694960e-02f,
  1.20544709e-01f, 2.05030804e-03f, 1.20128170e-01f, -3.12798016e-04f, 2.90116761e-02f, -9.03399065e-02f, 2.27203704e-02f, 1.21973321e-01f, -3.04544996e-02f, 1.07904159e-01f,
  1.50282905e-02f, -2.41864584e-02f, -2.54955678e-03f, 4.72624637e-02f, -4.66026785e-03f, 7.41528422e-02f, -4.92497087e-02f, -1.36456285e-02f, -7.03730732e-02f, -7.82212690e-02f,
  2.05308363e-01f, -3.50876302e-01f, 4.41923961e-02f, -8.02539885e-02f, 9.95443314e-02f, 1.22218594e-01f, 9.28549841e-02f, 9.40853357e-02f, 1.32917732e-01f, 7.02456161e-02f,
  4.12749214e-04f, 9.77552682e-02f, 2.46360749e-02f, 6.33171424e-02f, 7.40709156e-02f, -1.91064668e-03f, 4.63458449e-02f, 4.64795381e-02f, -3.61810401e-02f, 1.68294907e-01f,
  1.31010816e-01f, -3.86246555e-02f, 1.12049825e-01f, 1.48484170e-01f, -5.66948615e-02f, -6.93956986e-02f, 1.24248132e-01f, 3.80137600e-02f, -3.30162682e-02f, 1.06033489e-01f,
  -3.71183425e-01f, -1.90687269e-01f, 2.59068012e-01f, -2.57941216e-01f, -3.58204804e-02f, 1.59235343e-01f, 9.58066508e-02f, -1.22326329e-01f, -2.14029282e-01f, 4.11851220e-02f,
  3.88664491e-02f, -1.13679767e-01f, 9.70898382e-03f, 6.50755689e-03f, -2.60033004e-04f, 1.45314142e-01f, 1.19157314e-01f, 1.27813995e-01f, 8.55334029e-02f, -7.82539696e-03f,
  -4.05271091e-02f, -2.01552212e-01f, -1.68803304e-01f, -7.34773427e-02f, -1.19480632e-01f, -3.98492143e-02f, 1.82994977e-02f, -3.48980762e-02f, 4.42129141e-03f, 9.01026186e-04f,
  3.11874688e-01f, -1.95759326e-01f, 2.61376221e-02f, -1.82207063e-01f, -2.58688610e-02f, -4.90033738e-02f, -1.42957438e-02f, -1.08373269e-01f, -7.50614479e-02f, 2.10088249e-02f,
  -3.72080021e-02f, -6.43162951e-02f, 4.79094982e-02f, -7.19748512e-02f, -7.38489777e-02f, -1.23487070e-01f, -3.56747508e-02f, -3.09677143e-03f, 3.81820425e-02f, 9.33918264e-03f,
  -1.52616086e-03f, -8.19500387e-02f, 1.21681809e-01f, 4.80723344e-02f, -2.58734380e-03f, -3.07222009e-02f, 7.42704123e-02f, -7.88116083e-02f, -7.06651360e-02f, -5.53141534e-03f,
  -1.84737984e-02f, -4.31860872e-02f, -7.97779411e-02f, 1.20681373e-03f, 3.40034589e-02f, 8.75414461e-02f, -1.89627483e-02f, 2.54664961e-02f, 6.33381084e-02f, 7.10498840e-02f,
  -8.46789256e-02f, 9.23622251e-02f, 1.08155765e-01f, -6.94807395e-02f, -2.07762271e-02f, -7.28503913e-02f, 8.25096667e-03f, -2.35155895e-02f, -3.49012055e-02f, -9.67537016e-02f,
  -2.87118480e-02f, -7.62504712e-02f, -6.35891035e-02f, -4.03930582e-02f, -3.25777680e-02f, -9.76787731e-02f, -2.06333213e-02f, -6.38019368e-02f, -9.27849580e-03f, -2.88059916e-02f,
  1.61184803e-01f, -6.27257377e-02f, 1.10785708e-01f, 6.04956085e-03f, 2.33216044e-02f, -7.51018301e-02f, -6.46250602e-03f, -1.06437793e-02f, 2.78560631e-02f, 3.71506251e-02f,
  -5.93424626e-02f, 2.50723213e-03f, -9.81467869e-03f, -3.17585841e-02f, -2.71881465e-03f, -1.04002720e-02f, -1.75004322e-02f, -4.33103368e-02f, 8.21547359e-02f, 7.61061311e-02f,
  -6.14710152e-02f, 2.12473590e-02f, 1.49173230e-01f, 1.46134928e-01f, 5.50024547e-02f, 6.68950304e-02f, 8.06239173e-02f, 1.11182630e-01f, 6.52655661e-02f, 1.35716081e-01f,
  -4.15070094e-02f, 4.23151582e-01f, -7.14824617e-01f, 1.33900583e-01f, -1.02984041e-01f, -1.65232196e-01f, 3.21805060e-01f, 1.84594303e-01f, 8.57804567e-02f, 2.65840530e-01f,
  -2.77129374e-02f, -2.35819027e-01f, -1.82876989e-01f, -1.36624426e-01f, -8.80058035e-02f, 2.17091218e-01f, 1.05586246e-01f, -4.11528975e-01f, -3.98445159e-01f, 4.11650119e-03f,
  3.61664027e-01f, 2.41841018e-01f, -3.66170630e-02f, -4.09798212e-02f, 8.76164809e-02f, -9.54571962e-02f, 4.18254845e-02f, -3.46778855e-02f, 2.62165908e-02f, -7.47598559e-02f,
  -4.23372060e-01f, -1.25770643e-01f, -1.93289757e-01f, -5.87480776e-02f, -7.10729882e-02f, -3.34459357e-02f, -2.16913261e-02f, -1.88548952e-01f, -1.26169175e-01f, 2.31284648e-03f,
  -1.31900653e-01f, 1.35014276e-03f, -1.84648126e-01f, -7.10749477e-02f, -6.83436170e-02f, -3.40699889e-02f, 9.05719027e-03f, -1.82750702e-01f, -1.36192277e-01f, -1.08752497e-01f,
  6.14688508e-02f, -2.26026669e-01f, -3.73484552e-01f, 2.49124151e-02f, -1.44013822e-01f, -1.89710543e-01f, -1.31249338e-01f, -2.03672260e-01f, -1.95828408e-01f, 1.41235180e-02f,
  5.13231494e-02f, -2.00524344e-03f, -4.12193276e-02f, 4.99892123e-02f, 1.35401234e-01f, -5.12454882e-02f, -4.41559730e-03f, -1.08006587e-02f, -2.07944848e-02f, 1.40918288e-02f,
  -4.42078151e-02f, -1.87714845e-02f, -4.32870947e-02f, 4.32971530e-02f, 2.90874159e-03f, -5.65412417e-02f, 1.47888102e-02f, 1.48516491e-01f, 7.35493982e-03f, 3.65545750e-02f,
  -4.79873791e-02f, -1.71320792e-02f, -3.78650464e-02f, -6.49951398e-03f, 1.62390235e-03f, -5.27349561e-02f, 4.72706631e-02f, -6.25068992e-02f, 2.70682611e-02f, 7.65805040e-03f,
  2.13381425e-01f, -1.94613226e-02f, -3.72347161e-02f, 2.92448085e-02f, -3.36279697e-03f, -6.62679300e-02f, 4.21784967e-02f, 8.55524689e-02f, -9.27822515e-02f, -2.76684221e-02f,
  -6.59388900e-02f, -1.31981652e-02f, -5.76348715e-02f, -4.42606807e-02f, -9.19818878e-02f, -7.65642524e-02f, 1.59542218e-01f, -5.93482256e-02f, 2.48198155e-02f, -6.17341623e-02f,
  1.52615637e-01f, 1.10042974e-01f, -3.52244154e-02f, 3.20608392e-02f, 9.15357396e-02f, -2.52485052e-02f, -7.28746429e-02f, 9.69703123e-03f, -4.90066409e-02f, 3.99903566e-01f,
  -3.48863900e-01f, -1.32497475e-01f, 9.04268324e-02f, 2.37960234e-01f, 2.63781309e-01f, 1.63311690e-01f, 3.08506101e-01f, 1.77736506e-01f, 9.68796238e-02f, 1.69292942e-01f,
  -2.26776555e-01f, -3.54818523e-01f, -2.10661426e-01f, -2.11095601e-01f, -2.20362559e-01f, 2.89992094e-01f, 3.91182691e-01f, -4.64870296e-02f, -2.69695580e-01f, -9.11723524e-02f,
  4.89006788e-02f, 7.61057064e-02f, -1.57444715e-01f, -1.30284086e-01f, 1.67399362e-01f, 6.67997003e-02f, 2.21976385e-01f, -3.35901529e-02f, -1.01871423e-01f, 2.15513378e-01f,
  -4.84191515e-02f, -1.38500169e-01f, 1.07452273e-01f, -8.93303230e-02f, -1.06287420e-01f, -1.09970346e-01f, 4.90111820e-02f, -1.10248253e-01f, -1.95611984e-01f, -1.29097775e-01f,
  -1.27950728e-01f, -2.33077541e-01f, -2.04930812e-01f, -9.78763252e-02f, -3.43256034e-02f, -1.48385122e-01f, -6.99003413e-02f, -1.26295224e-01f, -1.55256428e-02f, -1.57062858e-01f,
  -7.34908506e-02f, -1.73189506e-01f, -1.28787205e-01f, 5.46012521e-02f, -1.91822574e-01f, -1.34445578e-01f, -4.71319407e-02f, -1.75617337e-01f, -1.86236277e-01f, 1.46246448e-01f,
  -6.50784150e-02f, -8.26598145e-03f, -9.06596333e-02f, 1.05639629e-01f, -2.16390155e-02f, 4.86376099e-02f, -2.39607436e-03f, -1.04616426e-01f, 2.55425759e-02f, -1.49504598e-02f,
  -1.79669946e-01f, 6.68296590e-02f, 1.14109050e-02f, -7.48001188e-02f, -9.54859853e-02f, -6.85185790e-02f, -1.56360096e-04f, 2.90539768e-02f, 8.17157850e-02f, 2.87800003e-02f,
  3.13266404e-02f, 5.58119500e-03f, 7.00732991e-02f, 3.30037996e-02f, 6.22619614e-02f, -1.05203576e-01f, 6.25878572e-02f, -5.72984442e-02f, -6.89749345e-02f, 2.93872990e-02f,
  2.80801356e-01f, -1.07611403e-01f, 1.53793752e-01f, 2.95539163e-02f, 2.69599706e-02f, -8.58757347e-02f, 5.80859091e-03f, 8.37803558e-02f, -8.79011527e-02f, -2.96515256e-01f,
  -2.52347201e-01f, -1.93360656e-01f, -2.10822318e-02f, 2.51502022e-02f, -2.66214479e-02f, -5.93761764e-02f, 1.80093609e-02f, 1.69835761e-01f, 9.34812278e-02f, 1.02711901e-01f,
  1.46516562e-01f, 2.03964695e-01f, 2.69849688e-01f, 1.95773825e-01f, 1.41590133e-01f, 8.11093152e-02f, 1.66689664e-01f, 7.73154348e-02f, -4.58363555e-02f, 4.58057076e-01f,
  1.77590013e-01f, -5.22440612e-01f, 1.26128241e-01f, 3.45676154e-01f, 2.85925895e-01f, 2.65757769e-01f, -6.13860637e-02f, 5.33371754e-02f, 1.06279999e-01f, 6.63798973e-02f,
  -1.78610519e-01f, 6.73657209e-02f, 1.15927778e-01f, -2.16356497e-02f, 1.33063152e-01f, 1.33392394e-01f, 2.51178622e-01f, 3.58770102e-01f, 3.47552121e-01f, 1.13791175e-01f,
  6.27477840e-02f, 6.60091490e-02f, 3.51021923e-02f, -1.61224008e-02f, -1.13544874e-01f, 1.69039175e-01f, -5.81941791e-02f, -1.45479485e-01f, -7.91349560e-02f, -1.39969155e-01f,
  -2.05528930e-01f, -2.03886718e-01f, 2.22692087e-01f, -9.59481150e-02f, -1.50065303e-01f, -1.23653226e-01f, -4.10335287e-02f, -1.59104437e-01f, -9.85527933e-02f, -5.83834499e-02f,
  -4.89347568e-03f, -4.07612845e-02f, 2.91277189e-02f, -1.67537834e-02f, -5.90901040e-02f, -7.72655085e-02f, -1.21493414e-01f, 4.45730276e-02f, 1.74733400e-02f, -1.70742959e-01f,
  -3.84987332e-02f, -2.50177924e-02f, -3.05384919e-02f, 2.40003597e-02f, -2.71217506e-02f, 1.09203041e-01f, -1.28985420e-01f, -2.35390943e-02f, 1.02218717e-01f, 3.25865820e-02f,
  8.32273439e-02f, 7.64356852e-02f, 1.39893994e-01f, 1.41539469e-01f, 9.91684347e-02f, 2.97199152e-02f, 6.07656613e-02f, 1.18699022e-01f, 1.93814382e-01f, 5.27754165e-02f,
  1.00682499e-02f, 2.01725826e-01f, 3.24072391e-02f, 2.10757162e-02f, 9.98272523e-02f, 6.64755255e-02f, -6.31662784e-03f, -8.03523585e-02f, 8.76040831e-02f, 8.05725455e-02f,
  1.15046456e-01f, -7.31121972e-02f, -1.12092666e-01f, -3.75802517e-02f, -1.67686298e-01f, 1.09503634e-01f, -1.50052300e-02f, -5.61821274e-02f, -4.29058596e-02f, -3.53800803e-02f,
  -9.83789414e-02f, 2.59559840e-01f, 5.75327985e-02f, -6.61215782e-02f, -9.60835963e-02f, -1.67576745e-01f, 8.46440420e-02f, -9.48171765e-02f, -1.49798393e-01f, -4.84745912e-02f,
  -1.45976737e-01f, -7.26372898e-02f, -2.51704864e-02f, 9.71041713e-03f, 2.17235595e-01f, 1.53985932e-01f, -2.01761536e-02f, -3.35398875e-02f, -9.93800387e-02f, -1.02815777e-01f,
  -8.99064317e-02f, 1.03382379e-01f, 2.00666457e-01f, 1.76918373e-01f, 9.47002694e-02f, 2.05457807e-01f, 9.02269185e-02f, 3.37221660e-02f, 9.15864035e-02f, 2.27478091e-02f,
  -2.85574287e-01f, 4.17367995e-01f, -4.40223098e-01f, 1.45699844e-01f, 1.96643043e-02f, 1.21726934e-02f, 2.95369178e-01f, 1.11628234e-01f, 4.45202440e-02f, 8.56506824e-02f,
  4.78005670e-02f, 3.79456282e-02f, 5.82956932e-02f, 9.65332836e-02f, 1.13745391e-01f, 2.69955337e-01f, 1.32697776e-01f, -2.16418415e-01f, -2.34828308e-01f, -1.57668263e-01f,
  2.27469817e-01f, 1.31417245e-01f, -8.80690739e-02f, 4.78985012e-02f, 2.10581888e-02f, -2.43750308e-02f, 3.74897830e-02f, 2.26035845e-02f, 8.19292217e-02f, -4.25674170e-02f,
  -3.19102794e-01f, -2.39107385e-01f, -1.13015138e-01f, -1.98707096e-02f, -2.13357702e-01f, -2.31790021e-01f, -1.26291424e-01f, -2.11269155e-01f, -6.56509846e-02f, 6.29168823e-02f,
  -1.81069881e-01f, -1.49022369e-02f, 1.01078451e-01f, 1.26179755e-01f, 8.56687501e-02f, -9.74858627e-02f, 3.93939838e-02f, -1.49274334e-01f, -1.13725692e-01f, -3.01979214e-01f,
  2.89429069e-01f, -2.71648020e-01f, -4.07157272e-01f, -9.27666947e-03f, -2.10191697e-01f, -1.72251657e-01f, -1.11623168e-01f, -3.16535652e-01f, -3.33575040e-01f, -7.66560882e-02f,
  -2.90473681e-02f, 1.33599283e-03f, 5.69363683e-02f, 1.26065865e-01f, 2.25409463e-01f, 2.43654270e-02f, 1.20098375e-01f, 1.72682509e-01f, 9.92410034e-02f, 5.23840152e-02f,
  -4.94930446e-02f, -2.07949743e-01f, -2.80096363e-02f, -8.69528875e-02f, -4.67120260e-02f, 2.40571215e-03f, 6.29793033e-02f, 1.58090889e-01f, 3.72661874e-02f, -1.21196788e-02f,
  -4.56473082e-02f, -4.99642529e-02f, -5.29162250e-02f, 3.60575505e-02f, -1.46266386e-01f, -1.16598364e-02f, 3.88208049e-04f, 2.84375679e-02f, -2.57752668e-02f, 8.42618346e-02f,
  2.54077375e-01f, 4.93469089e-02f, -8.77433345e-02f, 9.85930040e-02f, -4.66849245e-02f, -2.10670494e-02f, -1.41460383e-02f, 4.12835702e-02f, -3.13396305e-02f, 7.07962438e-02f,
  5.75874634e-02f, -7.90660083e-02f, 1.92291185e-01f, 1.38392016e-01f, -4.78018299e-02f, 2.51614358e-02f, 1.37950897e-01f, -7.40174623e-03f, 7.50359371e-02f, -7.80208260e-02f,
  3.04260731e-01f, 5.30760847e-02f, -5.64668290e-02f, 1.05460696e-01f, -4.18581143e-02f, -2.05299016e-02f, 1.52770355e-01f, -5.04504133e-04f, -1.24904886e-01f, 4.19462174e-01f,
  -1.07472323e-01f, -7.95322657e-02f, 1.63866684e-01f, -9.74115282e-02f, -3.12839448e-02f, -7.62601346e-02f, -2.26390526e-01f, -1.82508871e-01f, 9.06142406e-04f, -1.85574368e-02f,
  4.41049896e-02f, 5.65161072e-02f, 4.19535935e-02f, -7.24447668e-02f, -1.94178239e-01f, -1.24884471e-01f, -7.18487203e-02f, -1.00022011e-01f, -1.74434483e-01f, -2.04977736e-01f,
  -7.33753443e-02f, -4.88764979e-02f, -1.18690088e-01f, -1.03994116e-01f, -5.06849550e-02f, 3.61859752e-03f, 5.59049174e-02f, -1.46592362e-02f, -2.10433379e-02f, 5.24903042e-03f,
  -1.04040742e-01f, -1.45130858e-01f, -2.68654656e-02f, -5.56279942e-02f, 6.88606501e-02f, 7.66463354e-02f, -4.98966835e-02f, -3.24526168e-02f, 1.58627052e-02f, -4.19945940e-02f,
  1.34234680e-02f, -9.46609583e-03f, -2.80157216e-02f, -1.63716227e-02f, -1.01317376e-01f, -1.09559417e-01f, -3.99680212e-02f, -8.46399739e-02f, -1.56823751e-02f, -5.16263843e-02f,
  -2.51869671e-02f, -4.17138860e-02f, -1.02896117e-01f, -1.67338233e-02f, -8.84501562e-02f, 2.46468149e-02f, -9.32961777e-02f, -8.10415968e-02f, -4.47205119e-02f, -5.42727150e-02f,
  -7.89133310e-02f, 1.88474394e-02f, -3.01637570e-03f, -2.69085709e-02f, 4.31475379e-02f, 3.54693970e-03f, 8.73675337e-04f, -9.60005522e-02f, 1.94642469e-02f, -1.78463981e-02f,
  -1.77786481e-02f, 1.00850880e-01f, -2.17318558e-03f, -1.09523013e-01f, -1.19148932e-01f, -8.95694494e-02f, -6.23298064e-02f, -9.39715356e-02f, -6.54180571e-02f, 5.87546406e-03f,
  -7.30327442e-02f, -4.09883261e-02f, 3.36778648e-02f, -4.69441265e-02f, 2.79668369e-04f, -5.01534380e-02f, -2.68932115e-02f, -1.03701323e-01f, -9.14568081e-02f, -6.21894784e-02f,
  -9.19011906e-02f, 1.65037334e-01f, -3.24054956e-02f, -7.84478411e-02f, -2.18175817e-02f, 1.40862271e-01f, 7.44038150e-02f, -6.02600863e-03f, 2.74971481e-02f, -2.77560912e-02f,
  -1.45800099e-01f, -8.04045424e-02f, -6.71984479e-02f, -5.50355855e-03f, -5.90040796e-02f, -5.13211414e-02f, -7.24493936e-02f, -4.42361273e-02f, -6.28828853e-02f, 3.66717055e-02f,
  -1.70507766e-02f, -1.56879902e-01f, -1.34402126e-01f, -1.89476889e-02f, -9.70183611e-02f, -5.52172139e-02f, -9.96988565e-02f, -5.46543598e-02f, -7.86820054e-02f, -9.81872603e-02f,
  2.09451377e-01f, -4.04277116e-01f, -1.57976523e-01f, 3.92045826e-02f, -8.64451602e-02f, -2.30192631e-01f, -4.85670835e-01f, -1.73472479e-01f, 3.64264213e-02f, -3.92426670e-01f,
  -2.09548205e-01f, 1.66730464e-01f, 6.42772615e-02f, 4.89499560e-03f, -1.55958325e-01f, -4.94666129e-01f, -3.34320903e-01f, -3.20991017e-02f, 1.44418687e-01f, -1.56905875e-02f,
  -1.23931728e-02f, 1.48877546e-01f, 1.96140096e-01f, 7.57780001e-02f, -8.16139430e-02f, 9.02747437e-02f, -1.69990122e-01f, 1.07676946e-02f, -1.83411911e-01f, -1.52635962e-01f,
  -2.08415821e-01f, -1.09207973e-01f, 1.16809420e-02f, 1.21626489e-01f, -6.37515774e-03f, 3.51880826e-02f, -1.10958241e-01f, 6.10900037e-02f, 2.13037785e-02f, -5.89230172e-02f,
  2.69582607e-02f, -2.27293596e-02f, 8.59177113e-02f, 2.68720686e-02f, -3.80694643e-02f, 3.63491736e-02f, 3.55744436e-02f, 6.71274066e-02f, 7.20172375e-03f, -1.12018064e-01f,
  -9.75552872e-02f, 1.39201283e-02f, 1.68584362e-02f, -4.60063331e-02f, -2.32420322e-02f, 1.41344249e-01f, -1.60232577e-02f, 6.74680993e-02f, -1.17235975e-02f, -1.47049591e-01f,
  -6.30559996e-02f, -4.95167822e-03f, -2.99131274e-02f, 1.09923206e-01f, 6.25346303e-02f, -5.35705909e-02f, 5.22570275e-02f, -5.76183721e-02f, 5.57200611e-02f, -3.47593194e-03f,
  -9.13108364e-02f, -2.65642330e-02f, 2.48117410e-02f, -4.14449759e-02f, 5.96404187e-02f, -1.96565464e-02f, -4.00882997e-02f, -3.12891416e-02f, -3.27625833e-02f, -1.46452347e-02f,
  5.85957579e-02f, -1.60743296e-02f, 4.66434434e-02f, 4.59819846e-03f, -1.33705661e-01f, -7.28784725e-02f, 5.95439449e-02f, 6.88322471e-04f, 2.63964571e-02f, -1.76545698e-02f,
  5.28106466e-02f, -1.73512883e-02f, -1.49201423e-01f, -1.21081024e-02f, -7.92661831e-02f, -2.22102366e-02f, -1.14146667e-02f, 7.19563290e-02f, 9.10686478e-02f, -4.83880863e-02f,
  -1.15617700e-01f, -1.16509892e-01f, -4.06416729e-02f, 6.82971701e-02f, -3.94411162e-02f, 3.64052653e-02f, -1.09029792e-01f, -5.86248025e-05f, -8.54757847e-04f, 3.70769836e-02f,
  -8.38399120e-03f, -1.07847892e-01f, -5.04138097e-02f, -6.95256889e-02f, 3.62987705e-02f, 2.81269886e-02f, -1.13023542e-01f, -4.31988984e-02f, -6.03020675e-02f, -2.86929220e-01f,
  3.16879451e-01f, 5.36181740e-02f, 5.29698692e-02f, 6.80805743e-02f, 1.67910948e-01f, 2.42820561e-01f, 2.45212168e-01f, 2.45952934e-01f, 9.98819247e-02f, 1.37839854e-01f,
  1.18210122e-01f, -3.82499285e-02f, -7.66845793e-02f, -1.19240791e-01f, 4.21346053e-02f, -1.36832613e-02f, -1.09168701e-01f, -2.44983230e-02f, -4.51586135e-02f, -1.15391826e-02f,
  3.60645466e-02f, 1.79531649e-01f, 1.08455278e-01f, 4.68688644e-03f, -7.10087195e-02f, -1.03510655e-02f, 4.72516529e-02f, -4.47626598e-02f, -1.02673031e-01f, -2.91662186e-01f,
  -2.73934215e-01f, 1.67608231e-01f, 3.72363552e-02f, -6.13141544e-02f, 8.83792713e-02f, 8.83296207e-02f, 1.00266626e-02f, 1.16222747e-01f, 1.31020829e-01f, -4.50436026e-03f,
  -2.08521932e-02f, -2.65639424e-02f, 7.84070939e-02f, 4.55365740e-02f, 1.79923289e-02f, -2.34380905e-02f, 1.01114754e-02f, 2.04894766e-02f, -2.48025749e-02f, -1.18823953e-01f,
  -9.16090701e-03f, 1.05226122e-01f, 9.11298469e-02f, -1.78364515e-02f, -5.98273911e-02f, -1.09681144e-01f, 4.26879972e-02f, -1.27705231e-01f, 1.16444640e-02f, -8.46707672e-02f,
  1.94849987e-02f, 1.38784319e-01f, 7.59344548e-03f, -3.95068377e-02f, 2.83350777e-02f, 4.60575186e-02f, -6.45123795e-02f, -2.92337071e-02f, 9.28699449e-02f, 9.56632644e-02f,
  2.31910963e-02f, 5.41768456e-03f, 1.95560843e-01f, 1.59804985e-01f, 4.36846837e-02f, 4.22919989e-02f, -4.55019400e-02f, 9.28895772e-02f, 7.07330778e-02f, 1.54533297e-01f,
  3.49427499e-02f, 2.10713372e-02f, 8.41395333e-02f, -3.18036340e-02f, 5.85801974e-02f, 8.58063996e-02f, 2.56125163e-02f, 1.41941264e-01f, 6.87687919e-02f, 1.32806897e-01f,
  6.68469165e-03f, 2.18587428e-01f, -1.18058927e-01f, -2.13556290e-01f, -7.29849190e-02f, -5.86117171e-02f, -1.16557553e-01f, 7.41390586e-02f, -3.63308899e-02f, -2.26769168e-02f,
  -1.64949428e-02f, 4.62744385e-02f, 3.90468799e-02f, -3.60739753e-02f, 1.22964449e-01f, 2.94616376e-03f, -1.90205183e-02f, 1.82041638e-02f, -1.37866274e-01f, -6.87062666e-02f,
  -1.16572203e-02f, 5.82287423e-02f, 6.61867559e-02f, 1.43006037e-03f, 1.65116228e-02f, -1.48985181e-02f, -2.46360488e-02f, -6.69187084e-02f, -2.25022063e-02f, 1.71744227e-01f,
  1.70604706e-01f, 3.87248605e-01f, 2.55431026e-01f, -1.58077791e-01f, -1.63856804e-01f, 1.01320997e-01f, 2.63772964e-01f, 1.73431888e-01f, -1.79412097e-01f, 3.45153101e-02f,
  -4.43845727e-02f, -3.01188529e-01f, -1.15665048e-01f, -8.22464004e-02f, 1.35079026e-01f, 1.90496191e-01f, 1.67358533e-01f, 1.13552921e-01f, -1.23807408e-01f, -1.31939650e-01f,
  -2.26303473e-01f, -6.30416498e-02f, 7.85101578e-03f, 5.33307232e-02f, 6.34651557e-02f, -1.15812130e-01f, 1.24600202e-01f, 5.19268252e-02f, 1.15133367e-01f, 4.51984890e-02f,
  -3.99242528e-02f, 3.58192086e-01f, -2.35797122e-01f, -2.26676658e-01f, -1.38846800e-01f, -4.80049923e-02f, -6.47605257e-03f, 5.49829332e-03f, 9.24165826e-03f, 4.09790613e-02f,
  -1.50627732e-01f, 1.85375437e-02f, 6.69298647e-03f, -3.16575132e-02f, -3.91696431e-02f, -1.31528713e-02f, 5.51109388e-02f, 8.71836320e-02f, -3.08995117e-02f, 5.74503206e-02f,
  -1.72354907e-01f, -6.79598078e-02f, 1.32453144e-01f, 1.21201426e-01f, 1.14284456e-01f, -2.03334212e-01f, 1.35066524e-01f, 9.00214836e-02f, 8.05073529e-02f, 1.38005719e-01f,
  -9.91230831e-02f, 4.08708528e-02f, 6.29559010e-02f, 1.50334448e-01f, -7.07867593e-02f, -5.92938177e-02f, -1.27420602e-02f, 1.41734928e-02f, -1.70280226e-02f, 9.11498070e-02f,
  6.35155141e-02f, -1.92379802e-02f, 1.24344766e-01f, 6.54909834e-02f, -7.27723986e-02f, 7.69841427e-04f, 3.23905121e-03f, 9.47712287e-02f, -4.28338610e-02f, 5.12182675e-02f,
  -1.12877026e-01f, -2.23752856e-02f, 3.08374818e-02f, 1.32799605e-02f, 2.82238168e-03f, 5.04732169e-02f, -1.11226469e-01f, -6.90559074e-02f, 7.14234188e-02f, 1.15267932e-01f,
  -2.84165293e-01f, -2.89286468e-02f, -7.88608789e-02f, 5.97521886e-02f, 4.21953620e-03f, -9.08462405e-02f, -3.91953327e-02f, -7.05967005e-03f, -2.73112953e-02f, 5.21105677e-02f,
  7.21556991e-02f, 2.04608478e-02f, 3.81970480e-02f, -9.89156514e-02f, -2.10786924e-01f, -9.44043174e-02f, -7.80759752e-02f, -1.35972261e-01f, -1.14460945e-01f, -1.04712816e-02f,
  -1.94214601e-02f, -1.26977980e-01f, -2.37934157e-01f, -1.00207306e-01f, -8.95513222e-02f, -2.63057381e-01f, -3.78380455e-02f, -1.18963271e-01f, -1.32303491e-01f, -1.09260589e-01f,
  6.39473736e-01f, 1.46774441e-01f, -3.54784317e-02f, -1.62191130e-02f, -3.06009024e-01f, -1.29240423e-01f, -2.14945152e-01f, 3.72752883e-02f, 5.82625493e-02f, 8.51566344e-02f,
  1.05752878e-01f, 1.12426691e-01f, 1.85917318e-01f, 1.94660574e-01f, 1.65769428e-01f, 7.60772750e-02f, 1.09317228e-02f, 9.78122801e-02f, 2.00823490e-02f, 1.07561186e-01f,
  6.31369278e-02f, 7.11237043e-02f, 2.80273646e-01f, 1.14487432e-01f, -3.32645439e-02f, -4.37368527e-02f, -1.00971587e-01f, -5.13360724e-02f, -5.99803578e-04f, -3.21533270e-02f,
  1.59122035e-01f, 4.69508357e-02f, -1.51235564e-02f, -8.97325277e-02f, -1.83119521e-01f, 4.92578559e-02f, -5.41855916e-02f, -6.78787529e-02f, -1.06975771e-01f, 2.53074039e-02f,
  -1.40825942e-01f, -3.97293605e-02f, -1.22642964e-01f, -1.15775816e-01f, -1.32983223e-01f, -4.99681607e-02f, 7.54656196e-02f, -1.93312578e-02f, -8.14085361e-04f, 5.20044304e-02f,
  -2.81639621e-02f, -1.41224697e-01f, -1.56418890e-01f, -1.11479379e-01f, -8.34040064e-03f, 7.33181194e-04f, -8.83383118e-03f, -6.83842450e-02f, -5.39261475e-02f, 1.25545934e-01f,
  -8.36434141e-02f, -4.08633500e-02f, 8.84644091e-02f, 1.77124739e-02f, 1.82993591e-01f, 9.61632952e-02f, -1.35722104e-02f, 2.99788658e-02f, -4.55287173e-02f, 3.50667760e-02f,
  -2.06807237e-02f, 7.35560134e-02f, -1.01139117e-02f, 5.92097417e-02f, 2.62153484e-02f, -9.56659392e-02f, 8.85619875e-03f, 9.60755348e-02f, 7.15864524e-02f, 5.25238104e-02f,
  -2.42970828e-02f, 2.89892145e-02f, 5.34483567e-02f, -2.76569556e-02f, 1.85114648e-02f, 5.11139035e-02f, 1.13416590e-01f, 9.35603455e-02f, -1.12013519e-02f, 7.94457854e-04f,
  -9.37198568e-03f, -1.40591085e-01f, 1.75445363e-01f, 9.71075222e-02f, -8.96780416e-02f, -1.03674941e-01f, -3.55619774e-03f, 1.21934777e-02f, -8.13549832e-02f, -6.41157106e-02f,
  -3.30183096e-02f, 1.24795001e-03f, -1.04101673e-02f, -4.64950502e-02f, -3.99684310e-02f, 3.83141264e-02f, 1.19844981e-01f, -3.66521589e-02f, 1.49129601e-02f, -2.21705418e-02f,
  1.53108649e-02f, 8.21939390e-03f, 4.75698942e-03f, -6.77218661e-02f, -4.39666994e-02f, 9.57760774e-03f, -1.00691523e-02f, -2.87899114e-02f, 5.55977114e-02f, 1.72577068e-01f,
  -6.03347421e-01f, 1.97036639e-01f, 2.06017662e-02f, -2.56094813e-01f, -2.43146375e-01f, -2.52558470e-01f, 5.31807765e-02f, -1.07838944e-01f, -1.48691535e-01f, 2.64481008e-01f,
  1.62478015e-01f, -1.82886794e-02f, 4.94198725e-02f, -4.66267802e-02f, -2.20483154e-01f, 2.15181798e-01f, 2.61061583e-02f, -3.21405917e-01f, -4.45661187e-01f, -4.56142724e-01f,
  -2.58372843e-01f, -4.57469016e-01f, -4.40659165e-01f, -3.09359521e-01f, -4.53826226e-02f, -2.11026594e-01f, -6.83322623e-02f, -3.06085020e-01f, -2.36761451e-01f, -1.00549221e-01f,
  2.55576760e-01f, -2.98459202e-01f, -1.03408836e-01f, -6.45923167e-02f, 7.77913332e-02f, 9.74937454e-02f, 5.31591773e-02f, -5.08681498e-02f, 9.85060185e-02f, 3.98121476e-02f,
  -1.43272821e-02f, 7.56455660e-02f, -7.22889677e-02f, -3.36145572e-02f, -7.41892159e-02f, -2.37917006e-02f, -6.08203607e-03f, -8.37604254e-02f, -2.57452819e-02f, 2.23529771e-01f,
  2.37755209e-01f, -4.76711616e-02f, 9.49278548e-02f, 6.41916785e-03f, -6.56609423e-03f, 1.49578312e-02f, 7.43592754e-02f, -1.21737242e-01f, -9.54945162e-02f, 2.60010250e-02f,
  -1.00744784e-01f, 1.11089908e-01f, -5.22769149e-03f, -8.53872523e-02f, 7.04595447e-02f, -6.34245947e-03f, 1.36668393e-02f, 5.93986511e-02f, -9.05036628e-02f, -2.18396299e-02f,
  1.38871685e-01f, 1.14627099e-02f, -4.80895974e-02f, 2.05334201e-02f, -6.59006834e-02f, 3.20161730e-02f, -3.68118170e-03f, 6.71780929e-02f, 1.66357856e-03f, 5.94571643e-02f,
  -2.04500593e-02f, 6.10790662e-02f, -4.87172194e-02f, -7.15890527e-02f, 8.37514526e-05f, 6.60207123e-02f, 9.99628305e-02f, 2.71491073e-02f, -5.67634404e-02f, 5.04965335e-02f,
  -6.51171133e-02f, -1.66145623e-01f, 7.83128589e-02f, 4.66472134e-02f, 4.08138148e-02f, 7.53223822e-02f, 5.05391210e-02f, -2.95838770e-02f, 4.29034419e-03f, -5.74190207e-02f,
  -7.19043165e-02f, -3.29457819e-02f, 2.49827094e-02f, 1.58805639e-01f, -4.37269285e-02f, -3.82830240e-02f, 7.71871731e-02f, 6.16662167e-02f, 2.85407044e-02f, 1.51854664e-01f,
  2.29435131e-01f, 1.00333532e-02f, 1.24072574e-01f, 1.87012643e-01f, 3.42287458e-02f, 1.33017346e-03f, 2.31717881e-02f, -1.10853314e-02f, -2.29805652e-02f, 5.51787838e-02f,
  4.97490197e-01f, 2.38006338e-01f, 2.33545899e-01f, 1.30939677e-01f, -3.65071557e-02f, -1.66055724e-01f, -4.90974374e-02f, 6.07995279e-02f, 7.52058579e-03f, 3.12102959e-02f,
  -2.02172309e-01f, -2.35697553e-01f, -5.00952862e-02f, -7.03890473e-02f, -3.54903266e-02f, 3.15073319e-02f, 8.33725780e-02f, 1.59881309e-01f, 2.16286793e-01f, 6.30235486e-03f,
  2.23138314e-02f, 2.50964910e-01f, 3.36263210e-01f, 2.13259354e-01f, -5.70761748e-02f, -2.17428356e-02f, 6.42567277e-02f, -1.25083709e-02f, -6.18163235e-02f, 1.01661600e-01f,
  -2.05099225e-01f, 1.43128783e-01f, -3.66954803e-02f, 3.39867063e-02f, 6.91998750e-02f, 2.46921644e-01f, 1.12603895e-01f, 1.14663646e-01f, 9.93785858e-02f, -5.08448370e-02f,
  -2.83333985e-03f, 8.26348588e-02f, -2.09799148e-02f, -1.01788752e-01f, -3.11245434e-02f, -2.16745008e-02f, 4.14940491e-02f, -1.20673232e-01f, -7.22958297e-02f, 8.12915154e-03f,
  -2.16400072e-01f, -1.96669564e-01f, -2.25754350e-01f, -1.28132582e-01f, -1.76637888e-01f, -1.21785201e-01f, -1.20416403e-01f, -1.02715522e-01f, 5.92194637e-03f, 5.49224094e-02f,
  -5.68123944e-02f, 7.32157454e-02f, -1.61754191e-01f, -2.46386915e-01f, -2.41168454e-01f, 1.33985020e-02f, 3.14647029e-03f, -1.41099289e-01f, -1.77417621e-01f, 1.91560723e-02f,
  -1.82787240e-01f, -2.21426725e-01f, -1.98245212e-01f, 7.20499307e-02f, 1.34902433e-01f, -7.73072466e-02f, 1.84928030e-02f, -1.55079901e-01f, -1.03904724e-01f, -1.42164856e-01f,
  -7.29239583e-02f, 1.05780639e-01f, 1.84733137e-01f, -1.97399110e-02f, -5.69766611e-02f, -7.36790225e-02f, -7.02321678e-02f, -1.27772734e-01f, 4.89839017e-02f, 1.38291821e-01f,
  -2.19532311e-01f, -3.00009012e-01f, 1.23689830e-01f, 8.07777271e-02f, 8.27969611e-02f, 5.33614010e-02f, -1.40977517e-01f, -2.71920450e-02f, -3.79768055e-04f, -1.19444743e-01f,
  7.85453338e-03f, 1.14525087e-01f, 6.28536642e-02f, -2.12612860e-02f, 1.24209616e-02f, 3.28020640e-02f, -6.62423670e-02f, 7.11224880e-03f, -8.75502229e-02f, 1.34084430e-02f,
  1.07619472e-01f, 4.37417142e-02f, 3.59326974e-02f, -1.93309207e-02f, -4.71263565e-02f, 8.92921463e-02f, 7.40669891e-02f, 3.14322882e-03f, 7.37336949e-02f, 7.56275058e-02f,
  4.13343072e-01f, -2.63272077e-01f, 2.89947838e-01f, 3.12090904e-01f, 3.30429405e-01f, 2.30901837e-01f, 1.59639314e-01f, 1.97738647e-01f, 1.66006610e-01f, -2.79316423e-03f,
  -1.32930398e-01f, 2.49123648e-02f, 7.04772025e-02f, -8.48734826e-02f, -2.31153751e-03f, -1.03967031e-02f, 8.46941322e-02f, 2.28099987e-01f, 1.59237579e-01f, 1.33568347e-01f,
  -1.45404011e-01f, -2.10827158e-04f, -9.51752216e-02f, 4.35008444e-02f, -3.95016335e-02f, 9.51056853e-02f, -2.06842441e-02f, -1.21072195e-01f, -5.67861162e-02f, -1.50575504e-01f,
  -1.74371928e-01f, -1.36110216e-01f, -2.26721913e-02f, -6.32141382e-02f, -8.28344598e-02f, -1.54845556e-02f, 6.08301014e-02f, -4.13737493e-04f, -1.56732291e-01f, -4.78554331e-02f,
  -5.85460402e-02f, -1.14745021e-01f, 3.03901229e-02f, 4.73408075e-03f, 2.52615046e-02f, -1.71498023e-02f, -1.45120144e-01f, -8.81944373e-02f, 2.32456718e-02f, -5.35568818e-02f,
  -5.93414716e-02f, -4.91407327e-02f, 1.55167907e-01f, 8.45111012e-02f, 4.24687266e-02f, 4.65254486e-02f, -3.18606198e-02f, 8.67103972e-03f, 6.63200840e-02f, 7.13024810e-02f,
  -1.54080495e-01f, 1.40264094e-01f, 4.37852368e-02f, -2.03174576e-02f, 3.88905071e-02f, 7.17472658e-02f, 9.74758640e-02f, 2.35268530e-02f, 6.36893809e-02f, 5.51209822e-02f,
  2.11027320e-02f, 2.28436459e-02f, 8.39446560e-02f, 8.81964564e-02f, 5.33180460e-02f, 4.19653207e-02f, 8.89361277e-02f, -5.55994213e-02f, 1.03479112e-02f, 1.34796498e-03f,
  1.77965090e-02f, 4.95232269e-03f, -2.20125029e-03f, -1.00915365e-01f, -7.95221981e-03f, 3.13211489e-03f, -4.27144319e-02f, -6.18777275e-02f, 7.44403601e-02f, 1.73301231e-02f,
  -1.98795289e-01f, 5.62914014e-02f, -2.59645749e-02f, -9.82021093e-02f, -1.63326804e-02f, -1.32083684e-01f, 1.29752085e-02f, -8.57136175e-02f, -1.80679977e-01f, -1.16120670e-02f,
  -9.01923627e-02f, -1.00198753e-01f, -9.47068259e-02f, -6.15793914e-02f, 9.73900873e-03f, 1.11312000e-02f, -1.67091280e-01f, -3.58740352e-02f, -8.99074972e-02f, -1.37898728e-01f,
  -9.51937959e-02f, 8.86945873e-02f, 2.27859914e-01f, 1.85483888e-01f, 3.52667384e-02f, 1.45631909e-01f, 6.19228259e-02f, 2.70341691e-02f, 5.12377173e-02f, -4.02233526e-02f,
  -3.93745393e-01f, 2.21782297e-01f, 3.51754516e-01f, -2.60287881e-01f, 1.31671026e-01f, 1.97362229e-01f, 2.88264424e-01f, 9.33710765e-03f, -1.28232464e-01f, 1.18566886e-01f,
  8.32433403e-02f, -1.86332271e-01f, 5.77127095e-03f, -8.44379961e-02f, 4.78028931e-04f, 1.84417188e-01f, 2.60008693e-01f, 8.84471741e-03f, -2.82990664e-01f, -3.12199831e-01f,
  -1.63795143e-01f, -1.97158977e-01f, -2.40586877e-01f, -4.17843200e-02f, -2.35803686e-02f, -3.29846442e-02f, 2.53188998e-01f, 6.86307847e-02f, 1.54769927e-01f, 1.87528189e-02f,
  -1.60600290e-01f, 8.48618802e-03f, -1.06973182e-02f, -8.74568895e-02f, 1.09582998e-01f, -7.43725449e-02f, -3.18219401e-02f, 4.26388197e-02f, 2.72225458e-02f, 9.28570330e-03f,
  -3.31654809e-02f, -4.86431010e-02f, 4.33901921e-02f, -2.59923451e-02f, -3.81433070e-02f, -4.38577272e-02f, -7.03671724e-02f, -9.75138396e-02f, -6.37874603e-02f, -2.67867185e-02f,
  3.40268165e-02f, -1.18206628e-01f, 2.74892636e-02f, 5.60987480e-02f, 5.55544272e-02f, -9.53489989e-02f, 1.73723456e-02f, -1.68550923e-01f, 1.32677648e-02f, -2.27087542e-01f,
  -7.58229420e-02f, 5.64545877e-02f, 4.90054265e-02f, -1.18430117e-02f, -1.18955281e-02f, 4.88283038e-02f, 6.70463294e-02f, 2.44408567e-03f, -2.96907104e-03f, -5.50409816e-02f,
  2.24648416e-02f, -2.95615885e-02f, 8.37597717e-03f, 5.86696826e-02f, -7.90521204e-02f, -5.25036827e-02f, -4.17388268e-02f, 2.66000032e-02f, 4.00273390e-02f, -5.10401800e-02f,
  -7.83361495e-03f, 6.55922145e-02f, 4.18736935e-02f, -4.79738489e-02f, 8.95341262e-02f, 1.03507049e-01f, -9.26723778e-02f, -6.13394380e-02f, -8.05758312e-02f, -5.13054468e-02f,
  -1.90084964e-01f, 2.80979753e-01f, -1.70111731e-01f, 1.95933785e-02f, 6.02687895e-02f, 4.56549153e-02f, -6.99301586e-02f, 1.04753032e-01f, 7.13054165e-02f, -4.45603542e-02f,
  5.82814105e-02f, -1.36465542e-02f, 6.58657402e-02f, -6.35202858e-04f, -1.43520400e-01f, -3.62927392e-02f, -5.40512614e-02f, -2.86923703e-02f, -4.12938818e-02f, -6.15627468e-02f,
  8.34283829e-02f, -2.24412739e-01f, -3.00518215e-01f, -8.71248394e-02f, -9.75383893e-02f, -2.29551151e-01f, -1.50581643e-01f, -1.42235577e-01f, -7.39432126e-02f, -2.46606112e-01f,
  -1.79735646e-01f, -2.36406013e-01f, 4.48298514e-01f, -1.47627383e-01f, -3.45344663e-01f, -3.11471373e-01f, -4.07147378e-01f, -2.10307613e-01f, -2.09433362e-01f, -1.64480910e-01f,
  -1.49586931e-01f, 4.45863828e-02f, 3.62678885e-01f, 1.76709428e-01f, 1.64515898e-01f, -1.67033523e-02f, 7.56612122e-02f, 3.58802885e-01f, 1.70965120e-01f, -3.53000820e-01f,
  -2.26868421e-01f, 1.16302771e-03f, 8.84836167e-02f, 7.33178779e-02f, -3.69063467e-02f, 6.80031553e-02f, 2.08601072e-01f, -2.72386745e-02f, -7.13559687e-02f, 1.49658740e-01f,
  2.94227123e-01f, -1.66236147e-01f, 6.17906041e-02f, -4.59921286e-02f, -4.76954579e-02f, -5.66151626e-02f, -4.68633138e-03f, 4.03503850e-02f, -5.62333427e-02f, -8.81236196e-02f,
  -1.03261933e-01f, -1.32848606e-01f, 2.39385124e-02f, 4.25180458e-02f, -1.37836143e-01f, -1.24360703e-01f, 3.62300389e-02f, 1.27900913e-01f, 8.26430917e-02f, -8.66860002e-02f,
  -7.68550038e-02f, -1.17711276e-01f, 3.11377905e-02f, 4.68739644e-02f, -9.56631638e-03f, 6.91981167e-02f, 7.17238560e-02f, 4.05195057e-02f, 2.49663694e-03f, 4.37476113e-02f,
  -7.19647929e-02f, 1.25176027e-01f, 7.34888911e-02f, 3.81068932e-03f, -8.51601288e-02f, -4.96244356e-02f, -6.29331246e-02f, 4.87869754e-02f, 6.23172708e-02f, 1.08716726e-01f,
  -7.63642341e-02f, -7.44252056e-02f, -4.22165580e-02f, -6.63959086e-02f, 7.69749060e-02f, 1.77692566e-02f, 3.08222175e-02f, 5.86835742e-02f, -2.93106195e-02f, -1.18087329e-01f,
  2.54156366e-02f, 1.69960111e-02f, 1.93074290e-02f, 9.93431434e-02f, -7.85195306e-02f, -2.17484240e-03f, -1.30445257e-01f, 1.45668034e-02f, -2.19399314e-02f, -1.00113057e-01f,
  1.55442342e-01f, 1.17449328e-01f, -5.32175936e-02f, 4.11892645e-02f, -8.85846987e-02f, 4.53779399e-02f, 6.50035441e-02f, -4.83826622e-02f, -2.93657947e-02f, -1.76675785e-02f,
  1.81416504e-03f, -1.03264384e-01f, 7.95714557e-02f, 3.65921035e-02f, -1.09060168e-01f, -1.23189263e-01f, -6.86166883e-02f, -1.73964258e-02f, 1.44640822e-02f, -1.22341834e-01f,
  1.80332437e-02f, -1.18676022e-01f, 7.10039884e-02f, 1.28918290e-01f, -7.36494735e-02f, 4.13576257e-04f, 1.33600309e-01f, 2.50279661e-02f, 1.06730625e-01f, -2.61061788e-02f,
  -1.11821070e-01f, 4.77464080e-01f, 3.19041044e-01f, -2.70293266e-01f, -3.30682471e-02f, 1.44417539e-01f, 2.70682335e-01f, 1.42620444e-01f, -1.18445382e-02f, 1.20013118e-01f,
  2.90866680e-02f, -2.85539836e-01f, -8.39352794e-03f, -1.05067909e-01f, 6.56475965e-03f, 2.34637037e-01f, 1.39981315e-01f, -1.31290704e-01f, -3.25694412e-01f, -2.30988771e-01f,
  -2.04155087e-01f, -2.20328793e-01f, -2.31542453e-01f, -7.33635500e-02f, 1.38979122e-01f, -1.15957260e-01f, 2.42064416e-01f, -2.15490982e-02f, 1.65115446e-01f, 1.40944675e-01f,
  -1.71053838e-02f, 3.27128023e-01f, -2.31616110e-01f, -2.04895601e-01f, -5.12460172e-02f, -8.83285850e-02f, 3.18357609e-02f, 3.06161828e-02f, 1.20493313e-02f, 7.41420910e-02f,
  -7.51058161e-02f, 2.28654817e-02f, 1.16653414e-02f, -7.46313110e-02f, -6.92351386e-02f, -3.76683846e-02f, 1.93465734e-03f, 2.24265922e-02f, -2.66914591e-02f, 1.28365591e-01f,
  -1.62276030e-01f, -9.95164737e-02f, 1.03929371e-01f, 1.48581266e-01f, 1.40449315e-01f, -1.93458751e-01f, 9.19820890e-02f, 1.16506750e-02f, 1.49789527e-01f, 9.62086469e-02f,
  -4.67364788e-02f, -1.34881902e-02f, -4.58661932e-03f, 9.76054743e-02f, -1.36645764e-01f, 5.94841223e-03f, 7.44608343e-02f, -4.83013988e-02f, -5.39450906e-02f, -6.34063631e-02f,
  5.52716777e-02f, -1.35079259e-02f, -7.38352910e-02f, 1.16785347e-01f, 3.49217206e-02f, -1.88820891e-03f, -8.42659574e-05f, 1.16411538e-03f, 4.84640524e-02f, 2.52264105e-02f,
  -3.57421525e-02f, 7.58653926e-03f, -1.29941506e-02f, -3.07407901e-02f, 1.21544831e-01f, 4.36132923e-02f, -5.67522720e-02f, -1.91169698e-02f, 1.38156340e-02f, 7.59564489e-02f,
  -2.90237516e-01f, -5.47783077e-02f, -5.18170856e-02f, -2.87267864e-02f, 7.72705209e-03f, -2.27345936e-02f, -3.18654291e-02f, -8.55979249e-02f, -1.37029972e-03f, -7.39804506e-02f,
  9.22816098e-02f, -4.60657999e-02f, 9.02766362e-02f, -7.44037330e-02f, -2.34968483e-01f, -6.70788437e-02f, -2.25556612e-01f, -1.78120837e-01f, -1.04402952e-01f, -1.73751358e-02f,
  -9.42240506e-02f, -2.56654322e-01f, -3.23100209e-01f, -1.10434055e-01f, -8.33830237e-02f, -2.61607289e-01f, -1.18174724e-01f, -1.19238712e-01f, -1.05994716e-01f, -1.86463580e-01f,
  3.82408142e-01f, 7.57423714e-02f, -1.06557503e-01f, 1.16795234e-01f, -2.10421339e-01f, -2.41386399e-01f, -2.21498445e-01f, -1.45725593e-01f, 9.87231955e-02f, 1.18722588e-01f,
  9.15321410e-02f, 2.38225579e-01f, 2.49201506e-01f, 1.31095305e-01f, 9.31436568e-02f, -6.33110926e-02f, -2.63919253e-02f, -4.39751819e-02f, -4.82477546e-02f, -7.28096738e-02f,
  3.51778567e-02f, -2.13209521e-02f, -5.87717816e-02f, -7.06076473e-02f, -4.64104451e-02f, 7.67631605e-02f, -5.48562035e-02f, -5.39806001e-02f, -1.03388038e-02f, 9.48565155e-02f,
  2.75191844e-01f, -1.46446154e-01f, 4.40203883e-02f, -1.13461301e-01f, -1.71421859e-02f, 3.70655991e-02f, -5.16862124e-02f, -1.04073443e-01f, -5.75984456e-02f, -6.42392188e-02f,
  -2.22229380e-02f, 5.01742586e-02f, -6.97722286e-02f, -3.00978515e-02f, -1.52044013e-01f, 1.83361415e-02f, -1.10742152e-01f, -1.46742299e-01f, -1.04390398e-01f, 7.62912557e-02f,
  5.91887869e-02f, -6.30891547e-02f, -8.71274620e-02f, -3.35425511e-02f, 5.89424325e-03f, -2.72803530e-02f, 2.22826432e-02f, -1.21873476e-01f, 2.91234534e-02f, -7.30721280e-02f,
  -7.72326672e-03f, 3.67588587e-02f, 1.35893404e-01f, 1.51840830e-02f, 9.28455498e-03f, 2.85673272e-02f, -1.18333381e-02f, -2.16523707e-02f, -1.50386356e-02f, 2.74326038e-02f,
  -9.12030786e-03f, 4.43997420e-02f, 9.91087314e-03f, 8.27671811e-02f, 1.09927341e-01f, 1.01669751e-01f, -5.66019351e-03f, -2.26784758e-02f, 1.23155471e-02f, 8.97020474e-02f,
  6.39652014e-02f, -4.94965212e-03f, 1.17800079e-01f, 5.10963611e-02f, 2.69663241e-02f, 3.78083661e-02f, 1.11718640e-01f, -4.83056111e-03f, 2.60473732e-02f, -6.33568913e-02f,
  2.20372558e-01f, -4.50690314e-02f, 1.12823002e-01f, -1.00443373e-02f, -1.38323784e-01f, -1.02478251e-01f, -1.40575869e-02f, -1.54531762e-01f, -1.63063943e-01f, -1.04232408e-01f,
  1.07053639e-02f, 9.56872925e-02f, -1.27484007e-02f, -1.33684710e-01f, 3.58214304e-02f, -4.11677994e-02f, 1.62444264e-02f, 6.91379979e-02f, 6.76018149e-02f, 5.81420474e-02f,
  -4.97177579e-02f, -4.12196741e-02f, 1.17508106e-01f, 2.58012265e-02f, 1.61147490e-02f, 2.90910900e-02f, 3.21440175e-02f, 8.08728188e-02f, 5.50065674e-02f, 1.32445484e-01f,
  -5.30073838e-03f, -1.00149885e-01f, 1.29984781e-01f, 1.66025281e-01f, -8.30105245e-02f, -3.08404505e-01f, -4.48470950e-01f, -2.37762809e-01f, 2.87097692e-02f, 3.37252356e-02f,
  -2.24270876e-02f, 1.36812449e-01f, 3.27663682e-02f, 2.72341222e-02f, -1.16345890e-01f, 1.18974736e-02f, 1.42335296e-01f, 1.31817713e-01f, -3.27721648e-02f, -7.96812624e-02f,
  -8.59949738e-04f, 4.51577939e-02f, 1.00566104e-01f, 1.27044737e-01f, 2.52489746e-01f, 3.70978005e-02f, 1.06590457e-01f, 1.00391515e-01f, 1.60955023e-02f, 4.32944536e-01f,
  2.28009641e-01f, -9.33351442e-02f, -1.37708247e-01f, 8.39910060e-02f, 8.45865998e-03f, 9.27774236e-02f, -2.19329330e-03f, 2.61295345e-02f, -6.98926449e-02f, 1.11672588e-01f,
  1.34103894e-01f, 4.97452281e-02f, -8.80465731e-02f, 9.26222056e-02f, 5.72007671e-02f, -4.73676212e-02f, 1.11390598e-01f, -3.59009020e-02f, -7.48881847e-02f, 2.56289355e-02f,
  9.14107636e-02f, 8.89512300e-02f, -1.21115267e-01f, -1.95009649e-01f, -8.50993320e-02f, -2.89485008e-02f, -1.75654247e-01f, 9.12709720e-03f, -2.44203821e-01f, 5.22532277e-02f,
  7.88421705e-02f, -8.17815140e-02f, 2.14803051e-02f, 1.58873890e-02f, 1.19592771e-02f, 5.49050868e-02f, 7.57074729e-02f, 2.43759770e-02f, 9.24638659e-02f, 1.38677657e-01f,
  -3.22150532e-03f, -5.36940433e-03f, -2.36862097e-02f, -5.32596409e-02f, 1.28067642e-01f, 2.80036740e-02f, 1.04338594e-01f, -2.63171606e-02f, 4.00009789e-02f, 8.33495185e-02f,
  1.89911649e-02f, -4.13771793e-02f, 1.19332917e-01f, 6.27921820e-02f, 4.36078310e-02f, 2.01135967e-02f, 9.45735872e-02f, -1.67169031e-02f, -3.14870141e-02f, -6.20047785e-02f,
  -1.23389184e-01f, -1.56798109e-01f, 1.40061438e-01f, 7.01241344e-02f, 7.35679418e-02f, 3.00945658e-02f, 3.42835337e-02f, -3.89138311e-02f, 1.68209299e-02f, 1.02613186e-02f,
  -8.75172317e-02f, -3.43117453e-02f, -6.70332229e-03f, 3.96568142e-02f, -1.08782221e-02f, 2.05219425e-02f, 2.10701168e-01f, 1.61230601e-02f, -9.32529494e-02f, 1.35252267e-01f,
  6.08492307e-02f, -1.74819633e-01f, -2.10829318e-01f, -2.27214277e-01f, -5.91877624e-02f, -2.25104570e-01f, -1.82987452e-01f, -1.26739219e-01f, -3.62588614e-01f, -3.43561679e-01f,
  -4.89748985e-01f, 1.47061553e-02f, 3.60097855e-01f, -4.51273650e-01f, -3.58518422e-01f, -7.63658956e-02f, 1.27206631e-02f, -1.96907684e-01f, -2.92495877e-01f, -9.40956455e-03f,
  -2.83396661e-01f, -1.88493967e-01f, -1.50004491e-01f, 6.70141801e-02f, 1.29776821e-01f, 2.76804984e-01f, 2.34033480e-01f, 1.17039472e-01f, -1.69149637e-02f, -7.45409876e-02f,
  -6.68656677e-02f, -1.40525088e-01f, -7.38480687e-02f, 9.44092032e-03f, -6.31469637e-02f, -1.96375251e-01f, 1.42769381e-01f, -1.15125552e-02f, -3.94229628e-02f, 5.59864379e-02f,
  2.50316918e-01f, -2.15763599e-01f, -6.11789525e-02f, -1.01146452e-01f, -3.78266573e-02f, 5.89854531e-02f, -5.64571433e-02f, -1.23687558e-01f, -1.67738989e-01f, -6.64206967e-02f,
  -1.31003782e-01f, -1.06265046e-01f, -1.33904457e-01f, 1.77885704e-02f, -2.83151790e-02f, -6.35221303e-02f, -5.42408004e-02f, 7.23814890e-02f, 8.55900794e-02f, 2.13122703e-02f,
  4.08253223e-02f, -8.10918063e-02f, -8.57618451e-02f, 5.72874583e-02f, -4.10399288e-02f, -4.19255346e-02f, -1.23193860e-01f, -9.98934507e-02f, -4.13771532e-02f, 1.64911710e-02f,
  1.25343889e-01f, 1.83647163e-02f, -8.75393823e-02f, -1.11828342e-01f, -8.07478800e-02f, -9.91130546e-02f, -1.32941855e-02f, -1.05657019e-01f, 1.28723532e-02f, -9.17746052e-02f,
  -6.05172925e-02f, -5.71290813e-02f, -7.40303323e-02f, -1.41983880e-02f, -4.80173789e-02f, 1.19174784e-02f, -4.87123840e-02f, -5.05992137e-02f, 2.21248879e-03f, -1.63225308e-01f,
  -1.22520305e-01f, -5.08495197e-02f, -4.78260331e-02f, -2.27105692e-02f, -6.42087087e-02f, -5.73188998e-02f, 4.13874201e-02f, 2.82505378e-02f, 2.96235140e-02f, -4.25553508e-02f,
  2.11578212e-03f, -1.29064471e-01f, -3.65797766e-02f, -5.27788773e-02f, -1.00818537e-02f, 1.32603467e-01f, -5.73044866e-02f, -6.78586066e-02f, -8.36568251e-02f, 7.67222568e-02f,
  4.60692570e-02f, 1.27490526e-02f, 9.95135009e-02f, 3.70705687e-02f, -2.50179265e-02f, -6.57727651e-05f, 7.66389295e-02f, -4.02543135e-02f, 4.34641317e-02f, 8.14339444e-02f,
  1.12170361e-01f, -2.70919148e-02f, 2.83037350e-02f, -1.03167184e-02f, 1.07351445e-01f, -8.55478793e-02f, -8.51416402e-03f, 3.19429152e-02f, 6.17535636e-02f, 1.05143405e-01f,
  7.46246278e-02f, -5.95990196e-02f, -5.79347730e-01f, 2.46736169e-01f, -1.19201958e-01f, -1.12382323e-01f, 8.77572149e-02f, 3.08211833e-01f, 2.86485910e-01f, 2.06464380e-02f,
  -1.04745112e-01f, -9.25066620e-02f, -1.66100964e-01f, -2.08356246e-01f, -2.09840968e-01f, -1.57428026e-01f, -3.39847982e-01f, -2.91627616e-01f, -7.29068965e-02f, 3.98690790e-01f,
  3.13005596e-01f, 2.40816787e-01f, 1.51852041e-01f, 1.12163574e-01f, 9.57672074e-02f, 4.39152420e-02f, -6.48111627e-02f, -7.54930004e-02f, -2.07619578e-01f, -3.59868467e-01f,
  -1.29576474e-01f, -4.42678072e-02f, -9.15086120e-02f, -7.76063576e-02f, -1.15415826e-01f, 8.79403874e-02f, 6.96190968e-02f, -1.28055543e-01f, 9.86424927e-03f, 5.32738045e-02f,
  -7.88675100e-02f, 6.00928068e-02f, -1.49467150e-02f, 9.38628614e-02f, 1.38759434e-01f, 8.92308056e-02f, -5.83327515e-03f, -1.75196260e-01f, -1.77186519e-01f, -5.48497662e-02f,
  -4.73173447e-02f, -2.88846225e-01f, -2.50266343e-01f, -1.13502316e-01f, -4.70924638e-02f, -1.24069721e-01f, -1.06295776e-02f, -4.65153754e-02f, -2.65809208e-01f, 2.78552473e-01f,
  6.41187746e-03f, -6.13368787e-02f, 1.46352962e-01f, 7.15867281e-02f, 1.68528706e-01f, -7.87200630e-02f, -7.84047297e-04f, 4.31541800e-02f, 9.73229706e-02f, 8.19638520e-02f,
  -4.70384769e-03f, -1.80416424e-02f, 1.45687461e-01f, 1.61231995e-01f, 9.63486284e-02f, -2.39855405e-02f, -4.05513346e-02f, 1.66921213e-01f, 5.95265813e-03f, 1.55085385e-01f,
  6.78073987e-02f, 3.78037319e-02f, 4.71657664e-02f, 9.95271951e-02f, -8.16080421e-02f, -2.00982131e-02f, 1.08666427e-01f, 8.60942602e-02f, 8.18773955e-02f, 5.56596369e-03f,
  3.82931143e-01f, -2.07310379e-01f, 2.71428134e-02f, -4.17631539e-03f, -5.31264860e-03f, 5.45336455e-02f, -3.30809946e-03f, -2.40029022e-02f, -9.16821659e-02f, 1.89179286e-01f,
  1.11765921e-01f, 9.73343924e-02f, 1.60547551e-02f, 8.88001770e-02f, 9.09846723e-02f, 6.83575422e-02f, -3.42996642e-02f, -1.06450155e-01f, -1.16614737e-02f, 8.06354508e-02f,
  1.17985599e-01f, 2.37338673e-02f, 1.70128401e-02f, 4.93668318e-02f, 1.14938535e-01f, -2.56940108e-02f, 1.55796826e-01f, 2.49328971e-01f, -1.21381603e-01f, 4.24500227e-01f,
  -4.01412189e-01f, -2.82809347e-01f, 2.32765839e-01f, 2.66096741e-01f, 3.50101173e-01f, 3.88203502e-01f, 3.20511729e-01f, 2.29822844e-01f, 1.46289766e-01f, 9.66186300e-02f,
  -4.28660102e-02f, -1.20283492e-01f, -1.56667258e-03f, 2.48078699e-03f, -8.95966776e-03f, 3.21353734e-01f, 2.68505037e-01f, 2.14514941e-01f, 1.52820677e-01f, 1.75810695e-01f,
  2.19640091e-01f, 8.91678855e-02f, -6.67393729e-02f, 2.03228090e-02f, 1.98845670e-01f, 2.21777350e-01f, 1.95633739e-01f, 1.38496846e-01f, 1.42259136e-01f, 3.31581801e-01f,
  -1.43171936e-01f, -1.99386686e-01f, 3.53686661e-02f, -1.36049435e-01f, -1.73728928e-01f, -6.52089790e-02f, -8.61696526e-02f, -3.77405845e-02f, 1.84689239e-02f, 9.14649442e-02f,
  -6.90007433e-02f, -1.13876298e-01f, -8.68277922e-02f, -5.68739399e-02f, -1.03721302e-02f, -8.01702142e-02f, -4.90507185e-02f, 8.85870829e-02f, -2.05472438e-03f, -3.89456027e-03f,
  -4.20094170e-02f, 9.57061127e-02f, 2.19607055e-01f, 9.28436145e-02f, -6.12973236e-02f, 3.22325714e-02f, -1.62348926e-01f, -1.97883584e-02f, 8.64593014e-02f, 6.25324324e-02f,
  1.96733147e-01f, 1.10678105e-02f, -3.54643948e-02f, 5.77289239e-02f, -4.26730700e-02f, 3.04020662e-02f, 1.35098204e-01f, 4.47266623e-02f, 4.60395813e-02f, 4.68514971e-02f,
  -3.23936604e-02f, 2.01063473e-02f, -2.65160650e-02f, 1.57133192e-02f, -4.50080968e-02f, 8.10177624e-02f, 8.63438845e-02f, -7.79799968e-02f, -1.13948666e-01f, -1.16336204e-01f,
  -6.32191636e-03f, 5.72763570e-02f, -4.73413169e-02f, 4.56628948e-02f, -2.18743440e-02f, 7.11509213e-02f, 2.18287893e-02f, -5.00601940e-02f, 5.48561513e-02f, 1.73510779e-02f,
  1.20757557e-01f, -2.01306656e-01f, -5.12955226e-02f, -1.11730564e-02f, -2.08626930e-02f, -1.56605288e-01f, -8.95538479e-02f, -3.42255533e-02f, -6.97516650e-02f, 9.45913419e-02f,
  -4.45849672e-02f, -1.50588796e-01f, -1.77247703e-01f, 2.47527435e-02f, -4.62792963e-02f, 3.08706798e-02f, -9.06496346e-02f, 1.12100355e-01f, 1.23872548e-01f, 7.26248696e-02f,
  -4.57235761e-02f, 2.42443427e-01f, 1.31865248e-01f, 7.49155805e-02f, -2.88525578e-02f, 5.19017987e-02f, 4.50094715e-02f, -4.75743636e-02f, 1.26291946e-01f, 6.29243776e-02f,
  -3.06327641e-01f, 2.20674291e-01f, 3.41544449e-01f, -2.35937923e-01f, 4.21613127e-01f, 4.62264121e-01f, 6.06459200e-01f, 2.34837055e-01f, -1.07735373e-01f, 4.77192998e-02f,
  -3.99988070e-02f, -3.87585193e-01f, -3.76737595e-01f, -2.02723190e-01f, 3.27685624e-02f, 4.27969486e-01f, 1.69007838e-01f, -3.04690935e-02f, -4.43627276e-02f, 2.32103437e-01f,
  1.25023155e-02f, -1.66289687e-01f, -2.20348939e-01f, -2.43311539e-01f, -2.34870404e-01f, -2.25420982e-01f, 5.04884943e-02f, 1.25198811e-01f, 2.14807466e-01f, -1.51660874e-01f,
  -1.23053968e-01f, 1.01106219e-01f, 4.49455678e-02f, -1.81855187e-01f, -1.91655681e-02f, -5.85670955e-02f, 1.58699024e-02f, -1.49217188e-01f, 2.00521816e-02f, 6.97903112e-02f,
  -4.95514348e-02f, -7.27503896e-02f, -8.67872834e-02f, -2.43514236e-02f, -1.41756749e-03f, 1.30529076e-01f, -8.20550695e-02f, -1.44546315e-01f, -2.36576587e-01f, -6.40575141e-02f,
  -1.60745427e-01f, 8.24119970e-02f, 2.11360738e-01f, 1.04108214e-01f, -8.11317042e-02f, -5.91087714e-02f, 2.92927083e-02f, -6.75113276e-02f, -4.53425460e-02f, -2.12008700e-01f,
  -6.75596371e-02f, 1.55296987e-02f, 1.05089739e-01f, 2.91222171e-03f, -8.58782902e-02f, 4.44235876e-02f, -5.76593950e-02f, -4.43580411e-02f, 4.16452847e-02f, -1.06607871e-02f,
  6.34571984e-02f, -2.71004569e-02f, -7.39566833e-02f, -1.23144649e-02f, -1.22133806e-01f, 7.08238333e-02f, 9.26976204e-02f, -8.19691196e-02f, 5.22755831e-02f, 4.32492085e-02f,
  -8.23600870e-03f, -2.75803171e-02f, -9.36738178e-02f, -8.86825398e-02f, 8.77471119e-02f, 3.78208756e-02f, -4.86493558e-02f, -9.07416567e-02f, -4.09775600e-02f, 1.86586022e-01f,
  -2.85496861e-01f, 2.89388955e-01f, -1.59501866e-01f, -3.14694755e-02f, -7.12132687e-03f, -1.54341641e-03f, -7.24863559e-02f, 3.18701863e-02f, 2.16616653e-02f, -3.86349484e-02f,
  3.85321304e-02f, 8.75415001e-03f, -9.29272845e-02f, 4.05658484e-02f, 8.94154459e-02f, 5.23158684e-02f, 1.49852922e-02f, -3.48598808e-02f, 8.39036598e-04f, -1.62729360e-02f,
  -5.75599037e-02f, 1.67015389e-01f, -1.16107650e-02f, -3.26994807e-02f, 4.97475751e-02f, -8.88690352e-02f, -4.11729738e-02f, 6.86327070e-02f, -8.61766748e-03f, -1.14873588e-01f,
  3.88466030e-01f, -2.95043346e-02f, 4.15778942e-02f, 2.10596740e-01f, 8.02975520e-03f, -8.21797401e-02f, -7.35432878e-02f, -4.21235561e-02f, 1.65870264e-01f, 5.70548065e-02f,
  -9.53283682e-02f, -2.46571764e-01f, 2.10290868e-02f, -2.27315933e-01f, -1.32947102e-01f, 6.99276477e-02f, 1.27583444e-01f, -1.23369463e-01f, -2.15153366e-01f, -2.77612716e-01f,
  -1.97440609e-01f, -1.58391699e-01f, -4.83467355e-02f, -1.70646831e-02f, -2.18277201e-02f, -4.67685563e-03f, 9.92533043e-02f, 2.15517301e-02f, -1.10305533e-01f, 2.22911593e-03f,
  -2.65122563e-01f, 6.28117397e-02f, -8.91509876e-02f, -1.14209257e-01f, -1.08408108e-01f, -8.01788867e-02f, -1.92912608e-01f, 2.98321538e-04f, 9.02670920e-02f, -3.30851488e-02f,
  -9.86671541e-04f, -8.47034752e-02f, -7.14085996e-02f, -1.29160956e-01f, 3.50647159e-02f, -7.40035251e-02f, 1.00800924e-01f, 7.74784535e-02f, -4.64691557e-02f, -1.59753367e-01f,
  -1.32618919e-01f, -1.03618629e-01f, 1.24014266e-01f, 1.88545566e-02f, -1.53908525e-02f, 1.39143700e-02f, -3.21507603e-02f, 5.61780408e-02f, -1.37782516e-02f, 1.99788556e-01f,
  -2.58446068e-01f, -5.78628741e-02f, -1.21519707e-01f, -7.08995610e-02f, 1.79281123e-02f, -4.75038774e-02f, -5.43753207e-02f, 2.94114705e-02f, -1.25304595e-01f, -1.06783874e-01f,
  -8.49611536e-02f, -1.91234842e-01f, -3.88112552e-02f, -1.04555869e-02f, -6.70597330e-02f, -9.13350843e-03f, -5.92923574e-02f, -5.88470027e-02f, -7.80394673e-02f, -8.95798057e-02f,
  -5.63025661e-02f, -1.60795432e-02f, -1.37242660e-01f, -1.93158329e-01f, -5.09751029e-02f, -1.18823256e-02f, -1.70607775e-01f, -1.78531110e-01f, 5.96654601e-03f, -3.91316563e-02f,
  -1.63577110e-01f, -2.59310812e-01f, -1.17471993e-01f, -1.14049211e-01f, -1.86700020e-02f, -8.25879648e-02f, -1.94921285e-01f, -8.41636956e-02f, -4.17198911e-02f, -3.44785638e-02f,
  -1.33996055e-01f, -1.47785828e-01f, 7.34554883e-03f, -5.54434396e-02f, -6.45627230e-02f, -4.15507779e-02f, -4.90240678e-02f, -1.61754414e-02f, 2.88225189e-02f, 1.29197156e-02f,
  3.21179330e-02f, 7.30585456e-02f, 2.21566066e-01f, 7.35451430e-02f, 8.49984959e-02f, 1.19032696e-01f, -3.89299989e-02f, 2.39317510e-02f, 1.42494887e-01f, 2.53510535e-01f,
  -1.40159309e-01f, 2.79435277e-01f, -1.52717188e-01f, 2.93013066e-01f, 1.06798396e-01f, -7.43493885e-02f, 4.70615700e-02f, 1.64230108e-01f, 1.33064017e-01f, 2.16250733e-01f,
  1.62925661e-01f, 2.71147370e-01f, 2.75850952e-01f, 5.13236746e-02f, 1.02922507e-01f, 5.65379672e-02f, 1.52981907e-01f, -8.40091854e-02f, -2.11031184e-01f, 1.06423125e-02f,
  9.32060406e-02f, -1.38951689e-02f, -6.08787201e-02f, -2.07668059e-02f, 3.03515196e-01f, 2.83443779e-01f, 1.41079307e-01f, 2.44933590e-01f, 1.64110005e-01f, 3.38832170e-01f,
  -7.87909999e-02f, 5.81097463e-03f, -9.53152925e-02f, -1.54367343e-01f, -6.47044703e-02f, -6.78314269e-02f, -4.02998142e-02f, -8.89757574e-02f, -3.95614356e-02f, -1.59562752e-01f,
  -9.02044401e-02f, -2.25810707e-02f, -3.41146067e-02f, -1.37808964e-01f, -1.95073470e-01f, -1.93685204e-01f, -2.95966491e-02f, 1.27815992e-01f, 1.55764595e-01f, -4.01496701e-03f,
  3.17358151e-02f, -1.32223085e-01f, -3.42369825e-02f, -1.46665081e-01f, -3.84477824e-02f, -1.18223958e-01f, -1.37439519e-02f, 3.22843120e-02f, -6.89952746e-02f, 3.85911092e-02f,
  -2.47020006e-01f, -1.42098516e-01f, -5.70527539e-02f, -1.15050949e-01f, -1.40501723e-01f, -6.06375448e-02f, -8.34912434e-02f, -7.48759732e-02f, -1.44909084e-01f, -9.82954055e-02f,
  3.95464189e-02f, 3.87115888e-02f, -9.37855616e-02f, -1.00758381e-01f, -1.15436144e-01f, -7.99644087e-03f, -5.33018680e-03f, -1.56497926e-01f, -2.41014361e-01f, -4.75831982e-03f,
  8.93381760e-02f, 2.35189442e-02f, -4.22307588e-02f, -2.25008950e-02f, 4.36869822e-02f, -1.71028152e-01f, -1.13926111e-02f, -1.38941184e-01f, -7.19100833e-02f, 4.34874147e-02f,
  3.23444903e-01f, -8.94528180e-02f, 9.81445163e-02f, 2.25184515e-01f, 4.36326191e-02f, 4.74153534e-02f, 2.19518960e-01f, 5.29129505e-02f, 7.65317380e-02f, 4.10205405e-03f,
  -2.70801000e-02f, -1.06882058e-01f, -7.52908885e-02f, 1.85612943e-02f, -1.70104116e-01f, -1.66997597e-01f, 4.26600017e-02f, 2.68921345e-01f, 1.27996713e-01f, 1.03262462e-01f,
  -3.91536020e-02f, 2.56060604e-02f, -2.59531178e-02f, 3.95260155e-02f, 4.21527140e-02f, -9.57920477e-02f, -1.15716234e-01f, -1.32310949e-02f, -1.30044371e-01f, -1.83366522e-01f,
  2.06043318e-01f, -6.43958628e-01f, 1.19010635e-01f, 2.02821016e-01f, 2.99229324e-01f, 1.69857845e-01f, -1.01810105e-01f, 1.10116169e-01f, 2.58979172e-01f, -2.39486530e-01f,
  -3.96074891e-01f, -1.98211804e-01f, -1.72678158e-01f, -2.15570793e-01f, -2.80916244e-01f, -2.23670110e-01f, 4.68332227e-03f, 1.76637024e-01f, 2.59505659e-01f, 5.93601987e-02f,
  -1.11242682e-01f, -3.55428234e-02f, 1.10817738e-02f, 5.55905737e-02f, -2.22748537e-02f, 6.97182072e-03f, -1.48047218e-02f, -5.13538383e-02f, -2.10608840e-01f, -2.22775772e-01f,
  3.10123451e-02f, -1.02495693e-03f, 9.22342017e-02f, -1.18969671e-01f, -1.22909054e-01f, -2.16380842e-02f, -8.21018890e-02f, 5.08913584e-02f, -1.12129725e-03f, -3.45410369e-02f,
  7.81854335e-03f, 3.47937010e-02f, 6.18315488e-02f, 4.67157550e-02f, 9.19805467e-02f, 7.59865344e-02f, -6.54025748e-02f, 1.13620907e-02f, -1.83662530e-02f, -1.79616615e-01f,
  -2.87967563e-01f, -8.75304565e-02f, 1.16861291e-01f, 8.76341239e-02f, -3.75460573e-02f, 6.05397974e-04f, -8.78988355e-02f, 7.11920112e-02f, 1.49401292e-01f, 7.55013898e-02f,
  3.35939378e-02f, 2.79928520e-02f, 1.21747851e-01f, 3.59494723e-02f, -4.01700847e-03f, 8.53159726e-02f, 1.20761864e-01f, -9.32544023e-02f, 4.54197116e-02f, -1.02669172e-01f,
  -1.20016471e-01f, -2.68161073e-02f, -5.64936288e-02f, -5.43062612e-02f, -9.28205028e-02f, 5.06723039e-02f, -5.52951079e-03f, -1.33978546e-01f, -1.69306993e-02f, -1.69696640e-02f,
  -1.06264941e-01f, 2.13273689e-02f, 9.22296941e-02f, -4.86499667e-02f, -9.19736773e-02f, 5.73394969e-02f, 4.41935137e-02f, -4.56431806e-02f, 7.61306137e-02f, 1.10189617e-02f,
  -2.94521265e-02f, 3.82312685e-02f, -1.70778297e-02f, -3.83758405e-03f, 5.32235056e-02f, -8.02348703e-02f, -4.33180034e-02f, 1.13635315e-02f, 2.89918613e-02f, 1.68398656e-02f,
  2.77500553e-03f, -9.33376476e-02f, -7.49088218e-03f, -9.15846303e-02f, 1.61450088e-01f, 1.18705153e-01f, -2.15669096e-01f, -2.07504351e-02f, 1.01975696e-02f, -9.94751677e-02f,
  -1.12432070e-01f, 3.77413779e-02f, 7.28571862e-02f, 1.23504475e-01f, 6.00874983e-02f, 1.61166325e-01f, 2.39636656e-02f, 7.40639120e-02f, 1.34834439e-01f, 6.88802160e-04f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  1.99337661e-01f, 2.46053413e-01f, 4.96833116e-01f, 1.15010925e-01f, 5.04650772e-01f, 3.71114463e-01f, 7.78814629e-02f, 5.78078665e-02f, 5.28475046e-01f, 2.68982828e-01f,
  1.85747296e-01f, 2.82843620e-01f, 3.28262985e-01f, 5.37757635e-01f, 2.07342327e-01f, 2.08016470e-01f, 1.56254828e-01f, 3.53570163e-01f, 1.59661278e-01f, 2.06618026e-01f,
  1.53188288e-01f, 4.36930031e-01f, 2.17990711e-01f, 3.50603461e-01f, 3.68847817e-01f, 2.72124857e-01f, 1.92054331e-01f, 3.14086974e-01f, 2.57203668e-01f, 5.26747555e-02f,
  -9.59312394e-02f, 3.22420269e-01f, 4.39453870e-01f, 2.46766433e-01f, 3.10174614e-01f, 2.36671686e-01f, 7.91774616e-02f, 2.48496398e-01f, 3.06977689e-01f, 1.05073154e-01f,
  2.19110742e-01f, 2.96575069e-01f, 1.13255575e-01f, 2.93785334e-01f, 6.19891360e-02f, 2.98665136e-01f, 2.73547351e-01f, 1.49428964e-01f, 2.91501850e-01f, 1.10352091e-01f,
  1.39115244e-01f, 2.79005557e-01f, 7.25422502e-02f, 8.69862288e-02f, 1.54638916e-01f, 4.35438424e-01f, 2.26643458e-01f, 3.31591368e-01f, 4.51852053e-01f, 3.71988416e-01f,
  4.50585127e-01f, 7.86438808e-02f, 2.57112831e-01f, 2.70631015e-01f, 2.92360932e-01f, 2.71879852e-01f, 2.92952210e-01f, 8.56644660e-02f, 1.61851764e-01f, 1.72512695e-01f,
  7.64565589e-03f, 4.17845070e-01f, 4.58583713e-01f, 2.11298928e-01f, 2.37061113e-01f, 2.42755353e-01f, 3.05247277e-01f, 3.08928847e-01f, 2.95386165e-01f, 2.53514081e-01f,
  4.26383168e-01f, 6.34310544e-01f, 3.63468051e-01f, 2.63933986e-01f, 2.11855471e-01f, 1.90994278e-01f, 3.23264837e-01f, 3.24976832e-01f, 3.77376378e-01f, 4.06445771e-01f,
  3.74961376e-01f, 3.31063896e-01f, 3.56753767e-01f, 4.09427822e-01f, 2.68764794e-01f, 3.38647008e-01f, 2.80157536e-01f, 4.21590120e-01f, 2.53496706e-01f, 1.37168616e-01f,
  4.71904159e-01f, 2.33851150e-01f, 2.62709588e-01f, 4.18530822e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.29257292e-01f, -1.97564483e-01f, -2.14779496e-01f, -3.13655511e-02f, -5.46980947e-02f, 4.05908301e-02f, -1.03636906e-01f, -1.83138996e-02f, -1.77787691e-01f, -6.43610433e-02f,
  -1.93865284e-01f, -1.13300681e-01f, 2.35577095e-02f, -1.11595506e-03f, 8.43873248e-03f, 1.32944435e-01f, 1.24740237e-02f, -2.40636796e-01f, 1.34892017e-01f, -1.05893672e-01f,
  -1.86351135e-01f, -1.80970747e-02f, -1.52131885e-01f, 4.72063236e-02f, -3.05472463e-02f, -1.69022262e-01f, -4.43540931e-01f, -2.03398556e-01f, -3.27986687e-01f, -5.63177466e-01f,
  3.81087095e-01f, 4.83905852e-01f, -1.53595418e-01f, 3.48582119e-01f, 1.58705655e-02f, -2.77410418e-01f, -2.89633900e-01f, 2.32556298e-01f, 3.22047323e-01f, -1.88379854e-01f,
  -1.44616842e-01f, 4.96668480e-02f, 2.16851115e-01f, 5.32572530e-02f, 5.26719093e-02f, 1.04370512e-01f, 2.53054430e-03f, -4.07373458e-01f, -2.08073869e-01f, -4.62053746e-01f,
  -5.71807064e-02f, 2.31816873e-01f, -2.60202229e-01f, -3.58778611e-02f, 1.44669265e-01f, -2.23974645e-01f, 1.16305701e-01f, 1.01679660e-01f, -1.13696605e-01f, -4.71243337e-02f,
  3.01624946e-02f, -1.14282601e-01f, -7.56879985e-01f, -2.24674772e-02f, -9.87060443e-02f, -1.60195693e-01f, -1.13042116e-01f, 1.02827000e-02f, -1.55100286e-01f, -1.12044320e-01f,
  4.47748601e-01f, -1.53734311e-01f, 4.17587787e-01f, -8.00452158e-02f, 2.67976522e-01f, 3.23665917e-01f, -6.73188269e-02f, 2.86777049e-01f, 6.38521835e-02f, -2.08784848e-01f,
  -1.42646477e-01f, -5.82384430e-02f, 2.01682508e-01f, 1.71818701e-03f, -2.44327694e-01f, 1.66563329e-03f, -4.10879284e-01f, 3.55114937e-02f, 3.41481864e-01f, 2.84377396e-01f,
  2.01691240e-01f, 3.41063827e-01f, 1.90358147e-01f, -4.41976249e-01f, -1.55415416e-01f, -1.62183553e-01f, 1.24900468e-01f, -1.94147341e-02f, 1.92682892e-01f, -1.71061121e-02f,
  -3.18672955e-02f, 2.63668984e-01f, -5.96783347e-02f, -3.46961617e-01f, 6.94580972e-02f, -5.45204818e-01f, -3.57289881e-01f, -1.69812664e-01f, -6.32349327e-02f, 3.79029721e-01f,
  -1.29915297e-01f, -3.01290751e-01f, -1.15619600e-01f, -2.77224571e-01f, -2.34099343e-01f, -7.97015727e-02f, -5.44403732e-01f, -4.49117213e-01f, -3.99620175e-01f, -2.78470457e-01f,
  -1.86086625e-01f, -3.12933475e-01f, 4.06958461e-01f, -3.49783331e-01f, -1.01490812e-02f, -3.13658446e-01f, -1.37823448e-01f, 1.58648297e-01f, -1.87511623e-01f, -1.33993506e-01f,
  -7.35630766e-02f, 1.15227088e-01f, 4.81284782e-02f, -9.91426632e-02f, 6.67069852e-02f, 3.18786688e-02f, 5.44911139e-02f, 4.72052507e-02f, -3.00759450e-02f, -5.47656119e-02f,
  -2.19569623e-01f, -1.58673242e-01f, 4.67104986e-02f, -1.69237435e-01f, -2.99012065e-02f, 1.27937077e-02f, -6.08036341e-03f, 8.03603977e-02f, -3.13087776e-02f, 3.55805159e-02f,
  -1.49987832e-01f, 3.46784264e-01f, -1.82425007e-01f, 1.53109401e-01f, -9.79443789e-02f, 8.40211362e-02f, 2.95356750e-01f, 1.01226941e-01f, -1.09034017e-01f, 4.07486916e-01f,
  -5.42079926e-01f, 6.31698966e-02f, 3.44896495e-01f, -4.28793758e-01f, 2.59674162e-01f, 6.80940092e-01f, -4.63892400e-01f, 3.17665547e-01f, -5.74156828e-02f, -3.81633490e-01f,
  2.06521496e-01f, 6.57355040e-02f, 9.36216190e-02f, 5.35861492e-01f, 1.13306455e-01f, 1.80634245e-01f, 8.56947824e-02f, 6.93257451e-02f, -2.33059481e-01f, 1.37253210e-01f,
  1.01356292e-02f, -1.26170032e-02f, -7.30025694e-02f, -2.51171649e-01f, 2.93610603e-01f, 2.86458611e-01f, 6.59596846e-02f, 3.20675075e-01f, -5.14834583e-01f, -1.26129910e-01f,
  -3.82203341e-01f, 1.43290982e-01f, -5.10288715e-01f, -1.08282492e-01f, -3.84432644e-01f, 1.81013882e-01f, -4.35165241e-02f, -8.34307373e-02f, 2.21227765e-01f, 2.87637979e-01f,
  -2.75431365e-01f, -1.94144145e-01f, -4.31417316e-01f, -2.58536935e-02f, 3.41995895e-01f, -1.72407269e-01f, 4.02062610e-02f, -9.92494375e-02f, 6.05203025e-02f, -8.30407798e-01f,
  -6.93147480e-01f, 1.43786520e-01f, -5.17955601e-01f, -1.93456426e-01f, -2.71191180e-01f, 8.73396844e-02f, 6.50598526e-01f, -1.25693157e-01f, 1.25952795e-01f, 3.83521318e-01f,
  1.30742326e-01f, -4.08534765e-01f, 1.05427913e-01f, 2.68493563e-01f, -5.06305158e-01f, -1.43396512e-01f, -4.31815684e-01f, -5.72300367e-02f, 6.49446920e-02f, -5.13935089e-01f,
  -1.79550499e-01f, -1.88205704e-01f, -5.67949295e-01f, -8.74313593e-01f, 1.91848323e-01f, -4.17692721e-01f, 3.83069776e-02f, 3.42944741e-01f, 7.63661927e-03f, -4.58897144e-01f,
  1.80673853e-01f, -2.25197911e-01f, -3.03101446e-02f, 2.02818841e-01f, -1.83139354e-01f, 1.22876532e-01f, -2.66195029e-01f, 2.33881310e-01f, -4.72693861e-01f, -2.85136312e-01f,
  -3.72979432e-01f, -8.86424929e-02f, -5.55625260e-01f, 3.01655196e-02f, -5.16326632e-03f, 5.35997737e-04f, 1.93284944e-01f, 2.79363453e-01f, 1.20653935e-01f, 4.69326675e-02f,
  -6.30492941e-02f, -3.29071805e-02f, 9.23718885e-02f, 4.06397842e-02f, 9.43042338e-02f, 4.20078188e-02f, 1.39795572e-01f, -2.62632873e-02f, 2.42973119e-01f, -2.24867925e-01f,
  5.54772094e-02f, 7.89295807e-02f, 2.90254384e-01f, 1.87602118e-02f, -1.07896380e-01f, -5.94480671e-02f, -8.49002674e-02f, 7.14216381e-02f, -3.57034095e-02f, 4.33982283e-01f,
  2.78871246e-02f, -1.70991793e-01f, -7.79830813e-02f, -3.86324599e-02f, 5.54626763e-01f, -2.49866247e-01f, -2.51219362e-01f, -1.12932059e-03f, 2.35551789e-01f, 7.39044230e-03f,
  -3.27904105e-01f, -1.44995898e-01f, -1.13478944e-01f, 1.78960964e-01f, -7.41642192e-02f, -3.41251642e-02f, -3.58392894e-01f, -2.70228893e-01f, -3.76151800e-01f, -2.99009457e-02f,
  1.38525441e-02f, 2.84670949e-01f, -1.56292126e-01f, 1.39021829e-01f, -2.53865331e-01f, -2.26401910e-01f, -1.26221806e-01f, -2.75474519e-01f, -1.99666470e-01f, -1.59772247e-01f,
  -4.93771285e-02f, -4.38330531e-01f, 9.16683525e-02f, 3.69579822e-01f, -2.75506496e-01f, -2.82495767e-01f, 1.04438961e-01f, -2.33237119e-03f, 1.10617869e-01f, -2.42113605e-01f,
  -2.96376348e-01f, -4.38378379e-03f, -1.42821014e-01f, -3.04624587e-02f, 6.04905151e-02f, -2.89066106e-01f, -2.67060190e-01f, -2.37408355e-01f, 4.23658818e-01f, 3.70891728e-02f,
  -7.83473253e-02f, -3.13368648e-01f, -4.37441409e-01f, -9.84540880e-02f, 1.44635618e-01f, -1.06080398e-01f, 2.99919963e-01f, 6.11519933e-01f, 3.83446336e-01f, 1.04763322e-01f,
  -2.72959113e-01f, 1.96569100e-01f, 7.43130827e-03f, 2.00866476e-01f, 1.82233214e-01f, 3.78834397e-01f, 3.14122319e-01f, -2.94682294e-01f, -2.34215677e-01f, 6.29726723e-02f,
  -1.82099506e-01f, 1.29569501e-01f, -3.01613152e-01f, -6.27455069e-03f, 5.00021935e-01f, -8.41180384e-02f, -3.44874375e-02f, -4.34770375e-01f, -1.13252029e-01f, -7.69993961e-02f,
  -4.28918719e-01f, -1.72636330e-01f, 5.16518913e-02f, -1.15460582e-01f, 2.30982482e-01f, 3.65983069e-01f, -5.21324314e-02f, 3.54698226e-02f, -8.79118741e-02f, -3.58137488e-01f,
  1.47728175e-01f, 1.23358201e-02f, 2.31885061e-01f, 4.45794702e-01f, -1.02296814e-01f, -1.54227510e-01f, 1.20411456e-01f, 1.44805223e-01f, -3.86259258e-01f, -4.64359522e-01f,
  -1.35301739e-01f, -1.06039025e-01f, -2.28555933e-01f, 6.78192079e-02f, -1.93890184e-02f, -6.93446547e-02f, -3.81063856e-02f, -1.94528010e-02f, -4.46391776e-02f, -3.18278931e-02f,
  1.33535117e-01f, -3.24828736e-02f, 8.03709179e-02f, -7.82935098e-02f, -6.39272928e-02f, -1.86209269e-02f, -3.95804457e-02f, -4.58065607e-02f, -4.66840416e-02f, 1.08193099e-01f,
  2.56716926e-02f, 8.67589936e-02f, 1.42501801e-01f, 4.62969653e-02f, 2.54334067e-03f, 2.34515741e-02f, 6.87474310e-02f, -1.39264204e-02f, -2.11940736e-01f, -1.96248144e-01f,
  -5.25275528e-01f, 6.51583135e-01f, -4.48953897e-01f, -3.30456614e-01f, 5.20113185e-02f, 3.42463136e-01f, 5.58759570e-01f, 8.78375918e-02f, 1.20566398e-01f, -1.97415635e-01f,
  -2.41891295e-01f, -3.20312172e-01f, -3.28625143e-01f, -2.22274773e-02f, -1.60561129e-01f, 8.56480747e-03f, 9.09755379e-02f, -1.55518994e-01f, -1.00481048e-01f, -1.98726520e-01f,
  -2.79769868e-01f, -1.89501554e-01f, 2.92940624e-02f, -3.85853425e-02f, 9.21535343e-02f, 5.71114523e-03f, 5.04919849e-02f, -9.58577767e-02f, -2.38327280e-01f, -5.35617769e-01f,
  -4.86135989e-01f, -6.47401333e-01f, -2.33071372e-01f, -1.66737497e-01f, 3.19793254e-01f, -2.04806879e-01f, 1.56862691e-01f, 2.75542647e-01f, -5.67726977e-02f, 4.16857809e-01f,
  2.02831879e-01f, -7.18053132e-02f, -3.23628247e-01f, -4.48343128e-01f, -3.54299605e-01f, 1.38799474e-01f, -4.91845638e-01f, 6.21141642e-02f, 2.47394547e-01f, 1.64365277e-01f,
  -1.76484287e-01f, 5.31628311e-01f, -2.33424142e-01f, 2.93996513e-01f, -1.37353748e-01f, -2.08462179e-01f, -7.11804479e-02f, -8.92059386e-01f, -1.67466655e-01f, -1.05150118e-01f,
  3.25906575e-01f, 3.98743944e-03f, 7.72156417e-02f, 3.36337328e-01f, 2.71821886e-01f, 8.68093595e-02f, -1.83289796e-01f, -1.62820637e-01f, -7.50059858e-02f, -1.20215893e-01f,
  1.53334543e-01f, 2.44800493e-01f, 2.67596096e-01f, -3.23748887e-01f, -3.84175330e-01f, -3.11389714e-01f, -1.53364658e-01f, 2.04711780e-01f, 1.10754251e-01f, 1.52229061e-02f,
  -1.66097954e-01f, -6.08354956e-02f, 1.12153627e-01f, -6.11344934e-01f, -6.89668581e-02f, 2.19485462e-01f, -3.99271362e-02f, 2.66628146e-01f, -1.94238707e-01f, -6.17489964e-02f,
  4.33174640e-01f, -3.59815061e-01f, 3.81929904e-01f, -3.80726725e-01f, -3.59425098e-01f, 3.99201006e-01f, -4.44152087e-01f, -5.28793372e-02f, 6.13124251e-01f, -1.74945980e-01f,
  -2.75884688e-01f, -3.86392385e-01f, 1.26655042e-01f, 1.45445867e-02f, -1.29118860e-01f, -3.25324163e-02f, 2.05796808e-02f, -8.88381377e-02f, -6.88995570e-02f, -1.56175822e-01f,
  -1.87207907e-01f, -8.68470967e-02f, 1.02370493e-01f, -2.28880852e-01f, -1.20255299e-01f, -1.24121606e-01f, -2.42068037e-01f, 1.56845257e-01f, -6.45779772e-03f, 1.57100514e-01f,
  -9.25102532e-02f, -2.02096835e-01f, -1.00089192e-01f, -4.93980832e-02f, 1.47374477e-02f, -2.23591581e-01f, -1.69866458e-01f, 1.54161349e-01f, 1.27691180e-01f, -5.14309168e-01f,
  -8.18955228e-02f, 8.07149783e-02f, -1.14977360e-01f, -7.05370724e-01f, -4.02143806e-01f, 2.81446707e-03f, 1.39840450e-02f, -2.94660300e-01f, -7.16257393e-02f, -3.76877964e-01f,
  1.42628253e-01f, 2.39146221e-02f, -4.15954500e-01f, 1.48258850e-01f, -1.62023559e-01f, -8.07213634e-02f, -6.95199966e-02f, -4.63867448e-02f, -3.42580140e-01f, -5.71202226e-02f,
  -1.41201109e-01f, 1.52873889e-01f, 3.17849487e-01f, 7.74973631e-02f, -1.84624955e-01f, 2.09550802e-02f, 7.61807337e-02f, 3.95469308e-01f, -3.01271766e-01f, 3.31734508e-01f,
  -5.43001294e-02f, -1.44008726e-01f, 1.63335338e-01f, -1.29381344e-01f, 5.21614909e-01f, -2.94611841e-01f, 3.31889182e-01f, -1.62318572e-01f, 3.87928456e-01f, -7.80217722e-02f,
  1.11596204e-01f, 1.65424973e-01f, -5.72854519e-01f, 7.11097047e-02f, -2.00659670e-02f, -4.95536476e-01f, -2.41571628e-02f, -3.12917680e-01f, -7.00947121e-02f, -4.35916394e-01f,
  -1.60390496e-01f, -3.39725494e-01f, -5.42979300e-01f, -1.13013089e-01f, -7.58534744e-02f, 7.22030401e-02f, -3.72750819e-01f, 3.12012471e-02f, 2.78452516e-01f, -2.25769654e-02f,
  -7.03939199e-01f, -2.25394085e-01f, -7.60726109e-02f, 1.26352599e-02f, 1.40021667e-01f, 4.38911408e-01f, 1.16511337e-01f, -2.75345929e-02f, 3.03641617e-01f, -1.81366652e-02f,
  1.93648152e-02f, -1.96164280e-01f, -6.02831878e-02f, 2.37203360e-01f, 2.22538888e-01f, -1.51565716e-01f, -1.24206692e-01f, 6.32097498e-02f, -1.08943716e-01f, -1.93186194e-01f,
  1.98016092e-01f, 1.58682801e-02f, -9.31289196e-02f, 1.27628893e-01f, -1.17475204e-01f, 4.16090935e-01f, -4.65585999e-02f, -8.88320953e-02f, 1.46840006e-01f, 2.85009623e-01f,
  3.42332900e-01f, -4.32196595e-02f, 2.56448716e-01f, 3.97204645e-02f, -1.12950534e-01f, 9.85929221e-02f, -5.31291544e-01f, 2.02498645e-01f, 1.38110384e-01f, 1.45270869e-01f,
  4.22036611e-02f, 1.14779115e-01f, 1.57759741e-01f, -1.09361686e-01f, 5.85065037e-02f, 1.42966071e-02f, -1.16825588e-01f, 1.07185327e-01f, 5.88253103e-02f, 2.19101131e-01f,
  9.70828310e-02f, 4.69267666e-02f, 9.21717361e-02f, 4.53605689e-02f, -1.09253258e-01f, -8.44254494e-02f, -1.16249621e-01f, 1.27930790e-01f, -1.58316344e-01f, -4.17971388e-02f,
  2.22461462e-01f, -1.18847162e-01f, -7.13720471e-02f, -1.80739328e-01f, 6.86305091e-02f, 1.43270968e-02f, 3.52051228e-01f, 4.91849966e-02f, -4.90655750e-01f, 3.80595446e-01f,
  1.20752029e-01f, -2.74794638e-01f, -3.50537330e-01f, -1.27264723e-01f, 1.59116417e-01f, 5.13135791e-01f, 1.06743924e-01f, 2.75386393e-01f, 1.00637875e-01f, 2.31909409e-01f,
  -7.39564896e-02f, 4.40120220e-01f, 2.78346539e-01f, -3.88996825e-02f, 6.24822825e-02f, -5.09643495e-01f, 4.21453863e-01f, -1.56746805e-01f, -9.28483754e-02f, -3.73345077e-01f,
  2.09221870e-01f, -1.55766308e-01f, 2.44921386e-01f, -4.09191400e-01f, 3.08701694e-02f, -7.36801848e-02f, -7.04172105e-02f, -4.62365746e-02f, -1.40258521e-01f, -1.53939687e-02f,
  -1.92835510e-01f, 1.24085583e-01f, -1.26667440e-01f, -1.46058640e-02f, -1.84586539e-03f, -5.43218814e-02f, -3.58109504e-01f, 3.34750026e-01f, -1.30172908e-01f, 4.42836255e-01f,
  6.61606938e-02f, -1.66676909e-01f, -3.90658677e-01f, -2.74161607e-01f, -6.71097815e-01f, 1.80577576e-01f, -1.77994236e-01f, -4.25667554e-01f, -1.68423027e-01f, 3.60114500e-02f,
  -1.05123736e-01f, -2.17705429e-01f, 3.11922282e-01f, 2.95184225e-01f, 4.14997727e-01f, -3.27865556e-02f, -2.57274866e-01f, -4.00321223e-02f, -4.96580191e-02f, -1.12675920e-01f,
  -9.55370367e-02f, -7.19496250e-01f, 2.45181814e-01f, -1.74301460e-01f, -1.29691556e-01f, -2.13740110e-01f, -3.65052462e-01f, -3.27732682e-01f, -3.19876187e-02f, -2.30527490e-01f,
  2.38965616e-01f, 4.82974946e-01f, 2.21067742e-01f, -2.37537146e-01f, 9.09774661e-01f, 2.96545416e-01f, -2.56665170e-01f, 4.16973919e-01f, -5.23625053e-02f, -2.92067081e-01f,
  3.61398667e-01f, -4.35163528e-01f, 2.67403275e-01f, 1.27311513e-01f, 1.57710552e-01f, -2.49295488e-01f, -4.90284920e-01f, -3.98326606e-01f, -6.37589335e-01f, 1.73413277e-01f,
  -2.63754159e-01f, -1.66996866e-01f, 5.35072446e-01f, 2.04238133e-03f, -2.72454143e-01f, 1.86402217e-01f, 5.17933816e-02f, -2.92419136e-01f, 3.83953825e-02f, -9.20146182e-02f,
  -1.60155464e-02f, 4.26005796e-02f, 8.95727351e-02f, -1.69800892e-01f, 5.26784770e-02f, 3.43377441e-02f, 2.66107805e-02f, -6.01101220e-02f, -1.95222855e-01f, 8.94142315e-02f,
  2.15806693e-01f, 2.95707494e-01f, 1.43118009e-01f, 6.78762719e-02f, -2.63615996e-02f, -2.20670670e-01f, -1.41009033e-01f, 1.97460040e-01f, 1.82210773e-01f, -1.61844343e-01f,
  6.78881817e-03f, 1.09391036e-02f, -2.56656915e-01f, -6.25497773e-02f, 3.99711549e-01f, -4.23242748e-02f, -4.86008734e-01f, -2.63084143e-01f, -1.13606840e-01f, -3.70731875e-02f,
  -3.86818111e-01f, -5.09860158e-01f, -2.74277836e-01f, -6.55353591e-02f, -1.05797589e-01f, 2.88441509e-01f, -5.10354221e-01f, -1.92926258e-01f, 1.15368344e-01f, -1.58140704e-01f,
  -9.20634866e-02f, -1.26536280e-01f, -1.60745412e-01f, -2.66945094e-01f, -5.51268637e-01f, 3.60285565e-02f, 3.35913211e-01f, 1.22559987e-01f, -9.17817801e-02f, -5.30904591e-01f,
  -7.12976009e-02f, 2.63717800e-01f, 1.17507698e-02f, 2.76771843e-01f, -1.36223331e-01f, -3.20178390e-01f, 1.68419063e-01f, 2.07258731e-01f, -2.12328061e-01f, -3.23648512e-01f,
  6.79610431e-01f, -2.64001071e-01f, -5.74336171e-01f, -3.58700782e-01f, -5.37425637e-01f, 3.75972949e-02f, -2.42991462e-01f, -4.08666534e-03f, -1.06780663e-01f, -1.09943725e-01f,
  2.85475969e-01f, -5.87954447e-02f, -2.69893497e-01f, -9.95837748e-02f, 2.61980176e-01f, -1.88676447e-01f, -8.60309005e-02f, 1.69046000e-01f, 1.82313934e-01f, 2.23371342e-01f,
  4.19245958e-01f, 2.40205556e-01f, -1.78850610e-02f, 1.12711757e-01f, -3.89441311e-01f, -6.08884841e-02f, -3.21947545e-01f, -3.10741603e-01f, -2.38531142e-01f, -2.32444722e-02f,
  -3.27700347e-01f, -3.15120488e-01f, -9.46963280e-02f, -2.37780660e-01f, -5.11106849e-01f, -1.75608218e-01f, -3.65684897e-01f, -1.91871539e-01f, 2.75389791e-01f, -5.77845052e-02f,
  -3.35886516e-02f, -2.23153047e-02f, -2.17532963e-01f, -8.61718059e-02f, -4.22216088e-01f, -3.39244843e-01f, -5.19983470e-01f, -2.68567771e-01f, -3.52505893e-01f, 4.52769607e-01f,
  4.28732246e-01f, -1.40547991e-01f, 3.21325183e-01f, -1.96439132e-01f, -2.99687237e-01f, 1.91746637e-01f, 3.21382612e-01f, 8.78629386e-02f, 3.38779896e-01f, 1.70090452e-01f,
  -1.05305240e-01f, -3.44925791e-01f, -5.16579747e-01f, -4.30532843e-02f, 1.66378096e-01f, -1.31465271e-01f, -2.56097734e-01f, -1.15937382e-01f, -5.27515151e-02f, -8.51064101e-02f,
  -5.71325533e-02f, -1.48887619e-01f, -1.08090639e-01f, 4.16406989e-02f, -1.77689560e-03f, -5.80128096e-02f, -1.01825379e-01f, 7.61326328e-02f, -1.49784312e-01f, 6.68366700e-02f,
  1.60707869e-02f, 1.02294095e-01f, 9.91099402e-02f, -8.92675668e-03f, 1.14052661e-01f, 1.58127993e-01f, 1.66245773e-02f, 1.73173383e-01f, 1.45367667e-01f, 7.83581845e-03f,
  2.44862929e-01f, -4.55862246e-02f, -1.26614794e-01f, -1.96379006e-01f, -2.19025135e-01f, -1.04209118e-01f, -1.16733618e-01f, -1.49053514e-01f, 1.70139492e-01f, -1.73083022e-01f,
  -5.51759712e-02f, 2.87263989e-01f, -1.85341090e-01f, -6.04790926e-01f, 2.64816016e-01f, -1.01198226e-01f, -1.43904015e-01f, -2.48811364e-01f, -1.04435638e-01f, -1.13386095e-01f,
  1.64907519e-02f, -1.92519456e-01f, 1.51724145e-01f, -1.85922012e-01f, -2.39933029e-01f, 1.14113823e-01f, -1.96887791e-01f, -2.53022075e-01f, -2.73417830e-01f, 2.84137517e-01f,
  1.04527891e-01f, -3.13186675e-01f, -5.36857367e-01f, -4.79228348e-02f, -5.58673799e-01f, -1.57273844e-01f, -1.10690504e-01f, -6.02443181e-02f, -3.84058021e-02f, 2.09335342e-01f,
  5.27125835e-01f, -2.62458418e-02f, -5.97484112e-02f, -5.76407835e-02f, 2.46619940e-01f, -8.23083669e-02f, -1.53703600e-01f, -1.59026757e-01f, -3.92332256e-01f, 2.20473513e-01f,
  -3.35158966e-02f, -2.31936857e-01f, 2.43107919e-02f, 4.90534276e-01f, 7.28554875e-02f, -1.58396631e-01f, -1.90121427e-01f, -3.26073200e-01f, 1.04884893e-01f, -1.05898112e-01f,
  1.38783855e-02f, -1.39240354e-01f, -4.22346145e-02f, 8.54491964e-02f, -1.46928385e-01f, 3.23428184e-01f, -1.44668356e-01f, -1.70450717e-01f, -8.31827894e-02f, 2.31234029e-01f,
  1.20595612e-01f, -1.96450695e-01f, -2.46568844e-01f, -2.21760627e-02f, -2.75976658e-02f, 1.61195561e-01f, -2.65901357e-01f, -4.24059406e-02f, 1.14534432e-02f, 1.34752274e-01f,
  4.72386390e-01f, 4.42295313e-01f, 4.38541286e-02f, 3.64269018e-01f, -1.89150244e-01f, -5.66515662e-02f, -2.20165163e-01f, 4.48634252e-02f, -2.62160480e-01f, -2.37646371e-01f,
  -3.26069891e-01f, -3.35608460e-02f, 3.23720664e-01f, -7.37166181e-02f, 1.54506981e-01f, -2.81614289e-02f, -9.39296186e-02f, 6.46653250e-02f, -1.45713881e-01f, 2.19872564e-01f,
  2.27878585e-01f, -2.04423547e-01f, 1.90623105e-01f, -1.44587651e-01f, 1.11168705e-01f, 1.62151948e-01f, 7.95763582e-02f, 7.74706677e-02f, 1.16639979e-01f, 3.97786796e-02f,
  4.81654629e-02f, -9.54712704e-02f, -9.89504717e-03f, 3.77065465e-02f, 1.49123743e-01f, 1.71201736e-01f, -6.24476224e-02f, 9.18492377e-02f, 2.44687080e-01f, -1.54669993e-02f,
  -1.71874743e-02f, -7.13288561e-02f, 1.24697275e-01f, 2.62723655e-01f, 1.52100399e-01f, -4.26842533e-02f, -1.30494967e-01f, 7.51592964e-02f, 3.14087689e-01f, -2.33011525e-02f,
  1.75765634e-01f, -2.24947989e-01f, 2.62978494e-01f, 1.55029148e-02f, -5.86682037e-02f, -1.49470761e-01f, 2.83147395e-01f, -1.83650315e-01f, -2.47597441e-01f, -1.51330428e-02f,
  6.94627613e-02f, -3.64877999e-01f, -1.59610152e-01f, -1.17219806e-01f, -1.69539019e-01f, -4.23083633e-01f, -2.65872359e-01f, -6.80499151e-02f, 9.77900326e-02f, -3.12534571e-01f,
  -2.26225272e-01f, 2.24818736e-02f, 2.03731880e-01f, -3.00523311e-01f, -2.48912454e-01f, -2.58247226e-01f, 1.78510651e-01f, 3.48542556e-02f, -2.07209647e-01f, -2.88500458e-01f,
  1.80310622e-01f, -6.07580096e-02f, 5.46336211e-02f, 4.14190367e-02f, -6.18702359e-02f, 2.17850119e-01f, -1.56382442e-01f, -5.32444045e-02f, -1.56758130e-01f, -3.43243152e-01f,
  -7.44461343e-02f, 4.97632474e-02f, -1.65177673e-01f, -1.97240666e-01f, 5.07653475e-01f, -1.59755960e-01f, -1.67465329e-01f, -8.95232931e-02f, -1.03002135e-03f, 3.91607463e-01f,
  -2.44784579e-01f, -1.61123440e-01f, 1.89219460e-01f, 1.99999228e-01f, -1.77725747e-01f, 8.32074881e-02f, -1.16498291e-01f, -1.30620033e-01f, 1.01252295e-01f, -2.18342334e-01f,
  9.62018967e-02f, -2.21923262e-01f, -4.69546646e-01f, -2.01288581e-01f, -2.02875197e-01f, -2.32950568e-01f, -2.88848191e-01f, -1.49224013e-01f, 3.19341980e-02f, -3.84884626e-02f,
  -3.22266370e-01f, -8.60849172e-02f, -1.84065521e-01f, 1.30246207e-01f, -3.84988606e-01f, -2.48682395e-01f, -7.90432543e-02f, 1.22700259e-01f, -2.71845579e-01f, 5.54406881e-01f,
  2.99420685e-01f, -4.18935537e-01f, -1.67206228e-01f, -1.07751429e-01f, 1.12298891e-01f, -1.43946201e-01f, -1.74983248e-01f, -4.33681905e-01f, 1.30488962e-01f, 3.68452698e-01f,
  -6.67473301e-02f, -2.33916596e-01f, -2.61583000e-01f, -1.20360240e-01f, -2.54225526e-02f, -6.76192418e-02f, -3.87540795e-02f, 2.59838074e-01f, 4.48281229e-01f, 2.47254714e-01f,
  -3.51331413e-01f, 7.36185730e-01f, -1.30576834e-01f, 2.09324330e-01f, -6.11633956e-02f, -1.05710052e-01f, -2.33623069e-02f, 1.52997345e-01f, -2.49566659e-02f, -1.05161369e-01f,
  1.49448991e-01f, 2.06469204e-02f, -8.64538327e-02f, -2.28417944e-02f, 5.35362624e-02f, -3.33287746e-01f, -1.06031723e-01f, 7.68592507e-02f, -2.03341857e-01f, 2.24498156e-02f,
  1.19201466e-01f, -2.77661264e-01f, -1.09848440e-01f, -1.98208094e-01f, 2.00853944e-01f, -5.85803203e-02f, 8.03898722e-02f, -4.13650900e-01f, -2.95184880e-01f, -3.45901214e-02f,
  1.18437499e-01f, 2.18042076e-01f, -1.04619369e-01f, -2.86470026e-01f, -3.06146622e-01f, -2.00207770e-01f, 1.88069299e-01f, 2.36237317e-01f, -2.09001482e-01f, -2.53342092e-01f,
  4.74947423e-01f, -2.53728420e-01f, 3.04113597e-01f, -2.78073639e-01f, -2.00277120e-02f, 2.71335185e-01f, -2.06052780e-01f, -1.21455684e-01f, 3.47055733e-01f, 8.27440023e-02f,
  -3.54911625e-01f, 7.92271867e-02f, -1.90049514e-01f, 5.93963802e-01f, -2.67202854e-01f, -1.20623372e-01f, -1.13945246e-01f, 3.68501008e-01f, 1.07900023e-01f, -8.48142207e-02f,
  2.99540132e-01f, -3.31492692e-01f, -3.01483780e-01f, 6.29888698e-02f, -3.87928843e-01f, -2.40178239e-02f, 3.64464194e-01f, -8.08671564e-02f, 5.14473259e-01f, -4.15491998e-01f,
  2.07222700e-02f, -2.32820988e-01f, -1.81628928e-01f, -2.95250058e-01f, 1.53321669e-01f, 4.12738681e-01f, 4.60668117e-01f, -2.64508426e-02f, 3.31176594e-02f, -3.34649503e-01f,
  1.72785461e-01f, -4.19178575e-01f, 3.30137998e-01f, 1.85775772e-01f, -3.62412810e-01f, 1.79872155e-01f, 1.73598215e-01f, -2.29736581e-01f, 3.34313333e-01f, 1.05205663e-01f,
  1.56848341e-01f, -4.51802611e-01f, -4.72402632e-01f, -5.03409684e-01f, -1.47695735e-01f, 3.59176546e-01f, -8.68097022e-02f, -1.82439432e-01f, 2.94649452e-01f, -1.95235070e-02f,
  -4.98901576e-01f, 6.38649911e-02f, -2.75846064e-01f, 3.72196108e-01f, 5.85016422e-02f, -2.03464851e-01f, -2.20732510e-01f, -3.52780640e-01f, -1.86001301e-01f, -2.02625245e-01f,
  2.44955137e-01f, 1.10662557e-01f, -2.39398584e-01f, -3.81173760e-01f, 1.59423836e-02f, -3.31382215e-01f, 1.03636041e-01f, -2.60779232e-01f, -2.56601065e-01f, -3.09943408e-01f,
  -4.44531679e-01f, 2.39295170e-01f, 4.53243941e-01f, -3.68411034e-01f, -1.25315130e-01f, -3.50785375e-01f, -2.78791875e-01f, -1.09090663e-01f, 4.05603349e-01f, -2.90314317e-01f,
  1.33988634e-02f, 1.46810710e-01f, 7.32900277e-02f, -3.39125618e-02f, -4.12718877e-02f, 7.45479837e-02f, -3.06355823e-02f, 1.13680154e-01f, 5.01845367e-02f, -2.75831781e-02f,
  -2.08510794e-02f, -2.44646817e-02f, -3.96793336e-02f, 7.60795698e-02f, -2.08616421e-01f, -8.52497518e-02f, -1.10253230e-01f, 2.24983599e-02f, 2.54748225e-01f, -7.15371296e-02f,
  -1.81220621e-01f, 1.32096082e-01f, 3.04948492e-03f, -1.38750851e-01f, 7.15988362e-03f, -1.48557276e-01f, -2.49342948e-01f, 4.42376584e-01f, 3.67669821e-01f, -2.78349593e-02f,
  -1.40191913e-01f, 1.57103583e-01f, 2.90439904e-01f, -3.90056789e-01f, -3.96171778e-01f, -1.18378028e-01f, -5.94321825e-02f, -1.67338401e-01f, -2.53759086e-01f, -2.03787893e-01f,
  -1.24314606e-01f, 2.86873043e-01f, -3.80351633e-01f, 3.59923959e-01f, -7.79265612e-02f, 1.73525050e-01f, -9.27996784e-02f, -1.08231507e-01f, -4.13605310e-02f, -4.90349419e-02f,
  4.60999459e-02f, 1.80420682e-01f, 1.93862498e-01f, -8.31776951e-03f, -1.34239420e-01f, -3.67051549e-02f, -2.43474066e-01f, -2.31004253e-01f, -1.40264675e-01f, -1.14304379e-01f,
  -3.79951268e-01f, 3.61260116e-01f, -1.25000715e-01f, -5.44018038e-02f, -2.58599937e-01f, 3.29725780e-02f, -2.79918790e-01f, -1.24682784e-01f, -9.00122523e-02f, 1.65505081e-01f,
  -1.33670107e-01f, 2.72140473e-01f, -1.56602070e-01f, -7.45344982e-02f, -1.92418262e-01f, -2.49934465e-01f, -4.09421772e-02f, 1.07554160e-02f, 2.06106588e-01f, -9.06100348e-02f,
  -1.36193320e-01f, -1.61419585e-01f, -9.87772420e-02f, -3.30612868e-01f, 3.74434382e-01f, -1.13945112e-01f, -7.03455787e-03f, -1.77973717e-01f, -1.79130480e-01f, -1.91802546e-01f,
  -3.66992116e-01f, 3.49687666e-01f, -3.99338841e-01f, -1.83068857e-01f, -1.38502985e-01f, -2.11514115e-01f, -2.96356648e-01f, 2.88614720e-01f, -2.69408405e-01f, 4.17018056e-01f,
  -6.54892400e-02f, -3.65008026e-01f, 3.06031108e-01f, 5.00822902e-01f, -1.52242467e-01f, 1.70922518e-01f, -2.02160612e-01f, 2.88189977e-01f, -2.00831741e-01f, -3.67669702e-01f,
  -1.40389487e-01f, -1.20284744e-01f, 7.33787715e-02f, 2.97519892e-01f, -1.96601883e-01f, -1.72960266e-01f, -2.19703510e-01f, 4.69880819e-01f, -1.97356716e-01f, 2.55370736e-01f,
  -1.62013233e-01f, 4.25734818e-01f, 1.43303514e-01f, -2.82391131e-01f, -1.86994568e-01f, -2.14491427e-01f, -1.10306695e-01f, -3.19003284e-01f, 2.11095810e-01f, 8.98152031e-03f,
  2.00312287e-02f, 1.13641717e-01f, -2.06537661e-03f, 1.25304163e-01f, -5.36440387e-02f, 1.11062348e-01f, 2.14385353e-02f, 7.15781003e-02f, 6.41041771e-02f, 4.41531241e-02f,
  -7.41468146e-02f, 2.33168229e-01f, 3.94952297e-02f, -1.00339763e-01f, 1.47721559e-01f, -2.59202253e-02f, -2.18656391e-01f, -9.96282231e-03f, 8.87378603e-02f, -1.11829765e-01f,
  2.19581380e-01f, -2.42217377e-01f, -2.44567782e-01f, 1.90926239e-01f, 8.89946595e-02f, -9.12646875e-02f, -1.35991126e-01f, -2.34655514e-01f, -6.82912320e-02f, -7.32237548e-02f,
  -2.01275840e-01f, 2.57068664e-01f, -1.55081257e-01f, -1.56165324e-02f, 2.78160628e-02f, -2.44533941e-01f, -2.56372660e-01f, -2.22433656e-01f, 4.30460483e-01f, -8.02115202e-02f,
  -4.70646173e-02f, 2.28187051e-02f, 8.83332938e-02f, -1.98085651e-01f, -1.37689024e-01f, -5.63946180e-02f, 3.20950568e-01f, 2.97921509e-01f, -1.84488550e-01f, -5.18661812e-02f,
  8.88662711e-02f, -5.38211018e-02f, -2.33457506e-01f, 2.54443079e-01f, -4.73865867e-01f, -1.36007085e-01f, 2.95529753e-01f, 2.54357636e-01f, 6.30088300e-02f, -2.02587053e-01f,
  -3.66981447e-01f, -1.78402722e-01f, -1.03578884e-02f, 5.10693192e-01f, -1.30217209e-01f, 9.26767141e-02f, 1.22530386e-01f, -1.54771611e-01f, -1.52758792e-01f, 1.23757469e-02f,
  -3.26795876e-01f, -2.17837393e-01f, 1.00324504e-01f, -4.47734706e-02f, -5.05112708e-02f, -1.18896991e-01f, -2.76075959e-01f, 3.08503687e-01f, -1.46184132e-01f, -4.74106789e-01f,
  -3.62966061e-01f, -2.98526973e-01f, -8.90326500e-02f, 1.49000019e-01f, 2.53913730e-01f, -3.71448040e-01f, -1.57070830e-01f, -2.59085715e-01f, -1.59865871e-01f, -3.04137021e-02f,
  -2.08710909e-01f, -1.54173464e-01f, -1.40726447e-01f, 1.83834419e-01f, 5.88226020e-01f, 2.26939723e-01f, -1.66575044e-01f, -3.94507535e-02f, -1.44088045e-01f, -2.32132167e-01f,
  -2.82113731e-01f, -6.72830865e-02f, -1.90595850e-01f, -3.79194230e-01f, -4.13244694e-01f, -8.36212039e-02f, -1.99877650e-01f, -1.45902351e-01f, 2.62381673e-01f, 4.30217415e-01f,
  -1.78804472e-01f, -2.72984058e-01f, -2.64615584e-02f, -2.43633884e-04f, 3.06479007e-01f, -2.71686614e-01f, 4.42682624e-01f, -1.19411618e-01f, -6.17863834e-01f, -1.98076218e-01f,
  -2.05820054e-01f, -2.12497950e-01f, 5.55350184e-01f, -8.94976407e-03f, -9.26072299e-02f, -6.73745722e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.35323182e-01f, 2.03531682e-02f, 1.20925680e-01f, -1.17108248e-01f, -1.46927565e-01f, -3.96569706e-02f, -5.59647679e-02f, -6.88948929e-02f, -5.35982773e-02f, 1.79924399e-01f,
  7.32266977e-02f, -4.10803333e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    