/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.13724172e-01f, 1.23450071e-01f, 3.32240105e-01f, -1.30587205e-01f, -3.43266457e-01f, -1.44174516e-01f, -5.57383373e-02f, -1.54993877e-01f, -1.51058897e-01f, 7.30396137e-02f,
  -8.14132094e-02f, 1.60862491e-01f, 9.20723081e-02f, -3.31615359e-02f, -1.29630223e-01f, 1.86870828e-01f, -1.97012275e-01f, 1.58809759e-02f, 1.02401339e-02f, -8.07915777e-02f,
  -6.40314519e-02f, -1.53687835e-01f, 2.12937698e-01f, -1.00933589e-01f, -1.03401147e-01f, 3.09040565e-02f, -5.23908176e-02f, 8.11352432e-02f, -1.20088942e-02f, -9.76985879e-03f,
  6.74737170e-02f, 1.00221904e-02f, -3.03116883e-03f, 1.29320949e-01f, -9.10773501e-02f, -2.77889669e-02f, 2.99649239e-02f, 9.61886272e-02f, 5.33516593e-02f, -4.75653633e-02f,
  -2.66767181e-02f, -2.00234000e-02f, 2.74336487e-02f, -2.49475390e-02f, -5.64735122e-02f, 5.79188857e-03f, -2.72384714e-02f, 1.64764025e-03f, 2.10818145e-02f, 2.60856021e-02f,
  2.59388331e-02f, 8.33542552e-03f, -2.95854416e-02f, 4.99736406e-02f, 1.55733982e-02f, 1.03736371e-02f, 5.00945076e-02f, 6.46306388e-03f, 9.02453531e-03f, -7.20149353e-02f,
  -4.42575514e-02f, -1.37069812e-02f, 9.87245981e-03f, 2.87163444e-02f, -1.06735183e-02f, 1.97091214e-02f, -4.03144658e-02f, 1.95055548e-02f, 7.63139036e-03f, -3.83455791e-02f,
  8.58744606e-03f, -4.31956314e-02f, 5.62607348e-02f, -7.80478120e-03f, -2.08620653e-02f, -1.30500309e-02f, 4.27154871e-03f, 1.87070146e-02f, -1.14562456e-02f, 1.86083689e-02f,
  -1.85678583e-02f, -3.66449207e-02f, -6.39616465e-03f, 1.47186117e-02f, 5.12258112e-02f, 1.97118614e-02f, -3.94327082e-02f, -7.73296691e-03f, -6.06687553e-03f, -1.72494736e-03f,
  -1.75234899e-02f, -2.72631906e-02f, 1.02615990e-01f, -7.60396756e-03f, 5.24279140e-02f, -6.92280848e-03f, -2.32551210e-02f, -1.88231189e-02f, 3.36723775e-03f, -3.74014005e-02f,
  -2.68285454e-04f, 4.27459478e-02f, -9.76983011e-02f, -1.62154846e-02f, 4.34437171e-02f, -7.23713310e-03f, 2.96416115e-02f, 1.77345350e-02f, -4.15287167e-02f, -3.61026637e-02f,
  -2.48349714e-03f, -4.17195633e-02f, 3.75846401e-03f, -5.84026836e-02f, -3.48453335e-02f, -1.82158630e-02f, -1.04226723e-01f, -7.90017284e-03f, 2.64090095e-02f, 3.54501628e-03f,
  -2.65706587e-03f, -5.97333252e-01f, -1.07862450e-01f, -4.37400043e-01f, 1.08298324e-01f, -3.84589843e-02f, 3.52294780e-02f, -2.33889148e-01f, -2.36322418e-01f, -6.34923652e-02f,
  1.04933724e-01f, -1.84862614e-01f, 7.10879592e-03f, -2.76183963e-01f, 2.32393906e-01f, -3.36961187e-02f, -5.23929745e-02f, -9.61348638e-02f, -9.28558260e-02f, -1.33632690e-01f,
  1.94426924e-02f, -9.91001129e-02f, 4.13981155e-02f, -1.02176160e-01f, 2.89956592e-02f, -8.52285549e-02f, 2.04616547e-01f, 1.28181977e-02f, 7.12377429e-02f, -2.34897397e-02f,
  -5.02838346e-04f, -1.31388247e-01f, 2.89984606e-02f, -5.10603227e-02f, 1.64152812e-02f, 7.87601247e-02f, 3.34672779e-02f, 8.37136209e-02f, -2.19560694e-02f, -2.43100952e-02f,
  2.85161175e-02f, -3.96528654e-03f, -3.34209725e-02f, -1.56160248e-02f, -6.34264806e-03f, -3.79749723e-02f, 3.90377529e-02f, -4.08251816e-03f, -7.15270638e-02f, 1.25317676e-02f,
  -6.10572100e-02f, 1.11213699e-02f, -4.34576487e-03f, -3.80641706e-02f, 2.48676678e-03f, -4.78841215e-02f, -1.07470213e-03f, 2.87864860e-02f, 1.25080813e-03f, -2.19831076e-02f,
  -1.51637243e-03f, 4.88046929e-03f, 4.27056253e-02f, -3.38882245e-02f, -1.73537582e-02f, 2.34707575e-02f, -2.65656598e-02f, 1.40916056e-03f, -2.62034703e-02f, 3.41590494e-02f,
  -7.21945689e-05f, -2.42804289e-02f, -5.64281791e-02f, 2.29496583e-02f, -3.12323570e-02f, -1.12475930e-02f, 3.75333242e-02f, -1.46355676e-02f, -2.63907183e-02f, -1.57523772e-03f,
  -1.37189243e-04f, 8.86188180e-04f, -7.43347406e-03f, 4.61660326e-02f, 4.74087615e-03f, -1.40912272e-02f, -2.95545300e-03f, -5.28958105e-02f, 3.55524719e-02f, 4.98047508e-02f,
  4.36580507e-03f, -8.90120789e-02f, -2.14912300e-03f, 1.74159575e-02f, 2.77015362e-02f, 3.18055935e-02f, 1.35128805e-02f, -1.40815983e-02f, -1.06729532e-03f, 6.12913780e-02f,
  1.75220035e-02f, 2.70137955e-02f, 2.94856932e-02f, 1.12026157e-02f, 1.32877044e-02f, -2.13664919e-02f, -5.69839729e-03f, -1.87963841e-03f, 1.01536056e-02f, -3.31267854e-03f,
  4.25373651e-02f, -1.42537281e-02f, 2.30368674e-02f, -2.55645276e-03f, 3.09903193e-02f, 6.92910850e-02f, -4.63831387e-02f, -3.15743014e-02f, 1.82490703e-02f, 1.92720778e-02f,
  -2.93872386e-01f, 3.05121124e-01f, -2.72878427e-02f, 5.02061918e-02f, -7.67141804e-02f, 2.08699122e-01f, -8.76085758e-02f, 6.95258677e-02f, 3.70449275e-02f, 1.39244542e-01f,
  6.62090704e-02f, 1.61876865e-02f, 1.34320006e-01f, 2.86024243e-01f, -6.57019690e-02f, 1.19497314e-01f, 2.97784247e-02f, -1.87296420e-02f, -2.88804006e-02f, 1.11811087e-02f,
  2.96615995e-02f, 9.22173858e-02f, -6.34731203e-02f, 3.81566174e-02f, -5.66398911e-02f, -1.03954799e-01f, 2.64763776e-02f, 2.04257462e-02f, -4.13375460e-02f, 1.07998207e-01f,
  9.09504667e-02f, 8.98597091e-02f, 9.68089141e-03f, -4.30030003e-02f, 2.73892768e-02f, 9.88212135e-03f, -4.87589240e-02f, -5.54401614e-02f, -6.94240183e-02f, 4.73308675e-02f,
  -4.52801809e-02f, -6.52937368e-02f, -2.44001374e-02f, -1.80708095e-02f, 7.95536395e-03f, -3.90716642e-02f, 9.86609980e-03f, 3.38960513e-02f, 4.57259314e-03f, 3.63550372e-02f,
  -8.27174932e-02f, -2.75219921e-02f, -3.43685374e-02f, 5.11530740e-03f, -5.74629568e-02f, -2.27732398e-02f, 3.71349342e-02f, -2.29172241e-02f, -2.91780196e-02f, 2.18864251e-02f,
  2.17521731e-02f, 4.21442576e-02f, -6.36147112e-02f, 1.50894281e-02f, 5.29557429e-02f, -7.54314065e-02f, 6.77462714e-03f, 9.38906427e-03f, -4.82415557e-02f, -1.99344698e-02f,
  -2.10454706e-02f, 2.74438262e-02f, -6.71460554e-02f, 1.68276411e-02f, -6.19651303e-02f, 1.78338215e-02f, 2.98314379e-03f, 8.98565073e-03f, -9.04580504e-02f, 2.25919802e-02f,
  8.79485742e-05f, 8.25063698e-03f, -7.35546602e-03f, -5.76408729e-02f, 1.63174327e-02f, -5.46590835e-02f, 8.80738441e-03f, -3.58002819e-02f, -4.83886003e-02f, 1.45721566e-02f,
  1.40475750e-01f, 1.24652907e-01f, -1.64027531e-02f, 1.08045219e-02f, -4.24141437e-02f, -1.53636383e-02f, 9.10943747e-03f, 1.26330284e-02f, -8.61056969e-02f, 2.81621106e-02f,
  -3.20580862e-02f, -1.10569715e-01f, 3.71613204e-02f, 5.22924252e-02f, -4.45837015e-03f, 2.59936638e-02f, 4.17421162e-02f, -2.88380776e-02f, 1.61055904e-02f, 3.91853265e-02f,
  -5.02025783e-02f, -4.21170443e-02f, -2.30666716e-02f, -2.38674805e-02f, 3.00312061e-02f, 1.72097888e-02f, 4.42925952e-02f, 6.44083619e-02f, 8.58817436e-03f, -1.65000912e-02f,
  2.31476352e-01f, -1.86049864e-01f, 2.53819406e-01f, -2.41942331e-01f, 1.85687706e-01f, -1.08752534e-01f, -8.25516433e-02f, -1.38517350e-01f, -9.08237591e-04f, -2.26722851e-01f,
  -9.25446451e-02f, 1.66528281e-02f, -3.45764644e-02f, -6.62242845e-02f, 4.55255993e-02f, -2.27060229e-01f, -1.15948185e-01f, -1.35926187e-01f, 6.18584976e-02f, 2.05364954e-02f,
  1.29133724e-02f, -1.79927319e-01f, -4.55361651e-03f, 1.82478391e-02f, 4.61593345e-02f, 1.28635347e-01f, -7.34918043e-02f, 1.33913428e-01f, -1.62400883e-02f, -4.54293899e-02f,
  4.49098051e-02f, 1.43764287e-01f, 6.27012849e-02f, 3.16942371e-02f, 6.30840957e-02f, 9.43838879e-02f, -5.68363741e-02f, -1.49347708e-02f, 2.97878496e-02f, -5.08072823e-02f,
  -6.60620071e-03f, 6.07642159e-02f, -6.06267601e-02f, 1.22490665e-02f, 5.66993542e-02f, -5.40955877e-03f, -4.02810192e-03f, 2.49402765e-02f, 6.40151964e-04f, 4.62559378e-03f,
  -1.03804588e-01f, -3.50890569e-02f, -5.98642137e-03f, -6.38083071e-02f, -3.05120423e-02f, 4.82840687e-02f, 6.18528482e-03f, 3.27985100e-02f, -2.97528245e-02f, -1.27875374e-03f,
  4.43236083e-02f, 9.13765356e-02f, 1.54842762e-02f, -2.45940220e-02f, 6.45092651e-02f, -3.99380885e-02f, 4.95795044e-04f, 2.36590263e-02f, -1.20610476e-03f, -2.95782778e-02f,
  -2.95682922e-02f, -1.96502488e-02f, -5.98114654e-02f, -5.92193101e-04f, 2.46175943e-04f, -2.30345875e-02f, 4.38786820e-02f, -3.73344980e-02f, -7.92982057e-02f, -6.06052252e-03f,
  -3.47704403e-02f, 8.38221423e-03f, -4.88482602e-02f, -4.74256165e-02f, -7.59612257e-03f, -2.36007012e-02f, -4.97166486e-03f, -7.74433687e-02f, -1.19976858e-02f, -9.97318700e-03f,
  6.51720213e-03f, 4.75107580e-02f, -4.26394120e-02f, -1.33983130e-02f, -3.54931504e-02f, 1.18285371e-03f, 5.06746583e-02f, -1.65943485e-02f, -4.40973118e-02f, 2.72504035e-02f,
  2.49795858e-02f, -6.61266744e-02f, 5.91838732e-02f, -3.89556251e-02f, -5.97192831e-02f, -9.23422724e-02f, 6.85215369e-02f, -6.07269332e-02f, 8.21473915e-03f, 5.36151193e-02f,
  1.27267521e-02f, -2.63611376e-02f, 3.52523825e-03f, 2.98353676e-02f, -2.36978345e-02f, -3.42002623e-02f, 5.03403693e-02f, 1.03670768e-01f, 4.12927344e-02f, -3.09634972e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.88779515e-01f, 1.87375233e-01f, 7.31729576e-03f, -2.68861383e-01f, 2.13708043e-01f, -7.24438159e-03f, -1.61009207e-01f, 1.52145073e-01f, -9.69948694e-02f, -7.38093108e-02f,
  6.12120219e-02f, -1.37964666e-01f, 1.02068745e-01f, -6.98898509e-02f, -6.74538314e-02f, 6.55592158e-02f, -7.28076026e-02f, -1.90014064e-01f, 6.20273724e-02f, -9.55239758e-02f,
  9.18239262e-03f, 7.53831044e-02f, 6.76239952e-02f, 2.74340779e-01f, 1.43022435e-02f, -5.26092611e-02f, -1.19200818e-01f, 1.21074349e-01f, -6.79756626e-02f, 1.07564434e-01f,
  -2.20912069e-01f, -1.69420719e-01f, -9.33909863e-02f, -3.02281361e-02f, -9.06726494e-02f, -1.00401558e-01f, -6.52884543e-02f, -5.11416569e-02f, -4.75193821e-02f, -1.47864310e-04f,
  -1.83925163e-02f, 1.08171992e-01f, 3.09428964e-02f, 7.04368725e-02f, -2.50663441e-02f, -1.01636965e-02f, -2.74562393e-04f, -3.30888405e-02f, -6.90231426e-03f, 5.34177125e-02f,
  5.48479781e-02f, 5.39236236e-03f, -2.87842117e-02f, 1.41584622e-02f, 6.43464550e-02f, 1.58366691e-02f, -5.22534475e-02f, -3.95037904e-02f, -4.65926006e-02f, 1.38031477e-02f,
  2.89020198e-03f, -7.47613758e-02f, 8.95211548e-02f, -6.97643384e-02f, 4.61735167e-02f, -1.54560702e-02f, -1.63582098e-02f, -1.09603759e-02f, -2.42056954e-03f, -2.39629280e-02f,
  -1.71078723e-02f, 3.23726935e-03f, -3.59105989e-02f, -2.60601453e-02f, -6.09401204e-02f, -3.29307690e-02f, -1.70727149e-02f, -1.25814192e-02f, 9.17949714e-03f, -5.19673675e-02f,
  4.54625152e-02f, 2.51775719e-02f, 3.82810161e-02f, -6.47869939e-03f, -1.61556844e-02f, 3.72299515e-02f, 9.34305340e-02f, 1.38542447e-02f, -4.48279940e-02f, -5.28436266e-02f,
  -3.03211540e-01f, -3.22535008e-01f, -2.57248115e-02f, -1.24777751e-02f, -2.80096307e-02f, -1.57417926e-05f, -2.97896704e-03f, -1.59914624e-02f, 7.75993336e-03f, 4.46875133e-02f,
  -6.49609119e-02f, -7.45971873e-02f, -2.34977957e-02f, 2.47651860e-02f, -1.11723030e-02f, -7.03419372e-02f, -3.53856534e-02f, -2.92048156e-02f, -4.98195887e-02f, 4.36597094e-02f,
  -3.38708200e-02f, -2.58658193e-02f, -7.30779255e-04f, 9.85198561e-03f, 1.18596787e-02f, -4.77521196e-02f, -7.66757652e-02f, 9.87148844e-03f, -1.19409719e-02f, -2.81320866e-02f,
  3.03438574e-01f, 7.31381401e-02f, -2.10439458e-01f, 8.27700719e-02f, -1.05507001e-01f, -1.32940367e-01f, -3.40271294e-02f, -8.72419775e-02f, -1.05604209e-01f, 1.09765492e-01f,
  1.73503652e-01f, -6.54299557e-02f, 4.75785658e-02f, 3.26763451e-01f, 1.65004253e-01f, 1.04126394e-01f, 2.41237387e-01f, 1.66008770e-02f, 5.37998416e-03f, 1.05371244e-01f,
  1.02833249e-01f, 2.57837504e-01f, 2.05096126e-01f, 1.59983471e-01f, 6.52703792e-02f, 4.18014154e-02f, 1.22474998e-01f, -1.05401769e-01f, 1.60210311e-01f, 1.43818334e-02f,
  6.63163662e-02f, 4.48436663e-02f, 3.40368189e-02f, 4.81341891e-02f, -4.35507037e-02f, 3.46227176e-03f, -5.79474047e-02f, -2.25614524e-03f, -1.77165717e-02f, -9.02749896e-02f,
  -3.70252319e-02f, 8.85211825e-02f, 2.97348797e-02f, -2.97073033e-02f, 9.10214894e-03f, -4.61883731e-02f, -5.72135113e-02f, -9.99462977e-02f, -6.21520691e-02f, -2.57004928e-02f,
  -1.59963116e-01f, 2.76675224e-02f, -4.99181915e-03f, 6.33788258e-02f, 4.17069197e-02f, 1.19747110e-01f, 4.25344296e-02f, -3.40330452e-02f, -1.84268765e-02f, -3.99050638e-02f,
  5.02995588e-02f, 2.66106818e-02f, 1.45287663e-01f, -7.36839231e-03f, 6.13519326e-02f, 3.11186630e-02f, 8.01384524e-02f, 5.10190129e-02f, -8.10062140e-02f, 4.22621742e-02f,
  7.12146387e-02f, -7.67211989e-02f, 8.21779307e-04f, 2.35711858e-02f, 3.85857113e-02f, 2.29105968e-02f, 4.57870737e-02f, 5.04215574e-03f, -1.19561858e-01f, -3.43672000e-02f,
  2.33504232e-02f, 2.02595140e-04f, -5.40636368e-02f, 6.17621280e-02f, 5.85666336e-02f, -1.01174556e-01f, 1.26757873e-02f, -1.48022845e-01f, -5.19642048e-02f, -1.60952248e-02f,
  2.80363820e-02f, 1.03913441e-01f, 2.87022181e-02f, -4.87878285e-02f, -2.16945168e-02f, 9.00971666e-02f, 7.04436451e-02f, 3.52411978e-02f, 1.06691994e-01f, 2.98072007e-02f,
  -2.40662713e-02f, 3.65678295e-02f, -4.39945571e-02f, -4.84051630e-02f, 4.15292010e-02f, -8.61326512e-03f, 3.65944579e-02f, -3.20897438e-02f, 2.83047929e-02f, -7.20677711e-03f,
  8.74713957e-02f, -5.08708786e-03f, 8.38494673e-02f, -2.60584205e-02f, -1.26677370e-02f, -5.90605624e-02f, -1.24184132e-01f, -5.05651534e-02f, 8.89685005e-02f, 4.21034507e-02f,
  -6.37737885e-02f, -1.58725306e-01f, 7.17706531e-02f, 3.38851005e-01f, -9.40107629e-02f, -3.76940101e-01f, -5.32314658e-01f, 1.74194500e-02f, -3.53424162e-01f, -1.05269097e-01f,
  1.62541986e-01f, -1.96346298e-01f, -1.74084947e-01f, -1.38362199e-02f, 1.65410817e-01f, -4.27340925e-01f, 3.85560021e-02f, -1.00602515e-01f, -1.66553795e-01f, 7.31541067e-02f,
  9.41642746e-02f, 1.69908687e-01f, 1.63352624e-01f, 3.67624044e-01f, 3.58890817e-02f, 3.18996519e-01f, 5.78877628e-01f, 7.71744363e-03f, 5.11636555e-01f, 2.74489708e-02f,
  -2.19727069e-01f, -6.31894097e-02f, -1.03476299e-02f, -5.30496314e-02f, 8.47360864e-02f, 4.92110439e-02f, 2.14560106e-02f, 3.72521281e-02f, 1.62700843e-02f, 5.01196161e-02f,
  -7.36732632e-02f, -4.10132064e-03f, -1.53300343e-02f, -1.08692357e-02f, -5.22508137e-02f, 2.35086270e-02f, -2.60035601e-02f, -6.74496219e-02f, -4.25646044e-02f, -7.50004351e-02f,
  -8.53173286e-02f, -3.20396870e-02f, 1.69014689e-02f, 6.13959692e-02f, 9.65653509e-02f, -2.92747878e-02f, -2.88754255e-02f, 3.97340860e-03f, -1.17639713e-02f, -6.59143552e-03f,
  1.29229184e-02f, 6.02122433e-02f, -1.08488180e-01f, 1.15859578e-03f, 4.29465771e-02f, 1.54911168e-02f, -5.86994626e-02f, -5.14291972e-02f, 2.12405957e-02f, -1.60781331e-02f,
  3.33034322e-02f, 2.07764823e-02f, -9.53073613e-03f, -5.27698286e-02f, -5.22283502e-02f, -8.78795981e-02f, -1.37381144e-02f, 8.29997808e-02f, 6.91426732e-03f, -3.21998484e-02f,
  -4.41672094e-02f, 2.05361489e-02f, -6.89839711e-03f, 5.52937947e-03f, 1.65061709e-02f, 7.63579831e-02f, 5.95352501e-02f, -1.96140762e-02f, 2.70055048e-02f, -3.59510258e-02f,
  1.01634093e-01f, 2.27895230e-01f, -6.17304118e-03f, 4.09789942e-02f, -6.88000629e-03f, -6.26332536e-02f, 3.43867727e-02f, 4.30306606e-03f, 9.68061239e-02f, -6.82184612e-03f,
  1.11951150e-01f, -6.21183440e-02f, 2.67403349e-02f, 8.96957964e-02f, 1.64124891e-01f, 9.32324007e-02f, 9.70505625e-02f, 1.25582621e-01f, 7.17931911e-02f, 1.21410005e-01f,
  8.05613771e-03f, -1.30722642e-01f, 2.29153056e-02f, -2.27406807e-02f, 3.09524573e-02f, 2.93356478e-02f, 3.98696363e-02f, 4.39148955e-02f, 7.19931126e-02f, -1.02120593e-01f,
  -4.93066698e-01f, 5.43046296e-02f, -7.90392011e-02f, -1.14411779e-01f, -2.26009309e-01f, -2.50800580e-01f, -1.56851888e-01f, -1.48960233e-01f, -1.63193807e-01f, 1.03842713e-01f,
  -2.00423971e-02f, -7.46570081e-02f, 1.33294299e-01f, -3.46311450e-01f, -4.56550300e-01f, -4.05199111e-01f, -2.23232418e-01f, -1.94979236e-01f, -6.87488765e-02f, 7.57623017e-02f,
  -9.36842859e-02f, -3.40666324e-01f, -1.81194156e-01f, 3.41539830e-02f, 7.37112900e-03f, 2.61967480e-01f, 6.18913509e-02f, 1.41193584e-01f, 1.79175183e-01f, -6.53666407e-02f,
  -1.10778444e-01f, 2.62142599e-01f, 1.34780660e-01f, -3.98912542e-02f, 5.16890362e-02f, -1.88978389e-02f, 2.16309284e-03f, 1.97211821e-02f, 1.77666433e-02f, -5.79465320e-03f,
  -1.32899219e-02f, -6.48194924e-02f, -8.45583752e-02f, -2.64713019e-02f, -1.03466008e-02f, 6.03852198e-02f, -7.13361008e-03f, 3.58300470e-02f, 5.75733446e-02f, -4.15461138e-02f,
  -6.49623526e-03f, -6.68285862e-02f, -3.38906143e-03f, -1.43482581e-01f, -8.95866528e-02f, 5.77997379e-02f, -2.42349133e-02f, 1.15801893e-01f, -1.07931672e-02f, 6.94955885e-02f,
  -2.02121884e-02f, -5.37290387e-02f, -7.81053454e-02f, 6.88498912e-05f, 6.39329031e-02f, 1.63948182e-02f, -4.12188210e-02f, 6.82051927e-02f, -4.46485728e-02f, 2.86857877e-02f,
  -6.56980136e-03f, 1.18880416e-03f, -1.13396168e-01f, -2.00667195e-02f, -3.16129476e-02f, -6.62856176e-02f, 1.65984053e-02f, 2.68647764e-02f, -7.44976550e-02f, 5.76377623e-02f,
  -5.95841818e-02f, -4.20014225e-02f, 3.81573178e-02f, 2.57660542e-02f, 2.17390750e-02f, 1.16828801e-02f, -2.34852619e-02f, 4.42056637e-03f, 1.01277903e-02f, -4.65806164e-02f,
  5.10235615e-02f, 4.37281691e-02f, 5.36551513e-02f, 1.43362358e-02f, -4.60779890e-02f, -2.26677563e-02f, -1.72952354e-01f, -6.38693944e-02f, 2.78255604e-02f, -4.98433970e-02f,
  1.58030465e-02f, -1.26265893e-02f, -7.91233033e-02f, -7.69174984e-03f, 4.54844423e-02f, 8.55049938e-02f, 3.56731638e-02f, 7.46045113e-02f, -1.06877722e-01f, 9.35994834e-02f,
  1.39427520e-02f, 7.08256848e-03f, 6.95301918e-03f, 1.30922208e-02f, -2.98744105e-02f, 7.38298055e-03f, 6.92766011e-02f, 2.17407197e-03f, 6.76762685e-03f, -1.30677640e-01f,
  -7.49159157e-02f, 2.97316015e-02f, -9.98961776e-02f, -7.17092156e-02f, -4.54676636e-02f, -3.47853988e-01f, -2.28487343e-01f, 1.41017750e-01f, 1.44422069e-01f, 4.84949425e-02f,
  -1.62200555e-02f, -1.58291273e-02f, 1.88772470e-01f, -2.04672664e-01f, 9.00220051e-02f, 2.22323045e-01f, -9.07407254e-02f, -5.39271384e-02f, 7.73276836e-02f, 1.54124303e-02f,
  1.73205048e-01f, -5.83255701e-02f, -1.62382796e-01f, 6.10751621e-02f, -2.16419235e-01f, -6.41147867e-02f, 2.37092208e-02f, -1.38069704e-01f, -1.63593516e-01f, 6.60943538e-02f,
  -1.03073314e-01f, 2.72962842e-02f, -1.58249050e-01f, -6.26164153e-02f, -7.72116408e-02f, -3.72435115e-02f, -1.10394701e-01f, -7.58078769e-02f, -9.49853361e-02f, -3.78455743e-02f,
  -6.34092614e-02f, 8.31429381e-03f, 9.14514661e-02f, 6.67243078e-02f, -4.05563191e-02f, -5.32207489e-02f, -5.59273176e-02f, -1.23345509e-01f, -8.68590623e-02f, -8.56202319e-02f,
  -7.62288794e-02f, -4.37587276e-02f, -1.00030780e-01f, 4.07228572e-03f, 8.00907053e-03f, -8.92027095e-02f, -9.69275758e-02f, 5.33530749e-02f, 3.31988521e-02f, -2.53823232e-02f,
  2.53444612e-02f, -7.65302498e-03f, 2.22948007e-02f, 1.71610191e-02f, -3.97568084e-02f, 3.51800956e-03f, 7.76865259e-02f, 2.87398361e-02f, -4.60419320e-02f, -1.17341978e-02f,
  -8.31011869e-03f, 5.32807037e-02f, 5.32614551e-02f, 2.16997042e-02f, -3.85789499e-02f, 5.52883297e-02f, 6.10533589e-03f, -8.43266472e-02f, -6.40541762e-02f, -8.71805996e-02f,
  1.58089437e-02f, 3.73882465e-02f, 3.33183166e-03f, -8.38136971e-02f, 7.10811764e-02f, -3.92251238e-02f, -6.26622289e-02f, -6.01175092e-02f, -2.02358589e-02f, 7.21528977e-02f,
  4.91700508e-02f, 8.81624967e-02f, -3.08876093e-02f, -6.52517844e-03f, -7.70440605e-03f, 4.27908041e-02f, 3.12717780e-02f, -1.76688089e-04f, 3.62869650e-02f, 9.26695094e-02f,
  -7.69662187e-02f, -7.88736418e-02f, -2.14074757e-02f, 2.91917250e-02f, 5.65107875e-02f, 5.75463772e-02f, -2.83184443e-02f, -2.87098554e-03f, -1.90484840e-02f, 7.06778839e-02f,
  5.32611785e-03f, 7.35550001e-02f, 7.73692280e-02f, -5.68052493e-02f, 2.09693294e-02f, 4.13189642e-02f, 6.54101744e-02f, -8.00025910e-02f, -6.26865402e-02f, 5.48476949e-02f,
  2.85340309e-01f, -3.46512020e-01f, -2.09375303e-02f, 1.86535195e-01f, 1.94239080e-01f, -7.66168237e-02f, 1.36000440e-01f, 1.60144060e-03f, 3.97100449e-02f, -1.64004192e-01f,
  8.99658948e-02f, 2.18730569e-02f, -3.96303125e-02f, 3.58504765e-02f, 2.08862558e-01f, -1.61997795e-01f, 8.78406316e-02f, -1.19126095e-02f, -5.43514546e-03f, 1.99387614e-02f,
  1.40418425e-01f, 1.11569360e-01f, 7.29776844e-02f, -9.97965559e-02f, -7.13753607e-03f, -6.54167011e-02f, -9.14910287e-02f, 2.39430387e-02f, -4.40808348e-02f, 1.19158275e-01f,
  -3.06057073e-02f, -2.97678709e-02f, -9.67896450e-03f, 3.27552594e-02f, -1.28053173e-01f, -1.56428039e-01f, -5.39535545e-02f, 5.91119528e-02f, 4.23001014e-02f, -1.63976792e-02f,
  -1.07686222e-01f, -1.71191175e-03f, 7.77021050e-02f, 3.61674950e-02f, -2.92716678e-02f, -1.83546916e-02f, -3.69028980e-03f, -4.01158668e-02f, -4.67805490e-02f, 4.52833548e-02f,
  -1.80357341e-02f, -4.70298827e-02f, -2.56734286e-02f, 1.32065434e-02f, -3.51873389e-03f, 1.10784424e-02f, 3.54806241e-03f, -4.27986719e-02f, 3.25586973e-03f, -1.58721849e-03f,
  5.22439880e-03f, -1.53505709e-02f, -2.08914131e-02f, 5.37427049e-03f, 3.49242403e-03f, -1.23697631e-02f, -4.76642661e-02f, -4.88840370e-03f, 1.55333029e-02f, -6.74129575e-02f,
  2.31589098e-02f, -4.24198573e-04f, 6.54543340e-02f, -3.64950821e-02f, -2.03085449e-02f, 7.40801021e-02f, -4.82466631e-02f, 5.03183983e-04f, -8.27311873e-02f, 3.18619907e-02f,
  7.63815455e-03f, -6.49617985e-02f, -5.78242689e-02f, 4.02737111e-02f, 8.68054181e-02f, 1.05180172e-03f, -4.94095087e-02f, -4.55665402e-02f, -3.62986326e-02f, 3.17187011e-02f,
  -1.68789297e-01f, -1.17972977e-01f, 7.38195851e-02f, -2.44818926e-02f, -1.09985158e-01f, -7.14386329e-02f, -2.54946016e-02f, -5.04091941e-02f, -1.22153096e-01f, -6.79963678e-02f,
  -9.41706356e-03f, 2.79395543e-02f, -7.82930031e-02f, -7.65286572e-03f, 1.51761780e-02f, -3.56387417e-03f, -4.92113158e-02f, -8.06789193e-03f, 4.84289825e-02f, -2.26444248e-02f,
  -2.35312488e-02f, -4.74859327e-02f, 3.46687213e-02f, -5.27201742e-02f, 3.25519517e-02f, -4.66191359e-02f, -5.62865473e-02f, -1.95047027e-03f, 1.61260739e-03f, -5.05474284e-02f,
  -2.04696655e-01f, -1.16234615e-01f, -3.34943205e-01f, -2.77233243e-01f, 3.41409557e-02f, -6.17161155e-01f, -4.10648584e-01f, -9.07038376e-02f, 3.98478732e-02f, 1.70531601e-03f,
  -1.68708086e-01f, 2.01222766e-02f, 2.41732802e-02f, -7.32047111e-02f, -9.15501639e-02f, 1.45373940e-01f, -3.36540580e-01f, -2.19119430e-01f, -2.95001417e-02f, -2.98133731e-01f,
  -1.44214466e-01f, -4.10703495e-02f, -2.08422855e-01f, 3.17476913e-02f, -2.03769177e-01f, -5.05120754e-02f, 1.96807951e-01f, 4.66384590e-02f, -2.20678717e-01f, 9.32480618e-02f,
  -1.36807531e-01f, 4.23676893e-02f, -1.15112886e-01f, 5.67541346e-02f, -1.73632622e-01f, -3.04426495e-02f, 3.81937176e-02f, 1.20118717e-02f, -8.58420432e-02f, 2.56596087e-03f,
  4.68799770e-02f, 5.57441963e-03f, 2.22997796e-02f, 1.61376433e-03f, -9.15033221e-02f, -1.26057211e-02f, 1.22522889e-02f, 2.38331780e-02f, -4.24920507e-02f, -4.10158969e-02f,
  -1.25351727e-01f, -8.35977942e-02f, -8.34017172e-02f, 1.92523494e-01f, 1.80908758e-03f, -1.86940201e-03f, -4.73024361e-02f, -1.43013731e-01f, 1.48567846e-02f, -4.20032740e-02f,
  -2.33379379e-02f, 5.61317466e-02f, -1.71050001e-02f, 7.23919421e-02f, -6.98339939e-02f, -9.42099188e-03f, -1.31904008e-02f, -7.89191052e-02f, 4.59530316e-02f, 2.45983861e-02f,
  3.21929678e-02f, 9.04772151e-03f, 1.21248029e-01f, -3.75160165e-02f, -1.16242103e-01f, 8.03447217e-02f, -1.04078036e-02f, 6.55968413e-02f, 2.13235291e-03f, -4.36284244e-02f,
  7.44640529e-02f, -5.10208383e-02f, 5.21178804e-02f, 3.25606205e-02f, -4.19586152e-02f, 1.75438616e-02f, 6.91097155e-02f, -2.08199192e-02f, -5.42191193e-02f, -6.05797255e-03f,
  -4.18854803e-02f, -6.87992126e-02f, 3.92173529e-02f, 4.17476036e-02f, 6.66278005e-02f, -5.10148779e-02f, 5.92802577e-02f, 1.90004464e-02f, -8.95371214e-02f, -1.19790304e-02f,
  -1.60004031e-02f, 7.98132420e-02f, 7.13290647e-02f, -1.06202681e-02f, 3.82161736e-02f, -2.90399585e-02f, 5.91508672e-02f, -1.10353883e-02f, 1.95084270e-02f, -3.64770442e-02f,
  6.58445284e-02f, 9.53381956e-02f, 1.08711787e-01f, -5.70656965e-03f, 7.18974099e-02f, -3.65101285e-02f, -5.33187054e-02f, 6.67878315e-02f, 2.20252331e-02f, 1.34060308e-02f,
  -2.02070232e-02f, 1.58442706e-02f, 1.47519801e-02f, -5.74403405e-02f, -4.56703007e-02f, 1.29158692e-02f, 2.18190085e-02f, -2.77558947e-03f, -1.62827526e-03f, 3.33591402e-02f,
  -1.01162098e-01f, 1.43076822e-01f, -1.18660536e-02f, 1.96046438e-02f, 4.58848663e-02f, 6.49444014e-03f, 2.98048393e-03f, 3.15099768e-02f, 7.83129185e-02f, -3.87557261e-02f,
  -3.46559007e-03f, -3.73447984e-02f, -1.76641382e-02f, 3.56636457e-02f, -3.67259495e-02f, -4.36941162e-02f, 7.69759044e-02f, 5.72057702e-02f, 6.04381971e-02f, -1.13261551e-01f,
  -2.37226393e-02f, -6.84740990e-02f, -9.49940458e-02f, 7.95879066e-02f, -8.64732340e-02f, 7.05915764e-02f, 2.03603879e-02f, -3.92636769e-02f, 1.81519259e-02f, 6.41918853e-02f,
  8.93237665e-02f, 1.08232088e-02f, -3.69118452e-02f, -1.15924552e-02f, 1.28001980e-02f, -2.43169554e-02f, 3.61373909e-02f, -1.03077829e-01f, 3.90223190e-02f, -6.96409270e-02f,
  -2.98999399e-02f, -9.90429241e-03f, -7.41425157e-02f, 1.02396913e-01f, 4.37933654e-02f, -1.05558090e-01f, -3.88918514e-03f, -5.99187687e-02f, -8.10688455e-03f, 4.21222970e-02f,
  -3.35978903e-02f, 5.17074354e-02f, -1.87463164e-02f, 4.95145209e-02f, 2.25816052e-02f, -4.77520898e-02f, -5.59929051e-02f, 8.14896002e-02f, 2.13966603e-04f, -1.01875197e-02f,
  1.34171573e-02f, -1.18700676e-02f, -6.17942549e-02f, 1.71823427e-02f, 1.19607642e-01f, -5.04732039e-03f, 3.76781379e-03f, 5.82507066e-02f, -4.24335375e-02f, 6.77378401e-02f,
  5.95009923e-02f, 1.71394495e-03f, -8.40515867e-02f, -4.40977253e-02f, -8.34870040e-02f, -1.10342667e-01f, 5.09398989e-02f, -6.36189729e-02f, -5.50906248e-02f, -2.53233612e-02f,
  -3.25205252e-02f, -8.99092779e-02f, 2.43016891e-02f, -2.54732352e-02f, -7.36988708e-02f, -4.85097691e-02f, 8.33321512e-02f, 5.22313975e-02f, 5.47288284e-02f, 7.02460557e-02f,
  6.88508824e-02f, -7.49523342e-02f, 3.18604000e-02f, 6.27964735e-02f, 3.63209844e-02f, 5.16059324e-02f, -6.95307404e-02f, 3.50797810e-02f, -4.88543697e-02f, 4.44134558e-03f,
  -8.11829716e-02f, 8.36850777e-02f, 3.86639126e-02f, -1.38017032e-02f, -2.03679912e-02f, 5.13149165e-02f, 1.68169215e-02f, 5.43483980e-02f, -5.98535612e-02f, -1.42236974e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  9.99198854e-02f, -7.38548860e-02f, -3.10525179e-01f, 2.06626669e-01f, 8.90617147e-02f, 4.08325382e-02f, -7.27316886e-02f, -6.55820295e-02f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  5.24888895e-02f, -6.22481257e-02f, -7.53496438e-02f, -2.72250712e-01f, -3.00669372e-01f, -3.03521425e-01f, 1.53914407e-01f, -2.55047292e-01f, -4.38078880e-01f, 1.40258282e-01f,
  3.58066678e-01f, -2.72637576e-01f, 9.32105035e-02f, -1.28284886e-01f, -8.54815468e-02f, -2.08290532e-01f, -3.62025225e-03f, 1.86387613e-01f, 5.25359884e-02f, -2.97710329e-01f,
  5.59849799e-01f, -4.82846767e-01f, 2.00460106e-01f, -1.32505193e-01f, 5.77648997e-01f, 2.78520852e-01f, -1.34916557e-02f, 4.88304943e-02f, -1.72578707e-01f, -5.50468862e-01f,
  -6.97803795e-02f, -1.45848006e-01f, 3.46379541e-02f, 2.94361591e-01f, -2.74697132e-02f, -2.23236844e-01f, -1.16637371e-01f, -2.65547246e-01f, 2.45184854e-01f, 8.23140293e-02f,
  1.89121395e-01f, 2.53676564e-01f, 5.96088469e-02f, 2.55040109e-01f, 2.39475325e-01f, -1.55371383e-01f, -2.19100162e-01f, 2.05872566e-01f, -1.51121303e-01f, 2.99425349e-02f,
  -1.96871504e-01f, 1.82617381e-01f, 7.67955184e-02f, 3.82456899e-01f, -1.87957093e-01f, -1.29476130e-01f, -4.96791899e-02f, -2.67948061e-01f, -2.72913724e-01f, -1.58363789e-01f,
  -7.80777186e-02f, -4.91058044e-02f, 2.09837239e-02f, -1.48637637e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.87622625e-02f, 1.69177651e-01f, 5.79156317e-02f, 5.25310695e-01f, -1.40024528e-01f, 4.19013619e-01f, -3.55215281e-01f, 3.86730880e-01f, -3.36468756e-01f, -6.02720790e-02f,
  4.48184460e-01f, 4.81375545e-01f, 6.67012110e-02f, 1.98717609e-01f, 4.58785653e-01f, 1.52920121e-02f, -7.79018030e-02f, 6.13540784e-03f, 2.62641788e-01f, 3.61698449e-01f,
  -2.02649727e-01f, 2.45695084e-01f, -5.11119813e-02f, 5.74401580e-02f, 1.68842286e-01f, -2.49434516e-01f, 2.53463745e-01f, 3.75353247e-01f, 2.21120164e-01f, 9.10611004e-02f,
  2.20262095e-01f, 1.73412770e-01f, 1.87897161e-01f, -2.55200770e-02f, 1.21329367e-01f, 3.44763190e-01f, -7.18159750e-02f, -7.90488064e-01f, -7.23138526e-02f, -1.41834125e-01f,
  -3.06628764e-01f, -2.75056250e-02f, 4.71229970e-01f, 1.57806382e-01f, -8.12554434e-02f, 3.78681272e-02f, 7.67606823e-03f, -5.88026782e-03f, -1.73105553e-01f, 1.79552913e-01f,
  2.42430598e-01f, 3.92093733e-02f, 3.31226885e-01f, -7.19257712e-01f, 6.18943930e-01f, -3.46915156e-01f, 1.85519829e-01f, 4.95984167e-01f, 1.03165865e-01f, -3.44187790e-03f,
  1.33733660e-01f, -2.14118406e-01f, 7.52055570e-02f, -8.08933154e-02f, 1.11377552e-01f, -2.98884779e-01f, 4.63636488e-01f, 7.41722465e-01f, 2.03776121e-01f, -5.06949663e-01f,
  -2.34428763e-01f, 2.76211947e-01f, 7.06736594e-02f, -2.85560220e-01f, -1.54238194e-01f, 7.57560790e-01f, 3.54993790e-01f, -1.25291809e-01f, 5.29561996e-01f, 3.24853882e-02f,
  4.51999485e-01f, -1.51750490e-01f, 2.22951472e-01f, 4.58403885e-01f, -2.42471978e-01f, -5.23028612e-01f, -2.12828711e-01f, 1.62689760e-01f, -3.13169897e-01f, -2.22554520e-01f,
  3.41817945e-01f, 3.72725546e-01f, 5.00133216e-01f, -4.81763892e-02f, 5.04909933e-01f, 2.22079128e-01f, 3.78396779e-01f, -2.27948397e-01f, 2.05561817e-01f, 2.40961745e-01f,
  1.92760170e-01f, 2.43765041e-01f, 3.83192189e-02f, -1.89546630e-01f, 1.66616470e-01f, -4.35345545e-02f, -1.56331733e-01f, 3.07740778e-01f, 4.88538533e-01f, -7.61213824e-02f,
  6.60891831e-01f, -5.65723553e-02f, -3.35392743e-01f, 3.42852354e-01f, -5.54019623e-02f, 2.84914434e-01f, -7.83996165e-01f, -2.75416613e-01f, -2.15875626e-01f, -1.32546306e-01f,
  -1.64362505e-01f, 3.71887684e-01f, 1.18593025e+00f, -2.67035328e-02f, -3.32903378e-02f, 3.14675629e-01f, -2.91214943e-01f, -1.88668638e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  3.35545167e-02f, 3.52461077e-02f, 4.36378747e-01f, 3.69696140e-01f, 3.21843743e-01f, 1.25933066e-01f, 5.46841882e-02f, 1.76099703e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.66953415e-01f, 3.81907046e-01f, 1.76876411e-01f, 2.20082581e-01f, -2.82680504e-02f, 3.20690647e-02f, 2.14122146e-01f, 9.27118436e-02f, 2.42061615e-02f, 1.19813427e-01f,
  3.32479268e-01f, 3.38715494e-01f, -7.35544693e-03f, -2.43639722e-01f, -3.75784039e-01f, 2.61585861e-01f, -1.74067169e-01f, -3.05725515e-01f, -1.37241602e-01f, 5.15999161e-02f,
  -2.37060025e-01f, 3.45003664e-01f, 2.27955684e-01f, 1.04450233e-01f, -2.36211821e-01f, 2.14613661e-01f, -3.33142400e-01f, 3.29959214e-01f, -1.97400287e-01f, -2.95061171e-01f,
  1.06335945e-01f, -1.29991263e-01f, 8.57983455e-02f, 1.18646443e-01f, 5.19281439e-02f, -8.49434659e-02f, -2.25969255e-01f, 1.28491819e-01f, 7.83672556e-02f, 1.26088575e-01f,
  2.96498865e-01f, 2.99880491e-03f, -3.11797559e-02f, -2.44181648e-01f, 1.20522641e-01f, 1.97671056e-01f, 3.28680634e-01f, -6.09553039e-01f, -2.21408904e-01f, -1.00960471e-01f,
  -1.88140273e-01f, -4.37818915e-02f, 3.61981057e-02f, -4.78832759e-02f, 1.99252814e-01f, 7.13574141e-02f, -3.11015755e-01f, 4.94461320e-02f, 1.14343777e-01f, 1.64004013e-01f,
  -1.76768284e-02f, -1.64486334e-01f, -2.49276489e-01f, -1.19353414e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -1.63638115e-01f, 1.29341125e-01f, -1.71274081e-01f, 1.50315166e-01f, -2.77749561e-02f, 1.50929883e-01f, -8.39317217e-02f, 1.46547988e-01f, -1.86954290e-01f, 3.36047113e-02f,
  -4.22626063e-02f, -7.67414048e-02f, -1.97790653e-01f, -3.64161506e-02f, -3.83012667e-02f, 1.25522301e-01f, 2.32633278e-01f, -2.90597022e-01f, 2.24170163e-01f, 3.45675759e-02f,
  -2.04082891e-01f, 5.20342588e-01f, 2.91700214e-01f, 5.21026272e-03f, -1.10327015e-02f, -6.01942725e-02f, 4.89468485e-01f, 4.20753002e-01f, 5.06572247e-01f, 3.98277044e-01f,
  2.07867548e-02f, 1.48251429e-01f, -2.51430213e-01f, -1.44847199e-01f, -7.66203552e-02f, -2.46761695e-01f, -2.04743221e-02f, -4.55888808e-02f, 7.08690211e-02f, 4.95091267e-02f,
  2.09707320e-01f, 1.02090225e-01f, -2.75877595e-01f, 1.39243469e-01f, 1.63674682e-01f, -8.37863982e-03f, 2.97938168e-01f, -1.90273061e-01f, -4.79501970e-02f, 1.55140609e-01f,
  5.03093004e-02f, 1.16982395e-02f, -2.06093892e-01f, 2.55597591e-01f, -9.43110809e-02f, -2.41677128e-02f, 5.52147746e-01f, 4.99234498e-01f, 3.24146122e-01f, -1.89483780e-02f,
  1.22989643e+00f, 1.01860654e+00f, 7.03703642e-01f, -1.00381531e-01f, 3.56399655e-01f, 5.08402824e-01f, 1.93884298e-01f, -1.73723325e-01f, 4.92297918e-01f, -4.45765257e-01f,
  1.81715176e-01f, -3.82470757e-01f, 5.68845093e-01f, 7.27175549e-02f, 6.41691804e-01f, 1.25511631e-01f, -1.27890527e-01f, 4.06629771e-01f, -2.04882920e-01f, 1.16566432e+00f,
  4.96506959e-01f, 1.48629218e-01f, 2.94295013e-01f, -1.20091930e-01f, 4.41643298e-01f, 1.00051314e-01f, 5.43826044e-01f, -2.64057100e-01f, -3.70411724e-01f, -3.59490782e-01f,
  4.66731757e-01f, 8.44328105e-01f, -6.08625829e-01f, 8.67578983e-02f, 8.42548907e-02f, 6.42730415e-01f, -1.25455916e-01f, -8.82687122e-02f, 1.05463520e-01f, 1.53462961e-01f,
  1.21668860e-01f, -2.71000713e-01f, 2.30990171e-01f, -8.11482221e-02f, 3.12364399e-01f, 2.45376691e-01f, 5.59351183e-02f, -2.17741683e-01f, 1.42549882e-02f, 2.76807994e-01f,
  -2.16318071e-01f, 6.32791221e-01f, 1.04006872e-01f, 7.05366284e-02f, 2.34630138e-01f, 2.79459149e-01f, -1.48590267e-01f, -6.65633857e-01f, -2.77332187e-01f, 1.76758692e-01f,
  5.68438411e-01f, 4.74924773e-01f, -2.50357777e-01f, -5.64967215e-01f, -3.76324892e-01f, 1.43606141e-01f, 1.97892666e-01f, 3.22180033e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  -1.23025864e-01f, 2.51643211e-02f, -5.59325852e-02f, -3.92795727e-02f, 5.73866554e-02f, 4.63288933e-01f, 1.51064545e-01f, -9.19725001e-02f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  2.11679816e-01f, -3.20628971e-01f, 2.94481851e-02f, -3.69665772e-01f, -2.24753261e-01f, -8.96415710e-02f, 1.47439009e-02f, 1.60713047e-01f, 1.57784790e-01f, 2.33628020e-01f,
  -3.14184338e-01f, 2.60067135e-01f, -1.56790465e-01f, -5.13830900e-01f, 5.08683845e-02f, -1.99365094e-01f, 2.79135220e-02f, 1.48559406e-01f, 1.04415081e-01f, 1.74977198e-01f,
  3.89124781e-01f, -2.03933835e-01f, 6.35675788e-02f, -2.69192666e-01f, 5.25580607e-02f, -3.34265560e-01f, 8.02378953e-02f, -1.49698451e-01f, 6.86134845e-02f, -2.68729925e-02f,
  -1.18623681e-01f, 5.82204640e-01f, -1.60503313e-01f, 3.51219863e-01f, 3.58805954e-02f, -1.60577804e-01f, -1.66274875e-01f, 3.69416177e-01f, -2.37281397e-01f, 1.39926344e-01f,
  -2.35133812e-01f, 1.71125993e-01f, 2.71371100e-02f, 1.03283301e-01f, -2.47609749e-01f, -2.14288935e-01f, -3.36180665e-02f, 3.69903773e-01f, -3.29353400e-02f, -1.52158931e-01f,
  1.01230871e-02f, -1.61362946e-01f, 3.81549925e-01f, 4.22365636e-01f, -2.12811604e-01f, 3.03664088e-01f, 1.97475985e-01f, 2.97040135e-01f, -9.32028145e-02f, -2.97073036e-01f,
  1.01804808e-01f, 3.16322863e-01f, -3.74735482e-02f, -4.95843291e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -1.58364385e-01f, 1.06360316e-01f, -2.42658794e-01f, 4.19473238e-02f, -4.86257523e-02f, -2.35530511e-01f, 1.39711455e-01f, -1.88124806e-01f, -5.60955191e-03f, -2.22077921e-01f,
  5.77392988e-02f, -1.63423583e-01f, -2.32944176e-01f, -4.41673584e-02f, 5.17622614e-03f, 1.43687159e-01f, -1.89351380e-01f, 1.21471897e-01f, -6.96941912e-02f, -9.73814353e-02f,
  -3.65976281e-02f, 2.01349676e-01f, -3.03744555e-01f, 2.99300849e-01f, -9.93159339e-02f, 2.82653302e-01f, 2.04505786e-01f, 2.32294425e-01f, -8.85754749e-02f, 7.87900448e-01f,
  -2.40132868e-01f, -5.00323713e-01f, -2.00526446e-01f, 4.03970003e-01f, 2.01952666e-01f, 6.35861456e-01f, 7.39170969e-01f, -1.89589933e-01f, -4.09639060e-01f, -1.04269944e-01f,
  -4.50370349e-02f, 1.49961367e-01f, 2.18310788e-01f, -7.72074938e-01f, 9.54893947e-01f, 1.38738573e+00f, 2.49310717e-01f, -1.86828986e-01f, -4.12107378e-01f, -6.53854072e-01f,
  -6.26738071e-01f, -2.41992325e-01f, -4.17083770e-01f, -7.26478636e-01f, -1.93587184e-01f, -8.23282823e-02f, -8.26991275e-02f, 2.67194044e-02f, 6.25814870e-02f, 8.61418068e-01f,
  1.42820263e+00f, -3.21590118e-02f, 6.90525889e-01f, 7.47111499e-01f, 2.01079637e-01f, -6.36494979e-02f, -2.72713173e-02f, -2.20043898e-01f, -8.74304026e-02f, 9.44419578e-02f,
  -1.87273785e-01f, -1.37355864e-01f, 2.38871157e-01f, 2.59812716e-02f, 2.94273179e-02f, -2.38755852e-01f, -1.51318312e-01f, -1.48805305e-01f, 2.36587211e-01f, 9.23444927e-02f,
  4.79811847e-01f, 7.50934780e-01f, 6.08565450e-01f, 3.87158543e-01f, 2.05704436e-01f, 3.85173410e-02f, 6.08108997e-01f, -1.72758475e-01f, 1.67327479e-01f, 9.54754353e-01f,
  2.14823652e-02f, 1.42756462e+00f, -2.30713993e-01f, -5.07210344e-02f, -3.68808687e-01f, -4.27601486e-01f, -5.12392461e-01f, -3.22296172e-01f, -4.41259265e-01f, -3.68517250e-01f,
  -4.49646622e-01f, 3.90697002e-01f, -2.69977659e-01f, 4.03109848e-01f, 6.74730688e-02f, -1.50602132e-01f, 2.66654134e-01f, 4.93829131e-01f, -5.55051267e-02f, -1.50116771e-01f,
  -3.28681879e-02f, 3.52179676e-01f, -3.23996186e-01f, 1.80056870e-01f, -2.40400165e-01f, -2.66389877e-01f, -2.40745425e-01f, 1.33462220e-01f, -3.55446607e-01f, 4.06538486e-01f,
  -7.23654777e-02f, -4.89238873e-02f, 4.02168989e-01f, 2.85646677e-01f, -2.79781938e-01f, -1.24676004e-01f, 1.72966737e-02f, -1.29829705e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  -2.01646060e-01f, 2.36235425e-01f, 6.52067244e-01f, -2.55752385e-01f, -6.13623746e-02f, 7.01495826e-01f, -2.99733907e-01f, -7.77304098e-02f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -9.15939733e-02f, 2.93798685e-01f, 3.06755811e-01f, 3.08752507e-01f, -9.42468286e-01f, -6.74485462e-03f, -4.23685908e-01f, 2.74903029e-01f, 1.12639450e-01f, 5.28386593e-01f,
  1.09141982e+00f, -1.52492571e+00f, 7.87651539e-02f, 1.57786235e-01f, -2.01775074e-01f, 1.52732953e-02f, -6.50512516e-01f, 9.86312181e-02f, -2.80470610e-01f, 6.10770136e-02f,
  -4.88600045e-01f, 1.60134152e-01f, -6.21325314e-01f, 4.04326081e-01f, -2.28697002e-01f, 2.92585373e-01f, 1.18619132e+00f, -2.33587027e-01f, -1.12717748e-02f, -9.34059024e-01f,
  -1.12604976e-01f, 2.01396734e-01f, -5.40801585e-01f, -1.67787701e-01f, -5.94905615e-01f, 5.32830656e-01f, -1.34855404e-01f, 4.97261107e-01f, -7.62689829e-01f, 4.81025696e-01f,
  2.10017953e-02f, -5.42062521e-01f, 3.13692302e-01f, 7.28229046e-01f, 1.58029720e-02f, -1.26590014e+00f, -5.40663081e-04f, 2.01937109e-01f, -3.27449858e-01f, -6.61631584e-01f,
  -7.86244810e-01f, -7.17594802e-01f, 1.93516880e-01f, 2.47377083e-01f, 8.52162361e-01f, 4.47250247e-01f, -1.83573008e-01f, 3.09907109e-01f, -5.16823351e-01f, -2.45081082e-01f,
  -2.43599132e-01f, 7.11887538e-01f, 4.13078479e-02f, 4.83148277e-01f, 7.56015897e-01f, 5.75819492e-01f, 3.98005128e-01f, 4.67820972e-01f, 4.76604670e-01f, -4.12878633e-01f,
  7.72502005e-01f, -5.03220439e-01f, 2.20240578e-01f, -1.01327449e-01f, -4.63205308e-01f, -1.07426274e+00f, -6.63376823e-02f, 1.14912510e+00f, -4.23442692e-01f, 1.11000739e-01f,
  1.79001376e-01f, 3.31514254e-02f, 4.71760780e-01f, 1.13580036e+00f, -5.64528346e-01f, 5.38322218e-02f, -3.48656118e-01f, -8.14682692e-02f, 4.19069408e-03f, 2.05683485e-01f,
  4.82898533e-01f, -2.31619149e-01f, -1.38182551e-01f, 4.88902628e-01f, 6.79842383e-02f, 5.09166121e-02f, 7.92900264e-01f, 1.18320346e-01f, 6.56847000e-01f, 1.48928776e-01f,
  -4.84417707e-01f, 5.04402339e-01f, -3.38266581e-01f, -9.42241669e-01f, -1.01963729e-01f, -2.99121499e-01f, 2.84440011e-01f, 5.46784997e-01f, -4.60138470e-02f, -3.78078997e-01f,
  -9.94338691e-02f, -3.06036454e-02f, -4.51463670e-01f, -4.13085908e-01f, -7.55705655e-01f, 2.64345914e-01f, -1.64301261e-01f, -1.35224909e-01f, 6.69390708e-02f, 3.01751703e-01f,
  1.92010373e-01f, 2.55841374e-01f, -2.53307343e-01f, 4.88702059e-01f, -1.58308655e-01f, -1.43672153e-01f, 8.87183309e-01f, 6.13656640e-01f, 6.47659451e-02f, -6.49877310e-01f,
  -9.09087777e-01f, -3.72017533e-01f, 3.97394896e-01f, -4.85911161e-01f, -5.06685488e-02f, 6.72722340e-01f, 2.11887449e-01f, 4.37980592e-01f, 1.61619708e-01f, 6.26094282e-01f,
  2.42031425e-01f, -4.22662616e-01f, -7.02016503e-02f, 8.91648605e-02f, 1.14658546e+00f, 1.85055196e-01f, 9.04720783e-01f, -1.22709823e+00f, 4.29520726e-01f, 1.23926592e+00f,
  2.19986916e-01f, -6.18149102e-01f, 2.08227128e-01f, -1.99838161e-01f, -7.33629465e-01f, 3.05744320e-01f, 1.78032238e-02f, 3.46879214e-01f, -4.95192677e-01f, -1.30413324e-01f,
  -4.40744907e-01f, 4.08165097e-01f, -2.03908771e-01f, -7.64238596e-01f, 8.39450717e-01f, -4.85308051e-01f, 4.53075677e-01f, 3.86582553e-01f, 1.90451890e-01f, -3.55634570e-01f,
  -7.38850832e-01f, 7.27693379e-01f, -7.36900419e-02f, -4.97226380e-02f, 2.95323163e-01f, -2.91448563e-01f, -2.71597385e-01f, 8.25006738e-02f, 1.23711210e-02f, -1.94403678e-01f,
  7.14313447e-01f, -9.07359719e-01f, 4.01306115e-02f, -8.63962889e-01f, -1.73575744e-01f, -1.66387230e-01f, -8.13325107e-01f, 1.41138956e-01f, -2.26002306e-01f, 6.98931277e-01f,
  -6.50215387e-01f, -3.68597955e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.32700413e-01f, 9.07977577e-03f, -3.38591784e-01f, -3.54836017e-01f, 1.90673649e-01f, -9.05590355e-02f, 2.78443247e-01f, -1.65876731e-01f, -4.69898343e-01f, 4.98785347e-01f,
  1.81481615e-01f, -2.53347725e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    