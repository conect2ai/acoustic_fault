/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.32194859e-01f, -4.62514125e-02f, -4.58844826e-02f, 3.82388979e-02f, 1.71346709e-01f, 1.30612016e-01f, 1.75949633e-01f, 2.20314600e-02f, -1.17897764e-02f, 1.62983574e-02f,
  6.68972358e-02f, 5.64727075e-02f, -5.14050238e-02f, 1.80992946e-01f, 2.28875205e-01f, -1.37328394e-02f, 1.68183699e-01f, 1.23492815e-01f, -2.47458220e-02f, 1.63607419e-01f,
  6.45975322e-02f, 2.65998572e-01f, 1.04206562e-01f, 5.55845723e-02f, 1.18142255e-01f, -1.08644500e-01f, 2.10590497e-01f, -6.06294051e-02f, 3.10105812e-02f, 9.31768268e-02f,
  -3.78152379e-03f, -7.65378550e-02f, -1.08973263e-02f, -3.26913260e-02f, -2.26538256e-02f, -3.31532173e-02f, 8.81361868e-03f, 1.69009306e-02f, 1.56724977e-03f, -7.84927397e-05f,
  -2.69395914e-02f, 4.18665074e-02f, -1.04692671e-02f, -3.40079851e-02f, 2.93578058e-02f, 1.57904141e-02f, -5.18349335e-02f, -4.92250994e-02f, -6.24439567e-02f, 4.06167991e-02f,
  9.40893870e-03f, -6.06586635e-02f, 1.93926673e-02f, 9.87817720e-03f, 1.31233269e-02f, -2.19310150e-02f, -6.75567761e-02f, -5.31023443e-02f, -4.55341153e-02f, -5.36721796e-02f,
  1.15222178e-01f, 2.86208503e-02f, 8.83231983e-02f, 4.79805022e-02f, -9.78870783e-03f, 9.17605415e-04f, 1.40073178e-02f, 1.58425011e-02f, 2.58893687e-02f, -9.08425543e-04f,
  3.39901187e-02f, 9.62764621e-02f, -1.99543666e-02f, 1.67397968e-02f, 1.12064399e-01f, -5.16499504e-02f, 8.35603476e-02f, 2.77398098e-02f, 1.48077626e-02f, 2.95348815e-04f,
  -4.14915420e-02f, 4.36381511e-02f, 1.55021381e-02f, -8.52825213e-03f, -1.12101119e-02f, 3.60947065e-02f, 1.37185277e-02f, 2.14784760e-02f, 1.35488547e-02f, 5.06700501e-02f,
  2.43921373e-02f, -2.32536485e-03f, -5.64997904e-02f, 3.39961946e-02f, -2.14766487e-02f, 3.86114344e-02f, 1.62553675e-02f, 3.91273201e-02f, -4.74724509e-02f, 1.98487584e-02f,
  -4.43265773e-02f, -4.22108471e-02f, 2.55359896e-02f, 5.02570011e-02f, 2.04490926e-02f, -3.94457355e-02f, 4.68802601e-02f, -1.01081347e-02f, 3.75285298e-02f, 6.28233552e-02f,
  -1.01275761e-02f, 5.92077561e-02f, -2.77443938e-02f, 1.93857830e-02f, 3.69232409e-02f, 2.57284604e-02f, 1.61153208e-02f, -7.16058314e-02f, -4.23830412e-02f, -2.03578603e-02f,
  2.09613830e-01f, -1.49898622e-02f, -9.15464535e-02f, 5.52159175e-02f, 8.91414732e-02f, -1.52759954e-01f, -2.11675644e-01f, 2.00379372e-01f, 4.01531607e-02f, -7.88315907e-02f,
  8.92173424e-02f, -3.94094782e-03f, -9.19048786e-02f, 8.76375008e-03f, 1.96546003e-01f, -1.23966582e-01f, 1.13720186e-01f, -1.14961818e-01f, 4.71525267e-02f, 5.69554083e-02f,
  9.36087891e-02f, 1.65452003e-01f, 1.20577909e-01f, 8.71400163e-02f, -2.41795834e-03f, 1.06406122e-01f, 8.60807449e-02f, -2.36442368e-02f, 1.24801002e-01f, 1.49372162e-03f,
  -4.85328101e-02f, 6.73622042e-02f, 9.59555060e-02f, 1.16367324e-03f, -2.21698899e-02f, -2.04033777e-02f, -8.12441185e-02f, -9.40461233e-02f, -3.20652537e-02f, -2.19302699e-02f,
  5.36857266e-03f, -3.26304175e-02f, 3.52786481e-02f, 4.02432308e-02f, -6.32085428e-02f, -2.87282895e-02f, 2.16778796e-02f, -1.79802198e-02f, -3.42644155e-02f, -3.70862968e-02f,
  -3.50179933e-02f, 4.97439839e-02f, -2.80262474e-02f, 5.03928494e-03f, -4.93396558e-02f, 2.51767281e-02f, 3.31572853e-02f, -2.26638075e-02f, 7.05665257e-03f, 3.83529253e-02f,
  4.00752202e-02f, -6.36640750e-03f, -4.29737307e-02f, 3.31977569e-02f, -3.37746996e-03f, 1.01363403e-03f, 5.55404089e-02f, 4.69681583e-02f, 4.28281501e-02f, -4.78922166e-02f,
  3.02829519e-02f, 2.88826432e-02f, 4.42322940e-02f, 2.41721119e-03f, -3.07220463e-02f, -1.80031918e-02f, -2.55168118e-02f, -6.48234487e-02f, -1.07991517e-01f, 8.74320045e-03f,
  -1.30678271e-03f, -3.95047925e-02f, 1.45373470e-03f, 3.04680560e-02f, -6.34538382e-03f, 4.47185189e-02f, -3.61138172e-02f, 3.59949507e-02f, 1.73129607e-02f, -2.49991771e-02f,
  -4.39000577e-02f, 2.68013142e-02f, 8.82207067e-04f, -3.33136395e-02f, -4.51566577e-02f, -3.34727690e-02f, 1.12981480e-02f, 1.13095559e-01f, 6.41722418e-03f, 8.35313350e-02f,
  -9.19561386e-02f, -9.16967448e-03f, 1.74412020e-02f, -9.12611652e-03f, 4.12145443e-02f, -1.08614517e-02f, -1.93831732e-03f, -1.09494347e-02f, 7.28271976e-02f, 5.49410395e-02f,
  2.36412026e-02f, -4.06914484e-03f, -2.92229280e-02f, -5.18347360e-02f, 1.77814327e-02f, 2.92670317e-02f, 1.31584574e-02f, -2.27812957e-02f, 2.41488758e-02f, -1.42490687e-02f,
  1.14532694e-01f, -1.10510558e-01f, 4.99587245e-02f, 2.80003063e-02f, 1.08898126e-01f, 4.23364677e-02f, 2.96888966e-02f, -8.37638751e-02f, -1.33935198e-01f, -2.58220822e-01f,
  -1.17235184e-01f, -1.05176345e-02f, -1.44553408e-01f, -2.51168370e-01f, 1.33616216e-02f, -2.09765047e-01f, -8.46480057e-02f, -1.90130472e-02f, -1.10532068e-01f, 7.73247108e-02f,
  3.29834782e-02f, -1.19364284e-01f, 6.09163605e-02f, -3.72457765e-02f, 8.56555551e-02f, 1.05691448e-01f, 2.45523490e-02f, 4.25789021e-02f, -5.72132245e-02f, -2.11103796e-03f,
  -3.86921763e-02f, -8.74875635e-02f, 7.31183141e-02f, 8.73727277e-02f, 4.62567694e-02f, 7.47188628e-02f, 6.42204611e-03f, 4.10315767e-02f, 6.74297987e-03f, -1.83249898e-02f,
  9.25911404e-03f, 8.28187261e-03f, -2.08561644e-02f, 7.84426555e-02f, -1.30011672e-02f, -6.72996342e-02f, 4.00223024e-02f, 8.72870628e-03f, 7.25659803e-02f, 5.67703396e-02f,
  -4.80676293e-02f, -1.67797431e-02f, 9.51015353e-02f, 7.12616518e-02f, -4.15236363e-03f, 4.61185910e-02f, 2.09811470e-03f, 5.21230549e-02f, -6.71454100e-03f, 3.93783487e-02f,
  -1.49875870e-02f, -7.36172795e-02f, 7.05725327e-02f, -2.11033914e-02f, -7.77389808e-03f, 5.13992906e-02f, -6.11551218e-02f, -8.59434530e-02f, 9.17390287e-02f, 1.69967115e-02f,
  6.25063628e-02f, -5.53551801e-02f, 4.68399785e-02f, 7.39689590e-03f, 5.92495091e-02f, -6.11835346e-02f, 5.16962335e-02f, -4.83030751e-02f, 9.93820280e-02f, -2.33058482e-02f,
  -8.55376571e-02f, -3.18110883e-02f, 3.99868079e-02f, -8.12497921e-03f, 1.51060475e-03f, -1.92235485e-02f, -7.38348961e-02f, -6.84952363e-02f, -2.63712462e-02f, -3.46558727e-02f,
  -5.89199699e-02f, -1.36055395e-01f, 2.82481872e-03f, 3.29498313e-02f, -2.19973009e-02f, 2.59555541e-02f, 2.05687210e-02f, -1.17270760e-01f, -4.71532494e-02f, 8.10796209e-03f,
  7.47317309e-03f, 6.60587996e-02f, 7.96222314e-03f, -4.68340516e-02f, 5.30252345e-02f, 1.54064866e-02f, 6.87917881e-03f, -2.74003986e-02f, -2.98356824e-02f, -4.65053618e-02f,
  5.64451814e-02f, 2.55930293e-02f, 2.03295797e-02f, -2.45104954e-02f, -7.52169453e-03f, -1.91007964e-02f, 1.27013460e-01f, 8.62554684e-02f, 1.06466319e-02f, -4.21609245e-02f,
  3.56011152e-01f, -2.56642610e-01f, 7.75141865e-02f, 7.29216039e-02f, 1.47529289e-01f, 6.73787147e-02f, -3.19232116e-03f, 1.10985227e-01f, -3.15584317e-02f, -2.98313558e-01f,
  1.05649330e-01f, 6.45085350e-02f, -1.10744024e-02f, -5.30353300e-02f, 3.19936186e-01f, -1.49918213e-01f, 2.90768817e-02f, -1.28732890e-01f, -3.50279026e-02f, -1.22357719e-02f,
  6.59331633e-03f, -4.95598614e-02f, 9.55622457e-03f, -4.94827293e-02f, -7.15784077e-03f, -8.51216242e-02f, 3.15844230e-02f, 3.87343951e-02f, 4.04530838e-02f, 2.50185709e-02f,
  4.33057137e-02f, 2.38814224e-02f, 6.32719919e-02f, -7.32355267e-02f, 1.17460147e-01f, -3.05900797e-02f, 2.31002308e-02f, 2.41009537e-02f, 6.99825659e-02f, 3.81610915e-02f,
  -2.98325606e-02f, 2.06020791e-02f, 6.34881407e-02f, -3.30951549e-02f, -3.34410332e-02f, 1.66184828e-02f, 1.92630431e-03f, 1.01613859e-02f, -7.65384361e-02f, -9.86815766e-02f,
  -1.22782975e-01f, -3.92874330e-02f, -8.32732394e-02f, -4.60709445e-02f, 5.97776324e-02f, -5.38177490e-02f, -7.64783770e-02f, 3.61329764e-02f, -4.27422747e-02f, 8.57092813e-03f,
  1.82984453e-02f, -2.24187057e-02f, -2.05775853e-02f, 2.39163544e-02f, -4.31258120e-02f, -4.94025573e-02f, -5.16902618e-02f, -1.05121955e-02f, 1.43602388e-02f, -3.65841761e-02f,
  3.19408551e-02f, 4.49888129e-03f, -1.08095529e-02f, -4.42729518e-02f, -5.59115559e-02f, 1.67658478e-02f, -8.30642972e-03f, 1.98769718e-02f, -4.68825288e-02f, 1.09805372e-02f,
  -8.79074447e-03f, -6.92853425e-03f, 2.77734511e-02f, -2.61593168e-03f, 4.63123992e-02f, -2.28320882e-02f, -5.58869205e-02f, -4.68769856e-02f, 4.08159047e-02f, 9.78241712e-02f,
  -1.13795489e-01f, 3.52692790e-02f, -5.54925762e-02f, 1.85340289e-02f, -8.08051846e-04f, -1.04378993e-02f, 9.03420076e-02f, -8.85548219e-02f, 3.17162201e-02f, 3.70264947e-02f,
  -1.09194564e-02f, 2.22277381e-02f, -9.22091422e-05f, 5.46866171e-02f, -4.66414355e-02f, -7.69132748e-02f, 6.75000716e-04f, 3.89945507e-03f, 7.76283070e-02f, 6.62110075e-02f,
  -7.77604729e-02f, -8.85985978e-03f, 2.23053172e-02f, 2.15897691e-02f, -2.47669723e-02f, 3.81443053e-02f, 2.68492270e-02f, 9.35700834e-02f, 4.53670397e-02f, 3.05736018e-03f,
  2.39863917e-01f, 2.78356254e-01f, -2.85248961e-02f, 2.92442413e-03f, -4.97220866e-02f, -5.13225496e-02f, -1.16487354e-01f, 8.65915716e-02f, 1.52691975e-01f, 2.00400636e-01f,
  -2.07990892e-02f, 1.33370280e-01f, 1.29748620e-02f, 2.86710739e-01f, 1.68890469e-02f, 2.90959597e-01f, 2.66696215e-01f, 2.03236848e-01f, 1.70247138e-01f, 4.77955006e-02f,
  8.66008624e-02f, 1.00350954e-01f, 7.28360116e-02f, 1.00121628e-02f, 2.02258024e-02f, -2.46555638e-02f, 1.70160271e-03f, -2.06057534e-01f, -2.55578235e-02f, -8.08265209e-02f,
  9.26636904e-02f, 1.44251976e-02f, 3.37501019e-02f, 5.26161715e-02f, -1.78747512e-02f, -6.07120655e-02f, -6.38633296e-02f, -8.87567475e-02f, 5.34545071e-03f, -1.23084998e-02f,
  -5.61299548e-02f, 1.73928514e-02f, 3.46017145e-02f, 2.65403762e-02f, 4.47307378e-02f, 1.05843684e-02f, -1.19953547e-02f, -1.83358137e-02f, 3.50273587e-02f, 3.23808827e-02f,
  -4.72460315e-02f, -4.92244847e-02f, 3.07594892e-02f, 4.26737182e-02f, 2.04123762e-02f, 4.21144441e-02f, -2.59464439e-02f, -5.36591001e-02f, 1.55274582e-04f, 3.00601721e-02f,
  -3.64097692e-02f, -3.63865383e-02f, -9.64637380e-03f, 7.77438581e-02f, 3.59502025e-02f, -2.24444959e-02f, -1.26413712e-02f, -2.81539187e-02f, 3.77050601e-04f, 4.32184152e-02f,
  -2.15574484e-02f, -3.41074020e-02f, 3.40492278e-02f, -5.65570481e-02f, 3.65091041e-02f, -3.45224738e-02f, 6.63424432e-02f, -1.84035804e-02f, 6.28976226e-02f, 7.70355985e-02f,
  7.65715986e-02f, -4.03811149e-02f, 5.53146079e-02f, -4.19959472e-03f, 2.09788214e-02f, -2.88281310e-02f, 2.49103606e-02f, 1.00353576e-01f, -3.92312631e-02f, -1.11577706e-02f,
  1.34015813e-01f, 9.32120830e-02f, 3.25267174e-04f, 2.32233889e-02f, 3.27969268e-02f, 5.40272817e-02f, 5.84344519e-03f, 2.77593639e-02f, -3.50663364e-02f, 1.16231190e-02f,
  4.75678034e-03f, 2.27829311e-02f, -2.56177085e-03f, -4.73103710e-02f, -6.56159520e-02f, 4.29562218e-02f, -2.64338087e-02f, -3.51932123e-02f, -8.42206627e-02f, -3.63752544e-02f,
  1.88407488e-02f, -2.29039211e-02f, 3.31090465e-02f, 4.62403558e-02f, -2.50402670e-02f, -8.27028751e-02f, 1.06549421e-02f, -3.90061885e-02f, 6.51072189e-02f, -3.81432809e-02f,
  6.90186471e-02f, 4.04286832e-02f, 5.66653013e-02f, 3.14642042e-02f, 1.04236186e-01f, 1.73178464e-01f, 1.69717744e-01f, -4.59129661e-02f, -8.73316675e-02f, 1.16077252e-02f,
  1.14279829e-01f, 4.85607572e-02f, -1.46234140e-01f, 5.36573604e-02f, 1.09396465e-01f, -1.59007370e-01f, 1.37349397e-01f, 3.67977433e-02f, -8.79157707e-02f, 1.11783966e-02f,
  4.77340892e-02f, 1.43461362e-01f, -2.71572592e-03f, 7.38436431e-02f, 1.39098972e-01f, 9.74915083e-03f, -2.67621614e-02f, 8.06470290e-02f, 1.31518513e-01f, -8.73399153e-03f,
  -2.74616126e-02f, -5.50816813e-03f, 4.18640226e-02f, -1.85812209e-02f, 5.42594641e-02f, 3.11744865e-02f, 4.63678576e-02f, 9.23105627e-02f, -2.63545546e-03f, 3.69428396e-02f,
  1.19616361e-02f, -3.63364741e-02f, 8.66241381e-02f, 8.19914863e-02f, -8.06882903e-02f, -1.62755735e-02f, -1.75220333e-02f, 1.73622780e-02f, -6.07003607e-02f, -1.28990412e-02f,
  1.67605579e-02f, 6.70651942e-02f, -4.75040860e-02f, -5.71413934e-02f, -8.70174915e-02f, -2.76781674e-02f, -5.84583096e-02f, -5.38780056e-02f, 4.13316041e-02f, 5.65406345e-02f,
  5.36537822e-03f, -1.59737058e-02f, -2.76083313e-03f, 7.49368444e-02f, 1.34221641e-02f, -5.94424531e-02f, 6.16377685e-04f, 8.32600892e-03f, -2.88907830e-02f, -1.88712906e-02f,
  -5.98328039e-02f, -9.93120819e-02f, 2.04722639e-02f, -7.43809119e-02f, 2.53967680e-02f, 3.71158458e-02f, -4.01314460e-02f, 2.19127908e-02f, 2.84765922e-02f, -9.32485983e-02f,
  -9.56484228e-02f, 1.07866162e-02f, -8.31103101e-02f, -1.04707137e-01f, -1.48528619e-02f, 1.05405496e-02f, 4.93423901e-02f, -3.97846475e-02f, -5.65231591e-02f, 6.79511111e-03f,
  3.64275202e-02f, 8.61064047e-02f, -6.14243224e-02f, 6.17496967e-02f, 5.04707843e-02f, 1.70103218e-02f, -2.95431521e-02f, 6.42038286e-02f, -1.96071658e-02f, 3.20263803e-02f,
  -1.57522764e-02f, 1.03861578e-02f, -6.79126084e-02f, 5.54208793e-02f, 4.44944799e-02f, 4.52885032e-02f, -6.06520101e-02f, 2.41545662e-02f, 8.27007964e-02f, -6.70676259e-03f,
  -8.26854724e-03f, -7.24311545e-03f, -2.86233425e-02f, -6.76600486e-02f, 4.25985940e-02f, 9.90278870e-02f, -7.40992054e-02f, 1.20040298e-01f, 8.55110586e-03f, 1.10904574e-02f,
  2.64935885e-02f, -1.67591944e-01f, 1.58633471e-01f, -1.40249178e-01f, 2.59365976e-01f, 9.34207514e-02f, -6.97992817e-02f, 1.76019147e-02f, 5.55277467e-02f, -2.82906622e-01f,
  -5.86374737e-02f, -8.31549093e-02f, 3.07283783e-03f, 6.18273579e-02f, 2.45984077e-01f, 7.96809569e-02f, 4.49779853e-02f, -7.92804956e-02f, 7.43833035e-02f, -1.08588502e-01f,
  1.13542520e-01f, -1.12570478e-02f, 2.18861654e-01f, 1.55485179e-02f, 9.51613709e-02f, -1.73818871e-01f, -3.75530533e-02f, 6.62385896e-02f, -8.43112692e-02f, 9.05822068e-02f,
  5.03466986e-02f, -9.52832401e-02f, -6.21716902e-02f, -3.71616110e-02f, -4.42326022e-03f, -2.79358774e-03f, -5.13411872e-02f, 3.72629687e-02f, 5.55034876e-02f, 2.70425063e-02f,
  -9.57883745e-02f, 6.75009415e-02f, 5.23408800e-02f, -2.85043381e-02f, -1.77862141e-02f, 6.15876466e-02f, 9.99796838e-02f, 5.24412505e-02f, 3.51813845e-02f, 1.16639324e-01f,
  5.55525795e-02f, 9.57173482e-03f, 2.02759579e-02f, -1.04366928e-01f, 4.89137173e-02f, -4.54031825e-02f, 1.22442674e-02f, -5.62028447e-03f, 5.71129993e-02f, -1.92088187e-02f,
  -6.37201816e-02f, -4.84550335e-02f, 4.04362865e-02f, 6.90469220e-02f, 2.03459170e-02f, 8.14643279e-02f, 1.15414592e-03f, -1.44231226e-02f, 1.08124607e-03f, -6.61577657e-02f,
  1.65236071e-02f, -4.36502397e-02f, -4.94434275e-02f, 2.61253081e-02f, -4.12770174e-02f, -2.50504501e-02f, -5.92740290e-02f, 4.22348604e-02f, 4.33703400e-02f, 2.97579113e-02f,
  1.80938747e-02f, -5.97877242e-03f, -5.24978489e-02f, 2.99500916e-02f, 2.91953962e-02f, 1.21835025e-03f, -3.10920998e-02f, 4.14669104e-02f, -9.32940841e-03f, 3.62917446e-02f,
  -2.00387776e-01f, -2.61316180e-01f, 3.67037840e-02f, 4.57859635e-02f, -1.98997259e-02f, 1.13281785e-02f, -7.07397014e-02f, 7.96048045e-02f, -6.55712187e-02f, -2.19563544e-02f,
  1.51240602e-02f, -3.07712443e-02f, -2.31345762e-02f, 6.44203424e-02f, -7.30721727e-02f, 3.49632534e-03f, -1.32346615e-01f, -5.81893101e-02f, -6.15599789e-02f, -6.71682954e-02f,
  -1.76164862e-02f, 8.38534255e-03f, 1.12176789e-02f, 2.88732699e-03f, 6.72016246e-03f, 1.00158229e-02f, -4.41179350e-02f, -2.90482622e-02f, 4.74866405e-02f, -1.38492761e-02f,
  3.40388454e-02f, -1.81372359e-01f, -1.63384631e-01f, -3.51878665e-02f, 5.45765227e-03f, -7.08165914e-02f, 6.18771613e-02f, 4.55396622e-02f, -1.32180586e-01f, -2.03162469e-02f,
  6.44245520e-02f, -2.63621151e-01f, 5.24645261e-02f, -1.15474336e-01f, 9.92925838e-02f, 1.11805752e-01f, 3.23464558e-03f, -1.00653119e-01f, 2.52533741e-02f, -5.77881895e-02f,
  2.63266508e-02f, 6.32181987e-02f, 5.65554835e-02f, 9.15156156e-02f, 5.63326366e-02f, -5.43637462e-02f, 1.46001548e-01f, -4.82654348e-02f, -2.29936466e-02f, 5.22998013e-02f,
  -2.85211634e-02f, 3.33112665e-02f, 5.24115004e-03f, -4.26291227e-02f, 4.29574847e-02f, 2.90714204e-02f, 8.56102780e-02f, 6.45840019e-02f, 7.61102289e-02f, 3.34289558e-02f,
  -8.25720876e-02f, 2.02592947e-02f, -5.50313145e-02f, 4.96887006e-02f, 5.32006752e-03f, -9.72753912e-02f, 1.10871624e-02f, 1.02890246e-02f, -4.06198651e-02f, -3.07673402e-02f,
  -3.18847075e-02f, 1.57180261e-02f, -4.02370803e-02f, 7.87440389e-02f, -3.27941924e-02f, 6.58842251e-02f, 6.96286112e-02f, 6.71959817e-02f, 5.13682775e-02f, -1.06568605e-01f,
  -4.99062911e-02f, -6.31106198e-02f, -4.62353975e-02f, 2.97023654e-02f, 2.95391716e-02f, -6.19661808e-02f, 5.40383309e-02f, -1.38554238e-02f, 3.99273112e-02f, 3.23336944e-02f,
  -4.59114425e-02f, 1.57318451e-02f, 9.49594453e-02f, -4.34337594e-02f, -3.72921042e-02f, -9.16957036e-02f, -4.84549237e-04f, 5.37532009e-02f, -4.51279022e-02f, 4.78529669e-02f,
  -7.26491064e-02f, 2.34741028e-02f, -1.88905634e-02f, -3.98494527e-02f, -7.34452978e-02f, 7.10808858e-02f, 5.74182197e-02f, 3.45842214e-03f, 2.90733320e-03f, 3.10361013e-02f,
  7.45753795e-02f, 6.11712858e-02f, -1.00455575e-01f, 3.45637724e-02f, -4.77750897e-02f, -6.47704257e-03f, -2.14416794e-02f, 1.97132211e-02f, -9.50807929e-02f, 2.45040692e-02f,
  -6.97087944e-02f, -2.31768726e-03f, 5.40834665e-02f, -8.00165534e-03f, -5.10012656e-02f, -2.17924751e-02f, 2.83063743e-02f, -3.11639979e-02f, 2.17318870e-02f, -1.87220499e-02f,
  9.55610536e-03f, 2.58830916e-02f, 5.46472818e-02f, -1.17517747e-02f, 5.96900880e-02f, -9.41415131e-02f, -7.13611543e-02f, 2.42136382e-02f, -1.79285072e-02f, -4.64826524e-02f,
  1.57094970e-01f, 1.04474418e-01f, -2.84756388e-04f, 1.89510465e-01f, 7.88372532e-02f, 1.09009989e-01f, 1.69938318e-02f, 1.97546452e-01f, 3.31890546e-02f, 2.28112806e-02f,
  2.10317206e-02f, 3.43408473e-02f, -1.02294303e-01f, -7.27924928e-02f, -2.31408566e-01f, -1.60598427e-01f, -8.52524117e-02f, -1.47668412e-03f, -4.02678736e-02f, 8.56362209e-02f,
  -1.10169221e-03f, 4.54758517e-02f, -5.07803820e-03f, 4.82020639e-02f, 2.54554916e-02f, 1.53798029e-01f, -3.37996334e-02f, 9.26333070e-02f, 6.47770390e-02f, -1.79441553e-02f,
  -4.41509485e-02f, 1.29227981e-01f, -6.29946440e-02f, 3.45596559e-02f, 5.83120994e-02f, 4.31426615e-02f, -4.01933864e-02f, -3.74838784e-02f, -5.95392808e-02f, -5.94927557e-02f,
  2.85379849e-02f, -1.01081148e-01f, 2.32602712e-02f, -6.82432577e-02f, 2.69532036e-02f, 4.31570075e-02f, 3.88200651e-03f, 2.08128206e-02f, 5.20595722e-02f, -5.33434935e-03f,
  3.42821367e-02f, 7.46147241e-03f, 7.17457682e-02f, -1.13565782e-02f, -3.76040861e-02f, 2.64774561e-02f, -6.87571894e-03f, -5.34293391e-02f, 2.09479872e-02f, 5.64156212e-02f,
  -2.17179600e-02f, -2.46345364e-02f, 1.33935318e-04f, 3.98763036e-03f, 2.23992323e-03f, -6.22833753e-03f, -8.14976729e-03f, 3.72935794e-02f, 4.40840349e-02f, -4.93416414e-02f,
  -4.54261266e-02f, -1.87318623e-02f, 4.89175990e-02f, -7.94632640e-03f, 1.28962835e-02f, 5.01226168e-03f, -3.90427522e-02f, -9.63224098e-03f, -7.50108212e-02f, 5.81288524e-02f,
  8.09943452e-02f, -7.60364346e-03f, -2.60989778e-02f, -5.66668212e-02f, -9.57072992e-03f, 4.06169668e-02f, 4.56384756e-02f, 6.85168877e-02f, 3.99396376e-04f, 3.82902212e-02f,
  5.13179451e-02f, 1.03476055e-01f, 9.41683277e-02f, -3.98804545e-02f, 5.29221222e-02f, -5.43213962e-03f, 3.66376340e-02f, 1.55000910e-02f, 1.89598855e-02f, 5.66346087e-02f,
  1.40370186e-02f, 4.80531454e-02f, 1.07802739e-02f, 1.34394700e-02f, 4.57339697e-02f, 2.94491909e-02f, -2.68231332e-02f, 8.46550148e-03f, 7.18417857e-03f, 7.22475573e-02f,
  -2.12853644e-02f, -8.18072911e-03f, -2.88548996e-03f, 6.24038614e-02f, 3.76589783e-02f, -3.76532273e-03f, 5.96460700e-02f, -8.70683754e-04f, 5.72588146e-02f, -5.47576137e-02f,
  -4.94241454e-02f, 1.83704570e-01f, -2.27993235e-01f, -3.25302035e-01f, -9.99006927e-02f, 1.50573522e-01f, -7.66498130e-03f, -1.13487773e-01f, 1.71826803e-03f, 1.73136696e-01f,
  -4.27558199e-02f, 7.79886320e-02f, 1.36635706e-01f, -4.23734188e-02f, -9.72168595e-02f, 5.83099350e-02f, 8.19247738e-02f, 1.00359082e-01f, -2.58198031e-03f, -1.31012816e-02f,
  -1.28265873e-01f, 5.67350686e-02f, -2.59932458e-01f, -7.05365464e-02f, -1.51986361e-01f, -1.99583203e-01f, -1.79332286e-01f, -7.24027529e-02f, -1.26520187e-01f, -2.56902669e-02f,
  -6.76959977e-02f, 4.01608311e-02f, -1.13764115e-01f, 1.70348343e-02f, 6.88843727e-02f, -1.78629607e-02f, -4.02191244e-02f, -7.62970047e-03f, -9.18914825e-02f, 3.13028693e-02f,
  6.72007278e-02f, -4.37727980e-02f, -5.57150284e-04f, -2.81590968e-02f, 1.43531186e-03f, -9.68783647e-02f, 1.15833215e-01f, -1.79230031e-02f, 4.06806394e-02f, 1.56056304e-02f,
  7.01026917e-02f, 5.66975065e-02f, -9.07015651e-02f, 5.31174093e-02f, -5.00494521e-03f, 1.10820506e-03f, 5.66097014e-02f, 5.05254939e-02f, 4.87980098e-02f, 1.13551706e-01f,
  5.98136988e-03f, 1.37459338e-02f, -2.78846566e-02f, -1.01065179e-02f, -3.18134129e-02f, -5.95795140e-02f, 9.11778286e-02f, 1.52093954e-02f, 1.98023804e-02f, -4.05554064e-02f,
  -1.35455038e-02f, 2.46960465e-02f, 3.35870385e-02f, 3.68868075e-02f, 2.13857777e-02f, 4.31002751e-02f, -4.93508093e-02f, -1.55673400e-02f, -6.64778948e-02f, -4.21236083e-02f,
  -3.19751948e-02f, 2.03387067e-02f, -1.09919785e-02f, -2.54655369e-02f, -3.20610800e-03f, -7.39758089e-03f, -4.20627333e-02f, -4.18437645e-02f, -4.40255599e-03f, -1.72008723e-02f,
  7.01825917e-02f, 6.46412224e-02f, 1.33129780e-03f, 1.53916851e-02f, 4.40831296e-02f, 9.39985439e-02f, 1.08832046e-02f, 1.30072292e-02f, 4.99896333e-02f, -1.88867375e-02f,
  -2.06146408e-02f, -6.57081157e-02f, 3.15599404e-02f, -8.07339698e-03f, -5.00532277e-02f, -6.93544419e-03f, -1.97110213e-02f, -2.76859533e-02f, 2.43326891e-02f, 4.81712408e-02f,
  1.04863206e-02f, 2.04988122e-02f, -3.78733384e-03f, -1.89800337e-02f, 3.94930094e-02f, 5.21200225e-02f, 1.00722358e-01f, 1.48499617e-02f, -3.97426039e-02f, 2.65636388e-02f,
  8.30309018e-02f, -5.54755889e-03f, 1.52879711e-02f, -2.77052298e-02f, 1.33905008e-01f, 1.27444295e-02f, -8.76690745e-02f, -5.94405830e-02f, 6.09480888e-02f, -1.66852012e-01f,
  -5.03331609e-02f, 6.46367818e-02f, -7.24660158e-02f, -6.02076165e-02f, 2.09076717e-01f, 9.37013626e-02f, -3.27667296e-02f, -6.78173751e-02f, -2.98362914e-02f, 9.77825280e-03f,
  1.28428325e-01f, -3.30382586e-02f, 2.43525617e-02f, 4.76185940e-02f, -6.98738247e-02f, -1.74482688e-02f, 6.55622110e-02f, -5.46422936e-02f, 6.12424966e-03f, 9.79245007e-02f,
  5.91767244e-02f, -1.18659236e-01f, 5.54533377e-02f, -6.68937936e-02f, -3.42233442e-02f, 1.95639720e-03f, 3.18076797e-02f, 4.42534871e-02f, -4.90417928e-02f, 1.49568161e-02f,
  4.95030098e-02f, -8.35166052e-02f, -5.81244156e-02f, -6.15991792e-03f, 2.97671687e-02f, 4.14291918e-02f, 6.34308085e-02f, 7.28500783e-02f, 2.01021582e-02f, 9.92786288e-02f,
  5.23796752e-02f, -5.50217275e-03f, 1.18523801e-03f, -6.50839582e-02f, -5.05798832e-02f, -1.48651912e-03f, -3.57775129e-02f, 3.18358429e-02f, -2.29489245e-02f, -5.35128936e-02f,
  -6.78031594e-02f, 1.67124048e-02f, -1.20983813e-02f, -2.09228098e-02f, -2.17894986e-02f, -5.47654666e-02f, -3.13167498e-02f, 3.06295007e-02f, 2.76945904e-02f, -5.52937314e-02f,
  2.28260900e-03f, -1.90457478e-02f, -7.62839988e-02f, -7.99985416e-03f, 1.57182757e-02f, 2.97719818e-02f, -8.14334974e-02f, -2.57090181e-02f, -3.44824581e-03f, -4.40305695e-02f,
  -6.18050992e-02f, -9.58629251e-02f, -1.38862515e-02f, 5.06593920e-02f, -4.43631820e-02f, 5.05194142e-02f, 4.56953607e-02f, -5.79952188e-02f, -6.23025261e-02f, 5.67865856e-02f,
  -6.90744594e-02f, -1.79897249e-01f, -5.49750440e-02f, 5.38561353e-03f, -2.47743428e-02f, -1.90078504e-02f, 8.01877305e-02f, -2.01719850e-02f, 3.25157531e-02f, 6.55043311e-03f,
  -1.31025966e-02f, 7.01339263e-03f, 5.81700876e-02f, -5.37380651e-02f, 8.52954462e-02f, 5.16722500e-02f, 3.52622904e-02f, -5.29799536e-02f, -6.65023923e-02f, -4.26457729e-03f,
  2.19323076e-02f, 1.25507880e-02f, -1.35687189e-02f, -9.97488014e-03f, 3.01856245e-03f, -3.73428613e-02f, 3.17079201e-02f, 6.33290857e-02f, -2.91125756e-02f, -5.33256121e-02f,
  -7.50506297e-02f, -2.27473661e-01f, 6.49635121e-02f, -6.60927072e-02f, 8.23468864e-02f, 6.83015138e-02f, 4.86094169e-02f, -1.02330875e-02f, 8.16160068e-02f, -5.09940870e-02f,
  3.86861600e-02f, -1.85079217e-01f, 7.93367326e-02f, 2.59464849e-02f, 2.09930480e-01f, 4.16113101e-02f, 6.34148195e-02f, -7.07771331e-02f, 7.80616552e-02f, -4.69827428e-02f,
  -3.56326513e-02f, -1.08563174e-02f, 1.57176778e-01f, -2.19594184e-02f, -7.84672946e-02f, -9.82625559e-02f, -8.66535399e-03f, 5.19770049e-02f, 3.79295950e-03f, 4.60150093e-02f,
  4.85588126e-02f, -7.66587928e-02f, 9.97969508e-03f, 4.83347960e-02f, 3.91009003e-02f, 7.40512162e-02f, -9.56193805e-02f, -5.08091133e-03f, -4.63560894e-02f, -1.06016338e-01f,
  -3.34922820e-02f, -1.39845889e-02f, -5.44500947e-02f, 3.47321145e-02f, 6.99155480e-02f, -1.75040457e-02f, -7.78060183e-02f, 6.33336753e-02f, -8.50504860e-02f, -2.90913060e-02f,
  5.18010110e-02f, 6.67197704e-02f, 1.85933989e-02f, 2.17751749e-02f, -1.37507180e-02f, 2.20527407e-02f, 4.33907053e-03f, -9.07481182e-03f, -2.94988286e-02f, 3.39895487e-02f,
  3.73033732e-02f, -4.54562269e-02f, 3.03526353e-02f, 3.59930620e-02f, -3.47485989e-02f, -2.27449741e-02f, -3.33441123e-02f, 3.28385308e-02f, -1.74164716e-02f, 1.03367046e-01f,
  -8.26599970e-02f, 5.24339527e-02f, 2.85488069e-02f, 3.97833288e-02f, -3.92410047e-02f, 5.14290631e-02f, -4.53877896e-02f, -6.98906705e-02f, -6.52014613e-02f, 1.97046809e-02f,
  2.98209917e-02f, 2.54115872e-02f, 1.40419509e-02f, 4.86380942e-02f, 8.37317184e-02f, 1.47426138e-02f, -3.57455090e-02f, 8.46918523e-02f, 4.55280766e-02f, -9.24675539e-02f,
  1.70845538e-02f, -1.76654205e-01f, -6.56217635e-02f, -1.29796779e-02f, -2.20342353e-03f, -1.71112316e-03f, 1.88468639e-02f, 6.93094730e-03f, 4.50188406e-02f, -9.75096133e-03f,
  -3.33480686e-02f, -8.07804894e-03f, 2.37118732e-02f, -1.92827303e-02f, 6.17098659e-02f, -4.86769900e-02f, 1.83871470e-03f, -3.45075466e-02f, 3.47355455e-02f, 4.98358645e-02f,
  5.19559868e-02f, 2.10468974e-02f, -1.92657169e-02f, 7.41016236e-04f, -4.48443741e-02f, 1.14337197e-02f, -5.93947573e-03f, -1.13092467e-01f, 3.30860429e-02f, 4.67150472e-03f,
  1.71553075e-01f, 1.60387576e-01f, -6.47093281e-02f, 1.82547748e-01f, -1.52920596e-02f, 8.48207846e-02f, 1.41155198e-01f, 4.62781601e-02f, 6.37421459e-02f, 1.35435328e-01f,
  -8.94610398e-03f, 5.04132695e-02f, 5.42415269e-02f, 5.52964285e-02f, 4.66134213e-02f, 8.47978517e-03f, 7.67196566e-02f, 9.94795859e-02f, 1.07958578e-02f, 1.95031390e-01f,
  -6.20482229e-02f, 1.37574285e-01f, -3.97436209e-02f, 3.51091437e-02f, 1.30387649e-01f, 4.00185212e-02f, 6.97716922e-02f, -4.86948267e-02f, -1.60379596e-02f, -1.61416233e-01f,
  1.70519054e-01f, 1.68177664e-01f, 1.75389915e-03f, -1.68642355e-03f, 4.80820276e-02f, 1.01285549e-02f, 3.59743200e-02f, -6.17497079e-02f, -2.85563264e-02f, 1.20773455e-02f,
  3.85125130e-02f, -2.19537430e-02f, -7.70035088e-02f, 1.03129065e-02f, 4.22052108e-02f, -3.56766507e-02f, -7.15353265e-02f, 3.53995971e-02f, -4.45415033e-03f, 4.78659645e-02f,
  -6.64696693e-02f, -6.59983754e-02f, 5.62112837e-04f, -2.89662797e-02f, -9.51295570e-02f, -5.68560371e-03f, 1.42639549e-02f, 1.66539699e-02f, 9.69131440e-02f, -2.59593502e-03f,
  -1.55367320e-02f, 6.05382351e-03f, -1.46791879e-02f, -8.37653223e-03f, 3.00040934e-02f, 2.35364996e-02f, -2.71313358e-02f, -2.18700934e-02f, -1.71291176e-02f, 7.15741962e-02f,
  -4.23047040e-03f, -1.44160185e-02f, -5.29409992e-03f, -1.95322260e-02f, 5.69617096e-03f, 4.38892022e-02f, -3.62903029e-02f, -1.10478653e-02f, -3.88305746e-02f, -7.26376101e-02f,
  2.96784621e-02f, -4.57733609e-02f, -5.30379042e-02f, -8.97690840e-03f, -2.82710399e-02f, -1.96477491e-02f, 2.73362380e-02f, 8.53604600e-02f, -4.06242609e-02f, -5.34200445e-02f,
  2.94562250e-01f, 2.11133674e-01f, 3.31671871e-02f, 7.83246830e-02f, -3.12995836e-02f, 5.69770895e-02f, -1.26124751e-02f, -4.24315184e-02f, 7.11228922e-02f, -2.20876979e-03f,
  5.88027586e-04f, -2.25251745e-02f, 1.86169818e-02f, 2.71553583e-02f, 3.95486578e-02f, -6.73806202e-03f, 1.59069039e-02f, 1.10676792e-02f, 7.70747587e-02f, -2.51162387e-02f,
  7.81448632e-02f, 7.08187371e-02f, 2.24142168e-02f, 4.42417189e-02f, -2.15411489e-03f, -1.92726974e-03f, 4.20873724e-02f, -6.28378913e-02f, -5.88283017e-02f, -3.90592441e-02f,
  3.24263126e-01f, 1.00424558e-01f, 2.90640056e-01f, 2.87026346e-01f, -7.85147920e-02f, 8.03079531e-02f, 9.14160237e-02f, 7.79376626e-02f, 2.66315728e-01f, -3.11490651e-02f,
  -1.35208219e-01f, 1.07183971e-01f, -1.29854307e-01f, 1.44954100e-01f, 8.11649784e-02f, -9.09159426e-03f, 1.34965733e-01f, -7.92370178e-03f, -3.32367979e-02f, -1.31209446e-02f,
  2.14428566e-02f, -2.46266618e-01f, -2.19196603e-02f, -1.37299538e-01f, 1.51811205e-02f, -1.94339976e-02f, -3.30860950e-02f, -6.32509366e-02f, 1.73089672e-02f, 7.70148076e-03f,
  -4.45013419e-02f, -8.41906816e-02f, 3.08217611e-02f, 5.36615141e-02f, 2.58619916e-02f, 5.18470816e-02f, -2.91266367e-02f, -1.28274448e-02f, -9.64643247e-03f, 2.02782620e-02f,
  2.69959942e-02f, 3.74979489e-02f, 1.83052327e-02f, -4.27548476e-02f, 8.04025009e-02f, 4.31783199e-02f, -1.61826704e-02f, 7.10928813e-02f, 8.40215907e-02f, -5.54078221e-02f,
  7.95324072e-02f, 2.59653255e-02f, 2.72847172e-02f, 2.76314821e-02f, 3.49244177e-02f, -1.77527387e-02f, -5.74560240e-02f, 8.79186729e-04f, 2.17523240e-02f, 3.39961611e-02f,
  -3.10598463e-02f, -8.53886595e-04f, -1.03853373e-02f, 2.22506393e-02f, 4.52208817e-02f, -9.71315429e-02f, -4.33148108e-02f, -2.19191927e-02f, -6.70815678e-03f, -9.99980513e-03f,
  8.12127963e-02f, -5.60219586e-02f, -2.07963726e-03f, 2.06099879e-02f, 1.34230675e-02f, -2.93641258e-02f, 7.88644031e-02f, -5.91439828e-02f, 3.22937705e-02f, 3.82180475e-02f,
  -2.98728216e-02f, 2.98180915e-02f, -2.06271186e-02f, -3.64583023e-02f, 2.79849600e-02f, -4.58117351e-02f, 2.54321843e-03f, 6.10448122e-02f, -2.24047024e-02f, -2.85772849e-02f,
  -1.49754053e-02f, 2.78091375e-02f, 2.11484078e-03f, -3.58418189e-02f, -4.63329405e-02f, 2.10416913e-02f, 5.36873750e-02f, 5.21376356e-02f, 3.24732438e-02f, 8.32270671e-05f,
  -3.72073390e-02f, -5.99160232e-03f, 7.05806240e-02f, 2.76497081e-02f, -2.84452010e-02f, -2.87792888e-02f, -2.15699081e-03f, 7.39348829e-02f, -5.67060784e-02f, -1.17281685e-02f,
  -5.04122451e-02f, 1.39912311e-02f, -2.31707096e-02f, -3.24923992e-02f, -3.30739394e-02f, 6.20549405e-03f, 5.31786494e-02f, 4.04501557e-02f, -7.10582286e-02f, 3.07079330e-02f,
  -1.38267308e-01f, -1.06369779e-01f, -5.00328690e-02f, -1.45364299e-01f, -4.88816462e-02f, 2.28694174e-03f, 5.41604124e-02f, -2.92800106e-02f, -1.28300339e-01f, 1.62415914e-02f,
  5.07375598e-02f, -3.04543115e-02f, 7.94492587e-02f, -3.70307118e-02f, 1.26460195e-02f, 4.93630506e-02f, -1.65054485e-01f, 5.01833558e-02f, -6.35580495e-02f, 6.43752050e-03f,
  1.81594037e-03f, 2.70216167e-02f, 2.36757156e-02f, -3.23358737e-02f, -5.15830982e-03f, -7.70568252e-02f, 1.67874619e-01f, 1.04579926e-01f, 6.59641111e-03f, 1.41033484e-02f,
  7.82158300e-02f, 8.95404443e-02f, -8.84294957e-02f, 6.43145591e-02f, 5.07053286e-02f, 1.51921296e-03f, 5.57220355e-03f, 4.52808701e-02f, -5.49076125e-02f, -1.24547854e-02f,
  -2.53252760e-02f, -2.72333957e-02f, 3.26330103e-02f, -2.74472144e-02f, -7.27655739e-02f, -1.80141833e-02f, 1.30561432e-02f, 7.71744698e-02f, -3.63019519e-02f, -5.01343757e-02f,
  -9.90655869e-02f, -7.59662166e-02f, -3.64446603e-02f, -7.57076815e-02f, -7.74297193e-02f, 3.05286590e-02f, -8.88598859e-02f, -4.40157056e-02f, -8.98245946e-02f, -1.08721219e-02f,
  6.89351931e-02f, -2.54068580e-02f, -6.91720024e-02f, 3.06853820e-02f, 5.50092617e-03f, 3.79705429e-02f, -3.65938097e-02f, 1.43345594e-02f, -1.09958276e-01f, -6.90841377e-02f,
  6.25145510e-02f, 2.43085958e-02f, -1.51942717e-02f, 1.98313054e-02f, -7.56113455e-02f, 1.95337180e-02f, -2.72071213e-02f, -8.28011800e-03f, 3.03936973e-02f, 3.25372554e-02f,
  -2.58411672e-02f, 3.94528685e-03f, 4.69721556e-02f, -4.05405201e-02f, -7.17761293e-02f, 6.45436719e-02f, -2.26512584e-05f, -3.39390114e-02f, 1.04519702e-01f, 1.08631849e-01f,
  1.87048707e-02f, -8.97520408e-02f, -8.41233805e-02f, -4.53504249e-02f, 4.47154827e-02f, -2.62829792e-02f, 5.22187203e-02f, -6.09708205e-02f, -5.60747832e-02f, -7.32752085e-02f,
  -2.30858140e-02f, -2.33128183e-02f, 2.31430288e-02f, 2.54687387e-02f, 7.74099156e-02f, -7.50938356e-02f, -3.22990045e-02f, 6.35411292e-02f, -2.93203685e-02f, 1.71925630e-02f,
  3.82622592e-02f, 5.69844991e-02f, -3.56659405e-02f, -3.83520573e-02f, 4.66183200e-02f, 4.41933842e-03f, -1.03866579e-02f, -3.90085764e-02f, 2.72744931e-02f, -5.29999658e-02f,
  -2.10294545e-01f, -1.10391028e-01f, -7.03469589e-02f, -4.21800353e-02f, -1.23504311e-01f, -1.31892085e-01f, 3.72502161e-03f, 2.95578670e-02f, -1.68727890e-01f, 4.08680663e-02f,
  2.48365793e-02f, -3.39250006e-02f, 7.65522495e-02f, -1.08164243e-01f, 8.38247240e-02f, 5.07940352e-02f, -5.72039261e-02f, -2.71547716e-02f, 1.08206548e-01f, -1.22122422e-01f,
  1.01544797e-01f, 3.92895639e-02f, 1.59822151e-01f, 9.43309143e-02f, 7.71896318e-02f, 5.66353537e-02f, 1.07500337e-01f, 1.34556979e-01f, 8.49534944e-02f, 1.19264998e-01f,
  -1.08238664e-02f, -9.26224440e-02f, -5.60234450e-02f, 6.90559484e-03f, -3.79318697e-03f, -7.15428814e-02f, 7.92747959e-02f, -2.59170160e-02f, -6.41947761e-02f, -5.83593547e-02f,
  -1.18994340e-02f, 6.39225617e-02f, -4.25981432e-02f, -4.48121838e-02f, -4.02342565e-02f, 2.65977923e-02f, -2.89590340e-02f, -4.92145270e-02f, 4.96231988e-02f, -4.44230624e-02f,
  4.99936938e-02f, -1.07250391e-02f, -1.40727712e-02f, -2.67481785e-02f, -9.27670766e-03f, -6.30369261e-02f, -1.53021291e-02f, 1.02554843e-01f, 5.37495278e-02f, 8.51005986e-02f,
  -8.14197063e-02f, -4.75579947e-02f, -2.20961664e-02f, 4.64367233e-02f, -1.96716040e-02f, -1.28338598e-02f, 2.11819001e-02f, 1.04486488e-01f, 1.11764958e-02f, 3.55504081e-02f,
  -9.97145250e-02f, 5.60878366e-02f, 3.99232358e-02f, -1.05775289e-01f, 4.03705910e-02f, -1.22110516e-01f, 4.27058898e-03f, 1.13644511e-01f, -7.66899530e-03f, 2.26603486e-02f,
  2.62980498e-02f, -2.70024538e-02f, -6.01903759e-02f, 1.27417194e-02f, -1.23044942e-03f, 4.61991727e-02f, 3.36558893e-02f, 7.37987533e-02f, 2.17721909e-02f, 6.40004873e-02f,
  -8.05308297e-02f, -1.01475939e-01f, 1.87957920e-02f, -4.77814078e-02f, -8.26834608e-03f, -5.70227858e-03f, -5.57258204e-02f, -8.05511102e-02f, 1.58301294e-02f, 5.35587743e-02f,
  4.96318452e-02f, -1.24707930e-01f, 3.83424573e-03f, 6.01084158e-02f, 3.71379443e-02f, 2.30522417e-02f, -7.63571123e-03f, 1.45278024e-02f, 4.88753207e-02f, 9.05108377e-02f,
  -1.16502289e-02f, -4.80159111e-02f, 9.78178531e-02f, 4.40914258e-02f, 1.10938149e-02f, -9.82649252e-03f, 8.88023973e-02f, -2.45159119e-02f, 2.72339638e-02f, -3.45757902e-02f,
  1.28694922e-01f, 2.39971891e-01f, 2.16556326e-01f, 1.96714569e-02f, 1.15040466e-01f, 4.82605845e-02f, 1.22612212e-02f, 1.45494670e-01f, 1.45080522e-01f, -1.87894687e-01f,
  -6.28139898e-02f, -4.78267893e-02f, 4.07169461e-02f, -9.71240178e-02f, -2.27213696e-01f, 2.92350706e-02f, 6.69885650e-02f, 2.76891254e-02f, 2.23614961e-01f, 3.65060493e-02f,
  1.22956984e-01f, -1.39402434e-01f, 1.02454744e-01f, 1.03381708e-01f, 8.89181495e-02f, 7.81617910e-02f, -1.51578054e-01f, 8.94680768e-02f, -2.65761223e-02f, -6.22113273e-02f,
  4.93181311e-03f, 3.12217996e-02f, 1.21873423e-01f, 9.13779289e-02f, 1.26659200e-01f, -8.39347136e-04f, -2.68565826e-02f, -4.26735282e-02f, 7.63624161e-03f, 2.76491027e-02f,
  -2.61345003e-02f, 5.18304529e-03f, -1.63988024e-02f, 1.20512536e-02f, 5.10431342e-02f, 3.40244845e-02f, 6.46819696e-02f, 9.16113630e-02f, -5.44069568e-04f, -9.68967099e-03f,
  5.13655283e-02f, -1.06687872e-02f, -1.87511966e-02f, -9.59217623e-02f, -4.56995629e-02f, 2.82393731e-02f, 3.33477817e-02f, 6.70653805e-02f, -5.69350831e-03f, -7.80707374e-02f,
  -4.09256108e-02f, 5.88798597e-02f, -2.26755217e-02f, -4.63556312e-02f, -6.34692907e-02f, -4.53755818e-02f, 2.94061620e-02f, -9.58580989e-03f, 3.33478535e-03f, -3.63584459e-02f,
  -3.60308066e-02f, 1.30391179e-03f, 1.01722389e-01f, 6.06731102e-02f, -1.59401391e-02f, -6.96627796e-02f, -4.45633382e-02f, 9.19196978e-02f, 6.56732470e-02f, 5.70669807e-02f,
  -5.12197353e-02f, -1.24491192e-02f, -2.63542626e-02f, 2.50216015e-02f, -3.09826657e-02f, 3.48167904e-02f, -2.45964248e-03f, 2.49514282e-02f, 4.18603793e-02f, 4.71948236e-02f,
  2.05801744e-02f, -3.70016471e-02f, 2.00422127e-02f, -4.82635647e-02f, -1.64894443e-02f, -7.61520956e-03f, 2.11253110e-02f, 2.07892545e-02f, -6.35149181e-02f, -8.75664204e-02f,
  -2.95684971e-02f, -6.29953071e-02f, -3.90314944e-02f, 2.33306792e-02f, -2.17396300e-02f, -4.21479158e-02f, 3.19525562e-02f, -3.11792623e-02f, 6.38774270e-03f, 1.42573181e-03f,
  -2.09279964e-03f, -4.53244597e-02f, -7.64346346e-02f, 3.18185911e-02f, 1.57853141e-02f, -6.07360303e-02f, -3.14875133e-02f, 4.96848822e-02f, -1.88500586e-03f, 1.37354219e-02f,
  5.15038371e-02f, 1.55858934e-01f, 7.28102550e-02f, 2.35166952e-01f, -6.32310146e-03f, 2.32248589e-01f, 3.15725297e-01f, -3.80255394e-02f, -1.24262840e-01f, 1.76079482e-01f,
  1.86410040e-01f, -8.43575448e-02f, 4.90777008e-02f, 2.88215429e-01f, 1.79627672e-01f, 4.13177721e-02f, 1.95650041e-01f, 1.82941094e-01f, -7.98874274e-02f, -3.29118595e-02f,
  7.23260045e-02f, 2.00878412e-01f, 5.96278831e-02f, -5.09255391e-04f, 5.06444871e-02f, -6.84668422e-02f, 9.26021748e-05f, -1.23467809e-02f, 2.01488286e-01f, 9.42266732e-02f,
  -9.58838128e-03f, -3.84656638e-02f, 9.23735555e-04f, 4.01879512e-02f, 4.80052531e-02f, 8.40751380e-02f, 1.14163710e-02f, -1.77724995e-02f, -5.87849058e-02f, -1.94664411e-02f,
  1.42621091e-02f, -9.63827819e-02f, -3.23738679e-02f, -3.29647702e-03f, -4.66799848e-02f, -2.79409103e-02f, 6.25878619e-03f, -6.07805662e-02f, 4.32990342e-02f, -4.98150475e-02f,
  -1.02632884e-02f, 8.65109917e-03f, 1.91292185e-02f, -2.18105912e-02f, -1.46303861e-03f, -3.25478278e-02f, 3.57316546e-02f, -3.79828475e-02f, -8.11230242e-02f, 1.41123217e-02f,
  -2.22739764e-03f, -1.23237621e-03f, -2.87326537e-02f, 5.14495419e-03f, -2.80304886e-02f, 4.62786071e-02f, 1.48404483e-02f, 1.85561813e-02f, 1.80203188e-02f, 3.91144454e-02f,
  1.16073526e-02f, -4.31432761e-02f, 3.57144736e-02f, 4.16887812e-02f, 8.88083689e-03f, 1.49910746e-03f, 6.47296160e-02f, 1.02399457e-02f, 6.81021661e-02f, 6.28317297e-02f,
  9.54792544e-04f, -1.26944790e-02f, 4.84680459e-02f, 2.85954140e-02f, -1.90621205e-02f, 4.79610590e-03f, 5.60113452e-02f, 3.30465427e-03f, -7.26243258e-02f, 2.85521969e-02f,
  1.36583284e-01f, -2.26678196e-02f, -5.26207387e-02f, 1.51104005e-02f, -9.53386817e-03f, -7.45164528e-02f, 5.84691949e-02f, -1.23058259e-02f, 6.98992535e-02f, -5.20813558e-03f,
  8.95948634e-02f, 8.72668326e-02f, 1.26567101e-02f, 5.89363985e-02f, 3.53480577e-02f, 7.70053193e-02f, 4.58241329e-02f, 1.07226977e-02f, -3.40774730e-02f, -1.40111726e-02f,
  5.68897231e-03f, -5.77753149e-02f, -5.63145317e-02f, -1.11829024e-02f, 6.53423667e-02f, 1.75054241e-02f, -7.99885616e-02f, -1.74292531e-02f, 4.49217781e-02f, 1.88090326e-03f,
  6.10342026e-02f, 2.55367104e-02f, -3.61286476e-02f, -9.95456651e-02f, -6.08694591e-02f, -2.65037477e-01f, -2.19946742e-01f, 4.71170507e-02f, 2.02197239e-01f, 3.31505723e-02f,
  -1.38611346e-01f, 1.35980561e-01f, 7.10087046e-02f, -1.24017380e-01f, -5.74146435e-02f, -7.57861286e-02f, -2.20216632e-01f, -7.94044435e-02f, 3.79032269e-02f, -7.89358988e-02f,
  -2.62011532e-02f, -1.52461633e-01f, -1.25206262e-01f, -6.16214760e-02f, -9.53939259e-02f, 7.36674741e-02f, 3.44453193e-02f, 3.27212326e-02f, -7.10160211e-02f, 1.04153112e-01f,
  -2.17311736e-02f, 5.01183160e-02f, -2.69243238e-03f, 1.15800552e-01f, -6.86607435e-02f, -1.54917315e-02f, -6.56190217e-02f, -1.83114484e-02f, 1.90441217e-02f, -2.85476632e-02f,
  5.05581871e-02f, 2.73971986e-02f, -1.52793527e-03f, 4.47922572e-02f, -1.73411462e-02f, 1.16161101e-01f, 1.40019944e-02f, -6.08255900e-02f, -3.84467617e-02f, -3.36630736e-03f,
  -2.20666844e-02f, -7.91172311e-02f, -6.37625158e-02f, -8.84389356e-02f, 6.32597655e-02f, -6.53974898e-03f, -9.76794865e-03f, 2.28204802e-02f, -5.43686934e-02f, -6.99027954e-03f,
  2.64300266e-03f, 9.91183519e-03f, -7.48237967e-02f, 8.65323469e-02f, -5.60369268e-02f, 7.94173330e-02f, 5.06128073e-02f, 2.09825411e-02f, 6.08201064e-02f, 3.50045934e-02f,
  -8.33374821e-03f, 8.20989534e-02f, -3.37685533e-02f, 9.04223416e-03f, -7.80635253e-02f, 7.33417794e-02f, 1.65117867e-02f, 2.23836571e-04f, 3.64856534e-02f, -1.85646545e-02f,
  -1.89672913e-02f, -1.11757480e-01f, 5.41835092e-02f, -8.34657475e-02f, 2.40994152e-02f, 7.56505504e-02f, 2.03606635e-02f, 1.58446236e-03f, -3.58859673e-02f, -5.71331121e-02f,
  -1.67945147e-01f, -1.72924787e-01f, 1.52795017e-02f, -2.95821298e-03f, -2.31496412e-02f, 1.06818043e-02f, 7.33176470e-02f, 3.78800295e-02f, -2.94381902e-02f, 2.30810256e-03f,
  -5.22269160e-02f, 2.20502671e-02f, -7.78774470e-02f, -7.99816288e-03f, 4.76739444e-02f, -4.53350805e-02f, -3.13237682e-02f, -6.42905086e-02f, -6.83689117e-02f, 7.73866996e-02f,
  -7.38271847e-02f, -4.94585978e-03f, 4.27698568e-02f, -3.80884111e-02f, -1.34314857e-02f, 7.78551325e-02f, -6.75935624e-03f, -4.53505665e-02f, 3.89396981e-03f, 5.21375984e-02f,
  -5.06171100e-02f, 1.72994345e-01f, 1.04478426e-01f, -6.68800548e-02f, 8.05629324e-03f, 4.66787554e-02f, -1.90949187e-01f, 1.16082430e-01f, -3.73155735e-02f, 1.84753150e-01f,
  -7.53125697e-02f, 1.84625864e-01f, 1.16124243e-01f, 1.05619267e-01f, -1.58485204e-01f, 3.81983705e-02f, -1.07875742e-01f, 3.28545310e-02f, -4.01406288e-02f, 1.03211597e-01f,
  -1.41986594e-01f, -6.39508888e-02f, 1.88458506e-02f, 9.19567049e-02f, -2.75764782e-02f, -1.29794879e-02f, -7.51874298e-02f, 4.64384928e-02f, -3.08312736e-02f, 3.75936925e-02f,
  -2.38748230e-02f, -2.77815312e-02f, 7.15518892e-02f, 3.96609418e-02f, 1.42183090e-02f, 7.03965873e-02f, -7.56883547e-02f, -1.98773239e-02f, 2.10459824e-04f, 4.12450992e-02f,
  -3.18901017e-02f, 9.09016207e-02f, -2.08204314e-02f, -4.41487990e-02f, 9.71530005e-03f, 3.70889902e-02f, -3.34302336e-02f, -3.61880548e-02f, 4.08274913e-03f, -4.66289446e-02f,
  8.35895166e-02f, -2.59706136e-02f, 1.67023893e-02f, -1.45534901e-02f, -6.21540006e-03f, -2.93837041e-02f, -1.80382933e-02f, 3.75741883e-03f, -6.14916272e-02f, 1.00863948e-01f,
  1.45267202e-02f, -9.36435312e-02f, -5.27311675e-02f, 6.39196038e-02f, -4.18722630e-02f, -4.81566191e-02f, -8.38162377e-02f, -1.21098101e-01f, -5.36018498e-02f, 2.20012832e-02f,
  -2.76134051e-02f, 3.49381119e-02f, -5.10013551e-02f, -2.83436067e-02f, 2.22753342e-02f, -5.45954704e-02f, 1.75010022e-02f, 5.64860320e-03f, -1.47667285e-02f, -2.42942274e-02f,
  -2.45752442e-03f, -7.17184623e-04f, 8.69036373e-03f, -6.02357509e-03f, 1.42020974e-02f, 5.70442760e-03f, 1.98049005e-02f, 4.37457636e-02f, 4.55276342e-03f, -6.46021888e-02f,
  1.64623410e-02f, -7.79467002e-02f, -7.18505830e-02f, 3.24522406e-02f, -2.82817036e-02f, 3.98353823e-02f, 5.77351041e-02f, -2.89247222e-02f, 1.17891049e-02f, 2.54626591e-02f,
  -3.91301187e-03f, -7.19546750e-02f, -2.41147280e-02f, -5.26432246e-02f, -3.28759700e-02f, -4.79438342e-02f, 3.43787670e-03f, 1.12879695e-03f, 6.62478735e-04f, -6.38073385e-02f,
  -1.24994235e-03f, -1.86016187e-02f, -7.46535733e-02f, 3.80734801e-02f, 1.49761243e-02f, -2.65548639e-02f, 2.01309752e-02f, 7.29309395e-02f, 1.15981169e-01f, 5.08438498e-02f,
  2.63504148e-01f, 4.64741364e-02f, 2.03414988e-02f, 2.99820304e-01f, 1.26168653e-01f, 1.64682522e-01f, 1.34845236e-02f, 1.63849697e-01f, 1.86843216e-01f, 8.47484469e-02f,
  1.45700365e-01f, 2.08912250e-02f, -1.17763683e-01f, 1.77777652e-02f, 8.63316804e-02f, -1.23668365e-01f, 1.79150119e-01f, 6.95192367e-02f, -2.69814674e-02f, 9.91872400e-02f,
  7.09691122e-02f, 1.56423226e-01f, 1.38954213e-02f, 2.50896271e-02f, 9.05970559e-02f, 7.80399442e-02f, -2.18014233e-02f, -2.25187279e-02f, 1.93136990e-01f, 2.51542665e-02f,
  -4.08738554e-02f, -1.50586560e-01f, -7.36308023e-02f, -5.02172820e-02f, -8.20002146e-03f, 1.03760045e-02f, 5.02678659e-03f, -8.78644548e-03f, -4.68337210e-04f, 6.70149848e-02f,
  1.44184027e-02f, -8.06995481e-03f, 3.33775729e-02f, -6.81839958e-02f, -7.63964979e-03f, 4.25620601e-02f, -6.44288072e-03f, -2.90872212e-02f, -2.42994782e-02f, -6.17920561e-03f,
  -8.06533992e-02f, -2.54620574e-02f, 2.27156170e-02f, -4.18302231e-02f, 2.82853022e-02f, -9.58339032e-03f, 1.88279413e-02f, -2.54255272e-02f, 7.03771710e-02f, 5.79741560e-02f,
  -5.72473276e-03f, -6.96466714e-02f, -6.37919903e-02f, -1.49132321e-02f, 1.42319696e-02f, 3.43590155e-02f, 7.65757337e-02f, 6.20568777e-03f, -5.70858419e-02f, -2.37127934e-02f,
  6.14175573e-02f, 9.35986340e-02f, -1.70436390e-02f, 3.59730683e-02f, -4.46764454e-02f, -3.12543474e-02f, -8.38780925e-02f, 4.30990383e-02f, 2.84175817e-02f, -7.04502165e-02f,
  1.23072730e-03f, 6.25749305e-02f, -2.31896061e-02f, 7.29700327e-02f, -4.93578473e-03f, 5.40829375e-02f, 3.28053199e-02f, 5.65496348e-02f, 4.15121578e-02f, 7.45162135e-03f,
  1.89978793e-01f, 1.59642518e-01f, -9.98530351e-03f, 2.48758085e-02f, -5.76072000e-02f, 6.35131542e-03f, -4.38676635e-03f, 2.17518564e-02f, -4.91889231e-02f, -3.93101908e-02f,
  4.67468873e-02f, -3.88453007e-02f, 1.02800034e-01f, -1.58787984e-02f, -3.50856483e-02f, 3.95407937e-02f, 5.62957255e-03f, 2.60348972e-02f, 5.18464223e-02f, -4.19164971e-02f,
  5.17459996e-02f, 2.63820682e-02f, -8.67397860e-02f, 6.26988038e-02f, 7.69620761e-02f, 4.51392420e-02f, 2.95766760e-02f, -1.25460764e-02f, 1.36271328e-01f, -6.66588172e-03f,
  1.58340946e-01f, -5.10181524e-02f, -1.65135205e-01f, 1.42259255e-01f, 7.10350499e-02f, -1.45015940e-01f, -3.24309468e-01f, 1.03733234e-01f, -1.96366027e-01f, -2.80839333e-04f,
  -1.92988832e-02f, 7.26066381e-02f, -2.06244588e-01f, 1.97983578e-01f, 8.30494165e-02f, -8.13915655e-02f, 1.30242988e-01f, 4.86434959e-02f, 9.00283735e-03f, 5.37728751e-03f,
  9.11301747e-02f, 3.22620213e-01f, 4.16746661e-02f, 2.40488112e-01f, 1.66477486e-01f, 8.32650959e-02f, 2.18945563e-01f, -1.24844760e-01f, 2.24446759e-01f, 9.19693187e-02f,
  6.94648102e-02f, 2.19305344e-02f, -4.70102690e-02f, 4.52266913e-03f, 9.60570797e-02f, -3.68130244e-02f, -1.09079786e-01f, 7.45223509e-03f, -1.05465800e-02f, 1.01838289e-02f,
  1.40123852e-02f, 1.70599893e-02f, 2.90236250e-02f, 2.91323066e-02f, 1.28380237e-02f, -2.35070996e-02f, 3.10428478e-02f, -5.07603474e-02f, -1.65735986e-02f, -3.74191217e-02f,
  -6.53365031e-02f, -3.92697789e-02f, -3.38195115e-02f, -8.82327631e-02f, 1.10153453e-02f, -3.92936952e-02f, -3.02258562e-02f, -3.68136279e-02f, -3.37363519e-02f, -9.98406857e-02f,
  1.50180301e-02f, -4.45635282e-02f, 7.16689229e-02f, -1.32415649e-02f, 6.72488809e-02f, 9.49494913e-03f, 8.19407590e-03f, -1.07108606e-02f, -1.32957222e-02f, 1.41539341e-02f,
  7.84687139e-03f, 4.28166687e-02f, 2.25733547e-03f, -5.40348031e-02f, 6.41866529e-04f, -2.01391615e-02f, 4.17414717e-02f, 7.04110935e-02f, 6.15662150e-03f, -2.48416737e-02f,
  -4.31236587e-02f, 4.17732215e-03f, 5.61207794e-02f, -4.59091552e-02f, -1.18711488e-02f, -1.50060682e-02f, 2.62474883e-02f, -6.53599277e-02f, -1.38369752e-02f, -6.50975434e-03f,
  3.69772241e-02f, 1.55650035e-01f, -4.52610776e-02f, 1.89056108e-03f, -5.19409329e-02f, 8.44370127e-02f, 2.55782325e-02f, 3.32054980e-02f, -1.97770614e-02f, -1.75047270e-03f,
  8.19051042e-02f, 5.01529267e-03f, 2.26085410e-02f, 1.87121960e-03f, 1.33139854e-02f, -3.53798643e-02f, -4.79061762e-03f, 5.02074510e-02f, 2.06877291e-02f, 7.71186966e-03f,
  2.44124010e-02f, 4.64779176e-02f, -3.14116515e-02f, 6.98241889e-02f, 3.07516591e-03f, 3.45781967e-02f, -4.72456071e-04f, -3.17923054e-02f, 3.62366214e-02f, -2.67533828e-02f,
  1.10279970e-01f, -2.32023850e-01f, -5.49161360e-02f, -1.70327015e-02f, -2.02951897e-02f, -4.00279127e-02f, -3.52540985e-02f, -8.94178972e-02f, -9.79015008e-02f, -6.14922382e-02f,
  4.73410599e-02f, -1.10700861e-01f, 4.79990356e-02f, -3.63916717e-02f, 1.48121327e-01f, 3.84297855e-02f, 8.93928111e-02f, 1.37338340e-01f, 9.72672179e-02f, 7.18975589e-02f,
  7.46370256e-02f, 1.28956318e-01f, 3.69889960e-02f, 6.93155080e-02f, 3.63615784e-03f, 6.48311973e-02f, 1.25898883e-01f, 4.83616553e-02f, 5.30923419e-02f, 3.56630720e-02f,
  2.77044233e-02f, 4.31200452e-02f, 1.48085520e-01f, 6.79496676e-02f, 8.10938701e-02f, 9.48824361e-02f, -7.33052790e-02f, 8.01860821e-04f, -4.45196740e-02f, -6.53510317e-02f,
  3.19999158e-02f, -1.06615294e-02f, 3.43852080e-02f, 6.47608489e-02f, -2.69515514e-02f, -2.55240444e-02f, 2.18057167e-02f, 1.11498423e-02f, -5.74704595e-02f, -7.19874278e-02f,
  5.28557636e-02f, 1.07115395e-02f, -5.57077676e-03f, -3.36349234e-02f, -3.32471877e-02f, 7.40605518e-02f, -1.16243130e-02f, -4.89947125e-02f, -3.20869572e-02f, -2.06397027e-02f,
  5.29913828e-02f, 6.50312677e-02f, -3.93305682e-02f, -6.39164373e-02f, -7.16670454e-02f, -7.24722669e-02f, -5.61292432e-02f, -4.52073589e-02f, -1.06925875e-01f, 3.18721235e-02f,
  -3.63025293e-02f, -8.19326863e-02f, 5.00033051e-02f, 8.10482055e-02f, -6.80377781e-02f, 7.52321333e-02f, -2.46698726e-02f, -2.70527285e-02f, -5.35438508e-02f, 6.23771138e-02f,
  5.12467735e-02f, -5.08021638e-02f, -3.53743024e-02f, -5.37626855e-02f, -4.84203473e-02f, 1.30313411e-02f, -4.71131951e-02f, -8.38457644e-02f, 7.97061324e-02f, 2.29812469e-02f,
  6.06321208e-02f, -4.37700972e-02f, 1.18758954e-01f, 4.78334315e-02f, -8.01947713e-02f, 1.05341129e-01f, 2.50738636e-02f, -2.36075595e-02f, -7.59899989e-03f, 3.33619826e-02f,
  -6.29000412e-03f, 1.34862196e-02f, 3.50133423e-03f, -8.48350376e-02f, 7.54667222e-02f, 6.59404844e-02f, -3.06647085e-02f, 2.99801528e-02f, -3.87655087e-02f, -2.99372654e-02f,
  1.29875559e-02f, -2.80082393e-02f, -4.43002395e-02f, -8.44183266e-02f, -4.73121256e-02f, -6.41825423e-02f, 2.38752812e-02f, 2.43965127e-02f, -2.52964962e-02f, 5.44235110e-02f,
  1.46350309e-01f, -3.87097448e-02f, 1.32652268e-01f, 1.00926787e-01f, 8.10458884e-02f, -4.76470329e-02f, 8.99656266e-02f, 3.82141098e-02f, 1.27376005e-01f, -2.06820995e-01f,
  -4.84872572e-02f, 5.06603019e-03f, 6.93236515e-02f, 4.03167270e-02f, 1.44726217e-01f, 2.58531962e-02f, -2.83383448e-02f, -6.72746776e-03f, 1.01822786e-01f, -3.16107497e-02f,
  1.02002084e-01f, -2.71319542e-02f, 4.56131063e-02f, -6.09528199e-02f, -3.20308320e-02f, 9.25874524e-03f, -1.66765392e-01f, -5.19548170e-02f, -1.72619194e-01f, 5.37703373e-02f,
  3.82970497e-02f, 5.79018071e-02f, -5.93956327e-03f, -3.08947219e-03f, -4.56459029e-03f, -4.39090803e-02f, -7.28891715e-02f, -8.27928539e-03f, 1.78146828e-02f, 3.60605493e-02f,
  -1.58866104e-02f, -1.65112577e-02f, 1.26731703e-02f, 7.34488294e-02f, -5.25623634e-02f, 7.61179924e-02f, -3.80264558e-02f, -5.88216037e-02f, 6.20512702e-02f, -7.00709131e-03f,
  1.90825351e-02f, 3.15918438e-02f, 7.26942495e-02f, -2.72040889e-02f, -8.72666109e-03f, -6.66508405e-03f, 5.62028587e-02f, -8.68421048e-02f, -3.93680669e-02f, -5.17395558e-03f,
  6.17394783e-02f, -4.34774756e-02f, -7.43582565e-03f, -1.88585240e-02f, 3.85945290e-02f, 3.90859880e-02f, 1.65465977e-02f, -5.87859936e-02f, -5.02594411e-02f, -4.68966477e-02f,
  4.18421291e-02f, 5.50433807e-02f, -5.76034300e-02f, -5.93334697e-02f, 6.08541025e-03f, -5.61231822e-02f, -1.38904471e-02f, -9.35444143e-03f, -2.76959781e-02f, -2.15933472e-02f,
  -1.41693549e-02f, 5.47521561e-02f, 5.77581078e-02f, 2.46915463e-02f, 3.23497243e-02f, 1.66021392e-03f, -2.28537414e-02f, -5.52776502e-03f, -6.65365777e-04f, -6.75211772e-02f,
  1.28181349e-03f, -8.22445750e-02f, 3.83435225e-04f, -4.76591624e-02f, 4.84712748e-03f, -1.15702497e-02f, -3.15730795e-02f, -2.76484843e-02f, 2.24300772e-02f, -1.41347898e-02f,
  -6.64603105e-03f, -2.50750296e-02f, -1.32925868e-01f, -6.46089911e-02f, 7.67724738e-02f, 1.69055816e-02f, -1.08365260e-01f, -1.38344327e-02f, -2.44711582e-02f, -3.41609083e-02f,
  -3.38772610e-02f, -9.38676670e-02f, -5.80694824e-02f, -6.65590018e-02f, -5.60856573e-02f, -5.49601875e-02f, -2.85163186e-02f, 1.03358505e-02f, -5.17192297e-02f, -7.45897442e-02f,
  3.35139385e-03f, 3.19274664e-01f, -2.64182426e-02f, 2.64956445e-01f, 1.72094293e-02f, 1.08093537e-01f, 1.63066328e-01f, 1.61917061e-01f, 1.03791036e-01f, 9.93492678e-02f,
  1.01324320e-02f, 9.86462310e-02f, -7.35153034e-02f, 1.70558318e-01f, -9.51113999e-02f, 5.28672375e-02f, 1.32285461e-01f, 1.15639880e-01f, -7.99425095e-02f, 4.38413769e-03f,
  2.50232257e-02f, -2.33167745e-02f, 1.37141980e-02f, -1.34482443e-01f, -1.73396226e-02f, -5.41620106e-02f, -6.61411136e-02f, -7.93316439e-02f, -7.45787425e-03f, -6.66989759e-02f,
  2.56815087e-02f, 2.05128212e-02f, -1.14345951e-02f, -6.29470199e-02f, -9.11118388e-02f, -3.77454981e-02f, 8.64459574e-03f, -1.05241295e-02f, -5.52793071e-02f, -1.85164120e-02f,
  -9.81906950e-02f, -4.37009297e-02f, -2.30555423e-03f, -3.22920308e-02f, 1.49557432e-02f, 1.09258443e-01f, -1.52293677e-02f, 1.05451092e-01f, -3.11541129e-02f, -9.32730958e-02f,
  5.09383194e-02f, 7.27684423e-02f, 1.67072415e-02f, 4.83169593e-02f, -7.23343566e-02f, -9.41198878e-03f, 2.75291260e-02f, 7.69101679e-02f, 5.84453382e-02f, 9.31776166e-02f,
  5.69561981e-02f, -1.18351668e-01f, 4.80270945e-02f, 6.62405938e-02f, -6.55763000e-02f, -3.70700918e-02f, 5.84762767e-02f, 3.75806750e-03f, -5.41997934e-03f, -4.31566462e-02f,
  -5.18981507e-03f, 2.42009293e-02f, -6.35854155e-03f, 1.39076589e-02f, 5.49291894e-02f, 8.54710862e-02f, -1.04932986e-01f, 5.26344664e-02f, 7.58037046e-02f, 3.74132469e-02f,
  -2.44165119e-02f, 1.03496797e-02f, 6.08905479e-02f, 9.28512774e-03f, -9.07385275e-02f, -3.16249989e-02f, -4.11145389e-02f, -1.41627202e-02f, 1.46530510e-03f, 1.74342673e-02f,
  7.12530985e-02f, 1.66030824e-01f, -9.94678438e-02f, 4.07104986e-03f, -2.69899201e-02f, 5.96611053e-02f, -6.29746765e-02f, 5.63635640e-02f, 5.32621481e-02f, 8.05266609e-04f,
  5.06350305e-04f, -2.17124466e-02f, 3.36273499e-02f, -3.59684788e-02f, 7.17240572e-03f, -3.73928286e-02f, 1.89110113e-03f, 1.76163185e-02f, 9.63096023e-02f, 6.28548637e-02f,
  5.48163205e-02f, 4.19718437e-02f, 1.20513444e-03f, -6.62729293e-02f, -8.06667097e-03f, 3.35142910e-02f, 7.25092441e-02f, 4.39134389e-02f, 2.22395291e-03f, -4.14100401e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.12519920e-01f, -2.74891313e-02f, -3.70856840e-04f, 4.18654457e-03f, -7.55258501e-02f, 4.58280966e-02f, 4.12664749e-02f, -4.79298458e-02f, -2.21348535e-02f, 7.56627768e-02f,
  -6.39850944e-02f, -5.99092282e-02f, 7.48953596e-02f, 6.54842556e-02f, -5.75708486e-02f, -4.63521294e-02f, 3.21316719e-02f, -2.78034005e-02f, -2.92243399e-02f, -1.59675516e-02f,
  -5.11240959e-02f, -4.37251814e-02f, 1.14160748e-02f, 3.15770097e-02f, 1.50069557e-02f, -7.62810977e-03f, 1.05391681e-01f, 6.34160265e-02f, 1.81889981e-02f, 7.73385242e-02f,
  2.48690471e-02f, -1.66112296e-02f, -6.10077986e-03f, -3.75151001e-02f, -3.19258198e-02f, 4.11494523e-02f, -2.77266838e-02f, -9.61463973e-02f, 6.58235848e-02f, 9.20176208e-02f,
  -2.44659893e-02f, -7.73673952e-02f, -6.67010024e-02f, -3.61312591e-02f, -4.07203063e-02f, -5.57664782e-02f, -1.02876127e-01f, -7.39447549e-02f, 4.48639840e-02f, 6.60609901e-02f,
  2.99742129e-02f, -6.95901141e-02f, 9.99729335e-02f, 6.52681142e-02f, 6.93848208e-02f, 1.38375610e-02f, 1.54991094e-02f, -5.51547036e-02f, 6.85007721e-02f, 1.94095634e-02f,
  5.08116335e-02f, -3.62987025e-03f, -5.20127127e-03f, 5.60787320e-02f, 5.10771871e-02f, 7.13002384e-02f, -4.14453000e-02f, -5.86368032e-02f, 2.04409566e-02f, -1.58102904e-02f,
  -4.89506461e-02f, -2.47584586e-03f, -3.12297679e-02f, -1.45795364e-02f, 4.66935262e-02f, -5.98237626e-02f, 1.45370336e-02f, 6.23661093e-02f, -4.05193679e-02f, -1.27165718e-02f,
  6.28174320e-02f, -2.67176945e-02f, 4.56127189e-02f, -8.93662311e-03f, -6.46991059e-02f, -6.34699240e-02f, 1.88685767e-02f, 5.29267825e-02f, -1.53998286e-02f, 4.01822366e-02f,
  -1.91878937e-02f, 1.69250220e-02f, 7.19175162e-03f, -7.01469332e-02f, -4.47020940e-02f, 3.51305911e-03f, 6.23543095e-03f, -2.87078489e-02f, 3.12494412e-02f, 2.75621228e-02f,
  4.98781018e-02f, 5.53506687e-02f, 6.50183856e-02f, -2.30144504e-02f, -5.49816452e-02f, 5.26904203e-02f, 3.14535797e-02f, 2.67869253e-02f, 3.29388529e-02f, 5.07138073e-02f,
  -3.88195328e-02f, 8.42734054e-02f, -1.43531486e-02f, -3.93525399e-02f, 2.57790554e-02f, 9.90559533e-02f, 5.29936925e-02f, -9.89639852e-03f, 2.81975716e-02f, 6.70736954e-02f,
  -1.03384100e-01f, -9.53927189e-02f, -6.83971047e-02f, -1.01741306e-01f, 1.17081173e-01f, 7.33327046e-02f, 2.79894564e-02f, -7.02628344e-02f, -1.98036611e-01f, 8.10184777e-02f,
  7.04784095e-02f, -1.15700074e-01f, 2.82546803e-02f, -1.38515800e-01f, -1.07771836e-01f, -1.46055475e-01f, -6.18690206e-03f, -2.49778274e-02f, -1.00590333e-01f, 6.54993132e-02f,
  -1.05545312e-01f, -9.29076150e-02f, 3.43070738e-02f, -2.62797084e-02f, 2.22417992e-02f, 1.20256945e-01f, 1.96871594e-01f, 1.45219982e-01f, 9.73877870e-03f, -1.83646623e-02f,
  2.18075141e-02f, 1.82400495e-02f, -4.95506264e-03f, -1.01472571e-01f, 9.58477482e-02f, 1.02254272e-01f, 4.29798737e-02f, 2.16755960e-02f, -4.54743691e-02f, 8.30271095e-02f,
  1.30381748e-01f, -5.06740287e-02f, -6.91559464e-02f, 8.46506655e-03f, -3.24986763e-02f, 2.71182531e-03f, -7.25039169e-02f, -2.19130394e-04f, -6.68999106e-02f, -1.23701124e-02f,
  -3.77221629e-02f, -6.44964725e-03f, 1.65573601e-02f, -4.28472608e-02f, -2.01496687e-02f, -1.13000050e-01f, -1.55950701e-02f, 4.43983115e-02f, -5.81940748e-02f, -1.44729456e-02f,
  7.74822980e-02f, 4.70961593e-02f, -2.47496553e-03f, 3.78928818e-02f, -6.83548078e-02f, -6.67368546e-02f, 5.39368913e-02f, 8.73609632e-02f, 6.96139829e-03f, -2.96553001e-02f,
  4.54707257e-02f, 8.22580084e-02f, 5.98727614e-02f, 5.10315038e-02f, 6.03862405e-02f, -1.21656572e-02f, 6.72206059e-02f, -1.89718381e-02f, -1.53890215e-02f, -3.49396504e-02f,
  -2.08086111e-02f, 3.38950125e-03f, 6.06472120e-02f, 1.03408977e-01f, 1.45982504e-02f, 2.59814169e-02f, 3.54343764e-02f, 2.97555560e-03f, 6.91915303e-02f, 1.09751552e-01f,
  2.75658946e-02f, 2.74288077e-02f, -5.98671660e-02f, 2.70914030e-03f, -6.73102099e-04f, 1.21644000e-03f, 2.70876493e-02f, 4.93095554e-02f, -2.88134329e-02f, 2.61322930e-02f,
  1.01146018e-02f, 1.03107303e-01f, 8.82637948e-02f, 6.24964014e-02f, 8.37745741e-02f, 1.18643679e-02f, -9.88128409e-03f, -3.12925838e-02f, 6.36380687e-02f, 5.19680120e-02f,
  -4.15872000e-02f, 5.23040220e-02f, -2.50235945e-02f, 4.27255146e-02f, 4.88437563e-02f, 5.56523465e-02f, -2.80461758e-02f, -5.94133623e-02f, -2.78510414e-02f, -7.87570626e-02f,
  -4.29841951e-02f, -1.57548621e-01f, 5.80618493e-02f, 2.05303468e-02f, 1.61018685e-01f, 2.11283043e-02f, 5.55627458e-02f, -1.18336231e-01f, -8.43452588e-02f, -4.01796661e-02f,
  -7.94396400e-02f, -7.82556981e-02f, -1.68199167e-02f, -1.35057330e-01f, 7.58739188e-02f, -8.84912610e-02f, -6.40964508e-02f, 3.78808603e-02f, 5.81843592e-02f, 7.37202242e-02f,
  6.40419498e-02f, -6.31801691e-03f, -6.39375225e-02f, -5.50591275e-02f, 9.12922695e-02f, 3.00842524e-02f, 1.20361932e-02f, 3.84536162e-02f, 4.44931118e-03f, -7.98114315e-02f,
  -5.84134758e-02f, 6.56333119e-02f, -6.26505762e-02f, 5.11270128e-02f, -3.82287218e-03f, -3.69573049e-02f, -8.54318589e-03f, 4.65778522e-02f, 3.25716548e-02f, -3.62676606e-02f,
  -3.16156680e-03f, 3.02240457e-02f, -5.01869246e-02f, -4.73003238e-02f, 1.93673633e-02f, -6.26271963e-02f, 4.87928689e-02f, -6.72477782e-02f, 9.18351859e-02f, 5.19481860e-02f,
  -1.39266327e-02f, -8.24300721e-02f, -1.94467474e-02f, 5.00998497e-02f, 8.07753503e-02f, 1.23609900e-02f, 1.97476763e-02f, 8.12959373e-02f, 7.79278902e-03f, 4.70249988e-02f,
  1.06960736e-01f, 1.01140618e-01f, -9.95168462e-02f, 2.58735735e-02f, -6.29955307e-02f, 8.07525367e-02f, 5.38083836e-02f, 2.46524392e-03f, 1.09619591e-02f, -5.58689237e-02f,
  7.78687298e-02f, -6.00041747e-02f, -5.25465561e-03f, -6.09572269e-02f, 6.15629517e-02f, 3.40494961e-02f, 6.05370812e-02f, 3.20558175e-02f, -9.37782414e-03f, 8.04887116e-02f,
  5.07884100e-02f, 3.16114165e-02f, -7.29191601e-02f, -1.99804008e-02f, -6.52889982e-02f, -3.10844686e-02f, 3.11337225e-02f, 4.95076068e-02f, -6.47593588e-02f, -6.01668730e-02f,
  -1.67972758e-01f, 2.14133388e-03f, 2.20551956e-02f, -7.45429397e-02f, -3.89946252e-02f, 4.08919565e-02f, 4.56470326e-02f, 2.83035953e-02f, -3.39252986e-02f, 3.11129377e-03f,
  -2.28822744e-03f, -4.61582318e-02f, 3.70415486e-02f, 5.07398099e-02f, -1.97535791e-02f, -2.47084014e-02f, -8.55608061e-02f, -6.65552765e-02f, 6.43285364e-02f, -1.39511721e-02f,
  7.67768845e-02f, 7.36786425e-02f, -1.47653809e-02f, 3.90866362e-02f, 2.00625379e-02f, 6.36514053e-02f, -3.57822627e-02f, -9.24807563e-02f, 5.16878478e-02f, 1.32560525e-02f,
  7.95881078e-02f, 6.59503341e-02f, 7.64025748e-02f, 4.99828383e-02f, -4.49054688e-02f, -1.46606360e-02f, 1.25137093e-02f, -6.42246231e-02f, -2.53786445e-02f, -3.26144025e-02f,
  -1.15547575e-01f, -9.33612287e-02f, -5.64077012e-02f, 3.00189443e-02f, -3.52286920e-02f, -5.60808368e-02f, -7.04643801e-02f, 1.30456276e-02f, 8.83414075e-02f, -2.39600074e-02f,
  2.49028690e-02f, -7.03258440e-02f, 8.33228007e-02f, 1.00743985e-02f, -4.76822257e-02f, -3.87029387e-02f, -1.18437419e-02f, 6.32935092e-02f, -5.46306670e-02f, 4.48859185e-02f,
  9.11619142e-02f, 5.91365844e-02f, -5.58952801e-02f, -7.05526695e-02f, -5.00462428e-02f, 1.47160804e-02f, -6.47303611e-02f, -8.56168419e-02f, 4.49309573e-02f, -1.65039860e-02f,
  -2.90895663e-02f, -7.54403919e-02f, -7.23069347e-03f, 4.03588116e-02f, 3.47618647e-02f, -2.49740556e-02f, 7.31561333e-02f, 1.28018390e-02f, -2.53671315e-02f, -1.43341031e-02f,
  -4.98326607e-02f, 8.34982097e-02f, 8.49328265e-02f, 1.88873075e-02f, 6.96081296e-02f, -4.63427640e-02f, 2.89222449e-02f, -7.44583383e-02f, -5.05599417e-02f, 6.09657876e-02f,
  -1.69222173e-03f, 5.60052646e-03f, 3.15821916e-02f, 6.66366844e-03f, -4.65333275e-03f, -1.24203926e-02f, 3.17774601e-02f, 7.49705508e-02f, 3.95580530e-02f, -5.40217645e-02f,
  4.35057245e-02f, -7.63131827e-02f, 6.32673651e-02f, -9.43121836e-02f, -2.81219296e-02f, -1.90785769e-02f, -2.72811633e-02f, 4.56279702e-02f, 8.02727789e-02f, 7.66477734e-02f,
  8.72145407e-03f, -2.32445262e-02f, -2.82653607e-02f, -5.82603589e-02f, -5.09993024e-02f, 7.92253688e-02f, 7.39569515e-02f, -6.09411113e-02f, -7.40066590e-03f, -4.61217482e-03f,
  8.53700489e-02f, -6.72485530e-02f, 8.91844705e-02f, -1.32488795e-02f, -7.61284167e-03f, -7.01830387e-02f, 6.83708936e-02f, -5.77155389e-02f, 5.40152751e-03f, -4.33792397e-02f,
  5.62209822e-02f, 3.49103697e-02f, -6.91325739e-02f, 2.47028060e-02f, -4.86566201e-02f, -4.22051363e-02f, 4.31845300e-02f, 3.35396565e-02f, -1.32335015e-02f, -6.10375628e-02f,
  2.69437935e-02f, -2.97018848e-02f, 4.13269438e-02f, -8.25461820e-02f, 3.04484200e-02f, -4.29913998e-02f, 2.99820416e-02f, 9.60167646e-02f, 6.17500581e-02f, -2.34288368e-02f,
  1.00794509e-01f, 6.77495748e-02f, -5.95324580e-03f, 1.28175333e-01f, 6.45788610e-02f, 3.50764021e-02f, 1.27210081e-01f, 1.79401323e-01f, 1.01200297e-01f, 5.80723546e-02f,
  -1.13564700e-01f, 3.03580295e-02f, -1.82069987e-02f, -3.75029892e-02f, -7.98734725e-02f, 3.91146690e-02f, 4.73506898e-02f, -6.24777712e-02f, 9.22006890e-02f, 2.47325609e-03f,
  9.02949721e-02f, -1.16395261e-02f, -1.09277435e-01f, -3.87257971e-02f, -6.39440725e-03f, -3.70791159e-03f, -5.97128607e-02f, -6.90819845e-02f, -9.86692980e-02f, 3.49230282e-02f,
  -5.74506447e-02f, -3.09182983e-02f, -4.09530401e-02f, 3.92562635e-02f, 2.43265671e-03f, -8.34724456e-02f, 1.18696429e-01f, 3.39574963e-02f, 2.90971585e-02f, 4.01415825e-02f,
  1.66367069e-02f, -2.40045525e-02f, -1.39964670e-02f, 4.35018986e-02f, -4.65590209e-02f, -6.90874010e-02f, 1.14598192e-01f, 2.59661339e-02f, -6.42487109e-02f, -2.39807628e-02f,
  -1.84666924e-02f, 5.92495278e-02f, 4.44563329e-02f, -4.26773168e-02f, 2.85454541e-02f, 7.31475577e-02f, -2.03545429e-02f, -7.78822154e-02f, 2.84485891e-02f, -2.03617997e-02f,
  2.72144154e-02f, 6.68456033e-02f, -2.85448227e-02f, -3.27152759e-02f, 7.65664279e-02f, 1.83443516e-03f, 9.10346024e-03f, -4.64976430e-02f, 2.54698321e-02f, -2.76180003e-02f,
  -5.07814549e-02f, 8.32308754e-02f, 4.61244062e-02f, 6.69004694e-02f, 3.25542688e-02f, 6.22038282e-02f, -5.93386590e-02f, 9.15072784e-02f, -1.96110867e-02f, -5.11094667e-02f,
  -1.20816834e-03f, 2.53431574e-02f, -6.02838099e-02f, 1.70380585e-02f, -2.81290505e-02f, 1.57010909e-02f, -6.64779125e-03f, 6.10212311e-02f, -2.14965045e-02f, 4.91108112e-02f,
  2.10240595e-02f, 5.76445460e-02f, -2.84656640e-02f, 3.37746032e-02f, 4.20287885e-02f, -1.00320112e-02f, 6.36581006e-03f, -3.90004963e-02f, -5.83532229e-02f, 4.47643138e-02f,
  5.27935550e-02f, 4.65034693e-02f, 6.21591471e-02f, 1.59107763e-02f, -5.19603118e-02f, 6.06405102e-02f, -1.59245264e-02f, -4.59061600e-02f, 3.58584784e-02f, 6.19511940e-02f,
  3.54719646e-02f, 1.07606634e-01f, -2.69633196e-02f, 4.42069508e-02f, 6.72504157e-02f, -3.90652828e-02f, 3.59728895e-02f, -1.01226918e-01f, -1.90574154e-02f, -5.45867793e-02f,
  1.53366476e-01f, 1.08459257e-01f, 7.16171935e-02f, 4.56829704e-02f, -1.34444728e-01f, -1.31378293e-01f, -1.17046982e-01f, 1.28359310e-02f, -7.91758224e-02f, 2.43639238e-02f,
  -2.86654709e-03f, 4.34724651e-02f, 2.11061332e-02f, 7.68913403e-02f, 2.95259673e-02f, -1.71046164e-02f, 3.87846567e-02f, -1.12927303e-01f, 7.99213201e-02f, 1.09343745e-01f,
  1.39159471e-01f, 3.84049327e-03f, 1.87104151e-01f, 4.64847907e-02f, 9.45010483e-02f, 4.32894118e-02f, -9.12021846e-03f, 3.33329365e-02f, 1.38173979e-02f, -4.27750535e-02f,
  -7.76446611e-02f, 2.59121843e-02f, 5.82578294e-02f, -2.69493088e-02f, 6.14590757e-02f, 6.09897599e-02f, -5.81357479e-02f, -9.02742743e-02f, 1.56144192e-02f, -6.15851209e-02f,
  -8.07382837e-02f, 5.94784170e-02f, -6.59676120e-02f, -5.87112363e-03f, -5.38839921e-02f, 3.87120433e-02f, -5.91875091e-02f, -2.15786360e-02f, 2.66125761e-02f, 3.80532071e-02f,
  -1.51026733e-02f, 4.91487719e-02f, 3.98153700e-02f, -5.07512838e-02f, 2.82385424e-02f, -1.93325933e-02f, -5.99119812e-02f, -3.57572176e-02f, 1.98588520e-02f, 1.03395067e-01f,
  -4.18681838e-02f, -8.28686208e-02f, 6.16491884e-02f, -6.10472560e-02f, 1.12945788e-01f, 8.40603898e-04f, -1.38302781e-02f, 2.71260701e-02f, -7.40812859e-03f, 7.85961002e-02f,
  -8.48393887e-03f, -6.02640808e-02f, -1.73800196e-02f, -3.84463929e-02f, -1.31967403e-02f, 5.40351570e-02f, 3.46436463e-02f, -2.60661524e-02f, -6.29641861e-02f, -1.65277123e-02f,
  -7.45827630e-02f, -7.92849157e-03f, 4.97461595e-02f, -4.31221351e-02f, 4.06059921e-02f, -1.81953050e-02f, 7.61268660e-02f, -1.12736877e-03f, -7.09678307e-02f, -6.86664209e-02f,
  6.30850121e-02f, 1.69907972e-01f, -3.27661559e-02f, -5.74905537e-02f, -7.36485049e-03f, -1.88137684e-02f, 1.12571895e-01f, -1.34592848e-02f, 1.07757352e-01f, -4.54028808e-02f,
  -4.02032286e-02f, -4.78542614e-04f, -8.47261399e-02f, -4.80354838e-02f, -1.95142888e-02f, 7.04802126e-02f, -1.09668802e-02f, -2.19012648e-02f, 5.65279201e-02f, -5.99544263e-03f,
  -3.49539407e-02f, -1.17803030e-01f, 6.90415967e-03f, -3.18487734e-02f, -1.23196072e-03f, -8.52594227e-02f, -3.16912425e-03f, -1.87916309e-02f, -2.95451116e-02f, -4.54066806e-02f,
  -1.05612606e-01f, -9.56088677e-02f, -7.79586053e-03f, -4.56891432e-02f, 5.24051711e-02f, -1.20431557e-01f, -1.19334824e-01f, -1.18428893e-01f, -4.25491072e-02f, -1.67599763e-03f,
  2.76610279e-03f, 7.33727217e-02f, 1.15582675e-01f, -1.57354623e-02f, -8.84334594e-02f, 1.23759545e-01f, -1.35343745e-01f, -1.13793416e-02f, -7.84048960e-02f, -1.35493457e-01f,
  -1.24188505e-01f, -5.16643971e-02f, -1.03030661e-02f, 5.36999889e-02f, -1.14682630e-01f, -7.18826503e-02f, -3.27237286e-02f, -4.62756082e-02f, -5.98586872e-02f, 5.53444847e-02f,
  6.40217513e-02f, 5.02870157e-02f, 5.24197295e-02f, 7.45377690e-02f, 2.23110653e-02f, 3.73221468e-03f, 5.12699829e-03f, -2.47179680e-02f, 2.05481052e-02f, -8.10613409e-02f,
  -6.62380755e-02f, 7.64014199e-02f, 1.41838109e-02f, 7.97334760e-02f, -9.81146842e-02f, -6.14318401e-02f, -8.55766833e-02f, 1.08902017e-02f, -7.85530545e-03f, 4.78132032e-02f,
  -9.41226035e-02f, -1.24611715e-02f, -2.86045521e-02f, 7.85014331e-02f, -3.54250968e-02f, 3.54350992e-02f, -7.98878148e-02f, 8.68914835e-03f, -6.28716871e-02f, -5.25888316e-02f,
  -3.54144926e-04f, -3.80762964e-02f, 9.16135684e-02f, -6.29626885e-02f, 1.43199079e-02f, 7.15801939e-02f, -2.01974604e-02f, 4.44731824e-02f, -6.32502660e-02f, -7.19630420e-02f,
  6.31209761e-02f, -1.50730601e-02f, 4.92836647e-02f, -4.06505133e-04f, -1.12760421e-02f, 4.34672274e-02f, -7.50388503e-02f, -4.91835661e-02f, 5.39050177e-02f, -8.09534267e-02f,
  -1.66697043e-03f, -1.16011230e-02f, 5.07712848e-02f, 7.02877790e-02f, 7.29230717e-02f, -8.53192508e-02f, 1.84263829e-02f, 6.47077262e-02f, -3.60782966e-02f, -2.82936711e-02f,
  5.70857078e-02f, 9.77743715e-02f, -1.45993587e-02f, 5.92001602e-02f, -3.23940776e-02f, 4.85801809e-02f, 3.44927870e-02f, -1.24285229e-01f, 5.64785413e-02f, -2.10782737e-02f,
  -4.29640487e-02f, 2.60975864e-02f, -6.32582139e-03f, -4.45561036e-02f, -6.81555793e-02f, -1.88823622e-02f, 4.93113995e-02f, -3.47771533e-02f, 7.63138980e-02f, -4.62605692e-02f,
  7.63460249e-02f, 9.37308818e-02f, -9.66674760e-02f, 3.83706316e-02f, -3.66015248e-02f, -1.93624571e-02f, 7.60909840e-02f, 7.93223456e-02f, 6.28453717e-02f, -5.82033843e-02f,
  -1.92533150e-01f, -6.39587939e-02f, -1.08057961e-01f, -1.79631785e-02f, -3.24008800e-02f, 1.18145093e-01f, 1.68348342e-01f, -6.86587840e-02f, 2.34214906e-02f, 1.23089589e-01f,
  1.32649034e-01f, -4.77342680e-03f, 4.65248115e-02f, 2.98907366e-02f, 8.86110531e-04f, -9.55336615e-02f, 2.81011779e-02f, 1.17421627e-01f, -2.83456128e-02f, -2.49173064e-02f,
  -7.26160780e-02f, 5.64440787e-02f, 6.88385367e-02f, -5.52429780e-02f, 4.66239750e-02f, -8.16041380e-02f, 3.88299599e-02f, -6.72660023e-02f, 9.60794091e-02f, 4.51703779e-02f,
  -7.30086714e-02f, -9.77722481e-02f, -7.07587749e-02f, 4.04583812e-02f, -4.61946195e-03f, 7.05597624e-02f, -5.30464165e-02f, 8.09972510e-02f, -2.42293291e-02f, -4.70717512e-02f,
  3.39342430e-02f, 1.20576443e-02f, -7.26737976e-02f, -2.60822717e-02f, 5.51462471e-02f, 3.14925015e-02f, 1.83359981e-02f, 3.43339592e-02f, -4.26691696e-02f, -2.82983743e-02f,
  -9.37711671e-02f, -8.75756517e-03f, 9.38644707e-02f, -1.17354617e-02f, -3.48280594e-02f, -7.95256943e-02f, 3.00776605e-02f, 3.78092192e-02f, -1.38916029e-02f, -2.89078001e-02f,
  4.88732159e-02f, -2.68687885e-02f, -4.96968217e-02f, 5.96764777e-03f, 6.20111898e-02f, 2.40042880e-02f, 3.80509421e-02f, -1.54406801e-02f, -3.85542586e-02f, 5.80920018e-02f,
  -7.18898922e-02f, 3.20897512e-02f, -5.92177436e-02f, -3.19060348e-02f, 2.38690438e-04f, 1.51245762e-02f, -5.72052039e-02f, 7.40826055e-02f, 7.97520429e-02f, 2.07176227e-02f,
  -1.17879082e-02f, 4.20845784e-02f, 6.23690784e-02f, 7.58124515e-02f, 6.02914430e-02f, 5.04944921e-02f, 7.46517926e-02f, -1.05900960e-02f, -3.44524458e-02f, -7.04551861e-02f,
  3.66334291e-03f, 9.98041332e-02f, -2.73512695e-02f, -3.49431448e-02f, -2.01387703e-02f, 2.94749215e-02f, 1.62120126e-02f, 1.50837610e-02f, 4.34508398e-02f, 1.17935073e-02f,
  -6.68706000e-02f, 2.36801729e-02f, 4.25978862e-02f, 7.40034059e-02f, 2.99636647e-03f, 3.68202515e-02f, -6.54891774e-04f, 6.13655970e-02f, -3.36346813e-02f, 6.22098781e-02f,
  -2.85568293e-02f, -4.69773356e-03f, -1.52790518e-02f, 1.75182428e-02f, 8.37566927e-02f, 3.08429971e-02f, 5.50382212e-02f, 2.71423832e-02f, 2.10891441e-02f, -8.12498257e-02f,
  9.44017805e-03f, 1.10190623e-01f, -3.17878239e-02f, -2.91817561e-02f, 9.86876711e-02f, 7.22356141e-02f, -4.38810773e-02f, 6.69227242e-02f, -9.43045467e-02f, 9.19136330e-02f,
  3.42759229e-02f, 5.19547611e-02f, 7.34934285e-02f, -1.64462428e-03f, -8.41156319e-02f, 2.68892553e-02f, 1.04293600e-03f, 5.57965785e-02f, 6.20252341e-02f, 3.16484049e-02f,
  6.20874241e-02f, -3.78972827e-03f, -5.78342862e-02f, -2.01117434e-02f, -2.19293255e-02f, -2.25621904e-03f, -3.76975797e-02f, 4.74907309e-02f, 1.17082417e-01f, -3.74756083e-02f,
  -1.83511619e-02f, -3.96055430e-02f, -2.14427877e-02f, 1.61371357e-03f, 3.95317823e-02f, -1.11291534e-03f, 2.90769944e-03f, 9.58167389e-02f, 6.82516471e-02f, 2.24343035e-02f,
  7.58696115e-04f, -6.39520213e-02f, 7.97078386e-02f, 2.94500720e-02f, -5.29910885e-02f, -1.79336444e-02f, 8.94297138e-02f, -2.89475056e-03f, -6.91702068e-02f, -7.72848427e-02f,
  -8.91958252e-02f, -9.73446518e-02f, -6.29763454e-02f, -1.81370731e-02f, 7.76216239e-02f, 6.86358660e-02f, -1.32179884e-02f, 6.55859783e-02f, 2.41985191e-02f, -5.52438535e-02f,
  1.00982310e-02f, 2.62567643e-02f, -1.97087787e-02f, -6.21047541e-02f, -2.04525050e-02f, -4.90272082e-02f, 8.15810710e-02f, -5.13608456e-02f, -7.32847536e-03f, 4.01687436e-02f,
  8.05014446e-02f, 6.72888011e-02f, -6.75191544e-03f, -3.65173956e-03f, -1.45045202e-03f, 7.80631378e-02f, -9.73299891e-02f, 7.36928210e-02f, -2.64297500e-02f, 1.46650029e-02f,
  2.49177273e-02f, 2.46307664e-02f, -1.60592552e-02f, 3.08809411e-02f, 7.26094916e-02f, 2.06649322e-02f, -7.51864538e-02f, 1.18080555e-02f, 5.37192300e-02f, 6.67158663e-02f,
  6.99608624e-02f, -1.99141484e-02f, 7.13047013e-03f, -1.44553799e-02f, 2.57565547e-02f, 6.89705536e-02f, 8.74102414e-02f, -6.72524620e-04f, 7.38893822e-02f, -7.97277391e-02f,
  -8.90173167e-02f, -7.69547373e-02f, -5.45193776e-02f, -5.08990400e-02f, -6.64770901e-02f, 7.83694908e-02f, 9.69054773e-02f, -2.66325027e-02f, 1.51970098e-02f, 6.64850920e-02f,
  -4.85640354e-02f, 8.16185027e-02f, -6.34662658e-02f, -8.84696990e-02f, -4.28734347e-02f, -7.79325143e-02f, 5.79626411e-02f, -4.73969094e-02f, 5.97505979e-02f, 3.37841287e-02f,
  6.58280402e-02f, 1.85626432e-01f, 6.31266087e-02f, -7.87406266e-02f, 1.07368425e-01f, 1.18145477e-02f, -3.48968208e-02f, 4.63266894e-02f, -6.72687544e-03f, -6.60709441e-02f,
  -1.06504783e-01f, 1.37791917e-01f, -1.39875457e-01f, 1.07525505e-01f, -2.89532784e-02f, 4.22587059e-02f, 1.67247951e-02f, 2.10280493e-02f, 1.19739994e-01f, -1.28174908e-02f,
  8.37413520e-02f, -2.37880163e-02f, 1.16457038e-01f, 4.62029278e-02f, -2.40741149e-02f, -1.05355149e-02f, -3.21735218e-02f, 7.35914856e-02f, -3.08838431e-02f, -3.93685624e-02f,
  8.46955851e-02f, 4.14729379e-02f, -7.54032657e-02f, -7.31870383e-02f, -5.11605404e-02f, -3.69062158e-03f, 6.34957030e-02f, -8.92197862e-02f, -3.75380144e-02f, 6.05174638e-02f,
  -1.22911837e-02f, 6.03946820e-02f, -4.00094986e-02f, 7.47395307e-03f, 7.33881770e-03f, -9.00742598e-03f, -4.09695506e-02f, -4.19182703e-02f, 1.00880370e-01f, 1.15580447e-01f,
  1.05219401e-01f, 6.67908415e-02f, -5.41474409e-02f, -1.27671706e-03f, 2.64017414e-02f, -9.80581418e-02f, -1.72114838e-02f, -8.34759548e-02f, 3.21584009e-02f, -5.59402332e-02f,
  1.05858102e-01f, 5.23570254e-02f, -3.46004516e-02f, 8.89536813e-02f, -9.10838470e-02f, -1.00862369e-01f, -2.16096770e-02f, 9.40750539e-02f, 3.91993448e-02f, 5.70708625e-02f,
  -1.23484051e-02f, 5.35150543e-02f, 6.38886243e-02f, 3.00591867e-02f, -7.03312531e-02f, 1.19975433e-02f, -1.33698089e-02f, 5.67851029e-02f, -5.83232827e-02f, -8.54840688e-03f,
  -8.13836753e-02f, -1.46659827e-02f, -6.25558123e-02f, -5.09760752e-02f, -6.92042932e-02f, -2.41426006e-02f, -4.12615463e-02f, 5.87652512e-02f, -4.50222231e-02f, 6.49509281e-02f,
  5.05284518e-02f, -9.21829045e-02f, -6.34488761e-02f, -4.39126007e-02f, 5.35821542e-02f, -3.92474942e-02f, 1.99431553e-03f, 8.19582865e-03f, -1.01310022e-01f, 5.63250221e-02f,
  -8.88916627e-02f, 1.10496732e-03f, 1.11650035e-01f, 8.34219810e-03f, -7.30094090e-02f, -5.04807234e-02f, -9.23537761e-02f, -5.49294578e-04f, -7.67847300e-02f, 1.40035879e-02f,
  7.52478540e-02f, 4.90953540e-03f, 1.91978775e-02f, 8.80302861e-02f, -2.72221230e-02f, -3.86027768e-02f, 2.93667167e-02f, 3.07549089e-02f, -1.83644462e-02f, -5.34605235e-02f,
  9.77707058e-02f, 1.15526624e-01f, 7.49759749e-02f, -1.42485378e-02f, 9.59790647e-02f, 3.12625943e-03f, -9.78346467e-02f, 1.21663317e-01f, -3.55840288e-02f, -4.34675999e-02f,
  -1.59527168e-01f, -4.97644283e-02f, -7.04640672e-02f, -1.06795184e-01f, 2.67194938e-02f, 5.88243566e-02f, -1.30715854e-02f, 3.15004773e-02f, 1.64374098e-01f, 6.10182248e-02f,
  1.44482609e-02f, 7.33833062e-03f, 8.67939144e-02f, 1.13595933e-01f, -1.34736020e-02f, 1.96127333e-02f, -6.89905733e-02f, 1.26421005e-02f, -8.30346942e-02f, -3.68290278e-03f,
  -2.64948849e-02f, 9.28093567e-02f, -7.38588572e-02f, 3.02326423e-03f, -8.10210034e-02f, -5.49534447e-02f, -9.55538452e-03f, -7.52579719e-02f, -3.57466079e-02f, -6.93028793e-02f,
  -8.51526707e-02f, 3.09914872e-02f, -3.71877733e-03f, 9.40557860e-04f, 1.02946334e-01f, -5.47844619e-02f, 7.21313730e-02f, 1.04477450e-01f, -6.75051585e-02f, 1.26152605e-01f,
  -2.63184216e-02f, -8.62340629e-02f, -4.07851674e-02f, 5.14145978e-02f, -8.41139443e-03f, 3.00796330e-03f, -9.45991799e-02f, -7.17525333e-02f, -2.00350601e-02f, 7.07575260e-03f,
  1.20485418e-01f, -4.62383963e-02f, 5.06674014e-02f, -6.44498765e-02f, 3.39446627e-02f, -1.12929501e-01f, -2.22857539e-02f, 2.39562951e-02f, -5.00878915e-02f, -5.11190407e-02f,
  3.00658196e-02f, 4.73923348e-02f, 3.39984633e-02f, 1.29710091e-02f, -2.70588417e-02f, 8.54190253e-03f, -1.50254546e-02f, -3.69205736e-02f, 4.41009179e-02f, 1.10432185e-01f,
  4.97156791e-02f, 7.40915313e-02f, 4.92437296e-02f, -4.19943854e-02f, 3.52879078e-03f, 2.75345035e-02f, -4.84865233e-02f, -2.10079476e-02f, 2.91989129e-02f, -1.35364663e-02f,
  -6.03126697e-02f, -8.33529904e-02f, -9.29170549e-02f, 2.99552958e-02f, -8.78574476e-02f, 4.36956808e-02f, -6.59372732e-02f, -4.31822473e-03f, -1.04715200e-02f, 1.60612352e-02f,
  -2.76195090e-02f, -4.32965606e-02f, 3.70586440e-02f, -5.30104376e-02f, -3.51716354e-02f, 1.97155196e-02f, -9.52555016e-02f, -1.83238517e-02f, -1.05046064e-01f, 9.79426578e-02f,
  9.65676550e-03f, 3.17685790e-02f, 3.46124917e-02f, -6.36343285e-02f, -7.12909997e-02f, -3.98871154e-02f, 3.85406576e-02f, -2.92642117e-02f, -6.02036752e-02f, -5.21837994e-02f,
  1.31010100e-01f, 1.14826187e-01f, 1.29011497e-01f, 2.61742413e-01f, -1.99315578e-01f, -2.79627442e-01f, -1.92383409e-01f, -5.30232005e-02f, -1.10044554e-01f, -1.47553924e-02f,
  6.87430147e-04f, -2.98606772e-02f, 9.96078998e-02f, 5.52301519e-02f, 1.30570531e-01f, -6.08341321e-02f, -2.80584283e-02f, -2.59177741e-02f, -4.76699434e-02f, 1.00657091e-01f,
  8.45261216e-02f, 6.63625374e-02f, 1.66153058e-01f, 1.95292950e-01f, -2.84232423e-02f, 2.80880034e-01f, 2.11848229e-01f, 1.04198210e-01f, 2.30977926e-02f, 3.38775478e-02f,
  -8.02193731e-02f, -7.18006939e-02f, 2.69991923e-02f, -8.57888386e-02f, 9.50084552e-02f, -1.44177899e-02f, 4.25608121e-02f, -8.60466436e-03f, -3.51180620e-02f, 6.79937424e-03f,
  -1.58803351e-02f, 3.42670567e-02f, 1.49641633e-02f, -1.49315316e-02f, -2.11209934e-02f, -2.31481660e-02f, 4.00431454e-03f, 5.36071397e-02f, 5.15778363e-02f, 9.06125978e-02f,
  8.46536905e-02f, -2.34289058e-02f, -2.50541158e-02f, 1.09161049e-01f, 7.44769275e-02f, 1.27353938e-02f, -4.88366522e-02f, -3.63940257e-03f, -9.42501947e-02f, 9.09722876e-03f,
  -1.32288062e-03f, 1.83867961e-02f, -5.37320860e-02f, -3.52503471e-02f, -2.95664966e-02f, -2.30127815e-02f, 5.34938984e-02f, -2.19183285e-02f, 3.15761454e-02f, -2.52557937e-02f,
  3.30792256e-02f, 1.06155425e-01f, -8.44442397e-02f, -1.08356796e-01f, -2.42036711e-02f, -6.65766969e-02f, -3.74310426e-02f, -4.35855016e-02f, -5.71958348e-03f, 3.77632445e-03f,
  -9.24049914e-02f, 2.89126076e-02f, -6.85537905e-02f, 4.71207909e-02f, 1.92031555e-03f, -6.35009035e-02f, 4.74536605e-02f, -8.02712888e-03f, 4.23733518e-02f, -4.79944609e-02f,
  2.91850921e-02f, 2.09393576e-01f, 7.61860982e-03f, 1.99941304e-02f, 5.68884201e-02f, -3.69226895e-02f, 1.23966038e-02f, 9.45590511e-02f, 3.67263588e-03f, 4.60857786e-02f,
  2.44132858e-02f, -9.93092544e-03f, -1.27927780e-01f, 1.75363626e-02f, -4.10135239e-02f, -5.02129160e-02f, 1.09868847e-01f, 7.87520111e-02f, 1.32016875e-02f, 6.96527734e-02f,
  -1.66662149e-02f, 2.89676562e-02f, -7.01621547e-03f, 5.84293948e-03f, 5.75318187e-02f, -9.17566847e-03f, -2.62867729e-03f, -6.30652979e-02f, -2.65425406e-02f, 8.29669535e-02f,
  -8.89155418e-02f, -1.40554309e-02f, -3.17170024e-02f, -1.42190918e-01f, -1.80640835e-02f, -4.57973331e-02f, -1.73337907e-01f, -3.48742083e-02f, 4.15341184e-02f, -4.09307852e-02f,
  -9.39992815e-02f, 4.62780148e-02f, 1.07419997e-01f, -3.19749005e-02f, 7.65894428e-02f, -3.30705405e-03f, -8.12137052e-02f, 5.60374334e-02f, -1.44200232e-02f, -4.08180878e-02f,
  -7.93170463e-03f, -5.39477617e-02f, 1.64668411e-02f, -4.25395258e-02f, -1.45641014e-01f, -5.95206283e-02f, -2.18802709e-02f, -8.17798376e-02f, -1.36021048e-01f, -3.56479026e-02f,
  5.77978007e-02f, 6.06283881e-02f, 5.17588593e-02f, -7.24673495e-02f, -8.63480661e-03f, -5.25904074e-02f, -7.47736543e-02f, -4.73586209e-02f, -7.86236748e-02f, 4.60685454e-02f,
  -1.56780351e-02f, 9.54905711e-03f, -1.11121088e-01f, 7.30568692e-02f, -7.25203529e-02f, -6.99252710e-02f, 2.64708605e-03f, 7.06464499e-02f, -2.72255074e-02f, -9.16414410e-02f,
  5.89482952e-03f, 1.83676393e-03f, -5.37371263e-02f, 7.62393139e-03f, 2.28876006e-02f, -8.62056296e-03f, 3.78861316e-02f, 1.06555469e-01f, 3.49592939e-02f, 4.84027267e-02f,
  5.13130911e-02f, 4.87440862e-02f, 4.04108390e-02f, 9.81050916e-03f, -1.14192683e-02f, -5.22120148e-02f, 5.16657792e-02f, 9.48053971e-02f, -1.50708416e-02f, 1.06884884e-02f,
  8.14047381e-02f, 7.51542300e-02f, 8.85547176e-02f, -4.74625500e-03f, -1.52011625e-02f, -3.43665481e-02f, -5.64413853e-02f, -2.30993386e-02f, -7.46830329e-02f, -4.02263589e-02f,
  5.47430590e-02f, 8.36185962e-02f, 5.84797412e-02f, -1.40605047e-02f, -7.22615644e-02f, 7.16048852e-02f, -9.61901154e-03f, 9.59897563e-02f, 3.56523879e-02f, -5.92890270e-02f,
  -6.55636936e-02f, -1.19679794e-01f, 5.51391467e-02f, -5.11377230e-02f, 4.78793979e-02f, 5.44684287e-03f, -8.62474460e-03f, 6.59724027e-02f, -4.67220210e-02f, -2.14690380e-02f,
  -8.02019015e-02f, -8.50089863e-02f, 6.05492033e-02f, -7.56085664e-02f, -7.58888498e-02f, 6.13262355e-02f, -5.75750545e-02f, 1.57864708e-02f, -5.27083836e-02f, 4.30952311e-02f,
  -3.67069766e-02f, -6.76215813e-02f, 5.94872236e-03f, -4.73368391e-02f, -5.99039160e-02f, 8.48187320e-03f, 7.67655820e-02f, 3.64668928e-02f, -6.28778040e-02f, 7.30336830e-02f,
  5.97570799e-02f, -3.70933600e-02f, -1.50034698e-02f, -5.10983951e-02f, 1.61978342e-02f, -2.06851959e-02f, 3.20255905e-02f, -9.58395079e-02f, -1.02700070e-01f, 6.09492825e-04f,
  2.38681491e-02f, 1.85680520e-02f, -1.73713069e-03f, 4.33735289e-02f, -6.57385215e-02f, -8.52324665e-02f, 3.69581804e-02f, 8.86966288e-02f, -1.24964282e-01f, 4.24130671e-02f,
  -5.72538096e-03f, 3.90450209e-02f, -5.87099679e-02f, -3.19590494e-02f, -7.49567524e-02f, -8.36674497e-02f, -7.19121099e-03f, 3.69668081e-02f, -8.65868330e-02f, 5.67333810e-02f,
  6.16576476e-03f, -7.73623511e-02f, 1.11913309e-02f, 1.52026638e-02f, 1.24861291e-02f, 3.32711972e-02f, 6.77625015e-02f, -7.44519681e-02f, -1.31476875e-02f, -6.75591826e-02f,
  1.43307028e-02f, 7.55539015e-02f, -2.18179971e-02f, -3.75619307e-02f, -5.11097535e-02f, 3.58302929e-02f, -3.36332880e-02f, 1.25882514e-02f, -9.39929485e-02f, -7.61573091e-02f,
  -3.57271433e-02f, -1.24277677e-02f, 1.40370214e-02f, 6.73404932e-02f, -5.06924130e-02f, -1.57368872e-02f, 7.59744421e-02f, 2.34952606e-02f, -5.46807796e-02f, -4.48027886e-02f,
  2.74607632e-02f, 8.85292590e-02f, -9.78641957e-03f, -9.02353600e-02f, -5.21494411e-02f, -6.46312386e-02f, -7.43643334e-03f, 3.43052149e-02f, 7.53157809e-02f, 1.10729160e-02f,
  -8.90332237e-02f, -9.14769694e-02f, 5.31290807e-02f, 7.43225813e-02f, -1.06034130e-02f, -4.23716055e-03f, -3.80672812e-02f, -6.61265925e-02f, 3.95807624e-02f, 7.46612772e-02f,
  -5.25737973e-03f, -5.02370931e-02f, 4.81967703e-02f, -1.62519719e-02f, -3.32577266e-02f, 1.83868241e-02f, 2.69842334e-02f, -8.41727331e-02f, -5.37318215e-02f, -4.42692041e-02f,
  1.21494010e-01f, 8.23950861e-03f, 2.38994043e-03f, -6.28979504e-02f, -4.83820438e-02f, 2.12739687e-02f, -2.27132626e-02f, 3.41714243e-04f, 5.10376971e-03f, -4.54050452e-02f,
  9.95981246e-02f, 2.43621506e-02f, -3.33076566e-02f, -7.28226304e-02f, 7.29948282e-02f, -8.61760005e-02f, 5.29654771e-02f, -4.02027182e-02f, 8.81082788e-02f, 3.07380483e-02f,
  8.50807428e-02f, 7.56832883e-02f, -3.13237705e-03f, 6.74008802e-02f, 8.42420980e-02f, 7.46174082e-02f, 2.18318570e-02f, 9.59010050e-02f, 5.38018607e-02f, 7.81442896e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -8.49862918e-02f, 1.21243440e-01f, -6.67337421e-03f, -8.22549164e-02f, -6.55131638e-02f, -1.36446320e-02f, 6.32396713e-02f, 1.10154450e-01f, 9.19443741e-03f, 7.78498501e-02f,
  -1.92523859e-02f, -1.34565860e-01f, 1.19114257e-01f, 6.47143945e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.13875309e-01f, -1.52521832e-02f, -1.14157267e-01f, -6.35098368e-02f, -1.05139017e-01f, -1.72871485e-01f, 9.16228294e-02f, 9.21511278e-02f, 5.23297414e-02f, 3.18670236e-02f,
  3.43411528e-02f, 1.19678713e-01f, 4.51955795e-02f, 1.63464352e-01f, -1.58471651e-02f, 1.47399902e-01f, 3.03521436e-02f, -2.19673589e-01f, -3.90592441e-02f, 7.77487308e-02f,
  2.11750176e-02f, -6.35735989e-02f, 8.02913904e-02f, -1.36980966e-01f, -8.46267343e-02f, 3.86333317e-02f, 3.44621874e-02f, -1.08623371e-01f, -3.25521640e-02f, -7.61594698e-02f,
  3.92450728e-02f, -7.66454712e-02f, 1.07420921e-01f, -1.88642502e-01f, 1.12012789e-01f, 5.25728799e-04f, -2.50384724e-03f, -6.95384890e-02f, -3.00870091e-01f, 2.14159250e-01f,
  1.09625101e-01f, -2.81775862e-01f, 2.13874429e-02f, -2.10123956e-01f, -6.31937198e-03f, -6.39785826e-02f, 6.06481656e-02f, 8.05320367e-02f, -2.01167345e-01f, -2.24039972e-01f,
  2.80494541e-02f, 8.92854556e-02f, -2.05037128e-02f, -7.81726614e-02f, -6.19567037e-02f, -1.87174261e-01f, -4.04142514e-02f, 1.60937130e-01f, -1.20543316e-02f, -8.49446133e-02f,
  -1.96326822e-01f, -3.90753746e-02f, 4.55556344e-03f, -7.48040602e-02f, -9.77050141e-02f, 1.37217985e-02f, 5.84357791e-02f, -9.31871235e-02f, -3.87741476e-02f, -7.90705308e-02f,
  -1.41646877e-01f, 1.18143529e-01f, -5.09547926e-02f, -3.45550552e-02f, -1.63157079e-02f, 8.75788629e-02f, 6.97406456e-02f, -8.47391132e-03f, -6.19311817e-02f, 5.58196269e-02f,
  -1.31980255e-01f, 1.37745991e-01f, -8.02973732e-02f, -1.42678097e-01f, -1.19942695e-01f, -1.76544096e-02f, -1.40661746e-01f, 1.42567875e-02f, 1.14481017e-01f, -1.46187440e-01f,
  -8.47035646e-02f, 2.05564439e-01f, 1.38375565e-01f, -2.71977454e-01f, 4.03577052e-02f, 3.72586429e-01f, 5.19161439e-03f, -4.71792221e-02f, -1.18970111e-01f, 1.46763489e-01f,
  1.76729560e-01f, -2.39201054e-01f, 5.33899106e-02f, 5.25239706e-02f, 1.69263363e-01f, -4.49365878e-04f, -2.32321784e-01f, 1.95592493e-01f, -1.04832068e-01f, -6.93578869e-02f,
  -5.97114861e-02f, 7.35159963e-02f, 1.19982541e-01f, -2.78132886e-01f, -2.64680367e-02f, -8.79704580e-02f, 1.81886718e-01f, 1.01060621e-01f, -1.38160974e-01f, -1.61505938e-01f,
  1.39999673e-01f, -1.56349912e-01f, -7.39949420e-02f, 1.30417824e-01f, 1.71317279e-01f, -1.10197924e-01f, 8.36048424e-02f, -1.18245490e-01f, 6.41591568e-03f, -1.32609621e-01f,
  3.00842226e-02f, -1.30088385e-02f, -9.33358818e-02f, -4.16199444e-03f, 6.64352998e-02f, -4.49033827e-02f, -4.09419425e-02f, -1.26073897e-01f, 3.37242670e-02f, 1.07937507e-01f,
  -1.68891802e-01f, -7.39510581e-02f, 8.02679956e-02f, 4.94622998e-02f, 4.32525156e-03f, 9.68894586e-02f, -7.94001520e-02f, 6.95992932e-02f, -3.52857150e-02f, -5.88197522e-02f,
  -2.20183972e-02f, 1.57589272e-01f, -1.22743815e-01f, 1.53114527e-01f, 1.05849274e-01f, -2.37608820e-01f, -1.57130007e-02f, 2.93244988e-01f, -5.04385754e-02f, 1.18084461e-03f,
  -9.55282301e-02f, 1.84451472e-02f, 6.68707937e-02f, 9.39307641e-03f, -5.14369160e-02f, 1.26037095e-02f, 1.77919924e-01f, -1.24731235e-01f, -2.12209925e-01f, -7.45771900e-02f,
  1.40239567e-01f, -1.14327013e-01f, 1.03852890e-01f, 1.63673565e-01f, 2.04551443e-02f, 6.46398962e-02f, 1.00667380e-01f, 1.19146615e-01f, -1.31291032e-01f, -1.98156565e-01f,
  -8.93083960e-02f, 3.34859639e-02f, 1.31666079e-01f, -1.75482854e-02f, 9.05340165e-02f, -7.19920546e-03f, -8.48060995e-02f, -2.50224732e-02f, 9.83184204e-02f, 1.92788824e-01f,
  -7.17116054e-03f, -1.31728845e-02f, 1.28858387e-01f, -1.17129818e-01f, -5.15867583e-03f, -6.88893795e-02f, 1.06853424e-02f, -3.14863808e-02f, 1.07538573e-01f, 1.20551318e-01f,
  8.33515152e-02f, -1.61067009e-01f, 1.44582242e-01f, 2.38043554e-02f, 6.55453503e-02f, 6.74610138e-02f, 1.38815746e-01f, -9.05801058e-02f, 8.77437592e-02f, -2.35222895e-02f,
  1.64145991e-01f, -6.78026751e-02f, 8.40101764e-02f, 1.54326661e-02f, -5.69267459e-02f, 8.59920904e-02f, -7.97154382e-02f, 2.17158958e-01f, 1.59656648e-02f, -7.57499486e-02f,
  1.41114354e-01f, 2.44202897e-01f, -7.13195130e-02f, -1.05067626e-01f, 7.55100548e-02f, -8.52458477e-02f, 1.06712691e-01f, -1.04859009e-01f, 1.03115633e-01f, 6.59626424e-02f,
  1.13375798e-01f, -8.76299515e-02f, 1.48980012e-02f, 2.23497041e-02f, 2.26208463e-01f, -1.90884441e-01f, -1.65498286e-01f, 1.37881553e-02f, -2.15063081e-03f, 5.85497022e-02f,
  2.75982562e-02f, 1.77846938e-01f, -7.04304595e-03f, -3.03040724e-02f, -1.35079682e-01f, -8.60940069e-02f, 1.45118311e-02f, 5.53779490e-02f, -1.33606836e-01f, 5.88259809e-02f,
  1.52124660e-02f, -3.13887256e-03f, -1.32682607e-01f, -2.40533426e-02f, -3.50723788e-02f, 7.82862008e-02f, 1.13250412e-01f, 1.37527853e-01f, 8.22670683e-02f, 1.83403329e-03f,
  -2.38252934e-02f, -4.12375145e-02f, -1.32058531e-01f, -1.00547545e-01f, -1.00987941e-01f, -1.54039683e-02f, 2.95726620e-02f, -9.90437791e-02f, -2.55011991e-02f, -1.16638489e-01f,
  -5.65200076e-02f, -8.97133052e-02f, 6.91398829e-02f, 1.27812698e-01f, -6.62896037e-02f, 5.23885302e-02f, 1.45890921e-01f, 2.41361141e-01f, 6.17314018e-02f, -1.46915331e-01f,
  1.23170957e-01f, -2.00569957e-01f, -1.62115082e-01f, -3.13361622e-02f, -6.59381747e-02f, -7.16620237e-02f, -7.53328577e-02f, 1.63517997e-01f, -7.86890164e-02f, -5.09832017e-02f,
  4.34117205e-02f, -4.08802293e-02f, 7.95329958e-02f, -2.67506968e-02f, 9.13322121e-02f, 1.06361181e-01f, -7.23305568e-02f, 1.37994155e-01f, -1.78645968e-01f, 1.33679748e-01f,
  -7.02893734e-02f, -1.57720804e-01f, -1.74326897e-01f, 7.85088241e-02f, 1.23907015e-01f, 4.88319509e-02f, 2.52759829e-03f, -7.91604966e-02f, 5.72969615e-02f, 7.36469105e-02f,
  -1.13114148e-01f, -1.82089940e-01f, -2.36016978e-02f, -1.61324814e-02f, -3.62955034e-02f, -3.65012214e-02f, 9.19032693e-02f, -1.03048109e-01f, 3.46221216e-02f, -1.07468739e-01f,
  -8.08263421e-02f, -2.55136993e-02f, 2.24255398e-02f, 1.17932968e-01f, 8.76162276e-02f, 1.55964613e-01f, -1.54960588e-01f, -1.26285136e-01f, 1.26221254e-01f, 9.36523527e-02f,
  4.07915004e-02f, 8.29942897e-02f, 1.07688010e-01f, -1.11540198e-01f, -4.04138081e-02f, -7.13522360e-02f, 7.81891420e-02f, 1.14979923e-01f, 4.40494530e-02f, -5.66835888e-02f,
  2.91609019e-02f, 2.65150309e-01f, 9.61367786e-03f, -1.12968743e-01f, -9.23892781e-02f, -5.84839098e-02f, -2.49955766e-02f, 8.17867368e-02f, -4.44357470e-02f, -1.71420291e-01f,
  -5.86603908e-03f, 6.13218248e-02f, -7.16754198e-02f, 1.43199274e-02f, -1.50596246e-01f, -2.54852567e-02f, 3.87701467e-02f, -1.87619686e-01f, 4.21866104e-02f, -7.72080943e-02f,
  -4.20023911e-02f, 1.92832485e-01f, -2.20410928e-01f, 9.99286324e-02f, 1.62106514e-01f, -1.43071398e-01f, 4.39772308e-02f, 5.23245186e-02f, 5.53794466e-02f, -8.15591738e-02f,
  -8.68419036e-02f, 1.35034144e-01f, -3.46501544e-02f, -7.47194290e-02f, 4.30277586e-02f, -1.15038119e-01f, -3.65214273e-02f, -2.63695512e-02f, 5.17663993e-02f, 1.81104410e-02f,
  -3.46401185e-02f, -1.14452094e-01f, -1.14252441e-01f, -6.23214655e-02f, 8.19580257e-02f, 8.03098157e-02f, 7.71824121e-02f, -5.07223010e-02f, -3.14362794e-02f, 9.33692418e-03f,
  7.26306587e-02f, 1.37172446e-01f, -3.62947360e-02f, -1.34386539e-01f, 1.03534088e-01f, -5.03725037e-02f, -1.08136587e-01f, -2.07345467e-03f, -7.18426257e-02f, -6.93152249e-02f,
  3.41519415e-02f, 3.40185836e-02f, 1.65230677e-01f, 3.31118368e-02f, 7.32731149e-02f, -4.09561880e-02f, 1.01330034e-01f, -7.46725500e-02f, 1.04011908e-01f, 5.91371097e-02f,
  6.23522215e-02f, 6.68312162e-02f, 1.23398840e-01f, 5.82140833e-02f, -1.14740571e-02f, 1.64839283e-01f, -6.97030574e-02f, -7.26193516e-03f, -1.01429172e-01f, 1.28817439e-01f,
  1.22993208e-01f, 7.11685494e-02f, 2.03989027e-03f, 6.57327548e-02f, -1.00631580e-01f, -2.59339940e-02f, -7.93607756e-02f, 1.38913333e-01f, -7.40344226e-02f, 1.37074396e-01f,
  -9.61629488e-03f, 9.68988091e-02f, 1.40960693e-01f, -1.32312462e-01f, -1.09541208e-01f, -7.99444169e-02f, 3.59137617e-02f, -9.69286785e-02f, 9.03266147e-02f, 1.62887096e-01f,
  -1.78120844e-02f, -1.23750784e-01f, 1.00918688e-01f, 1.95268113e-02f, 1.81387067e-02f, 1.72132730e-01f, 6.22896850e-02f, -6.54313415e-02f, -2.83910967e-02f, -1.20010249e-01f,
  -1.21879160e-01f, 3.33337598e-02f, -2.87323557e-02f, -1.37601048e-01f, 8.42291489e-03f, 9.15736109e-02f, -2.70133503e-02f, -1.36096314e-01f, 4.73267101e-02f, 1.05865173e-01f,
  7.13261124e-03f, 2.38559306e-01f, 2.99868528e-02f, -6.78725587e-03f, 1.63992614e-01f, -1.43378809e-01f, -6.13886900e-02f, 6.10455452e-03f, -5.77822402e-02f, -1.07237086e-01f,
  1.38860136e-01f, 2.72673368e-02f, -6.53559854e-03f, 1.54509872e-01f, -1.32659525e-01f, -3.86353247e-02f, 1.86292138e-02f, -9.77910310e-02f, -4.58623283e-02f, 1.98562831e-01f,
  8.68754834e-02f, -1.46431223e-01f, 1.65979136e-02f, 1.18542174e-02f, 1.85750231e-01f, -6.78413436e-02f, 1.28866360e-01f, -7.56136002e-03f, 1.38619587e-01f, -1.56303182e-01f,
  6.99211732e-02f, -1.58402175e-01f, -1.51358038e-01f, -1.22272242e-02f, -2.87448633e-02f, 1.23181812e-01f, 1.25129670e-01f, 7.69847408e-02f, -9.37486812e-02f, -1.31625175e-01f,
  4.24251333e-02f, -6.47421032e-02f, -8.60318691e-02f, -3.42514669e-03f, 8.53650123e-02f, 1.76984578e-01f, -1.05249457e-01f, -1.03447832e-01f, -1.58959866e-01f, -7.18590245e-02f,
  8.52106065e-02f, 1.32171527e-01f, -8.46541207e-03f, 3.61464615e-03f, -6.63749129e-02f, -1.55274436e-01f, -7.64688756e-03f, -9.33338553e-02f, 1.23628499e-02f, -3.72237600e-02f,
  -1.95268705e-01f, 1.33090898e-01f, 1.80193745e-02f, -3.77040952e-02f, -1.15095250e-01f, -6.06237613e-02f, -9.82429087e-02f, 1.54282212e-01f, -3.85655579e-03f, -2.10538685e-01f,
  -2.53088884e-02f, -9.45969149e-02f, 1.06799230e-02f, 1.63245514e-01f, 1.65598579e-02f, 4.80310395e-02f, -1.36495277e-01f, -1.00874670e-01f, -1.24296926e-01f, 2.16199569e-02f,
  -1.50559276e-01f, -1.99748337e-01f, 1.54136848e-02f, -6.93060458e-02f, 4.17876467e-02f, -1.52091980e-01f, -8.84841233e-02f, -2.03458257e-02f, 1.45226225e-01f, -1.32319227e-01f,
  -3.23875606e-01f, 2.30008706e-01f, 1.52214184e-01f, -1.98743284e-01f, 1.39850408e-01f, -4.16592620e-02f, 4.84610498e-02f, -2.25018799e-01f, -1.49496580e-02f, 5.72625697e-02f,
  -1.09356418e-01f, -1.27133310e-01f, 3.75484675e-02f, 1.71142042e-01f, 1.12943806e-01f, -8.60944018e-02f, -1.58653811e-01f, -7.90952221e-02f, 2.01611638e-01f, -4.04588394e-02f,
  3.64808440e-02f, 4.06885110e-02f, -8.26046430e-03f, -1.48527488e-01f, 1.43569231e-01f, 9.84383672e-02f, 6.50199875e-02f, -1.84135735e-01f, 7.14766011e-02f, 7.56616220e-02f,
  -2.14897040e-02f, 1.93465650e-02f, 1.23235052e-02f, 1.41227573e-01f, -8.34130868e-02f, -1.58954188e-01f, 3.31825092e-02f, 2.94633619e-02f, 6.79248124e-02f, 1.87164061e-02f,
  -4.72786538e-02f, 1.10416878e-02f, -8.62658620e-02f, 1.64683416e-01f, 7.15489835e-02f, -5.84305227e-02f, 1.52545676e-01f, -1.39208034e-01f, -6.01521321e-02f, -6.64436221e-02f,
  2.22467650e-02f, 1.79811940e-01f, 4.03128229e-02f, 4.43095416e-02f, 2.40944296e-01f, -1.77723885e-01f, 8.41563568e-02f, -8.75628218e-02f, 1.51082650e-01f, 1.50367513e-01f,
  -5.85706159e-02f, 2.80011967e-02f, -4.55481112e-02f, 1.57884344e-01f, 2.32800171e-02f, 5.88066727e-02f, -1.28560007e-01f, -9.35865752e-03f, -4.25942009e-03f, -1.78289950e-01f,
  -2.21630290e-01f, 1.13370679e-01f, 6.44044578e-02f, 1.84868589e-01f, 3.76403220e-02f, -1.49753943e-01f, 3.96098718e-02f, 1.93152770e-01f, 8.93812254e-02f, -5.49454289e-03f,
  -1.02505319e-01f, -3.77002731e-02f, 3.53407450e-02f, -6.80388436e-02f, 6.13650642e-02f, -7.06040710e-02f, -2.77267210e-02f, 5.58928698e-02f, 6.57110661e-02f, 9.55398753e-02f,
  -1.01488732e-01f, -8.63835290e-02f, -5.56885004e-02f, -1.63201466e-02f, -8.82370919e-02f, 3.21927704e-02f, -1.35053992e-01f, 3.36651318e-02f, -1.01926476e-01f, 2.11767014e-02f,
  1.57873402e-03f, -9.60944444e-02f, -2.83408947e-02f, -1.06662530e-02f, 8.47468898e-02f, 8.00677389e-02f, -1.51308402e-01f, 7.91262388e-02f, -1.54382348e-01f, 3.26640084e-02f,
  -8.92525259e-03f, -1.67320517e-03f, 6.69170171e-02f, -2.91309226e-02f, -2.36185994e-02f, -8.23695436e-02f, 1.00094646e-01f, -1.32491812e-01f, -1.04404479e-01f, 1.54275611e-01f,
  9.75349694e-02f, 3.27749401e-02f, 6.56106994e-02f, -3.77039276e-02f, -8.21265355e-02f, 1.08762592e-01f, -1.22150639e-02f, 5.20723052e-02f, 4.82317396e-02f, 1.95562951e-02f,
  5.12876315e-03f, -4.61941306e-03f, -3.34512070e-02f, 1.70322061e-02f, 9.72640738e-02f, -3.08864638e-02f, 3.93073149e-02f, -2.77820248e-02f, -2.71725897e-02f, 5.57155311e-02f,
  9.15785972e-03f, -9.64460224e-02f, 9.76493061e-02f, 1.05675049e-02f, 9.91156101e-02f, 1.61057170e-02f, -8.80899057e-02f, -4.68646772e-02f, -7.46395960e-02f, 6.64944947e-02f,
  1.34704500e-01f, 1.18997693e-01f, -9.73831266e-02f, 7.26298168e-02f, -8.25403854e-02f, 1.00089744e-01f, 1.33342817e-01f, 3.97866629e-02f, 8.62435773e-02f, -4.24718857e-02f,
  7.37738272e-04f, 3.29305381e-02f, 1.77123980e-03f, 1.44404724e-01f, -9.16424543e-02f, -1.09872431e-01f, -1.11303180e-01f, -1.69084296e-01f, -2.98193600e-02f, 8.94004479e-02f,
  -5.57059348e-02f, -7.24657392e-03f, -8.14692974e-02f, -1.42531514e-01f, -8.88589472e-02f, 1.73429906e-01f, 7.23692179e-02f, 4.18276563e-02f, -8.89198575e-03f, -1.26355842e-01f,
  5.81914671e-02f, -7.22545758e-02f, -8.93271118e-02f, 2.65419241e-02f, -7.73045188e-03f, 4.76701930e-02f, -9.88550335e-02f, 2.78445873e-02f, -7.52688646e-02f, 2.76765823e-02f,
  -6.13295287e-02f, 1.01566287e-02f, 1.55061260e-01f, -2.07017958e-02f, -1.56687107e-02f, 2.28408679e-01f, -6.45734221e-02f, 2.82954555e-02f, 1.79906309e-01f, -1.23783723e-01f,
  -6.29520118e-02f, -8.50861818e-02f, 5.43640479e-02f, 9.93339717e-03f, -1.33694202e-01f, -1.37522489e-01f, -7.16364086e-02f, 2.81719584e-02f, 9.81366262e-02f, -5.54283820e-02f,
  -1.10521372e-02f, -2.38490812e-02f, -4.62094415e-03f, 1.48838669e-01f, 1.30234063e-01f, -1.18462481e-01f, -1.25264078e-01f, 2.54070852e-02f, 1.79014608e-01f, 1.30795300e-01f,
  2.57630646e-02f, -1.15387499e-01f, 1.31548852e-01f, 3.78616266e-02f, 2.25650277e-02f, 1.10300891e-01f, 6.92500845e-02f, 2.06745610e-01f, -2.44180560e-02f, -7.50717074e-02f,
  9.16540921e-02f, -1.08483709e-01f, -1.02360271e-01f, 3.16556878e-02f, 8.26223493e-02f, 1.15238531e-02f, 6.15032017e-02f, -6.66202158e-02f, 2.02056885e-01f, 2.64363617e-01f,
  1.73792124e-01f, 1.35189556e-02f, 1.90029562e-01f, 1.06741330e-02f, -2.57443726e-01f, 6.94774315e-02f, -1.80198312e-01f, -1.06224000e-01f, 8.03605467e-02f, -1.89629123e-02f,
  -1.22807071e-01f, -8.03167596e-02f, -4.91987094e-02f, 1.21429414e-02f, -7.47335926e-02f, 2.73471531e-02f, -2.21398170e-03f, 1.48529023e-01f, -8.71862620e-02f, 9.61419418e-02f,
  3.29997689e-02f, -5.11642806e-02f, 1.28773749e-02f, -1.55180454e-01f, -2.22004145e-01f, -4.21403721e-02f, 5.14207445e-02f, -2.83929463e-02f, -3.67342979e-02f, -1.16187707e-02f,
  8.20916519e-02f, -8.45033005e-02f, 1.19895294e-01f, -1.08493283e-01f, 4.89777215e-02f, 4.85210307e-02f, -3.98908108e-02f, 1.65386628e-02f, -3.09682898e-02f, -2.16930106e-01f,
  9.09731463e-02f, 1.15493663e-01f, -1.94582641e-01f, 6.03814013e-02f, -1.64625943e-02f, 4.14226204e-03f, 9.29072723e-02f, -1.02060013e-01f, 2.09717043e-02f, -1.51191959e-02f,
  1.17918357e-01f, 7.93259405e-03f, -8.46588686e-02f, 2.95773428e-02f, -3.00750472e-02f, 6.17572367e-02f, -4.14916947e-02f, -1.09601477e-02f, 6.45548999e-02f, -1.73471883e-01f,
  -1.35871679e-01f, 2.24427376e-02f, -1.32710174e-01f, -2.18904451e-01f, -6.99388562e-03f, 9.81629640e-02f, 7.92601053e-03f, -2.09783539e-02f, 8.76871943e-02f, -2.16837361e-01f,
  -3.47643979e-02f, 4.77234982e-02f, 2.13235896e-02f, 1.82791710e-01f, 1.17875577e-03f, -1.88745156e-01f, 3.67702208e-02f, 1.30025782e-02f, 1.02592655e-01f, -1.79799289e-01f,
  -1.44802794e-01f, 9.16534886e-02f, -5.51111586e-02f, -4.81669232e-02f, 9.10184383e-02f, -5.36183640e-02f, -1.71202831e-02f, -1.84803888e-01f, -1.31519794e-01f, -9.21972841e-03f,
  1.00202836e-01f, 6.24514110e-02f, 4.26539257e-02f, -1.28744796e-01f, -1.41279511e-02f, -9.84127745e-02f, -6.79810792e-02f, -4.77649122e-02f, -1.00208148e-02f, -8.54669064e-02f,
  8.70390311e-02f, 2.23858654e-02f, -8.46876651e-02f, -1.74296111e-01f, 9.11931023e-02f, -4.09824327e-02f, 1.27168179e-01f, -1.57594845e-01f, 1.02167763e-01f, 4.99259494e-02f,
  6.16514832e-02f, 5.40598594e-02f, -5.24174571e-02f, 1.03970636e-02f, -4.92781140e-02f, -1.58467665e-01f, -3.82989347e-02f, 1.15751073e-01f, -1.11454520e-02f, 6.64175313e-04f,
  9.99425799e-02f, 3.74654084e-02f, 1.98708996e-02f, 1.85787544e-01f, 9.01797786e-02f, -8.90675783e-02f, 3.75921614e-02f, -1.74791440e-01f, 3.27755976e-03f, -3.57163027e-02f,
  1.66480020e-01f, 6.09390140e-02f, -5.31346165e-02f, 2.15186179e-01f, 1.68796375e-01f, -6.86646029e-02f, -5.56722097e-03f, 1.40366927e-01f, 8.10925737e-02f, -8.35808739e-02f,
  -1.37805909e-01f, 3.16233151e-02f, 1.40422821e-01f, -3.39464620e-02f, 1.51539713e-01f, 1.77761726e-02f, 1.82306409e-01f, 7.94983730e-02f, 5.06673120e-02f, 1.26790479e-01f,
  -6.54697865e-02f, 1.20155536e-01f, -6.09398335e-02f, 1.43170059e-01f, 1.69239089e-01f, -1.50597179e-02f, -6.64008558e-02f, -7.43549317e-02f, 1.37465507e-01f, 6.99196011e-02f,
  -8.03130046e-02f, -4.20463905e-02f, -5.96713834e-02f, -1.58166036e-01f, -7.59967864e-02f, -1.27456397e-01f, -1.11696564e-01f, 1.78236410e-01f, 5.18811047e-02f, -8.98301154e-02f,
  -1.69128701e-01f, 2.16368982e-03f, 7.13518709e-02f, -8.16539675e-02f, 8.20556879e-02f, -1.04914255e-01f, -3.56998444e-02f, -7.62565657e-02f, -8.39184225e-02f, -8.40611011e-02f,
  -5.80542050e-02f, 1.30003765e-01f, -3.57774124e-02f, 5.03451861e-02f, -6.68178648e-02f, -1.01581000e-01f, 3.29982080e-02f, -1.99513417e-02f, -1.88459679e-01f, 5.08159511e-02f,
  -1.14026420e-01f, -1.10352896e-01f, -5.83357597e-03f, 9.03266966e-02f, -1.84169617e-02f, 1.53488234e-01f, -3.00750621e-02f, -2.28987215e-03f, 4.18783352e-02f, 1.82759315e-01f,
  -4.57131192e-02f, 4.09117900e-02f, 7.08830804e-02f, 4.14387695e-02f, -4.44188677e-02f, 1.60081163e-01f, 2.17175181e-03f, -1.24344274e-01f, 2.94387545e-02f, 2.90601142e-02f,
  9.55605358e-02f, 1.32841775e-02f, 2.17570700e-02f, 6.68009818e-02f, -7.33956993e-02f, 8.85042176e-02f, 8.21027085e-02f, -5.69627918e-02f, -1.98702421e-02f, -9.99079794e-02f,
  -3.12910564e-02f, -1.52039662e-01f, 7.29865581e-02f, 1.30239949e-01f, -1.30300745e-01f, 5.14552370e-02f, 1.05794974e-01f, -7.38339275e-02f, 5.49710132e-02f, 4.37991275e-03f,
  6.53524324e-02f, 5.55378059e-03f, 8.18692222e-02f, -1.19437110e-02f, 6.85303956e-02f, 1.82588287e-02f, -1.43267155e-01f, -1.54223293e-01f, 8.43115523e-02f, 1.87205039e-02f,
  -9.73878577e-02f, 1.15162201e-01f, -3.94366402e-03f, -1.29868507e-01f, -9.91591662e-02f, 2.64633037e-02f, 9.59575102e-02f, 9.47246924e-02f, 4.99651954e-02f, 1.83513090e-01f,
  1.48227662e-01f, -1.31313100e-01f, 1.31919071e-01f, 1.40338093e-01f, 1.30855232e-01f, 7.07341805e-02f, -2.63731405e-02f, -7.86134228e-02f, -4.96961512e-02f, 8.85773972e-02f,
  2.35529039e-02f, 7.42821693e-02f, 1.26433775e-01f, -2.31468141e-01f, -8.65515694e-02f, 5.89668797e-03f, -5.83243296e-02f, -5.84593080e-02f, -7.99110457e-02f, -9.41703320e-02f,
  -3.21466476e-02f, 7.58985877e-02f, -1.24311566e-01f, 7.15249404e-02f, 1.94375589e-01f, -2.30924234e-01f, 1.25491982e-02f, -1.25023440e-01f, -1.06650144e-01f, -3.62568684e-02f,
  -6.23336062e-02f, 1.17275365e-01f, -1.06037341e-01f, -1.58643484e-01f, -7.47629330e-02f, -4.85957377e-02f, 1.25674292e-01f, 4.69186716e-02f, -7.64466776e-03f, 3.08954678e-02f,
  4.73928824e-02f, 7.56362304e-02f, -9.06314477e-02f, -1.58361331e-01f, -1.81370154e-01f, 5.81172965e-02f, 5.62108122e-03f, 6.32529408e-02f, 1.55211136e-01f, 1.30836040e-01f,
  1.19172685e-01f, -2.28855573e-02f, 4.57580648e-02f, 2.98009124e-02f, -1.34409755e-01f, -2.44928338e-02f, -1.08917229e-01f, 6.31256178e-02f, -4.83634695e-02f, -8.31302851e-02f,
  1.50667489e-01f, -2.05596656e-01f, -9.02344212e-02f, 2.82616559e-02f, -6.96933866e-02f, 1.54273555e-01f, 5.48144318e-02f, -1.32459804e-01f, 5.06253541e-02f, 2.83451289e-01f,
  5.42652458e-02f, -1.46724686e-01f, -2.27216259e-02f, -6.24378286e-02f, -1.39569283e-01f, 5.71522005e-02f, 5.29336147e-02f, -1.70351803e-01f, -8.98225605e-02f, -1.66624308e-01f,
  5.49219130e-03f, 1.73275873e-01f, -1.63702473e-01f, 4.46751267e-02f, 2.13267300e-02f, 9.06249136e-03f, 1.06506698e-01f, -1.52581483e-02f, -2.96086855e-02f, 1.84237529e-02f,
  -5.30740581e-02f, 1.34028926e-01f, -5.20555340e-02f, 1.53645724e-01f, -9.24669579e-02f, -2.32980028e-02f, 3.40071656e-02f, 5.82740791e-02f, -1.08604729e-01f, -2.74251085e-02f,
  6.65275306e-02f, -1.12892672e-01f, 1.58776015e-01f, -6.06350824e-02f, -1.61651671e-01f, -2.67563164e-02f, 2.51554660e-02f, -1.19537860e-01f, -6.45462573e-02f, 9.75962430e-02f,
  -1.53672814e-01f, -2.92998739e-03f, -2.84572337e-02f, 7.38043636e-02f, 6.50425032e-02f, -1.50131136e-01f, -5.32407761e-02f, -1.11458756e-01f, 5.65084219e-02f, 1.20961815e-01f,
  -6.08742312e-02f, 1.43219650e-01f, -1.38067052e-01f, 6.45554662e-02f, 8.29720870e-02f, 5.88945448e-02f, 1.25217095e-01f, -3.71443778e-02f, -6.49348348e-02f, -1.42000377e-01f,
  -9.88848880e-02f, -1.01295546e-01f, -2.55403910e-02f, 1.36174724e-01f, -1.62302777e-02f, 3.70615977e-03f, 3.64426225e-02f, -7.17493221e-02f, -1.37003854e-01f, 1.18964642e-01f,
  -4.16423900e-05f, -2.56171018e-01f, 4.02551070e-02f, -7.32628703e-02f, 2.31514964e-02f, 5.26455007e-02f, -1.05351098e-01f, -6.94958419e-02f, -5.24876378e-02f, -7.60076866e-02f,
  -1.55924127e-01f, 1.26681384e-02f, 1.37095347e-01f, -1.03824370e-01f, 8.98745507e-02f, 1.04115969e-02f, -7.71704540e-02f, -1.32701084e-01f, -1.29632028e-02f, -1.14812003e-02f,
  -1.34368436e-02f, -4.58124839e-02f, 1.52474582e-01f, 1.63461953e-01f, 7.41883665e-02f, 5.84402643e-02f, 2.39015766e-03f, -7.08297919e-03f, 1.46845669e-01f, 1.47238806e-01f,
  -9.58653390e-02f, -1.77594926e-03f, -5.20770848e-02f, -1.37153447e-01f, 2.39717290e-02f, -7.02105388e-02f, -1.65263832e-01f, 7.04521388e-02f, -1.39614651e-02f, 4.75441515e-02f,
  -3.07226125e-02f, -1.20466515e-01f, 5.33796214e-02f, 1.76607281e-01f, -5.04932031e-02f, 7.03242943e-02f, -1.04685798e-01f, 1.14210278e-01f, -3.49728540e-02f, -1.12001020e-02f,
  8.33616555e-02f, 1.71342224e-01f, 1.60355698e-02f, -5.38046844e-02f, -1.88514754e-01f, -5.83174229e-02f, -3.56487222e-02f, -5.19312769e-02f, -3.82160880e-02f, 1.46485046e-01f,
  2.94577461e-02f, -1.30602822e-01f, 2.15311330e-02f, -1.74940228e-01f, -1.08808652e-01f, -1.23391025e-01f, -3.22997607e-02f, 7.02069253e-02f, -5.30744977e-02f, -7.13169947e-02f,
  7.02463239e-02f, 1.28421992e-01f, 4.43894323e-03f, -2.50260346e-02f, -2.06017807e-01f, 1.03601873e-01f, 7.55406842e-02f, -1.96324855e-01f, -2.70427600e-03f, -7.59612769e-02f,
  6.15723282e-02f, -1.11123338e-01f, 7.40797296e-02f, 8.90363529e-02f, -4.30899262e-02f, -1.37131348e-01f, -3.78449671e-02f, -4.92841154e-02f, -1.16547253e-02f, -1.08596221e-01f,
  -3.96509171e-02f, -1.21715851e-01f, 3.21672820e-02f, -4.12302837e-02f, 1.05257735e-01f, 4.76610586e-02f, 4.95148003e-02f, -1.62921309e-01f, 4.27038334e-02f, -5.50953634e-02f,
  4.78846803e-02f, 3.87399830e-02f, -5.37327491e-02f, 3.57430167e-02f, 2.25019688e-03f, -2.01894436e-02f, -5.78728393e-02f, -6.71656802e-02f, -1.92419559e-01f, 1.96650326e-01f,
  6.20798469e-02f, -1.45984992e-01f, 8.40116292e-02f, -1.45401239e-01f, 5.84534481e-02f, 1.26106590e-01f, 5.70506565e-02f, -1.86840504e-01f, -2.14195117e-01f, 6.73212409e-02f,
  -8.46881270e-02f, 1.39494985e-01f, -5.97238056e-02f, 8.69740322e-02f, -1.20238341e-01f, -1.43785387e-01f, -6.63430393e-02f, -1.98854715e-01f, -2.62919426e-01f, 1.06225237e-01f,
  -7.83004016e-02f, -5.09584658e-02f, -1.02173209e-01f, -1.16203398e-01f, -1.00531923e-02f, -1.05567545e-01f, -5.17186970e-02f, 1.27380759e-01f, -3.47845606e-04f, 3.29891779e-02f,
  -7.31011555e-02f, -5.24384081e-02f, 6.91906512e-02f, 1.12884268e-01f, 6.81278110e-02f, -1.19521469e-01f, 5.04087284e-03f, -4.08205874e-02f, -4.30684984e-02f, -3.92202064e-02f,
  -1.82517506e-02f, 2.96650622e-02f, -9.62101296e-02f, 7.54694641e-02f, 1.19487271e-02f, 4.82152915e-03f, 1.31962150e-01f, -8.50359350e-02f, 2.70384084e-02f, 1.32353067e-01f,
  3.40168215e-02f, -7.53556564e-02f, 1.46407634e-01f, -1.51418567e-01f, 1.65042251e-01f, 1.25699237e-01f, 6.29295111e-02f, 5.59736304e-02f, 3.23343948e-02f, 4.03385758e-02f,
  -2.39263568e-03f, -1.22587763e-01f, -8.22077692e-02f, -8.00417662e-02f, -7.04976022e-02f, 5.09417281e-02f, -7.73278400e-02f, -1.76006148e-03f, -6.79028183e-02f, -7.17368200e-02f,
  1.56686716e-02f, 6.29196018e-02f, -9.09794345e-02f, -1.07907273e-01f, 5.93842939e-02f, 5.68748750e-02f, 9.44502205e-02f, 9.56227258e-02f, -8.88479799e-02f, -4.30859625e-02f,
  -4.04497162e-02f, 4.35472056e-02f, -2.62308605e-02f, 3.58873717e-02f, -1.03525154e-01f, -1.87970802e-01f, -1.39973596e-01f, 1.71959773e-01f, 1.04918376e-01f, -8.35357979e-02f,
  -1.55598566e-01f, 1.39929563e-01f, -7.72815868e-02f, 1.14793805e-02f, -1.77891314e-01f, -3.74020934e-02f, -1.07061647e-01f, -3.04588657e-02f, 1.37412518e-01f, 3.88404801e-02f,
  8.70300159e-02f, -1.72621831e-01f, -1.28583953e-01f, 5.10564372e-02f, 7.79968128e-02f, -3.12471166e-02f, 7.63095990e-02f, -1.15618564e-01f, 4.46138941e-02f, -2.64546182e-02f,
  3.15913334e-02f, -1.04208820e-01f, 1.60377786e-01f, 6.20979555e-02f, 8.17700550e-02f, 1.38196006e-01f, -1.03826970e-01f, 1.39014181e-02f, 7.35584199e-02f, -4.85570654e-02f,
  -8.90087187e-02f, 7.78910890e-02f, 4.76323515e-02f, -4.70976308e-02f, 4.73997369e-02f, -8.31609517e-02f, 4.71896753e-02f, 3.93532962e-02f, 4.54647876e-02f, 9.25343484e-02f,
  -1.16584580e-02f, -6.11658283e-02f, 6.94317743e-02f, -9.93087217e-02f, -1.66021436e-02f, 8.35321695e-02f, 1.84201077e-01f, -2.84940619e-02f, 2.54761372e-02f, 1.27741069e-01f,
  1.25478163e-01f, -7.77202547e-02f, 9.86302495e-02f, 7.05609694e-02f, -1.24066941e-01f, 5.65011017e-02f, 3.58829089e-02f, 1.95174247e-01f, -6.06449172e-02f, -2.96575785e-01f,
  -3.03561594e-02f, -5.41661792e-02f, 2.59314175e-03f, -1.58014074e-01f, -9.50909182e-02f, 1.61017627e-01f, 1.39702395e-01f, 5.49522452e-02f, -6.09802902e-02f, 6.43612519e-02f,
  1.17193222e-01f, 5.53943925e-02f, -2.38497332e-02f, 5.06197959e-02f, -4.35311273e-02f, 9.34740305e-02f, -9.57793444e-02f, 1.85595378e-01f, 7.68028647e-02f, 1.00063138e-01f,
  -7.06633329e-02f, 2.17277594e-02f, -5.20141758e-02f, 3.34512070e-02f, 4.62312661e-02f, -1.11105323e-01f, -5.26606403e-02f, -5.41607067e-02f, -1.34799212e-01f, 1.56698644e-01f,
  -7.16135576e-02f, 1.43737212e-01f, 1.70727387e-01f, 2.53443629e-01f, -2.96093598e-02f, -4.99269404e-02f, 7.18561113e-02f, 2.15315878e-01f, -9.72786620e-02f, -1.05524883e-01f,
  4.11119275e-02f, 1.43810436e-01f, -5.46614304e-02f, -8.98203552e-02f, 1.99004307e-01f, -1.20555967e-01f, -6.97095841e-02f, 1.43696547e-01f, -1.00166708e-01f, 1.54542595e-01f,
  1.55151799e-01f, -3.69389281e-02f, 2.11238235e-01f, 3.79604101e-01f, 1.09179929e-01f, 4.08933572e-02f, -1.57511197e-02f, -1.97769523e-01f, -2.59393573e-01f, 1.00642480e-01f,
  -2.30246365e-01f, -2.14714289e-01f, -1.41214386e-01f, -5.05415201e-02f, -3.21314707e-02f, 9.87159163e-02f, -7.48579055e-02f, -2.78869309e-02f, 1.03595577e-01f, -1.25981271e-01f,
  2.46425550e-02f, 7.29454588e-03f, -1.16276108e-01f, 1.63045987e-01f, 8.09129998e-02f, -1.36811882e-01f, 6.27934113e-02f, -4.87340018e-02f, -2.23206580e-01f, -1.28283262e-01f,
  -2.54802145e-02f, 1.79618701e-01f, 1.30963802e-01f, 7.35564604e-02f, 4.91158478e-02f, -1.68635100e-02f, -1.82322983e-03f, -1.15237854e-01f, 5.79952411e-02f, 7.76572376e-02f,
  1.49176270e-01f, 1.07439242e-01f, -8.99029821e-02f, -2.28435829e-01f, 2.85847951e-02f, -2.18057726e-02f, 1.45065757e-02f, 6.00313023e-02f, -1.06759571e-01f, 1.18599676e-01f,
  4.79327068e-02f, -3.15625891e-02f, 9.51848999e-02f, -1.20547988e-01f, 1.18514523e-01f, -5.52044809e-02f, 1.20020933e-01f, 1.12203695e-01f, -5.20981364e-02f, -3.45388278e-02f,
  -1.40740275e-01f, -9.48927030e-02f, 6.99291155e-02f, 5.98612688e-02f, -4.42538224e-02f, -1.23875197e-02f, 1.28307551e-01f, 1.24189235e-01f, -9.81200263e-02f, 1.12097405e-01f,
  -9.36579555e-02f, -6.91037625e-02f, 9.83235016e-02f, -1.32897452e-01f, -8.24836195e-02f, 2.37939954e-01f, 7.55153894e-02f, -1.83896288e-01f, -8.39194134e-02f, 1.69674888e-01f,
  1.04028158e-01f, -1.81687757e-01f, -1.70432568e-01f, 1.85824782e-01f, 1.91858243e-02f, -1.95944682e-03f, -7.98009560e-02f, 1.89703763e-01f, 2.95596067e-02f, 5.57924919e-02f,
  1.21585310e-01f, 1.31185755e-01f, 6.40931651e-02f, -1.25096261e-03f, 6.12194603e-03f, 1.33692652e-01f, 6.59869891e-03f, -1.58500463e-01f, -1.35934517e-01f, 4.47119474e-02f,
  4.64823730e-02f, 1.43403366e-01f, -1.36304647e-01f, -8.55983049e-02f, 7.07104504e-02f, 5.62209338e-02f, 3.11649255e-02f, -1.47609208e-02f, -9.88904759e-02f, -6.03906140e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.97391620e-02f, 1.09286807e-01f, 6.67100772e-02f, 1.89897139e-02f, -1.11915534e-02f, 2.41580047e-02f, -5.51685169e-02f, -1.20264374e-01f, -3.06373294e-02f, 1.24398142e-01f,
  1.34021705e-02f, -7.70529005e-05f, 2.63998881e-02f, -8.41447472e-05f, -1.14955932e-01f, -7.49686360e-02f, -8.24090093e-02f, -8.90473053e-02f, -4.27078828e-02f, 8.12427849e-02f,
  -7.77266696e-02f, 1.07628122e-01f, 1.39347073e-02f, -1.00584067e-01f, -2.72514522e-02f, 3.01668029e-02f, 5.83999641e-02f, 7.08002895e-02f, -8.70928690e-02f, -1.12453274e-01f,
  -4.68651243e-02f, 6.76957741e-02f, -8.64239633e-02f, 1.30379677e-01f, -1.22358367e-01f, 8.11736099e-03f, 8.67480561e-02f, -7.53015950e-02f, 7.04711303e-02f, 4.44478877e-02f,
  -7.15349019e-02f, 9.64487344e-02f, -6.56740367e-02f, -3.55606806e-03f, -1.24824613e-01f, 7.76674971e-02f, 5.72204683e-03f, -1.50338691e-02f, 1.44672289e-01f, 4.58981059e-02f,
  9.98674482e-02f, -1.17879383e-01f, 7.88563266e-02f, 3.49285044e-02f, 3.68356630e-02f, 1.26365662e-01f, -8.22216794e-02f, 5.53404801e-02f, -5.22730947e-02f, -3.13402750e-02f,
  7.73577690e-02f, -1.15264319e-01f, 1.01044811e-01f, 8.53097811e-02f, 5.18275425e-02f, 9.97936279e-02f, 2.98386216e-02f, -5.41883288e-03f, -5.26792705e-02f, -4.65440266e-02f,
  4.30240249e-03f, -1.68021582e-02f, 6.46286905e-02f, 1.12312205e-01f, -5.15215471e-02f, 3.70257087e-02f, 5.95735684e-02f, 1.89843623e-03f, 6.65564612e-02f, 7.38314018e-02f,
  9.87062156e-02f, 6.91371933e-02f, -1.03980169e-01f, 1.29298881e-01f, 6.04125932e-02f, -4.92585637e-02f, 4.44436334e-02f, 1.33246630e-01f, 1.28367692e-01f, 1.23337237e-02f,
  -8.68030116e-02f, -1.46007150e-01f, -1.70030996e-01f, 1.88602470e-02f, -2.47243419e-02f, 5.71904853e-02f, -7.48983398e-02f, 8.64473358e-02f, 5.35379723e-02f, -8.96577314e-02f,
  8.05009156e-02f, 1.41643239e-02f, -2.85506919e-02f, 1.51024252e-01f, -7.74294063e-02f, -1.59953296e-01f, -2.50181742e-02f, 5.25923334e-02f, 3.14704664e-02f, 5.14146797e-02f,
  6.44575506e-02f, 2.03546360e-02f, -1.43524662e-01f, -2.15355307e-02f, 4.29536439e-02f, -7.43521303e-02f, -5.58112264e-02f, -1.33124888e-01f, 2.19757222e-02f, -1.60289332e-01f,
  1.00639582e-01f, 1.47614509e-01f, -1.37534002e-02f, -1.30201355e-01f, -1.03327036e-01f, -1.72817737e-01f, 8.87303613e-03f, 5.72301671e-02f, -9.51029360e-02f, 4.23409604e-03f,
  2.49140169e-02f, 5.47328964e-02f, -7.14435205e-02f, -2.26384196e-02f, -1.16854785e-02f, -8.90812948e-02f, 5.56734838e-02f, 9.49065983e-02f, 1.23329582e-02f, -7.10159093e-02f,
  -7.51768723e-02f, -6.42507598e-02f, 1.35653406e-01f, 5.48942909e-02f, 1.09640323e-01f, -4.96441163e-02f, 1.36525512e-01f, 9.24954116e-02f, 5.91374487e-02f, -2.20965315e-02f,
  1.07524619e-01f, 1.98386014e-02f, -2.42290124e-02f, 1.39187679e-01f, 7.36770183e-02f, -1.38118029e-01f, 1.20149083e-01f, 8.93200934e-02f, 4.80444469e-02f, 8.56793821e-02f,
  5.82744963e-02f, 3.27626267e-03f, 1.03504628e-01f, 4.70433794e-02f, 2.96486840e-02f, 6.20328747e-02f, -1.09955044e-02f, 1.49042187e-02f, 3.59054133e-02f, -6.41324893e-02f,
  1.02983654e-01f, 2.96905916e-02f, 1.44566270e-02f, 4.34676334e-02f, -5.53835891e-02f, -9.50687602e-02f, 3.25172991e-02f, 1.38144821e-01f, 4.45934162e-02f, -1.21732764e-01f,
  9.48221758e-02f, -2.73284353e-02f, 6.82276040e-02f, 7.78613985e-02f, -9.78282616e-02f, 7.52633810e-02f, -6.45792112e-02f, 7.09766597e-02f, -1.16907679e-01f, -1.55951232e-02f,
  9.34063047e-02f, -5.25474362e-02f, 4.18926473e-04f, 1.44816235e-01f, 1.15960818e-02f, -1.77080336e-03f, -7.89597631e-02f, 5.41704558e-02f, 7.91837871e-02f, 1.63837880e-01f,
  1.40465900e-01f, 3.39063294e-02f, 9.88350883e-02f, -3.67256887e-02f, 9.43221971e-02f, 5.55237476e-03f, 1.45248175e-02f, 1.39301375e-01f, 1.83933564e-02f, -1.97386630e-02f,
  6.20948114e-02f, 8.33099335e-02f, -4.96291406e-02f, -5.41183576e-02f, 5.18377610e-02f, 5.00232615e-02f, -8.94770399e-02f, -7.86178857e-02f, -7.80965760e-02f, -8.44876468e-02f,
  -1.57634448e-02f, -5.83248548e-02f, 7.30572641e-02f, -1.65454492e-01f, 1.78502742e-02f, 9.42359567e-02f, 1.23488203e-01f, -1.25756890e-01f, 7.47582596e-03f, 1.01586513e-01f,
  -1.81114107e-01f, 1.90284774e-02f, 9.22967792e-02f, -1.68592066e-01f, 7.48180598e-02f, -7.75805637e-02f, -1.20357417e-01f, -3.65655078e-03f, 1.27160251e-01f, -2.13177428e-02f,
  -2.92341169e-02f, 1.63380988e-02f, 5.30806894e-04f, 1.49296716e-01f, -7.63109997e-02f, 3.98556050e-03f, -9.07033235e-02f, -9.07027274e-02f, 6.43985718e-02f, 1.20695438e-02f,
  1.36327464e-02f, 7.06881583e-02f, -2.69566588e-02f, -6.91985264e-02f, 1.14697078e-02f, 3.32537144e-02f, 5.84746562e-02f, 9.21278000e-02f, -5.71345948e-02f, 5.65824993e-02f,
  1.65731594e-01f, 1.74579889e-01f, 9.73024890e-02f, 9.91280600e-02f, 3.41684893e-02f, -4.01857570e-02f, 5.64477826e-03f, -7.30118295e-03f, -2.22979933e-02f, -5.03927283e-02f,
  2.02413145e-02f, 9.69144925e-02f, 1.02846414e-01f, 1.27006844e-01f, 1.42211244e-01f, -5.25428541e-02f, 4.49044332e-02f, 1.07077494e-01f, -7.30891749e-02f, -3.08552235e-02f,
  -5.53789884e-02f, -3.39532126e-04f, -3.52668911e-02f, -1.95396896e-02f, 1.22836366e-01f, 6.74909577e-02f, -5.29402159e-02f, -4.49729338e-02f, -1.47604376e-01f, 1.78245846e-02f,
  7.48080686e-02f, 4.83657308e-02f, -1.13760903e-01f, 9.18974075e-03f, 2.31400449e-02f, -1.21640161e-01f, -9.95149389e-02f, 9.96072441e-02f, 1.01883635e-01f, 4.26916778e-02f,
  -2.63139722e-03f, 3.97174135e-02f, -6.46736175e-02f, -1.99023504e-02f, 1.47976086e-01f, 9.93157625e-02f, -2.66977157e-02f, 1.70468166e-02f, -1.07983522e-01f, -4.04559560e-02f,
  1.07511848e-01f, 3.35689224e-02f, -4.56477627e-02f, -4.27972302e-02f, 4.48303334e-02f, 1.25741184e-01f, -5.49453981e-02f, -2.69695781e-02f, 7.84574226e-02f, -1.33056566e-01f,
  1.62250862e-01f, 1.58561841e-01f, -2.25942750e-02f, 1.15743235e-01f, -1.53981848e-02f, 4.11686264e-02f, 1.33684175e-02f, 1.55685574e-01f, 9.40482765e-02f, 1.15025118e-01f,
  2.04285562e-01f, -4.38922122e-02f, 1.69597790e-01f, 4.40440178e-02f, 1.30804360e-01f, -4.60660085e-02f, 8.85643065e-02f, 1.46506384e-01f, 2.45430563e-02f, 1.39264166e-01f,
  -4.71585542e-02f, -1.92234037e-03f, 9.83444229e-02f, -2.46569663e-02f, 2.01859772e-01f, 7.18783811e-02f, -7.56809115e-02f, 1.50711685e-01f, 2.02997878e-01f, -7.32863992e-02f,
  -1.79248266e-02f, 2.08879843e-01f, -7.29540139e-02f, 1.01491265e-01f, -1.25932381e-01f, 9.15986672e-02f, 1.73085749e-01f, -6.33896068e-02f, 1.98967561e-01f, 4.80912104e-02f,
  -5.63565046e-02f, 6.44725561e-02f, -6.70241937e-02f, -4.21631187e-02f, -2.70203333e-02f, 1.61111102e-01f, -1.33415610e-01f, -8.46422389e-02f, 2.01454118e-01f, -3.77923697e-02f,
  -7.30465949e-02f, 7.42915720e-02f, 1.26599878e-01f, 3.01414467e-02f, 1.43585846e-01f, 8.88896063e-02f, -9.13054794e-02f, -1.51393667e-01f, -9.96431634e-02f, 1.59687117e-01f,
  9.39707905e-02f, 3.66439968e-02f, -1.01118255e-03f, -7.14794695e-02f, -3.37681994e-02f, 1.63491890e-01f, 1.76886693e-02f, 8.65278915e-02f, 7.88741633e-02f, 3.77532691e-02f,
  -9.20951813e-02f, 8.85277838e-02f, 1.30488724e-01f, 5.75569421e-02f, 8.45665485e-02f, 1.20937396e-02f, 1.46867961e-01f, 1.05328046e-01f, -9.08877626e-02f, 7.20907077e-02f,
  7.72193298e-02f, 4.79654223e-02f, 7.09796026e-02f, -7.52818445e-03f, -2.49389261e-02f, 7.72807226e-02f, 6.77528605e-02f, -9.23979133e-02f, 1.30736306e-01f, -1.83493763e-01f,
  6.80479854e-02f, 1.23439595e-01f, -1.21560581e-01f, -1.38204202e-01f, 4.71403785e-02f, -2.26551086e-01f, -1.20904185e-02f, 1.56733021e-01f, 5.42633645e-02f, 5.09487540e-02f,
  -1.20693438e-01f, -7.79925671e-04f, -1.12251014e-01f, -5.24828993e-02f, -4.24527042e-02f, 1.12316661e-01f, -6.30829185e-02f, 6.45545945e-02f, -3.33912149e-02f, 6.78826347e-02f,
  -4.41663787e-02f, -7.69557208e-02f, -5.96330911e-02f, 1.94808450e-02f, 2.86653135e-02f, 1.35302961e-01f, 3.72930467e-02f, -1.12789273e-02f, 4.13198397e-02f, -7.04109296e-02f,
  1.42874733e-01f, 2.90918406e-02f, 1.04507156e-01f, 1.18456952e-01f, 5.01703296e-04f, -7.73821995e-02f, -3.05414591e-02f, -6.21544048e-02f, -1.29986912e-01f, -8.63559078e-03f,
  9.53942016e-02f, 5.54816239e-02f, 3.17653082e-02f, -6.36688471e-02f, 1.70922335e-02f, 1.34939149e-01f, -9.30634588e-02f, 1.28188863e-01f, 2.11342834e-02f, 9.86000225e-02f,
  -1.16379097e-01f, -5.96584976e-02f, 1.63119078e-01f, -5.52070886e-02f, 2.32206620e-02f, 3.51104215e-02f, 2.84659173e-02f, 8.02358463e-02f, 3.99398655e-02f, -7.62871429e-02f,
  -8.66222307e-02f, 1.52057022e-01f, -8.90229046e-02f, -1.84129074e-01f, 1.07601337e-01f, -8.59768093e-02f, -5.44657186e-02f, -1.76579691e-02f, 1.53544610e-02f, 9.44040567e-02f,
  3.11404746e-02f, 1.81333479e-02f, 9.90105867e-02f, 1.03321016e-01f, -1.25868469e-01f, -1.75659314e-01f, -1.20054208e-01f, 8.13286528e-02f, -1.05404317e-01f, -6.31517023e-02f,
  -2.07726926e-01f, 1.76658243e-01f, -1.15233781e-02f, -2.42761999e-01f, 9.90369916e-02f, -1.48478627e-01f, 3.40367630e-02f, -4.64779735e-02f, -1.31778151e-01f, -1.15996890e-01f,
  -7.31642842e-02f, 8.02608803e-02f, -3.14140469e-02f, -2.67946813e-02f, 1.67962447e-01f, -9.01034251e-02f, -9.21579227e-02f, 7.50460178e-02f, -3.60508040e-02f, 4.66758236e-02f,
  1.18424729e-01f, -6.00907877e-02f, -9.75046381e-02f, -1.04279228e-01f, -8.20811316e-02f, -1.02614678e-01f, 1.12050973e-01f, -9.47251320e-02f, -5.23794591e-02f, -1.03806354e-01f,
  7.06887171e-02f, -3.23060788e-02f, 6.04562126e-02f, -3.74178253e-02f, -4.88208532e-02f, -1.24431320e-01f, -9.63845029e-02f, 5.17366901e-02f, -9.82505903e-02f, -8.35212022e-02f,
  -5.37166558e-02f, 8.64656270e-02f, 2.49158572e-02f, -8.20941031e-02f, 9.54960510e-02f, 1.08521596e-01f, 8.41871500e-02f, 5.33645079e-02f, -1.15177631e-01f, -3.22071165e-02f,
  6.40193969e-02f, -4.50484417e-02f, 1.03861324e-01f, 6.03046566e-02f, -9.41155925e-02f, -8.32054988e-02f, -1.17044955e-01f, -7.47276619e-02f, 5.81996702e-02f, 1.13709271e-02f,
  8.10060352e-02f, 1.52449086e-02f, 1.76563219e-03f, -4.66772960e-03f, 1.29164547e-01f, -4.07193527e-02f, 1.02720223e-01f, -4.13969755e-02f, 7.21647292e-02f, -1.06211625e-01f,
  -4.87270392e-02f, -1.32084623e-01f, 4.56960201e-02f, -1.10757463e-02f, -7.21093044e-02f, -9.52345580e-02f, -1.04314489e-02f, -6.88591078e-02f, -3.40477787e-02f, 1.28051237e-04f,
  -1.14342071e-01f, -7.14711621e-02f, 9.68703553e-02f, 1.40020680e-02f, -6.94619343e-02f, 2.39756461e-02f, 1.14614859e-01f, -9.76771303e-03f, 1.08556002e-02f, -6.39595389e-02f,
  -5.16346209e-02f, -4.05729599e-02f, -8.85675400e-02f, 3.40791307e-02f, -1.13881491e-01f, 7.72251487e-02f, -8.18090811e-02f, -2.39580628e-02f, -9.33182165e-02f, -6.34300411e-02f,
  9.56221148e-02f, 8.46338049e-02f, -1.25570521e-02f, 6.71543777e-02f, -3.39247957e-02f, 7.43762851e-02f, -5.06310761e-02f, 1.25583917e-01f, -1.07481167e-01f, -4.39620437e-03f,
  1.85900554e-02f, -1.76156429e-03f, -6.97357804e-02f, -2.54571661e-02f, 8.31943005e-02f, 1.18423603e-01f, 1.23840384e-01f, -1.19696464e-02f, -6.60126423e-03f, -7.19815716e-02f,
  -9.01613384e-02f, -8.11454281e-02f, 4.42442447e-02f, 5.09840921e-02f, 6.49262816e-02f, 3.25293839e-02f, 3.24014202e-02f, 4.98096161e-02f, -6.73203245e-02f, -6.02379367e-02f,
  8.50128904e-02f, 1.11510456e-01f, -3.96226160e-02f, -4.51536709e-03f, 1.23957366e-01f, -8.83232206e-02f, 1.31099047e-02f, -5.33820018e-02f, 5.88761568e-02f, 2.70646531e-03f,
  8.98215622e-02f, -1.05993576e-01f, 9.00575146e-02f, -3.80016305e-02f, 3.87360603e-02f, 1.17927805e-01f, 1.04794659e-01f, 1.25327110e-01f, -2.88365223e-02f, 1.01082548e-01f,
  -3.01463474e-02f, 2.22869944e-02f, -8.62004310e-02f, 6.97772801e-02f, -3.99980918e-02f, 8.46119672e-02f, -9.46787596e-02f, -1.08573707e-02f, 1.19618036e-01f, 1.05676115e-01f,
  2.05133334e-02f, 9.93164256e-02f, 6.68681487e-02f, -9.73709002e-02f, 1.20676272e-01f, -8.95107687e-02f, -8.69008526e-02f, 6.93772435e-02f, 3.94376032e-02f, -9.31511670e-02f,
  -4.95541170e-02f, -1.23567663e-01f, 1.92406233e-02f, 5.75223714e-02f, 9.65719372e-02f, 1.26072867e-02f, -4.20814231e-02f, 9.03500393e-02f, -2.80612223e-02f, 2.89868396e-02f,
  -1.22494355e-01f, 1.59912482e-01f, -8.86290744e-02f, -1.30803481e-01f, -7.97022954e-02f, 6.02832660e-02f, -3.12476587e-02f, -1.40366122e-01f, 8.04164708e-02f, -6.65064305e-02f,
  1.14644513e-01f, -5.76667823e-02f, -6.67404830e-02f, 3.35140601e-02f, 1.67802479e-02f, -1.05029248e-01f, 8.79431218e-02f, 7.54638612e-02f, 9.07790661e-02f, -1.10229909e-01f,
  -1.22429326e-01f, 2.19293348e-02f, 4.95514870e-02f, 4.11757790e-02f, -6.17880486e-02f, 6.52486831e-02f, 1.09043665e-01f, -8.51967186e-02f, -3.17552164e-02f, -1.01796217e-01f,
  8.71279016e-02f, 6.87815547e-02f, 5.49303927e-02f, -6.49117678e-02f, -6.58036247e-02f, -8.32598209e-02f, -4.32459228e-02f, -6.13958621e-03f, -9.42303091e-02f, -1.15508005e-01f,
  -6.54466897e-02f, -3.05199735e-02f, 8.84336755e-02f, -1.29044512e-02f, -1.00118667e-01f, -5.34262843e-02f, 1.02020008e-02f, 1.12520315e-01f, -9.03266966e-02f, 7.64319599e-02f,
  1.34742940e-02f, -2.70719361e-02f, 5.42081259e-02f, 8.46036747e-02f, -4.45563495e-02f, -1.18916228e-01f, -1.11382850e-01f, -7.53739551e-02f, 9.16166976e-02f, 9.47797373e-02f,
  -1.14390120e-01f, 6.77822536e-05f, -1.25633385e-02f, -4.03907374e-02f, 5.50397411e-02f, -1.08556651e-01f, 2.51086578e-02f, 7.45976046e-02f, -1.97775871e-03f, 8.40140879e-02f,
  3.76760471e-03f, -8.25484991e-02f, -9.89290699e-03f, 8.18586722e-02f, 1.14471734e-01f, 7.54627213e-02f, -5.27537502e-02f, 5.90358712e-02f, -5.79145439e-02f, 9.74684134e-02f,
  1.01102017e-01f, 8.46934319e-03f, 6.89513162e-02f, -5.17480634e-03f, -3.91587801e-02f, 5.71538843e-02f, -5.85897565e-02f, -9.85060111e-02f, 4.38129231e-02f, -1.11012466e-01f,
  -1.11339785e-01f, -6.90887589e-03f, 7.41523355e-02f, -9.55709666e-02f, -3.60685550e-02f, 1.35594338e-01f, -6.98536113e-02f, -5.48254959e-02f, -1.13847353e-01f, -5.06575927e-02f,
  9.34438705e-02f, 9.29431543e-02f, -9.04577225e-02f, 1.03851792e-03f, 2.26621274e-02f, 2.55102832e-02f, 4.58308645e-02f, -4.26845215e-02f, 5.36978170e-02f, 1.14960276e-01f,
  1.50972679e-02f, 1.04071639e-01f, 4.88698334e-02f, 7.01431707e-02f, 1.11381978e-01f, -8.39975029e-02f, 5.73281907e-02f, -1.03871018e-01f, -6.38400689e-02f, -1.73203766e-01f,
  6.81368113e-02f, 9.23460647e-02f, -4.54218462e-02f, 1.10744402e-01f, -5.23174889e-02f, 4.51949351e-02f, 6.96086362e-02f, 8.73251706e-02f, 4.67869714e-02f, 1.63799852e-01f,
  -6.28150534e-03f, 3.49544846e-02f, 1.00753188e-01f, -4.71067317e-02f, -9.67630222e-02f, -1.27538413e-01f, 1.43080682e-01f, 4.87906067e-03f, 7.00387433e-02f, -1.06106736e-01f,
  6.02864362e-02f, 1.10479772e-01f, 1.61703900e-02f, -4.60404018e-03f, -6.78563192e-02f, 1.57458782e-02f, 7.07631409e-02f, 9.45396721e-02f, -5.59685864e-02f, 6.34592995e-02f,
  1.04269743e-01f, 1.09709539e-01f, -2.81991512e-02f, 8.52455497e-02f, -1.03999324e-01f, -1.17082700e-01f, -1.29687777e-02f, 1.27293244e-01f, 1.24890357e-01f, -3.50145921e-02f,
  6.42159674e-03f, 1.11508191e-01f, -1.24806724e-01f, 6.59494922e-02f, 1.31710306e-01f, 6.06589690e-02f, 1.59725323e-01f, 3.41953826e-04f, 8.35276097e-02f, -6.74684048e-02f,
  -2.95864772e-02f, 5.49678989e-02f, 4.88088876e-02f, 1.37765065e-01f, -7.60483667e-02f, 8.56944025e-02f, 1.31986752e-01f, -8.88838843e-02f, -7.11982176e-02f, 1.49193719e-01f,
  1.55835913e-03f, -5.18163014e-03f, -8.96532610e-02f, -3.02459672e-02f, -1.07783072e-01f, 1.42608538e-01f, -1.17212459e-01f, -1.52979940e-01f, -6.89866245e-02f, 3.54243889e-02f,
  -1.31114751e-01f, -4.24886346e-02f, -7.71832466e-02f, 1.13592625e-01f, -5.50502390e-02f, -2.97589358e-02f, 2.65637203e-03f, 3.17589007e-02f, -7.36759305e-02f, -1.08351469e-01f,
  -2.44784914e-02f, 8.19746330e-02f, 4.46507409e-02f, 1.45089522e-01f, -8.32486972e-02f, 5.17443642e-02f, 1.34502441e-01f, -1.98763553e-02f, 9.91220772e-02f, -1.01574220e-01f,
  -2.81135980e-02f, -2.54936032e-02f, 4.74422723e-02f, -8.76957998e-02f, 6.94972053e-02f, 1.12183876e-01f, -4.65574712e-02f, 1.17368691e-01f, 8.90871584e-02f, -1.51592493e-02f,
  -7.02962950e-02f, 7.14157298e-02f, 1.12259202e-02f, -9.66891348e-02f, 1.43031716e-01f, -8.84333178e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.82362886e-02f, 1.54695064e-01f, 1.11429565e-01f, 1.37774363e-01f, 1.32538572e-01f, -9.81883891e-03f, 2.92872381e-03f, 7.34066889e-02f, -6.17852099e-02f, -3.71913277e-02f,
  1.26922056e-01f, -1.99844539e-02f, 4.76502739e-02f, 1.33764535e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  4.00533266e-02f, -1.07276037e-01f, 1.16143404e-02f, 1.03364073e-01f, -1.60721153e-01f, 3.93433832e-02f, -1.70991663e-02f, 6.36479780e-02f, -1.99416094e-02f, -1.10854484e-01f,
  -9.66693386e-02f, -9.13893953e-02f, -1.39383659e-01f, 5.98371886e-02f, 1.93653945e-02f, -3.38234492e-02f, -1.38740167e-01f, 3.26338038e-02f, -5.48474304e-02f, 3.29908263e-03f,
  7.35385716e-02f, 1.67736504e-02f, -1.24381750e-03f, 1.08562171e-01f, 7.47542232e-02f, 8.23547393e-02f, -1.31626099e-01f, 9.46025848e-02f, 2.64769197e-01f, -1.97488815e-01f,
  -2.33345777e-01f, -8.15269575e-02f, 2.64624268e-01f, -4.31928076e-02f, 1.97032541e-01f, 1.41019234e-02f, -1.70624956e-01f, -1.91835985e-01f, 3.48691046e-02f, -2.83804983e-02f,
  -1.20746791e-02f, 6.96704835e-02f, -1.56949848e-01f, -1.31960705e-01f, 5.38556129e-02f, -1.13457292e-01f, 2.81914975e-02f, 1.26181170e-01f, -1.97318465e-01f, -4.49771136e-02f,
  -4.36426252e-02f, 1.37230501e-01f, 7.81200966e-03f, 7.15575516e-02f, 5.31851351e-02f, -5.74933663e-02f, 5.23775741e-02f, -4.29418124e-02f, -3.44586372e-02f, -6.19858783e-03f,
  9.94009376e-02f, 7.45993182e-02f, -5.61759770e-02f, -1.25008762e-01f, 4.71424237e-02f, -3.35625783e-02f, -1.48708224e-01f, 9.50172320e-02f, 8.60000923e-02f, -1.30174980e-02f,
  -4.04676534e-02f, 4.12752964e-02f, 9.67984200e-02f, -4.67935838e-02f, -6.15466572e-02f, 1.32225379e-01f, -4.62624580e-02f, -6.21459633e-02f, 7.37639815e-02f, 3.65706384e-02f,
  8.77061784e-02f, 1.25114694e-01f, 6.68051690e-02f, 1.55685291e-01f, -3.13533060e-02f, -6.35582730e-02f, -5.13873734e-02f, 7.37994835e-02f, -5.93456514e-02f, 9.15565342e-02f,
  -9.61725228e-03f, -4.83719595e-02f, -1.01064868e-01f, 2.21402366e-02f, -4.58065607e-03f, -1.24237768e-01f, -2.60895621e-02f, 5.88130299e-03f, 1.43007264e-01f, 2.63203890e-03f,
  4.11988907e-02f, 1.29173458e-01f, -2.04471499e-01f, -1.03859052e-01f, -1.92395180e-01f, 2.79669166e-02f, 1.80052176e-01f, -6.83883131e-02f, -1.09023243e-01f, 1.27374500e-01f,
  6.19282313e-02f, 7.50815570e-02f, 6.34943247e-02f, -1.17951728e-01f, 4.56731617e-02f, 9.90056433e-04f, 1.18217117e-03f, -1.00196436e-01f, 1.26485616e-01f, 7.13915750e-02f,
  1.12880163e-01f, -1.15366839e-01f, 4.63648736e-02f, -3.29349302e-02f, -8.85031074e-02f, 8.62010568e-02f, -9.99781489e-02f, -5.74385300e-02f, -1.31643787e-01f, 5.24555147e-03f,
  -1.08203001e-01f, -5.48114590e-02f, -5.55542931e-02f, -5.37283905e-02f, -3.41620184e-02f, 9.47750434e-02f, -7.50809014e-02f, -2.01970153e-02f, -1.98692568e-02f, -1.19807474e-01f,
  -6.29770607e-02f, 5.23455162e-03f, -6.74585178e-02f, 1.26004927e-02f, -1.46404147e-01f, -1.06937820e-02f, -7.14549646e-02f, 1.83881982e-03f, 4.55585234e-02f, 4.52609733e-02f,
  5.94196394e-02f, 2.08340032e-04f, -1.06959224e-01f, 9.83851701e-02f, -1.10229127e-01f, -8.93466845e-02f, -1.86387226e-02f, 3.53199095e-02f, 5.55550195e-02f, 6.81962669e-02f,
  9.41278338e-02f, -9.63959768e-02f, 1.41115636e-01f, -6.36422858e-02f, 6.74784998e-04f, -6.17537200e-02f, -3.88568453e-02f, 1.90936387e-01f, 8.98433179e-02f, 2.01002702e-01f,
  9.52723622e-02f, 3.90491299e-02f, -1.58749416e-01f, -1.25751838e-01f, -1.09782875e-01f, 9.68646780e-02f, -1.71176484e-03f, -9.08385962e-02f, -1.17610535e-02f, -1.52030401e-02f,
  6.09862208e-02f, -6.19943775e-02f, 1.05751745e-01f, 2.52541457e-03f, -6.82150945e-02f, -1.36520684e-01f, -5.93704544e-02f, 7.46264160e-02f, -1.04725264e-01f, -6.28867075e-02f,
  -6.57297075e-02f, -8.13888162e-02f, -8.67769420e-02f, -2.14675199e-02f, 2.34035421e-02f, 9.26541630e-03f, 1.36798158e-01f, 1.05322879e-02f, 1.20582581e-01f, 7.46757016e-02f,
  9.44008082e-02f, 5.08983806e-02f, -5.87627618e-03f, 4.70647253e-02f, 3.76991443e-02f, 1.20015398e-01f, 1.42584592e-01f, 2.39418391e-02f, 5.01359105e-02f, -4.05384228e-02f,
  4.97294478e-02f, -1.27123922e-01f, 2.21367250e-03f, 1.27120793e-01f, 1.25132993e-01f, -9.58856717e-02f, 1.02621593e-01f, 8.21992531e-02f, -8.02339464e-02f, -1.13725148e-01f,
  -1.43933594e-01f, 1.33959353e-01f, -2.43129823e-02f, -1.16699524e-01f, -1.35046944e-01f, 9.03697237e-02f, -1.74717277e-01f, -1.04373777e-02f, 1.08210996e-01f, -9.69229545e-03f,
  1.53042257e-01f, 2.18634438e-02f, -5.58782704e-02f, 4.52586375e-02f, -4.76263911e-02f, -2.69875154e-02f, 5.88957816e-02f, 2.21957743e-01f, -6.12349771e-02f, -1.41312540e-01f,
  1.78727895e-01f, -3.51365060e-02f, -8.52361470e-02f, -8.20930526e-02f, -1.24036007e-01f, -8.34950805e-02f, -7.48679042e-02f, -8.58865008e-02f, 6.61012530e-02f, -2.78775450e-02f,
  -1.24299573e-02f, -7.21897348e-04f, 1.10622838e-01f, -1.03647351e-01f, -1.38770133e-01f, 9.11912620e-02f, -1.32583693e-01f, -4.47041877e-02f, -9.82621610e-02f, -3.52314189e-02f,
  -3.76302265e-02f, 5.31254821e-02f, -2.18874142e-02f, -9.53104347e-02f, -1.77811071e-01f, -8.01080763e-02f, -4.95654978e-02f, 1.00683391e-01f, -3.67216766e-03f, -1.41869977e-01f,
  -6.17735013e-02f, -1.14078052e-01f, 1.23000659e-01f, 8.84053484e-02f, 7.62363300e-02f, -1.15593988e-02f, -8.29693750e-02f, 1.12810440e-01f, 1.65942833e-02f, 7.28788450e-02f,
  1.69635385e-01f, -2.48951942e-01f, -1.80436611e-01f, 1.47223353e-01f, 2.58595608e-02f, -3.80187444e-02f, -7.31203333e-02f, 1.33715495e-01f, -1.20477930e-01f, -1.22652374e-01f,
  1.77135542e-01f, 6.86250068e-03f, 2.78335437e-02f, -3.20821665e-02f, -5.94039857e-02f, 4.82844338e-02f, -3.26467603e-02f, -1.33716702e-01f, 1.61813110e-01f, -2.04584986e-01f,
  -2.44466156e-01f, -9.35857967e-02f, -5.94288073e-02f, 1.37480944e-01f, -1.50495887e-01f, 2.10177034e-01f, 8.78492892e-02f, -1.61605000e-01f, -4.58866321e-02f, 1.97532736e-02f,
  3.61341611e-02f, -7.86076263e-02f, 9.62591246e-02f, 8.40947777e-02f, 4.58055548e-02f, -3.00858188e-02f, -9.19325799e-02f, 1.14865482e-01f, 4.24148217e-02f, 1.88291259e-02f,
  -5.46187609e-02f, 5.35819158e-02f, -3.17209288e-02f, 8.16541836e-02f, 7.26620555e-02f, -1.22920878e-01f, -8.02976042e-02f, -1.98006891e-02f, -1.86348587e-01f, 4.94598523e-02f,
  -5.04197925e-02f, 4.12401259e-02f, -3.18689607e-02f, -5.94130866e-02f, -2.65737027e-02f, -2.47505791e-02f, -8.58292952e-02f, 1.17355950e-01f, -3.93831097e-02f, -9.03406665e-02f,
  7.10095540e-02f, -1.08157881e-01f, -1.26782656e-01f, -1.04860775e-01f, -1.08187363e-01f, -8.44474435e-02f, 2.76174862e-02f, 7.85502866e-02f, -4.40444378e-03f, -7.93649256e-02f,
  -9.46668163e-02f, 6.03349181e-03f, 1.30798325e-01f, -1.97614938e-01f, 1.52370587e-01f, -7.54617155e-02f, -5.02992459e-02f, -1.10539775e-02f, -4.59566005e-02f, 3.23088840e-02f,
  -1.76775344e-02f, 2.02978719e-02f, 1.05949812e-01f, -1.07597411e-01f, -1.24796838e-01f, -1.83488354e-01f, -5.46692275e-02f, 8.19708109e-02f, 4.71421629e-02f, 1.18906468e-01f,
  2.90280636e-02f, 4.70004790e-02f, 5.95059954e-02f, 8.22595805e-02f, 7.00943843e-02f, 1.06208257e-01f, -6.54582530e-02f, -1.30794033e-01f, -4.40040790e-03f, 8.50690156e-03f,
  -2.87824571e-02f, 9.52104032e-02f, 6.49487302e-02f, 2.26144493e-02f, -8.35834220e-02f, 1.64872125e-01f, -3.23065324e-04f, 8.47781356e-03f, 1.32972524e-02f, 6.52654767e-02f,
  8.09253007e-02f, -2.00788304e-01f, 1.41062379e-01f, 2.54651923e-02f, -1.53100528e-02f, -1.62833065e-01f, 8.48169848e-02f, -2.46690400e-02f, -8.18668976e-02f, -4.96635586e-02f,
  6.62343726e-02f, 3.65515873e-02f, 4.57523055e-02f, 5.37237264e-02f, 8.63735899e-02f, -4.87931408e-02f, 6.69864565e-02f, -1.05436966e-01f, 7.66371861e-02f, -4.54054475e-02f,
  9.59017798e-02f, -7.39753023e-02f, -2.74330117e-02f, 4.61851917e-02f, 2.65536517e-01f, -1.46478698e-01f, -2.18054533e-01f, -6.39788136e-02f, -1.81469157e-01f, 5.04768863e-02f,
  6.99781626e-02f, 1.59597903e-01f, 1.13190740e-01f, 6.84128655e-03f, -5.08316010e-02f, -2.17744783e-01f, 1.97403505e-01f, 2.80323494e-02f, 2.91140955e-02f, 7.60959387e-02f,
  7.90432394e-02f, -9.53914598e-03f, 3.15876126e-01f, 9.52728614e-02f, -2.86470563e-03f, 1.76339019e-02f, -1.55855656e-01f, -7.76775703e-02f, 1.03845097e-01f, -6.69589415e-02f,
  1.17389098e-01f, 7.73160011e-02f, 1.87956877e-02f, 1.15098685e-01f, -5.74085191e-02f, 1.02290429e-01f, 8.60695727e-03f, 1.08516142e-01f, -1.26494784e-02f, 6.98053837e-02f,
  2.14784518e-02f, 7.27180988e-02f, 1.54259168e-02f, -3.95465232e-02f, 7.40978420e-02f, 6.35384470e-02f, 1.16285123e-01f, -1.81535602e-01f, 2.65153013e-02f, 1.57368127e-02f,
  -5.07388934e-02f, -4.86207418e-02f, 5.36550693e-02f, 8.29465315e-02f, -5.39021567e-02f, 8.59257728e-02f, -5.20883650e-02f, -1.33120537e-01f, -1.89274386e-01f, -5.85388616e-02f,
  1.39789358e-01f, 6.96351901e-02f, -1.77733749e-01f, -5.51187582e-02f, 3.57138962e-01f, -1.05555907e-01f, -1.65991694e-01f, 3.90716642e-02f, 1.74195677e-01f, -3.46711911e-02f,
  1.93351209e-01f, -8.67615491e-02f, -1.22608855e-01f, -4.14514765e-02f, 3.05281244e-02f, -8.43243971e-02f, 2.33918428e-01f, 1.24598727e-01f, 1.26709282e-01f, 9.59897488e-02f,
  -2.83106733e-02f, 9.38137248e-02f, 8.02365392e-02f, -9.78047550e-02f, -1.78363070e-01f, -2.44717032e-01f, -1.57529160e-01f, -6.26769438e-02f, 8.35915953e-02f, -2.09774431e-02f,
  1.17855575e-02f, -1.62884027e-01f, 4.28016763e-03f, 8.18954334e-02f, -3.81794572e-02f, 1.37967721e-01f, 1.06653489e-01f, 5.67103736e-02f, 2.49003749e-02f, -6.43231124e-02f,
  9.23516154e-02f, 1.82510242e-01f, -1.45464301e-01f, -5.19843362e-02f, 9.61850509e-02f, -7.20910281e-02f, -6.57731369e-02f, -8.86828545e-03f, 1.09057330e-01f, 8.23537558e-02f,
  -2.08803117e-01f, 9.80320107e-03f, 1.12763569e-02f, 5.19757383e-02f, 1.17601112e-01f, 1.17722459e-01f, -3.32901999e-03f, 9.98458788e-02f, 7.34770149e-02f, 2.37675197e-02f,
  1.30420700e-01f, -2.90733743e-02f, -8.78727958e-02f, 7.72129223e-02f, 6.27093092e-02f, 1.02967367e-01f, 1.38960660e-01f, -2.47214764e-01f, 1.55278251e-01f, 2.36553341e-01f,
  1.08568579e-01f, 1.12851091e-01f, -9.13127661e-02f, 5.89591563e-02f, 5.10338433e-02f, -2.41085842e-01f, -8.96433815e-02f, -1.44013055e-02f, 1.49897426e-01f, -1.24975406e-01f,
  5.44270687e-02f, 6.01001754e-02f, 1.51322648e-01f, -1.86253086e-01f, -1.53444052e-01f, -1.95402250e-01f, -5.60536087e-02f, -5.08345813e-02f, -4.14404236e-02f, -8.33621323e-02f,
  -2.59369165e-01f, 9.16748494e-02f, -2.17269119e-02f, -1.51972204e-01f, 9.31500793e-02f, -1.58623293e-01f, -1.39796026e-02f, 1.78254947e-01f, -1.22207306e-01f, 8.07599649e-02f,
  5.76934554e-02f, -1.43258208e-02f, 3.77596654e-02f, 6.11185562e-03f, 7.96976835e-02f, 1.22816369e-01f, 1.03486277e-01f, 1.12720907e-01f, -5.45565747e-02f, 9.06867757e-02f,
  -1.52444929e-01f, 7.26022152e-03f, 5.31583279e-02f, -1.48639534e-04f, -1.11221619e-01f, 1.53568471e-02f, -1.03281319e-01f, 8.74997824e-02f, -4.96825241e-02f, 1.44352347e-01f,
  -8.93844292e-02f, 7.66802579e-03f, -3.16072837e-03f, -6.33930694e-03f, 3.54778059e-02f, -6.04799204e-02f, -4.01786566e-02f, -1.05835628e-02f, -8.08846876e-02f, 9.35562551e-02f,
  -1.12567171e-01f, -1.58804879e-02f, 2.12215453e-01f, -2.80039608e-02f, 5.51589131e-02f, 2.69666538e-02f, -1.41056374e-01f, 6.12481730e-03f, 1.95122480e-01f, -1.61839455e-01f,
  1.83671609e-01f, -9.71596539e-02f, -1.41783267e-01f, -1.97730079e-01f, -5.61380535e-02f, 1.64591238e-01f, 1.44394293e-01f, -1.03022091e-01f, -8.42335224e-02f, -6.34595677e-02f,
  1.13190427e-01f, -1.91215187e-01f, 3.28878015e-02f, -4.05592956e-02f, -1.29721910e-01f, -1.70652241e-01f, -7.46665196e-03f, -7.26511031e-02f, -7.27151185e-02f, -1.15595236e-01f,
  -6.61917925e-02f, -1.00625595e-02f, 2.38607489e-02f, 9.27042887e-02f, 1.10015431e-02f, 2.74003111e-02f, 1.57593414e-02f, 3.68431993e-02f, 1.23566985e-01f, 3.94415893e-02f,
  9.30822566e-02f, 2.91357010e-05f, -7.22856298e-02f, -1.05279051e-01f, 9.30000693e-02f, -9.48824659e-02f, 8.03279430e-02f, -6.50661215e-02f, 1.58920616e-01f, -6.35212883e-02f,
  1.71928648e-02f, -1.44008398e-02f, -1.15662053e-01f, 6.11449070e-02f, 4.22332883e-02f, -1.59548577e-02f, -4.25132690e-03f, 6.90176114e-02f, 6.65350780e-02f, 6.63804412e-02f,
  1.70707665e-02f, 2.97485311e-02f, 1.27893955e-01f, 7.89801553e-02f, -2.96711307e-02f, 2.58541048e-01f, -1.28421351e-01f, -5.02521917e-02f, -1.00913355e-02f, 9.35805291e-02f,
  -6.65195510e-02f, -1.93624020e-01f, 1.87502667e-01f, 2.64288247e-01f, -3.23630460e-02f, -7.59418979e-02f, -6.14992380e-02f, 1.75171439e-02f, 1.28770500e-01f, -1.18938364e-01f,
  -7.72872940e-02f, 2.10680276e-01f, 1.21175483e-01f, 2.06553265e-01f, -1.56835970e-02f, 1.53966382e-01f, -7.06222281e-02f, -1.33181605e-02f, 2.05350995e-01f, 9.52226669e-03f,
  9.49678570e-02f, 1.50138482e-01f, -2.54857112e-02f, 3.82947698e-02f, -8.27987194e-02f, -5.63962609e-02f, 5.99662066e-02f, 9.34509095e-03f, 3.35879624e-02f, 5.96890301e-02f,
  3.00992634e-02f, -2.08586119e-02f, -1.29677892e-01f, -1.20504968e-01f, -1.13545172e-01f, -7.34683722e-02f, -8.60931352e-02f, 1.15956500e-01f, -2.93001197e-02f, 9.27773193e-02f,
  -7.24664107e-02f, -1.37248999e-02f, -8.50025639e-02f, -7.99314827e-02f, -8.82305857e-03f, -1.33102149e-01f, -1.25853673e-01f, -1.22404292e-01f, 1.04640149e-01f, -1.85238179e-02f,
  1.11174688e-01f, 1.17638230e-01f, 8.13493952e-02f, 4.10887636e-02f, 6.17218651e-02f, -7.62663037e-02f, -1.66395262e-01f, -1.62193328e-01f, 2.53433716e-02f, -2.03479216e-01f,
  -1.53824463e-02f, -7.85116404e-02f, 4.29798402e-02f, 7.46627003e-02f, 1.19961001e-01f, 7.89244398e-02f, -1.82104856e-01f, -1.21779338e-01f, 2.13791445e-01f, -1.02164403e-01f,
  1.07649297e-01f, 1.30718360e-02f, -5.73326275e-02f, 1.38378054e-01f, -1.53460144e-03f, -1.11200497e-01f, 2.16420859e-01f, -9.19369310e-02f, -2.37556502e-01f, -1.17927924e-01f,
  8.31847712e-02f, -3.37384380e-02f, -3.62901017e-02f, 1.80141747e-01f, -9.70102698e-02f, 4.39191945e-02f, -1.24754176e-01f, -9.79831293e-02f, 7.13539273e-02f, 1.60413653e-01f,
  9.83695462e-02f, -1.17395997e-01f, -2.45367531e-02f, 1.24708794e-01f, 1.15656637e-01f, 1.60865840e-02f, -1.62024098e-03f, -3.84082943e-02f, 5.24327196e-02f, 1.78712666e-01f,
  -9.65735875e-03f, 1.32545326e-02f, 1.13878377e-01f, 1.16445497e-01f, -2.00272165e-02f, 1.27240524e-01f, 1.13774613e-01f, -5.01517542e-02f, 5.92863671e-02f, 7.23380074e-02f,
  -8.76270384e-02f, -6.61220625e-02f, 1.61225013e-02f, 1.30523846e-01f, -5.19558117e-02f, 2.06172257e-03f, -1.76160838e-02f, -4.31132615e-02f, 1.47162601e-01f, 1.28824279e-01f,
  -8.58994573e-02f, -2.86201201e-02f, -1.52526889e-02f, -1.02106437e-01f, 1.51582628e-01f, -5.24204820e-02f, -1.81084752e-01f, 6.71858788e-02f, 1.38652727e-01f, 3.66069004e-02f,
  -1.21411309e-01f, 1.48646146e-01f, -1.94046825e-01f, 1.42602637e-01f, 1.27814502e-01f, 1.32165268e-01f, 4.58603874e-02f, -1.16257869e-01f, 1.40668169e-01f, -1.26153007e-01f,
  1.00579992e-01f, 1.99213997e-02f, 5.90629596e-03f, 2.27445453e-01f, 8.09114203e-02f, -1.91868901e-01f, -4.76829968e-02f, 1.33502245e-01f, 1.29971430e-02f, -1.21048957e-01f,
  -8.83555338e-02f, -3.13369408e-02f, -6.18539453e-02f, 5.11680245e-02f, 8.05987790e-02f, 1.57932088e-01f, -5.04461229e-02f, -6.49740323e-02f, -5.72914199e-04f, -1.58594549e-02f,
  2.27932986e-02f, 3.26656625e-02f, 4.27595191e-02f, -2.20891029e-01f, -8.30685422e-02f, -6.65813535e-02f, -7.03568161e-02f, 5.59093207e-02f, -9.84745398e-02f, -3.52472365e-02f,
  -5.99434553e-03f, -1.03406809e-01f, -5.44852093e-02f, -5.24489842e-02f, -1.27015665e-01f, -1.59781948e-01f, -8.44847336e-02f, -4.14341092e-02f, 3.71674970e-02f, 7.58984089e-02f,
  -1.46146297e-01f, 1.47354975e-02f, -7.70653039e-02f, 1.25512490e-02f, -1.36611640e-01f, -1.10015996e-01f, -6.34114444e-02f, 1.10380650e-01f, -3.24712723e-01f, 1.38742864e-01f,
  1.53992340e-01f, -1.18349694e-01f, -6.91433698e-02f, -7.02015683e-02f, 8.70599151e-02f, 1.16190016e-01f, 1.17993653e-01f, -5.17187044e-02f, -1.55221090e-01f, 1.28591627e-01f,
  -1.46674156e-01f, 8.61711651e-02f, -1.56467348e-01f, 9.88944620e-02f, -1.20886602e-02f, -2.39367001e-02f, -1.92857921e-01f, -3.33540142e-02f, 1.15461253e-01f, 2.30717286e-01f,
  1.12956800e-01f, 1.63342014e-01f, 1.57352816e-02f, -6.52631521e-02f, -5.05971685e-02f, 1.43884867e-01f, -6.01740256e-02f, -1.65953130e-01f, 1.03633329e-01f, -1.95139661e-01f,
  7.24981874e-02f, -1.99937224e-02f, -9.12317410e-02f, 8.53319392e-02f, -7.65406247e-03f, -2.09442183e-01f, -1.46209925e-01f, 1.89396560e-01f, -1.78763755e-02f, -2.41084043e-02f,
  1.67098090e-01f, -1.53904215e-01f, 1.00924470e-01f, -1.22235335e-01f, 1.17917277e-01f, 1.26980022e-01f, 7.16298074e-03f, -5.80326393e-02f, -1.73656985e-01f, -7.18984054e-03f,
  -3.12764533e-02f, -7.92907253e-02f, -1.36999547e-01f, 1.04479223e-01f, 2.42627766e-02f, 1.21955700e-01f, 4.67559397e-02f, 1.91362090e-02f, 2.34568026e-02f, -1.30184051e-02f,
  -7.30411932e-02f, -2.26037249e-01f, -8.57760832e-02f, -1.97275534e-01f, -1.90403447e-01f, 1.28618911e-01f, 1.47543445e-01f, 3.37949172e-02f, -9.68789756e-02f, 3.56979296e-02f,
  -7.67818019e-02f, -1.94597512e-01f, 1.78613245e-01f, 3.45734894e-01f, -4.09768224e-02f, -3.22425389e-03f, -1.97919652e-01f, -3.45953479e-02f, 2.83387452e-01f, -8.51330173e-04f,
  -5.56329861e-02f, -1.82776414e-02f, 1.23392619e-01f, 6.20956048e-02f, 4.77016956e-01f, -7.95609690e-03f, 1.09383471e-01f, 7.62725025e-02f, -3.54862884e-02f, -1.23521537e-01f,
  8.07334706e-02f, 1.37135595e-01f, 5.65862879e-02f, -1.78831816e-01f, 1.17738424e-02f, 5.65556856e-03f, 6.52114153e-02f, -8.08561072e-02f, -9.98973101e-02f, -1.14782184e-01f,
  -1.83059201e-01f, -1.61455661e-01f, -9.37502384e-02f, -9.48039219e-02f, 1.20017044e-01f, -1.25951171e-01f, -9.62806419e-02f, -8.13004747e-02f, 2.87322886e-02f, -1.02544099e-01f,
  1.80508457e-02f, -6.78573847e-02f, -1.32521361e-01f, 9.27305520e-02f, 4.95465808e-02f, -3.52112539e-02f, -5.76994894e-03f, -1.86527222e-01f, 2.88620442e-02f, -5.02593070e-02f,
  -1.33949265e-01f, -6.08627871e-02f, 3.43037099e-02f, 4.17350531e-02f, -4.65290584e-02f, -6.92027807e-03f, -8.00596327e-02f, -1.24786854e-01f, -1.19466417e-01f, 9.74597409e-03f,
  7.49767348e-02f, -1.15894929e-01f, -2.01163620e-01f, 1.75533593e-01f, -1.69062167e-01f, 6.12032898e-02f, 1.17746860e-01f, 1.76130354e-01f, 5.55272140e-02f, -8.17273632e-02f,
  6.30058162e-03f, -1.73603743e-01f, 1.92064676e-03f, -1.05605451e-02f, 3.42372879e-02f, 1.89156398e-01f, 1.29146457e-01f, -8.85407701e-02f, 2.19235327e-02f, 2.03845903e-01f,
  -3.89105380e-02f, 8.48540589e-02f, 1.50262993e-02f, 2.72998419e-02f, -4.90198210e-02f, -1.03727438e-01f, -1.29124418e-01f, 1.55480519e-01f, 9.81748179e-02f, 5.04870862e-02f,
  5.53037412e-03f, 4.44974080e-02f, -4.63918746e-02f, 1.11879095e-01f, 5.40342256e-02f, -1.15965985e-01f, 2.47578770e-02f, -1.42732002e-02f, 2.57945852e-03f, 6.10771514e-02f,
  7.21668899e-02f, 1.74580023e-01f, -2.70119635e-03f, -1.33992955e-01f, 2.06104107e-02f, 1.21379152e-01f, 8.78163613e-03f, 1.86028227e-01f, -1.05392814e-01f, -4.53935526e-02f,
  -1.12505235e-01f, 1.02300934e-01f, 1.31310597e-01f, 7.18527436e-02f, -4.70873825e-02f, 9.36173052e-02f, 1.15199007e-01f, 4.96360064e-02f, -1.21608846e-01f, 1.45345777e-01f,
  -9.03425440e-02f, 1.95169508e-01f, 8.93986449e-02f, -6.38811216e-02f, -2.50151366e-01f, 1.08316988e-01f, 3.01167697e-01f, -1.95477232e-02f, -5.39497994e-02f, -5.92608042e-02f,
  -9.31529254e-02f, -2.33406812e-01f, 1.51457384e-01f, 1.39959112e-01f, 1.26050085e-01f, -9.42623913e-02f, -2.40261510e-01f, -1.54038295e-01f, -9.16621685e-02f, -5.85296378e-02f,
  -9.35914293e-02f, 8.65100697e-02f, -2.90142983e-01f, -1.53171539e-01f, -1.18782677e-01f, -6.26006871e-02f, 4.61040027e-02f, -4.31609862e-02f, 5.31691834e-02f, -1.03165053e-01f,
  -4.57738191e-02f, 3.79992812e-03f, -3.42177898e-02f, 1.13870531e-01f, -3.01200692e-02f, 6.75304160e-02f, -8.76185484e-04f, 1.33258281e-02f, -3.63557483e-03f, -8.97012576e-02f,
  1.57583989e-02f, 9.12607461e-02f, 6.97249100e-02f, -1.11433715e-01f, 4.75183688e-02f, -7.41221309e-02f, -2.02136740e-01f, 1.12988047e-01f, 1.02610186e-01f, 8.14589858e-02f,
  7.82803744e-02f, 1.27048856e-02f, 9.82469171e-02f, -1.76226608e-02f, 1.25462294e-01f, -3.17692794e-02f, 1.02521785e-01f, -1.09360330e-01f, -1.51190599e-02f, -7.64542520e-02f,
  -1.07168265e-01f, -7.78535232e-02f, -7.39380643e-02f, -2.09229469e-01f, 2.09895000e-02f, 1.92231223e-01f, -2.07831222e-03f, -7.61573166e-02f, -3.88122872e-02f, 1.32682815e-01f,
  -2.51539856e-01f, -6.54118927e-03f, -4.99638282e-02f, 1.06210642e-01f, -3.11071966e-02f, 2.83722095e-02f, -1.60896704e-01f, -3.95168550e-02f, -1.38515979e-02f, -1.18972659e-01f,
  4.98122722e-03f, -1.01392053e-01f, -1.25226423e-01f, 4.77756709e-02f, 1.97757348e-01f, -2.07915828e-02f, 4.53006960e-02f, 1.53036058e-01f, 1.97287742e-02f, -1.21698223e-01f,
  -2.02732924e-02f, -8.69738981e-02f, 1.19971558e-01f, 5.72621450e-03f, 6.59364462e-02f, 1.07463218e-01f, 6.59501553e-02f, 1.18037269e-01f, -8.68910551e-02f, -2.01126635e-02f,
  4.26510200e-02f, -2.69553694e-03f, 1.42468855e-01f, 2.40206788e-03f, -1.03233367e-01f, -5.10887876e-02f, -3.49578261e-02f, 3.43322568e-02f, -1.58031240e-01f, -8.13908502e-02f,
  1.47506341e-01f, 6.79547247e-03f, -1.30221085e-03f, -2.82277614e-02f, 3.13142873e-02f, 1.87593214e-02f, -1.05079763e-01f, -2.44861003e-02f, -5.33039756e-02f, 4.94769551e-02f,
  8.13819692e-02f, -1.17765162e-02f, -1.16482317e-01f, -1.07228644e-01f, -4.63945717e-02f, -5.27361594e-02f, -8.90817195e-02f, 8.45918208e-02f, 2.49345154e-01f, -6.51804879e-02f,
  -1.42546698e-01f, -1.03651911e-01f, 3.19356471e-02f, -1.99469663e-02f, 1.80411965e-01f, 7.50840679e-02f, 3.02922744e-02f, -8.95317867e-02f, -8.51547495e-02f, -1.02005459e-01f,
  9.04588029e-02f, 7.28042200e-02f, 8.66549909e-02f, 1.31295145e-01f, -1.01584040e-01f, 1.09408662e-01f, 1.78650871e-01f, -5.40539809e-02f, -1.71311200e-01f, -1.11594535e-01f,
  -2.07628623e-01f, -2.85740376e-01f, -4.92748097e-02f, 2.06902996e-02f, -1.40243486e-01f, -2.60391049e-02f, -1.76927567e-01f, -8.85058716e-02f, 2.34919749e-02f, 1.21027194e-01f,
  5.57267554e-02f, 9.68486518e-02f, -6.54451475e-02f, -1.80095360e-02f, -1.30401803e-02f, -6.79724440e-02f, -7.27692470e-02f, -1.29649118e-01f, 1.61926270e-01f, -1.28196940e-01f,
  -1.70502052e-01f, 1.41890422e-01f, 7.79786929e-02f, -3.64541672e-02f, -1.08409800e-01f, -5.54357208e-02f, 1.21940255e-01f, -3.31062488e-02f, 2.85426937e-02f, 8.81559998e-02f,
  -7.97023103e-02f, -9.29231867e-02f, 8.54443610e-02f, 1.33613218e-02f, 6.16158023e-02f, -1.02849819e-01f, -6.79360479e-02f, 8.66081342e-02f, 7.07882866e-02f, -1.79739483e-02f,
  -4.52316403e-02f, 3.90241109e-02f, -7.84944072e-02f, 1.06856644e-01f, -5.56041114e-03f, -1.31584883e-01f, -1.24154694e-01f, 1.85017493e-02f, 5.56941740e-02f, -2.79949382e-02f,
  2.79677715e-02f, -2.66139824e-02f, 1.24348281e-02f, -1.61913007e-01f, 9.04935151e-02f, 9.04284641e-02f, 1.55696079e-01f, -1.11633260e-03f, -1.16177000e-01f, -1.51944444e-01f,
  -1.65709853e-01f, -1.86383471e-01f, -2.05175951e-02f, -1.13569677e-01f, -2.38292515e-01f, 4.86510694e-02f, -1.10732898e-01f, -3.97956222e-02f, -3.07226293e-02f, -1.50630265e-01f,
  6.44620089e-03f, -1.14189480e-02f, -1.20850071e-01f, -3.78986932e-02f, -1.63465161e-02f, 8.71794000e-02f, 2.94479281e-02f, -3.66670229e-02f, 6.67693606e-03f, 3.99716347e-02f,
  -8.83102491e-02f, -1.54638067e-01f, 1.06108971e-01f, 7.16542639e-03f, -3.59611176e-02f, -1.34140417e-01f, 8.66846815e-02f, -5.92515580e-02f, -1.32270306e-01f, -9.57166869e-03f,
  -2.69135796e-02f, -9.65658277e-02f, -8.87378305e-02f, 4.84858751e-02f, 3.78808342e-02f, 3.34172063e-02f, -1.14879813e-02f, -1.28243804e-01f, 1.12678573e-01f, 5.02203107e-02f,
  -5.01567833e-02f, 7.54592046e-02f, -1.43729687e-01f, -6.91755265e-02f, 1.08904978e-02f, -1.45502374e-01f, -3.12603712e-02f, 1.85752392e-01f, 2.31294651e-02f, -9.89846364e-02f,
  1.22555614e-01f, 8.87205359e-03f, -1.44840106e-01f, -1.37314618e-01f, -1.90917730e-01f, 3.10509354e-02f, 2.04786152e-01f, -8.62990767e-02f, 5.30195003e-03f, -4.02541645e-02f,
  -6.74509332e-02f, -7.72177652e-02f, -3.45916227e-02f, -1.04802996e-02f, -3.25665213e-02f, 6.92245215e-02f, 1.96359798e-01f, 1.72262207e-01f, 3.02912239e-02f, 2.17896417e-01f,
  6.35210723e-02f, 3.07601504e-02f, 7.56232589e-02f, 3.19132470e-02f, 1.66185215e-01f, -1.14235833e-01f, 5.31184152e-02f, -7.86616430e-02f, -1.11191086e-01f, 1.35790512e-01f,
  -1.06773950e-01f, -1.88442562e-02f, -7.11457878e-02f, 1.07104078e-01f, 1.15989752e-01f, 6.11398742e-02f, -1.16423301e-01f, 1.30400002e-01f, 1.44236222e-01f, -1.37896150e-01f,
  -2.77319737e-02f, -1.98741749e-01f, 1.60181955e-01f, -5.20250946e-02f, -8.18747282e-03f, -9.76967216e-02f, 7.35281548e-03f, 4.05621119e-02f, 8.67233127e-02f, 6.66206256e-02f,
  -1.27307093e-02f, -1.11080058e-01f, 2.13273559e-02f, -1.83086451e-02f, 1.17936470e-01f, -1.45542592e-01f, 1.00228013e-02f, -1.09912775e-01f, -4.68882397e-02f, -8.61086398e-02f,
  1.06761135e-01f, -1.20858163e-01f, -1.97159842e-01f, 9.58779603e-02f, 2.01909080e-01f, -1.59553781e-01f, -2.11333875e-02f, 4.86983843e-02f, 1.25445807e-02f, -7.43211713e-04f,
  1.26344949e-01f, 4.46156226e-02f, -1.37388319e-01f, 2.54154634e-02f, -1.22983046e-01f, -3.82065810e-02f, -7.89216459e-02f, 1.94620863e-01f, 8.62641912e-03f, 1.79165617e-01f,
  1.79067299e-01f, -8.78439993e-02f, 2.20200107e-01f, 8.27572271e-02f, 1.05044544e-01f, 6.50209188e-02f, -1.15403496e-01f, -6.79792240e-02f, -1.33845642e-01f, 6.49400651e-02f,
  5.48947342e-02f, 7.54112378e-02f, -1.87094174e-02f, -9.58434492e-02f, 6.95850626e-02f, -3.50857303e-02f, -4.71482463e-02f, 1.82959363e-01f, -7.92047232e-02f, 1.90058015e-02f,
  3.60986926e-02f, -6.31354675e-02f, -1.63881537e-02f, 2.34628115e-02f, -8.19860250e-02f, -3.10085770e-02f, -1.69620752e-01f, -7.92204514e-02f, -4.56018485e-02f, -5.34489676e-02f,
  8.59268829e-02f, 5.31328544e-02f, -8.96353945e-02f, 4.77255136e-02f, -4.01816666e-02f, -1.28356501e-01f, 2.84639914e-02f, -5.17641678e-02f, 6.32462231e-03f, 5.40708862e-02f,
  -1.47329390e-01f, -1.10679884e-02f, -2.64313743e-02f, 8.37061480e-02f, -3.80489752e-02f, 1.67897195e-01f, 2.21403956e-01f, -1.47780493e-01f, -1.59515381e-01f, 1.61379233e-01f,
  1.79910466e-01f, -1.27441004e-01f, 3.60232219e-02f, -8.57294127e-02f, -9.14278924e-02f, -4.18562666e-02f, 1.28749564e-01f, 9.42429155e-02f, -9.67398169e-04f, -2.23392285e-02f,
  -1.61191404e-01f, -9.42307040e-02f, -3.40965763e-02f, -1.28432375e-03f, -4.03902382e-02f, 6.45829588e-02f, -1.11181289e-01f, 3.92385647e-02f, 3.52642611e-02f, -1.18494950e-01f,
  1.48149431e-01f, -8.12132880e-02f, 4.05500643e-02f, 7.19112903e-02f, -1.79398119e-01f, -1.00245096e-01f, 8.48583281e-02f, -5.44204228e-02f, 8.88565183e-02f, 9.61846560e-02f,
  1.60751566e-01f, -1.03965707e-01f, 2.90546212e-02f, 1.01641379e-01f, 5.92162535e-02f, -3.35353077e-03f, 5.48202693e-02f, -5.02024479e-02f, -5.15498444e-02f, 1.29637420e-02f,
  2.26181880e-01f, 4.88958620e-02f, 1.09578952e-01f, 1.02208249e-01f, -8.81442428e-02f, -4.78214025e-02f, -6.26414567e-02f, 5.72124422e-02f, -1.56635717e-01f, 1.12180069e-01f,
  1.35756910e-01f, -4.30128723e-02f, 3.11872326e-02f, -1.26571491e-01f, 6.42071143e-02f, 1.77962944e-01f, -8.35693479e-02f, 3.00242692e-01f, 7.73321316e-02f, -2.07132548e-01f,
  -1.23565070e-01f, -9.79604200e-04f, -4.69304211e-02f, -3.74709666e-02f, 5.06684110e-02f, 2.39447311e-01f, 5.44682294e-02f, -1.20297290e-01f, -6.13870360e-02f, 1.26457810e-01f,
  1.19123183e-01f, -1.29016533e-01f, -4.10386734e-03f, 2.15956762e-01f, -4.34445031e-02f, 2.27805018e-01f, 2.72269040e-01f, 5.78025021e-02f, -9.87871960e-02f, -1.68940440e-01f,
  -2.37406772e-02f, -2.19642222e-01f, -1.17197752e-01f, 8.61182138e-02f, 8.12241733e-02f, 1.42375410e-01f, -1.84773490e-01f, -1.75654575e-01f, -2.20153872e-02f, -8.90875310e-02f,
  9.19167101e-02f, -7.91817084e-02f, 9.40803364e-02f, 4.72614020e-02f, -1.30237304e-02f, -2.76288465e-02f, -1.95476025e-01f, -1.44959152e-01f, -5.40140131e-03f, 1.14810333e-01f,
  -8.33095834e-02f, 2.86006574e-02f, -6.11937381e-02f, 7.91971684e-02f, 1.24413604e-02f, -5.75045273e-02f, -3.29335220e-02f, -1.18907511e-01f, -3.15719359e-02f, -8.08669329e-02f,
  -7.50479996e-02f, 6.67169094e-02f, -5.78603931e-02f, -4.18643095e-02f, 6.74977526e-02f, -1.44963458e-01f, 9.81927067e-02f, -6.59359619e-02f, -1.41708955e-01f, 1.19545488e-02f,
  3.27177756e-02f, -1.25835836e-01f, -2.77436879e-02f, 3.67541313e-02f, -4.01756130e-02f, -4.35434356e-02f, 9.11701657e-03f, 3.19293998e-02f, -1.31583512e-01f, -1.35565877e-01f,
  -6.28174171e-02f, -3.80397439e-02f, -2.25071386e-02f, -6.15908876e-02f, 2.75727315e-03f, 9.86194834e-02f, -1.00201525e-01f, -1.45826459e-01f, 1.89100027e-01f, 2.88981814e-02f,
  -6.74905479e-02f, -5.28327860e-02f, 2.44223308e-02f, 1.73180133e-01f, 7.45832026e-02f, 2.13040426e-01f, 1.02970608e-01f, -8.84984881e-02f, 1.04710557e-01f, -1.06674187e-01f,
  -2.53940951e-02f, 6.23533241e-02f, -8.83571804e-03f, -1.57307357e-01f, -1.05257690e-01f, -3.36817876e-02f, -1.41858891e-01f, -5.13533913e-02f, -1.19732425e-01f, 1.87557377e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.20600581e-01f, 7.52830505e-02f, 1.32391334e-01f, 1.30826071e-01f, 1.15703105e-03f, 6.69391602e-02f, -1.01655431e-01f, 1.20423123e-01f, 8.61388370e-02f, -4.54981253e-02f,
  1.16081864e-01f, -5.90524115e-02f, -4.89131734e-02f, 1.76594481e-02f, -1.06685504e-01f, -9.63246748e-02f, 5.19724339e-02f, 1.32013649e-01f, -3.77023108e-02f, 1.09833553e-01f,
  9.42393243e-02f, 5.77589273e-02f, 3.82621549e-02f, 4.25638817e-03f, -6.84543326e-02f, -5.71060255e-02f, 4.88780141e-02f, -1.29677445e-01f, 6.40502125e-02f, -3.38596404e-02f,
  5.00873923e-02f, -2.31064949e-02f, 1.42776921e-01f, 5.46385385e-02f, 7.43395090e-02f, -6.73590451e-02f, -1.74719132e-02f, 4.97059822e-02f, 8.71491805e-03f, 3.48987542e-02f,
  9.54321846e-02f, 1.61907319e-02f, 6.91231042e-02f, -3.48897502e-02f, -1.04779951e-01f, 4.56306748e-02f, -9.46200639e-03f, -1.09302796e-01f, -6.82449415e-02f, -1.67882796e-02f,
  4.64078598e-02f, -1.11211702e-01f, 3.57775949e-02f, -9.39166546e-02f, -4.03454416e-02f, 5.08244708e-02f, -1.13621652e-01f, -8.54693279e-02f, -8.70782137e-02f, -5.52181387e-04f,
  7.38215968e-02f, 6.69711679e-02f, -2.76528988e-02f, 5.24045341e-02f, -5.48577197e-02f, 1.66608587e-01f, 2.81435642e-02f, 1.60376847e-01f, 1.80666715e-01f, -7.78137073e-02f,
  7.47633055e-02f, 9.07917842e-02f, -3.14982273e-02f, 1.69263020e-01f, 1.78020358e-01f, -3.89325842e-02f, 6.35950193e-02f, 2.62051802e-02f, 1.91474959e-01f, -7.62619674e-02f,
  -2.88964938e-02f, 1.29852258e-02f, 2.36775889e-03f, 1.04891531e-01f, 7.65484720e-02f, 1.16792336e-01f, -1.71540696e-02f, -5.94319813e-02f, 1.34583637e-01f, -1.24917813e-01f,
  -1.96064770e-01f, 5.59800342e-02f, -1.37072369e-01f, 5.40515929e-02f, -2.56782155e-02f, 7.67189488e-02f, -1.81986347e-01f, -3.52712721e-02f, 6.14033267e-02f, 7.33609945e-02f,
  7.26630390e-02f, 2.60037798e-02f, -1.03632800e-01f, -2.55186297e-02f, -1.28912061e-01f, -2.22780593e-02f, 1.80955932e-01f, -4.36565727e-02f, -5.41848578e-02f, 8.29209667e-03f,
  1.36003166e-01f, 1.47494137e-01f, 1.49191707e-01f, 3.72176431e-02f, -6.13878965e-02f, -4.54992577e-02f, 8.48124474e-02f, 9.69711915e-02f, 2.30320194e-03f, 1.78022847e-01f,
  3.04991957e-02f, -7.22547714e-03f, -1.56187629e-02f, 2.10787375e-02f, -2.45001204e-02f, 1.07220253e-02f, -9.38006788e-02f, -5.45009859e-02f, -1.22857755e-02f, 1.43198529e-02f,
  -5.53889610e-02f, 7.28866458e-02f, 8.06885362e-02f, -3.96735556e-02f, -7.05113187e-02f, -1.87701955e-02f, -1.11001521e-01f, 2.05286499e-02f, 1.75059587e-01f, -9.22802184e-03f,
  7.36592803e-03f, -1.09580837e-01f, -2.97101997e-02f, -3.34260613e-02f, 1.47222608e-01f, 7.98048079e-02f, 2.68121082e-02f, 6.41785935e-02f, 3.75660993e-02f, 4.71632928e-02f,
  1.07275821e-01f, -6.01519719e-02f, 1.70078352e-01f, -1.33722395e-01f, -2.01277971e-01f, -7.03879818e-02f, 1.01052970e-01f, -1.46178290e-01f, -2.47656275e-02f, 9.61094275e-02f,
  -6.35903850e-02f, -8.49977508e-03f, 1.46974176e-01f, 3.67815010e-02f, -2.73985043e-02f, 9.76905748e-02f, -2.00033247e-01f, 1.30609229e-01f, -8.82932469e-02f, 1.17026620e-01f,
  7.06272349e-02f, -9.16214734e-02f, 4.79553081e-03f, -1.11959957e-01f, 1.23736136e-01f, 9.78211388e-02f, 7.23833963e-02f, -2.83631720e-02f, 1.08395470e-03f, -8.77074376e-02f,
  -3.94111238e-02f, 5.20604514e-02f, 1.01554781e-01f, -7.76468664e-02f, 9.99065489e-03f, -2.43352912e-02f, -1.41640782e-01f, -6.99300244e-02f, 8.18964913e-02f, -8.62477943e-02f,
  -1.23946317e-01f, -6.12429082e-02f, 1.43093720e-01f, -1.29808700e-02f, -1.46419808e-01f, -2.80588511e-02f, -3.09427194e-02f, -2.71567181e-02f, 1.83567643e-01f, 7.67326877e-02f,
  2.19256785e-02f, 1.04231708e-01f, -3.59879285e-02f, 7.36470520e-02f, 1.18576244e-01f, 4.89737503e-02f, 7.16962144e-02f, 1.09087955e-02f, 4.93872985e-02f, 5.47843464e-02f,
  4.88212071e-02f, 4.18378748e-02f, 8.19555894e-02f, 2.51011662e-02f, 1.34446383e-01f, -8.43652338e-02f, 8.79908577e-02f, 1.92641690e-01f, -1.54247992e-02f, -2.34476581e-01f,
  -1.19613528e-01f, 1.06270753e-01f, -1.99416392e-02f, -9.35996696e-02f, -1.10439651e-01f, 1.01509102e-01f, 4.55838107e-02f, -1.05027452e-01f, 9.00280625e-02f, 1.37750864e-01f,
  -5.29614538e-02f, -1.30655453e-01f, -7.37519711e-02f, 1.47852257e-01f, 2.33702622e-02f, 2.47619390e-01f, 1.92781046e-01f, 3.76800378e-03f, 1.58837542e-01f, 1.21257037e-01f,
  1.83366224e-01f, -9.54376757e-02f, -1.33727007e-02f, 1.59237713e-01f, 4.65839729e-02f, 8.86020064e-02f, -3.90338935e-02f, -1.61485285e-01f, 2.17466384e-01f, -3.59676369e-02f,
  1.02920987e-01f, -7.98283368e-02f, -9.09928754e-02f, 9.66622904e-02f, -6.39537349e-02f, -8.93763304e-02f, 8.49793777e-02f, -9.75452214e-02f, -5.32571450e-02f, -1.52818661e-03f,
  -3.60519588e-02f, 1.22901075e-01f, 2.12874040e-01f, 7.03601241e-02f, 1.68483853e-01f, 1.85830779e-02f, 9.73448623e-03f, 1.58217132e-01f, 1.77951798e-01f, 1.30411893e-01f,
  2.24721804e-01f, 1.67713851e-01f, 1.78779140e-01f, 1.47440761e-01f, 1.88403595e-02f, 4.12281975e-02f, 1.08214572e-01f, 4.35449593e-02f, 1.12866491e-01f, 1.93249628e-01f,
  -1.02784773e-02f, 1.31964356e-01f, -5.23152761e-02f, 6.48248568e-02f, 4.50741127e-02f, -1.55755013e-01f, 2.29252893e-02f, -7.28025436e-02f, -6.41956478e-02f, 7.53806680e-02f,
  -2.08746687e-01f, -3.94168757e-02f, 1.49828317e-02f, 4.58621494e-02f, 1.04971968e-01f, -2.91700900e-01f, -7.90643245e-02f, -1.41565114e-01f, -1.18837647e-01f, -6.38138801e-02f,
  2.09218070e-01f, 2.64605463e-01f, 1.09548621e-01f, 9.11764987e-03f, -4.70338855e-03f, 1.63957551e-01f, -6.40601367e-02f, 2.17117324e-01f, 1.40922964e-02f, 1.80791929e-01f,
  -2.20234934e-02f, -1.27815872e-01f, 1.40557110e-01f, 6.44383729e-02f, -9.85103399e-02f, -4.28784713e-02f, 3.98662873e-04f, 8.07902366e-02f, -5.71071170e-02f, 7.69711956e-02f,
  4.54184972e-03f, 3.47456336e-01f, -5.79571677e-03f, 1.92361370e-01f, 2.19697729e-01f, -3.81486900e-02f, -3.16227786e-02f, 1.57364026e-01f, 1.28346860e-01f, -3.52052180e-03f,
  -2.62823887e-02f, 8.76332074e-02f, 7.18043000e-03f, 7.61916190e-02f, -3.85692976e-02f, -8.14187154e-03f, 9.92963612e-02f, 5.40978611e-02f, 1.60079449e-01f, 5.53083010e-02f,
  -3.52782831e-02f, 1.15521342e-01f, 3.81190367e-02f, 3.15736756e-02f, 1.04878567e-01f, -1.91471353e-01f, 3.17854017e-01f, -2.28429183e-01f, -3.37893190e-03f, 9.23831016e-02f,
  2.19633311e-01f, 2.32107371e-01f, 8.40899795e-02f, -6.96647689e-02f, 1.89967945e-01f, -1.05239935e-01f, -4.33702208e-02f, 1.99086010e-01f, -4.36247513e-02f, 1.45066500e-01f,
  -1.31013766e-01f, 2.79571558e-03f, 1.25154153e-01f, -4.30675745e-02f, -9.80554745e-02f, -2.46331841e-01f, -1.81520492e-01f, -7.70252272e-02f, 2.09690154e-01f, -2.59904146e-01f,
  6.77736104e-02f, -1.18689969e-01f, -4.32653539e-03f, -1.65511388e-02f, 3.22603881e-02f, 3.40510100e-01f, 3.70663963e-02f, 2.69185156e-02f, 1.94674581e-02f, 1.06947169e-01f,
  1.32138819e-01f, -1.17963932e-01f, 4.46983390e-02f, 4.82967682e-02f, -2.68592816e-02f, -1.21968158e-01f, -6.13197610e-02f, 4.55517285e-02f, 8.16405118e-02f, 1.28497764e-01f,
  1.14425704e-01f, 9.33550671e-02f, -1.04145341e-01f, -7.01979622e-02f, -7.06563517e-02f, 9.18413252e-02f, 1.03114136e-01f, 2.10879631e-02f, 7.44928122e-02f, 2.58150958e-02f,
  -1.36884553e-02f, -4.48364951e-02f, -6.41101971e-02f, 1.35109752e-01f, -1.17490189e-02f, 1.65704429e-01f, 5.68406694e-02f, 8.69177356e-02f, -5.66281341e-02f, -1.25256881e-01f,
  -1.75840020e-01f, 8.17758292e-02f, 2.69651096e-02f, -1.25732198e-01f, -6.28332272e-02f, 6.61102533e-02f, -8.45265985e-02f, -5.09554893e-02f, -4.07646410e-02f, 6.52037188e-02f,
  5.87226488e-02f, 2.81258114e-02f, 5.06619513e-02f, -5.98848723e-02f, -4.93882515e-04f, 1.50916670e-02f, -4.13103662e-02f, -9.63852480e-02f, -1.34604514e-01f, 8.45149681e-02f,
  1.17079295e-01f, -9.17395726e-02f, -1.19735815e-01f, 8.62559676e-02f, -1.86387375e-02f, -6.28668591e-02f, 2.20555812e-02f, -2.42789518e-02f, 1.10792480e-01f, -3.96176390e-02f,
  -1.58985797e-02f, 7.66010433e-02f, -4.68588881e-02f, 1.22396782e-01f, 8.40051994e-02f, -1.31811630e-02f, 7.07987696e-02f, 1.22131467e-01f, -1.17977843e-01f, 1.11043714e-01f,
  7.14594275e-02f, 5.42069264e-02f, 1.45955667e-01f, -1.00518102e-02f, 9.76920128e-02f, -8.05510208e-02f, 1.55688412e-02f, -1.45604461e-02f, 1.63418025e-01f, -6.06328286e-02f,
  1.21226825e-01f, -7.39500076e-02f, 1.10424928e-01f, 1.50523096e-01f, 1.26267433e-01f, -5.53743765e-02f, 7.40046054e-02f, 1.01053752e-01f, 1.17468104e-01f, 6.68276027e-02f,
  1.23777382e-01f, -1.02679178e-01f, 1.89762507e-02f, -1.01554647e-01f, -2.07969517e-01f, -1.17823780e-02f, -3.84493023e-02f, 5.23062684e-02f, -2.49572471e-02f, -4.41908352e-02f,
  -2.53852248e-01f, 8.53751004e-02f, -1.73087597e-01f, -3.70637178e-02f, 1.16536058e-01f, 4.57336307e-02f, -1.42650142e-01f, -1.63201660e-01f, 6.76939264e-02f, 2.09403355e-02f,
  1.51621938e-01f, 1.57193393e-02f, -2.65294546e-03f, 9.93105769e-02f, 4.72064130e-02f, 1.21696219e-01f, 1.70874611e-01f, 2.44803369e-01f, -7.21284971e-02f, -9.04878527e-02f,
  -6.58248365e-02f, 4.35531419e-03f, 1.43716216e-01f, -1.11677952e-01f, 1.71958908e-01f, 6.93197642e-03f, -7.32211992e-02f, 1.05200976e-01f, 1.05959691e-01f, -1.18443564e-01f,
  -1.14041388e-01f, -4.25987504e-02f, -1.05518945e-01f, 1.23933829e-01f, 1.15711927e-01f, 7.56543055e-02f, -8.32595080e-02f, -1.06325857e-01f, -7.07955062e-02f, -1.16227709e-01f,
  9.58773494e-02f, 4.43498194e-02f, 5.10039516e-02f, 1.07449509e-01f, -1.52885001e-02f, 1.14738112e-02f, 1.35743888e-02f, -6.35121539e-02f, -3.27260569e-02f, 9.01386738e-02f,
  -7.52039850e-02f, -2.73607206e-02f, -6.44094795e-02f, -9.02975202e-02f, -4.99983467e-02f, -5.91928102e-02f, -8.77972990e-02f, -6.73134625e-02f, 5.42940013e-02f, 7.14420974e-02f,
  9.56309214e-02f, -9.89874303e-02f, -2.78254668e-03f, 4.57758904e-02f, -4.91492562e-02f, 8.30215961e-02f, -6.48400262e-02f, -5.94768263e-02f, -5.15913814e-02f, 2.47862842e-03f,
  -3.20868567e-02f, 6.78876936e-02f, 8.41114148e-02f, 6.80071637e-02f, -2.07547676e-02f, -7.25256652e-02f, 7.58044943e-02f, -6.80997521e-02f, 9.79982689e-02f, -9.18609872e-02f,
  6.77775741e-02f, -1.09232165e-01f, -6.11401945e-02f, -1.06310956e-01f, 8.92678127e-02f, 1.17975689e-01f, 4.07347679e-02f, -8.75004753e-02f, 2.22627856e-02f, 1.00497022e-01f,
  -8.94182473e-02f, 4.41549942e-02f, 8.17746371e-02f, 7.94802383e-02f, -2.33560558e-02f, 5.15095852e-02f, 1.26564324e-01f, -2.54981574e-02f, -6.60723299e-02f, -2.58380808e-02f,
  1.54977694e-01f, -6.36415407e-02f, -2.40576286e-02f, 6.39921054e-02f, 1.42984420e-01f, 1.69423632e-02f, 6.08500205e-02f, 1.35364696e-01f, -8.18997920e-02f, 2.41797008e-02f,
  1.70253515e-02f, -1.67207140e-02f, 4.99390773e-02f, 5.96326217e-02f, -9.15410221e-02f, -9.05574188e-02f, -5.26731536e-02f, 9.32206307e-03f, 4.27777926e-03f, -2.01318134e-02f,
  1.03636481e-01f, 6.01889566e-02f, -4.48206887e-02f, -1.62400131e-03f, 8.18822756e-02f, 1.32322207e-01f, -7.92756975e-02f, -4.87435535e-02f, 1.63396057e-02f, 1.18638642e-01f,
  -1.29455537e-01f, 3.63693014e-02f, 1.24242954e-01f, 7.65637234e-02f, 1.09655887e-01f, -1.51285097e-01f, -8.83437917e-02f, 7.02976361e-02f, -3.69307175e-02f, 6.45139664e-02f,
  -7.96352029e-02f, 1.71770260e-01f, 1.38971373e-03f, -1.24773674e-01f, 1.67578906e-02f, 1.12091832e-01f, 5.38578108e-02f, -3.41093354e-02f, -1.17309168e-01f, -1.17697828e-01f,
  2.08419966e-04f, -8.99903625e-02f, 5.53147122e-03f, 4.74920943e-02f, -2.35683210e-02f, -4.74563800e-02f, 5.54571971e-02f, 3.10971458e-02f, -1.11489054e-02f, 1.37967616e-01f,
  1.30212352e-01f, -6.75409883e-02f, 8.70996621e-03f, -7.75317699e-02f, 1.41770601e-01f, 1.56623751e-01f, 2.15027824e-01f, 1.30835205e-01f, 1.58069268e-01f, 1.37370050e-01f,
  7.59248734e-02f, 1.96114823e-01f, 9.21786427e-02f, 1.77411437e-01f, 2.56026179e-01f, -1.47069735e-03f, 2.50561565e-01f, 1.17492951e-01f, 1.92913279e-01f, 8.15850794e-02f,
  2.12460563e-01f, 2.13048533e-01f, 1.58431664e-01f, -2.87000593e-02f, 1.38742343e-01f, 1.65773138e-01f, 9.34028905e-03f, 3.65615031e-03f, -2.59501725e-01f, -3.80863529e-03f,
  1.60464659e-01f, -1.76894814e-01f, -1.62253261e-01f, 1.99575499e-01f, -2.38237053e-01f, -8.89201835e-02f, 2.79760987e-01f, 8.50878283e-02f, 2.17318729e-01f, -3.16132069e-01f,
  7.76714832e-02f, -8.33277926e-02f, -1.56431437e-01f, 1.71123087e-01f, 2.70915389e-01f, 3.25451493e-01f, -3.12330239e-02f, -4.18321677e-02f, 6.23737983e-02f, -2.62440480e-02f,
  -9.21972170e-02f, 1.50549248e-01f, 6.68145716e-02f, 2.28478061e-03f, 8.15982595e-02f, -1.25433668e-01f, 7.01193586e-02f, 2.38824353e-01f, -1.06642142e-01f, 3.49474745e-03f,
  9.61778238e-02f, -1.60761446e-01f, 1.69765949e-02f, 9.69348550e-02f, 3.08268238e-02f, -3.72531787e-02f, 7.20285922e-02f, 1.80749651e-02f, -1.26189524e-02f, -2.46426482e-02f,
  2.48612724e-02f, 1.35885432e-01f, 1.12921476e-01f, 2.98805684e-02f, -7.59394513e-03f, 1.40827298e-01f, -1.14575930e-01f, -1.16948724e-01f, -4.83535556e-03f, 2.62456127e-02f,
  2.66867341e-03f, 9.81111676e-02f, 1.32193312e-01f, 1.18278868e-01f, 1.05165303e-01f, 7.00821122e-03f, 7.69707710e-02f, 1.47654461e-02f, 1.56728342e-01f, -1.05633013e-01f,
  -1.98659480e-01f, -4.60289009e-02f, 3.72159155e-03f, 4.64099087e-02f, 1.07352674e-01f, -3.79295237e-02f, -1.19393706e-01f, -7.25953057e-02f, -2.97510773e-02f, -1.38563141e-01f,
  -6.57323003e-02f, 4.92781587e-02f, -9.14374739e-02f, 2.24181917e-03f, -6.55020252e-02f, 1.32979363e-01f, 6.33664755e-03f, -5.02541512e-02f, -9.14558247e-02f, -3.98357324e-02f,
  -1.02112211e-01f, 1.62094116e-01f, 1.72344297e-01f, 8.95425826e-02f, 3.96398120e-02f, -7.00366348e-02f, -4.62514907e-02f, 8.64612609e-02f, 2.87047941e-02f, 1.09459452e-01f,
  1.27167806e-01f, -6.79738820e-02f, -7.92174265e-02f, 5.69550209e-02f, -7.64605328e-02f, 7.55811557e-02f, -1.42195867e-02f, 9.55458507e-02f, 1.10473849e-01f, 5.10020554e-02f,
  5.63608445e-02f, 5.64664192e-02f, 1.43688719e-03f, -1.30019905e-02f, 1.41408816e-01f, -8.31639543e-02f, 3.14239273e-03f, -8.10227543e-02f, 3.49278152e-02f, -3.15184928e-02f,
  1.02366142e-01f, 8.43128413e-02f, -1.00609936e-01f, 1.02191223e-02f, -7.61172995e-02f, -1.10166415e-03f, 6.42417446e-02f, -8.24147090e-02f, -4.16928045e-02f, 1.36558697e-01f,
  1.43510625e-01f, -6.55332021e-03f, -1.41447028e-02f, 1.05359532e-01f, 5.73337916e-03f, 2.37958673e-02f, -3.64214331e-02f, 1.15786314e-01f, -2.96106413e-02f, 2.04920378e-02f,
  -1.00200683e-01f, 1.60851970e-01f, -6.77215904e-02f, -8.31025541e-02f, 1.46206087e-02f, 9.52069238e-02f, 3.92202698e-02f, 2.73369905e-02f, 9.05030686e-03f, -7.42753819e-02f,
  7.92113170e-02f, 1.81062683e-01f, 6.79470524e-02f, 6.07326569e-04f, -1.13436855e-01f, -9.46206227e-02f, 6.19876608e-02f, -3.16744335e-02f, -9.79022160e-02f, 1.16598800e-01f,
  -1.08983137e-01f, 1.98350344e-02f, 4.67252024e-02f, -9.02662724e-02f, 3.73767875e-02f, 5.37831523e-02f, 8.09464902e-02f, 9.95717645e-02f, -1.20354995e-01f, 1.08191170e-01f,
  -5.41374134e-03f, -6.90355897e-02f, -8.33126977e-02f, 1.27894804e-01f, 9.58941802e-02f, -4.36353199e-02f, 4.72228564e-02f, -9.08623263e-02f, 1.04024142e-01f, -8.81163180e-02f,
  -6.10224418e-02f, 4.15305756e-02f, -3.45610008e-02f, -6.44502714e-02f, 4.16034274e-02f, 3.32398191e-02f, 1.59809560e-01f, 1.36500895e-01f, 5.21797538e-02f, -3.61328125e-02f,
  -7.74914771e-02f, -4.94655780e-02f, -3.73721607e-02f, -2.64830217e-02f, 9.80663374e-02f, -7.95265734e-02f, -2.60915160e-02f, -8.39239731e-02f, 6.97224354e-03f, 3.87760364e-02f,
  -1.23620279e-01f, -9.24962759e-03f, 4.07551862e-02f, 4.81206477e-02f, -1.04445465e-01f, -1.32643417e-01f, -9.16969404e-02f, 5.31276725e-02f, 1.65004551e-01f, 7.16167539e-02f,
  5.31256273e-02f, -2.38612425e-02f, -9.73613337e-02f, -5.65022193e-02f, -4.45363112e-02f, 3.49709205e-02f, -1.33368269e-01f, 3.56274284e-02f, 6.28033057e-02f, -1.95560455e-02f,
  1.29758604e-02f, 8.10338482e-02f, 9.87933204e-02f, 6.91948831e-02f, 7.83298016e-02f, 7.16386214e-02f, 1.46447316e-01f, 1.36820808e-01f, 6.40971810e-02f, 2.31205877e-02f,
  -1.11109436e-01f, 9.62671041e-02f, 1.08480677e-01f, 3.05125192e-02f, -3.21239941e-02f, 1.22557119e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  6.92817010e-03f, 3.60906795e-02f, -3.27503197e-02f, 1.42715126e-01f, 1.54406354e-01f, 1.42692149e-01f, 7.93420374e-02f, 9.16653723e-02f, -2.81344093e-02f, 9.57311317e-02f,
  2.31937900e-01f, -1.46951163e-02f, 6.00846261e-02f, -3.90811190e-02f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  3.89380343e-02f, 2.44717835e-03f, -1.50436582e-02f, 3.78782153e-02f, 4.33465578e-02f, -9.02276561e-02f, 1.58270180e-01f, 1.47205532e-01f, -6.57192245e-02f, -4.56112139e-02f,
  1.20723464e-01f, 5.40650077e-02f, -3.88868712e-02f, -1.87097296e-01f, 1.69042245e-01f, -5.61704161e-03f, 1.27626970e-01f, 8.10548365e-02f, 1.82608441e-01f, 3.75183597e-02f,
  -1.33805191e-02f, -1.67317931e-02f, 1.10509634e-01f, 7.26953894e-02f, -1.43576726e-01f, 5.35690971e-02f, 3.98496771e-03f, -7.25845248e-02f, -8.27409923e-02f, -1.72882617e-01f,
  -5.08784433e-04f, -5.65758646e-02f, 2.84165442e-01f, -1.32655781e-02f, 2.48680428e-01f, -8.99620429e-02f, 4.91268821e-02f, 1.45479916e-02f, -1.73764110e-01f, -1.14819340e-01f,
  -1.50690362e-01f, 1.24860175e-01f, -2.01567665e-01f, 2.02810436e-01f, 1.23173758e-01f, -1.67406932e-01f, -3.57603580e-02f, -8.95998850e-02f, 1.25630975e-01f, -1.80812046e-01f,
  -1.84984095e-02f, -1.70381099e-01f, -7.96488598e-02f, 3.20214173e-03f, 2.98443157e-02f, 2.13706300e-01f, -9.52257067e-02f, -2.55091220e-01f, 1.15440086e-01f, -7.08454549e-02f,
  -1.26308471e-01f, -1.46525562e-01f, -9.61065441e-02f, -6.73358217e-02f, -2.68545765e-02f, -4.88284938e-02f, 1.67348385e-01f, 1.81921154e-01f, 1.07815936e-01f, 5.41710705e-02f,
  2.16531497e-03f, -6.25659432e-03f, -1.28107980e-01f, -1.18741263e-02f, 1.00280479e-01f, 5.95110357e-02f, 9.70660076e-02f, 1.72317639e-01f, -1.29418179e-01f, 6.16718866e-02f,
  5.63386874e-03f, -3.93763781e-02f, 5.01065888e-02f, 1.55681353e-02f, -3.16368826e-02f, 1.22237662e-02f, 2.22125221e-02f, 4.25444320e-02f, 1.40881330e-01f, -1.28238931e-01f,
  6.84829429e-02f, 3.18423212e-02f, -1.80200294e-01f, 2.50117958e-01f, 2.29455963e-01f, 6.17195182e-02f, -1.83865190e-01f, -3.68623286e-02f, 9.49304625e-02f, -1.82879448e-01f,
  2.71916568e-01f, 5.72189689e-02f, 9.06490088e-02f, 1.68149501e-01f, -1.73217848e-01f, -1.56040028e-01f, 9.81409773e-02f, -2.27818131e-01f, 1.09887738e-02f, 7.95366615e-03f,
  -9.26861241e-02f, -6.15840890e-02f, -3.65994871e-02f, -1.98422559e-02f, -9.38399658e-02f, 2.40147486e-01f, 1.41632244e-01f, -3.35963070e-02f, -5.49964122e-02f, 6.65139332e-02f,
  -6.92677125e-02f, 1.53585792e-01f, 5.18077565e-03f, -1.21938184e-01f, -1.56905174e-01f, 2.16669932e-01f, -1.02503315e-01f, -8.36239159e-02f, -7.20169209e-03f, -4.05844152e-02f,
  6.94941804e-02f, -8.29630643e-02f, 1.02363482e-01f, 4.91800793e-02f, -2.54089083e-03f, 1.27717108e-01f, -3.92271318e-02f, 2.43754145e-02f, 1.54326171e-01f, -9.75008830e-02f,
  1.82098523e-02f, -8.50626081e-03f, -2.30810456e-02f, 1.41059309e-01f, -7.68299773e-02f, -1.40090473e-02f, -8.88210461e-02f, 3.33127864e-02f, -3.40686217e-02f, 3.21164392e-02f,
  -1.94623113e-01f, -7.07552582e-02f, 5.54933138e-02f, -3.23259145e-01f, -7.00560659e-02f, -1.44696888e-03f, 1.87906161e-01f, -1.34546757e-01f, -5.44678196e-02f, 2.70508796e-01f,
  1.25183687e-01f, -3.38523053e-02f, -1.48676097e-01f, -1.52876033e-02f, 1.87829554e-01f, 1.40254259e-01f, -1.00525454e-01f, 3.15729529e-01f, 7.32368678e-02f, -2.45300606e-01f,
  7.51252770e-02f, -5.13907000e-02f, -7.48458952e-02f, -1.05332015e-02f, 2.70284325e-01f, -2.40052357e-01f, -8.17329213e-02f, 1.06250830e-01f, -1.89237576e-02f, 5.91430161e-03f,
  1.31674871e-01f, 7.46221794e-03f, 4.35714722e-02f, 2.12928817e-01f, -1.35597080e-01f, 5.21220453e-02f, 2.61049364e-02f, 3.59101035e-02f, -3.80866900e-02f, -3.89056690e-02f,
  -9.51882973e-02f, -6.96154684e-02f, -9.27991718e-02f, -1.15739450e-01f, 2.11843736e-02f, 1.47504166e-01f, -6.48910552e-02f, -1.99197941e-02f, -2.10418925e-02f, -4.92847823e-02f,
  -9.99873318e-03f, 8.17004070e-02f, -6.68532699e-02f, 1.32376671e-01f, -6.11440912e-02f, 2.83870071e-01f, -7.90000409e-02f, 7.38162324e-02f, 2.71114223e-02f, 4.96399477e-02f,
  -1.09486431e-01f, -1.08231410e-01f, 1.65202506e-02f, -7.02425167e-02f, -1.04782894e-01f, -9.77280959e-02f, 3.83624919e-02f, 1.61272213e-01f, 4.42600511e-02f, -8.11805055e-02f,
  2.51822807e-02f, 1.81624413e-01f, -4.31924984e-02f, 1.44637777e-02f, -2.59705484e-01f, -1.68464050e-01f, 2.19896324e-02f, -8.64385739e-02f, 1.34978577e-01f, -8.36969241e-02f,
  1.89446107e-01f, -4.12309058e-02f, -1.34389535e-01f, -8.63372311e-02f, 4.54655141e-02f, -6.65795133e-02f, 2.31426917e-02f, 5.71966358e-02f, 2.34834608e-02f, -9.85592306e-02f,
  -1.07990831e-01f, 8.19556937e-02f, -1.16380095e-01f, 1.64028794e-01f, 1.49342060e-01f, 1.46638349e-01f, 5.11885341e-03f, -1.76825762e-01f, 4.49560471e-02f, 4.81975377e-02f,
  -5.65475002e-02f, -6.31138608e-02f, -1.27698049e-01f, 1.51411399e-01f, -5.72345369e-02f, -1.26347944e-01f, -5.13984151e-02f, 9.59573016e-02f, 7.62572065e-02f, 2.45449040e-02f,
  -1.03339627e-01f, 5.87236993e-02f, 1.67216696e-02f, -1.44957647e-01f, 6.76452294e-02f, 4.44631055e-02f, -2.84533314e-02f, -9.03163329e-02f, 5.99083677e-02f, -7.19406381e-02f,
  5.16366884e-02f, -8.31347108e-02f, -1.74397886e-01f, -6.38893992e-02f, -5.39787067e-03f, 1.68676361e-01f, 5.96679188e-02f, -5.16360290e-02f, 7.12626651e-02f, -1.37756057e-02f,
  -8.53934065e-02f, 2.20802307e-01f, -1.79159015e-01f, -2.87637506e-02f, -2.02774212e-01f, 1.99858814e-01f, -3.56838964e-02f, -2.21996307e-01f, 8.70932476e-04f, 6.54680803e-02f,
  1.30929753e-01f, -4.78646718e-02f, 7.02345893e-02f, -1.06897213e-01f, -3.36304568e-02f, -3.64110172e-01f, 8.16452652e-02f, 3.16785157e-01f, 1.22405542e-02f, 1.30085319e-01f,
  1.87639166e-02f, 3.55026089e-02f, -7.19066709e-02f, 1.46938860e-01f, -7.41170123e-02f, 1.22939944e-01f, 3.77759337e-02f, -7.62995407e-02f, -6.69161752e-02f, -1.63203940e-01f,
  4.43151146e-02f, -1.56079635e-01f, 6.06231503e-02f, -2.05276217e-02f, 1.14251219e-01f, 6.71795532e-02f, -1.39562801e-01f, -8.78446177e-02f, 3.15110050e-02f, -5.36847971e-02f,
  -3.36320885e-02f, 1.11900523e-01f, 6.13871291e-02f, 1.38649464e-01f, -3.61572243e-02f, 4.41839769e-02f, -3.71269286e-02f, -2.33845860e-02f, 2.37946343e-02f, 5.91946840e-02f,
  -7.78272748e-02f, 1.95960961e-02f, 3.90370898e-02f, 1.44221932e-01f, -2.10629459e-02f, -5.72095364e-02f, 7.16834292e-02f, 7.89266527e-02f, -8.61394927e-02f, 4.14957404e-02f,
  9.06424969e-02f, -6.38514534e-02f, -8.39664638e-02f, -1.17752939e-01f, 4.27059904e-02f, 2.20879331e-01f, 7.50068054e-02f, -1.19781278e-01f, -8.02427977e-02f, 6.52939603e-02f,
  5.31695150e-02f, 6.45749783e-03f, -7.26382509e-02f, -1.23862639e-01f, -5.98799847e-02f, 1.48072839e-01f, -1.61100104e-01f, 1.72018819e-02f, 1.31282732e-01f, -4.90460880e-02f,
  7.30078726e-04f, 2.04437941e-01f, -5.24360463e-02f, 4.95526791e-02f, 1.35162070e-01f, 1.77731588e-02f, -4.28888686e-02f, 1.27193943e-01f, -9.70142186e-02f, -6.31829649e-02f,
  -1.40925450e-02f, -1.17383286e-01f, 9.37397927e-02f, 7.67508149e-02f, 1.34876207e-01f, -3.00554752e-01f, 9.50155258e-02f, -5.73616661e-03f, 1.05996802e-01f, 3.97368073e-02f,
  8.15913379e-02f, -1.50107276e-02f, -3.07904370e-02f, -1.50179997e-01f, -1.32740354e-02f, -1.66040704e-01f, -1.29188254e-01f, -8.19665566e-02f, -7.35620409e-02f, -1.65581983e-02f,
  1.39492890e-03f, -1.00574069e-01f, -4.17653993e-02f, 3.18315104e-02f, -1.08335294e-01f, -1.32699028e-01f, 1.86958313e-02f, 1.27692163e-01f, -9.51781496e-02f, -1.26094326e-01f,
  -1.65358528e-01f, -4.12265286e-02f, -7.45544955e-02f, -1.22036010e-01f, 1.21269129e-01f, -1.60054728e-01f, -1.66664734e-01f, -1.51744336e-01f, 2.70783249e-02f, -9.83634070e-02f,
  -9.49063748e-02f, 1.40655383e-01f, -1.09733254e-01f, 1.83339611e-01f, 6.68057129e-02f, 1.15330644e-01f, -1.28734663e-01f, -5.20524271e-02f, 4.81278896e-02f, -1.91142648e-01f,
  2.00322241e-01f, -5.90931997e-02f, 1.71275854e-01f, 1.43544436e-01f, 1.00953177e-01f, -2.37122059e-01f, 1.89880997e-01f, -1.57107368e-01f, 9.79495198e-02f, 1.14729941e-01f,
  5.91512723e-03f, 1.01245409e-02f, -2.30635777e-01f, 1.82545468e-01f, -4.53185774e-02f, -7.04083417e-04f, 1.72274992e-01f, -9.22541097e-02f, -7.71952718e-02f, 1.56829074e-01f,
  -3.82101629e-03f, 1.69478998e-01f, -9.78403166e-02f, -2.27294210e-02f, -2.20866710e-01f, 1.05294332e-01f, -1.39559895e-01f, 1.25978753e-01f, -1.19931459e-01f, -1.16847105e-01f,
  2.82027815e-02f, -1.66224554e-01f, 6.35736957e-02f, -4.03179415e-02f, -9.21547338e-02f, -3.50052193e-02f, -6.60855770e-02f, -1.38412774e-01f, 2.27345657e-02f, -7.72119164e-02f,
  -1.23880468e-01f, -1.81847334e-01f, -1.88186876e-02f, 1.00028077e-02f, 1.14934407e-01f, -4.07771021e-02f, -4.01861407e-02f, -6.66094348e-02f, 5.04281856e-02f, -8.72951522e-02f,
  -1.83618098e-01f, -1.21504180e-01f, 1.85617562e-02f, -2.77076751e-01f, -7.70849362e-02f, 1.24251440e-01f, 1.65432796e-01f, -2.60253042e-01f, 1.02735432e-02f, 7.34072998e-02f,
  1.63001105e-01f, -2.13478610e-01f, -5.29082082e-02f, 1.02237396e-01f, 5.03236726e-02f, 1.85448170e-01f, -1.37273252e-01f, 2.76456714e-01f, 2.11888939e-01f, -4.21659797e-02f,
  -1.41382083e-01f, -6.50129616e-02f, -2.22047865e-01f, -1.45655185e-01f, 7.03631863e-02f, 4.92425524e-02f, 2.14461356e-01f, -1.51094645e-01f, 8.92988741e-02f, -6.03100657e-02f,
  4.46934178e-02f, -4.79352847e-02f, -1.47888735e-01f, 2.13239893e-01f, -1.01799496e-01f, -1.17500089e-01f, 5.68623282e-02f, 1.27895817e-01f, 6.84103966e-02f, -2.34100334e-02f,
  8.95594433e-02f, -2.53466070e-02f, 1.59153953e-01f, 1.43405469e-02f, 6.89255521e-02f, -1.35274166e-02f, -6.93361238e-02f, 1.85385481e-01f, -4.79233377e-02f, 1.58035263e-01f,
  3.76281738e-02f, 1.85720682e-01f, 8.77389014e-02f, 9.71765667e-02f, 1.12184368e-01f, 1.96821913e-02f, 2.67746225e-02f, -2.34023795e-01f, 1.19220130e-01f, 5.44867814e-02f,
  2.14530677e-01f, 1.03211865e-01f, 6.77701309e-02f, 2.89954953e-02f, -3.79627682e-02f, 9.65131819e-02f, -7.35849738e-02f, 1.79817304e-01f, -1.00867897e-02f, 1.51308611e-01f,
  -5.65056242e-02f, -2.37216149e-02f, -2.64577698e-02f, -2.43036479e-01f, 1.39544308e-01f, 2.10127845e-01f, 2.48276472e-01f, -1.69431478e-01f, 8.57163221e-02f, -5.31345829e-02f,
  3.18912230e-02f, -1.31886616e-01f, -2.45379016e-01f, 3.05097520e-01f, -1.34381922e-02f, 8.63993838e-02f, 1.53362388e-02f, -1.84550151e-01f, -1.43731758e-01f, 1.40077204e-01f,
  -5.24184704e-02f, 5.51406713e-03f, 1.44019127e-01f, -9.72964764e-02f, 1.11009575e-01f, -1.06851704e-01f, -1.11563809e-01f, 9.18840468e-02f, 2.74146665e-02f, -2.07761019e-01f,
  6.67865062e-03f, -8.05217102e-02f, -2.16788724e-02f, -1.10086992e-01f, -4.79984768e-02f, -1.37442157e-01f, -1.57089800e-01f, -1.61409900e-02f, -1.12774968e-01f, -3.15813534e-02f,
  -3.77970636e-02f, -1.15851656e-01f, -1.70242354e-01f, -5.01291733e-03f, -9.28348675e-02f, -3.03053781e-02f, -1.10455476e-01f, -3.82101834e-02f, 1.33621581e-02f, 4.17102166e-02f,
  -8.96894932e-02f, 2.21312076e-01f, -9.53425281e-03f, -4.88198102e-02f, 5.90404943e-02f, -8.43705162e-02f, -4.62040268e-02f, 6.15574494e-02f, -1.90233216e-01f, -4.63867933e-02f,
  -3.22961733e-02f, -2.51983762e-01f, 6.82993382e-02f, -4.14267033e-02f, 3.81889865e-02f, -1.76924944e-01f, -1.64187998e-01f, 2.55209237e-01f, -3.94028910e-02f, -1.80799752e-01f,
  -2.22644687e-01f, 1.70611382e-01f, -2.00033225e-02f, 1.34617925e-01f, -1.22822963e-01f, 2.34719828e-01f, 1.56722188e-01f, -1.25159755e-01f, -2.02063099e-02f, 5.39549440e-02f,
  -1.08896993e-01f, 1.72285095e-01f, 2.48927414e-01f, -1.93606559e-02f, -2.48946864e-02f, -8.96929502e-02f, 4.01236080e-02f, 4.74418253e-02f, -1.24302022e-02f, 7.92883113e-02f,
  6.80054054e-02f, -1.15637667e-01f, 8.64129737e-02f, 1.93288952e-01f, 6.57261303e-03f, 1.03000730e-01f, 2.65674472e-01f, 1.32619902e-01f, -5.22495527e-03f, 7.55283311e-02f,
  4.45247442e-02f, 7.48162866e-02f, -9.60781053e-02f, -9.56739560e-02f, -8.47724639e-03f, 5.43633923e-02f, -3.89852049e-03f, 1.00519173e-01f, -8.78251716e-02f, 3.79081294e-02f,
  6.94206432e-02f, 9.94298011e-02f, -1.22905560e-01f, -1.48473173e-01f, 6.94843531e-02f, -2.01575503e-01f, -5.97145967e-03f, 9.63446200e-02f, 1.02484912e-01f, -1.24024928e-01f,
  -1.05203435e-01f, -3.37706171e-02f, 1.46068418e-02f, -9.48666558e-02f, 7.09305704e-02f, -7.50645995e-02f, -9.68651399e-02f, -2.74276771e-02f, -5.26036099e-02f, 3.29038762e-02f,
  1.44121781e-01f, -1.27682120e-01f, 7.08717406e-02f, 1.32518366e-01f, 1.28628567e-01f, -2.10456863e-01f, 5.89864850e-02f, -6.32089078e-02f, -4.93259691e-02f, -7.49279559e-02f,
  -1.87331781e-01f, 2.99121365e-02f, -1.56087326e-02f, 1.07807636e-01f, 1.40677616e-01f, -2.06771776e-01f, 2.97182016e-02f, -1.01356185e-03f, -1.59018070e-01f, -7.78938606e-02f,
  1.82287306e-01f, 6.57174513e-02f, 9.45409760e-02f, -2.01121405e-01f, -2.81857401e-01f, 2.40810364e-01f, -1.07476220e-01f, 4.34971564e-02f, -2.12244485e-02f, -1.64429814e-01f,
  -3.17881584e-01f, 3.20315594e-03f, 4.28877361e-02f, 3.61808464e-02f, 4.61906306e-02f, 1.17586680e-01f, 5.38644269e-02f, 4.07190695e-02f, 1.02931924e-01f, 2.73861922e-03f,
  -1.06034853e-01f, -9.23071895e-03f, 1.29967943e-01f, -1.49695659e-02f, -1.02353901e-01f, -5.40027358e-02f, -8.65092427e-02f, -6.02581762e-02f, 1.92963243e-01f, 2.98951399e-02f,
  -1.07680194e-01f, -8.29889998e-02f, 1.20275229e-01f, 6.19996786e-02f, -9.01857838e-02f, -8.67062882e-02f, -6.86604343e-03f, 9.75636542e-02f, 2.22307928e-02f, 2.25671530e-01f,
  -1.69666156e-01f, -6.82842135e-02f, -8.91454965e-02f, -1.55063599e-01f, -6.26544654e-02f, -1.79730386e-01f, 1.36845723e-01f, 7.48027340e-02f, 3.99943031e-02f, -1.03804700e-01f,
  -1.76873446e-01f, -8.10295716e-02f, -5.37928529e-02f, -3.31369340e-01f, 1.49344817e-01f, 2.49157578e-01f, -4.81103323e-02f, 2.19050452e-01f, 1.41977489e-01f, -8.64431635e-02f,
  -7.10903853e-02f, 1.38961121e-01f, 1.89728484e-01f, -2.65258756e-02f, 1.02816224e-01f, -1.08248375e-01f, -1.53026789e-01f, -1.17071807e-01f, 2.28102326e-01f, -1.57694429e-01f,
  1.10906802e-01f, -6.60031885e-02f, 1.14687316e-01f, 3.26308236e-02f, 6.61397055e-02f, -7.81237707e-02f, 5.66876978e-02f, -9.10097882e-02f, -1.05729867e-02f, -2.92576733e-03f,
  1.25984550e-01f, -2.94636693e-02f, -8.26656669e-02f, 1.14478886e-01f, 1.41574573e-02f, 1.52981222e-01f, 1.41048804e-01f, 6.35426864e-02f, 1.25766993e-01f, 6.02081120e-02f,
  5.22514321e-02f, -8.54134187e-02f, 4.35824245e-02f, -1.33893639e-01f, 1.11735336e-01f, -4.39340621e-02f, 1.22854680e-01f, 1.04019344e-01f, 4.38264273e-02f, 1.01507865e-01f,
  9.65206102e-02f, 1.03036501e-01f, -7.86753222e-02f, 1.85743153e-01f, -1.60448477e-01f, 2.14755279e-03f, -1.50789525e-02f, -5.00301942e-02f, 4.43023033e-02f, -2.50585467e-01f,
  3.46720926e-02f, 1.76283941e-01f, 1.89607248e-01f, 9.39728692e-04f, -8.74885321e-02f, 1.60079859e-02f, 3.68704759e-02f, -2.13178232e-01f, 7.25650787e-02f, 3.34453851e-01f,
  -1.59615036e-02f, 1.96151081e-02f, 1.12778842e-01f, -1.50612751e-02f, -1.16380200e-01f, 1.89371645e-01f, 9.55610499e-02f, -6.26268163e-02f, -4.48157005e-02f, -2.35213026e-01f,
  -1.50778398e-01f, -8.95299539e-02f, -2.63880622e-02f, -6.33338541e-02f, 8.00000131e-02f, -1.30299762e-01f, 7.92765319e-02f, 1.42286438e-02f, -3.16782519e-02f, -1.32904551e-03f,
  -1.13821082e-01f, -1.52103633e-01f, 1.56471301e-02f, 2.32309271e-02f, 5.86069003e-02f, -9.94824544e-02f, 3.16679268e-03f, -8.97856280e-02f, 2.90083960e-02f, 2.82812882e-02f,
  -7.55646229e-02f, -9.27033797e-02f, -5.94623834e-02f, -3.13424878e-02f, 6.17269687e-02f, 8.92043933e-02f, 1.52953193e-01f, 1.39582485e-01f, 1.34494692e-01f, 5.36344126e-02f,
  1.10084809e-01f, -1.24296159e-01f, 5.57782128e-03f, 1.54292062e-01f, -8.30989107e-02f, 6.22298978e-02f, -8.05638134e-02f, 4.09402885e-02f, 1.16324529e-01f, -1.46180198e-01f,
  7.79028237e-02f, -1.70802861e-01f, -1.11975290e-01f, 1.76774412e-01f, -8.74815788e-03f, -3.13714743e-01f, -7.96903223e-02f, 1.06679872e-01f, -1.92429602e-01f, 9.87205952e-02f,
  -4.89661992e-02f, 2.08829060e-01f, -1.22810779e-02f, 3.18670459e-02f, 2.92745065e-02f, -7.66278207e-02f, 3.34176049e-03f, -1.91691834e-02f, 1.91594303e-01f, -2.06190303e-01f,
  2.33998328e-01f, -2.06679944e-02f, 5.36362501e-03f, 9.50727146e-03f, -4.38217372e-02f, 1.41338214e-01f, 1.76772445e-01f, -8.60348716e-03f, -9.18798596e-02f, 1.15133218e-01f,
  -9.11817104e-02f, 1.78540319e-01f, 3.25605392e-01f, -9.99683067e-02f, 1.74142476e-02f, -1.44711077e-01f, 1.30186900e-01f, 1.12933517e-01f, 5.54567203e-02f, 1.17550232e-01f,
  9.77087617e-02f, 3.08872852e-02f, 9.78615042e-03f, -8.84985030e-02f, 1.16117902e-01f, 1.02392845e-01f, 8.34985375e-02f, 5.00788316e-02f, 1.32380828e-01f, 5.50831296e-02f,
  -1.03786997e-01f, 7.53898174e-02f, 3.77690941e-02f, 5.27143218e-02f, -1.66843295e-01f, -4.83706482e-02f, 1.14262708e-01f, 3.21566798e-02f, 1.38025671e-01f, -1.81994569e-02f,
  9.26135704e-02f, -5.91929480e-02f, 3.65693606e-02f, -4.87469546e-02f, -8.56423303e-02f, 6.62533045e-02f, 1.08210802e-01f, -5.56596592e-02f, -1.40093699e-01f, 1.07668296e-01f,
  -4.01948765e-02f, -2.47290149e-01f, 2.15000466e-01f, -8.26030821e-02f, 1.69662967e-01f, -9.61994678e-02f, -1.55043289e-01f, 1.58127472e-01f, 2.02497363e-01f, -8.15582648e-02f,
  9.65904072e-02f, 1.40793964e-01f, -2.20118552e-01f, 9.50213447e-02f, -2.97999710e-01f, 2.44264454e-02f, 2.23597395e-03f, 1.24442205e-01f, 1.18617378e-01f, -2.05669016e-01f,
  -1.10103428e-01f, 9.68640968e-02f, 8.78039524e-02f, 2.15594061e-02f, -1.97731405e-02f, -4.63333130e-02f, -4.88085374e-02f, -3.26010324e-02f, -1.70571476e-01f, -5.42915836e-02f,
  1.37970522e-01f, 5.85835539e-02f, 3.35925855e-02f, -5.72964251e-02f, -1.80457477e-02f, 4.57051881e-02f, 2.17501268e-01f, -6.93526715e-02f, -1.42702371e-01f, 5.41206561e-02f,
  1.35754585e-01f, 1.34130061e-01f, 1.13364726e-01f, 1.22217298e-01f, 2.84847673e-02f, -1.12762414e-01f, 1.69895947e-01f, 1.53744847e-01f, 6.81535900e-02f, 9.81926769e-02f,
  1.26566544e-01f, 1.03569284e-01f, -1.64264683e-02f, 3.43587697e-02f, 1.38935342e-01f, -8.13340992e-02f, 1.54363483e-01f, 1.58065602e-01f, 4.94602881e-02f, -4.47646044e-02f,
  2.01561898e-02f, 8.25312510e-02f, -1.55689254e-01f, 2.98306160e-02f, 5.50813042e-02f, 9.30238515e-02f, 4.74793576e-02f, -7.96800256e-02f, -9.72823985e-03f, 2.62713820e-01f,
  -1.88658744e-01f, -2.86598671e-02f, -1.08501352e-01f, -8.77839252e-02f, -1.10932894e-01f, -2.15070564e-02f, -1.19391553e-01f, -1.18319198e-01f, -3.61551233e-02f, -7.83807486e-02f,
  9.27413329e-02f, 1.27039969e-01f, -3.25750709e-02f, -8.00612420e-02f, -7.33999312e-02f, 1.51686311e-01f, -1.57423258e-01f, -3.05787325e-02f, 7.87585303e-02f, 2.74829622e-02f,
  -1.09018177e-01f, 1.00304045e-01f, 4.05359007e-02f, -9.76308137e-02f, 4.04457971e-02f, -7.08582401e-02f, 6.72836527e-02f, -2.68454142e-02f, -1.08280964e-01f, -3.78671661e-03f,
  1.13426745e-01f, -4.99136113e-02f, -1.13179214e-01f, 1.56040505e-01f, -1.46834748e-02f, -5.40701440e-03f, 1.19139552e-01f, 8.27918053e-02f, 9.10219774e-02f, -1.35676771e-01f,
  2.85900906e-02f, 7.45073780e-02f, 1.27183199e-01f, -4.89231795e-02f, 1.65490480e-03f, 8.90795216e-02f, 1.17984377e-01f, 3.71116810e-02f, 2.33971402e-02f, 2.89041132e-01f,
  -1.39916167e-01f, 1.28350472e-02f, -7.39901140e-02f, -4.54744929e-03f, 3.59027758e-02f, -3.13817650e-01f, -2.78839655e-02f, 5.36260903e-02f, 9.86684933e-02f, -1.58117563e-02f,
  -1.95655264e-02f, -1.45679146e-01f, 1.15096904e-01f, -3.49229991e-01f, -1.06421702e-01f, 3.33105773e-01f, -1.09823048e-01f, 5.59567958e-02f, 1.23593114e-01f, 3.99670703e-03f,
  -2.70523369e-01f, 1.32815875e-02f, -3.71754868e-03f, -6.96441606e-02f, -4.09895256e-02f, -1.14237107e-01f, 1.49778910e-02f, -1.62022159e-01f, 8.33956227e-02f, -7.64140300e-03f,
  1.07382573e-01f, -2.33320035e-02f, -1.15421988e-01f, -4.08821367e-02f, -1.37295470e-01f, -3.16647403e-02f, -4.51611541e-02f, -1.80913121e-01f, -3.24461833e-02f, -1.25418440e-01f,
  -5.12909517e-02f, 5.01627848e-02f, 2.23139059e-02f, -1.16825141e-02f, -4.80738357e-02f, -1.19832642e-01f, 8.37293118e-02f, -1.68122575e-01f, -3.62330638e-02f, -5.01304567e-02f,
  -1.41225606e-02f, 4.11807112e-02f, -2.06665576e-01f, 2.29615256e-01f, -1.10171087e-01f, -1.00967124e-01f, -3.85659039e-02f, -8.55845511e-02f, 1.67010743e-02f, -1.68694690e-01f,
  -5.02694994e-02f, 3.62812839e-02f, -1.30939528e-01f, -2.47670308e-01f, 2.01330222e-02f, -2.49395203e-02f, 1.75708294e-01f, -2.03837469e-01f, -2.07063451e-01f, 2.15957478e-01f,
  -1.23275980e-01f, -1.15577981e-01f, -1.01124667e-01f, 1.70491874e-01f, -3.86635475e-02f, 1.66991010e-01f, 8.96864235e-02f, 9.96734649e-02f, 1.41984761e-01f, -5.52382879e-02f,
  4.92923968e-02f, 9.04091969e-02f, -1.67479992e-01f, 1.06819600e-01f, 2.03151554e-01f, 1.27953961e-02f, 9.39190388e-02f, -1.01768732e-01f, 2.00838391e-02f, 1.02841273e-01f,
  2.97642518e-02f, 2.27458552e-01f, 1.01786703e-01f, 3.37148979e-02f, -6.18896857e-02f, 2.21214220e-01f, 3.87623385e-02f, 6.89660013e-02f, 2.86458731e-01f, -3.32845375e-02f,
  1.35653704e-01f, -3.16370949e-02f, 1.39932364e-01f, -1.17642783e-01f, -6.25790879e-02f, 1.20141238e-01f, 1.47532010e-02f, 4.39409874e-02f, -3.40641141e-02f, -1.91613153e-01f,
  -7.72802606e-02f, -3.55050862e-02f, 9.85334045e-04f, 4.28269133e-02f, 5.78534193e-02f, 1.04186013e-01f, -1.31962493e-01f, -2.16596812e-01f, -1.15991123e-01f, -8.47716406e-02f,
  2.34759529e-03f, 3.82119939e-02f, -1.09803520e-01f, -3.66021097e-02f, 1.25424312e-02f, -1.51257798e-01f, -1.47677083e-02f, 2.23303631e-01f, 2.79355068e-02f, 7.79061690e-02f,
  -1.48089901e-01f, 9.46514755e-02f, -2.43139137e-02f, -1.95072442e-01f, -1.17425621e-01f, 1.25119507e-01f, 1.11073680e-01f, -8.17020983e-02f, -3.77527401e-02f, -1.61148682e-01f,
  2.95030534e-01f, -1.73050702e-01f, -1.00589670e-01f, 2.36200273e-01f, -9.11084488e-02f, 8.79470482e-02f, 6.30489141e-02f, -4.82599251e-02f, -1.49852231e-01f, 1.96181133e-01f,
  -6.54208139e-02f, 7.55564868e-02f, -2.14190651e-02f, -1.08873889e-01f, 1.46582410e-01f, -9.21015814e-02f, -1.81577429e-01f, 9.83821899e-02f, -7.25368708e-02f, -5.25209941e-02f,
  1.03341930e-01f, 6.91888630e-02f, -3.42002064e-01f, -5.32270931e-02f, -1.27134681e-01f, 4.70533688e-03f, -5.73403910e-02f, 6.69606552e-02f, 1.11568362e-01f, 1.06238686e-01f,
  1.62162492e-03f, 1.27210021e-01f, 1.00257494e-01f, 2.52886023e-02f, 7.40960762e-02f, 7.61032701e-02f, 8.14915746e-02f, 3.72413062e-02f, 8.81689694e-03f, 1.24249317e-01f,
  1.61146030e-01f, -1.07295081e-01f, -3.02246343e-02f, -7.28203356e-02f, 2.18815610e-01f, 3.05976644e-02f, -7.73923588e-04f, -9.08523351e-02f, 1.25561997e-01f, 8.41642078e-03f,
  -9.97728258e-02f, 2.22747847e-01f, 8.84448737e-02f, 1.04471080e-01f, -2.00536475e-01f, 1.28251955e-01f, 1.04649238e-01f, -1.73474982e-01f, 1.14224702e-01f, 1.26507152e-02f,
  1.65174063e-02f, -8.62069521e-03f, -1.23573869e-01f, 2.24058749e-03f, -4.85663265e-02f, -1.22272093e-02f, -9.27880034e-02f, 2.34280929e-01f, -1.93065628e-01f, -3.57843712e-02f,
  1.64843470e-01f, -1.21408142e-01f, 3.33265513e-02f, 4.05453667e-02f, 1.05701372e-01f, -1.39711872e-01f, 1.70792088e-01f, -1.53123066e-01f, 9.35939327e-02f, -1.68805104e-02f,
  -1.70989409e-01f, 1.90114632e-01f, -1.53918147e-01f, -1.12899698e-01f, 3.90995323e-04f, -9.26034898e-02f, -2.12162331e-01f, 7.57443905e-02f, -1.39749947e-03f, -3.76477242e-02f,
  4.35310155e-02f, -1.60479754e-01f, 2.18431279e-02f, -1.30862504e-01f, -6.45997897e-02f, -8.85156840e-02f, 9.46454555e-02f, 4.24123593e-02f, -7.60067925e-02f, -9.76908132e-02f,
  -6.15999065e-02f, 2.09048428e-02f, -1.54492278e-02f, -8.38376954e-02f, 9.95578319e-02f, -7.17031434e-02f, -9.65607837e-02f, -1.20706514e-01f, 6.59421980e-02f, -1.64253339e-01f,
  -1.26511738e-01f, -2.96409265e-03f, -1.74170434e-01f, 3.95620242e-02f, -1.79815199e-02f, -2.16550872e-01f, -7.36901239e-02f, -4.64902148e-02f, 5.48831560e-02f, -5.70056923e-02f,
  -1.43361669e-02f, 3.83505039e-02f, 2.62146071e-02f, -3.03062826e-01f, -1.64614126e-01f, 7.07507432e-02f, -1.44927222e-02f, 1.07674785e-01f, -2.53915936e-02f, 2.64358431e-01f,
  9.48014110e-03f, -2.42647186e-01f, -6.15671314e-02f, 1.15976021e-01f, -7.51990378e-02f, -4.98060547e-02f, 1.63471863e-01f, 2.62198411e-02f, 1.85966447e-01f, -3.21483612e-02f,
  3.26141976e-02f, -2.24066731e-02f, -2.97690276e-02f, 2.00420260e-01f, 1.02661267e-01f, 9.37768891e-02f, -1.00063257e-01f, 2.18814276e-02f, 1.13394327e-01f, -1.00535518e-02f,
  3.76454853e-02f, -8.39438885e-02f, 1.07039325e-01f, -6.47299886e-02f, -2.07490131e-01f, 9.89119187e-02f, -7.76780173e-02f, -8.68443772e-02f, 3.90125439e-02f, -1.43244177e-01f,
  -3.81929837e-02f, 4.87257466e-02f, 1.94835395e-01f, -3.89307216e-02f, -1.39494270e-01f, -8.95963758e-02f, -1.41662255e-01f, -2.58561671e-01f, -9.88010392e-02f, 1.04504414e-01f,
  -1.17161594e-01f, -1.28942430e-01f, -1.11979157e-01f, 1.56489730e-01f, 3.77842933e-02f, -4.89822775e-02f, 6.05549105e-02f, 2.78206170e-02f, -1.42605141e-01f, 1.42322518e-02f,
  -8.84277672e-02f, -3.97225283e-02f, 1.61874101e-01f, -1.51595756e-01f, -1.60643578e-01f, 6.74563348e-02f, 1.02188610e-01f, 1.62379771e-01f, 7.32936114e-02f, -5.32511098e-04f,
  -1.91160738e-01f, 1.81243196e-01f, 2.32864656e-02f, -2.62002140e-01f, 2.60173559e-01f, 1.67696383e-02f, -5.04737198e-02f, -4.16262029e-03f, 6.56142831e-02f, 2.31849682e-02f,
  -1.97744444e-02f, -1.31513566e-01f, -8.58978704e-02f, -5.27382009e-02f, -7.92723075e-02f, -1.49633348e-01f, -3.43480073e-02f, -1.06363043e-01f, 1.92856327e-01f, -1.65896431e-01f,
  1.28897250e-01f, 9.80166495e-02f, -1.09670073e-01f, 1.27334952e-01f, 2.78365612e-01f, -1.70128807e-01f, -7.87168182e-03f, -2.81936824e-02f, -3.39890160e-02f, 9.53278616e-02f,
  -8.99944752e-02f, -1.14843743e-02f, 6.99706674e-02f, -4.05272283e-02f, 3.91248912e-02f, 1.22033924e-01f, 8.56806412e-02f, 7.82354251e-02f, -4.64976057e-02f, 6.66779801e-02f,
  8.92674252e-02f, -4.03289236e-02f, 4.35392521e-02f, -2.08416283e-02f, 6.98456466e-02f, 9.59859490e-02f, 1.50291786e-01f, -1.48419347e-02f, 1.00972176e-01f, -5.06704263e-02f,
  2.15268079e-02f, 1.15987435e-01f, -2.96584498e-02f, 1.93546623e-01f, -9.76635590e-02f, -6.81326017e-02f, -6.98706284e-02f, -1.62050769e-01f, 7.26671442e-02f, -2.37990487e-02f,
  -4.56267186e-02f, -2.70216111e-02f, 8.30938444e-02f, 1.67935088e-01f, -7.83002228e-02f, -1.31019592e-01f, -6.16121739e-02f, -1.16260089e-01f, -1.40537500e-01f, 1.92260772e-01f,
  -1.82173550e-01f, 8.99797752e-02f, -1.00292936e-02f, -2.12780297e-01f, -1.30259590e-02f, 9.07284096e-02f, -3.76143716e-02f, -3.89171951e-02f, 1.37865305e-01f, -2.57667638e-02f,
  5.46520948e-02f, 3.13665941e-02f, 1.02179378e-01f, 5.55693954e-02f, -9.13478658e-02f, -2.39455402e-01f, -1.15567081e-01f, 7.69882044e-03f, 7.61092035e-03f, 3.98966931e-02f,
  -3.44888382e-02f, -4.67806533e-02f, 2.94388413e-01f, -3.89247797e-02f, 1.73432961e-01f, 1.25768557e-01f, -2.75125410e-02f, 1.48185059e-01f, 2.78959513e-01f, 3.78199667e-02f,
  -3.78809907e-02f, -8.69323760e-02f, 4.91750874e-02f, 1.62340969e-01f, 2.76121739e-02f, 2.39006862e-01f, 1.42208025e-01f, -2.34481674e-02f, 1.17198601e-01f, -1.06354058e-02f,
  1.35765925e-01f, 1.55007392e-01f, -5.06773107e-02f, 6.65682331e-02f, 2.01504737e-01f, 1.42890021e-01f, -3.78956599e-03f, 7.10043907e-02f, 6.72366545e-02f, 1.14890806e-01f,
  -1.31724089e-01f, -6.10869788e-02f, -4.20287363e-02f, -2.07933426e-01f, -1.21524706e-01f, -1.25939483e-02f, -6.22679107e-02f, 1.08229898e-01f, -4.83587198e-02f, -2.50718355e-01f,
  1.66333929e-01f, 6.28292412e-02f, -9.48570967e-02f, 2.63547927e-01f, -1.43372670e-01f, -8.92395228e-02f, 1.14287153e-01f, -2.13453501e-01f, -2.21137628e-01f, -2.89472216e-03f,
  1.77121833e-01f, -1.70875469e-03f, -2.51920633e-02f, 6.41367119e-03f, -6.41080886e-02f, -6.25989512e-02f, -8.90682936e-02f, 6.22585788e-02f, -8.11299607e-02f, -1.66758388e-01f,
  -4.55726264e-03f, -1.06103316e-01f, -2.42712364e-01f, -7.90859833e-02f, -2.63940450e-02f, -9.74289253e-02f, 1.61776409e-01f, -4.74738069e-02f, -1.12998836e-01f, -3.12602781e-02f,
  5.40349633e-02f, 3.20948404e-03f, 1.87423453e-01f, 8.76607671e-02f, 3.82670946e-02f, 5.13659865e-02f, 2.75216568e-02f, 6.37534112e-02f, -1.35913178e-01f, -3.15355249e-02f,
  3.79361934e-03f, -2.95712128e-02f, -6.93200603e-02f, 8.27247426e-02f, 2.12231070e-01f, 2.70025954e-02f, -1.53722584e-01f, 1.53140604e-01f, -3.40834558e-02f, -3.77763668e-03f,
  -9.80773196e-02f, -4.22004089e-02f, -1.06886305e-01f, -1.05766580e-01f, -2.72953473e-02f, -1.37746587e-01f, -7.80610889e-02f, -5.18397987e-02f, 2.31111243e-01f, -1.28113255e-01f,
  5.91156706e-02f, 6.32861182e-02f, -3.05568930e-02f, -1.08505808e-01f, -1.68797553e-01f, -2.09879577e-01f, 1.27684167e-02f, 1.65772647e-01f, -9.19324979e-02f, 2.53524572e-01f,
  -6.94164857e-02f, -2.32180297e-01f, -8.60402137e-02f, 1.03341565e-02f, 2.90790349e-01f, -2.08003029e-01f, -6.23950325e-02f, -8.80695730e-02f, -6.65070117e-02f, 1.42624289e-01f,
  6.77921399e-02f, 8.29138979e-02f, -2.98948791e-02f, -2.34724477e-01f, 3.53683755e-02f, -1.21679343e-01f, -7.15328520e-03f, -8.52541253e-02f, 2.15615425e-02f, -9.66724530e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  3.21611539e-02f, 1.52315691e-01f, -1.23983599e-01f, -1.03726067e-01f, 9.95615795e-02f, 4.73739877e-02f, -6.75576106e-02f, -3.03082392e-02f, -2.46468280e-02f, -8.30096155e-02f,
  5.52546643e-02f, -3.69307362e-02f, 3.94087695e-02f, -1.84737474e-01f, 8.94664079e-02f, 8.89126509e-02f, 6.03253022e-02f, 2.24969257e-02f, 1.58748124e-02f, 7.08358958e-02f,
  9.23891924e-03f, 2.04812959e-02f, 3.42491493e-02f, -3.98562327e-02f, -2.57314052e-02f, 1.09307123e-02f, 6.50276765e-02f, -6.67981654e-02f, 1.10002898e-01f, -1.00944050e-01f,
  4.05040085e-02f, -7.58902431e-02f, 1.73993528e-01f, 5.80437817e-02f, 1.51933163e-01f, 2.77709588e-02f, -7.40913674e-02f, 1.96453314e-02f, -1.45693943e-01f, -2.41289347e-01f,
  -5.24711832e-02f, 1.25379726e-01f, -2.48127691e-02f, 2.04682186e-01f, 9.87997279e-02f, -1.01735108e-01f, 5.15224785e-02f, 7.13227838e-02f, 1.32228240e-01f, -9.36724152e-03f,
  7.57689849e-02f, -3.58191095e-02f, -7.71244764e-02f, -7.56002888e-02f, -3.59993316e-02f, 2.11052280e-02f, -8.15800875e-02f, 5.92058301e-02f, -9.78283118e-03f, 4.00063843e-02f,
  1.78629771e-01f, -1.88987300e-01f, 1.25481844e-01f, 7.99169317e-02f, -4.64075990e-02f, -6.42641410e-02f, 1.20289207e-01f, 1.19887710e-01f, 8.19051564e-02f, 1.27744094e-01f,
  1.03955977e-01f, 1.49160281e-01f, -2.87858769e-02f, 1.85023710e-01f, -8.87047052e-02f, -1.04404181e-01f, 7.60598248e-03f, 1.18555995e-02f, -2.06477791e-02f, 1.13660423e-02f,
  -4.30404767e-02f, 4.36055213e-02f, 9.11210552e-02f, -5.66154644e-02f, 1.30789518e-01f, -1.90222431e-02f, 1.08169742e-01f, -8.11561793e-02f, 8.39032978e-02f, -3.17191035e-02f,
  -1.30848572e-01f, 1.82947777e-02f, 2.33622044e-02f, 1.58649534e-01f, 1.13902383e-01f, -7.49399066e-02f, -1.66681573e-01f, 1.57138556e-01f, 6.44640103e-02f, -1.37294725e-01f,
  3.92509252e-02f, -6.84609413e-02f, -2.75443010e-02f, -2.08057240e-01f, 3.13215107e-02f, 8.83547664e-02f, 7.72855133e-02f, -7.06793070e-02f, 1.59207612e-01f, -9.22131836e-02f,
  -3.12416367e-02f, 6.14184625e-02f, -1.47286654e-01f, -7.57994503e-02f, -1.10876992e-01f, 2.10548509e-02f, 7.84282982e-02f, -9.43315253e-02f, 1.31380811e-01f, -2.10663187e-03f,
  -6.56140456e-03f, 4.63160239e-02f, 2.35088002e-02f, -4.70256433e-02f, -9.34598818e-02f, -5.42189255e-02f, -5.17026596e-02f, 7.45733753e-02f, 1.07403465e-01f, -2.01505870e-02f,
  1.89189792e-01f, 1.41171366e-01f, 5.51724248e-03f, 1.77541032e-01f, 1.97548509e-01f, -9.31407418e-03f, -1.26755387e-01f, 1.61263179e-02f, -1.30025104e-01f, 1.19703792e-01f,
  2.09623337e-01f, 1.91719696e-01f, 1.73053399e-01f, 4.00674939e-02f, -1.91617102e-04f, 1.11754900e-02f, 2.28335306e-01f, -1.00109503e-01f, -9.02633741e-02f, -5.50969206e-02f,
  -1.78969100e-01f, 7.37265348e-02f, 1.71931967e-01f, 1.29039422e-01f, 1.75903961e-01f, 1.72268227e-02f, 2.29505803e-02f, -1.80587620e-01f, -3.59507129e-02f, 7.75043666e-02f,
  -5.05816750e-02f, -4.02899981e-01f, 2.96022128e-02f, 3.19580823e-01f, 3.81673388e-02f, -5.06590344e-02f, 7.67062977e-02f, 2.34483808e-01f, 4.94987983e-03f, -1.68969303e-01f,
  -2.08712488e-01f, 1.26205653e-01f, -7.39943162e-02f, -1.81009859e-01f, 5.93296774e-02f, -1.53855696e-01f, 2.91426748e-01f, -1.93542361e-01f, 3.13785253e-03f, 6.71710148e-02f,
  1.45950750e-01f, 2.52677023e-01f, 5.77780530e-02f, 1.09586976e-01f, -1.14276610e-01f, -2.04430390e-02f, 4.52880375e-02f, -5.06869853e-02f, 7.21645430e-02f, 1.66479647e-01f,
  1.65478870e-01f, -1.32609680e-01f, -1.01795800e-01f, 1.35267302e-01f, -1.15831636e-01f, -1.19793221e-01f, 6.58023059e-02f, 9.90852267e-02f, 7.74256745e-03f, 1.14842549e-01f,
  -5.22081479e-02f, 3.70914973e-02f, 3.74096744e-02f, -7.00672939e-02f, -6.39043823e-02f, -7.11358935e-02f, 5.26090302e-02f, 3.44883054e-02f, -6.30933270e-02f, 5.56784756e-02f,
  -9.55895483e-02f, -8.05675536e-02f, -1.83646623e-02f, -6.19236566e-02f, -1.17632926e-01f, -9.54510178e-03f, -1.17631339e-01f, -8.12104642e-02f, 1.53874438e-02f, -7.26170167e-02f,
  9.12478790e-02f, 6.59812391e-02f, -9.47216228e-02f, 2.63633337e-02f, 9.51589942e-02f, -4.45966162e-02f, 4.23959866e-02f, -5.08146174e-02f, -9.71163437e-03f, 9.10755768e-02f,
  5.89451753e-02f, 2.36798115e-02f, 9.02487859e-02f, 9.40001309e-02f, 4.57841195e-02f, -1.36878714e-01f, -3.94316986e-02f, 3.84153947e-02f, -4.78244014e-02f, 7.27870241e-02f,
  -2.94496492e-02f, 9.76749957e-02f, -5.39254285e-02f, -3.31986062e-02f, 1.74484272e-02f, 6.94241598e-02f, -2.48126243e-03f, 6.72175586e-02f, 5.73177598e-02f, 3.22425477e-02f,
  -7.60771707e-02f, -3.74254175e-02f, 8.46238211e-02f, 1.01911239e-01f, 8.35569575e-02f, -9.14465263e-02f, -4.03713360e-02f, 3.25072967e-02f, -4.50459309e-02f, -4.84008603e-02f,
  -2.29838919e-02f, -1.96994804e-02f, 8.44965354e-02f, -4.28854153e-02f, -4.56649475e-02f, 1.12830564e-01f, 1.49553837e-02f, -9.23633575e-02f, 6.07767254e-02f, -3.34222987e-02f,
  1.37025248e-02f, 1.53749779e-01f, 8.72397870e-02f, -8.72533023e-03f, 1.10105053e-01f, 3.03796139e-02f, -1.19269509e-02f, 4.79746573e-02f, 1.11489765e-01f, 4.24426198e-02f,
  8.96574929e-03f, 9.19951126e-02f, -3.31654847e-02f, 5.17693050e-02f, -9.39094578e-04f, -8.15732703e-02f, -1.07186730e-04f, -8.69852751e-02f, 4.61251885e-02f, 6.14561401e-02f,
  9.95661020e-02f, -5.26218954e-03f, -2.09247187e-01f, 1.45235166e-01f, -1.52680233e-01f, -2.43640468e-01f, 5.48189767e-02f, -2.31872480e-02f, 2.29634368e-03f, 8.63529071e-02f,
  -2.90952176e-02f, -4.31526639e-02f, -1.31263822e-01f, 1.07502021e-01f, 1.80228129e-01f, -1.28451943e-01f, -1.36156142e-01f, -5.02710184e-03f, -9.58281457e-02f, 9.21397433e-02f,
  2.69238204e-01f, -2.28090566e-02f, -6.74360618e-02f, 4.96768095e-02f, -6.87247515e-03f, 9.28969830e-02f, 2.13734090e-01f, 2.91679893e-02f, -3.04096807e-02f, -5.99985383e-02f,
  6.35821745e-02f, 1.65655151e-01f, 4.53850590e-02f, 1.35444179e-01f, -6.83650300e-02f, 1.82790324e-01f, 5.71748316e-02f, 2.97351237e-02f, -7.10526630e-02f, 1.15250655e-01f,
  -1.11877453e-03f, 2.38936525e-02f, 1.54890671e-01f, 2.20103487e-01f, 9.35022533e-02f, -1.22042648e-01f, 1.79404408e-01f, 1.67192984e-02f, -1.20878434e-02f, -2.80382968e-02f,
  1.98546782e-01f, -7.55987614e-02f, 1.02228276e-01f, -4.46517542e-02f, 2.06407066e-02f, -5.68431094e-02f, 1.20558545e-01f, -5.11321872e-02f, -1.86071321e-02f, 2.62770474e-01f,
  9.17592049e-02f, -5.34706982e-03f, -9.63619724e-02f, 2.12671965e-01f, -1.09685585e-01f, -1.97462425e-01f, 2.01825842e-01f, 3.32392715e-02f, 2.46589798e-02f, -5.58859296e-02f,
  -7.81764761e-02f, 1.05830371e-01f, 1.46861121e-01f, -2.06843093e-01f, 3.54244665e-04f, -7.50288367e-02f, -1.49884045e-01f, 2.31597498e-02f, -2.25565001e-01f, 1.43227547e-01f,
  1.21161774e-01f, 1.12262547e-01f, 1.66597217e-01f, -5.48341535e-02f, -4.75608669e-02f, -1.41204065e-02f, 1.43577665e-01f, -4.74989563e-02f, -3.27176824e-02f, 2.25079097e-02f,
  -7.48664439e-02f, 1.21506890e-02f, -8.95475149e-02f, 1.06662080e-01f, 1.01871990e-01f, 4.21498008e-02f, 6.46410882e-02f, 1.63529366e-01f, 1.22105509e-01f, 1.08674936e-01f,
  8.07291549e-03f, 1.08076580e-01f, 4.87081185e-02f, 3.12190149e-02f, 1.02005064e-01f, 5.02278320e-02f, 1.14208192e-01f, -6.93386700e-03f, -7.66494572e-02f, -9.09291115e-03f,
  1.22809894e-01f, 3.55474092e-02f, 6.58532083e-02f, -9.01179463e-02f, 2.12378874e-02f, 6.17206059e-02f, 1.87288336e-02f, 1.45668805e-01f, 1.64881870e-01f, -1.30497664e-01f,
  7.43056983e-02f, -3.33787617e-03f, 1.15960896e-01f, 1.76968038e-01f, 6.01353422e-02f, 1.56584695e-01f, 6.90357238e-02f, 5.06286584e-02f, -1.48573732e-02f, -1.14742786e-01f,
  1.48569494e-01f, 1.95549309e-01f, -1.81487024e-01f, 1.21156596e-01f, -1.21279746e-01f, -9.82762799e-02f, 1.19353645e-01f, -4.77022938e-02f, -1.46072879e-01f, -1.03807393e-02f,
  1.27844661e-01f, -1.27215283e-02f, -2.22396672e-01f, 1.13882110e-01f, 5.59373051e-02f, 8.41433331e-02f, 1.05231784e-01f, -1.02608219e-01f, -3.80774364e-02f, 3.09506446e-01f,
  9.04966437e-04f, -2.95010414e-02f, -3.34863216e-02f, -2.58829277e-02f, 3.07388511e-02f, -1.05115296e-02f, -3.04568671e-02f, 1.06653661e-01f, -1.19315498e-01f, 7.73342475e-02f,
  6.34371862e-02f, 8.88759866e-02f, -2.36557890e-02f, -9.98342484e-02f, -1.36988327e-01f, 2.40732402e-01f, 2.73237586e-01f, 1.02805868e-01f, 2.24925742e-01f, 1.35379449e-01f,
  -9.03533325e-02f, -3.20319653e-01f, -3.69503275e-02f, 1.85109779e-01f, 1.13216966e-01f, 1.26064077e-01f, -4.38211635e-02f, 5.78943826e-02f, 1.22196972e-01f, -8.69853348e-02f,
  -6.93548620e-02f, 1.39928237e-01f, -7.12162703e-02f, -2.25318193e-01f, 9.17899460e-02f, -2.04204202e-01f, 4.10555266e-02f, -1.76904742e-02f, -8.96109566e-02f, 1.38277724e-01f,
  2.77832091e-01f, 2.22648174e-01f, -4.22569066e-02f, -1.33620486e-01f, 6.13429248e-02f, 1.87988132e-01f, -3.50413740e-01f, -5.33102006e-02f, -5.97904846e-02f, -1.95003912e-01f,
  9.60579515e-02f, -8.60478431e-02f, 8.75816345e-02f, 6.31066114e-02f, 1.21808738e-01f, -7.33102188e-02f, 2.30404418e-02f, -2.58934442e-02f, -2.22153850e-02f, 8.90744850e-02f,
  -1.65850058e-01f, -1.79429293e-01f, -1.92074142e-02f, 2.97743618e-01f, 4.96583134e-02f, -1.36064296e-03f, 8.35727528e-02f, 3.20805795e-02f, 2.92328894e-01f, -9.84545648e-02f,
  2.84680296e-02f, 2.84389276e-02f, 7.74382874e-02f, 9.84850228e-02f, -1.07323579e-01f, -1.48896709e-01f, -2.57151984e-02f, -5.26517816e-02f, -2.29164455e-02f, 1.66677654e-01f,
  -7.38316327e-02f, 1.24584183e-01f, 2.09713951e-02f, 1.63252413e-01f, -1.03043668e-01f, -4.25035357e-02f, 1.77121133e-01f, 1.03681616e-01f, 5.55203594e-02f, -2.33560372e-02f,
  1.09846041e-01f, -1.05971312e-02f, 4.83664982e-02f, -2.00607115e-03f, -1.72261432e-01f, 3.31243463e-02f, -2.03989539e-02f, -1.21300705e-01f, -1.03343949e-01f, -1.75134927e-01f,
  1.48463234e-01f, -6.64077699e-02f, -2.39419177e-01f, 1.35518849e-01f, 1.11708961e-01f, 3.64858583e-02f, -1.63141921e-01f, 2.09551170e-01f, -2.55115390e-01f, 1.25859961e-01f,
  -1.30384266e-01f, -1.18174300e-01f, -4.78886515e-02f, 3.23432945e-02f, -9.96854082e-02f, -8.07402954e-02f, -1.92252100e-02f, -6.69886991e-02f, 8.95724222e-02f, -1.42635908e-02f,
  1.60489112e-01f, -1.16033973e-02f, 8.75289589e-02f, 3.14803123e-02f, 2.55014468e-02f, 1.82754859e-01f, 3.17395449e-01f, -1.47262841e-01f, -3.44438553e-02f, 1.39988109e-01f,
  2.92879529e-02f, 5.61536774e-02f, 4.60973889e-01f, 1.67033949e-03f, 7.60511532e-02f, 6.17358722e-02f, 1.36505038e-01f, 1.12968557e-01f, -1.64166652e-02f, 1.49880514e-01f,
  1.27250016e-01f, 1.85644239e-01f, 1.29824907e-01f, 9.55683142e-02f, 7.55047575e-02f, 1.79027870e-01f, 1.63111687e-01f, -3.34069021e-02f, 1.33278430e-01f, 2.22922176e-01f,
  -1.11380793e-01f, -4.10911478e-02f, 8.00063089e-02f, -1.22549934e-02f, -1.59169689e-01f, 1.16186135e-01f, 3.90081038e-03f, 8.28482658e-02f, 2.16326997e-01f, -3.23245861e-02f,
  1.94559470e-01f, 1.89044148e-01f, -7.40749761e-02f, 8.54257122e-02f, -1.42744966e-02f, 2.10107759e-01f, 1.18118808e-01f, -8.05994496e-02f, -1.41560867e-01f, 9.92723033e-02f,
  -6.21673129e-02f, -1.54932320e-01f, 7.80475140e-02f, -4.75220233e-02f, 2.08170563e-02f, -8.22253972e-02f, -5.90923289e-03f, 2.13549063e-01f, 1.46722972e-01f, 5.86438598e-03f,
  1.27568141e-01f, 1.26891106e-01f, -1.47320271e-01f, 6.84486553e-02f, -2.15186521e-01f, -6.30114526e-02f, -1.13861384e-02f, 1.61623329e-01f, 2.18036715e-02f, -7.53926262e-02f,
  1.60918608e-01f, -1.37164429e-01f, 1.58532038e-01f, 8.81287009e-02f, -3.20485905e-02f, -9.08877626e-02f, 8.38861465e-02f, 1.05473801e-01f, 1.96079612e-02f, 1.31490707e-01f,
  1.20221086e-01f, 4.71524931e-02f, 1.50524467e-01f, 1.52160332e-01f, 5.94961159e-02f, 9.03422982e-02f, 1.26037076e-01f, 2.01624438e-01f, 1.21887155e-01f, 1.60052404e-01f,
  1.75208360e-01f, 1.52012110e-01f, -7.94728771e-02f, -1.13392584e-01f, 6.38825148e-02f, -1.40412793e-01f, -4.32443582e-02f, 1.12446457e-01f, 2.11907938e-01f, 1.57128736e-01f,
  2.40622740e-02f, 1.41491979e-01f, -3.16421539e-02f, 1.60013869e-01f, -7.01415539e-02f, 8.89088959e-02f, -9.91678163e-02f, 1.26525462e-01f, -9.31995874e-06f, -1.39559045e-01f,
  3.18179652e-02f, -7.90273678e-03f, 2.68710077e-01f, 1.81530058e-01f, 1.53126881e-01f, -1.39820606e-01f, 1.17398836e-01f, 1.24260806e-01f, -7.59332478e-02f, 4.63379361e-02f,
  -4.22271900e-02f, 2.85484996e-02f, -1.04180269e-01f, -4.99095842e-02f, 7.06034303e-02f, -2.01968208e-01f, 7.21644908e-02f, 1.11723527e-01f, 1.05374709e-01f, 4.01446298e-02f,
  -2.30431072e-02f, -9.53966472e-03f, -8.83743465e-02f, 5.55974105e-03f, -2.25960344e-01f, 4.35883373e-01f, 7.69651607e-02f, -1.46941826e-01f, 8.18247944e-02f, 8.87167081e-02f,
  -5.08631719e-03f, 1.80376023e-02f, -8.34245831e-02f, -1.04556262e-01f, 1.59360319e-02f, -1.17828175e-01f, -6.24020062e-02f, -8.31907019e-02f, 6.15501497e-03f, -7.88793266e-02f,
  -1.51463663e-02f, -1.15816504e-01f, -6.67041838e-02f, 1.28057748e-01f, 4.30208817e-02f, 2.96420343e-02f, 6.96227029e-02f, 2.73593944e-02f, 8.80163312e-02f, 1.19569123e-01f,
  -5.90353385e-02f, 5.45872329e-03f, -7.53499866e-02f, 7.23670647e-02f, -1.63074322e-02f, 1.44426785e-02f, 7.22413138e-02f, -1.18211746e-01f, 1.62158217e-02f, 4.78317700e-02f,
  1.33626368e-02f, -8.96139070e-02f, 1.13922626e-01f, -4.82671196e-03f, 4.50256392e-02f, -1.27748409e-02f, -2.13145614e-02f, 7.06696287e-02f, -7.57763833e-02f, -1.04154222e-01f,
  -1.73983760e-02f, 3.90483253e-02f, 3.81807867e-03f, 1.05581522e-01f, -1.24445774e-01f, 9.89103988e-02f, -1.63002536e-02f, -1.52487919e-01f, -7.13071898e-02f, 6.21058270e-02f,
  -2.45664045e-02f, -4.14269194e-02f, 8.92737135e-02f, -4.12553027e-02f, 6.94009429e-03f, 4.80902474e-03f, 8.36603194e-02f, -7.02086538e-02f, -5.91833424e-03f, 5.25419414e-02f,
  -4.86621335e-02f, -3.56046185e-02f, 5.01738535e-03f, 5.23008928e-02f, -1.17093921e-01f, 1.04632221e-01f, -8.72761235e-02f, -1.02505937e-01f, 5.93006238e-02f, 5.68164438e-02f,
  -1.34462025e-02f, 1.34556100e-01f, 1.26246527e-01f, -6.81094974e-02f, 8.46804008e-02f, 9.91647691e-02f, 1.62241101e-01f, 1.34845376e-01f, 1.24890387e-01f, -3.99325639e-02f,
  -5.13936877e-02f, -1.05623141e-01f, -8.43593758e-03f, 6.15037978e-02f, 5.90549856e-02f, -7.83382729e-02f, -6.87266812e-02f, 1.06086925e-01f, -7.25319907e-02f, -1.45536950e-02f,
  -8.57184604e-02f, -1.19531555e-02f, -3.73030640e-02f, 1.78848561e-02f, -8.14940259e-02f, 2.15908531e-02f, 9.39358845e-02f, 1.20557345e-01f, 1.48355858e-02f, -1.83561887e-03f,
  -7.90233351e-03f, 8.06725845e-02f, 6.04585232e-03f, -1.16334371e-01f, -3.38746905e-02f, -4.33888026e-02f, -5.69538884e-02f, -2.11996377e-01f, 1.31858075e-02f, 1.51470616e-01f,
  -5.22768358e-03f, 3.69478203e-02f, -3.80817764e-02f, 3.11893634e-02f, 1.16844095e-01f, -4.27882038e-02f, -3.79581377e-02f, -2.67344657e-02f, 1.37934433e-02f, -7.87939280e-02f,
  9.92209315e-02f, -4.24388424e-02f, 2.09473759e-01f, -7.60634169e-02f, -7.02613667e-02f, -7.55113512e-02f, -1.11526594e-01f, 8.21195617e-02f, 1.22042984e-01f, -3.10947490e-03f,
  -5.24808280e-02f, 9.89284068e-02f, 2.45041102e-02f, -5.08766100e-02f, -3.37276645e-02f, 5.75365722e-02f, -7.08785057e-02f, -3.27675305e-02f, -1.21377327e-01f, -1.45398895e-03f,
  -3.65787814e-03f, -2.61269067e-03f, 5.19019924e-02f, -6.56882115e-03f, -9.48399901e-02f, 1.27757862e-01f, -7.89837018e-02f, -6.23090565e-03f, -8.71985927e-02f, -7.65622407e-02f,
  -8.37817788e-03f, -9.28491354e-02f, 1.60351396e-02f, -4.48243245e-02f, -1.02610730e-01f, 9.95764583e-02f, -3.97584811e-02f, 1.18803397e-01f, 3.98560725e-02f, 9.44063365e-02f,
  -1.12973541e-01f, 1.54748289e-02f, -1.86335819e-04f, -6.54897243e-02f, -1.14833385e-01f, 5.16731292e-02f, -5.68395965e-02f, -4.67652269e-02f, 1.80939846e-02f, -1.21136487e-01f,
  -5.01185134e-02f, -7.35948905e-02f, -7.15701953e-02f, 1.08427569e-01f, 2.64050756e-02f, -1.28343580e-02f, 1.07970417e-01f, 1.00597911e-01f, 3.45483944e-02f, 4.22724560e-02f,
  -2.22357921e-02f, 4.73463684e-02f, 8.20710659e-02f, 6.08658008e-02f, 1.16218053e-01f, -1.12464681e-01f, -1.24632753e-01f, -6.60743117e-02f, -2.23487224e-02f, -6.63131401e-02f,
  -9.29814279e-02f, 7.99940377e-02f, -1.10105887e-01f, -6.46735951e-02f, -7.54950717e-02f, 9.71708819e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  6.58052117e-02f, 1.06039457e-01f, 1.77848160e-01f, -7.94695094e-02f, 2.16408335e-02f, 1.22825086e-01f, -5.10029793e-02f, 3.55438553e-02f, 1.77083448e-01f, -1.47944596e-02f,
  3.68231758e-02f, -1.88976377e-02f, 3.82268205e-02f, -7.50362268e-03f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  2.14501902e-01f, 3.64733934e-01f, 2.63424665e-01f, 1.60895124e-01f, -6.33740425e-02f, 3.43650803e-02f, -4.18276340e-01f, 1.84831485e-01f, 1.92120001e-01f, 9.30421650e-02f,
  -3.38348836e-01f, 2.07348391e-01f, 2.35341161e-01f, -3.04141253e-01f, 2.55178452e-01f, -1.31439772e-02f, 4.09012139e-01f, -3.18257213e-02f, -2.01799944e-01f, 2.26700887e-01f,
  5.25748432e-02f, 2.16458514e-01f, -4.23456877e-02f, 2.56561071e-01f, 8.71349126e-02f, -2.29468271e-01f, -1.60317764e-01f, -1.81170762e-01f, -3.48608457e-02f, -2.58214593e-01f,
  2.76200294e-01f, -6.57661259e-02f, -1.13043502e-01f, -3.48174065e-01f, 4.03414875e-01f, 1.12858050e-01f, 6.64505363e-02f, -1.79247215e-01f, -1.89295530e-01f, -1.48834169e-01f,
  1.68061227e-01f, -8.38670507e-03f, 3.42046320e-01f, -1.43499061e-01f, -7.73650780e-02f, 2.95660943e-02f, 2.11848065e-01f, 3.14701833e-02f, 4.27162319e-01f, 2.72695608e-02f,
  -9.67864394e-02f, -8.43472555e-02f, 2.48827532e-01f, 4.80607860e-02f, 1.14031658e-01f, -6.92786798e-02f, -3.07736278e-01f, -4.03539121e-01f, 3.51579815e-01f, -1.16165675e-01f,
  -2.70069569e-01f, -3.50036100e-02f, -1.18917458e-01f, 3.36534940e-02f, 2.79103577e-01f, 2.75422573e-01f, -1.52165024e-02f, 1.01488821e-01f, 2.37287432e-01f, -1.71422452e-01f,
  -1.75920516e-01f, -3.72458011e-01f, 1.16438292e-01f, 2.89723575e-01f, 3.89100015e-02f, 2.78635230e-03f, -2.05298066e-02f, 3.19681197e-01f, -8.44239816e-02f, 8.40872247e-03f,
  6.95105270e-03f, 3.03587973e-01f, 4.38113719e-01f, 1.59913331e-01f, -5.98356389e-02f, 2.22319216e-01f, -1.43295303e-01f, 4.13752906e-02f, 1.38754785e-01f, 1.16931023e-02f,
  -7.95492670e-04f, -4.33926374e-01f, 8.33011121e-02f, 2.21856833e-01f, 2.89816260e-01f, -1.59329340e-01f, -1.62309289e-01f, 5.10088086e-01f, -3.45146626e-01f, -4.01690662e-01f,
  3.03569764e-01f, 3.01213205e-01f, 2.86253244e-01f, 2.47194290e-01f, -8.56483579e-02f, 4.56637859e-01f, -3.82401310e-02f, -2.69722313e-01f, 2.09862500e-01f, -2.80426413e-01f,
  7.09805489e-02f, 1.78438053e-01f, 2.53574461e-01f, 1.21385738e-01f, 1.05422977e-02f, 1.74276158e-01f, -1.27298564e-01f, -1.04669882e-02f, 2.17096344e-01f, 4.74890880e-02f,
  -2.08442703e-01f, -2.78939232e-02f, 1.34766623e-01f, 2.45478362e-01f, -2.16272697e-01f, 5.24580739e-02f, 2.29490712e-01f, -1.35151878e-01f, -3.24430346e-01f, 2.62303591e-01f,
  8.84217545e-02f, -4.07425202e-02f, 1.56654492e-01f, 7.61306807e-02f, 5.35999574e-02f, -5.77109531e-02f, -3.70686024e-01f, -3.11029285e-01f, 1.02335438e-01f, -1.52336374e-01f,
  -1.46529421e-01f, 2.35004947e-01f, 2.16404468e-01f, 6.03313074e-02f, -9.72162485e-02f, -1.99145496e-01f, 4.03106272e-01f, -4.03472126e-01f, -4.79601659e-02f, -6.55443594e-02f,
  -1.64679572e-01f, -2.44413689e-01f, -1.09667420e-01f, 4.11670715e-01f, -1.21023975e-01f, -4.50185925e-01f, -7.40316957e-02f, 2.98773289e-01f, 1.49132654e-01f, -2.79590458e-01f,
  -1.74821943e-01f, 8.48452821e-02f, -2.79507309e-01f, 3.14689100e-01f, 3.10106844e-01f, 2.26980418e-01f, -3.59159172e-01f, 1.49948552e-01f, 4.36251648e-02f, 3.82649839e-01f,
  -3.64424884e-01f, 4.95240480e-01f, 2.03891560e-01f, -2.47998074e-01f, -9.47166756e-02f, 1.60333067e-01f, 1.37049988e-01f, 4.31620955e-01f, 1.72955036e-01f, -3.39850001e-02f,
  9.01530907e-02f, -3.74469757e-02f, 6.49534389e-02f, -1.30731642e-01f, -1.01104394e-01f, -2.12401807e-01f, -1.19247533e-01f, 1.19030692e-01f, 3.64415288e-01f, -1.20740995e-01f,
  -7.33458623e-03f, 3.54892239e-02f, -6.17574640e-02f, 7.88474828e-02f, -1.05133578e-01f, -1.65346071e-01f, -1.86569378e-01f, 5.24858721e-02f, -1.53479546e-01f, -1.96469083e-01f,
  -5.20431459e-01f, -1.25294983e-01f, -3.46153319e-01f, 1.33788377e-01f, -1.26998946e-01f, -2.81375404e-02f, -2.62520403e-01f, 2.93463796e-01f, -3.60910803e-01f, -6.17767759e-02f,
  1.47711217e-01f, -6.67056143e-02f, -3.43238503e-01f, -1.46861356e-02f, 3.93126719e-03f, -3.80419135e-01f, 8.85359570e-02f, -2.62280315e-01f, -3.14977884e-01f, 1.15813456e-01f,
  1.85750313e-02f, 6.90013915e-02f, 9.49090868e-02f, -1.03286214e-01f, 3.11119825e-01f, -2.03847930e-01f, -2.47944862e-01f, 1.50263757e-01f, -1.17339343e-01f, -1.70276746e-01f,
  -2.56758779e-01f, -4.19494808e-01f, -2.35472500e-01f, 5.19280396e-02f, -2.09420547e-01f, 2.15603381e-01f, -1.10244773e-01f, 2.55537242e-01f, 4.40314174e-01f, -9.89399180e-02f,
  -2.06494451e-01f, 1.51427016e-01f, 7.57963434e-02f, -1.10286567e-02f, 1.25131160e-01f, 1.80623919e-01f, 1.44912586e-01f, -2.16659442e-01f, -2.04171032e-01f, 1.77705929e-01f,
  4.50372398e-01f, -1.98316485e-01f, -1.01365961e-01f, 5.44044375e-02f, -3.02380621e-02f, 4.38202582e-02f, 2.36224785e-01f, 2.59300381e-01f, -1.10147282e-01f, 8.61925706e-02f,
  -3.21524203e-01f, -2.43505184e-02f, -9.82985720e-02f, 8.14638436e-02f, 2.90022224e-01f, -1.25611499e-01f, 2.50298083e-01f, 6.52694628e-02f, 1.71116203e-01f, -2.89425492e-01f,
  1.98173121e-01f, -1.15226202e-01f, -2.13128492e-01f, -1.04978360e-01f, -2.99165875e-01f, 1.98513210e-01f, -1.68393664e-02f, 2.43465751e-01f, 1.52923791e-02f, 1.67330325e-01f,
  2.71469533e-01f, 1.25824019e-01f, 7.20903128e-02f, 2.37731233e-01f, -3.48335057e-01f, -6.01885803e-02f, -1.67619035e-01f, -2.54129291e-01f, 1.25290051e-01f, -1.33217245e-01f,
  3.76490653e-01f, -1.42345160e-01f, -2.30119899e-01f, -2.16243595e-01f, 1.80624604e-01f, -8.96651968e-02f, 6.77151307e-02f, -3.85613590e-01f, 2.85162449e-01f, 2.28697434e-01f,
  -4.22655828e-02f, 1.07644051e-01f, 1.33740351e-01f, 2.19721690e-01f, -3.93035710e-01f, 1.23394743e-01f, -9.74715129e-02f, 3.45880017e-02f, -2.01887742e-01f, 5.04683703e-02f,
  -8.99012983e-02f, -1.52465224e-01f, 2.75917917e-01f, 5.49777031e-01f, 2.30827287e-01f, -2.66163558e-01f, 1.31939381e-01f, 8.18821266e-02f, 9.89644602e-02f, 1.48758106e-02f,
  -1.85973778e-01f, -2.69211262e-01f, 2.88817316e-01f, 6.43376037e-02f, 4.37245630e-02f, 1.28790796e-01f, 3.09561938e-01f, -2.09079012e-01f, 3.07487637e-01f, 3.37456644e-01f,
  6.51952773e-02f, 1.60426665e-02f, 8.76578242e-02f, 2.93486238e-01f, -2.32435837e-01f, -5.34212068e-02f, 1.67665035e-01f, 3.03671032e-01f, 1.44159887e-02f, 1.91241413e-01f,
  1.19634606e-01f, 3.75244282e-02f, 1.71854004e-01f, 3.45255136e-01f, -3.47329266e-02f, -5.06124198e-01f, 2.42843419e-01f, 1.24778926e-01f, 1.89746678e-01f, -2.61442244e-01f,
  2.17510730e-01f, -4.73277494e-02f, -2.84923971e-01f, -2.22823456e-01f, 1.56698674e-01f, -3.97270590e-01f, -4.00950164e-01f, -2.04025060e-01f, 1.70690641e-01f, 3.14252138e-01f,
  4.46911678e-02f, -1.16317339e-01f, 9.16182250e-02f, -4.63748246e-01f, -2.51640856e-01f, -2.50623852e-01f, -3.80430073e-01f, -4.66787741e-02f, 3.57053615e-02f, -4.68083501e-01f,
  -5.02078719e-02f, -5.84722720e-02f, -1.01888038e-01f, -3.16853635e-02f, -4.50037941e-02f, 2.29685530e-01f, 9.47507545e-02f, -1.38163164e-01f, -1.67795867e-01f, 4.07067090e-01f,
  -3.27776879e-01f, 4.28435467e-02f, 5.04635833e-02f, -1.24008060e-01f, 2.15331927e-01f, -3.65738481e-01f, -2.01133452e-02f, 2.65600178e-02f, -1.94560755e-02f, -6.23439029e-02f,
  1.85577393e-01f, 2.16777697e-01f, 1.38628513e-01f, 1.56761110e-01f, 5.66430353e-02f, -2.03808516e-01f, 8.17320775e-03f, 3.68627965e-01f, -3.21760952e-01f, -3.52963835e-01f,
  2.43704095e-01f, 6.40730634e-02f, 1.97860047e-01f, -1.47180269e-02f, -9.92311910e-03f, -1.46329358e-01f, 1.29765958e-01f, 9.89548266e-02f, 2.10645288e-01f, 4.33862992e-02f,
  -7.62695298e-02f, 9.75344032e-02f, -1.85709670e-01f, -2.46439785e-01f, -2.41061762e-01f, 1.87326998e-01f, -1.45472940e-02f, 3.34576845e-01f, -3.86727780e-01f, 4.98335660e-01f,
  -2.23684967e-01f, -9.16211605e-02f, -2.29531184e-01f, 2.33919308e-01f, -2.83179376e-02f, -1.46454766e-01f, -4.25312340e-01f, -2.53256649e-01f, 1.46519244e-01f, -1.48483768e-01f,
  -2.31746718e-01f, -8.35008994e-02f, 1.89196542e-01f, -2.63387114e-01f, -1.65662989e-02f, 1.70086443e-01f, -3.12044024e-01f, 5.51647581e-02f, -1.24310397e-01f, 3.62214416e-01f,
  3.14486802e-01f, 6.94456547e-02f, -2.83905864e-01f, -6.42821118e-02f, 2.11814195e-01f, 2.82779001e-02f, -1.01364419e-01f, -8.90111849e-02f, -1.44452736e-01f, -1.97404921e-01f,
  1.64304122e-01f, -2.07370639e-01f, 2.23575249e-01f, 1.31160721e-01f, -3.26074183e-01f, 9.09129977e-02f, 2.33832449e-02f, 1.72844213e-02f, -2.28451332e-03f, -1.09888099e-01f,
  5.98732345e-02f, -4.39576656e-02f, -7.28227645e-02f, 2.75633395e-01f, 2.49689788e-01f, 4.69455756e-02f, -2.02454999e-01f, 1.30563885e-01f, 8.40852037e-03f, -4.44402337e-01f,
  -8.32716376e-02f, 1.68060645e-01f, -3.56616944e-01f, 4.21897888e-01f, -4.77678090e-01f, 6.79414198e-02f, -2.31378600e-01f, -1.07300445e-01f, 7.19679743e-02f, 3.43246549e-01f,
  8.18045996e-03f, -1.55714080e-02f, 6.49622828e-02f, -1.47280559e-01f, 3.46871018e-01f, 3.39002609e-02f, 1.32823393e-01f, -1.63666084e-01f, -2.53774613e-01f, 3.14469039e-02f,
  1.29470378e-01f, -3.69829535e-02f, -1.43021449e-01f, -4.56900895e-02f, 4.22274172e-01f, -7.76085779e-02f, -2.43292600e-01f, 2.99786925e-01f, 4.11829144e-01f, 4.05826308e-02f,
  -3.10559988e-01f, -3.72678302e-02f, 3.30195844e-01f, -2.17534021e-01f, -3.28146927e-02f, 2.62351394e-01f, 2.90230423e-01f, -1.53332084e-01f, 4.53353822e-02f, -1.26274511e-01f,
  2.66163886e-01f, 4.77104522e-02f, 1.26304358e-01f, -2.38190874e-01f, -1.52875051e-01f, -1.39706671e-01f, 1.77681558e-02f, 5.27924113e-02f, 4.19854522e-01f, -2.30250046e-01f,
  -3.51325601e-01f, -1.40642509e-01f, 2.52494253e-02f, 1.79374859e-01f, -1.50029566e-02f, -3.06041036e-02f, -2.14897096e-01f, 1.35747716e-01f, -2.61933744e-01f, -2.36117586e-01f,
  5.73894344e-02f, -1.42280847e-01f, -2.20969200e-01f, -1.40925303e-01f, -3.04114688e-02f, 1.05466180e-01f, 1.02942005e-01f, -1.18487917e-01f, -4.48090658e-02f, -3.78578067e-01f,
  4.03228462e-01f, 3.98549169e-01f, 2.09633738e-01f, 2.88009554e-01f, 5.84605746e-02f, 1.52429417e-01f, -1.99364528e-01f, 3.51127148e-01f, 2.55304985e-02f, 3.16737980e-01f,
  -3.80764902e-01f, 5.29946527e-04f, 1.38531830e-02f, 3.22124928e-01f, -2.82330304e-01f, 5.04005253e-01f, 1.74711898e-01f, -1.71746925e-01f, -1.57432258e-01f, -3.79229784e-02f,
  2.00620994e-01f, -3.77327114e-01f, -8.73246938e-02f, 2.91992843e-01f, -2.14528471e-01f, 3.43426876e-02f, -1.19121268e-01f, 3.67950022e-01f, 2.12862645e-03f, -2.77506381e-01f,
  -2.54681319e-01f, 2.92481780e-01f, -8.51433426e-02f, 1.01924270e-01f, 8.49903077e-02f, 2.01196060e-01f, -1.74172342e-01f, 1.26498416e-01f, 2.53578424e-01f, 2.30974369e-02f,
  -1.38760671e-01f, -3.88436206e-02f, -2.97089100e-01f, 1.77256390e-01f, 9.56514198e-03f, 3.79035234e-01f, 3.62154573e-01f, 9.05180871e-02f, 2.21723333e-01f, 6.75350726e-02f,
  2.42881745e-01f, -2.29430839e-01f, 3.63853127e-01f, 2.00159311e-01f, 1.37624919e-01f, -1.48202419e-01f, 2.72807211e-01f, -1.88813031e-01f, -1.16774097e-01f, -1.81805491e-01f,
  -4.25315201e-02f, 2.74453700e-01f, 1.09449243e-02f, 1.18255034e-01f, -3.10520411e-01f, -3.18789333e-01f, -9.51554552e-02f, -2.66761094e-01f, 3.59460652e-01f, 3.34826469e-01f,
  -1.58702061e-01f, 1.60817981e-01f, -2.26251855e-01f, 8.67557153e-02f, 2.43750259e-01f, 2.81668715e-02f, 5.63488454e-02f, 4.73645404e-02f, -1.62382368e-02f, -2.46098310e-01f,
  3.87112558e-01f, 2.54473120e-01f, -4.02289659e-01f, 1.89270988e-01f, 2.97160208e-01f, 3.69202852e-01f, 1.16944984e-02f, -2.53816754e-01f, 3.75437528e-01f, -3.72557864e-02f,
  -6.02832399e-02f, -1.96862578e-01f, 5.96755333e-02f, -2.93990001e-02f, -2.14242503e-01f, -1.39632463e-01f, 2.42098659e-01f, -1.61888227e-02f, -8.41890574e-02f, -1.44017786e-01f,
  7.60130510e-02f, -2.64621258e-01f, -1.67893797e-01f, 1.97003670e-02f, -2.80539095e-01f, 7.02276379e-02f, 1.71280265e-01f, 1.57375500e-01f, 4.99311276e-03f, -2.76902229e-01f,
  -1.24392040e-01f, -3.28611761e-01f, -3.51973414e-01f, -3.34527701e-01f, 1.80937812e-01f, -1.92225114e-01f, -8.80578309e-02f, -1.41580015e-01f, -3.26907367e-01f, 9.79985669e-02f,
  -1.84892148e-01f, -1.15603119e-01f, 3.19687389e-02f, 2.74497092e-01f, 1.18471578e-01f, -3.12175214e-01f, 3.56261879e-01f, 1.12095527e-01f, 3.34772915e-01f, 1.74407169e-01f,
  7.35488683e-02f, -1.44265592e-01f, 6.03383742e-02f, -3.75853062e-01f, 2.00666964e-01f, -9.01380628e-02f, -3.11412752e-01f, -1.96166396e-01f, -9.37681347e-02f, -2.51101166e-01f,
  4.51755449e-02f, -3.11644346e-01f, -7.98281804e-02f, -1.02661431e-01f, -1.36569113e-01f, 3.82128239e-01f, -4.66712624e-01f, -8.89915004e-02f, -6.91669881e-02f, 1.03104450e-01f,
  -1.11138806e-01f, -1.30926639e-01f, 6.12952471e-01f, -7.69315585e-02f, -1.05186820e-01f, -1.23026371e-01f, 9.84527245e-02f, -3.38381171e-01f, 1.53982475e-01f, -2.84542233e-01f,
  -1.59373522e-01f, -3.93815944e-03f, -9.85479429e-02f, -6.15090467e-02f, -4.59028363e-01f, -3.23286504e-01f, -3.24242830e-01f, 1.00456104e-01f, -6.89547211e-02f, 5.38135730e-02f,
  3.56269717e-01f, 1.31877184e-01f, -2.76482582e-01f, -2.56814778e-01f, 3.93121541e-02f, -1.60565689e-01f, -2.73757786e-01f, 1.03042610e-01f, -6.99684843e-02f, 3.11199665e-01f,
  -5.10811150e-01f, -2.99239993e-01f, -4.06318277e-01f, -9.50614959e-02f, 2.35122412e-01f, 1.12196267e-01f, -2.00903580e-01f, -2.39915609e-01f, -3.91269505e-01f, -1.25304520e-01f,
  2.11561128e-01f, 1.49894506e-01f, 2.34064534e-01f, -1.74069911e-01f, -1.10481732e-01f, 2.91946918e-01f, -9.78884771e-02f, -4.53617424e-01f, 3.30525786e-01f, -2.38035947e-01f,
  -1.39776662e-01f, -3.78593244e-02f, 3.13774943e-01f, 1.57660484e-01f, 1.03540108e-01f, -1.44423097e-01f, 1.99492306e-01f, -1.44136548e-01f, -1.36732966e-01f, -6.08827956e-02f,
  4.97048236e-02f, -3.01902294e-01f, -3.86735350e-01f, -1.92132130e-01f, -9.64872167e-03f, -1.12945244e-01f, -2.75460869e-01f, 1.44922929e-02f, -8.87038559e-02f, -2.48349141e-02f,
  2.44594350e-01f, 2.88859248e-01f, -1.11426592e-01f, 1.31625637e-01f, -1.57521084e-01f, -4.26306650e-02f, 8.08008239e-02f, -9.99645069e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  4.57206815e-02f, 8.48085880e-02f, -1.15411272e-02f, -3.74043882e-02f, 8.53610784e-03f, -9.05755721e-03f, -7.27885403e-04f, 2.25963071e-02f, -9.48498622e-02f, 1.00261927e-01f,
  -3.07377987e-02f, -2.11486388e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    