/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.01950097e-01f, -2.93247607e-02f, 7.16332346e-02f, 1.45273849e-01f, -1.05876379e-01f, 1.06759198e-01f, 1.34968042e-01f, -1.20107168e-02f, 1.62137032e-01f, 4.89099398e-02f,
  -1.60419479e-01f, 8.17262754e-02f, -6.79811910e-02f, -4.74513024e-02f, -3.43977362e-02f, -9.30848718e-02f, 5.22307120e-02f, 1.35088116e-01f, -1.15562879e-01f, 5.48592582e-02f,
  -5.73418960e-02f, -1.58653274e-01f, 3.02325319e-02f, -1.32526696e-01f, 7.83738419e-02f, -4.42956947e-02f, -1.25748262e-01f, -1.26843646e-01f, 3.59179452e-02f, -1.00547992e-01f,
  9.90046039e-02f, 5.98468520e-02f, 7.78430142e-03f, 7.11818114e-02f, 1.91003773e-02f, 1.26024082e-01f, 8.73788521e-02f, -8.93765762e-02f, 5.05549833e-02f, -1.31655000e-02f,
  2.46837568e-02f, 3.56738120e-02f, -5.81860589e-03f, 1.31835295e-02f, 4.34877314e-02f, 7.64154550e-03f, -2.14371569e-02f, 9.96227935e-02f, 1.21913413e-02f, 7.90060684e-02f,
  1.11485884e-01f, 6.50672615e-02f, 8.10423866e-02f, -3.85961197e-02f, -3.78634385e-03f, 4.13956270e-02f, 5.20441309e-02f, -4.16010479e-03f, 7.86939338e-02f, -1.43148750e-02f,
  4.10341471e-02f, -5.21485247e-02f, 8.05139318e-02f, -3.75017747e-02f, 3.34933260e-03f, -2.24871431e-02f, 1.89338606e-02f, -3.95866930e-02f, 3.17770243e-02f, 9.95756872e-03f,
  -1.55758718e-02f, -5.16504096e-03f, 5.82836904e-02f, -3.56145613e-02f, 1.42431296e-02f, 2.71232985e-02f, 2.61448380e-02f, -2.80845053e-02f, 4.30497341e-02f, -2.79459041e-02f,
  -6.86343685e-02f, -5.43565899e-02f, -5.40199876e-03f, -1.79124102e-02f, 1.44285997e-02f, -6.18791208e-02f, -5.91068007e-02f, 5.48864156e-02f, -6.30514920e-02f, 6.11250103e-02f,
  -7.13480115e-02f, -9.42105800e-02f, 3.11001274e-03f, 9.81031638e-03f, -4.17636149e-02f, -2.15216447e-02f, -3.14656943e-02f, 6.08974248e-02f, -9.06723216e-02f, 5.72007075e-02f,
  -5.26067987e-03f, 4.82966080e-02f, -2.85351146e-02f, -2.00771578e-02f, -5.94623089e-02f, -1.94144831e-03f, -4.98179421e-02f, -6.41411403e-03f, -1.22022675e-02f, -4.98874001e-02f,
  -7.95114599e-03f, -7.85333104e-03f, -3.36295106e-02f, 8.38759616e-02f, 4.62730825e-02f, 2.35531684e-02f, 1.67134777e-02f, 8.31750855e-02f, -9.80223864e-02f, -4.08186717e-03f,
  5.14181331e-02f, 2.92276859e-01f, -2.76791807e-02f, 2.25893944e-03f, 4.95895334e-02f, -2.74100527e-02f, 7.24687949e-02f, 1.98632091e-01f, 1.76668260e-02f, 1.45667762e-01f,
  5.30395061e-02f, -5.37237786e-02f, -8.53274688e-02f, 7.67805474e-03f, -4.05142874e-01f, -1.65068492e-01f, -1.85180623e-02f, 8.32777917e-02f, -2.09370200e-02f, 1.91031918e-01f,
  -1.41531333e-01f, -1.24345057e-01f, -1.28071159e-01f, 7.90358931e-02f, 8.60106498e-02f, 8.58185664e-02f, -7.48184770e-02f, -1.69445574e-02f, 7.86034949e-03f, -1.09107964e-01f,
  -7.18933716e-02f, 1.61361694e-01f, -7.35810958e-03f, 4.81730737e-02f, 4.38461378e-02f, 2.97987293e-02f, -2.73198020e-02f, -1.32703230e-01f, -6.80938289e-02f, 7.74165913e-02f,
  2.79428288e-02f, -8.02340135e-02f, 4.57453029e-03f, -3.63132320e-02f, 4.44584079e-02f, 2.84865554e-02f, -4.52628545e-02f, 2.15531923e-02f, 7.27088824e-02f, -4.36936133e-03f,
  5.30813560e-02f, 8.66197795e-03f, 5.23976013e-02f, 1.06967147e-02f, -7.37675186e-03f, -4.01214473e-02f, -7.45648146e-02f, -2.69937795e-02f, 1.72658246e-02f, -1.15577374e-02f,
  4.87487316e-02f, 5.08730672e-02f, 8.64803675e-04f, 2.14758478e-02f, 2.32669618e-02f, 9.81216785e-03f, 5.81317535e-03f, -5.15621416e-02f, -1.92478590e-03f, 4.03047390e-02f,
  3.36885639e-02f, 2.24387310e-02f, -2.81913672e-02f, 3.88547033e-02f, -8.65793694e-03f, 6.77045137e-02f, -5.18310256e-02f, 3.13353017e-02f, 5.05917035e-02f, -1.91942248e-02f,
  2.28809025e-02f, -5.67583879e-03f, -2.78084297e-02f, -5.04496694e-02f, -2.46207621e-02f, 2.32435409e-02f, -3.31437141e-02f, 6.61376864e-02f, -2.93493699e-02f, -5.32455295e-02f,
  1.10108346e-01f, 1.81046262e-01f, 4.16233465e-02f, -3.15611698e-02f, 4.71950918e-02f, -1.97702739e-02f, 1.81303232e-03f, 8.45706090e-02f, -3.00568505e-03f, -1.67940598e-04f,
  6.80080354e-02f, -9.38152429e-03f, -2.81939516e-03f, -1.56528708e-02f, -8.38453099e-02f, -1.84463076e-02f, 4.97165471e-02f, 1.46244913e-02f, 3.14566381e-02f, 4.24682796e-02f,
  4.03482020e-02f, 3.89488526e-02f, -8.33639205e-02f, 2.35459134e-02f, -1.87536012e-02f, 3.86220366e-02f, 7.23459199e-02f, 7.18010589e-02f, -5.67884929e-03f, 3.38036567e-02f,
  3.57249707e-01f, 2.72981018e-01f, 2.15098113e-01f, 1.49611220e-01f, -5.17999232e-02f, 1.89760953e-01f, 2.17021644e-01f, 7.04934373e-02f, 6.72237724e-02f, 4.96446528e-02f,
  1.13137672e-03f, 2.62808412e-01f, -3.71461697e-02f, 2.35539049e-01f, -1.73816849e-02f, 4.08924147e-02f, 1.83426544e-01f, 8.17500800e-02f, -2.37108357e-02f, 5.77497520e-02f,
  -1.08517222e-02f, -6.31388798e-02f, 5.01192771e-02f, -6.89147860e-02f, 1.32194266e-01f, -3.16292420e-02f, -2.31094986e-01f, -9.58991498e-02f, -3.74886580e-02f, 3.33395973e-02f,
  1.02780543e-01f, -2.74549797e-02f, 6.66854754e-02f, 8.12226906e-02f, 2.47645546e-02f, 1.73197326e-03f, 6.24747984e-02f, -5.84230088e-02f, -6.90358877e-02f, -6.27577119e-03f,
  8.88520759e-03f, 3.63975614e-02f, 1.02441162e-02f, -2.78403610e-02f, -2.12522168e-02f, 2.50720177e-02f, 4.79198359e-02f, 1.37803880e-02f, 7.74499774e-02f, 9.58732367e-02f,
  1.94554962e-02f, 7.59150193e-04f, -4.32116096e-04f, -3.85776572e-02f, 3.37067358e-02f, -1.67908042e-03f, 4.61869538e-02f, 2.50393674e-02f, 4.34991792e-02f, -6.37974404e-03f,
  2.37032752e-02f, -2.65759323e-02f, 3.42491493e-02f, -3.19261402e-02f, 2.40604021e-02f, -4.57049906e-02f, -1.17193088e-02f, -1.50935240e-02f, -6.33562973e-04f, 3.34582180e-02f,
  2.88230907e-02f, 6.78070858e-02f, -1.13513991e-02f, 4.60727215e-02f, 6.89847767e-02f, -1.42198792e-02f, 1.58534236e-02f, 3.67368907e-02f, 2.88585667e-02f, -5.53963473e-03f,
  -5.82898967e-02f, -9.03529755e-04f, 9.86876525e-03f, -5.13102747e-02f, -1.90448649e-02f, -1.01659307e-02f, 1.26963072e-02f, -2.15050392e-02f, 8.72604898e-04f, -3.86904255e-02f,
  -2.08692402e-02f, -3.73409726e-02f, -4.29907590e-02f, -8.33905861e-03f, -2.44129132e-02f, 5.76450713e-02f, -3.72787826e-02f, 7.08760917e-02f, 3.95121388e-02f, 2.33530942e-02f,
  -1.89452432e-02f, -1.54124117e-02f, 3.18866037e-02f, -3.35232988e-02f, -2.62833890e-02f, -1.92923341e-02f, -5.35437576e-02f, -6.08090647e-02f, -6.09456263e-02f, -2.77799554e-02f,
  -2.05176231e-02f, -1.26818037e-02f, 3.61864775e-04f, 3.94616015e-02f, -2.06716005e-02f, 3.85340825e-02f, 2.13078614e-02f, -1.60676092e-02f, -4.72426042e-02f, -1.79078840e-02f,
  -2.04063207e-01f, 1.09408330e-02f, 3.55586410e-02f, -1.48617595e-01f, 7.11749541e-03f, 2.81547636e-01f, 3.18145454e-01f, -1.49939045e-01f, 7.57073015e-02f, 9.23755020e-02f,
  3.53785120e-02f, 1.38672397e-01f, 2.61138469e-01f, -6.27251938e-02f, 2.14513227e-01f, 1.77631825e-01f, 4.26841080e-02f, -1.88350603e-02f, 4.16221134e-02f, -1.13984272e-01f,
  -4.90048528e-02f, -1.26093820e-01f, -8.82505402e-02f, -8.46056268e-02f, -8.96677598e-02f, -1.99404404e-01f, -1.49273798e-01f, 1.17003351e-01f, -1.24863014e-01f, -4.05526115e-03f,
  -8.95108059e-02f, -4.12458293e-02f, -9.09230672e-03f, -4.02818099e-02f, -7.74505883e-02f, -6.96080551e-02f, 1.25791943e-02f, 9.06945243e-02f, 2.42611412e-02f, 5.09490520e-02f,
  2.84849200e-02f, -6.36252090e-02f, -3.80582921e-02f, -3.00715491e-02f, 1.63549762e-02f, -1.44716978e-04f, -7.22600818e-02f, -3.08875367e-02f, -1.36886956e-02f, -4.62043751e-03f,
  4.47962210e-02f, -5.47427386e-02f, -1.11064808e-02f, 1.59751307e-02f, 1.42419357e-02f, -5.89373149e-02f, 2.95081711e-03f, 2.25155409e-02f, -3.66923958e-02f, -4.35288548e-02f,
  9.80928019e-02f, 6.49448484e-02f, 5.76913776e-03f, -7.27228820e-02f, -3.23718041e-02f, -7.09146336e-02f, -2.73373239e-02f, 6.66834507e-03f, 4.47553815e-03f, -7.38326809e-04f,
  -1.73514746e-02f, -4.11411040e-02f, -1.89540461e-02f, 1.78459138e-02f, -8.99428094e-04f, -1.72395594e-02f, -1.15463510e-03f, -2.86336895e-02f, 1.45952068e-02f, -7.45541379e-02f,
  2.12416332e-02f, -3.29214223e-02f, 4.77181822e-02f, -4.78848144e-02f, -1.21721234e-02f, 5.52955791e-02f, -1.81870218e-02f, 3.83247584e-02f, -2.64164358e-02f, 1.57253444e-02f,
  4.59620655e-02f, -1.46461681e-01f, 1.29495729e-02f, -1.23619447e-02f, 3.45368683e-03f, 5.90976514e-02f, 4.29359898e-02f, 2.75219884e-03f, 5.05587459e-02f, -2.00594459e-02f,
  -6.84933877e-03f, 1.84160098e-03f, 2.61144303e-02f, 3.90339866e-02f, 5.86802000e-03f, -4.25586365e-02f, 2.53372081e-02f, -1.74056436e-03f, -3.87904444e-03f, -9.23660919e-02f,
  -1.04339853e-01f, 3.76569815e-02f, -5.14184171e-03f, -2.99938140e-03f, -3.35190445e-02f, 2.27345470e-02f, 2.40701437e-02f, -7.37810368e-03f, 3.72930467e-02f, 6.29904717e-02f,
  4.46128584e-02f, -1.35071814e-01f, -2.66345829e-01f, -1.84093937e-01f, 9.93105210e-03f, 1.65581644e-01f, 4.56163809e-02f, -1.54251844e-01f, -3.23755890e-02f, 1.13314874e-01f,
  2.26434171e-02f, -4.54827249e-02f, 9.38038975e-02f, -5.80550991e-02f, 1.06187984e-02f, 7.81226605e-02f, -8.65594298e-02f, -4.23901826e-02f, -6.70985281e-02f, -1.68365121e-01f,
  -5.26695698e-02f, -3.32938954e-02f, -1.06845759e-01f, -9.10138488e-02f, -2.09190156e-02f, -5.25533073e-02f, 5.35351075e-02f, -1.85446553e-02f, -2.11110506e-02f, 9.59666222e-02f,
  3.31856608e-02f, -1.21703988e-03f, -7.67322183e-02f, -3.29743363e-02f, -4.58347499e-02f, 6.68994337e-02f, -3.56128514e-02f, 4.58922097e-03f, -5.74400984e-02f, -1.25184201e-03f,
  -2.84262970e-02f, 4.69196923e-02f, 3.69195081e-03f, 5.36059290e-02f, -7.63612799e-03f, -7.70770982e-02f, 7.16786459e-02f, -3.22464779e-02f, -2.07495000e-02f, 3.44891511e-02f,
  -1.05927125e-01f, 3.74706015e-02f, -1.60676613e-02f, -5.33570275e-02f, -1.04542501e-01f, 9.61258821e-03f, 5.33119738e-02f, -1.07379984e-02f, 1.62340272e-02f, 1.80830285e-02f,
  1.23445034e-01f, -6.82118256e-03f, -4.57247421e-02f, -1.83705743e-02f, 2.25463938e-02f, -3.46706994e-02f, -5.21551771e-03f, -1.71301011e-02f, -2.01927731e-03f, -5.71070276e-02f,
  1.11980531e-02f, 6.55080331e-03f, 2.44901385e-02f, 3.29338647e-02f, 1.02291014e-02f, -1.77932288e-02f, -2.99907755e-02f, -4.80205007e-02f, 3.35633978e-02f, -2.69580595e-02f,
  -2.95314174e-02f, -4.12669890e-02f, -1.22460444e-02f, 9.57361422e-03f, -2.79536862e-02f, -1.01979468e-02f, 4.37307805e-02f, -5.70843443e-02f, -3.05939838e-02f, -4.47734743e-02f,
  9.09285024e-02f, -1.28720567e-01f, -3.50537375e-02f, -5.81372995e-04f, 3.49065512e-02f, 1.25044277e-02f, -8.24430361e-02f, 7.07379403e-03f, 1.13877244e-02f, -6.40563741e-02f,
  7.97274038e-02f, -4.94364504e-05f, -1.14277424e-02f, -1.01024341e-02f, 1.62893832e-02f, 4.94602025e-02f, -3.71963792e-02f, 2.35092863e-02f, -6.47822469e-02f, -2.55686510e-02f,
  4.94027063e-02f, -8.91280826e-03f, 3.75220105e-02f, 5.93757145e-02f, 4.68560494e-02f, -2.87495442e-02f, 5.94859011e-02f, 2.80373227e-02f, 7.59746134e-03f, -2.42059529e-02f,
  3.85738611e-02f, -2.93572843e-01f, 1.10913210e-01f, -7.03199804e-02f, 2.04592213e-01f, 3.10268998e-01f, 2.55091667e-01f, -7.72832632e-02f, -1.47140563e-01f, -1.34603202e-01f,
  9.54096299e-03f, -3.49957235e-02f, -5.03340550e-02f, -5.07135503e-02f, 2.04993784e-01f, -1.10445909e-01f, 2.23347098e-02f, 9.27033648e-02f, -9.12047699e-02f, 1.77709234e-03f,
  1.46914218e-02f, -1.05013093e-02f, -3.33831739e-03f, 6.85123354e-02f, 4.32808734e-02f, -1.10771798e-01f, -6.29429938e-03f, 1.66750029e-01f, 1.17594800e-06f, 8.19392353e-02f,
  9.96273709e-04f, -1.77615792e-01f, -4.70622294e-02f, 7.20535666e-02f, 8.48386809e-02f, 4.26756106e-02f, 5.39644137e-02f, 5.31507693e-02f, 2.76623666e-02f, -3.74086425e-02f,
  -2.01099385e-02f, 4.05392423e-02f, -9.79815349e-02f, 4.65466231e-02f, 2.07652897e-02f, -4.39983346e-02f, 4.52910699e-02f, 2.77422462e-02f, -2.15282235e-02f, 3.67999799e-03f,
  2.53765713e-02f, -6.35705590e-02f, -5.68463691e-02f, -2.73896270e-02f, 7.04349056e-02f, -3.77067737e-03f, -4.52635922e-02f, 4.89069428e-03f, -2.64905151e-02f, 9.99071077e-03f,
  6.98450357e-02f, 6.43258542e-02f, 2.38902476e-02f, 3.68276164e-02f, -1.25233158e-02f, 7.16640651e-02f, 1.90960243e-02f, -4.02636640e-02f, -2.87481174e-02f, -2.32606735e-02f,
  -2.48356126e-02f, -7.17723966e-02f, 1.68696493e-02f, 3.45867053e-02f, -1.35664856e-02f, 2.43847165e-02f, 3.28688957e-02f, 1.12236477e-02f, 2.25861277e-02f, -1.22625371e-02f,
  -3.44167538e-02f, 1.38678839e-02f, -4.73015085e-02f, 7.98471421e-02f, 2.58740634e-02f, 2.91700251e-02f, -4.32717352e-04f, 3.23418416e-02f, -5.39298020e-02f, 6.33706599e-02f,
  -3.32184546e-02f, -5.08378707e-02f, -4.11701389e-02f, 4.91462536e-02f, 6.54699057e-02f, -2.09185015e-02f, 4.53652181e-02f, 3.75453047e-02f, -4.32470739e-02f, 2.23197490e-02f,
  3.63109708e-02f, 6.48769811e-02f, -2.19932962e-02f, -1.12754675e-02f, -2.96106357e-02f, -2.99157053e-02f, -2.97780167e-02f, 4.37105559e-02f, 1.53594166e-02f, 4.49441858e-02f,
  -3.21476050e-02f, 2.18726825e-02f, 6.90013170e-02f, 2.93994900e-02f, 3.67572829e-02f, 7.34372288e-02f, 6.67769555e-03f, -3.35670151e-02f, -2.91634519e-02f, -1.11025702e-02f,
  -3.41767430e-01f, 1.91470653e-01f, 2.66536400e-02f, -7.89242610e-02f, 1.98450778e-02f, 7.33367428e-02f, -2.68724505e-02f, 3.30672599e-02f, 2.06582934e-01f, 1.71069384e-01f,
  -6.54969811e-02f, -2.24544425e-02f, -1.32014777e-03f, 3.53215076e-02f, -1.32866368e-01f, 3.70471738e-02f, -3.09784524e-02f, 8.42310116e-03f, 1.26078930e-02f, -1.15192086e-01f,
  -9.16284248e-02f, -2.95126508e-03f, -1.27273127e-01f, -3.92358713e-02f, 9.59393382e-03f, -1.09037764e-01f, -1.20612122e-01f, -4.09410857e-02f, 1.03752501e-02f, -6.63818642e-02f,
  -1.04602277e-01f, 3.01496275e-02f, 7.36516260e-04f, 7.50710592e-02f, -1.39389597e-02f, 1.90867167e-02f, -3.27088274e-02f, 6.36991765e-03f, -4.16516215e-02f, 6.03410788e-03f,
  -6.00545853e-02f, 7.52621097e-03f, -6.72455225e-03f, 1.37704257e-02f, 1.04943536e-01f, 8.67456719e-02f, 3.41178142e-02f, -4.85162959e-02f, 8.58136341e-02f, -2.03131922e-02f,
  -1.01177348e-02f, 1.61912646e-02f, 6.63910508e-02f, 3.44395116e-02f, 1.08372781e-03f, 1.88375879e-02f, -1.60255115e-02f, -2.21577920e-02f, 5.49958423e-02f, 3.78845744e-02f,
  -7.22140372e-02f, -1.33233843e-02f, 3.48644182e-02f, 4.52092923e-02f, 3.02521158e-02f, -1.99273881e-02f, 1.98689085e-02f, 4.63869888e-03f, 2.16656290e-02f, 4.73386329e-03f,
  -1.74144544e-02f, 2.43943091e-02f, -1.96071956e-02f, -2.96768360e-02f, -8.54480043e-02f, 4.57516760e-02f, 4.49721469e-03f, -3.06390077e-02f, 6.94436580e-03f, 5.41756526e-02f,
  5.79272844e-02f, 3.17035504e-02f, 6.32612407e-03f, -5.20749390e-02f, 7.28619918e-02f, -6.69989809e-02f, 4.75780107e-04f, -1.49920508e-02f, -4.91127893e-02f, -6.45717829e-02f,
  -4.66656918e-03f, -3.42371725e-02f, 1.00230007e-02f, -8.42620991e-03f, 3.69626060e-02f, -6.02713749e-02f, 1.52556272e-02f, -2.50860620e-02f, 1.83573570e-02f, 1.60406623e-02f,
  3.33098471e-02f, 3.18629667e-02f, -3.15694651e-03f, 3.52102853e-02f, 5.82469590e-02f, -1.83296818e-02f, -2.34691203e-02f, -3.15033458e-03f, -4.05532354e-03f, 1.88018009e-02f,
  -4.67986427e-02f, -2.34959647e-02f, -8.73812512e-02f, 2.45946776e-02f, 3.77648175e-02f, -5.92209361e-02f, -1.68170333e-02f, -1.62654724e-02f, -3.88144590e-02f, -9.56030656e-03f,
  3.18601519e-01f, -9.99986455e-02f, -1.61100715e-01f, 1.04151778e-01f, 1.98473617e-01f, 3.66927125e-02f, -7.38975182e-02f, 5.37157841e-02f, 9.40914324e-04f, -7.02103376e-02f,
  1.20394211e-02f, 8.01962838e-02f, -2.32735559e-01f, 2.14902520e-01f, 2.18236953e-01f, -1.53138697e-01f, 2.00065196e-01f, 4.59175371e-02f, -5.48560768e-02f, 1.40110075e-01f,
  8.58281553e-02f, 1.34885669e-01f, -1.10979788e-01f, 5.95324039e-02f, 1.61856890e-01f, -1.04416171e-02f, 1.14892974e-01f, -1.31785586e-01f, 2.15769172e-01f, 7.10539445e-02f,
  6.56590750e-03f, -2.93938722e-02f, -3.50623764e-03f, -3.44354436e-02f, 6.01597056e-02f, 8.16850737e-02f, -2.98163807e-03f, -6.31418498e-03f, -5.32549173e-02f, 4.29172702e-02f,
  3.23374309e-02f, 5.99724799e-02f, 7.00893179e-02f, -2.07305010e-02f, 3.05675883e-02f, 8.26697350e-02f, -1.02487421e-02f, -6.09117299e-02f, -5.99647909e-02f, -5.71147026e-03f,
  -6.84600100e-02f, -3.12109701e-02f, -2.22385023e-02f, 1.32328281e-02f, -4.52989666e-03f, -2.64699701e-02f, 4.44391277e-03f, -4.61044069e-03f, -3.95867266e-02f, 4.85843755e-02f,
  7.23413527e-02f, 1.49588753e-02f, -5.48602305e-02f, -1.57679450e-02f, 2.15514805e-02f, -5.85754476e-02f, 3.88872549e-02f, -5.24392389e-02f, 5.16178794e-02f, -3.31071205e-02f,
  -1.82399042e-02f, 3.34912017e-02f, 3.80899273e-02f, 1.77550130e-02f, 4.91508096e-03f, -3.84785756e-02f, 3.40238735e-02f, 2.40253936e-03f, 2.59572472e-02f, 2.29601879e-02f,
  2.68703997e-02f, -7.86285754e-03f, -7.92745873e-03f, 2.34849304e-02f, -6.81380043e-03f, 4.82072346e-02f, 6.32229149e-02f, -6.13543093e-02f, 7.91942850e-02f, 5.95523715e-02f,
  5.97685613e-02f, 6.20279051e-02f, -5.92154674e-02f, -3.42885181e-02f, -7.90116901e-04f, 2.58085728e-02f, -3.63738760e-02f, 5.10335565e-02f, 2.72407606e-02f, -2.60939784e-02f,
  9.39729139e-02f, -4.27940115e-02f, 2.73989905e-02f, 1.35526210e-02f, 2.52366122e-02f, -4.02744375e-02f, 2.16604434e-02f, 1.43298283e-02f, 1.23371363e-01f, -1.03106536e-02f,
  5.58863282e-02f, 2.47902311e-02f, -3.07461526e-02f, 2.51502860e-02f, -6.93176035e-03f, 6.32815287e-02f, 5.88625185e-02f, -6.43785521e-02f, 3.03780250e-02f, -2.26697568e-02f,
  1.51430756e-01f, 8.85202643e-03f, -6.46077767e-02f, 3.09329499e-02f, -4.73126443e-03f, 2.03636155e-01f, 2.41484389e-01f, 3.81653532e-02f, 8.07276070e-02f, -5.03596738e-02f,
  5.95950671e-02f, -9.68989581e-02f, 8.48753005e-03f, 2.21590295e-01f, 2.56362885e-01f, 2.14696780e-01f, 2.48079747e-01f, 3.32636200e-02f, 7.72417635e-02f, -4.63233404e-02f,
  7.24747777e-02f, 4.56622355e-02f, 1.71069160e-01f, -7.46571198e-02f, -3.66851501e-02f, -1.92793578e-01f, -2.03569055e-01f, -1.30044430e-01f, -9.79184210e-02f, 1.23786870e-02f,
  8.52989629e-02f, -8.08589533e-03f, -7.63501674e-02f, 7.08661377e-02f, 2.11418085e-02f, 2.83365268e-02f, -6.90409616e-02f, -6.46857172e-02f, -2.58307671e-03f, -1.64321195e-02f,
  -2.94399634e-02f, 1.94199523e-03f, 1.27806212e-03f, -1.52348988e-02f, 2.20435541e-02f, -3.18943448e-02f, 1.41518712e-02f, 2.35010926e-02f, -4.52777371e-02f, -1.01286983e-02f,
  8.99793580e-03f, -3.20469178e-02f, -4.57958728e-02f, 3.31256613e-02f, -2.02580113e-02f, -1.33744264e-02f, -1.96096040e-02f, -2.76406035e-02f, 1.00175720e-02f, 3.24492492e-02f,
  -3.96003686e-02f, -9.58295632e-03f, 1.54173328e-02f, 5.15947193e-02f, -2.82463543e-02f, 8.34995415e-03f, -2.49484256e-02f, -1.75283849e-02f, -3.84253599e-02f, -1.15204332e-02f,
  1.72383096e-02f, -1.97314005e-02f, -7.25872349e-03f, -3.66626158e-02f, -1.90022960e-03f, 1.27171846e-02f, -4.03854549e-02f, 8.85196775e-03f, 2.35092603e-02f, -1.74189016e-04f,
  1.91911869e-02f, -1.64342374e-02f, -7.87371323e-02f, 3.18606347e-02f, -1.92911606e-02f, 2.70917919e-02f, -2.77230088e-02f, 1.79611053e-02f, -1.72869172e-02f, 2.27260217e-02f,
  3.29982229e-02f, -1.58122003e-01f, -2.30089240e-02f, -1.53872808e-02f, -2.28461865e-02f, -4.81622480e-02f, 8.00983608e-02f, 6.34496808e-02f, -5.55893183e-02f, 6.15978576e-02f,
  -5.68541214e-02f, -7.19669312e-02f, -7.63355419e-02f, 2.41605658e-02f, -3.46860178e-02f, 7.80411139e-02f, -5.65008111e-02f, -5.42560965e-02f, -1.70955751e-02f, 1.93285886e-02f,
  -5.19366860e-02f, 3.65163609e-02f, 6.66557923e-02f, -5.07242158e-02f, -1.08319409e-02f, -3.91990542e-02f, -1.94084607e-02f, 2.37758327e-02f, -5.93056120e-02f, -3.18104886e-02f,
  -1.95060775e-01f, 2.18245268e-01f, -9.91179869e-02f, -2.37019345e-01f, 1.07225329e-01f, 7.77798593e-02f, -1.25015210e-02f, 9.75639969e-02f, 6.95330873e-02f, 1.87363774e-01f,
  5.14137698e-03f, -1.15855582e-01f, 4.21217494e-02f, -6.52650222e-02f, -2.87821829e-01f, -2.88539901e-02f, -7.38502890e-02f, -1.28998207e-02f, 6.82158694e-02f, 1.45831732e-02f,
  -2.98642293e-02f, 4.06274498e-02f, -9.33265686e-02f, 2.44019315e-01f, -7.09228441e-02f, 5.09791961e-03f, -8.98085386e-02f, 3.91944684e-02f, -9.08589140e-02f, 4.08446752e-02f,
  4.22166400e-02f, 4.80771139e-02f, 1.66899562e-02f, 1.25742659e-01f, -1.61597673e-02f, -5.42680398e-02f, -1.97417773e-02f, -5.32751456e-02f, -4.06580456e-02f, -5.62554188e-02f,
  2.78374795e-02f, 4.98069152e-02f, 4.39031841e-03f, -3.71896587e-02f, 5.43476902e-02f, 6.28299341e-02f, -2.66516320e-02f, 5.97519688e-02f, 1.89246628e-02f, -5.74529096e-02f,
  6.40594736e-02f, -4.36342210e-02f, -4.09822240e-02f, -4.29470912e-02f, -4.32626344e-02f, 1.03851454e-02f, -4.02241573e-02f, 1.22268526e-02f, -4.95734811e-02f, -3.32292579e-02f,
  2.73807514e-02f, -9.09819305e-02f, 3.25321853e-02f, -7.11903423e-02f, -1.72040481e-02f, 1.01267090e-02f, -7.36351404e-03f, -2.07044035e-02f, -4.15837541e-02f, 3.84260491e-02f,
  -6.94446862e-02f, -7.02053756e-02f, 5.97756095e-02f, 2.76493989e-02f, -5.37244231e-03f, 6.07017102e-03f, -6.48594126e-02f, -2.87397150e-02f, -2.86413562e-02f, -4.54737395e-02f,
  3.62513848e-02f, 3.28843184e-02f, 1.67060979e-02f, -2.56279111e-02f, 1.19750589e-01f, -2.53318865e-02f, 5.24241067e-02f, 2.12750956e-02f, 5.21976985e-02f, -1.36720426e-02f,
  2.09041104e-01f, 9.27993581e-02f, 3.75485122e-02f, 4.14461158e-02f, 1.06268888e-02f, 6.02769256e-02f, -1.38646951e-02f, 2.73136199e-02f, 5.89890853e-02f, 2.27467977e-02f,
  -4.33100611e-02f, -6.42739087e-02f, -1.12972846e-02f, 2.83677038e-02f, -3.56144793e-02f, -3.57861631e-02f, 8.37452617e-03f, -3.66081707e-02f, 4.16256227e-02f, -9.95054748e-03f,
  -8.73441342e-03f, 2.60551907e-02f, -1.63122732e-02f, -2.60240212e-02f, -2.71294229e-02f, -7.72792893e-03f, -8.82031918e-02f, 1.80714373e-02f, -5.85461818e-02f, 4.01432859e-03f,
  1.72656953e-01f, 3.44976425e-01f, -1.13288246e-01f, 9.40381512e-02f, -1.17071860e-01f, -1.74147025e-01f, -2.02170908e-01f, -3.33041251e-02f, 1.09415457e-01f, 6.17701150e-02f,
  -4.19940427e-02f, 2.29137734e-01f, -5.95703311e-02f, -1.09848298e-01f, -2.83338308e-01f, -4.69822921e-02f, -6.22655079e-02f, -1.13722570e-02f, -1.01430053e-02f, 8.08396041e-02f,
  -5.79320379e-02f, -1.09780423e-01f, -2.76780844e-01f, -1.90723054e-02f, -7.21306652e-02f, 7.53388330e-02f, 4.00875472e-02f, -9.67938751e-02f, -1.70432758e-02f, -8.00921470e-02f,
  2.74698213e-02f, 7.19901323e-02f, -5.14218211e-02f, 8.94086377e-04f, 1.59491363e-04f, -8.35391320e-03f, 1.81482397e-02f, -7.98332468e-02f, -2.69762259e-02f, -1.29634207e-02f,
  2.93531194e-02f, 4.46322151e-02f, -4.98739034e-02f, -1.83115527e-02f, 4.89518531e-02f, -3.82384472e-02f, 1.81973726e-02f, -6.31812215e-02f, 7.04932306e-03f, -9.47644114e-02f,
  -6.60138875e-02f, 4.83244583e-02f, -1.16812810e-02f, 5.72753586e-02f, -1.04224300e-02f, 6.51535671e-03f, 3.42381839e-03f, -1.66337229e-02f, 5.72191700e-02f, 3.34297940e-02f,
  -1.97074153e-02f, 4.62110788e-02f, -1.67886112e-02f, 3.03075034e-02f, 3.98593768e-02f, -5.23570776e-02f, 5.55735305e-02f, 1.11687267e-02f, 2.45914012e-02f, 5.95599413e-03f,
  -3.89655530e-02f, 1.89497136e-02f, 2.70683225e-03f, -2.02843342e-02f, 4.00645509e-02f, -2.75038537e-02f, 4.70234528e-02f, 8.30631703e-02f, -3.70148234e-02f, -3.15833837e-02f,
  3.13151767e-03f, -1.16536766e-03f, -2.75955852e-02f, 9.39774234e-03f, -2.24517044e-02f, -6.68896921e-03f, 3.34533714e-02f, 4.19386514e-02f, -2.71387156e-02f, -6.31534532e-02f,
  2.80037910e-01f, 3.36260855e-01f, 7.49530643e-03f, 4.31994423e-02f, -2.43845228e-02f, -5.49829565e-03f, 3.67281474e-02f, 9.43989307e-02f, 6.92416579e-02f, -2.05528531e-02f,
  3.12892273e-02f, -3.63705531e-02f, 9.42893401e-02f, 1.80629436e-02f, -2.43881755e-02f, 5.30426800e-02f, 3.63690630e-02f, 4.12166417e-02f, -3.44681479e-02f, 9.88332257e-02f,
  5.35914004e-02f, -2.52431072e-02f, -7.65246898e-02f, -6.26553297e-02f, 2.64292192e-02f, -3.98658775e-02f, 3.80770415e-02f, -1.61260692e-03f, 1.36240395e-02f, -2.87672528e-03f,
  -2.06772238e-01f, -9.43549536e-03f, -2.28520796e-01f, -2.35786796e-01f, 1.52107447e-01f, 1.56042650e-01f, -1.57559663e-01f, 1.08425230e-01f, -7.86824748e-02f, 1.88642532e-01f,
  1.84081364e-02f, -1.94632053e-01f, -3.51569876e-02f, 1.08890161e-01f, -2.37136528e-01f, 1.42542427e-04f, -5.70753124e-03f, -2.30084267e-02f, 1.98774524e-02f, -1.18224703e-01f,
  2.99718883e-03f, 1.61662504e-01f, -9.90540013e-02f, 1.87788114e-01f, 4.46955711e-02f, -6.54933080e-02f, -6.77932501e-02f, -6.70972764e-02f, 1.03355050e-01f, 4.27303165e-02f,
  -1.58057902e-02f, 7.33992457e-02f, 1.35957869e-02f, 1.74954217e-02f, 6.55736476e-02f, -1.85200833e-02f, -3.51488814e-02f, -2.41826437e-02f, -4.50332090e-02f, 3.49548161e-02f,
  -4.37026098e-02f, -5.35346083e-02f, 5.65612316e-02f, 3.77777107e-02f, -4.66427989e-02f, -2.04785876e-02f, 2.53545102e-02f, 1.81650128e-02f, -4.83795851e-02f, -2.18005423e-02f,
  1.01149203e-02f, 5.76849207e-02f, -7.18886927e-02f, -3.48466784e-02f, -1.22489296e-02f, -1.89858787e-02f, -7.77712977e-03f, -8.41206685e-02f, -2.29988433e-02f, -1.41970562e-02f,
  -1.81538798e-02f, 3.32740061e-02f, -1.60675421e-02f, 2.49592122e-02f, 7.87659083e-03f, 5.48398159e-02f, 1.10885873e-02f, 6.70596166e-03f, -7.64889419e-02f, -2.84527354e-02f,
  -4.56198528e-02f, -8.86431634e-02f, 1.76282879e-02f, -7.51160504e-03f, 8.18961207e-03f, 6.61927275e-03f, -1.13094142e-02f, 7.68807679e-02f, -5.11483941e-03f, -4.31056134e-02f,
  -2.17163581e-02f, 1.45999240e-02f, 4.57737744e-02f, -1.29967695e-02f, 7.04675838e-02f, -2.78913113e-03f, 2.98740100e-02f, 4.14058715e-02f, -1.78617481e-02f, -6.31077439e-02f,
  -2.55335402e-02f, -1.15369469e-01f, 3.51725146e-02f, 6.53525144e-02f, -1.66212656e-02f, 4.82998788e-02f, 4.97934856e-02f, 6.91566337e-03f, -1.21943643e-02f, 1.88255478e-02f,
  1.25867790e-02f, -4.05774377e-02f, 3.44153643e-02f, -3.53547521e-02f, 2.60976925e-02f, 8.14490095e-02f, -3.94789986e-02f, -1.27193157e-03f, -3.74512300e-02f, -1.30085517e-02f,
  -7.41682500e-02f, -3.53018045e-02f, -1.09440293e-02f, 9.12016332e-02f, 7.53052859e-03f, 2.72802487e-02f, -1.86630934e-02f, -3.18495370e-02f, 3.71944788e-03f, -4.45357114e-02f,
  -1.61677040e-02f, 2.16340676e-01f, -1.76928565e-01f, -1.08438417e-01f, -1.96144417e-01f, 6.47476362e-03f, -9.08645466e-02f, -1.20788828e-01f, -3.21169645e-02f, 2.67944962e-01f,
  -7.00102895e-02f, 2.37533003e-01f, 8.59125331e-02f, -9.74381994e-03f, -7.38089383e-02f, 8.75836611e-02f, 4.69791405e-02f, 1.78928927e-01f, -2.61275768e-02f, -3.40264551e-02f,
  -5.28096966e-02f, -1.31569232e-03f, -1.15872055e-01f, -5.25141358e-02f, -5.35749495e-02f, 1.25971045e-02f, 8.11214820e-02f, -1.10553235e-01f, -1.45112835e-02f, 1.89085752e-02f,
  -9.49483663e-02f, 4.14709561e-02f, -5.63395256e-03f, 3.83631885e-02f, -5.11817299e-02f, 3.78376320e-02f, 4.13406864e-02f, 1.04478968e-03f, -2.00323183e-02f, -3.94934602e-02f,
  1.34509355e-01f, -1.93973240e-02f, -4.63955998e-02f, -1.59953590e-02f, -8.87795016e-02f, -1.78244635e-02f, -8.39280412e-02f, -5.59882820e-02f, 3.61992978e-02f, 3.21791065e-03f,
  -6.73858598e-02f, -5.07771596e-02f, -1.48133142e-02f, 4.62075546e-02f, -2.07052268e-02f, -6.36100397e-02f, 1.61955375e-02f, 5.09741008e-02f, 5.92283793e-02f, 3.64007391e-02f,
  1.29609117e-02f, 1.14467822e-03f, 2.27576494e-03f, -1.82707421e-02f, -6.71369862e-03f, -3.43252532e-02f, -1.87736023e-02f, 4.50498313e-02f, -4.84792888e-02f, 5.04839979e-02f,
  -3.07927281e-02f, -4.20466028e-02f, 2.23933347e-02f, -3.21831176e-04f, 3.03734606e-03f, 8.92624632e-02f, -1.99102275e-02f, 5.85485250e-02f, -1.77827496e-02f, -9.30969715e-02f,
  4.09621969e-02f, -1.18730934e-02f, -1.66452527e-02f, -2.65920535e-03f, 3.27451080e-02f, -5.77743053e-02f, 4.29451689e-02f, 4.97185737e-02f, 3.08885276e-02f, 8.09958205e-03f,
  1.15623111e-02f, 2.38620400e-01f, -5.45767918e-02f, 4.01114598e-02f, 3.25304307e-02f, 5.38362190e-02f, 1.73707046e-02f, 2.26546954e-02f, -3.07492428e-02f, 2.57151034e-02f,
  -2.16854401e-02f, -2.53160819e-02f, 4.29796390e-02f, -2.31714770e-02f, 2.08992511e-04f, 2.08868601e-04f, 5.49911857e-02f, 4.28500846e-02f, -3.34286578e-02f, 1.16261393e-02f,
  4.01235595e-02f, 1.03123970e-01f, 1.44648021e-02f, 2.54581850e-02f, 8.11676309e-02f, 2.02008802e-02f, 6.96070120e-02f, -4.43366319e-02f, 3.78771015e-02f, -7.29364390e-03f,
  2.88632698e-02f, -4.56486605e-02f, -8.64798203e-03f, -4.99920882e-02f, -9.77144465e-02f, 2.91306615e-01f, 2.76917875e-01f, -7.57820308e-02f, -6.55458272e-02f, -6.01881780e-02f,
  1.07901953e-01f, 1.41535271e-02f, 4.15067002e-02f, 6.40371740e-02f, 3.20693761e-01f, 1.55664027e-01f, 1.27396762e-01f, 1.08741179e-01f, -5.81531450e-02f, 6.39595650e-03f,
  -5.44368736e-02f, 1.33871004e-01f, 1.42602054e-02f, -1.19310699e-01f, -1.15213031e-02f, -4.67516892e-02f, 2.52232943e-02f, -1.44073544e-02f, -1.48762362e-02f, 4.55084071e-02f,
  7.97418132e-02f, -1.57439634e-01f, -1.62321050e-02f, 6.15681708e-02f, 7.84895048e-02f, 1.40310349e-02f, 7.58798122e-02f, 7.34132901e-02f, 1.25628579e-02f, -4.21103649e-02f,
  1.47623224e-02f, -4.00649793e-02f, 4.42080060e-03f, -7.19844401e-02f, -3.22535932e-02f, -8.29646662e-02f, -6.56770766e-02f, 1.97529551e-02f, 3.25951874e-02f, -5.64317182e-02f,
  -3.44494246e-02f, -1.91686116e-02f, -1.01414904e-01f, 8.28107595e-02f, 9.08114016e-03f, -4.96663712e-03f, -3.19410414e-02f, 1.72471628e-02f, 5.62406443e-02f, -3.20802368e-02f,
  -3.95855457e-02f, 5.66400252e-02f, -7.86861591e-03f, 5.01136892e-02f, 3.66927683e-02f, -1.69467237e-02f, 4.85684760e-02f, 3.27242538e-02f, -1.32150929e-02f, -2.95344964e-02f,
  4.54691723e-02f, 1.31752137e-02f, -3.99983861e-02f, -4.10344042e-02f, 6.90667778e-02f, -4.86296043e-02f, 6.18951470e-02f, -2.56883726e-02f, -4.44562882e-02f, -4.93683033e-02f,
  -5.12876548e-02f, 4.43418846e-02f, -6.78058108e-03f, 2.56802496e-02f, 5.71439974e-02f, 4.06541117e-02f, -5.47841713e-02f, 2.31685340e-02f, -3.98172764e-03f, -9.35715530e-03f,
  2.41705582e-01f, 1.43403038e-01f, 1.62838325e-02f, -5.54924458e-02f, 4.62171547e-02f, 6.66479208e-03f, 4.97618131e-02f, -4.17219475e-02f, 8.55033398e-02f, 8.83997828e-02f,
  2.81568002e-02f, 4.84938659e-02f, 4.39490825e-02f, 7.57496282e-02f, 2.80722184e-03f, 2.22804565e-02f, 4.56351936e-02f, -7.59666134e-03f, 1.12690143e-02f, 1.21312984e-03f,
  1.89271979e-02f, -1.58011355e-02f, -2.20015254e-02f, -6.83289394e-02f, -7.95904696e-02f, -4.44763787e-02f, -3.54695991e-02f, 2.15827990e-02f, -2.10918635e-02f, -2.99285650e-02f,
  1.58115283e-01f, 1.31432250e-01f, 3.06336850e-01f, 1.64574146e-01f, -3.03376820e-02f, 2.99673863e-02f, 6.62500635e-02f, 3.53107229e-02f, 3.92501801e-01f, -2.12321535e-01f,
  -1.44405767e-01f, 1.80537477e-01f, 5.65460101e-02f, -6.75696209e-02f, -4.91178930e-02f, 1.79806173e-01f, -1.01813331e-01f, 1.44837657e-02f, 1.91817462e-01f, -1.12931088e-01f,
  1.01142801e-01f, -2.56590039e-01f, 2.19736565e-02f, -1.61363304e-01f, -5.66443130e-02f, 4.97577786e-02f, -3.47586870e-01f, 1.39144175e-02f, -2.98208624e-01f, -7.33418614e-02f,
  6.54974878e-02f, 1.37506276e-01f, 3.46421823e-02f, 7.49063352e-03f, -2.24502496e-02f, -1.33563727e-01f, -8.43417794e-02f, -9.76908579e-03f, 8.17610249e-02f, 8.10050443e-02f,
  4.59338687e-02f, -4.61929813e-02f, -5.53255575e-03f, 3.66131552e-02f, 4.43252549e-03f, -9.95989237e-03f, 4.59979177e-02f, 9.45384521e-03f, 6.67572767e-02f, 6.64480776e-02f,
  9.59257483e-02f, 2.55974587e-02f, -4.05038744e-02f, -6.50746152e-02f, 7.86333829e-02f, 3.21938023e-02f, -3.07564950e-03f, -5.13283350e-02f, -4.50297929e-02f, -1.19954254e-03f,
  -2.80941464e-02f, -4.18987451e-03f, -4.62176315e-02f, -5.24197298e-04f, 4.93118167e-03f, 2.17274781e-02f, 1.60316955e-02f, -1.09200105e-02f, 1.20299766e-02f, 2.06244700e-02f,
  -2.94664931e-02f, -2.77733686e-03f, 7.92761426e-03f, 5.16671874e-02f, -7.16697332e-03f, -1.93468239e-02f, -5.39728776e-02f, 3.08869239e-02f, 1.88709854e-03f, 3.92843634e-02f,
  -1.34258708e-02f, -3.91724799e-03f, 3.45720798e-02f, -6.13846863e-03f, -3.54083558e-03f, -1.05390223e-02f, -1.57030281e-02f, 4.84177023e-02f, 6.16877638e-02f, -3.04900538e-02f,
  -6.32833019e-02f, -1.58273175e-01f, 2.21509337e-02f, 8.26625302e-02f, 1.81456283e-02f, -9.30716190e-03f, 2.98887230e-02f, -3.92071120e-02f, 3.07136960e-02f, -3.61138396e-02f,
  -1.18242092e-01f, 1.40796667e-02f, -4.99342568e-02f, -3.15155052e-02f, 1.89057160e-02f, -1.58089306e-02f, -3.68458927e-02f, -1.63047668e-02f, -6.76384196e-02f, -4.32677865e-02f,
  -9.72437561e-02f, 2.24891193e-02f, 1.96351651e-02f, -1.74592342e-02f, -1.00825556e-01f, -7.16868192e-02f, 6.59587607e-03f, 6.14049993e-02f, -3.14752012e-02f, 1.86336543e-02f,
  -8.01706687e-02f, 2.67882854e-01f, 1.63747534e-01f, 1.75699189e-01f, -2.43995130e-01f, -3.14858198e-01f, -1.15828931e-01f, 3.00701801e-02f, 2.19057873e-01f, -1.04478085e-02f,
  -5.89613318e-02f, 1.74606964e-01f, 1.34755978e-02f, 1.29326463e-01f, -3.02339625e-02f, 6.42697439e-02f, 6.67325631e-02f, 7.56391976e-03f, 9.80192795e-02f, 7.28230253e-02f,
  3.41351796e-03f, -1.61956288e-02f, 1.15207657e-01f, -3.66304666e-02f, -7.98239484e-02f, 1.68828070e-01f, 7.12228045e-02f, -1.90801695e-02f, -2.23517441e-03f, -7.23687857e-02f,
  -8.53216648e-02f, 1.41563296e-01f, 5.62887080e-02f, 4.38972116e-02f, -1.43775977e-02f, -8.51243809e-02f, -2.13125013e-02f, -4.64104116e-02f, -2.92674429e-03f, 7.25214258e-02f,
  -1.75923724e-02f, -2.72146892e-02f, 6.54831007e-02f, -1.93103906e-02f, -4.59087230e-02f, 6.41640928e-03f, 3.34757231e-02f, 2.49134153e-02f, 1.80135090e-02f, -8.80339518e-02f,
  -2.30923435e-03f, -4.57602665e-02f, -4.73978296e-02f, 1.29900321e-01f, 4.46902066e-02f, 9.69664007e-02f, 4.06048298e-02f, 3.63279618e-02f, 1.85934566e-02f, 3.34928073e-02f,
  1.29529592e-02f, -2.59074159e-02f, -1.85322470e-03f, 4.66095842e-02f, -7.61055434e-03f, 2.37663426e-02f, -4.42295745e-02f, -2.56538708e-02f, 5.42403981e-02f, -4.68081534e-02f,
  2.85978299e-02f, 3.89792286e-02f, 6.39487877e-02f, -1.49570443e-02f, -2.13704985e-02f, 5.51538095e-02f, -1.56162819e-02f, 3.19885127e-02f, 2.44932226e-03f, 5.49755841e-02f,
  3.87643091e-02f, -3.67514156e-02f, -7.04311393e-03f, -4.61490452e-02f, -3.55394855e-02f, 2.77796816e-02f, 8.00728276e-02f, 1.84721053e-02f, -1.89402178e-02f, -6.12867437e-02f,
  4.05147187e-02f, 1.73399210e-01f, 3.00398543e-02f, 5.28149446e-03f, 2.36762371e-02f, -6.53477311e-02f, 6.36017695e-02f, 5.73748956e-03f, 9.08546522e-02f, 2.19368692e-02f,
  -8.53862166e-02f, 1.61408987e-02f, 1.96865406e-02f, -4.09476124e-02f, 2.99744103e-02f, -4.23711771e-03f, -1.72941771e-03f, 2.32747830e-02f, -1.12334285e-02f, -3.29305902e-02f,
  5.47947502e-03f, 1.61210839e-02f, 7.46347755e-03f, -2.57004406e-02f, -3.09212450e-02f, -6.51846826e-02f, -6.12951107e-02f, 2.73152329e-02f, -1.22091314e-02f, -1.21298870e-02f,
  4.30145323e-01f, 8.79008847e-04f, 6.02296516e-02f, 2.08580747e-01f, 1.36507884e-01f, -7.44028250e-03f, -1.42253697e-01f, 4.80468534e-02f, 3.22729461e-02f, -7.85386413e-02f,
  6.75064921e-02f, 4.32858393e-02f, -2.80229211e-01f, 9.06582177e-02f, -3.20253037e-02f, -2.41101295e-01f, 1.75333828e-01f, -3.92591581e-02f, 5.67562655e-02f, 1.47563785e-01f,
  1.70967296e-01f, 6.99021295e-02f, -5.40069863e-03f, 3.43108922e-02f, 1.99678302e-01f, 8.11105445e-02f, 1.87285453e-01f, -2.09554695e-02f, 1.34433284e-01f, -8.14669132e-02f,
  -1.08674407e-01f, -1.40998606e-02f, 8.37726668e-02f, -1.95167735e-02f, 1.07714096e-02f, 7.24778920e-02f, 2.49361582e-02f, -9.43542048e-02f, 8.37981626e-02f, -3.24930288e-02f,
  -5.08046821e-02f, -1.63773466e-02f, 5.35304435e-02f, -6.31834045e-02f, 7.11493269e-02f, -3.31157749e-03f, 3.53385285e-02f, 1.05508633e-01f, 9.19072852e-02f, -2.66843550e-02f,
  8.13978091e-02f, 2.03361064e-02f, 3.45666967e-02f, 3.24472226e-02f, 6.79948181e-02f, 2.19573490e-02f, 2.70280633e-02f, -2.41577253e-02f, 6.79384843e-02f, 7.77483284e-02f,
  4.80608493e-02f, 7.78334273e-04f, -4.67727073e-02f, -1.83884166e-02f, 3.53343226e-02f, 2.86947796e-03f, 2.41662506e-02f, -6.04614541e-02f, 1.22369625e-01f, -4.03975882e-02f,
  3.08801550e-02f, 7.96005577e-02f, -3.42643857e-02f, 3.26493196e-02f, 1.16539374e-01f, -3.16911526e-02f, 2.89516207e-02f, -2.47198269e-02f, 1.07115977e-01f, -9.86418780e-03f,
  -4.65672128e-02f, -3.10380943e-02f, -6.32934719e-02f, -3.30378376e-02f, -6.42947331e-02f, -1.04533264e-03f, 5.52027114e-02f, -2.74967495e-02f, -6.66934177e-02f, 1.34663181e-02f,
  6.39424250e-02f, 1.50248647e-01f, -7.26486593e-02f, -4.22664359e-02f, -4.66786139e-02f, 2.18627267e-02f, -6.54963553e-02f, 2.73654088e-02f, -3.58637348e-02f, 2.10925601e-02f,
  9.21457037e-02f, 5.32871746e-02f, -9.07164440e-03f, 8.38987529e-02f, -6.26703575e-02f, 8.09803158e-02f, -3.09586674e-02f, -8.28482863e-03f, 5.98652754e-03f, 6.11524507e-02f,
  4.83286940e-02f, -7.85899609e-02f, 3.47798727e-02f, 7.72511587e-02f, 3.69432010e-02f, -5.77856461e-03f, 3.06291450e-02f, 6.52342215e-02f, 2.40651947e-02f, 5.50093036e-03f,
  -3.38209122e-01f, 1.61066443e-01f, 1.24310873e-01f, -1.82541832e-01f, 4.53897379e-02f, -1.17430583e-01f, -9.49438140e-02f, -4.59083430e-02f, -2.19282001e-01f, -5.77634685e-02f,
  -2.22172633e-01f, 1.34079084e-01f, -2.38139480e-02f, -1.93709508e-01f, -3.37762952e-01f, -8.93056616e-02f, -3.54267746e-01f, -4.37323041e-02f, -1.14132345e-01f, 3.47755961e-02f,
  -1.32626235e-01f, -2.29077727e-01f, -7.39910081e-02f, 1.59043670e-02f, 3.27971689e-02f, 5.22570685e-02f, -1.08767524e-01f, 1.50553256e-01f, 1.89145226e-02f, 9.17417184e-02f,
  3.25274952e-02f, 1.24923483e-01f, 5.05000837e-02f, 1.31880432e-01f, 4.22547832e-02f, 2.97900774e-02f, 1.70795768e-02f, 9.28162932e-02f, 4.29898389e-02f, -2.51243487e-02f,
  7.94470236e-02f, 4.72490229e-02f, -3.23507302e-02f, -3.30688693e-02f, -3.26259844e-02f, 1.65738314e-02f, 5.66199236e-02f, -7.58658955e-03f, 1.02069033e-02f, 1.46319820e-02f,
  5.90401739e-02f, -1.66589096e-02f, -4.37135473e-02f, -2.69620214e-03f, 6.00253372e-03f, -3.63624021e-02f, -7.71679869e-03f, 7.52218515e-02f, 5.19555586e-04f, -6.59957156e-02f,
  -4.42469455e-02f, -1.13529377e-02f, 1.94357354e-02f, 2.87687848e-03f, 6.20385893e-02f, -8.23533442e-03f, -7.86277577e-02f, -4.48433906e-02f, 2.92468984e-02f, 5.83897997e-03f,
  -4.78673689e-02f, 9.57620051e-03f, -5.07536605e-02f, -2.19380446e-02f, -1.17726959e-02f, 3.35173979e-02f, 2.02395599e-02f, 2.29603499e-02f, -5.24619706e-02f, -2.60519069e-02f,
  -5.29126674e-02f, -8.08041732e-05f, 1.18148513e-02f, 4.60363925e-03f, -5.72467856e-02f, 1.13427604e-03f, -8.06277096e-02f, -2.54948088e-03f, -5.11453561e-02f, 6.44278340e-03f,
  -3.63220274e-02f, -1.46229893e-01f, -4.97936681e-02f, 1.09903887e-03f, -4.54702154e-02f, 6.02264628e-02f, -1.14388876e-02f, -7.54695237e-02f, 3.32136117e-02f, 1.15697924e-02f,
  2.15470586e-02f, -3.10152862e-02f, 2.61088181e-02f, 4.54275608e-02f, -1.23267192e-02f, -6.55979887e-02f, -5.26155718e-02f, 7.29215611e-03f, -4.07269672e-02f, -3.00587900e-02f,
  8.09266604e-03f, 4.14409824e-02f, -5.70523366e-03f, -2.15584040e-02f, -1.11723188e-02f, -3.30487732e-03f, 2.11382546e-02f, 3.17476280e-02f, -2.74889376e-02f, 7.74645340e-03f,
  -5.20598650e-01f, -3.68574038e-02f, -1.13734312e-01f, -3.03548843e-01f, -1.84152931e-01f, 4.55082580e-03f, -1.19942270e-01f, -1.79894969e-01f, -1.48540616e-01f, 1.57752596e-02f,
  3.93435396e-02f, -2.39938647e-02f, 9.97816399e-02f, -1.08766416e-02f, -1.23343043e-01f, 1.83086514e-01f, -1.35499701e-01f, -1.09397331e-02f, 3.61128822e-02f, -2.65707850e-01f,
  -1.70433328e-01f, -1.02953516e-01f, -3.46655883e-02f, 2.35154070e-02f, -1.02057882e-01f, -9.70920771e-02f, -9.65646654e-02f, 5.79210408e-02f, -3.99662368e-03f, 2.52973475e-02f,
  -9.01267678e-02f, -9.61596072e-02f, 7.07693025e-02f, 4.65196893e-02f, -7.08712041e-02f, 7.16445670e-02f, -8.66121892e-03f, 1.10240787e-01f, -2.38223616e-02f, -2.91861445e-02f,
  3.83203034e-03f, -5.98547831e-02f, -1.03163365e-02f, -1.19662052e-02f, -6.07109293e-02f, 5.02103157e-02f, -2.70598307e-02f, 1.00379689e-02f, 5.52454740e-02f, 1.49317803e-02f,
  1.01207629e-01f, -1.02466689e-02f, -5.17712012e-02f, 5.25851771e-02f, 2.86731403e-02f, 3.72392833e-02f, 3.62052163e-03f, -1.61073264e-02f, -4.94909585e-02f, -7.13311434e-02f,
  2.91143693e-02f, -3.10161021e-02f, -9.25771147e-03f, 2.57086940e-02f, 2.14910936e-02f, -3.54406908e-02f, 3.82040367e-02f, 3.72131839e-02f, 4.09024917e-02f, -1.89462435e-02f,
  -7.69147724e-02f, -2.16310844e-02f, 2.06203759e-02f, 1.52263800e-02f, 2.40058103e-03f, -3.68225761e-02f, 4.26101033e-03f, -1.41266463e-02f, -7.34300613e-02f, -2.14809459e-02f,
  4.15996797e-02f, -3.93911236e-04f, -1.77823976e-02f, 7.81308208e-03f, 7.04881176e-02f, 2.21024305e-02f, 3.23206116e-03f, -1.56296045e-02f, 1.15297986e-02f, -7.53724203e-03f,
  -1.92261189e-01f, -2.23199159e-01f, -2.23493185e-02f, 2.42252629e-02f, 4.79111895e-02f, 5.04567707e-03f, 3.48360674e-03f, 2.55061444e-02f, -4.26337793e-02f, -3.31120640e-02f,
  -4.67728730e-03f, -4.51489206e-04f, -2.91849934e-02f, -2.40370966e-02f, 2.37320419e-02f, -3.29333618e-02f, -6.80891350e-02f, -4.21031602e-02f, -6.48258403e-02f, 3.89012462e-03f,
  3.78025435e-02f, -4.30122092e-02f, 4.45469581e-02f, -6.16875328e-02f, -3.03449538e-02f, -1.29685774e-02f, -7.43814111e-02f, 8.46383944e-02f, 5.93509786e-02f, -1.06254104e-03f,
  -4.98657554e-01f, 1.80942804e-01f, -1.29138544e-01f, 1.11269280e-01f, -3.61879840e-02f, 1.11797728e-01f, 2.23113541e-02f, 2.08753258e-01f, 5.77418581e-02f, 2.66817898e-01f,
  1.23333715e-01f, -1.31988466e-01f, 9.73303840e-02f, 2.42036879e-01f, -1.96533158e-01f, 9.99130085e-02f, 1.13869712e-01f, 1.33728078e-02f, 1.29372133e-02f, 1.28896475e-01f,
  2.67571472e-02f, 2.11418048e-01f, -1.45090837e-02f, 1.88752875e-01f, 7.84974825e-03f, -2.98670549e-02f, 7.48525411e-02f, -3.12959664e-02f, 1.34178832e-01f, -4.01092060e-02f,
  -1.65082943e-02f, 2.27937605e-02f, -4.89545986e-02f, 8.72059260e-03f, -3.16598937e-02f, -3.96882929e-02f, 6.30617440e-02f, -2.38193199e-02f, -2.60063764e-02f, -3.39626558e-02f,
  -5.80140837e-02f, 2.06913538e-02f, 6.55945614e-02f, -1.92035101e-02f, 2.03668866e-02f, 3.90486792e-03f, -3.88397053e-02f, 6.40613958e-02f, 1.26090515e-02f, -4.32861177e-03f,
  -3.52504402e-02f, 1.22788800e-02f, -1.71244740e-02f, 9.12763774e-02f, -2.12450530e-02f, -1.82365738e-02f, 4.36136150e-04f, -8.13357532e-02f, 3.05777811e-03f, 1.50645347e-02f,
  -4.60217595e-02f, -1.47616370e-02f, 5.40176779e-02f, 5.98364556e-03f, 6.17400277e-03f, 2.97888648e-02f, 7.33812451e-02f, 2.13474222e-02f, -4.23758179e-02f, 3.37446034e-02f,
  2.69375555e-02f, 7.41714193e-03f, 3.85799408e-02f, -1.23393899e-02f, 7.94546381e-02f, -1.08449887e-02f, -5.01198769e-02f, 3.70645449e-02f, 1.43270865e-02f, 1.75771734e-03f,
  1.91870180e-03f, -2.28916132e-03f, 8.52607191e-03f, -1.23310518e-02f, 2.51819864e-02f, -4.41432968e-02f, 4.19298187e-02f, -3.49006951e-02f, 8.99913721e-03f, -6.47633597e-02f,
  1.43448472e-01f, 2.52385378e-01f, 2.49648951e-02f, 4.20480296e-02f, 2.06093136e-02f, -1.31791197e-02f, -1.61471143e-02f, -6.04657605e-02f, 1.11008650e-02f, 6.02940954e-02f,
  -4.81637232e-02f, 5.32769784e-03f, -5.46683893e-02f, -3.94195644e-03f, 3.26575316e-03f, 5.93289509e-02f, 5.81055693e-02f, 5.61236516e-02f, 2.77229734e-02f, 5.60216047e-03f,
  8.02386552e-02f, 9.18360334e-03f, 5.32778096e-04f, -3.23665328e-02f, 3.44893634e-02f, -9.33356676e-03f, 2.80737542e-02f, -3.53075825e-02f, -1.44269457e-02f, -9.32572875e-03f,
  3.02648157e-01f, 5.27940243e-02f, 1.73267439e-01f, -4.29907069e-03f, -3.15034688e-02f, -3.92451100e-02f, 6.93094656e-02f, 7.24903569e-02f, 3.12809467e-01f, -4.67202952e-03f,
  -1.76167071e-01f, 5.40325865e-02f, 7.47831315e-02f, -1.88906729e-01f, -1.27067685e-01f, 5.14379330e-02f, -4.37728092e-02f, -3.90610308e-03f, 2.27155909e-02f, 9.49030519e-02f,
  2.93456148e-02f, -1.45158753e-01f, -1.80241331e-01f, -1.53088063e-01f, -3.22993170e-03f, 3.38462517e-02f, -2.46903226e-01f, -6.29377887e-02f, -1.99052289e-01f, -5.59734218e-02f,
  -1.00793555e-01f, 1.12482265e-01f, 3.01861558e-02f, 2.45417543e-02f, -2.64637135e-02f, -2.49175578e-02f, -1.02365717e-01f, -4.10964936e-02f, -3.28448638e-02f, 7.28478208e-02f,
  -4.11694460e-02f, -5.06479386e-03f, 2.77429931e-02f, -7.41632059e-02f, 1.18647777e-02f, -1.45059675e-02f, 1.08300149e-03f, 2.98287682e-02f, 3.92519310e-02f, 1.40423402e-02f,
  2.30415426e-02f, 3.96455936e-02f, -8.47539213e-03f, -5.59426993e-02f, -5.93182724e-03f, -4.50204313e-02f, 9.67461709e-03f, -3.89627106e-02f, 4.23622467e-02f, 6.88629374e-02f,
  2.06319820e-02f, 3.72292064e-02f, 6.63725212e-02f, 1.10652847e-02f, 1.63265206e-02f, 2.13944120e-03f, -8.45727921e-02f, 5.55815699e-04f, -3.33262868e-02f, -4.58196104e-02f,
  -2.85735074e-02f, 1.55059090e-02f, -2.30996385e-02f, -3.22122648e-02f, -2.16483641e-02f, 3.55522856e-02f, 1.67851038e-02f, -8.73665288e-02f, 4.68502529e-02f, -7.66735524e-02f,
  -5.34414388e-02f, -1.19064087e-02f, -1.79343275e-03f, -1.03636803e-02f, 4.41810489e-02f, 1.25520881e-02f, 9.45973583e-03f, 3.85427312e-03f, 2.38658758e-04f, 3.10104769e-02f,
  3.48247401e-03f, -7.41721084e-03f, 1.42981000e-02f, 1.79224145e-02f, -3.93570475e-02f, -6.30887002e-02f, 5.66626117e-02f, 4.37246896e-02f, 4.33444185e-03f, 1.07757887e-02f,
  2.46637035e-02f, 3.72802257e-03f, -3.51029560e-02f, -2.71835551e-03f, 5.32912882e-03f, 3.27357613e-02f, -5.63468300e-02f, -5.41888662e-02f, -4.45321314e-02f, -5.87785058e-02f,
  2.59317197e-02f, -7.51838461e-02f, 7.42593408e-02f, 5.51963001e-02f, 1.66424066e-02f, 6.75719697e-03f, -4.06081378e-02f, -7.98196997e-03f, 2.83254334e-03f, -4.72757258e-02f,
  -8.69711488e-02f, -8.85823965e-02f, 1.07319184e-01f, -2.66436249e-01f, 2.47090653e-01f, 1.08269647e-01f, -1.59828156e-01f, 9.09561813e-02f, 2.58071460e-02f, -1.16233535e-01f,
  -1.38311565e-01f, -3.52103412e-02f, 1.96861643e-02f, -2.17731953e-01f, -1.71983823e-01f, 1.23296678e-02f, -3.08919132e-01f, -1.51984841e-01f, 1.53949350e-01f, -7.35076964e-02f,
  2.97955442e-02f, -1.22508883e-01f, -1.14799008e-01f, 1.25348017e-01f, 6.72663003e-03f, 8.20915997e-02f, -2.18539402e-01f, 2.04005897e-01f, -1.11980431e-01f, 4.46179928e-03f,
  -7.36219436e-02f, -8.96944478e-02f, 2.18136911e-03f, 3.08426581e-02f, -8.09034407e-02f, -3.26104350e-02f, 4.90660258e-02f, 5.79655431e-02f, -5.94324097e-02f, 2.00273693e-02f,
  -1.33513229e-03f, 6.49578869e-02f, -3.38634811e-02f, 1.21188328e-01f, 9.94902775e-02f, 3.78599614e-02f, 8.70250985e-02f, -3.47086298e-03f, 2.26925761e-02f, 1.23501115e-01f,
  -4.38995026e-02f, 3.26268263e-02f, -9.33452249e-02f, 1.65737271e-02f, -8.43104348e-03f, -5.66232810e-03f, 2.49708984e-02f, 4.09647785e-02f, 5.26028797e-02f, 7.11931894e-03f,
  6.14902712e-02f, -2.18706969e-02f, -4.13215496e-02f, 3.19769569e-02f, -3.23874578e-02f, -3.03041935e-02f, -1.02396775e-02f, 1.20055687e-03f, -4.21075672e-02f, 1.41570177e-02f,
  -2.22064462e-02f, -1.97842140e-02f, 6.35593310e-02f, -1.74279921e-02f, -2.87604891e-02f, -3.43181901e-02f, -5.59675992e-02f, 1.99373253e-02f, -1.54042058e-02f, -5.17166965e-02f,
  1.88106002e-04f, -5.25838919e-02f, -4.24612761e-02f, -2.16783211e-02f, -8.19454528e-03f, 6.32892922e-02f, 6.14583977e-02f, 7.65682235e-02f, 3.85511294e-02f, 1.78953018e-02f,
  -1.76015258e-01f, -1.87150851e-01f, -7.45628998e-02f, -8.89457576e-03f, 1.40322782e-02f, -3.62018459e-02f, -8.20641965e-02f, 1.49327945e-02f, -2.59336904e-02f, 5.95506243e-02f,
  8.30183327e-02f, -2.73961443e-02f, -3.61955613e-02f, -6.91488832e-02f, -8.31731185e-02f, -1.54853547e-02f, -1.39897406e-01f, -5.36865480e-02f, -9.58385989e-02f, 1.65555428e-03f,
  3.12334578e-02f, 3.75470668e-02f, -4.04278468e-03f, -5.59751019e-02f, -4.26159278e-02f, -5.85284159e-02f, -2.27571409e-02f, -1.67702809e-02f, 2.63062883e-02f, 1.73289590e-02f,
  2.49713287e-01f, -9.67305452e-02f, -8.59246328e-02f, -6.07180186e-02f, 1.66825160e-01f, 2.18355030e-01f, -6.76654205e-02f, 1.25101179e-01f, 7.03482777e-02f, -7.61964396e-02f,
  -2.88252011e-02f, -1.41819136e-03f, -2.94430643e-01f, -4.75163125e-02f, -2.33904719e-02f, -2.27084741e-01f, 5.93844689e-02f, -2.67557986e-02f, 3.02146487e-02f, 1.57909654e-02f,
  -2.67981663e-02f, -3.58754620e-02f, -1.05679639e-01f, 1.22198321e-01f, -3.91907729e-02f, 5.23304045e-02f, -7.46917129e-02f, -8.81249383e-02f, -2.54201740e-02f, -8.17533582e-02f,
  1.03596687e-01f, -8.84813294e-02f, -2.38291342e-02f, -5.13024405e-02f, 7.66679943e-02f, 8.91474336e-02f, -5.82375638e-02f, -5.89506067e-02f, -9.48400237e-03f, -4.67296839e-02f,
  1.15739191e-02f, -3.52115147e-02f, 2.84622498e-02f, -5.03518283e-02f, 3.39941792e-02f, 2.82125510e-02f, 1.28144249e-02f, 3.42143513e-02f, -3.13194096e-02f, -1.37492958e-02f,
  4.61588133e-05f, 1.92994773e-02f, 5.67911193e-02f, 3.43428738e-02f, 7.32997656e-02f, 8.26960336e-03f, -3.23046893e-02f, -4.43586633e-02f, 3.21966372e-02f, 6.16386486e-03f,
  3.62065956e-02f, 2.06807405e-02f, 3.25432457e-02f, 7.27008805e-02f, 1.85209047e-03f, 6.19193688e-02f, -2.63562407e-02f, 2.99837813e-02f, 5.70786931e-03f, 1.99488886e-02f,
  9.79584875e-04f, 6.00406453e-02f, 5.51103102e-03f, 3.01820673e-02f, 1.36315059e-02f, 6.32861927e-02f, -6.45593368e-03f, -4.70707491e-02f, -3.54006737e-02f, 7.75995897e-03f,
  -4.04171608e-02f, 2.27263267e-03f, -2.59629451e-02f, 3.92358825e-02f, 3.37143093e-02f, -1.52200107e-02f, 2.95943022e-02f, 4.28577997e-02f, 8.10075644e-03f, -3.81034836e-02f,
  -3.16558010e-03f, -2.28740275e-01f, 2.66076326e-02f, 2.11255960e-02f, -9.83250216e-02f, 6.28376529e-02f, 6.07321821e-02f, 2.60772426e-02f, -3.09705753e-02f, -1.85107663e-02f,
  4.67533246e-02f, 5.81189692e-02f, 8.02432559e-03f, 3.24465781e-02f, -7.64050055e-03f, -4.24670465e-02f, -3.66593823e-02f, -1.15598366e-02f, 2.49052010e-02f, 3.05135269e-02f,
  -3.85961914e-03f, 5.43969534e-02f, -1.56733934e-02f, -3.24304402e-02f, -2.24014744e-02f, 1.73158702e-02f, 5.86508624e-02f, -4.16989625e-02f, -4.94217612e-02f, -5.17493039e-02f,
  4.18997824e-01f, -1.82809725e-01f, -8.70188922e-02f, 1.06639549e-01f, -2.01945470e-04f, 7.47578591e-02f, 1.42036781e-01f, -1.27356470e-01f, 3.20669025e-01f, -2.00858220e-01f,
  -8.61998647e-02f, 1.15311801e-01f, -1.15841962e-01f, -7.53245726e-02f, 3.32745135e-01f, 1.19434275e-01f, 5.79449674e-03f, -4.13032584e-02f, 1.13957457e-01f, -1.25830233e-01f,
  3.96565460e-02f, -8.35108683e-02f, -8.23836699e-02f, -2.37069130e-01f, -3.03672738e-02f, -5.90374507e-02f, -9.47614610e-02f, -5.73205166e-02f, -1.27468035e-01f, -1.48091372e-02f,
  3.58996540e-02f, -2.90897787e-02f, -8.73490721e-02f, 3.74866389e-02f, -4.47688289e-02f, -5.57154417e-02f, 3.85510316e-03f, 8.21247771e-02f, -7.60296453e-03f, 1.30470898e-02f,
  4.53990847e-02f, 1.67460367e-02f, 5.87710477e-02f, 1.48989568e-02f, 1.05605200e-02f, -1.05848880e-02f, -4.65145223e-02f, 4.20132698e-03f, -7.80585036e-02f, -1.78591609e-02f,
  -2.71847215e-03f, -1.98910013e-03f, -6.30581602e-02f, 2.76041068e-02f, -3.45362648e-02f, -8.10774043e-03f, 3.54374424e-02f, 3.39598535e-03f, -1.93931069e-02f, 4.25394028e-02f,
  -6.46709725e-02f, 2.75597274e-02f, -1.84557829e-02f, -2.15379205e-02f, -2.82366760e-02f, -8.02629739e-02f, -1.85304675e-02f, -2.44455114e-02f, 5.73446900e-02f, -1.07846940e-02f,
  -1.36020705e-02f, -4.02322263e-02f, 1.16455518e-02f, 2.61099078e-02f, -5.01015298e-02f, -1.65856890e-02f, 2.88530160e-02f, -5.69082759e-02f, 1.95301231e-02f, -2.78274668e-03f,
  5.37948646e-02f, 4.43504192e-02f, -7.66110867e-02f, -6.27759621e-02f, 1.92661602e-02f, -2.54363436e-02f, -2.65378058e-02f, -6.42148256e-02f, -3.58364061e-02f, -4.97065634e-02f,
  -7.82606751e-02f, -4.90220189e-02f, 2.26178151e-02f, -4.41113450e-02f, -1.80450268e-02f, 2.54523437e-02f, 2.37438586e-02f, -3.41293886e-02f, -3.51683572e-02f, 3.16287987e-02f,
  -6.05350882e-02f, -5.35151549e-02f, 7.10691977e-03f, 1.85150057e-02f, 6.21944144e-02f, 1.04955481e-02f, -5.52922674e-03f, 1.05226217e-02f, 4.80697230e-02f, -6.16327040e-02f,
  -2.81706844e-02f, 9.37737431e-03f, 5.56727834e-02f, 3.28101516e-02f, -1.89475194e-02f, -6.66511152e-03f, 4.30590659e-02f, -2.84150615e-02f, -4.47355397e-02f, 1.68637820e-02f,
  -1.58793896e-01f, 3.61694694e-02f, -2.16108635e-01f, -2.06382632e-01f, -1.39848366e-01f, 2.68878102e-01f, 1.90670758e-01f, -9.90811512e-02f, -7.17520118e-02f, 2.77911544e-01f,
  5.08344769e-02f, -1.43180341e-01f, 8.25434700e-02f, 3.41148265e-02f, -5.65981343e-02f, 1.71572953e-01f, 1.41843155e-01f, 9.00243297e-02f, -7.99849555e-02f, 3.32589522e-02f,
  -1.48585334e-01f, 1.11323081e-01f, -1.85185298e-01f, -8.85863900e-02f, -8.37460682e-02f, -2.36576572e-01f, -9.58549455e-02f, -9.64099094e-02f, -1.03297442e-01f, -1.12325370e-01f,
  8.61526132e-02f, 5.05159497e-02f, -8.99336636e-02f, -6.24571601e-03f, 5.62505387e-02f, -3.01039722e-02f, -5.41425217e-03f, -5.20339534e-02f, -9.52082276e-02f, -7.75875640e-04f,
  8.82239565e-02f, -5.52087799e-02f, -3.28330286e-02f, 3.09907757e-02f, 2.86923144e-02f, -6.39604107e-02f, -6.34679347e-02f, -5.51737286e-02f, -1.25222445e-01f, -1.86584704e-02f,
  -2.80080531e-02f, 3.59833799e-02f, -1.20391566e-02f, 7.55584314e-02f, -1.03295892e-01f, -2.21017835e-04f, 5.87472655e-02f, -7.15687871e-02f, 2.74315812e-02f, 3.41501236e-02f,
  1.09399058e-01f, -7.56192859e-03f, 4.44880277e-02f, -3.72501500e-02f, -1.20576983e-02f, -4.79843840e-02f, 3.93358320e-02f, 4.04438525e-02f, 9.37259849e-03f, 8.80023837e-02f,
  3.18433857e-04f, -6.92874119e-02f, 2.92672999e-02f, -1.68981997e-03f, -2.65743379e-02f, -1.37178060e-02f, -8.43796227e-03f, -3.67902145e-02f, -7.63205485e-03f, -3.17684896e-02f,
  4.32853289e-02f, 2.42502764e-02f, 1.41556682e-02f, 4.46099713e-02f, -9.04888287e-03f, 1.95790585e-02f, 3.89109813e-02f, -3.76783013e-02f, -2.31252685e-02f, 1.70206651e-02f,
  1.23217955e-01f, 2.19034269e-01f, -3.83150280e-02f, -5.36014326e-02f, 1.74965728e-02f, 5.34223802e-02f, 3.22629325e-02f, -1.98678598e-02f, 1.14249133e-01f, 3.22267041e-02f,
  -2.22818032e-02f, 1.84112713e-02f, 3.86192091e-02f, -3.02786063e-02f, -1.30457142e-02f, 5.33353351e-02f, 4.74655628e-03f, -5.38698107e-04f, 5.97814769e-02f, 3.52965705e-02f,
  6.74102157e-02f, 4.49104868e-02f, -4.59811054e-02f, -1.17135540e-01f, -2.44813431e-02f, 7.14753121e-02f, -2.03787889e-02f, 3.03208567e-02f, 3.56342085e-02f, 2.83173956e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.80162236e-01f, 1.35476440e-01f, -1.37759134e-01f, 3.67281176e-02f, 1.66273162e-01f, 1.72969535e-01f, 6.53379261e-02f, 1.59172919e-02f, 7.34408349e-02f, 1.09932154e-01f,
  5.65911643e-02f, -8.51117671e-02f, -8.19912329e-02f, -7.23852590e-02f, -4.16371897e-02f, 1.60355028e-02f, 8.31734762e-03f, 5.15459850e-02f, 8.90558437e-02f, -3.56191350e-03f,
  -8.19757953e-02f, -9.97391269e-02f, -1.09325275e-01f, -5.63040823e-02f, 3.95794995e-02f, 9.49858595e-03f, -5.76541480e-03f, -9.90444496e-02f, -6.29241765e-02f, 2.42264997e-02f,
  3.87754920e-03f, 1.56107582e-02f, -3.97960171e-02f, -7.17206523e-02f, 7.56309256e-02f, 3.75055596e-02f, -6.49843439e-02f, -6.33566082e-02f, 3.52086197e-03f, 9.38621238e-02f,
  -1.47533007e-02f, 2.69673746e-02f, -1.43523403e-02f, -5.76175936e-02f, 4.99245562e-02f, -4.23535220e-02f, -7.44332448e-02f, -2.80453824e-03f, 6.01247791e-03f, -7.23631606e-02f,
  1.90301072e-02f, -1.53790163e-02f, 6.23473004e-02f, 5.11442451e-03f, -2.56739091e-02f, 1.68392397e-02f, 4.63160947e-02f, -2.77043376e-02f, 7.16717541e-02f, -2.95553040e-02f,
  -3.07510346e-02f, 6.12499416e-02f, -2.33556498e-02f, -6.45397082e-02f, 8.85598138e-02f, -5.43401688e-02f, 1.70669854e-02f, -6.27334416e-02f, -6.47480227e-03f, -8.35481808e-02f,
  5.42000271e-02f, 3.62038016e-02f, -9.08627454e-03f, 5.27008995e-02f, 4.38379757e-02f, -4.12241518e-02f, -8.41222480e-02f, 2.01088134e-02f, 1.69871456e-03f, -6.44282103e-02f,
  -4.54328433e-02f, -1.75824724e-02f, -7.12719634e-02f, 5.14083020e-02f, -4.85908762e-02f, -3.92087922e-02f, 4.51452434e-02f, -6.54355735e-02f, 8.89217388e-03f, 4.99263033e-02f,
  1.12947434e-01f, 1.89385936e-01f, -4.40876409e-02f, 3.93259041e-02f, 3.75322858e-03f, -9.32493806e-03f, -3.33539471e-02f, -3.12183462e-02f, 9.68450904e-02f, 8.11488479e-02f,
  9.52801108e-02f, 4.91599031e-02f, -3.21343839e-02f, 9.72220488e-03f, 5.91921387e-03f, 2.78908219e-02f, 8.26954767e-02f, 4.67974655e-02f, 6.33255243e-02f, -7.77854398e-02f,
  -9.16069448e-02f, 5.81393316e-02f, 8.35036114e-02f, 7.47238891e-03f, 8.88182372e-02f, 6.33973852e-02f, -5.00160418e-02f, -1.45435371e-02f, -3.58607918e-02f, 4.02929597e-02f,
  1.73984736e-01f, -2.56541222e-01f, -1.97058216e-01f, -6.09992631e-02f, 1.34407341e-01f, 1.26242831e-01f, -8.77354443e-02f, 4.33041938e-02f, -5.40012643e-02f, 6.67733233e-03f,
  1.34676760e-02f, -9.66253579e-02f, -2.83557028e-01f, 5.30984402e-02f, -4.39494699e-02f, -1.86221495e-01f, 1.06546834e-01f, 1.38019532e-01f, -4.41136695e-02f, -6.87557533e-02f,
  7.69264773e-02f, 1.26552954e-01f, -6.36944994e-02f, 1.57493532e-01f, 1.42929554e-01f, 1.18855461e-01f, 6.76524267e-02f, -1.65848061e-01f, 1.66271538e-01f, 5.91408312e-02f,
  6.19616397e-02f, -9.13519692e-03f, -2.49597281e-02f, -5.21740839e-02f, -2.66736187e-02f, -2.57106815e-02f, -4.84192334e-02f, -6.46044239e-02f, 4.88391481e-02f, 5.57072498e-02f,
  -2.82694232e-02f, 5.08903190e-02f, 6.31773174e-02f, -5.15153408e-02f, 4.75875773e-02f, -6.00312650e-02f, -2.59791296e-02f, -4.79087494e-02f, -1.08899558e-02f, -9.84686315e-02f,
  -1.36602551e-01f, 4.93249409e-02f, 1.24295577e-02f, 4.59622294e-02f, -2.91032773e-02f, 5.20501938e-03f, 1.57486498e-02f, -1.82384590e-03f, 4.23712395e-02f, 8.53513405e-02f,
  6.30869472e-04f, 6.01113141e-02f, -4.29354645e-02f, 3.60396914e-02f, 4.46919948e-02f, 2.42754873e-02f, -1.84928738e-02f, 4.63109277e-02f, -7.90959224e-02f, 7.53005967e-03f,
  -2.15151273e-02f, -5.47013879e-02f, -6.45730272e-03f, -1.97412036e-02f, 3.32743349e-03f, 1.47282407e-02f, -3.13513763e-02f, -5.27739190e-02f, -3.66172865e-02f, -2.92325160e-03f,
  -6.88307639e-03f, -4.60395366e-02f, -4.98166420e-02f, -2.13448517e-02f, -6.76710457e-02f, -8.17398503e-02f, -1.23545462e-02f, -1.64120011e-02f, 2.85387458e-03f, 4.81588282e-02f,
  6.59068003e-02f, -1.20533302e-01f, -6.99128583e-02f, 4.31764089e-02f, 4.01046302e-04f, 9.74969938e-02f, -3.56112048e-02f, 2.86541600e-02f, -4.39686552e-02f, 3.77978235e-02f,
  3.49184461e-02f, 6.21584384e-03f, 5.27505502e-02f, -3.64260189e-02f, 2.50187796e-02f, 7.97169935e-03f, 1.40309585e-02f, -6.28369525e-02f, 7.43889660e-02f, 2.23835614e-02f,
  6.86042476e-03f, 9.06056762e-02f, -1.00076897e-02f, 8.23981967e-03f, 1.15141638e-01f, -3.84758897e-02f, -4.65711094e-02f, 5.10362238e-02f, 8.56620222e-02f, 1.98917240e-02f,
  1.25654668e-01f, 3.99915203e-02f, -1.81197077e-01f, -1.11204550e-01f, -3.33197415e-02f, 4.39241454e-02f, 1.53564112e-02f, -3.09087969e-02f, -1.23167604e-01f, 1.12005912e-01f,
  4.93484251e-02f, -3.57864387e-02f, 1.23489261e-01f, 8.32326040e-02f, -3.95364836e-02f, 1.23681955e-01f, 1.02424718e-01f, 2.80254018e-02f, 2.20127404e-02f, 8.23327750e-02f,
  4.80715098e-04f, 6.43045455e-02f, -1.08686902e-01f, 7.89143145e-02f, 7.38543198e-02f, -9.00931209e-02f, 7.63870254e-02f, -1.41602397e-01f, 7.12483600e-02f, -5.92179745e-02f,
  1.45702427e-02f, -3.18274610e-02f, -5.60610332e-02f, -4.55536246e-02f, -5.84301241e-02f, 8.88918489e-02f, -6.26672953e-02f, -3.34208570e-02f, -7.31759965e-02f, 4.86881398e-02f,
  -1.57502554e-02f, 4.09624316e-02f, -5.22916280e-02f, -8.05996880e-02f, 5.61166815e-02f, -1.21131249e-01f, 3.19268070e-02f, -1.33287730e-02f, -3.27238850e-02f, -1.41775571e-02f,
  -2.34599840e-02f, -3.71410996e-02f, -6.36843368e-02f, 7.32988119e-02f, 4.19299342e-02f, -7.21121207e-02f, -7.44058713e-02f, 2.12724153e-02f, -4.85201143e-02f, -8.72714221e-02f,
  -3.55906896e-02f, -1.13526266e-02f, -4.04954189e-03f, 8.15116167e-02f, -4.05159108e-02f, -3.57457884e-02f, 4.64342386e-02f, -6.24718219e-02f, -4.66892086e-02f, 7.61804134e-02f,
  -7.25863725e-02f, 2.52340697e-02f, 1.03385067e-02f, -5.97248189e-02f, 6.87724799e-02f, 3.88570055e-02f, 5.68341017e-02f, -7.90029168e-02f, -2.11749133e-02f, -3.11516970e-02f,
  4.05983888e-02f, -1.39334323e-02f, 2.95941364e-02f, 7.27518052e-02f, 3.05886902e-02f, -7.52560943e-02f, 1.19527234e-02f, 6.34702146e-02f, -7.85138831e-02f, 6.00581728e-02f,
  1.22466065e-01f, 1.38955731e-02f, -2.49308273e-02f, 5.85604422e-02f, -1.46872327e-02f, 5.69912009e-02f, 9.56356451e-02f, -4.61691478e-03f, 3.83295957e-03f, 5.09240925e-02f,
  3.82246003e-02f, 3.72981802e-02f, 1.08523481e-01f, 4.96319942e-02f, -5.81450835e-02f, 6.60902932e-02f, 1.89366471e-02f, -8.58918503e-02f, -6.86492724e-03f, -2.87271962e-02f,
  -1.09670997e-01f, -6.60068691e-02f, 7.57908896e-02f, -7.34195411e-02f, -9.37217660e-03f, -4.39209044e-02f, -9.74677131e-02f, 1.08049735e-02f, 4.94670570e-02f, 2.20196228e-02f,
  2.09641904e-02f, -1.56485811e-01f, 1.38010591e-01f, -1.98545814e-01f, 4.06254753e-02f, -6.77593499e-02f, -4.22393382e-02f, -1.80027306e-01f, -7.40745291e-02f, -1.69910878e-01f,
  -6.28094971e-02f, 1.24667332e-01f, 1.34376571e-01f, -1.96774051e-01f, 2.32398257e-01f, 1.69170037e-01f, -1.20514713e-01f, -8.71830955e-02f, 3.84330228e-02f, -1.42515004e-01f,
  1.05584906e-02f, -1.58721775e-01f, 1.09343536e-01f, -1.28129885e-01f, -9.96321961e-02f, -2.02629119e-01f, 1.45036755e-02f, -1.65220108e-02f, -2.32460752e-01f, -2.93802340e-02f,
  4.01872285e-02f, -7.81783909e-02f, 2.79395618e-02f, 4.49084351e-03f, -1.06793627e-01f, -1.91818215e-02f, 2.96490695e-02f, 2.93165930e-02f, -2.15079747e-02f, 8.46149027e-02f,
  -1.12146847e-02f, 1.95520241e-02f, -9.12005305e-02f, 8.89455378e-02f, 1.99774262e-02f, -1.84538718e-02f, -1.47931324e-02f, 4.19644490e-02f, 7.53492713e-02f, 3.37567255e-02f,
  9.78398249e-02f, 8.09433833e-02f, 7.98837543e-02f, 3.67683396e-02f, 4.69672829e-02f, -1.63851455e-02f, -1.98528562e-02f, 8.79767463e-02f, -9.09379274e-02f, -6.45868629e-02f,
  -8.42148066e-02f, -3.47624458e-02f, -8.84679239e-03f, -8.88135955e-02f, 7.39113390e-02f, 2.75951158e-03f, 8.71086344e-02f, -6.31432235e-03f, 5.37559297e-03f, -1.60697959e-02f,
  -1.26687130e-02f, -3.89470272e-02f, -1.88189205e-02f, 3.34365107e-02f, -3.31701338e-03f, -3.43326218e-02f, 6.67983219e-02f, -6.98908940e-02f, -1.78380422e-02f, -5.20658456e-02f,
  3.40080187e-02f, -4.99086566e-02f, -8.90541971e-02f, -2.99497973e-02f, 3.98753658e-02f, 1.00630149e-01f, 5.11634015e-02f, -7.82200042e-03f, -2.96894438e-03f, 9.81542692e-02f,
  -5.90884313e-02f, -5.52564338e-02f, -2.08879206e-02f, 2.53148545e-02f, -2.69610677e-02f, -7.94429705e-02f, 3.88455912e-02f, -3.88968810e-02f, -6.04955442e-02f, -6.07350096e-02f,
  4.01984751e-02f, -4.31561619e-02f, -4.60825674e-03f, -7.75635429e-03f, -2.70029586e-02f, -2.83504035e-02f, 5.82880937e-02f, 8.85922182e-03f, -4.42553461e-02f, 2.77688005e-03f,
  1.45155555e-02f, 4.08924520e-02f, -3.40078101e-02f, -9.90182981e-02f, -8.05152208e-03f, -2.62153689e-02f, -6.68468401e-02f, 7.82919377e-02f, 7.78346211e-02f, 3.54850069e-02f,
  1.02769427e-01f, -2.23073080e-01f, 1.48393989e-01f, 1.38361171e-01f, 6.57309517e-02f, -2.70553082e-02f, 2.09678560e-01f, 3.43446285e-02f, 1.05445199e-02f, -2.08459765e-01f,
  8.47627297e-02f, 2.35561933e-02f, -1.73542332e-02f, -1.60835870e-02f, 2.00939909e-01f, -4.67080325e-02f, 8.96401778e-02f, 3.89144607e-02f, 4.24816236e-02f, -9.20463447e-03f,
  6.15527220e-02f, 1.16202394e-02f, 4.47472036e-02f, -6.67601600e-02f, 7.50705376e-02f, -6.60430873e-03f, 5.71202226e-02f, 8.32579136e-02f, 3.52593884e-02f, 1.25691872e-02f,
  -4.17816229e-02f, 1.25506306e-02f, 5.64551987e-02f, -1.08633183e-01f, -4.43620458e-02f, -6.35833889e-02f, 7.61378035e-02f, 9.53373089e-02f, 7.73361847e-02f, -5.72624430e-02f,
  -7.80732557e-02f, 5.03219478e-03f, -4.93966639e-02f, -2.71560438e-02f, -4.17309888e-02f, 8.42946544e-02f, 6.49576187e-02f, -1.95605140e-02f, -2.44382620e-02f, -4.64563072e-02f,
  -1.59441829e-02f, -8.09864625e-02f, 3.11432909e-02f, -5.93532249e-02f, 4.01930325e-02f, -9.88154113e-02f, -8.96511506e-03f, -4.66010496e-02f, 2.24631373e-02f, -1.20733045e-01f,
  -5.87389432e-02f, -5.50082326e-02f, 6.50989264e-02f, 3.69739383e-02f, -3.84307839e-02f, -6.06115647e-02f, 7.22569525e-02f, 8.78688768e-02f, 5.09431511e-02f, 8.81990045e-03f,
  8.32251608e-02f, -3.12872007e-02f, -2.81462055e-02f, -3.50874141e-02f, -4.82526012e-02f, 7.13879392e-02f, -1.60263311e-02f, 8.04885179e-02f, 2.93224044e-02f, -2.17713062e-02f,
  4.54027615e-02f, 8.09758008e-02f, -1.06367595e-01f, -7.89238662e-02f, 2.77450662e-02f, -4.27604094e-02f, -1.34387671e-03f, -1.55057823e-02f, 5.13742492e-02f, -3.82705661e-03f,
  -6.14691861e-02f, -3.64737846e-02f, -1.06116235e-01f, 5.62896952e-02f, 3.98787893e-02f, -6.90601990e-02f, -4.27814052e-02f, -1.34438649e-02f, 6.50086701e-02f, -6.82415068e-03f,
  6.62352294e-02f, 3.17784958e-02f, 4.29414511e-02f, 3.55953872e-02f, -2.43765470e-02f, -1.01087309e-01f, 7.05641806e-02f, 2.54442506e-02f, -3.88334952e-02f, -5.74016459e-02f,
  9.55218170e-03f, -4.16424349e-02f, -7.98838362e-02f, -2.65878960e-02f, 2.35249028e-02f, -1.01698928e-01f, 3.95936631e-02f, 2.84810700e-02f, -1.79897267e-02f, 2.46627349e-02f,
  5.74736856e-02f, -9.46229845e-02f, -1.67130962e-01f, -1.53527021e-01f, -2.20544010e-01f, -2.87038684e-01f, -1.57668039e-01f, -8.75191540e-02f, 1.13397196e-01f, 7.22556859e-02f,
  -9.09200162e-02f, 1.62273243e-01f, 1.13043666e-01f, -2.17475444e-01f, -1.56136288e-03f, 1.19177632e-01f, -1.25671133e-01f, -2.92035490e-02f, 2.06228551e-02f, -1.43704206e-01f,
  -9.72541422e-02f, -1.25136733e-01f, -4.15098593e-02f, -2.05350950e-01f, -2.00846821e-01f, 2.98416801e-02f, 2.39966828e-02f, -1.79691896e-01f, -8.10089186e-02f, -2.09683012e-02f,
  -4.64900304e-03f, -1.16811488e-02f, -8.73525515e-02f, -2.80000661e-02f, 4.86365892e-02f, 1.57674449e-03f, -1.02534378e-02f, -3.61292847e-02f, -2.48593576e-02f, -6.17622994e-02f,
  3.04521248e-02f, -3.40376571e-02f, 3.53026204e-02f, -7.70801725e-03f, -3.07561662e-02f, -6.48068637e-02f, 1.80138145e-02f, 3.31781991e-02f, 3.55784483e-02f, -3.52058634e-02f,
  4.39636484e-02f, -8.40595663e-02f, -1.44728161e-02f, 1.14369050e-01f, -3.86236385e-02f, 3.79089639e-02f, 5.84006980e-02f, -7.85636902e-02f, -4.21772562e-02f, -7.61953890e-02f,
  -4.76434641e-03f, 6.86957389e-02f, 3.52299996e-02f, 1.93717312e-02f, -1.35499562e-04f, -3.95979621e-02f, -4.87028100e-02f, -1.28448140e-02f, 4.49311733e-02f, -4.40291949e-02f,
  -4.93307859e-02f, 6.79836795e-03f, -8.73288661e-02f, 2.87029520e-02f, 5.03826253e-02f, 1.22321345e-01f, 3.57561596e-02f, 5.19045256e-02f, 4.30699736e-02f, 6.86261654e-02f,
  1.01060439e-02f, -6.00402802e-02f, 7.52403289e-02f, -6.19734861e-02f, 6.90057725e-02f, 1.60269700e-02f, 4.38431539e-02f, 7.67937452e-02f, 7.31027573e-02f, -1.04570560e-01f,
  -7.85316527e-02f, -1.99822970e-02f, 5.47530886e-04f, -1.30720427e-02f, 4.23703752e-02f, -7.58014843e-02f, -8.93379450e-02f, 5.70092462e-02f, -3.12739275e-02f, -8.76029283e-02f,
  1.49866967e-02f, 5.12230359e-02f, -1.26407584e-02f, 5.91878071e-02f, -4.28494103e-02f, -3.42935473e-02f, -1.33053772e-02f, 9.06417891e-02f, -8.36577043e-02f, 6.51873276e-02f,
  -9.94886532e-02f, 3.22000049e-02f, 9.21596363e-02f, 6.94123805e-02f, 1.89783645e-03f, -5.42633235e-02f, -1.17328241e-02f, 7.20211444e-03f, -9.00053307e-02f, 2.78119370e-02f,
  1.78595513e-01f, -3.58789526e-02f, -1.28237516e-01f, 1.14230085e-02f, 8.52859318e-02f, -6.60981387e-02f, 3.76801305e-02f, 1.84237156e-02f, -6.33996306e-03f, -1.01033069e-01f,
  1.17220310e-02f, -1.64950803e-01f, 7.73098739e-03f, -1.91326253e-04f, 5.21461368e-02f, 5.94040975e-02f, 5.19722477e-02f, -1.91894062e-02f, 9.39565599e-02f, -5.62965460e-02f,
  2.80911271e-02f, 1.22767515e-01f, 8.16802010e-02f, 1.01087660e-01f, 9.00407135e-02f, 3.69410589e-02f, -4.22466593e-03f, -1.48127591e-02f, -2.59083286e-02f, 7.47138838e-05f,
  5.22917882e-02f, 7.49664828e-02f, 9.15711224e-02f, -3.80954560e-04f, 5.70843462e-03f, -5.78048602e-02f, -5.44489287e-02f, -8.81388411e-02f, 4.17022407e-03f, 2.27935519e-02f,
  4.31095362e-02f, 1.61326900e-02f, -2.43764650e-02f, 8.92713070e-02f, 6.85333759e-02f, -1.07134664e-02f, 3.30817625e-02f, -4.34573293e-02f, -3.18549946e-02f, -9.70628858e-03f,
  2.65765209e-02f, -6.75812885e-02f, -9.13457945e-02f, 4.95746769e-02f, -9.39870924e-02f, -3.26133072e-02f, 1.35134170e-02f, -8.70265439e-02f, 6.98018260e-03f, -7.81910568e-02f,
  -1.05741322e-02f, -4.21711020e-02f, -7.13828504e-02f, 2.42674705e-02f, 6.71840012e-02f, -3.72735225e-02f, -3.89070772e-02f, 2.11672280e-02f, -5.55636548e-02f, 3.43541726e-02f,
  7.16027319e-02f, -7.83781335e-03f, 6.84508830e-02f, 5.00003770e-02f, 3.24144848e-02f, -7.39885196e-02f, 4.80651781e-02f, 5.37335575e-02f, -4.93023396e-02f, -6.36316091e-02f,
  -4.86052223e-02f, 8.74162391e-02f, 4.71726097e-02f, 8.99886526e-03f, -1.89286619e-02f, -6.99726790e-02f, 3.23758461e-02f, 5.52881658e-02f, 1.05413133e-02f, -5.00344299e-02f,
  1.45742008e-02f, -1.08143799e-01f, -3.25487033e-02f, 1.80132259e-02f, 4.61508781e-02f, -3.82897723e-03f, -5.39097525e-02f, 7.02059120e-02f, 3.79819833e-02f, 7.25838393e-02f,
  1.12143876e-02f, -6.11579046e-03f, 3.48677710e-02f, -3.06572616e-02f, 2.53881351e-03f, -1.15184104e-02f, -7.01956600e-02f, -5.81028722e-02f, -2.32513417e-02f, 3.74156237e-02f,
  3.54362354e-02f, -4.25622761e-02f, -9.55699682e-02f, -6.91029876e-02f, 2.75543183e-02f, -7.67764971e-02f, -7.19403476e-02f, 3.09935622e-02f, 5.21912351e-02f, -6.55654296e-02f,
  -5.83167225e-02f, 6.29246756e-02f, -1.03027381e-01f, 6.42342940e-02f, -1.47809312e-01f, 4.36453409e-02f, 1.45849928e-01f, 5.43805063e-02f, -3.11665889e-02f, 2.02383354e-01f,
  1.95510566e-01f, 3.09364628e-02f, 1.70057774e-01f, 2.36895904e-01f, 1.12818718e-01f, 9.38242599e-02f, 1.97284713e-01f, 8.71705562e-02f, -4.78988960e-02f, 8.97560865e-02f,
  -1.21406848e-02f, 2.31871337e-01f, 4.33539115e-02f, 3.56253311e-02f, -5.76731376e-02f, -1.21661939e-01f, 1.57850422e-02f, -1.74477380e-02f, 2.08630003e-02f, 4.77103665e-02f,
  2.95928922e-02f, -3.50296684e-02f, 1.03370491e-02f, -7.07285106e-02f, -1.73376482e-02f, -8.85998830e-02f, -4.96945865e-02f, -1.58654042e-02f, -7.49581605e-02f, 1.51240965e-02f,
  -6.92425817e-02f, -4.63107713e-02f, 3.80633548e-02f, 5.09968074e-03f, -6.80778548e-02f, 3.35782245e-02f, 1.42664630e-02f, 3.56281400e-02f, 5.04721999e-02f, -1.90061461e-02f,
  -4.80441377e-02f, 5.79601415e-02f, 6.78740963e-02f, -1.82286911e-02f, 5.24469838e-03f, -1.29578300e-02f, 6.52227774e-02f, -3.38575505e-02f, -6.82202205e-02f, -1.02849482e-02f,
  -5.38910441e-02f, -8.98310989e-02f, 3.14169861e-02f, 6.56360239e-02f, 3.01660802e-02f, 2.07437575e-02f, 9.62168649e-02f, -2.53890604e-02f, -8.54895413e-02f, 3.75193954e-02f,
  -2.72690635e-02f, -4.97363955e-02f, 4.54223901e-02f, 6.95507973e-02f, 5.47033176e-02f, 1.91916488e-02f, 6.98041990e-02f, -4.20469977e-02f, -4.06338759e-02f, 4.42502387e-02f,
  -5.21965623e-02f, 3.29939723e-02f, -2.84108501e-02f, -3.30465585e-02f, -5.57375289e-02f, -1.29958037e-02f, -3.11804563e-02f, 3.73851322e-02f, -2.22150609e-02f, 1.16770258e-02f,
  1.37927473e-01f, 7.22118169e-02f, -1.05043426e-02f, 4.40496169e-02f, -1.84811223e-02f, -1.06239319e-02f, 1.40175410e-02f, -3.38999555e-02f, 4.88879606e-02f, -8.18706080e-02f,
  -8.04288760e-02f, 1.26035661e-02f, -3.88686173e-02f, -8.23866799e-02f, -7.29727671e-02f, 8.71271491e-02f, 6.88053370e-02f, -1.51090743e-02f, 6.30221814e-02f, 5.66622131e-02f,
  6.64306656e-02f, 6.33395538e-02f, -7.94993266e-02f, -6.27441853e-02f, 7.26905912e-02f, 2.04923488e-02f, 5.03049120e-02f, -3.06621976e-02f, 9.88073554e-03f, 5.13696000e-02f,
  1.09892733e-01f, 2.15275702e-03f, 7.27935210e-02f, 1.06811516e-01f, 2.49073058e-01f, 2.13145092e-01f, 2.47413777e-02f, 1.60829887e-01f, 2.88703054e-01f, -5.16071320e-02f,
  1.07466951e-01f, -7.98121542e-02f, -7.14264289e-02f, 3.91111150e-02f, 8.69685188e-02f, -9.52810980e-03f, 1.54360294e-01f, 9.08289701e-02f, 1.13166515e-02f, 1.02014571e-01f,
  1.30167276e-01f, -5.75716347e-02f, -1.93825126e-01f, -1.60023808e-01f, 2.51208041e-02f, -1.76549837e-01f, -8.58123600e-02f, -6.26988709e-02f, -5.11824936e-02f, 1.37992473e-02f,
  -1.60375256e-02f, 2.25215666e-02f, -3.41715030e-02f, 4.64542676e-03f, 1.87684465e-02f, 1.99226309e-02f, 2.70979945e-02f, 4.54643043e-03f, -1.75261497e-02f, -4.65993844e-02f,
  -8.02498460e-02f, -6.16638511e-02f, 1.14632763e-01f, 8.84055123e-02f, -8.32919180e-02f, 6.92302808e-02f, -1.11528095e-02f, 9.30167437e-02f, -2.80351117e-02f, 2.45804037e-03f,
  -6.11808039e-02f, 3.86746861e-02f, 9.23752114e-02f, 2.79675908e-02f, 3.63618061e-02f, 7.94274732e-02f, -7.84999225e-03f, -8.33641738e-02f, -6.67404896e-03f, 4.91288565e-02f,
  4.15407717e-02f, 1.95866567e-03f, -4.18455265e-02f, -9.02728438e-02f, 5.06482348e-02f, -7.05605075e-02f, 8.18160698e-02f, 5.31892367e-02f, -3.43886539e-02f, 7.08794892e-02f,
  -1.37013709e-02f, -3.38755660e-02f, 4.62815464e-02f, -3.88474688e-02f, 8.08843970e-03f, -4.17026579e-02f, -1.84345804e-02f, 6.41135573e-02f, -5.07721677e-02f, 2.27711089e-02f,
  -7.95305371e-02f, -1.49245635e-02f, 4.96281758e-02f, -3.81237157e-02f, 6.99348748e-02f, 2.14221943e-02f, -6.35385439e-02f, -3.00919935e-02f, 5.62933497e-02f, 2.65063476e-02f,
  1.10852465e-01f, -2.66089160e-02f, 5.03757857e-02f, 1.31115466e-02f, -2.28404049e-02f, -2.99249403e-02f, 4.30414826e-02f, -6.04736470e-02f, 2.06533559e-02f, -2.29354650e-02f,
  -6.17501419e-03f, 1.92426075e-03f, 3.18563432e-02f, -9.39493552e-02f, 2.32183142e-03f, 1.55077334e-02f, -1.28078582e-02f, 3.51335481e-02f, -2.14476865e-02f, -8.27996656e-02f,
  -1.42822845e-03f, -6.64889365e-02f, -6.68739155e-02f, -6.36885837e-02f, 2.99210884e-02f, -4.36600000e-02f, 6.20693453e-02f, -5.62865511e-02f, 2.43151188e-02f, 4.16833274e-02f,
  1.92583129e-01f, 1.59927875e-01f, 2.18235597e-01f, 2.11111411e-01f, 4.88835014e-03f, -1.82963878e-01f, -7.38380700e-02f, -4.67080995e-03f, 2.97773719e-01f, -3.58880498e-02f,
  -1.30342007e-01f, 2.11039007e-01f, -1.30675703e-01f, 5.80504611e-02f, -2.22953290e-01f, -2.01897353e-01f, 7.04097599e-02f, 1.10947698e-01f, 1.22129090e-01f, -8.79024249e-03f,
  3.65290605e-02f, -8.17744285e-02f, -4.87447158e-02f, -1.35010898e-01f, 6.71147257e-02f, 1.92620188e-01f, -1.83592930e-01f, -7.46417865e-02f, -2.87808124e-02f, -3.68202142e-02f,
  1.44162204e-03f, 4.57111448e-02f, 7.24796429e-02f, 6.01088107e-02f, -2.60387268e-02f, 5.52914515e-02f, 1.99286398e-02f, 9.37570073e-03f, 1.14787286e-02f, 2.42869221e-02f,
  -3.03613637e-02f, 2.96886880e-02f, 1.70054007e-02f, 5.63524887e-02f, 8.17026198e-02f, 8.33741054e-02f, 8.23495239e-02f, 2.75368243e-02f, 1.77403055e-02f, -1.54823326e-02f,
  6.79048300e-02f, 5.66997007e-02f, 4.98540029e-02f, -4.09372672e-02f, 2.10191607e-02f, -2.27448195e-02f, 6.90739322e-03f, 9.40458849e-03f, 8.90525337e-03f, 9.81764942e-02f,
  -6.50207549e-02f, -7.80492872e-02f, -4.18128259e-02f, -2.35189795e-02f, 4.60830070e-02f, 3.57481129e-02f, 5.25792763e-02f, -5.65641886e-03f, -3.85791399e-02f, -1.05043262e-01f,
  4.16454040e-02f, -6.32754043e-02f, -1.05769094e-02f, 9.89192538e-03f, 5.61693273e-02f, -2.08461843e-02f, 4.76822481e-02f, -7.09611923e-02f, -1.18323565e-02f, -4.68183123e-02f,
  1.21907080e-02f, 3.81001122e-02f, -2.88289636e-02f, 5.83850592e-02f, -8.19221288e-02f, -3.66660543e-02f, -4.92409952e-02f, 6.14006855e-02f, -1.78039595e-02f, 5.02414536e-03f,
  -1.06571831e-01f, -1.00350872e-01f, -5.26999161e-02f, -7.80095309e-02f, 5.88196181e-02f, 2.79950071e-03f, 5.53671494e-02f, -1.50966980e-02f, 7.00440556e-02f, -7.64688626e-02f,
  2.32045967e-02f, -1.45463590e-02f, 7.13097677e-02f, -8.90584569e-03f, 2.30446104e-02f, 7.33274668e-02f, 8.16688016e-02f, -6.71517253e-02f, 1.69337988e-02f, 3.95519547e-02f,
  2.72405017e-02f, 4.19565924e-02f, 3.32511030e-02f, -9.97467246e-03f, -1.95253957e-02f, -3.81494351e-02f, 3.08279023e-02f, 1.10216215e-02f, 5.23032853e-03f, -7.71054253e-02f,
  -4.02910620e-01f, 1.58399388e-01f, -1.87124964e-02f, -7.97768682e-02f, -2.01886222e-01f, -1.12532094e-01f, 5.47095872e-02f, -4.65904437e-02f, -9.88530368e-02f, 2.20460102e-01f,
  7.46953264e-02f, -1.41560107e-01f, 1.54488534e-01f, 1.99359447e-01f, -2.14951530e-01f, 2.23295316e-01f, -2.79877596e-02f, 5.12963310e-02f, -3.21898535e-02f, -1.45349177e-02f,
  -5.16534746e-02f, -3.58567387e-02f, 9.72797722e-02f, -1.45586329e-02f, -1.21038109e-01f, -7.88489059e-02f, 8.04455355e-02f, 1.04842894e-02f, -7.37396032e-02f, -4.02477905e-02f,
  -6.64140135e-02f, -2.19733104e-01f, -1.48140490e-01f, -1.04582302e-01f, -2.11489260e-01f, -7.18293013e-03f, -1.35987282e-01f, 1.57788228e-02f, -4.43857163e-02f, -9.08224732e-02f,
  9.80871357e-03f, 3.24185789e-02f, 1.55551182e-02f, 1.66118518e-02f, 3.80287915e-02f, 2.44003367e-02f, 3.70407775e-02f, 3.68396752e-02f, 4.90255170e-02f, 3.96477357e-02f,
  -6.12958968e-02f, 4.23347577e-03f, -2.69550327e-02f, -1.86801609e-02f, 2.65371446e-02f, -4.13777195e-02f, 4.72289398e-02f, -6.87553957e-02f, -6.22640103e-02f, -1.20550450e-02f,
  6.62090257e-02f, 3.87095697e-02f, -6.67976066e-02f, 3.95760164e-02f, 3.43217440e-02f, -3.45687549e-05f, -1.49025042e-02f, -8.23893771e-03f, 2.43353471e-02f, -9.20832902e-03f,
  -1.09876707e-01f, 5.16864322e-02f, -3.55698690e-02f, -4.29178588e-02f, 3.66050862e-02f, 7.31694791e-03f, 9.34441984e-02f, -3.50869745e-02f, 5.12118265e-02f, -8.34679231e-03f,
  -4.57290560e-03f, -1.00713655e-01f, -1.77955988e-03f, 9.43112299e-02f, -5.78906797e-02f, 3.18519808e-02f, -6.37071505e-02f, -7.96125643e-03f, 5.59506081e-02f, 3.02934088e-02f,
  -3.32168639e-01f, -1.81513354e-01f, -1.17380053e-01f, -8.23772401e-02f, -1.46522969e-02f, -2.72549018e-02f, 3.24488394e-02f, -1.04378350e-01f, -8.75580981e-02f, -9.39232856e-02f,
  -2.98464186e-02f, 3.56750451e-02f, -1.29701287e-01f, 3.13141868e-02f, -7.49020576e-02f, -2.19163932e-02f, -3.89867858e-03f, -1.12466857e-01f, -5.15008345e-02f, -4.26858440e-02f,
  3.10569424e-02f, -6.55261055e-02f, 3.50240581e-02f, 9.16504264e-02f, -1.69947352e-02f, -2.69764056e-03f, -7.63562322e-02f, -5.17844073e-02f, -6.80184588e-02f, -2.42171180e-03f,
  -1.35180667e-01f, -1.19646015e-02f, -2.18187913e-01f, -1.82315230e-01f, 7.20022619e-02f, -2.90835559e-01f, -2.93287396e-01f, -1.91291340e-03f, -1.07295746e-02f, 9.45518166e-02f,
  1.90806873e-02f, 1.71466526e-02f, 1.07240230e-02f, -3.31032902e-01f, -5.59428744e-02f, -3.30993114e-03f, -2.57312745e-01f, -1.67621657e-01f, -6.95123672e-02f, -1.19534500e-01f,
  2.43534278e-02f, -1.51616231e-01f, -9.54384059e-02f, 9.00432747e-03f, -1.27852380e-01f, -1.16694113e-02f, 1.51557863e-01f, 6.98556826e-02f, -2.91515309e-02f, -2.37534344e-02f,
  -7.71596432e-02f, 8.16021860e-03f, 8.48931596e-02f, -4.50899228e-02f, -1.21495008e-01f, 4.39391509e-02f, 1.42392199e-02f, -6.75768554e-02f, -7.63350651e-02f, -4.49692309e-02f,
  2.93400022e-03f, 6.57169595e-02f, -1.97192878e-02f, 5.96949793e-02f, -6.75858334e-02f, 4.67629172e-02f, -7.65168741e-02f, 3.70094739e-02f, 8.88492819e-03f, 1.76480170e-02f,
  -8.49660486e-02f, -4.98145930e-02f, -2.41217874e-02f, 1.66794378e-02f, -1.70697505e-03f, -7.65509624e-03f, 1.60264969e-02f, -7.73313865e-02f, 5.23797832e-02f, -8.92554298e-02f,
  3.78874019e-02f, 7.62102455e-02f, 5.30211851e-02f, 3.91942672e-02f, -7.08127394e-02f, -2.59038080e-02f, 2.24195439e-02f, 2.28538737e-02f, -1.49633540e-02f, -4.58968244e-02f,
  1.87558476e-02f, 9.41648334e-03f, 6.51592612e-02f, -3.56178656e-02f, -1.66501962e-02f, -3.20553519e-02f, 8.49658251e-03f, 4.45142798e-02f, 2.50286367e-02f, -5.51976338e-02f,
  -6.23121336e-02f, 1.90390162e-02f, -1.21174864e-02f, 3.26727815e-02f, -3.24676707e-02f, 1.26315635e-02f, 7.13344142e-02f, -4.09778282e-02f, 8.71107634e-03f, -1.13908267e-02f,
  -8.53769854e-03f, 1.47266194e-01f, -5.81673384e-02f, 5.30402362e-02f, 8.67594872e-03f, -2.87726801e-02f, -3.74263003e-02f, -2.14379299e-02f, -5.78954853e-02f, 4.02359888e-02f,
  -4.22455966e-02f, 7.53906965e-02f, -4.63045109e-03f, -1.85559259e-03f, -6.26263693e-02f, -4.92833294e-02f, 3.75197595e-03f, 2.03559324e-02f, 4.19023260e-02f, 4.80415262e-02f,
  5.80000393e-02f, 6.75973147e-02f, 5.01152314e-02f, 3.31798708e-03f, 3.07685304e-02f, 5.21170869e-02f, 2.09997762e-02f, -2.90433094e-02f, -3.87000665e-02f, -4.64409776e-02f,
  1.56363755e-01f, 7.02480003e-02f, -7.93190766e-03f, -4.65108231e-02f, -1.10311463e-01f, -6.46996871e-02f, 5.89068420e-02f, 3.51783149e-02f, 1.38764337e-01f, -7.52197765e-03f,
  -4.17308435e-02f, 5.61021231e-02f, -2.84194201e-02f, -1.03054354e-02f, 4.29751165e-02f, -1.21761262e-02f, 1.05441011e-01f, -2.12192126e-02f, -1.58145686e-03f, -1.37635246e-02f,
  -4.28602174e-02f, -1.58322472e-02f, -5.03436327e-02f, -6.84706122e-02f, 6.12160489e-02f, 4.79162559e-02f, -1.46620110e-01f, -9.46111884e-03f, 4.41040136e-02f, 6.43277094e-02f,
  8.48293155e-02f, 8.75287130e-02f, -1.65264904e-02f, 9.34003368e-02f, -9.49751809e-02f, 4.90798522e-03f, -6.81525171e-02f, -6.40013665e-02f, -8.56793821e-02f, -5.43589108e-02f,
  5.18630631e-02f, 4.75600548e-02f, -4.70108390e-02f, 3.55303288e-02f, 3.62136103e-02f, -5.76210320e-02f, -6.82131127e-02f, 9.49964747e-02f, 3.70063409e-02f, -3.08908224e-02f,
  4.53860313e-02f, -4.74481210e-02f, -5.44055440e-02f, 3.85002457e-02f, 2.29611471e-02f, 5.66864833e-02f, 3.10232379e-02f, 4.66811918e-02f, -3.03419703e-03f, 1.85700990e-02f,
  3.25061716e-02f, -6.64386153e-02f, 6.43820167e-02f, -6.49113879e-02f, -6.65465072e-02f, -9.39001963e-02f, -5.10339886e-02f, 6.78592827e-03f, 9.13475454e-02f, 3.53470398e-03f,
  -4.98329587e-02f, 5.22445142e-03f, 5.16448095e-02f, 3.14570703e-02f, -5.50338253e-02f, -2.75885966e-02f, -2.28004083e-02f, -2.02597696e-02f, -4.69446294e-02f, -1.39747411e-02f,
  -8.69847015e-02f, 1.78219080e-02f, 3.35570537e-02f, -3.88408042e-02f, 5.41916601e-02f, 7.26871416e-02f, 4.66342010e-02f, 6.34193271e-02f, 1.00085875e-02f, -2.07510106e-02f,
  3.71961966e-02f, 8.55884179e-02f, 3.04318015e-02f, 1.13455188e-02f, -4.84911818e-03f, -7.05411136e-02f, 6.82683289e-02f, -2.48103589e-03f, -7.13591203e-02f, -8.29391368e-03f,
  -2.76659895e-03f, 2.60749012e-02f, 8.53930712e-02f, -5.73860528e-03f, 5.33640236e-02f, 4.80319820e-02f, 6.15557916e-02f, -7.79938698e-02f, -1.69632246e-03f, 7.68045112e-02f,
  -7.82353282e-02f, -2.27216147e-02f, -6.01466186e-02f, -1.72026455e-02f, -2.47873440e-02f, -3.03639919e-02f, -3.25475194e-05f, -2.29616575e-02f, -4.20759358e-02f, 8.44595879e-02f,
  1.24931363e-02f, 5.03050834e-02f, -6.43487554e-03f, 1.54934660e-01f, -7.11209923e-02f, -1.10453345e-01f, 5.42861875e-03f, 6.68305829e-02f, 7.14512989e-02f, 1.64640732e-02f,
  4.46398109e-02f, 2.63834707e-02f, -5.22451773e-02f, 1.75191518e-02f, 7.20325783e-02f, -9.58302021e-02f, -3.87299061e-02f, -2.95509566e-02f, -3.58002558e-02f, 7.20750988e-02f,
  8.88043568e-02f, 2.99430862e-02f, 4.13960405e-03f, 5.26488572e-02f, 1.10886604e-01f, 8.23042542e-02f, -2.47289389e-02f, -9.66451969e-03f, 2.00495236e-02f, 6.27897382e-02f,
  4.11980525e-02f, -4.64930286e-04f, -5.43657411e-03f, 1.98071394e-02f, 6.17357157e-02f, -2.62557063e-02f, -8.31041783e-02f, -9.44772363e-02f, 8.47267434e-02f, 5.53681552e-02f,
  -4.29886915e-02f, -1.81145165e-02f, -2.80891694e-02f, -4.25167121e-02f, 6.25994429e-03f, 9.48722195e-03f, -3.03418655e-02f, -2.14110892e-02f, 6.63050637e-02f, 2.06375401e-02f,
  -5.21086566e-02f, 7.99019486e-02f, -2.86269188e-03f, 6.30707815e-02f, 1.25736510e-02f, 9.22288466e-03f, 1.37035139e-02f, 2.26316843e-02f, -7.60786375e-03f, -4.23943587e-02f,
  9.63771343e-02f, -1.16168242e-02f, -9.62753296e-02f, 3.16460803e-02f, -7.84740970e-03f, -6.61282241e-02f, -4.05563377e-02f, 4.86120619e-02f, 5.68858162e-02f, -7.04540610e-02f,
  4.08024490e-02f, 3.45565602e-02f, -4.17429581e-03f, 1.90918632e-02f, -4.87915128e-02f, 5.78683652e-02f, -5.16075036e-03f, 5.95321544e-02f, -1.65782347e-02f, 1.77707225e-02f,
  -8.29925686e-02f, 5.07994182e-02f, 4.15332243e-02f, 5.84600009e-02f, -8.50165486e-02f, 2.14853827e-02f, 1.80138424e-02f, -2.96552330e-02f, -3.14207524e-02f, -5.28708100e-02f,
  5.02486899e-02f, 1.23049647e-01f, 8.08612257e-02f, -2.83339098e-02f, 7.81724881e-03f, -9.12586227e-02f, -5.45071475e-02f, -3.63375992e-03f, -1.78892948e-02f, -2.22318769e-02f,
  9.61534679e-02f, -6.03220277e-02f, 1.79225788e-03f, 4.38921228e-02f, 9.00837779e-02f, -7.75920004e-02f, -1.91962551e-02f, -1.93998925e-02f, 8.83265287e-02f, 8.18135217e-02f,
  9.34623331e-02f, 5.49149513e-02f, -4.40679342e-02f, -6.34399503e-02f, -1.74243022e-02f, 8.69987532e-02f, 2.48211194e-02f, 8.23546425e-02f, -2.71084867e-02f, -2.38190703e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.19834915e-01f, 9.50681493e-02f, 5.04062288e-02f, 1.42707154e-01f, 6.28443658e-02f, 5.53550944e-02f, 4.20183763e-02f, -2.07787100e-02f, 7.34320134e-02f, 1.59225076e-01f,
  1.71161428e-01f, 1.35316193e-01f, -1.26616331e-02f, 3.01050153e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.08198129e-01f, 4.53118086e-02f, 2.47568882e-04f, -8.07844847e-02f, -1.12269260e-01f, -4.73654717e-02f, -1.16990052e-01f, 5.74696213e-02f, 7.68416226e-02f, -2.03711510e-01f,
  -4.80924780e-03f, -4.71496489e-03f, -1.88344121e-01f, -3.65182087e-02f, 1.35175854e-01f, -6.23527691e-02f, -1.87587291e-02f, -1.26932427e-01f, -2.07116604e-01f, 8.28371663e-03f,
  4.09248471e-02f, 4.83554415e-03f, -3.14256325e-02f, -9.34431478e-02f, 5.92330098e-02f, 4.86972816e-02f, -1.34574294e-01f, -8.86828229e-02f, 3.49111333e-02f, 1.41262412e-01f,
  -5.49287386e-02f, 5.93345501e-02f, -3.74694169e-02f, -8.82521272e-02f, -3.87157425e-02f, 8.62831324e-02f, -1.44391924e-01f, -3.08469143e-02f, -1.12146966e-01f, 9.25686732e-02f,
  1.05681770e-01f, -1.85791999e-02f, 2.10087344e-01f, 4.80249077e-02f, -2.49734029e-01f, 1.99248672e-01f, 2.93025114e-02f, -1.71958312e-01f, 1.33019701e-01f, -4.48390059e-02f,
  1.30676348e-02f, -1.42835155e-01f, 9.26244855e-02f, 1.90852180e-01f, 7.58672059e-02f, 1.96599945e-01f, 8.48526135e-02f, -1.71963409e-01f, -1.00748084e-01f, -2.96891108e-02f,
  1.14083523e-02f, 1.43661886e-01f, 1.33578721e-02f, -1.09638982e-01f, 7.62266070e-02f, 9.56116989e-02f, -2.07635984e-02f, 4.09769751e-02f, 3.94031405e-02f, -8.06446895e-02f,
  -5.37165254e-02f, -2.05139685e-02f, 6.55257106e-02f, 1.21079579e-01f, -9.36463624e-02f, -1.03825152e-01f, 2.04775542e-01f, -2.89607700e-02f, 6.70424849e-02f, -6.61967620e-02f,
  1.65089995e-01f, 7.89774656e-02f, 2.41990030e-01f, -6.56887423e-03f, -4.24788101e-03f, 1.81512117e-01f, 8.20566118e-02f, 1.24800049e-01f, -2.15969272e-02f, 7.82955736e-02f,
  6.28069192e-02f, 2.42059261e-01f, -1.42042458e-01f, -1.93996206e-01f, 4.57204469e-02f, -6.33112416e-02f, 2.42465943e-01f, -1.78518891e-01f, -1.91270947e-01f, 1.21027239e-01f,
  -2.53123879e-01f, 1.59222819e-02f, 2.21183583e-01f, -1.56366661e-01f, -1.02795050e-01f, 2.21974805e-01f, 1.23032145e-01f, -1.37525454e-01f, -1.55546546e-01f, 9.98530686e-02f,
  -4.01005037e-02f, -2.20212480e-03f, -4.98679318e-02f, -8.91700685e-02f, -1.36163294e-01f, -6.85353428e-02f, -2.21209554e-03f, 2.58355811e-02f, 1.21546939e-01f, -1.79716587e-01f,
  -4.09626961e-02f, -8.97509512e-03f, -1.16496356e-02f, 9.51165855e-02f, -2.19243959e-01f, -1.61102146e-01f, 1.27946600e-01f, 4.33388306e-03f, -1.68708876e-01f, -1.27692088e-01f,
  -3.66909020e-02f, -1.01369321e-02f, -1.37831569e-01f, -7.63459131e-02f, 1.16715200e-01f, 1.47795483e-01f, 5.31504750e-02f, -7.04919398e-02f, -8.94119814e-02f, -6.99414536e-02f,
  -1.43414080e-01f, 6.32556826e-02f, -8.16510916e-02f, 1.14274703e-01f, -1.03741251e-02f, 3.15186903e-02f, -4.89700288e-02f, -5.06051742e-02f, -9.81253833e-02f, -1.44161778e-02f,
  -5.31440973e-02f, -1.09630525e-01f, 3.52162383e-02f, 2.39672020e-01f, -8.41506198e-02f, 9.48779359e-02f, -1.48993789e-03f, 3.50067159e-03f, -1.35112973e-02f, -5.37481974e-04f,
  -5.88273862e-03f, 4.50959392e-02f, -1.66558221e-01f, -1.33072019e-01f, -6.06169105e-02f, -1.62932917e-01f, -1.49276972e-01f, 3.78794044e-01f, 1.56101078e-01f, 9.22346339e-02f,
  1.93593159e-01f, 2.52713300e-02f, -4.18742746e-01f, 2.31227949e-01f, 2.17240334e-01f, 1.16026849e-01f, 3.18436235e-01f, -1.48308262e-01f, -6.30233018e-03f, -4.23573777e-02f,
  -4.13750485e-02f, 1.62248805e-01f, 1.09120138e-01f, 1.45543903e-01f, -1.57847866e-01f, -2.34965980e-01f, 9.26729292e-02f, 2.47752398e-01f, -3.91848125e-02f, 8.65093172e-02f,
  -1.09286137e-01f, -2.14024317e-02f, -1.42674893e-01f, 6.08138032e-02f, -1.31237313e-01f, 1.04687899e-01f, -1.00218527e-01f, 1.15058772e-01f, 7.37987310e-02f, 1.26718313e-01f,
  -1.00015506e-01f, 6.24538511e-02f, 1.43722584e-02f, -2.42840331e-02f, -1.07577384e-01f, 1.69905469e-01f, -2.03286454e-01f, -5.59874326e-02f, 8.90598819e-02f, -1.03045627e-01f,
  -1.68655850e-02f, 8.02739784e-02f, 2.39252467e-02f, -9.31988284e-02f, -2.30820570e-02f, -4.06040102e-02f, 7.12718070e-02f, 8.05365816e-02f, 2.41383821e-01f, -7.93123022e-02f,
  -3.10706943e-01f, -5.00321425e-02f, -9.54023823e-02f, -7.38133341e-02f, 1.19727962e-01f, -1.46200210e-01f, -4.86583412e-02f, 1.23996340e-01f, -8.00254419e-02f, 8.97371024e-02f,
  -2.13873044e-01f, -1.32474184e-01f, -6.80435970e-02f, 3.95611048e-01f, -1.69600844e-01f, -3.08673054e-01f, 1.30265737e-02f, 6.61037788e-02f, -5.01363650e-02f, 1.08627982e-01f,
  -1.40576467e-01f, -1.97705194e-01f, 2.53740121e-02f, 8.65494013e-02f, -8.59547630e-02f, -1.82047412e-01f, -5.17564602e-02f, -3.50071825e-02f, 8.20520446e-02f, 1.30898980e-02f,
  4.77450062e-03f, 1.72852322e-01f, -2.26162821e-01f, 2.13220064e-02f, 1.18786404e-02f, 4.89067882e-02f, -1.17041744e-01f, 1.25736907e-01f, 5.94891831e-02f, 2.29038764e-02f,
  1.01337016e-01f, 1.19829059e-01f, -1.01835184e-01f, 1.03413306e-01f, -1.18705489e-01f, 7.62754232e-02f, 1.28124386e-01f, 8.15747157e-02f, -5.28563373e-02f, 8.85385573e-02f,
  -1.46103948e-01f, 1.25033721e-01f, 1.19937785e-01f, 1.58295725e-02f, -3.87102813e-02f, 1.92818847e-02f, -5.09138480e-02f, -4.38276380e-02f, 3.39452513e-02f, -4.55875546e-02f,
  -2.30851322e-01f, 2.39614218e-01f, -2.05926761e-01f, 2.79384434e-01f, 9.32577401e-02f, 5.47576994e-02f, 1.87711436e-02f, 3.61532383e-02f, 2.71025360e-01f, 3.50645989e-01f,
  5.92628010e-02f, -1.94823340e-01f, 9.58346501e-02f, 1.53972611e-01f, 1.76695645e-01f, 4.17024195e-02f, -6.97929636e-02f, 8.23813304e-02f, -2.52019167e-01f, -2.79900640e-01f,
  -1.71388183e-02f, -8.03809520e-03f, -2.03828231e-01f, 2.89833755e-03f, 2.95769870e-01f, 2.47034609e-01f, 8.53811800e-02f, 8.26338828e-02f, 2.21289080e-02f, -5.47880642e-02f,
  8.03221911e-02f, 3.00895609e-02f, 1.04653560e-01f, 5.58721609e-02f, 1.60541922e-01f, -2.16944274e-02f, -7.84477815e-02f, -2.60734290e-01f, 4.49867249e-02f, 3.29609727e-03f,
  4.34813388e-02f, -6.18548915e-02f, 6.96006641e-02f, -1.26186134e-02f, -5.91872372e-02f, 4.24854159e-02f, 1.23685695e-01f, -1.33725092e-01f, -7.37540871e-02f, 1.08771548e-01f,
  -7.36666992e-02f, -7.01707080e-02f, 8.36040229e-02f, -7.84158185e-02f, -1.28474385e-01f, -9.67233852e-02f, -7.07326457e-02f, -5.44076860e-02f, 4.14506271e-02f, 1.07447952e-01f,
  4.49053198e-03f, 1.06463566e-01f, -3.99537645e-02f, -6.35873303e-02f, 2.73973849e-02f, 6.12108894e-02f, -1.36182252e-02f, 1.23586334e-01f, -1.93712801e-01f, -1.56253383e-01f,
  6.89238459e-02f, -2.46512368e-01f, 2.64379442e-01f, -7.16773495e-02f, -2.02572912e-01f, -8.02168474e-02f, -1.36588424e-01f, 3.05842254e-02f, 1.56961024e-01f, -1.45279676e-01f,
  -7.58329630e-02f, 2.85070658e-01f, -1.27122492e-01f, -2.65765876e-01f, 7.92521760e-02f, -1.50995746e-01f, -1.34462252e-01f, 1.03277415e-01f, -8.66179019e-02f, -1.99474290e-01f,
  -1.88439608e-01f, 1.53398708e-01f, 1.25429491e-02f, -1.01265952e-01f, 1.45971507e-01f, -1.97227284e-01f, -9.01771858e-02f, -5.93308769e-02f, 9.77338850e-02f, 1.10666886e-01f,
  -2.21251026e-01f, -4.33110148e-02f, -5.38474633e-05f, 1.38372511e-01f, 7.83914402e-02f, 9.92422998e-02f, -5.62125444e-02f, -1.96300843e-03f, 6.31810352e-02f, -1.23893827e-01f,
  -6.09597377e-02f, -5.33006340e-02f, 8.56606662e-02f, 1.06925167e-01f, 8.10777843e-02f, 6.09827153e-02f, -7.07896650e-02f, 1.23262545e-03f, -1.03509873e-01f, 8.13384503e-02f,
  8.91913846e-02f, -7.26497639e-03f, -1.36687517e-01f, -1.00371137e-01f, -6.85784547e-03f, -1.25912145e-01f, 4.47226688e-02f, -9.86732543e-02f, 2.09603291e-02f, -1.26427248e-01f,
  -5.20240469e-03f, -1.26451984e-01f, -2.03091905e-01f, 1.47932142e-01f, 5.84742911e-02f, -1.76577404e-01f, 1.17434748e-01f, 1.30800128e-01f, -1.04143910e-01f, 5.45041189e-02f,
  8.51362795e-02f, 1.47487479e-03f, -2.16766950e-02f, -1.86267391e-01f, -2.02711552e-01f, 1.54492632e-01f, -1.17987089e-01f, -1.81376383e-01f, -5.10042720e-02f, -2.77517573e-03f,
  9.09127593e-02f, -1.86126586e-02f, 1.09976977e-01f, 7.35425651e-02f, -1.73621923e-02f, 1.61001366e-02f, 1.41144425e-01f, 9.40812305e-02f, 2.55763065e-02f, 7.84171447e-02f,
  3.92909460e-02f, -2.52366420e-02f, 4.71570641e-02f, -1.92018986e-01f, -4.16295230e-02f, 8.42355564e-02f, -3.80573347e-02f, 1.72380228e-02f, 1.40390903e-01f, -9.20272022e-02f,
  -3.68719622e-02f, -7.52429888e-02f, -9.33402702e-02f, -1.92829266e-01f, 2.04907563e-02f, -2.55200356e-01f, 1.71137735e-01f, -1.31700844e-01f, -2.48048767e-01f, 1.95225037e-03f,
  -6.65968284e-03f, 7.64869303e-02f, 2.14667395e-01f, 3.50163057e-02f, -4.68760207e-02f, -5.10525964e-02f, -1.53104991e-01f, -2.21028402e-01f, -9.20454413e-02f, -6.53702393e-02f,
  4.61409315e-02f, 8.38564411e-02f, -4.06878851e-02f, -1.82729438e-01f, -2.91919172e-01f, -2.47918844e-01f, -7.06785321e-02f, -5.35212234e-02f, 8.95355945e-04f, -9.24954191e-02f,
  -1.68904632e-01f, -1.30691290e-01f, -1.69215694e-01f, -2.28322819e-01f, -3.34444754e-02f, -7.61751905e-02f, -1.36024803e-01f, -6.79889396e-02f, 7.23645911e-02f, -9.62691829e-02f,
  1.88981697e-01f, 1.99390933e-01f, -3.00158896e-02f, -9.89236459e-02f, 2.13885680e-02f, -2.47801095e-02f, -1.02486853e-02f, -1.74021125e-01f, -1.75379530e-01f, -7.89434165e-02f,
  -1.53410763e-01f, 1.07342094e-01f, 9.29535851e-02f, 5.37948720e-02f, 4.48757187e-02f, -4.19299565e-02f, -2.12489069e-01f, -1.40643567e-01f, 2.06520766e-01f, 5.12662753e-02f,
  3.55014689e-02f, -5.61690256e-02f, -3.80585482e-03f, -1.40800262e-02f, 2.79054195e-02f, -2.27981165e-01f, -7.55500197e-02f, -1.37154549e-01f, -1.55081019e-01f, -3.88048254e-02f,
  1.31277189e-01f, 1.11750036e-01f, 2.03786772e-02f, -9.03341398e-02f, 9.46656093e-02f, -1.71336010e-02f, 2.27206349e-01f, -9.40127075e-02f, -2.78421212e-02f, 1.71545625e-01f,
  -4.58714142e-02f, -2.69121051e-01f, -3.54000105e-04f, -5.47172390e-02f, 1.45076990e-01f, -4.01390456e-02f, -1.46826617e-02f, -6.17230870e-02f, -2.35404626e-01f, -2.25656647e-02f,
  1.49475962e-01f, -7.83568472e-02f, -1.86863303e-01f, -3.71518768e-02f, -5.42009398e-02f, 9.62773412e-02f, -2.45916665e-01f, -2.02943780e-03f, -3.00378919e-01f, 1.97894454e-01f,
  1.80294260e-01f, 8.82985741e-02f, 2.06444621e-01f, -1.98257431e-01f, 5.22315688e-02f, 7.19057247e-02f, -8.47397745e-02f, -1.30118385e-01f, -2.44247451e-01f, -3.45852226e-01f,
  -3.14574055e-02f, 8.34852159e-02f, -2.85885669e-02f, -9.04490501e-02f, -5.17229969e-03f, 1.99169427e-01f, 1.70817971e-02f, 1.47944495e-01f, -5.32304682e-02f, 1.57653421e-01f,
  -1.97377950e-01f, -7.59606510e-02f, 1.83120638e-01f, 6.44706339e-02f, -4.08439934e-02f, 5.86221032e-02f, -4.56425250e-02f, 2.17180196e-02f, 1.11262597e-01f, 1.61578711e-02f,
  -9.62272510e-02f, -5.36445081e-02f, -1.09201066e-01f, 1.40420064e-01f, 4.46651168e-02f, 1.44980103e-01f, -1.34590939e-01f, 1.16084389e-01f, 2.57427003e-02f, -8.95300973e-03f,
  -9.70945060e-02f, -7.67332017e-02f, 1.81374207e-01f, -2.84714857e-04f, 1.04311034e-01f, -3.52909341e-02f, 1.26182184e-01f, -9.33639035e-02f, 1.08899660e-02f, 9.59558133e-03f,
  5.45508042e-02f, 2.01758459e-01f, 4.48865481e-02f, 1.78156450e-01f, 1.09158143e-01f, -2.33409088e-02f, 7.01844469e-02f, -4.35283780e-02f, -6.46923408e-02f, 3.10113370e-01f,
  -2.16477346e-02f, -6.55453354e-02f, 4.46503721e-02f, -1.23088993e-03f, 4.38262150e-02f, -6.59123436e-02f, -9.08726752e-02f, -9.39805135e-02f, -4.52596061e-02f, -4.92584668e-02f,
  -1.01483971e-01f, -1.10619046e-01f, -1.41691994e-02f, 4.57757749e-02f, 3.52031812e-02f, 3.40946354e-02f, 6.48817513e-03f, -1.21204242e-01f, 2.07937788e-02f, 8.92599225e-02f,
  2.11917888e-02f, -2.82022562e-02f, 1.09978721e-01f, 1.31435990e-01f, 9.22546387e-02f, -1.47478342e-01f, 5.72061986e-02f, -1.10747628e-01f, 9.73168388e-02f, -6.07369989e-02f,
  -3.62965241e-02f, -5.72844818e-02f, 4.60020304e-02f, -1.34619936e-01f, -6.01272564e-03f, -1.68410894e-02f, 5.01251817e-02f, -6.62448108e-02f, -9.38802063e-02f, 9.70631912e-02f,
  1.39692739e-01f, 1.27870813e-02f, 1.36347279e-01f, 2.48847455e-02f, -6.31599426e-02f, -2.11491868e-01f, -2.12912168e-03f, -4.13195081e-02f, 2.30370387e-02f, -1.03491396e-01f,
  -4.87492643e-02f, 9.04554203e-02f, -3.42713036e-02f, 9.66053531e-02f, -1.37692019e-01f, 1.92292575e-02f, -2.16864999e-02f, -4.32951525e-02f, -8.65728781e-02f, 2.38284376e-02f,
  -3.67934704e-02f, -8.98075849e-02f, 4.53802086e-02f, -1.55579254e-01f, -8.48355070e-02f, 3.47314924e-01f, -3.43581848e-02f, 3.07024270e-01f, 1.90856919e-01f, -2.97616571e-01f,
  8.76007453e-02f, 3.58240120e-02f, -1.16952002e-01f, -7.84374699e-02f, 1.07411265e-01f, -1.08600453e-01f, -3.76531750e-01f, -1.50536209e-01f, 8.79007764e-03f, 3.20668221e-01f,
  1.62700802e-01f, 1.34076094e-02f, 4.95171770e-02f, 5.83577435e-03f, -9.89861786e-02f, 1.62206292e-01f, -1.47414252e-01f, 1.78978801e-01f, -7.58039057e-02f, -1.63548619e-01f,
  -1.85269475e-01f, 1.76450804e-01f, 5.94204143e-02f, 6.80737197e-02f, -2.35151034e-02f, -6.96980432e-02f, 1.01247981e-01f, -6.91836700e-03f, -4.52215150e-02f, -2.01570825e-03f,
  -4.51661907e-02f, 9.36251283e-02f, -1.29856840e-01f, 3.86105105e-02f, 9.86033082e-02f, 6.36018813e-02f, -4.99331430e-02f, -7.74311423e-02f, -4.41829814e-03f, -9.58433822e-02f,
  -7.51489103e-02f, -1.46677613e-01f, 7.77123347e-02f, 1.63786232e-01f, -4.55981046e-02f, -1.62405416e-01f, 4.20776010e-02f, -1.24610968e-01f, 8.99276137e-02f, -2.14726925e-01f,
  2.50800788e-01f, -2.91620314e-01f, -1.18661873e-01f, -1.53621241e-01f, -4.21860777e-02f, 1.12274423e-01f, -9.33051035e-02f, -2.13095114e-01f, 1.50812849e-01f, 9.72847417e-02f,
  1.16198719e-01f, 3.57036963e-02f, 1.50843738e-02f, -2.84347087e-01f, -7.12596178e-02f, -8.90901685e-03f, 1.40908450e-01f, -3.97168174e-02f, 2.75084227e-01f, 3.42613198e-02f,
  1.06823500e-02f, -3.31061892e-02f, -3.83137405e-01f, 4.12842110e-02f, 5.39530255e-02f, -7.26950616e-02f, 3.71331070e-03f, -1.47605881e-01f, -4.45702346e-03f, -1.15537778e-01f,
  -4.45558168e-02f, 5.50902113e-02f, -5.48308529e-02f, -7.16775656e-02f, 1.10484555e-01f, 1.82127029e-01f, -9.33992490e-02f, 1.37061998e-01f, -1.50632719e-03f, 2.18889657e-02f,
  -5.34721613e-02f, -1.21850096e-01f, -2.23695803e-02f, -2.70128679e-02f, -6.36828393e-02f, 1.98152289e-01f, 5.11082597e-02f, 2.82630846e-02f, 3.37284580e-02f, -1.21034486e-02f,
  1.44871594e-02f, -7.64183700e-03f, 4.20413800e-02f, -1.41828999e-01f, -7.11516365e-02f, 1.09194294e-01f, 1.61378533e-01f, -1.96996570e-01f, -5.46771996e-02f, 1.19082250e-01f,
  2.29864195e-02f, 3.04813217e-02f, -9.57576558e-02f, -1.04012862e-02f, -3.74394655e-03f, -6.36587813e-02f, 1.31873190e-01f, 1.16691001e-01f, 1.64843231e-01f, -3.26088555e-02f,
  -7.09351599e-02f, 3.34940292e-02f, -9.33429673e-02f, -8.21648166e-02f, -2.01673970e-01f, 1.19450174e-01f, 2.73826480e-01f, -1.74561828e-01f, 4.08089943e-02f, -1.49157196e-01f,
  -2.39115119e-01f, -7.18177557e-02f, 2.37197220e-01f, -1.07125640e-01f, -2.17931151e-01f, -2.52703577e-01f, 7.83743411e-02f, 2.38245711e-01f, 6.36448413e-02f, -1.75634418e-02f,
  1.66828826e-01f, 3.67642194e-02f, 9.14445892e-02f, -1.21585175e-01f, -7.30511993e-02f, 1.46570966e-01f, -5.58441579e-02f, -1.22576684e-01f, 1.99449826e-02f, -9.48796868e-02f,
  -2.45350618e-02f, -1.83638223e-02f, -1.47829475e-02f, -1.79302786e-02f, 3.71610858e-02f, -5.28492872e-03f, -1.61528245e-01f, -9.76606924e-03f, -1.18828699e-01f, -1.32443249e-01f,
  -1.10391505e-01f, 3.19575034e-02f, 1.13923356e-01f, 1.34335369e-01f, 7.30784936e-03f, -1.53900674e-02f, -1.66312575e-01f, -1.66844621e-01f, -2.41946708e-02f, -1.38861284e-01f,
  -8.95330384e-02f, 1.48184448e-01f, 4.65591140e-02f, -7.77919516e-02f, -6.75996840e-02f, -1.50736451e-01f, 1.69640128e-02f, -1.96334749e-01f, 1.93398446e-02f, -4.00355339e-01f,
  -1.76298290e-01f, -5.78145497e-02f, -4.52741720e-02f, -1.14245534e-01f, 1.02788299e-01f, -3.08267951e-01f, 6.18617684e-02f, 3.98233354e-01f, 1.31227970e-01f, 9.90434587e-02f,
  -2.94808839e-02f, -2.18132228e-01f, 1.11370727e-01f, 6.30994502e-04f, 1.02561921e-01f, -6.34740591e-02f, 3.31277177e-02f, -1.32530734e-01f, 1.41774446e-01f, -8.65680203e-02f,
  -1.70897081e-01f, -6.04954083e-03f, 4.59355153e-02f, 1.18219480e-01f, 5.88719398e-02f, 5.31590879e-02f, -1.19085044e-01f, 5.61953634e-02f, -4.81701456e-02f, -1.60524100e-01f,
  -1.66660920e-01f, 2.99105793e-02f, -1.35524496e-01f, 2.99316615e-01f, 3.53279598e-02f, 1.29821792e-01f, 6.67876825e-02f, 9.67666507e-02f, -5.43381013e-02f, -1.11603905e-02f,
  1.66612361e-02f, 1.04945235e-01f, 1.17875651e-01f, 8.28919932e-02f, 2.82382015e-02f, -4.42889407e-02f, 1.06960900e-01f, -5.65764681e-02f, -2.76250690e-02f, -2.35062093e-02f,
  -8.88128206e-02f, 7.99105391e-02f, 5.41918762e-02f, 4.35312875e-02f, -5.20534292e-02f, 1.02257319e-01f, -7.16967806e-02f, -6.50978908e-02f, -1.07637659e-01f, 3.38256247e-02f,
  -2.19107598e-01f, 1.56049773e-01f, -2.47006938e-02f, 3.48392069e-01f, -8.17745328e-02f, -1.63992807e-01f, 9.76035446e-02f, 9.46639404e-02f, 7.58861974e-02f, 2.30885550e-01f,
  -1.48979872e-01f, -5.93538880e-02f, 2.90021463e-03f, 1.07591471e-03f, 1.26300901e-01f, 4.23525572e-02f, 5.13787530e-02f, 1.02991536e-01f, -2.99837768e-01f, -1.86206102e-01f,
  1.03946604e-01f, 4.08142507e-02f, -2.95590043e-01f, 1.33676797e-01f, -7.53414184e-02f, 5.59366308e-02f, -5.37641533e-03f, 7.50411078e-02f, 2.99172779e-03f, -2.00007826e-01f,
  -1.57899782e-02f, -7.57520944e-02f, -6.27805814e-02f, 1.04669891e-01f, 1.10132964e-02f, 8.94851163e-02f, -1.39116496e-02f, -2.06219941e-01f, 7.54494071e-02f, 1.13645405e-01f,
  1.19107805e-01f, -4.69890889e-03f, -3.67830731e-02f, 4.38627526e-02f, 1.04838666e-02f, 7.91155025e-02f, -2.14934591e-02f, 9.75440219e-02f, -9.75683630e-02f, 9.76880193e-02f,
  1.08300850e-01f, -5.47960550e-02f, 1.48629084e-01f, -3.06265634e-02f, 9.19635966e-02f, 1.07237749e-01f, 1.78474441e-01f, -1.12405168e-02f, 6.58144876e-02f, 2.45055124e-01f,
  -2.32862215e-02f, 5.41106379e-03f, 7.79360235e-02f, -4.41689007e-02f, 1.59061894e-01f, -5.23445979e-02f, 1.92310885e-01f, 1.26437927e-02f, 1.56495571e-01f, -1.14772931e-01f,
  -3.19494419e-02f, 1.95685223e-01f, -3.56624797e-02f, -1.36582345e-01f, 2.10216254e-01f, 4.06222828e-02f, 3.93975563e-02f, -7.75900260e-02f, 5.50954677e-02f, -1.17153272e-01f,
  -1.12653062e-01f, -1.68865010e-01f, 1.57482415e-01f, 4.69688922e-02f, 2.06684187e-01f, -5.68311755e-03f, 1.82681486e-01f, 2.50691473e-02f, -2.84328371e-01f, 1.36279866e-01f,
  1.04466945e-01f, -1.46306023e-01f, -8.13306421e-02f, -3.00429482e-02f, 5.23026288e-02f, -1.75904766e-01f, -1.42535895e-01f, 5.46246879e-02f, -5.75329252e-02f, -1.40585333e-01f,
  -9.91126671e-02f, -2.31576674e-02f, -2.80237552e-02f, -4.62688506e-02f, -1.06723040e-01f, -1.95994332e-01f, 1.02169693e-01f, -6.81560934e-02f, 2.14160215e-02f, -8.66275951e-02f,
  8.99061095e-03f, 1.06931575e-01f, -6.52564503e-03f, 1.56284004e-04f, 3.50029245e-02f, 8.36847536e-03f, 7.62428418e-02f, -1.34663329e-01f, 1.73623145e-01f, -1.57218203e-02f,
  -1.72856718e-01f, -1.21755846e-01f, -8.96853656e-02f, 1.13117978e-01f, 3.92727228e-03f, -7.15469792e-02f, -1.12995997e-01f, 4.70247157e-02f, 7.64859393e-02f, -5.14972508e-02f,
  9.76283774e-02f, -1.14874225e-02f, -7.01755211e-02f, -1.98689848e-01f, -1.17014796e-01f, 1.93434760e-01f, -3.28889608e-01f, -2.25523919e-01f, 1.66227412e-03f, -4.11765911e-02f,
  8.67427215e-02f, 4.99716736e-02f, -2.61295736e-01f, -6.40350059e-02f, 2.52942324e-01f, -1.59065291e-01f, 2.41355523e-01f, 3.00461918e-01f, 1.05176285e-01f, -1.78659037e-01f,
  -5.51025942e-03f, -2.31190071e-01f, -3.96919250e-01f, -1.50714874e-01f, -2.95932777e-02f, -6.50561601e-02f, -1.02697700e-01f, 2.24819724e-02f, -4.54605035e-02f, 2.13090889e-02f,
  -6.00148514e-02f, -8.80536512e-02f, -1.78007320e-01f, 1.34653375e-01f, 2.87931025e-01f, 2.86972541e-02f, -1.96993211e-03f, 1.12910926e-01f, 1.08546615e-01f, -1.38375713e-02f,
  1.42521635e-01f, -7.18045384e-02f, -8.00945237e-02f, -4.45314273e-02f, -1.29337773e-01f, -1.42388284e-01f, -6.19448796e-02f, -1.27189696e-01f, 7.59823620e-03f, -1.11130305e-01f,
  -1.15404166e-01f, -7.46492529e-03f, 1.00471430e-01f, 6.28848225e-02f, -8.75894800e-02f, 3.92936589e-03f, -1.78014293e-01f, -1.73201263e-02f, -8.25071856e-02f, -1.76815465e-01f,
  -5.61378635e-02f, -1.52039945e-01f, -2.86424942e-02f, -1.64683059e-01f, -1.67872995e-01f, -1.43897802e-01f, -1.59657300e-01f, -1.23998418e-01f, 4.25624587e-02f, -1.88534856e-02f,
  1.70284063e-01f, 4.98258881e-02f, -1.76300481e-02f, -1.56330854e-01f, -7.89869297e-03f, -1.43259719e-01f, -7.56623074e-02f, -2.48631820e-01f, -4.53872345e-02f, 1.77514434e-01f,
  -2.25197792e-01f, 1.62688363e-02f, -1.72057990e-02f, -1.41691700e-01f, -1.67994335e-01f, 1.13561228e-02f, 3.10306530e-02f, -1.88974768e-01f, -1.38357341e-01f, 1.80365890e-02f,
  -1.03144936e-01f, -4.36561108e-02f, 5.36139533e-02f, -8.19849968e-02f, 2.06059460e-02f, 1.48698077e-01f, -1.06181670e-03f, 7.79750338e-03f, -2.28734761e-02f, 1.10820264e-01f,
  -1.02058128e-01f, 9.43052247e-02f, 6.02275319e-02f, 7.98171088e-02f, -8.85070488e-02f, 1.82685733e-01f, 1.41613809e-02f, 1.26424089e-01f, 1.07549839e-01f, 9.78819430e-02f,
  6.29684553e-02f, 7.21005797e-02f, 1.54173821e-01f, 7.75605366e-02f, 1.17727190e-01f, 3.86073329e-02f, 7.21550826e-03f, -1.02551162e-01f, -5.04812710e-02f, 1.16930865e-01f,
  4.91357557e-02f, 2.03986958e-01f, 1.35758042e-01f, -6.37752179e-04f, 1.64021328e-01f, -5.85208498e-02f, 1.11619145e-01f, 2.74763796e-02f, 8.66638869e-02f, 6.70024892e-03f,
  1.28449783e-01f, -1.81442872e-01f, -3.04968972e-02f, 1.71881258e-01f, -1.54203296e-01f, -2.27554768e-01f, 8.00896212e-02f, 3.42262059e-01f, -1.32622480e-01f, 1.30065098e-01f,
  -1.70999005e-01f, 2.56808758e-01f, 2.34476477e-01f, -1.14189409e-01f, 3.36998701e-01f, 1.64527774e-01f, -1.02683611e-01f, 1.06040739e-01f, 2.76237756e-01f, -1.04031049e-01f,
  9.11973193e-02f, -1.71395317e-02f, 4.41374853e-02f, -1.81105360e-01f, -1.61329042e-02f, 4.87318933e-02f, -1.35729849e-01f, 1.45163506e-01f, -1.74714178e-01f, -1.59305111e-01f,
  -3.57258669e-03f, 1.80765167e-01f, 8.70188326e-02f, 1.53688416e-01f, 1.13424994e-01f, -5.49395420e-02f, -1.33543372e-01f, -9.17758122e-02f, -6.61957264e-02f, -7.30592161e-02f,
  -8.15308243e-02f, -1.05796449e-01f, -4.91104871e-02f, -7.36225247e-02f, 6.65743873e-02f, 1.54768884e-01f, 1.03951089e-01f, -6.08185865e-02f, -9.20919050e-03f, -1.95922658e-01f,
  6.52980208e-02f, 5.56982756e-02f, 1.95262283e-02f, -4.15006429e-02f, 1.15262069e-01f, -5.75343817e-02f, -5.94420126e-03f, 1.05770342e-01f, 1.25008091e-01f, 7.89367408e-02f,
  1.57772765e-01f, 3.69031504e-02f, 8.21632221e-02f, 2.45375499e-01f, 1.11410990e-01f, 8.85133967e-02f, -1.10651307e-01f, -7.16012418e-02f, -4.55630794e-02f, 7.99703076e-02f,
  -6.88520074e-02f, 2.18948647e-01f, -1.41072497e-01f, 1.39057919e-01f, 1.64124042e-01f, 2.70319432e-01f, -2.08632313e-02f, 4.40190919e-02f, 1.50157318e-01f, -1.29600286e-01f,
  -1.74182802e-01f, 1.59920707e-01f, 7.24684149e-02f, 2.90311184e-02f, 1.82836205e-01f, -2.77417935e-02f, -1.39221221e-01f, -1.66917011e-01f, -3.47959027e-02f, 1.26676396e-01f,
  4.25470285e-02f, 1.32235840e-01f, -1.27827361e-01f, 6.26163706e-02f, 1.19097650e-01f, 3.52178663e-02f, -9.14636627e-02f, -6.97339303e-04f, 1.77222207e-01f, -7.13170320e-02f,
  1.14364199e-01f, 9.97210070e-02f, 3.34878825e-02f, -1.88256532e-01f, -1.24519439e-02f, 4.10477668e-02f, -1.06583111e-01f, -1.47125125e-01f, 5.06602265e-02f, 5.46314046e-02f,
  -3.31591964e-02f, -4.17319909e-02f, 3.24690305e-02f, 9.91549045e-02f, -1.66001931e-01f, -6.49126098e-02f, -3.84346358e-02f, -8.64672661e-02f, -9.39128846e-02f, 1.48773717e-03f,
  -7.09718168e-02f, -7.36411959e-02f, -4.27394100e-02f, 7.23442957e-02f, -3.56998108e-02f, -1.47568703e-01f, -2.70743724e-02f, 1.99819915e-02f, -1.62728786e-01f, -1.03347152e-01f,
  9.97228101e-02f, -1.78966746e-01f, 1.62394598e-01f, 5.93252853e-02f, -4.15290967e-02f, -1.08137876e-01f, -3.34600024e-02f, -9.95201394e-02f, 1.61041856e-01f, -1.75983101e-01f,
  -5.89744970e-02f, 2.23407120e-01f, -3.27363819e-01f, -1.18122227e-01f, 1.82573289e-01f, -1.28155604e-01f, -2.69496173e-01f, 8.16069394e-02f, -1.64731387e-02f, 3.13952006e-02f,
  -8.89334008e-02f, 1.76425368e-01f, 1.04333714e-01f, -1.53432801e-01f, 1.41074821e-01f, -2.20683306e-01f, 1.14201605e-01f, 1.38332516e-01f, 9.82626826e-02f, -1.48149177e-01f,
  -2.50909120e-01f, -8.49654451e-02f, 2.67192945e-02f, -1.28197810e-02f, 1.39298541e-02f, -3.91755588e-02f, -1.12715140e-01f, 8.01095963e-02f, 1.14605956e-01f, 6.87002912e-02f,
  7.61827305e-02f, -2.04880051e-02f, -6.46440461e-02f, -4.32270253e-03f, 8.08383599e-02f, 1.30089298e-01f, -7.09291548e-02f, 1.72478303e-01f, -1.80587113e-01f, 1.12621367e-01f,
  -3.19676660e-02f, 7.47956187e-02f, 8.20478573e-02f, 4.03638445e-02f, -6.55147880e-02f, 8.10463801e-02f, 9.72849801e-02f, 6.07722765e-03f, 1.28791228e-01f, 9.92432535e-02f,
  1.96058042e-02f, -1.78038388e-01f, -2.52169549e-01f, -5.40126897e-02f, 5.96783794e-02f, -1.44548848e-01f, -5.43112345e-02f, -1.60056859e-01f, -7.62009155e-03f, 3.92428646e-03f,
  -7.15813786e-02f, -1.39635667e-01f, -2.47293323e-01f, -3.13682742e-02f, -7.59934932e-02f, 1.58264562e-01f, 1.80382505e-01f, -1.23968326e-01f, -2.85524964e-01f, 9.06670094e-02f,
  2.74367571e-01f, 2.06684589e-01f, -4.98294272e-02f, -3.28793824e-01f, -1.23584727e-02f, 4.72978055e-02f, -1.70412183e-01f, 5.20420335e-02f, 1.35451883e-01f, 2.86905766e-02f,
  3.47846523e-02f, -1.81417018e-01f, -1.34520615e-02f, 2.38159925e-01f, -9.90207940e-02f, 1.08247712e-01f, 8.45234245e-02f, 9.17108208e-02f, -1.81459617e-02f, -5.87374941e-02f,
  -1.10587068e-01f, -5.94754843e-03f, -1.04904428e-01f, 3.04824561e-02f, -7.73829222e-02f, -7.56289884e-02f, -1.79821365e-02f, 4.24314961e-02f, 1.28840014e-01f, -5.99324107e-02f,
  4.60142791e-02f, 1.13359988e-01f, -8.86404961e-02f, 4.24816273e-03f, -9.06606689e-02f, -1.79986417e-01f, 4.37966734e-02f, 2.52695624e-02f, -3.10925432e-02f, -1.22281432e-01f,
  -7.86955580e-02f, -1.00172296e-01f, -6.61289468e-02f, -1.14533395e-01f, 2.65329361e-01f, -4.84898984e-02f, -1.88480809e-01f, -1.53912693e-01f, -1.63659707e-01f, 4.83565740e-02f,
  -9.14592519e-02f, -2.12635532e-01f, 1.10070542e-01f, 3.31423998e-01f, 7.19133690e-02f, 1.34211138e-01f, -1.92097962e-01f, -2.64780641e-01f, 2.33987167e-01f, 1.71244547e-01f,
  1.90066516e-01f, -4.19452041e-02f, 1.94518611e-01f, -7.28395432e-02f, -7.89667517e-02f, -3.55250910e-02f, -3.87160033e-01f, -1.00277141e-01f, -2.58642714e-02f, -6.09515235e-02f,
  3.79475988e-02f, -1.74770012e-01f, -1.44249678e-01f, -5.44315092e-02f, 4.19197902e-02f, 8.36733505e-02f, -8.13605115e-02f, 1.07592598e-01f, 1.24299355e-01f, 1.93393767e-01f,
  4.83918674e-02f, 2.25526132e-02f, 1.02742121e-01f, -4.29955013e-02f, -9.67691690e-02f, -1.39144570e-01f, -4.75710556e-02f, -4.23875675e-02f, 5.96689098e-02f, 1.88012347e-01f,
  4.24866006e-02f, 1.37458757e-01f, 1.64619237e-01f, 1.15775270e-02f, 4.85939160e-03f, 1.87697411e-01f, -2.05742940e-01f, -3.26089598e-02f, 1.86992567e-02f, 1.12038836e-01f,
  1.14804924e-01f, -5.35830185e-02f, -5.71484342e-02f, 1.71946719e-01f, -7.09167793e-02f, -9.24980342e-02f, 6.80920342e-03f, 1.90779865e-01f, 5.40799536e-02f, 5.69501258e-02f,
  -7.02207610e-02f, -8.10285434e-02f, 8.69813934e-02f, -2.24261597e-01f, 1.21130221e-01f, -1.36213794e-01f, -2.79240552e-02f, 1.44188672e-01f, -3.12305868e-01f, -9.87833068e-02f,
  -1.87789239e-02f, 4.43984196e-02f, 3.92500274e-02f, 2.54694372e-01f, -2.13102371e-01f, -3.45893383e-01f, -1.25169054e-01f, 2.50907898e-01f, 1.00394920e-01f, 4.65372168e-02f,
  3.00390333e-01f, -2.45285764e-01f, -7.26065971e-03f, 6.53989017e-02f, -1.09147102e-01f, -2.39537600e-02f, 1.69886902e-01f, 8.10630694e-02f, 6.94865957e-02f, -1.37754500e-01f,
  2.15462707e-02f, 3.26028764e-02f, -1.83207840e-01f, 3.93541418e-02f, -9.95889232e-02f, -3.43429483e-02f, 9.60068554e-02f, -2.64149576e-01f, 7.53106475e-02f, -2.97246426e-02f,
  -1.12229595e-02f, -1.89619213e-01f, -1.24516347e-02f, -1.08205892e-01f, -1.37318388e-01f, -2.08584607e-01f, -1.21768221e-01f, -8.67873058e-02f, -1.12946436e-01f, -1.37013122e-01f,
  -1.59568235e-01f, 1.03740260e-01f, 6.05975427e-02f, 6.79665282e-02f, 9.01263729e-02f, -7.71427602e-02f, -1.27718717e-01f, 1.32540554e-01f, 6.59110397e-02f, -8.79064500e-02f,
  -8.28684792e-02f, -5.18623553e-02f, -2.59778172e-01f, -2.18309671e-01f, -1.08707033e-01f, 2.47626975e-01f, 2.72834927e-01f, -1.40385807e-01f, 1.46539018e-01f, -8.96750912e-02f,
  -3.32197803e-03f, -2.40483314e-01f, 1.42454848e-01f, -1.02748886e-01f, 1.49708033e-01f, -3.19356382e-01f, -3.27746004e-01f, 8.12642053e-02f, 8.61515030e-02f, 1.24284737e-01f,
  -2.00743988e-01f, -3.29809427e-01f, -1.01548091e-01f, 1.63254201e-01f, 4.54156920e-02f, -1.59581173e-02f, -6.53935000e-02f, 2.10971788e-01f, -2.32866351e-02f, 1.10042945e-01f,
  5.62266447e-02f, -2.59591788e-02f, 4.02749367e-02f, -6.47371113e-02f, 1.39932502e-02f, -1.87273204e-01f, -4.65641357e-02f, 1.40556067e-01f, -1.39575496e-01f, -1.74129203e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  7.78130963e-02f, 8.09811652e-02f, 1.83223248e-01f, 2.36727253e-01f, 5.08778356e-02f, 2.36128017e-01f, -2.64535286e-02f, -3.02853473e-02f, -7.50959888e-02f, 1.69753984e-01f,
  1.03007229e-02f, 1.81206748e-01f, 1.74998626e-01f, 4.98045683e-02f, 8.05920511e-02f, 7.23939165e-02f, 2.08750308e-01f, -2.43175964e-04f, 6.55955374e-02f, -5.70675777e-03f,
  2.38206163e-01f, 5.28366677e-02f, 1.77229598e-01f, 1.30402163e-01f, 2.50419192e-02f, -1.41437307e-01f, 2.44609207e-01f, -1.45937905e-01f, 1.07577749e-01f, 1.41474217e-01f,
  -8.00877437e-02f, 1.10842906e-01f, -9.36732516e-02f, 8.95985812e-02f, 3.16579491e-01f, -1.01836063e-01f, 2.70051450e-01f, -3.18044089e-02f, 6.32124543e-02f, -2.82035947e-01f,
  -2.39292741e-01f, -2.17953008e-02f, 2.21199580e-02f, 2.91751087e-01f, 3.09831172e-01f, -1.02600105e-01f, -1.15704879e-01f, 1.81809124e-02f, -4.61504966e-01f, 3.68880063e-01f,
  5.90568734e-03f, 1.36461273e-01f, 2.66839862e-01f, -2.34076843e-01f, -1.47476226e-01f, 5.16475774e-02f, -5.72821945e-02f, 1.68145820e-02f, -1.74034797e-02f, -2.45024189e-01f,
  2.99344689e-01f, -2.75423788e-02f, -6.95616752e-02f, -9.98609662e-02f, 3.09750009e-02f, 9.83490348e-02f, 1.03602186e-01f, 1.51789114e-01f, 2.11783230e-01f, -1.01268500e-01f,
  7.32145607e-02f, -7.25852698e-02f, 1.12699933e-01f, -1.29228294e-01f, 1.63068213e-02f, -3.98577191e-02f, 1.96968645e-01f, -2.13038102e-02f, 4.59937043e-02f, 1.69608355e-01f,
  7.05988631e-02f, 1.56535935e-02f, -4.33236733e-02f, 1.16629846e-01f, 1.16401777e-01f, -4.60159704e-02f, 5.01155257e-02f, 6.79436997e-02f, 8.93170610e-02f, -1.55840591e-01f,
  -1.42797559e-01f, -1.47043262e-02f, 2.34023571e-01f, 9.14464593e-02f, 1.13021560e-01f, -3.21140327e-02f, -8.81063491e-02f, -1.39290066e-02f, 8.25365633e-02f, -2.75991201e-01f,
  5.77723347e-02f, -9.53902900e-02f, 8.33895952e-02f, -3.21271829e-02f, -1.23123087e-01f, -2.64684707e-01f, 1.93440735e-01f, 2.20894605e-01f, 1.25903524e-02f, -1.19793214e-01f,
  2.20046327e-01f, -4.67770062e-02f, -3.55972275e-02f, -7.30870366e-02f, -4.45668958e-02f, -9.40445885e-02f, -6.52505830e-02f, 1.75401002e-01f, -2.08030045e-02f, 5.67308962e-02f,
  -1.97096691e-02f, -1.48419347e-02f, -1.16972722e-01f, -7.76795000e-02f, 2.34417282e-02f, 4.62811403e-02f, -1.97882634e-02f, -2.27141567e-03f, 3.98529582e-02f, -5.59058785e-02f,
  7.22578019e-02f, -1.03806354e-01f, 3.21964384e-03f, -1.04677141e-01f, -5.68862967e-02f, 1.10368736e-01f, -2.09271498e-02f, 8.46433491e-02f, 3.34665962e-02f, 1.35630995e-01f,
  -1.13124978e-02f, -1.20613255e-01f, -3.05592697e-02f, 8.07962641e-02f, -6.47563636e-02f, -4.88672443e-02f, -1.19154930e-01f, -6.73861578e-02f, 2.85170246e-02f, -1.24201821e-02f,
  7.31145814e-02f, -1.07742148e-02f, -2.23913807e-02f, -7.40930811e-02f, -5.08573912e-02f, 2.73419195e-03f, 5.90420887e-02f, -5.34002744e-02f, -1.32464737e-01f, -2.50945557e-02f,
  -9.51820910e-02f, 1.21930093e-01f, -9.80500951e-02f, 1.27293438e-01f, 4.45260257e-02f, 1.11505061e-01f, -3.20764519e-02f, 1.06511272e-01f, -2.89812144e-02f, -6.98892847e-02f,
  -1.04205213e-01f, 7.18399435e-02f, 9.20968950e-02f, 4.06909809e-02f, 2.14418489e-02f, -1.54844951e-03f, 7.60288462e-02f, 1.07452452e-01f, -1.34828448e-01f, -8.71734917e-02f,
  1.15630321e-01f, 8.79427567e-02f, -1.20174915e-01f, 1.90818235e-01f, -1.67338438e-02f, -8.06478113e-02f, -9.65685397e-02f, -8.21508616e-02f, -9.49079916e-03f, 9.97255519e-02f,
  8.37124288e-02f, -7.10152239e-02f, 1.79673266e-02f, 1.00138085e-02f, 2.18919724e-01f, -8.82293358e-02f, 4.40912805e-02f, 1.13326266e-01f, 1.18525796e-01f, 1.07561622e-03f,
  1.98689073e-01f, 6.30422980e-02f, 1.49773985e-01f, 7.59645402e-02f, 6.47234023e-02f, 1.26170695e-01f, 2.82041654e-02f, -8.71059895e-02f, -7.91073740e-02f, 1.32424667e-01f,
  -1.31146237e-01f, -8.53293762e-03f, 1.94104850e-01f, -9.91975218e-02f, 1.55645370e-01f, 1.78755760e-01f, -9.11675096e-02f, 1.05950907e-01f, 4.32867147e-02f, 7.04004467e-02f,
  -2.37371415e-01f, -2.32310295e-01f, -2.54582494e-01f, -1.95675895e-01f, 8.01592767e-02f, 1.09829446e-02f, -1.62789628e-01f, -1.81144327e-02f, -2.27001995e-01f, -1.13069765e-01f,
  -3.65766212e-02f, 1.26979157e-01f, 2.56491125e-01f, 3.69153507e-02f, -6.93719164e-02f, -2.19411492e-01f, -6.97615072e-02f, 1.11223951e-01f, -1.67004079e-01f, -3.55847403e-02f,
  -1.39914960e-01f, -2.22989962e-01f, -1.10023625e-01f, -1.00194551e-01f, 1.09981775e-01f, 6.30679131e-02f, 1.61819965e-01f, 2.79316828e-02f, 1.09780744e-01f, 5.17613403e-02f,
  4.83582281e-02f, 1.97914734e-01f, 1.08780459e-01f, 2.26622615e-02f, -1.26797399e-02f, -1.16432738e-02f, 1.78729385e-01f, 1.48992360e-01f, 1.68826669e-01f, 7.33758509e-02f,
  -4.61232737e-02f, 8.27676281e-02f, 1.69023246e-01f, -8.66434649e-02f, 1.86555266e-01f, 9.77142155e-02f, 5.72957657e-02f, 6.98653832e-02f, -4.58400957e-02f, 1.29476517e-01f,
  1.27402330e-02f, -7.87344761e-03f, -4.12568226e-02f, 3.74093130e-02f, 9.82050039e-03f, 1.08210191e-01f, -8.19654018e-02f, 8.70616361e-02f, -4.72481884e-02f, 1.16642274e-01f,
  1.06585898e-01f, 9.67523754e-02f, -1.67357117e-01f, -3.53322513e-02f, -1.93810001e-01f, -3.25473733e-02f, 6.16511554e-02f, -1.46883711e-01f, 6.43019676e-02f, 2.95258593e-02f,
  -6.63315356e-02f, -1.42748326e-01f, -1.26554906e-01f, -1.83234096e-01f, -7.44228512e-02f, -1.30886242e-01f, 1.04123987e-01f, 2.78891593e-01f, -1.46439657e-01f, -1.63406551e-01f,
  -7.66873956e-02f, -1.08949266e-01f, -1.64254233e-01f, 1.50142774e-01f, -6.29918128e-02f, -2.29401305e-01f, -1.12886772e-01f, 2.37806305e-01f, -5.48129007e-02f, 5.28589226e-02f,
  1.71611890e-01f, 5.54767698e-02f, 2.04139091e-02f, 1.27380133e-01f, 7.72301629e-02f, -1.44306552e-02f, -3.35318744e-02f, -8.74461755e-02f, 7.17711374e-02f, 1.26753813e-02f,
  3.13072116e-03f, 7.27006048e-02f, -4.42721546e-02f, 6.97837770e-02f, 1.11382768e-01f, -6.49528652e-02f, -7.22839534e-02f, -9.13374498e-03f, 4.55591939e-02f, -1.21079467e-03f,
  2.84113120e-02f, -4.93156947e-02f, 1.32483676e-01f, 5.74022159e-02f, 3.30082886e-02f, -7.16301203e-02f, -9.84253082e-03f, 2.45069005e-02f, -3.44601572e-02f, -8.18006024e-02f,
  -1.13774436e-02f, -1.19012762e-02f, 1.31701753e-02f, -1.26273986e-02f, -2.40054615e-02f, -8.38078335e-02f, -3.48310582e-02f, -8.48403797e-02f, 1.46995140e-02f, 1.48021176e-01f,
  -9.46803689e-02f, 1.38811052e-01f, -1.43485352e-01f, -7.96301365e-02f, -9.94515866e-02f, 8.37003067e-02f, 1.11299329e-01f, -5.24403267e-02f, 2.21201871e-02f, -7.34575689e-02f,
  4.13808301e-02f, -7.55907893e-02f, 1.47434875e-01f, 1.97784558e-01f, 5.42092025e-02f, 8.30717087e-02f, 1.54833362e-01f, -1.05348393e-01f, -4.85974215e-02f, -7.98790306e-02f,
  -1.12349428e-01f, 1.30535597e-02f, 1.19305804e-01f, 1.52169213e-01f, 7.13058515e-04f, 2.02680845e-02f, 7.33104646e-02f, -6.54137433e-02f, 7.43152276e-02f, 4.74451818e-02f,
  7.68798441e-02f, 1.76388234e-01f, 7.10241199e-02f, -1.22553416e-01f, -7.07602454e-03f, -5.83444200e-02f, 4.12644595e-02f, -9.58859921e-02f, 7.82267973e-02f, -2.45110411e-02f,
  -8.37632641e-02f, -1.01869725e-01f, -7.57605284e-02f, -1.86402872e-02f, 1.86912343e-02f, 5.50743304e-02f, 1.83496609e-01f, -5.22391535e-02f, -3.74119431e-02f, 1.22674368e-01f,
  6.85731024e-02f, -1.22143850e-01f, 1.54161021e-01f, 1.10971555e-01f, -1.27684148e-02f, -3.50946710e-02f, 1.67965114e-01f, 1.67180330e-01f, 2.48637027e-03f, 1.85593963e-02f,
  2.85074096e-02f, -5.52396327e-02f, -7.62077644e-02f, 3.33192684e-02f, -5.08185849e-02f, -2.68694405e-02f, 1.44777462e-01f, 7.94402733e-02f, -1.18834168e-01f, 1.04272425e-01f,
  8.85627940e-02f, 8.43176916e-02f, 4.10330892e-02f, -2.42902473e-01f, -1.34261489e-01f, 9.40478668e-02f, 2.21318118e-02f, -1.56088680e-01f, 1.28449857e-01f, -3.95370573e-02f,
  -1.49237007e-01f, -4.90200445e-02f, -7.64910281e-02f, -4.04969752e-02f, -1.23498537e-01f, 1.89675912e-01f, 1.11424133e-01f, -1.28145263e-01f, 3.32956649e-02f, 4.15114649e-02f,
  3.63745652e-02f, -2.73215938e-02f, -4.71777879e-02f, -9.04541984e-02f, 9.51450542e-02f, -4.12455313e-02f, 9.00039449e-02f, -8.06861967e-02f, 1.48593605e-01f, 2.28913024e-01f,
  1.31451681e-01f, 1.12133712e-01f, -3.25185172e-02f, 1.08365774e-01f, 1.33874230e-02f, 1.71212032e-01f, 1.52514189e-01f, 3.05649906e-01f, 1.17367387e-01f, 9.04678330e-02f,
  -8.46744552e-02f, 5.71057945e-02f, -5.73580377e-02f, 2.34669939e-01f, 1.57726265e-03f, 1.33927330e-01f, -4.76945415e-02f, 1.06998004e-01f, 9.30816606e-02f, 8.79784394e-03f,
  1.67366818e-01f, -5.97964488e-02f, 1.01768132e-02f, 8.70172828e-02f, 1.46983370e-01f, 3.93350385e-02f, 2.22264752e-02f, 1.29701495e-01f, 7.84219988e-03f, 1.85668409e-01f,
  2.42810369e-01f, 1.61435515e-01f, 1.20553948e-01f, 1.97230414e-01f, 4.32407558e-02f, 1.43511459e-01f, 1.18440643e-01f, 2.45902508e-01f, 1.50658637e-01f, 1.28910199e-01f,
  -2.88858861e-01f, -2.23633647e-01f, -2.26023383e-02f, 2.97072202e-01f, -9.98371765e-02f, 1.53295964e-01f, 3.33098859e-01f, 2.94413775e-01f, 1.86699942e-01f, 9.50444564e-02f,
  4.14757282e-02f, -3.04023232e-02f, -3.80507223e-02f, 1.20764710e-01f, 6.76179752e-02f, 4.33440544e-02f, 3.47620368e-01f, 1.40688419e-01f, -1.90416560e-01f, 4.91978228e-02f,
  1.37358144e-01f, -2.94570271e-02f, 2.35418901e-01f, -7.44243935e-02f, -9.04613435e-02f, 8.75165761e-02f, 6.19245805e-02f, 3.31497192e-02f, 2.45036438e-01f, 6.40455037e-02f,
  1.63414627e-01f, 1.44375980e-01f, -8.01818818e-02f, 8.68512169e-02f, 4.68469448e-02f, 1.41425014e-01f, 9.10554379e-02f, 1.11693166e-01f, 7.29807317e-02f, 1.88897103e-01f,
  2.87846047e-02f, -2.22664606e-02f, -4.19276319e-02f, 1.13559090e-01f, 1.26848504e-01f, -3.66251392e-04f, 1.25698343e-01f, 8.51782560e-02f, -9.07361582e-02f, -1.76848397e-01f,
  -8.48016217e-02f, 1.92358777e-01f, 6.80435523e-02f, -8.81326944e-02f, 8.21928158e-02f, -1.94950439e-02f, -8.68750587e-02f, 8.07793159e-03f, -1.59619406e-01f, -1.15486696e-01f,
  -1.35571152e-01f, -3.02858260e-02f, -2.27632701e-01f, -1.54566662e-02f, 1.87744379e-01f, -1.83589514e-02f, -2.78569013e-01f, -5.21709509e-02f, 1.74712583e-01f, 1.03855856e-01f,
  1.72334313e-01f, -1.39639288e-01f, -1.06400006e-01f, 1.64442554e-01f, -5.96675016e-02f, 1.49221554e-01f, -2.69384999e-02f, 2.52379686e-01f, 6.81237280e-02f, -1.13873146e-01f,
  -3.63636389e-03f, -5.80852255e-02f, 7.16929436e-02f, 1.86584115e-01f, -1.37606233e-01f, -5.24908770e-03f, 3.89745981e-02f, 4.48680334e-02f, 1.34589165e-01f, 9.18356031e-02f,
  5.59652783e-02f, -2.81319534e-03f, 3.70805450e-02f, 1.79977134e-01f, 2.48821755e-03f, 2.14210570e-01f, 1.16023056e-01f, -5.29129542e-02f, 4.43846434e-02f, 9.36216190e-02f,
  -1.19457925e-02f, -2.61252411e-02f, 5.55486046e-02f, 2.18256384e-01f, 3.82381678e-02f, -2.52358802e-02f, 8.48248973e-02f, -3.15058157e-02f, 1.09543957e-01f, 1.16953021e-02f,
  6.51967451e-02f, -1.07909203e-01f, -1.96299143e-02f, 5.73722459e-02f, 2.08483204e-01f, 4.20816317e-02f, -1.41084731e-01f, -6.65538311e-02f, 7.90040568e-02f, 1.21277153e-01f,
  -6.17349520e-02f, 1.27502948e-01f, -1.90019161e-01f, 1.04583867e-01f, 1.13919854e-01f, 2.48660538e-02f, 9.11189541e-02f, -1.15272991e-01f, -1.50002658e-01f, 5.94859868e-02f,
  5.42654209e-02f, -7.86254779e-02f, -2.11733505e-01f, -1.97964072e-01f, 1.06799148e-01f, 1.47517860e-01f, -3.85787785e-02f, -1.52906790e-01f, 1.61430970e-01f, 9.79167745e-02f,
  3.23378369e-02f, 6.95496276e-02f, -1.40441194e-01f, 1.24310650e-01f, 6.01809658e-02f, -4.53745946e-02f, 7.79988617e-02f, -4.86638471e-02f, -5.50647229e-02f, 1.11061655e-01f,
  9.07120407e-02f, 1.67093456e-01f, -4.13639210e-02f, 3.43834125e-02f, 1.14631914e-01f, 5.04401326e-02f, -9.73781571e-02f, -1.11005366e-01f, 1.42585695e-01f, 1.68823868e-01f,
  -3.06242406e-02f, 1.75024662e-02f, 1.27615795e-01f, -8.14694155e-04f, 3.11842412e-02f, 1.57701433e-01f, 1.60341978e-01f, 4.57956232e-02f, 1.62764207e-01f, 1.23215228e-01f,
  4.45862077e-02f, -3.45842615e-02f, 1.60471305e-01f, 3.11660729e-02f, 1.14298664e-01f, -1.30682483e-01f, -1.03964560e-01f, 4.97504845e-02f, 1.08203720e-02f, -2.05529705e-02f,
  1.79303437e-01f, 1.53706759e-01f, -7.27999806e-02f, 1.18602626e-01f, 3.15093733e-02f, 1.58049203e-02f, 1.15067422e-01f, -4.90634702e-02f, -6.69781640e-02f, -2.44979292e-01f,
  -1.41200379e-01f, 6.66622818e-02f, -2.00377256e-02f, 5.69980964e-02f, 3.62271778e-02f, -2.13310510e-01f, 1.17329702e-01f, 1.56076834e-01f, -1.42795574e-02f, 1.61342427e-01f,
  1.18013673e-01f, 1.24436319e-01f, 1.00167520e-01f, -1.54787347e-01f, -1.19752109e-01f, -9.58518162e-02f, 1.97758436e-01f, 8.25551450e-02f, -6.40438423e-02f, -9.68841240e-02f,
  -1.17845766e-01f, -5.68678528e-02f, -1.01777039e-01f, -6.52135834e-02f, -2.89787315e-02f, -9.06360000e-02f, 4.69345786e-02f, 2.60770798e-01f, 2.03468174e-01f, 1.01207703e-01f,
  9.43644866e-02f, 1.25168324e-01f, 5.45684211e-02f, 1.08263522e-01f, -8.43811315e-03f, 1.49152324e-01f, 1.44866899e-01f, 1.32802129e-01f, -1.83737930e-02f, 2.33085722e-01f,
  6.45224676e-02f, -1.86076581e-01f, 2.61429220e-01f, 1.35319367e-01f, 8.09171349e-02f, 1.75792083e-01f, 1.91670910e-01f, 1.50631830e-01f, -5.13648652e-02f, 6.43944666e-02f,
  1.29105136e-01f, 1.47026390e-01f, -2.49296919e-01f, 1.90998688e-01f, 1.06895417e-02f, -3.08387005e-03f, 2.54857928e-01f, -2.33217493e-01f, 1.43912092e-01f, 2.85721213e-01f,
  1.25747710e-01f, 2.05251873e-01f, -9.62504968e-02f, -2.30036259e-01f, -2.40740135e-01f, 2.46467337e-01f, 1.27925038e-01f, -9.77209732e-02f, 1.42738804e-01f, 7.07018748e-02f,
  -1.98148534e-01f, 3.36534888e-01f, -3.26366797e-02f, 1.56543136e-01f, 1.47706538e-01f, 2.57500470e-01f, 1.37263790e-01f, -4.04394604e-02f, -5.88096045e-02f, 1.24110647e-01f,
  -7.85527825e-02f, -9.71717387e-02f, 1.29127219e-01f, 1.75154209e-01f, -2.08888873e-01f, -1.98342968e-02f, -5.83730452e-02f, 6.15202039e-02f, 1.64164439e-01f, 1.09326169e-01f,
  2.47026488e-01f, 1.37228161e-01f, 5.72395176e-02f, -4.25672419e-02f, 6.80470169e-02f, 1.77155852e-01f, 1.22581899e-01f, -2.52323467e-02f, -3.93142588e-02f, 1.79516494e-01f,
  1.72155909e-02f, 2.75919080e-01f, 1.90350577e-01f, 8.74193981e-02f, 8.79651755e-02f, 2.79657632e-01f, 6.75154896e-03f, 3.20865870e-01f, 2.00997181e-02f, 1.65933087e-01f,
  -7.87527487e-03f, 1.53250411e-01f, 1.81158304e-01f, -8.84733498e-02f, -2.73450434e-01f, -3.97761874e-02f, 1.50824055e-01f, -1.89542904e-01f, 2.54362285e-01f, -2.30736673e-01f,
  -9.82048810e-02f, 1.75003648e-01f, -2.36580044e-01f, -3.57566565e-01f, -2.55297482e-01f, -3.98781687e-01f, 1.27834842e-01f, 2.72491574e-01f, -2.02439904e-01f, 1.86281465e-02f,
  3.57818678e-02f, -1.05537586e-01f, -6.48629367e-02f, 8.27509612e-02f, 1.94786057e-01f, -2.61288807e-02f, 2.69032031e-01f, -1.32077321e-01f, -7.39761665e-02f, -1.25273317e-01f,
  -3.27894278e-02f, 2.26716831e-01f, 2.53948480e-01f, -1.33660942e-01f, -1.79981627e-02f, -1.80990428e-01f, 1.74934119e-01f, -2.89054643e-02f, -9.68135297e-02f, -5.68162687e-02f,
  -9.68940407e-02f, 8.11260268e-02f, 9.41646099e-02f, 2.96364948e-02f, 7.35737309e-02f, -1.62274092e-02f, -2.55610105e-02f, -8.48221853e-02f, 5.59473336e-02f, 1.29971012e-01f,
  1.91862863e-02f, 1.37102067e-01f, 2.10370459e-02f, 2.77746487e-02f, 5.19765764e-02f, -2.25514043e-02f, 1.59305960e-01f, 3.98503840e-02f, -1.06101215e-01f, 3.43530066e-02f,
  -7.83009231e-02f, -1.24370791e-01f, 6.28468394e-02f, 1.45675912e-01f, -4.76516411e-02f, 9.25153717e-02f, -9.68890339e-02f, -4.34163548e-02f, -4.36632708e-02f, -1.19699210e-01f,
  -1.80304050e-02f, 8.04987699e-02f, 3.50116678e-02f, 8.07595924e-02f, -1.71623200e-01f, 1.54043123e-01f, -2.36514844e-02f, -9.35458988e-02f, 1.01920143e-01f, 4.56088521e-02f,
  3.93663757e-02f, 9.56173092e-02f, -6.75908104e-02f, -2.21844435e-01f, 1.85977574e-02f, 2.60595560e-01f, 6.30009919e-02f, -4.56861332e-02f, -1.00931339e-01f, 6.02699369e-02f,
  -8.12983364e-02f, 6.30441308e-02f, 3.08009148e-05f, 1.03537925e-01f, -3.00750043e-02f, 1.21306501e-01f, -5.49773052e-02f, 2.05457136e-01f, -8.62511173e-02f, 1.22001030e-01f,
  9.36653093e-03f, -8.84507596e-02f, 2.15828672e-01f, 1.55423522e-01f, 5.84963188e-02f, -1.45039782e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.01944515e-01f, 1.99126944e-01f, 5.68132550e-02f, 1.23320818e-01f, 1.53562844e-01f, 1.19628292e-02f, 3.33173461e-02f, 7.77862146e-02f, 2.56387275e-02f, 6.46493137e-02f,
  9.28491279e-02f, 2.05123618e-01f, 2.76783973e-01f, 1.62189752e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.01668857e-01f, -5.07383086e-02f, -2.56951988e-01f, -2.63902724e-01f, 1.23014050e-02f, 3.95965762e-02f, -2.09008623e-02f, 9.62726623e-02f, -5.19628190e-02f, 4.91183922e-02f,
  1.94321960e-01f, 7.32196048e-02f, -2.77240038e-01f, -1.37401104e-01f, -1.41653381e-02f, 7.22274184e-02f, 1.69913858e-01f, -2.77921036e-02f, 3.75592560e-01f, -1.61994129e-01f,
  2.06519023e-01f, -3.28081220e-01f, 1.66511476e-01f, -3.05821180e-01f, 4.93849628e-02f, -8.92013609e-02f, -4.10793751e-01f, -1.33229211e-01f, -2.90466577e-01f, 3.70526373e-01f,
  -3.38840127e-01f, -2.00356930e-01f, 1.45981014e-02f, 3.59794348e-01f, 2.09753171e-01f, 1.25535667e-01f, 6.81634769e-02f, 4.19574380e-01f, -3.57973009e-01f, 2.36436680e-01f,
  1.25028249e-02f, 3.32126588e-01f, 6.09480031e-02f, -2.03609109e-01f, -3.03606898e-01f, -9.51130595e-03f, -6.34366810e-01f, -1.06639192e-01f, -4.55559641e-01f, -2.96402685e-02f,
  6.01182759e-01f, 2.36768206e-03f, 8.97777602e-02f, 4.16939221e-02f, -1.28140405e-01f, -2.06685904e-02f, -2.79115457e-02f, -2.03055814e-01f, -2.02054486e-01f, 2.53384560e-01f,
  -2.14716438e-02f, -1.20747834e-01f, -3.81528497e-01f, 3.51094067e-01f, -2.23187760e-01f, -3.47364098e-02f, -3.89332980e-01f, 4.43730019e-02f, -3.70615780e-01f, 2.63916910e-01f,
  -1.54806852e-01f, -2.47042254e-01f, 8.85515511e-02f, -8.97423103e-02f, -6.44273013e-02f, 2.24445403e-01f, -6.26403391e-02f, 6.13270001e-03f, -2.08727363e-02f, 6.41840920e-02f,
  -3.43161613e-01f, 1.26723558e-01f, 1.89318448e-01f, 2.01988161e-01f, -1.10374294e-01f, 8.00400099e-04f, 8.54847133e-02f, 8.84639397e-02f, 3.38160992e-01f, -2.76838336e-02f,
  1.94990516e-01f, -1.85769171e-01f, 9.50913504e-02f, 2.32413545e-01f, 2.62787074e-01f, 2.56399632e-01f, -1.37619048e-01f, -1.35712326e-01f, 2.24224687e-01f, 3.69487345e-01f,
  -8.46312568e-02f, 1.63241759e-01f, -8.43818206e-03f, 2.14504942e-01f, 3.34680602e-02f, -4.86049354e-01f, 6.74060136e-02f, -7.03606248e-01f, 1.12514704e-01f, 5.27965903e-01f,
  -5.10264039e-01f, -9.24461335e-02f, -2.62043536e-01f, 9.28191245e-02f, 3.34692091e-01f, -5.74338287e-02f, 9.96731147e-02f, -2.18082890e-01f, 5.03992699e-02f, -9.57069471e-02f,
  2.32682794e-01f, 3.61938655e-01f, -2.33907282e-01f, -1.12835532e-02f, 3.25511873e-01f, 4.24302280e-01f, -4.75088894e-01f, -1.75622806e-01f, -1.23240739e-01f, -5.30328415e-02f,
  1.24898136e-01f, 2.49619242e-02f, 6.87145144e-02f, -3.01661640e-01f, -6.55234046e-03f, 2.12919891e-01f, 2.11930275e-02f, -5.77792898e-02f, 1.55575097e-01f, 2.75703445e-02f,
  -5.25724329e-02f, 2.40792587e-01f, 2.79360078e-02f, 9.57501936e-04f, 8.53084549e-02f, 2.65604835e-02f, -3.22839655e-02f, -4.17436138e-02f, -3.14949304e-01f, -6.77665249e-02f,
  9.01380032e-02f, 7.10429251e-02f, -1.79318175e-01f, -3.99309158e-01f, 1.20887071e-01f, -1.40428036e-01f, 5.06258905e-02f, 1.88188702e-01f, 4.70734626e-01f, 8.03177804e-02f,
  2.85409719e-01f, -2.89501816e-01f, -1.67547077e-01f, -1.90895513e-01f, -1.60762578e-01f, -1.49399281e-01f, 2.29098927e-02f, 2.18551978e-01f, -2.14135900e-01f, -2.58883476e-01f,
  5.29213190e-01f, -7.01186478e-01f, -2.48801097e-01f, 4.55174536e-01f, 1.49353489e-01f, -3.38394672e-01f, 1.25832930e-01f, 7.93317974e-01f, -2.08534583e-01f, -4.19805907e-02f,
  -1.29348010e-01f, -1.63773019e-02f, 4.66229498e-01f, 2.33371481e-02f, 2.51880318e-01f, -3.11312765e-01f, 1.17172517e-01f, -2.32223675e-01f, 1.63357601e-01f, 1.50241762e-01f,
  1.82435378e-01f, -1.67014580e-02f, 1.75796285e-01f, 2.81061810e-02f, -1.62119865e-02f, 1.92736596e-01f, -3.47414076e-01f, -2.83553302e-01f, 1.30566120e-01f, 1.95500597e-01f,
  2.21658587e-01f, -9.13435221e-03f, -3.51160243e-02f, -3.18975955e-01f, -1.42798707e-01f, 1.39689565e-01f, -2.81010360e-01f, -1.36024877e-01f, -3.81634265e-01f, 7.22940043e-02f,
  -4.38000828e-01f, 2.49800663e-02f, -2.79044420e-01f, 2.10584715e-01f, -6.68434501e-02f, -2.07372025e-01f, -7.53238425e-02f, 3.33207518e-01f, -3.87047142e-01f, -2.65299767e-01f,
  -2.23489001e-01f, -3.88822705e-01f, -4.55426455e-01f, -1.57405987e-01f, 2.52944291e-01f, -9.71832871e-02f, -3.22083116e-01f, -1.63276196e-01f, 4.82064337e-01f, -2.25207850e-01f,
  3.73544216e-01f, -2.98751026e-01f, 1.42323017e-01f, 3.10417771e-01f, -1.78920161e-02f, 2.17216253e-01f, -9.06427577e-02f, -1.96450338e-01f, -5.33313565e-02f, 4.97434676e-01f,
  -3.91974896e-01f, -3.03756624e-01f, 3.33806127e-01f, 2.41691574e-01f, 1.78325158e-02f, -1.78039432e-01f, -2.90343910e-01f, 1.87220961e-01f, 4.96049561e-02f, -2.86654532e-01f,
  -2.06952006e-01f, -1.98780656e-01f, 3.55797098e-03f, -5.77420183e-02f, -3.66076648e-01f, 2.15910561e-02f, 2.75601260e-02f, 2.71224052e-01f, 2.75553942e-01f, -2.11418957e-01f,
  3.64795268e-01f, -1.09594673e-01f, 3.86350304e-02f, 2.16179475e-01f, 2.60538876e-01f, -3.57629061e-02f, -2.97185779e-01f, 2.47916967e-01f, 1.14674583e-01f, 2.33123600e-01f,
  1.90094784e-01f, -1.04163997e-01f, 3.19597423e-01f, -1.03853948e-01f, -1.18396729e-01f, 5.91976615e-03f, 1.22179784e-01f, 2.38312826e-01f, 1.99970812e-01f, 5.54247126e-02f,
  -1.63155887e-02f, -1.31922709e-02f, -2.68868715e-01f, -5.90069406e-02f, -3.25234771e-01f, -2.49116033e-01f, -3.06869924e-01f, -1.46824464e-01f, 4.45143431e-02f, -9.09698531e-02f,
  2.09022000e-01f, -6.25057399e-01f, -5.47135808e-03f, -2.56506860e-01f, -5.00905931e-01f, -3.31552833e-01f, 3.29991490e-01f, 3.62348825e-01f, -1.16711169e-01f, 3.07174146e-01f,
  1.72149930e-02f, -2.82176733e-01f, -8.46425667e-02f, -5.28076291e-01f, -4.99765903e-01f, -3.05937435e-02f, 2.19035462e-01f, 3.76204073e-01f, -1.16517499e-01f, -1.13624811e-01f,
  -2.38189958e-02f, 1.78114995e-02f, -2.09456518e-01f, -1.53931096e-01f, -2.11766129e-03f, -1.45157307e-01f, 2.90503651e-01f, -4.09338117e-01f, 3.93519521e-01f, 3.21723893e-02f,
  1.28151653e-02f, 4.54869606e-02f, 4.33503360e-01f, 8.69255513e-02f, -2.89452583e-01f, 8.46787393e-02f, 1.41821295e-01f, -5.04752576e-01f, 1.87129617e-01f, 8.45185146e-02f,
  1.14337690e-01f, 2.53599379e-02f, 7.59111792e-02f, 2.95075476e-02f, 4.20329310e-02f, 6.11162335e-02f, 3.53930853e-02f, -2.67044097e-01f, 3.14404219e-02f, 1.12558864e-02f,
  1.86426848e-01f, 2.92427838e-01f, -8.48618988e-03f, 2.43441299e-01f, -3.94625396e-01f, -1.77915871e-01f, -4.16214503e-02f, -2.05943763e-01f, -2.28504926e-01f, 4.06100243e-01f,
  -2.44500116e-01f, -2.28389829e-01f, -2.98991531e-01f, 3.83614074e-03f, 4.30656131e-03f, 1.60375774e-01f, -2.34314084e-01f, 2.75441289e-01f, -2.00459287e-01f, 2.60941982e-01f,
  2.57433504e-01f, -5.16708672e-01f, -2.27267191e-01f, 6.07552707e-01f, 3.39611828e-01f, -5.56884222e-02f, -4.84089196e-01f, -4.27884281e-01f, 2.19129503e-01f, -3.46528083e-01f,
  -2.27013305e-01f, -2.48273611e-01f, -1.19874359e-03f, -1.04642816e-01f, -1.67336926e-01f, -1.69591278e-01f, -1.35755584e-01f, 6.44061506e-01f, -3.25790942e-01f, 3.02175343e-01f,
  -4.85345088e-02f, 5.10432012e-03f, 3.38427685e-02f, -2.40766816e-02f, 5.86456917e-02f, 8.83293077e-02f, 5.49334586e-02f, 1.13293976e-01f, -3.08684975e-01f, 1.28491402e-01f,
  -1.61808934e-02f, -1.38578504e-01f, -1.26550078e-01f, -1.08614542e-01f, -3.42095852e-01f, -8.02858695e-02f, -1.21152783e-02f, -2.07153052e-01f, -6.46704957e-02f, 1.37111992e-01f,
  -2.46093974e-01f, 1.42637178e-01f, 4.29948956e-01f, -5.79548627e-03f, 1.16201699e-01f, -2.13332504e-01f, -3.22329760e-01f, -3.89434993e-01f, 3.06455284e-01f, -7.44104013e-03f,
  -4.16967981e-02f, 5.72231472e-01f, 3.99350256e-01f, 2.86485910e-01f, 2.02797681e-01f, 1.03444897e-01f, -1.87350020e-01f, -5.18672764e-01f, 3.85119766e-02f, -4.66104537e-01f,
  -3.45014095e-01f, -3.51595759e-01f, -2.08327740e-01f, 2.68328398e-01f, -2.00632766e-01f, -2.90805340e-01f, 1.68364957e-01f, 5.26086874e-02f, -7.67814443e-02f, 6.13540858e-02f,
  3.43394876e-01f, -3.85308921e-01f, 2.56379515e-01f, -3.22833836e-01f, -3.01050633e-01f, -2.08064988e-01f, 3.49858850e-02f, 1.94074064e-01f, 2.55163610e-01f, -1.57674491e-01f,
  -1.82915986e-01f, 3.58558744e-01f, -1.04749005e-03f, -1.92984402e-01f, -1.77681819e-01f, -1.21485420e-01f, 4.07386035e-01f, -1.99374780e-01f, -1.51321203e-01f, 1.78601164e-02f,
  2.32689735e-02f, -5.21681532e-02f, 1.01260886e-01f, -2.73379743e-01f, 8.82601663e-02f, 5.08615328e-03f, -1.74305454e-01f, 2.27124002e-02f, 2.05121681e-01f, 3.87037843e-02f,
  5.90807088e-02f, 1.94520175e-01f, -2.57073253e-01f, 1.39663056e-01f, 7.43835941e-02f, 1.15786649e-01f, -3.99591148e-01f, -1.01840578e-01f, -1.79412201e-01f, 2.58464646e-02f,
  1.14565827e-01f, 1.87445924e-01f, 1.94710158e-02f, 4.58418220e-01f, -3.75894934e-01f, 4.49441135e-01f, -5.96199259e-02f, -1.26104936e-01f, -2.82289743e-01f, 3.08403373e-01f,
  3.17326128e-01f, 4.54536617e-01f, -1.27089083e-01f, 1.56164482e-01f, -3.46272826e-01f, -1.80946231e-01f, 2.89183408e-01f, -3.91829282e-01f, -5.57741702e-01f, -8.58434215e-02f,
  -1.52216151e-01f, 2.23937452e-01f, 2.22229481e-01f, -1.91149592e-01f, 5.30100055e-02f, -1.57822683e-01f, 3.76808718e-02f, 8.26910958e-02f, -3.03362817e-01f, -7.32620358e-02f,
  1.96023405e-01f, 2.91980822e-02f, -3.05176992e-02f, 1.77115500e-01f, -1.37750700e-01f, 1.78735465e-01f, 4.52109396e-01f, 1.39785141e-01f, -1.93141565e-01f, -4.77298871e-02f,
  -2.07588896e-01f, 2.61965007e-01f, 5.36471233e-02f, -1.40318111e-01f, -2.12283716e-01f, -1.67658359e-01f, 1.64070264e-01f, -9.79271308e-02f, 1.50956064e-01f, 2.71666974e-01f,
  2.01213628e-01f, -4.15315852e-02f, 6.30136952e-02f, -8.49480927e-02f, -4.47121821e-03f, 6.01660237e-02f, 1.41260192e-01f, 9.19196848e-03f, 2.74466693e-01f, 1.20106578e-01f,
  3.30034971e-01f, -5.35600595e-02f, -4.09195013e-02f, 2.24104077e-01f, 1.13840662e-02f, 1.21754348e-01f, -9.34944004e-02f, -1.51113868e-01f, 2.35421032e-01f, -2.12735042e-01f,
  3.74477565e-01f, -2.13537827e-01f, 5.54367125e-01f, 2.12950003e-03f, 6.24138899e-02f, 4.78158176e-01f, -1.37131974e-01f, 4.83326018e-01f, 2.82551646e-01f, 1.48778170e-01f,
  3.93827885e-01f, 1.86761051e-01f, -8.42298642e-02f, 2.03970224e-01f, 3.67416769e-01f, -6.04665615e-02f, -1.33667335e-01f, 4.86348599e-01f, 3.10816579e-02f, 6.17216766e-01f,
  2.91003764e-01f, -4.21664894e-01f, -1.70761928e-01f, -1.49109021e-01f, -6.91052526e-02f, 5.24824083e-01f, 3.21161687e-01f, -6.41139522e-02f, 1.07980356e-01f, -1.69056386e-01f,
  -2.76672900e-01f, 1.04564145e-01f, -1.25427589e-01f, -2.55102605e-01f, 2.86592916e-02f, -2.33999252e-01f, 2.03939661e-01f, -7.32969046e-02f, 1.01765633e-01f, -2.14767888e-01f,
  1.15982808e-01f, 3.58094722e-01f, 8.42046291e-02f, 2.77861387e-01f, 5.54932281e-02f, -1.90662563e-01f, 6.16418794e-02f, -2.37283021e-01f, -1.15573138e-01f, -2.88520545e-01f,
  9.27415192e-02f, 1.22556731e-01f, -4.79111932e-02f, -4.23237160e-02f, 2.76450455e-01f, 3.91139090e-02f, 1.94958165e-01f, 2.75162280e-01f, -5.70365369e-01f, 1.10294789e-01f,
  1.37004152e-01f, 1.81291312e-01f, 3.28104109e-01f, 1.60701334e-01f, -4.53805596e-01f, 1.50878742e-01f, 1.24008000e-01f, -8.48643482e-02f, 2.53756762e-01f, 4.46621567e-01f,
  7.72819966e-02f, -2.42802024e-01f, -3.79043192e-01f, 3.29711497e-01f, -2.55997807e-01f, -1.80450559e-01f, -6.81641651e-03f, -2.11929604e-01f, 1.55265937e-02f, 4.68637049e-02f,
  2.54565984e-01f, -1.63042724e-01f, -8.67100880e-02f, 1.89809594e-02f, 2.36798435e-01f, 4.33742136e-01f, -4.08453256e-01f, 2.81563878e-01f, 5.21413498e-02f, -6.76265955e-02f,
  1.46343913e-02f, -1.00879431e-01f, -1.45806745e-01f, -3.51149559e-01f, 2.14214742e-01f, 1.48071244e-01f, -1.48221388e-01f, -4.09847438e-01f, 6.35298789e-01f, -8.95216316e-03f,
  -8.35389793e-02f, 5.86809777e-02f, -1.24231756e-01f, -2.11174060e-02f, 3.27998996e-02f, 3.43066096e-01f, -3.60373966e-02f, -1.43587396e-01f, -1.24470353e-01f, 2.41134576e-02f,
  4.87883873e-02f, -2.62982070e-01f, 1.21074019e-03f, 1.67645197e-02f, -5.74304769e-03f, -2.85803437e-01f, 2.54067481e-01f, 2.07242090e-02f, 4.39356174e-03f, -1.51490211e-01f,
  3.12196046e-01f, -8.22780430e-02f, -2.87888735e-03f, 1.88586324e-01f, 1.74164474e-01f, -1.94739714e-01f, 2.01443229e-02f, -3.20637167e-01f, 3.50935072e-01f, -3.12619925e-01f,
  -5.76469451e-02f, 4.03941125e-02f, -1.85166374e-01f, -3.87211800e-01f, -7.40731508e-02f, 2.79292345e-01f, 5.23538888e-01f, 8.28689933e-02f, 5.05211592e-01f, -1.88028067e-01f,
  2.49418274e-01f, 5.19845523e-02f, -1.84514821e-01f, 3.23195219e-01f, -2.86091387e-01f, -6.99109435e-02f, 2.40366831e-01f, 3.07069957e-01f, 6.30868375e-02f, 4.24682409e-01f,
  3.99320543e-01f, -1.22122906e-01f, -2.21110582e-01f, -4.28696662e-01f, -1.12650894e-01f, -1.33162707e-01f, -6.45890227e-03f, -8.37987214e-02f, 2.09578872e-01f, -1.05797671e-01f,
  1.83904737e-01f, 4.92322773e-01f, -2.02242970e-01f, -1.60154421e-02f, 1.58660501e-01f, -2.86153764e-01f, 2.52415426e-02f, 7.49767721e-02f, 1.06613010e-01f, 3.50414038e-01f,
  -1.00014016e-01f, 1.76852830e-02f, 1.64431363e-01f, 6.34655729e-02f, 2.06733886e-02f, 1.02405630e-01f, -1.41484052e-01f, 1.87665865e-01f, 8.33533853e-02f, 1.93878725e-01f,
  9.14018750e-02f, -1.80457503e-01f, -5.73992014e-01f, -1.93387885e-02f, -7.35897422e-02f, -2.82757849e-01f, 2.79153734e-01f, 6.69439286e-02f, -4.44749445e-01f, -1.86638925e-02f,
  4.46802825e-01f, 3.94867212e-01f, 3.91252160e-01f, -2.15237200e-01f, 1.50178313e-01f, -3.43138039e-01f, -2.82279551e-01f, -1.94129243e-01f, -2.83326190e-02f, -1.83505341e-01f,
  -1.28585696e-01f, -3.59832734e-01f, -1.55502737e-01f, 1.32424518e-01f, 4.31021154e-02f, 2.73082435e-01f, -3.61463666e-01f, 2.56071419e-01f, 4.27319318e-01f, -3.78276914e-01f,
  2.89746910e-01f, 2.92742789e-01f, 2.21791461e-01f, -2.85457343e-01f, -2.71794796e-01f, -2.54209906e-01f, -7.95120932e-03f, 1.95537299e-01f, 5.54831401e-02f, -6.23082928e-02f,
  -5.90080731e-02f, -9.10904352e-03f, 7.81029090e-02f, -1.58013240e-01f, -1.84590831e-01f, 4.27169949e-01f, -2.08286449e-01f, -1.65979773e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.39640654e-02f, -2.79615670e-02f, 3.23531851e-02f, 9.27146450e-02f, -6.91580623e-02f, 1.12352017e-02f, -9.85589698e-02f, 6.06274530e-02f, 7.55062550e-02f, 2.36397870e-02f,
  1.96932200e-02f, 1.74282379e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    