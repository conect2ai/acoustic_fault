/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.57218590e-01f, -4.64546144e-01f, -1.56152591e-01f, -2.18017310e-01f, -1.81119069e-02f, -5.70636764e-02f, -2.98873305e-01f, -3.23376531e-04f, -3.12177371e-02f, -2.62397528e-01f,
  6.72128350e-02f, 3.10145497e-01f, 2.52842516e-01f, 4.56422746e-01f, 2.42461219e-01f, -3.08230281e-01f, -2.36292675e-01f, 2.17042327e-01f, 3.41543376e-01f, 1.16360627e-01f,
  -5.53529635e-02f, -1.87953070e-01f, 8.74493867e-02f, 1.05968200e-01f, -2.80217379e-01f, 3.58832628e-01f, -3.08961216e-02f, -1.27438024e-01f, 3.51111777e-02f, -2.52722025e-01f,
  -7.63987601e-02f, -2.24961162e-01f, 1.93573058e-01f, 5.19572720e-02f, -3.52655537e-02f, -5.49379401e-02f, -2.96333488e-02f, -1.07168876e-01f, -2.69648321e-02f, -4.05298471e-02f,
  -8.09826031e-02f, -5.80637157e-02f, -2.42718738e-02f, 5.20590171e-02f, -7.50666484e-02f, -2.98193991e-02f, 3.36323194e-02f, -3.55153112e-04f, 1.06551506e-01f, -4.59492812e-03f,
  -5.90577237e-02f, -1.27698496e-01f, -1.36095554e-01f, 7.57175758e-02f, -1.19277146e-02f, 9.55373794e-02f, 8.72876346e-02f, -4.43554670e-02f, 1.58883661e-01f, -1.70204565e-01f,
  6.09197766e-02f, -1.26669943e-01f, -8.40777606e-02f, 3.12045831e-02f, 3.58057022e-02f, 2.14006547e-02f, 9.04231444e-02f, 2.66137463e-03f, -1.04623381e-02f, 1.34031344e-02f,
  6.86712191e-02f, 6.10651821e-02f, 5.98633289e-03f, -4.02540602e-02f, 1.46432612e-02f, -1.00117818e-01f, -3.17221470e-02f, -5.59408925e-02f, 1.47262067e-01f, 3.71684670e-04f,
  3.41264419e-02f, -4.37288657e-02f, 6.57628179e-02f, 1.50801158e-02f, -2.31006974e-03f, 1.14429012e-01f, -6.77212002e-03f, 6.40414655e-03f, -5.09251244e-02f, -6.82719692e-04f,
  6.22066576e-03f, 4.43599939e-01f, 3.09368633e-02f, 4.55561727e-02f, -2.40898170e-02f, 1.24777919e-02f, 5.30771725e-02f, 5.41015007e-02f, -6.17067292e-02f, 2.14267131e-02f,
  4.92547601e-02f, 5.36543876e-02f, 4.78413254e-02f, -4.14475463e-02f, 1.10164344e-01f, 3.15009505e-02f, -1.15027865e-02f, 5.70887420e-03f, 8.11856687e-02f, -1.08310543e-01f,
  -2.70846467e-02f, -6.26187539e-04f, -1.03344833e-02f, 2.83946786e-02f, 4.80484497e-03f, 9.45051983e-02f, -1.03146387e-02f, 2.15723068e-02f, 1.28347039e-01f, -3.61477323e-02f,
  4.45129067e-01f, -2.84677565e-01f, 2.84158707e-01f, -7.97784775e-02f, 4.08460349e-01f, 3.33568662e-01f, 3.65557611e-01f, 1.12218417e-01f, -3.19706649e-02f, -2.76872851e-02f,
  6.86678067e-02f, -1.14148095e-01f, -2.54091501e-01f, -9.56746265e-02f, 5.72721027e-02f, -6.38442934e-02f, -2.15077624e-01f, 9.32475552e-02f, 2.43443996e-01f, 1.11671768e-01f,
  -1.80762723e-01f, -1.19208507e-01f, 5.21366037e-02f, -1.77572817e-02f, -2.27392495e-01f, 7.39540011e-02f, -2.79966276e-02f, -1.10515624e-01f, 1.08756848e-01f, -4.66023505e-01f,
  3.58894914e-02f, -4.87367390e-03f, 3.57480571e-02f, -4.28397991e-02f, -3.22228819e-02f, -8.05371776e-02f, -1.86956637e-02f, -1.00210093e-01f, -5.27645499e-02f, -8.23378488e-02f,
  4.68027033e-03f, -1.03694506e-01f, -2.43715532e-02f, -2.60480605e-02f, 1.42450966e-02f, -1.90768111e-02f, -1.27271593e-01f, -1.08293466e-01f, -2.42266282e-02f, -3.57691646e-02f,
  -1.78912610e-01f, 7.45627433e-02f, 1.38641730e-01f, 3.13648675e-03f, -4.07249434e-03f, 4.29110937e-02f, 4.03795252e-03f, -5.00982953e-03f, 6.19601235e-02f, -2.14753717e-01f,
  -4.83832024e-02f, 6.15382008e-02f, 5.80071434e-02f, 4.77484018e-02f, -7.91033506e-02f, 1.05469152e-02f, -7.42824525e-02f, 4.92555499e-02f, 9.06145293e-03f, -2.54714098e-02f,
  2.56138109e-02f, 4.34081554e-02f, 1.38643375e-02f, -7.21546495e-03f, -1.83096714e-02f, 2.20267614e-03f, 4.78496961e-02f, -3.07873953e-02f, 3.18088132e-04f, 7.47251362e-02f,
  -4.35540453e-02f, 7.38240778e-02f, -2.49518994e-02f, -5.11398204e-02f, -2.36203633e-02f, -1.59179326e-02f, -2.92386767e-02f, -1.88146792e-02f, -8.37556645e-02f, -2.05048136e-02f,
  -1.24831446e-01f, 1.01226456e-01f, -1.19880974e-01f, -4.57924493e-02f, 4.44272906e-02f, 2.25771032e-02f, 4.32896102e-03f, 5.97456172e-02f, 6.45551383e-02f, -6.70560449e-02f,
  7.15409173e-03f, 1.39377201e-02f, -5.17797023e-02f, 1.69330183e-02f, 8.72352943e-02f, -1.76692959e-02f, 3.76745220e-03f, 1.07769489e-01f, 2.87259906e-03f, 1.07592540e-02f,
  -9.96925384e-02f, 9.78853405e-02f, 1.82445601e-01f, 3.82301174e-02f, -5.04741669e-02f, 1.23883128e-01f, 8.46218318e-02f, 3.96028422e-02f, 2.58567452e-01f, -3.76262446e-03f,
  -6.07967496e-01f, -2.73996353e-01f, -2.08597422e-01f, 2.19644755e-01f, 3.43712956e-01f, 1.33197591e-01f, -3.34974885e-01f, 9.50307623e-02f, 1.99285388e-01f, -4.07760255e-02f,
  1.49531677e-01f, 4.43255484e-01f, 5.57058342e-02f, 1.29925817e-01f, -1.81289643e-01f, -3.38125348e-01f, -1.60399705e-01f, -1.46941394e-01f, 1.53216168e-01f, 2.31533885e-01f,
  1.42060071e-01f, 4.64589670e-02f, 1.14264907e-02f, -3.75091583e-02f, 9.25557688e-02f, 3.05804193e-01f, 9.11218002e-02f, 9.16402265e-02f, 8.39097500e-02f, -2.48282012e-02f,
  -1.49211928e-01f, -2.17418462e-01f, 7.92534277e-02f, 6.50002137e-02f, 1.10066094e-01f, -1.17986411e-01f, -3.46831195e-02f, 3.19177061e-02f, 6.11624308e-02f, -7.52144074e-03f,
  1.37219965e-01f, 1.47822559e-01f, 7.94231240e-03f, 2.59700026e-02f, 2.41471492e-02f, 4.25840095e-02f, -2.62237545e-02f, -8.95746127e-02f, -3.93812247e-02f, 1.03624538e-01f,
  1.42503142e-01f, 7.59637207e-02f, -3.19869779e-02f, 7.11155385e-02f, -4.70619425e-02f, 1.50888309e-01f, 1.07778259e-01f, 4.24325988e-02f, 4.21898998e-02f, -1.93656906e-02f,
  -1.50239319e-02f, 2.27403063e-02f, 5.06096371e-02f, -2.90548913e-02f, -3.32798883e-02f, -1.74089931e-02f, -5.22716157e-02f, -2.25684904e-02f, 5.24229407e-02f, -3.19106616e-02f,
  1.77362915e-02f, -5.82533665e-02f, -3.35219949e-02f, -1.87847158e-03f, 8.24565664e-02f, 4.87723984e-02f, 2.77580023e-02f, -6.13227440e-03f, -1.43175339e-02f, -6.45635128e-02f,
  -1.87687334e-02f, -9.40077603e-02f, 4.89302836e-02f, -6.12054579e-02f, -8.61218721e-02f, 3.09869591e-02f, -7.58407563e-02f, 2.20238082e-02f, 8.05740729e-02f, -7.13087618e-02f,
  1.33470491e-01f, -9.01781991e-02f, 3.12151555e-02f, -5.05857579e-02f, 4.21332307e-02f, 1.13636432e-02f, 7.62383565e-02f, 5.69761451e-03f, 9.75511670e-02f, 3.33255380e-02f,
  5.74091189e-02f, -9.78691429e-02f, -9.58384797e-02f, 4.98440489e-02f, 2.02388875e-03f, 7.58020265e-04f, 1.15104787e-01f, 1.40948892e-02f, 7.17749223e-02f, 9.22908634e-02f,
  -5.25425188e-02f, -3.11310329e-02f, -1.13373742e-01f, -1.88217103e-01f, -1.37296803e-02f, -9.49745649e-04f, 2.26897486e-02f, 3.52705084e-02f, -1.28012866e-01f, -1.64334565e-01f,
  -2.62491792e-01f, -1.82547286e-01f, -7.88150504e-02f, 3.64504188e-01f, -8.62743482e-02f, -4.10208285e-01f, -4.78610486e-01f, 2.55572591e-02f, 2.27848619e-01f, 1.84718671e-03f,
  -1.25919744e-01f, -5.07308245e-02f, -1.57651275e-01f, -1.29192444e-02f, -1.10542990e-01f, 2.63613332e-02f, 3.48500133e-01f, 3.90209816e-02f, -1.39098525e-01f, -9.80757400e-02f,
  1.28896803e-01f, 1.76537707e-01f, 2.08379254e-01f, 7.43446797e-02f, 2.71150351e-01f, 1.18685186e-01f, 1.85438722e-01f, 3.40382755e-02f, -1.57699302e-01f, 6.15833580e-01f,
  -1.47232160e-01f, -9.67214927e-02f, 8.11275095e-02f, 1.14762381e-01f, -1.93005074e-02f, 5.48488321e-03f, -2.78387889e-02f, 7.49760047e-02f, -8.72213468e-02f, 1.08838275e-01f,
  7.07687214e-02f, 9.12780240e-02f, -1.16411738e-01f, 1.38651580e-01f, 5.39759286e-02f, -7.24589527e-02f, 1.19748838e-01f, 1.28953531e-01f, 7.16407895e-02f, 1.86563656e-02f,
  4.78270929e-03f, -2.59445403e-02f, -1.72351316e-01f, -8.23904574e-02f, -4.49725725e-02f, 1.03144404e-04f, -1.96550265e-02f, 7.99750015e-02f, -5.24822511e-02f, 2.40898028e-01f,
  -3.37724760e-02f, -2.76179351e-02f, -5.69649599e-03f, 3.43600847e-02f, 1.50678307e-02f, -4.94774543e-02f, 7.84283783e-03f, 2.41229441e-02f, 8.65537003e-02f, -3.58780064e-02f,
  -8.28543771e-03f, -1.08659714e-02f, 6.86733350e-02f, 6.65397570e-02f, 1.45346895e-01f, 7.25507066e-02f, 1.98787041e-02f, 4.21156362e-02f, -7.47069530e-03f, -3.92880617e-03f,
  -6.20451383e-02f, 8.43005925e-02f, 3.39226164e-02f, 7.21516162e-02f, 1.21332165e-02f, 1.27223106e-02f, 9.72600281e-02f, -1.39062693e-02f, -3.57209928e-02f, 7.53833130e-02f,
  1.12685531e-01f, -6.20382167e-02f, 1.13667563e-01f, 1.35163188e-01f, 9.13846567e-02f, -6.79772049e-02f, -3.79216373e-02f, 3.69776003e-02f, -8.44090804e-03f, -4.30890881e-02f,
  1.83382835e-02f, 7.90679306e-02f, -7.47576579e-02f, 2.63865516e-02f, 3.57443653e-03f, 1.32118434e-01f, 6.36064336e-02f, 7.75529444e-02f, 1.09021403e-01f, 1.39795661e-01f,
  1.06157571e-01f, 9.59874988e-02f, 5.18324003e-02f, 2.22864542e-02f, 1.08550742e-01f, 9.96399894e-02f, -5.17227780e-03f, 3.92122902e-02f, -5.32708690e-02f, 1.20411895e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.25396693e+00f, 1.58600554e-01f, -6.16750598e-01f, -6.89238131e-01f, -4.30857241e-01f, -4.14187640e-01f, -2.33712599e-01f, 2.76419222e-02f, -2.52226412e-01f, -1.55546173e-01f,
  6.32469207e-02f, 3.36101979e-01f, 1.03636421e-01f, 6.92902058e-02f, 2.04555973e-01f, -3.14307958e-01f, -8.36289465e-01f, -4.42412853e-01f, 1.41367897e-01f, 9.69465971e-02f,
  1.35607332e-01f, -1.64183483e-01f, -3.61022383e-01f, 7.51611069e-02f, 8.75350833e-02f, 3.30474913e-01f, -1.75586179e-01f, -1.98199227e-01f, 7.62394071e-02f, -3.87161314e-01f,
  3.33555430e-01f, -3.15504760e-01f, -3.81612107e-02f, -2.05113247e-01f, -8.81899893e-02f, -5.46754375e-02f, 6.54208064e-02f, 4.94712926e-02f, -4.27766852e-02f, 6.19683377e-02f,
  -1.03336774e-01f, -6.18512593e-02f, -8.54031593e-02f, 1.84512973e-01f, 7.49708735e-04f, -4.81671952e-02f, -6.19499534e-02f, -1.15285993e-01f, -4.67542745e-02f, 1.41569868e-01f,
  5.01112156e-02f, -2.34727815e-01f, -7.57715926e-02f, 7.08493441e-02f, -1.00732714e-01f, -2.03309089e-01f, 1.79718837e-01f, 1.28880933e-01f, -1.24061994e-01f, 1.90176547e-01f,
  -1.43384665e-01f, 9.43928212e-02f, 3.01269609e-02f, 3.84739637e-02f, -4.64976355e-02f, 2.62359474e-02f, 9.44205448e-02f, 9.39757526e-02f, 5.32465754e-03f, 1.57015309e-01f,
  -1.43446311e-01f, -1.01073891e-01f, 1.18958876e-01f, -6.57941699e-02f, 6.41165376e-02f, -1.35626914e-02f, -4.39316444e-02f, 1.05462804e-01f, -7.37191215e-02f, -7.02402592e-02f,
  -4.94611450e-02f, 1.36509374e-01f, -7.95086846e-02f, 2.36052081e-01f, -2.49635354e-01f, -1.20417342e-01f, -8.63929316e-02f, 5.45541905e-02f, 4.83074635e-02f, -4.34611179e-02f,
  3.08146894e-01f, -5.71782827e-01f, 5.45083694e-02f, 7.72293210e-02f, 1.36937186e-01f, -3.67546082e-02f, -6.22776002e-02f, 4.29443754e-02f, -1.06211275e-01f, 4.44496796e-02f,
  -1.42785832e-01f, 9.75499749e-02f, -8.14633891e-02f, -2.54520103e-02f, 1.04363248e-01f, 1.41197562e-01f, 6.08927868e-02f, -1.03630787e-02f, 1.62621662e-02f, 1.70659542e-01f,
  -2.13637692e-03f, 4.72065024e-02f, 2.80787408e-01f, 1.48951843e-01f, 9.16043371e-02f, -2.80840527e-02f, 2.48807043e-01f, 1.43672884e-01f, -9.69532952e-02f, 2.97011971e-01f,
  -1.24598432e+00f, 4.98722762e-01f, -6.18295595e-02f, -7.11468756e-01f, 3.58064920e-01f, 2.70789653e-01f, 1.00004554e+00f, 1.65169418e-01f, -2.86043048e-01f, 2.03123406e-01f,
  1.41432192e-02f, -2.17857450e-01f, 2.70129703e-02f, 1.97139502e-01f, 1.51178002e-01f, 4.59006011e-01f, 3.49864244e-01f, -2.53590643e-01f, -3.42842907e-01f, -4.76096161e-02f,
  3.24371815e-01f, -2.42493987e-01f, -8.85479689e-01f, -1.80225626e-01f, 1.03829846e-01f, 1.03761647e-02f, 8.98294970e-02f, -1.91850409e-01f, 1.93475038e-01f, 9.28362180e-03f,
  -4.96920571e-02f, -3.36141765e-01f, 9.45213586e-02f, -3.20124000e-01f, -1.07319690e-02f, -2.10890964e-01f, -1.99131854e-02f, -3.28886777e-01f, 7.14014918e-02f, -7.18922243e-02f,
  -1.91109687e-01f, -1.46968320e-01f, -5.28316908e-02f, 1.69556692e-01f, -2.57663786e-01f, 8.27484354e-02f, -1.09459624e-01f, -2.12488309e-01f, -1.89223085e-02f, 2.35880598e-01f,
  4.21029240e-01f, -2.24093497e-01f, -1.49803698e-01f, 2.34673232e-01f, 3.73522431e-01f, -3.46743286e-01f, 1.31016523e-01f, -5.68573289e-02f, -1.45253658e-01f, -4.95982349e-01f,
  5.07400604e-03f, -1.06299572e-01f, 9.60020572e-02f, -6.80502802e-02f, 1.31820766e-02f, 1.38824154e-02f, -1.74316764e-02f, -5.25821038e-02f, -3.20747793e-02f, -1.86150834e-01f,
  1.78167999e-01f, -1.14189349e-02f, -5.57326153e-02f, -2.11080071e-02f, -4.99287136e-02f, 4.83614989e-02f, 6.56068549e-02f, -6.22962750e-02f, 1.02974854e-01f, -1.80632826e-02f,
  -9.15929209e-03f, -6.70067742e-02f, -8.09194148e-02f, 1.72310457e-01f, 1.50996342e-01f, 2.09615275e-01f, -1.42508140e-03f, -7.82085955e-02f, -1.00489162e-01f, 5.89041673e-02f,
  -7.69134313e-02f, 1.98964849e-01f, -2.65542623e-02f, 7.78513551e-02f, -1.42588794e-01f, -8.42302069e-02f, 5.60770109e-02f, 7.85375771e-04f, 2.63133403e-02f, 1.21189743e-01f,
  -1.01705261e-01f, -1.52534708e-01f, 1.14710055e-01f, 3.24096568e-02f, -2.34087054e-02f, -3.87763567e-02f, 1.94680303e-01f, -7.25355670e-02f, -8.12764317e-02f, -1.49578094e-01f,
  2.42891312e-01f, 4.41996120e-02f, -3.48174274e-01f, -8.78294259e-02f, 5.34069426e-02f, -1.19953401e-01f, -1.32001698e-01f, -3.35641243e-02f, 9.76899266e-03f, 1.63576365e-01f,
  3.19748893e-02f, -7.94257224e-02f, -3.85994107e-01f, -1.37319625e-03f, -1.16076678e-01f, -5.54294139e-02f, -3.07072382e-02f, 1.49082646e-01f, 9.18409154e-02f, 2.36844510e-01f,
  3.04603837e-02f, 4.79978584e-02f, 5.46267629e-02f, -5.26044052e-03f, 3.49721611e-02f, 6.04524091e-02f, -7.70287495e-03f, -4.29141559e-02f, -7.34316483e-02f, -8.95200893e-02f,
  4.79476079e-02f, -5.99588715e-02f, -1.99176356e-01f, -1.40357152e-01f, -2.72101015e-02f, 1.00619867e-01f, -1.13334760e-01f, -2.04373673e-01f, -3.39898974e-01f, -2.18227729e-01f,
  1.65436760e-01f, -2.25931168e-01f, 2.18042701e-01f, 6.49236441e-02f, -9.74060744e-02f, 1.01559691e-01f, 1.22963928e-01f, 4.36104536e-02f, 7.92111903e-02f, 6.22936636e-02f,
  -4.01663296e-02f, 8.11470440e-04f, -1.52125254e-01f, -6.78188056e-02f, 4.71341982e-02f, 1.24918483e-02f, 5.43675572e-03f, 2.82995924e-02f, -4.54000123e-02f, 8.92716944e-02f,
  -1.09739900e-01f, -2.12785557e-01f, 3.10733728e-03f, -4.82771210e-02f, -2.35770922e-02f, -1.40706927e-01f, 7.05912486e-02f, -1.74244449e-01f, -5.56952991e-02f, 1.41972065e-01f,
  -1.94112256e-01f, -6.69343174e-02f, -8.47117603e-03f, 4.61586267e-02f, -1.29525047e-02f, -7.10415170e-02f, 3.00666839e-02f, 2.91622598e-02f, 9.28011611e-02f, -1.29714119e-03f,
  4.72819917e-02f, 4.82903831e-02f, 8.32219794e-02f, 1.83132678e-01f, 6.02252856e-02f, -1.32218391e-01f, -2.18079060e-01f, 5.16352467e-02f, -4.47649993e-02f, -2.86011379e-02f,
  -1.23096891e-01f, -9.99504849e-02f, 7.50419870e-02f, -1.33891627e-01f, -7.54084066e-03f, -1.50342127e-02f, -1.13783881e-01f, -1.27000660e-01f, 6.44596219e-02f, -1.74683183e-02f,
  5.69187760e-01f, -1.30821675e-01f, 3.68465036e-02f, 1.82169154e-02f, -9.49117988e-02f, 4.19374816e-02f, 3.46237272e-02f, -8.95677879e-03f, -2.85950676e-02f, 8.79043639e-02f,
  -1.70122720e-02f, 4.85304371e-02f, -7.83117786e-02f, -1.18029833e-01f, 1.00809522e-01f, -3.43437050e-03f, 1.10400379e-01f, 1.38334915e-01f, 5.76119460e-02f, 1.97370365e-01f,
  5.12213148e-02f, 2.42834419e-01f, 3.82719904e-01f, 2.57413864e-01f, -2.70069093e-02f, 6.82103857e-02f, 1.78762436e-01f, 5.31600416e-02f, 7.04293177e-02f, 3.76350701e-01f,
  5.15672982e-01f, -8.27847496e-02f, -8.71371388e-01f, 1.33552253e-01f, -3.74146909e-01f, -3.62219065e-01f, -3.65699261e-01f, 4.49531376e-01f, 4.36393529e-01f, -3.78619879e-01f,
  4.60632592e-02f, 4.83554691e-01f, 1.51151568e-01f, 1.95638791e-01f, 2.69901037e-01f, -6.20954156e-01f, -6.24116242e-01f, -8.76736194e-02f, 3.09705853e-01f, 2.82750398e-01f,
  2.69972473e-01f, 1.24395825e-01f, 3.81907463e-01f, 3.87012362e-01f, -4.56691176e-01f, 8.19727406e-02f, -4.85007405e-01f, -3.20620924e-01f, -4.26345766e-01f, -1.05453014e+00f,
  -7.14273155e-01f, -1.98116973e-01f, 5.38301542e-02f, 3.97300184e-01f, -2.12151170e-01f, 1.53475150e-01f, 6.87736645e-02f, -2.35954430e-02f, 1.09862342e-01f, 6.63432479e-03f,
  -1.93232484e-02f, 8.94143134e-02f, 9.44255851e-04f, -2.50522681e-02f, -6.89081699e-02f, -7.17723519e-02f, -2.13225484e-02f, 1.17095053e-01f, -5.67160621e-02f, -7.42517561e-02f,
  -1.99591324e-01f, -1.46249294e-01f, -4.92066175e-01f, -7.18562007e-02f, -1.47068828e-01f, -2.20489383e-01f, -3.32407743e-01f, -2.20921189e-01f, -2.76453674e-01f, -4.04225528e-01f,
  5.45011200e-02f, -2.71123108e-02f, -3.96609716e-02f, -1.66125745e-01f, 9.52312648e-02f, -2.29715444e-02f, -7.37871751e-02f, -1.36430040e-01f, -1.95753659e-04f, -5.37053384e-02f,
  1.80378847e-03f, -1.52627677e-01f, 1.13561749e-02f, 4.43856828e-02f, 3.04333959e-02f, -6.08627237e-02f, 5.47206998e-02f, -9.21287984e-02f, -9.73965153e-02f, -8.24434962e-03f,
  1.61348656e-01f, -8.47591460e-02f, -1.52809508e-02f, 1.42620936e-01f, 7.33845010e-02f, -2.11847983e-02f, -3.10892221e-02f, 1.53149679e-01f, 7.12675154e-02f, 9.96933598e-03f,
  6.38884723e-01f, 1.47941411e-01f, -3.68002281e-02f, -2.06136052e-02f, 5.96921220e-02f, 1.13657869e-01f, -1.56518891e-01f, 2.36977097e-02f, -6.17649555e-02f, 6.88249394e-02f,
  8.47617090e-02f, 6.97888955e-02f, -3.11563443e-02f, -8.34888592e-02f, -3.22469771e-02f, -5.85801117e-02f, 4.19850759e-02f, -1.25149950e-01f, 3.87505740e-02f, -8.66866261e-02f,
  1.05015546e-01f, 2.96048038e-02f, 2.35666260e-01f, -1.05005400e-02f, 1.23340666e-01f, 8.70555416e-02f, -1.34317771e-01f, -2.99895424e-02f, 1.84929103e-01f, 3.01469564e-01f,
  3.55687916e-01f, -6.31658733e-02f, -5.75216532e-01f, 3.16199571e-01f, 1.17629655e-02f, -4.34267372e-02f, 2.25871906e-01f, -3.48407626e-01f, 2.95637548e-01f, 3.68732750e-01f,
  -1.88060194e-01f, -1.33385643e-01f, 1.59601107e-01f, -2.32198805e-01f, -7.41379261e-01f, -1.08837159e-02f, 2.94920616e-02f, -5.61587751e-01f, -6.66485727e-01f, -5.79304576e-01f,
  1.51724353e-01f, 3.49123999e-02f, -2.55209178e-01f, -5.36638916e-01f, 4.14872438e-01f, 2.74364084e-01f, 3.26685965e-01f, 2.80992240e-01f, 4.62749554e-03f, 5.03633976e-01f,
  -9.67398807e-02f, -4.33438778e-01f, -1.81132853e-02f, -9.12197307e-02f, -8.13448429e-03f, 3.09704361e-03f, -1.55374780e-01f, -5.09945787e-02f, -2.07087155e-02f, -3.15344222e-02f,
  5.93869351e-02f, -1.19340874e-01f, -2.42482901e-01f, -2.95359418e-02f, -2.59348005e-01f, -1.74357504e-01f, -4.64593209e-02f, -3.27061713e-01f, -1.10315189e-01f, -2.92367607e-01f,
  1.10870436e-01f, -2.69730300e-01f, -3.57581794e-01f, -2.26627976e-01f, -3.10990036e-01f, -2.03893289e-01f, -1.16373427e-01f, -2.99718499e-01f, -2.88159579e-01f, 3.07927608e-01f,
  9.90771651e-02f, 4.27839123e-02f, -2.21409705e-02f, -1.95086747e-02f, 9.85301882e-02f, 1.03750929e-01f, -4.14624400e-02f, 5.21691740e-02f, -6.78771362e-02f, 2.97877621e-02f,
  -9.88794491e-04f, 2.89446930e-03f, -2.51448397e-02f, 2.78312620e-02f, -5.89380488e-02f, -5.67131899e-02f, 7.24636763e-02f, 1.63096767e-02f, -5.74519783e-02f, 6.60165250e-02f,
  -1.49802328e-03f, -2.88154241e-02f, 1.17453434e-01f, -1.00728616e-01f, 2.40580589e-02f, -4.52370048e-02f, 2.56500486e-02f, 1.00922622e-02f, 9.88469273e-03f, 2.73999162e-02f,
  3.06249797e-01f, -6.44288436e-02f, 1.65901050e-01f, -3.54867764e-02f, 1.91231817e-02f, 1.35519467e-02f, 1.43820062e-01f, 9.30860862e-02f, 8.97598569e-04f, -9.27136913e-02f,
  -1.11772381e-01f, -1.40057892e-01f, 1.29429489e-01f, 1.39752746e-01f, -4.49514203e-02f, 6.95382133e-02f, 1.81261465e-01f, 7.66648874e-02f, -3.18894237e-02f, 5.25393635e-02f,
  1.90804869e-01f, 2.02647984e-01f, 1.18825898e-01f, 2.28626296e-01f, 1.03801221e-01f, 1.12104565e-02f, 1.17376737e-01f, 1.59768865e-01f, -6.56437501e-02f, 6.06834531e-01f,
  -6.93319142e-01f, -3.50516170e-01f, -1.95204969e-02f, -3.98010351e-02f, 1.01426005e-01f, 1.01769064e-02f, -6.15413189e-01f, -8.18865374e-02f, 4.27969933e-01f, -2.87184209e-01f,
  -1.10182032e-01f, 7.22068222e-03f, 6.22555055e-03f, -8.86922404e-02f, -6.24582946e-01f, -6.48853898e-01f, -4.87200052e-01f, -2.45962813e-01f, -9.64800417e-02f, -2.07326617e-02f,
  5.40047996e-02f, -8.66050720e-02f, -9.40736532e-02f, 6.21932596e-02f, -8.77369642e-02f, -1.56723391e-02f, -5.54919504e-02f, -2.01026574e-01f, -4.33382601e-01f, -6.13179028e-01f,
  -2.25561455e-01f, -1.50586978e-01f, 2.53525168e-01f, -1.59007460e-01f, 1.43695980e-01f, -7.79874697e-02f, -1.33790821e-01f, -1.10792682e-01f, 5.39644575e-03f, -1.43042326e-01f,
  -1.88612044e-01f, 1.77486435e-01f, -3.64592448e-02f, 2.17745826e-02f, -8.57517403e-03f, -2.04925150e-01f, 1.33813443e-02f, -7.38352537e-02f, -1.76328361e-01f, 2.19638199e-01f,
  -2.57486284e-01f, -1.71007276e-01f, -4.05716002e-01f, 2.64886320e-01f, 5.06100710e-03f, 1.25056326e-01f, -8.74527320e-02f, -2.42775101e-02f, -5.08876368e-02f, -3.69756460e-01f,
  2.04214398e-02f, 5.60207069e-02f, 1.06459185e-01f, -7.62956813e-02f, -1.17271334e-01f, 1.62376314e-01f, -1.62535965e-01f, -3.55552323e-02f, -1.42401293e-01f, -1.33382350e-01f,
  3.17514539e-01f, 4.24318090e-02f, 1.89072937e-02f, -6.58185482e-02f, -2.65971385e-02f, 1.28311832e-02f, -1.39054880e-01f, -9.64047480e-03f, -1.38458341e-01f, 2.28690818e-01f,
  -4.82002236e-02f, 2.75134165e-02f, 1.32978454e-01f, 2.55255550e-02f, 5.10101672e-03f, -5.34996465e-02f, -1.67239591e-01f, -8.90621692e-02f, -8.65663588e-02f, -1.55344367e-01f,
  -3.42776962e-02f, 8.98018554e-02f, -2.33822301e-01f, -2.69968271e-01f, -1.11164376e-02f, 3.12849164e-01f, -2.73526702e-02f, 7.21020401e-02f, 1.13299713e-01f, 6.41305894e-02f,
  -8.97227451e-02f, -2.56502479e-01f, 7.09795505e-02f, 5.39988931e-03f, -8.64672512e-02f, -9.62549150e-02f, -2.16324538e-01f, 8.05722475e-02f, -1.80014551e-01f, 2.17228860e-01f,
  1.43718747e-02f, -2.06801936e-01f, -5.56774020e-01f, -1.18745506e-01f, -2.69484490e-01f, -5.29977262e-01f, -2.74462759e-01f, -1.08379452e-03f, -3.96979541e-01f, -5.57357132e-01f,
  -4.07192469e-01f, -5.47106266e-01f, -6.35321617e-01f, -6.74828529e-01f, -4.14912820e-01f, -1.83380153e-02f, -3.86521548e-01f, -1.17020048e-01f, 9.69421789e-02f, -1.12843551e-01f,
  -7.72284195e-02f, -2.03900002e-02f, -1.48549125e-01f, 1.93344224e-02f, 2.02293426e-01f, -1.61740959e-01f, -1.30350709e-01f, -4.43629511e-02f, -9.67943221e-02f, -1.46221787e-01f,
  -1.83542341e-01f, -4.67346013e-01f, -1.44360453e-01f, 2.99564283e-02f, -4.91958499e-01f, -4.97936219e-01f, -5.75238705e-01f, -3.69443536e-01f, 5.91504872e-02f, -4.80260670e-01f,
  -7.56615698e-01f, -2.69243509e-01f, 1.06804177e-01f, 2.09452510e-01f, -1.52440429e-01f, 2.42993236e-01f, -2.86670029e-02f, 2.37355120e-02f, 2.68605202e-01f, -6.05297228e-03f,
  -9.33289081e-02f, 2.00564861e-01f, -1.50376931e-01f, -1.72629073e-01f, -2.41560623e-01f, -5.04564829e-02f, 1.41171878e-02f, -7.23417550e-02f, 5.78118563e-02f, 8.74411315e-02f,
  2.26497397e-01f, 1.87218845e-01f, 2.06886649e-01f, 1.78862423e-01f, 1.52340472e-01f, 1.59114495e-01f, 1.45851756e-02f, -5.74166290e-02f, 1.77959234e-01f, -2.32876062e-01f,
  2.31332835e-02f, 3.00741214e-02f, -1.25670526e-02f, -3.49291116e-02f, 1.70115292e-01f, -4.45635617e-02f, -7.59725571e-02f, 8.13053921e-02f, 2.16605403e-02f, -1.65124536e-02f,
  2.51373891e-02f, -2.76118666e-02f, -1.13913037e-01f, -5.35935201e-02f, -5.27526252e-02f, -4.92014177e-02f, 9.81348753e-02f, 5.04497960e-02f, 1.21180318e-01f, 5.44030890e-02f,
  1.67581007e-01f, 1.23438142e-01f, -6.78654686e-02f, -1.54752836e-01f, -6.06228318e-03f, -9.31430310e-02f, 8.43297690e-03f, 1.24102578e-01f, -2.09628001e-01f, 5.01980335e-02f,
  -4.59826887e-01f, 3.80870521e-01f, -1.19304657e-01f, 1.03294358e-01f, -2.83121993e-03f, 2.03379050e-01f, 2.01035738e-02f, -5.18565141e-02f, -4.10491154e-02f, -1.03812456e-01f,
  -5.75252343e-03f, -1.47156611e-01f, -1.67035922e-01f, 7.66751543e-02f, -4.06465977e-02f, 7.24379048e-02f, 2.28487909e-01f, -3.03953029e-02f, 1.29600480e-01f, -1.18544195e-02f,
  1.72118679e-01f, 3.12071443e-01f, 2.23274067e-01f, 4.97271605e-02f, 4.99205515e-02f, -5.67333736e-02f, -6.12569302e-02f, 4.81079146e-02f, 8.40780139e-02f, 2.07565818e-02f,
  5.13459183e-02f, 3.37303787e-01f, 5.19893393e-02f, 1.97111860e-01f, 2.99171329e-01f, 2.47033328e-01f, 2.97412276e-01f, 3.42462599e-01f, 7.61537924e-02f, 2.26403981e-01f,
  1.47800714e-01f, 4.86940145e-02f, 8.50712508e-02f, 2.11619616e-01f, 1.93085045e-01f, 2.10312471e-01f, 1.44066349e-01f, 8.14467203e-03f, 2.12335922e-02f, -4.28119823e-02f,
  1.40403211e-01f, 3.65109765e-03f, -1.19940907e-01f, 8.91130641e-02f, 1.41656578e-01f, 6.15629032e-02f, 1.37718186e-01f, 4.62273099e-02f, 4.08830717e-02f, 8.72360915e-02f,
  -3.76838833e-01f, 2.42983744e-01f, -1.17410242e-03f, 9.00029987e-02f, 3.40346172e-02f, -7.14524537e-02f, -7.38490969e-02f, -4.72718030e-02f, -1.88926637e-01f, -5.52532971e-02f,
  1.87923647e-02f, -6.20129481e-02f, 1.87291607e-01f, -5.82301849e-03f, -1.39630819e-02f, -9.73560587e-02f, 8.19509570e-03f, 1.34182483e-01f, 1.85803518e-01f, -1.22161442e-02f,
  5.15653230e-02f, 2.52010785e-02f, 5.20864949e-02f, 9.32370275e-02f, 2.58126706e-01f, 5.85810002e-03f, 1.38035387e-01f, 8.74971226e-02f, 1.59627318e-01f, 1.00019850e-01f,
  7.20928609e-02f, 6.23311587e-02f, 1.46414995e-01f, 9.34703499e-02f, 4.66190539e-02f, 9.48561430e-02f, -4.84972484e-02f, -2.97309831e-02f, 1.84488758e-01f, -3.59105952e-02f,
  -1.38142228e-01f, 1.19717941e-01f, -1.35836853e-02f, 8.67371410e-02f, 2.52374057e-02f, 1.06792979e-01f, -8.46451595e-02f, -5.34205846e-02f, -2.08839357e-01f, -5.89034744e-02f,
  -6.85717165e-02f, -2.25409046e-02f, 8.25299099e-02f, 2.63715610e-02f, -7.54362941e-02f, -5.90463914e-02f, -1.40805885e-01f, -6.70605078e-02f, 8.61170068e-02f, -3.71387005e-02f,
  -3.84399056e-01f, 2.81760573e-01f, -9.03234333e-02f, -4.01737317e-02f, 6.79331832e-03f, -1.56914309e-01f, 8.97622854e-02f, -9.70365405e-02f, -6.00661635e-02f, -2.67243814e-02f,
  8.90867028e-04f, -4.99333553e-02f, -2.47853599e-03f, -5.80980182e-02f, -1.14792399e-01f, -7.85256103e-02f, 2.76635005e-03f, 8.71894509e-02f, 1.21923923e-01f, -2.99507827e-02f,
  -1.68616753e-02f, -9.96272936e-02f, -2.45353058e-01f, 6.75248802e-02f, -2.37213299e-02f, -9.21700820e-02f, -8.91085789e-02f, 4.17061634e-02f, 9.89436209e-02f, -1.33459549e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  5.15165091e-01f, 4.90604043e-02f, 5.91529787e-01f, 5.41294932e-01f, 8.56563807e-01f, 4.09794338e-02f, 4.90491539e-01f, -4.31231260e-02f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.59203875e-01f, -2.28493527e-01f, -8.85056928e-02f, 2.73148883e-02f, -4.03340161e-02f, 7.92665929e-02f, 6.20505139e-02f, -7.50317471e-03f, 1.59505740e-01f, 5.97809590e-02f,
  8.82367939e-02f, -1.33295119e-01f, 5.86688817e-01f, -2.17903808e-01f, -1.99755430e-01f, 3.33243221e-01f, 2.17291474e-01f, 1.87172920e-01f, -1.61958978e-01f, -3.96486670e-02f,
  1.94758922e-02f, -4.31834489e-01f, 3.45751792e-01f, 1.47066474e-01f, -2.52538592e-01f, -4.00640637e-01f, -2.26634830e-01f, 2.09185898e-01f, 2.20062360e-01f, 3.68843257e-01f,
  -7.76599646e-02f, -7.28761405e-02f, 4.25086826e-01f, -2.69368917e-01f, 1.36153579e-01f, 3.58946878e-03f, -4.60723221e-01f, -6.60455465e-01f, -1.18558004e-01f, 1.22306794e-01f,
  -2.68615961e-01f, -5.25859833e-01f, 2.58391470e-01f, -2.15818822e-01f, 3.22728425e-01f, 1.64457366e-01f, -4.95735230e-03f, -5.61773814e-02f, 8.08035508e-02f, 2.44113743e-01f,
  -2.01951876e-01f, -2.08776534e-01f, -1.02638870e-01f, -4.61487710e-01f, 5.18620431e-01f, -4.83364835e-02f, 3.05417001e-01f, -2.49567524e-01f, 1.81006417e-01f, -2.28997394e-02f,
  1.98900163e-01f, -1.52317639e-02f, -2.30740666e-01f, -4.01835144e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -2.78464615e-01f, 4.09604579e-01f, 1.69641092e-01f, -9.79053788e-03f, -8.63681555e-01f, -6.55161262e-01f, -6.98191762e-01f, -3.12719285e-01f, -9.31839824e-01f, 1.50163138e+00f,
  -5.45553982e-01f, -7.41329253e-01f, -5.26089191e-01f, -8.70322168e-01f, -4.74949688e-01f, 2.24752143e-01f, 4.45482314e-01f, 6.07295394e-01f, -4.49891016e-02f, 3.60188007e-01f,
  -1.43257514e-01f, 4.72270876e-01f, -1.06919454e-02f, 1.36508495e-01f, -1.81986257e-01f, -6.03749752e-01f, 2.99282581e-01f, 1.43730724e+00f, 8.95250440e-02f, -1.83915243e-01f,
  3.27673525e-01f, -1.53987229e-01f, 1.32604825e+00f, -5.11628836e-02f, 7.11653102e-03f, 4.03262913e-01f, -3.27483296e-01f, -2.06786290e-01f, 1.70374453e-01f, 7.39255995e-02f,
  4.94335830e-01f, -3.34188789e-01f, -3.06152564e-04f, 8.24044466e-01f, 1.13818705e+00f, 5.39517283e-01f, 5.38835466e-01f, -4.27980632e-01f, -2.99731135e-01f, 4.14633065e-01f,
  3.33327532e-01f, -2.05743015e-02f, 1.32849172e-01f, 3.81980449e-01f, 2.34239846e-01f, -2.44455218e-01f, 1.17087565e-01f, 5.40732622e-01f, 9.47889835e-02f, 4.87270147e-01f,
  -7.75209844e-01f, 4.81026113e-01f, 7.53977001e-01f, -2.67123908e-01f, 1.12289202e+00f, -1.76662743e-01f, 5.27075469e-01f, 7.09086359e-02f, -6.73859596e-01f, 1.23491712e-01f,
  1.98798984e-01f, 2.04732008e-02f, 1.47565472e+00f, 1.51800728e+00f, -6.02520816e-03f, -1.19503237e-01f, 9.70475256e-01f, 3.91209841e-01f, 1.80185050e-01f, -2.72619575e-01f,
  1.28246635e-01f, 5.19506931e-01f, 1.98130220e-01f, 2.40224987e-01f, 1.26654610e-01f, -7.71309197e-01f, 7.49358118e-01f, 1.93818614e-01f, 5.78547008e-02f, -5.11139035e-01f,
  -7.08476782e-01f, 8.09389800e-02f, -4.63333577e-01f, 6.92191005e-01f, 6.02287650e-02f, -3.57353508e-01f, 6.77923560e-01f, 3.72291237e-01f, 5.18166423e-01f, 3.97610188e-01f,
  -4.18059170e-01f, -7.11087584e-01f, -4.21064198e-02f, 6.98148787e-01f, -6.17738962e-01f, 1.92552820e-01f, 1.55933738e-01f, -1.62925437e-01f, 6.81640446e-01f, 8.58737975e-02f,
  2.65797138e-01f, -6.76164962e-03f, 3.62359434e-01f, 5.51037550e-01f, 3.31469089e-01f, 1.43028319e-01f, 1.37193573e+00f, 4.31122631e-01f, 2.85567045e-01f, 2.58469105e-01f,
  6.90650046e-01f, -6.73792422e-01f, 8.17307383e-02f, 1.15800726e+00f, 9.29211378e-02f, 5.55144697e-02f, 2.25705251e-01f, 4.47333097e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.50607669e-01f, -4.89811301e-02f, 3.75345647e-01f, -9.20498893e-02f, 3.43947142e-01f, 7.20516145e-01f, 8.32322299e-01f, 4.75591034e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.63346425e-01f, -3.09262127e-01f, 3.30624104e-01f, 1.43432721e-01f, -6.56200290e-01f, 3.76226753e-01f, 5.18572509e-01f, 3.73641104e-02f, 7.15091109e-01f, -4.06334490e-01f,
  6.40028119e-02f, -6.83160350e-02f, -1.32007465e-01f, 2.58003563e-01f, 1.67851895e-01f, -1.26405194e-01f, -1.30388722e-01f, -2.09778294e-01f, -3.74901026e-01f, -3.33052933e-01f,
  3.72348517e-01f, 6.48687243e-01f, 3.03103775e-01f, 7.53302634e-01f, -3.02231945e-02f, 1.35355383e-01f, -3.19950193e-01f, 1.76481634e-01f, 2.71653920e-01f, 1.00408852e-01f,
  2.80464560e-01f, -6.32980838e-02f, -6.64247498e-02f, 4.97382522e-01f, -8.91461223e-03f, -2.90561110e-01f, 2.14493424e-01f, -3.45993012e-01f, -5.19360043e-02f, -4.10187393e-01f,
  3.86188358e-01f, -2.72377044e-01f, -1.25297774e-02f, -3.06367069e-01f, 5.12714614e-04f, -2.90612549e-01f, 2.44471014e-01f, 1.86617136e-01f, -3.24010476e-02f, -1.14727132e-01f,
  -4.64470014e-02f, -2.95623422e-01f, -1.30893504e-02f, -4.61095661e-01f, -2.85074353e-01f, 5.73490143e-01f, -1.69462875e-01f, -7.10166693e-02f, 1.53572708e-01f, 2.07879156e-01f,
  -5.34695871e-02f, 2.01211512e-01f, -4.64760929e-01f, -9.26445425e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  3.33117038e-01f, -6.44332692e-02f, 6.17478609e-01f, -2.18672603e-01f, -4.87982929e-01f, 7.17137754e-01f, 7.01175451e-01f, 5.73995054e-01f, -3.24355364e-01f, 5.93816161e-01f,
  2.43180722e-01f, -1.80806488e-01f, -3.31591666e-01f, 7.70538211e-01f, 8.22346151e-01f, 3.40184599e-01f, -2.35801652e-01f, 3.24794978e-01f, -2.40606487e-01f, 5.65166056e-01f,
  -1.62395582e-01f, -1.22581117e-01f, 1.10485029e+00f, 2.60620207e-01f, 7.74197519e-01f, -3.10272276e-01f, -7.82264829e-01f, -5.38111508e-01f, 2.15620145e-01f, -6.46923482e-01f,
  7.91904688e-01f, 2.39841640e-01f, -3.58154029e-02f, 2.31512800e-01f, 1.56011015e-01f, -2.61104405e-02f, -1.03544462e+00f, -4.27265793e-01f, -1.42549956e+00f, -4.04116958e-01f,
  5.46764076e-01f, 3.04527223e-01f, 5.28097391e-01f, 8.21103632e-01f, 7.29146898e-01f, 3.26081455e-01f, -5.39208412e-01f, 7.74191260e-01f, 7.55556583e-01f, 7.48517573e-01f,
  3.21702026e-02f, 7.68958092e-01f, 8.17886353e-01f, -1.43351495e+00f, 3.50140303e-01f, -1.40668511e+00f, 5.31738222e-01f, -2.74111211e-01f, 3.93732309e-01f, 2.58488029e-01f,
  3.92935365e-01f, -3.17963392e-01f, 7.64999509e-01f, -8.46700013e-01f, 2.42270231e-01f, -5.78981638e-01f, 9.09810722e-01f, -8.20860788e-02f, 1.42857230e+00f, 5.99635005e-01f,
  8.34571123e-01f, 7.67659962e-01f, -9.01135087e-01f, -1.83587238e-01f, 5.18247485e-01f, -4.84185547e-01f, 7.03932643e-01f, -1.80222616e-01f, 4.17539418e-01f, 9.95412841e-02f,
  -3.09836008e-02f, -1.22076936e-01f, 5.72508097e-01f, 8.15830112e-01f, -3.97808403e-01f, -1.34203935e+00f, -1.23430383e+00f, -7.14539826e-01f, 8.40606809e-01f, 4.40309763e-01f,
  -1.74294591e-01f, 1.08939685e-01f, -3.88871171e-02f, -7.59847090e-02f, 2.27540582e-01f, 5.12992799e-01f, 5.36171496e-01f, 4.95991260e-01f, 4.47644979e-01f, 3.82729203e-01f,
  1.09097230e+00f, -1.33568510e-01f, 2.69702733e-01f, 8.61083996e-03f, 3.06444436e-01f, 8.35437536e-01f, 5.20345688e-01f, -4.30644393e-01f, -8.67417529e-02f, -1.24361515e+00f,
  2.13623360e-01f, 3.39559674e-01f, 8.14461946e-01f, 6.40776157e-01f, 1.87220022e-01f, 4.94123518e-01f, -8.66379499e-01f, 1.20538378e+00f, 7.30776489e-01f, 9.86205563e-02f,
  4.45259720e-01f, 8.85887146e-02f, 3.55178624e-01f, 5.80667853e-01f, -1.49215236e-02f, 9.01900053e-01f, 7.97692239e-01f, -8.41227472e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  5.18383741e-01f, 6.38779283e-01f, 3.01629066e-01f, 7.58055210e-01f, 3.04589868e-01f, 3.86157393e-01f, 8.08826275e-03f, 7.55523220e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -5.15836000e-01f, -1.83451533e-01f, 9.64172006e-01f, -1.12378156e+00f, 2.64253259e-01f, 2.81401515e-01f, 2.21258759e-01f, 1.66107923e-01f, 2.45153144e-01f, -2.45998412e-01f,
  4.38625425e-01f, -9.28601623e-01f, -2.78867483e-01f, -1.16589472e-01f, -4.73494679e-01f, -5.67266420e-02f, 5.23147956e-02f, -8.55954885e-02f, -7.82360286e-02f, 2.19679832e-01f,
  -3.59475583e-01f, -1.68402219e+00f, -5.66016614e-01f, -9.76357311e-02f, -3.29138875e-01f, 1.41424701e-01f, 1.89841211e-01f, -9.66596484e-01f, -6.50968015e-01f, 5.73635936e-01f,
  4.00339991e-01f, -1.20087385e-01f, 6.04142845e-02f, 5.01588464e-01f, 1.62073880e-01f, 7.44805098e-01f, 1.12341511e+00f, -1.05385005e+00f, -9.59335804e-01f, -5.89347064e-01f,
  7.74929404e-01f, -4.81716394e-01f, -1.40374467e-01f, -9.04699981e-01f, -3.58327419e-01f, 2.17248291e-01f, -1.14594746e+00f, 3.89251262e-01f, -4.66783702e-01f, -4.69694853e-01f,
  -5.47860563e-01f, -4.97205369e-03f, -6.43041730e-03f, 6.86499357e-01f, -1.31889567e-01f, 4.90821034e-01f, -1.23086655e+00f, -1.21555412e+00f, 3.70273411e-01f, 6.12937570e-01f,
  -3.96643460e-01f, -4.77260239e-02f, -9.79787946e-01f, 1.82826951e-01f, 4.72557127e-01f, -2.19460621e-01f, -1.21399415e+00f, -5.46589755e-02f, -1.41196275e+00f, 2.91281998e-01f,
  9.01912689e-01f, 4.79646504e-01f, 5.07364124e-02f, 3.75826433e-02f, 4.67991121e-02f, -2.09835216e-01f, 4.50300008e-01f, -7.58765280e-01f, -4.95674729e-01f, 3.60434175e-01f,
  -8.15178752e-01f, 1.33889318e-01f, -4.82902616e-01f, -4.44623768e-01f, 1.11726470e-01f, 1.90005928e-01f, -2.69021660e-01f, 3.34557034e-02f, 2.75445074e-01f, -6.81425929e-01f,
  -1.89739868e-01f, -6.26556203e-02f, 2.63278157e-01f, -3.51310343e-01f, 6.15935385e-01f, -1.36312753e-01f, -6.05840802e-01f, -2.45892704e-02f, 2.79345602e-01f, 3.94607754e-03f,
  9.46816579e-02f, 5.75858116e-01f, 9.92483675e-01f, -7.86527395e-02f, 2.63042510e-01f, 6.28585815e-01f, -8.78935874e-01f, 5.79093039e-01f, -8.19656134e-01f, -6.29253566e-01f,
  -8.32178630e-03f, 4.28546101e-01f, -2.64599502e-01f, -4.14976031e-01f, 3.66332680e-02f, -2.78946042e-01f, 1.86760023e-01f, 1.24892092e+00f, -5.66453934e-01f, 4.53089714e-01f,
  -2.88670331e-01f, 6.05039239e-01f, -1.55039936e-01f, 3.61670196e-01f, -1.99350387e-01f, 3.67196620e-01f, 1.74808919e-01f, -5.64630508e-01f, 7.21597970e-01f, 7.85083950e-01f,
  -3.29908282e-01f, -9.00465250e-01f, -1.00778913e+00f, -2.08373472e-01f, 6.52365386e-01f, -4.77204651e-01f, -1.88333839e-01f, -1.11349300e-01f, -8.15982342e-01f, 8.68240118e-01f,
  4.92007971e-01f, -3.13294768e-01f, 6.29373014e-01f, -7.09242225e-01f, 3.21542412e-01f, -5.18819690e-01f, 5.24619162e-01f, 5.11562943e-01f, 1.16318667e+00f, 5.75368583e-01f,
  -5.81329286e-01f, -6.95728660e-01f, 4.94813204e-01f, -4.45744604e-01f, -1.37925208e+00f, -2.43899420e-01f, 9.28865790e-01f, -9.95373249e-01f, -2.08445355e-01f, 4.60373700e-01f,
  -7.07382679e-01f, -3.32747251e-01f, 4.62598860e-01f, 2.22365305e-01f, 1.92249417e-01f, 4.96616662e-01f, -4.36070651e-01f, 9.06370103e-01f, -9.73645091e-01f, -1.00407648e+00f,
  3.45088243e-01f, -4.81127143e-01f, 5.94755411e-01f, 2.39511039e-02f, 1.70352813e-02f, -1.66909313e+00f, 1.10226452e+00f, 6.08624995e-01f, -2.36890033e-01f, 1.19494712e+00f,
  1.24918425e+00f, -1.57072675e+00f, 1.26851952e+00f, -7.06460178e-01f, -1.08647144e+00f, 1.20485164e-02f, -4.77967292e-01f, 7.32253432e-01f, -1.34285676e+00f, 5.69394767e-01f,
  7.82474056e-02f, -1.08225536e+00f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -4.16806370e-01f, 8.24145079e-02f, 2.38947242e-01f, 2.91193891e-02f, 2.94707660e-02f, -5.82328796e-01f, 2.17539877e-01f, -2.26797074e-01f, 1.40208215e-01f, 2.25374371e-01f,
  2.59565830e-01f, 6.51610255e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    