/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.21812147e-01f, -6.40379414e-02f, -6.43788055e-02f, 7.98740909e-02f, 7.97299370e-02f, 6.39011711e-02f, 1.39158264e-01f, 3.88715602e-02f, -3.77774052e-02f, -1.53314039e-01f,
  1.12402789e-01f, -1.46308139e-01f, 3.16468515e-02f, 6.70352653e-02f, 2.48262644e-01f, 1.52183324e-02f, 1.96290448e-01f, 2.17148792e-02f, -1.53211365e-02f, -2.54023429e-02f,
  7.02936649e-02f, 1.48612902e-01f, -2.18413435e-02f, 1.40142441e-01f, 1.81031451e-02f, -5.97687205e-04f, 5.49487621e-02f, -1.84453912e-02f, -9.35140401e-02f, 5.83628267e-02f,
  9.74892601e-02f, 1.04062654e-01f, 3.66567373e-02f, -3.10087227e-03f, -1.31335203e-02f, -7.25774765e-02f, 8.28019530e-03f, -3.45404185e-02f, -4.55134921e-02f, -7.64676183e-02f,
  4.24587866e-03f, 1.02944318e-02f, -2.64007784e-02f, -6.67677820e-02f, -8.85364786e-02f, 4.76427786e-02f, -5.79172038e-02f, 6.52756318e-02f, 9.79375909e-04f, -1.03690028e-01f,
  -9.19475332e-02f, -3.68705764e-02f, -6.97450563e-02f, -1.71925444e-02f, -7.24737421e-02f, -5.30104972e-02f, -5.41492291e-02f, 1.35622928e-02f, 3.36953402e-02f, -1.38598112e-02f,
  -1.03192009e-01f, 3.27695012e-02f, -5.02448678e-02f, -7.38654425e-03f, 2.63340562e-03f, -1.21286092e-02f, 6.95927516e-02f, 3.62741090e-02f, 2.89922375e-02f, 3.91027844e-03f,
  4.08482999e-02f, 1.91673394e-02f, -3.54588255e-02f, -8.50646719e-02f, -5.28456084e-03f, 5.05619347e-02f, 5.64934337e-04f, 4.35725227e-03f, -2.86502833e-03f, -2.51659565e-02f,
  4.84862141e-02f, 7.33680883e-03f, 3.26118991e-02f, -3.72167639e-02f, 7.61336312e-02f, -2.77333502e-02f, -3.02222054e-02f, -5.68052940e-02f, -6.95649767e-03f, -6.77009672e-02f,
  6.21355930e-03f, 3.87727059e-02f, -1.19637931e-02f, -1.12662129e-01f, 4.81121503e-02f, -4.46840301e-02f, 3.69849093e-02f, -4.92379144e-02f, -2.93887816e-02f, 7.19333664e-02f,
  -1.29667357e-01f, -2.11637281e-02f, 8.35058689e-02f, 1.79436523e-02f, 5.48780859e-02f, -2.83942726e-02f, 3.64502370e-02f, 1.76886003e-02f, 2.56479476e-02f, 2.22088676e-02f,
  -4.14752327e-02f, -4.30019051e-02f, 2.99544353e-02f, 5.45712039e-02f, 1.96043309e-02f, 4.73327823e-02f, 4.76983525e-02f, -1.90848280e-02f, 8.80930386e-03f, -1.73547454e-02f,
  -3.58283728e-01f, 3.55695933e-02f, -1.10852964e-01f, -1.79245919e-02f, -4.61015403e-02f, -2.83705890e-01f, -2.49686047e-01f, 1.06182061e-01f, -3.39560181e-01f, 5.59011176e-02f,
  1.58358499e-01f, -5.18073794e-03f, -9.07223821e-02f, 8.71246457e-02f, 1.02578383e-02f, -5.50559498e-02f, 1.37618147e-02f, -2.18910296e-02f, -3.34447175e-02f, 4.66905124e-02f,
  -1.11652449e-01f, 2.06610605e-01f, 5.53442053e-02f, 2.80107617e-01f, 7.26881996e-02f, 7.39618689e-02f, 3.04667264e-01f, 1.07606903e-01f, 2.15936154e-01f, 5.03616482e-02f,
  -3.24191526e-02f, -4.68058363e-02f, -4.12578732e-02f, 8.73882975e-03f, 5.12188636e-02f, 8.79590884e-02f, 1.50416875e-02f, 1.95886511e-02f, -1.57195367e-02f, -3.19217294e-02f,
  -2.26457901e-02f, 6.25525936e-02f, -2.29196437e-02f, -5.98608144e-02f, -6.75066635e-02f, -3.03088594e-02f, 3.59670185e-02f, -6.33900752e-03f, 2.19751447e-02f, -4.34195958e-02f,
  -5.31039871e-02f, 1.51305241e-04f, 4.78563970e-03f, 8.55149329e-02f, -2.13368684e-02f, -5.36120273e-02f, -3.22315916e-02f, -2.06801426e-02f, 2.83462014e-02f, 1.72478252e-03f,
  -9.26599745e-03f, -5.94783574e-02f, 3.20754796e-02f, 5.58145605e-02f, 6.73267916e-02f, 2.16528531e-02f, 1.33236800e-03f, 6.41197860e-02f, -1.09935701e-02f, -3.23909987e-03f,
  4.53742109e-02f, 9.04413126e-03f, 3.74010615e-02f, -4.48756032e-02f, -6.57394752e-02f, -4.79497053e-02f, 5.66428807e-03f, 5.70321307e-02f, -2.42844690e-02f, 5.49483448e-02f,
  -5.84400520e-02f, 3.60492431e-02f, 5.14427759e-03f, 7.07095629e-03f, 4.26915772e-02f, -3.17830890e-02f, 3.21688503e-02f, -2.00113617e-02f, -7.37520074e-03f, 2.34268177e-02f,
  6.73617795e-02f, 1.60945952e-01f, 7.52622122e-03f, -3.83371934e-02f, 2.25566924e-02f, 3.43987420e-02f, 3.43451351e-02f, 1.85359307e-02f, 1.05279148e-01f, 5.52339107e-02f,
  -1.62608677e-03f, -6.29011914e-02f, 3.71599235e-02f, 5.05314581e-02f, 2.13466305e-02f, -3.81760858e-02f, -2.00149231e-02f, 8.17959830e-02f, 8.76715034e-02f, 3.27414386e-02f,
  5.25034741e-02f, -2.04914417e-02f, 4.21068631e-02f, 6.64390698e-02f, 6.03093579e-02f, 1.96708944e-02f, -7.35957688e-03f, -3.85175496e-02f, 4.63640466e-02f, -1.33283474e-02f,
  -3.27770948e-01f, -6.93451613e-02f, -7.64721632e-02f, -1.88876286e-01f, -7.16929212e-02f, -1.20552853e-02f, -7.99536780e-02f, -1.75531730e-02f, -2.80391052e-02f, -7.96351582e-03f,
  -9.64204296e-02f, 2.63845529e-02f, -6.85083941e-02f, -1.65864572e-01f, -3.05512428e-01f, -2.03053236e-01f, -1.53621480e-01f, -1.26598984e-01f, -9.55071673e-02f, -1.64791010e-02f,
  -1.09397493e-01f, -1.22815207e-01f, -1.27852693e-01f, -1.76659897e-02f, 6.06936179e-02f, 4.96646166e-02f, 5.22739515e-02f, 8.68591592e-02f, 2.81398818e-02f, -5.00067100e-02f,
  9.51762572e-02f, -7.24848956e-02f, 9.98127609e-02f, -2.93587875e-02f, 3.96006145e-02f, -2.32663117e-02f, 7.29414895e-02f, -6.91298619e-02f, 1.62067097e-02f, -3.72101367e-02f,
  1.16939910e-01f, -5.41427955e-02f, -6.14940673e-02f, -2.46720010e-04f, -1.20345671e-02f, 3.77054587e-02f, -3.14099304e-02f, 6.59452081e-02f, -7.09252581e-02f, -1.62738096e-02f,
  2.50440184e-02f, 3.97370346e-02f, 3.42662707e-02f, -1.20725026e-02f, -3.40413302e-02f, -1.88895981e-04f, 1.47333508e-02f, 4.94695827e-02f, 3.42285037e-02f, -3.70083675e-02f,
  -4.97106165e-02f, -1.28897966e-03f, 1.75565891e-02f, -7.19244941e-04f, -5.63463643e-02f, -5.64636569e-03f, -1.11541459e-02f, -9.20966361e-03f, -1.62594847e-03f, -7.71899745e-02f,
  9.83310165e-04f, 1.56205026e-02f, -1.01763578e-02f, -6.53952882e-02f, 1.41354641e-02f, 2.55549923e-02f, -1.87684484e-02f, -8.91547501e-02f, 2.14610361e-02f, -3.27392332e-02f,
  7.26657063e-02f, 1.32751381e-02f, 2.43398082e-02f, -2.91368435e-03f, -2.73854844e-02f, 1.47085339e-02f, -5.08642755e-02f, -2.92538274e-02f, 4.26681079e-02f, -2.56165247e-02f,
  1.38531032e-04f, 7.18650818e-02f, -7.29557872e-02f, -2.96044722e-02f, -6.17921054e-02f, -2.46401820e-02f, -6.62804991e-02f, -6.08236529e-02f, 5.02750985e-02f, 7.30242953e-02f,
  8.93892907e-03f, -8.00944678e-03f, 8.82052779e-02f, 1.76652819e-02f, -1.22296698e-02f, -4.45322171e-02f, 4.20089550e-02f, 1.35339694e-02f, -5.98683953e-02f, -3.14422660e-02f,
  5.04172295e-02f, 3.43038216e-02f, -5.60135068e-03f, -3.19460742e-02f, 4.35847528e-02f, 6.05126023e-02f, 3.91089879e-02f, -2.29762737e-02f, -4.60824696e-03f, 1.74586158e-02f,
  2.77330786e-01f, 1.45191163e-01f, 5.01795597e-02f, 1.68428645e-01f, -1.73397481e-01f, -1.42137378e-01f, 1.77729875e-01f, 7.76851624e-02f, 2.69587368e-01f, 1.71866324e-02f,
  6.82816580e-02f, 8.50940030e-03f, 1.59238130e-01f, 8.74262396e-03f, 3.84255238e-02f, 1.27271965e-01f, 9.69512984e-02f, -4.34270501e-02f, 4.45440821e-02f, 1.12314999e-01f,
  9.08801481e-02f, -7.92335998e-03f, 8.57180357e-02f, -1.81593839e-02f, 7.50385225e-02f, 2.02650633e-02f, -5.17740175e-02f, 3.27515649e-03f, -6.38629720e-02f, -1.46909297e-01f,
  2.99027264e-02f, 4.71640341e-02f, 3.39835836e-03f, 1.53535686e-03f, 2.76914760e-02f, 1.95029657e-02f, -8.88375342e-02f, -2.97077261e-02f, -2.13639392e-03f, 5.44007383e-02f,
  6.38318658e-02f, 1.82048921e-02f, -7.07602277e-02f, 4.46268506e-02f, -2.40552668e-02f, -4.42840066e-03f, -2.40663458e-02f, 6.08955733e-02f, 2.82921549e-03f, 7.21888151e-03f,
  5.06536737e-02f, -4.06181585e-04f, 2.40774639e-02f, -3.32200341e-02f, 2.72010993e-02f, 8.95906389e-02f, -3.09392530e-03f, -3.75038944e-02f, -2.96848044e-02f, -8.41353275e-03f,
  5.10175824e-02f, -1.68564450e-02f, -4.97900993e-02f, 3.00919227e-02f, 7.26288408e-02f, 2.10314225e-02f, 6.86183432e-03f, -2.87396964e-02f, 1.54300155e-02f, 1.93228833e-02f,
  8.56712926e-03f, 2.21168697e-02f, 3.87978107e-02f, -1.04891378e-02f, 4.50571359e-04f, 6.25904836e-03f, -1.26765016e-02f, -3.60792391e-02f, -2.96661793e-03f, 3.65013331e-02f,
  -9.18396562e-03f, 9.52562410e-03f, -1.11885881e-02f, 1.78768858e-02f, -4.51487340e-02f, 3.57663594e-02f, -1.81615558e-02f, 5.42236827e-02f, 1.59955304e-02f, -9.33815073e-03f,
  -3.89457680e-03f, 1.02584086e-01f, 4.25740518e-02f, -9.16019902e-02f, 9.33086034e-03f, 8.65663216e-03f, 7.25331604e-02f, -2.73714699e-02f, 8.77184346e-02f, 6.54557571e-02f,
  -7.70149454e-02f, -6.41711578e-02f, 1.99994911e-02f, -4.15208936e-03f, -4.05510478e-02f, -3.68144885e-02f, -3.84499468e-02f, 1.42376907e-02f, 2.25672834e-02f, 8.09484906e-03f,
  3.41080166e-02f, 3.95531058e-02f, -6.30486757e-02f, 3.45793217e-02f, -3.27964090e-02f, 1.84447989e-02f, 3.10078263e-02f, 6.06042519e-03f, -1.17989602e-02f, 2.77208239e-02f,
  4.70013879e-02f, 1.16892226e-01f, -1.30237117e-02f, 1.82469591e-01f, -4.07017022e-03f, -3.91510502e-02f, -3.02752163e-02f, 2.09328711e-01f, 2.05614164e-01f, 1.26477212e-01f,
  9.65147689e-02f, 6.12684293e-03f, -1.75570369e-01f, 1.16454311e-01f, -3.77895653e-01f, -2.65666723e-01f, 9.14803743e-02f, 2.82140579e-02f, 4.16430719e-02f, 1.42937690e-01f,
  -8.38072523e-02f, 8.09795260e-02f, -2.38041684e-01f, 9.41821709e-02f, 1.56975798e-02f, 1.51184365e-01f, -1.41019180e-01f, -4.25355136e-02f, 1.44595370e-01f, 5.16953133e-02f,
  5.14890477e-02f, 1.84605733e-01f, 6.27895221e-02f, 1.23997480e-02f, 6.26589656e-02f, -3.32214870e-02f, -1.83066837e-02f, -2.16217376e-02f, 4.92475219e-02f, -4.82714409e-03f,
  -6.40530214e-02f, 8.90960079e-03f, 9.17829201e-02f, -3.89905274e-02f, -3.82704264e-03f, 7.55250752e-02f, -7.86791649e-03f, 2.89920028e-02f, 2.14162320e-02f, -8.35285522e-04f,
  1.20583493e-02f, 5.06191589e-02f, 5.77327348e-02f, 6.42496049e-02f, 3.28739509e-02f, 1.17486484e-01f, -1.95501503e-02f, -1.20183313e-02f, 3.94872539e-02f, 6.81587234e-02f,
  -3.77090387e-02f, -6.32020980e-02f, 2.56617628e-02f, 8.30578357e-02f, 3.40241529e-02f, 4.27365787e-02f, 9.43225436e-03f, -1.88718084e-02f, 7.45740114e-03f, 9.86259431e-03f,
  4.73449565e-02f, 6.72567114e-02f, 4.67884690e-02f, 2.83016991e-02f, 4.32386715e-03f, 1.84935909e-02f, 1.38203511e-02f, 3.39812785e-03f, -3.39809619e-02f, 2.40061269e-03f,
  -1.41801527e-02f, 2.91066784e-02f, -6.84989840e-02f, -9.58398357e-03f, 2.38736924e-02f, -2.02339161e-02f, -1.27732416e-03f, 3.31177562e-02f, -2.90956311e-02f, -2.30518654e-02f,
  7.36059695e-02f, 1.94117025e-01f, 2.21258104e-02f, 1.03734441e-01f, -1.50005356e-03f, -4.09305096e-02f, -6.16175495e-03f, -3.26745166e-03f, -1.73978489e-02f, 2.00659130e-03f,
  5.18876389e-02f, -4.78036655e-03f, -7.96466544e-02f, -1.84773598e-02f, 3.66546214e-03f, -2.40696291e-03f, -8.97925161e-03f, -4.60350104e-02f, 2.09303033e-02f, -3.43935634e-03f,
  -1.11643877e-02f, -1.78007521e-02f, 1.63363181e-02f, -4.75653745e-02f, -2.16422006e-02f, -3.84183079e-02f, 3.90138030e-02f, 2.87925806e-02f, -7.15030432e-02f, -4.56310324e-02f,
  -1.99020505e-01f, 7.63740912e-02f, 7.90365934e-02f, -1.85912222e-01f, -2.94681527e-02f, -1.57459781e-01f, -1.74134642e-01f, 4.36206954e-03f, 2.73626130e-02f, 1.30932564e-02f,
  -7.24037737e-02f, 1.80745929e-01f, -1.81716215e-02f, -4.33625914e-02f, -6.67466894e-02f, 1.22531438e-02f, -1.53302729e-01f, -1.36087656e-01f, 4.70936596e-02f, -9.82745085e-03f,
  -7.20333010e-02f, -1.14299990e-01f, -9.01446566e-02f, -7.47549757e-02f, -5.25226705e-02f, -1.60619002e-02f, -1.29899204e-01f, -9.03998613e-02f, -5.41793443e-02f, 4.25251871e-02f,
  -3.35156098e-02f, 1.10871933e-01f, 1.81619786e-02f, 9.21840146e-02f, -5.32037616e-02f, 6.38318583e-02f, 6.35376573e-03f, 1.87190566e-02f, -7.90643692e-02f, 7.73065761e-02f,
  1.42777618e-02f, 2.80181933e-02f, 5.99740893e-02f, 1.36767598e-02f, 1.08408667e-01f, 3.17134336e-02f, 1.14383297e-02f, -8.17263406e-03f, -5.20997681e-02f, 2.12400854e-02f,
  -2.68677194e-02f, -1.32314791e-03f, -6.11655191e-02f, -6.20795367e-03f, 2.42350996e-03f, -2.31630076e-02f, -2.93323528e-02f, 3.62334810e-02f, 6.61239997e-02f, -2.03697849e-02f,
  -2.96762530e-02f, 7.01319054e-02f, -4.91834208e-02f, -2.73675397e-02f, 5.11027090e-02f, -3.92641835e-02f, 5.15440991e-03f, -5.49129248e-02f, 2.35147476e-02f, -2.18194127e-02f,
  -3.71535905e-02f, 4.93531860e-02f, -3.70572507e-03f, -1.25280851e-02f, 8.11227337e-02f, 4.50195819e-02f, -1.40188728e-02f, -3.92677449e-02f, -9.99950767e-02f, -1.04409009e-02f,
  -1.25067141e-02f, 3.32829989e-02f, -5.32067306e-02f, -7.88045675e-02f, -1.45682599e-02f, 7.69043490e-02f, 1.43244974e-02f, 4.75345142e-02f, -5.62577993e-02f, 1.99157074e-02f,
  -1.42829761e-01f, 2.00660396e-02f, -3.13622095e-02f, -7.47750476e-02f, 6.47313744e-02f, 2.80553196e-03f, -4.12318623e-03f, 7.39950538e-02f, -6.39339397e-03f, 3.77169764e-03f,
  -5.86591177e-02f, -4.39891778e-02f, -4.66031488e-03f, 1.90249681e-02f, 3.43364440e-02f, 1.84214953e-02f, -4.17625904e-02f, -3.26784961e-02f, 7.92983826e-03f, 9.28552821e-02f,
  1.09194629e-02f, -6.39395565e-02f, 1.02285799e-02f, -3.20382230e-02f, 1.40706627e-02f, -2.42802370e-02f, 8.25466290e-02f, 7.70003861e-03f, -4.81485855e-03f, -7.34093040e-03f,
  2.38994122e-01f, 9.46291983e-02f, 2.97304839e-01f, 6.89608902e-02f, 2.46144205e-01f, 1.45445153e-01f, 6.01861440e-02f, 1.44763738e-01f, 1.88866690e-01f, -8.65816176e-02f,
  5.40621020e-02f, 4.91702836e-03f, -5.15789762e-02f, -1.19027518e-01f, 1.36554897e-01f, -1.60449743e-01f, 9.63409245e-02f, 1.92080513e-02f, -2.96887811e-02f, -2.13665515e-02f,
  5.73682506e-03f, -1.02484748e-01f, -7.68435374e-02f, -1.08345240e-01f, 1.86485182e-02f, 3.26638222e-02f, 4.82044071e-02f, -2.36198734e-02f, -3.37598287e-02f, 1.00106090e-01f,
  2.96038715e-03f, 5.71886776e-03f, 5.41664027e-02f, 3.70820910e-02f, 1.25146449e-01f, 1.22850001e-01f, 1.26991859e-02f, -2.18072049e-02f, -4.08210829e-02f, 4.32581566e-02f,
  -4.78530629e-03f, -1.12536522e-02f, 4.89289649e-02f, 2.36422773e-02f, 3.22485417e-02f, -1.10490983e-02f, -7.35509628e-03f, -2.09087636e-02f, -4.02571224e-02f, -1.64946672e-02f,
  2.69911196e-02f, 2.58302153e-03f, 4.81136404e-02f, -1.69804581e-02f, 4.84521575e-02f, -5.05320448e-03f, -3.48195583e-02f, 1.87398642e-02f, 4.36318070e-02f, 8.16281289e-02f,
  2.76027787e-02f, 3.88463251e-02f, 6.64052963e-02f, -1.02482801e-02f, -3.83411460e-02f, 9.86904744e-03f, -1.74891818e-02f, -6.58564419e-02f, 7.09099248e-02f, -2.41094977e-02f,
  2.13819873e-02f, 2.18748692e-02f, -9.49036889e-03f, 1.33064222e-02f, 7.87569806e-02f, -1.66485254e-02f, -9.76772606e-02f, -5.05921105e-03f, 2.29650177e-03f, -1.96376573e-02f,
  5.00583090e-02f, 6.93356097e-02f, 2.03479566e-02f, 2.33162567e-02f, 4.02463488e-02f, 4.79460880e-02f, -3.34696025e-02f, -1.74942650e-02f, -1.95050705e-02f, 1.79180466e-02f,
  3.63269709e-02f, 2.03751311e-01f, -5.28769158e-02f, -1.48703288e-02f, -5.78378066e-02f, 1.88491249e-03f, 2.31700167e-02f, -3.36607196e-03f, 7.89627507e-02f, 6.49911240e-02f,
  4.42723297e-02f, 2.37871747e-04f, 3.66982222e-02f, -3.19180787e-02f, 1.52569553e-02f, 8.79541188e-02f, 1.81952212e-02f, -2.46198643e-02f, 6.30808473e-02f, 5.06311134e-02f,
  -6.30032551e-03f, 1.14632798e-02f, -7.72519857e-02f, -1.43278670e-02f, -3.24971005e-02f, -1.52028147e-02f, 3.67086865e-02f, 2.71082930e-02f, 7.72702098e-02f, -1.18799489e-02f,
  1.58790708e-01f, -4.92639886e-03f, -1.39077187e-01f, 6.43716902e-02f, 2.54772216e-01f, 2.79910527e-02f, -1.16469167e-01f, 1.68158740e-01f, 1.07494732e-02f, 1.15931947e-02f,
  3.26576345e-02f, -4.13303152e-02f, -1.96073681e-01f, 3.34138535e-02f, -2.61504203e-01f, -2.76570141e-01f, 6.60722852e-02f, -6.22496903e-02f, -1.04288161e-02f, 2.11238116e-01f,
  -5.57122938e-02f, 9.45490822e-02f, -1.34340033e-01f, 1.91721857e-01f, 7.51581565e-02f, 4.76356782e-03f, -9.67836659e-03f, 3.43444496e-02f, 1.11076854e-01f, 3.41103366e-03f,
  -4.76050898e-02f, 4.10398990e-02f, 6.96219429e-02f, -4.11164761e-02f, -3.10208369e-02f, 1.76879223e-02f, -4.41103019e-02f, -3.97012495e-02f, -1.91415306e-02f, 1.70312729e-02f,
  2.74995714e-02f, 2.94457264e-02f, 4.05296218e-03f, 5.03053516e-02f, 6.80302158e-02f, 2.05695350e-02f, 5.14078587e-02f, 4.08561863e-02f, 1.76627487e-02f, -7.83919543e-03f,
  -2.37353779e-02f, -2.79199821e-03f, -2.75132759e-03f, -4.03920598e-02f, -3.47434863e-04f, 1.04145939e-02f, -3.73266749e-02f, -9.52169076e-02f, 1.76198427e-02f, 3.75625007e-02f,
  4.77414206e-02f, 3.37646268e-02f, -6.77996129e-03f, 1.02942586e-02f, -1.89735298e-03f, 4.77552935e-02f, -3.07682058e-04f, -4.44541313e-03f, 6.66236207e-02f, 2.46097017e-02f,
  3.26567702e-02f, -1.05213774e-02f, 2.66877767e-02f, -3.31090726e-02f, 2.10048202e-02f, 6.46767467e-02f, -3.31352204e-02f, 2.03717779e-03f, 3.56761180e-02f, 2.07521673e-02f,
  3.85208838e-02f, -6.96520973e-03f, 4.66373097e-03f, -2.40070019e-02f, -1.06672877e-02f, -1.86557490e-02f, 2.84980945e-02f, 2.55760513e-02f, -1.01890974e-02f, -3.61854881e-02f,
  -5.89918904e-02f, -9.03802440e-02f, -4.31982353e-02f, 4.89521299e-05f, -8.79742801e-02f, -8.64082295e-03f, 8.81279912e-03f, 4.33372445e-02f, 6.47646200e-04f, 3.28711024e-03f,
  1.69684775e-02f, -2.18984764e-02f, -1.72925629e-02f, 5.68496622e-02f, 1.50319915e-02f, -4.95118685e-02f, -3.71299088e-02f, 6.91734767e-03f, 6.68951403e-03f, -3.62445833e-03f,
  1.85496714e-02f, -5.58181200e-03f, -5.48554845e-02f, 4.62814532e-02f, 4.31471430e-02f, -6.21756986e-02f, 5.36296144e-02f, -5.50130643e-02f, 5.88111095e-02f, -5.64729236e-02f,
  2.39418089e-01f, -3.31356645e-01f, 1.29401669e-01f, -5.73986843e-02f, 1.64968610e-01f, -7.16098845e-02f, 4.40525413e-02f, -4.73122187e-02f, -3.41268182e-02f, -2.57311374e-01f,
  -1.37599200e-01f, -2.12899353e-02f, -1.11329228e-01f, -1.13974899e-01f, -2.75682280e-04f, -1.29312098e-01f, -1.05109036e-01f, -5.51478341e-02f, 1.93675924e-02f, -1.09816432e-01f,
  4.33089351e-03f, -1.84820816e-01f, 5.93974926e-02f, -2.14308798e-02f, 3.31225507e-02f, 3.43608111e-02f, -8.41794461e-02f, 1.38832748e-01f, 5.54517051e-03f, 7.04463422e-02f,
  1.22920759e-01f, -4.62623462e-02f, 9.43619087e-02f, 1.92402527e-02f, -6.14783987e-02f, 5.00555634e-02f, -1.67473275e-02f, 6.04159907e-02f, 5.45109734e-02f, -2.30331775e-02f,
  7.81084830e-03f, 3.30902897e-02f, -4.00576703e-02f, 2.16373848e-03f, 1.31703028e-02f, 1.12324720e-02f, 3.49058839e-03f, 5.21134250e-02f, 2.95615327e-02f, -2.06438527e-02f,
  2.08011754e-02f, -3.89568973e-03f, -1.78169683e-02f, 8.89812782e-03f, -2.00205725e-02f, 1.39301913e-02f, 4.72349785e-02f, 6.86743110e-03f, -2.46009659e-02f, -7.99402073e-02f,
  1.77395884e-02f, -8.54422525e-02f, 1.04985043e-01f, 4.30745073e-02f, 9.84948035e-03f, -2.50889305e-02f, 1.40247503e-02f, -1.72401164e-02f, 1.04239155e-02f, -3.06770988e-02f,
  -7.60111213e-03f, 3.62853333e-03f, 5.77104231e-03f, 4.40314673e-02f, 2.36468706e-02f, 6.88032135e-02f, 6.58517893e-05f, -1.02127506e-03f, 7.10697100e-03f, 2.34885607e-02f,
  -3.52824442e-02f, 2.76897717e-02f, 1.83394197e-02f, 2.97289696e-02f, 4.68940400e-02f, 6.87722489e-02f, -2.20331065e-02f, 6.63435757e-02f, -3.00130411e-03f, -2.99907266e-03f,
  -2.57684290e-01f, -3.36359054e-01f, -7.17073008e-02f, 4.11745459e-02f, -5.32781743e-02f, -4.33555245e-03f, -4.64789942e-02f, 1.19381910e-02f, -5.99358268e-02f, -2.64366921e-02f,
  1.48590272e-02f, 2.11292058e-02f, 3.80772427e-02f, 2.48338301e-02f, -1.86421908e-02f, -8.40494707e-02f, -5.73455133e-02f, -1.44231319e-02f, -8.79854560e-02f, 4.41015810e-02f,
  -1.57500319e-02f, -3.06672640e-02f, -4.13651951e-03f, 1.57590527e-02f, 3.29880267e-02f, -2.14041993e-02f, -1.27550317e-02f, 1.95693430e-02f, -6.17576204e-02f, 2.77639385e-02f,
  2.06672912e-03f, 3.03509887e-02f, -4.88594323e-02f, 8.08151588e-02f, -1.39644489e-01f, -3.68307084e-01f, -3.09257567e-01f, 3.94108845e-03f, -6.46965876e-02f, 2.02403944e-02f,
  -4.41956632e-02f, 1.68007642e-01f, -1.90996245e-01f, -4.31212224e-02f, -1.38286293e-01f, -2.27563038e-01f, -4.66531590e-02f, -1.23338234e-02f, -9.32593495e-02f, -5.84018789e-02f,
  -3.46037410e-02f, -3.51763628e-02f, 5.68716377e-02f, 8.10010657e-02f, 9.43056215e-03f, 2.21104398e-01f, 8.84404033e-02f, -1.01249494e-01f, 2.54071444e-01f, 2.89328825e-02f,
  1.46269221e-02f, 1.35152042e-02f, 1.19358942e-01f, -5.36877625e-02f, 5.53188175e-02f, 4.92305346e-02f, 7.26167485e-02f, -7.32075274e-02f, -3.94282751e-02f, 2.68577915e-02f,
  -3.46780978e-02f, 9.10808519e-02f, 6.41822666e-02f, -2.30327193e-02f, -1.33669917e-02f, 2.79962234e-02f, -1.58867948e-02f, -3.26995924e-02f, 2.43308078e-02f, -6.02113344e-02f,
  4.20664102e-02f, 7.15544298e-02f, -8.32041446e-03f, 4.85049859e-02f, 1.11956364e-02f, -3.72506455e-02f, -7.84809142e-02f, 1.06567983e-02f, 3.29273865e-02f, -1.27133029e-02f,
  1.03933953e-01f, -6.76978156e-02f, -6.22131564e-02f, 5.96726052e-02f, -1.91385075e-02f, -2.42754370e-02f, 1.41547322e-02f, -9.83007438e-03f, -4.70378548e-02f, -1.53894222e-03f,
  -1.11438837e-02f, 2.94402856e-02f, 9.45141632e-03f, -5.43568023e-02f, -1.72096975e-02f, 1.46688828e-02f, -3.85643020e-02f, -8.29084031e-03f, 4.44097072e-03f, 4.26692702e-02f,
  3.10273673e-02f, -6.43338710e-02f, 1.39132990e-02f, -4.82829325e-02f, -2.05340423e-03f, -3.39854807e-02f, 5.27505949e-02f, 7.04530813e-03f, 1.15112001e-02f, 4.95813647e-03f,
  -2.04306558e-01f, -2.98815612e-02f, 2.71168053e-02f, -1.26930873e-03f, 4.40044515e-02f, 3.19203474e-02f, -1.39312565e-01f, 5.39472587e-02f, -7.25557879e-02f, -4.48694490e-02f,
  -3.31114084e-02f, -3.33026797e-02f, -5.85153699e-04f, 3.25268023e-02f, -6.39348943e-03f, 4.59961034e-03f, -5.15768304e-03f, 3.35743790e-03f, 6.53818995e-02f, -5.29359002e-03f,
  2.48964354e-02f, -9.72225890e-02f, 2.54548173e-02f, 7.39943311e-02f, -2.15292182e-02f, 1.17758863e-01f, 8.69896188e-02f, 7.92104304e-02f, 1.67417955e-02f, 2.36413535e-02f,
  4.37887549e-01f, -3.84765744e-01f, 1.48338214e-01f, -1.90050062e-02f, 8.14391673e-02f, -3.55153173e-01f, -8.20832327e-02f, 5.67872897e-02f, 3.26104686e-02f, -1.82215244e-01f,
  3.99292149e-02f, -2.87752040e-02f, -3.24995220e-02f, -1.56398192e-01f, 2.30663922e-02f, -1.36403471e-01f, -3.09101325e-02f, -6.70465007e-02f, 8.46307054e-02f, 3.85247357e-02f,
  1.45993575e-01f, -1.01652652e-01f, 4.99665737e-02f, -1.47585208e-02f, 1.48914456e-01f, 1.70387119e-01f, 4.32069227e-02f, 1.87117625e-02f, 6.90033063e-02f, -3.14013883e-02f,
  6.51063323e-02f, 1.14711627e-01f, 1.40835002e-01f, -5.62159996e-03f, -1.84135139e-02f, 3.32141519e-02f, -2.79043335e-02f, 1.88350920e-02f, 9.18805674e-02f, -5.52424602e-02f,
  -6.59069568e-02f, -7.42434487e-02f, -1.63760390e-02f, 1.00509133e-02f, 1.24175167e-02f, 6.59530684e-02f, 3.96670960e-02f, -3.43604088e-02f, 1.20893512e-02f, 2.60325838e-02f,
  1.68157388e-02f, -7.46867508e-02f, -5.96291758e-03f, -6.55153617e-02f, 7.23675936e-02f, -2.34576166e-02f, -4.99817170e-02f, -6.66932622e-03f, -5.40354922e-02f, -2.31967513e-02f,
  -1.04695670e-02f, 4.09943052e-02f, -2.45947689e-02f, -2.41997205e-02f, 6.25490816e-03f, 5.75745441e-02f, -6.08294969e-04f, 2.33102534e-02f, 2.24918034e-02f, -1.70038864e-02f,
  3.38924602e-02f, -2.12127203e-03f, 1.85497396e-03f, -1.99104566e-02f, 1.39902104e-02f, -7.80988336e-02f, 2.63238717e-02f, 1.55789722e-02f, 2.28154310e-03f, 3.48192900e-02f,
  -5.50406612e-03f, -1.21989921e-02f, 3.11172139e-02f, -5.82352607e-03f, 5.50425728e-04f, -4.02098484e-02f, -2.46727802e-02f, 1.69704820e-03f, 2.62064226e-02f, 1.52567094e-02f,
  -1.91724792e-01f, -1.35666609e-01f, -1.46014234e-02f, -3.09901722e-02f, -4.22697142e-03f, -5.00547327e-02f, 9.35797652e-05f, -1.50630390e-02f, -3.54059935e-02f, 7.05102533e-02f,
  -1.52157098e-02f, 2.39867885e-02f, -2.15412881e-02f, 1.53230305e-03f, -1.35857314e-02f, -2.82606017e-02f, 7.90211838e-04f, -4.68146475e-03f, -3.42674591e-02f, -2.71089375e-02f,
  4.35633548e-02f, 4.12877537e-02f, -1.65127893e-03f, 6.67721406e-02f, -3.21489796e-02f, 1.87758263e-02f, 3.67694651e-03f, 1.80020593e-02f, 4.41193059e-02f, -7.69931776e-03f,
  5.24681032e-01f, 1.57288704e-02f, 1.10696085e-01f, 2.96260625e-01f, 1.78624187e-02f, 1.42010644e-01f, 2.70341903e-01f, -3.08953263e-02f, -2.54358649e-02f, -5.82397878e-02f,
  1.92966014e-02f, 1.23502761e-01f, -6.07032292e-02f, 8.32008421e-02f, 1.06942549e-01f, -1.82536155e-01f, 7.51826391e-02f, 6.89398348e-02f, -9.04113054e-02f, 1.26527280e-01f,
  3.91274430e-02f, -3.51636857e-02f, 4.77204993e-02f, -1.68859288e-01f, 1.99474484e-01f, 3.11259385e-02f, -3.74761857e-02f, 6.69480264e-02f, 1.46040872e-01f, -3.00028315e-03f,
  -2.25785658e-01f, -1.43145829e-01f, -1.18248677e-02f, -2.99850870e-02f, 6.10381067e-02f, 2.07106676e-02f, 8.38791579e-02f, 3.32365707e-02f, -4.10134019e-03f, -1.30481608e-02f,
  9.47728828e-02f, 1.53571116e-02f, 5.08765988e-02f, -5.70177026e-02f, 3.66273895e-02f, 3.23886089e-02f, 2.34775571e-03f, -1.47076296e-02f, -5.91610521e-02f, -3.73855233e-04f,
  -1.93628483e-02f, 1.60247423e-02f, 4.18491885e-02f, -3.85773219e-02f, 2.65488569e-02f, 1.20442417e-02f, 2.41313819e-02f, 2.75376439e-02f, 1.32869687e-02f, -1.47411618e-02f,
  -7.26780146e-02f, -1.04015926e-02f, -6.39660507e-02f, -3.59165557e-02f, 1.92991905e-02f, -6.75420985e-02f, -5.98850008e-03f, -3.14538553e-02f, -3.82139869e-02f, -1.59193873e-02f,
  3.17494310e-02f, -1.12843970e-02f, -6.56941952e-03f, -1.98532138e-02f, 3.28642577e-02f, 2.19165422e-02f, 4.92466763e-02f, -1.38551239e-02f, 8.88645090e-03f, -1.29046775e-02f,
  -5.67158312e-02f, -1.54251570e-03f, -7.26553947e-02f, 5.29979728e-02f, -4.38765548e-02f, 2.49500666e-02f, -4.75951992e-02f, 1.59700178e-02f, 2.20306925e-02f, 7.81716406e-02f,
  1.27798483e-01f, 1.69775769e-01f, -1.29762441e-02f, -7.52256205e-03f, -2.78236363e-02f, 6.36075959e-02f, -5.34389503e-02f, 4.92032841e-02f, 3.07154432e-02f, 1.10667264e-02f,
  -3.84724364e-02f, 1.31825823e-03f, 5.40037602e-02f, 3.44894715e-02f, -4.45504747e-02f, -7.85601810e-02f, 3.42439115e-02f, 5.88286556e-02f, 6.12495653e-02f, 9.64703877e-03f,
  6.15404174e-02f, -6.51079230e-03f, 2.33117901e-02f, -8.00698623e-03f, 4.22409028e-02f, 5.20716533e-02f, 3.39498594e-02f, -4.48682606e-02f, 1.06114205e-02f, -8.01552087e-03f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.24140300e-01f, 7.81576112e-02f, 8.18010494e-02f, 3.47765163e-02f, 4.20722142e-02f, 6.13099672e-02f, 1.30612954e-01f, -3.88499685e-02f, 3.51531506e-02f, 1.05929106e-01f,
  1.40385702e-01f, 1.64370984e-02f, 1.09651126e-01f, 7.51021178e-03f, -6.73326030e-02f, -6.34453148e-02f, -5.01299836e-02f, 4.10902649e-02f, 2.74691638e-02f, 2.90716928e-03f,
  -8.76329169e-02f, -1.07740618e-01f, 1.08268578e-02f, -2.31800973e-02f, -1.09342588e-02f, -6.44964352e-02f, -1.04887642e-01f, 1.27264708e-01f, 6.34280741e-02f, -2.00481489e-02f,
  5.49237579e-02f, 3.33796628e-02f, 7.76401088e-02f, -2.47927289e-02f, -4.30101827e-02f, 1.31095126e-02f, 3.33291776e-02f, 2.85080429e-02f, -4.13572639e-02f, -5.82955293e-02f,
  -7.89840594e-02f, -8.48756135e-02f, 8.73014797e-03f, 6.81804940e-02f, 3.17328870e-02f, -2.50500944e-02f, 4.76384126e-02f, -1.37754362e-02f, 8.74281451e-02f, 6.17978610e-02f,
  -1.47118873e-03f, -3.20825987e-02f, 3.18792686e-02f, -8.19563195e-02f, -8.49422626e-03f, 5.73627353e-02f, 1.03674762e-01f, -6.30325750e-02f, -3.17694731e-02f, 5.80760650e-02f,
  7.75466710e-02f, 4.55382746e-03f, 2.23983414e-02f, 7.05125555e-02f, 7.23458901e-02f, 7.66387656e-02f, 7.29621276e-02f, 4.88324240e-02f, 4.14517568e-03f, 3.77846360e-02f,
  7.77542498e-03f, -2.55397148e-02f, -1.09790236e-01f, -5.78590259e-02f, 1.21484194e-02f, -1.14491279e-03f, -8.40349272e-02f, 6.05995357e-02f, 4.65770140e-02f, -6.08843789e-02f,
  6.00217469e-02f, -6.57562241e-02f, 5.82275018e-02f, -3.36125493e-02f, -1.37717742e-02f, 8.92231986e-03f, -5.91608696e-02f, 6.93459138e-02f, -4.23970297e-02f, -9.20055658e-02f,
  -5.11479378e-02f, 7.27045313e-02f, -5.03555499e-02f, -8.75221789e-02f, -5.82662225e-02f, 2.18503978e-02f, -2.50857119e-02f, -9.00900438e-02f, 4.71842624e-02f, -3.14605944e-02f,
  -7.63770491e-02f, 6.01638108e-03f, -4.33037542e-02f, -4.78061251e-02f, 2.19566189e-02f, 5.25263883e-02f, 3.33034284e-02f, -8.77219439e-02f, -7.54688587e-03f, 7.66161904e-02f,
  4.91654538e-02f, 2.12568231e-02f, -9.41916704e-02f, -5.28008724e-03f, -9.54154357e-02f, 5.87284863e-02f, 7.42233098e-02f, -1.56489983e-02f, 2.73522139e-02f, -9.30162594e-02f,
  2.29480669e-01f, 1.74065262e-01f, 1.65301368e-01f, 1.93754509e-01f, -2.14333266e-01f, -2.46123701e-01f, -5.48728183e-02f, 5.85640147e-02f, -4.16561589e-02f, 2.65019946e-02f,
  8.31476375e-02f, -6.64083064e-02f, 1.17246412e-01f, 4.51338068e-02f, 1.13128498e-01f, 7.80272558e-02f, -5.67498133e-02f, -1.64196029e-01f, -7.85111561e-02f, 1.63170159e-01f,
  9.44329724e-02f, 1.38195142e-01f, 2.20042720e-01f, 1.65157109e-01f, 2.20143944e-02f, 1.44980237e-01f, 2.00982958e-01f, 6.99600205e-02f, 7.39151016e-02f, -8.37819204e-02f,
  -1.59085825e-01f, -2.32783630e-02f, 2.17563342e-02f, -9.30465311e-02f, -5.22280950e-03f, -8.30246042e-03f, -9.36196595e-02f, 5.59384003e-02f, 4.45650183e-02f, -1.87329389e-02f,
  7.56571302e-03f, -6.34590387e-02f, -7.41531402e-02f, -2.36179885e-02f, 7.12050945e-02f, -2.08937377e-02f, -2.12021489e-02f, -6.13935851e-02f, -3.64247262e-02f, 1.43401846e-02f,
  3.39402184e-02f, 5.41488975e-02f, 6.14810511e-02f, -3.98132727e-02f, -2.12465394e-02f, -5.86172976e-02f, 4.84489277e-02f, 5.42641282e-02f, -7.02463686e-02f, -3.27684134e-02f,
  -4.56070434e-03f, 5.82547747e-02f, 6.22084625e-02f, 4.19821627e-02f, -1.68860741e-02f, -1.02273915e-02f, 1.00192145e-01f, -4.71922942e-02f, -9.24244374e-02f, 6.88823089e-02f,
  -7.27816075e-02f, 6.86388882e-03f, -6.04829527e-02f, 1.16493730e-02f, 4.01538089e-02f, -2.35779490e-03f, -1.00137405e-02f, -3.47625390e-02f, 1.80537626e-02f, 9.48446319e-02f,
  2.60548200e-03f, 4.58233431e-02f, 2.76717041e-02f, -3.33890878e-02f, 1.27501944e-02f, 5.23114800e-02f, 2.85732411e-02f, 1.00961328e-01f, 2.69727968e-02f, 1.14969853e-02f,
  7.20682666e-02f, 2.03448012e-01f, 7.08511397e-02f, 1.96806211e-02f, -6.13772869e-02f, -9.74204764e-02f, -6.07332913e-03f, -6.78148493e-02f, 1.33742765e-02f, 2.52480083e-03f,
  6.49851337e-02f, -4.26296443e-02f, 2.53622066e-02f, 9.22854058e-03f, 7.50745982e-02f, 8.29650238e-02f, 2.27283090e-02f, 5.50547102e-03f, 2.34133564e-02f, 3.22512053e-02f,
  1.03217341e-01f, -3.76193412e-02f, 2.46172640e-02f, -5.28684594e-02f, -9.04610194e-03f, -3.32903974e-02f, 2.09023599e-02f, -9.39077977e-03f, -4.18281257e-02f, 7.41836876e-02f,
  2.51962915e-02f, -1.66766569e-01f, -4.97436881e-01f, -1.00768000e-01f, 1.36973023e-01f, 2.52452016e-01f, -2.96331719e-02f, 4.72577177e-02f, -2.68075496e-01f, 1.24806881e-01f,
  1.80263713e-01f, -1.69337481e-01f, -1.00816078e-01f, 8.51830468e-02f, 5.19302301e-02f, -9.87398475e-02f, 1.64155945e-01f, 9.79233757e-02f, -5.43530174e-02f, 7.15281591e-02f,
  -5.46347443e-03f, 2.61958063e-01f, -2.19939485e-01f, 1.32677570e-01f, -1.14592770e-03f, -8.07889476e-02f, 1.50487244e-01f, -9.85017791e-02f, 1.91073120e-01f, 8.86330083e-02f,
  9.93851274e-02f, 3.97266448e-02f, -6.20006993e-02f, -8.01925287e-02f, 4.70104925e-02f, 1.10519394e-01f, -3.91931692e-03f, -2.74136253e-02f, -2.57998165e-02f, 2.60178912e-02f,
  2.35262439e-02f, -3.36082503e-02f, -4.29135039e-02f, -3.42480391e-02f, -8.79248753e-02f, -2.80595403e-02f, -2.28854604e-02f, 2.39754040e-02f, -2.62546372e-02f, -4.96239290e-02f,
  -2.51319967e-02f, -5.84428608e-02f, 2.11107060e-02f, 2.01523006e-02f, -4.48191240e-02f, 7.89090898e-03f, 6.35410324e-02f, 1.52437470e-03f, 4.82587591e-02f, 6.17296994e-02f,
  5.84497005e-02f, -2.93758716e-02f, 1.08392835e-02f, -3.36172283e-02f, -4.28611152e-02f, 2.05852687e-02f, 3.86408065e-03f, -2.56885327e-02f, -5.80820218e-02f, -1.77980852e-04f,
  8.86254385e-03f, -4.40212898e-02f, 3.12416684e-02f, -2.10199095e-02f, 5.68566732e-02f, 2.47075167e-02f, 5.25054932e-02f, 3.78330760e-02f, -4.24159057e-02f, -4.10385132e-02f,
  1.48462495e-02f, 8.79236776e-03f, 4.98017594e-02f, 2.39628199e-02f, -1.84848998e-02f, -3.02826744e-02f, 1.70959421e-02f, 6.02182234e-03f, -3.33400480e-02f, 7.57597461e-02f,
  1.64786622e-01f, 4.20255996e-02f, 3.52639928e-02f, 2.60424353e-02f, -5.35088666e-02f, 2.69357767e-02f, -1.79922208e-02f, 4.09107935e-03f, -4.77478318e-02f, -1.96596235e-02f,
  6.71098083e-02f, 1.96616016e-02f, 1.29656121e-01f, -4.41241488e-02f, 1.52130704e-02f, 9.55136567e-02f, 2.56384611e-02f, -4.60705347e-02f, 2.22311560e-02f, 6.93054646e-02f,
  -3.47989872e-02f, 4.21907939e-02f, -1.28512597e-02f, -1.91216636e-02f, 1.13165029e-03f, 5.00950739e-02f, -2.41315495e-02f, 7.25785736e-04f, 2.10117288e-02f, -2.17032433e-02f,
  1.25195056e-01f, -1.74500309e-02f, -2.47211270e-02f, 4.59008701e-02f, -4.37164567e-02f, -1.54106006e-01f, -1.02627903e-01f, -3.89749892e-02f, -2.42985785e-01f, -9.89897526e-04f,
  5.17738722e-02f, -1.65947616e-01f, 7.70032704e-02f, -1.63499825e-02f, 1.44595662e-02f, -1.04563190e-02f, 3.52561437e-02f, -1.99441001e-01f, -1.38503537e-01f, 1.78269967e-01f,
  6.92757070e-02f, 1.35041073e-01f, 6.30446821e-02f, 1.75694466e-01f, 4.74897400e-02f, 2.19742239e-01f, 2.57467240e-01f, 6.08122349e-02f, 1.35326847e-01f, -9.19973478e-02f,
  6.69295574e-03f, 1.41062781e-01f, 4.56983224e-02f, -7.80632123e-02f, 8.35508779e-02f, -1.76517962e-04f, 9.55491737e-02f, -8.21749344e-02f, 4.36639898e-02f, 3.32720242e-02f,
  -3.12748291e-02f, 4.97522838e-02f, -2.02357806e-02f, 2.56916992e-02f, 6.11117370e-02f, -6.63423836e-02f, -9.71714407e-02f, -1.68240927e-02f, -1.02884613e-01f, 3.71112786e-02f,
  -9.34215321e-04f, -4.10819016e-02f, -1.13324776e-01f, 1.83213863e-03f, -4.55748364e-02f, 7.23028779e-02f, 2.77699903e-02f, -3.71812657e-02f, -2.31105145e-02f, -2.56756693e-02f,
  9.38969105e-02f, -5.46213165e-02f, -9.75700021e-02f, -4.22651833e-03f, 1.12297863e-01f, -4.82821725e-02f, -5.70039861e-02f, 9.89392772e-03f, 2.07807608e-02f, 5.07493354e-02f,
  7.55380914e-02f, -3.45253735e-03f, -1.28200144e-01f, 4.64066155e-02f, 1.00326248e-01f, -5.07633314e-02f, -7.19464570e-02f, 3.13895084e-02f, -3.94316437e-03f, -8.42233375e-02f,
  -4.73602153e-02f, 9.57962424e-02f, 1.00124940e-01f, -6.85205683e-02f, 1.02669047e-02f, 3.95607501e-02f, -2.07116194e-02f, 1.84947532e-02f, -5.94499558e-02f, -9.72962473e-03f,
  6.47820011e-02f, 2.15534136e-01f, -6.98538050e-02f, 2.27713306e-02f, 5.43164723e-02f, 6.17205203e-02f, -1.02848656e-01f, -1.26053438e-01f, 1.09479129e-02f, 2.66118087e-02f,
  -1.19844461e-02f, -3.80551592e-02f, 7.59566873e-02f, -4.17209193e-02f, -5.36417253e-02f, 3.31533812e-02f, 8.47750381e-02f, 5.68003580e-02f, 2.63848398e-02f, 5.29456772e-02f,
  9.41333026e-02f, -2.47417334e-02f, 1.37238624e-02f, 9.58183315e-03f, 4.58128043e-02f, 2.56987903e-02f, 5.55740595e-02f, 3.64313014e-02f, -3.07486560e-02f, -5.84832579e-02f,
  -7.64843896e-02f, 9.26845595e-02f, -1.43739149e-01f, -7.50892088e-02f, 5.93687817e-02f, -1.47615075e-01f, -1.07121296e-01f, 5.08843502e-03f, 7.96391442e-02f, 1.62770748e-01f,
  -4.44696583e-02f, 6.99696094e-02f, 1.50907770e-01f, -2.09861770e-01f, -2.42224783e-01f, -1.37323484e-01f, -3.25393587e-01f, -2.02106759e-01f, -1.58611014e-01f, -1.08355686e-01f,
  -8.40640664e-02f, -1.30825475e-01f, -1.78693205e-01f, 2.79501583e-02f, 1.06125595e-02f, 8.77511203e-02f, 7.02917250e-03f, 2.40551066e-02f, -1.82028204e-01f, -6.62182793e-02f,
  -8.43612924e-02f, 1.03109591e-01f, -6.42258823e-02f, -5.99755049e-02f, -5.07864691e-02f, -7.89724407e-04f, -6.17904589e-02f, -2.13528425e-02f, -1.43876765e-02f, -8.31989124e-02f,
  -2.14253515e-02f, 4.42053452e-02f, -4.06782725e-04f, 2.80769309e-03f, 6.37067780e-02f, -3.75414337e-03f, -5.12194149e-02f, 6.02734052e-02f, 4.71721292e-02f, -2.83151288e-02f,
  -3.18631753e-02f, 5.62802888e-02f, -4.18495312e-02f, -2.56560091e-02f, -3.32790427e-02f, 1.90562252e-02f, 2.22734082e-03f, -2.51992121e-02f, -9.03179720e-02f, -1.42614022e-02f,
  -6.77321777e-02f, 3.10756676e-02f, -6.61807284e-02f, 1.51892621e-02f, -4.77074906e-02f, 5.15196323e-02f, 3.99412252e-02f, -3.68674658e-02f, -1.81029793e-02f, 7.46307671e-02f,
  -4.24392335e-02f, 1.46953864e-02f, -8.10831115e-02f, -2.77102310e-02f, -7.85593763e-02f, 3.24435718e-02f, -1.21489391e-02f, 3.78835611e-02f, 1.21280560e-02f, -6.83150589e-02f,
  -5.03867976e-02f, -1.84352212e-02f, 7.58970249e-03f, 1.90569442e-02f, -1.22941546e-02f, -1.07176118e-02f, 3.98474969e-02f, 7.34570846e-02f, 5.03690727e-02f, 1.11468099e-02f,
  -6.89422041e-02f, 1.25797763e-01f, 1.03364706e-01f, 6.37634471e-02f, 3.29910740e-02f, 2.12124418e-02f, -3.94034907e-02f, 3.95471090e-03f, 2.52719708e-02f, 2.20913533e-02f,
  3.19258906e-02f, -8.40991503e-04f, -5.28319255e-02f, 3.86415161e-02f, -7.33050331e-02f, -8.07965398e-02f, -7.10550556e-03f, 5.49432598e-02f, 4.13806140e-02f, 2.90992334e-02f,
  6.29150271e-02f, 3.22787203e-02f, -1.91754252e-02f, -7.58577287e-02f, -8.38873088e-02f, 3.01834904e-02f, -1.06363602e-01f, 6.56969547e-02f, -2.51257904e-02f, 6.77348599e-02f,
  -5.16374297e-02f, 3.05167716e-02f, -1.00604799e-02f, 4.07249108e-02f, 5.34137040e-02f, 9.65077803e-02f, 8.57460473e-05f, 5.92353158e-02f, 1.00207046e-01f, 8.94043222e-02f,
  -7.34355440e-03f, 2.15857569e-02f, 1.24290874e-02f, -2.63177361e-02f, 5.24477400e-02f, 3.04476209e-02f, 4.30221185e-02f, 5.61276749e-02f, 5.08388877e-02f, -2.99343113e-02f,
  -3.93368192e-02f, 8.48038569e-02f, -6.40296042e-02f, -1.87846795e-02f, 3.04505974e-02f, 1.12723755e-02f, -6.54874966e-02f, -8.71675014e-02f, 3.62013392e-02f, 3.93104814e-02f,
  1.22457836e-02f, 9.53735411e-02f, -4.85903770e-02f, -4.16958109e-02f, -7.70206898e-02f, 3.17449383e-02f, 6.19102595e-03f, -2.85961479e-02f, 3.62828970e-02f, 4.94826436e-02f,
  6.21166499e-03f, 4.85231020e-02f, 3.00730858e-03f, -4.58075628e-02f, 5.23847751e-02f, 1.01007260e-01f, -7.33642979e-03f, 4.30111885e-02f, 4.32207918e-04f, -3.02989166e-02f,
  -3.40176187e-02f, -6.63069338e-02f, 2.83256676e-02f, -5.80752417e-02f, -1.04825348e-01f, -3.22501063e-02f, 3.04056313e-02f, -2.05207081e-03f, -2.94100307e-02f, -1.85278337e-02f,
  1.45290466e-02f, 5.89781292e-02f, 6.28258009e-03f, -4.72722715e-03f, 4.65213209e-02f, -9.45646241e-02f, 4.93214950e-02f, 5.98266013e-02f, -4.31017019e-02f, 4.74671498e-02f,
  5.99285066e-02f, 6.11988567e-02f, -1.06390435e-02f, 7.39923045e-02f, -5.05922921e-02f, 4.03466634e-02f, 1.29137177e-03f, -7.27191344e-02f, -6.63797632e-02f, -2.68949824e-03f,
  5.20588867e-02f, 2.27664877e-02f, -2.78408378e-02f, 7.55301267e-02f, -9.18332022e-04f, 4.70085405e-02f, 4.91324179e-02f, -2.89388001e-02f, -2.85267644e-02f, -6.37947256e-03f,
  8.25190917e-02f, -2.32726038e-02f, 6.91120028e-02f, -5.43836318e-02f, 3.52670811e-02f, 8.09808224e-02f, 7.15065375e-02f, 3.99016030e-02f, -6.43819049e-02f, -3.00194155e-02f,
  4.57129665e-02f, -2.04924233e-02f, -1.87043604e-02f, 7.42731243e-02f, 5.18286042e-02f, 5.67825995e-02f, -4.44197431e-02f, 8.49278048e-02f, -3.90722118e-02f, 2.28933170e-02f,
  7.30465055e-02f, 1.79919284e-02f, 5.04461722e-03f, 3.78904305e-02f, 4.60762642e-02f, 8.85926839e-03f, -3.04682683e-02f, 4.38504629e-02f, 5.29913493e-02f, 2.24011522e-02f,
  -1.55129105e-01f, 1.57773629e-01f, -9.91848856e-02f, -2.66602244e-02f, 6.28661830e-03f, -6.16894010e-03f, 4.30332385e-02f, 3.40352170e-02f, -1.21580370e-01f, -6.64952919e-02f,
  -1.25631355e-02f, -1.29338190e-01f, -9.24534947e-02f, 5.18070580e-03f, -5.44537492e-02f, -7.12339506e-02f, 5.76660670e-02f, 2.13406002e-03f, -6.15385585e-02f, 1.04997523e-01f,
  9.80893895e-02f, -3.94222587e-02f, -1.06832579e-01f, 6.32014051e-02f, -4.69072685e-02f, 2.44041178e-02f, 4.73903269e-02f, 5.75467758e-02f, 8.90885666e-02f, 3.34404372e-02f,
  3.57125662e-02f, -1.80126846e-01f, -7.58700818e-02f, -1.67325535e-03f, -3.81209515e-02f, -8.87429118e-02f, -8.07786733e-02f, 2.79232711e-02f, -1.49176968e-02f, 7.79582337e-02f,
  3.32805626e-02f, 9.90693048e-02f, -1.47262830e-02f, -7.84236118e-02f, 2.10431963e-02f, -4.67497036e-02f, -7.82124419e-03f, -5.10763340e-02f, -4.48663868e-02f, -6.98517710e-02f,
  1.85088683e-02f, 7.56105594e-03f, -4.40354720e-02f, 4.44113277e-02f, -5.23338607e-03f, 3.21725868e-02f, -1.14428718e-02f, -1.22821322e-02f, 3.10876761e-02f, -2.55304724e-02f,
  -2.45479457e-02f, -6.05231114e-02f, -7.49657193e-05f, -6.87975949e-03f, -2.38200966e-02f, -5.68873808e-02f, 2.41891537e-02f, -2.97463406e-02f, 4.04488109e-03f, 7.84711540e-02f,
  2.59670336e-02f, -4.66842577e-02f, 2.85876431e-02f, 4.09468673e-02f, 6.24890663e-02f, 3.04895844e-02f, -8.22392032e-02f, 6.04058988e-02f, -2.65630540e-02f, 4.75918278e-02f,
  3.49651501e-02f, 6.92948252e-02f, -3.67709808e-02f, 3.89127098e-02f, 8.96868035e-02f, -8.48558992e-02f, -2.36789249e-02f, 2.66832225e-02f, 1.75883761e-03f, -4.27394919e-02f,
  2.62032566e-03f, -1.15065500e-01f, -3.62686813e-02f, -8.08030739e-02f, 4.95928563e-02f, -6.06923066e-02f, 7.36368969e-02f, -4.72719260e-02f, -2.52090190e-02f, -1.23043091e-03f,
  -5.28566614e-02f, -8.20103381e-03f, 2.90689413e-02f, -3.21135931e-02f, -1.69803482e-02f, 1.01126567e-01f, -2.89851800e-02f, 6.57577440e-02f, 5.95181696e-02f, 8.83799270e-02f,
  -4.90858871e-03f, -8.46704319e-02f, -9.65253916e-03f, 3.25447693e-02f, -2.90239416e-02f, 3.18627469e-02f, -2.38647573e-02f, 3.46182077e-03f, 6.68685213e-02f, 9.24731195e-02f,
  -2.32509926e-01f, 1.22247659e-01f, -3.77132222e-02f, 1.62795950e-02f, -6.65425509e-02f, 1.56896234e-01f, 1.26316145e-01f, -3.89551856e-02f, -1.21863885e-02f, 1.58541620e-01f,
  9.57641304e-02f, -9.28452238e-02f, 9.19322949e-03f, 2.07760841e-01f, -3.08435671e-02f, 1.10278644e-01f, 6.27645701e-02f, 8.37388560e-02f, -2.52183825e-02f, -8.73901471e-02f,
  -1.29580393e-01f, -8.98511708e-03f, 8.94429013e-02f, -8.57412592e-02f, -7.07790302e-03f, 1.70458518e-02f, 1.20326281e-02f, -5.97278811e-02f, 4.63718809e-02f, 1.33412499e-02f,
  2.80335601e-02f, -9.06221569e-02f, 3.94047350e-02f, -5.25467880e-02f, -1.06084920e-01f, 2.64447983e-02f, -1.45900948e-03f, -2.63470951e-02f, -7.62226731e-02f, 1.00230277e-02f,
  -6.16048202e-02f, -1.83236729e-02f, -2.43324623e-03f, 1.71388034e-02f, 6.42293990e-02f, 3.45665216e-02f, 3.39147635e-02f, 9.10115689e-02f, -1.37819443e-02f, 2.12546648e-03f,
  1.36480844e-02f, -2.67212698e-03f, 5.26955072e-03f, 5.15871532e-02f, 3.76422070e-02f, 9.27322805e-02f, -3.09677068e-02f, -7.47432560e-02f, 1.65673830e-02f, -1.03838861e-01f,
  -1.03507482e-01f, 2.82408902e-03f, 2.09023152e-02f, -3.36784050e-02f, -6.28550872e-02f, -2.11687982e-02f, 3.98266762e-02f, 3.52111049e-02f, -9.28026661e-02f, 6.00000136e-02f,
  4.49556485e-02f, 7.39747062e-02f, -1.50938714e-02f, 2.88529452e-02f, 1.56873129e-02f, 1.35261640e-02f, 4.29076999e-02f, 5.27872443e-02f, -3.32190096e-02f, -4.35380153e-02f,
  -1.53591838e-02f, -4.27562408e-02f, 1.15716932e-02f, 5.48212370e-03f, 7.06777573e-02f, -3.02950088e-02f, -3.64344455e-02f, 3.43995504e-02f, -1.72142945e-02f, 7.32775703e-02f,
  -1.70875937e-02f, -4.85369228e-02f, -6.91566542e-02f, -1.05695337e-01f, 5.32676578e-02f, -9.35259238e-02f, -4.19784412e-02f, 3.92708890e-02f, -5.30742928e-02f, 3.09683494e-02f,
  -8.17089006e-02f, 1.15962494e-02f, -9.68260411e-03f, 3.65959555e-02f, 6.57111332e-02f, -1.96474772e-02f, 6.73267171e-02f, -4.53307964e-02f, 7.26329386e-02f, 2.31982339e-02f,
  4.80688363e-03f, -6.56948835e-02f, -5.38147986e-02f, -2.05288995e-02f, 2.95425821e-02f, -6.26684516e-04f, -1.14176184e-01f, 4.21309657e-02f, -2.07044464e-02f, 1.53448153e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.08808137e-01f, -5.37269637e-02f, 1.38473555e-01f, 1.16148278e-01f, -4.24955562e-02f, -5.83092719e-02f, 8.98515657e-02f, 3.80040482e-02f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.37921080e-01f, 7.38694370e-02f, 3.24340276e-02f, -8.59452561e-02f, 2.63973236e-01f, 2.62147993e-01f, -7.62124062e-02f, -1.97030697e-02f, 1.38713978e-02f, 3.52868080e-01f,
  -1.30279168e-01f, 1.46068051e-01f, -7.73472786e-02f, 2.79644169e-02f, -8.59130826e-03f, 6.26930520e-02f, 1.94607213e-01f, -1.30574092e-01f, -6.45830482e-02f, -1.38443625e-02f,
  -2.24498242e-01f, -1.40100718e-01f, -4.09612536e-01f, -5.03481589e-02f, -3.61804329e-02f, -3.52495499e-02f, 1.84127823e-01f, 7.51093403e-02f, -1.47642419e-01f, -6.81539178e-02f,
  6.79191649e-02f, 2.26580933e-01f, 7.21609145e-02f, 8.27081949e-02f, 2.68123418e-01f, 1.85628906e-01f, -3.17837745e-01f, 4.81294915e-02f, -9.39588696e-02f, -2.07442701e-01f,
  -8.78247842e-02f, 1.80739298e-01f, -1.76585186e-02f, 4.17775139e-02f, 1.99328829e-02f, -1.66221172e-01f, -3.86563800e-02f, 2.02046439e-01f, -3.34239185e-01f, -3.88675071e-02f,
  -2.14223430e-01f, -3.34888756e-01f, -6.75841123e-02f, -2.53760010e-01f, -9.75938514e-02f, -1.11915231e-01f, -1.87115207e-01f, -5.57415001e-02f, -1.79883525e-01f, 5.26258582e-03f,
  -2.23655194e-01f, -1.09011918e-01f, -3.72807793e-02f, -1.30524799e-01f, -8.84585306e-02f, -4.72632833e-02f, -1.77018717e-01f, -1.25593618e-01f, -9.00329426e-02f, 1.14179544e-01f,
  6.04750775e-02f, -2.35079583e-02f, 1.62665974e-02f, -7.23541752e-02f, 1.19207487e-01f, 1.39081748e-02f, -1.41057998e-01f, 1.98144212e-01f, 1.13213517e-01f, -1.65996864e-01f,
  -3.41377035e-02f, 1.17128760e-01f, -1.37901884e-02f, 1.73449516e-01f, 1.29715696e-01f, 2.63201505e-01f, 2.49321565e-01f, -6.50544837e-03f, -8.36605281e-02f, -6.00751974e-02f,
  -3.78252007e-02f, -1.83551446e-01f, 1.06170788e-01f, -1.42420545e-01f, 1.46917492e-01f, -2.21800238e-01f, -5.65062836e-02f, 1.58048764e-01f, 5.67755215e-02f, 1.08485587e-01f,
  1.28214926e-01f, 1.18313409e-01f, 2.29373991e-01f, 1.84828147e-01f, -5.94180524e-02f, -6.04981109e-02f, -7.19215721e-02f, 1.90414414e-01f, 1.05715394e-01f, -3.07089001e-01f,
  -1.62673667e-01f, -4.94473614e-02f, 1.63338453e-01f, -8.67453441e-02f, 1.61479503e-01f, 8.14138129e-02f, 1.71830311e-01f, -5.32284640e-02f, -9.29154754e-02f, 2.27387428e-01f,
  1.00049987e-01f, 1.51253015e-01f, 5.73835894e-02f, -4.88397293e-02f, -1.52215168e-01f, 1.66013220e-03f, 3.65687683e-02f, 5.23545928e-02f, 2.49609873e-01f, 3.37840974e-01f,
  9.71432775e-02f, 2.46571869e-01f, -2.03086212e-01f, 7.43422806e-02f, -2.43256643e-01f, -1.91838190e-01f, 6.21493943e-02f, 5.31850532e-02f, -1.64157718e-01f, -2.65961438e-01f,
  4.22078893e-02f, -2.16210008e-01f, 4.06758338e-02f, -3.35131995e-02f, -2.82688409e-01f, 1.16694244e-02f, -9.74896774e-02f, -2.67749369e-01f, 1.38608024e-01f, -7.68836960e-02f,
  -2.14961395e-01f, -3.47404093e-01f, 1.50295407e-01f, 5.48091754e-02f, -4.48904663e-01f, -3.13101768e-01f, 7.65484348e-02f, -2.72595380e-02f, 9.38363895e-02f, 1.63034335e-01f,
  -1.41203701e-01f, -4.84534614e-02f, 1.59509070e-02f, -1.94008693e-01f, 5.39218783e-02f, 9.32603702e-02f, 2.52652615e-01f, 1.81824937e-01f, -3.26552577e-02f, 1.60438102e-02f,
  1.16978824e-01f, 9.88817140e-02f, 1.08418897e-01f, -2.55963206e-01f, -1.65688157e-01f, -1.54222939e-02f, 2.66684920e-01f, -1.47970691e-01f, 2.51895338e-01f, -1.78652983e-02f,
  2.45760664e-01f, 1.18041903e-01f, 7.73949176e-02f, 4.17760879e-01f, 6.75063059e-02f, 1.97533350e-02f, -4.48708646e-02f, 1.71965778e-01f, -1.58414766e-01f, 1.16365321e-01f,
  -1.49780333e-01f, -2.35270739e-01f, 1.57295868e-01f, -3.61410141e-01f, -5.73626347e-03f, -1.97379455e-01f, 3.10143398e-04f, 7.31759295e-02f, 1.28215104e-01f, 4.30887379e-02f,
  -1.61757663e-01f, -1.67250991e-01f, -3.30802113e-01f, 1.07885681e-01f, 2.43131444e-01f, -2.21319139e-01f, -2.17599720e-01f, 2.96860665e-01f, 2.64574448e-03f, 8.64976197e-02f,
  1.08715005e-01f, -1.86472625e-01f, -5.03220670e-02f, -1.39860362e-01f, 2.16387898e-01f, 2.90776134e-01f, -7.55670443e-02f, 2.87787169e-01f, -2.23503858e-01f, 4.61567678e-02f,
  -1.35149315e-01f, 8.24080873e-03f, -1.07494794e-01f, -1.21095277e-01f, 4.82774526e-02f, -7.47614130e-02f, -2.49371827e-01f, -5.60124330e-02f, 2.28117421e-01f, 7.31775239e-02f,
  -1.11765161e-01f, 5.01574343e-03f, -1.72921330e-01f, 2.53026456e-01f, -1.05148144e-01f, 1.29103690e-01f, 4.61206622e-02f, 3.46323431e-01f, -2.06801407e-02f, -2.97414511e-01f,
  3.40013057e-02f, -2.20481768e-01f, -2.86929786e-01f, 3.22730929e-01f, -2.75811046e-01f, 3.40773314e-02f, -2.96316087e-01f, 1.15562387e-01f, -1.11220004e-02f, 1.49487436e-01f,
  3.38577330e-01f, 1.38602614e-01f, 1.63416788e-01f, -1.24586653e-03f, 1.62300810e-01f, 8.65039825e-02f, 8.37897509e-02f, -1.30141035e-01f, 3.37789282e-02f, 7.72752762e-02f,
  2.64965370e-03f, -8.64123255e-02f, -6.96757361e-02f, -2.55205929e-02f, -9.32853818e-02f, -1.62568778e-01f, 1.33535832e-01f, -8.42906982e-02f, 1.58695742e-01f, -1.56268924e-01f,
  -1.16112754e-01f, -5.76638915e-02f, 9.36697349e-02f, 3.25669814e-03f, 2.26459317e-02f, -8.20938572e-02f, 5.99483550e-02f, 2.75132954e-02f, 2.05860749e-01f, 1.09998165e-02f,
  -2.08288636e-02f, -1.20464165e-03f, 4.60451422e-03f, -1.28515959e-01f, -1.14738546e-01f, 7.97493756e-02f, -1.65289834e-01f, -2.29133725e-01f, -6.43576607e-02f, -9.46818739e-02f,
  -1.67914867e-01f, -5.80226891e-02f, 9.27156806e-02f, -1.89342201e-01f, -1.20169997e-01f, 1.11824803e-01f, 1.24773324e-01f, 1.81263700e-01f, 1.14857823e-01f, -1.11977318e-02f,
  -7.94881135e-02f, 2.60413051e-01f, 2.57789701e-01f, -1.14938088e-01f, 1.45901382e-01f, 2.39963949e-01f, -9.44632888e-02f, 2.67713368e-01f, -2.22909257e-01f, -9.62761566e-02f,
  2.60964278e-02f, -1.06357731e-01f, 9.52937230e-02f, -5.23520745e-02f, 2.90237278e-01f, 1.16958961e-01f, 1.34121105e-01f, 1.40226886e-01f, 9.04062837e-02f, -2.30405182e-01f,
  4.74854559e-02f, 6.91305250e-02f, 8.85004327e-02f, 1.84293970e-01f, 1.03481784e-01f, 1.80056825e-01f, 1.60809308e-01f, 1.17508019e-03f, 1.53473765e-01f, -1.27871349e-01f,
  2.97825754e-01f, 1.43192530e-01f, -3.65769230e-02f, 5.40321283e-02f, -2.26511247e-03f, 1.85507134e-01f, 1.92281485e-01f, 8.25858712e-02f, 1.91486716e-01f, -1.56350583e-01f,
  6.59073815e-02f, -4.09899577e-02f, 2.49296188e-01f, 1.72156408e-01f, 9.56237763e-02f, 6.19757622e-02f, -2.37856716e-01f, -1.44277558e-01f, 1.70073316e-01f, -9.63512287e-02f,
  2.87190899e-02f, -2.06024602e-01f, -1.36625528e-01f, -2.58363128e-01f, -1.57931194e-01f, -1.14230894e-01f, 1.42513812e-02f, -1.55795395e-01f, 1.71728656e-01f, -3.45894061e-02f,
  2.67712455e-02f, -3.24623138e-02f, 4.58235815e-02f, 1.74528643e-01f, 2.18804792e-01f, 1.00503705e-01f, -6.79859892e-02f, 4.76814620e-02f, 1.56937376e-01f, -1.05559349e-01f,
  7.03941211e-02f, 2.44557932e-01f, 3.59098583e-01f, 3.38988721e-01f, 3.46672922e-01f, 3.04202914e-01f, -1.79824397e-01f, 1.55832976e-01f, -1.05111346e-01f, 5.03669120e-02f,
  4.25115675e-02f, -5.74725419e-02f, -1.06452182e-01f, 5.63956574e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.84994191e-01f, 3.45460117e-01f, 8.99306126e-03f, 4.53468829e-01f, -1.67398438e-01f, 9.29716974e-02f, 3.13743770e-01f, 1.90960646e-01f, 4.78710920e-01f, 1.72414407e-01f,
  2.91055948e-01f, -2.11932972e-01f, -4.18792605e-01f, 2.97700793e-01f, 3.78673553e-01f, -1.64940387e-01f, 3.04074697e-02f, 3.42386067e-01f, -2.96006799e-01f, -2.27742121e-01f,
  1.71426117e-01f, 2.78084219e-01f, 2.52957970e-01f, -4.50138867e-01f, 1.30811125e-01f, -2.83019602e-01f, 1.02153927e-01f, 1.46702275e-01f, 3.92416120e-01f, -1.97996981e-02f,
  1.72397852e-01f, -3.42152342e-02f, 9.17812288e-02f, -4.42256071e-02f, -1.73645467e-01f, 9.12889317e-02f, 2.67489761e-01f, 2.44320437e-01f, 2.55912840e-01f, 1.84104085e-01f,
  2.54293650e-01f, 1.14380524e-01f, 1.76490530e-01f, 6.69646338e-02f, 1.24122754e-01f, 1.59285590e-01f, -1.64139584e-01f, 1.88272167e-02f, 2.17573583e-01f, -2.55722553e-02f,
  1.81098580e-01f, 3.00115943e-01f, -5.98043241e-02f, 2.47778311e-01f, -9.45633203e-02f, 7.13167638e-02f, -1.84403837e-01f, 3.65482450e-01f, 5.87578379e-02f, 2.86109686e-01f,
  1.79149926e-01f, 7.70615833e-03f, -4.56232913e-02f, -5.15787527e-02f, 1.12818047e-01f, 5.76920062e-02f, 1.30792454e-01f, -1.05928555e-01f, -3.05803027e-02f, -7.11615384e-02f,
  -2.34227404e-02f, -1.41859353e-01f, -9.06573012e-02f, 3.67984436e-02f, -2.87402943e-02f, -3.20778117e-02f, -1.15907267e-01f, -1.23832978e-01f, -1.16933562e-01f, -1.33938491e-01f,
  1.56130791e-01f, -1.73640028e-01f, -1.43797785e-01f, 1.11227855e-01f, -4.65455614e-02f, -3.27125303e-02f, 8.37666541e-02f, 1.61777824e-01f, -1.06591702e-01f, -2.91066431e-02f,
  3.02189030e-02f, 1.18157528e-01f, 1.81868106e-01f, 1.15288168e-01f, -5.89879751e-02f, 5.79939969e-02f, -7.99466670e-02f, 7.94628076e-03f, -1.73304409e-01f, -1.29739419e-01f,
  1.08083293e-01f, 1.10560311e-02f, -6.08737133e-02f, 2.67270114e-02f, 1.06922939e-01f, 7.02696592e-02f, -1.07588910e-01f, 8.52649286e-02f, 2.55131721e-02f, 3.58493142e-02f,
  6.53116480e-02f, 1.59693658e-01f, 1.73516542e-01f, 3.26301306e-02f, -2.25216132e-02f, 1.06380194e-01f, -2.29972340e-02f, 2.99870549e-03f, 5.13740033e-02f, 4.42230925e-02f,
  -1.15027830e-01f, 1.85238067e-02f, -1.16669737e-01f, 1.67454649e-02f, -1.24647066e-01f, 1.12401560e-01f, -1.29388720e-02f, -2.21299566e-02f, 1.88030601e-01f, -5.34281395e-02f,
  3.38586196e-02f, 2.89523751e-02f, 3.34155411e-02f, 1.83168188e-01f, 1.82844460e-01f, 1.65802583e-01f, -1.23618254e-02f, 7.14807287e-02f, 1.96357355e-01f, 1.82915986e-01f,
  -1.92720667e-01f, -7.08881542e-02f, 1.90404058e-01f, -1.46574462e-02f, 1.09242141e-01f, -1.28636152e-01f, -6.69008866e-02f, 9.22861099e-02f, -1.40357941e-01f, 1.57459266e-02f,
  1.60044562e-02f, 2.67870426e-02f, 1.42250299e-01f, -1.37886658e-01f, -7.71395862e-02f, -9.48675945e-02f, -2.33019385e-02f, 8.59448537e-02f, 2.62631755e-02f, 1.14271820e-01f,
  2.57249564e-01f, 1.01393200e-01f, 1.94249094e-01f, -2.69769877e-02f, 1.15151666e-01f, 1.87101364e-02f, -1.29936993e-01f, 6.28350005e-02f, 7.73407817e-02f, 1.56135201e-01f,
  -2.02452496e-01f, 2.79891759e-01f, -6.68267580e-03f, -9.22333226e-02f, -1.71550512e-01f, 3.11926961e-01f, 9.57513452e-02f, -5.45312651e-02f, 7.23393708e-02f, -1.82869762e-01f,
  -4.78989869e-01f, -1.26203924e-01f, -4.30841357e-01f, -5.55889606e-02f, 7.66557455e-02f, 3.16107005e-01f, 3.04886937e-01f, 3.03946376e-01f, -1.68700293e-01f, 1.35072947e-01f,
  -1.19438536e-01f, 3.66205201e-02f, 8.81141350e-02f, -2.76056658e-02f, -1.82693124e-01f, -1.06570683e-01f, -1.56392127e-01f, 1.27622068e-01f, -8.86796042e-02f, 1.27833905e-02f,
  1.50141194e-01f, 2.33145710e-02f, -6.69026896e-02f, 8.89642611e-02f, -1.55103520e-01f, 3.76817351e-03f, 1.48488373e-01f, -2.95262206e-02f, -6.95739388e-02f, 1.47521451e-01f,
  -1.24998115e-01f, -3.60658839e-02f, 1.36444852e-01f, 1.97241157e-01f, 2.13769555e-01f, -1.56481918e-02f, 4.43402864e-02f, 8.63628089e-02f, -5.74721694e-02f, -5.14513068e-02f,
  1.93255246e-01f, 3.50139067e-02f, -1.51437894e-01f, 6.44207150e-02f, 5.22555374e-02f, 4.33926508e-02f, 1.64262444e-01f, -1.64163142e-01f, -3.13075073e-02f, 4.45105806e-02f,
  -9.14532542e-02f, -1.52773649e-01f, 6.26863241e-02f, -7.31276199e-02f, 4.04629000e-02f, 4.95698787e-02f, -1.40400052e-01f, 1.31109551e-01f, -2.96074734e-03f, 1.05907835e-01f,
  -1.33177176e-01f, -1.10348128e-01f, -1.02390654e-01f, -4.95303683e-02f, -2.49495474e-03f, 3.58557664e-02f, -1.52888238e-01f, -8.26655477e-02f, -5.87499551e-02f, -3.88162653e-03f,
  1.15268834e-01f, 1.43978611e-01f, -1.55451313e-01f, 5.91768278e-03f, 1.04096949e-01f, -1.48303568e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  3.28781694e-01f, 2.30098158e-01f, -1.24602266e-01f, -1.11492813e-01f, -1.26428567e-02f, 1.69271782e-01f, -1.42778516e-01f, 1.79216564e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -5.38485609e-02f, 3.63800302e-02f, -6.92423433e-02f, -5.87368272e-02f, -6.23561740e-02f, 4.02211072e-03f, 1.50391012e-01f, 1.12828963e-01f, 2.09941138e-02f, -1.81809422e-02f,
  1.32468328e-01f, -1.48145080e-01f, 1.13380319e-02f, 5.29302321e-02f, -2.02198662e-02f, -3.28728976e-03f, 1.39282584e-01f, -6.98022842e-02f, -6.84534460e-02f, -4.68685478e-02f,
  -1.71135277e-01f, -2.64575869e-01f, -8.65553692e-03f, -1.01112455e-01f, -3.35272327e-02f, -2.54558921e-01f, -8.54048431e-02f, -8.34212601e-02f, 1.11141227e-01f, 1.29785493e-01f,
  -1.92204490e-01f, 4.74529527e-02f, 1.09943949e-01f, 3.34805287e-02f, 7.26765171e-02f, -3.80638205e-02f, -1.26856044e-01f, 6.69326261e-02f, 3.94426696e-02f, -2.78208017e-01f,
  -1.45434380e-01f, -1.72080889e-01f, -2.57395804e-01f, -1.83433384e-01f, -2.96506703e-01f, -3.11937094e-01f, 2.28240058e-01f, -1.59102529e-01f, -3.32979590e-01f, 7.29812160e-02f,
  -2.90245026e-01f, -1.85488522e-01f, -2.83140335e-02f, 1.19891509e-01f, -3.97168547e-02f, -8.76001492e-02f, 3.51919323e-01f, 3.02224583e-03f, -3.59503552e-02f, 1.05605431e-01f,
  -1.32098004e-01f, -2.64559895e-01f, 2.33162314e-01f, -2.05752719e-02f, -1.21580951e-01f, 1.92652255e-01f, -1.28106773e-01f, 1.58238769e-01f, 3.10634039e-02f, 1.17163830e-01f,
  1.45854563e-01f, 1.58144787e-01f, -1.09626893e-02f, 1.09738119e-01f, 2.32455418e-01f, -1.58871174e-01f, 3.19887787e-01f, -1.77577779e-01f, -2.60982513e-01f, 1.61364749e-01f,
  -2.79557943e-01f, 2.31350824e-01f, -1.23101003e-01f, 4.93102133e-01f, -1.70186475e-01f, -1.55766010e-01f, -1.21086583e-01f, 4.06692438e-02f, -2.91290760e-01f, -3.99021059e-03f,
  -2.49409508e-02f, -1.06718376e-01f, 7.87100047e-02f, 3.39580208e-01f, -8.69566202e-02f, 7.98919648e-02f, -1.18451670e-01f, 3.55933653e-03f, 5.74148707e-02f, -7.14795142e-02f,
  -1.51922092e-01f, 8.78512487e-02f, -3.50966394e-01f, -2.45427489e-01f, 3.38242948e-02f, -1.52324304e-01f, 1.05487786e-01f, -1.68843642e-01f, 3.35931808e-01f, -2.40135565e-01f,
  -9.88328680e-02f, 4.57694456e-02f, -3.70770335e-01f, -5.38355578e-03f, -6.46272441e-03f, 1.96018189e-01f, -1.44681960e-01f, 3.35727781e-01f, 9.26176012e-02f, -6.18416257e-02f,
  -2.79844105e-01f, 3.11549932e-01f, -1.39892325e-01f, 1.89588770e-01f, 1.19510755e-01f, 1.35275170e-01f, 4.29611932e-03f, 5.06753698e-02f, 2.19682693e-01f, 7.82312229e-02f,
  1.35007218e-01f, -6.00024126e-02f, -2.32033692e-02f, -1.51115686e-01f, -2.96954006e-01f, 6.31137341e-02f, -9.17686373e-02f, -2.05539033e-01f, -1.53571069e-01f, -6.75057173e-02f,
  -1.99452698e-01f, -1.82439148e-01f, 8.86663795e-02f, 1.34507939e-01f, -3.41838717e-01f, 2.57858932e-01f, 1.26657501e-01f, -6.98527321e-02f, -4.14034002e-04f, -1.86311617e-01f,
  1.90916002e-01f, 3.69320452e-01f, -2.58169957e-02f, 6.18585013e-02f, 8.41089785e-02f, 8.88293386e-02f, -1.19713224e-01f, -2.38127381e-01f, 1.25268206e-01f, -1.07080415e-01f,
  -7.08584115e-02f, 1.60429627e-01f, -1.39519712e-02f, 1.88469604e-01f, -1.02971308e-01f, -5.28376326e-02f, 1.11377835e-02f, -2.09048569e-01f, 1.05051666e-01f, -9.49692279e-02f,
  1.86959654e-01f, -1.55274227e-01f, 2.20828429e-01f, 8.02161917e-03f, -1.13937464e-02f, -5.11183105e-02f, -2.92476833e-01f, -1.53444573e-01f, 5.76063730e-02f, 2.71520078e-01f,
  -9.29153245e-03f, 2.68593997e-01f, 9.95548591e-02f, 3.41036730e-02f, -2.18178019e-01f, 3.32131505e-01f, 1.13790564e-01f, 1.67955980e-01f, -7.49729201e-02f, 1.95858866e-01f,
  -2.83209030e-02f, -2.84767654e-02f, 2.10941792e-01f, -1.29017964e-01f, 4.49429862e-02f, 4.27266379e-04f, 8.06582198e-02f, 2.07629308e-01f, -7.70578235e-02f, 5.48980618e-03f,
  -2.13337764e-02f, 1.65802151e-01f, 2.31622189e-01f, -1.09703511e-01f, 1.82382196e-01f, -1.24803437e-02f, 3.80138643e-02f, 2.80101240e-01f, -2.11879000e-01f, 9.03589576e-02f,
  1.46466956e-01f, 5.16834334e-02f, -1.72380619e-02f, -1.51234627e-01f, 7.36060590e-02f, 1.68136153e-02f, -2.38725290e-01f, -6.48192763e-02f, -3.55735011e-02f, 4.23720926e-02f,
  -4.39302996e-02f, -1.49756119e-01f, -1.21583663e-01f, 9.79973599e-02f, -1.23737328e-01f, 1.56587794e-01f, -2.83896595e-01f, 4.63374555e-02f, -6.86686635e-02f, -4.56663445e-02f,
  -1.82115063e-01f, 5.30680791e-02f, -1.65964097e-01f, 1.85774252e-01f, -3.40438597e-02f, -1.62019596e-01f, 1.53929785e-01f, 3.31381522e-02f, -2.46200517e-01f, 1.54323563e-01f,
  -1.04878128e-01f, 1.05747692e-01f, 5.56461699e-02f, 3.73073488e-01f, -8.18188116e-02f, -1.88136622e-01f, -2.41838813e-01f, -1.96688026e-01f, -4.25991684e-01f, 1.46137148e-01f,
  -4.76521142e-02f, 7.92749077e-02f, 2.32673697e-02f, 4.59126383e-01f, -2.39650920e-01f, 1.88642457e-01f, 1.47495568e-01f, -1.23713590e-01f, -6.78061172e-02f, 1.87421590e-01f,
  -6.99656010e-02f, 1.30709767e-01f, -1.24929398e-02f, 2.08087608e-01f, 2.44315520e-01f, 2.61796713e-01f, -1.87622048e-02f, -4.15674523e-02f, 1.38626061e-02f, 1.01474591e-01f,
  -5.17595001e-03f, 2.70229667e-01f, 2.08030641e-01f, 1.61674187e-01f, 1.54726446e-01f, -3.71884227e-01f, 2.40742624e-01f, -3.16910744e-01f, 1.63447469e-01f, -7.31433835e-03f,
  -5.93219474e-02f, 1.02922752e-01f, -1.57778170e-02f, -1.53384939e-01f, 7.78501481e-02f, -9.41608399e-02f, -1.90500990e-02f, 3.06429174e-02f, -1.45295367e-01f, 8.29939991e-02f,
  -7.14596640e-03f, 1.76972784e-02f, -2.10744381e-01f, 8.21095109e-02f, -2.95911461e-01f, -1.23989731e-01f, 1.24368966e-01f, -8.32227170e-02f, -1.05790710e-02f, -1.21994652e-01f,
  2.67171770e-01f, -2.26061299e-01f, 5.10944091e-02f, -4.89524081e-02f, -3.70759189e-01f, 1.36633694e-01f, -2.01172438e-02f, 3.26790303e-01f, -5.36868349e-02f, 2.18423203e-01f,
  -1.09212607e-01f, 8.55867267e-02f, -1.10411778e-01f, 2.97959864e-01f, 1.52577847e-01f, 1.25147989e-02f, 1.24846041e-01f, 1.71845555e-01f, -1.51355132e-01f, 1.21478677e-01f,
  -7.47340247e-02f, -1.16207160e-01f, -1.69614181e-02f, -1.06783919e-02f, 8.88401195e-02f, 1.51974872e-01f, 1.22469999e-01f, 2.76952684e-01f, 1.89636663e-01f, -7.17437118e-02f,
  3.31128053e-02f, 9.21604559e-02f, -2.13598117e-01f, 3.45297039e-01f, -1.99377462e-01f, -2.10468113e-01f, 4.34257269e-01f, -1.44812927e-01f, 2.29137018e-03f, -3.88922304e-01f,
  -2.58970708e-02f, -1.70709372e-01f, 1.57274276e-01f, -3.60631317e-01f, -1.33791445e-02f, -3.14655095e-01f, -7.27654546e-02f, -1.82566345e-02f, 1.67229753e-02f, 7.94579387e-02f,
  1.42306313e-01f, 1.42350927e-01f, -1.47738770e-01f, 1.65369302e-01f, -1.21738650e-02f, -1.30311415e-01f, -4.58181351e-02f, -6.08179383e-02f, -2.44379848e-01f, -6.07797168e-02f,
  -8.59115869e-02f, 1.79305434e-01f, -1.42688692e-01f, -1.29748926e-01f, 2.79843599e-01f, 2.87334442e-01f, -3.86160761e-01f, 8.56243446e-02f, 4.81716543e-02f, -1.91867836e-02f,
  2.07614407e-01f, 9.75262672e-02f, -7.98022076e-02f, -9.81063396e-02f, -2.70408928e-01f, -2.52602190e-01f, -4.03319567e-01f, -7.06435356e-04f, -2.24679876e-02f, 2.66133789e-02f,
  -2.08222508e-01f, 4.43722516e-01f, 2.60990579e-02f, 5.47615811e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  5.57816774e-02f, -3.04886904e-02f, 1.71205908e-01f, 1.52640671e-01f, 1.23059571e-01f, -4.67837453e-02f, 1.90820932e-01f, 1.39048800e-01f, 1.83179170e-01f, -4.84339111e-02f,
  1.47236779e-03f, 1.05371200e-01f, 1.22055240e-01f, 1.84400141e-01f, 6.44731596e-02f, -3.66071686e-02f, 1.84487984e-01f, -1.50922015e-01f, -2.78926343e-01f, 1.34161732e-03f,
  -2.51234889e-01f, 2.53198147e-01f, 1.54291108e-01f, -5.46401329e-02f, 5.98191857e-01f, -1.39449075e-01f, 1.01867877e-01f, -1.38110518e-01f, 1.90594837e-01f, 1.99046448e-01f,
  -1.11798853e-01f, 1.30987331e-01f, 3.99031132e-01f, 3.22222233e-01f, 8.54430050e-02f, 1.19898230e-01f, 2.22845957e-01f, -3.25920843e-02f, -5.37411831e-02f, 2.46608168e-01f,
  3.29196781e-01f, 1.42539591e-01f, -3.28418911e-02f, 1.61656156e-01f, -1.37650594e-02f, -1.33005872e-01f, -5.49578108e-02f, 2.89156288e-01f, -2.21152455e-01f, 4.49360013e-01f,
  4.74295050e-01f, -1.11658782e-01f, 9.41476151e-02f, -1.22652844e-01f, 2.83456057e-01f, 3.76306742e-01f, -3.57281297e-01f, 3.02758932e-01f, 1.58048838e-01f, -6.82360157e-02f,
  3.01388130e-02f, 5.51807284e-02f, -1.94353983e-01f, 8.63639340e-02f, 6.17356785e-02f, 5.38221793e-03f, -1.24668799e-01f, -1.42140478e-01f, -1.63348079e-01f, 3.46205831e-02f,
  1.48223311e-01f, -1.39745146e-01f, -1.07291110e-01f, -7.86791816e-02f, -1.72267139e-01f, -1.27098784e-01f, -1.76956102e-01f, -1.49752751e-01f, -1.17644362e-01f, 5.04401289e-02f,
  -1.65960230e-02f, 1.41280219e-01f, -4.04938646e-02f, -1.19499527e-01f, 1.82172284e-01f, -6.76395372e-03f, 1.31679863e-01f, 3.41825075e-02f, 4.16225009e-02f, -9.72949192e-02f,
  1.46258146e-01f, 7.57259224e-03f, -9.51073617e-02f, -3.97179201e-02f, -1.03162229e-02f, 1.19480111e-01f, 1.04592398e-01f, 1.93194538e-01f, 1.67100299e-02f, -9.85423252e-02f,
  -2.34748293e-02f, 4.66600135e-02f, -3.34636196e-02f, 1.03533238e-01f, -1.04397647e-01f, -4.97087799e-02f, -7.94602092e-03f, -5.94776496e-02f, 1.12947069e-01f, -1.46038398e-01f,
  9.29097980e-02f, 1.07378833e-01f, 1.21694684e-01f, -6.84971316e-03f, -1.64346159e-01f, 3.42317484e-02f, -4.71062995e-02f, 2.00145110e-01f, -2.31185425e-02f, -2.21342549e-01f,
  2.39558756e-01f, 3.37816239e-03f, 8.80114548e-03f, 5.21273725e-02f, -1.25959530e-01f, 1.73737511e-01f, -1.66962445e-01f, -6.45311847e-02f, 8.97953138e-02f, 5.93012087e-02f,
  3.70388776e-02f, 1.67428002e-01f, 8.73927474e-02f, 1.70329779e-01f, -9.58667472e-02f, -9.50010493e-02f, 2.25035846e-01f, 2.07291543e-01f, 9.06307772e-02f, 9.46156960e-03f,
  -4.80066091e-02f, -2.50743210e-01f, 7.79189467e-02f, 5.16044684e-02f, -4.27568138e-01f, 2.48461246e-01f, 7.08930660e-03f, 2.32995689e-01f, 1.24392703e-01f, 1.82688504e-01f,
  -1.17877088e-01f, 2.02677310e-01f, -1.13769621e-01f, 2.23590747e-01f, 1.64178044e-01f, -1.06028996e-01f, -1.02043070e-01f, -5.70912212e-02f, 1.36707067e-01f, 1.08359598e-01f,
  2.50101149e-01f, 2.49132350e-01f, 1.84072077e-01f, 7.40813166e-02f, 1.05722122e-01f, 3.12588960e-01f, 2.23171674e-02f, -3.41757759e-02f, 2.71233588e-01f, 3.36642653e-01f,
  -1.20964333e-01f, 1.15531750e-01f, 7.77227059e-02f, -2.49809802e-01f, -9.66849476e-02f, 3.39404255e-01f, -3.95700306e-01f, 2.99490988e-01f, 3.04185301e-01f, -1.13366090e-01f,
  -4.23953794e-02f, -1.15874007e-01f, 3.17379951e-01f, 4.37050074e-01f, -1.75833315e-01f, 3.55402797e-01f, 3.78568955e-02f, 1.53772011e-01f, 1.26452655e-01f, 1.86235353e-01f,
  -1.66757375e-01f, -1.47434846e-01f, 2.28445247e-01f, -7.36368522e-02f, 2.56630406e-02f, -2.88419314e-02f, -3.33956927e-02f, 1.38552830e-01f, 8.82841349e-02f, 1.69716001e-01f,
  1.60448879e-01f, 6.75195530e-02f, 9.12548229e-02f, 1.07867690e-02f, 1.75718740e-01f, -3.33909482e-01f, -3.58060226e-02f, -1.37317115e-02f, -1.96632072e-01f, -1.05619408e-01f,
  -4.47762311e-01f, 2.28559896e-01f, -7.69499764e-02f, 3.16631109e-01f, 9.28509906e-02f, -1.85153499e-01f, 6.43703222e-01f, 2.31613323e-01f, 4.98609990e-02f, -3.02664675e-02f,
  3.10374767e-01f, -7.32032284e-02f, -1.35726333e-01f, 1.38314232e-01f, 6.97939172e-02f, 1.98944405e-01f, 1.78927466e-01f, 1.95920631e-01f, 2.93253688e-03f, 9.71777886e-02f,
  2.78944701e-01f, -1.94158461e-02f, 1.70423269e-01f, 1.29064217e-01f, 9.37588662e-02f, -6.12451620e-02f, -2.19445840e-01f, 2.64138609e-01f, -2.13934258e-01f, -2.16162533e-01f,
  1.04984902e-01f, -3.14942867e-01f, 2.61327494e-02f, -1.89331934e-01f, 9.02075917e-02f, -1.35632530e-01f, -7.37626180e-02f, -1.44381925e-01f, 2.75223404e-01f, -8.16017240e-02f,
  -1.80281803e-01f, 9.50883105e-02f, 1.29462212e-01f, 9.40004289e-02f, 1.66544855e-01f, -9.29895267e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  2.76804268e-01f, 2.67177403e-01f, 7.54454732e-02f, -1.23281248e-01f, 2.20895335e-01f, 2.15640739e-01f, 1.25595212e-01f, -3.99488509e-02f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -1.81612208e-01f, 4.83842343e-02f, -6.87304661e-02f, -2.39008129e-01f, -1.29072815e-01f, 1.08782984e-01f, -1.59848243e-01f, -9.46724638e-02f, -2.20907852e-01f, -1.40207052e-01f,
  -1.77333340e-01f, 1.37746245e-01f, -4.10278823e-04f, -1.13052696e-01f, -1.39228866e-01f, -2.83006251e-01f, 3.01594496e-01f, -3.17311764e-01f, -1.66463733e-01f, -7.14996271e-03f,
  2.18545437e-01f, -3.48395288e-01f, 2.86954463e-01f, -1.96235739e-02f, 3.44406925e-02f, 2.58693218e-01f, 8.72386518e-05f, -1.57053068e-01f, -2.26359099e-01f, -2.17453122e-01f,
  -2.56118745e-01f, 2.27214724e-01f, -1.77168716e-02f, 3.40237804e-02f, 2.01758176e-01f, -2.41017923e-01f, 1.91425622e-01f, -1.85272992e-01f, 8.39532614e-02f, 1.74274355e-01f,
  -1.05692215e-01f, 3.39272320e-02f, 3.51458378e-02f, 2.11657569e-01f, -1.33245692e-01f, -1.14192054e-01f, -5.39356284e-02f, -4.72619236e-02f, 3.81796509e-01f, -1.75932467e-01f,
  -2.75966525e-02f, -1.66254610e-01f, 2.35333309e-01f, -7.58506879e-02f, 2.02781811e-01f, -1.41266277e-02f, -1.53526172e-01f, 4.01402712e-01f, -5.95509224e-02f, 1.36795547e-02f,
  -5.42777218e-02f, 2.70839870e-01f, -3.35124254e-01f, 1.68644473e-01f, 6.72019944e-02f, 4.57177423e-02f, 1.76885590e-01f, 3.57919261e-02f, 2.75506049e-01f, -1.38012871e-01f,
  -1.37852192e-01f, -2.39819944e-01f, -2.20301226e-01f, -1.51593104e-01f, -8.16435590e-02f, -3.25588554e-01f, -9.35882032e-02f, 4.16051269e-01f, -2.86075115e-01f, -1.15871012e-01f,
  1.83830664e-01f, -1.71562865e-01f, -2.67896265e-01f, -3.90819311e-01f, -1.98699683e-01f, 1.91228196e-01f, -2.26057142e-01f, -3.87879491e-01f, -2.31420789e-02f, -2.28959888e-01f,
  5.83645515e-03f, 7.50228316e-02f, -1.07148968e-01f, -1.82711527e-01f, 1.95363745e-01f, -1.49746701e-01f, -8.95303190e-02f, 1.75438315e-01f, -2.73267806e-01f, -3.06246787e-01f,
  -4.71928753e-02f, 4.44977507e-02f, 1.26271009e-01f, -3.48116487e-01f, 9.60645676e-02f, -4.71762381e-02f, -1.45281821e-01f, -1.98357701e-01f, -2.08944343e-02f, 2.89633274e-01f,
  -2.01844394e-01f, -1.57447472e-01f, 1.02160862e-02f, -6.43873028e-03f, -3.21422011e-01f, -7.48252422e-02f, -1.21726461e-01f, -2.75203973e-01f, 2.50289977e-01f, -1.69891953e-01f,
  5.33422343e-02f, -2.89895207e-01f, -1.06484152e-01f, -1.28775500e-02f, -2.65378863e-01f, -9.03089121e-02f, -1.26120418e-01f, 2.32398689e-01f, -1.41974688e-01f, 2.73386627e-01f,
  1.03644252e-01f, 7.94550404e-02f, -1.82849821e-02f, -1.69583276e-01f, -2.66526222e-01f, -2.99801677e-01f, -2.82544438e-02f, 9.35556740e-02f, 7.00612515e-02f, -1.97335958e-01f,
  -1.65991366e-01f, 3.65399927e-01f, -2.24699870e-01f, 1.39395401e-01f, -9.41627100e-02f, 1.10108569e-01f, -3.05603892e-01f, -4.85252142e-01f, -3.16650793e-02f, 5.69059961e-02f,
  -8.22775885e-02f, -5.01044571e-01f, 1.58016950e-01f, -1.27556249e-01f, 1.89308524e-01f, 1.56010956e-01f, 7.26076365e-02f, -2.65320450e-01f, 2.53516644e-01f, -1.21077299e-02f,
  2.35046968e-01f, -1.40900731e-01f, 1.37095332e-01f, -1.07884720e-01f, -9.87671241e-02f, 4.51498739e-02f, -1.81519724e-02f, 1.88901037e-01f, -2.58146785e-02f, 6.06674477e-02f,
  1.76333770e-01f, 5.59302829e-02f, 6.09223731e-02f, -2.06957400e-01f, 1.01391934e-01f, -2.89085388e-01f, -3.00596833e-01f, -3.62691879e-01f, -6.77433833e-02f, 1.34388819e-01f,
  2.36262411e-01f, -4.00260806e-01f, 5.76149404e-01f, 2.52273679e-01f, 1.46934018e-01f, 5.86713254e-02f, 1.23104919e-02f, 6.78965775e-03f, -2.27089912e-01f, -1.93124980e-01f,
  -5.09695224e-02f, 2.24320963e-01f, 3.75521332e-02f, -4.97216061e-02f, 3.42971921e-01f, 1.21406339e-01f, -4.04340066e-02f, 1.37154594e-01f, 1.81846380e-01f, 2.28670090e-01f,
  -1.15451552e-01f, 1.39029890e-01f, 1.37864470e-01f, 2.03395769e-01f, 2.10236192e-01f, 7.37954527e-02f, -5.30953743e-02f, -2.04664782e-01f, -2.69813001e-01f, 1.45341987e-02f,
  1.15469046e-01f, -3.47018689e-01f, -7.61146247e-02f, -1.79561496e-01f, 3.03918481e-01f, -1.77993312e-01f, 6.29730672e-02f, -1.71122149e-01f, -5.98379858e-02f, -2.29727775e-02f,
  -2.14047506e-01f, -1.20068312e-01f, 2.43944585e-01f, 9.10895765e-02f, -2.05153838e-01f, -2.01966271e-01f, 1.80815589e-02f, -2.23682478e-01f, 1.97210148e-01f, -2.08929941e-01f,
  8.84711221e-02f, 1.52187079e-01f, -1.44396707e-01f, -1.95948668e-02f, -3.10312986e-01f, -3.92575562e-02f, 1.00213727e-02f, -2.42178351e-01f, 3.46452028e-01f, 2.72700906e-01f,
  1.83334369e-02f, 8.72251689e-02f, 1.97342366e-01f, 8.05435106e-02f, 6.53426573e-02f, 2.99034595e-01f, -2.02921972e-01f, 1.48324836e-02f, -2.49754056e-01f, 3.22573185e-01f,
  -3.66270430e-02f, -2.14731529e-01f, 1.34398565e-01f, 1.90144405e-01f, -1.76478878e-01f, -6.84612319e-02f, -2.76310034e-02f, -3.64461802e-02f, -2.06400126e-01f, 3.51102836e-03f,
  -1.38962165e-01f, -7.59126469e-02f, -3.51585075e-02f, -3.16066951e-01f, 9.16956812e-02f, -1.42840564e-01f, 3.59030440e-02f, -7.06432313e-02f, -1.83870584e-01f, -6.24922663e-02f,
  -5.23704141e-02f, 2.15561613e-01f, -3.00373048e-01f, 1.11614108e-01f, -2.68308908e-01f, 2.03959450e-01f, -3.76178205e-01f, 1.73689708e-01f, 1.72204927e-01f, 3.24222654e-01f,
  1.73989385e-01f, -2.98910588e-01f, -4.70063388e-02f, 1.83206514e-01f, -2.07167417e-01f, -1.93384245e-01f, 1.49396971e-01f, 1.75565764e-01f, -1.32255303e-03f, 2.41297826e-01f,
  -6.84209988e-02f, -7.72778541e-02f, 1.57156676e-01f, 5.50243556e-02f, -5.19088022e-02f, -1.56713337e-01f, 2.77393172e-03f, 2.15352923e-01f, -1.73409551e-01f, -2.19801322e-01f,
  6.01649284e-02f, 2.33054712e-01f, -3.69799793e-01f, -1.91435382e-01f, -1.70526803e-01f, -6.84961155e-02f, -2.08742663e-01f, -3.78020525e-01f, 8.78170431e-02f, -3.06368232e-01f,
  8.08352828e-02f, -3.96374524e-01f, 1.64510772e-01f, -2.49969393e-01f, 5.81540652e-02f, -3.42348628e-02f, -1.29148528e-01f, -2.62381405e-01f, 2.15760484e-01f, 1.22110583e-02f,
  2.78171524e-02f, -1.87551007e-01f, -1.40755266e-01f, 5.17671518e-02f, 7.90738463e-02f, 5.23218624e-02f, -1.81505695e-01f, -8.62744153e-02f, 1.70080066e-02f, -9.44998488e-02f,
  1.15617350e-01f, -2.32632309e-01f, -1.37852788e-01f, 5.92243969e-02f, 3.10236692e-01f, 4.22017008e-01f, -1.09235436e-01f, 2.78098345e-01f, 1.42522335e-01f, 1.05477147e-01f,
  -3.34714025e-01f, 5.23846805e-01f, -4.10250127e-01f, 1.44599378e-01f, -2.03681141e-01f, 1.54100567e-01f, -1.76291034e-01f, 1.15957811e-01f, 7.96559155e-02f, 1.58189237e-01f,
  7.76937604e-02f, -1.55782416e-01f, -1.84047118e-01f, -1.48804992e-01f, 2.46462628e-01f, 1.04533695e-01f, 2.75244862e-01f, -1.07097505e-02f, -6.77484944e-02f, 1.70917377e-01f,
  8.92233327e-02f, 1.01486549e-01f, -1.54341698e-01f, -4.10502627e-02f, -1.12417236e-01f, -6.74623251e-02f, 1.92235336e-01f, 2.33712137e-01f, 3.65122706e-01f, -2.97441278e-02f,
  4.93731350e-02f, -1.86262935e-01f, -6.45254403e-02f, -5.84343635e-03f, -2.94797838e-01f, -2.41499797e-01f, -3.03377301e-01f, 3.98782939e-01f, 9.56081226e-02f, 7.62939528e-02f,
  2.62653023e-01f, 2.57049531e-01f, 1.44126773e-01f, -1.65743902e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  1.24982834e-01f, 6.40445650e-02f, 4.76009071e-01f, 4.75168735e-01f, 3.30736607e-01f, 3.85417789e-01f, -3.20173167e-02f, 3.79949063e-01f, -1.69099152e-01f, 4.43733305e-01f,
  3.55457336e-01f, 2.03152839e-02f, -1.04408443e-01f, 6.71912953e-02f, 1.13962717e-01f, -2.70842910e-01f, 4.56647635e-01f, -1.16265945e-01f, 5.08891512e-03f, -4.81077552e-01f,
  2.13515610e-01f, -8.21082145e-02f, 1.55123938e-02f, -5.18702447e-01f, 1.53738514e-01f, 2.91225165e-01f, -8.08572173e-02f, 6.77837506e-02f, -5.74775115e-02f, 4.01262790e-01f,
  2.77532130e-01f, -1.28616199e-01f, 1.46751732e-01f, -7.25217462e-02f, -1.76826671e-01f, 1.78383514e-01f, -3.64840478e-01f, 2.25022182e-01f, 2.26525873e-01f, -1.32390708e-01f,
  7.93069229e-02f, 1.44742683e-01f, 2.53452986e-01f, 1.73138633e-01f, 2.49955446e-01f, -3.62936854e-02f, -1.97577268e-01f, -6.49546906e-02f, -1.23504184e-01f, -1.32797778e-01f,
  -1.77263901e-01f, 1.39822677e-01f, -7.51669854e-02f, -1.69832066e-01f, 3.21673639e-02f, 1.34920537e-01f, 3.53941381e-01f, -4.13324237e-01f, -1.87065676e-01f, 1.46909609e-01f,
  -2.62360364e-01f, -4.01137859e-01f, 3.07035565e-01f, 2.54333794e-01f, 2.18681321e-01f, 2.96300411e-01f, 2.19995216e-01f, -1.93263292e-02f, 2.23032340e-01f, -2.41914019e-02f,
  1.85104698e-01f, -1.52729541e-01f, -3.84752490e-02f, 1.37309609e-02f, 2.37661317e-01f, -1.88229933e-01f, -1.69562861e-01f, 3.90842527e-01f, -3.73073727e-01f, 1.72527701e-01f,
  -3.42894673e-01f, -3.57457809e-02f, -1.95944682e-01f, -2.37117007e-01f, -2.92722732e-01f, 1.83192298e-01f, 1.95121728e-02f, -1.75718695e-01f, 3.88786256e-01f, -3.53359312e-01f,
  6.28889576e-02f, 8.67717937e-02f, 1.07384197e-01f, -3.07289600e-01f, 5.91344774e-01f, 1.25606850e-01f, 1.28470324e-02f, -2.35476479e-01f, -1.07606299e-01f, 2.26265654e-01f,
  -3.85143533e-02f, -2.04806048e-02f, 2.08825693e-01f, -1.02685168e-01f, -3.79780345e-02f, 1.02289826e-01f, -7.41887316e-02f, 1.97013989e-01f, 1.39908925e-01f, -2.23059773e-01f,
  4.50124592e-02f, 2.69950956e-01f, -1.57987028e-01f, 2.28448182e-01f, -9.67758670e-02f, 5.20143151e-01f, 2.21716970e-01f, 2.37092033e-01f, 1.00935929e-01f, 5.08467019e-01f,
  -3.04549076e-02f, 4.01266307e-01f, -1.78637594e-01f, 1.77016065e-01f, -3.64919715e-02f, 4.59510475e-01f, -1.59385428e-01f, -1.22073337e-01f, 1.58438444e-01f, -3.26778628e-02f,
  -3.88938971e-02f, 2.25738034e-01f, -2.85722852e-01f, 2.09509671e-01f, 9.59166139e-02f, 2.56925106e-01f, 9.17883813e-02f, 7.14969169e-03f, -1.57815088e-02f, 2.40290135e-01f,
  2.94058442e-01f, -3.51851165e-01f, 3.96777540e-01f, -2.84959655e-02f, -4.12439883e-01f, 1.45053685e-01f, -1.21351287e-01f, 1.14362575e-01f, -7.25173131e-02f, -9.21764225e-02f,
  1.91070810e-01f, 1.90482080e-01f, 1.97446108e-01f, -1.77068874e-01f, -2.21300036e-01f, 3.34377699e-02f, 4.65055741e-02f, -4.76246849e-02f, 2.23467216e-01f, 2.59718388e-01f,
  3.57344970e-02f, -3.75100560e-02f, -1.39126271e-01f, 1.08866908e-01f, 2.27215052e-01f, -1.10994875e-01f, 2.17485070e-01f, -1.81941181e-01f, 1.39693961e-01f, -1.29040942e-01f,
  2.08441019e-01f, -1.44954279e-01f, -1.17989115e-01f, 1.64118171e-01f, 1.13174915e-01f, -9.48813409e-02f, 1.74649909e-01f, -1.07620277e-01f, -5.57397604e-02f, -2.75352057e-02f,
  -5.14961705e-02f, 9.89034399e-02f, -3.19401741e-01f, -8.14075675e-03f, 1.06681213e-01f, 6.57900572e-02f, -7.89860487e-02f, -1.13437697e-01f, 3.29691947e-01f, 2.93331623e-01f,
  2.69282311e-01f, -8.38177428e-02f, -1.07418858e-01f, -1.25806496e-01f, 5.21931984e-02f, 1.41201720e-01f, 1.31146610e-01f, 1.08503830e-02f, -1.32181779e-01f, -6.68292046e-02f,
  -4.62472439e-02f, 8.91011879e-02f, 2.25455910e-02f, 9.59477872e-02f, -2.38831803e-01f, 2.40732580e-02f, -2.32777093e-02f, 2.25342855e-01f, 1.90952942e-01f, 2.51240939e-01f,
  -1.10743888e-01f, 9.70694125e-02f, -1.45772651e-01f, 5.21804988e-02f, 6.07062243e-02f, -4.58986647e-02f, -1.44161098e-02f, -1.48079358e-02f, 1.38848752e-01f, -4.52320427e-02f,
  2.27747351e-01f, 1.76549375e-01f, -1.17398438e-03f, 7.20511600e-02f, 3.27372253e-02f, 6.00697286e-02f, -1.63813502e-01f, 5.15563488e-02f, -1.17391450e-02f, -1.21921934e-01f,
  1.19671680e-01f, 1.03992231e-01f, 1.42973978e-02f, -1.48335338e-01f, 1.62518710e-01f, -1.25399783e-01f, -1.94927286e-02f, -8.79740044e-02f, -1.58985972e-01f, 4.26032729e-02f,
  1.41009152e-01f, 1.67165563e-01f, -8.62032473e-02f, 7.71309584e-02f, 9.48581472e-02f, 5.43443598e-02f, 1.27115259e-02f, 8.13231170e-02f, -1.51436180e-01f, -7.02354610e-02f,
  1.65764272e-01f, 8.90026689e-02f, 1.27667218e-01f, -2.17842668e-01f, -1.49816260e-01f, -2.09421944e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  -4.96363500e-03f, 6.63482994e-02f, 4.97581810e-02f, 1.39636295e-02f, 1.07052110e-01f, 8.19684416e-02f, 1.76398546e-01f, -1.12335153e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  2.17702314e-02f, 2.00292811e-01f, -2.58482367e-01f, 3.47908527e-01f, 1.63252637e-01f, -1.00619704e-01f, 1.59889683e-01f, 1.60102814e-01f, 5.66231012e-02f, 5.37729561e-01f,
  3.02723050e-01f, 1.66013867e-01f, -7.01633245e-02f, -4.64284837e-01f, -2.07916513e-01f, 5.48198521e-02f, -4.63673115e-01f, 4.98439610e-01f, 3.55891347e-01f, -3.82424861e-01f,
  5.55095255e-01f, -1.96857750e-01f, -2.69845396e-01f, -5.39918780e-01f, -4.59082961e-01f, 4.52282280e-01f, -3.17313552e-01f, -2.18882691e-02f, 5.47926664e-01f, -2.30769604e-01f,
  -9.39451233e-02f, 1.56874940e-01f, -5.51598489e-01f, 4.57509756e-01f, -4.23402607e-01f, -1.08879805e-01f, -4.91154902e-02f, 6.71387240e-02f, 2.30154082e-01f, 1.41592965e-01f,
  4.75574404e-01f, -4.77335840e-01f, -3.75799060e-01f, 1.36494845e-01f, -2.57997185e-01f, -2.15152711e-01f, -3.14884931e-01f, -5.62525809e-01f, -6.08529985e-01f, -4.46060121e-01f,
  -8.07798445e-01f, 5.19818246e-01f, 5.05197465e-01f, -5.35695314e-01f, 4.37280893e-01f, 3.36385965e-01f, -6.62169993e-01f, -1.62002727e-01f, -2.28298798e-01f, 2.54844576e-01f,
  1.29925549e-01f, 2.43325993e-01f, 9.10088494e-02f, -3.01100854e-02f, -5.46950221e-01f, 3.38280141e-01f, 3.70266408e-01f, -4.11815554e-01f, 5.36599815e-01f, -5.44556320e-01f,
  1.32267416e-01f, 5.85812069e-02f, -4.57352519e-01f, 3.22756320e-01f, -2.86258813e-02f, -4.85089898e-01f, -2.44091600e-01f, 9.53470170e-02f, -1.23722292e-01f, -2.08915323e-01f,
  1.34167239e-01f, -7.00176656e-01f, -2.36816213e-01f, 5.61523497e-01f, -4.95218903e-01f, -4.11211044e-01f, 4.55499738e-01f, -1.01623066e-01f, 3.81558031e-01f, -1.10940114e-01f,
  -2.96262324e-01f, -3.68382514e-01f, -4.59305681e-02f, 3.04497451e-01f, 7.18520135e-02f, -1.12483151e-01f, -1.23501286e-01f, -2.91484565e-01f, -4.54822220e-02f, 3.01931709e-01f,
  -4.80531365e-01f, 4.56564724e-01f, -1.81938112e-01f, -3.18018258e-01f, -2.25050181e-01f, -3.05838466e-01f, 2.70122141e-01f, 4.02533621e-01f, -3.66720080e-01f, -1.33039474e-01f,
  4.91695911e-01f, 6.21339500e-01f, -9.41128358e-02f, 4.57268767e-02f, 1.00504451e-01f, 8.43406245e-02f, 4.04907942e-01f, 2.21625060e-01f, -2.68890560e-01f, -3.70132238e-01f,
  8.86664093e-02f, 2.54814357e-01f, 5.40769517e-01f, -1.04722418e-01f, -2.95931369e-01f, -2.77715567e-02f, 1.34344473e-01f, 2.10918531e-01f, 3.10298383e-01f, 4.81285483e-01f,
  3.63260120e-01f, 4.70609546e-01f, 5.52325606e-01f, 7.93993007e-03f, -6.62449777e-01f, -1.97218269e-01f, 5.36885977e-01f, 2.49694474e-02f, -4.87554640e-01f, 3.43293428e-01f,
  -5.82311116e-02f, -7.40188584e-02f, -2.18576550e-01f, 1.90941542e-01f, 6.85979307e-01f, 3.16104054e-01f, 9.71186236e-02f, -5.63666701e-01f, -7.36423060e-02f, 7.49166727e-01f,
  -2.67103016e-01f, -3.63561332e-01f, 2.31195405e-01f, 2.17656627e-01f, 1.44763917e-01f, -1.14067383e-01f, 3.98168117e-01f, -3.50294262e-01f, -1.24683782e-01f, -2.72441655e-02f,
  2.54275799e-01f, 4.41846341e-01f, -2.32757702e-01f, -2.02855498e-01f, -4.24241066e-01f, -6.75193146e-02f, 3.35228086e-01f, 4.71197695e-01f, 4.26030457e-01f, -4.87771295e-02f,
  3.50227177e-01f, 3.69401783e-01f, -3.49258840e-01f, 4.08735722e-01f, 1.03747591e-01f, -2.66886532e-01f, -4.31506038e-01f, 7.23579109e-01f, 2.40205407e-01f, 1.90442666e-01f,
  -5.30339539e-01f, -5.64781845e-01f, 1.17042191e-01f, 2.06857651e-01f, -8.33296403e-02f, -2.69420594e-01f, -4.11540449e-01f, 5.45954406e-01f, 3.59433830e-01f, -2.36006916e-01f,
  8.74828361e-03f, -2.75734812e-02f, 4.83008534e-01f, -5.58623374e-01f, -3.01125526e-01f, -4.61021990e-01f, -8.42535496e-03f, 5.18132627e-01f, 3.09370816e-01f, 3.81336436e-02f,
  -6.65586710e-01f, -3.90324324e-01f, 5.74147165e-01f, -5.22137642e-01f, 1.07884996e-01f, -1.42021537e-01f, -1.74559042e-01f, -5.72620593e-02f, -3.67085487e-01f, 1.21544465e-01f,
  -3.25575471e-01f, 4.49517488e-01f, 7.03608692e-02f, -3.28567952e-01f, 1.25860900e-01f, 7.81561732e-02f, 5.26933312e-01f, -2.82167494e-01f, -2.47056216e-01f, -1.25813752e-01f,
  -2.16062978e-01f, -7.59785324e-02f, 5.48176654e-02f, 2.38804147e-02f, 4.91317175e-02f, 6.39521554e-02f, 2.91549832e-01f, -6.30842090e-01f, -2.42975652e-01f, -1.87103048e-01f,
  1.00216486e-01f, -4.89448965e-01f, -1.10468164e-01f, -3.83454055e-01f, -4.46211487e-01f, -2.34147310e-01f, 4.99500483e-01f, -2.07532912e-01f, 4.71763194e-01f, 4.07862991e-01f,
  5.39086759e-01f, 4.42200780e-01f, 3.95428985e-01f, -2.99502999e-01f, 2.00157791e-01f, 1.57544967e-02f, -3.08382928e-01f, -6.21253550e-01f, -6.43923998e-01f, 3.22857738e-01f,
  5.11216462e-01f, -1.93431959e-01f, 6.97778761e-02f, -1.19989097e-01f, 8.15753341e-02f, -8.61889943e-02f, -6.74286112e-02f, -5.67100763e-01f, -4.98731703e-01f, -3.19620430e-01f,
  -3.34330589e-01f, -3.64207685e-01f, -4.43337619e-01f, -3.93359184e-01f, -2.08883792e-01f, -6.05471313e-01f, -3.23257685e-01f, -3.10635507e-01f, 1.24936067e-02f, 1.16554774e-01f,
  -5.69294244e-02f, 7.94360489e-02f, -3.52315396e-01f, -4.44799334e-01f, -4.92349595e-01f, -1.22746088e-01f, -9.20934454e-02f, 4.79669012e-02f, 3.00529629e-01f, -2.20226824e-01f,
  -2.83361018e-01f, -8.63004401e-02f, -1.92800015e-01f, 5.99249005e-01f, -2.85666764e-01f, 6.10140413e-02f, 3.30979288e-01f, -3.96130048e-02f, 2.11539805e-01f, -2.80874431e-01f,
  2.10363790e-01f, 4.13824171e-01f, 2.39178732e-01f, -2.83670068e-01f, 6.09625578e-02f, 6.00375235e-01f, -5.96922755e-01f, 3.39496493e-01f, -2.82347828e-01f, 3.65316480e-01f,
  6.56399369e-01f, 1.97360978e-01f, -3.73890609e-01f, -4.44170088e-01f, -5.43456614e-01f, 7.12020278e-01f, 2.22615451e-01f, 1.23316385e-01f, -6.00014746e-01f, -1.49029240e-01f,
  -6.51639044e-01f, 6.92247689e-01f, 3.29034090e-01f, -3.38000834e-01f, -3.87765557e-01f, -3.30007076e-01f, -1.96257949e-01f, -6.18695207e-02f, -1.15088753e-01f, -2.15749025e-01f,
  -3.85112971e-01f, -2.45457366e-02f, 3.19650322e-01f, 1.97624519e-01f, -1.48752913e-01f, -2.98514634e-01f, -1.64986849e-02f, 3.05691063e-01f, 2.92819858e-01f, 2.58269012e-01f,
  -7.21979588e-02f, -1.57936569e-02f, 1.48387954e-01f, -5.22173643e-01f, 6.01531208e-01f, -1.94218144e-01f, 5.03705978e-01f, -6.71552896e-01f, 1.90048322e-01f, -2.02640891e-01f,
  2.79415101e-01f, 4.17439699e-01f, 5.66134274e-01f, 4.43080246e-01f, 3.60675044e-02f, -3.75989318e-01f, 5.84038734e-01f, -2.61788934e-01f, -6.55112937e-02f, 4.51368205e-02f,
  1.96126685e-01f, 3.48443314e-02f, 7.52423033e-02f, 9.64736044e-02f, 6.20990634e-01f, 2.43936598e-01f, 4.31562126e-01f, 7.89807498e-01f, 5.02272788e-03f, 1.28404543e-01f,
  -1.69930607e-01f, 2.24864379e-01f, 5.01123130e-01f, -9.92410928e-02f, -4.44966346e-01f, 1.90963283e-01f, 4.24641967e-01f, -2.39234604e-02f, 6.60774708e-01f, -8.94667655e-02f,
  2.41099134e-01f, -3.67597908e-01f, -4.75085109e-01f, 5.32676280e-01f, -4.07679647e-01f, 5.23512125e-01f, 5.35054445e-01f, -3.45867515e-01f, -5.33517860e-02f, -3.29607546e-01f,
  -1.96925640e-01f, 1.99985385e-01f, 4.46178503e-02f, -9.89795774e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  6.88226297e-02f, 2.07336053e-01f, 1.12840518e-01f, -3.35850865e-01f, 2.35407650e-01f, -2.17628013e-02f, -9.38983113e-02f, 1.92842618e-01f, 5.25139868e-02f, 4.19597551e-02f,
  1.84717346e-02f, 9.22936946e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    