/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.74962997e-01f, 2.45931104e-01f, 1.13070183e-01f, -7.56082386e-02f, -1.77536398e-01f, -2.81342603e-02f, -1.41375571e-01f, 5.50836883e-02f, -7.72317126e-02f, 1.16411150e-01f,
  -5.05393259e-02f, 5.47883138e-02f, -5.43968566e-02f, 2.53272429e-02f, -1.88045889e-01f, 8.30882639e-02f, -3.98585275e-02f, 5.00706993e-02f, 3.61912698e-02f, 9.62759629e-02f,
  2.94664465e-02f, -3.87041382e-02f, 1.75061226e-02f, 2.13167556e-02f, 9.89222601e-02f, 6.08550757e-02f, -4.91161458e-02f, 2.79508512e-02f, 2.36092508e-02f, -6.83925673e-02f,
  -6.12021089e-02f, 1.92070231e-02f, -5.39574362e-02f, 5.75124808e-02f, -2.11851876e-02f, 2.45153606e-02f, -2.44323518e-02f, -5.41350953e-02f, -9.84232756e-04f, 3.86568978e-02f,
  9.56029817e-02f, 3.20615945e-03f, -1.46498429e-02f, 4.67721187e-03f, -3.83673124e-02f, 2.25958694e-02f, 6.23484375e-03f, -7.30089145e-03f, -1.80776301e-03f, -4.95986789e-02f,
  9.46472660e-02f, 7.75945932e-02f, 9.52335075e-02f, 7.86941200e-02f, -1.53426779e-02f, -2.91460231e-02f, 6.28448129e-02f, 2.40142308e-02f, 7.20576290e-03f, -3.20015363e-02f,
  4.40287478e-02f, 2.87648011e-02f, -7.94107839e-03f, 5.09340130e-02f, 7.51110679e-03f, -2.03466229e-02f, -5.99956838e-03f, -2.29762327e-02f, -1.34444842e-02f, 3.29713300e-02f,
  -4.58967052e-02f, 8.23098142e-03f, 2.42340583e-02f, 5.56783974e-02f, 2.82042418e-02f, -2.50653224e-03f, 1.15060285e-02f, 1.33540379e-02f, 3.64245959e-02f, -1.78257916e-02f,
  1.01622613e-02f, -2.51975264e-02f, 2.62395311e-02f, -2.64006648e-02f, -4.32365248e-03f, -4.53188121e-02f, 5.02782427e-02f, 3.58940922e-02f, 9.38023999e-03f, -1.68013629e-02f,
  1.20266922e-01f, 1.28974110e-01f, 1.48022138e-02f, -4.05189171e-02f, 1.38537902e-02f, 1.73283983e-02f, -4.36533913e-02f, -3.80713120e-03f, 1.03853278e-01f, -1.08356103e-02f,
  5.20027243e-02f, -1.13754803e-02f, 5.43473251e-02f, -2.82245446e-02f, -3.71735282e-02f, 2.33120634e-03f, 2.70720553e-02f, 6.05898350e-02f, 1.81838043e-03f, 2.86473315e-02f,
  -5.86123625e-03f, 4.52378802e-02f, -8.13853927e-03f, 3.54549587e-02f, -4.65775430e-02f, 1.19548356e-02f, -2.70144474e-02f, 4.33019549e-03f, -3.75507660e-02f, 7.77976438e-02f,
  1.32848769e-01f, -8.12621322e-03f, -1.25638023e-01f, -1.73559617e-02f, -1.24320559e-01f, 3.94535325e-02f, 1.31087273e-01f, -1.23643773e-02f, -2.64854729e-03f, 1.90592691e-01f,
  1.48975387e-01f, -1.01491109e-01f, 2.52409447e-02f, 1.99616238e-01f, 1.35149211e-01f, 1.52877986e-01f, 9.26278457e-02f, -1.23386234e-02f, -1.15076259e-01f, 8.19459483e-02f,
  -2.49195355e-03f, 1.87664449e-01f, -5.64716645e-02f, 2.73993164e-02f, 2.68880166e-02f, -1.01772197e-01f, 7.87270628e-03f, -1.17935531e-01f, 1.79641824e-02f, -6.88882396e-02f,
  -1.21697702e-01f, 5.86767914e-03f, -8.32704641e-03f, 3.95180099e-02f, -4.27991967e-04f, -2.27233041e-02f, 3.31348926e-02f, -8.63159262e-03f, -1.85994282e-02f, 1.43412966e-02f,
  5.80291450e-02f, 6.64105788e-02f, -1.02570299e-02f, -7.79941399e-03f, 2.11503566e-03f, 3.44906636e-02f, 3.64833102e-02f, 2.55862009e-02f, -3.58740147e-03f, 9.19113401e-03f,
  -5.87932824e-04f, -4.44639809e-02f, 5.05885966e-02f, 2.50900518e-02f, 3.48752886e-02f, -2.14465130e-02f, 5.39875962e-02f, -7.31488541e-02f, -5.80767207e-02f, -3.32580358e-02f,
  1.98701639e-02f, -7.57858753e-02f, 7.98381343e-02f, 1.15775876e-01f, 4.92077991e-02f, 3.30955535e-02f, 6.11397922e-02f, 7.73753375e-02f, 1.60339661e-02f, 1.22224979e-01f,
  -5.69323488e-02f, 5.97802512e-02f, 2.06093141e-03f, 1.28870383e-02f, 7.42431134e-02f, 5.12715839e-02f, -4.39455658e-02f, 5.93765043e-02f, -3.29556726e-02f, -5.03474362e-02f,
  -1.37725491e-02f, -6.96755126e-02f, 2.12375482e-04f, -6.20916039e-02f, -8.51446912e-02f, 5.34852482e-02f, 5.87273911e-02f, -5.29532097e-02f, -6.76249266e-02f, -7.75548769e-03f,
  1.00859746e-01f, 2.84845987e-03f, -2.87981760e-02f, -1.49923526e-02f, -1.22076301e-02f, 4.30344567e-02f, 2.74862945e-02f, 9.77494642e-02f, -7.47405887e-02f, 1.84159335e-02f,
  5.78360781e-02f, 4.56972793e-02f, 7.22836778e-02f, -4.27276827e-02f, 8.45881924e-02f, 5.06369583e-02f, -1.27430698e-02f, 1.62308160e-02f, -3.23884636e-02f, -6.29623309e-02f,
  6.56844974e-02f, 4.44315039e-02f, 6.75343871e-02f, 2.24466454e-02f, 4.09586020e-02f, -1.63203292e-02f, -3.19972783e-02f, -1.47342533e-02f, 1.72457669e-03f, 9.07409377e-03f,
  -3.91036183e-01f, -6.53541684e-02f, -1.64006591e-01f, 3.56705077e-02f, 2.19535530e-02f, -1.44148467e-03f, -1.84766293e-01f, 5.66218384e-02f, -3.67700100e-01f, 1.47257373e-01f,
  6.41293898e-02f, -3.66872139e-02f, -1.92919716e-01f, 2.28578120e-01f, 1.17095023e-01f, -1.89594373e-01f, 1.56741306e-01f, 8.26480314e-02f, -2.19197437e-01f, 4.04569693e-02f,
  -6.51284307e-02f, 2.47401834e-01f, 7.19345361e-02f, 2.96106935e-01f, 2.74665444e-03f, 5.69373183e-02f, 3.60859841e-01f, -2.54999176e-02f, 2.80667037e-01f, 1.94868669e-01f,
  -1.35605007e-01f, -1.21040665e-01f, -1.80204923e-03f, -2.12755650e-02f, 8.89098495e-02f, 1.44630270e-02f, 1.83978770e-02f, 2.64461040e-02f, -5.62888682e-02f, -4.93774675e-02f,
  -4.84973229e-02f, -2.59253997e-02f, 4.16608676e-02f, 1.79383140e-02f, -2.34302264e-02f, -8.15174170e-03f, -4.87387963e-02f, 1.32492175e-02f, 7.30087422e-03f, -6.59394115e-02f,
  -4.16350737e-02f, 2.19321083e-02f, 1.08658150e-03f, 5.86576685e-02f, -2.09629647e-02f, -5.25291748e-02f, 1.70261208e-02f, -1.63854640e-02f, 1.21415835e-02f, 3.98042873e-02f,
  3.92338121e-03f, -7.36853704e-02f, 4.18555327e-02f, 4.67172079e-03f, -3.49454805e-02f, -7.42736552e-03f, 1.31365862e-02f, 6.11485019e-02f, -1.69607438e-02f, 3.56836133e-02f,
  3.93791050e-02f, -1.18522812e-02f, -1.22276694e-02f, -4.55457643e-02f, -2.24799830e-02f, -1.67344268e-02f, -3.27570476e-02f, 6.65313229e-02f, -1.96054447e-02f, -1.26494402e-02f,
  -7.56283998e-02f, 1.78658403e-03f, 2.41031386e-02f, 2.29466315e-02f, 1.35916406e-02f, -4.09378931e-02f, 3.83159444e-02f, -2.85342429e-02f, -3.66061255e-02f, 2.47336924e-02f,
  1.86569184e-01f, 1.04236752e-01f, 2.38669906e-02f, 1.05214966e-02f, 1.17384931e-02f, 8.20984542e-02f, -1.61451823e-03f, 4.56912369e-02f, -5.12168789e-03f, 3.86055224e-02f,
  6.51893690e-02f, 6.85154647e-02f, -3.30790728e-02f, 2.76813973e-02f, 2.49259621e-02f, -6.09809346e-03f, 1.29116867e-02f, 5.17538711e-02f, 8.33726227e-02f, 5.45719825e-02f,
  2.74615623e-02f, -5.03732190e-02f, 1.61971506e-02f, -3.40236770e-03f, 2.77174283e-02f, 7.34824911e-02f, 3.63636091e-02f, -2.06049290e-02f, 5.65345064e-02f, -4.47497256e-02f,
  3.78895968e-01f, 1.40882619e-02f, -1.43038437e-01f, 2.03022286e-01f, 1.56865314e-01f, -4.63061482e-02f, -1.03584342e-01f, 1.73356250e-01f, 1.38744399e-01f, 5.50502427e-02f,
  -4.73097479e-03f, 6.91247731e-02f, -6.18653670e-02f, 6.12404989e-03f, 3.91279198e-02f, -6.78544715e-02f, 9.91758555e-02f, 7.59412348e-02f, -2.86924299e-02f, 4.09080088e-03f,
  3.23429443e-02f, -3.46807092e-02f, -6.17490299e-02f, 1.74226072e-02f, 7.41205215e-02f, -8.09819344e-03f, -3.07954755e-02f, -7.78273121e-02f, -6.08794689e-02f, -1.59490313e-02f,
  1.33319169e-01f, 1.63373411e-01f, 5.45479469e-02f, -1.08641841e-01f, -6.31518885e-02f, 8.99202097e-03f, -7.71304369e-02f, -1.30430654e-01f, 2.25185324e-02f, -5.48049472e-02f,
  -2.19389033e-02f, 1.30521273e-02f, -2.06368100e-02f, -7.92437866e-02f, 4.02875096e-02f, -2.05531754e-02f, -7.50259496e-03f, -4.84990329e-03f, -1.83803476e-02f, -1.66457109e-02f,
  6.07693233e-02f, 3.80000174e-02f, 5.55593669e-02f, -1.11763331e-03f, -8.59104171e-02f, -3.52507941e-02f, 5.25137484e-02f, -6.21621870e-02f, 1.98310167e-02f, 5.38901947e-02f,
  -5.93396164e-02f, -1.64159201e-02f, 2.72998661e-02f, 7.06109926e-02f, 1.02578860e-03f, 5.54125011e-02f, -2.45430190e-02f, 5.11662960e-02f, -4.83660288e-02f, 2.67643686e-02f,
  -4.84681688e-02f, 1.01368524e-01f, 1.16773667e-02f, -4.52999212e-02f, 3.77757140e-02f, 4.23687361e-02f, 1.29349250e-02f, 6.86179250e-02f, 9.18039866e-03f, -1.07210455e-02f,
  -1.74312084e-03f, -5.35562150e-02f, 8.78714770e-03f, 3.19618173e-02f, 2.08998099e-02f, -6.75526708e-02f, -1.39728077e-02f, 5.61276115e-02f, 6.77610114e-02f, -8.09012279e-02f,
  7.90988356e-02f, 9.56521779e-02f, -3.90041731e-02f, 9.71561298e-02f, 7.28699639e-02f, 2.43947636e-02f, 1.60922762e-02f, -4.63464446e-02f, -1.08475298e-01f, 2.27002706e-03f,
  -5.71739785e-02f, 6.30270988e-02f, -7.00959610e-03f, 2.54551005e-02f, -2.50569284e-02f, 1.22250291e-02f, -8.92080367e-03f, 3.54499035e-02f, 7.92381391e-02f, 6.88199848e-02f,
  -3.60047705e-02f, 4.71975766e-02f, -5.42899705e-02f, 1.36774912e-01f, 1.60155687e-02f, -5.83663173e-02f, 1.49767511e-02f, -2.18295995e-02f, -2.85854302e-02f, -9.99929458e-02f,
  1.92803085e-01f, -1.17002547e-01f, 1.55022621e-01f, 3.71040069e-02f, -3.57166044e-02f, 2.35248789e-01f, 2.42596552e-01f, -2.84590889e-02f, 1.42436653e-01f, 8.84741768e-02f,
  1.03366867e-01f, 9.81189832e-02f, 5.48670776e-02f, 8.83078575e-02f, 1.64188445e-01f, 1.62355751e-01f, 1.04027301e-01f, -5.87416161e-03f, -1.62472539e-02f, 2.26375032e-02f,
  6.55636936e-03f, 7.55587593e-02f, 9.01016891e-02f, 7.65889660e-02f, 5.63027970e-02f, 6.69469535e-02f, -7.36499056e-02f, 5.66584803e-02f, 6.68579619e-03f, 7.18167238e-03f,
  1.08827278e-01f, 3.34650949e-02f, 9.14402530e-02f, 3.25893946e-02f, 2.55488474e-02f, -2.93180440e-02f, -1.28445225e-02f, -3.50679494e-02f, -3.41383666e-02f, -1.06387436e-02f,
  6.02418222e-02f, -6.01229072e-02f, 2.26592738e-02f, -1.55942589e-02f, 4.66838144e-02f, 3.99409942e-02f, -9.86477211e-02f, 1.56368613e-02f, 6.10442534e-02f, 9.87646356e-02f,
  5.34688830e-02f, -2.91779861e-02f, -3.89928631e-02f, 3.42356302e-02f, -5.15420660e-02f, -3.62968929e-02f, 1.82333663e-02f, 9.42657068e-02f, 2.26098243e-02f, -5.31621575e-02f,
  1.70397703e-02f, 8.92849732e-03f, -8.21365491e-02f, 9.43447873e-02f, -2.67789941e-02f, 5.50904311e-02f, 4.29632328e-02f, -5.75767942e-02f, -6.49655685e-02f, -4.90198173e-02f,
  1.30610252e-02f, -4.84163902e-04f, 5.02246208e-02f, 5.61087625e-03f, 4.70466278e-02f, 5.57220541e-02f, 6.02978580e-02f, -2.43230723e-02f, 5.56381280e-03f, -2.02394556e-02f,
  5.06568477e-02f, -8.88309628e-02f, 5.47593012e-02f, 4.38176617e-02f, -1.49696190e-02f, 6.01819083e-02f, 3.08449771e-02f, -6.16513118e-02f, -4.22557890e-02f, -4.90853079e-02f,
  -7.38462284e-02f, 4.17261273e-02f, -1.75837874e-02f, -5.46391914e-03f, 7.23988190e-02f, 2.60245278e-02f, 9.88827422e-02f, -1.19062707e-01f, 2.38832235e-02f, 1.89198274e-02f,
  -6.14902638e-02f, -2.03482416e-02f, 2.66619306e-02f, 6.37276610e-03f, -3.43697295e-02f, -3.42693441e-02f, 6.06901161e-02f, -1.25593059e-02f, 1.57976430e-02f, -2.79524289e-02f,
  9.67699662e-02f, 9.24682617e-03f, -2.73582060e-02f, -1.40569182e-02f, 3.91563028e-02f, -3.76877673e-02f, -7.26959063e-03f, -2.60680076e-02f, -6.86943829e-02f, -7.66197443e-02f,
  -3.48515421e-01f, 2.71417294e-02f, -3.50202203e-01f, -2.03262158e-02f, -9.69533715e-03f, -2.01684330e-02f, -5.67896180e-02f, -2.86787413e-02f, -1.53097525e-01f, 2.53969610e-01f,
  4.74215932e-02f, -2.53401548e-01f, 4.52319458e-02f, -1.73395069e-03f, -2.37375304e-01f, 9.07746702e-02f, -8.82718898e-03f, 6.21870756e-02f, -2.13659797e-02f, -1.55806625e-02f,
  -1.15483813e-02f, 1.39322951e-01f, -1.09516315e-01f, 6.67639226e-02f, -8.51126090e-02f, -5.97417504e-02f, 1.83278881e-02f, -6.15715086e-02f, -3.60179320e-02f, 1.31297763e-02f,
  4.77368608e-02f, 7.93719739e-02f, -5.91609329e-02f, -9.19749290e-02f, -1.22143151e-02f, -5.43728173e-02f, -1.62935816e-02f, -5.76832779e-02f, -2.66275648e-02f, -6.01483211e-02f,
  -5.60470186e-02f, -1.17243931e-01f, -2.29391083e-02f, 2.75305528e-02f, 1.05313389e-02f, -8.02361220e-02f, -1.22601226e-01f, -1.71457622e-02f, -6.91726506e-02f, 8.06685463e-02f,
  -3.18893977e-02f, -2.29285564e-02f, -4.04860405e-03f, -4.81753722e-02f, -3.74603458e-02f, 1.65319312e-02f, -1.97859071e-02f, -6.48259744e-02f, -2.22355630e-02f, -4.25371863e-02f,
  6.42164890e-03f, -1.10240292e-03f, 7.42345490e-03f, -2.92337816e-02f, 1.05038984e-02f, 5.49364910e-02f, -1.97062753e-02f, 2.85729151e-02f, 2.36791987e-02f, 1.33428071e-02f,
  2.28577759e-03f, -2.89622135e-02f, 1.90325081e-02f, -3.61379161e-02f, 5.04554324e-02f, 7.33608231e-02f, 9.99642350e-03f, 5.31127350e-03f, -2.60924865e-02f, 9.53200553e-03f,
  -1.94281284e-02f, -2.43208408e-02f, 8.08580369e-02f, 3.75950858e-02f, 2.81855185e-02f, 1.45068895e-02f, 4.15695496e-02f, -7.07574980e-03f, -2.25198455e-02f, 1.06835030e-02f,
  2.11932883e-01f, 7.65168294e-02f, 4.64194715e-02f, -5.55408187e-02f, -2.47630551e-02f, 1.22701833e-02f, 5.19728921e-02f, 1.90801602e-02f, 1.48756485e-02f, 9.08227358e-03f,
  4.03599404e-02f, 3.01203560e-02f, 2.32387111e-02f, -1.04123177e-02f, -4.11414504e-02f, 6.08258881e-02f, 9.92598236e-02f, -4.34050784e-02f, 4.38883826e-02f, -2.37469859e-02f,
  5.57300933e-02f, 2.48965248e-02f, -4.42616604e-02f, 6.27152249e-02f, 8.00629482e-02f, 5.64776920e-02f, 1.76413171e-02f, -2.21048947e-02f, 4.97645661e-02f, -1.10211140e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.22933918e-01f, 1.08582847e-01f, -2.24345829e-02f, 2.78248806e-02f, -1.09177247e-01f, -7.01682642e-02f, -1.49615079e-01f, 5.53217269e-02f, -2.31028106e-02f, -5.45001179e-02f,
  8.39440897e-02f, -7.35573918e-02f, 1.10058308e-01f, 1.40697490e-02f, 7.16013834e-02f, 1.08586498e-01f, 1.28086373e-01f, -5.42776510e-02f, 1.87172387e-02f, 1.47936314e-01f,
  1.74598247e-02f, -1.51415449e-02f, 1.28921673e-01f, 2.32160110e-02f, 2.39675455e-02f, -2.11461494e-03f, 2.04066902e-01f, 3.35650183e-02f, -5.54523505e-02f, -5.89536168e-02f,
  -1.00887805e-01f, 4.52468544e-02f, 4.41118237e-03f, 3.78494561e-02f, 4.24186476e-02f, 2.82891877e-02f, -5.23698553e-02f, 4.51721027e-02f, -6.53041080e-02f, -1.85734574e-02f,
  -5.49947657e-02f, -8.62767641e-03f, 6.62184134e-02f, 2.50546187e-02f, -7.61722922e-02f, 1.88973770e-02f, 5.65216355e-02f, -1.06267147e-01f, 9.94111225e-03f, 7.18961284e-02f,
  -1.55045586e-02f, 1.11019321e-01f, 1.23251388e-02f, -7.04619214e-02f, -7.34050721e-02f, -2.34573409e-02f, 5.80549724e-02f, 6.74819052e-02f, -3.74422036e-02f, 5.65432943e-02f,
  7.58327097e-02f, -3.36624309e-02f, -3.09333354e-02f, -7.39498213e-02f, 3.12874652e-02f, 2.15325691e-02f, 9.38650192e-05f, -3.54528204e-02f, 1.27367936e-02f, 1.02983102e-01f,
  4.16784361e-03f, 6.26511127e-02f, -3.37758064e-02f, -4.91314642e-02f, -2.81183459e-02f, 4.77005951e-02f, 1.30700413e-02f, -5.98028535e-03f, -7.31709003e-02f, 2.98945457e-02f,
  -8.67545009e-02f, 6.55442029e-02f, 5.81686720e-02f, 6.92246407e-02f, 1.30384751e-02f, -3.79782543e-02f, 8.50619078e-02f, 1.14090536e-02f, -2.14372482e-02f, 3.05881500e-02f,
  3.48334983e-02f, 2.27782145e-01f, 3.55386771e-02f, -8.59322175e-02f, 5.49348369e-02f, -2.19417773e-02f, 1.28628165e-02f, 4.32640798e-02f, 3.87630835e-02f, 1.18667491e-01f,
  1.03041537e-01f, -6.67919070e-02f, 2.94107497e-02f, 6.02494851e-02f, 7.98471272e-02f, 6.78670332e-02f, 4.53705117e-02f, 5.08725680e-02f, -7.50647783e-02f, -4.59559672e-02f,
  -2.60075051e-02f, 1.08315796e-01f, 1.00233452e-02f, -1.46152051e-02f, 1.72972493e-03f, -7.42518827e-02f, -7.41799399e-02f, 2.64231432e-02f, -5.41379303e-02f, -3.71691324e-02f,
  -2.15093791e-02f, -3.47127691e-02f, -1.15215838e-01f, -8.36501494e-02f, 6.81428164e-02f, 9.47038010e-02f, 1.24870315e-01f, -6.37872368e-02f, 1.29958406e-01f, -2.07243375e-02f,
  7.07006305e-02f, 2.29741931e-02f, 1.37884612e-03f, -4.59994050e-03f, 1.01464517e-01f, 5.89437522e-02f, 9.50625986e-02f, 8.00849050e-02f, 3.73679772e-02f, -1.47609515e-02f,
  -4.78137247e-02f, 1.30019421e-02f, -4.65006605e-02f, -1.14433989e-01f, -4.47654491e-03f, -1.31008342e-01f, -1.80735774e-02f, -8.38290453e-02f, -9.01613792e-04f, -1.88740566e-02f,
  6.58507049e-02f, 2.83906944e-02f, -2.58230660e-02f, 2.60616206e-02f, -5.44084832e-02f, 7.38748014e-02f, -5.75337596e-02f, -2.43314989e-02f, -1.90751534e-02f, 5.82675040e-02f,
  2.33539790e-02f, 5.94826303e-02f, 7.52195995e-03f, -2.33561033e-04f, 5.79956770e-02f, -3.80985960e-02f, -3.02746911e-02f, 4.75397445e-02f, -2.83563826e-02f, -1.24678109e-02f,
  -7.51961097e-02f, 4.54857871e-02f, -2.71318424e-02f, -4.97377366e-02f, -9.01491120e-02f, 5.30631728e-02f, 6.73401207e-02f, -1.29620340e-02f, 1.39089406e-03f, 5.21068871e-02f,
  -7.25477040e-02f, 1.69978552e-02f, -3.35329175e-02f, 8.19521248e-02f, -6.71925172e-02f, -4.10884731e-02f, 4.36824821e-02f, 9.18696001e-02f, 6.68910742e-02f, -3.33878621e-02f,
  3.15224677e-02f, -2.97873169e-02f, 9.84614119e-02f, -1.96188372e-02f, -3.50840874e-02f, -3.65529992e-02f, -3.39960889e-03f, -3.50738615e-02f, 2.04163250e-02f, -6.27994016e-02f,
  8.01044628e-02f, -7.25640804e-02f, -5.42016737e-02f, -5.53272776e-02f, 1.88916363e-02f, -4.88864109e-02f, -2.28402670e-03f, -5.20737320e-02f, -5.98541237e-02f, 8.93904492e-02f,
  7.27798033e-04f, -2.29909196e-02f, -6.02314137e-02f, -6.01130761e-02f, 2.18673646e-02f, -6.68863254e-03f, -2.52112001e-02f, 1.34257618e-02f, -3.46158519e-02f, 5.13525270e-02f,
  2.93651167e-02f, -8.53788257e-02f, -5.20118698e-02f, 5.60666882e-02f, -5.76226674e-02f, -2.52633169e-03f, 6.92516640e-02f, -2.14812998e-03f, 3.63845937e-02f, -8.30037370e-02f,
  6.67309687e-02f, -1.65740997e-02f, 5.45344688e-02f, -1.04915768e-01f, -1.03924863e-01f, -7.66750649e-02f, -8.15463066e-02f, -2.95620337e-02f, 3.11413072e-02f, 4.89329128e-03f,
  2.86797062e-02f, -3.54149826e-02f, -1.37793511e-01f, -9.59384665e-02f, -4.48328294e-02f, -9.49404538e-02f, -9.90944952e-02f, -2.06422746e-01f, 9.43010971e-02f, 3.70218828e-02f,
  -5.35006300e-02f, 2.49642972e-02f, 2.06550017e-01f, -1.47587001e-01f, 2.04272166e-01f, 1.41862035e-01f, -1.62690416e-01f, 4.12569046e-02f, -6.34846687e-02f, -1.50253788e-01f,
  3.57357711e-02f, -1.76402647e-02f, 4.39200625e-02f, -1.72500849e-01f, -1.31191298e-01f, -5.27154803e-02f, 5.94616905e-02f, -6.71340302e-02f, -1.71524778e-01f, -7.08329454e-02f,
  -4.33367342e-02f, 2.86403745e-02f, -5.48210256e-02f, 1.10814556e-01f, -5.22428751e-02f, 1.58259794e-02f, 3.76867875e-03f, 2.57784836e-02f, 6.09946065e-02f, 5.29851168e-02f,
  -9.26535018e-03f, -1.21000642e-02f, -2.39650905e-03f, 4.98083383e-02f, 9.15220287e-03f, -6.55675903e-02f, -7.64550129e-03f, -2.11496819e-02f, -1.14324987e-01f, -5.66391535e-02f,
  -1.82756763e-02f, -4.34969999e-02f, -1.04771189e-01f, -4.53882143e-02f, 4.32667807e-02f, 3.56911607e-02f, 8.73602107e-02f, -4.76026312e-02f, 2.87525393e-02f, 3.46974581e-02f,
  8.92370418e-02f, 5.97042181e-02f, -3.98191474e-02f, 4.54116203e-02f, -1.18169086e-02f, 7.14073479e-02f, -7.31481686e-02f, -1.09683245e-03f, -8.53916109e-02f, -1.14753759e-02f,
  -5.75511530e-02f, -1.47134727e-02f, 2.68375520e-02f, -6.81500090e-03f, -4.65831123e-02f, -8.97020623e-02f, 4.24107760e-02f, -2.21877433e-02f, -6.79751784e-02f, -5.84453624e-03f,
  -6.55171499e-02f, -2.84176115e-02f, -4.93162451e-03f, 6.57152757e-02f, 5.38407527e-02f, 1.18720941e-02f, 1.29350089e-02f, -3.09142144e-03f, 7.94075653e-02f, 6.45002723e-02f,
  -8.36705565e-02f, 6.26136884e-02f, -9.87109765e-02f, 6.52430058e-02f, -8.88614333e-04f, 8.14352408e-02f, 3.44594270e-02f, 1.58200487e-02f, -5.70482090e-02f, 1.00377955e-01f,
  -3.30679528e-02f, -3.98958251e-02f, -6.69185221e-02f, -3.39045636e-02f, -1.28355727e-01f, 1.70440506e-02f, -3.41681242e-02f, 1.83664002e-02f, 3.35732140e-02f, -5.92328236e-02f,
  -7.48563334e-02f, -5.59126846e-02f, 9.87236500e-02f, -6.40781075e-02f, 2.55041495e-02f, 4.49087210e-02f, -9.44494456e-03f, 1.22805955e-02f, -1.15606445e-03f, -8.93677473e-02f,
  -1.01614997e-01f, 5.86237833e-02f, 1.43426970e-01f, 5.69558069e-02f, 5.53189889e-02f, -1.94541719e-02f, -1.95839647e-02f, 5.54228388e-02f, 2.63050608e-02f, 4.93570678e-02f,
  -3.35400477e-02f, 1.31245658e-01f, 2.05042656e-03f, 8.72264728e-02f, -1.51126534e-01f, 2.94350982e-02f, 7.86405802e-03f, -7.16082230e-02f, 7.61334896e-02f, -2.61668153e-02f,
  4.29769643e-02f, 3.11251655e-02f, 9.18651372e-02f, 3.45310345e-02f, 1.31137088e-01f, -2.00812574e-02f, -6.11158647e-02f, 5.15846349e-02f, 2.91522164e-02f, 2.42646821e-02f,
  4.97983061e-02f, 5.02172895e-02f, 1.05629988e-01f, 8.44090283e-02f, 6.03345037e-02f, 7.54261166e-02f, 9.17139351e-02f, -7.03851879e-02f, 9.12835598e-02f, -1.93892345e-02f,
  6.19272403e-02f, 2.95782685e-02f, 4.15316224e-02f, -7.07147345e-02f, 6.64351061e-02f, 3.11240070e-02f, 1.23051569e-01f, -5.37674129e-02f, 1.35854376e-03f, 8.62382203e-02f,
  3.64003368e-02f, -3.35303247e-02f, 9.37724579e-03f, -6.03872538e-02f, -5.14542758e-02f, -7.87152164e-03f, -2.17843782e-02f, -5.84131181e-02f, -5.09219281e-02f, -8.14403072e-02f,
  3.02234720e-02f, -1.04985014e-01f, 4.06375825e-02f, -4.23906073e-02f, -9.35180932e-02f, -5.57197221e-02f, 4.03849743e-02f, 5.69491014e-02f, 1.59525815e-02f, 5.99529631e-02f,
  5.42004071e-02f, 3.32750604e-02f, -4.09265682e-02f, 8.43136758e-02f, -4.34290543e-02f, -1.55557543e-02f, -9.34718251e-02f, -1.19144162e-02f, 1.57027394e-02f, -5.11684008e-02f,
  -2.49685273e-02f, -2.14274600e-02f, -4.26588096e-02f, -4.34660763e-02f, -4.04601432e-02f, -5.96725978e-02f, 2.44651418e-02f, -3.91493700e-02f, -4.74324375e-02f, 2.91571096e-02f,
  -1.03443768e-03f, -1.15453629e-02f, -4.62496951e-02f, 7.14428425e-02f, 6.88515529e-02f, -7.34146833e-02f, -1.59076601e-02f, -7.23410174e-02f, 8.45994428e-03f, -3.13390605e-02f,
  -7.87531212e-03f, 3.64641398e-02f, 1.61856450e-02f, 8.11608881e-02f, -3.71253379e-02f, -5.86145930e-02f, -2.31928229e-02f, -9.41562355e-02f, 6.48646653e-02f, -8.98012891e-04f,
  7.85868764e-02f, 6.94747120e-02f, -7.77733326e-02f, -2.42747320e-03f, -1.42749948e-02f, -7.58595094e-02f, -3.42087187e-02f, 4.73670289e-03f, 9.26485881e-02f, -7.87377059e-02f,
  1.27957001e-01f, -1.71211079e-01f, -7.73299951e-03f, 2.74249911e-01f, 5.94485998e-02f, -1.15348853e-01f, -2.02174932e-01f, 1.76745862e-01f, 1.74053032e-02f, -8.37477222e-02f,
  2.19682977e-01f, -5.78331761e-02f, -2.19390485e-02f, 1.51904598e-01f, 1.76146045e-01f, 6.40279204e-02f, 1.29493952e-01f, 3.09844296e-02f, 1.51288718e-01f, 8.33955333e-02f,
  2.78978229e-01f, 3.46783288e-02f, -1.95478648e-02f, 1.97608396e-02f, -7.70351365e-02f, -3.51302978e-03f, -1.07617155e-02f, -1.39165238e-01f, -2.02253857e-03f, -3.79503630e-02f,
  -2.71388348e-02f, 3.05720735e-02f, 2.86821648e-02f, -1.20652780e-01f, 1.88398585e-02f, -1.10746719e-01f, -1.07842095e-01f, -2.19592024e-02f, 1.62725674e-03f, -2.44308561e-02f,
  7.58125931e-02f, -3.45131531e-02f, -3.34478393e-02f, 5.10009900e-02f, -1.01740986e-01f, -5.66066615e-02f, -1.51283387e-02f, -4.21667621e-02f, -5.59929758e-02f, 4.15982977e-02f,
  3.05780321e-02f, -5.73140718e-02f, -3.29772830e-02f, 3.47403158e-03f, 5.99069744e-02f, 3.14734541e-02f, -9.90583077e-02f, -4.71315673e-03f, -5.60787581e-02f, -8.42187740e-03f,
  5.93230166e-02f, -2.84295268e-02f, -1.19261324e-01f, 8.38949159e-02f, 2.97538452e-02f, -8.81294068e-03f, -4.95323427e-02f, -2.09960472e-02f, -3.46558280e-02f, -6.27520457e-02f,
  1.51640235e-03f, -3.25719640e-03f, 1.23809949e-02f, -4.86328546e-03f, -4.58751470e-02f, 3.58762592e-03f, -2.61999611e-02f, 7.91223068e-03f, 4.67745736e-02f, 7.10632503e-02f,
  -2.61904243e-02f, -2.92982571e-02f, 9.50513929e-02f, -3.33056897e-02f, 5.26233651e-02f, 6.12170324e-02f, 1.24226660e-01f, -3.42469439e-02f, -7.43242577e-02f, -3.49010825e-02f,
  -9.49496180e-02f, 1.40453488e-01f, -3.38698435e-03f, 5.18315621e-02f, -7.71916360e-02f, -6.11352287e-02f, -1.00110106e-01f, 3.93324606e-02f, -2.18684208e-02f, 6.68920437e-03f,
  -5.21342009e-02f, -2.55945860e-03f, 4.45590392e-02f, -5.34608662e-02f, -5.71397021e-02f, 6.33557374e-03f, -1.60857104e-02f, -2.13842131e-02f, -9.60558001e-03f, 4.71094400e-02f,
  -4.62561287e-02f, -7.68662337e-03f, -1.13938637e-01f, -6.07044026e-02f, 9.53567922e-02f, -3.27483937e-03f, -1.77271478e-02f, -1.93411801e-02f, 1.17125986e-02f, -3.41748856e-02f,
  -1.00463778e-01f, -1.32207442e-02f, -2.16400057e-01f, -8.15317109e-02f, -1.91712938e-02f, -3.77212644e-01f, -2.64841825e-01f, -6.62555173e-02f, -2.27259174e-02f, -7.99212009e-02f,
  -2.27573141e-01f, 7.23784417e-02f, 1.44682944e-01f, -1.59230009e-01f, 1.32156059e-01f, 1.00774817e-01f, -2.93411762e-01f, -2.29525536e-01f, 1.45072833e-01f, -1.14310578e-01f,
  -2.53261887e-02f, -1.91092908e-01f, -4.29878756e-02f, 8.60304236e-02f, -2.09702358e-01f, -4.17884737e-02f, 7.61461407e-02f, -5.70274778e-02f, -1.44884810e-01f, -1.27379801e-02f,
  -9.56115648e-02f, -2.18262523e-01f, -1.85146391e-01f, -8.67987052e-02f, -1.20435543e-01f, -8.53281319e-02f, -1.44775007e-02f, -5.13170324e-02f, -6.52799308e-02f, -8.41865258e-04f,
  5.95267005e-02f, 4.60960530e-02f, 4.57067452e-02f, 3.04500666e-02f, 7.75705874e-02f, -8.47514421e-02f, -4.87836413e-02f, -9.94173810e-03f, -8.06967691e-02f, 5.68677746e-02f,
  4.40615080e-02f, 3.47395912e-02f, -1.90467313e-01f, 6.98173698e-03f, -3.95390689e-02f, -3.25956866e-02f, -1.23778805e-02f, 6.13158122e-02f, -1.11610375e-01f, -1.64682046e-01f,
  -3.90713550e-02f, -3.39967348e-02f, -4.94818836e-02f, -1.83274485e-02f, -8.23868662e-02f, 2.13906970e-02f, -1.09798387e-02f, 3.43390629e-02f, -7.08108023e-02f, -2.14972347e-02f,
  9.23949014e-03f, 1.38084143e-02f, 2.92674061e-02f, 3.91824581e-02f, -8.80412459e-02f, 6.87204003e-02f, -4.48709205e-02f, -4.45987855e-04f, 6.33789599e-02f, -3.62034887e-04f,
  -2.74367146e-02f, -8.45572874e-02f, -1.27491662e-02f, -6.52479306e-02f, -6.14964729e-03f, 5.34430407e-02f, 1.06745157e-02f, 2.95309070e-02f, -2.09155157e-02f, -2.86148489e-02f,
  -3.56282778e-02f, -2.79177874e-01f, -4.88209957e-03f, -3.05090547e-02f, 7.19103664e-02f, -5.07141761e-02f, -4.72273305e-03f, 8.03763717e-02f, -2.71766223e-02f, -1.07955253e-02f,
  -1.82667792e-01f, 3.74812121e-03f, 2.32196935e-02f, 6.63047433e-02f, 5.57014197e-02f, -4.64091413e-02f, 2.79325191e-02f, 4.86869700e-02f, 4.45819311e-02f, 6.72409236e-02f,
  3.34695093e-02f, -1.66787151e-02f, -1.54221915e-02f, -2.35125124e-02f, -9.81960967e-02f, -8.45678225e-02f, -1.15803797e-02f, 1.36853056e-02f, -6.84925467e-02f, 7.91706741e-02f,
  -2.05283597e-01f, 8.87750760e-02f, -8.84228051e-02f, -9.50735733e-02f, -2.13153273e-01f, -5.99068515e-02f, 2.70913020e-02f, -7.17191324e-02f, 3.82347628e-02f, 1.41754657e-01f,
  1.25479877e-01f, -5.97955436e-02f, 1.91238776e-01f, 8.12842846e-02f, -2.91870665e-02f, 1.37656644e-01f, 3.57508399e-02f, -3.23385559e-02f, -3.74771431e-02f, -1.34931996e-01f,
  -6.88928440e-02f, -4.08055931e-02f, -2.26992257e-02f, 3.82629852e-03f, -1.57914251e-01f, -8.56309757e-02f, 2.44201012e-02f, -3.79047543e-02f, -3.13741155e-02f, 1.79189034e-02f,
  -1.30676150e-01f, -1.37943178e-01f, -3.19698304e-02f, -2.35672109e-02f, -1.38635218e-01f, -4.47313115e-02f, -5.71630783e-02f, -9.21379998e-02f, -2.25738846e-02f, -9.23487470e-02f,
  1.83092225e-02f, -5.82966991e-02f, 3.73987816e-02f, 1.69861149e-02f, 3.38411741e-02f, -2.62291580e-02f, 8.37202091e-03f, -3.24750766e-02f, -4.76265466e-03f, 2.10153293e-02f,
  2.17180327e-02f, -3.50327864e-02f, 7.53600076e-02f, 9.96743422e-03f, 9.25728157e-02f, -2.53695976e-02f, -1.07785814e-01f, -3.70505713e-02f, -1.39319738e-02f, 3.52080874e-02f,
  4.57650460e-02f, -5.98514527e-02f, 7.40749016e-02f, -1.14132988e-03f, 6.00595474e-02f, -5.57986759e-02f, 6.78726807e-02f, -9.15128961e-02f, 6.80694133e-02f, -3.38489860e-02f,
  6.49651140e-02f, 6.93853274e-02f, 7.49519980e-03f, 2.14190409e-02f, 7.47016668e-02f, -3.53157148e-02f, -1.34837069e-03f, -1.52069395e-02f, 9.13898125e-02f, -5.22476248e-02f,
  6.95483908e-02f, 5.14057577e-02f, -1.50635457e-02f, 6.60399869e-02f, 1.68647096e-02f, -4.52063233e-02f, -5.62934130e-02f, -7.45168328e-02f, 1.25552550e-01f, -1.25937015e-02f,
  -1.36133671e-01f, -1.72405258e-01f, -7.01528266e-02f, 5.13063967e-02f, -6.43275455e-02f, -9.77137387e-02f, -1.78564265e-02f, -8.86970386e-02f, 2.55624168e-02f, -1.63476486e-02f,
  -9.51468498e-02f, 4.98363748e-02f, -5.90037927e-02f, 6.06224649e-02f, 8.40738565e-02f, 5.14072105e-02f, -1.05453342e-01f, 7.65604142e-04f, -1.32560311e-02f, 2.88169123e-02f,
  1.17579736e-02f, -4.59082276e-02f, -3.27820219e-02f, -2.55530849e-02f, 6.47063330e-02f, -7.75945326e-03f, -8.28219056e-02f, -4.10166644e-02f, -1.13421865e-01f, -3.57828732e-03f,
  -7.65731633e-02f, -5.95298447e-02f, -1.47114312e-02f, -5.93600459e-02f, -4.77725342e-02f, -2.91088154e-03f, 3.32494304e-02f, 1.24609448e-01f, 1.06109940e-02f, 3.45293023e-02f,
  2.24089734e-02f, 4.59810942e-02f, -4.83955635e-04f, -6.52924180e-02f, -8.19887444e-02f, -3.70118208e-02f, -1.32033437e-01f, 1.05406819e-02f, -5.45223653e-02f, 3.54197435e-02f,
  -7.49494061e-02f, -1.36621952e-01f, -2.29580197e-02f, -5.78952767e-02f, 5.51621616e-03f, 2.01850813e-02f, 4.19508033e-02f, -6.21725693e-02f, 5.14154397e-02f, -9.15433466e-03f,
  -5.79808354e-02f, 4.52153124e-02f, 1.06843017e-01f, 6.67594522e-02f, 7.32647255e-02f, -2.73950044e-02f, -2.13051797e-03f, -4.57835048e-02f, 6.61085024e-02f, 6.46915659e-02f,
  -1.09020830e-03f, 2.62695877e-03f, 6.50614128e-02f, 3.71468812e-02f, -5.36908172e-02f, 7.34898299e-02f, -1.12067638e-02f, -9.44046304e-03f, -6.95052296e-02f, -7.78196380e-02f,
  -3.38609666e-02f, 4.50543873e-03f, -5.14475219e-02f, 5.30676171e-02f, -1.47867659e-02f, 4.66204509e-02f, 1.47106024e-02f, 6.63955808e-02f, 8.03848822e-03f, -5.39428405e-02f,
  -1.06320255e-01f, 5.79347052e-02f, 2.28976924e-02f, 1.22241797e-02f, 8.09257552e-02f, 3.63395996e-02f, -2.04848871e-02f, 1.47916423e-02f, -4.93923165e-02f, 6.75213113e-02f,
  -4.04734015e-02f, -7.78513355e-03f, -6.34202734e-02f, -8.62660930e-02f, -9.85064209e-02f, 6.14391174e-03f, -4.48768027e-02f, -3.15731876e-02f, 1.78464074e-02f, 9.07755084e-03f,
  3.18103982e-03f, -2.04207711e-02f, 1.20543987e-02f, 1.07981889e-02f, -7.36288205e-02f, -9.50882137e-02f, -1.41599425e-03f, -4.73252125e-02f, 3.14329527e-02f, -7.76535869e-02f,
  4.37167659e-02f, -9.35567021e-02f, -2.07223184e-02f, 4.82946038e-02f, 6.42720684e-02f, -1.23142600e-02f, -6.13963418e-02f, 1.26842260e-02f, -8.10409710e-02f, 1.90467332e-02f,
  6.03160262e-02f, 2.23633740e-02f, -1.57862566e-02f, 8.18585828e-02f, 2.60001980e-03f, -1.73509326e-02f, -4.90035750e-02f, -1.15379699e-01f, -2.55063865e-02f, 6.91591427e-02f,
  -9.39975157e-02f, -3.80263701e-02f, -1.20833926e-02f, -5.54496460e-02f, 5.30455336e-02f, -6.71759173e-02f, -6.61633443e-03f, 1.25997607e-02f, -7.34218359e-02f, -3.42953242e-02f,
  6.72358721e-02f, 1.73924610e-01f, 1.31756619e-01f, 4.06461116e-03f, 7.57264271e-02f, -1.55060947e-01f, -6.98904321e-02f, 6.50210977e-02f, 5.21731079e-02f, 8.47697631e-02f,
  -4.38838564e-02f, 1.17628984e-01f, 6.12659100e-03f, -3.98941804e-03f, -3.50718945e-01f, -1.96270436e-01f, -1.67346790e-01f, -9.91715938e-02f, -3.18804607e-02f, -3.31358127e-02f,
  -1.57149449e-01f, -4.62747142e-02f, -7.98240155e-02f, 1.91132836e-02f, 7.75747523e-02f, 1.24683864e-01f, -2.62027472e-01f, 1.01489954e-01f, -3.25429812e-02f, -4.84382026e-02f,
  -4.31972072e-02f, 2.36230046e-02f, 7.19460770e-02f, 5.46345115e-02f, -2.08960325e-02f, 1.39503842e-02f, -1.26901567e-01f, -1.41059030e-02f, -1.73702352e-02f, -1.70416124e-02f,
  -1.20664109e-02f, -8.89262930e-02f, -1.62604190e-02f, 5.35605252e-02f, 1.13379031e-01f, 7.95625523e-02f, -8.20816378e-04f, 7.52536505e-02f, 1.40817419e-01f, 5.07444032e-02f,
  2.88020330e-03f, 5.35272136e-02f, 2.25897599e-02f, -2.85716709e-02f, -5.37903467e-03f, 3.57553102e-02f, -6.93776179e-03f, 2.66744904e-02f, -1.79941040e-02f, -2.88810637e-02f,
  -5.73006868e-02f, 1.56321414e-02f, 9.37939659e-02f, -3.78164090e-02f, 5.28645962e-02f, -6.69540986e-02f, 6.18916983e-03f, 1.25183277e-02f, -3.17882768e-05f, -6.72964603e-02f,
  -4.90626022e-02f, 2.34262981e-02f, -3.14935786e-03f, 1.05371065e-01f, -8.88717175e-03f, -7.92563055e-03f, -8.08200836e-02f, 5.24692461e-02f, -3.16742212e-02f, 5.48882075e-02f,
  4.92788330e-02f, -7.01230466e-02f, 1.05173908e-01f, 2.22847797e-02f, 6.03482798e-02f, 7.47691765e-02f, 8.61546099e-02f, 5.83234876e-02f, -4.46223021e-02f, -1.00366473e-01f,
  -1.78109139e-01f, -1.06926233e-01f, -1.00588664e-01f, 6.38906285e-02f, -1.86244994e-02f, -8.32278281e-03f, -2.85693258e-02f, 1.11033328e-01f, -9.43520665e-02f, 2.31863335e-02f,
  -2.55618747e-02f, 1.32643236e-02f, -7.49210222e-03f, 2.73003429e-02f, -5.33954948e-02f, -7.74173588e-02f, 4.36486080e-02f, 4.02409612e-04f, 2.34328043e-02f, -7.75662661e-02f,
  3.23485322e-02f, 7.62431475e-04f, -8.60363711e-03f, 7.17071816e-02f, 2.19938122e-02f, 6.86443597e-02f, 7.17333052e-03f, 1.19282966e-02f, -2.25750403e-03f, 7.56856811e-04f,
  1.77053824e-01f, -5.69598861e-02f, -1.00128613e-01f, 6.06408305e-02f, -4.42579612e-02f, -7.36702010e-02f, -4.21874486e-02f, -1.35762822e-02f, -8.39558095e-02f, -1.10566027e-01f,
  1.10080250e-01f, -1.12608701e-01f, 6.81916252e-02f, 1.30702145e-02f, 1.58037424e-01f, -4.35411744e-02f, -3.35853011e-03f, -2.88929157e-02f, 8.82017314e-02f, 3.20348963e-02f,
  8.07385892e-02f, 5.18557206e-02f, 2.94611230e-02f, -1.71556808e-02f, 4.90502780e-03f, 3.35736461e-02f, 8.85339975e-02f, 8.20862316e-03f, -1.48630412e-02f, -7.72671960e-03f,
  2.38928795e-02f, 4.54366915e-02f, -1.02186806e-01f, 5.15142195e-02f, 1.18687205e-01f, -1.84215680e-02f, 3.75620350e-02f, -1.42507756e-03f, -3.85009646e-02f, -1.10372484e-01f,
  -1.17136845e-02f, -5.33853993e-02f, 6.52687326e-02f, 8.27430263e-02f, -1.98249966e-02f, 6.01754896e-02f, -6.52188063e-02f, 1.78260524e-02f, 1.65964607e-02f, -6.84241056e-02f,
  1.85033716e-02f, -2.91454885e-02f, 1.65361725e-02f, 3.32314409e-02f, 3.25492285e-02f, 8.33941624e-02f, 7.23917829e-03f, -4.32096682e-02f, -2.49416614e-03f, -5.01735434e-02f,
  -9.18132253e-03f, 9.21178609e-02f, 6.91880751e-03f, -1.00699335e-01f, -1.07478179e-01f, -1.21211849e-01f, -4.17560749e-02f, 3.80198993e-02f, -6.15435652e-02f, 6.90653995e-02f,
  -1.47421416e-02f, -1.61448698e-02f, -2.36600637e-02f, -1.00892104e-01f, -3.51369992e-04f, 7.37026855e-02f, -9.81823131e-02f, -1.06231071e-01f, -5.39661720e-02f, -1.32703602e-01f,
  6.13858476e-02f, -4.35040854e-02f, -3.74687687e-02f, -1.15328226e-02f, -5.03690317e-02f, -6.36041760e-02f, 1.02688104e-01f, 3.01873349e-02f, -2.47036386e-02f, 3.36163230e-02f,
  -1.74361728e-02f, 1.31523907e-01f, -1.29661426e-01f, 5.38610481e-02f, 1.57642476e-02f, -7.18929917e-02f, -4.26603034e-02f, 2.31813360e-02f, 6.59177452e-02f, -3.70628051e-02f,
  5.43394387e-02f, 7.00215176e-02f, -6.64316416e-02f, 3.12232655e-02f, 4.91663590e-02f, 4.49804477e-02f, -2.56981719e-02f, 7.59530962e-02f, 3.44504081e-02f, 7.48088863e-03f,
  5.27089462e-02f, -1.10377491e-01f, 1.22655541e-01f, 1.15465121e-02f, 2.09964719e-02f, 2.32912274e-03f, 3.00877485e-02f, 6.91587329e-02f, 7.23801702e-02f, 5.57366088e-02f,
  1.00008614e-01f, -4.40047048e-02f, 5.92001677e-02f, 1.78835858e-02f, 8.71272311e-02f, -1.29732797e-02f, 4.40619066e-02f, -1.62077583e-02f, 3.14756185e-02f, 5.99798653e-03f,
  -2.97369845e-02f, -4.53837536e-04f, -4.14162613e-02f, 8.44529737e-03f, -1.19459564e-02f, -9.50486865e-03f, -6.53092116e-02f, 1.92336105e-02f, 3.21535133e-02f, -1.03556588e-01f,
  7.68125802e-02f, -2.35604309e-03f, -6.04356267e-03f, 1.01046339e-01f, -8.33417028e-02f, 4.96839024e-02f, -4.40722704e-02f, -5.87659441e-02f, -1.22029126e-01f, 8.72427896e-02f,
  6.35306910e-02f, 3.93342115e-02f, 9.34358835e-02f, -7.87391290e-02f, -9.54310149e-02f, 3.01026031e-02f, -8.38652551e-02f, -1.78781357e-02f, -1.35121197e-02f, -4.54377308e-02f,
  6.60044625e-02f, 6.79491311e-02f, -1.01132587e-01f, 5.05471379e-02f, 9.46279913e-02f, 1.76026858e-02f, -1.14770895e-02f, -2.85069831e-02f, -7.48169571e-02f, 5.29150814e-02f,
  3.20745707e-02f, -3.59236598e-02f, 3.68792564e-02f, -4.95659523e-02f, 7.99255669e-02f, 3.24628651e-02f, 9.33577307e-03f, 2.55019143e-02f, -7.78020918e-02f, 4.88984026e-02f,
  5.66553436e-02f, -2.73320992e-02f, 7.14932904e-02f, -6.75890818e-02f, -3.66973504e-02f, -7.55019560e-02f, -7.09835514e-02f, 5.40912040e-02f, 5.76749705e-02f, 3.34408209e-02f,
  5.91120459e-02f, -1.61950402e-02f, -1.96923129e-03f, 1.14052882e-02f, -3.87988277e-02f, 5.57538532e-02f, -6.27914909e-03f, -7.02725053e-02f, -1.31679503e-02f, -3.25037763e-02f,
  -3.75582762e-02f, 8.34062323e-02f, 8.24785605e-02f, 9.84342396e-02f, 8.54563937e-02f, -1.86521150e-02f, -1.51532227e-02f, -7.03197643e-02f, 6.00809343e-02f, 7.34814256e-02f,
  2.01867186e-02f, -9.04417112e-02f, 5.01971785e-03f, -7.91955590e-02f, 4.12170589e-02f, 4.10399325e-02f, 4.41856608e-02f, -1.07402168e-01f, -1.00670628e-01f, -2.35680398e-02f,
  -5.93692772e-02f, 5.48217027e-03f, -3.85437533e-02f, 5.67299649e-02f, 4.61567827e-02f, 5.69903404e-02f, -1.87889542e-02f, -4.37720418e-02f, 8.14960599e-02f, 2.73319222e-02f,
  4.25651763e-03f, -5.32874987e-02f, 3.44773829e-02f, 8.44870433e-02f, -6.02622367e-02f, 5.15971482e-02f, -7.45222941e-02f, -1.93018727e-02f, 5.33809476e-02f, -4.11740504e-02f,
  1.89707622e-01f, -3.96403186e-02f, 8.44714493e-02f, 1.00897454e-01f, 1.14759050e-01f, 2.33925525e-02f, 8.82799998e-02f, -2.76630968e-02f, 2.41964683e-02f, -1.70681164e-01f,
  -9.09239613e-03f, -1.28013548e-02f, 6.16576383e-03f, -8.49172324e-02f, -5.22213243e-02f, -7.03406781e-02f, 7.03053316e-03f, -5.61709628e-02f, -6.35506213e-02f, -8.73312056e-02f,
  5.60536273e-02f, -4.29793112e-02f, 4.15418148e-02f, 4.11712117e-02f, 1.13369852e-01f, 1.01140449e-02f, -7.71204308e-02f, 9.73057002e-03f, -4.94196117e-02f, 7.36756995e-02f,
  6.43957853e-02f, -6.82660341e-02f, -4.07180190e-02f, 3.89992595e-02f, -1.33940419e-02f, -2.99780909e-03f, -2.87508033e-02f, 3.50143611e-02f, 8.37803334e-02f, -9.92480367e-02f,
  4.14296947e-02f, 5.11947386e-02f, -2.74115824e-03f, -1.29307276e-02f, -9.33322981e-02f, -6.39225692e-02f, 5.60438558e-02f, -1.17905578e-02f, 3.54184024e-02f, -4.58985232e-02f,
  -1.20347999e-02f, -4.75915037e-02f, 6.69997931e-02f, -4.65566330e-02f, 7.31147006e-02f, 8.72557014e-02f, 1.53601868e-03f, 7.17642810e-03f, 3.56953181e-02f, 9.03659612e-02f,
  -7.40469918e-02f, 2.02349853e-02f, 9.48769599e-03f, -6.41712695e-02f, -5.77107593e-02f, 3.30574363e-02f, -7.58661181e-02f, 6.37109354e-02f, 5.31351566e-02f, -7.35009089e-02f,
  -1.65540222e-02f, -6.63125217e-02f, 6.15818612e-02f, -6.72383159e-02f, 8.43725353e-02f, 3.33642736e-02f, -4.63845162e-03f, 3.26269232e-02f, 1.61901559e-03f, 2.21954435e-02f,
  6.70014396e-02f, -7.85205588e-02f, 5.46029247e-02f, 7.20035704e-03f, 4.53089960e-02f, -6.00059330e-02f, 8.84052366e-03f, 4.72538397e-02f, -1.95861105e-02f, -8.32934231e-02f,
  -7.29917735e-02f, -1.25252485e-01f, -4.26563211e-02f, 6.27740771e-02f, -6.79657832e-02f, -1.16325855e-01f, -4.06601839e-03f, -2.72128899e-02f, -1.44353183e-02f, -7.21210986e-02f,
  6.45288303e-02f, -8.98265913e-02f, 2.87790652e-02f, 7.42905810e-02f, -8.00820254e-03f, -1.23150967e-01f, -1.98424123e-02f, -1.04924470e-01f, -6.46489337e-02f, -3.61272655e-02f,
  -6.47758087e-03f, 2.24197097e-03f, 2.55945269e-02f, 7.86653385e-02f, 7.42393583e-02f, 6.42492175e-02f, -1.82978585e-02f, 6.08839132e-02f, -7.68896714e-02f, -1.99833401e-02f,
  4.34396081e-02f, -7.65038803e-02f, -1.62134338e-02f, 1.82982683e-02f, 7.07102241e-03f, -1.49554074e-01f, -5.34755439e-02f, 1.01801820e-01f, 3.45728695e-02f, -2.09198520e-02f,
  2.88941395e-02f, 6.47429228e-02f, -5.58135286e-02f, 7.13491738e-02f, 4.47163470e-02f, -1.39635533e-01f, -1.14035839e-02f, -1.12464547e-01f, 8.98760781e-02f, 1.48287773e-01f,
  3.66798136e-04f, 4.10896614e-02f, -4.33092639e-02f, 8.53189752e-02f, 2.18715883e-04f, 4.01422605e-02f, 1.71040580e-01f, 3.49771231e-02f, 1.26048565e-01f, 7.39315599e-02f,
  -1.30493632e-02f, 9.93077457e-02f, 1.78347751e-02f, -3.10148802e-02f, 7.11405352e-02f, -5.19148558e-02f, 6.90115541e-02f, -4.74713072e-02f, -6.31829351e-02f, 1.03431623e-02f,
  -1.17560057e-02f, -6.20954111e-02f, -3.57399769e-02f, -2.59757489e-02f, 9.59453806e-02f, 8.36349577e-02f, 7.58580863e-02f, -5.05070686e-02f, -6.12051450e-02f, 1.37991533e-02f,
  8.54600314e-03f, 2.36642882e-02f, 6.01954907e-02f, -3.34901065e-02f, -5.33348061e-02f, -2.67616147e-03f, -8.07228498e-03f, 3.51112373e-02f, 3.12034320e-02f, -1.37728099e-02f,
  6.46905676e-02f, -1.47161754e-02f, -1.41149731e-02f, -3.88057083e-02f, -9.35411379e-02f, -2.20402014e-02f, -6.93700314e-02f, -6.57813274e-04f, -6.74427897e-02f, -5.35209849e-02f,
  1.71537362e-02f, -6.73556775e-02f, 2.79293843e-02f, -7.56265223e-02f, 3.04897763e-02f, -4.87947464e-02f, -9.18677673e-02f, -6.03212789e-02f, -3.88172306e-02f, -4.00216132e-02f,
  8.38817731e-02f, 3.29675749e-02f, -3.38091403e-02f, 4.92366543e-03f, -7.15781422e-03f, -3.04947235e-02f, 7.65209720e-02f, 4.68850769e-02f, 3.48426290e-02f, 4.27932553e-02f,
  3.29288840e-02f, 6.99704140e-02f, 3.87797430e-02f, -7.93724880e-02f, 1.65715348e-02f, 7.18255565e-02f, 5.88621162e-02f, 2.90626800e-03f, -4.17158455e-02f, -1.08376937e-02f,
  7.53415329e-03f, 1.18551012e-02f, -1.08187869e-01f, -2.61022728e-02f, -4.31542546e-02f, 5.18049998e-03f, 7.45541081e-02f, -2.51448601e-02f, -4.86060902e-02f, -6.36502495e-03f,
  1.05673693e-01f, 6.80303201e-02f, 9.87630188e-02f, 2.18052808e-02f, -3.30216251e-02f, 9.79990810e-02f, 2.74017695e-02f, 7.74634704e-02f, -6.64237067e-02f, -1.29013546e-02f,
  -5.66586256e-02f, 8.16109404e-02f, 1.87944416e-02f, -6.65179566e-02f, -1.10883750e-01f, -1.46856368e-01f, -2.24707171e-01f, 4.86774929e-02f, 3.62507254e-02f, 1.00113764e-01f,
  -1.07331567e-01f, 1.72891408e-01f, -2.81056669e-02f, -2.27386188e-02f, -2.53986269e-01f, -1.31046489e-01f, -2.00281635e-01f, -1.23869263e-01f, -9.69268978e-02f, -9.60086584e-02f,
  -5.66188507e-02f, -4.79542054e-02f, -1.83923811e-01f, -1.24233412e-02f, 5.19492403e-02f, 9.97684821e-02f, -4.56597842e-02f, 1.39682591e-01f, 1.19152591e-02f, 1.08075533e-02f,
  -3.06281950e-02f, 8.15873966e-02f, 8.07992667e-02f, 2.15122532e-02f, -5.57844564e-02f, -5.87832853e-02f, -9.07512903e-02f, 2.29018703e-02f, -2.15652548e-02f, -1.18026309e-01f,
  -3.29150558e-02f, -1.60260331e-02f, -7.15329498e-03f, -5.60507998e-02f, 1.96552780e-02f, 1.00964621e-01f, 5.86962923e-02f, -2.08936110e-02f, -5.54521680e-02f, 6.28218502e-02f,
  6.59853518e-02f, -6.75653294e-02f, -9.11191944e-03f, 3.70625556e-02f, -9.61265862e-02f, -1.67720150e-02f, -1.98586415e-02f, -5.41475229e-02f, -3.22924368e-02f, -6.45491034e-02f,
  1.97907444e-02f, 7.10145980e-02f, -3.06819975e-02f, 8.84682685e-02f, 9.85785481e-03f, -2.47546174e-02f, 9.85298604e-02f, 6.65002465e-02f, 5.22228666e-02f, 3.26930499e-03f,
  4.11936156e-02f, 8.41655433e-02f, -1.66237622e-03f, -7.71170110e-02f, -5.04425820e-03f, 2.61170194e-02f, 1.36337085e-02f, 6.97962940e-02f, 2.16374360e-02f, -6.10892884e-02f,
  -4.86435406e-02f, 4.69356179e-02f, -2.26372350e-02f, 9.19717699e-02f, -7.19890445e-02f, 6.24472164e-02f, -6.42074049e-02f, -1.03620552e-01f, 7.76158273e-02f, 3.14949639e-02f,
  -6.63846657e-02f, -1.54616293e-02f, -6.03748336e-02f, 3.75583172e-02f, 1.70435756e-02f, -8.42656046e-02f, -6.15028385e-03f, 4.67625074e-02f, -1.05013764e-02f, -6.48627849e-03f,
  5.81524931e-02f, 4.49405648e-02f, -8.26539621e-02f, 2.08260324e-02f, -3.05859349e-03f, -7.55552156e-03f, -4.67291586e-02f, -1.10147849e-01f, 2.34156381e-02f, -3.09294239e-02f,
  -7.28882253e-02f, -5.42035736e-02f, -2.35070307e-02f, -6.51432872e-02f, -5.78965433e-02f, -2.24024300e-02f, 5.70851825e-02f, 2.12107003e-02f, -5.39983772e-02f, -5.32945655e-02f,
  1.52447939e-01f, -5.25753060e-03f, -6.98742783e-03f, -1.18735462e-01f, -4.80930097e-02f, -3.41076287e-03f, -4.95644938e-03f, 1.61318236e-03f, 6.36068657e-02f, -1.25393286e-01f,
  -8.12175199e-02f, 1.33991778e-01f, 6.40935674e-02f, -1.67236090e-01f, 2.18342721e-01f, 1.29572943e-01f, -1.15044519e-01f, -3.83344963e-02f, 1.02097906e-01f, -2.72209663e-03f,
  -4.35096994e-02f, -6.97099939e-02f, 8.77120346e-02f, -9.12075117e-02f, -6.60912022e-02f, -1.11865222e-01f, -1.56099692e-01f, -3.63632925e-02f, -2.02878669e-01f, -6.20252155e-02f,
  -1.87062155e-02f, 2.30708271e-02f, 1.21947758e-01f, -2.58436427e-04f, 1.00802399e-01f, 1.30911469e-02f, 3.94731425e-02f, 1.25145450e-01f, -6.49788901e-02f, 7.07117170e-02f,
  -4.22580028e-03f, -7.71412849e-02f, -3.11007388e-02f, 9.66553688e-02f, -5.10283448e-02f, 4.72277217e-02f, 5.31147793e-02f, -6.15525320e-02f, -6.15107864e-02f, 7.69832656e-02f,
  1.01281285e-01f, 1.39963124e-02f, 7.72049055e-02f, -4.54031602e-02f, 1.48612754e-02f, -3.83677743e-02f, 6.67724609e-02f, 4.39939238e-02f, -3.71768810e-02f, 3.77160385e-02f,
  -5.11431694e-02f, -4.23893034e-02f, -1.93997789e-02f, -4.41172719e-02f, 1.48863038e-02f, -7.07012117e-02f, 7.71649629e-02f, 9.73299444e-02f, -2.20781565e-02f, 5.77823035e-02f,
  4.92768711e-04f, -1.10641709e-02f, 6.68011140e-03f, -7.66352983e-03f, 5.62871993e-02f, 5.03296554e-02f, -2.36357041e-02f, -2.28838921e-02f, -6.48939461e-02f, -2.27946416e-02f,
  -4.23471211e-03f, -3.87554094e-02f, 3.94564457e-02f, -1.07620262e-01f, -5.71427904e-02f, -4.67462204e-02f, 3.67173739e-02f, -8.34993720e-02f, 1.48048736e-02f, 2.13793162e-02f,
  5.94094507e-02f, 2.52178553e-02f, 1.13332517e-01f, 6.55681789e-02f, -2.93795113e-02f, -7.00567067e-02f, 7.77888298e-02f, 2.76636109e-02f, 3.68522331e-02f, 5.52492682e-03f,
  3.15885618e-02f, 7.90077820e-02f, 1.02401376e-02f, 4.11298349e-02f, -2.10775193e-02f, 3.79958116e-02f, -3.48022170e-02f, 6.64014667e-02f, -6.87454641e-02f, -6.32956401e-02f,
  -3.11489478e-02f, 1.00133963e-01f, 1.01990074e-01f, 7.28435963e-02f, 4.35705297e-02f, -1.07454784e-01f, -3.87422107e-02f, -8.83785188e-02f, 2.62302142e-02f, 7.96543956e-02f,
  4.49784398e-02f, 2.74797738e-01f, 2.00066015e-01f, 1.16364755e-01f, -1.46318138e-01f, -2.74231315e-01f, -2.72760183e-01f, 4.81829681e-02f, -1.57221835e-02f, 4.89645917e-03f,
  -1.04546085e-01f, 1.04132332e-01f, 1.15019567e-02f, -8.05431232e-03f, -1.73159033e-01f, -1.16789356e-01f, -1.28463283e-01f, -5.80890551e-02f, -8.40948373e-02f, 3.23384441e-02f,
  -3.38938064e-03f, 9.81965382e-03f, 1.21980041e-01f, 1.37054339e-01f, -2.32870560e-02f, 2.60875702e-01f, 3.60705182e-02f, 6.96413144e-02f, 9.92651805e-02f, -8.61033574e-02f,
  -1.15263894e-01f, 8.98378715e-02f, 5.87930046e-02f, -7.24715069e-02f, -6.67380227e-04f, 4.32625823e-02f, 8.99896696e-02f, -6.17237687e-02f, 2.31308900e-02f, 1.01293094e-01f,
  5.65253943e-02f, -2.01782840e-03f, 1.18667610e-01f, -6.49725199e-02f, -2.81337053e-02f, -2.45411936e-02f, 1.01641588e-01f, 1.07461810e-01f, 1.90489665e-02f, 4.68923151e-02f,
  1.29858479e-01f, 6.80892635e-03f, 2.76777130e-02f, -3.00471261e-02f, 4.66151237e-02f, -1.87185388e-02f, 5.52670285e-02f, 1.74456723e-02f, 1.28127843e-01f, -8.41274450e-04f,
  1.07639758e-02f, 1.39512178e-02f, -4.89982367e-02f, 1.89015083e-02f, 1.85854938e-02f, -4.92453546e-05f, 3.06649171e-02f, 1.98408086e-02f, -5.88224083e-03f, -4.63067479e-02f,
  -4.27122340e-02f, 2.58627860e-03f, -6.17397577e-02f, -6.11710967e-03f, 5.51799536e-02f, -3.16387303e-02f, 6.81265071e-02f, -4.93627265e-02f, -2.82780882e-02f, 3.50122005e-02f,
  -4.13839705e-02f, -1.76070929e-02f, 5.87716661e-02f, -4.76259775e-02f, -2.16727462e-02f, 8.74088854e-02f, -6.22377060e-02f, 3.07120546e-03f, 5.65007795e-03f, -3.36911269e-02f,
  -1.54836178e-01f, 1.33345276e-01f, 7.75450841e-02f, -7.37558603e-02f, 2.10266765e-02f, 1.13324018e-03f, 5.46984449e-02f, 4.82604429e-02f, -3.05928774e-02f, -5.98788299e-02f,
  9.46403965e-02f, -1.79443061e-02f, -5.38447388e-02f, 3.99862044e-02f, 5.20173721e-02f, -3.96350846e-02f, -5.76819405e-02f, 5.32641709e-02f, 1.27479434e-01f, 3.04039964e-03f,
  1.17662162e-01f, 9.84590054e-02f, -2.67445631e-02f, -6.85457587e-02f, 6.71271160e-02f, 6.56823590e-02f, 7.14340135e-02f, 3.55280079e-02f, 2.09262613e-02f, -7.74218934e-03f,
  1.67697042e-01f, 1.11728255e-02f, 5.40334843e-02f, 3.28920670e-02f, 2.07459163e-02f, 1.91545021e-02f, -1.00557983e-01f, -5.15928306e-02f, -1.80205062e-03f, -1.07432306e-01f,
  -8.22081789e-02f, -9.61976424e-02f, -1.50855690e-01f, 3.73675637e-02f, -8.05745050e-02f, -1.05137557e-01f, -9.26888827e-03f, -1.01617113e-01f, -2.39726845e-02f, 9.47098306e-04f,
  -3.77284996e-02f, 8.92110839e-02f, 7.07450286e-02f, -4.53646705e-02f, 7.21808970e-02f, 4.32663709e-02f, -4.49470542e-02f, -8.48726705e-02f, 1.34282243e-02f, 1.87574401e-02f,
  -1.34339603e-02f, -3.71742547e-02f, 8.14244896e-02f, -6.30938634e-02f, 1.36696100e-02f, -3.21364105e-02f, 8.00037533e-02f, -1.35683995e-02f, 7.11370334e-02f, -5.62686399e-02f,
  -3.29847857e-02f, -7.52042830e-02f, -7.97446147e-02f, -1.65874517e-04f, 5.44444732e-02f, -4.55187708e-02f, 2.23780870e-02f, 6.31857589e-02f, -2.58530583e-03f, 1.33309718e-02f,
  -4.11315588e-03f, -8.81635621e-02f, 5.00879996e-02f, -2.59788334e-02f, 6.18967898e-02f, -5.20736054e-02f, 3.32887694e-02f, 8.22286382e-02f, 1.51670100e-02f, -5.56620955e-02f,
  -1.84628032e-02f, -5.30052371e-02f, -9.02388021e-02f, -9.73417424e-03f, 4.38624881e-02f, 6.23926632e-02f, 3.98219451e-02f, 4.59002219e-02f, 8.69028121e-02f, -1.78850684e-02f,
  6.95000514e-02f, -3.12383603e-02f, -4.19560969e-02f, 6.90779164e-02f, -2.45042332e-02f, -5.00316545e-02f, 8.46732482e-02f, 1.01198226e-01f, 7.68099278e-02f, -4.61054005e-04f,
  -3.05092633e-02f, -5.39938845e-02f, -4.28476669e-02f, -4.24363352e-02f, 7.05932081e-02f, 8.02541822e-02f, -7.97106624e-02f, 5.17824069e-02f, 8.02207887e-02f, -8.71939138e-02f,
  -6.55919313e-02f, -9.22786351e-03f, 1.71497278e-02f, -9.46356542e-03f, -8.49692598e-02f, 2.72405948e-02f, -5.85919060e-02f, 4.11722586e-02f, 6.79410398e-02f, 5.01600616e-02f,
  -8.31030402e-03f, 9.38468948e-02f, -9.85489711e-02f, -2.86533311e-02f, 5.40700927e-02f, -6.15009712e-03f, 1.16831167e-02f, 6.08959198e-02f, 2.76674386e-02f, -9.62284654e-02f,
  6.71776384e-02f, 5.14113270e-02f, -4.25858311e-02f, 2.57849433e-02f, 8.39427039e-02f, -8.75900239e-02f, -7.78224692e-02f, -1.43290367e-02f, -2.64467485e-02f, -6.58246875e-03f,
  -5.97955137e-02f, 1.03306314e-02f, -2.67722290e-02f, -2.21248791e-02f, -7.47253522e-02f, -7.19061643e-02f, -1.13205940e-01f, -6.51489124e-02f, -3.94934937e-02f, 1.32377490e-01f,
  9.15533155e-02f, 8.82790759e-02f, -2.89277881e-02f, 2.15539746e-02f, 7.51912817e-02f, 2.30360683e-03f, -3.28433402e-02f, 8.59063491e-02f, -1.18676503e-03f, -3.30086499e-02f,
  -8.17203615e-03f, 2.21193228e-02f, -2.80705150e-02f, 5.08216722e-03f, -1.96360680e-03f, -8.96073058e-02f, 7.01343492e-02f, -5.18399477e-02f, 5.32934554e-02f, 9.77807716e-02f,
  3.92482504e-02f, -5.62567711e-02f, 3.02587915e-02f, -8.27372670e-02f, 6.28793687e-02f, 1.59891823e-03f, -8.80720317e-02f, -6.23105578e-02f, -2.31340025e-02f, 4.90905344e-02f,
  7.74247199e-02f, 4.31689844e-02f, 6.65214285e-02f, -5.69010824e-02f, 2.76620537e-02f, -3.44983041e-02f, -8.16754848e-02f, 3.20259891e-02f, 5.80260679e-02f, -4.44393186e-03f,
  -9.15777162e-02f, 5.13236225e-02f, -8.39977786e-02f, 2.92808525e-02f, -9.90337729e-02f, 3.39961261e-03f, 2.06281897e-02f, 4.88096997e-02f, -5.85397296e-02f, -5.32854907e-02f,
  -2.25153975e-02f, 9.12744477e-02f, 4.59406525e-02f, -7.74633661e-02f, -1.06853068e-01f, 4.59839031e-02f, 5.48892934e-03f, -1.07232809e-01f, 6.68835342e-02f, -1.54482154e-03f,
  4.60403189e-02f, 1.03589613e-02f, 6.94354847e-02f, 6.17238916e-02f, -3.74736008e-03f, -2.20335927e-02f, -5.34525625e-02f, 6.24697655e-02f, -3.51159424e-02f, 1.40659131e-06f,
  7.20337406e-02f, 2.63945269e-03f, -7.76456967e-02f, 6.77469522e-02f, -4.46142107e-02f, -2.15806644e-02f, 7.14108869e-02f, -5.75573668e-02f, 4.02835906e-02f, -3.30404043e-02f,
  7.67145082e-02f, 9.32578817e-02f, -2.82829348e-02f, -2.25393027e-02f, 1.46521730e-02f, -4.90969494e-02f, -5.41126467e-02f, 3.00882813e-02f, -8.17489065e-03f, -4.47658338e-02f,
  6.97666488e-04f, 2.70788111e-02f, 4.26832289e-02f, 3.75123583e-02f, -4.65169996e-02f, -7.70058110e-02f, -2.94695403e-02f, -3.05257365e-02f, 1.36598982e-02f, -1.67058352e-02f,
  -4.24876474e-02f, -5.82005410e-03f, 3.41858007e-02f, 5.83412200e-02f, 9.51083004e-02f, -6.41840175e-02f, -6.45347163e-02f, -2.56163310e-02f, 6.99871406e-02f, 9.13487896e-02f,
  1.92568138e-01f, 1.00095525e-01f, 1.59212396e-01f, 6.52330816e-02f, -9.36806798e-02f, -3.13335568e-01f, -2.34309420e-01f, 1.32002542e-02f, -9.83540118e-02f, -1.01807341e-01f,
  8.04951116e-02f, -6.24830797e-02f, 2.40401831e-02f, -9.47944000e-02f, 5.89296184e-02f, -2.39331182e-02f, -5.49131483e-02f, -1.44506827e-01f, -6.60613775e-02f, 1.12200901e-01f,
  1.33657858e-01f, -3.88453938e-02f, 2.04487264e-01f, 8.78912136e-02f, -2.86891796e-02f, 2.15737328e-01f, 6.28440827e-02f, -4.77719028e-03f, 8.68782103e-02f, -6.05661236e-02f,
  -9.31816101e-02f, 4.06606868e-02f, 6.22362569e-02f, 1.88149698e-02f, 4.60394006e-03f, 8.31970852e-03f, -5.13726287e-02f, -1.43033564e-01f, 5.01830317e-02f, -5.60460016e-02f,
  1.97171960e-02f, 6.54911846e-02f, -1.16409838e-01f, -2.70535983e-02f, -5.62337898e-02f, -8.85507613e-02f, 1.66419130e-02f, 8.83067921e-02f, 2.91629937e-02f, -2.72752754e-02f,
  2.30766293e-02f, -7.49247223e-02f, -7.91949332e-02f, 1.36123803e-02f, 1.26429871e-01f, -2.06571668e-02f, 7.77390692e-03f, 3.00868358e-02f, 2.09145783e-03f, 6.68207649e-03f,
  2.95211114e-02f, 7.69728795e-03f, 6.52189851e-02f, 4.74730618e-02f, 2.07410082e-02f, -2.94951703e-02f, -5.30732870e-02f, -1.21415127e-02f, 2.46676598e-02f, -2.28683706e-02f,
  -3.26749459e-02f, -3.70620564e-02f, -4.38075364e-02f, 6.67528361e-02f, -1.09525165e-02f, -2.71548126e-02f, -5.03116138e-02f, 9.95210111e-02f, 3.05002909e-02f, 2.23838240e-02f,
  -1.46120805e-02f, -4.27718420e-04f, -3.15440595e-02f, 1.50130587e-02f, 9.21603292e-03f, 7.76601210e-03f, 6.99539110e-02f, 6.51878119e-02f, 9.43075567e-02f, 3.06236707e-02f,
  9.32639241e-02f, 1.87785372e-01f, -7.69936200e-03f, -7.55526125e-02f, -3.94758172e-02f, -4.47811850e-04f, -4.91999276e-02f, 2.12122481e-02f, 1.32720947e-01f, 7.50826448e-02f,
  -3.61293368e-02f, 4.39052330e-03f, 3.69064100e-02f, 4.31502126e-02f, 6.30458295e-02f, -4.29630503e-02f, 8.60726237e-02f, -1.46001047e-02f, -4.06883992e-02f, 4.21349555e-02f,
  2.61907391e-02f, -8.31955448e-02f, 5.50263040e-02f, -2.61394456e-02f, 1.72230471e-02f, -5.64454645e-02f, -1.60657745e-02f, 7.64771551e-02f, -3.81320380e-02f, 5.05706631e-02f,
  -5.08622639e-02f, -7.29112700e-02f, -2.32899323e-01f, 2.09825709e-02f, 6.11627009e-03f, -2.09027871e-01f, -1.28325179e-01f, -9.29956064e-02f, -6.16885386e-02f, 1.19450226e-01f,
  9.04499553e-03f, 2.48990748e-02f, 5.46344295e-02f, -1.26356512e-01f, -3.21945250e-02f, 4.55880687e-02f, -2.38334443e-02f, 3.54974344e-02f, -2.21514720e-02f, -5.40459454e-02f,
  6.44443631e-02f, -6.46378472e-03f, -7.16091841e-02f, -6.88717887e-02f, -1.67638242e-01f, -2.87071522e-02f, 8.86462480e-02f, 4.06122357e-02f, -6.55172393e-02f, 3.45478468e-02f,
  7.76439905e-02f, 4.50582430e-02f, -2.73149796e-02f, 1.18248416e-02f, 1.89367831e-02f, -3.54023688e-02f, 2.31797770e-02f, -5.80711709e-03f, 6.83098435e-02f, 3.26046278e-03f,
  -3.51597369e-02f, 6.32393211e-02f, -2.29628347e-02f, 5.37638627e-02f, 2.26100883e-03f, -7.89623931e-02f, -6.11041731e-04f, 8.84577781e-02f, -9.51008219e-03f, -9.85413119e-02f,
  -3.36088352e-02f, -7.14073405e-02f, -5.67738265e-02f, 1.02384351e-01f, -1.84767076e-03f, 1.45167075e-02f, -7.70097375e-02f, 6.62860721e-02f, 6.98362067e-02f, 3.28269228e-02f,
  -2.67715026e-02f, -4.17474397e-02f, -3.53767499e-02f, 4.31502890e-03f, -1.83103401e-02f, 7.75020644e-02f, -4.13120724e-02f, -6.51458874e-02f, -5.59858941e-02f, -3.23492587e-02f,
  -3.16983983e-02f, 4.64441553e-02f, -6.56203413e-03f, -1.31041138e-02f, 7.92569369e-02f, -1.31050786e-02f, -1.91414300e-02f, -1.14771789e-02f, 1.09031284e-02f, 7.22738728e-02f,
  4.23747450e-02f, -1.81022771e-02f, -2.05429699e-02f, 3.58008295e-02f, -8.78442526e-02f, -7.91411474e-02f, 5.57400584e-02f, -4.71206903e-02f, 1.78972017e-02f, -7.27235675e-02f,
  -7.75802284e-02f, 8.49535912e-02f, 2.18411330e-02f, -5.16829863e-02f, -3.61120962e-02f, -3.08475718e-02f, -6.19934015e-02f, -5.93194515e-02f, -3.14530917e-02f, -4.35921066e-02f,
  -1.22662988e-02f, -2.45383233e-02f, -8.47871900e-02f, 4.28853370e-02f, -9.89120267e-03f, 1.48981111e-02f, -7.79301301e-03f, 4.18722071e-02f, -2.94549242e-02f, 7.45995194e-02f,
  -1.86763778e-02f, 7.04118013e-02f, 4.19019647e-02f, -6.65099248e-02f, -4.36302722e-02f, 3.26916836e-02f, 3.74365374e-02f, 1.32269235e-02f, 4.52983268e-02f, -2.22186428e-02f,
  -1.26610994e-01f, 4.73329462e-02f, -9.56633538e-02f, -1.02043532e-01f, 8.13766643e-02f, -1.34614870e-01f, -2.80717341e-03f, 1.28990402e-02f, -1.38884872e-01f, 6.07357919e-02f,
  -2.30873097e-03f, -9.22646895e-02f, 8.17944296e-03f, -1.29913032e-01f, -2.50607371e-01f, -9.90837663e-02f, -1.74194679e-01f, -1.21888705e-01f, -1.07898146e-01f, 6.43014684e-02f,
  -4.85148430e-02f, 3.42594497e-02f, -8.57556239e-02f, 9.50961187e-02f, -2.81725265e-02f, 1.11127868e-01f, 1.13062032e-01f, 1.33642167e-01f, 4.36394103e-02f, -5.70194684e-02f,
  4.95170690e-02f, -4.80015241e-02f, 1.43508185e-02f, 7.77780190e-02f, -2.19127666e-02f, 1.12077862e-01f, 6.45447150e-02f, -6.08956106e-02f, -1.02232788e-02f, 1.99630335e-02f,
  7.10236505e-02f, 4.40521725e-02f, -9.32950303e-02f, 1.24140792e-02f, 9.21706483e-03f, 3.78022827e-02f, -5.31756915e-02f, 6.18698150e-02f, 1.80546232e-02f, -8.02919343e-02f,
  3.62629667e-02f, -9.71008316e-02f, -5.11190929e-02f, -9.54221040e-02f, 4.30304632e-02f, -4.32621278e-02f, -5.53759634e-02f, -3.62092033e-02f, 2.26432011e-02f, -1.07956044e-01f,
  6.63056523e-02f, -8.72047916e-02f, -8.26388672e-02f, 7.50583932e-02f, -6.34867549e-02f, 7.62248933e-02f, -4.28612195e-02f, -3.63404565e-02f, 1.08813494e-02f, 1.15261655e-02f,
  -6.08205795e-02f, 1.15248859e-02f, 3.61861126e-03f, -5.20150773e-02f, -4.92578633e-02f, -2.15651989e-02f, 9.27429274e-02f, -5.89308180e-02f, -3.94888148e-02f, 4.52521406e-02f,
  2.96225064e-02f, 9.85448621e-03f, 8.74722525e-02f, 8.65152776e-02f, -2.56796577e-03f, -2.22805161e-02f, 4.13698032e-02f, -5.89425303e-02f, -2.27161180e-02f, -8.89129117e-02f,
  8.01408589e-02f, 3.62244733e-02f, 6.83423728e-02f, 3.77000459e-02f, 7.64143690e-02f, -9.23444517e-03f, 4.44924869e-02f, -1.32778229e-03f, -2.75236648e-02f, -2.33839843e-02f,
  8.37248415e-02f, 4.47383262e-02f, -6.00031402e-04f, -2.16038264e-02f, 1.83365494e-02f, -6.97938129e-02f, -8.93516187e-03f, -5.90918586e-03f, -1.35529125e-02f, 3.14340964e-02f,
  3.42271365e-02f, -4.18107957e-02f, 1.32502604e-03f, 4.53115664e-02f, 1.81792751e-02f, -2.81163454e-02f, 1.68048274e-02f, -4.42848466e-02f, 3.68406698e-02f, -2.44792253e-02f,
  -8.40236098e-02f, 4.11299318e-02f, -8.25880170e-02f, 8.64644200e-02f, 8.50919709e-02f, -9.35653523e-02f, -7.77543858e-02f, 5.70730567e-02f, -9.58891660e-02f, 3.98971625e-02f,
  1.65367294e-02f, -1.98126957e-02f, 2.28048563e-02f, -6.12700842e-02f, -7.34281316e-02f, -2.94456519e-02f, 2.09875777e-02f, -3.06407176e-02f, -5.18674180e-02f, 4.18503061e-02f,
  5.96605428e-02f, 6.09025657e-02f, -1.54018328e-02f, -3.16158757e-02f, 9.07502919e-02f, 5.68458028e-02f, 8.55945870e-02f, -4.05197823e-03f, 4.91490252e-02f, 7.00360090e-02f,
  -9.50608123e-03f, 5.53029217e-02f, -1.00928321e-02f, 6.39766902e-02f, -4.15236019e-02f, -3.79746445e-02f, -2.15516109e-02f, -2.44067535e-02f, 3.26019037e-03f, -1.74730346e-02f,
  -3.28928903e-02f, -7.09280148e-02f, -5.97343147e-02f, -4.00182232e-02f, -4.98167379e-03f, 7.81659558e-02f, -8.63633901e-02f, 8.26042145e-02f, 9.22151729e-02f, -6.29262030e-02f,
  3.48322876e-02f, 2.54348051e-02f, -1.91786569e-02f, 3.94183137e-02f, 7.27842450e-02f, -8.18105415e-02f, -6.57253340e-02f, -6.07627928e-02f, 8.47681984e-02f, -1.18079642e-03f,
  -4.84177172e-02f, 7.44209662e-02f, -8.10584724e-02f, 1.00983456e-02f, 1.43216606e-02f, 7.96838943e-03f, 3.80870374e-03f, 4.74561527e-02f, -1.30783562e-02f, -3.44489701e-02f,
  8.00656453e-02f, -2.75655091e-02f, 1.41470563e-02f, 1.02782091e-02f, 6.74039200e-02f, 1.04553908e-01f, 1.18987318e-02f, -7.01954961e-02f, 1.07520577e-02f, -6.47372678e-02f,
  2.00327989e-02f, -6.39617816e-02f, -4.51246239e-02f, -1.89095251e-02f, -2.57299691e-02f, -1.12851318e-02f, -3.93909067e-02f, -6.54394329e-02f, 3.49709019e-02f, 7.94588625e-02f,
  -5.10565378e-03f, 1.21563368e-01f, -1.01827435e-01f, 2.48915348e-02f, 1.02706887e-01f, 5.88947386e-02f, 8.53554681e-02f, -6.49665520e-02f, 1.26040755e-02f, -4.23511714e-02f,
  7.97229186e-02f, 5.66634238e-02f, -2.19215434e-02f, -6.33592978e-02f, 7.02071115e-02f, 2.53566578e-02f, -3.77788059e-02f, 4.71492074e-02f, 1.03910051e-01f, 1.22869667e-03f,
  -2.65240446e-02f, -1.29359728e-02f, -1.45364897e-02f, -2.06619278e-02f, -4.68570478e-02f, 8.59490596e-03f, -2.55232863e-02f, 2.55237129e-02f, 1.91399436e-02f, -1.07380119e-03f,
  -6.81408644e-02f, -1.17526449e-01f, -1.57241635e-02f, -1.26440451e-01f, -5.55335842e-02f, -1.91294953e-01f, -8.11096132e-02f, 3.04108337e-02f, 2.48302706e-02f, -7.17193261e-02f,
  -2.10032929e-02f, 6.20657615e-02f, 1.85917411e-02f, -2.79385354e-02f, 5.75757734e-02f, 1.48776755e-01f, -1.88556910e-02f, -2.14748569e-02f, -3.62037942e-02f, -1.32334322e-01f,
  -7.80125782e-02f, -1.48214608e-01f, 9.61504653e-02f, -1.09358072e-01f, -9.86308679e-02f, -4.48376462e-02f, 7.12593570e-02f, -8.69041532e-02f, 2.19596904e-02f, -9.31669548e-02f,
  -9.85444039e-02f, -8.86108205e-02f, -8.36093575e-02f, 7.59194419e-02f, 4.62793782e-02f, 1.26627937e-03f, -5.60610443e-02f, -7.22743645e-02f, 2.34871004e-02f, 4.06220220e-02f,
  6.72926605e-02f, 3.19111012e-02f, 3.84554151e-03f, -8.46184324e-03f, -7.06931800e-02f, -3.22067253e-02f, -1.18837483e-01f, -7.99201652e-02f, -1.79273132e-02f, 3.24777775e-02f,
  4.27214280e-02f, -6.82324544e-02f, -3.41425538e-02f, -1.76463975e-03f, 3.18219997e-02f, 3.04538459e-02f, -1.33675421e-02f, -4.73679863e-02f, 3.27391475e-02f, 4.30853665e-02f,
  -1.04364054e-02f, -3.92409004e-02f, 7.06550851e-02f, 6.41516745e-02f, -3.98654602e-02f, -8.02550390e-02f, 3.85459960e-02f, 5.04376888e-02f, 4.30234484e-02f, -7.88043216e-02f,
  6.81691766e-02f, -2.49330103e-02f, 4.69030775e-02f, 1.22017525e-01f, 5.72811775e-02f, 4.07768749e-02f, -5.32748587e-02f, 8.57325196e-02f, 3.61115597e-02f, 5.01208529e-02f,
  -5.36574461e-02f, -8.64004865e-02f, 4.54526693e-02f, 2.48641102e-03f, -1.25634633e-02f, 5.48876189e-02f, 4.16377634e-02f, 7.54832197e-03f, -8.35079849e-02f, 5.56073561e-02f,
  -6.05310611e-02f, -1.04530819e-01f, -4.81055230e-02f, 3.56183574e-02f, 7.36785755e-02f, 5.02079464e-02f, 2.01399606e-02f, 8.38151760e-03f, 4.84677702e-02f, 1.48918433e-03f,
  8.05410370e-03f, 6.34987280e-02f, -1.02595240e-02f, 3.87119874e-02f, 2.39554606e-02f, -7.31845126e-02f, 8.22808892e-02f, -9.90031194e-03f, 2.30334196e-02f, 7.54958689e-02f,
  -1.01256007e-02f, -7.98758417e-02f, -4.33664545e-02f, -6.13487400e-02f, 8.55060294e-03f, 9.22916457e-02f, 1.49291130e-02f, 7.00374097e-02f, 8.15382302e-02f, 3.73622440e-02f,
  -1.13519229e-01f, 1.38361454e-01f, 3.21055055e-02f, -1.00276895e-01f, 7.28935972e-02f, 5.68891689e-03f, -1.42665133e-01f, -6.22143620e-04f, 1.43705964e-01f, 3.46236378e-02f,
  -3.09973173e-02f, -2.32990142e-02f, -6.12117210e-03f, -5.18936552e-02f, -1.31815583e-01f, 1.95513200e-02f, -4.14641872e-02f, -1.05736084e-01f, 1.05188735e-01f, -2.38876045e-02f,
  1.51354177e-02f, -1.63624272e-01f, -1.36788428e-01f, -5.42269275e-02f, 7.17853531e-02f, 4.82339486e-02f, -6.79144040e-02f, 1.62287261e-02f, 5.12615079e-03f, 1.77811868e-02f,
  -1.97733324e-02f, 1.53075039e-01f, -3.18346396e-02f, 2.33439095e-02f, -4.00215164e-02f, 1.40166143e-02f, 2.07183715e-02f, -4.93650734e-02f, -5.82435392e-02f, 7.16351643e-02f,
  4.24493775e-02f, -5.10022938e-02f, 9.69309658e-02f, -6.01801164e-02f, -3.79503630e-02f, 3.01542953e-02f, 9.23113059e-03f, -6.37882352e-02f, -8.49811882e-02f, 7.37712160e-02f,
  8.11609924e-02f, -3.67772765e-02f, 6.43123537e-02f, -8.30552131e-02f, -4.05148864e-02f, 3.50850113e-02f, -2.80799940e-02f, 1.51725085e-02f, 7.79988915e-02f, 9.25697833e-02f,
  -1.23272212e-02f, -5.32822534e-02f, 2.78160274e-02f, 1.52991442e-02f, 2.34391168e-02f, 9.25140455e-02f, 4.19635959e-02f, -6.99565411e-02f, 8.68084468e-03f, 6.12853058e-02f,
  -1.17050663e-01f, 1.76979117e-02f, 4.96696644e-02f, -7.09921345e-02f, 4.31658402e-02f, -4.62923050e-02f, -3.42626832e-02f, 5.13388291e-02f, 2.77307648e-02f, -3.78817581e-02f,
  2.04938706e-02f, -8.95481091e-03f, 8.65295231e-02f, 4.80702966e-02f, 2.09662057e-02f, 4.46419120e-02f, 4.43344470e-03f, 3.51173095e-02f, -9.86618251e-02f, 2.97742374e-02f,
  -3.61157395e-03f, 1.67139843e-02f, 9.69877373e-03f, -8.27948749e-02f, -8.37107450e-02f, -1.62861291e-02f, -1.35924742e-02f, 3.00305132e-02f, -1.15222767e-01f, -1.75313875e-02f,
  -4.08943482e-02f, -7.86827281e-02f, -4.99048717e-02f, -1.67487413e-02f, -4.95251045e-02f, -6.09431835e-03f, -5.17284349e-02f, 8.38936248e-04f, -5.45017719e-02f, 2.53630988e-02f,
  4.58943844e-02f, -4.55848165e-02f, 6.99471459e-02f, -5.91694377e-02f, -8.66664648e-02f, -3.93777639e-02f, -5.97406439e-02f, -8.76617432e-02f, -6.23586029e-03f, 7.39700049e-02f,
  7.01692626e-02f, 6.15203977e-02f, -7.98408017e-02f, 8.03945884e-02f, 5.63836917e-02f, -4.35897820e-02f, -8.12532231e-02f, 7.33029842e-02f, 3.71553041e-02f, -1.15893781e-01f,
  -1.58271659e-02f, -5.39699942e-02f, -5.09765409e-02f, 1.11934682e-03f, 1.28045723e-01f, 5.57699520e-03f, -4.13363846e-03f, -4.82714698e-02f, -4.52144928e-02f, -2.18927953e-02f,
  1.72878671e-02f, 3.45116630e-02f, 1.01445556e-01f, 1.59077004e-01f, 9.34931710e-02f, 4.70386744e-02f, 1.16533652e-01f, -8.62555504e-02f, 1.09848842e-01f, 7.90110677e-02f,
  -9.91531536e-02f, 3.52155380e-02f, 3.53226624e-02f, 1.93331502e-02f, 9.84474570e-02f, -2.62346566e-02f, -7.59258447e-03f, 5.86147346e-02f, 5.53844906e-02f, -2.98376773e-02f,
  -4.55873497e-02f, -4.72344533e-02f, 3.84482145e-02f, 1.89732052e-02f, 1.49703315e-02f, -1.65560693e-02f, -3.77680175e-02f, 6.04331307e-02f, -4.88578044e-02f, -1.19137028e-02f,
  1.89297050e-02f, 2.77969018e-02f, 2.12961752e-02f, 1.40132174e-01f, -8.14029351e-02f, 3.83560769e-02f, -1.76352542e-02f, 9.09200981e-02f, 1.10947534e-01f, 3.67092304e-02f,
  1.69153679e-02f, 6.44823983e-02f, -8.40135217e-02f, -1.06150113e-01f, -1.47547787e-02f, 1.37403496e-02f, -2.27999054e-02f, -7.22475797e-02f, 5.41081950e-02f, -1.01310536e-02f,
  3.52879288e-03f, -1.47123234e-02f, 5.03289476e-02f, -4.33209836e-02f, 6.04393557e-02f, -2.28242781e-02f, 9.50923935e-02f, -4.42884229e-02f, 3.12926918e-02f, -2.77919006e-02f,
  8.68129060e-02f, 3.95900011e-02f, -3.77410017e-02f, 6.14923760e-02f, -6.12891018e-02f, -1.47711234e-02f, 1.67137850e-02f, -8.57326686e-02f, 7.70307565e-03f, 2.00820193e-02f,
  3.15670408e-02f, 8.93973559e-02f, -7.23850280e-02f, 4.65922290e-03f, -6.45726323e-02f, 3.80215235e-02f, -7.47383833e-02f, -1.45301931e-02f, 3.88406999e-02f, -5.60423881e-02f,
  7.38675753e-03f, 5.42878918e-02f, 2.48866342e-02f, 7.42768273e-02f, -4.49292511e-02f, -1.14276305e-01f, -3.40914913e-02f, -1.69157889e-02f, 9.11867917e-02f, 4.03743908e-02f,
  -1.21246390e-02f, 1.26212910e-02f, 3.20528336e-02f, 6.19609803e-02f, -7.33003244e-02f, -3.36990831e-03f, 3.45430598e-02f, -5.40446565e-02f, -1.97903384e-02f, -8.46146606e-03f,
  9.50514004e-02f, -1.24417637e-02f, 4.63736355e-02f, 2.48888671e-01f, -8.40314925e-02f, -4.11892116e-01f, -2.64864653e-01f, -2.30986439e-02f, -2.06989214e-01f, -1.04689218e-01f,
  2.54417006e-02f, 1.72427576e-02f, -2.09003258e-02f, 7.47696236e-02f, 2.28564531e-01f, -1.19116500e-01f, 2.34027743e-01f, 4.45386469e-02f, 9.90624577e-02f, 1.30302042e-01f,
  5.76303862e-02f, 1.64076075e-01f, 2.38829434e-01f, 1.76216587e-01f, 7.59614930e-02f, 8.36100429e-02f, 2.54102349e-01f, 5.29276021e-02f, 2.00541869e-01f, 8.74340385e-02f,
  -1.62847489e-01f, -6.60030842e-02f, 2.10939925e-02f, 4.25693765e-02f, -3.16987261e-02f, -1.40962452e-01f, -7.81061724e-02f, 9.09883343e-03f, 2.29934063e-02f, 6.80968456e-04f,
  -8.35591853e-02f, 1.49027213e-01f, -1.21780466e-02f, 2.37154160e-02f, -1.12414197e-03f, 7.78696910e-02f, -2.58468967e-02f, -8.38716030e-02f, -3.16230878e-02f, 3.15860696e-02f,
  -1.52921230e-01f, -3.74187008e-02f, -2.20120475e-02f, 4.84362803e-02f, -7.50418529e-02f, -4.71893465e-03f, -7.98625648e-02f, -2.70439051e-02f, -1.10268183e-02f, 1.07447850e-02f,
  -6.41150922e-02f, 3.37403491e-02f, 2.52663065e-02f, 3.59710194e-02f, 1.76101050e-03f, 4.74086441e-02f, 4.70399894e-02f, 1.69871990e-02f, 1.18525494e-02f, 1.66747626e-02f,
  3.28050144e-02f, 4.03526388e-02f, 1.06861591e-01f, 5.30704558e-02f, -2.13945210e-02f, -8.48623142e-02f, 2.48019770e-02f, -3.27311195e-02f, 3.61160599e-02f, -1.44186821e-02f,
  2.07025129e-02f, 2.12307204e-03f, -1.35813616e-02f, -4.94399779e-02f, 5.87695315e-02f, 5.42495213e-02f, 8.01841766e-02f, -3.98824103e-02f, -4.98672239e-02f, -1.18195247e-02f,
  1.27758402e-02f, 6.58804700e-02f, -7.50569478e-02f, 6.24697246e-02f, -4.54715043e-02f, 1.59190816e-03f, 8.12888443e-02f, -3.56226303e-02f, 1.49672300e-01f, -1.17539344e-02f,
  -2.08865590e-02f, -9.97951850e-02f, 6.83663180e-03f, 3.40548321e-03f, 3.01085273e-03f, -7.39133134e-02f, -2.89119557e-02f, -3.13742235e-02f, -2.97616087e-02f, 4.79224958e-02f,
  -2.02284176e-02f, -7.73291960e-02f, 3.03400755e-02f, -8.05191174e-02f, -1.42179336e-02f, -1.28210127e-01f, -2.45264196e-03f, 5.42486347e-02f, -5.35682105e-02f, 5.40844053e-02f,
  2.74337202e-01f, -1.91148520e-01f, 1.05250306e-01f, -4.99304291e-03f, -1.33086042e-02f, 9.02161300e-02f, 2.02396661e-01f, -1.10868730e-01f, -9.65923294e-02f, -1.63677126e-01f,
  -4.86404449e-02f, 1.45934941e-02f, 5.33250459e-02f, 4.29071002e-02f, 8.78057703e-02f, -4.92758639e-02f, -7.30728805e-02f, -1.10351115e-01f, 9.99173429e-03f, 5.43977246e-02f,
  8.45571384e-02f, 5.94841391e-02f, -2.74848584e-02f, -1.42555669e-01f, 8.72802734e-02f, 6.32552952e-02f, -7.54066557e-03f, 5.42031303e-02f, -1.07919760e-01f, 2.62978394e-02f,
  -1.51749671e-04f, -6.16630912e-02f, -1.00973882e-02f, 4.03201617e-02f, 2.74132621e-02f, -5.13453372e-02f, -6.46196008e-02f, 4.04368062e-03f, 8.33418369e-02f, 1.41573893e-02f,
  5.51448911e-02f, -3.15232091e-02f, -3.61143313e-02f, 4.13414650e-02f, 9.92094632e-03f, -3.73958168e-03f, -8.96808039e-03f, 4.04723659e-02f, -3.94550487e-02f, -6.12012856e-02f,
  -1.06463290e-03f, -6.84701577e-02f, 4.36526090e-02f, 4.79945652e-02f, -9.95313823e-02f, -5.24232499e-02f, -9.09461156e-02f, -5.15126437e-02f, -5.64281829e-02f, -5.32016121e-02f,
  3.36930109e-03f, 2.97188703e-02f, -1.92263629e-02f, -1.56289916e-02f, -7.61286989e-02f, 1.44985812e-02f, 6.42284080e-02f, -6.59582019e-02f, 1.48022715e-02f, -4.33427468e-02f,
  -3.07026915e-02f, -5.45701236e-02f, 8.21557420e-04f, -3.63125205e-02f, -6.86122046e-04f, 1.76990386e-02f, -1.31093822e-02f, -7.74450321e-03f, -5.90808578e-02f, 6.06959164e-02f,
  -7.02578276e-02f, 4.36306410e-02f, 7.49518946e-02f, -1.13327308e-02f, 1.31756328e-02f, 6.70113638e-02f, 3.85895297e-02f, -3.25631164e-02f, 1.26267495e-02f, 2.01058909e-02f,
  -6.73405034e-03f, -1.45871460e-01f, 4.77818027e-02f, 4.46091220e-02f, 2.78041083e-02f, -9.71853957e-02f, -3.81560600e-03f, 1.66706201e-02f, 5.69983460e-02f, 7.21792951e-02f,
  -4.71184067e-02f, 5.75965755e-02f, 2.62023080e-02f, -7.57521763e-02f, -1.07996672e-01f, -8.52071792e-02f, -4.16663624e-02f, -6.98104054e-02f, 5.89016564e-02f, 3.94531190e-02f,
  1.14514660e-02f, -4.66129705e-02f, -5.48426472e-02f, -6.86124489e-02f, -1.74642429e-02f, -7.12456703e-02f, 6.92449138e-02f, 4.00401205e-02f, 3.66169885e-02f, 1.72344670e-02f,
  -7.49459490e-02f, -6.44707903e-02f, 4.28386629e-02f, -3.57060023e-02f, -8.38228688e-02f, -6.82802796e-02f, 1.99481957e-02f, -1.08213224e-01f, 8.23916048e-02f, 9.00229886e-02f,
  3.10237911e-02f, -7.02715591e-02f, 8.75400603e-02f, 1.52502492e-01f, -5.77115640e-02f, -3.75614315e-02f, 4.39084917e-02f, -2.04179548e-02f, -1.43834231e-02f, -6.10304289e-02f,
  -6.91210255e-02f, 9.62430909e-02f, -3.67587097e-02f, -8.12715963e-02f, -1.53875602e-02f, -8.67623091e-02f, 1.08619377e-01f, 6.58764094e-02f, -1.44698732e-02f, -4.42744792e-02f,
  5.26333638e-02f, 1.07738465e-01f, 8.03823583e-03f, -9.40390117e-03f, 3.44537795e-02f, -2.70846412e-02f, -3.80916707e-02f, 3.30627076e-02f, -5.64456098e-02f, -7.19523206e-02f,
  2.85338070e-02f, -2.35881098e-02f, 6.06478937e-02f, -7.08613172e-02f, -7.41078034e-02f, 6.07142076e-02f, 7.91222081e-02f, -2.86778789e-02f, 5.38740568e-02f, -4.69969325e-02f,
  3.10284551e-02f, -9.15540848e-03f, 3.68620791e-02f, -2.03615427e-02f, -3.99649851e-02f, -5.34399189e-02f, -7.16526061e-02f, 1.04177538e-02f, 8.55028480e-02f, 4.58679311e-02f,
  6.37626462e-03f, -2.47781929e-02f, 4.23827432e-02f, -8.02593008e-02f, -3.30742858e-02f, -5.35136573e-02f, -3.90919372e-02f, 7.26085901e-02f, -3.43660079e-02f, -2.38374546e-02f,
  -6.32582009e-02f, -1.25706661e-02f, 5.86558320e-03f, -6.25999346e-02f, -1.35553237e-02f, -3.67879197e-02f, -1.92336261e-03f, 6.13241969e-03f, -5.29767349e-02f, -5.60959876e-02f,
  -3.78518924e-02f, -6.61202595e-02f, -1.21369713e-03f, -2.15594843e-02f, 5.73448762e-02f, 5.93697727e-02f, 1.53739341e-02f, -1.56287719e-02f, -7.67363294e-04f, 3.76610048e-02f,
  1.39186885e-02f, 5.50428815e-02f, -5.13723791e-02f, 3.65345762e-03f, 9.79676396e-02f, -6.83702081e-02f, 5.58056273e-02f, -4.59494554e-02f, 8.44990015e-02f, 4.88604754e-02f,
  5.79216219e-02f, 1.04973065e-02f, -3.08538741e-03f, -8.85994881e-02f, 5.39671294e-02f, -2.51031499e-02f, -3.31169702e-02f, -7.46856928e-02f, -4.59478870e-02f, -3.31888348e-02f,
  -4.08434644e-02f, -8.41500908e-02f, -6.77279010e-02f, 9.72136185e-02f, 2.86042336e-02f, 1.43396566e-02f, 6.48281723e-02f, 5.90427965e-02f, 8.54685381e-02f, 1.64991450e-02f,
  7.21199214e-02f, -9.94447917e-02f, -1.28065115e-02f, -3.50670479e-02f, 2.06374042e-02f, 1.12062626e-01f, 5.63043617e-02f, 2.84718219e-02f, -3.17160971e-02f, 9.74885821e-02f,
  6.61482140e-02f, -3.11678723e-02f, 6.24977313e-02f, 6.02988824e-02f, -4.23018541e-03f, -2.11910382e-02f, 2.99590752e-02f, 2.71113068e-02f, -4.89852652e-02f, 6.86727837e-02f,
  -7.82430395e-02f, 4.39950861e-02f, 5.69025651e-02f, 5.44478409e-02f, 6.08826093e-02f, -4.64507006e-02f, -4.67657037e-02f, 3.13361920e-02f, -7.59626478e-02f, -6.75006397e-03f,
  5.55780679e-02f, 9.94369388e-03f, 7.58156851e-02f, -2.82872338e-02f, 9.98040587e-02f, -4.62302798e-03f, 2.88995188e-02f, 3.17061059e-02f, 6.71143234e-02f, -1.42676849e-02f,
  -6.29600435e-02f, -2.05463404e-03f, 2.17662174e-02f, 8.72197300e-02f, -6.95873797e-02f, -4.55685817e-02f, 7.14969113e-02f, 7.53484517e-02f, -4.70611155e-02f, -5.30460179e-02f,
  2.11505871e-02f, -1.38295982e-02f, -7.61549696e-02f, -8.92415866e-02f, -5.59726469e-02f, -6.58887997e-02f, -5.86494319e-02f, -3.99285182e-03f, 7.25491252e-03f, -1.86041966e-02f,
  -7.53279254e-02f, 2.74199992e-03f, 7.77070969e-02f, -2.99726054e-02f, 4.46712859e-02f, -1.73619147e-02f, 7.67964646e-02f, -1.28042437e-02f, 6.24014288e-02f, 5.20972535e-03f,
  2.21675932e-02f, 8.55672583e-02f, 4.58983518e-02f, 2.07217620e-03f, -7.90461723e-04f, -3.68184969e-02f, -6.66241273e-02f, -5.29064834e-02f, 4.06942926e-02f, 2.19374225e-02f,
  5.51730208e-03f, 6.47353530e-02f, -6.14078157e-02f, 5.92912175e-02f, 6.56323358e-02f, -1.52322662e-03f, 6.48277774e-02f, -7.24668652e-02f, -6.48376495e-02f, -7.35171437e-02f,
  1.59400646e-02f, 1.86802410e-02f, -5.98570937e-03f, 2.47825384e-02f, 8.25523864e-03f, -6.54670075e-02f, -7.39734769e-02f, 4.88085262e-02f, -5.63831553e-02f, 4.30748351e-02f,
  9.52054262e-02f, -4.90291379e-02f, -7.26218522e-02f, 1.45402327e-02f, -8.96675885e-02f, 2.04262566e-02f, -1.62809473e-02f, -5.85945323e-02f, 4.38504927e-02f, -9.27100033e-02f,
  6.11860901e-02f, 2.76670381e-02f, 5.84759302e-02f, 8.69054198e-02f, 2.61969380e-02f, 6.18036613e-02f, 5.71753830e-02f, -5.78710958e-02f, -7.93142803e-03f, 6.00527860e-02f,
  -5.66931665e-02f, -1.11955956e-01f, -8.43674764e-02f, 8.76578093e-02f, -5.21069951e-02f, -7.03096762e-02f, -1.02674067e-01f, 7.72579759e-03f, 7.83374310e-02f, -1.79775599e-02f,
  8.28897059e-02f, -3.56025435e-02f, -3.04468977e-03f, -1.15966074e-01f, -6.35731518e-02f, 6.57857209e-02f, -1.24783956e-01f, -6.60855249e-02f, -2.68042628e-02f, 3.91348489e-02f,
  -1.18439078e-01f, 5.25691025e-02f, -1.21069647e-01f, -4.72581573e-02f, -4.17820625e-02f, -2.60687880e-02f, 1.33279189e-01f, -2.14870162e-02f, -2.40883138e-02f, 7.34356865e-02f,
  -3.46120037e-02f, 1.67012349e-01f, -2.32908633e-02f, 3.48969661e-02f, 7.58323222e-02f, -6.51808036e-03f, 4.01322991e-02f, 2.65073739e-02f, 7.50099868e-02f, -2.43878234e-02f,
  -6.30270317e-02f, 3.57516925e-03f, -4.23012674e-02f, -1.14370640e-02f, -6.25077710e-02f, -1.73804853e-02f, -4.41182330e-02f, 8.39788374e-03f, 8.42406899e-02f, 3.89374942e-02f,
  -4.96701486e-02f, -4.57822494e-02f, -9.72431228e-02f, 3.90187316e-02f, -2.34570783e-02f, -5.61984405e-02f, -8.29346776e-02f, 7.10450404e-04f, 2.37492640e-02f, -2.86759455e-02f,
  -3.43591757e-02f, -2.66075181e-03f, -6.76350221e-02f, -4.72760871e-02f, 8.96798596e-02f, 1.82465222e-02f, 8.73746425e-02f, 3.78038287e-02f, -5.01222834e-02f, -2.33705454e-02f,
  4.55373786e-02f, 6.01855926e-02f, 2.05075294e-02f, -3.18461545e-02f, 1.88154206e-02f, 6.83888048e-03f, -4.37622145e-02f, -9.54973251e-02f, -2.37294752e-02f, -5.09140268e-02f,
  5.95487421e-03f, 7.82600269e-02f, -7.39784986e-02f, -7.62630776e-02f, -7.42119327e-02f, 1.73821170e-02f, 7.56098540e-04f, 4.86382395e-02f, 7.12352842e-02f, -8.32872987e-02f,
  -1.95390694e-02f, 7.31302574e-02f, 1.00061573e-01f, 8.67693648e-02f, 8.52465034e-02f, 4.69646342e-02f, 5.25513180e-02f, 4.68133315e-02f, -6.39650747e-02f, 3.73641178e-02f,
  7.92880803e-02f, 3.12059075e-02f, -8.15322772e-02f, -6.18395135e-02f, 3.29787992e-02f, -3.14818509e-02f, -3.18592265e-02f, -5.32677844e-02f, -3.86667773e-02f, -4.46362309e-02f,
  -3.78940180e-02f, -7.15418309e-02f, -4.52076318e-03f, 6.75933883e-02f, 6.46022558e-02f, 6.66107144e-03f, -2.44501489e-03f, 7.06271678e-02f, -4.32812981e-02f, -6.34310097e-02f,
  -1.52177379e-01f, -2.26917565e-02f, 1.37002289e-01f, 7.62116536e-02f, 5.37537374e-02f, 8.85109976e-02f, -2.26356275e-02f, 8.20005238e-02f, -3.11805625e-02f, -2.17904951e-02f,
  7.21451789e-02f, -3.04469895e-02f, 1.65477376e-02f, -1.10790491e-01f, 3.85648981e-02f, -7.80024752e-03f, 7.92383961e-03f, -7.09618703e-02f, -2.33540926e-02f, -7.35591501e-02f,
  -5.32621481e-02f, -1.25686169e-01f, -1.09906763e-01f, -8.61463323e-02f, 3.41370772e-03f, -1.90397855e-02f, -3.93262655e-02f, 2.32675392e-02f, 5.52489348e-02f, -9.59094763e-02f,
  6.78015575e-02f, 2.72590127e-02f, -1.81535014e-03f, -6.11192212e-02f, 3.07926293e-02f, -8.89964253e-02f, 4.02341830e-03f, 7.37497881e-02f, 6.71546683e-02f, 1.05424568e-01f,
  -1.79738533e-02f, -2.35709641e-02f, 1.05791111e-02f, -6.49475977e-02f, 2.62373090e-02f, -8.99559706e-02f, -3.68681774e-02f, 1.32497903e-02f, -8.94316938e-03f, -3.54656056e-02f,
  7.08841383e-02f, 2.41791550e-02f, 1.15941875e-02f, 5.62258065e-02f, -1.01743773e-01f, -9.79190022e-02f, -5.26628606e-02f, -4.81863059e-02f, -3.15174344e-03f, 1.10933870e-01f,
  1.80639084e-02f, 9.31300502e-03f, -2.90052146e-02f, 4.20776904e-02f, -6.22145236e-02f, 8.27026889e-02f, -8.98835585e-02f, 5.76787919e-04f, -6.53709546e-02f, -6.46473393e-02f,
  -3.15740220e-02f, 1.69569568e-03f, -4.73885164e-02f, -1.03729375e-01f, -3.46192941e-02f, -1.70949046e-02f, -5.55460639e-02f, 8.68599266e-02f, 1.51299462e-02f, -8.55202079e-02f,
  1.14420000e-02f, -3.63563374e-02f, 7.45464116e-02f, 4.03123647e-02f, 6.74294028e-03f, -5.52289225e-02f, 8.04327130e-02f, 4.01024632e-02f, 7.16098472e-02f, -4.83963974e-02f,
  6.01264760e-02f, 6.41220361e-02f, 8.45872536e-02f, -4.67111822e-03f, -3.92828789e-03f, 1.95625182e-02f, -2.15302669e-02f, -4.77312971e-03f, 9.04437602e-02f, -1.36048626e-02f,
  -2.50293799e-02f, -5.60044385e-02f, -3.08266953e-02f, -9.42285433e-02f, 2.18619732e-03f, 3.82728465e-02f, -8.70127417e-03f, 1.05596267e-01f, 1.06263258e-01f, 1.69177148e-02f,
  -1.98247302e-02f, 5.41437678e-02f, -1.69099662e-02f, -2.33406052e-02f, -9.51110870e-02f, -5.62726520e-02f, 5.22316992e-02f, -3.21154557e-02f, 2.73457691e-02f, -3.69639546e-02f,
  -8.17091949e-03f, 5.54424012e-03f, 2.18526214e-01f, 3.37547362e-02f, 1.54236630e-01f, 1.62119064e-02f, 7.89628625e-02f, 1.25063658e-01f, 1.74729377e-02f, -5.59178740e-02f,
  -2.13629013e-04f, 6.77367076e-02f, 5.91701120e-02f, -1.59073710e-01f, 1.32911447e-02f, 5.87718859e-02f, 4.03873958e-02f, 8.33976548e-03f, 8.97756219e-02f, 7.12152719e-02f,
  2.56966166e-02f, 1.25437404e-03f, -4.33407724e-02f, -1.04887292e-01f, -3.65637317e-02f, 4.87104356e-02f, -1.17283545e-01f, -2.44329311e-02f, -4.51434441e-02f, -5.66913038e-02f,
  -7.41677685e-03f, -3.62958871e-02f, 7.02708960e-02f, 1.28700212e-02f, -1.16216904e-02f, -7.47020170e-02f, 6.17394410e-02f, -6.58979267e-02f, 5.18827885e-02f, 7.20526278e-02f,
  5.82453348e-02f, -7.39922398e-04f, 6.79045916e-02f, -7.58141503e-02f, 1.00615934e-01f, -9.82800312e-03f, -1.70396268e-02f, 4.55558971e-02f, -3.61561291e-02f, 8.71070400e-02f,
  3.01357433e-02f, -5.21653593e-02f, 3.61302234e-02f, 4.49404307e-02f, -7.70208985e-03f, -8.52567032e-02f, -3.97328362e-02f, -8.91739652e-02f, -5.15622124e-02f, -5.45201600e-02f,
  8.52508768e-02f, 9.49616730e-02f, -4.61865738e-02f, -2.97247674e-02f, -2.40333695e-02f, -1.55176967e-02f, -9.54335481e-02f, -3.02740466e-02f, -1.02332421e-01f, -3.48346457e-02f,
  -1.41698113e-02f, -5.93685247e-02f, -5.83152398e-02f, -4.29849774e-02f, -1.93186495e-02f, -1.46878033e-03f, -8.87247846e-02f, 2.85402220e-02f, 2.21802574e-02f, 5.51164150e-02f,
  3.34609449e-02f, -8.09788406e-02f, 1.97830442e-02f, -1.76987201e-02f, 1.09038226e-01f, -4.55007814e-02f, 3.77451703e-02f, 6.46661296e-02f, -2.95256288e-03f, -5.84123246e-02f,
  -1.01706199e-01f, -8.91260952e-02f, -5.28752021e-02f, -3.35977823e-02f, -2.24312283e-02f, 6.64962381e-02f, -5.93396090e-02f, -8.75962451e-02f, 3.87540422e-02f, -5.52431792e-02f,
  -4.45162272e-03f, 6.36936724e-02f, 2.46136226e-02f, -6.02179803e-02f, 5.83799370e-02f, -1.15896072e-02f, -7.07414076e-02f, -6.55665621e-02f, -3.84803638e-02f, -5.89163452e-02f,
  3.86107676e-02f, 1.41541054e-02f, -9.74180922e-02f, -2.05646418e-02f, 4.73686540e-03f, 9.84134804e-03f, 3.97349931e-02f, 3.65969986e-02f, -6.87685683e-02f, -3.61412466e-02f,
  4.71517667e-02f, -7.32827634e-02f, 1.24234289e-01f, 1.50809782e-02f, 7.50188977e-02f, 1.60383433e-02f, 9.76454467e-02f, -6.19538836e-02f, -4.95707542e-02f, -9.82130915e-02f,
  7.84911914e-04f, -3.74846607e-02f, 1.41680697e-02f, -4.19402421e-02f, 9.88458693e-02f, -5.35035394e-02f, -8.26702565e-02f, -4.53676432e-02f, 1.21503159e-01f, -8.37359354e-02f,
  -3.35258543e-02f, 4.00352664e-02f, 2.69611124e-02f, 1.12154800e-02f, -8.62147659e-02f, -5.98882958e-02f, -6.56649545e-02f, 4.44511548e-02f, -4.61831726e-02f, 9.41011086e-02f,
  1.21273519e-02f, 4.96697836e-02f, -4.26221527e-02f, -1.03236161e-01f, 1.52018974e-02f, -5.40640280e-02f, 1.59929115e-02f, 5.35066314e-02f, 1.57807786e-02f, 3.72623280e-02f,
  3.74953039e-02f, 4.98450845e-02f, 4.34923247e-02f, -1.26459608e-02f, -1.90191120e-02f, 7.09582493e-02f, -6.35579079e-02f, 1.29602589e-02f, -1.99211501e-02f, 7.10469112e-02f,
  4.94337343e-02f, 2.24291477e-02f, -9.46167782e-02f, -8.78884830e-03f, -8.43020156e-02f, -2.99538895e-02f, 7.45739089e-03f, -8.23225752e-02f, -1.92966163e-02f, 9.50521138e-03f,
  -3.94584797e-02f, 8.92256200e-02f, -8.25510733e-03f, 5.79136573e-02f, 8.46745670e-02f, 6.13263622e-02f, -7.46720582e-02f, 4.27691825e-02f, 3.02626994e-02f, -6.13855105e-03f,
  -7.45678470e-02f, -2.52887141e-02f, 7.58192018e-02f, -7.29399398e-02f, -2.46562455e-02f, -2.36208495e-02f, 2.85154395e-02f, 3.02797053e-02f, -5.51766641e-02f, 4.20117341e-02f,
  5.90306055e-03f, -5.23242280e-02f, -3.88384797e-02f, 4.34653461e-02f, -5.14148138e-02f, 1.06040120e-01f, 1.85757149e-02f, -4.96216826e-02f, -7.57372705e-03f, -2.00331416e-02f,
  -1.09232748e-02f, -8.47132578e-02f, 7.08789229e-02f, 3.80024277e-02f, -6.40281811e-02f, -9.66736227e-02f, -6.51787445e-02f, 4.69392650e-02f, 3.65655869e-02f, -7.66958296e-02f,
  -7.26108253e-02f, 7.54233450e-02f, -3.72839980e-02f, 3.58055905e-02f, 7.60367811e-02f, 3.66663970e-02f, -1.57045305e-03f, 9.28349793e-03f, 5.66898584e-02f, 1.45681808e-02f,
  6.59951717e-02f, 3.96326482e-02f, -9.13619027e-02f, -1.87622905e-02f, -4.97324355e-02f, -1.84631161e-02f, -1.84307843e-02f, -1.80590674e-02f, 1.82961058e-02f, -4.81859297e-02f,
  4.43899743e-02f, 1.69553868e-02f, -1.07987672e-01f, -7.67304376e-02f, -1.31631613e-01f, -9.68237892e-02f, -2.05384523e-01f, -2.29241792e-02f, 2.98439786e-02f, -1.01273127e-01f,
  -7.94094652e-02f, 6.69870153e-02f, 3.38173620e-02f, -1.17617100e-01f, 1.43411964e-01f, 1.72302023e-01f, -1.08702675e-01f, -1.30190596e-01f, -3.90182734e-02f, -7.34835938e-02f,
  5.37230261e-02f, -5.29091945e-03f, -1.06291555e-01f, -4.36530337e-02f, -1.75925866e-01f, -1.09893112e-02f, 6.39223233e-02f, 6.43345248e-03f, 1.18786832e-02f, -5.89713454e-02f,
  -7.70200416e-02f, -1.33990675e-01f, 3.60926986e-02f, -8.57161954e-02f, -1.22409575e-01f, 3.25966626e-02f, -4.10672165e-02f, 3.73443328e-02f, -5.56322969e-02f, -9.05598924e-02f,
  4.57582884e-02f, -1.54069625e-02f, 1.29903527e-02f, 5.29991612e-02f, -8.89634043e-02f, 2.60847621e-02f, -6.25717640e-02f, 1.71192661e-02f, 7.13272989e-02f, 2.82700751e-02f,
  -7.13059455e-02f, -1.65798105e-02f, -5.80654629e-02f, 6.12335727e-02f, 1.90456572e-04f, -1.42208347e-02f, 3.41890901e-02f, -5.34486137e-02f, -8.30051079e-02f, -4.27753385e-03f,
  -7.13322312e-02f, 8.89534876e-02f, 4.32102084e-02f, 3.49256471e-02f, -5.04925251e-02f, 1.59842689e-02f, -7.65195265e-02f, -2.90090591e-02f, -5.48034720e-02f, -1.06010847e-02f,
  -5.61994165e-02f, 1.36979874e-02f, 1.04717659e-02f, -1.20206689e-03f, 6.54587895e-02f, -5.68365008e-02f, -3.03602014e-02f, 6.79568276e-02f, 5.72621077e-02f, 2.14470234e-02f,
  -8.66857916e-03f, -6.33360073e-02f, -4.95847724e-02f, -6.38850555e-02f, 7.82476738e-02f, 2.42009424e-02f, 1.22016491e-02f, 3.66032608e-02f, 1.48119284e-02f, 7.34696686e-02f,
  -3.72877531e-02f, -5.40399700e-02f, 3.34716700e-02f, -7.39317238e-02f, -1.56835355e-02f, -2.94781346e-02f, 6.80016652e-02f, -3.69226895e-02f, -6.79474846e-02f, 2.31411662e-02f,
  -8.23344141e-02f, -4.69333827e-02f, 1.37225343e-02f, -6.66939914e-02f, 2.50125136e-02f, -2.39820331e-02f, 8.76967385e-02f, 8.63218606e-02f, 5.42594232e-02f, -7.77486386e-03f,
  2.37682350e-02f, 5.36998659e-02f, -3.35002542e-02f, -5.86310923e-02f, 5.30411191e-02f, -7.20999017e-02f, 2.12982874e-02f, 6.36236817e-02f, 3.22016515e-03f, -7.58694038e-02f,
  9.17283818e-02f, 6.30729273e-02f, -7.28323013e-02f, 1.19554121e-02f, -3.10971518e-03f, 4.09957534e-03f, 8.34609643e-02f, 1.00096241e-01f, 2.24095793e-03f, 1.64783657e-01f,
  3.51050869e-02f, 7.61565045e-02f, 1.02213204e-01f, 1.79389700e-01f, 8.93921256e-02f, 1.11136273e-01f, 1.97843522e-01f, 1.56063512e-02f, -3.70842852e-02f, 1.02642260e-01f,
  1.18192891e-02f, 1.82687819e-01f, 3.45159434e-02f, -5.85643873e-02f, 1.18051164e-01f, -1.66441351e-01f, -1.33320531e-02f, -1.13125920e-01f, 6.60907924e-02f, 6.90357760e-02f,
  3.32795456e-02f, 5.57543673e-02f, 8.32531080e-02f, -4.95447144e-02f, 4.34154049e-02f, 4.68987040e-02f, 4.48006950e-02f, -2.71115871e-03f, -6.98845312e-02f, 5.00128008e-02f,
  -8.99541564e-03f, 2.83028409e-02f, -8.81503075e-02f, 4.56090420e-02f, -5.30107729e-02f, -4.44151871e-02f, -2.81322673e-02f, -9.60490406e-02f, -8.47881958e-02f, 1.06567241e-01f,
  2.63519734e-02f, 2.85873096e-02f, 8.76106042e-03f, -3.81151997e-02f, -7.89260119e-02f, 9.94563028e-02f, -1.77226998e-02f, -5.60023636e-03f, 1.44697903e-02f, -8.02982673e-02f,
  1.03220388e-01f, -4.98977341e-02f, 3.52544785e-02f, -4.28151265e-02f, -3.59103531e-02f, -4.53956313e-02f, 1.61891747e-02f, 6.84109256e-02f, -6.90395012e-02f, 1.34768207e-02f,
  1.40777286e-02f, -6.23313412e-02f, 3.51060070e-02f, 8.80122483e-02f, -3.92494611e-02f, 7.37640560e-02f, 4.49887142e-02f, 2.26217080e-02f, 6.68068416e-03f, 8.94566346e-03f,
  1.36463586e-02f, 3.02340053e-02f, 1.74773708e-02f, -1.15740933e-01f, -7.85296876e-03f, -6.05468564e-02f, -1.44367979e-03f, 3.81581672e-02f, -4.09158431e-02f, -1.06830206e-02f,
  7.27190301e-02f, 9.77178887e-02f, 2.85370275e-02f, -2.24585384e-02f, 4.54622880e-02f, 1.22368604e-01f, -9.55442153e-03f, 3.86476181e-02f, 9.32276621e-02f, -4.03804816e-02f,
  -2.14130878e-02f, 7.11813867e-02f, 1.58057921e-02f, -1.77483179e-03f, -5.25484011e-02f, 5.36141172e-02f, 1.08646095e-01f, -5.05671203e-02f, 4.85532023e-02f, 6.28734902e-02f,
  1.16302446e-01f, 6.13245107e-02f, -7.92871788e-02f, -1.92453060e-02f, -2.43927538e-02f, -9.95265227e-03f, -7.06782043e-02f, -2.68685371e-02f, 3.10231093e-02f, 1.31092872e-02f,
  2.13693548e-02f, -7.73832500e-02f, -7.11955205e-02f, 9.82197449e-02f, 2.70278938e-02f, -1.41342795e-02f, 7.35270828e-02f, 4.72946167e-02f, 7.94234648e-02f, 5.77902272e-02f,
  9.90056060e-03f, -9.35829133e-02f, 8.42587929e-03f, -3.12763825e-02f, -3.32978368e-02f, 4.69749682e-02f, -6.90226704e-02f, -6.45201951e-02f, 4.34519313e-02f, -4.09909599e-02f,
  7.32284337e-02f, -8.30683559e-02f, 1.82792861e-02f, 5.27834296e-02f, -9.13233161e-02f, -3.75317223e-03f, 6.15025610e-02f, 5.38748018e-02f, 1.23167755e-02f, -6.22716099e-02f,
  -4.06068489e-02f, 4.38889228e-02f, 7.30939209e-03f, -2.99990666e-03f, -5.82216270e-02f, 9.56356227e-02f, 9.01205558e-03f, 4.75434400e-02f, -6.76491857e-02f, 6.37872098e-03f,
  -8.30061957e-02f, -1.58328488e-02f, 4.18356396e-02f, 2.88624838e-02f, -1.46106922e-03f, -7.54312873e-02f, -7.51501843e-02f, -7.11686024e-03f, 3.11515760e-02f, 2.34330911e-02f,
  7.07416087e-02f, 2.10173633e-02f, -2.26384774e-03f, -7.90006518e-02f, -1.46216145e-02f, -4.54892553e-02f, 3.83144319e-02f, -6.92645460e-02f, -3.31411548e-02f, -8.06309432e-02f,
  -3.80200930e-02f, -5.47130741e-02f, 6.80768713e-02f, 1.82516165e-02f, 2.48712953e-02f, 6.94919825e-02f, -5.89368194e-02f, -4.91230004e-02f, 8.17744657e-02f, 3.36352107e-03f,
  1.21657168e-02f, 6.81602955e-02f, 2.05513723e-02f, 1.86345745e-02f, 5.82265109e-02f, 6.87660351e-02f, -4.84232716e-02f, -7.35168606e-02f, 5.95810674e-02f, -1.05863735e-02f,
  -1.83944367e-02f, 9.17846933e-02f, 8.39654878e-02f, -1.35011543e-02f, -9.98371914e-02f, 6.68731034e-02f, 2.41236724e-02f, 2.46741548e-02f, -5.70271909e-02f, -2.77452823e-02f,
  -4.30050232e-02f, 1.66140459e-02f, 2.69332249e-02f, -1.20736966e-02f, 9.34822857e-03f, 4.97090667e-02f, -4.60692085e-02f, 6.31717220e-02f, -6.21527247e-02f, -4.62870151e-02f,
  1.35297906e-02f, 7.20464215e-02f, 6.70073554e-02f, 5.96536659e-02f, -1.70071740e-02f, 5.00132388e-04f, -4.91718911e-02f, 1.45579800e-02f, -1.08145364e-02f, -8.34670663e-02f,
  7.76222125e-02f, 8.68793800e-02f, 5.49041629e-02f, -4.51481789e-02f, -7.54130259e-02f, -5.08357286e-02f, 6.10428564e-02f, -7.24678338e-02f, 7.22181872e-02f, -8.13113376e-02f,
  1.61653701e-02f, 7.34258294e-02f, 1.13369830e-01f, -4.16328311e-02f, -5.19190431e-02f, -5.43405972e-02f, -1.04818180e-01f, 3.46534438e-02f, 1.24944195e-01f, 1.62036885e-02f,
  3.86328809e-02f, 6.30726442e-02f, 2.01275498e-02f, 5.36073409e-02f, 9.43438262e-02f, 9.60133299e-02f, 8.12781230e-02f, 4.12128493e-02f, 6.49858117e-02f, -1.11375423e-02f,
  8.56291428e-02f, 6.82826936e-02f, 4.56219129e-02f, -7.43180662e-02f, -7.69290254e-02f, -8.28225762e-02f, -3.17548253e-02f, 2.92109158e-02f, -3.64440419e-02f, -9.00726691e-02f,
  8.04963708e-02f, 3.82661745e-02f, -3.85367274e-02f, -9.19453800e-03f, 7.01851472e-02f, -6.05817977e-03f, -1.71798021e-02f, 1.01214554e-02f, -5.09201288e-02f, 7.47699142e-02f,
  -2.34209038e-02f, -2.15408169e-02f, 6.17773756e-02f, 2.28392170e-03f, -3.42100933e-02f, 4.95373942e-02f, 6.26494065e-02f, -2.57287715e-02f, 3.28899547e-02f, 4.01319452e-02f,
  7.28895515e-02f, 1.05886772e-01f, -5.96877234e-03f, -1.14595322e-02f, -2.53091031e-03f, 6.71389624e-02f, -5.93731850e-02f, -5.03737144e-02f, 1.15831965e-03f, 9.67676938e-03f,
  6.76191747e-02f, -7.10531771e-02f, -8.91273767e-02f, 6.62958845e-02f, 7.43181407e-02f, -1.61609352e-02f, -4.47973236e-02f, 6.44514710e-02f, 4.83516371e-03f, -4.22484539e-02f,
  -2.74603274e-02f, -1.99428424e-02f, -4.58358414e-02f, -5.32003567e-02f, 4.54638824e-02f, 5.75660840e-02f, -9.64788534e-03f, 2.38360614e-02f, 1.00973457e-01f, 1.96923185e-02f,
  -2.81518344e-02f, -3.58752422e-02f, 8.27240869e-02f, 7.51517490e-02f, 3.26582119e-02f, 5.07052690e-02f, 2.16578636e-02f, 3.05715892e-02f, -2.90700365e-02f, -4.16011699e-02f,
  1.11726798e-01f, 6.27903640e-02f, 4.66531031e-02f, 5.42896502e-02f, -1.51841491e-02f, 7.15618581e-02f, -1.43979285e-02f, 8.00688341e-02f, 3.56213637e-02f, 1.56711098e-02f,
  9.28805396e-02f, -4.03190628e-02f, -2.24265046e-02f, 2.79131550e-02f, 9.76595283e-03f, -3.70584987e-02f, 1.64759252e-02f, 8.07134807e-02f, -1.45886578e-02f, 8.49172696e-02f,
  8.64355341e-02f, 2.47286968e-02f, 7.94765428e-02f, -6.82756901e-02f, 5.83127104e-02f, 5.12873530e-02f, -2.71107312e-02f, -9.60846320e-02f, 4.56030294e-02f, 6.31653368e-02f,
  -1.76839963e-01f, 1.08748741e-01f, -8.57458636e-02f, -1.08962163e-01f, 6.86926767e-02f, 7.99879991e-03f, -1.04313903e-01f, 1.41422763e-01f, -1.97139997e-02f, -4.09200452e-02f,
  7.11926818e-02f, -1.06631152e-01f, -8.88155401e-03f, 3.26673947e-02f, -1.15140714e-01f, -1.93727165e-02f, 4.06378135e-02f, 3.24427411e-02f, 1.03461385e-01f, 2.72245836e-02f,
  -7.76026249e-02f, -6.56913146e-02f, -2.34110225e-02f, 1.08509444e-01f, 2.35347971e-02f, 3.32325809e-02f, -8.55744109e-02f, 7.00865462e-02f, -6.21760003e-02f, 4.02393378e-02f,
  -6.97235242e-02f, 5.48964329e-02f, 4.98977005e-02f, -2.65498403e-02f, -7.49143213e-02f, 1.87552739e-02f, 4.57814336e-02f, -1.17250960e-02f, 6.06479757e-02f, 5.90719804e-02f,
  3.80289257e-02f, 5.51133081e-02f, -1.23889158e-02f, -5.78972362e-02f, 4.16932963e-02f, 4.24654409e-02f, -3.65530290e-02f, -3.26959938e-02f, 7.28524178e-02f, 7.46919140e-02f,
  -6.13885783e-02f, -5.94197847e-02f, 3.22082229e-02f, -1.07353264e-02f, -3.41106881e-03f, -8.68054256e-02f, -6.26213802e-03f, 6.19835481e-02f, -7.57587980e-03f, -3.44011523e-02f,
  -7.63221458e-02f, -3.24001499e-02f, -4.45227325e-02f, 2.16379948e-02f, 6.27641231e-02f, 6.65889829e-02f, -3.87035906e-02f, -7.27733481e-04f, 1.98378209e-02f, -7.06762448e-02f,
  4.60349247e-02f, -4.95977327e-02f, 5.03209718e-02f, -4.76241000e-02f, -8.60116929e-02f, 1.96258910e-02f, -1.24516990e-02f, 7.15151802e-02f, 9.28934198e-03f, 8.34289864e-02f,
  -5.86586781e-02f, -8.14064667e-02f, 1.02848362e-03f, -4.57287580e-02f, 7.31058121e-02f, 6.60727397e-02f, 6.68064430e-02f, 1.08536363e-01f, 6.62120506e-02f, 4.35196571e-02f,
  2.41246708e-02f, -9.58891883e-02f, 4.30169292e-02f, -7.38109350e-02f, 9.97285247e-02f, -3.86227854e-02f, -7.24954978e-02f, 9.73937437e-02f, 4.32781577e-02f, -6.18627034e-02f,
  5.53777553e-02f, 4.82419431e-02f, 1.17465779e-02f, -1.98751478e-03f, -6.91624284e-02f, 2.82177012e-02f, -2.58191619e-02f, -5.88382892e-02f, -8.32078010e-02f, -2.91323885e-02f,
  5.62277474e-02f, -5.73691577e-02f, -6.79442286e-02f, 2.03250330e-02f, 1.31328106e-02f, -6.31130412e-02f, -9.00900215e-02f, 3.25364284e-02f, 2.93163024e-03f, -8.38969722e-02f,
  -3.20790142e-01f, 4.26972955e-02f, 9.15762559e-02f, -1.95406869e-01f, 4.83360663e-02f, 8.36345181e-02f, -1.43865213e-01f, 2.34047174e-02f, -1.67435914e-01f, -1.29291406e-02f,
  5.16130105e-02f, -2.03280807e-01f, 2.44996101e-01f, -1.09644219e-01f, -1.83667950e-02f, 1.15747787e-01f, -1.36340320e-01f, -6.07494526e-02f, 6.64487556e-02f, 3.02028470e-02f,
  -5.19533567e-02f, 5.31763658e-02f, 1.64193720e-01f, 2.19854757e-01f, -5.10421135e-02f, -5.81936017e-02f, -1.58569172e-01f, 1.37147024e-01f, -4.44094203e-02f, -5.05576059e-02f,
  9.51021686e-02f, 2.39506233e-02f, 1.06439069e-01f, 3.68462689e-02f, 2.01583803e-02f, -4.69047241e-02f, -7.78636411e-02f, 2.39405353e-02f, -8.15895095e-04f, -4.51952778e-02f,
  -1.13632798e-01f, 5.65808602e-02f, -1.05534904e-01f, 6.39975443e-02f, 8.63468181e-03f, -4.73149754e-02f, 1.18803702e-01f, 2.17130985e-02f, 5.63822351e-02f, -9.66119170e-02f,
  1.25081807e-01f, -3.81457917e-02f, -2.44201794e-02f, -3.06407604e-02f, -3.48172709e-02f, 3.84747908e-02f, -2.01574005e-02f, -4.12292816e-02f, -1.21141728e-02f, 2.24093758e-02f,
  -6.67981571e-03f, -8.59171301e-02f, -5.41668721e-02f, 4.77716699e-02f, 7.64873549e-02f, -2.93757338e-02f, 2.67008934e-02f, -1.06951001e-03f, 1.57915186e-02f, -5.62268570e-02f,
  -7.03369752e-02f, -8.01374912e-02f, -3.04546524e-02f, -5.23192286e-02f, -4.84276526e-02f, 2.70309448e-02f, -4.61075269e-02f, -2.90426519e-03f, -7.06398189e-02f, 1.83668528e-02f,
  1.69382989e-02f, 5.24690561e-02f, -7.40234628e-02f, -6.86362907e-02f, 8.88706073e-02f, 1.03517845e-02f, -1.20725343e-02f, -6.63520172e-02f, -2.48328829e-03f, -4.18466069e-02f,
  -3.99708329e-03f, -9.02436450e-02f, 3.01493127e-02f, 5.85637018e-02f, -6.54279739e-02f, 1.47493929e-03f, 1.49128763e-02f, -5.24862148e-02f, -1.54097885e-01f, 5.05230054e-02f,
  -4.81299534e-02f, -7.97047466e-02f, -2.12145615e-02f, -8.32417533e-02f, -1.69231335e-03f, -3.45668606e-02f, -2.14364789e-02f, -1.22050434e-01f, -8.72774124e-02f, -3.88184227e-02f,
  3.72385548e-04f, 1.09911999e-02f, -4.32692394e-02f, -4.25004847e-02f, -5.38514704e-02f, -7.26951435e-02f, -1.30262628e-01f, 4.15983461e-02f, -6.58211112e-02f, -1.10259317e-01f,
  -1.38570637e-01f, 5.46417348e-02f, -9.96029750e-02f, -6.65645748e-02f, 3.15090045e-02f, -1.46602299e-02f, -1.06686398e-01f, 5.30514047e-02f, -8.98604691e-02f, 6.90979809e-02f,
  1.26644894e-02f, -7.29838684e-02f, 6.52214885e-02f, -1.31787837e-01f, -3.07281107e-01f, -1.89417943e-01f, -9.61542353e-02f, -4.00911830e-02f, 4.59802411e-02f, 1.03601478e-02f,
  -1.31014749e-01f, -1.04358485e-02f, -1.76573526e-02f, 8.75725523e-02f, 1.71459839e-02f, 1.20227985e-01f, 1.21115521e-02f, 5.69447838e-02f, 8.00989754e-03f, 3.39633673e-02f,
  -9.64426771e-02f, -6.51033744e-02f, 6.12980910e-02f, -4.39070910e-02f, -6.89225867e-02f, 9.87749249e-02f, -4.55832779e-02f, -3.70307304e-02f, 3.01626250e-02f, -1.07702710e-01f,
  -7.45930523e-02f, 7.09744915e-02f, 8.16814527e-02f, 7.81566277e-02f, 2.88286321e-02f, -1.29585778e-02f, -3.20986495e-03f, -4.51416820e-02f, 9.57795978e-03f, -1.27331736e-02f,
  1.00498619e-02f, 6.46032542e-02f, 3.22699845e-02f, -6.97201565e-02f, 1.74284820e-02f, 6.62758127e-02f, -7.42253810e-02f, 9.23943371e-02f, -1.50332265e-02f, 6.13940544e-02f,
  6.51675928e-03f, -4.15431373e-02f, 8.47818106e-02f, -4.99410629e-02f, 3.05306371e-02f, -6.71335682e-02f, -3.68683413e-02f, 4.62519228e-02f, -4.51247022e-02f, 3.02981623e-02f,
  -2.38739755e-02f, -3.11035160e-02f, 2.75390502e-02f, 1.05131045e-01f, 7.50454292e-02f, -1.82719547e-02f, 2.11062469e-02f, -1.52471093e-02f, -9.08218846e-02f, 1.31744789e-02f,
  4.04775003e-03f, 1.50957266e-02f, 5.52497208e-02f, -7.69435987e-02f, 2.11142767e-02f, 5.65138459e-02f, -2.13549826e-02f, 7.38476738e-02f, 3.39953601e-02f, 6.05781609e-03f,
  -7.14322105e-02f, -6.49955720e-02f, -2.25039423e-02f, -3.11249960e-02f, 3.47872935e-02f, -1.31514696e-02f, -6.31751940e-02f, -3.98904122e-02f, 3.80763188e-02f, 7.19625130e-02f,
  -5.90733439e-02f, -3.18008475e-02f, -8.46023187e-02f, 2.54691653e-02f, -7.26551265e-02f, -6.07882068e-02f, 9.31483414e-03f, 4.76271138e-02f, -2.37170570e-02f, -5.23604490e-02f,
  7.85764828e-02f, 4.64242473e-02f, -6.31877854e-02f, 3.81116010e-02f, -3.25589217e-02f, -7.43240938e-02f, -4.53983694e-02f, 1.04146777e-02f, 5.21875061e-02f, -6.52833655e-02f,
  -1.64723858e-01f, -6.83666840e-02f, -1.06187008e-01f, 1.37175936e-02f, -3.03033907e-02f, -3.57221141e-02f, -4.01458666e-02f, 5.35329245e-02f, 3.15758288e-02f, -2.47124229e-02f,
  -1.98992249e-02f, 6.35337606e-02f, 7.95768648e-02f, -1.17208086e-01f, -2.79048905e-02f, -2.52343714e-02f, -1.30988404e-01f, -1.08780883e-01f, 6.82044476e-02f, -1.61981732e-01f,
  -5.16408533e-02f, -1.40205503e-01f, 2.62175985e-02f, -1.15266427e-01f, -1.26760066e-01f, -4.82464693e-02f, -5.04061207e-02f, 3.88727523e-02f, -1.21658193e-02f, 6.65363669e-02f,
  -8.05138871e-02f, 9.27072391e-02f, -2.19830777e-02f, 1.03174396e-01f, -9.91228595e-02f, -1.04920506e-01f, 1.37796337e-02f, 9.27831307e-02f, -3.09451646e-03f, -3.06419134e-02f,
  -1.74795964e-03f, 5.94032928e-02f, -7.67905265e-02f, 3.21886837e-02f, -4.33192728e-03f, -4.22989316e-02f, 6.15706220e-02f, 6.81882864e-03f, 2.54680458e-02f, -8.91017839e-02f,
  -4.93785143e-02f, 3.67364800e-03f, -4.12946530e-02f, -4.36817408e-02f, 6.65792078e-02f, 4.26921062e-02f, -2.41952762e-02f, 3.39801684e-02f, 6.88210726e-02f, 2.40727812e-02f,
  -4.89777029e-02f, -1.34919137e-02f, -2.92343013e-02f, 6.15186617e-02f, -2.45032888e-02f, -5.75221702e-02f, -7.18138069e-02f, 2.90119741e-02f, 2.80588809e-02f, 6.83484823e-02f,
  -3.44520842e-04f, -4.47929017e-02f, -2.55751852e-02f, -9.84879211e-02f, 4.01221514e-02f, 8.72926190e-02f, 7.52803758e-02f, -7.09947124e-02f, -1.17035724e-01f, -4.56088446e-02f,
  1.00377493e-01f, -5.10469601e-02f, 9.98277739e-02f, -2.20153742e-02f, -9.78019610e-02f, 6.95911720e-02f, 4.98215705e-02f, -6.59259111e-02f, -4.74126972e-02f, -9.99750048e-02f,
  3.52974236e-02f, 7.84607828e-02f, 4.28456105e-02f, 1.01355845e-02f, 8.81284326e-02f, -2.24407553e-03f, 7.91634694e-02f, 1.60525125e-02f, 4.78469431e-02f, 1.14031538e-01f,
  -9.65858176e-02f, 5.14211990e-02f, 8.04779585e-04f, -4.40292209e-02f, 8.37786719e-02f, 3.66924368e-02f, 9.08764172e-03f, 3.97752002e-02f, -9.39836726e-02f, -1.31784603e-02f,
  8.42278004e-02f, -6.25878247e-03f, 7.61178359e-02f, -6.00331835e-02f, 5.39128073e-02f, 4.33064662e-02f, -2.75804214e-02f, -9.70705077e-02f, -1.08445697e-02f, -5.39715961e-02f,
  2.73417495e-02f, 2.24391725e-02f, -1.09786279e-01f, -1.03207670e-01f, 7.68047571e-02f, 1.54691041e-01f, 2.09511533e-01f, -5.24265729e-02f, -5.91968335e-02f, 2.60543346e-01f,
  1.25625178e-01f, 1.48430625e-02f, 3.87634002e-02f, 2.64319479e-01f, 1.92467924e-02f, 9.55263674e-02f, 1.82807475e-01f, 1.31808788e-01f, -5.37812188e-02f, -2.85046678e-02f,
  -1.05144046e-01f, 1.29592597e-01f, -8.45298544e-02f, -2.40778625e-02f, 5.22743575e-02f, -1.81131452e-01f, 2.25559324e-02f, -1.20878905e-01f, 5.21372892e-02f, 7.25081116e-02f,
  6.43343925e-02f, -1.24655351e-01f, -6.89925402e-02f, 3.22756469e-02f, -1.20877502e-02f, 3.11738495e-02f, -7.27456957e-02f, -6.59786686e-02f, 1.97974630e-02f, 2.15241406e-02f,
  -6.01282343e-02f, -9.62439999e-02f, 8.54828358e-02f, -7.77550712e-02f, -5.05733192e-02f, -4.52482179e-02f, 1.11519471e-02f, -3.84219736e-02f, -7.36068860e-02f, -4.47957404e-02f,
  -4.78153229e-02f, 7.68570825e-02f, -2.55413987e-02f, 6.00973237e-03f, 7.54814222e-02f, 2.42335461e-02f, -4.84066010e-02f, 4.86778133e-02f, -1.88541356e-02f, -3.06307524e-02f,
  -1.24644740e-02f, 4.14524414e-03f, 3.65369394e-02f, -1.18034845e-02f, 2.23163348e-02f, 9.40911174e-02f, -3.86419408e-02f, -7.79753625e-02f, -6.19556047e-02f, 7.78125133e-03f,
  -1.14731668e-02f, -9.61481780e-02f, -7.81961977e-02f, 2.18911786e-02f, 2.46902872e-02f, -3.06968689e-02f, -3.64881791e-02f, 4.88462970e-02f, -1.47118820e-02f, 7.13570714e-02f,
  2.65239980e-02f, -2.04663295e-02f, 4.17029718e-03f, 5.17460741e-02f, 4.27176394e-02f, 1.53613538e-02f, 1.87048744e-02f, -4.71239984e-02f, 4.87490594e-02f, -8.09088275e-02f,
  7.19328299e-02f, 5.45311831e-02f, -2.91775297e-02f, 3.84814069e-02f, -7.35935494e-02f, 1.07657472e-02f, 4.33693230e-02f, 7.33197713e-03f, -1.03316316e-02f, -5.86885326e-02f,
  -2.23473702e-02f, 1.90562587e-02f, 2.51172371e-02f, -4.94168662e-02f, -3.98197770e-03f, -1.50480773e-02f, 3.95863391e-02f, -8.33732858e-02f, 7.33290315e-02f, -7.56847337e-02f,
  7.60929585e-02f, 3.76344882e-02f, -6.31678663e-03f, -9.42077264e-02f, -3.72895449e-02f, 1.38924979e-02f, -3.31682414e-02f, -5.82317002e-02f, -1.46502489e-02f, 3.49251069e-02f,
  8.91992003e-02f, -6.02250621e-02f, 8.44311193e-02f, 5.84010296e-02f, 2.20740470e-03f, 2.78964881e-02f, -1.07080616e-01f, -5.02593443e-02f, -8.34219679e-02f, -9.97807365e-03f,
  3.54032740e-02f, -7.86352754e-02f, -9.54623148e-02f, 2.42216531e-02f, -1.46620587e-01f, -8.36042762e-02f, 4.69001345e-02f, 2.70153228e-02f, -6.38311431e-02f, -9.60262679e-03f,
  1.01545034e-02f, -1.11261413e-01f, 1.72331487e-03f, -2.43857084e-03f, -8.67113378e-03f, 1.37471169e-01f, 1.19124614e-01f, 5.17190434e-02f, 5.31565920e-02f, -1.08747736e-01f,
  -6.88191354e-02f, -1.90095566e-02f, -6.51974976e-02f, 1.67701766e-02f, -3.94946896e-02f, 8.02151784e-02f, 1.12336874e-02f, -6.00594766e-02f, 4.74319197e-02f, 3.31843160e-02f,
  -2.55098976e-02f, 7.91015849e-02f, 3.74440700e-02f, 3.28096859e-02f, -4.54406766e-03f, 2.39449106e-02f, 3.02285105e-02f, 1.79641955e-02f, -5.78121133e-02f, -5.71538322e-02f,
  3.27859968e-02f, 2.36861389e-02f, -5.85713051e-02f, -4.44991887e-03f, -7.50796217e-03f, -9.06462073e-02f, -9.89467725e-02f, 1.75879933e-02f, -6.39432743e-02f, -5.38566411e-02f,
  9.60924849e-02f, -4.66946140e-02f, -4.39241379e-02f, -4.48436998e-02f, 2.83742528e-02f, 2.15828642e-02f, 3.74486484e-03f, 1.12573542e-02f, 3.17039043e-02f, -1.80931203e-02f,
  4.16807346e-02f, -3.08428071e-02f, -3.84723693e-02f, 6.43645003e-02f, -5.26652746e-02f, 5.95073439e-02f, -3.03145275e-02f, 4.90302294e-02f, 1.05535291e-01f, -1.86820123e-02f,
  -6.39460310e-02f, 5.50990738e-02f, 4.47998308e-02f, -3.26091386e-02f, 6.92484202e-03f, 3.43392417e-02f, 9.25261974e-02f, 3.12711869e-04f, -2.00574566e-02f, 8.09873119e-02f,
  3.02792285e-02f, -4.92842905e-02f, -3.17323282e-02f, 5.45005538e-02f, -1.18860193e-02f, -8.42908919e-02f, -3.17241289e-02f, 2.77563389e-02f, -6.65357038e-02f, -6.24829531e-03f,
  7.99666252e-03f, 1.09297074e-02f, -5.07642254e-02f, 2.68023610e-02f, -9.65947211e-02f, 4.13711518e-02f, -9.87363863e-04f, 4.17580940e-02f, 5.14897890e-02f, -2.94270460e-02f,
  3.29724476e-02f, -4.29336261e-03f, -6.30316436e-02f, 3.91611494e-02f, -5.71520254e-02f, 8.19909349e-02f, -5.88896275e-02f, -7.11121969e-03f, 2.34764889e-02f, -7.89103583e-02f,
  -1.05633967e-01f, -4.33035418e-02f, 1.84412524e-02f, -1.06531568e-01f, -3.56559306e-02f, -1.24709047e-02f, -1.53087571e-01f, 1.86557937e-02f, 1.07253745e-01f, -7.69007653e-02f,
  -3.98763381e-02f, 1.04848132e-01f, -5.12330011e-02f, -2.95765093e-03f, -8.14751536e-02f, 4.60090525e-02f, -1.24438822e-01f, -6.42059594e-02f, 2.24117916e-02f, -2.66100951e-02f,
  -6.16960227e-02f, 1.36439409e-02f, -7.08867610e-02f, 1.15867443e-01f, 2.40112506e-02f, 7.57627264e-02f, -1.08915277e-01f, 3.55350152e-02f, -1.01544961e-01f, -4.94455397e-02f,
  3.33357863e-02f, 2.03876700e-02f, 8.50897953e-02f, 7.76354745e-02f, 6.40556067e-02f, -1.09944254e-01f, -7.07712173e-02f, -2.34432239e-03f, 3.79611477e-02f, 4.35009934e-02f,
  2.82850186e-03f, 3.87440920e-02f, -5.97446896e-02f, -2.27971468e-02f, -5.51817194e-02f, 9.26729664e-02f, -8.48989096e-03f, 6.44157501e-03f, 9.81304646e-02f, 8.73287320e-02f,
  2.50257924e-02f, 7.62004927e-02f, 1.76135404e-03f, -3.88224162e-02f, -4.91369106e-02f, -2.69396901e-02f, 2.95248311e-02f, -8.94098505e-02f, 6.40890077e-02f, 4.54193130e-02f,
  1.25941467e-02f, -2.66551115e-02f, 5.00625372e-02f, 1.84799917e-02f, -9.49837714e-02f, 7.79285505e-02f, 8.79551768e-02f, -1.04888253e-01f, -3.32621671e-02f, -1.44304708e-02f,
  -9.93082225e-02f, -2.52366625e-02f, 5.57215922e-02f, -4.90304977e-02f, -2.83454191e-02f, -1.06590511e-02f, 7.01448768e-02f, -3.38852815e-02f, 7.44181871e-02f, -8.87521803e-02f,
  8.40900764e-02f, -6.34209290e-02f, 8.31926018e-02f, -7.08271861e-02f, 7.76507407e-02f, 1.41247818e-02f, 2.92034578e-02f, 4.47967574e-02f, -3.10005229e-02f, 1.45708397e-02f,
  7.66723007e-02f, 2.96507776e-03f, -1.28832450e-02f, 1.94343496e-02f, 1.23569127e-02f, -7.36905786e-04f, -1.72161534e-02f, -8.61779377e-02f, -6.18266053e-02f, -7.67155364e-02f,
  -1.03346810e-01f, -7.00436458e-02f, -6.65852726e-02f, -6.65517896e-03f, -3.13746333e-02f, -4.33441065e-02f, -8.38133693e-02f, -1.21176830e-02f, -7.08310530e-02f, 6.57966062e-02f,
  -1.66740641e-02f, 6.62364662e-02f, 4.67655016e-03f, 9.17140171e-02f, 7.18828477e-03f, -9.54106003e-02f, -9.37270150e-02f, 2.12743785e-02f, -7.51700951e-03f, -6.05013743e-02f,
  2.27169413e-02f, -5.17912135e-02f, -9.95649546e-02f, -1.06810723e-02f, -4.69656698e-02f, 1.84201600e-03f, -1.43469870e-02f, 2.69523561e-02f, -5.04417457e-02f, 1.79620013e-02f,
  -5.42193055e-02f, 3.46058868e-02f, 1.08983129e-01f, -8.77602100e-02f, -5.55694811e-02f, 9.00422409e-02f, 4.72505577e-03f, -2.24768985e-02f, 8.15344825e-02f, -4.95671853e-02f,
  -6.62467405e-02f, 6.07384853e-02f, -6.90453425e-02f, 1.80057492e-02f, 2.28369720e-02f, -1.57614928e-02f, 1.00530691e-01f, -7.37019554e-02f, -8.45547169e-02f, 8.10976177e-02f,
  -5.38343042e-02f, 1.05157562e-01f, -6.75034150e-02f, 9.18544680e-02f, 9.16522741e-02f, 9.31270514e-03f, 6.95729777e-02f, 5.98653220e-02f, 1.14310309e-02f, -5.00536896e-02f,
  -4.81871655e-03f, -7.84030035e-02f, 2.97375955e-02f, -6.36957884e-02f, 7.40151107e-02f, -1.43391406e-02f, 3.78376991e-02f, 2.52528694e-02f, 6.33697510e-02f, 7.96958804e-03f,
  -7.85194039e-02f, 5.41892163e-02f, -4.68844883e-02f, 5.21325618e-02f, -1.47778969e-02f, 5.20706438e-02f, -1.02938041e-02f, 6.42839596e-02f, -6.68544397e-02f, -3.48907546e-03f,
  -4.43165340e-02f, 7.02356994e-02f, -3.41581926e-02f, 4.78291214e-02f, 9.26747173e-02f, 3.26142577e-03f, -4.42678146e-02f, 8.33753794e-02f, 2.32483596e-02f, 5.31930216e-02f,
  -6.93948120e-02f, 1.21100713e-02f, 8.94599259e-02f, 1.40195293e-02f, -4.26422618e-02f, 4.46470343e-02f, 1.06949052e-02f, 4.67968993e-02f, 4.04918902e-02f, -7.48129785e-02f,
  -9.84039679e-02f, 5.22593502e-03f, -6.92923293e-02f, 9.71104298e-03f, 6.86160848e-02f, 8.75840411e-02f, -7.15725124e-02f, 4.83428352e-02f, -2.10789107e-02f, -1.81959905e-02f,
  -1.23783629e-02f, 1.04689440e-02f, -6.75913841e-02f, 7.01668113e-02f, -3.43288146e-02f, 1.63245276e-02f, -1.10510495e-02f, -7.31802136e-02f, -2.55260598e-02f, 3.21456082e-02f,
  6.05276115e-02f, -8.36638138e-02f, -6.14163689e-02f, -8.53169858e-02f, -7.89551958e-02f, 7.28466958e-02f, -2.46656872e-02f, -4.90378067e-02f, -8.38875771e-02f, 5.55932336e-02f,
  -3.68088707e-02f, -1.64267253e-02f, 8.79654512e-02f, -7.92774558e-02f, -7.11996183e-02f, 8.85418653e-02f, 4.32606898e-02f, 2.11506896e-02f, -1.40947290e-02f, 4.33875658e-02f,
  -1.41364887e-01f, -1.25407562e-01f, -7.70229846e-02f, -8.18567574e-02f, -1.24237254e-01f, -2.20427200e-01f, -2.07217216e-01f, -1.76972717e-01f, 6.00572005e-02f, -1.38014788e-03f,
  -2.18082160e-01f, -5.65838441e-03f, 3.23270936e-03f, -1.77993327e-01f, 7.14193285e-02f, 2.55191445e-01f, -1.50910765e-01f, -9.81696472e-02f, 3.36906463e-02f, -1.56954154e-01f,
  6.36297241e-02f, -5.67089841e-02f, 7.10867271e-02f, -1.34418562e-01f, -1.17264785e-01f, -3.40334140e-02f, 1.48860989e-02f, -6.05113022e-02f, -1.11224487e-01f, -9.33894441e-02f,
  1.45590864e-02f, 1.39088288e-01f, -4.45959084e-02f, -1.03889750e-02f, -1.16892077e-01f, -7.18551353e-02f, -5.01996465e-02f, 8.64484906e-03f, 4.27453592e-02f, -9.93544385e-02f,
  1.55786928e-02f, -3.39101069e-02f, -6.43822700e-02f, -7.48013481e-02f, -9.64081585e-02f, -3.24667171e-02f, 4.48580422e-02f, 1.79355145e-02f, -3.73219773e-02f, 6.54048100e-02f,
  -1.14005804e-01f, -2.19864119e-02f, -1.16485904e-03f, 8.36846307e-02f, -6.68276027e-02f, -1.72826387e-02f, 4.70708162e-02f, 4.50601131e-02f, 4.13821489e-02f, 1.99850518e-02f,
  -3.47064547e-02f, 4.09750193e-02f, 4.71515507e-02f, -1.00086637e-01f, -3.97796035e-02f, -6.69792295e-03f, -4.39859368e-03f, 3.74946222e-02f, 8.29137638e-02f, -3.55722345e-02f,
  -5.58805577e-02f, 8.41005743e-02f, -4.33090255e-02f, 7.02564344e-02f, -7.31868222e-02f, 1.30605372e-02f, 7.80021548e-02f, -9.69368778e-03f, -9.21238363e-02f, 7.11764619e-02f,
  -2.94458889e-03f, 4.23514061e-02f, 1.16922006e-01f, 6.84205815e-02f, -4.96628769e-02f, -5.20000234e-03f, -4.04864140e-02f, 5.95014468e-02f, 3.50299478e-02f, 3.45385931e-02f,
  -8.11154246e-02f, -5.76045513e-02f, -4.90045920e-02f, 2.99676303e-02f, 2.55623572e-02f, -7.43178725e-02f, -2.79399976e-02f, -1.13066517e-01f, -1.72787067e-02f, 1.39786443e-03f,
  7.79347029e-03f, 2.10968386e-02f, 3.06520667e-02f, 7.07145855e-02f, -7.17811957e-02f, -5.54773398e-02f, -5.58895543e-02f, -2.81720161e-02f, 5.27119450e-02f, -8.84175152e-02f,
  -5.74783534e-02f, -1.31271472e-02f, 1.01944327e-01f, 8.50561336e-02f, 7.85232037e-02f, -9.37594399e-02f, 1.65895298e-02f, -3.62203829e-02f, 8.06996692e-03f, -5.75727448e-02f,
  -7.02220276e-02f, 6.63284808e-02f, -3.81035618e-02f, -7.11978152e-02f, 8.57284218e-02f, 6.03681765e-02f, -1.70872174e-02f, -2.75645200e-02f, -1.12417281e-01f, 6.91323355e-02f,
  -4.71072793e-02f, 8.17690492e-02f, -2.49461997e-02f, 2.43714415e-02f, 5.00513501e-02f, -3.96017842e-02f, 2.65981983e-02f, -4.69720773e-02f, -3.80249172e-02f, 5.43098897e-02f,
  2.59125186e-03f, 5.52753583e-02f, -6.71986267e-02f, -7.06173554e-02f, -2.29506288e-03f, -6.35644644e-02f, -6.63391426e-02f, -6.05836175e-02f, 5.67451306e-02f, -6.10438064e-02f,
  -1.08353563e-01f, 1.33145628e-02f, 3.89667675e-02f, -4.19609211e-02f, 2.45309565e-02f, 2.47362759e-02f, 3.84303704e-02f, 1.49631361e-02f, 2.25776620e-02f, 4.76491228e-02f,
  -4.22315160e-03f, -7.21174404e-02f, -6.97908401e-02f, -8.84928256e-02f, -1.19686057e-03f, 3.01845232e-03f, -3.09772845e-02f, -3.12529020e-02f, -7.50729872e-04f, 2.34886557e-02f,
  5.85155189e-02f, 6.88574836e-02f, -4.91004298e-03f, 8.30579177e-02f, -3.21996175e-02f, 1.41349230e-02f, 4.08660173e-02f, 4.49245498e-02f, -6.91506453e-03f, 7.95600712e-02f,
  1.09951012e-02f, -3.16081308e-02f, 7.48725317e-04f, -2.14167070e-02f, 1.79575775e-02f, -5.97779751e-02f, 4.09102142e-02f, -4.29690490e-03f, 2.83804554e-02f, -3.95110212e-02f,
  -9.23854113e-02f, -1.75587449e-03f, 5.41702174e-02f, 1.75749175e-02f, -1.11524174e-02f, 6.41152114e-02f, 9.75525193e-03f, 4.81618196e-02f, -2.95648985e-02f, -6.23444840e-02f,
  -8.36637467e-02f, -7.92903230e-02f, 2.64847539e-02f, 2.87388265e-02f, -8.10555816e-02f, -5.25365509e-02f, -3.40471342e-02f, -1.47350794e-02f, -2.43637711e-02f, -4.70092669e-02f,
  7.29952827e-02f, -3.25649008e-02f, 2.54203305e-02f, -8.57556015e-02f, 5.88298738e-02f, -8.64365622e-02f, 1.71602014e-02f, -1.53096560e-02f, 2.55821478e-02f, -4.16245870e-02f,
  -7.42982104e-02f, 8.34817439e-02f, -2.49000378e-02f, 2.49527749e-02f, 2.78436299e-02f, -1.43210869e-02f, -7.87661895e-02f, 3.59688960e-02f, 4.65780161e-02f, -7.48474970e-02f,
  8.72486159e-02f, -7.33297169e-02f, -5.69842681e-02f, -4.47099917e-02f, -5.99632412e-02f, -1.28374826e-02f, -7.44396448e-02f, 8.30803514e-02f, -1.62300095e-02f, 7.11448565e-02f,
  -1.01145796e-01f, -3.04161534e-02f, 7.23326877e-02f, -6.77615032e-02f, -1.20694369e-01f, -9.42895338e-02f, 7.96839148e-02f, -1.96930952e-02f, 1.92079693e-02f, 9.41114053e-02f,
  8.63458589e-02f, -1.05187790e-02f, -7.38006830e-03f, 2.88098380e-02f, 6.58878908e-02f, 6.72515184e-02f, -8.94129276e-03f, -7.83458911e-03f, -6.49567395e-02f, -7.93579444e-02f,
  -4.40900885e-02f, 1.42169427e-02f, 1.10192103e-02f, -9.99979675e-02f, -1.50905540e-02f, -1.11709256e-02f, -2.43990254e-02f, -5.66335283e-02f, 1.01659596e-01f, 9.12572071e-02f,
  -4.65001464e-02f, 1.40775938e-03f, -7.31791556e-02f, 6.35156268e-03f, 3.45506258e-02f, 4.01525274e-02f, -1.53442030e-03f, 3.15612741e-02f, -9.08244178e-02f, 4.06335928e-02f,
  9.44803953e-02f, -2.35080495e-02f, 6.71309279e-03f, 1.60649382e-02f, 2.78813159e-03f, -8.70973803e-03f, 2.86289621e-02f, 7.57133290e-02f, 2.36083083e-02f, -1.88636370e-02f,
  8.04528594e-02f, -1.80503912e-02f, -1.67173147e-02f, -1.18689137e-02f, -7.47597367e-02f, 1.39135709e-02f, -1.46945026e-02f, -6.12295978e-02f, 4.41152975e-02f, 3.24974842e-02f,
  -3.25965206e-03f, 3.04017905e-02f, 1.41906943e-02f, -3.72773372e-02f, 1.91681311e-02f, 8.45792890e-02f, 6.47790283e-02f, 6.82181045e-02f, 7.11027160e-02f, -6.39470816e-02f,
  5.63558750e-02f, -6.07479215e-02f, -8.58046785e-02f, -3.32512110e-02f, 4.90454186e-05f, 2.70626694e-02f, -4.65967134e-02f, 6.30362183e-02f, 5.72351217e-02f, 2.78225560e-02f,
  -2.03827093e-03f, 4.11495529e-02f, 1.17875330e-01f, 4.39470895e-02f, 3.89495939e-02f, -2.97930297e-02f, -4.18081582e-02f, -3.85420024e-03f, 5.32082595e-05f, -8.86581019e-02f,
  3.59503739e-02f, 1.16137110e-01f, -5.61911426e-02f, -6.73549548e-02f, 1.15805175e-02f, 2.00650934e-02f, -7.29505066e-03f, -5.71963377e-02f, -3.63575183e-02f, -6.95921332e-02f,
  -9.11001787e-02f, 5.31951264e-02f, -6.89000711e-02f, 3.94445993e-02f, -2.04988979e-02f, 6.86413571e-02f, -3.61063406e-02f, -4.35986221e-02f, -5.98959066e-03f, 5.21725193e-02f,
  9.81602259e-03f, -4.07369174e-02f, -3.54056172e-02f, 4.80189547e-02f, 2.37974674e-02f, 2.40405668e-02f, 6.31696954e-02f, 3.80340517e-02f, 2.47700196e-02f, 8.21918622e-02f,
  -3.47357392e-02f, -1.45300813e-02f, -6.71580210e-02f, 4.77088690e-02f, -1.48829641e-02f, 1.68673158e-01f, 2.44852304e-01f, -1.29581586e-01f, -1.24354556e-01f, 1.28926128e-01f,
  2.45171651e-01f, -3.85696664e-02f, 2.30709568e-01f, 1.12033002e-01f, 9.72148553e-02f, 1.85538128e-01f, 1.59726396e-01f, 1.96738943e-01f, -1.59218892e-01f, -7.62306377e-02f,
  -1.45401374e-01f, 8.99862200e-02f, 1.04936346e-01f, -9.82641503e-02f, 1.23599589e-01f, -1.11134022e-01f, 6.01543635e-02f, -8.35724827e-03f, 9.59709585e-02f, -1.22939553e-02f,
  3.15260515e-02f, -9.88249183e-02f, 3.84929180e-02f, 2.65815272e-03f, -5.54450043e-02f, -6.60687014e-02f, 1.62793305e-02f, 1.13025934e-01f, -2.99687516e-02f, -6.46331087e-02f,
  5.64477630e-02f, -1.91785917e-02f, -2.95017250e-02f, -2.88107917e-02f, -4.23833244e-02f, -1.13727868e-01f, -1.65353343e-02f, 9.64602008e-02f, -6.04654476e-02f, 2.02478990e-02f,
  -3.44772562e-02f, -2.52757203e-02f, 7.69126490e-02f, 1.54596316e-02f, -2.10506711e-02f, -3.55737028e-03f, -2.48990022e-02f, 3.85688357e-02f, -5.36203617e-03f, -7.38205165e-02f,
  3.16244438e-02f, -2.52405740e-02f, 2.39570495e-02f, 5.85223734e-02f, 2.00092588e-02f, -4.37316485e-02f, 6.89708441e-02f, 4.74721082e-02f, 5.51454090e-02f, 5.26126288e-02f,
  -9.38683003e-02f, 5.63495047e-02f, -7.18425661e-02f, -1.43278493e-02f, -1.58592574e-02f, -3.75968255e-02f, -5.21762036e-02f, 1.72671629e-04f, -4.26567234e-02f, 2.09022649e-02f,
  7.98650235e-02f, 5.30394763e-02f, -1.65031501e-03f, -9.17094178e-04f, 5.35317324e-02f, 1.39099937e-02f, -6.55505946e-03f, -4.87225726e-02f, -5.88972755e-02f, 5.76781631e-02f,
  8.23611692e-02f, -6.92466497e-02f, 6.10496011e-03f, -7.70001411e-02f, -3.16474400e-02f, 6.34119958e-02f, -2.57402728e-03f, -3.29374820e-02f, -6.05251230e-02f, 4.46180180e-02f,
  -2.81425081e-02f, -8.28923732e-02f, -1.02223270e-01f, 3.06626577e-02f, -1.44758332e-03f, -1.84859335e-02f, -3.38866487e-02f, -1.23063773e-02f, 1.88999213e-02f, -4.20102058e-03f,
  -2.40799226e-02f, -5.14611974e-02f, -4.28400300e-02f, -5.36344154e-03f, -1.58839300e-02f, 4.19050083e-02f, -1.09502085e-01f, 4.70505375e-03f, -6.81466833e-02f, -8.71289149e-02f,
  1.88928187e-01f, 1.86996982e-02f, -9.07416046e-02f, -1.09684445e-01f, -6.13703728e-02f, 1.14134268e-03f, 8.86268972e-04f, -1.31375059e-01f, 3.41263935e-02f, -1.45704038e-02f,
  3.53679769e-02f, 6.48272261e-02f, 1.36133000e-01f, 6.91885948e-02f, 1.85363859e-01f, 1.59140274e-01f, 3.26740667e-02f, 9.30236056e-02f, 6.70981631e-02f, 8.31789002e-02f,
  9.04522017e-02f, 1.51287526e-01f, 1.00904934e-01f, -1.80428978e-02f, -1.47086214e-02f, -6.04814477e-02f, 4.03247252e-02f, 2.55035125e-02f, -5.89943603e-02f, 1.94619000e-02f,
  5.87395392e-02f, 1.39471233e-01f, -4.87713404e-02f, -7.89935235e-03f, 7.60165527e-02f, 7.21967071e-02f, 2.29155794e-02f, 2.16475315e-02f, 6.44807667e-02f, 5.72384298e-02f,
  -3.27856629e-03f, -3.06716282e-02f, 9.89660621e-03f, 1.79928690e-02f, -9.18723047e-02f, 6.23089857e-02f, 1.82399340e-02f, -4.10390720e-02f, -7.33326524e-02f, -3.57815214e-02f,
  -7.98554793e-02f, -3.47993523e-02f, 7.40181794e-03f, -5.07051162e-02f, 1.66764166e-02f, -2.99959034e-02f, 6.93971175e-04f, -3.24382782e-02f, -6.14094175e-02f, 4.64986637e-02f,
  -3.18377353e-02f, -6.69697183e-04f, 1.24076614e-03f, -9.03651193e-02f, 9.83484276e-03f, 6.65766075e-02f, -5.80105595e-02f, 7.06818625e-02f, -4.05982770e-02f, -3.81709449e-02f,
  4.63245325e-02f, 1.96391921e-02f, 2.71079596e-02f, -1.45545155e-02f, 8.66645109e-03f, -9.62348953e-02f, -1.11227306e-02f, -7.66717419e-02f, 1.22377798e-02f, 6.38401955e-02f,
  -4.41343226e-02f, 7.36939311e-02f, -2.11960934e-02f, 6.34225309e-02f, -6.31012544e-02f, 8.72684270e-02f, 4.56958674e-02f, 9.07866135e-02f, -2.40116920e-02f, -1.62216451e-03f,
  2.08992641e-02f, 2.16307882e-02f, 4.05911431e-02f, -3.76617722e-02f, -7.13693723e-02f, 1.28886262e-02f, 1.71813164e-02f, -7.49820173e-02f, 7.08497539e-02f, 1.93645246e-02f,
  4.17245813e-02f, 4.11804914e-02f, 2.99454574e-02f, -1.68875251e-02f, 5.34559414e-02f, 9.49299254e-04f, 3.98051525e-05f, 4.40961532e-02f, 1.90825015e-02f, -6.83034435e-02f,
  6.43837303e-02f, 8.23111534e-02f, -4.98752743e-02f, 6.46717846e-02f, 5.06648459e-02f, -5.87858818e-03f, -8.89944658e-02f, -8.87489133e-03f, -1.76928788e-02f, 2.30253413e-02f,
  1.58697870e-02f, 2.58473661e-02f, 2.14399591e-01f, -1.10035114e-01f, -2.24711560e-02f, 1.28885973e-02f, 1.70984074e-01f, -7.69819990e-02f, -1.66810617e-01f, -1.15737997e-01f,
  -3.09724882e-02f, -8.52176454e-03f, 2.47513920e-01f, -6.38502985e-02f, 2.07544819e-01f, 1.90754980e-01f, 1.69440936e-02f, 4.76460867e-02f, 1.89583171e-02f, -2.77368743e-02f,
  -3.50410007e-02f, -1.24975301e-01f, 1.35876074e-01f, -1.36402354e-01f, -9.11062001e-04f, -7.18995556e-02f, 2.23072376e-02f, 1.99910268e-01f, -8.37215185e-02f, 9.88833606e-02f,
  2.66284235e-02f, -8.29844773e-02f, -8.92107561e-02f, -1.17159896e-01f, -3.60708348e-02f, 8.63621235e-02f, 9.09696240e-03f, 4.84008081e-02f, -1.03051431e-01f, -6.98433816e-02f,
  -2.06379816e-02f, 3.91487330e-02f, -7.06695318e-02f, 2.67481208e-02f, -1.04210779e-01f, -7.61167333e-02f, -9.82726738e-03f, -4.82907258e-02f, 9.34059173e-03f, 8.36849213e-02f,
  1.00948483e-01f, 1.18020352e-03f, -1.32484464e-02f, 2.96609271e-02f, -2.48468705e-02f, -3.01010218e-02f, 9.82880685e-03f, 6.98093995e-02f, -8.32172576e-03f, -6.59341887e-02f,
  3.32764797e-02f, 6.48874789e-02f, -4.78911363e-02f, -3.82271893e-02f, 2.25035157e-02f, -7.94022381e-02f, -8.64191353e-02f, 1.60770733e-02f, 4.65561040e-02f, 3.72930057e-02f,
  -8.28125775e-02f, 4.32783086e-03f, -1.81873161e-02f, 6.21087812e-02f, -1.07524893e-03f, -4.72523309e-02f, 1.29946508e-02f, 1.26208579e-02f, 5.70211634e-02f, -6.76818490e-02f,
  1.27189923e-02f, -8.43097940e-02f, 7.16993883e-02f, 2.27932632e-02f, 1.31418733e-02f, 1.53659722e-02f, 5.97801246e-02f, 9.55894515e-02f, 4.23397422e-02f, 6.55220076e-02f,
  -6.97726160e-02f, -8.57174844e-02f, -1.24066874e-01f, -2.82561202e-02f, 3.21321450e-02f, -3.37570235e-02f, -2.93458886e-02f, -5.20778857e-02f, 3.35478112e-02f, -7.84346014e-02f,
  -4.20947932e-02f, 8.48847032e-02f, -1.04891375e-01f, 1.95435627e-04f, 3.75662744e-02f, -1.04244836e-01f, -4.49084044e-02f, 6.54273340e-03f, -6.52652904e-02f, 6.38242951e-03f,
  -1.06198356e-01f, 1.98056456e-02f, 3.86866741e-02f, -6.31805649e-03f, -5.36932871e-02f, 3.36016677e-02f, -4.88701239e-02f, 3.22717540e-02f, 5.68124317e-02f, 4.42780182e-02f,
  1.83375217e-02f, -2.02589259e-02f, -1.20859928e-01f, -3.65412794e-02f, -5.35530299e-02f, -2.56336659e-01f, -1.17229447e-01f, -3.33940499e-02f, -1.68174859e-02f, 2.62776017e-02f,
  4.83700000e-02f, 5.26702851e-02f, 3.90010998e-02f, -1.70006528e-01f, -9.21744108e-02f, 2.03935746e-02f, -1.32409036e-01f, -4.64935377e-02f, -4.13022712e-02f, -4.55594156e-03f,
  6.91713244e-02f, -1.05727777e-01f, -1.08431548e-01f, 7.10901171e-02f, -1.22176714e-01f, -4.60315943e-02f, 1.62005916e-01f, 6.14312366e-02f, -3.11518423e-02f, 3.17939394e-03f,
  -6.98842555e-02f, 1.63025171e-01f, 5.28890081e-02f, 3.40839401e-02f, 3.98574173e-02f, 2.40115207e-02f, 3.01479567e-02f, -6.43383637e-02f, -6.83834180e-02f, -1.00482680e-01f,
  2.15719920e-02f, 2.66604815e-02f, 3.42556275e-03f, 2.52711568e-02f, -6.30557463e-02f, 6.04434684e-02f, -4.44539897e-02f, -1.89043544e-02f, 3.81246419e-03f, -6.22337498e-02f,
  -1.39000759e-01f, 6.61591068e-02f, -8.32169410e-03f, -8.01736042e-02f, 2.99457554e-02f, -4.10778783e-02f, -1.18253037e-01f, -3.14231515e-02f, -3.92731912e-02f, 4.11217958e-02f,
  -4.95138019e-02f, 3.55192162e-02f, 2.41788086e-02f, 4.15810123e-02f, -4.49242406e-02f, 3.71347554e-02f, -7.19200149e-02f, 2.91135423e-02f, -5.99961989e-02f, -2.66170464e-02f,
  4.36572060e-02f, -4.44537252e-02f, 1.85075905e-02f, -4.48771678e-02f, -2.85600945e-02f, 1.07073158e-01f, -7.76567012e-02f, -2.79083103e-02f, -1.07152775e-01f, -9.91984606e-02f,
  2.79674996e-02f, 2.04706434e-02f, 2.62041353e-02f, -6.52570128e-02f, -2.50848625e-02f, -2.50407327e-02f, -7.57533312e-02f, 7.62276351e-02f, -5.70024662e-02f, 6.50969371e-02f,
  7.96168745e-02f, 1.48368732e-03f, 2.22457629e-02f, 3.67803336e-03f, 1.12117482e-02f, 5.81040867e-02f, -1.06347218e-01f, -7.91087002e-02f, -6.44110218e-02f, 2.42210496e-02f,
  5.38047850e-02f, -1.83723178e-02f, -3.76631832e-03f, 3.63717563e-02f, 1.27233472e-02f, 7.36783445e-02f, 6.55080844e-03f, -8.86140689e-02f, -7.73947537e-02f, -6.21698387e-02f,
  6.16828911e-02f, 4.24631871e-02f, -1.13246534e-02f, 4.71150912e-02f, 8.48574489e-02f, -3.59959528e-02f, -3.64208966e-02f, -3.51356678e-02f, 2.23084986e-02f, 7.36396760e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.15708075e-01f, 9.36966389e-02f, 1.12619705e-01f, 8.64141993e-03f, -6.00145757e-03f, -9.23088863e-02f, -1.04159862e-02f, 2.21205186e-02f, 1.26030892e-01f, 1.13453060e-01f,
  6.91122785e-02f, -2.53877304e-02f, 5.05573675e-02f, 1.54353678e-02f, 1.85913220e-01f, 1.36234179e-01f, -1.96698078e-04f, 4.25267480e-02f, -8.52046832e-02f, -1.20996432e-02f,
  7.61820450e-02f, 3.70445736e-02f, -7.34484717e-02f, 8.52408409e-02f, 1.48185343e-03f, 2.61666235e-02f, 4.11959812e-02f, -6.83741197e-02f, -6.83412030e-02f, 7.73334270e-03f,
  -7.00335205e-03f, 7.61010200e-02f, 5.96239790e-02f, -1.93659998e-02f, 1.66190788e-01f, 2.03379374e-02f, 3.32330144e-03f, 1.21477008e-01f, 1.78391397e-01f, 4.92238700e-02f,
  1.55602396e-01f, -2.63198130e-02f, -1.13071002e-01f, 2.44018324e-02f, -6.49754480e-02f, -1.25917867e-02f, 1.98226282e-03f, 3.36293271e-03f, 9.86198708e-02f, 2.13672742e-01f,
  9.03201625e-02f, 1.28723821e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.30178213e-01f, 5.94875868e-03f, 2.70355642e-01f, -5.24142617e-03f, -7.73743689e-02f, -7.20086545e-02f, 3.13649178e-01f, 1.29318625e-01f, 1.53776333e-01f, -1.19819030e-01f,
  6.28475770e-02f, 2.74260193e-01f, -6.37665205e-03f, -9.39269215e-02f, 1.09475069e-01f, 1.18787572e-01f, -1.42110825e-01f, 2.86210299e-01f, 1.36862010e-01f, 1.46523919e-02f,
  -7.51124322e-02f, 1.20754810e-02f, -1.28445625e-01f, -1.81754842e-01f, 2.91258711e-02f, 7.58450255e-02f, -1.66613162e-01f, -1.74785152e-01f, -9.05430168e-02f, 6.07608855e-02f,
  -1.34446010e-01f, 6.07418176e-03f, 2.52618734e-02f, -3.41590941e-02f, 6.31210804e-02f, -1.03498911e-02f, -3.01465653e-02f, -1.51050493e-01f, -1.17831878e-01f, 1.14316091e-01f,
  3.68553214e-02f, 1.25202581e-01f, 1.07132725e-01f, 5.42985089e-02f, -8.27726629e-03f, 1.44858481e-02f, 1.89863387e-02f, 4.33008671e-02f, -7.33414963e-02f, 1.21132679e-01f,
  1.25732273e-01f, 8.60875845e-02f, 6.51336387e-02f, 1.53221637e-01f, -1.19884074e-01f, 2.52928119e-02f, -2.02553291e-02f, 1.42787904e-01f, -9.07857195e-02f, 7.48933777e-02f,
  8.46077949e-02f, 7.01407790e-02f, 9.99105647e-02f, -4.35675308e-02f, 2.48020187e-01f, 1.89441860e-01f, 2.96048164e-01f, 1.67738646e-01f, -1.22109249e-01f, -5.19284159e-02f,
  3.85761529e-01f, -1.45751059e-01f, 2.22527355e-01f, -2.46902451e-01f, -7.27841407e-02f, 3.00547451e-01f, -7.08961561e-02f, -6.14946559e-02f, 1.66363902e-02f, -9.67221335e-03f,
  -1.16778925e-01f, 1.78494468e-01f, 3.74967903e-02f, 1.41194582e-01f, -1.16392002e-01f, -3.24070528e-02f, -1.38601229e-01f, -7.41531625e-02f, 1.43403962e-01f, -1.06453016e-01f,
  -1.38928711e-01f, -1.84713975e-01f, -1.12793654e-01f, -2.68430375e-02f, -1.31843984e-01f, 1.09930284e-01f, 1.54785305e-01f, 1.55575022e-01f, 9.66059342e-02f, 3.36755700e-02f,
  -1.18944868e-01f, -1.21717982e-01f, -1.55701488e-01f, 9.27194953e-02f, 3.20638455e-02f, 1.19115226e-01f, 1.98550522e-01f, 4.57030907e-02f, 3.49008814e-02f, -5.82103850e-03f,
  6.51841844e-03f, 8.47349167e-02f, -7.42504075e-02f, -5.19104162e-03f, 1.37364030e-01f, 7.40918815e-02f, 2.57321801e-02f, -3.87845398e-03f, -6.52356818e-02f, -3.16477455e-02f,
  1.76275335e-02f, 1.93769425e-01f, 1.13432445e-01f, 2.16224100e-02f, -5.68121299e-03f, -1.50731295e-01f, -8.03461298e-02f, 1.48867399e-01f, -1.48680910e-01f, 1.88041165e-01f,
  -8.95111077e-03f, -2.88118385e-02f, 7.07474947e-02f, -6.03977926e-02f, -1.78841606e-01f, -6.20018616e-02f, -9.62912589e-02f, -8.81427005e-02f, 4.71857097e-03f, -2.24201769e-01f,
  1.03328908e-02f, 1.80750471e-02f, -8.74987468e-02f, -8.08525532e-02f, 1.42589778e-01f, -9.33328941e-02f, -2.19877601e-01f, -1.55064771e-02f, 3.05266194e-02f, -5.17714508e-02f,
  1.06039964e-01f, 5.16277812e-02f, 1.18524946e-01f, -6.08872436e-02f, 6.24067038e-02f, 2.10199840e-02f, 5.91228670e-03f, 5.35987392e-02f, 6.65384606e-02f, -9.25084949e-02f,
  7.59881735e-02f, -5.73696159e-02f, 2.69163698e-02f, -8.99684951e-02f, 1.47333592e-01f, -2.34454186e-04f, 7.66873658e-02f, -9.67825130e-02f, -7.72076920e-02f, 5.80782928e-02f,
  -2.79059540e-02f, 1.40012488e-01f, 1.18535958e-01f, -4.95992489e-02f, -1.52204320e-01f, 7.12633431e-02f, 1.16967410e-01f, 5.29576326e-03f, -6.02575205e-02f, 1.20328717e-01f,
  -1.12128824e-01f, -1.04617320e-01f, 6.13896921e-02f, 5.10349078e-03f, -8.08465257e-02f, 3.78293023e-02f, -4.96155992e-02f, -1.53343067e-01f, -1.14062488e-01f, -3.16111967e-02f,
  1.07001647e-01f, -1.16767704e-01f, 4.47554030e-02f, -4.85938638e-02f, 5.91044500e-02f, 1.19768612e-01f, -7.74476379e-02f, -1.97585430e-02f, -1.56549029e-02f, 2.47832388e-01f,
  2.44374767e-01f, 1.35569766e-01f, -2.10600555e-01f, 2.69550830e-01f, 1.99646633e-02f, 1.26672998e-01f, 5.04371105e-03f, -5.74882478e-02f, 1.25004753e-01f, -1.01062566e-01f,
  5.47337607e-02f, 1.24566361e-01f, -6.48455471e-02f, 5.33878766e-02f, 8.49379785e-03f, -2.07275674e-02f, 4.14974652e-02f, -1.19007910e-02f, -2.02641308e-01f, 9.61569026e-02f,
  2.22467650e-02f, 1.32870093e-01f, 1.00318618e-01f, 3.69790904e-02f, 9.29500982e-02f, -1.54470699e-02f, -4.68171090e-02f, -1.32806554e-01f, -5.17066978e-02f, 7.24438950e-02f,
  -5.37184775e-02f, -8.92641246e-02f, 3.71172279e-02f, 6.38085380e-02f, -5.72708659e-02f, -5.08881621e-02f, -1.11622266e-01f, -9.82857421e-02f, 6.10407442e-02f, 1.55334234e-01f,
  -5.72898239e-02f, 6.65404797e-02f, -6.02226816e-02f, 9.87037867e-02f, 3.80625837e-02f, 4.10033166e-02f, 1.71485320e-01f, 5.88884279e-02f, -5.48489168e-02f, -1.57099277e-01f,
  1.07675366e-01f, 4.20706347e-02f, 1.47865266e-01f, 5.29843569e-02f, -1.77925497e-01f, 7.01810420e-02f, 1.03259891e-01f, 9.33245663e-03f, 1.41534731e-01f, 5.78266382e-02f,
  1.18280742e-02f, 1.36390090e-01f, -1.79330215e-01f, -7.51352087e-02f, -1.81751549e-02f, -9.95802060e-02f, 1.88105956e-01f, -3.11928988e-03f, 1.37261868e-01f, -7.64203444e-02f,
  1.65600061e-01f, -3.82660702e-02f, 5.16835004e-02f, 8.77631158e-02f, -6.97861565e-03f, 2.42978358e-03f, -2.23029763e-01f, -5.93713596e-02f, 8.90798345e-02f, -2.99900342e-02f,
  -1.26113323e-02f, -1.79303110e-01f, 9.09144245e-03f, -1.82885155e-01f, 8.73484984e-02f, 4.85158898e-02f, 1.71799008e-02f, -8.36267620e-02f, -1.76445454e-01f, 1.52640110e-02f,
  1.45060971e-01f, -3.30525264e-02f, -4.03097197e-02f, -1.89177305e-01f, -3.04433759e-02f, -5.76584153e-02f, 1.13234378e-01f, 4.27349061e-02f, 1.18741222e-01f, -2.19996478e-02f,
  1.33080423e-01f, 8.55038762e-02f, 1.54912814e-01f, -6.51144385e-02f, -6.85261339e-02f, -5.55214062e-02f, 4.04305290e-03f, -4.74997610e-02f, 9.74374115e-02f, 5.23274094e-02f,
  -1.74387485e-01f, -1.15029804e-01f, -6.30235896e-02f, 6.17929585e-02f, -1.44585177e-01f, 1.28067032e-01f, 1.97924346e-01f, 8.63266960e-02f, 2.67804205e-01f, 2.97331586e-02f,
  -3.12537514e-02f, 5.41583039e-02f, -1.01631902e-01f, 5.44555746e-02f, 7.29212314e-02f, 5.79377934e-02f, 1.31250560e-01f, -1.36860669e-01f, -2.91230120e-02f, 4.90998365e-02f,
  -1.72469661e-01f, -5.80791682e-02f, 5.23996688e-02f, -1.51438117e-01f, -2.20265076e-01f, 9.66798961e-02f, 2.32658628e-02f, -2.10881695e-01f, -2.25767344e-01f, 7.78282136e-02f,
  2.69715577e-01f, 4.69624996e-03f, -1.75112709e-02f, -4.21078652e-02f, -8.32218211e-03f, 1.23475984e-01f, -1.54257908e-01f, 2.60087401e-01f, 1.12524390e-01f, -3.88803706e-02f,
  5.58300428e-02f, -9.64388028e-02f, 2.44134590e-01f, 1.70065850e-01f, -7.60522783e-02f, 1.20378904e-01f, 1.39535666e-01f, 2.47873694e-01f, -1.39399767e-01f, -1.09998830e-01f,
  -7.26742297e-02f, 3.74846943e-02f, 3.06288134e-02f, -9.78091434e-02f, -1.65368970e-02f, 5.04170218e-03f, -1.20136030e-01f, -6.42219186e-02f, -1.39071003e-01f, 7.25005716e-02f,
  -2.79519148e-02f, 2.18586087e-01f, 6.88116923e-02f, -9.92217138e-02f, 7.17151314e-02f, -5.61581552e-02f, -4.86449227e-02f, -1.55531749e-01f, 8.70458931e-02f, 1.41313970e-02f,
  -2.34966680e-01f, -1.78210467e-01f, -1.80004239e-01f, 9.61402580e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.08008109e-01f, 7.85032734e-02f, 1.94660053e-01f, 5.16933575e-02f, 1.86619567e-04f, -5.84983751e-02f, 1.12446025e-01f, -1.01101220e-01f, -3.79173830e-02f, -3.13437730e-02f,
  -3.00047845e-02f, 9.95557830e-02f, -8.28503594e-02f, -6.82266653e-02f, 1.03416637e-01f, -7.02433810e-02f, -1.14795126e-01f, 3.33634275e-03f, 5.25853336e-02f, 3.62954214e-02f,
  9.65261310e-02f, -7.18670934e-02f, 8.02691206e-02f, -1.28863618e-01f, 1.02211289e-01f, 1.03692830e-01f, 9.32994038e-02f, -9.28411447e-03f, -3.06491908e-02f, 9.48923901e-02f,
  4.44651097e-02f, -3.24791744e-02f, 8.96443147e-03f, -1.05918627e-02f, -3.98359299e-02f, 1.63488641e-01f, -1.14947595e-01f, -1.15702733e-01f, -1.35546038e-02f, -7.16382563e-02f,
  -3.90624139e-03f, -9.79980081e-02f, 7.13588968e-02f, 1.48041591e-01f, 5.02088442e-02f, -9.88268107e-02f, -7.18855951e-03f, -2.55633648e-02f, 7.37515092e-02f, 3.73002142e-02f,
  9.44277123e-02f, 9.61696655e-02f, 5.42241037e-02f, -6.92447796e-02f, -4.53735925e-02f, 5.68391606e-02f, -1.03108943e-01f, 1.09845893e-02f, 5.89125277e-03f, -5.06492332e-02f,
  1.27724709e-03f, 1.22242630e-01f, -6.26824871e-02f, 1.71875264e-02f, 1.22870831e-02f, 6.37096763e-02f, 1.33633003e-01f, 1.47982035e-02f, 8.15896243e-02f, 1.03245459e-01f,
  2.16193289e-01f, 2.69855820e-02f, -2.01921891e-02f, -1.81119949e-01f, 7.43195340e-02f, 2.74251942e-02f, 4.39110398e-02f, -1.94778889e-02f, -1.96086410e-02f, 5.75559586e-02f,
  -1.14178836e-01f, 6.29612729e-02f, -4.73067723e-02f, -1.12662753e-02f, 5.07001393e-02f, -6.47493405e-04f, 9.65962261e-02f, -8.91059563e-02f, -5.78346774e-02f, 1.28275171e-01f,
  -9.12476555e-02f, -3.90538611e-02f, 6.59808740e-02f, -7.74674490e-02f, -1.09921210e-02f, 1.68262981e-02f, -6.40632734e-02f, -5.28927594e-02f, 1.05892926e-01f, 3.30484100e-02f,
  3.32850479e-02f, -5.08576520e-02f, -9.19351280e-02f, 1.58933480e-03f, -4.43842914e-03f, 1.24813169e-01f, 4.95311655e-02f, -8.29461962e-02f, -7.84955025e-02f, -7.48249367e-02f,
  7.63860196e-02f, -1.00506335e-01f, 4.41425703e-02f, 9.50965360e-02f, 2.05377817e-01f, -5.50501309e-02f, 1.50119185e-01f, -9.56555363e-03f, -1.87480636e-02f, -5.88325858e-02f,
  3.66856568e-02f, 5.23229018e-02f, -1.77347343e-02f, 1.45499438e-01f, 6.79950863e-02f, -3.72706465e-02f, -2.57394947e-02f, 4.25952822e-02f, -9.94906295e-04f, -3.58776785e-02f,
  2.64457855e-02f, 1.49175012e-02f, -9.55282003e-02f, -5.38443476e-02f, 3.10028773e-02f, 4.03863117e-02f, 1.49954222e-02f, -8.61782804e-02f, -2.54466590e-02f, 1.36073500e-01f,
  1.14488706e-01f, 9.97951031e-02f, 3.49732898e-02f, -1.23331949e-01f, 1.19314916e-01f, 1.80173963e-01f, 7.27548404e-03f, -5.60062081e-02f, -2.99109463e-02f, 1.66770414e-01f,
  1.02738999e-01f, -1.03360347e-01f, -7.01405779e-02f, 3.88843603e-02f, 1.61599070e-02f, -5.41350571e-03f, 5.25481924e-02f, -1.17226942e-02f, 1.41500950e-01f, 1.65596634e-01f,
  1.73322693e-03f, -8.91807452e-02f, -1.75999459e-02f, 2.98042037e-02f, 8.70672390e-02f, 9.08890646e-03f, 7.44572803e-02f, 1.24298871e-01f, 1.48413451e-02f, 6.82655796e-02f,
  1.27056912e-01f, -1.14121154e-01f, -9.72924009e-02f, 4.93257716e-02f, -7.99965393e-03f, -1.06397241e-01f, -5.47682121e-02f, 1.55967763e-02f, -4.09619696e-02f, -1.50852930e-02f,
  1.29324809e-01f, 5.36196642e-02f, -3.54218781e-02f, -5.34199364e-02f, 1.26968697e-01f, 1.98118463e-01f, 2.49748901e-02f, -4.18185955e-03f, 1.60329029e-01f, 7.68325105e-02f,
  -1.04786996e-02f, 1.42866135e-01f, -9.33067501e-02f, 6.96745282e-03f, 5.48836961e-03f, -2.48622410e-02f, 1.23835839e-01f, 5.69090098e-02f, -1.36869764e-02f, -1.20013177e-01f,
  -1.51133984e-01f, 2.58545093e-02f, -1.16164796e-02f, 3.81690711e-02f, 1.27202317e-01f, -9.49686468e-02f, -8.58451128e-02f, -4.53958521e-03f, -4.91162688e-02f, 9.52380374e-02f,
  -7.81518817e-02f, 1.04335263e-01f, 1.65350828e-02f, -4.86414693e-02f, -2.55117621e-02f, -3.02063562e-02f, -1.00680232e-01f, -1.07472681e-01f, -4.63072695e-02f, 8.86419713e-02f,
  6.19906858e-02f, -7.17941597e-02f, 2.08319034e-02f, -2.24341862e-02f, -1.17595635e-01f, -1.21396989e-01f, -9.24035236e-02f, -3.47593985e-03f, -8.04183781e-02f, -1.26255497e-01f,
  9.94025767e-02f, 1.08628199e-01f, 9.66442227e-02f, -1.56400856e-02f, -8.94046016e-03f, 3.34269851e-02f, -7.40064494e-03f, -4.37289216e-02f, 1.03434116e-01f, -1.06883980e-01f,
  -3.75790112e-02f, -4.77101505e-02f, -8.42887759e-02f, -6.65306374e-02f, -3.44968848e-02f, 9.23453271e-03f, -5.38013913e-02f, 7.89462253e-02f, -7.41141066e-02f, -5.54080121e-02f,
  -3.09253577e-02f, 3.52311991e-02f, 1.26588821e-01f, 1.35881931e-01f, 1.78971738e-02f, -6.99649006e-02f, 8.70916694e-02f, 1.71167720e-02f, 4.22885567e-02f, 9.24571678e-02f,
  -9.87729896e-03f, -2.17354856e-02f, -4.11949418e-02f, -1.26949444e-01f, 1.85989905e-02f, 1.19759195e-01f, 2.84735952e-02f, -9.90806222e-02f, -3.03171407e-02f, -4.53025848e-02f,
  -1.41487300e-01f, 1.07352681e-01f, 1.61879823e-01f, -6.81065917e-02f, -1.39142483e-01f, 7.85744041e-02f, 2.40999654e-01f, -1.30643189e-01f, 7.95091093e-02f, 9.45319608e-02f,
  6.25748336e-02f, 1.76869780e-01f, 4.27912399e-02f, 2.20800087e-01f, 1.46137597e-02f, 7.23560825e-02f, 6.58657849e-02f, -1.36338145e-01f, 5.02443202e-02f, 4.17436175e-02f,
  3.75392251e-02f, 1.71472237e-01f, -6.47903681e-02f, -2.35764533e-02f, 4.60642800e-02f, 8.76130238e-02f, -2.88458299e-02f, 9.02837515e-02f, 1.07256159e-01f, 1.22948512e-01f,
  -1.46047596e-03f, -1.18412614e-01f, 1.38931163e-02f, 1.70935616e-02f, 1.04723282e-01f, 3.97657529e-02f, -2.73568183e-02f, 6.46843910e-02f, 1.06108867e-01f, -7.60381818e-02f,
  7.64490291e-02f, -7.79204257e-03f, -5.17576784e-02f, 1.03580967e-01f, -1.36882234e-02f, 2.96457298e-02f, -1.21464632e-01f, -1.43717542e-01f, 4.18835785e-03f, 4.48431484e-02f,
  1.55663729e-01f, -5.24234325e-02f, 1.61193401e-01f, 1.23178206e-01f, 1.42457038e-01f, 1.85001522e-01f, -1.33201733e-01f, 1.85177833e-01f, -1.00902423e-01f, 7.67679214e-02f,
  8.04473087e-02f, 9.13943052e-02f, 4.42499369e-02f, 1.69559792e-01f, 1.16982616e-01f, 6.36650175e-02f, 4.94734235e-02f, -3.57042216e-02f, 1.15783796e-01f, 1.00079775e-01f,
  -1.05384536e-01f, -5.50047643e-02f, 6.79548383e-02f, -6.57485276e-02f, 1.22679202e-02f, -1.35930434e-01f, 3.96349542e-02f, -1.34118080e-01f, 7.34659750e-03f, 9.61797237e-02f,
  -1.66021168e-01f, -7.50591531e-02f, 7.19176754e-02f, -1.83014688e-03f, -6.20392412e-02f, -5.15721664e-02f, 9.07860547e-02f, 6.29361123e-02f, 7.77242780e-02f, -8.24084692e-03f,
  3.36462222e-02f, -7.55330548e-02f, -6.50435826e-03f, 2.18726601e-02f, 2.87854522e-02f, -4.29005884e-02f, 5.62019348e-02f, -1.11520275e-01f, 1.00743234e-01f, -3.96698117e-02f,
  -6.91137370e-03f, -3.52717907e-04f, 3.06221959e-03f, 2.37375513e-01f, 4.92422208e-02f, 2.28223354e-02f, 2.06228755e-02f, -9.05412734e-02f, -5.02313562e-02f, 1.70907087e-03f,
  8.25949013e-02f, 1.84636548e-01f, 1.40026242e-01f, -4.31971345e-03f, -1.44082308e-01f, -6.71969950e-02f, -1.63504705e-02f, -1.79501325e-02f, -4.52134348e-02f, -1.18072577e-01f,
  -1.86094284e-01f, 5.45503087e-02f, -1.40486196e-01f, -6.82519143e-03f, 1.10231072e-01f, -1.20175950e-01f, -8.48822594e-02f, 2.41519581e-03f, 7.85901695e-02f, -7.65107125e-02f,
  8.60882923e-02f, -1.27164766e-01f, 1.14957452e-01f, -7.15942234e-02f, -4.39118557e-02f, -7.58505464e-02f, -5.00432327e-02f, 7.41737708e-02f, 1.12343580e-01f, -4.12243009e-02f,
  -3.22497413e-02f, -1.34874687e-01f, 9.22098011e-02f, -1.55544402e-02f, 1.37978932e-02f, -1.07733876e-01f, 1.00463055e-01f, -2.85279695e-02f, -9.04693678e-02f, 5.11681363e-02f,
  -5.69439493e-02f, 5.59271462e-02f, 9.84669179e-02f, -1.16938159e-01f, 9.68164653e-02f, -2.71266177e-02f, 7.94547498e-02f, 2.20530480e-02f, -1.35047955e-03f, -6.60528988e-02f,
  -1.54915848e-03f, 1.17101170e-01f, -8.51583853e-02f, -3.63413170e-02f, -3.47378962e-02f, -1.14904769e-01f, 3.45613919e-02f, 5.97841255e-02f, -1.02936856e-01f, -6.98373793e-03f,
  -9.36242715e-02f, -6.23678491e-02f, 8.39056000e-02f, -1.18322313e-01f, 2.38724034e-02f, 2.07071900e-02f, -1.05815686e-01f, 1.82463061e-02f, -4.60907333e-02f, -3.54848467e-02f,
  7.40891099e-02f, 4.39833477e-03f, 2.39082016e-02f, 6.12345012e-03f, 8.11314508e-02f, -8.45783278e-02f, 9.80785489e-02f, 1.07311495e-01f, 1.10492215e-01f, 5.81721924e-02f,
  -4.74079605e-03f, 4.55455929e-02f, 1.07713059e-01f, -4.47286256e-02f, 5.54538742e-02f, 5.95191345e-02f, 1.08262546e-01f, -9.87399146e-02f, -4.05813418e-02f, 8.01255926e-02f,
  -1.03559634e-02f, -3.71186584e-02f, -7.72835761e-02f, -6.49692938e-02f, -8.33992511e-02f, 5.67260459e-02f, -2.42799576e-02f, 5.29632904e-02f, -1.10507712e-01f, 5.36312759e-02f,
  6.01181723e-02f, -1.20288944e-02f, -1.00366734e-01f, 1.02585733e-01f, 7.52458051e-02f, -1.04372427e-01f, -1.16744153e-02f, 3.79951075e-02f, 9.67281833e-02f, 1.66431163e-02f,
  -7.81016378e-03f, 5.88348620e-02f, 1.40978787e-02f, 4.43974882e-02f, -8.61764625e-02f, 1.36041604e-02f, 1.37437910e-01f, 1.44591164e-02f, -3.75160575e-02f, -1.08542919e-01f,
  1.06503265e-02f, 9.16747842e-03f, 4.04108427e-02f, 9.01928917e-02f, -7.66701996e-02f, 3.99793945e-02f, 4.14243564e-02f, 1.43547878e-02f, 5.52388579e-02f, 1.65225733e-02f,
  -5.51071838e-02f, -5.01656868e-02f, 1.74686506e-01f, 1.60036415e-01f, 5.30838668e-02f, 3.42599303e-03f, 6.10816367e-02f, 5.03352396e-02f, 3.48132923e-02f, 1.30270481e-01f,
  1.47250935e-01f, -4.80955057e-02f, -1.46822929e-01f, 2.24964127e-01f, 3.30676436e-02f, -6.27063587e-02f, 1.99081123e-01f, -1.44348936e-02f, 8.01136065e-03f, 1.32031724e-01f,
  1.57463983e-01f, -2.69992761e-02f, -3.68716591e-03f, 7.20444918e-02f, -7.25447088e-02f, -1.65761579e-02f, 6.62432110e-04f, 6.71399310e-02f, -1.34806277e-03f, 3.29536907e-02f,
  7.71585330e-02f, 1.28637582e-01f, -2.41378248e-02f, 9.09192711e-02f, -5.89350499e-02f, 6.35863319e-02f, -3.14007071e-03f, 6.36495873e-02f, 9.28019285e-02f, -8.29100460e-02f,
  4.77989800e-02f, -2.42591444e-02f, -1.32318273e-01f, -8.17439109e-02f, 1.17408589e-01f, -9.70007703e-02f, 3.41680832e-02f, 9.64226723e-02f, -5.41603751e-02f, -8.87224078e-03f,
  -7.81492218e-02f, 3.43601331e-02f, -6.60443828e-02f, -2.83409934e-02f, 1.50378779e-01f, 9.92268771e-02f, -4.40900475e-02f, 6.67100074e-03f, 8.05428848e-02f, 1.45700261e-01f,
  -5.00513315e-02f, 1.03081226e-01f, 1.41012475e-01f, 3.43278944e-02f, -1.11430213e-01f, 7.43361656e-03f, 1.95779279e-01f, 9.81031209e-02f, 1.57454848e-01f, -7.99851120e-03f,
  9.86574963e-02f, 4.31212820e-02f, 2.09416658e-01f, -1.14360765e-01f, -3.33318152e-02f, 4.82479893e-02f, -8.09086300e-03f, 1.00754768e-01f, 1.35833174e-01f, -9.71134827e-02f,
  1.98077083e-01f, -1.13807417e-01f, 3.41270491e-02f, 2.28605941e-01f, 1.91947892e-01f, 4.57378663e-02f, 6.46607727e-02f, -3.53563875e-02f, 1.04207443e-02f, -3.80232669e-02f,
  1.02369621e-01f, 6.64286967e-03f, 1.63142845e-01f, -2.07018740e-02f, -3.66894752e-02f, 1.21294841e-01f, 2.29538307e-02f, 1.01548649e-01f, -6.87695965e-02f, 1.39729157e-01f,
  2.16420248e-01f, 1.75465852e-01f, -8.96229148e-02f, 1.31810367e-01f, -4.98933569e-02f, -1.63429845e-02f, -1.15634181e-01f, 2.09598392e-01f, 2.06160098e-02f, -6.95527792e-02f,
  -4.42085937e-02f, 2.54472852e-01f, -2.24466547e-02f, 9.50826779e-02f, -4.09453623e-02f, 5.56460582e-02f, -2.58551203e-02f, 2.35779900e-02f, 2.26431727e-01f, -1.25517249e-01f,
  -1.21204689e-01f, 1.65480107e-01f, -7.65262023e-02f, 2.56198287e-01f, 7.52587169e-02f, 2.74911840e-02f, 2.74253003e-02f, 1.22168235e-01f, -4.95411688e-03f, 1.69344962e-01f,
  -7.37717003e-02f, -3.53832245e-02f, 4.53082696e-02f, 1.35962456e-01f, 1.73532382e-01f, 1.28554657e-01f, -3.34790535e-02f, -8.12978223e-02f, -9.20386687e-02f, -4.41408195e-02f,
  -9.19438973e-02f, -4.69146147e-02f, -5.77175692e-02f, -7.28480592e-02f, -7.50828609e-02f, -6.54791221e-02f, -9.74955037e-03f, 8.61642789e-03f, -1.15085110e-01f, 2.81293951e-02f,
  -3.26385163e-02f, -3.85805331e-02f, 3.48541290e-02f, 1.04580827e-01f, 1.27602974e-03f, -2.72204150e-02f, 1.11932322e-01f, 1.38795637e-02f, 1.31755739e-01f, -8.55369940e-02f,
  -5.50939403e-02f, -1.25227138e-01f, -6.15308173e-02f, -1.70382727e-02f, -6.88404441e-02f, -7.45562762e-02f, 6.58273771e-02f, 5.61332889e-02f, -3.25976685e-02f, -2.28808988e-02f,
  9.12963971e-02f, 4.05176952e-02f, -8.24720860e-02f, 7.02840611e-02f, 1.09420508e-01f, -4.02326845e-02f, 5.20759374e-02f, -4.39409129e-02f, 4.54830602e-02f, 3.18231829e-03f,
  -1.31966054e-01f, 8.83985893e-04f, -1.02369942e-01f, 2.31826920e-02f, 1.36161046e-02f, 1.28898127e-02f, 2.72698142e-02f, -7.77022243e-02f, -5.60242347e-02f, -3.46650109e-02f,
  3.11748451e-03f, 4.56965193e-02f, -4.36489917e-02f, -2.58719064e-02f, 1.00316808e-01f, 1.33040994e-01f, -1.37120232e-01f, 1.87706903e-01f, 1.01283245e-01f, 2.00224698e-01f,
  6.95008039e-03f, -3.53170633e-02f, 1.25245303e-01f, 1.81139514e-01f, 4.11440916e-02f, -8.13120455e-02f, 1.02228805e-01f, 3.35413255e-02f, -1.87571310e-02f, 9.70022827e-02f,
  1.37732118e-01f, -1.78009242e-01f, -1.10855773e-01f, -8.18954930e-02f, -2.05161367e-02f, -1.00029208e-01f, 4.43955213e-02f, -2.56732553e-02f, 1.45057365e-02f, 4.98393504e-03f,
  -8.87379125e-02f, 2.49432042e-01f, 1.20002940e-01f, -9.52067375e-02f, 1.49779975e-01f, -5.47547378e-02f, 1.25432655e-01f, 4.06200904e-03f, 1.03859492e-01f, 8.17183312e-03f,
  8.41317251e-02f, 4.71614115e-02f, -5.68322800e-02f, -8.04099366e-02f, -1.10347368e-01f, -4.84838262e-02f, 1.23180160e-02f, 7.73664564e-02f, -1.70423426e-02f, -4.78630476e-02f,
  1.38961421e-02f, 7.43835792e-02f, -9.09687430e-02f, -5.32172509e-02f, -1.23209514e-01f, 1.17281161e-01f, 2.24694815e-02f, 5.97408079e-02f, 8.82195961e-03f, 9.25332084e-02f,
  1.32964132e-02f, -1.38656870e-01f, -6.01417385e-03f, 3.67490202e-02f, -7.85513967e-02f, -1.75254028e-02f, -1.77723184e-01f, 5.40873446e-02f, -1.85872689e-02f, -4.34031785e-02f,
  -4.89411540e-02f, -1.05850451e-01f, 5.64768091e-02f, 2.44442765e-02f, 6.23650476e-02f, 9.16977748e-02f, -1.56214461e-02f, 4.09319401e-02f, 7.59081095e-02f, 6.36492372e-02f,
  -1.67036913e-02f, 5.05793281e-02f, 1.17119238e-01f, 1.18520468e-01f, -1.04161471e-01f, -3.96197364e-02f, -2.69724354e-02f, -3.61860450e-03f, 9.32446048e-02f, -9.82306078e-02f,
  5.41965812e-02f, -1.43762296e-02f, 1.16502784e-01f, 1.18792325e-01f, -9.42475423e-02f, -1.02110812e-02f, -1.25222886e-02f, 8.49234238e-02f, 1.44203911e-02f, -1.19817026e-01f,
  -9.83047560e-02f, 8.09769854e-02f, -5.78207783e-02f, 9.87181738e-02f, -4.21649106e-02f, -7.33086690e-02f, -5.18113710e-02f, -1.88715495e-02f, 9.87474024e-02f, 1.03976145e-01f,
  7.38442168e-02f, 1.11413039e-01f, 1.07208021e-01f, -9.11314785e-02f, -1.32489279e-01f, 7.77191296e-02f, -5.98984212e-02f, -1.68010499e-03f, 6.32863045e-02f, 8.53708759e-02f,
  2.42393930e-02f, -8.87499824e-02f, -3.28537896e-02f, 9.49456319e-02f, 2.73057278e-02f, 1.09123355e-02f, -1.26545712e-01f, -7.15285540e-02f, -6.75252676e-02f, -6.37420686e-03f,
  5.33031562e-05f, -6.44011348e-02f, 2.70237494e-02f, 1.11514330e-01f, 1.27686739e-01f, 9.28589795e-03f, -4.04554084e-02f, 1.16489500e-01f, 2.16008201e-01f, -9.76266619e-03f,
  6.35486543e-02f, -2.03604307e-02f, -3.63758206e-02f, 1.85950965e-01f, 1.33138612e-01f, 8.83607715e-02f, 1.92157924e-02f, -5.94419092e-02f, 1.19497210e-01f, 1.80441812e-01f,
  3.05581037e-02f, 4.26612943e-02f, 9.23077241e-02f, 8.89035985e-02f, -1.10121809e-01f, -1.26742572e-01f, 2.63862708e-03f, 1.61948621e-01f, -5.38392551e-02f, 3.19997370e-02f,
  1.18994024e-02f, -1.04911745e-01f, 1.33666098e-01f, 4.51879725e-02f, -6.88052997e-02f, 1.10038236e-01f, 1.06413573e-01f, -3.05586355e-03f, 9.07901749e-02f, 2.07483202e-01f,
  -8.25306699e-02f, -8.28492716e-02f, 2.10954510e-02f, -1.79910511e-02f, 1.04060844e-01f, 4.72235046e-02f, -2.42306641e-03f, 4.66545001e-02f, -2.01516971e-02f, 1.95567962e-03f,
  4.54358123e-02f, 1.06868029e-01f, 1.36652470e-01f, 7.59157469e-04f, 1.32910281e-01f, -7.42388666e-02f, -1.02582164e-01f, 9.53886434e-02f, -1.16002440e-01f, -5.61905429e-02f,
  -6.75807670e-02f, 9.36513469e-02f, 7.03886002e-02f, 4.66258526e-02f, 3.20747569e-02f, 6.28510863e-02f, 4.13644128e-02f, 3.58121954e-02f, -3.98738459e-02f, 1.15776166e-01f,
  9.40952916e-03f, -4.39377353e-02f, -1.59641504e-02f, 8.81788209e-02f, 1.28282204e-01f, 5.80129363e-02f, -7.35844970e-02f, -1.20932631e-01f, 5.24246953e-02f, -4.40180413e-02f,
  -1.34315699e-01f, -3.33508514e-02f, 1.85429752e-01f, 3.96825969e-02f, -1.87328249e-01f, -1.22222610e-01f, -5.60968295e-02f, 1.80980250e-01f, 1.14296705e-01f, 1.21194636e-02f,
  1.08449399e-01f, 1.24298356e-01f, -9.84193459e-02f, 2.41317779e-01f, 3.32445018e-02f, -2.07782723e-02f, 2.37256095e-01f, 6.89970329e-02f, -1.72956530e-02f, 4.04066108e-02f,
  3.43808644e-02f, -9.10655707e-02f, 6.59195483e-02f, 2.77507067e-01f, 3.63334902e-02f, -1.34941012e-01f, -1.18239611e-01f, 6.59119040e-02f, -6.51092129e-03f, -1.09183602e-01f,
  6.55345693e-02f, -5.37959039e-02f, 1.42911807e-01f, 2.78125913e-03f, 4.44662292e-04f, -1.02520257e-01f, -1.76235005e-01f, 1.31888047e-01f, -9.89348739e-02f, -2.44686045e-02f,
  -1.21690892e-02f, -3.99992010e-03f, -2.64930818e-02f, -9.69778094e-03f, -1.06776878e-01f, -9.03555676e-02f, 7.00920597e-02f, 8.95953774e-02f, -8.67077336e-02f, -6.14492111e-02f,
  -5.76381907e-02f, -5.95513396e-02f, -1.10653631e-01f, -7.58306831e-02f, -6.80358410e-02f, 1.05722301e-01f, -8.78512189e-02f, 9.37299877e-02f, -1.95187721e-02f, 1.44118443e-01f,
  1.07827127e-01f, 3.23690586e-02f, -8.44347402e-02f, 1.33167375e-02f, -1.85649041e-02f, 9.87989679e-02f, 4.81688231e-02f, 7.20456764e-02f, -3.12246028e-02f, 6.40710890e-02f,
  -8.14448819e-02f, 1.27062723e-01f, -8.77637565e-02f, -9.37745944e-02f, -3.87791805e-02f, -9.78060998e-03f, -8.21111128e-02f, 4.70339842e-02f, 1.13094926e-01f, -1.07015826e-01f,
  -9.37856063e-02f, -4.29838486e-02f, -1.00645483e-01f, 9.86730903e-02f, -4.56288829e-03f, -1.06592797e-01f, 3.68034765e-02f, 3.31057534e-02f, -1.48028461e-02f, 3.07307579e-02f,
  7.72426575e-02f, -2.26971184e-04f, 5.08527383e-02f, 2.84147225e-02f, 4.35069390e-02f, -7.48159066e-02f, 1.09280080e-01f, 5.03381342e-02f, -1.01108469e-01f, -1.22597016e-01f,
  -1.35120004e-01f, -7.58636743e-02f, -9.72327143e-02f, 1.09429687e-01f, -9.95117426e-02f, -1.59457214e-02f, -9.86620411e-02f, -5.98855950e-02f, -2.93671992e-02f, -2.79404912e-02f,
  -9.71400365e-02f, -6.77575320e-02f, -3.88042666e-02f, -9.54557955e-02f, 2.01500550e-01f, -9.36751626e-03f, 7.69811049e-02f, -3.22761550e-03f, -3.20534110e-02f, 1.69520184e-01f,
  4.22890149e-02f, 9.08043534e-02f, -9.10139531e-02f, 2.90313512e-02f, -1.70141575e-03f, -6.13652319e-02f, 1.05493747e-01f, 1.34955585e-01f, 1.51556566e-01f, -8.90839547e-02f,
  -5.90939261e-02f, 2.90030241e-01f, 4.76366607e-03f, -7.74291381e-02f, -7.96572268e-02f, 2.84123775e-02f, -4.66597155e-02f, -1.28978431e-01f, -7.09035546e-02f, 5.15454933e-02f,
  2.20109329e-01f, -1.14498936e-01f, -1.26974240e-01f, -6.32858500e-02f, -1.23279974e-01f, 1.84686646e-01f, -7.50782341e-02f, -1.04079269e-01f, 1.99166477e-01f, -4.74983938e-02f,
  -6.17101090e-03f, -1.00275435e-01f, 8.61862004e-02f, -5.99058643e-02f, 5.07364236e-02f, -3.88717018e-02f, -4.47227433e-03f, -6.14714921e-02f, 6.51181713e-02f, 2.18276337e-01f,
  1.82836875e-01f, -3.32669169e-02f, -4.55739461e-02f, -8.94026831e-02f, -7.71683007e-02f, -2.25464231e-03f, 1.29986405e-01f, 8.87816548e-02f, -1.43000990e-01f, -3.84747833e-02f,
  1.25002578e-01f, 1.88217342e-01f, -9.53905880e-02f, 1.01106957e-01f, -4.46739756e-02f, 7.52988085e-02f, -4.83304858e-02f, 6.86695725e-02f, 1.45383522e-01f, 6.49518846e-03f,
  9.16991755e-02f, 2.02032208e-01f, 2.16384962e-01f, 1.96834832e-01f, -1.80543035e-01f, 2.42412239e-02f, -2.40940288e-01f, 1.45312160e-01f, -1.72823202e-02f, 3.61685157e-02f,
  -3.89653668e-02f, 1.67328462e-01f, 5.39284088e-02f, -1.07371369e-02f, -6.46799663e-03f, -1.30521968e-01f, -4.23421804e-03f, -3.15783322e-02f, 1.10853054e-01f, -6.21369332e-02f,
  1.50219500e-01f, -8.53653476e-02f, -9.19137001e-02f, -7.19185621e-02f, 1.62893683e-01f, -1.04631536e-01f, -8.63938185e-04f, -1.26259625e-01f, -8.49111285e-03f, -9.73484665e-02f,
  -1.16025798e-01f, 2.92089842e-02f, -9.23993662e-02f, 1.48154140e-01f, 1.32053390e-01f, 9.62428898e-02f, 1.47774756e-01f, 9.02205184e-02f, -9.82081145e-02f, 4.94526066e-02f,
  6.44790828e-02f, -3.72486957e-03f, 7.92448446e-02f, -2.71163485e-03f, 1.59609124e-01f, -2.52705179e-02f, 1.52783185e-01f, 1.35588050e-01f, -1.35599333e-03f, 1.22524211e-02f,
  -1.08750155e-02f, -9.03755352e-02f, 1.07564494e-01f, 1.37215644e-01f, 3.07290698e-03f, -4.76488620e-02f, -2.15590913e-02f, 8.14234018e-02f, -1.08676963e-01f, 1.08793251e-01f,
  1.26919404e-01f, -2.50241254e-02f, -8.14331174e-02f, -3.22795659e-02f, 2.64621135e-02f, -3.74993384e-02f, 1.12759091e-01f, 4.19673584e-02f, -2.20359534e-01f, -7.45812654e-02f,
  -1.62468955e-01f, 7.76795149e-02f, 7.45302066e-02f, -4.00561392e-02f, 3.65826041e-02f, -2.37009414e-02f, -5.39409108e-02f, -1.09544963e-01f, 1.09313734e-01f, -2.26424616e-02f,
  -1.58578739e-01f, -1.83536895e-02f, -3.37728150e-02f, 1.50734514e-01f, 1.19593777e-01f, 1.28970772e-01f, 3.32172811e-02f, -1.14279523e-01f, 1.46343678e-01f, 8.92271101e-02f,
  1.14269033e-01f, 1.00745469e-01f, 9.83720347e-02f, -4.70997579e-03f, -8.88479054e-02f, -2.23091338e-02f, 8.34080130e-02f, 9.90142971e-02f, -8.71710405e-02f, 9.64422338e-03f,
  1.09709993e-01f, -3.82649712e-02f, -5.18136807e-02f, 1.27762714e-02f, -5.00270091e-02f, 1.29530102e-01f, -4.85081747e-02f, -8.85327831e-02f, 3.36288325e-02f, 5.21240477e-03f,
  6.35034293e-02f, -1.21670537e-01f, -1.30250946e-01f, 8.64909589e-02f, -4.95883115e-02f, 4.33103554e-02f, 1.02036335e-01f, 1.31264527e-03f, 1.19670490e-02f, 7.31752366e-02f,
  1.55356862e-02f, -4.49651815e-02f, -7.35805482e-02f, 1.16663426e-02f, 3.67311649e-02f, 5.13326637e-02f, 6.23546392e-02f, -6.68647662e-02f, -5.58791868e-02f, 8.43886286e-02f,
  1.26156822e-01f, 7.70220533e-02f, 1.74827389e-02f, 4.79481779e-02f, -1.72339827e-01f, 9.90841687e-02f, 5.44614978e-02f, 3.30503583e-02f, 1.09422587e-01f, 8.70470237e-03f,
  1.41112013e-02f, -2.50826939e-04f, 3.27489036e-03f, -1.03972375e-01f, -7.35149682e-02f, 3.56518365e-02f, 1.24531470e-01f, -4.94407602e-02f, -1.10344186e-01f, 5.46976831e-03f,
  -8.30340907e-02f, 1.01741798e-01f, 5.22733442e-02f, 2.56403033e-02f, -6.07393160e-02f, 1.00045778e-01f, -1.05077974e-01f, -1.13632426e-01f, -1.38084382e-01f, 7.46059567e-02f,
  -9.55952927e-02f, 8.76920819e-02f, -8.54017213e-02f, -5.61354421e-02f, -2.99182739e-02f, -7.36115035e-03f, 1.09652840e-01f, -7.59472698e-02f, 1.07167147e-01f, 3.72649804e-02f,
  6.69067651e-02f, -1.14899836e-01f, 8.18663612e-02f, 3.15960310e-02f, 1.01626329e-01f, 5.18449433e-02f, -6.23756573e-02f, -1.28057292e-02f, -3.56349573e-02f, -2.24636309e-02f,
  3.19715552e-02f, 8.76749158e-02f, -2.26044878e-02f, -2.96411142e-02f, 8.21883231e-02f, 8.77399445e-02f, -1.22807465e-01f, 9.07703340e-02f, 5.14636487e-02f, -1.35151386e-01f,
  1.52976140e-01f, 9.25580114e-02f, -7.37833232e-02f, -5.45133241e-02f, -4.12390605e-02f, 1.71210021e-01f, 1.32451672e-02f, 1.89091548e-01f, 1.47401944e-01f, 2.16813415e-01f,
  -2.23850105e-02f, 1.24455437e-01f, 1.69384256e-01f, 3.42911631e-02f, 4.92651889e-04f, 3.16320173e-02f, 1.93252400e-01f, 1.14998050e-01f, 1.07474821e-02f, -7.72203505e-02f,
  -1.19441748e-01f, 8.44205245e-02f, -6.26863465e-02f, -2.70777941e-02f, -6.46519884e-02f, -2.25989036e-02f, -8.56447369e-02f, 2.87988335e-02f, -9.47921276e-02f, 1.12826630e-01f,
  2.06035450e-01f, 5.98782301e-03f, -2.01164465e-02f, 5.19245416e-02f, -7.71425962e-02f, 2.30873283e-02f, 1.57642096e-01f, 1.95450559e-01f, -7.48312473e-02f, 8.17991495e-02f,
  4.01131324e-02f, -8.40020180e-02f, -6.57656938e-02f, -9.43474378e-03f, -6.52756467e-02f, 3.26685123e-02f, 1.96937203e-01f, 1.04105644e-01f, 1.05904162e-01f, -3.99134308e-02f,
  -1.24991219e-02f, -3.34143788e-02f, 6.08662851e-02f, 1.44258127e-01f, 6.03452139e-03f, -2.26221215e-02f, 5.53334989e-02f, -4.27594297e-02f, -1.60070695e-02f, -3.65585908e-02f,
  1.19934030e-01f, -1.35169858e-02f, -3.95296104e-02f, 9.19776782e-02f, -2.37028468e-02f, -6.46803454e-02f, -4.00302373e-02f, 1.02663189e-01f, -3.55747230e-02f, -7.16809779e-02f,
  1.99227873e-02f, -5.07735163e-02f, 2.82010511e-02f, -1.22471988e-01f, 1.71277821e-02f, -1.90879852e-02f, -5.55408299e-02f, 7.99116790e-02f, -8.31025243e-02f, 8.29962343e-02f,
  6.89651743e-02f, 8.24422911e-02f, -1.86862275e-02f, -3.38150524e-02f, -3.45071144e-02f, -1.12233751e-01f, -3.78295593e-03f, 9.80371460e-02f, 9.67034698e-02f, -9.90414172e-02f,
  -1.06846862e-01f, 1.92591362e-02f, 8.30596834e-02f, 1.13316007e-01f, -1.31423831e-01f, 4.82090749e-02f, 2.80892234e-02f, 5.89862876e-02f, 1.88288037e-02f, -4.48233914e-03f,
  3.93683799e-02f, -4.57901135e-02f, 5.50410748e-02f, 3.51226442e-02f, 4.57332171e-02f, 2.65938435e-02f, 2.36172993e-02f, -5.34125790e-02f, 8.57460871e-02f, 1.92326866e-02f,
  1.00324810e-01f, -9.04827565e-02f, 4.17493321e-02f, 9.42837372e-02f, -2.45623067e-02f, 6.06244877e-02f, -5.49416337e-03f, 4.81026173e-02f, -1.41581604e-02f, -7.73904696e-02f,
  -9.29448754e-02f, 4.69912700e-02f, 6.19154051e-02f, 1.16564631e-01f, -6.54040050e-05f, 4.26718071e-02f, -1.65627897e-03f, 1.07760072e-01f, 6.74189478e-02f, 4.09536883e-02f,
  4.92301732e-02f, 6.50362670e-02f, -3.31049711e-02f, 8.52077976e-02f, 1.20310202e-01f, 3.74562829e-03f, -7.80556723e-02f, -1.18283562e-01f, 3.06460727e-02f, -7.77031630e-02f,
  -1.20348349e-01f, -1.34086579e-01f, 1.40315741e-01f, -1.11380443e-01f, -1.60574988e-02f, 9.63952094e-02f, -3.12636197e-02f, -2.87064929e-02f, 5.10094389e-02f, -2.82943305e-02f,
  -1.07858591e-02f, 9.20405164e-02f, -9.73222312e-03f, 2.30531562e-02f, 1.35338053e-01f, -5.85937984e-02f, 1.24684960e-01f, -5.29784411e-02f, -3.76881361e-02f, -7.83184618e-02f,
  -5.71852662e-02f, -3.87067744e-03f, 1.26117468e-01f, -5.01705632e-02f, -4.59442809e-02f, 1.05450489e-01f, 2.56645642e-02f, -8.46801624e-02f, 7.58852763e-03f, 8.44163634e-03f,
  8.63539651e-02f, 1.09934866e-01f, 1.35186046e-01f, 1.10014051e-01f, -4.45015095e-02f, -9.77361873e-02f, 1.10087052e-01f, -8.70704353e-02f, 2.93383598e-02f, -3.39228548e-02f,
  7.55846128e-02f, -1.57362327e-01f, 9.65615958e-02f, -1.02397442e-01f, -8.00020248e-02f, 4.31445576e-02f, 1.82675719e-02f, 1.34123445e-01f, 2.94422023e-02f, -8.54975656e-02f,
  1.00058161e-01f, 2.27419962e-03f, 4.15995568e-02f, 1.28491446e-01f, 1.53146446e-01f, 2.23584771e-02f, -7.57377520e-02f, -7.62184858e-02f, 9.65214148e-02f, -2.76839007e-02f,
  -1.25032976e-01f, -9.16291401e-02f, -8.90150070e-02f, -1.50829762e-01f, -1.31947428e-01f, 7.01994598e-02f, -1.50121562e-02f, 5.53612262e-02f, -5.38081899e-02f, 3.07217948e-02f,
  1.73197359e-01f, 4.68913950e-02f, 3.92884873e-02f, -1.37497291e-01f, 1.23004057e-01f, 3.74284349e-02f, -9.97577980e-03f, -6.58702701e-02f, 1.21643886e-01f, 5.50387576e-02f,
  3.12304739e-02f, 7.32549056e-02f, -9.05960202e-02f, -2.51490623e-02f, -8.44182819e-02f, -1.02098165e-02f, 1.14059947e-01f, -9.55141708e-02f, -1.54147178e-01f, 2.52405647e-02f,
  -5.32618389e-02f, -8.68167281e-02f, 9.31505859e-02f, -6.21757805e-02f, 6.66829422e-02f, -1.14672584e-02f, 1.35423720e-01f, -7.76700601e-02f, -1.03978232e-01f, 4.61727753e-02f,
  -9.57042947e-02f, 1.04746334e-02f, 6.34218901e-02f, -7.18793124e-02f, -6.48171129e-03f, -5.00289127e-02f, -4.97637093e-02f, 1.21773176e-01f, 1.92493722e-02f, 1.43645450e-01f,
  5.30683585e-02f, -6.09173402e-02f, -2.76785437e-02f, 1.18352398e-01f, 1.89810634e-01f, -5.61404079e-02f, 1.05183415e-01f, 4.18774672e-02f, -5.38968369e-02f, -6.87881485e-02f,
  -4.31711860e-02f, 5.26634930e-03f, -9.02244635e-03f, 9.93275568e-02f, -3.28684263e-02f, -4.71143946e-02f, -5.27863689e-02f, -1.48505032e-01f, -1.12039715e-01f, -4.67502885e-02f,
  -9.47010294e-02f, -1.23452947e-01f, -1.32684857e-01f, 5.84737211e-02f, -6.36412576e-02f, -4.32913639e-02f, -1.43852636e-01f, 7.06927329e-02f, -1.90219861e-02f, -1.05837218e-01f,
  -3.24697047e-02f, -1.38107553e-01f, 1.34211496e-01f, -9.00204256e-02f, -2.35914290e-02f, -1.08946115e-01f, -1.27914175e-01f, -3.86813805e-02f, -1.36579275e-01f, -6.99145570e-02f,
  -6.61896914e-02f, -8.70554000e-02f, 1.13255709e-01f, -9.82948244e-02f, -6.37558624e-02f, 6.42207339e-02f, -1.05469674e-01f, 1.12453803e-01f, 3.99517454e-02f, 1.09136969e-01f,
  1.26748845e-01f, -1.19148359e-01f, -7.12640435e-02f, 4.97724861e-02f, 1.03547506e-01f, 6.13991134e-02f, 6.30876496e-02f, -1.20688111e-01f, -1.15857250e-03f, -7.48884976e-02f,
  -6.08308800e-02f, -1.80072337e-02f, 4.37557809e-02f, 1.22564256e-01f, 1.25058293e-01f, -6.62569776e-02f, 1.00258008e-01f, -8.24654922e-02f, 7.60621056e-02f, -5.33377528e-02f,
  1.47824645e-01f, 6.70321435e-02f, -1.29151568e-01f, 4.34586070e-02f, 3.06763742e-02f, 2.53698170e-01f, -2.10827529e-01f, 1.40578479e-01f, 2.15903446e-01f, 2.64893740e-01f,
  -5.02155237e-02f, 2.39226595e-02f, 1.15558580e-01f, -5.84949413e-03f, 7.61416778e-02f, -5.83751276e-02f, 1.17593654e-01f, -9.26979482e-02f, 1.10104792e-01f, -1.14427537e-01f,
  -8.37742388e-02f, 2.23555565e-01f, -1.00238465e-01f, 4.97073261e-03f, 1.49989322e-01f, -1.30435467e-01f, -2.48468909e-02f, 2.70511527e-02f, -6.52860552e-02f, 4.72323075e-02f,
  4.53061387e-02f, -1.00994430e-01f, -2.48554535e-02f, 1.62674725e-01f, -1.04163446e-01f, -6.68681785e-02f, 1.45079806e-01f, 3.14756036e-01f, -7.52277533e-03f, 1.27986856e-02f,
  -3.08462209e-03f, 8.60608742e-02f, -2.93425862e-02f, -2.22560912e-02f, -6.11640625e-02f, 2.92592589e-02f, 1.99876711e-01f, -5.35336472e-02f, 6.90589622e-02f, -9.96333361e-03f,
  -6.58697337e-02f, -1.18991576e-01f, 3.98541503e-02f, 1.05812021e-01f, -7.86376074e-02f, -1.15412176e-01f, 8.03005993e-02f, -1.62702426e-01f, -4.35258858e-02f, 2.74608266e-02f,
  1.49008200e-01f, 1.15644976e-01f, -5.93527891e-02f, -2.04534531e-02f, -6.57884553e-02f, 7.51763955e-02f, 1.29886538e-01f, -2.77339239e-02f, 1.54106319e-01f, 1.52658328e-01f,
  -8.93680230e-02f, 3.13734598e-02f, -1.68205306e-01f, 9.97653082e-02f, 2.86888462e-02f, -2.26694793e-02f, 1.80444922e-02f, -5.16957752e-02f, 1.01525657e-01f, 1.73983797e-02f,
  -8.91547501e-02f, -1.18795047e-02f, -7.75472820e-02f, -3.73541564e-03f, -1.52572238e-05f, -7.09626675e-02f, -3.93472984e-02f, 5.95408008e-02f, -6.88465163e-02f, -1.18001856e-01f,
  -8.87246877e-02f, -3.76220644e-02f, 5.75399734e-02f, -2.85578258e-02f, -1.18421257e-01f, 3.73421498e-02f, -1.07773066e-01f, 4.63351458e-02f, -1.26453578e-01f, -2.91086137e-02f,
  7.98364505e-02f, 1.05749846e-01f, 1.09642878e-01f, -3.74196321e-02f, 2.79769339e-02f, 6.39521927e-02f, 8.47200230e-02f, -1.29128071e-02f, 9.24458802e-02f, -1.00578956e-01f,
  -8.19247514e-02f, 6.98791519e-02f, -2.30268873e-02f, 6.59106523e-02f, -8.44515115e-02f, -2.84549557e-02f, -5.12547381e-02f, 3.76564339e-02f, -1.08332813e-01f, -4.75786664e-02f,
  -8.56403708e-02f, 7.34053925e-02f, -1.20732549e-03f, -1.75959412e-02f, 1.50130972e-01f, 6.73670173e-02f, -8.66579488e-02f, -1.01663724e-01f, 3.47348936e-02f, 7.54530057e-02f,
  -8.78397748e-02f, 4.56242748e-02f, 2.25774229e-01f, 2.32089162e-01f, -2.87806600e-01f, 1.85925394e-01f, -6.57148147e-03f, 2.29645506e-01f, 1.20009489e-01f, -1.87662497e-01f,
  3.62487091e-03f, 1.10725470e-01f, 1.14919737e-01f, 2.85587925e-02f, 2.65414089e-01f, -1.63542271e-01f, -1.19593069e-01f, 5.83562851e-02f, 8.63582268e-02f, 1.55305833e-01f,
  -5.35698719e-02f, 6.58582970e-02f, 1.61814719e-01f, -1.15098521e-01f, 1.09239236e-01f, 1.91131398e-01f, 1.45393074e-01f, -1.14383668e-01f, 1.45946652e-01f, -7.71564320e-02f,
  1.16945058e-01f, 1.73129663e-02f, -1.15652584e-01f, 9.28365663e-02f, 1.88877322e-02f, 1.77191839e-01f, -2.73309499e-02f, -4.37755138e-02f, 9.72454175e-02f, 1.80271398e-02f,
  3.38658765e-02f, 1.02673881e-01f, -4.29155156e-02f, -8.63195434e-02f, 1.34304583e-01f, 3.35885659e-02f, 4.00455808e-03f, -1.89711433e-02f, -1.92626297e-01f, -1.06316470e-01f,
  6.93134964e-02f, 9.76278260e-02f, -6.51647151e-02f, -3.39698121e-02f, 4.26480025e-02f, -5.75115979e-02f, -7.75613114e-02f, -3.95743772e-02f, -2.09111697e-03f, 1.44774839e-01f,
  -4.99089882e-02f, 1.10408433e-01f, 1.01863630e-01f, 1.35581583e-01f, -3.94330248e-02f, 4.50422689e-02f, -4.03539985e-02f, 8.21561888e-02f, -3.72235328e-02f, 1.70316562e-01f,
  4.28576283e-02f, 1.65119916e-01f, 8.51087049e-02f, 1.56150162e-01f, 2.14507937e-01f, 1.83180407e-01f, -6.61141202e-02f, 5.10506816e-02f, 2.05614388e-01f, -7.74783194e-02f,
  -5.87063730e-02f, -8.42294320e-02f, -1.38404727e-01f, 4.38127592e-02f, 8.69608521e-02f, -1.01392739e-01f, 1.47878364e-01f, -6.49055243e-02f, 9.10106227e-02f, 5.79229277e-03f,
  -6.00469932e-02f, 4.62233238e-02f, 3.31701636e-02f, -3.11069712e-02f, 4.28336021e-03f, 9.17861760e-02f, 8.73866752e-02f, 3.73145193e-02f, -5.46337478e-02f, 3.00231367e-01f,
  -7.95520023e-02f, 7.58140013e-02f, -8.88164788e-02f, -1.60358928e-03f, -9.12920162e-02f, -1.09424256e-01f, 1.93101529e-03f, 6.42619655e-02f, 1.96285352e-01f, -3.29828560e-02f,
  1.73328549e-01f, -1.41792642e-02f, -6.16932809e-02f, -2.51587946e-02f, -1.03509575e-01f, 1.81195527e-01f, -4.78858724e-02f, -1.03430338e-01f, -8.67650192e-03f, 2.26210672e-02f,
  1.25940263e-01f, 2.33356305e-03f, 8.92983600e-02f, 1.49434671e-01f, -4.16524746e-02f, -2.51120031e-02f, -5.66314273e-02f, 1.17018729e-01f, -1.73456799e-02f, 8.40394273e-02f,
  -2.09618602e-02f, -7.55201653e-02f, -1.83091328e-01f, -6.76297992e-02f, -6.36992827e-02f, 1.11206092e-01f, 1.32136106e-01f, -5.01581915e-02f, 1.00252010e-01f, 9.64605212e-02f,
  2.47878097e-02f, -9.91802067e-02f, 1.26242423e-02f, -1.16793096e-01f, 7.89548606e-02f, 3.85295041e-03f, 6.09418228e-02f, 9.60924625e-02f, -1.70296319e-02f, 7.92945921e-02f,
  -3.01755108e-02f, -8.14256296e-02f, -3.21028046e-02f, 5.79085015e-02f, 5.65135069e-02f, -1.04568444e-01f, 3.85844335e-02f, -1.16853431e-01f, 4.02095430e-02f, 2.31508221e-02f,
  1.81559063e-02f, -2.97264643e-02f, 5.18521108e-02f, -1.64302647e-01f, -9.86514054e-03f, -3.46286856e-02f, -1.09622233e-01f, 6.78502023e-02f, 3.62792835e-02f, 1.36881247e-01f,
  -4.37770858e-02f, -1.87523477e-02f, 1.20793559e-01f, 2.50405055e-02f, -7.51007348e-02f, 6.80514500e-02f, -3.86475958e-02f, -8.86979997e-02f, 8.65066051e-02f, 1.40367821e-01f,
  -8.65862221e-02f, -1.14469685e-01f, -2.74099242e-02f, -7.79524073e-03f, 5.23448773e-02f, 1.03485929e-02f, 1.40353248e-01f, -9.85004976e-02f, 1.13310911e-01f, -6.90160459e-03f,
  1.36040658e-01f, 1.65880725e-01f, 1.82321012e-01f, -2.04103719e-02f, -2.86668725e-02f, 1.42112970e-01f, 1.28526866e-01f, 9.55458134e-02f, -4.97459508e-02f, -6.67573288e-02f,
  1.32131234e-01f, -9.32923332e-02f, -5.29363528e-02f, 1.19188085e-01f, 7.83105493e-02f, 7.51760751e-02f, -9.63154137e-02f, 7.18945563e-02f, 1.01320125e-01f, 6.74393177e-02f,
  -1.01986311e-01f, 1.13520417e-02f, -6.35327026e-02f, 5.57155870e-02f, -1.01741731e-01f, -2.05223225e-02f, 1.18021131e-01f, -1.21057689e-01f, 2.95106061e-02f, -1.18513770e-01f,
  -6.56031221e-02f, -5.10953777e-02f, 6.23918474e-02f, 8.80932808e-02f, 5.08223437e-02f, 2.10898835e-03f, -4.62638400e-02f, -7.94632882e-02f, 9.38322544e-02f, 1.70193687e-02f,
  -6.68513104e-02f, -3.10808234e-02f, 4.98576686e-02f, 1.21842727e-01f, 7.83856586e-03f, 1.18607968e-01f, 1.61108240e-01f, -1.84754711e-02f, -5.23244366e-02f, -6.40459126e-03f,
  1.97566122e-01f, -7.31508657e-02f, 3.66568714e-02f, 2.41331244e-03f, -1.20127678e-01f, 9.58652422e-02f, 8.33730698e-02f, 1.35445431e-01f, 7.83607811e-02f, 2.43178550e-02f,
  1.55161813e-01f, 1.56656295e-01f, 6.00233451e-02f, 7.20058754e-02f, -4.88670208e-02f, 6.41502962e-02f, -1.13369770e-01f, 6.21454492e-02f, -5.55292144e-03f, 2.39744615e-02f,
  1.49771934e-02f, -6.94611818e-02f, -2.28237733e-02f, 6.58858120e-02f, 1.00841127e-01f, -1.68055266e-01f, 8.07304904e-02f, 1.02053024e-01f, -4.32248833e-03f, 9.31326523e-02f,
  5.24597615e-02f, -1.25704870e-01f, 2.28444003e-02f, -8.38823244e-02f, 9.42558944e-02f, 7.72323534e-02f, 4.14221399e-02f, -9.19226110e-02f, -1.12740420e-01f, 6.93083704e-02f,
  8.78753811e-02f, 2.42987648e-02f, 6.84980378e-02f, 9.44947749e-02f, -7.24440366e-02f, -1.27076685e-01f, 5.37829325e-02f, -9.49816629e-02f, -1.18080340e-01f, 1.05191328e-01f,
  -8.22714046e-02f, 7.32035264e-02f, 1.03744194e-01f, 8.13265368e-02f, -8.42741728e-02f, -5.68131171e-03f, -8.65445733e-02f, -1.06984368e-02f, 1.12999737e-01f, 6.76245913e-02f,
  -1.28557384e-01f, -2.51513347e-02f, -3.75158228e-02f, 2.85853036e-02f, 6.05542548e-02f, -7.78280348e-02f, -4.66657504e-02f, -1.46723583e-01f, 7.69360662e-02f, -6.10083938e-02f,
  -8.80721137e-02f, -9.44078788e-02f, 7.59607852e-02f, 9.54275355e-02f, 6.67476803e-02f, -9.31180865e-02f, -2.01597400e-02f, 1.17866315e-01f, 1.62343532e-01f, 2.63127163e-02f,
  2.64515013e-01f, 1.55001283e-01f, 5.41273803e-02f, 6.93442971e-02f, -1.00901045e-01f, -1.04179658e-01f, -7.71148130e-02f, -1.61586478e-01f, 3.60586271e-02f, -2.49743000e-01f,
  5.91362454e-02f, 1.08510979e-01f, 5.35415784e-02f, 9.14758891e-02f, -1.25834897e-01f, -1.07856147e-01f, 1.33589372e-01f, -7.12252408e-02f, -1.38767630e-01f, -2.21051499e-02f,
  6.31836653e-02f, 6.87591881e-02f, -7.03934953e-02f, -1.31065965e-01f, 1.36294961e-01f, -1.42679766e-01f, -5.66979460e-02f, -9.05092955e-02f, 6.20473875e-03f, -7.77850673e-02f,
  -5.82892820e-02f, -3.84639911e-02f, -3.00510097e-02f, -9.54042301e-02f, -7.28809014e-02f, -1.59819186e-01f, 1.76243618e-01f, -1.70854833e-02f, 9.51388013e-03f, -3.92300263e-02f,
  1.73858833e-02f, 1.15360834e-01f, 1.72489926e-01f, -4.66562994e-02f, 6.41625449e-02f, -2.70973165e-02f, -9.04173926e-02f, -1.23600096e-01f, 1.89965487e-01f, -1.03268459e-01f,
  8.85401741e-02f, -1.04917504e-01f, 8.07560161e-02f, -1.14684269e-01f, 1.09442800e-01f, -5.99854700e-02f, 9.92566869e-02f, 1.28883481e-01f, 1.95825830e-01f, 2.02721700e-01f,
  2.07667977e-01f, -1.02132395e-01f, 1.93839833e-01f, 8.76428559e-02f, 1.85626581e-01f, -1.86428931e-02f, 1.79406375e-01f, 1.93021163e-01f, 2.91798532e-01f, 2.51230076e-02f,
  -1.53085589e-01f, -2.12449729e-01f, -1.28920794e-01f, -8.36245120e-02f, -2.30182912e-02f, -1.42838329e-01f, -1.00940235e-01f, 1.51034206e-01f, -9.02112201e-02f, 2.14516193e-01f,
  1.54605523e-01f, 1.50793687e-01f, 1.82979226e-01f, 4.29758839e-02f, 6.85799941e-02f, -2.33833101e-02f, -1.74686629e-02f, 1.75074011e-01f, 5.92639111e-02f, 6.38964958e-03f,
  -4.27458212e-02f, -7.46582448e-02f, 8.13657492e-02f, -8.71157572e-02f, 5.51359281e-02f, -8.24258775e-02f, 2.12948211e-02f, 2.07414418e-01f, -1.42586768e-01f, 8.55408702e-03f,
  -1.47668362e-01f, -1.67355686e-02f, -7.07893893e-02f, -7.19985813e-02f, -8.86766985e-02f, 1.02629602e-01f, 1.07593909e-01f, 5.45408726e-02f, 3.47061269e-03f, -9.12119225e-02f,
  2.05931291e-02f, 1.00419976e-01f, 3.12841624e-01f, 1.91438153e-01f, 8.63612965e-02f, -1.23696171e-01f, -1.20282792e-01f, 2.09043279e-01f, 1.56250801e-02f, -1.31472982e-02f,
  6.02728128e-02f, 2.73749996e-02f, -1.82731941e-01f, -5.32687083e-02f, -2.85191787e-03f, -1.12319496e-02f, 1.29654571e-01f, 9.93155539e-02f, 7.33659640e-02f, -6.60635084e-02f,
  -7.33272880e-02f, 1.87972817e-03f, 3.49624828e-02f, -1.20584570e-01f, 3.72208469e-03f, -1.30020604e-01f, -1.10192873e-01f, -1.34158820e-01f, 1.35761559e-01f, -7.23364353e-02f,
  -8.53946432e-02f, -7.43505955e-02f, -7.04595521e-02f, 1.90762617e-02f, 6.10142238e-02f, -7.91582912e-02f, 4.69888374e-02f, 7.93684870e-02f, 1.15115372e-02f, 1.27414897e-01f,
  -9.95237753e-02f, -7.11409077e-02f, 6.86053187e-02f, -7.58304307e-03f, 1.28361642e-01f, 9.66505110e-02f, 1.43696457e-01f, 4.69172709e-02f, 7.37394467e-02f, 4.31901626e-02f,
  -1.14612229e-01f, 9.64091346e-02f, 2.21076738e-02f, 1.00842878e-01f, 1.23405695e-01f, -7.15277344e-02f, -2.50800364e-02f, -3.05268466e-02f, 6.15034662e-02f, -2.73390990e-02f,
  -7.31180832e-02f, 7.60101341e-03f, -9.83668938e-02f, 3.59891616e-02f, -5.15461192e-02f, -1.09272294e-01f, 4.34856825e-02f, 2.93019786e-02f, 1.11875758e-01f, -8.87986366e-03f,
  -5.92965186e-02f, -5.95594868e-02f, 8.14085305e-02f, -2.64915414e-02f, 8.98231044e-02f, -4.43737917e-02f, -9.50575620e-02f, 4.60822247e-02f, 1.01661906e-01f, -4.38744538e-02f,
  -5.86460419e-02f, -4.58525531e-02f, 3.83358411e-02f, -1.53807905e-02f, 1.34292501e-03f, -8.29347074e-02f, 1.39178053e-01f, -2.60530580e-02f, 5.38304858e-02f, -6.41812086e-02f,
  -9.23554599e-03f, 1.42514154e-01f, -4.31459397e-04f, 1.15482081e-02f, -1.40230320e-02f, 1.04242451e-01f, 1.09441154e-01f, 2.26344317e-02f, 5.27945682e-02f, -1.81815848e-02f,
  -4.70998744e-03f, -9.94968489e-02f, -1.38732120e-02f, -3.48889157e-02f, -7.36940140e-03f, -3.49375443e-03f, 2.55000759e-02f, -5.99382967e-02f, -3.68945114e-02f, -1.04048230e-01f,
  -1.00003354e-01f, 4.42189351e-02f, 1.29630730e-01f, -4.01001088e-02f, 3.50358076e-02f, -5.79747483e-02f, 1.09587051e-01f, -7.96262175e-03f, -1.80661604e-02f, 6.15415610e-02f,
  -1.03593960e-01f, -1.61066931e-02f, -4.08511609e-02f, -6.93101957e-02f, -7.23466203e-02f, -1.04848161e-01f, 3.17076780e-02f, -9.34751034e-02f, -1.16630070e-01f, 1.28246948e-01f,
  7.08496124e-02f, 8.35298002e-03f, -1.13487758e-01f, -1.19046785e-03f, 5.95077313e-02f, -4.31082360e-02f, 9.91927907e-02f, 4.97456416e-02f, 4.77351546e-02f, -6.08046055e-02f,
  -1.89309083e-02f, -1.07572898e-01f, -1.10394157e-01f, -5.93937077e-02f, 1.06993124e-01f, 7.47957127e-03f, 7.42942020e-02f, 1.93651870e-01f, 1.36098778e-02f, 9.71752927e-02f,
  1.16687223e-01f, 8.70463625e-02f, 1.54722497e-01f, 2.04238802e-01f, -1.03366897e-01f, 3.75965983e-02f, 1.67339385e-01f, 5.80828153e-02f, -5.65306544e-02f, 1.29976183e-01f,
  1.62357509e-01f, 3.56530678e-03f, 1.92391220e-02f, -1.61247293e-03f, -8.17647874e-02f, 1.01494864e-01f, 8.81029852e-03f, -1.43627852e-01f, 1.67046905e-01f, 8.63763243e-02f,
  -8.00913572e-02f, 1.58431634e-01f, -5.50601371e-02f, 1.26727626e-01f, 2.08084270e-01f, -2.06545684e-02f, 1.68306038e-01f, 1.31936297e-01f, -7.92589411e-02f, 9.53166112e-02f,
  7.46463910e-02f, 3.04975305e-02f, -1.09438531e-01f, -2.01387703e-02f, 1.06537165e-02f, 1.61443695e-01f, 1.15191743e-01f, 1.10662505e-01f, 3.75661552e-02f, -1.18074782e-01f,
  7.75387585e-02f, 3.33444998e-02f, 4.13720571e-02f, 3.79160345e-02f, 9.28002298e-02f, 5.80760352e-02f, 1.35429993e-01f, 6.90866485e-02f, -8.37675706e-02f, 2.30901651e-02f,
  3.67359743e-02f, 7.14345798e-02f, 1.30698562e-01f, -1.39534911e-02f, -7.69934356e-02f, 9.18004066e-02f, -1.82901874e-01f, 1.77337199e-01f, 1.66257665e-01f, 1.64789092e-02f,
  1.36193588e-01f, -3.14866751e-03f, 1.31993413e-01f, -1.85923558e-02f, 7.36194104e-02f, -1.67738318e-01f, -1.93149030e-01f, -4.97647636e-02f, 9.54166353e-02f, -2.08935559e-01f,
  -9.88894030e-02f, 8.50600377e-02f, -8.99778530e-02f, 1.12603329e-01f, 9.36250985e-02f, 8.82979333e-02f, -7.19531700e-02f, 1.25411913e-01f, 1.45040989e-01f, -7.98085555e-02f,
  2.71615125e-02f, 1.49359971e-01f, 5.47677139e-03f, 1.81560621e-01f, 7.96748474e-02f, 2.54339397e-01f, 1.12117231e-01f, 3.11679691e-02f, -3.94985303e-02f, -7.60120898e-02f,
  8.22673887e-02f, 9.53996647e-03f, -1.39060104e-02f, 6.59546554e-02f, -4.25130986e-02f, 7.98716992e-02f, -6.94133043e-02f, -5.15371598e-02f, 1.00513346e-01f, 8.43231604e-02f,
  1.08448252e-01f, 5.24132326e-02f, -2.20625717e-02f, -3.59325595e-02f, 1.07998922e-02f, -9.26406831e-02f, 1.45037517e-01f, -6.66031912e-02f, 1.06577337e-01f, 1.19794048e-01f,
  6.37383899e-03f, -1.35057911e-01f, -9.88602862e-02f, 1.13647655e-01f, 2.65278518e-02f, -1.33604079e-01f, -6.53490573e-02f, 3.12537029e-02f, -9.97980982e-02f, 5.19593731e-02f,
  3.22440825e-02f, -1.35431523e-02f, -4.41208575e-03f, -5.49230259e-03f, 1.75199777e-01f, 1.75976545e-01f, 7.15186223e-02f, 2.96684429e-02f, 1.06530331e-01f, -1.27008870e-01f,
  -1.20509341e-01f, -1.26100525e-01f, 1.49554744e-01f, -1.22655995e-01f, -2.32769363e-02f, -9.17205811e-02f, 1.24855518e-01f, 1.14216805e-01f, -1.51562080e-01f, 1.26629090e-02f,
  1.54924363e-01f, -2.45120330e-03f, 9.75904986e-02f, -2.29347758e-02f, 1.21797159e-01f, -1.30460206e-02f, -6.77106678e-02f, -8.68157670e-02f, 1.29348457e-01f, -1.00947320e-01f,
  2.19950993e-02f, 6.49606064e-02f, -3.55968513e-02f, 2.18906663e-02f, -8.57662261e-02f, -1.09985851e-01f, 3.28378752e-02f, 3.64734568e-02f, 9.21384618e-02f, -3.74326576e-03f,
  -2.91569508e-03f, -1.02804154e-01f, 6.84640333e-02f, -8.54282547e-03f, -1.05307057e-01f, 4.24936004e-02f, -3.30443643e-02f, -9.61495936e-03f, 1.22577742e-01f, 3.91514637e-02f,
  -3.31547484e-02f, 3.90388668e-02f, 1.93177223e-01f, -6.07075058e-02f, 6.18361048e-02f, 3.29519548e-02f, -8.13841894e-02f, 4.23937477e-02f, -3.51938279e-03f, -6.56956658e-02f,
  -6.44781962e-02f, 9.47509557e-02f, 1.85118884e-01f, 6.91779181e-02f, 1.96929470e-01f, 3.48852389e-02f, 9.80681181e-02f, 1.22407161e-01f, -3.70677933e-02f, 6.24463297e-02f,
  1.92059904e-01f, -1.48023963e-02f, -6.00070767e-02f, 2.88613122e-02f, -1.12163750e-02f, 6.17749281e-02f, 7.91413635e-02f, -1.56701535e-01f, 5.76313101e-02f, 5.11250496e-02f,
  1.04548940e-02f, 2.54615061e-02f, -7.58529752e-02f, -1.11544177e-01f, -4.33491953e-02f, 9.15515944e-02f, -4.26028483e-02f, 1.22189097e-01f, 9.61887911e-02f, -3.53639647e-02f,
  6.79539964e-02f, -3.82749401e-02f, 7.24417269e-02f, -4.16105427e-02f, -6.10900521e-02f, 8.52229819e-02f, -6.15670979e-02f, -1.14829745e-03f, -9.77060050e-02f, 7.49834105e-02f,
  -3.58589701e-02f, 6.20921552e-02f, 1.06310971e-01f, 5.39643466e-02f, -4.37757932e-04f, 2.92451140e-02f, 8.68266374e-02f, -3.48346680e-02f, -9.36486050e-02f, 6.73845634e-02f,
  1.05006196e-01f, -2.35969760e-02f, 1.60130523e-02f, 1.17488399e-01f, 6.23605773e-02f, 8.18283260e-02f, -7.47890249e-02f, -5.31021021e-02f, 9.88217164e-03f, -4.48554428e-03f,
  -2.80126315e-02f, 1.07297890e-01f, -5.13148271e-02f, -1.22971915e-01f, -1.13560081e-01f, -5.83091192e-02f, 1.28393352e-01f, -6.76221400e-02f, 1.22683175e-01f, -9.48236138e-02f,
  1.33764878e-01f, 6.33697510e-02f, 1.96200699e-01f, 1.16828553e-01f, -5.03561087e-02f, 9.97940227e-02f, 2.09751472e-01f, -7.10501298e-02f, -1.35413602e-01f, -8.30303505e-02f,
  -1.07597195e-01f, 1.28921807e-01f, 9.23113450e-02f, -8.10283422e-02f, 7.66820535e-02f, 3.11212391e-02f, -9.50385779e-02f, 1.85325630e-02f, -1.04551621e-01f, -3.88122792e-03f,
  2.15111360e-01f, -2.16856389e-03f, 1.15961015e-01f, 4.72777523e-02f, 1.49793923e-01f, 2.25834593e-01f, -7.64460564e-02f, 1.25759825e-01f, 2.44641379e-02f, 9.20764208e-02f,
  1.42900214e-01f, 1.41321257e-01f, 1.47418618e-01f, -7.11833732e-03f, 4.92080580e-04f, -3.25557366e-02f, -1.60827152e-02f, -9.77045074e-02f, -6.30410761e-02f, 2.22705044e-02f,
  4.78304364e-02f, 1.48272231e-01f, 4.34398428e-02f, 1.32766172e-01f, -1.07937105e-01f, 8.09759498e-02f, 2.58724242e-02f, 3.14159282e-02f, 4.99558188e-02f, 1.62359476e-01f,
  1.57134265e-01f, 1.46224588e-01f, 8.53369385e-02f, -1.43322900e-01f, 1.05735147e-02f, 8.33264291e-02f, 6.71753362e-02f, 4.55495827e-02f, -8.72665197e-02f, 7.95815587e-02f,
  -1.15422547e-01f, 4.60567214e-02f, -4.52152267e-02f, 9.63795856e-02f, -1.27477152e-02f, 1.35890201e-01f, 2.98767164e-02f, 6.72063604e-02f, -7.11207092e-02f, 1.23635337e-01f,
  -1.08362706e-02f, -4.42285836e-02f, 2.40217838e-02f, -5.33624366e-02f, 3.16656008e-02f, -1.43737480e-01f, 7.86465406e-02f, 6.15830300e-03f, -5.33497706e-03f, -5.63927740e-02f,
  8.33616182e-02f, -6.01512194e-02f, 5.37105389e-02f, 5.41292541e-02f, -2.42590345e-02f, 1.15793552e-02f, -9.17140990e-02f, -6.85078949e-02f, -1.34195928e-02f, -8.28898102e-02f,
  1.02439761e-01f, -3.17710675e-02f, -6.19952865e-02f, -9.67627838e-02f, 1.02421440e-01f, 4.59978022e-02f, -9.39022005e-02f, 1.84246749e-02f, 1.08580649e-01f, -1.10317022e-02f,
  1.36772811e-01f, -8.48915875e-02f, -8.68791565e-02f, -9.07388180e-02f, -6.05760375e-03f, 2.51365956e-02f, -1.23463131e-01f, -9.84807834e-02f, 1.06970929e-01f, -9.57195088e-02f,
  -9.74398255e-02f, 1.05956838e-01f, 2.24820189e-02f, 9.73999221e-03f, -1.26030877e-01f, -1.01457253e-01f, 5.23429550e-02f, -5.42565398e-02f, -3.49583104e-02f, -7.15340860e-03f,
  -1.57970339e-02f, 4.25693728e-02f, -9.93240401e-02f, 8.60365573e-03f, 1.53079256e-02f, 1.30078390e-01f, -5.87551519e-02f, -1.80737562e-02f, 6.13209531e-02f, -3.35301943e-02f,
  -2.60908045e-02f, -9.86425951e-02f, -1.80731434e-02f, -6.38578907e-02f, 4.27595451e-02f, -1.20904766e-01f, -9.07165110e-02f, -3.97424325e-02f, 9.49245766e-02f, 1.24092937e-01f,
  -1.25481114e-01f, 8.84941518e-02f, -1.30651042e-01f, 1.33321360e-01f, -1.16083048e-01f, 1.06402248e-01f, 1.16661198e-01f, 6.75695390e-02f, 1.72973961e-01f, -8.95671993e-02f,
  1.15700148e-01f, 1.91126030e-03f, -4.83975001e-02f, 1.63330808e-02f, 1.20443553e-01f, 6.02323972e-02f, -4.25844714e-02f, -1.17581576e-01f, 5.97380474e-02f, -3.93595919e-02f,
  9.37758945e-03f, 8.31551254e-02f, -9.98037681e-02f, 1.14883974e-01f, 2.69370675e-02f, -8.28199610e-02f, 5.70283085e-02f, 4.88656051e-02f, 9.13602188e-02f, -2.71948818e-02f,
  7.95567967e-03f, 3.59364226e-02f, -1.01878397e-01f, -4.92351968e-03f, -4.86736037e-02f, 1.02816440e-01f, -7.78548047e-02f, 1.16932131e-01f, 2.14088168e-02f, 1.78339221e-02f,
  4.89629097e-02f, -1.30336687e-01f, -5.02394028e-02f, 9.66820195e-02f, 1.96045563e-02f, -1.04281725e-03f, -6.34412020e-02f, 2.81518064e-02f, -7.96813741e-02f, 8.28677788e-02f,
  -1.02605507e-01f, 1.30044669e-01f, 9.89084225e-03f, 2.58606434e-01f, 8.49702731e-02f, 2.03105077e-01f, 1.17784038e-01f, -4.36406070e-03f, -3.15155119e-01f, 3.42288017e-02f,
  -3.20135891e-01f, 1.41546905e-01f, 1.77903295e-01f, -2.14000270e-01f, 1.00400550e-02f, 1.31435152e-02f, -2.70433854e-02f, -7.98280090e-02f, -5.09306155e-02f, -1.72457978e-01f,
  -1.69216618e-02f, 7.25052133e-02f, 1.56109184e-01f, 7.25219920e-02f, 4.48647514e-02f, 2.05122381e-01f, 1.20449618e-01f, -1.13467522e-01f, 5.25870211e-02f, 2.24227775e-02f,
  -9.21707973e-03f, 6.42770901e-02f, -1.02192730e-01f, -1.60031155e-01f, -5.02275676e-02f, -4.28684838e-02f, 4.43020426e-02f, -3.74880731e-02f, 3.91865857e-02f, -1.26736268e-01f,
  1.46503374e-01f, -1.08386278e-01f, -6.71930462e-02f, -1.42462552e-01f, -3.76459807e-02f, 1.42587602e-01f, 7.64812753e-02f, 2.86455695e-02f, -1.18602879e-01f, 1.30127862e-01f,
  8.56394842e-02f, 1.71135701e-02f, -1.22831734e-02f, -6.14905469e-02f, 1.56807564e-02f, -6.42713085e-02f, -6.68268949e-02f, -6.69162069e-03f, 5.26488423e-02f, -4.78738844e-02f,
  8.01198781e-02f, -9.61743668e-02f, -1.03709415e-01f, 1.42986432e-01f, 1.29775628e-01f, -1.11062735e-01f, 3.46226804e-02f, 4.62812483e-02f, -7.71658868e-02f, -4.59277667e-02f,
  -7.65620694e-02f, 9.06865820e-02f, -5.26446141e-02f, 1.94077361e-02f, 1.41430914e-01f, 1.46096066e-01f, 4.06509116e-02f, 5.49590075e-03f, 1.13901116e-01f, 5.13126701e-03f,
  -1.25391960e-01f, 8.97268727e-02f, 1.25691712e-01f, -1.59367193e-02f, 7.25809708e-02f, -2.05898844e-02f, -1.23908417e-02f, 5.52200153e-02f, -1.85868237e-02f, 1.02876090e-02f,
  1.38073713e-01f, -2.83919293e-02f, 2.19019838e-02f, 1.86415929e-02f, 2.11748946e-02f, -4.42844816e-03f, 2.44854748e-01f, 7.39672557e-02f, 8.92493650e-02f, 1.18776545e-01f,
  5.63139431e-02f, -1.35990381e-01f, -9.55175050e-03f, 2.48921633e-01f, 1.26665264e-01f, 5.02520846e-03f, -1.08401865e-01f, -1.93541392e-03f, 3.88999507e-02f, -1.20022871e-01f,
  5.02085872e-02f, 5.12927882e-02f, 1.54290050e-01f, -8.95372629e-02f, 1.64376460e-02f, -2.70178611e-03f, -9.11196768e-02f, -9.23125148e-02f, -2.87128668e-02f, 6.38319999e-02f,
  -3.20140049e-02f, 8.48263428e-02f, 4.20716181e-02f, 1.52325658e-02f, -3.65499370e-02f, 9.02624950e-02f, -4.80595627e-04f, 3.71651538e-02f, -1.99807603e-02f, 1.03558183e-01f,
  1.51291132e-01f, 1.31978944e-01f, 9.66292247e-02f, -3.82358842e-02f, 1.13363236e-01f, 1.89617559e-01f, 4.27834056e-02f, -3.26071195e-02f, 1.16788428e-02f, 3.14539601e-03f,
  -1.61112055e-01f, -4.17066067e-02f, -3.05758491e-02f, -1.30016118e-01f, -1.30001292e-01f, 3.39490213e-02f, -3.12726770e-04f, 6.95776492e-02f, -9.14898142e-02f, 4.03763466e-02f,
  5.25438748e-02f, -5.89199215e-02f, 1.10295594e-01f, 8.78373832e-02f, -1.62664969e-02f, -2.74647772e-02f, -6.81780577e-02f, 2.89703459e-02f, 1.67804547e-02f, 8.25003237e-02f,
  -3.02870739e-02f, 3.03374678e-02f, 9.90745872e-02f, -4.28963751e-02f, -1.33052453e-01f, 5.32073081e-02f, 6.61196746e-03f, -5.95065728e-02f, 1.26209389e-02f, -4.17810865e-02f,
  -7.20542297e-02f, 8.27173591e-02f, -9.75585133e-02f, -2.35560574e-02f, 9.44962427e-02f, -3.75211127e-02f, -2.27435306e-03f, -6.16899580e-02f, 2.00011544e-02f, 2.34777275e-02f,
  5.79350702e-02f, 1.76757842e-01f, 8.96704420e-02f, -1.27687708e-01f, 6.25946447e-02f, 4.11886387e-02f, -5.76257035e-02f, -4.04085070e-02f, -1.00908868e-01f, 1.02434114e-01f,
  -2.25268677e-02f, -3.42088044e-02f, -7.46817812e-02f, 1.60622597e-02f, 4.09377441e-02f, -2.74310801e-02f, 5.85151371e-03f, 7.82257095e-02f, 1.22525774e-01f, -9.90604907e-02f,
  -1.63822640e-02f, -1.30192339e-02f, 3.12579833e-02f, 8.70429873e-02f, -1.10849202e-01f, -5.19896150e-02f, 2.46302108e-03f, -9.26721171e-02f, 6.87877927e-03f, 1.12593867e-01f,
  1.35434091e-01f, 1.06057249e-01f, -3.53804193e-02f, -1.14577256e-01f, -4.86108288e-03f, 4.33406942e-02f, 9.37502831e-02f, 2.08196864e-02f, -9.46721584e-02f, 1.21805795e-01f,
  8.70674551e-02f, 6.28504679e-02f, -4.44215573e-02f, 3.91850695e-02f, -2.73232963e-02f, -1.06071509e-01f, 6.92279637e-02f, -8.79740790e-02f, 2.94621903e-02f, 3.07491124e-02f,
  7.27334544e-02f, 1.20670028e-01f, -8.63260478e-02f, 3.49933505e-02f, -1.23216160e-01f, 1.19182587e-01f, 4.88112420e-02f, -3.37447375e-02f, -5.56306913e-02f, -4.44549397e-02f,
  -6.65321127e-02f, 1.42141534e-02f, 1.47899300e-01f, -4.67188582e-02f, 1.21113643e-01f, -4.99142036e-02f, 1.07090019e-01f, -9.06393230e-02f, -9.84997824e-02f, 4.90745753e-02f,
  6.55236170e-02f, -7.69912377e-02f, 3.51560637e-02f, 6.52312264e-02f, -1.22850463e-01f, -4.85234410e-02f, -5.04713319e-02f, 1.27890557e-01f, -1.63730830e-02f, -5.37601188e-02f,
  9.23724398e-02f, -4.23488207e-03f, 1.41614228e-01f, 2.50221621e-02f, -3.40071395e-02f, 5.07360883e-02f, -1.29680946e-01f, 4.60805409e-02f, 6.12653010e-02f, -1.84634924e-01f,
  -7.85536468e-02f, 7.98491612e-02f, -1.07089020e-01f, 9.84009132e-02f, -1.43979583e-03f, 5.56373857e-02f, 8.39430913e-02f, 2.34347824e-02f, -2.34840717e-02f, -7.59531409e-02f,
  -4.91774790e-02f, -6.89681917e-02f, -8.82413685e-02f, 6.37826398e-02f, 9.03111249e-02f, 8.55379179e-02f, 1.30984619e-01f, -1.22373410e-01f, 5.94092570e-02f, -2.64950041e-02f,
  -1.17543466e-01f, 3.18393409e-02f, -8.53932574e-02f, 1.16283357e-01f, -1.08563051e-01f, 5.08291088e-02f, 1.38364360e-01f, 5.00149559e-03f, -3.79995704e-02f, 1.04813986e-01f,
  -1.36699406e-02f, -3.43827270e-02f, -1.03549711e-01f, -9.30790454e-02f, -1.19829714e-01f, -6.97257966e-02f, -3.02229803e-02f, 4.77960743e-02f, -4.20656763e-02f, 1.11032054e-02f,
  4.77214493e-02f, -3.88450921e-02f, -6.47497773e-02f, -1.79626141e-02f, -2.44483929e-02f, 9.98931453e-02f, -1.07545249e-01f, -9.31385085e-02f, -2.48208530e-02f, 4.87414971e-02f,
  -1.29565997e-02f, -4.85790595e-02f, 2.25018084e-01f, 6.36502802e-02f, 1.84710264e-01f, 2.60768998e-02f, 3.90954949e-02f, 2.50969410e-01f, 2.11904332e-01f, -9.00290534e-02f,
  -1.20925978e-01f, -1.54806525e-01f, 2.85992008e-02f, 1.74787074e-01f, -4.88312803e-02f, -1.61642265e-02f, 1.48993671e-01f, -3.81583790e-03f, -7.97267333e-02f, 3.52901936e-01f,
  5.04404977e-02f, 1.60585269e-01f, 1.31339028e-01f, -2.82753538e-02f, -1.89974606e-02f, -1.55038595e-01f, 1.08733110e-01f, 1.68449923e-01f, 1.81352034e-01f, 4.16159555e-02f,
  -2.64456216e-02f, 4.12617102e-02f, -7.78774396e-02f, 2.28186455e-02f, -6.34211209e-03f, -1.88851971e-02f, -5.01953717e-03f, 9.46326926e-02f, 3.69690498e-03f, 3.34095359e-02f,
  -1.26980469e-01f, -6.85608983e-02f, -9.03595015e-02f, 1.04480058e-01f, 1.82143942e-01f, 1.27402067e-01f, 1.34075835e-01f, 1.23286374e-01f, -5.76347336e-02f, 6.16201535e-02f,
  4.49594595e-02f, 1.39654651e-01f, 1.99863553e-01f, 3.40118296e-02f, 1.46837592e-01f, -1.90108437e-02f, -7.43569583e-02f, 1.66273803e-01f, 1.15234859e-01f, 2.60114223e-01f,
  -1.31399497e-01f, -3.71668860e-02f, -1.79590195e-01f, 2.51294281e-02f, -2.89407186e-03f, 1.93433434e-01f, -7.90410340e-02f, 2.19287928e-02f, -1.30102232e-01f, -1.37534380e-01f,
  4.61632721e-02f, 4.85340655e-02f, 1.54233361e-02f, 4.67480272e-02f, 1.11935765e-01f, 2.25920230e-02f, 9.72816348e-02f, -9.99739096e-02f, 1.76974963e-02f, 6.83901832e-02f,
  -2.16542855e-02f, -5.61329685e-02f, 6.27215654e-02f, -3.74052525e-02f, 1.07528875e-02f, 8.16868320e-02f, -1.39210537e-01f, 5.24569191e-02f, -3.39795798e-02f, -9.22538340e-02f,
  -7.79413655e-02f, -2.31212974e-02f, 2.36284696e-02f, -9.16961208e-02f, 6.21313415e-02f, -8.64995420e-02f, 7.85215273e-02f, 5.50013445e-02f, 1.77223291e-02f, 6.40479326e-02f,
  -5.47748283e-02f, -1.19120635e-01f, -1.04084603e-01f, 1.16213216e-02f, 1.35602370e-01f, -6.21068329e-02f, 1.08007595e-01f, 2.14965101e-02f, -1.15322083e-01f, -8.96315351e-02f,
  9.02765766e-02f, -2.43220516e-02f, -3.87401059e-02f, 7.40977526e-02f, -2.66952254e-02f, 9.66523066e-02f, 9.42532122e-02f, 2.93579441e-03f, 7.73569420e-02f, 4.69419025e-02f,
  1.03209257e-01f, -5.50329238e-02f, -9.24665779e-02f, 4.93984818e-02f, -1.06339179e-01f, -1.06541244e-02f, 7.85422325e-03f, -1.28685072e-01f, -9.20794234e-02f, -8.41563102e-04f,
  1.58273339e-01f, 2.15091348e-01f, -4.57678139e-02f, -1.84112079e-02f, 1.10301010e-01f, 3.61958779e-02f, -2.09329143e-01f, 4.83229943e-02f, -2.58990586e-01f, 8.60401616e-02f,
  1.43325612e-01f, -1.94320828e-01f, -1.08043998e-01f, -6.29870221e-02f, 3.38444337e-02f, 2.07114760e-02f, 1.65481880e-01f, 3.29872370e-02f, -1.61927909e-01f, -7.94675350e-02f,
  1.26769785e-02f, 7.63757527e-02f, 2.34792549e-02f, 6.11012988e-02f, 1.24127969e-01f, -3.72363217e-02f, 1.22771397e-01f, -6.59892485e-02f, 5.66705130e-02f, -9.42375734e-02f,
  -2.29378119e-02f, -9.92312506e-02f, -5.74385487e-02f, 1.11505799e-01f, 5.65731190e-02f, -9.22646448e-02f, 2.88125928e-02f, -8.46529603e-02f, 1.10811517e-01f, -1.04823709e-01f,
  6.70296028e-02f, -1.37513980e-01f, 3.43906097e-02f, 1.20315276e-01f, -2.87919901e-02f, 7.64041394e-02f, -1.37195975e-01f, 5.70422895e-02f, -4.92491722e-02f, -1.04773775e-01f,
  4.27852459e-02f, -7.42865773e-03f, -4.18208353e-02f, -8.56802892e-03f, 8.94874409e-02f, -1.59351842e-03f, -1.16258122e-01f, -2.53706481e-02f, 1.30339032e-02f, -3.32534537e-02f,
  8.46955404e-02f, -5.87492734e-02f, 8.26899521e-03f, -7.18801618e-02f, 9.46399290e-03f, -1.32577177e-02f, -7.99117461e-02f, 4.54650261e-02f, -1.40854726e-02f, -1.04087114e-01f,
  -8.57895687e-02f, -8.82461816e-02f, 4.30389568e-02f, 9.24264565e-02f, 1.49425445e-02f, 8.45635384e-02f, 2.17750780e-02f, -5.64689077e-02f, 1.39893461e-02f, -1.09811738e-01f,
  5.60880778e-03f, 8.66099447e-02f, -1.14083201e-01f, 8.30599889e-02f, 1.32676680e-02f, -2.11466681e-02f, -7.10337004e-03f, -2.64849961e-02f, 7.54094794e-02f, 5.66489324e-02f,
  2.37599444e-02f, 6.38851780e-04f, 2.32261848e-02f, 8.50380287e-02f, 5.19855246e-02f, 1.03909716e-01f, -8.76107439e-02f, 1.11779146e-01f, 1.16240025e-01f, 2.13576900e-03f,
  1.17090315e-01f, -1.46757802e-02f, -2.47503500e-02f, 2.64187027e-02f, -9.53187793e-02f, -9.86155048e-02f, -9.35322866e-02f, 3.65351997e-02f, 1.71795040e-02f, 1.03244781e-01f,
  -7.42536634e-02f, 1.11640602e-01f, -5.57856523e-02f, -1.01144528e-02f, -4.22038212e-02f, 1.05349980e-01f, -7.45069468e-03f, -5.59503622e-02f, 1.10406458e-01f, -8.49890262e-02f,
  7.55723640e-02f, -3.86133641e-02f, 5.15851900e-02f, 8.53781998e-02f, -7.69540370e-02f, 7.32169971e-02f, -1.37268025e-02f, -9.28363428e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  4.30897363e-02f, -3.44020277e-02f, 1.21644258e-01f, -6.84993491e-02f, 1.27146602e-01f, 2.21013993e-01f, -3.91231999e-02f, 2.67882552e-02f, 1.59619823e-01f, 2.25088019e-02f,
  -2.81699412e-02f, 2.22593784e-01f, -1.04242899e-01f, 8.53595659e-02f, 1.20828815e-01f, -1.61826853e-02f, 2.16921255e-01f, 2.76860118e-01f, 4.04331908e-02f, 6.96234703e-02f,
  -3.65018728e-03f, -1.01193063e-01f, -5.07690758e-02f, 1.26755154e-02f, 2.05369312e-02f, 2.29259968e-01f, 6.53892234e-02f, 3.03880900e-01f, 1.00938551e-01f, -3.04263309e-02f,
  2.26748455e-02f, 1.18016107e-02f, 1.79270014e-01f, 2.05215752e-01f, -8.60578418e-02f, -9.00737196e-02f, 1.45392373e-01f, 2.71646291e-01f, 2.02780768e-01f, 3.55687849e-02f,
  3.05656288e-02f, -7.68609792e-02f, 1.37078883e-02f, 2.59368092e-01f, 1.09824538e-01f, 1.80429265e-01f, 8.81662294e-02f, -9.67549235e-02f, 2.24574149e-01f, -6.73563480e-02f,
  5.21868095e-02f, 2.45655589e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  2.53999922e-02f, -1.50422260e-01f, -7.01055974e-02f, -1.16393261e-01f, 1.10322237e-01f, 5.70764504e-02f, -1.78373411e-01f, -2.01189481e-02f, 1.28863618e-01f, 2.66219318e-01f,
  -1.77005455e-01f, 2.40134820e-01f, -7.85236359e-02f, -1.00195259e-02f, -1.73994973e-02f, 4.53679375e-02f, -2.54740752e-02f, 3.02437134e-02f, 9.13359150e-02f, 3.71946804e-02f,
  -2.87769688e-03f, -7.35033080e-02f, 1.23678759e-01f, 1.91065490e-01f, -2.26918682e-02f, 1.32469401e-01f, 1.68438196e-01f, -1.90133397e-02f, -2.20013335e-01f, -8.30189139e-02f,
  -1.16074756e-01f, -2.95711169e-03f, 1.05821118e-02f, -6.39576167e-02f, -2.79034507e-02f, -1.86028779e-01f, 1.41323330e-02f, 2.23084226e-01f, -5.00523522e-02f, -2.45480072e-02f,
  1.61874563e-01f, 5.14933467e-03f, -7.08646774e-02f, 1.18280090e-01f, -2.07549065e-01f, -1.72064140e-01f, 5.61499000e-02f, 1.22066043e-01f, 2.94668581e-02f, -1.59739539e-01f,
  -1.18974885e-02f, -3.00898012e-02f, -1.33869976e-01f, 7.06949010e-02f, -1.10578746e-01f, 4.59496900e-02f, 1.38348892e-01f, 1.07903801e-01f, 3.70786078e-02f, -4.57197130e-02f,
  -1.40138254e-01f, 8.61600414e-02f, -5.69703709e-03f, 9.16863754e-02f, -1.55126408e-01f, 3.16884257e-02f, 1.90188792e-02f, 6.58644512e-02f, 1.60507604e-01f, 5.51722459e-02f,
  -1.07072163e-02f, 5.46737481e-03f, -1.25398338e-01f, -3.00101750e-02f, -2.36404598e-01f, 2.63629228e-01f, 6.81385696e-02f, 1.62454695e-02f, -1.75703675e-01f, 1.12376558e-02f,
  1.76736340e-01f, -3.74407601e-03f, 1.16131894e-01f, 1.09239712e-01f, -5.74243777e-02f, -1.72466710e-01f, 1.20326526e-01f, 5.49954474e-02f, -5.22704870e-02f, 5.70339989e-03f,
  -3.24287973e-02f, 6.92923367e-02f, -9.76122022e-02f, 2.70780455e-02f, -9.00771841e-02f, 1.96393371e-01f, -1.12852186e-01f, 3.70824859e-02f, -1.21015608e-01f, 4.92206737e-02f,
  -1.39702976e-01f, 6.41124174e-02f, 3.50198932e-02f, 2.18504332e-02f, -6.79616034e-02f, 1.06101260e-01f, -8.28913078e-02f, -5.12285670e-03f, -1.59512371e-01f, 2.20398054e-01f,
  -1.14549950e-01f, 1.01163700e-01f, 4.54060175e-02f, 8.32918361e-02f, -3.24843191e-02f, -7.14355111e-02f, 9.09994766e-02f, -1.04691334e-01f, 7.56049529e-02f, 7.56627396e-02f,
  -1.27793819e-01f, 1.31907940e-01f, -9.65846404e-02f, -4.76454273e-02f, 8.83865133e-02f, -2.00203583e-02f, -9.15980712e-02f, -3.44242081e-02f, -1.04657479e-01f, -1.67276815e-01f,
  -1.26765847e-01f, -1.46804480e-02f, 9.09766927e-02f, -5.88487983e-02f, -1.25347733e-01f, -1.91198409e-01f, 1.23957068e-01f, 1.17923647e-01f, -2.89340049e-01f, 3.40558112e-01f,
  -2.58913003e-02f, -1.05464332e-01f, 5.54677509e-02f, 1.04474723e-02f, 2.09298566e-01f, 1.30571015e-02f, -1.05982229e-01f, 1.78008270e-03f, -1.10720601e-02f, 1.44594461e-01f,
  -1.09802835e-01f, 1.70334339e-01f, 1.17841236e-01f, -3.82118486e-02f, 8.37267116e-02f, 9.23113823e-02f, 6.97216615e-02f, 6.15864508e-02f, 9.25092995e-02f, -3.74404527e-02f,
  -6.02025492e-03f, 3.02953124e-02f, -5.99110909e-02f, -5.03971092e-02f, -1.33587748e-01f, 3.69993933e-02f, -1.15334406e-01f, 8.34565312e-02f, -3.15730497e-02f, 2.30019051e-03f,
  -8.96935314e-02f, 3.11655235e-02f, -2.21528843e-01f, 1.26175299e-01f, -8.68672952e-02f, -3.64972241e-02f, 1.62429586e-01f, 9.71241966e-02f, -9.30011123e-02f, 1.00797884e-01f,
  1.71522841e-01f, -1.62690866e-03f, -2.19686376e-03f, -7.07074702e-02f, -1.19769620e-02f, 4.48444895e-02f, 1.07591808e-01f, -6.59930110e-02f, 1.24020185e-02f, -9.26600099e-02f,
  1.51858348e-02f, 1.26335040e-01f, 1.30630612e-01f, 2.45909631e-01f, -3.90696041e-02f, 1.43504918e-01f, -4.13654074e-02f, 2.06544846e-02f, -4.42609452e-02f, -2.60943830e-01f,
  2.01950043e-01f, -3.30854028e-01f, 1.31082907e-01f, -7.84474611e-02f, -1.11815915e-01f, -6.42128140e-02f, -1.65934354e-01f, 8.79227668e-02f, -3.38276811e-02f, 3.12706754e-02f,
  9.37549472e-02f, -1.64992351e-03f, -1.81053281e-01f, -6.07785769e-02f, 3.24736461e-02f, -1.45742847e-02f, 1.24996789e-02f, -1.34953380e-01f, -4.99704368e-02f, 9.23213437e-02f,
  3.90744470e-02f, 7.76398033e-02f, -3.37683558e-02f, 1.06997892e-01f, -1.24304928e-01f, 8.36237147e-02f, 1.32987887e-01f, 1.01234183e-01f, -4.40618619e-02f, -2.16460839e-01f,
  1.34023979e-01f, 2.63330098e-02f, -2.13318482e-01f, 1.31617039e-01f, 1.04667827e-01f, 1.43876106e-01f, 2.23246172e-01f, 4.03180942e-02f, -3.46315615e-02f, 3.22246663e-02f,
  -4.17181142e-02f, 1.72411874e-01f, 9.13098752e-02f, 7.34896138e-02f, 2.53908220e-03f, 1.00180477e-01f, -4.94885333e-02f, 2.16307685e-01f, -1.21610492e-01f, -7.90061615e-03f,
  -1.31852716e-01f, 1.60039842e-01f, -7.32299760e-02f, 1.06881990e-03f, 1.36619180e-01f, -6.30940869e-02f, 5.40485904e-02f, 1.17761284e-01f, 6.42142445e-02f, 5.00083305e-02f,
  -3.23982649e-02f, 9.92883444e-02f, -1.58280388e-01f, -3.26831281e-01f, 1.75109789e-01f, -2.00329393e-01f, -4.41430323e-02f, -4.36686948e-02f, 1.17380738e-01f, 2.94949859e-02f,
  -9.43769813e-02f, 1.47409737e-01f, 7.77268261e-02f, -4.93712649e-02f, 1.01906165e-01f, 1.44911958e-02f, -1.14162818e-01f, -1.33410737e-01f, -3.37844454e-02f, -1.02187246e-01f,
  -5.82657158e-02f, -7.67410696e-02f, -1.19070247e-01f, 1.06518030e-01f, -1.19436577e-01f, -6.57107122e-03f, -6.37983065e-03f, 1.54137835e-01f, -7.97607899e-02f, -3.49970274e-02f,
  -2.19867378e-02f, 9.44090560e-02f, -3.79760340e-02f, 2.77895876e-03f, 1.07454039e-01f, -1.02526918e-02f, -1.58094671e-02f, 5.89354374e-02f, 1.06461331e-01f, 5.28296940e-02f,
  9.40579176e-02f, 1.37331381e-01f, 9.30853114e-02f, -2.70478837e-02f, -1.52296439e-01f, 7.26380572e-02f, 1.90281197e-01f, 1.38069957e-01f, -9.77902040e-02f, 1.12033831e-02f,
  -1.20198093e-02f, 2.58679301e-01f, -8.20427984e-02f, -7.60969818e-02f, 3.30573544e-02f, 5.24025336e-02f, -1.33257568e-01f, -5.73941134e-02f, 6.40665814e-02f, -1.45434052e-01f,
  1.34114757e-01f, 2.00044028e-02f, 7.30797127e-02f, -1.44980671e-02f, -1.05600223e-01f, -4.65117916e-02f, -1.74903750e-01f, -2.09481776e-01f, 1.72644362e-01f, 1.24810889e-01f,
  8.25280771e-02f, -1.63885042e-01f, -1.08729303e-01f, 8.40294436e-02f, 1.28820976e-02f, -6.86919019e-02f, -8.51855949e-02f, 1.22390032e-01f, -7.78215975e-02f, 6.41220063e-02f,
  -9.94453058e-02f, -1.69566765e-01f, -4.05694209e-02f, 9.21785161e-02f, -1.35064781e-01f, 7.12504536e-02f, 1.47470176e-01f, 1.06646687e-01f, 2.33707875e-02f, 1.15798041e-01f,
  1.30596399e-01f, 3.32386307e-02f, 9.85490978e-02f, -1.08401256e-03f, -1.23234533e-01f, -9.97792631e-02f, -8.35282579e-02f, 3.00264865e-01f, 1.05705038e-01f, 1.54032886e-01f,
  2.42389128e-01f, -4.11495082e-02f, 8.36643055e-02f, -9.10656974e-02f, -2.57134833e-03f, -1.58397987e-01f, 8.27345997e-02f, 5.36371209e-02f, 6.96736351e-02f, -5.22188134e-02f,
  8.28362629e-02f, 1.26536086e-01f, -1.78143233e-01f, -4.42338698e-02f, -1.64955929e-01f, 1.31843463e-01f, 4.30018008e-02f, -4.96128835e-02f, 2.45798323e-02f, -5.63925542e-02f,
  -7.02841505e-02f, 3.77652980e-02f, 5.97432107e-02f, 8.95838998e-03f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -3.82261984e-02f, -1.20096095e-01f, 1.48164798e-02f, -7.85581842e-02f, 1.00325316e-01f, -1.34432703e-01f, 1.58864055e-02f, 9.89128873e-02f, 1.22094348e-01f, 7.02242330e-02f,
  -5.78770600e-02f, 7.27198720e-02f, 2.83708964e-02f, -1.22786410e-01f, -5.52658411e-03f, 6.64335042e-02f, 9.07455683e-02f, -3.66719291e-02f, 1.01652071e-01f, 9.69162285e-02f,
  5.41972741e-02f, -2.86388658e-02f, -7.23689795e-02f, -2.22134702e-02f, 1.08787656e-01f, -2.50515547e-02f, -7.77280852e-02f, 1.90247297e-02f, 1.99590288e-02f, -8.97765011e-02f,
  -3.15115857e-03f, -1.17054984e-01f, -6.55346215e-02f, -7.51379654e-02f, 5.02027459e-02f, 2.21317797e-03f, 9.93895382e-02f, 3.20545561e-03f, 1.97501965e-02f, -1.05673023e-01f,
  1.81225277e-02f, 1.17064044e-01f, 2.39467416e-02f, 2.39877701e-02f, 4.11423109e-02f, -6.21044002e-02f, 7.76915923e-02f, -1.13031350e-01f, -4.90095615e-02f, -1.13385335e-01f,
  -5.79850897e-02f, -6.69333562e-02f, -1.13788992e-01f, 9.27277431e-02f, 5.49667664e-02f, -4.29481119e-02f, 1.19110979e-01f, -3.77323255e-02f, 5.18217459e-02f, -1.20369280e-02f,
  -1.00597538e-01f, -3.14239301e-02f, -6.84768483e-02f, 6.03469610e-02f, 2.76493996e-01f, 1.88837051e-01f, 2.10821971e-01f, 1.32108554e-01f, 1.89782962e-01f, 1.35268256e-01f,
  -2.11393833e-01f, -2.72077173e-01f, 1.32703051e-01f, -1.47489309e-01f, 3.63321483e-01f, -2.95969635e-01f, -3.43068093e-02f, -1.12184018e-01f, 7.30935708e-02f, -8.74913111e-03f,
  -1.75945126e-02f, 2.23317280e-01f, 7.23599177e-03f, -1.26734018e-01f, 3.41927297e-02f, 2.40740273e-02f, 1.37360498e-01f, 1.27051808e-02f, -7.81561341e-03f, -1.95901379e-01f,
  -1.31186351e-01f, -8.84786397e-02f, 1.90292627e-01f, 2.93777883e-01f, 1.78444132e-01f, -2.25313138e-02f, -1.84115186e-01f, 2.22247876e-02f, 8.37518871e-02f, 1.58644747e-03f,
  1.11320078e-01f, 1.04273684e-01f, 6.34129867e-02f, 2.03018963e-01f, -1.25171319e-01f, 1.97454289e-01f, 5.91825396e-02f, 1.15775436e-01f, 3.21116209e-01f, -1.03542544e-01f,
  1.87285598e-02f, -8.52343366e-02f, -1.39939770e-01f, -4.33546081e-02f, 1.35731161e-01f, 1.45165280e-01f, -1.73024744e-01f, 1.00368090e-01f, -1.32521302e-01f, 3.02388281e-01f,
  -1.78829804e-02f, 2.03302316e-02f, -5.66577986e-02f, -3.04965414e-02f, -1.84561759e-02f, -6.15230575e-02f, 1.70155585e-01f, 6.85828030e-02f, -6.06055632e-02f, -5.74393645e-02f,
  -2.85180472e-02f, -9.03665870e-02f, 2.16761846e-02f, -2.47193947e-02f, 6.87480792e-02f, 1.14026248e-01f, 8.05875137e-02f, 2.03753728e-02f, 1.46025335e-02f, 9.95405950e-03f,
  9.18550882e-03f, -1.95565354e-03f, -8.53185654e-02f, -5.12650870e-02f, -1.02241769e-01f, 1.38783688e-02f, -9.85514820e-02f, 1.13009125e-01f, 3.29850987e-02f, -6.98662773e-02f,
  9.41078663e-02f, 4.22827266e-02f, 7.02949148e-03f, 2.44724769e-02f, 5.67682721e-02f, -7.84341171e-02f, 1.11013874e-02f, 4.18893471e-02f, 4.55932952e-02f, -5.17114531e-03f,
  -9.26584762e-04f, 4.98178825e-02f, 1.42105147e-02f, 7.88320303e-02f, -7.61059253e-03f, 6.19659722e-02f, 3.52937952e-02f, -6.05462007e-02f, -7.15231523e-02f, -1.36448786e-01f,
  -1.24938190e-01f, -7.39870816e-02f, -1.42406836e-01f, 1.40614390e-01f, -2.96632405e-02f, -2.11084038e-02f, -2.38403119e-02f, -3.68255675e-02f, 8.13862160e-02f, -6.08481020e-02f,
  6.02900758e-02f, 1.02357462e-01f, 1.36970818e-01f, -2.35306807e-02f, 7.65588060e-02f, 2.94497050e-02f, 2.66686492e-02f, 2.14317385e-02f, 1.07301787e-01f, 2.42717918e-02f,
  -5.79965226e-02f, 1.32214144e-01f, 1.55360047e-02f, -1.01472892e-01f, 9.66446772e-02f, -4.28910032e-02f, 4.97598797e-02f, -6.96148053e-02f, -6.48205951e-02f, 3.41256186e-02f,
  7.13447705e-02f, 1.13359597e-02f, -1.16671987e-01f, -1.22739218e-01f, -1.82756875e-02f, -8.89491439e-02f, 5.21569066e-02f, 4.04688455e-02f, 9.22560915e-02f, -3.63022946e-02f,
  -6.07548282e-02f, -1.76568236e-02f, -9.71540287e-02f, 4.40354384e-02f, -6.41953782e-04f, -6.85026720e-02f, -1.22047827e-01f, -2.87173726e-02f, -6.34482428e-02f, -5.40035181e-02f,
  -5.63294999e-02f, -1.17154950e-02f, -8.48404989e-02f, 9.95303765e-02f, -7.40971882e-03f, -8.76461342e-02f, 1.15045205e-01f, -7.75269344e-02f, 5.44201536e-03f, -6.04106747e-02f,
  -6.64714500e-02f, -7.99341425e-02f, -4.64545786e-02f, -1.66287050e-02f, 1.30857024e-02f, 3.85356285e-02f, 1.27733320e-01f, 9.29117873e-02f, -8.69236067e-02f, -6.49498925e-02f,
  -2.34627817e-02f, -1.35996575e-02f, -1.52403703e-02f, -1.11938477e-01f, 6.52353615e-02f, 6.43528923e-02f, 1.97212137e-02f, -8.86705145e-02f, -1.25863597e-01f, -3.51198725e-02f,
  1.08176293e-02f, -8.34907442e-02f, 1.29665554e-01f, 9.14393067e-02f, 4.20951247e-02f, 8.78333822e-02f, 2.38979775e-02f, 1.30020887e-01f, 9.26968381e-02f, 1.74888119e-01f,
  1.75223704e-02f, 2.89717838e-02f, -2.38438889e-01f, -1.68862462e-01f, 2.01077297e-01f, 6.48463741e-02f, -1.25271440e-01f, 1.47857592e-01f, 3.19383144e-02f, -1.53462619e-01f,
  2.22363789e-02f, 9.51207727e-02f, 9.60409269e-02f, 1.31193638e-01f, -7.35479454e-03f, -9.98034179e-02f, -5.40621914e-02f, 8.26762319e-02f, 1.37014821e-01f, -5.40973432e-02f,
  5.86042143e-02f, 3.57639305e-02f, 3.13224681e-02f, 1.07606836e-01f, -1.19989254e-01f, 4.69176285e-02f, 1.64744422e-01f, -2.01537628e-02f, -1.24186650e-01f, 1.04828507e-01f,
  -1.96108948e-02f, -8.21581706e-02f, -1.03840545e-01f, -7.85596147e-02f, 1.18628502e-01f, 2.23455250e-01f, 1.27864461e-02f, -8.86862203e-02f, -1.03007875e-01f, -5.81162311e-02f,
  6.47561550e-02f, -9.25160721e-02f, 3.65519971e-02f, 8.11401457e-02f, -1.10135183e-01f, 4.55177017e-02f, -7.37039298e-02f, 1.28008518e-02f, -3.11622396e-02f, 6.92998469e-02f,
  3.68626826e-02f, 1.48847595e-01f, -1.02170706e-01f, -8.90804678e-02f, -5.10623492e-02f, 1.31463081e-01f, 5.46659566e-02f, -1.08985439e-01f, 9.09124035e-03f, 1.06713064e-01f,
  -2.28395741e-02f, -1.24010127e-02f, -9.65936184e-02f, 5.15967570e-02f, 6.58359602e-02f, -5.02932779e-02f, 5.57252616e-02f, 1.96077555e-01f, -7.77087063e-02f, -3.20889205e-02f,
  -1.20932236e-01f, 8.76907408e-02f, -8.14597011e-02f, 5.63727394e-02f, -3.63998897e-02f, -1.48079172e-02f, -1.09006632e-02f, -5.30205891e-02f, -2.80073285e-02f, 3.95875275e-02f,
  6.91719577e-02f, -2.62878705e-02f, -6.04859330e-02f, -1.25896156e-01f, -2.23934706e-02f, 1.23877890e-01f, 4.20628153e-02f, -5.28409742e-02f, -1.22966200e-01f, -9.65402797e-02f,
  -1.29349351e-01f, -4.85603102e-02f, -4.98624034e-02f, -2.75842175e-02f, 4.85668704e-02f, 1.15152054e-01f, 1.13382518e-01f, -1.12282410e-01f, 8.49600788e-03f, -9.45404917e-02f,
  1.82689272e-03f, 9.23398584e-02f, -4.38546436e-03f, -6.95951059e-02f, -5.87977702e-03f, 1.52879193e-01f, 4.92556207e-02f, -3.62595879e-02f, -1.03773497e-01f, 1.02376774e-01f,
  -3.22226807e-02f, 6.51621222e-02f, 1.27718136e-01f, 6.29739687e-02f, -6.41464442e-02f, -6.70193415e-03f, -1.16810732e-01f, -4.09210101e-02f, -6.93347529e-02f, -5.94437346e-02f,
  6.65586814e-02f, -5.70655540e-02f, -2.44058389e-02f, 1.52322501e-02f, 1.24017633e-01f, -9.31935757e-02f, -1.01651073e-01f, 1.14717223e-01f, 6.42531365e-02f, -5.15090600e-02f,
  1.42130271e-01f, -6.07570186e-02f, -1.53022734e-02f, -7.35727474e-02f, 1.46864340e-01f, -9.60983709e-02f, 1.24083914e-01f, -1.03519626e-01f, -3.53286676e-02f, 3.37638743e-02f,
  -5.81065528e-02f, 6.48497865e-02f, -4.09968682e-02f, 1.04317725e-01f, 6.75413087e-02f, 3.11508644e-02f, 2.51276679e-02f, -1.44395396e-01f, 6.47685826e-02f, 1.18124403e-01f,
  -1.35711119e-01f, -1.23546325e-01f, -8.18181783e-02f, -6.05971031e-02f, -8.58212411e-02f, -3.15225311e-02f, 5.11711091e-03f, -1.72930621e-02f, -7.22874934e-03f, 6.56038746e-02f,
  8.58782604e-02f, 7.31971767e-03f, 7.59554207e-02f, 6.90869093e-02f, -3.21386307e-02f, -8.43974203e-02f, -7.95085877e-02f, 1.41492290e-02f, 1.10738933e-01f, 5.64470850e-02f,
  -1.08982204e-02f, -1.26208812e-01f, -9.25102755e-02f, -1.88320912e-02f, 1.55336484e-01f, 1.69808529e-02f, -7.92259052e-02f, -8.45119134e-02f, -3.24269123e-02f, -9.75167304e-02f,
  -8.25233534e-02f, 5.30234091e-02f, -5.05560935e-02f, -1.05717316e-01f, -5.15026264e-02f, -1.12964258e-01f, -1.22420363e-01f, -7.13338330e-02f, 4.15675119e-02f, -1.67948715e-02f,
  -4.39229421e-03f, 1.09991636e-02f, 3.96426618e-02f, 3.73740308e-02f, -1.50180864e-03f, 1.91654503e-01f, -2.90213730e-02f, -4.09395732e-02f, -2.49310229e-02f, 1.51142955e-01f,
  -7.75828511e-02f, -7.51403421e-02f, -5.88951409e-02f, -1.18641160e-01f, 1.18387520e-01f, -6.24529682e-02f, -3.81607786e-02f, 9.78685468e-02f, 2.36025825e-02f, 6.03745431e-02f,
  -6.88181743e-02f, -9.42921638e-02f, -4.31281514e-02f, -1.24174841e-02f, -4.62797238e-03f, -2.15015188e-02f, 1.66061502e-02f, 2.72184703e-03f, -1.00985654e-01f, -3.48479189e-02f,
  -5.35208993e-02f, -6.27837852e-02f, 1.15136363e-01f, -8.68675932e-02f, 5.89268208e-02f, 1.35920700e-02f, 2.45922897e-02f, -1.36847779e-01f, -9.43647325e-02f, -8.68197456e-02f,
  1.12324916e-01f, -1.20728135e-01f, -5.17459102e-02f, -7.04918057e-02f, -1.09335907e-01f, 1.41796306e-01f, -4.15143892e-02f, -2.15883777e-02f, 6.39605969e-02f, -1.13781601e-01f,
  -4.30228189e-02f, -7.10137486e-02f, -7.86414742e-02f, -1.48457512e-01f, 3.11310347e-02f, 6.48429394e-02f, -1.39472242e-02f, -1.01030907e-02f, 1.46393245e-02f, 1.23996794e-01f,
  -3.07962149e-02f, 3.48793566e-02f, -1.18840383e-02f, -3.80291720e-03f, -2.49758828e-02f, -6.16102256e-02f, 2.65799370e-02f, -1.61103979e-01f, 6.94184825e-02f, 5.19873612e-02f,
  9.96228978e-02f, -1.08308531e-02f, -1.39267510e-02f, -7.43641891e-03f, 1.20366968e-01f, 1.18761778e-01f, 1.33115381e-01f, -1.25567108e-01f, 1.22591496e-01f, -3.39285918e-02f,
  -6.32832870e-02f, 6.47258684e-02f, -1.84348747e-02f, 1.55238494e-01f, -1.32087260e-01f, -2.58451141e-02f, 2.59351302e-02f, 1.55035466e-01f, 1.76710989e-02f, 4.42385813e-03f,
  8.49855468e-02f, 9.02166590e-02f, 6.71966420e-03f, -1.25383407e-01f, 2.81536505e-02f, 8.74147564e-02f, 1.00196004e-01f, -1.30116075e-01f, -9.74808559e-02f, 9.25991535e-02f,
  -1.12545170e-01f, 1.60754591e-01f, 7.42540583e-02f, 1.14732338e-02f, -1.18898936e-01f, 2.00627632e-02f, -1.74938310e-02f, 9.83209312e-02f, -8.27058703e-02f, 1.03200503e-01f,
  2.08375350e-01f, 1.05464950e-01f, -1.04316019e-01f, 2.07531247e-02f, 1.50579229e-01f, 1.12958014e-01f, -8.88862759e-02f, -8.56362432e-02f, 1.25191912e-01f, 1.41403237e-02f,
  9.49255154e-02f, 1.07321188e-01f, 4.09859046e-02f, -5.95073663e-02f, 1.12435194e-02f, -8.13640356e-02f, 9.00213718e-02f, -3.82322967e-02f, -8.82354006e-02f, 4.23184708e-02f,
  9.02244598e-02f, 7.50263315e-03f, -1.01635888e-01f, -9.52372476e-02f, -1.03257857e-01f, -4.88196798e-02f, -1.25787124e-01f, 1.06413960e-01f, -6.76685274e-02f, 5.72546497e-02f,
  -1.20401897e-01f, -8.45454400e-04f, 1.48172257e-04f, 4.55475189e-02f, -6.74884096e-02f, 1.06363436e-02f, -7.07850466e-03f, 4.12353128e-02f, -8.49928930e-02f, 8.30799714e-02f,
  1.03989244e-01f, -5.09461649e-02f, 3.49634737e-02f, 1.39357569e-02f, -1.39432922e-01f, 7.97409192e-03f, 8.67114887e-02f, 2.86357477e-02f, 1.24316551e-02f, 2.69850958e-02f,
  -5.56447469e-02f, 1.11439824e-01f, -3.37372459e-02f, 2.31085587e-02f, 8.56840312e-02f, -1.12922221e-01f, 4.76919040e-02f, 6.68702349e-02f, -2.80546043e-02f, -8.40690434e-02f,
  -7.19939843e-02f, 1.79378018e-01f, 2.87211761e-02f, -5.99826984e-02f, 1.46424863e-02f, 1.02302186e-01f, -8.14166106e-03f, -3.22550349e-02f, -3.06140371e-02f, 7.70903230e-02f,
  3.23234452e-03f, 6.04016483e-02f, -4.02732380e-02f, -7.51896724e-02f, 3.34449299e-02f, 8.83627757e-02f, 1.20253853e-01f, -9.45288390e-02f, -6.52298778e-02f, 2.26137694e-02f,
  2.99618840e-01f, 2.67180473e-01f, 4.74318504e-01f, 3.55002433e-01f, 3.26757044e-01f, 3.68311286e-01f, 4.02841300e-01f, 5.28180242e-01f, -2.55505443e-02f, -1.45585522e-01f,
  -1.58809587e-01f, 3.25671405e-01f, 2.60672778e-01f, 2.01678082e-01f, -8.12906474e-02f, 1.00329975e-02f, 1.85190335e-01f, -1.36258245e-01f, -2.07565248e-01f, -1.15915410e-01f,
  1.08130366e-01f, 2.75142103e-01f, -8.66593514e-03f, 1.11019351e-01f, 7.96334445e-02f, 2.71428853e-01f, -6.34100437e-02f, -1.96141779e-01f, -7.93414041e-02f, 1.11714900e-01f,
  -1.53032973e-01f, -3.71330567e-02f, -1.34708881e-01f, -7.76015893e-02f, 6.85697570e-02f, 1.58360153e-02f, -1.25197470e-01f, -2.11001337e-01f, -1.07745118e-02f, -1.52772978e-01f,
  -1.47314966e-01f, -1.90763593e-01f, 8.28893110e-02f, 5.13796397e-02f, -7.80077577e-02f, 5.37698150e-01f, 7.39872903e-02f, 7.42290020e-02f, 2.11254165e-01f, 2.48709202e-01f,
  7.99618475e-03f, -2.06660330e-02f, 2.80036807e-01f, -7.23807216e-02f, 2.18239278e-01f, -1.35172471e-01f, -8.98383856e-02f, 2.23737285e-01f, 1.87025294e-01f, -7.07832277e-02f,
  4.73259330e-01f, -1.20977767e-01f, -7.64730275e-02f, -8.27262923e-02f, 5.78240380e-02f, -1.09340832e-01f, -7.46463090e-02f, -5.38053289e-02f, -5.33367097e-02f, 2.52158735e-02f,
  6.19632043e-02f, -6.59696087e-02f, -6.21852912e-02f, 1.19063705e-01f, 8.13391656e-02f, 3.11482185e-03f, 8.59144852e-02f, 1.29431814e-01f, 1.01450637e-01f, -8.50785151e-02f,
  -5.57046570e-02f, -9.30392891e-02f, -5.20495288e-02f, 1.15910761e-01f, 4.61263098e-02f, 1.91760305e-02f, -3.88881899e-02f, 7.10096210e-02f, -3.13606076e-02f, 1.07701391e-01f,
  1.09402046e-01f, -1.31047204e-01f, -3.13113220e-02f, -3.71346250e-02f, -6.97984323e-02f, -7.80084208e-02f, -4.23403941e-02f, 8.87998119e-02f, 7.74302930e-02f, 8.92411247e-02f,
  -2.01634429e-02f, -1.11447573e-01f, -4.67340425e-02f, -1.48245662e-01f, -2.25153789e-02f, -6.71110377e-02f, 1.08295754e-01f, -4.30671871e-02f, 5.61384782e-02f, 1.28678381e-01f,
  -8.58190060e-02f, 6.69813827e-02f, -1.11786395e-01f, 7.63490424e-02f, 1.95183549e-02f, 2.23542075e-03f, 1.49044394e-02f, -1.05790079e-01f, -9.02617201e-02f, 2.97534149e-02f,
  8.41095075e-02f, 5.58614284e-02f, 1.13434710e-01f, 9.68968123e-02f, -3.90421525e-02f, -1.17224880e-01f, -6.37978390e-02f, 8.12274516e-02f, 7.11863115e-02f, 9.30687413e-02f,
  3.72258462e-02f, 8.01749155e-02f, 1.05461501e-01f, 5.15320636e-02f, 2.76790708e-01f, 2.06520095e-01f, -2.70545393e-01f, 6.72252178e-02f, 4.76923324e-02f, -3.02115649e-01f,
  8.94235373e-02f, 3.28487298e-03f, 1.42287649e-02f, -8.17849487e-02f, -7.08398595e-02f, 2.21809626e-01f, 2.58409362e-02f, 1.16591360e-02f, 2.46817708e-01f, 9.68520865e-02f,
  -1.13031864e-01f, -8.72058719e-02f, -2.21069809e-02f, 8.26866105e-02f, 4.76655290e-02f, -1.28540769e-01f, 1.19885467e-01f, 1.28131226e-01f, -1.15752919e-02f, 1.74757913e-02f,
  1.23235628e-01f, 8.07640329e-02f, 1.24661610e-01f, -2.99310610e-02f, -1.12499923e-01f, 1.63511753e-01f, 1.15623720e-01f, 9.88998339e-02f, -1.11488793e-02f, 9.73883271e-03f,
  -2.94604823e-02f, -1.10206850e-01f, -5.86095415e-02f, -8.35943818e-02f, -2.09310595e-02f, -3.36171649e-02f, 4.58979905e-02f, -1.44639671e-01f, 1.55609697e-01f, 5.80691546e-02f,
  1.43859863e-01f, -2.35240646e-02f, 3.65762925e-03f, -5.89583218e-02f, -6.21584952e-02f, -1.08680241e-01f, 6.65586144e-02f, -1.35633066e-01f, 1.74796388e-01f, -4.38852571e-02f,
  -1.55751139e-01f, 1.05225155e-02f, -8.62958208e-02f, -1.07965156e-01f, 2.17122564e-04f, 4.65015061e-02f, 5.75459190e-02f, -1.17970526e-01f, 7.26175085e-02f, 6.94697276e-02f,
  -1.53706387e-01f, 1.36855856e-01f, -9.40083936e-02f, -1.29890427e-01f, 4.95382212e-02f, 1.23237625e-01f, -2.13483945e-02f, 7.19766095e-02f, -5.47536202e-02f, -8.06985497e-02f,
  5.07397354e-02f, 1.22367926e-01f, 5.85346445e-02f, 1.72153637e-01f, -5.76518215e-02f, -9.55813602e-02f, 3.24156061e-02f, 7.81467482e-02f, 2.49926876e-02f, -1.18019179e-01f,
  1.41418546e-01f, -1.12143666e-01f, -1.92953385e-02f, -6.88903704e-02f, 1.42250746e-01f, -9.57435295e-02f, -5.02994657e-02f, -1.09462410e-01f, -9.01700854e-02f, 1.52261391e-01f,
  -5.71774542e-02f, 5.77818565e-02f, 1.27627626e-01f, 1.20201796e-01f, -3.97500694e-02f, 1.32179540e-02f, -7.89372027e-02f, 4.42020828e-03f, 6.46912083e-02f, -2.78557111e-02f,
  1.82107389e-01f, -6.11333214e-02f, -3.26528884e-02f, -6.78193718e-02f, 2.71187387e-02f, 8.91654491e-02f, 1.16514564e-01f, -4.37391996e-02f, 1.28774820e-02f, 1.35993836e-02f,
  -8.22157934e-02f, -1.30887538e-01f, 1.83627799e-01f, -4.14264807e-03f, -1.05599657e-01f, 9.78089869e-02f, 8.05238858e-02f, -6.71953186e-02f, 7.39303157e-02f, -3.56236771e-02f,
  8.40486661e-02f, 3.10939886e-02f, 2.40082279e-01f, 2.47635320e-01f, 5.74499443e-02f, 1.29247559e-02f, 3.56679130e-03f, -5.88712692e-02f, 4.13473025e-02f, 9.30855125e-02f,
  1.10688724e-01f, 1.21297603e-02f, 7.06510916e-02f, 9.78512317e-02f, -1.14765950e-03f, 6.02042377e-02f, 1.49975315e-01f, 1.09591365e-01f, -4.01281603e-02f, -3.74160856e-02f,
  -8.99106413e-02f, 1.63002953e-01f, 2.08422821e-02f, -9.66451764e-02f, 1.49520323e-01f, -3.87230776e-02f, -9.26245749e-02f, -1.00653484e-01f, 9.64234248e-02f, -1.13630541e-01f,
  -3.96064259e-02f, 1.27269074e-01f, 1.17645949e-01f, -7.67867863e-02f, -2.75117885e-02f, 4.92849527e-03f, -6.97404053e-03f, -6.13525957e-02f, 1.11491747e-01f, -1.46039680e-01f,
  5.39614782e-02f, 1.66573063e-01f, -2.92646158e-02f, -2.33096574e-02f, -1.03980951e-01f, 1.27785625e-02f, -7.04562068e-02f, -3.51912975e-02f, 9.10481885e-02f, -9.19421092e-02f,
  4.87923510e-02f, -7.59572089e-02f, 5.57706803e-02f, -2.31346935e-02f, -4.73120203e-03f, 9.17963684e-02f, 2.13718161e-01f, 8.21887702e-02f, 7.63108283e-02f, 2.24035624e-02f,
  7.73039237e-02f, 1.61513671e-01f, 1.05523378e-01f, 7.85215348e-02f, 1.35074303e-01f, 1.09847523e-01f, 3.51733416e-01f, 2.55043894e-01f, -3.28770936e-01f, -3.58712636e-02f,
  3.19876462e-01f, -3.74867529e-01f, 6.82549626e-02f, -2.93693808e-03f, 1.67414561e-01f, 9.79631245e-02f, -1.95782915e-01f, 2.86976993e-01f, -1.23541728e-01f, 1.60436228e-01f,
  1.02309063e-01f, 2.44113997e-01f, -1.86323691e-02f, -4.44618948e-02f, -2.60198005e-02f, 1.32446170e-01f, -1.05581842e-01f, 9.94221121e-02f, 2.55100697e-01f, 7.33082518e-02f,
  -5.36766835e-02f, -5.36211506e-02f, 7.16153309e-02f, 1.12004310e-01f, -1.65481512e-02f, 7.16976449e-02f, 1.11845694e-01f, 1.20137334e-01f, 5.03034890e-02f, -1.15992804e-03f,
  1.75285146e-01f, 4.83792908e-02f, 2.67766595e-01f, 2.82234196e-02f, 1.89021662e-01f, 3.50438021e-02f, -8.27224851e-02f, 7.47599304e-02f, 1.72240019e-01f, -1.46233618e-01f,
  1.54733241e-01f, 1.19357042e-01f, -6.69737607e-02f, 5.99220693e-02f, -5.90488464e-02f, -1.30103871e-01f, 7.25748390e-02f, 7.25080259e-03f, -1.92889757e-02f, -2.55312771e-02f,
  9.45215449e-02f, -1.17966056e-01f, -4.14080285e-02f, -3.08962185e-02f, -7.74394348e-02f, 4.95257303e-02f, -5.46148047e-02f, -1.51008386e-02f, -2.20736545e-02f, 5.62119558e-02f,
  8.14131349e-02f, 1.06226422e-01f, 6.39896002e-03f, -2.79341936e-02f, -5.16814776e-02f, 2.50859950e-02f, 2.94781085e-02f, -9.50007513e-02f, -9.95133594e-02f, -9.38196555e-02f,
  1.48612168e-02f, 3.82517576e-02f, -3.65881883e-02f, -1.01923935e-01f, 1.57285407e-02f, -1.03484325e-01f, -3.22730802e-02f, 9.12663713e-02f, -1.09662145e-01f, -5.09995520e-02f,
  6.61887527e-02f, 3.67255136e-02f, -1.17328659e-01f, -9.06010792e-02f, 1.18953735e-01f, -1.12315878e-01f, 5.86243868e-02f, -4.78509776e-02f, 8.23657289e-02f, -1.72436852e-02f,
  -8.84710327e-02f, 6.22740202e-03f, 6.22791387e-02f, -9.14079770e-02f, 1.12524502e-01f, 6.88317269e-02f, 5.28787486e-02f, 6.81640655e-02f, -9.63662099e-03f, 1.38841107e-01f,
  3.12778689e-02f, -4.27794456e-02f, -5.80394920e-03f, -1.10177681e-01f, -8.01894441e-02f, 2.32962091e-02f, -1.41117594e-03f, 1.07848905e-01f, 9.34736524e-03f, 2.18752250e-02f,
  4.24650125e-02f, 2.92977002e-02f, 5.37873954e-02f, -4.14857306e-02f, -1.06508158e-01f, 3.75267901e-02f, -2.63218693e-02f, 1.19775757e-01f, -2.80833337e-02f, 2.38333419e-02f,
  1.71702400e-01f, 2.42649749e-01f, 1.76802516e-01f, 1.68197542e-01f, -3.39125812e-01f, -2.14710757e-01f, 1.32466584e-01f, 1.83296800e-01f, -5.94305582e-02f, 1.53344810e-01f,
  -6.96421252e-04f, -1.53949022e-01f, -8.26802850e-02f, -1.03920393e-01f, 1.25222877e-01f, 1.13992073e-01f, 1.13999650e-01f, -6.86143786e-02f, 3.90840657e-02f, -6.87479377e-02f,
  1.29377529e-01f, 1.95847541e-01f, -3.86960730e-02f, -3.99204493e-02f, 9.19506028e-02f, -6.91220984e-02f, 4.95594740e-02f, 2.16988668e-01f, 1.08641498e-01f, -3.11551616e-02f,
  1.12408381e-02f, -1.05604544e-01f, -2.72620562e-02f, -4.02847305e-02f, -4.74714637e-02f, 1.30362093e-01f, 3.19342278e-02f, 1.98638558e-01f, 2.26829827e-01f, 1.29201591e-01f,
  -1.78218000e-02f, -4.82713431e-02f, -5.42494878e-02f, -1.16261117e-01f, -1.99916940e-02f, -4.71545607e-02f, 4.31361534e-02f, 1.41166076e-01f, -1.20810591e-01f, -3.16354930e-02f,
  -1.23812752e-02f, 3.39640304e-02f, 5.76679669e-02f, 1.57928467e-01f, 1.71461657e-01f, 4.53130491e-02f, 2.07742359e-02f, 2.15860102e-02f, -5.23128286e-02f, -4.53707874e-02f,
  1.26095265e-01f, 4.80812341e-02f, -4.37223203e-02f, -1.93324424e-02f, 8.80579203e-02f, -3.87663171e-02f, 8.94658417e-02f, 9.14745182e-02f, 1.00855529e-01f, -2.36763712e-02f,
  -3.34532862e-03f, 1.26604855e-01f, 8.18976089e-02f, 1.09053552e-01f, 8.76171663e-02f, -5.19736484e-02f, 2.72352695e-02f, 4.00317274e-02f, -6.32057860e-02f, -1.09767757e-01f,
  -9.75516886e-02f, -7.11727664e-02f, -9.26969498e-02f, -9.22909379e-02f, -3.02602239e-02f, 1.11042801e-03f, 6.95507601e-02f, 3.16153876e-02f, 1.67904533e-02f, 9.98122171e-02f,
  -1.65692111e-03f, -1.16357796e-01f, -5.92672266e-02f, -7.25406334e-02f, -3.64925638e-02f, -6.53205663e-02f, -5.58069833e-02f, 7.94112906e-02f, -7.70874992e-02f, 3.76141891e-02f,
  9.82597657e-03f, 1.04029804e-01f, -1.55142054e-03f, -3.16887125e-02f, -9.27209929e-02f, -1.11977570e-01f, -1.13831885e-01f, 3.45894955e-02f, -1.28559858e-01f, -8.37065056e-02f,
  1.34584859e-01f, -3.31525244e-02f, 5.54656796e-02f, -2.33197752e-02f, 3.77614088e-02f, -7.02640936e-02f, -2.69257044e-03f, 7.16253370e-02f, -5.26486561e-02f, 6.00916110e-02f,
  4.33989149e-03f, -9.13420543e-02f, 5.62841967e-02f, -9.45941359e-02f, -1.24748591e-02f, -1.98712461e-02f, 1.16246119e-01f, 4.71496880e-02f, 1.55307516e-01f, 5.20746522e-02f,
  1.02746464e-01f, 2.48151775e-02f, -2.49097832e-02f, 4.27265950e-02f, 4.34643850e-02f, 6.89642057e-02f, 8.87556970e-02f, 1.48004889e-01f, 1.05236985e-01f, 8.60979855e-02f,
  -7.53806084e-02f, 4.37920280e-02f, 1.61374416e-02f, 3.78334560e-02f, -3.23833600e-02f, 1.18086293e-01f, -1.24720909e-01f, -2.75609293e-03f, -4.89641465e-02f, 1.17676742e-01f,
  3.06751542e-02f, -1.12670355e-01f, -1.93315446e-02f, 6.42960891e-02f, -2.91671399e-02f, 1.10999145e-01f, 1.22826554e-01f, 5.17167337e-03f, 4.33098674e-02f, -8.86176378e-02f,
  -4.01786268e-02f, -1.64353233e-02f, -1.80952046e-02f, 1.34969175e-01f, 1.10445097e-01f, 9.60830674e-02f, 1.05159827e-01f, -7.91314542e-02f, -7.95485303e-02f, -9.17937141e-03f,
  -1.04167663e-01f, -6.44158944e-02f, 2.25090946e-04f, -8.62485617e-02f, 1.35158315e-01f, 6.95324019e-02f, -1.21841274e-01f, 1.42935582e-03f, 4.24725227e-02f, 9.83051136e-02f,
  -5.26031218e-02f, -2.78843306e-02f, -9.26103268e-04f, -4.22064960e-02f, -7.75966719e-02f, -1.53659023e-02f, 1.25275567e-01f, -3.89614142e-02f, -4.61639510e-03f, -1.11251518e-01f,
  6.88745081e-02f, 1.34033144e-01f, 1.59219727e-02f, 9.44898203e-02f, 9.92995203e-02f, 1.37421906e-01f, -1.01317279e-01f, 1.56412676e-01f, 1.11211255e-01f, 3.90115418e-02f,
  1.38090938e-01f, -7.72448108e-02f, 1.74952634e-02f, -1.01485759e-01f, 8.91341269e-03f, 6.45241365e-02f, -2.69942917e-02f, -4.87759560e-02f, 1.21891156e-01f, 8.48445073e-02f,
  -3.53446715e-02f, -6.17313646e-02f, -1.11418463e-01f, -2.94260178e-02f, 1.77036580e-02f, -6.81578815e-02f, -3.07167396e-02f, -7.73886144e-02f, -2.34818161e-02f, 6.63076863e-02f,
  9.69535783e-02f, 2.46653669e-02f, -7.54268542e-02f, -4.33343239e-02f, -1.13891743e-01f, 2.18447298e-03f, -6.27644733e-02f, 5.52482940e-02f, -5.87115735e-02f, 5.43478653e-02f,
  -1.08680971e-01f, 1.27798207e-02f, 3.16876955e-02f, -3.41980606e-02f, 9.64595899e-02f, -1.13009356e-01f, -2.43247338e-02f, 9.97909382e-02f, -6.73178434e-02f, -7.72702768e-02f,
  4.03951630e-02f, 9.67883170e-02f, 8.09426010e-02f, -8.62722751e-03f, 5.50518893e-02f, -1.59072150e-02f, -1.09217644e-01f, 2.56205741e-02f, -2.97192354e-02f, 9.91925970e-02f,
  8.99973214e-02f, 8.40038732e-02f, 1.21171094e-01f, -7.83969909e-02f, -2.93398723e-02f, -7.60157108e-02f, 1.52198672e-01f, 1.31766111e-01f, 1.22016057e-01f, -9.29199830e-02f,
  3.54905762e-02f, -3.67974564e-02f, -1.64247602e-02f, 4.15589847e-02f, 5.41754961e-02f, -2.50239931e-02f, -1.15672432e-01f, -4.98509370e-02f, 5.12721948e-02f, -7.25342408e-02f,
  -8.28307346e-02f, 7.39976242e-02f, 7.56979594e-03f, -1.00486606e-01f, 1.21980719e-01f, 3.94309349e-02f, -1.59077439e-02f, -5.86043783e-02f, -3.95436957e-03f, 1.38496488e-01f,
  1.82873651e-01f, 1.27275154e-01f, -2.39690896e-02f, -1.85999891e-03f, -5.72027788e-02f, 8.54523256e-02f, 1.64330583e-02f, 3.62285860e-02f, 7.29753673e-02f, -1.00976802e-01f,
  8.03025514e-02f, 2.33699784e-01f, -9.82309226e-03f, 1.05685249e-01f, 1.31817222e-01f, -6.69346118e-05f, -5.46134375e-02f, -2.09074430e-02f, 5.19920699e-02f, -5.03812507e-02f,
  5.17252795e-02f, -1.66115575e-02f, 1.76695082e-02f, 2.72404440e-02f, -9.61320698e-02f, -1.12777501e-01f, -8.43336359e-02f, 9.06871855e-02f, -1.01314552e-01f, 2.35351678e-02f,
  7.95596987e-02f, 1.04140388e-02f, -6.60107955e-02f, -1.19773909e-01f, 9.10608992e-02f, 1.74423773e-02f, -1.01224944e-01f, 3.72787751e-02f, 4.72701062e-03f, -6.95839673e-02f,
  1.06505565e-02f, -1.39146507e-01f, -3.47096138e-02f, 5.57103716e-02f, 4.51742597e-02f, -7.39623159e-02f, 3.69659066e-02f, 5.47545366e-02f, 1.07632481e-01f, 3.37180905e-02f,
  -6.96410313e-02f, 1.17461480e-01f, 1.36210574e-02f, -4.16436465e-03f, -3.97202298e-02f, -1.15860395e-01f, 8.46870691e-02f, -1.10518992e-01f, 1.85870789e-02f, -4.46142303e-03f,
  -5.84416687e-02f, 5.16797975e-02f, 6.94665387e-02f, -5.02892211e-02f, 7.42667094e-02f, -1.13701336e-01f, -9.35526118e-02f, -1.08943954e-01f, 1.02118529e-01f, -6.46500438e-02f,
  8.06099325e-02f, 3.82491238e-02f, -3.66252996e-02f, -3.80447805e-02f, 6.32262751e-02f, -4.94679511e-02f, -2.49769017e-02f, -9.65943187e-03f, -1.01975948e-01f, -5.30990735e-02f,
  2.98714228e-02f, 8.47801790e-02f, 1.04896180e-01f, 7.01530501e-02f, -7.23387226e-02f, 1.06355734e-01f, 8.33713785e-02f, -6.72125742e-02f, 1.19145758e-01f, -3.30946073e-02f,
  5.91278151e-02f, -2.99724471e-02f, -3.51852626e-02f, -3.69615331e-02f, -2.17610598e-02f, 4.75135678e-03f, -1.02870753e-02f, -4.82948869e-02f, -6.54604882e-02f, 1.18629523e-01f,
  2.62725782e-02f, -9.03093591e-02f, 8.40145946e-02f, 1.45559579e-01f, 2.50289053e-01f, 2.27858663e-01f, 2.17706174e-01f, 2.34586820e-01f, 3.96212757e-01f, 3.93244267e-01f,
  -8.12988281e-02f, 7.51105044e-03f, 1.05828695e-01f, -1.98114067e-01f, 1.04602203e-01f, 1.40944868e-01f, 1.22027487e-01f, -9.44377482e-03f, 1.03694787e-02f, -2.71182470e-02f,
  -1.83795929e-01f, -3.91581096e-02f, 2.43219629e-01f, 3.13272953e-01f, -1.46490425e-01f, 2.84588728e-02f, 2.97250096e-02f, 7.61510432e-02f, -9.74671617e-02f, 8.00987780e-02f,
  2.04865545e-01f, -4.18788102e-03f, -7.69046471e-02f, 8.41841027e-02f, -1.40840188e-02f, 7.88136944e-02f, -1.80514734e-02f, 4.04308829e-03f, -8.05187598e-02f, 1.73690896e-02f,
  -1.40801027e-01f, -1.23366579e-01f, 1.38171643e-01f, -1.56037629e-01f, 7.46973008e-02f, -2.83342786e-02f, -3.27580161e-02f, 1.76907986e-01f, -9.61384401e-02f, -1.56529471e-02f,
  1.90855026e-01f, 8.66557509e-02f, 1.06130600e-01f, -7.02831000e-02f, 4.90006432e-02f, -5.15692793e-02f, 2.12172270e-02f, -1.60101756e-01f, -3.38584743e-02f, 5.58619946e-02f,
  -8.21374133e-02f, 1.16133131e-02f, 3.35100621e-01f, -6.16272613e-02f, -1.55752406e-01f, 7.33584166e-02f, 8.41365978e-02f, 6.02451786e-02f, 1.37035161e-01f, -5.16980179e-02f,
  -7.14759976e-02f, -3.55681852e-02f, 5.20157032e-02f, 2.00602841e-02f, 8.42100009e-02f, 2.11756816e-03f, 7.89731741e-02f, -1.91807717e-01f, 1.09865800e-01f, 7.81995133e-02f,
  -8.12435970e-02f, 1.30330324e-02f, -4.81089838e-02f, 1.68733627e-01f, 7.78838173e-02f, 1.20038511e-02f, 1.09577693e-01f, -5.86039498e-02f, -2.38518249e-02f, 5.57913706e-02f,
  9.24930722e-02f, -2.71111348e-04f, -1.52583169e-02f, 2.19508782e-02f, 2.24702265e-02f, 4.36277054e-02f, 4.04258743e-02f, 7.44587630e-02f, -2.07130630e-02f, 4.51135673e-02f,
  1.28945515e-01f, 1.08379602e-01f, -3.34513709e-02f, -2.38697417e-02f, 5.42139374e-02f, 1.26944751e-01f, 1.10021032e-01f, 1.04171745e-01f, 1.50603265e-01f, -7.52098784e-02f,
  8.10188353e-02f, -1.09299749e-01f, -6.84947520e-02f, 9.39851627e-02f, -1.07442312e-01f, -3.90251842e-03f, 4.63632867e-02f, -7.55105913e-02f, -1.41916513e-01f, 6.20054780e-03f,
  6.09772652e-02f, -4.88784947e-02f, 3.13223936e-02f, 2.07509790e-02f, -7.89467394e-02f, -1.20068505e-01f, 6.32854402e-02f, 7.48661831e-02f, 1.36731654e-01f, -1.28005058e-01f,
  1.44489750e-01f, 1.47632837e-01f, -1.96155384e-02f, 1.91636637e-01f, -3.06369625e-02f, 4.75200973e-02f, -1.27569214e-01f, -5.36909774e-02f, 1.30810350e-01f, -3.28989178e-02f,
  9.94960293e-02f, -9.66775417e-02f, -5.58413900e-02f, 2.14093421e-02f, -4.73819077e-02f, -6.44275267e-03f, -6.00380674e-02f, -5.93433790e-02f, 7.22920448e-02f, 7.32829273e-02f,
  4.23041619e-02f, -1.27793908e-01f, 4.72953506e-02f, -6.29059002e-02f, 9.38038006e-02f, -7.29076639e-02f, -2.99971402e-02f, -1.28602594e-01f, -1.77989006e-02f, 2.56262589e-02f,
  3.38554829e-02f, 9.70115140e-02f, -1.52386174e-01f, 6.92649335e-02f, 9.34247375e-02f, 6.56340495e-02f, 1.11774869e-01f, -4.94989827e-02f, 1.38818219e-01f, 9.36917365e-02f,
  5.08710518e-02f, -4.39352728e-02f, 1.07170939e-01f, 1.32752866e-01f, 1.21780269e-01f, -2.55070701e-02f, -2.66481116e-02f, -1.19766176e-01f, -1.54608399e-01f, 6.09774925e-02f,
  -4.99870516e-02f, 1.05121709e-01f, 5.73662706e-02f, 1.24735638e-01f, -1.14803106e-01f, 2.11481795e-01f, 7.82242604e-03f, 9.43650007e-02f, 6.65742997e-03f, 1.14949867e-01f,
  -1.15794681e-01f, 2.40892824e-02f, 1.42970741e-01f, 1.04918152e-01f, -6.88060559e-03f, -2.41247136e-02f, 6.08523861e-02f, 3.84996273e-02f, 1.84373558e-01f, -9.08649340e-02f,
  -2.30174333e-01f, -1.72941893e-01f, 3.04767471e-02f, 7.70619363e-02f, -2.08867192e-01f, 2.73918599e-01f, 1.27923340e-01f, -9.10611227e-02f, 1.59578025e-02f, 4.36819568e-02f,
  7.26828799e-02f, -6.74327537e-02f, -9.65833291e-02f, 8.36234614e-02f, -8.05879608e-02f, 9.06239003e-02f, -1.95404384e-02f, 7.75206536e-02f, -4.99287285e-02f, 3.31224948e-02f,
  1.61252901e-01f, 3.86556387e-02f, -6.01363853e-02f, 6.83254525e-02f, 8.20728391e-02f, -5.41324653e-02f, 1.40413880e-01f, -2.65431330e-02f, -4.63542417e-02f, -3.81236710e-02f,
  -1.42896190e-01f, 4.29794891e-03f, -6.27886727e-02f, 2.14523539e-01f, -3.16423038e-03f, -5.31670898e-02f, -1.09080866e-01f, 1.46919951e-01f, -1.08722188e-01f, 1.52726725e-01f,
  1.75298415e-02f, -5.56377247e-02f, 1.04391556e-02f, 1.24197386e-01f, -1.90363894e-03f, -1.47482445e-02f, 6.92234859e-02f, 4.90322709e-03f, 5.64229116e-02f, 9.46267396e-02f,
  6.95242658e-02f, 9.15286914e-02f, 1.21881351e-01f, -3.19065116e-02f, 6.34926707e-02f, -2.89683342e-02f, 7.39081353e-02f, -7.65521824e-02f, 6.81414232e-02f, -1.19812964e-02f,
  9.35804322e-02f, -1.10403672e-01f, -9.41100344e-03f, 1.00266881e-01f, 7.30967298e-02f, -5.28226346e-02f, -1.17329977e-01f, -6.21327907e-02f, 9.38215554e-02f, -1.34046063e-01f,
  5.54295145e-02f, -1.99800879e-02f, -6.68810457e-02f, 5.25418036e-02f, 5.08043692e-02f, -1.88562609e-02f, -9.17280167e-02f, -1.32343555e-02f, -6.26136288e-02f, -1.10771015e-01f,
  2.61347182e-02f, -9.38800424e-02f, -1.90622583e-02f, 3.42017375e-02f, -8.06462243e-02f, 1.16608351e-01f, 3.21852565e-02f, 2.82413028e-02f, -9.51263756e-02f, 1.80182997e-02f,
  3.57266627e-02f, -6.79886192e-02f, -5.95772872e-04f, 1.11167461e-01f, 9.19620171e-02f, -1.03151359e-01f, -7.97203854e-02f, 5.21112345e-02f, -9.58126187e-02f, -1.18213855e-01f,
  -1.04893833e-01f, -3.17243673e-02f, 9.56240147e-02f, 2.14767009e-02f, 5.44102266e-02f, -1.25170210e-02f, 8.12773183e-02f, -1.18139222e-01f, 6.25654235e-02f, 7.28132725e-02f,
  -2.61996444e-02f, -9.43822935e-02f, -5.43314852e-02f, 7.06446022e-02f, -5.52019551e-02f, -7.71601647e-02f, 1.71783622e-02f, -5.63466586e-02f, -3.98494303e-03f, -9.13094655e-02f,
  -7.08270594e-02f, -6.36231154e-02f, 3.65031734e-02f, -1.10367667e-02f, -4.82523367e-02f, 2.99208499e-02f, 1.13498196e-01f, 3.92314233e-02f, -1.95344597e-01f, -3.29995602e-02f,
  1.24440283e-01f, -6.67207362e-03f, 2.67403740e-02f, 1.92736059e-01f, -3.42820622e-02f, -4.74210232e-02f, 6.79503754e-02f, 1.15569979e-01f, 1.38381183e-01f, -7.16530681e-02f,
  -4.32054102e-02f, 4.55180779e-02f, 1.37483971e-02f, -5.53120812e-03f, 1.00491857e-02f, 5.31047136e-02f, -5.24152964e-02f, -1.03305625e-02f, 1.27406985e-01f, -1.10394783e-01f,
  -1.51011581e-02f, 1.35367587e-01f, 3.54308262e-02f, -7.85096362e-03f, 4.82119173e-02f, 1.96516998e-02f, -1.30283281e-01f, -1.21826246e-01f, 2.66151186e-02f, 1.31128475e-01f,
  -6.39948919e-02f, 1.88659087e-01f, 9.16026309e-02f, 5.12818471e-02f, -5.72575815e-02f, 1.30921558e-01f, -2.54521775e-03f, -2.51299553e-02f, -4.66211960e-02f, -1.64683592e-02f,
  1.06155105e-01f, -8.62952694e-03f, 1.95763595e-02f, 1.25760451e-01f, 7.65426382e-02f, -9.39415768e-02f, 9.21187103e-02f, 1.36960492e-01f, 1.23842634e-01f, 6.36824369e-02f,
  -8.63073543e-02f, 3.51053029e-02f, -6.65169582e-02f, 1.56829655e-02f, 1.16726018e-01f, -2.47710440e-02f, -4.93730158e-02f, -1.89078953e-02f, -1.15814649e-01f, -7.50252604e-02f,
  -1.13982923e-01f, 2.44972445e-02f, 8.26377794e-03f, -1.15725383e-01f, 8.48435611e-02f, -2.10026745e-02f, -9.72241536e-02f, 1.25119641e-01f, 9.50663164e-02f, -7.99627528e-02f,
  -5.77551797e-02f, -2.23971959e-02f, 7.70134404e-02f, -1.01655833e-01f, 6.11535609e-02f, -9.04026404e-02f, -2.85269357e-02f, 6.92822263e-02f, -5.51213510e-03f, -1.60376094e-02f,
  -9.48300064e-02f, -1.20237418e-01f, -7.04810694e-02f, -6.32626191e-03f, 4.36578458e-03f, 4.59644310e-02f, 6.25033900e-02f, 1.05143197e-01f, 9.77582708e-02f, -2.82542277e-02f,
  4.66446169e-02f, 1.13638416e-02f, 4.91777901e-03f, 4.41644937e-02f, 2.95096096e-02f, -1.09302707e-01f, -6.13690466e-02f, -5.31637692e-04f, -8.43935180e-03f, -7.68237263e-02f,
  -1.02823235e-01f, 6.29588589e-02f, -6.41989633e-02f, 8.50927681e-02f, -1.19896375e-01f, -1.06910214e-01f, -1.30066082e-01f, 9.04732123e-02f, -9.61125791e-02f, 9.83795896e-02f,
  6.18697293e-02f, -7.77049139e-02f, -6.85564131e-02f, 1.17031420e-02f, -8.13813657e-02f, -9.09664184e-02f, -6.21940307e-02f, -4.18470837e-02f, -1.08943664e-01f, -1.02257460e-01f,
  -6.07357100e-02f, -4.14844565e-02f, -4.97493297e-02f, 8.40926394e-02f, -9.67924595e-02f, -5.45704067e-02f, -3.84115055e-02f, -5.72905242e-02f, 6.95893541e-02f, 7.10141733e-02f,
  -8.40225369e-02f, 9.12637338e-02f, -5.98768741e-02f, 8.98909569e-02f, 8.96955729e-02f, -9.08019543e-02f, 7.34847486e-02f, 5.74930534e-02f, -5.97740076e-02f, 4.69185598e-03f,
  6.75314292e-03f, 1.55103102e-01f, 1.00654416e-01f, -9.55974404e-03f, -1.22274369e-01f, 1.18885450e-01f, 1.06441647e-01f, 8.00162181e-02f, -7.40262046e-02f, -3.60493595e-03f,
  -1.22513868e-01f, -1.18315957e-01f, 1.27554119e-01f, -2.93061994e-02f, 1.24149852e-01f, -1.18003502e-01f, 4.24768180e-02f, 1.16169974e-02f, 6.25578836e-02f, 7.91624039e-02f,
  1.44686937e-01f, -1.83240827e-02f, -1.16020083e-01f, -2.04423498e-02f, -9.79903340e-03f, 1.33741781e-01f, -3.98865575e-03f, 6.81887344e-02f, -2.71449182e-02f, 8.36719722e-02f,
  2.21817140e-02f, 7.45962784e-02f, 1.43237412e-01f, -1.08919390e-01f, -8.71241763e-02f, -2.34529451e-02f, -2.04505976e-02f, 1.81933325e-02f, 1.20740511e-01f, 5.05345725e-02f,
  1.17061153e-01f, 5.87173477e-02f, -1.15806200e-01f, 9.33709443e-02f, 5.01667336e-02f, 1.07720308e-01f, -4.27369326e-02f, -1.24690525e-01f, -9.83438715e-02f, -1.19909659e-01f,
  6.19788282e-03f, 8.46317038e-02f, 3.61962840e-02f, 9.81398020e-03f, 4.11524102e-02f, 1.00297369e-01f, 1.14767142e-01f, 7.17822239e-02f, -8.32268819e-02f, -1.90187246e-02f,
  -1.01370737e-01f, 8.86156186e-02f, -7.66228065e-02f, 4.66936007e-02f, 5.36996908e-02f, 1.42728731e-01f, 1.15890898e-01f, 2.72233132e-02f, -1.30907842e-03f, -2.15203315e-02f,
  -1.29743561e-01f, -1.64357554e-02f, -9.37467068e-02f, -3.76319662e-02f, -3.80142741e-02f, 1.15971193e-01f, -7.08512142e-02f, 4.09514830e-02f, 3.38385738e-02f, 1.95861254e-02f,
  2.81033348e-02f, -3.85259204e-02f, 9.14101154e-02f, 2.61689816e-02f, -5.25683574e-02f, 3.61068808e-02f, -3.64563055e-02f, -7.72283587e-04f, 8.48826244e-02f, 1.43429935e-01f,
  4.83096130e-02f, -1.19885402e-02f, -4.57844846e-02f, -1.33361379e-02f, -1.01825289e-01f, 2.20354032e-02f, 2.14195680e-02f, 9.72552598e-02f, -5.91950454e-02f, -2.43959781e-02f,
  -3.39727439e-02f, 4.41710092e-02f, -6.73301965e-02f, -8.92592072e-02f, -6.88821357e-03f, -5.92226647e-02f, 4.64895740e-02f, 5.23900613e-02f, 2.51342412e-02f, 3.25684510e-02f,
  1.52623177e-01f, 1.50221184e-01f, -3.09256208e-03f, 4.75093089e-02f, 1.85838208e-01f, -2.48675421e-02f, -1.99893102e-01f, 1.64409146e-01f, 5.56905121e-02f, -3.43076959e-02f,
  7.36421496e-02f, 8.93790498e-02f, 1.40252545e-01f, -1.16598599e-01f, 4.79208529e-02f, 1.00245699e-01f, -1.51626065e-01f, 2.34215483e-02f, 1.19474091e-01f, 1.35678276e-01f,
  1.00376770e-01f, 8.25850815e-02f, -8.48453715e-02f, 6.63511874e-03f, 3.30774449e-02f, -1.00483663e-01f, 6.57337606e-02f, -3.02424859e-02f, 2.84496258e-04f, -2.70709526e-02f,
  1.06263824e-01f, -8.28246027e-02f, 9.59828719e-02f, -5.78358136e-02f, -2.92528383e-02f, 1.53328672e-01f, -5.73507957e-02f, -5.70702143e-02f, 1.54595852e-01f, 6.43331110e-02f,
  7.66910538e-02f, -1.37055472e-01f, -6.59398139e-02f, 7.84036964e-02f, 4.36142050e-02f, -5.90105206e-02f, 1.43091306e-01f, -1.08536668e-01f, -2.46012248e-02f, 5.85223995e-02f,
  -3.49881165e-02f, 1.18888289e-01f, -9.48788375e-02f, -1.49529174e-01f, 3.47285718e-02f, 3.63028347e-02f, -5.70660550e-03f, -1.88698340e-02f, -2.22723428e-02f, -1.12285398e-01f,
  4.82870126e-03f, -4.17468958e-02f, -1.21489778e-01f, -6.83079362e-02f, 9.62134153e-02f, 2.83219106e-03f, -2.37829108e-02f, 5.52616715e-02f, -8.73636920e-03f, 1.10887922e-01f,
  -9.56484955e-03f, 3.88368927e-02f, 5.14130108e-02f, 3.45511152e-03f, -4.91658263e-02f, 5.77387698e-02f, 2.56926753e-02f, -6.36757389e-02f, -3.56226228e-02f, -2.38660071e-02f,
  2.67049801e-02f, 7.09415302e-02f, -7.62173682e-02f, 1.37492150e-01f, -7.51435161e-02f, 1.10889331e-01f, 1.09476112e-02f, -5.68995923e-02f, 8.89141709e-02f, -3.02709434e-02f,
  9.49820727e-02f, -5.02849370e-02f, 4.93042357e-02f, -2.73001902e-02f, -1.07285827e-01f, -1.19462267e-01f, 1.12782001e-01f, 1.92014556e-02f, -9.44394842e-02f, -5.74358404e-02f,
  1.01526469e-01f, -9.14349481e-02f, -1.05180942e-01f, -5.79977296e-02f, -6.73642009e-02f, -1.19366311e-02f, -1.97150744e-02f, -4.22673561e-02f, -4.03520875e-02f, -1.02334216e-01f,
  -9.26628187e-02f, 8.54016095e-03f, -7.18474910e-02f, -8.11859891e-02f, 8.16951171e-02f, 1.53588383e-02f, 5.73158562e-02f, -1.28526449e-01f, -6.60773413e-03f, -2.18562651e-02f,
  -8.71873870e-02f, -4.99926880e-02f, -7.64105050e-03f, -2.55557857e-02f, -1.03017524e-01f, 1.11805825e-02f, 6.70533329e-02f, -1.12485930e-01f, -1.36081889e-01f, 4.89890277e-02f,
  -1.45842947e-04f, 1.07205786e-01f, 1.31239429e-01f, -2.67799497e-02f, -4.64929780e-03f, -9.06886458e-02f, -9.45057906e-03f, -1.03850767e-01f, 9.46489349e-03f, 1.26901055e-02f,
  6.79754466e-02f, -5.73351346e-02f, 5.49151897e-02f, -1.63704492e-02f, 5.52417859e-02f, 1.01362959e-01f, -4.32647988e-02f, 1.82451718e-02f, -6.97680935e-02f, -3.44238169e-02f,
  -5.49481101e-02f, -8.79581124e-02f, -8.36224779e-02f, 4.30468246e-02f, -9.70646590e-02f, -8.78782272e-02f, 8.51079226e-02f, -7.66125396e-02f, -6.11963868e-02f, 6.15950674e-02f,
  -1.21798284e-01f, 1.70060545e-02f, -8.76572505e-02f, -2.35990379e-02f, 3.66599411e-02f, 1.62738059e-02f, -3.88418734e-02f, -9.85343531e-02f, -6.53883144e-02f, -5.45624457e-02f,
  -5.52428812e-02f, 9.37815979e-02f, 1.02780201e-02f, 1.33069325e-03f, 6.29738381e-04f, -8.95190760e-02f, -2.11185236e-02f, 5.54951653e-02f, 1.85284168e-02f, -1.13893822e-01f,
  5.58729060e-02f, -7.92737305e-02f, 1.94417275e-02f, -6.39220849e-02f, 3.47908703e-03f, 4.53344323e-02f, 5.14561385e-02f, 9.70190316e-02f, -5.27434945e-02f, 3.06229088e-02f,
  -6.88668201e-03f, -4.63942811e-03f, -1.22851476e-01f, 2.39192825e-02f, 3.43110263e-02f, -8.75550061e-02f, 1.50728360e-01f, 1.98931769e-02f, -5.26470616e-02f, -1.16853416e-02f,
  -1.23622566e-01f, -7.91932270e-02f, 9.01191235e-02f, -5.71789630e-02f, 6.06668442e-02f, 6.46778643e-02f, 5.95613793e-02f, -1.03310943e-01f, 2.76106969e-03f, -4.87632006e-02f,
  1.40749410e-01f, -1.36519922e-02f, -1.07852906e-01f, -4.65771742e-03f, -5.52880242e-02f, 8.99252221e-02f, -9.65593085e-02f, -5.35293482e-02f, -1.70887727e-03f, 7.45086521e-02f,
  -6.59639165e-02f, 1.17227107e-01f, 2.45453045e-02f, 3.39581072e-02f, 9.01707783e-02f, 1.07243964e-02f, -4.93091084e-02f, -2.86606010e-02f, -1.31213233e-01f, -1.40854761e-01f,
  -1.13545209e-01f, -3.26554920e-03f, -1.22610286e-01f, -2.37746276e-02f, 5.67404255e-02f, 5.93649819e-02f, 1.04551844e-01f, 6.36625886e-02f, -1.03808321e-01f, 5.74958734e-02f,
  -8.96658003e-02f, 5.87016493e-02f, 1.13097787e-01f, -7.79944584e-02f, 1.45858854e-01f, 8.50024745e-02f, -2.64676362e-02f, -6.49007186e-02f, -8.87419432e-02f, 5.62503226e-02f,
  9.48580205e-02f, -1.24509118e-01f, 9.66915265e-02f, -1.05519272e-01f, 1.42456636e-01f, 1.40188485e-01f, 1.72498301e-01f, 1.18154719e-01f, 2.27331713e-01f, 1.05957627e-01f,
  -1.94682822e-01f, -1.89864621e-01f, 7.04787970e-02f, 7.08893910e-02f, 1.62869006e-01f, -7.76807719e-04f, -6.34474307e-02f, -6.80519268e-02f, 4.03028652e-02f, 4.86880122e-03f,
  8.50115418e-02f, 3.60099487e-02f, -4.26567197e-02f, 8.52519348e-02f, 9.12658274e-02f, -7.84116089e-02f, 4.25933860e-02f, 1.33395910e-01f, 5.24438471e-02f, 4.81872261e-03f,
  1.04208060e-01f, 7.03101233e-02f, 1.10569932e-01f, 2.52044767e-01f, 1.44928217e-01f, -3.54611278e-02f, 1.38172925e-01f, -1.14152350e-01f, -1.22156173e-01f, -6.14454560e-02f,
  1.04103684e-01f, 1.56833798e-01f, 1.36051044e-01f, 1.67913884e-01f, -1.65730566e-02f, -8.81377608e-03f, 5.90682868e-03f, -5.62341418e-03f, 1.06014468e-01f, 6.41557872e-02f,
  -1.04237817e-01f, -9.61243734e-02f, 2.46840343e-02f, -3.14961523e-02f, 7.94616863e-02f, 6.09092005e-02f, 7.47631863e-02f, -5.50688850e-03f, 6.79501072e-02f, 2.49955177e-01f,
  -7.13042840e-02f, 1.08059179e-02f, 2.90940944e-02f, 3.10190357e-02f, -8.59116241e-02f, 6.51837587e-02f, 1.90355405e-01f, -8.92866775e-02f, -7.87982903e-03f, -3.42949666e-02f,
  -9.94416848e-02f, -1.17289774e-01f, 7.93869868e-02f, 1.13726817e-01f, 1.60337731e-01f, 1.34876281e-01f, -1.06688179e-01f, -9.54679251e-02f, -8.83800685e-02f, -1.57204747e-01f,
  -9.86155272e-02f, 1.04205780e-01f, 7.65061006e-02f, 9.74314958e-02f, -1.41965613e-01f, 1.12960294e-01f, 1.51330521e-02f, -8.20243284e-02f, -8.70805308e-02f, 1.02081664e-01f,
  3.14373896e-02f, -9.53715071e-02f, 3.43871117e-02f, -1.03157923e-01f, -7.61367083e-02f, 6.72231391e-02f, -8.52622092e-02f, 5.00174686e-02f, 2.20599789e-02f, 9.22905877e-02f,
  -4.64483202e-02f, 9.70507935e-02f, 2.74870154e-02f, 1.05691805e-01f, -1.13173269e-01f, -5.91463000e-02f, -1.24402501e-01f, 6.23032302e-02f, 3.90047655e-02f, -1.42916674e-02f,
  5.72961289e-03f, 4.48597632e-02f, 7.60967657e-02f, -6.47138134e-02f, 6.75401539e-02f, 1.04086116e-01f, 4.43357006e-02f, 5.13674431e-02f, -1.87397860e-02f, 9.43457857e-02f,
  1.05563961e-01f, 6.06499761e-02f, 1.20933510e-01f, -1.67041346e-02f, -8.60604420e-02f, 1.30342720e-02f, -1.25916019e-01f, -3.65121625e-02f, 1.03552751e-01f, -1.11163393e-01f,
  -1.21185713e-01f, -1.04551837e-01f, 8.21723789e-02f, 9.57698151e-02f, 1.46477789e-01f, 1.32911876e-01f, -8.22554156e-02f, 7.88737014e-02f, -4.81912233e-02f, -1.46685347e-01f,
  -2.61221401e-04f, -1.18898995e-01f, 2.91263852e-02f, 1.58014402e-01f, 9.57297906e-02f, 5.00232987e-02f, 1.43380621e-02f, -1.12358825e-02f, 1.09676346e-01f, -8.35497603e-02f,
  -4.30062152e-02f, -8.88454542e-02f, 4.14623283e-02f, -6.02972358e-02f, -1.70066431e-02f, 9.22112912e-02f, -5.49789071e-02f, 5.89984991e-02f, 1.14785515e-01f, 1.20302826e-01f,
  -7.85147548e-02f, 8.14698488e-02f, -3.29221524e-02f, -3.62085067e-02f, -6.34602308e-02f, 5.40162623e-02f, -7.34461024e-02f, -7.04580247e-02f, 9.46090147e-02f, -5.42109348e-02f,
  -8.52233917e-02f, 3.87228280e-02f, 5.12278639e-02f, -2.65092626e-02f, -5.49360402e-02f, 7.30946101e-03f, -8.67598504e-02f, 5.85940890e-02f, 6.50020316e-02f, -8.87288973e-02f,
  -1.14018083e-01f, 1.61293074e-01f, 6.17026165e-02f, 1.17254898e-01f, 7.25907013e-02f, 7.31160268e-02f, 2.47445572e-02f, 1.04351386e-01f, 4.04452812e-03f, -5.71855195e-02f,
  9.14054215e-02f, -3.08461068e-03f, 7.30449159e-04f, -1.09800458e-01f, -8.75413641e-02f, 1.23370022e-01f, 1.06108516e-01f, 1.15587480e-01f, 7.64056370e-02f, 1.04346514e-01f,
  1.45241424e-01f, 5.86335510e-02f, -1.64918348e-01f, -2.32174754e-01f, -2.28454303e-02f, 3.06161821e-01f, -1.01817772e-01f, 3.55068482e-02f, -1.28978461e-01f, -1.39703244e-01f,
  4.17359546e-02f, 9.62551087e-02f, 7.83726200e-02f, 1.31529182e-01f, -8.26359447e-03f, 6.71531186e-02f, 4.79182377e-02f, -4.60097790e-02f, -1.04163857e-02f, 1.47070989e-01f,
  -5.70322871e-02f, 2.85521429e-03f, 1.07104443e-01f, 5.14244428e-03f, -7.64802545e-02f, 1.40525103e-01f, -2.81294119e-02f, 1.44293055e-01f, 2.58989483e-01f, -5.88078424e-02f,
  -1.14137657e-01f, -1.69931039e-01f, -2.28443854e-02f, 2.26817802e-01f, 3.41963917e-02f, 3.82843316e-01f, 2.46032640e-01f, 1.15894191e-01f, -6.41633198e-02f, -8.72750580e-02f,
  4.07984294e-02f, 3.58415097e-02f, -6.47477508e-02f, 1.56185925e-02f, 1.90433487e-01f, 7.57731721e-02f, -8.75549018e-02f, 1.20497733e-01f, -7.08667794e-03f, 1.19903192e-01f,
  -1.27829373e-01f, 2.29415037e-02f, 2.56850123e-01f, 1.97165050e-02f, 1.30580515e-01f, 2.81520262e-02f, -1.64420247e-01f, -3.42069706e-03f, 5.44351079e-02f, -1.07099764e-01f,
  4.05357406e-02f, -1.00918271e-01f, -2.57915846e-04f, 1.46675974e-01f, 7.06110895e-02f, 1.42342690e-02f, 9.86397266e-02f, 2.16133669e-01f, 1.47446170e-02f, 6.42522797e-02f,
  -1.71988104e-02f, 1.08292602e-01f, 7.11429045e-02f, 6.15072623e-02f, 1.90491788e-02f, -1.08328216e-01f, 1.47065341e-01f, -1.44392431e-01f, -2.51760259e-02f, 7.60428384e-02f,
  -8.13240632e-02f, -9.28955153e-02f, 4.80200872e-02f, -3.10969260e-02f, 1.18635092e-02f, 1.31227806e-01f, -1.00883916e-01f, 5.93003295e-02f, -8.55440870e-02f, 5.66919483e-02f,
  7.83145949e-02f, -1.65719830e-03f, -6.60744160e-02f, -1.07687540e-01f, 1.31228790e-01f, 1.16136424e-01f, 1.51706329e-02f, -2.24455837e-02f, 1.39913140e-02f, 7.99445137e-02f,
  -1.48950011e-01f, -7.40555823e-02f, 1.97293442e-02f, 7.09635299e-03f, 1.23568000e-02f, 7.28076845e-02f, 7.89934024e-02f, 9.17975828e-02f, 4.91188467e-02f, 1.30045488e-01f,
  4.76036482e-02f, -5.47743477e-02f, 1.58503264e-01f, 1.00728534e-01f, 8.00375175e-03f, 3.07569094e-02f, -3.25699709e-02f, 3.92685495e-02f, -4.55347821e-03f, 9.55386609e-02f,
  3.11317910e-02f, 9.89582948e-03f, 5.88448457e-02f, -7.82239735e-02f, -2.47418173e-02f, -3.30269337e-03f, -9.26585644e-02f, 6.62119091e-02f, 4.58761863e-02f, -5.54991774e-02f,
  -4.59888298e-03f, 1.48287490e-01f, -1.46027163e-01f, 1.11859543e-02f, 1.83596268e-01f, -2.48344451e-01f, 7.97980055e-02f, -2.59540007e-02f, 3.09441090e-02f, 9.88783240e-02f,
  -8.89351666e-02f, 7.44309684e-04f, 8.12176839e-02f, 1.28158808e-01f, 8.85629728e-02f, 1.86243922e-01f, -7.30456561e-02f, -1.21915042e-01f, 2.17028465e-02f, 1.23996705e-01f,
  1.23274989e-01f, 2.45261285e-02f, 1.65316522e-01f, 3.38454656e-02f, -4.93802354e-02f, -5.66863902e-02f, 9.24722180e-02f, 8.75726633e-04f, -3.72837447e-02f, 1.08039036e-01f,
  5.17831556e-02f, 7.68454224e-02f, -4.33755182e-02f, -8.55375081e-02f, 1.51205391e-01f, -3.61118168e-02f, 4.25033830e-02f, 4.39166129e-02f, 2.46506277e-03f, 7.04408213e-02f,
  8.07164684e-02f, -3.14638317e-02f, 6.84504956e-02f, 8.66428539e-02f, -1.49046658e-02f, 6.21413551e-02f, -1.99768189e-02f, 7.41022825e-02f, -8.66324827e-02f, 1.26504926e-02f,
  2.40511424e-03f, -1.24442518e-01f, -1.21013168e-02f, -1.05286233e-01f, 2.27077022e-01f, 2.16795262e-02f, -5.71334139e-02f, -9.09132790e-03f, -6.23867139e-02f, 1.46696970e-01f,
  5.37729822e-02f, -9.92748365e-02f, -1.05220012e-01f, 3.45221651e-03f, 1.50332585e-01f, 8.77093971e-02f, -2.36314200e-02f, -2.83298083e-02f, -3.67944315e-02f, -1.77807540e-01f,
  -3.53046022e-02f, 1.23981632e-01f, -8.30434635e-02f, 1.07197948e-01f, -1.24990799e-01f, 7.64105693e-02f, 5.19059747e-02f, -7.68682510e-02f, -4.62775081e-02f, 5.43778809e-03f,
  -4.61489037e-02f, -6.05700500e-02f, 6.95968941e-02f, -7.32495217e-03f, -6.43211901e-02f, 5.17644500e-03f, 1.27327874e-01f, -1.56184221e-02f, -1.27054319e-01f, -6.92340359e-02f,
  1.21871345e-01f, 5.51174991e-02f, -6.81699440e-02f, 6.91971704e-02f, 3.97231132e-02f, 1.11229219e-01f, -1.11717708e-01f, -1.06117805e-03f, 4.37339470e-02f, -1.28515959e-01f,
  1.23099610e-01f, 1.72380116e-02f, 6.08971380e-02f, 1.21425517e-01f, 7.69226030e-02f, 1.24044791e-02f, -7.06046820e-02f, -1.05161734e-01f, 2.88740527e-02f, -5.99186011e-02f,
  2.42676735e-02f, -2.28165351e-02f, 4.56008688e-02f, 9.75173563e-02f, -7.45883286e-02f, -1.07510850e-01f, 1.05056345e-01f, 1.19846560e-01f, 3.63986343e-02f, -2.49231756e-02f,
  1.57922078e-02f, 9.37924236e-02f, -1.67001169e-02f, 1.17577962e-03f, 2.17267573e-01f, 9.90325212e-02f, 2.24072322e-01f, -3.99124026e-02f, -1.25081867e-01f, 4.31834422e-02f,
  1.09524868e-01f, 1.22008704e-01f, -1.26994461e-01f, 3.65413904e-01f, -5.14649134e-03f, -5.63140996e-02f, -4.06775884e-02f, -5.32355420e-02f, 1.45969242e-01f, -8.56679305e-02f,
  -1.47677809e-01f, -6.89466745e-02f, -3.15754451e-02f, -2.16689985e-02f, 5.49618006e-02f, 2.35168204e-01f, -2.57905643e-03f, 5.94242699e-02f, 1.66832864e-01f, 5.59410639e-02f,
  -1.23771593e-01f, 5.57338027e-03f, -5.80709279e-02f, -4.72511314e-02f, 1.15709215e-01f, 6.40908107e-02f, 8.81151184e-02f, -4.06369269e-02f, -7.91088343e-02f, 1.11566216e-01f,
  1.91139467e-02f, 1.93716824e-01f, 6.96202216e-04f, -1.39267802e-01f, -1.25957550e-02f, 5.09444587e-02f, -9.00980905e-02f, 5.78009151e-03f, 1.64695799e-01f, 9.24505889e-02f,
  2.36906007e-01f, 1.73136070e-01f, 5.71679138e-02f, 1.20593719e-01f, 2.25595698e-01f, -1.16080686e-01f, 4.07405458e-02f, -7.81390890e-02f, 6.20373450e-02f, 1.92684010e-01f,
  4.26324904e-02f, 7.31896907e-02f, 8.08119476e-02f, 6.29874319e-02f, 3.26910429e-02f, 1.15181863e-01f, -8.62528384e-02f, -4.78842817e-02f, -7.04935491e-02f, 1.01267584e-01f,
  1.26553938e-01f, -4.99980748e-02f, 1.47112980e-01f, -6.94822744e-02f, -1.51714608e-01f, -1.64738726e-02f, 4.28293534e-02f, 9.96304676e-02f, -1.27343148e-01f, 8.82946551e-02f,
  1.15438767e-01f, 2.52644066e-02f, 6.73274174e-02f, -3.77653469e-03f, 2.80484855e-02f, -1.66710280e-02f, 7.31368884e-02f, 2.25083530e-01f, -5.30080348e-02f, 9.97063704e-03f,
  -4.80935425e-02f, 4.42722887e-02f, 1.75212637e-01f, 2.42912006e-02f, 1.72364458e-01f, -1.06199615e-01f, -4.86559868e-02f, -1.12258391e-02f, 4.41394597e-02f, 5.80587685e-02f,
  1.16616912e-01f, 2.62303222e-02f, 1.55021828e-02f, 1.43675208e-01f, 2.19235774e-02f, 1.08489031e-02f, 2.51217205e-02f, -1.05064072e-01f, 1.11028783e-01f, -4.74425107e-02f,
  -1.07780859e-01f, -4.13410887e-02f, 7.52630383e-02f, 8.38153139e-02f, -2.35123243e-02f, -4.92962338e-02f, 3.46794426e-02f, 1.00686960e-02f, 7.65789002e-02f, -5.90218902e-02f,
  -9.36648995e-02f, -5.03816158e-02f, 9.01785865e-02f, -3.53891067e-02f, 5.69033287e-02f, 1.07272416e-01f, 5.40236793e-02f, -4.52699773e-02f, -5.68715483e-02f, 6.96139261e-02f,
  -3.66308764e-02f, 1.64651707e-01f, 6.20872751e-02f, 1.62870556e-01f, 1.82586476e-01f, 1.63437322e-01f, 2.05648869e-01f, 2.76642174e-01f, -2.00631961e-01f, 1.11709267e-01f,
  8.17333441e-03f, -8.19744915e-02f, -5.92460707e-02f, 5.62752001e-02f, 1.11363173e-01f, 1.09176137e-01f, -2.58816238e-02f, 1.27566397e-01f, -4.53841388e-02f, -8.38252157e-02f,
  2.82627605e-02f, 1.08153999e-01f, 1.13263912e-02f, -1.44595250e-01f, -1.03273436e-01f, 4.81062569e-02f, -1.08266279e-01f, -3.31464969e-02f, -9.86006036e-02f, -9.65042319e-03f,
  -1.61352828e-01f, -8.64863545e-02f, -3.56248692e-02f, 1.29647344e-01f, 6.47430941e-02f, 1.18704781e-01f, 1.04875989e-01f, -1.08472712e-01f, 1.00107379e-02f, -1.96290508e-01f,
  -1.00967787e-01f, -8.68977010e-02f, 9.60712135e-03f, -6.43334091e-02f, 1.39848337e-01f, 1.14930578e-01f, -1.71954781e-02f, 1.32302076e-01f, -1.17320083e-01f, 2.07851995e-02f,
  1.86736211e-01f, 5.53729460e-02f, -4.24026959e-02f, 1.92889385e-03f, 6.53414875e-02f, -7.20121935e-02f, -1.23527274e-01f, 5.68769015e-02f, -6.27745390e-02f, -2.28877775e-02f,
  -2.69057285e-02f, -1.24162614e-01f, -6.64934888e-02f, -7.15248585e-02f, -9.62065440e-03f, -3.05874962e-02f, 1.09339222e-01f, 3.08383144e-02f, -1.02322578e-01f, 7.19043314e-02f,
  2.69084543e-01f, 1.36449218e-01f, -4.75494890e-03f, 3.23603414e-02f, 9.83474851e-02f, -2.97191590e-01f, -1.03092656e-01f, 6.39678538e-02f, 1.73966557e-01f, -6.79394752e-02f,
  -5.69178537e-02f, -5.69311483e-03f, 8.54845494e-02f, 9.75270793e-02f, 1.04681253e-02f, 2.31562376e-01f, -1.07837655e-01f, -1.73269272e-01f, -8.44739377e-02f, -8.55320226e-03f,
  -9.65015814e-02f, 9.69989039e-03f, 1.78884655e-01f, 5.89085780e-02f, -2.80197114e-02f, -1.39889702e-01f, -3.86997908e-02f, 1.15863256e-01f, 1.31408557e-01f, 2.97701694e-02f,
  -9.39374343e-02f, 3.69211584e-02f, 8.59949142e-02f, 3.59634981e-02f, -8.19597095e-02f, 7.62404129e-02f, 2.01842517e-01f, -3.47369015e-02f, -5.46401739e-02f, 1.80286527e-01f,
  1.15008682e-01f, -5.05561531e-02f, -8.07346925e-02f, -5.87347522e-03f, 1.96804792e-01f, 4.89247367e-02f, 2.39552325e-03f, -6.31586090e-02f, -9.87070948e-02f, 3.89854908e-02f,
  4.29227427e-02f, 5.06505109e-02f, 1.12383209e-01f, -7.20091984e-02f, 2.46153370e-01f, -2.55362354e-02f, 8.16635862e-02f, 7.64837116e-02f, 3.43778729e-01f, 3.41657013e-01f,
  1.18413344e-01f, 3.11598659e-01f, 2.62521077e-02f, 2.87695736e-01f, -5.03361821e-02f, 1.14662573e-01f, 1.72645926e-01f, -4.01390523e-01f, 3.05332124e-01f, -1.66532472e-01f,
  1.12885945e-01f, 8.06796700e-02f, 6.79136603e-04f, 1.23345241e-01f, 1.15128621e-01f, 1.14612468e-01f, -1.12696797e-01f, 9.70836282e-02f, -1.36288092e-01f, 1.18301526e-01f,
  1.20291747e-01f, -6.82372600e-02f, 1.06689315e-02f, 3.85023467e-02f, -1.30282998e-01f, -1.68616980e-01f, 1.31190121e-01f, 2.17302904e-01f, 6.82872310e-02f, 5.76926619e-02f,
  -1.65700704e-01f, -1.65316202e-02f, 7.75429308e-02f, 1.60329118e-01f, 1.43321946e-01f, -2.44612455e-01f, -4.56039310e-02f, 4.82378341e-02f, -4.61855009e-02f, 1.45610459e-02f,
  1.44011676e-01f, 2.35996973e-02f, 2.55257905e-01f, 2.33550698e-01f, -7.07758591e-03f, -1.30421624e-01f, -1.66761905e-01f, 2.91371793e-01f, 2.57850617e-01f, -3.79762091e-02f,
  5.59884682e-02f, 4.39327918e-02f, 8.41000453e-02f, 3.06223869e-01f, -1.16071910e-01f, 1.52832717e-01f, 1.15139000e-01f, 1.81957901e-01f, 1.97788224e-01f, 2.18676422e-02f,
  2.10290745e-01f, -1.47978952e-02f, -5.54427020e-02f, -3.70834470e-02f, -1.08411148e-01f, -1.21883146e-01f, 8.66573155e-02f, 4.74596545e-02f, 1.87293366e-02f, 4.80896421e-02f,
  1.07987389e-01f, -1.08349726e-01f, -1.11733384e-01f, 8.75927657e-02f, -8.07371289e-02f, -9.44407135e-02f, 2.99105532e-02f, -2.41016466e-02f, -7.55860209e-02f, -5.54614887e-02f,
  4.85581197e-02f, -1.07560620e-01f, -6.87420070e-02f, -1.30019739e-01f, -1.14479937e-01f, 5.98937944e-02f, 1.01489224e-01f, -1.26889944e-01f, -6.61142766e-02f, 1.46584269e-02f,
  6.90601245e-02f, -5.29265478e-02f, -3.28117423e-02f, -1.23523667e-01f, 2.10357327e-02f, 9.40448940e-02f, -2.27265130e-03f, -7.08928481e-02f, -9.02377144e-02f, 7.56384106e-03f,
  -3.25597338e-02f, 6.64662421e-02f, 1.25251889e-01f, 8.24535415e-02f, -3.04858387e-02f, 1.14144526e-01f, 5.75941280e-02f, -6.15800470e-02f, -3.92286405e-02f, -1.02738515e-01f,
  1.66746806e-02f, -5.75669156e-03f, 6.09768815e-02f, -7.52374157e-02f, 3.02575808e-03f, -1.18557982e-01f, -4.05030847e-02f, -2.26464719e-02f, -4.24656570e-02f, 9.48243439e-02f,
  -8.38736370e-02f, 4.11617458e-02f, -4.86613400e-02f, 3.00182756e-02f, -1.97068211e-02f, -4.98398356e-02f, -7.59329870e-02f, 7.64422566e-02f, -1.76316854e-02f, -7.43993148e-02f,
  1.01963080e-01f, 1.42532084e-02f, 1.08375393e-01f, -4.54493761e-02f, 3.83667201e-02f, -8.66281986e-03f, 6.02403097e-02f, -2.83217970e-02f, 7.55203292e-02f, 5.78812845e-02f,
  -1.09937876e-01f, 3.90379876e-02f, -1.49336699e-02f, -4.37513627e-02f, -1.85954235e-02f, -1.71108544e-02f, 1.04016364e-01f, 4.31399010e-02f, 8.06087404e-02f, -6.99468553e-02f,
  1.08340025e-01f, 6.84697330e-02f, 9.82222706e-02f, 3.68468687e-02f, -5.01086786e-02f, -1.10847205e-01f, 5.61522469e-02f, -1.86095797e-02f, -8.72453675e-02f, -4.80131879e-02f,
  -1.19297102e-01f, 1.00710839e-02f, 1.96338426e-02f, -5.48147708e-02f, 6.58370107e-02f, -5.44836968e-02f, -1.12197019e-01f, 8.96508247e-02f, -4.20345701e-02f, -5.83292171e-02f,
  3.20750251e-02f, 8.93795192e-02f, -6.87352195e-02f, -4.82302941e-02f, -1.02950759e-01f, -1.32304132e-01f, -4.51846458e-02f, 6.64164945e-02f, -4.48218472e-02f, -6.79321140e-02f,
  -7.73314536e-02f, 5.20261638e-02f, -1.23043917e-02f, 1.16595276e-01f, 1.01443492e-01f, -1.10984221e-02f, -1.17074430e-01f, 2.45599877e-02f, -7.05270544e-02f, -1.62642784e-02f,
  9.17619690e-02f, 1.45236969e-01f, 8.55319053e-02f, -4.41806726e-02f, 2.24032640e-01f, 1.54823855e-01f, -1.58178315e-01f, -1.68913543e-01f, 2.37533413e-02f, 4.62712254e-03f,
  -3.67852226e-02f, 1.29843101e-01f, -6.90732524e-02f, 9.16209742e-02f, -4.33221012e-02f, -6.71792850e-02f, -3.27578709e-02f, 1.68749109e-01f, -6.25342578e-02f, -1.28021210e-01f,
  7.22089559e-02f, -1.12700336e-01f, 5.99028580e-02f, 2.15243787e-01f, -4.70597558e-02f, 3.31356302e-02f, 1.83827341e-01f, 1.29181057e-01f, -8.93448442e-02f, 4.94135320e-02f,
  1.21377461e-01f, 1.43079370e-01f, 5.72812259e-02f, 1.17893204e-01f, -5.00488952e-02f, -4.93871607e-02f, 7.78407650e-03f, 1.90293282e-01f, 1.67284142e-02f, 2.33061343e-01f,
  -1.34662287e-02f, -1.05343848e-01f, -1.38827637e-01f, 9.42275226e-02f, 1.09091818e-01f, 8.37325957e-03f, 6.43902346e-02f, 1.00784674e-01f, 3.69591005e-02f, 1.09392263e-01f,
  5.54708764e-02f, 1.64022267e-01f, -4.09839787e-02f, 6.64004758e-02f, -1.10072710e-01f, -2.86582075e-02f, -6.25156909e-02f, 1.21249594e-01f, -4.05376330e-02f, -1.16431415e-02f,
  -8.69242474e-02f, 3.03325988e-02f, 1.86453145e-02f, 4.89726514e-02f, 1.96362019e-01f, 2.20513985e-01f, 3.21725309e-01f, 2.25627944e-01f, 1.97745070e-01f, 2.12009713e-01f,
  -7.54532591e-02f, 1.00814044e-01f, -3.12120710e-02f, -2.46504679e-01f, 1.03657909e-01f, -1.66400596e-02f, 8.48986581e-02f, 1.31387755e-01f, 5.99341765e-02f, -5.08405901e-02f,
  1.42841205e-01f, 1.42911404e-01f, 7.17322379e-02f, 6.94168806e-02f, 5.89927323e-02f, 1.18646711e-01f, 1.54539244e-02f, 4.29202765e-02f, 5.66521361e-02f, 2.17844266e-02f,
  -1.39432758e-01f, 9.69465123e-04f, 1.36611551e-01f, 7.55928382e-02f, -1.02677792e-01f, 1.30762070e-01f, -8.15128237e-02f, -1.94311757e-02f, 6.07584938e-02f, -4.56230864e-02f,
  1.24173522e-01f, 6.40633181e-02f, 1.25839040e-01f, -7.27680549e-02f, -1.10559516e-01f, 1.12397313e-01f, 5.41820079e-02f, 3.41162123e-02f, -1.40305506e-02f, 1.07670967e-02f,
  7.24419728e-02f, -1.61087848e-02f, -4.08913791e-02f, 1.37517437e-01f, 1.57426909e-01f, 1.37586951e-01f, 3.91755961e-02f, -8.86707082e-02f, -6.15415676e-03f, 6.71328083e-02f,
  -1.25367060e-01f, 1.42930105e-01f, -1.03926934e-01f, -4.12581898e-02f, 1.62889838e-01f, -6.19067475e-02f, 1.67063937e-01f, -6.11917675e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  -5.31471446e-02f, 1.73491701e-01f, -5.01613654e-02f, 1.06312536e-01f, 1.85944796e-01f, -6.43295273e-02f, 1.25849932e-01f, 5.06272390e-02f, -7.13718608e-02f, -6.26582429e-02f,
  2.59866208e-01f, -3.22935581e-02f, 8.23122263e-02f, 1.14651248e-01f, -2.95720901e-02f, 2.67553508e-01f, -5.83991967e-02f, 2.46554121e-01f, 1.52412280e-01f, 1.18473589e-01f,
  -6.32391721e-02f, -2.26106457e-02f, -8.89719874e-02f, 2.08054796e-01f, 1.37053609e-01f, 2.32060477e-01f, 1.60246179e-01f, -9.63120684e-02f, -1.55650554e-02f, -5.80962263e-02f,
  1.45958597e-02f, -1.25819266e-01f, 1.04253791e-01f, -1.87334921e-02f, -8.38699564e-02f, -1.40896052e-01f, 3.15762788e-01f, -5.01108170e-02f, -6.34002164e-02f, 2.83477813e-01f,
  6.60223141e-02f, 8.37135613e-02f, 6.26482368e-02f, 2.29390025e-01f, -1.09667405e-02f, 1.55106544e-01f, -5.87920733e-02f, 2.85682768e-01f, -9.46686715e-02f, -3.13549563e-02f,
  2.18372837e-01f, 2.76936859e-01f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -2.56198317e-01f, -1.45887256e-01f, -2.22650930e-01f, 1.85144022e-02f, -1.69257462e-01f, -2.35165924e-01f, 1.03674181e-01f, -7.25169629e-02f, 1.68781336e-02f, -3.39011878e-01f,
  -2.33767390e-01f, -6.06984012e-02f, 1.13982568e-02f, -4.11368683e-02f, -2.50588711e-02f, -1.06051512e-01f, -1.59082979e-01f, -3.37654129e-02f, -2.02038512e-02f, -7.49741727e-03f,
  5.61727323e-02f, 5.78120649e-02f, 1.24188559e-02f, 1.47932500e-01f, 1.88791305e-01f, 1.03418581e-01f, 7.72945657e-02f, 8.16074759e-03f, 6.24804460e-02f, 1.05329230e-02f,
  5.08556999e-02f, -8.61074105e-02f, -1.95122398e-02f, 7.01792389e-02f, 1.08587854e-01f, 4.18458171e-02f, -1.49687201e-01f, -1.43659115e-01f, 1.48187846e-01f, -1.41112818e-04f,
  -5.22521995e-02f, -7.39472508e-02f, 1.31337540e-02f, 4.98887002e-02f, 9.21195932e-03f, -2.07447652e-02f, 4.37926240e-02f, 1.27336770e-01f, -1.34708613e-01f, 8.37840810e-02f,
  -3.11969616e-03f, 2.98083536e-02f, -1.11027367e-01f, 1.50702998e-01f, 1.32273301e-01f, 5.41678965e-02f, 9.70101133e-02f, 1.57181218e-01f, 1.30073398e-01f, -2.79336900e-01f,
  -4.80650105e-02f, -6.93818554e-02f, -6.02518842e-02f, -1.66365743e-01f, 6.39488548e-02f, -8.58544260e-02f, -3.96897271e-02f, 1.04071572e-01f, -2.93399976e-03f, -1.23295754e-01f,
  3.16505015e-01f, 9.81589966e-03f, 1.37025252e-01f, -1.41137868e-01f, -7.25317225e-02f, 2.22136095e-01f, -6.28062338e-02f, -5.54737486e-02f, 7.04100542e-03f, 6.47613332e-02f,
  -3.27826776e-02f, 6.26789927e-02f, 1.72898313e-03f, -7.54169151e-02f, -1.64647568e-02f, 5.97201660e-02f, -2.45089918e-01f, -1.40485470e-03f, -7.65918866e-02f, 4.05627936e-02f,
  -1.80859249e-02f, -3.81452404e-02f, 7.53289759e-02f, 9.53389157e-04f, -9.26542655e-02f, 6.25142157e-02f, -8.54330584e-02f, 1.83107346e-01f, 1.18883327e-01f, -1.38234943e-01f,
  -4.88192663e-02f, -1.61290541e-02f, 1.21919110e-01f, 3.14574852e-03f, 1.04574084e-01f, 6.68055266e-02f, 4.24380898e-02f, -2.35482957e-02f, 1.24034427e-01f, 1.13959303e-02f,
  6.69750646e-02f, -1.36293992e-02f, -9.80086252e-03f, -3.72177623e-02f, -5.02954833e-02f, 2.41405979e-01f, -9.32976231e-03f, -8.11219886e-02f, -1.02793798e-01f, 1.15707546e-01f,
  3.74614969e-02f, -4.03023027e-02f, -1.21765763e-01f, -2.71578550e-01f, -2.54300423e-02f, 2.34372765e-02f, 2.96631595e-03f, -1.81195781e-01f, -9.03636143e-02f, -2.04440996e-01f,
  -1.67144850e-01f, -1.36372000e-01f, -7.76146576e-02f, -1.00511529e-01f, -5.25928140e-02f, -3.22792269e-02f, -1.75494105e-01f, -1.83954492e-01f, -2.99226195e-01f, -2.02862188e-01f,
  -4.44064327e-02f, -2.02977195e-01f, 5.36667779e-02f, -1.36366570e-02f, -1.27766520e-01f, 9.30464268e-02f, 6.05927631e-02f, 1.26877263e-01f, 1.75561637e-01f, 4.44159955e-02f,
  1.06451325e-01f, -1.37636918e-04f, -7.32314140e-02f, -1.93376411e-02f, 1.82365716e-01f, 2.08955873e-02f, 3.24099399e-02f, -1.75711900e-01f, -9.56886262e-02f, -5.88983223e-02f,
  5.12927491e-03f, -5.79514243e-02f, 9.31091681e-02f, 1.68213099e-01f, 9.93962735e-02f, -1.41834572e-01f, -7.67632872e-02f, 9.35098454e-02f, -1.02163188e-01f, 6.60130531e-02f,
  1.09913051e-01f, 7.72816641e-03f, 2.29662862e-02f, 8.45335573e-02f, 1.06899984e-01f, 1.11245446e-01f, -2.11003661e-01f, 7.08410069e-02f, -3.43709253e-03f, -1.24075465e-01f,
  1.05743773e-01f, 1.31432623e-01f, 9.17055756e-02f, 9.28490832e-02f, 1.24237351e-01f, 6.88687190e-02f, 5.38714826e-02f, 5.92187839e-03f, -5.98005205e-02f, -8.66990834e-02f,
  5.12672551e-02f, -8.11329260e-02f, -4.13449928e-02f, 9.62119102e-02f, 4.98176143e-02f, 9.87799168e-02f, 1.66354269e-01f, -8.37518126e-02f, 1.53020933e-01f, -1.87695846e-02f,
  2.60209143e-01f, -1.19568579e-01f, 2.24499673e-01f, 1.78075284e-01f, 5.01387641e-02f, 4.43486264e-03f, 8.26346055e-02f, -2.30130889e-02f, 1.81224197e-01f, -6.85710460e-02f,
  -8.81134644e-02f, 6.44091796e-03f, 9.93863419e-02f, -4.18412276e-02f, -1.61515251e-01f, -1.34440780e-01f, -1.44925825e-02f, -5.79329357e-02f, -1.22484416e-01f, -1.65820405e-01f,
  1.17978506e-01f, 2.66870439e-01f, -4.42117564e-02f, -5.74350990e-02f, -6.88743740e-02f, -4.81029935e-02f, 3.49595062e-02f, -1.12899110e-01f, 2.60699932e-02f, 5.56832366e-02f,
  1.23618692e-01f, 1.86310355e-02f, 1.13083296e-01f, -3.04582883e-02f, -4.19360250e-02f, -1.08253270e-01f, -1.59785971e-02f, 1.41672920e-02f, -4.24073152e-02f, -1.60734311e-01f,
  1.32236034e-01f, -1.35027587e-01f, -1.02531789e-02f, 1.89426303e-01f, -7.06607550e-02f, 4.67048772e-02f, 9.40483157e-03f, -4.78090756e-02f, -1.95947532e-02f, -1.89885780e-01f,
  -1.38312146e-01f, -1.45636722e-01f, -3.99132334e-02f, 5.13680372e-03f, 2.41634734e-02f, 4.04921733e-02f, 1.95833772e-01f, 7.61667490e-02f, -6.23423234e-02f, 6.50074566e-03f,
  2.29881421e-01f, 1.55913243e-02f, 5.83310314e-02f, 8.72839689e-02f, 1.67803958e-01f, -3.70629616e-02f, 1.12342380e-01f, -2.99690990e-03f, 9.10378695e-02f, -1.26063034e-01f,
  -3.98574248e-02f, -1.05625257e-01f, 6.68017641e-02f, 8.56701210e-02f, -2.33301092e-02f, -1.20647795e-01f, 5.66221252e-02f, -1.67378541e-02f, -1.24534279e-01f, -3.05588208e-02f,
  -6.94604665e-02f, -6.78982362e-02f, -2.80209184e-02f, 8.10397640e-02f, -1.11534342e-01f, -1.73308775e-02f, 1.19770899e-01f, 1.06311113e-01f, -1.08694978e-01f, -1.12430742e-02f,
  4.09591291e-03f, -1.11881599e-01f, 1.20697081e-01f, 3.79769132e-02f, 1.18673332e-01f, 1.77340005e-02f, 7.61767253e-02f, -1.07587531e-01f, 3.27396467e-02f, 4.01428491e-02f,
  -2.89289746e-03f, -1.02480099e-01f, -4.29810733e-02f, 4.25805449e-02f, 2.53991298e-02f, 7.37672076e-02f, 9.31991637e-02f, 2.51314938e-01f, 3.96758914e-02f, -1.49338335e-01f,
  -1.13820210e-01f, 1.10999353e-01f, 1.25640966e-02f, -2.90693883e-02f, -1.64433539e-01f, -2.00297982e-02f, 3.87277678e-02f, 1.26270324e-01f, 1.20136343e-01f, -1.36538059e-01f,
  -1.30913556e-01f, -1.90779522e-01f, -1.13192715e-01f, -2.31754348e-01f, -2.09142461e-01f, -9.57139060e-02f, -2.60019392e-01f, -1.37812689e-01f, -4.88453954e-02f, 1.65698439e-01f,
  -2.08920464e-01f, -9.83200371e-02f, 3.50429341e-02f, -3.27481478e-02f, 1.07064083e-01f, 1.18893944e-02f, 4.43293527e-02f, 7.52934515e-02f, 1.48027092e-02f, 7.90105574e-03f,
  1.10080428e-01f, -1.04821119e-02f, 1.60603806e-01f, 5.99467009e-03f, 6.00340702e-02f, 1.02982804e-01f, -5.02311327e-02f, 4.99284491e-02f, -7.13588148e-02f, -1.66017171e-02f,
  7.91801419e-03f, -9.07800868e-02f, -1.76207423e-02f, -1.32468700e-01f, 7.19154477e-02f, 6.05968945e-02f, 6.52356446e-02f, -8.73639882e-02f, -3.18720229e-02f, 4.67856936e-02f,
  -1.88182548e-01f, 4.93576378e-02f, -9.34662239e-05f, 9.77944657e-02f, -2.40156557e-02f, -1.11183701e-02f, 2.11161431e-02f, 6.34599850e-02f, -3.38554718e-02f, -4.08374853e-02f,
  1.26513287e-01f, -1.70293480e-01f, 5.74542722e-03f, 3.92949879e-02f, 1.13830961e-01f, -1.71149001e-01f, 7.81912878e-02f, -1.46404728e-02f, -4.26663607e-02f, 1.91112697e-01f,
  1.20714657e-01f, 4.50623978e-04f, -1.71876580e-01f, 3.10351253e-02f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  8.20894837e-02f, 1.37500554e-01f, -3.79001908e-02f, 1.42126143e-01f, 1.60733312e-02f, 7.29665607e-02f, -3.41769704e-03f, -1.00208625e-01f, -1.52823746e-01f, 1.27206981e-01f,
  -9.79212672e-02f, -7.71102533e-02f, -1.65817607e-02f, -1.31503055e-02f, -3.10871433e-02f, 5.60318045e-02f, -6.00576699e-02f, 3.87865230e-02f, 1.56293437e-01f, -1.65105499e-02f,
  2.66641062e-02f, -5.71455546e-02f, -1.21758558e-01f, 7.06573948e-02f, 1.51197538e-01f, 6.12533018e-02f, -1.98401939e-02f, 1.51282176e-01f, 7.67675936e-02f, -1.53916460e-02f,
  -6.66013211e-02f, -7.24405944e-02f, -1.07096411e-01f, 8.37050453e-02f, 8.45609307e-02f, 5.32277748e-02f, 2.59935278e-02f, -8.02229941e-02f, 9.79657006e-03f, 6.77495599e-02f,
  -1.70696564e-02f, -7.45633990e-02f, 9.60866883e-02f, -2.76013166e-02f, -2.40708720e-02f, 1.12056993e-01f, 8.29686522e-02f, 4.46229279e-02f, -2.64754929e-02f, 4.52695079e-02f,
  3.50237638e-02f, -1.12942316e-01f, -7.67253935e-02f, 1.69914197e-02f, -6.39761910e-02f, 1.13705397e-02f, -2.03525592e-02f, 1.87136233e-01f, -9.25937071e-02f, -6.28713518e-02f,
  4.30149212e-02f, -4.36170958e-02f, 3.09889410e-02f, 9.71758068e-02f, 3.88438901e-04f, -1.03503101e-01f, -1.32668957e-01f, -1.57978877e-01f, -9.04939100e-02f, -7.41002038e-02f,
  -4.59006466e-02f, -1.35936365e-02f, 1.59033254e-01f, -6.04491532e-02f, 1.04556754e-01f, -3.55003625e-02f, 3.09901349e-02f, -1.93625409e-02f, 6.73817517e-03f, -7.66971195e-03f,
  -7.83788338e-02f, -7.18745291e-02f, -5.10843210e-02f, -6.19649626e-02f, 1.66888177e-01f, 1.08859979e-01f, 2.48817150e-02f, -1.11127250e-01f, -4.15824503e-02f, -8.31194595e-02f,
  4.01009582e-02f, -2.59273387e-02f, -3.82474996e-02f, -5.68161123e-02f, -4.89788204e-02f, 6.87547848e-02f, 1.06367683e-02f, -4.70454246e-02f, -3.33882831e-02f, 3.92615311e-02f,
  7.92278424e-02f, -5.95920943e-02f, 2.77244579e-02f, 6.07691035e-02f, -8.19591433e-02f, -8.59837532e-02f, 1.17018752e-01f, 1.04358956e-01f, -6.23362809e-02f, 3.53514403e-02f,
  -5.61177693e-02f, 1.15644880e-01f, 1.84297860e-02f, 5.20836823e-02f, -1.30627779e-02f, 1.61235675e-01f, 6.22677281e-02f, 1.32512987e-01f, -7.45404959e-02f, 1.68902889e-01f,
  6.78667845e-03f, 7.28374571e-02f, 1.40705079e-01f, 1.21856824e-01f, -4.61643748e-02f, 1.03310250e-01f, 1.03788204e-01f, 2.78336145e-02f, -3.35898474e-02f, -3.16260792e-02f,
  6.78342581e-02f, 1.59400821e-01f, 4.25891988e-02f, 1.32890821e-01f, -1.01176739e-01f, 2.33896021e-02f, 3.44351530e-02f, 1.12083167e-01f, -1.03538185e-01f, -6.89538429e-03f,
  -1.11484177e-01f, -8.05900395e-02f, -1.20015092e-01f, -7.52392337e-02f, 1.01080881e-02f, -4.26360816e-02f, -3.02521815e-03f, -4.55946811e-02f, -5.56992888e-02f, 9.40088555e-02f,
  1.17772579e-01f, -3.41746286e-02f, 1.50803059e-01f, 3.88852917e-02f, 8.70184787e-03f, 2.42180943e-01f, 5.10499291e-02f, 1.08119160e-01f, -3.86404209e-02f, 1.01369709e-01f,
  -7.07443058e-02f, -4.84068468e-02f, -1.35600254e-01f, 2.36160964e-01f, 9.65225324e-02f, -1.14086851e-01f, -9.47511867e-02f, -5.80741577e-02f, -1.96055584e-02f, -9.90668535e-02f,
  3.67825739e-02f, 1.16577417e-01f, 1.50638059e-01f, 3.46278735e-02f, 1.17819712e-01f, 1.24914132e-01f, -5.47556244e-02f, 1.02051208e-02f, 3.60947214e-02f, 1.08942933e-01f,
  -9.07522812e-02f, 1.59773782e-01f, -3.10487207e-02f, 2.39433162e-02f, 6.13812394e-02f, -5.06540947e-02f, 6.03760704e-02f, -3.61380391e-02f, -5.58881508e-03f, 1.48505718e-02f,
  -8.28679800e-02f, 1.05622537e-01f, 7.98543245e-02f, 1.04339778e-01f, -1.09055333e-01f, 1.01779185e-01f, -1.83205605e-02f, -4.85473089e-02f, -7.20701218e-02f, -1.63033798e-01f,
  -2.61492636e-02f, 3.82244512e-02f, -2.14991853e-01f, -1.14748798e-01f, -3.14371809e-02f, -1.40980661e-01f, 5.13370000e-02f, -2.16731708e-02f, 4.03605551e-02f, 1.12659380e-01f,
  4.44216914e-02f, -2.16603912e-02f, 2.14569755e-02f, -1.02160484e-01f, 2.94346046e-02f, 4.48769927e-02f, 4.11871113e-02f, 1.09622926e-01f, 1.30110353e-01f, 4.96472791e-02f,
  -3.14328596e-02f, -1.25611037e-01f, 9.40996855e-02f, -7.69256055e-02f, 1.02790892e-01f, 1.02278389e-01f, 9.08777416e-02f, 2.78071444e-02f, 7.98084587e-02f, 2.71908417e-02f,
  -7.13314041e-02f, 1.16131961e-01f, -1.31060332e-01f, -1.25815257e-01f, -7.12483078e-02f, -7.84154758e-02f, 6.16121069e-02f, 1.29085734e-01f, 1.39849797e-01f, -1.02013901e-01f,
  -1.32728532e-01f, -1.00924512e-02f, -1.30822398e-02f, -1.21735856e-01f, 1.03785224e-01f, 7.11898729e-02f, -6.65294081e-02f, -1.08150996e-01f, -8.43286067e-02f, 1.07719554e-02f,
  2.81252526e-02f, -1.26446383e-02f, 1.14319980e-01f, -1.15813516e-01f, -1.39243633e-01f, 5.94564481e-03f, 5.81587069e-02f, -7.76455179e-02f, -3.56708653e-02f, -3.18060778e-02f,
  4.15744334e-02f, -8.21595639e-02f, 4.48104478e-02f, 4.58355509e-02f, -4.32592351e-03f, 6.85793385e-02f, -3.75447683e-02f, 3.63644212e-02f, 2.73884018e-03f, 9.15628523e-02f,
  2.67282706e-02f, 2.45284867e-02f, -6.43463992e-03f, 5.68741448e-02f, -1.20963983e-01f, 1.12420619e-01f, 1.23654425e-01f, -9.41895992e-02f, 8.48551095e-02f, -1.16041116e-01f,
  -7.49965385e-02f, -1.89397410e-02f, 3.62270810e-02f, -8.04103166e-02f, 4.91792336e-03f, -8.70199502e-02f, 4.73435782e-02f, -2.28575431e-02f, -1.08443640e-01f, -1.15452707e-02f,
  -1.29003897e-01f, 1.12079024e-01f, 3.55707034e-02f, -1.27518699e-01f, -1.51338624e-02f, 1.79123245e-02f, 2.26139370e-02f, -2.97911633e-02f, -8.75055715e-02f, 7.19909966e-02f,
  3.36290896e-02f, 5.74786924e-02f, 5.57709951e-03f, 3.24045829e-02f, -4.90067378e-02f, -5.14719076e-02f, -5.36512583e-02f, 1.74710285e-02f, -4.06673476e-02f, -9.51044112e-02f,
  -1.16507508e-01f, -5.76612577e-02f, -3.76557349e-04f, 7.38668889e-02f, -1.90160666e-02f, 1.42075513e-02f, -8.60173926e-02f, 7.17181191e-02f, -8.68678093e-02f, 4.43356670e-02f,
  8.74606445e-02f, 8.18807483e-02f, -1.25423893e-02f, 1.54171437e-01f, 9.83350445e-03f, -4.48703282e-02f, -1.56838343e-01f, -3.79226473e-03f, -4.90939058e-02f, 8.55060145e-02f,
  -9.83282700e-02f, -2.38000557e-01f, -1.19200908e-01f, -9.19325575e-02f, 9.51831788e-02f, 1.35919571e-01f, 9.61145088e-02f, -1.87425321e-04f, -4.72578779e-02f, 1.21333756e-01f,
  9.76289511e-02f, 4.78937477e-02f, 4.30258095e-01f, -1.86310876e-02f, -1.42886996e-01f, 3.26974541e-02f, 1.80765182e-01f, -1.68591112e-01f, 5.76143637e-02f, 8.15551169e-03f,
  -3.81716974e-02f, -2.94912718e-02f, -7.67535642e-02f, -4.34366763e-02f, -1.18480176e-02f, 8.02045017e-02f, -1.59211949e-01f, 5.03413640e-02f, 6.23234883e-02f, 4.06924188e-02f,
  -7.37031251e-02f, 1.08023040e-01f, -8.71233791e-02f, -6.50022402e-02f, 3.71015817e-02f, 1.24576159e-01f, 5.74564654e-03f, 7.81293809e-02f, -7.12451637e-02f, 2.33302992e-02f,
  -6.63538128e-02f, -5.40986955e-02f, 1.32684723e-01f, 9.14655253e-02f, -9.46472287e-02f, 1.58534378e-01f, 7.31697259e-03f, 1.14470065e-01f, 7.27377785e-03f, 1.13888592e-01f,
  -1.01998402e-02f, 9.98141989e-02f, -1.05327502e-01f, 1.39470652e-01f, 4.02727127e-02f, 1.16590656e-01f, -1.00203536e-01f, 2.07691416e-02f, -4.41319682e-02f, 2.52914056e-02f,
  -1.35060966e-01f, -7.63403857e-03f, 5.14516011e-02f, 8.77522901e-02f, 3.23082656e-02f, 1.38398796e-01f, 2.74514034e-02f, 2.29491055e-01f, -1.16599061e-01f, 7.21476972e-02f,
  -3.11826337e-02f, -7.63508230e-02f, 8.93752500e-02f, -6.02991283e-02f, -1.75592909e-03f, -6.72628656e-02f, -1.11192450e-01f, 1.42778344e-02f, -7.89335668e-02f, -9.07969922e-02f,
  8.52033570e-02f, -8.47285166e-02f, -1.16104916e-01f, -8.94301459e-02f, 8.61350149e-02f, 1.17834359e-02f, -5.04235737e-02f, 1.17934451e-01f, 8.20701942e-02f, -3.75284627e-02f,
  6.77368119e-02f, 1.29034063e-02f, -1.40681744e-01f, -2.95445342e-02f, 2.66564153e-02f, -8.14817324e-02f, -1.12270050e-01f, 4.82624546e-02f, 5.08210203e-03f, 1.13407083e-01f,
  6.16294295e-02f, 1.07892282e-01f, -6.45874813e-02f, 7.50729665e-02f, 7.60617033e-02f, -3.46736126e-02f, -9.03593525e-02f, 1.17365450e-01f, 4.42514382e-02f, 2.77523678e-02f,
  -8.45422074e-02f, -1.02991112e-01f, -4.12024558e-02f, 1.65344626e-01f, 8.96274298e-02f, -6.08184896e-02f, 1.63413156e-02f, -8.27447549e-02f, 1.30985290e-01f, 2.20116138e-01f,
  4.19607051e-02f, 3.25052083e-01f, 5.04751839e-02f, -5.64755350e-02f, 2.19789818e-01f, 9.39396769e-02f, 1.00309893e-01f, -1.99647974e-02f, 1.63080946e-01f, 1.73916325e-01f,
  -7.77560100e-02f, 8.20078403e-02f, 6.77372664e-02f, 2.15929467e-02f, 8.69643837e-02f, -3.61412726e-02f, 3.22977379e-02f, -3.43619995e-02f, -1.33705169e-01f, 6.68970346e-02f,
  -7.17870221e-02f, -1.47337988e-02f, -5.93782924e-02f, -1.02262899e-01f, -9.84788761e-02f, -1.02944545e-01f, -3.07878926e-02f, 3.16375554e-01f, 3.22639127e-04f, 3.30020301e-02f,
  9.89566892e-02f, 2.88260039e-02f, 4.54844758e-02f, -1.50156766e-01f, -1.09025732e-01f, 9.58766090e-04f, 1.43029347e-01f, -5.00639901e-02f, -3.18455882e-02f, -8.72180760e-02f,
  -1.78891383e-02f, -1.31790921e-01f, 1.08454615e-01f, 1.03609651e-01f, -6.15485907e-02f, -1.34441443e-02f, 2.30295539e-01f, -9.08613577e-02f, 1.44897968e-01f, 2.83113450e-01f,
  -8.00644010e-02f, -6.45925775e-02f, -5.71449474e-02f, 2.00003773e-01f, 8.22055116e-02f, -5.29038981e-02f, -1.67611629e-01f, -7.01062009e-02f, 1.02391057e-01f, -3.74425203e-02f,
  1.21233113e-01f, 6.77072722e-03f, -1.52285052e-02f, 5.00481240e-02f, 2.70454772e-02f, 7.21954694e-03f, 4.79476862e-02f, 5.15575670e-02f, 9.22153145e-02f, -5.12307417e-03f,
  1.16382957e-01f, -1.11001097e-02f, 1.16372891e-01f, -1.08754538e-01f, 6.47750571e-02f, 9.12629589e-02f, 3.26453932e-02f, 8.22387636e-03f, -2.87185386e-02f, 1.26519635e-01f,
  -6.15992658e-02f, 2.03434825e-02f, 3.19226459e-02f, 6.58599511e-02f, 3.44988033e-02f, 4.75385711e-02f, -1.44160360e-01f, -1.02036715e-01f, 1.09715282e-03f, 8.41845050e-02f,
  1.18344307e-01f, -8.26844499e-02f, -1.13149315e-01f, 4.00018841e-02f, -6.65611103e-02f, 2.41340119e-02f, 6.05739057e-02f, 4.77058887e-02f, -1.11972503e-01f, 6.36613443e-02f,
  1.04843289e-01f, 8.44368860e-02f, 2.31424184e-03f, -3.64774913e-02f, -1.02765411e-01f, 9.24577639e-02f, 3.88493463e-02f, -1.57463029e-02f, 2.92079374e-02f, -1.01943418e-01f,
  5.39678298e-02f, 8.91442224e-02f, -1.61187500e-02f, -1.20651186e-01f, -2.81490795e-02f, -1.65992752e-02f, -4.41720001e-02f, 2.06463709e-02f, 8.85867029e-02f, 1.09938726e-01f,
  -1.28741920e-01f, -7.15464586e-03f, 1.00607343e-01f, -1.10306367e-01f, 3.49015109e-02f, 1.67976692e-02f, -2.23379992e-02f, 1.26569241e-01f, 1.61590710e-01f, 1.99063435e-01f,
  -8.66708905e-02f, 9.64927599e-02f, 7.38958195e-02f, 2.25778874e-02f, -2.83156522e-02f, -6.49865568e-02f, -2.68327951e-01f, 6.38192669e-02f, 9.28612426e-02f, -8.36046934e-02f,
  1.05009943e-01f, 3.15786228e-02f, -8.97331834e-02f, 7.50743086e-03f, 4.93637808e-02f, 1.20061142e-02f, -9.08944309e-02f, -3.48918326e-02f, 1.63780572e-03f, -2.73589864e-02f,
  2.34841183e-01f, 2.09719986e-02f, -8.47129244e-03f, 2.63348013e-01f, -1.14722803e-01f, 9.83248055e-02f, -7.20655620e-02f, 4.93196286e-02f, 6.85803667e-02f, 5.53556047e-02f,
  -9.15436894e-02f, 1.45400539e-01f, 1.46312185e-03f, 8.07095915e-02f, 7.67559186e-03f, 5.04002459e-02f, -1.38004199e-01f, -1.14171602e-01f, -5.71046509e-02f, -5.00492342e-02f,
  1.70475677e-01f, 3.45421620e-02f, -2.02144403e-02f, -3.48106995e-02f, 6.57874644e-02f, 8.38387236e-02f, -4.16376516e-02f, 1.11640982e-01f, -9.84127074e-02f, 5.02979755e-03f,
  7.21719414e-02f, -9.21501815e-02f, -1.12503534e-03f, 1.75157469e-02f, 8.00275952e-02f, -1.16624914e-01f, 9.77939069e-02f, -1.16663344e-01f, -1.14080451e-01f, 8.50050598e-02f,
  7.86525458e-02f, -9.31951590e-03f, 1.97692931e-01f, -6.37660734e-04f, 1.01575151e-01f, 9.27338675e-02f, -1.95244923e-01f, 1.74420163e-01f, 8.82045180e-03f, 1.79651737e-01f,
  1.61902308e-01f, -1.62070721e-01f, 1.57727897e-02f, -7.24580735e-02f, -1.40815144e-02f, -1.00346610e-01f, 1.34450227e-01f, 6.78566024e-02f, 2.63927691e-02f, 5.35116605e-02f,
  -7.66072720e-02f, 8.81953537e-02f, 4.88150269e-01f, -1.06235661e-01f, -7.81083256e-02f, -9.66029763e-02f, -1.00243099e-01f, -8.92212391e-02f, 4.28856611e-02f, -1.98043846e-02f,
  3.10500246e-02f, 2.99780238e-02f, 9.35590342e-02f, -1.35655329e-01f, -4.61476333e-02f, 5.62267154e-02f, -1.21578306e-01f, 1.26585871e-01f, 4.65757549e-02f, -6.72698542e-02f,
  -4.63482272e-03f, -2.16502901e-02f, -4.25793231e-02f, -4.63084094e-02f, -1.39883250e-01f, 3.99989337e-02f, 4.34599631e-02f, 5.51408008e-02f, 6.90606833e-02f, -1.23663116e-02f,
  6.48868904e-02f, 7.99889266e-02f, 1.16117053e-01f, -7.16168899e-04f, -4.66171606e-03f, 2.04525903e-01f, 2.92875431e-03f, -1.82265379e-02f, -7.90251866e-02f, 3.35220933e-01f,
  -3.39499600e-02f, 4.96729277e-02f, -3.30783287e-03f, 2.41575450e-01f, 8.24246854e-02f, 7.26821572e-02f, -9.04259011e-02f, -8.07088614e-02f, -1.14472888e-01f, -1.46965325e-01f,
  -1.19265370e-01f, -1.83229167e-02f, 1.74191431e-03f, -4.05851565e-02f, -9.36795324e-02f, -1.14822015e-02f, -9.26403627e-02f, -6.99174479e-02f, 1.03922032e-01f, 1.20200291e-01f,
  -7.78319826e-03f, 1.98077019e-02f, 1.05563208e-01f, 1.27408311e-01f, 9.99121740e-02f, -8.92375261e-02f, 6.13508038e-02f, 5.97894266e-02f, 2.17740480e-02f, 1.19090807e-02f,
  4.31757607e-02f, 1.00617565e-01f, 4.26483043e-02f, -1.21509671e-01f, 1.08094662e-01f, 4.05217856e-02f, -8.59220847e-02f, -3.78312450e-03f, -3.90787236e-02f, 1.55059949e-01f,
  -7.46531412e-02f, -9.53323692e-02f, 7.18014538e-02f, 5.98508902e-02f, -1.33134857e-01f, -1.84484702e-02f, 1.42480791e-01f, 1.34147843e-02f, 1.48585334e-01f, -2.38262136e-02f,
  -7.93969259e-02f, 1.07359670e-01f, -5.08198254e-02f, -2.87640877e-02f, 7.86517411e-02f, -4.32215743e-02f, -1.20546654e-01f, 1.87135860e-01f, 6.21536784e-02f, -7.26929531e-02f,
  1.41951963e-02f, -4.21260670e-02f, 1.79569572e-01f, -8.73698220e-02f, -3.06863729e-02f, 9.33805555e-02f, -6.27687350e-02f, 6.08822182e-02f, 1.06164783e-01f, -9.52485297e-03f,
  1.32040894e-02f, 8.48166794e-02f, 1.38812559e-02f, 2.23303854e-01f, -2.14101851e-01f, 6.39703423e-02f, -8.04445893e-02f, 2.11170942e-01f, 2.51264989e-01f, 5.97869679e-02f,
  -1.31322965e-01f, 2.51787364e-01f, -1.02486283e-01f, 1.70036927e-02f, 6.63225353e-02f, -1.01473115e-01f, -4.20552045e-02f, -1.19743543e-02f, 8.64117742e-02f, 2.04709768e-02f,
  1.92628801e-01f, -1.25845239e-01f, -5.74566387e-02f, -7.14011192e-02f, -1.26138836e-01f, -1.56980455e-01f, -6.95013106e-02f, 1.90972954e-01f, -2.79247784e-03f, 8.04277789e-03f,
  -2.92842742e-02f, -2.30761850e-03f, -9.53132287e-02f, -9.69887599e-02f, -5.25013804e-02f, -2.32755882e-03f, 1.11373588e-01f, 1.16485141e-01f, 1.37662711e-02f, -1.30427584e-01f,
  2.65341699e-02f, 2.08180770e-02f, -1.01794511e-01f, 1.97070576e-02f, -6.86246008e-02f, -5.23084216e-02f, 2.36769855e-01f, -2.13012621e-02f, 1.33786961e-01f, -6.40290901e-02f,
  8.18480998e-02f, -3.32130939e-02f, -6.44061416e-02f, -7.08439648e-02f, -1.93720330e-02f, -1.16741717e-01f, -1.16988212e-01f, 4.00397837e-01f, -7.15626776e-02f, -3.00816614e-02f,
  9.02179927e-02f, 2.50025004e-01f, 3.28770787e-01f, 3.01643938e-01f, 2.42930472e-01f, 2.55445898e-01f, 2.73821384e-01f, 9.47250947e-02f, -9.45154130e-02f, -4.02652957e-02f,
  -2.60970354e-01f, 2.65989393e-01f, 3.25742900e-01f, 4.52311456e-01f, -1.40862793e-01f, 5.35407901e-01f, -1.79087192e-01f, -2.32155155e-02f, 1.23369269e-01f, -9.11590606e-02f,
  5.92981987e-02f, -1.11232728e-01f, -1.52734950e-01f, -1.62929505e-01f, -4.55193669e-01f, -1.14852846e-01f, 1.64127052e-01f, -2.31187288e-02f, -1.25311702e-01f, 1.60282344e-01f,
  -1.22054577e-01f, 1.40914887e-01f, 1.43678971e-02f, 1.08920895e-01f, 1.00738421e-01f, -1.55549468e-02f, -1.16776600e-01f, -1.70222181e-03f, 1.48870066e-01f, 1.44711152e-01f,
  -1.72664464e-01f, 1.18251905e-01f, -9.25770998e-02f, -1.31258994e-01f, -1.38966873e-01f, -3.63751836e-02f, 2.68968809e-02f, -2.61093006e-02f, -1.36570543e-01f, -5.67511395e-02f,
  3.13811749e-01f, -4.49202061e-02f, 1.10385623e-02f, 1.97983339e-01f, -1.14192098e-01f, 1.11696154e-01f, 1.47587642e-01f, -1.81479111e-01f, -1.06431171e-03f, 2.31548473e-02f,
  3.15449089e-02f, 1.21174060e-01f, -3.10539734e-02f, 2.63780542e-02f, 1.92297101e-01f, 2.02992767e-01f, 4.46507931e-02f, -4.74782400e-02f, 8.71742517e-02f, -4.11324129e-02f,
  -7.17580765e-02f, 3.23018059e-02f, 7.43245110e-02f, 1.77147970e-01f, 1.20704375e-01f, -1.54430225e-01f, 7.72670135e-02f, -1.16768084e-01f, -1.92049844e-03f, -5.31083718e-02f,
  -2.51312982e-02f, -7.06561282e-02f, -1.00099318e-01f, -1.22302296e-02f, -9.11675692e-02f, 9.63910669e-02f, -4.71240059e-02f, -7.14703500e-02f, 2.22583979e-01f, 9.86439511e-02f,
  4.78239022e-02f, 2.50472780e-02f, 9.96150151e-02f, 6.61839843e-02f, -5.67232072e-02f, 1.84189081e-02f, -6.65878579e-02f, -5.32451421e-02f, -4.58789244e-02f, 6.19014576e-02f,
  6.19927160e-02f, -4.48495485e-02f, -9.59466845e-02f, -4.01719548e-02f, -5.64609207e-02f, 1.03348516e-01f, -6.65950477e-02f, -7.89137110e-02f, -4.74981628e-02f, 1.13779776e-01f,
  -9.89432484e-02f, -1.11777604e-01f, 1.24735825e-01f, -1.11646585e-01f, -1.10252030e-01f, 8.86061788e-02f, 8.76812115e-02f, 3.23277228e-02f, 2.52742916e-02f, -1.16423085e-01f,
  -6.19290769e-02f, -6.45489478e-03f, -1.26265720e-01f, 1.16566934e-01f, 7.16743118e-04f, 1.00875832e-01f, -2.04170775e-02f, -1.01323634e-01f, 9.10345837e-02f, -7.82179311e-02f,
  1.76131295e-03f, 1.00018144e-01f, -7.59396106e-02f, 1.81583822e-01f, 2.12061390e-01f, 4.76678871e-02f, -2.78164029e-01f, 1.72907896e-02f, -2.53421396e-01f, -7.80385062e-02f,
  -1.29407793e-01f, -1.96238190e-01f, 5.21285832e-02f, -8.36292505e-02f, 1.38093561e-01f, -9.21700895e-02f, 1.57941189e-02f, 1.69529408e-01f, 1.85716942e-01f, 9.12636593e-02f,
  -6.05373122e-02f, 4.29532211e-03f, 4.37543362e-01f, 3.85446809e-02f, -5.89229502e-02f, -5.81165552e-02f, 1.38216257e-01f, -6.95844321e-03f, 1.09731615e-01f, -2.21965790e-01f,
  -4.42355685e-03f, -9.20134261e-02f, -9.85670164e-02f, -2.99604293e-02f, 4.44942079e-02f, 2.99283624e-01f, -3.03814244e-02f, 8.82611126e-02f, -3.73482741e-02f, 4.29351442e-02f,
  5.74146137e-02f, -2.59310249e-02f, -2.40867175e-02f, 3.99283953e-02f, -7.51845464e-02f, -9.20370296e-02f, -8.57779309e-02f, 4.86979727e-03f, -2.76097413e-02f, -2.09521223e-02f,
  1.27931805e-02f, -2.05265388e-01f, 5.89665174e-02f, -8.15894604e-02f, 1.02456793e-01f, 2.88132932e-02f, 2.94876546e-02f, 2.36926734e-01f, 1.59080714e-01f, 2.73471266e-01f,
  -3.16071063e-02f, 1.15740061e-01f, -8.42018425e-02f, 8.47743899e-02f, 1.34282395e-01f, -5.15351184e-02f, 2.44503915e-02f, 1.42992333e-01f, -1.09692015e-01f, -1.02794012e-02f,
  -8.85246992e-02f, -8.40519648e-03f, 2.88551934e-02f, -1.07857034e-01f, -2.51485139e-01f, -1.54428601e-01f, -1.22394249e-01f, -6.18950017e-02f, -8.42179134e-02f, 5.02441935e-02f,
  7.92743172e-03f, 8.98508579e-02f, -1.09143704e-01f, -1.08364727e-02f, 1.14834420e-01f, 3.93718183e-02f, 3.53509396e-01f, -9.08868462e-02f, 4.41156998e-02f, 3.52893174e-02f,
  2.58008689e-02f, 1.22393064e-01f, -8.41618516e-03f, 7.04707429e-02f, -1.56522971e-02f, 4.88877222e-02f, 2.29659416e-02f, -3.62194888e-02f, -1.21931434e-01f, 2.72990048e-01f,
  -1.17768925e-02f, -6.42409548e-03f, 2.20167683e-03f, 6.77708909e-02f, -5.51852770e-02f, -9.23151448e-02f, -7.87562057e-02f, -2.81081703e-02f, 3.55778597e-02f, 6.28777891e-02f,
  -1.65384747e-02f, 1.37290999e-01f, 8.65714531e-03f, -8.70004371e-02f, -2.89927679e-03f, -1.17319450e-01f, 1.08986199e-01f, -4.84752879e-02f, 5.47722131e-02f, 1.22921214e-01f,
  9.75336879e-02f, 1.62964359e-01f, -2.06929799e-02f, 9.86020919e-03f, 1.10453181e-01f, 1.08012237e-01f, -9.42636505e-02f, 1.57789871e-01f, -1.16965435e-01f, 1.71384856e-01f,
  4.12878692e-02f, 1.08543411e-01f, 1.70820206e-01f, -7.50840679e-02f, 2.46914372e-01f, 1.47318244e-02f, 1.26016706e-01f, -1.48453355e-01f, -9.82379839e-02f, 1.43648669e-01f,
  5.78430258e-02f, -2.09779516e-02f, 3.13265696e-02f, -1.27008945e-01f, 1.48583101e-02f, 8.40028077e-02f, 6.60253093e-02f, 3.35173984e-03f, 6.49723783e-02f, 5.57841323e-02f,
  -1.46260643e-02f, -1.32167384e-01f, -8.76666419e-03f, 1.01476647e-01f, -9.98399481e-02f, 1.18730672e-01f, 8.91990438e-02f, 9.94720906e-02f, -2.15639398e-02f, 7.56425411e-02f,
  -1.24978565e-01f, 1.86834812e-01f, -1.07023120e-01f, 1.12940699e-01f, 5.53215109e-02f, -9.26855505e-02f, 6.75192568e-03f, -3.85587886e-02f, 1.83075562e-01f, -8.64913464e-02f,
  4.31909151e-02f, -7.52224494e-03f, 4.70123924e-02f, -4.87290397e-02f, -5.57491519e-02f, -1.23373747e-01f, 1.65913641e-01f, 2.68249102e-02f, 1.08577900e-01f, 1.11165121e-01f,
  1.73240844e-02f, 1.25851333e-01f, 3.17831859e-02f, 1.94727808e-01f, -5.56186885e-02f, -1.21572867e-01f, -1.00351840e-01f, 2.94818282e-02f, -5.47048822e-02f, -1.10131174e-01f,
  1.12488069e-01f, -5.93297929e-03f, 8.70977044e-02f, 1.08046025e-01f, 4.29788679e-02f, 8.75585377e-02f, 4.85449173e-02f, 1.14447117e-01f, -2.01649413e-01f, 1.68098196e-01f,
  -1.23693280e-01f, 2.99769312e-01f, 1.79130390e-01f, 9.86546353e-02f, -8.65766108e-02f, 4.51916829e-02f, -5.32063730e-02f, 6.67329133e-02f, -1.26897618e-01f, -8.07311758e-02f,
  -8.92070606e-02f, -1.35354102e-01f, 5.96172474e-02f, 2.19347477e-02f, 2.22968087e-01f, 7.08103478e-02f, 5.03816865e-02f, -1.33122206e-01f, 1.00131199e-01f, 2.24647410e-02f,
  7.56690279e-02f, -1.12388939e-01f, -3.69170979e-02f, -9.65162367e-02f, -6.55193031e-02f, -1.49857532e-02f, 8.80981386e-02f, 4.60225344e-03f, 6.52029887e-02f, 8.16947222e-02f,
  -4.45335992e-02f, -2.85301879e-02f, -3.54694128e-02f, 5.34920096e-02f, -1.39220908e-01f, -7.49847293e-02f, 7.26635903e-02f, -5.03202295e-03f, 1.13866068e-01f, -6.08183071e-02f,
  5.96515909e-02f, 6.21969439e-02f, 1.21054046e-01f, 4.13501337e-02f, -4.97165993e-02f, -4.70555425e-02f, 9.74458009e-02f, -9.72227454e-02f, -1.15096815e-01f, 1.59126282e-01f,
  -7.39036724e-02f, 3.00223529e-01f, -1.31437957e-01f, -1.15741640e-01f, -1.93972047e-02f, 1.98683083e-01f, 1.08671188e-01f, -8.59056041e-02f, 7.88443312e-02f, 1.52948335e-01f,
  5.91514669e-02f, 1.61857978e-01f, -6.73455968e-02f, 9.36272964e-02f, -1.13135576e-02f, 8.82185623e-02f, 1.02547392e-01f, -1.77021340e-01f, -1.23027816e-01f, -1.34496793e-01f,
  7.38019869e-02f, -4.69309278e-03f, 1.10134501e-02f, 1.11446790e-02f, -8.22534692e-03f, -6.60907626e-02f, -6.88182488e-02f, 5.82201518e-02f, 1.23638637e-01f, 7.05014318e-02f,
  -8.31288844e-02f, 5.83778322e-02f, -5.32971285e-02f, -7.46639222e-02f, -2.02897098e-02f, 4.56346609e-02f, 1.28428772e-01f, 1.05417699e-01f, -7.27552027e-02f, 8.51906687e-02f,
  -8.39941651e-02f, 8.03759173e-02f, 6.04776256e-02f, 1.03265755e-01f, 1.25594988e-01f, -9.66960117e-02f, 6.93978509e-03f, -9.26231295e-02f, -6.10449612e-02f, 3.32749635e-02f,
  1.14408635e-01f, -5.03953882e-02f, 1.82232540e-02f, 1.01980984e-01f, -2.76617110e-02f, -1.05527699e-01f, -4.27735671e-02f, 6.90865442e-02f, 2.31297296e-02f, -1.42036796e-01f,
  -4.17555608e-02f, -5.68059552e-03f, -9.55577008e-03f, 1.17358655e-01f, -1.44659892e-01f, 5.97042330e-02f, -2.80477405e-02f, -9.96269658e-02f, 1.56637914e-02f, 1.20043509e-01f,
  -3.71996686e-02f, 1.02682397e-01f, 1.48478419e-01f, -6.84619099e-02f, -4.58505079e-02f, -9.85141769e-02f, 3.84641364e-02f, 1.51992902e-01f, -7.87881240e-02f, -1.42678216e-01f,
  -1.92627273e-02f, -6.49114996e-02f, 5.71400684e-04f, -5.58717325e-02f, -5.23649063e-03f, 7.65082166e-02f, -1.08777210e-01f, 3.30848247e-02f, -9.20142978e-02f, 1.25415415e-01f,
  3.87435853e-02f, 4.19996828e-02f, 2.01125816e-01f, -6.40907884e-02f, -5.41106947e-02f, 9.35285445e-03f, 6.93223700e-02f, -1.09795876e-01f, 1.27203194e-02f, -7.87997246e-02f,
  4.63042781e-02f, 2.89261881e-02f, 8.31009746e-02f, -1.14507392e-01f, 7.95511380e-02f, 4.52425219e-02f, 9.46095039e-04f, 1.79851912e-02f, 8.36968049e-02f, 4.59156297e-02f,
  -1.28910735e-01f, -2.42632418e-03f, 8.90438855e-02f, -5.37116677e-02f, 7.11714625e-02f, 5.34084737e-02f, -8.36811364e-02f, 3.87994573e-02f, 6.49446696e-02f, -9.78575274e-03f,
  6.13311976e-02f, -1.12578742e-01f, -8.63547530e-03f, -2.55500991e-02f, 4.69900966e-02f, -5.18582724e-02f, -1.22235991e-01f, 2.00542863e-02f, -1.10775277e-01f, 5.86223528e-02f,
  5.58261015e-02f, -1.14120748e-02f, -3.24860290e-02f, -1.72680169e-02f, 1.39994413e-01f, -9.36072841e-02f, 4.68599796e-02f, -9.88084897e-02f, 1.21911764e-01f, -8.93648267e-02f,
  -3.27536352e-02f, -8.14853758e-02f, -1.70179754e-02f, 3.68313715e-02f, -4.37142514e-02f, -4.50177751e-02f, -1.25058442e-01f, -3.32370810e-02f, -9.71437618e-02f, 1.18566111e-01f,
  5.71708269e-02f, 1.82206854e-02f, 1.05569988e-01f, 1.84977502e-02f, 9.64606479e-02f, 6.55069649e-02f, -4.94671389e-02f, -4.83606309e-02f, -8.55735037e-03f, 8.32591876e-02f,
  4.36993688e-02f, -5.92689253e-02f, -9.95077789e-02f, -4.10459973e-02f, 5.86908720e-02f, -6.29090369e-02f, 1.01660490e-01f, 8.87239426e-02f, 5.35166711e-02f, -1.05312988e-01f,
  -1.41481198e-02f, 6.89736232e-02f, -1.33009385e-02f, 7.86921531e-02f, 5.81964701e-02f, 7.14516565e-02f, -4.98645119e-02f, 8.93007368e-02f, 2.42169965e-02f, -2.31722202e-02f,
  -5.88412322e-02f, -9.86109078e-02f, 6.97831213e-02f, -5.09422161e-02f, 5.46755604e-02f, -4.89409489e-04f, -7.07615465e-02f, 9.23786908e-02f, 1.90981980e-02f, -4.34333235e-02f,
  -1.38721704e-01f, 9.22342166e-02f, 6.66517168e-02f, 4.98679988e-02f, 5.88479489e-02f, 1.05400793e-01f, 5.63932061e-02f, -1.70914643e-02f, 1.36275142e-01f, 8.12210888e-02f,
  2.08633263e-02f, 1.06542632e-01f, 2.60217022e-02f, -9.54718050e-03f, 5.19493483e-02f, 2.55224854e-01f, 3.58564347e-01f, -2.17484444e-01f, -3.14517260e-01f, -2.03381121e-01f,
  -3.12645584e-02f, -2.51312852e-01f, 1.49331063e-01f, 3.99551503e-02f, 1.10499248e-01f, 6.86279759e-02f, 3.29185389e-02f, -3.56302112e-02f, 1.26259789e-01f, -6.29753843e-02f,
  4.78931963e-01f, 2.38121469e-02f, 2.24301070e-02f, 9.11553130e-02f, 5.54209277e-02f, -2.02973872e-01f, 1.02088824e-01f, -2.36007199e-02f, 1.44267410e-01f, 8.54905844e-02f,
  8.57945383e-02f, 2.58016121e-02f, 9.75458398e-02f, 2.50360012e-01f, -1.05687171e-01f, -4.70780693e-02f, 2.66991019e-01f, -9.07103866e-02f, -2.11020336e-02f, -7.24571431e-03f,
  3.66914347e-02f, -3.47266789e-03f, 1.07269131e-01f, 1.13312207e-01f, -9.67771485e-02f, 1.19781576e-01f, 4.91229296e-02f, 8.80767405e-02f, 7.81428441e-03f, 1.94135010e-01f,
  1.53542981e-01f, 6.80385856e-03f, -1.31495213e-02f, 3.00510049e-01f, 1.45144701e-01f, -9.72728059e-02f, 6.43640459e-02f, -1.61510557e-01f, -1.34236170e-02f, -5.40666431e-02f,
  -2.00006533e-02f, 2.24464126e-02f, -3.49764228e-02f, 1.05564766e-01f, -1.50286257e-02f, 7.27827614e-03f, -3.04567330e-02f, 1.57391906e-01f, 2.26324741e-02f, 7.17493445e-02f,
  6.55606203e-03f, 3.01124388e-03f, 9.56775025e-02f, -2.48877727e-03f, 1.78669691e-02f, 4.65398841e-02f, 3.93716432e-02f, -8.66735876e-02f, 4.67538610e-02f, -6.42756894e-02f,
  5.17938547e-02f, 9.93980560e-03f, 2.01091599e-02f, 1.08003207e-01f, 1.04910925e-01f, 8.02750736e-02f, 5.18677011e-02f, 7.19364360e-02f, -8.68050531e-02f, -7.69301318e-03f,
  -7.75904730e-02f, 9.41771194e-02f, 7.02576041e-02f, -4.99169752e-02f, 9.26501527e-02f, 5.86710013e-02f, -1.11895964e-01f, -1.03813872e-01f, 4.16547433e-02f, -6.00077845e-02f,
  1.10734642e-01f, -1.11363612e-01f, 1.17245965e-01f, 1.09156244e-01f, 9.33520794e-02f, 1.39985317e-02f, 9.38706696e-02f, -1.47389006e-02f, 2.06229128e-02f, 2.25006882e-02f,
  -6.82547316e-02f, 2.10593753e-02f, 9.81674343e-02f, 1.17334343e-01f, -3.88726816e-02f, 7.06057390e-03f, -1.27810448e-01f, 4.23109904e-02f, -8.96231383e-02f, 2.77358945e-02f,
  -4.15813811e-02f, -8.86561796e-02f, -4.31288891e-02f, -1.22990616e-01f, 5.09776883e-02f, -2.13832172e-04f, 3.85998368e-01f, 2.77840674e-01f, 2.16746479e-01f, 2.98380256e-01f,
  3.19043934e-01f, 2.19515324e-01f, -3.67472917e-02f, 2.27991417e-01f, 1.68872662e-02f, 3.20757300e-01f, 1.87366322e-01f, -2.80112494e-02f, -2.91263871e-02f, 1.26109764e-01f,
  -2.06883764e-03f, 3.25736366e-02f, 9.20321047e-02f, -1.70929521e-01f, 8.08336586e-02f, -8.42936635e-02f, -1.14566997e-01f, 1.18815213e-01f, 1.06367104e-01f, 3.48906554e-02f,
  -1.26682311e-01f, -1.04717515e-01f, -6.98918700e-02f, -1.10224947e-01f, 4.24159020e-02f, 1.60644487e-01f, 5.15306406e-02f, 1.50883570e-01f, 9.43698511e-02f, 3.00148185e-02f,
  -1.32938087e-01f, -8.08370784e-02f, 1.04129151e-01f, 1.27578288e-01f, 1.40592411e-01f, -7.70746469e-02f, 1.42866626e-01f, 6.68323636e-02f, -7.91560858e-02f, 2.55135056e-02f,
  -2.60787047e-02f, -1.26430139e-01f, 1.98621452e-02f, -6.97188675e-02f, 1.37975499e-01f, -9.73154604e-02f, 1.39494628e-01f, -3.45914103e-02f, 3.63269858e-02f, -1.26647577e-01f,
  -1.25785515e-01f, 1.30527645e-01f, -1.45187154e-01f, -5.29805478e-03f, -5.69306985e-02f, 1.98326260e-01f, -1.38083503e-01f, -9.21723619e-02f, 1.34732485e-01f, 2.22013369e-01f,
  -8.87963250e-02f, 3.98635093e-05f, 8.99821594e-02f, 1.88451886e-01f, -7.79083818e-02f, 1.07247680e-02f, 6.23593107e-02f, 5.64981513e-02f, 1.96205765e-01f, -7.82795474e-02f,
  -5.03373370e-02f, -8.44144449e-02f, 1.11060686e-01f, -1.25943780e-01f, -2.43835766e-02f, -4.90299985e-02f, 7.83282071e-02f, -1.02072150e-01f, 5.71224764e-02f, 1.04851663e-01f,
  -6.34682924e-02f, -3.07330750e-02f, 4.72946418e-03f, -3.72483432e-02f, 1.17335677e-01f, -4.59487773e-02f, 1.45439547e-03f, -3.31022777e-02f, -4.06170227e-02f, 4.48054411e-02f,
  2.05873083e-02f, 1.20779350e-01f, 1.05036356e-01f, 8.35743919e-02f, -1.90813281e-02f, -8.43130052e-02f, 5.37908927e-04f, -6.79620309e-03f, 3.10762320e-02f, -9.61544514e-02f,
  1.66588441e-01f, -4.15508561e-02f, -5.61791845e-02f, 8.70747864e-03f, -3.37787382e-02f, 5.29844686e-03f, -8.42063576e-02f, 2.73147039e-02f, 8.57817680e-02f, -3.81922023e-03f,
  -5.76036312e-02f, 2.02382550e-01f, -4.68922332e-02f, -5.36462516e-02f, 6.81701228e-02f, 1.71832606e-01f, 1.24625944e-01f, 6.91474676e-02f, -3.68992751e-03f, -7.49307051e-02f,
  -4.19012718e-02f, -1.09638505e-01f, 7.95359761e-02f, 1.19041391e-01f, -1.07804211e-02f, 4.15108502e-02f, 1.36414384e-02f, 1.26925439e-01f, -4.18746620e-02f, 6.10821042e-03f,
  -1.32497504e-01f, -3.67781334e-02f, -1.87999308e-01f, 6.23739697e-02f, -3.11567504e-02f, -6.30825460e-02f, -3.02621871e-02f, 2.86529213e-02f, 9.43482220e-02f, 3.08911595e-02f,
  -4.37936075e-02f, -8.10447782e-02f, 6.53924346e-02f, -1.19602859e-01f, -1.10426135e-02f, -9.68013480e-02f, -5.22417240e-02f, -9.44106188e-03f, 2.27002829e-01f, 1.70872256e-01f,
  1.48842037e-01f, 3.21932226e-01f, 7.90829137e-02f, -9.27440524e-02f, 3.45412269e-02f, 4.43133377e-02f, -3.39016095e-02f, -3.96055579e-02f, 4.30108011e-02f, 2.34910041e-01f,
  -6.74671843e-04f, -1.17677152e-01f, -1.80775207e-02f, 6.77362904e-02f, -1.06264940e-02f, -6.64485246e-02f, -7.38705397e-02f, -3.95688042e-02f, -6.05859561e-03f, 4.82664593e-02f,
  7.24930987e-02f, -9.09817126e-03f, 1.39280129e-02f, -6.44328818e-02f, -3.47061232e-02f, 7.53762349e-02f, 3.20401130e-04f, 2.01760799e-01f, 4.03829962e-02f, -9.69580039e-02f,
  5.11837564e-02f, -5.90451770e-02f, 1.98894456e-01f, 1.34716868e-01f, 6.24191307e-04f, 3.28184254e-02f, -4.37767357e-02f, 1.72990322e-01f, 1.04390338e-01f, 2.07990974e-01f,
  1.56570882e-01f, 1.87420413e-01f, 1.13250777e-01f, -1.56269461e-01f, 1.11324102e-01f, -9.00169909e-02f, 2.62256991e-02f, -1.36571392e-01f, -4.09138277e-02f, 2.08067462e-01f,
  -1.19113915e-01f, 1.42997708e-02f, -7.25173578e-02f, -1.32317260e-01f, 1.11708306e-01f, -1.00762188e-01f, -1.58861205e-01f, -4.91850600e-02f, 1.12409957e-01f, -7.80384988e-02f,
  -8.34005028e-02f, -2.72252355e-02f, 1.58811510e-01f, 3.91756231e-03f, -1.00480415e-01f, 5.03642522e-02f, -5.73639665e-03f, 1.54069409e-01f, 1.68162808e-01f, 3.12272087e-02f,
  6.10191002e-02f, 1.74202323e-01f, -1.19886212e-01f, 5.68517074e-02f, -6.08599596e-02f, -1.19229056e-01f, 1.12078093e-01f, 4.30471562e-02f, 5.90629205e-02f, 7.16720521e-02f,
  1.41232356e-01f, -1.16135098e-01f, 1.39878631e-01f, -1.64074525e-02f, -1.35877449e-02f, -1.03330694e-01f, 1.53184474e-01f, 7.46683031e-02f, -4.56078649e-02f, 2.26428658e-01f,
  -9.20327753e-02f, 2.94385105e-02f, -6.91489279e-02f, 1.17071226e-01f, 1.41931459e-01f, 2.38134284e-02f, -8.32136646e-02f, -1.18158728e-01f, 6.93078190e-02f, -1.29771173e-01f,
  2.04222918e-01f, -7.26175383e-02f, -3.05892471e-02f, -9.71267279e-03f, 1.27707124e-02f, 6.36910871e-02f, -6.62073120e-02f, -1.24540552e-01f, 8.62829611e-02f, -3.93324345e-02f,
  -1.51315495e-01f, -4.92107756e-02f, -4.46059592e-02f, -1.26933366e-01f, 4.92857061e-02f, -3.39361280e-02f, 1.23182554e-02f, 2.36398410e-02f, -6.42193779e-02f, -7.36503676e-02f,
  4.76690009e-02f, -9.41459313e-02f, -4.27898057e-02f, 9.11723450e-02f, 1.45618677e-01f, -2.19023842e-02f, 7.32283816e-02f, 2.27856282e-02f, -8.82930458e-02f, 3.84288915e-02f,
  -6.17048517e-02f, -4.13078666e-02f, -2.59722560e-03f, 1.01279616e-01f, 4.09425646e-02f, 8.00168365e-02f, -6.81130290e-02f, 5.62388226e-02f, 5.56312837e-02f, -8.27816799e-02f,
  1.19098544e-01f, 1.18060835e-01f, 1.01774335e-01f, 9.90678295e-02f, 6.19458929e-02f, 1.09046958e-01f, -3.26002836e-02f, 4.72552329e-02f, -4.23962437e-02f, -3.50473598e-02f,
  -1.55517220e-01f, 6.90289587e-02f, -1.27790377e-01f, -8.02008808e-02f, 1.34492889e-02f, -1.00651309e-01f, 7.19821677e-02f, 8.12150091e-02f, -1.43294809e-02f, 5.34757040e-02f,
  6.29035607e-02f, 9.21089724e-02f, 2.75100432e-02f, 8.73299316e-02f, -8.21018443e-02f, 1.12039879e-01f, 1.67230591e-01f, 2.55944163e-01f, 1.58567294e-01f, 2.76394665e-01f,
  2.16915935e-01f, 4.08792906e-02f, 3.79202962e-01f, 1.20535880e-01f, 3.79761696e-01f, -2.44371239e-02f, 5.46344332e-02f, 3.76961492e-02f, -4.77747545e-02f, 4.40025292e-02f,
  7.59459957e-02f, 7.13799298e-02f, 2.25212485e-01f, -1.47331506e-01f, -1.29748538e-01f, -9.06585604e-02f, 2.17767507e-02f, -5.61041534e-02f, 1.71856552e-01f, 8.81446674e-02f,
  -1.92583147e-02f, -9.31746513e-02f, 6.92359284e-02f, -2.27807716e-01f, 8.90862346e-02f, 3.99798483e-01f, 1.05257802e-01f, -6.30405545e-03f, -9.36131775e-02f, 7.40305111e-02f,
  -3.65990065e-02f, -1.60491273e-01f, 5.33440784e-02f, 1.60201162e-01f, 1.51254788e-01f, -1.42796695e-01f, 1.05307750e-01f, 2.30578822e-03f, 1.52572200e-01f, 7.88311288e-03f,
  -7.47914612e-02f, 9.86947119e-02f, 5.11004813e-02f, -1.72555387e-01f, 1.17616199e-01f, -1.71534136e-01f, 1.06839433e-01f, 2.77517021e-01f, -4.62575443e-02f, -1.17077291e-01f,
  -1.84737161e-01f, 2.75068969e-01f, -2.93994173e-02f, -1.01575822e-01f, -1.75386921e-01f, -1.42813757e-01f, 4.46376018e-02f, -8.60500783e-02f, 3.35052460e-01f, 1.17732711e-01f,
  2.03550205e-01f, 3.31541002e-01f, 3.41671370e-02f, -6.21334761e-02f, 1.40998945e-01f, 2.98097014e-01f, -4.10030961e-01f, -2.38602102e-01f, -5.37296295e-01f, 4.39001530e-01f,
  2.13929996e-01f, 3.44015181e-01f, -1.07012659e-01f, 5.99723101e-01f, -1.28782019e-01f, 4.33915704e-02f, -3.00785003e-04f, -1.06097452e-01f, 1.02765709e-01f, -9.39767808e-02f,
  -1.73739180e-01f, 4.39517386e-03f, -1.55509517e-01f, -8.81668832e-03f, 1.36590764e-01f, -1.78978771e-01f, 1.17932573e-01f, 3.00747395e-01f, 4.28644978e-02f, -7.93256238e-02f,
  -7.01915100e-02f, -5.88961355e-02f, 1.96196452e-01f, -2.65465509e-02f, 4.86347936e-02f, -6.27790019e-02f, 1.68502554e-01f, 3.07882011e-01f, -1.97354272e-01f, 7.12688938e-02f,
  -1.23301022e-01f, -7.89608881e-02f, -1.46548018e-01f, -7.86053017e-02f, -4.78399247e-02f, -1.45227241e-03f, 4.94533740e-02f, -1.26538798e-01f, 1.41672403e-01f, 1.22524276e-01f,
  -1.22499689e-01f, -4.65930142e-02f, 8.17852328e-04f, 1.00418240e-01f, -4.62437188e-03f, -2.77212143e-01f, -8.54212046e-02f, 9.03293937e-02f, 2.02221736e-01f, 7.00583100e-01f,
  -7.54597783e-02f, -1.29338214e-02f, -8.34399760e-02f, 3.41614991e-01f, -6.92813993e-02f, 7.40492269e-02f, 1.41711636e-02f, 1.14546202e-01f, 4.51683961e-02f, -1.24518508e-02f,
  -5.68522178e-02f, -2.21791923e-01f, -2.43808702e-01f, -1.44112840e-01f, -1.45571738e-01f, -7.59047344e-02f, 9.40631032e-02f, -2.52656657e-02f, 5.32265604e-02f, 1.20887652e-01f,
  -1.58891857e-01f, -3.12860273e-02f, 1.62809283e-01f, -4.33057621e-02f, -1.89716183e-03f, 7.77913816e-03f, -9.66300294e-02f, -7.47104809e-02f, 1.34799376e-01f, 1.78709310e-02f,
  1.82909951e-01f, 3.33621770e-01f, 1.04611360e-01f, -7.77870743e-03f, -1.26473695e-01f, -1.25502631e-01f, 5.98928668e-02f, 1.48788810e-01f, -6.75866306e-02f, 1.25748381e-01f,
  1.68734983e-01f, 9.97772291e-02f, 3.70840803e-02f, -2.77247950e-02f, -1.62788570e-01f, -1.30862594e-01f, -5.90267144e-02f, 4.08350192e-02f, 1.10360816e-01f, 2.61686686e-02f,
  3.36607695e-02f, -5.97004183e-02f, 4.57111858e-02f, -3.33769545e-02f, -1.36299253e-01f, -3.42280045e-02f, -1.38472110e-01f, 1.50483266e-01f, 1.30617827e-01f, -7.39420112e-03f,
  5.22020049e-02f, 1.37799412e-01f, 1.79447502e-01f, 1.40770242e-01f, -1.30264923e-01f, 8.02276656e-02f, -1.33651569e-01f, -3.64687592e-02f, -6.78090155e-02f, 9.95812379e-03f,
  3.88578996e-02f, -1.22274077e-02f, -1.34557143e-01f, 8.18467215e-02f, 3.02355569e-02f, 3.01388390e-02f, 9.54714641e-02f, -4.88531590e-02f, 1.38477921e-01f, 1.40243918e-01f,
  7.63947070e-02f, 8.30514580e-02f, 8.27391297e-02f, -8.70346054e-02f, 5.19023649e-03f, 3.89486961e-02f, 5.77158295e-02f, 1.03186727e-01f, -1.72634982e-02f, 8.10380057e-02f,
  -9.36240703e-02f, 2.80375984e-02f, -2.08865516e-02f, 9.20082107e-02f, -3.33736092e-02f, 4.41151448e-02f, -1.21422280e-02f, 4.92807440e-02f, 1.00516133e-01f, -9.50674042e-02f,
  2.10548416e-02f, -7.03919530e-02f, 1.87382679e-02f, -4.74696839e-03f, -5.69252521e-02f, 1.27250344e-01f, -9.49291959e-02f, -1.08406194e-01f, -7.59349838e-02f, -2.21173670e-02f,
  3.66470627e-02f, -4.17843024e-04f, -1.84202492e-02f, -6.58304915e-02f, 1.25916541e-01f, 3.50315794e-02f, -2.75638420e-03f, -7.31536970e-02f, 8.43936927e-04f, -1.78610738e-02f,
  9.11052525e-02f, 5.84950559e-02f, -4.46439609e-02f, 2.99799442e-02f, -9.51838344e-02f, -5.12671694e-02f, 1.05235346e-01f, -4.41626012e-02f, 8.79661366e-02f, 3.89306545e-02f,
  2.15373263e-02f, 9.70624201e-03f, 5.94184659e-02f, 1.00136831e-01f, -1.17657855e-01f, -4.83990414e-03f, -5.47852069e-02f, -1.41031742e-01f, 8.98972154e-02f, -4.10076231e-02f,
  1.83500022e-01f, -1.61125749e-01f, -4.28037792e-02f, 9.87427458e-02f, -9.62100178e-02f, 2.89194100e-03f, -1.21150445e-02f, 5.79123423e-02f, -1.14589460e-01f, -9.37045664e-02f,
  9.38889012e-02f, -1.55376801e-02f, 1.22783612e-02f, 7.49207512e-02f, -7.01162266e-03f, 6.70799613e-02f, -3.86945866e-02f, 1.45846993e-01f, -4.96429503e-02f, 5.68266846e-02f,
  1.09684646e-01f, 1.82671949e-01f, -3.13394330e-02f, 1.34089857e-01f, -9.74445716e-02f, -4.01043408e-02f, 4.68330570e-02f, -2.12808419e-02f, -4.03504223e-02f, -5.68515286e-02f,
  -4.38390486e-02f, 2.67622545e-02f, 9.23147425e-03f, 2.28596218e-02f, -3.91443931e-02f, 2.64123990e-03f, 1.29094526e-01f, -9.56388414e-02f, 5.62669523e-02f, -1.48181487e-02f,
  2.29975432e-02f, -9.05641839e-02f, 6.07643053e-02f, 2.59308487e-01f, 8.58039111e-02f, 1.05988733e-01f, 5.60399517e-02f, -6.00344595e-03f, 7.52823353e-02f, -1.03681535e-01f,
  1.24440640e-01f, -1.27588913e-01f, -4.96290289e-02f, 8.71030465e-02f, 5.33390306e-02f, -6.90345913e-02f, -1.17083654e-01f, 9.25371125e-02f, 4.80684415e-02f, -1.28707796e-01f,
  1.20460309e-01f, 1.70332164e-01f, 5.36310151e-02f, -5.47736026e-02f, -1.57782108e-01f, 1.50070950e-01f, -1.86434910e-02f, 1.52083069e-01f, -4.13336605e-02f, 8.26799721e-02f,
  -3.28358699e-04f, -9.90812480e-02f, 9.42726657e-02f, 2.41442900e-02f, -5.40846549e-02f, 7.01380288e-03f, -4.65771556e-02f, -1.00048289e-01f, -6.43952638e-02f, 1.70641509e-03f,
  1.99279934e-02f, 7.88790062e-02f, 8.65969807e-02f, 7.98347667e-02f, 5.04158847e-02f, -1.05815856e-02f, -6.36727214e-02f, -1.83025617e-02f, 1.35820270e-01f, -2.96042413e-02f,
  -6.11131545e-03f, -2.04869267e-03f, 1.15173370e-01f, 3.83827128e-02f, 7.29928911e-02f, 1.36606559e-01f, 4.89300154e-02f, -1.75152533e-02f, -8.68953466e-02f, 1.10788807e-01f,
  1.09134540e-01f, 4.27961163e-02f, -1.07296899e-01f, 1.06513269e-01f, 1.01813458e-01f, 4.78083007e-02f, 3.27694900e-02f, 5.75017259e-02f, 6.33989796e-02f, 4.39423509e-02f,
  -1.07480101e-01f, -2.04000901e-02f, -1.43427914e-02f, -1.95224676e-02f, 6.56318218e-02f, 1.11480877e-01f, -9.70317796e-02f, -6.30512834e-03f, -1.06220908e-01f, 1.19332656e-01f,
  8.41212738e-03f, 1.01645812e-01f, 9.79248434e-02f, -1.05208546e-01f, -8.82627070e-02f, 2.38914508e-03f, 1.60344735e-01f, -3.47412936e-02f, 1.56905994e-01f, -1.16253741e-01f,
  9.72404480e-02f, -1.12114042e-01f, -2.78133829e-03f, 1.11545864e-02f, 1.10659704e-01f, 4.84507345e-02f, 3.61737162e-02f, -7.91539401e-02f, -1.19398221e-01f, -2.83469222e-02f,
  1.21953316e-01f, -1.43352384e-02f, 1.21334560e-01f, -1.17554873e-01f, 3.85509245e-02f, 1.97733920e-02f, 9.14047956e-02f, -1.22519396e-01f, 1.98409297e-02f, 1.11957164e-02f,
  5.28178327e-02f, 7.64657781e-02f, -6.43750802e-02f, 7.58445561e-02f, -3.81066389e-02f, 6.41806945e-02f, 6.91083074e-02f, 8.49874616e-02f, 2.40498334e-02f, -1.36271968e-01f,
  7.78130442e-02f, -7.27863982e-02f, 3.87049802e-02f, 8.55297297e-02f, 1.82367302e-02f, -9.79701057e-02f, -9.02227685e-02f, 9.79663953e-02f, 9.10893902e-02f, -1.04722738e-01f,
  -6.93293959e-02f, 7.73110166e-02f, 2.58441977e-02f, 4.58170325e-02f, 1.24212019e-02f, 1.70892581e-01f, 5.74400462e-03f, -8.10898915e-02f, 1.12158403e-01f, -5.52319288e-02f,
  1.03745729e-01f, 3.86981219e-02f, -5.33762388e-02f, -4.47436981e-02f, 3.98956947e-02f, 1.54071778e-01f, 3.17494362e-03f, -1.18917681e-01f, 2.05222722e-02f, 8.85056704e-03f,
  -7.93813020e-02f, -8.56583752e-03f, 1.93606079e-01f, 1.47948951e-01f, 9.67705026e-02f, 1.33588314e-02f, 1.04889404e-02f, -3.51954848e-02f, -1.43888772e-01f, 4.49433774e-02f,
  4.78994958e-02f, -1.03027999e-01f, -8.88112653e-03f, -7.67603144e-02f, 1.52836278e-01f, -1.51508432e-02f, -6.66279197e-02f, -6.63851053e-02f, -2.45792922e-02f, 1.21118098e-01f,
  -8.76596048e-02f, -1.41629532e-01f, -5.24231680e-02f, 2.82543391e-01f, -5.81675321e-02f, 2.68958360e-02f, -4.84739505e-02f, 1.08925909e-01f, 1.09451994e-01f, -1.49198249e-01f,
  6.78772014e-03f, -7.70451576e-02f, 2.23762050e-01f, 7.14882314e-02f, 9.84868929e-02f, -9.48329177e-03f, 1.45132452e-01f, -1.38948768e-01f, -3.54427062e-02f, 8.03350434e-02f,
  5.69240414e-02f, 1.05638064e-01f, 1.92965120e-01f, -1.39063656e-01f, -6.18755259e-03f, 1.89988628e-01f, -3.32940929e-02f, -1.72485616e-02f, -1.03870928e-01f, 1.73502326e-01f,
  4.19140980e-02f, -1.18236013e-01f, -1.20185465e-01f, 4.51209620e-02f, -7.77442008e-02f, -6.77045137e-02f, 1.51026011e-01f, -6.79666921e-02f, 4.76820059e-02f, 9.65589061e-02f,
  1.35674745e-01f, 1.48278847e-01f, 1.52638957e-01f, 5.95065318e-02f, -6.86617494e-02f, -3.06000803e-02f, -1.12621121e-01f, -3.64980064e-02f, -1.10164076e-01f, -9.53317508e-02f,
  1.99416075e-02f, -6.49246871e-02f, -4.32828106e-02f, 1.08161978e-01f, -2.07425822e-02f, -8.02242905e-02f, -8.03218409e-02f, 1.11327097e-01f, 7.63079077e-02f, 8.34057927e-02f,
  1.92245424e-01f, -1.02785431e-01f, 2.15935167e-02f, 4.31520641e-02f, -8.73612016e-02f, 6.18243292e-02f, -2.73605231e-02f, -4.65243720e-02f, 3.52613591e-02f, 1.25130475e-01f,
  2.19764411e-02f, -6.21412545e-02f, 7.84826502e-02f, -9.53613315e-03f, -1.16456136e-01f, 4.02447581e-02f, 3.48825902e-02f, 7.79334307e-02f, -1.21138312e-01f, -1.32890284e-01f,
  -1.21571496e-02f, -9.62535888e-02f, 1.56010664e-03f, 8.98366049e-02f, 1.23386651e-01f, -1.12576939e-01f, -1.27598971e-01f, 5.21468297e-02f, -4.37316038e-02f, -2.92958971e-02f,
  5.99655928e-03f, 1.33272428e-02f, -5.41896969e-02f, -2.97510047e-02f, 4.13473137e-02f, -8.38872716e-02f, -9.08530653e-02f, -1.21919692e-01f, -5.38251922e-02f, 1.29782548e-02f,
  4.12860177e-02f, 1.51018158e-01f, 1.65876150e-01f, 3.68652821e-01f, 2.55122930e-01f, 3.73931587e-01f, 2.11767897e-01f, 8.96996632e-02f, -2.04326332e-01f, -1.08653054e-01f,
  -2.52380878e-01f, -1.99864745e-01f, -4.36454117e-01f, -7.03025516e-03f, -2.93110795e-02f, -1.57435074e-01f, -6.78436086e-02f, -5.80477044e-02f, -1.71461269e-01f, -6.20244890e-02f,
  -7.67714251e-03f, 1.44674219e-02f, 7.43990242e-02f, -1.54687732e-01f, 4.05395120e-01f, 2.89320648e-02f, 3.63756597e-01f, 2.05007955e-01f, 2.64158994e-01f, 4.93020356e-01f,
  1.11339636e-01f, -1.80353567e-01f, 5.60445562e-02f, 1.86316986e-02f, 8.48934203e-02f, -1.07020484e-02f, 3.78628522e-02f, 4.52603787e-01f, 1.50675908e-01f, -1.16224207e-01f,
  -2.20506832e-01f, -1.10003538e-01f, -7.14722946e-02f, -3.39104608e-02f, 1.40509112e-02f, -1.03235338e-02f, 2.18412116e-01f, -1.80964991e-02f, 4.64212038e-02f, -1.02144331e-01f,
  -1.29184769e-02f, 1.04913190e-01f, -1.83280885e-01f, 1.06529191e-01f, 4.49341498e-02f, 2.36810625e-01f, 5.35042323e-02f, -9.14827585e-02f, 1.64734066e-01f, 1.86940178e-01f,
  2.17140988e-01f, -1.18215363e-02f, -1.57122463e-02f, 1.88523736e-02f, -3.47208418e-02f, 1.79245770e-01f, -1.27479658e-01f, -3.58268023e-02f, -9.99877602e-02f, -7.07407221e-02f,
  2.12781001e-02f, 1.74633358e-02f, -7.91934878e-02f, -9.20267180e-02f, -3.32514234e-02f, 9.66985002e-02f, 5.30197583e-02f, 2.67779063e-02f, -9.07731708e-03f, -8.87628868e-02f,
  -2.84121968e-02f, 4.12355065e-02f, -1.32373199e-01f, 1.36831090e-01f, -1.04203746e-01f, -1.68061233e-03f, 1.22335441e-01f, 1.11361429e-01f, 3.10884029e-01f, 1.76526222e-03f,
  -1.10975847e-01f, 4.55567092e-02f, -3.16519812e-02f, 8.84181913e-03f, -5.67076504e-02f, -8.61905888e-02f, 1.00770563e-01f, 4.50278409e-02f, -2.33140904e-02f, 3.98881622e-02f,
  4.23554070e-02f, 1.45996004e-01f, -4.58758660e-02f, 1.04410179e-01f, 1.02289498e-01f, 1.47454664e-02f, 4.14982066e-02f, -6.38682470e-02f, 1.04011685e-01f, 2.43984684e-02f,
  -5.92886098e-02f, 7.61938095e-02f, 9.38761085e-02f, 2.60857530e-02f, 3.47795114e-02f, -1.73870772e-02f, -7.48539194e-02f, -5.69422655e-02f, 1.40038624e-01f, 7.94570222e-02f,
  -2.96043437e-02f, 9.05647501e-02f, 8.21872056e-02f, 1.15260504e-01f, 8.99206325e-02f, 2.33733267e-01f, -1.16195910e-01f, -7.47741312e-02f, -7.77923986e-02f, 1.31443605e-01f,
  1.06820703e-01f, -9.73103940e-02f, -3.78338657e-02f, 1.46818250e-01f, 3.79152931e-02f, -7.66187012e-02f, -4.58511189e-02f, -1.29331499e-01f, 7.77839422e-02f, -1.80951700e-01f,
  -1.72131643e-01f, -2.70105060e-02f, 1.56917907e-02f, 1.46445697e-02f, 7.22428113e-02f, 1.24748379e-01f, -5.94614670e-02f, 1.21820405e-01f, -6.20164461e-02f, -3.45077552e-03f,
  5.15057147e-02f, -1.18526399e-01f, 5.24395742e-02f, 5.27239293e-02f, 1.35575727e-01f, 1.78271741e-01f, -4.25061621e-02f, 6.03917092e-02f, 2.05944162e-02f, -1.98075045e-02f,
  2.21347418e-02f, 4.38135117e-03f, -1.05137251e-01f, 8.91444087e-02f, 7.03723282e-02f, 1.05955057e-01f, -2.34482326e-02f, -1.27401024e-01f, -6.41422942e-02f, 8.23390856e-02f,
  4.49007004e-02f, -1.39039546e-01f, 1.04988955e-01f, -3.99690755e-02f, 5.30047603e-02f, 8.51046294e-02f, 3.30526754e-02f, -7.09921122e-02f, 5.40863238e-02f, 1.07311688e-01f,
  -1.10943869e-01f, 7.71163180e-02f, 5.02470322e-02f, 1.74321041e-01f, -9.87997651e-02f, -8.10514539e-02f, 8.96466896e-02f, 8.69871750e-02f, 3.34868878e-02f, -1.30311977e-02f,
  -2.06608735e-02f, 7.71290287e-02f, 5.28006405e-02f, -6.41018823e-02f, 6.69556409e-02f, 2.73330733e-02f, 1.55705437e-01f, -4.80246320e-02f, 1.28365204e-01f, 4.72758599e-02f,
  -2.04301868e-02f, 5.49168400e-02f, -4.20692004e-03f, 2.03546304e-02f, 1.80748209e-01f, 1.51375368e-01f, 3.47695574e-02f, 2.84782231e-01f, 4.16146554e-02f, 4.60847244e-02f,
  1.20170794e-01f, 5.55142537e-02f, 2.61970758e-02f, -4.43547852e-02f, -1.68906245e-02f, -1.09309673e-01f, -9.79169309e-02f, -6.32058978e-02f, -1.01231799e-01f, -6.58622533e-02f,
  -9.64778438e-02f, -1.09406523e-01f, 7.41791278e-02f, 4.01376337e-02f, 3.63607518e-03f, 1.09172389e-01f, 3.92673723e-02f, -8.34382884e-03f, -2.07723174e-02f, -2.16333233e-02f,
  -2.00387817e-02f, 3.22912224e-02f, 1.02351949e-01f, -2.01089773e-02f, 6.95749894e-02f, -3.84327658e-02f, -1.26696274e-01f, 6.03967309e-02f, -2.21483409e-02f, -1.38685092e-01f,
  -1.16586648e-01f, 4.76578325e-02f, 1.20349884e-01f, -2.30411012e-02f, -2.23021470e-02f, -3.45301442e-02f, 5.98248802e-02f, 3.50116789e-02f, -2.52520125e-02f, 1.32980376e-01f,
  2.02237312e-02f, -1.65015027e-01f, -5.00638299e-02f, 2.27324054e-01f, 1.02990955e-01f, 1.46551356e-02f, -5.50321043e-02f, 3.63704003e-03f, -1.06598422e-01f, 3.89522724e-02f,
  1.04988769e-01f, -4.50604409e-02f, 7.21508861e-02f, -1.01977713e-01f, -5.72925471e-02f, 1.07241487e-02f, -1.36817634e-01f, -9.68709067e-02f, -4.20278357e-03f, 1.44527525e-01f,
  8.06133598e-02f, -7.04367757e-02f, 5.32581769e-02f, -2.80516911e-02f, -4.69624847e-02f, -1.60492696e-02f, 4.96576242e-02f, 7.91147649e-02f, -1.22104332e-01f, -1.21727988e-01f,
  -8.75274837e-02f, 9.85055342e-02f, -1.05965689e-01f, 1.15609035e-01f, -4.31913100e-02f, 1.39867231e-01f, -1.02020567e-02f, 6.77496940e-02f, -9.42092165e-02f, 1.02812096e-01f,
  1.21533208e-01f, 1.09806918e-02f, -1.04078399e-02f, -1.08138688e-01f, 1.25138581e-01f, -2.05817968e-02f, 7.64792785e-02f, 5.25666401e-02f, 3.95022668e-02f, -1.73567347e-02f,
  4.18716222e-02f, -1.07888624e-01f, -7.60799572e-02f, 1.07000545e-01f, 1.54851368e-02f, 3.56331766e-02f, 1.50900647e-01f, 1.11227907e-01f, 9.57627818e-02f, 1.52335271e-01f,
  -1.68762002e-02f, 1.28933176e-01f, 1.22865602e-01f, -1.31634608e-01f, 2.93960292e-02f, -7.27670118e-02f, -1.06415763e-01f, -9.20517817e-02f, -5.91140017e-02f, 8.52897614e-02f,
  8.04826766e-02f, 1.15567349e-01f, 1.97137818e-01f, -1.17593985e-02f, 1.51222840e-01f, -2.61427462e-02f, 7.48300599e-03f, 1.29561499e-01f, -1.33226752e-01f, 1.52498484e-01f,
  -4.28303219e-02f, 2.43300602e-01f, 1.54556409e-01f, 1.12346329e-01f, 1.90166011e-02f, 1.90830395e-01f, 4.05935943e-02f, -7.64864013e-02f, 9.43412632e-02f, -1.03848197e-01f,
  -1.18346155e-01f, -1.07495278e-01f, -1.04848690e-01f, 4.84545194e-02f, -1.41030863e-01f, -1.61537770e-02f, -1.17614090e-01f, 2.27947868e-02f, -1.02603801e-01f, 1.14243284e-01f,
  6.95822611e-02f, 1.67869627e-01f, -4.47836444e-02f, 1.26270100e-01f, -5.34417704e-02f, -2.76721101e-02f, 1.79495569e-02f, -9.19254795e-02f, 2.45897230e-02f, 2.77904724e-03f,
  5.15077114e-02f, 5.37031740e-02f, 2.72054635e-02f, -9.33722965e-03f, -1.36327118e-01f, -2.91694365e-02f, -1.32721975e-01f, -8.03673863e-02f, -8.82046223e-02f, -8.19227472e-02f,
  2.39217103e-01f, -9.91989821e-02f, 1.29420221e-01f, 1.64546311e-01f, -7.67110214e-02f, 2.25264821e-02f, 3.69482227e-02f, -9.13805738e-02f, 5.27383350e-02f, -1.00834616e-01f,
  -4.90855724e-02f, -2.18095388e-02f, 1.10621154e-01f, 5.67524023e-02f, 6.58076536e-03f, 1.01723429e-02f, -7.21322522e-02f, 4.02958412e-03f, -3.96946669e-02f, 1.08837299e-01f,
  4.51974943e-02f, -9.47505087e-02f, 3.27590257e-02f, 5.41703440e-02f, -9.56983268e-02f, 1.15822360e-03f, 9.35020149e-02f, 1.59958880e-02f, -2.61808094e-02f, 2.52895039e-02f,
  7.21457079e-02f, -2.62348503e-02f, -1.15298077e-01f, 7.89350420e-02f, -4.63601500e-02f, 3.87001112e-02f, -1.01790734e-01f, -4.84537072e-02f, 2.39956960e-01f, -1.22940496e-01f,
  4.31504436e-02f, 2.55545489e-02f, -3.62125114e-02f, 2.73875799e-02f, -5.83770983e-02f, -2.76512094e-02f, -1.03838984e-02f, 9.43407416e-02f, 1.22361571e-01f, 3.04428805e-02f,
  -5.25890179e-02f, 1.39691219e-01f, -4.93947603e-02f, 2.28158981e-02f, 6.05730005e-02f, 8.59284252e-02f, -1.08971104e-01f, 6.09264709e-02f, 1.08227201e-01f, 8.53900891e-03f,
  7.13837892e-02f, -7.01037645e-02f, -1.16274327e-01f, -1.20267980e-01f, 3.31048332e-02f, 3.75782177e-02f, 5.36210611e-02f, -6.26566857e-02f, -9.33249444e-02f, -9.38354433e-02f,
  1.15998872e-01f, -4.13339920e-02f, -5.10207564e-02f, -7.48453364e-02f, -7.31577426e-02f, 1.58169642e-01f, -1.22075513e-01f, -8.70893076e-02f, 1.14473910e-03f, 1.74821496e-01f,
  -7.04693869e-02f, 2.79169399e-02f, -4.81886789e-02f, 1.22228032e-02f, -4.92753908e-02f, -3.63776018e-03f, -1.93497539e-03f, -4.65739751e-03f, -1.08163975e-01f, -1.58501849e-01f,
  -1.01358756e-01f, 1.17682546e-01f, 1.28464386e-01f, -9.00406837e-02f, -1.08873211e-01f, -1.89059116e-02f, 1.74948759e-02f, 1.08232595e-01f, -3.09104342e-02f, -1.23096509e-02f,
  9.89720002e-02f, 3.40375467e-03f, -9.87109244e-02f, -1.21181551e-02f, -9.11525637e-02f, -6.55875131e-02f, 7.77765587e-02f, 1.49227129e-02f, 1.09760687e-01f, 4.49395441e-02f,
  3.71767357e-02f, -1.14780039e-01f, -3.39956507e-02f, 6.30612001e-02f, -8.35737884e-02f, -1.06415100e-01f, -1.88463628e-02f, 5.42220026e-02f, 9.15295631e-02f, -4.37124744e-02f,
  -1.09068520e-01f, 7.39939660e-02f, 3.36217768e-02f, -5.04884822e-03f, -1.14468105e-01f, -4.59750630e-02f, -3.87533903e-02f, 7.07613602e-02f, -1.36053622e-01f, -4.15639393e-02f,
  5.72440550e-02f, -8.88050944e-02f, 7.01440722e-02f, -7.34104365e-02f, -5.29292226e-02f, 3.90635207e-02f, -8.98291394e-02f, 2.65244134e-02f, -4.75736968e-02f, -2.71481499e-02f,
  -9.55050960e-02f, -1.23933017e-01f, -9.37297791e-02f, -4.57948111e-02f, -2.52569374e-02f, -1.13706425e-01f, 5.16190380e-02f, -1.29545897e-01f, -2.78011803e-02f, -6.33469895e-02f,
  -1.43079404e-02f, -7.47277811e-02f, -9.38712284e-02f, 2.75401138e-02f, -9.98833450e-04f, -1.07455827e-01f, -5.31816557e-02f, 1.95094958e-01f, -9.85903367e-02f, 2.86642648e-02f,
  -1.00363195e-01f, -7.14493468e-02f, -6.53673559e-02f, -8.99736732e-02f, 8.65674317e-02f, 1.04895942e-01f, 7.50904307e-02f, 9.49367657e-02f, -2.38841074e-03f, -1.46377990e-02f,
  1.98241305e-02f, -2.62805680e-03f, 2.93750186e-02f, -3.37999500e-02f, -1.15991369e-01f, -6.26122579e-02f, -6.36571413e-03f, 9.43862461e-03f, -8.27496592e-03f, 6.86786026e-02f,
  5.96586205e-02f, 1.31401137e-01f, -2.79278588e-02f, -1.17858842e-01f, -4.85448837e-02f, 1.63025409e-02f, 6.02555424e-02f, -5.28181419e-02f, -4.43727411e-02f, -2.82857995e-02f,
  -1.28984094e-01f, 3.64324637e-02f, -1.72448047e-02f, 1.71232391e-02f, -8.35503116e-02f, -1.92431528e-02f, 4.08187229e-03f, 4.88674901e-02f, 8.64531547e-02f, 5.27444407e-02f,
  1.02429099e-01f, -1.37248859e-01f, 1.23806871e-01f, 7.57078826e-03f, 4.03537974e-02f, 7.45021086e-03f, -6.16366565e-02f, 4.92601767e-02f, -4.17253189e-02f, 1.04427949e-01f,
  -8.03338885e-02f, -1.86802614e-02f, -5.16428016e-02f, 1.53581247e-01f, -5.19694611e-02f, -1.73194945e-01f, -3.23983170e-02f, -1.06122516e-01f, -1.98964596e-01f, -6.10352382e-02f,
  4.42587584e-02f, 1.95224918e-02f, -1.14630304e-01f, -1.10174291e-01f, -1.30489290e-01f, -1.24558143e-01f, -4.52360436e-02f, 7.29441717e-02f, 1.02694236e-01f, 4.47338037e-02f,
  8.68963599e-02f, -5.86621091e-02f, 1.66067883e-01f, 1.70431659e-01f, 1.00704797e-01f, 2.94170558e-01f, -1.29841849e-01f, 1.09668255e-01f, 1.45396050e-02f, 5.55824898e-02f,
  -9.26477015e-02f, 1.44465134e-01f, 5.16398028e-02f, 2.49247015e-01f, -9.66162980e-02f, -1.24098070e-01f, -1.97832063e-02f, -2.35090218e-02f, 1.79883502e-02f, 6.19860403e-02f,
  -7.90180564e-02f, 4.28751670e-02f, 1.81502908e-01f, 1.16429992e-01f, -1.37396023e-01f, 1.08662054e-01f, 2.86896620e-02f, -3.73585033e-03f, -1.15924887e-01f, 1.91868007e-01f,
  -1.11327305e-01f, 2.82279891e-03f, -7.85277635e-02f, 7.82330632e-02f, 1.70495570e-01f, 4.06269729e-02f, 2.19273176e-02f, -9.93064269e-02f, 7.07545131e-02f, 7.42480382e-02f,
  -9.32483468e-03f, -5.38778119e-02f, 8.36714655e-02f, -1.86919905e-02f, 1.24220565e-01f, 1.44714311e-01f, 1.93076029e-01f, 1.39638960e-01f, -3.11595052e-02f, 1.52780250e-01f,
  -1.04762256e-01f, 2.79347561e-02f, 1.14753107e-02f, 4.12450470e-02f, 5.86597323e-02f, -1.37093961e-01f, 3.99620235e-02f, 4.56247032e-02f, 2.68901512e-02f, 9.01166946e-02f,
  1.25274673e-01f, -1.79978032e-02f, -1.12636156e-01f, 7.64115676e-02f, 2.77524889e-01f, 8.39608139e-04f, -1.15012579e-01f, -1.12444729e-01f, 6.34399951e-02f, -1.04856446e-01f,
  3.88226695e-02f, 3.99493473e-03f, -2.92573944e-02f, 5.85781075e-02f, 3.47145535e-02f, -9.23251864e-05f, -8.30799863e-02f, -1.26823317e-02f, 1.80131942e-02f, 2.67393347e-02f,
  -4.76272330e-02f, 6.98041618e-02f, 1.87653601e-02f, -1.14304744e-01f, 7.64056742e-02f, -8.86830613e-02f, -8.44230056e-02f, 7.23807290e-02f, 1.64997075e-02f, -8.34205747e-02f,
  -7.11923987e-02f, -8.92195702e-02f, -9.07600224e-02f, -1.33963004e-01f, 7.40937963e-02f, -1.01468809e-01f, 5.22351228e-02f, 1.17640533e-01f, -8.31182227e-02f, 1.92267716e-01f,
  -6.15824051e-02f, 8.91996473e-02f, -8.93494934e-02f, 4.45571868e-03f, 1.40937164e-01f, 1.84949666e-01f, -8.15473124e-02f, -1.11450255e-01f, -3.43323275e-02f, -1.14771677e-02f,
  -1.62200421e-01f, -1.13794982e-01f, -4.77556959e-02f, 1.06386747e-02f, 1.26925468e-01f, 1.85915511e-02f, -1.01040587e-01f, -6.14730082e-02f, -3.64838205e-02f, -1.06364954e-03f,
  6.20828383e-02f, 6.47054091e-02f, 2.88183638e-03f, 6.39952719e-03f, -2.56952681e-02f, -8.84407982e-02f, 1.15834191e-01f, 9.24155209e-03f, 1.26451746e-01f, -2.20640507e-02f,
  1.44196883e-01f, -1.52539574e-02f, 1.45784989e-01f, 7.29010329e-02f, 7.48282671e-02f, -6.79392088e-03f, -1.24861613e-01f, -6.01264136e-03f, -1.25157684e-01f, -5.62156439e-02f,
  -2.53785010e-02f, 7.06645250e-02f, 9.35900956e-02f, -9.55707356e-02f, 9.94105190e-02f, 1.11983061e-01f, -1.00281648e-01f, 3.33435722e-02f, 1.31820604e-01f, 4.99021560e-02f,
  -7.81516209e-02f, -6.17453493e-02f, -5.29127643e-02f, -2.20780354e-02f, -4.23618443e-02f, 6.43076142e-04f, -2.01538242e-02f, -9.52083021e-02f, -2.44891420e-02f, -2.72077080e-02f,
  -5.88839501e-02f, -8.29515234e-03f, 6.46222802e-03f, -8.63161683e-02f, 1.13417931e-01f, -8.90497863e-03f, 4.16355021e-02f, 3.45500857e-02f, 4.50647324e-02f, 1.10383583e-02f,
  -8.68247226e-02f, -3.33479047e-02f, 5.55012748e-02f, -3.87835875e-02f, 9.76195112e-02f, 2.02947669e-02f, -2.70662550e-02f, 6.29797429e-02f, -1.37755796e-01f, 7.39866197e-02f,
  -3.16124898e-03f, -1.28560260e-01f, 1.21497191e-01f, -7.23506510e-02f, 4.26781401e-02f, -4.70637111e-03f, 8.31329748e-02f, -2.43681334e-02f, -8.60483870e-02f, 4.56709377e-02f,
  1.08206384e-01f, -9.34440345e-02f, 2.33910277e-01f, 1.31193340e-01f, 1.04335114e-01f, -1.86040420e-02f, 7.51519576e-02f, 7.18284175e-02f, -2.82324757e-02f, -1.27374172e-01f,
  1.13896228e-01f, -2.54544076e-02f, -7.39212707e-02f, -2.28215102e-02f, 4.09740359e-02f, 1.75744481e-02f, 8.33243355e-02f, -6.61293715e-02f, 5.19688837e-02f, -5.17617213e-03f,
  1.90406553e-02f, -4.17634584e-02f, -1.11572333e-01f, -6.55028373e-02f, -1.10858165e-01f, -5.47562875e-02f, 2.52871308e-02f, 8.03622007e-02f, -8.04057419e-02f, 8.78371447e-02f,
  -7.46433660e-02f, 2.69972589e-02f, 1.17317393e-01f, -1.07609123e-01f, 1.01408409e-02f, 1.08222634e-01f, -3.37742898e-03f, 1.55224591e-01f, -5.11942282e-02f, -5.55234849e-02f,
  -1.53078856e-02f, -2.27988455e-02f, -4.19576205e-02f, -3.38020623e-02f, 2.45516211e-01f, 1.84960976e-01f, 4.20325436e-02f, 2.57067353e-01f, 2.55765289e-01f, 2.98125148e-01f,
  -2.97563106e-01f, 1.99176565e-01f, -1.81153998e-01f, -3.28471735e-02f, -1.36377305e-01f, -1.19604155e-01f, -1.20126836e-01f, -2.53174126e-01f, -1.96471475e-02f, 9.32005942e-02f,
  -1.45691395e-01f, 1.69206485e-01f, 5.72454631e-02f, 9.37268604e-03f, -8.85553285e-02f, 5.95655479e-02f, 6.39892817e-01f, 1.13426104e-01f, 2.39093900e-01f, 2.09677927e-02f,
  3.07963486e-03f, 2.10722849e-01f, 1.91363059e-02f, -1.09460272e-01f, 4.31858376e-02f, 4.17703763e-02f, -3.13947909e-02f, -4.65401560e-02f, -1.20101646e-01f, 4.70170587e-01f,
  -1.17093757e-01f, -1.67100772e-01f, -1.24848515e-01f, 2.16018185e-02f, -1.17082909e-01f, -1.50086373e-01f, 5.25656529e-02f, 9.74747911e-02f, 8.33201855e-02f, -1.00306995e-01f,
  -2.68278085e-02f, 8.04995671e-02f, 1.42407091e-02f, 1.70912847e-01f, 1.82261039e-02f, -1.18028492e-01f, 1.58127695e-01f, -2.24797800e-02f, 9.72286537e-02f, -2.75524743e-02f,
  -2.46018339e-02f, 1.33545682e-01f, 1.17952265e-02f, 1.56569675e-01f, 2.33868905e-03f, -7.94592500e-02f, -1.22960970e-01f, 5.38825616e-03f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  1.07924841e-01f, 1.62843112e-02f, -4.67223860e-02f, 1.03339054e-01f, -9.95821431e-02f, -8.65975991e-02f, 8.55284259e-02f, 1.14419796e-01f, 7.56667256e-02f, 9.38288867e-02f,
  8.23488086e-02f, -9.64612439e-02f, 2.08844408e-01f, 3.37177277e-01f, -8.62316266e-02f, 1.95821494e-01f, -6.71499781e-03f, 1.45931795e-01f, 1.21746331e-01f, 1.41696883e-02f,
  2.92393640e-02f, 6.42504096e-02f, -1.23658925e-02f, -3.27880718e-02f, 2.25443512e-01f, 1.22028217e-01f, -4.36789170e-02f, 3.16775702e-02f, -3.34465951e-02f, 1.12155840e-01f,
  1.41332567e-01f, -3.28711383e-02f, 7.83788711e-02f, 5.77478260e-02f, 9.91210639e-02f, -1.05558299e-02f, 6.90656975e-02f, 5.12606315e-02f, 8.88871178e-02f, 2.12333146e-02f,
  9.54876319e-02f, 1.68773636e-01f, -8.00354630e-02f, 8.97688046e-02f, -4.32948843e-02f, -1.80688892e-02f, -1.14270583e-01f, 1.35967284e-01f, -3.81539166e-02f, -2.28466094e-02f,
  4.44300659e-02f, 2.89353877e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  2.26446167e-01f, -1.14568613e-01f, 4.09509361e-01f, -1.12672798e-01f, 2.05554128e-01f, 2.93176234e-01f, 2.56321013e-01f, -3.29667389e-01f, 3.65135372e-01f, -4.67558891e-01f,
  -3.03644747e-01f, 1.27924040e-01f, 2.68817157e-01f, -4.34716642e-02f, 1.60704091e-01f, 1.34780720e-01f, -3.10551953e-02f, -1.01273321e-01f, -1.27401222e-02f, -1.86677516e-01f,
  7.30105024e-03f, 2.29618937e-01f, -3.86286795e-01f, 1.63520008e-01f, -2.76319951e-01f, 7.06227124e-02f, -6.77424073e-02f, 1.88392952e-01f, -5.01079857e-02f, -2.06005543e-01f,
  -1.74559057e-02f, 5.57970516e-02f, -1.43958494e-01f, 7.74000809e-02f, -3.05914700e-01f, -8.91065598e-03f, -1.92087829e-01f, -8.50275084e-02f, 1.39545783e-01f, -1.54632270e-01f,
  2.36772168e-02f, -3.28395605e-01f, 9.54986885e-02f, 3.94683450e-01f, 4.74672876e-02f, -1.25607565e-01f, 2.65059793e-06f, -9.71253589e-02f, -1.16487183e-01f, 1.39303161e-02f,
  5.46703339e-01f, -1.22162297e-01f, 1.07613511e-01f, -2.84718364e-01f, 4.10421751e-02f, -2.97453217e-02f, -1.83127880e-01f, -9.20342505e-02f, -1.54225260e-01f, 2.39394575e-01f,
  -5.09593338e-02f, -1.00743465e-01f, 1.51097542e-02f, 4.06908393e-01f, 1.56663269e-01f, 4.75050569e-01f, 9.70942900e-02f, 2.29449049e-01f, 1.45760030e-01f, -3.45779993e-02f,
  -1.78280875e-01f, 2.88411051e-01f, -5.84567964e-01f, 3.78739655e-01f, 2.84431130e-01f, -3.28388095e-01f, -8.24130774e-02f, -1.21776797e-01f, 1.36940956e-01f, -1.26661479e-01f,
  -1.19301677e-02f, -2.75974303e-01f, -5.35874302e-03f, 7.44393319e-02f, -1.33625343e-01f, 2.80393064e-01f, -3.35678428e-01f, 1.01989303e-02f, -1.97501361e-01f, 5.27739465e-01f,
  2.74239555e-02f, -2.44975269e-01f, -1.87954620e-01f, 1.02467455e-01f, -1.02512158e-01f, -3.70531231e-02f, -1.52231276e-01f, 6.87835366e-02f, -1.05738863e-01f, -8.71275812e-02f,
  4.23511257e-03f, 6.52231798e-02f, 1.61686584e-01f, 3.59169155e-01f, -7.55413398e-02f, -4.43623960e-02f, 3.29435617e-02f, 1.02518298e-01f, 4.68413047e-02f, 2.07441330e-01f,
  -5.60940914e-02f, -1.04371563e-01f, 6.83755241e-03f, -6.52439240e-03f, 3.29985261e-01f, -2.18209967e-01f, 1.49833128e-01f, 4.75221127e-02f, 1.91151947e-01f, 1.82005510e-01f,
  4.72794473e-02f, 5.60611263e-02f, -7.20473155e-02f, 2.19316632e-01f, -2.01122060e-01f, -9.43362117e-02f, 4.13010344e-02f, -1.57841220e-01f, 1.26086846e-01f, 3.51424634e-01f,
  -4.01174545e-01f, -4.48067151e-02f, 1.36863291e-01f, -3.25919092e-01f, -2.63483524e-01f, 5.43219328e-01f, -2.69192368e-01f, 5.45630276e-01f, 3.15394133e-01f, -3.48741233e-01f,
  9.54342820e-03f, -1.08292267e-01f, -9.64584295e-03f, -7.72190467e-02f, -2.79295761e-02f, -2.62834579e-02f, 1.49962408e-02f, 5.41337967e-01f, 1.10827014e-01f, -8.81218463e-02f,
  -1.19474754e-01f, -3.27458754e-02f, 2.41858345e-02f, 3.89249504e-01f, -1.12012878e-01f, -1.14483170e-01f, -1.41099781e-01f, 1.48517475e-01f, -1.67979658e-01f, 8.00930560e-02f,
  3.90756391e-02f, -3.28867100e-02f, -1.64392829e-01f, 4.78988327e-02f, 3.21736634e-01f, 9.73182842e-02f, -2.51002520e-01f, 2.21061260e-01f, -8.84949043e-02f, 6.72066629e-01f,
  -4.36544955e-01f, -3.90599445e-02f, 2.52598561e-02f, -8.03371370e-02f, 2.93286499e-02f, 2.38318592e-02f, 1.41506977e-02f, -1.25379786e-01f, -3.99575025e-01f, -1.91015512e-01f,
  -3.94097827e-02f, 1.02221094e-01f, 4.69163433e-02f, 1.53715491e-01f, 1.74016110e-03f, 7.25208074e-02f, 5.92656694e-02f, -2.65212864e-01f, 2.39112340e-02f, -5.08690588e-02f,
  -1.54453248e-01f, -4.14963812e-01f, 3.16162705e-02f, -3.80297929e-01f, -6.30037248e-01f, -3.59424472e-01f, -1.47846043e-01f, -2.54346669e-01f, 3.32619071e-01f, 1.29588261e-01f,
  2.66062587e-01f, -2.60841642e-02f, -3.78477782e-01f, 3.26491237e-01f, -7.80559704e-02f, 1.52954042e-01f, 7.78181106e-02f, 1.08984627e-01f, 2.47456245e-02f, 3.67200166e-01f,
  -1.08376220e-01f, -2.39230156e-01f, 4.24220636e-02f, -5.88349476e-02f, 1.75349265e-01f, 1.33104503e-01f, -2.73203373e-01f, -3.96422535e-01f, 1.81740567e-01f, 3.57576072e-01f,
  2.40023658e-01f, -9.95073840e-02f, -9.97915342e-02f, 5.16095720e-02f, 2.06087738e-01f, 8.92269313e-02f, 3.36402893e-01f, -1.06026672e-01f, -4.29781795e-01f, -3.23919952e-03f,
  5.24933450e-02f, -2.06296444e-01f, 1.90577731e-01f, -1.79620549e-01f, -5.34718454e-01f, -1.65826067e-01f, -3.02526429e-02f, -1.86389852e-02f, -1.85909376e-01f, 1.08946068e-02f,
  -7.30708316e-02f, 9.37531143e-02f, 1.40603557e-01f, 2.25303173e-01f, 8.45652744e-02f, -1.06211849e-01f, 1.01460718e-01f, 1.62322409e-02f, 7.46222585e-02f, 9.12540406e-02f,
  -5.21976948e-02f, -9.83277634e-02f, 5.82213029e-02f, 2.12226003e-01f, 2.49079406e-01f, 2.82247007e-01f, -3.10567431e-02f, -1.21518619e-01f, 2.74635643e-01f, -3.34507376e-01f,
  -2.74561439e-02f, -1.39548238e-02f, -1.80398867e-01f, 3.46136123e-01f, 5.08946240e-01f, -3.30466121e-01f, -1.42515883e-01f, 2.67598450e-01f, -4.26551178e-02f, -8.78978893e-03f,
  8.51116050e-03f, -6.71589747e-02f, -3.62627991e-02f, 2.21328154e-01f, -1.06985174e-01f, -1.15227662e-01f, 6.47414327e-02f, -7.95594230e-02f, 2.14046344e-01f, -1.08969018e-01f,
  1.95896000e-01f, -3.60898614e-01f, 3.06742061e-02f, 4.55122650e-01f, -7.30830804e-03f, -1.18099578e-01f, 2.94139713e-01f, 2.67850086e-02f, -2.91229077e-02f, 4.75859456e-03f,
  -2.77483970e-01f, -1.67313933e-01f, 5.19408397e-02f, -1.10902846e-01f, 1.46001822e-03f, -2.22109765e-01f, 6.40631840e-02f, -2.01036558e-01f, 2.70351857e-01f, 2.26991065e-02f,
  4.62321416e-02f, -1.58876047e-01f, 9.41986293e-02f, -9.35537666e-02f, -2.16788590e-01f, -1.74493343e-02f, 2.33110279e-01f, 2.42032424e-01f, -1.22971006e-01f, -8.47703964e-02f,
  -3.40885632e-02f, -2.42111415e-01f, 1.78977281e-01f, 6.42872825e-02f, 1.17707863e-01f, -4.06812802e-02f, 1.91989973e-01f, -1.16737016e-01f, 1.77520424e-01f, 3.76514137e-01f,
  -1.06512658e-01f, -2.30134174e-01f, 1.19388305e-01f, 2.39615962e-01f, 1.15348257e-01f, 1.89645737e-01f, -2.73554265e-01f, -1.62132010e-01f, -3.18175465e-01f, -2.52886653e-01f,
  -1.77670196e-01f, 1.22178204e-01f, -1.10349962e-02f, -5.73510490e-02f, 1.80753693e-01f, 1.05840527e-02f, 1.27585113e-01f, -1.62633300e-01f, -1.23591609e-02f, -1.22664288e-01f,
  4.93839607e-02f, 1.27332527e-02f, 1.85388327e-01f, -9.83852223e-02f, 1.41482770e-01f, 3.68765295e-01f, -1.31879658e-01f, -5.56036346e-02f, -4.20686118e-02f, 1.07300773e-01f,
  2.80060291e-01f, -7.83261508e-02f, -9.56668239e-03f, -9.98978764e-02f, -3.39825153e-01f, 8.93566087e-02f, 2.54803956e-01f, -1.63785070e-01f, 1.51417464e-01f, -7.73933008e-02f,
  -1.14720814e-01f, -2.23560631e-01f, 3.79653811e-01f, -8.46329629e-02f, -1.55527741e-01f, -1.39883801e-01f, 1.98733181e-01f, -2.40396485e-02f, -8.26692060e-02f, 7.54708424e-02f,
  2.59726882e-01f, -1.88228600e-02f, -1.11251213e-01f, 6.73847273e-02f, 1.45440251e-02f, 3.87300514e-02f, 2.01483935e-01f, 5.29800579e-02f, -3.53948935e-03f, 6.30864799e-02f,
  -2.46388577e-02f, -6.44942820e-02f, -1.06880158e-01f, 2.24494606e-01f, -2.49927610e-01f, 2.70963669e-01f, -3.49190980e-01f, -1.49297807e-02f, 1.07578598e-01f, 6.22849315e-02f,
  -7.31771290e-02f, -3.20166081e-01f, 1.40571250e-02f, 4.55576301e-01f, 2.03303754e-01f, -2.73869365e-01f, -1.13842539e-01f, -2.20403988e-02f, -1.96124896e-01f, 5.49668148e-02f,
  -9.10189897e-02f, -8.66253045e-04f, 5.21595702e-02f, 1.00575067e-01f, -1.15636885e-01f, -1.40355021e-01f, 1.02404930e-01f, -1.56156808e-01f, 3.52299273e-01f, 3.64052624e-01f,
  -1.14670031e-01f, -4.40567315e-01f, -1.52105853e-01f, -2.49066368e-01f, -3.15447524e-02f, -2.09744126e-02f, -4.39154617e-02f, 4.50038947e-02f, -1.20018400e-01f, -4.02757153e-02f,
  4.05695468e-01f, -8.37325528e-02f, -1.10519491e-01f, -1.28362894e-01f, -9.11151469e-02f, 1.08591333e-01f, 4.15799916e-01f, -2.50768989e-01f, 1.73564821e-01f, -1.56358585e-01f,
  4.12086770e-02f, 1.05108745e-01f, 2.73756236e-01f, -1.41735196e-01f, -6.51376009e-01f, -1.65293366e-01f, -6.66927323e-02f, 3.39496642e-01f, 1.00435168e-01f, 4.06288564e-01f,
  -1.35125086e-01f, -1.11711062e-01f, -4.58394289e-02f, -2.54561275e-01f, -9.93389934e-02f, 4.06164005e-02f, -1.83557123e-02f, -3.77261281e-01f, -1.04181863e-01f, -1.14061765e-01f,
  -2.52762735e-01f, -2.01942652e-01f, -4.53571200e-01f, -4.60285366e-01f, 3.67052913e-01f, 1.88661620e-01f, 7.78641552e-02f, 1.54132292e-01f, -4.70257737e-02f, 2.24267513e-01f,
  -3.33427973e-02f, 1.18509829e-01f, 2.09771007e-01f, 1.98457479e-01f, 2.29002517e-02f, 1.20590895e-01f, -6.66022301e-02f, -1.63957402e-01f, -9.84333828e-02f, 1.90682128e-01f,
  -2.13624164e-01f, 2.61563897e-01f, -2.19021678e-01f, -3.16994041e-01f, -1.17890328e-01f, 9.21796933e-02f, 1.59108520e-01f, -1.12850279e-01f, -1.81572288e-01f, -1.45493776e-01f,
  -6.80871531e-02f, -1.29029915e-01f, 8.90475065e-02f, -1.62617713e-01f, -4.17430907e-01f, -4.93649300e-03f, 3.77799988e-01f, -1.56319011e-02f, 6.09827004e-02f, -1.63681209e-01f,
  -7.80043527e-02f, 3.85719508e-01f, 3.73005718e-02f, 1.02432005e-01f, -1.91415343e-02f, 6.43043742e-02f, -8.12717751e-02f, -1.25123128e-01f, 4.15896744e-01f, 1.59724995e-01f,
  2.36297131e-01f, -1.30046308e-01f, 3.29668485e-02f, -1.12698033e-01f, -1.85895227e-02f, 1.38188601e-01f, 1.54294550e-01f, 2.91985154e-01f, -2.94610709e-01f, 1.70763016e-01f,
  -6.69119731e-02f, 7.13556632e-02f, 6.38001263e-02f, -1.66938618e-01f, -5.51094674e-02f, -2.85954058e-01f, -2.29746193e-01f, -2.33412221e-01f, 3.24746400e-01f, 3.82320583e-01f,
  -3.75226080e-01f, 4.65708077e-01f, 2.45940477e-01f, -1.79486394e-01f, -1.07392564e-01f, 2.23966688e-01f, -3.46491858e-02f, -1.09096654e-01f, -1.11123301e-01f, -3.93174142e-02f,
  -1.25209689e-01f, 1.50766075e-01f, 8.27890337e-02f, -8.03290680e-02f, -5.98368235e-02f, 5.35903499e-02f, -1.15892000e-01f, -5.09192705e-01f, -1.48120965e-03f, -2.61420071e-01f,
  -1.66749403e-01f, 2.65543848e-01f, -1.67981118e-01f, -1.09409407e-01f, -1.60137370e-01f, -2.34791152e-02f, 3.88356864e-01f, 7.73642138e-02f, -2.02588469e-01f, 1.58984005e-01f,
  -1.94024622e-01f, 2.75991142e-01f, 1.97648220e-02f, 3.97475481e-01f, -4.38760042e-01f, -2.39938758e-02f, 1.06122047e-02f, 2.61586368e-01f, 5.13651147e-02f, 2.31528550e-01f,
  3.71207237e-01f, -1.32199466e-01f, -2.76883215e-01f, 9.58534628e-02f, 3.81392688e-02f, 1.56971673e-05f, 7.47998580e-02f, -4.74192649e-02f, -1.30174115e-01f, -3.91619503e-02f,
  9.44929421e-02f, 2.68814474e-01f, -2.35898584e-01f, -4.77575138e-02f, -5.63883334e-02f, -2.34233290e-01f, -7.92437419e-02f, -2.11267114e-01f, -4.64136377e-02f, 3.49784791e-01f,
  1.42764717e-01f, 1.96388498e-01f, -1.39354080e-01f, -2.64207363e-01f, -3.17925841e-01f, -1.81171611e-01f, -1.98832333e-01f, 1.04623564e-01f, 5.19354874e-03f, 5.39122410e-02f,
  -2.86204487e-01f, -9.20630395e-02f, -4.14049029e-02f, -1.50485620e-01f, 2.34233096e-01f, -2.83900052e-01f, 7.63632432e-02f, -1.68856159e-01f, -7.63925016e-02f, -1.34360984e-01f,
  1.61740333e-01f, 5.35361052e-01f, -7.02044219e-02f, -8.87128562e-02f, -3.05287898e-01f, -2.70546287e-01f, 8.57616141e-02f, -1.73102930e-01f, 3.71761099e-02f, 1.53938115e-01f,
  -1.58284739e-01f, -8.60047862e-02f, -7.33590350e-02f, -2.33355463e-01f, 4.65433337e-02f, -1.70736507e-01f, 2.98279747e-02f, -3.90334010e-01f, 1.01684070e+00f, 1.47022028e-02f,
  -1.06339557e-02f, -1.85591087e-01f, 2.15642393e-01f, -1.97194189e-01f, -2.13844821e-01f, -4.99186292e-02f, -4.30351973e-01f, 4.30735461e-02f, -2.36000195e-02f, 1.56899855e-01f,
  7.47092441e-02f, 7.64836371e-02f, -8.97592977e-02f, -9.31386128e-02f, 1.79146335e-01f, -8.96674246e-02f, -1.41349211e-01f, -2.66858395e-02f, 2.93046553e-02f, -5.33359528e-01f,
  2.61091530e-01f, 5.72442561e-02f, 2.50323355e-01f, 2.53561676e-01f, 2.52978235e-01f, 3.61610413e-01f, -2.69579254e-02f, -4.34780151e-01f, 7.46960998e-01f, -5.68281829e-01f,
  -9.75875929e-02f, 3.13210078e-02f, -8.76802504e-02f, -1.55386582e-01f, -2.67830696e-02f, 1.52596561e-02f, 9.23254415e-02f, 1.60865322e-01f, -4.13612723e-02f, -1.22261636e-01f,
  -4.33083298e-03f, 9.83354449e-02f, 1.45966679e-01f, -1.56511784e-01f, -1.96094275e-01f, -4.78261083e-01f, 9.49560106e-02f, 6.20235279e-02f, 2.52844483e-01f, -1.39994361e-02f,
  -3.02856505e-01f, 7.96992481e-02f, 1.63544089e-01f, 5.95306121e-02f, 5.79038799e-01f, -3.86876017e-02f, 5.19425832e-02f, 9.33203325e-02f, -1.73006356e-01f, 7.27662519e-02f,
  -3.43594216e-02f, 2.34745935e-01f, -4.99617994e-01f, -1.93982512e-01f, -1.05622649e-01f, -8.09714273e-02f, 4.62004682e-03f, 7.33996853e-02f, -2.20140949e-01f, 2.24585518e-01f,
  3.16925406e-01f, -2.73614898e-02f, 1.67811856e-01f, -5.79996370e-02f, -5.94393909e-02f, -2.63711721e-01f, 1.23856426e-03f, -5.43040084e-03f, -1.00357443e-01f, 1.11280970e-01f,
  1.01204768e-01f, -6.25723004e-02f, 9.56133381e-02f, 3.22469085e-01f, -1.24728031e-01f, -8.31442997e-02f, 5.31068623e-01f, 3.12670529e-01f, 7.72945136e-02f, 2.53143340e-01f,
  -3.44045401e-01f, -3.84332687e-01f, -1.75918192e-01f, -1.86978653e-01f, 1.34460539e-01f, -1.00407012e-01f, -1.00929409e-01f, 1.09625310e-01f, 3.09482347e-02f, -1.91270992e-01f,
  3.96046191e-02f, 2.25046545e-01f, -6.40209615e-02f, 7.36869350e-02f, 1.43973738e-01f, -1.63309604e-01f, 3.87444168e-01f, -8.61785561e-02f, 3.57575059e-01f, -1.65170252e-01f,
  6.57639205e-02f, 1.81126580e-01f, -4.00863253e-02f, -1.81761160e-01f, 2.15561956e-01f, 3.01827252e-01f, -8.18433017e-02f, 9.03765671e-03f, 1.81111708e-01f, 6.52533844e-02f,
  4.55250293e-01f, 5.26522398e-02f, -1.86261952e-01f, -2.21203983e-01f, -5.87845594e-02f, 1.75647393e-01f, -3.57246816e-01f, -2.08614320e-01f, -6.72452971e-02f, -9.27570313e-02f,
  -1.74438849e-01f, -2.14790739e-02f, 1.69039369e-01f, -2.38286555e-02f, -3.93842638e-01f, 8.89414921e-02f, -1.65969595e-01f, 1.19188122e-01f, -1.69789255e-01f, 1.43710315e-01f,
  3.11859045e-02f, -1.50174499e-01f, 7.19474554e-02f, -8.91328380e-02f, 1.17710613e-01f, -3.82766239e-02f, -1.95186995e-02f, 2.31379420e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -7.44950213e-03f, 2.48419315e-01f, 1.37751009e-02f, -6.07275926e-02f, -9.97427776e-02f, -1.63415575e-03f, 5.75627051e-02f, -1.88073680e-01f, -6.89702034e-02f, -9.02005136e-02f,
  1.29231140e-01f, 2.45827213e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    