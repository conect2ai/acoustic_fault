/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.79955101e-01f, 1.57196045e-01f, 1.41083553e-01f, 1.91648856e-01f, -3.47965091e-01f, -1.28558815e-01f, 7.42678419e-02f, 1.31856680e-01f, -1.56098858e-01f, 1.31673411e-01f,
  1.40879757e-03f, 7.13909464e-03f, 1.69163927e-01f, -1.02488808e-01f, 1.57384589e-01f, 1.93682685e-03f, -2.66850561e-01f, 8.89837295e-02f, -1.06033804e-02f, -3.02198678e-01f,
  -3.76247078e-01f, 6.00716956e-02f, 2.60653794e-01f, 1.53303221e-02f, 4.85177934e-02f, -5.18314615e-02f, 1.56311318e-01f, 1.53126195e-01f, -1.97315542e-03f, -3.20710301e-01f,
  3.36624384e-01f, 1.99817300e-01f, -1.17207691e-01f, -1.15135811e-01f, 3.91952917e-02f, 1.46631196e-01f, 1.09982505e-01f, 1.17496632e-01f, 3.23956572e-02f, 2.83328332e-02f,
  -2.83392575e-02f, -6.04185537e-02f, -2.61432175e-02f, -6.20073825e-02f, 3.68778743e-02f, 3.70696075e-02f, 4.84250449e-02f, 1.02539003e-01f, 2.79538371e-02f, 1.11623630e-01f,
  -1.87861145e-01f, -1.14133447e-01f, 3.16232070e-02f, -4.53042537e-02f, 7.88435414e-02f, -1.69546798e-01f, 8.32623616e-02f, -9.06952843e-02f, 2.01203991e-02f, 1.63788572e-01f,
  -8.59731734e-02f, 2.97758486e-02f, -5.57962395e-02f, 5.12729734e-02f, -5.73814623e-02f, -5.63003065e-04f, 2.06537191e-02f, -6.04825057e-02f, -3.35533991e-02f, 8.41559693e-02f,
  -1.85430422e-02f, -2.63454951e-02f, -3.67553867e-02f, 9.16377306e-02f, -3.49035114e-02f, 1.74296033e-02f, -4.23873402e-02f, 3.17529659e-03f, -2.26732492e-02f, 1.59599986e-02f,
  -4.57149670e-02f, -2.38069706e-02f, 5.22224307e-02f, -1.95562840e-02f, -7.64767677e-02f, 2.34020725e-02f, -6.88854009e-02f, -4.73876260e-02f, 9.01407823e-02f, -6.12100810e-02f,
  2.60097891e-01f, -2.43924856e-01f, 1.98090538e-01f, 5.54804467e-02f, 2.86108237e-02f, 5.80300996e-03f, 2.34270785e-02f, -7.96541497e-02f, -8.29602592e-03f, 7.01311082e-02f,
  -9.19721089e-03f, 1.17987834e-01f, 1.14936531e-01f, 1.06930919e-02f, -4.95040342e-02f, -1.77603718e-02f, 6.14621385e-04f, 4.57630493e-02f, -6.09944947e-02f, 4.54738997e-02f,
  1.14240848e-01f, -8.64937082e-02f, 1.87858924e-01f, 5.68364635e-02f, -1.06245996e-02f, -8.50616768e-02f, 1.22837424e-01f, 6.66310191e-02f, 7.61918873e-02f, 2.70207644e-01f,
  -5.88692650e-02f, 3.16499919e-01f, -1.65360108e-01f, 3.16693991e-01f, -1.44367546e-01f, -1.86588928e-01f, -5.38664937e-01f, 9.69864130e-02f, 3.46577942e-01f, 2.06399150e-02f,
  1.64031804e-01f, 1.29308298e-01f, 3.60501856e-01f, 8.73249024e-02f, -2.08964840e-01f, -1.45065397e-01f, -3.24782543e-02f, -1.29711822e-01f, -3.83226395e-01f, -4.61319983e-01f,
  -1.23968169e-01f, -2.47206315e-02f, 1.53895631e-01f, 2.31465064e-02f, 1.57962456e-01f, 1.95869267e-01f, 4.11912829e-01f, 1.91954374e-02f, -2.26985067e-02f, 2.66421996e-02f,
  -1.22613460e-01f, 1.83974698e-01f, -3.21203023e-02f, 1.62678942e-01f, 1.74185514e-01f, 5.86845428e-02f, 2.45653298e-02f, 2.01248333e-01f, 8.27829987e-02f, 1.06944360e-01f,
  8.23952407e-02f, 3.65096368e-02f, 6.49404451e-02f, 1.09682024e-01f, 5.38857020e-02f, 8.80979002e-02f, 1.69316739e-01f, 8.58267769e-02f, 1.31381497e-01f, 1.30162716e-01f,
  2.18436122e-02f, -9.05633122e-02f, -7.82127753e-02f, 1.02053983e-02f, 3.44407335e-02f, 1.14420764e-01f, 4.14584912e-02f, 8.43305290e-02f, 1.18039191e-01f, 1.04454167e-01f,
  2.58907527e-02f, -6.76698377e-03f, -5.85081317e-02f, -8.71586129e-02f, -6.70588203e-03f, 1.20817358e-02f, 2.03955043e-02f, -1.08860202e-01f, 7.33309751e-03f, -5.07786982e-02f,
  -2.56180707e-02f, 2.07277108e-02f, -1.72012281e-02f, 7.80465896e-04f, 4.97017168e-02f, 3.28027681e-02f, -1.03359424e-01f, 3.36623378e-02f, -5.16252453e-03f, 1.68034658e-02f,
  -5.07378951e-02f, -6.54428899e-02f, -4.15059272e-04f, -3.93720604e-02f, -9.23489686e-03f, 8.44182819e-03f, -3.17077972e-02f, 1.92170758e-02f, 8.05750117e-02f, 6.42745569e-03f,
  2.64965922e-01f, 1.89383631e-03f, 1.20364949e-01f, -6.66081253e-03f, 2.94964779e-02f, 1.23810656e-01f, 6.35809526e-02f, 1.79920532e-02f, 8.19608644e-02f, 3.42698768e-02f,
  -6.47940710e-02f, -3.61230411e-03f, 5.22164404e-02f, -2.24017026e-03f, -4.61901613e-02f, -2.51431894e-02f, 2.47700606e-02f, -6.42273948e-02f, 5.07671572e-02f, 8.44350234e-02f,
  8.29842463e-02f, -1.01732597e-01f, -1.92888558e-01f, -5.05380891e-02f, 3.96429598e-02f, -1.08958825e-01f, -3.42999846e-02f, -1.09977443e-02f, -1.27992198e-01f, -8.68863016e-02f,
  -3.75868604e-02f, 1.86491653e-01f, 5.13779938e-01f, -7.38447607e-02f, 3.64540219e-01f, 2.19431296e-01f, 4.19487566e-01f, -1.91356894e-02f, -7.81940892e-02f, 3.35027069e-01f,
  4.76072021e-02f, -3.99618417e-01f, -4.78267998e-01f, -3.61650646e-01f, -2.68974751e-01f, 2.97407418e-01f, 2.24650204e-01f, -1.91173360e-01f, -3.03971380e-01f, -3.10027152e-02f,
  -1.55376017e-01f, 3.34585831e-02f, -2.66187191e-01f, -1.91264957e-01f, 1.91251010e-01f, -2.65924484e-01f, 2.25256979e-01f, 4.93402593e-02f, 1.89850137e-01f, 1.58347577e-01f,
  1.01390541e-01f, 2.52242774e-01f, -1.82943344e-01f, -1.81987345e-01f, -5.10853194e-02f, -4.99390252e-02f, -6.37142509e-02f, 2.67067198e-02f, -6.25164509e-02f, -2.23447233e-02f,
  -3.47984694e-02f, -6.41893372e-02f, -2.33307108e-02f, -2.35459283e-02f, 1.33903762e-02f, 6.36269618e-03f, -4.29817028e-02f, -1.78795487e-01f, -1.47996143e-01f, 2.55870726e-02f,
  -7.67196566e-02f, 1.25998944e-01f, 1.67799652e-01f, 8.54945183e-03f, -8.29480663e-02f, -1.67678237e-01f, 1.05991594e-01f, 7.34704435e-02f, -5.20268381e-02f, 2.43323296e-02f,
  -7.57396668e-02f, 9.12846550e-02f, 5.32941595e-02f, -2.69119977e-04f, -4.49838303e-02f, 1.07062506e-02f, 2.90367268e-02f, -4.14037555e-02f, -3.27819660e-02f, 3.63290422e-02f,
  -2.24081725e-02f, 4.40973490e-02f, -3.63093689e-02f, 4.96633118e-03f, -4.56058420e-02f, 8.12187269e-02f, 6.06539547e-02f, -6.89693764e-02f, -1.00934654e-01f, -5.74428076e-03f,
  -3.90174575e-02f, -1.61900150e-03f, 5.39682247e-02f, -6.97852001e-02f, 2.16182936e-02f, -3.84413498e-03f, -1.10469358e-02f, 6.23413846e-02f, -5.76355755e-02f, 6.88308105e-02f,
  -2.43763790e-01f, -9.53338668e-02f, -4.79052216e-02f, -4.48260568e-02f, 5.75488657e-02f, -1.18047763e-02f, 1.38257705e-02f, 2.61878152e-03f, 2.60794088e-02f, -5.30578708e-03f,
  -7.80064836e-02f, 1.51572749e-02f, 2.70051304e-02f, 4.21960540e-02f, -3.91002297e-02f, -2.27636583e-02f, -6.12788014e-02f, -8.67201015e-02f, 2.89223213e-02f, 2.89668981e-02f,
  -4.96143177e-02f, -9.85585852e-04f, -6.33456856e-02f, -9.48756710e-02f, -2.67632436e-02f, 3.83047312e-02f, -3.23701017e-02f, -1.04325414e-01f, 4.64789122e-02f, -1.33038670e-01f,
  1.54898986e-01f, -2.33068287e-01f, -7.74861872e-03f, -3.10017973e-01f, 3.39392982e-02f, 3.30137074e-01f, 7.74887353e-02f, -9.34011340e-02f, -7.03020990e-02f, 5.03784865e-02f,
  2.29251593e-01f, -5.16411522e-03f, 6.30486608e-02f, -1.05685322e-02f, 2.00482816e-01f, 3.56981568e-02f, -1.94012806e-01f, -1.00888394e-01f, 2.09729970e-01f, 1.01512112e-01f,
  -1.44131944e-01f, -3.53870511e-01f, -1.43553957e-01f, 1.50317149e-02f, -1.69372380e-01f, 1.81368604e-01f, -4.44130227e-02f, -1.12263829e-01f, 2.20085368e-01f, -7.11882472e-01f,
  6.54835030e-02f, -2.89765924e-01f, 9.12038386e-02f, 7.63336793e-02f, 1.31718731e-02f, 6.97381422e-02f, 6.80575147e-02f, -5.84160723e-02f, 1.29691765e-01f, -5.00006005e-02f,
  -3.93374860e-02f, 1.19400173e-02f, -8.11918527e-02f, -1.20236702e-01f, -3.56018394e-02f, -6.79956377e-02f, -1.36797383e-01f, -1.42880559e-01f, -8.93947110e-03f, 2.78930999e-02f,
  -1.17052719e-01f, -3.09415925e-02f, -3.09869349e-02f, 5.07948026e-02f, -9.98129100e-02f, 8.91204271e-03f, 1.01691810e-02f, -1.21470146e-01f, 1.14835195e-01f, -1.64181143e-01f,
  1.47107961e-02f, 7.28761181e-02f, 1.22554842e-02f, -4.59063798e-02f, -1.94536138e-03f, -1.35826543e-02f, -8.43122527e-02f, 3.55315432e-02f, -5.60279824e-02f, -4.76447344e-02f,
  4.16436829e-02f, 6.89252140e-03f, -3.55205163e-02f, 9.28395707e-03f, 4.15508188e-02f, -5.41890711e-02f, -3.79841961e-02f, 1.02722198e-02f, 1.80956360e-03f, -1.78944245e-02f,
  -7.32747987e-02f, 3.78024317e-02f, -9.04873759e-02f, -1.09628700e-01f, 3.53806256e-03f, -6.10536151e-02f, -4.49981503e-02f, 4.58943797e-03f, 7.09552784e-03f, 1.51874088e-02f,
  1.43865556e-01f, 2.65339941e-01f, -4.10010740e-02f, -1.71261113e-02f, 1.46808363e-02f, -5.60067222e-03f, -3.58512178e-02f, -1.91462021e-02f, -2.54650470e-02f, 5.47508709e-02f,
  4.79436815e-02f, 5.05324379e-02f, 2.92925835e-02f, -2.75690183e-02f, 7.87717700e-02f, 1.04938962e-01f, 6.10033572e-02f, 4.75321300e-02f, 1.87309813e-02f, 1.72610190e-02f,
  -8.92680977e-03f, 9.21311677e-02f, 2.00548247e-01f, 6.54430836e-02f, 4.45260927e-02f, 2.23149195e-01f, 1.21474110e-01f, 1.12210616e-01f, 2.96845168e-01f, 3.12639356e-01f,
  3.61469448e-01f, -3.76045406e-01f, -2.03640953e-01f, -6.91653341e-02f, 1.26760110e-01f, 2.86590397e-01f, 4.14342612e-01f, 2.11528271e-01f, -1.79587435e-02f, -1.32900968e-01f,
  -1.55650392e-01f, -1.99597597e-01f, -5.17732382e-01f, -2.33627513e-01f, 8.01366121e-02f, -9.94913504e-02f, -3.81532937e-01f, -1.91655040e-01f, 3.45902771e-01f, 6.85428262e-01f,
  2.18358979e-01f, 1.44061103e-01f, 1.25382081e-01f, 8.59291553e-02f, -6.19882606e-02f, -1.25909850e-01f, -3.97815228e-01f, -2.77508974e-01f, 1.45011768e-02f, -5.52522659e-01f,
  -2.26324186e-01f, -6.88873678e-02f, 1.18379608e-01f, -6.40027225e-02f, -6.69822618e-02f, 5.91156706e-02f, 1.17577106e-01f, -8.12922567e-02f, -7.77991265e-02f, 7.31742068e-04f,
  -1.38799071e-01f, -1.58712156e-02f, -5.45501299e-02f, 2.90370733e-02f, 4.07152586e-02f, 3.33250538e-02f, -8.88449401e-02f, -3.78215127e-02f, -1.08466655e-01f, 6.61078468e-02f,
  -9.75079462e-02f, -3.94091792e-02f, -1.40256613e-01f, 1.93342622e-02f, 7.38041028e-02f, -1.10273592e-01f, -4.80987206e-02f, 9.93844345e-02f, 8.79439190e-02f, 8.63911882e-02f,
  2.10822579e-02f, -4.55274880e-02f, 5.03240265e-02f, 4.94259596e-02f, -1.31755397e-02f, -2.27606334e-02f, -6.87686801e-02f, -3.68671417e-02f, 4.68315780e-02f, 3.70577015e-02f,
  -3.96474684e-03f, -1.34099303e-02f, 2.32899692e-02f, -6.04836084e-03f, -8.13249324e-04f, -9.46473405e-02f, 5.60479285e-03f, -1.96756516e-02f, -9.64161679e-02f, 1.30102588e-02f,
  3.11435591e-02f, -1.84540097e-02f, -6.56716675e-02f, 5.38042672e-02f, 7.46832937e-02f, -7.58007839e-02f, 1.29430322e-02f, 3.60780247e-02f, 6.98493980e-03f, -1.45849437e-02f,
  1.03067160e-01f, -9.89595428e-02f, -7.50370771e-02f, 2.83103436e-02f, -6.25095144e-02f, -1.09475395e-02f, -7.60842189e-02f, -3.90240066e-02f, -1.26694977e-01f, -2.87312223e-03f,
  6.18159734e-02f, 4.68444936e-02f, -9.33009386e-02f, -7.24430243e-03f, 1.54500112e-01f, 5.32160737e-02f, -4.04213853e-02f, -5.48057146e-02f, 3.58330719e-02f, -5.35708182e-02f,
  -1.44603401e-02f, 1.15190543e-01f, 1.20686054e-01f, -1.02237456e-01f, -4.51146252e-02f, 1.97268985e-02f, 3.23632956e-02f, 4.77463081e-02f, 4.78318371e-02f, 1.56478569e-01f,
  7.15093136e-01f, -7.44427294e-02f, -1.54404283e-01f, 2.44666085e-01f, 1.08163066e-01f, -5.70054948e-02f, 4.84387875e-02f, -5.89253940e-03f, -1.99946389e-02f, 2.60588676e-01f,
  -2.28399158e-01f, -1.12784244e-01f, -1.70923546e-01f, -2.30107456e-01f, -1.28681332e-01f, 1.09022506e-01f, 1.54279724e-01f, -9.92523357e-02f, -1.98801935e-01f, 5.55302165e-02f,
  6.41330481e-02f, 1.59000903e-01f, -1.05726413e-01f, -1.03863459e-02f, 3.89521867e-01f, 2.56055266e-01f, 4.18073405e-03f, 1.69719920e-01f, -2.91783214e-02f, 8.69460404e-01f,
  1.76368535e-01f, -7.67287537e-02f, -1.07217327e-01f, 1.77110508e-02f, -8.90228059e-03f, 3.18390341e-03f, 2.96345875e-02f, -2.61692721e-02f, 4.59224619e-02f, 1.49729177e-02f,
  -5.22945970e-02f, -3.78025658e-02f, 5.82243502e-02f, -7.15490151e-03f, 1.42437173e-02f, -3.79519127e-02f, -9.87413228e-02f, -7.91654810e-02f, -4.21259589e-02f, -4.26022485e-02f,
  1.14661135e-01f, 3.74878049e-02f, -4.47784699e-02f, -1.56946048e-01f, -2.09090531e-01f, -1.39061436e-01f, -5.70906475e-02f, 3.36841606e-02f, -8.71844739e-02f, 4.30800676e-01f,
  3.92527804e-02f, 3.21630612e-02f, -6.64768592e-02f, 9.69837382e-02f, -1.95500813e-02f, 6.11227565e-03f, -6.40737265e-03f, 5.29140932e-03f, -8.34611803e-03f, 7.14808553e-02f,
  7.92990730e-04f, -5.52053675e-02f, -8.63484964e-02f, 1.56176845e-02f, 4.74232025e-02f, -7.18057975e-02f, 5.90963615e-03f, 8.70144367e-03f, -6.13053516e-02f, 9.95409302e-03f,
  -1.25161437e-02f, 1.85851157e-02f, -2.57348400e-02f, 3.66995670e-02f, -1.06040891e-02f, -4.82128784e-02f, 3.46358530e-02f, -2.15833094e-02f, -4.36934503e-03f, 4.69056070e-02f,
  -3.40557024e-02f, -3.17712903e-01f, 2.41428226e-01f, -1.02748081e-01f, 2.56336257e-02f, -3.29682864e-02f, -1.05171138e-02f, 4.51017357e-02f, 6.83783600e-03f, 5.15619330e-02f,
  -7.53971040e-02f, 3.56801413e-02f, -2.34290529e-02f, 1.80668943e-02f, 4.43011299e-02f, 3.57665084e-02f, -4.80206963e-03f, 6.62298203e-02f, -3.62733975e-02f, 6.94711357e-02f,
  2.31749509e-02f, 3.81898731e-02f, 4.83044349e-02f, 4.12163325e-03f, 6.98918626e-02f, 7.39789531e-02f, 5.37064038e-02f, 8.96606371e-02f, -4.41236533e-02f, 2.29205996e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.88981915e+00f, 6.76803440e-02f, 7.30514079e-02f, -6.96173608e-01f, 1.07434559e+00f, -4.68372367e-02f, -5.63873708e-01f, -8.80200803e-01f, -4.87301558e-01f, 9.59713981e-02f,
  6.35018051e-01f, 7.22529888e-01f, 1.99835360e-01f, 3.83056492e-01f, -1.12486136e+00f, -4.38984483e-01f, -8.33342075e-01f, -1.00110543e+00f, -5.01952887e-01f, 5.38111806e-01f,
  6.95142865e-01f, -3.71443838e-01f, -1.07156706e+00f, -5.68895876e-01f, 6.03267133e-01f, 3.71127486e-01f, -1.52537614e-01f, 1.89287290e-01f, 2.84358740e-01f, 8.79394293e-01f,
  7.31088579e-01f, 1.05313798e-02f, 5.61998971e-02f, 5.13899364e-02f, 3.64299536e-01f, -2.15064853e-01f, -3.40810306e-02f, -1.26216307e-01f, 2.95779090e-02f, -2.18825907e-01f,
  3.32311332e-01f, 2.24323139e-01f, -1.77995101e-01f, 2.42629394e-01f, -1.67867215e-03f, -1.29048750e-01f, -2.33524129e-01f, -5.45067787e-01f, -4.13399965e-01f, 3.38292629e-01f,
  6.98351443e-01f, 2.33109444e-01f, -2.27068961e-02f, -2.98735648e-01f, -4.12484318e-01f, 6.16204515e-02f, 8.84072930e-02f, 2.04248596e-02f, -6.24674559e-01f, 4.55757566e-02f,
  -2.83377357e-02f, -1.41809173e-02f, 1.80142701e-01f, -3.46912891e-02f, 1.92501154e-02f, -6.84097558e-02f, 5.47323711e-02f, 9.23694298e-02f, -1.85113549e-01f, -3.56852934e-02f,
  7.24946056e-03f, -6.85038939e-02f, 7.15899244e-02f, -1.38961911e-01f, -3.09288763e-02f, -9.91426632e-02f, -1.27977394e-02f, -1.26595020e-01f, 4.66282405e-02f, 4.45463695e-03f,
  -1.82647109e-01f, 1.70838162e-02f, 7.83536285e-02f, 3.05587091e-02f, -6.78802133e-02f, 2.20366362e-02f, 1.86634943e-01f, -3.65852043e-02f, -4.38509397e-02f, 1.46437407e-01f,
  -1.24361843e-01f, -3.12693208e-01f, 1.57760546e-01f, -1.12283649e-02f, -1.73768662e-02f, 8.39417055e-02f, 2.46713787e-01f, 4.86869477e-02f, 3.36371034e-01f, -2.07355693e-02f,
  5.34303375e-02f, -2.41279289e-01f, 6.86583519e-02f, 8.67664889e-02f, 3.09711918e-02f, 5.45342080e-02f, 2.12657191e-02f, 1.30965561e-01f, -2.14882456e-02f, 2.99470425e-01f,
  -1.80087849e-01f, -4.46338713e-01f, -3.13610971e-01f, 1.35710284e-01f, 1.38953745e-01f, -2.03399897e-01f, 3.49572450e-01f, 1.72140658e-01f, -2.56328076e-01f, -3.36899340e-01f,
  7.93221712e-01f, -8.57464969e-01f, -1.44736141e-01f, 6.50217295e-01f, 5.60913980e-01f, 3.75902414e-01f, 3.49103004e-01f, 1.06210053e-01f, 2.30503365e-01f, -2.13938765e-03f,
  1.08591422e-01f, 5.04369557e-01f, 4.41629469e-01f, 2.64480412e-01f, 2.50592619e-01f, 9.65834633e-02f, 2.53711402e-01f, 2.29403526e-01f, 2.20627353e-01f, 3.13001946e-02f,
  1.80891789e-02f, -3.28915685e-01f, -2.92863339e-01f, -7.83430263e-02f, -1.25380769e-01f, 2.96552986e-01f, -1.01826623e-01f, -2.45538965e-01f, -2.91065484e-01f, -1.06540821e-01f,
  -5.22698164e-01f, -1.68835595e-02f, 4.16364938e-01f, 1.66917369e-01f, -6.99562132e-02f, -1.30994737e-01f, -1.07084122e-02f, -2.95694917e-01f, -1.69529021e-01f, -2.11607084e-01f,
  -2.88909618e-02f, -2.17463747e-02f, 1.62351325e-01f, -2.22702429e-01f, -1.02161624e-01f, -1.16185643e-01f, -1.88719705e-01f, -1.22734509e-01f, 4.70265411e-02f, -1.11791722e-01f,
  -9.72880516e-03f, -1.31314218e-01f, 3.46105807e-02f, 8.11508819e-02f, 2.48265982e-01f, 2.10852087e-01f, -1.37137204e-01f, -1.29439503e-01f, 6.17556423e-02f, -4.27078642e-02f,
  2.94268191e-01f, 6.13954440e-02f, 2.61234045e-01f, -2.03323681e-02f, 1.39745906e-01f, 2.50730217e-02f, 6.93963692e-02f, 4.62147072e-02f, 2.11444214e-01f, -8.48515108e-02f,
  1.39924269e-02f, 8.70131627e-02f, 8.69672000e-03f, 2.10114434e-01f, 1.88268982e-02f, -1.06061220e-01f, -9.67812464e-02f, -1.60674639e-02f, -1.98284350e-02f, -6.01570047e-02f,
  1.55493813e-02f, 1.06516100e-01f, -1.81818202e-01f, -1.40357643e-01f, -9.59807783e-02f, 6.16603494e-02f, 3.39526348e-02f, -6.39188141e-02f, 3.69077064e-02f, -1.72477886e-01f,
  -2.73526907e-01f, 5.19895554e-01f, 3.19009453e-01f, 3.79114300e-02f, -8.25097412e-02f, -3.10164362e-01f, 2.13953763e-01f, -2.27299809e-01f, -3.48297745e-01f, -2.35864550e-01f,
  -6.49603605e-02f, -9.44456384e-02f, -1.16774559e-01f, -1.68926746e-01f, -6.44055530e-02f, -4.56900187e-02f, 1.42827882e-02f, 1.53591007e-01f, 4.10515703e-02f, -2.71077722e-01f,
  -1.94815680e-01f, 1.75828077e-02f, 2.43105546e-01f, 1.98844850e-01f, 1.95016876e-01f, 3.93815637e-01f, -5.36942445e-02f, -2.26398073e-02f, 1.14874862e-01f, 1.91539084e-03f,
  -1.47152448e+00f, 1.46983480e+00f, -8.97584558e-01f, -4.83388841e-01f, 1.92989215e-01f, 3.66356641e-01f, 1.45667398e+00f, 5.57414472e-01f, -4.40897673e-01f, 4.08776909e-01f,
  4.68293190e-01f, -6.49336815e-01f, -2.54817545e-01f, -2.11131871e-01f, 3.91437709e-01f, 9.52486336e-01f, 5.91145396e-01f, -8.91950846e-01f, -1.23956847e+00f, -3.12237293e-01f,
  1.82774574e-01f, -2.42307067e-01f, -4.51441795e-01f, -1.41264170e-01f, -4.28283289e-02f, -7.57343829e-01f, 2.51240641e-01f, 4.88262326e-02f, 3.48262280e-01f, -4.51626271e-01f,
  -4.73730505e-01f, 1.47131875e-01f, -2.73900688e-01f, 1.99383479e-02f, 7.83078074e-02f, -5.91084324e-02f, -1.62712969e-02f, -1.66125417e-01f, 4.21716552e-03f, -8.72097164e-02f,
  -2.34188531e-02f, 1.07011041e-02f, -1.15692943e-01f, 6.44169673e-02f, 2.99202502e-02f, -4.73844670e-02f, 1.08088598e-01f, -1.07444361e-01f, -9.52460021e-02f, 1.60470217e-01f,
  4.65601176e-01f, -7.60972202e-02f, -4.08951379e-02f, 4.10391837e-01f, 3.13091427e-01f, -2.18193635e-01f, 3.17349195e-01f, -2.73859620e-01f, -2.85727352e-01f, -1.88092753e-01f,
  7.12824836e-02f, -3.94901596e-02f, 3.15787154e-03f, 3.87883931e-02f, 1.26506209e-01f, 6.45315945e-02f, -9.68486012e-04f, 7.78750703e-02f, -2.06165258e-02f, 8.21345970e-02f,
  7.79171214e-02f, -7.18605146e-03f, 3.08761746e-02f, 7.01059494e-03f, -1.61006004e-01f, -2.46610176e-02f, -8.92193615e-02f, 1.82947934e-01f, -1.27906362e-02f, -2.02541146e-03f,
  5.91796711e-02f, 8.47920626e-02f, 8.16714615e-02f, -7.17241839e-02f, 7.96774551e-02f, -1.03901252e-01f, -1.45420149e-01f, -3.91748175e-02f, -8.00581053e-02f, -9.36891418e-03f,
  1.39836118e-01f, -1.00250188e-02f, -2.55823210e-02f, -6.13267273e-02f, -5.98410405e-02f, 7.62710571e-02f, -8.88267979e-02f, 1.84545834e-02f, 3.20371427e-02f, -3.48934904e-02f,
  1.28767133e-01f, -7.89333284e-02f, 1.64858162e-01f, -2.70824693e-02f, -1.61945120e-01f, -2.35033222e-02f, 2.81342268e-01f, -1.80063635e-01f, -2.02810336e-02f, -4.54902835e-02f,
  1.57772541e-01f, -9.15505067e-02f, -1.68017790e-01f, -9.52091068e-02f, -9.36418399e-02f, -2.19457239e-01f, -5.49840890e-02f, -1.21491954e-01f, 5.16067408e-02f, 5.85988522e-01f,
  1.18053603e+00f, -5.62812626e-01f, -1.89061856e+00f, 3.24244291e-01f, -9.16950345e-01f, -2.03001678e-01f, -9.87398386e-01f, 5.77832341e-01f, 1.15048206e+00f, -5.59787810e-01f,
  1.18777707e-01f, 7.18806982e-01f, -5.89306764e-02f, 3.21895890e-02f, -2.58073300e-01f, -1.21754813e+00f, -1.22479153e+00f, -1.18053174e+00f, -4.41207886e-01f, 1.11329719e-01f,
  -1.99892893e-01f, -6.53716326e-01f, -2.89007634e-01f, -2.23707959e-01f, -3.72795314e-01f, -4.16176468e-01f, -1.10301864e+00f, -9.07734275e-01f, -9.58710372e-01f, -1.75758660e+00f,
  -1.28638303e+00f, 1.42433748e-01f, -6.71117231e-02f, 2.75403380e-01f, -4.58556265e-01f, 4.15762484e-01f, -8.06434266e-03f, -6.85858950e-02f, 3.54592502e-01f, 5.44876680e-02f,
  1.28895611e-01f, 3.32914948e-01f, 3.45438570e-01f, -2.77425647e-01f, 3.53002883e-02f, -3.84864621e-02f, 1.82746351e-01f, -2.00874731e-01f, -1.34804189e-01f, 1.65382877e-01f,
  -7.38524050e-02f, -1.82052121e-01f, -2.77471960e-01f, 5.87031953e-02f, 3.14910449e-02f, -1.80453390e-01f, -3.49945545e-01f, 6.19422458e-02f, -2.95686901e-01f, -5.00583649e-01f,
  -2.05958679e-01f, 7.54732043e-02f, -2.84381807e-01f, 9.70556512e-02f, 3.41874272e-01f, 1.94040686e-02f, 6.73964694e-02f, -1.70221359e-01f, -8.83827731e-02f, -6.08866476e-02f,
  -4.41696830e-02f, -1.67657197e-01f, 1.22469552e-01f, -7.40185827e-02f, -1.86900973e-01f, -8.20343420e-02f, 5.06656505e-02f, -8.42225477e-02f, -9.06093493e-02f, -2.34466745e-03f,
  3.38485241e-02f, 1.99747980e-01f, 9.83282402e-02f, -2.04798188e-02f, -2.04061165e-01f, -5.10377586e-02f, 3.17930914e-02f, 1.39725104e-01f, 1.32991582e-01f, 1.40695870e-01f,
  4.99313623e-01f, 1.29508087e-02f, 7.67136291e-02f, 4.30004179e-01f, 4.46859449e-02f, 2.15249598e-01f, -3.08338236e-02f, 1.17814749e-01f, 2.70941913e-01f, 1.78555414e-01f,
  1.09306395e-01f, 3.12122572e-02f, -1.35153964e-01f, 1.48167834e-02f, -5.70912287e-02f, 5.92041276e-02f, 9.94395539e-02f, -5.88677041e-02f, 1.75386712e-01f, 2.07198441e-01f,
  1.34605750e-01f, 1.01210244e-01f, 1.10301495e-01f, 2.60066409e-02f, 3.92238468e-01f, 2.19521523e-01f, -2.71299481e-01f, -1.95887387e-01f, 7.97044933e-02f, -4.91072573e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.49987614e+00f, 8.51538420e-01f, 1.98430622e+00f, 4.08982933e-02f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -4.30482179e-01f, 2.61023436e-02f, -7.16758251e-01f, 2.64557451e-01f, -1.74785507e+00f, -1.13420463e+00f, -1.20147109e+00f, -7.08955303e-02f, -1.12123680e+00f, 1.39110163e-01f,
  1.60798883e+00f, 1.07403323e-01f, -9.68634188e-02f, -6.17442071e-01f, -7.96126962e-01f, 5.57171643e-01f, -1.61994547e-01f, 2.81879008e-01f, -1.14393139e+00f, -1.27922878e-01f,
  4.20493841e-01f, -2.56283432e-02f, 6.00768030e-01f, -3.29297364e-01f, -5.00053585e-01f, 1.01951957e+00f, 4.34287228e-02f, -6.92842543e-01f, -1.78063786e+00f, 8.78549874e-01f,
  -3.02075410e+00f, 8.38643670e-01f, 8.86722386e-01f, 7.63409078e-01f, 1.71283841e-01f, 1.36995852e+00f, 5.63991666e-01f, 9.85989988e-01f, -1.17761803e+00f, 9.30876672e-01f,
  -1.72915435e+00f, -9.36737418e-01f, -1.24395204e+00f, -2.26152062e+00f, -6.68788970e-01f, -5.52149236e-01f, -1.91467118e+00f, -5.72790980e-01f, -8.08074236e-01f, 2.40602076e-01f,
  -4.59013909e-01f, -1.10022701e-01f, 1.45807773e-01f, -1.18942952e+00f, -2.23577261e+00f, -6.36003554e-01f, 9.49563384e-01f, 1.69304430e+00f, 5.97709835e-01f, 3.20917368e-02f,
  2.50367165e-01f, -1.31350529e+00f, 1.02322423e+00f, -4.67568517e-01f, 3.98507237e-01f, -1.88472402e+00f, 1.86101586e-01f, 8.90560985e-01f, 4.70839627e-02f, -4.15844589e-01f,
  3.75476152e-01f, 6.11619473e-01f, 1.10692084e+00f, -6.76244676e-01f, -1.15712523e+00f, -1.65444207e+00f, 5.35196483e-01f, -1.04313776e-01f, -1.58266291e-01f, 1.59171313e-01f,
  -4.39873226e-02f, 2.83500105e-01f, 4.45194066e-01f, 7.22840428e-01f, -1.32412180e-01f, 1.22143388e+00f, 1.02616858e+00f, 6.24123752e-01f, -1.67673767e+00f, 1.01337278e+00f,
  1.09730053e+00f, 8.86914492e-01f, -1.25007570e+00f, -5.29664993e-01f, 3.28632325e-01f, 2.39639148e-01f, 6.73697472e-01f, 8.18796396e-01f, 1.14055097e+00f, -1.79930961e+00f,
  1.16211236e+00f, -7.50916719e-01f, 1.64520061e+00f, 6.27218008e-01f, 6.25882268e-01f, -1.15024340e+00f, -1.29478371e+00f, 1.45859718e+00f, -2.64936924e+00f, -8.78269076e-01f,
  -1.31952763e+00f, -1.28615749e+00f, -1.69484127e+00f, 3.37548554e-02f, 2.12322325e-02f, -1.09806716e+00f, -3.42382222e-01f, -4.45190132e-01f, -8.85099828e-01f, -2.20078811e-01f,
  3.61797750e-01f, -7.40225017e-01f, -7.20330358e-01f, -8.71852711e-02f, 1.32611528e-01f, 4.83262718e-01f, 9.15603161e-01f, -2.01416206e+00f, 1.09909499e+00f, -1.39306784e+00f,
  1.08516824e+00f, -6.46913350e-01f, -1.24766123e+00f, 5.07908128e-03f, 2.96867877e-01f, -1.19508839e+00f, 1.46377850e+00f, 1.31992769e+00f, 1.57605672e+00f, 1.49152327e+00f,
  -7.98461616e-01f, 1.78637698e-01f, -6.16458476e-01f, -5.81483424e-01f, 2.41052151e-01f, 1.58236891e-01f, 6.53525412e-01f, -7.63019681e-01f, -4.28872436e-01f, -4.87588167e-01f,
  -1.52145028e+00f, 4.23141599e-01f, -2.89847583e-01f, -1.45524418e+00f, -9.23714519e-01f, 2.09387803e+00f, 1.20641911e+00f, -1.83161542e-01f, -1.92110276e+00f, -7.65771925e-01f,
  -4.21209455e-01f, 2.04256073e-01f, 2.84034759e-01f, -1.38233829e+00f, 1.88580394e-01f, 1.16498137e+00f, 1.41228175e+00f, -1.35497117e+00f, -1.17505276e+00f, 1.38585305e+00f,
  1.40585452e-01f, -5.63554704e-01f, 1.04363406e+00f, -1.01901650e+00f, 1.05194628e-01f, -8.97967398e-01f, 7.53268003e-01f, 3.39456111e-01f, -1.95567036e+00f, 1.27204430e+00f,
  4.25891608e-01f, 7.55083203e-01f, 1.66942310e+00f, -6.04267716e-01f, 9.02053297e-01f, -9.25257206e-01f, 1.54654533e-01f, 4.01728570e-01f, -1.60646033e+00f, -6.00743890e-01f,
  1.09377110e+00f, -1.33324802e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -9.82739553e-02f, -3.56913991e-02f, 8.80700529e-01f, -8.88293207e-01f, -3.27567607e-01f, 3.54473591e-01f, 1.33106768e+00f, -7.70541072e-01f, 6.45008624e-01f, -2.89520323e-01f,
  -6.13863170e-01f, 1.81315348e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    