/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.83124554e-01f, -1.29018232e-01f, -3.04191709e-01f, 8.74802545e-02f, 2.76591539e-01f, 2.07808912e-01f, 1.19999632e-01f, 9.48001444e-02f, -1.14303632e-02f, -1.83558315e-02f,
  7.29085356e-02f, 8.59296396e-02f, -6.82551563e-02f, 1.77977979e-01f, -5.98960370e-03f, -5.86792678e-02f, 1.34304166e-03f, -1.83073953e-01f, 3.14815789e-02f, 3.38097811e-01f,
  2.71106750e-01f, -1.49524231e-02f, -1.76727548e-01f, 9.88340527e-02f, -9.19636935e-02f, 9.94761242e-04f, -1.42914027e-01f, -1.25490814e-01f, -4.82822806e-02f, -3.12187016e-01f,
  -2.44842857e-01f, -2.25066945e-01f, -2.82817949e-02f, -2.08214168e-02f, -1.99692063e-02f, -7.58181214e-02f, -3.22807170e-02f, -1.59831166e-01f, 1.57769099e-02f, -2.99453028e-02f,
  -1.06027126e-02f, -1.95564236e-02f, -3.53859626e-02f, 6.77814558e-02f, -6.28611371e-02f, 1.94813013e-02f, 7.77128013e-03f, -6.65605217e-02f, -1.17062293e-01f, -2.20244247e-02f,
  1.42288879e-01f, -4.74431589e-02f, -6.93023577e-02f, 6.49453402e-02f, -3.60224629e-03f, -3.09539190e-03f, 6.90647215e-02f, -5.44675179e-02f, -3.84969637e-02f, -2.00161859e-01f,
  -4.59641851e-02f, -6.66210502e-02f, -7.44324178e-02f, -1.35754822e-02f, 6.40548468e-02f, -9.15383995e-02f, -2.71638185e-02f, 1.03677474e-01f, 8.98403451e-02f, -7.66217634e-02f,
  1.10522900e-02f, -1.75303835e-02f, 5.56329563e-02f, -3.67778800e-02f, 4.97130230e-02f, -2.47197803e-02f, 6.20592851e-04f, 2.66772509e-02f, 8.85839611e-02f, -1.22930091e-02f,
  9.47476644e-03f, -1.08718187e-01f, -6.65078685e-02f, -4.22843872e-03f, -4.66960110e-02f, 5.65740690e-02f, -4.67893556e-02f, 1.01161502e-01f, -4.78326343e-02f, -2.94059254e-02f,
  7.57254586e-02f, -1.36511609e-01f, -1.06205873e-01f, -4.49707173e-02f, -2.94110551e-02f, -2.03835517e-02f, -1.74617525e-02f, 3.13344263e-02f, 9.36889206e-04f, 4.54054140e-02f,
  -6.46021031e-03f, -6.83619827e-02f, -4.11179475e-02f, -4.36891317e-02f, 6.03060052e-02f, 6.28151447e-02f, 3.73007506e-02f, -5.09246765e-03f, 3.37641835e-02f, 7.93588720e-03f,
  3.83562893e-02f, 7.14351684e-02f, -1.33638764e-02f, 5.89928851e-02f, -6.51958063e-02f, -7.62133300e-02f, -9.11820531e-02f, -9.29272547e-02f, -2.06713036e-01f, -9.11626816e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.52116016e-01f, 5.40148735e-01f, -1.61139131e-01f, 2.04841197e-01f, 2.82649189e-01f, 2.06089750e-01f, 5.63625932e-01f, 3.24010789e-01f, 2.82425154e-02f, 9.34204534e-02f,
  2.40529105e-01f, 8.83962438e-02f, 1.37681186e-01f, 1.78061843e-01f, 3.22944283e-01f, 3.74180347e-01f, 1.97973564e-01f, -1.76991999e-01f, -3.94163251e-01f, -1.89331606e-01f,
  1.22920178e-01f, -9.17511061e-02f, -3.12365383e-01f, -1.50629327e-01f, 4.55926992e-02f, -7.69940484e-03f, 4.08512242e-02f, 7.96974152e-02f, -9.77250040e-02f, -1.66925013e-01f,
  -4.22930092e-01f, 2.32939675e-01f, -1.16272777e-01f, 3.08526400e-02f, -1.65473055e-02f, -1.98223770e-01f, -1.23333357e-01f, -3.38075131e-01f, -1.40582263e-01f, -1.03890941e-01f,
  -3.65869217e-02f, -4.22108918e-01f, -4.55900915e-02f, -1.86607167e-01f, -2.02874124e-01f, -9.64522287e-02f, -1.15209199e-01f, -5.01747690e-02f, 1.63380608e-01f, -3.11839189e-02f,
  1.23164624e-01f, 4.37826326e-04f, 3.63296345e-02f, 2.31660426e-01f, 2.05616370e-01f, 4.98525426e-02f, 5.63321970e-02f, -1.86316334e-02f, -1.12875752e-01f, -1.72663406e-01f,
  -8.13427288e-03f, 1.51362807e-01f, 1.20051980e-01f, 1.27154440e-01f, 1.10575803e-01f, 6.46729916e-02f, -5.92575446e-02f, 4.06896695e-02f, 1.31077871e-01f, 5.12442105e-02f,
  -1.69539630e-01f, 6.89102933e-02f, -2.15485334e-01f, -1.49387330e-01f, -1.53930873e-01f, -7.70687535e-02f, -9.79911834e-02f, -6.40101060e-02f, -4.40500379e-02f, -8.96968786e-03f,
  1.24029242e-01f, 4.03177701e-02f, -1.45942032e-01f, -3.04802265e-02f, -6.92348182e-02f, 1.39523178e-01f, -5.46935201e-02f, -7.93790445e-02f, -1.25567913e-01f, -1.06577486e-01f,
  -9.25588235e-03f, 3.96719247e-01f, -1.37569368e-01f, 1.01080008e-01f, -1.27848834e-01f, -1.07928902e-01f, 1.88933671e-01f, -5.06207608e-02f, 2.55690459e-02f, 1.83498695e-01f,
  4.35653105e-02f, -9.61601138e-02f, -5.17965555e-02f, -1.66139171e-01f, -2.10738540e-01f, 2.78488151e-03f, 1.09325141e-01f, -2.55861133e-02f, 3.43063362e-02f, 7.69707561e-02f,
  1.14633739e-01f, -4.47097793e-02f, -1.08536378e-01f, 1.48661509e-01f, 1.62319839e-01f, -4.39501368e-02f, 1.15929106e-02f, 3.65985408e-02f, 8.27053376e-03f, 2.41743848e-02f,
  1.07981920e+00f, -2.75814593e-01f, -6.68743789e-01f, 1.79667592e-01f, -2.64301777e-01f, -1.04696117e-01f, -4.09109414e-01f, 1.79351181e-01f, 1.60670981e-01f, -3.60897303e-01f,
  1.99493110e-01f, 4.38722908e-01f, 3.51055980e-01f, 1.77389815e-01f, 2.77130872e-01f, -4.09618974e-01f, -3.55585039e-01f, -3.83090749e-02f, 1.96988687e-01f, -7.29267001e-02f,
  1.81307681e-02f, -1.56080708e-01f, 2.41851434e-01f, 2.07925394e-01f, -2.87036717e-01f, 1.27629265e-01f, -5.78501463e-01f, -2.09000468e-01f, -2.42059693e-01f, -6.47448421e-01f,
  -1.73555464e-01f, -7.20907077e-02f, 1.35639995e-01f, 2.01068133e-01f, -1.59528151e-01f, 7.52935484e-02f, 3.27241495e-02f, -1.58349484e-01f, 9.79291797e-02f, -2.19737794e-02f,
  3.66996676e-02f, 4.86450084e-02f, 2.34608933e-01f, -8.11064243e-02f, -2.78048098e-01f, -2.15144828e-01f, -1.00715853e-01f, -3.70696746e-02f, 1.91951543e-02f, -9.51137543e-02f,
  -1.69367582e-01f, -1.57733306e-01f, -9.91716087e-02f, -8.14047977e-02f, -1.30793512e-01f, -4.96185161e-02f, -3.75131994e-01f, -2.52010167e-01f, -1.97112709e-01f, -5.41484833e-01f,
  1.13365836e-01f, -7.49077126e-02f, -5.28463982e-02f, -3.04397643e-02f, 1.14721492e-01f, 1.77921429e-02f, -3.09270676e-02f, 6.78238347e-02f, -1.17603116e-01f, -2.09984109e-01f,
  2.30564196e-02f, -8.37845057e-02f, 5.26601076e-02f, 9.16552171e-02f, -5.16497456e-02f, 9.04007629e-03f, 2.93237437e-02f, -9.33692902e-02f, 3.56800407e-02f, 1.08721843e-02f,
  6.24931231e-02f, 6.87011778e-02f, -5.33938520e-02f, 9.09304619e-02f, -6.67248815e-02f, 1.17961876e-01f, 3.24864127e-02f, -2.26365309e-02f, 1.15108967e-01f, -1.11287180e-02f,
  1.68036327e-01f, 1.92588449e-01f, -2.04308778e-02f, -5.81019744e-02f, 5.30227870e-02f, 1.09001212e-01f, 1.58607170e-01f, 6.30121008e-02f, 2.85872877e-01f, 1.04045473e-01f,
  6.18383884e-02f, 1.53886244e-01f, -5.42350747e-02f, -8.83808583e-02f, -5.18622249e-03f, -5.77798812e-03f, 6.82596937e-02f, 2.19239384e-01f, 6.04674108e-02f, -5.00805750e-02f,
  2.38219239e-02f, -2.66036368e-03f, 1.90102577e-01f, 1.08923808e-01f, -5.36519326e-02f, 6.75119087e-02f, -1.17427118e-01f, -2.80682966e-02f, 3.72612663e-02f, -5.96575402e-02f,
  4.95722830e-01f, 4.53178197e-01f, 4.51059848e-01f, 1.57085702e-01f, -3.25324424e-02f, 3.10814917e-01f, 7.00571835e-01f, 3.72184157e-01f, -3.30318324e-02f, 1.76435769e-01f,
  -1.33678066e-02f, -5.11927903e-02f, -5.59553429e-02f, -1.24523707e-01f, 1.77161902e-01f, 1.79170385e-01f, 7.82079250e-02f, 2.32129581e-02f, -3.72786373e-02f, 9.01608542e-02f,
  4.21211608e-02f, 1.34636030e-01f, -5.32242190e-03f, 6.24624193e-02f, 6.54451996e-02f, -8.25253800e-02f, 7.68252015e-02f, 4.90202568e-02f, 9.98272151e-02f, 1.48736034e-02f,
  -1.48911417e-01f, 4.02489781e-01f, -5.77583089e-02f, -1.80512995e-01f, -2.98278034e-02f, -2.99813095e-02f, 1.42842680e-02f, 3.42922993e-02f, -7.22363591e-02f, -5.04065268e-02f,
  -7.53486529e-02f, -1.86744109e-01f, -6.76137581e-02f, 8.44878182e-02f, 6.94646910e-02f, 3.34839895e-02f, 6.55709058e-02f, 1.64105505e-01f, 2.10503489e-01f, 1.12349279e-01f,
  -1.01078920e-01f, 1.73760336e-02f, 3.62132818e-01f, 1.78335533e-01f, 8.39612484e-02f, -1.23944916e-01f, 1.37178138e-01f, 1.17956772e-01f, 1.48968011e-01f, -3.66051607e-02f,
  -1.84499323e-01f, 1.00452770e-02f, 6.57925010e-02f, 1.74801629e-02f, -1.57078266e-01f, -7.91317672e-02f, -1.55648500e-01f, 5.82539104e-02f, 3.09029780e-02f, -1.75185308e-01f,
  -9.77070481e-02f, 7.46434927e-02f, 9.02653784e-02f, 1.27794921e-01f, -9.37400982e-02f, 1.55203938e-01f, 1.45837903e-01f, -6.50927005e-03f, -2.90670078e-02f, -2.24382766e-02f,
  -1.66168347e-01f, 1.47724682e-02f, 1.12158179e-01f, 1.33512383e-02f, -4.13286388e-02f, 7.07950071e-02f, -7.82875996e-03f, 1.07168503e-01f, -8.16770941e-02f, -2.57870574e-02f,
  -1.00568600e-01f, 1.00576401e-01f, -1.58223286e-01f, -9.64002311e-02f, 6.24053925e-02f, -1.46933317e-01f, 9.21989754e-02f, 2.60516889e-02f, 5.04555367e-03f, 9.51207951e-02f,
  8.54021907e-02f, -5.62565140e-02f, 4.40974161e-02f, 4.71840724e-02f, -6.53063953e-02f, -7.76064210e-03f, 5.85482977e-02f, 2.30316222e-01f, 4.25140113e-02f, 9.90007296e-02f,
  3.19728851e-02f, 1.44087434e-01f, 7.68535435e-02f, 8.56551081e-02f, -4.01614374e-03f, -5.70421331e-02f, 6.67540580e-02f, 9.27298609e-03f, 1.45922169e-01f, -6.64262101e-04f,
  -5.88556789e-02f, 3.36229473e-01f, 3.89916062e-01f, 7.36888200e-02f, 2.31586412e-01f, -1.08231306e-01f, -2.74465740e-01f, -4.08506185e-01f, -4.38766301e-01f, -8.59192461e-02f,
  2.20613599e-01f, -1.73246823e-02f, -9.00675505e-02f, -1.28847033e-01f, -2.48698756e-01f, -2.83574730e-01f, 1.12052402e-02f, 1.51670739e-01f, -2.63166159e-01f, -4.20401752e-01f,
  -6.14020042e-02f, 2.66238272e-01f, 3.52273345e-01f, -1.23510264e-01f, 2.36548722e-01f, 5.24221323e-02f, 2.97061265e-01f, 4.52715546e-01f, 4.45994258e-01f, 4.17694956e-01f,
  2.46135294e-01f, 3.08193207e-01f, -6.91048279e-02f, 1.68638527e-01f, 3.15598458e-01f, -1.09616093e-01f, 8.84268209e-02f, 2.07709250e-04f, 8.84937402e-03f, -4.74487543e-02f,
  2.32815444e-01f, -1.35065755e-02f, 5.86639112e-03f, 6.83753341e-02f, 1.04451319e-02f, -1.57837600e-01f, -1.79860577e-01f, -3.68842222e-02f, -2.28998870e-01f, -2.20461160e-01f,
  1.65047854e-01f, 4.45849299e-01f, 1.40947089e-01f, -3.61061156e-01f, -1.59550518e-01f, 1.68901399e-01f, 1.47133380e-01f, 6.00963086e-02f, 2.44343188e-03f, -2.31276199e-01f,
  -1.09491765e-01f, 1.53602168e-01f, 2.05934048e-01f, 8.99149552e-02f, 7.36096948e-02f, -2.46380605e-02f, -1.74077612e-03f, 1.19305607e-02f, -1.19546317e-01f, 4.48012799e-02f,
  -1.10644475e-01f, 3.92059870e-02f, 2.39408147e-02f, -1.42382398e-01f, 1.30069718e-01f, 2.12377146e-01f, 7.58597208e-03f, 9.79531482e-02f, -3.21984179e-02f, 1.12378336e-01f,
  -1.33423597e-01f, -1.01390537e-02f, 8.12786371e-02f, -1.01784103e-01f, 9.09322873e-03f, 6.19591400e-02f, 3.98123115e-02f, 1.50761411e-01f, 1.64381787e-02f, 2.00870782e-01f,
  -5.05040288e-01f, 4.36375439e-01f, -3.76862101e-02f, -8.30887854e-02f, 1.91813827e-01f, 1.96199760e-01f, 2.63586938e-01f, 1.41401410e-01f, 2.31231719e-01f, -1.64010838e-01f,
  8.80161021e-03f, -7.94932693e-02f, 1.37718515e-02f, -1.69504117e-02f, -8.13207552e-02f, -8.74164402e-02f, 1.75951883e-01f, -2.78250966e-02f, -1.19262584e-01f, 1.83878615e-01f,
  -1.13800943e-01f, -2.77687728e-01f, -4.32581633e-01f, -4.64472711e-01f, -1.94819734e-01f, -1.82606354e-01f, -2.55147487e-01f, -7.07036024e-03f, -3.11479121e-01f, -6.32627249e-01f,
  -5.94749689e-01f, 1.97150275e-01f, 3.10908724e-03f, 7.42385685e-02f, -1.04745477e-01f, -6.29042625e-01f, -5.75723350e-01f, -2.70059556e-01f, 9.96340290e-02f, 1.15741000e-01f,
  2.53229529e-01f, 1.75772220e-01f, 1.14888415e-01f, -8.00395757e-02f, -6.53843164e-01f, -2.33974740e-01f, -2.74200886e-01f, -2.81046361e-01f, -5.30774593e-01f, -5.79587281e-01f,
  -1.07646376e-01f, 8.96474198e-02f, 3.60924308e-03f, -4.79162596e-02f, 2.32417196e-01f, 1.03837341e-01f, 5.66209674e-01f, 1.41166970e-01f, -1.81269959e-01f, 1.29539922e-01f,
  2.65719265e-01f, -3.07247251e-01f, -1.25271501e-02f, -5.42542599e-02f, 6.41647279e-02f, 1.33702129e-01f, -7.04811737e-02f, 2.58928258e-02f, 4.77493703e-02f, -7.26757199e-02f,
  3.61924507e-02f, 1.29653320e-01f, -1.22480214e-01f, -2.89026927e-02f, -1.61068082e-01f, -3.02952677e-01f, 8.11481997e-02f, -6.53974637e-02f, -4.17940579e-02f, -1.74258158e-01f,
  -1.30824000e-01f, -3.28287184e-01f, -3.82879674e-01f, 2.65350360e-02f, -2.02263981e-01f, 1.37926894e-03f, 5.50083369e-02f, -2.01883376e-01f, -2.30873957e-01f, 2.16834337e-01f,
  6.10063560e-02f, -2.05101518e-04f, -1.08610308e-02f, -3.43183614e-02f, 4.02544700e-02f, 1.98462349e-03f, -6.88600689e-02f, -1.49976267e-02f, -4.19073403e-02f, -7.43585229e-02f,
  7.41395801e-02f, 5.72029725e-02f, 1.00546936e-02f, 5.93431443e-02f, 3.40544023e-02f, -1.32823601e-01f, -9.01019722e-02f, 1.90482765e-01f, -1.71445668e-01f, -3.21945995e-02f,
  1.00643650e-01f, 4.37099338e-02f, 1.87988237e-01f, -1.11911893e-01f, 4.71445778e-03f, -4.54997756e-02f, -4.84830886e-02f, 7.66576268e-03f, 8.53146389e-02f, -3.46653536e-02f,
  4.61044520e-01f, -1.28451094e-01f, 1.06373049e-01f, 7.53878728e-02f, -4.45476435e-02f, 4.05605137e-02f, 1.39355645e-01f, 5.46930060e-02f, -3.00618783e-02f, 1.41150858e-02f,
  -1.43392146e-01f, 6.50475696e-02f, 7.34127015e-02f, 5.00979312e-02f, -8.89639184e-02f, -1.10784449e-01f, 1.55522794e-01f, 1.37455547e-02f, -8.93705562e-02f, 1.37852877e-01f,
  1.67458475e-01f, -1.90726593e-01f, -6.12228774e-02f, 1.85481101e-01f, 1.46982335e-02f, -1.33812577e-01f, 3.69332209e-02f, 1.28215671e-01f, -3.96807134e-01f, 5.28855920e-01f,
  -1.25013804e+00f, 4.03291807e-02f, -2.04586789e-01f, -8.24639723e-02f, 4.04087484e-01f, 1.59142256e-01f, -5.66410040e-03f, -8.14068988e-02f, 4.98289801e-02f, -1.86645001e-01f,
  2.21658334e-01f, 2.22998649e-01f, 4.38270606e-02f, 1.58033833e-01f, -1.03185140e-01f, 1.41922668e-01f, 3.86047900e-01f, -9.06228945e-02f, 4.34940029e-03f, 2.03155100e-01f,
  4.19211447e-01f, -1.08819112e-01f, -4.19160455e-01f, 1.38624966e-01f, -1.80979192e-01f, 1.67045780e-02f, 1.25351980e-01f, 1.88178532e-02f, 2.27288678e-01f, -4.65415090e-01f,
  -2.94716090e-01f, -3.39786649e-01f, 2.21934721e-01f, 7.04034939e-02f, -3.57407108e-02f, -1.08397409e-01f, -1.72370806e-01f, 9.00704239e-04f, 1.91818759e-01f, -9.61538181e-02f,
  8.13568756e-02f, -4.74209562e-02f, 4.58039045e-02f, 4.21545543e-02f, -5.83743118e-02f, -4.74396162e-02f, -1.84030216e-02f, 3.62805533e-03f, -1.31006435e-01f, -1.66645184e-01f,
  5.41835010e-01f, 7.62295304e-03f, -3.18220198e-01f, 1.15398601e-01f, -5.91678210e-02f, 2.75378115e-02f, -1.49318695e-01f, -3.86053175e-01f, -2.37002566e-01f, -8.92179132e-01f,
  1.04225082e-02f, -4.14879285e-02f, -8.18331689e-02f, -2.42030993e-02f, -1.07300349e-01f, -5.09595079e-03f, -6.67380635e-03f, -5.50829060e-03f, -5.58255194e-03f, -1.27307922e-01f,
  1.33633614e-01f, -1.41394902e-02f, -9.46370363e-02f, -3.65987904e-02f, -7.01918527e-02f, -8.18783976e-03f, -3.42674032e-02f, -7.25868195e-02f, -1.12621948e-01f, -6.11554421e-02f,
  1.84425265e-02f, 8.79904721e-03f, -5.43124713e-02f, 7.51224309e-02f, 1.16531245e-01f, -8.57585296e-03f, 2.49869260e-03f, 1.53616373e-03f, 1.53745413e-02f, -4.73689139e-02f,
  -1.76998928e-01f, 2.56592244e-01f, -2.86242902e-01f, 9.70872715e-02f, -1.25150785e-01f, -6.60459772e-02f, -7.35618025e-02f, -1.13775339e-02f, -3.40749300e-03f, -1.54776156e-01f,
  -5.16488031e-02f, -1.76277950e-01f, -1.05697975e-01f, 2.69150943e-03f, -6.84779808e-02f, -4.55314629e-02f, -9.32165049e-03f, 1.30729333e-01f, 4.98579480e-02f, 9.01654810e-02f,
  -7.63849681e-03f, -4.05427396e-01f, -5.98603785e-01f, -3.46304893e-01f, -6.47928566e-02f, -3.94430608e-01f, -3.09670717e-01f, -3.32799345e-01f, -3.10652286e-01f, -7.27302492e-01f,
  -9.28079844e-01f, 2.49386858e-02f, -5.34562290e-01f, -2.52432883e-01f, -4.03970838e-01f, -1.79243967e-01f, -5.42208672e-01f, -2.31666137e-02f, 1.31416142e-01f, -2.26516694e-01f,
  3.82297463e-03f, -5.70563264e-02f, -3.38028520e-01f, -1.62659928e-01f, -2.57285833e-01f, -4.94599372e-01f, -5.71365356e-01f, -5.45470834e-01f, -3.08184892e-01f, 1.44284233e-01f,
  -9.44360867e-02f, -6.47822738e-01f, -3.16261917e-01f, 1.03482865e-01f, 2.32219011e-01f, -8.26807916e-02f, -1.45733118e-01f, 1.26333619e-02f, 2.24643633e-01f, -2.74397850e-01f,
  -9.79771167e-02f, 4.90336902e-02f, 1.19614102e-01f, -5.34408167e-02f, -3.49106230e-02f, -5.69647253e-02f, -1.39038131e-01f, 1.67837776e-02f, 1.85221374e-01f, 1.49831519e-01f,
  1.31232992e-01f, 1.91634125e-03f, -5.01514785e-02f, 1.17640480e-01f, -6.24315031e-02f, 1.31630942e-01f, 1.90395825e-02f, 3.49895796e-03f, 1.01295464e-01f, 2.86352307e-01f,
  2.73504317e-01f, 1.59787446e-01f, 2.58024335e-01f, 2.34716937e-01f, 2.59853512e-01f, -8.06198921e-03f, 2.08627224e-01f, 2.87906229e-01f, 2.26951793e-01f, 5.84790818e-02f,
  -6.17357679e-02f, -8.16319734e-02f, 2.46620718e-02f, -1.41742647e-01f, 1.71473995e-02f, 1.34179100e-01f, 1.85311381e-02f, -5.09442994e-03f, -4.79739048e-02f, 7.70875514e-02f,
  2.96912622e-02f, -4.09730375e-02f, -1.48575798e-01f, 3.92330959e-02f, 9.65240151e-02f, -6.91250861e-02f, -1.10805638e-01f, 3.45072597e-02f, 2.24757165e-01f, 8.49911496e-02f,
  8.94834772e-02f, 5.61100654e-02f, -3.10618151e-02f, 1.26394909e-02f, -1.30771915e-03f, -8.27824101e-02f, -2.08775364e-02f, 9.44514479e-03f, 2.81974580e-02f, -2.02679485e-02f,
  -1.57360718e-01f, -1.54401302e-01f, -1.04616448e-01f, 1.11530073e-01f, -7.38026723e-02f, 6.27722070e-02f, -3.18365879e-02f, -4.56911735e-02f, 6.16153739e-02f, 7.87281245e-02f,
  2.33609393e-01f, -6.08130433e-02f, -5.18799797e-02f, 6.85205460e-02f, -1.10314369e-01f, 5.39398007e-02f, -8.60600173e-03f, -1.82633027e-01f, 1.29598603e-01f, 1.25562072e-01f,
  1.75087288e-01f, 1.32695824e-01f, 1.49358204e-02f, -7.21712643e-03f, -2.65095849e-03f, -2.40794420e-01f, -1.29268482e-01f, 7.11309314e-02f, -6.01904616e-02f, -1.39802620e-01f,
  -2.12104276e-01f, 5.46169400e-01f, 2.78738618e-01f, -1.55453414e-01f, 4.80104208e-01f, 9.11732391e-02f, 1.82004482e-01f, -5.09870015e-02f, -2.76893564e-03f, 1.87070698e-01f,
  5.77366352e-01f, 1.20953482e-03f, 7.09403306e-02f, -2.69668430e-01f, -4.57868904e-01f, -1.45033032e-01f, -2.04365730e-01f, -7.19661117e-01f, -6.29631341e-01f, -1.20422587e-01f,
  -2.26783201e-01f, -4.27460760e-01f, -7.41609871e-01f, -3.25703919e-01f, 7.85010010e-02f, -2.82290667e-01f, 2.26391435e-01f, -2.46753488e-02f, 1.81913659e-01f, -9.08246785e-02f,
  -2.68308669e-01f, 2.38832831e-01f, -2.35243171e-01f, -4.05839868e-02f, 1.68093830e-01f, -1.18116982e-01f, 3.15755606e-02f, -1.60896987e-01f, 1.36145025e-01f, -4.38649394e-02f,
  2.95292467e-01f, 1.92335933e-01f, 2.32360199e-01f, -1.67325273e-01f, -1.23177124e-02f, -1.46530032e-01f, -1.35984123e-01f, -3.42805356e-01f, -2.59272277e-01f, -6.97740093e-02f,
  8.08839872e-02f, 2.03753307e-01f, -3.51855718e-02f, 9.89417136e-02f, -1.66566432e-01f, -1.99587628e-01f, 2.14962084e-02f, -1.51853532e-01f, 6.02735020e-02f, -2.68622130e-01f,
  -1.87557101e-01f, -3.36995870e-02f, 9.53486264e-02f, -1.00764118e-01f, -1.12674765e-01f, 9.32655111e-02f, -5.17144129e-02f, -7.37942159e-02f, -2.20571250e-01f, -1.47057205e-01f,
  3.46548520e-02f, 1.95613652e-01f, -9.62525755e-02f, 8.84932131e-02f, -1.19134061e-01f, 1.84164103e-02f, -1.13063730e-01f, -7.28997290e-02f, -3.88420969e-02f, 4.84871492e-02f,
  -2.28515435e-02f, 1.76957652e-01f, 9.02342424e-02f, -2.88522337e-02f, 1.14800416e-01f, -7.06970971e-03f, -5.86661808e-02f, 3.46626453e-02f, 2.05448195e-02f, 6.31440431e-02f,
  -4.91604626e-01f, 1.58785209e-01f, -2.28501529e-01f, -5.58776665e-04f, 1.45311654e-02f, 4.72401120e-02f, 1.79941192e-01f, -4.80561033e-02f, 1.72285065e-01f, -1.55463859e-01f,
  4.50368933e-02f, 3.01010404e-02f, 4.50696088e-02f, -4.31141853e-02f, -2.61083469e-02f, -5.11236303e-02f, 6.78241402e-02f, -1.84737742e-01f, -1.52102038e-01f, -1.34545863e-01f,
  -1.67277947e-01f, -2.88445622e-01f, -4.64712560e-01f, -2.77863324e-01f, -1.52488261e-01f, -3.12662035e-01f, -2.74705648e-01f, -2.89321125e-01f, -3.01419139e-01f, -5.38130462e-01f,
  5.76817513e-01f, 3.03540885e-01f, 3.18265915e-01f, 1.68537661e-01f, -1.10561326e-01f, -3.89535874e-01f, -3.41131091e-01f, -2.85552680e-01f, -3.30780521e-02f, 1.15107283e-01f,
  -1.65130757e-02f, -1.07216321e-01f, -1.71621159e-01f, 2.98573147e-03f, 1.39587387e-01f, 5.58715984e-02f, 1.66678414e-01f, 2.52675951e-01f, 4.38141115e-02f, -3.48258018e-02f,
  2.34950148e-02f, 1.79543570e-01f, 2.78278857e-01f, -7.73203000e-02f, 2.61332095e-01f, -1.18149713e-01f, -3.85908633e-02f, 2.40493029e-01f, 4.19593491e-02f, 8.16072285e-01f,
  2.69774348e-01f, 2.11811095e-01f, -3.15326333e-01f, 7.27187693e-02f, 1.06182270e-01f, -3.69981341e-02f, -1.45200893e-01f, 5.74319027e-02f, -1.11376401e-02f, -1.41106118e-02f,
  8.84222239e-02f, 1.45420328e-01f, 1.60505340e-01f, -1.04784342e-02f, -1.60601437e-01f, -2.83660572e-02f, -8.17520767e-02f, 2.51821607e-01f, 4.29861844e-02f, 2.09029287e-01f,
  6.23138659e-02f, -1.07060291e-01f, -2.21716240e-01f, -2.14956537e-01f, 8.97237286e-02f, -4.96127494e-02f, -1.16092578e-01f, 5.84334061e-02f, -3.18610191e-01f, 6.86308295e-02f,
  -1.21212333e-01f, -7.24485740e-02f, -1.53621202e-02f, 1.20280601e-01f, -2.41905078e-02f, 8.24599061e-03f, 8.75031725e-02f, -1.61867276e-01f, -5.14913090e-02f, 6.60394430e-02f,
  -7.11160973e-02f, -5.16937971e-02f, -1.29024401e-01f, 5.01468293e-02f, -1.03128776e-01f, 6.44428134e-02f, -8.94483849e-02f, 1.06805548e-01f, -5.15122004e-02f, -1.60309121e-01f,
  3.70356254e-02f, 2.31365897e-02f, -5.87068126e-02f, -2.76657008e-02f, -4.03451035e-03f, 1.99439190e-02f, 6.97741518e-03f, -1.30084723e-01f, -1.59100547e-01f, 1.87796764e-02f,
  -3.72910738e-01f, -4.83976930e-01f, -4.77086380e-02f, -2.89018471e-02f, 7.62983933e-02f, 9.57241580e-02f, -7.53661394e-02f, -7.91167021e-02f, 6.09123032e-04f, -5.29332273e-03f,
  8.82363319e-02f, -5.71542755e-02f, -3.42440940e-02f, 9.77081805e-03f, -5.13850339e-02f, -2.19901040e-01f, 1.29313460e-02f, -1.32319689e-01f, -5.41681349e-02f, 7.04319477e-02f,
  -3.99617031e-02f, -5.90902627e-01f, -6.22471869e-01f, -2.19159469e-01f, -4.76048052e-01f, -4.23169941e-01f, -5.39789557e-01f, -2.79496074e-01f, -7.75325835e-01f, -5.44501781e-01f,
  -4.65214700e-01f, -7.84805790e-02f, -2.11743265e-01f, -3.54573041e-01f, -3.85224164e-01f, -3.21739241e-02f, -4.08813715e-01f, 3.69811170e-02f, 2.42814366e-02f, -4.62620646e-01f,
  -3.94192077e-02f, 1.08862910e-02f, -2.41316944e-01f, 1.00007160e-02f, -3.06028649e-02f, -4.08787876e-01f, -4.30455893e-01f, -1.55018106e-01f, 1.29081428e-01f, -5.07072918e-03f,
  1.64570585e-02f, -2.38995880e-01f, 4.08565365e-02f, 3.75948042e-01f, -9.21606049e-02f, 1.92633256e-01f, -9.85472798e-02f, -1.35337740e-01f, 1.29203990e-01f, -5.76800227e-01f,
  -2.97237813e-01f, 1.37401819e-01f, -8.23143497e-02f, 3.21630985e-02f, -5.17198220e-02f, 6.41649663e-02f, -2.07491353e-01f, 1.04538575e-01f, 2.69475412e-02f, -1.12392433e-01f,
  -1.51773915e-01f, 1.33133456e-01f, 3.89205217e-02f, 1.60489663e-01f, 5.15389070e-02f, -2.26739615e-01f, 4.54534255e-02f, -2.70830303e-01f, -2.46787503e-01f, -6.29406273e-02f,
  -3.15631717e-01f, -2.63107389e-01f, -2.05827430e-01f, -5.24066016e-02f, -1.97291106e-01f, -1.01009190e-01f, 1.24289989e-01f, 3.09019148e-01f, 1.19802713e-01f, -6.39412552e-02f,
  -2.48652156e-02f, -4.07383926e-02f, 3.13975550e-02f, 1.38456985e-01f, 4.78729643e-02f, 6.14109002e-02f, 1.16978250e-01f, -6.54914230e-02f, 2.42179316e-02f, 3.27657238e-02f,
  -2.45705415e-02f, 4.78505082e-02f, -8.18681866e-02f, -1.80013925e-01f, -6.67680353e-02f, -7.33944103e-02f, 3.86311673e-02f, -3.33043672e-02f, 4.34000455e-02f, -1.09505184e-01f,
  -2.22906545e-02f, 4.19257618e-02f, -2.21134070e-02f, 1.25375167e-01f, -2.54344106e-01f, -2.43412375e-01f, 7.62427673e-02f, 9.24915969e-02f, 1.28098518e-01f, 1.30291641e-01f,
  -3.32728438e-02f, 1.83356911e-01f, -2.15386391e-01f, -2.67822575e-02f, 1.36384770e-01f, 5.09445332e-02f, -7.23511279e-02f, 1.44359330e-02f, -1.15978373e-02f, -9.19276029e-02f,
  1.02442317e-01f, 1.22538218e-02f, -3.67479259e-03f, 6.37668446e-02f, 1.11982681e-01f, 1.05373584e-01f, 3.70547026e-02f, -1.85905308e-01f, 6.24476224e-02f, 1.57590702e-01f,
  -1.11157820e-02f, -1.76411048e-01f, -3.59570086e-01f, -1.03958815e-01f, -8.47289804e-04f, -7.46050104e-02f, 6.45306259e-02f, -1.35076651e-03f, -3.79202887e-02f, -7.64760599e-02f,
  9.29978311e-01f, -1.88706607e-01f, -5.10825515e-01f, 3.28008533e-01f, -4.29251492e-01f, -5.89944661e-01f, -9.90633249e-01f, -2.69703921e-02f, 4.23951268e-01f, -3.15205276e-01f,
  -1.67607307e-01f, 1.96691766e-01f, 1.04123786e-01f, -7.49903917e-02f, -5.04812077e-02f, -5.09805799e-01f, -2.08256930e-01f, -1.30999848e-01f, -6.22560009e-02f, -5.46043515e-01f,
  -1.83194116e-01f, 3.74328554e-01f, 5.07512331e-01f, 1.20847777e-01f, -1.01172917e-01f, 1.24441147e-01f, -2.83857733e-01f, -6.83515668e-02f, -4.58448082e-01f, -4.56486821e-01f,
  -6.69855654e-01f, -4.93519872e-01f, -1.06443837e-01f, 1.45471409e-01f, -1.90917239e-01f, -4.60257493e-02f, -2.26926640e-01f, -1.06114419e-02f, 1.38964560e-02f, -1.64237633e-01f,
  -1.27823338e-01f, -6.35728613e-02f, 6.06049262e-02f, -1.12040266e-01f, 1.74869876e-02f, -2.33370941e-02f, 9.46244299e-02f, -8.58396441e-02f, -5.28964959e-03f, -2.90224552e-01f,
  1.43339053e-01f, -1.22996889e-01f, -4.44598138e-01f, -1.38913229e-01f, -1.54634818e-01f, -5.80309927e-02f, -2.79114693e-01f, -3.27097088e-01f, -4.04724598e-01f, 6.08716942e-02f,
  -2.00112909e-01f, -6.16867654e-02f, -1.29546732e-01f, -9.43317413e-02f, 5.65924607e-02f, -2.56730374e-02f, -1.47494068e-02f, -2.10714042e-01f, -2.45912131e-02f, 5.82368113e-02f,
  6.48256484e-03f, 1.13270739e-02f, 7.24257156e-02f, 5.90539500e-02f, 8.10572207e-02f, -2.45353784e-02f, -8.09130166e-03f, -4.77179550e-02f, 2.26073824e-02f, -1.23296762e-02f,
  -6.40839487e-02f, -6.37557954e-02f, 8.98035392e-02f, 4.90383431e-02f, 3.00077889e-02f, 4.53006849e-02f, 1.20442510e-01f, -1.01459906e-01f, 9.99953821e-02f, -1.29482746e-01f,
  2.34421313e-01f, -7.59861395e-02f, -1.49080947e-01f, -1.57732025e-01f, -8.26384947e-02f, 1.27446741e-01f, 4.62324992e-02f, 4.38638143e-02f, 1.31581992e-01f, 1.58436634e-02f,
  -2.23097667e-01f, 8.07415918e-02f, -7.24473894e-02f, -1.51161537e-01f, 2.02892777e-02f, -1.56153947e-01f, -8.22858587e-02f, -1.96695268e-01f, -1.84984833e-01f, 2.40826234e-01f,
  2.98411518e-01f, -4.22645919e-02f, 7.49008656e-02f, -5.77023588e-02f, 1.83391646e-02f, 4.76242229e-02f, 1.06420510e-01f, -5.41298697e-03f, 9.06992331e-03f, 4.29922640e-01f,
  1.20484757e+00f, -2.99245149e-01f, -5.05055130e-01f, 1.74302265e-01f, -2.70933419e-01f, -1.25323117e-01f, -3.66010070e-01f, 1.77893303e-02f, 1.27189100e-01f, -1.24621890e-01f,
  2.13450342e-01f, 5.24123728e-01f, 3.24993759e-01f, 2.53330976e-01f, 1.51945621e-01f, -5.02562761e-01f, -5.42755187e-01f, -1.37857392e-01f, 2.55203664e-01f, 2.17716902e-01f,
  2.69021299e-02f, -4.82818075e-02f, 2.65836805e-01f, 1.48617089e-01f, -2.97892034e-01f, 2.09728882e-01f, -3.24324608e-01f, -2.05287948e-01f, -1.99203119e-01f, -5.24315476e-01f,
  -1.41027674e-01f, 9.80636105e-02f, 1.67867020e-01f, 1.29974648e-01f, -7.13362992e-02f, 7.98782855e-02f, 9.86123607e-02f, -7.28006959e-02f, 8.51501450e-02f, -4.46696021e-02f,
  -1.00908183e-01f, -4.29512113e-02f, -2.18686704e-02f, -9.14554000e-02f, -5.07916994e-02f, -5.75649105e-02f, 6.69424385e-02f, 2.00426187e-02f, -2.19406430e-02f, -8.31648260e-02f,
  -4.55234870e-02f, 5.18552139e-02f, -1.29943639e-01f, 3.64317298e-02f, 1.39997110e-01f, 1.23000674e-01f, -4.30249348e-02f, 1.59095064e-01f, 8.23693499e-02f, -5.47070689e-02f,
  -1.58187434e-01f, 8.55958834e-02f, 9.06577706e-02f, -5.34462072e-02f, 2.16942951e-02f, -4.27188128e-02f, -6.17366284e-02f, -5.64734526e-02f, 6.40347600e-02f, 1.53747806e-02f,
  7.57317815e-04f, 1.73674766e-02f, 2.66106846e-03f, -3.38102132e-02f, -6.88572526e-02f, -1.87259596e-02f, 8.57098214e-03f, -5.19618280e-02f, -3.32956836e-02f, 3.31207328e-02f,
  1.58574939e-01f, 2.38597244e-02f, -9.94134471e-02f, 1.63442902e-02f, -8.14967453e-02f, 3.43479142e-02f, 8.36280435e-02f, 9.41064507e-02f, -6.73380196e-02f, -9.55503285e-02f,
  6.23352863e-02f, 1.28030702e-01f, 4.01298935e-03f, 8.99254531e-02f, 5.94280362e-02f, -6.16699979e-02f, 1.05070971e-01f, -1.26546351e-02f, -1.86729014e-01f, -9.54631865e-02f,
  6.78016916e-02f, 6.40791357e-02f, -5.07956892e-02f, 6.17796145e-02f, 6.54637348e-03f, -2.09294986e-02f, 9.52651724e-02f, 1.54210612e-01f, -4.03446369e-02f, -1.66068837e-01f,
  -1.37364626e-01f, -7.11184070e-02f, -3.03520206e-02f, 8.81597772e-02f, 1.52983636e-01f, 1.49711847e-01f, -2.90293451e-02f, 1.64395422e-02f, 1.46079995e-02f, -1.29682779e-01f,
  -7.76562333e-01f, 2.58300807e-02f, -3.25086601e-02f, -8.19940686e-01f, -4.99651283e-01f, -1.18365958e-01f, -4.42909271e-01f, -3.82645056e-02f, 1.93021864e-01f, -1.47728607e-01f,
  -2.65876830e-01f, -4.38608289e-01f, 8.67758915e-02f, 3.71867746e-01f, 4.29053813e-01f, 1.71938643e-01f, 2.18863294e-01f, 1.33059010e-01f, -1.23830251e-01f, -4.14984912e-01f,
  -1.15418643e-01f, -3.93635929e-01f, -1.05459079e-01f, 1.94340929e-01f, -5.19871175e-01f, -2.27729365e-01f, 7.82728661e-04f, -2.41112530e-01f, 2.00381204e-01f, -5.48747063e-01f,
  -5.50749838e-01f, -6.54049754e-01f, 1.22797094e-01f, 4.56961105e-03f, -2.08222002e-01f, 1.56067312e-01f, -1.91565081e-01f, -1.14491187e-01f, -9.63852648e-03f, -7.49623999e-02f,
  -3.34348738e-01f, 1.00075658e-02f, -3.23647529e-01f, -1.99799061e-01f, -2.32369512e-01f, -1.22997329e-01f, -1.53024625e-02f, 1.96225986e-01f, 2.34071314e-01f, 1.06538266e-01f,
  -3.09253414e-03f, -2.28253063e-02f, -1.22401804e-01f, 2.11390078e-01f, 2.60348022e-01f, 2.00879648e-01f, -9.18120425e-03f, 1.33970514e-01f, 4.07429516e-01f, -9.93625447e-02f,
  7.65551478e-02f, 9.83342994e-03f, -1.37476651e-02f, 2.11868454e-02f, -9.63715911e-02f, -1.25450879e-01f, -1.32339269e-01f, -1.04168698e-01f, 1.85046326e-02f, 1.86412018e-02f,
  -1.80998154e-03f, 1.12293132e-01f, 8.54819175e-03f, 6.47257119e-02f, -5.70483655e-02f, -1.07396483e-01f, -6.50627166e-03f, 1.52344748e-01f, 3.10442392e-02f, -8.99803862e-02f,
  3.33275944e-02f, 8.58652741e-02f, -7.86479563e-02f, -1.00701138e-01f, 1.02735795e-01f, 2.25076601e-01f, 9.81551688e-03f, -7.81775638e-02f, -1.14828415e-01f, 6.69049658e-03f,
  -5.59186459e-01f, 7.82557905e-01f, -3.17893893e-01f, -1.00511968e-01f, -1.63029581e-01f, 1.41612887e-01f, -1.57949895e-01f, 4.23490070e-02f, -5.29545248e-02f, -1.05030775e-01f,
  -8.31210166e-02f, -1.89581901e-01f, 5.53706894e-03f, -7.91720767e-03f, -3.03388864e-01f, -1.40943572e-01f, 6.91432580e-02f, -2.54403472e-01f, 2.52706677e-01f, 7.34041110e-02f,
  1.36020392e-01f, -3.37527804e-02f, -8.38700756e-02f, -9.24574733e-02f, -3.14298682e-02f, 4.20942865e-02f, -1.49241626e-01f, -1.58074379e-01f, 1.32022783e-01f, -2.76723001e-02f,
  4.01118040e-01f, 4.82593209e-01f, 1.74775511e-01f, 4.30915445e-01f, 2.74089545e-01f, 2.21199289e-01f, 2.18508750e-01f, 1.49260953e-01f, 4.42139842e-02f, 1.79266497e-01f,
  1.08770534e-01f, 1.58692718e-01f, 2.47329459e-01f, 2.08837911e-01f, 1.71176597e-01f, 1.55109897e-01f, 2.51149654e-01f, 7.77129875e-03f, -3.69488373e-02f, 7.67305121e-02f,
  2.53834516e-01f, -3.83126885e-02f, -1.41864404e-01f, -8.02478939e-03f, 2.34865233e-01f, 2.31036320e-01f, 1.24288619e-01f, 8.57130215e-02f, 3.44209492e-01f, 3.28839958e-01f,
  -9.25028771e-02f, 2.16397092e-01f, 7.37111419e-02f, 5.60086183e-02f, 1.04540093e-02f, -5.96334860e-02f, -3.14560421e-02f, -1.37653247e-01f, -5.51320463e-02f, -1.32300556e-01f,
  -7.41015673e-02f, -4.06863727e-02f, 2.92095896e-02f, -1.15766160e-01f, -1.29389733e-01f, -1.98676616e-01f, -3.72432880e-02f, -2.16222946e-02f, 1.24070548e-01f, -6.02990715e-03f,
  2.00356543e-01f, -1.46048769e-01f, -1.37920499e-01f, 2.68863179e-02f, 1.25994757e-01f, -7.65767246e-02f, -3.75393182e-02f, 5.45572490e-02f, -6.05438836e-02f, 7.37050697e-02f,
  1.69727147e-01f, 6.17549755e-02f, 1.07648231e-01f, -8.27224478e-02f, 4.09031063e-02f, 2.50637461e-03f, 4.59914990e-02f, 9.56607014e-02f, -5.01728803e-02f, -8.72076973e-02f,
  -3.90524678e-02f, 1.94489583e-01f, 3.79820243e-02f, 1.41404703e-01f, 2.61349231e-01f, 1.46222875e-01f, -1.65102687e-02f, -1.21194506e-02f, 3.92716154e-02f, -2.39499196e-01f,
  -1.86049685e-01f, -8.78325403e-02f, -1.17605552e-01f, 1.81139708e-02f, -5.17710708e-02f, 2.13504344e-01f, 1.80770934e-01f, 1.20343335e-01f, 6.36047870e-02f, -3.73432711e-02f,
  -5.32924652e-01f, 1.59686908e-01f, 6.49843216e-02f, -1.31566867e-01f, 4.06645145e-03f, -4.37308177e-02f, 2.21545383e-01f, -4.82000671e-02f, -2.27219313e-01f, -1.32278159e-01f,
  -1.53068453e-01f, -6.99345618e-02f, -9.51786041e-02f, -9.74120200e-02f, -1.44124597e-01f, -2.48610094e-01f, -7.52647668e-02f, -1.19025372e-01f, -1.12280183e-01f, -1.84398144e-01f,
  -2.15796456e-02f, -1.69969305e-01f, -2.94577718e-01f, -1.49027780e-01f, -7.10912645e-02f, -5.14172390e-02f, -1.51837319e-01f, -1.83086425e-01f, -1.03067055e-01f, -4.10056189e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.04142028e-01f, 1.80461228e-01f, 1.99003950e-01f, 7.82984197e-01f, 7.18677640e-01f, 1.08680397e-01f, 1.55173391e-01f, 5.82297921e-01f, 5.96380532e-01f, 1.97665945e-01f,
  6.24062598e-01f, 5.82738854e-02f, 2.92025894e-01f, 2.78636605e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  7.73082599e-02f, -2.33521834e-02f, 9.76519659e-02f, -2.84641206e-01f, 4.01316315e-01f, 2.40588218e-01f, 3.09727073e-01f, -4.10700351e-01f, -1.78462014e-01f, 2.77750105e-01f,
  2.42189080e-01f, -2.41152138e-01f, 1.45783842e-01f, -2.64075369e-01f, -2.20613748e-01f, -2.59942889e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -3.94333079e-02f, 1.43391594e-01f, 2.50929501e-02f, 7.26817191e-01f, -2.57188603e-02f, -5.71258545e-01f, -2.58065194e-01f, -1.14262678e-01f, 9.34162065e-02f, -2.02484205e-01f,
  -3.62274379e-01f, 3.38198215e-01f, 3.70278507e-01f, 6.17284119e-01f, 3.30193229e-02f, 1.74241856e-01f, 5.23877621e-01f, 1.35352895e-01f, 3.26300591e-01f, 1.52530894e-01f,
  -1.24694251e-01f, 5.74310601e-01f, 6.46661997e-01f, 6.67529464e-01f, 3.25200647e-01f, -8.44506249e-02f, 1.26823142e-01f, 2.66252935e-01f, 5.50853789e-01f, -3.28886300e-01f,
  6.39834702e-02f, 2.20260486e-01f, 1.11013532e+00f, -1.15404733e-01f, 1.87766150e-01f, -1.15943313e-01f, -1.90770477e-01f, 6.34202480e-01f, 2.95168102e-01f, 8.28660056e-02f,
  -2.56818622e-01f, 1.70075566e-01f, -3.68931778e-02f, -1.24406412e-01f, 3.61210387e-03f, -5.54791212e-01f, 1.96632072e-01f, -3.89143266e-02f, -3.92419130e-01f, -1.98207840e-01f,
  3.99290353e-01f, -1.43024161e-01f, -1.45879202e-02f, 2.45103404e-01f, -1.32027194e-01f, 4.45941567e-01f, 9.56549272e-02f, 5.78878522e-01f, 3.89574319e-01f, 1.52108610e-01f,
  -2.05400884e-01f, -4.22343820e-01f, 7.94441029e-02f, 3.70847762e-01f, -2.96263874e-01f, 2.20931247e-01f, -2.00817004e-01f, -1.42021194e-01f, -2.80683845e-01f, 2.06364155e-01f,
  4.11472380e-01f, 1.31727055e-01f, 4.25172061e-01f, 5.32422841e-01f, -1.23828702e-01f, 4.95935649e-01f, 1.24449119e-01f, -3.37365508e-01f, 3.41602623e-01f, -2.35851005e-01f,
  -2.88323183e-02f, 1.54165626e-01f, -2.46536117e-02f, -2.31710464e-01f, 1.96783245e-01f, 4.24125642e-01f, -6.51522130e-02f, 4.57152456e-01f, 4.32568938e-01f, 5.53416371e-01f,
  6.96227849e-02f, 1.18030466e-01f, -4.03351992e-01f, -3.06277692e-01f, 6.98424280e-01f, -2.33320549e-01f, 4.33910400e-01f, -7.09683597e-01f, -4.45561320e-01f, 2.85037845e-01f,
  -1.19967580e-01f, 8.07494521e-01f, -1.27839074e-01f, -3.73233438e-01f, -3.09690654e-01f, -2.66804874e-01f, 7.66878605e-01f, -2.03313798e-01f, 3.74626160e-01f, 9.19479132e-03f,
  4.32562798e-01f, 5.94079643e-02f, -1.16909280e-01f, 1.46521419e-01f, 2.99126565e-01f, 3.06472898e-01f, 1.35057077e-01f, 1.27016902e-01f, -1.40814662e-01f, -4.23220634e-01f,
  -1.00777380e-01f, 6.38374507e-01f, 6.49642706e-01f, -8.06326985e-01f, -1.86786726e-01f, -1.08630329e-01f, -8.61005068e-01f, 5.94908416e-01f, 6.81054965e-02f, 5.80743790e-01f,
  6.75075412e-01f, 1.74077183e-01f, -2.50189334e-01f, 1.48990422e-01f, 5.86374164e-01f, 1.02368534e+00f, 2.30435088e-01f, 7.12489963e-01f, -1.88969016e-01f, 5.93021631e-01f,
  -1.62900537e-01f, 7.96731040e-02f, 2.44156614e-01f, 1.12607576e-01f, -1.80577815e-01f, 1.00943474e-02f, 3.79241467e-01f, -2.29655474e-01f, 4.31304760e-02f, 6.89561129e-01f,
  -6.97784871e-02f, 2.56872088e-01f, 5.45893535e-02f, 6.01527750e-01f, 3.24454099e-01f, 5.49872231e-04f, -8.13143253e-02f, -4.85765606e-01f, -1.41773839e-02f, 3.92974466e-01f,
  -2.57035866e-02f, -3.01683575e-01f, 2.88671345e-01f, 6.03601396e-01f, 1.46940514e-01f, 1.17805123e-01f, 1.68266505e-01f, -1.04148678e-01f, 2.09638104e-01f, -3.16531509e-01f,
  4.16672349e-01f, 1.03318647e-01f, 7.89903224e-01f, 5.16607940e-01f, -2.85505146e-01f, 5.46442628e-01f, 5.66123366e-01f, -5.73280632e-01f, -3.27975392e-01f, 1.70224324e-01f,
  4.13443409e-02f, 3.65359813e-01f, 1.66472122e-01f, -2.73926765e-01f, -1.43824264e-01f, 3.09214592e-02f, 5.92129350e-01f, -2.12896541e-01f, 1.43145055e-01f, -2.19896123e-01f,
  1.35229379e-01f, -2.08025128e-01f, 2.32365131e-01f, -4.43712860e-01f, 1.60980150e-01f, -4.01421100e-01f, -1.14125140e-01f, 7.06499636e-01f, -4.21281755e-02f, 1.24531262e-01f,
  -4.43354249e-01f, 1.40888795e-01f, 6.10902011e-01f, -4.30629134e-01f, 1.46476105e-01f, -1.44426047e-03f, -2.37377748e-01f, -1.45802453e-01f, 1.49261147e-01f, 6.52065635e-01f,
  -3.36976528e-01f, 9.16186512e-01f, -6.22626185e-01f, 3.93478900e-01f, 8.82169545e-01f, 2.01806515e-01f, 5.89682341e-01f, -8.48347843e-02f, 3.06277871e-01f, 5.45814693e-01f,
  1.12258041e+00f, 7.40996182e-01f, 3.32910061e-01f, 3.54271173e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -9.48640555e-02f, 8.46025944e-01f, 7.66561449e-01f, 3.25852662e-01f, 1.79911375e-01f, 1.32591978e-01f, 2.21128106e-01f, 4.29891288e-01f, 1.17767438e-01f, 5.00274122e-01f,
  1.27352372e-01f, 3.67401659e-01f, 4.77157563e-01f, 4.84554976e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.39475662e-01f, -4.88881886e-01f, 4.25810248e-01f, 6.03646450e-02f, -5.16778827e-01f, 2.70433426e-01f, 1.70253009e-01f, -2.58471686e-02f, -2.13561635e-02f, 2.19591800e-02f,
  4.60075215e-02f, 1.21368863e-01f, 9.48672444e-02f, -9.20106173e-02f, -3.73313040e-01f, -2.17869699e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -2.70244986e-01f, 1.47011876e-01f, 4.45224047e-01f, -5.28691374e-02f, -2.76879132e-01f, -1.51679382e-01f, 1.49711105e-03f, -6.92181885e-01f, 4.81893212e-01f, 1.18054792e-01f,
  -2.29161143e-01f, 9.74672660e-02f, 2.98110098e-01f, -4.71001118e-02f, 3.01204562e-01f, 2.81286120e-01f, 1.55934167e+00f, 4.76378500e-01f, -2.58891910e-01f, 2.06069723e-01f,
  6.26962662e-01f, -2.61139214e-01f, 1.54241368e-01f, -2.55273223e-01f, -3.39390874e-01f, -1.61260143e-01f, -5.91702610e-02f, 2.55446732e-02f, 8.74075517e-02f, 2.21920922e-01f,
  -2.49433666e-01f, 7.64317587e-02f, 1.17634408e-01f, -3.28464387e-03f, 5.72752178e-01f, -8.18275847e-03f, -9.03833330e-01f, 3.38809669e-01f, 5.58730923e-02f, -5.08365512e-01f,
  2.43073124e-02f, 4.58499163e-01f, 1.51376920e-02f, 1.99931070e-01f, 4.79187548e-01f, -8.55328068e-02f, -1.04233921e-01f, 3.95800352e-01f, 4.86818343e-01f, 1.15591633e+00f,
  3.63748401e-01f, 3.37724417e-01f, 8.20168406e-02f, 3.41332346e-01f, 1.09917603e-01f, -3.74061495e-01f, 8.38384092e-01f, 7.25876331e-01f, -8.11724588e-02f, 3.79466981e-01f,
  8.03502798e-01f, 8.34644914e-01f, 4.79316473e-01f, 2.95228362e-01f, -4.98483121e-01f, -3.51783395e-01f, -7.47754872e-01f, 8.96576717e-02f, 4.98193279e-02f, 5.80592930e-01f,
  -4.59272981e-01f, -5.88798448e-02f, -4.19256389e-01f, 3.64798576e-01f, 4.74171817e-01f, 3.80991489e-01f, 2.25079373e-01f, -9.01506618e-02f, 1.84137598e-01f, -1.13077009e+00f,
  -1.04926944e+00f, -7.66222998e-02f, 3.10910847e-02f, 3.05047601e-01f, 9.48730588e-01f, 4.36466038e-01f, -2.69274145e-01f, 2.77348191e-01f, 1.06241751e+00f, 1.08033225e-01f,
  -8.26046243e-02f, 4.57665145e-01f, -8.17179084e-02f, 8.39197576e-01f, 7.30119526e-01f, -2.62845308e-02f, 1.28908336e-01f, 2.00358868e-01f, -1.02137685e-01f, -2.00770080e-01f,
  -2.08462745e-01f, -7.81395137e-02f, -2.27065742e-01f, -1.41391397e-01f, -2.20223188e-01f, 1.44993633e-01f, -1.94638252e-01f, -1.58027083e-01f, -1.53958112e-01f, -7.95014799e-02f,
  -1.63159490e-01f, 1.24868035e-01f, -5.06636500e-01f, -2.11910486e-01f, -4.33439493e-01f, -1.60872877e-01f, 2.02922449e-01f, 3.44755501e-01f, 4.77413625e-01f, 4.15944874e-01f,
  -2.53970504e-01f, -4.92491126e-02f, 4.06360656e-01f, 4.37910229e-01f, -2.80143559e-01f, -1.52975947e-01f, 9.83998775e-02f, 1.78240833e-03f, 5.41601181e-01f, -5.50191760e-01f,
  -2.36756951e-01f, 5.02574861e-01f, -4.08705883e-02f, 2.49943584e-01f, 5.98378122e-01f, 5.64092875e-01f, -5.91719568e-01f, 2.63812505e-02f, 9.15019035e-01f, 1.41879246e-01f,
  1.31368965e-01f, -2.55124986e-01f, -2.69022733e-01f, 6.92363262e-01f, 1.31362391e+00f, 1.09623015e-01f, -4.96093452e-01f, 3.46436411e-01f, 7.12947667e-01f, -2.72804379e-01f,
  -1.14749864e-01f, -1.86659932e-01f, 1.34674504e-01f, -3.85315835e-01f, 2.33224317e-01f, -2.92489111e-01f, 2.35103503e-01f, 2.85497427e-01f, 9.53437947e-03f, -1.44809440e-01f,
  1.55742997e-02f, 1.16879940e-02f, 5.33731103e-01f, -9.95642483e-01f, -5.98481536e-01f, -5.78954875e-01f, -2.29009628e-01f, 2.92929560e-01f, -8.64924252e-01f, 1.46632001e-01f,
  -3.66828918e-01f, -1.18608162e-01f, 5.87257981e-01f, 4.04909253e-02f, -8.52755427e-01f, -6.46637559e-01f, 6.10870011e-02f, 6.86336383e-02f, -4.81291413e-02f, -2.39974499e-01f,
  -5.38963675e-02f, -1.77556723e-01f, 1.52004659e-02f, 1.46822840e-01f, -2.33174473e-01f, -2.22700715e-01f, -3.16999853e-02f, 1.38441520e-02f, -1.98147327e-01f, 7.80541003e-02f,
  -1.77269042e-01f, -2.17186540e-01f, -2.14814991e-01f, 4.09775048e-01f, 7.74959862e-01f, 2.62193382e-01f, -3.22681844e-01f, -2.37008911e-02f, -6.81514591e-02f, -3.47271532e-01f,
  -1.68015176e-04f, 2.84817755e-01f, 1.07870124e-01f, -4.53625880e-02f, 3.85970473e-01f, 2.26191413e-02f, -3.37031841e-01f, 4.38416660e-01f, 9.45016265e-01f, -9.07109499e-01f,
  3.38580608e-01f, 3.54744017e-01f, 4.83785778e-01f, -2.05390275e-01f, -1.88439369e-01f, -5.42099029e-03f, 4.83799547e-01f, -3.01204085e-01f, -7.09565431e-02f, 1.02463588e-01f,
  9.51315165e-02f, -8.31337720e-02f, -2.92712003e-01f, 4.99741077e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  2.29306400e-01f, 4.52637821e-01f, 9.99030396e-02f, 4.72923934e-01f, 1.93451777e-01f, 8.26013923e-01f, -1.93250835e-01f, -1.01767011e-01f, -2.76799593e-02f, 5.43835640e-01f,
  3.99934798e-01f, -1.36127025e-01f, -2.84325510e-01f, 4.33082610e-01f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -3.40225726e-01f, 1.43093333e-01f, -4.19361055e-01f, 4.32572812e-02f, 6.23154342e-02f, 2.90992204e-02f, -2.05258951e-01f, -2.99691498e-01f, -2.21182168e-01f, 1.28241368e-02f,
  1.89775787e-02f, -2.64522918e-02f, 3.12543333e-01f, 1.11357775e-02f, -6.86752349e-02f, 3.06293339e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -4.86001730e-01f, 4.54684347e-01f, -1.54761657e-01f, -4.91185695e-01f, -7.96672106e-01f, -1.86175123e-01f, -2.94938684e-01f, 3.85722876e-01f, 2.09466875e-01f, 4.67881233e-01f,
  5.48497319e-01f, 4.84306097e-01f, -4.80696768e-01f, 5.87115921e-02f, -8.07636380e-02f, 2.27546409e-01f, -1.00237153e-01f, 2.20767945e-01f, -9.16325003e-02f, 2.89864630e-01f,
  6.56540036e-01f, 1.72672540e-01f, 3.48804086e-01f, -5.27534723e-01f, 2.08717167e-01f, -2.82220155e-01f, 7.48598814e-01f, 3.68438751e-01f, -5.53166345e-02f, 1.94869876e-01f,
  4.16049123e-01f, 9.35101330e-01f, -3.81277293e-01f, 1.95221126e-01f, 5.04618406e-01f, -5.49272418e-01f, -5.96663100e-04f, 4.94280994e-01f, -4.43994433e-01f, 4.99293774e-01f,
  2.16364086e-01f, -4.28342968e-01f, -5.48123181e-01f, -2.76338011e-01f, 5.11359051e-02f, -1.17800131e-01f, 4.32152361e-01f, 2.99528956e-01f, 8.83714974e-01f, -6.25804067e-01f,
  -1.91532016e-01f, 1.33516085e+00f, -1.68890953e-02f, 6.31646574e-01f, 3.03642184e-01f, 5.32015383e-01f, 2.35072643e-01f, -4.38146830e-01f, -1.20663829e-01f, 1.18235362e+00f,
  8.21219664e-03f, 7.02134818e-02f, -1.59981012e-01f, 2.93085605e-01f, 4.83675953e-03f, 5.58037274e-02f, -5.74107587e-01f, 4.59046572e-01f, -2.53108084e-01f, -8.58664289e-02f,
  -7.11093009e-01f, -4.56181139e-01f, 2.12334692e-01f, 2.16747284e-01f, 5.62201321e-01f, 1.30606532e-01f, -5.17967165e-01f, 1.80120707e-01f, 6.95408061e-02f, 4.89709564e-02f,
  -2.31280431e-01f, -7.29224533e-02f, 3.74829844e-02f, -1.35129839e-01f, -1.87404618e-01f, -2.41930380e-01f, 2.10735321e-01f, -4.64285947e-02f, 3.66695821e-02f, 5.14206886e-02f,
  -2.37907559e-01f, -1.35511771e-01f, -1.47764862e-01f, 4.17566299e-02f, 9.73039567e-02f, 6.66285679e-02f, 1.08206511e+00f, -1.04856288e+00f, 8.12127665e-02f, 1.06410480e+00f,
  -1.21255018e-01f, 2.96012610e-02f, 2.37709537e-01f, -1.82363689e-01f, -2.33886033e-01f, -6.97873652e-01f, -4.49508317e-02f, 8.06869864e-01f, -7.32876003e-01f, 5.03495634e-02f,
  1.58050641e-01f, -2.75390036e-02f, -1.00536518e-01f, 1.79586083e-01f, 1.82933256e-01f, -6.88337624e-01f, 5.14149725e-01f, 5.38006723e-01f, 7.04692066e-01f, 3.14615697e-01f,
  -1.58116817e-02f, 8.08210611e-01f, -4.88990620e-02f, -5.97424388e-01f, -3.93662840e-01f, 3.72401550e-02f, 6.89306483e-02f, -2.86088735e-01f, -4.81748343e-01f, 5.53463697e-01f,
  5.69890365e-02f, -2.31669143e-01f, 2.56153256e-01f, 1.58626154e-01f, -6.27289057e-01f, -1.91026926e-02f, -2.20910996e-01f, 3.60404029e-02f, 2.76164204e-01f, 3.63637954e-01f,
  2.42159486e-01f, 2.38091089e-02f, 4.17827904e-01f, 6.94451034e-01f, -4.14037406e-01f, -4.55108941e-01f, 6.06969118e-01f, -7.98442245e-01f, 5.72802842e-01f, 2.73500949e-01f,
  -4.16912049e-01f, 2.46745646e-01f, 1.86133623e-01f, -2.32439131e-01f, 1.08398527e-01f, -3.36571127e-01f, 2.10033014e-01f, 1.45728454e-01f, 4.56123978e-01f, -2.55547851e-01f,
  -3.32814679e-02f, -1.38773441e-01f, -9.76900831e-02f, -1.28459230e-01f, 4.73893248e-02f, -8.94050375e-02f, -2.47261138e-04f, -1.26161436e-02f, 1.04209989e-01f, -5.90474121e-02f,
  -1.64544821e-01f, 1.84952691e-01f, 7.09896609e-02f, -2.06227899e-02f, -6.26122439e-03f, 9.12056193e-02f, 5.87833345e-01f, 1.33755296e-01f, 1.44248933e-01f, -1.83816403e-01f,
  7.28276908e-01f, 1.80229202e-01f, 6.99407160e-01f, 5.94902262e-02f, 1.98100805e-01f, 4.25660014e-01f, -8.04675967e-02f, -8.29137027e-01f, -6.79908037e-01f, 6.29128739e-02f,
  5.52414417e-01f, -5.29386587e-02f, 1.06788259e-02f, 8.62147331e-01f, -5.63175142e-01f, -5.03412545e-01f, -2.88398921e-01f, -4.62798141e-02f, 3.88998240e-01f, 4.10869926e-01f,
  -2.11492151e-01f, 7.15723574e-01f, 4.55304772e-01f, -2.44304407e-02f, 7.83283561e-02f, -1.64743558e-01f, -1.44198492e-01f, 1.55716181e-01f, -3.04993510e-01f, -3.85886639e-01f,
  -6.46843255e-01f, 2.34212592e-01f, -1.30455405e-01f, 3.34006011e-01f, -9.19834450e-02f, -5.10027349e-01f, 1.90924436e-01f, -1.81220233e-01f, 5.61697900e-01f, 8.94406214e-02f,
  4.22747165e-01f, -2.56317295e-02f, 3.24842483e-01f, -4.00151849e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  1.92375004e-01f, -3.08480978e-01f, 2.69263595e-01f, 7.34556735e-01f, 2.38058448e-01f, 1.55382127e-01f, 4.58282381e-01f, 1.79670811e-01f, -1.44445643e-01f, -1.59675963e-02f,
  -3.08883607e-01f, -1.75268680e-01f, -8.59525502e-02f, -1.12467885e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -6.27172947e-01f, -6.61967874e-01f, -2.90553970e-03f, 3.30687225e-01f, -2.93060094e-01f, -8.01872730e-01f, 1.72257572e-01f, -4.44100499e-02f, -7.34639049e-01f, -2.09683508e-01f,
  7.03159198e-02f, 2.59065658e-01f, -2.39781439e-01f, 7.91068971e-02f, -2.30279654e-01f, 4.29615617e-01f, -1.59284681e-01f, 2.86905169e-01f, -7.20371425e-01f, 2.86247283e-01f,
  5.29373856e-03f, -5.55996954e-01f, -7.11903036e-01f, 1.55270696e-01f, -9.86803532e-01f, 3.07166517e-01f, 2.78063994e-02f, 3.42437595e-01f, -1.99683577e-01f, 4.63371903e-01f,
  -1.21869004e+00f, -6.25559926e-01f, -6.98917061e-02f, 8.10559511e-01f, 5.51151037e-01f, 3.00789028e-01f, -1.02477238e-01f, 3.84099066e-01f, -8.27533901e-01f, 6.97202161e-02f,
  -7.98948467e-01f, -6.51397109e-01f, 3.09507579e-01f, -5.80425449e-02f, 1.38889877e-02f, -8.36737156e-01f, -3.08216177e-02f, -6.07717276e-01f, 1.20122276e-01f, 1.37962908e-01f,
  5.75414181e-01f, -7.05360547e-02f, -7.62635946e-01f, -8.22732210e-01f, 2.54688919e-01f, -1.14246341e-03f, -2.09426805e-01f, -1.39098763e-01f, 1.96384281e-01f, -6.85308158e-01f,
  -3.91058512e-02f, -4.58270669e-01f, 4.89456385e-01f, -5.36236949e-02f, -9.29270163e-02f, -9.42884982e-02f, 1.29673153e-01f, 2.11417496e-01f, -4.83146846e-01f, 1.24266475e-01f,
  3.29536259e-01f, 1.82146564e-01f, -8.14046383e-01f, -1.67569458e-01f, -2.11714152e-02f, -3.84002507e-01f, -5.87847382e-02f, -8.18339363e-02f, 5.76735288e-02f, 3.14021885e-01f,
  4.87164445e-02f, 3.01311523e-01f, -4.37697887e-01f, 3.74794513e-01f, -2.98641324e-01f, 7.13629648e-02f, -3.59870940e-01f, -5.06820902e-02f, 3.66691202e-01f, -2.75064945e-01f,
  2.27790192e-01f, -2.57310927e-01f, -1.69454515e-01f, 3.30381721e-01f, -1.48303002e-01f, -3.68605196e-01f, 1.62239417e-01f, 1.59157827e-01f, -6.49211049e-01f, -1.04630804e+00f,
  5.72736621e-01f, 5.29933125e-02f, -1.00387977e-02f, 1.80337593e-01f, -6.04413509e-01f, 2.12666094e-01f, -3.12683076e-01f, 3.60451639e-01f, 1.33874804e-01f, 9.49953571e-02f,
  -9.62665617e-01f, -9.01383013e-02f, -1.11973509e-01f, -5.42252541e-01f, 6.87490106e-02f, 1.41360953e-01f, -6.23108089e-01f, -2.59849399e-01f, -4.45973814e-01f, 1.42514363e-01f,
  -7.70486474e-01f, 2.35672787e-01f, -6.14955723e-01f, -3.98403667e-02f, -7.78813213e-02f, 2.26759017e-01f, 2.83918649e-01f, -2.08287090e-01f, 4.98873115e-01f, -6.74462616e-01f,
  -1.12732375e+00f, -4.60317284e-01f, -1.14704996e-01f, 7.36461699e-01f, -7.72727787e-01f, -6.82854876e-02f, 1.00363457e+00f, -1.48533955e-01f, -7.17269719e-01f, 2.58709770e-02f,
  1.63265020e-01f, -1.93592440e-02f, -1.42360032e-01f, -5.83755553e-01f, 2.12949172e-01f, -5.43549716e-01f, 2.61822641e-01f, -3.40098023e-01f, 4.24113363e-01f, -5.61280176e-02f,
  -2.83464491e-01f, -1.16055794e-01f, -8.74795556e-01f, -2.06344463e-02f, 2.44206250e-01f, 1.55213550e-01f, 7.55327344e-02f, -2.16589138e-01f, 1.18073657e-01f, -1.14094353e+00f,
  3.60459328e-01f, 6.04831576e-01f, 1.12913914e-01f, 2.65800029e-01f, -1.11545026e+00f, 2.13553503e-01f, 3.37581307e-01f, -2.32830167e-01f, 5.21888733e-01f, -1.74073136e+00f,
  8.40606689e-02f, -9.86866891e-01f, 9.18881893e-02f, -5.76646626e-01f, -3.64510179e-01f, 1.78815722e-01f, -3.81513506e-01f, -6.53266311e-01f, 2.39627734e-02f, -7.66476512e-01f,
  9.57824364e-02f, 1.71118945e-01f, -7.59446993e-02f, -1.45170435e-01f, -9.38714445e-01f, 3.36728662e-01f, -1.57981515e+00f, -9.14969891e-02f, -6.23744316e-02f, 2.75928199e-01f,
  1.86513752e-01f, -1.16341579e+00f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -3.60267222e-01f, -1.62102535e-01f, 3.70719343e-01f, -1.53827459e-01f, -2.75096744e-01f, 1.98045701e-01f, -1.18107252e-01f, -1.18161604e-01f, 4.42290336e-01f, -2.20516101e-01f,
  4.55076337e-01f, 3.73799682e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    