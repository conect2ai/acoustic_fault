/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.73867989e-01f, 9.72170234e-02f, 3.29539627e-01f, 3.51315946e-03f, -2.30697751e-01f, -1.74442381e-01f, 1.88766763e-01f, -1.39199272e-01f, 2.84505099e-01f, -1.11547254e-01f,
  -1.63810283e-01f, 1.54209256e-01f, 2.35620409e-01f, -7.01830462e-02f, -3.89847085e-02f, 3.42303634e-01f, -1.03390805e-01f, 3.55145000e-02f, 1.60871089e-01f, -8.58867075e-03f,
  1.18758284e-01f, -2.92665601e-01f, 1.19777866e-01f, -2.17874959e-01f, -5.59283886e-03f, 5.66848069e-02f, -2.55793631e-01f, 1.09149799e-01f, -3.01795870e-01f, -2.35975888e-02f,
  -2.40216050e-02f, 1.02486029e-01f, -1.14705145e-01f, 9.06545017e-03f, -9.15029421e-02f, -7.32392296e-02f, -2.89769657e-02f, -5.84603706e-03f, 3.49041037e-02f, 6.70600981e-02f,
  1.57752112e-02f, 4.08864580e-02f, -5.13388552e-02f, 3.41522209e-02f, -2.10368261e-02f, -1.34412870e-02f, 3.52012143e-02f, 1.26065919e-02f, 9.60009311e-06f, 3.45210843e-02f,
  7.11753219e-02f, 1.78046878e-02f, -4.71346825e-02f, -4.39430885e-02f, 3.00118886e-02f, 3.50062847e-02f, -1.50153404e-02f, 1.29195740e-02f, -1.75616089e-02f, -8.81805271e-03f,
  -7.65067562e-02f, 6.23725727e-02f, -5.37406304e-04f, 4.78505297e-03f, -2.29629632e-02f, 2.25802697e-02f, -9.99076176e-04f, 1.48055255e-02f, 6.47213683e-02f, -3.73995528e-02f,
  -6.24117889e-02f, -3.35690565e-03f, -2.24818854e-04f, 1.44634815e-02f, 7.49103278e-02f, -1.37306023e-02f, -2.09802557e-02f, 3.06190021e-04f, 2.69879438e-02f, 1.77128948e-02f,
  2.77242605e-02f, 9.72159021e-03f, 2.90706530e-02f, -2.69964966e-03f, 1.19831692e-02f, 1.75533164e-02f, 2.09402125e-02f, 5.76336868e-02f, 3.91267687e-02f, -2.13242341e-02f,
  -1.14448600e-01f, -8.11413080e-02f, 1.02861308e-01f, 3.10925618e-02f, 8.43017548e-03f, -5.24158329e-02f, -1.91033687e-02f, -7.52812950e-03f, 1.63374878e-02f, -6.81477338e-02f,
  -9.29574743e-02f, -8.61486420e-02f, 1.23580471e-02f, -9.35660768e-03f, -3.19897160e-02f, -4.54147793e-02f, -2.00810703e-03f, -6.48886189e-02f, -1.05718210e-01f, -4.91620228e-02f,
  -5.80905527e-02f, 9.05712601e-03f, -3.22995288e-03f, -6.28071800e-02f, -4.69373986e-02f, -4.98304702e-02f, -1.40008377e-02f, 2.24422924e-02f, -8.63669962e-02f, 1.23105031e-02f,
  -2.48533599e-02f, -1.25194699e-01f, -2.24302560e-02f, -1.83174863e-01f, -1.92542002e-01f, 2.03958839e-01f, 1.17428899e-01f, -1.36433095e-01f, 3.58775593e-02f, -6.45173937e-02f,
  1.39198199e-01f, 1.84857041e-01f, 1.51995957e-01f, 4.74012680e-02f, 5.55686533e-01f, 3.25594932e-01f, 2.02637121e-01f, 1.17207661e-01f, 1.37866959e-02f, -1.01488352e-01f,
  -3.27451862e-02f, 1.90866664e-02f, 4.30611111e-02f, -2.24403113e-01f, -2.83051997e-01f, -1.27150670e-01f, 3.71400602e-02f, -9.72382277e-02f, -1.31450016e-02f, 3.36370282e-02f,
  1.43641993e-01f, -4.50184941e-02f, -8.18291605e-02f, -3.55072841e-02f, -6.53749192e-03f, 2.08611526e-02f, 1.01986248e-02f, 3.92644964e-02f, -5.89220077e-02f, -2.51544192e-02f,
  2.75363568e-02f, -8.42624623e-03f, -2.21824087e-02f, -3.62779908e-02f, -3.43829542e-02f, -5.01988195e-02f, -6.57514781e-02f, -4.56125997e-02f, -5.24655990e-02f, -3.75390574e-02f,
  -1.92504227e-02f, 4.42545824e-02f, -2.66031250e-02f, 3.99414413e-02f, -1.81247070e-02f, -1.39386561e-02f, 4.21781428e-02f, -2.75064148e-02f, 2.98960265e-02f, 2.22730990e-02f,
  7.59879709e-04f, -7.09279701e-02f, -4.41550873e-02f, -6.77190814e-03f, 8.21796954e-02f, -6.90071136e-02f, 6.93717971e-02f, 2.44943630e-02f, -2.61848401e-02f, -1.32186599e-02f,
  2.35362705e-02f, -1.63185410e-02f, 1.74643274e-03f, -3.77796851e-02f, -2.94486396e-02f, -7.89085701e-02f, 3.12793106e-02f, 2.15660073e-02f, -1.78475082e-02f, 1.88444729e-03f,
  2.44975016e-02f, 2.70303655e-02f, -4.37043235e-02f, -1.14997420e-02f, 1.26100378e-02f, -5.71884634e-03f, -4.19333018e-02f, -4.04891483e-02f, -1.01853358e-02f, 6.01372682e-03f,
  2.10130364e-01f, 1.17418543e-01f, -1.67971142e-02f, 9.06832051e-03f, 4.40961272e-02f, 8.13278661e-04f, 4.88229655e-02f, -3.51658389e-02f, 6.32228032e-02f, -1.50132719e-02f,
  -6.57379627e-02f, -3.95682827e-02f, 5.12682945e-02f, 3.70434932e-02f, -2.59573366e-02f, 7.15248957e-02f, 5.75122721e-02f, -6.90131169e-03f, -2.28997003e-02f, 4.37293313e-02f,
  -5.46354009e-03f, -9.18546598e-03f, -7.92562515e-02f, -4.81506884e-02f, -5.94497286e-03f, 4.64738626e-03f, -3.49802850e-03f, -2.35758014e-02f, 3.65383946e-03f, 2.53772195e-02f,
  -4.62694168e-01f, 4.67682272e-01f, 6.92507103e-02f, -2.72672415e-01f, -2.60267437e-01f, 6.49308115e-02f, -4.13137764e-01f, 2.22218921e-03f, 1.93641596e-02f, 1.88563734e-01f,
  -5.12332655e-02f, 1.09661013e-01f, -9.79827866e-02f, -2.39101276e-02f, -1.56059906e-01f, 1.06553964e-01f, -3.70873474e-02f, 6.82210177e-02f, 9.65395719e-02f, -6.36994373e-04f,
  -1.48397103e-01f, -1.21360481e-01f, -1.99915156e-01f, 1.44889310e-01f, -6.12757392e-02f, 2.42983252e-02f, -6.37171566e-02f, -2.32618786e-02f, 4.29700539e-02f, -3.18546966e-02f,
  -1.54278368e-01f, -7.85299242e-02f, -1.01038255e-01f, 1.03094175e-01f, 3.61565091e-02f, 2.81937178e-02f, -4.57138419e-02f, -3.33709605e-02f, -3.09469607e-02f, -2.38775685e-02f,
  4.04987037e-02f, 9.63916443e-03f, -3.88047472e-02f, 2.60705817e-02f, 4.19315435e-02f, -3.25064734e-02f, 4.26024683e-02f, 5.92553569e-03f, -2.11240328e-03f, -6.59364834e-02f,
  2.84883622e-02f, 1.66536067e-02f, -6.78682923e-02f, 1.16981015e-01f, 3.57375294e-03f, -7.06302875e-04f, -6.20272569e-03f, 1.81669630e-02f, 1.07705581e-03f, 4.22717035e-02f,
  9.75585077e-04f, 4.52553928e-02f, -1.39437551e-02f, -3.39932404e-02f, 2.39592753e-02f, -5.09747416e-02f, 8.63894168e-03f, 2.12430563e-02f, 6.46302151e-03f, -3.87983979e-03f,
  -1.26981903e-02f, -2.26634219e-02f, 4.86322083e-02f, -4.56733927e-02f, -5.49450368e-02f, -2.54803374e-02f, -2.71642674e-03f, 7.74462614e-03f, 4.92183939e-02f, -3.30984406e-02f,
  1.02992160e-02f, 3.58839356e-03f, 2.85950629e-03f, -1.28961410e-02f, 4.54221964e-02f, -4.71208468e-02f, 1.28899934e-03f, 3.19440141e-02f, -1.57956895e-03f, -5.43423221e-02f,
  2.96334028e-01f, 4.43422973e-01f, 1.66886002e-02f, -9.82959941e-02f, 8.71691927e-02f, 1.00497015e-01f, 4.59588505e-02f, -3.34544927e-02f, 8.82260054e-02f, 1.01915216e-02f,
  -2.81954533e-03f, -7.55935535e-02f, 4.29744124e-02f, -1.76731162e-02f, -1.40244461e-04f, 3.58162187e-02f, 2.65193377e-02f, 6.32841587e-02f, -2.45463382e-02f, 1.24429902e-02f,
  1.83482580e-02f, -2.09296327e-02f, -1.35837654e-02f, -8.67867768e-02f, 3.02550010e-02f, 2.49699205e-02f, -2.66792905e-03f, -2.96889426e-04f, 8.08729380e-02f, 5.22616431e-02f,
  -6.41512036e-01f, 1.06443681e-01f, 3.61108705e-02f, -2.50108629e-01f, -2.20068961e-01f, -1.19125113e-01f, -1.53066218e-01f, -5.19513711e-02f, -3.00169736e-01f, 1.37732401e-01f,
  -1.96866319e-01f, 4.01718244e-02f, 5.01556993e-02f, -1.61044821e-01f, -2.76190400e-01f, 5.40792942e-02f, -2.47143283e-01f, 4.58543152e-02f, -1.29699275e-01f, -4.67080921e-02f,
  -1.50581524e-01f, -4.14204560e-02f, -1.95829757e-02f, 3.99937332e-02f, 3.33900601e-02f, 7.74084255e-02f, 1.59031883e-01f, 1.24472409e-01f, 2.16208547e-02f, 6.74967766e-02f,
  -1.55024782e-01f, -1.67396873e-01f, 2.76287296e-03f, 7.41343424e-02f, 1.58324465e-02f, 2.54835729e-02f, 4.12284881e-02f, -2.42790710e-02f, -7.98870903e-03f, -1.88596081e-03f,
  -8.32876936e-03f, -4.30358052e-02f, -2.62013935e-02f, -2.86634061e-02f, -7.46378154e-02f, -5.34233563e-02f, -6.40618056e-02f, 1.09960381e-02f, 2.58942647e-03f, -3.87083255e-02f,
  -1.67089999e-02f, 1.15374643e-02f, 3.94836664e-02f, -5.60786622e-03f, -2.14316007e-02f, -6.70221969e-02f, 1.26085593e-03f, 7.17546344e-02f, -4.20992449e-02f, -5.78014553e-02f,
  -1.63419973e-02f, 5.09961993e-02f, 1.92205310e-02f, 1.83194708e-02f, -5.22057805e-03f, -2.46268362e-02f, 3.40672722e-03f, 2.48211622e-02f, -1.66926272e-02f, -2.17901058e-02f,
  -5.37186041e-02f, -3.57126668e-02f, -2.99918447e-02f, -1.07098836e-04f, -1.91289876e-02f, -1.90503325e-03f, 2.86368225e-02f, 1.53002404e-02f, -2.22231913e-02f, 2.79368227e-03f,
  -2.17083432e-02f, -1.11943031e-04f, -5.14180958e-03f, 3.46395783e-02f, 1.14129828e-02f, 3.02879084e-02f, -1.33414920e-02f, 2.50637289e-02f, 3.44837978e-02f, 5.50976098e-02f,
  1.37675896e-01f, 2.69241780e-01f, 4.99382503e-02f, 3.01101594e-04f, -1.17496625e-02f, -8.82827640e-02f, 1.12141832e-03f, 4.27440591e-02f, 2.54958402e-02f, 1.50518985e-02f,
  4.27644700e-03f, -4.00164491e-03f, 6.44015446e-02f, -1.34793837e-02f, 3.68816480e-02f, 1.74150541e-02f, 4.55816314e-02f, -8.55206605e-03f, 5.95477484e-02f, 8.31841119e-03f,
  5.67101166e-02f, 5.83121739e-03f, -8.17236230e-02f, 4.81518321e-02f, -1.72045119e-02f, 3.59848998e-02f, 2.59774905e-02f, -7.75919762e-03f, 5.16163968e-02f, 2.10309606e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.27686930e-01f, 3.16209704e-01f, -1.64058343e-01f, -2.16450635e-02f, -2.67243207e-01f, 4.03908901e-02f, 8.86256620e-02f, 5.67940325e-02f, -1.52770981e-01f, 2.75343657e-01f,
  1.48132414e-01f, -1.43481478e-01f, 2.36000150e-01f, 3.55416119e-01f, -2.66588420e-01f, 2.98498839e-01f, 8.70624185e-02f, 4.66686077e-02f, 8.31838511e-03f, 1.32811014e-02f,
  -6.85847849e-02f, 2.30736181e-01f, 1.02836490e-01f, 1.68304875e-01f, -7.03398436e-02f, -5.97213171e-02f, 3.96779962e-02f, -3.22771631e-02f, -5.75630367e-03f, -9.09072906e-02f,
  -1.40320376e-01f, -1.52883038e-01f, -8.29733089e-02f, -5.33070751e-02f, -1.44020498e-01f, -9.58635584e-02f, -4.55863327e-02f, -5.39751500e-02f, -2.74529792e-02f, 3.09598353e-03f,
  -4.71325096e-04f, -1.63535271e-02f, -8.83668382e-03f, -1.08599197e-02f, -4.65385057e-02f, -6.42168801e-03f, 3.48968618e-02f, -1.35130128e-02f, 9.74934082e-03f, -8.10693949e-03f,
  6.06501140e-02f, -3.41842417e-03f, -8.71620793e-03f, 3.70898694e-02f, -9.46679246e-03f, 5.21299243e-02f, -5.12913102e-03f, -5.39662279e-02f, -4.98179458e-02f, -3.78565192e-02f,
  -3.92291807e-02f, -1.21825133e-02f, 5.12646176e-02f, -5.69172613e-02f, 1.42453806e-02f, 1.04962178e-02f, -1.52248535e-02f, -4.57907692e-02f, 1.94850136e-02f, 1.66532751e-02f,
  -2.62544602e-02f, -4.88976296e-03f, -8.13358575e-02f, 1.03104606e-01f, -3.39757488e-03f, -1.85182355e-02f, 4.17810027e-03f, -2.63079330e-02f, 6.00482225e-02f, -6.75816834e-02f,
  4.20133397e-02f, -2.02827826e-02f, 3.95285003e-02f, 3.57442424e-02f, -4.86301742e-02f, 3.26436013e-02f, 9.07323733e-02f, -7.73858977e-03f, -1.84428580e-02f, -5.10653108e-02f,
  -2.37050518e-01f, -2.44528621e-01f, -4.38254252e-02f, -4.84689698e-02f, -3.23243365e-02f, -1.20110577e-02f, 1.47724804e-02f, -1.05413748e-02f, -3.01475804e-02f, -6.39000162e-02f,
  2.69570276e-02f, -5.11017628e-02f, -4.56086397e-02f, -1.65713951e-02f, 2.30688564e-02f, 3.60818356e-02f, -9.11676418e-03f, 2.19963323e-02f, -8.16371366e-02f, -6.92994371e-02f,
  -4.84445095e-02f, -4.51662019e-02f, 2.07834560e-02f, -1.81796867e-02f, 1.21101094e-02f, -5.07782921e-02f, -5.11166938e-02f, -4.00370359e-03f, -3.54901999e-02f, 7.41211995e-02f,
  1.70395926e-01f, -3.72384638e-02f, 3.07158586e-02f, -1.51980355e-01f, -1.32011637e-01f, 2.33168736e-01f, 4.02040571e-01f, 2.82935938e-03f, -1.66478887e-01f, 1.62301779e-01f,
  -3.12396251e-02f, 7.69360214e-02f, 2.41911352e-01f, 6.42651245e-02f, 1.13731854e-01f, 1.35033861e-01f, 9.62898582e-02f, 6.69576004e-02f, -9.02514085e-02f, 1.07345961e-01f,
  -2.40126848e-02f, 9.21211913e-02f, 5.13344146e-02f, -7.99996853e-02f, 1.43676670e-03f, -1.93014860e-01f, -8.17912370e-02f, 7.37224817e-02f, -1.37774438e-01f, -1.76651087e-02f,
  4.61133309e-02f, 3.94654572e-02f, 4.83840369e-02f, 4.98964079e-02f, -3.21686640e-02f, -6.88143894e-02f, 7.92879686e-02f, 1.24820046e-01f, -1.01536792e-02f, 7.64961215e-03f,
  8.58072191e-02f, -1.73582304e-02f, -5.52942082e-02f, 3.46777737e-02f, -1.50954388e-02f, -6.17861971e-02f, -6.28754497e-02f, -6.17288128e-02f, 1.52299087e-02f, 8.24061409e-03f,
  -1.26491627e-02f, -6.87850192e-02f, -3.44980955e-02f, -4.46654111e-03f, -3.43790166e-02f, -5.34003191e-02f, 2.55989507e-02f, -3.75352688e-02f, -4.01073247e-02f, -9.04816613e-02f,
  7.32249320e-02f, 3.50528434e-02f, 6.58596382e-02f, 6.31635031e-03f, 2.73041688e-02f, -1.29515547e-02f, -9.33866296e-03f, 3.00807226e-02f, -2.46378276e-02f, -1.23540824e-02f,
  -7.12156892e-02f, -4.08737883e-02f, 4.38798405e-03f, 3.98920529e-04f, 1.52256628e-02f, 3.99802215e-02f, 9.59264562e-02f, -1.19824961e-01f, -3.49827595e-02f, -6.48313910e-02f,
  2.44871649e-06f, 6.40120916e-03f, -5.99198528e-02f, 4.52433247e-03f, -5.29354028e-02f, 4.85509820e-02f, -5.98766208e-02f, -3.69600616e-02f, -7.59776235e-02f, 9.41741168e-02f,
  4.01339941e-02f, 8.57077166e-02f, 3.97582278e-02f, 6.35288954e-02f, -4.35143188e-02f, 5.67299873e-03f, 1.05680693e-02f, 3.01207509e-03f, -4.33758758e-02f, 1.44385025e-02f,
  -5.39036058e-02f, -8.24024063e-03f, -2.04275432e-03f, -5.38247898e-02f, -1.24418009e-02f, -4.91702184e-02f, 1.37135424e-02f, 1.55931823e-02f, 8.72559100e-03f, -1.74228474e-02f,
  -4.37446777e-03f, 7.05563650e-02f, 5.38335592e-02f, -4.38319184e-02f, -9.58635509e-02f, 4.45823409e-02f, -4.42536809e-02f, 6.40131021e-03f, -1.65462820e-03f, -4.19431925e-02f,
  8.72073974e-03f, -1.40795320e-01f, -3.35260421e-01f, -3.32308799e-01f, -1.03602998e-01f, -3.40627611e-01f, -3.68502349e-01f, -5.43822534e-02f, -1.61926150e-01f, 1.39252633e-01f,
  7.99197610e-03f, -1.46566883e-01f, 1.59164414e-01f, -4.24114197e-01f, -2.96881020e-01f, -3.36120240e-02f, -2.61580259e-01f, -2.08807155e-01f, -9.13871154e-02f, 2.03615241e-02f,
  -5.44021791e-03f, -9.18543860e-02f, -1.92087635e-01f, 1.19403467e-01f, -2.15887517e-01f, 1.22197069e-01f, 3.08688104e-01f, 1.20235793e-01f, -1.69464182e-02f, -1.03974611e-01f,
  -1.46981895e-01f, 7.07609206e-02f, -7.40372017e-02f, 3.53872147e-03f, 2.09470075e-02f, 3.77452262e-02f, 1.35457302e-02f, -4.66879532e-02f, -4.27620783e-02f, 1.33255906e-02f,
  6.08480982e-02f, -6.25311723e-03f, -4.26254272e-02f, 1.62248872e-02f, -2.09657922e-02f, -2.10872907e-02f, 1.53373992e-02f, -1.34922087e-01f, -4.15025800e-02f, -8.68305787e-02f,
  -7.81379640e-02f, -5.30532561e-02f, 1.57337878e-02f, 1.97311286e-02f, -4.03154716e-02f, -4.74577695e-02f, -4.34870496e-02f, -3.32332170e-03f, 3.74978557e-02f, -5.10387234e-02f,
  9.57934856e-02f, 9.15009901e-02f, -2.15231255e-02f, -8.16952214e-02f, -1.10100594e-03f, -4.94381133e-03f, -6.18371628e-02f, 1.57652181e-02f, -3.94029990e-02f, 6.33143261e-02f,
  -6.29019458e-03f, -5.39194643e-02f, 1.99606791e-02f, -2.56118011e-02f, 8.92245676e-03f, -5.19919535e-03f, 2.45068856e-02f, 9.00124013e-03f, -8.14337879e-02f, -6.73927069e-02f,
  -3.94488573e-02f, 1.41706432e-05f, -2.18125759e-03f, 3.28464583e-02f, -4.80924547e-02f, 4.32915501e-02f, 5.23245744e-02f, 4.74030226e-02f, -2.33432627e-03f, -7.34386593e-03f,
  2.48544086e-02f, 1.30945683e-01f, -2.49253288e-02f, -2.01331116e-02f, 1.70036331e-02f, -2.05649752e-02f, -5.52466698e-02f, -5.82947768e-02f, 3.83529104e-02f, 4.27367399e-03f,
  7.21732974e-02f, 1.62064831e-03f, 6.18839003e-02f, -8.56374353e-02f, 2.85352534e-03f, 4.62546982e-02f, 7.50551671e-02f, 7.26689026e-02f, -4.98658307e-02f, 3.15978862e-02f,
  2.30811834e-02f, 9.71568748e-02f, 2.83823721e-02f, -1.95338950e-02f, 5.27267717e-02f, 1.62456054e-02f, -2.23385077e-03f, -2.60625463e-02f, 3.83601710e-02f, -4.05078977e-02f,
  -5.18679917e-01f, 2.02354029e-01f, -1.37661517e-01f, -3.82769585e-01f, -1.01568729e-01f, -1.87250033e-01f, -3.94782335e-01f, -3.35000493e-02f, -4.33681905e-02f, -3.13219354e-02f,
  -1.19946279e-01f, 1.63851790e-02f, 2.70277083e-01f, -9.66596305e-02f, 1.03353642e-01f, 2.95137405e-01f, -2.60436058e-01f, -1.75298616e-01f, 1.61200777e-01f, -2.02415138e-01f,
  1.77400038e-02f, -8.22402239e-02f, 2.71447711e-02f, 1.59909219e-01f, -3.69285375e-01f, -1.52306899e-01f, -1.56561285e-02f, -1.62702389e-02f, -2.43180037e-01f, -1.26468480e-01f,
  -2.98780799e-01f, -2.32558221e-01f, -1.28491729e-01f, -4.89968695e-02f, -1.57849163e-01f, -1.39380470e-01f, -1.05468601e-01f, -1.67307574e-02f, -2.61149788e-03f, 5.54023571e-02f,
  -4.16250154e-02f, 8.70890617e-02f, -1.46904076e-02f, 5.32315411e-02f, -3.39322463e-02f, -8.01099762e-02f, 4.74643596e-02f, -1.54467016e-01f, 1.15124332e-02f, 3.07462756e-02f,
  -1.07468041e-02f, -1.35583533e-02f, -1.28297940e-01f, -3.85096967e-02f, -5.10394536e-02f, -1.12572804e-01f, -6.83641210e-02f, -2.48399787e-02f, -7.69512877e-02f, -2.13178638e-02f,
  4.36101221e-02f, -1.03462031e-02f, -1.06448252e-02f, -2.29059495e-02f, -9.14048404e-03f, 5.50971217e-02f, -5.52871451e-03f, 2.23071110e-02f, -3.62525657e-02f, -3.85829806e-03f,
  -5.91485202e-02f, -2.33238675e-02f, -6.62501901e-02f, -6.00761771e-02f, -2.24292884e-03f, -4.51699682e-02f, -1.50458200e-03f, -4.19350788e-02f, -5.97749557e-03f, 5.39181242e-03f,
  1.66159198e-02f, -1.79093052e-02f, 2.51430590e-02f, -7.35098943e-02f, -5.35205267e-02f, 4.74403333e-03f, 8.84889439e-03f, 6.57311752e-02f, 2.93683875e-02f, -3.71397869e-03f,
  -2.69566655e-01f, -3.04571301e-01f, -5.38056158e-02f, -1.17770910e-01f, 4.92569543e-02f, 1.71908326e-02f, 3.47885750e-02f, 8.29095859e-03f, -6.65592253e-02f, -4.87545598e-03f,
  -5.46736568e-02f, 1.48242563e-02f, -1.41896084e-01f, -1.84893459e-02f, 5.97157814e-02f, 9.41669568e-03f, -1.51689807e-02f, -4.42743786e-02f, -1.11938275e-01f, -2.18627304e-02f,
  -1.21117588e-02f, 3.14678624e-02f, 3.69892344e-02f, 1.47049446e-02f, -5.12662902e-02f, -4.14282419e-02f, 1.13803996e-02f, -1.17663573e-02f, -5.48044853e-02f, -2.26022378e-02f,
  1.24809903e-03f, 2.17948914e-01f, 2.38113105e-01f, 1.36963785e-01f, -1.39877662e-01f, -2.85784543e-01f, -1.23133533e-01f, 5.13326973e-02f, -7.86265060e-02f, 9.38441604e-02f,
  4.17468026e-02f, 1.32881448e-01f, 7.27793500e-02f, -7.48111755e-02f, -1.99700549e-01f, -1.65901408e-01f, -7.02493712e-02f, -1.70070585e-02f, 7.60086477e-02f, 2.26833180e-01f,
  2.26739775e-02f, -1.81398362e-01f, 1.14172325e-01f, -3.71775329e-02f, 1.03513137e-01f, 2.50627548e-01f, 1.13667704e-01f, -4.78034802e-02f, 1.48456335e-01f, -2.16535836e-01f,
  -1.16838999e-02f, 3.11807171e-02f, 4.35748585e-02f, -4.69627343e-02f, 6.00985959e-02f, 3.84543613e-02f, 2.29849909e-02f, -6.19684458e-02f, 1.50848897e-02f, -4.08397382e-03f,
  2.67855693e-02f, 7.60634020e-02f, -2.31808573e-02f, -2.84378324e-02f, -3.64260040e-02f, 2.96261385e-02f, 3.56453769e-02f, 1.87829963e-03f, -6.38554245e-02f, 1.35537274e-02f,
  7.68851712e-02f, 6.35728240e-02f, -1.17433807e-02f, -1.91154312e-02f, 4.41311449e-02f, 1.86584983e-02f, -6.30705804e-03f, 4.97170771e-03f, 3.29204537e-02f, 5.80468774e-02f,
  -6.07270300e-02f, -4.88659255e-02f, -7.25900531e-02f, 2.34311356e-05f, -7.12623224e-02f, 1.01521224e-01f, -3.98659036e-02f, 4.04706709e-02f, 2.17600483e-02f, -9.98719484e-02f,
  1.25981480e-01f, -3.12453173e-02f, -1.17577106e-01f, 1.04623340e-01f, 5.82854562e-02f, -1.70407202e-02f, 5.63941561e-02f, 6.51210838e-04f, 1.61087755e-02f, 7.23999590e-02f,
  6.28463626e-02f, 1.91517435e-02f, -5.60354032e-02f, -7.95850158e-02f, -1.17741644e-01f, 4.72937599e-02f, 3.32706757e-02f, -1.83551367e-02f, 1.02946640e-03f, -1.28496261e-02f,
  -8.41519516e-03f, 1.34167805e-01f, 4.97440901e-03f, -6.13031387e-02f, -2.25473177e-02f, -1.51896523e-02f, -4.90549989e-02f, -1.19283972e-02f, 9.21235904e-02f, -1.18070349e-01f,
  4.53857817e-02f, -3.71733792e-02f, -2.66519301e-02f, -1.04351360e-02f, -6.35345578e-02f, 2.52595264e-02f, 2.15141978e-02f, 8.33918080e-02f, 3.89469340e-02f, 6.07915521e-02f,
  1.22718319e-01f, -3.24636400e-02f, 9.12510883e-03f, 3.68164591e-02f, 5.57740666e-02f, -4.18217443e-02f, 1.29770460e-02f, 8.55610967e-02f, -1.20179895e-02f, 2.83691287e-02f,
  2.39525542e-01f, 1.66936278e-01f, 8.86461698e-03f, 3.31342161e-01f, -7.96903148e-02f, -3.87469918e-01f, -5.17304301e-01f, 2.52174318e-01f, -2.47989208e-01f, -4.27740589e-02f,
  2.67882168e-01f, -9.00946334e-02f, 5.95242493e-02f, 3.71136159e-01f, 4.41099942e-01f, -2.31684446e-02f, 3.75905186e-01f, 5.95507100e-02f, 2.88218446e-02f, 1.81007579e-01f,
  2.03431144e-01f, 4.13939863e-01f, 3.71342748e-01f, 3.67770016e-01f, 1.46477491e-01f, 1.81266248e-01f, 3.98590744e-01f, -4.78448719e-03f, 2.12116688e-01f, 1.09329462e-01f,
  -2.36395255e-01f, -4.43357974e-02f, -1.57381836e-02f, -4.30231504e-02f, -8.86360125e-04f, -1.63503200e-01f, -7.92982057e-02f, 7.50331301e-03f, 4.48239185e-02f, -1.24489041e-02f,
  -5.11120409e-02f, 3.35312635e-02f, -6.26062676e-02f, 1.53870285e-02f, -3.97996940e-02f, -3.08761862e-03f, -7.17164874e-02f, -6.07365035e-02f, -6.34098724e-02f, -3.65117714e-02f,
  -9.73922238e-02f, 9.13501251e-03f, -4.26985547e-02f, -2.40773093e-02f, 3.33199278e-02f, -1.33576849e-02f, -1.08043835e-01f, 3.86797497e-03f, -7.01188296e-02f, 2.71843467e-02f,
  2.85537411e-02f, -2.12677065e-02f, 7.82411918e-03f, -1.30270692e-02f, 7.03754574e-02f, -1.71541963e-02f, 4.83374856e-03f, 3.44746895e-02f, -3.17592099e-02f, 1.29266204e-02f,
  5.70281083e-03f, -1.14042982e-02f, -2.84271147e-02f, -6.60236254e-02f, 1.55619094e-02f, -2.19378732e-02f, -4.05926928e-02f, 8.00885186e-02f, -1.61562569e-03f, -2.01361533e-02f,
  1.02608548e-02f, 9.49757770e-02f, -1.72006488e-02f, 6.39530085e-03f, 5.54081611e-02f, 2.02624104e-03f, 7.26281181e-02f, -3.73525396e-02f, -3.97770442e-02f, -2.44507883e-02f,
  1.48718864e-01f, 2.57625818e-01f, -8.89728367e-02f, 9.59419459e-03f, -9.83356312e-02f, 2.64355224e-02f, -3.18586603e-02f, 3.71267013e-02f, 6.28497973e-02f, 7.54291657e-03f,
  -3.19871269e-02f, -1.41119771e-02f, 4.57836799e-02f, -3.08690574e-02f, 1.05710931e-01f, -4.37930152e-02f, 5.30633144e-02f, -6.65589049e-03f, 4.30157632e-02f, 1.12516239e-01f,
  2.71747224e-02f, -5.85509315e-02f, -2.27491576e-02f, -9.92103070e-02f, -3.22596123e-03f, -9.19867214e-03f, 8.79332423e-03f, -2.68543568e-02f, 5.75789139e-02f, 1.29689078e-03f,
  -2.32780784e-01f, 2.37488315e-01f, -2.08437189e-01f, 1.21701688e-01f, -7.94353262e-02f, 7.31534138e-02f, 1.13898553e-01f, -3.66246700e-02f, -5.40551310e-03f, 5.60683489e-01f,
  2.61447966e-01f, -1.62631884e-01f, 2.30461106e-01f, 3.06945205e-01f, -5.35403788e-02f, 1.48134202e-01f, 2.52143502e-01f, 1.14336140e-01f, -8.27426761e-02f, 5.72711863e-02f,
  -7.70449266e-02f, 3.44822437e-01f, 2.67647821e-02f, 1.12613030e-01f, 1.53492168e-01f, -1.03029341e-01f, 8.41169357e-02f, -1.55320644e-01f, 9.79491845e-02f, 2.78488151e-03f,
  1.04347475e-01f, 1.53443113e-01f, -1.12855397e-01f, -4.00661752e-02f, 1.12773821e-01f, 4.91489694e-02f, -3.02433707e-02f, -8.40663910e-02f, -1.28115147e-01f, 3.75469178e-02f,
  -4.25400548e-02f, -1.07065693e-01f, 2.73046978e-02f, -5.22433221e-02f, -5.38015962e-02f, -7.13740215e-02f, -6.35105520e-02f, -2.86960490e-02f, -1.19158356e-02f, 4.17735986e-02f,
  -9.29095894e-02f, -4.14347611e-02f, -1.95854437e-03f, 6.84958789e-03f, -9.03141573e-02f, -3.26624922e-02f, 4.71178815e-02f, -1.15264188e-02f, 9.18984599e-03f, 3.88525203e-02f,
  -2.06934940e-02f, -1.04535269e-02f, 2.51497328e-02f, -3.46446433e-03f, -4.36603911e-02f, 4.27916497e-02f, 3.60710993e-02f, 2.86753792e-02f, -1.05877981e-01f, 5.44829816e-02f,
  -4.01030332e-02f, 2.05512973e-03f, -4.80838818e-03f, -6.79341182e-02f, 8.79276693e-02f, 3.77448392e-03f, -6.82342146e-03f, 6.48936704e-02f, -6.26622811e-02f, 1.11264633e-02f,
  3.70267183e-02f, -4.29357262e-03f, 5.67868054e-02f, -2.43208520e-02f, 4.75953519e-02f, -9.23290253e-02f, -1.16979545e-02f, 3.63029018e-02f, -5.62311662e-03f, -7.03127705e-04f,
  1.28958106e-01f, 2.85887152e-01f, 5.80518506e-02f, -2.87756976e-02f, 9.87420976e-03f, 6.39194548e-02f, 4.96406816e-02f, -3.30902413e-02f, 2.93564759e-02f, 4.09613848e-02f,
  3.55707072e-02f, 1.28838941e-02f, 5.80777079e-02f, 4.11929116e-02f, -9.86376181e-02f, 1.39215410e-01f, 1.09938428e-01f, -2.99000517e-02f, 6.79003000e-02f, -3.87253873e-02f,
  5.27359694e-02f, 6.02328852e-02f, -1.46869114e-02f, 1.83417778e-02f, 2.78688222e-02f, 8.34598765e-02f, -4.50136997e-02f, 1.74416918e-02f, -2.94208210e-02f, -6.69859648e-02f,
  -4.08385932e-01f, 8.96970332e-02f, 9.95063484e-02f, -3.04841220e-01f, 8.68808851e-02f, -8.34301785e-02f, -1.15354463e-01f, 1.17913738e-01f, 6.14898987e-02f, 8.85472596e-02f,
  8.05674866e-02f, 1.73767973e-02f, 9.18424129e-02f, -6.97699189e-02f, -3.22599530e-01f, 1.73331145e-02f, -1.98240906e-01f, -1.42282844e-01f, 2.66905110e-02f, -7.12673366e-02f,
  -1.57148138e-01f, -1.34619931e-02f, -1.00017458e-01f, 4.64951545e-02f, 7.91184306e-02f, -1.54715972e-02f, 6.29143091e-03f, 1.73004180e-01f, -1.51451975e-02f, 4.26981971e-02f,
  1.17573224e-01f, 3.20776761e-01f, 1.17419004e-01f, 7.24904016e-02f, -7.07905814e-02f, -6.30314425e-02f, 3.31411138e-02f, 1.17282614e-01f, 1.94174063e-03f, -2.78562661e-02f,
  4.16788906e-02f, 2.31927056e-02f, 1.91042926e-02f, 2.24032141e-02f, -1.28446277e-02f, 2.23885626e-02f, 1.25115301e-04f, -7.17510656e-03f, 7.66133294e-02f, 4.17267978e-02f,
  -2.92234700e-02f, 5.84074743e-02f, -5.06934784e-02f, -1.94932688e-02f, 2.72314269e-02f, 2.43921019e-02f, -3.03611830e-02f, 3.58779803e-02f, -2.12022364e-02f, 3.03695593e-02f,
  -4.63468060e-02f, -6.42671734e-02f, 2.08355021e-02f, 1.19164534e-01f, 1.83459595e-02f, 4.59480882e-02f, -3.13336030e-02f, 3.91588211e-02f, -8.04310814e-02f, -7.28654787e-02f,
  1.32070659e-02f, -4.49668169e-02f, 1.93007886e-02f, -1.51773065e-01f, -1.10370234e-01f, 4.13749665e-02f, -8.46273378e-02f, 2.85299011e-02f, -9.42673683e-02f, 2.48676706e-02f,
  1.31346375e-01f, 4.93561849e-02f, 2.23344713e-02f, -1.01568103e-01f, 3.84848043e-02f, -4.21228297e-02f, -3.61558124e-02f, -4.70588915e-02f, 1.13631040e-02f, -4.99611087e-02f,
  -4.64477167e-02f, 1.47614125e-02f, 1.26986012e-01f, 7.75299370e-02f, 9.91368107e-03f, 4.24358696e-02f, -2.51245480e-02f, -2.98830140e-02f, -1.86698511e-02f, -5.41741364e-02f,
  -7.53038302e-02f, -4.88638766e-02f, -7.99198542e-03f, 6.11111373e-02f, -4.51869406e-02f, -6.95748106e-02f, -8.84631369e-03f, 1.22493710e-02f, -7.88730606e-02f, 4.04439047e-02f,
  -1.99112091e-02f, 3.01378071e-02f, -9.95386392e-02f, -5.73977940e-02f, -5.31647094e-02f, 7.78004304e-02f, -5.49941212e-02f, 1.08959712e-02f, 6.24205032e-03f, -9.21984948e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.75482854e-01f, 1.58518866e-01f, 2.39237174e-01f, 2.35456333e-01f, 5.06354962e-03f, -1.50081351e-01f, 3.35804701e-01f, 1.19351931e-02f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.70893803e-01f, 2.69440979e-01f, -2.29160577e-01f, 2.47358397e-01f, 1.77573696e-01f, 1.51303485e-01f, -1.11483410e-01f, -5.08120000e-01f, -5.87672949e-01f, 1.48013473e-01f,
  7.37890229e-02f, 1.48870230e-01f, 1.86482802e-01f, 3.66490901e-01f, -1.62710726e-01f, -3.43589872e-01f, 2.21390396e-01f, 2.08748644e-03f, 1.36350900e-01f, 5.08384705e-01f,
  4.31691080e-01f, 8.75495911e-01f, 4.21991408e-01f, -9.31299198e-03f, 2.84508355e-02f, 2.04406038e-01f, -8.96307901e-02f, 2.94741094e-01f, -1.20928511e-01f, -2.02224717e-01f,
  -5.52484728e-02f, 8.99512321e-02f, -2.85716712e-01f, -8.79022479e-03f, -2.01971546e-01f, -1.59121275e-01f, 3.86692360e-02f, -2.54709125e-01f, -4.74927127e-01f, 2.24896252e-01f,
  -2.85030127e-01f, 3.50645673e-03f, -1.90740213e-01f, -3.91500354e-01f, 4.35025424e-01f, 4.19556171e-01f, -1.86508566e-01f, -2.11953178e-01f, -7.96320736e-02f, -1.72561838e-03f,
  3.40382993e-01f, 1.58921555e-01f, -2.05812290e-01f, -5.45456111e-01f, 4.68726009e-01f, 2.98899889e-01f, -4.16200936e-01f, -2.85228938e-01f, 2.41640106e-01f, 2.39137933e-01f,
  3.43635470e-01f, 4.97649878e-01f, -2.64861465e-01f, 1.98464975e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.73895404e-01f, -9.32056606e-02f, 4.83011268e-02f, -2.43449196e-01f, -2.39229023e-01f, -3.16200137e-01f, 2.04504624e-01f, 1.20260894e-01f, -1.79952029e-02f, -1.49826780e-01f,
  2.07377434e-01f, 5.70157804e-02f, -1.89228311e-01f, -1.49993345e-01f, -5.91429323e-02f, 1.86779171e-01f, 2.14352399e-01f, 1.50553286e-01f, -1.19291857e-01f, -9.41160414e-03f,
  1.99195519e-01f, -2.28823379e-01f, -2.46998534e-01f, -4.12247218e-02f, -7.68945366e-02f, -1.80424619e-02f, -3.20510529e-02f, -1.80085793e-01f, 4.52310294e-01f, -1.01682119e-01f,
  9.46080126e-03f, -1.34795189e-01f, 3.30691338e-01f, 2.25741178e-01f, 1.93211615e-01f, 7.44650781e-01f, 2.26805866e-01f, 6.18359447e-01f, 1.58635169e-01f, -2.16160402e-01f,
  2.02030331e-01f, 3.66280586e-01f, 6.12714291e-02f, 6.08767807e-01f, -1.83241844e-01f, 3.48848961e-02f, 3.03204030e-01f, -1.12693414e-01f, 7.48702288e-01f, 7.35276267e-02f,
  6.43600643e-01f, 1.50540903e-01f, 3.57504860e-02f, -2.29354843e-01f, 4.76761043e-01f, 6.90112650e-01f, 7.47167587e-01f, -7.81796575e-02f, 5.01922071e-01f, 6.92600310e-01f,
  4.26567085e-02f, 2.41982281e-01f, 3.77281636e-01f, 4.02599901e-01f, 1.74728379e-01f, -1.12940684e-01f, 2.22989842e-01f, -1.29044861e-01f, -4.96554762e-01f, -1.71167240e-01f,
  -1.79776713e-01f, 2.34996065e-01f, 1.89950895e-02f, -2.29479924e-01f, 2.97337938e-02f, -3.49242538e-01f, 3.28821719e-01f, 6.10068262e-01f, 2.59771973e-01f, -1.51219681e-01f,
  -3.10317636e-01f, 8.22855905e-03f, 4.59614187e-01f, 1.46581521e-02f, -7.87630498e-01f, 3.36623609e-01f, 1.18594304e-01f, -1.52988378e-02f, 2.42838040e-01f, 3.23272198e-01f,
  7.86527812e-01f, -1.00302175e-01f, -1.16921300e-02f, 1.05498946e+00f, 8.68760586e-01f, -1.44348189e-01f, 6.21669054e-01f, -2.83371657e-02f, -1.20626651e-02f, 4.06738192e-01f,
  1.64545313e-01f, -1.44375533e-01f, -3.19320709e-01f, -6.03077486e-02f, 8.47235024e-01f, 3.04656684e-01f, -3.52036923e-01f, 1.92821011e-01f, 1.64765015e-01f, -2.73882449e-01f,
  5.18209159e-01f, 2.64712483e-01f, 3.47527504e-01f, -1.26016870e-01f, 6.55145228e-01f, 3.79526466e-01f, 9.23723131e-02f, -6.77059591e-01f, 4.43534076e-01f, 6.69136822e-01f,
  -2.86651272e-02f, -1.91776916e-01f, 5.52112401e-01f, 6.36726677e-01f, 3.11757296e-01f, -2.35864550e-01f, 9.84020680e-02f, 4.60965484e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  -5.93683720e-02f, 4.57551390e-01f, 6.71745688e-02f, 3.16225410e-01f, -2.22274605e-02f, 4.36349332e-01f, 1.39218628e-01f, 3.28675717e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -7.14929774e-02f, 4.02619213e-01f, 3.79431278e-01f, -3.39927405e-01f, 3.55792969e-01f, -2.59111285e-01f, 5.77640057e-01f, -2.91318446e-01f, -2.07169548e-01f, 2.86935180e-01f,
  2.73496527e-02f, -3.82127553e-01f, 4.08964992e-01f, 1.94220960e-01f, 2.87460595e-01f, -2.49623984e-01f, 2.10823610e-01f, 1.87324315e-01f, -1.54288366e-01f, -3.11598599e-01f,
  6.70549273e-01f, -3.13587934e-01f, 4.59827602e-01f, 2.79282779e-01f, -2.69809306e-01f, -8.07174668e-02f, 1.49852201e-01f, -1.26904815e-01f, 2.25987554e-01f, 3.02531216e-02f,
  -5.29908299e-01f, 1.43480062e-01f, -7.23018885e-01f, 1.11359753e-01f, -2.32513011e-01f, -3.57506037e-01f, -6.01227999e-01f, -3.19908679e-01f, 3.54685694e-01f, -1.23440288e-01f,
  4.49106507e-02f, -1.03811353e-01f, -5.66447139e-01f, 2.23941982e-01f, 3.48599404e-01f, -5.84149845e-02f, 1.97906211e-01f, 9.24378932e-02f, 2.29026124e-01f, -4.47032869e-01f,
  -6.33475631e-02f, 2.95438856e-01f, 4.59452450e-01f, 4.08635557e-01f, -1.87611282e-02f, 3.69969338e-01f, -6.00736067e-02f, -2.17294231e-01f, 3.86525124e-01f, -1.98195219e-01f,
  -2.40126580e-01f, -2.30392545e-01f, -9.37201828e-02f, 2.84738749e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  7.07673550e-01f, 2.18512937e-01f, 1.98363125e-01f, 4.39484477e-01f, -1.20337203e-01f, 4.63598728e-01f, -4.67917234e-01f, 8.85601878e-01f, -1.47455603e-01f, 2.73198724e-01f,
  2.40840893e-02f, 7.81507015e-01f, 3.43247429e-02f, -5.18756688e-01f, -3.41861874e-01f, 1.02519643e+00f, 3.72423023e-01f, 9.77986827e-02f, -2.20463146e-02f, 6.77234605e-02f,
  -3.44123505e-02f, -3.00742000e-01f, -5.39775416e-02f, 7.51782879e-02f, -6.69442937e-02f, -4.58304495e-01f, 6.83408678e-02f, 2.43390411e-01f, 1.51044458e-01f, 1.23790812e+00f,
  -3.87590468e-01f, -2.72959620e-01f, 4.53771651e-01f, 2.50876755e-01f, 6.63551569e-01f, -3.68034504e-02f, 8.44109058e-02f, -9.39996421e-01f, 1.00511506e-01f, 1.17617905e-01f,
  1.64577335e-01f, 3.69194686e-01f, -3.94288868e-01f, 1.35753483e-01f, 2.43690446e-01f, 5.76661170e-01f, -5.01655579e-01f, 5.84039092e-01f, -5.29113710e-01f, -2.03083754e-01f,
  -4.99606341e-01f, -3.77554834e-01f, 3.06011647e-01f, -4.39852446e-01f, 2.55020827e-01f, 3.77851605e-01f, 2.90720880e-01f, -5.99727854e-02f, -3.44567984e-01f, 5.06605625e-01f,
  5.49145639e-01f, 5.03072679e-01f, -7.85433292e-01f, 6.12136543e-01f, -9.22160000e-02f, -3.14809799e-01f, -1.44997001e-01f, -5.39089479e-02f, -6.83678314e-02f, -2.16874912e-01f,
  1.08299211e-01f, 1.77864321e-02f, 3.85634452e-02f, 1.50512263e-01f, -1.80914938e-01f, 1.07746199e-01f, 2.77350307e-01f, 1.52705058e-01f, -3.29862565e-01f, 1.26926601e-01f,
  -6.21095598e-01f, 4.50937867e-01f, 6.15590662e-02f, 3.68448012e-02f, -9.07928169e-01f, 1.42243892e-01f, -8.69819298e-02f, 6.26695395e-01f, 2.94088989e-01f, -1.38198435e-01f,
  -1.91822469e-01f, 1.17331290e+00f, -1.68929487e-01f, -2.04835355e-01f, 4.51084197e-01f, 9.63220239e-01f, 3.09617724e-02f, -8.91525269e-01f, -3.60605359e-01f, 1.02486283e-01f,
  -1.66140407e-01f, 8.67629051e-01f, -7.09162951e-01f, -6.57994032e-01f, 1.18655317e-01f, -1.50452390e-01f, 1.06046844e+00f, 9.02527750e-01f, -1.00092456e-01f, 6.33952498e-01f,
  2.72348821e-01f, -2.27059741e-02f, 2.21876726e-01f, 2.01484486e-01f, -1.50833093e-02f, 1.05095424e-01f, 3.26678276e-01f, -2.85080850e-01f, 1.82619870e-01f, 3.08778524e-01f,
  -1.37232020e-01f, -3.78140748e-01f, -1.37718409e-01f, -1.35393605e-01f, 3.16320598e-01f, 8.65269125e-01f, -3.40868711e-01f, -2.39259601e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  1.27321810e-01f, 1.88106894e-01f, 5.04273653e-01f, 8.93949792e-02f, 1.80739611e-01f, -2.96098534e-02f, 2.30084777e-01f, -6.46480620e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  2.01902464e-01f, -5.17853975e-01f, 1.69354662e-01f, 7.16513768e-02f, -4.37579453e-01f, -4.36850125e-03f, 6.05261326e-01f, -4.74745840e-01f, -1.00280499e+00f, -1.28676012e-01f,
  -5.47400892e-01f, -2.04236165e-01f, 6.85978383e-02f, 7.47076333e-01f, 6.34741902e-01f, -2.15777203e-01f, 1.78185984e-01f, 1.61462165e-02f, -4.29218292e-01f, -1.77767828e-01f,
  4.49113846e-01f, 4.51803803e-02f, -2.43047893e-01f, -5.42777121e-01f, -1.92963481e-01f, 9.48422492e-01f, -1.61491200e-01f, -4.35314238e-01f, -2.36891508e-01f, -5.34305811e-01f,
  4.87945080e-01f, 4.86468345e-01f, -4.54995304e-01f, -1.25382677e-01f, 2.99406826e-01f, 2.91499197e-01f, 6.00208819e-01f, 7.20764816e-01f, 1.51169688e-01f, -3.89781207e-01f,
  -5.76930881e-01f, 6.06343091e-01f, 4.99221563e-01f, 3.15877914e-01f, 4.62240390e-02f, -7.53855050e-01f, -8.37793946e-01f, 9.50582504e-01f, -4.53744769e-01f, -3.96812528e-01f,
  -8.79660308e-01f, -9.08185616e-02f, 3.29110101e-02f, -2.35790938e-01f, 9.63635504e-01f, -1.35866463e-01f, 2.36584246e-01f, -2.83995599e-01f, -4.43193376e-01f, 3.03004324e-01f,
  -3.92457470e-02f, 9.45250511e-01f, -2.84958094e-01f, -1.71598688e-01f, -5.25593936e-01f, -4.34053466e-02f, 5.95384598e-01f, -1.55448765e-01f, -4.82860178e-01f, -5.67876935e-01f,
  -1.29270107e-01f, 1.00322448e-01f, 6.57434225e-01f, -4.14599590e-02f, -7.26333737e-01f, -8.72645974e-01f, 1.22894116e-01f, 5.95963180e-01f, 2.48019755e-01f, -1.56066760e-01f,
  7.78727472e-01f, -3.15771133e-01f, -2.34841347e-01f, 5.46227060e-02f, -1.22107184e+00f, -4.51466382e-01f, -6.73517823e-01f, 5.06123900e-01f, 2.50997394e-01f, -2.09918693e-02f,
  -5.65038741e-01f, -3.48002702e-01f, 5.04174717e-02f, -5.95279038e-01f, 9.73667026e-01f, -3.84748161e-01f, 3.62575471e-01f, 1.05063677e+00f, 7.49123633e-01f, 1.09582651e+00f,
  1.32811224e+00f, -1.88956484e-01f, -1.09779441e+00f, -5.37198722e-01f, -8.01582038e-02f, -1.72033280e-01f, 5.03686547e-01f, -2.71738350e-01f, -2.06741795e-01f, -4.36515003e-01f,
  -7.56889224e-01f, -2.67034233e-01f, -7.20914066e-01f, 2.37094104e-01f, -8.50267857e-02f, -6.58467233e-01f, -4.06381637e-01f, 8.89495552e-01f, -4.22325939e-01f, 5.69622636e-01f,
  5.35242379e-01f, -8.16381201e-02f, -2.43925855e-01f, 6.29862130e-01f, 2.14176342e-01f, -1.17968000e-01f, 2.94597566e-01f, -1.05038166e-01f, -5.75663149e-01f, -4.40929264e-01f,
  -1.34128571e-01f, -9.07500327e-01f, 1.75726533e-01f, 3.38585228e-01f, 6.85986400e-01f, 2.54383143e-02f, -1.95720151e-01f, 2.66759545e-01f, 1.89270809e-01f, 8.84347916e-01f,
  4.62367415e-01f, -5.93289196e-01f, 2.76289403e-01f, 2.22463518e-01f, 8.13331425e-01f, 8.09459209e-01f, -3.94078583e-01f, 7.34614015e-01f, 1.10711980e+00f, -6.43621624e-01f,
  -8.34235609e-01f, 7.48460054e-01f, -6.33321524e-01f, -6.76311970e-01f, -7.39610732e-01f, -2.56699115e-01f, -1.77775010e-01f, -7.46161997e-01f, 9.04469848e-01f, -3.74166444e-02f,
  1.01155952e-01f, 5.07373251e-02f, -1.10016614e-01f, -4.35293704e-01f, -6.25739813e-01f, 1.60672352e-01f, 6.36817217e-01f, -4.68026876e-01f, 2.08972290e-01f, -5.48823252e-02f,
  8.40073287e-01f, 4.88067478e-01f, 3.79834563e-01f, 1.96310952e-01f, -4.70825195e-01f, -4.77619544e-02f, 7.90629625e-01f, 4.08172935e-01f, 3.26662123e-01f, 4.45554703e-02f,
  -1.56922549e-01f, -5.65165915e-02f, 6.35420009e-02f, 2.34861583e-01f, 1.16471887e+00f, -6.11759543e-01f, 2.51053602e-01f, -4.95656252e-01f, -5.67113124e-02f, 5.98018825e-01f,
  -9.59243298e-01f, -1.97944820e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.08285660e-01f, -1.73306167e-01f, 8.95779207e-02f, -4.19932723e-01f, -2.24358648e-01f, 2.62570143e-01f, 8.82920384e-01f, -3.04722667e-01f, -3.47247899e-01f, 5.56835532e-01f,
  -2.90113807e-01f, -9.45691913e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    