/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.27292591e-01f, 1.64621234e-01f, 9.49467644e-02f, -1.67735055e-01f, 8.01661015e-02f, -1.99246421e-01f, -7.21269399e-02f, 1.09689176e-01f, -8.06132182e-02f, 6.35194704e-02f,
  -1.31725490e-01f, -1.27589032e-01f, 8.37973058e-02f, -2.14785904e-01f, -2.89512634e-01f, -8.39068517e-02f, -2.55416214e-01f, -1.99365720e-01f, -8.08161721e-02f, -5.49395978e-02f,
  -3.68196480e-02f, -1.01174191e-01f, 1.48328274e-01f, 2.24766970e-01f, 4.16679643e-02f, 1.51087955e-01f, 1.79602876e-01f, 2.08917797e-01f, -9.87443142e-03f, 5.23928702e-02f,
  -8.45046118e-02f, 2.72423699e-02f, 9.39899608e-02f, 2.43837722e-02f, -2.01227516e-02f, -2.04946157e-02f, -7.01025948e-02f, 4.29239236e-02f, 3.84534188e-02f, 1.88458469e-02f,
  -9.90786403e-02f, 2.04313602e-02f, -2.56300159e-02f, -1.84146427e-02f, -2.61208862e-02f, 3.99935506e-02f, 9.74785164e-03f, 2.89930925e-02f, 3.74423414e-02f, 2.85320394e-02f,
  2.62302198e-02f, -7.92066529e-02f, -5.62094487e-02f, -6.70423582e-02f, -3.91211584e-02f, 5.05807437e-03f, 6.09694421e-03f, 5.83230294e-02f, 1.00702504e-02f, 4.66060452e-02f,
  -6.63709641e-02f, 1.10883042e-02f, 5.94977252e-02f, 2.35249233e-02f, -7.41768489e-03f, 4.68879342e-02f, -3.15119624e-02f, 9.94119700e-03f, -5.41408593e-03f, 1.22805219e-02f,
  -2.28328221e-02f, 4.63158563e-02f, -9.61351469e-02f, 1.60423089e-02f, 2.82212626e-02f, 3.33048962e-02f, -1.49472635e-02f, -8.02184492e-02f, 1.86047088e-02f, -1.47179114e-02f,
  6.22661151e-02f, -6.93039875e-03f, 2.42807399e-02f, -3.32164690e-02f, 3.05047613e-02f, 5.23310415e-02f, -1.08549360e-03f, 3.36050726e-02f, 3.18800360e-02f, -3.98466960e-02f,
  -6.07239343e-02f, 5.60700484e-02f, 7.85891861e-02f, -2.71334667e-02f, -3.28154303e-02f, 1.79400891e-02f, -8.45882762e-03f, -5.02260998e-02f, -1.81202888e-02f, 1.80542134e-02f,
  2.50139069e-02f, -8.44562054e-03f, -1.66414175e-02f, -6.37283474e-02f, 2.40884311e-02f, -2.34426185e-02f, -1.63934380e-02f, -3.21815424e-02f, -2.67011430e-02f, -8.25877488e-02f,
  -1.53370220e-02f, 1.64730009e-02f, -2.33396068e-02f, 6.78125024e-02f, -6.26321808e-02f, 1.66059490e-02f, -8.16850737e-02f, 3.63327451e-02f, -5.05711362e-02f, -3.43829058e-02f,
  9.79432929e-03f, 2.23031957e-02f, -2.19096035e-01f, -1.37673914e-02f, 1.97140902e-01f, 1.11513279e-01f, -2.38044970e-02f, 2.12690637e-01f, -1.04316026e-01f, 2.20093220e-01f,
  9.30991694e-02f, -5.60877547e-02f, -1.42854348e-01f, 5.37064448e-02f, -9.15424600e-02f, -2.24311888e-01f, 1.40047505e-01f, 3.00150122e-02f, -5.40375384e-03f, 2.16828853e-01f,
  -6.46050870e-02f, 2.22869247e-01f, -9.70356613e-02f, 1.72457799e-01f, 1.42867312e-01f, 4.86707985e-02f, 1.08374231e-01f, -1.09179512e-01f, 5.15693575e-02f, -9.74663999e-03f,
  1.55113712e-01f, 1.19134769e-01f, 2.50690822e-02f, -6.05408065e-02f, 1.09856322e-01f, -3.96111533e-02f, -3.60828564e-02f, -7.37902373e-02f, -1.40196225e-02f, 2.31873430e-02f,
  4.18189019e-02f, -3.43195349e-02f, 2.88899820e-02f, -2.94618160e-02f, 9.00012180e-02f, -2.10565468e-03f, -1.88623075e-04f, 8.36758688e-02f, -1.10091558e-02f, 4.18733098e-02f,
  -8.70760232e-02f, -2.90952083e-02f, -3.45453955e-02f, 4.85759601e-02f, -9.43230093e-02f, 1.28010204e-02f, -3.42692770e-02f, -4.34001051e-02f, 5.10356054e-02f, 6.61560819e-02f,
  5.09014959e-03f, 1.99759286e-02f, -2.11140998e-02f, 4.55122665e-02f, -7.07836775e-03f, 2.31684111e-02f, -2.46977974e-02f, 2.37985011e-02f, -3.41626666e-02f, 1.78472213e-02f,
  2.21800432e-03f, 1.59904454e-02f, -1.39300479e-02f, -2.70925695e-03f, -1.90029480e-03f, 3.23571935e-02f, -4.35488112e-02f, 1.43199833e-02f, -1.45495944e-02f, 3.01240738e-02f,
  -3.63656692e-02f, -9.01868101e-03f, 2.82160775e-03f, 1.39289657e-02f, 1.92356054e-02f, -3.67257111e-02f, 2.12547574e-02f, -4.21010815e-02f, 3.46578634e-03f, -2.59800982e-02f,
  1.53677627e-01f, 1.99094221e-01f, 6.07459135e-02f, 6.35573491e-02f, 7.42982700e-02f, 8.07551295e-02f, -3.40348529e-03f, -4.28706147e-02f, -4.34315950e-02f, 2.95014642e-02f,
  -2.48643272e-02f, 4.10239697e-02f, 1.01587211e-03f, 1.00157782e-03f, -2.52850167e-02f, 1.90999191e-02f, 2.85788607e-02f, -4.29659756e-03f, 1.25141919e-01f, 9.19492450e-03f,
  2.40462124e-02f, 5.37615754e-02f, -2.96544237e-03f, 7.25807175e-02f, 6.61884248e-02f, 9.64741409e-03f, 2.41247416e-02f, -3.55460085e-02f, 7.04444246e-04f, -5.94663359e-02f,
  2.13423222e-01f, -5.49617670e-02f, 2.07019016e-01f, -5.20474911e-02f, 7.13076219e-02f, -6.66280612e-02f, 4.79784328e-03f, -7.44821364e-03f, 2.84718633e-01f, -1.31283894e-01f,
  -1.29911199e-01f, 7.92599618e-02f, 1.24402694e-01f, -2.02152327e-01f, -5.75924106e-02f, 3.87585871e-02f, -1.69644818e-01f, -2.95509845e-02f, 1.16055951e-01f, -1.63223986e-02f,
  -2.58377977e-02f, -3.16370606e-01f, -1.24056689e-01f, -1.96346343e-01f, 1.87513307e-02f, 5.07062487e-02f, -1.02484800e-01f, 1.94612716e-03f, -2.44015247e-01f, -4.84493822e-02f,
  -9.39537063e-02f, 1.28082097e-01f, 2.37939674e-02f, 3.18214297e-02f, -1.02485018e-02f, -1.04936026e-01f, 2.71630995e-02f, -5.74091710e-02f, 5.15209138e-02f, 7.17443526e-02f,
  7.31431469e-02f, 6.85775876e-02f, -5.06445765e-02f, -3.67860869e-02f, 4.38770913e-02f, 7.45530054e-02f, 2.26479303e-02f, 4.78028283e-02f, 2.75840089e-02f, 3.63603570e-02f,
  8.91969278e-02f, -2.32087206e-02f, 2.11400446e-02f, 3.18783373e-02f, -2.54164413e-02f, 2.58438066e-02f, -4.75883670e-02f, 3.46307382e-02f, 4.35135234e-03f, 4.39177044e-02f,
  -7.18409345e-02f, -3.52371633e-02f, -1.01937847e-02f, 2.31610220e-02f, -5.29880002e-02f, -1.34452316e-03f, -1.10480720e-02f, -2.16052197e-02f, -3.24487616e-03f, -8.38962272e-02f,
  6.26560673e-02f, -3.78144197e-02f, -2.12218575e-02f, -7.84775428e-03f, -9.53380615e-02f, -2.57817898e-02f, -3.87378260e-02f, 2.70034950e-02f, 1.71634294e-02f, 3.56555358e-02f,
  -2.26475373e-02f, 1.92688815e-02f, 7.83276558e-03f, 3.15414034e-02f, -1.98719390e-02f, -5.34022646e-03f, -4.43859026e-02f, 2.21793167e-02f, -8.16578232e-03f, 2.92995386e-02f,
  -8.00671503e-02f, 2.27832776e-02f, 4.80374806e-02f, -9.11174193e-02f, 5.31497486e-02f, 3.07210311e-02f, 3.50126028e-02f, 1.31252734e-02f, 7.55818561e-03f, -2.57138927e-02f,
  -1.96654256e-02f, -9.81917307e-02f, 7.91971162e-02f, -4.79879156e-02f, 1.04286866e-02f, -5.52026613e-04f, -4.02100310e-02f, 2.70627625e-02f, -2.11658049e-02f, -3.80534045e-02f,
  -6.78326115e-02f, 1.43946577e-02f, 9.05005708e-02f, 5.11576571e-02f, -3.35475616e-02f, 1.72782931e-02f, 2.80839521e-02f, 7.00728446e-02f, -5.48490137e-02f, -4.00056988e-02f,
  8.30853283e-02f, -2.05657497e-01f, 1.38281181e-01f, -2.17616230e-01f, 2.53463574e-02f, -2.45112002e-01f, -2.68086463e-01f, -2.65744999e-02f, -2.10774601e-01f, -2.50786632e-01f,
  -2.56150682e-03f, -9.46206301e-02f, 3.46449837e-02f, -2.47978717e-01f, 1.39761224e-01f, -2.24932991e-02f, -1.64267465e-01f, -5.30413762e-02f, -5.65738268e-02f, 2.97359116e-02f,
  2.10404880e-02f, -1.70118868e-01f, 1.62542045e-01f, -6.23457730e-02f, 1.08712176e-02f, 2.96278503e-02f, 7.05239773e-02f, 9.04311910e-02f, -1.54127162e-02f, -3.07333414e-02f,
  1.11823089e-01f, 2.10401297e-01f, 6.89628050e-02f, 7.02508539e-02f, 1.77871026e-02f, -3.03259864e-02f, 7.75866285e-02f, 5.61362356e-02f, 5.24737276e-02f, -7.22419098e-02f,
  1.71653014e-02f, -3.13130282e-02f, -3.43288258e-02f, -7.49992803e-02f, -2.33057998e-02f, -7.59210065e-02f, 6.31184950e-02f, -3.58142331e-02f, -3.54254991e-02f, 8.07011649e-02f,
  -1.44464592e-03f, 7.12281466e-03f, 2.36000326e-02f, -8.00228938e-02f, 3.36183198e-02f, -8.09007362e-02f, -3.37443836e-02f, -7.65993074e-03f, -1.54417632e-02f, -6.91629499e-02f,
  -3.24242655e-03f, 1.13343885e-02f, -3.01321708e-02f, 3.72801088e-02f, 5.35841379e-03f, 8.86453316e-02f, -5.31825162e-02f, 5.51214330e-02f, 3.76776769e-03f, -4.41574678e-02f,
  -1.09532528e-01f, 7.16425851e-02f, -2.86937915e-02f, -1.01837339e-02f, 3.98111576e-03f, -4.62691374e-02f, 2.21211836e-02f, -1.52725689e-02f, -4.14576828e-02f, 2.47134324e-02f,
  -4.61597219e-02f, -5.86862341e-02f, 1.88809889e-03f, -8.89319461e-03f, -5.93018644e-02f, 3.17587052e-03f, -2.71693128e-03f, 1.06636975e-02f, -1.01171480e-02f, 8.13910142e-02f,
  -5.27584590e-02f, 3.46793197e-02f, 6.35174743e-04f, -1.85803026e-02f, -4.30933712e-03f, 1.23554310e-02f, 2.02984288e-02f, -3.45513262e-02f, -5.07403910e-03f, 6.80397218e-03f,
  -2.51497254e-02f, 2.82052886e-02f, 4.17322665e-02f, -3.89347225e-02f, -1.04364604e-01f, 3.61261368e-02f, -2.94051152e-02f, -4.66824360e-02f, 4.65960288e-03f, 1.32846842e-02f,
  -2.15690564e-02f, 5.32069914e-02f, 4.44493480e-02f, 1.37837138e-02f, 2.16483846e-02f, 3.24325785e-02f, 2.11317744e-02f, -4.11647074e-02f, 4.81359437e-02f, 6.03108609e-04f,
  6.17187381e-01f, 2.40598947e-01f, 2.76001394e-01f, 2.92862564e-01f, 1.02791712e-01f, 8.78465101e-02f, 1.81342021e-01f, 1.67423904e-01f, 2.18358785e-01f, -1.69971704e-01f,
  -1.33644454e-02f, 2.07728699e-01f, -1.23132475e-01f, 2.22847953e-01f, 2.40630642e-01f, -6.81238174e-02f, 2.17995346e-01f, 1.44399442e-02f, 7.03580603e-02f, 2.13858038e-01f,
  1.37597933e-01f, 7.52949044e-02f, 3.15379575e-02f, -5.85519634e-02f, 2.21375644e-01f, 6.36696666e-02f, -1.19456872e-01f, -6.54066131e-02f, 4.69505467e-05f, -2.47722473e-02f,
  6.94809034e-02f, 6.58866316e-02f, 1.52908145e-02f, -4.69462313e-02f, 3.04955766e-02f, 1.53049780e-03f, -1.13889575e-02f, -5.70704490e-02f, -2.65603065e-02f, -1.72089245e-02f,
  1.11687998e-03f, -3.02464161e-02f, -2.58802380e-02f, 1.57967098e-02f, 6.18993789e-02f, 4.06400971e-02f, 1.38391536e-02f, 7.28014186e-02f, -7.74566922e-03f, 5.26970550e-02f,
  6.97541311e-02f, 1.19845029e-02f, -2.34034393e-04f, -2.92708017e-02f, 3.89720052e-02f, 1.62682459e-02f, -5.22930846e-02f, -1.59784053e-02f, 2.16737315e-02f, 4.06132340e-02f,
  1.55625464e-02f, -1.67626273e-02f, 1.30659323e-02f, -1.51966391e-02f, 4.87558171e-02f, -6.65653870e-02f, -1.97099335e-03f, -2.61468086e-02f, 4.18684483e-02f, 5.23643792e-02f,
  -8.65859259e-03f, 4.56065759e-02f, 4.43868153e-02f, 2.78272550e-03f, 3.37046497e-02f, -1.72754861e-02f, -2.81071905e-02f, 2.19279937e-02f, 5.18178158e-02f, 4.44093393e-03f,
  -4.68738750e-02f, 1.96262654e-02f, -2.61825901e-02f, -1.68855395e-02f, -2.87864357e-02f, 2.86757741e-02f, -1.09685184e-02f, 4.25477959e-02f, -2.48038843e-02f, -4.29460360e-03f,
  -5.32086641e-02f, 1.48013815e-01f, -9.05827153e-03f, 1.26980599e-02f, -4.40855920e-02f, -2.05145441e-02f, 2.76700705e-02f, 5.95087260e-02f, 5.97262830e-02f, 5.85979670e-02f,
  -1.97368935e-02f, 1.85112786e-02f, 3.24481912e-02f, -6.25549033e-02f, -7.57758021e-02f, 2.03408003e-02f, 5.02875671e-02f, -7.17021152e-02f, 4.51165251e-02f, 2.44744867e-02f,
  -1.63436010e-02f, -5.22154011e-02f, 3.85800712e-02f, -1.54012069e-02f, -5.38298823e-02f, -6.79215565e-02f, 7.60003328e-02f, -1.79561097e-02f, -4.03566398e-02f, 6.68719877e-03f,
  1.16043888e-01f, 1.17780454e-01f, 1.51231885e-02f, -1.34122133e-01f, -1.82273060e-01f, -3.37680101e-01f, -2.07802385e-01f, -1.52734607e-01f, -1.24123767e-01f, 6.36090040e-02f,
  -1.63539052e-01f, 1.48128539e-01f, 1.02081664e-01f, -3.02371770e-01f, -3.34362298e-01f, -9.11818072e-02f, -1.98974699e-01f, -1.14184991e-01f, -1.69619359e-02f, 3.90362889e-02f,
  -2.53423769e-02f, -1.33965865e-01f, -1.19710051e-01f, 2.37255208e-02f, 4.55117449e-02f, 1.35537446e-01f, 2.21168511e-02f, 6.31154105e-02f, 4.67246427e-04f, -6.88133314e-02f,
  1.40771523e-01f, 1.50466219e-01f, 4.27840604e-03f, -1.69243719e-02f, 6.19194172e-02f, 6.04133047e-02f, 1.58088151e-02f, 6.52946392e-03f, 1.84844621e-02f, -1.12682804e-01f,
  5.10042161e-02f, 3.93652134e-02f, -2.91443169e-02f, -9.76164546e-03f, 2.76230033e-02f, -8.07279721e-03f, -8.07628036e-03f, -1.54775595e-02f, 2.30439976e-02f, -2.31538005e-02f,
  -5.24181174e-03f, -1.60929244e-02f, -3.05980910e-02f, 3.99460830e-02f, -4.07819711e-02f, 2.30063149e-03f, 3.47263515e-02f, -1.02196736e-02f, -5.99209070e-02f, -1.05712876e-01f,
  3.78892645e-02f, 9.02205706e-02f, 4.89791557e-02f, 1.12759713e-02f, 2.04801019e-02f, 7.70901069e-02f, 9.07692709e-04f, 2.22633835e-02f, 7.96471536e-02f, 1.70527492e-02f,
  -3.77137284e-03f, -1.10706436e-02f, 1.29985446e-02f, 1.35477062e-03f, -1.22462129e-02f, 3.68348919e-02f, 8.61072075e-03f, 1.11858230e-02f, -7.93595426e-03f, -3.81565727e-02f,
  2.19173171e-02f, -1.97351221e-02f, 3.40811051e-02f, 5.35270944e-03f, 5.15927095e-03f, -3.52873318e-02f, -2.04598252e-02f, -1.54867535e-02f, -6.55714015e-04f, -1.46318413e-02f,
  5.56578040e-02f, 1.55181497e-01f, -8.08802322e-02f, -2.97058932e-02f, -2.01314688e-02f, -4.83981296e-02f, -1.45526323e-02f, -4.87392358e-02f, 8.13079700e-02f, 2.86424235e-02f,
  1.90644637e-02f, -9.75185353e-03f, 8.00082535e-02f, -7.27227097e-03f, -4.59467620e-02f, -4.82853465e-02f, 4.84585166e-02f, -1.50007075e-02f, 2.60144891e-03f, 7.35498592e-02f,
  6.29801974e-02f, 2.17698724e-03f, -1.18301827e-02f, 5.19641489e-02f, -4.12015170e-02f, 6.38005557e-03f, 3.43384780e-02f, 6.66734530e-03f, -1.20595060e-02f, 6.92795846e-04f,
  8.45855549e-02f, 2.03666389e-01f, -8.38159695e-02f, -1.40449945e-02f, -1.47682294e-01f, 7.98405260e-02f, 5.23506030e-02f, -3.74774225e-02f, -2.45842934e-01f, 8.46644640e-02f,
  7.61274993e-02f, 7.37494901e-02f, -5.13593992e-03f, 1.52965695e-01f, -1.30223855e-01f, -1.16466135e-01f, 4.34231609e-02f, 1.49506748e-01f, -1.60196617e-01f, 2.23088078e-02f,
  -7.79055059e-02f, 1.11796431e-01f, 1.05824888e-01f, 4.11733203e-02f, 1.16140157e-01f, 7.80405253e-02f, 5.86279146e-02f, -6.06555641e-02f, 2.54780531e-01f, -6.24113576e-03f,
  -2.63741668e-02f, -7.73409009e-02f, 1.50173143e-01f, -1.52575364e-02f, 4.97155963e-03f, 1.57648064e-02f, 1.21148247e-02f, 2.61442941e-02f, -2.00643018e-02f, -5.62175177e-02f,
  -2.79426426e-02f, 3.30173410e-02f, 6.98291659e-02f, -5.49622104e-02f, 2.01128442e-02f, 2.07751375e-02f, -3.04077901e-02f, 2.91144717e-02f, 1.12140775e-02f, 3.65160815e-02f,
  1.94857698e-02f, -1.78785827e-02f, 6.01307601e-02f, 1.46830101e-02f, -7.94942752e-02f, -1.45745953e-03f, -1.71401650e-02f, -2.78452244e-02f, -2.72309990e-04f, 3.57479118e-02f,
  5.35470173e-02f, 6.25926033e-02f, 4.59775142e-03f, 5.83780818e-02f, -6.48309197e-03f, -8.03824794e-03f, 4.91505861e-02f, -1.42416824e-02f, -2.38125082e-02f, 3.60999554e-02f,
  8.54172260e-02f, 1.71674397e-02f, 4.56546284e-02f, 4.39674817e-02f, -2.63072904e-02f, 5.66337407e-02f, -5.79718547e-03f, -3.85518782e-02f, -3.27340961e-02f, -7.12654460e-03f,
  -6.66982308e-02f, -4.43187915e-02f, 1.08132372e-04f, -1.52088664e-02f, -7.29465485e-02f, 2.94558872e-02f, 4.49591503e-02f, 2.90899239e-02f, -2.64935885e-02f, 8.80907774e-02f,
  -3.78790824e-03f, 3.00961919e-02f, -1.93395913e-02f, -5.21849981e-03f, -3.85724852e-04f, 4.32183594e-02f, 1.39172710e-02f, -1.19571518e-02f, -3.23122591e-02f, -1.35737900e-02f,
  4.12109755e-02f, -2.69043725e-02f, -1.45911667e-02f, -6.26867777e-03f, -4.30846438e-02f, 1.34990228e-06f, 2.44073644e-02f, -4.67449725e-02f, 7.60741904e-02f, 2.70290468e-02f,
  3.86059135e-02f, -6.16968377e-03f, -7.08520487e-02f, 4.93643209e-02f, 9.89310145e-02f, 1.30734639e-02f, -4.71181087e-02f, 5.42233437e-02f, -3.12046334e-02f, -1.28174191e-02f,
  2.12604508e-01f, 1.29196718e-02f, 1.09461732e-01f, 1.31142959e-01f, -3.29535119e-02f, -2.00474277e-01f, -2.02897653e-01f, 2.16467734e-02f, 2.28599459e-01f, -1.42372698e-01f,
  -9.92022976e-02f, 2.60156125e-01f, -1.13900907e-01f, -2.10995510e-01f, -7.78038725e-02f, -1.78267136e-01f, -1.63124606e-01f, 1.13115441e-02f, 1.37762278e-01f, 2.45997310e-02f,
  5.96009791e-02f, -2.90940851e-01f, -1.07839033e-01f, -8.97590443e-02f, 2.80878674e-02f, 1.41109750e-01f, -1.14326172e-01f, -3.16254944e-02f, -7.09466562e-02f, -9.64396894e-02f,
  -1.26917481e-01f, 7.24439621e-02f, -5.19186119e-03f, 3.53375487e-02f, -1.43882018e-02f, -1.64686758e-02f, -1.83247160e-02f, -6.81225061e-02f, 2.00593509e-02f, 4.28259186e-02f,
  3.98452282e-02f, -5.86097986e-02f, 1.56606361e-02f, 1.74869541e-02f, 4.75285873e-02f, 2.59239338e-02f, 1.73328388e-02f, -2.27940083e-02f, 1.12319112e-01f, -1.89708211e-02f,
  7.95287341e-02f, 4.19759518e-03f, -2.75258068e-03f, -9.85426083e-02f, 9.21470970e-02f, -6.07443601e-02f, -7.87615106e-02f, -6.16240464e-02f, -2.14285944e-02f, 3.31878029e-02f,
  -5.76159917e-02f, -3.89311723e-02f, -6.53145015e-02f, -6.44113123e-02f, -3.05755846e-02f, -4.98263761e-02f, 2.09230911e-02f, -1.90114621e-02f, 3.28389779e-02f, -4.35821563e-02f,
  -3.69548015e-02f, -4.38282825e-03f, 1.67625677e-02f, 2.32204907e-02f, -1.32371858e-02f, 1.24677829e-02f, -1.50716361e-02f, -6.14612587e-02f, 1.27449511e-02f, 7.65605494e-02f,
  2.97225546e-02f, -4.33679111e-02f, 4.43466613e-03f, -2.98900455e-02f, -5.96334636e-02f, 2.74193883e-02f, 2.38703135e-02f, 1.91883929e-02f, 3.75058949e-02f, -9.35021136e-03f,
  9.88283381e-03f, -1.13622703e-01f, 3.89464907e-02f, -3.80023420e-02f, -2.07265490e-03f, -8.69931467e-03f, -7.75566548e-02f, 9.36771743e-03f, 6.19775662e-03f, -7.64997080e-02f,
  -4.65861149e-02f, 1.23903221e-02f, -4.70770635e-02f, -2.08866037e-02f, -6.84183612e-02f, -5.12623054e-04f, 1.92876961e-02f, -1.35406675e-02f, -9.15329978e-02f, 1.42849302e-02f,
  -1.89662892e-02f, 6.04096334e-03f, -1.19174020e-02f, 5.72177768e-02f, -3.30386423e-02f, -2.38134488e-02f, 8.27253237e-02f, 5.58404736e-02f, 3.01482733e-02f, -4.05608118e-02f,
  -3.60984147e-01f, -1.05968468e-01f, -1.46498799e-01f, -3.31094600e-02f, 1.38345703e-01f, -6.78298771e-02f, -1.13906503e-01f, 1.11211583e-01f, 1.26722202e-01f, 7.39405677e-02f,
  6.40855730e-02f, -2.20223680e-01f, -2.07264964e-02f, 6.81460872e-02f, -1.08338460e-01f, 1.59950703e-01f, 7.61276390e-03f, -2.00761724e-02f, 1.24246836e-01f, -6.74176216e-02f,
  7.97161087e-02f, 1.61607936e-01f, -7.75950626e-02f, 1.56624913e-01f, -6.64580464e-02f, -3.02624423e-02f, 6.67239577e-02f, -4.60806079e-02f, -3.35335843e-02f, -2.87733190e-02f,
  -8.35950226e-02f, 5.16078137e-02f, -6.91184923e-02f, -4.76657189e-02f, -1.06490791e-01f, -3.19436155e-02f, -6.27120882e-02f, -5.00236861e-02f, -4.61665280e-02f, -2.26955153e-02f,
  -8.74624997e-02f, -2.88630724e-02f, -1.02011468e-02f, 8.22989792e-02f, 2.96656862e-02f, 3.37806083e-02f, 3.63417491e-02f, -7.50183268e-03f, 3.52363698e-02f, -3.24605411e-04f,
  -1.17759779e-02f, -2.54621319e-02f, -1.50294704e-02f, 3.87648456e-02f, 2.51007490e-02f, 2.02239752e-02f, -1.96210351e-02f, 8.46499897e-05f, 1.64104737e-02f, 3.24406363e-02f,
  4.29995768e-02f, -6.48892000e-02f, 4.41952758e-02f, -5.28376512e-02f, 3.12194750e-02f, 2.71614734e-02f, -1.98791698e-02f, 2.73653567e-02f, -3.28140594e-02f, 1.70032922e-02f,
  1.20424991e-03f, 1.23210615e-02f, 4.89360243e-02f, 1.52657898e-02f, 1.30913174e-02f, -1.65539905e-02f, -1.59457978e-03f, 3.96654308e-02f, -1.91008504e-02f, 3.70040275e-02f,
  4.48982418e-02f, -3.31412181e-02f, 5.24522886e-02f, -2.50737071e-02f, -5.51800290e-03f, 4.90600662e-03f, 4.62266095e-02f, 2.41767149e-02f, -6.30257502e-02f, -1.66702084e-02f,
  -1.01569161e-01f, 4.18130979e-02f, 3.65499780e-02f, -1.47411246e-02f, 3.69352335e-03f, 6.75856881e-03f, -2.16556527e-02f, 4.09593135e-02f, -1.89774986e-02f, -2.71153115e-02f,
  1.30800102e-02f, 2.99648475e-02f, -3.21549289e-02f, -2.19623130e-02f, -6.64758831e-02f, 7.00310245e-02f, -4.20528315e-02f, -6.24100342e-02f, -8.55014771e-02f, -3.98536325e-02f,
  -2.71507073e-03f, 4.14134488e-02f, 4.64035049e-02f, 5.75936995e-02f, -3.85622610e-03f, 1.85646266e-02f, -1.08042024e-02f, -7.90066645e-02f, 3.02660633e-02f, 8.51278100e-03f,
  8.60335678e-02f, 3.53780985e-01f, -8.72135982e-02f, 1.38913110e-01f, -1.82578966e-01f, -9.18531492e-02f, -7.28152320e-02f, 6.11231141e-02f, 6.20536618e-02f, 3.23290437e-01f,
  1.94709282e-02f, 1.33508295e-01f, 5.61614055e-03f, 1.17186747e-01f, -4.48947966e-01f, -3.55464332e-02f, 4.19803821e-02f, 1.63580507e-01f, -8.56014639e-02f, 1.56376064e-02f,
  -7.32855722e-02f, 5.26290275e-02f, -1.63881332e-01f, -1.00707844e-01f, -2.86037065e-02f, 2.39203703e-02f, -1.09496817e-01f, -8.15152451e-02f, 4.33123931e-02f, -1.34895235e-01f,
  -1.62000712e-02f, 1.51951909e-01f, -4.17042635e-02f, 2.75933575e-02f, -1.48876868e-02f, -8.70278291e-03f, -8.31488892e-02f, -1.04270577e-01f, -4.63662632e-02f, 2.08842773e-02f,
  -5.80867380e-03f, -1.48774087e-01f, 8.20176750e-02f, -1.63813941e-02f, -1.42732663e-02f, -5.17881326e-02f, -5.25844172e-02f, -9.63862333e-03f, -1.98311880e-02f, -9.27065536e-02f,
  1.12150442e-02f, 3.97828035e-02f, 3.88369672e-02f, -6.70638159e-02f, -8.88432786e-02f, 3.91131500e-03f, -1.09459169e-03f, -2.15424336e-02f, 7.59902177e-03f, -1.97908878e-02f,
  -4.23793793e-02f, -3.46483067e-02f, 3.54100540e-02f, -5.53203449e-02f, 6.39517903e-02f, -1.55996615e-02f, -5.92919067e-02f, -3.59521061e-02f, 6.24592276e-03f, -3.13171670e-02f,
  2.28535198e-02f, 4.30155583e-02f, -4.94984500e-02f, -2.91599352e-02f, -9.23680980e-03f, 1.92533117e-02f, -4.14875038e-02f, 2.49765962e-02f, -1.88467242e-02f, -2.45776754e-02f,
  -5.02838679e-02f, -2.78575509e-03f, 1.93635765e-02f, -5.17112799e-02f, -2.31608227e-02f, -6.58008605e-02f, -3.57478601e-03f, 4.57992814e-02f, -5.33540100e-02f, -8.16596001e-02f,
  4.73383181e-02f, 1.41609579e-01f, 7.08988756e-02f, -2.25414336e-02f, 5.65278009e-02f, 4.80577126e-02f, -2.53965706e-02f, 4.65687774e-02f, 2.57739332e-02f, -3.19634601e-02f,
  -7.49656698e-03f, 3.76681909e-02f, 1.97189897e-02f, -4.68061231e-02f, -2.61041578e-02f, 4.19227965e-02f, 1.93035649e-03f, 2.05152552e-03f, -3.42011899e-02f, 4.05024588e-02f,
  -5.23404703e-02f, -1.79815125e-02f, -4.43522818e-02f, 3.81314568e-02f, -2.51139291e-02f, -2.23177802e-02f, 7.44133890e-02f, -3.14579830e-02f, -4.14632522e-02f, 3.55079654e-03f,
  2.34772816e-01f, -2.95269370e-01f, -6.67643324e-02f, 1.63896561e-01f, 2.29717791e-01f, 1.37275746e-02f, -2.16442607e-02f, 6.66650757e-02f, 1.05521372e-02f, -1.46743566e-01f,
  5.85858114e-02f, 3.52249965e-02f, -1.67877436e-01f, 9.17655006e-02f, 1.29126504e-01f, -3.54995459e-01f, 3.87025960e-02f, -2.15549413e-02f, -4.62337099e-02f, 9.62797627e-02f,
  1.43434957e-01f, 1.57929957e-01f, -6.44502416e-02f, 5.43939248e-02f, 1.57399580e-01f, 5.85753024e-02f, 2.24640101e-01f, -5.22637069e-02f, 1.57235965e-01f, 3.21637131e-02f,
  2.97651597e-04f, -1.32063165e-01f, -4.62141521e-02f, -3.35457898e-03f, 3.58918235e-02f, 2.78159920e-02f, 1.51698561e-02f, 1.85456872e-02f, 6.99943453e-02f, -4.38737087e-02f,
  -4.54152413e-02f, 2.94174231e-03f, -1.66700105e-03f, 1.21908141e-02f, 5.50012141e-02f, 3.56217218e-03f, 3.05537358e-02f, 2.73532085e-02f, 1.84641778e-02f, -4.39931862e-02f,
  -5.29360548e-02f, -4.28772392e-03f, 5.67747951e-02f, -7.61262104e-02f, -8.15434847e-03f, 1.39645822e-02f, -5.54534309e-02f, -3.84814367e-02f, -1.02152685e-02f, 5.52017167e-02f,
  1.14924936e-02f, -1.25322202e-02f, -3.06624994e-02f, 1.79837234e-02f, 2.24448764e-03f, 1.73981246e-02f, 5.55844754e-02f, -9.59263928e-03f, 3.03213391e-02f, -6.81086793e-04f,
  3.99267003e-02f, 6.46784976e-02f, 1.33925891e-02f, 1.42616015e-02f, 2.84983758e-02f, -1.30517865e-02f, 5.41328937e-02f, -3.17341909e-02f, 2.89932620e-02f, -1.36442306e-02f,
  -2.58814055e-03f, 1.93498507e-02f, -2.01087650e-02f, 1.97272468e-02f, -4.00034077e-02f, 3.63982841e-03f, 8.63563735e-03f, -2.00142544e-02f, 3.39321159e-02f, 1.33564547e-02f,
  -1.26692140e-02f, 4.19363715e-02f, -2.51842998e-02f, -6.40416518e-02f, -1.91909168e-02f, 8.33970830e-02f, -3.93769406e-02f, 3.40956748e-02f, -4.93870080e-02f, 8.58400688e-02f,
  6.66814893e-02f, 9.28077661e-03f, 6.84175342e-02f, 2.71389019e-02f, -1.90843195e-02f, -2.65837591e-02f, 4.11608145e-02f, 2.87164710e-02f, 6.21117130e-02f, -1.87701848e-03f,
  3.26210223e-02f, 1.72816366e-02f, -3.77828144e-02f, 8.73124748e-02f, 6.76382929e-02f, -2.21483987e-02f, 2.79861130e-02f, -4.54413034e-02f, 3.12891863e-02f, -6.06784970e-02f,
  2.74126649e-01f, -3.87485921e-01f, -8.28776062e-02f, 1.26159281e-01f, 2.15725124e-01f, 9.15873200e-02f, 1.89847395e-01f, -6.85150689e-03f, 6.63300380e-02f, -2.95096070e-01f,
  7.92603120e-02f, 7.88713172e-02f, -8.34884420e-02f, 2.33236216e-02f, 2.95083225e-01f, -1.03823334e-01f, -2.88795959e-02f, -1.74442269e-02f, -4.19337526e-02f, -6.11358956e-02f,
  7.74158910e-02f, 1.64222196e-01f, 5.89061826e-02f, -9.78426263e-02f, 9.16224718e-02f, -8.59340802e-02f, -5.12659661e-02f, 4.29199729e-03f, -4.05205367e-03f, 1.20700330e-01f,
  -1.72259565e-02f, 5.66567630e-02f, 1.07512355e-01f, -2.93015186e-02f, -4.83437395e-03f, -1.97472833e-02f, -3.64634804e-02f, -1.27231497e-02f, 4.81427871e-02f, 2.43402608e-02f,
  -1.40076298e-02f, 1.08846202e-02f, 8.27805996e-02f, 3.75258513e-02f, -1.78492498e-02f, 3.34774740e-02f, -2.07664110e-02f, -4.64754738e-02f, 3.21135372e-02f, 4.81796078e-03f,
  1.79917384e-02f, -7.87992999e-02f, -1.85624901e-02f, -6.77800179e-02f, -6.91329613e-02f, 7.46902823e-03f, -7.93968444e-04f, 1.68708749e-02f, -3.94261926e-02f, 5.43015860e-02f,
  -4.46926020e-02f, 1.59610398e-02f, -1.35648623e-02f, -9.73706320e-03f, 3.62497531e-02f, 9.10219774e-02f, -1.91972498e-02f, -2.72591449e-02f, -3.89040671e-02f, -4.26317267e-02f,
  2.34981962e-02f, 3.34824398e-02f, -3.33650745e-02f, -2.92541534e-02f, -1.66575285e-03f, 2.38722586e-03f, 1.06052672e-02f, 2.18329113e-02f, -3.13322544e-02f, 3.82267945e-02f,
  1.29999500e-02f, -8.92298110e-03f, 6.32195361e-03f, -2.40389127e-02f, 3.18024531e-02f, 6.28500953e-02f, -5.37670404e-02f, 6.68786583e-04f, -9.81750991e-03f, 3.23483236e-02f,
  -2.88683295e-01f, -2.46302396e-01f, 8.94971099e-03f, -1.18665854e-02f, -6.43303618e-02f, -1.27328843e-01f, -6.59453571e-02f, -4.22558235e-03f, -7.85226822e-02f, -1.94570851e-02f,
  -5.60635664e-02f, -5.63695421e-03f, -1.06804803e-01f, -5.25983088e-02f, -4.06146385e-02f, -7.44717270e-02f, 3.48660909e-02f, -4.42455672e-02f, -2.32239235e-02f, -4.58664335e-02f,
  -9.53904837e-02f, 4.77381377e-03f, 2.13174075e-02f, 4.08301950e-02f, -1.32122515e-02f, 3.48176882e-02f, -2.28593145e-02f, -2.40282365e-03f, -9.07842536e-03f, -4.83776368e-02f,
  -1.99851826e-01f, -4.55402629e-03f, -1.53090041e-02f, -3.85749549e-01f, -8.72579366e-02f, 2.57742465e-01f, 1.27312467e-01f, -1.89220518e-01f, -1.53926745e-01f, 1.01612985e-01f,
  1.54477870e-02f, 7.01896176e-02f, 2.65797496e-01f, -1.07271753e-01f, 2.82109022e-01f, 2.30169088e-01f, -5.44568114e-02f, 6.28596246e-02f, 2.70481445e-02f, -1.31142139e-01f,
  -6.99675828e-02f, -1.33094937e-01f, 6.34042621e-02f, -1.40379488e-01f, -1.79563329e-01f, -1.74143195e-01f, -3.38008348e-03f, 1.87410992e-02f, -1.63579121e-01f, 4.89673577e-02f,
  4.82942499e-02f, -1.20424218e-01f, -1.06827542e-01f, -2.52023782e-03f, -7.18744053e-03f, 1.51307397e-02f, 1.89933702e-02f, 1.24499261e-01f, -2.46027466e-02f, -5.35302535e-02f,
  -9.01561696e-03f, 2.03107744e-02f, -9.21120644e-02f, 2.91689374e-02f, -3.63929644e-02f, -6.81300685e-02f, -6.20761700e-02f, 2.68714316e-02f, -4.39711101e-02f, -7.45149627e-02f,
  -6.17673667e-03f, -3.25490497e-02f, -1.19605280e-01f, -2.07375083e-02f, -4.89692353e-02f, -3.37823965e-02f, -4.56508510e-02f, 7.09769726e-02f, -6.08896418e-03f, -6.48064772e-03f,
  1.04659051e-02f, 1.85847636e-02f, 5.50088286e-02f, -7.54656969e-03f, 6.69535324e-02f, -6.44095689e-02f, 1.07476665e-02f, 5.95938414e-02f, 1.31645435e-02f, -2.46222247e-03f,
  4.43544192e-03f, -3.99770476e-02f, -1.61135383e-02f, 3.63842361e-02f, -3.91629385e-03f, -5.32976165e-02f, 2.94580832e-02f, -2.32142527e-02f, -3.09790820e-02f, -3.83194834e-02f,
  -3.05598928e-03f, 1.15093747e-02f, 3.44898626e-02f, 3.92312631e-02f, 6.52935356e-02f, 2.94504743e-02f, 5.68570383e-03f, -1.47197079e-02f, 3.66748497e-02f, 9.83834267e-03f,
  1.44414991e-01f, -9.91182774e-02f, 4.48578894e-02f, -3.39093767e-02f, 4.17381413e-02f, -2.22348273e-02f, 3.81858721e-02f, -2.10229568e-02f, 9.20034051e-02f, 5.18983565e-02f,
  4.89343219e-02f, -2.79579032e-02f, 4.02137563e-02f, -2.11519655e-03f, -9.67376772e-03f, 5.19819446e-02f, 4.50394899e-02f, 3.73265818e-02f, -4.28956114e-02f, 1.41987102e-02f,
  -7.87718687e-03f, 5.26998267e-02f, 3.47353965e-02f, -1.05253654e-02f, -5.03704995e-02f, -1.13315717e-03f, -5.71652427e-02f, -3.79774645e-02f, 5.53230830e-02f, 2.46421285e-02f,
  6.43465817e-01f, -1.18505247e-01f, 2.55616265e-03f, 2.32310221e-01f, 8.30411687e-02f, -5.06694894e-03f, 9.38147083e-02f, 8.50227997e-02f, 2.56568044e-01f, -4.72334698e-02f,
  -3.56227309e-02f, 1.05379876e-02f, -1.52655184e-01f, -2.88639944e-02f, 1.92498490e-01f, -9.89027843e-02f, 9.66106206e-02f, 4.27375026e-02f, -1.69880036e-02f, 1.23393886e-01f,
  1.14959665e-01f, -1.31006166e-01f, -1.04581803e-01f, -1.69557422e-01f, 8.24472383e-02f, -2.64059044e-02f, -1.29650116e-01f, -9.45644602e-02f, -8.40243399e-02f, -1.17029175e-01f,
  1.02410153e-01f, 2.03568086e-01f, 5.33566512e-02f, 2.24281531e-02f, 4.62249182e-02f, -2.77446937e-02f, 9.64750443e-03f, -4.95029390e-02f, -4.49835472e-02f, 2.27997079e-02f,
  -4.58807014e-02f, 3.76689509e-02f, 3.74224000e-02f, -1.63233560e-02f, 7.06699044e-02f, -1.07649881e-02f, -2.69760657e-02f, -6.11700974e-02f, -4.36558761e-02f, 3.69500904e-03f,
  -3.36258486e-02f, -1.70144737e-02f, 4.54367958e-02f, -2.40687337e-02f, 4.49395776e-02f, -3.15137021e-03f, -7.87879515e-04f, -3.05800010e-02f, 4.65951227e-02f, 9.05083865e-02f,
  3.43571603e-02f, 1.67487301e-02f, 3.94933252e-03f, -3.05603892e-02f, 1.31627228e-02f, 1.33958813e-02f, -1.14898849e-02f, -9.40021407e-03f, 1.11586051e-02f, 1.45153394e-02f,
  5.20155914e-02f, 4.10798006e-02f, 2.38420372e-03f, 1.33685779e-03f, -7.19442545e-03f, 6.18019626e-02f, 6.86418638e-03f, 1.59621667e-02f, 5.17666750e-02f, 8.59456882e-03f,
  -2.57158503e-02f, -6.68704335e-04f, -3.20859589e-02f, -2.99577359e-02f, 1.00366632e-02f, -3.85128856e-02f, 2.74819089e-03f, 2.55848709e-02f, -1.75794009e-02f, 3.57856113e-03f,
  1.38366476e-01f, 2.12883741e-01f, -4.79474738e-02f, 4.81623039e-02f, 7.29181524e-03f, 5.68167977e-02f, -9.59068071e-03f, 3.69927660e-03f, 2.13552937e-02f, 1.05199451e-02f,
  5.15119843e-02f, 5.43645918e-02f, -9.84060485e-03f, 5.57455756e-02f, -2.02785432e-02f, 5.93033805e-02f, -1.68672279e-02f, 6.01981394e-02f, -9.83559806e-03f, -2.30610967e-02f,
  5.48144244e-02f, 4.47937734e-02f, -2.22236216e-02f, -4.15607616e-02f, -5.48840314e-02f, -7.11562624e-03f, 3.67215835e-02f, 2.86036264e-02f, -2.16825940e-02f, -7.80493300e-03f,
  4.97665964e-02f, -9.87097621e-02f, -1.23425126e-01f, 1.32278591e-01f, 1.23871729e-01f, -3.08633029e-01f, -2.44656369e-01f, 1.00610219e-01f, 4.79061715e-02f, -3.76406386e-02f,
  -1.29043311e-02f, -1.64217263e-01f, -2.00144604e-01f, -1.40256286e-01f, -3.22276652e-01f, -2.44687274e-01f, -1.55296654e-01f, -9.10065398e-02f, 1.01516182e-02f, 1.43139539e-02f,
  4.49255481e-02f, 1.04071954e-02f, -6.38360903e-02f, 1.48265496e-01f, 5.73874339e-02f, 1.91423163e-01f, 1.39392212e-01f, -2.79362518e-02f, 1.00885846e-01f, -5.77445608e-03f,
  -1.64038315e-01f, 3.67901325e-02f, 3.54218706e-02f, -2.43176278e-02f, 4.10800204e-02f, 8.58488157e-02f, -3.86997834e-02f, -5.30149862e-02f, -1.42267095e-02f, -1.52694900e-02f,
  -6.58996403e-02f, 8.32712557e-03f, -9.30115674e-03f, -1.52619733e-02f, -1.06695679e-03f, 7.44412541e-02f, -2.19046660e-02f, -4.47346717e-02f, 2.34609805e-02f, -7.30795339e-02f,
  -3.45500112e-02f, 1.87794808e-02f, -2.89582703e-02f, -2.82560624e-02f, -2.60970239e-02f, -5.42936400e-02f, -6.06009960e-02f, -2.96428986e-03f, 5.79165854e-02f, 1.89915057e-02f,
  -1.23564154e-02f, -7.83748087e-03f, 2.29513533e-02f, 2.40769368e-02f, -6.52367324e-02f, 2.37768255e-02f, -3.75761576e-02f, 3.44821364e-02f, -1.34463226e-02f, -5.68129048e-02f,
  7.22070178e-03f, -2.29573902e-02f, 4.88927364e-02f, -1.27548175e-02f, -1.48562454e-02f, 9.93744954e-02f, -5.26220761e-02f, -1.66162907e-03f, -2.01214775e-02f, 1.63188111e-02f,
  6.35887124e-03f, -1.95399188e-02f, 1.36494553e-02f, 4.52625826e-02f, -3.21375881e-03f, -9.69466753e-03f, 1.43607787e-03f, -4.87245731e-02f, -2.07718685e-02f, -1.68005135e-02f,
  -1.06375195e-01f, -2.21330840e-02f, 1.61840126e-03f, 4.51636538e-02f, -2.88140196e-02f, -3.53703126e-02f, -2.34689098e-02f, 1.24391802e-02f, -5.04165180e-02f, -7.29346722e-02f,
  4.99328971e-02f, 6.93128332e-02f, -3.82253639e-02f, 9.42264218e-03f, 3.09219602e-02f, -8.10393319e-02f, 1.48030650e-02f, 6.01360910e-02f, 4.74173762e-02f, 9.18065608e-02f,
  1.77130979e-02f, -1.61027107e-02f, 7.36627802e-02f, 1.56300403e-02f, 5.42181507e-02f, -1.34735154e-02f, 5.94319291e-02f, -1.87221970e-02f, -3.72697152e-02f, 4.12222557e-03f,
  -8.07629451e-02f, 3.72300819e-02f, -8.94870982e-02f, -1.13477036e-01f, -1.82404771e-01f, 1.21634498e-01f, 2.38034293e-01f, -1.32635534e-01f, -7.67430142e-02f, 1.71073556e-01f,
  1.36924982e-01f, 1.90032888e-02f, 9.60396305e-02f, -1.55696757e-02f, -1.32165909e-01f, 1.38102761e-02f, -5.49996495e-02f, 1.21546350e-01f, -1.64521396e-01f, 6.38203419e-05f,
  -1.42367348e-01f, -7.29304701e-02f, -1.95374086e-01f, -9.31344628e-02f, -4.51258644e-02f, -7.78311938e-02f, -7.38726482e-02f, 5.59905693e-02f, 3.08277141e-02f, -1.20168954e-01f,
  3.39128003e-02f, 1.01601280e-01f, 1.43656377e-02f, -1.03277210e-02f, -5.01363240e-02f, 1.73145402e-02f, 8.63343775e-02f, -4.23114374e-02f, -2.33045351e-02f, 6.43165410e-02f,
  8.57555792e-02f, 2.54547354e-02f, 2.31845342e-02f, 2.91635487e-02f, -4.63257581e-02f, -4.44893129e-02f, -2.61176452e-02f, -3.62955220e-02f, 4.51993383e-02f, -1.04295891e-02f,
  2.11809669e-02f, 3.04520745e-02f, 1.15410984e-02f, 1.88405048e-02f, -9.33547914e-02f, -4.13115211e-02f, 4.21078429e-02f, -4.15887609e-02f, 5.86845987e-02f, -7.72479400e-02f,
  8.68562907e-02f, -3.24275084e-02f, -5.46924360e-02f, -2.48741992e-02f, -2.81717218e-02f, -3.09181213e-03f, -2.37449445e-02f, 6.66839182e-02f, 5.99947060e-03f, -1.27724772e-02f,
  2.91066766e-02f, -3.11241560e-02f, -2.47307792e-02f, 5.34422062e-02f, 1.23239849e-02f, 6.31920993e-02f, -1.38168484e-02f, 2.47826357e-03f, 1.85343288e-02f, -1.33554116e-02f,
  5.37617654e-02f, -4.92013805e-02f, -2.37446092e-02f, 2.82240640e-02f, -5.29011637e-02f, 4.20948826e-02f, 3.62083018e-02f, 1.41123887e-02f, -8.90535116e-03f, -1.08797401e-02f,
  -1.64197683e-02f, 1.06366463e-01f, 3.13175842e-02f, -3.10042733e-03f, 2.75002196e-02f, -5.39461970e-02f, 2.05791998e-03f, -4.47794236e-02f, -2.67916154e-02f, 4.40778956e-03f,
  1.92939416e-02f, -2.87150349e-02f, -2.83532012e-02f, -8.24451968e-02f, 2.95630563e-02f, -1.31856315e-02f, 8.22848082e-02f, -1.18501987e-02f, -7.26453820e-03f, 4.08467613e-02f,
  9.84056015e-03f, 7.68176764e-02f, 2.08453950e-03f, -6.03058934e-02f, 4.64066863e-02f, 9.31058377e-02f, -3.67220901e-02f, 4.73731235e-02f, 3.58849764e-02f, 7.67199323e-03f,
  2.32311592e-01f, -2.54574597e-01f, -9.00947824e-02f, 1.86014175e-01f, 4.28360589e-02f, 1.14583671e-01f, 2.00416282e-01f, -1.15409493e-01f, 2.38213520e-02f, 9.05741937e-03f,
  -1.05467357e-03f, -1.01491764e-01f, -1.89927667e-01f, 2.54680794e-02f, 1.74803361e-01f, -2.04166193e-02f, 1.86604977e-01f, 4.24437225e-02f, 1.25708962e-02f, -2.21950375e-02f,
  1.16679944e-01f, -3.87855712e-03f, -1.12813272e-01f, -1.17204428e-01f, 6.28398135e-02f, -1.45748734e-01f, -3.93213779e-02f, -1.90812245e-01f, -2.57607047e-02f, 7.43422564e-03f,
  1.06049888e-02f, -9.30703282e-02f, -9.41224098e-02f, 8.81950278e-03f, -3.66079062e-02f, 1.05082907e-01f, -4.37990054e-02f, 3.84535752e-02f, 1.69362258e-02f, 3.91415060e-02f,
  2.15227138e-02f, 4.73296456e-02f, 5.07202335e-02f, -4.32056710e-02f, 6.12833165e-02f, 4.28007822e-03f, -2.16555279e-02f, -4.90588248e-02f, -8.29501636e-03f, -7.61152655e-02f,
  -6.76084012e-02f, 2.86054071e-02f, 1.39070125e-02f, 1.99484061e-02f, -3.68147306e-02f, -1.47674950e-02f, 7.01870173e-02f, 1.23317251e-02f, 3.28326933e-02f, 4.70489636e-02f,
  5.00914780e-03f, 3.71684991e-02f, 3.35692056e-02f, -3.44167240e-02f, 1.60950964e-04f, -5.86268492e-02f, -4.30458374e-02f, 7.19835316e-06f, 6.94146976e-02f, -1.36509528e-02f,
  -3.58219701e-03f, 4.66173887e-02f, -5.71871623e-02f, 3.69917676e-02f, -1.65959727e-02f, 3.63004170e-02f, -5.84374294e-02f, -3.20977643e-02f, 2.01749662e-03f, 4.76058275e-02f,
  -2.55021788e-02f, 3.51827662e-03f, -6.21280633e-02f, -1.43238073e-02f, -2.36045029e-02f, 8.41703452e-03f, 4.39781733e-02f, -4.72954754e-03f, -1.28469318e-02f, 5.31353354e-02f,
  1.40630649e-02f, -9.63117331e-02f, 8.88842437e-03f, 6.77575730e-03f, 1.45225879e-02f, -5.05981483e-02f, 3.57919596e-02f, -5.74461259e-02f, 6.83494508e-02f, -5.14990240e-02f,
  4.55252007e-02f, -3.71068045e-02f, 7.51999486e-03f, 6.16403557e-02f, 5.57285137e-02f, 3.82745117e-02f, -6.47852719e-02f, -5.46661206e-03f, 3.12085059e-02f, -1.44203473e-02f,
  -5.13055325e-02f, 3.57346497e-02f, 1.26736490e-02f, 2.96367072e-02f, 1.94882993e-02f, 7.87303895e-02f, -3.59406439e-03f, -1.91013241e-04f, 6.69374540e-02f, -3.61262169e-03f,
  -1.39413858e-02f, -5.05325943e-02f, 1.91753954e-01f, -1.04727089e-01f, 1.68740496e-01f, 6.80472180e-02f, 2.46752277e-01f, -5.92045970e-02f, 2.30935961e-01f, -2.84596086e-01f,
  -1.06121808e-01f, 2.07662284e-02f, -4.09067981e-03f, -2.21814349e-01f, 2.66806409e-02f, -1.03046730e-01f, -1.72511443e-01f, -1.61081254e-02f, 1.13057047e-01f, -5.88480523e-03f,
  -4.64673080e-02f, -2.92049319e-01f, -1.86514314e-02f, -1.88560471e-01f, -5.57770170e-02f, 3.94145958e-02f, -2.59765357e-01f, 1.02059595e-01f, -1.24270238e-01f, -1.19141219e-02f,
  8.99862275e-02f, 1.17549270e-01f, -3.11116339e-03f, -3.96389551e-02f, -1.84874795e-02f, 7.66262934e-02f, 7.59592222e-04f, 1.03062123e-01f, 1.09185696e-01f, 3.94296795e-02f,
  -5.28906137e-02f, -4.70619164e-02f, -3.72653082e-02f, 7.02042058e-02f, 4.36111800e-02f, 2.22481862e-02f, -1.17899328e-02f, 4.42896672e-02f, -1.58528276e-02f, 6.36689141e-02f,
  3.19486775e-04f, 2.18188693e-03f, 1.57596525e-02f, -4.31998037e-02f, -2.13608593e-02f, 4.75182608e-02f, 7.54361376e-02f, 2.10446585e-02f, -1.62183121e-02f, 5.75815737e-02f,
  2.43715644e-02f, 7.55234882e-02f, -1.79982726e-02f, -1.54635916e-02f, -4.17649038e-02f, -3.25862807e-03f, -4.60346155e-02f, 1.50580425e-02f, 4.49464843e-02f, -2.86133252e-02f,
  -9.18226391e-02f, 1.91405751e-02f, 3.96147417e-03f, 7.46105388e-02f, -4.93548363e-02f, 2.79949922e-02f, -2.24846080e-02f, -6.06535040e-02f, -1.05483301e-01f, -3.22807841e-02f,
  1.64710189e-04f, 4.08623461e-03f, -8.18777364e-03f, -1.03519857e-02f, 6.42747432e-03f, 1.21147316e-02f, -9.91236866e-02f, 4.87293489e-02f, 6.47735223e-02f, 7.11061759e-03f,
  -8.89688432e-02f, -5.80278784e-02f, 2.58314703e-02f, 6.31025508e-02f, 2.04747096e-02f, -2.42909081e-02f, 2.95265242e-02f, -7.34071806e-02f, 1.35865733e-02f, 1.41586782e-02f,
  -5.84151968e-03f, 7.73239881e-02f, 2.44611651e-02f, -1.44340647e-02f, 2.13512983e-02f, -2.38854941e-02f, 3.28300893e-02f, -3.61643173e-02f, -4.04577889e-02f, -8.28801244e-02f,
  -4.42457534e-02f, 7.65792206e-02f, -1.86147522e-02f, -2.15660762e-02f, 7.15129450e-03f, -3.37644108e-02f, 6.91018766e-03f, 9.08036367e-04f, 1.02541717e-02f, -7.51777366e-02f,
  -1.37545913e-01f, 4.00216132e-01f, 1.45011872e-01f, 1.96298510e-01f, -1.51773050e-01f, -7.52714798e-02f, 4.77399305e-02f, 6.99546114e-02f, 1.60449296e-01f, 1.31261542e-01f,
  -1.49989007e-02f, 2.33403981e-01f, 1.85266495e-01f, 1.04595542e-01f, -2.94380039e-01f, 1.33758157e-01f, -2.99986880e-02f, 1.04347274e-01f, 8.95891115e-02f, 7.77267665e-03f,
  1.71439424e-02f, 4.92514595e-02f, 7.16828927e-02f, 6.20025843e-02f, 1.09066926e-02f, 6.77921399e-02f, -2.09242433e-01f, 7.76464716e-02f, -1.25110790e-01f, -5.29165082e-02f,
  -4.85727601e-02f, 5.89946657e-02f, 8.68285298e-02f, 4.24117669e-02f, -8.31184350e-03f, -7.54729360e-02f, -2.70939413e-02f, 7.23497127e-04f, -9.62313265e-03f, -1.79767795e-02f,
  4.01505567e-02f, -5.10547776e-03f, 2.52835453e-02f, 7.07425922e-02f, 2.62772068e-02f, -2.91487053e-02f, -1.92818430e-03f, -6.28824532e-02f, 7.71056637e-02f, 3.61101367e-02f,
  4.20879833e-02f, -5.75661175e-02f, -3.53690274e-02f, 2.83652451e-02f, -3.25831920e-02f, -4.98402752e-02f, -1.31458752e-02f, -1.72662013e-03f, -3.97854820e-02f, 4.82455231e-02f,
  -1.85105298e-02f, 3.55209410e-02f, 5.75226732e-03f, 3.57049517e-02f, 4.75056209e-02f, 4.10682801e-03f, 1.28997359e-02f, -4.68917042e-02f, 2.08619349e-02f, 1.76657289e-02f,
  -1.54205263e-02f, 2.84568989e-03f, 3.48500870e-02f, -3.11249625e-02f, -1.97408032e-02f, 4.66897301e-02f, -9.36279772e-04f, -3.56985070e-02f, 4.43086959e-02f, -3.45660299e-02f,
  7.78786168e-02f, -2.22161952e-02f, 6.93760291e-02f, -5.58360340e-03f, -7.88569916e-03f, -2.65699904e-02f, -3.20296176e-02f, 5.56022897e-02f, -1.31292911e-02f, -9.51142330e-03f,
  1.42372465e-02f, 9.57699567e-02f, 2.06980538e-02f, -2.91191991e-02f, -1.55492388e-02f, -2.71301046e-02f, 3.35007720e-02f, 6.45561749e-03f, 6.24572225e-02f, 1.33829862e-02f,
  -7.73373395e-02f, -9.91564989e-03f, -7.16998428e-03f, -3.95311527e-02f, -7.13651180e-02f, -3.64099890e-02f, 3.85122746e-02f, 1.88282561e-02f, -3.21766622e-02f, -8.46416950e-02f,
  -2.03907471e-02f, -2.37055980e-02f, -4.00796765e-03f, -2.46891677e-02f, -1.10031208e-02f, -4.44751531e-02f, -1.53665226e-02f, -3.09475008e-02f, -4.89832349e-02f, -3.80997732e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.09330200e-02f, -2.69537866e-02f, -5.06600402e-02f, -2.59540439e-01f, 4.43327241e-02f, -9.69194621e-02f, -1.17052466e-01f, -1.07121952e-04f, 3.82803194e-03f, 1.39916083e-02f,
  -1.16607442e-01f, -8.89125094e-03f, 1.99126884e-01f, -1.32088989e-01f, 5.25098890e-02f, 1.22332618e-01f, -2.12483883e-01f, -3.66996974e-02f, 7.69881066e-04f, -1.64130777e-01f,
  -1.73122510e-02f, -8.88800770e-02f, 3.42004225e-02f, -5.42874634e-02f, -2.01079771e-01f, -3.75333354e-02f, -8.34122151e-02f, -9.69353423e-04f, -1.98923156e-01f, 9.25085917e-02f,
  -1.28859013e-01f, -1.73077822e-01f, -9.10706446e-02f, -8.92635435e-04f, -1.41637996e-01f, -8.36204290e-02f, -1.02665499e-01f, -3.53280716e-02f, 3.11714206e-02f, 7.26695508e-02f,
  2.58844197e-02f, -4.42441031e-02f, -1.49801783e-02f, 1.00124329e-01f, 3.15480717e-02f, 2.28595790e-02f, 5.98600134e-02f, -2.92791594e-02f, 7.34662113e-04f, -5.08697592e-02f,
  6.36696965e-02f, -2.71275416e-02f, -1.02921249e-02f, 6.38564825e-02f, 6.37619272e-02f, -3.14632095e-02f, 3.03805177e-03f, -3.79239731e-02f, -6.26683906e-02f, 7.19011575e-02f,
  -1.65103208e-02f, 3.41278687e-02f, -6.08044863e-03f, -1.20300492e-02f, -7.48114660e-02f, 5.56435287e-02f, 5.21150567e-02f, -9.55154970e-02f, 2.54535042e-02f, 4.72814627e-02f,
  1.66359097e-02f, -4.44760406e-03f, 6.50683865e-02f, 8.89420416e-03f, 2.13486608e-02f, -7.69260898e-02f, 2.50886455e-02f, -6.47505522e-02f, 5.79859391e-02f, 5.53136133e-02f,
  -1.12028606e-01f, 4.71044332e-03f, -3.19578266e-03f, 4.85267788e-02f, -1.51795419e-02f, -7.99931493e-03f, -8.79042875e-03f, -7.73748010e-02f, 1.57977547e-02f, 2.11561155e-02f,
  -1.30838111e-01f, -1.95299402e-01f, -5.27958907e-02f, -4.19365093e-02f, 2.58721784e-03f, 1.89594664e-02f, -4.77182753e-02f, -1.05830751e-01f, -1.05394341e-01f, -3.14090997e-02f,
  -9.62255150e-03f, -7.34060183e-02f, -1.95065122e-02f, -2.87885219e-02f, -2.46330500e-02f, 3.44750285e-02f, -7.66152740e-02f, -9.05969962e-02f, -1.07307792e-01f, 5.64916581e-02f,
  -5.82709983e-02f, 3.81701775e-02f, 6.30777329e-02f, -3.51577476e-02f, -1.29602522e-01f, -9.42302570e-02f, 3.61070633e-02f, 5.69026470e-02f, -1.24314530e-02f, 7.48611167e-02f,
  1.17815845e-01f, 9.87039134e-02f, -1.13450354e-02f, 2.72032082e-01f, -2.20467329e-01f, -2.83625543e-01f, -2.25370824e-01f, 6.54078797e-02f, -1.72294363e-01f, -1.60479352e-01f,
  9.31671932e-02f, 4.33764048e-02f, 1.43105090e-01f, 1.44697413e-01f, 2.45442122e-01f, 1.39810875e-01f, 1.82079360e-01f, 2.74806004e-03f, 8.26801639e-03f, 2.04303458e-01f,
  2.48268738e-01f, 1.81953177e-01f, 3.54753286e-01f, 3.98209617e-02f, 1.37023749e-02f, 1.86383232e-01f, 3.55643809e-01f, 9.34327543e-02f, 1.92595661e-01f, 1.61806159e-02f,
  -9.48607996e-02f, 1.09262317e-01f, -1.11838861e-04f, -8.08545873e-02f, 8.11330229e-02f, -4.49616760e-02f, -6.05648160e-02f, -8.77501070e-02f, 2.88506337e-02f, 8.72362927e-02f,
  -7.84799457e-02f, 6.84558302e-02f, 2.46718042e-02f, -5.06722974e-03f, 8.16889945e-03f, 2.57391613e-02f, -3.99936736e-02f, -2.75361575e-02f, -7.12019056e-02f, 9.81934741e-02f,
  -5.33348620e-02f, -7.16845691e-03f, -4.37873416e-02f, 2.91408673e-02f, -3.62390019e-02f, 1.16837593e-02f, -4.89692856e-03f, 9.77522723e-05f, -7.16038346e-02f, -3.85877863e-02f,
  9.58398208e-02f, -4.13171165e-02f, 3.66006531e-02f, -2.27164421e-02f, -8.42674542e-03f, 2.03536302e-02f, -7.10446062e-03f, 5.32907359e-02f, 3.19700427e-02f, -3.87946405e-02f,
  2.54743639e-02f, -3.26636285e-02f, -7.53874052e-03f, -6.73119575e-02f, 6.58372268e-02f, 3.55907269e-02f, -8.08717459e-02f, 4.15231064e-02f, -2.97598653e-02f, -1.41212838e-02f,
  -2.58365758e-02f, 9.46232453e-02f, 4.00505960e-02f, 6.10562274e-03f, -5.75702973e-02f, 2.25278232e-02f, 9.76526812e-02f, -7.87349418e-03f, 3.21474089e-03f, -1.57308783e-02f,
  7.44399056e-02f, 3.10912549e-01f, -2.29625702e-02f, -2.58274190e-02f, 2.61297077e-02f, -6.12987429e-02f, -8.00802186e-03f, 2.23701727e-02f, 1.27005801e-01f, -4.36499203e-03f,
  3.75787020e-02f, -1.07468724e-01f, 4.48618410e-03f, -3.33952494e-02f, -7.14762136e-02f, 2.00282391e-02f, 4.00239453e-02f, 1.28185386e-02f, 4.59104730e-03f, 1.33398622e-01f,
  3.41917202e-02f, -4.33220230e-02f, -3.64876762e-02f, -9.10375565e-02f, 4.93180007e-02f, -2.36559249e-02f, -1.59547273e-02f, 1.30906524e-02f, 8.70217085e-02f, -2.08144505e-02f,
  -2.21819624e-01f, 1.17817707e-01f, -2.30898619e-01f, -1.85077980e-01f, 5.49025089e-03f, -7.02290237e-02f, -1.49712473e-01f, 8.57085288e-02f, -1.63259953e-01f, 1.56777084e-01f,
  1.32207721e-01f, -2.00236067e-01f, 1.61249921e-01f, -2.07606703e-01f, -1.98926002e-01f, -4.03030068e-02f, -2.53253132e-01f, -1.75690249e-01f, 3.34542915e-02f, -9.05969832e-03f,
  -2.16532171e-01f, 4.01439443e-02f, -7.60668144e-02f, 9.94210914e-02f, -1.75269619e-02f, -5.43252751e-02f, 5.65944910e-02f, 1.11009061e-01f, -8.66429210e-02f, 2.84711272e-02f,
  8.41048583e-02f, -5.01025617e-02f, -8.73790458e-02f, -3.46021913e-02f, -5.17152920e-02f, 2.97551211e-02f, 4.45423983e-02f, -5.57276718e-02f, 1.85579583e-02f, -6.36817589e-02f,
  6.78225514e-03f, -4.85094711e-02f, -7.66108138e-03f, 5.90792112e-02f, -7.68806264e-02f, -3.07861622e-03f, -7.18194023e-02f, 2.29988564e-02f, 3.71447243e-02f, -5.11462539e-02f,
  -6.56438693e-02f, -8.32402781e-02f, -6.22494593e-02f, -9.93172526e-02f, -9.69493538e-02f, 7.98512995e-02f, -7.98670948e-02f, -4.94599566e-02f, 2.74094138e-02f, -1.79260857e-02f,
  -3.27787455e-03f, 5.54246828e-02f, -1.15007944e-02f, 7.36518577e-02f, -1.41400164e-02f, 7.64263570e-02f, 4.03649323e-02f, -6.95637465e-02f, -5.10285087e-02f, 4.74635512e-02f,
  -4.75202762e-02f, -4.22941707e-02f, 2.43761577e-02f, -3.25010307e-02f, -9.25723538e-02f, -1.53684011e-02f, -1.91409439e-02f, -2.19320618e-02f, 2.11287793e-02f, 5.52464016e-02f,
  -6.22006804e-02f, -2.45041084e-02f, -2.69984882e-02f, 4.12858091e-02f, 1.67825557e-02f, -2.99992599e-02f, -8.16089734e-02f, 2.78512333e-02f, -1.60342138e-02f, 4.92082117e-03f,
  1.94909945e-02f, -7.65162557e-02f, 7.12320507e-02f, 7.84074143e-03f, 7.56678656e-02f, -8.26460049e-02f, 4.16420177e-02f, -2.18653376e-03f, 1.15686636e-02f, 9.85385384e-03f,
  -4.37187627e-02f, -7.23960251e-02f, -5.82732484e-02f, -5.08958586e-02f, 2.62647197e-02f, -5.15803099e-02f, 1.41393840e-02f, 6.26625493e-02f, 3.94970886e-02f, 6.44030645e-02f,
  3.08061559e-02f, -5.76106757e-02f, -1.94550231e-02f, -6.84635639e-02f, -3.33228931e-02f, 4.85502817e-02f, 2.08186843e-02f, 3.90727110e-02f, -4.85150144e-02f, 2.18757354e-02f,
  3.03351760e-01f, -2.67801523e-01f, -1.15401745e-01f, -8.23007748e-02f, 1.99103169e-02f, -2.99483985e-02f, -2.04844843e-03f, -1.87768653e-01f, -1.15688421e-01f, -1.85311645e-01f,
  -7.93451965e-02f, 1.93761569e-02f, 6.51651397e-02f, -1.27010778e-01f, 2.57925957e-01f, -2.43861992e-02f, -4.48135622e-02f, 5.27505763e-02f, -1.09342873e-01f, -1.34699672e-01f,
  -7.57991225e-02f, -2.40491591e-02f, -4.29984787e-03f, -6.48954809e-02f, -1.42655998e-01f, -5.76249287e-02f, 1.14004835e-01f, 4.66103479e-02f, -9.01515707e-02f, 1.32091597e-01f,
  -1.57341640e-02f, -6.37130961e-02f, 4.28273641e-02f, -2.78708171e-02f, -6.94470201e-03f, 8.65549296e-02f, 2.56774183e-02f, 1.75257385e-01f, -2.29131449e-02f, -8.03805068e-02f,
  -1.42894937e-02f, -8.37336108e-03f, 5.58073111e-02f, 3.32344137e-03f, -4.52280231e-02f, -4.22343723e-02f, -5.10291532e-02f, -5.16160019e-02f, -2.87037902e-02f, 5.51138213e-03f,
  -6.01076595e-02f, -2.46851444e-02f, -8.29266906e-02f, -8.80393311e-02f, 2.67472938e-02f, -3.57289724e-02f, -1.15789901e-02f, 4.03823555e-02f, -1.01234938e-03f, -3.46530080e-02f,
  3.48845720e-02f, 8.90020803e-02f, 7.04566017e-02f, -2.26230118e-02f, -1.84210055e-02f, 5.37671447e-02f, -1.14927283e-02f, -8.40130597e-02f, -7.69980298e-03f, 2.46160850e-02f,
  -4.56685051e-02f, -1.03402987e-01f, 1.74067747e-02f, 7.06756860e-03f, 6.22656308e-02f, 7.31177330e-02f, 6.03468642e-02f, 5.95566258e-02f, 5.74125610e-02f, 1.68654555e-03f,
  9.79012921e-02f, 1.10924877e-02f, 3.10555696e-02f, -6.03651665e-02f, -2.60981228e-02f, -5.38425520e-03f, -1.49445990e-02f, -6.06229044e-02f, -6.30149618e-02f, 4.92914654e-02f,
  -6.10944219e-02f, 6.52744342e-03f, -7.00607570e-03f, -4.00601737e-02f, 1.79054923e-02f, 8.63802880e-02f, 1.83403604e-02f, -7.72368982e-02f, -1.85563217e-03f, -1.57066230e-02f,
  5.47565380e-03f, 5.96161783e-02f, -4.39165309e-02f, -2.74153277e-02f, -1.80180240e-02f, -4.05065864e-02f, -5.33232139e-03f, -2.93017514e-02f, 2.25845929e-02f, -7.34674931e-02f,
  -9.04790405e-03f, 2.78298780e-02f, 6.55142441e-02f, -2.83364970e-02f, -5.05047292e-02f, 2.11922405e-03f, 6.50650114e-02f, -6.54127970e-02f, -4.92798351e-02f, -1.85009763e-02f,
  8.78408328e-02f, -1.59573108e-01f, -6.85905740e-02f, -9.29598417e-03f, -7.67234936e-02f, 4.98753637e-02f, 3.60425860e-02f, -1.19778447e-01f, -2.61341959e-01f, 8.59934464e-02f,
  4.76735830e-02f, 3.86431441e-02f, 7.47786835e-02f, 8.34458843e-02f, 2.58560423e-02f, 1.20955305e-02f, 6.96300492e-02f, 1.53773472e-01f, -7.51445219e-02f, 5.24015874e-02f,
  4.65034284e-02f, -1.42754670e-02f, 3.44557092e-02f, -7.17635453e-02f, 2.80847419e-02f, 6.06323481e-02f, 3.19148675e-02f, 8.42524227e-03f, 1.38400301e-01f, 1.05915897e-01f,
  -3.76157686e-02f, -3.07000782e-02f, -1.80763230e-02f, -2.60109250e-02f, -4.31344174e-02f, 2.44259145e-02f, 1.41585141e-01f, 9.73585844e-02f, -3.73653881e-02f, 3.77097465e-02f,
  -6.95154294e-02f, -1.79376900e-02f, -1.02797918e-01f, 4.24698330e-02f, -7.19883516e-02f, -4.45417911e-02f, -8.66460502e-02f, 3.28758024e-02f, 2.96276156e-03f, -5.05689392e-03f,
  2.98679061e-02f, -1.47380438e-02f, 4.49951738e-02f, 6.72584921e-02f, -2.82236468e-02f, -6.16039969e-02f, 4.17351387e-02f, -1.75618250e-02f, -4.27536778e-02f, 4.24999185e-02f,
  -4.15220186e-02f, 5.55834696e-02f, -5.27695455e-02f, -1.85806304e-02f, 6.24375269e-02f, -4.01464850e-02f, 5.48696294e-02f, 1.50165400e-02f, 5.73745109e-02f, 5.89449070e-02f,
  -9.93553549e-02f, -2.82265730e-02f, 3.18593495e-02f, -5.62711768e-02f, -1.79036660e-03f, 2.85684061e-03f, 1.27477869e-02f, 6.52638897e-02f, -2.75957379e-02f, 2.03251783e-02f,
  -6.05970286e-02f, 1.11310054e-02f, 4.38538715e-02f, 2.07671504e-02f, -8.36022198e-02f, -7.98683986e-02f, 5.91785610e-02f, 8.05286467e-02f, -4.89730388e-02f, -5.00699244e-02f,
  1.95121244e-02f, -1.21572979e-01f, 4.26528528e-02f, 6.84957672e-03f, -2.87190024e-02f, 6.75326362e-02f, 1.35327298e-02f, -9.39060226e-02f, -3.22227888e-02f, 6.65666955e-03f,
  -1.79417953e-02f, -4.11608443e-02f, -7.65512586e-02f, -5.72594777e-02f, -9.90465581e-02f, -2.28609461e-02f, 1.35278776e-02f, 8.18401948e-03f, 2.74002310e-02f, 1.15202535e-02f,
  -4.16046530e-02f, -1.69868857e-04f, 1.47069050e-02f, 4.13748547e-02f, -5.17028309e-02f, 1.01397723e-01f, 2.64311600e-02f, 5.39892688e-02f, 1.45613933e-02f, -6.80996031e-02f,
  1.03218025e-02f, 4.30555604e-02f, -1.75423119e-02f, -5.54459281e-02f, -2.54930928e-02f, -1.32038083e-03f, -1.23111576e-01f, 4.13918664e-04f, -1.48706973e-01f, 6.30528256e-02f,
  6.04416709e-04f, -1.03197344e-01f, -3.45650353e-02f, -1.84263214e-01f, -2.32267708e-01f, -1.50927231e-01f, -8.19348842e-02f, -1.08398981e-01f, -1.33370355e-01f, 4.70873713e-02f,
  -9.85616893e-02f, -7.63012171e-02f, -1.56560317e-01f, 8.83413702e-02f, 1.27331272e-01f, 1.46756664e-01f, 2.03188673e-01f, 7.30439350e-02f, 4.73044142e-02f, 5.67990690e-02f,
  -4.08248939e-02f, -6.27039522e-02f, 3.73154879e-02f, -5.70122525e-02f, 2.05517709e-02f, 1.69173852e-01f, 9.63200852e-02f, -1.28691867e-02f, -8.14998150e-02f, 2.52573136e-02f,
  3.73719782e-02f, -8.58440697e-02f, -8.34685862e-02f, -7.87966549e-02f, -4.31468971e-02f, -7.21039549e-02f, -1.02312285e-02f, 3.61102670e-02f, 3.72087099e-02f, 3.93550508e-02f,
  8.95558670e-03f, -2.49960017e-03f, 8.95942748e-02f, 8.22457150e-02f, -1.37104793e-02f, -4.31327475e-03f, 2.30576620e-02f, 4.02006656e-02f, 4.86884788e-02f, 1.39757544e-02f,
  1.04216821e-02f, 1.09577596e-01f, 4.80747558e-02f, 2.78939353e-03f, 3.13096084e-02f, -4.64955568e-02f, -5.29549606e-02f, -4.57521044e-02f, 6.27551833e-03f, 5.35744131e-02f,
  8.78186226e-02f, -9.25289690e-02f, -8.57271552e-02f, 7.89254010e-02f, -6.31167069e-02f, -4.72810119e-02f, -5.84374964e-02f, -5.79183251e-02f, -5.51258884e-02f, 1.43811200e-02f,
  1.82923563e-02f, -2.95684282e-02f, -5.63980527e-02f, 6.89315870e-02f, -1.39658367e-02f, -2.43119132e-02f, 8.37446675e-02f, -3.87821011e-02f, -2.94130063e-03f, 1.50786350e-02f,
  1.64609440e-02f, 2.06787229e-01f, 1.03632705e-02f, -3.78569998e-02f, 9.00705624e-03f, 9.41452011e-02f, -4.89791222e-02f, -8.16566125e-03f, 6.00777529e-02f, -3.13949212e-02f,
  1.59470126e-01f, 4.06448245e-02f, 5.31637929e-02f, 6.02449626e-02f, -3.65793593e-02f, 2.93107554e-02f, 1.18449315e-01f, 2.34693326e-02f, -3.76986759e-03f, -1.54820969e-02f,
  1.37709484e-01f, 7.08448514e-02f, 5.10337390e-02f, 2.49703303e-02f, 5.47230653e-02f, 1.49033656e-02f, 2.24896856e-02f, 6.53611822e-03f, 5.91979846e-02f, 6.29710332e-02f,
  -8.16751420e-02f, -1.07133776e-01f, -4.08528857e-02f, -9.60110873e-02f, 7.51081929e-02f, -2.52905581e-02f, 7.87170976e-02f, 2.99527626e-02f, -3.99348550e-02f, -1.18995365e-02f,
  2.59425342e-02f, -8.72292742e-02f, -2.89576128e-02f, -3.71616520e-02f, 6.23266213e-02f, -7.39888176e-02f, -5.10154013e-03f, -6.69744536e-02f, -7.01705441e-02f, -1.28496915e-01f,
  -5.18152118e-02f, -5.87503687e-02f, -4.50075651e-03f, -2.68493369e-02f, -4.77999151e-02f, 2.44300142e-02f, 1.43341525e-02f, 1.05942693e-02f, -3.87479726e-04f, -5.87549284e-02f,
  -6.16940074e-02f, -6.02611862e-02f, 4.92823906e-02f, 2.45258100e-02f, 5.29934727e-02f, -4.03902940e-02f, -1.06408834e-01f, 8.43968987e-02f, 4.14539240e-02f, 7.70374984e-02f,
  3.43701392e-02f, 1.78279215e-03f, -5.72119392e-02f, 8.58941227e-02f, -3.73614579e-02f, 7.88790509e-02f, 4.03214954e-02f, -8.22868645e-02f, -9.18010995e-02f, 5.91834597e-02f,
  -5.07989489e-02f, -2.73528472e-02f, -1.86948851e-02f, 5.82337752e-02f, -6.11601472e-02f, -2.23688241e-02f, 3.24639194e-02f, 6.14869855e-02f, -2.00170986e-02f, -8.03050250e-02f,
  -3.59018818e-02f, 6.83031185e-03f, 2.65698265e-02f, -1.91740133e-02f, 7.28683993e-02f, -1.51032032e-02f, -1.92187726e-02f, 3.94339636e-02f, 9.01764855e-02f, -2.35741120e-02f,
  -7.45554417e-02f, -1.11222826e-02f, 5.31941131e-02f, 6.99103028e-02f, -4.91582975e-02f, 3.97374108e-02f, 1.98399299e-03f, 2.22967621e-02f, -8.18034783e-02f, 5.05965166e-02f,
  8.08458626e-02f, 4.46848013e-02f, 2.49925498e-02f, 3.49137783e-02f, -8.96712169e-02f, 1.63906179e-02f, 7.78815076e-02f, -1.13322204e-02f, -5.03471643e-02f, -4.77678031e-02f,
  2.59436052e-02f, -6.43815994e-02f, -6.61576837e-02f, -4.30426076e-02f, 6.93002939e-02f, -4.96111698e-02f, -3.97130363e-02f, 5.71609251e-02f, -6.04253635e-02f, -5.62462360e-02f,
  -3.62035520e-02f, -6.47587776e-02f, 8.51322245e-03f, 6.16904022e-03f, 8.91894102e-03f, 4.96034101e-02f, -4.51822802e-02f, -1.30088665e-02f, 8.45324919e-02f, -1.50145628e-02f,
  7.29437470e-02f, -7.73632750e-02f, 7.30033293e-02f, 6.42075017e-02f, -2.81943269e-02f, -5.69618866e-02f, -3.69471125e-02f, 4.18691151e-02f, -5.54613248e-02f, 4.84680086e-02f,
  -1.80687092e-03f, 4.23633903e-02f, -1.65117174e-01f, -1.18232191e-01f, 2.23925686e-03f, -2.01254904e-01f, -9.57663953e-02f, 4.10115644e-02f, -1.76965855e-02f, -3.92874479e-02f,
  -3.50237153e-02f, 6.65177032e-02f, 7.50116259e-02f, -3.48618478e-02f, -2.84730047e-02f, 8.13030079e-02f, -1.22308441e-01f, -1.46575257e-01f, 3.17748040e-02f, -1.56501412e-01f,
  4.49580774e-02f, -5.87506071e-02f, -1.32241428e-01f, 4.93438691e-02f, -1.29399657e-01f, -9.26717967e-02f, 8.51231664e-02f, -3.93014261e-03f, -7.11771101e-02f, -6.71209395e-02f,
  4.56782952e-02f, 1.18570574e-01f, -2.65221018e-03f, 6.10070899e-02f, -5.61165437e-02f, -9.34855938e-02f, 2.21113544e-02f, 7.18924925e-02f, -2.58553517e-03f, 2.24645506e-03f,
  -4.38594632e-02f, 1.08631112e-01f, -3.02640144e-02f, 2.50232276e-02f, 5.29338159e-02f, -6.28153160e-02f, -1.05211467e-01f, 2.07492616e-02f, 4.84978072e-02f, -5.57248853e-02f,
  -3.33305784e-02f, -8.03992525e-02f, -8.27765018e-02f, 9.99425817e-03f, -1.28163518e-02f, -2.76646093e-02f, -2.53518894e-02f, 2.46071033e-02f, -4.44644876e-02f, -1.49635039e-02f,
  -3.95634957e-02f, -3.04993466e-02f, -2.51275972e-02f, -3.53196673e-02f, 6.76544085e-02f, -7.90942460e-02f, 7.81387910e-02f, 4.42949310e-02f, -6.38243109e-02f, 2.83623189e-02f,
  -2.43890099e-03f, -6.97442051e-03f, 2.37533208e-02f, -8.16180333e-02f, -5.27574420e-02f, 1.14802010e-02f, -5.45994267e-02f, 4.24981229e-02f, 6.49078786e-02f, -4.51537967e-02f,
  6.48535267e-02f, 2.44356692e-02f, 3.23710106e-02f, -5.21636494e-02f, -1.95282679e-02f, 7.80337229e-02f, 8.82823542e-02f, 6.82783425e-02f, -6.36519678e-03f, 5.08821569e-02f,
  -8.58281776e-02f, 4.16652709e-02f, -5.11390045e-02f, 8.15752707e-03f, -8.20627213e-02f, -1.79905314e-02f, 3.68297584e-02f, -4.82519418e-02f, -5.17850928e-03f, -4.14089225e-02f,
  -6.14251941e-03f, -4.72454838e-02f, 7.94105828e-02f, -2.41767466e-02f, 5.15416935e-02f, 5.13759069e-02f, 4.57826778e-02f, -5.92891350e-02f, -3.19618993e-02f, 3.04806884e-02f,
  -9.24813449e-02f, 3.37554961e-02f, 2.34231353e-02f, 7.45183006e-02f, -7.15891570e-02f, -8.71858746e-02f, 1.39047308e-02f, -2.75763404e-02f, -3.41160712e-03f, 5.96674643e-02f,
  -8.25173855e-02f, -1.04887620e-01f, 2.14291990e-01f, -1.45333692e-01f, 1.42834723e-01f, 2.29877919e-01f, 1.35931730e-01f, 6.57105893e-02f, -7.09056109e-02f, -1.69045404e-01f,
  7.62603385e-03f, -1.25360578e-01f, 4.35699821e-02f, 2.26189252e-02f, 1.19426966e-01f, 2.19488814e-02f, -4.29067686e-02f, -3.42582166e-02f, 5.76173663e-02f, -9.84660536e-02f,
  5.97526645e-03f, -1.11888330e-02f, 2.02276841e-01f, 7.18061700e-02f, -4.78197075e-02f, -8.84798914e-02f, -1.44522965e-01f, 1.30843833e-01f, -2.54353639e-02f, 9.15000867e-03f,
  -9.58436951e-02f, -1.69278204e-01f, -6.91835061e-02f, 8.19050372e-02f, 2.94118971e-02f, -5.94384000e-02f, 6.98082969e-02f, -5.97215665e-04f, -4.34620418e-02f, -6.19009994e-02f,
  -4.57029752e-02f, -1.88889820e-02f, -7.25395754e-02f, -5.01755066e-02f, -1.92036033e-02f, -3.38821486e-02f, -2.36009024e-02f, 1.69330288e-03f, 4.31465171e-02f, 1.15956746e-01f,
  1.16501018e-01f, 8.11336711e-02f, 5.06999381e-02f, 9.94884595e-03f, 1.02833539e-01f, -1.23661710e-02f, 2.80907508e-02f, -1.43310130e-02f, -3.10322829e-02f, 3.02112941e-02f,
  2.44866796e-02f, 4.71128114e-02f, 3.00406069e-02f, -6.63604122e-03f, 2.39344500e-02f, -3.23675126e-02f, -4.57759649e-02f, 5.69844525e-03f, -9.46105793e-02f, -5.06135188e-02f,
  5.95555268e-02f, -3.82484272e-02f, 1.04962457e-02f, -8.14266950e-02f, -6.75899461e-02f, 1.45816030e-02f, 6.53166100e-02f, -4.51314598e-02f, 3.58230695e-02f, 2.46571135e-02f,
  1.33217890e-02f, 6.64300248e-02f, -3.04928701e-02f, -7.71891698e-02f, 2.72387043e-02f, 4.42538299e-02f, -8.34623948e-02f, 3.00580841e-02f, -1.12796247e-01f, 6.92275120e-03f,
  -1.51606217e-01f, -2.09363356e-01f, -6.95205256e-02f, -1.16514660e-01f, 3.98995280e-02f, -3.28542385e-03f, -6.02380671e-02f, 7.26585984e-02f, 6.60672458e-03f, 2.61347257e-02f,
  -6.89774603e-02f, -6.68244660e-02f, -7.49482960e-02f, -8.65562782e-02f, 7.33518004e-02f, 7.54069909e-02f, 1.47943003e-02f, -8.22254121e-02f, -2.09750142e-03f, 4.62135933e-02f,
  2.78658830e-02f, -6.26139417e-02f, 1.16251670e-02f, 4.98596691e-02f, -3.98972891e-02f, -6.29186034e-02f, 9.19316709e-03f, 6.73886761e-02f, 6.29558116e-02f, -6.42756000e-02f,
  1.09959416e-01f, 5.29692844e-02f, 1.04160599e-01f, 7.52705261e-02f, -5.26805595e-02f, -2.20025018e-01f, -1.21269636e-01f, -1.31071076e-01f, 3.03235222e-02f, -5.42543903e-02f,
  -1.30947560e-01f, 2.23838076e-01f, 1.07835662e-02f, -5.36743179e-02f, 2.43826360e-02f, 9.21632722e-02f, -1.05736479e-01f, -6.02284409e-02f, 4.21454646e-02f, 1.84157863e-02f,
  9.90029722e-02f, -1.66879781e-03f, 1.08852543e-01f, -7.69898714e-03f, -7.59629160e-02f, 8.94141421e-02f, -2.57599931e-02f, -1.11986376e-01f, 5.68561442e-02f, 3.68378498e-02f,
  -4.74796370e-02f, -3.58544327e-02f, 3.24111059e-02f, 3.20990235e-02f, -1.08684190e-02f, -6.19757362e-02f, 3.49097140e-02f, 5.91865778e-02f, -6.93031959e-03f, -9.63297859e-03f,
  -2.94107404e-02f, -3.64288734e-03f, -8.30165297e-02f, 4.22205739e-02f, 6.32436946e-02f, -2.70610992e-02f, 6.86649382e-02f, 4.15611863e-02f, 5.09187244e-02f, -4.71962355e-02f,
  -1.76951941e-02f, 3.46985534e-02f, -7.66839162e-02f, 1.00729428e-01f, 1.53444400e-02f, -6.56628907e-02f, 8.09284747e-02f, 9.69569385e-02f, 8.76322985e-02f, 5.79404831e-02f,
  4.14645970e-02f, -3.56678888e-02f, -4.95871753e-02f, 7.79179903e-03f, 6.94788918e-02f, -7.09460229e-02f, 3.39526078e-03f, 1.87633690e-04f, -3.03419139e-02f, -3.74426693e-03f,
  -2.34223027e-02f, 1.93242934e-02f, 7.93771818e-02f, -7.26093054e-02f, -2.44151447e-02f, 6.23520687e-02f, 4.47841696e-02f, 1.23008741e-02f, -4.70400490e-02f, -6.94950745e-02f,
  -6.13447316e-02f, 3.12154666e-02f, 2.85165571e-03f, 6.10111915e-02f, -2.38509383e-02f, -4.94976118e-02f, -6.93152770e-02f, 6.82795644e-02f, 2.39070170e-02f, -1.92476939e-02f,
  -6.20954633e-02f, 6.22684397e-02f, -3.68111930e-03f, 2.81215999e-02f, 4.56893593e-02f, -1.18946861e-02f, 1.04569935e-03f, -4.41119634e-02f, -3.29693630e-02f, -7.72290304e-02f,
  8.55046213e-02f, 1.20788673e-02f, -4.66260277e-02f, -2.40873192e-02f, -6.71378374e-02f, 6.61352277e-02f, -2.87892949e-02f, 2.36153137e-02f, -3.13327089e-02f, -5.15684523e-02f,
  -3.72870639e-02f, 4.32663262e-02f, 4.08185534e-02f, -5.77334198e-04f, 5.50710410e-02f, 1.01975992e-01f, -6.90555722e-02f, -6.99108541e-02f, 7.21467892e-03f, 6.80166706e-02f,
  7.60417059e-02f, 8.09038430e-02f, 7.00389594e-03f, -7.68451169e-02f, -1.20384498e-02f, 5.71328923e-02f, 2.97386851e-02f, 1.37834042e-01f, 2.43341938e-01f, -1.21635556e-01f,
  -1.44364297e-01f, -5.22431321e-02f, 4.16449904e-02f, -1.67315155e-02f, -2.32563298e-02f, 1.09906703e-01f, 5.58514148e-02f, -3.44628468e-02f, 1.90961435e-01f, -2.89808270e-02f,
  5.07791713e-02f, -4.30665873e-02f, -1.47043392e-01f, -1.01287505e-02f, -1.41456187e-01f, 2.14137661e-04f, -1.02119856e-01f, 2.68884543e-02f, -2.10664615e-01f, -5.12514785e-02f,
  4.15010303e-02f, 6.48837537e-02f, -3.33724804e-02f, 4.54571061e-02f, 2.08268929e-02f, 3.61196212e-02f, -1.29702345e-01f, 3.05914097e-02f, 1.62044063e-03f, 1.09442465e-01f,
  -6.49195760e-02f, -5.66878915e-02f, 1.12983838e-01f, 2.91881151e-02f, 7.71575347e-02f, 4.79220003e-02f, 9.30819288e-02f, 8.15880150e-02f, -3.90163437e-02f, -4.41777930e-02f,
  -6.07816018e-02f, 3.80795598e-02f, -7.05320984e-02f, -1.35069452e-02f, -4.95860688e-02f, 2.35966612e-02f, 5.11392206e-02f, -1.26273409e-01f, -6.41511306e-02f, -8.31662770e-03f,
  8.45228806e-02f, 8.97629466e-03f, 2.52116863e-02f, 2.38214005e-02f, -4.53806669e-02f, -4.26466279e-02f, 1.37603898e-02f, -5.46888299e-02f, 9.54231918e-02f, -1.11328453e-01f,
  -1.63559581e-03f, -4.99710999e-02f, 4.37854454e-02f, 6.08543120e-02f, 2.89351717e-02f, -7.89283291e-02f, -3.14723141e-02f, -1.27469478e-02f, 9.24450904e-02f, 6.91889450e-02f,
  6.60669878e-02f, 6.16996437e-02f, -7.95346219e-03f, -1.93625931e-02f, -7.43442029e-02f, 5.38644493e-02f, 7.31712431e-02f, -7.86842778e-02f, -3.43911946e-02f, -4.98631783e-02f,
  7.00014681e-02f, 7.27744624e-02f, 9.55343768e-02f, 9.24815014e-02f, 1.90427788e-02f, -1.09641403e-02f, 9.38343033e-02f, -3.08374818e-02f, 6.85550869e-02f, 1.45421093e-02f,
  -2.67344322e-02f, -6.21403493e-02f, 3.24901380e-02f, -9.08832550e-02f, 7.00300112e-02f, -1.51146147e-02f, -8.51673186e-02f, -6.66827336e-03f, 4.64708656e-02f, 3.71612795e-02f,
  -1.63361318e-02f, -4.40518260e-02f, 3.39308679e-02f, 5.79793844e-03f, 4.59494963e-02f, -4.44002450e-02f, -5.50407246e-02f, -1.51830884e-02f, -2.32511405e-02f, 2.46201567e-02f,
  -4.13623117e-02f, 1.27371237e-01f, 6.29728585e-02f, 1.56399176e-01f, -1.57222271e-01f, -9.83474031e-02f, 7.88755901e-03f, -2.38786042e-02f, -8.78106430e-03f, 1.43448785e-01f,
  7.14169368e-02f, 4.10326198e-02f, 3.95987146e-02f, 7.65364915e-02f, -2.14330062e-01f, -7.65310898e-02f, 8.73108506e-02f, 6.70229495e-02f, 1.80423632e-02f, 6.55552894e-02f,
  6.87668547e-02f, -6.80581480e-02f, 9.48371217e-02f, 5.66919148e-02f, 7.35479146e-02f, 1.74303621e-01f, 1.40214458e-01f, -9.96968299e-02f, 6.14974499e-02f, -1.25189498e-01f,
  -4.57416885e-02f, 1.61165781e-02f, 3.79391201e-02f, -8.15663561e-02f, 2.31684577e-02f, 3.33598778e-02f, 1.13665171e-01f, 3.61765511e-02f, -1.88379698e-02f, 4.84431237e-02f,
  -3.36571457e-03f, 4.16809209e-02f, -4.79621552e-02f, -7.37047791e-02f, 3.33809517e-02f, 6.86466992e-02f, 7.04591721e-02f, 2.52017640e-02f, 1.49696702e-02f, -4.52846289e-02f,
  2.71506850e-02f, 1.04971051e-01f, 1.14607699e-01f, 7.78536573e-02f, 6.50257692e-02f, 4.06612642e-02f, 2.98108235e-02f, 5.22115305e-02f, 3.05190887e-02f, 7.41205215e-02f,
  1.83738470e-02f, 5.31861819e-02f, 3.95723768e-02f, 7.95258395e-03f, 1.40750930e-02f, 6.77488223e-02f, 3.94080766e-02f, -5.22753187e-02f, -2.29626056e-02f, 6.24872111e-02f,
  -7.52105266e-02f, 8.70319456e-02f, -7.38838390e-02f, 9.72371027e-02f, 5.90123832e-02f, -2.95079891e-02f, 1.69801414e-02f, 5.86641114e-03f, -3.35889421e-02f, 6.89301938e-02f,
  6.83874562e-02f, -8.35020617e-02f, -5.62595874e-02f, -7.24860579e-02f, -1.10653482e-01f, -5.99472784e-03f, -3.09712384e-02f, 2.48132609e-02f, 4.12127599e-02f, -6.86610341e-02f,
  4.28353958e-02f, 1.68471485e-01f, -7.46637061e-02f, -1.96083053e-03f, 7.30458945e-02f, -6.06043637e-02f, 4.05546231e-03f, -4.67087552e-02f, 7.41640925e-02f, -3.68445255e-02f,
  2.26365868e-02f, 3.76463048e-02f, -2.03485303e-02f, 6.66026920e-02f, 7.41250142e-02f, 6.15388788e-02f, -4.55851406e-02f, -4.48264815e-02f, 9.59486738e-02f, -8.31392221e-03f,
  3.68505754e-02f, -9.26748570e-03f, 2.82798484e-02f, -3.31578441e-02f, 6.09320067e-02f, 1.07006751e-01f, -2.63033900e-02f, 9.47010964e-02f, 5.44474758e-02f, -4.55861092e-02f,
  9.62152705e-02f, -1.18058696e-01f, 4.42048647e-02f, -1.14771314e-01f, -1.70577258e-01f, -1.95989624e-01f, -2.03471720e-01f, -2.30919555e-01f, -7.71526173e-02f, -1.46318600e-01f,
  -1.01926133e-01f, 1.77404016e-01f, 1.69337150e-02f, -2.32750118e-01f, 9.18760300e-02f, 1.36847243e-01f, -2.18851328e-01f, -3.82010750e-02f, 2.98122242e-02f, -1.43134788e-01f,
  -3.62944379e-02f, -2.44569004e-01f, 5.62569052e-02f, -1.93117037e-01f, -1.16859041e-01f, 5.19368751e-03f, 2.91605815e-02f, -4.72216494e-02f, -6.68314174e-02f, 4.41331454e-02f,
  -5.86182959e-02f, -8.71003792e-02f, -2.61128950e-03f, 9.33744200e-03f, -4.21234081e-03f, -5.89731410e-02f, 8.19348469e-02f, -5.16611263e-02f, -1.01370491e-01f, 4.51802090e-02f,
  5.73433787e-02f, 4.96188849e-02f, -6.31787777e-02f, 1.08150594e-01f, -1.06335297e-01f, -9.55134165e-03f, -4.27339673e-02f, 6.57027066e-02f, 3.85223404e-02f, -6.04455359e-02f,
  -2.45702211e-02f, 1.69772040e-02f, 2.08675954e-02f, 6.77939132e-02f, 5.26446588e-02f, -2.76103560e-02f, 2.58994736e-02f, 1.33272871e-01f, 4.10479642e-02f, -3.67918238e-02f,
  1.99893769e-02f, 6.66303188e-02f, -6.40832353e-03f, -2.68974099e-02f, -7.26836771e-02f, -9.36064795e-02f, 3.68139111e-02f, 1.68572145e-03f, -7.23921740e-03f, -2.83096042e-02f,
  3.52700381e-03f, -3.08192912e-02f, 1.06355455e-02f, -8.51361156e-02f, -3.15672532e-02f, 4.92912310e-04f, -3.99913825e-02f, 5.53802326e-02f, -6.01072721e-02f, 4.07131808e-03f,
  -2.13775337e-02f, -8.81685934e-04f, 3.76786962e-02f, -1.67484581e-03f, 6.07846528e-02f, 2.87033375e-02f, -3.12389713e-02f, 6.21884018e-02f, 2.68104468e-02f, 7.79083511e-03f,
  -4.82398644e-02f, -7.93544650e-02f, -4.58023436e-02f, 5.10856248e-02f, -4.55826931e-02f, 2.42083576e-02f, -4.62695807e-02f, 2.13901140e-02f, 1.89856254e-02f, -5.86309247e-02f,
  -8.43288824e-02f, 6.41905740e-02f, -7.36253709e-02f, -6.74649030e-02f, 7.40602016e-02f, 2.51275171e-02f, 1.37965130e-02f, 6.23375773e-02f, -6.20877109e-02f, 5.20530939e-02f,
  -3.66900600e-02f, 3.83783206e-02f, 4.31032805e-03f, -1.61887556e-02f, 6.97779804e-02f, 2.37674620e-02f, 4.65516448e-02f, 4.58372422e-02f, 4.13127057e-03f, -9.63602588e-02f,
  -1.35469034e-01f, -4.37033437e-02f, 7.00655952e-03f, -1.35828882e-01f, 8.65492448e-02f, 2.12777103e-03f, -9.23574865e-02f, 1.52304962e-01f, -7.82328174e-02f, 3.59862931e-02f,
  -3.21436040e-02f, -6.35707751e-02f, -1.58603862e-02f, -8.09887722e-02f, -1.00722343e-01f, 2.66803019e-02f, -4.07729624e-03f, 2.51852255e-02f, 1.20823823e-01f, -7.56597295e-02f,
  8.61320943e-02f, 2.55497359e-02f, 9.19380486e-02f, 1.84184685e-01f, 5.81557490e-02f, 1.95298679e-02f, -9.94728580e-02f, 1.78710781e-02f, -3.95254567e-02f, -1.41220698e-02f,
  -3.81887779e-02f, 6.69915229e-02f, -1.30736874e-02f, -2.14361846e-02f, -4.44367751e-02f, -1.00693397e-01f, 3.37633640e-02f, 2.51321995e-04f, 4.68037613e-02f, -6.74767699e-03f,
  -1.35155469e-01f, 9.89154428e-02f, 2.55233347e-02f, -6.88203275e-02f, -1.55676771e-02f, 1.07950922e-02f, 1.06924940e-02f, 3.50753255e-02f, -2.73999870e-02f, -6.39834553e-02f,
  -2.46069767e-02f, 4.94568571e-02f, -8.66962671e-02f, -5.52437343e-02f, -5.67212701e-03f, -8.35353658e-02f, 6.26489613e-03f, 4.97539900e-02f, 3.67596485e-02f, 5.60567155e-03f,
  -1.50253959e-02f, -7.65396748e-03f, 5.01622967e-02f, 1.63138639e-02f, 3.03451661e-02f, -3.76158729e-02f, 5.48483767e-02f, 6.74434155e-02f, 4.84170206e-02f, -7.14869052e-02f,
  -7.31086880e-02f, 1.27336588e-02f, 2.72695851e-02f, 2.00231541e-02f, 8.41956027e-03f, -1.18727423e-02f, -6.45674393e-02f, -5.74604683e-02f, 3.80318947e-02f, -5.25785536e-02f,
  -9.21611488e-02f, 1.89046969e-03f, 3.96079570e-02f, -6.83865324e-02f, -4.87557016e-02f, -8.02628845e-02f, 2.39871852e-02f, 9.55787450e-02f, 5.60384691e-02f, 7.08758011e-02f,
  -7.75335804e-02f, 3.14376354e-02f, 2.76699057e-03f, -4.36853850e-03f, 2.92760916e-02f, 7.40649328e-02f, -6.90967292e-02f, -8.54699090e-02f, 4.23677042e-02f, -5.15174903e-02f,
  5.69610260e-02f, -4.32245918e-02f, 3.91445607e-02f, 8.26868042e-02f, 7.02776611e-02f, -8.50741658e-03f, -3.53343785e-02f, 1.74741168e-02f, -9.94993225e-02f, 2.96436120e-02f,
  5.42140938e-02f, 6.62275478e-02f, -1.90750714e-02f, 9.63144843e-03f, 4.68024164e-02f, -8.96549448e-02f, -5.82487918e-02f, -7.17575327e-02f, -4.99847066e-03f, -6.21149801e-02f,
  7.92261213e-02f, 4.41837087e-02f, 4.28882837e-02f, 5.04376404e-02f, -9.11996216e-02f, 4.15210641e-04f, -4.80368994e-02f, -1.94471497e-02f, 1.52710229e-01f, 2.97765639e-02f,
  -1.46237150e-01f, 1.13828428e-01f, -2.42376514e-02f, -6.63921013e-02f, -5.43604903e-02f, -3.10080014e-02f, 3.07630952e-02f, 6.83039660e-03f, 4.60023545e-02f, -7.12471604e-02f,
  4.26156297e-02f, -2.44787727e-02f, -1.02924086e-01f, -7.73266032e-02f, -8.75670090e-02f, 6.22072145e-02f, 4.94106533e-03f, -1.32845685e-01f, 3.41356508e-02f, -5.06440876e-03f,
  -8.95957202e-02f, 2.02623028e-02f, -7.34692961e-02f, 7.19933733e-02f, 2.55061388e-02f, -1.64990090e-02f, 8.14426094e-02f, -5.94211966e-02f, -4.16745953e-02f, -6.51269630e-02f,
  -2.41451953e-02f, -5.37479073e-02f, 1.00642033e-01f, -3.00583560e-02f, -4.76452187e-02f, -2.13921368e-02f, 1.75914597e-02f, -5.50592355e-02f, -3.92014123e-02f, -1.74819697e-02f,
  1.21231778e-02f, 9.08117071e-02f, 9.02270153e-02f, -3.82450819e-02f, 3.36769037e-02f, -1.75405014e-02f, 8.65174606e-02f, -8.18153918e-02f, 1.03674740e-01f, 9.32705849e-02f,
  -1.57072413e-04f, 4.69118915e-02f, 1.02550015e-02f, 5.79488985e-02f, -5.43567203e-02f, 5.09437639e-03f, -3.26076299e-02f, 9.61333215e-02f, -7.28735998e-02f, -1.19855702e-02f,
  -4.02255058e-02f, 5.05082635e-03f, -3.91243631e-03f, -2.67762523e-02f, -5.70620112e-02f, 7.89006352e-02f, 1.23649603e-02f, 1.35050137e-02f, 5.59755377e-02f, 3.70227620e-02f,
  8.45336094e-02f, -2.44456902e-02f, 6.67276308e-02f, 7.14382306e-02f, -4.78457622e-02f, 8.13371018e-02f, 8.71235281e-02f, 3.89357768e-02f, -7.83469826e-02f, 1.15141757e-02f,
  8.58383700e-02f, 1.38476565e-01f, 7.42188320e-02f, -9.42346305e-02f, 6.44016489e-02f, -2.95660477e-02f, 5.70703037e-02f, 6.69473633e-02f, 2.08401456e-02f, -6.94532394e-02f,
  7.58383274e-02f, -1.46048265e-02f, -2.16331091e-02f, 1.98121853e-02f, -3.73108871e-02f, -8.78846422e-02f, 2.46220771e-02f, 9.04651731e-02f, -2.58308314e-02f, -1.28579431e-03f,
  -7.16724917e-02f, 8.97503346e-02f, 8.54337141e-02f, 2.38549039e-02f, -1.08462125e-02f, 3.43247801e-02f, 6.78502349e-03f, 8.39747339e-02f, 4.70218286e-02f, 5.07961363e-02f,
  1.23628460e-01f, -1.72743127e-01f, -8.72266591e-02f, -2.30715834e-02f, -6.89344779e-02f, -5.71647845e-02f, -8.32618959e-03f, -1.00826688e-01f, -3.42596993e-02f, -1.89675111e-02f,
  9.48835835e-02f, -8.64113867e-02f, 7.60785490e-02f, 9.36521590e-02f, 8.84229094e-02f, 1.81017052e-02f, -7.67849609e-02f, 5.18925302e-02f, 1.83929279e-02f, 1.04642376e-01f,
  1.13461420e-01f, -1.51817529e-02f, -2.66296249e-02f, -1.53653333e-02f, 7.90248886e-02f, 3.71880047e-02f, 7.23152086e-02f, 1.70883408e-03f, -1.27927139e-01f, 7.02517331e-02f,
  9.33558643e-02f, -1.78537592e-02f, 6.91697979e-03f, -1.70741118e-02f, -7.91024193e-02f, -5.11614233e-02f, -2.01046839e-02f, 3.87263633e-02f, 1.05381161e-02f, -4.07863408e-02f,
  -9.72174257e-02f, -3.19694430e-02f, 4.55365703e-02f, 4.18429039e-02f, -6.70029875e-03f, -7.12112784e-02f, -3.71506140e-02f, 4.90049943e-02f, -8.54432881e-02f, 1.58667902e-03f,
  1.07953846e-02f, -6.29526004e-02f, 8.58017355e-02f, -1.30738288e-01f, -6.95131943e-02f, -4.28197198e-02f, -1.22161292e-01f, 4.81735803e-02f, -1.13637991e-01f, -8.58241767e-02f,
  5.21586314e-02f, 8.80312249e-02f, -4.45562089e-03f, -4.79466617e-02f, -1.83573682e-02f, 3.78999859e-02f, -5.30703478e-02f, -4.03620005e-02f, 6.46987092e-03f, 2.09315922e-02f,
  4.78652120e-02f, 5.83536476e-02f, 5.61439730e-02f, -2.85354760e-02f, -1.67339891e-02f, 1.01384791e-02f, -3.77979577e-02f, 6.46170899e-02f, -1.83333773e-02f, 5.59448563e-02f,
  3.65828462e-02f, 3.43147144e-02f, 4.80629019e-02f, -4.46470119e-02f, -5.53456880e-02f, 8.85168016e-02f, -4.27506082e-02f, 3.46105061e-02f, -6.65985197e-02f, 2.73098256e-02f,
  1.38770984e-02f, -3.84498946e-02f, -7.24918768e-02f, 5.18996604e-02f, 3.63290384e-02f, 7.69894645e-02f, -3.84606421e-02f, -9.63183418e-02f, -2.19555557e-04f, -9.76902805e-03f,
  -1.62973944e-02f, 5.28343581e-02f, -1.79255567e-02f, 2.38781772e-03f, 5.80270365e-02f, -7.48600438e-02f, 4.70010983e-03f, -9.39565077e-02f, -1.14797398e-01f, -3.82156968e-02f,
  -4.00393046e-02f, -7.54382461e-02f, 6.80621760e-03f, -7.41579011e-02f, -9.08519998e-02f, -6.73700720e-02f, 4.17249613e-02f, -7.48108476e-02f, -4.59509119e-02f, -1.70795377e-02f,
  2.05140874e-01f, 3.27978015e-01f, 2.78442025e-01f, 2.87008554e-01f, -1.76461544e-02f, -3.50470766e-02f, -9.78260860e-03f, 4.87977937e-02f, 1.55507848e-01f, 2.40017995e-02f,
  -1.49061307e-01f, 1.86821252e-01f, -2.01475114e-01f, 7.13269785e-02f, -1.89885974e-01f, -1.48067176e-01f, 2.22362876e-02f, 2.51535960e-02f, 1.09387532e-01f, 1.00834996e-01f,
  -4.20455597e-02f, -1.94160849e-01f, 1.70842856e-02f, -8.69149119e-02f, 1.59530655e-01f, 1.31202266e-01f, -4.51003723e-02f, -7.60502443e-02f, 2.17349250e-02f, -7.16770366e-02f,
  -1.08763361e-02f, 3.87316123e-02f, 1.06310941e-01f, 2.82634664e-02f, -4.17724997e-02f, 8.11353400e-02f, 8.79094675e-02f, -4.07431042e-03f, -2.01455224e-02f, 2.77891401e-02f,
  6.12484366e-02f, 4.02223468e-02f, 8.36065635e-02f, -7.32438564e-02f, 7.75991306e-02f, 5.19160517e-02f, -1.48417838e-02f, 1.42406330e-01f, 6.49462864e-02f, 6.81269318e-02f,
  2.63098050e-02f, 3.37022729e-03f, 9.97069478e-03f, 1.13656186e-01f, 5.11714183e-02f, 6.91693053e-02f, -3.08672450e-02f, 3.56950089e-02f, 4.40951139e-02f, 5.94919063e-02f,
  -3.47654559e-02f, 2.48980466e-02f, -4.33199946e-03f, 5.71707897e-02f, -4.72149625e-02f, -5.70482924e-04f, 6.19735867e-02f, -8.28651637e-02f, 6.20466135e-02f, -6.39005229e-02f,
  -5.35331406e-02f, -9.78991762e-03f, -3.17786075e-02f, -8.81160493e-04f, 4.97278757e-02f, 3.59252430e-02f, -2.78058834e-03f, 1.46743301e-02f, 6.26830459e-02f, 2.71207746e-02f,
  -8.74930918e-02f, 7.35292658e-02f, 3.85500863e-02f, -1.03760157e-02f, 2.22126786e-02f, -1.91857349e-02f, 3.79487425e-02f, 8.48413482e-02f, -8.22999403e-02f, -1.95227098e-02f,
  3.07994448e-02f, 1.24545462e-01f, 2.90713776e-02f, -7.51032233e-02f, 6.87722340e-02f, -6.71008453e-02f, 4.07638960e-02f, -2.22356953e-02f, -3.31305973e-02f, 3.08284964e-02f,
  -5.84703684e-02f, -2.39653122e-02f, -8.45563263e-02f, -5.05572334e-02f, 5.40412671e-04f, 5.62090576e-02f, -1.80750992e-02f, -3.18294093e-02f, 6.58826977e-02f, 4.71076509e-03f,
  2.68690716e-02f, -2.46674232e-02f, -2.22234894e-02f, -5.45839556e-02f, -7.32465237e-02f, 4.22512889e-02f, -1.20281817e-04f, 8.15603510e-02f, -3.89339477e-02f, 7.37537146e-02f,
  2.14451835e-01f, 6.90268874e-02f, -1.83399111e-01f, 3.26289842e-03f, -1.14688307e-01f, -2.00653344e-01f, -2.16737524e-01f, -8.25005770e-02f, 1.15827128e-01f, 9.15631056e-02f,
  3.24761798e-03f, 4.43864167e-02f, 3.94421034e-02f, 2.20201518e-02f, 4.87397425e-02f, 1.50417089e-01f, 4.60394137e-02f, -6.31059557e-02f, 8.43596458e-02f, 2.93091051e-02f,
  7.31835738e-02f, -2.26161946e-02f, -1.35585517e-01f, -1.05503418e-01f, -8.93984437e-02f, -3.78240235e-02f, 7.41478428e-02f, -1.28802240e-01f, -4.87534925e-02f, 1.05497036e-02f,
  9.37955920e-03f, 1.21743143e-01f, 1.21090058e-02f, 3.09161749e-02f, 6.35580570e-02f, -1.21782854e-01f, -7.25988671e-02f, -1.08685670e-02f, -7.22497329e-02f, 6.23715259e-02f,
  8.43109116e-02f, 3.01392302e-02f, -1.37569904e-02f, -1.38167874e-03f, -8.99002925e-02f, 5.36021106e-02f, 5.57150990e-02f, -2.41532139e-02f, -1.32436585e-02f, -7.82327726e-02f,
  2.77452078e-02f, -9.52465981e-02f, -2.64145434e-02f, 2.52536461e-02f, 3.39254513e-02f, 5.16294502e-02f, -3.43074240e-02f, 5.17902449e-02f, -5.22997975e-02f, 3.92078049e-02f,
  1.56888366e-02f, 6.12492636e-02f, -9.16339010e-02f, 4.83447686e-02f, -2.14168485e-02f, -2.08307225e-02f, -8.62160474e-02f, -5.09790890e-02f, -2.87327450e-02f, -2.54527517e-02f,
  1.84883364e-02f, 4.19954732e-02f, 6.02487521e-03f, 3.57158966e-02f, 5.54582067e-02f, 2.55637150e-02f, 6.12601750e-02f, 3.66384834e-02f, 1.55305155e-02f, -5.53276576e-02f,
  7.26575777e-03f, -4.86347824e-02f, -3.18493024e-02f, -7.76747093e-02f, -3.42039950e-02f, 2.75399797e-02f, -5.90410270e-03f, -3.05541256e-03f, -2.91620158e-02f, -4.98587936e-02f,
  -3.02972719e-02f, 2.76337862e-01f, -1.07160686e-02f, -5.78049608e-02f, 3.07371709e-02f, -2.72313133e-02f, -3.14891078e-02f, 5.62433712e-02f, 7.88569227e-02f, 8.62237439e-02f,
  -7.64696002e-02f, 1.99427065e-02f, 1.53241800e-02f, -8.33589360e-02f, -3.92814772e-03f, 2.60834210e-02f, -2.17991192e-02f, 4.21214998e-02f, -3.97428609e-02f, 1.71896126e-02f,
  -9.20368582e-02f, 2.74045374e-02f, 6.36519492e-02f, 1.51728718e-02f, 2.86963433e-02f, 5.19594699e-02f, -2.14947332e-02f, 7.21401423e-02f, 3.05440873e-02f, 8.04195702e-02f,
  -3.00884962e-01f, 9.43918526e-02f, 4.35491242e-02f, -2.30157122e-01f, 1.08144477e-01f, -1.98586881e-02f, 3.90524231e-03f, 5.38331568e-02f, 3.77160311e-02f, 1.48344398e-01f,
  1.25825107e-01f, -4.89680953e-02f, 1.58796832e-01f, -8.19085762e-02f, -3.66531312e-01f, -7.20818043e-02f, -2.37929538e-01f, -1.71157926e-01f, -5.11724725e-02f, 1.48739358e-02f,
  -1.58738673e-01f, -5.87975830e-02f, -8.63973275e-02f, 9.01688188e-02f, 2.54986603e-02f, 1.17816575e-01f, -5.13782836e-02f, 1.59449756e-01f, 1.86586939e-02f, 2.08960809e-02f,
  -9.20893177e-02f, 1.60827607e-01f, 1.65212397e-02f, 1.37830094e-01f, 1.95484031e-02f, 2.80709285e-02f, -4.32063192e-02f, 3.43684740e-02f, 6.35783421e-04f, 1.53991021e-02f,
  -1.79643987e-03f, 1.27683297e-01f, 1.54257463e-02f, 6.45600557e-02f, 1.02424122e-01f, 9.00868922e-02f, -2.39927042e-02f, -9.07655898e-03f, 3.94069329e-02f, 6.82195872e-02f,
  7.51051456e-02f, 7.60305226e-02f, 5.21035679e-02f, -9.59501043e-02f, -7.75162652e-02f, 6.86567575e-02f, -7.93120041e-02f, -6.52783960e-02f, -7.91938603e-02f, 4.07319739e-02f,
  -6.45081848e-02f, 4.60202619e-02f, -2.99276412e-02f, 4.64210212e-02f, -7.91686680e-03f, 4.71153371e-02f, -2.30956227e-02f, -3.52642611e-02f, 5.22546768e-02f, -6.98475316e-02f,
  -4.33923863e-02f, -6.22785359e-04f, 8.39957222e-02f, -5.78984655e-02f, -8.45574323e-05f, 1.39409509e-02f, -4.49211486e-02f, 1.07568696e-01f, -3.51418997e-03f, -5.36974072e-02f,
  5.97487874e-02f, -7.58650079e-02f, -5.20584509e-02f, -2.87648886e-02f, 2.21150834e-02f, 9.21897367e-02f, 3.21657322e-02f, 2.87475828e-02f, -4.32313653e-03f, -5.57451099e-02f,
  -1.24743402e-01f, -5.78526743e-02f, 2.92328969e-02f, 9.55481008e-02f, 3.47133949e-02f, 7.96058029e-03f, -9.56660733e-02f, -4.32993509e-02f, -1.21203043e-01f, -5.33034168e-02f,
  -3.85116339e-02f, 6.54052123e-02f, -1.19972244e-01f, 2.22860742e-02f, 1.11842770e-02f, -5.24091236e-02f, 7.24742096e-03f, -1.07221439e-01f, 2.13309657e-02f, 2.07044911e-02f,
  4.83213626e-02f, 1.31974500e-02f, -4.62937169e-02f, -3.42475511e-02f, -1.09580047e-02f, -3.65172811e-02f, -6.75193295e-02f, -1.20109078e-02f, 9.43446159e-02f, -4.36306447e-02f,
  -2.54320920e-01f, 3.53781104e-01f, -2.61272937e-01f, 1.02809303e-01f, -1.18115932e-01f, 1.38310120e-01f, 2.33532533e-01f, 1.17841043e-01f, 1.64121091e-01f, 2.51466453e-01f,
  1.64522156e-01f, -4.36368249e-02f, 1.31850928e-01f, 3.05571228e-01f, 5.02844565e-02f, 1.62736654e-01f, 3.48885447e-01f, 1.39992386e-01f, 2.04273276e-02f, 4.41940688e-02f,
  -1.11523226e-01f, 9.09717306e-02f, 3.45078371e-02f, -1.43927976e-01f, -1.07593241e-03f, -2.50372350e-01f, -2.76471153e-02f, -2.54485667e-01f, 5.87571189e-02f, 6.97932988e-02f,
  7.94080086e-03f, 5.72027117e-02f, -6.47790357e-02f, -7.07203448e-02f, -5.67869917e-02f, -8.05849582e-02f, 7.14655221e-03f, -5.06564640e-02f, -1.86598953e-02f, -8.75606854e-03f,
  -1.10654915e-02f, 2.91016549e-02f, -6.50642440e-02f, -4.27855812e-02f, -7.05352658e-03f, -6.05937317e-02f, -1.20903300e-02f, -8.11851323e-02f, 1.10805901e-02f, -1.37410730e-01f,
  4.40017832e-03f, 5.43053821e-02f, -1.34576065e-02f, -6.22745929e-03f, -1.41855692e-02f, -2.36515962e-02f, 4.61374708e-02f, -6.17735423e-02f, -3.07201054e-02f, 1.18710198e-01f,
  -8.76463279e-02f, -3.63662536e-03f, -6.36193156e-03f, -4.83961999e-02f, -6.15829006e-02f, 8.39031208e-03f, 6.36786222e-02f, 5.46908379e-02f, -3.96108888e-02f, -4.16862732e-03f,
  -6.91136569e-02f, 3.56821008e-02f, 4.83783223e-02f, 4.85181250e-02f, -1.01998104e-02f, 6.01166412e-02f, 1.13556283e-02f, 2.30504833e-02f, -3.39340232e-02f, 5.94055802e-02f,
  8.00361186e-02f, 1.47048710e-02f, 4.33421619e-02f, -3.73451672e-02f, 7.72826225e-02f, 2.85601411e-02f, -2.98111923e-02f, 5.31957820e-02f, -1.04976743e-02f, 1.71347633e-02f,
  1.39878705e-01f, 2.11520061e-01f, -4.49579917e-02f, 2.06541363e-03f, 8.25195760e-02f, -1.34734728e-03f, -6.53467374e-04f, 5.14649861e-02f, 6.51101992e-02f, -1.32744592e-02f,
  -5.47662117e-02f, -2.81820334e-02f, 9.37200859e-02f, -9.33473706e-02f, -3.84228677e-02f, 1.06082208e-01f, 8.68801624e-02f, 1.33977439e-02f, 1.03852022e-02f, 2.57722214e-02f,
  -6.26742691e-02f, 5.14284037e-02f, 2.17284895e-02f, 5.10775186e-02f, 1.25185354e-03f, -6.23628171e-03f, 1.11341588e-02f, -6.15532398e-02f, 2.33650599e-02f, -9.16741975e-03f,
  -8.06931853e-02f, -2.07215324e-01f, -1.71667144e-01f, 1.26468122e-01f, 4.22176830e-02f, 3.37719023e-02f, -2.47124936e-02f, -7.18960240e-02f, -2.66164333e-01f, 1.85580850e-02f,
  1.03731818e-01f, -1.25457779e-01f, -1.47032082e-01f, -3.42407301e-02f, 4.08985466e-02f, -2.42819056e-01f, 4.21332084e-02f, 9.35652703e-02f, -3.68735120e-02f, 3.44945379e-02f,
  -5.67338690e-02f, 1.81227803e-01f, 4.72184755e-02f, 1.34575084e-01f, 1.37142092e-01f, 1.67041600e-01f, 2.81277865e-01f, 1.08738452e-01f, 2.04247758e-01f, 1.84644595e-01f,
  5.59613388e-03f, -5.57961911e-02f, -5.31884246e-02f, -1.68835800e-02f, 2.07781475e-02f, -9.08926688e-03f, 1.03413910e-01f, 2.55610123e-02f, -2.21758080e-03f, 2.53998600e-02f,
  1.36717334e-02f, 3.03274188e-02f, 6.15913719e-02f, 3.61663774e-02f, -2.28055450e-03f, 4.94191423e-02f, -9.61916894e-02f, -2.32155006e-02f, -8.82273689e-02f, -6.36242256e-02f,
  -2.57666782e-02f, -9.33225453e-03f, -3.51814218e-02f, -2.07616966e-02f, -1.86351575e-02f, -1.62741374e-02f, -1.52306082e-02f, 1.03547215e-01f, 2.42529102e-02f, 9.54243764e-02f,
  2.82410756e-02f, -2.16045063e-02f, -2.79396176e-02f, -1.89860892e-02f, -6.77459389e-02f, -3.87015343e-02f, -2.74898801e-02f, -3.48752216e-02f, -5.21441847e-02f, -3.65221612e-02f,
  -4.37020920e-02f, 1.75494682e-02f, 4.23527882e-02f, -9.56549216e-03f, 2.83301473e-02f, -2.80344728e-02f, 2.99963774e-03f, 2.01661582e-03f, 5.66316433e-02f, 1.26007563e-02f,
  -1.43447425e-02f, 6.93325549e-02f, -2.24716756e-02f, 8.25254172e-02f, 2.86235306e-02f, 4.18837089e-03f, -5.53502478e-02f, -6.91528693e-02f, -3.90430465e-02f, 1.02917127e-01f,
  1.24412425e-01f, 1.02172092e-01f, -7.41258413e-02f, -4.54547219e-02f, 5.56927454e-03f, -2.49424446e-02f, 3.84947024e-02f, 3.94179299e-02f, 6.82470948e-03f, -4.84230332e-02f,
  1.06698051e-01f, 8.62714872e-02f, 7.92724937e-02f, -6.17324281e-03f, 1.50003955e-01f, 1.87954716e-02f, 7.18134344e-02f, 4.34097610e-02f, -1.68141699e-03f, 6.26349449e-02f,
  1.16170406e-01f, 4.31214496e-02f, 2.06092335e-02f, -4.69446648e-03f, 5.89172952e-02f, 1.51617629e-02f, 1.34901822e-01f, -1.56145683e-02f, -8.05712584e-03f, 1.39860166e-02f,
  -2.60377191e-02f, -3.89590561e-02f, 3.18632945e-02f, 7.27296844e-02f, -1.52378201e-01f, -1.93684939e-02f, -1.01296119e-01f, 5.73845655e-02f, 5.31341769e-02f, 1.19246114e-02f,
  2.18497515e-02f, 2.64304504e-03f, 8.62109363e-02f, 8.61002430e-02f, 1.13222273e-02f, 2.82556564e-02f, 9.42916959e-05f, 4.78974395e-02f, -4.18038145e-02f, -7.67785311e-02f,
  1.25848046e-02f, -5.82691617e-02f, -2.57865619e-02f, -2.82854624e-02f, -1.00852147e-01f, 8.03853199e-02f, 3.87273394e-02f, -4.75018956e-02f, -3.51846293e-02f, -2.93374043e-02f,
  -7.01584443e-02f, -6.95077926e-02f, 4.91292439e-02f, -8.95618945e-02f, 3.58587019e-02f, -4.59798202e-02f, 4.08612937e-02f, -1.47894975e-02f, 5.46593890e-02f, -9.11799222e-02f,
  4.00204808e-02f, -5.93407340e-02f, 7.73872510e-02f, -7.42034465e-02f, 3.74119915e-02f, 1.69729702e-02f, 7.29655176e-02f, 3.95342112e-02f, 5.48712425e-02f, 3.40456218e-02f,
  -6.04087301e-02f, -7.95169622e-02f, -1.17250290e-02f, 6.23074099e-02f, 4.80105318e-02f, 3.13011631e-02f, 2.79952660e-02f, -4.66088131e-02f, -1.76630877e-02f, -2.09334530e-02f,
  -5.05730361e-02f, -5.95534183e-02f, 3.56993601e-02f, 5.10996021e-02f, -1.89393573e-02f, -2.36295853e-02f, 2.96937302e-02f, 4.70467433e-02f, 9.96545074e-04f, -7.45843798e-02f,
  -7.54296780e-02f, 4.54552621e-02f, 5.64671569e-02f, -6.93359226e-02f, -1.90891493e-02f, -5.52982837e-02f, 8.72758925e-02f, -3.91597301e-02f, 5.26861995e-02f, -3.91628258e-02f,
  8.37011784e-02f, -5.53741120e-02f, 5.80517314e-02f, -1.13853598e-02f, 4.90893163e-02f, -3.60030332e-03f, 1.56359524e-02f, -1.61468443e-02f, -7.21263438e-02f, -7.10681677e-02f,
  -9.62668285e-02f, -5.85957058e-02f, 7.18148276e-02f, 2.31204238e-02f, -9.07715112e-02f, 6.36811331e-02f, 5.85771501e-02f, -5.12772538e-02f, 4.79626557e-04f, -2.42986530e-02f,
  5.17570600e-02f, 6.31015515e-03f, 2.30850056e-02f, 2.70731337e-02f, -5.80912195e-02f, -1.01373978e-01f, -2.74980403e-02f, 5.36532439e-02f, -5.33886477e-02f, -3.38230468e-02f,
  4.68107462e-02f, 3.40810209e-03f, -6.55004522e-03f, 1.67719387e-02f, -1.99368410e-02f, -2.60005854e-02f, 1.40657295e-02f, -8.97095054e-02f, -6.39608279e-02f, 1.33700194e-02f,
  3.62808034e-02f, -2.08166707e-02f, -1.14411078e-02f, 2.49166298e-03f, 6.78764433e-02f, 6.52470067e-02f, -1.10245362e-01f, -5.96125163e-02f, -4.78935130e-02f, 4.19498906e-02f,
  -3.86019759e-02f, -1.07317962e-01f, -9.79080871e-02f, -1.12513766e-01f, -1.00573137e-01f, -1.58094987e-01f, -8.60066786e-02f, -8.88253078e-02f, -1.61154680e-02f, -6.45435229e-02f,
  -1.23255685e-01f, -8.56277719e-03f, 4.22597043e-02f, 9.29932147e-02f, 1.12386115e-01f, -2.01682597e-02f, -9.23166499e-02f, 2.12600492e-02f, -5.06015643e-02f, -8.71900618e-02f,
  -3.99659574e-02f, -2.23819390e-02f, 9.52376947e-02f, -2.54222825e-02f, -6.49903044e-02f, 2.46908553e-02f, -3.71401645e-02f, -6.86053708e-02f, 1.40257422e-02f, -2.66098883e-02f,
  -7.89261684e-02f, -5.24856448e-02f, -1.56376474e-02f, 6.01717457e-02f, -5.11157475e-02f, 5.25912195e-02f, 5.31185158e-02f, 3.04808337e-02f, 9.07935668e-03f, 2.21465086e-03f,
  3.22375111e-02f, -2.55797002e-02f, -7.33117461e-02f, 5.35266511e-02f, 1.36654424e-02f, -4.78181541e-02f, 6.00836426e-02f, 5.62736355e-02f, 1.02634365e-02f, -6.93844259e-03f,
  -5.02104964e-03f, -1.08341565e-02f, -4.00059149e-02f, 5.37146628e-02f, 4.73808795e-02f, 8.94095749e-02f, -8.49059131e-03f, 3.78590263e-02f, 3.35463285e-02f, 4.94780391e-02f,
  6.56149685e-02f, 2.11522076e-02f, -7.73252100e-02f, -3.26673128e-02f, -6.82443678e-02f, 2.17532665e-02f, 8.93079042e-02f, 9.34410393e-02f, -2.38984283e-02f, 9.69453454e-02f,
  -1.46799143e-02f, -1.26467003e-02f, -4.15268354e-02f, -2.29205266e-02f, 5.42703904e-02f, 1.73684880e-02f, 1.04177948e-02f, 3.45324725e-02f, 2.95627341e-02f, -1.36991572e-02f,
  2.02464778e-02f, -3.95593792e-02f, 6.20506927e-02f, 5.79937473e-02f, 5.70811369e-02f, -2.12675356e-03f, -4.67188247e-02f, -8.40968713e-02f, -1.22495880e-02f, 8.81568063e-03f,
  2.84624193e-02f, 7.81783927e-03f, 3.39570120e-02f, 6.25965968e-02f, -9.31956172e-02f, -5.42737311e-03f, 2.93819197e-02f, 2.34169252e-02f, 7.15967268e-02f, 7.82520398e-02f,
  7.43195117e-02f, 1.68341659e-02f, -4.60434593e-02f, -1.48532456e-02f, 3.19016948e-02f, -1.84424985e-02f, -3.19031142e-02f, -6.45593852e-02f, -4.07093093e-02f, -9.24964100e-02f,
  -1.62171334e-01f, -5.44289760e-02f, 1.02441356e-01f, -6.62739798e-02f, 1.17266133e-01f, 5.72239840e-03f, 9.02020037e-02f, -6.25210851e-02f, -1.64482832e-01f, 3.95139568e-02f,
  -5.15041798e-02f, -8.25883076e-02f, -2.74200607e-02f, -2.18970254e-01f, -9.66475233e-02f, -1.98225319e-01f, -1.22328125e-01f, 3.50836217e-02f, -2.14327127e-02f, 8.29869062e-02f,
  -9.62367132e-02f, -7.20794499e-02f, -1.15095735e-01f, 3.29209566e-02f, -4.17871587e-02f, 9.71782431e-02f, -1.54774021e-02f, 1.17152467e-01f, 8.81347433e-02f, -1.50440284e-03f,
  4.12922166e-02f, -4.20328006e-02f, -4.26842347e-02f, -3.34281405e-03f, 1.24155790e-01f, 3.29603590e-02f, -3.29136774e-02f, 5.28737381e-02f, 5.39820734e-03f, 4.58032452e-02f,
  -2.39481162e-02f, -5.43514676e-02f, -9.03849378e-02f, -3.22312526e-02f, -5.22828884e-02f, -1.78067461e-02f, -1.28463032e-02f, 6.96507022e-02f, -6.17845729e-02f, -4.86148223e-02f,
  -5.97152673e-02f, 7.86233544e-02f, 4.81388951e-03f, -2.04294715e-02f, 3.79859731e-02f, 1.38002662e-02f, -4.32671644e-02f, -2.28587911e-02f, -3.41706979e-03f, -1.67946871e-02f,
  -4.21601869e-02f, 5.22386245e-02f, 4.79459316e-02f, 1.74710806e-02f, -7.74033964e-02f, -6.51082471e-02f, 1.51425162e-02f, -1.76645089e-02f, -1.68211609e-02f, -6.33872449e-02f,
  4.96173985e-02f, 5.11627384e-02f, 2.81328745e-02f, -6.46188557e-02f, 1.22538023e-02f, -1.43638402e-02f, 3.28061506e-02f, 8.02682489e-02f, 7.61734918e-02f, 5.08063752e-03f,
  -1.57969128e-02f, 3.83597575e-02f, 3.96314450e-02f, -2.03255434e-02f, 4.55936752e-02f, -6.95426837e-02f, -9.13551003e-02f, -4.69771326e-02f, -2.26737149e-02f, 2.73617208e-02f,
  9.22304764e-02f, -7.73320720e-02f, -5.21255396e-02f, 1.09310545e-01f, 3.59483212e-02f, 3.64210792e-02f, 7.88170192e-03f, 1.49331801e-02f, -3.11233662e-02f, -2.88624000e-02f,
  1.14021152e-01f, 7.44198188e-02f, 7.49660954e-02f, -9.27533284e-02f, -5.51684611e-02f, -3.49833183e-02f, 3.07459291e-02f, 5.91943711e-02f, -3.83528657e-02f, -5.79404011e-02f,
  8.43420550e-02f, -9.80471540e-03f, 6.25306591e-02f, -5.25399782e-02f, 7.90770575e-02f, 5.81877790e-02f, 4.06000987e-02f, 2.59496886e-02f, 4.44153026e-02f, 3.86598632e-02f,
  -1.06823854e-01f, -9.53411683e-02f, -3.32663395e-02f, -3.80523968e-03f, -1.13417819e-01f, 1.34389579e-01f, -2.62986170e-03f, -1.07044578e-01f, -1.27574533e-01f, 4.65887133e-03f,
  7.30450973e-02f, -8.97713006e-02f, 1.28465578e-01f, 1.43659174e-01f, 1.00521281e-01f, 1.32915273e-01f, 1.69508189e-01f, -2.82673556e-02f, -6.66359961e-02f, -6.00278489e-02f,
  3.98666263e-02f, -4.74146791e-02f, 7.97753260e-02f, 2.75781099e-02f, 5.20393513e-02f, -5.85092120e-02f, -4.80097570e-02f, -3.28348428e-02f, 9.56431553e-02f, 4.34283875e-02f,
  1.16272522e-02f, 4.02882602e-03f, 1.02140773e-02f, -4.12448607e-02f, 6.49055988e-02f, -1.61262583e-02f, -5.94505817e-02f, -1.28556378e-02f, 1.40645970e-02f, 7.40974918e-02f,
  -6.18749820e-02f, -6.15257695e-02f, -1.62761733e-02f, -2.96799857e-02f, 7.27032451e-03f, -3.50263193e-02f, 4.38810885e-02f, -3.43146548e-02f, 5.35279922e-02f, 8.31072405e-03f,
  -2.32582856e-02f, -8.57789144e-02f, 5.14371842e-02f, -1.77058652e-02f, -1.88490003e-02f, -7.76389474e-03f, 2.68678628e-02f, -5.10505661e-02f, 3.60394455e-02f, 6.82248771e-02f,
  -1.76700833e-03f, -6.47840798e-02f, 4.38570417e-02f, 6.80518374e-02f, -1.93150677e-02f, -1.23333242e-02f, 5.13490029e-02f, 2.94961054e-02f, 6.72111064e-02f, 4.01354916e-02f,
  1.22248670e-02f, -9.43914875e-02f, 7.66805839e-03f, -3.47422101e-02f, -4.65341583e-02f, -1.20830648e-02f, -6.12682328e-02f, -8.71100873e-02f, 2.09589824e-02f, 6.54001310e-02f,
  2.29447447e-02f, -4.39868197e-02f, 1.42297028e-02f, 7.28048384e-02f, -1.51135409e-02f, 6.09428398e-02f, 5.79830399e-03f, 2.61688605e-02f, -2.77796015e-02f, -9.41119157e-03f,
  -1.61612388e-02f, -1.34352624e-01f, -3.74517068e-02f, -9.33689848e-02f, 5.09639718e-02f, 6.16481788e-02f, -1.28683420e-02f, -8.73961449e-02f, 1.04494961e-02f, -5.75874597e-02f,
  1.43427588e-02f, -2.96540558e-02f, -2.46882029e-02f, -2.66849194e-02f, -5.24258837e-02f, -9.65242013e-02f, -6.37176028e-03f, 5.67580154e-03f, -1.80021469e-02f, -1.63830984e-02f,
  -5.04107028e-02f, 5.19058369e-02f, -4.48659696e-02f, -6.11760318e-02f, -1.63202286e-02f, 3.38029349e-03f, -7.49260336e-02f, -2.54364610e-02f, -1.05534922e-02f, -2.50491034e-02f,
  -1.19294859e-02f, -3.66632789e-02f, 1.68297917e-03f, 8.92942920e-02f, 3.10181323e-02f, -2.09732931e-02f, -4.04914469e-02f, -3.21472883e-02f, -1.28714517e-01f, 2.37069391e-02f,
  5.86850308e-02f, -3.83482687e-03f, 1.52874710e-02f, 5.72135672e-02f, 1.46794304e-01f, 1.95485447e-03f, -7.30506405e-02f, 9.87723395e-02f, -4.80331406e-02f, 4.15588170e-02f,
  9.44600329e-02f, 3.40624116e-02f, 2.25489605e-02f, -1.17734699e-02f, -7.35372677e-02f, 1.15235709e-01f, 1.53464854e-01f, 3.01066656e-02f, 4.04624157e-02f, 3.08413692e-02f,
  -1.40360326e-01f, 2.78063826e-02f, -5.04308827e-02f, -1.59910880e-03f, 1.70407780e-02f, 2.12736987e-02f, -2.32912879e-02f, -2.92060315e-03f, 1.10777266e-01f, -3.68402200e-03f,
  -6.64105937e-02f, -6.34548487e-03f, -8.49690437e-02f, -1.67636871e-02f, -8.10850486e-02f, 6.41669612e-03f, -8.90747551e-03f, 1.44164748e-02f, 1.83041263e-02f, -6.54210597e-02f,
  -4.69063185e-02f, -4.56640422e-02f, 8.44562240e-03f, 9.40798372e-02f, 2.20874231e-02f, -6.16805293e-02f, 1.28663685e-02f, -7.15352967e-03f, -8.05471763e-02f, -5.98198362e-02f,
  -8.78079832e-02f, -3.74382399e-02f, -6.20477535e-02f, 5.00912778e-02f, 3.36489454e-02f, 1.30669000e-02f, 4.87001240e-02f, -4.99513559e-02f, 8.81743729e-02f, 1.47375185e-03f,
  2.76518683e-03f, 6.60950039e-03f, 2.26911362e-02f, 4.94862720e-02f, 1.81139912e-02f, -6.55832961e-02f, 3.92036922e-02f, 3.68984230e-02f, 8.19052756e-02f, 4.09317911e-02f,
  -1.14965066e-02f, 4.66690101e-02f, -4.59348336e-02f, 5.20160533e-02f, -8.07112157e-02f, 6.04098663e-02f, 4.48639914e-02f, -3.52346525e-02f, 9.18560401e-02f, 2.84833387e-02f,
  -2.02262029e-02f, 4.97805476e-02f, 4.39742245e-02f, -2.15907954e-02f, 3.78891267e-02f, 4.48054075e-03f, 2.98213586e-02f, -4.55176979e-02f, -4.76698973e-04f, 5.66116022e-03f,
  4.74662893e-02f, 3.06737833e-02f, 1.62354764e-02f, 3.08169727e-03f, -2.99710203e-02f, -1.43572958e-02f, 2.69134790e-02f, 4.78068693e-03f, 6.50244355e-02f, 6.29336536e-02f,
  1.01604678e-01f, -8.04127529e-02f, 8.92458409e-02f, -8.36591944e-02f, -2.56236419e-02f, 1.29819885e-02f, -3.43212858e-03f, 3.41489837e-02f, 5.50861806e-02f, 3.82262953e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  6.91667944e-02f, 1.78418875e-01f, 1.48288339e-01f, 1.60363838e-01f, 1.33936992e-02f, 3.90549097e-03f, 9.69485417e-02f, -4.08736691e-02f, 3.25674415e-02f, -1.49052292e-02f,
  3.19193639e-02f, 5.80425970e-02f, 1.79961637e-01f, -4.70365137e-02f, -7.48281367e-03f, 9.16134566e-02f, 2.18330681e-01f, 1.58586517e-01f, 8.78046304e-02f, 2.27302983e-01f,
  2.07105264e-01f, -3.06634866e-02f, -3.90715115e-02f, 1.06989793e-01f, 1.04455791e-01f, 3.54245082e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  8.38368908e-02f, 1.97101474e-01f, -6.08529337e-02f, 1.61425203e-01f, 2.81384528e-01f, 1.09113730e-01f, -1.05183776e-02f, -2.17650682e-02f, -1.35662049e-01f, -2.17929363e-01f,
  6.90713525e-02f, -3.29011194e-02f, 3.02643911e-03f, 1.85250133e-01f, 7.17401505e-02f, 1.54244617e-01f, 1.05367303e-01f, 1.84759885e-01f, -3.86114378e-04f, -1.00409992e-01f,
  -2.05782473e-01f, -3.13413665e-02f, -1.26706585e-01f, 5.83874434e-02f, -1.48176372e-01f, 1.83784068e-01f, -2.22520661e-02f, -3.59000415e-01f, -1.35613948e-01f, -9.39607993e-02f,
  2.41320699e-01f, 1.74116269e-01f, 2.77607627e-02f, -2.02350676e-01f, -3.70311253e-02f, 1.39999568e-01f, 1.03672542e-01f, -6.29561245e-02f, 3.13387215e-02f, -1.89599723e-01f,
  -1.90641999e-01f, -2.06776951e-02f, 8.91791433e-02f, 5.87456999e-03f, -5.33014126e-02f, -1.66704848e-01f, 6.72603995e-02f, -6.50228560e-02f, 2.72746338e-03f, 6.70439601e-02f,
  -7.61149749e-02f, -9.18250903e-02f, -3.27559486e-02f, -8.43333676e-02f, 2.19256863e-01f, -2.13034302e-01f, -1.31347194e-01f, -8.30640569e-02f, 1.27535015e-02f, 1.10649224e-02f,
  6.52905693e-03f, 1.39957443e-01f, 1.59159914e-01f, -1.08981386e-01f, -3.94781865e-02f, -7.25305546e-03f, 1.41960338e-01f, 5.62512688e-02f, 2.28152171e-01f, -1.50555195e-02f,
  8.38073790e-02f, 1.18261345e-01f, -1.19094789e-01f, 1.14920996e-01f, 8.55875090e-02f, 1.71682388e-01f, -2.86547071e-03f, -7.65890852e-02f, -4.58979793e-02f, 1.30574286e-01f,
  1.06573790e-01f, -9.38067287e-02f, 1.31077826e-01f, -7.66039416e-02f, -5.25105633e-02f, 1.72103494e-01f, -2.05511749e-01f, 4.13961530e-01f, -1.72107488e-01f, 8.85870904e-02f,
  -7.71938562e-02f, -2.12832674e-01f, -8.05004016e-02f, -2.60741524e-02f, 1.89209461e-01f, 1.12435065e-01f, 2.12916285e-01f, -3.72765929e-01f, 7.84784257e-02f, 9.27431211e-02f,
  1.20186932e-01f, 5.11932485e-02f, -1.25975698e-01f, -1.02005698e-01f, -1.33204058e-01f, 3.99720222e-02f, -7.87823945e-02f, -1.61342397e-01f, 3.00575849e-02f, -1.48529202e-01f,
  1.85287431e-01f, 2.17455607e-02f, 5.46162724e-02f, -9.01573896e-02f, -1.50621340e-01f, -4.65639830e-02f, -1.19129263e-01f, 1.34896189e-01f, 3.87541903e-03f, -7.50305951e-02f,
  -4.57775444e-02f, 1.50675744e-01f, -1.51426464e-01f, -8.74707997e-02f, -5.01653664e-02f, -5.55699244e-02f, 8.10847580e-02f, 1.90947838e-02f, 2.97946334e-02f, 1.14033990e-01f,
  -1.96143202e-02f, -2.56350897e-02f, -1.09104805e-01f, -1.37628019e-01f, 6.77636638e-02f, -1.05975665e-01f, -1.47210956e-01f, -4.92836274e-02f, 3.94462794e-02f, 1.89101353e-01f,
  -1.00355163e-01f, 1.68957394e-02f, -1.16007263e-02f, 6.02928624e-02f, -1.72480699e-02f, -5.21261885e-04f, -2.03546938e-02f, -1.82900921e-01f, 2.60430366e-01f, -2.09643304e-01f,
  -1.59884870e-01f, 2.30202883e-01f, 1.22276738e-01f, 2.48944402e-01f, -1.02365509e-01f, -1.21789880e-01f, 3.38250250e-01f, 1.18457608e-01f, -1.70960709e-01f, -3.14125448e-01f,
  7.48382881e-02f, 1.13586880e-01f, 1.04718339e-02f, -9.73416716e-02f, -2.79561430e-01f, 1.59630209e-01f, -2.26635486e-01f, 2.04233542e-01f, 4.37428802e-02f, -6.22157156e-02f,
  1.39650926e-01f, 2.58683953e-02f, -1.41241238e-01f, -1.44018069e-01f, -1.91492826e-01f, -8.59316438e-03f, -1.21140093e-01f, 1.71540126e-01f, -1.26466349e-01f, -8.03045332e-02f,
  -2.76045240e-02f, 1.71653666e-02f, 1.25933498e-01f, 1.56442784e-02f, -1.25927359e-01f, 2.27119640e-01f, -1.67475510e-02f, 6.26698276e-03f, 9.37515572e-02f, -4.17095162e-02f,
  7.18782842e-02f, -7.81291053e-02f, 8.00363272e-02f, -1.79936156e-01f, 1.11588746e-01f, 5.46275601e-02f, 1.81321390e-02f, -3.71184461e-02f, -1.01162359e-01f, -5.83014917e-03f,
  1.18785128e-01f, -2.03721728e-02f, 1.60345033e-01f, 1.17568277e-01f, -3.91904637e-03f, 5.18604741e-03f, 5.55070629e-03f, 1.19305231e-01f, 9.76019949e-02f, 6.81013241e-02f,
  1.64766937e-01f, -2.17339188e-01f, -8.27685967e-02f, 2.28052348e-01f, 1.86140873e-02f, 2.83351094e-01f, 3.34325098e-02f, -1.59314156e-01f, 1.78983271e-01f, -1.63457021e-01f,
  -1.34811878e-01f, 7.54577592e-02f, 3.41515392e-02f, 2.11962745e-01f, 2.94774771e-01f, -2.14666769e-01f, 2.84180697e-02f, 5.18247113e-02f, 3.40761185e-01f, -6.93894550e-02f,
  1.31646007e-01f, -1.08255148e-01f, -1.45601422e-01f, 1.96154222e-01f, -5.88706769e-02f, -9.24042091e-02f, 1.30961195e-01f, -5.52979559e-02f, 1.01452380e-01f, -4.31924500e-02f,
  1.62995338e-01f, -1.35336116e-01f, 1.27611116e-01f, -5.76019809e-02f, -3.58286500e-03f, -5.37106721e-03f, -4.57941415e-03f, 1.36412472e-01f, -1.46153808e-01f, -4.12308192e-03f,
  -1.97469860e-01f, -8.05859715e-02f, 4.58794162e-02f, -5.00547513e-03f, 2.54348963e-02f, -1.64735511e-01f, 3.11414013e-03f, -8.73472020e-02f, -3.60157005e-02f, -1.49214521e-01f,
  9.99588594e-02f, -1.51012272e-01f, 8.69337842e-02f, -2.11696878e-01f, -6.14735223e-02f, 6.67783096e-02f, -1.20424218e-01f, -1.04758881e-01f, -1.38872400e-01f, 1.14627101e-01f,
  7.78855244e-03f, -8.90266970e-02f, 1.10168137e-01f, 9.86246741e-04f, 6.39440417e-02f, -2.18039587e-01f, -4.60344963e-02f, -1.40744552e-01f, -2.58197170e-02f, 2.60854177e-02f,
  -1.54161945e-01f, 2.24486187e-01f, -1.71877354e-01f, -9.24716610e-03f, -1.91179752e-01f, -1.53834233e-02f, 5.76914474e-02f, 1.95180714e-01f, -1.46816984e-01f, -2.11280182e-01f,
  1.55490646e-02f, 2.25793898e-01f, -1.14427321e-01f, -2.81851619e-01f, -6.36462867e-02f, -5.64145818e-02f, -1.11737214e-01f, 3.57092656e-02f, 1.92878231e-01f, -1.12455800e-01f,
  1.00602016e-01f, 2.52393037e-02f, -2.80952845e-02f, 3.22703235e-02f, -9.11383927e-02f, -8.25791657e-02f, 9.06272456e-02f, -3.30850594e-02f, 1.56267919e-02f, 1.59264594e-01f,
  -1.30018741e-01f, -7.04550445e-02f, -2.03022033e-01f, 1.28801405e-01f, 1.78801745e-01f, 1.21469144e-02f, 4.45843581e-03f, -9.59124863e-02f, 1.91812456e-01f, 7.75792301e-02f,
  -5.05482368e-02f, 2.25932105e-03f, 3.11364345e-02f, -1.75118014e-01f, -1.11408541e-02f, -9.71758962e-02f, 6.80139363e-02f, 5.88539168e-02f, -1.00608170e-01f, -1.35970712e-01f,
  1.41667306e-01f, 9.29341018e-02f, -1.79761574e-02f, -6.73201680e-02f, -4.93043251e-02f, -6.96782395e-02f, -6.79110065e-02f, -3.47524695e-02f, 1.64168894e-01f, 7.51926303e-02f,
  -4.75951731e-02f, -2.76111010e-02f, -3.38043422e-02f, -4.81717795e-01f, 4.23703454e-02f, -1.39796972e-01f, -1.21168189e-01f, 1.17595978e-01f, -2.95225605e-02f, -3.15955341e-01f,
  -1.84469953e-01f, 3.69841278e-01f, -4.40736502e-01f, -1.36016369e-01f, 1.11364320e-01f, -1.72832578e-01f, 1.08725995e-01f, 1.08419828e-01f, 1.82612479e-01f, -1.15592130e-01f,
  2.14963257e-01f, -6.98165670e-02f, 1.24775451e-02f, -3.78466137e-02f, -4.49225083e-02f, 8.72288719e-02f, 1.44449770e-01f, 6.13881275e-03f, 6.63588941e-02f, 4.84919325e-02f,
  -7.81302676e-02f, 1.38689250e-01f, -4.23905589e-02f, 2.80139092e-02f, -2.59181261e-01f, -1.06599450e-01f, 2.07911804e-01f, -3.30181904e-02f, -1.28412455e-01f, -4.66730557e-02f,
  3.35462689e-02f, 3.48427631e-02f, 1.43104732e-01f, -2.36123335e-03f, 1.96055137e-02f, -4.90870625e-02f, 1.72958821e-02f, -1.06837042e-01f, 1.72586888e-01f, 7.64834955e-02f,
  -6.54590949e-02f, 4.46137749e-02f, -7.36882314e-02f, -4.52103838e-02f, 4.18906435e-02f, -1.20013254e-02f, -3.75487655e-02f, 1.16978757e-01f, -2.71163788e-02f, 1.05013989e-01f,
  -1.00659765e-02f, -1.53749706e-02f, -2.97080390e-02f, -3.57033312e-01f, -1.94859132e-02f, 8.60239118e-02f, -2.40240604e-01f, 1.82398558e-01f, -2.09227443e-01f, 9.80610959e-03f,
  -9.41179395e-02f, -2.31419921e-01f, 3.87074128e-02f, 7.35072643e-02f, 7.60713443e-02f, 1.46175608e-01f, 5.84595613e-02f, -2.07456440e-01f, 1.51183307e-01f, 1.68478891e-01f,
  4.86935377e-02f, 2.91569438e-02f, -1.51817337e-01f, 2.61033494e-02f, -2.24652454e-01f, 7.51707479e-02f, 1.35506943e-01f, -1.44064948e-01f, -6.89980090e-02f, -2.62363292e-02f,
  -3.15358192e-02f, -2.93142404e-02f, 1.06194198e-01f, -7.00543076e-02f, 5.76240122e-02f, 1.05150556e-02f, 1.39092714e-01f, -1.56835038e-02f, 3.89479324e-02f, 5.59708327e-02f,
  -4.83759679e-02f, 1.98167384e-01f, -7.47982273e-03f, 1.88668650e-02f, -7.22327679e-02f, -1.13991998e-01f, -6.38048723e-02f, -4.62691933e-02f, -1.53059483e-01f, 1.72806174e-01f,
  1.41490415e-01f, -1.05755068e-01f, -1.06795639e-01f, 3.12118493e-02f, -5.25706671e-02f, -6.37504607e-02f, 1.15960510e-02f, -5.86269796e-02f, -6.83203414e-02f, -8.09490010e-02f,
  -1.03126310e-01f, -1.94824368e-01f, 1.26134157e-02f, -1.31364629e-01f, -1.31398901e-01f, -1.16235666e-01f, 2.10868027e-02f, 1.66953251e-01f, -1.42487481e-01f, 1.98517516e-02f,
  -2.82658309e-01f, 1.82046890e-01f, -2.45684251e-01f, -1.67921521e-02f, -6.45439848e-02f, 2.23719403e-01f, 1.36822779e-02f, -6.81601018e-02f, 9.01817083e-02f, -2.64209479e-01f,
  6.16470799e-02f, 2.29567587e-02f, -1.09609045e-01f, -1.19007289e-01f, -6.44290671e-02f, 1.83339864e-01f, -1.20160997e-01f, 1.15852103e-01f, -5.45704998e-02f, -1.74587354e-01f,
  -1.36250451e-01f, -2.60949105e-01f, 7.59610499e-04f, -2.30721980e-02f, 5.05364984e-02f, -1.09066129e-01f, -1.32109895e-02f, -4.27158773e-02f, -1.67642102e-01f, 5.61137013e-02f,
  -8.34576488e-02f, 8.63958895e-02f, 7.66706690e-02f, 7.25385621e-02f, 2.56445725e-02f, 1.38778672e-01f, -1.68765396e-01f, 7.40004331e-02f, 4.97480109e-02f, -8.22102875e-02f,
  6.01426437e-02f, -1.26450151e-01f, 1.73593163e-01f, 7.58036152e-02f, 1.94569796e-01f, -9.79839936e-02f, -1.01445727e-01f, 2.11532097e-02f, -6.71227723e-02f, -1.00393347e-01f,
  1.04418404e-01f, 4.60972413e-02f, 9.63278115e-02f, 2.76618004e-01f, 8.91082436e-02f, -1.36726210e-02f, 9.64435339e-02f, -5.08756302e-02f, 2.92743314e-02f, -4.59250659e-02f,
  1.55026153e-01f, 1.57770708e-01f, -2.91984469e-01f, 1.69673726e-01f, -1.54711053e-01f, -3.14982474e-01f, 3.06813642e-02f, 3.48664150e-02f, -5.25069945e-02f, 1.64815336e-01f,
  2.18687624e-01f, -3.36491823e-01f, -2.94296980e-01f, 2.61430740e-01f, -1.66683376e-01f, -1.09138705e-01f, 1.40999198e-01f, -1.24730468e-01f, 6.35774285e-02f, 2.32348099e-01f,
  1.63912132e-01f, -1.24234505e-01f, 9.29356664e-02f, 4.35911827e-02f, 4.62225415e-02f, -5.50164320e-02f, -3.82224121e-03f, 1.28029920e-02f, -3.10822856e-02f, 1.36183985e-02f,
  1.16391622e-01f, 3.18228044e-02f, 8.83084834e-02f, -1.06122449e-01f, 1.18159443e-01f, -1.53416499e-01f, 1.28996316e-02f, 1.96584955e-01f, 8.69880319e-02f, 1.15934744e-01f,
  -9.85518768e-02f, -4.26101349e-02f, -2.46457309e-02f, 5.32090366e-02f, 6.69175759e-02f, -4.98746941e-03f, -1.20302357e-01f, 1.08449794e-01f, 8.03617686e-02f, 7.95127526e-02f,
  -2.41243944e-01f, -5.89650497e-02f, -9.18457881e-02f, 1.05007678e-01f, 1.34732142e-01f, 4.85719182e-02f, -6.88664208e-04f, -5.28607555e-02f, -6.63019866e-02f, -7.83974081e-02f,
  -9.52255875e-02f, -1.22108318e-01f, 2.20371876e-02f, 1.27620220e-01f, -1.54910043e-01f, 5.52949458e-02f, -4.21855003e-02f, 2.78306752e-01f, 1.19895563e-01f, -6.07065931e-02f,
  2.56971508e-01f, -1.56786740e-01f, 4.26212788e-01f, 1.18129387e-01f, -3.96578014e-02f, 1.37638599e-01f, 1.16996981e-01f, -2.20535889e-01f, 1.70789152e-01f, 4.25200045e-01f,
  -2.74978671e-02f, 1.63439810e-01f, -1.51019078e-02f, -1.27645865e-01f, -3.89726013e-02f, -1.97350606e-01f, 1.63516760e-01f, 7.99370259e-02f, -7.24523067e-02f, 6.10730015e-02f,
  7.04767853e-02f, 1.50524229e-01f, -1.84206530e-01f, 6.68757707e-02f, 1.61105067e-01f, 2.72210035e-02f, 6.70324713e-02f, -1.04348794e-01f, 3.54556851e-02f, -3.22547108e-02f,
  -4.81472053e-02f, 2.05112368e-01f, 7.33060250e-03f, -2.55784005e-01f, 1.21853342e-02f, 2.22306661e-02f, 2.74575595e-02f, -6.19042292e-02f, -1.94482833e-01f, -4.53192964e-02f,
  -1.31747559e-01f, -5.19750565e-02f, 1.57548748e-02f, 1.25351891e-01f, -2.23110408e-01f, 3.86622697e-02f, 2.92186309e-02f, -1.32327422e-01f, -9.91119593e-02f, -5.44333681e-02f,
  1.45564839e-01f, -2.61479132e-02f, -1.14467829e-01f, -9.54938903e-02f, -7.59726912e-02f, -1.47582479e-02f, 4.89446288e-03f, -5.27127273e-02f, -8.04670900e-02f, 2.35413864e-01f,
  -2.27419674e-01f, 2.15984240e-01f, 1.06188521e-01f, -8.80703032e-02f, 2.78481305e-01f, -2.74502933e-02f, 3.03231388e-01f, 2.59655826e-02f, 5.33195361e-02f, -7.86360651e-02f,
  -1.45492256e-01f, -1.99701145e-01f, -3.77749540e-02f, 1.99730217e-01f, 7.37103969e-02f, -1.67937115e-01f, 1.17032126e-01f, 2.02383965e-01f, 1.04547255e-01f, -1.05881887e-02f,
  1.35872617e-01f, -3.35174352e-02f, 5.26080802e-02f, -7.28818700e-02f, 7.00625703e-02f, 1.16401285e-01f, -1.15808994e-01f, 8.75088051e-02f, -1.01599373e-01f, 9.61155295e-02f,
  1.68710187e-01f, 9.77664590e-02f, 1.20432712e-01f, 7.67937079e-02f, 8.71820822e-02f, -1.77863874e-02f, 2.50231981e-01f, -2.76537985e-01f, -2.43674114e-01f, 9.64725204e-03f,
  1.11343838e-01f, 8.88194591e-02f, 5.79065122e-02f, -8.76086298e-03f, 1.30309582e-01f, -5.28525151e-02f, 2.98496317e-02f, -1.14831477e-01f, 7.32730255e-02f, 9.83400345e-02f,
  -2.40180027e-02f, 1.02578692e-01f, 7.43368343e-02f, -5.78503385e-02f, -1.19080078e-02f, -1.02668712e-02f, -1.54591098e-01f, 3.50241482e-01f, -4.55562782e-04f, -9.90169942e-02f,
  1.96129754e-01f, 9.08798911e-03f, 1.76138710e-02f, -2.21534237e-01f, 6.77074911e-03f, -1.18911982e-01f, 4.85891625e-02f, 1.06982805e-01f, -1.93287358e-02f, 5.82085364e-02f,
  -3.25955719e-01f, -1.38967633e-01f, -2.56839573e-01f, -8.94280747e-02f, -7.40890503e-02f, 2.68537849e-01f, -1.95024740e-02f, -3.07469755e-01f, 3.83490808e-02f, 2.96699554e-02f,
  -1.99211627e-01f, -1.64908096e-01f, 1.34996176e-01f, 2.90933430e-01f, -3.33394445e-02f, 2.28796005e-01f, 1.25098467e-01f, -1.49817700e-02f, 5.85202686e-03f, 3.36244255e-02f,
  -7.79718161e-02f, -4.97082546e-02f, -9.31747556e-02f, -1.24917917e-01f, 1.85092151e-01f, -7.77927935e-02f, 7.33103529e-02f, -6.71685711e-02f, -2.46795952e-01f, 2.81331339e-03f,
  -1.84877053e-01f, 1.93010107e-01f, 1.90416172e-01f, 4.33005355e-02f, -1.19153559e-01f, -8.13562423e-02f, 9.68221948e-02f, 2.49489844e-02f, -1.33703932e-01f, 9.64884385e-02f,
  -1.26576930e-01f, -5.21946251e-02f, 6.71185330e-02f, -1.39147118e-01f, 5.79139180e-02f, 5.68426847e-02f, -3.58406678e-02f, 1.72829464e-01f, -4.64484952e-02f, 1.29118410e-03f,
  1.78344801e-01f, -7.20737800e-02f, 6.36000633e-02f, 4.27258424e-02f, 3.48881558e-02f, 7.67671838e-02f, -5.17540239e-02f, -1.25620306e-01f, 2.89583504e-01f, -2.57691622e-01f,
  -2.38710746e-01f, -1.85592353e-01f, -2.00202137e-01f, 1.25477672e-01f, -3.28592271e-01f, 2.27044344e-01f, 1.22328354e-02f, 7.84107149e-02f, -1.26488611e-01f, -5.63585795e-02f,
  -5.72353080e-02f, -1.07685491e-01f, 1.86263755e-01f, 1.78036392e-01f, -2.28273094e-01f, -1.74920395e-01f, -1.22926220e-01f, 1.45685766e-02f, 7.06549063e-02f, 6.79529756e-02f,
  8.52010921e-02f, 1.25837237e-01f, 1.05357766e-01f, -1.28990054e-01f, -1.36812829e-04f, -1.81443095e-01f, -2.47759037e-02f, 1.50468596e-03f, -2.66642511e-01f, 8.79378170e-02f,
  -1.28586039e-01f, -2.84458902e-02f, -1.47389561e-01f, -9.67027694e-02f, 4.59239706e-02f, 2.23989010e-01f, 1.95173368e-01f, 6.16544066e-03f, -9.41189006e-02f, 1.12757675e-01f,
  -4.05580029e-02f, 2.16125436e-02f, 1.27051368e-01f, 1.92051485e-01f, -2.95370184e-02f, -7.05547929e-02f, -2.01527372e-01f, 2.60767527e-02f, 1.25565594e-02f, -5.52771017e-02f,
  -1.01527944e-01f, 1.09861940e-01f, 8.84888396e-02f, 2.85905749e-01f, -8.62943474e-03f, 3.65085304e-02f, 2.70904638e-02f, -4.98430384e-03f, 8.13066214e-03f, -9.02197585e-02f,
  -8.81925076e-02f, -1.31728321e-01f, -1.56389087e-01f, 9.36898589e-02f, -1.67023808e-01f, 5.75962029e-02f, 1.66837066e-01f, 8.96571875e-02f, 1.27838865e-01f, -9.25322324e-02f,
  4.38698798e-01f, -8.74094740e-02f, -3.12914908e-01f, -9.50228795e-02f, -2.95005310e-02f, -4.14040871e-03f, -1.71682909e-02f, -5.39485961e-02f, -1.09663777e-01f, 3.31146777e-01f,
  8.72844905e-02f, 4.73136865e-02f, -1.23533480e-01f, -1.22074604e-01f, 7.96136633e-02f, -1.52527876e-02f, -1.11512924e-02f, 5.66781163e-02f, -1.81479543e-01f, 1.71385169e-01f,
  1.14378706e-01f, 1.78365096e-01f, 1.34410709e-01f, -1.19064018e-01f, 9.00000408e-02f, -2.27486081e-02f, 2.57297695e-01f, 2.22479433e-01f, 8.55489671e-02f, 2.33706892e-01f,
  -5.72932214e-02f, 7.55063593e-02f, -2.46848613e-02f, -9.37103629e-02f, -1.40118361e-01f, -2.99867373e-02f, 1.59783736e-02f, 2.79828817e-01f, 1.67761326e-01f, -1.02321386e-01f,
  1.70070902e-02f, 7.72672100e-03f, -5.68263419e-03f, -6.24024309e-02f, -4.23491523e-02f, 1.58750862e-01f, 2.67255157e-01f, 2.08547071e-01f, 2.28770316e-01f, 3.31413709e-02f,
  1.27772763e-01f, 1.77195355e-01f, -2.27815565e-02f, 1.59448057e-01f, -6.56809732e-02f, -7.83193707e-02f, -4.60519753e-02f, 1.90304313e-02f, -2.16436446e-01f, 1.56682968e-01f,
  1.03827886e-01f, 5.59939183e-02f, 1.27091795e-01f, -8.44132248e-03f, 3.47278357e-01f, -2.45159015e-01f, -2.97385216e-01f, -4.59849387e-02f, 3.82103696e-02f, -1.16152115e-01f,
  7.31069893e-02f, -7.56823346e-02f, 6.88501224e-02f, 3.48366231e-01f, 2.72480678e-02f, -2.02238753e-01f, -6.20731190e-02f, -1.97365716e-01f, -8.40754434e-02f, 6.97707683e-02f,
  -1.20206229e-01f, 6.89146742e-02f, -1.88272685e-01f, -1.18511915e-01f, 1.16220035e-01f, 4.92026247e-02f, -1.30352333e-01f, -6.63060173e-02f, 8.92602429e-02f, -7.35132843e-02f,
  1.32329851e-01f, 1.23770966e-03f, 2.26918831e-01f, 1.06267244e-01f, -2.19579563e-02f, -1.13748126e-01f, 1.37314321e-02f, 6.23353943e-02f, -1.77384749e-01f, -1.72496274e-01f,
  4.45940159e-02f, 8.10917541e-02f, 1.31948248e-01f, 8.45975131e-02f, 1.97382554e-01f, 1.06522642e-01f, 1.06661372e-01f, 6.47746772e-02f, 1.93737634e-02f, -1.65230587e-01f,
  3.41520309e-02f, -7.96337798e-02f, 6.10852540e-02f, 4.81172046e-03f, -7.67786205e-02f, 1.46577165e-01f, -2.60405876e-02f, 1.26118332e-01f, -7.82141611e-02f, -9.73238796e-02f,
  -2.03732267e-01f, -5.81790991e-02f, -5.55499010e-02f, -1.82645038e-01f, -8.55574980e-02f, 1.01308703e-01f, -1.85668066e-01f, -2.00887192e-02f, -3.36037725e-02f, -1.64498001e-01f,
  1.23896390e-01f, 2.25602865e-01f, -2.73792773e-01f, -2.33465999e-01f, 2.51739860e-01f, 4.20429334e-02f, 4.46121693e-02f, 8.69201422e-02f, -2.35538036e-02f, -1.86038330e-01f,
  1.52616978e-01f, 1.01839222e-01f, 1.50236711e-01f, -4.42736708e-02f, 8.32623616e-02f, -5.02469614e-02f, 7.62406588e-02f, -1.19979307e-01f, -1.28082111e-01f, 9.36990529e-02f,
  3.59638967e-02f, -1.12284692e-02f, -9.89846289e-02f, 5.45235761e-02f, -1.65831119e-01f, -4.72074933e-02f, 1.44811288e-01f, -8.84195883e-03f, 1.12415604e-01f, 7.43246898e-02f,
  -9.45634767e-02f, 7.32878670e-02f, 1.89253390e-01f, -8.76636133e-02f, -1.17293790e-01f, -5.58200441e-02f, 8.18198472e-02f, -7.68135265e-02f, 4.54405844e-02f, 9.79529768e-02f,
  7.65730217e-02f, 1.38442665e-01f, 4.20031771e-02f, -1.36001512e-01f, -1.44231245e-01f, -2.77693849e-02f, 1.88365718e-03f, -1.41036958e-01f, -7.70485923e-02f, -9.98391509e-02f,
  -1.34907246e-01f, -1.26137108e-01f, -5.80528639e-02f, -1.65811136e-01f, -6.79320320e-02f, 9.32132155e-02f, -1.02906100e-01f, 2.19420061e-01f, -2.14929655e-01f, -1.19585380e-01f,
  -9.15395766e-02f, -8.27406421e-02f, -2.53004909e-01f, 4.85693216e-02f, 1.88722745e-01f, 7.23555833e-02f, 2.03671575e-01f, -1.37871698e-01f, -1.44358441e-01f, 1.90792426e-01f,
  1.03034809e-01f, 1.77691709e-02f, 5.01930006e-02f, 1.08894363e-01f, -1.78346440e-01f, 1.47396430e-01f, -5.65379411e-02f, -2.60933906e-01f, -5.24955839e-02f, 8.33307207e-02f,
  -7.50708058e-02f, -2.44037472e-02f, 6.73671812e-02f, -1.23463482e-01f, -1.48458764e-01f, -2.76627392e-02f, 9.00157467e-02f, 2.34576836e-02f, -7.80984908e-02f, 1.48048148e-01f,
  -1.34749964e-01f, -1.66936778e-02f, -2.93574808e-03f, 6.19874783e-02f, -1.20722674e-01f, -1.49141118e-01f, 8.83308798e-03f, -2.24594329e-03f, 1.18608736e-01f, 3.29980664e-02f,
  6.12871461e-02f, -3.78394797e-02f, -4.51335870e-02f, 1.45348862e-01f, -1.27763584e-01f, 1.84906036e-01f, -4.12966609e-02f, -5.50199747e-02f, 6.92890584e-02f, -2.09550541e-02f,
  7.74522126e-02f, 1.34980574e-01f, -1.02880478e-01f, -9.48624909e-02f, 2.87413280e-02f, 3.73268723e-02f, 9.56061482e-02f, -1.33552805e-01f, -1.11695506e-01f, 2.35231310e-01f,
  9.06561613e-02f, 1.82854012e-01f, -7.06068724e-02f, -2.24034652e-01f, 1.95336640e-01f, -1.98539376e-01f, -5.48420921e-02f, -8.91682655e-02f, 1.81506336e-01f, 1.11603558e-01f,
  2.90485770e-01f, -2.58119792e-01f, 1.02903053e-01f, -3.31996419e-02f, 3.62590253e-01f, 8.84742066e-02f, -1.43643245e-02f, -1.02830045e-01f, -2.27204803e-02f, 1.16206139e-01f,
  -1.65392876e-01f, -6.78311586e-02f, 2.74158432e-03f, 1.88367870e-02f, -3.28319184e-02f, -1.49876019e-02f, 5.88745177e-02f, -3.94247808e-02f, -9.73201394e-02f, -1.05841206e-02f,
  -3.27916406e-02f, -6.34216815e-02f, 1.47641256e-01f, 7.95286447e-02f, 1.46079110e-02f, -1.93552300e-01f, -2.17728555e-01f, -1.04106136e-01f, -1.15387455e-01f, -3.91731225e-02f,
  -1.70453459e-01f, -4.97571975e-02f, -9.87989753e-02f, 7.95663819e-02f, 1.34650674e-02f, -9.31649208e-02f, -1.17095374e-01f, -1.34232759e-01f, 4.32608351e-02f, -1.58305451e-01f,
  -3.13463733e-02f, 3.62600908e-02f, 1.86831485e-02f, 2.61422843e-01f, -2.44366447e-03f, -8.94438401e-02f, -1.15824863e-01f, -1.06190115e-01f, -1.12055279e-01f, 1.16993971e-02f,
  -6.06761575e-02f, -1.16368160e-01f, 1.27388418e-01f, -2.10643858e-01f, -2.87983805e-01f, 3.47447731e-02f, -1.87881067e-02f, 1.55574650e-01f, -1.42556235e-01f, 1.83986977e-01f,
  4.74420130e-01f, -2.51945615e-01f, -2.83775717e-01f, -8.92507471e-03f, -1.09392069e-01f, 7.50652626e-02f, 1.60393104e-01f, -1.74152985e-01f, -1.37772113e-01f, 1.81961253e-01f,
  -2.04708606e-01f, 7.53376335e-02f, 1.52877979e-02f, -2.07807064e-01f, -7.37285614e-02f, 9.44916010e-02f, -1.61331505e-01f, -5.13273031e-02f, -1.12945437e-01f, -2.93506812e-02f,
  -9.72930863e-02f, 2.39406601e-01f, -3.55634764e-02f, 9.61433426e-02f, 7.51738250e-02f, -8.19001049e-02f, 1.82637915e-01f, 1.05143271e-01f, 1.16486832e-01f, 2.18333066e-01f,
  7.45584723e-03f, 7.54053667e-02f, -2.94120740e-02f, -1.18080489e-01f, -7.43322354e-03f, 5.56528643e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.87889487e-01f, 1.64383873e-01f, 6.76588640e-02f, 1.13247009e-02f, -4.84338962e-02f, -3.35280597e-02f, 6.03605248e-02f, 9.52724293e-02f, 4.64414060e-02f, -4.95051667e-02f,
  -3.92447785e-02f, 1.41948521e-01f, 3.59877273e-02f, -8.72874483e-02f, 1.21887065e-01f, -4.97902595e-02f, -1.78361721e-02f, -1.11919880e-01f, -6.07637800e-02f, -4.50466536e-02f,
  5.37130795e-02f, -9.86141860e-02f, 6.50938377e-02f, -4.13658582e-02f, -1.29340142e-01f, 1.52907252e-01f, -1.82270840e-01f, -9.80237126e-02f, 3.89826074e-02f, -1.65805712e-01f,
  -4.43675965e-02f, 1.78534120e-01f, -1.17631674e-01f, -1.83404818e-01f, 4.43646610e-02f, -9.93634239e-02f, -2.01804101e-01f, 1.74462214e-01f, -7.58619830e-02f, 2.76070982e-01f,
  8.24190825e-02f, 4.84363139e-02f, 2.93715717e-03f, 7.96935149e-03f, 8.23331922e-02f, 5.60681596e-02f, -4.79886234e-02f, 4.82362621e-02f, -1.26103908e-01f, 3.95331420e-02f,
  1.53079882e-01f, -1.09993577e-01f, -8.14420655e-02f, 1.07700542e-01f, -5.65447919e-02f, 3.23180296e-02f, -9.83274058e-02f, 1.22212008e-01f, -1.15250371e-01f, 2.74220556e-02f,
  -8.21808204e-02f, -5.24291173e-02f, 7.65614659e-02f, 8.16756412e-02f, -1.70306452e-02f, 1.71953693e-01f, 1.00166410e-01f, 1.07276239e-01f, 6.80780783e-02f, -6.15299158e-02f,
  1.93995580e-01f, -8.67741257e-02f, 6.86766282e-02f, -5.49865291e-02f, 1.70893863e-01f, -8.40121359e-02f, -6.26156777e-02f, 7.20016286e-03f, 1.16668507e-01f, -8.83092266e-03f,
  -9.05968174e-02f, 1.60905689e-01f, 2.06315462e-02f, 1.29143387e-01f, -1.27896458e-01f, -1.96102764e-02f, -4.64083478e-02f, -1.68426469e-01f, 2.54169432e-03f, 1.35120690e-01f,
  -5.26686311e-02f, -6.31926358e-02f, 1.31660461e-01f, -5.34915626e-02f, -7.28971213e-02f, -2.54205186e-02f, -1.27551973e-01f, 6.73227832e-02f, 3.52278128e-02f, -1.34811565e-01f,
  4.02449444e-02f, -3.36909597e-03f, -6.97215870e-02f, -2.55206991e-02f, 1.85498700e-01f, -8.72246251e-02f, -2.30083559e-02f, 1.19740188e-01f, -5.98829910e-02f, 7.55715668e-02f,
  -1.29351526e-01f, -6.16688430e-02f, -1.30995169e-01f, -4.45258617e-02f, -1.00080505e-01f, 1.79024544e-02f, 3.83415110e-02f, -9.71522182e-02f, 1.24615870e-01f, -1.53778821e-01f,
  2.34490901e-01f, -7.75629096e-03f, -4.38463874e-03f, -2.24722531e-02f, -6.11085147e-02f, 6.73823431e-02f, -6.75383657e-02f, 1.14539847e-01f, -5.58066778e-02f, 1.92569092e-01f,
  -3.81449871e-02f, 3.11116893e-02f, 2.17016619e-02f, 3.92575599e-02f, 1.46063581e-01f, 2.12168187e-01f, 1.21542111e-01f, 1.45815790e-01f, 1.38851926e-01f, -1.28164701e-02f,
  2.69327573e-02f, -7.51663968e-02f, 1.00545011e-01f, 8.23614970e-02f, -6.21169098e-02f, 7.87233710e-02f, 1.79194715e-02f, 1.07565910e-01f, -1.83346257e-01f, 1.04399435e-01f,
  9.95808979e-04f, 1.02074102e-01f, -2.62382422e-02f, -1.87219858e-01f, 1.21081777e-01f, 8.04953948e-02f, -6.63744956e-02f, -1.24839172e-01f, 9.20768678e-02f, -2.78097764e-02f,
  -9.63072628e-02f, 1.42065853e-01f, -1.93590283e-01f, -1.77018300e-01f, 5.94067723e-02f, 2.45273873e-01f, 1.15300104e-01f, 2.73333341e-02f, 3.09643205e-02f, -1.31646916e-01f,
  -1.11351483e-01f, -1.01783827e-01f, 8.58678669e-02f, -1.41950771e-02f, 1.43138394e-01f, 8.95618126e-02f, 1.74806044e-01f, -3.42045613e-02f, 4.61375304e-02f, 1.50950655e-01f,
  6.94653764e-02f, -1.14134979e-02f, 1.64524630e-01f, -7.36498833e-02f, 1.18287124e-01f, -9.07528028e-02f, 3.38104274e-03f, 8.14796835e-02f, -2.37994250e-02f, -1.91850588e-03f,
  7.41663668e-03f, -2.65478734e-02f, 2.14315981e-01f, 1.50381729e-01f, 1.24313831e-01f, 2.61071533e-01f, 3.90231535e-02f, 2.05102101e-01f, 5.73476180e-02f, 1.25580639e-01f,
  8.82963687e-02f, 3.82855460e-02f, 1.82838932e-01f, 4.56884876e-02f, -1.02035306e-01f, 1.82932988e-01f, 7.19561651e-02f, 6.47623315e-02f, 8.23709667e-02f, 2.47748625e-02f,
  1.72238156e-01f, 2.51203984e-01f, -1.21804494e-02f, 5.50742410e-02f, 2.08286151e-01f, -7.25291222e-02f, 2.28534088e-01f, 1.24863364e-01f, 1.94004163e-01f, -2.12373495e-01f,
  -4.81342077e-02f, 2.37986669e-01f, -1.49880692e-01f, -1.81147158e-01f, 1.31020308e-01f, 1.62126958e-01f, 2.97186747e-02f, -1.65303633e-01f, 6.52216300e-02f, 4.12559882e-02f,
  -1.59413889e-01f, 3.29036504e-01f, -1.29852399e-01f, -1.82252720e-01f, 1.73399603e-04f, 2.56868064e-01f, -2.26021353e-02f, 5.47520146e-02f, -5.27708046e-02f, 2.14015484e-01f,
  1.75575837e-02f, 2.30189323e-01f, 8.15365463e-02f, -1.02910809e-01f, 9.23735201e-02f, -1.00629397e-01f, 2.41204888e-01f, 1.04334876e-01f, 5.72448075e-02f, -1.63260940e-02f,
  1.35858282e-01f, 1.15050249e-01f, -5.87011240e-02f, 1.03278384e-01f, -7.53355324e-02f, 1.43204704e-01f, -1.37774302e-02f, -3.93409617e-02f, 7.15828314e-02f, -6.36951253e-02f,
  -1.45737054e-02f, 1.67202219e-01f, 9.66794193e-02f, 4.41623144e-02f, 9.73403901e-02f, -1.07114390e-01f, 1.97227523e-01f, -1.37037322e-01f, 7.25428620e-03f, 1.81598797e-01f,
  9.72836539e-02f, 1.81746542e-01f, 1.40421063e-01f, -1.35797739e-01f, 1.30603820e-01f, -2.78120060e-02f, -2.41411656e-01f, 5.33381552e-02f, 2.50672132e-01f, 1.40490234e-02f,
  -1.03361569e-01f, -1.36983469e-01f, -2.07068864e-02f, -1.00717478e-01f, -1.70261085e-01f, 4.68093865e-02f, 1.23452976e-01f, 2.25952923e-01f, 8.93744379e-02f, -2.13506564e-01f,
  2.70752534e-02f, -3.75199206e-02f, 4.02413681e-02f, 2.68873721e-02f, 1.57955080e-01f, 1.68176696e-01f, -6.67209625e-02f, 5.00526652e-02f, 4.85992283e-02f, 3.09496168e-02f,
  -6.92634135e-02f, 1.36509761e-01f, 4.58147340e-02f, 1.66320056e-01f, -8.60054940e-02f, -1.11196414e-02f, 2.57029384e-01f, 6.26240149e-02f, -6.55291900e-02f, 1.23547867e-01f,
  -8.74770805e-02f, -8.99780765e-02f, 5.68005666e-02f, -1.03671908e-01f, 1.17584154e-01f, 2.66303923e-02f, -5.05332388e-02f, -4.41027470e-02f, -8.34005624e-02f, 1.56668760e-02f,
  1.77855864e-01f, -9.33506340e-02f, 4.70855199e-02f, 1.31136477e-02f, -2.64647324e-02f, -7.40993917e-02f, -1.07426353e-01f, 2.57180911e-02f, -1.28806233e-02f, 1.40956283e-01f,
  8.90565589e-02f, 1.13208212e-01f, -4.84721176e-02f, 1.31404521e-02f, -1.06283382e-01f, 4.42147255e-04f, -3.44581786e-03f, -1.06781788e-01f, 1.69606268e-01f, -5.88166453e-02f,
  -1.49395734e-01f, 8.57094303e-02f, 1.98997512e-01f, -2.79181218e-03f, 7.47262388e-02f, 2.70393565e-02f, 1.22410253e-01f, -1.79900408e-01f, 1.62750110e-02f, 1.14518262e-01f,
  -7.39171356e-02f, 1.37528852e-01f, 9.32296962e-02f, -3.21290269e-02f, 3.28705609e-02f, -7.76862502e-02f, -1.17251948e-02f, -9.91751775e-02f, 1.63347796e-01f, 1.09939858e-01f,
  9.41061378e-02f, 8.13970193e-02f, 1.01457439e-01f, -6.91966116e-02f, -1.82454586e-02f, -5.16392924e-02f, 7.51845390e-02f, 3.88078555e-03f, -4.91124615e-02f, -8.40188712e-02f,
  1.63735002e-01f, -6.42111450e-02f, -3.76666524e-02f, 4.82267812e-02f, -6.85807467e-02f, -4.71871309e-02f, 1.14962675e-01f, -6.12784512e-02f, -2.71428470e-03f, 7.47117847e-02f,
  9.66938138e-02f, -5.93681913e-03f, -5.33154644e-02f, 1.08347245e-01f, 2.51837969e-02f, -1.07229933e-01f, 5.11533134e-02f, 2.84236344e-03f, -1.41358197e-01f, -4.29875813e-02f,
  1.22168669e-02f, 1.03238106e-01f, 7.36128762e-02f, 2.78031498e-01f, 1.35650542e-02f, 1.64065570e-01f, 5.02507612e-02f, 1.47657961e-01f, 8.05383623e-02f, 1.20284706e-01f,
  5.75757995e-02f, 1.26619160e-03f, 1.92523047e-01f, 3.48374508e-02f, 2.04103753e-01f, -8.83782580e-02f, 2.17933357e-01f, -1.02085985e-01f, 1.29179984e-01f, -8.97446647e-02f,
  4.83100601e-02f, 1.57400921e-01f, -6.02094829e-02f, 2.25578412e-01f, -3.41863371e-02f, 5.81852086e-02f, -1.25865266e-02f, 2.71762848e-01f, -1.75214678e-01f, -4.73546274e-02f,
  -1.85931578e-01f, -1.82446614e-01f, 2.05495849e-01f, 3.57933223e-01f, 1.09208353e-01f, 2.41889372e-01f, 2.51625273e-02f, 5.55890054e-02f, 1.29241515e-02f, 7.04899654e-02f,
  -4.60707135e-02f, 6.03146292e-02f, -5.56024797e-02f, 1.25813082e-01f, 2.69032001e-01f, -2.10960377e-02f, -6.20085606e-03f, 1.64913535e-01f, -1.36012390e-01f, 2.80529052e-01f,
  -1.02920644e-01f, 1.31927267e-01f, 1.59540176e-01f, -2.28290781e-02f, -9.73868966e-02f, -7.42646083e-02f, 1.05532713e-01f, 3.46339345e-02f, 5.01742698e-02f, -4.26938236e-02f,
  -6.50618374e-02f, 2.00966019e-02f, 1.36873722e-01f, -4.76214588e-02f, 5.89938089e-02f, 1.09329946e-01f, 5.80348037e-02f, -7.36203790e-02f, -4.13847566e-02f, -6.04030155e-02f,
  -1.40525438e-02f, 5.23747131e-03f, -1.09877177e-01f, -9.96997356e-02f, -5.65561429e-02f, -1.00856051e-01f, -7.02335611e-02f, -4.88574132e-02f, -6.78419024e-02f, 8.49351957e-02f,
  2.73496602e-02f, -8.57138634e-02f, -5.40004075e-02f, 5.04947454e-02f, -1.40080869e-01f, 1.06904812e-01f, 1.99433547e-02f, -5.24318442e-02f, -9.00627747e-02f, 1.11510932e-01f,
  1.04423858e-01f, 2.35193428e-02f, -1.09582394e-01f, -1.21138975e-01f, 4.75093424e-02f, -1.05426991e-02f, -1.20427921e-01f, -5.29188151e-03f, 6.35991991e-02f, 1.63449317e-01f,
  1.14208646e-01f, 8.56075063e-03f, 4.45964299e-02f, -2.26505827e-02f, -7.28815347e-02f, -7.71555379e-02f, -4.69358377e-02f, 7.51525909e-02f, -1.74365658e-02f, -1.89826395e-02f,
  -4.22212202e-03f, 9.33487937e-02f, 9.61810574e-02f, 2.79615019e-02f, -8.37855712e-02f, -9.09374654e-02f, 1.29748270e-01f, -9.24472362e-02f, 5.02905622e-02f, 5.03401048e-02f,
  1.13289408e-01f, -8.60961899e-02f, -2.29578316e-02f, 1.55266151e-01f, 3.90639938e-02f, 5.37059642e-02f, 9.23341587e-02f, 1.64509505e-01f, 1.05228648e-01f, 3.69728170e-02f,
  1.45116523e-01f, 4.56291288e-02f, 5.17546125e-02f, 5.23048155e-02f, 7.58730993e-02f, 1.28110081e-01f, 6.69518709e-02f, 2.09080935e-01f, -3.71414237e-02f, -9.21999279e-04f,
  1.28520519e-01f, 9.70560387e-02f, -1.26049099e-02f, 7.48688430e-02f, 9.31300670e-02f, -1.05719581e-01f, -5.43827266e-02f, 2.93163899e-02f, -8.57260600e-02f, 3.78420809e-03f,
  -1.07606165e-01f, -7.72840306e-02f, -1.16447829e-01f, 2.07427099e-01f, -2.69280970e-01f, 2.40433235e-02f, 7.02052265e-02f, -1.15198255e-01f, 1.71640620e-01f, -6.57451153e-02f,
  1.10111259e-01f, -3.03896200e-02f, 2.03075707e-01f, 6.04191385e-02f, -1.13794217e-02f, -1.55223804e-02f, 1.01352997e-01f, -9.58014950e-02f, 2.07805410e-01f, -8.95337686e-02f,
  -4.64600883e-02f, -1.25464961e-01f, 2.53102873e-02f, 2.23368425e-02f, -4.84353118e-02f, 6.66524470e-02f, -9.43737254e-02f, -1.17464647e-01f, 2.61798739e-01f, -1.98268563e-01f,
  1.00719348e-01f, -5.69427907e-02f, 1.61827520e-01f, 2.61232723e-02f, -8.70673954e-02f, -7.16623515e-02f, 2.99878895e-01f, 2.36916885e-01f, 2.29694381e-01f, 1.89392507e-01f,
  1.60802528e-01f, 2.81884760e-01f, 1.82776928e-01f, 2.71357894e-01f, 1.84458598e-01f, -6.66273162e-02f, 1.06358774e-01f, -1.67643428e-02f, 3.92892323e-02f, 2.54189700e-01f,
  -6.72336370e-02f, 8.34231600e-02f, 2.58111268e-01f, 2.03614652e-01f, 1.27384320e-01f, -1.17048949e-01f, -1.35459423e-01f, 1.52931601e-01f, -2.33295076e-02f, 9.46923159e-03f,
  -5.97400069e-02f, -9.93971601e-02f, 1.12186946e-01f, -3.47445041e-01f, -1.23920575e-01f, 6.23178342e-03f, 2.37621628e-02f, 7.88640752e-02f, 2.22342670e-01f, -1.50189981e-01f,
  -5.62859848e-02f, 8.47446248e-02f, 3.01383972e-01f, -9.12492126e-02f, -7.15924799e-02f, -7.16654435e-02f, -2.07553416e-01f, 7.61030093e-02f, 1.68626249e-01f, -5.15924068e-03f,
  -5.20992130e-02f, -1.42953053e-01f, 8.65955576e-02f, 1.03333257e-01f, -7.96411484e-02f, 1.82171874e-02f, 1.21086091e-01f, -1.11577511e-01f, 1.51768059e-01f, -7.15905428e-02f,
  1.35190323e-01f, -1.92217171e-01f, 4.42876033e-02f, -9.72358957e-02f, 1.60395205e-01f, -1.62176520e-03f, -1.04208514e-01f, 1.81863770e-01f, 1.17827237e-01f, 1.03928126e-01f,
  3.70572768e-02f, 8.58808607e-02f, -8.82417411e-02f, 1.58941239e-01f, 9.69420299e-02f, -8.00681561e-02f, -4.65856642e-02f, 3.14683318e-02f, 1.21100761e-01f, 8.32656622e-02f,
  -8.61135945e-02f, -1.46319777e-01f, -9.67611969e-02f, -2.34261658e-02f, 4.35196934e-03f, 4.65852320e-02f, -7.83444196e-02f, -8.70159864e-02f, -1.37529880e-01f, 7.66161978e-02f,
  -9.60828438e-02f, -1.53999627e-01f, -1.14207983e-01f, -9.48450714e-02f, -1.17090009e-01f, 9.76189896e-02f, -1.54178262e-01f, -3.86056006e-02f, -4.66395132e-02f, 7.99864084e-02f,
  1.77605823e-01f, 1.02224899e-02f, -1.31435499e-01f, 7.74656609e-02f, 1.89061090e-03f, 5.38212359e-02f, -8.85482207e-02f, -1.44943118e-01f, 1.33512579e-02f, 1.28618777e-01f,
  -1.30214825e-01f, 6.53813109e-02f, 4.02807407e-02f, 6.45460337e-02f, 2.73692943e-02f, -4.82583158e-02f, 1.20296039e-01f, -4.33648676e-02f, -1.63072571e-02f, -1.63622275e-02f,
  -2.96887159e-02f, -1.04122110e-01f, 1.07270442e-01f, -6.94658831e-02f, -7.60901021e-03f, -6.79659471e-02f, -7.46370628e-02f, 4.49304022e-02f, -1.04719531e-02f, 2.56141685e-02f,
  6.16888143e-02f, -1.28610283e-01f, 5.90386018e-02f, -1.91439986e-02f, 4.06061858e-02f, -9.98887420e-02f, -4.53565232e-02f, -1.13039315e-01f, 1.68361329e-02f, -9.61853936e-02f,
  1.69579014e-01f, -1.65133625e-02f, 1.60014614e-01f, 1.67931825e-01f, 2.76064068e-01f, 1.31858364e-01f, 2.25300699e-01f, 1.76694989e-01f, -6.66577071e-02f, 1.74331069e-01f,
  1.75640881e-01f, 1.34340450e-01f, 1.04644977e-01f, -1.96604863e-01f, 1.23541228e-01f, 7.51079693e-02f, -1.73741609e-01f, -1.11013867e-01f, 6.10280856e-02f, 1.54657900e-01f,
  -4.09039520e-02f, -1.41973212e-01f, 2.11994156e-01f, -8.65051746e-02f, -1.20296709e-01f, 3.37798931e-02f, -7.14264764e-03f, -8.97721797e-02f, 2.68256754e-01f, 7.24720210e-02f,
  3.90978344e-02f, 1.21308519e-02f, -4.80628833e-02f, 4.68402766e-02f, 1.37958363e-01f, 2.44880632e-01f, 1.46775350e-01f, 4.72295247e-02f, 1.38813972e-01f, 8.58644992e-02f,
  -1.75427452e-01f, 1.76914614e-02f, -9.33929160e-02f, 5.75027801e-02f, 9.72354412e-02f, -8.37693140e-02f, 4.35556704e-03f, 1.04563005e-01f, -2.33176313e-02f, 1.71379030e-01f,
  -7.56222084e-02f, 1.37933463e-01f, -8.58166590e-02f, -7.72041008e-02f, 4.77240905e-02f, 1.01788454e-01f, -8.20018277e-02f, 1.26652550e-02f, -8.80282298e-02f, -5.60631137e-03f,
  -8.05983543e-02f, 2.20517721e-02f, 1.57764420e-01f, -1.04616441e-01f, 1.72130093e-01f, 4.92454544e-02f, 1.00347511e-01f, 7.21411556e-02f, -6.67840764e-02f, 7.06251785e-02f,
  9.53424945e-02f, 1.90142274e-01f, 5.99222966e-02f, 1.40037969e-01f, -8.43014568e-02f, 1.47778779e-01f, 6.58763573e-02f, 4.92180474e-02f, 3.85198295e-02f, -1.69782788e-01f,
  -4.81470525e-02f, 1.59357898e-02f, 8.02308396e-02f, 9.26576331e-02f, -7.67666176e-02f, -4.01130840e-02f, 8.75666216e-02f, 1.43325150e-01f, 5.46720698e-02f, 5.68343401e-02f,
  5.91603033e-02f, 1.33950589e-02f, 1.32174924e-01f, 5.73631860e-02f, 6.09993227e-02f, -1.15054296e-02f, -6.79718629e-02f, 2.76391022e-02f, -1.91394798e-02f, -1.13272876e-01f,
  5.18674254e-02f, 4.37843427e-02f, 4.68341596e-02f, 6.67318255e-02f, -6.95448890e-02f, -1.30243227e-02f, -1.10801362e-01f, -4.46272306e-02f, 1.02355555e-01f, -1.06146008e-01f,
  -1.88196972e-02f, -4.02773507e-02f, 1.35324866e-01f, -2.70750877e-02f, 6.58961907e-02f, 8.77313614e-02f, 1.80027857e-01f, -1.21339656e-01f, 6.44906312e-02f, 1.13103136e-01f,
  -1.12148330e-01f, -8.52706879e-02f, 4.31140251e-02f, 1.13600999e-01f, -2.48204786e-02f, -1.01871237e-01f, 8.32044892e-03f, -1.42082095e-01f, -2.44038757e-02f, -7.35007375e-02f,
  -3.10435258e-02f, -1.27271749e-02f, -1.86561234e-02f, 2.61644069e-02f, 1.52149603e-01f, -1.06638705e-03f, 2.33132280e-02f, -3.26252100e-03f, -6.12295866e-02f, -2.65150424e-02f,
  2.16282811e-02f, -1.24822319e-01f, -4.22415510e-02f, 1.22803673e-01f, 9.39207375e-02f, 8.42359476e-03f, 9.10173655e-02f, 3.52482200e-02f, 1.12697385e-01f, -2.83214152e-02f,
  1.45808086e-01f, 1.93452127e-02f, 7.57222399e-02f, -5.79021722e-02f, 3.11764353e-03f, 2.98648272e-02f, -2.77722236e-02f, -8.23477805e-02f, -1.20762043e-01f, -5.33179529e-02f,
  -4.69523817e-02f, 3.20663489e-02f, -1.20079340e-02f, 1.60899028e-01f, 9.96593609e-02f, 1.41911119e-01f, -1.06051616e-01f, 2.64895498e-03f, 4.94609028e-02f, -8.85334834e-02f,
  7.36286342e-02f, 8.68467316e-02f, 5.14746308e-02f, 1.90230459e-02f, 7.43583813e-02f, 7.83356279e-02f, 1.18316822e-01f, 3.85654382e-02f, -9.72221345e-02f, -5.47589064e-02f,
  1.11220847e-03f, -1.12409562e-01f, 7.89576545e-02f, -1.36881042e-02f, 7.40681812e-02f, -1.11017227e-01f, 2.10083202e-01f, -1.60175711e-02f, 1.09175049e-01f, 2.22327318e-02f,
  7.29416078e-03f, 2.22033903e-01f, 2.10234210e-01f, 2.23581538e-01f, 9.10184830e-02f, 6.44445866e-02f, 1.05960064e-01f, 2.89817065e-01f, 2.20532976e-02f, -1.02319829e-01f,
  1.44199491e-01f, 1.64409339e-01f, 9.66858789e-02f, 2.08300442e-01f, 1.99559152e-01f, 2.63609350e-01f, -3.01989347e-01f, -2.94216108e-02f, 5.30232079e-02f, -4.41700786e-01f,
  -1.46568090e-01f, -1.39798522e-01f, -6.36798963e-02f, 2.56409436e-01f, -1.08437665e-01f, -4.75621343e-01f, -3.19219798e-01f, 3.11385274e-01f, -3.58251452e-01f, -1.78675264e-01f,
  -1.49738714e-01f, -2.75713265e-01f, -6.41611312e-03f, 5.63186631e-02f, 3.18492115e-01f, -6.02011830e-02f, 3.31852108e-01f, -1.56836137e-01f, -2.88351066e-02f, -8.27090368e-02f,
  8.34357068e-02f, 1.92286387e-01f, 2.36002326e-01f, -7.54847154e-02f, 1.34070784e-01f, -1.72334135e-01f, -1.24707501e-02f, 1.99775025e-01f, -9.80847701e-02f, -5.33924103e-02f,
  -6.41895235e-02f, 8.36274624e-02f, 3.60962600e-01f, 8.16700384e-02f, -1.51480556e-01f, 5.28296903e-02f, 4.17625308e-02f, 6.92103431e-02f, 9.99528319e-02f, -1.65568769e-01f,
  1.32548839e-01f, 2.13266581e-01f, 1.50357410e-01f, 4.93528843e-02f, 1.34539172e-01f, 1.34137079e-01f, 1.46264091e-01f, -2.51377039e-02f, 1.14419207e-01f, 7.44419023e-02f,
  2.63760574e-02f, 2.83626437e-01f, 4.25780267e-02f, 7.45084584e-02f, 1.62867427e-01f, 6.34316530e-04f, 1.02475539e-01f, 3.00068967e-03f, 7.29581863e-02f, -1.33924484e-01f,
  -1.62287280e-01f, 1.08368412e-01f, -1.07339777e-01f, -8.25099181e-03f, 4.57656123e-02f, -6.18181154e-02f, 2.10753262e-01f, 2.40320656e-02f, 1.15940422e-01f, -2.77675927e-01f,
  -2.17056558e-01f, 1.08462915e-01f, 1.08565509e-01f, -1.03770323e-01f, 1.47765791e-02f, 7.36098066e-02f, 1.39773890e-01f, 2.97711313e-01f, 1.46108955e-01f, -7.02284500e-02f,
  -9.58716273e-02f, 2.08930727e-02f, -6.26794845e-02f, -1.72997802e-01f, -5.66568896e-02f, -1.55671882e-02f, -6.62685931e-02f, 1.79290757e-01f, 1.36456922e-01f, 4.51396555e-02f,
  1.49594173e-01f, -1.08615831e-01f, 1.83692485e-01f, -1.20730795e-01f, 7.57640675e-02f, 1.35664001e-01f, 1.36388540e-01f, 1.81227222e-01f, -1.95585415e-01f, 1.73587412e-01f,
  -8.46593827e-02f, -1.10651843e-01f, -9.06017721e-02f, -9.81587321e-02f, 1.38062939e-01f, -9.01111960e-02f, 4.58811373e-02f, -7.45292827e-02f, 1.02367118e-01f, 1.21244891e-02f,
  -1.55042345e-02f, -1.74604282e-01f, -7.97798261e-02f, 1.37945026e-01f, 3.29054007e-03f, -1.21157989e-03f, 1.42080992e-01f, -2.47764010e-02f, 1.61648057e-02f, 8.67746770e-02f,
  1.09012328e-01f, 1.65154552e-03f, 1.68833271e-01f, -2.26805583e-01f, 3.21395583e-02f, -2.32080072e-01f, -2.11227804e-01f, 4.92505394e-02f, -4.88379933e-02f, 1.26565278e-01f,
  -1.24970637e-01f, 8.10112339e-03f, 1.22644827e-01f, -4.59857099e-02f, 4.94333059e-02f, 1.74058810e-01f, -1.47230133e-01f, -1.07311364e-02f, 1.91047877e-01f, 5.69173917e-02f,
  -2.35336453e-01f, 4.81219590e-02f, -4.73207794e-02f, 1.83707222e-01f, -4.24253419e-02f, 2.11963337e-03f, 9.30703804e-02f, -5.58355004e-02f, -9.34624001e-02f, 1.02457874e-01f,
  5.64832380e-03f, 1.39147195e-03f, -2.77453978e-02f, 5.97416274e-02f, -8.78136903e-02f, 1.04354164e-02f, -1.47294581e-01f, 1.80083975e-01f, -9.05033574e-02f, 1.62191704e-01f,
  -1.11460172e-01f, 3.04579884e-01f, -8.56560320e-02f, -2.24606860e-02f, -4.82691899e-02f, -9.59709585e-02f, -4.81175371e-02f, -3.39429379e-02f, 8.91156346e-02f, 8.83648470e-02f,
  2.08055571e-01f, 1.74464852e-01f, -9.31596290e-03f, 9.37229842e-02f, 4.97472063e-02f, 2.32167244e-02f, -6.40110224e-02f, -5.60762100e-02f, 8.07195082e-02f, 3.86000313e-02f,
  1.72668830e-01f, -1.29809886e-01f, 1.36200637e-01f, 1.63039472e-02f, -1.09870858e-01f, -5.51889800e-02f, 2.32832357e-02f, 7.00746253e-02f, -1.62789553e-01f, 1.29631311e-01f,
  -1.36337832e-01f, 3.46006639e-02f, 8.12347904e-02f, -7.45122805e-02f, 1.08175194e-02f, 1.23089507e-01f, 2.97462773e-02f, 1.14477716e-01f, 1.79221690e-01f, -1.40351206e-01f,
  -5.01127914e-04f, 7.29819611e-02f, -1.68011010e-01f, -8.07145238e-02f, 1.20278701e-01f, 1.17850579e-01f, 5.69954980e-03f, -8.55414793e-02f, 1.14879556e-01f, -1.25545546e-01f,
  2.58696396e-02f, 5.94162196e-02f, -2.62518283e-02f, -3.39454263e-02f, 1.02586269e-01f, 5.88587113e-02f, 1.15123540e-01f, -8.53347480e-02f, 5.26752062e-02f, 9.19122249e-02f,
  -1.17198505e-01f, 9.30486992e-02f, 1.78690385e-02f, 2.07519997e-02f, 1.44695744e-01f, -3.56658064e-02f, -1.66490704e-01f, -3.41905132e-02f, 8.58814493e-02f, -2.96130385e-02f,
  -9.23042446e-02f, -1.25491023e-01f, 8.42098221e-02f, -4.27855970e-03f, 9.62530300e-02f, 3.52939740e-02f, -1.08487114e-01f, -6.52100593e-02f, 1.54618070e-01f, 9.22535285e-02f,
  1.51618898e-01f, 1.00391425e-01f, 2.44895723e-02f, -1.03417672e-01f, 1.79862157e-01f, 1.07492544e-02f, -5.49234450e-02f, 1.41795993e-01f, -9.32863876e-02f, -3.50331212e-03f,
  1.22058012e-01f, 1.18349969e-01f, 5.79170696e-02f, 7.36453459e-02f, -9.52523351e-02f, 2.97305230e-02f, -4.47187060e-03f, 3.30454595e-02f, -5.18283322e-02f, -1.15391821e-01f,
  3.76233645e-03f, 3.15898098e-02f, 7.00891425e-04f, -4.86871488e-02f, 1.83577575e-02f, 8.19824338e-02f, 1.01339296e-01f, -6.42401576e-02f, 5.73523343e-02f, -6.58786744e-02f,
  1.51137924e-02f, -1.25513345e-01f, 1.11432999e-01f, -2.01404486e-02f, -4.87775430e-02f, 1.72062114e-01f, 6.99030906e-02f, -4.86026295e-02f, 4.64316793e-02f, 5.82048632e-02f,
  -8.47468749e-02f, 4.77917567e-02f, -8.11367258e-02f, -9.10739973e-02f, 6.29023835e-02f, -1.04859181e-01f, 1.53745815e-01f, 5.89828342e-02f, 6.89036995e-02f, -1.04670294e-01f,
  1.00355536e-01f, 7.55007043e-02f, 1.47464797e-01f, 1.82295039e-01f, -7.93959275e-02f, -6.18754439e-02f, -6.06876612e-02f, -2.77208686e-02f, 9.13346261e-02f, 1.07258745e-02f,
  -1.09658174e-01f, 1.70074120e-01f, 8.49406421e-02f, 1.33919388e-01f, -1.08142886e-02f, 8.75808671e-02f, 2.04519257e-01f, 7.70870298e-02f, 4.60588075e-02f, 1.08439468e-01f,
  -8.03429857e-02f, 1.12678908e-01f, 8.17493871e-02f, -1.11588677e-02f, 1.61744252e-01f, 1.69498920e-01f, 4.73992229e-02f, 5.14530987e-02f, 1.84169188e-02f, -8.77635740e-03f,
  -5.45380749e-02f, 1.23474792e-01f, -8.91808122e-02f, 1.67656198e-01f, 1.10168032e-01f, 8.30427408e-02f, -1.64996430e-01f, 2.68116482e-02f, -5.44553325e-02f, 8.70838463e-02f,
  -8.22604075e-03f, 1.75273139e-02f, -1.08837530e-01f, 1.79326549e-01f, -1.01109501e-02f, 2.28442416e-01f, 2.56964732e-02f, -1.29203439e-01f, -9.04252231e-02f, 3.68793681e-02f,
  -6.90426230e-02f, -1.47865728e-01f, -2.88759712e-02f, -1.47608504e-01f, -6.98486483e-03f, 1.84050366e-01f, -1.33637309e-01f, 1.17740624e-01f, 7.78605789e-02f, -2.52127126e-02f,
  9.72887501e-02f, 1.17737524e-01f, -7.07187727e-02f, 6.90152049e-02f, 2.61936001e-02f, -2.18269136e-02f, 7.95006901e-02f, -8.97570327e-03f, 3.48559991e-02f, 3.21952514e-02f,
  6.22806549e-02f, 1.09056449e-02f, 5.57653531e-02f, -1.06833525e-01f, -4.57781777e-02f, 4.16019969e-02f, 1.44630829e-02f, 1.54251575e-01f, 1.20315395e-01f, 2.19580844e-01f,
  1.28868222e-01f, 1.70474365e-01f, 7.40135536e-02f, 5.97968372e-03f, 1.61048874e-01f, -7.19049945e-02f, 1.23030782e-01f, 6.31346479e-02f, 7.50944242e-02f, -2.64095783e-01f,
  1.66121960e-01f, 2.00078972e-02f, -2.91718870e-01f, 8.25940818e-02f, -1.82268992e-01f, -1.13074183e-01f, -1.51520729e-01f, 6.48795590e-02f, 9.71768424e-02f, -4.57258299e-02f,
  1.22042246e-01f, 1.02375463e-01f, 3.20399433e-01f, -1.09836003e-02f, -5.98892197e-02f, 3.60931084e-02f, -9.01957378e-02f, 7.20019117e-02f, 1.84345376e-02f, 6.79470226e-02f,
  -7.18203783e-02f, -5.07439524e-02f, -7.37924576e-02f, -8.22082311e-02f, -4.80105765e-02f, 1.29180387e-01f, -4.15776372e-02f, -5.32561205e-02f, 2.58628309e-01f, 7.50506073e-02f,
  -1.75486103e-01f, -3.55315059e-02f, 1.48811996e-01f, 2.39637308e-03f, 7.59117976e-02f, 1.22151569e-01f, -4.68328819e-02f, 2.53223419e-01f, 7.13065043e-02f, -7.27588823e-03f,
  -1.26881316e-01f, -1.34296209e-01f, 1.08355314e-01f, -9.46511924e-02f, -4.14826795e-02f, 7.95708969e-02f, -8.09078738e-02f, -5.57341054e-02f, 4.07921486e-02f, -1.29741073e-01f,
  -2.56694071e-02f, -1.94011293e-02f, 1.50641456e-01f, 1.93721265e-01f, 1.76926926e-01f, 9.64576676e-02f, 4.07626517e-02f, -9.10396595e-03f, -6.47658110e-02f, -1.19836600e-02f,
  -5.02396487e-02f, 1.42290682e-01f, 6.96742237e-02f, -1.40693009e-01f, 2.45486081e-01f, -1.80017054e-02f, -3.41020599e-02f, 5.00790663e-02f, -8.51957202e-02f, 2.05863789e-01f,
  -2.35298142e-01f, 5.43086380e-02f, 1.23200774e-01f, 1.33637190e-01f, 6.33706525e-02f, 5.21210320e-02f, 3.63911241e-02f, -1.81557816e-02f, -6.84484392e-02f, -4.16241400e-02f,
  -2.16411322e-01f, -1.84935719e-01f, -1.50317773e-01f, -4.20121364e-02f, 8.43256339e-02f, 1.73707455e-01f, 5.79588227e-02f, 2.04864576e-01f, 8.36784393e-02f, 7.80186206e-02f,
  -8.05988982e-02f, 5.19499443e-02f, -1.43644977e-02f, 3.43726538e-02f, -1.40902260e-02f, 6.43589254e-03f, -4.30633165e-02f, -1.27065303e-02f, -1.70678608e-02f, 4.28424403e-02f,
  -6.20686077e-02f, 3.76650020e-02f, 1.23016089e-01f, -1.51871368e-01f, 1.37500077e-01f, 5.70098758e-02f, 9.19161588e-02f, -8.14842731e-02f, 1.54241189e-01f, -7.32286796e-02f,
  2.02221284e-03f, -2.33691633e-02f, 1.47130370e-01f, 1.19284786e-01f, -4.25078124e-02f, 1.85126439e-01f, 1.71131697e-02f, -8.20320621e-02f, -1.11758478e-01f, 8.85170177e-02f,
  1.20862663e-01f, 1.01759836e-01f, 1.29207432e-01f, 7.77364671e-02f, 7.60409981e-02f, 1.26279607e-01f, -1.63372327e-02f, 7.72068948e-02f, 3.58012728e-02f, -5.64017184e-02f,
  1.33021921e-01f, 1.51124641e-01f, 8.64353925e-02f, -7.48263672e-03f, -1.45397827e-01f, -7.25711063e-02f, -1.54040456e-01f, 7.82959014e-02f, -1.06098659e-01f, 4.96615916e-02f,
  -1.31361842e-01f, -1.28610998e-01f, -1.85327053e-01f, -7.82379732e-02f, -5.48072942e-02f, -5.93546070e-02f, -1.32356972e-01f, 3.61629993e-01f, -1.08581960e-01f, 5.67681640e-02f,
  9.96815711e-02f, 5.63591234e-02f, 1.04466483e-01f, -3.26928981e-02f, 1.17862590e-01f, 3.97469141e-02f, -1.38458833e-01f, 1.33073881e-01f, 8.14891756e-02f, 9.76106450e-02f,
  -1.26798555e-01f, -2.07002051e-02f, 1.13119476e-01f, 1.47640593e-02f, -9.61325169e-02f, -1.04434982e-01f, 1.46791369e-01f, -4.58197482e-02f, 2.31298758e-03f, -8.43756348e-02f,
  6.97998405e-02f, 1.49276674e-01f, 9.17981863e-02f, -1.25566766e-01f, 3.64683755e-02f, 6.13135025e-02f, 1.36356931e-02f, 1.22846188e-02f, -1.04099907e-01f, 6.94835410e-02f,
  7.84292966e-02f, 1.28652856e-01f, 1.66997433e-01f, 4.08884026e-02f, -2.46615391e-02f, -4.61870097e-02f, 8.05195197e-02f, 1.34212151e-01f, 5.25469780e-02f, 2.04278212e-02f,
  -1.07586617e-02f, -1.22412525e-01f, 1.78497896e-01f, -1.24958105e-01f, -7.73348263e-04f, 2.19847038e-01f, 8.43268761e-04f, 1.81860834e-01f, -8.59082304e-03f, 9.03655542e-04f,
  7.39584789e-02f, 1.42561331e-01f, -1.33457124e-01f, -8.03702548e-02f, 8.68882835e-02f, 5.54333292e-02f, -4.49788980e-02f, 6.26015961e-02f, -2.38041341e-01f, 3.34991477e-02f,
  -1.06671914e-01f, 3.04101944e-01f, 3.92813273e-02f, 1.37973070e-01f, 7.69297332e-02f, 1.22723103e-01f, -3.82394716e-02f, -5.88999912e-02f, 3.28840837e-02f, 8.93919766e-02f,
  5.46439402e-02f, 4.89415191e-02f, -5.56201600e-02f, 1.30707905e-01f, -1.84256434e-02f, 2.58243214e-02f, 5.69046475e-02f, 5.63410576e-03f, -1.32697269e-01f, -2.81818607e-03f,
  3.53996153e-03f, 8.05392116e-02f, -2.32890993e-02f, -2.82839108e-02f, 1.10912032e-01f, -5.87704629e-02f, -3.75559181e-02f, 1.89445332e-01f, 1.55276448e-01f, 2.02735946e-01f,
  1.38750300e-01f, -1.49280205e-02f, 1.31757319e-01f, 1.98932722e-01f, 6.47263080e-02f, 3.90950851e-02f, 9.36811790e-02f, -4.94988300e-02f, 6.34383112e-02f, 1.84090238e-03f,
  -5.31724021e-02f, -1.97419580e-02f, -5.71047254e-02f, -3.42924986e-03f, 1.43465400e-01f, 4.16050777e-02f, 5.50617352e-02f, 7.34462813e-02f, 1.73172042e-01f, -1.74200580e-01f,
  -1.64584503e-01f, -5.82353361e-02f, -1.49762243e-01f, 1.36195511e-01f, -4.57423478e-02f, 1.34512916e-01f, 6.57412186e-02f, -1.08094595e-01f, -8.54730457e-02f, -3.45815681e-02f,
  1.50309037e-02f, -1.28070600e-02f, 5.07193208e-02f, -6.73572719e-02f, -2.34369505e-02f, -9.30357948e-02f, -1.21611748e-02f, 8.22164714e-02f, 1.67041458e-02f, -1.79559272e-02f,
  1.46514699e-01f, 4.57347631e-02f, 8.05349424e-02f, -8.11215341e-02f, -1.02396272e-01f, -2.10588630e-02f, -1.23191111e-01f, -5.14550954e-02f, -4.02779654e-02f, 9.67317969e-02f,
  -9.00533497e-02f, 3.16512473e-02f, 1.47289589e-01f, 8.68586302e-02f, 1.95604011e-01f, -9.41422880e-02f, 8.35236385e-02f, 1.98724851e-01f, -4.16072793e-02f, 9.32008028e-02f,
  -5.55920601e-02f, 2.99233757e-02f, 1.00329611e-03f, 1.02007100e-02f, -1.31948769e-01f, 6.61077946e-02f, -3.18952613e-02f, -2.14793533e-02f, -6.69985712e-02f, 4.05103154e-02f,
  7.95301124e-02f, 7.85756484e-02f, -4.34912182e-02f, -3.60397659e-02f, 3.19429934e-02f, -2.57331263e-02f, -9.08929557e-02f, 8.55704211e-03f, 9.62570608e-02f, 5.93740344e-02f,
  -4.98107374e-02f, 9.20061171e-02f, 5.45103326e-02f, 5.61389700e-02f, -1.13598414e-01f, -1.31527185e-01f, -7.30396360e-02f, 7.30156675e-02f, 8.06042086e-03f, -7.18965679e-02f,
  -5.50054386e-02f, 2.09311899e-02f, -5.22632897e-03f, 3.56711484e-02f, 8.69990066e-02f, -7.63896480e-02f, 1.75882559e-02f, -1.22977450e-01f, -5.36049902e-02f, 1.76822886e-01f,
  4.49567735e-02f, -1.16516069e-01f, -7.04241171e-02f, 1.02804281e-01f, 1.03018187e-01f, 4.33587655e-02f, 8.49725083e-02f, 7.89377186e-03f, -6.46975711e-02f, 5.33705987e-02f,
  -4.81502861e-02f, -8.44938383e-02f, -9.07664895e-02f, 8.82255435e-02f, -2.15663109e-02f, 9.49366167e-02f, -1.25395566e-01f, 1.05199717e-01f, 1.00072533e-01f, 9.49691460e-02f,
  -2.05143429e-02f, 8.45930949e-02f, 3.85112315e-02f, 1.09055519e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  8.12437013e-02f, 1.58671569e-02f, 1.25851959e-01f, -2.80078556e-02f, -5.59477843e-02f, 1.74815103e-01f, 1.88256457e-01f, -1.77304242e-02f, 4.89826985e-02f, 2.24198312e-01f,
  1.36973737e-02f, 4.26271297e-02f, -2.14650165e-02f, 3.66375968e-02f, 1.44854441e-01f, 1.85984388e-01f, -1.68328360e-02f, 4.56793196e-02f, -4.35023308e-02f, 5.05334809e-02f,
  2.00670853e-01f, 7.43586272e-02f, -5.18375412e-02f, -8.06054380e-03f, 5.61491102e-02f, -2.94835698e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  1.02201365e-01f, 1.14264429e-01f, 9.40185413e-02f, -7.62606040e-03f, -1.04258806e-01f, -1.17824502e-01f, 2.64628902e-02f, 2.26264730e-01f, -3.78129810e-01f, -4.77363139e-01f,
  -3.27338986e-02f, -7.55363936e-03f, -4.05491322e-01f, -3.22669894e-02f, 7.47513697e-02f, -4.24292892e-01f, 9.16951746e-02f, -2.13763773e-01f, -2.72205204e-01f, 1.16134115e-01f,
  7.18419999e-02f, 4.06489372e-01f, -3.91165376e-01f, 4.09103543e-01f, 7.14861929e-01f, 9.10532102e-02f, 2.18712255e-01f, 4.41910833e-01f, -1.49611279e-01f, -3.86249483e-01f,
  1.32014096e-01f, 4.19039339e-01f, 2.57726222e-01f, 2.07373083e-01f, 2.18955740e-01f, -1.45926610e-01f, -3.89113098e-01f, 5.43072760e-01f, 3.01997036e-01f, 1.23341352e-01f,
  -2.59012014e-01f, -3.25418621e-01f, -1.32667378e-01f, -6.95583075e-02f, -1.37972742e-01f, -8.62845629e-02f, -7.60750100e-02f, -2.24640936e-01f, 1.03339158e-01f, 1.83820739e-01f,
  -8.86420235e-02f, -1.05594836e-01f, 2.66652852e-01f, 1.53039798e-01f, 3.62673223e-01f, -1.70166284e-01f, -1.06378682e-01f, 1.02757022e-01f, 3.33664045e-02f, -2.91694403e-02f,
  -1.73837915e-01f, -7.42206946e-02f, -1.13702333e-03f, 1.61553137e-02f, 1.39944628e-01f, -1.25424907e-01f, -2.78269678e-01f, 6.62592798e-02f, -1.96885280e-02f, 3.76526475e-01f,
  -1.32197991e-01f, 3.42136808e-02f, 5.52794874e-01f, -3.59266549e-01f, -3.60272020e-01f, -1.82965070e-01f, -4.05935913e-01f, 3.10256153e-01f, 2.19021678e-01f, 1.54101744e-01f,
  1.91207096e-01f, 7.99830630e-03f, 1.63399383e-01f, -8.19315240e-02f, 3.00902098e-01f, 4.01173234e-01f, 1.29052877e-01f, 3.32163721e-01f, -5.18714488e-01f, 1.17612652e-01f,
  -1.63997356e-02f, -2.35136509e-01f, -1.88809738e-01f, -8.59110430e-02f, 2.93776274e-01f, 3.23031574e-01f, 9.05813947e-02f, 2.01601163e-01f, -2.01955074e-04f, 1.06641747e-01f,
  -2.75747985e-01f, 3.75009507e-01f, -3.36991157e-03f, -1.07676819e-01f, -2.75154829e-01f, -3.61619949e-01f, -5.58686703e-02f, 1.20319109e-02f, 2.38602310e-01f, 6.80004582e-02f,
  -9.73177478e-02f, -3.84860992e-01f, -1.01311862e-01f, 4.06222135e-01f, 1.21488534e-01f, 1.51232108e-01f, -4.90417480e-01f, -1.98573604e-01f, 4.26428646e-01f, -4.31370400e-02f,
  1.51063129e-02f, 7.85568058e-02f, 2.48619765e-01f, 3.58423471e-01f, -2.23566871e-02f, 3.95006150e-01f, -6.89335018e-02f, -2.60304324e-02f, 3.14500034e-02f, 2.99144000e-01f,
  2.70893842e-01f, 7.41978884e-02f, -8.36602822e-02f, -2.00404599e-01f, 1.52949542e-01f, 2.25309014e-01f, -4.33156252e-01f, 1.75643042e-01f, -4.01433796e-01f, -1.45052940e-01f,
  -2.20323011e-01f, -5.79195097e-02f, -4.51504663e-02f, 1.43670723e-01f, 2.19335005e-01f, -4.17802036e-02f, 1.70614585e-01f, 2.80866385e-01f, -1.38531357e-01f, 1.38510138e-01f,
  -4.25086796e-01f, 3.64230245e-01f, -3.47647101e-01f, -4.09247987e-02f, -4.58740592e-02f, -7.05205500e-01f, -4.71293032e-02f, -3.55965555e-01f, 1.45343825e-01f, 3.54887664e-01f,
  -6.09646916e-01f, -5.83144069e-01f, 8.13832730e-02f, 2.29236275e-01f, -4.58751023e-01f, -4.60687637e-01f, -1.45864263e-01f, 4.67382781e-02f, -1.32521749e-01f, -5.83691411e-02f,
  -9.19809267e-02f, -2.20418349e-01f, 1.31358773e-01f, 2.56287493e-02f, -3.82073671e-02f, 1.19337417e-01f, 3.21102709e-01f, -3.31829458e-01f, 1.55757919e-01f, -6.78322241e-02f,
  -3.58475804e-01f, -3.35196257e-01f, -1.02966547e-01f, -2.09013060e-01f, -5.87580318e-04f, -1.86568201e-01f, -6.58544973e-02f, 9.52473059e-02f, 1.96710497e-01f, 3.41816358e-02f,
  2.25256696e-01f, -1.82697311e-01f, -1.26656860e-01f, 2.70626713e-02f, 2.23771751e-01f, 1.45910710e-01f, -4.78862226e-01f, -3.11581671e-01f, -2.39758521e-01f, 2.09512085e-01f,
  -2.91420370e-01f, 9.17378813e-02f, -2.92857498e-01f, -1.03009894e-01f, 1.54086888e-01f, 1.74272023e-02f, -3.84245396e-01f, -2.67460458e-02f, -8.66361782e-02f, 2.96627544e-02f,
  -7.88621977e-02f, -5.33602715e-01f, -4.79545236e-01f, -2.16015294e-01f, -4.31215167e-01f, -1.71331033e-01f, 4.41179931e-01f, -2.75064021e-01f, 9.04942900e-02f, 2.21964523e-01f,
  4.91689444e-01f, 3.66190642e-01f, -5.20653009e-01f, -1.18650652e-01f, 2.15044126e-01f, 2.16622666e-01f, 8.20077285e-02f, -9.06081498e-02f, -7.38644227e-02f, 2.75035828e-01f,
  -1.51544660e-01f, 3.00267309e-01f, 2.73591101e-01f, -1.70039803e-01f, -8.67749453e-02f, -1.57875076e-01f, -1.48294166e-01f, -9.53426361e-02f, 2.35565916e-01f, -5.19342780e-01f,
  6.49205521e-02f, -1.99638307e-02f, 4.02360456e-03f, -9.43770707e-02f, 5.37878990e-01f, 3.76259424e-02f, -1.40020186e-02f, 2.47565225e-01f, 4.72433493e-02f, 5.25932983e-02f,
  -1.86053649e-01f, -1.77253067e-01f, -1.90548643e-01f, -1.80737570e-01f, 9.84836742e-02f, -9.36489701e-02f, 1.94291666e-01f, 2.45000631e-01f, -1.73006684e-01f, 1.48714527e-01f,
  3.01281475e-02f, -1.26726991e-02f, 3.25874984e-01f, 8.45847279e-02f, -1.42281055e-01f, -4.68159914e-02f, 2.54620284e-01f, 2.02267587e-01f, 2.60212600e-01f, 1.57801852e-01f,
  1.60604864e-01f, -2.09439382e-01f, 1.51391983e-01f, -2.14301888e-03f, 2.71119863e-01f, 2.61615694e-01f, 3.30182821e-01f, -3.83910865e-01f, 2.25622103e-01f, -1.26517907e-01f,
  6.01391494e-01f, -1.43024817e-01f, 1.31587192e-01f, 1.53906122e-01f, -4.74754870e-01f, -7.34464750e-02f, 4.72476706e-02f, -1.73068400e-02f, -2.50549048e-01f, 2.00285748e-01f,
  -5.27240103e-03f, -1.01789728e-01f, 9.72397253e-02f, -4.01371807e-01f, -2.60224268e-02f, -1.79304858e-04f, 2.03301907e-01f, -1.01865381e-01f, -2.96760798e-02f, -1.48520559e-01f,
  -2.20477983e-01f, 5.91150373e-02f, 3.55138123e-01f, -1.68097727e-02f, -6.12306036e-02f, -2.28734523e-01f, -1.14563875e-01f, -8.55985209e-02f, 8.19151461e-01f, 3.22935060e-02f,
  -1.30054936e-01f, 1.50452584e-01f, -9.03131142e-02f, 2.17515025e-02f, -1.78580672e-01f, -1.58944204e-01f, 1.06265962e-01f, -9.32159834e-03f, 2.23795231e-02f, -7.95485824e-02f,
  5.64730950e-02f, -1.93884134e-01f, 2.91217357e-01f, -2.50805736e-01f, 2.28488371e-01f, 6.25666529e-02f, -2.65821606e-01f, 1.39202356e-01f, -4.93951654e-03f, 1.75425306e-01f,
  -9.79087129e-02f, 9.45741683e-03f, 3.45298290e-01f, -1.48334265e-01f, -4.32407826e-01f, -5.94747178e-02f, 2.61325240e-01f, -7.08573079e-03f, 4.56544667e-01f, 1.72575802e-01f,
  2.80906409e-01f, 7.26166517e-02f, 4.25010979e-01f, -1.47219360e-01f, 2.83012837e-02f, 4.64153588e-01f, 9.71908718e-02f, 3.75435740e-01f, -2.75927663e-01f, -4.62100059e-01f,
  2.14230418e-01f, 3.12074602e-01f, 5.00073552e-01f, 3.14771354e-01f, -8.15119520e-02f, 4.35128182e-01f, 5.21472931e-01f, 3.48949760e-01f, -1.06209740e-01f, -1.44835114e-01f,
  -4.39223535e-02f, -1.26314223e-01f, -1.90494776e-01f, -1.79756477e-01f, -3.28996122e-01f, -2.72665434e-02f, -2.70407379e-01f, 2.42131010e-01f, -1.38874784e-01f, 1.87586203e-01f,
  3.26935574e-02f, -1.52052850e-01f, -8.05575922e-02f, 4.77899641e-01f, -3.93399075e-02f, -1.03945911e-01f, -6.41645566e-02f, 3.80131155e-02f, 4.70490634e-01f, -1.48627236e-01f,
  -1.27658784e-01f, -7.16536194e-02f, -6.16308488e-02f, -7.76916072e-02f, 1.57058835e-01f, -1.02900527e-01f, 2.73434579e-01f, -1.29378110e-01f, 1.43944904e-01f, -6.90700784e-02f,
  2.49340177e-01f, 2.72426307e-01f, 2.26638958e-01f, 1.77493200e-01f, 2.84227371e-01f, 4.40515488e-01f, 3.13758880e-01f, 2.89544910e-01f, 4.27727342e-01f, 1.55099496e-01f,
  1.16770953e-01f, 8.74839947e-02f, -2.44438425e-01f, 2.10683778e-01f, 3.09051454e-01f, -4.57958013e-01f, 4.89565164e-01f, -1.28214404e-01f, -5.76226056e-01f, 3.78390141e-02f,
  4.00935292e-01f, -6.08653605e-01f, 4.50890154e-01f, -1.37596458e-01f, -5.52034736e-01f, -9.30163711e-02f, -2.99490839e-01f, -3.13246548e-02f, -2.75970489e-01f, 3.60087723e-01f,
  4.29275304e-01f, -6.18778825e-01f, -2.72657901e-01f, -9.25683305e-02f, 1.51020691e-01f, -6.49394915e-02f, -6.53630942e-02f, -1.35455042e-01f, -6.68037161e-02f, -1.77528843e-01f,
  -1.18588850e-01f, 2.00243235e-01f, -5.82421683e-02f, -1.95381060e-01f, -1.71190441e-01f, -3.84421237e-02f, -3.36843550e-01f, -3.44774202e-02f, -2.31548533e-01f, 2.92989701e-01f,
  6.66959211e-02f, 1.22544896e-02f, 1.32139727e-01f, -1.15608804e-01f, -2.97233939e-01f, 2.70281900e-02f, 1.14337221e-01f, 4.34516966e-02f, -5.69852702e-02f, -6.69238120e-02f,
  -3.25510651e-01f, -1.77763760e-01f, 3.22441347e-02f, 8.99305120e-02f, -4.83616330e-02f, -3.13969344e-01f, -3.67426515e-01f, -2.41388768e-01f, -1.63467169e-01f, 8.51522833e-02f,
  -4.00497854e-01f, 5.68052381e-03f, 2.57802069e-01f, 6.53994083e-02f, 2.44096965e-02f, 7.74423704e-02f, -1.82848424e-01f, -5.44219613e-01f, -4.22475815e-01f, -3.45347166e-01f,
  3.83550256e-01f, 3.47913168e-02f, 2.81529218e-01f, -7.74360299e-02f, -1.33701280e-01f, 3.67065281e-01f, 4.67243165e-01f, 2.60263205e-01f, 2.62870461e-01f, -6.02633595e-01f,
  1.97696477e-01f, -1.93262801e-01f, -2.61768192e-01f, -2.74713580e-02f, 7.78561309e-02f, -2.18754947e-01f, -3.09118703e-02f, -2.39503562e-01f, -2.19234731e-02f, -1.61208194e-02f,
  1.48202226e-01f, 2.39525199e-01f, 4.67297077e-01f, -7.63124004e-02f, 1.13954861e-02f, -2.01240927e-01f, -1.73793584e-02f, 1.91274881e-01f, -1.53157488e-01f, -2.07723081e-02f,
  3.63718987e-01f, 2.38333225e-01f, -7.87893310e-02f, -1.41113788e-01f, -1.00496337e-01f, -2.50393838e-01f, -7.84056485e-02f, -1.29148468e-01f, -7.47016892e-02f, -3.91060393e-03f,
  -2.60764569e-01f, -9.80461761e-03f, -8.47400874e-02f, -2.53449604e-02f, -4.38995332e-01f, -6.07568882e-02f, 5.00698574e-02f, -2.56405085e-01f, -1.69784099e-01f, 1.06943749e-01f,
  1.09367650e-02f, -5.18490076e-02f, 1.29957020e-01f, -8.90920088e-02f, 1.59566134e-01f, -1.30497441e-01f, 1.47617295e-01f, -5.60003333e-02f, -9.10491422e-02f, -4.97812107e-02f,
  -6.90717250e-02f, -2.72889256e-01f, -1.18353345e-01f, 2.05951378e-01f, -3.59527916e-01f, -2.38067761e-01f, -3.68912160e-01f, -1.87450260e-01f, 1.58132821e-01f, -2.37965405e-01f,
  -5.47972806e-02f, -4.55303527e-02f, 1.47399038e-01f, -9.96292382e-02f, 2.61663318e-01f, -1.37607232e-01f, -4.69199985e-01f, 4.39266488e-02f, -2.39542902e-01f, 1.46648601e-01f,
  1.83177084e-01f, 2.41466388e-02f, -3.74445468e-02f, 5.70416152e-01f, 1.04620576e-01f, -7.55083980e-03f, 3.61737758e-01f, -9.37658548e-02f, -2.01406956e-01f, -1.07493378e-01f,
  1.84877310e-02f, -2.21525446e-01f, -1.11758240e-01f, -4.46000975e-03f, -3.78943145e-01f, -1.34133786e-01f, -1.56954173e-02f, -2.84867287e-02f, -1.75978541e-01f, 3.51750284e-01f,
  -6.06973954e-02f, -1.03327110e-01f, 3.13972265e-01f, 3.39651674e-01f, -8.84504840e-02f, 1.35592997e-01f, -3.67873043e-01f, -1.80384815e-01f, -9.93249342e-02f, -3.52188587e-01f,
  -3.30366902e-02f, 4.39406484e-01f, -2.93678865e-02f, -2.32232332e-01f, 1.80842787e-01f, -8.86138231e-02f, -1.47954924e-02f, -2.72491843e-01f, 2.04482302e-01f, -7.49475285e-02f,
  2.16128483e-01f, -4.76545960e-01f, 7.69934058e-02f, -1.46978498e-01f, -4.68321949e-01f, 2.35777959e-01f, 3.25946450e-01f, -4.27306712e-01f, 2.93266743e-01f, 2.69227743e-01f,
  6.01489395e-02f, 1.53912053e-01f, -1.39562756e-01f, -1.99159220e-01f, -2.24800423e-01f, -1.88773707e-01f, 4.64253873e-01f, -2.02149257e-01f, -3.91800016e-01f, -3.56060535e-01f,
  2.97148228e-01f, 2.60144532e-01f, 3.36940348e-01f, -3.69821519e-01f, -2.08148602e-02f, 4.93717082e-02f, -1.56473994e-01f, -3.27063650e-02f, 5.06195307e-01f, 2.24291265e-01f,
  -2.16638416e-01f, -3.19197811e-02f, 1.89555436e-01f, 5.46979904e-01f, 3.20224836e-02f, 8.98550749e-02f, 1.31527949e-02f, -1.50022984e-01f, -1.43036202e-01f, -6.07402697e-02f,
  -2.97726262e-02f, -6.43241405e-02f, -3.75987478e-02f, -1.57398432e-01f, -3.39942038e-01f, -1.37488186e-01f, 8.42643753e-02f, -1.73394978e-01f, 1.71660885e-01f, -7.80827329e-02f,
  1.51450470e-01f, -4.12818193e-02f, 2.84893304e-01f, 4.17435765e-02f, -5.68481907e-02f, 2.33288169e-01f, -1.06478103e-01f, -5.38191617e-01f, 1.31513134e-01f, 1.90295026e-01f,
  3.82582664e-01f, 2.55122483e-01f, -6.64904788e-02f, 2.38189712e-01f, 1.64863244e-02f, 1.37839049e-01f, -6.16856873e-01f, -1.51597351e-01f, 2.83003598e-01f, -2.42154300e-01f,
  -5.28433561e-01f, 8.00401047e-02f, -2.48545572e-01f, -2.68624455e-01f, 2.53890485e-01f, -3.65104377e-01f, -3.60273540e-01f, 8.78097042e-02f, 3.73639584e-01f, 2.49506757e-01f,
  -2.38146082e-01f, 4.03542817e-01f, -1.25416026e-01f, 6.26089498e-02f, 3.68873216e-02f, -1.48393020e-01f, -1.77061036e-01f, 4.07904881e-04f, -2.23081470e-01f, 1.85506836e-01f,
  -2.69113988e-01f, 3.14941794e-01f, -1.84918404e-01f, 3.52717228e-02f, 1.62131324e-01f, 2.85858046e-02f, 2.09395096e-01f, 8.24711844e-02f, -1.50395259e-01f, 1.93483815e-01f,
  1.61179751e-01f, -7.13616833e-02f, -1.55068077e-02f, -3.77756566e-01f, -2.31694356e-01f, -1.43061250e-01f, 2.68229753e-01f, 2.23088011e-01f, -1.89171627e-01f, 1.75755367e-01f,
  -7.87331387e-02f, -3.60162184e-02f, 2.42506310e-01f, 1.42917382e-02f, -2.38653682e-02f, 3.29267293e-01f, -1.74036808e-02f, 9.39491540e-02f, -6.56774864e-02f, 1.32848043e-02f,
  6.81793764e-02f, -1.00535434e-02f, 2.38116696e-01f, 1.06778026e-01f, -4.43940237e-03f, -1.08024161e-02f, -9.33893844e-02f, -5.23014426e-01f, -4.90045428e-01f, 2.15541214e-01f,
  -2.38711253e-01f, 8.22359771e-02f, 1.22372821e-01f, 4.55897719e-01f, 4.55472879e-02f, 3.49817425e-01f, 8.18098262e-02f, -3.15403402e-01f, -2.94121653e-01f, 4.40312102e-02f,
  -9.57379490e-02f, 1.98775977e-01f, 1.86942935e-01f, 4.98912930e-01f, -4.77353364e-01f, -5.40100932e-01f, 4.30979490e-01f, 3.18202049e-01f, -1.76458225e-01f, -2.74100482e-01f,
  1.32287428e-01f, 1.93407774e-01f, -1.61497056e-01f, 2.16198444e-01f, 5.18903844e-02f, 4.18983549e-01f, -1.37845188e-01f, -1.67066958e-02f, -3.86080235e-01f, -7.50585571e-02f,
  -1.00771889e-01f, 2.94475883e-01f, -5.61432466e-02f, 1.28086790e-01f, 1.38164803e-01f, 1.58961102e-01f, -3.29196483e-01f, 3.35895985e-01f, -3.95463929e-02f, 9.67281908e-02f,
  1.47124872e-01f, -2.78721806e-02f, -2.61661202e-01f, -1.59149975e-01f, -6.09744154e-02f, 6.54422790e-02f, -3.04527670e-01f, -2.02017233e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.04572587e-03f, 1.42362654e-01f, 5.89035749e-02f, -4.60863225e-02f, -1.46383476e-02f, -6.42962083e-02f, 4.06346731e-02f, 8.37612748e-02f, 2.95693260e-02f, -3.69469225e-02f,
  3.25509310e-02f, 3.96559611e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    