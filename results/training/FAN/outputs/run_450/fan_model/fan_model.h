/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.67641497e-01f, -2.53360420e-02f, -1.18469276e-01f, -7.44337291e-02f, -1.24235630e-01f, -1.39877588e-01f, -5.21669798e-02f, 4.24472541e-02f, -7.70578533e-02f, 4.79556881e-02f,
  1.41752183e-01f, -2.88558304e-01f, 1.72774076e-01f, -2.50222743e-01f, -2.88096666e-01f, 2.13044688e-01f, -5.68943806e-02f, -1.14487275e-01f, 2.78628524e-03f, 5.64155122e-03f,
  -1.14530779e-01f, -9.88248587e-02f, 4.30838466e-02f, 2.73386594e-02f, -1.98798224e-01f, 8.21705014e-02f, 1.45906538e-01f, 2.72939522e-02f, -4.11128514e-02f, -1.06311336e-01f,
  -2.73643509e-02f, -3.36677134e-02f, -2.23371312e-02f, -1.02414833e-02f, 7.44893327e-02f, 3.36642656e-03f, 2.40528062e-02f, -2.51330528e-02f, -5.38081191e-02f, 1.15814298e-01f,
  -2.18578596e-02f, -6.70625195e-02f, 8.13410152e-03f, -4.13604267e-02f, -1.13023497e-01f, -6.04730146e-03f, -6.85420930e-02f, -1.72480289e-02f, 2.89405733e-02f, -5.15807606e-02f,
  -2.88487710e-02f, -1.84163935e-02f, 3.07271834e-02f, 5.92246316e-02f, 1.31454589e-02f, 1.54839912e-02f, 2.13763770e-02f, 5.92395850e-02f, -1.86560042e-02f, -2.72839703e-02f,
  -3.39916497e-02f, -4.75194640e-02f, -1.63494442e-02f, -4.73533291e-03f, -6.48643523e-02f, 8.92905071e-02f, -3.98625247e-02f, 1.23978418e-03f, -3.87931913e-02f, -5.27446158e-02f,
  1.66606177e-02f, -4.97552902e-02f, 5.63815869e-02f, 1.08670332e-02f, -2.17834339e-02f, 2.19375119e-02f, -1.87945049e-02f, 5.37349805e-02f, 1.09750535e-02f, -1.33294966e-02f,
  3.60237360e-02f, -3.66764329e-02f, 4.39386331e-02f, 1.02357037e-01f, 6.25022873e-02f, 2.48885397e-02f, -1.06293201e-01f, -8.28105882e-02f, 1.07103631e-01f, 1.93918366e-02f,
  5.78514524e-02f, 1.78316966e-01f, 5.65753356e-02f, 2.20449152e-03f, 9.26040858e-03f, -1.46245835e-02f, -7.29151070e-02f, -4.17507254e-02f, 1.38827283e-02f, -5.42635433e-02f,
  -9.49311443e-03f, -9.50746238e-03f, -5.34116365e-02f, -2.46308483e-02f, -7.96659142e-02f, 9.65747312e-02f, 9.58128944e-02f, 1.48017062e-02f, -2.42502610e-05f, -8.19822028e-03f,
  -1.97477601e-02f, 1.39078712e-02f, -1.11568905e-02f, 4.42581996e-03f, -1.94596928e-02f, 3.03463638e-02f, -5.67972586e-02f, 2.17530262e-02f, -3.01596932e-02f, 2.71321498e-02f,
  2.16017723e-01f, -2.05482244e-01f, -2.91437209e-02f, -1.69926807e-01f, -7.09675550e-02f, -3.40673774e-01f, -1.24726661e-01f, -1.26068085e-01f, -1.30713627e-01f, -1.39694422e-01f,
  5.38021177e-02f, -1.42599223e-02f, 8.77860263e-02f, -5.91904745e-02f, 3.21233533e-02f, 1.63810439e-02f, -2.28650406e-01f, -8.93044993e-02f, 5.29164225e-02f, -2.01089635e-01f,
  -2.32128259e-02f, -2.08278403e-01f, 2.97251306e-02f, -1.25288442e-01f, 6.63259402e-02f, -1.78513546e-02f, -1.11124245e-03f, 1.08004913e-01f, 2.19963603e-02f, 4.28086706e-02f,
  7.44374841e-02f, 4.84102853e-02f, 3.76591645e-02f, 8.82804692e-02f, -9.72889066e-02f, -9.32622422e-03f, -3.45377624e-03f, 1.21345222e-01f, 4.04493734e-02f, 9.96641293e-02f,
  4.43933755e-02f, -5.41357906e-04f, -1.50003722e-02f, -3.60757969e-02f, -5.30018890e-03f, 7.87912905e-02f, 3.97226028e-02f, 2.97921058e-02f, 6.52575940e-02f, 1.23752616e-01f,
  9.31121856e-02f, 1.16255112e-01f, -5.44217750e-02f, -2.49058679e-02f, 3.43726054e-02f, -6.07403778e-02f, -1.48087069e-01f, 4.35628816e-02f, 5.47307022e-02f, -1.00653037e-01f,
  4.98608537e-02f, -2.56134123e-02f, 6.05915934e-02f, 1.26196116e-01f, -2.87203975e-02f, 8.41218308e-02f, -1.00323092e-02f, -6.41973689e-03f, -1.36061097e-02f, -5.65320030e-02f,
  -3.36322077e-02f, -4.31775339e-02f, -2.71095689e-02f, 9.64989588e-02f, -1.01803601e-01f, -2.65148133e-02f, 3.11908387e-02f, 5.01776226e-02f, 1.58255734e-02f, 1.19212661e-02f,
  8.46572518e-02f, -3.55745926e-02f, 8.20978954e-02f, 1.03240341e-01f, -1.56684257e-02f, 4.63833772e-02f, 1.03508592e-01f, 7.22806305e-02f, 2.76651364e-02f, -3.47119607e-02f,
  -2.32358173e-01f, -2.34764561e-01f, -1.80916919e-04f, -1.90606322e-02f, -3.33574996e-03f, -6.03116304e-03f, -5.79978526e-03f, -4.80170809e-02f, -2.42313053e-02f, 3.67840715e-02f,
  -7.48121813e-02f, -1.15560345e-01f, -7.93756172e-02f, 1.03655048e-01f, -6.74645184e-04f, -6.84667677e-02f, -8.46969523e-03f, -4.56149764e-02f, -7.28260502e-02f, 8.34908220e-04f,
  2.82812323e-02f, -6.01828247e-02f, 8.25132150e-03f, -1.32099852e-01f, -1.44118845e-01f, 9.18566883e-02f, -1.28917322e-01f, 6.43192679e-02f, 1.03201479e-01f, -5.58491535e-02f,
  -7.73462653e-02f, 1.24534935e-01f, -2.19183132e-01f, -8.48865882e-03f, 1.23468302e-02f, -2.97183722e-01f, -1.26958266e-01f, 1.21956892e-01f, -3.37946087e-01f, 2.82826662e-01f,
  1.30674392e-01f, 3.62768210e-03f, -1.00087292e-01f, 1.46538556e-01f, -2.19345450e-01f, -2.75512785e-01f, 6.49382845e-02f, -3.21248733e-02f, -1.74412534e-01f, 2.43911311e-01f,
  -7.23432824e-02f, 1.93847492e-01f, -8.98044333e-02f, 1.02059275e-01f, 1.03793435e-01f, -2.17091870e-02f, 1.78537428e-01f, -3.90372751e-03f, 1.30038366e-01f, 6.60682693e-02f,
  -3.46837007e-02f, 1.09934680e-01f, -1.21515179e-02f, -8.91821831e-02f, 1.17816143e-02f, -4.95977066e-02f, -4.56452137e-03f, 1.13075189e-02f, -1.55151561e-01f, 2.18933518e-03f,
  5.00741741e-03f, -7.35628477e-04f, -1.17458189e-02f, -6.65238053e-02f, -1.74454302e-01f, -6.58654198e-02f, -1.17834002e-01f, -3.41886543e-02f, 2.26756725e-02f, -7.97385350e-02f,
  -5.35870418e-02f, -8.18713158e-02f, -1.27406538e-01f, 5.08356653e-03f, -7.49420747e-02f, -4.40381169e-02f, -7.18117133e-02f, 2.27192231e-03f, 1.40174404e-02f, -7.20840544e-02f,
  2.20629550e-03f, -6.39670268e-02f, -6.72357064e-03f, 2.76203770e-02f, 5.40864430e-02f, 1.50248274e-01f, -4.15968299e-02f, 6.75482526e-02f, -8.55925456e-02f, 4.71476465e-02f,
  1.07781917e-01f, 1.65971182e-02f, -2.70023886e-02f, -9.35266092e-02f, 9.14110802e-03f, 1.39033377e-01f, 2.94414926e-02f, -1.44417053e-02f, -7.61696696e-02f, 3.33722644e-02f,
  2.61035413e-02f, -3.06797791e-02f, 2.91853547e-02f, 2.85990741e-02f, 1.96500099e-03f, -3.56602073e-02f, -8.62137079e-02f, 1.17995637e-02f, 2.20528268e-03f, -5.45335263e-02f,
  8.10178667e-02f, 1.69353724e-01f, 2.66052186e-02f, -3.40009481e-02f, 4.97308895e-02f, 3.63616273e-02f, -1.28701143e-02f, 1.74372122e-02f, -4.65967543e-02f, 3.77041027e-02f,
  3.51774581e-02f, 3.87921073e-02f, -3.28659564e-02f, 1.98843405e-02f, -5.23936599e-02f, 2.40554102e-02f, 6.22159876e-02f, 2.17434447e-02f, 7.79979080e-02f, 3.34685259e-02f,
  1.72680944e-01f, 2.38324869e-02f, 4.01132815e-02f, 3.78816426e-02f, 2.89005041e-02f, 7.25582615e-02f, 3.30731161e-02f, -2.68886331e-02f, -3.11086327e-02f, -7.61507377e-02f,
  -1.47056907e-01f, -1.11201160e-01f, 6.40702769e-02f, -1.59721076e-01f, 5.53813130e-02f, 1.28435576e-02f, -1.58400759e-02f, -1.01879217e-01f, -1.36428261e-02f, -7.34099895e-02f,
  -2.03837723e-01f, 3.08949262e-01f, -2.82225490e-01f, -1.30198866e-01f, 4.49895523e-02f, -2.10150152e-01f, -9.14549548e-03f, -4.32097912e-03f, 4.88758497e-02f, -1.49669096e-01f,
  -5.06276600e-02f, -2.74525762e-01f, -1.15115941e-01f, -7.90510401e-02f, -5.38029373e-02f, 1.44248962e-01f, -8.62145349e-02f, 1.16814282e-02f, 1.76527321e-01f, 9.07491222e-02f,
  4.09569778e-02f, 2.38921680e-02f, 3.88471410e-02f, 7.18067959e-02f, -1.19207516e-01f, -1.49703985e-02f, 1.20795602e-02f, 7.72179142e-02f, 6.43550381e-02f, -3.16490210e-03f,
  -3.85625437e-02f, -2.21700165e-02f, -1.57519933e-02f, 1.53171336e-02f, 8.68228227e-02f, 1.88712236e-02f, 7.36305565e-02f, 2.73273233e-02f, 9.69300345e-02f, -2.78272983e-02f,
  -5.25415540e-02f, -3.23241800e-02f, -2.62433123e-02f, 2.52574645e-02f, 2.45370865e-02f, 6.07246868e-02f, 7.06091970e-02f, -2.47659571e-02f, 8.04819819e-03f, 3.17993127e-02f,
  -5.59993368e-03f, 8.22256878e-03f, -4.62982766e-02f, -5.08665442e-02f, 2.33641118e-02f, 2.01002304e-02f, -1.67129375e-02f, -3.27448100e-02f, 5.70848100e-02f, -2.96432860e-02f,
  -8.46659020e-03f, 3.68794277e-02f, -2.12020222e-02f, 1.43469190e-02f, -5.09343743e-02f, -3.74841574e-03f, 5.70885791e-03f, -2.55569965e-02f, -6.06050640e-02f, 6.43141661e-03f,
  -3.81784439e-02f, 1.56009654e-02f, 3.81499827e-02f, -7.05267265e-02f, -2.98966374e-03f, -9.35269985e-03f, -3.15594822e-02f, -6.53494000e-02f, 1.63728166e-02f, -1.86266284e-02f,
  -2.15245411e-02f, -1.15935259e-01f, -1.57033764e-02f, 3.47129069e-02f, 8.78788456e-02f, -5.63949719e-02f, -2.73514204e-02f, -9.17931646e-03f, 5.74438088e-02f, -9.81848501e-03f,
  -7.98034370e-02f, 2.69006100e-02f, 3.39447819e-02f, 5.45725692e-03f, 3.44716851e-03f, -5.38157932e-02f, -1.76926181e-02f, 5.48979193e-02f, -3.11774779e-02f, -2.43783253e-03f,
  -1.32605219e-02f, 6.49844063e-03f, -2.67512947e-02f, 3.68108302e-02f, 3.08185704e-02f, -7.38562271e-02f, 2.49987599e-02f, -1.38948821e-02f, -3.56882624e-02f, -3.49896103e-02f,
  1.12256981e-01f, 4.35166173e-02f, -3.28664295e-02f, -4.68793623e-02f, -7.30757043e-02f, 1.34841993e-01f, -1.17306905e-02f, -2.42081568e-01f, 1.36906132e-01f, 8.79440308e-02f,
  -3.89248729e-02f, 9.89898220e-02f, 1.27812475e-01f, -4.36041914e-02f, 3.12854558e-01f, 2.41985202e-01f, 1.03031300e-01f, 1.25971049e-01f, 4.10214588e-02f, 2.88631078e-02f,
  3.35453786e-02f, -4.12647985e-02f, -9.37615484e-02f, -2.27768347e-01f, -2.68881708e-01f, -2.43089318e-01f, -2.67748743e-01f, -1.07855916e-01f, -1.53879732e-01f, -1.59190688e-02f,
  5.26574403e-02f, 9.85989720e-02f, -1.33086964e-01f, 8.27226341e-02f, -3.40352010e-04f, -3.47913429e-02f, -2.93930992e-02f, 1.05393203e-02f, 2.34437529e-02f, 8.95065721e-03f,
  2.04209369e-02f, 7.18943626e-02f, 2.06597298e-02f, 7.27484524e-02f, 8.53713751e-02f, 1.84099544e-02f, 4.95012291e-02f, -8.44369680e-02f, 1.22091509e-02f, 2.46888269e-02f,
  5.76952065e-04f, 5.45082167e-02f, 5.52589167e-03f, 5.58599643e-02f, 6.23294944e-03f, 8.45553055e-02f, -5.60170747e-02f, -8.81487727e-02f, -7.24686161e-02f, 8.79007764e-03f,
  6.14144877e-02f, -1.52407922e-02f, -1.26919061e-01f, -6.02836125e-02f, -6.09587040e-03f, -9.97999310e-02f, 1.50682166e-01f, -4.19530198e-02f, -5.47896028e-02f, 2.17312928e-02f,
  1.50430889e-03f, 3.15345116e-02f, 2.19867490e-02f, 3.67931575e-02f, -6.03261329e-02f, -7.75558501e-02f, -5.52030513e-03f, -7.28584230e-02f, -2.07634680e-02f, -8.15240964e-02f,
  9.45117623e-02f, 5.27931675e-02f, -4.00474370e-02f, -5.89981079e-02f, 3.02997716e-02f, 9.99398381e-02f, -2.37146281e-02f, 4.93937656e-02f, -1.14881523e-01f, -1.02404812e-02f,
  1.03026174e-01f, 8.70522037e-02f, -8.19346681e-02f, -1.03924405e-02f, -2.66252887e-02f, -1.03736557e-02f, 3.24964598e-02f, 5.57886139e-02f, 1.23843081e-01f, -6.62918240e-02f,
  -1.26910852e-02f, -3.88461426e-02f, 2.35221554e-02f, 5.77595644e-02f, -4.49822694e-02f, 4.96771373e-02f, -1.90166458e-02f, 3.05462498e-02f, -1.58512488e-01f, 7.38522261e-02f,
  -6.07833192e-02f, 8.13797861e-02f, -2.52849404e-02f, -9.65117440e-02f, 6.41942071e-03f, -1.17135914e-02f, -8.35317299e-02f, 8.00440684e-02f, 1.40558491e-02f, 1.85124148e-02f,
  -3.90679061e-01f, 1.55130118e-01f, 8.22954476e-02f, -2.01016933e-01f, 2.74666362e-02f, -7.40985870e-02f, -1.19758700e-03f, -6.16674535e-02f, -1.26395494e-01f, 1.51362330e-01f,
  -1.15313105e-01f, 1.16354421e-01f, 1.08225429e-02f, -1.37521416e-01f, -4.61307496e-01f, -1.67793348e-01f, -3.20348024e-01f, 4.56763841e-02f, -1.56359792e-01f, 7.91443698e-03f,
  -1.50794044e-01f, -2.79929638e-01f, -5.35141565e-02f, -3.75027917e-02f, 8.85948539e-02f, 2.04882577e-01f, -3.01448498e-02f, 6.53396174e-02f, 5.59989475e-02f, -9.89485905e-02f,
  3.97573523e-02f, 2.21188907e-02f, 6.79570362e-02f, 2.73597576e-02f, -1.91118754e-02f, 5.16150631e-02f, 8.70906413e-02f, 2.44608130e-02f, -5.13371006e-02f, 4.86729816e-02f,
  5.14927879e-02f, -8.82957801e-02f, -7.89229423e-02f, -9.09558535e-02f, -3.93285155e-02f, -2.34198570e-03f, 3.95453200e-02f, 5.51916361e-02f, 4.59291749e-02f, -5.24894111e-02f,
  3.48254107e-02f, 1.21417912e-02f, -4.74038459e-02f, -1.49739590e-02f, 1.02818551e-04f, -5.78718148e-02f, 2.89788060e-02f, 4.51254733e-02f, 6.81907311e-02f, -1.11227408e-01f,
  -3.87883075e-02f, -9.49760899e-03f, 6.48046881e-02f, 3.54062580e-02f, -7.59864822e-02f, 2.06999313e-02f, -9.15451795e-02f, 9.71530471e-03f, -7.24144131e-02f, 1.51580386e-02f,
  9.67520941e-03f, -2.11444385e-02f, -1.46663859e-02f, -6.65990030e-03f, -4.61730175e-02f, 8.85628313e-02f, -7.67412484e-02f, 1.14270069e-01f, -2.12607030e-02f, -1.45456882e-03f,
  7.59824961e-02f, 1.64578538e-02f, 1.13369800e-01f, 3.25122438e-02f, 5.08824997e-02f, -1.28142834e-01f, -5.11797108e-02f, -2.85427552e-03f, -2.61266995e-03f, -9.72263515e-03f,
  4.08216985e-03f, 6.33016303e-02f, 2.38566808e-02f, 1.39411222e-02f, 4.81509790e-02f, -4.16103825e-02f, -6.92829043e-02f, -1.03507027e-01f, 2.02911329e-02f, -6.82865083e-02f,
  6.13013767e-02f, -2.70513329e-03f, 1.14016347e-01f, 3.55990753e-02f, -4.54267152e-02f, -4.70697274e-03f, 4.49625179e-02f, 2.57744491e-02f, -5.16717881e-03f, -5.55096529e-02f,
  5.72073385e-02f, 5.72615396e-03f, -1.49628326e-01f, -2.14440711e-02f, -2.87267230e-02f, 4.45405506e-02f, -1.59434546e-02f, 2.79619750e-02f, -8.26658458e-02f, 3.48944552e-02f,
  6.09952584e-02f, -3.19190085e-01f, -2.26531744e-01f, 1.60393082e-02f, 2.71370202e-01f, 1.87580749e-01f, 1.98275059e-01f, -1.58962533e-02f, -1.66482747e-01f, -2.52985619e-02f,
  1.51293606e-01f, -3.37636352e-01f, -1.19787820e-01f, 9.69846919e-02f, 1.91767499e-01f, -2.14848876e-01f, 7.74937272e-02f, 2.11795811e-02f, -5.70303649e-02f, 6.77556023e-02f,
  -2.96710096e-02f, 2.04213142e-01f, -6.59167767e-02f, -5.47049679e-02f, 5.83646772e-03f, -3.10025979e-02f, 2.29959354e-01f, 1.03854360e-02f, 1.23026185e-01f, -4.52297218e-02f,
  1.05535917e-01f, -7.93965459e-02f, -1.71743762e-02f, -4.24550250e-02f, 1.21388296e-02f, 1.17915295e-01f, 7.00691417e-02f, -5.20006195e-02f, 6.91313893e-02f, -1.05411939e-01f,
  -9.13294256e-02f, 7.05106407e-02f, -2.09645890e-02f, 2.87507456e-02f, 1.04091525e-01f, 5.74261434e-02f, -1.18843429e-01f, 3.04606203e-02f, -1.33345723e-01f, -1.13394652e-02f,
  -1.18287109e-01f, -2.80947424e-02f, 1.20669842e-01f, -5.17909303e-02f, 9.74605232e-03f, -4.13136482e-02f, 5.20976186e-02f, -5.78619540e-04f, -4.48807776e-02f, -2.29971879e-03f,
  -1.32467144e-03f, -2.60832738e-02f, 7.28816912e-02f, 1.58453863e-02f, 3.76409814e-02f, -5.84681444e-02f, -8.09136964e-03f, -1.48417922e-02f, -7.80759752e-02f, -4.49171886e-02f,
  3.04284040e-03f, -3.64526315e-03f, -8.68425891e-03f, 2.66727321e-02f, 2.24242657e-02f, 2.78544296e-02f, 2.11976916e-02f, 2.60896678e-03f, -4.18066513e-03f, -1.84794385e-02f,
  -1.11239534e-02f, 2.36486830e-02f, -3.91129777e-03f, -4.32413556e-02f, 9.82053578e-03f, 1.25092819e-01f, 3.35569829e-02f, 3.52808647e-02f, 2.23153364e-02f, -3.04315872e-02f,
  -4.80921902e-02f, -1.93655849e-01f, -1.17609166e-01f, -3.87170934e-03f, -1.15776099e-01f, 4.01853072e-03f, -6.59721121e-02f, -4.79160361e-02f, -6.63510486e-02f, -1.09830657e-02f,
  1.10640049e-01f, 2.81211473e-02f, -3.34819555e-02f, 4.53469455e-02f, 3.39542143e-02f, 2.16978379e-02f, 1.11730993e-02f, -7.44007975e-02f, -5.16830981e-02f, 2.59542558e-02f,
  6.83928058e-02f, 5.73212802e-02f, -9.22042876e-02f, 4.27586846e-02f, -2.69684810e-02f, -7.89740589e-03f, 3.38102318e-02f, -1.45078485e-03f, -4.28792685e-02f, -7.59435967e-02f,
  3.88592899e-01f, 9.60399210e-02f, 3.40199649e-01f, -8.58628899e-02f, 9.47835520e-02f, -2.18878966e-03f, 8.49611387e-02f, 6.76899254e-02f, 3.68621051e-01f, -1.68876261e-01f,
  -1.06482260e-01f, 2.41850361e-01f, 4.33879048e-02f, -1.59773931e-01f, 6.79724887e-02f, -7.12566078e-03f, -7.92604163e-02f, -7.63111115e-02f, 7.61645585e-02f, -3.16067301e-02f,
  5.40575162e-02f, -3.32787842e-01f, 1.97122712e-02f, -3.17025155e-01f, 6.33089170e-02f, 4.28113043e-02f, -1.77133039e-01f, -1.04417279e-01f, -2.95675606e-01f, 7.94667657e-03f,
  4.71902154e-02f, 1.00251690e-01f, 1.20671250e-01f, 7.07930177e-02f, 2.00112127e-02f, -4.98134457e-02f, -7.86294341e-02f, -6.88909665e-02f, 9.03586149e-02f, -4.55974974e-03f,
  -6.97734207e-02f, 3.41986157e-02f, -3.96657027e-02f, 1.29571389e-02f, -1.25642316e-02f, -2.63821185e-02f, -3.39475982e-02f, 1.44483209e-01f, 3.67271863e-02f, 1.73703686e-03f,
  1.20002694e-01f, -2.76996978e-02f, 1.42988442e-02f, 4.06463677e-03f, -1.09036556e-02f, 5.43707572e-02f, 1.48564503e-02f, 6.43346086e-02f, 6.32131519e-03f, -1.50405597e-02f,
  -7.24892095e-02f, -7.97596574e-02f, 1.24176750e-02f, 1.79315247e-02f, 2.68717716e-03f, 4.71214876e-02f, -9.30424482e-02f, -4.42381762e-02f, 7.08064213e-02f, -4.27964926e-02f,
  -2.35903375e-02f, 2.15042904e-02f, -3.79555449e-02f, -7.23842159e-03f, -7.44028240e-02f, 1.14329699e-02f, -4.61782478e-02f, -3.55594978e-02f, -8.59377440e-03f, 2.99755130e-02f,
  -6.48748875e-02f, -1.07115284e-01f, -1.19940378e-02f, -7.59138018e-02f, -3.89711633e-02f, 2.57941969e-02f, -6.63864389e-02f, 1.27332276e-02f, 5.06071560e-02f, -2.38346849e-02f,
  -1.02907971e-01f, -2.44578570e-01f, 3.10595706e-02f, -2.16561090e-02f, 2.60067116e-02f, -4.43297215e-02f, 2.20140330e-02f, -1.58886388e-02f, -9.04377177e-02f, -3.57138105e-02f,
  -2.56346110e-02f, -4.37526554e-02f, -4.75223437e-02f, -3.14877890e-02f, 1.33058215e-02f, -1.85024936e-03f, -9.52617675e-02f, -3.48754935e-02f, -2.64068041e-02f, -1.97424423e-02f,
  -7.29616135e-02f, -1.55147417e-02f, -1.70307234e-02f, -2.08049230e-02f, -2.75655147e-02f, -9.26671401e-02f, 5.61093446e-03f, 4.28900570e-02f, -1.51313782e-01f, -1.12069339e-01f,
  1.38091967e-01f, 1.45438522e-01f, 2.92989183e-02f, 4.51245718e-03f, -8.31526220e-02f, 1.70689493e-01f, 1.00621164e-01f, -1.27050839e-02f, 7.15884715e-02f, 4.08763625e-02f,
  -5.17340340e-02f, -1.87736735e-01f, 2.52076060e-01f, 1.00930758e-01f, 2.03966737e-01f, 2.90740639e-01f, 6.84923828e-02f, -1.26630023e-01f, 1.09545588e-01f, 3.27530620e-03f,
  1.04061767e-01f, 1.43751144e-01f, 2.50745565e-01f, 8.18749964e-02f, -4.75193150e-02f, -6.55078515e-02f, 7.49102309e-02f, 1.31720165e-02f, -1.88509852e-01f, 3.59933451e-02f,
  -7.14968666e-02f, 2.84360605e-03f, -7.71851540e-02f, 6.02480806e-02f, 5.63622899e-02f, -1.19133750e-02f, -1.03109621e-01f, 5.51203378e-02f, -9.68763083e-02f, 1.04509972e-01f,
  6.23603910e-02f, 2.63234209e-02f, 3.10603660e-02f, -4.29854840e-02f, -9.98264030e-02f, -3.09863314e-02f, 2.81982385e-02f, -3.51345725e-02f, -2.05625892e-02f, 3.69809344e-02f,
  7.97881410e-02f, -3.80423591e-02f, -8.89078677e-02f, -5.84887676e-02f, -7.07368925e-02f, -2.21149083e-02f, 5.89230657e-03f, 2.72213817e-02f, 1.06797758e-02f, 2.46562287e-02f,
  1.54868644e-02f, 5.23458868e-02f, 7.40527064e-02f, 6.98884502e-02f, 3.29171717e-02f, -8.32139421e-03f, 1.05114039e-02f, 3.81599413e-03f, -5.23621850e-02f, 5.97127900e-02f,
  -2.40929406e-02f, -4.30622557e-03f, -6.43079216e-03f, 2.27350183e-03f, -1.09376060e-02f, -1.98206119e-02f, -3.92041951e-02f, 4.41602282e-02f, -3.80731275e-04f, -3.81564274e-02f,
  4.72119190e-02f, 7.26226345e-03f, 4.36353050e-02f, 4.80361506e-02f, 6.93645328e-02f, -5.22672944e-03f, -1.18545722e-02f, 1.61338900e-03f, 2.96500139e-02f, 2.59752218e-02f,
  7.20533133e-02f, 8.57256055e-02f, 6.28253147e-02f, -1.09872766e-01f, -6.86086249e-03f, -4.47287932e-02f, 6.80094063e-02f, 3.26300040e-02f, 7.03434572e-02f, 1.59341171e-02f,
  -3.32435705e-02f, -3.10462154e-02f, -4.29631583e-02f, -8.58020261e-02f, 2.18535475e-02f, 4.79587959e-03f, -9.40215401e-03f, -2.42655282e-03f, 2.33836900e-02f, -4.39963825e-02f,
  -2.56591272e-02f, 5.01536466e-02f, 1.02826580e-02f, -3.50441858e-02f, 3.60526852e-02f, -1.16162589e-02f, -8.68723914e-02f, 2.10687947e-02f, -6.35896693e-04f, 4.14474942e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.72314197e-01f, 5.08632541e-01f, 3.70622396e-01f, 7.25057364e-01f, 3.67114991e-02f, -2.52596796e-01f, 1.65410385e-01f, 2.85610616e-01f, 5.12388766e-01f, -1.67512968e-01f,
  -1.59814373e-01f, 2.62358159e-01f, -8.32149535e-02f, 1.87249780e-01f, 7.27272825e-03f, -3.25430073e-02f, 2.62647778e-01f, 1.11283123e-01f, 3.49718034e-01f, 2.52797723e-01f,
  1.80821657e-01f, -2.10479319e-01f, 1.24391988e-01f, -1.30082831e-01f, -4.50802520e-02f, 2.01718643e-01f, -7.64321461e-02f, 1.81092814e-01f, -1.49077237e-01f, -1.33575007e-01f,
  -1.78445384e-01f, 3.69227558e-01f, -9.69500467e-02f, 9.03331861e-02f, -3.57795842e-02f, -8.50664824e-02f, -1.40528558e-02f, -5.20375893e-02f, 1.75803760e-03f, -8.25111121e-02f,
  -4.07953002e-02f, -8.63641221e-03f, -3.00668366e-02f, 9.62981395e-03f, 1.65880814e-01f, 6.06020205e-02f, 7.13328868e-02f, 5.23085855e-02f, 9.29544270e-02f, -7.11951330e-02f,
  9.04923212e-03f, -8.22790265e-02f, 3.68060097e-02f, 3.02923825e-02f, 5.06924093e-02f, 1.59247056e-01f, 5.79236299e-02f, -7.29184039e-03f, -1.60107091e-02f, 1.08474948e-01f,
  3.26307118e-02f, 1.06068335e-01f, 8.59719738e-02f, -1.45969270e-02f, 7.62433931e-02f, -5.34519218e-02f, 8.72145817e-02f, -1.04120538e-01f, 1.08255379e-01f, 1.61729637e-03f,
  -2.11398844e-02f, 1.00145033e-02f, -4.06952761e-03f, 4.19971980e-02f, 6.32598028e-02f, 2.41195429e-02f, -2.34742928e-02f, -1.71637051e-02f, 4.83226627e-02f, 1.60037354e-02f,
  1.04283534e-01f, 1.99896134e-02f, -9.34227183e-02f, -8.94664079e-02f, -9.42711756e-02f, 8.36996362e-02f, -2.13007014e-02f, 4.77916114e-02f, -5.55107817e-02f, -3.85822542e-02f,
  5.42542562e-02f, 5.48558593e-01f, -2.72862222e-02f, -1.00384191e-01f, 1.55803040e-02f, -9.59431976e-02f, -1.85809308e-03f, -8.01626369e-02f, 1.91332772e-01f, -3.25914635e-03f,
  1.59820430e-02f, -4.04058546e-02f, -5.37932850e-02f, 8.06565862e-03f, 1.09400961e-03f, -9.39958319e-02f, 3.92407700e-02f, 1.41098693e-01f, 9.04865637e-02f, 4.36694473e-02f,
  6.23666123e-02f, 3.26543339e-02f, -2.39821151e-02f, 2.33181454e-02f, -1.87517285e-01f, 2.25194935e-02f, 2.91542634e-02f, 2.53051147e-02f, -3.71989794e-02f, 5.17271832e-03f,
  -9.21685755e-01f, 3.27877283e-01f, -8.87130052e-02f, -3.08996558e-01f, 1.54869363e-01f, -1.95291862e-01f, -5.29898144e-02f, 1.58687562e-01f, -1.31778806e-01f, 2.56242484e-01f,
  1.87738955e-01f, -1.54541746e-01f, 3.70878547e-01f, 1.82513386e-01f, -4.13552225e-01f, 1.75894007e-01f, -2.40691915e-01f, -1.93899527e-01f, 1.68122977e-01f, -4.77710925e-02f,
  -1.08158469e-01f, 9.99875218e-02f, -2.81200763e-02f, 3.73790026e-01f, -1.39455393e-01f, -1.32130191e-01f, -2.64033582e-02f, 2.96814084e-01f, -2.26948231e-01f, 6.80370405e-02f,
  -3.64671946e-01f, 1.58054882e-03f, 1.55374222e-02f, -3.44993174e-02f, -1.63786262e-01f, -4.26428430e-02f, -1.54171661e-01f, 5.60605377e-02f, 3.56076360e-02f, -1.68739371e-02f,
  -9.28760320e-02f, 7.64438808e-02f, -5.58607914e-02f, 9.67552289e-02f, 2.09128074e-02f, 2.31808294e-02f, 5.10991439e-02f, -7.09152687e-03f, 1.57740086e-01f, 3.07794474e-02f,
  6.49776384e-02f, 4.10902612e-02f, -1.16855456e-02f, -7.39485621e-02f, 3.66460457e-02f, 6.31601065e-02f, -1.74469315e-02f, -9.60236937e-02f, -8.15036520e-02f, -3.48176509e-02f,
  -7.01405806e-03f, -1.15158565e-01f, 2.10817456e-02f, -3.61856148e-02f, 9.42895561e-02f, -3.16512734e-02f, 1.35936588e-02f, -8.42927955e-03f, 3.88523601e-02f, 7.55800009e-02f,
  -1.03960708e-01f, 2.29272107e-03f, 1.86141357e-02f, -1.46471277e-01f, -7.07291951e-03f, -8.35562870e-02f, 5.15059242e-03f, -8.64098668e-02f, -6.18483350e-02f, -4.43617925e-02f,
  3.10295504e-02f, -3.23353186e-02f, 1.18877534e-02f, 2.88856570e-02f, 5.54681420e-02f, 2.47255862e-02f, 6.55533373e-02f, 7.56989196e-02f, -4.18380485e-04f, -4.89708893e-02f,
  -5.31706870e-01f, -3.29104543e-01f, 1.18299220e-02f, -1.89404096e-02f, -7.29474872e-02f, -7.27841854e-02f, -5.83876506e-04f, 2.97739077e-02f, -5.62274270e-02f, -1.20209478e-01f,
  -1.03839755e-01f, -3.10282689e-02f, -2.13523284e-01f, 2.88815368e-02f, -7.06055537e-02f, -5.98358624e-02f, -4.61628400e-02f, -1.03090860e-01f, -2.10619017e-01f, -1.91979446e-02f,
  -4.73036356e-02f, -5.34277447e-02f, -2.00529546e-02f, 9.63314474e-02f, 7.01127499e-02f, -2.79493071e-02f, -6.85761869e-02f, 2.86840945e-02f, -6.00230470e-02f, -1.14904540e-02f,
  -3.56330156e-01f, 1.49881542e-01f, -4.06065077e-01f, 7.84545615e-02f, -2.76698649e-01f, 5.39044440e-01f, 4.75792289e-01f, 4.17814665e-02f, -9.13276523e-03f, 5.09333432e-01f,
  3.43132198e-01f, 9.91727691e-03f, 1.19974725e-01f, 5.84158242e-01f, 5.82726486e-02f, 4.05260921e-01f, 2.94734597e-01f, 2.94213921e-01f, -2.20627800e-01f, -1.31083027e-01f,
  -1.53389409e-01f, 2.33912200e-01f, 2.13624477e-01f, -2.71883458e-01f, 1.05978526e-01f, -4.37865883e-01f, -3.00092772e-02f, -2.55289137e-01f, 1.89982012e-01f, 3.36590894e-02f,
  2.55845375e-02f, -1.99997544e-01f, -8.87265876e-02f, -3.76100279e-02f, -4.66451235e-02f, -4.82403785e-02f, -6.16069883e-02f, 2.68646087e-02f, -1.05400458e-01f, -1.09971471e-01f,
  5.58037944e-02f, -1.35902241e-01f, 3.51700969e-02f, -6.80545270e-02f, -1.20329708e-01f, -2.46395003e-02f, 1.50358200e-03f, 3.37340645e-02f, -4.38140053e-03f, -1.70914251e-02f,
  -4.00186703e-02f, 1.50887631e-02f, 4.06645685e-02f, 9.92977917e-02f, -1.18345961e-01f, 1.23498425e-01f, 6.41500652e-02f, 4.66038734e-02f, 3.94737870e-02f, -1.28790282e-03f,
  -3.34182754e-03f, -1.83892205e-01f, -8.36924165e-02f, 2.83846818e-02f, -4.26523909e-02f, 8.27890635e-02f, 7.16625825e-02f, 2.75537483e-02f, -5.25576510e-02f, 5.89357018e-02f,
  -2.69093346e-02f, -5.31757548e-02f, 5.22553213e-02f, 3.25157009e-02f, 3.84385213e-02f, 3.73395160e-02f, 3.46096270e-02f, -3.44820581e-02f, -3.80227007e-02f, 1.44944191e-01f,
  4.61191274e-02f, -8.05353895e-02f, -3.77692282e-02f, 2.89000161e-02f, -3.43291163e-02f, -1.10978000e-01f, 8.13579112e-02f, 3.83705907e-02f, -8.88118579e-04f, -3.12006306e-02f,
  2.14306697e-01f, -2.45755807e-01f, -6.72729164e-02f, 1.14020500e-02f, -6.64602295e-02f, -3.89462803e-03f, 6.09709546e-02f, -7.88940713e-02f, -7.40261301e-02f, -1.00208171e-01f,
  -1.77986491e-02f, -1.58429462e-02f, 3.66035551e-02f, 9.36613828e-02f, 1.33148464e-03f, -4.48644012e-02f, 6.18811511e-02f, -1.29388034e-01f, 1.51317313e-01f, -8.13884512e-02f,
  4.23800834e-02f, -1.66088328e-01f, -5.63162491e-02f, -7.31730685e-02f, 5.92645593e-02f, 1.57303944e-01f, -1.19461104e-01f, -9.89236236e-02f, -7.97908902e-02f, 4.47726995e-02f,
  5.56793809e-02f, -4.50963750e-02f, 4.40611601e-01f, 1.67272329e-01f, -1.15067504e-01f, 2.03370988e-01f, 5.27538478e-01f, -3.30051005e-01f, -5.94105162e-02f, -3.87456827e-02f,
  -1.54239997e-01f, 4.33454156e-01f, 1.79762408e-01f, 5.17614000e-02f, 4.30551708e-01f, 7.65490159e-02f, -1.68466836e-01f, 6.03770651e-02f, 2.10682955e-02f, -4.24443707e-02f,
  -1.89528659e-01f, -3.74149680e-01f, 5.58376946e-02f, -4.24055785e-01f, -2.62056272e-02f, 8.58457386e-03f, -1.38740405e-01f, 2.83156693e-01f, -1.13433294e-01f, 2.59469002e-01f,
  -8.44431221e-02f, -1.84376657e-01f, -9.87666994e-02f, -4.75998819e-02f, -2.08130125e-02f, 1.29695637e-02f, 2.37570480e-01f, 3.31246257e-01f, -4.81141657e-02f, -2.17312737e-03f,
  1.95993468e-01f, 1.63958333e-02f, -8.03986266e-02f, -1.69379562e-02f, -1.05801821e-01f, -4.10416462e-02f, -9.87151787e-02f, -1.00086689e-01f, 4.99120057e-02f, 2.97450572e-02f,
  2.05017999e-02f, 4.63729426e-02f, -4.27084006e-02f, 6.55953810e-02f, 1.75145268e-02f, -7.68261477e-02f, 6.43273890e-02f, 2.05199063e-01f, 3.14506032e-02f, 4.60413694e-02f,
  -1.10127151e-01f, -6.11426942e-02f, -4.34769914e-02f, -1.59355626e-02f, 2.64266487e-02f, -2.34431457e-02f, -3.51128876e-02f, 6.45959983e-03f, -7.02405646e-02f, -1.16214097e-01f,
  -1.87084936e-02f, -5.63937202e-02f, -4.45542410e-02f, -4.35906798e-02f, -6.01700880e-02f, -5.85496426e-02f, 9.50993225e-02f, 5.01533300e-02f, -2.14557089e-02f, 5.04090115e-02f,
  -1.87559277e-02f, 1.11473642e-01f, -1.00474358e-02f, 4.86988313e-02f, 4.11716886e-02f, 8.57310817e-02f, -1.19795695e-01f, 4.71551046e-02f, -3.86418663e-02f, 1.10187590e-01f,
  -3.21392938e-02f, -2.16637142e-02f, 1.34180253e-02f, -1.28244564e-01f, 4.77317758e-02f, -1.54570058e-01f, 1.61744449e-02f, -3.94920558e-02f, 9.93915275e-02f, -1.08802058e-02f,
  -7.80235380e-02f, 3.33885960e-02f, 4.62725125e-02f, 1.68244727e-02f, -6.08093627e-02f, -1.35028362e-01f, 7.54983053e-02f, -5.00701461e-03f, -7.38573968e-02f, -5.42735271e-02f,
  -6.43755049e-02f, 1.64645463e-02f, 7.45355934e-02f, -3.93519886e-02f, -1.29271597e-01f, 7.64760375e-02f, -7.14882016e-02f, -1.51258251e-02f, 8.12619403e-02f, 7.47101083e-02f,
  -1.66488275e-01f, -3.26574981e-01f, -8.99306759e-02f, -1.18423395e-01f, -2.09881380e-01f, -1.37511700e-01f, 1.83522105e-01f, -4.77333784e-01f, -2.42084429e-01f, -9.43963826e-02f,
  4.66546370e-03f, -2.36797370e-02f, 4.67809409e-01f, -2.01194525e-01f, 4.40139323e-01f, 3.74117225e-01f, -1.51795059e-01f, 9.98474658e-02f, -1.75463289e-01f, -3.08708698e-01f,
  -1.66322201e-01f, -2.17700437e-01f, 3.33313555e-01f, -4.16253090e-01f, -3.37281555e-01f, -2.70067930e-01f, 2.10138515e-01f, 6.17312044e-02f, -2.72729129e-01f, 1.16774701e-02f,
  -3.03209782e-01f, -2.84399658e-01f, -5.94635941e-02f, -3.36351641e-03f, -1.30437285e-01f, 9.70459804e-02f, 1.25806868e-01f, 2.13537216e-01f, 1.53705152e-02f, 8.21078569e-03f,
  1.42256811e-01f, -2.18809061e-02f, -2.34466478e-01f, 6.04866594e-02f, -1.31534800e-01f, -2.20127642e-01f, -9.94845107e-03f, 1.38648646e-03f, -1.89840272e-02f, 3.05115618e-02f,
  -1.80652086e-02f, -5.91868162e-02f, -9.19053331e-02f, 3.10623925e-02f, 1.84741616e-02f, -7.97853172e-02f, 1.66175365e-01f, 2.47201443e-01f, 3.36518278e-03f, -1.05489992e-01f,
  -8.57182816e-02f, 7.15490952e-02f, 5.54415584e-02f, -1.13854771e-02f, -5.66910133e-02f, -6.75158948e-02f, 3.23465876e-02f, 5.49290180e-02f, 7.60403648e-02f, -2.55353041e-02f,
  -6.86218143e-02f, 4.37309369e-02f, -1.23310141e-01f, 1.61878522e-02f, -2.79187318e-02f, 4.54137176e-02f, 1.08236775e-01f, -1.51373088e-01f, -5.60026467e-02f, 1.23889614e-02f,
  7.89919794e-02f, -1.09289989e-01f, -7.66860172e-02f, 1.68123081e-01f, -8.32272768e-02f, 1.50415972e-01f, -1.80094212e-01f, -6.86561838e-02f, 5.75646535e-02f, 1.35324553e-01f,
  -2.83578157e-01f, -2.45992422e-01f, 6.62418455e-02f, -1.07026219e-01f, 1.08513303e-01f, -1.06602982e-01f, -2.81708110e-02f, -1.37094840e-01f, -6.24789894e-02f, -7.98119903e-02f,
  -6.97277188e-02f, 8.66687894e-02f, -1.22535750e-01f, -7.22536296e-02f, -2.81684194e-02f, -3.41413952e-02f, 1.14354953e-01f, -3.14120986e-02f, 2.15470437e-02f, -1.73813790e-01f,
  5.18042669e-02f, 3.91868018e-02f, 5.74326105e-02f, -1.24929264e-01f, 4.70286347e-02f, 7.85707608e-02f, -1.05454713e-01f, -2.66960096e-02f, -3.55798006e-02f, -8.41820538e-02f,
  6.95637286e-01f, 2.95120716e-01f, 4.08660382e-01f, 4.08488750e-01f, 4.34803925e-02f, 2.36055236e-02f, 1.43403798e-01f, 1.35916501e-01f, 5.43229759e-01f, 1.86198540e-02f,
  -1.66391775e-01f, 3.78046453e-01f, -1.61879227e-01f, 1.86237037e-01f, -4.60163862e-01f, -2.45521918e-01f, 1.06537543e-01f, 1.10859044e-01f, 5.29019199e-02f, 1.47543743e-01f,
  4.01357487e-02f, -4.95329559e-01f, -5.72139658e-02f, -2.10981458e-01f, 3.13047767e-01f, 2.63336569e-01f, -4.74547982e-01f, -2.89776057e-01f, 7.12457076e-02f, -2.41045624e-01f,
  7.52688572e-02f, 3.81356254e-02f, 1.02685988e-01f, 5.29189128e-03f, 1.14370607e-01f, 5.39928935e-02f, -5.43024801e-02f, -1.03737786e-01f, -1.73319299e-02f, -6.99558470e-04f,
  6.16874769e-02f, -1.37877529e-02f, 4.31090267e-03f, -1.83639526e-02f, 4.23977412e-02f, 1.36800244e-01f, 8.67834389e-02f, 1.50788993e-01f, 1.90557212e-01f, 1.53482229e-01f,
  2.17864871e-01f, 1.79096833e-01f, 4.50851619e-02f, -3.78125869e-02f, 5.42949550e-02f, 7.19314516e-02f, -2.22147834e-02f, -1.81774911e-03f, 1.54489353e-01f, 6.25444949e-02f,
  -1.06877185e-01f, -9.57121477e-02f, -6.15883470e-02f, 4.61940505e-02f, -8.68683960e-03f, 1.03356419e-02f, -3.11969947e-02f, -1.01891220e-01f, 1.70668550e-02f, -7.92459492e-03f,
  6.68166801e-02f, 5.09231240e-02f, 2.64392998e-02f, 1.58606693e-01f, -2.45753042e-02f, 1.10019870e-01f, -3.67766358e-02f, -8.15509993e-04f, 4.50543202e-02f, 5.91307729e-02f,
  -1.53196724e-02f, -3.69462855e-02f, -1.64107000e-03f, 5.95916212e-02f, -3.71255837e-02f, -7.11527765e-02f, 9.91569757e-02f, 1.16789222e-01f, 4.67274264e-02f, -1.45962745e-01f,
  -2.32814476e-01f, -4.38067913e-01f, -1.68919004e-02f, 4.35833298e-02f, -7.89521933e-02f, -1.52588654e-02f, 5.03145382e-02f, 1.02942117e-01f, -8.75432715e-02f, 1.01080984e-02f,
  8.01611133e-03f, 6.22808784e-02f, -5.15556671e-02f, -1.00031327e-02f, -1.32093489e-01f, 1.02718743e-02f, -2.02890914e-02f, -1.43384293e-01f, -1.84177920e-01f, -8.89746174e-02f,
  2.57315002e-02f, -5.21031469e-02f, -8.83699022e-03f, 2.10400485e-02f, 6.50340319e-02f, -5.90407290e-02f, 6.36512041e-02f, 5.39324768e-02f, -1.15344778e-01f, -8.83743688e-02f,
  -8.30469310e-01f, 1.16687216e-01f, -1.27483964e-01f, -6.63120747e-01f, 1.90032274e-01f, 4.78310168e-01f, -2.68809408e-01f, 1.52120158e-01f, -3.55129778e-01f, 1.15990579e-01f,
  -1.17716350e-01f, -3.77543300e-01f, -1.54836280e-02f, -5.17032385e-01f, -6.85148239e-01f, -4.41704094e-01f, -4.56735253e-01f, -3.49118024e-01f, -2.03693911e-01f, -3.37735899e-02f,
  -3.14651877e-01f, -2.09450766e-01f, -1.58317432e-01f, 4.38447803e-01f, 6.93800524e-02f, 1.58309549e-01f, 1.15840316e-01f, 3.63190144e-01f, 1.02930196e-01f, 3.88739966e-02f,
  -2.28516519e-01f, -1.83382109e-01f, -5.08760959e-02f, 4.06107828e-02f, 1.20380558e-01f, 1.23344600e-01f, 2.67524850e-02f, -8.05115886e-03f, -6.56870976e-02f, -3.52550671e-02f,
  5.95314614e-02f, 1.52055724e-02f, -1.12275548e-01f, -1.39062349e-02f, -3.34863202e-03f, -2.53621489e-02f, -4.18114476e-03f, 1.96142681e-02f, -4.45958003e-02f, -5.88229150e-02f,
  -6.53047711e-02f, 6.97084442e-02f, -9.22658667e-03f, -7.03848749e-02f, -7.59925693e-03f, -3.67787704e-02f, -4.08053584e-02f, 2.50240937e-02f, 6.82939589e-02f, -1.94547232e-02f,
  -4.37245844e-03f, 1.92170835e-03f, 1.28973918e-02f, -5.43783903e-02f, -3.50783542e-02f, 9.49543193e-02f, 5.92812747e-02f, 7.15827197e-02f, 4.44445647e-02f, 2.27984693e-02f,
  2.58989241e-02f, -3.76749365e-03f, -1.08249955e-01f, -1.79450717e-02f, -9.23297778e-02f, -1.52193988e-02f, 2.06333362e-02f, -1.18323021e-01f, -5.30186296e-02f, -1.17240109e-01f,
  -8.48394483e-02f, 2.98915114e-02f, -4.33030762e-02f, 8.00833404e-02f, -6.91137463e-02f, 9.31470543e-02f, 5.23091406e-02f, 7.99773261e-02f, -2.58908868e-02f, 1.13149881e-02f,
  -5.70783950e-03f, 1.09588906e-01f, -1.95248686e-02f, 1.81945004e-02f, -6.35769740e-02f, 6.09245226e-02f, -9.90389362e-02f, 9.47252214e-02f, 1.04743056e-01f, 2.26794537e-02f,
  1.26667514e-01f, 8.46704915e-02f, 2.00078800e-01f, -8.02755132e-02f, 9.98053625e-02f, -9.50074941e-03f, 1.70604733e-03f, -5.01581207e-02f, 7.61545002e-02f, 4.56284285e-02f,
  1.28896490e-01f, 1.27926171e-01f, 4.77371402e-02f, 3.27840075e-02f, -2.27098726e-02f, 5.70401475e-02f, -7.70946033e-03f, 3.80881540e-02f, 4.85153385e-02f, 2.84547675e-02f,
  -4.53462064e-01f, 6.28639981e-02f, -4.28333312e-01f, -2.31742799e-01f, -3.91204298e-01f, -1.68637276e-01f, -8.21192339e-02f, 3.39802131e-02f, 2.19266817e-01f, 2.72415996e-01f,
  -5.72250076e-02f, 2.48538777e-01f, 5.71417689e-01f, -3.27664971e-01f, 7.54352510e-02f, 4.68491048e-01f, -3.20100814e-01f, -4.58848551e-02f, -5.45687834e-03f, -1.65043548e-01f,
  -3.07033956e-01f, -1.20959699e-01f, -3.00434083e-01f, -1.10666547e-02f, -5.47835052e-01f, -2.53609836e-01f, -3.05001318e-01f, -9.80906710e-02f, -4.97600824e-01f, -2.55156904e-01f,
  -5.21085024e-01f, 1.75320357e-01f, -2.21230432e-01f, -4.38311100e-02f, -2.82420814e-01f, -2.36748327e-02f, -5.01731150e-02f, 1.88723475e-01f, -9.62188765e-02f, 3.56151424e-02f,
  2.18315553e-02f, 1.40847012e-01f, -5.68089001e-02f, 1.54468760e-01f, -1.26563404e-02f, -2.81004738e-02f, -1.07970558e-01f, -2.33488977e-01f, 9.05213598e-03f, -6.42429590e-02f,
  1.03178360e-02f, -1.54470235e-01f, -2.74017423e-01f, -2.61814781e-02f, -2.50863850e-01f, -1.44382358e-01f, 4.12495360e-02f, -1.29290223e-01f, -1.59885615e-01f, -2.15997636e-01f,
  1.23764828e-01f, -5.67332879e-02f, 5.23323603e-02f, 6.15397990e-02f, 6.99487180e-02f, -6.21814057e-02f, -1.54002914e-02f, 5.56010380e-02f, -9.88034606e-02f, -1.21842787e-01f,
  -1.98870488e-02f, 4.99082729e-02f, 3.46093774e-02f, -8.13282803e-02f, 2.57818587e-03f, 1.86837941e-01f, 9.07377824e-02f, -3.58157419e-02f, -4.08272333e-02f, -2.00824663e-01f,
  3.52834351e-02f, 7.35191554e-02f, -1.04584105e-01f, -1.58179104e-01f, 4.28023413e-02f, 6.85517937e-02f, -3.31896394e-02f, 7.27035776e-02f, 1.23498410e-01f, -1.62454739e-01f,
  -4.11719114e-01f, -7.11009651e-02f, 1.20361929e-03f, 1.48892239e-01f, -2.97522340e-02f, 2.77750604e-02f, 7.00399503e-02f, -1.84523880e-01f, -1.72924120e-02f, 1.13653935e-01f,
  4.08221669e-02f, 5.24886325e-02f, -1.35723650e-01f, -1.07832504e-02f, 1.82865232e-01f, 3.86575848e-04f, 2.14956459e-02f, 4.74124923e-02f, -7.90950581e-02f, -1.57627955e-01f,
  -7.29675964e-02f, 1.77428991e-01f, 7.99591839e-02f, -1.06068075e-01f, -6.26365244e-02f, -1.43950939e-01f, -6.93582445e-02f, 5.61307482e-02f, -2.19982252e-01f, -1.90501288e-02f,
  2.30784528e-02f, -3.29419225e-01f, 1.63911521e-01f, 5.67733049e-01f, 1.53019037e-02f, -5.23925364e-01f, -6.18930399e-01f, 7.40597919e-02f, 1.47059381e-01f, -4.46616143e-01f,
  -1.07489869e-01f, 1.52838469e-01f, -3.99939150e-01f, 2.63818473e-01f, 5.51359773e-01f, -1.80943325e-01f, 1.60232082e-01f, 6.27820641e-02f, 2.45873004e-01f, 7.68676251e-02f,
  5.21143079e-01f, 3.17250937e-01f, 4.75204468e-01f, 1.61415994e-01f, 1.16354264e-01f, 2.87052482e-01f, 5.12476146e-01f, -1.78291693e-01f, 1.87247366e-01f, 5.79324365e-02f,
  -1.66242912e-01f, -3.56469192e-02f, 1.27740866e-02f, -9.04864296e-02f, 1.21021926e-01f, -1.61885828e-01f, -1.16662703e-01f, -1.68451220e-02f, 5.42206643e-03f, 5.61104305e-02f,
  -3.23589556e-02f, 2.19727699e-02f, 1.35619000e-01f, 2.66290903e-02f, -1.05575338e-01f, -8.44312180e-03f, 1.39889866e-01f, 8.71548280e-02f, 3.57025228e-02f, 5.28193191e-02f,
  -2.23636311e-02f, 5.87012526e-03f, -2.02668067e-02f, 1.07479461e-01f, 9.38689262e-02f, 5.97680248e-02f, -6.11338811e-03f, 3.76934744e-02f, -8.79039615e-03f, 1.21643417e-01f,
  -6.10096715e-02f, -3.74937872e-03f, 1.24790752e-02f, 1.10303015e-01f, 3.23663262e-04f, 1.42928332e-01f, 1.50429141e-02f, 2.90594921e-02f, 5.43182939e-02f, 7.42439926e-02f,
  1.15508743e-01f, 1.10248215e-01f, 5.98251075e-02f, -1.29535962e-02f, 1.57428365e-02f, -8.21183342e-03f, 6.30837027e-03f, -1.20670972e-02f, 2.96349637e-02f, 9.54323336e-02f,
  -2.38218214e-02f, 1.12520345e-02f, -1.13124296e-01f, -6.35211393e-02f, 2.20406875e-02f, 9.70950350e-03f, -2.76552178e-02f, -6.77644089e-02f, 3.52791548e-02f, -2.58446876e-02f,
  -1.80338815e-01f, 8.94807726e-02f, 7.03832954e-02f, 4.37294357e-02f, 7.52297342e-02f, -8.80539194e-02f, 1.01714628e-03f, 1.65678449e-02f, 4.79879640e-02f, -8.63514915e-02f,
  4.91278879e-02f, -1.39559684e-02f, -3.71162444e-02f, -1.08917788e-01f, 3.51753645e-02f, 1.60972793e-02f, 7.00053200e-02f, -2.38701254e-02f, 8.15416276e-02f, 3.20217386e-02f,
  3.13398778e-03f, -1.24695443e-01f, 4.77002114e-02f, -2.60948222e-02f, -3.42803597e-02f, -7.45285898e-02f, -9.80672017e-02f, 2.86472570e-02f, 5.43656275e-02f, 7.97301345e-03f,
  -8.56866896e-01f, 1.75180465e-01f, 7.36005425e-01f, -5.65856040e-01f, 5.23263924e-02f, 5.21430612e-01f, 3.16960096e-01f, 2.15270855e-02f, -2.81097531e-01f, -7.34843612e-02f,
  -9.45651457e-02f, -1.48522049e-01f, 3.53262305e-01f, 7.44514633e-03f, 3.90166819e-01f, 3.23011905e-01f, 1.76580213e-02f, -4.74760905e-02f, 1.24360703e-01f, -1.68050975e-01f,
  1.65573845e-03f, -1.39575362e-01f, 4.80703741e-01f, 4.17464338e-02f, -1.11792022e-02f, -1.29376054e-01f, -1.90101922e-01f, 2.19523340e-01f, -8.93934593e-02f, 1.24701872e-01f,
  -3.94317508e-02f, -2.50700295e-01f, -1.61228478e-02f, 6.66950271e-02f, 1.08894948e-02f, -7.01888800e-02f, 7.28297010e-02f, 5.75690418e-02f, -9.09416974e-02f, -1.24423929e-01f,
  -4.47809249e-02f, 1.20091610e-01f, -1.74376756e-01f, 1.98801327e-02f, -7.80196935e-02f, -1.24281859e-02f, 7.27628618e-02f, 1.14988960e-01f, 3.81336547e-02f, 7.83538669e-02f,
  2.20880687e-01f, 6.47722706e-02f, 7.86562711e-02f, -1.01097018e-01f, 1.12078317e-01f, -1.96075421e-02f, 6.09077364e-02f, 5.54431565e-02f, -2.70368848e-02f, -1.94934383e-01f,
  -6.26225546e-02f, 2.43057553e-02f, 6.71304464e-02f, -1.82628315e-02f, 7.56305009e-02f, -6.65809587e-02f, -1.38338059e-02f, -3.29992920e-02f, -7.25556491e-03f, -8.94508697e-03f,
  -6.26236498e-02f, -7.54756480e-02f, -2.12659454e-03f, -1.36937192e-02f, -2.85707880e-02f, -1.44652739e-01f, 2.95137372e-02f, 2.74935178e-03f, -3.93813327e-02f, 3.52816768e-02f,
  -3.83522622e-02f, -7.20905699e-03f, -1.40539957e-02f, -2.82666925e-02f, 3.82717289e-02f, 7.95140043e-02f, 4.17913310e-02f, 8.58090892e-02f, 7.73590617e-03f, 1.45608261e-02f,
  6.63032988e-03f, -3.79722446e-01f, -1.70995109e-02f, -4.79761176e-02f, -1.20021077e-02f, 4.37407149e-03f, 1.34998597e-02f, -6.19989112e-02f, -1.39413640e-01f, -7.70037025e-02f,
  -2.24903245e-02f, -9.54372436e-02f, -2.17672624e-02f, -2.33569182e-02f, 8.00175518e-02f, 4.71499264e-02f, -6.37841225e-02f, -1.39535785e-01f, -6.67655841e-02f, 2.45275535e-02f,
  -1.15746353e-02f, -5.03465384e-02f, 4.37387377e-02f, -9.49166864e-02f, -1.52616620e-01f, -1.43475952e-02f, -1.14760824e-01f, 2.71788500e-02f, 6.53936267e-02f, 8.88614878e-02f,
  1.02247611e-01f, 2.49471977e-01f, -6.96948217e-03f, -6.34708330e-02f, -1.70386285e-01f, -4.45785969e-01f, -3.55852276e-01f, -4.80125956e-02f, 2.04717979e-01f, 2.23575458e-01f,
  -2.40266144e-01f, 4.74062115e-01f, 2.04828292e-01f, -3.98775131e-01f, -3.15603256e-01f, -1.05289062e-02f, -4.67913002e-01f, -1.56947806e-01f, 3.47846597e-02f, -1.07757002e-01f,
  -2.50115186e-01f, -4.17263329e-01f, -2.48466343e-01f, -1.46932587e-01f, -2.92742729e-01f, 1.00944839e-01f, -1.99229166e-01f, -3.67655791e-02f, -9.55696851e-02f, -5.16993850e-02f,
  2.44823638e-02f, 4.64841165e-02f, 6.57425728e-03f, -4.22194414e-03f, -1.18417770e-01f, 1.90746114e-02f, -9.98878479e-02f, -8.99755061e-02f, -5.55209778e-02f, 9.22007188e-02f,
  1.31323740e-01f, 3.29021044e-04f, 9.83274877e-02f, -3.28755639e-02f, 3.03232973e-03f, 2.23238498e-01f, 1.60618156e-01f, 1.65215880e-02f, -3.19797099e-02f, 4.95248102e-02f,
  -1.92290135e-02f, 7.23177800e-03f, 6.91535920e-02f, 1.02865197e-01f, 4.53172214e-02f, 2.89666522e-02f, 9.96108726e-02f, 3.63609120e-02f, 6.37883171e-02f, 2.28429213e-01f,
  -1.05215289e-01f, -6.22420833e-02f, -9.42763761e-02f, 1.86921611e-01f, 4.51542698e-02f, -4.50744713e-03f, 6.09802082e-02f, -5.73300421e-02f, -6.13681832e-03f, 8.65826011e-02f,
  -4.24967222e-02f, 1.04985334e-01f, 1.72215663e-02f, -8.45936686e-02f, 3.10180057e-02f, 1.09475091e-01f, 5.66892773e-02f, 5.25244139e-02f, 2.39020381e-02f, 7.15839043e-02f,
  -6.30464628e-02f, -2.17160761e-01f, 8.70573446e-02f, 2.96279648e-03f, -7.91597217e-02f, 1.43011108e-01f, -4.07571383e-02f, 1.02072597e-01f, -7.74163008e-02f, -3.45384255e-02f,
  -1.70902431e-01f, -1.31476521e-01f, 1.47572532e-02f, 1.04890419e-02f, 2.94738300e-02f, -5.17250597e-02f, -1.65573835e-01f, -9.41758901e-02f, -9.60259810e-02f, -4.08378281e-02f,
  -5.68236336e-02f, -3.97207700e-02f, 8.13486427e-02f, -1.12959277e-02f, -1.58919562e-02f, -2.03226715e-01f, -1.53185010e-01f, -1.73196830e-02f, -1.23935066e-01f, 1.07746966e-01f,
  3.50631922e-02f, 2.81863473e-02f, 7.07935467e-02f, -3.96025069e-02f, -1.60148684e-02f, -4.74662054e-03f, 1.47609070e-01f, 4.25372086e-02f, 8.32192898e-02f, 9.10282508e-02f,
  -6.82050824e-01f, 5.95652223e-01f, -4.30330008e-01f, 2.15085119e-01f, -8.69296566e-02f, 5.75503588e-01f, 6.27338886e-01f, 7.30037242e-02f, 2.24787816e-01f, 3.59591842e-01f,
  2.21798029e-02f, 2.10462213e-02f, 1.45333201e-01f, 3.30657840e-01f, -2.32310876e-01f, 1.81055963e-01f, 2.81207234e-01f, 2.44313017e-01f, 8.55907723e-02f, -9.86767784e-02f,
  -2.03551948e-01f, 4.27829251e-02f, -3.15535903e-01f, -7.77657330e-02f, -2.19449729e-01f, -3.02631497e-01f, -1.29864678e-01f, -2.59653121e-01f, 2.44694669e-02f, 8.10159147e-02f,
  -1.89682424e-01f, -2.30351537e-01f, -1.03719346e-01f, -1.27572238e-01f, -1.55323923e-01f, -4.10282202e-02f, -9.03608873e-02f, -6.74229413e-02f, -3.40884514e-02f, 1.17856689e-01f,
  -3.47615853e-02f, -7.59747624e-02f, 1.09147206e-01f, 5.75611182e-02f, 1.72468975e-01f, 5.08731902e-02f, 1.00804130e-02f, 5.05117215e-02f, 9.51779857e-02f, -5.89877330e-02f,
  4.26266938e-02f, 5.24405129e-02f, -9.41586774e-03f, 1.01629220e-01f, -3.11058015e-02f, 9.25087333e-02f, 1.25942424e-01f, -5.56921586e-02f, 8.29033777e-02f, 1.33367941e-01f,
  -8.58936533e-02f, 7.26612925e-05f, 1.05346009e-01f, -9.00269374e-02f, 1.39539525e-01f, -1.00039970e-02f, 1.13101572e-01f, -1.77418247e-01f, 2.94826459e-03f, 3.69348228e-02f,
  4.81906310e-02f, 1.43299401e-02f, 3.51876882e-03f, 1.22204676e-01f, -2.13160599e-03f, 8.02311003e-02f, -1.04630746e-01f, -7.09170252e-02f, -2.12365258e-02f, -1.19886650e-02f,
  -2.22559571e-02f, 2.55911108e-02f, 9.91999656e-02f, -8.38888064e-02f, 1.24902323e-01f, 4.27169316e-02f, 6.35243580e-02f, -1.87085532e-02f, 1.25370210e-03f, -5.56890406e-02f,
  2.44224846e-01f, -1.42462226e-02f, 9.83274505e-02f, 9.82852057e-02f, 2.98942905e-02f, 2.81695207e-03f, 2.18971148e-02f, 2.30189767e-02f, 6.42223060e-02f, 6.81406409e-02f,
  -1.50382102e-01f, -6.15069568e-02f, -2.06177607e-02f, -7.17571229e-02f, -4.02816534e-02f, 9.09207091e-02f, 3.35323773e-02f, -9.53454673e-02f, -6.52932376e-02f, -1.13137446e-01f,
  6.21917099e-03f, -2.14004908e-02f, -3.86678651e-02f, 3.24581414e-02f, -2.55849282e-03f, -2.11912654e-02f, -2.19026469e-02f, -9.34503749e-02f, 6.19013561e-03f, 1.83788240e-02f,
  4.86891687e-01f, -5.33578336e-01f, 2.05503240e-01f, 1.54922634e-01f, 4.70403999e-01f, 2.95738190e-01f, 3.41490805e-01f, 2.25088000e-01f, 2.48119816e-01f, -4.37490880e-01f,
  5.42176946e-04f, -3.19144696e-01f, -1.42685086e-01f, -2.54851550e-01f, 4.56233978e-01f, -4.33758721e-02f, -3.36796641e-02f, -2.51182467e-01f, 7.53726438e-02f, -2.76188236e-02f,
  1.89566627e-01f, -5.87174259e-02f, 1.53953597e-01f, -3.25160384e-01f, -1.55002745e-02f, -9.29457322e-02f, -2.18136862e-01f, 7.12252557e-02f, -3.24347049e-01f, 8.39819908e-02f,
  -8.65964741e-02f, -1.73051283e-01f, -1.66995957e-01f, -1.50418460e-01f, -6.93787262e-02f, -6.19164184e-02f, -1.55610010e-01f, 1.21927202e-01f, 9.49122608e-02f, 4.93507311e-02f,
  -1.67358220e-01f, -2.34312508e-02f, -5.16191274e-02f, 1.37082890e-01f, 6.16108179e-02f, -2.22459678e-02f, 5.44925705e-02f, -1.02967314e-01f, 2.45588403e-02f, 4.78236414e-02f,
  1.15944736e-01f, -3.66958268e-02f, 9.60197859e-03f, -6.69724867e-02f, 2.92862561e-02f, 4.80565429e-02f, 5.06903860e-04f, -2.07378399e-02f, -6.42170459e-02f, 8.68187845e-02f,
  8.00816342e-02f, -2.60733310e-02f, -2.50866800e-03f, -5.16755730e-02f, 5.57362027e-02f, 1.45131454e-01f, 1.67506803e-02f, -3.05441208e-02f, -3.71893533e-02f, -6.75403178e-02f,
  6.75741583e-02f, -2.87900493e-02f, -2.59129964e-02f, 2.96293739e-02f, -1.89581290e-02f, 9.88538414e-02f, -4.06656377e-02f, -7.83414692e-02f, -9.24927369e-02f, 6.39433786e-02f,
  6.15344048e-02f, 2.44983565e-02f, 1.03813028e-02f, 4.78646047e-02f, 3.64737213e-03f, 9.04749893e-03f, -1.07600309e-01f, 8.21390674e-02f, 2.22303905e-02f, 1.36483973e-02f,
  -4.47879612e-01f, -5.24093747e-01f, -1.35242611e-01f, -8.17004517e-02f, -1.41392812e-01f, -1.10875890e-01f, -2.75953729e-02f, 6.10100813e-02f, -1.53432295e-01f, 2.68841889e-02f,
  -7.78453574e-02f, -1.42845288e-01f, -6.96486235e-02f, 8.08642060e-02f, -9.17402878e-02f, 7.51764178e-02f, -8.61017928e-02f, -1.96269110e-01f, -1.29264176e-01f, -1.35256290e-01f,
  -7.35895038e-02f, 2.70969085e-02f, 5.63893244e-02f, 6.09108172e-02f, -5.13845086e-02f, 1.21655762e-01f, 4.93235998e-02f, -6.43278807e-02f, -2.76237559e-02f, -3.89385590e-04f,
  -7.38297880e-01f, 1.74351349e-01f, -2.02284530e-01f, -5.68784364e-02f, -2.67193705e-01f, -3.61165196e-01f, -1.27701871e-02f, -2.18525410e-01f, -1.24722002e-02f, 2.32542992e-01f,
  -3.36925872e-02f, -2.96817310e-02f, 1.83702245e-01f, 1.11109488e-01f, -3.73843521e-01f, 2.05896646e-01f, -2.12611899e-01f, -2.01147404e-02f, 3.89236882e-02f, -3.31912339e-01f,
  -1.49048522e-01f, 1.37834325e-01f, -1.08208671e-01f, -1.02117568e-01f, -2.80249357e-01f, -1.08995423e-01f, 8.37428570e-02f, -1.39727518e-01f, 3.24355229e-03f, -6.57719150e-02f,
  -4.34550315e-01f, -1.03413746e-01f, -9.99965146e-02f, -1.43080920e-01f, -1.85526252e-01f, -7.29645491e-02f, -1.43704072e-01f, 3.38388681e-02f, 6.59052655e-02f, -1.52572945e-01f,
  -1.01712020e-02f, -9.24760923e-02f, -1.85568314e-02f, 1.02559343e-01f, -5.41774854e-02f, 2.13786531e-02f, -9.77300201e-03f, -1.46728203e-01f, -4.61855195e-02f, 6.69158921e-02f,
  8.37718695e-03f, -9.12860632e-02f, -5.27970605e-02f, 5.39622083e-02f, -1.62088037e-01f, -6.51648780e-03f, 4.09634970e-02f, 5.62227443e-02f, -1.16169401e-01f, -1.31559670e-01f,
  1.18198786e-02f, 7.67038465e-02f, -6.03894889e-02f, 1.02434672e-01f, 4.29019853e-02f, 1.07721342e-02f, 3.04709468e-02f, 9.56728756e-02f, 2.93661151e-02f, -5.41653782e-02f,
  -6.88464344e-02f, -3.33702937e-02f, -1.39957350e-02f, 2.12582219e-02f, -2.29196027e-02f, 1.74620692e-02f, 2.48365346e-02f, -1.13566466e-01f, -1.85584109e-02f, -4.56083119e-02f,
  -1.25632524e-01f, -1.90355089e-02f, 7.68294930e-02f, -3.02307401e-02f, -1.53567359e-01f, 6.72166934e-03f, -1.09808311e-01f, 8.02912191e-03f, -3.72523093e-03f, -1.32074669e-01f,
  -7.08505690e-01f, -5.40131629e-01f, -4.25220728e-02f, -1.03716508e-01f, -1.14379609e-02f, -8.58042091e-02f, 4.36505526e-02f, -3.57673801e-02f, -1.76079899e-01f, -8.52692127e-02f,
  -4.63384837e-02f, 6.23797625e-02f, -1.19127996e-01f, -3.19669000e-03f, 1.26784980e-01f, -6.64122635e-03f, -5.85589409e-02f, -2.06167772e-02f, -1.66465297e-01f, -1.26151085e-01f,
  -4.43395525e-02f, 2.40150895e-02f, 6.78780377e-02f, -1.16921002e-02f, 1.20646775e-01f, -3.22409198e-02f, 2.48486400e-02f, -5.64844208e-03f, -1.61316216e-01f, 6.84452951e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  4.09035414e-01f, 2.29305923e-01f, 2.44324759e-01f, 3.16905409e-01f, 1.44549295e-01f, 2.68882632e-01f, 6.84991121e-01f, 2.74184585e-01f, 2.57922590e-01f, 2.97205269e-01f,
  3.16081762e-01f, 4.51512992e-01f, 6.29034460e-01f, 2.22468436e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -5.38134910e-02f, 4.35862601e-01f, 7.75749190e-03f, -3.92946079e-02f, 1.01436362e-01f, -1.28553838e-01f, -8.90450403e-02f, -2.89261550e-01f, 4.09501325e-03f, 2.49030665e-01f,
  1.76979542e-01f, -3.04687709e-01f, -7.73353353e-02f, -4.45735455e-01f, -7.87126794e-02f, 7.00288638e-02f, 8.63422379e-02f, -1.29161894e-01f, -1.27280235e-01f, 2.92297244e-01f,
  -3.18554729e-01f, 1.36438117e-03f, -2.82824337e-01f, -2.40279675e-01f, 3.55353981e-01f, -3.40399286e-03f, 3.59261632e-01f, 1.41192436e-01f, -1.63346261e-01f, -1.04851313e-01f,
  3.30519170e-01f, 7.09692538e-02f, -6.20786324e-02f, -4.97534685e-02f, -1.87696844e-01f, -1.83053929e-02f, -3.02893430e-01f, -1.02866478e-01f, -2.16432571e-01f, -2.32818604e-01f,
  1.94702342e-01f, -3.42116863e-01f, 2.00680554e-01f, 3.75128686e-01f, -2.40176126e-01f, -3.22947353e-01f, -3.92374903e-01f, 3.42062384e-01f, -2.98876464e-01f, -1.68710440e-01f,
  -1.79639205e-01f, -1.70360252e-01f, 1.50620341e-01f, -2.74889886e-01f, -6.51756525e-02f, -1.87593251e-01f, 8.94140229e-02f, -2.76867986e-01f, 3.30925107e-01f, -3.54273647e-01f,
  -1.00437529e-01f, -3.36654261e-02f, 1.47291407e-01f, -4.04335737e-01f, -1.37504622e-01f, -1.49693504e-01f, -1.03111705e-02f, -2.16812059e-01f, 6.58949539e-02f, -1.96620181e-01f,
  -7.58786947e-02f, 5.25030717e-02f, 5.57134300e-02f, 2.37632737e-01f, -2.08066210e-01f, 2.34849408e-01f, -1.13762639e-01f, 6.91390643e-03f, 4.39218916e-02f, -3.35415989e-01f,
  -2.64076889e-01f, 6.96163550e-02f, 4.26954180e-01f, 2.40063980e-01f, -2.44593441e-01f, -9.82441828e-02f, -3.75263631e-01f, 3.19016725e-02f, -3.72078940e-02f, 2.02495113e-01f,
  -1.20018467e-01f, 2.71362178e-02f, -1.99283250e-02f, 2.74386913e-01f, -3.44719440e-01f, -4.65598665e-02f, 1.83838457e-01f, 3.46440300e-02f, -4.02634710e-01f, -1.09341897e-01f,
  -3.77414934e-02f, 3.91721353e-02f, 2.34668493e-01f, 5.29703014e-02f, -1.24029748e-01f, 5.74419856e-01f, 5.20095348e-01f, -2.31356129e-01f, -9.30952430e-02f, -1.95460320e-01f,
  2.62641519e-01f, -2.48939872e-01f, -6.68653101e-02f, -1.65497005e-01f, 8.24429840e-02f, 4.07137930e-01f, -1.49829343e-01f, -3.50662097e-02f, 3.74756813e-01f, -3.81321549e-01f,
  -2.32443228e-01f, -8.06410760e-02f, 1.96522355e-01f, 3.20102930e-01f, 7.57349059e-02f, -9.86203402e-02f, -4.33929684e-03f, 3.22414756e-01f, -1.27803952e-01f, -4.94201705e-02f,
  -9.32168390e-04f, 1.78671107e-01f, -8.08980092e-02f, -1.65934399e-01f, 1.84091359e-01f, -4.03177179e-02f, -1.59328163e-01f, 1.86784655e-01f, 4.29674745e-01f, -2.87809879e-01f,
  3.40554357e-01f, -3.70114744e-02f, 2.87624121e-01f, -7.51082599e-02f, 3.39057416e-01f, -9.81419757e-02f, -4.12645340e-01f, 3.51830065e-01f, -2.83097178e-01f, 3.07608750e-02f,
  3.09519004e-02f, -3.97017598e-01f, 2.36520037e-01f, -7.39251822e-02f, -1.48400031e-02f, 2.16320932e-01f, 1.86126754e-01f, -2.11254612e-01f, 1.86825752e-01f, 2.27635782e-02f,
  2.28515565e-01f, -1.93347901e-01f, 2.28627533e-01f, -9.90378764e-03f, -1.62779987e-01f, 7.70220160e-02f, 6.23168498e-02f, -1.95737258e-01f, -1.04717106e-01f, -7.00435519e-01f,
  6.34867027e-02f, 7.20916595e-03f, -6.96006045e-02f, 1.22582838e-01f, -3.89395118e-01f, 4.86506283e-01f, 4.02569950e-01f, 1.48339644e-01f, -3.51581812e-01f, -3.22987229e-01f,
  1.51493758e-01f, 1.96953386e-01f, 4.66695428e-02f, 1.69002771e-01f, 1.67243034e-02f, -2.26870626e-01f, -3.12815487e-01f, -9.33594704e-02f, 8.17031860e-02f, -9.36482102e-02f,
  2.00349554e-01f, -2.95588523e-01f, -2.30063841e-01f, -3.02313477e-01f, -3.10614526e-01f, -1.95066761e-02f, 1.60480123e-02f, -9.61450711e-02f, 1.68793961e-01f, 1.41134456e-01f,
  9.50969830e-02f, 3.12149853e-01f, 3.28759432e-01f, 2.12771758e-01f, -8.63606706e-02f, 5.11319220e-01f, 1.40279055e-01f, -3.29283595e-01f, -1.71000987e-01f, 2.56773144e-01f,
  1.59010246e-01f, 2.02190101e-01f, -5.92233017e-02f, -2.03215748e-01f, -3.15020382e-02f, -2.32590035e-01f, -2.33824596e-01f, 4.45239954e-02f, 1.34784684e-01f, -1.28935441e-01f,
  1.03172868e-01f, 3.06779683e-01f, -3.43904585e-01f, 4.12949502e-01f, -2.64015645e-01f, 3.36105339e-02f, -5.56738302e-02f, 7.34643415e-02f, -3.11153203e-01f, 6.52583688e-02f,
  3.64604928e-02f, 1.27432108e-01f, 9.71961543e-02f, -2.00158671e-01f, 2.00709105e-01f, 4.25572485e-01f, 1.05742030e-01f, 4.57010239e-01f, 1.58311948e-01f, 4.78043944e-01f,
  -3.29112977e-01f, -4.00876533e-03f, -4.92947221e-01f, -2.18261674e-01f, 2.09701538e-01f, 2.15899378e-01f, 3.28792930e-01f, -3.87068063e-01f, -2.77747124e-01f, -1.03242926e-01f,
  1.13713481e-01f, 7.36925974e-02f, 5.09446859e-02f, -5.96621213e-03f, -7.33191222e-02f, 2.60372490e-01f, 2.43916716e-02f, 2.51765907e-01f, -3.64550710e-01f, -4.45094891e-02f,
  3.76118332e-01f, -2.05652893e-01f, 1.06235147e-01f, -3.08938473e-02f, -4.24278639e-02f, 4.95183706e-01f, -1.68619722e-01f, 2.61242479e-01f, -3.49229902e-01f, 1.40428513e-01f,
  3.77823234e-01f, 3.68038230e-02f, -4.67790455e-01f, 2.38552764e-01f, 2.97541708e-01f, 2.90175140e-01f, 1.04028806e-01f, -1.37708306e-01f, -3.31763625e-02f, -1.43708542e-01f,
  4.90069091e-02f, 2.44965367e-02f, -9.14151743e-02f, 7.38673806e-02f, -1.83331251e-01f, 2.05203354e-01f, -3.60635638e-01f, 1.28897667e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.20515028e-01f, 3.78085017e-01f, 2.69836277e-01f, 2.60018498e-01f, 4.60493833e-01f, 3.10030282e-01f, 3.38259727e-01f, 4.41081107e-01f, 1.74400479e-01f, 3.28273386e-01f,
  -1.72572285e-01f, -3.87406826e-01f, -3.00130606e-01f, 6.04045630e-01f, 8.53458643e-02f, -2.52193958e-01f, -2.01168567e-01f, 4.93169129e-01f, 2.37797141e-01f, 3.37094426e-01f,
  3.99604350e-01f, 6.33169770e-01f, 4.98863071e-01f, -4.83916104e-01f, -1.52713224e-01f, 5.64798474e-01f, -5.76491833e-01f, 6.73365772e-01f, -3.68877709e-01f, 7.43043661e-01f,
  -2.58598030e-02f, 1.90234095e-01f, 6.34196997e-01f, 1.76740974e-01f, 4.19691317e-02f, 4.79489475e-01f, 6.06390499e-02f, 3.97067159e-01f, 1.09635092e-01f, -5.83140738e-02f,
  6.12896860e-01f, -6.29285574e-01f, -5.87173522e-01f, 5.02568245e-01f, -5.87523401e-01f, -3.90766948e-01f, -9.35723186e-01f, 6.12490952e-01f, -1.99912533e-01f, 2.06831515e-01f,
  5.69367230e-01f, -2.69868076e-01f, 2.08900437e-01f, -4.28561240e-01f, -6.93834066e-01f, 3.04667801e-01f, 5.10211051e-01f, -1.37629420e-01f, 5.68654537e-01f, -5.35906971e-01f,
  -2.90905833e-01f, 3.52357954e-01f, 4.97050494e-01f, -8.29210043e-01f, 1.21632941e-01f, 1.51027724e-01f, -7.36366734e-02f, 2.97087461e-01f, 2.71260202e-01f, -1.32069528e-01f,
  6.38010323e-01f, 1.48377821e-01f, -1.06800254e-02f, 2.07066461e-01f, -4.24749613e-01f, 9.00709569e-01f, -6.71614230e-01f, 2.82462895e-01f, 1.13356821e-01f, 1.01792777e+00f,
  -7.48428702e-01f, 1.31957397e-01f, -6.15222633e-01f, 1.81850120e-01f, 7.56284356e-01f, -3.91331196e-01f, 3.47722381e-01f, -4.24998790e-01f, 4.08100486e-01f, -2.94393718e-01f,
  -6.94466233e-01f, -2.60217488e-01f, -3.76478761e-01f, 3.98380458e-01f, -6.12450898e-01f, 3.42777461e-01f, 5.22515059e-01f, 8.19353014e-02f, -1.81736112e-01f, 5.12221277e-01f,
  8.83821249e-02f, 1.15554243e-01f, 4.27490145e-01f, 6.43225461e-02f, 5.13198495e-01f, 2.82873750e-01f, 8.05184543e-01f, -4.02432650e-01f, 1.95194572e-01f, -3.99273574e-01f,
  2.97993302e-01f, 1.14900701e-01f, 7.00655758e-01f, 6.57607540e-02f, -3.42340589e-01f, 3.27220052e-01f, -6.98472440e-01f, -2.81104222e-02f, 3.60232323e-01f, -4.83860485e-02f,
  7.75066197e-01f, 4.15188447e-02f, 4.35251743e-01f, 6.08654261e-01f, 4.84488726e-01f, -4.47664112e-01f, 8.72293234e-01f, 1.13489978e-01f, 1.39125571e-01f, 4.53110129e-01f,
  -9.85725150e-02f, 2.46873036e-01f, 6.47479534e-01f, 2.18016319e-02f, 4.67244506e-01f, 3.58511865e-01f, 2.60251850e-01f, 3.89942527e-01f, -2.07525894e-01f, 6.87734723e-01f,
  -6.73435152e-01f, 1.86483786e-01f, 2.64363382e-02f, 1.62324443e-01f, -4.44640696e-01f, 3.71697336e-01f, 1.34734869e-01f, 6.37612998e-01f, 3.81867260e-01f, -4.25384909e-01f,
  -8.74697119e-02f, -2.92427212e-01f, 4.39921945e-01f, -4.27234918e-02f, -1.86524376e-01f, 2.85836816e-01f, -1.05534337e-01f, 7.34921157e-01f, -3.21539253e-01f, 2.46112674e-01f,
  2.68093348e-01f, 7.01487362e-01f, 4.57678378e-01f, 4.49891627e-01f, 6.39225245e-01f, -3.89871411e-02f, 1.29701570e-01f, -4.76583689e-02f, 1.90918908e-01f, -2.34406918e-01f,
  -2.87491903e-02f, -5.83663464e-01f, 2.94601947e-01f, -3.77445638e-01f, 5.21487355e-01f, 1.75966650e-01f, 4.06531721e-01f, -1.61969274e-01f, 4.06221747e-02f, 1.78587884e-01f,
  -1.52461261e-01f, 3.88870031e-01f, -3.72479022e-01f, 1.06967342e+00f, 5.26074469e-01f, -4.41006035e-01f, -1.43679485e-01f, 7.45042086e-01f, 2.07942173e-01f, -1.11442506e-01f,
  7.48257577e-01f, -1.67256847e-01f, 1.10921584e-01f, 7.13917494e-01f, 3.30459714e-01f, 3.41432244e-01f, 5.85689545e-01f, -3.06012332e-01f, 1.24771222e-01f, 7.38623589e-02f,
  3.33414048e-01f, 1.95982754e-01f, 3.12636010e-02f, 6.13264330e-02f, 5.63552856e-01f, -2.04790339e-01f, 5.94548881e-01f, 2.03843504e-01f, -6.89809501e-01f, -4.21571344e-01f,
  -4.79374826e-01f, 4.52531159e-01f, 3.45895737e-02f, 4.89798903e-01f, -1.75961107e-01f, -4.98169452e-01f, 8.36595535e-01f, -2.49594808e-01f, 1.43533498e-01f, 8.31795990e-01f,
  3.16654779e-02f, 1.46372154e-01f, 8.97848979e-02f, 2.51296610e-01f, 3.47568005e-01f, 1.28605040e-02f, 9.00851339e-02f, 1.60265699e-01f, 2.48268694e-01f, 5.59995115e-01f,
  3.06847304e-01f, 4.61240292e-01f, 3.66009504e-01f, 7.48274088e-01f, -2.38458204e-04f, -5.98186314e-01f, 2.57803231e-01f, 6.61895335e-01f, 6.40594482e-01f, -6.93000197e-01f,
  -3.08691934e-02f, 5.00074267e-01f, 2.35507309e-01f, 6.76846743e-01f, 1.22219965e-01f, 2.11731624e-02f, 3.63627166e-01f, -2.04144135e-01f, 1.70430496e-01f, 8.58706474e-01f,
  -1.76300511e-01f, 5.40829003e-01f, 3.51142943e-01f, 4.30696368e-01f, -1.81738093e-01f, 6.24993622e-01f, 5.37207723e-02f, 1.07717969e-01f, 1.97782621e-01f, 3.73489335e-02f,
  3.34628165e-01f, -8.98588672e-02f, 2.19505399e-01f, 2.50147045e-01f, 1.64297849e-01f, 9.21035483e-02f, 7.51616061e-01f, 6.15038753e-01f, 5.41105092e-01f, -5.03644526e-01f,
  5.47230184e-01f, -5.34752190e-01f, 2.55527258e-01f, -6.44962668e-01f, 4.55449104e-01f, 4.51399535e-01f, -5.72799385e-01f, 6.72086626e-02f, -7.78738409e-02f, 5.55200219e-01f,
  6.31768286e-01f, 2.83353418e-01f, -2.39716172e-02f, -5.90184689e-01f, 7.33422995e-01f, -1.56702042e-01f, -5.18042743e-01f, 4.64456767e-01f, 5.60053170e-01f, 7.48797599e-03f,
  -7.94671327e-02f, 6.18410408e-01f, 1.45223349e-01f, 8.30720901e-01f, 2.04213485e-01f, 5.66596746e-01f, 4.41067338e-01f, -6.19219542e-01f, -9.46055576e-02f, -1.52223244e-01f,
  -3.54055166e-01f, 4.37659860e-01f, -8.78714681e-01f, 1.09751150e-01f, 2.79318213e-01f, 6.48353755e-01f, 1.04382150e-01f, -2.32310146e-01f, 7.78144524e-02f, 3.53452206e-01f,
  6.09050930e-01f, -5.38298726e-01f, -8.75934958e-02f, 2.84933597e-01f, 6.11404359e-01f, 4.08491582e-01f, 1.10995978e-01f, 2.00187147e-01f, 6.36220336e-01f, -2.34487697e-01f,
  3.79092604e-01f, -2.87735928e-02f, 1.62778139e-01f, 4.75716025e-01f, -2.07276776e-01f, 5.55842817e-01f, 1.13962114e-01f, 4.17419106e-01f, 4.67653453e-01f, -3.51001203e-01f,
  1.30738378e-01f, -6.09072387e-01f, 6.12799823e-01f, 2.17882454e-01f, -2.10928395e-01f, -4.86524284e-01f, 7.25673854e-01f, -3.11549336e-01f, 8.26529384e-01f, -1.03201307e-02f,
  -1.62877366e-01f, 4.42213267e-01f, 8.99513587e-02f, 6.31093264e-01f, -1.32953212e-01f, 7.22960651e-01f, 2.02731475e-01f, -4.51201856e-01f, 6.23925328e-01f, 1.21698663e-01f,
  6.16037369e-01f, 3.85811865e-01f, -8.71316418e-02f, 4.23281133e-01f, 4.42300051e-01f, 4.69196379e-01f, 1.19473562e-01f, -1.77477896e-01f, -5.95557503e-02f, 2.63135165e-01f,
  3.46423358e-01f, -4.61534321e-01f, -5.30589521e-01f, 7.79676378e-01f, 5.09510756e-01f, -1.72579765e-01f, 6.19952083e-02f, 8.31179559e-01f, -7.18275189e-01f, -5.64014018e-01f,
  -8.76919031e-01f, -3.74153465e-01f, 3.51765454e-01f, -2.99336344e-01f, -5.88865892e-04f, -5.63360214e-01f, 5.61779141e-01f, -5.17975569e-01f, 3.05430502e-01f, -5.74403703e-01f,
  7.02323169e-02f, 1.31708443e-01f, 4.02290747e-02f, -4.61363763e-01f, -1.15015261e-01f, 3.55992109e-01f, 4.02799368e-01f, 3.18628192e-01f, -1.18920930e-01f, 1.50896236e-01f,
  -3.63835454e-01f, 6.04100935e-02f, 3.08981538e-01f, -7.02317536e-01f, 1.40051082e-01f, -3.48628163e-01f, 6.34770095e-01f, -9.47304368e-02f, -3.95650834e-01f, 4.41807002e-01f,
  1.04821905e-01f, -4.91830111e-01f, -4.92170483e-01f, -6.21865511e-01f, 3.22304934e-01f, 7.70270407e-01f, 7.27101505e-01f, -4.97369677e-01f, -1.16700202e-01f, 7.47899637e-02f,
  3.05376798e-01f, 7.81970322e-02f, -3.48794162e-01f, -7.28794932e-01f, 5.12446463e-01f, -6.48202479e-01f, -2.17499197e-01f, 3.20745170e-01f, -1.19894274e-01f, 3.35132182e-01f,
  2.74175648e-02f, -6.40024021e-02f, -3.51794332e-01f, 3.82758766e-01f, 3.58645737e-01f, 2.90864736e-01f, 2.99061477e-01f, 7.04916120e-01f, 3.41719419e-01f, -6.85727775e-01f,
  2.45377794e-01f, -3.22109133e-01f, -7.24218011e-01f, -3.44108135e-01f, 6.03361368e-01f, 3.49672705e-01f, -5.28274357e-01f, -3.01947325e-01f, 4.65968205e-03f, -3.59115183e-01f,
  5.39627671e-01f, 3.24950188e-01f, 8.62877786e-01f, -7.58998573e-01f, 5.74001014e-01f, -3.18738967e-01f, -3.72306377e-01f, 3.35635960e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.17232531e-01f, 3.68252844e-01f, 3.64061505e-01f, 3.07262093e-01f, 3.44424635e-01f, 4.06343997e-01f, 1.62846297e-01f, 3.30327392e-01f, 1.58569038e-01f, 3.51515472e-01f,
  2.28229120e-01f, 2.88309216e-01f, 2.64633507e-01f, 4.89587188e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  7.15035647e-02f, 1.65381834e-01f, -8.96930844e-02f, 6.21082708e-02f, -4.85340245e-02f, -1.47280782e-01f, -3.15151185e-01f, -4.38778341e-01f, -5.82847059e-01f, -3.74843538e-01f,
  -3.02798599e-01f, -1.06161110e-01f, 4.89464730e-01f, -3.18096399e-01f, -5.43123543e-01f, 2.15894058e-01f, 4.21785921e-01f, -1.20997854e-01f, 4.47981209e-01f, -8.22641909e-01f,
  7.94741690e-01f, -9.36465979e-01f, 5.19997299e-01f, -2.34125599e-01f, -2.39089523e-02f, 4.14824307e-01f, -3.92100036e-01f, -3.67397696e-01f, -4.97330964e-01f, -7.62336671e-01f,
  -2.51534492e-01f, -2.41438493e-01f, -4.20354009e-02f, 4.26858693e-01f, 3.00029248e-01f, -1.43590704e-01f, -1.98067680e-01f, 2.39925653e-01f, 2.45512128e-01f, 2.68197328e-01f,
  1.64540544e-01f, -5.12910783e-01f, 5.90773940e-01f, -1.79265533e-02f, -5.52163899e-01f, -3.54197294e-01f, 7.51628757e-01f, 1.29511699e-01f, 6.29437566e-01f, 1.89813823e-01f,
  -8.84362012e-02f, 5.88856280e-01f, 6.60987079e-01f, -4.15804565e-01f, 5.15705168e-01f, -4.20250922e-01f, -4.89006191e-01f, -5.30560732e-01f, -6.22658491e-01f, 5.28394520e-01f,
  -6.21596575e-01f, 5.23079693e-01f, -4.04419839e-01f, -7.89660931e-01f, -1.21892378e-01f, -4.59679514e-01f, -2.67501473e-01f, 1.59953386e-01f, -4.10299301e-02f, 2.94175386e-01f,
  8.11018497e-02f, -9.23496410e-02f, 1.32393554e-01f, 3.54793310e-01f, 4.47305411e-01f, -2.71089911e-01f, -4.24401015e-01f, -1.20369811e-02f, -1.97265893e-01f, -3.53569120e-01f,
  5.06885648e-01f, -5.66412508e-01f, -4.61989939e-01f, 2.62772024e-01f, -5.86168051e-01f, -9.59590897e-02f, -7.41732240e-01f, -7.19837751e-03f, 4.24761683e-01f, -5.04113674e-01f,
  -4.08751696e-01f, -4.28442843e-03f, -3.53183389e-01f, 7.52918422e-01f, 7.39721537e-01f, 3.80025476e-01f, -2.69785851e-01f, -2.06606388e-01f, -4.40546662e-01f, -2.86516011e-01f,
  -2.95373619e-01f, -2.77386606e-01f, -3.22687298e-01f, -1.01636842e-01f, -3.63576502e-01f, 1.11952864e-01f, -2.37259746e-01f, 4.56189871e-01f, 1.50819659e-01f, -5.28413206e-02f,
  4.86544937e-01f, 6.07813060e-01f, -9.98541787e-02f, 1.49607658e-01f, -1.23892883e-02f, -1.00330484e+00f, -9.10390168e-02f, -2.36076917e-02f, 3.19337428e-01f, -1.46461263e-01f,
  1.98706508e-01f, 2.17204466e-01f, 5.44847488e-01f, -1.03762579e+00f, -1.14986137e-01f, -6.49990499e-01f, -1.88493326e-01f, 5.68129420e-01f, -1.62451759e-01f, -2.66553778e-02f,
  1.56090274e-01f, -6.40929863e-03f, 2.10042372e-02f, -1.08410232e-01f, 7.87723735e-02f, 1.64839923e-01f, 1.16640195e-01f, 5.53975821e-01f, -1.35769933e-01f, -6.60198107e-02f,
  3.97253871e-01f, 6.80573702e-01f, -5.97397745e-01f, -3.78896482e-02f, -4.38240021e-01f, 4.67508405e-01f, 1.61395669e-01f, -6.68084741e-01f, -3.81816536e-01f, 4.16841239e-01f,
  1.30065948e-01f, 4.19560611e-01f, 4.97645408e-01f, 3.91846478e-01f, -3.56253117e-01f, 1.31465402e-02f, -3.31074238e-01f, -5.69256246e-01f, -7.69418061e-01f, -7.75349259e-01f,
  -6.27535284e-02f, -4.40515965e-01f, 1.44088432e-01f, 5.86349852e-02f, -2.87822157e-01f, 3.66077334e-01f, 2.45066211e-01f, 1.07986577e-01f, 3.93333375e-01f, -5.86434066e-01f,
  -5.62645793e-01f, 5.39201975e-01f, -5.27424514e-01f, -4.76614028e-01f, -4.88108039e-01f, 1.11482590e-01f, -4.40324903e-01f, 1.58944026e-01f, 4.83269453e-01f, 2.75464281e-02f,
  -7.21217036e-01f, -1.15159512e+00f, -2.09672749e-01f, -6.45058900e-02f, -5.67457795e-01f, 4.68922764e-01f, -4.87635106e-01f, 3.81998390e-01f, 5.47874808e-01f, -3.81571025e-01f,
  -2.57486194e-01f, -3.37952226e-01f, 2.66546439e-02f, 4.85676378e-01f, -3.54002386e-01f, 1.84916615e-01f, 3.13697457e-01f, -6.00525411e-03f, -1.98226959e-01f, -2.04879865e-01f,
  3.23626697e-02f, 4.56283718e-01f, -3.03920731e-02f, -5.08091271e-01f, -2.60284364e-01f, -2.97016799e-01f, 4.52825397e-01f, -2.89889127e-01f, -6.89512134e-01f, -3.14736545e-01f,
  -4.74616677e-01f, 6.62479758e-01f, -5.59352994e-01f, 3.15760374e-01f, -5.74894011e-01f, 3.75134468e-01f, -9.87256885e-01f, -5.82246482e-01f, -4.71409917e-01f, 1.12838708e-01f,
  3.96505415e-01f, -5.81493139e-01f, 5.04161455e-02f, -8.21031630e-01f, 1.79833826e-02f, -7.54076019e-02f, 1.40403226e-01f, -3.48223835e-01f, -9.71925706e-02f, -1.53722465e-01f,
  -1.19485818e-01f, 2.17796326e-01f, 2.54794151e-01f, -3.85716438e-01f, -6.82214499e-02f, -3.46542031e-01f, 3.67921740e-01f, 4.56447393e-01f, -1.72149152e-01f, 3.42570245e-01f,
  5.32442868e-01f, -4.11912560e-01f, -4.24660146e-01f, -8.07562590e-01f, -4.80411559e-01f, 5.69238424e-01f, -6.52056158e-01f, -5.01093626e-01f, -5.81410170e-01f, 4.05139565e-01f,
  2.35706136e-01f, 2.53950328e-01f, 3.72871011e-01f, -4.29533094e-01f, -4.13007379e-01f, 2.39709631e-01f, 6.40223250e-02f, -1.95260108e-01f, 2.46148229e-01f, -4.69336174e-02f,
  -3.33592474e-01f, -2.90988475e-01f, 1.90136269e-01f, 1.61522314e-01f, 2.26312876e-01f, 5.79756439e-01f, 4.83909041e-01f, 3.59091222e-01f, 6.42166317e-01f, -2.88020879e-01f,
  -5.43158829e-01f, 8.79905075e-02f, -5.97528219e-01f, 2.36530796e-01f, -6.28613532e-01f, 6.70299649e-01f, -5.25114417e-01f, -2.03779675e-02f, -8.38603883e-04f, -5.94251454e-01f,
  -6.05669796e-01f, -3.89368713e-01f, 2.96512898e-02f, 3.51331264e-01f, -2.03551516e-01f, -4.65488613e-01f, -7.29987860e-01f, 8.29317570e-01f, 1.07231595e-01f, -4.05638628e-02f,
  -5.58028102e-01f, -2.61644665e-02f, 1.74079999e-01f, -2.33067110e-01f, -2.57655948e-01f, 1.58607453e-01f, -1.06584188e-02f, 3.10832262e-01f, -2.31807232e-01f, 1.16345398e-01f,
  4.43997443e-01f, 4.71783996e-01f, 4.67799038e-01f, -3.52977723e-01f, 6.63355887e-01f, -1.32896572e-01f, 4.17977452e-01f, -8.40764165e-01f, -2.38221258e-01f, 2.18989953e-01f,
  -8.42673600e-01f, 1.39891177e-01f, 6.64155856e-02f, -1.70057386e-01f, -5.31760514e-01f, 4.01892543e-01f, -8.51021931e-02f, -5.19751608e-01f, 7.65671849e-01f, -5.17952263e-01f,
  -3.94358896e-02f, 3.99428606e-01f, 4.54080701e-02f, 2.37325490e-01f, 1.91502031e-02f, -1.93473473e-02f, 1.78900644e-01f, 1.65355831e-01f, 8.26810747e-02f, 2.59087384e-01f,
  4.14147563e-02f, 1.48545459e-01f, -2.43914917e-01f, 3.54423881e-01f, -4.76306915e-01f, -5.00971735e-01f, -2.67792553e-01f, 2.18257770e-01f, -5.40526986e-01f, -2.31663674e-01f,
  4.88758445e-01f, 9.95177776e-02f, 1.13965020e-01f, 1.64741084e-01f, 4.11786199e-01f, -2.40480885e-01f, 2.57005244e-01f, -8.40737402e-01f, -7.56893873e-01f, 7.39204824e-01f,
  -4.52376574e-01f, 2.80362964e-01f, 7.78182223e-02f, -2.59250432e-01f, 1.93960428e-01f, 1.29296765e-01f, 1.27439097e-01f, 2.38405019e-01f, 2.23218083e-01f, -1.02384456e-01f,
  1.72302097e-01f, -4.09937024e-01f, -3.12671572e-01f, 1.31247593e-02f, -5.44679999e-01f, -3.29468578e-01f, 1.74210846e-01f, -5.44381380e-01f, -3.81365985e-01f, -4.75554764e-01f,
  -5.69031835e-01f, -5.24356067e-01f, -2.05113947e-01f, -4.63761352e-02f, -6.36695743e-01f, 5.92113972e-01f, -1.52493328e-01f, -1.51905060e-01f, 7.30948806e-01f, -9.80955541e-01f,
  5.08488178e-01f, -3.16152036e-01f, -5.76186597e-01f, -1.38351575e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  7.12638795e-02f, -2.95008346e-02f, 7.28336200e-02f, -2.46065091e-02f, 2.22497061e-01f, 1.52642623e-01f, 3.44166905e-02f, -2.67621642e-03f, 1.75440431e-01f, -1.04947671e-01f,
  9.54811741e-03f, 6.57181963e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    