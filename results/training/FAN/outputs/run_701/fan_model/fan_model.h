/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.08448692e-01f, -1.65380016e-01f, -7.76014924e-02f, -4.63706329e-02f, -4.04495895e-02f, 9.87625420e-02f, -1.05944589e-01f, 2.01720357e-01f, 1.26293033e-01f, -1.86129674e-01f,
  -5.83965257e-02f, 5.50211631e-02f, 1.16512194e-01f, 2.03838646e-01f, 2.03060165e-01f, -2.00442851e-01f, -2.45135948e-01f, 4.27266061e-02f, 3.28674436e-01f, 1.20933987e-01f,
  -1.44580573e-01f, -7.61735514e-02f, 1.14489734e-01f, 9.63657815e-03f, -8.25776309e-02f, 8.33137780e-02f, -1.03514321e-01f, -8.05397555e-02f, -1.11867778e-01f, -2.78980464e-01f,
  -4.44305018e-02f, -3.09330039e-02f, 1.26514599e-01f, -3.09686270e-02f, -6.62453771e-02f, 7.62963668e-02f, 7.97994584e-02f, 2.87431218e-02f, -1.06600024e-01f, 5.88688010e-04f,
  -9.40494388e-02f, -2.66461540e-03f, 5.85867791e-03f, -3.85723449e-02f, 1.10043406e-01f, 4.26970497e-02f, -3.22228186e-02f, 1.03966944e-01f, 2.51021422e-02f, 1.20207015e-02f,
  -7.64016360e-02f, -1.23223282e-01f, -5.03128916e-02f, 1.16725020e-01f, 1.02161080e-01f, 6.00198545e-02f, 1.01857729e-01f, 6.17205501e-02f, 5.44802509e-02f, 6.78625144e-03f,
  -9.37077552e-02f, -1.12429298e-01f, -5.27993627e-02f, -7.74593055e-02f, 1.51536928e-03f, -1.30519802e-02f, -4.77203242e-02f, 2.37143617e-02f, -5.36761619e-02f, 1.05534643e-02f,
  4.52427343e-02f, -2.49860920e-02f, 2.04781909e-02f, 8.49753842e-02f, 4.80985530e-02f, 4.86557558e-02f, 4.33638459e-03f, 5.50434701e-02f, 5.44354655e-02f, 1.14193624e-02f,
  4.96052615e-02f, 5.76099381e-02f, 4.30354476e-02f, 9.69905555e-02f, -4.11661156e-02f, 1.12637408e-01f, -4.01589014e-02f, -6.61095381e-02f, 2.07269453e-02f, 2.22469289e-02f,
  1.83657527e-01f, 1.74139127e-01f, -4.10321280e-02f, 3.57267596e-02f, 7.22657070e-02f, 3.70498523e-02f, 2.43833922e-02f, 3.69066447e-02f, -3.20468582e-02f, -2.62572207e-02f,
  3.01010404e-02f, 1.94734603e-03f, 3.34373489e-03f, -2.45626196e-02f, 2.71879602e-02f, 3.23330285e-03f, -1.04877360e-01f, 2.21161470e-02f, 8.17971528e-02f, -6.52357712e-02f,
  1.54755460e-02f, -5.87579655e-03f, 8.87862891e-02f, -7.46558681e-02f, 4.11249921e-02f, 6.45550564e-02f, 4.56689596e-02f, 6.22977056e-02f, 1.50120571e-01f, -2.82116011e-02f,
  1.51957676e-01f, -2.84921497e-01f, -2.60854419e-02f, -9.60874185e-02f, -1.52944237e-01f, 5.14793433e-02f, -1.77844167e-01f, 9.97948796e-02f, -4.91919369e-02f, -1.71197131e-01f,
  -1.51551971e-02f, 2.21065551e-01f, 1.15825504e-01f, 6.79277256e-02f, 2.09812045e-01f, -2.07553595e-01f, -2.11973324e-01f, 4.06477135e-03f, 2.97691554e-01f, 1.14030682e-01f,
  -2.68980991e-02f, 2.80918963e-02f, 3.04998551e-02f, 7.77766183e-02f, -2.02825576e-01f, 1.12163007e-01f, -1.99214876e-01f, -7.37114921e-02f, -1.17185913e-01f, -2.49885082e-01f,
  2.88799293e-02f, -1.97336733e-01f, 1.67561501e-01f, 4.78360523e-03f, -7.95764551e-02f, -3.80800180e-02f, -1.47783784e-02f, 4.01200764e-02f, -1.93334855e-02f, 5.57132484e-03f,
  -1.11403368e-01f, -2.87163705e-02f, -1.75069598e-03f, -3.11279632e-02f, -3.74976434e-02f, -5.10418080e-02f, -1.34102002e-01f, -7.51689598e-02f, -9.79702696e-02f, -1.94918346e-02f,
  -1.49977580e-01f, -1.63541704e-01f, -1.12953864e-01f, -7.52523541e-02f, -7.42695807e-03f, 5.99546134e-02f, -1.16228893e-01f, -7.00734407e-02f, -7.68058226e-02f, -1.54189259e-01f,
  5.39386123e-02f, 5.30583486e-02f, -4.32032794e-02f, -7.40925735e-03f, 1.27370916e-02f, -1.52002042e-02f, 7.65003311e-03f, 1.33692920e-02f, 8.85612965e-02f, -4.55182306e-02f,
  5.97487539e-02f, 1.14094708e-02f, -7.76586309e-02f, -1.08583262e-02f, 3.87448817e-02f, -6.97802156e-02f, -1.70118660e-02f, -8.81833509e-02f, 1.87164510e-03f, -8.49721208e-02f,
  3.86918187e-02f, -6.42366335e-02f, 9.19576436e-02f, 3.57302949e-02f, -5.01009636e-02f, 4.65117730e-02f, -6.39898255e-02f, 3.81836109e-02f, 5.78488670e-02f, 1.94786780e-03f,
  2.24782210e-02f, 4.74621691e-02f, 3.04032722e-03f, -1.93528328e-02f, -2.04120912e-02f, 3.25185433e-02f, -7.53166750e-02f, 3.09185348e-02f, -4.85618301e-02f, -3.82477976e-02f,
  5.23793176e-02f, 9.61223394e-02f, -1.13596112e-01f, -3.04844808e-02f, -8.49549845e-03f, 3.46769355e-02f, -4.40162160e-02f, 1.52226267e-02f, -3.01318467e-02f, -1.10285752e-01f,
  -7.69869313e-02f, 1.41605455e-02f, 1.09279372e-01f, 7.59675950e-02f, -1.97916515e-02f, 2.89163436e-03f, 3.65929529e-02f, -5.50993495e-02f, 1.34637505e-01f, 1.61901508e-02f,
  -3.11244696e-01f, -2.09256828e-01f, 6.28660899e-03f, 2.30181962e-02f, 7.40144849e-02f, 9.94515717e-02f, -2.96638291e-02f, -1.34427086e-01f, -8.54431018e-02f, -7.44625330e-02f,
  2.47650519e-02f, 1.23240106e-01f, 5.57444096e-02f, 8.04013312e-02f, 8.45757686e-03f, -1.28510490e-01f, -8.44425634e-02f, -1.66231375e-02f, 1.46047428e-01f, 2.04826504e-01f,
  1.36445820e-01f, 1.62636247e-02f, -1.47484262e-02f, 5.66494204e-02f, -2.29238551e-02f, 2.86973640e-02f, -1.79202020e-01f, 2.76378244e-02f, 1.92523990e-02f, -1.53461784e-01f,
  1.47917286e-01f, -2.43927404e-01f, 1.41822562e-01f, 6.01202883e-02f, -1.68474484e-02f, -8.63774307e-03f, 1.21482750e-02f, 1.92712359e-02f, 3.79731730e-02f, -2.52384506e-02f,
  5.44052571e-03f, 2.85101845e-03f, 9.42238346e-02f, 1.30824491e-01f, -2.54084310e-03f, 9.43281054e-02f, -4.61257547e-02f, 2.22999742e-03f, -8.64281207e-02f, -2.06473805e-02f,
  9.88458842e-03f, -3.25504504e-02f, -3.24242003e-02f, -1.97284911e-02f, -8.12493339e-02f, 5.04067726e-02f, -5.41577600e-02f, -5.86362183e-02f, -1.24018788e-01f, -1.68818176e-01f,
  -3.54085304e-02f, 2.88391206e-02f, 3.97312865e-02f, -2.50934418e-02f, 1.12799391e-01f, -8.07975419e-03f, 6.71626925e-02f, 5.68875782e-02f, 1.07046627e-01f, -7.35756662e-03f,
  5.49980029e-02f, -4.28627338e-03f, 6.39811605e-02f, -7.75504857e-02f, 6.26689121e-02f, 1.45908725e-02f, -2.86124670e-03f, 4.52010846e-03f, -5.69547620e-03f, 6.77657351e-02f,
  -1.89062767e-02f, 2.36727428e-02f, 7.83135667e-02f, 6.93361536e-02f, -3.05216797e-02f, 3.50290388e-02f, 9.64929163e-02f, 1.32901054e-02f, -6.74540177e-03f, 2.20903195e-02f,
  3.15297581e-02f, -9.25229415e-02f, 2.80394335e-03f, 9.94544104e-03f, 3.56249847e-02f, 3.80487530e-03f, 9.27876905e-02f, 4.69340272e-02f, 9.79755521e-02f, 6.25104681e-02f,
  5.67400269e-02f, 6.13436699e-02f, 2.57884357e-02f, 1.23398462e-02f, 7.63929188e-02f, 8.24177340e-02f, 6.77004382e-02f, 3.09766433e-03f, 3.14479321e-02f, 9.32063088e-02f,
  -2.02338714e-02f, -6.15450405e-02f, -3.60840783e-02f, 4.45541143e-02f, 8.90386254e-02f, 1.74555613e-03f, 8.08339715e-02f, 4.58770469e-02f, 7.49605969e-02f, 4.80107591e-02f,
  1.01178437e-02f, 1.81143358e-01f, 1.28242031e-01f, 5.44232652e-02f, 1.07143410e-01f, -7.60138854e-02f, 1.14116378e-01f, -1.37103364e-01f, -1.85618684e-01f, 1.42031208e-01f,
  -4.27687392e-02f, -1.74525335e-01f, -7.62116164e-02f, -3.18511426e-02f, -1.88812226e-01f, 2.80567091e-02f, 1.93505168e-01f, -6.89785331e-02f, -1.58803269e-01f, -1.99809432e-01f,
  2.88602468e-02f, -1.35038383e-02f, -1.23742670e-02f, -2.79929060e-02f, -5.78404032e-02f, -2.07159474e-01f, 9.89013016e-02f, -5.58899017e-03f, 8.91328231e-02f, 1.89192995e-01f,
  9.38891545e-02f, 2.05317199e-01f, -7.27413222e-02f, -3.88833061e-02f, 5.00096940e-02f, 5.32700457e-02f, 5.60120642e-02f, 9.76310112e-03f, 1.26487657e-01f, 1.15214206e-01f,
  5.94497249e-02f, 8.22344646e-02f, 1.02380976e-01f, -2.10982561e-02f, 3.22899111e-02f, 3.11234742e-02f, 1.39587060e-01f, 2.08994169e-02f, -9.00710188e-03f, 9.73705202e-02f,
  6.16142005e-02f, 5.32156304e-02f, 1.43277392e-01f, 2.24657785e-02f, -7.99797550e-02f, -9.33475196e-02f, 3.67323644e-02f, 4.83944453e-02f, -5.42828962e-02f, -4.47727218e-02f,
  7.63475969e-02f, 1.55537948e-02f, 1.31103199e-03f, 3.74378376e-02f, -1.16585031e-01f, -9.24169794e-02f, -6.72274455e-02f, -6.83247522e-02f, -7.75296837e-02f, -1.41538056e-02f,
  -1.29735410e-01f, -2.16598772e-02f, -1.03381403e-01f, -3.38050239e-02f, -4.36676741e-02f, -6.59286752e-02f, -9.81334317e-03f, -9.97674987e-02f, -7.85920173e-02f, -6.80890447e-03f,
  -5.69069833e-02f, -7.76627362e-02f, 3.59199534e-04f, -1.24620065e-01f, -4.39840443e-02f, 1.81188658e-02f, -1.15126759e-01f, -1.12038709e-01f, -5.05234189e-02f, -9.36661214e-02f,
  -1.44232392e-01f, 1.07110642e-01f, 9.17367637e-02f, -1.45805879e-02f, 5.97178116e-02f, 5.57954721e-02f, 2.87328977e-02f, -1.65325329e-02f, 2.80194301e-02f, 4.10721265e-02f,
  -3.71694826e-02f, 2.08543688e-02f, 2.18760725e-02f, 7.18108639e-02f, -2.88479943e-02f, 5.02723083e-02f, 1.47910506e-01f, 7.29847979e-03f, 4.38619182e-02f, -1.13683706e-02f,
  8.71770531e-02f, -6.62001967e-02f, 3.51141319e-02f, -4.73287553e-02f, -4.92558209e-03f, -1.36651710e-01f, -3.64582911e-02f, -4.01374139e-02f, -9.18848515e-02f, -3.09975389e-02f,
  3.53563219e-01f, -4.11666900e-01f, -2.60627344e-02f, -1.44227818e-02f, -2.60493636e-01f, -1.22263625e-01f, -2.28557691e-01f, -7.54875019e-02f, -2.10960850e-01f, -3.37527901e-01f,
  -2.61679083e-01f, -5.13312891e-02f, -5.93618266e-02f, 4.08753194e-02f, 9.72080305e-02f, -2.63729870e-01f, -2.77971655e-01f, 2.10956514e-01f, 2.13959068e-01f, -1.02435641e-01f,
  -1.82830900e-01f, 2.94669289e-02f, 7.13165924e-02f, 2.52585094e-02f, -3.23541433e-01f, -1.48745745e-01f, -2.38566801e-01f, -1.71956226e-01f, -2.63035595e-01f, -2.83047765e-01f,
  1.11123244e-03f, 5.81794791e-03f, -1.02303050e-01f, -1.88649133e-01f, -1.92421645e-01f, 2.54107115e-04f, -6.31763041e-02f, -1.05987899e-01f, -9.44307223e-02f, -1.11810811e-01f,
  -1.13652207e-01f, -1.13363080e-01f, -1.48079425e-01f, -1.99102163e-01f, -1.77382261e-01f, -7.04466775e-02f, -1.54451787e-01f, -3.63795757e-02f, -1.10550120e-01f, -1.64830938e-01f,
  -2.91331530e-01f, -2.03780949e-01f, 6.36809766e-02f, -2.19000906e-01f, -5.23615330e-02f, -8.55775401e-02f, -2.11237162e-01f, -7.56834969e-02f, 3.63983735e-02f, -2.15756804e-01f,
  -4.56247330e-02f, 2.78641097e-02f, 5.39012393e-03f, -1.26839960e-02f, 5.13907447e-02f, -1.28000341e-02f, 6.83415160e-02f, -5.45238378e-03f, -1.17082363e-02f, 3.30147520e-02f,
  1.11243293e-01f, 5.21921217e-02f, 8.99985433e-02f, 1.14125073e-01f, 4.10970226e-02f, 8.94913897e-02f, 8.33869204e-02f, -2.22368464e-02f, 7.30806170e-03f, 9.40714702e-02f,
  4.46317382e-02f, 5.53979725e-02f, 7.08257258e-02f, 6.13981523e-02f, 8.01349953e-02f, 7.79549107e-02f, 1.58832058e-01f, 8.81789848e-02f, 1.38802782e-01f, 4.05295044e-02f,
  -3.30107696e-02f, -5.37461713e-02f, -1.38990909e-01f, -7.14603364e-02f, -1.26393154e-01f, -1.56534627e-01f, -1.68933704e-01f, -1.42286226e-01f, -1.14562333e-01f, -1.21616781e-01f,
  -1.05527453e-01f, -9.63680744e-02f, -1.08737528e-01f, -1.50035664e-01f, -1.63864687e-01f, -1.37761578e-01f, -1.77402854e-01f, -1.18854828e-01f, -1.30969837e-01f, -1.75934881e-01f,
  -1.22974701e-01f, -1.30536884e-01f, -1.65404063e-02f, -1.01816356e-01f, -6.49279878e-02f, -9.36253816e-02f, -1.46869928e-01f, -1.25182495e-01f, -8.57694820e-03f, -1.55658498e-01f,
  1.04277425e-01f, -4.61759325e-03f, -2.19311729e-01f, -7.46652111e-02f, -1.80222496e-01f, -1.63364008e-01f, -2.53412545e-01f, -1.31173939e-01f, 1.34663895e-01f, -1.79947928e-01f,
  1.27281323e-01f, 1.57732829e-01f, 7.00413063e-02f, 1.35458887e-01f, 3.68610732e-02f, -1.69655517e-01f, -1.90044343e-01f, 7.88916368e-03f, 3.19493189e-02f, -8.14712867e-02f,
  -8.26213229e-03f, -1.58374831e-02f, 1.93056569e-01f, 5.20864949e-02f, -4.51319711e-03f, 6.83789998e-02f, -1.03943713e-01f, 7.14920880e-03f, 7.46631771e-02f, -1.50496796e-01f,
  -1.61676437e-01f, 2.64602266e-02f, 3.17373173e-03f, 1.24481827e-01f, 8.46512336e-03f, 7.97287002e-02f, 4.23442572e-02f, 7.22374814e-03f, 5.57175875e-02f, -1.10703353e-02f,
  9.97002572e-02f, 3.47300768e-02f, -4.22855206e-02f, 5.47244512e-02f, -3.36519554e-02f, 1.70146842e-02f, 7.80743137e-02f, 6.79112300e-02f, 1.68518685e-02f, 9.77966711e-02f,
  -8.21854192e-05f, 2.18707211e-02f, -3.02395727e-02f, -8.32044855e-02f, 6.06875792e-02f, 7.78497085e-02f, 2.43120845e-02f, 1.35720402e-01f, 6.45427108e-02f, 6.50151372e-02f,
  -7.76386783e-02f, -4.93978411e-02f, 1.11894822e-03f, 3.68370600e-02f, -2.92597823e-02f, 4.28103358e-02f, -2.57144440e-02f, 5.28828204e-02f, 7.80876875e-02f, -2.96847187e-02f,
  -3.59543338e-02f, -3.60521376e-02f, 2.95083458e-03f, -6.40554801e-02f, -1.14259301e-02f, -7.62535259e-02f, -6.90496117e-02f, -2.83957701e-02f, 3.70185636e-02f, 4.25932109e-02f,
  7.54768252e-02f, 5.95296435e-02f, -3.20125301e-03f, 7.68140554e-02f, -2.84884702e-02f, -6.41042441e-02f, 9.62157324e-02f, -1.56717896e-02f, -7.02761114e-02f, 6.38321117e-02f,
  6.15054816e-02f, 3.42857130e-02f, 2.43880320e-02f, 1.49797529e-01f, 8.56369585e-02f, 5.48682809e-02f, 2.41313479e-03f, 5.23825064e-02f, 5.87908514e-02f, 8.39103982e-02f,
  2.09030341e-02f, 2.77260002e-02f, 4.40601557e-02f, 3.10586896e-02f, -5.85048459e-02f, 5.29589690e-02f, -8.88110604e-04f, -6.16384186e-02f, 5.01638129e-02f, -1.02639049e-02f,
  -5.37543669e-02f, -1.12136984e-02f, 1.97998434e-02f, 4.31277964e-04f, 3.47079039e-02f, -4.73742094e-03f, -2.26786118e-02f, -5.73425516e-02f, -9.24278609e-03f, -1.29420944e-02f,
  -4.61283103e-02f, 1.10575266e-01f, -1.47677600e-01f, -2.99360175e-02f, -8.10580179e-02f, -3.35108414e-02f, 9.05553848e-02f, -8.86396468e-02f, -1.14244418e-02f, 7.61375623e-03f,
  -9.86174271e-02f, -1.99673951e-01f, -6.27297759e-02f, -6.39065728e-02f, -4.86664474e-02f, 1.55558363e-01f, 1.18348777e-01f, -7.44497627e-02f, -1.85911432e-01f, -6.50679246e-02f,
  -1.15057096e-01f, 2.33656093e-02f, 4.81361710e-03f, 3.32072303e-02f, 2.69002169e-01f, 1.10525995e-01f, 1.68926165e-01f, 1.53498292e-01f, 1.78053811e-01f, 3.21106762e-01f,
  1.97407603e-02f, -7.62789510e-03f, -1.34972874e-02f, 3.64639685e-02f, 6.01412170e-02f, 1.30738541e-01f, 2.93871015e-02f, 5.88200204e-02f, 4.71122302e-02f, -4.45094332e-02f,
  3.11964434e-02f, -4.74626152e-03f, 9.02280062e-02f, 2.39675436e-02f, 1.05353497e-01f, -6.41018823e-02f, -2.94055957e-02f, 6.74575418e-02f, 8.06514472e-02f, -1.90860648e-02f,
  1.28864823e-03f, 1.90886408e-02f, 4.97105308e-02f, -2.73912083e-02f, 6.26008287e-02f, -7.54613876e-02f, 9.64474753e-02f, 8.86023939e-02f, 7.42431805e-02f, 2.60311216e-01f,
  3.54750715e-02f, 2.86693554e-02f, -6.15927130e-02f, -1.03780115e-02f, -8.41616616e-02f, 2.03093551e-02f, -2.65831463e-02f, -6.51296675e-02f, 7.71243572e-02f, 2.52969540e-03f,
  -5.13319671e-02f, -8.59169513e-02f, -8.89326707e-02f, 2.31769308e-02f, 1.26072010e-02f, -3.57271396e-02f, 9.77170654e-03f, 1.31315961e-02f, 8.50096345e-03f, -2.45415568e-02f,
  7.84064760e-04f, 4.96969000e-02f, -3.45265530e-02f, -5.25338240e-02f, 3.76631618e-02f, -1.20573692e-01f, -1.21315420e-02f, -1.20930016e-01f, -8.59563500e-02f, -9.64767784e-02f,
  -2.97375885e-03f, -9.75137800e-02f, 1.27255008e-01f, -5.43821752e-02f, 7.93716162e-02f, 2.19858326e-02f, 8.32471773e-02f, -4.77877073e-02f, -4.14856710e-02f, 5.83550669e-02f,
  6.99411109e-02f, 5.97955147e-03f, 1.92071963e-02f, -1.22259595e-02f, -3.11505534e-02f, 8.52068886e-02f, 5.39705083e-02f, -3.02994102e-02f, 9.92521048e-02f, 8.60658064e-02f,
  1.15231164e-02f, 6.06009550e-02f, 5.97210191e-02f, 4.32243757e-02f, 1.44301131e-01f, 1.35734305e-02f, 8.83658603e-02f, 2.26646259e-01f, 1.20505886e-02f, 3.40148211e-01f,
  4.64660794e-01f, -7.16539621e-02f, -1.43789485e-01f, 2.06608474e-01f, -6.27693385e-02f, -3.05390526e-02f, -1.93614379e-01f, -6.25286102e-02f, 2.61163972e-02f, -6.17348440e-02f,
  -1.80520356e-01f, 5.12201153e-02f, -1.78758893e-02f, -4.02178392e-02f, -1.06535383e-01f, -1.08845748e-01f, -1.33138001e-01f, 6.60341755e-02f, 8.79172757e-02f, -5.89849316e-02f,
  1.27991214e-02f, 1.74013019e-01f, 1.82990789e-01f, -2.77109556e-02f, 1.01623617e-01f, 1.51514977e-01f, -1.96662582e-02f, -4.07322459e-02f, -1.80013284e-01f, -4.74439636e-02f,
  1.38726234e-01f, 4.95765544e-02f, -1.81672105e-04f, 3.68436314e-02f, 3.86270471e-02f, 8.22986141e-02f, 1.06883056e-01f, 1.91445258e-02f, 2.62000430e-02f, 7.24147409e-02f,
  -1.10433465e-02f, 9.05491691e-03f, 4.37776856e-02f, 8.67144093e-02f, 9.79392529e-02f, 1.05185889e-01f, -3.44239324e-02f, 7.29561448e-02f, -4.68412451e-02f, -1.66664328e-02f,
  -3.41126546e-02f, 2.71412823e-02f, -1.28081277e-01f, 2.28369087e-02f, 3.12786177e-02f, 3.91169451e-02f, 4.10304591e-02f, 6.71459585e-02f, 4.28472795e-02f, 1.86279103e-01f,
  -7.59074315e-02f, 3.67286019e-02f, -2.51617860e-02f, -3.41061652e-02f, 3.16276848e-02f, 3.16307284e-02f, -2.27372665e-02f, -5.44441789e-02f, 4.74130884e-02f, 5.36224917e-02f,
  -1.19719580e-01f, 7.15682609e-03f, 4.69111130e-02f, -1.50346840e-02f, -4.15325724e-02f, -3.94897833e-02f, -2.40254216e-02f, -5.86791374e-02f, -3.20747159e-02f, 2.62545105e-02f,
  1.25066284e-02f, -1.11177765e-01f, -2.27404684e-02f, -1.44581832e-02f, -3.24158482e-02f, -5.38509749e-02f, -2.70991828e-02f, -1.78087819e-02f, 2.54834164e-02f, 2.58663390e-03f,
  1.54301032e-01f, -1.75076663e-01f, 1.78093895e-01f, -4.65562642e-02f, -1.38041645e-03f, 1.81194954e-02f, 2.32108086e-02f, 5.90927452e-02f, 6.80620819e-02f, 9.58235040e-02f,
  -1.63164232e-02f, 9.94660333e-02f, 7.34686181e-02f, -4.98770960e-02f, 7.49366209e-02f, 7.41467997e-02f, -1.06778130e-01f, 7.77493715e-02f, -2.89872549e-02f, 2.23782379e-02f,
  -2.78486311e-02f, 8.57204273e-02f, 6.03645816e-02f, -3.80074270e-02f, -4.86092567e-02f, 9.42037627e-02f, 6.51467741e-02f, 9.76733118e-02f, 2.25121491e-02f, 2.38981858e-01f,
  -1.12137139e-01f, 1.89557612e-01f, 2.62563586e-01f, -1.51859090e-01f, -4.32881154e-02f, 3.32475975e-02f, 1.60397083e-01f, 8.27063024e-02f, -1.53229341e-01f, -2.21634712e-02f,
  2.28468403e-02f, -3.78753692e-02f, -3.72149721e-02f, 4.92935702e-02f, 7.10889604e-03f, -5.91933075e-03f, 6.76337555e-02f, -1.12336036e-02f, -9.88696292e-02f, -4.21479419e-02f,
  -1.17743783e-01f, -1.64141551e-01f, -4.61083166e-02f, -7.08178878e-02f, -1.03729799e-01f, -1.74829751e-01f, 5.44742271e-02f, -4.69372459e-02f, 6.68718992e-03f, -1.04334988e-01f,
  1.44119367e-01f, 1.55529067e-01f, -9.34763774e-02f, -9.19732451e-02f, 4.24888022e-02f, -1.04056522e-01f, 3.68163688e-03f, 7.21827000e-02f, -8.25254768e-02f, 9.67723411e-03f,
  -9.77318510e-02f, 5.85126914e-02f, -3.74167971e-02f, -1.93515643e-02f, 6.23437651e-02f, -1.15204696e-02f, 2.76004970e-02f, 9.57325399e-02f, 3.67661193e-02f, 8.21976066e-02f,
  -5.62282018e-02f, 6.81233704e-02f, 9.03741047e-02f, -3.27723846e-02f, 3.89502645e-02f, 1.69611648e-02f, 2.70040091e-02f, -5.43409288e-02f, 3.91145376e-03f, -5.88420453e-03f,
  -7.26859868e-02f, 4.92734611e-02f, 6.04174994e-02f, -3.96104194e-02f, -4.54176478e-02f, -3.21733542e-02f, -1.55645544e-02f, 2.45680958e-02f, 3.65567952e-02f, 2.31081573e-03f,
  -9.04841255e-03f, -2.30630171e-02f, 6.52613640e-02f, -4.23138663e-02f, 1.26553085e-02f, 4.30313498e-02f, 4.08348069e-02f, -3.50248516e-02f, -2.23815348e-02f, 6.38625175e-02f,
  2.72800820e-03f, 3.32140923e-02f, -5.73072918e-02f, 2.48464681e-02f, -1.52422981e-02f, -1.58732682e-02f, -4.61549759e-02f, -8.85870028e-03f, -5.98455817e-02f, -2.53233723e-02f,
  -1.55907348e-01f, 2.53809392e-01f, -1.65306345e-01f, -2.39941869e-02f, -3.00976392e-02f, 2.19412521e-02f, -5.40381297e-02f, 6.00030534e-02f, 1.18365716e-02f, -5.44204153e-02f,
  3.47590330e-03f, 4.08372991e-02f, 3.20639312e-02f, 7.01982006e-02f, 5.26657142e-03f, -5.13712391e-02f, 7.05962852e-02f, -2.43822560e-02f, -4.27390747e-02f, 6.32331066e-04f,
  1.28791947e-02f, -1.15776181e-01f, -6.40129298e-02f, -9.86387879e-02f, -1.35103106e-01f, -1.39696404e-01f, 9.80321551e-04f, -1.52958468e-01f, -8.62416625e-02f, -1.26622394e-01f,
  3.20156455e-01f, -9.82840285e-02f, 2.33803838e-01f, 1.88189879e-01f, -1.90068305e-01f, -5.14729060e-02f, -8.19072053e-02f, 1.09707557e-01f, 1.41694739e-01f, -1.08781718e-02f,
  -3.60940807e-02f, 2.18992606e-02f, 1.06224656e-01f, 1.35843635e-01f, 2.68556446e-01f, 1.95307821e-01f, 1.59442857e-01f, 2.60712802e-01f, 2.52030879e-01f, 2.55721584e-02f,
  -5.79871126e-02f, 1.45544574e-01f, 2.84723759e-01f, 2.64840305e-01f, 5.78362159e-02f, 3.15512680e-02f, 9.94673371e-02f, 1.66111693e-01f, -1.10443188e-02f, 9.84651148e-02f,
  7.38323107e-02f, 5.93171641e-02f, 2.21543729e-01f, 1.45284282e-02f, 7.06683844e-02f, 1.64040133e-01f, 1.92993283e-02f, 1.11012593e-01f, 3.34079266e-02f, 1.46295771e-01f,
  4.22331914e-02f, 2.92888358e-02f, 6.14230521e-02f, 1.05669245e-01f, 2.92935595e-02f, 1.21194653e-01f, 1.82376117e-01f, 2.93665051e-01f, 2.26098344e-01f, 1.94873258e-01f,
  -7.19330236e-02f, -6.39335364e-02f, 1.31553188e-01f, 1.61131606e-01f, 1.74661919e-01f, 9.79853049e-02f, 1.50678709e-01f, 1.39366075e-01f, 2.34739214e-01f, 2.42829248e-01f,
  3.09033431e-02f, -1.07596613e-01f, -5.72486557e-02f, -1.27367854e-01f, -3.82296257e-02f, -8.08671489e-02f, -1.41960070e-01f, -7.95207694e-02f, -1.30063489e-01f, -1.65959410e-02f,
  -8.68433788e-02f, -3.27249616e-02f, -6.31275773e-02f, -3.74616198e-02f, -1.36645779e-01f, -4.95036803e-02f, -8.31638873e-02f, -7.60465264e-02f, 7.51843583e-03f, -7.16319233e-02f,
  -8.22098702e-02f, -6.37468137e-03f, -1.54925855e-02f, -1.57963753e-01f, -1.22937337e-01f, -7.56946653e-02f, -3.49094309e-02f, -1.11364998e-01f, -1.45310894e-01f, -1.10033132e-01f,
  1.00213997e-01f, 6.80753663e-02f, 2.15824604e-01f, 1.33955941e-01f, 1.03635959e-01f, 1.58402115e-01f, 1.00656711e-01f, 1.71118200e-01f, 9.81437564e-02f, 1.83332920e-01f,
  1.19416624e-01f, 2.37993941e-01f, 1.29831076e-01f, 9.21532139e-02f, 1.66521445e-01f, 1.79323703e-01f, 1.60516262e-01f, 1.22583292e-01f, 2.03139395e-01f, 1.92258194e-01f,
  1.27510235e-01f, 2.52023697e-01f, 1.03977330e-01f, 2.47464687e-01f, 9.32376385e-02f, 2.36923173e-01f, 1.55688122e-01f, 1.13694936e-01f, 1.40848160e-01f, 3.69162172e-01f,
  3.31538647e-01f, -9.35224891e-02f, 2.01265603e-01f, 1.23283505e-01f, -2.90142279e-02f, -6.74091056e-02f, -1.79020718e-01f, -1.16216905e-01f, -2.25872714e-02f, -4.51666489e-02f,
  -4.49316634e-04f, -8.63069966e-02f, 4.65935543e-02f, -6.03228584e-02f, -1.02325551e-01f, 1.27211679e-02f, 1.02229796e-01f, 7.58359879e-02f, -1.26729473e-01f, -1.21294081e-01f,
  -1.99871048e-01f, 4.79497388e-02f, 4.62361015e-02f, 3.17927054e-03f, 3.10466830e-02f, -6.80867955e-02f, 1.13006063e-01f, 1.45166576e-01f, -3.50799970e-02f, 1.80520803e-01f,
  1.74061418e-01f, 2.05988899e-01f, -7.77622536e-02f, -6.67160936e-03f, 9.83215272e-02f, -8.07118565e-02f, -2.87187994e-02f, -5.78843765e-02f, 1.12270601e-02f, 1.14701735e-02f,
  -2.76541878e-02f, 1.53294597e-02f, -4.21206263e-04f, 3.41162048e-02f, -5.72457351e-02f, 2.18278933e-02f, 5.11773489e-02f, -1.66426171e-02f, 1.22764885e-01f, -3.69488001e-02f,
  -3.54160629e-02f, 5.16210049e-02f, 1.60983846e-01f, 2.41958145e-02f, -2.73128729e-02f, 1.30512521e-01f, 2.43147812e-03f, -1.93991717e-02f, 4.98112477e-02f, -2.67531052e-02f,
  -1.15468152e-01f, -3.09675317e-02f, -3.37643898e-03f, -1.56522188e-02f, -7.13501126e-02f, -1.38127161e-02f, 7.36118481e-02f, -3.43646295e-02f, 1.62407886e-02f, -7.01818466e-02f,
  -4.21829000e-02f, -2.40185559e-02f, -6.43572435e-02f, 4.55770977e-02f, -6.76472858e-02f, 5.44701330e-02f, -1.31984316e-02f, -7.07199648e-02f, 4.61577736e-02f, 3.66456993e-02f,
  1.51557447e-02f, 1.08619198e-01f, -9.31972731e-03f, -9.27440263e-03f, 1.29708862e-02f, 1.75422523e-02f, -2.44384613e-02f, -3.47982347e-02f, 5.06231338e-02f, 8.88549387e-02f,
  -2.27556564e-02f, 6.53424114e-02f, -7.26910755e-02f, -2.65805982e-02f, 5.38397655e-02f, -3.95645723e-02f, 6.85321391e-02f, -3.00649051e-02f, 1.68673396e-02f, 2.69875079e-02f,
  -1.03205219e-02f, 7.95767233e-02f, 1.38366640e-01f, -9.71705243e-02f, -8.03818181e-02f, -8.78273323e-02f, 4.16218080e-02f, 9.88141447e-02f, -2.34344639e-02f, 1.76365990e-02f,
  1.72822885e-02f, 2.74047330e-02f, -2.47320831e-02f, -5.30787930e-03f, -6.78101480e-02f, -9.63593200e-02f, -1.45213023e-01f, 4.02304577e-03f, -9.59187970e-02f, -1.78308159e-01f,
  -2.88048446e-01f, 1.26442000e-01f, -1.36494096e-02f, -2.01396272e-01f, -5.62170930e-02f, 1.40168920e-01f, 8.73792171e-02f, 1.18960351e-01f, -7.21628254e-04f, 6.16024025e-02f,
  1.89911962e-01f, 2.25328669e-01f, 5.05646206e-02f, 1.02011427e-01f, 1.07252494e-01f, -4.36955616e-02f, -4.37411405e-02f, -1.31903403e-02f, -9.22996271e-03f, 2.00406581e-01f,
  8.14166144e-02f, -3.68548371e-02f, -1.20758273e-01f, 9.60127786e-02f, -2.32828199e-03f, 1.87481746e-01f, 5.84315211e-02f, 9.34060737e-02f, 1.67207271e-01f, -3.14833894e-02f,
  -2.68562995e-02f, 6.45646602e-02f, 1.68150336e-01f, 2.86591146e-02f, 3.41927409e-02f, 6.23399019e-02f, 1.71314612e-01f, 4.58722673e-02f, 5.93542792e-02f, 8.02704841e-02f,
  1.09234817e-01f, 1.24548048e-01f, -4.94924821e-02f, 3.60578671e-02f, 5.31204930e-03f, 1.47373810e-01f, 1.14580328e-02f, 6.66403696e-02f, 4.47520912e-02f, 1.67963758e-01f,
  1.07679226e-01f, 1.18794717e-01f, 8.98647606e-02f, 2.20823303e-01f, 2.13750824e-01f, 5.57659157e-02f, 1.09745130e-01f, 1.94393784e-01f, 2.60690749e-01f, 7.33647421e-02f,
  -7.52385557e-02f, 7.43949180e-03f, -5.82153201e-02f, -1.55193865e-01f, -5.15355915e-02f, -7.85909966e-02f, -1.28877118e-01f, -3.48478295e-02f, -7.53407329e-02f, -1.49338201e-01f,
  -1.53857768e-01f, -1.77647602e-02f, -5.53728715e-02f, -7.70575032e-02f, -6.14587888e-02f, -1.07498825e-01f, -1.08653381e-01f, -7.99754858e-02f, -1.52464760e-02f, -1.58627138e-01f,
  -8.84880051e-02f, -2.25132536e-02f, -1.06222868e-01f, -9.02971253e-02f, -5.74678704e-02f, -6.43898919e-02f, -7.36750364e-02f, 6.11164083e-04f, -7.96832964e-02f, -4.62572128e-02f,
  -7.16794431e-02f, 6.11256026e-02f, -3.21743498e-03f, 7.91458711e-02f, 8.23612809e-02f, 5.78904971e-02f, 4.62771347e-03f, 3.10352016e-02f, 7.68089518e-02f, 7.73004517e-02f,
  4.45076115e-02f, -7.35026747e-02f, 1.12344632e-02f, 6.17888048e-02f, 2.91985162e-02f, 9.76389498e-02f, 9.42170769e-02f, -1.88193079e-02f, 9.24310833e-02f, 9.78705063e-02f,
  3.48042287e-02f, 1.27403766e-01f, -3.37701216e-02f, -2.95712166e-02f, 1.28663033e-01f, 2.28657182e-02f, 1.19237065e-01f, 5.71072213e-02f, 4.99121584e-02f, -7.00840428e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.04254997e-01f, -3.14673245e-01f, 2.98587680e-02f, -4.43242818e-01f, -2.89354533e-01f, -1.89279482e-01f, -9.70694125e-02f, -1.32622138e-01f, -2.84420282e-01f, -2.48787463e-01f,
  -1.14703603e-01f, 2.10063428e-01f, 5.45895025e-02f, 2.03453168e-01f, 2.48488113e-01f, -6.46986738e-02f, -1.98831990e-01f, 2.31212810e-01f, 4.18784440e-01f, 1.51412517e-01f,
  -5.16063347e-02f, 4.73660864e-02f, -2.20331103e-02f, 4.60238568e-02f, -1.35023206e-01f, 9.46604013e-02f, -1.98544323e-01f, -9.40033421e-02f, -9.98851061e-02f, -3.25863659e-01f,
  2.85735518e-01f, -3.49837154e-01f, -2.22580396e-02f, -1.27612069e-01f, -9.23047811e-02f, -3.58986855e-02f, 4.26484756e-02f, -1.03971653e-01f, -3.85978967e-02f, -1.54693633e-01f,
  -6.98829442e-02f, -3.47906239e-02f, 8.58016089e-02f, 3.82573605e-02f, -1.02575839e-01f, -7.39930347e-02f, -3.77631709e-02f, -5.61726466e-02f, 6.76222295e-02f, 1.90896131e-02f,
  1.05582468e-01f, -1.02418549e-01f, 3.38061154e-02f, -2.02173740e-02f, 5.25590628e-02f, 1.71659198e-02f, 1.62610207e-02f, -8.40287879e-02f, 3.69256884e-02f, -1.49681970e-01f,
  6.34564180e-03f, 1.16346925e-01f, 4.15290333e-02f, -9.17404797e-03f, 4.54696752e-02f, 2.33997628e-02f, 2.69037839e-02f, -5.95600046e-02f, 3.18778716e-02f, -6.32786825e-02f,
  -2.04529576e-02f, -1.61607824e-02f, 1.78162567e-02f, -5.75108565e-02f, -3.42393182e-02f, -1.32967666e-01f, -3.57517712e-02f, -6.20709639e-03f, -8.45909864e-02f, -1.37938604e-01f,
  -1.36316702e-01f, -7.50689432e-02f, -1.01468869e-01f, 3.38995419e-02f, -6.85787871e-02f, -1.20221317e-01f, -3.87057103e-02f, 6.45989999e-02f, -8.97827670e-02f, -3.63275856e-02f,
  4.10453454e-02f, 1.59586165e-02f, -6.71033487e-02f, 2.18262766e-02f, -8.15655366e-02f, -1.52508140e-01f, 1.75768696e-02f, -4.96751629e-02f, -1.15482815e-01f, 6.15726225e-02f,
  -4.23796810e-02f, 3.54944263e-03f, -1.33403204e-02f, -3.26225460e-02f, 8.63401517e-02f, 1.55015131e-02f, -3.29196267e-02f, 7.37793148e-02f, 4.41329777e-02f, -8.42030942e-02f,
  -4.81120013e-02f, -7.01927990e-02f, 6.35270700e-02f, 6.10835925e-02f, 4.88736667e-02f, 7.42631331e-02f, 1.23814099e-01f, 1.24665082e-01f, 1.58099994e-01f, 1.27172887e-01f,
  -5.69783933e-02f, -1.93288743e-01f, 8.86051357e-03f, -4.27564159e-02f, 1.58994392e-01f, 2.10467026e-01f, 3.80683362e-01f, 1.07626945e-01f, 5.85750006e-02f, 1.24562886e-02f,
  -6.77916706e-02f, -2.67992139e-01f, -3.70970398e-01f, -1.34222314e-01f, -7.16163740e-02f, 2.00475499e-01f, 1.93579748e-01f, 2.23620255e-02f, 1.44382462e-01f, 1.56757221e-01f,
  3.31665687e-02f, 9.41310748e-02f, -8.99052396e-02f, -1.15411878e-01f, -1.63563222e-01f, 1.15967408e-01f, -5.21588996e-02f, -1.14379235e-01f, -5.81621490e-02f, -1.60723642e-01f,
  -1.60257787e-01f, -2.87820905e-01f, 8.25193822e-02f, -1.21415615e-01f, -6.49836510e-02f, -9.36274882e-03f, -6.55323416e-02f, -1.73543662e-01f, -1.13679655e-01f, -9.20967907e-02f,
  -1.09010093e-01f, -1.76162705e-01f, -3.51747870e-01f, -2.18903720e-02f, -1.20393582e-01f, -1.00858249e-01f, -1.17841952e-01f, -1.28862992e-01f, -1.78860024e-01f, -5.66483214e-02f,
  -1.26457289e-01f, -9.69820768e-02f, -1.39081851e-01f, -4.40557897e-02f, -2.41466388e-01f, 3.59637141e-02f, -9.17962715e-02f, -1.26444906e-01f, -1.39944986e-01f, -1.18736625e-01f,
  1.76706817e-02f, 8.14813524e-02f, 3.54765430e-02f, 1.10082857e-01f, 6.83223009e-02f, -7.74489120e-02f, -7.82846846e-03f, -5.19099906e-02f, -9.84336220e-05f, 7.35861510e-02f,
  -4.59565222e-02f, 1.02152815e-02f, 4.91262600e-02f, 8.24968964e-02f, -2.08798721e-02f, -3.24519165e-02f, 2.61605829e-02f, 8.23118463e-02f, -1.74753312e-02f, 1.24518216e-01f,
  4.18777205e-02f, -6.48666620e-02f, 1.16690695e-02f, -4.65697609e-02f, 8.14747065e-02f, -2.28971802e-02f, 1.04164176e-01f, -7.54169300e-02f, -4.34327163e-02f, 9.10943002e-02f,
  3.27148028e-02f, -9.64217484e-02f, 8.88512731e-02f, 5.70617579e-02f, -9.14480165e-02f, 2.81895809e-02f, -9.44541469e-02f, -6.49548620e-02f, -5.34667671e-02f, -1.42289579e-01f,
  -1.65621005e-02f, -1.17077343e-01f, -2.03724891e-01f, 6.02091998e-02f, 6.85689272e-03f, 1.01230964e-01f, 4.36364412e-02f, 2.75932308e-02f, 5.10830283e-02f, 1.24565661e-01f,
  4.84507605e-02f, 1.61200196e-01f, 1.94524959e-01f, 4.18834127e-02f, -3.59924026e-02f, 1.96246266e-01f, 1.07830234e-01f, 1.78413972e-01f, 1.32163584e-01f, 2.18455136e-01f,
  8.05119276e-01f, -1.41758680e-01f, -1.45175248e-01f, 2.80781955e-01f, -8.76965970e-02f, -1.43149421e-01f, -2.46109307e-01f, 1.47472113e-01f, 2.18854323e-01f, -3.22950445e-02f,
  1.09247774e-01f, 4.00802761e-01f, 2.48329535e-01f, 2.63048172e-01f, 1.40370354e-01f, -2.84536719e-01f, -1.79730535e-01f, 4.82370611e-03f, 2.18111530e-01f, -1.35698058e-02f,
  -7.68768862e-02f, -5.54210320e-03f, 2.05272779e-01f, 1.19176924e-01f, -2.16123462e-01f, 1.22410536e-01f, -2.77958661e-01f, -2.01993689e-01f, -1.90630406e-01f, -3.43201160e-01f,
  -2.44602546e-01f, 1.73116684e-01f, 1.49025247e-01f, 6.66213781e-02f, -2.62324605e-02f, 9.53321084e-02f, 1.24099210e-01f, -1.10278599e-01f, 7.04268040e-03f, -1.29112124e-01f,
  -8.66815448e-02f, 6.65496103e-03f, -3.31199877e-02f, -2.28959601e-02f, -1.49382040e-01f, -1.51635678e-02f, -1.39035564e-03f, 1.45704914e-02f, -3.19985896e-02f, -4.08300236e-02f,
  7.59242699e-02f, 5.98194450e-02f, -1.33984402e-01f, -4.29645032e-02f, 6.27993271e-02f, 1.04528042e-02f, -6.37873039e-02f, -8.10851529e-02f, 7.77588487e-02f, 1.56212356e-02f,
  -6.85018972e-02f, 5.77460453e-02f, 5.07987067e-02f, 4.58118655e-02f, -4.65918146e-02f, 7.74065405e-02f, -1.84399504e-02f, -1.06410675e-01f, -3.54711041e-02f, -5.25535122e-02f,
  -8.00387636e-02f, 7.75731653e-02f, 1.27609372e-01f, 8.06336477e-02f, -1.08106174e-02f, -4.24920395e-02f, 3.40093896e-02f, -5.16864061e-02f, -3.11036576e-02f, -4.55649681e-02f,
  7.85574317e-02f, -9.25380662e-02f, -2.51191705e-02f, -7.81530589e-02f, -9.73010585e-02f, 1.15826994e-01f, 2.49285791e-02f, 1.21918231e-01f, 3.37009248e-03f, 6.50446191e-02f,
  -1.18928785e-02f, 1.38640612e-01f, 5.82867153e-02f, -5.55394851e-02f, -1.48767252e-02f, -1.15391277e-02f, -3.29792127e-02f, -9.08951089e-02f, -7.56724998e-02f, -7.61402994e-02f,
  -4.91951890e-02f, -5.23625547e-03f, -6.67179096e-03f, -9.34109464e-02f, 2.52042320e-02f, 8.41756836e-02f, 3.94367389e-02f, 1.49685070e-02f, 5.92317581e-02f, -6.77611753e-02f,
  1.15908142e-02f, 5.00980355e-02f, 9.00398344e-02f, 1.16384313e-01f, -3.63959298e-02f, 1.97767168e-01f, 1.02266259e-02f, 3.46125513e-02f, 1.68318767e-02f, 6.60586543e-03f,
  1.72401115e-01f, 1.49082094e-01f, 6.36003613e-02f, 1.11027770e-02f, -1.50336832e-01f, -8.80062059e-02f, -4.19439673e-02f, 4.44162451e-03f, 3.71404327e-02f, 7.39234909e-02f,
  -1.34851756e-02f, 1.83351357e-02f, 3.09864115e-02f, 9.99640599e-02f, 1.11071430e-01f, 1.90075547e-01f, 1.31972507e-01f, 6.13960475e-02f, -7.29640871e-02f, 4.31542173e-02f,
  8.52298215e-02f, 1.18060894e-02f, 6.07273392e-02f, 5.06955758e-02f, 1.70694157e-01f, -5.18383607e-02f, 5.96499853e-02f, 1.12334944e-01f, 1.71602592e-01f, 2.81795174e-01f,
  7.83017650e-02f, 1.04672931e-01f, -1.29587501e-01f, 5.37870228e-02f, -7.17118680e-02f, 5.69439195e-02f, -7.03774691e-02f, -3.97988642e-03f, -1.18407965e-01f, -4.79356162e-02f,
  -6.36018515e-02f, 1.60737857e-02f, 4.59500514e-02f, -3.75167616e-02f, -5.50947189e-02f, -4.44194824e-02f, -4.83869314e-02f, 1.24043569e-01f, 4.36290465e-02f, 5.54625876e-02f,
  4.98490930e-02f, -3.52468602e-02f, -5.32496274e-02f, -1.55210063e-01f, 7.49727562e-02f, -1.12951472e-01f, -1.31526783e-01f, 2.10317653e-02f, -7.78334513e-02f, 7.13773966e-02f,
  -9.06204209e-02f, -1.88110024e-02f, 1.06923208e-01f, -4.51608635e-02f, -1.43679408e-02f, -3.26610990e-02f, 9.44868252e-02f, 7.00595006e-02f, 3.85120651e-03f, 7.17413798e-02f,
  -5.09874634e-02f, -2.19188090e-02f, -7.33969286e-02f, -2.10417777e-01f, -1.14972785e-01f, 1.28597999e-03f, 1.96669884e-02f, -4.95436937e-02f, -1.06548361e-01f, -2.94213463e-02f,
  7.99898431e-02f, 1.10757492e-01f, -6.07662350e-02f, 5.44650704e-02f, -3.43011543e-02f, -2.71181818e-02f, -9.57808569e-02f, 8.53378884e-03f, 8.28546565e-03f, -4.66688769e-04f,
  -1.92848042e-01f, -2.30865926e-01f, 4.55791038e-03f, 1.59792542e-01f, 7.50207826e-02f, -5.38139939e-02f, -5.30541837e-02f, -2.86736898e-03f, -7.23706782e-02f, -4.21571024e-02f,
  -9.89856198e-04f, 2.13565696e-02f, -5.06167412e-02f, 5.67686297e-02f, -1.08819135e-01f, -9.55241695e-02f, -6.78857341e-02f, 1.58965234e-02f, -7.11856186e-02f, -6.93247318e-02f,
  -2.60691177e-02f, -1.72378629e-01f, -1.61098242e-01f, -1.37735561e-01f, -5.19457385e-02f, -2.17054814e-01f, -2.12285340e-01f, -7.18003958e-02f, -1.27097622e-01f, -2.31316000e-01f,
  8.14170763e-02f, -3.32858562e-01f, 1.19088106e-01f, 1.58497602e-01f, 1.71746183e-02f, 3.76458727e-02f, 1.63832754e-01f, 6.88040480e-02f, 5.63656054e-02f, -1.01779699e-01f,
  -1.77555710e-01f, -1.90414533e-01f, -1.01106003e-01f, -2.28697449e-01f, -1.87509671e-01f, 7.17349350e-02f, 1.46258697e-01f, 1.57235026e-01f, 2.21401811e-01f, 1.79145217e-01f,
  6.07743300e-02f, 8.82250220e-02f, 9.53004230e-03f, 4.41198796e-02f, -5.30164652e-02f, 1.51356012e-02f, -1.68615654e-02f, -8.10159370e-03f, -1.02222160e-01f, -2.89372429e-02f,
  4.61298153e-02f, -6.51302263e-02f, 5.74952066e-02f, -1.19395658e-01f, -1.54562369e-01f, -1.11201577e-01f, -1.77613832e-02f, -3.70267928e-02f, -4.71332334e-02f, 2.94266287e-02f,
  -4.11235690e-02f, -5.61770014e-02f, -9.49392840e-02f, -8.22488591e-02f, -2.26077773e-02f, -6.72041699e-02f, -6.03551231e-02f, -2.26151142e-02f, 7.23990276e-02f, -8.91943928e-03f,
  -5.36318235e-02f, -1.36971623e-01f, -6.14604466e-02f, 6.94394484e-02f, -1.20639674e-01f, -6.79682121e-02f, 2.21927539e-02f, -5.71778901e-02f, -2.41665523e-02f, 7.32916817e-02f,
  8.11614916e-02f, 3.99601646e-02f, -5.40618077e-02f, -4.87411208e-02f, -4.04986776e-02f, -4.04469296e-02f, 4.13316078e-02f, -5.23942057e-03f, -3.14693078e-02f, 1.86236203e-02f,
  -9.40650851e-02f, 1.94586795e-02f, 1.04785204e-01f, 6.03603246e-03f, -6.87122867e-02f, 2.50027664e-02f, 1.19688194e-02f, 2.09643394e-02f, -1.22798411e-02f, 6.58907043e-03f,
  -5.38645685e-03f, 4.99025285e-02f, 8.64709243e-02f, 2.13495828e-02f, -9.55100581e-02f, 3.07287704e-02f, 3.42053212e-02f, -9.83388275e-02f, -4.85739000e-02f, 4.64847758e-02f,
  1.64143682e-01f, -2.66728569e-02f, 1.00007325e-01f, -6.46434955e-06f, 6.34492040e-02f, -2.28336435e-02f, -4.17479388e-02f, 1.59422606e-02f, -1.62906107e-02f, -3.21471468e-02f,
  -4.97326069e-02f, -6.61030859e-02f, -7.18972683e-02f, -5.41911945e-02f, 5.40782511e-02f, -3.14511992e-02f, -1.13513343e-01f, -6.12368286e-02f, 1.21576272e-01f, 8.58172551e-02f,
  -7.16881603e-02f, 6.67063445e-02f, 1.55349553e-01f, 8.66275430e-02f, 7.46710896e-02f, 8.63323137e-02f, 4.44627441e-02f, 1.04726836e-01f, 4.82186414e-02f, 1.70091689e-01f,
  4.50752228e-01f, -2.03767031e-01f, -4.05588865e-01f, 1.16660632e-01f, -1.87461704e-01f, -2.51141429e-01f, -2.09138557e-01f, -5.22959381e-02f, 1.22002058e-01f, -1.73436671e-01f,
  -1.30827636e-01f, 4.19982411e-02f, -7.04240575e-02f, -1.18240513e-01f, -1.09754451e-01f, -3.23658764e-01f, -3.55809450e-01f, -1.67636529e-01f, 1.00827694e-01f, -5.72207123e-02f,
  -3.96472365e-02f, -2.35149711e-02f, 1.16641484e-01f, 3.68188955e-02f, -2.84067709e-02f, -4.55124453e-02f, -2.16262579e-01f, -1.40820414e-01f, -2.25734398e-01f, -1.80772215e-01f,
  -3.11606348e-01f, 5.46639320e-03f, -1.32431850e-01f, 9.43885967e-02f, -1.90034509e-01f, -4.85639796e-02f, -8.61393288e-02f, -1.09093539e-01f, 5.79557605e-02f, -3.68348807e-02f,
  4.57897037e-02f, -6.77765906e-02f, 8.01210850e-02f, -8.10975060e-02f, -8.37076157e-02f, -3.75825427e-02f, 4.04202053e-03f, 2.32535228e-03f, 3.20011042e-02f, -4.48727794e-02f,
  -5.09974957e-02f, -1.18192129e-01f, -9.98049751e-02f, 1.09246057e-05f, -9.51250866e-02f, -4.51669507e-02f, 7.73867301e-04f, 5.33823147e-02f, -1.11559369e-01f, -9.77429748e-02f,
  2.65146210e-03f, 4.44288701e-02f, -3.27822529e-02f, -9.78217125e-02f, -3.87936085e-02f, -6.86658733e-03f, 6.32370859e-02f, 2.55810749e-02f, 3.48268747e-02f, -5.98195847e-03f,
  -1.45564545e-02f, -1.42410159e-01f, 1.41789801e-02f, 3.15372013e-02f, 8.47540237e-03f, 9.62026566e-02f, 6.87730312e-02f, -1.16488067e-02f, -1.35139497e-02f, -8.15925188e-03f,
  1.19845770e-01f, 2.82051191e-02f, 7.21120322e-03f, 7.96845034e-02f, -1.07508153e-01f, 1.20549509e-02f, 8.70039985e-02f, -2.39689890e-02f, -2.35084407e-02f, 3.32550146e-02f,
  1.56485036e-01f, -3.09153870e-02f, -3.37711237e-02f, 8.22444558e-02f, 1.12343930e-01f, -3.03586423e-02f, 2.32641562e-03f, -7.25704208e-02f, 8.92844871e-02f, 5.88645460e-03f,
  -3.72154154e-02f, 1.51517699e-02f, -2.36980002e-02f, 5.24475835e-02f, -1.07106483e-02f, -1.11308314e-01f, 2.34382637e-02f, 7.03754649e-02f, 4.51032333e-02f, -6.75001973e-03f,
  -6.85878247e-02f, 1.21488320e-02f, 3.52551155e-02f, 5.61109409e-02f, -1.45288417e-02f, 3.63753624e-02f, 8.09449479e-02f, 9.20111686e-02f, 1.30206104e-02f, -3.40435561e-03f,
  1.66858166e-01f, 1.76989332e-01f, 3.49243730e-02f, 1.25621706e-01f, -2.13396564e-01f, -2.93902189e-01f, -1.96723878e-01f, -2.53087003e-02f, 6.49377853e-02f, 1.01423718e-01f,
  -1.76150590e-01f, -3.77382010e-01f, -3.39857079e-02f, -1.35006070e-01f, -1.34269089e-01f, 1.85513496e-01f, 1.81105718e-01f, -6.49077212e-03f, -3.73093665e-01f, -3.85226011e-01f,
  -2.38779053e-01f, 9.03546885e-02f, 1.15854017e-01f, -8.50695893e-02f, 3.55772227e-02f, -2.23968044e-01f, 2.11309269e-01f, 5.20865014e-03f, -2.16629103e-01f, 1.03434762e-02f,
  1.54034555e-01f, -1.93989992e-01f, -1.62789643e-01f, -2.96564609e-01f, 1.40756946e-02f, -5.04870154e-02f, -1.66360468e-01f, -2.69773062e-02f, -4.84833047e-02f, 4.21198197e-02f,
  -2.55767554e-01f, -1.45950064e-01f, -2.60568440e-01f, -2.04983756e-01f, 2.16379240e-02f, -7.37312958e-02f, 1.52306467e-01f, 1.37460176e-02f, 9.56387371e-02f, -1.19149163e-01f,
  -1.49662539e-01f, -3.12134385e-01f, -1.85469911e-01f, -7.40688667e-02f, 1.46049615e-02f, -8.04494321e-02f, -1.26012757e-01f, -2.03424454e-01f, -1.90872818e-01f, 3.35974187e-01f,
  -2.69471388e-03f, -1.05771206e-01f, -1.55388133e-03f, 1.36089236e-01f, 3.94320190e-02f, -3.10934130e-02f, 3.21595185e-02f, 3.77829000e-03f, 4.13078330e-02f, -1.71862748e-02f,
  -7.03429803e-02f, 8.03480297e-02f, 9.50113088e-02f, 8.52820799e-02f, 5.49139753e-02f, -1.80014018e-02f, -3.14888135e-02f, 1.92206159e-01f, 3.25380862e-02f, -4.08635028e-02f,
  4.94192122e-03f, -1.18545406e-01f, 3.79282162e-02f, -5.13637438e-02f, 4.13768627e-02f, 1.27993688e-01f, -5.06025478e-02f, -2.92637269e-03f, -2.19465001e-03f, -5.14045265e-03f,
  2.66033351e-01f, -1.22217737e-01f, 1.68671072e-01f, -2.19601080e-01f, -3.51720043e-02f, 5.49393147e-03f, 1.00755235e-02f, -6.38488978e-02f, -7.83328041e-02f, -5.36673293e-02f,
  -2.62692660e-01f, -7.84258172e-02f, 8.97416398e-02f, -7.68460706e-02f, -2.03014269e-01f, -1.31224751e-01f, 4.85326536e-02f, -1.27768546e-01f, -1.90844342e-01f, -3.56298462e-02f,
  2.18948931e-01f, -1.03542758e-02f, 9.59896371e-02f, 1.20719060e-01f, -2.24485081e-02f, -1.12665541e-01f, 6.70480877e-02f, -6.57963306e-02f, -9.91935655e-02f, 4.00632173e-01f,
  -2.81284451e-01f, -4.69724312e-02f, 1.89746022e-02f, 8.07776526e-02f, -1.09851444e-02f, -1.53948128e-01f, -2.06111997e-01f, -6.21798560e-02f, 1.45849541e-01f, 1.59865335e-01f,
  1.90590113e-01f, 2.86129177e-01f, 2.12718710e-01f, 9.10219401e-02f, 8.98979679e-02f, 4.00370061e-02f, 2.22430006e-02f, -5.72863594e-03f, -8.54961276e-02f, -5.86793572e-02f,
  3.53538394e-02f, -1.14101872e-01f, -5.60428016e-02f, -7.78901130e-02f, 1.31281853e-01f, 4.65236269e-02f, -2.41107903e-02f, -2.49002483e-02f, 4.25598957e-03f, 2.27042168e-01f,
  3.61376703e-01f, -3.05623058e-02f, 8.96367505e-02f, 3.37792821e-02f, 9.63982195e-03f, -1.02395583e-02f, -7.54275313e-03f, 3.92787196e-02f, -2.61840522e-02f, 2.61631571e-02f,
  6.02365509e-02f, 1.39814932e-02f, -1.62824601e-01f, 1.48044545e-02f, -5.32399602e-02f, -2.75901835e-02f, 1.31306350e-02f, -5.05612530e-02f, -3.80277932e-02f, 7.48625621e-02f,
  7.02838749e-02f, 6.32192194e-02f, 6.92298114e-02f, -1.48374131e-02f, -2.40978878e-02f, 6.09856024e-02f, -2.29737107e-02f, 4.30315994e-02f, -3.74036469e-02f, 9.65346694e-02f,
  1.04831949e-01f, 1.94111273e-01f, 1.18030638e-01f, -1.71357375e-02f, -7.91343395e-03f, 4.55879718e-02f, 7.57102743e-02f, -6.24597725e-03f, -1.32324826e-02f, -4.13447134e-02f,
  -2.84000430e-02f, 7.14456812e-02f, -7.95234889e-02f, 2.88304705e-02f, 5.08453697e-02f, 1.20353132e-01f, -2.76924782e-02f, 1.70845643e-01f, 4.84273061e-02f, 1.38928574e-02f,
  -2.15462763e-02f, -1.20112598e-01f, -3.92629392e-02f, -5.51061556e-02f, 6.38130959e-03f, 1.71820283e-01f, 6.16096295e-02f, -5.32432050e-02f, -4.26684693e-02f, -6.40631393e-02f,
  3.96934241e-01f, -1.36500821e-01f, 8.37818086e-02f, -5.90490364e-02f, -5.94102889e-02f, 4.69109826e-02f, 1.76000565e-01f, -2.07826570e-02f, -3.25619429e-02f, 2.95137987e-02f,
  -1.56126218e-02f, 4.42844741e-02f, -7.22243562e-02f, 4.83661750e-03f, -1.77844584e-01f, -2.90860683e-02f, 1.27253577e-01f, 1.63659588e-01f, 1.18592598e-01f, 1.98024079e-01f,
  6.59013093e-02f, 8.92056376e-02f, 6.10973984e-02f, 1.34730101e-01f, -4.38143983e-02f, 1.53593391e-01f, -1.14939790e-02f, 7.51930103e-02f, -8.99160132e-02f, -5.17159477e-02f,
  1.65184557e-01f, 1.87689558e-01f, 2.38704547e-01f, 2.01851130e-01f, 2.06229940e-01f, 2.32824728e-01f, 2.02691674e-01f, 1.27732143e-01f, 4.42194864e-02f, 2.04063356e-01f,
  8.75641406e-02f, 2.19602764e-01f, 2.40191594e-01f, 1.83325633e-01f, 1.86522737e-01f, 2.07238808e-01f, 7.64843300e-02f, 1.16708711e-01f, 1.03711590e-01f, 1.94673628e-01f,
  7.30795190e-02f, 5.56488372e-02f, -2.28418577e-02f, 2.52743699e-02f, 1.20107837e-01f, 6.88142031e-02f, 8.81521255e-02f, 1.25182137e-01f, 1.20334886e-01f, 4.24030125e-02f,
  1.07085019e-01f, -3.86625230e-02f, -2.25615036e-03f, -4.52818386e-02f, -1.88810036e-01f, -1.95422500e-01f, 2.21343078e-02f, -1.02833152e-01f, -6.69081584e-02f, -9.04747620e-02f,
  -8.58844742e-02f, -7.18644308e-03f, 4.77222400e-03f, -4.70947986e-03f, -1.33629978e-01f, -1.53782368e-01f, -3.58590521e-02f, 3.16863358e-02f, 1.44893542e-01f, -7.91716352e-02f,
  6.94943070e-02f, 5.12189083e-02f, 1.35512218e-01f, 6.36295155e-02f, -1.24894828e-02f, 2.38513714e-03f, 1.07941985e-01f, -2.20031906e-02f, 1.27882687e-02f, 3.77772041e-02f,
  1.35605782e-01f, 1.07250214e-01f, 1.46995082e-01f, -3.84837575e-03f, 5.50880879e-02f, 7.61734545e-02f, -1.08689934e-01f, 3.80051765e-03f, 1.12816401e-01f, -4.72409651e-02f,
  3.14703304e-03f, 1.60476848e-01f, 1.28180414e-01f, -4.07974571e-02f, -5.23474999e-02f, 6.36307448e-02f, 7.61884637e-03f, -7.27185560e-03f, 5.93485385e-02f, -4.76613976e-02f,
  -1.39093390e-02f, -6.79179132e-02f, -4.66036536e-02f, -6.28579780e-02f, -6.43386506e-03f, 8.32434744e-02f, 2.90353168e-02f, -7.12881461e-02f, -1.86267234e-02f, -1.56073317e-01f,
  -8.72706920e-02f, 2.62629390e-01f, -2.30961982e-02f, -2.35570055e-02f, -8.70628282e-02f, -1.51890472e-01f, 6.13495596e-02f, -8.46663490e-03f, -1.11891262e-01f, -1.31799787e-01f,
  -1.53938690e-02f, 3.09880283e-02f, -3.09897754e-02f, 4.39381674e-02f, -3.73333576e-03f, -1.39205039e-01f, -1.23890907e-01f, 9.42491964e-02f, -9.45420787e-02f, -8.21339488e-02f,
  -6.00981638e-02f, -3.49188074e-02f, 6.98346421e-02f, 1.11728437e-01f, -5.74608892e-02f, -6.51902035e-02f, -4.00470085e-02f, 5.26458863e-03f, -1.50056276e-02f, -1.05617046e-01f,
  1.18484572e-01f, -2.17361704e-01f, -2.10730866e-01f, -9.77828503e-02f, -1.10788114e-01f, -1.50839329e-01f, -1.01663388e-01f, 4.88303490e-02f, 3.13739516e-02f, -2.16799602e-01f,
  -7.18647009e-03f, 1.30524173e-01f, -2.99634831e-03f, -2.06239298e-02f, 1.20906457e-02f, -2.94872493e-01f, -2.11620197e-01f, -1.92533359e-02f, 3.29841524e-01f, 1.47687241e-01f,
  9.97130275e-02f, 8.85404497e-02f, 4.31665741e-02f, 9.41737667e-02f, -1.54293448e-01f, 2.71370709e-02f, -2.66036659e-01f, -1.40616789e-01f, -4.90790866e-02f, -3.63499492e-01f,
  -5.40469289e-02f, -1.77934304e-01f, -1.87789351e-02f, 1.67821385e-02f, -5.15828282e-03f, 3.41582224e-02f, 5.33204488e-02f, 2.24993788e-02f, -3.18991393e-02f, 4.11234386e-02f,
  -8.67138505e-02f, 1.54045582e-01f, -1.65215489e-02f, 5.52712418e-02f, 1.14803925e-01f, 2.04178989e-02f, 6.01402447e-02f, 1.76684670e-02f, -1.13714457e-01f, -4.44083624e-02f,
  5.11559891e-03f, -1.37436584e-01f, -7.44110495e-02f, -4.55860309e-02f, -1.57021523e-01f, 3.07359803e-03f, -1.53918952e-01f, -5.20492047e-02f, -1.79774150e-01f, -2.74762243e-01f,
  -6.34803921e-02f, 2.08385661e-03f, 9.91848707e-02f, 6.34787977e-02f, 3.37346531e-02f, 4.76819277e-02f, 6.20375499e-02f, -5.17089777e-02f, 9.33100581e-02f, 2.01132931e-02f,
  -2.75986902e-02f, 1.96651649e-02f, -4.17695306e-02f, -7.05828592e-02f, -7.16472790e-02f, -3.61753851e-02f, 4.98188287e-02f, -1.04247116e-01f, 5.21099642e-02f, 6.61128536e-02f,
  4.71947249e-03f, 1.00451764e-02f, 5.49822897e-02f, 1.28817722e-01f, 8.23656935e-03f, 1.15427233e-01f, -1.71728525e-02f, 2.93335579e-02f, 9.53212008e-02f, -2.32086144e-03f,
  1.41378835e-01f, -1.98478907e-01f, -1.01040982e-01f, -3.35836858e-02f, 4.53888327e-02f, 2.01248787e-02f, 1.34132663e-03f, 6.87303692e-02f, 4.12750058e-02f, 8.73829201e-02f,
  -3.78914960e-02f, 8.97042826e-02f, -1.00897681e-02f, -1.96445603e-02f, 8.95665362e-02f, 1.01401448e-01f, -9.44036804e-03f, 8.48608539e-02f, -3.26821543e-02f, 4.67357598e-02f,
  1.78662799e-02f, 1.03520148e-01f, 7.88190141e-02f, -4.61147055e-02f, -8.57899431e-03f, 3.15585025e-02f, -1.98255740e-02f, -1.99198388e-02f, -5.28514385e-03f, 9.06308219e-02f,
  1.97200119e-01f, -2.68448859e-01f, 8.41217116e-03f, -6.06255606e-02f, -1.33148596e-01f, -6.01159036e-02f, -1.40482575e-01f, -1.33526875e-02f, -1.02435820e-01f, -1.31378949e-01f,
  -2.56331265e-02f, 9.67098922e-02f, 8.24686289e-02f, 1.89417809e-01f, 1.12391986e-01f, -9.38692093e-02f, -1.58741072e-01f, 1.58058017e-01f, 3.21748674e-01f, -3.29835969e-03f,
  -1.73589379e-01f, -6.01445138e-02f, 6.23335317e-02f, -7.97518808e-03f, -2.47011185e-01f, -4.88479249e-02f, -2.55823463e-01f, -7.35914633e-02f, -1.02908090e-01f, -3.24915290e-01f,
  2.75649369e-01f, 1.28273338e-01f, 2.25488693e-02f, 7.11703002e-02f, -1.06759556e-02f, -5.20868413e-03f, -1.76051911e-02f, -7.32034370e-02f, 8.76402669e-03f, 1.14605464e-02f,
  -2.85345446e-02f, -4.92687784e-02f, 3.94725762e-02f, 6.64683133e-02f, 7.08827227e-02f, 2.50309203e-02f, 6.74948171e-02f, 2.09358893e-03f, -5.86459450e-02f, -5.12968563e-02f,
  5.19526675e-02f, 5.99070340e-02f, 1.57284990e-01f, 5.19008674e-02f, 1.54429719e-01f, 1.62088484e-01f, 1.28674567e-01f, 2.54850369e-02f, 1.38786778e-01f, -9.22476407e-03f,
  -2.71833930e-02f, -7.42034661e-03f, 1.15206942e-01f, 3.08224354e-02f, 4.31589894e-02f, 2.44242717e-02f, 1.11863270e-01f, 1.63000166e-01f, 1.26005679e-01f, -4.17380854e-02f,
  -5.22818156e-02f, 3.05365361e-02f, 7.89727494e-02f, -4.84741032e-02f, -2.47495398e-02f, -2.73985956e-02f, -3.59722748e-02f, 4.71132584e-02f, 2.89503057e-02f, 4.72606197e-02f,
  2.12892275e-02f, -7.79426694e-02f, -1.34184048e-01f, -7.57303610e-02f, -4.65408713e-02f, 8.56419373e-03f, 1.44413905e-02f, -4.36741933e-02f, -3.79867367e-02f, -9.57990885e-02f,
  1.27659187e-01f, 2.34266058e-01f, 1.36112766e-02f, -3.12784724e-02f, -6.15861341e-02f, -3.78566869e-02f, -4.96058874e-02f, -3.65357436e-02f, -9.97402593e-02f, -1.56945214e-02f,
  8.01801533e-02f, 5.23087494e-02f, 2.45245527e-02f, -1.17278740e-01f, -8.71122777e-02f, 5.26767969e-02f, -1.26681784e-02f, 4.68606800e-02f, -8.72794911e-02f, -8.55217054e-02f,
  -6.63359240e-02f, -2.96692224e-03f, 2.32008830e-01f, 6.01373464e-02f, 9.19284970e-02f, 1.37377977e-01f, 6.62225764e-03f, 2.39315666e-02f, 5.75197823e-02f, -7.67708896e-03f,
  -2.45033383e-01f, -1.48545876e-01f, 1.18485451e-01f, -2.03022450e-01f, -6.82439357e-02f, -9.59002376e-02f, -2.29966477e-01f, -1.34697407e-01f, 1.33446325e-02f, -1.73208177e-01f,
  -7.05567971e-02f, -1.03317238e-01f, -3.80809419e-02f, -1.84080288e-01f, -3.45547855e-01f, -2.14326963e-01f, -1.31968766e-01f, -1.93714097e-01f, -2.06763402e-01f, -2.58533746e-01f,
  -2.50451148e-01f, -2.53021955e-01f, -1.19291909e-01f, -2.03546304e-02f, -3.63534428e-02f, 7.51082227e-02f, 1.34138718e-01f, 5.57224229e-02f, 9.49020162e-02f, 9.76128653e-02f,
  -1.24906912e-01f, 1.85583308e-01f, 1.25647843e-01f, -3.28454264e-02f, -7.81184584e-02f, 4.82985117e-02f, -5.75479940e-02f, 2.84511596e-03f, 1.67920053e-01f, -2.99396319e-03f,
  -9.64356884e-02f, -2.76477505e-02f, 1.38585297e-02f, -5.35950586e-02f, -1.14536963e-01f, -9.65838283e-02f, -1.52626574e-01f, -2.68651303e-02f, 6.51440397e-02f, 6.03831327e-03f,
  -1.83333024e-01f, -3.05427667e-02f, -7.55896345e-02f, -5.44041209e-02f, 5.64286113e-02f, -6.76410496e-02f, 3.03174909e-02f, 3.62956449e-02f, 1.84586093e-01f, 1.28540471e-01f,
  -8.69317651e-02f, -2.22045779e-02f, -1.82979684e-02f, -4.42548245e-02f, -8.99366587e-02f, 9.64341462e-02f, 4.11739424e-02f, -9.09509510e-02f, 1.81770157e-02f, -6.30401447e-02f,
  8.69380012e-02f, 5.54475933e-02f, -3.32792588e-02f, 5.24811745e-02f, 6.23462833e-02f, -6.07844181e-02f, -5.97167090e-02f, -1.33165717e-01f, 2.90707871e-02f, 1.20526413e-02f,
  1.08737508e-02f, 1.26353264e-01f, 4.72991578e-02f, -9.36600715e-02f, -2.98697278e-02f, -1.37442499e-01f, -1.60947349e-02f, 2.87986826e-03f, -6.58999337e-03f, -8.23694617e-02f,
  -1.42756060e-01f, 1.60095483e-01f, 3.45683545e-02f, 1.49331773e-02f, 2.20931731e-02f, -3.06346174e-02f, 5.38289472e-02f, -7.72795677e-02f, 4.49960157e-02f, -1.43081844e-01f,
  4.28563654e-02f, -1.46269873e-01f, -1.05782904e-01f, -9.77675393e-02f, -1.25830382e-01f, 2.44526342e-02f, -2.11854696e-01f, -3.52764241e-02f, 1.30708218e-02f, -4.43044491e-02f,
  -1.71880931e-01f, -1.07783921e-01f, -1.60435304e-01f, -1.56157576e-02f, -5.42052314e-02f, -5.99009655e-02f, -9.88985971e-03f, 4.59297746e-02f, 2.28745006e-02f, -2.12950408e-01f,
  -3.11379135e-01f, -2.57623971e-01f, -8.44770893e-02f, -2.68909901e-01f, 2.24030130e-02f, -1.60608232e-01f, -2.64398634e-01f, -2.34765112e-01f, -1.08841784e-01f, -1.80953458e-01f,
  -5.00136800e-02f, 4.13701609e-02f, 1.06450338e-02f, 8.85728374e-02f, -1.00486472e-01f, -1.29217565e-01f, 8.94946679e-02f, 1.42072096e-01f, 1.89877838e-01f, 8.53869841e-02f,
  9.86475572e-02f, 3.51140015e-02f, 4.24473323e-02f, 8.89350250e-02f, -3.09486389e-02f, 4.63343784e-02f, 5.30846901e-02f, 1.91911142e-02f, 1.04689393e-02f, -9.69864875e-02f,
  -1.73732594e-01f, -2.11482495e-01f, 1.58508524e-01f, 7.28583112e-02f, 1.25982855e-02f, -3.68587859e-02f, -1.17310740e-01f, 1.59187809e-01f, 1.29497990e-01f, 1.64448749e-02f,
  -8.33911374e-02f, 1.26018420e-01f, -1.03881776e-01f, 6.87601939e-02f, -9.43548419e-03f, -6.65606931e-02f, 3.38023063e-03f, 5.20852283e-02f, 4.33037337e-03f, -7.25945979e-02f,
  -5.72084151e-02f, -7.08700866e-02f, -1.25814572e-01f, -6.65207729e-02f, -1.74683854e-01f, 4.62937504e-02f, -3.27476300e-02f, 2.12156028e-03f, -5.28022423e-02f, -2.20030293e-01f,
  1.36505160e-02f, 1.13236442e-01f, 7.57204078e-04f, -6.39519170e-02f, -6.13244176e-02f, -5.77144846e-02f, 3.81826833e-02f, 1.36689339e-02f, 9.79251135e-03f, -4.75528166e-02f,
  -2.04213765e-02f, 5.80577478e-02f, 4.90194233e-03f, 3.56711186e-02f, 2.96911169e-02f, -1.39665782e-01f, 2.86256112e-02f, -8.59572273e-03f, -2.47991774e-02f, -1.12676881e-02f,
  9.13990512e-02f, -2.32294686e-02f, 9.08244997e-02f, -4.82771285e-02f, 1.00959234e-01f, 2.64738891e-02f, -4.38649990e-02f, 7.20439628e-02f, 1.16449203e-02f, 4.49466221e-02f,
  -3.82752746e-01f, 2.32271448e-01f, -1.10763989e-01f, 4.98746000e-02f, 6.44000620e-02f, 1.04531407e-01f, -6.13494851e-02f, 1.09521180e-01f, 3.63421477e-02f, -2.82097366e-02f,
  -8.84737074e-02f, -1.02225102e-01f, -1.60713524e-01f, -5.65902926e-02f, -2.71623954e-03f, -5.37246978e-03f, -1.85319752e-01f, 4.29344438e-02f, -4.08909749e-03f, -1.26090109e-01f,
  -1.36534914e-01f, -2.40515828e-01f, -1.97846189e-01f, -2.37189054e-01f, -2.16983542e-01f, -1.92055721e-02f, -2.70889662e-02f, 1.43709211e-02f, -1.19074553e-01f, -3.87379855e-01f,
  -3.11152548e-01f, 4.00488526e-02f, 1.60529569e-01f, -6.29063472e-02f, 2.78127193e-01f, -1.31858230e-01f, -3.22888672e-01f, -2.50175506e-01f, -6.11231290e-02f, 4.17395169e-03f,
  1.98790401e-01f, 2.01387003e-01f, 1.10945918e-01f, 6.73054829e-02f, -3.09668660e-01f, -8.19252059e-02f, -3.64100374e-02f, -1.12081192e-01f, -3.17648768e-01f, -1.82720214e-01f,
  5.09094931e-02f, -5.46978340e-02f, -9.93703231e-02f, -2.00347781e-01f, 1.72641929e-02f, 7.65673816e-03f, 8.69847760e-02f, 1.04055993e-01f, 1.16483003e-01f, 1.20654233e-01f,
  2.30611801e-01f, -1.22593552e-01f, 2.35557463e-02f, 9.25106779e-02f, 2.20711112e-01f, -1.89251304e-01f, -4.32627238e-02f, -7.35465661e-02f, 1.14090569e-01f, 1.31747555e-02f,
  1.04272731e-01f, -1.17319273e-02f, 7.27383271e-02f, -7.87399802e-03f, -1.92173362e-01f, -5.74732199e-02f, -1.35389701e-01f, -2.61513382e-01f, -2.13273570e-01f, -1.44827768e-01f,
  1.11145347e-01f, 2.35796459e-02f, -9.26639363e-02f, -2.13096827e-01f, -1.20097727e-01f, -7.74070323e-02f, 2.58316542e-03f, -6.06586039e-02f, -2.19733387e-01f, -8.15057084e-02f,
  1.22370552e-02f, -2.52728742e-02f, 6.73211440e-02f, 4.88720946e-02f, 6.39688522e-02f, 1.55083984e-01f, 8.39260444e-02f, -1.80148687e-02f, -8.21473449e-02f, -5.01533821e-02f,
  7.12680072e-02f, 3.07715777e-02f, -3.43655311e-02f, -6.08601943e-02f, 6.45042881e-02f, -6.25695940e-03f, -4.36653420e-02f, -7.49113783e-02f, 3.53853568e-03f, -2.15031626e-03f,
  5.36582954e-02f, 4.56614457e-02f, -1.26251001e-02f, -9.53948870e-02f, -7.15536857e-03f, -1.07336745e-01f, 1.72116309e-02f, -8.59243721e-02f, -1.01121804e-02f, 1.22601744e-02f,
  -1.38385892e-01f, 1.00167364e-01f, 1.07335590e-01f, -5.80713488e-02f, 7.79916644e-02f, 1.48472022e-02f, 2.29807589e-02f, -2.51854919e-02f, 3.70855033e-02f, -1.21343441e-01f,
  -4.18820605e-02f, -9.85693783e-02f, 7.73407891e-02f, -7.54667148e-02f, -1.79632828e-01f, -4.58743162e-02f, -3.29370461e-02f, -4.33776751e-02f, -1.36699215e-01f, -8.24833568e-03f,
  -1.25649169e-01f, -2.12052673e-01f, -1.94834843e-01f, -1.77299261e-01f, -1.39467046e-01f, -1.95543513e-01f, -9.41296369e-02f, -4.98589575e-02f, -2.71316946e-01f, -2.93863893e-01f,
  4.83177394e-01f, 2.03966901e-01f, 4.22934704e-02f, 9.74560603e-02f, -3.77808996e-02f, 1.49477884e-01f, 3.54891062e-01f, 2.03372955e-01f, 1.17592709e-02f, 7.20860660e-02f,
  -2.73712277e-02f, -8.65539685e-02f, -6.87979981e-02f, -1.03193246e-01f, 1.06354840e-01f, 1.04494058e-01f, -1.72567312e-02f, 1.22558638e-01f, 1.11419763e-02f, 1.29041404e-01f,
  -2.63663102e-02f, 5.53498324e-03f, 1.71081066e-01f, 1.65115446e-01f, 1.74272865e-01f, -5.86529672e-02f, -1.03664733e-02f, 1.67897254e-01f, 8.83305222e-02f, 5.79317734e-02f,
  -8.65232497e-02f, 2.29660854e-01f, -1.62695095e-01f, -1.68254271e-01f, -3.26717086e-02f, 9.31235477e-02f, 1.21687859e-01f, 4.80803438e-02f, -4.97411825e-02f, -4.97844219e-02f,
  -3.65525708e-02f, -4.33810567e-03f, 8.63856673e-02f, 9.05789156e-03f, 1.78953800e-02f, -9.12502501e-03f, -3.66635099e-02f, 1.57446742e-01f, 3.20127723e-03f, -3.76544036e-02f,
  2.72705816e-02f, 2.65772864e-02f, 3.13095935e-02f, 5.91512360e-02f, 7.29697645e-02f, -4.26662080e-02f, 6.99518844e-02f, 2.34103408e-02f, -3.70568745e-02f, -2.22079270e-02f,
  5.86847365e-02f, 1.16474241e-01f, 8.60802233e-02f, 1.50904790e-01f, 1.51576266e-01f, 4.91018593e-02f, 2.70398259e-02f, 9.91954952e-02f, 2.39420131e-01f, 2.40452707e-01f,
  6.39027357e-02f, 7.59640709e-02f, 1.73933625e-01f, 2.32465550e-01f, -4.01469357e-02f, 9.24487561e-02f, -1.69362705e-02f, 5.40245846e-02f, 8.27812329e-02f, 1.25510171e-01f,
  2.73040030e-02f, 8.32965448e-02f, 1.43968299e-01f, 9.81064439e-02f, -1.60250664e-02f, -1.49734123e-02f, 9.03935507e-02f, 3.63448188e-02f, 1.47504941e-01f, 9.72618610e-02f,
  -2.16455877e-01f, 6.37366548e-02f, -6.11787178e-02f, 3.82088940e-03f, 7.40107149e-02f, -1.11951575e-01f, 6.95968792e-02f, -6.05507195e-02f, -9.95380580e-02f, 2.06491407e-02f,
  -3.54966633e-02f, 4.27458435e-03f, 1.64339706e-01f, 2.10933536e-01f, 8.76985416e-02f, 2.67604347e-02f, -5.92269488e-02f, 4.15730551e-02f, -1.18023425e-01f, -1.42170891e-01f,
  -1.03692554e-01f, -4.56059165e-02f, -1.90869197e-01f, -5.96574880e-02f, 2.31310725e-02f, -1.49659708e-01f, 1.06503693e-02f, -4.15981598e-02f, -7.44519830e-02f, 4.51860726e-02f,
  -1.07712023e-01f, 4.64977250e-02f, -2.34116971e-01f, -1.68149740e-01f, -1.25555202e-01f, -1.23210303e-01f, -1.37968346e-01f, 1.13809861e-01f, 2.81022415e-02f, -2.56491870e-01f,
  -6.97625950e-02f, 4.06160094e-02f, -1.31020978e-01f, -5.88186979e-02f, -1.81171969e-01f, -2.48044297e-01f, -2.91876465e-01f, -3.35608155e-01f, -1.14323080e-01f, -2.16448307e-02f,
  -6.38863742e-02f, -1.10664114e-01f, -1.22168459e-01f, -1.72862802e-02f, -4.51225266e-02f, 3.54274549e-02f, -1.37350693e-01f, -1.65036973e-02f, -3.06280199e-02f, -1.84997767e-01f,
  -3.46335799e-01f, 3.83110978e-02f, -1.05021097e-01f, -5.81238084e-02f, -1.43610030e-01f, 1.91425458e-01f, -2.54121125e-02f, -1.54399157e-01f, -8.96645524e-03f, -3.11882999e-02f,
  -4.40395586e-02f, 8.68993029e-02f, -5.03076613e-02f, -6.53274953e-02f, -1.55072298e-03f, -6.67607635e-02f, -2.98643224e-02f, -5.59297353e-02f, -5.22747189e-02f, 1.04422748e-01f,
  -4.53778841e-02f, -1.68433785e-01f, -9.11586061e-02f, 1.05426274e-02f, 1.29897371e-01f, -1.08614177e-01f, 6.71204552e-02f, 5.60918748e-02f, 9.70622897e-02f, 3.44386511e-03f,
  -7.21893013e-02f, 7.20020663e-03f, -1.87814259e-03f, 1.13726869e-01f, -1.51875168e-02f, 2.40766481e-02f, -2.87684295e-02f, 4.47338773e-03f, -3.01487967e-02f, -7.35337734e-02f,
  2.76918709e-03f, 2.79273815e-03f, 3.28370370e-02f, -6.02297671e-02f, -1.22341746e-02f, -1.12584993e-01f, -1.78727552e-01f, -1.82593480e-01f, -2.79257055e-02f, -3.94060910e-02f,
  -7.98715204e-02f, 3.08941994e-02f, 1.86441522e-02f, -8.74316767e-02f, -6.57434389e-02f, -9.10554230e-02f, -2.80224476e-02f, -5.88423721e-02f, -8.43881741e-02f, -1.25816450e-01f,
  -6.60331398e-02f, -1.28045037e-01f, -1.61723822e-01f, 4.94347475e-02f, -5.08579612e-02f, 9.37618688e-02f, 7.57701769e-02f, -1.28001228e-01f, -3.02720945e-02f, -1.14078403e-01f,
  -3.41255218e-02f, -8.69526528e-04f, 3.47894207e-02f, 5.64733054e-04f, 3.75657491e-02f, -1.06493764e-01f, 4.05749306e-02f, -1.28521502e-01f, 5.70451133e-02f, 1.32294059e-01f,
  1.22782968e-01f, 2.10796949e-03f, 2.84594148e-02f, -8.14410076e-02f, -4.84733703e-03f, -5.03848419e-02f, -1.00169487e-01f, -4.22749706e-02f, -1.07166672e-03f, -8.51749852e-02f,
  -3.56337905e-01f, -2.10794628e-01f, -3.45075577e-01f, -2.67540701e-02f, 1.17548272e-01f, -4.01463173e-02f, -1.40012085e-01f, -1.19113922e-01f, -2.82673892e-02f, -8.01630225e-03f,
  1.16341211e-01f, 2.66547531e-01f, 1.84250534e-01f, 2.04044163e-01f, -9.21041816e-02f, -1.80076167e-01f, -1.01570599e-01f, -1.81329846e-01f, 1.38540059e-01f, 2.27910995e-01f,
  2.88435251e-01f, 1.79215893e-01f, -1.08726203e-01f, 7.99557716e-02f, 1.40387818e-01f, 2.95855284e-01f, -1.01010054e-01f, 1.30194843e-01f, 1.48326680e-01f, 1.11825541e-01f,
  7.81043842e-02f, -3.47817421e-01f, -1.25490606e-03f, 2.45799627e-02f, 7.07395971e-02f, -5.51786162e-02f, 8.69711488e-02f, -2.58094162e-01f, -1.33330733e-01f, 4.65139607e-03f,
  -6.06985800e-02f, -1.03589498e-01f, 2.12296695e-02f, 1.04658373e-01f, 2.90852739e-03f, -6.71674609e-02f, -1.92396164e-01f, -3.14287066e-01f, -2.57934242e-01f, -8.62195715e-02f,
  1.75275519e-01f, 6.49790764e-02f, -2.26200372e-01f, -1.02337733e-01f, -2.76990503e-01f, -1.47174699e-02f, -1.45260960e-01f, -6.68416172e-02f, -2.29916006e-01f, -8.55662748e-02f,
  -1.24059562e-02f, 6.73335940e-02f, -9.08670202e-02f, -1.76398814e-01f, 1.80108193e-02f, -4.07591872e-02f, 7.80733442e-03f, 1.22642338e-01f, 4.20366451e-02f, -7.56825358e-02f,
  5.83024435e-02f, 4.47649360e-02f, 5.29744662e-02f, -4.96289507e-02f, 1.56365305e-01f, -3.56062651e-02f, 7.48422986e-04f, -4.49076034e-02f, -1.30234152e-01f, -1.37401214e-02f,
  2.99577788e-02f, -1.45599589e-01f, 2.56442297e-02f, -6.35028034e-02f, -1.11034155e-01f, -1.03489846e-01f, -2.93570589e-02f, -4.34205942e-02f, 7.32220104e-03f, -1.07536495e-01f,
  2.25457147e-01f, -2.21220434e-01f, 6.43346086e-02f, 2.02572599e-01f, 4.85110879e-02f, -1.75035801e-02f, 3.59921679e-02f, -6.27541319e-02f, -8.25376809e-03f, -4.03551087e-02f,
  -7.68411905e-02f, -9.49401185e-02f, 8.18704888e-02f, -6.59761727e-02f, 1.03572987e-01f, -5.27821817e-02f, 6.19745702e-02f, 7.13119656e-02f, -1.75688528e-02f, -1.02689132e-01f,
  -1.52618572e-01f, -4.67575677e-02f, -2.10742243e-02f, -9.80759487e-02f, 1.27723133e-02f, 1.11286424e-01f, 7.19993562e-02f, 1.58393234e-01f, -1.26188755e-01f, -4.95781675e-02f,
  5.82736731e-01f, -2.12997109e-01f, 9.17189419e-02f, 6.59726560e-02f, -1.67332530e-01f, -3.34214121e-02f, -2.21651569e-01f, -5.50270081e-02f, 9.93948057e-02f, -5.21952882e-02f,
  5.49199805e-02f, 8.60038772e-02f, 5.22288419e-02f, 1.50600001e-01f, 1.59337521e-01f, -2.30049267e-02f, 8.75446294e-03f, 2.06829071e-01f, 2.68177330e-01f, 3.94950211e-02f,
  1.15222214e-02f, -1.42940423e-02f, 1.05302200e-01f, 8.86046607e-03f, -3.36964801e-02f, 8.63413066e-02f, 3.41016911e-02f, 5.67613691e-02f, -1.34186354e-02f, 9.83168185e-02f,
  2.88891733e-01f, 2.10928112e-01f, 9.80200619e-02f, -1.91209614e-02f, 4.66876058e-03f, 4.62470390e-03f, -4.36069556e-02f, -4.48099524e-02f, -1.01033568e-01f, -1.35283455e-01f,
  2.82976218e-02f, 3.87791805e-02f, 2.51439642e-02f, -6.72411779e-03f, -6.64728284e-02f, 1.79535570e-03f, -1.37541622e-01f, 1.75138284e-02f, 8.93128812e-02f, 6.30432158e-04f,
  -8.89625475e-02f, -6.87127262e-02f, -1.00350924e-01f, -1.31138518e-01f, -2.77251638e-02f, 5.91538586e-02f, -1.45356748e-02f, -4.34466377e-02f, -7.57477358e-02f, 5.51412329e-02f,
  1.08129509e-01f, -2.42345557e-02f, 3.97136882e-02f, -2.73862649e-02f, -3.68990749e-02f, -1.25845373e-01f, -4.49961722e-02f, -1.56405624e-02f, 6.99112415e-02f, -1.35403857e-01f,
  -1.73979267e-01f, -5.36120590e-03f, 4.57692146e-03f, -2.90779979e-03f, 9.69703719e-02f, -6.49718493e-02f, 6.14113845e-02f, -5.43146618e-02f, 2.76135933e-02f, 1.26684029e-02f,
  -2.22267527e-02f, -2.39275931e-03f, 8.44018310e-02f, -3.07192486e-02f, -5.51570021e-03f, -6.27541021e-02f, 2.01079547e-02f, -2.55578235e-02f, 7.42815956e-02f, -6.53917864e-02f,
  -2.87477151e-02f, 2.02150360e-01f, 1.46399096e-01f, 8.22640508e-02f, 3.46249267e-02f, -1.19511306e-01f, 2.14784294e-02f, -2.78392155e-02f, -1.71844348e-01f, 4.23054397e-02f,
  8.56438559e-03f, 2.56812852e-02f, -9.46175158e-02f, -1.00209206e-01f, -5.08520007e-02f, 6.89209178e-02f, 6.56759217e-02f, 1.36142135e-01f, 8.03244710e-02f, 5.03656045e-02f,
  -1.03860907e-01f, -6.45822287e-03f, 1.70225441e-01f, -1.36161782e-02f, 2.11007241e-02f, 1.81571245e-01f, 4.49958965e-02f, 2.89309095e-03f, -3.12497597e-02f, 4.84994911e-02f,
  4.04286653e-01f, -1.53665198e-02f, -4.79795575e-01f, 8.00730139e-02f, -2.52116472e-01f, -1.78606957e-01f, -4.73506562e-02f, 7.01698661e-02f, 1.47268698e-01f, -4.77827042e-02f,
  -1.25873059e-01f, 6.23553209e-02f, -3.42024453e-02f, -9.67155546e-02f, -3.30562564e-03f, -1.45997718e-01f, -2.78923571e-01f, -1.32989451e-01f, -1.05879322e-01f, -1.12926394e-01f,
  -6.51155040e-02f, 7.31024668e-02f, 8.72318894e-02f, -3.31549123e-02f, -1.25753999e-01f, -5.10863811e-02f, -2.23652378e-01f, -2.05964670e-02f, -1.77382573e-01f, -1.85313076e-01f,
  -3.53833020e-01f, -5.10943532e-02f, -2.57273316e-01f, 1.31307542e-01f, -1.21943474e-01f, 2.48156977e-03f, -1.99047834e-01f, -1.35223538e-01f, -4.65587303e-02f, -1.02205209e-01f,
  -1.11640252e-01f, 4.43545505e-02f, -1.09633878e-01f, -1.17001899e-01f, -1.55493440e-02f, -3.80350910e-02f, -7.65385758e-03f, 5.36037274e-02f, -2.25017611e-02f, -1.44324571e-01f,
  -4.43929248e-02f, -1.48142427e-01f, -1.25127420e-01f, -9.36038792e-02f, -1.98159248e-01f, -2.38251574e-02f, -2.42925048e-01f, -2.09475622e-01f, -2.12704733e-01f, -7.16601014e-02f,
  2.82432847e-02f, 3.93196382e-02f, -2.53554787e-02f, 7.83314928e-02f, 7.47790411e-02f, 7.90978689e-03f, 4.45774309e-02f, 4.33415473e-02f, 2.53587235e-02f, 2.68113762e-02f,
  6.49322122e-02f, -7.88876414e-02f, 4.69312035e-02f, 4.33515683e-02f, -1.08343579e-01f, 2.62191780e-02f, 7.14717209e-02f, 2.85629611e-02f, -6.56431988e-02f, 7.62851834e-02f,
  4.16399017e-02f, 2.00297534e-02f, 9.55507508e-04f, 2.14579385e-02f, -5.09454943e-02f, -3.97850722e-02f, 1.92927048e-02f, 4.59616818e-02f, 5.36304601e-02f, -9.03488770e-02f,
  3.46944124e-01f, 3.44745703e-02f, 9.30625945e-02f, -2.70155184e-02f, -2.86650062e-02f, 3.89879681e-02f, -1.89283453e-02f, 3.63743566e-02f, 5.37717268e-02f, -2.67407317e-02f,
  -1.00577489e-01f, -6.60752133e-02f, -2.71111038e-02f, -1.11911017e-02f, 1.23992134e-02f, 9.81293153e-04f, 4.10414450e-02f, -3.00606117e-02f, 6.33981079e-02f, 1.14185005e-01f,
  9.23950821e-02f, 1.68037206e-01f, 2.27258861e-01f, 6.90159872e-02f, 3.22999880e-02f, 1.49343982e-01f, 6.01947354e-03f, 1.96432471e-02f, -1.96679514e-02f, 3.36605251e-01f,
  1.08607531e-01f, 1.77023873e-01f, 4.97801490e-02f, 2.24558458e-01f, 1.39123291e-01f, -2.55137324e-01f, -3.42506647e-01f, -2.20557466e-01f, -7.29714781e-02f, 1.09354809e-01f,
  1.48473484e-02f, 5.74547052e-02f, 2.36249343e-02f, -7.45526180e-02f, -2.38578051e-01f, 2.70125847e-02f, 1.95657820e-01f, 1.16281332e-02f, -2.27823675e-01f, -1.96973443e-01f,
  4.79519963e-02f, 7.83920959e-02f, -1.42769709e-01f, -6.43604323e-02f, 2.56266832e-01f, 9.13380757e-02f, -6.76295115e-03f, 2.23878965e-01f, 2.11826414e-01f, 4.21661377e-01f,
  8.20953771e-02f, 1.09445229e-01f, -7.69251818e-03f, 8.64661932e-02f, 1.86004996e-01f, 6.41292781e-02f, -7.12309256e-02f, -4.44745086e-02f, 9.85885784e-02f, -1.70676149e-02f,
  2.05277115e-01f, -2.90084817e-02f, 3.12763117e-02f, -6.59742355e-02f, -1.13265418e-01f, -3.47279236e-02f, -5.31130098e-02f, -1.67594895e-01f, -1.53733090e-01f, 5.35581075e-03f,
  2.14022487e-01f, 1.30811170e-01f, -6.35416955e-02f, -1.97063029e-01f, 2.99578384e-02f, 4.86542610e-03f, 4.11428139e-03f, -5.99687966e-03f, -1.22895956e-01f, -3.78583849e-04f,
  3.39500755e-02f, 1.10237412e-01f, 6.09948358e-04f, 1.67027295e-01f, 3.87523361e-02f, -4.15727915e-03f, 1.23406865e-01f, 1.43917516e-01f, 3.33420672e-02f, 6.20593093e-02f,
  7.67066609e-03f, 6.10355996e-02f, 6.41021654e-02f, 9.24262926e-02f, 1.28182605e-01f, 9.11448374e-02f, 5.54018840e-02f, 6.19615726e-02f, 6.06225729e-02f, 4.27110419e-02f,
  -1.57533977e-02f, -1.62702464e-02f, 5.24141751e-02f, -4.52401191e-02f, 5.46314567e-02f, 2.81399954e-02f, 1.09559871e-01f, -3.50188017e-02f, 3.83459940e-03f, 1.38254315e-01f,
  -5.75761646e-02f, -1.96240157e-01f, 1.49376735e-01f, -7.19373152e-02f, 5.78926355e-02f, 2.97180060e-02f, 1.15866706e-01f, 8.74132961e-02f, 1.93818092e-01f, -7.78433904e-02f,
  1.48539230e-01f, 4.07671602e-03f, 2.19849721e-02f, -1.39160693e-01f, -1.24355294e-01f, 2.28324533e-02f, 3.75731140e-02f, -1.62601933e-01f, -1.89012140e-01f, 3.37548666e-02f,
  -9.74147543e-02f, -2.96750754e-01f, -1.94663331e-01f, -2.42534950e-01f, -3.49043706e-03f, 1.11939879e-02f, -1.16552599e-01f, -3.01152859e-02f, -1.60903186e-01f, -1.30841851e-01f,
  -2.81604975e-01f, 8.51830374e-03f, -6.71022758e-02f, 2.53154546e-01f, 7.84656480e-02f, -1.65914670e-01f, -3.51539820e-01f, -1.38357967e-01f, 1.57101765e-01f, -1.08645871e-01f,
  6.26313239e-02f, 1.85030863e-01f, 1.65125236e-01f, 2.05133315e-02f, -2.33420953e-01f, 1.84979977e-03f, 2.72745907e-01f, 1.77444331e-03f, -5.34071103e-02f, -1.05545714e-01f,
  1.74964741e-01f, 1.61574975e-01f, -5.50349243e-03f, 1.65301878e-02f, 2.24950895e-01f, 1.37392491e-01f, 4.40609008e-02f, 1.45217702e-01f, 1.31631881e-01f, 2.74815738e-01f,
  -1.75517216e-01f, -4.11543474e-02f, -9.83710289e-02f, 1.06145948e-01f, -7.24814013e-02f, 7.22019523e-02f, 2.66082939e-02f, 4.27620448e-02f, 3.73406932e-02f, -1.09519467e-01f,
  7.25931227e-02f, -5.14750145e-02f, 1.93656519e-01f, 3.54682691e-02f, -1.61989313e-02f, -1.85157850e-01f, -6.23069070e-02f, -2.45672446e-02f, -2.37346992e-01f, -1.03831127e-01f,
  1.91615224e-01f, 1.37034163e-01f, -5.39540201e-02f, -1.16597459e-01f, -2.64843047e-01f, -1.26730716e-02f, -2.16349155e-01f, -5.91654480e-02f, -3.17925155e-01f, -9.54258367e-02f,
  -1.08899670e-02f, -1.59281924e-01f, -4.39044721e-02f, 9.08664316e-02f, 1.93898678e-02f, -3.10777430e-03f, 5.50892763e-02f, 3.04951388e-02f, -2.32338011e-02f, -8.09870139e-02f,
  -5.63124120e-02f, -1.31499469e-01f, 1.58035941e-02f, -6.90624937e-02f, 2.58018263e-02f, 4.76465411e-02f, -1.63805962e-01f, -1.39666498e-01f, 5.23780845e-03f, -2.03547366e-02f,
  -7.41471257e-03f, -1.07893087e-01f, 1.14911877e-01f, -4.72473688e-02f, 4.93496694e-02f, -5.82672283e-02f, 6.24852488e-03f, -1.35421399e-02f, 1.87009219e-02f, 1.45087853e-01f,
  1.39445886e-01f, 8.80499706e-02f, -3.00613362e-02f, -1.24115720e-01f, -1.49295023e-02f, -5.41781820e-02f, -5.08148894e-02f, -3.86626944e-02f, -1.16076171e-01f, -1.85743764e-01f,
  -2.61513978e-01f, -1.82231098e-01f, 7.12784976e-02f, 2.31686328e-02f, 2.07036864e-02f, -9.45443138e-02f, -7.24067818e-03f, -1.41849682e-01f, -5.45193292e-02f, -1.31369710e-01f,
  1.58810057e-02f, -4.53702174e-02f, -1.86073735e-01f, -1.00171342e-01f, -9.08516720e-02f, -1.32836953e-01f, -6.01484179e-02f, -1.38819382e-01f, -2.01061815e-01f, -1.64305598e-01f,
  2.26356342e-01f, 3.15639004e-02f, 1.00684516e-01f, 8.05854648e-02f, 1.74016580e-02f, -1.19920589e-01f, -2.43758902e-01f, -3.62098180e-02f, 3.61589491e-02f, 1.59196630e-01f,
  2.35437393e-01f, 2.47680128e-01f, 6.56872392e-02f, 9.61175933e-02f, -9.33880731e-03f, -1.00606352e-01f, -4.14815284e-02f, 3.16466987e-02f, 7.40011483e-02f, 4.05779965e-02f,
  9.60152522e-02f, 7.18615875e-02f, 1.02702782e-01f, 1.00046524e-03f, 1.67193972e-02f, 5.93233146e-02f, -1.30236829e-02f, 4.12393622e-02f, 1.21483333e-01f, 1.18496463e-01f,
  4.14791673e-01f, 3.67006734e-02f, -3.02626938e-02f, 9.81207043e-02f, -4.11384925e-03f, 1.56746954e-02f, 4.88542989e-02f, 5.59046641e-02f, -5.72653301e-02f, -8.21014196e-02f,
  1.40215650e-01f, 4.76425812e-02f, -1.79804917e-02f, -9.04128887e-03f, 4.42186967e-02f, 9.47606787e-02f, 7.56244957e-02f, -5.29936329e-02f, -2.92127077e-02f, 1.21691406e-01f,
  9.52093229e-02f, 4.06705029e-02f, -5.28913811e-02f, -1.20172203e-01f, 6.29424676e-02f, 1.06502108e-01f, -1.32360402e-02f, 8.59799087e-02f, 8.31625238e-02f, 3.34898308e-02f,
  1.99366063e-01f, -5.44427857e-02f, -2.09332735e-04f, -2.01735063e-03f, -1.38371304e-01f, 2.14214697e-02f, 2.93675624e-02f, -8.69122297e-02f, 1.04454197e-02f, -6.65659681e-02f,
  5.40272938e-03f, -1.52064804e-02f, -7.10284561e-02f, 1.12626795e-02f, 7.90246204e-02f, 6.95830807e-02f, 6.58840463e-02f, -2.37422697e-02f, 1.01233542e-01f, 7.00892955e-02f,
  -7.35649746e-03f, -3.40187624e-02f, 7.25385174e-03f, 3.41363847e-02f, 9.40954313e-02f, 9.59908143e-02f, -1.56889688e-02f, -3.42097059e-02f, -3.04570552e-02f, 2.68348847e-02f,
  4.18315604e-02f, -6.89513311e-02f, 1.74969423e-03f, 4.27952036e-02f, 5.03838956e-02f, 6.71946108e-02f, 1.16790853e-01f, 4.54526171e-02f, 2.70024892e-02f, 3.43138948e-02f,
  5.84653299e-03f, 8.31180438e-02f, -8.40952620e-02f, -6.76405057e-02f, -1.54566109e-01f, 8.59589279e-02f, 6.80826232e-03f, 9.74655226e-02f, -2.85602380e-02f, 1.06739122e-02f,
  -8.37577332e-04f, -4.21354920e-02f, -5.31786457e-02f, -2.82890201e-02f, -1.15709260e-01f, -4.76978756e-02f, -9.35971588e-02f, -1.27130663e-02f, -1.00942485e-01f, -6.87760338e-02f,
  2.39434261e-02f, 1.49001196e-01f, 1.69985995e-01f, -2.32920386e-02f, -1.76124081e-01f, -2.07264796e-01f, -1.81022823e-01f, -2.22332478e-01f, -5.98906577e-02f, -4.25823778e-02f,
  -1.18559331e-01f, -1.19124837e-01f, 1.24598548e-01f, 9.19645131e-02f, 7.17581213e-02f, 2.68956244e-01f, 3.19319278e-01f, 1.89982921e-01f, 4.20189463e-03f, -9.28131491e-02f,
  1.48615660e-03f, 1.39424950e-01f, 7.87348226e-02f, 4.94430140e-02f, 1.45703837e-01f, -5.61076812e-02f, 1.64672464e-01f, 1.69781417e-01f, 4.19758186e-02f, 3.44537884e-01f,
  3.94451059e-02f, -2.48093624e-03f, -6.88959658e-02f, 1.16704646e-02f, -3.83403711e-02f, 4.63075051e-03f, -2.95412187e-02f, 2.02956080e-01f, -1.17273778e-01f, 3.47727351e-02f,
  -4.90775779e-02f, -8.30662157e-03f, -6.43729493e-02f, -4.02591489e-02f, -6.34544566e-02f, -1.12145230e-01f, 1.21964350e-01f, 1.81066021e-01f, 1.60146743e-01f, 1.03593962e-02f,
  4.45443057e-02f, -2.07087815e-01f, -1.40371993e-01f, -1.31033599e-01f, 4.81644925e-03f, -4.64629978e-02f, -2.70527340e-02f, -6.39057830e-02f, -1.13632247e-01f, 4.73437570e-02f,
  -8.66236463e-02f, -2.78536920e-02f, 5.03363051e-02f, 1.85090974e-01f, 8.42230469e-02f, -4.36436683e-02f, 1.38060404e-02f, 4.34419960e-02f, 6.83083236e-02f, -7.56234257e-03f,
  -7.73847327e-02f, 6.14863867e-03f, 1.16565265e-03f, -5.89534305e-02f, -2.98899952e-02f, 3.91757004e-02f, -1.07499743e-02f, 5.02428114e-02f, -5.74844703e-02f, -2.12289542e-02f,
  8.63941107e-03f, 9.46503878e-03f, -1.46058742e-02f, 6.61943406e-02f, 4.52445261e-02f, 2.93596145e-02f, 6.63759410e-02f, -1.88786276e-02f, 6.21039346e-02f, -2.37656273e-02f,
  -7.54904747e-02f, -5.42866997e-02f, 7.06665069e-02f, 4.31120023e-02f, -3.36683616e-02f, -8.44645500e-02f, 3.26979794e-02f, -1.00278988e-01f, -8.05661529e-02f, -4.28684354e-02f,
  -1.81983083e-01f, -4.73507866e-02f, -3.32983695e-02f, 5.84064424e-02f, -6.72033131e-02f, -1.42734116e-02f, -1.25729786e-02f, -2.89993696e-02f, -3.81975956e-02f, -2.67207325e-02f,
  -5.62324934e-02f, -2.15245456e-01f, -1.96420982e-01f, -9.78119597e-02f, -1.04190238e-01f, -1.72480375e-01f, -6.25552461e-02f, -1.93290859e-01f, -1.58209801e-01f, -7.85626620e-02f,
  2.73723572e-01f, -1.96864545e-01f, 1.11140870e-01f, 8.64304304e-02f, -6.87876120e-02f, 1.09149806e-01f, -3.31868008e-02f, 4.47762422e-02f, -6.53838068e-02f, -6.23637997e-02f,
  4.11387086e-02f, 1.23381928e-01f, 3.56732868e-02f, 1.14084475e-01f, 9.25908387e-02f, -1.65145174e-01f, -1.45473741e-02f, 7.49964416e-02f, 2.89423048e-01f, 2.98422347e-05f,
  -5.66540137e-02f, -1.78436548e-01f, 2.41866335e-02f, -3.96617502e-02f, -1.65001884e-01f, 2.18149256e-02f, -1.90154791e-01f, -1.91870674e-01f, -1.13331564e-01f, -3.98947477e-01f,
  -1.98335867e-04f, -4.49940376e-02f, 1.34359926e-01f, -2.00878605e-02f, 5.73254675e-02f, -2.44648587e-02f, 1.32312059e-01f, -9.31764245e-02f, -2.29969434e-02f, -7.96969011e-02f,
  7.69010261e-02f, -1.09290689e-01f, 6.11346541e-03f, -4.91357408e-03f, 2.42142696e-02f, 5.94132878e-02f, -1.06975749e-01f, -4.71603572e-02f, 1.48922130e-02f, -1.09400107e-02f,
  6.82256818e-02f, 5.22582270e-02f, -9.12172999e-03f, 1.92294996e-02f, 1.24764368e-01f, 7.18351305e-02f, -3.70350704e-02f, 2.24274825e-02f, 1.13384619e-01f, -3.03750895e-02f,
  1.56805769e-01f, 8.28372240e-02f, -8.34156200e-02f, 8.76547694e-02f, 1.13365993e-01f, -2.90050562e-02f, 2.59004496e-02f, 5.66332489e-02f, 9.53929424e-02f, -9.37208533e-03f,
  -1.08132936e-01f, -6.72132596e-02f, 8.38872865e-02f, 4.12524492e-02f, 1.42869875e-02f, -1.03274167e-01f, -9.99540314e-02f, 1.16550289e-02f, -5.58888987e-02f, -3.82017419e-02f,
  -1.53269365e-01f, -5.72864823e-02f, -1.24105010e-02f, -1.29908934e-01f, -1.21168057e-02f, -1.42357359e-02f, 1.14600156e-02f, 1.03574641e-01f, -6.65608793e-02f, -4.40636463e-02f,
  -6.83560744e-02f, 1.02452062e-01f, 6.72732992e-03f, -1.70085311e-01f, -1.15748033e-01f, -3.08771320e-02f, 2.49588285e-02f, -9.61682796e-02f, -2.01327801e-02f, -2.02182755e-02f,
  -9.51155871e-02f, -2.91909892e-02f, -3.05424780e-02f, -7.42728636e-02f, 9.61868539e-02f, 5.38414232e-02f, -4.09659222e-02f, 4.74061258e-02f, -6.76102191e-02f, -8.03336948e-02f,
  -7.04635829e-02f, -1.11818220e-02f, 2.21058249e-01f, 3.03308666e-02f, 5.15937842e-02f, 2.13961303e-01f, 1.14800125e-01f, -5.40937968e-02f, 5.04767373e-02f, 7.82571509e-02f,
  -3.69133241e-02f, -4.13636386e-01f, 2.39495739e-01f, 1.47305727e-01f, 2.18964100e-01f, 3.46035421e-01f, 3.20301145e-01f, 8.47354233e-02f, -1.78112194e-03f, -6.34680837e-02f,
  -2.77416527e-01f, -1.93096235e-01f, -2.53322899e-01f, -2.22102180e-01f, -1.89396411e-01f, 6.44254535e-02f, 1.60288557e-01f, 1.08969688e-01f, 2.73997575e-01f, 2.03172699e-01f,
  -7.11831003e-02f, -8.26275647e-02f, -1.48074254e-01f, 2.22770590e-03f, 6.83908025e-03f, -7.00797066e-02f, -1.11683933e-02f, 9.85550787e-03f, -2.07194030e-01f, -1.16462961e-01f,
  -1.39456345e-02f, 3.88788921e-03f, 1.87779404e-02f, -2.16370344e-01f, -5.83087467e-02f, -9.17893276e-02f, -1.77777447e-02f, -1.22097127e-01f, -1.42323626e-02f, 2.51824874e-02f,
  -1.87683515e-02f, -4.93230447e-02f, 4.69288118e-02f, -1.20789995e-02f, 8.40975344e-02f, -4.28342037e-02f, -1.54502586e-01f, -1.10186331e-01f, -1.56406835e-01f, -1.12917587e-01f,
  -6.93159401e-02f, 8.92216638e-02f, 1.44602790e-01f, 4.18626145e-02f, -2.40727849e-02f, -1.07729785e-01f, 8.87669344e-03f, 1.47792809e-02f, 5.32273715e-03f, -7.51187131e-02f,
  -1.03872165e-01f, -1.12614380e-02f, 2.81916056e-02f, -7.73953050e-02f, -3.90910264e-03f, 3.12829763e-02f, 2.68415660e-02f, 7.91900307e-02f, -5.13709709e-02f, 2.61491239e-02f,
  -6.62866533e-02f, 6.79808017e-03f, 7.23291263e-02f, 9.22714546e-03f, -7.96604082e-02f, 2.18126383e-02f, -1.35218175e-02f, -2.15897206e-02f, -1.52861372e-01f, 2.06898674e-02f,
  -3.78118753e-02f, 3.29504199e-02f, 1.75930914e-02f, -6.01774547e-03f, -1.50807008e-01f, 5.10809012e-03f, 4.49743308e-02f, -8.24968144e-02f, 1.97640099e-02f, 9.45441611e-03f,
  -8.97612870e-02f, -7.60140419e-02f, 9.15362388e-02f, 3.76530248e-03f, 1.32658586e-01f, -1.49679482e-01f, -6.39978871e-02f, -2.22043656e-02f, 7.32493177e-02f, 2.87678558e-02f,
  6.61624670e-02f, -2.52535883e-02f, 4.02098261e-02f, 1.71321575e-02f, 2.08825037e-01f, 1.52058914e-01f, -1.21298678e-01f, 1.08706243e-01f, -2.72819996e-02f, -4.27968651e-02f,
  -7.94150755e-02f, 6.10164888e-02f, 1.94552720e-01f, 9.73792598e-02f, -2.38344576e-02f, 2.04615951e-01f, 1.08843490e-01f, 9.21820328e-02f, 1.25514269e-01f, 1.81895316e-01f,
  -4.73379046e-01f, -6.23361059e-02f, 2.25435123e-01f, -1.49412632e-01f, -2.45997712e-01f, -3.73102784e-01f, -4.67148066e-01f, -2.91342646e-01f, -2.88069725e-01f, -2.06548512e-01f,
  -1.18177779e-01f, 1.05305776e-01f, 5.20482101e-02f, 2.83965375e-02f, -2.01114357e-01f, -3.37539285e-01f, -2.44244114e-01f, -8.44981819e-02f, -1.34667605e-01f, -2.32011154e-01f,
  -3.44050199e-01f, -3.14577281e-01f, -2.57769704e-01f, -1.05417825e-01f, -3.59857045e-02f, 1.29709527e-01f, 1.28755212e-01f, -7.60555416e-02f, -3.09150782e-03f, 7.88866580e-02f,
  3.62669170e-01f, 9.43065733e-02f, 3.64211574e-02f, -1.02106117e-01f, 1.08042940e-01f, -1.38175394e-03f, -4.46895100e-02f, 9.00634751e-02f, 2.64932346e-02f, 9.93491635e-02f,
  -6.67571127e-02f, -1.00236237e-01f, -6.23177029e-02f, -7.66134337e-02f, -1.68456972e-01f, -8.88435543e-02f, 5.38549852e-03f, 2.05216669e-02f, 4.74511683e-02f, 9.66545567e-02f,
  -5.84661886e-02f, -8.77689794e-02f, 3.41028571e-02f, 1.22306764e-01f, 1.36428848e-01f, 6.30632266e-02f, 3.12956810e-01f, 2.07444966e-01f, 2.66153753e-01f, 1.02223523e-01f,
  -2.13432480e-02f, 1.00102928e-02f, 3.52670476e-02f, -2.42596660e-02f, -3.75337414e-02f, -2.83317994e-02f, 4.56856415e-02f, -4.81087826e-02f, -8.88779387e-02f, -5.10787480e-02f,
  6.98038414e-02f, -1.45784337e-02f, 4.68739606e-02f, -2.22869962e-02f, 5.69071546e-02f, -4.40271609e-02f, -3.56735028e-02f, 7.77442232e-02f, 1.42934650e-01f, -5.17983697e-02f,
  -6.67464584e-02f, -7.14333206e-02f, -1.06475474e-02f, 7.71854147e-02f, 8.28692783e-03f, -3.17793782e-03f, 4.78566944e-04f, 3.28053720e-02f, 1.56831853e-02f, -5.74301630e-02f,
  2.32642919e-01f, 8.83624181e-02f, -3.38658281e-02f, 6.65993690e-02f, -3.25870588e-02f, 9.52603966e-02f, 1.98553473e-01f, 8.64128396e-02f, 6.86163828e-02f, 1.11508071e-02f,
  1.23829655e-01f, 5.31210937e-02f, 1.53348580e-01f, -7.64419138e-02f, -9.28578302e-02f, -2.08006967e-02f, -1.35279238e-01f, 8.58362950e-03f, 8.45800936e-02f, 5.18187024e-02f,
  -3.97508517e-02f, -1.50446326e-01f, 8.23788345e-02f, 2.15535954e-01f, 9.07211080e-02f, 1.23373354e-02f, 1.24042951e-01f, 1.11485377e-01f, 6.69928268e-02f, -4.47522663e-02f,
  -2.96817690e-01f, -8.19684118e-02f, -4.65289019e-02f, 1.89323485e-01f, 2.57364064e-01f, 3.21726501e-01f, 2.16326296e-01f, 1.08238801e-01f, 1.92459136e-01f, 3.21684964e-02f,
  -1.32366613e-01f, 4.96463403e-02f, 1.46287769e-01f, 6.54275417e-02f, 1.34703815e-01f, 2.73781091e-01f, 3.07586968e-01f, 3.78391370e-02f, 4.74655591e-02f, 1.46143660e-01f,
  1.74322173e-01f, -1.84270721e-02f, -1.51833624e-01f, 6.10793345e-02f, 4.95764390e-02f, 1.63463801e-01f, 1.44771695e-01f, 9.84383225e-02f, 3.88741717e-02f, 2.23939434e-01f,
  -6.60191774e-02f, -4.58890311e-02f, 3.09238676e-02f, -4.42837970e-03f, -9.24224332e-02f, -2.32270136e-01f, -5.28988428e-02f, -7.49444738e-02f, -9.22454074e-02f, 2.99668424e-02f,
  -1.90043561e-02f, -6.56733140e-02f, -2.47673038e-02f, -1.16955467e-01f, -2.32664030e-02f, -1.05986066e-01f, -1.62985250e-01f, 9.65928435e-02f, 1.07028987e-02f, 2.68578064e-02f,
  6.11664169e-02f, 6.38670102e-03f, 8.84223804e-02f, 7.09872926e-03f, 4.17293273e-02f, -3.37693132e-02f, -1.01512387e-01f, 3.78474221e-02f, -1.13663249e-01f, 6.86284825e-02f,
  1.70227125e-01f, -4.75529060e-02f, -7.93512464e-02f, 5.58896475e-02f, 3.63710523e-02f, -2.13996898e-02f, 1.44098833e-01f, 5.16803004e-02f, 1.43529981e-01f, -1.02414086e-01f,
  -2.73170099e-02f, 7.81874508e-02f, 6.84267050e-03f, -3.74494568e-02f, -1.21690758e-01f, 2.92133261e-02f, -4.26326059e-02f, -8.55971873e-02f, -9.22533348e-02f, -1.40805328e-02f,
  -1.14078522e-02f, 3.33304107e-02f, -2.25961089e-01f, 1.43381942e-03f, -8.52136388e-02f, 4.32783216e-02f, -1.38563409e-01f, -9.00501087e-02f, -1.42065629e-01f, 2.02861652e-02f,
  5.99453400e-04f, -3.72498743e-02f, 7.35516995e-02f, -4.18031625e-02f, 3.97724519e-03f, -1.27436921e-01f, 4.44016978e-02f, -2.99486108e-02f, 1.28220115e-02f, 7.79707730e-02f,
  2.41787620e-02f, -1.18337132e-01f, -2.99720056e-02f, -1.18406720e-01f, -2.56149340e-02f, -1.71635277e-03f, -2.78601367e-02f, 8.92785117e-02f, 9.30650719e-03f, -1.45375937e-01f,
  -2.03878433e-02f, 1.47381663e-01f, 1.48133323e-01f, 1.63443789e-01f, 1.53173760e-01f, 8.63386244e-02f, 1.53363338e-02f, 1.57802664e-02f, -6.55341893e-02f, -1.02316909e-01f,
  7.14847028e-01f, 4.03042018e-01f, 2.15670198e-01f, 5.34023158e-02f, 5.34646250e-02f, 4.88410965e-02f, 1.90340400e-01f, 2.45611653e-01f, -3.46169919e-02f, 8.84808004e-02f,
  -1.27173319e-01f, -2.04949036e-01f, -1.92354232e-01f, -2.01157466e-01f, 1.32827848e-01f, 1.85619071e-01f, 5.61890975e-02f, 1.55671477e-01f, 1.85294952e-02f, 1.60636532e-03f,
  1.82055514e-02f, 2.11791918e-01f, 2.12406471e-01f, 1.86753437e-01f, -3.34483832e-02f, -2.49072760e-02f, 1.58609375e-01f, 8.30254238e-03f, -1.75562091e-02f, -9.85383466e-02f,
  -2.25897461e-01f, 2.25376338e-01f, -1.51307702e-01f, -4.17415015e-02f, -8.41282159e-02f, -1.12743424e-02f, 2.19422225e-02f, 5.51709346e-02f, 2.46681925e-02f, -4.13728617e-02f,
  -6.72021434e-02f, -9.14613307e-02f, -5.54795004e-02f, -8.27469304e-03f, 2.52276212e-02f, 4.93586101e-02f, 6.72258288e-02f, -2.17392556e-02f, -8.69471133e-02f, -4.09751385e-02f,
  -2.09908441e-01f, 2.88362131e-02f, 9.92952008e-03f, -8.33172128e-02f, -6.48370236e-02f, -1.10326059e-01f, 4.50712293e-02f, 2.14358177e-02f, 4.33755182e-02f, 1.78958923e-01f,
  -1.41096145e-01f, -9.75233316e-02f, -1.39351249e-01f, -4.45198901e-02f, -6.27484333e-05f, 8.37803781e-02f, -1.15819335e-01f, -1.11859599e-02f, -8.68463423e-03f, 5.74677736e-02f,
  -8.54080170e-02f, -1.63769443e-02f, -1.29483089e-01f, -9.18395594e-02f, -6.06145263e-02f, 9.72264819e-03f, -2.27584299e-02f, -1.04907319e-01f, -1.43202573e-01f, -1.55087560e-01f,
  -3.13488543e-02f, -3.63047868e-02f, -8.26233253e-02f, -7.64221996e-02f, -3.06649245e-02f, -1.38109326e-01f, -1.35347366e-01f, -2.47288737e-02f, -3.18856388e-02f, 3.19235846e-02f,
  -4.16814178e-01f, -3.29144686e-01f, -9.81916860e-02f, 8.40549245e-02f, 4.20185365e-02f, 2.17941403e-02f, -3.87240387e-02f, -1.28905371e-01f, -4.38760146e-02f, -8.78159702e-02f,
  5.57738431e-02f, -4.24242504e-02f, -1.24812864e-01f, 6.20901622e-02f, -9.26969294e-03f, -7.03480979e-03f, -6.16486818e-02f, -6.72352612e-02f, -1.36188224e-01f, -6.17647804e-02f,
  -3.31354924e-02f, 7.33423382e-02f, 7.39080012e-02f, 5.10365367e-02f, 5.22889718e-02f, -1.22874036e-01f, -6.46535829e-02f, 1.01068597e-02f, 2.51478832e-02f, 2.46816963e-01f,
  -8.39307129e-01f, -2.13490888e-01f, 1.27786517e-01f, -8.94491971e-02f, 2.48663589e-01f, 1.98649332e-01f, 3.15311223e-01f, 1.80080116e-01f, -9.47288275e-02f, -4.40572836e-02f,
  -1.97640017e-01f, -1.50463894e-01f, -2.32499853e-01f, -1.44521100e-02f, -5.56742176e-02f, 3.32751215e-01f, 2.35763177e-01f, 4.14983789e-03f, 8.95633027e-02f, 1.17548026e-01f,
  1.91707149e-01f, -1.90208368e-02f, -3.04057866e-01f, -2.31051445e-01f, 3.46446447e-02f, -1.70518141e-02f, -3.24424654e-02f, 2.52527073e-02f, -1.00545466e-01f, 6.51471391e-02f,
  2.83544004e-01f, -3.08422387e-01f, -5.41867502e-03f, -2.59725153e-01f, -1.40958816e-01f, -2.36680046e-01f, -5.17086312e-02f, -2.30965465e-02f, -7.29131848e-02f, 1.15374357e-01f,
  -5.38566187e-02f, -4.92971353e-02f, -6.04530983e-02f, -5.45733087e-02f, 1.52105168e-01f, -5.76072112e-02f, -8.61967541e-03f, -7.13153929e-03f, -3.76658589e-02f, 4.75434586e-02f,
  2.13347562e-02f, 6.81864396e-02f, 1.65018216e-01f, -8.81177001e-03f, -2.89309658e-02f, -6.20707721e-02f, 2.76455469e-02f, 6.05785241e-03f, -2.74311891e-03f, 7.10866675e-02f,
  9.27375853e-02f, -4.96839285e-02f, -1.07222885e-01f, 3.64130326e-02f, -1.19372584e-01f, 5.81093552e-03f, 1.52994487e-02f, -2.60319840e-03f, 2.65269689e-02f, -5.50280511e-02f,
  9.14315432e-02f, 2.07137782e-03f, -4.93559940e-03f, 5.10163978e-02f, -2.21541692e-02f, 2.87945126e-03f, -4.58617806e-02f, -6.02480136e-02f, -6.32397160e-02f, -5.46708889e-02f,
  -2.67865229e-03f, 9.25606638e-02f, 3.24036777e-02f, 1.02787465e-01f, 9.82736871e-02f, -8.82793963e-02f, 4.63732183e-02f, -1.66322030e-02f, -1.15843475e-01f, -5.75048057e-03f,
  3.01645994e-01f, -1.50908068e-01f, -1.87740792e-02f, 2.03060638e-03f, -2.19041575e-02f, -8.22425187e-02f, -1.82138994e-01f, 3.02405450e-02f, 4.33427542e-02f, 1.41028926e-01f,
  -3.06491442e-02f, 2.50182841e-02f, -3.29979956e-02f, -2.77561918e-02f, 1.58989489e-01f, 3.78725529e-02f, -1.36930957e-01f, 6.84215575e-02f, 1.03740111e-01f, 1.57727841e-02f,
  7.68254921e-02f, 1.87357932e-01f, 2.62307018e-01f, 8.27617273e-02f, 7.51248822e-02f, 1.74127027e-01f, 1.34122550e-01f, 1.59000516e-01f, 1.02270797e-01f, 1.74425557e-01f,
  -2.62818903e-01f, -1.72408223e-01f, -9.54394117e-02f, -1.80974424e-01f, -1.57147825e-01f, -1.55050740e-01f, -2.15481102e-01f, 1.16355447e-02f, 5.11537194e-02f, -2.52380222e-01f,
  -5.94899096e-02f, 1.72337666e-01f, 1.07252948e-01f, 1.54993474e-01f, 1.94049597e-01f, -1.20019265e-01f, -3.04505348e-01f, -6.00624867e-02f, 2.37502426e-01f, 1.31304428e-01f,
  -3.89477611e-02f, -2.71454081e-02f, -1.58626065e-02f, 3.31639424e-02f, -4.99403067e-02f, 1.82986502e-02f, -9.30490345e-02f, -1.63828388e-01f, -5.75312674e-02f, -3.60018492e-01f,
  1.22152798e-01f, -1.67453498e-01f, -1.50620090e-02f, -9.93506983e-02f, -1.32339001e-01f, -1.29751429e-01f, -4.97238562e-02f, -9.14586782e-02f, -2.25319043e-02f, -2.52647363e-02f,
  -9.18951333e-02f, 5.10179028e-02f, 5.13127670e-02f, 9.39051881e-02f, -9.17236358e-02f, 8.90450627e-02f, 4.38569747e-02f, -1.06169507e-01f, -9.20647681e-02f, 6.53400794e-02f,
  -8.47141668e-02f, -8.67788494e-02f, -9.16505903e-02f, -6.44216910e-02f, -4.74404320e-02f, 1.03876926e-02f, 1.94756798e-02f, -5.03330417e-02f, -5.28781163e-03f, -1.37781635e-01f,
  2.24797837e-02f, 1.67061370e-02f, 5.91459824e-03f, -3.34571931e-03f, -4.24360931e-02f, 8.67581144e-02f, -5.60420379e-02f, 5.95742837e-02f, 8.60508438e-03f, 1.71636745e-01f,
  -6.13721870e-02f, -1.37388483e-01f, -2.23006643e-02f, -7.24006817e-02f, -1.45756915e-01f, 4.15153913e-02f, 3.16412896e-02f, -2.70293429e-02f, -6.23541996e-02f, -6.74130321e-02f,
  7.74720162e-02f, 9.96640548e-02f, -5.83970621e-02f, 5.43964282e-02f, -5.10877110e-02f, -2.25897059e-02f, 8.27023238e-02f, 6.54064640e-02f, 7.45956153e-02f, 3.90835665e-02f,
  1.59850642e-01f, -1.30389899e-01f, -4.17239964e-02f, -3.09265777e-02f, -9.05634165e-02f, -8.24496225e-02f, -1.32519647e-01f, 2.39309985e-02f, 4.45090570e-02f, 9.81446281e-02f,
  1.02322221e-01f, 1.19982794e-01f, -2.81766914e-02f, 1.21030964e-01f, 8.44067708e-02f, 9.41382162e-03f, 3.51796821e-02f, -5.53329401e-02f, -3.10204439e-02f, 2.88470816e-02f,
  5.45505285e-02f, 2.90737916e-02f, -1.08145056e-02f, 1.05799191e-01f, -2.37570684e-02f, -3.44181620e-02f, 1.66264936e-01f, 1.36020958e-01f, 7.59064034e-02f, 5.06121479e-02f,
  -3.47538263e-01f, 1.57314390e-01f, 7.94859827e-02f, -4.34956014e-01f, 7.44313896e-02f, 3.16279203e-01f, 3.25579643e-01f, 7.99900964e-02f, -1.25964329e-01f, -1.09005712e-01f,
  9.16620344e-02f, -8.42915997e-02f, -1.98394179e-01f, -1.51838779e-01f, -1.66544830e-03f, 3.28872614e-02f, -1.99981987e-01f, -2.47163117e-01f, -2.33692359e-02f, 6.27021026e-03f,
  -1.10942185e-01f, -3.11110467e-01f, -2.96901911e-01f, -1.65119782e-01f, -3.28611910e-01f, -2.05951273e-01f, -2.15136215e-01f, -1.88758343e-01f, 1.39182478e-01f, -2.77391344e-01f,
  -1.58596396e-01f, 2.60954112e-01f, 2.80210301e-02f, -4.27981094e-02f, 5.40589243e-02f, 4.48941672e-03f, 3.20499986e-02f, -6.77982643e-02f, 9.25004929e-02f, 9.98693630e-02f,
  3.96629795e-02f, 4.06982638e-02f, -2.24089846e-02f, -3.63617204e-02f, 5.50218895e-02f, -6.84534013e-03f, 9.04221311e-02f, 4.57929596e-02f, 1.17445812e-01f, 1.86588511e-01f,
  1.68792441e-01f, 1.48947179e-01f, 1.33786097e-01f, 2.00337097e-01f, 2.19926834e-01f, 9.50122923e-02f, 2.44225010e-01f, 1.19479783e-01f, 1.79743230e-01f, -5.84016778e-02f,
  -3.76156494e-02f, -5.13708442e-02f, -5.61173931e-02f, -6.68489933e-02f, 3.86190973e-02f, 3.23857442e-02f, -3.98336835e-02f, -4.20371853e-02f, 2.16398109e-02f, -1.51570603e-01f,
  1.43535852e-01f, -1.16135618e-02f, 2.38097701e-02f, -1.27191916e-01f, -3.18243057e-02f, 7.73365498e-02f, 4.03101742e-02f, 3.18443030e-03f, 5.03739044e-02f, 5.74484803e-02f,
  7.16849938e-02f, 7.60577768e-02f, -4.63604778e-02f, 2.32446380e-02f, 9.85373035e-02f, -6.78465217e-02f, 1.03985623e-01f, -2.68336870e-02f, -3.70399766e-02f, 1.17568806e-01f,
  -3.72139454e-01f, 7.52880424e-02f, -2.37254813e-01f, -1.60073657e-02f, 2.13648900e-02f, -4.03446630e-02f, 3.19551514e-03f, -6.25006780e-02f, -4.11904640e-02f, 7.06530437e-02f,
  1.87545404e-01f, -1.45214677e-01f, 8.35707039e-03f, 3.54246385e-02f, -7.79593959e-02f, 8.90277028e-02f, 1.22020217e-02f, -4.55165282e-02f, 5.69730438e-02f, 4.42396402e-02f,
  6.99271169e-03f, 1.64299551e-02f, -1.21062890e-01f, -8.20263773e-02f, -1.34697743e-02f, -4.22187895e-02f, -1.27312809e-01f, 2.23931242e-02f, 3.15618403e-02f, -2.06693709e-01f,
  -1.69448376e-01f, -9.16624516e-02f, -1.79912776e-01f, -3.77711505e-02f, 8.90390365e-04f, -6.79889172e-02f, -2.15847254e-01f, -1.72621123e-02f, 5.08602373e-02f, -9.79239568e-02f,
  1.16587253e-02f, 9.98887345e-02f, -8.58102813e-02f, -2.06648633e-01f, -3.48666340e-01f, -2.49726310e-01f, -2.90558636e-01f, -3.14632207e-01f, -6.38795868e-02f, 1.41279846e-01f,
  9.48289558e-02f, -6.55933619e-02f, -1.08931385e-01f, -6.35692701e-02f, 1.12914883e-01f, 1.01622894e-01f, -1.19065359e-01f, -1.75640900e-02f, -1.23135159e-02f, -8.51429626e-02f,
  -2.61503726e-01f, -2.64478903e-02f, -1.03385665e-01f, 5.04155904e-02f, 4.41761464e-02f, -1.55702028e-02f, 2.62621958e-02f, -7.36968666e-02f, 7.10434243e-02f, -6.13629967e-02f,
  9.39571857e-02f, 1.10968933e-01f, -3.82082537e-02f, 5.35386354e-02f, 5.40690161e-02f, -4.45664711e-02f, -1.07672602e-01f, -2.95797531e-02f, -4.18095924e-02f, -4.49454188e-02f,
  6.61855564e-02f, -8.84531960e-02f, -1.85311571e-01f, -4.47527096e-02f, -1.20625772e-01f, 9.74994991e-03f, 4.90695564e-03f, 9.60033685e-02f, 5.29227406e-03f, -1.38435317e-02f,
  1.98442582e-02f, 7.65252709e-02f, 4.02199328e-02f, 5.74766546e-02f, -7.37214386e-02f, 7.66061619e-02f, -2.99301185e-02f, -1.06870517e-01f, 7.98343420e-02f, 7.65234008e-02f,
  2.28184275e-02f, 6.38054833e-02f, 8.16686302e-02f, 2.96121370e-02f, -1.31842904e-02f, -4.48015742e-02f, -8.95534679e-02f, -2.04598024e-01f, -7.87209347e-02f, 1.65245794e-02f,
  2.51113065e-02f, 6.16573961e-03f, 6.34271055e-02f, 1.25324056e-02f, -7.11428225e-02f, -3.03205252e-02f, -1.73829775e-02f, 7.27647042e-04f, -1.04511976e-01f, -2.53484771e-02f,
  -1.31117001e-01f, -1.30732104e-01f, -2.72061508e-02f, 1.39580220e-02f, -7.06013106e-03f, 9.49957222e-02f, -1.17644630e-02f, -6.70396015e-02f, -2.74912883e-02f, -6.82234615e-02f,
  -5.15546724e-02f, -1.33929681e-02f, -5.81302913e-03f, 1.60257131e-01f, 2.70130746e-02f, -6.43537333e-03f, -8.52922127e-02f, -6.09448738e-02f, 1.48036117e-02f, 6.81484416e-02f,
  -4.03853357e-02f, -8.80230293e-02f, -2.36331925e-01f, -1.06218889e-01f, 5.49023077e-02f, -1.59564048e-01f, -7.66494572e-02f, -1.39286658e-02f, -1.67144820e-01f, -2.20693916e-01f,
  3.89572531e-01f, 2.68409044e-01f, -7.23569021e-02f, 6.37033135e-02f, -2.26348937e-01f, -3.29133540e-01f, -3.11363012e-01f, -8.32302794e-02f, 2.03352366e-02f, 9.13070291e-02f,
  -6.34133220e-02f, -4.25507920e-03f, -1.12787768e-01f, -9.36624929e-02f, -9.17131975e-02f, 1.13625415e-01f, 3.56719866e-02f, -1.65349677e-01f, -3.53804022e-01f, -2.36434385e-01f,
  -5.06252609e-02f, 2.33410131e-02f, 9.43818688e-02f, 5.48281893e-02f, 2.02229515e-01f, -3.28351520e-02f, -9.97727737e-02f, -1.22169971e-01f, -5.32272309e-02f, 2.93963820e-01f,
  1.08324446e-01f, 1.89764313e-02f, -1.56772241e-01f, 8.45634416e-02f, 5.12482896e-02f, 1.37989357e-01f, 8.24053809e-02f, 1.36471793e-01f, 8.39513913e-02f, 1.68248013e-01f,
  6.15656301e-02f, 1.27299219e-01f, 3.54837719e-03f, -1.68754905e-02f, -1.57631636e-02f, 4.00307104e-02f, 1.76603943e-02f, 6.60513043e-02f, -3.34202126e-02f, 6.66447654e-02f,
  4.75202501e-02f, -1.33209631e-01f, -2.17784807e-01f, -1.14336245e-01f, -4.63014543e-02f, -1.89002797e-01f, -1.01635635e-01f, -4.64239297e-03f, -2.52129912e-01f, 1.78623959e-01f,
  -8.74970034e-02f, -5.04444644e-04f, -8.73177722e-02f, -1.57060549e-01f, -6.38193637e-02f, 7.97028467e-02f, -4.78137061e-02f, -1.43449783e-01f, -1.42157465e-01f, -3.05480342e-02f,
  -3.18828113e-02f, -6.70295879e-02f, -9.13197175e-02f, -1.24429837e-02f, 6.08910015e-03f, -9.29057077e-02f, -7.73393437e-02f, -3.29325013e-02f, -9.97506678e-02f, 3.13632600e-02f,
  -2.51429118e-02f, -3.66745852e-02f, 1.26383349e-01f, -4.04691137e-03f, 4.20287214e-02f, -5.72835580e-02f, -3.40185054e-02f, -2.45512277e-03f, -4.04662006e-02f, 4.33990955e-02f,
  -5.67652695e-02f, -4.93266910e-01f, 1.48219362e-01f, 4.12108004e-02f, 8.55102167e-02f, 1.18969344e-01f, -2.47946195e-03f, -3.99178676e-02f, 1.14382483e-01f, 4.33827564e-02f,
  3.64174731e-02f, 1.54135391e-01f, 1.75253496e-01f, 7.85377845e-02f, 6.01792224e-02f, 6.66087493e-02f, 7.81640038e-02f, -7.90634602e-02f, 3.06426976e-02f, 1.10693678e-01f,
  1.26221865e-01f, 3.88992727e-02f, -1.59141496e-01f, -4.37301248e-02f, 7.21650794e-02f, -6.10274635e-02f, -4.16008309e-02f, 2.83793509e-02f, -1.61852956e-01f, 8.08919072e-02f,
  4.77847546e-01f, -2.91507572e-01f, -3.55403006e-01f, -1.82108637e-02f, -1.24747127e-01f, -1.53645128e-01f, -2.03662306e-01f, 7.22278878e-02f, 5.89651950e-02f, -3.41575354e-01f,
  -8.09739828e-02f, 1.69010699e-01f, 3.60655338e-02f, 2.23878641e-02f, 1.11920893e-01f, -3.26952070e-01f, -2.86670506e-01f, 1.16326667e-01f, 3.02921027e-01f, 1.61204189e-01f,
  2.74149068e-02f, 9.67957303e-02f, 6.77652583e-02f, 8.51113945e-02f, -3.39264691e-01f, -4.35324349e-02f, -3.09097677e-01f, -1.70997187e-01f, -1.92274600e-01f, -4.21293050e-01f,
  -4.00855005e-01f, -5.42372279e-03f, 7.49039650e-02f, 7.00566694e-02f, -2.26072501e-02f, 1.27869338e-01f, -3.67492959e-02f, 1.00191176e-01f, 1.48310274e-01f, 8.99974704e-02f,
  2.86219772e-02f, 1.43479626e-03f, 8.19932595e-02f, 6.12231269e-02f, 4.32535820e-02f, -3.94277796e-02f, 5.00925556e-02f, 1.67442173e-01f, 3.21926847e-02f, 8.65193456e-03f,
  -1.20592641e-03f, 6.65698647e-02f, 8.19857344e-02f, -1.86001603e-02f, 9.06181112e-02f, 7.03239888e-02f, -1.26566947e-01f, -6.76151291e-02f, -7.05536827e-03f, -1.63222447e-01f,
  -4.75834869e-02f, -4.10761014e-02f, -1.21407285e-01f, 6.25334159e-02f, 1.63832027e-02f, 1.02440845e-02f, -3.47994417e-02f, 3.70473750e-02f, -2.73464825e-02f, 4.54329252e-02f,
  2.85281111e-02f, -6.04468696e-02f, 5.64709119e-02f, -8.09037313e-02f, -1.44252688e-01f, -8.68701562e-02f, 6.30728975e-02f, -8.34684446e-02f, 1.24793351e-02f, -2.48863436e-02f,
  3.24136093e-02f, 1.04530221e-02f, -1.35017887e-01f, -1.02866650e-01f, -8.14349297e-03f, -1.09751880e-01f, -4.35877824e-04f, 1.78820454e-02f, 5.85790277e-02f, -4.35876139e-02f,
  1.23441964e-03f, 1.67664900e-01f, -5.83246257e-03f, -9.67113487e-03f, 6.62908703e-02f, 1.71614960e-02f, -5.44707105e-02f, -3.01121958e-02f, 6.51399046e-02f, -4.62741479e-02f,
  1.78138316e-02f, 5.39358743e-02f, -1.43335670e-01f, -5.17925341e-03f, 4.31290008e-02f, 1.13886939e-02f, -7.79670849e-02f, 2.92563513e-02f, -7.42531717e-02f, -2.11015597e-01f,
  -1.33866712e-01f, 1.11911125e-01f, 1.22909047e-01f, 7.22528845e-02f, 8.91060978e-02f, 8.16565603e-02f, -7.99459144e-02f, -6.82585016e-02f, 1.30842492e-01f, -3.43317874e-02f,
  1.23706669e-01f, -4.58834954e-02f, -8.30146205e-03f, 2.60595888e-01f, 1.55673191e-01f, 1.19712725e-01f, 1.83141217e-01f, 1.05149932e-01f, 1.61154509e-01f, 1.05606206e-01f,
  6.67754188e-02f, 1.54704764e-01f, 2.35514849e-01f, 9.96293947e-02f, 6.04895838e-02f, 2.19306603e-01f, 1.02922954e-01f, 1.06197767e-01f, 1.37954816e-01f, 6.10147938e-02f,
  1.89532354e-01f, 1.17831060e-03f, -2.71579195e-02f, 6.37355149e-02f, 1.34319067e-01f, 2.07735240e-01f, 2.69171596e-02f, -6.07987382e-02f, 2.05446202e-02f, 1.80236802e-01f,
  5.62418364e-02f, -1.14574851e-02f, 1.03507087e-01f, 9.48984623e-02f, -1.05751216e-01f, 4.51790029e-03f, 1.12361154e-02f, -1.03193983e-01f, -1.01703659e-01f, -1.07073069e-01f,
  -2.25503389e-02f, -1.57328486e-01f, -1.35354614e-02f, -1.36260629e-01f, -1.31115645e-01f, -1.37792364e-01f, -1.42590791e-01f, -4.68890108e-02f, 1.27733648e-01f, 2.78992653e-02f,
  9.52259749e-02f, -4.47330810e-02f, 1.43208411e-02f, 5.87789267e-02f, 2.07915138e-02f, 2.18477491e-02f, -9.41756144e-02f, -6.27652407e-02f, -8.46031308e-03f, -7.13775009e-02f,
  2.27321789e-01f, -2.20825803e-02f, 9.33517218e-02f, 3.53011675e-02f, 1.73506681e-02f, -1.26980683e-02f, 1.59907211e-02f, 2.70715374e-02f, -4.13686223e-02f, -1.11225560e-01f,
  -6.88108578e-02f, 1.18238896e-01f, 5.90648837e-02f, 2.18036193e-02f, 9.61908102e-02f, -8.85756835e-02f, -1.22400947e-01f, -1.64928939e-02f, -7.36095980e-02f, -7.91738257e-02f,
  -5.20291366e-02f, -3.90369934e-03f, -1.59556076e-01f, -1.50619475e-02f, 1.52852433e-02f, -4.94613722e-02f, 5.95792895e-03f, -1.01925462e-01f, -4.23726588e-02f, 1.50718307e-03f,
  2.43335851e-02f, -1.03850309e-02f, 1.26179680e-01f, 2.09840760e-02f, -4.78474014e-02f, -1.46631211e-01f, 6.40040860e-02f, -9.54539031e-02f, 4.64561060e-02f, 9.52383578e-02f,
  -1.19040973e-01f, -7.50556290e-02f, -7.23027438e-02f, -2.28080153e-02f, -1.33991197e-01f, -4.55458416e-03f, 5.41514307e-02f, 1.10426672e-01f, 1.79316346e-02f, -1.91753299e-03f,
  3.48516256e-02f, 2.55327560e-02f, 3.04700658e-02f, 1.33629024e-01f, 8.94854516e-02f, 1.74848199e-01f, 3.42200212e-02f, -3.35398130e-02f, -4.37774882e-02f, -7.83254802e-02f,
  4.07320678e-01f, -2.65581250e-01f, 2.65019745e-01f, 1.26804590e-01f, 8.61158371e-02f, 1.37998343e-01f, 1.32505015e-01f, 4.87952679e-02f, 6.77482635e-02f, 9.43661854e-02f,
  -8.82788971e-02f, -4.50752042e-02f, 1.10917322e-01f, 1.61664356e-02f, 9.60884914e-02f, 7.62435272e-02f, 1.36857763e-01f, 8.93092230e-02f, 1.39484122e-01f, 1.08779900e-01f,
  -1.35210291e-01f, -4.42270599e-02f, 4.88679931e-02f, 3.85664566e-03f, -1.44911319e-01f, 3.41874361e-02f, 6.78769350e-02f, -2.56319027e-02f, -1.69249251e-01f, -1.21019758e-01f,
  -2.42988169e-01f, -3.36798057e-02f, 1.47454470e-01f, -1.32298365e-01f, -1.09642997e-01f, -8.91851261e-02f, 5.16863093e-02f, -9.56783742e-02f, -1.28040969e-01f, -8.39617327e-02f,
  -4.51131389e-02f, -1.29076377e-01f, 7.61060230e-03f, -1.32441029e-01f, -6.68765744e-03f, 9.90043767e-03f, -1.16608046e-01f, -3.69042344e-02f, -4.84198891e-02f, -1.99914835e-02f,
  -4.15416546e-02f, -4.60720621e-02f, -2.06262991e-02f, -3.17494273e-02f, 2.21122671e-02f, -3.14879045e-03f, 6.34744987e-02f, -8.44967440e-02f, -5.11564612e-02f, 4.62415889e-02f,
  -1.00906044e-01f, 1.41128553e-02f, 9.49335620e-02f, 1.34121463e-01f, 7.96228871e-02f, 1.82667509e-01f, 3.42877991e-02f, 2.20399573e-02f, 4.54591252e-02f, -7.48224854e-02f,
  -1.11817140e-02f, -2.04101987e-02f, -8.48805439e-03f, 6.68452978e-02f, 3.02382912e-02f, 4.63119447e-02f, 1.90448074e-03f, -5.07060848e-02f, 5.85277267e-02f, 8.53402689e-02f,
  7.88125247e-02f, 1.07419781e-01f, -9.32682026e-03f, -4.74695861e-02f, -3.72920036e-02f, -2.33098529e-02f, -2.47072279e-02f, -1.09574944e-01f, -8.89872946e-03f, 7.35743940e-02f,
  -2.67960489e-01f, 2.38637954e-01f, 1.47376075e-01f, 6.99187145e-02f, 2.77724527e-02f, 4.74591739e-03f, 4.38998900e-02f, -1.87860832e-01f, -1.74792763e-02f, -5.36199957e-02f,
  -1.22613326e-01f, 1.00984402e-01f, 5.89633286e-02f, -8.51227492e-02f, 5.27568385e-02f, -5.99125996e-02f, -4.45419252e-02f, 1.49249569e-01f, -6.40827343e-02f, -1.74616009e-01f,
  2.03725882e-02f, 9.81023833e-02f, 3.89312021e-02f, 6.55447766e-02f, 6.59940466e-02f, 1.01202123e-01f, 8.80641788e-02f, 1.67901088e-02f, 1.39959320e-01f, 1.32542685e-01f,
  -4.49239016e-01f, 1.69334576e-01f, -2.61593908e-01f, -1.36599109e-01f, 1.56372875e-01f, 1.86476663e-01f, 2.35609263e-01f, 7.46829882e-02f, -4.60554846e-02f, 4.85650543e-03f,
  9.38779954e-03f, -6.44717664e-02f, 2.30800975e-02f, 7.73911551e-02f, 4.06283624e-02f, 2.84124464e-01f, 1.60241708e-01f, -6.93670660e-02f, -2.33469903e-01f, 1.67551916e-02f,
  1.66538924e-01f, -6.90629631e-02f, -3.62832814e-01f, -8.03119224e-03f, 9.23675746e-02f, -8.98244977e-02f, -9.10478383e-02f, -1.13632172e-01f, 1.37972578e-01f, 2.25992426e-01f,
  -2.71765351e-01f, -1.95029125e-01f, -8.07091296e-02f, -1.01196721e-01f, -1.67935878e-01f, -1.60170928e-01f, 3.03395558e-02f, -1.44648924e-01f, 1.26787394e-01f, -2.21403502e-03f,
  -1.97079871e-02f, 6.11867756e-02f, 6.98657557e-02f, -3.62712629e-02f, -2.38010108e-01f, -7.37245679e-02f, -1.04839064e-01f, -2.00449347e-01f, -1.71557441e-01f, -1.38069898e-01f,
  2.95639277e-01f, 6.00752160e-02f, -1.23858713e-01f, 7.03279376e-02f, -5.50580770e-02f, -1.89358458e-01f, -2.01239303e-01f, -1.20877251e-01f, -2.12473333e-01f, -1.68145880e-01f,
  5.59512749e-02f, -2.22859960e-02f, -5.13734529e-03f, 2.49230955e-02f, 2.28001294e-03f, 9.11101475e-02f, 7.13628381e-02f, 3.27116288e-02f, 1.32209495e-01f, -2.78411135e-02f,
  5.93903055e-03f, -6.42457008e-02f, -1.04369074e-01f, -7.57098421e-02f, -7.09534511e-02f, 3.97347100e-02f, 8.47242028e-02f, 3.81459519e-02f, -4.53198291e-02f, 4.52270061e-02f,
  -3.21318433e-02f, -4.48301621e-02f, -8.66317600e-02f, -4.70132045e-02f, 6.39848635e-02f, -1.46391764e-02f, -2.90258154e-02f, -6.38314858e-02f, -1.64806899e-02f, -1.36419043e-01f,
  -1.96670845e-01f, -7.91592970e-02f, -1.46362102e-02f, 2.15974767e-02f, 1.46077611e-02f, -5.27962968e-02f, -5.77004999e-02f, -4.31784503e-02f, 6.48364797e-02f, -1.20819658e-01f,
  -8.42620898e-03f, -5.41291572e-03f, 2.18756441e-02f, -1.37866233e-02f, -9.10775289e-02f, 8.06272682e-03f, 1.75813511e-01f, 8.24857429e-02f, 7.37580284e-02f, -8.80262852e-02f,
  1.48840204e-01f, 8.00475925e-02f, -1.76395759e-01f, -7.76381269e-02f, -8.70346054e-02f, -1.69378281e-01f, -1.81238912e-02f, -8.37645009e-02f, -1.62260041e-01f, -1.63449824e-01f,
  -5.07759929e-01f, 1.26358256e-01f, 2.67251074e-01f, -3.81743908e-01f, 1.77962050e-01f, 3.43825310e-01f, 4.14190322e-01f, 1.59255892e-01f, -3.28799009e-01f, -7.43093155e-03f,
  6.74586669e-02f, -2.26284444e-01f, -1.74203038e-01f, 4.15371731e-02f, 2.33901888e-01f, 1.46215379e-01f, 9.27387103e-02f, 5.88919073e-02f, 1.02041706e-01f, 1.32089347e-01f,
  -1.14368731e-02f, -2.32535750e-01f, -2.36762971e-01f, -2.24674582e-01f, -2.46221811e-01f, -2.03028977e-01f, -3.72050554e-02f, 2.18871776e-02f, 1.39717609e-01f, -1.19522981e-01f,
  1.33455426e-01f, 8.06680992e-02f, 1.11614332e-01f, -3.36080207e-03f, 4.71744686e-02f, -2.44390685e-02f, -9.12063867e-02f, -1.12219334e-01f, -7.60484487e-02f, -6.58545271e-02f,
  -1.48893461e-01f, 2.23436635e-02f, -6.61047995e-02f, 3.93160898e-03f, -1.03409387e-01f, -3.37584615e-02f, -3.59675032e-03f, 2.04993039e-02f, -8.61492679e-02f, 8.42406005e-02f,
  4.32632864e-03f, -3.91600654e-03f, 1.74705610e-01f, 1.10747814e-01f, 1.34789161e-02f, 3.58185247e-02f, 1.09272748e-01f, 2.53738253e-03f, 1.68286175e-01f, -2.56410062e-01f,
  -7.77793229e-02f, -2.79697590e-02f, 6.99396059e-02f, -1.97978429e-02f, -4.94060740e-02f, 8.53771418e-02f, 3.70831490e-02f, 2.28650160e-02f, 1.92768816e-02f, 5.26040308e-02f,
  -1.53199136e-02f, 6.65122569e-02f, 2.47699767e-02f, 6.43020794e-02f, -8.07431415e-02f, -4.52365912e-03f, -6.29166737e-02f, -1.17535777e-02f, -1.26843257e-02f, -2.23874729e-02f,
  1.60497427e-02f, 6.63483813e-02f, -8.62976089e-02f, 7.22690970e-02f, 1.01396181e-01f, -4.05223630e-02f, -5.87931089e-02f, 1.39341578e-01f, -6.06090873e-02f, 6.97237160e-03f,
  -1.49061278e-01f, 4.10649717e-01f, -1.93944827e-01f, 7.35606700e-02f, -5.68478294e-02f, 8.93674418e-02f, -7.17341667e-03f, 1.31976670e-02f, -7.49847516e-02f, -1.55797298e-03f,
  -4.15506363e-02f, -6.17356338e-02f, 5.22116683e-02f, 5.99295497e-02f, -1.73697378e-02f, 1.15832388e-02f, 6.67892471e-02f, 2.99552493e-02f, -1.60068050e-02f, -1.40276089e-01f,
  -3.50758880e-02f, -4.71851565e-02f, -1.03503048e-01f, 3.74787375e-02f, -7.61328787e-02f, -3.06910947e-02f, 8.99652392e-02f, 9.23953205e-03f, 9.68730897e-02f, -1.46873921e-01f,
  -3.40055794e-01f, -1.45381957e-01f, -3.19186568e-01f, 4.40198891e-02f, 6.34881631e-02f, 8.19635913e-02f, 1.93055928e-01f, 1.01641610e-01f, 1.40197292e-01f, -7.73958396e-03f,
  -2.38062348e-02f, 1.33217826e-01f, -3.84954438e-02f, 1.42533138e-01f, 5.72768413e-02f, 1.57299325e-01f, 1.33288726e-01f, 3.76766324e-02f, -2.33681034e-02f, 1.13668591e-01f,
  1.34235248e-01f, 1.18450876e-02f, -2.88224816e-01f, 5.47629669e-02f, 1.49513632e-01f, 8.11264440e-02f, -1.32720724e-01f, -1.68837197e-02f, 6.52422309e-02f, 1.85546815e-01f,
  -2.03263715e-01f, -1.67726859e-01f, 8.43116120e-02f, 8.38023499e-02f, -1.43602714e-01f, -7.40830153e-02f, -3.16783562e-02f, -1.15753852e-01f, 7.98023194e-02f, -1.19990684e-01f,
  -3.73395532e-02f, 4.32429053e-02f, 1.44056842e-01f, 5.28635979e-02f, -2.30607428e-02f, 2.40678433e-02f, -9.41490829e-02f, -4.03092913e-02f, -1.17190242e-01f, -2.80873775e-02f,
  1.40407547e-01f, 7.04178587e-02f, -1.63542017e-01f, 2.87005492e-02f, -4.68291193e-02f, 6.04053698e-02f, -1.05948299e-01f, 3.67754214e-02f, -1.08675532e-01f, 2.12557055e-03f,
  4.73092608e-02f, -3.71976644e-02f, 5.98890036e-02f, 1.41053190e-02f, -6.95947616e-04f, 1.02009535e-01f, 1.20783709e-01f, 8.96515101e-02f, 6.84452429e-02f, -1.02230057e-01f,
  2.18618345e-02f, 2.56951619e-02f, 6.58314377e-02f, -2.90416740e-02f, 6.09004833e-02f, -1.59327567e-01f, -7.40582356e-03f, -4.52536941e-02f, -1.14983432e-01f, -8.89355615e-02f,
  5.27515728e-03f, -3.60763893e-02f, 3.25337090e-02f, 1.44362658e-01f, -3.22512873e-02f, -2.48317420e-02f, 7.84959942e-02f, -1.89450011e-02f, 2.12667119e-02f, -2.10215077e-02f,
  -2.10513547e-01f, -1.70366123e-01f, -4.61221003e-04f, -5.89167997e-02f, -2.17260104e-02f, 1.88634060e-02f, -1.79573208e-01f, 1.84836350e-02f, -1.03480086e-01f, -3.37480828e-02f,
  -1.34981319e-01f, -8.63138884e-02f, -5.63458726e-02f, 2.59459652e-02f, -8.98577459e-03f, -1.63334049e-02f, 8.38967040e-02f, 4.30372618e-02f, 2.91690547e-02f, -9.13822874e-02f,
  -3.45583609e-03f, 2.16186251e-02f, -1.36589715e-02f, 8.27838853e-02f, -3.62771414e-02f, 2.11124755e-02f, -8.32724646e-02f, -7.02607725e-03f, -1.52655438e-01f, -1.40225038e-01f,
  9.55080315e-02f, -2.78840601e-01f, 3.07914913e-01f, 5.42932935e-02f, -3.82168472e-01f, -3.15508068e-01f, -3.14663917e-01f, -2.16591552e-01f, 1.45049556e-03f, -1.65712237e-01f,
  -1.51880756e-01f, 1.06644936e-01f, 1.22665115e-01f, 3.00922126e-01f, 2.76564270e-01f, 2.09087113e-04f, 3.03712487e-01f, 5.62245548e-01f, 4.43938941e-01f, -7.15429261e-02f,
  -1.62783384e-01f, 1.95337251e-01f, 3.69990021e-01f, 2.37819105e-01f, -1.77630596e-02f, -5.55287376e-02f, 1.83513701e-01f, 6.13641664e-02f, -5.90837710e-02f, 1.38870493e-01f,
  1.82692315e-02f, -1.07472107e-01f, 1.01784050e-01f, 7.32939839e-02f, 4.60204370e-02f, 6.38178438e-02f, 3.75576913e-02f, 7.71046579e-02f, -5.51417470e-02f, -9.21653733e-02f,
  1.46495933e-02f, -3.27160358e-02f, -1.81861401e-01f, -1.41085774e-01f, -2.88841818e-02f, -5.68271428e-02f, 5.36100306e-02f, 2.24020883e-01f, 1.28476977e-01f, 3.19691263e-02f,
  -1.08783446e-01f, -1.75672397e-01f, -1.65380314e-02f, -6.05914034e-02f, 7.07584023e-02f, -2.40305625e-02f, 6.52666995e-03f, -3.64367925e-02f, 7.71408305e-02f, -1.58877193e-03f,
  2.06531286e-02f, -7.38100484e-02f, 4.75360267e-02f, 8.96586478e-02f, 6.54506981e-02f, 2.34001949e-02f, 1.56854652e-03f, -3.67458276e-02f, 7.03689009e-02f, 5.08048981e-02f,
  4.44588065e-02f, 4.61265706e-02f, 5.92524558e-03f, -6.14565657e-03f, 5.48959933e-02f, -7.72331376e-03f, 1.61965173e-02f, 7.43491724e-02f, -4.96559171e-03f, 3.81607153e-02f,
  2.10469565e-03f, 3.46660838e-02f, 1.11721866e-02f, 1.41298041e-01f, -3.52776498e-02f, 7.68727064e-02f, -9.32438150e-02f, -2.76884586e-02f, -4.97810133e-02f, -1.47684682e-02f,
  -2.67034590e-01f, 4.45568119e-04f, -7.59023130e-02f, 4.63709906e-02f, -7.23487437e-02f, 1.93862058e-02f, -1.01309337e-01f, -3.18524949e-02f, -1.31266356e-01f, -8.93408507e-02f,
  -8.08185935e-02f, -1.53992353e-02f, -1.61832739e-02f, -2.66663544e-02f, -9.46510304e-03f, -2.71434840e-02f, -7.71716535e-02f, 1.10495143e-01f, 5.43801449e-02f, -1.23810463e-01f,
  1.39750987e-02f, -9.98047292e-02f, -2.67405827e-02f, -1.35695532e-01f, -2.16706201e-01f, -3.70598547e-02f, -4.29292619e-02f, -2.94036381e-02f, -7.13519529e-02f, -1.88850820e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  3.17152947e-01f, 1.84813470e-01f, 2.00037733e-01f, 1.14495188e-01f, 1.55062959e-01f, 1.39449582e-01f, 2.56638080e-01f, 4.54159528e-02f, 7.83058926e-02f, 2.22025201e-01f,
  -1.26990840e-01f, 1.04169019e-01f, 1.61651880e-01f, 1.50682822e-01f, 1.15827896e-01f, 4.31015529e-02f, 2.02655450e-01f, 2.23792672e-01f, 7.18007088e-02f, 1.58549860e-01f,
  1.13694422e-01f, -1.38836697e-01f, 1.12796903e-01f, -1.32314637e-01f, 2.26332605e-01f, 2.10123405e-01f, -1.46836955e-02f, 2.48437688e-01f, 1.35520294e-01f, 1.35564581e-01f,
  1.50617436e-01f, 1.90024391e-01f, 1.47139072e-01f, 7.11470470e-02f, 9.69995558e-02f, 2.85431445e-01f, 5.30688912e-02f, 4.25765216e-01f, 1.80331070e-03f, 3.79090428e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.14838205e-01f, -5.49380034e-02f, -9.53488648e-02f, -1.87578171e-01f, 3.75833362e-02f, -5.30148344e-03f, 3.45143937e-02f, -7.25469738e-02f, -2.64122397e-01f, -4.65434194e-02f,
  -8.38699266e-02f, -5.48308827e-02f, -3.36524338e-01f, -2.92908996e-01f, -1.09373637e-01f, 1.83535770e-01f, -4.09107208e-02f, -2.30993345e-01f, 7.97459632e-02f, -6.70590550e-02f,
  5.35218045e-02f, -5.41143864e-02f, -7.63973817e-02f, 7.45239034e-02f, -2.18113795e-01f, 1.64420038e-01f, -1.98823616e-01f, -1.35987680e-02f, 9.09137428e-02f, -6.48416653e-02f,
  2.90001094e-01f, 1.27935717e-02f, 1.61607087e-01f, -1.43519640e-01f, -1.45030515e-02f, 8.11822936e-02f, -1.87302679e-01f, 1.45998418e-01f, 1.56064615e-01f, 2.97476016e-02f,
  -1.80797771e-01f, -1.40129495e-02f, 5.08747958e-02f, 1.33829579e-01f, 4.95802611e-02f, 1.92547068e-01f, -7.75216669e-02f, 4.65074182e-02f, 2.22933397e-01f, -8.57011974e-02f,
  4.35028896e-02f, 2.16017157e-01f, 2.86972642e-01f, -5.71366064e-02f, 7.69759864e-02f, -6.17079437e-02f, 1.52928218e-01f, -3.29447538e-01f, -1.21844128e-01f, -6.40811697e-02f,
  1.60519674e-01f, 1.00930505e-01f, -8.86196084e-03f, -1.62576631e-01f, 5.27397543e-02f, -2.12943442e-02f, 1.09241307e-02f, -1.48369838e-02f, 4.36988920e-02f, -1.10914029e-01f,
  -8.13660696e-02f, 1.28876623e-02f, -1.05176792e-01f, 5.46155237e-02f, 1.63497120e-01f, 7.53922621e-03f, 2.75360607e-02f, 8.19180757e-02f, -3.66454795e-02f, -1.21488817e-01f,
  3.74427475e-02f, 4.14508805e-02f, 4.41929027e-02f, 1.80274606e-01f, -1.54595613e-01f, -8.98106247e-02f, -7.87008405e-02f, -2.71712467e-02f, -8.69692340e-02f, -1.42044440e-01f,
  2.66256213e-01f, -1.07260309e-01f, -3.67511027e-02f, 1.78880751e-01f, -1.08450413e-01f, -8.72330368e-02f, 5.52918836e-02f, 2.30086654e-01f, -1.45033211e-01f, 7.41071478e-02f,
  -1.01717286e-01f, -3.96213084e-02f, 1.05675980e-01f, 1.76496521e-01f, 1.02147460e-01f, 1.71383079e-02f, 2.37830669e-01f, -1.31291421e-02f, 2.41969023e-02f, 7.45904893e-02f,
  -1.44695640e-01f, -5.90291061e-02f, -1.41972870e-01f, -7.42946938e-02f, -7.76893124e-02f, -6.55157417e-02f, -1.48380399e-01f, 1.03590459e-01f, -1.41466483e-01f, -8.75890255e-03f,
  -3.73837352e-02f, 2.13795453e-01f, 1.78575799e-01f, -8.91637653e-02f, -1.36892289e-01f, -2.35063165e-01f, -9.88145173e-02f, -2.20135599e-01f, -2.64652912e-02f, 7.77305439e-02f,
  4.72440235e-02f, 2.46924516e-02f, 2.02628329e-01f, 9.89533588e-02f, -1.07140437e-01f, 7.16223121e-02f, 1.04454808e-01f, 2.82611102e-02f, -9.91827622e-02f, 4.09171805e-02f,
  6.03342950e-02f, 5.29357828e-02f, 2.94269458e-03f, -1.76235735e-02f, -2.74628773e-02f, 1.17155164e-01f, 7.45472237e-02f, 4.44925986e-02f, 5.12044132e-02f, 1.11925103e-01f,
  -2.12988742e-02f, 7.54387528e-02f, 1.53875247e-01f, -1.54855371e-01f, -1.93908185e-01f, -4.28578407e-02f, -4.93261665e-02f, -1.57898039e-01f, 1.51818290e-01f, 5.86033948e-02f,
  -1.27701536e-01f, -1.00904694e-02f, -1.15799218e-01f, -9.17553753e-02f, 9.41751823e-02f, 1.74122095e-01f, -1.12660460e-01f, -5.71506992e-02f, 1.66369468e-01f, -1.09772366e-02f,
  -1.30650908e-01f, 1.81396022e-01f, 1.08812384e-01f, 8.22657496e-02f, -4.15730253e-02f, -9.45029184e-02f, -2.68390775e-02f, 3.57778408e-02f, -5.67824170e-02f, -9.44683179e-02f,
  4.59025204e-02f, 2.75936015e-02f, -1.35159135e-01f, 7.32549131e-02f, 1.79850012e-02f, -2.80736953e-01f, -1.79544106e-01f, -1.12816520e-01f, -2.44782850e-01f, -9.71349850e-02f,
  -9.54025388e-02f, 3.10145646e-01f, -5.93925221e-03f, -2.47519091e-02f, 8.31263065e-02f, 6.18935525e-02f, -1.81760192e-01f, -2.92969346e-02f, 6.67408556e-02f, 1.09217636e-01f,
  3.50135155e-02f, 3.12314499e-02f, 1.04307264e-01f, -1.59465522e-02f, -4.01988328e-02f, 1.24856830e-02f, -3.12913895e-01f, 4.49903496e-02f, 2.62736231e-01f, 1.10990964e-01f,
  2.41901074e-02f, 1.59139633e-01f, -9.33852643e-02f, 1.03686348e-01f, 1.78120032e-01f, 1.37809590e-02f, -1.59058809e-01f, 1.09844469e-02f, 1.56039208e-01f, 1.46099301e-02f,
  -2.17795670e-02f, -2.50122808e-02f, 6.55010864e-02f, 6.66780025e-02f, 1.83088824e-01f, 5.50747570e-03f, 1.20594315e-01f, 6.80558160e-02f, -2.55821854e-01f, -2.28560388e-01f,
  8.18859711e-02f, -2.02011243e-01f, -2.86345810e-01f, 1.61713094e-01f, 1.15153551e-01f, -9.24230739e-02f, -8.23685750e-02f, 3.87560506e-03f, 9.48088393e-02f, 7.49036819e-02f,
  8.65058377e-02f, -1.11066408e-01f, 3.74006629e-02f, 1.01967789e-01f, -1.38074458e-01f, -2.06101194e-01f, 8.74959528e-02f, -1.34686530e-01f, 5.14200889e-02f, 1.58209383e-01f,
  8.90342295e-02f, 8.66568610e-02f, -1.14122644e-01f, -3.73810157e-02f, -1.34526253e-01f, 1.15672991e-01f, -1.38118804e-01f, 4.42561358e-02f, -3.46230231e-02f, 1.85662657e-02f,
  -1.26735628e-01f, -2.21203297e-01f, 4.45941314e-02f, -1.52723446e-01f, -7.47099519e-02f, -1.92565575e-01f, -4.07141894e-02f, 5.60470037e-02f, -2.55090594e-02f, -5.78071289e-02f,
  -2.31878817e-01f, 5.30974306e-02f, 6.94162622e-02f, 3.33201811e-02f, 5.22166267e-02f, 2.00588793e-01f, 2.27549616e-02f, 1.06957875e-01f, 6.24831654e-02f, -8.96213800e-02f,
  -2.71739244e-01f, -4.42104787e-02f, -8.78215060e-02f, 8.22610036e-02f, -8.28972384e-02f, 2.06017494e-01f, 2.03249574e-01f, 1.17494464e-01f, -2.66570151e-02f, -1.11830018e-01f,
  8.75744000e-02f, 7.55839497e-02f, -1.67691395e-01f, -6.83295056e-02f, 7.05192313e-02f, -1.24637663e-01f, -6.56172559e-02f, 1.16520151e-01f, 2.34381244e-01f, 1.10880591e-01f,
  -1.87545437e-02f, 1.42433792e-01f, 1.24950930e-01f, -1.28189726e-02f, 6.31992519e-03f, -8.81446674e-02f, 1.45986423e-01f, 1.30781040e-01f, -5.10382541e-02f, -1.05033085e-01f,
  -1.13327555e-01f, -5.65792024e-02f, 1.67799383e-01f, 1.07011357e-02f, 8.30361843e-02f, 5.82369640e-02f, -9.85149518e-02f, -2.64251471e-01f, 7.02159777e-02f, -5.07835485e-02f,
  8.54015946e-02f, -1.06974691e-01f, 1.53509004e-03f, -2.82598697e-02f, -3.32238413e-02f, 1.23376045e-02f, -1.17796026e-01f, -8.52796510e-02f, -6.89867232e-03f, -4.17357311e-02f,
  3.29558206e-05f, -1.04375094e-01f, 1.45842820e-01f, -2.66470835e-02f, -1.09161384e-01f, -1.82575285e-01f, 1.32808268e-01f, 2.78709251e-02f, 5.93451969e-02f, -3.82777415e-02f,
  7.40870759e-02f, 1.47247612e-01f, -9.92361382e-02f, -7.67460689e-02f, -9.37944278e-02f, 1.10912457e-01f, 5.81466146e-02f, 9.20966342e-02f, 1.00388773e-01f, 1.25436723e-01f,
  -2.11691275e-01f, -7.34319836e-02f, -8.44387487e-02f, -2.60199420e-02f, 2.20502098e-03f, 1.36867687e-01f, 1.51239097e-01f, -1.02038998e-02f, 1.12307400e-01f, -1.22009441e-02f,
  -4.97081354e-02f, -5.61336800e-02f, 2.69747730e-02f, -2.53854692e-01f, -1.21383637e-01f, -7.12377205e-02f, -8.84331986e-02f, 8.39801133e-02f, 1.40991118e-02f, -9.59266499e-02f,
  6.99381903e-02f, -2.29425933e-02f, -7.73046985e-02f, 5.62209524e-02f, 2.47632802e-01f, -5.84461121e-03f, -1.73489064e-01f, 1.67625114e-01f, -7.71567374e-02f, 6.45114481e-02f,
  5.39905019e-02f, 4.73546647e-02f, -2.04203781e-02f, -3.64038628e-03f, 1.38799608e-01f, -6.24834932e-02f, 9.73201767e-02f, 4.07810360e-02f, 3.81724834e-02f, 9.34856012e-02f,
  -1.45395368e-01f, 8.99848118e-02f, 2.52009537e-02f, 1.49023086e-01f, 1.09878421e-01f, 2.70364657e-02f, 1.54660344e-01f, 9.20116305e-02f, 1.71905398e-01f, -1.08628748e-02f,
  2.02208143e-02f, -5.33690229e-02f, -1.41387582e-01f, -1.48990631e-01f, 2.12021187e-01f, -5.09845875e-02f, 1.35200009e-01f, 6.91543967e-02f, 1.04501784e-01f, -1.47283614e-01f,
  1.59713030e-01f, -1.07241988e-01f, 7.45732039e-02f, 4.49286699e-02f, 9.96953622e-03f, -1.02599286e-01f, 1.77228585e-01f, 6.43876120e-02f, -4.42183204e-02f, 1.68602645e-01f,
  1.71524242e-01f, 1.23492973e-02f, 1.54527083e-01f, 2.54641231e-02f, -4.73929346e-02f, -4.16929089e-02f, 3.09917089e-02f, -2.69075215e-01f, -3.45290862e-02f, -1.10237584e-01f,
  -1.63048655e-01f, 6.49883226e-03f, -1.55550256e-01f, 8.88777524e-02f, 1.07201897e-01f, 3.64540890e-02f, -1.63289264e-01f, 2.26621613e-01f, 6.03809208e-02f, 4.40309942e-02f,
  -2.31205776e-01f, 1.90004542e-01f, -9.48738456e-02f, 9.12598297e-02f, -1.36719659e-01f, 1.54865354e-01f, -1.34461567e-01f, 3.09210047e-02f, -2.41539674e-03f, 3.66562381e-02f,
  -3.30683216e-02f, 6.65507093e-02f, 5.84120750e-02f, 2.22677335e-01f, -3.66846751e-03f, 5.19905277e-02f, -1.09925032e-01f, 1.14757322e-01f, -8.35309923e-02f, -5.30062616e-02f,
  -2.26387996e-02f, -5.62588274e-02f, -1.45049959e-01f, 7.59961503e-03f, 6.06554337e-02f, -3.04304380e-02f, -1.49668902e-01f, -1.33253351e-01f, 2.06178442e-01f, 3.66697982e-02f,
  -3.37902792e-02f, 8.03647041e-02f, -4.78534736e-02f, -6.11234643e-02f, -1.78868175e-01f, 2.03487590e-01f, -8.13827887e-02f, -2.13376671e-01f, 2.35822890e-02f, -3.67752984e-02f,
  6.98409155e-02f, -1.94545165e-01f, 1.47945806e-02f, 1.10050905e-02f, 6.05627634e-02f, -1.36914445e-04f, 9.38546583e-02f, -1.64303202e-02f, -2.55724251e-01f, 7.14592785e-02f,
  -5.55789322e-02f, -1.67912751e-01f, -2.68773019e-01f, 1.14790775e-01f, 3.60835828e-02f, -8.97453353e-02f, -1.02328680e-01f, 2.69019380e-02f, -4.74107899e-02f, 1.04297891e-01f,
  6.38662577e-02f, -1.21787451e-01f, 1.80963024e-01f, 3.78414169e-02f, 1.75868217e-02f, -2.05400348e-01f, -7.72768408e-02f, 2.92271338e-02f, 1.09635048e-01f, 2.32707247e-01f,
  6.41194582e-02f, 7.51472265e-02f, 1.37527868e-01f, -8.33070800e-02f, 6.71783462e-02f, 1.51702594e-02f, -1.46717131e-01f, -3.34511418e-03f, -1.01135798e-01f, 9.58090946e-02f,
  -1.09246820e-01f, 5.36513403e-02f, -2.25598440e-02f, -2.73131765e-02f, 2.11872786e-01f, 1.17604561e-01f, 1.93394553e-02f, -1.68592378e-03f, -8.80561862e-03f, 3.89337242e-02f,
  -2.13172197e-01f, -3.90296802e-02f, 1.13073297e-01f, 1.74461044e-02f, 2.18678042e-01f, 2.22533140e-02f, 1.30085409e-01f, -2.25203872e-01f, 1.38534948e-01f, -1.34559087e-02f,
  -1.95782602e-01f, 4.35143709e-02f, -1.93062142e-01f, 1.07332304e-01f, 1.10386923e-01f, -4.64638621e-02f, 5.83242588e-02f, 1.19645983e-01f, 1.77787066e-01f, 5.77431135e-02f,
  -6.27341941e-02f, 1.85903057e-01f, -1.13840558e-01f, -1.03710229e-02f, -7.57759884e-02f, -2.12412626e-01f, -1.99702963e-01f, 6.23005554e-02f, -2.38907397e-01f, 3.13333273e-02f,
  5.94118163e-02f, -5.13287336e-02f, -4.79393639e-02f, -1.27989024e-01f, -1.60614148e-01f, 1.39501736e-01f, 1.26936734e-01f, 6.30930823e-04f, -1.60312310e-01f, -1.54693099e-02f,
  9.66766477e-02f, -7.79477227e-03f, -7.32979178e-02f, 6.22038767e-02f, 1.96852498e-02f, 4.36896943e-02f, -7.26954341e-02f, 8.72382075e-02f, 9.98870656e-02f, 7.65712038e-02f,
  1.56550005e-01f, 4.71631531e-03f, -1.56426460e-01f, 1.96719244e-02f, 5.55280922e-03f, 7.84973279e-02f, 5.41529618e-03f, 8.94853696e-02f, -1.30924731e-01f, -1.50070712e-01f,
  4.35068831e-02f, -3.70712653e-02f, -7.06343427e-02f, 1.17326051e-01f, 5.88360569e-03f, -1.57235295e-01f, 3.82074453e-02f, -1.48964047e-01f, -9.40552633e-03f, 5.72895631e-02f,
  -2.78961122e-01f, -1.75382674e-01f, 4.80652377e-02f, 1.54831707e-01f, -1.96172848e-01f, 6.70551062e-02f, 5.46781719e-02f, -1.37269706e-01f, 1.65630862e-01f, 6.82292655e-02f,
  -1.60707280e-01f, 8.93083885e-02f, 1.30372703e-01f, 1.86510235e-01f, 1.39344469e-01f, 2.36010745e-01f, 1.25086308e-01f, -1.11825444e-01f, 1.07128926e-01f, 1.95836276e-01f,
  1.05830617e-01f, -2.04897020e-02f, 1.06205553e-01f, -7.11968169e-02f, -1.71352804e-01f, -6.92015141e-02f, -9.04524401e-02f, 9.16704834e-02f, -2.48248711e-01f, 3.98823060e-02f,
  1.30770162e-01f, 2.44060591e-01f, 4.26942408e-02f, 1.61496252e-01f, -8.96261074e-03f, -7.26003274e-02f, 6.66576847e-02f, -2.62585818e-03f, 6.04205728e-02f, -2.10559726e-01f,
  1.59662589e-01f, 8.37921724e-02f, -5.21138534e-02f, 5.20879924e-02f, 3.85621525e-02f, -3.98001075e-02f, 7.40322992e-02f, 1.87157243e-01f, 1.69585515e-02f, 4.13778014e-02f,
  2.58423954e-01f, 9.31336954e-02f, 1.76825419e-01f, 1.63709566e-01f, -5.42501211e-02f, -1.22923158e-01f, 1.11763418e-01f, -3.97192091e-02f, 6.12424165e-02f, 3.38100940e-02f,
  -9.27414279e-03f, 9.67946723e-02f, 6.72232872e-03f, -1.07368313e-01f, -1.23697922e-01f, 2.57898003e-01f, 6.80868095e-03f, -1.31220356e-01f, 1.13096513e-01f, -3.27973114e-03f,
  3.14120859e-01f, -8.85512456e-02f, -1.26171455e-01f, 8.21822137e-03f, -1.75017223e-01f, -5.76759083e-03f, -6.40666336e-02f, -1.03938483e-01f, 1.94370449e-02f, -9.54419747e-02f,
  -2.02196345e-01f, 2.11991984e-02f, 2.46281810e-02f, -2.32281372e-01f, -2.42379252e-02f, -9.05821845e-02f, 1.33133546e-01f, -4.49590981e-02f, 1.08411103e-01f, -7.61746839e-02f,
  -7.79947862e-02f, 4.37295176e-02f, -3.54099199e-02f, 3.56269255e-02f, -1.28689826e-01f, -1.51996061e-01f, -2.04831362e-02f, -1.23497076e-01f, -5.96754365e-02f, 1.41058505e-01f,
  -2.87887573e-01f, -1.94889680e-01f, -8.60622153e-02f, 2.65047073e-01f, -4.69000312e-03f, -1.60664711e-02f, 8.41544475e-03f, -4.07982245e-03f, 1.81509912e-01f, 1.73607454e-01f,
  7.79128969e-02f, 2.56571956e-02f, -3.52226309e-02f, -7.32941087e-04f, -2.52454337e-02f, 2.82258242e-02f, -8.75714570e-02f, 5.62226214e-02f, 1.50809079e-01f, 1.60236340e-02f,
  -5.89249879e-02f, -5.38921952e-02f, 5.11805862e-02f, 5.76833114e-02f, -1.16455205e-01f, 2.52336897e-02f, 7.04318061e-02f, -1.28808022e-01f, -1.46651864e-01f, -1.30925462e-01f,
  -4.62451912e-02f, 1.24966979e-01f, 1.16107412e-01f, -2.37852514e-01f, 7.00083561e-03f, 8.90999138e-02f, 1.88456759e-01f, -7.32236682e-03f, 6.58234805e-02f, -1.42436117e-01f,
  -8.01228285e-02f, 4.96360213e-02f, 1.71279144e-02f, -8.49160105e-02f, 2.60946840e-01f, 1.27820730e-01f, -1.47906080e-01f, 2.97427066e-02f, 9.03438330e-02f, -3.45774228e-04f,
  4.35070582e-02f, 2.32551694e-02f, 1.50505096e-01f, -1.57081038e-01f, 1.39649352e-02f, -2.56894138e-02f, 1.92169398e-02f, -4.81855646e-02f, -1.14512891e-01f, -7.73179531e-02f,
  -3.64343524e-02f, -1.48028716e-01f, 6.58735335e-02f, 7.30534196e-02f, 1.12021744e-01f, -6.74702749e-02f, 2.82260347e-02f, -1.34507697e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.32367224e-01f, 1.21366285e-01f, 1.22754611e-01f, 1.12288460e-01f, 2.27014899e-01f, 7.25348368e-02f, 1.82785466e-01f, 2.51236051e-01f, 9.16116759e-02f, 4.29406762e-02f,
  1.82517081e-01f, 5.61780296e-02f, 2.55312860e-01f, 1.24974832e-01f, -1.68714635e-02f, -1.19690038e-01f, 8.00869241e-03f, 1.21658936e-01f, -1.21038094e-01f, 2.21019417e-01f,
  -6.96832538e-02f, 8.34962279e-02f, -9.94398519e-02f, -4.89890995e-03f, 1.96761876e-01f, 2.27718979e-01f, 7.50918388e-02f, -2.02789918e-01f, 3.44036110e-02f, 1.95268184e-01f,
  1.52549312e-01f, -8.53184909e-02f, 8.31578523e-02f, 2.14092761e-01f, -6.48324704e-03f, -1.02027832e-03f, -5.25508225e-02f, -1.86232582e-01f, -9.21800137e-02f, 1.57147586e-01f,
  3.08268458e-01f, -7.01953620e-02f, 1.96944401e-01f, -1.87120050e-01f, 8.07782933e-02f, -1.74264669e-01f, -7.98769295e-02f, 9.75297913e-02f, 2.10852772e-02f, -7.59888887e-02f,
  -1.12837888e-01f, -7.84538165e-02f, -3.71005163e-02f, 1.93461999e-01f, -1.71250165e-01f, -6.28171191e-02f, -1.50161847e-01f, 2.07912281e-01f, 1.24101110e-01f, 9.13770124e-03f,
  2.69394852e-02f, -1.97114363e-01f, -1.13426812e-03f, -1.09443732e-01f, 5.80061227e-02f, 6.21163994e-02f, -2.16363426e-02f, -3.25189382e-02f, -3.61372950e-03f, 1.15250096e-01f,
  2.84522939e-02f, 1.44902589e-02f, 6.82706460e-02f, 7.20595270e-02f, 2.82117520e-02f, -3.83949392e-02f, -9.76223405e-03f, -2.46112868e-02f, -6.48567686e-03f, -3.88849638e-02f,
  1.63280860e-01f, 8.77133459e-02f, 1.53864577e-01f, 9.43681300e-02f, 1.50167361e-01f, 2.38343298e-01f, 2.03394651e-01f, -2.31180504e-01f, 4.38698014e-04f, -2.96415299e-01f,
  1.14787012e-01f, 2.74220616e-01f, 1.15709640e-02f, -2.30734318e-01f, 1.98966652e-01f, 4.60229628e-03f, -1.18030421e-01f, -2.21925154e-01f, -1.07417762e-01f, -2.23641440e-01f,
  2.05719993e-01f, -2.84466684e-01f, 2.06390247e-02f, -2.30953798e-01f, -1.75004706e-01f, 4.29793634e-02f, -2.13713795e-01f, 4.59363870e-02f, 1.12411626e-01f, 2.12502733e-01f,
  3.65415454e-01f, -1.69136003e-01f, -2.34339535e-01f, 2.50611659e-02f, -1.26073465e-01f, -3.68530639e-02f, -3.03787202e-01f, -1.05854683e-01f, -3.90541583e-01f, -7.59207755e-02f,
  3.72977376e-01f, -1.02111228e-01f, 1.06690980e-01f, 8.14185217e-02f, -2.35216767e-01f, -2.35483840e-01f, 3.63693311e-04f, 4.34834987e-01f, -1.86511539e-02f, -1.39442831e-01f,
  -3.64788175e-02f, 2.40731388e-02f, -8.85514989e-02f, -1.06941946e-01f, -1.40228227e-01f, 2.02480868e-01f, 4.42908145e-02f, -7.26045594e-02f, 8.17616880e-02f, -5.43795712e-02f,
  2.51545608e-01f, 2.93303460e-01f, 3.47807370e-02f, -2.00827077e-01f, 2.43921936e-01f, 1.36830434e-01f, 3.32040377e-02f, 1.41743533e-02f, -2.86690183e-02f, 1.37676910e-01f,
  6.44915625e-02f, 8.54181708e-04f, 3.25748712e-01f, -1.69795588e-01f, 2.56032437e-01f, -5.47486283e-02f, 1.11775137e-01f, 1.74968705e-01f, -4.27810878e-01f, 8.94381553e-02f,
  1.23632541e-02f, 2.25402027e-01f, 2.17556506e-01f, 5.36462180e-02f, 1.61030620e-01f, -3.41947079e-02f, -1.62436798e-01f, -2.30299477e-02f, 1.27880052e-01f, 1.68021813e-01f,
  -3.00103799e-02f, -2.41128519e-01f, -3.74146849e-02f, 4.98666540e-02f, -1.81221813e-01f, 1.70402020e-01f, 5.85371256e-02f, 9.70062688e-02f, -1.48450792e-01f, -1.55158773e-01f,
  -2.88886279e-02f, 1.91968471e-01f, 8.07186030e-03f, 1.30881682e-01f, -4.25210260e-02f, 1.66502923e-01f, -1.08441934e-01f, -7.70688755e-03f, -7.15376884e-02f, 1.19442441e-01f,
  8.31890106e-02f, 1.40149549e-01f, 1.24241896e-01f, 1.55519351e-01f, 1.07234299e-01f, 1.65131971e-01f, 2.07495883e-01f, 8.97662565e-02f, 7.11334199e-02f, 2.23540530e-01f,
  1.78263821e-02f, 1.05849877e-01f, 7.50653222e-02f, 1.59911618e-01f, -1.28455222e-01f, -2.02349350e-02f, 1.34971831e-02f, 8.54634568e-02f, -1.52177751e-01f, 8.65377486e-02f,
  -1.09050654e-01f, -2.03744411e-01f, 3.61248255e-02f, 2.05635298e-02f, -1.49601355e-01f, -4.20783907e-02f, 3.02150458e-01f, 6.70501888e-02f, -2.80258209e-01f, 1.06656305e-01f,
  2.64591612e-02f, -2.03204393e-01f, -9.82849523e-02f, 9.53206494e-02f, 2.25576889e-02f, 1.14087395e-01f, -6.18565269e-02f, 2.06447795e-01f, 2.15591967e-01f, 2.78693557e-01f,
  -2.15892568e-01f, -2.48922538e-02f, -8.41385592e-03f, 8.17109570e-02f, -2.31639504e-01f, 1.98397845e-01f, 2.63548017e-01f, 7.17769936e-02f, 2.04448983e-01f, -4.78459969e-02f,
  -3.56547870e-02f, 9.18983743e-02f, 1.21025681e-01f, -3.98928881e-01f, 1.27890587e-01f, 2.95174345e-02f, 3.08377117e-01f, 1.54146373e-01f, -2.11691022e-01f, -5.65152280e-02f,
  7.49851391e-02f, -1.62236858e-02f, 3.30254197e-01f, 3.54531169e-01f, 1.13496371e-01f, 2.57519484e-01f, -7.04566715e-03f, 1.62923764e-02f, 1.32802250e-02f, 3.98969576e-02f,
  1.29182618e-02f, 7.86750205e-03f, -1.20750956e-01f, 1.82039231e-01f, 1.74406454e-01f, -2.31661834e-02f, 1.31793216e-01f, 6.05255142e-02f, 1.20384227e-02f, -7.43194520e-02f,
  1.03079773e-01f, -9.74977296e-03f, -2.90617682e-02f, 4.94929701e-02f, -1.37102932e-01f, 1.31188110e-01f, -1.03522815e-01f, 6.19445480e-02f, -2.41224375e-02f, 8.54451358e-02f,
  5.90498410e-02f, -1.47663161e-01f, 2.20481202e-01f, -3.86490598e-02f, -4.76893112e-02f, 1.88611850e-01f, 4.33144160e-02f, 5.72186820e-02f, -1.42676145e-01f, 4.69468944e-02f,
  1.60275534e-01f, 1.31891802e-01f, -2.30560116e-02f, 5.21525135e-03f, -1.59622714e-01f, 5.87007254e-02f, 2.62839586e-01f, -4.71723154e-02f, 1.27764016e-01f, -3.51748765e-02f,
  1.73589036e-01f, 1.17236219e-01f, -6.45788461e-02f, 5.94353583e-03f, -3.22386883e-02f, 2.91387528e-01f, -6.82877600e-02f, -2.41016932e-02f, -1.75351039e-01f, 8.23258534e-02f,
  -2.85436772e-02f, 1.72077298e-01f, 8.70184600e-02f, 1.37283430e-01f, -1.66893691e-01f, 1.54150708e-03f, -1.41760200e-01f, -1.15224041e-01f, -2.65579671e-03f, 1.15445733e-01f,
  4.45603253e-03f, -3.19312029e-02f, 9.87002775e-02f, -5.32410778e-02f, 3.81970890e-02f, -1.05734557e-01f, -3.48883942e-02f, 1.24391466e-01f, -8.01006854e-02f, 5.41477790e-03f,
  7.37386271e-02f, 1.36644229e-01f, 1.53386921e-01f, 2.43551861e-02f, 9.75487977e-02f, -1.07951030e-01f, 6.39938936e-02f, -1.23051196e-01f, 2.83669843e-03f, -1.14245988e-01f,
  -1.41444072e-01f, -6.89066052e-02f, -4.37715650e-02f, -1.44558147e-01f, 1.60949394e-01f, 1.32552296e-01f, 6.39604256e-02f, 2.07579043e-02f, 1.42614409e-01f, 1.03760555e-01f,
  -3.66025776e-01f, -4.76450846e-02f, 2.52814025e-01f, 2.83682346e-01f, -1.09695464e-01f, 7.12880269e-02f, 2.53074039e-02f, 3.71310785e-02f, -1.48114655e-02f, 6.02673069e-02f,
  1.90765038e-01f, 6.91306144e-02f, 3.35677937e-02f, 9.65464208e-03f, 2.99676531e-03f, 8.66841525e-03f, -1.39304370e-01f, -2.86713559e-02f, 2.53903061e-01f, -2.79484868e-01f,
  3.10006440e-01f, -9.00406241e-02f, 1.10228285e-01f, -6.54098764e-02f, 1.94534644e-01f, 2.28214949e-01f, -3.45510274e-01f, 2.46129766e-01f, 1.91752389e-01f, 1.60572514e-01f,
  3.40620786e-01f, 1.89759299e-01f, 1.37263238e-01f, -8.24581906e-02f, 1.11523725e-01f, 2.07395017e-01f, 1.41865864e-01f, 2.22175434e-01f, 7.18900412e-02f, 1.80254459e-01f,
  2.02982575e-01f, -7.46771768e-02f, 1.38786733e-01f, 9.65209752e-02f, 2.21191823e-01f, 1.80375874e-01f, -9.09668431e-02f, -1.36328444e-01f, -1.13095336e-01f, -6.17675297e-02f,
  1.37530863e-01f, -1.82362292e-02f, 3.52073848e-01f, 7.10847974e-02f, -1.91299424e-01f, 1.45771876e-02f, -4.72873822e-02f, 1.40666468e-02f, -4.70011830e-02f, 3.51493537e-01f,
  -1.59103259e-01f, 9.58888605e-02f, 2.20331028e-01f, 1.55598238e-01f, 1.87422782e-01f, -2.54901499e-01f, -1.25894070e-01f, 5.43481670e-02f, -5.89172170e-02f, -2.27689162e-01f,
  -7.09729567e-02f, -2.57960588e-01f, 1.28875151e-01f, -1.15698472e-01f, -1.96303457e-01f, -7.05569461e-02f, 8.50288272e-02f, 2.38743369e-02f, 1.79449230e-01f, -2.70537823e-01f,
  2.14227304e-01f, -5.97894937e-02f, 3.63936543e-01f, -1.79388985e-01f, 8.61869529e-02f, 2.05756620e-01f, 1.72207996e-01f, -8.68543759e-02f, -1.54343039e-01f, 1.63328294e-02f,
  2.44360507e-01f, 6.81666136e-02f, 5.55987507e-02f, 1.09114222e-01f, 1.29685745e-01f, -6.90372102e-03f, 4.18221839e-02f, -1.68566927e-02f, -1.59960473e-03f, 2.95857154e-02f,
  2.00767159e-01f, 1.44715905e-01f, -1.25985906e-01f, -5.55914305e-02f, 1.23585276e-01f, 6.44651204e-02f, 2.82085314e-02f, 1.54649676e-03f, 1.33191377e-01f, -2.17550546e-02f,
  1.00934096e-01f, 8.13855082e-02f, -1.13902360e-01f, -5.15754037e-02f, 5.44904880e-02f, 1.33347642e-02f, 4.01051063e-03f, 8.04617256e-02f, -9.23860818e-02f, -4.77642454e-02f,
  9.64707881e-02f, -4.60245423e-02f, 2.49408721e-03f, -1.20543264e-01f, 2.58891672e-01f, 1.00810323e-02f, -1.19374665e-02f, 2.00527355e-01f, 1.32744089e-01f, 1.56334326e-01f,
  8.35393742e-02f, 1.93739146e-01f, -1.28911892e-02f, 1.13104157e-01f, -1.98491335e-01f, 1.06996261e-01f, 8.34949538e-02f, 1.77227315e-02f, 1.74631760e-01f, 9.30336788e-02f,
  2.85579652e-01f, 1.41728356e-01f, 9.59537923e-02f, 1.43597737e-01f, 6.80537373e-02f, 1.49197161e-01f, 1.15896799e-02f, -3.86042939e-03f, 1.59662306e-01f, 1.30194901e-02f,
  -1.60997301e-01f, 1.25417858e-01f, -2.22154424e-01f, -2.79993825e-02f, 1.66814372e-01f, 1.58408388e-01f, 1.65826991e-01f, 8.23539943e-02f, -9.11343247e-02f, -2.28059143e-01f,
  -1.83845889e-02f, -6.40102103e-02f, 3.79385233e-01f, 2.52823591e-01f, 1.59419566e-01f, 6.17494807e-02f, 2.95037925e-01f, 2.05716401e-01f, -1.31704718e-01f, 2.61648804e-01f,
  6.29512370e-02f, 2.12580770e-01f, 1.62333816e-01f, 2.88552903e-02f, -2.50193849e-02f, 1.25021383e-01f, 7.53366053e-02f, -1.24006540e-01f, -1.15475461e-01f, -1.84409730e-02f,
  -1.50126562e-01f, -2.78299987e-01f, 1.43888667e-01f, 1.01721972e-01f, -4.14255857e-01f, 1.52586222e-01f, 7.08397254e-02f, 1.56117827e-01f, -2.22895771e-01f, -1.88113570e-01f,
  -4.60656732e-03f, -1.31040156e-01f, 3.43596697e-01f, 2.63288260e-01f, -4.02889811e-02f, 1.84663936e-01f, -1.36454374e-01f, 5.47634140e-02f, 2.19098538e-01f, 7.83208162e-02f,
  -2.29088843e-01f, 2.86152035e-01f, 7.67074600e-02f, -3.07885945e-01f, -6.75135404e-02f, -1.43243015e-01f, 7.16304630e-02f, -1.62310466e-01f, 1.68331251e-01f, -3.74729373e-02f,
  -1.52854934e-01f, 1.49828434e-01f, -1.12828225e-01f, -1.13065027e-01f, 1.11896582e-01f, 2.44495898e-01f, 2.41585374e-01f, 1.47316530e-01f, 4.36157174e-02f, -4.46905792e-02f,
  -8.43102019e-03f, 1.17438873e-02f, 9.11359936e-02f, 1.13633879e-01f, 3.18479608e-03f, -6.89800382e-02f, 2.20177069e-01f, 2.66266316e-01f, 1.90244660e-01f, 1.78643793e-01f,
  2.63543814e-01f, 1.08399585e-01f, 2.02974990e-01f, 1.25025764e-01f, 1.27992377e-01f, 2.23009005e-01f, 1.19516499e-01f, 1.49099946e-01f, -2.07412481e-01f, -2.41492108e-01f,
  -8.68355408e-02f, 3.02168280e-02f, 1.40074734e-02f, 4.90941443e-02f, 1.77634239e-01f, 1.97471023e-01f, -1.64698780e-01f, 3.75945270e-02f, -1.89242423e-01f, -2.23128602e-01f,
  -3.50476384e-01f, 1.70043722e-01f, 1.38724566e-01f, 1.42899796e-01f, 1.13665327e-01f, 2.95964301e-01f, 3.39086026e-01f, 1.21003971e-01f, -2.55825520e-01f, 4.47647832e-02f,
  -2.77854443e-01f, -1.49312720e-01f, -5.46307117e-02f, -1.20474145e-01f, 1.85880847e-02f, 7.78782219e-02f, 1.02689825e-01f, 1.30168721e-01f, 3.73097420e-01f, 2.03611180e-01f,
  2.60717601e-01f, 8.11344832e-02f, 1.40838042e-01f, -1.36511937e-01f, 7.51269832e-02f, -4.36787128e-01f, -1.40088886e-01f, 1.28412277e-01f, 6.22609854e-02f, -1.13908954e-01f,
  -3.20656866e-01f, 4.80575785e-02f, 4.10733461e-01f, -1.96935788e-01f, 4.63366322e-02f, -1.44848615e-01f, 1.80380244e-03f, -3.77672493e-01f, -1.72886811e-02f, -5.02183847e-02f,
  1.77611694e-01f, -1.45566147e-02f, 3.51739116e-02f, 1.01366535e-01f, 9.70523730e-02f, 1.83355212e-01f, 8.05459991e-02f, 1.53020114e-01f, -1.52521664e-02f, 8.94091949e-02f,
  3.45806554e-02f, 1.08472742e-01f, -3.60762700e-02f, -7.34021515e-02f, -2.15228543e-01f, 2.56820589e-01f, -1.33448616e-01f, -8.15865844e-02f, -1.54587433e-01f, -2.27766335e-01f,
  2.83284664e-01f, -1.03305571e-01f, -7.22492188e-02f, 3.81934643e-02f, -3.72042097e-02f, 9.18961763e-02f, -3.42950642e-01f, 7.59700090e-02f, -2.33819589e-01f, -1.69836104e-01f,
  1.22535326e-01f, -1.42976403e-01f, 5.35545424e-02f, 2.94428039e-02f, -1.21458426e-01f, 1.50401652e-01f, -2.60023726e-03f, 2.45391309e-01f, 1.69391558e-01f, 2.10927606e-01f,
  -1.51321769e-01f, -3.05931479e-01f, -2.12722216e-02f, -2.97288038e-02f, -1.43695161e-01f, -2.96683400e-03f, -1.36438295e-01f, -1.53365463e-01f, -3.09096333e-02f, 1.61189437e-01f,
  -6.00725263e-02f, 3.12769234e-01f, 2.37531140e-02f, 1.38337668e-02f, 3.93335044e-01f, 7.20064715e-02f, -8.98628086e-02f, -2.59600461e-01f, -5.01805954e-02f, -7.94521868e-02f,
  1.04690388e-01f, 3.26014727e-01f, -2.22083420e-01f, -3.73079002e-01f, -1.33084767e-02f, 2.21323431e-01f, 2.21939787e-01f, 8.42813328e-02f, 6.15725592e-02f, 4.58288230e-02f,
  1.13871597e-01f, -3.84001783e-03f, 6.47764802e-02f, 4.60508978e-03f, 2.15772122e-01f, 1.07991390e-01f, -2.43217304e-01f, -2.41710708e-01f, 2.57819667e-02f, 8.84702429e-02f,
  5.91570698e-02f, 3.65946591e-02f, -1.46391224e-02f, -3.33226845e-02f, -9.98140946e-02f, -1.68028951e-01f, 2.49461040e-01f, 3.30133736e-02f, -2.82393515e-01f, -2.36706302e-01f,
  -1.21738710e-01f, 9.81378928e-02f, -1.97091445e-01f, -2.57055014e-02f, 8.73486474e-02f, 1.75979704e-01f, -9.89386588e-02f, -1.56717643e-01f, -3.24646384e-02f, 2.51152605e-01f,
  1.46453857e-01f, 1.89793304e-01f, -5.96904382e-02f, 7.21077025e-02f, 1.04418285e-01f, 3.77100371e-02f, -7.84437060e-02f, 4.20715362e-01f, 1.06755711e-01f, 1.49781099e-02f,
  4.36582183e-03f, -2.88561374e-01f, -2.16997504e-01f, 1.45248011e-01f, -3.60079780e-02f, -1.50873944e-01f, -1.40936613e-01f, -8.12032297e-02f, 4.44089845e-02f, 1.44348845e-01f,
  4.25602384e-02f, -2.77110994e-01f, -5.89961410e-02f, -1.89745426e-01f, 4.59927134e-02f, -8.75920057e-02f, 5.86755387e-02f, 2.16006741e-01f, 8.59500468e-02f, 5.47653548e-02f,
  -1.30718760e-02f, 7.80617520e-02f, 1.50250822e-01f, 5.12822019e-03f, 5.76746725e-02f, 1.00522675e-01f, 1.81512022e-03f, 1.48814991e-01f, 8.76701027e-02f, 8.76699463e-02f,
  3.42772081e-02f, 9.74616483e-02f, 1.27901942e-01f, -2.23178729e-01f, -5.26582226e-02f, 8.08516219e-02f, 4.45254296e-02f, 2.25194991e-01f, -1.41774029e-01f, -1.33441150e-01f,
  -3.21634322e-01f, -4.69335588e-03f, -1.10331155e-01f, 1.79566041e-01f, 1.92690939e-01f, -1.88472390e-01f, 3.70232984e-02f, 3.02188933e-01f, 1.00248702e-01f, -7.33237192e-02f,
  -8.95812064e-02f, 2.64169395e-01f, 5.20840138e-02f, -1.58330023e-01f, -8.98303539e-02f, -1.84728011e-01f, 1.00679398e-01f, 9.81214717e-02f, 1.65805966e-01f, -8.47723559e-02f,
  2.99179375e-01f, -2.14621231e-01f, 1.88184261e-01f, -4.67229038e-02f, -8.35774317e-02f, 1.49849877e-01f, 8.21675658e-02f, -2.22171739e-01f, 4.88532744e-02f, 2.58017570e-01f,
  2.49990094e-02f, 1.15639232e-01f, 6.52158484e-02f, 1.63919494e-01f, 2.45408565e-01f, 3.47146749e-01f, -2.12698244e-02f, 1.10757902e-01f, -7.32464064e-03f, -1.96227193e-01f,
  -4.11803462e-02f, -1.60178870e-01f, 2.14178592e-01f, 1.72621533e-02f, 2.38493681e-01f, 1.75556362e-01f, -4.38678218e-03f, -5.11045661e-03f, 7.88444057e-02f, 2.16027573e-01f,
  1.28359839e-01f, 1.44287705e-01f, 5.79845980e-02f, -6.19110791e-03f, 1.33447155e-01f, 1.67604163e-01f, -1.26023725e-01f, -9.09056664e-02f, 8.82017091e-02f, -1.55986603e-02f,
  -2.36996144e-01f, 3.54920328e-02f, 1.07396558e-01f, 9.60812066e-03f, 1.78346619e-01f, -3.13009173e-02f, -1.83012094e-02f, -2.09817871e-01f, 4.69363064e-01f, 1.11358054e-01f,
  -2.65721325e-02f, 2.48951256e-01f, -1.12048751e-02f, -8.38984922e-02f, 4.03921120e-02f, 2.40681380e-01f, 4.36423644e-02f, 6.65144175e-02f, 4.61880676e-02f, -1.46118790e-01f,
  9.57521871e-02f, 8.17171782e-02f, -1.28470669e-02f, 1.89861223e-01f, 2.12381274e-01f, -1.14321209e-01f, 7.21106827e-02f, 5.59080765e-02f, 3.15279290e-02f, -9.18468907e-02f,
  -5.95303737e-02f, 9.06746462e-02f, -4.28883061e-02f, 2.53569931e-01f, -3.52625042e-01f, 1.36055529e-01f, -6.25234889e-03f, -2.91250870e-02f, 1.69695374e-02f, 2.75559098e-01f,
  1.48661628e-01f, 1.32454440e-01f, -2.43239686e-01f, -2.66861230e-01f, -8.67726579e-02f, 1.98005900e-01f, 3.38350460e-02f, -1.70255244e-01f, -6.01272397e-02f, 6.77156001e-02f,
  -5.71484677e-02f, -6.11254945e-02f, -7.53985271e-02f, 8.98132920e-02f, -1.82413440e-02f, -9.46961939e-02f, 9.47733521e-02f, 6.97347596e-02f, 1.60082504e-01f, 2.64346957e-01f,
  1.46581858e-01f, -5.70490286e-02f, -1.74977910e-02f, 1.71654783e-02f, -4.04594317e-02f, 8.56463909e-02f, -1.26192942e-01f, 1.50584146e-01f, -4.96946238e-02f, 5.92432506e-02f,
  3.75635885e-02f, -1.49220303e-01f, 1.42964408e-01f, 4.09660153e-02f, -3.12817954e-02f, 1.25575602e-01f, -7.99524114e-02f, 5.87703176e-02f, 1.78338721e-01f, 1.17341183e-01f,
  -5.11872284e-02f, -1.00808907e-02f, -3.62916514e-02f, -7.04694912e-02f, 1.46942800e-02f, 5.27861342e-02f, 1.88335687e-01f, 9.41724926e-02f, 2.24636957e-01f, -2.10416466e-01f,
  -2.19257828e-02f, -4.42414097e-02f, -2.03680173e-01f, 9.78091955e-02f, 3.15832831e-02f, 2.21602656e-02f, -7.29708821e-02f, -7.23911077e-02f, -1.80600002e-01f, 9.21538472e-02f,
  -4.78937328e-02f, 1.39569968e-01f, -2.09356621e-01f, 6.36978149e-02f, 2.24873200e-01f, 1.45792976e-01f, -2.00833268e-02f, -1.12879321e-01f, 9.65212360e-02f, 1.67452767e-01f,
  -2.34529991e-02f, 4.48113941e-02f, 2.44271029e-02f, -9.01530683e-02f, 3.05056553e-02f, -7.14316294e-02f, 1.87953897e-02f, 7.63844103e-02f, 1.38639927e-01f, -3.73995751e-02f,
  -5.13650626e-02f, 5.44953942e-02f, -9.75958481e-02f, -4.19725589e-02f, 1.04853660e-01f, 1.33075500e-02f, 2.32407041e-02f, 1.31957963e-01f, -3.09480801e-02f, -3.35465148e-02f,
  -7.87205324e-02f, -1.67441834e-02f, -1.44084059e-02f, -8.38138685e-02f, -2.65902936e-01f, -1.54338717e-01f, 7.28445351e-02f, 1.84966624e-01f, 2.47747507e-02f, 2.25835845e-01f,
  -3.26328278e-01f, 2.64648974e-01f, -6.41670823e-02f, 1.58316329e-01f, 8.55231658e-02f, -5.94017394e-02f, 1.60452262e-01f, 6.96695596e-02f, -2.24398002e-01f, 2.67156567e-02f,
  2.21484065e-01f, 7.06432089e-02f, 1.00989081e-01f, 1.29968151e-01f, 3.53973269e-01f, 6.80914298e-02f, 1.89893246e-01f, -2.16401983e-02f, -9.18463543e-02f, 3.15961021e-04f,
  2.51044720e-01f, -1.40853480e-01f, 1.45356953e-01f, -5.43118119e-02f, -2.55788844e-02f, 1.85613811e-01f, -1.42265875e-02f, -3.41947936e-02f, 1.66792333e-01f, -1.83483258e-01f,
  3.44155192e-01f, -1.75677419e-01f, 3.10317606e-01f, -1.40576899e-01f, 1.31947353e-01f, 5.33808768e-02f, 1.35641158e-01f, 1.42985672e-01f, 1.50556087e-01f, 5.42613827e-02f,
  1.19293980e-01f, 2.32084438e-01f, 2.00760856e-01f, 8.00245404e-02f, 2.17990354e-01f, 3.66350338e-02f, 2.90600121e-01f, 4.37865585e-01f, 2.02921435e-01f, -1.42254159e-01f,
  1.02852717e-01f, 1.71675920e-01f, -3.64996318e-04f, 1.13919929e-01f, -2.47881398e-01f, 2.50200361e-01f, -8.53509381e-02f, -7.34146684e-02f, 2.81872243e-01f, 8.54408070e-02f,
  2.31007889e-01f, -1.71001717e-01f, 1.79936877e-03f, 7.54149035e-02f, -1.47942841e-01f, 5.20245824e-03f, 9.34194922e-02f, 2.09881067e-01f, -7.49626830e-02f, -9.91576314e-02f,
  1.63395435e-01f, -1.94845662e-01f, -8.17185342e-02f, 1.43351495e-01f, 2.26537034e-01f, 1.97719455e-01f, 1.38011798e-01f, -2.39256069e-01f, -1.00545831e-01f, -1.13008767e-01f,
  8.84330422e-02f, -5.16257761e-03f, 3.47031690e-02f, 5.01667671e-02f, -2.00545825e-02f, -1.72255576e-01f, -1.88117504e-01f, 1.40014872e-01f, -1.18476734e-01f, 8.72034729e-02f,
  -3.05068552e-01f, 2.69421995e-01f, 5.11196218e-02f, 1.35116220e-01f, -1.12612449e-01f, -8.53459686e-02f, -8.28738287e-02f, 1.80190191e-01f, 2.87558824e-01f, 1.30552128e-01f,
  1.38094217e-01f, 1.24364883e-01f, 1.40929207e-01f, 2.33183175e-01f, 3.48018147e-02f, 1.98093176e-01f, 5.22261448e-02f, 1.98069349e-01f, 6.49646074e-02f, -7.32258856e-02f,
  1.16233990e-01f, 1.38101559e-02f, 1.65163521e-02f, -3.10043711e-02f, -8.93219560e-02f, -2.11276412e-02f, -1.18039511e-02f, -9.18740034e-02f, -2.84627397e-02f, -1.96357630e-02f,
  -2.15810195e-01f, 6.17685728e-02f, 2.49399558e-01f, -5.45729809e-02f, -2.56787330e-01f, -1.16011389e-01f, -7.86463916e-02f, -5.23411557e-02f, 1.04111850e-01f, 2.11696446e-01f,
  5.99577874e-02f, 2.00159736e-02f, -2.40206048e-02f, 1.71559274e-01f, 1.19925857e-01f, 1.80352792e-01f, -2.14750051e-01f, 2.21584275e-01f, 2.49807209e-01f, -3.32616299e-01f,
  7.60302097e-02f, -1.19537026e-01f, 2.22486760e-02f, -1.09170817e-01f, -3.54234800e-02f, -5.17091341e-02f, -6.11893088e-02f, 3.61868143e-01f, -1.45093754e-01f, -1.92732662e-01f,
  1.19818650e-01f, 2.75137395e-01f, 1.45731553e-01f, 1.81381121e-01f, 5.14492132e-02f, -1.92120448e-01f, -3.50918993e-02f, -2.11733267e-01f, -3.63530330e-02f, 1.43200636e-01f,
  -2.00170558e-02f, -4.37800102e-02f, 1.94911912e-01f, 2.25506082e-01f, 1.44890487e-01f, 1.55399233e-01f, 2.31220663e-01f, 1.45990089e-01f, 1.14061898e-02f, -5.34761176e-02f,
  1.35847434e-01f, 1.34536222e-01f, -2.73193214e-02f, -8.78428146e-02f, -1.64281037e-02f, -1.38099238e-01f, 2.10718736e-01f, -4.01504040e-02f, -9.65679511e-02f, 5.13836443e-02f,
  -1.21284328e-01f, 3.04358955e-02f, -5.42899743e-02f, 1.06791921e-01f, 7.43901134e-02f, 7.07787573e-02f, -4.99406904e-02f, -7.77059644e-02f, -2.30140045e-01f, -1.07385628e-01f,
  1.89951044e-02f, 2.21889038e-02f, -5.97123019e-02f, 7.20776618e-02f, -8.62034410e-02f, -1.16079086e-02f, 4.23110612e-02f, 9.56228226e-02f, 2.02055976e-01f, 2.94768393e-01f,
  -2.05684319e-01f, 1.90839872e-01f, 2.57707536e-01f, -1.15820430e-01f, 7.65827447e-02f, 2.16846809e-01f, 3.00667286e-01f, 2.09604517e-01f, 1.47835106e-01f, 2.09498946e-02f,
  -1.37568831e-01f, 1.15557462e-01f, -1.17504098e-01f, -1.72811866e-01f, 1.28568456e-01f, 5.67916408e-03f, 2.99870700e-01f, 2.65134394e-01f, 1.53547063e-01f, -1.21934794e-01f,
  -1.44943036e-02f, -2.07993507e-01f, -9.63632166e-02f, -5.90462349e-02f, -5.93667217e-02f, 1.05843239e-01f, 2.21023131e-02f, 3.92259881e-02f, 3.01506799e-02f, 1.47816747e-01f,
  1.46679595e-01f, 3.81136616e-03f, 5.24420924e-02f, 1.08530588e-01f, 9.73945111e-02f, -1.59522705e-02f, 1.24783501e-01f, -3.02937049e-02f, -1.56879146e-02f, -6.94016516e-02f,
  -6.72722310e-02f, 1.21710181e-01f, -5.99233024e-02f, 1.78969815e-01f, -1.51942819e-01f, 1.13315612e-01f, -2.87395194e-02f, 4.42020819e-02f, 2.24313334e-01f, -4.76953872e-02f,
  -1.68327585e-01f, -3.50364894e-01f, 1.90312892e-01f, -7.30557218e-02f, -1.06292423e-02f, 7.92584270e-02f, 9.60427597e-02f, 1.70887455e-01f, -9.70803201e-02f, -5.90259694e-02f,
  -1.00478269e-01f, 1.28287226e-01f, 3.60241048e-02f, 2.51375109e-01f, -9.03217494e-02f, 9.56154913e-02f, 1.13201572e-03f, 1.83431357e-01f, -4.13232781e-02f, 3.04006159e-01f,
  2.61219621e-01f, 1.07772872e-01f, -1.52918203e-02f, 2.51933690e-02f, -1.17056027e-01f, 2.45126143e-01f, -2.89269667e-02f, -1.88229367e-01f, -6.24178797e-02f, -1.30606219e-01f,
  -2.14339569e-01f, 1.97380051e-01f, 2.52103448e-01f, -1.22125149e-01f, 5.63545525e-02f, -6.97297826e-02f, -1.87169775e-01f, -2.65469790e-01f, 5.60203975e-04f, 1.34146288e-01f,
  9.80553329e-02f, 1.44699201e-01f, 2.50690758e-01f, 2.30391756e-01f, 2.07195021e-02f, 2.54533231e-01f, 2.86192447e-01f, 1.86378524e-01f, 1.44287348e-01f, 3.49861421e-02f,
  1.99950919e-01f, 1.86012283e-01f, -2.16591373e-01f, -8.27619210e-02f, -1.72546521e-01f, 6.76302612e-02f, 7.59723131e-03f, 9.71886441e-02f, 1.72073126e-01f, 1.49948359e-01f,
  -1.18211210e-01f, 6.49196357e-02f, 7.03612715e-02f, -1.27679303e-01f, 1.06024466e-01f, 1.65484939e-02f, -1.47973910e-01f, 1.12835534e-01f, 1.47204220e-01f, 1.45794973e-01f,
  3.58661830e-01f, 2.02117413e-01f, -7.79111385e-02f, -4.82623652e-03f, -1.82911679e-01f, -1.39236748e-01f, 7.36556724e-02f, 1.63297370e-01f, -7.35052004e-02f, -8.19192901e-02f,
  6.36988506e-02f, -9.58621725e-02f, 1.38546333e-01f, 1.21906057e-01f, 1.76814556e-01f, -1.44580051e-01f, 2.91750938e-01f, -3.17804813e-01f, 1.18305059e-02f, -5.64137809e-02f,
  4.49081473e-02f, -7.95176998e-02f, 9.41271111e-02f, 8.83984640e-02f, -3.23240548e-01f, 4.05982733e-02f, 1.63868815e-01f, -2.42778093e-01f, -9.49922875e-02f, 2.41342317e-02f,
  -3.50317508e-02f, -1.26108468e-01f, 1.15790948e-01f, 2.89924115e-01f, 9.91553813e-02f, 2.10630193e-01f, 1.08944185e-01f, -1.11042731e-01f, 1.22344509e-01f, 9.91480649e-02f,
  -6.04965575e-02f, 5.41613996e-02f, 2.68473715e-01f, -4.40422744e-02f, 5.61065674e-02f, 9.19076651e-02f, -6.69011474e-02f, 1.25437006e-01f, 4.77647819e-02f, -1.32412627e-01f,
  2.39037424e-02f, -1.77974537e-01f, 1.79731771e-01f, 2.35607848e-01f, -6.34116977e-02f, 1.31498948e-01f, -1.63911924e-01f, 1.28657490e-01f, 2.78283060e-01f, 1.61705688e-01f,
  -1.19026363e-01f, -5.27894050e-02f, 4.09328863e-02f, -2.39204362e-01f, -5.16824499e-02f, 1.37233153e-01f, 8.21805969e-02f, 1.22749031e-01f, 1.29194051e-01f, -2.65767097e-01f,
  -2.18665496e-01f, -4.72087674e-02f, 1.36842877e-01f, -2.08000824e-01f, 1.67388633e-01f, 5.79569861e-02f, -9.05188173e-02f, -2.34901141e-02f, -2.83953816e-01f, -7.46594416e-03f,
  -1.30648866e-01f, -8.33278820e-02f, 1.47418723e-01f, 1.65632993e-01f, -6.40622452e-02f, -2.77462125e-01f, 2.61465549e-01f, 2.57674754e-01f, -1.93843618e-01f, -1.89708561e-01f,
  -2.62181431e-01f, -1.32645831e-01f, 2.77216956e-02f, 7.33226314e-02f, -1.53009119e-02f, 1.60957932e-01f, -4.11944687e-02f, -1.89281795e-02f, 2.53789932e-01f, 1.83224663e-01f,
  2.10171759e-01f, 2.27864251e-01f, 2.45394617e-01f, 2.29539901e-01f, 1.79278031e-01f, 2.33710244e-01f, 1.13472529e-01f, 2.56472766e-01f, 7.47572109e-02f, 2.46004343e-01f,
  -1.19988039e-01f, -7.83594698e-02f, -1.21114291e-01f, 1.18874393e-01f, 1.12075254e-01f, -1.03315525e-01f, -1.83643907e-01f, -1.08438209e-01f, 1.60062164e-01f, 8.63564685e-02f,
  3.54949057e-01f, -7.23729581e-02f, -5.07997833e-02f, -1.97429761e-01f, -2.36254722e-01f, 1.21144690e-01f, 3.25862365e-03f, 5.78093268e-02f, 1.63678914e-01f, -2.07396820e-01f,
  -5.52458465e-02f, -8.45123976e-02f, -9.50303860e-03f, -3.30996364e-02f, 2.69792885e-01f, 1.85777601e-02f, 6.21527657e-02f, -6.13590404e-02f, -2.47741655e-01f, 5.15730754e-02f,
  -7.62213320e-02f, 3.51659581e-02f, 8.62506870e-03f, -9.82933939e-02f, 8.84637088e-02f, -2.44449854e-01f, 6.38578013e-02f, 4.58189379e-03f, -8.93802643e-02f, 3.42782140e-01f,
  -9.65445265e-02f, -1.20137580e-01f, -6.84108958e-03f, -9.43422318e-02f, -7.39454180e-02f, -1.10418908e-01f, -2.79981513e-02f, 7.56318048e-02f, -2.12979615e-01f, 2.59349912e-01f,
  -2.99466789e-01f, 2.94398755e-01f, -4.94768918e-02f, -1.20333852e-02f, 9.19308960e-02f, 9.13144350e-02f, 6.72901794e-02f, -1.00798234e-02f, -5.75017035e-02f, 2.29486853e-01f,
  6.42125383e-02f, 1.77227557e-02f, 1.90743983e-01f, 3.44038829e-02f, -7.72899687e-02f, -1.37776226e-01f, -9.59137306e-02f, 9.39819887e-02f, -1.41434157e-02f, -2.12282762e-01f,
  1.38249278e-01f, -1.40472576e-02f, 7.35078752e-02f, 1.54381379e-01f, 8.60324875e-02f, -1.08713523e-01f, -1.76489294e-01f, -7.63607323e-02f, -6.43936917e-03f, 9.77873206e-02f,
  2.04675838e-01f, -1.14398561e-01f, -1.21372759e-01f, 6.94299340e-02f, 1.98414743e-01f, -7.75447562e-02f, 2.90002134e-02f, -8.92306343e-02f, -1.19652689e-01f, -7.21477196e-02f,
  -3.11077889e-02f, -1.86764538e-01f, -1.09570816e-01f, 1.72183827e-01f, -2.32639164e-01f, 1.32465333e-01f, -1.10605163e-02f, 1.36928663e-01f, 1.96467221e-01f, 4.10860814e-02f,
  1.44742548e-01f, -2.86349773e-01f, 2.86794633e-01f, 1.75371215e-01f, 6.05901591e-02f, -1.22980341e-01f, -3.71311635e-01f, -3.13848145e-02f, 1.22899063e-01f, -3.38294029e-01f,
  2.04587519e-01f, 1.62695691e-01f, 1.83388561e-01f, 1.48950107e-02f, 2.33343914e-01f, -2.81183571e-02f, 1.05854228e-01f, 1.49673924e-01f, 1.11225218e-01f, 2.79379994e-01f,
  -4.31142263e-02f, 2.87408918e-01f, 1.93240613e-01f, 1.02082603e-01f, 1.29822403e-01f, 1.88152775e-01f, 2.85562694e-01f, 2.77363639e-02f, -2.47396141e-01f, -2.34533966e-01f,
  -2.08699834e-02f, 1.38901606e-01f, -1.44591972e-01f, 1.03264056e-01f, -1.55291677e-01f, -1.67381033e-01f, 4.24225144e-02f, -7.82237202e-02f, 2.19028845e-01f, 1.62498076e-02f,
  -1.32426515e-01f, -2.57126451e-01f, -1.10624202e-01f, 1.65744290e-01f, -2.51578510e-01f, 1.01553453e-02f, 1.24367334e-01f, 1.63251266e-01f, -2.91877575e-02f, -5.44266328e-02f,
  -2.44962379e-01f, 2.29094014e-01f, 1.41714871e-01f, 1.75492540e-01f, -5.21332137e-02f, 1.34721794e-03f, 1.27770811e-01f, -1.15763076e-01f, -1.55041665e-01f, 3.08290899e-01f,
  3.29128534e-01f, -6.05778769e-02f, 1.05078816e-01f, -1.64711460e-01f, -1.85207486e-01f, 2.45143086e-01f, 6.29618689e-02f, -5.61016165e-02f, 8.10922764e-04f, -1.30872995e-01f,
  -6.01156056e-02f, 4.91603464e-02f, 2.62578845e-01f, -2.08231449e-01f, -4.85752486e-02f, -3.75796668e-02f, 2.19782457e-01f, -1.47723868e-01f, 1.05871335e-01f, 1.75722376e-01f,
  -4.05004099e-02f, -6.93048313e-02f, 1.16503693e-01f, -2.28591915e-02f, 1.33898422e-01f, 1.40752256e-01f, 1.73749462e-01f, 2.05216616e-01f, 1.09704316e-01f, 1.36959046e-01f,
  1.73888490e-01f, 9.09942985e-02f, -3.65169235e-02f, -1.23059042e-01f, -3.07514191e-01f, 1.46559432e-01f, -4.48840708e-02f, -9.41565782e-02f, 8.63785073e-02f, -4.02385928e-02f,
  2.37045154e-01f, 6.36114031e-02f, 2.84328878e-01f, -1.35379270e-01f, -1.36143163e-01f, -5.86441830e-02f, -1.25791281e-01f, 2.30666652e-01f, 8.47996920e-02f, -3.02317888e-01f,
  6.30740896e-02f, -2.48273894e-01f, 1.42474845e-01f, -1.56111047e-01f, -8.12811032e-03f, -2.08577931e-01f, -1.20210566e-01f, -3.27752322e-01f, 2.23699570e-01f, -2.75757462e-01f,
  -3.00997823e-01f, 5.33733815e-02f, -4.22918141e-01f, -5.16900085e-02f, -1.40530467e-01f, -4.39087525e-02f, -7.04290792e-02f, -2.93690041e-02f, 3.97071809e-01f, -5.54252528e-02f,
  -3.69148105e-02f, 3.88199627e-01f, -1.28898799e-01f, -2.06380412e-01f, 1.79546595e-01f, -1.31661460e-01f, 9.40071121e-02f, 1.66781954e-02f, 1.20549135e-01f, 1.15304053e-01f,
  -5.43972850e-02f, 2.61738986e-01f, -2.48910859e-01f, -2.34141685e-02f, 1.72526181e-01f, 1.51729628e-01f, 9.89016965e-02f, 2.26764336e-01f, -1.76894125e-02f, 8.88469443e-02f,
  2.90970773e-01f, 9.95965973e-02f, 2.11259708e-01f, 7.30632171e-02f, 2.31687158e-01f, 2.73570240e-01f, -6.69371411e-02f, 8.00157413e-02f, 1.04071222e-01f, -3.50677874e-03f,
  9.98062193e-02f, -1.32800788e-01f, 6.17025048e-02f, -1.09548010e-02f, 4.42700833e-02f, 1.30367383e-01f, -5.98578528e-02f, -5.23028374e-02f, 4.13673073e-01f, 2.02239960e-01f,
  -1.93722874e-01f, 3.69267277e-02f, 4.42625843e-02f, -2.02290744e-01f, -1.10698543e-01f, -3.09081525e-01f, -5.45573905e-02f, -1.53904436e-02f, -2.45000534e-02f, -1.50690228e-01f,
  1.71408609e-01f, 9.20352638e-02f, -5.79146668e-02f, -3.25314552e-01f, -8.26278061e-04f, -2.52889320e-02f, -3.76924157e-01f, 5.55327386e-02f, 9.74179804e-02f, -2.47409254e-01f,
  1.71538308e-01f, 6.84747845e-02f, 3.34460914e-01f, 2.63831317e-01f, 1.64509583e-02f, -2.43711788e-02f, 2.80654281e-01f, 1.05801702e-01f, -2.04106733e-01f, -5.53128347e-02f,
  1.29573956e-01f, 7.04982504e-02f, -7.35525116e-02f, 1.56548366e-01f, 1.77641705e-01f, 4.26178575e-01f, 1.72887579e-01f, 3.94594103e-01f, 5.25397062e-02f, 1.35396682e-02f,
  -7.37075694e-03f, 1.53470814e-01f, -1.39759481e-02f, 8.09558332e-02f, 1.72683686e-01f, 1.95586048e-02f, 2.02103388e-02f, -1.37500884e-02f, 8.75609815e-02f, 8.12018439e-02f,
  -1.52026370e-01f, -1.38734862e-01f, -5.33819124e-02f, 7.33628422e-02f, 4.28967811e-02f, -9.05071944e-02f, 6.09495565e-02f, -1.53019711e-01f, 8.84852484e-02f, -2.09993441e-02f,
  9.17608216e-02f, -1.44384317e-02f, 2.32020244e-02f, -1.58751428e-01f, -2.79828489e-01f, 1.88570261e-01f, -1.19057357e-01f, -5.95341139e-02f, 8.81174058e-02f, -1.81625351e-01f,
  -1.57322604e-02f, -1.95324302e-01f, -5.27698472e-02f, 8.84653479e-02f, -4.40305434e-02f, -3.05842422e-02f, 2.03557938e-01f, 8.78551006e-02f, -8.33622888e-02f, -1.35126188e-01f,
  -1.12405553e-01f, 1.70748964e-01f, 3.43949869e-02f, -9.37974080e-02f, 4.68567684e-02f, -2.75564939e-01f, 8.25110152e-02f, -4.16432433e-02f, -2.45733652e-02f, 2.96411753e-01f,
  1.62680540e-02f, -3.06352004e-02f, 1.31557539e-01f, 3.01820189e-02f, 1.66266546e-01f, -2.81243891e-01f, -5.25504583e-04f, 5.38468314e-03f, 2.46905521e-01f, 3.93791586e-01f,
  -4.49995464e-03f, -1.68783404e-02f, 4.68992516e-02f, 7.44083747e-02f, 4.44623865e-02f, 5.09602129e-02f, 2.98219249e-02f, -2.93481257e-02f, 1.26098529e-01f, 2.80205578e-01f,
  1.82466358e-01f, -2.16399636e-02f, 1.69984773e-01f, 8.05672333e-02f, 2.08607987e-01f, 2.05351844e-01f, 1.76608592e-01f, -1.45428509e-01f, 1.70023236e-02f, -1.32278381e-02f,
  2.75671538e-02f, 2.55354881e-01f, -1.16920315e-01f, 1.09666370e-01f, -4.59705442e-02f, -1.19953677e-01f, 2.49660522e-01f, 2.79092550e-01f, 1.04044944e-01f, -1.93243384e-01f,
  8.92646536e-02f, 1.10787153e-01f, 5.30589446e-02f, -2.07067534e-01f, -9.19393227e-02f, 9.26761255e-02f, 1.00131065e-01f, -6.88939169e-02f, -5.99366538e-02f, -8.31127986e-02f,
  -1.34214818e-01f, -1.34226859e-01f, -5.74429668e-02f, -4.45853919e-02f, 1.77658141e-01f, -2.99943443e-02f, -1.24438666e-01f, -7.81890377e-02f, 6.42400095e-03f, 8.09658840e-02f,
  4.26579028e-01f, 5.72471805e-02f, 8.12791362e-02f, 9.53181386e-02f, 9.06939581e-02f, -1.19531639e-02f, -2.80594587e-01f, -1.75919175e-01f, -1.14947349e-01f, 2.13725552e-01f,
  9.62218270e-02f, 1.81644619e-01f, -2.52295017e-01f, 1.74519401e-02f, -1.95668519e-01f, 1.91348299e-01f, 7.86904916e-02f, 1.98929176e-01f, 1.10508442e-01f, 1.40038460e-01f,
  1.33807674e-01f, 9.59562808e-02f, 9.52026844e-02f, 3.66738252e-02f, 2.12158963e-01f, 1.51169062e-01f, 1.02157310e-01f, 5.89451604e-02f, 1.30112424e-01f, -6.02706186e-02f,
  -1.08181126e-01f, 1.50406495e-01f, 1.68858021e-01f, -8.53160620e-02f, -5.82640618e-02f, -1.15097247e-01f, 2.21370205e-01f, 2.66074479e-01f, 1.17751829e-01f, -1.66932166e-01f,
  6.37315437e-02f, -1.73344582e-01f, 1.40310675e-01f, 2.94106007e-02f, -3.26148537e-03f, -9.31586027e-02f, 4.45497096e-01f, -5.36472313e-02f, 7.79360160e-02f, -1.23792946e-01f,
  3.40327062e-02f, 1.37527451e-01f, 1.04189150e-01f, -2.53050685e-01f, 1.83795214e-01f, -4.49159108e-02f, -4.36383158e-01f, 1.07860297e-01f, 3.15351635e-02f, -2.10670270e-02f,
  -1.00340366e-01f, -4.86625619e-02f, 2.74012357e-01f, 4.74401712e-02f, -1.39686942e-01f, -2.30008829e-02f, -1.21505149e-01f, 1.11533888e-01f, -3.18679869e-01f, 3.92618850e-02f,
  -1.91114053e-01f, -1.67410240e-01f, 2.26488695e-01f, 1.22180641e-01f, -3.96783687e-02f, 9.72110555e-02f, -7.78906494e-02f, 9.18857530e-02f, -2.39580825e-01f, 3.73309761e-01f,
  2.60917135e-02f, 6.66656950e-03f, -6.28901199e-02f, -1.24268472e-01f, -6.17633797e-02f, 4.00395952e-02f, -1.52975097e-01f, 2.64700688e-02f, -7.16586709e-02f, -2.37479769e-02f,
  -3.22475396e-02f, 2.08769869e-02f, 1.94358341e-02f, 5.17012551e-03f, 2.48070598e-01f, -1.08468950e-01f, -5.59017584e-02f, -3.07022240e-02f, 7.02618361e-02f, -1.13573998e-01f,
  6.53514937e-02f, -4.60976325e-02f, -3.19554478e-01f, -5.16491979e-02f, 1.05333984e-01f, -4.59405081e-03f, -7.04478621e-02f, 1.45257249e-01f, -9.03054625e-02f, 1.18163183e-01f,
  -1.90337852e-01f, -1.69229582e-01f, 1.63251366e-02f, 1.10644057e-01f, -6.02506548e-02f, 7.97259733e-02f, 2.65268892e-01f, 3.04109342e-02f, -1.63565442e-01f, 5.61858639e-02f,
  2.27832317e-01f, -2.12412670e-01f, -2.14495156e-02f, -3.12278569e-02f, -4.83395271e-02f, -2.06110358e-01f, 8.53570029e-02f, -1.33945361e-01f, 3.94047759e-02f, 1.60571992e-01f,
  5.96884713e-02f, -6.79307431e-02f, -1.57426726e-02f, 1.66090667e-01f, 2.01692075e-01f, 5.54667339e-02f, -1.19706616e-01f, 5.06887287e-02f, 2.73134969e-02f, -3.68364379e-02f,
  2.79696733e-01f, 1.74158692e-01f, 2.09180444e-01f, -1.02402270e-01f, 1.38954714e-01f, 4.77340221e-02f, 2.47740299e-02f, 1.24982953e-01f, 7.82020912e-02f, 1.84905350e-01f,
  2.39233784e-02f, 1.77210420e-01f, 1.50838926e-01f, 1.49603575e-01f, 1.39812395e-01f, -1.00678690e-02f, 2.18253225e-01f, 1.93891674e-01f, -2.20036134e-02f, -6.10806234e-02f,
  7.33955279e-02f, 7.61743039e-02f, -2.07031235e-01f, 2.76751574e-02f, -1.28160208e-01f, 1.36428401e-01f, -8.20372030e-02f, 2.53948011e-02f, 1.12839766e-01f, -3.50857638e-02f,
  1.90149099e-01f, 9.16017161e-04f, 4.66388725e-02f, 1.55438125e-01f, 1.91657946e-01f, 1.15574867e-01f, 1.48160443e-01f, 1.98748067e-01f, -6.07522167e-02f, 1.53135955e-01f,
  1.65952574e-02f, 2.08458286e-02f, -7.93611929e-02f, 1.17077008e-01f, 2.43334413e-01f, -8.80145282e-02f, 1.66688755e-01f, -1.76780701e-01f, -8.11906606e-02f, -1.55506715e-01f,
  -1.84356030e-02f, -7.14029297e-02f, -1.31718323e-01f, 3.86025198e-02f, -1.05817363e-01f, -1.39915481e-01f, -2.88651232e-02f, 2.22649187e-01f, -1.30892172e-03f, 1.20262019e-01f,
  2.26096846e-02f, -1.57749318e-02f, 1.89184342e-02f, 1.26341313e-01f, -1.27780661e-01f, -1.90201640e-01f, 7.82514215e-02f, -2.09898432e-03f, -3.53352278e-02f, -8.74360353e-02f,
  -3.50581259e-02f, 1.93679184e-02f, -8.80744681e-03f, -2.55841967e-02f, -1.10520363e-01f, -8.56700838e-02f, 1.30406693e-02f, -4.57286537e-02f, 3.35932896e-02f, -1.73384875e-01f,
  1.68796375e-01f, 1.84148952e-01f, 6.79572225e-02f, -1.18486583e-01f, 3.69963460e-02f, 2.14155644e-01f, -3.41251940e-02f, -5.76146841e-02f, 5.96294329e-02f, -6.26057340e-03f,
  -2.33078450e-01f, 1.27383649e-01f, 1.08432814e-01f, 1.51226595e-01f, 9.21703130e-02f, 3.67976725e-02f, 2.43462771e-02f, 2.84269433e-02f, -3.50553602e-01f, -2.54309118e-01f,
  -1.15595616e-01f, 1.17103286e-01f, -1.01375856e-01f, 1.44976556e-01f, 2.36440316e-01f, -4.44987603e-02f, -1.77830651e-01f, 1.22532755e-01f, 1.64505821e-02f, -2.58176774e-02f,
  4.22080047e-03f, -2.11618856e-01f, -1.97088331e-01f, -1.59398228e-01f, -9.44743454e-02f, -1.23595849e-01f, -6.77600056e-02f, -1.12474024e-01f, 6.21124581e-02f, -2.78041422e-01f,
  5.30745350e-02f, 9.17006060e-02f, 3.18233013e-01f, 1.60002634e-01f, -2.19085664e-01f, 2.66899616e-01f, 3.17964815e-02f, -5.19144088e-02f, -3.06671821e-02f, 2.74642259e-01f,
  6.96370155e-02f, 3.12462598e-02f, 1.74308226e-01f, 2.15556070e-01f, 1.25467062e-01f, 2.47016951e-01f, -7.09310174e-02f, 1.31039932e-01f, 2.60183383e-02f, 9.11686197e-02f,
  2.50145532e-02f, 3.93722318e-02f, 1.15719922e-01f, 9.61788185e-03f, -3.30505073e-01f, -2.64812052e-01f, -1.60445228e-01f, 9.82920900e-02f, -1.97265685e-01f, -8.63678530e-02f,
  -3.18974070e-02f, -1.86071187e-01f, 7.84418061e-02f, -2.57321119e-01f, -1.06610078e-03f, 1.40855297e-01f, 9.98350531e-02f, 2.01501876e-01f, -4.12415832e-01f, -5.88501729e-02f,
  -9.78936478e-02f, 4.09798548e-02f, -1.10412426e-01f, 7.39549473e-02f, 9.69038084e-02f, -7.67405853e-02f, -1.95174471e-01f, 2.64268696e-01f, -8.36557075e-02f, 1.66209400e-01f,
  -8.68022591e-02f, 1.54981807e-01f, 3.14443946e-01f, -1.49223447e-01f, 1.75024420e-02f, 3.12968165e-01f, 7.54997209e-02f, -1.71585903e-01f, 8.80795270e-02f, -2.05356270e-01f,
  4.29081023e-02f, 1.73137307e-01f, 2.14654341e-01f, -2.45842606e-01f, 3.48888189e-01f, 3.67160663e-02f, 2.07643002e-01f, 4.69226763e-02f, 6.19777851e-02f, -2.73947448e-01f,
  2.23064318e-01f, 8.46521277e-03f, 4.47004497e-01f, 3.18200737e-01f, 1.50034040e-01f, -3.58113796e-01f, 1.95828050e-01f, 1.18109711e-01f, 2.57593662e-01f, 2.62438692e-02f,
  -4.73710671e-02f, 1.82844475e-01f, 6.28872514e-02f, -4.44683013e-03f, 1.89338237e-01f, 5.69095090e-02f, 1.96225405e-01f, 1.33761495e-01f, -9.07798335e-02f, 7.19713047e-02f,
  -7.16956630e-02f, 7.37111866e-02f, 7.83902332e-02f, 1.10698819e-01f, -1.63001388e-01f, -2.75185257e-01f, 1.10850923e-01f, 4.33239900e-02f, 2.58414149e-01f, 4.81738970e-02f,
  2.02073101e-02f, -2.34250262e-01f, 9.08380747e-02f, -9.31539536e-02f, -5.81134856e-02f, -7.95283467e-02f, 5.85204102e-02f, 4.77290675e-02f, 2.36998424e-02f, -9.42256674e-02f,
  4.13848683e-02f, 1.64429799e-01f, 1.83730677e-01f, 3.22584867e-01f, -1.24915754e-02f, 5.33077167e-04f, 5.60535714e-02f, 1.06445059e-01f, -1.47718430e-01f, 1.67636201e-01f,
  8.16215724e-02f, 1.17812708e-01f, -1.10760115e-01f, 2.77854633e-02f, -1.04762383e-01f, 1.30121168e-02f, -8.81245881e-02f, 1.45172626e-02f, -2.44375259e-01f, -7.57645294e-02f,
  3.04769725e-01f, 1.40555218e-01f, -1.44223601e-01f, -2.21481070e-01f, 4.74196598e-02f, 1.67613983e-01f, -1.24760196e-01f, 2.44335234e-01f, -1.56777650e-01f, 2.43459880e-01f,
  1.20288849e-01f, -6.20006397e-02f, 3.29943709e-02f, 2.95823626e-02f, -1.21447116e-01f, 9.55982283e-02f, -2.29177281e-01f, 2.71382704e-02f, -3.01333051e-02f, 6.54861033e-02f,
  1.89752907e-01f, 5.65972691e-03f, 6.22223318e-02f, -7.14742951e-03f, -1.46793470e-01f, -3.28739807e-02f, -4.62073920e-04f, 9.37389359e-02f, -1.01160787e-01f, -1.41704530e-01f,
  1.86559781e-01f, -2.12226566e-02f, -4.39709350e-02f, 7.23212063e-02f, -1.59928098e-01f, -1.31080048e-02f, 2.19551757e-01f, -7.31783509e-02f, 2.33201385e-02f, 6.13593608e-02f,
  1.05533138e-01f, -9.59023014e-02f, -3.54420859e-03f, 1.87160745e-01f, -8.61753076e-02f, 3.08111191e-01f, 2.89433207e-02f, 8.94996747e-02f, -7.73464739e-02f, 2.13741928e-01f,
  -2.99680885e-02f, -1.38777867e-01f, 2.34409943e-02f, -5.34352921e-02f, 5.48724383e-02f, -1.80049613e-01f, 1.16255537e-01f, 3.12950946e-02f, -1.62428126e-01f, 2.45999515e-01f,
  -1.01258427e-01f, -7.01368824e-02f, -2.66085148e-01f, 1.86198354e-01f, 2.28839830e-01f, 1.13767467e-01f, 1.46166191e-01f, 2.97164589e-01f, -2.25879978e-02f, -2.53636483e-02f,
  -5.43670952e-02f, -1.17772810e-01f, 8.83447230e-02f, -8.80096853e-03f, 1.48431346e-01f, 2.11660266e-01f, 1.82623729e-01f, 2.47690275e-01f, 3.14787120e-01f, 2.81193286e-01f,
  3.33035171e-01f, 2.25248292e-01f, 1.55242741e-01f, 6.53409734e-02f, 2.56420553e-01f, 1.92937762e-01f, -3.41328979e-01f, -1.15564436e-01f, -1.72635689e-01f, 1.86536491e-01f,
  -1.63078144e-01f, -5.88240512e-02f, 1.56177774e-01f, 1.79116547e-01f, -6.65530339e-02f, -6.59388825e-02f, 2.90625878e-02f, -1.28555922e-02f, -2.67022103e-01f, 1.50833473e-01f,
  -8.37194398e-02f, 4.93472489e-03f, 9.07377824e-02f, 5.47549501e-02f, 4.26146984e-01f, 7.19999596e-02f, 5.10277860e-02f, 4.37243842e-02f, -3.81245226e-01f, 2.99809091e-02f,
  5.28362654e-02f, 4.32007797e-02f, 2.92461336e-01f, -1.26020629e-02f, -1.29257962e-01f, 7.84067735e-02f, 2.32887924e-01f, 3.42878550e-01f, 3.22922245e-02f, -2.63528991e-02f,
  1.10482581e-01f, -3.51816684e-01f, -1.34964362e-02f, -5.63618690e-02f, 1.25488611e-02f, 4.16452497e-01f, 1.18189482e-02f, -5.41691631e-02f, -2.44495258e-01f, 9.41448957e-02f,
  2.72479773e-01f, -2.63373256e-01f, -4.20032851e-02f, -2.14885369e-01f, -1.74106196e-01f, -2.93429494e-01f, -2.03474969e-01f, -2.49701977e-01f, 6.55426383e-02f, 1.22731388e-01f,
  1.32148266e-01f, 1.01463474e-01f, 1.98914796e-01f, 1.79290786e-01f, 1.36293694e-01f, 9.59719419e-02f, 5.60678029e-03f, 7.40067214e-02f, 2.21982718e-01f, 9.33476165e-02f,
  1.96223776e-03f, 1.59251139e-01f, -2.21510351e-01f, 6.40570894e-02f, -4.15017903e-02f, -1.06706291e-01f, -4.58827652e-02f, 5.11413403e-02f, -1.33719724e-02f, -2.54131313e-02f,
  3.43660325e-01f, -1.14239268e-01f, -4.13055792e-02f, 7.07223564e-02f, 9.66187194e-03f, -3.23279388e-02f, 2.63469107e-02f, -1.63057670e-01f, -2.73164630e-01f, -1.53607158e-02f,
  2.27596909e-01f, 1.17403362e-02f, -5.57095520e-02f, -7.29540288e-02f, -1.71016008e-01f, 1.59295946e-02f, 1.88116267e-01f, -1.28468320e-01f, -1.44014344e-01f, 8.21567699e-02f,
  -3.49333107e-01f, 6.02991804e-02f, -3.18163723e-01f, -1.04808370e-02f, -2.72859365e-01f, -7.19936639e-02f, 3.91173482e-01f, -3.12900871e-01f, 9.98582765e-02f, 1.78368017e-01f,
  6.31828653e-03f, -2.25993842e-01f, 2.77392119e-01f, -1.56023085e-01f, -2.70167291e-01f, -1.20900236e-01f, -5.94749302e-02f, 9.36179608e-02f, -2.07261935e-01f, 2.48203814e-01f,
  -1.72956139e-02f, -1.70037419e-01f, 2.98196763e-01f, 2.98899502e-01f, 6.34874254e-02f, 6.86702281e-02f, 1.48405641e-01f, 1.14126973e-01f, 2.68443763e-01f, 1.59635872e-01f,
  8.87106881e-02f, 1.67504907e-01f, 4.93910424e-02f, 1.44737750e-01f, -1.17819302e-01f, -1.03172980e-01f, 7.72277489e-02f, -1.31051347e-01f, -2.67061796e-02f, -1.15737051e-01f,
  1.32808849e-01f, 8.68910179e-02f, 3.66480798e-02f, -7.36163780e-02f, -2.69822508e-01f, 1.36075795e-01f, 2.96247691e-01f, 3.49244654e-01f, -9.67611745e-02f, -1.03488743e-01f,
  -3.85029130e-02f, -5.16925566e-02f, 3.19330573e-01f, -5.25839105e-02f, -5.39814010e-02f, 1.02274232e-01f, -9.18220356e-02f, -2.14316398e-01f, -2.84382522e-01f, -1.39192984e-01f,
  2.25380063e-01f, -1.12550698e-01f, 4.49081399e-02f, -6.55973181e-02f, 1.32333770e-01f, -1.63450703e-01f, -9.61313769e-02f, -1.49300750e-02f, -1.24177888e-01f, 5.50666489e-02f,
  2.32865259e-01f, 1.39663620e-02f, -4.87546399e-02f, 1.73050374e-01f, 1.54889569e-01f, 2.12553024e-01f, -7.40538165e-03f, -1.35421142e-01f, 9.13417637e-02f, -8.02036449e-02f,
  -3.38495001e-02f, -1.51327357e-01f, -1.06178135e-01f, 9.60099772e-02f, -2.78507397e-02f, -8.12701657e-02f, 1.93908378e-01f, 1.78329736e-01f, 2.45497391e-01f, 9.82036218e-02f,
  1.05615810e-01f, 1.81621820e-01f, 2.93919057e-01f, 1.68245181e-01f, 1.52634040e-01f, 8.29093531e-02f, 1.21898651e-01f, 1.32535368e-01f, -7.82041252e-02f, 1.28691839e-02f,
  3.42226699e-02f, 8.10360536e-03f, 9.31549445e-02f, 2.60202587e-03f, -3.74814570e-02f, 2.47841343e-01f, -1.62582472e-01f, 5.79630956e-02f, 5.89981154e-02f, -1.05973639e-01f,
  3.10883615e-02f, -3.57966721e-02f, -5.35416044e-02f, 6.99612722e-02f, 8.21745619e-02f, 7.66631812e-02f, 1.15968980e-01f, -8.60046893e-02f, -4.05625440e-02f, 7.31860027e-02f,
  -9.16454643e-02f, -7.15933889e-02f, 1.24567531e-01f, 1.74366683e-01f, 5.25723386e-04f, -6.55863360e-02f, 1.88075289e-01f, 1.35996789e-01f, 1.86881334e-01f, 1.60917431e-01f,
  1.08466923e-01f, 6.26191795e-02f, 1.17482126e-01f, -1.13102064e-01f, 4.60067950e-02f, 2.03325659e-01f, -1.61393993e-02f, -1.67668670e-01f, 2.14304626e-02f, -8.83534849e-02f,
  -3.48526746e-01f, -2.14266665e-02f, 1.91496581e-01f, 1.60109475e-02f, -5.20551503e-02f, 7.88821932e-03f, -2.38507241e-01f, -2.32151657e-01f, -4.77763712e-02f, 2.20561922e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.20968103e-01f, -1.44694196e-02f, -8.33539292e-02f, 2.85734564e-01f, 9.06672031e-02f, 8.45285729e-02f, 2.04126388e-01f, 1.22579642e-01f, 1.52563289e-01f, 5.40261678e-02f,
  2.02275306e-01f, 1.99186742e-01f, 1.61503181e-01f, 1.93400636e-01f, 8.55559483e-02f, -2.46681739e-03f, 2.09001839e-01f, 1.32133976e-01f, 1.43163696e-01f, 1.13140650e-01f,
  1.77130178e-01f, 1.88666750e-02f, 5.42602502e-02f, 1.82614289e-02f, 2.72241771e-01f, 2.55122453e-01f, 2.44225830e-01f, 1.24642290e-01f, 1.06306948e-01f, 1.53940991e-01f,
  -4.54660542e-02f, 1.81326389e-01f, 1.38131395e-01f, 1.60122126e-01f, 1.15361542e-01f, 5.87856537e-03f, 2.68673360e-01f, 1.72062501e-01f, 5.89230917e-02f, 1.31601363e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -3.78811359e-02f, -8.47278759e-02f, -1.39888655e-02f, -1.07664362e-01f, 1.61189124e-01f, -1.48397565e-01f, 9.05815810e-02f, -1.22664839e-01f, 3.35971862e-02f, -7.03179017e-02f,
  -6.43414035e-02f, 1.67378988e-02f, 2.63815876e-02f, -8.52382854e-02f, -2.92362049e-02f, 1.28590405e-01f, 4.55130637e-02f, 6.73923120e-02f, -1.84267849e-01f, 1.10554015e-02f,
  -1.36621282e-01f, -4.54684719e-02f, 6.44431859e-02f, 9.27954838e-02f, 1.44592654e-02f, -1.26691833e-01f, 1.48024544e-01f, 1.90357473e-02f, 3.13131586e-02f, 1.94138452e-01f,
  -6.38417294e-03f, 9.50239450e-02f, -1.17352948e-01f, 5.34018576e-02f, 4.86381873e-02f, -1.07421979e-01f, 2.84026116e-01f, -8.50720480e-02f, -7.60290325e-02f, 1.01487212e-01f,
  1.12441011e-01f, -3.42705287e-02f, -4.30080630e-02f, -1.00169457e-01f, -1.31378829e-01f, -1.08895920e-01f, -1.69032589e-01f, 1.41908199e-01f, -9.98038277e-02f, 4.36686873e-02f,
  -2.21874956e-02f, -4.89430735e-03f, 8.78402293e-02f, -1.98326245e-01f, 1.22674167e-01f, -8.47356692e-02f, -1.20325219e-02f, 1.37594193e-01f, -3.56436670e-02f, -2.50140987e-02f,
  7.11029535e-03f, -2.46201791e-02f, 4.48446199e-02f, -1.46663398e-01f, 2.78040078e-02f, 6.13016412e-02f, -5.05774245e-02f, 5.48165292e-02f, 6.37105927e-02f, 4.88895550e-03f,
  -4.34911996e-02f, -1.52784675e-01f, 6.30555674e-02f, -9.56829712e-02f, 1.02906324e-01f, -1.09016947e-01f, 1.15916431e-01f, 6.58282787e-02f, 7.73705244e-02f, -6.42986745e-02f,
  7.74516985e-02f, 6.36932999e-02f, -1.02742925e-01f, 1.14011846e-01f, 1.03275500e-01f, 1.99321508e-01f, -1.83637545e-01f, -2.97121909e-02f, -1.23072103e-01f, 1.72829404e-01f,
  -1.43478602e-01f, -7.33384490e-02f, 9.32057351e-02f, -1.78393319e-01f, -1.52971037e-03f, 3.57271098e-02f, -2.04553097e-01f, -1.29189258e-02f, 5.03558964e-02f, 9.28154960e-02f,
  -8.35433137e-03f, 8.61529559e-02f, -1.20631382e-01f, 2.90222876e-02f, -8.27428326e-02f, 4.17985581e-02f, -1.05807208e-01f, 7.87345916e-02f, -8.53905901e-02f, -3.46317030e-02f,
  -2.14381199e-02f, -1.22721888e-01f, -3.39034684e-02f, 1.53889954e-01f, -1.59140348e-01f, 1.38823688e-01f, -1.49077877e-01f, 1.46207944e-01f, -1.54870674e-01f, -9.37798843e-02f,
  -7.71834003e-03f, -2.64070332e-02f, 1.61040664e-01f, -1.33511856e-01f, 9.22497064e-02f, 4.28748131e-02f, -7.25183729e-03f, 8.04861709e-02f, 4.07188945e-02f, -7.96898901e-02f,
  -1.15269162e-01f, -1.78973094e-01f, -1.60508990e-01f, -2.35800762e-02f, -8.73008519e-02f, -1.21606432e-01f, -6.10583052e-02f, 5.93812950e-02f, -1.49411485e-01f, 7.50168338e-02f,
  -8.57060216e-03f, 1.90664858e-01f, -4.65689227e-02f, 4.50260863e-02f, 1.71534996e-03f, -9.05194785e-03f, 1.24616288e-01f, -1.12203501e-01f, -6.78972527e-03f, 2.78866588e-04f,
  -3.04182246e-02f, -5.61811440e-02f, -7.80253932e-02f, 1.54485866e-01f, -6.07621968e-02f, -6.83991760e-02f, 9.24725384e-02f, -2.39940807e-01f, -4.99813482e-02f, 7.87433237e-02f,
  -1.74829021e-01f, 1.50616214e-01f, -9.43935439e-02f, -3.69051844e-02f, -2.81142071e-03f, 9.73210633e-02f, -8.79188180e-02f, -4.81064059e-02f, 3.36699337e-02f, -1.14476524e-01f,
  -1.89258568e-02f, 5.56255914e-02f, 1.45502850e-01f, -6.34540021e-02f, 6.76447973e-02f, -4.64370064e-02f, 1.01140268e-01f, 7.13996068e-02f, 3.62298340e-02f, -1.79706495e-02f,
  -4.91211452e-02f, 1.05173215e-01f, 5.45368530e-02f, -1.60356462e-01f, -1.62386850e-01f, -2.07611263e-01f, 4.73593798e-04f, -1.41488209e-01f, 1.57293469e-01f, -1.39835387e-01f,
  1.92997362e-02f, 3.87092233e-02f, 1.01370461e-01f, -5.85466204e-03f, -5.43469973e-02f, 4.26837765e-02f, 1.81552321e-01f, -1.63812060e-02f, 7.08676726e-02f, 8.46771151e-02f,
  2.15634219e-02f, -5.94070069e-02f, -4.06368189e-02f, -9.87388417e-02f, -7.14575499e-02f, -4.05655168e-02f, -9.66001824e-02f, 1.51269019e-01f, 2.06515267e-01f, -5.05501293e-02f,
  -6.33487701e-02f, 5.45330793e-02f, -6.15034178e-02f, 5.16230129e-02f, 9.67241749e-02f, 1.00177296e-01f, 3.30844522e-02f, 9.04294923e-02f, -5.24270423e-02f, -1.97447255e-01f,
  -9.64027084e-03f, -7.64489919e-02f, 1.39537051e-01f, -2.03096401e-03f, -5.77426329e-02f, 1.99509203e-01f, -3.94692309e-02f, 7.33729675e-02f, 1.72255351e-03f, -5.42752258e-02f,
  -5.45786545e-02f, 1.24671850e-02f, -1.13079622e-01f, -3.38863358e-02f, -1.69120654e-01f, 2.80801989e-02f, 5.72670437e-02f, -1.07887730e-01f, -1.74688250e-01f, 3.40654254e-02f,
  1.25853390e-01f, 2.01291144e-02f, 1.17189456e-02f, 3.83381359e-02f, -4.05487902e-02f, -7.46762082e-02f, -1.28797352e-01f, -1.25023738e-01f, -6.82332814e-02f, 1.86192811e-01f,
  -9.14700795e-03f, 1.25013381e-01f, 9.04696807e-02f, -5.30311763e-02f, -9.83268097e-02f, 1.04518272e-01f, -7.95152634e-02f, 2.62653027e-02f, -1.25507206e-01f, -1.68022588e-01f,
  -2.58852355e-02f, 7.09232688e-03f, -4.25707139e-02f, -1.05462313e-01f, -1.16041653e-01f, -1.42223567e-01f, 8.69787633e-02f, -1.76809877e-02f, -2.10769668e-01f, 1.68591753e-01f,
  2.57283505e-02f, 1.40426323e-01f, -3.48278321e-02f, -6.26882017e-02f, -2.49359887e-02f, 4.40487862e-02f, 3.61421108e-01f, -3.13290283e-02f, 1.68861672e-01f, 3.20631601e-02f,
  8.16249847e-02f, 7.86826834e-02f, 1.96066409e-01f, -3.79178375e-02f, 1.20151967e-01f, -7.90101290e-03f, -2.09271491e-01f, 1.64427549e-01f, -4.99120094e-02f, 2.13750582e-02f,
  -1.94279291e-02f, -2.38369942e-01f, 5.48291951e-02f, 1.52321354e-01f, 2.26949733e-02f, 3.85573506e-02f, 4.88229580e-02f, -2.64858492e-02f, -6.98301941e-03f, -7.15624541e-02f,
  -1.85138494e-01f, -1.53816417e-01f, -1.04401320e-01f, 2.36616403e-01f, -9.61494371e-02f, -1.14515163e-01f, 1.70259550e-01f, -1.59153789e-01f, -9.54875797e-02f, -1.23522364e-01f,
  5.37758209e-02f, 1.28542393e-01f, 1.29538178e-01f, -2.07397163e-01f, 7.59190544e-02f, 6.35216758e-02f, -2.74491638e-01f, 1.90150321e-01f, 1.48043707e-02f, -1.40514355e-02f,
  -2.67366856e-01f, 3.09123825e-02f, -7.97028095e-02f, -6.69518933e-02f, -1.33133698e-02f, 1.10236377e-01f, -1.32703349e-01f, 4.60952297e-02f, 8.48025158e-02f, -2.48255786e-02f,
  1.75353661e-01f, -1.10857517e-01f, -2.38183327e-02f, -1.39572425e-02f, -3.65367159e-02f, -4.30994965e-02f, -1.51167184e-01f, 8.62198025e-02f, 9.17186886e-02f, -1.97170824e-01f,
  9.28789154e-02f, 6.91683218e-02f, 5.84059907e-03f, 9.93712470e-02f, 1.42546281e-01f, -2.19019741e-01f, 2.86976993e-01f, 1.09743662e-01f, 1.03888847e-01f, 1.47549763e-01f,
  -5.08926436e-02f, -1.23516582e-01f, -8.78234953e-02f, -3.35736096e-01f, -1.53345227e-01f, -1.19187169e-01f, -1.53617635e-01f, 3.00708469e-02f, 8.19852483e-03f, 9.15174466e-03f,
  1.28809184e-01f, 3.50033045e-02f, -6.67558089e-02f, -1.26620635e-01f, 6.26661330e-02f, -1.58167426e-02f, 6.50513396e-02f, -1.18488371e-01f, -2.01529432e-02f, 1.05788164e-01f,
  2.46920794e-01f, 9.77501944e-02f, 2.39103600e-01f, 5.08834049e-02f, 1.07055372e-02f, 2.38934252e-02f, 7.03029335e-02f, 1.65347874e-01f, 4.01639454e-02f, -3.85479741e-02f,
  -1.90732107e-01f, 1.20375842e-01f, 3.40243317e-02f, -2.08012238e-02f, -1.08677760e-01f, -1.76898867e-01f, -1.45881698e-01f, 1.71872839e-01f, 1.85746163e-01f, 1.20507749e-02f,
  5.92868822e-03f, -1.81459188e-01f, 9.13070068e-02f, 5.73735610e-02f, 1.33990765e-01f, -2.34399289e-02f, -4.73370515e-02f, 7.05982596e-02f, -2.91843325e-01f, 5.58680221e-02f,
  -4.96960655e-02f, 2.30882227e-01f, 1.55587241e-01f, -1.57700822e-01f, -7.44249597e-02f, 5.29803038e-02f, -4.17509973e-02f, -1.87910497e-01f, 1.81302249e-01f, -1.48282692e-01f,
  1.55737668e-01f, 1.11998752e-01f, 4.06040847e-02f, -5.24772145e-02f, 1.39388740e-01f, -1.90667193e-02f, -3.66368704e-03f, -8.54994282e-02f, -9.50527638e-02f, -8.98601487e-02f,
  7.88078383e-02f, 5.89079335e-02f, -1.91243023e-01f, 2.98312455e-01f, 1.28293559e-01f, -6.78143874e-02f, -3.24728005e-02f, -1.87840648e-02f, 1.17238499e-02f, -1.79988693e-03f,
  -6.52376488e-02f, -7.59973451e-02f, -1.06613368e-01f, -4.05752733e-02f, 7.97684863e-03f, 1.84016787e-02f, 1.14774220e-01f, -2.06505969e-01f, 3.72542404e-02f, 1.73445083e-02f,
  1.71282098e-01f, 1.52369529e-01f, -1.99659482e-01f, 8.30364600e-02f, -7.86530524e-02f, -7.00526908e-02f, -1.04998864e-01f, -1.41749203e-01f, -1.62657753e-01f, -1.20051667e-01f,
  -4.32314314e-02f, 1.59667119e-01f, 2.25593776e-01f, 1.39636472e-02f, 3.37568205e-03f, 2.41317153e-02f, -1.13007138e-02f, -5.16475402e-02f, -7.27169365e-02f, 9.75093397e-04f,
  -1.66980714e-01f, 1.34969102e-02f, -1.29355252e-01f, -7.77813792e-02f, -8.10911134e-02f, -4.76713671e-04f, 3.76266651e-02f, -1.45736709e-01f, -2.64599752e-02f, 2.21100915e-02f,
  3.52157205e-02f, 1.88016426e-02f, 1.80292845e-01f, -1.92676008e-01f, -2.88539603e-02f, 2.31437236e-02f, 3.98612097e-02f, 2.56265283e-01f, -5.74093163e-02f, 1.54983148e-01f,
  -7.05634132e-02f, -7.02647418e-02f, -1.75059676e-01f, -5.09357527e-02f, 5.47599196e-02f, 3.33325528e-02f, 9.28787068e-02f, -3.81238898e-03f, 1.32111562e-02f, -1.25558451e-01f,
  -1.78262830e-01f, 7.69208279e-03f, 7.78996348e-02f, -9.24372021e-03f, -1.04624055e-01f, 1.44473523e-01f, -1.27434492e-01f, -1.23809397e-01f, 3.83495390e-02f, -1.00621872e-01f,
  7.32606053e-02f, -3.08675487e-02f, -3.88438511e-03f, -4.49837931e-02f, 4.51114736e-02f, 1.00601710e-01f, 2.71961023e-03f, -4.96348664e-02f, 7.78170011e-04f, -1.62208490e-02f,
  -9.62887832e-04f, 1.56119987e-01f, 3.21763498e-03f, 3.94879803e-02f, 9.67530608e-02f, 6.18628450e-02f, -1.40996993e-01f, 2.30802130e-02f, 3.31301950e-02f, -2.84703337e-02f,
  -5.53129502e-02f, 1.30379274e-01f, -3.13091092e-02f, 4.53003384e-02f, -3.00465431e-02f, -1.81133851e-01f, 1.04285963e-01f, -1.64994597e-01f, -2.10343655e-02f, -2.69779172e-02f,
  8.66595134e-02f, 2.67157197e-01f, -4.84203212e-02f, 1.66888356e-01f, 4.76185977e-02f, -7.13858008e-02f, 3.73413041e-02f, 2.29831174e-01f, -1.94366232e-01f, 1.58705115e-01f,
  -1.89006016e-01f, -1.09147198e-01f, 8.77734944e-02f, -2.06984445e-01f, 1.56467855e-01f, -7.52372518e-02f, 1.51851490e-01f, -1.38655126e-01f, -1.39810264e-01f, 1.20019101e-01f,
  2.63906214e-02f, -1.73108771e-01f, -1.10576712e-02f, 1.29766613e-01f, -1.72442645e-01f, -1.33671328e-01f, 1.02424234e-01f, 2.46555116e-02f, 5.35327233e-02f, -1.28796294e-01f,
  -1.66254342e-02f, 2.30126772e-02f, -1.75824063e-03f, 2.80210581e-02f, -4.14506532e-02f, 2.57038057e-01f, 1.82142761e-02f, -3.30052450e-02f, 8.64777341e-02f, -7.01602697e-02f,
  -6.66460246e-02f, 1.40143037e-01f, -3.82848503e-03f, -5.44491671e-02f, -7.97577649e-02f, -1.54342636e-01f, 1.13254875e-01f, -6.27363380e-03f, -4.70940731e-02f, -1.18184112e-01f,
  -1.07344680e-01f, 5.74483946e-02f, 5.28261364e-02f, 1.62887156e-01f, -9.47581045e-03f, -1.15884587e-01f, 1.14520550e-01f, 6.07799478e-02f, -8.69645253e-02f, 1.48079991e-01f,
  1.98084891e-01f, -1.69985369e-01f, -6.63204119e-02f, -1.33858517e-01f, 1.07780077e-01f, -1.15466267e-01f, -7.45694935e-02f, 2.90991156e-03f, -9.39118639e-02f, -1.16892025e-01f,
  4.97829132e-02f, 1.66586444e-01f, -2.02050782e-03f, -3.34663615e-02f, 1.29097283e-01f, -1.88107580e-01f, -3.75465229e-02f, -1.18650056e-01f, 1.41185537e-01f, -4.40944079e-03f,
  -3.12902778e-02f, 1.15562096e-01f, -2.98269535e-03f, -7.43596628e-02f, 5.65553457e-02f, 7.81618953e-02f, 6.74031153e-02f, 1.21643402e-01f, 3.72347459e-02f, 9.00438055e-02f,
  1.14473753e-01f, 8.86489674e-02f, -5.95166497e-02f, -1.19436584e-01f, 7.67755648e-03f, -1.62455812e-01f, -1.56768471e-01f, -5.48777506e-02f, 6.57685027e-02f, 1.90986142e-01f,
  5.50454371e-02f, 1.25210151e-01f, -8.12239721e-02f, -7.97450766e-02f, -2.84680575e-02f, -4.97137420e-02f, 1.21368490e-01f, -1.10851064e-01f, 7.19078779e-02f, 1.92833282e-02f,
  6.88602030e-02f, 4.64799888e-02f, 4.34930250e-02f, -1.72243670e-01f, -1.99856982e-01f, -8.22558030e-02f, -9.69337970e-02f, -1.41672080e-03f, 4.40129340e-02f, 1.90082956e-02f,
  -1.36093080e-01f, 8.85158554e-02f, 1.02816179e-01f, -1.64689466e-01f, -1.40563045e-02f, -4.81614319e-04f, 7.59947067e-03f, 1.03158213e-01f, 3.03320065e-02f, 1.98569179e-01f,
  -5.85664846e-02f, -6.26438472e-04f, 6.92412630e-02f, 2.06605643e-02f, -7.23770857e-02f, -3.17926966e-02f, -5.11266142e-02f, 5.72998449e-02f, -1.26612196e-02f, -1.26352429e-01f,
  1.29426830e-02f, -3.87357920e-02f, -9.95685160e-02f, -2.41521403e-01f, 1.70902207e-01f, 4.29158844e-02f, -6.65969402e-02f, -4.46293503e-03f, -2.46278048e-02f, -6.28180131e-02f,
  -1.37451351e-01f, -9.32804942e-02f, -2.00300977e-01f, -1.34904861e-01f, -1.72606796e-01f, 2.26087607e-02f, 1.68036178e-01f, -7.62449130e-02f, -2.84358300e-02f, 1.23469695e-01f,
  2.08909303e-01f, 1.38555781e-03f, 1.95751429e-01f, -9.51535441e-03f, 4.19726819e-02f, -1.25446543e-01f, -2.13899966e-02f, -1.29796313e-02f, 6.39009103e-02f, 5.02881594e-02f,
  1.03422806e-01f, -3.13598961e-02f, 7.24658445e-02f, -7.41144344e-02f, 1.07483201e-01f, -1.30803198e-01f, -5.92596363e-03f, -6.79574385e-02f, 9.51117575e-02f, 8.93984362e-02f,
  -9.57814828e-02f, 7.68105080e-03f, 1.27975926e-01f, 1.36548683e-01f, -1.48592353e-01f, -5.06202802e-02f, 5.08906767e-02f, 7.88971484e-02f, -3.92254665e-02f, 2.22965434e-01f,
  1.34271830e-01f, 1.02371655e-01f, -1.81980491e-01f, -5.67996763e-02f, -1.84160605e-01f, 4.04433385e-02f, -1.45288751e-01f, -2.55445745e-02f, -7.67500140e-03f, 8.11897814e-02f,
  -1.68937922e-01f, -1.15415953e-01f, -1.45605937e-01f, -3.22507061e-02f, -4.11034860e-02f, 1.02284350e-01f, -3.59516479e-02f, 2.24914163e-01f, -4.65453565e-02f, 1.38803706e-01f,
  1.22627042e-01f, -5.86122461e-02f, -1.78334996e-01f, -1.61445048e-02f, -1.31281450e-01f, -1.15785599e-02f, 1.38502766e-03f, 8.67851079e-02f, 1.72876954e-01f, -5.07421754e-02f,
  -5.65288551e-02f, 1.28295064e-01f, 8.94318074e-02f, -4.69034612e-02f, -8.09011832e-02f, -1.22305721e-01f, 1.01262182e-02f, -1.34387568e-01f, -2.79730316e-02f, 7.82241747e-02f,
  -1.22824699e-01f, 1.09196059e-01f, -1.84002787e-01f, 4.99085225e-02f, 2.21741378e-01f, -1.69174209e-01f, -5.20331003e-02f, -1.54396966e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  5.40039390e-02f, -5.02732508e-02f, 1.60721242e-01f, 1.11952893e-01f, 1.26981467e-01f, 9.09761563e-02f, 1.27276376e-01f, 3.99634950e-02f, 2.48826042e-01f, 4.43120152e-01f,
  3.83496024e-02f, -1.25889510e-01f, -3.16485874e-02f, 2.90262133e-01f, -2.30458081e-01f, 1.41666114e-01f, 8.03262666e-02f, 2.67354734e-02f, 5.68402410e-02f, -5.73776960e-02f,
  2.49265246e-02f, 9.23985243e-02f, 3.23263742e-02f, -3.30068618e-02f, 2.58734554e-01f, -2.94593144e-02f, -6.91424534e-02f, -1.94295719e-01f, 2.33173698e-01f, -8.45977217e-02f,
  -1.32357880e-01f, 6.69290796e-02f, 1.81427464e-01f, 2.82306403e-01f, -5.75886331e-02f, -1.36768192e-01f, 3.26269686e-01f, 2.55625427e-01f, 1.78883359e-01f, 1.71912730e-01f,
  1.43814117e-01f, 8.34943820e-03f, -3.40041816e-02f, -1.56547055e-02f, 3.51356789e-02f, -1.00049697e-01f, -1.65373564e-01f, 1.48454756e-01f, -4.82907705e-02f, 1.58682138e-01f,
  -4.51940358e-01f, -1.73042789e-01f, -3.71375903e-02f, 5.80899864e-02f, 1.68892160e-01f, 1.74300164e-01f, 7.97697455e-02f, -8.37704539e-03f, -1.85784578e-01f, 2.47421637e-01f,
  1.19095668e-01f, -1.57756194e-01f, -5.77912331e-02f, 1.89214069e-02f, 1.47757575e-01f, 1.93988785e-01f, -6.90838322e-02f, 5.25574498e-02f, -5.55390008e-02f, 4.25917879e-02f,
  5.89643754e-02f, 1.68276861e-01f, 1.06326863e-01f, -2.94405222e-01f, -9.20089111e-02f, 2.68284827e-01f, -8.94743651e-02f, -3.30053046e-02f, 2.93212026e-01f, -1.75889745e-01f,
  -2.34988078e-01f, -3.17084342e-01f, -8.31445958e-03f, -2.47050658e-01f, -3.04431349e-01f, -1.28597319e-01f, 1.67320967e-01f, 1.19409636e-02f, 7.43714198e-02f, 8.37353319e-02f,
  -7.30687827e-02f, 1.26786545e-01f, 6.43133894e-02f, -1.25295833e-01f, 7.40673617e-02f, -9.48785543e-02f, 1.30643710e-01f, 2.36911684e-01f, -1.85585096e-01f, 1.69849783e-01f,
  1.00658700e-01f, -9.91114676e-02f, 2.57565789e-02f, 8.06739181e-02f, -2.94385906e-02f, 3.90223302e-02f, 2.00152159e-01f, 3.28754075e-02f, 2.94623137e-01f, 1.31385848e-01f,
  2.29589656e-01f, -1.51726469e-01f, 2.22420916e-01f, -1.32728174e-01f, 2.65210629e-01f, -6.33935258e-02f, 1.46363080e-01f, -1.75513588e-02f, -2.83876760e-03f, 1.47930041e-01f,
  -2.84591019e-01f, -6.06782511e-02f, 1.58819020e-01f, -7.80067742e-02f, 2.30975062e-01f, -3.26401412e-01f, 2.24275500e-01f, 1.98630705e-01f, -9.84542668e-02f, 1.97164994e-02f,
  4.95767444e-02f, -2.50197668e-02f, -1.84223011e-01f, -2.10718680e-02f, -3.40505899e-03f, 1.58476949e-01f, 4.35187183e-02f, -7.76493922e-02f, -2.27791116e-01f, 2.07534775e-01f,
  -1.47365928e-01f, -3.62357467e-01f, 3.21479216e-02f, 1.21010616e-02f, -1.03376433e-01f, -2.23672673e-01f, -1.64347736e-03f, -8.51164833e-02f, -7.30544776e-02f, -1.99501231e-01f,
  2.89516926e-01f, 7.81351179e-02f, 1.09677657e-01f, 2.11306497e-01f, 5.74779883e-02f, 8.10878351e-02f, 1.14852667e-01f, -9.43497941e-02f, 1.94003150e-01f, -2.66129412e-02f,
  6.73231110e-02f, 1.05871014e-01f, -3.64514560e-01f, 1.01205528e-01f, -4.48539257e-02f, 1.39085591e-01f, 1.89655628e-02f, -1.31178424e-02f, 1.86826602e-01f, -1.16666935e-01f,
  3.05450987e-02f, 1.30811602e-01f, 2.72547752e-01f, 1.66667268e-01f, 5.04503474e-02f, 3.89904529e-02f, 6.39987662e-02f, -1.58413947e-01f, 4.69200909e-01f, 2.77370904e-02f,
  3.04954022e-01f, 2.14349955e-01f, -8.48117769e-02f, -7.04446584e-02f, -1.20996185e-01f, -1.07326254e-01f, 1.26649484e-01f, -2.01842502e-01f, -1.75544340e-02f, -2.55996585e-01f,
  1.77585766e-01f, 2.26856753e-01f, 7.63443410e-02f, -5.18649668e-02f, -5.02060503e-02f, -1.74380675e-01f, -1.53526172e-01f, 4.79810126e-03f, -5.76002859e-02f, 1.30446211e-01f,
  -2.20206436e-02f, 8.90396461e-02f, -1.63070098e-01f, -1.18691511e-02f, 1.78434923e-01f, -1.80783063e-01f, 1.82742607e-02f, 4.70052026e-02f, 1.50096551e-01f, -7.22343102e-02f,
  -1.84321389e-01f, 7.96651989e-02f, -6.04411922e-02f, 4.29653041e-02f, -4.23541702e-02f, 7.46051669e-02f, -1.32372692e-01f, 2.66560167e-01f, -8.88712481e-02f, -1.86167974e-02f,
  -5.60817868e-02f, -3.29868533e-02f, 1.95333481e-01f, -1.03429787e-01f, -1.75803244e-01f, 1.52079403e-01f, -2.05906600e-01f, 1.27565945e-02f, -1.87635154e-01f, 2.67838431e-03f,
  -3.67147364e-02f, 8.01113173e-02f, -1.97089627e-01f, -5.39396740e-02f, -1.52066290e-01f, -3.40442620e-02f, 1.94474220e-01f, 6.55205324e-02f, 7.01059550e-02f, 5.09156249e-02f,
  1.28917992e-01f, 1.38347149e-01f, 1.41767725e-01f, 2.34230116e-01f, -3.88098732e-02f, 5.40375225e-02f, 1.08155794e-01f, -1.66723266e-01f, -3.78359295e-02f, 1.56960145e-01f,
  -2.07461387e-01f, -7.68170208e-02f, 2.06958100e-01f, -1.67561665e-01f, -5.39789498e-02f, -4.74893972e-02f, 2.84947187e-01f, -5.25071286e-02f, 1.12476707e-01f, 4.10068296e-02f,
  4.11007442e-02f, 3.75826582e-02f, 1.32093191e-01f, 6.64475262e-02f, 3.61009091e-02f, -1.32286742e-01f, -2.08532140e-01f, 7.91208446e-03f, 3.53659652e-02f, 4.84482832e-02f,
  4.97110561e-02f, -1.37843311e-01f, 1.80604905e-01f, 2.33091973e-02f, -1.91461563e-01f, -1.22254327e-01f, -4.02306259e-01f, -1.73369702e-02f, -1.45192966e-01f, 1.68923929e-01f,
  2.16560513e-01f, 4.92257141e-02f, -1.61954649e-02f, 6.06028400e-02f, -7.53218215e-03f, -2.01496412e-03f, 4.52964962e-01f, -3.95715758e-02f, -1.56619865e-02f, 3.29521179e-01f,
  -1.73242703e-01f, 1.05026670e-01f, 1.03331901e-01f, -2.07220718e-01f, -7.93975592e-02f, -8.92627016e-02f, -6.12507164e-02f, 6.41753748e-02f, -8.97153616e-02f, -5.10378517e-02f,
  2.10407913e-01f, 3.99386764e-01f, -1.27992198e-01f, -3.38072442e-02f, 1.78928971e-01f, 7.51697123e-02f, 2.33353242e-01f, 2.20075071e-01f, 2.09477216e-01f, -1.40888885e-01f,
  3.83019857e-02f, 8.48839898e-03f, -1.95945218e-01f, 2.39554882e-01f, -2.66208202e-01f, -1.48589209e-01f, 2.99580097e-01f, 5.31070456e-02f, 2.51587093e-01f, 1.09884739e-01f,
  1.73875511e-01f, 2.56450623e-01f, 6.58938885e-02f, 2.32259244e-01f, 1.44206956e-01f, 1.60468176e-01f, 3.82365137e-02f, 2.73875326e-01f, 1.56457558e-01f, -5.66779114e-02f,
  -1.07502211e-02f, 1.88071415e-01f, -7.69598261e-02f, -2.25292761e-02f, 1.90901920e-01f, -1.28805786e-01f, -2.80271530e-01f, 7.78555684e-03f, 2.30482548e-01f, -5.58490269e-02f,
  -1.61964670e-01f, 2.27877423e-01f, -1.44349724e-01f, -1.91035315e-01f, 1.51448622e-01f, -2.25147560e-01f, -1.47206232e-01f, 3.22283179e-01f, -7.51043633e-02f, -7.06651732e-02f,
  -7.35583436e-03f, -1.71601743e-01f, 4.48279560e-01f, 7.50443190e-02f, 1.87182829e-01f, 2.70143539e-01f, 1.22056462e-01f, -6.08375892e-02f, -4.04230803e-02f, 3.88630778e-02f,
  1.40714630e-01f, 1.52066633e-01f, 2.23507404e-01f, 5.89380190e-02f, 1.18418239e-01f, 6.03544824e-02f, 1.49053738e-01f, -2.98246592e-01f, 3.06387573e-01f, -3.42272371e-01f,
  7.87968710e-02f, -6.04869239e-02f, -2.11175844e-01f, -2.48153117e-02f, -1.00079924e-02f, 2.36388907e-01f, -3.63073719e-04f, 1.29657298e-01f, 3.30347210e-01f, -1.71335805e-02f,
  1.94213137e-01f, -1.80940226e-01f, 9.28965807e-02f, 1.39802456e-01f, 2.08228931e-01f, 2.40735844e-01f, 1.48064688e-01f, 2.82431394e-01f, 9.98655111e-02f, 1.20997600e-01f,
  2.88179696e-01f, 2.79886127e-01f, 7.15836138e-02f, -1.37398601e-01f, 4.73932885e-02f, 1.85925290e-02f, -1.11249946e-01f, 8.16819444e-02f, 1.66573286e-01f, -1.25682622e-01f,
  -1.10078990e-01f, -2.44503424e-01f, -4.63431366e-02f, -3.90187502e-01f, -1.99113131e-01f, -4.13906664e-01f, -8.21377411e-02f, -3.45632108e-03f, 7.79302195e-02f, -1.79909363e-01f,
  3.03491950e-02f, 9.36864614e-02f, 1.79759488e-01f, 1.43998593e-01f, 1.16496339e-01f, 1.13896661e-01f, 5.30563586e-04f, -4.64023165e-02f, -2.44812310e-01f, 1.11975104e-01f,
  -2.50205025e-02f, 1.64711758e-01f, 1.83664337e-01f, -1.16080232e-01f, 2.13175818e-01f, 2.01418132e-01f, 6.82684258e-02f, 1.87092602e-01f, 1.68553725e-01f, 3.69130760e-01f,
  -1.96702585e-01f, -1.32201716e-01f, 3.30588855e-02f, -4.10392098e-02f, 1.09447911e-01f, -5.13694957e-02f, 2.42712781e-01f, -2.17433661e-01f, -7.63732269e-02f, 5.19782975e-02f,
  -1.48943856e-01f, -2.05142368e-02f, 5.67150116e-03f, 9.41706970e-02f, 9.17358324e-02f, 2.27978081e-01f, 9.21393111e-02f, 2.49790624e-01f, -2.10134331e-02f, 4.69707325e-02f,
  1.39113769e-01f, 5.12253307e-02f, 4.09637988e-02f, 3.24388966e-02f, 1.18554384e-01f, -7.96782225e-02f, 1.51674181e-01f, 9.55691561e-02f, 2.99264472e-02f, 2.17762724e-01f,
  2.40445137e-03f, 7.62533620e-02f, -3.08665335e-01f, -2.91132405e-02f, -7.07522081e-03f, 2.59393364e-01f, 2.33544990e-01f, 2.54978240e-01f, -2.26843692e-02f, 3.43409032e-01f,
  -1.46871150e-01f, -4.57031913e-02f, 5.95891960e-02f, -1.69744581e-01f, 6.32489622e-02f, 2.19622582e-01f, 1.77196935e-02f, 3.10332835e-01f, 1.27796784e-01f, -1.43667221e-01f,
  2.00389042e-01f, 7.35732093e-02f, 2.91420966e-01f, -8.29406269e-03f, 2.28299767e-01f, 1.68598160e-01f, -4.17418443e-02f, 1.37782931e-01f, -3.85447145e-02f, 1.04282051e-01f,
  1.36874124e-01f, -2.67768890e-01f, -2.31019959e-01f, -1.95103645e-01f, -2.40012947e-02f, 5.85658150e-03f, -9.45485309e-02f, 3.89488131e-01f, -1.75433576e-01f, 2.12318003e-01f,
  -1.53219283e-01f, -1.08498402e-01f, 8.06470141e-02f, 3.67553346e-02f, 2.34787390e-01f, 3.34907800e-01f, 1.06916226e-01f, 6.31549582e-02f, 1.11532949e-01f, 1.34653568e-01f,
  7.79782832e-02f, -2.44139090e-01f, 8.01135823e-02f, 2.25191358e-02f, 1.71293825e-01f, 8.53835344e-02f, -2.66432855e-02f, -4.69104052e-02f, 2.11502224e-01f, 1.63283199e-01f,
  1.22775741e-01f, 1.77989319e-01f, 1.45632662e-02f, -1.47078067e-01f, 3.25826928e-02f, -1.02561370e-01f, -1.72231629e-01f, 1.93283156e-01f, 1.76161692e-01f, -1.16889283e-01f,
  -1.09264761e-01f, 7.81496149e-03f, 6.58796653e-02f, -9.75024551e-02f, -3.35155010e-01f, 3.27576846e-01f, -1.47503391e-01f, -5.48853949e-02f, -9.88446474e-02f, 1.59381405e-01f,
  -2.21736014e-01f, 3.21885496e-01f, 1.77866876e-01f, 2.02910706e-01f, -3.41830969e-01f, -6.14579534e-03f, -1.89908609e-01f, 1.30063564e-01f, -1.00771941e-01f, -5.56778945e-02f,
  8.48957598e-02f, 2.82767773e-01f, -7.67440796e-02f, -2.42551208e-01f, -1.06529072e-01f, 1.41362995e-01f, 1.22881532e-01f, 1.08271413e-01f, -1.53348282e-01f, 2.28003636e-01f,
  1.86925337e-01f, 5.50485291e-02f, 1.79641083e-01f, 1.38233125e-01f, -8.23273957e-02f, -2.38614902e-01f, -9.62042660e-02f, -5.25698364e-02f, -1.30639493e-01f, 2.09349096e-01f,
  -1.15489988e-02f, -3.11915964e-01f, 5.11393771e-02f, 3.13195854e-01f, -2.55439039e-02f, 1.24486662e-01f, 1.89584062e-01f, 2.14385912e-01f, 1.52370721e-01f, -1.18325856e-02f,
  1.22799287e-02f, 5.25314026e-02f, 1.12080559e-01f, -2.50249542e-03f, 6.73322901e-02f, -1.53353659e-03f, 8.13960582e-02f, 8.23582523e-03f, 1.66175425e-01f, -1.43706903e-01f,
  6.48078993e-02f, 8.60010535e-02f, 8.67824405e-02f, 3.50878537e-02f, 1.81922168e-02f, 2.65625656e-01f, 3.19931190e-03f, 9.02193934e-02f, -3.08142066e-01f, 1.46178782e-01f,
  -1.73850283e-01f, 3.54282230e-01f, -6.30212948e-02f, 1.23311877e-01f, 4.74606305e-02f, -1.42809570e-01f, -3.77664976e-02f, -2.30630577e-01f, -3.00988927e-02f, 2.64509410e-01f,
  3.36370409e-01f, 2.12709486e-01f, -1.90267473e-01f, 1.22223601e-01f, -1.39987037e-01f, -1.46933511e-01f, -2.30701178e-01f, 8.64145309e-02f, 1.61711961e-01f, 1.31365359e-01f,
  2.73990049e-03f, -3.46438549e-02f, 1.52769417e-01f, 1.68813218e-03f, 8.12526718e-02f, 1.48601741e-01f, -1.04480147e-01f, 1.12884670e-01f, -2.60660022e-01f, 1.33539200e-01f,
  9.71052945e-02f, -3.38544734e-02f, 6.29910454e-02f, 4.84448150e-02f, 4.46632877e-02f, 1.58842057e-01f, 2.78341442e-01f, 1.05331622e-01f, -1.49489954e-01f, -3.79108079e-02f,
  4.71715517e-02f, 3.77162769e-02f, 1.70228124e-01f, 3.70485187e-02f, 1.43692255e-01f, 1.47898197e-01f, 7.54125565e-02f, 5.09819724e-02f, 2.56386120e-02f, 2.26163745e-01f,
  1.18853962e-02f, -9.49658528e-02f, 1.00404851e-01f, 4.59749345e-03f, -2.25255296e-01f, 2.25748435e-01f, 9.78967473e-02f, 2.04831995e-02f, 1.05071664e-01f, 9.83963832e-02f,
  -8.57986063e-02f, -1.10054128e-01f, 1.90961972e-01f, 1.22687496e-01f, 1.53469607e-01f, 1.46275252e-01f, -9.26851183e-02f, -2.63461709e-01f, -3.58336307e-02f, 7.06227645e-02f,
  2.07870647e-01f, -5.52476011e-02f, -2.34765694e-01f, 2.07095772e-01f, -9.68240127e-02f, -9.05759111e-02f, 9.32600275e-02f, 2.61423856e-01f, 8.60186890e-02f, -2.11022630e-01f,
  1.94281474e-01f, -1.35761902e-01f, -3.44130620e-02f, -1.57410532e-01f, 6.86337724e-02f, 3.63121741e-02f, 1.53604701e-01f, 6.23018034e-02f, 9.24490299e-03f, 3.48419517e-01f,
  4.66320068e-02f, 1.69497222e-01f, 1.38515681e-01f, 4.11711723e-01f, -1.59547880e-01f, 1.47506788e-01f, 4.26452830e-02f, -2.20291927e-01f, -3.99991199e-02f, 2.88932826e-02f,
  2.03243628e-01f, 2.37700999e-01f, -1.11832647e-02f, 6.22558221e-03f, -3.35203409e-01f, 3.93097624e-02f, 1.31730825e-01f, -2.46220939e-02f, 7.06383772e-03f, 2.46148370e-02f,
  -3.42750102e-02f, -4.38614823e-02f, -3.47562358e-02f, 2.38542289e-01f, 2.15542153e-01f, -3.90668750e-01f, 9.18318331e-02f, 9.17649865e-02f, 1.65016111e-02f, -3.61907706e-02f,
  -1.23216696e-01f, 6.46504387e-03f, -2.38523912e-02f, 3.47965769e-02f, 3.47542346e-01f, -1.98283002e-01f, 1.87015623e-01f, 9.38616470e-02f, -3.02927997e-02f, 2.42986873e-01f,
  2.45330423e-01f, -1.00588284e-01f, 2.48025164e-01f, 4.14706245e-02f, -2.68509418e-01f, 1.45094603e-01f, -8.91845822e-02f, -1.88112721e-01f, -6.20184205e-02f, 5.39607601e-03f,
  -4.37645018e-02f, 3.15279990e-01f, 2.33666629e-01f, 7.98850060e-02f, 2.73189276e-01f, 2.68645901e-02f, 6.37410581e-02f, 2.99847960e-01f, 1.12387568e-01f, -5.92709519e-02f,
  -4.92719226e-02f, 3.58946882e-02f, 1.35018259e-01f, 1.53444096e-01f, -4.81285341e-02f, -9.57268178e-02f, -1.45238042e-02f, 3.39398682e-01f, 9.87392589e-02f, 2.03688279e-01f,
  6.22808263e-02f, -2.60842055e-01f, 2.35177532e-01f, 1.08348988e-01f, -2.22622320e-01f, -4.59407903e-02f, -1.68229327e-01f, 1.39642999e-01f, 5.48923835e-02f, -5.81572093e-02f,
  4.91211675e-02f, 1.17422091e-02f, 1.36453316e-01f, 1.42330617e-01f, -1.06661253e-01f, 6.92644268e-02f, 4.28636409e-02f, 6.62269294e-02f, -5.35945147e-02f, 1.77242175e-01f,
  -9.14596543e-02f, 9.42088217e-02f, -2.66589667e-03f, 1.51720583e-01f, -9.31444615e-02f, 1.38158873e-01f, 4.00083587e-02f, -1.04950130e-01f, 8.57926384e-02f, 2.12808356e-01f,
  1.23159200e-01f, -1.70220062e-01f, 6.09146021e-02f, 2.66559236e-03f, -6.19464368e-02f, 2.51802653e-01f, 1.19765602e-01f, -2.03987025e-02f, 1.05652191e-01f, -7.67696351e-02f,
  2.75351822e-01f, 2.46567696e-01f, 4.69072610e-02f, 2.61308283e-01f, 2.53191471e-01f, 2.08694026e-01f, -8.99554342e-02f, 1.31137893e-01f, 1.52310252e-01f, 1.27693817e-01f,
  3.68909985e-01f, 1.85341313e-01f, 1.14997469e-01f, -3.46139371e-01f, -9.68827307e-03f, -2.89414853e-01f, 2.72323221e-01f, -3.13004941e-01f, 1.37251271e-02f, -1.11098245e-01f,
  -9.26420614e-02f, 2.56953705e-02f, 6.67141080e-02f, 3.46804708e-02f, 3.82371061e-02f, -1.51688391e-02f, 2.09241688e-01f, 2.01592326e-01f, 1.58274397e-01f, -2.27844000e-01f,
  -1.47579700e-01f, -8.67298990e-03f, -3.15699764e-02f, -8.44016299e-02f, 8.10918435e-02f, -7.59882405e-02f, -1.76886097e-01f, 2.28753798e-02f, 1.15347378e-01f, 1.94311403e-02f,
  1.28502265e-01f, -1.23618454e-01f, -2.65763402e-01f, 2.76302636e-01f, -1.63869150e-02f, -3.63443553e-01f, 1.46775737e-01f, -1.26491502e-01f, -2.48976629e-02f, -3.01299337e-02f,
  -3.59566696e-02f, 1.20704167e-01f, 1.07924286e-02f, -2.75419671e-02f, 4.35096845e-02f, 1.28654838e-01f, 2.19453610e-02f, 7.78340250e-02f, 1.17848761e-01f, 3.50251287e-01f,
  -1.72531545e-01f, -1.27797872e-02f, 1.25141814e-01f, -9.01046321e-02f, -2.67053787e-02f, -7.64332805e-03f, -1.31058961e-01f, -1.66833512e-02f, -3.15303922e-01f, -1.37782723e-01f,
  -8.18751678e-02f, 1.38056397e-01f, 1.36648342e-01f, 7.97178075e-02f, -7.61506408e-02f, -1.83698460e-01f, 1.42130911e-01f, 1.99518934e-01f, 1.51641602e-02f, 6.23626076e-02f,
  1.70066208e-01f, -1.74360663e-01f, 4.43176895e-01f, 2.19147522e-02f, 1.11417562e-01f, 1.18500859e-01f, 1.70707911e-01f, 3.14630009e-02f, 8.03646818e-02f, 2.59835392e-01f,
  1.45618558e-01f, -1.36305332e-01f, -5.75321130e-02f, -2.20044702e-01f, -6.16843887e-02f, 1.17945917e-01f, 1.21962622e-01f, 3.82025465e-02f, 3.09892949e-02f, 7.68985748e-02f,
  -1.20084979e-01f, 1.65578261e-01f, -1.97064434e-03f, 5.66129275e-02f, 1.82366788e-01f, 4.40879166e-02f, 1.41554698e-02f, -5.96568361e-03f, 1.57270841e-02f, -1.13465272e-01f,
  -1.07161840e-02f, -9.49488878e-02f, -8.29799920e-02f, 7.15489592e-03f, 8.38060975e-02f, 2.66921967e-01f, 1.62215754e-01f, 1.62447169e-01f, -1.19832627e-01f, -1.30891263e-01f,
  1.44712001e-01f, -3.48362297e-01f, -5.66882119e-02f, 1.61445022e-01f, -6.50051907e-02f, 2.86906809e-01f, 1.61535814e-01f, -2.36312985e-01f, 3.93572450e-01f, -1.80598632e-01f,
  3.26921195e-01f, 9.89518464e-02f, 1.63236801e-02f, -1.47078291e-01f, -1.14975177e-01f, -1.74266305e-02f, 7.54746199e-02f, 3.41389865e-01f, 1.09176204e-01f, -2.41978951e-02f,
  -1.61910191e-01f, 1.94053613e-02f, -2.94748008e-01f, 3.56579684e-02f, 1.91441506e-01f, -6.20965250e-02f, 1.49592668e-01f, 3.72961946e-02f, -1.45593882e-01f, -6.76023960e-02f,
  2.60445237e-01f, 1.77389801e-01f, 1.05379418e-01f, 5.06296396e-01f, -6.90640137e-02f, 1.87962145e-01f, -1.20836534e-01f, -1.96691424e-01f, 5.50763719e-02f, -1.57778054e-01f,
  2.86207587e-01f, 7.57635832e-02f, 6.63718507e-02f, 1.76796347e-01f, 9.15380940e-02f, 9.75246429e-02f, 2.29027092e-01f, 1.38674993e-02f, 1.42591551e-01f, 2.14798227e-02f,
  -1.50472537e-01f, 2.16565967e-01f, 1.42508879e-01f, 1.01980522e-01f, -1.93845779e-01f, -4.88048010e-02f, 7.04028234e-02f, 1.45434633e-01f, 1.01462580e-01f, -1.46258026e-01f,
  -3.80878061e-01f, 1.58105835e-01f, 6.03839345e-02f, 9.50508267e-02f, 1.24152470e-02f, -3.55994314e-01f, -3.13724160e-01f, -3.91756892e-02f, -1.63340211e-01f, 1.36937544e-01f,
  2.95400679e-01f, 2.47669499e-02f, 2.40615532e-01f, 2.84545690e-01f, 1.21182829e-01f, -1.64886117e-01f, 1.99472100e-01f, -1.99400887e-01f, -6.42183647e-02f, -1.25710145e-01f,
  6.47626817e-02f, 1.35614574e-01f, 3.66870873e-02f, -3.51605505e-01f, 1.67567119e-01f, 1.72556236e-01f, 9.42914002e-03f, -7.64952525e-02f, -1.25300139e-01f, 1.81372195e-01f,
  1.16853215e-01f, -7.44604468e-02f, 1.32609412e-01f, 2.90758498e-02f, -9.52193439e-02f, 1.00042358e-01f, -1.55995116e-02f, 4.17492658e-01f, -1.91621706e-01f, -1.19854279e-01f,
  3.57226163e-01f, 9.42591876e-02f, 3.63001853e-01f, 3.07221394e-02f, 1.87605321e-01f, 1.31786093e-01f, 5.84104694e-02f, 9.22033489e-02f, 3.71720672e-01f, 8.81777331e-02f,
  5.35605289e-02f, 1.71774119e-01f, 1.29553929e-01f, 3.03307265e-01f, 2.05981329e-01f, -1.47250816e-01f, -3.06890495e-02f, 2.26517126e-01f, 8.57017711e-02f, 3.14964503e-01f,
  1.57681018e-01f, -2.34824926e-01f, 4.30699885e-02f, 1.29025340e-01f, 7.17882533e-03f, 6.91067800e-02f, 2.24185795e-01f, -9.84184816e-03f, 8.31097364e-02f, 4.22672600e-01f,
  -1.23360075e-01f, 3.21288072e-02f, 1.10880025e-01f, -1.95696846e-01f, 3.08237728e-02f, 2.77360529e-01f, -1.16018616e-02f, 5.22361815e-01f, 5.43284900e-02f, 1.35608807e-01f,
  2.14688499e-02f, 3.60153288e-01f, -1.04075328e-01f, 1.20116368e-01f, 2.08265819e-02f, 1.94471013e-02f, 1.59376729e-02f, 3.86846900e-01f, 2.95292795e-01f, -2.37599701e-01f,
  2.85713673e-01f, 4.58783880e-02f, 2.53096908e-01f, 2.98165437e-02f, -2.54659086e-01f, -6.84007183e-02f, -3.22752185e-02f, 4.17470634e-01f, -2.59241700e-01f, 1.25612274e-01f,
  -2.27999970e-01f, -1.56456053e-01f, 1.18602350e-01f, 4.51758578e-02f, 4.14975613e-01f, -2.41345674e-01f, 5.56661300e-02f, 1.88955545e-01f, 8.91015604e-02f, -6.52816892e-02f,
  1.18537722e-02f, 4.24272120e-02f, 7.83041716e-02f, 1.07714273e-01f, 1.08137980e-01f, 5.65166883e-02f, 2.70619597e-02f, -5.39986826e-02f, -7.01826345e-03f, 2.26428345e-01f,
  -4.04028334e-02f, 1.85574219e-01f, 1.46091087e-02f, 1.54592678e-01f, 2.43116975e-01f, -4.56448235e-02f, 7.08601996e-02f, -4.22398467e-03f, -3.80182117e-01f, 2.45899066e-01f,
  -7.32048973e-02f, 6.02562316e-02f, 1.36151463e-02f, 2.97193706e-01f, 2.13795658e-02f, -3.23912762e-02f, 6.53424785e-02f, -3.15919429e-01f, 2.74486393e-01f, 1.29421890e-01f,
  -2.19688997e-01f, 5.08984864e-01f, -3.17606509e-01f, -5.73673882e-02f, 2.05472127e-01f, 6.57474473e-02f, -1.49419218e-01f, -3.58050652e-02f, 2.49209907e-03f, -1.38173357e-01f,
  2.91175783e-01f, 2.06166521e-01f, 2.90187538e-01f, -1.66077435e-01f, 1.41617090e-01f, 2.82637812e-02f, -3.53798121e-02f, -7.80562982e-02f, -2.81432010e-02f, -1.43391877e-01f,
  5.72506115e-02f, 1.49598777e-01f, -2.63156742e-01f, -2.57160030e-02f, -7.20802397e-02f, -9.81819928e-02f, -5.89548089e-02f, -1.59827262e-01f, 3.40376794e-01f, -1.90565780e-01f,
  2.37123966e-02f, 2.86508501e-01f, -1.47829270e-02f, 2.22374752e-01f, 6.41731843e-02f, -4.41610441e-03f, -6.77855760e-02f, -2.46195700e-02f, -8.37443583e-03f, -1.58232134e-02f,
  6.13915734e-02f, -1.87560126e-01f, -4.34858812e-04f, 2.12972909e-01f, 2.15877533e-01f, -1.93179160e-01f, 1.60217568e-01f, 1.75608888e-01f, -1.56214992e-02f, 2.49195062e-02f,
  -5.28467000e-02f, 1.79056078e-01f, 9.13950130e-02f, 3.98002304e-02f, -1.27659272e-02f, 8.72513950e-02f, -1.32348746e-01f, 2.89773852e-01f, 1.75375074e-01f, 1.54045910e-01f,
  6.49421290e-02f, -1.77869499e-01f, 1.32307187e-01f, -8.89810249e-02f, -1.53856307e-01f, 1.88813373e-01f, -2.76200604e-02f, 1.14942655e-01f, -7.79580474e-02f, 1.64724112e-01f,
  -1.38487116e-01f, -5.23627794e-04f, -6.30084947e-02f, -2.36660928e-01f, 1.38086349e-01f, 1.58889174e-01f, 1.32585363e-02f, 2.24716645e-02f, 3.57159287e-01f, -1.14256762e-01f,
  3.72143686e-02f, 2.15196311e-01f, 2.73079365e-01f, 6.04699552e-02f, 9.22324359e-02f, 1.66715786e-01f, -1.61105856e-01f, -1.01916619e-01f, 6.28618672e-02f, -2.57435888e-01f,
  2.04585627e-01f, -3.23333979e-01f, 2.19259143e-01f, 4.39789183e-02f, -2.47917548e-02f, 2.66209692e-01f, -1.16132960e-01f, 1.11517191e-01f, -1.13244532e-02f, 1.25722975e-01f,
  -2.00866893e-01f, -1.06457174e-01f, -3.88748050e-02f, -9.30818319e-02f, 8.06238949e-02f, 1.98688403e-01f, 2.10436985e-01f, 4.84708510e-02f, -1.44977033e-01f, 8.87092054e-02f,
  -3.43697518e-02f, -3.43438655e-01f, -1.91042215e-01f, 1.66798577e-01f, 1.59735560e-01f, -6.89662993e-02f, 2.12910384e-01f, 2.71465667e-02f, -3.24452996e-01f, 1.11586256e-02f,
  1.36307478e-01f, -2.23694071e-01f, 2.72616535e-01f, 2.01706558e-01f, 1.52727500e-01f, 9.82125988e-04f, -2.50392199e-01f, 5.59649393e-02f, 1.08891860e-01f, -1.68570936e-01f,
  3.19404788e-02f, -1.68183237e-01f, 1.63085118e-01f, 1.47870183e-01f, 3.12593132e-02f, -2.52054296e-02f, 2.77447402e-01f, 2.56646216e-01f, 1.76792547e-01f, -1.49002939e-01f,
  -1.63782343e-01f, 2.42835745e-01f, -1.94278717e-01f, -1.38040334e-01f, -1.63122714e-01f, -1.27030060e-01f, -1.72432050e-01f, -3.38655189e-02f, -2.78729144e-02f, -1.43118262e-01f,
  2.77643383e-01f, 1.73289731e-01f, 2.91614592e-01f, 1.36547014e-01f, -9.68922228e-02f, 2.64039915e-02f, -2.91643053e-01f, -1.25659406e-01f, 4.77263220e-02f, -7.75710642e-02f,
  -7.51151666e-02f, 1.42882317e-01f, 9.17416438e-02f, -1.78041700e-02f, -5.92037058e-03f, 1.71462372e-01f, 7.36459568e-02f, 6.81123510e-03f, 5.12826815e-02f, 8.50603655e-02f,
  2.19742972e-02f, 7.78447464e-02f, 2.06271857e-01f, -1.69398084e-01f, -6.52776957e-02f, 1.26996294e-01f, -3.37880366e-02f, 6.09097704e-02f, 3.65204923e-02f, 2.58897424e-01f,
  4.84578609e-02f, 2.89590899e-02f, 1.02233596e-01f, 2.23282263e-01f, -3.72573733e-02f, 5.47495820e-02f, 4.37949523e-02f, 1.39193952e-01f, -1.87585756e-01f, -6.70260191e-03f,
  1.84069827e-01f, -1.20610811e-01f, 3.29587944e-02f, -7.77513087e-02f, 2.81715691e-01f, -2.24836599e-02f, -1.83920369e-01f, -9.02372897e-02f, -4.89357524e-02f, -2.37018287e-01f,
  7.80018866e-02f, 7.75717141e-04f, -1.01853032e-02f, -2.52012104e-01f, -6.88148290e-02f, 2.83354130e-02f, 3.46447855e-01f, 9.28826928e-02f, -5.80460131e-02f, 2.65253812e-01f,
  2.55728871e-01f, 2.42885515e-01f, 1.22951426e-01f, 2.50196725e-01f, 1.14472635e-01f, -1.30192772e-01f, 1.58177555e-01f, 1.20177664e-01f, 1.22066066e-01f, -1.51022136e-01f,
  1.95798744e-02f, 3.06304783e-01f, 8.01196098e-02f, 4.09945771e-02f, -2.54160706e-02f, 1.09581657e-01f, 1.45928323e-01f, 1.77081853e-01f, 1.20131329e-01f, 1.25792623e-01f,
  1.18205875e-01f, -1.96434613e-02f, 7.46675879e-02f, 4.62179370e-02f, 1.84491128e-01f, -2.37738732e-02f, 5.29126301e-02f, -4.74508815e-02f, -2.74931639e-01f, 3.04740340e-01f,
  -5.50782271e-02f, -3.27560343e-02f, 2.19088420e-01f, 1.02924488e-01f, 1.61700413e-01f, -1.63474172e-01f, 1.32599443e-01f, 1.83114648e-01f, 1.63941726e-01f, -6.12179004e-02f,
  5.12773804e-02f, -1.77604362e-01f, -7.50849321e-02f, 9.40922126e-02f, -1.86337121e-02f, -2.52888594e-02f, -3.77053410e-01f, -9.06092376e-02f, 8.60415101e-02f, -1.31756827e-01f,
  1.01106241e-01f, 1.35021672e-01f, 8.43403041e-02f, -2.16518998e-01f, 2.26239085e-01f, -1.59950972e-01f, -3.45501870e-01f, -2.60352761e-01f, -2.33788744e-01f, -1.10641815e-01f,
  1.89835533e-01f, 1.17048852e-01f, -1.10275142e-01f, 2.27783605e-01f, 3.42775956e-02f, 1.54795036e-01f, 2.20524311e-01f, 1.10445268e-01f, -3.79935838e-02f, 1.39558867e-01f,
  -4.48744558e-02f, 1.04620293e-01f, 1.82398379e-01f, 7.72757083e-02f, -1.40264869e-01f, 3.98008674e-01f, 6.92642927e-02f, 7.33244345e-02f, 3.16281319e-01f, 6.10817708e-02f,
  1.85822919e-01f, 1.53936267e-01f, 2.10719541e-01f, 1.34136781e-01f, 1.94435790e-01f, 4.69946787e-02f, -9.85574350e-03f, 2.12775722e-01f, -1.16905048e-01f, 5.53116314e-02f,
  -1.42556474e-01f, 2.14986116e-01f, -4.58895117e-02f, 2.12746009e-01f, 1.33187816e-01f, -1.31450117e-01f, 9.09176096e-02f, -2.11948052e-01f, -2.60639787e-01f, -1.07415400e-01f,
  2.13706076e-01f, -3.12186424e-02f, 2.47381672e-01f, 2.66749654e-02f, -1.67447060e-01f, -9.20761451e-02f, 4.86823581e-02f, 2.23807022e-02f, 9.78430584e-02f, 1.45932958e-01f,
  -1.54073581e-01f, 2.81365782e-01f, -7.43348226e-02f, -1.53832033e-01f, 2.96429992e-01f, 2.10637167e-01f, 3.77147980e-02f, -1.16214179e-01f, 1.82299793e-01f, -2.69741826e-02f,
  -1.02344811e-01f, -1.95535809e-01f, 5.27617857e-02f, 9.58124362e-03f, -8.86074081e-03f, -8.07326958e-02f, -1.55591056e-01f, 8.70362446e-02f, 1.21446654e-01f, -2.25586995e-01f,
  1.19297989e-01f, -4.18385305e-02f, -6.46698773e-02f, 8.31482187e-02f, -5.26777133e-02f, -1.63435012e-01f, -1.03772625e-01f, 3.84586938e-02f, 9.75273401e-02f, 5.85191920e-02f,
  1.86369643e-01f, 1.51687548e-01f, 1.19738407e-01f, -5.78437671e-02f, -7.99317658e-03f, 9.44473594e-03f, 1.06439635e-01f, 7.24023134e-02f, 8.20191950e-02f, 3.47055048e-02f,
  1.13807850e-01f, -1.07249394e-01f, 5.02721518e-02f, 5.35221174e-02f, 2.32812911e-01f, -1.11521281e-01f, -1.17167369e-01f, 3.58367935e-02f, -6.43678904e-02f, 1.23884082e-01f,
  -1.46204725e-01f, -6.98311701e-02f, -2.44020998e-01f, -2.10146874e-01f, 1.18492350e-01f, 1.35179497e-02f, -4.60606627e-02f, -5.55696376e-02f, 1.70925260e-02f, 1.49571851e-01f,
  -2.04159051e-01f, 1.04175515e-01f, 3.92048210e-01f, -1.52385086e-01f, -2.15437308e-01f, 9.80693623e-02f, -8.52563381e-02f, -2.39886306e-02f, -7.73052946e-02f, -2.41925463e-01f,
  -2.05515757e-01f, -1.53361842e-01f, -8.13978259e-03f, -2.68184483e-01f, -1.43843174e-01f, -2.37224266e-01f, 1.26662299e-01f, 1.95205584e-01f, 2.51727313e-01f, 3.81461792e-02f,
  -9.12453681e-02f, 2.42731318e-01f, 2.41424635e-01f, 2.37851575e-01f, 3.62156659e-01f, 2.44090706e-02f, -1.81027558e-02f, -1.80512473e-01f, 8.48113443e-04f, 1.06775416e-02f,
  -3.16953316e-04f, -1.55831918e-01f, 5.51131554e-02f, 1.38795167e-01f, 3.83678153e-02f, -5.88010773e-02f, -2.02395707e-01f, 1.12314120e-01f, 9.92004424e-02f, 2.19920333e-02f,
  5.87589778e-02f, 1.47456124e-01f, -1.18175760e-01f, 1.25566777e-02f, 3.70876081e-02f, 2.20571712e-01f, 4.19728644e-02f, 1.95679143e-02f, 8.35788157e-03f, -9.16425586e-02f,
  1.80712864e-01f, 3.15421820e-02f, -2.92090654e-01f, -2.64259279e-01f, 2.62548506e-01f, 2.81995516e-02f, 2.34791771e-01f, -2.57670015e-01f, 3.74520153e-01f, 1.50309382e-02f,
  1.62205637e-01f, 1.06500037e-01f, 3.21897238e-01f, -2.37251557e-02f, 9.05250311e-02f, -7.26532191e-02f, -1.35634765e-01f, 4.67947908e-02f, 6.29233271e-02f, -3.37233812e-01f,
  1.09110177e-02f, -1.01820491e-01f, 1.14125632e-01f, 1.24096841e-01f, 6.52095228e-02f, -2.17082158e-01f, 3.59790415e-01f, 1.12141237e-01f, 5.45801185e-02f, 6.87681362e-02f,
  1.43071488e-01f, 3.24703902e-01f, 2.33662680e-01f, 9.32028051e-03f, -8.43177065e-02f, 2.91531473e-01f, 3.35160851e-01f, 1.01630650e-01f, 1.10791720e-01f, 2.75245726e-01f,
  -1.14957117e-01f, 8.21624249e-02f, -1.79627649e-02f, -2.47659042e-01f, 1.34653568e-01f, 8.37627053e-03f, -4.83299792e-03f, 1.15429461e-01f, 1.79978907e-02f, 1.70541853e-01f,
  1.19427435e-01f, 5.75817488e-02f, 1.13466062e-01f, 2.19214886e-01f, 1.23547532e-01f, 1.71175808e-01f, -1.14433095e-01f, 8.30797628e-02f, 1.37445122e-01f, 3.09891164e-01f,
  3.34693901e-02f, 9.02783051e-02f, -8.01521316e-02f, 5.47784567e-02f, -1.68862730e-01f, 2.36130491e-01f, 5.24888001e-02f, 7.16145709e-02f, 3.60878587e-01f, 1.42572597e-01f,
  6.54415265e-02f, 1.31102264e-01f, 2.83078998e-01f, -2.06797764e-01f, 9.23888385e-02f, -3.85759324e-02f, -1.48743331e-01f, 1.20425321e-01f, 2.74473242e-02f, -3.08279186e-01f,
  5.86975738e-02f, 2.72058696e-02f, -2.33243294e-02f, 3.92465815e-02f, 1.66913271e-01f, -9.96759068e-03f, 2.09022174e-03f, 1.70332298e-01f, -1.00993134e-01f, -2.31726989e-01f,
  -8.03136155e-02f, 1.33605525e-01f, 1.01394631e-01f, -1.96934622e-02f, 8.92268345e-02f, -2.09564134e-01f, 1.77537873e-01f, -2.64550656e-01f, 2.17017874e-01f, 4.53957021e-02f,
  3.95993739e-02f, -1.44619178e-02f, -7.77480081e-02f, 3.70603681e-01f, -2.06778035e-01f, 8.98026302e-02f, -1.84919998e-01f, 3.41175561e-04f, -1.70516670e-02f, 4.82898913e-02f,
  2.12221161e-01f, -1.37074739e-02f, 1.27184778e-01f, 1.01187572e-01f, -5.97222485e-02f, 3.34370732e-02f, 1.73242301e-01f, 1.87614098e-01f, -2.75753308e-02f, 1.79190323e-01f,
  1.69753179e-01f, -2.22133454e-02f, 2.12178871e-01f, 2.58430094e-02f, 1.07505776e-01f, 1.21344216e-01f, 2.06643324e-02f, 1.28420126e-02f, -4.27000932e-02f, 1.88516621e-02f,
  -3.16778272e-02f, 7.02028200e-02f, 1.90208688e-01f, 2.99060315e-01f, 1.98055238e-01f, 3.02975863e-01f, -1.82429761e-01f, -1.02945566e-02f, -8.56695250e-02f, -1.34879023e-01f,
  -1.65035799e-01f, 1.94476306e-01f, -1.84502378e-01f, 2.27774829e-02f, -1.33951873e-01f, -1.05150431e-01f, 1.61292359e-01f, 2.98312977e-02f, 3.40149164e-01f, 8.33659023e-02f,
  -1.50831848e-01f, -5.20105138e-02f, -1.02106340e-01f, -2.97161460e-01f, 9.67391022e-03f, 1.65119305e-01f, 9.02363360e-02f, -2.44598821e-01f, -5.87175339e-02f, -6.11880310e-02f,
  1.85607627e-01f, -1.17404990e-01f, 5.38771302e-02f, 1.02990739e-01f, -1.26621509e-02f, 1.68883353e-02f, -7.15636313e-02f, 1.28845973e-02f, -3.94345336e-02f, -1.30291015e-01f,
  1.05042592e-01f, 6.63315579e-02f, 1.94127470e-01f, -9.14563984e-02f, 1.90697387e-02f, 1.57893658e-01f, 1.85548320e-01f, -3.88049074e-02f, 5.09633683e-02f, 1.14852093e-01f,
  -4.13252367e-03f, 5.37001006e-02f, -8.02520663e-02f, 7.05357417e-02f, -3.69654708e-02f, 1.18148416e-01f, 6.13880344e-02f, -7.62427077e-02f, -1.46054864e-01f, 1.25213996e-01f,
  -8.29023719e-02f, -2.79675722e-01f, 1.83293015e-01f, 2.79451581e-03f, 8.69331285e-02f, -4.20762040e-02f, -7.64884651e-02f, -9.70857125e-03f, -1.80710834e-02f, 6.37190342e-02f,
  -5.71859963e-02f, 3.33187282e-02f, -1.38051376e-01f, 9.27257910e-02f, -1.82509318e-01f, 3.18868637e-01f, 3.20139080e-02f, -1.07154239e-03f, 5.72630130e-02f, 2.98853889e-02f,
  1.81253944e-02f, -3.67109999e-02f, 5.33929877e-02f, 2.12076858e-01f, -1.45961523e-01f, -1.10609196e-01f, -8.24060366e-02f, 4.65492271e-02f, -2.15485860e-02f, 1.92507982e-01f,
  1.27927184e-01f, -1.77628342e-02f, 2.59952754e-01f, -1.63004883e-02f, 7.67893642e-02f, -5.04122339e-02f, 2.72748530e-01f, -2.21075043e-01f, 3.33624929e-01f, 7.01341182e-02f,
  -9.54478420e-03f, -1.21788807e-01f, -2.45573428e-02f, -1.19431525e-01f, 4.70828712e-02f, 1.37415677e-01f, 2.13626385e-01f, -1.59544602e-01f, 1.30822554e-01f, -6.31145015e-02f,
  -2.20757499e-01f, 6.99132830e-02f, -1.80034637e-02f, -2.08149888e-02f, 1.59761161e-01f, -2.46692464e-01f, -3.22794259e-01f, 4.79952395e-02f, 7.52525851e-02f, 7.90188164e-02f,
  6.99807182e-02f, 1.77986190e-01f, -1.46715403e-01f, -1.47497475e-01f, 9.84166861e-02f, -2.13202506e-01f, -1.43305019e-01f, -1.10790908e-01f, 6.34449720e-02f, -4.98328358e-02f,
  1.77144967e-02f, 2.19421461e-01f, -1.78136993e-02f, 1.65202916e-02f, -8.76269788e-02f, 1.21895432e-01f, -1.33496299e-01f, 2.83487439e-01f, -1.04622863e-01f, 2.89597064e-01f,
  -1.01897523e-01f, 9.81548801e-02f, 1.57332912e-01f, 7.35926554e-02f, 1.76989809e-01f, 1.05419062e-01f, 4.99013662e-02f, 6.26558140e-02f, -2.40228564e-01f, -8.87760371e-02f,
  2.21799426e-02f, 3.99272628e-02f, -6.38332590e-02f, -5.63187487e-02f, -4.96324375e-02f, -6.68402538e-02f, 7.70992637e-02f, 4.83309068e-02f, -2.02674255e-01f, 1.51646659e-01f,
  9.58475545e-02f, -1.49383664e-01f, 5.95714450e-02f, 1.24580048e-01f, -1.41334727e-01f, 9.37795080e-03f, 5.77380098e-02f, 4.30263206e-02f, 7.96501860e-02f, 1.24204956e-01f,
  -1.07588861e-02f, -1.40522197e-01f, -2.70275287e-02f, -2.21340880e-01f, -6.72249794e-02f, 2.66152527e-02f, -8.92021414e-03f, 1.97654828e-01f, 2.77507395e-01f, -1.15644336e-02f,
  -3.72524261e-02f, 2.00002849e-01f, -1.06128916e-01f, 2.37873965e-03f, 6.80198669e-02f, 1.18895367e-01f, 2.20227763e-01f, 2.70803440e-02f, 5.42749465e-02f, -3.46210867e-01f,
  -1.45003488e-02f, 2.01845411e-02f, -3.53672579e-02f, -1.79957807e-01f, 2.78610766e-01f, 4.55521554e-01f, 2.35899433e-01f, 9.71010849e-02f, 1.86634064e-03f, -2.17915047e-02f,
  -1.35318577e-01f, 2.45871115e-02f, -2.14226782e-01f, 7.21744746e-02f, -2.92774220e-03f, -1.06014356e-01f, -5.57675846e-02f, -1.38259694e-01f, 1.68746009e-01f, -8.16242695e-02f,
  1.88014776e-01f, 1.48543632e-02f, -2.86870182e-01f, 5.02262749e-02f, -3.78138870e-02f, -2.92127192e-01f, -1.04887716e-01f, 1.03338815e-01f, 7.67393038e-02f, -1.26060564e-02f,
  -3.62789296e-02f, -3.76025103e-02f, 3.83085489e-01f, 1.03747070e-01f, 1.74606860e-01f, 2.79637724e-01f, 2.56094843e-01f, 2.41601586e-01f, -1.69187829e-01f, 1.86294869e-01f,
  8.80545452e-02f, -2.12946404e-02f, -9.55109522e-02f, 2.33747825e-01f, 2.85652637e-01f, 7.20876828e-02f, 1.93039253e-01f, 1.24553554e-01f, 1.27456352e-01f, -6.83574900e-02f,
  3.75471301e-02f, -1.56596988e-01f, 2.07781166e-01f, -1.18804954e-01f, 3.38796340e-02f, 1.76630124e-01f, 5.38168335e-03f, 4.25296240e-02f, -1.91255491e-02f, 2.60690778e-01f,
  2.50311755e-02f, 4.87880446e-02f, 1.00479692e-01f, 1.99036360e-01f, -9.19066295e-02f, 2.26137623e-01f, -1.25680611e-01f, 1.82210818e-01f, 8.02463144e-02f, 5.07952459e-02f,
  -4.33502942e-02f, 1.02862262e-03f, 1.78329229e-01f, -2.43275263e-03f, 2.76723564e-01f, 2.95577317e-01f, 2.89118923e-02f, -9.78699997e-02f, 3.48269157e-02f, -2.68328283e-02f,
  9.62985456e-02f, 2.47926936e-02f, 7.68345222e-02f, 3.44693005e-01f, -3.05146515e-01f, -1.76496893e-01f, 3.03711385e-01f, 2.28757694e-01f, 1.20076634e-01f, -3.90071981e-02f,
  2.78950840e-01f, -8.07506591e-02f, -6.18784465e-02f, -7.49615952e-02f, 1.09089702e-01f, -1.41871348e-01f, 4.75173853e-02f, 5.07441871e-02f, -1.26734063e-01f, 2.67187297e-01f,
  -6.98181540e-02f, -4.29093242e-02f, 1.20557904e-01f, 2.35166863e-01f, -3.29672322e-02f, 5.76247759e-02f, 2.14256853e-01f, -3.98568958e-01f, -1.58502646e-02f, 4.66349646e-02f,
  9.60927606e-02f, -7.22841769e-02f, 1.00483894e-01f, 8.18935186e-02f, -1.13424264e-01f, 1.15376420e-01f, 3.67489085e-02f, 1.97806098e-02f, 1.04034543e-01f, 1.80118054e-01f,
  -6.95826784e-02f, 1.09486960e-01f, 9.49879438e-02f, 2.58235782e-01f, 1.90526947e-01f, -2.17614546e-01f, -1.24525145e-01f, 1.28661156e-01f, 6.72061816e-02f, -7.50654042e-02f,
  -1.68259352e-01f, 7.28261098e-03f, 6.24243021e-02f, -6.80277124e-02f, 2.70286381e-01f, -3.63442674e-02f, -1.46007854e-02f, 7.82082900e-02f, 1.04205765e-01f, -1.09076805e-01f,
  1.34052560e-01f, 1.40772626e-01f, 2.46026382e-01f, 1.22831658e-01f, -2.25003734e-01f, 1.39541356e-02f, 6.38365149e-02f, -1.56219393e-01f, -3.87890860e-02f, -1.35349438e-01f,
  1.20868944e-01f, 1.68896824e-01f, 2.24128723e-01f, 2.64809281e-01f, 1.35326609e-01f, 2.76350260e-01f, 9.14131403e-02f, 1.82364285e-02f, -5.67664579e-02f, -3.63437273e-02f,
  -4.65305410e-02f, 1.36936828e-01f, -2.21766755e-02f, 1.20018534e-01f, -1.78694889e-01f, -1.40425012e-01f, 7.00740749e-03f, -4.92349751e-02f, 1.63943797e-01f, 3.06380868e-01f,
  4.26207781e-02f, -9.40814912e-02f, 1.45704389e-01f, 2.37817824e-01f, -1.46130428e-01f, -9.97729227e-02f, -9.33512673e-02f, -4.84646903e-03f, -2.64285952e-02f, -4.52573076e-02f,
  1.78036429e-02f, 2.79495548e-02f, 2.89316922e-02f, 7.33202025e-02f, 1.28429666e-01f, 1.08499311e-01f, 1.39101043e-01f, 4.82872725e-02f, -9.57614481e-02f, -1.23672502e-03f,
  1.53122261e-01f, -1.40358478e-01f, -2.23566383e-01f, 1.37683302e-01f, 3.54974717e-02f, -6.70563579e-02f, -1.06726587e-03f, 1.95415363e-01f, 1.25484198e-01f, 8.25539976e-02f,
  -2.23145589e-01f, 1.19915970e-01f, -7.35423267e-02f, -8.14069957e-02f, -7.53325410e-03f, 2.60316789e-01f, -9.59268138e-02f, 2.05070689e-01f, 9.45501775e-02f, -8.45792592e-02f,
  -2.83450454e-01f, 6.22400567e-02f, 1.81660071e-01f, 2.18234546e-02f, -2.20353469e-01f, -2.47851059e-01f, 2.59340685e-02f, 1.00332327e-01f, -9.65889022e-02f, -1.65073812e-01f,
  -3.83173525e-02f, -2.55307723e-02f, -4.18166220e-02f, -2.58965828e-02f, -1.13062365e-02f, 5.13320565e-02f, 1.90560982e-01f, 1.90895095e-01f, 4.35818881e-02f, 1.91634104e-01f,
  -3.38436142e-02f, -1.85411572e-01f, -6.43577650e-02f, -1.50320768e-01f, -1.11268781e-01f, 1.48224145e-01f, 7.16016069e-03f, -1.33990198e-01f, -3.93515937e-02f, 1.14443615e-01f,
  -1.56295091e-01f, 6.82344139e-02f, 1.16461009e-01f, 1.09479027e-02f, 4.93308529e-02f, 1.66652307e-01f, 3.51866156e-01f, 3.84788178e-02f, 1.48275018e-01f, -1.73772778e-03f,
  4.10219803e-02f, -3.61222386e-01f, 1.17584474e-01f, 3.15939030e-03f, -2.59116381e-01f, 8.20806324e-02f, 1.78975537e-01f, -3.90824787e-02f, 4.61472943e-02f, -1.56733505e-02f,
  -1.33226678e-01f, -1.32311136e-01f, 1.18141674e-01f, 3.72164071e-01f, -4.23112631e-01f, -2.98099101e-01f, 6.06029965e-02f, -8.08249116e-02f, 6.02721274e-02f, 9.61055458e-02f,
  -2.15524714e-03f, 2.46488735e-01f, -1.74435645e-01f, -1.62844062e-02f, 1.69944212e-01f, 1.17513508e-01f, 2.62826443e-01f, 2.62496352e-01f, -1.10431083e-01f, -4.18661572e-02f,
  1.25157550e-01f, 2.14668095e-01f, -5.83250336e-02f, 5.59292473e-02f, 2.07272649e-01f, 2.02489406e-01f, 6.52087927e-02f, -1.63363785e-01f, -1.72250092e-01f, 3.74700017e-02f,
  2.78404772e-01f, -3.78087997e-01f, -9.26979706e-02f, 1.23025157e-01f, -2.85310358e-01f, -3.52371335e-01f, 1.76031217e-01f, 4.98112775e-02f, 9.26088095e-02f, 4.77761388e-01f,
  1.32209778e-01f, 2.04566061e-01f, 8.81773531e-02f, 3.39933597e-02f, -5.30525744e-02f, 8.18468109e-02f, 2.24514417e-02f, -1.10160291e-01f, -2.81343237e-02f, -1.25784036e-02f,
  -1.81845710e-01f, -4.16734628e-02f, 1.08761892e-01f, 1.62503012e-02f, -8.13976675e-02f, -5.53826466e-02f, -1.09198384e-01f, -2.95964181e-02f, -1.92053791e-03f, -4.42120023e-02f,
  -5.88548332e-02f, -7.18800053e-02f, 9.00371373e-02f, 1.56014442e-01f, -7.84158334e-02f, 5.13667986e-02f, -2.12154295e-02f, 1.52491093e-01f, -3.18431973e-01f, -3.36124492e-03f,
  4.75884639e-02f, 1.50435567e-01f, 4.97165918e-02f, 9.91557539e-02f, -3.87065415e-03f, 2.64426097e-02f, 8.61455128e-02f, -1.17805921e-01f, 1.23913109e-01f, 1.72328040e-01f,
  -2.31459811e-02f, 5.80423884e-03f, -2.49866452e-02f, 8.10212493e-02f, 7.91541710e-02f, 7.92907625e-02f, -1.03777228e-02f, 9.32479277e-02f, 7.01853931e-02f, -1.58524215e-01f,
  1.41404852e-01f, 5.02358042e-02f, -1.25653312e-01f, 7.77999172e-03f, 1.79971173e-01f, -2.23915242e-02f, 4.60531004e-02f, 1.43112913e-01f, -1.61083192e-01f, -6.89125508e-02f,
  7.36230761e-02f, 4.30640616e-02f, 2.27492288e-01f, 3.06737036e-01f, -7.32580945e-02f, 1.07584201e-01f, 6.98667988e-02f, -8.00790861e-02f, -2.08959237e-01f, -3.17216292e-02f,
  -1.11710079e-01f, 1.31599158e-01f, 1.77414075e-01f, 5.64345606e-02f, 4.38792743e-02f, 1.97273329e-01f, 1.64921407e-03f, 8.34514499e-02f, 7.60731846e-02f, 2.42206618e-01f,
  -9.75719243e-02f, -1.85293078e-01f, 5.39565347e-02f, 1.45629302e-01f, -1.57939177e-02f, 1.57131940e-01f, -1.52755678e-01f, -1.72142118e-01f, 1.55349955e-01f, -1.49953187e-01f,
  -2.66582500e-02f, -2.76091248e-01f, 1.31779790e-01f, 4.57903631e-02f, 1.32095262e-01f, 2.28083521e-01f, -8.63962919e-02f, -8.67725611e-02f, 5.09545766e-02f, 7.22068399e-02f,
  1.30310953e-01f, 1.17793217e-01f, -4.76527549e-02f, 7.39659220e-02f, -3.90111506e-01f, -1.45069882e-01f, -7.27890618e-03f, 2.43055582e-01f, 1.95021674e-01f, -2.13963836e-01f,
  3.39428008e-01f, 1.01359263e-04f, -1.87767923e-01f, -1.07070185e-01f, 4.43599485e-02f, 1.25868902e-01f, 9.43070278e-02f, -7.63730258e-02f, -7.33009204e-02f, 2.30930597e-01f,
  1.67683288e-02f, -1.10836789e-01f, 2.47616619e-01f, 7.52677694e-02f, 8.64021666e-03f, 1.36848539e-01f, 5.39342724e-02f, -2.53730714e-01f, -9.57441926e-02f, 4.81874421e-02f,
  7.96436742e-02f, 1.32176042e-01f, -2.48048566e-02f, 1.33917630e-01f, -4.12212685e-03f, 1.97277024e-01f, 1.00884005e-01f, 9.15275067e-02f, 9.12571698e-02f, 4.06649522e-02f,
  -4.39411215e-02f, 1.87073275e-01f, 1.60138667e-01f, -3.67376320e-02f, 4.91814390e-02f, 5.40322484e-03f, -1.07071772e-01f, 1.37042664e-02f, 2.18169570e-01f, -4.84903045e-02f,
  -1.50866844e-02f, 1.24957087e-02f, -2.29274128e-02f, 3.99126532e-03f, 3.58585753e-02f, 6.11588471e-02f, -1.19088799e-01f, -1.66988939e-01f, -5.39682135e-02f, -9.84116793e-02f,
  -8.48989710e-02f, 2.20434502e-01f, 9.36997384e-02f, -2.24033684e-01f, -2.60755777e-01f, -1.09001033e-01f, 1.48196205e-01f, 7.46265724e-02f, 6.83019757e-02f, 2.13076025e-01f,
  -1.75080881e-01f, -2.14373451e-02f, -7.00818598e-02f, -2.66417232e-03f, 3.14160995e-02f, 5.66805676e-02f, 2.29323879e-01f, 1.83497369e-01f, -3.99716124e-02f, -1.74955592e-01f,
  7.11620972e-03f, -2.25805730e-01f, 2.37159312e-01f, -2.86373377e-01f, -1.36497244e-01f, -7.79747090e-04f, -1.14717856e-01f, -1.31533220e-01f, 7.75141865e-02f, -6.40807599e-02f,
  1.06062070e-01f, 2.08022639e-01f, 2.10739687e-01f, 5.57057373e-02f, 1.69479698e-01f, -7.37185776e-03f, -2.51638353e-01f, 1.17623143e-01f, -1.29538238e-01f, -6.57560527e-02f,
  9.19355005e-02f, -8.67121518e-02f, -1.97598666e-01f, 6.33796602e-02f, 1.30155878e-02f, -2.92293187e-02f, 1.12964742e-01f, 1.51189948e-02f, 1.38375506e-01f, -1.01536084e-02f,
  -3.96436825e-02f, 1.59043118e-01f, -1.17009342e-01f, -1.26334131e-01f, -2.25320026e-01f, -5.82731515e-03f, 6.39107227e-02f, -1.79824322e-01f, 6.60005352e-03f, 2.39060167e-03f,
  -4.55512144e-02f, 1.22883655e-01f, 1.86308905e-01f, -1.79912355e-02f, 1.41113281e-01f, 1.99516537e-03f, 1.73213944e-01f, 2.63267785e-01f, -1.16903810e-02f, -1.35706753e-01f,
  1.16520636e-01f, 1.15406804e-01f, 7.02868849e-02f, -2.00002879e-01f, 9.28848833e-02f, 2.27831706e-01f, 1.34707525e-01f, 9.02745798e-02f, 2.82554686e-01f, 1.04390346e-01f,
  2.69260705e-02f, -1.56315058e-01f, -1.54350594e-01f, 2.12729916e-01f, -2.14976922e-01f, -1.66870505e-01f, -1.64370164e-01f, 1.20366842e-01f, -1.22579604e-01f, -1.30808754e-02f,
  9.00601521e-02f, -9.82766002e-02f, 9.42344889e-02f, 9.57495272e-02f, 2.02570945e-01f, -1.85718805e-01f, -2.88562458e-02f, -4.57811728e-02f, -1.93641290e-01f, 8.23268145e-02f,
  1.16234094e-01f, -2.43314691e-02f, 8.52297619e-02f, 9.46589485e-02f, 4.17616814e-02f, 1.09671324e-01f, 2.50504129e-02f, 7.99929816e-03f, 6.45649657e-02f, 4.37739119e-02f,
  3.07215173e-02f, -6.30334690e-02f, 1.70621332e-02f, 1.33085504e-01f, 1.25283690e-03f, -1.20498575e-02f, 4.10744548e-02f, 1.05601884e-01f, 1.57067269e-01f, -3.24109793e-02f,
  3.93435284e-02f, 5.39265499e-02f, -9.64319482e-02f, 6.08343445e-02f, -2.77964115e-01f, 1.43888116e-01f, -1.22917704e-01f, -1.23482326e-03f, -1.57283470e-01f, -2.39540171e-03f,
  -3.10750157e-02f, 1.06972829e-02f, -2.50379425e-02f, -9.00524855e-02f, -1.33871362e-01f, 7.15727359e-02f, 1.56173453e-01f, 9.58086848e-02f, -3.67487408e-03f, 1.33868661e-02f,
  -4.25663926e-02f, 1.69239968e-01f, -1.25471711e-01f, -5.26421890e-02f, -1.17439618e-02f, 6.42385259e-02f, 1.20055256e-02f, -7.58785382e-02f, 1.60112470e-01f, -8.46917406e-02f,
  1.92711130e-01f, 6.48216978e-02f, -4.70490493e-02f, 1.27257690e-01f, -1.80395246e-01f, -2.02234849e-01f, -1.07001573e-01f, -1.45007312e-01f, -1.62585825e-02f, 7.11353943e-02f,
  1.94635257e-01f, -2.19470620e-01f, 2.41354421e-01f, 1.33872464e-01f, -1.55794501e-01f, 8.03769305e-02f, 3.08032393e-01f, 2.19830751e-01f, 1.46054700e-01f, 1.82029560e-01f,
  1.58822119e-01f, 1.60745665e-01f, 1.85096145e-01f, 2.26561010e-01f, 2.23805696e-01f, 1.57720193e-01f, -2.64901407e-02f, 2.96602938e-02f, 7.71923969e-03f, 1.75929919e-01f,
  2.19912365e-01f, -1.74711585e-01f, -7.49020204e-02f, -3.17093641e-01f, 1.31677806e-01f, 3.54982018e-02f, 1.22961430e-02f, -1.64263234e-01f, -6.47922978e-02f, -2.32379615e-01f,
  1.28584132e-01f, -3.28125656e-01f, -1.97075486e-01f, -9.35357530e-03f, 1.81527317e-01f, -3.64739865e-01f, -1.63274139e-01f, 6.89728484e-02f, 1.95505023e-01f, -1.10132292e-01f,
  1.75958186e-01f, -2.56487131e-02f, 6.60771951e-02f, 3.98435183e-02f, 3.46356407e-02f, -1.57103151e-01f, -5.85711747e-02f, 1.82784751e-01f, 1.69816669e-02f, 5.07181808e-02f,
  1.23559590e-02f, 1.96374416e-01f, -1.84686020e-01f, -2.55545437e-01f, 1.68756261e-01f, -5.02581894e-02f, -2.41127163e-01f, -1.04052834e-01f, 1.95768364e-02f, -9.21717063e-02f,
  8.95842502e-04f, 1.60990447e-01f, -1.42465249e-01f, 2.34013960e-01f, -1.18952565e-01f, -6.28941751e-04f, 2.22737819e-01f, -1.33421049e-01f, 2.70742208e-01f, -2.12576799e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  -3.38027813e-03f, 1.46756500e-01f, 1.03011735e-01f, -1.29967090e-03f, 1.01893336e-01f, 1.77572388e-02f, 2.97304746e-02f, 6.08264692e-02f, 2.18473703e-01f, -3.83928530e-02f,
  1.01885423e-01f, 1.55021653e-01f, 1.59527391e-01f, 3.33110839e-02f, 4.88165654e-02f, -3.59780006e-02f, 2.58830398e-01f, -2.74202134e-02f, 1.18649036e-01f, 4.94312532e-02f,
  5.28376661e-02f, 2.27939010e-01f, 1.29896402e-01f, 1.11053199e-01f, 1.37130246e-01f, 1.69388831e-01f, 1.13182060e-01f, 2.80561894e-02f, 3.99794094e-02f, 8.97350088e-02f,
  5.87484501e-02f, 1.95023865e-01f, 1.74385056e-01f, 2.72161886e-02f, -4.07403633e-02f, 1.72605097e-01f, 9.87522826e-02f, 1.39282066e-02f, -3.75997648e-02f, 1.01267010e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  9.15807709e-02f, 4.87996452e-03f, -3.93759273e-02f, -2.70912588e-01f, -3.06980044e-01f, -8.29874277e-02f, -3.14054489e-01f, 1.03079997e-01f, 1.14999413e-01f, -1.18582271e-01f,
  -2.62771785e-01f, -2.21610397e-01f, -3.19445767e-02f, 2.03064814e-01f, 6.34226054e-02f, -1.01525960e-02f, 2.88898367e-02f, 2.15195864e-01f, 4.58128415e-02f, -9.60771739e-02f,
  1.12509644e-02f, 1.21876433e-01f, 1.16010576e-01f, -5.43445498e-02f, 1.17378607e-01f, -1.16272889e-01f, -2.83467919e-01f, 1.46596143e-02f, -1.73246399e-01f, 1.27041906e-01f,
  2.31547784e-02f, 1.76895961e-01f, -4.40251350e-01f, -2.46963091e-02f, -3.05887997e-01f, 1.31346643e-01f, 1.32666528e-01f, -1.84288025e-01f, 3.62625136e-03f, -1.84044123e-01f,
  -1.75748855e-01f, 1.60154998e-02f, -2.72682495e-02f, 2.60748118e-01f, -1.54413655e-01f, -1.80884585e-01f, -1.06628433e-01f, 2.42645576e-04f, -6.66707680e-02f, -1.57168120e-01f,
  -1.66777387e-01f, -1.94519326e-01f, -2.15845287e-01f, -4.49138999e-01f, 8.14383924e-02f, 2.42419213e-01f, -1.15362570e-01f, 1.28057331e-01f, 7.83314407e-02f, -7.49687329e-02f,
  6.76331371e-02f, 3.00382644e-01f, 1.07503079e-01f, -7.39737228e-02f, 8.10190141e-02f, 7.79503137e-02f, 1.75132468e-01f, 5.66505194e-02f, -4.15735722e-01f, -1.40416980e-01f,
  -2.43627235e-01f, -1.27897769e-01f, -3.06741774e-01f, 1.31001770e-01f, -7.40618929e-02f, 6.43284395e-02f, 2.32582167e-01f, -1.25945702e-01f, -2.05576479e-01f, -2.00178966e-01f,
  1.43317357e-01f, 5.28301895e-02f, -1.97088227e-01f, 1.21775441e-01f, -2.35618666e-01f, -7.44823366e-02f, -2.21767262e-01f, -1.33547291e-01f, 1.85382277e-01f, -4.19375867e-01f,
  -9.16309096e-03f, -9.92403105e-02f, -4.61280465e-01f, -3.75010639e-01f, 9.65197384e-03f, -5.03364690e-02f, 1.78127512e-01f, -1.81730658e-01f, 1.81849107e-01f, 3.00973833e-01f,
  -1.70808479e-01f, -1.41093612e-01f, -4.71243978e-01f, -2.73622274e-01f, 1.17020518e-01f, -1.14367671e-01f, -2.05047816e-01f, 1.47868931e-01f, 3.19664665e-02f, 2.73862839e-01f,
  1.71666130e-01f, -2.22133875e-01f, 1.66955724e-01f, 1.46008998e-01f, -2.06496760e-01f, -1.53796971e-01f, 1.08509131e-01f, 1.08535491e-01f, 1.98653027e-01f, 2.04824120e-01f,
  -9.64839384e-03f, -3.88680995e-01f, -2.38805652e-01f, 2.93278992e-01f, -3.06194305e-01f, 1.36297196e-01f, -1.01363972e-01f, -1.35370210e-01f, -1.28589734e-01f, 1.85399562e-01f,
  2.29367808e-01f, 1.95434421e-01f, -3.03220265e-02f, 3.46325822e-02f, 1.05698802e-01f, 7.44160637e-02f, -1.97621748e-01f, 1.40611842e-01f, 9.18970853e-02f, 1.29031897e-01f,
  7.96973258e-02f, -1.15454502e-01f, 3.04804802e-01f, -3.11541528e-01f, -1.42137840e-01f, 4.72975560e-02f, -2.57331003e-02f, 7.41170645e-02f, 4.71823692e-01f, 1.49207115e-01f,
  -2.53963351e-01f, -3.54665071e-01f, -2.33184874e-01f, 1.99001953e-01f, 2.87755996e-01f, -3.08531761e-01f, -3.61952275e-01f, 2.58114785e-01f, -1.12981305e-01f, -2.89154023e-01f,
  -5.33073187e-01f, -1.66881144e-01f, -8.50088298e-02f, 1.72933191e-01f, 2.17857212e-01f, 1.71985164e-01f, -3.71867359e-01f, -3.45252365e-01f, 8.96649137e-02f, 3.14291217e-03f,
  1.25699937e-01f, -1.63561597e-01f, 7.57804886e-02f, -1.87131420e-01f, -1.07712001e-01f, -7.92896599e-02f, 2.55329996e-01f, 2.23878086e-01f, 5.50059713e-02f, 1.01765424e-01f,
  -1.71220690e-01f, 1.34602338e-01f, 8.27553719e-02f, 8.15623906e-03f, -3.09237570e-01f, -1.76828638e-01f, -1.99555516e-01f, -2.59895995e-02f, 3.48500237e-02f, -2.65831985e-02f,
  -2.38522053e-01f, -5.56366503e-01f, 1.28912866e-01f, -7.54342079e-02f, -3.54643762e-02f, -6.93643242e-02f, -2.12231791e-03f, 2.63006543e-03f, -5.41475862e-02f, 4.05916478e-03f,
  -3.31808478e-01f, 1.93437979e-01f, 1.38399079e-01f, -1.39013290e-01f, -9.21414495e-02f, -2.19755828e-01f, 1.07781343e-01f, -1.83951944e-01f, 5.05612865e-02f, 1.23071991e-01f,
  1.30429268e-01f, 5.44886179e-02f, 2.25616336e-01f, -1.69015042e-02f, 2.14345023e-01f, -2.57652491e-01f, -2.44176328e-01f, -3.40978205e-01f, -2.26521254e-01f, -2.07051486e-01f,
  -7.13491887e-02f, 7.13200644e-02f, -4.82419103e-01f, 2.42465720e-01f, -3.77688259e-01f, 1.23692915e-01f, -1.48808748e-01f, -1.95023835e-01f, 2.04769187e-02f, 1.93995640e-01f,
  1.65336430e-01f, 1.40574217e-01f, -4.81324703e-01f, -9.14707109e-02f, -2.34263808e-01f, 1.46076679e-01f, 1.93816170e-01f, -4.35475409e-02f, -1.37787223e-01f, -8.24805573e-02f,
  -3.41659099e-01f, 3.50462757e-02f, 3.43719751e-01f, 6.37170449e-02f, 2.82133460e-01f, 2.70173222e-01f, -5.52335083e-02f, -6.55409917e-02f, -2.27208436e-01f, 1.03775047e-01f,
  1.32832557e-01f, 2.44138148e-02f, 1.45072892e-01f, 3.76575850e-02f, -1.35228246e-01f, -1.29286170e-01f, -2.10821286e-01f, 1.25478476e-01f, -3.10558766e-01f, 2.53704637e-01f,
  4.06228095e-01f, 7.35036433e-02f, 2.05971062e-01f, -5.32774329e-02f, 3.66572201e-01f, -1.48093224e-01f, -1.46838188e-01f, 2.48432532e-01f, -3.10832351e-01f, -1.20437406e-01f,
  -3.34290266e-01f, 2.39197463e-02f, -7.79423937e-02f, -3.50688100e-01f, 8.54134038e-02f, -3.49179029e-01f, -4.66974862e-02f, -1.20899275e-01f, -1.28227577e-01f, 1.03995584e-01f,
  1.05154477e-02f, 2.10861415e-02f, -3.26452047e-01f, -2.25735992e-01f, -1.13150485e-01f, 1.91508472e-01f, 1.44311832e-02f, 3.80433700e-03f, 1.05077721e-01f, 1.45924628e-01f,
  -2.28346795e-01f, 8.90902132e-02f, 1.08219028e-01f, -3.07831347e-01f, 9.24014428e-04f, -1.61322042e-01f, 1.67352140e-01f, -3.56571615e-01f, -3.64457726e-01f, -9.42879394e-02f,
  -2.49624103e-01f, 1.23636378e-02f, -2.04440996e-01f, -4.89120670e-02f, -1.42732859e-01f, 2.74529964e-01f, -2.62191985e-02f, -8.91125761e-03f, -3.87709141e-02f, 1.31497115e-01f,
  -1.74455926e-01f, 1.07018240e-01f, -5.26126958e-02f, 2.14460343e-01f, -3.51358391e-02f, -3.34306628e-01f, 2.26924956e-01f, -1.53530464e-01f, -8.50851387e-02f, 2.48520494e-01f,
  -3.10659632e-02f, 1.31736904e-01f, 1.29817620e-01f, 1.27889231e-01f, 2.49731407e-01f, 2.95758426e-01f, 7.65471831e-02f, 2.36006305e-02f, 1.43285707e-01f, 3.20031345e-02f,
  5.01100644e-02f, -7.89161697e-02f, -2.57798806e-02f, -1.93537667e-01f, 1.39325440e-01f, 1.94380239e-01f, 1.00009233e-01f, -1.22423224e-01f, 3.10187489e-01f, 2.10924670e-01f,
  -3.30554545e-02f, -2.60503893e-03f, 9.90647599e-02f, 4.70845759e-01f, 2.28802383e-01f, 2.56987642e-02f, -3.14579532e-02f, -1.79084003e-01f, 1.00146174e-01f, 1.30584091e-01f,
  -1.57833353e-01f, 1.29048362e-01f, -1.31976590e-01f, -4.46045876e-01f, 7.98596740e-02f, -2.11301386e-01f, 6.92560151e-02f, -2.45717660e-01f, -1.16419308e-01f, 3.59219372e-01f,
  2.03780636e-01f, 2.58240551e-01f, -2.34356597e-01f, -1.25358418e-01f, -2.14073449e-01f, -9.41070169e-02f, 2.19638854e-01f, -2.41486341e-01f, -1.21155404e-01f, 2.65796095e-01f,
  -5.78337573e-02f, -2.56740451e-01f, -4.16602008e-02f, -2.59274036e-01f, 2.20023498e-01f, -3.69544178e-02f, -1.14424780e-01f, 7.35981250e-03f, -9.94476750e-02f, 1.62071511e-02f,
  -2.15744406e-01f, 3.94225083e-02f, -1.72919318e-01f, 6.39252737e-02f, -1.29650906e-01f, -1.62899420e-01f, -2.85283625e-01f, -1.54957220e-01f, 1.34528643e-02f, -2.10940495e-01f,
  -2.61927042e-02f, -1.83569014e-01f, 3.99576910e-02f, 1.42933682e-01f, 8.04692209e-02f, -1.54367849e-01f, -6.24926202e-02f, 1.70381278e-01f, -6.10570833e-02f, 1.36041000e-01f,
  -5.69972359e-02f, -1.67844459e-01f, 1.68786928e-01f, -1.16986811e-01f, 2.01354831e-01f, 1.32196501e-01f, 8.36247653e-02f, 1.55635178e-01f, 2.82962136e-02f, 1.56388991e-02f,
  1.17301472e-01f, 2.11721450e-01f, 7.99677223e-02f, -3.81139070e-01f, -4.38498497e-01f, -4.91798878e-01f, -9.76335108e-02f, 2.46758357e-01f, 1.61745101e-01f, 1.10806674e-01f,
  -1.41486645e-01f, 2.16142721e-02f, -2.30107233e-02f, -3.98677170e-01f, 2.64268547e-01f, 2.41756693e-01f, 1.63716674e-01f, -1.71896040e-01f, 1.52000636e-01f, -2.76959509e-01f,
  -8.54525194e-02f, 1.01117171e-01f, -1.07599936e-01f, 1.34487618e-02f, -2.48086631e-01f, -1.20315254e-02f, 1.17583238e-01f, 1.21676773e-01f, 2.37104237e-01f, -1.62847593e-01f,
  -1.49168774e-01f, -2.98960894e-01f, 4.60141040e-02f, 1.13662474e-01f, -1.76406756e-01f, -1.09379075e-01f, -3.37945558e-02f, -1.40844667e-02f, -1.67812467e-01f, 6.58344885e-04f,
  -3.06040701e-02f, -1.32557496e-01f, -6.47870898e-02f, 6.99232072e-02f, 1.10415749e-01f, -1.28970236e-01f, -8.15993845e-02f, -1.43506601e-01f, 1.26423007e-02f, -9.00663584e-02f,
  1.32178634e-01f, 6.01764172e-02f, -1.79669574e-01f, -2.07962487e-02f, -3.57261971e-02f, -4.90814773e-03f, -5.19298129e-02f, 1.47347778e-01f, -1.26686662e-01f, -1.43002212e-01f,
  -1.95931077e-01f, 4.20184322e-02f, -9.89027768e-02f, -5.30952625e-02f, 6.73502078e-03f, 2.22995266e-01f, 2.08493993e-01f, -1.47709727e-01f, -1.47064090e-01f, 3.87516916e-02f,
  2.58612335e-01f, -1.99107885e-01f, -6.41662776e-02f, -7.99712762e-02f, -1.24445744e-01f, 2.72709638e-01f, 1.52913973e-01f, -8.54950771e-02f, -2.29254320e-01f, -3.05006772e-01f,
  -1.77717522e-01f, -2.76894927e-01f, 4.85708900e-02f, -1.55068859e-01f, -3.41347426e-01f, 1.39716253e-01f, -4.72805887e-01f, -3.09107035e-01f, -3.92175943e-01f, 2.12190866e-01f,
  1.99425340e-01f, -2.24627228e-03f, -1.81743756e-01f, 4.24942262e-02f, 2.36249119e-01f, 1.25901267e-01f, 1.93967775e-01f, -1.70774698e-01f, -1.02070838e-01f, -8.59011784e-02f,
  -9.18426365e-03f, -1.44256368e-01f, -7.91648328e-02f, -4.15815180e-03f, -5.82846589e-02f, -6.25181943e-02f, 9.15794522e-02f, -6.90718517e-02f, 3.14634852e-02f, -5.65750487e-02f,
  -1.94143336e-02f, 6.43001050e-02f, 1.89475015e-01f, 4.90966141e-02f, 1.18887782e-01f, -1.77107289e-01f, -1.34826735e-01f, 1.02368638e-01f, -2.94634234e-02f, 2.72120774e-01f,
  1.33685932e-01f, 2.15194002e-01f, -2.14442223e-01f, -1.86435819e-01f, 3.15040231e-01f, 5.23018911e-02f, -2.98206836e-01f, 5.21728070e-03f, 1.31459862e-01f, -8.81437734e-02f,
  3.02323967e-01f, -3.74342024e-01f, 1.58172116e-01f, -4.28793915e-02f, 4.46977392e-02f, -1.32977694e-01f, 1.77404344e-01f, -3.68296266e-01f, -4.38182354e-01f, -6.45118728e-02f,
  -2.61209488e-01f, 3.12074006e-01f, -3.05890471e-01f, 3.33171673e-02f, 9.54883471e-02f, -3.31394315e-01f, 1.87518954e-01f, 1.91712275e-01f, 1.42202586e-01f, 4.35684472e-01f,
  -1.06142424e-02f, -3.59193534e-01f, -3.31156522e-01f, -2.06846803e-01f, -1.54767290e-01f, -9.82178524e-02f, 9.36564803e-02f, -3.27592194e-01f, -7.93095604e-02f, -1.32109463e-01f,
  -2.26510435e-01f, 2.06413239e-01f, -2.62317825e-02f, 8.03923458e-02f, -2.22768381e-01f, -3.48288804e-01f, 2.56931372e-02f, 8.95365551e-02f, 4.39081304e-02f, -7.03261718e-02f,
  5.21506481e-02f, -1.92479774e-01f, -2.32490018e-01f, 1.69267267e-01f, -2.48372126e-02f, 1.52698690e-02f, -1.27623349e-01f, -2.12929115e-01f, -3.74064624e-01f, 3.09398562e-01f,
  3.38641167e-01f, 2.54833251e-01f, 5.81062511e-02f, -2.36540571e-01f, -2.73185015e-01f, -9.43623483e-02f, -3.57030839e-01f, -6.74463585e-02f, 6.67461520e-03f, 1.62022203e-01f,
  -2.30589002e-01f, 1.82707891e-01f, 9.38938782e-02f, -1.02725118e-01f, 7.96019584e-02f, 7.81126916e-02f, 1.76163048e-01f, -4.00566190e-01f, 6.18208982e-02f, 1.37375847e-01f,
  -1.18275724e-01f, -1.40203908e-01f, 6.45234659e-02f, 8.85262489e-02f, -6.44264162e-01f, -2.90340215e-01f, 1.17796287e-01f, 1.98358476e-01f, 1.32664695e-01f, -1.87224194e-01f,
  -2.40808561e-01f, -2.55388618e-01f, -1.92350764e-02f, -3.05049181e-01f, -3.66404295e-01f, -1.66735247e-01f, 1.30519690e-02f, 2.02526152e-01f, -6.05647601e-02f, -1.74534306e-01f,
  -2.44886771e-01f, -4.04348701e-01f, -2.07507387e-02f, 2.38264576e-01f, 4.35284525e-02f, -1.85030624e-01f, 2.39149094e-01f, -7.81099647e-02f, 2.30291963e-01f, -2.20653892e-01f,
  5.15945069e-02f, 5.35043282e-03f, -1.33566916e-01f, -1.45308405e-01f, 1.44452900e-01f, -1.94226325e-01f, 8.62259492e-02f, 7.92481527e-02f, 1.83906019e-01f, -1.98473379e-01f,
  -5.35974242e-02f, -2.27165921e-03f, -1.22866400e-01f, 4.57623973e-04f, -1.10432394e-01f, -1.11530557e-01f, -9.22306813e-03f, 1.37787268e-01f, 2.74803583e-03f, 1.54539719e-01f,
  6.97952658e-02f, 1.48299828e-01f, 2.52735466e-02f, -2.12338999e-01f, -1.24839351e-01f, 3.45716715e-01f, 2.51328319e-01f, -5.44510558e-02f, 1.52441218e-01f, 1.54511124e-01f,
  2.02961937e-01f, -2.53006548e-01f, -3.38984996e-01f, -1.62687168e-01f, -2.39751115e-01f, -2.80290365e-01f, -3.83555472e-01f, 3.20038199e-01f, 4.72020777e-03f, 8.13270360e-02f,
  -3.36915821e-01f, -4.07753855e-01f, -1.99379802e-01f, 1.55404657e-01f, -1.02332175e-01f, -1.19064681e-01f, 7.40247443e-02f, -1.71209157e-01f, 2.31573164e-01f, -1.10508047e-01f,
  -3.49072255e-02f, 2.87719574e-02f, -5.08139953e-02f, 5.15423575e-03f, -2.26320788e-01f, -3.69329527e-02f, -1.67816922e-01f, -2.28965491e-01f, -1.15868933e-01f, 8.72776434e-02f,
  -1.48469016e-01f, 1.06191456e-01f, -8.64915028e-02f, 2.46999562e-01f, 1.79183021e-01f, -4.06820886e-02f, 1.87442586e-01f, 3.84482630e-02f, -1.18874172e-02f, 1.17173642e-01f,
  -9.03625041e-02f, 1.32241011e-01f, 1.35505591e-02f, -1.53442860e-01f, 1.11969057e-02f, 1.49969593e-01f, -8.36807191e-02f, 2.73195267e-01f, 1.53854474e-01f, 3.75143178e-02f,
  -1.15880996e-01f, -7.04485402e-02f, -2.20277444e-01f, -9.60696861e-02f, 1.75767332e-01f, -2.26384014e-01f, 3.39721143e-01f, -5.55891022e-02f, -1.82591975e-01f, -1.71340436e-01f,
  -3.94681364e-01f, -7.64504746e-02f, -1.63138062e-01f, 9.38244455e-04f, -4.24730867e-01f, 2.27093920e-01f, 2.43178103e-02f, 2.73188025e-01f, 1.59503400e-01f, -2.40847275e-01f,
  -2.42356643e-01f, -2.59124160e-01f, -1.52851924e-01f, -2.46872567e-02f, 4.54583131e-02f, -1.20779745e-01f, 1.88589156e-01f, -9.20219496e-02f, 2.98609734e-01f, 2.87247807e-01f,
  -1.26140773e-01f, 1.03376716e-01f, 5.95916547e-02f, 1.09291486e-01f, 3.62389684e-01f, -9.59279388e-02f, -2.38541812e-01f, 3.18977028e-01f, -9.77000222e-02f, -2.29150966e-01f,
  1.84665665e-01f, -1.35820404e-01f, -1.17196754e-01f, -7.62545988e-02f, -1.20725051e-01f, -9.70419794e-02f, 2.36874044e-01f, -1.45061597e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.99507512e-02f, 5.25537133e-02f, 1.91015042e-02f, -1.41257808e-01f, 1.48280412e-02f, 1.07853018e-01f, -1.49254516e-01f, -4.36072275e-02f, 4.05930281e-02f, 3.61436349e-03f,
  -9.37520117e-02f, -1.72785074e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    