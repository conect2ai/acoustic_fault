/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.01571190e-01f, 1.10213608e-01f, -8.58004242e-02f, -2.60037363e-01f, -1.26627192e-01f, -1.30940750e-01f, 9.79238451e-02f, -2.75948755e-02f, -1.79404274e-01f, -3.96644697e-03f,
  -1.15376391e-01f, -2.87421525e-01f, -1.95826516e-01f, -1.23606436e-01f, -3.56368721e-02f, 1.37362942e-01f, 6.50651455e-02f, -5.17122447e-02f, -9.28930864e-02f, -3.83464023e-02f,
  -5.03190383e-02f, -3.38474996e-02f, -1.98774189e-01f, -4.60218079e-02f, 2.35367380e-02f, -1.16969801e-01f, -3.99777405e-02f, -1.98709846e-01f, -1.79196894e-02f, 9.11445990e-02f,
  -1.29243052e-02f, -2.48216512e-03f, -1.85455248e-01f, -7.22882897e-02f, -9.53187048e-02f, -6.19150922e-02f, -1.01554781e-01f, -8.19467232e-02f, -1.14141047e-01f, -2.64204182e-02f,
  -1.47714064e-01f, 7.42371473e-03f, -3.47298831e-02f, -1.01946168e-01f, -8.46576616e-02f, -1.07009694e-01f, -7.98252504e-03f, -8.32743123e-02f, -2.64413320e-02f, -6.49380609e-02f,
  6.54059649e-03f, -1.96910992e-01f, -1.46623462e-01f, -4.05150317e-02f, -1.69610023e-01f, -1.41981304e-01f, -1.16913684e-01f, -1.60438582e-01f, -7.50792623e-02f, -7.66367763e-02f,
  6.23847991e-02f, 8.63355771e-03f, -3.08503229e-02f, 8.86309594e-02f, 5.14406227e-02f, 3.95182371e-02f, 5.28025590e-02f, 1.75021030e-02f, 1.21274494e-01f, 1.19864531e-02f,
  3.43473181e-02f, 1.55187011e-01f, 5.09698577e-02f, 1.16499342e-01f, 1.57021984e-01f, 1.05066836e-01f, -4.93044816e-02f, 8.49444792e-02f, 7.10182786e-02f, 2.24651471e-02f,
  1.09608307e-01f, -2.42656213e-03f, 8.54290649e-02f, 1.48816302e-01f, 5.57123423e-02f, 5.04350699e-02f, 7.53348842e-02f, 5.24053276e-02f, 8.29131454e-02f, 5.55554889e-02f,
  -1.74458370e-01f, -2.47921720e-01f, -1.35351226e-01f, 7.25303143e-02f, -1.61764428e-01f, -1.54601812e-01f, -9.25778076e-02f, -6.77198991e-02f, -7.29277879e-02f, -1.27896026e-01f,
  -1.22969806e-01f, -6.78710639e-02f, -9.48937163e-02f, -5.59693053e-02f, -5.45536866e-03f, -1.13853514e-01f, -1.37689775e-02f, -5.42979836e-02f, -5.12157194e-02f, -1.74564421e-01f,
  -1.24465130e-01f, -1.36166736e-01f, -1.44225150e-01f, -1.03079617e-01f, -1.07577376e-01f, -2.37752482e-01f, -1.47599906e-01f, -7.15559050e-02f, -1.68818608e-01f, -5.11875749e-02f,
  -7.42677748e-02f, 2.02362552e-01f, 1.35634929e-01f, -2.87729595e-02f, 2.15801634e-02f, -2.61431728e-02f, 8.94349515e-02f, 4.06867526e-02f, -1.48127854e-01f, 4.59683686e-03f,
  -1.62347823e-01f, -2.05792636e-01f, -1.45575836e-01f, -9.61864591e-02f, -1.44444600e-01f, 2.25173146e-01f, 2.01973215e-01f, 2.83486079e-02f, -2.47931123e-01f, -1.73929840e-01f,
  -8.03829432e-02f, 3.10925841e-02f, -7.71349370e-02f, -5.39790615e-02f, 1.10836141e-01f, -8.12643468e-02f, 2.26227999e-01f, 1.44886628e-01f, 1.16737261e-02f, 3.24759692e-01f,
  3.47205736e-02f, 1.37315452e-01f, -1.30211189e-01f, -3.62318456e-02f, 1.11451738e-01f, -1.10655889e-01f, 3.01993825e-03f, -2.78412793e-02f, 2.23684050e-02f, -8.48301593e-03f,
  6.06994070e-02f, 3.81616950e-02f, -8.36486369e-02f, 8.40268433e-02f, 1.36007339e-01f, 5.66777494e-03f, -7.15030066e-04f, 1.09879613e-01f, 3.01917866e-02f, -6.59462065e-03f,
  -1.02194525e-01f, 8.37419033e-02f, 1.50366768e-01f, 2.64976028e-04f, 3.65944207e-02f, -8.49063173e-02f, 1.17762260e-01f, 1.08223781e-01f, 8.02162439e-02f, 2.68147200e-01f,
  -3.41450833e-02f, -8.36975290e-04f, 3.48339439e-03f, 2.39501484e-02f, -3.26327570e-02f, 6.49330392e-02f, 8.50714222e-02f, 4.91056852e-02f, -5.29693440e-02f, 5.01722889e-03f,
  1.93758029e-02f, -1.51342666e-02f, 7.73325935e-02f, 5.71225174e-02f, 3.36140990e-02f, 9.47707295e-02f, 8.01140592e-02f, 8.52367096e-03f, 6.31250814e-02f, -5.00646867e-02f,
  -2.36598421e-02f, 7.10213929e-02f, 5.28338514e-02f, -4.19813488e-03f, -2.23518722e-02f, 1.05230115e-01f, 7.95277283e-02f, -4.66184095e-02f, -4.59002936e-03f, 9.63232666e-02f,
  -1.04357868e-01f, -1.18846290e-01f, -8.07472393e-02f, -8.16740692e-02f, 4.01804335e-02f, 4.18789830e-04f, -4.02943343e-02f, -6.94604740e-02f, 2.15726122e-02f, -6.25194283e-03f,
  -4.78082001e-02f, 4.96048518e-02f, 5.24834171e-03f, -3.72176967e-03f, -1.79825518e-02f, -1.19101116e-03f, -8.03842396e-03f, 4.55172993e-02f, -3.22777554e-02f, 6.05282038e-02f,
  -3.66517715e-02f, 4.07183357e-03f, -1.24458306e-01f, -3.80658098e-02f, -1.88812409e-02f, 1.04866410e-02f, -2.77552567e-02f, -6.52511232e-03f, -5.15372260e-03f, -1.12043554e-02f,
  5.03359854e-01f, 3.94661486e-01f, -1.75962687e-01f, 2.29642689e-01f, -1.04089625e-01f, -9.01997462e-02f, -1.90156445e-01f, -2.08118954e-03f, 1.25255182e-01f, 2.76844315e-02f,
  -3.16691659e-02f, -8.39411095e-02f, 3.52497362e-02f, 4.99016652e-03f, -9.54749659e-02f, 6.64731953e-03f, 6.66476041e-02f, 7.02066794e-02f, -8.32968205e-02f, -9.13286656e-02f,
  3.88510227e-02f, 1.34748816e-01f, 1.16077699e-01f, 1.14326261e-01f, 1.54445171e-01f, -3.27522159e-02f, 7.47667626e-03f, 8.08637142e-02f, 1.28219873e-02f, 1.74752265e-01f,
  -2.34408855e-01f, 2.48941258e-01f, -5.82401492e-02f, 7.62182772e-02f, 3.74845453e-02f, 1.19416133e-01f, -1.70616135e-02f, 1.01208193e-02f, 1.13653369e-01f, 1.07175924e-01f,
  3.42736207e-02f, 1.06598912e-02f, 1.05218746e-01f, 5.41001223e-02f, 2.34091505e-02f, 9.92687121e-02f, 3.82065699e-02f, 1.67808130e-01f, 7.37434477e-02f, -5.47160693e-02f,
  8.37411582e-02f, 1.78774834e-01f, 6.08313549e-03f, 8.60762596e-03f, -4.27543223e-02f, 1.24680310e-01f, -8.43876600e-02f, -1.86422258e-05f, 3.66037749e-02f, 6.02356791e-02f,
  -6.10695081e-03f, 3.54245026e-03f, -9.88017023e-02f, 3.43499444e-02f, 6.86320942e-03f, -6.62021711e-02f, -1.82020068e-02f, -8.73232037e-02f, -4.29279283e-02f, 7.59823294e-03f,
  -4.88484390e-02f, 3.69626917e-02f, -7.42653832e-02f, -6.11603744e-02f, -4.67136279e-02f, -2.10585147e-02f, -8.69478211e-02f, -1.00486148e-02f, -2.86169723e-02f, -3.38043608e-02f,
  -5.17145917e-03f, -8.98047537e-02f, -4.84701581e-02f, 1.48260938e-02f, 3.11308750e-03f, -1.00640267e-01f, -5.75521998e-02f, -8.24254453e-02f, -3.35467723e-03f, -8.07195827e-02f,
  -1.20495290e-01f, -2.01155558e-01f, 1.68868471e-02f, -8.45328998e-03f, 6.83562309e-02f, -9.63065308e-03f, 4.23369333e-02f, 8.07397440e-02f, 1.23253958e-02f, 3.30738984e-02f,
  -2.56559420e-02f, 8.96115263e-04f, 2.46924181e-02f, 5.27165532e-02f, 2.91726850e-02f, -9.84032080e-02f, 1.78294573e-02f, 3.63008529e-02f, -1.00799091e-02f, 2.24997215e-02f,
  1.18360266e-01f, -1.27146114e-02f, -1.70392767e-02f, 6.04308806e-02f, 2.67975312e-02f, -4.82746176e-02f, -4.64706868e-02f, -6.98233023e-02f, -1.70927346e-01f, -1.16229206e-01f,
  4.18252498e-01f, -1.47055164e-01f, -2.74667412e-01f, 2.43054092e-01f, -1.93508640e-01f, -2.74049789e-01f, -4.10874993e-01f, -1.05361333e-02f, 2.30779335e-01f, 2.32578889e-02f,
  5.23179956e-03f, 1.78044870e-01f, 2.40594774e-01f, 8.05480927e-02f, -7.34764561e-02f, -2.25255609e-01f, -1.58741593e-01f, -8.45810100e-02f, 7.23425746e-02f, 2.22813897e-02f,
  -1.97356716e-02f, 4.89521623e-02f, 2.26208299e-01f, 8.29009190e-02f, 6.20692633e-02f, 1.18708089e-01f, -4.86870110e-02f, 2.09137797e-02f, -1.66958883e-01f, -7.76181072e-02f,
  1.88772439e-03f, -1.93661585e-01f, 7.48685375e-02f, 1.02001272e-01f, -4.76639755e-02f, 9.38133672e-02f, 9.75771695e-02f, 8.43924191e-03f, 8.16772208e-02f, 4.20969874e-02f,
  -3.98008041e-02f, 3.23856585e-02f, 3.42223085e-02f, -3.23193558e-02f, 3.04784402e-02f, 1.04784165e-02f, 2.06838585e-02f, 1.63186863e-02f, 5.23562655e-02f, -5.08970406e-04f,
  -4.02409323e-02f, -4.48130779e-02f, -1.95924327e-01f, -4.82880995e-02f, -2.68711559e-02f, 1.04238093e-01f, -9.83138010e-02f, -2.96487324e-02f, 1.70856100e-02f, 1.30045339e-01f,
  7.05317259e-02f, -1.28326537e-02f, 4.49974053e-02f, 3.62001406e-03f, 2.03039292e-02f, 7.42404684e-02f, 2.18256321e-02f, -3.43431979e-02f, 3.42571735e-03f, -3.06236185e-02f,
  -8.14803615e-02f, 2.12097857e-02f, -1.66275185e-02f, -5.33380061e-02f, 1.81844514e-02f, 8.33751168e-03f, 3.87665704e-02f, 4.65001278e-02f, -4.24494909e-04f, 5.73032163e-02f,
  6.41328394e-02f, -5.26507497e-02f, 5.48389815e-02f, 2.60480586e-02f, 2.12658662e-02f, 5.56917861e-02f, 9.74149071e-03f, 3.84389795e-02f, -2.66912244e-02f, 4.31136191e-02f,
  3.36243033e-01f, -1.50384262e-01f, 1.35953099e-01f, 6.62195217e-03f, -2.66075972e-02f, 6.27034605e-02f, 3.03821382e-03f, -3.30231860e-02f, -2.18704548e-02f, 1.49497595e-02f,
  -1.73065756e-02f, -2.73380917e-03f, -3.77794914e-02f, -1.80171765e-02f, -5.12362942e-02f, 6.39868155e-02f, -4.82719317e-02f, 5.23127243e-03f, -2.69295857e-03f, 4.94999588e-02f,
  1.28179453e-02f, -3.22344601e-02f, 5.80538213e-02f, -8.14663246e-02f, -4.38953154e-02f, 1.29861489e-01f, -7.21433014e-02f, 2.05190461e-02f, 2.12349743e-02f, 8.51794779e-02f,
  7.38183558e-02f, 6.89056590e-02f, 1.76234663e-01f, 1.03997990e-01f, -1.12639949e-01f, -7.78197125e-02f, -1.81686267e-01f, -9.14601162e-02f, 4.98697348e-02f, -1.35248095e-01f,
  6.35423362e-02f, 1.68125873e-04f, -7.44034187e-04f, 6.19071387e-02f, 3.61786690e-03f, -2.37356231e-01f, -2.07895339e-01f, -8.40419084e-02f, -1.87201038e-01f, -1.32581905e-01f,
  -1.73964784e-01f, -5.49989343e-02f, 6.47381768e-02f, -5.09420931e-02f, 5.99516071e-02f, 1.77859310e-02f, -6.57939527e-04f, 2.91239023e-02f, -3.01262625e-02f, -5.89692406e-02f,
  9.68725085e-02f, 2.09206596e-01f, -2.69832648e-02f, -6.19191974e-02f, -1.32155977e-02f, 4.07334268e-02f, -5.37408032e-02f, 6.41945191e-03f, 7.92411622e-03f, 8.15339833e-02f,
  3.14862803e-02f, 5.41338213e-02f, -7.14197531e-02f, 8.36460211e-04f, 1.56477312e-04f, -3.24430801e-02f, -1.67133398e-02f, 1.73833910e-02f, 2.76906583e-02f, -4.08929586e-03f,
  -5.92963696e-02f, -7.07217157e-02f, 4.28434908e-02f, 7.20500275e-02f, 1.90595128e-02f, -6.54810295e-02f, 3.13420519e-02f, 1.26090750e-01f, -1.01484871e-03f, -2.26480104e-02f,
  -1.19766884e-03f, -5.05715534e-02f, -8.73807743e-02f, -1.02061229e-02f, -3.49865519e-02f, -8.24441686e-02f, -5.30790202e-02f, -5.74880801e-02f, -1.46088287e-01f, -5.65782189e-02f,
  -9.87137929e-02f, -1.08687826e-01f, -4.38599810e-02f, -1.48913004e-02f, -7.36994967e-02f, -2.62583364e-02f, -8.58470872e-02f, -4.11205739e-02f, 1.87033694e-02f, 2.41728546e-03f,
  -3.08100451e-02f, -1.76359564e-02f, 4.90513071e-02f, -1.40168026e-01f, -4.85179797e-02f, -5.72377034e-02f, -9.84549820e-02f, -4.57312167e-02f, -2.17671357e-02f, 9.32751875e-03f,
  4.20002379e-02f, 8.64766240e-02f, -2.30519827e-02f, -7.95508698e-02f, 4.73369509e-02f, 2.31298823e-02f, 4.43202592e-02f, 1.69708095e-02f, 2.48181019e-02f, 7.76171610e-02f,
  2.22178493e-02f, 2.25106273e-02f, 9.84544456e-02f, 3.88283841e-02f, -5.32927439e-02f, -4.86610504e-03f, -8.72399583e-02f, 4.60632667e-02f, 7.79632526e-03f, 9.42679346e-02f,
  6.42323270e-02f, -1.26267120e-01f, -1.32954240e-01f, -2.50683147e-02f, 4.97879237e-02f, -4.22346406e-02f, -7.05157733e-03f, -6.90138191e-02f, -7.54021406e-02f, -1.62249625e-01f,
  -1.29071236e-01f, 4.02152129e-02f, 1.72873050e-01f, 1.25588432e-01f, 7.39940107e-02f, -1.63167566e-02f, -1.41963080e-01f, -1.00493081e-01f, -2.86680553e-02f, -2.21063774e-02f,
  1.31717533e-01f, -3.04520335e-02f, 8.38178545e-02f, 5.71778528e-02f, -3.74259613e-02f, 3.85113172e-02f, 1.48338035e-01f, -1.19092697e-02f, -1.75477155e-02f, -5.19598015e-02f,
  -3.40145379e-02f, -3.87663767e-02f, -3.22427414e-02f, -2.91999485e-02f, 8.04918036e-02f, 5.25106899e-02f, 7.34790713e-02f, 8.50160345e-02f, -3.56437303e-02f, 1.40368953e-01f,
  2.05057845e-01f, -2.93028690e-02f, 2.58471556e-02f, 1.73163041e-02f, 5.60986400e-02f, -1.91390023e-01f, -1.40634418e-01f, -3.77145857e-02f, -4.37311716e-02f, 4.94620912e-02f,
  8.22954997e-02f, -7.05540553e-02f, 1.91917177e-02f, -4.44590822e-02f, -8.97080377e-02f, -1.04481407e-01f, 9.43908282e-03f, -1.33981287e-01f, -6.52437881e-02f, 3.24824303e-02f,
  -6.33927574e-03f, 8.92530531e-02f, 3.03434972e-02f, -1.12124912e-01f, 1.38859283e-02f, 1.27479518e-02f, -1.16509832e-01f, -8.56775045e-02f, -1.61301449e-01f, -4.28807847e-02f,
  -1.55787259e-01f, -9.97614488e-02f, -8.45426172e-02f, -1.50784522e-01f, -2.44529042e-02f, -8.09738562e-02f, -3.27321403e-02f, 1.69810671e-02f, -4.97071370e-02f, -3.88900153e-02f,
  -3.08416449e-02f, -5.72871752e-02f, 3.04558780e-02f, -8.27443004e-02f, 1.13498904e-02f, -5.03743216e-02f, -1.50970623e-01f, -3.25457640e-02f, 9.99229681e-03f, -7.80856013e-02f,
  -8.05499777e-02f, -3.89784537e-02f, -1.29135013e-01f, -2.53571961e-02f, -3.57321501e-02f, -4.20507044e-02f, -3.51267611e-03f, -4.44119796e-03f, -4.74730730e-02f, -1.85740739e-01f,
  -6.55154362e-02f, -6.92756567e-03f, 4.13955413e-02f, -2.87289862e-02f, 9.82538238e-02f, 2.84080580e-02f, 5.41614108e-02f, -5.03648669e-02f, 4.94741946e-02f, 1.61031932e-02f,
  -3.77821997e-02f, 5.33177480e-02f, -2.02594381e-02f, -5.25420755e-02f, 8.78711939e-02f, -3.81978089e-03f, -5.79875335e-02f, 6.62027523e-02f, -2.02412941e-02f, 2.24793237e-02f,
  1.71565115e-02f, -9.04883891e-02f, -1.08237788e-01f, -6.57927096e-02f, 9.93662165e-04f, -5.40682003e-02f, 2.15877835e-02f, -1.91305224e-02f, -3.91827300e-02f, -1.68900341e-01f,
  4.01063085e-01f, 1.44782469e-01f, 3.79840553e-01f, 1.24902897e-01f, -1.27302855e-01f, -4.71076332e-02f, 1.24445617e-01f, -1.91418435e-02f, -9.63654742e-02f, 3.86142805e-02f,
  -1.19356327e-01f, -1.01441927e-01f, 1.98104698e-02f, -1.03083186e-01f, 1.24918751e-01f, 1.23588577e-01f, -1.50163630e-02f, 1.99923754e-01f, 2.42378429e-01f, -6.14970028e-02f,
  -8.83185640e-02f, 1.88949600e-01f, 1.69512987e-01f, 1.58857092e-01f, -4.29904424e-02f, -4.43403348e-02f, 1.70427412e-01f, -1.15924245e-02f, 3.85560244e-02f, -9.73359942e-02f,
  1.99525476e-01f, 1.59522146e-01f, -1.45846903e-02f, -2.17956752e-02f, 1.86518840e-02f, 6.51387945e-02f, 9.30699147e-03f, 2.95869820e-02f, 1.78895369e-02f, 1.91162471e-02f,
  -5.57641387e-02f, -5.85422777e-02f, -5.20619676e-02f, -3.99561599e-02f, 7.95780867e-02f, 4.98181470e-02f, 6.94132894e-02f, 1.45957246e-01f, 1.12188689e-01f, 6.53594285e-02f,
  -1.76665500e-01f, 1.05422400e-02f, 1.74473986e-01f, 6.31323978e-02f, 6.00889735e-02f, -7.74000734e-02f, 1.62574574e-01f, -2.23054346e-02f, 8.96623433e-02f, 2.35635877e-01f,
  -9.36605930e-02f, -3.10349781e-02f, -1.70371175e-01f, 9.60565638e-03f, 2.06153747e-03f, -7.90729523e-02f, -7.71209821e-02f, -1.08316287e-01f, -3.35479937e-02f, 8.16547796e-02f,
  7.04287812e-02f, -1.35417804e-02f, -4.22720425e-02f, 7.62044340e-02f, -5.64992353e-02f, -8.09993446e-02f, -8.22815076e-02f, -6.05369024e-02f, 7.68868253e-04f, -7.11593330e-02f,
  -5.68113662e-03f, -4.10363078e-02f, -2.24251095e-02f, 2.13528518e-02f, -3.26465927e-02f, -9.63717885e-03f, -5.47386967e-02f, -1.73185263e-02f, 5.25185242e-02f, -1.35208732e-02f,
  1.63294956e-01f, -1.32846227e-02f, 4.53999639e-02f, -8.86271708e-03f, -1.16251884e-02f, 3.74952592e-02f, 5.58501743e-02f, 1.60927158e-02f, 1.14335092e-02f, 7.99591392e-02f,
  -1.16503602e-02f, -4.94966991e-02f, 7.61998966e-02f, 4.21335027e-02f, 3.78814852e-03f, 1.26132235e-01f, 2.02836562e-02f, 7.59424940e-02f, 7.77592435e-02f, 2.22675726e-02f,
  9.50643495e-02f, 1.45484388e-01f, 1.20599538e-01f, 1.71021745e-01f, 6.32810891e-02f, 7.05882981e-02f, 2.00117037e-01f, 8.74394085e-03f, 1.27126396e-01f, 3.15686285e-01f,
  -2.76181966e-01f, -1.47542298e-01f, -2.85640031e-01f, 1.12510361e-01f, 7.09658563e-02f, -2.64574457e-02f, -1.42629683e-01f, -1.86156738e-03f, 1.46992788e-01f, 1.09603472e-01f,
  -5.06731234e-02f, -2.35297531e-02f, -9.97634977e-02f, 2.47453637e-02f, -3.57182264e-01f, -1.67265803e-01f, -2.15716846e-02f, -2.48529166e-01f, -1.40691906e-01f, 5.40858395e-02f,
  1.49410635e-01f, 3.28018479e-02f, -1.44218439e-02f, -5.73650785e-02f, 1.31638139e-01f, 4.40064259e-02f, 2.63155438e-02f, 9.65777859e-02f, 6.26377612e-02f, 7.01446384e-02f,
  -1.69430107e-01f, -1.44367754e-01f, -2.88947374e-02f, 4.08816971e-02f, -9.16011333e-02f, -4.57148142e-02f, -1.07203247e-02f, -4.76706512e-02f, 5.52596152e-02f, 3.91205214e-02f,
  5.45793325e-02f, 3.60515043e-02f, 3.51720341e-02f, 6.07917942e-02f, 6.69957995e-02f, 5.09772077e-02f, 1.16460420e-01f, 1.58013273e-02f, -6.00987487e-02f, -3.60269360e-02f,
  4.49397676e-02f, 4.92940396e-02f, -1.26896948e-01f, 3.06769181e-02f, -2.01260634e-02f, -3.08790319e-02f, 3.04455087e-02f, -4.45305593e-02f, -5.74573688e-02f, -5.28735854e-02f,
  -7.03814551e-02f, -9.65760499e-02f, 4.92689349e-02f, -7.91673139e-02f, 4.80966195e-02f, 2.79414374e-02f, 2.96909977e-02f, 2.91932225e-02f, -6.18040450e-02f, 1.05189398e-01f,
  -1.68138947e-02f, -6.78969268e-03f, -7.76371434e-02f, 5.05096186e-03f, -7.44612217e-02f, -2.98273731e-02f, -1.18934619e-03f, -2.79760193e-02f, -1.70811787e-02f, 2.57192412e-03f,
  -2.14782953e-02f, 7.07950965e-02f, -4.72767018e-02f, -6.91344365e-02f, -1.24350255e-02f, -6.15503602e-02f, 8.29973966e-02f, 5.55849262e-02f, 2.99087036e-02f, 5.15420213e-02f,
  1.01597048e-02f, -2.39868596e-01f, -1.15992077e-01f, -3.39158550e-02f, -3.89577784e-02f, 7.90053234e-02f, -3.47704925e-02f, 1.49562606e-03f, -1.04008391e-02f, -3.57421786e-02f,
  -3.97817045e-02f, -8.07124749e-02f, 3.70683934e-04f, 8.69770721e-03f, 1.76823717e-02f, -4.61554341e-02f, -2.61616167e-02f, -8.39802921e-02f, -5.30169196e-02f, 5.23579456e-02f,
  -3.56665514e-02f, 3.96112762e-02f, -1.59483135e-01f, -9.14250463e-02f, -6.27290905e-02f, -1.71535298e-01f, -4.19698469e-02f, -6.07303083e-02f, -1.87176079e-01f, -9.56949070e-02f,
  2.81245351e-01f, -2.91889776e-02f, -2.28184849e-01f, 1.49079189e-01f, -4.86749448e-02f, -1.82739243e-01f, -1.32358134e-01f, -8.44721273e-02f, 3.12435795e-02f, -1.46560058e-01f,
  -1.99044913e-01f, -2.14533404e-01f, -2.27205038e-01f, -2.83179969e-01f, -2.14570463e-01f, -1.27711818e-01f, -1.72849521e-01f, -1.49195623e-02f, -1.10194743e-01f, 6.89575355e-03f,
  -5.51876388e-02f, 1.24923319e-01f, 1.90712869e-01f, 1.41926231e-02f, -1.43379457e-02f, -3.59052308e-02f, -1.18634276e-01f, -2.33992692e-02f, -2.58973747e-01f, -1.58257298e-02f,
  -1.83256462e-01f, -9.40370634e-02f, -2.53132224e-01f, -1.07770182e-01f, -1.75665766e-01f, 1.76034290e-02f, -8.11885372e-02f, -1.11996777e-01f, -1.90557316e-01f, -2.15051800e-01f,
  -6.46393523e-02f, -2.09306121e-01f, -1.46406621e-01f, -1.68293640e-01f, -1.20976858e-01f, -6.98317289e-02f, -1.63882717e-01f, -4.12194505e-02f, -1.51531875e-01f, -1.88093603e-01f,
  -2.31765553e-01f, -7.19640404e-02f, -2.00870097e-01f, -2.04264954e-01f, -1.71170071e-01f, -9.08049420e-02f, -2.01909363e-01f, -1.90122902e-01f, -2.59738564e-01f, -1.45296544e-01f,
  1.52494563e-02f, 9.08840746e-02f, 1.20809060e-02f, 4.16253880e-02f, 4.61861752e-02f, 2.43424624e-03f, 1.70773747e-05f, 3.28950770e-02f, 9.21624899e-02f, 7.60953724e-02f,
  -6.75325328e-03f, 3.74531522e-02f, 9.15528759e-02f, 7.33125508e-02f, 1.55084040e-02f, 6.59764633e-02f, 5.59919178e-02f, 2.30169352e-02f, 2.14809217e-02f, 9.71041992e-02f,
  9.46154445e-02f, 1.36481086e-02f, 1.31205827e-01f, 3.21308933e-02f, 4.85393256e-02f, 9.94802266e-02f, 7.78569356e-02f, 1.18530571e-01f, 7.28883520e-02f, 1.12502888e-01f,
  -2.09021661e-02f, -2.00164765e-01f, -9.83091742e-02f, -2.35065922e-01f, -1.52965471e-01f, -1.21567339e-01f, -9.90490615e-02f, -1.88264817e-01f, -1.69310570e-01f, -9.78213474e-02f,
  -1.35789990e-01f, -1.68060839e-01f, -1.89006135e-01f, -1.59153864e-01f, -3.83442827e-02f, -6.10231534e-02f, -2.15209246e-01f, -1.63314298e-01f, -9.63956341e-02f, -7.37482160e-02f,
  -1.88654274e-01f, -6.42514527e-02f, 4.09706011e-02f, -1.14753790e-01f, -1.74979270e-01f, -1.03816561e-01f, -1.97673261e-01f, -6.26003295e-02f, -1.38988674e-01f, -1.28350407e-01f,
  -1.54131770e-01f, -6.06226623e-02f, -2.18483657e-01f, 7.15078115e-02f, -1.10656381e-01f, -8.26945081e-02f, -1.48150757e-01f, 2.42132377e-02f, 8.44233632e-02f, -1.21981338e-01f,
  -3.80613208e-01f, -2.85296112e-01f, -2.20250517e-01f, -2.00397253e-01f, -7.44186193e-02f, 6.11627698e-02f, 1.91640958e-01f, -7.52422586e-02f, -7.64423087e-02f, -1.26635715e-01f,
  1.59051463e-01f, 1.29917175e-01f, -2.92292610e-02f, 1.50538534e-01f, 2.41179094e-01f, 5.37755620e-03f, 1.58620421e-02f, 2.88181715e-02f, -6.26590326e-02f, 2.17276722e-01f,
  -2.53209323e-01f, -1.99938074e-01f, -2.15194151e-02f, -5.55024706e-02f, -2.35036314e-01f, -1.34301290e-01f, -9.38687921e-02f, -4.95479964e-02f, -1.49877876e-01f, -2.32063676e-03f,
  -2.28639051e-01f, -8.78299251e-02f, -1.77728966e-01f, -1.07721619e-01f, -3.12080383e-02f, -1.04789250e-01f, -5.07937036e-02f, -2.71694120e-02f, -1.51454046e-01f, -8.46551210e-02f,
  6.37795590e-03f, -2.08914727e-01f, -2.55144536e-01f, -7.15284795e-02f, -4.10698019e-02f, -3.74598354e-02f, -1.23742849e-01f, 1.10723460e-02f, -1.03324041e-01f, -4.93931100e-02f,
  4.39217240e-02f, -6.94436580e-02f, -2.50091124e-02f, -1.00984104e-01f, -9.97192413e-02f, 2.16398537e-02f, -4.01258096e-02f, -3.21146660e-02f, -4.43499871e-02f, 9.67319459e-02f,
  -1.16651908e-01f, -2.47566346e-02f, -6.18178397e-02f, -1.22616723e-01f, -2.31787898e-02f, -3.27041149e-02f, -4.98682112e-02f, 6.49500266e-02f, -6.72180206e-02f, -7.72120357e-02f,
  -5.04246540e-02f, 1.72610302e-02f, 8.32493231e-03f, -9.35586244e-02f, -3.56958099e-02f, -2.64506396e-02f, -3.80410850e-02f, 3.78444232e-02f, -5.00219427e-02f, -4.10429277e-02f,
  -1.90288484e-01f, -1.70784414e-01f, -1.07668852e-02f, 2.69599464e-02f, -4.09900323e-02f, 1.54172233e-03f, -1.07185081e-01f, -8.19386691e-02f, -1.16608106e-01f, -1.99687686e-02f,
  -9.14388672e-02f, -6.37961328e-02f, -7.46018589e-02f, 4.68410105e-02f, -5.93286529e-02f, 5.92127666e-02f, 6.25358298e-02f, -5.30528240e-02f, -2.73569906e-03f, -3.22159566e-02f,
  1.80757586e-02f, 3.16404290e-02f, 5.67252515e-03f, 6.75080984e-04f, -1.13638649e-02f, -1.64929971e-01f, -1.53713539e-01f, -4.12397571e-02f, -1.66596115e-01f, -1.10808769e-02f,
  -3.28618765e-01f, -9.19415206e-02f, -1.18387723e-02f, -3.63072425e-01f, -7.63540193e-02f, 2.01858524e-02f, 1.14611937e-02f, 1.56000271e-01f, 3.28503214e-02f, -3.62479985e-02f,
  7.33391056e-03f, 5.69877476e-02f, 2.11348925e-02f, 8.81058797e-02f, 1.60239622e-01f, -2.02571228e-02f, -1.45016357e-01f, -7.57867545e-02f, 2.13305518e-01f, 1.76631793e-01f,
  8.04447606e-02f, -7.31312186e-02f, 1.83414873e-02f, 2.49417648e-02f, -1.81937907e-02f, 1.24263316e-01f, 1.23258084e-02f, -1.01258546e-01f, -1.09679513e-02f, -1.49932995e-01f,
  2.20347866e-02f, -8.25471655e-02f, 6.35398328e-02f, 5.08691408e-02f, -8.75383709e-03f, 2.89670527e-02f, 5.00394255e-02f, 1.09125294e-01f, 1.34119108e-01f, 6.98810369e-02f,
  -3.51862162e-02f, 4.37673032e-02f, 2.83518527e-02f, 1.40847161e-01f, 6.42323419e-02f, 7.33504370e-02f, 1.69529870e-01f, 9.90649238e-02f, 1.26482412e-01f, 7.08186924e-02f,
  -3.55260330e-03f, -2.85174772e-02f, 7.89123103e-02f, 1.59930587e-01f, 1.65198371e-01f, 6.53437227e-02f, 1.74045876e-01f, 3.04705165e-02f, 2.01117754e-01f, 9.58812833e-02f,
  -7.33231828e-02f, 7.21943751e-02f, 7.02642351e-02f, 2.09613834e-02f, -6.32565171e-02f, -4.24990878e-02f, -4.45107976e-03f, 7.50977471e-02f, -1.28761493e-03f, -9.21595991e-02f,
  6.80076778e-02f, -7.65894577e-02f, -6.20408170e-02f, -5.40170223e-02f, 9.42852162e-03f, -5.82285300e-02f, -1.38277952e-02f, -1.00276973e-02f, 7.33596236e-02f, -1.03305906e-01f,
  2.42370572e-02f, 1.08106814e-01f, -3.49713825e-02f, 3.62931825e-02f, -5.27305854e-03f, -2.63080164e-03f, -8.20687856e-04f, -2.19119508e-02f, -1.06049757e-02f, 5.91884647e-03f,
  1.67653784e-01f, 2.47834045e-02f, -2.36929627e-03f, 1.52971357e-01f, 5.81730902e-02f, 1.42175242e-01f, -9.55381021e-02f, 1.74706265e-01f, -4.00898559e-03f, 7.64094368e-02f,
  7.85273165e-02f, -3.38924229e-02f, -1.09835733e-02f, 1.46616414e-01f, 1.11522406e-01f, 6.30497113e-02f, 3.99241447e-02f, 2.25785617e-02f, 3.61870676e-02f, 1.47993401e-01f,
  1.14335164e-01f, 1.28532782e-01f, 1.75758004e-02f, 2.34014317e-01f, 1.20083816e-01f, 1.14704736e-01f, 1.33405879e-01f, 1.18361264e-01f, 2.17573360e-01f, 1.54034600e-01f,
  -3.00436646e-01f, 2.70303339e-02f, -7.59475902e-02f, -1.26674607e-01f, 2.16615677e-01f, 8.17093700e-02f, 3.82991396e-02f, -1.27716502e-02f, -6.07801229e-02f, 4.28471565e-02f,
  2.27857664e-01f, 2.04728052e-01f, 6.09207600e-02f, 1.36279628e-01f, 1.69078670e-02f, 3.23626325e-02f, 4.57463153e-02f, -5.87507300e-02f, -7.87207410e-02f, 1.07150994e-01f,
  6.89390972e-02f, -8.02930668e-02f, -2.39673600e-01f, -8.04690495e-02f, 1.66588649e-02f, 6.17412217e-02f, -4.90804389e-02f, -5.70139810e-02f, 8.72354284e-02f, -3.11683817e-03f,
  1.82360094e-02f, 1.87458079e-02f, 1.23985641e-01f, 1.04174383e-01f, 1.87476322e-01f, -6.72766119e-02f, 1.94961822e-03f, 3.04414239e-03f, -1.13202324e-02f, -5.31849153e-02f,
  1.38907060e-01f, 1.20113984e-01f, 4.21237247e-03f, 1.08062878e-01f, -4.10471149e-02f, -8.13769549e-02f, -4.60284501e-02f, 6.35338016e-03f, 7.04531223e-02f, 1.01251639e-02f,
  9.63977575e-02f, 5.14981598e-02f, 2.27228794e-02f, 1.66947618e-02f, 1.15280420e-01f, -1.42776882e-02f, 6.19526990e-02f, -1.48334056e-02f, -1.20748300e-02f, -1.09447669e-02f,
  4.10214588e-02f, 1.39506951e-01f, 7.94473365e-02f, -2.96628214e-02f, -1.84199400e-02f, 1.34421168e-02f, 2.71646716e-02f, 8.60325061e-03f, -9.63592436e-03f, 3.98632549e-02f,
  1.82879847e-02f, 7.64166191e-02f, 3.38859744e-02f, -9.19536799e-02f, 1.74358319e-02f, -7.54614361e-03f, -1.12479767e-02f, 2.59386506e-02f, -1.67908166e-02f, -6.23569563e-02f,
  7.12598562e-02f, -1.84633899e-02f, -1.27122905e-02f, 2.14051325e-02f, 1.91367883e-02f, 4.27077711e-03f, -4.37133312e-02f, 6.62179142e-02f, -2.98166815e-02f, 2.55159121e-02f,
  -2.16702774e-01f, 1.36571124e-01f, -8.84515345e-02f, -2.29137428e-02f, -6.17854744e-02f, 2.58985553e-02f, 5.79732731e-02f, 7.21235871e-02f, 9.03904587e-02f, 7.21232444e-02f,
  6.31293096e-03f, -1.18704662e-01f, -5.34804277e-02f, 1.54458061e-02f, 5.41687049e-02f, 3.12609784e-02f, 5.94479702e-02f, 6.49886653e-02f, 5.22192232e-02f, 6.95228279e-02f,
  -5.10105789e-02f, -1.25026226e-01f, -8.92199799e-02f, -2.58996878e-02f, 4.98977862e-03f, -2.05157250e-02f, -3.14183459e-02f, -2.40576081e-03f, -3.62372771e-02f, -2.09597811e-01f,
  3.51789713e-01f, 2.82357991e-01f, 2.47557461e-01f, 3.52808893e-01f, 1.48419797e-01f, 6.50889287e-03f, 2.14915261e-01f, 8.56971443e-02f, 5.06536625e-02f, 9.90290940e-02f,
  3.32488418e-02f, 3.11994855e-03f, 2.80916784e-02f, -6.35752156e-02f, -4.13650908e-02f, 1.80019706e-01f, 1.88632101e-01f, 6.45784512e-02f, -4.12486680e-02f, -1.20744407e-01f,
  -5.59696890e-02f, 6.64750114e-02f, -1.65472291e-02f, -5.96984848e-02f, 1.78137153e-01f, -3.73737700e-03f, 1.35224238e-01f, 5.01203723e-02f, 1.18996138e-02f, 1.60268098e-01f,
  1.67416394e-01f, 3.20400894e-01f, 5.20556904e-02f, 1.83298700e-02f, 1.64791226e-01f, 1.56585351e-01f, 1.32037878e-01f, 5.76155633e-02f, 1.09936826e-01f, 1.47088036e-01f,
  1.68088108e-01f, 1.11990809e-01f, 1.82670355e-01f, 7.70425200e-02f, 2.03143016e-01f, 6.88455626e-02f, 7.60535151e-02f, 1.12513535e-01f, 1.58599213e-01f, 9.92176831e-02f,
  1.30817562e-01f, 9.38827321e-02f, 1.18035920e-01f, 1.02733700e-02f, -2.82646678e-02f, 5.91052137e-02f, 2.73888726e-02f, 6.10109558e-03f, 4.54455167e-02f, 1.44213811e-01f,
  -2.80853100e-02f, -7.13576600e-02f, -7.51162991e-02f, -4.88401875e-02f, -7.78174549e-02f, -6.89410269e-02f, 2.36722408e-04f, -9.90797952e-02f, -4.20062803e-02f, -7.25743771e-02f,
  4.43719476e-02f, -3.40634473e-02f, -4.54167053e-02f, 1.27483800e-01f, -6.34154454e-02f, -6.38740435e-02f, -4.48744558e-02f, 4.55367602e-02f, -4.39373869e-03f, -1.90571081e-02f,
  4.03821729e-02f, 3.39043955e-03f, 4.59393971e-02f, -1.23221770e-01f, 5.44599667e-02f, -2.43589655e-02f, -3.49432863e-02f, -3.49609479e-02f, 3.23665515e-02f, 7.10006952e-02f,
  1.17440253e-01f, 6.56260848e-02f, 1.32360667e-01f, 2.98668281e-03f, 1.72741991e-02f, 3.17877829e-02f, 7.44608045e-02f, 7.57387057e-02f, 1.28176317e-01f, 9.37721208e-02f,
  7.98438117e-02f, 1.39763936e-01f, 1.16992950e-01f, 1.10195376e-01f, 3.95169519e-02f, 7.66530782e-02f, 1.41334385e-01f, 4.02150042e-02f, -3.94476503e-02f, 1.11391366e-01f,
  1.31936461e-01f, -3.55516933e-02f, -1.36899622e-03f, 3.16961072e-02f, -3.58676501e-02f, 1.17277525e-01f, 8.04157257e-02f, -6.56110197e-02f, 4.89954539e-02f, 3.95445600e-02f,
  -4.16853558e-03f, 1.69978112e-01f, 1.95896253e-01f, -4.47494388e-02f, -3.37701440e-02f, 7.41013065e-02f, 2.79988199e-01f, -3.95742282e-02f, -1.67516723e-01f, 1.22602083e-01f,
  -2.02138007e-01f, -2.63054788e-01f, -1.69019267e-01f, -2.25381941e-01f, -8.80895332e-02f, 1.22587778e-01f, 2.17312902e-01f, -5.21521308e-02f, -5.38237765e-02f, -2.72226334e-03f,
  -1.32699251e-01f, -1.80931631e-02f, -3.34153920e-02f, -1.00835614e-01f, -4.83899638e-02f, -1.40235707e-01f, 6.43638819e-02f, 4.19551320e-02f, -2.36095209e-02f, 1.31838962e-01f,
  1.05907895e-01f, 5.44077940e-02f, -1.12237461e-01f, -1.74804509e-01f, -4.37833928e-02f, -1.08408533e-01f, -6.32326603e-02f, -4.92080823e-02f, -1.11808471e-01f, -4.68758084e-02f,
  -9.45019200e-02f, 6.49156654e-03f, -5.80804832e-02f, -1.87288783e-02f, 8.99537839e-03f, 4.94176289e-03f, -2.10653748e-02f, -2.05619894e-02f, -4.42238078e-02f, -4.79139723e-02f,
  -5.57356998e-02f, -3.76901440e-02f, -2.07903907e-02f, 7.49510713e-03f, -5.40209785e-02f, -9.31355655e-02f, -4.07404974e-02f, -8.89709145e-02f, -2.78971754e-02f, 1.09398521e-01f,
  -3.18953171e-02f, 5.80882281e-02f, 6.10293485e-02f, 7.95852542e-02f, 6.81731403e-02f, -8.94215703e-02f, 5.04584983e-02f, 1.12673052e-01f, -1.50895109e-02f, 8.45442191e-02f,
  -6.18509538e-02f, 7.53390091e-03f, 5.70902489e-02f, 8.58350769e-02f, 3.20655778e-02f, 3.27057242e-02f, -1.47383856e-02f, 2.06563268e-02f, 4.73943353e-02f, 6.12834841e-02f,
  2.36736834e-02f, 6.62956685e-02f, 2.09008809e-02f, 1.73374675e-02f, -3.78308445e-02f, -1.81024391e-02f, -7.11943284e-02f, -8.13449845e-02f, -1.13835946e-01f, -6.98198378e-02f,
  7.17938095e-02f, -8.98064300e-02f, 5.99298179e-02f, 7.81262945e-03f, 3.51370691e-04f, -1.22122234e-02f, 6.47347942e-02f, 4.42419872e-02f, -3.28107104e-02f, 3.86802442e-02f,
  -3.19239013e-02f, -1.08074648e-02f, 1.27069857e-02f, -2.25138608e-02f, 3.50987799e-02f, -1.17762677e-01f, 1.78908668e-02f, 6.57865331e-02f, 7.20781041e-04f, -4.02297033e-03f,
  -5.78863211e-02f, 3.99838127e-02f, 2.92300771e-04f, -4.86146053e-03f, 1.84761696e-02f, -6.37666658e-02f, 1.11223329e-02f, 2.74433512e-02f, -5.93721233e-02f, 1.65824160e-01f,
  4.23176557e-01f, -3.07284117e-01f, 2.13455595e-02f, 7.76130557e-02f, -2.04416856e-01f, -8.90730321e-03f, -1.56003371e-01f, -4.34154738e-03f, -7.59125426e-02f, -2.67568439e-01f,
  -9.06660408e-03f, 1.82825699e-01f, 2.48454139e-01f, 1.84854299e-01f, 1.62923306e-01f, -2.72473544e-01f, -1.51899427e-01f, 1.71787918e-01f, 4.11154985e-01f, 1.37612775e-01f,
  -7.30342641e-02f, -5.98916784e-02f, 1.20584734e-01f, 5.83781712e-02f, -8.93005058e-02f, 6.51678145e-02f, -1.20914459e-01f, -1.83586344e-01f, -1.20001011e-01f, -2.76975483e-01f,
  1.74475506e-01f, 2.30137780e-02f, 1.07382953e-01f, 6.36923909e-02f, 2.78296787e-02f, 4.15417962e-02f, 6.42624497e-02f, 1.11604026e-02f, 9.55487490e-02f, -9.39085409e-02f,
  -2.12281868e-02f, -2.77553443e-02f, -1.57468747e-02f, 1.06540779e-02f, -6.79923967e-02f, 1.27704944e-02f, -1.50677204e-01f, 8.44773427e-02f, 3.06938449e-03f, 8.48887563e-02f,
  -5.38156927e-02f, -2.12454963e-02f, 3.44434641e-02f, -8.26087128e-03f, 1.51951969e-01f, 7.88538083e-02f, 6.45138919e-02f, 3.07572838e-02f, 1.49208426e-01f, 1.79253686e-02f,
  6.29788712e-02f, 3.40140201e-02f, -7.25923777e-02f, -8.40644315e-02f, -1.12852126e-01f, -1.44230947e-02f, -2.73366068e-02f, -7.05673397e-02f, -1.71004515e-02f, -5.38266497e-03f,
  -4.43165451e-02f, -8.18871148e-03f, -1.01466142e-02f, -6.44790381e-02f, -8.92116874e-02f, 3.79149914e-02f, -1.69962663e-02f, 2.56986022e-02f, -7.32368231e-02f, -9.42155719e-02f,
  5.79605997e-02f, 3.67262848e-02f, -5.30214868e-02f, 5.08825965e-02f, -8.12554285e-02f, -1.99820101e-02f, 4.99773212e-03f, -7.68287107e-03f, -4.69069276e-03f, -2.75800042e-02f,
  -1.51060440e-03f, 1.29970774e-01f, 7.39491060e-02f, 1.09715261e-01f, -2.79169306e-02f, -2.93980949e-02f, 1.99985672e-02f, 2.56766099e-02f, -7.87218660e-02f, -3.11783399e-03f,
  1.33324526e-02f, 3.38400528e-02f, -5.62373102e-02f, 1.76193789e-02f, 1.05544537e-01f, -1.11890556e-02f, -9.84466970e-02f, 3.55477035e-02f, 6.28338233e-02f, -5.96737228e-02f,
  -9.46109518e-02f, -1.60001945e-02f, 1.58880383e-01f, -7.67808734e-03f, 2.33390797e-02f, 1.21981755e-01f, -3.10233254e-02f, -3.57345492e-02f, 1.11927718e-01f, -1.36287570e-01f,
  5.21829545e-01f, 2.75561120e-02f, 3.30596894e-01f, 2.57660389e-01f, 1.00569688e-01f, 1.83106035e-01f, 1.83701843e-01f, 3.19572747e-01f, 1.34979814e-01f, 1.44464105e-01f,
  -1.56920478e-01f, -2.10183367e-01f, 1.00696562e-02f, 3.96023430e-02f, 1.61335319e-01f, 9.67044532e-02f, 9.95055214e-02f, 2.71609336e-01f, 2.35694394e-01f, 1.63410664e-01f,
  -6.07984699e-02f, 9.59648117e-02f, 3.96081477e-01f, 1.87224627e-01f, 9.42843929e-02f, 5.27010597e-02f, 9.29545164e-02f, 4.02468443e-02f, 1.03797838e-01f, -9.01055932e-02f,
  3.36778685e-02f, 3.58068794e-01f, 6.32572919e-02f, 5.92229553e-02f, 7.79623687e-02f, 1.74933925e-01f, 1.04124993e-01f, 2.47147769e-01f, 4.01390493e-02f, 2.17518032e-01f,
  4.74802069e-02f, 7.86221549e-02f, 1.08409263e-01f, 1.24780007e-01f, 1.92518130e-01f, 1.37448549e-01f, 1.82320997e-01f, 3.45115930e-01f, 2.32460380e-01f, 1.75614566e-01f,
  -3.92971747e-02f, 8.84255022e-02f, 2.02730775e-01f, 1.69926465e-01f, 1.29528940e-01f, 4.84245718e-02f, 1.67928413e-01f, 1.25306994e-01f, 1.58350348e-01f, 1.19115435e-01f,
  -1.38642967e-01f, -2.91492026e-02f, -3.92942987e-02f, -1.40800700e-01f, -5.99122494e-02f, -1.24396734e-01f, -1.43137410e-01f, -1.85697466e-01f, -1.11629672e-01f, -8.30251202e-02f,
  -9.51247141e-02f, -7.80481100e-02f, -9.68564302e-02f, -6.50153980e-02f, -1.21625692e-01f, -1.47379830e-01f, -7.42234439e-02f, -8.49719197e-02f, -8.24629441e-02f, -8.71797204e-02f,
  -1.30511731e-01f, -1.33027718e-03f, -8.47673491e-02f, -1.57771319e-01f, -6.00393973e-02f, -1.47443622e-01f, -1.60597280e-01f, -2.35099867e-01f, -1.32547796e-01f, -3.92438844e-02f,
  -2.93618366e-02f, 1.00186862e-01f, 3.93273756e-02f, 6.50447384e-02f, 1.65158108e-01f, 1.14506572e-01f, 4.63359170e-02f, 1.25012308e-01f, 1.86201617e-01f, 1.22529507e-01f,
  8.20291191e-02f, 1.62757099e-01f, 8.90873224e-02f, 1.25411764e-01f, 2.15162262e-01f, 1.18865088e-01f, 1.16912156e-01f, 1.04191430e-01f, 1.94875494e-01f, 1.26531467e-01f,
  1.33616820e-01f, 1.10491067e-01f, 1.79984778e-01f, 8.53206664e-02f, 1.59936175e-01f, 5.20326719e-02f, 9.82966721e-02f, 1.77779198e-01f, 1.72356695e-01f, 1.02007963e-01f,
  -2.58863326e-02f, -3.17551553e-01f, -1.62282065e-01f, 9.25600827e-02f, -1.68107569e-01f, -4.37813513e-02f, -3.45967412e-02f, 1.11631021e-01f, 1.32673755e-01f, -1.89111650e-01f,
  -1.80335432e-01f, 4.91361320e-02f, 6.59623519e-02f, 1.94947664e-02f, -3.35208117e-03f, -1.24279581e-01f, 5.03339171e-02f, 2.10948139e-02f, 5.70464991e-02f, 3.67389545e-02f,
  -1.54463530e-01f, -2.25150008e-02f, 7.50180185e-02f, -2.61969119e-02f, -2.25365102e-01f, -9.59415957e-02f, -1.54800370e-01f, -1.96101725e-01f, -2.89347500e-01f, -3.67527485e-01f,
  -2.01472193e-01f, -2.46056542e-01f, -1.22217545e-02f, -1.98450595e-01f, -3.04890215e-01f, -1.22021943e-01f, -2.00793400e-01f, -1.79342002e-01f, -1.77730769e-01f, -1.36841729e-01f,
  -2.29753196e-01f, -1.10291578e-01f, -1.47473037e-01f, -1.74021497e-01f, -1.10550746e-01f, -7.87352920e-02f, -1.03417210e-01f, -7.70261213e-02f, -1.00456931e-01f, -2.81142712e-01f,
  -1.79881215e-01f, -2.25075290e-01f, -2.61606276e-01f, -9.46944281e-02f, -1.78278133e-01f, -1.55978367e-01f, -2.53515542e-01f, -2.89902449e-01f, -2.21898586e-01f, -2.78217465e-01f,
  -6.23511747e-02f, 2.88073123e-02f, 3.25749703e-02f, 1.33111492e-01f, 7.20305145e-02f, 2.14593858e-02f, 1.08857356e-01f, 4.31857929e-02f, 1.02093689e-01f, 7.91521966e-02f,
  1.38120279e-01f, 2.14370601e-02f, 1.80073529e-01f, 1.44011855e-01f, 8.73451531e-02f, 3.36962380e-02f, 6.96359724e-02f, 1.60284206e-01f, 6.01355657e-02f, 5.69494255e-02f,
  1.15990445e-01f, 7.18560964e-02f, 9.16673616e-02f, 5.94116151e-02f, 4.94938828e-02f, 1.37115076e-01f, 1.70189753e-01f, 1.69594705e-01f, 2.08615512e-01f, 1.49222896e-01f,
  1.51179284e-01f, 7.43120955e-03f, -1.14019789e-01f, -8.87857154e-02f, -6.12411089e-02f, -9.95123684e-02f, -1.02442399e-01f, -6.63524270e-02f, -2.12576494e-01f, -8.88470560e-02f,
  -1.26782283e-01f, -1.77524805e-01f, -1.04425669e-01f, -1.03742503e-01f, -9.53121260e-02f, -1.03863560e-01f, -1.18398853e-01f, -6.33136556e-02f, -1.42206445e-01f, -1.15173742e-01f,
  -1.70746759e-01f, -1.10914968e-01f, 8.73129442e-03f, -1.02118924e-01f, -1.31663769e-01f, -7.17747584e-02f, -1.13206260e-01f, -1.53348878e-01f, 5.86970001e-02f, 5.85127026e-02f,
  -7.59829283e-02f, 7.05241412e-02f, -4.84833941e-02f, -1.14728875e-01f, 1.09627120e-01f, 1.59121826e-01f, 6.97035640e-02f, 6.29867092e-02f, 9.22956876e-03f, 2.22727805e-02f,
  1.13869749e-01f, -5.37623316e-02f, -7.05407485e-02f, -2.08902825e-02f, -1.54306427e-01f, -1.68373123e-01f, -2.16582566e-01f, -3.26301157e-01f, -3.07370543e-01f, -1.69677958e-01f,
  -3.22320089e-02f, -8.78447965e-02f, -2.36560509e-01f, -2.42556855e-01f, -1.06258251e-01f, -1.34692058e-01f, 6.65844185e-03f, -4.91026156e-02f, -4.92557772e-02f, -1.88789234e-01f,
  2.51801079e-03f, 5.50731532e-02f, -1.38511553e-01f, -1.35683253e-01f, -1.68367606e-02f, -3.61598358e-02f, -5.83764426e-02f, -5.62218092e-02f, -6.57107532e-02f, -1.39760420e-01f,
  -1.32968500e-01f, -7.43965479e-03f, -4.38349582e-02f, -7.49382973e-02f, -7.32885599e-02f, -5.37498761e-03f, -1.06329188e-01f, -1.64797604e-01f, -1.59836635e-01f, -4.16867696e-02f,
  7.33666271e-02f, -9.88071486e-02f, -5.43894991e-02f, -1.00630842e-01f, -8.43525603e-02f, -1.28246829e-01f, -1.00897200e-01f, -1.58818260e-01f, -1.38245761e-01f, -2.14739352e-01f,
  1.53841488e-02f, 2.30838936e-02f, 6.66106120e-02f, 2.80492520e-03f, 7.22889826e-02f, 5.05162813e-02f, 3.09288222e-02f, 3.51178795e-02f, -2.14589965e-02f, 8.32119212e-02f,
  9.81457718e-03f, 3.84091958e-02f, 9.82398987e-02f, -2.75288615e-02f, -7.38180429e-02f, 7.05002174e-02f, 5.75441644e-02f, 2.59983316e-02f, -8.09033494e-03f, 3.33240256e-02f,
  -1.23114698e-02f, 1.22255549e-01f, 7.99973216e-03f, -2.13708822e-02f, -1.67589437e-03f, 6.40856847e-03f, 5.31085618e-02f, 6.83569536e-02f, 1.75411757e-02f, 1.05622493e-01f,
  -8.17961060e-03f, -2.92461496e-02f, -2.06191048e-01f, -1.90984696e-01f, -1.05921566e-01f, -8.44862238e-02f, 1.68189760e-02f, -9.39361304e-02f, -1.04853608e-01f, -6.39590248e-02f,
  -1.03078105e-01f, 4.57898341e-03f, -1.10137194e-01f, -2.63175406e-02f, -1.03841126e-01f, -1.57158956e-01f, -3.88494991e-02f, -1.21834770e-01f, -2.57399473e-02f, -5.30199669e-02f,
  2.21136678e-02f, -1.32229269e-01f, -1.16946496e-01f, -4.25051786e-02f, -1.65860485e-02f, -1.90763727e-01f, -1.42930269e-01f, -1.70111969e-01f, -1.39545500e-01f, -2.41386965e-01f,
  3.96462306e-02f, 2.61284351e-01f, 3.20154317e-02f, 6.24336526e-02f, -2.05936823e-02f, -1.49649322e-01f, -1.23390757e-01f, 1.16164781e-01f, 1.62631616e-01f, 1.19764544e-01f,
  2.06828192e-01f, 1.44419879e-01f, 2.48536408e-01f, 1.51032269e-01f, -1.04341835e-01f, 9.21780616e-03f, -2.09077052e-03f, -1.04468435e-01f, -9.74595025e-02f, -1.40387282e-01f,
  -2.25616898e-02f, 8.35828036e-02f, 1.60003781e-01f, 5.90686277e-02f, 2.43884191e-01f, 2.24335454e-02f, 7.06542879e-02f, 1.04972720e-01f, 4.83193249e-02f, 2.92967051e-01f,
  1.22558456e-02f, 1.44292459e-01f, 5.32221459e-02f, 6.28956929e-02f, 1.04027055e-01f, 7.12628067e-02f, 6.97765201e-02f, 1.95489988e-01f, 1.13266893e-01f, 3.96421477e-02f,
  1.13006413e-01f, 7.41648972e-02f, 1.30711153e-01f, 8.80464390e-02f, 6.89109340e-02f, 4.85497601e-02f, 9.66713056e-02f, 5.96003979e-02f, 9.93528813e-02f, -6.88268477e-03f,
  1.06440812e-01f, -3.48336366e-03f, 8.91783535e-02f, 5.19203469e-02f, 1.99919217e-03f, -5.12187965e-02f, 2.41897535e-02f, 9.02846903e-02f, 1.26618743e-01f, 1.83731131e-02f,
  -1.31646112e-01f, -1.90796025e-04f, -4.63457666e-02f, -1.27243936e-01f, -1.47396252e-01f, -4.81719077e-02f, -1.51698902e-01f, -1.24761544e-01f, -5.93189709e-02f, -1.07561179e-01f,
  -1.61180757e-02f, -1.35530531e-01f, -2.45942618e-03f, -6.31031692e-02f, -5.22923917e-02f, -1.23971127e-01f, -1.08160846e-01f, 1.52056944e-02f, -2.12961882e-02f, -3.20133865e-02f,
  -5.87524846e-02f, -1.01313472e-01f, 1.98687878e-04f, -7.10523874e-02f, -1.35902390e-01f, -2.46282443e-02f, -2.01891229e-01f, -9.93742272e-02f, -5.08161560e-02f, -6.46412447e-02f,
  1.78568423e-01f, 4.23090905e-02f, 1.43697098e-01f, 1.62379563e-01f, 7.63146430e-02f, 1.31191641e-01f, 2.25086808e-01f, 1.72900140e-01f, 1.06241859e-01f, 1.07231408e-01f,
  4.62809131e-02f, 7.80461133e-02f, 1.53015167e-01f, 1.40920728e-01f, 6.93895593e-02f, 1.39447957e-01f, 1.79048568e-01f, 9.44487378e-02f, 9.41004455e-02f, 1.05321825e-01f,
  5.10446839e-02f, -2.55311560e-03f, -1.15327453e-02f, 1.36171922e-01f, 1.15664065e-01f, -1.02274075e-01f, -6.29353803e-03f, 2.77455803e-02f, -1.83628425e-02f, -5.79164140e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.11590248e-01f, -7.59754851e-02f, 3.87208797e-02f, -1.89438835e-01f, 1.19117856e-01f, 2.27337368e-02f, -3.82198244e-02f, 1.18042668e-02f, 1.49912432e-01f, -1.50075272e-01f,
  -1.26184538e-01f, -5.95333576e-02f, -1.63816303e-01f, -1.53120145e-01f, -2.94953763e-01f, -3.12774897e-01f, -2.60615617e-01f, -3.50672841e-01f, -1.74272910e-01f, 2.31067836e-02f,
  -8.18397999e-02f, -9.61541906e-02f, -2.17806637e-01f, 1.50592346e-02f, 6.78514838e-02f, -1.56269607e-03f, 5.28378896e-02f, -1.11477837e-01f, 4.32777144e-02f, -2.10926369e-01f,
  -1.68459177e-01f, 9.80190933e-02f, 8.66366029e-02f, -1.22708179e-01f, 7.21961856e-02f, -3.88650633e-02f, -6.85808202e-03f, 4.43429165e-02f, 7.84271732e-02f, 4.96782176e-02f,
  -5.17384373e-02f, -1.35681713e-02f, -5.63090518e-02f, 9.30749159e-03f, 1.40674114e-01f, -2.52229124e-02f, -2.79858653e-02f, 8.11758451e-03f, 5.80194853e-02f, 1.75778806e-01f,
  -2.91745085e-02f, -7.63205886e-02f, -1.52501091e-01f, 1.97669208e-01f, 8.59380513e-02f, 8.86058956e-02f, 1.78001925e-01f, 1.33274481e-01f, 5.19516878e-02f, -1.08933367e-01f,
  5.69111034e-02f, 1.46774211e-04f, 2.26755366e-02f, -4.72054109e-02f, -8.13792869e-02f, 1.07503183e-01f, 2.73105465e-02f, -1.13951907e-01f, -3.29464470e-04f, -7.89600313e-02f,
  9.88283753e-02f, -5.62271811e-02f, 3.53708258e-03f, -2.00842693e-02f, -9.98164713e-03f, -1.16441855e-02f, -6.91288337e-02f, -4.15375344e-02f, 9.52491909e-03f, -5.54407388e-03f,
  -9.99224633e-02f, -1.01779476e-02f, -8.40950757e-03f, -6.23443834e-02f, -6.51951088e-03f, 1.50307436e-02f, 4.45792340e-02f, -7.52022937e-02f, -5.71045987e-02f, -7.32248873e-02f,
  -1.82252273e-01f, 1.11003354e-01f, -1.68612301e-01f, -3.74019668e-02f, -3.05239148e-02f, -7.22049475e-02f, -4.71897870e-02f, 5.61753921e-02f, 1.44145116e-02f, -4.16798517e-02f,
  4.17709798e-02f, -7.97498971e-02f, -9.59417224e-02f, -1.05855726e-02f, -6.35041296e-02f, -1.11335427e-01f, -1.86518937e-01f, -4.91744317e-02f, 2.67435815e-02f, 2.80888658e-02f,
  -2.09467173e-01f, -2.06522077e-01f, -3.43873590e-01f, -8.33424330e-02f, 1.72742233e-02f, -2.32187957e-01f, -2.78093815e-01f, -5.91463894e-02f, -3.74214165e-02f, -3.16239506e-01f,
  2.02148750e-01f, -2.31027827e-01f, -2.70761490e-01f, 2.52318680e-01f, -6.79925308e-02f, -1.68963626e-01f, -2.08716586e-01f, 7.73178861e-02f, 2.63840765e-01f, -1.58181652e-01f,
  -2.29985580e-01f, 9.80365425e-02f, -1.17625371e-01f, -2.03324407e-02f, -1.85461164e-01f, -3.55135620e-01f, -2.52367824e-01f, -1.00464545e-01f, 1.00416876e-01f, -2.09394470e-02f,
  8.74829665e-02f, 2.62125470e-02f, 1.10381708e-01f, 8.98187608e-02f, -7.83767998e-02f, -1.37818798e-01f, -1.31783471e-01f, -3.41083072e-02f, -2.95419961e-01f, -2.08683014e-01f,
  -3.35757196e-01f, -1.95389137e-01f, -4.23470847e-02f, -3.65098938e-02f, -2.16245023e-03f, 1.00611500e-01f, 1.46460896e-02f, 8.09785202e-02f, 9.53006819e-02f, 4.88674901e-02f,
  1.13329552e-02f, -1.01195220e-02f, 6.43013269e-02f, 5.29841594e-02f, 1.05470754e-02f, -2.32623406e-02f, 2.80007478e-02f, -1.46077285e-02f, -2.28609592e-02f, 3.73817161e-02f,
  -1.26890019e-01f, -1.20568015e-01f, -4.46189605e-02f, -5.97535260e-02f, 1.24274038e-01f, -1.03032276e-01f, -6.71566725e-02f, -3.65336128e-02f, -1.17502637e-01f, -1.17263190e-01f,
  -3.03272698e-02f, -2.84784399e-02f, 1.08636739e-02f, 1.11956313e-01f, 5.73046133e-02f, 5.19711301e-02f, -2.69460492e-03f, -3.69629860e-02f, 4.70947698e-02f, 7.08265156e-02f,
  -2.43701171e-02f, 5.36925159e-02f, 1.14772767e-01f, -3.60310413e-02f, 7.13358372e-02f, -8.02405737e-03f, -3.14405449e-02f, 7.23674288e-03f, 5.90625592e-02f, -5.94867691e-02f,
  -5.47329448e-02f, -3.26831378e-02f, 2.54937578e-02f, -3.67565826e-02f, -9.90014896e-02f, 7.31238630e-03f, -8.12008083e-02f, -1.03537505e-02f, 1.07279196e-01f, -1.02132410e-01f,
  2.78903246e-01f, -2.53486514e-01f, -9.23744738e-02f, 3.63578380e-04f, 4.30188961e-02f, 2.23226454e-02f, 2.31630914e-02f, 1.70220971e-01f, 5.67143932e-02f, -3.82493772e-02f,
  -9.54717025e-02f, 3.43794860e-02f, 2.56469660e-02f, 7.88259879e-02f, 7.18611926e-02f, 3.46293882e-03f, 3.55855562e-02f, -4.28583771e-02f, 9.94647369e-02f, 7.76184648e-02f,
  1.04078785e-01f, -4.46990016e-04f, -2.56069396e-02f, -6.16000369e-02f, -4.04394157e-02f, -6.01811372e-02f, -1.36207044e-01f, -4.65693027e-02f, -1.31570041e-01f, 3.35780322e-03f,
  7.33546019e-01f, 1.18639372e-01f, 1.84928060e-01f, 3.16384763e-01f, 2.18483537e-01f, 1.06636330e-01f, 2.64447093e-01f, 6.74893185e-02f, 1.76633354e-02f, 1.31734043e-01f,
  2.15772703e-01f, 1.52737036e-01f, 1.14014626e-01f, 3.22559252e-02f, 1.07749112e-01f, -1.31050467e-01f, -2.05016807e-01f, 1.21087857e-01f, 1.27703518e-01f, 7.71923512e-02f,
  -1.09614365e-01f, -1.20203428e-01f, 9.23820436e-02f, -8.70068371e-02f, -9.43006650e-02f, -7.49386922e-02f, -1.25716507e-01f, -6.10736981e-02f, -5.05189076e-02f, -2.24906757e-01f,
  3.69440876e-02f, 3.31472963e-01f, -1.56210493e-02f, -3.38356905e-02f, -2.53178645e-02f, -4.12251800e-03f, 9.47629586e-02f, -8.42671394e-02f, 4.16275999e-03f, -8.22591931e-02f,
  -4.79617566e-02f, -5.19093685e-03f, -7.39625543e-02f, -6.37597740e-02f, 7.92086497e-02f, 1.88760851e-02f, -3.85042876e-02f, -1.54283326e-02f, -3.59738767e-02f, 8.13792050e-02f,
  -3.96174379e-02f, -3.88033129e-02f, 7.04424828e-02f, -2.81044934e-02f, 1.29431814e-01f, 6.87929541e-02f, -6.65004225e-03f, -7.18741817e-03f, -4.31298316e-02f, 1.72338951e-02f,
  -3.57221961e-02f, 6.33684397e-02f, 5.63741103e-02f, 4.48935740e-02f, 6.21483065e-02f, 1.00722983e-01f, 4.20850068e-02f, -6.02950491e-02f, 7.23475367e-02f, -2.44134460e-02f,
  -8.98401719e-03f, 7.53685907e-02f, 4.89163660e-02f, 6.68730959e-03f, -4.13963869e-02f, 4.70104329e-02f, -2.77818348e-02f, -6.37703463e-02f, 5.34209376e-03f, 6.41068816e-02f,
  3.25997770e-02f, 6.02235757e-02f, 3.14964056e-02f, -5.16456086e-03f, 2.05708630e-02f, -9.85239223e-02f, -1.12549523e-02f, -3.71672809e-02f, -7.93049932e-02f, -1.44019559e-01f,
  -4.05219108e-01f, 2.40539372e-01f, -1.35298166e-02f, -6.41411468e-02f, 5.67796715e-02f, -3.10485009e-02f, 1.18806250e-01f, -5.59658185e-02f, -2.41948217e-02f, 6.97941810e-04f,
  7.85101112e-03f, 3.88775691e-02f, 2.83796601e-02f, -2.31950600e-02f, -1.67393871e-02f, 8.78073797e-02f, -3.22736837e-02f, 9.39013734e-02f, 4.80327941e-02f, -6.53332323e-02f,
  -1.58283770e-01f, 6.79598674e-02f, 1.24874249e-01f, 9.84158665e-02f, -9.99772996e-02f, 9.22519565e-02f, -5.98675832e-02f, 3.84967551e-02f, 7.42606521e-02f, -2.01473851e-03f,
  5.94901666e-02f, -4.63674754e-01f, 4.77113277e-02f, 3.45603913e-01f, 2.50822872e-01f, 1.51622415e-01f, 6.98433816e-02f, -4.58701141e-02f, 1.91929340e-01f, 1.23339752e-02f,
  -2.82310545e-01f, -1.64442793e-01f, -1.83898404e-01f, -2.57445425e-01f, -2.21327856e-01f, 7.89826661e-02f, 1.29290611e-01f, 2.08180267e-02f, 1.85798109e-01f, 1.56975776e-01f,
  3.90838869e-02f, 5.13362810e-02f, -2.12073531e-02f, 1.42520247e-02f, -1.78260863e-01f, -8.29017311e-02f, -5.90045750e-02f, -1.48923665e-01f, -1.52205557e-01f, -1.32464198e-02f,
  -4.38137688e-02f, -1.25648454e-01f, 1.49617940e-01f, -1.42797485e-01f, -7.40211681e-02f, 4.10355926e-02f, 6.88524335e-04f, -1.37708718e-02f, 5.64328171e-02f, 1.83641240e-01f,
  -7.05164745e-02f, -1.38642639e-01f, -2.12873533e-01f, -1.04759984e-01f, 6.12251982e-02f, -2.40682494e-02f, -1.44779816e-01f, 9.38695812e-05f, 6.63544387e-02f, -8.78490210e-02f,
  -6.18077815e-02f, 1.33067131e-01f, 7.40569010e-02f, 2.13025045e-02f, 1.27785709e-02f, 1.19849313e-02f, -4.30068783e-02f, -1.00040033e-01f, 6.02061674e-02f, 4.22197096e-02f,
  2.60769755e-01f, 6.60259724e-02f, -1.41643479e-01f, 5.46726212e-02f, -1.15608796e-01f, 7.93310776e-02f, 4.10529338e-02f, -1.37012243e-01f, -9.79654491e-02f, -1.80542231e-01f,
  -6.03263378e-02f, 9.81550962e-02f, -6.09427178e-03f, 8.72623846e-02f, -2.08597723e-02f, -1.65434927e-02f, -5.97329140e-02f, -9.65067819e-02f, -6.07718974e-02f, 3.62569541e-02f,
  -1.01024294e-02f, 3.34263816e-02f, 1.64132798e-03f, -1.63456544e-01f, -3.31147276e-02f, 3.94101664e-02f, -2.17257328e-02f, -8.05005897e-03f, -3.63568105e-02f, 4.45507206e-02f,
  -4.02114876e-02f, -2.72083525e-02f, 5.38387336e-02f, -1.75198436e-01f, 9.94188637e-02f, -1.52804494e-01f, -7.87625536e-02f, 1.76056679e-02f, 7.35079870e-02f, 9.81358886e-02f,
  -8.68999362e-02f, -3.30963396e-02f, -5.04130572e-02f, -8.84994492e-02f, 1.50843456e-01f, 1.80930361e-01f, -7.12072179e-02f, 3.82504538e-02f, 4.40444611e-02f, 7.65091181e-02f,
  3.01493909e-02f, 1.19829968e-01f, 2.02127561e-01f, 1.10001646e-01f, 1.21101819e-01f, 1.90893516e-01f, 1.36516914e-01f, 8.46933573e-02f, 1.05855294e-01f, 2.15475887e-01f,
  2.23166376e-01f, 2.07091853e-01f, 1.20997638e-01f, 1.16874225e-01f, -4.11157124e-02f, -4.25590873e-01f, -4.12060827e-01f, -1.65339649e-01f, -1.07151112e-02f, 8.29296783e-02f,
  3.70307378e-02f, -1.16937757e-01f, 1.44713953e-01f, -5.27128093e-02f, -2.70489633e-01f, 4.93231118e-02f, 9.53631476e-02f, -1.72463626e-01f, -4.06019300e-01f, -3.66080612e-01f,
  -8.25619325e-02f, -1.95670817e-02f, 2.21120734e-02f, -1.27131373e-01f, 3.19997221e-01f, 1.12759426e-01f, 2.30264455e-01f, 1.25064477e-01f, 5.99634238e-02f, 4.06935155e-01f,
  2.67330140e-01f, 1.77413732e-01f, -2.10797265e-01f, 5.05401753e-02f, -4.44987006e-02f, -1.87980141e-02f, -1.01395911e-02f, 8.91633183e-02f, 1.42282367e-01f, 1.55279964e-01f,
  4.37268103e-03f, 3.34760174e-02f, -6.29755855e-02f, -4.94378945e-03f, -1.75330684e-01f, -5.89146763e-02f, 4.07799520e-02f, 4.91919369e-02f, 7.58096054e-02f, 4.35272194e-02f,
  -1.28584847e-01f, -1.18526697e-01f, 3.61531936e-02f, -2.96026152e-02f, 1.31312171e-02f, 9.63826478e-02f, -3.88802886e-02f, 2.80011501e-02f, -1.07998282e-01f, 2.94631869e-01f,
  -2.00013295e-02f, -9.19148512e-03f, 1.65400356e-02f, 7.33366469e-04f, -7.42739486e-03f, 5.98401092e-02f, 1.51029915e-01f, -9.06044152e-03f, 1.73118908e-03f, -1.98200122e-02f,
  -2.00725701e-02f, -5.97659266e-03f, 3.74967866e-02f, 7.17920437e-03f, 1.03283890e-01f, 3.02487193e-03f, -5.70747182e-02f, 1.00277685e-01f, 4.21482474e-02f, 7.48572275e-02f,
  -9.72959474e-02f, -7.60529488e-02f, 7.90718123e-02f, -4.13637795e-02f, 8.50861296e-02f, 3.26677151e-02f, 1.66189149e-02f, 2.31030434e-02f, 8.64519477e-02f, 8.11099038e-02f,
  -8.84717405e-02f, -2.17934757e-01f, 2.21789643e-01f, -7.31147500e-03f, -1.26253944e-02f, -9.55276191e-02f, 4.74914201e-02f, 2.25078948e-02f, 3.99475768e-02f, -2.96859387e-02f,
  -9.38087329e-02f, -4.67308052e-02f, 5.35317585e-02f, -4.07441929e-02f, -1.26814082e-01f, 6.58282032e-03f, -1.49459392e-01f, -6.00067936e-02f, -1.65100068e-01f, -1.28771856e-01f,
  -8.44423398e-02f, -2.01381519e-01f, -2.05004871e-01f, 1.02255624e-02f, 1.09995052e-01f, -1.24980889e-01f, -7.42079839e-02f, -1.26729921e-01f, -1.54475883e-01f, -5.09275943e-02f,
  -1.06145412e-01f, 1.01092935e-01f, -7.74748921e-02f, 1.92424372e-01f, 2.30861068e-01f, 1.60700575e-01f, 6.88999891e-02f, 5.61551489e-02f, 1.52340114e-01f, 1.88240141e-01f,
  1.71213374e-01f, 1.78242758e-01f, 2.21615985e-01f, 1.26008809e-01f, 1.82798579e-01f, 8.50122944e-02f, 1.83912709e-01f, 1.48482859e-01f, 9.26986337e-02f, 2.16291025e-02f,
  2.26975486e-01f, 2.21168380e-02f, 8.00440926e-03f, 1.12365738e-01f, 2.06973538e-01f, 1.98461249e-01f, 1.27165481e-01f, 4.66937087e-02f, 1.44099444e-01f, 1.79646477e-01f,
  -9.10628811e-02f, 7.84384012e-02f, 4.85295318e-02f, 5.85680187e-04f, -1.27370819e-01f, -1.88362852e-01f, -4.79775947e-03f, -1.56034455e-01f, -1.18259579e-01f, -1.48608238e-01f,
  -1.01420050e-02f, -5.31592257e-02f, 4.07631919e-02f, 6.57750219e-02f, -1.42941594e-01f, 8.92013125e-03f, 5.73445074e-02f, -7.75778620e-03f, 4.92256992e-02f, -1.79351754e-02f,
  1.01306833e-01f, 1.23959057e-01f, 9.87861399e-03f, 9.68475118e-02f, 1.24585487e-01f, 2.03492176e-02f, 1.19519103e-02f, 3.46543007e-02f, -6.22950494e-02f, 5.87206110e-02f,
  3.63702476e-01f, 8.50945190e-02f, 1.98331147e-01f, 2.41129905e-01f, 1.87638238e-01f, 5.44581823e-02f, 6.50602207e-02f, 4.08955365e-02f, 1.49546847e-01f, 7.33722840e-03f,
  4.08584923e-02f, 6.11597523e-02f, 3.93131524e-02f, -2.73704678e-02f, 1.25239313e-01f, 7.04950392e-02f, -6.88816383e-02f, 8.61683711e-02f, 4.86833714e-02f, 6.20715879e-02f,
  5.29752113e-02f, -1.66251510e-01f, -1.37317609e-02f, -2.68377922e-02f, -6.46336228e-02f, 3.81294675e-02f, 2.78768074e-02f, 5.83383255e-02f, -1.22187193e-02f, -1.09041117e-01f,
  -1.25620306e-01f, 1.67632103e-01f, 1.12041272e-01f, 6.49816021e-02f, -5.67607544e-02f, -1.28439739e-01f, -1.35006942e-02f, -2.76827142e-02f, -1.95578203e-01f, -1.29247949e-01f,
  -4.74764965e-02f, -1.06540196e-01f, -2.96743046e-02f, 2.90463995e-02f, 2.61876639e-02f, -1.18502423e-01f, 7.60311633e-02f, 1.66550741e-01f, -9.71561596e-02f, -7.20467127e-04f,
  -3.99097847e-03f, -6.97972327e-02f, 6.81862906e-02f, 1.77756175e-01f, 6.41221851e-02f, 4.43601049e-02f, 1.51896551e-02f, 6.00512736e-02f, -8.11934695e-02f, -1.19178630e-01f,
  4.70497161e-01f, -3.82943988e-01f, -3.31421733e-01f, 4.19426598e-02f, -2.83902526e-01f, -1.48719519e-01f, -3.65242541e-01f, -1.03471071e-01f, 7.14286566e-02f, -3.44315618e-01f,
  -1.72096923e-01f, 3.07461798e-01f, 1.77728727e-01f, 1.31505951e-01f, 2.94774324e-01f, -3.29977363e-01f, -2.87016481e-01f, 1.72198221e-01f, 3.29224825e-01f, -1.07552618e-01f,
  -4.99476641e-02f, -3.49892466e-03f, 3.25071186e-01f, 4.83756652e-03f, -2.63050407e-01f, 5.30361664e-03f, -3.44346464e-01f, -6.93808347e-02f, -1.46563023e-01f, -1.74060524e-01f,
  -1.76781461e-01f, -5.22233173e-02f, 6.26507923e-02f, 1.60127804e-01f, -1.90620080e-01f, 5.64067475e-02f, -4.67091650e-02f, -1.64523199e-02f, -5.29222153e-02f, -1.04571916e-01f,
  5.11487015e-02f, 9.84445885e-02f, 9.84257236e-02f, -1.43638123e-02f, -3.79505977e-02f, 1.97353587e-02f, -6.54240474e-02f, 1.61489360e-02f, 9.04482752e-02f, -2.00001538e-01f,
  -4.65373695e-02f, 9.00476647e-04f, 1.27648130e-01f, -6.66128844e-02f, 3.85938436e-02f, 1.09851100e-01f, -2.12739289e-01f, -7.14357197e-02f, 6.74482202e-03f, -3.18721384e-01f,
  -5.98222613e-02f, -1.09007061e-01f, -3.55430804e-02f, -5.43779284e-02f, 5.35106733e-02f, -7.51551315e-02f, 3.96862291e-02f, 6.26226738e-02f, -2.29486730e-03f, -2.99544968e-02f,
  -5.24712056e-02f, -6.61116987e-02f, 2.73594297e-02f, 2.36929953e-02f, 1.38788146e-03f, 1.51461914e-01f, 3.08205821e-02f, -2.98012774e-02f, 9.61173773e-02f, 2.33975258e-02f,
  8.77532661e-02f, 2.05914769e-02f, -1.62480295e-01f, 2.55536307e-02f, -2.20950972e-02f, 4.93312478e-02f, -5.05332127e-02f, 4.52408865e-02f, -1.68177225e-02f, 1.20465219e-01f,
  -3.74020450e-02f, 1.54877186e-01f, -8.74854252e-02f, 9.96221080e-02f, -5.65924756e-02f, -1.18624419e-01f, -2.26380043e-02f, -1.01828985e-01f, 6.97694942e-02f, 3.21224146e-02f,
  -5.46303503e-02f, 8.40243790e-03f, -7.53337443e-02f, -1.85068384e-01f, 2.47449744e-02f, -1.85577292e-02f, -8.12866166e-02f, 1.00330308e-01f, 4.56952304e-02f, -7.10679069e-02f,
  -9.41545442e-02f, -2.95832497e-03f, 1.55931056e-01f, 5.13473488e-02f, 3.34249325e-02f, 6.80247098e-02f, -4.38001044e-02f, -2.13358887e-02f, 2.06941381e-01f, -1.68785200e-01f,
  5.40648639e-01f, -1.51607007e-01f, 2.14136243e-01f, 2.48103619e-01f, 2.65451223e-01f, 2.39655480e-01f, 1.52609169e-01f, 1.31095663e-01f, 2.14917526e-01f, 1.47939205e-01f,
  1.37367591e-01f, 1.22914992e-01f, 1.37179822e-01f, -4.83375005e-02f, 6.72359765e-02f, 4.52282429e-02f, -3.24643739e-02f, 5.71129397e-02f, 1.99944511e-01f, 1.78115368e-01f,
  -3.01467907e-02f, 6.21138588e-02f, 1.86631065e-02f, 1.90271158e-02f, 1.67734604e-02f, 5.28322794e-02f, -3.59661132e-02f, -1.43290520e-01f, -1.15517691e-01f, -1.33296937e-01f,
  -4.06622469e-01f, 1.26850113e-01f, 3.25300425e-01f, -3.37192044e-02f, -2.83317789e-02f, 7.75627270e-02f, -9.45916923e-04f, -1.02926001e-01f, -1.27385920e-02f, -1.59325033e-01f,
  -1.38315961e-01f, -5.32978401e-02f, -2.63061635e-02f, 4.79071550e-02f, -1.05584174e-01f, 3.36705148e-02f, -8.16206113e-02f, -1.38535544e-01f, -1.52172327e-01f, -9.77146924e-02f,
  -6.05464587e-03f, 6.12215176e-02f, 2.32671779e-02f, 8.18640292e-02f, -4.66404557e-02f, 9.69240367e-02f, -2.61295103e-02f, 1.44214248e-02f, 6.20223284e-02f, 4.52832095e-02f,
  1.17944494e-01f, 2.64487863e-02f, 2.38475818e-02f, -5.83158955e-02f, 4.22912389e-02f, 9.19574276e-02f, -8.00787285e-02f, -1.65359512e-01f, -4.28700931e-02f, 1.45517349e-01f,
  -7.04164505e-02f, 2.27009058e-02f, -8.91127288e-02f, 1.65448725e-01f, 3.53625789e-02f, -2.78863334e-03f, -2.92666443e-02f, -8.84424746e-02f, -1.13169439e-01f, 5.51041681e-03f,
  1.51477000e-02f, -8.83941427e-02f, 1.37411477e-02f, 9.15683433e-03f, -7.87417889e-02f, 6.60739169e-02f, 3.01029533e-02f, 3.66483652e-03f, -9.65826213e-03f, -4.29156423e-03f,
  -4.10623193e-01f, 1.60811633e-01f, 4.90013808e-02f, -1.42288804e-01f, -5.80579489e-02f, -1.20084174e-01f, 5.58557585e-02f, -3.17256413e-02f, -2.26237148e-01f, -1.46291181e-01f,
  -5.34741096e-02f, -3.21641639e-02f, 2.12158225e-02f, 1.98843591e-02f, 8.45411643e-02f, -8.97731408e-02f, -9.82410274e-03f, 2.35053692e-02f, -8.35716650e-02f, -1.84751406e-01f,
  -2.23554447e-02f, 1.85228791e-02f, -3.89534165e-03f, 7.96274021e-02f, 5.87262549e-02f, 7.54101127e-02f, 1.17169656e-02f, -4.07128856e-02f, -5.21494225e-02f, 9.31647345e-02f,
  1.41311750e-01f, 1.41703591e-01f, -4.00732718e-02f, 3.03708911e-01f, -5.65233231e-02f, -2.35564217e-01f, -2.47922063e-01f, -9.65270549e-02f, 2.28053153e-01f, 8.86326935e-03f,
  -6.49015382e-02f, 1.73273504e-01f, 1.55174866e-01f, -2.44741123e-02f, -1.22557051e-01f, -4.93374020e-02f, 1.14611402e-01f, -3.63939330e-02f, -2.75145978e-01f, -2.59171963e-01f,
  9.51270014e-02f, 4.74603288e-03f, 5.94907701e-02f, -9.25646126e-02f, 2.40867704e-01f, 4.30199504e-02f, 3.44580226e-02f, 1.16159907e-02f, -8.38727877e-02f, 3.23917538e-01f,
  1.03087820e-01f, -1.17388256e-02f, -1.29216522e-01f, 4.09988202e-02f, 4.09620553e-02f, 1.58390462e-01f, 1.75908834e-01f, 2.54373074e-01f, 1.14435315e-01f, 3.78964022e-02f,
  1.08593524e-01f, 2.00646855e-02f, 1.25392437e-01f, 3.27903926e-02f, -1.75206102e-02f, -8.22291225e-02f, -7.09795952e-02f, -1.04049638e-01f, 6.48069009e-02f, -5.19801676e-02f,
  1.75230294e-01f, -3.20179723e-02f, -1.48821041e-01f, -1.52975887e-01f, 4.01699468e-02f, -6.94928467e-02f, -2.10940480e-01f, -6.22271262e-02f, -1.96173444e-01f, 1.52176052e-01f,
  1.69866476e-02f, -3.05592846e-02f, -7.30638653e-02f, 8.00232589e-02f, 6.56759068e-02f, 1.94648020e-02f, -1.32409958e-02f, 3.46367843e-02f, -1.89969186e-02f, 9.77145135e-02f,
  -5.74816540e-02f, -7.38859400e-02f, 1.10299043e-01f, 2.45700572e-02f, -8.30171853e-02f, 1.30886450e-01f, 6.85106934e-05f, -7.36505687e-02f, -1.27694651e-01f, 9.11481977e-02f,
  -1.27993792e-01f, 1.62286870e-02f, 2.74365395e-02f, 6.94746450e-02f, 4.59406804e-03f, -7.83111602e-02f, 1.03556596e-01f, -3.95904854e-02f, -4.43403758e-02f, 3.01071703e-02f,
  1.83544159e-01f, -2.03386471e-01f, 1.55401632e-01f, -6.58130199e-02f, -4.48904522e-02f, -3.99363786e-02f, -2.10120417e-02f, -1.03943728e-01f, -7.85942376e-02f, -9.81652923e-03f,
  -1.75072208e-01f, -7.16482848e-02f, 8.77652690e-02f, 7.71372169e-02f, 2.86578294e-02f, 2.24181395e-02f, -1.32196978e-01f, -5.05057983e-02f, -8.11957717e-02f, 1.08272657e-02f,
  8.76873732e-03f, -1.86042771e-01f, -2.08583996e-01f, 2.43928060e-02f, 1.12291738e-01f, -1.76085085e-01f, -2.04777718e-01f, -6.75905868e-02f, -2.46693239e-01f, -3.43646184e-02f,
  -1.00226268e-01f, 8.36113244e-02f, 1.27631381e-01f, 2.28957221e-01f, 2.04699740e-01f, -1.11001112e-01f, -3.62021834e-01f, -3.75409484e-01f, -2.15984583e-02f, 9.43598896e-02f,
  2.09239766e-01f, 1.32767215e-01f, 1.54575288e-01f, -1.44878803e-02f, -4.31354344e-01f, -2.48087615e-01f, 7.25965351e-02f, -1.06215239e-01f, -4.46333289e-01f, -2.64299631e-01f,
  8.46469849e-02f, 8.62033442e-02f, -2.88644806e-02f, -1.99159846e-01f, 2.09787488e-01f, 6.83152229e-02f, 5.77411130e-02f, 1.72318622e-01f, 1.20822579e-01f, 2.88363546e-01f,
  2.20106676e-01f, 4.72782105e-02f, -2.51094643e-02f, 1.98711678e-01f, 2.59234369e-01f, -7.58978873e-02f, -1.61191806e-01f, -7.51553662e-03f, 1.49042103e-02f, -9.73016098e-02f,
  2.47637421e-01f, -4.94420640e-02f, 1.67049497e-01f, -7.80739170e-03f, -7.68832415e-02f, -2.32194245e-01f, -7.47374594e-02f, -2.08237067e-01f, -1.57077238e-01f, -1.41751304e-01f,
  1.27818465e-01f, 1.97220996e-01f, 3.75599004e-02f, -4.98022474e-02f, -1.35916963e-01f, 1.36412531e-01f, -7.74658248e-02f, -1.66782752e-01f, -1.10591851e-01f, -1.45672873e-01f,
  -2.35143176e-04f, -3.63151394e-02f, -8.84506665e-03f, 4.09622826e-02f, -1.30773246e-01f, 2.45994944e-02f, 7.54469186e-02f, 1.63462032e-02f, -3.83143537e-02f, -1.22277988e-02f,
  -1.22267297e-02f, -4.22471995e-03f, -5.07254116e-02f, 1.37095945e-02f, 9.45453346e-02f, -2.04514246e-02f, 3.03931511e-03f, -7.45324418e-02f, 9.95370746e-03f, -6.01520985e-02f,
  -2.43529975e-02f, 3.72790620e-02f, 1.13606505e-01f, -7.21096694e-02f, 9.12375655e-03f, -1.04779974e-01f, -3.63214649e-02f, -6.86012954e-02f, -1.62767917e-02f, 6.06056601e-02f,
  -2.28179470e-02f, 1.10003814e-01f, 4.84077558e-02f, -6.68868050e-02f, 2.40671001e-02f, -1.41959935e-02f, 1.83400899e-01f, 2.03576498e-02f, 1.50778323e-01f, -9.68795940e-02f,
  -4.82667796e-02f, -4.12154943e-02f, 2.03752965e-02f, 1.19505255e-02f, -1.03690311e-01f, 1.97169241e-02f, -3.17693837e-02f, 2.10834239e-02f, -6.25722781e-02f, 2.90147234e-02f,
  -4.23056893e-02f, -1.14016980e-01f, 2.78762728e-02f, -1.75558642e-01f, 2.81392783e-02f, -9.53927189e-02f, -1.20114595e-01f, -1.23961203e-01f, -9.45141837e-02f, -2.57549405e-01f,
  -4.00686525e-02f, -2.29858845e-01f, 3.66349369e-01f, -5.25995344e-02f, -4.33552682e-01f, -3.92427802e-01f, -4.69179124e-01f, -2.63172567e-01f, -2.07813513e-02f, -1.82283163e-01f,
  -3.55390869e-02f, 2.23564342e-01f, 1.94214657e-01f, 3.43069345e-01f, 3.35579842e-01f, 1.18398137e-01f, 3.73280793e-01f, 3.79381329e-01f, 3.13003838e-01f, 1.19282413e-04f,
  -1.02693383e-02f, 7.82467723e-02f, 2.72212446e-01f, 2.17443570e-01f, -1.26531757e-02f, 1.86500832e-01f, 1.52151734e-01f, 5.67839295e-02f, 1.19397759e-01f, 3.51909310e-01f,
  1.99222611e-03f, -2.42585555e-01f, 1.81059062e-01f, -3.51110920e-02f, -5.16095664e-03f, -4.03937809e-02f, -9.07035619e-02f, 1.51081085e-01f, -7.49593079e-02f, -5.75188510e-02f,
  4.94927466e-02f, -7.91926235e-02f, -9.59187523e-02f, -1.04214564e-01f, -1.89092696e-01f, -1.12212516e-01f, 3.01064793e-02f, 2.19089106e-01f, 1.81420565e-01f, -9.85447466e-02f,
  -1.37586325e-01f, -1.32200778e-01f, -8.60334709e-02f, -1.22618871e-02f, 6.47033304e-02f, 5.67194410e-02f, -8.86885077e-02f, -1.09066190e-02f, -2.97212042e-02f, -5.03724404e-02f,
  1.02741867e-01f, 2.25437898e-03f, -5.54592870e-02f, -8.17323998e-02f, -1.21612892e-01f, 6.46431744e-03f, -4.43102466e-03f, -6.19304255e-02f, 4.64149117e-02f, -4.77444427e-03f,
  -4.12184149e-02f, 5.37257306e-02f, -2.59001157e-03f, -7.56771117e-02f, 9.28523764e-02f, -2.37193555e-02f, -6.04412183e-02f, -4.05578688e-02f, -9.62961987e-02f, -2.60245446e-02f,
  -1.05899014e-01f, 5.09834327e-02f, -4.23480794e-02f, -3.65224481e-02f, 6.69058925e-03f, -4.79920059e-02f, -1.68938171e-02f, -3.05811390e-02f, 6.63041621e-02f, -6.01595342e-02f,
  -1.70280784e-01f, 2.35824481e-01f, -2.20403895e-02f, 7.25427940e-02f, -2.24469788e-02f, 5.46643175e-02f, 7.10582957e-02f, 3.27878706e-02f, -4.24201228e-02f, -9.61263850e-02f,
  -8.46590623e-02f, 1.31070130e-02f, 4.12556678e-02f, -1.33987963e-02f, -6.06502756e-04f, -1.05276078e-01f, -5.56397848e-02f, 9.87520665e-02f, 1.53327048e-01f, -2.04013344e-02f,
  -4.05108593e-02f, -1.08698279e-01f, -1.71799928e-01f, -9.61548015e-02f, -3.65843922e-02f, 2.13889610e-02f, -1.47940600e-02f, -8.90222788e-02f, -5.14646508e-02f, -2.08238527e-01f,
  -3.36370081e-01f, 1.32308513e-01f, -3.68499279e-01f, 1.90253198e-01f, 1.87915608e-01f, -6.84991106e-02f, -6.80167228e-02f, -7.16687739e-02f, 4.14661728e-02f, 8.49425495e-02f,
  -7.64440075e-02f, 9.96466503e-02f, 2.23058596e-01f, -6.35547796e-03f, -3.96930911e-02f, 2.33886033e-01f, 1.77707270e-01f, -1.65002286e-01f, -1.79703951e-01f, -1.45094972e-02f,
  3.12051773e-01f, 1.32239848e-01f, -1.31601423e-01f, -1.65829286e-02f, 1.23928368e-01f, 1.56210274e-01f, 9.50714052e-02f, 7.78854713e-02f, 3.01905330e-02f, 3.78317416e-01f,
  -3.43566909e-02f, -1.56282574e-01f, -1.88915320e-02f, 5.13497144e-02f, -1.36928670e-02f, -1.49222583e-01f, -1.01295397e-01f, -1.50459185e-01f, -8.14098716e-02f, -1.45704135e-01f,
  1.08293891e-01f, -1.86924860e-01f, 1.29892454e-01f, 4.52274398e-04f, -2.62263063e-02f, -1.66022629e-01f, -1.23985760e-01f, -1.19869448e-01f, -3.25516224e-01f, -2.62732148e-01f,
  2.76535273e-01f, -2.48695035e-02f, -2.66756654e-01f, -1.16890587e-01f, -1.78349122e-01f, -1.33082688e-01f, -2.49094576e-01f, -1.28312707e-01f, -3.27231884e-01f, -5.12820669e-02f,
  -1.34094819e-01f, -3.57684605e-02f, -5.98672852e-02f, -2.71696933e-02f, 8.64536923e-06f, 3.91477086e-02f, 3.29942093e-03f, 7.93152973e-02f, 8.00557062e-02f, -5.58348447e-02f,
  -4.83711995e-02f, -6.22573681e-02f, -6.48417100e-02f, -4.27617468e-02f, 7.95287266e-02f, 6.40386194e-02f, 3.07067428e-02f, -6.06908510e-03f, -7.11819604e-02f, -5.99552020e-02f,
  1.95358228e-02f, -1.03845350e-01f, 1.87482201e-02f, 6.22599237e-02f, 3.73889953e-02f, -1.64888427e-01f, 3.01530305e-02f, -3.67152356e-02f, -1.49207920e-01f, 5.68502657e-02f,
  2.58682340e-01f, -1.52514651e-01f, 1.47189843e-02f, -3.28291096e-02f, -6.18702359e-02f, 1.02091283e-02f, 1.12987198e-01f, -3.92747559e-02f, -1.39114335e-02f, -3.53328250e-02f,
  -9.85659957e-02f, -1.18013419e-01f, 6.55644089e-02f, 1.00160539e-01f, -7.03212395e-02f, 4.03804854e-02f, 2.00379610e-01f, 5.88653535e-02f, 1.30964015e-02f, -3.08197271e-02f,
  1.75501674e-01f, 2.64201853e-02f, 1.02778627e-02f, -3.20259668e-02f, 5.37829660e-02f, 6.73249513e-02f, 1.82872470e-02f, -3.96513939e-02f, -5.79499155e-02f, 4.20952067e-02f,
  -4.02253091e-01f, -2.68080920e-01f, -5.97886567e-04f, 1.47962719e-01f, 1.38630629e-01f, 2.69907147e-01f, 1.20518081e-01f, 4.31500189e-02f, 8.20123553e-02f, 5.68475649e-02f,
  -1.45606816e-01f, -8.57499465e-02f, -8.80362187e-03f, -1.46293659e-02f, -3.81812565e-02f, 2.32183039e-01f, 2.74371445e-01f, 1.75546929e-01f, 1.40910476e-01f, 2.43564755e-01f,
  1.01086184e-01f, 6.93945065e-02f, -9.27937999e-02f, 9.48686749e-02f, -5.73625714e-02f, 1.98584139e-01f, 6.72574863e-02f, -1.42328531e-01f, -6.90396950e-02f, -8.16509277e-02f,
  2.63638884e-01f, -2.44687930e-01f, 1.68227836e-01f, -1.17345527e-01f, -1.76123217e-01f, -7.19406828e-02f, 4.49293777e-02f, -2.37603150e-02f, -7.97580928e-02f, 2.04187538e-02f,
  -8.68801475e-02f, -1.15574129e-01f, -8.91688690e-02f, -1.19572468e-02f, 1.93242207e-02f, -7.72683620e-02f, -1.63939819e-01f, -1.45908833e-01f, -6.02977052e-02f, -6.05422892e-02f,
  -1.84564918e-01f, -1.94942445e-01f, 4.84766439e-02f, 1.99482287e-03f, -1.30563036e-01f, -1.92742217e-02f, -1.07786193e-01f, -8.39796066e-02f, -4.03909460e-02f, -4.57454287e-02f,
  5.16630821e-02f, -7.06054196e-02f, -8.89599547e-02f, -6.42645955e-02f, 5.32981418e-02f, 4.71423902e-02f, 8.77723619e-02f, -5.90295196e-02f, -2.16488671e-02f, -7.60267898e-02f,
  3.46300304e-02f, 9.73056257e-02f, -1.01351226e-02f, -2.67965682e-02f, -1.15627469e-02f, -9.36672390e-02f, -2.60225572e-02f, -8.20835978e-02f, -1.23775147e-01f, -1.83447432e-02f,
  -1.39153123e-01f, 3.41239534e-02f, 7.11962804e-02f, -1.00141307e-02f, -5.13651110e-02f, -4.39933911e-02f, -2.17686947e-02f, -1.51084185e-01f, 2.57492950e-03f, -6.25535240e-03f,
  4.54314381e-01f, -1.59627736e-01f, 3.04414406e-02f, 1.42486123e-02f, 4.82470822e-03f, -1.37402624e-01f, -1.03362754e-01f, -3.27724963e-02f, 1.34764895e-01f, 1.37930110e-01f,
  -3.52473333e-02f, -1.12052187e-02f, 2.89324224e-02f, -2.28981078e-02f, 1.13318689e-01f, -4.08277027e-02f, -1.49471879e-01f, 1.30695969e-01f, 1.03502661e-01f, 6.10105470e-02f,
  -2.15906417e-03f, 1.37644127e-01f, 1.96912244e-01f, 1.27502382e-01f, 4.43779118e-02f, 2.40527064e-01f, 1.32444859e-01f, 1.76054850e-01f, 1.36858255e-01f, 1.49084702e-01f,
  2.46429622e-01f, -3.19412462e-02f, -4.61539477e-01f, -2.50099581e-02f, -3.19627166e-01f, -2.86980987e-01f, -2.20799387e-01f, -2.29997523e-02f, 9.16469991e-02f, -1.34744838e-01f,
  5.94793670e-02f, 1.37690380e-01f, 1.28634229e-01f, 7.24000260e-02f, 6.04469441e-02f, -2.65342087e-01f, -2.80000240e-01f, -1.94312468e-01f, 1.42968781e-02f, -7.55907893e-02f,
  -1.14320293e-01f, 1.38532808e-02f, 1.41232051e-02f, -4.03767228e-02f, -1.01758882e-01f, -1.09508395e-01f, -1.49673879e-01f, -2.20656767e-01f, -3.18981558e-01f, -4.38287884e-01f,
  2.10195482e-02f, -1.80721104e-01f, 6.23027980e-02f, 7.16007128e-02f, 3.25270407e-02f, 9.44157392e-02f, 6.49800897e-02f, -3.74923013e-02f, 8.94604027e-02f, 8.38745832e-02f,
  5.73798530e-02f, 2.34750230e-02f, 1.24909721e-01f, 1.22695854e-02f, 1.26833105e-02f, -4.96601388e-02f, 7.35500753e-02f, 6.59037232e-02f, -9.09985602e-02f, 2.23978683e-02f,
  3.91554013e-02f, -8.89201015e-02f, -8.18298161e-02f, -3.08719818e-02f, 6.71199337e-03f, 4.29384857e-02f, -2.16447860e-02f, -9.79887992e-02f, -5.35142086e-02f, 6.89860359e-02f,
  -1.34030171e-02f, 1.70259154e-03f, -3.03521864e-02f, 1.23028316e-01f, 1.58863604e-01f, 1.33533522e-01f, 2.46132668e-02f, 1.00435503e-01f, 1.13281295e-01f, 9.29688737e-02f,
  1.12006171e-02f, -1.22336641e-01f, 8.04352462e-02f, 1.30311884e-02f, -1.01074323e-01f, -1.18855469e-01f, 2.00455859e-02f, 8.05407092e-02f, 8.55633244e-02f, -2.50685364e-02f,
  -2.82443892e-02f, -1.64629761e-02f, -1.09965861e-01f, 4.04424556e-02f, -1.72186613e-01f, -8.82925764e-02f, -1.24301203e-01f, 3.08408048e-02f, 8.41120929e-02f, -1.66506305e-01f,
  3.33897829e-01f, -3.26592803e-01f, 1.14587292e-01f, 8.33342038e-03f, -5.75371869e-02f, -4.76124808e-02f, -1.73733339e-01f, -2.48372052e-02f, -4.14274521e-02f, 1.82138085e-02f,
  -5.95655739e-02f, 1.18453093e-01f, 2.94761341e-02f, -4.52162139e-03f, 1.39471978e-01f, 1.57951295e-01f, 1.63147032e-01f, 1.24849617e-01f, -7.22417682e-02f, -3.91879901e-02f,
  8.19096118e-02f, 1.03362128e-01f, 2.27365404e-01f, 9.97758955e-02f, 9.88938585e-02f, 1.03887260e-01f, 1.78157285e-01f, -3.91172096e-02f, 7.41040707e-02f, 3.93973589e-01f,
  -1.50942713e-01f, -4.14086670e-01f, 2.80378371e-01f, 3.96222770e-01f, 3.34808290e-01f, 2.88761973e-01f, 5.41747287e-02f, 5.93408383e-02f, 1.84225366e-01f, -1.61905251e-02f,
  -2.11053975e-02f, -5.77974357e-02f, 6.90159053e-02f, 1.31323665e-01f, 8.94039124e-02f, 1.61172003e-01f, 2.94546723e-01f, 1.21764623e-01f, 2.37473443e-01f, 1.23113908e-01f,
  -3.97226866e-03f, 8.66574496e-02f, -1.48213934e-02f, 1.01084128e-01f, 1.22179747e-01f, 1.44492298e-01f, 1.53266698e-01f, 9.77960974e-03f, 3.22483899e-03f, 1.29948512e-01f,
  6.68503297e-03f, -1.89543635e-01f, 1.40701398e-01f, -1.55536041e-01f, -1.70286790e-01f, -1.87147930e-01f, -1.18789017e-01f, -2.64203995e-02f, -1.80044174e-01f, -1.32135926e-02f,
  -1.00389324e-01f, -1.64881036e-01f, 6.59594266e-03f, -4.24437784e-02f, -2.05858331e-02f, -1.54798642e-01f, -1.35886893e-01f, -2.30816063e-02f, 1.71257526e-01f, -5.25412709e-02f,
  2.05380227e-02f, 6.15730844e-02f, 7.67209157e-02f, 7.50265941e-02f, 9.12737548e-02f, 1.20767370e-01f, -2.90449876e-02f, 5.10826670e-02f, 6.34245202e-02f, -4.09125872e-02f,
  2.07768723e-01f, 6.03484139e-02f, 3.90783548e-02f, 7.74653852e-02f, 5.41255213e-02f, 3.77523638e-02f, -1.16988812e-02f, 9.08588916e-02f, 1.27500296e-01f, -1.59235954e-01f,
  2.05193553e-02f, 1.47133753e-01f, 1.61011498e-02f, -1.25771808e-02f, 4.69275564e-02f, 1.03341460e-01f, -2.58665234e-02f, -2.30445825e-02f, -1.51800171e-01f, 5.70190735e-02f,
  2.77118571e-02f, 5.72258793e-02f, -6.22273982e-02f, -1.31014779e-01f, -5.30285835e-02f, -1.99120753e-02f, 2.94684730e-02f, -1.11547992e-01f, -1.32895172e-01f, 5.45246750e-02f,
  1.62064925e-01f, 9.95238423e-02f, 5.79178743e-02f, -9.11694467e-02f, 2.29607597e-02f, -1.75162807e-01f, 3.70016284e-02f, -1.31619992e-02f, -2.49442067e-02f, 3.65757570e-02f,
  4.10010479e-03f, 6.25343353e-04f, -1.22749053e-01f, -7.17539266e-02f, -2.89011505e-02f, -4.20332663e-02f, -1.18230209e-01f, 1.10255659e-01f, 1.60494387e-01f, 8.02159458e-02f,
  -6.93105236e-02f, 1.01162158e-01f, 1.81130260e-01f, 2.95921266e-02f, -8.02391488e-03f, 2.16833219e-01f, 6.20006658e-02f, 3.08936238e-02f, 7.93960914e-02f, -9.94260758e-02f,
  4.16498482e-01f, 1.38647720e-01f, 3.03594828e-01f, 1.09570973e-01f, 1.37673721e-01f, 1.92781955e-01f, 2.55851537e-01f, 1.05817184e-01f, 1.04542792e-01f, 1.54169083e-01f,
  4.37801853e-02f, 5.51505908e-02f, -6.27573654e-02f, -8.96780926e-04f, 8.33923593e-02f, 6.51883855e-02f, 5.68887591e-02f, 1.40213847e-01f, 9.77818891e-02f, 5.96894957e-02f,
  7.27704391e-02f, 1.38652816e-01f, 1.50097921e-01f, -9.83889913e-04f, 5.70343398e-02f, -6.77862344e-03f, 7.34330341e-02f, 5.60918860e-02f, 8.27660039e-02f, -1.56809278e-02f,
  1.03191368e-01f, 1.75222069e-01f, 6.78506494e-02f, -9.49986055e-02f, -5.43177985e-02f, 1.02133183e-02f, 4.70361970e-02f, 1.06886938e-01f, 1.01426832e-01f, 1.00574479e-01f,
  -2.51843669e-02f, 2.89162472e-02f, 1.05994334e-02f, 3.97737697e-02f, 5.21210656e-02f, 9.89608094e-02f, 8.33230987e-02f, 1.38159022e-01f, 7.91976228e-02f, 6.44665677e-03f,
  -7.89593309e-02f, 3.14668939e-02f, 1.27997965e-01f, 1.13479635e-02f, 4.22809198e-02f, -3.92708629e-02f, 1.87315196e-02f, 1.94818899e-02f, -2.24720966e-02f, 6.64835200e-02f,
  -8.69292244e-02f, 5.43963499e-02f, -2.64026858e-02f, 2.17175838e-02f, -2.35731620e-02f, -4.29967158e-02f, -4.33740951e-02f, -9.08427238e-02f, 5.25666438e-02f, -4.45914604e-02f,
  -2.80350875e-02f, 3.59646156e-02f, 1.54860523e-02f, 2.27376353e-02f, -1.39977625e-02f, 6.37313575e-02f, -3.95976305e-02f, -9.05301142e-03f, -1.13351926e-01f, -3.50899026e-02f,
  -4.11950685e-02f, 3.86868976e-02f, 5.96984401e-02f, -6.50779381e-02f, -1.05436616e-01f, -8.21053833e-02f, -3.86722269e-03f, -1.36104360e-01f, -9.85245779e-02f, 1.03236578e-01f,
  -1.00580424e-01f, -6.98155537e-02f, -3.32527272e-02f, 2.83926539e-02f, -7.75376111e-02f, 1.03836535e-02f, 6.79034814e-02f, 4.56151143e-02f, 2.97211148e-02f, 1.36823073e-01f,
  4.47722264e-02f, -4.49449122e-02f, 2.11806297e-02f, -1.09052412e-01f, 5.42628132e-02f, -5.00373989e-02f, -6.40609115e-02f, 1.40938454e-03f, 1.55048281e-01f, 8.27643499e-02f,
  2.02239361e-02f, -6.48835208e-03f, 6.28990587e-03f, 1.15737282e-01f, -1.99154653e-02f, -1.25665784e-01f, -3.25180986e-03f, 1.90497600e-02f, 6.55033514e-02f, -3.45660597e-02f,
  5.81109107e-01f, 2.21736267e-01f, -3.52542847e-01f, 1.99187905e-01f, -1.89682096e-01f, -1.59385890e-01f, -3.72669958e-02f, 4.70716767e-02f, 2.49673009e-01f, 2.50620484e-01f,
  -1.06308319e-01f, -2.73283273e-01f, -1.02387793e-01f, -2.09664479e-01f, -1.68582857e-01f, 1.08979657e-01f, 8.37185085e-02f, -2.68614054e-01f, -5.01317024e-01f, -2.51013041e-01f,
  1.15835860e-01f, 1.86607152e-01f, 2.06598882e-02f, -9.37257707e-02f, 1.08002350e-01f, -4.97644022e-02f, 9.69650522e-02f, -4.42620972e-03f, -8.99095088e-02f, 1.84686128e-02f,
  -2.40941361e-01f, -1.95347577e-01f, -1.22288153e-01f, 1.72667298e-02f, 6.55398592e-02f, 4.16360237e-02f, -9.61434469e-02f, -2.59012692e-02f, -5.69979139e-02f, -5.05542606e-02f,
  -1.04494318e-01f, 2.53172256e-02f, -1.85109571e-01f, -1.43070757e-01f, -5.59483618e-02f, -8.26856270e-02f, 1.10397689e-01f, -6.35989457e-02f, -1.15375020e-01f, -7.99502507e-02f,
  -1.24378696e-01f, -1.90232247e-01f, -1.94201380e-01f, -1.10119246e-01f, -1.75750896e-01f, -1.03623010e-01f, -7.11941347e-02f, -1.72217906e-01f, -2.33716577e-01f, 2.89579242e-01f,
  1.34094462e-01f, 5.26332222e-02f, -8.48346502e-02f, -6.98660687e-02f, 4.80780154e-02f, 7.23413154e-02f, -2.37330608e-02f, 3.79327685e-02f, -6.01462126e-02f, 7.71853030e-02f,
  -1.78824738e-02f, 1.51312388e-02f, -8.76907259e-02f, 5.71250208e-02f, 1.63501855e-02f, -5.56120276e-02f, -1.97914825e-03f, 1.22354127e-01f, -4.41471972e-02f, 3.45413685e-02f,
  2.30006650e-02f, -1.62126958e-01f, 1.23276941e-01f, -2.35080682e-02f, -1.19403936e-01f, -7.40328282e-02f, -3.77814919e-02f, -7.51758972e-03f, 9.12408531e-02f, -3.54902609e-03f,
  2.66119719e-01f, -2.98892498e-01f, 5.85122742e-02f, -4.90791872e-02f, -1.43993683e-02f, -5.78092448e-02f, 5.81417531e-02f, -2.79170237e-02f, -6.08544145e-03f, 4.42670546e-02f,
  -1.73452705e-01f, -6.18050210e-02f, -4.74897958e-02f, -2.66503599e-02f, -4.50173765e-02f, -3.31039503e-02f, 8.88779536e-02f, 1.49474517e-02f, -4.52879816e-03f, 9.84872654e-02f,
  1.78705022e-01f, 1.23549804e-01f, 1.38316244e-01f, 5.53982444e-02f, 4.18548808e-02f, 5.64751662e-02f, 6.49329424e-02f, -5.45640104e-02f, 6.08909540e-02f, 4.44716603e-01f,
  -5.38888931e-01f, 1.98745668e-01f, 2.84191575e-02f, -3.69116396e-01f, -5.36064096e-02f, 6.11221492e-02f, 8.81370828e-02f, 4.05443385e-02f, -1.38862282e-01f, 1.88863441e-01f,
  1.23151369e-01f, 2.29888670e-02f, 1.79382525e-02f, -4.42028530e-02f, -2.77136207e-01f, 1.71322137e-01f, 6.41900897e-02f, -1.73805863e-01f, -2.71170497e-01f, -2.08028182e-01f,
  -1.21280819e-01f, -2.91646481e-01f, -3.79887819e-01f, -2.45178401e-01f, 3.47265229e-02f, -1.06068499e-01f, 1.13653876e-01f, -2.64970716e-02f, 1.42906159e-01f, 8.57777894e-02f,
  3.57146591e-01f, 3.49020399e-03f, -5.66775305e-03f, -1.42329425e-01f, 1.41776949e-01f, 4.83763106e-02f, 1.02025166e-01f, -5.14081791e-02f, 1.13532897e-02f, 2.01055724e-02f,
  -7.62918815e-02f, 1.99659646e-01f, -9.89822373e-02f, -1.65690705e-01f, -1.28643394e-01f, -1.16753623e-01f, -1.38193294e-01f, -1.42637134e-01f, 5.20784333e-02f, 1.66079476e-01f,
  6.39650971e-02f, -1.97728276e-02f, -2.03121871e-01f, -6.34810477e-02f, 6.12967499e-02f, -3.39950509e-02f, 7.93147013e-02f, -5.02784327e-02f, 2.11953614e-02f, 1.12057127e-01f,
  5.40027879e-02f, 2.63825655e-02f, 4.27355021e-02f, -2.06201464e-01f, -1.56552359e-01f, 1.11933075e-01f, -1.24414630e-01f, -1.01006545e-01f, 1.71429962e-02f, -1.74700260e-01f,
  1.23941265e-01f, 8.34335759e-02f, 8.98624733e-02f, 6.07311428e-02f, -1.35201499e-01f, -2.18171440e-02f, 1.44191142e-02f, 2.84554418e-02f, -3.27254599e-03f, -5.37290461e-02f,
  -6.75027445e-02f, 5.25270589e-02f, 1.56622417e-02f, -4.43085954e-02f, -3.58663909e-02f, 8.45657010e-03f, 3.75031009e-02f, -1.25269676e-02f, -4.50460948e-02f, -1.12628877e-01f,
  -6.18366040e-02f, -1.47512287e-01f, -2.71555241e-02f, -5.84988343e-03f, -2.12439802e-02f, 7.67050162e-02f, -1.29609138e-01f, 5.75962625e-02f, -6.21386990e-02f, -5.97817674e-02f,
  -7.40450993e-02f, 1.21287279e-01f, -6.65006638e-02f, -1.59263462e-02f, -1.45162120e-01f, 6.36315122e-02f, 1.88109390e-02f, -5.04074283e-02f, -1.22889847e-01f, -1.24153934e-01f,
  -1.44409418e-01f, -4.48091216e-02f, -1.39520243e-01f, -6.92924559e-02f, -5.42898849e-02f, -1.22932494e-01f, 5.50589152e-03f, -1.41609162e-01f, -9.41776261e-02f, -4.86903451e-02f,
  -5.14263753e-03f, -2.22662315e-01f, -3.12500268e-01f, 1.36820048e-01f, -9.95729119e-04f, 4.11047935e-02f, -3.41543645e-01f, -1.70638025e-01f, 2.35668391e-01f, -1.44382626e-01f,
  4.95354123e-02f, 3.10582757e-01f, -4.05479111e-02f, -5.93409687e-02f, -3.69775474e-01f, -4.85965341e-01f, -3.21365625e-01f, -2.76175916e-01f, 5.45497313e-02f, 2.41516456e-01f,
  2.22292960e-01f, 1.39190435e-01f, 6.11137450e-02f, 7.92592168e-02f, 7.25416765e-02f, 5.07704972e-04f, -7.58868977e-02f, -4.76116501e-02f, -1.65723190e-01f, -7.80378729e-02f,
  -1.25314653e-01f, -8.41963217e-02f, -4.27464657e-02f, -3.35636660e-02f, -4.83708754e-02f, -8.05471241e-02f, -3.14541422e-02f, -1.24551684e-01f, -5.72459735e-02f, -1.71315204e-02f,
  4.97164996e-03f, 4.45214845e-02f, 3.37941386e-02f, 1.49143994e-01f, 1.55720502e-01f, -7.30959848e-02f, -1.80204496e-01f, -6.00957386e-02f, -1.37538418e-01f, -1.42345935e-01f,
  -2.25240961e-02f, -3.79891954e-02f, -9.97623950e-02f, -6.67024702e-02f, -2.20454752e-01f, 2.23707035e-02f, -2.50514578e-02f, 1.38272077e-01f, -1.57092154e-01f, -1.71566099e-01f,
  -8.23238194e-02f, -2.21944042e-02f, 1.07619446e-03f, 5.05017154e-02f, 5.18407710e-02f, -8.26164111e-02f, 6.87295571e-03f, -2.68430132e-02f, 2.74602026e-02f, -7.75173083e-02f,
  -4.89980020e-02f, -6.69710105e-04f, 1.05842933e-01f, -1.39306718e-02f, -2.20045205e-02f, 2.49329116e-02f, -1.23663165e-01f, -1.64263368e-01f, 4.85418923e-03f, 3.19814160e-02f,
  -1.19529190e-02f, 1.14335455e-01f, 2.33840495e-02f, 7.37837851e-02f, -1.04895718e-01f, -1.94251537e-01f, -1.26622646e-04f, 2.18544193e-02f, -2.99532730e-02f, -1.00063384e-01f,
  1.60176009e-01f, -2.35865321e-02f, -4.29869518e-02f, 1.74035802e-02f, 2.43428946e-02f, -8.51493031e-02f, 9.63454228e-03f, -1.22111328e-01f, 4.23748866e-02f, 5.33659682e-02f,
  3.13362218e-02f, 1.11999232e-02f, -1.10120021e-01f, 7.67195746e-02f, 1.49191990e-01f, -1.81601557e-03f, -1.03192843e-01f, -9.59940907e-03f, 6.56097531e-02f, 2.07294568e-01f,
  -1.09691910e-01f, -9.42583308e-02f, -7.12982193e-02f, -8.43385309e-02f, -5.66741899e-02f, -8.90502036e-02f, -1.27826959e-01f, 1.23549160e-02f, -2.40658969e-01f, -3.00202549e-01f,
  -8.16173017e-01f, 4.26809713e-02f, 4.34360266e-01f, -5.04928708e-01f, -1.75496474e-01f, -1.93849936e-01f, -1.26021579e-01f, -1.63550094e-01f, -3.26336205e-01f, -4.96292636e-02f,
  1.54265640e-02f, -2.63854917e-02f, 1.53333932e-01f, 2.83549964e-01f, -1.48451347e-02f, 3.82735394e-02f, 3.79735697e-03f, 5.63845150e-02f, 1.26565814e-01f, -8.89261737e-02f,
  -1.39917761e-01f, -2.02944994e-01f, -2.87441194e-01f, -7.08471313e-02f, -1.36584982e-01f, -1.26867875e-01f, 1.06220096e-01f, -1.87510878e-01f, -4.24939767e-02f, -1.67964488e-01f,
  3.09391558e-01f, -2.50532418e-01f, 6.38574213e-02f, -1.19922541e-01f, 3.93121764e-02f, -1.29214182e-01f, -1.78121254e-01f, -8.55390877e-02f, -8.51603225e-02f, 7.87950121e-03f,
  -8.84362012e-02f, 1.26314908e-02f, -3.29457670e-02f, 1.26740366e-01f, -3.62874791e-02f, -3.63120511e-02f, 1.21242560e-01f, -3.26514132e-02f, 3.00911348e-02f, 1.35998115e-01f,
  1.99189112e-01f, -8.51868093e-02f, -9.90969315e-02f, -1.40323929e-04f, -5.89200705e-02f, -2.77809277e-02f, 6.65421784e-02f, -7.52857029e-02f, -2.27640811e-02f, -2.22889304e-01f,
  -9.77308974e-02f, 3.54777090e-03f, 1.53091215e-02f, 8.16433597e-03f, -3.63186449e-02f, -5.40327616e-02f, 4.30781096e-02f, 3.58593278e-02f, 9.65408515e-03f, 1.14893951e-02f,
  4.85635102e-02f, 1.05853237e-01f, -1.14936065e-02f, -2.94819381e-02f, -2.66603641e-02f, -1.78215224e-02f, -1.07949547e-01f, -4.74538058e-02f, -6.79728482e-03f, -6.04310408e-02f,
  -5.67917228e-02f, -1.03765458e-01f, -4.88800108e-02f, 9.46016461e-02f, -5.38424589e-02f, -3.68904099e-02f, -1.38231684e-02f, 9.41051915e-02f, -9.49684232e-02f, 1.03017082e-02f,
  1.92860663e-01f, 9.75640118e-02f, -3.71822156e-02f, -1.26775086e-01f, -1.03436941e-02f, 9.28464904e-02f, -3.08529641e-02f, 7.76771903e-02f, -2.22424325e-02f, 1.67004913e-02f,
  -6.14115298e-02f, -5.39444350e-02f, 5.01082763e-02f, 1.41972825e-01f, 3.75832878e-02f, -1.97489839e-02f, -1.92115596e-03f, -6.35343567e-02f, 9.37430561e-03f, 1.05492018e-01f,
  8.20926726e-02f, -1.06205322e-01f, -3.56180556e-02f, 6.30798787e-02f, -6.02093488e-02f, -1.73928924e-02f, 1.32893071e-01f, 4.13756073e-02f, 1.29048720e-01f, -7.55651519e-02f,
  -4.60759938e-01f, -1.92578778e-01f, -3.09959739e-01f, -2.01536402e-01f, -2.50283092e-01f, -1.85803343e-02f, -3.24366659e-01f, -6.15264699e-02f, -3.73340175e-02f, -3.32568735e-01f,
  -2.73534864e-01f, -7.82031268e-02f, -1.93666950e-01f, -1.41006425e-01f, -9.57434922e-02f, -3.23004603e-01f, -3.12140912e-01f, -2.79855847e-01f, -1.56475335e-01f, 9.87527817e-02f,
  -5.97321205e-02f, -5.09601682e-02f, 2.32422631e-02f, -3.29550020e-02f, 6.63465634e-02f, 7.12113688e-03f, -7.01022595e-02f, -9.22642946e-02f, 3.87853049e-02f, -2.15457901e-01f,
  -3.91889602e-01f, 1.13178808e-02f, 5.97343445e-02f, -9.40577220e-03f, -1.56249925e-01f, 4.45682369e-02f, -1.06514424e-01f, -3.52224335e-02f, -4.53344807e-02f, -9.70506519e-02f,
  -6.56489655e-02f, 6.31922483e-02f, -5.76467961e-02f, 7.44245294e-03f, -1.21060103e-01f, 8.06672778e-03f, 8.95891339e-02f, -7.00677261e-02f, 6.10742494e-02f, 1.29971802e-01f,
  9.40072164e-02f, -5.64374216e-02f, 9.58278868e-03f, 5.90565801e-02f, 1.55018911e-01f, -1.38599928e-02f, 1.12419143e-01f, 2.33440086e-01f, 6.63626865e-02f, 1.23066921e-02f,
  1.04554817e-01f, -9.32295024e-02f, -1.20264245e-02f, 5.54592423e-02f, 5.02333604e-02f, -5.60756139e-02f, 4.65271100e-02f, -1.03619173e-01f, -5.24553582e-02f, -4.34243456e-02f,
  -3.83090749e-02f, -2.57858224e-02f, -4.67180051e-02f, -5.22269532e-02f, 2.38267723e-02f, 1.07611492e-02f, 1.58132687e-02f, -4.84734960e-02f, 1.51201535e-03f, -1.94259714e-02f,
  2.58754124e-03f, 4.64033782e-02f, 6.21975698e-02f, 5.81527613e-02f, -4.98464284e-03f, -4.38870899e-02f, 5.05560935e-02f, 7.61888027e-02f, 1.35894716e-01f, 7.56108342e-03f,
  -2.51705468e-01f, -6.21079504e-02f, -2.41475478e-01f, 1.77017540e-01f, 2.72585507e-02f, 9.08478796e-02f, 6.89976066e-02f, -6.28280193e-02f, 5.25620840e-02f, 6.95674568e-02f,
  2.26966292e-01f, -1.26470495e-02f, -1.18661718e-02f, -1.45436944e-02f, -5.41303307e-02f, 3.27674598e-02f, 4.45440635e-02f, 1.39944395e-03f, 7.84072354e-02f, 1.72949880e-01f,
  8.11913386e-02f, -9.08735096e-02f, -1.08095050e-01f, -2.16549188e-02f, 1.69385955e-01f, 8.15979845e-04f, -5.30130118e-02f, 1.20654725e-01f, 4.68057841e-02f, -5.62178604e-02f,
  -4.60904181e-01f, -7.40468083e-03f, -1.88178793e-01f, -3.93156618e-01f, -3.82737488e-01f, -2.57551551e-01f, 1.95591943e-03f, -1.48748919e-01f, -3.26932043e-01f, -1.30968124e-01f,
  4.11582664e-02f, 5.80429211e-02f, 1.25163168e-01f, 1.05998158e-01f, 8.18240792e-02f, 1.73826795e-02f, -1.77106112e-01f, -1.23854168e-01f, -3.54161449e-02f, -6.91961572e-02f,
  -1.58324227e-01f, -1.25838056e-01f, -1.65450573e-01f, 2.45100930e-02f, -6.97423220e-02f, 1.34517718e-02f, 3.27352360e-02f, -1.41309917e-01f, -3.01472768e-02f, 3.50889284e-03f,
  4.55166548e-01f, -1.92610562e-01f, -1.82245269e-01f, -4.04988006e-02f, -5.93680795e-03f, -1.57445505e-01f, -9.34557393e-02f, 1.11924550e-02f, -1.70701500e-02f, -1.72693208e-02f,
  -1.56297103e-01f, -2.13544425e-02f, -5.29358424e-02f, 1.11243664e-03f, -1.82225108e-01f, 1.57912709e-02f, -1.17327139e-01f, -8.82311910e-02f, -2.25863885e-02f, 1.01110935e-01f,
  -2.51257345e-02f, -7.22000450e-02f, 1.02066599e-01f, 1.85153157e-01f, -1.83379673e-03f, -1.93969291e-02f, 5.08964434e-02f, 5.05106449e-02f, 8.84491354e-02f, 1.48714826e-01f,
  -9.10402928e-03f, 7.68963024e-02f, -1.66336596e-02f, -7.40376934e-02f, -1.83706768e-02f, -4.56506461e-02f, -2.16828883e-02f, 1.63172573e-01f, 4.40866537e-02f, 9.95447189e-02f,
  6.65214360e-02f, 9.49975103e-03f, -2.09128275e-03f, 4.43602651e-02f, 1.23989791e-01f, -9.91367251e-02f, 1.70679819e-02f, 1.35660559e-01f, 3.86352316e-02f, -9.32871625e-02f,
  8.92369356e-03f, 8.03209608e-04f, 6.41168579e-02f, 9.73487273e-02f, -6.94567263e-02f, 1.96691100e-02f, -2.14025937e-02f, -1.27848564e-02f, -2.99788150e-03f, -1.30916715e-01f,
  2.58538663e-01f, -1.69804782e-01f, 1.24160603e-01f, 3.80886421e-02f, 2.69134715e-02f, -1.14993341e-01f, -8.89903866e-03f, 5.90576380e-02f, -8.98142010e-02f, 2.40782332e-02f,
  -1.19814433e-01f, -7.03903064e-02f, -1.23559032e-02f, -6.23810925e-02f, -5.71546145e-02f, -5.26461713e-02f, -8.86596367e-02f, -3.21283452e-02f, 4.17986978e-03f, 4.96581234e-02f,
  -3.43919918e-02f, 5.24919964e-02f, 1.01004921e-01f, 1.45297557e-01f, 8.55723098e-02f, -2.28629205e-02f, 2.09649906e-01f, 1.69603795e-01f, 1.62859470e-01f, 1.75663456e-01f,
  3.06256652e-01f, 3.14479806e-02f, 1.79237679e-01f, 9.69961211e-02f, -2.82214195e-01f, -4.75428194e-01f, -5.80745161e-01f, -2.21476868e-01f, -1.20090088e-02f, -1.01304632e-02f,
  -1.10815383e-01f, -1.34810526e-03f, -1.57507020e-03f, -7.53510976e-03f, -1.50199875e-01f, -4.94313985e-02f, 6.56842487e-03f, 1.29373953e-01f, -1.77304503e-02f, -3.46642062e-02f,
  1.01523707e-02f, 1.61228478e-01f, 1.59508899e-01f, 8.23684484e-02f, 2.73222536e-01f, 5.16439825e-02f, 7.41145685e-02f, 4.69166152e-02f, 3.41121331e-02f, 5.18238842e-01f,
  2.65334070e-01f, 8.36913511e-02f, 6.18753582e-02f, 1.23972651e-02f, 6.25630245e-02f, 5.68410568e-02f, -2.70857122e-02f, 1.24440141e-01f, -9.17819887e-02f, -5.15765883e-02f,
  9.51730385e-02f, 1.81857675e-01f, -1.04622744e-01f, -7.29185492e-02f, -9.13909227e-02f, -3.36144269e-02f, 5.23920655e-02f, 9.23289508e-02f, -1.42115485e-02f, 3.72780971e-02f,
  -4.00683843e-02f, -1.95713729e-01f, -1.58730984e-01f, -2.92068630e-01f, -1.98543921e-01f, -7.08591193e-02f, -3.97739485e-02f, 1.29349470e-01f, -1.02486342e-01f, 2.06409339e-02f,
  -1.70479879e-01f, 4.42236289e-02f, 2.50395555e-02f, 3.58720757e-02f, -1.30759120e-01f, -1.23114839e-01f, -8.54923949e-02f, -1.06745616e-01f, -4.57346812e-02f, 3.90299270e-03f,
  -6.19481951e-02f, -4.25070748e-02f, -1.63873844e-02f, 4.87236045e-02f, 1.45858759e-02f, 7.79126063e-02f, 1.04980804e-02f, -4.78750840e-02f, -8.29714835e-02f, 6.20123465e-03f,
  3.37557830e-02f, 6.23663608e-03f, 1.56802639e-01f, 1.11209072e-01f, -3.88825350e-02f, 4.63116653e-02f, 6.93526599e-05f, -3.55044082e-02f, -7.93961510e-02f, -6.24113046e-02f,
  2.76787177e-04f, -3.15782934e-01f, 1.50638670e-01f, 1.73540428e-01f, 1.96946226e-02f, 1.77975506e-01f, 1.01809621e-01f, 1.36038572e-01f, 7.09315464e-02f, 9.74569917e-02f,
  1.23808235e-01f, 6.27092272e-02f, -1.91952754e-02f, 1.04304396e-01f, 3.01518366e-02f, -5.20768277e-02f, 5.30545972e-02f, 5.25645278e-02f, 1.33080602e-01f, 1.44825995e-01f,
  7.51673058e-02f, -4.99082878e-02f, -2.32524842e-01f, -1.26107797e-01f, -1.18436903e-01f, -1.18198551e-01f, -1.05928592e-01f, 1.23275099e-02f, -9.52684283e-02f, -2.08900571e-01f,
  -2.67551035e-01f, -5.29021084e-01f, 2.38138020e-01f, 5.52679412e-02f, -1.10731743e-01f, -2.51493037e-01f, -5.38824320e-01f, -3.62077355e-01f, -4.64632250e-02f, -2.77686536e-01f,
  -1.15031257e-01f, 2.26778582e-01f, 1.35394737e-01f, 1.99385270e-01f, -1.03241175e-01f, -1.96271315e-01f, 1.81189105e-01f, 3.92271727e-01f, 2.17907697e-01f, -8.51246193e-02f,
  7.73257464e-02f, 1.56778693e-01f, 3.22610438e-01f, 2.29216039e-01f, -2.59090401e-03f, 1.18088946e-01f, 1.09026499e-01f, -1.29332431e-02f, -1.34974912e-01f, 1.89009339e-01f,
  3.80311981e-02f, -2.64026642e-01f, 9.38730091e-02f, 1.41682371e-01f, 3.69031020e-02f, -1.36974752e-01f, -9.64274108e-02f, 3.60942930e-02f, 3.27774547e-02f, 1.34849668e-01f,
  6.53407946e-02f, 4.91247326e-02f, -1.26560694e-02f, 9.14818123e-02f, -1.98863521e-02f, -3.79126705e-02f, 6.87520131e-02f, 1.62558958e-01f, 1.10394292e-01f, -4.47450988e-02f,
  -2.58052479e-02f, 2.91707721e-02f, 6.97707012e-02f, -1.57036155e-01f, -2.04514325e-01f, 1.22667640e-01f, -7.96928704e-02f, -3.35921720e-02f, -8.86270776e-02f, -1.45615637e-01f,
  5.23366854e-02f, 5.99841997e-02f, 6.15824871e-02f, -5.23743294e-02f, -5.18588796e-02f, 8.86983722e-02f, -7.91722350e-03f, 7.58152157e-02f, 8.42076242e-02f, -3.35590467e-02f,
  2.55031418e-02f, 9.83887538e-02f, -1.07129462e-01f, -8.27833544e-03f, 1.09321035e-01f, 9.28730220e-02f, 4.40751240e-02f, 6.44168407e-02f, 2.80204803e-01f, 1.40568418e-02f,
  7.72516131e-02f, -1.54724894e-02f, 7.43341073e-02f, 9.63035449e-02f, 3.31153646e-02f, 6.26799464e-02f, 7.57290944e-02f, -9.63962078e-02f, 4.23383415e-02f, -2.28225179e-02f,
  -6.51665628e-02f, 2.68558133e-02f, 1.58674957e-03f, -2.90347007e-03f, 3.47941332e-02f, 7.60758668e-02f, -8.23865160e-02f, 2.11545929e-01f, 3.66535783e-02f, -1.08224154e-01f,
  -2.42541537e-01f, -1.49122700e-01f, -4.14076410e-02f, -7.84752369e-02f, -1.16693623e-01f, -1.12092614e-01f, 2.89902780e-02f, 7.50938430e-02f, -5.60205765e-02f, 9.22645535e-03f,
  1.98250785e-02f, -1.40147194e-01f, -1.89772427e-01f, -8.53946730e-02f, -1.88916609e-01f, 1.19960504e-02f, 4.36428078e-02f, -1.83344752e-01f, -2.24096417e-01f, -4.01432723e-01f,
  -2.03478679e-01f, 1.67115107e-01f, 1.60757288e-01f, -1.32539839e-01f, 5.71218021e-02f, 1.64447341e-03f, 6.30707815e-02f, -1.12460747e-01f, -3.86431292e-02f, -3.36288214e-02f,
  8.50048289e-02f, 1.24028154e-01f, -2.97630560e-02f, 2.67050117e-02f, 2.92839240e-02f, -1.87965989e-01f, -1.25156820e-01f, -1.43496886e-01f, -2.01191396e-01f, -1.62453279e-01f,
  -8.66800994e-02f, -1.64255679e-01f, -1.68832123e-01f, -1.21040851e-01f, -1.42782375e-01f, -2.27515161e-01f, -5.26077226e-02f, -1.13976359e-01f, 4.76285722e-03f, -1.03162661e-01f,
  4.40818757e-01f, 2.06921175e-01f, -7.14115202e-02f, -2.51683742e-02f, 1.27602607e-01f, 1.51660470e-02f, 7.31466487e-02f, 3.69319655e-02f, -7.06369895e-03f, -1.08217172e-01f,
  -7.04875588e-02f, 1.04846805e-01f, -1.00288682e-01f, 8.78516957e-02f, 3.99305820e-02f, 1.27431989e-01f, 1.30225509e-01f, 9.76899192e-02f, 1.41327754e-01f, 1.63709223e-01f,
  1.79829642e-01f, 9.64003354e-02f, 5.49263507e-02f, 4.07906510e-02f, 1.05460815e-01f, 1.47708386e-01f, 1.74033895e-01f, 4.22907174e-02f, 1.24062747e-01f, -2.36372352e-02f,
  1.49257807e-02f, -1.46490131e-02f, 9.36769694e-02f, 4.79004756e-02f, 1.03165641e-01f, -1.17682852e-04f, -1.14311665e-01f, -6.08577840e-02f, -3.65813747e-02f, -8.27111863e-03f,
  -4.04553749e-02f, 1.33981988e-01f, 1.20720834e-01f, 6.36457354e-02f, 2.31341440e-02f, 2.52113752e-02f, -5.10832183e-02f, 1.33331403e-01f, 1.70443028e-01f, 7.61171207e-02f,
  1.10060640e-01f, 2.84668729e-02f, 5.59716020e-03f, 1.82777159e-02f, 3.75084132e-02f, 8.61366317e-02f, 3.84469554e-02f, 3.84541191e-02f, 3.86942551e-02f, -6.99346699e-03f,
  3.18389058e-01f, 1.67916954e-01f, -1.57175943e-01f, 1.07013956e-01f, 3.71804386e-02f, 1.11854009e-01f, 1.19167581e-01f, 6.95441514e-02f, 3.90647277e-02f, 6.49312958e-02f,
  6.23030588e-02f, -7.59965628e-02f, -5.64042553e-02f, 4.78062294e-02f, -5.85919581e-02f, 2.81797163e-02f, 1.72121719e-01f, 8.02848674e-03f, 1.11375846e-01f, 1.75249930e-02f,
  2.18947567e-02f, -3.59441736e-03f, 3.69436480e-02f, 5.94670139e-02f, 5.35119958e-02f, -1.84774604e-02f, -2.75913123e-02f, -2.57703774e-02f, -1.65794604e-02f, -1.92291781e-01f,
  -5.06450593e-01f, -1.52819380e-01f, -4.44554463e-02f, -3.24846432e-02f, 2.65449852e-01f, 2.86447048e-01f, 2.96635181e-01f, 1.07525066e-01f, 7.39598498e-02f, 3.87820825e-02f,
  -2.13860512e-01f, -3.11239928e-01f, -3.60116720e-01f, -1.21908970e-01f, -6.53023794e-02f, 3.80885929e-01f, 4.22941476e-01f, -9.56412703e-02f, -2.69300099e-02f, 1.58404678e-01f,
  2.43006125e-01f, -1.05694838e-01f, -3.01652640e-01f, -1.73981205e-01f, 1.29580855e-01f, 1.01994686e-02f, 9.17027146e-02f, -1.56914383e-01f, 7.74576142e-02f, 4.35201563e-02f,
  -3.35435301e-01f, -3.70025456e-01f, 1.36798903e-01f, -3.00685186e-02f, -5.78620844e-02f, -1.21866226e-01f, 1.18612446e-01f, -1.42237350e-01f, -9.71632302e-02f, 7.94522185e-03f,
  -3.98428515e-02f, -4.26783040e-02f, -1.84372470e-01f, 1.69812459e-02f, -4.63475995e-02f, 2.19819099e-02f, 3.29766120e-03f, -1.99904144e-01f, -1.98230028e-01f, -1.01475835e-01f,
  7.18581900e-02f, -5.86751439e-02f, -2.06690446e-01f, 1.35408700e-01f, -4.19481397e-02f, 1.21240225e-02f, -1.86548769e-01f, -1.04289152e-01f, -2.84045905e-01f, -1.51872411e-01f,
  -2.13979390e-02f, -6.11876957e-02f, -5.52053079e-02f, -1.09742200e-02f, 1.07756257e-01f, 1.10188112e-01f, -2.32012547e-03f, 2.55249217e-02f, 1.38869099e-02f, 4.20700237e-02f,
  -1.08122028e-01f, -3.16450857e-02f, 1.32645667e-02f, 4.89115017e-03f, -4.94519025e-02f, 4.46885964e-03f, 8.86433870e-02f, -1.46737266e-02f, -6.14945889e-02f, -6.87472224e-02f,
  2.71058064e-02f, 2.00932869e-03f, -1.33855073e-02f, -8.39604437e-03f, 2.83506047e-02f, 1.03164099e-01f, -2.35554092e-02f, 1.96317080e-02f, -3.78511287e-02f, 6.07663170e-02f,
  -3.01423073e-01f, -2.15785839e-02f, 2.77721807e-02f, 2.61022560e-02f, -5.09744547e-02f, -8.55851024e-02f, -1.07046999e-01f, -3.10637169e-02f, -7.43082352e-03f, 9.32520605e-04f,
  -7.37535805e-02f, -1.78572424e-02f, -5.89537509e-02f, 7.79540315e-02f, 6.68613473e-03f, 7.07134081e-04f, 1.92487180e-01f, 1.00911513e-01f, 8.64646137e-02f, 4.18534838e-02f,
  1.37415513e-01f, 2.43697867e-01f, 1.91684470e-01f, 7.44907409e-02f, 6.68724403e-02f, 2.00228110e-01f, -4.05759923e-02f, 2.48090569e-02f, 9.75184292e-02f, 2.48615518e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.27454445e-01f, -9.87148564e-03f, 1.29780561e-01f, -6.32977933e-02f, 1.83099449e-01f, 3.59244011e-02f, 1.00992650e-01f, 4.22226489e-02f, 1.51089087e-01f, 1.10154830e-01f,
  3.36013526e-01f, 8.78830850e-02f, 2.32687935e-01f, 2.18574017e-01f, 6.01409376e-02f, 5.48939221e-02f, 2.26359203e-01f, 9.63559449e-02f, -4.97661866e-02f, 2.63749689e-01f,
  1.75218314e-01f, 1.01661809e-01f, 1.79315016e-01f, 7.53741562e-02f, -1.43615648e-01f, 3.84075701e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.38087052e-03f, 1.30523458e-01f, 2.26843543e-02f, 6.46556765e-02f, 8.54159296e-02f, 8.78084823e-02f, -1.23718902e-01f, 1.04419485e-01f, -1.88194774e-02f, -1.46106910e-02f,
  5.38609587e-02f, -1.24137085e-02f, 7.78447539e-02f, 4.49220538e-02f, 9.95824635e-02f, 1.15038129e-02f, -8.78877640e-02f, -1.12622365e-01f, 1.13744907e-01f, -9.71053094e-02f,
  2.75502577e-02f, -5.07809706e-02f, 2.84919608e-02f, -1.73076652e-02f, 4.34550643e-02f, 1.13870904e-01f, -1.73371196e-01f, 3.92511636e-02f, -8.70978609e-02f, 1.61705285e-01f,
  -1.96155533e-02f, -4.48007211e-02f, 9.56210792e-02f, 2.43376791e-02f, 1.26820773e-01f, 1.56620815e-01f, 5.49395643e-02f, -2.02428084e-02f, 1.42546609e-01f, 1.08770840e-01f,
  -7.46987909e-02f, 9.00714099e-02f, 1.46510884e-01f, -1.90576509e-01f, -3.86566013e-01f, -6.41255379e-02f, 6.62558600e-02f, -1.82640523e-01f, -6.31417632e-02f, -2.50116974e-01f,
  6.24090694e-02f, 5.53003252e-02f, 5.87714873e-02f, 1.40873596e-01f, 2.29189768e-01f, 1.78885520e-01f, -2.03561440e-01f, 1.63095400e-01f, -4.55835797e-02f, 2.15474948e-01f,
  -7.24667450e-03f, -1.47172838e-01f, 1.63926154e-01f, -1.41587332e-01f, -4.34482731e-02f, 1.28431663e-01f, -9.30622965e-03f, -1.30783647e-01f, -1.06302582e-01f, 1.72129244e-01f,
  -7.54382908e-02f, -2.30211783e-02f, -4.80326638e-02f, 1.27939731e-01f, 8.60901549e-02f, -5.99727035e-02f, 1.00505911e-01f, -3.98005508e-02f, 7.43149370e-02f, -3.96692157e-02f,
  -8.05794895e-02f, -2.41980683e-02f, -5.60416020e-02f, 3.81975295e-03f, 1.65168300e-01f, 2.60057170e-02f, -1.74388230e-01f, 4.43285145e-02f, 4.88052554e-02f, -2.05796063e-01f,
  1.00278519e-01f, 9.95060056e-02f, -9.49830040e-02f, -8.11600611e-02f, 2.88638800e-01f, -8.39665905e-02f, 2.60729231e-02f, 2.35492419e-02f, 1.32092666e-02f, -1.36140332e-01f,
  4.63950410e-02f, 8.74474272e-02f, 1.25647977e-01f, -2.56781071e-01f, 2.07975097e-02f, -1.81923270e-01f, 1.03018306e-01f, -7.66493231e-02f, -2.24307984e-01f, 3.47383060e-02f,
  7.34360591e-02f, 3.94432932e-01f, -1.70139864e-01f, -1.18673127e-02f, -4.82529998e-01f, -1.25723496e-01f, -8.69335383e-02f, -5.99164143e-03f, -1.44747436e-01f, 1.91083223e-01f,
  4.43683080e-02f, 6.63561076e-02f, 3.72071676e-02f, -2.05461115e-01f, -1.03574589e-01f, 1.06810622e-01f, 7.67221972e-02f, -8.89531374e-02f, -5.80433309e-02f, -2.35583916e-01f,
  -1.53559014e-01f, -1.49590954e-01f, -1.47558153e-01f, -8.68202448e-02f, -2.10970461e-01f, -8.74567702e-02f, 5.58844283e-02f, -7.71945342e-02f, -1.08992644e-01f, -7.22767860e-02f,
  -4.28333357e-02f, 2.43598633e-02f, -1.38265118e-01f, 1.66010745e-02f, 1.03844344e-04f, -6.72285855e-02f, -5.45445196e-02f, 1.75381482e-01f, 1.56498224e-01f, 6.25229999e-02f,
  -2.12795049e-01f, -1.19996034e-01f, -7.75156915e-02f, 2.03394786e-01f, 2.51060491e-03f, -8.50969926e-02f, 3.57266441e-02f, -4.45467494e-02f, 9.61146578e-02f, 9.74783152e-02f,
  1.81025296e-01f, 1.71245843e-01f, -1.16260466e-03f, 3.86679210e-02f, -9.36052650e-02f, -1.93770304e-02f, -5.14927097e-02f, -2.25849569e-01f, 9.76607669e-04f, -1.78707331e-01f,
  -6.71545863e-02f, 2.57512033e-01f, -8.98456126e-02f, -8.50861073e-02f, -2.29595691e-01f, -2.82276869e-01f, 7.78514072e-02f, -2.06656512e-02f, 1.61148787e-01f, -9.62903202e-02f,
  1.96075663e-01f, -2.70670367e-04f, -3.67311150e-01f, -7.93101639e-02f, -1.15434386e-01f, 1.39583321e-03f, -1.37470111e-01f, -2.30936423e-01f, -3.60737890e-02f, -1.24497861e-02f,
  -3.46638151e-02f, 1.02291033e-01f, 1.16088800e-01f, 1.05151311e-01f, 1.38796538e-01f, -7.25151226e-02f, 5.30563816e-02f, 1.50206044e-01f, -2.23947894e-02f, 3.89822014e-02f,
  5.02880961e-02f, 6.79102764e-02f, 8.90364870e-02f, 6.82940781e-02f, -3.93790985e-03f, 2.54549652e-01f, 1.90746412e-02f, -8.73740539e-02f, 2.90403254e-02f, 8.73949900e-02f,
  2.85739321e-02f, 5.77702224e-02f, 8.85335952e-02f, 1.55739442e-01f, -1.77454159e-01f, 5.02227480e-03f, 4.29364704e-02f, 3.06697302e-02f, -1.92314804e-01f, 5.99524342e-02f,
  3.30391861e-02f, 1.07918102e-02f, -4.19341810e-02f, -6.03318475e-02f, 3.28911155e-01f, 7.03636557e-02f, 8.62554759e-02f, -9.86439437e-02f, 7.22974315e-02f, -1.12860270e-01f,
  1.53476223e-01f, -5.05319089e-02f, 1.27949029e-01f, -3.06369383e-02f, -1.87941700e-01f, -1.63666308e-02f, 6.48660511e-02f, -8.17084312e-03f, -3.34795505e-01f, 4.66872379e-02f,
  1.54626310e-01f, -3.58840525e-01f, -4.24323343e-02f, -2.03380972e-01f, 2.79479444e-01f, 9.25313681e-02f, -8.77523646e-02f, -4.43030559e-02f, -2.47795179e-01f, 2.51970023e-01f,
  -5.86373359e-02f, 2.12179758e-02f, -1.78592697e-01f, 1.09785870e-01f, -1.18809938e-01f, 1.18655808e-01f, -3.69210057e-02f, -1.04444608e-01f, -3.49520184e-02f, -1.25317171e-01f,
  -1.34853438e-01f, -7.55589008e-02f, -8.34867433e-02f, -2.12170798e-02f, -1.50072396e-01f, 6.07995177e-03f, -9.20135975e-02f, -1.02018893e-01f, -2.66861357e-02f, -1.06660992e-01f,
  -5.43128187e-03f, -4.94945236e-02f, -1.17923729e-01f, -1.82955246e-02f, 1.50953889e-01f, 7.23194107e-02f, -9.62401554e-02f, 4.14326862e-02f, 1.80512264e-01f, 3.33617628e-02f,
  4.19498086e-02f, -1.02997541e-01f, 3.33383441e-01f, -1.06087327e-01f, 6.40674457e-02f, -1.10866785e-01f, 8.02902430e-02f, -2.16910872e-03f, -4.48744977e-03f, -2.38587618e-01f,
  -2.11349130e-01f, 1.20404348e-01f, 3.39715630e-02f, 2.19798684e-01f, 2.86241937e-02f, -5.52980304e-02f, -4.35684398e-02f, -1.65629104e-01f, -3.71514522e-02f, 4.55068285e-03f,
  -4.00727302e-01f, -1.04526095e-01f, 7.08393678e-02f, 9.12960991e-02f, -9.37980190e-02f, 7.10175335e-02f, 9.92163792e-02f, 1.43776506e-01f, -8.66005868e-02f, 1.24669574e-01f,
  1.35079235e-01f, 2.17832819e-01f, 5.50384447e-02f, 1.03263564e-01f, 1.27593681e-01f, -1.04150325e-01f, 4.96532908e-03f, -2.36646861e-01f, 5.11973485e-06f, 1.69729237e-02f,
  3.30850221e-02f, -1.97392981e-02f, 1.09866485e-01f, -1.50114158e-02f, 5.09761870e-02f, 7.12890476e-02f, 1.16954364e-01f, 2.80181170e-02f, 5.49518270e-03f, 1.41465291e-01f,
  -2.03668512e-02f, 5.48436008e-02f, 6.96116835e-02f, 1.07938305e-01f, 9.70558450e-02f, 2.55676322e-02f, -1.19629495e-01f, -9.85790864e-02f, -5.77802323e-02f, -5.17223999e-02f,
  -1.26985982e-01f, 4.78391089e-02f, 1.30534410e-01f, 2.20308304e-01f, -1.44772664e-01f, 1.61815897e-01f, -9.78376046e-02f, 1.57351062e-01f, -6.50728196e-02f, -4.66700718e-02f,
  -2.47039478e-02f, -7.80831724e-02f, -1.12117194e-01f, 1.11973822e-01f, -4.20669578e-02f, -1.01371422e-01f, -2.04593912e-02f, 1.27255216e-01f, -6.28682226e-02f, 1.87713489e-01f,
  4.58842237e-03f, -2.40932897e-01f, 1.62374917e-02f, -1.09103478e-01f, 2.03114018e-01f, -1.63249467e-02f, 2.09911674e-01f, -1.78889837e-02f, -1.54889142e-02f, 3.90375555e-02f,
  -1.64346442e-01f, 2.51562208e-01f, -2.33355552e-01f, 2.57860664e-02f, 9.11860317e-02f, 1.52766323e-02f, 2.32474014e-01f, 1.44177778e-02f, 1.47260234e-01f, 2.05541536e-01f,
  2.05585510e-02f, -7.44871646e-02f, -3.59192491e-02f, -2.12044358e-01f, 1.33337274e-01f, 7.42480308e-02f, 1.58466592e-01f, 5.46340570e-02f, -7.99487531e-02f, -1.75454751e-01f,
  1.18232504e-01f, -1.04228951e-01f, 2.72783637e-03f, 1.71242490e-01f, -4.20021713e-02f, 9.51455310e-02f, 4.34013531e-02f, 5.22104353e-02f, 1.76460907e-01f, -1.03094548e-01f,
  -1.12582617e-01f, -1.57303482e-01f, 9.49915573e-02f, -2.50655055e-01f, -6.13111071e-02f, 5.88623323e-02f, 3.06319088e-01f, 2.80995257e-02f, -5.22109121e-02f, -1.14762440e-01f,
  7.30072558e-02f, 9.56976041e-02f, 4.34931107e-02f, 1.24029182e-01f, -3.51999812e-02f, -9.39247310e-02f, -2.16340557e-01f, -7.37824151e-03f, -1.58124983e-01f, -4.29827124e-02f,
  1.26610026e-01f, 1.11174427e-01f, 4.58697928e-03f, 2.53319621e-01f, -2.23766923e-01f, -6.07756600e-02f, 2.08617344e-01f, -2.57293675e-02f, 1.61903366e-01f, -2.03229055e-01f,
  9.56625193e-02f, 1.61030397e-01f, -6.05178103e-02f, 9.26836804e-02f, -2.25465670e-02f, 2.40859076e-01f, -6.62548542e-02f, -1.47210032e-01f, 3.23058933e-01f, -6.23649210e-02f,
  1.50987074e-01f, -1.93409622e-01f, 7.18424991e-02f, -3.52509581e-02f, -1.02857035e-02f, 3.05944264e-01f, -3.70618068e-02f, -1.20695114e-01f, 6.42859042e-02f, -6.43742308e-02f,
  1.90420891e-03f, 8.12588409e-02f, -1.80902444e-02f, 1.13223828e-01f, -3.74144576e-02f, 9.66560841e-02f, 9.92840715e-03f, -8.56377706e-02f, 2.66258493e-02f, -4.16196976e-03f,
  3.20169851e-02f, -2.08241493e-02f, -5.10798395e-02f, -8.08660910e-02f, -6.57882616e-02f, -1.39761850e-01f, -7.40424842e-02f, -4.88446131e-02f, -8.10286775e-02f, -5.53119890e-02f,
  7.37761557e-02f, 7.20284730e-02f, -1.70979630e-02f, -2.42822263e-02f, 4.21515442e-02f, -1.21135496e-01f, -7.66406134e-02f, 2.21673250e-02f, 4.23002951e-02f, -1.41745582e-01f,
  -1.25250295e-01f, -1.04488075e-01f, 6.02690876e-02f, 1.13704808e-01f, -1.65924072e-01f, 2.86985207e-02f, -6.84854165e-02f, 4.39517722e-02f, -1.43826082e-01f, 1.37225106e-01f,
  -1.34402096e-01f, -1.38662988e-02f, -1.48676947e-01f, 9.53191817e-02f, 1.14955809e-02f, -1.84871405e-01f, -2.12084819e-02f, -5.34800254e-02f, 1.61149457e-01f, 1.79975018e-01f,
  6.04143180e-02f, -1.37540147e-01f, -1.90454304e-01f, 2.11780787e-01f, -7.04702362e-03f, 2.25605503e-01f, 1.36795029e-01f, 1.93193525e-01f, -1.19227976e-01f, 2.36032866e-02f,
  -1.12482794e-01f, 2.17803657e-01f, 1.27816290e-01f, 4.99090031e-02f, -1.95593503e-03f, 1.14668466e-01f, -1.73734874e-01f, -1.68125749e-01f, -3.30591276e-02f, -1.36122614e-01f,
  4.91145588e-02f, 1.49492055e-01f, 8.83915871e-02f, 6.61458522e-02f, 8.67061391e-02f, -1.78051963e-01f, -4.59998697e-02f, -8.24746564e-02f, -1.04229795e-04f, -8.70713592e-02f,
  -8.52257684e-02f, -8.63073021e-02f, -1.14500195e-01f, 1.01976968e-01f, 2.32501581e-01f, 1.63656160e-01f, 1.25010759e-01f, -1.96514681e-01f, 3.28231096e-01f, -9.00273323e-02f,
  -2.51802921e-01f, -1.12807430e-01f, 1.11058742e-01f, -7.38935396e-02f, -2.33896852e-01f, -3.42108048e-02f, -1.50515065e-01f, 3.58097628e-02f, 3.29990238e-02f, 2.11528279e-02f,
  7.12855607e-02f, 9.59288925e-02f, -9.72554609e-02f, -1.73899069e-01f, -7.23985862e-03f, 2.09297523e-01f, 1.24124549e-01f, -6.12739064e-02f, -2.38114782e-02f, 3.29766423e-01f,
  -4.62616384e-02f, 3.48496288e-01f, -1.83812454e-01f, -1.06997363e-01f, 6.67714030e-02f, -1.45437509e-01f, -1.29036028e-02f, 1.66104976e-02f, 1.66706026e-01f, -1.38395458e-01f,
  -9.55624729e-02f, -6.95198542e-03f, -4.25851569e-02f, 4.44246223e-03f, -6.41202256e-02f, -9.39468071e-02f, 6.03279546e-02f, 1.29164428e-01f, -7.00011030e-02f, -1.92611873e-01f,
  5.98386414e-02f, -5.14997281e-02f, -1.05048671e-01f, 9.31712538e-02f, 3.62154432e-02f, -1.96877763e-01f, 1.08295744e-02f, 9.48926061e-02f, 4.03852835e-02f, -6.99767321e-02f,
  -1.44126996e-01f, 4.43248525e-02f, 1.54658645e-01f, -5.83819896e-02f, -4.48526554e-02f, 6.59772987e-03f, -5.58605790e-02f, 3.91392931e-02f, -1.69684500e-01f, -1.63985565e-01f,
  8.11252147e-02f, -3.92863415e-02f, -8.63362327e-02f, -6.08481690e-02f, 2.06520690e-06f, 7.54870623e-02f, 8.55526701e-02f, 6.53822571e-02f, 1.35315254e-01f, -8.75502825e-02f,
  -9.01027210e-03f, 6.32465035e-02f, 8.10751244e-02f, 1.13643548e-02f, -9.86583978e-02f, -8.70753378e-02f, 8.16978216e-02f, 9.37727746e-03f, -2.11537436e-01f, -9.79441106e-02f,
  -8.94686207e-02f, 5.80168553e-02f, -1.52236179e-01f, 1.31691292e-01f, -2.29786098e-01f, 1.98895827e-01f, 2.91787773e-01f, 6.10164646e-03f, 1.06257983e-01f, -9.33881178e-02f,
  -3.84553894e-02f, 6.41596988e-02f, -1.20436609e-01f, 1.46551907e-01f, -2.01940522e-01f, 2.90458202e-02f, -2.16556877e-01f, -2.06026375e-01f, -7.22849071e-02f, 1.51866168e-01f,
  1.47410259e-01f, -1.53329924e-01f, 1.14488691e-01f, 1.29432991e-01f, -1.01469025e-01f, -2.91363411e-02f, -1.02538571e-01f, -3.89613360e-02f, 8.05023089e-02f, 6.91110939e-02f,
  1.73915718e-02f, 5.72107323e-02f, -9.42990705e-02f, -7.67548233e-02f, -6.42729849e-02f, 6.26677042e-03f, 8.24323017e-03f, -8.01080838e-02f, 3.89471203e-02f, 2.64558978e-02f,
  -2.27536827e-01f, -1.75752580e-01f, 1.72687262e-01f, 1.07159264e-01f, -1.30626827e-01f, -1.60116516e-02f, 1.63577683e-02f, 1.37197584e-01f, -2.60511003e-02f, 1.00067154e-01f,
  -2.09117457e-02f, -3.15896794e-02f, -5.77400476e-02f, 1.53503135e-01f, 1.62134796e-01f, 5.02939560e-02f, 2.69077253e-02f, -7.36843646e-02f, 8.25246051e-02f, 1.24258861e-01f,
  6.62810504e-02f, 2.15555862e-01f, -3.09292585e-01f, -1.19087249e-01f, 4.31170046e-01f, -2.54262635e-03f, -9.06870142e-02f, -2.93082297e-01f, 3.46859545e-02f, -2.46799693e-01f,
  1.35714009e-01f, -1.19436860e-01f, 1.76644251e-01f, 6.77361712e-02f, -1.50484666e-01f, -1.55085474e-01f, 1.09129623e-02f, -9.77710858e-02f, 1.14222452e-01f, -5.08828238e-02f,
  1.05255373e-01f, 3.95967625e-02f, -5.53677231e-02f, 1.10125683e-01f, 3.55134197e-02f, 1.49559885e-01f, -2.26964071e-01f, 2.43989006e-02f, 7.88847283e-02f, -6.58815801e-02f,
  2.83165649e-02f, -3.87855321e-02f, -7.56122619e-02f, 4.83150855e-02f, -1.49460435e-01f, -1.27078379e-02f, 1.19770260e-03f, -1.42255202e-02f, 4.73696813e-02f, 5.41932732e-02f,
  5.08964285e-02f, -4.98534702e-02f, 3.61214280e-02f, 5.52609935e-02f, -1.16156051e-02f, -2.92211096e-03f, 1.55870005e-01f, 1.15561357e-03f, 1.37027338e-01f, -1.09355683e-02f,
  7.99871385e-02f, -1.32079408e-01f, -8.60458612e-03f, -2.56381575e-02f, -4.36313786e-02f, 2.23328099e-02f, 4.53998372e-02f, 5.66835031e-02f, -1.09451778e-01f, -1.70469955e-01f,
  7.94006418e-03f, 2.33948580e-03f, -3.69654000e-01f, -1.43393338e-01f, -1.01200677e-01f, -6.41317815e-02f, 8.56185332e-02f, 1.78218976e-01f, 8.26718360e-02f, -2.80631222e-02f,
  2.93025821e-01f, -1.18392957e-02f, 6.32783249e-02f, 4.07605618e-01f, -8.50981027e-02f, 1.40009701e-01f, -1.90918490e-01f, -9.33698937e-02f, 2.37654939e-01f, 4.59306687e-02f,
  -8.75610039e-02f, 2.69668531e-02f, -2.02783376e-01f, 6.08450770e-02f, 2.14389041e-01f, -3.00273541e-02f, 2.02212501e-02f, -1.55840188e-01f, 4.60971221e-02f, 1.67499229e-01f,
  1.97220549e-01f, -4.54546511e-02f, -3.36416364e-02f, -3.96798924e-02f, 2.26914324e-02f, -2.85540689e-02f, 3.57833356e-02f, 3.87407839e-02f, 6.23941496e-02f, 1.17107304e-02f,
  -4.87540662e-02f, 3.24508324e-02f, -6.58236742e-02f, 9.33234915e-02f, 1.24779098e-01f, 1.48639590e-01f, 7.71864057e-02f, -5.11714667e-02f, 6.88869655e-02f, 9.74430814e-02f,
  2.67499864e-01f, -7.75632961e-03f, -1.76192373e-01f, -1.19604394e-01f, 1.19192481e-01f, 1.06840007e-01f, 6.09265268e-02f, -1.44474447e-01f, -8.69932622e-02f, 1.39494061e-01f,
  -1.16836436e-01f, -1.30287316e-02f, 1.54224560e-01f, -6.45482168e-02f, 3.53813358e-02f, -4.95323762e-02f, -7.12665319e-02f, 1.92887574e-01f, 1.51874378e-01f, 1.16450280e-01f,
  -3.66906002e-02f, 1.53600439e-01f, 3.50115329e-01f, 1.39027117e-02f, 1.58785939e-01f, -3.16189937e-02f, 4.64143269e-02f, -9.86635685e-02f, -1.23571590e-01f, -3.69830281e-02f,
  2.02465564e-01f, 1.62480965e-01f, 1.75464362e-01f, -1.96697235e-01f, 2.21084058e-02f, -2.03049257e-01f, 4.23359983e-02f, -1.60709694e-01f, 8.34787786e-02f, 4.20408770e-02f,
  -8.32582489e-02f, -1.00880630e-01f, 7.90377557e-02f, 1.02680296e-01f, 1.26913577e-01f, -1.33298221e-03f, -4.50169668e-02f, 1.24056272e-01f, 1.61317632e-01f, 1.22768477e-01f,
  -2.99376380e-02f, -1.25988796e-01f, 8.90728012e-02f, 9.95819792e-02f, 1.86206610e-03f, 1.05855025e-01f, 2.79554212e-03f, -1.83954313e-02f, 1.59083810e-02f, -2.80270129e-02f,
  7.45519251e-02f, -2.90422002e-03f, -7.89107457e-02f, -3.18306871e-02f, -2.22749904e-01f, 8.59264284e-02f, -1.60622932e-02f, 2.08744094e-01f, -1.58752441e-01f, 2.12976914e-02f,
  -1.63697764e-01f, 3.03478949e-02f, 2.66294293e-02f, 1.14801135e-02f, 9.83845443e-02f, 2.51845479e-01f, 1.20016024e-01f, 1.51794076e-01f, 6.09457009e-02f, 5.55816591e-02f,
  1.34008944e-01f, -2.13432565e-01f, 1.38914853e-01f, 1.25561684e-01f, -1.80743396e-01f, -9.08394903e-02f, 3.26914907e-01f, -7.76464269e-02f, -3.03896844e-01f, 2.05943845e-02f,
  -6.01861775e-02f, -3.83793414e-01f, 1.98058560e-01f, -1.15592152e-01f, 5.63998483e-02f, 8.57767910e-02f, -2.41867229e-01f, 1.06199227e-01f, -1.92506075e-01f, 1.13154359e-01f,
  -8.63791704e-02f, 1.82576075e-01f, -1.05694652e-01f, -3.02447416e-02f, 1.54054612e-01f, -1.39040255e-03f, -1.88950188e-02f, 1.29343957e-01f, -1.74744666e-01f, 1.35371491e-01f,
  4.51175729e-03f, 2.37870857e-01f, -6.80552796e-02f, -2.20843311e-02f, 5.06662689e-02f, -8.77891034e-02f, 7.01332390e-02f, -3.64354663e-02f, 1.09032683e-01f, 2.99946498e-02f,
  -1.38621956e-01f, -5.47033362e-02f, -3.57448682e-02f, -5.15033491e-02f, 1.30347490e-01f, 1.06201880e-01f, 2.18040809e-01f, -6.38965070e-02f, -2.44184822e-01f, 1.66566726e-02f,
  -5.10198511e-02f, 2.20943674e-01f, 6.12231018e-03f, -1.42383561e-01f, 4.70017530e-02f, 1.29532710e-01f, -5.34036495e-02f, -7.40656182e-02f, 3.86616886e-02f, 8.75723734e-02f,
  -4.50352505e-02f, 6.14085421e-02f, -5.50102852e-02f, -1.94961131e-01f, 3.49584073e-02f, -1.88972250e-01f, -5.28250448e-02f, -2.11068004e-01f, 2.42842901e-02f, 4.88632284e-02f,
  -4.33039159e-01f, 4.76840436e-02f, 7.00738430e-02f, -1.99338898e-01f, 9.58082825e-02f, 1.72552019e-02f, -6.47677183e-02f, 8.52259919e-02f, -4.57830019e-02f, -2.39685923e-02f,
  -2.51277611e-02f, 2.17294157e-01f, -2.76069224e-01f, 2.54182130e-01f, -1.97028667e-01f, 6.40703663e-02f, 9.16778669e-02f, -2.46427342e-01f, -3.92957553e-02f, 1.98490724e-01f,
  6.24530017e-02f, 2.72678286e-01f, -2.74522919e-02f, 1.10277925e-02f, 1.57704338e-01f, 1.08315691e-01f, 6.45516738e-02f, 6.36666343e-02f, -6.10438175e-02f, 3.70628200e-02f,
  -3.11302058e-02f, 1.33143827e-01f, 1.20411061e-01f, -1.28399571e-02f, 1.91860437e-01f, 1.23110181e-02f, -2.46278923e-02f, 1.46907106e-01f, -3.90782807e-04f, 1.41691566e-01f,
  3.25489491e-01f, 9.27804634e-02f, -2.47835264e-01f, -4.02579084e-03f, 3.48650962e-02f, -4.75146100e-02f, 2.49523968e-02f, -4.59190272e-03f, -2.54333001e-02f, -1.71876494e-02f,
  2.03282088e-02f, -1.10208452e-01f, 1.68569803e-01f, -1.96896687e-01f, -3.95081043e-02f, 5.55465324e-03f, 9.62047093e-03f, 1.41841220e-02f, -1.47440284e-01f, -8.58464614e-02f,
  -1.45529702e-01f, -3.03512253e-02f, 3.62597913e-01f, -9.93519947e-02f, -3.61954749e-01f, -1.67926237e-01f, 8.34909827e-02f, 2.82416850e-01f, 9.35675874e-02f, 8.93298239e-02f,
  6.18856661e-02f, -3.05239558e-02f, -9.47024450e-02f, 1.22140981e-01f, 7.24017918e-02f, 9.42971110e-02f, -1.57363325e-01f, 2.77811587e-01f, -5.53099737e-02f, -3.88187505e-02f,
  3.02605815e-02f, 9.17814597e-02f, 1.41125952e-03f, 6.44504279e-02f, -1.36157021e-01f, -1.71593487e-01f, 1.78489722e-02f, 5.13281822e-02f, -2.84191426e-02f, -1.79461408e-02f,
  3.62269245e-02f, -6.31706268e-02f, -9.04215276e-02f, 5.56364171e-02f, 2.37071048e-02f, 1.71299595e-02f, -1.53275952e-01f, -1.50668070e-01f, -7.64971524e-02f, -1.09508727e-02f,
  -8.58585685e-02f, -6.21942356e-02f, -2.47895289e-02f, 4.30122837e-02f, -1.02913931e-01f, 1.68084607e-01f, 3.84290457e-01f, -3.47749703e-02f, 1.93455890e-02f, -6.61854595e-02f,
  2.45824289e-02f, 1.46587551e-01f, 3.00014503e-02f, -2.30330139e-01f, -6.60455227e-02f, 1.10799074e-01f, -1.29861742e-01f, 2.63404757e-01f, -1.11988178e-02f, 1.80723928e-02f,
  -6.73593879e-02f, -6.77758828e-02f, -1.36773154e-01f, 8.82693455e-02f, 4.92642401e-03f, 1.04820304e-01f, 1.93040505e-01f, -2.96139736e-02f, 3.27815324e-01f, -1.08103037e-01f,
  2.20066190e-01f, -1.51682004e-01f, -1.29158303e-01f, -2.17024535e-01f, 6.40365556e-02f, 1.09558314e-01f, 3.74822840e-02f, 9.20893326e-02f, 1.09416783e-01f, -1.09255657e-01f,
  7.03569800e-02f, -3.81789058e-01f, 8.17369744e-02f, -2.64299959e-01f, 2.45139509e-01f, 2.70727947e-02f, 1.51617661e-01f, -3.83718729e-01f, 1.24079816e-01f, 1.39532998e-01f,
  -1.85258295e-02f, -8.42363313e-02f, -5.80027886e-02f, 5.32438532e-02f, -7.52504542e-02f, -2.74823718e-02f, 2.06510015e-02f, -1.47596588e-02f, -1.81163158e-02f, 1.66934058e-02f,
  6.58084676e-02f, 9.78972763e-02f, -2.40335241e-02f, -9.86011028e-02f, 5.44263385e-02f, -1.06643893e-01f, -3.13365087e-02f, 5.73558733e-03f, 2.36683801e-01f, -3.52029093e-02f,
  -1.09724730e-01f, -1.48739386e-02f, 2.33963467e-02f, -7.27726817e-02f, 4.25710008e-02f, -2.40222625e-02f, 1.19678885e-01f, -8.41881633e-02f, -5.50161190e-02f, -6.82265386e-02f,
  8.78691673e-02f, -2.37606987e-01f, -8.42504799e-02f, 8.67476512e-04f, 3.92412208e-02f, -3.43593187e-03f, 8.98834765e-02f, -1.64645642e-01f, 6.03218824e-02f, 1.46890521e-01f,
  3.71414006e-01f, -7.98022188e-03f, -3.71352255e-01f, -5.52539574e-03f, -2.88623907e-02f, 3.35001260e-01f, -3.31894197e-02f, -1.19686946e-01f, 4.56303954e-02f, -1.54887304e-01f,
  7.69737959e-02f, 1.82246283e-01f, 1.25672087e-01f, 1.61154345e-01f, -1.37407154e-01f, -2.45820242e-03f, -1.01357698e-02f, -4.37885411e-02f, 1.47996932e-01f, -1.63920522e-01f,
  4.62919325e-02f, 3.91323596e-01f, -9.19818506e-02f, -1.93212107e-02f, -4.84351106e-02f, 9.52321440e-02f, 1.92852635e-02f, 1.15834415e-01f, -3.79796773e-02f, 1.53031980e-03f,
  1.17051132e-01f, -7.45189339e-02f, -7.32593611e-03f, -1.04353994e-01f, -4.98821959e-02f, 9.64805633e-02f, 3.58580658e-03f, 6.52866289e-02f, -1.35695264e-01f, -6.25059083e-02f,
  7.68712759e-02f, -5.23480773e-02f, 2.31955871e-01f, 1.16296597e-01f, -2.37687454e-01f, -2.69277487e-02f, 6.45477474e-02f, 5.31236008e-02f, -1.17230631e-01f, 1.39454871e-01f,
  7.89480358e-02f, 8.02819952e-02f, -1.28643036e-01f, 1.24256328e-01f, 1.18079610e-01f, -5.57172811e-03f, 1.24437816e-01f, -1.62400864e-02f, 1.72781348e-02f, -2.71897819e-02f,
  -1.98810071e-01f, -4.34683561e-02f, -5.27936220e-02f, 1.52548179e-02f, 1.60895422e-01f, -4.56714407e-02f, 7.62556642e-02f, 1.56241044e-01f, 1.15984291e-01f, -1.96727782e-01f,
  -5.71679547e-02f, -1.99074894e-01f, 6.01048544e-02f, -7.41296113e-02f, -2.79732104e-02f, 6.55625984e-02f, 1.09507084e-01f, -8.40183944e-02f, -2.60686845e-01f, -1.49702176e-01f,
  -8.15577582e-02f, -1.34139163e-02f, 7.35984072e-02f, -1.97888955e-01f, -1.65674552e-01f, 7.08700269e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.85426414e-01f, 1.34150699e-01f, 2.10826829e-01f, 7.08574131e-02f, 1.48295507e-01f, 1.22957803e-01f, 1.27535522e-01f, 1.29307270e-01f, 9.45558548e-02f, 9.53719094e-02f,
  3.92182842e-02f, 1.76759269e-02f, 2.27385238e-01f, 1.71439387e-02f, 2.67322451e-01f, 2.12453473e-02f, -5.60151115e-02f, 4.94096652e-02f, -8.82934872e-03f, 1.53024167e-01f,
  1.43467724e-01f, 1.15067519e-01f, -4.76595312e-02f, 5.24744652e-02f, 4.04238775e-02f, -1.31604160e-04f, -8.86740163e-03f, 9.31447297e-02f, 1.89372882e-01f, -1.16611838e-01f,
  -1.84753045e-01f, 1.95905268e-02f, 2.25432575e-01f, -7.51840100e-02f, 1.25391409e-01f, 1.48239449e-01f, 1.92852914e-01f, 4.75511653e-03f, -7.37913419e-03f, 5.07617928e-02f,
  1.88255653e-01f, -2.38002330e-01f, 1.78210124e-01f, -9.60388258e-02f, -1.97701957e-02f, 2.04582259e-01f, 1.42453775e-01f, 1.75173104e-01f, 1.79139420e-01f, -1.87437862e-01f,
  -2.69617647e-01f, -1.05289347e-01f, -1.27207220e-01f, 1.53404593e-01f, 2.03382194e-01f, 6.53567389e-02f, 1.56750754e-02f, 1.84110790e-01f, -1.95897534e-01f, 8.97483677e-02f,
  1.51268303e-01f, 2.13743925e-01f, -1.46507397e-02f, -3.90214860e-01f, 1.11881383e-01f, 5.67298383e-02f, -3.17875780e-02f, 2.14299947e-01f, 8.38669576e-03f, -1.90027375e-02f,
  -1.47218987e-01f, 1.84165512e-03f, 3.22408751e-02f, -2.87833866e-02f, -1.36455014e-01f, 1.48173034e-01f, -1.81029573e-01f, -4.33037318e-02f, 1.91307396e-01f, 5.39609045e-02f,
  9.26389620e-02f, 7.78956860e-02f, -7.22999498e-02f, 8.77122208e-03f, 2.45507080e-02f, 1.20973785e-03f, 1.14176527e-01f, 2.23219302e-02f, -1.12608671e-01f, -2.57684868e-02f,
  1.31023839e-01f, 7.14223236e-02f, 8.22822675e-02f, -5.71859330e-02f, 2.65366919e-02f, 1.70313776e-01f, -2.78593916e-02f, 1.45205379e-01f, -2.30433904e-02f, 1.49910366e-02f,
  -4.70411703e-02f, 1.55361518e-01f, 1.11588098e-01f, 2.39102781e-01f, -1.09796241e-01f, 1.29087448e-01f, -1.57625750e-01f, -2.57574797e-01f, 8.21745619e-02f, -8.93256813e-02f,
  1.38993412e-01f, -9.02177207e-03f, 2.29741946e-01f, 9.85299498e-02f, -1.47987783e-01f, 8.29577073e-02f, -3.25429827e-01f, 1.15413733e-01f, -2.79162169e-01f, -8.37507471e-02f,
  3.05479616e-01f, 4.02907319e-02f, 1.00110710e-01f, -1.52113125e-01f, 3.12637120e-01f, 4.69846278e-01f, 9.56019089e-02f, -1.40791550e-01f, 1.03761414e-02f, 2.59518493e-02f,
  -1.27524033e-01f, -7.11823627e-03f, -6.75398903e-03f, 4.05350737e-02f, 8.31689611e-02f, 2.48774905e-02f, 4.19540852e-02f, 4.57785800e-02f, -4.85968105e-02f, 1.76707447e-01f,
  -4.17856835e-02f, 1.10612623e-01f, -1.56415820e-01f, 5.36251925e-02f, 7.51129463e-02f, 1.33710489e-01f, 1.01835221e-01f, -1.75889283e-02f, -3.81304711e-01f, -5.04405163e-02f,
  2.38393813e-01f, -1.38933826e-02f, 1.32230103e-01f, 2.23205775e-01f, -2.01929808e-01f, -3.90581116e-02f, -2.34205365e-01f, 1.45575330e-01f, 1.06066152e-01f, 4.85978052e-02f,
  -2.18334243e-01f, 3.17972541e-01f, -5.48609048e-02f, -1.25195593e-01f, -2.84433495e-02f, -8.89916196e-02f, -1.09179042e-01f, -1.06424063e-01f, 1.34342104e-01f, -3.33385140e-01f,
  -3.61064702e-01f, -2.56698132e-02f, 4.00862247e-01f, 8.80138576e-02f, -1.40899837e-01f, -3.08844358e-01f, 1.12156132e-02f, 6.69682324e-02f, 3.06412905e-01f, 1.91622078e-01f,
  -1.58466861e-01f, -1.66928127e-01f, -1.25818074e-01f, -1.11128971e-01f, 6.93026260e-02f, 2.70521462e-01f, -1.22927036e-02f, 3.80883634e-01f, -2.07842007e-01f, -4.39263545e-02f,
  -7.72601664e-02f, -3.42262417e-01f, 3.02963629e-02f, 1.84993476e-01f, 1.88166082e-01f, 8.32668245e-02f, 2.29494765e-01f, 9.73033160e-02f, 4.86889854e-02f, 1.43451840e-01f,
  -2.26349197e-03f, 5.79452189e-03f, 1.21301591e-01f, 1.34468198e-01f, 2.11261526e-01f, 7.33882785e-02f, 2.14894891e-01f, -1.55034550e-02f, 8.57439488e-02f, 5.40608801e-02f,
  8.68570730e-02f, -9.70783085e-02f, 2.45233148e-01f, 1.32622674e-01f, 2.87531931e-02f, -2.47493967e-01f, -1.90593287e-01f, 9.60073713e-03f, 9.27346125e-02f, 2.10400879e-01f,
  2.13622794e-01f, 5.01855835e-02f, -9.68254283e-02f, 2.17735916e-01f, 2.85030514e-01f, -3.53752613e-01f, 7.71846026e-02f, 7.58236423e-02f, -1.85231343e-02f, -5.61970612e-03f,
  -1.87727347e-01f, 1.08649787e-02f, -1.63536862e-01f, 2.44752660e-01f, -3.24427150e-02f, -7.20458163e-04f, -5.17267361e-02f, -1.74670994e-01f, 7.94437379e-02f, -1.66083369e-02f,
  -2.26600781e-01f, 3.78125817e-01f, 3.69112730e-01f, 6.49328157e-02f, 1.25054404e-01f, -5.69379106e-02f, 3.65076959e-01f, 3.53713259e-02f, 2.51321811e-02f, -3.83849680e-01f,
  -1.03578828e-01f, -1.18858144e-01f, -8.44885632e-02f, -2.94142663e-01f, -1.38638288e-01f, 4.70504850e-01f, -3.26447412e-02f, -4.30815816e-02f, 2.63004273e-01f, 1.27792895e-01f,
  -8.06342810e-02f, 6.91721812e-02f, 2.96589106e-01f, 2.46256460e-02f, 1.22049600e-01f, 3.97515260e-02f, 1.46115750e-01f, 9.76381004e-02f, 5.21772467e-02f, 1.59463257e-01f,
  -1.57830104e-01f, -1.26196947e-02f, 1.35368451e-01f, 3.79409976e-02f, -3.75554711e-03f, -8.04542601e-02f, -2.47756913e-01f, -2.49950334e-01f, -4.80208769e-02f, -2.71955822e-02f,
  3.67784016e-02f, -1.66115668e-02f, -1.04064234e-01f, -1.92654431e-01f, -2.54307827e-03f, 1.96046740e-01f, 1.33166999e-01f, -3.15491110e-01f, -2.75829136e-01f, 4.08125460e-01f,
  5.45379482e-02f, 1.21535629e-01f, -1.18104771e-01f, -1.37938693e-01f, 4.74158190e-02f, 7.41441399e-02f, 4.11399864e-02f, -1.21031798e-01f, -2.13374779e-01f, 3.49101461e-02f,
  3.72892380e-01f, 1.04233898e-01f, -1.89052269e-01f, -1.79544494e-01f, 5.06839693e-01f, -1.72816649e-01f, -1.28588220e-02f, -1.07036708e-02f, 1.58871040e-01f, -3.51495415e-01f,
  -3.97798061e-01f, -1.65808231e-01f, -3.22354212e-02f, 2.58948445e-01f, 7.27075711e-02f, -3.69071141e-02f, -1.68070242e-01f, 3.70978236e-01f, -1.80077419e-01f, -2.99438477e-01f,
  -5.98493591e-03f, 1.81019545e-01f, -5.57925887e-02f, 4.10712399e-02f, 7.50012398e-02f, 1.13810167e-01f, 6.02798983e-02f, 1.36899397e-01f, 2.67492998e-02f, -7.32397139e-02f,
  3.89656313e-02f, 1.36472052e-02f, 5.34820966e-02f, 1.54541492e-01f, -1.62511602e-01f, 4.17339355e-02f, 1.27261966e-01f, 1.03178404e-01f, 2.45783567e-01f, 7.31511414e-02f,
  1.24966770e-01f, -1.04893647e-01f, -2.24409238e-01f, -8.39399025e-02f, 6.47208318e-02f, -1.15453415e-01f, -1.24803223e-01f, -2.62351692e-01f, 5.30898646e-02f, -2.45920918e-03f,
  5.30929863e-02f, 5.40601881e-03f, 1.61987945e-01f, 8.33305269e-02f, -8.28158334e-02f, 1.15513228e-01f, 9.90181579e-04f, -6.05733469e-02f, 8.33947677e-03f, -1.79570854e-01f,
  -7.15781823e-02f, -5.93563821e-03f, -1.28645331e-01f, 2.64286995e-01f, -9.33387596e-03f, -2.20524117e-01f, 8.95898032e-04f, -2.50268448e-02f, 1.31864920e-01f, 2.13039935e-01f,
  3.04870099e-01f, -3.03890686e-02f, 2.42149547e-01f, 7.34048635e-02f, -8.28195438e-02f, 2.98506111e-01f, -2.43867338e-01f, 2.54890263e-01f, -6.77355230e-02f, 2.06855565e-01f,
  -2.90959686e-01f, 1.07555404e-01f, -7.00684190e-02f, 2.44090661e-01f, 1.58204243e-01f, 1.35514140e-01f, 1.90132216e-01f, 1.92066222e-01f, -1.92479808e-02f, -7.74187297e-02f,
  -8.90009291e-03f, -2.04964597e-02f, -5.89371985e-03f, 9.65454504e-02f, -1.81477552e-03f, 8.82330313e-02f, 1.53587729e-01f, -7.88872764e-02f, 2.49148548e-01f, 1.28510386e-01f,
  1.77355073e-02f, -5.47727235e-02f, -1.86419976e-03f, 4.58057299e-02f, -1.30342722e-01f, 9.34007317e-02f, 3.16785932e-01f, 1.11756675e-01f, -1.10483970e-02f, -5.84053509e-02f,
  1.98018849e-01f, -6.53636605e-02f, 8.21918324e-02f, 3.97162177e-02f, 1.14141658e-01f, -5.30468225e-02f, -6.25235960e-02f, -1.44686133e-01f, -5.52233867e-02f, 9.76252705e-02f,
  2.36229878e-03f, 2.19291613e-01f, 1.16007440e-01f, 2.47854665e-01f, 4.86936606e-03f, 5.01918048e-02f, 2.40891531e-01f, -2.53166944e-01f, -2.21421435e-01f, -2.98085790e-02f,
  3.60481799e-01f, 1.97794691e-01f, -9.63692814e-02f, 1.33103117e-01f, -1.11044832e-01f, 8.26156586e-02f, -1.25509873e-01f, 1.03285827e-01f, 2.89624184e-01f, 1.36198521e-01f,
  1.78833112e-01f, 2.83466112e-02f, 1.74608812e-01f, -6.37133271e-02f, 3.96287739e-02f, 2.39866838e-01f, 4.45845500e-02f, -1.70602232e-01f, 1.88923031e-01f, 2.08487317e-01f,
  -1.04325712e-02f, -7.58322775e-02f, 7.84560218e-02f, 1.14263855e-01f, 1.68353587e-01f, 7.64319524e-02f, 1.47134528e-01f, 1.02549858e-01f, -1.44234091e-01f, 1.52512453e-02f,
  6.54377565e-02f, 2.17486680e-01f, 6.12182878e-02f, 1.67012021e-01f, 7.85043240e-02f, 1.41332209e-01f, 4.26100343e-02f, -4.48844209e-03f, 2.02527702e-01f, -2.18905453e-02f,
  -3.66295338e-01f, 4.63253297e-02f, 1.53523043e-01f, -1.26021728e-01f, 1.50836585e-02f, -1.07237823e-01f, -2.05619439e-01f, -9.01425183e-02f, 2.89461225e-01f, -1.72525391e-01f,
  4.20817696e-02f, -2.98994452e-01f, -1.47276521e-01f, -8.48077089e-02f, 3.72888260e-02f, 1.56484291e-01f, 1.40939429e-01f, -1.74260780e-01f, -1.91945046e-01f, -2.74118811e-01f,
  1.40083089e-01f, 1.01064490e-02f, -2.78881878e-01f, 6.74925819e-02f, 8.45396370e-02f, 4.19261098e-01f, 3.10995209e-04f, 3.04522604e-01f, -9.62325409e-02f, 3.25209089e-02f,
  8.10655765e-03f, -1.38091564e-01f, -5.10245077e-02f, 2.15894133e-01f, 1.07216060e-01f, 3.80295336e-01f, 1.82915777e-01f, 1.56977490e-01f, -2.68820170e-02f, 6.57328824e-03f,
  1.11806870e-01f, 2.80900419e-01f, -4.47204486e-02f, -1.04411155e-01f, 3.34080279e-01f, 6.14416748e-02f, 9.37812999e-02f, -3.20654921e-02f, 2.40855992e-01f, 6.87265471e-02f,
  5.79484552e-02f, 1.56040683e-01f, 1.72430381e-01f, 1.76203564e-01f, 7.45975226e-03f, 1.46305785e-01f, -4.51417714e-02f, 6.05462827e-02f, 3.51020228e-03f, 1.61240116e-01f,
  1.30374193e-01f, -1.61946118e-02f, -3.94916475e-01f, -8.56280699e-02f, 2.97252059e-01f, 5.58599867e-02f, -8.65425989e-02f, -4.34424309e-03f, -1.80143937e-02f, -1.24535844e-01f,
  -1.02698784e-02f, 2.30089221e-02f, 2.65159737e-02f, -3.69539782e-02f, -2.77616620e-01f, 2.39337683e-01f, 7.37304389e-02f, 1.45607710e-01f, -1.19493030e-01f, -4.71825432e-03f,
  1.74990728e-01f, 1.20754495e-01f, 7.75455087e-02f, -2.61456639e-01f, -2.04599991e-01f, 1.58098864e-03f, 4.59610909e-01f, 1.69267207e-01f, 2.67430749e-02f, -1.18988425e-01f,
  2.46915966e-01f, -1.30238414e-01f, -1.80998119e-03f, 3.56835760e-02f, -2.29102205e-02f, -3.01650226e-01f, 2.83325184e-02f, -9.51161608e-02f, 2.64891714e-01f, 1.22627445e-01f,
  2.99265772e-01f, -9.69448593e-03f, -8.26090723e-02f, 2.93170482e-01f, -1.87539756e-01f, -1.01405166e-01f, 1.58848405e-01f, 1.00376420e-01f, 1.44974530e-01f, 2.69186664e-02f,
  -2.02641740e-01f, 8.39830860e-02f, 2.18889549e-01f, -5.65944277e-02f, 1.42884746e-01f, 5.28391711e-02f, 1.00501515e-01f, 1.57548741e-01f, -2.13446375e-03f, 3.29140499e-02f,
  -4.78422046e-02f, 1.19733468e-01f, -3.10898293e-04f, 4.85125650e-03f, 1.12132974e-01f, -8.89284238e-02f, -1.44901320e-01f, 1.38796028e-02f, 6.54384270e-02f, 5.58572039e-02f,
  4.09646630e-02f, 5.69920354e-02f, -5.26730828e-02f, 9.03074965e-02f, -2.03474626e-01f, -1.70397013e-01f, -1.50556609e-01f, -2.50839791e-03f, -4.17656563e-02f, -5.89283332e-02f,
  -9.88444462e-02f, 2.55348478e-02f, 3.91732566e-02f, -5.96957654e-02f, 1.69837534e-01f, 3.56147557e-01f, 2.78989166e-01f, 1.17780194e-01f, -2.72612810e-01f, 8.29222798e-02f,
  3.17679197e-01f, 4.49572772e-01f, -1.27683822e-02f, 3.94603387e-02f, -6.98007196e-02f, 7.94698969e-02f, -1.80265740e-01f, 4.21617001e-01f, -1.15769379e-01f, 1.79613069e-01f,
  1.61391526e-01f, -1.76817283e-01f, 1.73709437e-01f, -3.80606800e-01f, 1.03097394e-01f, 1.01546803e-02f, -3.21923673e-01f, -2.61001915e-01f, 2.02894974e-02f, -2.01486826e-01f,
  1.29066929e-01f, 1.05010308e-01f, -6.10520653e-02f, 1.97315663e-01f, 1.16367720e-01f, 1.01642415e-01f, 1.76403180e-01f, 9.76796523e-02f, 1.79685712e-01f, -4.02496494e-02f,
  6.90959841e-02f, 7.58166006e-03f, 8.74879286e-02f, -9.93021391e-03f, 7.35655576e-02f, 1.34232223e-01f, 6.92203194e-02f, 4.19489965e-02f, 1.32031187e-01f, -6.33784533e-02f,
  -1.52762875e-01f, 2.53750780e-03f, 2.54748136e-01f, -1.12471562e-02f, 6.14200011e-02f, 1.01146683e-01f, 7.27927610e-02f, 4.73113395e-02f, 1.21210732e-01f, -1.24473944e-01f,
  -1.33706063e-01f, -1.24998227e-01f, -6.70060515e-02f, 1.36463363e-02f, 1.64387282e-02f, 1.25269726e-01f, -1.21935941e-01f, 3.07868887e-02f, -6.75163057e-04f, -5.65482304e-03f,
  -8.87646228e-02f, -1.38547570e-01f, 2.19676837e-01f, -1.04830503e-01f, 2.32937351e-01f, -1.02674924e-01f, 9.90271568e-02f, 3.88458148e-02f, 4.90932703e-01f, -2.78545767e-02f,
  9.44868401e-02f, -7.68515691e-02f, 1.31727234e-01f, -1.02901593e-01f, 5.54110110e-02f, -1.15178429e-01f, 1.79570429e-02f, 8.59697163e-02f, 1.26434371e-01f, -1.65604144e-01f,
  3.76143903e-01f, 4.45954174e-01f, 6.49766549e-02f, -4.88271534e-01f, 1.27270250e-02f, 2.09562242e-01f, 1.39804155e-01f, 1.80487394e-01f, 9.29879248e-02f, -4.62407954e-02f,
  -5.76155260e-02f, -6.71506003e-02f, 1.32455364e-01f, 1.04162700e-01f, 1.25360176e-01f, 6.04312159e-02f, 2.99340010e-01f, -2.66995654e-02f, 2.30830252e-01f, 4.06716689e-02f,
  3.21134590e-02f, -1.08206831e-01f, -6.30077720e-02f, -1.42701253e-01f, 1.44643605e-01f, 1.01895034e-01f, 2.79522568e-01f, 7.88264647e-02f, 1.18780546e-01f, -9.92911831e-02f,
  1.45533100e-01f, 5.57686761e-02f, 7.56736919e-02f, -1.15829811e-01f, 2.40047928e-04f, -4.51253057e-02f, -1.39274746e-01f, -5.20957373e-02f, 6.26035209e-04f, 6.34028018e-02f,
  -4.81289737e-02f, 5.52904010e-02f, -3.86918522e-03f, -5.90717345e-02f, -7.52291903e-02f, 3.77287902e-02f, 4.03709710e-01f, 2.25272596e-01f, -8.82206410e-02f, 1.36897013e-01f,
  2.60996222e-01f, 3.41254711e-01f, 9.38970298e-02f, 1.10844925e-01f, 2.79901307e-02f, 8.69899243e-02f, 2.26107001e-01f, -1.49048612e-01f, 2.53120840e-01f, 1.34655423e-02f,
  1.08169891e-01f, -8.63983482e-02f, -1.33811817e-01f, 3.55543979e-02f, 1.39103755e-01f, 2.27170706e-01f, 1.15206875e-02f, -1.46515379e-02f, 9.89690945e-02f, -4.21493053e-02f,
  9.99678224e-02f, 7.01902732e-02f, 3.64217237e-02f, 2.82460637e-02f, 4.04161438e-02f, -6.08286113e-02f, 8.27423409e-02f, 6.99594319e-02f, -2.46051587e-02f, 1.12868011e-01f,
  6.48231432e-02f, 6.04108386e-02f, 1.16928034e-01f, 3.12082656e-02f, -2.64578909e-02f, -1.19358644e-01f, 4.07197662e-02f, -1.38120443e-01f, -1.86314732e-01f, -5.86144403e-02f,
  7.11090788e-02f, 1.25567466e-01f, -1.40225559e-01f, -9.31893960e-02f, 1.71791837e-01f, -5.26225567e-02f, -1.08211108e-01f, 1.19565912e-01f, 3.24276626e-01f, -1.11383639e-01f,
  -1.22360229e-01f, 3.90739813e-02f, -2.11600542e-01f, 4.53375839e-02f, 5.34808971e-02f, 8.58669654e-02f, 3.99546534e-01f, 4.55333963e-02f, -3.33744794e-01f, 4.65904828e-03f,
  1.77977338e-01f, 1.45047203e-01f, -2.53340453e-01f, -2.52001673e-01f, -4.24848823e-03f, 3.18585068e-01f, 1.03245124e-01f, 1.59912467e-01f, 9.16720778e-02f, -1.48399845e-01f,
  2.41508931e-01f, -3.81091349e-02f, -3.59489560e-01f, 3.38237464e-01f, 4.26039279e-01f, 1.04512848e-01f, 3.45591933e-01f, 9.48895514e-02f, -5.46435714e-02f, 2.28163287e-01f,
  1.51934981e-01f, 1.71854183e-01f, 1.43384501e-01f, 5.01156524e-02f, 1.38818800e-01f, 4.95783873e-02f, 1.23121955e-01f, 4.74148430e-02f, -4.54279706e-02f, 1.71803206e-01f,
  1.32545471e-01f, 1.38356006e-02f, 9.94872767e-03f, 3.42065506e-02f, 4.54997830e-02f, 9.06266049e-02f, 1.98010311e-01f, -3.22073996e-02f, -1.34834005e-02f, 1.46774232e-01f,
  1.23966277e-01f, -1.82806745e-01f, -2.72142410e-01f, -1.07276499e-01f, 3.33086163e-01f, -1.73438415e-01f, -1.12495668e-01f, 1.37761295e-01f, -4.02176343e-02f, 9.13875625e-02f,
  1.13615379e-01f, 9.47244540e-02f, -9.58514884e-02f, 1.58835769e-01f, -4.42369580e-02f, -4.21330892e-02f, -4.13452238e-02f, 3.49105746e-02f, -1.86617717e-01f, -1.43009990e-01f,
  -2.09023103e-01f, 2.37931073e-01f, -3.38751939e-03f, 6.39261007e-02f, -4.34825838e-01f, -2.85611421e-01f, 7.86099434e-02f, 1.32425874e-01f, -1.00998916e-01f, -3.42002571e-01f,
  1.35413716e-02f, 1.89094260e-01f, 2.77473569e-01f, 3.18793327e-01f, -2.04795673e-02f, -1.04318811e-02f, 3.39705616e-01f, 1.06594376e-01f, 5.12969792e-02f, -9.52869952e-02f,
  1.42081633e-01f, 1.43015563e-01f, -1.71281859e-01f, -2.73860902e-01f, -2.35269159e-01f, 2.98675925e-01f, -1.46059124e-02f, 1.01189800e-01f, -5.39225638e-02f, 4.16637436e-02f,
  4.29030247e-02f, -5.40524870e-02f, 2.06956461e-01f, 5.27926497e-02f, 1.94741637e-02f, 4.12743911e-02f, 6.92083836e-02f, 1.55608043e-01f, 7.96627253e-02f, 1.07246391e-01f,
  3.44011560e-02f, -2.68682651e-02f, 1.16644554e-01f, 1.06703378e-01f, -7.23120570e-02f, -8.42007995e-02f, -6.06293306e-02f, -9.08799917e-02f, 5.31779885e-01f, -6.37635663e-02f,
  6.65620714e-02f, 1.54131174e-01f, -1.47468418e-01f, 5.35298325e-02f, -7.32044578e-02f, -3.65846306e-02f, -1.53070837e-01f, -7.10523203e-02f, 9.78160203e-02f, 1.64789200e-01f,
  -3.89709957e-02f, 6.41443804e-02f, -6.96172789e-02f, -1.18055783e-01f, -4.51119721e-01f, 4.27613175e-03f, 7.41022527e-02f, 3.40505876e-02f, -1.46877959e-01f, 3.42202932e-02f,
  2.15423018e-01f, 2.44755164e-01f, 3.27074416e-02f, -1.86735719e-01f, -4.94564623e-02f, 7.60848746e-02f, 3.77304465e-01f, 2.43725672e-01f, 3.95737886e-02f, -1.41886547e-01f,
  3.21298271e-01f, 1.54994358e-03f, -1.78969011e-01f, 1.85000241e-01f, -9.45973992e-02f, 3.06732208e-01f, -1.70240968e-01f, -3.64879489e-01f, -2.96315044e-01f, -6.98694885e-02f,
  4.52960916e-02f, 1.89895138e-01f, -2.47737803e-02f, -3.30783017e-02f, 1.28543526e-01f, -1.96873117e-02f, -1.03454895e-01f, 1.56341150e-01f, 8.14964697e-02f, 1.11194871e-01f,
  -6.40431652e-03f, 7.05427006e-02f, 4.13899124e-02f, 7.86772892e-02f, -1.66131482e-01f, 1.36768473e-02f, 1.88782349e-01f, 1.41008887e-02f, -1.37204751e-02f, -7.15408102e-02f,
  -7.69885704e-02f, -9.08914581e-02f, -3.66149127e-01f, -1.79470614e-01f, -1.51399581e-03f, -3.65935296e-01f, 2.62882382e-01f, -5.87046929e-02f, 4.74060476e-02f, -2.25092709e-01f,
  3.40721726e-01f, -4.07998934e-02f, -2.04994872e-01f, -2.26413891e-01f, -2.57165790e-01f, -1.19793862e-01f, 1.23998500e-01f, 1.41046792e-01f, 1.48410633e-01f, -6.11167401e-02f,
  -3.12252134e-01f, 2.76334099e-02f, -1.19948402e-01f, 7.83407614e-02f, 1.42217427e-02f, -1.31016672e-01f, 1.69324949e-01f, 3.45981359e-01f, -6.86698854e-02f, 4.37142521e-01f,
  1.03957176e-01f, -2.88349926e-01f, 3.94001827e-02f, -1.04387067e-01f, -1.64734498e-01f, 2.47448519e-01f, 1.66264415e-01f, 3.99889313e-02f, 1.20309316e-01f, -8.25018510e-02f,
  -1.31871849e-02f, 1.82248294e-01f, -6.93576410e-02f, 4.96667802e-01f, -1.09484695e-01f, 7.95484558e-02f, 3.16442386e-03f, 2.24129081e-01f, 2.42466882e-01f, 5.13537452e-02f,
  5.88684417e-02f, 6.57277480e-02f, 1.33095339e-01f, -5.94746470e-02f, 1.27823740e-01f, 3.19836847e-02f, 1.80701569e-01f, 1.59566447e-01f, -5.15930057e-02f, 2.19887942e-02f,
  1.59213945e-01f, 1.03789702e-01f, 5.20203598e-02f, -8.89587849e-02f, 1.70754015e-01f, 1.63378268e-01f, 1.48906097e-01f, 9.32530239e-02f, -1.63498539e-02f, -2.08132729e-01f,
  1.80639122e-02f, -2.07864642e-02f, -9.09069367e-03f, -4.08326797e-02f, -5.54717481e-02f, -2.17443006e-03f, 6.30225390e-02f, -7.18989968e-02f, -7.40626678e-02f, 8.40646252e-02f,
  6.20423481e-02f, 1.83424205e-02f, -6.68378547e-02f, -1.49272934e-01f, -2.98844874e-02f, -2.89671049e-02f, 3.74209702e-01f, 2.43991479e-01f, 5.09916991e-02f, 1.54895917e-01f,
  2.90361404e-01f, 1.39555976e-01f, 1.95861965e-01f, 8.58212784e-02f, 1.47471011e-01f, -6.23612143e-02f, 2.65022486e-01f, 4.09428775e-02f, 1.49060532e-01f, 1.08645782e-01f,
  2.06650086e-02f, 7.66945770e-03f, 2.71710251e-02f, -5.91004416e-02f, 1.97868675e-01f, 1.49971753e-01f, -1.26691982e-02f, 1.62807144e-02f, 2.28936464e-01f, 1.85257494e-01f,
  6.71278834e-02f, 3.87400133e-03f, 5.37770092e-02f, 2.90098280e-01f, -9.88351833e-03f, 1.95362285e-01f, -3.04296482e-02f, 5.11312783e-02f, 1.14557240e-02f, 1.97119489e-01f,
  -1.72627628e-01f, 6.02005534e-02f, 2.34750076e-03f, 1.31265655e-01f, 5.13235899e-03f, 2.48341337e-01f, 1.52922824e-01f, -5.08630238e-02f, 8.43577161e-02f, 2.46287528e-02f,
  -5.35832703e-01f, 1.02659431e-03f, -1.54490694e-02f, 1.52186155e-01f, -2.13524118e-01f, -5.11792861e-02f, -1.61796838e-01f, -4.19474617e-02f, 2.08887905e-01f, -1.56398769e-02f,
  1.00692928e-01f, -8.83196741e-02f, 1.79989070e-01f, 3.96981873e-02f, 1.22740127e-01f, 5.54321846e-03f, 6.06405176e-02f, -2.13299006e-01f, 1.29158109e-01f, -1.28701925e-01f,
  -1.55821115e-01f, 1.44734710e-01f, -3.72561634e-01f, 9.22520235e-02f, -3.06050807e-01f, 2.33656302e-01f, -4.66342449e-01f, -2.63379276e-01f, -7.25359544e-02f, -5.14642000e-02f,
  -9.67727825e-02f, 1.39867086e-02f, -3.71917129e-01f, 2.65115499e-01f, -1.16036780e-01f, 1.38058648e-01f, 2.18625307e-01f, 1.95669666e-01f, -1.82652250e-01f, -3.56429666e-01f,
  2.02481180e-01f, 2.81814247e-01f, 6.54948428e-02f, 8.97378251e-02f, 4.04203571e-02f, 1.33927483e-02f, 1.23272642e-01f, 1.96581408e-01f, 1.99464530e-01f, 8.80852193e-02f,
  6.62155077e-02f, 2.76397675e-01f, 7.46644586e-02f, 1.15549818e-01f, -1.99386254e-02f, 1.20061092e-01f, 2.47266591e-01f, 7.94778392e-02f, -3.13407332e-02f, 1.44212529e-01f,
  1.94515899e-01f, 1.85452104e-01f, 4.99204099e-01f, 1.27316669e-01f, -2.90192664e-01f, 1.03020638e-01f, 6.94432110e-02f, 1.94098458e-01f, -8.66533443e-02f, 5.86957037e-02f,
  4.00581583e-03f, -2.03520685e-01f, 2.38438658e-02f, 1.60875991e-01f, 1.83860332e-01f, 4.30049449e-02f, 2.54831254e-01f, -1.82409346e-01f, 5.95989339e-02f, 1.25884667e-01f,
  -2.79928632e-02f, -1.34700030e-01f, 1.81700498e-01f, -9.23635513e-02f, 1.96728021e-01f, -5.26889376e-02f, 1.64354503e-01f, -1.34698212e-01f, 2.35411912e-01f, 1.78271830e-02f,
  1.49296612e-01f, -1.55343398e-01f, -2.99538851e-01f, -1.67817235e-01f, -1.08075611e-01f, 5.90825081e-02f, -3.12544972e-01f, -1.85000941e-01f, 1.85432509e-01f, -2.12940335e-01f,
  -2.85248786e-01f, -2.32186079e-01f, 4.72283095e-01f, 6.80011511e-02f, -3.51802669e-02f, -3.26027036e-01f, 8.76574591e-02f, 4.07567583e-02f, 1.56267196e-01f, 5.91579359e-03f,
  1.34412289e-01f, 1.56694606e-01f, 1.22893579e-01f, -7.03930929e-02f, 2.61759281e-01f, 2.11006641e-01f, 7.41280392e-02f, 1.25304714e-01f, 2.06662510e-02f, 1.09903120e-01f,
  1.94696903e-01f, 3.81072871e-02f, 3.52000743e-02f, 1.96063057e-01f, 1.69034034e-01f, -1.10792778e-01f, -1.09447010e-01f, -2.60374658e-02f, 1.70205116e-01f, 1.03205219e-01f,
  9.08837840e-02f, 2.16521956e-02f, -5.57779409e-02f, 4.76567261e-02f, -1.08779415e-01f, -8.53952672e-03f, -5.44737466e-02f, -5.47665218e-03f, 1.57969892e-01f, -1.19064234e-01f,
  -1.22686751e-01f, 7.97687173e-02f, 1.71691239e-01f, 5.66232167e-02f, 1.09385520e-01f, 2.34020144e-01f, 4.26145457e-02f, -3.18973303e-01f, -7.38117471e-02f, 1.75297290e-01f,
  1.42863123e-02f, 2.60874152e-01f, -1.67777240e-01f, 1.63801685e-01f, 1.91928800e-02f, 1.04672998e-01f, -4.93953750e-02f, 2.50316441e-01f, 3.26537378e-02f, 5.25247166e-03f,
  3.12508941e-01f, -1.19370986e-02f, 8.89893621e-02f, 9.16847363e-02f, -6.14568107e-02f, 4.15870547e-01f, -2.28129864e-01f, -2.00961888e-01f, -2.47004405e-02f, -5.34236848e-01f,
  8.01059678e-02f, 1.54663637e-01f, 8.20603296e-02f, 2.51328260e-01f, 8.09677988e-02f, 2.05703661e-01f, 1.65714175e-01f, 8.70270729e-02f, 7.64014944e-02f, 1.16215818e-01f,
  2.24369839e-01f, -2.17267964e-03f, 2.18069836e-01f, 1.68636218e-01f, 1.87306404e-01f, 1.21437490e-01f, -2.89705005e-02f, 5.39576337e-02f, 6.52229264e-02f, 2.97996812e-02f,
  1.26672104e-01f, 1.16620861e-01f, 9.26529765e-02f, 1.01136118e-01f, 5.98014742e-02f, -4.68481220e-02f, 8.76963362e-02f, 3.88231850e-03f, 1.87693059e-01f, -1.00342296e-01f,
  -2.25405708e-01f, -2.95891222e-02f, 7.61657879e-02f, -2.45731175e-01f, 2.31884141e-02f, 1.26543388e-01f, 9.52579379e-02f, 6.67065978e-02f, -6.61039129e-02f, 6.81039095e-02f,
  -2.48574257e-01f, -7.82994088e-03f, 4.42574561e-01f, 1.80654526e-01f, -3.54908556e-02f, -1.69794828e-01f, 3.96866977e-01f, 2.41931736e-01f, 3.02293658e-01f, 7.03564379e-03f,
  -1.12607524e-01f, 5.46850264e-02f, 6.30171970e-02f, -1.19533338e-01f, 2.63568580e-01f, 5.78146204e-02f, -8.24457183e-02f, -6.84721172e-02f, -1.67002082e-01f, 1.36005685e-01f,
  3.53791535e-01f, 8.66433159e-02f, -1.84183851e-01f, -3.94176692e-02f, 1.95925876e-01f, 1.11617044e-01f, -6.10660091e-02f, 2.86706716e-01f, 4.62178513e-02f, 2.59074830e-02f,
  -6.41630217e-02f, 2.04870209e-01f, 2.52446271e-02f, -6.98638037e-02f, -1.60598457e-02f, 7.42609575e-02f, 1.50386468e-01f, 5.07553481e-02f, -1.23732192e-02f, 7.20263496e-02f,
  4.16448154e-02f, -4.23876941e-02f, -7.42197111e-02f, 2.95025241e-02f, 3.05054516e-01f, -1.61924735e-02f, 6.07682802e-02f, -3.14477384e-02f, -5.25726378e-02f, 8.98075104e-02f,
  -1.35713667e-01f, 5.50450869e-02f, 6.26948476e-02f, -1.16726512e-03f, -1.59467280e-01f, 1.09276332e-01f, 5.75839840e-02f, -3.21818925e-02f, 1.00309454e-01f, 4.77709994e-02f,
  -2.86532551e-01f, -1.54410273e-01f, -2.36933380e-01f, -1.57602593e-01f, -7.33470991e-02f, 2.04356611e-01f, 2.82659680e-01f, -1.23908497e-01f, 3.82467061e-02f, -7.45620579e-02f,
  1.84356451e-01f, -3.26433659e-01f, 1.09581985e-01f, -6.30014995e-03f, 1.47244185e-01f, -2.45270789e-01f, -6.27264520e-03f, 1.44818857e-01f, 9.39932885e-04f, -2.89454103e-01f,
  -3.86613369e-01f, -2.48971969e-01f, -3.07864755e-01f, -2.15424716e-01f, 1.81175902e-01f, 5.52610643e-02f, -4.33095656e-02f, 2.25174725e-01f, 6.48260787e-02f, -3.81605104e-02f,
  1.31087229e-01f, 5.84416278e-02f, -1.43284230e-02f, 1.33706052e-02f, -3.42050157e-02f, -2.31753271e-02f, -5.72908893e-02f, 1.19122937e-01f, -1.39663657e-02f, -9.55751538e-02f,
  3.23869623e-02f, 8.85066688e-02f, -3.75516824e-02f, 6.73746392e-02f, -3.38943535e-03f, -9.75888595e-02f, 9.58875641e-02f, -8.10385272e-02f, -1.40593359e-02f, -8.44885595e-03f,
  4.85070385e-02f, -9.00103478e-04f, -1.06894888e-01f, -2.25936100e-01f, 1.91135243e-01f, 3.76007296e-02f, -7.14221820e-02f, 2.23370991e-03f, 2.88168609e-01f, -7.09984079e-02f,
  8.37744866e-03f, -1.07823022e-01f, -1.34880081e-01f, -1.26360087e-02f, 1.03874296e-01f, 1.23518415e-01f, 2.54113853e-01f, -2.78306548e-02f, 1.00667678e-01f, -6.90176636e-02f,
  2.75338143e-01f, 3.08955014e-02f, -3.12382489e-01f, -1.23587355e-01f, -4.79766764e-02f, 4.13118720e-01f, -3.54501933e-01f, -1.59113750e-01f, -1.90450847e-01f, -2.20531389e-01f,
  1.71100684e-02f, 3.45308185e-02f, -1.98745325e-01f, 1.43275648e-01f, 3.13094348e-01f, 1.03347868e-01f, 3.85629654e-01f, 4.59652878e-02f, 9.87426043e-02f, 1.94293588e-01f,
  1.55241802e-01f, 4.40956466e-02f, 1.50342822e-01f, 1.44275352e-01f, 2.11140841e-01f, 6.26525804e-02f, 1.97616175e-01f, 2.13301927e-01f, -1.20811954e-01f, 2.09655717e-01f,
  3.15717831e-02f, 7.68677145e-02f, 2.78989822e-01f, 4.32316028e-02f, 1.97332367e-01f, 1.73273370e-01f, 3.01916987e-01f, 2.18468010e-01f, 4.89318743e-02f, -9.74062309e-02f,
  1.86140873e-02f, -2.79454514e-02f, 1.76553465e-02f, 9.66648199e-03f, -2.18315333e-01f, -7.74287432e-03f, -2.24043235e-01f, -2.06338838e-01f, 2.01854765e-01f, 9.87654477e-02f,
  1.40419245e-01f, 7.38154203e-02f, 1.40213937e-01f, 1.25972465e-01f, 2.32936904e-01f, -2.46701419e-01f, 1.76803849e-03f, 1.09493136e-01f, 7.27561861e-02f, 6.78665121e-04f,
  1.59415737e-01f, 1.72986463e-01f, -2.09105015e-01f, 1.59434795e-01f, 1.64571449e-01f, -2.89981607e-02f, -3.55000168e-01f, 1.47933364e-01f, 2.41345227e-01f, -3.09832692e-02f,
  -9.45977047e-02f, 3.99699628e-01f, 1.95614204e-01f, 2.86021270e-02f, 1.06337972e-01f, -8.36386159e-02f, 3.22634459e-01f, 2.84686834e-01f, 4.61758077e-02f, 1.58566952e-01f,
  1.55319601e-01f, 1.04630589e-01f, -9.25532728e-02f, -3.87005270e-01f, -2.09832758e-01f, 5.69876552e-01f, 1.58072740e-01f, 9.38929468e-02f, 1.23065405e-01f, 7.66433552e-02f,
  1.00085258e-01f, 1.31586105e-01f, -1.92196090e-02f, 1.30673610e-02f, 1.02485657e-01f, 1.16625823e-01f, 8.73560160e-02f, 1.42149255e-01f, 3.45917940e-02f, 1.66640386e-01f,
  2.45072663e-01f, 1.51098475e-01f, -3.07949483e-02f, 5.53195029e-02f, 6.79125264e-02f, 3.43070435e-03f, -7.29725808e-02f, -9.74328294e-02f, 1.05012149e-01f, 1.44153144e-02f,
  -1.03089467e-01f, -7.26438835e-02f, 1.65436253e-01f, -8.58991072e-02f, 9.88956317e-02f, 1.55670151e-01f, 8.62060040e-02f, -1.26912192e-01f, 4.04508747e-02f, 1.74472313e-02f,
  -7.68607482e-02f, 1.15636222e-01f, 3.28383967e-02f, 1.35467917e-01f, 3.02615315e-01f, 1.65222153e-01f, -4.53566939e-01f, 9.72748268e-03f, 2.46937647e-02f, -7.18572363e-02f,
  -1.15733109e-01f, -2.17566922e-01f, 2.38226005e-03f, 1.65316127e-02f, -3.82149033e-02f, -1.32840127e-01f, -1.02067441e-01f, 2.12451458e-01f, -2.39666209e-01f, -1.53340399e-01f,
  -1.20088588e-02f, 2.52584517e-01f, 1.13994382e-01f, 2.57956058e-01f, 4.20564711e-01f, 2.51932293e-01f, -3.11711729e-02f, 2.70832121e-01f, -8.31849466e-04f, 3.25264096e-01f,
  -1.28926724e-01f, 1.00772828e-01f, -1.29314631e-01f, -3.16382782e-03f, -1.11410357e-01f, -7.76735693e-02f, -6.76798448e-02f, -6.26728386e-02f, 4.34406698e-02f, -3.49979033e-03f,
  -6.54563494e-03f, -3.12940851e-02f, 7.99282715e-02f, 1.19744986e-01f, 4.00477387e-02f, -4.51116264e-02f, 1.36137391e-02f, 5.80587648e-02f, 3.49775366e-02f, -7.30845258e-02f,
  2.75696628e-02f, 7.90684819e-02f, 2.14797795e-01f, 9.12987366e-02f, 9.05232877e-03f, -7.82351196e-02f, 1.02113001e-01f, -1.74316391e-01f, -2.31415391e-01f, -1.37270838e-01f,
  2.79412121e-01f, 5.60137592e-02f, 1.68894425e-01f, 2.56793611e-02f, -1.92519873e-01f, -1.95675001e-01f, 1.00541607e-01f, 8.50507841e-02f, -2.70419363e-02f, -9.92810801e-02f,
  1.09605104e-01f, -7.85217360e-02f, 1.23497732e-01f, 3.20304811e-01f, -4.20231931e-02f, 3.51035632e-02f, -1.11048736e-01f, 2.56260216e-01f, 6.89361915e-02f, 3.10174197e-01f,
  8.09174404e-02f, -1.05128691e-01f, 3.14645082e-01f, 6.89370856e-02f, -8.26782882e-02f, 1.94586925e-02f, 2.82679588e-01f, -1.68558024e-02f, -8.11390504e-02f, -1.07952729e-01f,
  1.48678944e-01f, -8.86556655e-02f, 6.51035681e-02f, -9.76440087e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.92006245e-01f, -2.70294398e-02f, 1.26557902e-01f, 2.53806233e-01f, 1.11928724e-01f, 7.68205523e-02f, 1.04870595e-01f, 2.46903792e-01f, 1.97172403e-01f, -3.97527404e-02f,
  8.68886858e-02f, 6.86009824e-02f, 1.11873001e-01f, 1.21663347e-01f, 1.33235231e-01f, 1.25641584e-01f, 2.17260480e-01f, 4.10592146e-02f, 2.56064326e-01f, 7.72525370e-02f,
  2.95486301e-02f, -5.69750443e-02f, 5.59536479e-02f, 2.13053465e-01f, 2.36838385e-01f, 1.09431349e-01f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  6.94330409e-02f, 1.53376549e-01f, -5.68434736e-03f, -2.55496223e-02f, 1.22460593e-02f, -2.92465650e-02f, 4.71589044e-02f, 7.12069273e-02f, 1.46399230e-01f, 2.12855265e-02f,
  2.00978201e-02f, -5.54112308e-02f, 1.37126748e-03f, 3.47271889e-01f, 1.52757972e-01f, -5.40180653e-02f, 2.47268185e-01f, 1.26343608e-01f, -6.17027506e-02f, 4.60583009e-02f,
  -2.06927791e-01f, -4.29435968e-02f, 8.67554620e-02f, 8.00969750e-02f, -4.51469049e-02f, 5.04555330e-02f, 2.54465997e-01f, -9.95169058e-02f, -4.68165352e-04f, 1.91453636e-01f,
  -8.88947919e-02f, -7.02053979e-02f, -2.33772576e-01f, 8.68034139e-02f, -1.94241375e-01f, 9.64817852e-02f, -6.57651247e-03f, 2.57927030e-01f, -3.73066426e-03f, 5.61434440e-02f,
  -1.81693882e-01f, 1.60527408e-01f, -1.87076516e-02f, -1.37709647e-01f, 1.19430281e-01f, -2.04303712e-01f, 4.89083864e-02f, 1.64996922e-01f, -7.10407272e-02f, 6.17099628e-02f,
  1.67775638e-02f, 2.65180439e-01f, 1.40675217e-01f, -2.12322906e-01f, -1.21718757e-01f, 8.20928216e-02f, 1.19981328e-02f, 1.79219380e-04f, 5.43231666e-02f, 1.13379158e-01f,
  3.61167565e-02f, 7.52476677e-02f, 1.02488883e-01f, 3.82207595e-02f, 2.33416080e-01f, 1.81931764e-01f, -1.05297565e-02f, 7.55698979e-02f, -6.08922467e-02f, 2.11006820e-01f,
  1.74243785e-02f, -1.37653828e-01f, 2.93724418e-01f, -1.77360594e-01f, 3.67447436e-02f, -3.63064632e-02f, -1.04333930e-01f, -5.63894548e-02f, -6.44791275e-02f, -4.24363017e-02f,
  1.07151367e-01f, -1.91912174e-01f, -1.31911114e-01f, 7.63987377e-02f, 1.26645267e-01f, -1.00656606e-01f, 2.47561216e-01f, -1.09823272e-01f, -9.55332518e-02f, -1.08351469e-01f,
  5.53182838e-03f, -2.39061534e-01f, 1.72020234e-02f, 1.73305482e-01f, -1.49407893e-01f, -1.59216732e-01f, 1.78815395e-01f, 2.86058277e-01f, -6.35333508e-02f, -2.11805589e-02f,
  -1.81136787e-01f, 6.74729496e-02f, 4.61715981e-02f, 3.05942688e-02f, 1.04725853e-01f, -7.81066641e-02f, 2.80481189e-01f, 9.30565223e-03f, 2.76059061e-02f, 2.69453209e-02f,
  4.64311391e-02f, -9.21306550e-04f, -1.38939405e-02f, -6.28258288e-02f, 5.51066436e-02f, 6.95726834e-03f, 1.95244998e-02f, -6.36189338e-03f, -1.46047026e-01f, 3.31539571e-01f,
  2.42520366e-02f, 2.98313610e-02f, -9.23073292e-02f, -3.91329676e-02f, 3.40593830e-02f, -1.40093774e-01f, -2.82204431e-02f, -4.73646671e-02f, 2.75009781e-01f, -1.24715783e-01f,
  -1.31292388e-01f, -4.06433754e-02f, 1.35187954e-01f, -3.00653502e-02f, 1.78837834e-03f, 1.10188335e-01f, 1.01478631e-02f, -4.69587632e-02f, -1.71374813e-01f, -1.38528019e-01f,
  -7.34129250e-02f, -2.73407064e-02f, -3.45658138e-02f, 1.77790802e-02f, 5.69173023e-02f, 2.70212106e-02f, -2.52378695e-02f, -2.24177420e-01f, 6.43912628e-02f, 6.99505433e-02f,
  -1.99589506e-01f, 1.81044769e-02f, -2.20978394e-01f, -1.23447470e-01f, -1.88619807e-01f, 1.87892005e-01f, 2.85439380e-02f, 1.05851635e-01f, 5.16981855e-02f, 1.52687222e-01f,
  -1.67745084e-01f, -2.43852302e-01f, -2.01272771e-01f, 1.36864841e-01f, 3.65194641e-02f, 4.77477722e-02f, -1.59134626e-01f, 3.00321262e-02f, -4.66568395e-02f, 2.75243014e-01f,
  -1.24915257e-01f, 1.26983181e-01f, -4.16920846e-03f, -2.16104656e-01f, -6.87168613e-02f, 1.63002610e-01f, -2.17827056e-02f, 1.70797810e-01f, 1.53651414e-02f, 2.36906007e-01f,
  -1.20800771e-01f, 1.00703478e-01f, 8.34878609e-02f, -1.72704652e-01f, 1.24159474e-02f, 1.43391907e-01f, -1.22934453e-01f, -6.61349148e-02f, 3.11937984e-02f, -1.11005738e-01f,
  -1.38697222e-01f, 1.28198951e-01f, 8.64703730e-02f, -2.03764513e-02f, 9.75708589e-02f, -2.23951451e-02f, -1.47412807e-01f, -1.39539942e-01f, 1.44907445e-01f, 3.74407358e-02f,
  1.44432068e-01f, 1.07550256e-01f, -1.42448574e-01f, -1.14527158e-01f, 6.25071581e-03f, 1.21097259e-01f, 4.70344350e-02f, -1.03521058e-02f, 4.32241894e-02f, -6.24144971e-02f,
  -1.02484070e-01f, 1.86109439e-01f, -8.36503059e-02f, -2.13271365e-01f, -4.91924724e-03f, 6.70152903e-03f, -3.33807200e-01f, -2.06235684e-02f, 1.50540143e-01f, -7.31835663e-02f,
  4.00248356e-02f, 1.07324496e-01f, -1.47784486e-01f, 4.07470651e-02f, -8.07974860e-03f, 1.36266857e-01f, -2.56832778e-01f, 1.32783920e-01f, -1.51911005e-01f, 1.09453708e-01f,
  -1.12315118e-01f, 1.03353545e-01f, -3.70851234e-02f, 1.03571407e-01f, -1.47859469e-01f, 6.87579066e-02f, 5.45257935e-03f, 3.90026369e-03f, 4.53943759e-03f, -1.31937806e-02f,
  -1.53184459e-01f, -1.24535076e-01f, 3.96787785e-02f, 3.03421170e-01f, 1.04759194e-01f, 1.01671860e-01f, -1.16601095e-01f, -3.03876828e-02f, -1.98687688e-01f, -1.35467589e-01f,
  -1.90859243e-01f, 2.49175578e-01f, 7.70087820e-03f, 9.88128036e-02f, -2.70345211e-02f, -1.21248700e-01f, -1.06354579e-01f, -1.38677418e-01f, 1.58118039e-01f, 6.36412576e-02f,
  7.12933913e-02f, -1.79625042e-02f, 3.12055618e-01f, -1.43720627e-01f, -6.53065508e-03f, -2.65938300e-03f, -1.05450772e-01f, -1.49628907e-01f, -1.64141744e-01f, -1.57313362e-01f,
  -1.07611783e-01f, 1.47433907e-01f, -1.76754937e-01f, -8.69347006e-02f, 2.23304331e-02f, -7.75120184e-02f, -1.69273734e-01f, -2.57014632e-02f, -1.12913050e-01f, -2.17631251e-01f,
  -3.59303467e-02f, -1.59814149e-01f, -1.66448668e-01f, -6.74077868e-02f, 1.82827972e-02f, 1.70910787e-02f, 9.54314470e-02f, -2.92221475e-02f, 2.72035133e-02f, 8.14166293e-02f,
  -4.71082889e-02f, 1.04461059e-01f, 3.60092409e-02f, 7.65617639e-02f, -8.55761096e-02f, -7.25187808e-02f, 1.62517622e-01f, 6.04573227e-02f, -1.67068303e-01f, 1.32829249e-01f,
  -6.25578593e-03f, 1.31490752e-01f, -6.45710379e-02f, -1.98341012e-01f, 6.07439168e-02f, 1.62402503e-02f, -1.21269643e-01f, 1.47489607e-01f, 1.46877706e-01f, 5.12666516e-02f,
  -5.74333109e-02f, -9.59719270e-02f, 2.39511937e-01f, -1.75863504e-01f, 1.17613025e-01f, 3.20665203e-02f, -1.35478139e-01f, -1.21757068e-01f, -1.90210685e-01f, -3.93830016e-02f,
  -1.99525371e-01f, -3.82049126e-03f, 8.69915560e-02f, -9.22538713e-02f, 3.44341807e-02f, 9.61031839e-02f, -2.29295958e-02f, -4.44001630e-02f, -2.77865320e-01f, 9.55478624e-02f,
  1.22387432e-01f, 4.53842105e-03f, -6.66888133e-02f, 9.94005129e-02f, 1.54789969e-01f, 2.21587434e-01f, -9.49818268e-02f, 1.86781958e-01f, -1.76695026e-02f, 3.66976261e-02f,
  1.66541502e-01f, -6.53703734e-02f, -8.94605275e-03f, 4.46729548e-02f, 1.43193662e-01f, 1.71880707e-01f, 1.18012287e-01f, 1.39261587e-02f, -1.64876416e-01f, -5.68529777e-02f,
  -3.41890723e-01f, -2.62674931e-02f, 5.56980968e-02f, -1.06021442e-01f, 2.76745081e-01f, -1.56421196e-02f, -2.88174246e-02f, -3.61909121e-02f, 1.56391069e-01f, -1.13362186e-01f,
  -1.36924386e-01f, 8.71293694e-02f, -3.77731510e-02f, -2.02065676e-01f, 6.82747811e-02f, 1.12185456e-01f, -6.48296177e-02f, -1.63115129e-01f, -7.45810196e-02f, 8.00741836e-02f,
  -6.14415370e-02f, -6.16280735e-02f, -1.05709665e-01f, 2.92989984e-02f, -9.76593196e-02f, 4.20918763e-02f, -5.92563152e-02f, 3.68871428e-02f, -7.55686611e-02f, -2.03894839e-01f,
  9.55115184e-02f, 1.07565932e-01f, 1.43003762e-01f, -1.30363882e-01f, -2.24411935e-01f, 1.07679240e-01f, 1.47541821e-01f, -3.83051187e-02f, 4.90967035e-02f, -2.75896583e-02f,
  8.07710737e-02f, -1.75161690e-01f, -2.12778598e-01f, -1.39423862e-01f, 1.17093148e-02f, -7.59701729e-02f, 1.59185752e-01f, 2.90061504e-01f, 1.03969745e-01f, 1.51906729e-01f,
  5.09634241e-02f, 1.25742361e-01f, -1.53817952e-01f, 4.04512882e-02f, 1.80175044e-02f, 1.23972140e-01f, -1.03265390e-01f, 1.14918172e-01f, -2.19037081e-03f, -2.35333331e-02f,
  2.65944928e-01f, 7.73930252e-02f, -1.35118272e-02f, -2.41464712e-02f, -2.80573703e-02f, 2.13795472e-02f, -2.50411868e-01f, -4.71289493e-02f, 9.98331532e-02f, -5.48445061e-02f,
  5.40654473e-02f, 1.64499313e-01f, -6.44241646e-02f, 2.29345933e-01f, -1.54727757e-01f, 1.10522859e-01f, -1.62620276e-01f, -4.70785946e-02f, 1.81208625e-01f, 1.13485791e-02f,
  -4.66507152e-02f, -2.13971823e-01f, -8.45809951e-02f, 1.39244143e-02f, 2.60697585e-02f, 8.74593947e-03f, -9.65794697e-02f, -1.22283801e-01f, 3.47687937e-02f, -1.76041916e-01f,
  8.22193474e-02f, -1.53393913e-02f, 1.66543022e-01f, 1.26296014e-01f, -1.21262325e-02f, 8.17848593e-02f, 1.04085408e-01f, -1.57520603e-02f, 3.34802747e-01f, -1.58694252e-01f,
  -1.98034972e-01f, -4.29746360e-02f, -1.06737919e-01f, -1.41456097e-01f, 6.17568344e-02f, 3.85106690e-02f, 1.00036755e-01f, 2.14444250e-01f, -1.56704098e-01f, 1.35154836e-02f,
  -3.79460119e-02f, -1.62906542e-01f, -1.66501664e-02f, -8.99253711e-02f, -9.62524675e-03f, -2.16200382e-01f, 4.76544164e-02f, -9.51935798e-02f, -1.53152838e-01f, -1.09557122e-01f,
  2.42969349e-01f, -3.89941074e-02f, -3.51021409e-01f, -5.60435504e-02f, 1.62482224e-02f, -2.32377812e-01f, 2.38359030e-02f, 8.27109069e-02f, -3.10624152e-01f, 1.38247102e-01f,
  1.24984905e-01f, 4.59428914e-02f, -1.90093741e-01f, 1.58931047e-01f, -3.05428118e-01f, 1.07617088e-01f, -2.37077236e-01f, 1.30765483e-01f, 1.48175182e-02f, 1.78549662e-01f,
  9.82667040e-03f, 5.46524003e-02f, -3.85319404e-02f, 2.89063831e-03f, 1.20500751e-01f, 1.24029107e-01f, -2.19450027e-01f, -1.01308174e-01f, 2.12405082e-02f, 9.51278582e-02f,
  -6.84724227e-02f, 2.12420508e-01f, -6.02503419e-02f, 7.36648887e-02f, -1.47561103e-01f, -9.05819535e-02f, -1.76505208e-01f, 8.38424116e-02f, -7.66823301e-03f, 6.61293566e-02f,
  1.07393153e-01f, -7.02919513e-02f, -2.06463739e-01f, 6.29924163e-02f, 1.62778750e-01f, -4.83149011e-03f, 6.37204424e-02f, -9.82026570e-03f, 1.10745013e-01f, 3.60088423e-02f,
  1.30847394e-01f, -5.10877073e-02f, -2.32406855e-01f, -4.32502665e-02f, -1.79507449e-01f, -9.76873040e-02f, -1.25677988e-01f, 7.92422052e-03f, -3.63852549e-03f, -5.14140651e-02f,
  1.07081823e-01f, -2.57111788e-01f, -6.93247989e-02f, 3.65541391e-02f, 9.90865231e-02f, -9.40163285e-02f, -5.25185168e-02f, -2.05705285e-01f, 2.86886245e-01f, -4.24257964e-02f,
  1.77451238e-01f, -9.49137658e-03f, 8.31870884e-02f, -2.78641656e-02f, 1.01920672e-01f, 1.87319770e-01f, 3.05753574e-02f, -1.91521078e-01f, -2.48685986e-01f, -6.44929186e-02f,
  1.50273398e-01f, -6.61445782e-02f, 2.55877793e-01f, 3.87787521e-02f, 1.82016060e-01f, 1.95085242e-01f, -9.82344970e-02f, 6.94768364e-03f, 2.83906795e-02f, -2.79361871e-03f,
  8.07376429e-02f, -4.97882701e-02f, -1.06171824e-01f, 9.65056866e-02f, 1.15206115e-01f, 4.99856994e-02f, 2.26667196e-01f, -2.75612753e-02f, 3.72915082e-02f, -1.43046215e-01f,
  9.48373079e-02f, 5.42591065e-02f, 2.89726295e-02f, -2.01923877e-01f, -4.57085893e-02f, 9.10100490e-02f, -2.54512057e-02f, -1.39848500e-01f, -4.27285321e-02f, -8.43849406e-03f,
  1.82602536e-02f, 1.27235219e-01f, 1.08956240e-01f, 8.59164000e-02f, 6.46536425e-02f, 3.33390720e-02f, -4.00239304e-02f, -6.49937838e-02f, -7.11969808e-02f, 6.76182657e-03f,
  5.29875234e-02f, 2.10418683e-02f, -1.62085578e-01f, 1.40274376e-01f, 2.02440813e-01f, -1.50199339e-01f, 6.49016127e-02f, -8.86788499e-03f, 2.74596307e-02f, -6.88692033e-02f,
  7.05414563e-02f, -1.42006531e-01f, -9.14199278e-02f, -2.24352162e-02f, 3.00849862e-02f, -2.96026189e-02f, 1.32905871e-01f, 5.16749695e-02f, 6.75460547e-02f, 6.59196302e-02f,
  5.90638481e-02f, -1.23640500e-01f, 1.66569814e-01f, 8.65655020e-03f, -1.51669726e-01f, -7.60658532e-02f, 4.44474965e-02f, 2.67602712e-01f, -9.16597471e-02f, 1.44760594e-01f,
  -1.53694704e-01f, 3.12477387e-02f, -4.24842462e-02f, 2.21248232e-02f, -5.83620556e-02f, -4.94250841e-02f, -1.51985660e-02f, 1.06319427e-01f, 1.88076302e-01f, 7.56301209e-02f,
  6.43430501e-02f, -9.00789425e-02f, 1.27510354e-01f, -1.23744264e-01f, -1.46476962e-02f, 1.87382832e-01f, -3.10164746e-02f, 1.14289403e-01f, -9.25877243e-02f, 8.93243477e-02f,
  -5.66441901e-02f, 5.88003993e-02f, 2.01359123e-01f, -8.64517540e-02f, -1.48584768e-01f, -3.92830595e-02f, -8.92698094e-02f, -1.58345476e-01f, 2.35131178e-02f, -2.31392831e-02f,
  7.97770396e-02f, -5.50634079e-02f, -1.40627712e-01f, -9.68405753e-02f, 1.00123860e-01f, 1.00108854e-01f, 1.20926671e-01f, 2.11806633e-02f, 1.74481217e-02f, 6.44115731e-02f,
  1.51687607e-01f, 1.42829672e-01f, 1.12977177e-01f, 3.80529873e-02f, -3.88006866e-02f, -1.48264527e-01f, -1.04534708e-01f, -3.99641953e-02f, 6.90082312e-02f, -4.40429524e-02f,
  1.10358976e-01f, -5.29715903e-02f, 2.59860903e-02f, 3.26422304e-02f, 1.15273312e-01f, 2.95295427e-03f, 1.08954772e-01f, 1.11127257e-01f, 4.36259694e-02f, -1.47110865e-01f,
  -9.44631025e-02f, 1.82776630e-01f, -1.42503440e-01f, 1.82742417e-01f, 1.20922573e-01f, -1.00439690e-01f, -2.35323280e-01f, 1.20408095e-01f, -6.48277625e-02f, -4.40583825e-02f,
  -1.15977585e-01f, -1.09782808e-01f, -2.41488311e-02f, 4.41556498e-02f, 1.67884752e-01f, 1.22538872e-01f, 7.71513134e-02f, 3.90908718e-02f, -2.55185831e-02f, 1.34186462e-01f,
  1.20564163e-01f, -8.98132101e-02f, -1.75558403e-01f, 5.09676896e-02f, -1.92672983e-01f, -3.62958275e-02f, 8.92411247e-02f, 1.05745057e-02f, 1.16805941e-01f, 1.43605009e-01f,
  1.26937151e-01f, 2.66784951e-02f, 5.86699285e-02f, 2.18615420e-02f, 1.94258079e-01f, -2.67768977e-03f, 9.05089229e-02f, -2.78659388e-02f, 3.71435992e-02f, 1.99151471e-01f,
  -2.09292054e-01f, 4.20736745e-02f, 7.73746744e-02f, 1.48033276e-01f, -1.66147903e-01f, 3.15237828e-02f, -1.06885716e-01f, -5.95211098e-03f, 6.32402673e-02f, -1.90773934e-01f,
  -2.06240252e-01f, -7.73329958e-02f, 5.53256236e-02f, 5.35597317e-02f, 7.16092363e-02f, 1.63093567e-01f, 5.66486493e-02f, 2.30601709e-03f, 9.57366377e-02f, 6.42767549e-02f,
  1.14464834e-01f, 1.84434608e-01f, -3.99859957e-02f, -1.27404407e-01f, -1.06010951e-01f, 2.42502376e-01f, -2.05853477e-01f, -1.02839626e-01f, -7.76603967e-02f, 1.73235200e-02f,
  -8.60392377e-02f, -5.92458807e-03f, -2.12154016e-01f, 9.27380323e-02f, -7.04486594e-02f, 3.94908637e-02f, 1.67587921e-01f, 9.86158755e-03f, 3.70233208e-02f, 1.90068092e-02f,
  2.31702819e-01f, 6.59428164e-02f, 1.55090898e-01f, -1.74492374e-01f, -2.38168851e-01f, 1.05643652e-01f, -1.82913095e-01f, -1.69743761e-01f, 7.12716952e-02f, 1.89174190e-02f,
  2.59073842e-02f, -1.39380112e-01f, 1.90321337e-02f, 1.20374575e-01f, 4.13603336e-02f, -1.64863765e-02f, 1.27857760e-01f, -2.34205112e-01f, 9.91988182e-02f, 8.15060437e-02f,
  -2.54308828e-03f, 4.17124368e-02f, -6.41651973e-02f, 5.53244017e-02f, 1.09959599e-02f, 8.43877643e-02f, -6.62127212e-02f, 1.81862433e-02f, 3.68719585e-02f, -2.36434489e-01f,
  -2.95361727e-01f, 1.42502427e-01f, 1.93876147e-01f, 3.80008966e-02f, 1.78540319e-01f, 1.70609266e-01f, -1.03954978e-01f, -7.02831149e-02f, 2.02772960e-01f, -5.82210831e-02f,
  -1.29924774e-01f, 8.92890915e-02f, 1.98729426e-01f, 3.30051780e-02f, 1.47592142e-01f, -1.31445453e-01f, 5.65645620e-02f, 1.67684585e-01f, -1.88890889e-01f, -1.83512598e-01f,
  -1.14942119e-01f, -4.10783291e-02f, 2.02851325e-01f, -7.14395270e-02f, 3.13007087e-02f, 8.20127577e-02f, 9.04996842e-02f, -8.16669464e-02f, 1.90402865e-02f, -4.90125045e-02f,
  -1.76020369e-01f, -1.57019392e-01f, 1.21987179e-01f, -1.02170512e-01f, -9.57565755e-02f, -1.09574094e-01f, 1.01393588e-01f, 1.12228334e-01f, 1.60302773e-01f, -7.44694322e-02f,
  5.33958860e-02f, -1.07848339e-01f, -8.44534785e-02f, -5.11105210e-02f, 2.35094260e-02f, -1.81389078e-02f, 3.91478613e-02f, -1.92576032e-02f, -7.19736703e-03f, 1.33637249e-01f,
  -1.14106558e-01f, -7.73046687e-02f, 3.26731801e-02f, -6.66384026e-02f, 3.75637710e-02f, 9.07376185e-02f, -2.46445555e-03f, 2.60730702e-02f, 1.73775762e-01f, -2.34980024e-02f,
  -2.05350399e-01f, -2.78538793e-01f, 5.74431345e-02f, 1.07733876e-01f, -1.42619640e-01f, 1.49356872e-01f, -6.48226961e-02f, -4.86953035e-02f, 3.05646181e-01f, 1.08298555e-01f,
  3.77606265e-02f, 6.10596361e-03f, -1.78330436e-01f, 1.82907417e-01f, -2.11627364e-01f, 2.95320284e-02f, 7.77537227e-02f, -1.24478884e-01f, -5.46399988e-02f, 7.45718181e-02f,
  -8.86275992e-02f, 1.63512155e-02f, -2.14100793e-01f, 2.40811199e-01f, -1.39781624e-01f, 3.61013715e-03f, 1.78864941e-01f, -7.19666183e-02f, -9.98604000e-02f, 1.17850482e-01f,
  -1.16679817e-01f, 1.21372445e-02f, 1.64109513e-01f, 1.52505234e-01f, -1.06868930e-01f, -1.19573437e-01f, -7.01660439e-02f, -4.02540155e-02f, -2.27343976e-01f, -1.34411812e-01f,
  -5.17930612e-02f, 1.25317603e-01f, 1.22023031e-01f, 1.28108844e-01f, 4.98584174e-02f, 2.42386106e-02f, -4.52165585e-03f, 9.37731341e-02f, 1.64717913e-01f, 1.62713438e-01f,
  -2.20515281e-02f, 5.49854487e-02f, 5.70280924e-02f, -1.78911816e-02f, -2.61272602e-02f, 1.83935568e-01f, -1.87597275e-02f, -8.97761285e-02f, -2.30172407e-02f, -3.67312320e-02f,
  7.26023167e-02f, 8.85724649e-02f, 1.02762543e-02f, -2.44508367e-02f, 4.60938178e-02f, -1.39058039e-01f, -1.32526178e-02f, -2.94696260e-02f, 1.76261410e-01f, 2.18928512e-03f,
  -1.07066929e-01f, -1.51549682e-01f, 2.43791685e-01f, -2.65945494e-02f, 2.05091462e-01f, -4.04699855e-02f, -3.66793163e-02f, -2.15916280e-02f, 1.11987837e-01f, -8.69385898e-02f,
  -8.56449082e-02f, -1.69742212e-01f, 2.66678900e-01f, 4.61479723e-02f, -5.38776182e-02f, -1.88352913e-01f, 5.68023399e-02f, 3.26790512e-02f, 9.25650671e-02f, 2.64593028e-02f,
  -1.20264940e-01f, 1.39221773e-01f, 1.60495508e-02f, -1.00232027e-01f, -8.18574131e-02f, -2.07576901e-01f, -1.03043839e-01f, 1.57060340e-01f, 1.35103762e-01f, 9.89579782e-02f,
  -9.92472190e-03f, 1.26861230e-01f, -7.73811042e-02f, -8.74108151e-02f, -1.31488919e-01f, 1.21844560e-02f, -1.32943213e-01f, 1.37599468e-01f, 1.25914976e-01f, -9.99279320e-02f,
  5.79038523e-02f, -7.06204399e-02f, 8.24776366e-02f, -1.23190895e-01f, -8.32955167e-02f, -8.03884566e-02f, -8.87488127e-02f, -6.82057962e-02f, -1.44826025e-01f, 6.15419745e-02f,
  9.07833204e-02f, -7.75642544e-02f, -1.33229658e-01f, -2.06308380e-01f, -7.85340443e-02f, 1.26938954e-01f, -1.25642493e-01f, 1.96530074e-02f, 1.78428963e-02f, -9.59232077e-02f,
  1.31944358e-01f, -5.51998988e-02f, -3.83258611e-02f, 1.09729789e-01f, -7.32033476e-02f, -4.33843769e-02f, -2.19488796e-02f, 1.26664400e-01f, 1.53671011e-01f, -1.42197162e-01f,
  -5.96621782e-02f, 1.09711923e-01f, 3.48404236e-02f, -4.12933640e-02f, 9.93581116e-02f, 1.25227273e-01f, 1.11124031e-01f, -5.17590623e-03f, 6.92442134e-02f, -1.92606181e-01f,
  -1.47485897e-01f, 2.06533819e-01f, -8.18976387e-02f, 7.91093260e-02f, -1.47676021e-01f, -4.71645519e-02f, -1.28100961e-01f, 1.26917288e-01f, -1.54252931e-01f, 4.81314957e-03f,
  -5.48756048e-02f, -8.80374834e-02f, 2.06472091e-02f, 1.39026716e-01f, 1.11527815e-02f, 1.62888303e-01f, 1.02947749e-01f, -1.37308285e-01f, 3.47238369e-02f, -6.70442358e-02f,
  1.19048148e-01f, -4.59763296e-02f, -1.20278738e-01f, 2.00233206e-01f, -1.85608968e-01f, -1.47976488e-01f, 1.77795142e-01f, -5.44678867e-02f, 2.88645681e-02f, -9.62584242e-02f,
  2.49409065e-01f, -3.85080813e-03f, -2.72585243e-01f, 3.93939726e-02f, -6.99888617e-02f, -9.81394053e-02f, 5.10759465e-02f, -1.07964665e-01f, -7.10923299e-02f, 2.35232990e-02f,
  -1.32211775e-01f, 7.97522813e-02f, -1.72607824e-02f, -9.93559659e-02f, -2.17750520e-02f, -4.85506430e-02f, -3.45567495e-01f, 1.29446104e-01f, -5.12339594e-03f, -9.22727510e-02f,
  -3.01658195e-02f, 1.55161023e-01f, -5.04077040e-02f, -1.47887245e-01f, 1.37482598e-01f, -3.49295586e-02f, -1.70814320e-01f, -2.02354878e-01f, 2.05024630e-02f, -1.06625527e-01f,
  8.31802115e-02f, -2.02213936e-02f, -3.04766506e-01f, -8.76818504e-03f, -2.86367349e-02f, 3.44305634e-02f, -1.66917935e-01f, 3.06671467e-02f, -2.94451881e-02f, 4.16405685e-02f,
  -7.70215392e-02f, -2.82587469e-01f, 1.14532419e-01f, 2.85125896e-02f, 1.24734461e-01f, 1.41871780e-01f, -5.99196972e-03f, 1.81464225e-01f, 1.14302449e-01f, -1.30871413e-02f,
  -1.41313255e-01f, -7.68391043e-02f, -2.86283214e-02f, -1.10995933e-01f, 9.66806337e-02f, 1.07343726e-01f, 1.26113087e-01f, 1.04030341e-01f, 1.92724727e-02f, 3.46678384e-02f,
  6.17050678e-02f, 4.51269334e-05f, -5.32314517e-02f, 1.22884668e-01f, 2.10386934e-03f, -3.45867202e-02f, 5.51627856e-03f, -3.31752095e-03f, 3.83134037e-02f, -1.11470511e-02f,
  -1.16678014e-01f, 6.46393821e-02f, 1.22732311e-01f, -8.18045288e-02f, 2.22874507e-01f, 1.03925087e-01f, 1.17480606e-01f, 8.03624988e-02f, 8.28386098e-02f, 4.55977619e-02f,
  1.79845482e-01f, 1.88468043e-02f, -9.56951678e-02f, 4.76372847e-03f, -5.98337874e-02f, 5.21633215e-02f, 7.22409487e-02f, -2.06093431e-01f, 6.78897798e-02f, 3.87945026e-02f,
  -5.52425422e-02f, 4.60723974e-02f, 1.81838304e-01f, 3.63802612e-02f, 1.79745451e-01f, -9.68232006e-02f, 6.93381997e-03f, 4.89651449e-02f, -1.40659407e-01f, 6.83772787e-02f,
  4.15711254e-02f, 2.35065281e-01f, -1.48020145e-02f, -1.06317133e-01f, -1.50667861e-01f, 1.14699803e-01f, 1.46542758e-01f, 1.68879136e-01f, 1.77249163e-02f, -2.10873947e-01f,
  1.79652777e-02f, -1.53232157e-01f, 1.05890192e-01f, -1.27650648e-01f, -4.95396182e-02f, 5.08580580e-02f, 1.11159965e-01f, 1.39522016e-01f, 9.77678318e-03f, -9.20374990e-02f,
  -8.12250748e-02f, 2.24899203e-01f, 8.35295618e-02f, 2.28196308e-02f, -9.14432332e-02f, -2.43434664e-02f, -1.26925707e-01f, 1.09067515e-01f, -1.57270908e-01f, -6.06909953e-02f,
  1.20298162e-01f, 4.35135588e-02f, 7.41883134e-03f, 8.88672844e-02f, 2.77380086e-03f, -1.67701337e-02f, -2.50020735e-02f, -1.70030400e-01f, 2.68758774e-01f, -1.33850440e-01f,
  -1.99651435e-01f, -1.47630483e-01f, -2.22827438e-02f, -1.64549410e-01f, -8.90228301e-02f, -1.43017069e-01f, 1.16967477e-01f, 9.65657532e-02f, -4.53556590e-02f, 1.42027795e-01f,
  2.29483228e-02f, 2.00750723e-01f, 1.29195750e-01f, -1.60953961e-02f, 7.07896845e-03f, -4.13392372e-02f, -1.26375273e-01f, -1.24033988e-01f, -3.22295159e-01f, -1.20810024e-01f,
  -5.95173165e-02f, 1.56155482e-01f, 2.78118700e-01f, -1.17678948e-01f, 2.50099570e-01f, 5.10508232e-02f, 1.58523664e-01f, -1.19553663e-01f, 2.54713774e-01f, 1.80578515e-01f,
  5.24657965e-02f, -1.38928980e-01f, -6.17884323e-02f, 3.22810523e-02f, 8.97221863e-02f, 1.44613892e-01f, -9.73128825e-02f, 1.98778976e-02f, -1.49198771e-01f, 4.36713509e-02f,
  -9.92474630e-02f, -9.53932628e-02f, 6.11608922e-02f, -9.27337408e-02f, 2.67464984e-02f, -2.14548372e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -1.43680811e-01f, -5.29967658e-02f, 9.12316516e-02f, -1.03114575e-01f, 2.83602417e-01f, 2.67330617e-01f, 1.43778071e-01f, -8.09884518e-02f, -4.58512548e-03f, 2.19188765e-01f,
  3.32279116e-01f, -6.57343166e-03f, -1.13767572e-01f, -1.09931771e-02f, -6.61407635e-02f, 1.20999530e-01f, -2.54789740e-01f, 2.40437984e-01f, 2.25941360e-01f, -4.02562022e-02f,
  -2.39713281e-01f, -3.29538025e-02f, -8.15416873e-02f, 1.44916877e-01f, 3.84243459e-01f, 1.27349958e-01f, 6.17682422e-03f, -4.31621969e-02f, 2.14470461e-01f, -2.66198128e-01f,
  2.55225003e-01f, -2.28036404e-01f, -2.35600948e-01f, 2.05506414e-01f, 1.26581997e-01f, -7.36866593e-02f, -1.59073606e-01f, -2.72237211e-01f, -6.80525042e-03f, -1.45444676e-01f,
  3.75500545e-02f, 1.92174584e-01f, -4.43239547e-02f, 2.05590770e-01f, -3.67678441e-02f, 1.23266935e-01f, -2.02745646e-02f, -2.98672505e-02f, -4.49151173e-02f, -2.18636528e-01f,
  5.07626347e-02f, 2.92491257e-01f, 5.41291796e-02f, 1.16250053e-01f, -1.86968207e-01f, 1.33312628e-01f, -9.59369019e-02f, 1.72422498e-01f, 1.03314512e-03f, -2.50431448e-01f,
  -2.45183110e-01f, 1.36238828e-01f, 2.20664471e-01f, -7.50385895e-02f, -4.54003900e-01f, 6.42631873e-02f, -2.05617085e-01f, 1.51227474e-01f, 3.17013077e-02f, -3.65535915e-01f,
  -6.91743642e-02f, 7.14584142e-02f, -2.24696666e-01f, 1.00770751e-02f, -4.31224257e-02f, 1.00612296e-02f, 4.84958887e-02f, -1.38743579e-01f, 1.58556119e-01f, 3.79385293e-01f,
  -5.21376096e-02f, -1.14514045e-01f, -4.97629808e-04f, -1.92108080e-01f, 1.22192716e-02f, 3.70230705e-01f, -2.87081331e-01f, 1.09419547e-01f, -6.25111610e-02f, 1.53989106e-01f,
  -4.85152472e-03f, 3.06830347e-01f, -2.08893660e-02f, -1.81332767e-01f, 1.32887453e-01f, -1.09050699e-01f, -8.60108286e-02f, -1.47813689e-02f, 9.47629288e-02f, -4.09025662e-02f,
  -3.33975181e-02f, -2.40012541e-01f, 1.26740187e-02f, -1.95251495e-01f, -2.55812675e-01f, 9.84487459e-02f, -2.67933384e-02f, 1.71536580e-01f, 3.00436113e-02f, 2.20147699e-01f,
  1.17421858e-02f, -3.59675102e-02f, 1.50433450e-03f, 2.43169725e-01f, 8.70371610e-02f, -4.32692230e-01f, -2.73293227e-01f, 3.31148833e-01f, 3.28005284e-01f, -2.17777699e-01f,
  -2.63247073e-01f, -5.36716892e-04f, 4.25794981e-02f, 4.19791977e-05f, 6.27887473e-02f, 1.13683909e-01f, -1.05833717e-01f, 1.21846586e-01f, 8.44834559e-03f, -2.64293179e-02f,
  -2.04329863e-01f, 1.55821117e-02f, 1.69295043e-01f, -5.28702177e-02f, -3.00002247e-01f, 1.85799465e-01f, -4.35850844e-02f, 2.70908326e-01f, 2.35834107e-01f, 2.30940044e-01f,
  1.48248032e-01f, 1.38086662e-01f, 3.35255146e-01f, 1.12327337e-01f, 1.87673688e-01f, 1.65038228e-01f, 3.22673708e-01f, -6.76927492e-02f, 1.79603770e-01f, 1.50282174e-01f,
  -4.22601014e-01f, -2.25711372e-02f, 4.23545182e-01f, 2.87624508e-01f, -2.72335410e-01f, 3.42748046e-01f, -2.06489205e-01f, -3.47737193e-01f, 3.30940992e-01f, 2.20560819e-01f,
  1.59036610e-02f, -4.33488458e-01f, 3.39065701e-01f, -8.21806584e-03f, 2.37426430e-01f, -3.23587835e-01f, 2.59782672e-01f, -1.04084797e-01f, -1.04020625e-01f, 2.77371258e-01f,
  -2.10865393e-01f, -1.91961974e-02f, 2.24521607e-01f, 9.52881724e-02f, -5.22280484e-02f, 9.64942276e-02f, 1.22435175e-01f, 1.13280892e-01f, -7.82143176e-02f, 6.64244071e-02f,
  -1.04752868e-01f, -6.90242322e-03f, 1.26193523e-01f, -4.10054862e-01f, -1.39450713e-03f, 2.43464559e-01f, 4.32588041e-01f, -3.60301845e-02f, -1.72783494e-01f, 4.07800451e-02f,
  4.62986007e-02f, 1.13947362e-01f, 1.25331968e-01f, 3.09442550e-01f, -9.28722993e-02f, -2.93264794e-03f, 3.00640166e-01f, 1.52250752e-01f, -3.39019865e-01f, 2.80758906e-02f,
  5.57108894e-02f, 3.01086575e-01f, 2.89701700e-01f, 1.39226496e-01f, 1.13422588e-01f, 2.13279217e-01f, 2.51402617e-01f, 2.25009277e-01f, 3.25956374e-01f, 1.97772801e-01f,
  4.84929606e-02f, 3.04677039e-01f, 1.67782724e-01f, -4.04945016e-02f, 1.06748439e-01f, 1.31609645e-02f, 1.60534889e-01f, 6.15390688e-02f, 4.58613932e-02f, -3.57767157e-02f,
  1.90745797e-02f, -4.40639108e-02f, -3.05066228e-01f, 3.83587554e-02f, 1.46540746e-01f, -3.94924134e-02f, 1.45815149e-01f, -2.65076607e-01f, 2.67142188e-02f, 2.35515133e-01f,
  3.26883674e-01f, -4.31206860e-02f, -3.76107506e-02f, 6.83352947e-02f, -6.84921220e-02f, 1.52010927e-02f, 2.68535227e-01f, 1.90295443e-01f, -4.89461189e-03f, 8.84588435e-02f,
  -4.21865545e-02f, -1.08384877e-01f, 2.76488483e-01f, 8.90014842e-02f, -9.01562050e-02f, -3.09823692e-01f, -1.17863819e-01f, 3.14529270e-01f, -1.78159252e-02f, 4.35011476e-01f,
  -8.05037469e-02f, -2.36277163e-01f, 8.57168734e-02f, 2.23740190e-01f, 1.74441457e-01f, -8.68024230e-02f, 1.99679181e-01f, -1.82122532e-02f, 2.17086319e-02f, 2.70576715e-01f,
  -7.01644924e-03f, -2.76192605e-01f, 1.13254013e-02f, -1.11188982e-02f, 2.61710137e-01f, 1.10493116e-01f, -5.00271767e-02f, -2.86791045e-02f, -1.92555919e-01f, -1.83401167e-01f,
  -1.96090695e-02f, -2.64811888e-02f, 9.37028974e-02f, -6.66112155e-02f, 1.28934667e-01f, 1.60589203e-01f, -1.43418714e-01f, 3.21111500e-01f, -9.72558260e-02f, -1.27658501e-01f,
  1.89061061e-01f, -3.80739160e-02f, -1.16178133e-01f, -2.32959241e-01f, -6.82058260e-02f, 5.75991385e-02f, 6.11196123e-02f, 1.09369189e-01f, 1.93257511e-01f, -7.60772154e-02f,
  -3.10648888e-01f, 5.00820994e-01f, 7.03531830e-03f, 4.56319414e-02f, -2.04843059e-02f, -1.46536291e-01f, 2.40438148e-01f, -3.12878519e-01f, 1.90209359e-01f, 1.53755352e-01f,
  -1.62251070e-01f, -1.20763190e-01f, 2.07794040e-01f, 1.48088872e-01f, 4.96845841e-02f, 1.16067007e-03f, -4.27186906e-01f, -4.94756550e-02f, 1.82512999e-01f, -2.60393620e-01f,
  2.40923613e-01f, -2.90683359e-01f, 3.11511219e-01f, 1.06211588e-01f, -4.93216738e-02f, 8.59665498e-03f, -1.36409864e-01f, -3.96143556e-01f, -2.53658388e-02f, 2.47623771e-01f,
  1.81805752e-02f, 5.54545708e-02f, -5.81192747e-02f, 3.11753210e-02f, -2.91021764e-02f, -2.70101428e-01f, -1.93279739e-02f, 1.65577918e-01f, -6.58104941e-02f, 5.46801388e-02f,
  1.47383571e-01f, 1.00882217e-01f, 1.93702757e-01f, 2.96241939e-01f, 1.92847773e-01f, 2.73871664e-02f, 1.34989828e-01f, 2.38991842e-01f, 1.33742485e-02f, 3.16855609e-01f,
  -2.68440872e-01f, 1.26241683e-03f, -5.65242488e-03f, 1.43297896e-01f, 2.02357005e-02f, 1.34141386e-01f, 1.89865917e-01f, 4.08402421e-02f, -1.67935714e-01f, 1.13043651e-01f,
  -6.34468645e-02f, 1.58039421e-01f, -1.72460988e-01f, -2.04663038e-01f, -1.29411981e-01f, 5.19692563e-02f, 1.52682081e-01f, 6.92778751e-02f, -8.28584880e-02f, 1.85052428e-04f,
  -1.67957455e-01f, 3.49364489e-01f, -1.01853162e-01f, -1.33138180e-01f, 2.28171140e-01f, -1.41604647e-01f, 1.25075325e-01f, 1.93561420e-01f, -8.36683437e-02f, 7.73013681e-02f,
  7.58816674e-02f, 2.77884990e-01f, 7.36960471e-02f, -3.31399709e-01f, 6.75201416e-02f, -2.90346414e-01f, -3.66003364e-01f, 2.22358897e-01f, 7.09100291e-02f, 1.72850147e-01f,
  -5.89887649e-02f, 1.40525445e-01f, 2.01974452e-01f, -2.21157581e-01f, 3.76181602e-01f, 1.10614300e-01f, 2.65078932e-01f, -2.17363425e-02f, -1.42580057e-02f, 6.06496446e-02f,
  2.85816014e-01f, -1.08714260e-01f, 2.87519217e-01f, -6.55832440e-02f, 8.33734572e-02f, -1.44747868e-01f, -3.63639481e-02f, 4.69422340e-01f, 9.69935283e-02f, -3.19569916e-01f,
  1.64184570e-02f, 2.67288089e-01f, 1.29099801e-01f, 2.82741100e-01f, -2.74364036e-02f, -1.42915994e-01f, -1.91533864e-01f, -1.12930067e-01f, 2.20806494e-01f, -7.17972592e-02f,
  5.29755801e-02f, -2.81744272e-01f, 1.64883013e-03f, -4.47657071e-02f, 2.65935659e-01f, -3.52828354e-02f, -3.64776254e-01f, 3.56298745e-01f, -5.63617051e-03f, 3.01486999e-01f,
  5.09126484e-01f, 2.80979395e-01f, 2.47484356e-01f, 8.88284221e-02f, -2.84460858e-02f, -1.06522933e-01f, -2.65745044e-01f, 3.96130867e-02f, 7.51774684e-02f, -1.34360924e-01f,
  -1.74092487e-01f, 1.83942214e-01f, 2.03302070e-01f, -1.62909448e-01f, -4.92628247e-01f, -1.19789600e-01f, -9.05280486e-02f, -3.01080167e-01f, 1.64928250e-02f, -1.62877917e-01f,
  1.06231913e-01f, -2.54933476e-01f, 1.19079866e-01f, 3.13680172e-01f, -1.14528589e-01f, -1.87752649e-01f, -1.78372234e-01f, 1.09475687e-01f, -6.58286661e-02f, 1.80603281e-01f,
  -2.35041566e-02f, 2.22092867e-01f, 9.05441940e-02f, -8.86411294e-02f, -2.06388265e-01f, 2.42726237e-01f, -1.27928138e-01f, -1.99820802e-01f, 1.97954420e-02f, 1.46543831e-01f,
  1.29059181e-01f, 4.66659330e-02f, 8.00049976e-02f, -6.01672269e-02f, 1.62563905e-01f, 1.03622256e-02f, -1.05495676e-01f, -4.42792438e-02f, -9.82007384e-02f, -7.32744187e-02f,
  -3.09223890e-01f, -5.13023473e-02f, -2.64930278e-01f, 2.64630079e-01f, -2.08552857e-03f, 2.84249246e-01f, -3.58116567e-01f, 7.41405636e-02f, -7.22343400e-02f, 6.42284378e-02f,
  -1.77232772e-01f, -2.21910790e-01f, 1.26129523e-01f, 1.27168775e-01f, -1.81488827e-01f, -7.38157798e-03f, -9.69415996e-03f, 2.92194098e-01f, -9.20115113e-02f, -6.77342415e-02f,
  7.22457618e-02f, -2.14028731e-01f, 2.00484470e-01f, 5.50873391e-02f, 7.46756420e-02f, 2.18998361e-02f, 1.97088748e-01f, 2.36358538e-01f, 2.62115508e-01f, -8.48991424e-02f,
  -2.53401875e-01f, -4.41108737e-03f, -6.42336113e-03f, -4.38801497e-02f, -2.44070292e-02f, 3.45534869e-02f, 8.38171616e-02f, -1.21835373e-01f, 1.64634585e-01f, -1.14442542e-01f,
  6.67606965e-02f, -7.82057121e-02f, 2.09202334e-01f, 1.28423750e-01f, 3.00459974e-02f, 1.29225273e-02f, -1.20183535e-01f, 1.48511618e-01f, -1.74268246e-01f, 1.47731930e-01f,
  -1.15462244e-02f, 1.14815883e-01f, -7.48435184e-02f, 1.11509636e-01f, 1.50957219e-02f, -2.46381164e-01f, -2.84273606e-02f, 1.15325578e-01f, 1.31594285e-01f, -1.91190839e-01f,
  -7.13457027e-03f, -3.25082570e-01f, -6.55792886e-03f, -1.46802098e-01f, 1.55622512e-01f, -1.95526570e-01f, -1.27264559e-01f, 1.28146917e-01f, -1.69491440e-01f, 3.31976593e-01f,
  -2.57407904e-01f, 2.82224476e-01f, -3.27166498e-01f, 2.91021407e-01f, 1.61376938e-01f, -4.39956665e-01f, -1.60691381e-01f, -9.26076770e-02f, -3.07199240e-01f, -4.13059682e-01f,
  1.34075537e-01f, 1.85958013e-01f, 7.26763308e-02f, -2.73346573e-01f, 3.64328355e-01f, -1.68343470e-01f, 1.84882760e-01f, -6.97207749e-02f, 3.84591073e-01f, 6.58734739e-02f,
  2.48790711e-01f, 1.54003695e-01f, 9.26276892e-02f, 9.77831855e-02f, -5.20270318e-02f, 2.13611424e-01f, 1.17814563e-01f, 4.28575790e-03f, 1.52064115e-01f, 2.97787078e-02f,
  -4.64187041e-02f, -1.38493136e-01f, -2.10002717e-02f, -1.87140420e-01f, 1.13685869e-01f, -3.83605137e-02f, 4.61573422e-01f, -1.85831547e-01f, -1.40358210e-01f, 1.20098069e-01f,
  6.33246601e-02f, -9.77090970e-02f, -1.13923557e-01f, -1.67879224e-01f, 2.28198588e-01f, -1.24468088e-01f, -1.24598304e-02f, 3.28248106e-02f, 1.04274169e-01f, -4.51126210e-02f,
  -1.86920464e-01f, -9.34290215e-02f, 2.56656501e-02f, -1.14142194e-01f, -2.42293015e-01f, 8.94660503e-02f, -4.15186316e-01f, -2.38663517e-02f, -2.22091123e-01f, -1.00678623e-01f,
  -2.48713959e-02f, 9.18548480e-02f, 1.42558841e-02f, 2.05691922e-02f, 1.98576450e-01f, 2.17676640e-01f, -1.00158617e-01f, 9.87754986e-02f, 1.78910941e-01f, -5.88692240e-02f,
  -4.05320346e-01f, 1.69694930e-01f, -4.01197135e-01f, -1.95508562e-02f, -6.34862706e-02f, 2.65038460e-01f, 4.62280691e-01f, -3.51377666e-01f, 1.32273719e-01f, -1.85658708e-01f,
  -1.62338782e-02f, -4.68168631e-02f, 2.73767501e-01f, 1.55743718e-01f, -5.45947812e-02f, -1.34171382e-01f, 7.92634785e-02f, 1.12172879e-01f, 8.99001136e-02f, -9.85672325e-02f,
  1.36521889e-03f, 6.30604103e-02f, -1.40918046e-01f, 1.54656723e-01f, -3.62600088e-01f, -1.86040819e-01f, -1.88183058e-02f, 1.15609959e-01f, 1.24855205e-01f, 1.00649968e-01f,
  1.49744481e-01f, 2.44242877e-01f, -8.55428278e-02f, 1.60226062e-01f, -2.69719623e-02f, 8.61913338e-02f, -1.12122245e-01f, 7.32944235e-02f, 5.08412607e-02f, 8.93915743e-02f,
  2.46482521e-01f, 7.07783848e-02f, 1.59730747e-01f, 2.50939906e-01f, 2.53550023e-01f, 8.64956006e-02f, 1.95527107e-01f, -2.44303374e-04f, 1.29947970e-02f, 2.19383046e-01f,
  2.02952519e-01f, 2.95079648e-02f, 1.45110548e-01f, 2.29902908e-01f, 1.01424390e-02f, 9.58895534e-02f, 6.29381165e-02f, 2.00487211e-01f, -1.94577381e-01f, 6.57436475e-02f,
  -2.96794891e-01f, 8.74156356e-02f, 1.01707252e-02f, -6.59336895e-02f, 1.99272588e-01f, 1.38048697e-02f, 1.49309456e-01f, 7.04469159e-03f, 1.05968095e-01f, 5.40890358e-03f,
  -3.44213039e-01f, 1.65287554e-02f, 1.71751052e-01f, -1.45932153e-01f, 1.78468227e-01f, 1.91153556e-01f, 2.38979638e-01f, -8.90192762e-02f, 5.18679507e-02f, -8.86515528e-03f,
  2.13308156e-01f, -1.53520163e-02f, -3.86587858e-01f, 4.36585814e-01f, -4.87529859e-02f, 1.70517862e-01f, -1.31560281e-01f, -2.06092112e-02f, -5.46400212e-02f, -8.66053104e-02f,
  2.57053137e-01f, 3.45580578e-01f, 3.34592521e-01f, -2.25728869e-01f, 1.79542646e-01f, -1.91274937e-02f, -2.18661055e-01f, 1.85747027e-01f, 1.44352660e-01f, -2.80841380e-01f,
  -2.51709968e-01f, 1.95865095e-01f, 1.82162151e-01f, 7.85258412e-02f, 6.05473295e-02f, 2.45972238e-02f, -1.18462220e-02f, 8.83661583e-02f, -1.68900583e-02f, -6.55821431e-03f,
  1.50172353e-01f, -8.74499157e-02f, -2.28503142e-02f, 2.10364088e-01f, -3.34180504e-01f, -7.96701461e-02f, -1.81648701e-01f, 6.22558780e-02f, 2.01126873e-01f, 3.47202927e-01f,
  -1.32557318e-01f, 1.38875037e-01f, -1.89589351e-01f, 2.94751108e-01f, -4.81432602e-02f, 1.60420239e-01f, -1.85162604e-01f, -3.85133237e-01f, -3.09223384e-01f, 3.61825228e-01f,
  -3.97099018e-01f, -8.54301825e-02f, -1.91494897e-02f, 6.38591051e-02f, -1.52039202e-02f, -2.01718062e-01f, 1.18825017e-04f, -1.94260925e-01f, 2.20443249e-01f, -4.47305366e-02f,
  3.51383954e-01f, 3.52608472e-01f, 6.84015751e-02f, -1.40409935e-02f, -5.81226218e-03f, 7.22402823e-04f, 8.29283446e-02f, -7.91166127e-02f, -1.09030493e-01f, -1.04736030e-01f,
  -1.95527017e-01f, 3.05741608e-01f, 8.52540284e-02f, -6.44609407e-02f, -3.94192487e-02f, 2.13292554e-01f, 2.21391216e-01f, -4.38737683e-02f, 3.97634178e-01f, 1.01674899e-01f,
  -9.39230085e-04f, -2.70770658e-02f, 1.15785830e-01f, 2.97765046e-01f, -2.97470652e-02f, -1.53497517e-01f, 2.31874332e-01f, 1.26645774e-01f, 1.42566040e-01f, 1.56098172e-01f,
  2.01741233e-01f, -3.55780274e-02f, 2.03226686e-01f, 1.69756278e-01f, 1.56801701e-01f, -5.10140769e-02f, 1.48480058e-01f, 2.13991608e-02f, 2.34021112e-01f, 3.25203016e-02f,
  2.37318516e-01f, -1.86667487e-01f, -1.53350338e-01f, -7.30229244e-02f, -3.80351961e-01f, -6.67695254e-02f, -2.24532485e-01f, 2.44835648e-03f, -1.99401513e-01f, 2.67145813e-01f,
  1.20495148e-01f, -1.71312362e-01f, 2.99300049e-02f, -3.02242506e-02f, 7.58684576e-02f, 2.48611435e-01f, 2.35786036e-01f, 2.44076297e-01f, -2.60169990e-02f, -3.75286937e-02f,
  4.81758751e-02f, -3.00935537e-01f, 5.03569320e-02f, 2.17037901e-01f, 1.75613627e-01f, 7.81937167e-02f, 1.14426896e-01f, -8.48227739e-02f, 1.46948114e-01f, -1.20632865e-01f,
  -3.33379596e-01f, 1.75178319e-01f, -8.79913568e-02f, 2.51246482e-01f, 4.20508087e-01f, 5.52975796e-02f, -7.77303129e-02f, -1.05513275e-01f, 2.52253413e-01f, 1.42129483e-02f,
  1.70918047e-01f, -3.68548222e-02f, -8.10729563e-02f, -8.10972899e-02f, 2.69279233e-03f, 6.37059584e-02f, 1.40446844e-02f, -1.77252889e-01f, -1.16276607e-01f, 2.45257895e-02f,
  -1.46378547e-01f, 5.19249812e-02f, 4.24798131e-02f, 6.21614009e-02f, 1.42565534e-01f, -2.05189124e-01f, 2.24209875e-01f, 2.05900609e-01f, 1.65051967e-01f, 1.43377692e-01f,
  1.07541040e-01f, -1.07995898e-01f, -6.92358939e-03f, 4.16068733e-01f, -9.23035592e-02f, -1.19780295e-01f, -2.97248382e-02f, -1.52145863e-01f, -4.86082107e-01f, 2.63649791e-01f,
  3.23138051e-02f, -5.20647094e-02f, 5.93367442e-02f, 2.23148376e-01f, 8.03225935e-02f, -3.15270931e-01f, 2.15279311e-01f, 9.71500650e-02f, 1.13271862e-01f, -2.13316396e-01f,
  1.58449188e-01f, 9.68611520e-03f, -8.01740810e-02f, 1.53807759e-01f, -2.84587920e-01f, 7.20785707e-02f, 8.19089785e-02f, 3.58813226e-01f, -1.47044107e-01f, 2.66083516e-02f,
  2.25820825e-01f, 4.27615106e-01f, 2.41710767e-02f, -3.23900312e-01f, -2.06475586e-01f, 1.62467018e-01f, 2.64881849e-01f, -2.42834300e-01f, 3.68087828e-01f, -3.40432078e-02f,
  1.16141468e-01f, 1.20472096e-01f, 9.47908983e-02f, -2.99272798e-02f, -3.12802047e-02f, 2.82932907e-01f, 1.76643729e-01f, -9.48865563e-02f, -1.28244475e-01f, 2.16382906e-01f,
  2.76827931e-01f, -1.52648911e-01f, 1.28341064e-01f, -4.63426560e-02f, 1.95169315e-01f, 1.41496792e-01f, -2.60234326e-02f, -1.13448165e-02f, -3.30567323e-02f, 1.64371863e-01f,
  -1.97530448e-01f, -1.61168545e-01f, 1.15332045e-01f, -1.56712279e-01f, 1.68702483e-01f, 3.96037996e-02f, -3.27582598e-01f, -1.25904486e-01f, -4.88265045e-02f, -1.22563139e-01f,
  3.01592350e-01f, 1.16908051e-01f, 1.28383026e-01f, -2.55269319e-01f, 7.82593060e-03f, 1.45387441e-01f, 2.59145647e-01f, -1.41558468e-01f, 1.64237514e-01f, 1.17921360e-01f,
  -2.15499669e-01f, 1.75506130e-01f, -4.07178044e-01f, -2.84240693e-01f, 1.74824044e-01f, -4.76308502e-02f, 5.84420562e-01f, -2.60726303e-01f, 3.17864597e-01f, 1.87272295e-01f,
  -1.08426303e-01f, 1.31059498e-01f, 3.32719594e-01f, -4.92254756e-02f, 1.41424701e-01f, -9.76391584e-02f, 5.11077344e-02f, 2.18243271e-01f, 3.93891096e-01f, -7.57018253e-02f,
  -5.44772223e-02f, -1.96480826e-02f, -7.20042884e-02f, 3.50509614e-01f, -1.02087982e-01f, -3.21164668e-01f, -2.16409117e-01f, -4.85532023e-02f, 2.06252307e-01f, -1.61920786e-02f,
  -1.99691534e-01f, 1.15275960e-02f, 1.12411961e-01f, 1.47525012e-01f, 2.63533652e-01f, 7.38928691e-02f, 2.34153911e-01f, -2.11946025e-01f, 1.15190998e-01f, 1.27263337e-01f,
  1.83266297e-01f, -2.06569076e-01f, 1.43615548e-02f, 2.70681888e-01f, 3.07081528e-02f, 1.46492362e-01f, -2.41663858e-01f, 2.03761414e-01f, 1.16870426e-01f, -1.63736463e-01f,
  -1.41887531e-01f, -6.21108897e-02f, -2.67798483e-01f, 1.87877536e-01f, 3.60197723e-01f, 1.63065583e-01f, 6.72041327e-02f, 1.53490171e-01f, 1.06843151e-01f, -2.52939731e-01f,
  3.94621283e-01f, -1.81129605e-01f, -2.93954372e-01f, 9.36139971e-02f, 1.80258572e-01f, -1.81549191e-01f, 1.24537140e-01f, -2.51372993e-01f, -7.20814690e-02f, 6.22869767e-02f,
  7.44437054e-02f, 2.65362829e-01f, -1.92844659e-01f, 1.49465248e-01f, 1.72675699e-01f, 2.89344549e-01f, -8.81144926e-02f, -2.52247542e-01f, 1.26101807e-01f, 4.29844968e-02f,
  3.56271774e-01f, 6.17855452e-02f, 4.29448597e-02f, 4.38186228e-01f, 2.52583232e-02f, -4.96569611e-02f, -7.15305358e-02f, 8.97652190e-03f, 1.21776089e-01f, 1.47732824e-01f,
  2.53688060e-02f, 3.85385454e-01f, 2.92442352e-01f, 7.73647726e-02f, -1.95270747e-01f, 1.88620716e-01f, 2.37309206e-02f, 2.58827694e-02f, -7.60018751e-02f, 1.63523868e-01f,
  1.89246103e-01f, 3.81652713e-02f, 1.69099253e-02f, 1.71231806e-01f, 4.80541177e-02f, 1.91773742e-01f, 2.22824216e-01f, 1.37751311e-01f, 1.73905000e-01f, 1.63577646e-01f,
  -3.24103311e-02f, 9.83726829e-02f, 9.27489102e-02f, 4.07102346e-01f, 1.84594989e-01f, -2.65173018e-01f, 1.84425652e-01f, 2.12339148e-01f, 2.15263516e-02f, -3.21066886e-01f,
  3.33204389e-01f, -1.59497365e-01f, 2.63481170e-01f, -2.21953496e-01f, -1.74554557e-01f, -2.48915821e-01f, 4.60002750e-01f, 3.26279461e-01f, 2.46687546e-01f, -3.33192021e-01f,
  5.21943271e-01f, 1.80069953e-01f, -4.31780182e-02f, -2.25476488e-01f, -2.57722139e-02f, 1.03010438e-01f, -1.42391339e-01f, 2.31416300e-01f, -7.48108998e-02f, 2.74776518e-01f,
  -1.82876736e-01f, -1.70673300e-02f, -2.70045966e-01f, 4.23939340e-02f, 2.78827399e-01f, 5.03618643e-02f, 3.47535647e-02f, 9.03565437e-02f, 1.10711507e-01f, 6.13927960e-01f,
  -6.35275766e-02f, 2.61859089e-01f, -1.20773464e-01f, -1.44242346e-01f, 2.28819549e-01f, 3.24334145e-01f, 2.79147446e-01f, 6.74190149e-02f, 7.01523796e-02f, -3.78279760e-02f,
  1.86247855e-01f, 8.40471461e-02f, 9.21618789e-02f, 2.68395483e-01f, 7.10370913e-02f, 5.30047826e-02f, -1.52702495e-01f, 1.03845373e-01f, 5.02548367e-02f, 4.44980226e-02f,
  1.59498855e-01f, 4.73712459e-02f, 1.49363339e-01f, 1.10974990e-01f, -1.59875572e-01f, -1.36844069e-02f, 1.89714953e-01f, -8.72429088e-02f, 1.11472756e-01f, -1.43373445e-01f,
  -1.91183373e-01f, 1.19278662e-01f, 1.72185063e-01f, 2.29778707e-01f, -1.80826411e-01f, 1.71682760e-02f, -3.04520935e-01f, 1.59202233e-01f, 1.27212340e-02f, 3.47361602e-02f,
  7.25268126e-02f, -2.04445571e-01f, 9.23917964e-02f, -6.15564585e-02f, 2.23294526e-01f, -2.27895185e-01f, 4.98345084e-02f, 1.70470342e-01f, -3.18766862e-01f, -1.28282279e-01f,
  2.73567140e-01f, -3.93312350e-02f, -3.67449746e-02f, 9.91007686e-02f, 6.75370991e-02f, -3.46411377e-01f, 4.39019322e-01f, 5.41636460e-02f, 1.21011198e-01f, -1.38108984e-01f,
  -2.39217237e-01f, 2.26320267e-01f, 9.70613807e-02f, 1.36834100e-01f, 1.96676731e-01f, -2.85951555e-01f, 2.22805843e-01f, 3.33318897e-02f, 1.32397920e-01f, 1.18344761e-01f,
  6.82085231e-02f, -1.65287852e-01f, -4.93148807e-03f, 7.97757059e-02f, 9.86633897e-02f, -1.25637159e-01f, 6.84737042e-02f, 1.52511269e-01f, 1.91218734e-01f, 1.00246400e-01f,
  1.81420222e-01f, 1.05149142e-01f, 6.28491789e-02f, 9.43260491e-02f, 2.40352452e-01f, -2.78818570e-02f, 2.74850607e-01f, 3.05282712e-01f, 3.08736619e-02f, 1.27733098e-02f,
  2.55335063e-01f, 5.76575361e-02f, 1.97948962e-01f, 3.37596238e-02f, 3.03740889e-01f, -1.70778826e-01f, -5.93903847e-02f, -2.44537801e-01f, -4.58254069e-02f, -2.25741342e-01f,
  1.29808858e-01f, 1.12003796e-02f, -2.11616427e-01f, 1.87890977e-01f, 7.97790885e-02f, -3.05564944e-02f, 1.89164549e-01f, -2.86156982e-01f, 4.61275131e-01f, 1.69237256e-01f,
  1.24044620e-01f, 5.87081201e-02f, -3.57369274e-01f, 1.96058154e-01f, 3.17654520e-01f, 2.22571224e-01f, -9.85579416e-02f, 2.41131887e-01f, 3.71794053e-03f, -3.19761217e-01f,
  1.17929190e-01f, 7.10060224e-02f, 8.76663253e-02f, -2.26638004e-01f, -3.39840591e-01f, 2.23469213e-01f, 1.07963033e-01f, 2.18818262e-01f, 3.49830270e-01f, -2.89218575e-01f,
  1.38087258e-01f, 3.68786417e-02f, -4.57403436e-02f, 3.53252828e-01f, 6.38990775e-02f, -1.57717779e-01f, 4.59814183e-02f, 1.99826345e-01f, -2.48824712e-02f, -1.89222470e-02f,
  -1.09881207e-01f, -1.86057076e-01f, -1.15282342e-01f, 7.22678602e-02f, -6.14214130e-02f, -1.76606283e-01f, -9.92217660e-02f, 7.94744492e-02f, 9.94422585e-02f, -7.07703531e-02f,
  -3.24368700e-02f, 1.68524787e-01f, 7.61415660e-02f, -2.32818455e-01f, -1.24508299e-01f, -2.92735159e-01f, -2.53612995e-01f, -9.36402157e-02f, 2.64858276e-01f, -1.30153388e-01f,
  -8.13572407e-02f, 2.45166510e-01f, 1.15903333e-01f, 5.88750765e-02f, 2.19421834e-02f, 3.11978489e-01f, -3.04224074e-01f, 4.95120473e-02f, -1.19392976e-01f, -2.47695372e-01f,
  -1.44451648e-01f, -6.46614432e-02f, -7.36721158e-01f, -2.62841284e-01f, -2.53371354e-02f, 2.08435401e-01f, 7.47562945e-02f, 2.30883703e-01f, 5.51445723e-01f, 3.26986730e-01f,
  2.06984635e-02f, -5.90725504e-02f, 2.70996720e-01f, 2.17282534e-01f, 1.65442973e-01f, 1.43825626e-02f, 8.71247426e-03f, 7.34408796e-02f, 7.38843456e-02f, 3.00949454e-01f,
  7.63738528e-02f, -2.00542852e-01f, -1.01662286e-01f, -7.39947781e-02f, -1.82105154e-02f, 1.04212172e-01f, -2.36538444e-02f, -1.11433202e-02f, 8.49587843e-02f, 7.22828060e-02f,
  1.35964692e-01f, -1.38758212e-01f, -1.03380956e-01f, 1.36778072e-01f, -7.14204237e-02f, -1.60323977e-01f, -8.53781297e-04f, 2.52962053e-01f, -7.49132782e-02f, 1.76773846e-01f,
  9.43197459e-02f, 1.66109085e-01f, 1.09432586e-01f, 5.23486435e-02f, 8.69896710e-02f, -6.07285798e-02f, 2.72964686e-01f, -7.66119435e-02f, 6.34172037e-02f, 1.77203834e-01f,
  -2.28534460e-01f, -1.52150661e-01f, -3.53119336e-02f, -1.78759582e-02f, 1.01140596e-01f, 1.28183350e-01f, 1.23663366e-01f, 1.27607614e-01f, -6.76324368e-02f, 2.30441928e-01f,
  -1.61657453e-01f, 6.31221160e-02f, 2.44154140e-01f, -3.22178900e-01f, -1.27671793e-01f, -1.39485132e-02f, -1.28777474e-01f, -1.15861379e-01f, -1.29301876e-01f, -3.18877064e-02f,
  1.43205181e-01f, 4.90723811e-02f, 1.48878217e-01f, -1.68390032e-02f, 1.66272700e-01f, -2.40720123e-01f, 3.10491830e-01f, 2.83075392e-01f, 8.65143463e-02f, 2.44994625e-01f,
  -2.24319045e-02f, 1.97271511e-01f, 3.26166332e-01f, -1.39198691e-01f, 1.43834144e-01f, -1.40725717e-01f, -3.36892635e-01f, 8.19231272e-02f, 1.84733868e-02f, 5.19965105e-02f,
  1.33118242e-01f, 4.71519940e-02f, 1.09565161e-01f, 5.97485201e-03f, 4.66680899e-02f, 3.67439806e-01f, 1.91776812e-01f, -2.06328221e-02f, -5.43549955e-02f, 3.65686789e-02f,
  -8.14406723e-02f, 3.53024118e-02f, 1.61101982e-01f, -2.27656424e-01f, 9.80596989e-02f, 9.16448683e-02f, 1.65869191e-01f, 2.64877021e-01f, 1.70163825e-01f, -1.16936848e-01f,
  1.75402924e-01f, 1.68407753e-01f, 6.93614483e-02f, 1.07561328e-01f, 5.72779067e-02f, -8.30001011e-02f, -5.15317032e-03f, 5.37950732e-02f, 8.20174906e-03f, 2.16574475e-01f,
  3.76469135e-01f, -4.21819799e-02f, -3.24378699e-01f, -4.05670926e-02f, -1.34413913e-01f, -6.00930024e-03f, -4.13694650e-01f, 1.99645013e-01f, 2.82296658e-01f, -1.66682750e-01f,
  -5.91499312e-03f, 1.00874923e-01f, 3.04504812e-01f, 3.05308163e-01f, -3.07033956e-01f, -1.25421882e-01f, 2.08551928e-01f, -2.34155118e-01f, 2.21258327e-01f, -1.20220464e-02f,
  1.39575332e-01f, -8.83757025e-02f, 2.35907823e-01f, -9.77818742e-02f, 2.17803977e-02f, -8.06768890e-03f, -2.13318288e-01f, -1.85068518e-01f, 8.80654231e-02f, -2.51212306e-02f,
  1.55918047e-01f, -1.29935145e-01f, 2.78058499e-01f, 1.77596211e-01f, 2.20388696e-01f, -2.34147478e-02f, 2.13209838e-01f, 1.43654747e-02f, 1.25625044e-01f, 5.13192937e-02f,
  -3.98280248e-02f, -9.90449563e-02f, 1.47140101e-01f, 2.12444648e-01f, 6.31769821e-02f, 1.75941080e-01f, 2.37047121e-01f, 2.02989116e-01f, 2.51712382e-01f, 3.58591259e-01f,
  -9.95466411e-02f, -7.45900422e-02f, 6.61614910e-02f, -3.88703272e-02f, 1.69287235e-01f, 6.51121289e-02f, 1.44220755e-01f, 5.39625399e-02f, -1.90547660e-01f, -1.20363094e-01f,
  4.21223432e-01f, -1.06032573e-01f, 1.00347623e-01f, -1.72812827e-02f, -4.60512154e-02f, -2.88983911e-01f, 2.30935305e-01f, 1.68921471e-01f, -5.19831106e-02f, 1.28230333e-01f,
  3.51915747e-01f, 3.95501517e-02f, -3.34375836e-02f, -2.29695544e-01f, -1.70614421e-01f, 5.23781516e-02f, 2.40412146e-01f, -3.76288109e-02f, 4.03351098e-01f, 1.41771793e-01f,
  3.01861376e-01f, 2.32500881e-01f, -4.21510674e-02f, -6.85308576e-02f, 3.80269028e-02f, 3.01201910e-01f, 1.65290684e-01f, 7.80898109e-02f, -2.47959986e-01f, 3.84303927e-01f,
  3.89224589e-01f, -4.80028391e-01f, 4.68910992e-04f, 7.97648355e-02f, 1.27233937e-01f, 4.34742957e-01f, 1.36110708e-01f, -9.59131345e-02f, -2.45355681e-01f, -1.91829931e-02f,
  5.25332093e-02f, 4.29233816e-03f, 1.56434193e-01f, 2.13850588e-01f, 1.70635059e-01f, -1.08719446e-01f, 2.09532335e-01f, 1.35124221e-01f, -8.92302543e-02f, 2.17779472e-01f,
  2.65626647e-02f, 8.10278654e-02f, 2.04913676e-01f, 2.39607841e-01f, 1.65411457e-01f, 2.10960343e-01f, 2.07991362e-01f, 8.56254995e-02f, 1.85136110e-01f, 3.18192273e-01f,
  1.26255721e-01f, -1.36638016e-01f, 2.83408821e-01f, -4.65000123e-02f, -4.03505415e-02f, -2.81689577e-02f, 1.20441288e-01f, 1.40684843e-01f, -1.49813294e-01f, 1.12547718e-01f,
  -3.33706379e-01f, -2.86129057e-01f, 2.15581372e-01f, 1.80348247e-01f, -2.64799893e-01f, -3.04733098e-01f, 1.39305592e-01f, -7.37951696e-02f, 2.70677893e-03f, -4.82509509e-02f,
  4.02246118e-01f, 2.20525041e-01f, -2.13761672e-01f, 1.41053259e-01f, -7.19300359e-02f, -3.23075801e-02f, 8.04621801e-02f, 1.61270663e-01f, 5.38791306e-02f, 9.14610457e-03f,
  1.87393293e-01f, 8.19411501e-02f, -1.60419464e-01f, 7.77317211e-02f, 2.79811081e-02f, 2.32938603e-02f, 1.37443870e-01f, -2.77470291e-01f, 3.80862266e-01f, 5.62098809e-02f,
  4.00431842e-01f, 9.70236436e-02f, -2.35715091e-01f, 1.42870158e-01f, 1.78271495e-02f, -2.47902330e-02f, -8.33029896e-02f, 1.20040789e-01f, 2.15937659e-01f, 2.02426821e-01f,
  -3.90522066e-03f, -2.28900295e-02f, 2.71231085e-01f, 2.57786326e-02f, 9.84029099e-02f, -1.01121524e-02f, 1.38048530e-01f, -8.29760581e-02f, -3.70236172e-04f, 2.77667671e-01f,
  2.01601043e-01f, 1.67826593e-01f, -4.16361168e-02f, 2.43060261e-01f, 2.13157132e-01f, 1.75277099e-01f, -3.93739849e-01f, -1.74241200e-01f, -4.33741659e-02f, -3.55874300e-02f,
  -6.69202060e-02f, -1.30872801e-01f, 2.64260143e-01f, -2.36266792e-01f, 9.21808369e-03f, 1.09810889e-01f, 8.50274935e-02f, 3.84718567e-01f, -2.93350726e-01f, 1.23700000e-01f,
  -4.96100262e-02f, 1.52882352e-01f, 2.27865070e-01f, 3.58119130e-01f, 1.52142659e-01f, -2.65095457e-02f, -2.82106191e-01f, 5.03785253e-01f, -3.53225350e-01f, 2.62509026e-02f,
  -2.36163009e-02f, -1.62568614e-01f, -1.17992043e-01f, -1.96277782e-01f, 1.54331565e-01f, 8.68383497e-02f, -3.14213425e-01f, 4.26506996e-01f, 2.72832662e-01f, -1.50242209e-01f,
  1.32516041e-01f, -4.94225144e-01f, 6.26671538e-02f, -2.71364272e-01f, 2.93268174e-01f, 2.79484898e-01f, -4.33808595e-01f, 5.00307679e-01f, 1.92383118e-02f, -2.12239638e-01f,
  -2.48048708e-01f, 1.42133012e-01f, 8.29388052e-02f, 2.15708017e-01f, 5.32408021e-02f, 1.53653502e-01f, 1.26488119e-01f, 1.63087063e-02f, -3.21848802e-02f, 1.15954980e-01f,
  1.01540342e-01f, 1.08820684e-01f, 3.19713242e-02f, -3.02379448e-02f, 7.44268224e-02f, 5.45550287e-02f, -1.20358624e-01f, -5.29395193e-02f, -3.74985151e-02f, 1.53977185e-01f,
  3.40596680e-03f, -2.53185689e-01f, 9.98643413e-03f, 1.88993827e-01f, 1.36687458e-01f, -1.04455836e-01f, 2.89767474e-01f, 2.37906957e-03f, 1.25004843e-01f, -2.96873581e-02f,
  -1.28494829e-01f, -4.18212891e-01f, 8.58442783e-02f, 2.87779123e-01f, 2.46597931e-01f, -2.58595914e-01f, 1.14984900e-01f, -1.37110859e-01f, -8.30827653e-02f, 5.75800128e-02f,
  2.62887776e-01f, -1.82298854e-01f, 1.50257200e-01f, 2.33792961e-01f, 9.79699939e-02f, 3.54102284e-01f, 4.16715480e-02f, -3.96252424e-01f, -8.82905200e-02f, -9.85850319e-02f,
  3.82642686e-01f, 8.56293216e-02f, -7.25257844e-02f, 3.29096198e-01f, -1.02598339e-01f, 1.21757574e-01f, -2.99305797e-01f, -3.07286400e-02f, -1.48421124e-01f, -2.61741757e-01f,
  2.81590432e-01f, 3.40779692e-01f, 3.41284573e-01f, -2.58205444e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.20193496e-01f, 6.99305385e-02f, 1.21178091e-01f, 2.18016088e-01f, 1.77811787e-01f, -6.15627058e-02f, -2.49517169e-02f, -4.91212681e-02f, 7.64217004e-02f, -6.28182068e-02f,
  1.06586581e-02f, -4.49316064e-03f, 2.32866287e-01f, 8.83303806e-02f, -8.70716176e-04f, 1.90312237e-01f, 1.83091789e-01f, 1.27186656e-01f, 1.69329241e-01f, 8.72028321e-02f,
  1.11753888e-01f, 7.06573352e-02f, 1.12721145e-01f, -3.44045013e-02f, 2.49151811e-02f, 5.46604069e-03f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -3.24690163e-01f, -1.59467474e-01f, 1.53645366e-01f, -1.27032235e-01f, -1.72516674e-01f, 9.50939655e-02f, 8.04718733e-02f, -1.64730027e-01f, 7.40716085e-02f, -3.06426585e-01f,
  -1.75943837e-01f, -2.63529599e-01f, 1.49849104e-02f, -1.31809935e-01f, -3.34755823e-05f, -7.42181838e-02f, 3.04078050e-02f, -3.47045541e-01f, -1.78206220e-01f, -2.09713340e-01f,
  2.32616365e-01f, 1.00686803e-01f, 1.67176008e-01f, 1.73480928e-01f, 5.42047527e-03f, 1.37920886e-01f, 2.77777821e-01f, -2.23263785e-01f, -1.74551234e-01f, 3.05413991e-01f,
  -3.55185941e-02f, 1.01894781e-01f, 1.01651743e-01f, 1.12613589e-01f, 2.48808682e-01f, 1.48328692e-01f, -2.21739158e-01f, -1.64355367e-01f, -1.15247443e-01f, -2.27028683e-01f,
  -3.67129624e-01f, 1.37684837e-01f, -2.80622423e-01f, 1.38595968e-01f, 1.93694293e-01f, 2.35176548e-01f, 1.89996827e-02f, 2.90667862e-01f, 1.32826596e-01f, 2.66575515e-01f,
  1.10837661e-01f, -2.00087324e-01f, 5.46438433e-02f, 5.25023974e-02f, -1.75946310e-01f, -1.37158900e-01f, -4.56956625e-01f, 1.38882503e-01f, 1.17408959e-02f, 5.64518683e-02f,
  -1.26117125e-01f, -2.23103717e-01f, -4.51688051e-01f, -8.61835480e-03f, 2.00999171e-01f, 1.96479455e-01f, 1.21298365e-01f, 1.84975624e-01f, 9.41970646e-02f, -3.31652135e-01f,
  -3.27769518e-01f, -1.33410662e-01f, -2.37044077e-02f, 3.00270796e-01f, 3.27642970e-02f, 1.76716417e-01f, 1.59843992e-02f, -5.28332684e-03f, 7.39857480e-02f, -8.84278268e-02f,
  -1.32892534e-01f, -1.95589721e-01f, -1.38342440e-01f, 2.79309690e-01f, 1.67057857e-01f, 5.85406413e-03f, -6.74109012e-02f, -1.55387804e-01f, -3.02081048e-01f, -1.92743406e-01f,
  3.12521040e-01f, 1.68874189e-01f, -5.38584404e-02f, 7.38611743e-02f, -3.88433278e-01f, -2.58314610e-01f, -2.46260151e-01f, 8.25552456e-03f, -2.28277929e-02f, -3.27565670e-01f,
  -1.16503581e-01f, -6.86481372e-02f, -1.83816671e-01f, 8.76616687e-02f, 1.17378561e-02f, -1.29693463e-01f, 3.71223927e-01f, -4.42307163e-03f, -1.32019401e-01f, -4.23911028e-02f,
  2.71619380e-01f, 2.19203994e-01f, -4.49955434e-01f, 2.06619397e-01f, -8.40457007e-02f, 1.21369392e-01f, 1.96859181e-01f, -5.56977510e-01f, -2.79491663e-01f, -5.53425431e-01f,
  -3.28068882e-01f, 2.32769996e-01f, 2.33331233e-01f, -3.59977901e-01f, 1.25689045e-01f, -1.73619628e-01f, -2.43705988e-01f, -2.37147003e-01f, -6.81414828e-02f, 1.14188887e-01f,
  2.48132180e-02f, -3.05421710e-01f, -1.68013975e-01f, 1.36683822e-01f, 5.88251017e-02f, -1.74484134e-01f, -9.50793624e-02f, 1.33228540e-01f, -2.54554242e-01f, -2.46490762e-01f,
  4.25309688e-02f, -3.26356202e-01f, 1.39984399e-01f, -2.87658602e-01f, -1.87349066e-01f, -1.16406448e-01f, -2.86772847e-01f, -3.43096517e-02f, 3.64831805e-01f, -3.27335179e-01f,
  4.19606268e-02f, -2.49768525e-01f, -3.77962850e-02f, -5.23346290e-03f, -3.05181712e-01f, 3.76196802e-01f, -1.96947560e-01f, -1.31042466e-01f, -3.40367049e-01f, 2.73837388e-01f,
  -1.78427309e-01f, -2.38368362e-01f, -3.39364856e-02f, -4.20889020e-01f, 4.69601750e-01f, 4.39550430e-01f, -3.77294660e-01f, -1.84525594e-01f, -1.07681833e-01f, 9.38409753e-03f,
  -5.10636985e-01f, -5.64384647e-02f, -2.67678052e-01f, 8.55731145e-02f, 2.93888718e-01f, -2.65468866e-01f, -2.56900564e-02f, -3.33366841e-02f, 1.10446159e-02f, -1.86205968e-01f,
  -1.30871385e-01f, -1.74723372e-01f, -3.05989116e-01f, 1.34384274e-01f, 1.99168310e-01f, 3.90593410e-01f, 3.91251892e-02f, 2.45072976e-01f, 1.14356183e-01f, 1.38313606e-01f,
  -2.15036258e-01f, -3.71112496e-01f, 9.08739958e-03f, -1.13125488e-01f, -1.42143399e-01f, -2.64313146e-02f, -1.70626372e-01f, -2.23515138e-01f, 8.24227184e-02f, -1.39417760e-02f,
  1.80400014e-01f, -4.78820782e-03f, -7.29125366e-02f, -5.55459894e-02f, 9.88641828e-02f, 8.42608213e-02f, -1.45565122e-01f, 1.29589751e-01f, -1.75604060e-01f, -4.64106724e-02f,
  7.69244805e-02f, -7.17151910e-02f, 2.35181794e-01f, 1.79530028e-02f, 4.17544186e-01f, -2.62506127e-01f, 7.72109479e-02f, -7.47592896e-02f, 3.56141269e-01f, -8.34530368e-02f,
  1.79921135e-01f, -1.37885422e-01f, -1.64240122e-01f, 7.88181499e-02f, 9.17128921e-02f, 2.64286965e-01f, -6.61307797e-02f, 1.22131690e-01f, -3.04979652e-01f, 1.54136373e-02f,
  1.59035102e-01f, -1.91906005e-01f, -5.66675603e-01f, 4.84864339e-02f, -8.60613137e-02f, -2.35122055e-01f, -4.86258417e-02f, -3.55437785e-01f, -6.33066818e-02f, -7.78813064e-02f,
  2.45961055e-01f, -1.49655625e-01f, 6.13529868e-02f, -6.35180235e-01f, -1.72088608e-01f, 1.72557414e-01f, 2.44937330e-01f, 2.11035326e-01f, 2.39588261e-01f, -2.85297930e-01f,
  -1.32777631e-01f, -1.05636284e-01f, -3.62371683e-01f, -5.18116057e-01f, -3.27788770e-01f, 2.75767982e-01f, 8.15751031e-02f, 2.22611688e-02f, -1.97124735e-01f, -9.09003466e-02f,
  -1.31390721e-01f, -1.93340674e-01f, -2.80321270e-01f, 2.48714864e-01f, -2.72606350e-02f, -2.29644433e-01f, 1.98778720e-03f, -1.33790985e-01f, -2.23296031e-01f, -8.09652880e-02f,
  1.82358876e-01f, -1.28049672e-01f, 2.08194062e-01f, 4.57547992e-01f, 1.97033390e-01f, 1.92058951e-01f, -1.96666524e-01f, -3.63586515e-01f, -4.10408020e-01f, 1.36301890e-01f,
  4.25003797e-01f, 5.06152585e-02f, -3.41561913e-01f, -1.40861392e-01f, -1.99579760e-01f, -3.98851424e-01f, -1.27469853e-01f, 1.22192115e-01f, 2.18922183e-01f, -1.77983537e-01f,
  -3.05228412e-01f, 2.24545538e-01f, 3.13807800e-02f, 2.25068271e-01f, -2.52626985e-01f, 2.00048730e-01f, 1.46520913e-01f, 1.12647735e-01f, -2.92031583e-03f, 1.49410814e-01f,
  1.54271454e-01f, 1.88603371e-01f, -1.42837137e-01f, -2.37034410e-01f, 2.24629685e-01f, 8.13929457e-03f, -9.88652110e-02f, -6.47120997e-02f, -2.84965217e-01f, 4.66427393e-02f,
  1.74261555e-01f, 3.83007387e-03f, -1.42585695e-01f, -1.73980400e-01f, 3.84879634e-02f, 1.38217568e-01f, -2.22136945e-01f, -1.18922040e-01f, -4.15131539e-01f, 6.24051169e-02f,
  -1.79969221e-01f, -4.04145904e-02f, 1.12407081e-01f, 2.66182870e-01f, 1.04943532e-02f, 1.20733984e-01f, 1.34462610e-01f, 2.11216301e-01f, 2.18447268e-01f, 6.96434826e-02f,
  1.20356190e-03f, 2.21949413e-01f, 4.69474383e-02f, 6.27792478e-02f, 2.17803150e-01f, 7.37569928e-02f, 1.13341920e-02f, 4.71593998e-02f, 2.77995318e-01f, -2.31463704e-02f,
  -3.25385779e-01f, 4.09914069e-02f, 2.68567204e-01f, -2.49308676e-01f, 2.14408323e-01f, 1.91883910e-02f, -2.18244363e-02f, -1.39275759e-01f, 6.66079149e-02f, -2.20736444e-01f,
  3.72100919e-01f, 1.00443155e-01f, 2.50541806e-01f, 5.31258918e-02f, -1.17841206e-01f, -9.34717655e-02f, -3.15352082e-01f, 3.39559704e-01f, 2.11439148e-01f, -1.93147272e-01f,
  2.81142294e-01f, 1.64164960e-01f, -2.01586396e-01f, 2.93333977e-01f, 2.69020647e-01f, -1.74305096e-01f, -1.10924356e-01f, -1.52759343e-01f, -1.05415255e-01f, 1.84529066e-01f,
  -2.37251803e-01f, -1.93382725e-01f, -5.39117455e-02f, 1.55807197e-01f, -2.41718799e-01f, -3.29697520e-01f, -5.31750262e-01f, -1.15442611e-02f, 1.53974697e-01f, -6.03047721e-02f,
  8.85521919e-02f, 2.19232082e-01f, 2.56969869e-01f, -3.06174129e-01f, 2.91651711e-02f, 1.86524585e-01f, 1.62426885e-02f, -5.31847551e-02f, -2.03349330e-02f, -1.29972562e-01f,
  -1.01912878e-01f, -1.71461031e-01f, -6.97679594e-02f, 1.05944283e-01f, 9.89975631e-02f, -3.05884834e-02f, -1.19997151e-01f, -2.07710624e-01f, -1.05773173e-01f, 4.85407747e-02f,
  1.04633346e-01f, -1.98712483e-01f, -1.81447774e-01f, 1.96976379e-01f, -2.23749101e-01f, -7.98297375e-02f, -9.26305130e-02f, 2.08707213e-01f, -1.73318714e-01f, 1.70925409e-01f,
  -8.95550698e-02f, 1.73092596e-02f, 1.95625991e-01f, 2.42528096e-01f, 2.97404200e-01f, 2.04227418e-01f, -1.54511198e-01f, -2.59291530e-01f, -2.78837085e-01f, -1.92436799e-01f,
  -9.55735222e-02f, -9.70958620e-02f, -1.63046688e-01f, -1.92257464e-01f, 1.56351994e-03f, -5.91796815e-01f, 1.16986737e-01f, -1.26238883e-01f, 4.94730502e-01f, -1.26230210e-01f,
  -5.79135679e-02f, -1.61647256e-02f, -5.02294719e-01f, -1.46447048e-01f, 6.69799745e-02f, 1.31613553e-01f, -1.82940096e-01f, 3.36889885e-02f, -4.98033047e-01f, 1.03444308e-01f,
  1.60430893e-01f, -2.23302439e-01f, -2.79455632e-01f, 1.99062526e-01f, -1.01605296e-01f, 1.38017491e-01f, 4.39640164e-01f, -4.78039775e-03f, 1.48486003e-01f, -2.77241737e-01f,
  5.97410835e-02f, 5.00216149e-02f, 1.18187428e-01f, -1.46857664e-01f, 4.57625352e-02f, 2.70234436e-01f, -1.23055294e-01f, -1.16601773e-01f, -1.35892257e-01f, -5.68115674e-02f,
  -2.53228787e-02f, 1.15144067e-01f, 2.26389263e-02f, -2.93564260e-01f, -1.56372517e-01f, -3.70286971e-01f, -3.21039930e-02f, -2.55901963e-01f, -9.31022782e-03f, 2.50433356e-01f,
  -2.15774730e-01f, 2.05107376e-01f, -2.52006233e-01f, 2.13007092e-01f, 3.46283391e-02f, 6.44200146e-02f, -5.94648309e-02f, 1.44961730e-01f, 8.72518271e-02f, -1.59545541e-01f,
  2.43250206e-01f, 7.93289840e-02f, 2.06165031e-01f, 3.62435788e-01f, 1.01033822e-01f, -1.79521650e-01f, 7.73781687e-02f, 3.94574553e-01f, 4.67576943e-02f, -5.35333514e-01f,
  -3.17270402e-03f, -3.94325882e-01f, -1.26705691e-01f, -2.68500090e-01f, -4.85976368e-01f, -1.16389096e-01f, 1.22936785e-01f, -1.75746847e-02f, -4.39221084e-01f, 2.05411553e-01f,
  -1.69115499e-01f, 2.88021624e-01f, -5.44949062e-02f, -2.71224856e-01f, 2.38206819e-01f, 2.13632748e-01f, -2.37977490e-01f, -2.35973790e-01f, -2.39844620e-01f, -7.80614167e-02f,
  4.12596427e-02f, 1.75193757e-01f, -2.80412346e-01f, 2.52559811e-01f, 9.20635685e-02f, -3.61731231e-01f, 1.97358236e-01f, 1.69565454e-01f, 7.87434429e-02f, -2.65840352e-01f,
  1.41701713e-01f, -3.84068251e-01f, 5.12816012e-02f, -1.89485084e-02f, -1.59556627e-01f, -1.05951920e-01f, -2.87592411e-01f, 2.09136218e-01f, 2.35958770e-01f, 2.72397488e-01f,
  2.21585054e-02f, 2.23312557e-01f, -2.06087753e-01f, 3.68986279e-01f, 3.43455911e-01f, 4.50001895e-01f, -2.61213183e-01f, 2.88238768e-02f, 2.51775146e-01f, 1.10583618e-01f,
  1.75807044e-01f, 3.21622163e-01f, 3.07818323e-01f, -2.41588056e-01f, 3.50261062e-01f, 3.09341133e-01f, 2.76826948e-01f, 1.04143895e-01f, 3.26245248e-01f, -3.38099509e-01f,
  -4.72706646e-01f, -6.76335990e-02f, -3.50054324e-01f, -3.74097265e-02f, -2.12547049e-01f, 2.67489046e-01f, -4.03189898e-01f, -7.08544701e-02f, -3.17543775e-01f, -1.87700823e-01f,
  -1.96401760e-01f, -4.11127150e-01f, -3.33051622e-01f, -4.92037879e-03f, -3.57665747e-01f, -2.22124770e-01f, 4.28715318e-01f, -1.38105333e-01f, 1.67391405e-01f, 3.18429898e-03f,
  2.12487027e-01f, -1.89290076e-01f, 1.31858334e-01f, -3.89070809e-01f, 4.84684318e-01f, -3.49729091e-01f, 1.56831264e-01f, -2.38554671e-01f, -3.94045413e-02f, 7.22053181e-03f,
  3.15323055e-01f, 1.76021039e-01f, -2.17556227e-02f, -2.51080513e-01f, 2.08345667e-01f, 1.97728217e-01f, 2.38372490e-01f, 2.65022010e-01f, 1.01602517e-01f, 2.66347766e-01f,
  4.61098999e-02f, 4.19827551e-01f, 4.96132560e-02f, 1.56947464e-01f, 3.17126930e-01f, -4.08703804e-01f, -2.42139757e-01f, 4.79323417e-01f, 1.69863150e-01f, -5.45996167e-02f,
  3.98993911e-03f, 2.33190268e-01f, -1.51822820e-01f, -2.19233662e-01f, 5.43599352e-02f, 1.31857106e-02f, -2.11585402e-01f, 1.15563888e-02f, -2.26822466e-01f, -1.50639147e-01f,
  1.49229839e-01f, 5.19536614e-01f, 8.32371637e-02f, 8.06542858e-03f, -2.26125032e-01f, 1.77116871e-01f, 2.08573759e-01f, -3.58997107e-01f, -3.16001564e-01f, -2.47485027e-01f,
  -3.81656349e-01f, 2.80398786e-01f, 2.64965147e-01f, -3.33804816e-01f, -4.41607200e-02f, -6.53604940e-02f, 1.44695058e-01f, 2.37882495e-01f, -6.02242649e-01f, 1.40706927e-01f,
  -4.67718720e-01f, 2.73198873e-01f, 6.12579228e-04f, -1.75805271e-01f, -1.20327078e-01f, -6.24878518e-02f, -5.38491726e-01f, 1.36538789e-01f, -3.60662460e-01f, -7.13485718e-01f,
  9.64852124e-02f, -2.92651225e-02f, -1.83845043e-01f, 1.26538575e-01f, 1.05878055e-01f, 1.39909536e-01f, -2.30606291e-02f, 1.75964415e-01f, -2.76805997e-01f, 2.72537265e-02f,
  9.41347405e-02f, 4.46435362e-02f, -6.34403899e-02f, -5.68851046e-02f, -6.20194152e-02f, 3.72409485e-02f, -9.57044028e-03f, 1.71074167e-01f, -1.09047384e-03f, -6.99683055e-02f,
  1.40560225e-01f, -1.95991203e-01f, -5.51737994e-02f, 2.47815967e-01f, -1.87213365e-02f, -1.98602483e-01f, -1.77435026e-01f, 2.25440621e-01f, 7.64322057e-02f, -1.65639758e-01f,
  1.33483201e-01f, -1.31516248e-01f, -4.04755592e-01f, 7.51099885e-02f, -2.22665936e-01f, 7.61622190e-02f, -5.26311994e-02f, 5.47174178e-02f, 3.52549195e-01f, -2.47603923e-01f,
  -2.45609492e-01f, 7.29838610e-02f, -2.35105619e-01f, -2.17264220e-01f, -1.02812923e-01f, -1.47006392e-01f, -3.68648291e-01f, 1.33557869e-02f, -4.77257431e-01f, -3.38515490e-01f,
  -5.47969520e-01f, -3.33825022e-01f, 3.10850054e-01f, 2.68297642e-01f, 2.46793389e-01f, -2.18500644e-01f, -2.55065858e-01f, -2.61599541e-01f, -6.55371770e-02f, -1.29395604e-01f,
  2.38884270e-01f, -1.67863175e-01f, -1.26636744e-01f, 3.01736474e-01f, 1.39181852e-01f, 1.78706527e-01f, 1.18374042e-01f, -2.52288077e-02f, 7.69942626e-02f, 2.15201959e-01f,
  1.34066209e-01f, 3.08140993e-01f, 2.24105224e-01f, 1.59332976e-02f, -1.19478501e-01f, 1.05440188e-02f, 1.31066591e-01f, 9.46430936e-02f, 2.52389163e-01f, 2.07655415e-01f,
  -2.02249840e-01f, 5.24794720e-02f, 5.01150005e-02f, -3.11034173e-02f, 1.68989122e-01f, -3.44653577e-02f, -3.63790929e-01f, -3.31902832e-01f, 1.72256175e-02f, -3.29818398e-01f,
  -2.27753878e-01f, -1.18901461e-01f, 1.18040815e-01f, 3.10850680e-01f, 2.46713027e-01f, -3.88861299e-01f, -1.58044711e-01f, 4.90253083e-02f, 2.54734635e-01f, -3.12717080e-01f,
  2.92595744e-01f, -3.08963746e-01f, -2.82152355e-01f, -4.86476034e-01f, 9.71697420e-02f, 4.46459323e-01f, -7.51291811e-02f, -3.30856323e-01f, -7.55246878e-02f, -4.32596445e-01f,
  -1.07235201e-01f, -2.63840526e-01f, 4.15119752e-02f, -3.11432391e-01f, 3.94413501e-01f, 8.51248950e-02f, -3.21551204e-01f, -2.07913905e-01f, 2.50018805e-01f, -1.75104171e-01f,
  2.09832042e-01f, -6.15536392e-01f, -4.09860998e-01f, -1.97842196e-01f, 1.97977602e-01f, 1.07210919e-01f, -3.33127767e-01f, -2.98215270e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.25734702e-01f, -1.45794107e-02f, -7.27592334e-02f, -1.62333846e-02f, 7.36310240e-03f, -5.07234000e-02f, 5.07935300e-04f, -5.70812635e-02f, 1.09578133e-01f, -1.12773180e-02f,
  1.04033455e-01f, -1.26040634e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    