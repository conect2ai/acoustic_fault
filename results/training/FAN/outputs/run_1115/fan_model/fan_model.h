/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.17425519e-01f, 2.79181510e-01f, 2.91650176e-01f, -8.05419907e-02f, 2.68782005e-02f, 8.28338116e-02f, 1.91456616e-01f, -1.01947792e-01f, -2.74875369e-02f, 9.59623381e-02f,
  1.10685088e-01f, -3.69089991e-02f, -8.99939984e-02f, -1.55701682e-01f, -5.71450889e-02f, 1.30330354e-01f, -1.70172323e-02f, 2.70967744e-03f, -1.60177097e-01f, -1.41661152e-01f,
  -1.49497256e-01f, -8.89770836e-02f, -3.02816182e-02f, -8.24537277e-02f, 3.41321975e-02f, -8.13947320e-02f, 2.69018143e-01f, 8.91265497e-02f, 1.50070339e-01f, 1.81620568e-01f,
  2.46225700e-01f, 1.32879540e-01f, -2.18826696e-01f, -1.93611726e-01f, 4.32396270e-02f, -1.60214324e-02f, -5.17857522e-02f, -7.47638121e-02f, -2.01414414e-02f, -2.87938062e-02f,
  -9.26882029e-02f, -8.69439095e-02f, -1.22502662e-01f, -3.57603654e-03f, 6.08923919e-02f, -2.82560894e-03f, -1.46290874e-02f, 4.95890267e-02f, 1.03791635e-02f, 6.92468211e-02f,
  -1.05578192e-02f, 1.28710002e-01f, 3.66301723e-02f, -6.69972524e-02f, -1.19182922e-01f, -9.07750651e-02f, 4.08771820e-02f, -8.92207250e-02f, -2.92109977e-02f, 8.96935612e-02f,
  -6.14401028e-02f, 5.78463599e-02f, 7.95698464e-02f, 7.64844716e-02f, -5.23484051e-02f, 1.07177533e-01f, 1.71194389e-03f, 4.60842550e-02f, 6.79136366e-02f, 7.72667825e-02f,
  8.32180977e-02f, 1.02625802e-01f, 6.26010150e-02f, 5.42763621e-02f, 8.35392475e-02f, 1.17927767e-01f, 5.69784939e-02f, 4.02398556e-02f, 5.98231517e-02f, 2.78566144e-02f,
  5.48192002e-02f, 2.58969385e-02f, 6.62100911e-02f, -2.12706085e-02f, 5.48832007e-02f, 9.37115476e-02f, 7.29933307e-02f, -1.26899332e-02f, 1.20259330e-01f, 6.48934096e-02f,
  -2.39351299e-02f, 1.65527239e-02f, -6.62314519e-02f, -1.04237720e-01f, -5.52436598e-02f, -2.21055672e-02f, 6.35791272e-02f, -4.00837995e-02f, -7.47525739e-03f, -1.16594108e-02f,
  -5.80758601e-02f, -2.89563350e-02f, 7.50490353e-02f, -5.26151694e-02f, -1.10175632e-01f, -1.14298403e-01f, -8.55713338e-03f, -1.40169546e-01f, -1.15775235e-01f, -7.59287924e-02f,
  -4.47739735e-02f, -3.76155786e-02f, 5.91520481e-02f, -5.68434075e-02f, -5.33434155e-04f, -7.38057643e-02f, -4.94664013e-02f, -1.28470346e-01f, 1.12842647e-02f, -9.46653914e-03f,
  2.01490998e-01f, -1.11048475e-01f, 1.86260734e-02f, 8.65335315e-02f, 4.19736356e-02f, -2.79185306e-02f, -8.29112977e-02f, -1.42116368e-01f, -1.87622830e-02f, 4.79014367e-02f,
  1.28824726e-01f, 1.32943869e-01f, 1.08007416e-01f, 2.91290060e-02f, 1.30212888e-01f, 2.86251213e-03f, -9.21550617e-02f, 1.10606253e-01f, 1.94894359e-01f, -8.01015347e-02f,
  -1.97885893e-02f, 1.49113219e-02f, 6.01659268e-02f, -1.08222999e-01f, -9.22261998e-02f, 4.51125950e-02f, -5.17016053e-02f, -9.51281637e-02f, -1.27348900e-01f, -1.31736800e-01f,
  5.76844551e-02f, 5.94551954e-03f, 1.41665235e-01f, 2.14468271e-01f, 1.57438695e-01f, -5.32091632e-02f, 1.20604075e-02f, 6.02803342e-02f, 1.74259618e-02f, -1.81701258e-02f,
  3.46378349e-02f, 5.98244742e-02f, 6.81386143e-02f, 1.30185768e-01f, 4.98602800e-02f, 1.57287434e-01f, 9.23384726e-02f, 5.17854504e-02f, 5.02324775e-02f, -1.28605636e-02f,
  -1.79860145e-02f, 1.30529106e-01f, 1.72454819e-01f, 6.95394874e-02f, 8.10940191e-02f, 1.91222683e-01f, 1.95369851e-02f, 1.04190512e-02f, -9.95656475e-04f, 2.20866501e-02f,
  -9.51668844e-02f, 5.52021712e-02f, -2.29759421e-03f, -2.99584325e-02f, 2.42582038e-02f, 4.81268279e-02f, -7.40381482e-04f, 1.49106234e-02f, 6.20763414e-02f, -5.61556108e-02f,
  -1.43071562e-02f, 4.03476954e-02f, 6.70720488e-02f, -3.41700688e-02f, -6.81491047e-02f, 6.72478527e-02f, -2.90794410e-02f, -2.99260151e-02f, -2.91178599e-02f, 1.73746999e-02f,
  2.70858873e-02f, 5.21101244e-02f, -2.27696989e-02f, -1.05320491e-01f, -3.98692526e-02f, 3.44262831e-02f, 2.45303530e-02f, 2.10652500e-02f, 3.25816683e-02f, 3.39506217e-03f,
  6.97031021e-02f, 2.01705188e-01f, 5.85044026e-02f, -3.86560075e-02f, 6.53778911e-02f, 3.67676876e-02f, 2.90174335e-02f, -6.73395023e-03f, 9.81864035e-02f, -6.96705356e-02f,
  -6.76654046e-03f, 2.53350735e-02f, 1.13454744e-01f, 1.32915042e-02f, 2.25476120e-02f, 9.00625810e-02f, 8.74556676e-02f, 9.29620937e-02f, 8.35294425e-02f, 1.07941739e-01f,
  1.09760977e-01f, 1.47637114e-01f, 2.10987806e-01f, 1.02317177e-01f, 3.84735353e-02f, 2.55888999e-01f, 1.09352149e-01f, 7.25151747e-02f, 1.61634594e-01f, -1.35679049e-02f,
  1.82206705e-01f, -1.64025977e-01f, 3.03174168e-01f, -2.49052092e-01f, -2.19844297e-01f, 6.64811432e-02f, -3.12785730e-02f, 6.65864944e-02f, -1.55050203e-01f, -1.22931279e-01f,
  -2.49579757e-01f, -1.25872508e-01f, -1.75597798e-02f, 6.96363673e-02f, 2.25172177e-01f, 1.92165732e-01f, 2.75730908e-01f, 3.49042356e-01f, 2.79274136e-01f, 1.02155739e-02f,
  -2.31472284e-01f, -1.13493256e-01f, 8.25733468e-02f, 1.87472939e-01f, -3.77600715e-02f, -2.68331170e-02f, 7.33289123e-02f, 5.71793094e-02f, 4.65176962e-02f, 1.14067785e-01f,
  2.11537197e-01f, 2.09795740e-02f, 9.83715653e-02f, -1.06890142e-01f, 1.27520161e-02f, 1.30320683e-01f, -9.33262426e-03f, 1.35422096e-01f, -6.18785843e-02f, 6.44900873e-02f,
  -4.24904749e-03f, -9.10028964e-02f, 8.53304490e-02f, -3.38139981e-02f, -1.31259123e-02f, -2.15815604e-02f, 6.99506141e-03f, 1.61756948e-01f, 8.41759816e-02f, -9.18810815e-02f,
  -1.68459699e-01f, -8.81382227e-02f, 5.08075543e-02f, 1.78944226e-02f, 1.62902370e-01f, 9.62986574e-02f, 1.20191753e-01f, 1.12518191e-01f, 1.85077175e-01f, 3.02927792e-02f,
  -6.80921460e-03f, -2.95432992e-02f, -2.51510292e-02f, -9.77083892e-02f, -2.95235533e-02f, -2.36346349e-02f, -3.14564481e-02f, -1.87345333e-02f, -4.87820171e-02f, 6.39912114e-02f,
  -1.08594140e-02f, -5.19486219e-02f, -4.63277549e-02f, 4.73625585e-02f, -3.04649081e-02f, -1.82486083e-02f, 5.29520512e-02f, -4.94271070e-02f, 5.56824468e-02f, 2.56076604e-02f,
  -1.25075672e-02f, -6.36295378e-02f, -6.50666729e-02f, 3.76751907e-02f, 6.50625080e-02f, 6.14534505e-02f, -3.26658562e-02f, -2.49885134e-02f, 9.65172984e-03f, -1.28824785e-01f,
  -1.42512709e-01f, 1.41136572e-01f, 1.03228822e-01f, 4.76082675e-02f, -7.29505867e-02f, 7.16005117e-02f, -1.05707310e-01f, -1.77110359e-02f, -1.00237820e-02f, 6.21199124e-02f,
  -1.11322943e-02f, 4.68137115e-02f, 3.72959748e-02f, 5.57684572e-03f, -6.19072914e-02f, 4.38986570e-02f, -1.19978540e-01f, 5.55473045e-02f, 4.23444957e-02f, 2.52960399e-02f,
  -1.07045323e-01f, 1.01645045e-01f, -4.18023160e-03f, 1.05186097e-01f, 9.72394273e-03f, 7.47915059e-02f, 9.56921801e-02f, 1.20319888e-01f, 1.37860686e-01f, 5.18439561e-02f,
  -9.63853225e-02f, -2.51325523e-03f, -1.75368175e-01f, -1.72758531e-02f, -1.54420719e-01f, -2.21467733e-01f, -1.95997998e-01f, -5.21938540e-02f, 6.09346852e-02f, 2.47798413e-02f,
  -1.17331762e-02f, 3.95997725e-02f, -5.75118512e-02f, -2.50588451e-02f, -1.37850985e-01f, -7.63090104e-02f, -1.89072818e-01f, -1.63609087e-01f, -9.38903242e-02f, -4.64692935e-02f,
  4.10541892e-02f, -1.23176381e-01f, -2.07396343e-01f, -8.14172328e-02f, 9.17412341e-02f, -4.51450348e-02f, -1.05253883e-01f, 7.27140978e-02f, 8.21242481e-02f, 1.93129361e-01f,
  -4.21585515e-02f, 7.62893707e-02f, -3.87592101e-03f, 1.34704620e-01f, -4.01759567e-03f, 1.13865726e-01f, 5.53733706e-02f, 3.27917449e-02f, 8.40836298e-03f, 1.35551989e-02f,
  1.28666192e-01f, -6.95133535e-03f, 1.94601789e-02f, 6.01745546e-02f, 4.91829142e-02f, 9.36663002e-02f, -2.08803695e-02f, -3.91165875e-02f, -3.88693297e-03f, -4.99019958e-03f,
  7.14723989e-02f, 9.49284881e-02f, -5.64607866e-02f, 7.50861247e-04f, 1.00894317e-01f, 1.94624308e-02f, 1.39949508e-02f, 3.88558507e-02f, 2.67074164e-02f, 6.99410141e-02f,
  6.23996630e-02f, -1.10976115e-01f, 2.22854726e-02f, -4.04311717e-02f, -2.29542460e-02f, 3.28457355e-02f, -3.07281930e-02f, -4.41839173e-03f, 7.35878795e-02f, -6.98740110e-02f,
  5.74732870e-02f, -6.52588978e-02f, 4.05555330e-02f, 2.25006640e-02f, 4.84646335e-02f, -7.26491436e-02f, 7.13308603e-02f, -7.71905556e-02f, -6.44309372e-02f, -6.77020941e-03f,
  2.38490272e-02f, 4.88602510e-03f, 6.12154156e-02f, 6.03383221e-02f, -1.57361180e-02f, 1.39590045e-02f, 2.48183087e-02f, 6.86419606e-02f, -9.44732875e-03f, 9.52489674e-02f,
  -1.51498571e-01f, -2.02733308e-01f, 7.01576099e-02f, -6.79270998e-02f, 3.77225205e-02f, -3.01065836e-02f, 5.79279698e-02f, -8.63796324e-02f, 8.93417299e-02f, 4.21595089e-02f,
  -8.49297922e-03f, 2.04191264e-02f, 3.10229734e-02f, 6.47458807e-02f, -8.64612460e-02f, 3.22817340e-02f, -1.09408364e-01f, -1.20622046e-01f, -4.49415110e-02f, 4.09520035e-05f,
  -1.04212314e-02f, -1.99828833e-01f, -2.58690089e-01f, -1.68017581e-01f, 6.35048375e-02f, -1.94489226e-01f, -2.96523850e-02f, 1.39383888e-02f, -2.39542529e-01f, -2.43382126e-01f,
  -1.10021017e-01f, 6.91477209e-02f, -3.98129672e-02f, -2.64124256e-02f, 2.47789294e-01f, 3.36015254e-01f, 1.42776057e-01f, 4.53481730e-03f, 6.64319247e-02f, 2.64317226e-02f,
  3.29052180e-01f, 1.89616550e-02f, -1.45009100e-01f, -2.70769875e-02f, -2.24642426e-01f, -2.43712291e-01f, -2.53875971e-01f, -1.75925836e-01f, -1.37223572e-01f, 2.10415378e-01f,
  4.65846658e-02f, -7.79535435e-03f, -3.35504184e-03f, -1.42322481e-01f, 1.20931655e-01f, -1.72542762e-02f, 8.03888068e-02f, 1.42671317e-01f, 1.03710823e-01f, -9.15744156e-02f,
  2.94379126e-02f, 2.76352167e-01f, -1.52714103e-02f, 1.61207497e-01f, 1.16748609e-01f, -1.71672124e-02f, 1.25952721e-01f, 2.59834323e-02f, 7.37289712e-02f, -3.06162480e-02f,
  1.89291865e-01f, 1.83293700e-01f, 1.80669487e-01f, 1.52466819e-01f, 7.70168081e-02f, 1.81331888e-01f, 3.65397148e-02f, -9.99011248e-02f, -2.20103618e-02f, 2.29885250e-01f,
  2.05915019e-01f, 2.31107578e-01f, 1.90626800e-01f, 2.22271327e-02f, 1.25936449e-01f, 1.55709773e-01f, 1.82213083e-01f, 6.50596693e-02f, 9.52421874e-02f, -4.86074341e-03f,
  -6.15859106e-02f, -1.56463012e-01f, -9.12389252e-03f, -9.54649299e-02f, -1.28164127e-01f, -9.44317058e-02f, -1.07526682e-01f, 1.34980225e-03f, -8.69508386e-02f, 8.48131441e-03f,
  -4.91654091e-02f, -1.22058459e-01f, -1.95396487e-02f, -2.22384697e-03f, -8.18397477e-02f, -3.49757336e-02f, -7.72538930e-02f, -4.03277203e-02f, 6.35174364e-02f, 2.04473156e-02f,
  4.63542156e-02f, -4.68615964e-02f, -6.61794245e-02f, -1.01808016e-03f, 2.46770382e-02f, -7.56973252e-02f, -8.75015110e-02f, 5.01605049e-02f, -5.42269312e-02f, 5.33134863e-03f,
  -9.54584703e-02f, 2.79683828e-01f, -8.87850598e-02f, 3.03724837e-02f, 1.19685031e-01f, 1.44113109e-01f, 5.40396981e-02f, 1.02167740e-01f, 8.77505988e-02f, 7.55933598e-02f,
  1.80781439e-01f, 2.37961616e-02f, 1.56837162e-02f, 1.43855000e-02f, 1.02220945e-01f, 1.57297254e-01f, 1.06227063e-01f, 2.35489905e-02f, 8.88125971e-02f, 7.14455396e-02f,
  4.03512008e-02f, -1.98238958e-02f, -5.11637330e-02f, -1.10069759e-01f, 2.86426842e-02f, -2.58973688e-02f, -6.80653453e-02f, 7.13398233e-02f, 7.99484104e-02f, -1.06861003e-01f,
  -2.45094150e-01f, 7.08136847e-03f, -9.25089940e-02f, 2.53509611e-01f, 9.51180831e-02f, -1.85936660e-01f, -7.83657655e-02f, -1.09515719e-01f, 8.47164914e-02f, 5.55586768e-03f,
  6.01560250e-02f, 6.64274320e-02f, 1.96162891e-02f, 7.10237399e-02f, -2.27108479e-01f, 8.43651965e-02f, 1.63246199e-01f, 3.15263085e-02f, -1.46476001e-01f, -2.09733415e-02f,
  1.84209242e-01f, 1.54516742e-01f, 1.33534014e-01f, 8.35075751e-02f, 3.13515633e-01f, 1.57737330e-01f, 1.00792907e-01f, 1.51392400e-01f, 7.38599598e-02f, 2.84557879e-01f,
  -1.11871161e-01f, -9.61444005e-02f, 9.74401832e-02f, 1.20750949e-01f, 4.17099483e-02f, 4.66298684e-03f, 3.67158540e-02f, 6.40141517e-02f, 8.57256725e-02f, 8.94125924e-02f,
  9.30302888e-02f, 9.78198498e-02f, 1.37724087e-01f, 1.68526486e-01f, 7.58490413e-02f, 4.99716327e-02f, 7.63906091e-02f, 7.29006827e-02f, 5.70942201e-02f, -2.38195565e-02f,
  1.77495822e-01f, 7.60194957e-02f, -5.43835908e-02f, -2.72110309e-02f, -5.44647574e-02f, 8.90955925e-02f, -1.04657397e-01f, -2.79424135e-02f, -1.11617319e-01f, 1.57260507e-01f,
  6.98921755e-02f, -1.39421552e-01f, -2.30299998e-02f, -5.77872358e-02f, -5.56074865e-02f, -8.94103944e-03f, -3.57194692e-02f, -1.16007939e-01f, -3.60917449e-02f, -7.44438404e-03f,
  -1.42681273e-02f, -6.00705892e-02f, -7.57454187e-02f, -4.98047844e-02f, -2.05506608e-02f, -4.83849160e-02f, -2.53431499e-02f, -8.45651403e-02f, -1.37706459e-01f, 2.18358207e-02f,
  -6.20641783e-02f, -1.72891989e-01f, -3.22531462e-02f, -1.04332808e-02f, -8.69347434e-03f, -1.09833013e-02f, -8.02685767e-02f, -5.88679351e-02f, -1.38521835e-01f, -8.79481360e-02f,
  -2.22326294e-02f, 3.65165691e-03f, 5.25947772e-02f, 6.41365051e-02f, 6.97619244e-02f, 5.56044653e-02f, 2.06331890e-02f, 1.27664864e-01f, 5.93029447e-02f, 3.90562229e-02f,
  2.17326023e-02f, -6.40588254e-02f, 1.01193115e-01f, 9.30214226e-02f, -1.72753651e-02f, 8.02026838e-02f, 1.63578898e-01f, 9.15832818e-02f, 1.02146573e-01f, 1.35975972e-01f,
  7.41882697e-02f, -3.58508378e-02f, -1.42826602e-01f, 1.28201637e-02f, -2.04863939e-02f, -5.22703454e-02f, -1.48160830e-01f, -7.41383880e-02f, -9.83894840e-02f, -5.69583066e-02f,
  1.07182294e-01f, -9.53849182e-02f, -7.31179044e-02f, 1.71870545e-01f, 4.60583009e-02f, 7.35296160e-02f, -6.10788651e-02f, 1.78186610e-01f, 1.60298198e-01f, -6.93788603e-02f,
  6.37828782e-02f, 2.50869513e-01f, 2.24607259e-01f, 3.10224742e-01f, 4.19789940e-01f, 2.56581195e-02f, 6.37706593e-02f, 3.56993109e-01f, 3.71176481e-01f, 2.07487598e-01f,
  2.55100369e-01f, 1.15130462e-01f, 1.65434420e-01f, 2.37113968e-01f, 8.34172778e-03f, 2.51498848e-01f, -3.80305760e-02f, -1.98441371e-03f, 7.20150536e-03f, -7.54279494e-02f,
  -1.37777492e-01f, -1.16668813e-01f, 2.72353083e-01f, 2.46171698e-01f, 8.18554088e-02f, 1.59129202e-01f, 6.37429804e-02f, 9.38179642e-02f, 1.96156666e-01f, 4.26862426e-02f,
  1.41614676e-01f, 5.67500964e-02f, 1.64427757e-01f, 4.86702509e-02f, 2.25812029e-02f, 5.50275221e-02f, 1.05009288e-01f, 1.41987696e-01f, 1.61627918e-01f, 1.53768897e-01f,
  1.83936253e-01f, 4.04415503e-02f, -1.37083959e-02f, 2.21983701e-01f, 1.24268450e-01f, 1.99438855e-01f, 1.55051738e-01f, 6.07025959e-02f, 9.72921103e-02f, 1.61768943e-02f,
  5.42838909e-02f, -7.27337366e-03f, -1.58385813e-01f, -6.24190420e-02f, -1.47597060e-01f, -1.12629086e-01f, -1.12089001e-01f, -1.58974916e-01f, -6.41799122e-02f, -2.05444768e-01f,
  -2.22330764e-02f, -1.29929602e-01f, -1.87675026e-03f, -1.14923522e-01f, -7.16692582e-03f, -1.37696758e-01f, -3.20078395e-02f, -6.36811182e-02f, -7.99009949e-02f, -1.70183003e-01f,
  -7.45389462e-02f, -2.64651775e-02f, -9.92955491e-02f, -3.74718532e-02f, -2.35103965e-02f, -3.93435918e-02f, -5.02606519e-02f, -5.18508293e-02f, -2.83937026e-02f, -4.64964025e-02f,
  -7.80829266e-02f, 2.09001437e-01f, 7.89560154e-02f, 1.91370979e-01f, 1.06292009e-01f, 2.16902956e-01f, 2.88436469e-02f, 1.13932371e-01f, 1.12796105e-01f, 1.83290198e-01f,
  5.10917380e-02f, 1.23708837e-01f, 1.12594225e-01f, 1.26456127e-01f, 9.54724252e-02f, 6.96896911e-02f, 3.27000804e-02f, 1.68235853e-01f, 2.37516999e-01f, 9.70658436e-02f,
  1.32488042e-01f, 1.01980813e-01f, 4.32331301e-02f, 4.37997654e-02f, 1.10859849e-01f, 1.44718185e-01f, 4.25856933e-02f, 1.60993218e-01f, 2.03664899e-01f, -4.10951264e-02f,
  3.39260042e-01f, 2.99664915e-01f, 3.58382791e-01f, 1.56163409e-01f, 1.11491360e-01f, 2.69368272e-02f, 2.70333230e-01f, 5.88057488e-02f, -5.36907353e-02f, -1.68132130e-02f,
  -1.46477386e-01f, -9.29930136e-02f, -3.53189632e-02f, 4.87880856e-02f, 9.94592607e-02f, 2.64604867e-01f, 2.27335945e-01f, 1.76429167e-01f, -6.10054750e-03f, -6.37251884e-02f,
  -5.60738752e-03f, 8.29681382e-02f, 9.39322188e-02f, 4.08719257e-02f, 1.54586125e-03f, -5.34783825e-02f, 1.84529081e-01f, 7.86921382e-02f, 7.03896284e-02f, 1.34917304e-01f,
  2.63441093e-02f, 2.45206282e-01f, 1.01534231e-03f, -1.02709189e-01f, 3.44045945e-02f, -6.17995933e-02f, 3.62993777e-02f, -3.52086276e-02f, 4.93021682e-03f, 1.73941981e-02f,
  -3.14835808e-03f, -3.81304063e-02f, 1.99126229e-02f, -3.14217247e-02f, 4.77141999e-02f, -8.77298117e-02f, 1.18307240e-01f, 1.27569452e-01f, 6.57238290e-02f, -8.77830461e-02f,
  9.68394428e-03f, 1.50511026e-01f, 2.20797047e-01f, 1.14884116e-01f, 8.34526494e-02f, -4.13242802e-02f, -2.85315979e-02f, -2.30422299e-02f, 4.93368246e-02f, 2.52589025e-02f,
  -5.58953285e-02f, 2.62345690e-02f, -5.23936637e-02f, -1.47604821e-02f, 2.87166275e-02f, -9.85716358e-02f, 8.06629434e-02f, 5.41083738e-02f, 8.98869615e-03f, -2.59004142e-02f,
  2.11028159e-02f, -5.12315966e-02f, -4.51641530e-02f, 6.26380071e-02f, -5.33553399e-02f, 5.15090004e-02f, 8.42832476e-02f, -4.91549373e-02f, -7.57676810e-02f, 6.91952650e-03f,
  3.27786170e-02f, 2.46967077e-02f, 4.12971675e-02f, 9.29893646e-03f, -3.91180515e-02f, 6.46987855e-02f, -1.25022363e-02f, -9.89716575e-02f, -6.95272982e-02f, -7.53259882e-02f,
  -3.97256464e-02f, 7.33707994e-02f, -6.99068308e-02f, 9.05073136e-02f, -3.92881520e-02f, -9.81661603e-02f, -2.13569943e-02f, 1.08974434e-01f, -3.82325687e-02f, 7.96458200e-02f,
  -5.00866435e-02f, 1.18152937e-02f, 9.80143398e-02f, -1.16127077e-02f, 3.60568352e-02f, -3.53934541e-02f, 3.53743732e-02f, 1.11061826e-01f, 3.69996205e-02f, -7.35272244e-02f,
  -2.95622740e-02f, 9.25943628e-02f, 8.19885731e-02f, -4.43581417e-02f, 2.42968723e-02f, -7.75263272e-03f, -1.99989378e-02f, -6.31739199e-02f, -4.29667793e-02f, 2.76348479e-02f,
  -2.97310889e-01f, -1.47180319e-01f, -2.01630920e-01f, -2.28464097e-01f, 5.87912612e-02f, -9.37712193e-02f, -2.88376004e-01f, -7.49084353e-02f, 1.50173698e-02f, -1.49386287e-01f,
  7.50932246e-02f, 2.32219636e-01f, 7.58546665e-02f, 1.70545727e-01f, 7.46358559e-02f, -1.53086171e-01f, -5.83032183e-02f, 4.68525365e-02f, 1.14998244e-01f, 1.56443775e-01f,
  6.55820146e-02f, -8.49144906e-02f, 4.48296033e-02f, -5.12150228e-02f, 5.42701669e-02f, -2.71480251e-02f, -1.56747788e-01f, -1.00356955e-02f, -6.09901808e-02f, -1.93129674e-01f,
  6.99545220e-02f, -3.95873599e-02f, 1.26975894e-01f, 1.44912943e-01f, 2.22514588e-02f, 1.79472417e-02f, 5.48628252e-03f, 8.77965521e-03f, -2.57548690e-02f, -1.62719972e-02f,
  1.57696195e-02f, 1.19364567e-01f, 9.07733142e-02f, 5.21200225e-02f, -2.34734844e-02f, -4.03305963e-02f, 5.73137626e-02f, 3.18354480e-02f, 4.67430614e-02f, 7.36885220e-02f,
  4.98171560e-02f, -7.04274839e-03f, -4.25477885e-02f, 2.18027532e-02f, 4.34897728e-02f, 8.30722824e-02f, -1.05618730e-01f, -6.94549829e-02f, 4.54745330e-02f, -1.14315569e-01f,
  -8.64472613e-02f, -5.53668365e-02f, 2.65641417e-02f, -7.29847252e-02f, -5.10607325e-02f, 1.55200800e-02f, -1.06200285e-01f, -7.87550658e-02f, -4.56194468e-02f, -1.32973373e-01f,
  3.58888172e-02f, -1.00496382e-01f, 1.10493349e-02f, -6.54294118e-02f, 6.39693066e-03f, -4.73736338e-02f, -6.57237768e-02f, 4.57120091e-02f, 7.20183030e-02f, -1.00820489e-01f,
  -4.61067706e-02f, -6.39903694e-02f, -2.67205536e-02f, -1.74209441e-03f, 3.56925279e-02f, -4.17056568e-02f, -3.98535579e-02f, -1.34660359e-02f, -4.16943990e-02f, -3.69355604e-02f,
  -7.96772316e-02f, 9.80532467e-02f, -1.39772415e-01f, -5.46999983e-02f, 7.02255452e-03f, 8.25162828e-02f, -2.60349009e-02f, 4.08360213e-02f, 9.16073918e-02f, 8.25196225e-03f,
  7.64349252e-02f, 6.53613433e-02f, 5.89719750e-02f, -3.91292311e-02f, -9.86692961e-03f, -4.10009362e-02f, -6.12482131e-02f, -5.51337451e-02f, 3.54332328e-02f, 2.98163556e-02f,
  -8.95594154e-03f, -5.68055222e-03f, -1.13203675e-01f, -9.42176804e-02f, -8.62933844e-02f, 1.28641240e-02f, 2.71647982e-03f, -6.43693283e-02f, -3.02799158e-02f, -2.45949879e-01f,
  6.27547324e-01f, -4.09617633e-01f, 4.45452742e-02f, 2.40809947e-01f, -1.61118552e-01f, -1.95738584e-01f, -2.10036650e-01f, 6.22988725e-03f, 1.96997449e-01f, -3.06470995e-03f,
  -5.11875749e-02f, 1.45466015e-01f, 1.35138303e-01f, 6.73280433e-02f, 2.88107470e-02f, -1.23341635e-01f, -2.02002022e-02f, 1.17600799e-01f, 2.05248252e-01f, -9.24675763e-02f,
  -1.36122644e-01f, 1.41776755e-01f, 2.44123921e-01f, 1.54362358e-02f, -9.81354788e-02f, 4.89235297e-02f, -1.29170148e-02f, -2.66156569e-02f, -9.66102034e-02f, -2.62004491e-02f,
  3.52895781e-02f, 3.27385999e-02f, 1.85502201e-01f, 9.24807340e-02f, 8.42817202e-02f, 1.45092338e-01f, 1.45958364e-01f, 5.28589077e-02f, 1.15461126e-01f, 4.47900034e-02f,
  8.67685229e-02f, 2.12486945e-02f, 1.37798609e-02f, -4.73599089e-03f, 9.75843817e-02f, 1.41174287e-01f, 8.23548585e-02f, 1.74792036e-01f, 2.03837931e-01f, -1.93367489e-02f,
  7.91654550e-03f, 5.72940856e-02f, 1.19549334e-01f, 1.55432811e-02f, -2.02905051e-02f, 1.29406855e-01f, -3.32575366e-02f, -3.28642577e-02f, 1.79724127e-01f, 1.92799255e-01f,
  5.11946529e-02f, -3.82409357e-02f, -6.87859878e-02f, -3.29999737e-02f, -1.29701748e-01f, -5.98893575e-02f, 1.92886926e-02f, -9.97703001e-02f, -3.03541459e-02f, 1.60022341e-02f,
  -5.84071390e-02f, -6.42624944e-02f, -8.49972200e-03f, 6.48681214e-03f, -9.71502513e-02f, 2.19691861e-02f, -1.14864270e-04f, -1.01134486e-01f, -1.06626675e-02f, -6.14768863e-02f,
  -2.18534786e-02f, 4.98533808e-03f, 6.08428456e-02f, -5.97920567e-02f, -5.37590496e-02f, 2.68007778e-02f, -1.57843754e-02f, -1.37802809e-01f, 1.03212949e-02f, -7.82052577e-02f,
  1.90924734e-01f, 2.07321361e-01f, 1.17139347e-01f, 1.25047684e-01f, 3.85714509e-02f, 4.08874303e-02f, 4.41644294e-03f, 9.08896178e-02f, 1.32110208e-01f, 1.03144050e-01f,
  1.86773818e-02f, 1.32937238e-01f, -1.24932127e-02f, 2.68763062e-02f, 1.15092903e-01f, 9.40620825e-02f, -1.11341225e-02f, 6.89820349e-02f, 1.21397272e-01f, 5.53611666e-02f,
  -2.36643218e-02f, 2.58030575e-02f, 1.92423284e-01f, 3.20618637e-02f, 6.18334152e-02f, 1.46852672e-01f, 7.91370049e-02f, 1.55471981e-01f, 1.69029042e-01f, 8.70719329e-02f,
  2.49964863e-01f, 3.79308820e-01f, 1.12656713e-01f, 2.79722124e-01f, 5.00093475e-02f, -1.11553364e-01f, 5.49001358e-02f, 2.97750961e-02f, -6.24782108e-02f, 6.74891546e-02f,
  9.23492536e-02f, -5.99182993e-02f, 9.06935930e-02f, 3.19750868e-02f, 1.27534822e-01f, 1.96522459e-01f, 1.20667703e-01f, 9.95765030e-02f, -6.72392696e-02f, -1.43115103e-01f,
  -5.19532599e-02f, 5.49629629e-02f, 1.39991403e-01f, 1.75269172e-01f, 6.09774515e-02f, 6.64045066e-02f, 1.10932268e-01f, 1.10662475e-01f, 8.01300406e-02f, 3.54043365e-01f,
  -1.28063887e-01f, 2.91093856e-01f, -9.37420502e-02f, 4.81119640e-02f, 1.11561552e-01f, 3.02357599e-02f, 6.99471086e-02f, 1.08498015e-01f, 1.30502153e-02f, 2.89055835e-02f,
  4.27101031e-02f, 1.10394791e-01f, 9.78469402e-02f, 1.09907530e-01f, -9.07683559e-03f, 1.24602308e-02f, 1.77855548e-02f, 1.58298805e-01f, 4.71347533e-02f, 1.49306580e-01f,
  1.87848195e-01f, 2.07922846e-01f, 6.91595972e-02f, 4.55019772e-02f, 1.38367876e-01f, 1.02104992e-01f, 1.77411344e-02f, 1.39544427e-01f, -4.69881902e-03f, 1.08641818e-01f,
  -6.52156863e-03f, -6.50955038e-03f, -9.90082920e-02f, 1.67963710e-02f, -1.26687944e-01f, 2.41685119e-02f, 9.51839611e-02f, -5.77638298e-02f, -4.30330038e-02f, -1.54904127e-02f,
  9.18395631e-03f, 8.60966276e-03f, -3.04576922e-02f, 6.94852546e-02f, 1.29701570e-02f, -2.80495430e-03f, 7.64858350e-02f, -5.69933802e-02f, 4.36456166e-02f, -8.67298320e-02f,
  -1.14899062e-01f, 4.55775894e-02f, 1.99649930e-02f, -6.12334833e-02f, 7.20675737e-02f, -4.90665585e-02f, -1.85131971e-02f, -1.06611170e-01f, 3.85630205e-02f, -1.86759960e-02f,
  -1.97410136e-01f, -2.31833179e-02f, 7.01131970e-02f, 1.10981792e-01f, 1.04623653e-01f, 7.36157643e-03f, 1.11334175e-01f, -3.48442197e-02f, 1.01235896e-01f, 1.96659211e-02f,
  8.01017955e-02f, 4.35775556e-02f, 9.23437029e-02f, 4.66163494e-02f, -3.51848267e-02f, 1.81615651e-02f, -2.90750004e-02f, 5.00013530e-02f, 1.20142177e-02f, 7.42376922e-03f,
  1.10435002e-02f, -6.63339868e-02f, -1.64120644e-02f, -1.40752792e-01f, -8.24628547e-02f, -1.68580022e-02f, -1.18081793e-01f, 1.42737869e-02f, -4.01740409e-02f, -1.92002907e-01f,
  4.27739829e-01f, 5.88717699e-01f, 1.41851217e-01f, 5.90254925e-02f, -7.27992301e-05f, 1.70413718e-01f, 4.13392395e-01f, 3.38508934e-01f, 1.29500985e-01f, 6.34644702e-02f,
  -1.19382322e-01f, -3.32943797e-01f, -2.95048714e-01f, -2.26594642e-01f, -5.50387837e-02f, 1.89721361e-01f, 9.09532085e-02f, -7.58468062e-02f, -1.21714063e-01f, -9.75354463e-02f,
  -9.03645828e-02f, 3.93839218e-02f, 7.96514284e-03f, -1.87730193e-02f, -4.37409393e-02f, -1.63806766e-01f, 1.25721797e-01f, 1.83918141e-02f, -3.70273292e-02f, -5.34718335e-02f,
  -3.41567904e-01f, 3.07200134e-01f, -1.51253134e-01f, -1.05037298e-02f, 1.07274884e-02f, 7.54500628e-02f, 6.94953604e-03f, 2.98848972e-02f, 6.46028966e-02f, 1.52065093e-02f,
  -1.06544718e-01f, -5.50964884e-02f, -1.26209348e-01f, -4.85846885e-02f, 2.83178929e-02f, -8.03831294e-02f, 6.51506260e-02f, 4.10819519e-03f, 9.43890680e-03f, 8.13023522e-02f,
  -2.23929342e-02f, 1.30722001e-01f, 7.07580820e-02f, 7.61639252e-02f, 5.58356522e-03f, -5.79128861e-02f, 4.17301245e-02f, 8.67984816e-02f, -1.19691517e-03f, 1.54660329e-01f,
  1.05093885e-02f, 1.26731684e-02f, 6.64322749e-02f, 1.77366976e-02f, 3.58086526e-02f, 3.54288821e-03f, -8.79790708e-02f, -3.31900902e-02f, -4.20821719e-02f, 2.23989375e-02f,
  -2.01374870e-02f, -1.03203863e-01f, 4.33309712e-02f, -6.18143007e-02f, -1.50830373e-01f, -4.89572715e-03f, 6.54756874e-02f, 5.78505360e-02f, -7.67083094e-02f, 1.96822099e-02f,
  -7.39736483e-02f, 2.57684588e-02f, -9.46144834e-02f, 2.65153460e-02f, 5.73499762e-02f, -6.04256336e-03f, -5.19474298e-02f, 4.16601114e-02f, 5.46368258e-03f, 6.51483424e-03f,
  -1.37189552e-01f, -7.98587576e-02f, -1.09500624e-01f, -5.76453209e-02f, 7.00991303e-02f, 2.94620041e-02f, -8.99851993e-02f, -4.57460573e-03f, -5.77572286e-02f, -1.20124612e-02f,
  -1.78140923e-02f, 1.90275721e-02f, -1.07517548e-01f, 4.59785797e-02f, 1.85196493e-02f, 1.66579597e-02f, 6.70852587e-02f, -1.04918726e-01f, -4.57016379e-02f, 1.23922028e-01f,
  1.33452401e-01f, 1.26033500e-01f, 1.27004571e-02f, -1.29954098e-02f, 1.01252928e-01f, -3.13027613e-02f, -1.33014530e-01f, 5.50650433e-02f, -9.03510209e-03f, 1.49944589e-01f,
  3.25715542e-01f, 1.79578096e-01f, -2.71821350e-01f, 2.45137960e-01f, 7.66194835e-02f, 9.56843942e-02f, 2.67846823e-01f, 3.24370295e-01f, 2.12757543e-01f, 5.26139550e-02f,
  -9.41931531e-02f, -9.28318799e-02f, -1.78962156e-01f, -1.67421386e-01f, -2.57639438e-01f, -1.28498092e-01f, -1.20105915e-01f, -3.21694642e-01f, -2.02465624e-01f, 1.61758508e-03f,
  9.50722583e-03f, 1.53606251e-01f, -7.91371390e-02f, -1.10404275e-01f, 1.27590552e-01f, -1.23610944e-01f, 1.52797764e-02f, -9.84993875e-02f, -2.07295731e-01f, -1.17829494e-01f,
  -1.28214106e-01f, 1.63741127e-01f, -1.08359613e-01f, -1.21749647e-01f, -1.19515195e-01f, -4.51952703e-02f, -9.25678015e-02f, 8.81391228e-04f, -7.12608919e-02f, -1.21009620e-02f,
  -1.21226469e-02f, -6.60604462e-02f, -4.55600582e-02f, -1.85022838e-02f, 1.13417335e-01f, -6.12047538e-02f, -1.01390213e-01f, -1.64715767e-01f, -2.05337062e-01f, -1.00668430e-01f,
  -1.29262865e-01f, -1.04042906e-02f, -6.56557158e-02f, 2.55291220e-02f, 2.09144093e-02f, -1.53318599e-01f, -5.83822466e-02f, 4.30572331e-02f, 1.40638668e-02f, 1.72545671e-01f,
  3.44597995e-02f, 6.35686517e-02f, 8.13796651e-03f, 7.18775168e-02f, 2.76139658e-02f, -9.53088608e-03f, -1.96734499e-02f, 7.98757300e-02f, 1.01225719e-01f, 6.48059547e-02f,
  -1.01295905e-02f, 1.00635454e-01f, -1.50266232e-03f, 3.82760465e-02f, -4.35530134e-02f, 6.34420812e-02f, -2.67687589e-02f, -3.06610987e-02f, 1.84884183e-02f, -1.36835882e-02f,
  1.54361166e-02f, -7.12124631e-02f, 8.46219286e-02f, -2.54157302e-03f, -9.80320722e-02f, 3.68799060e-03f, 9.38889608e-02f, 4.53231335e-02f, 1.44357532e-01f, -1.80440340e-02f,
  3.01324129e-01f, -2.59989500e-01f, -1.01266898e-01f, -6.43401295e-02f, -2.60416307e-02f, -8.82600173e-02f, 6.98907941e-04f, -1.34399101e-01f, -1.03021711e-01f, 2.45317891e-02f,
  4.06522676e-02f, 3.97760235e-02f, 6.55669942e-02f, 2.39630044e-02f, -3.52118872e-02f, 6.78450167e-02f, 1.40331378e-02f, -7.42003024e-02f, -1.10971399e-01f, -1.94851607e-02f,
  2.73930971e-02f, 7.65224323e-02f, 1.24745533e-01f, 1.01906195e-01f, 2.45698765e-02f, -5.69655187e-02f, -4.99276370e-02f, -2.78341062e-02f, 6.25831261e-02f, 1.69435978e-01f,
  -5.19950867e-01f, 1.14695109e-01f, -4.32907306e-02f, -2.22855628e-01f, 3.34552191e-02f, 1.78879470e-01f, 3.44951391e-01f, 1.03503831e-01f, -1.86249748e-01f, -8.41444209e-02f,
  -3.46952975e-02f, -1.48282677e-01f, -2.66683400e-01f, -1.04774646e-01f, -1.24488235e-01f, 1.73076689e-01f, 6.42631948e-02f, -1.99876994e-01f, -2.79180352e-02f, 4.87650111e-02f,
  -6.33512363e-02f, -1.21838592e-01f, -2.59878218e-01f, -2.28954479e-01f, -1.46731392e-01f, -8.69814679e-02f, -5.97052276e-02f, -8.30698907e-02f, -7.04415813e-02f, -1.57157853e-01f,
  -4.38451022e-03f, -2.91409135e-01f, -9.78748873e-02f, -1.27027318e-01f, -8.46321657e-02f, -1.77330822e-01f, 4.18694504e-03f, -4.87148724e-02f, -1.31213859e-01f, -9.92847234e-02f,
  -1.01266861e-01f, -6.22706302e-02f, -5.19111827e-02f, -6.63186163e-02f, -1.15729429e-01f, -1.24031387e-01f, -8.55741575e-02f, -1.59673855e-01f, -1.09705411e-01f, -4.88494784e-02f,
  -2.15454102e-02f, -1.15520038e-01f, 4.61072102e-02f, 4.00055014e-02f, -1.08187333e-01f, -1.86318144e-01f, 2.39278097e-02f, -1.75142974e-01f, -1.11621596e-01f, 1.76747758e-02f,
  8.14538226e-02f, 1.22564100e-02f, -1.11545939e-02f, 6.50010929e-02f, -3.72373685e-02f, 3.65425870e-02f, -4.12612259e-02f, 1.12995699e-01f, 6.28309026e-02f, 4.43059802e-02f,
  1.52449673e-02f, -2.32602842e-02f, 1.03667267e-01f, 1.83462501e-02f, -3.32090247e-04f, 5.68973599e-03f, 2.16550436e-02f, 9.58636329e-02f, 5.42232357e-02f, 3.04553676e-02f,
  1.12267137e-02f, -1.40701430e-02f, -7.58649083e-03f, -1.73172131e-02f, -1.16148852e-02f, 1.04403600e-01f, 9.32915136e-02f, -2.35709250e-02f, 5.12933545e-02f, 4.84576588e-03f,
  8.93024132e-02f, -6.88671842e-02f, -6.59516901e-02f, -1.55697837e-01f, -2.82679647e-02f, -1.02185890e-01f, -1.02901943e-01f, -1.64353609e-01f, -1.72747597e-01f, -6.13564588e-02f,
  -5.53719234e-03f, -1.27114013e-01f, 3.01139131e-02f, -6.28142357e-02f, -6.79568723e-02f, -5.55633977e-02f, 5.78358285e-02f, -4.72219661e-02f, -1.49069071e-01f, -1.20014019e-01f,
  -5.12826629e-02f, 4.88402508e-03f, 8.10279027e-02f, 3.53682637e-02f, -8.79406556e-02f, -2.73516234e-02f, 5.84331341e-02f, 3.62156555e-02f, 6.31992221e-02f, 7.42396414e-02f,
  -3.32142472e-01f, 2.85027593e-01f, 2.98253119e-01f, -1.76512793e-01f, 1.59143865e-01f, 2.07159035e-02f, 5.89143187e-02f, -1.65542528e-01f, -1.93222851e-01f, 7.38938451e-02f,
  1.85805947e-01f, 7.64372274e-02f, 1.04194462e-01f, 8.05981681e-02f, 1.06434822e-01f, 1.65682912e-01f, 1.96706682e-01f, 2.52802484e-02f, -1.35842487e-02f, -1.16789587e-01f,
  -9.46022272e-02f, -1.13312364e-01f, -1.29516318e-01f, -1.11747921e-01f, -2.97481902e-02f, -2.92042959e-02f, 1.61190256e-01f, 7.65429884e-02f, 1.41775280e-01f, 2.18852445e-01f,
  4.20622855e-01f, 3.39683816e-02f, -7.36519173e-02f, -7.40032122e-02f, 1.77789852e-01f, -9.64127555e-02f, -3.42226177e-02f, -4.80173230e-02f, -7.13837296e-02f, 2.75894478e-02f,
  8.34175944e-02f, 2.86850575e-02f, 1.51265971e-02f, 5.63019849e-02f, -3.92118320e-02f, -1.07401062e-03f, -8.60015675e-02f, -4.47291657e-02f, 8.79831389e-02f, 1.51911020e-01f,
  1.28937617e-01f, 1.77490652e-01f, 1.33102372e-01f, -8.13606661e-03f, -4.82235439e-02f, 3.92293930e-02f, 6.17131367e-02f, 5.16464077e-02f, 9.57821310e-03f, 3.11505166e-03f,
  -3.52917314e-02f, 1.10009909e-01f, 5.63976076e-03f, -4.76504527e-02f, -2.08950620e-02f, 2.48281043e-02f, 8.39533433e-02f, 6.82701990e-02f, -5.92511706e-03f, -3.14202793e-02f,
  -8.89581516e-02f, 5.53050451e-02f, -5.61995134e-02f, -2.35501491e-02f, -1.82866340e-03f, 1.12098660e-02f, 1.46596611e-01f, 1.72378272e-02f, -5.29719219e-02f, -8.12456980e-02f,
  -3.64862895e-03f, 2.93194614e-02f, -8.44070092e-02f, -3.26802544e-02f, -2.59941071e-02f, 5.36999293e-02f, -4.97462489e-02f, -5.57797588e-02f, 3.54199596e-02f, -9.05938447e-02f,
  5.10596745e-02f, -1.83618218e-02f, 6.96735755e-02f, -7.50800893e-02f, 2.39137132e-02f, -3.61444987e-02f, 2.83226725e-02f, -1.42740846e-01f, 5.26546687e-02f, 4.15149778e-02f,
  -6.84293211e-02f, -6.27707392e-02f, 4.77566160e-02f, -5.35183400e-03f, -2.48497557e-02f, 1.05493050e-02f, -3.99951125e-03f, 2.88805477e-02f, 5.75211979e-02f, 1.17756263e-03f,
  -3.38122472e-02f, -3.62664834e-02f, -2.10881401e-02f, 6.74604252e-02f, 9.48526780e-04f, 1.85938310e-02f, 7.21184015e-02f, 4.82698679e-02f, -1.09788741e-03f, -2.77682990e-02f,
  -1.97656393e-01f, -1.48323715e-01f, 2.15764448e-01f, 7.22896531e-02f, -3.39205377e-02f, 9.81122926e-02f, 4.77119908e-02f, 1.71252862e-02f, -2.43097562e-02f, 7.27435574e-03f,
  -2.00624391e-02f, -4.98064645e-02f, 2.28974428e-02f, 2.59303488e-03f, 2.00454757e-01f, 2.49705479e-01f, 1.81179881e-01f, 2.39351675e-01f, 1.93359241e-01f, -6.81381375e-02f,
  3.12862098e-02f, 1.06963821e-01f, 1.40156403e-01f, -4.72283065e-02f, -6.23022020e-02f, -8.24709535e-02f, 9.33843702e-02f, -7.74203688e-02f, -1.18295595e-01f, 4.59590778e-02f,
  -8.84293988e-02f, -1.34249642e-01f, 2.93701538e-03f, -4.53727171e-02f, -1.16864748e-01f, -2.14903995e-01f, -2.42165420e-02f, -7.61530772e-02f, -9.16111097e-02f, -5.95976375e-02f,
  2.57632062e-02f, -3.81895564e-02f, -9.52024944e-03f, -1.35685608e-01f, -6.39060289e-02f, -1.54186502e-01f, 2.52118725e-02f, 1.90325100e-02f, -9.69924033e-02f, -1.03736825e-01f,
  -2.90637836e-02f, -1.21577300e-01f, 2.43672486e-02f, -1.45163640e-01f, -8.41800473e-04f, -5.44961309e-03f, -2.08996400e-01f, -1.65344268e-01f, -1.72522873e-01f, -1.09215073e-01f,
  1.92519233e-01f, -6.49236217e-02f, 1.21016540e-02f, 8.70292634e-02f, 4.08235528e-02f, 5.27876653e-02f, 9.69076678e-02f, 1.27143353e-01f, 2.07772013e-02f, -1.72812119e-02f,
  9.98897180e-02f, 1.68751940e-01f, 9.55718830e-02f, 7.47031868e-02f, 2.89502963e-02f, 1.05077788e-01f, 1.23598159e-03f, 9.63361114e-02f, 9.24785808e-02f, 7.82385617e-02f,
  -3.18033360e-02f, 9.95257776e-03f, -2.16255039e-02f, 5.04665747e-02f, 8.35039392e-02f, 1.76544785e-01f, -2.41548587e-02f, -1.38474405e-02f, 3.14973742e-02f, -3.37206312e-02f,
  -1.69380844e-01f, -1.27270981e-03f, -6.48526624e-02f, -1.14078529e-01f, -8.76685381e-02f, -1.69092536e-01f, -1.41523510e-01f, -9.83343944e-02f, -1.51689872e-01f, -4.12323326e-02f,
  -1.24106862e-01f, -3.76630425e-02f, -1.05487309e-01f, -1.31622255e-01f, -1.37428660e-02f, 2.12032329e-02f, -5.18300794e-02f, -4.72774766e-02f, 4.15442772e-02f, -1.06370099e-01f,
  -3.30243632e-02f, -4.39772606e-02f, -2.09878255e-02f, 1.72891300e-02f, -1.31879464e-01f, 1.22409044e-02f, -3.66744362e-02f, -2.03320712e-01f, -1.20680988e-01f, -6.94216415e-03f,
  5.30741096e-01f, 4.95120198e-01f, 2.28220478e-01f, 1.44499347e-01f, 1.03599794e-01f, 1.64329737e-01f, 3.40952486e-01f, 4.40926887e-02f, -6.19209707e-02f, 2.20170051e-01f,
  1.90423667e-01f, -1.33689895e-01f, -6.31967112e-02f, -8.54480267e-02f, 5.46289459e-02f, 2.86394864e-01f, 2.34135300e-01f, 1.50371958e-02f, -2.00611845e-01f, -1.14837661e-01f,
  2.49518752e-02f, 2.19069719e-01f, 1.24705255e-01f, 6.53811768e-02f, 1.83918681e-02f, -1.87261015e-01f, 1.55205220e-01f, 1.76947489e-01f, 2.29308218e-01f, 1.90725625e-01f,
  -1.42623335e-01f, 2.52866358e-01f, -7.11819604e-02f, 1.18793529e-02f, -3.94335669e-03f, 6.22593947e-02f, 8.72988403e-02f, -6.13508187e-02f, 1.28323823e-01f, 9.51135531e-02f,
  -1.27954455e-02f, 9.15205404e-02f, 7.03057796e-02f, 6.06943108e-02f, 2.68188654e-04f, -1.79430638e-02f, 6.03398606e-02f, 8.36837590e-02f, -3.31476219e-02f, 4.30051796e-02f,
  3.95933539e-02f, 2.00909659e-01f, 1.94046944e-01f, 1.14986906e-03f, -6.06713891e-02f, 2.60393191e-02f, 8.42464864e-02f, 7.89031759e-02f, 3.43386680e-02f, 7.06147030e-02f,
  -6.44074231e-02f, -6.27356395e-03f, 4.29230323e-03f, -1.50128575e-02f, 1.96074545e-02f, 2.70033404e-02f, 4.22175266e-02f, -3.02817859e-02f, -3.37339640e-02f, -6.15573736e-05f,
  1.89790339e-03f, -4.45034774e-03f, -3.44046876e-02f, 1.80360973e-02f, -4.78124693e-02f, -4.75645624e-03f, -1.15614869e-02f, 4.12643813e-02f, -1.36448406e-02f, 3.35952416e-02f,
  4.03822958e-02f, -4.04835790e-02f, 2.71132272e-02f, -8.75974968e-02f, 9.18775890e-03f, 3.21233384e-02f, -2.70840749e-02f, -1.00793801e-02f, 3.04107536e-02f, 1.41898870e-01f,
  -2.23030701e-01f, 8.18419233e-02f, -4.91620880e-03f, -4.40850891e-02f, -2.71758772e-02f, -1.75789576e-02f, -6.36213124e-02f, -1.00650815e-02f, 1.63145196e-02f, 1.57749951e-02f,
  4.76371720e-02f, 1.74186099e-02f, 6.16906304e-03f, -4.05192841e-03f, -3.54129970e-02f, -1.02556627e-02f, 6.70167878e-02f, 5.88690769e-03f, -2.84268297e-02f, 1.25395983e-01f,
  1.48499861e-01f, -7.59855984e-03f, -2.60925330e-02f, -7.72455856e-02f, -4.48489636e-02f, -2.18581017e-02f, 1.98633615e-02f, -5.27099110e-02f, -2.68807057e-02f, 1.36452436e-01f,
  -6.08611643e-01f, -3.68854314e-01f, 2.34674916e-01f, -3.42022330e-01f, 1.89579904e-01f, 3.56285691e-01f, 2.47750133e-01f, 6.44171089e-02f, 1.08954031e-02f, -9.74553376e-02f,
  -1.68421134e-01f, -1.08659975e-01f, -1.33913606e-01f, 9.09828320e-02f, 1.01020172e-01f, 2.31956318e-02f, 1.50833666e-01f, 1.11401998e-01f, 4.20923114e-01f, 3.64001989e-01f,
  8.28806981e-02f, -1.25231415e-01f, -1.30084679e-01f, 5.14259301e-02f, 1.10997353e-02f, 2.64024455e-02f, -1.26682803e-01f, -5.40171191e-02f, 4.77282181e-02f, -4.04040590e-02f,
  1.95801444e-02f, -1.91023842e-01f, 1.53152868e-01f, -1.67849064e-01f, -1.33066148e-01f, -7.10322410e-02f, 7.12719793e-03f, -9.91527662e-02f, -5.80659062e-02f, 1.70899406e-02f,
  -8.10868442e-02f, 2.02102140e-02f, -2.32880041e-02f, 5.05218282e-02f, 7.36432290e-03f, 3.83633114e-02f, -1.12882316e-01f, -4.29302491e-02f, -6.64343834e-02f, -8.16434342e-03f,
  -6.04550936e-04f, 1.94109045e-02f, -6.60384446e-02f, 7.30749685e-03f, 4.58823256e-02f, 1.94998272e-02f, 2.37422939e-02f, 9.76380799e-03f, 3.98739688e-02f, -7.51710385e-02f,
  -1.92106292e-02f, 7.35978037e-03f, 1.40906855e-01f, -9.18422639e-03f, 5.58464378e-02f, -4.54281978e-02f, 3.59981731e-02f, 4.00462039e-02f, 2.70210672e-02f, 6.56379387e-02f,
  1.18677774e-02f, 4.89785150e-02f, 3.98474708e-02f, -1.60598923e-02f, 2.64976621e-02f, -4.50627208e-02f, 2.06510965e-02f, -7.02012554e-02f, 1.61128510e-02f, -2.85449531e-02f,
  -2.17346498e-03f, 7.47446418e-02f, -3.66562866e-02f, 9.58580822e-02f, 2.06632353e-02f, -1.30216284e-02f, -1.12545211e-02f, 6.60109594e-02f, -4.11302783e-02f, 5.77792823e-02f,
  -9.30800587e-02f, 5.44781704e-03f, -5.85727207e-02f, -2.32771728e-02f, -5.67066483e-03f, -7.93445781e-02f, -6.90537542e-02f, 4.91197892e-02f, -4.51495089e-02f, -9.96491779e-03f,
  2.00989172e-02f, -5.55684641e-02f, -1.45990446e-01f, 3.67718469e-03f, 6.44100904e-02f, 5.14064990e-02f, -5.89987561e-02f, -5.90666831e-02f, -2.51995381e-02f, 3.55716273e-02f,
  -7.23953247e-02f, 2.84626391e-02f, 3.89202824e-03f, 5.31009324e-02f, 4.65501323e-02f, 3.96487489e-02f, 6.00616224e-02f, 9.52740610e-02f, 4.75868098e-02f, -1.54398426e-01f,
  4.78039123e-02f, 2.60760576e-01f, 1.94013223e-01f, -1.13167606e-01f, 2.49417648e-02f, 1.35273933e-01f, 2.92025447e-01f, 1.09534524e-01f, -1.58041902e-02f, -9.23762918e-02f,
  -2.33886972e-01f, -2.02137485e-01f, -1.22008912e-01f, -1.30978450e-01f, 3.20912758e-03f, 1.54275075e-01f, 2.30975285e-01f, 1.21954732e-01f, 1.05826914e-01f, 3.15753743e-02f,
  -1.40113652e-01f, -4.79695648e-02f, -2.93257623e-03f, 8.11487958e-02f, 2.64380015e-02f, -3.81001793e-02f, 1.21500358e-01f, 9.15742144e-02f, 1.00836538e-01f, 1.64002165e-01f,
  -8.02225992e-02f, 1.79948866e-01f, -9.64782834e-02f, -1.18975081e-01f, -3.89682017e-02f, 9.84551609e-02f, -6.17561443e-03f, 8.87521580e-02f, 3.71331200e-02f, 1.06379129e-02f,
  -3.51186693e-02f, -2.57486869e-02f, -2.41914727e-02f, -5.00528887e-02f, 5.73363863e-02f, 7.81455562e-02f, 1.50984555e-01f, 1.70144677e-01f, 6.66514859e-02f, 6.38348982e-02f,
  -8.46931636e-02f, 1.32222965e-01f, 1.82577923e-01f, 1.49626702e-01f, 3.51653807e-02f, -4.25487384e-02f, 1.44606754e-01f, 1.39941901e-01f, 8.97967741e-02f, 1.46125272e-01f,
  8.43098480e-03f, 9.74224322e-03f, -3.30005176e-02f, 5.08939987e-03f, -9.45244357e-02f, -4.73082619e-05f, 1.02551905e-02f, -5.48452791e-03f, 1.25000179e-02f, 7.70821869e-02f,
  2.03577075e-02f, -3.38583887e-02f, -6.56526722e-03f, 1.15165390e-01f, -3.78911160e-02f, 6.22203127e-02f, -1.44799938e-02f, -2.03880668e-02f, 7.40133077e-02f, -6.12224378e-02f,
  -2.83913370e-02f, -3.47691551e-02f, 1.57532580e-02f, 3.42340916e-02f, -3.70715186e-02f, 5.57399020e-02f, -2.79430822e-02f, -3.32890935e-02f, 3.17158401e-02f, 3.82264927e-02f,
  -3.60409915e-01f, 6.96505327e-03f, -4.64382395e-03f, -5.94242364e-02f, 9.64979827e-02f, -2.93000955e-02f, -8.63972232e-02f, 3.08323000e-02f, 1.07196427e-03f, 8.33050311e-02f,
  8.10920745e-02f, 3.45152803e-04f, 5.87326474e-02f, 1.21870767e-02f, -4.47415784e-02f, -1.59133673e-02f, 1.07869105e-02f, 5.59475506e-03f, -1.66574102e-02f, -4.59134998e-03f,
  2.22095735e-02f, 4.55920100e-02f, -6.55424744e-02f, 4.11815457e-02f, 1.05693735e-01f, -2.75510326e-02f, 6.89657629e-02f, 3.73269245e-02f, -1.01313610e-02f, -6.20799847e-02f,
  4.97168154e-01f, 3.46804298e-02f, 1.63672909e-01f, 1.38763368e-01f, 1.40464783e-01f, 2.36788169e-01f, 1.91648379e-01f, 1.68775573e-01f, 2.16026455e-02f, -1.26624390e-01f,
  3.04679014e-02f, -8.60510767e-02f, -5.17092161e-02f, 6.86041042e-02f, 1.83516204e-01f, -2.56074569e-03f, 1.57038257e-01f, 9.06840190e-02f, 2.18595728e-01f, 4.04289328e-02f,
  1.11086937e-02f, -3.96583341e-02f, 1.53746188e-01f, 5.57154417e-02f, -8.96070004e-02f, -1.87005788e-01f, -1.50292724e-01f, 4.24762331e-02f, 5.42631857e-02f, -3.32115479e-02f,
  -2.44085237e-01f, 2.31529996e-01f, 7.33952001e-02f, 7.21511468e-02f, 3.51217604e-05f, 1.10615060e-01f, 7.42698014e-02f, 7.53918514e-02f, 1.51736543e-01f, -1.27919612e-03f,
  1.40907526e-01f, 9.74998474e-02f, 1.50563240e-01f, -2.54308842e-02f, 6.79518059e-02f, 2.38953512e-02f, 1.00993164e-01f, 2.43408512e-02f, 3.71473096e-03f, -4.43239370e-03f,
  7.35792443e-02f, 2.03771189e-01f, 2.42213801e-01f, 1.51552498e-01f, 7.87059739e-02f, 1.83725983e-01f, 4.30574343e-02f, 1.16124041e-01f, 1.08987495e-01f, -5.11139780e-02f,
  -3.22425887e-02f, -6.11217655e-02f, -5.32819107e-02f, 4.29868465e-03f, -1.05274871e-01f, -5.78619093e-02f, -7.12075531e-02f, 1.21467412e-02f, -8.72672573e-02f, 3.84101807e-03f,
  -4.04890031e-02f, -3.96653712e-02f, 7.76651083e-03f, 1.42929042e-02f, -8.24895799e-02f, 6.10555783e-02f, 2.28882991e-02f, -1.24453485e-01f, 1.91057753e-02f, 1.03583336e-02f,
  -9.08545218e-03f, -6.43377891e-03f, -5.01377396e-02f, 1.99376941e-02f, -2.68366858e-02f, 1.32260650e-01f, 1.43841524e-02f, -7.74828494e-02f, -7.96114281e-02f, -1.16631773e-03f,
  -3.52974206e-01f, 8.65565091e-02f, 6.07979037e-02f, 2.21267380e-02f, 9.95023698e-02f, -1.69946179e-02f, -1.57955359e-03f, 4.46339436e-02f, 2.18348857e-02f, -3.79152223e-03f,
  2.98917145e-02f, 6.06996045e-02f, -5.55906519e-02f, -1.74583010e-02f, 6.14179671e-02f, 4.34363484e-02f, 1.92487389e-02f, 1.30253300e-01f, 3.46929245e-02f, 4.15620878e-02f,
  -6.39066696e-02f, 1.28151506e-01f, 1.28994480e-01f, 8.70249048e-02f, -9.25632566e-03f, 1.34008229e-01f, 5.81767671e-02f, -2.28640530e-02f, 3.11234649e-02f, -8.10276791e-02f,
  2.16140952e-02f, -1.50427878e-01f, 7.79319778e-02f, -1.68638617e-01f, -6.53520301e-02f, -4.99515608e-03f, 5.94957136e-02f, 1.52477607e-01f, -4.27330993e-02f, -2.85492162e-04f,
  -2.96560880e-02f, 1.41782239e-01f, 7.59355128e-02f, 2.20335245e-01f, 2.10335404e-01f, 9.49132442e-03f, -9.25941579e-03f, 1.28263220e-01f, 2.72547513e-01f, 1.87504217e-01f,
  1.42290341e-02f, 5.83771244e-02f, 1.29978463e-01f, 1.66458383e-01f, -4.67867367e-02f, -5.67735322e-02f, -9.28768367e-02f, -4.43564057e-02f, 3.75820436e-02f, -1.21446654e-01f,
  -5.22726960e-02f, 1.64310083e-01f, 5.94673827e-02f, 1.48564741e-01f, 4.22511473e-02f, 1.50454178e-01f, 9.77439508e-02f, 2.10413802e-02f, 1.55919313e-01f, 9.31971595e-02f,
  1.14424504e-01f, 1.92439947e-02f, -3.96378245e-03f, 4.57478762e-02f, -1.93051044e-02f, 1.51387393e-01f, 1.99237734e-01f, 2.28873670e-01f, 2.30613500e-01f, 1.42198488e-01f,
  1.32081985e-01f, 4.13711444e-02f, 6.65794089e-02f, 1.97829381e-02f, 1.81232229e-01f, 4.71971557e-02f, 1.36864081e-01f, 2.92537622e-02f, 9.73889306e-02f, -1.47095751e-02f,
  -7.05887824e-02f, -8.36195201e-02f, -2.46103499e-02f, -1.04074709e-01f, -9.28092003e-02f, -1.60424665e-01f, -1.19809270e-01f, -7.62140602e-02f, -9.71633419e-02f, -1.17119819e-01f,
  -5.08835874e-02f, -8.67507607e-02f, -1.66479964e-02f, -9.75056663e-02f, -1.47817254e-01f, -5.44002093e-02f, -1.04199998e-01f, -3.67186032e-02f, -7.59654194e-02f, -6.28808886e-02f,
  -6.58648461e-02f, -8.29740167e-02f, -4.32218909e-02f, -4.25530151e-02f, 7.89864436e-02f, 3.61631438e-03f, -3.75064462e-02f, -1.04185887e-01f, -1.13485247e-01f, -7.59154558e-02f,
  -2.46538699e-01f, 3.36611569e-01f, 2.70863380e-02f, -4.36718650e-02f, -2.33467054e-02f, 5.67254685e-02f, 9.63303223e-02f, 1.07944936e-01f, 1.62664037e-02f, 3.51697803e-02f,
  7.61116669e-02f, 1.08557545e-01f, 1.28786430e-01f, 1.90272257e-01f, 3.02077713e-03f, 1.23615988e-01f, 1.16588548e-01f, -1.78427587e-03f, 1.15914211e-01f, 9.20971930e-02f,
  1.62577182e-01f, 5.69087714e-02f, -5.01786964e-03f, -2.88233962e-02f, 1.67152420e-01f, 9.27308202e-02f, -6.18487783e-03f, -4.53576824e-04f, 6.16993420e-02f, -1.10149592e-01f,
  9.70577076e-02f, 7.43789831e-03f, 2.52010167e-01f, -1.99206382e-01f, -1.77139360e-02f, 2.08985716e-01f, 4.31272537e-01f, 1.85721777e-02f, -1.56195045e-01f, 1.47868171e-01f,
  -1.94626972e-01f, -2.55581647e-01f, -1.50537178e-01f, -3.30038816e-02f, 9.14988443e-02f, 3.28781962e-01f, 6.09082244e-02f, 3.75822335e-02f, -1.49470363e-02f, 1.03285156e-01f,
  -8.98245946e-02f, -2.51096219e-01f, -1.70327663e-01f, -9.13720876e-02f, -1.20767884e-01f, -9.78911743e-02f, -8.86268467e-02f, -9.02254954e-02f, 2.13867836e-02f, 1.41011238e-01f,
  2.78695285e-01f, 1.01576515e-01f, -8.35513622e-02f, -2.25649610e-01f, -9.61348191e-02f, -7.15414733e-02f, 1.13975732e-02f, -8.11702609e-02f, -7.59011582e-02f, -4.22986932e-02f,
  -1.45767316e-01f, -3.93995345e-02f, -1.51556194e-01f, 4.08906974e-02f, 3.70260254e-02f, -3.39002982e-02f, -1.10765927e-01f, 6.36541173e-02f, -5.08153485e-03f, 1.20518729e-02f,
  -1.84632495e-01f, -7.17244819e-02f, -1.81204900e-02f, -3.42349224e-02f, 6.25957474e-02f, -5.78786992e-02f, 3.21875885e-02f, 6.32432699e-02f, 2.16417443e-02f, 1.19721331e-01f,
  5.92067651e-02f, 8.81524831e-02f, 4.00271080e-02f, 1.81129687e-02f, 6.32889271e-02f, 9.09764394e-02f, -8.41353834e-03f, 6.61724657e-02f, 1.24184834e-02f, 6.65995702e-02f,
  9.00411606e-02f, 4.96179201e-02f, 1.75654087e-02f, 3.80417220e-02f, -7.37121552e-02f, 5.13344705e-02f, 7.74637982e-02f, 5.60589433e-02f, -3.33016850e-02f, -2.07584910e-02f,
  1.49090821e-02f, -3.29807284e-03f, 4.46933247e-02f, -7.47366948e-03f, 3.55309397e-02f, 2.54768897e-02f, 7.29168281e-02f, 7.07729608e-02f, 8.45869109e-02f, 2.79450119e-02f,
  -1.70328557e-01f, -1.93458900e-01f, 1.35544300e-01f, -5.66216893e-02f, 5.99707058e-03f, -7.73408264e-02f, -9.04554799e-02f, -6.10966124e-02f, -2.43200753e-02f, -1.02255289e-02f,
  4.31201346e-02f, -5.10292836e-02f, -5.41372262e-02f, 1.85794644e-02f, 5.33903725e-02f, -5.92182465e-02f, -5.72286062e-02f, -6.78779259e-02f, 1.75723154e-02f, -4.55426537e-02f,
  -7.77934492e-02f, 1.56991363e-01f, 1.64618522e-01f, 2.28072880e-04f, 6.22803271e-02f, 7.77602941e-02f, 6.72682300e-02f, 1.51904225e-01f, 1.61119580e-01f, 1.43476307e-01f,
  3.29083592e-01f, -1.50374815e-01f, 4.15430330e-02f, -8.05756450e-02f, -2.51303047e-01f, -2.33505383e-01f, -2.46196643e-01f, -2.47035809e-02f, -6.66245669e-02f, -3.78485955e-02f,
  -9.85035896e-02f, -4.21221979e-04f, -1.67493019e-02f, 1.13229156e-01f, 1.87757775e-01f, -6.06197491e-02f, -9.62941069e-03f, 1.06592104e-01f, 1.74385294e-01f, -2.85763368e-02f,
  -1.20647170e-01f, -8.07319805e-02f, 6.14294782e-02f, 1.39048249e-01f, -1.59694657e-01f, -2.34975070e-02f, -1.33648282e-02f, 5.91306016e-03f, -7.02909157e-02f, -9.46805924e-02f,
  1.09231003e-01f, 8.93620700e-02f, -6.47802204e-02f, -1.04066774e-01f, 2.31995508e-02f, -9.08103120e-03f, -7.44489655e-02f, -8.65757465e-03f, 1.76280718e-02f, 3.36135514e-02f,
  -1.33823723e-01f, -7.44987950e-02f, -4.60568033e-02f, 5.06579205e-02f, 1.46814510e-02f, -9.14354473e-02f, 1.08516589e-01f, 1.24428086e-01f, 6.23209178e-02f, 7.03354105e-02f,
  -1.24796979e-01f, -1.69118255e-01f, 2.76432489e-04f, -1.01301335e-01f, 1.17447287e-01f, -8.50238949e-02f, 5.45339920e-02f, -7.60462582e-02f, -1.27160400e-02f, -5.31844189e-03f,
  -1.03355691e-01f, 9.19419378e-02f, 1.71735156e-02f, 2.25178786e-02f, 1.16855558e-02f, 4.38128300e-02f, 4.60182689e-02f, -2.28883382e-02f, 4.98812236e-02f, 1.20425276e-01f,
  1.94610152e-02f, 8.47453028e-02f, 5.21113500e-02f, 3.29252146e-02f, 2.35400405e-02f, 7.95430616e-02f, -2.63172630e-02f, 8.55505615e-02f, 6.53600693e-02f, 1.74975052e-01f,
  8.67811590e-03f, 2.97180973e-02f, 3.78411859e-02f, 9.16294008e-02f, 9.13348421e-02f, 1.21953174e-01f, 2.51349341e-02f, 1.69199735e-01f, 5.89591973e-02f, 9.29838568e-02f,
  -6.51917756e-02f, 5.31458035e-02f, 1.23570552e-02f, 8.07017311e-02f, -2.12459476e-03f, -4.74283956e-02f, -7.80696571e-02f, -7.57400542e-02f, 2.00854130e-02f, 7.70674646e-02f,
  1.08448431e-01f, 3.78819220e-02f, -1.68211162e-02f, -2.61961538e-02f, -1.27512276e-01f, -5.93664981e-02f, -4.00645137e-02f, -4.10014391e-02f, 1.26032596e-02f, 2.43452992e-02f,
  -1.24812067e-01f, -8.56390595e-02f, -4.72519211e-02f, -1.91564068e-01f, -2.36920156e-02f, -1.49325743e-01f, -1.63865745e-01f, -9.48396474e-02f, -1.64628997e-01f, -2.17115909e-01f,
  1.06521413e-01f, 5.96179701e-02f, 2.77018905e-01f, 1.53421491e-01f, 3.07801783e-01f, 2.29283586e-01f, 1.36556551e-01f, 4.85151894e-02f, 5.12492210e-02f, 1.86303705e-01f,
  9.18188021e-02f, -9.28030312e-02f, 7.15100858e-03f, 8.83580651e-03f, 1.89176518e-02f, 1.94303885e-01f, 2.49533519e-01f, 2.14136496e-01f, 2.05590814e-01f, 2.02351093e-01f,
  1.32594317e-01f, 1.98679551e-01f, 1.73139229e-01f, 7.42466301e-02f, 3.51630757e-03f, 4.07518968e-02f, 1.36459455e-01f, 1.68348223e-01f, 1.07691638e-01f, 1.73132315e-01f,
  3.37897278e-02f, -1.75713021e-02f, 5.29343635e-03f, 2.05849968e-02f, 8.34245756e-02f, -1.36833578e-01f, 4.51358147e-02f, -4.84887771e-02f, -9.37826633e-02f, 3.62495072e-02f,
  -2.89509725e-02f, 1.29869044e-01f, -1.51514681e-02f, 6.98577240e-02f, -9.35545005e-03f, 3.92736234e-02f, 1.63645577e-02f, 6.66158721e-02f, -7.47767687e-02f, -2.62168050e-02f,
  2.88809128e-02f, 8.49458054e-02f, 2.93671079e-02f, -1.34889083e-02f, -2.82196552e-02f, -1.14097305e-01f, 4.97956388e-03f, 3.43195088e-02f, -5.19328266e-02f, -2.28571724e-02f,
  9.78883579e-02f, 9.31830034e-02f, -2.64235027e-02f, 1.06467336e-01f, 1.00632966e-01f, -1.26742944e-02f, 2.72880718e-02f, 1.21341683e-01f, 8.79744589e-02f, 3.09819467e-02f,
  1.14870280e-01f, 8.71291310e-02f, 1.49793793e-02f, 5.03513776e-02f, 3.81990597e-02f, 1.33788690e-01f, 5.88909499e-02f, 6.90591112e-02f, -1.86853614e-02f, 2.68121529e-02f,
  6.19204491e-02f, 5.98347075e-02f, 9.00591239e-02f, 2.23210845e-02f, 1.14371233e-01f, 1.03318699e-01f, 7.79490545e-02f, 5.36134932e-03f, 1.33674696e-01f, 1.30141318e-01f,
  1.05867526e-02f, -1.52391359e-01f, -1.97425887e-01f, -1.26847982e-01f, -6.83887526e-02f, -7.94211701e-02f, -9.97193679e-02f, -1.54585645e-01f, -9.01069269e-02f, -3.07273474e-02f,
  -1.67685840e-02f, -6.32832199e-02f, -6.18080162e-02f, -1.27987107e-02f, 2.01653633e-02f, -6.02605473e-03f, -8.32592025e-02f, 7.48688877e-02f, -3.02354805e-02f, -4.53231446e-02f,
  -8.96800980e-02f, -2.20103785e-02f, -1.82603315e-01f, -1.11466020e-01f, -2.67290678e-02f, -1.40898168e-01f, -1.89906374e-01f, -9.75869894e-02f, -1.46506459e-01f, -2.26719864e-02f,
  3.00674736e-01f, 2.02880111e-02f, 2.63058782e-01f, 2.23872453e-01f, 9.97366733e-04f, 8.96223634e-02f, -9.60859805e-02f, 4.56495471e-02f, 1.16626933e-01f, 1.27565814e-02f,
  1.64379954e-01f, 2.05615044e-01f, 3.76348972e-01f, 3.27424288e-01f, 2.78026253e-01f, 1.89443126e-01f, 3.42704386e-01f, 4.57549453e-01f, 2.78663665e-01f, -1.83395203e-02f,
  7.12238699e-02f, 1.38014495e-01f, 2.98874646e-01f, 2.82535970e-01f, 1.11321487e-01f, 1.34365395e-01f, 2.00674206e-01f, 1.90549001e-01f, 8.89470652e-02f, 8.29344690e-02f,
  1.58746481e-01f, 2.84517050e-01f, 2.71170408e-01f, 2.53435969e-01f, 1.64987177e-01f, 1.05897196e-01f, 2.33458847e-01f, 2.59750962e-01f, 1.43057019e-01f, 8.83151293e-02f,
  2.08228976e-01f, 1.52644515e-01f, 2.67810255e-01f, 1.50617093e-01f, 2.10210145e-01f, 1.16648473e-01f, 1.71345234e-01f, 2.16401026e-01f, 2.50033140e-01f, 8.09660926e-02f,
  4.91844676e-02f, 4.33711223e-02f, 1.23430252e-01f, 1.39453009e-01f, 8.13519135e-02f, 2.22793251e-01f, 1.68706939e-01f, 1.80422679e-01f, 1.38882026e-01f, 3.33414078e-02f,
  -1.60752609e-01f, -7.22480044e-02f, -1.15946688e-01f, -1.73096001e-01f, -7.19096586e-02f, -1.32228315e-01f, -1.29418105e-01f, -1.49829224e-01f, -5.60511686e-02f, -1.31949484e-01f,
  -1.48951814e-01f, -8.61302242e-02f, -1.54333338e-01f, -1.42615899e-01f, -4.03062180e-02f, -1.39283031e-01f, -6.65605441e-02f, -1.88132986e-01f, -3.41479927e-02f, -1.28219053e-01f,
  -6.46201521e-02f, -1.10262744e-01f, -1.58328209e-02f, -1.29265189e-01f, -6.19396605e-02f, -1.10230826e-01f, -1.59143597e-01f, -1.79109201e-01f, -1.90392226e-01f, -9.85251889e-02f,
  1.85523897e-01f, 2.77207643e-01f, 5.35631292e-02f, 1.56415090e-01f, 1.19599119e-01f, 2.34689400e-01f, 2.03862399e-01f, 1.50020048e-01f, 2.76492983e-01f, 2.10303321e-01f,
  1.44514993e-01f, 1.40599683e-01f, 1.91442370e-01f, 1.64511785e-01f, 1.16491452e-01f, 2.19551682e-01f, 1.29510671e-01f, 1.76232904e-01f, 1.99267939e-01f, 1.43173113e-01f,
  1.34261653e-01f, 9.25439224e-02f, 8.51368159e-02f, 2.20736012e-01f, 1.40593380e-01f, 1.56709120e-01f, 1.86045915e-01f, 1.28285304e-01f, 2.46649534e-01f, -3.61132771e-02f,
  -3.18124264e-01f, -3.17254215e-01f, -1.51533051e-04f, -2.86049753e-01f, -2.02777311e-02f, 9.91547778e-02f, 6.71821833e-02f, -7.73815811e-02f, -9.94268507e-02f, -6.29763352e-03f,
  2.87155882e-02f, -1.13770723e-01f, -2.10777983e-01f, -1.15740813e-01f, -1.43978685e-01f, -2.49279261e-01f, -2.79976994e-01f, -1.41220555e-01f, 3.59913073e-02f, 8.55814964e-02f,
  4.26227674e-02f, -9.99602824e-02f, -2.21439838e-01f, -6.74593747e-02f, -1.44026443e-01f, -1.31741405e-01f, -4.64071967e-02f, -1.05581850e-01f, 1.30448258e-02f, -1.67990208e-01f,
  4.87611964e-02f, -1.81718603e-01f, -6.93069696e-02f, -2.37978786e-01f, -1.00240916e-01f, -2.95455512e-02f, 2.42647454e-02f, -1.39926478e-01f, -1.21676303e-01f, -8.09726119e-02f,
  -1.10994190e-01f, -8.72570425e-02f, -1.80724755e-01f, -4.15195152e-02f, -1.48022801e-01f, -1.08612329e-01f, -1.84769601e-01f, -1.51907682e-01f, -6.96860179e-02f, 2.34807618e-02f,
  -1.74193472e-01f, -9.89885852e-02f, -2.87986882e-02f, -4.29683216e-02f, -1.83573551e-02f, -1.17445365e-01f, -7.44843781e-02f, 2.58112355e-04f, -1.24735571e-01f, -6.49319366e-02f,
  1.92826480e-01f, 4.41662446e-02f, 6.61763549e-02f, -3.45279486e-03f, 7.97698647e-02f, 1.28819291e-02f, -9.56090093e-02f, 5.32635413e-02f, 1.49800509e-01f, -1.71458926e-02f,
  8.98716077e-02f, 4.51843403e-02f, 2.06034109e-02f, -3.14145423e-02f, 3.54008004e-02f, -4.23105359e-02f, 4.28308919e-02f, 9.28000063e-02f, 2.62178034e-02f, 7.76983052e-02f,
  -5.99755021e-03f, 1.61682084e-01f, -9.34923999e-03f, 9.28099155e-02f, -1.52992252e-02f, 8.54462609e-02f, 4.63825651e-02f, 8.27450082e-02f, 1.17625229e-01f, 3.95757370e-02f,
  3.79546173e-02f, -7.61487558e-02f, -9.44213048e-02f, -1.25579089e-01f, -5.64336106e-02f, -1.10916823e-01f, -6.72542378e-02f, 2.17374414e-03f, -4.92627732e-02f, 2.03558709e-02f,
  -4.26754430e-02f, -9.06383693e-02f, -1.00222014e-01f, -2.11403631e-02f, -9.63089801e-03f, 5.30518293e-02f, -1.61902532e-01f, -1.13342620e-01f, -8.78998935e-02f, -3.36815119e-02f,
  -1.00178979e-01f, 2.23534321e-03f, -1.13028921e-01f, -7.40259439e-02f, -7.37323835e-02f, -2.27794349e-02f, 2.79626455e-02f, 5.71766961e-03f, -3.15421708e-02f, 2.46425029e-02f,
  -7.43835717e-02f, 4.86026257e-02f, -1.98873043e-01f, -1.18740797e-02f, 3.26661617e-02f, -3.98148187e-02f, 1.92571208e-02f, -1.05445564e-03f, 4.85391356e-04f, 1.89589664e-01f,
  2.90349692e-01f, 1.92324102e-01f, 5.61839901e-02f, -9.48720202e-02f, -1.08522676e-01f, -1.18192822e-01f, -1.96031019e-01f, -2.66071439e-01f, -2.83391207e-01f, 7.37174898e-02f,
  5.27767576e-02f, -2.89828647e-02f, -1.67794794e-01f, -2.51730382e-01f, -9.12502930e-02f, -5.31402342e-02f, -2.68048555e-01f, -1.49047479e-01f, -1.03197731e-01f, -2.02469960e-01f,
  1.61602914e-01f, 6.20851479e-02f, 4.87951078e-02f, 9.64638814e-02f, -6.51656911e-02f, 1.78590287e-02f, 6.08928353e-02f, -5.43922670e-02f, -5.49990684e-03f, -5.36170695e-03f,
  5.54562546e-02f, -7.89581146e-03f, -9.75006167e-03f, 2.71596201e-02f, -4.88491021e-02f, 2.48147771e-02f, -1.43337980e-01f, -1.66382536e-01f, -1.59225628e-01f, -5.60920984e-02f,
  1.92394648e-02f, -8.62659216e-02f, -8.04923251e-02f, -2.16043759e-02f, -1.67893380e-01f, -8.15945268e-02f, -1.65335350e-02f, -1.58617988e-01f, -2.17269778e-01f, -5.93954287e-02f,
  1.25749245e-01f, -3.69327376e-03f, -2.03362741e-02f, -3.15807872e-02f, 2.22739689e-02f, -9.78804193e-03f, 8.74819141e-03f, -1.49410730e-02f, 4.64338027e-02f, -5.91030195e-02f,
  8.09137884e-04f, -1.64175648e-02f, 1.59105808e-02f, -3.28959934e-02f, -7.67366663e-02f, -5.34967370e-02f, -8.08910653e-02f, -3.81965302e-02f, -2.63304748e-02f, -6.10522516e-02f,
  -8.43650550e-02f, -1.21473400e-02f, -1.45974439e-02f, 4.25651148e-02f, -6.60903454e-02f, 1.67830137e-03f, 4.14704643e-02f, 6.34579062e-02f, 6.45547658e-02f, 1.01357855e-01f,
  -9.27064102e-03f, 2.29999200e-02f, 7.92843923e-02f, 1.26993926e-02f, 8.98267478e-02f, -5.69618866e-02f, -2.76667010e-02f, 3.75957601e-02f, 5.52924909e-02f, 4.92928959e-02f,
  1.06856950e-01f, 1.90115180e-02f, -8.15897156e-03f, 6.54790550e-02f, 2.27316469e-02f, 1.49369940e-01f, -3.47426385e-02f, -9.17217880e-02f, 3.01266555e-02f, 5.16211353e-02f,
  5.38691841e-02f, 1.78276710e-02f, -3.51612568e-02f, -6.04743809e-02f, -2.72017270e-02f, 1.79847069e-02f, -9.05513391e-03f, -6.58680052e-02f, 8.24858397e-02f, -2.74588093e-02f,
  1.21352067e-02f, 4.00671244e-01f, -5.49511500e-02f, -1.02246262e-01f, -9.25106332e-02f, 4.26935218e-02f, 1.49463549e-01f, 1.88063040e-01f, -2.70788260e-02f, 3.41513529e-02f,
  2.89645523e-01f, 1.36160314e-01f, 1.96503222e-01f, 2.21920595e-01f, 3.00455719e-01f, -7.25399554e-02f, -2.34581009e-01f, -1.83874115e-01f, -2.70293392e-02f, -8.59464481e-02f,
  -2.11738974e-01f, -2.73041606e-01f, -6.28659353e-02f, -1.80310175e-01f, -2.53980756e-01f, -2.14202613e-01f, -1.42780244e-01f, -1.18628517e-01f, 6.14784546e-02f, -3.58748913e-01f,
  -1.47892579e-01f, 2.66469091e-01f, 2.09244620e-02f, 3.32133509e-02f, 1.12072401e-01f, -4.37559932e-03f, 1.59854833e-02f, 3.13984491e-02f, 1.11637473e-01f, -4.76738960e-02f,
  7.35342428e-02f, 9.86976549e-02f, -1.07141146e-02f, -1.14990948e-02f, -4.25236411e-02f, 4.53394242e-02f, 8.14971849e-02f, 6.46824762e-02f, 1.00050256e-01f, 5.54881245e-02f,
  -5.80233224e-02f, 5.12651838e-02f, 1.21015638e-01f, 7.89365843e-02f, 2.61637360e-01f, -4.28663045e-02f, 1.40452027e-01f, 1.41890526e-01f, 2.42724434e-01f, -4.45629992e-02f,
  -4.40709889e-02f, 4.12277915e-02f, 7.85845220e-02f, 3.29411104e-02f, -5.79069294e-02f, -5.27918749e-02f, -1.35599658e-01f, 5.67461327e-02f, -5.09520359e-02f, 1.50793558e-02f,
  6.71207160e-03f, 4.38456126e-02f, 3.15773825e-04f, -6.35900050e-02f, -2.80159339e-02f, 5.59501909e-03f, -8.17640647e-02f, 3.06704175e-02f, -5.86998239e-02f, -3.97331752e-02f,
  5.80764487e-02f, 3.82137522e-02f, -6.95969388e-02f, -1.01168260e-01f, -2.71864999e-02f, -9.83744953e-03f, -8.56794268e-02f, 8.67432952e-02f, 1.27871215e-01f, 2.56387191e-03f,
  -3.10109630e-02f, 1.54629201e-01f, -2.27058411e-01f, 6.98606968e-02f, -8.70658308e-02f, 1.90315899e-02f, 4.31325547e-02f, 1.14370408e-02f, 3.67620699e-02f, -6.17913902e-04f,
  1.29851341e-01f, 3.76537144e-02f, 4.03962061e-02f, -7.23829046e-02f, -8.28565191e-03f, 2.39876974e-02f, 1.05861887e-01f, -7.69643188e-02f, -3.45676877e-02f, 1.89717319e-02f,
  -7.28068524e-04f, -3.60694801e-04f, -2.95121502e-02f, -1.36687132e-02f, 4.46677096e-02f, -7.78428614e-02f, -1.40599161e-01f, -2.81235273e-03f, 6.47455901e-02f, -2.07616866e-01f,
  6.03743017e-01f, -8.52695853e-02f, 3.43865693e-01f, 1.94234103e-01f, -5.34391180e-02f, 1.02664316e-02f, -1.80287674e-01f, -6.77943900e-02f, 8.58908966e-02f, -3.44354995e-02f,
  -4.13492620e-02f, -1.08685931e-02f, 1.87388398e-02f, -5.82852848e-02f, 7.68495649e-02f, -1.90525018e-02f, 8.66596624e-02f, 2.76002973e-01f, 3.42512727e-01f, 8.40267763e-02f,
  -1.35504544e-01f, 3.47791091e-02f, 3.03563774e-01f, 1.91650540e-01f, -2.80781947e-02f, 3.19384411e-02f, 1.09812684e-01f, 1.79423437e-01f, -2.32755169e-02f, 7.97586069e-02f,
  2.22971007e-01f, 2.00082585e-01f, 8.16643834e-02f, -1.75664350e-02f, -3.90594378e-02f, 5.48020303e-02f, 3.70093808e-03f, 1.44223273e-01f, 7.12545738e-02f, 1.57909393e-01f,
  6.66428059e-02f, 5.47170788e-02f, -3.93561600e-03f, 5.05458638e-02f, 1.49111077e-01f, 1.32992536e-01f, 1.35714963e-01f, 1.28512070e-01f, 1.86427474e-01f, 3.08504608e-02f,
  -1.44841567e-01f, 4.78545129e-02f, 1.63537115e-01f, 6.10274561e-02f, 3.22120227e-02f, 2.19613597e-01f, 6.87059164e-02f, 3.51539664e-02f, 1.39594585e-01f, 4.99410555e-02f,
  -5.82934357e-02f, 4.64786924e-02f, -3.36144902e-02f, -3.28045674e-02f, -7.15069473e-02f, -1.03378454e-02f, 1.37531487e-02f, -1.27300590e-01f, -1.68569647e-02f, -1.49955839e-01f,
  -1.66989546e-02f, -9.98535082e-02f, 5.61429895e-02f, -5.17132059e-02f, -1.66249022e-01f, -2.66909506e-02f, -3.97510491e-02f, -1.53553098e-01f, -6.52823299e-02f, -4.38489094e-02f,
  -4.88565490e-02f, 1.64034199e-02f, -3.46134380e-02f, -1.18042924e-01f, -1.30393744e-01f, -8.79095271e-02f, -3.87708619e-02f, -1.07486151e-01f, -1.51188478e-01f, 1.46949589e-02f,
  -1.42771844e-02f, 1.42512619e-01f, 3.89705524e-02f, 7.72287278e-03f, 1.26310468e-01f, 2.74210237e-02f, 1.28694819e-02f, 2.01646313e-02f, 3.31119262e-02f, 6.76717535e-02f,
  4.46833856e-02f, 9.81112197e-02f, 1.34362448e-02f, -6.37020962e-03f, 1.34009957e-01f, -1.21289697e-02f, -5.16046993e-02f, 8.96834284e-02f, 9.55565199e-02f, -2.76220068e-02f,
  -9.74906534e-02f, 5.24566732e-02f, 2.78963655e-01f, 5.28046936e-02f, 1.78418104e-02f, 1.41764283e-01f, 1.25034481e-01f, 5.66660985e-02f, 1.90510452e-01f, 9.36062559e-02f,
  4.68550563e-01f, 3.49971980e-01f, 1.00944176e-01f, 3.45327944e-01f, 2.09881701e-02f, -1.47047818e-01f, 3.85013712e-03f, -4.09472287e-02f, 3.83156948e-02f, 1.68843850e-01f,
  7.14025348e-02f, 1.64831206e-02f, 4.54747938e-02f, -2.87101138e-02f, 2.75955710e-04f, -7.03279674e-02f, 6.85614720e-02f, -1.03944920e-01f, -2.81150818e-01f, -1.11613944e-01f,
  -1.37630463e-01f, 3.94228697e-02f, 1.13216273e-01f, -5.48473075e-02f, 2.07484458e-02f, 2.14660745e-02f, 2.27022469e-01f, 1.46358415e-01f, 8.65304470e-03f, -1.92773957e-02f,
  -3.38102207e-02f, 1.96359903e-01f, -1.32878408e-01f, 1.15068331e-02f, 1.58980340e-02f, -7.26444349e-02f, -8.38600621e-02f, 6.02138788e-02f, 5.20365909e-02f, 4.75309938e-02f,
  -1.27098886e-02f, 3.94334346e-02f, -1.05661610e-02f, -4.91174459e-02f, 5.53732030e-02f, -8.55436455e-03f, 3.99948470e-02f, 8.14098399e-03f, 4.18381020e-02f, 3.93282510e-02f,
  4.56750393e-03f, 1.10809356e-01f, 7.30987042e-02f, -6.42863140e-02f, -3.11450772e-02f, 3.53208296e-02f, 4.76089679e-02f, 1.34489276e-02f, -1.44225424e-02f, 2.69971322e-02f,
  3.99509594e-02f, -4.42605000e-03f, 1.94429383e-02f, -5.36615625e-02f, 7.23956444e-04f, 1.43502024e-03f, -4.21613976e-02f, 8.23557004e-02f, -2.54614670e-02f, -4.42347936e-02f,
  6.97087543e-03f, -2.18486087e-03f, -4.11838852e-02f, 6.39413297e-02f, -1.59842633e-02f, 4.13143560e-02f, 1.08077973e-02f, -2.35376228e-03f, 7.24260136e-02f, 7.90003687e-02f,
  -4.11351174e-02f, -3.00113410e-02f, 1.32526934e-01f, -5.77625036e-02f, -1.78969540e-02f, 7.84995779e-02f, -4.78662252e-02f, 8.47233925e-03f, -7.07047954e-02f, 5.17423972e-02f,
  1.88536182e-01f, 9.93216038e-02f, 6.74001053e-02f, -2.53867172e-02f, -2.18124334e-02f, 4.66939919e-02f, -2.53257267e-02f, 3.93702053e-02f, 5.33795059e-02f, -1.42236613e-02f,
  1.33659104e-02f, -7.11408556e-02f, 3.94480675e-02f, 2.99401805e-02f, -3.12434267e-02f, -1.41098976e-01f, 5.20984270e-02f, 7.36207888e-02f, -6.61179721e-02f, 4.46477830e-02f,
  3.88901271e-02f, -4.27815504e-02f, -3.07908840e-02f, -3.17684636e-02f, -9.67890918e-02f, -3.60940918e-02f, -5.35422042e-02f, -1.22046560e-01f, -6.16122112e-02f, 7.06108660e-02f,
  -5.25827825e-01f, 5.71815431e-01f, 2.61119753e-01f, -2.02829555e-01f, -1.57901838e-01f, 1.25723392e-01f, 3.23811412e-01f, 1.07612848e-01f, -3.52399081e-01f, 1.84542537e-01f,
  1.41606718e-01f, -1.84410542e-01f, 2.45352779e-02f, 2.94808466e-02f, 5.83486930e-02f, 1.74363777e-01f, 3.70924547e-02f, 1.29818555e-03f, -6.18073307e-02f, -1.54514369e-02f,
  -8.59380364e-02f, -1.36974335e-01f, -1.49624780e-01f, -1.30660802e-01f, 4.48382273e-02f, -1.82201058e-01f, 1.08762771e-01f, 1.26339376e-01f, 1.32349178e-01f, 1.69194058e-01f,
  2.92222351e-01f, 1.98211044e-01f, -9.26739052e-02f, -1.16138563e-01f, 1.37155065e-02f, -8.20240006e-02f, 9.37216505e-02f, -5.12205586e-02f, -5.08569404e-02f, 6.63181171e-02f,
  -9.04465094e-02f, 2.58707702e-02f, 2.62730438e-02f, -1.61169190e-02f, 6.03791028e-02f, -1.26240626e-02f, 2.96469387e-02f, 1.69884209e-02f, -1.14260260e-02f, 9.72340554e-02f,
  4.22418267e-02f, 5.95991239e-02f, 1.08665176e-01f, -2.60997470e-03f, 7.49299079e-02f, -1.50269866e-01f, 8.28081816e-02f, -2.89768423e-03f, 2.53114961e-02f, 8.68465081e-02f,
  -7.66401589e-02f, 3.60446274e-02f, -7.18559772e-02f, 5.79960309e-02f, -2.74038948e-02f, -6.42098933e-02f, -8.82099420e-02f, -1.67748071e-02f, 2.03172956e-02f, -5.94659783e-02f,
  -4.10231985e-02f, 2.24520285e-02f, 9.78082195e-02f, -2.06427034e-02f, -2.39867549e-02f, 7.59098902e-02f, 4.84680310e-02f, -1.20472005e-02f, 3.25550064e-02f, -4.16506268e-02f,
  -4.70373705e-02f, -2.42234785e-02f, -1.43158771e-02f, 8.68024770e-03f, 5.95005304e-02f, 1.48260258e-02f, -6.01831712e-02f, 1.88631471e-02f, -2.38736626e-02f, -9.75441337e-02f,
  -6.85141012e-02f, -5.06631993e-02f, -1.08338455e-02f, 9.98945092e-04f, -1.50053594e-02f, 9.21044685e-03f, -3.02830227e-02f, -1.14400336e-03f, -2.96220873e-02f, 2.32876781e-02f,
  1.28731102e-01f, -2.31712833e-02f, 2.12902892e-02f, 1.52416155e-02f, -1.04018286e-01f, -2.61406880e-02f, -3.91987488e-02f, -2.75712763e-03f, 3.56546380e-02f, 4.92223054e-02f,
  2.71937903e-02f, -6.56642020e-02f, -1.26186877e-01f, 7.07099885e-02f, 1.34436721e-02f, -1.70829922e-01f, 5.66956215e-02f, -3.99178527e-02f, -2.80378573e-02f, 4.82861092e-03f,
  3.72275740e-01f, 4.34388630e-02f, 7.64541924e-02f, -6.72603250e-02f, -2.73421258e-01f, -2.08723173e-01f, -2.20002308e-01f, 6.46952987e-02f, -9.02238637e-02f, -9.90649238e-02f,
  -1.38454005e-01f, -4.02764380e-02f, -4.15142775e-02f, 1.70307830e-02f, 1.44135192e-01f, -8.61249939e-02f, -3.56392302e-02f, 1.66621074e-01f, 2.76267946e-01f, 9.41193253e-02f,
  -1.20310046e-01f, 4.56007011e-02f, 2.85291672e-01f, 1.44608647e-01f, -1.01828791e-01f, -1.77204192e-01f, -1.32528380e-01f, -3.05356644e-02f, 1.43960491e-02f, -4.91267666e-02f,
  -1.27288718e-02f, 1.46117285e-01f, -5.12631275e-02f, -5.74544072e-04f, -1.22075349e-01f, 1.09922238e-01f, -4.73176092e-02f, -1.22849958e-03f, 3.32359411e-02f, 3.75019014e-03f,
  -2.47582830e-02f, 5.26855029e-02f, -6.79512396e-02f, -1.85950641e-02f, 1.98788401e-02f, 6.06200173e-02f, 1.76637158e-01f, 1.54140055e-01f, 7.64399320e-02f, 4.91932705e-02f,
  -1.00934483e-01f, -2.87253875e-02f, -4.84229177e-02f, -9.86632332e-03f, 2.50994805e-02f, -1.50737651e-02f, 8.64069164e-02f, -3.51022668e-02f, 6.41350597e-02f, 1.00872656e-02f,
  -2.04657204e-02f, 1.40977381e-02f, -6.19035121e-03f, 7.84752518e-03f, -7.82276616e-02f, -6.38850704e-02f, -6.28391877e-02f, -8.05522874e-03f, -3.63542773e-02f, -7.69720227e-02f,
  -4.91510592e-02f, -1.07100327e-02f, -1.14587128e-01f, -4.94580343e-02f, -9.52900425e-02f, -1.35488296e-02f, -1.00471109e-01f, -4.72414047e-02f, -1.12587288e-01f, -4.65198308e-02f,
  -9.64209214e-02f, -1.76681504e-02f, -1.80540904e-01f, -2.77865548e-02f, -5.41596115e-02f, 5.67038991e-02f, -2.98026912e-02f, 2.95380224e-02f, -5.51203750e-02f, -1.05894893e-01f,
  -4.55067344e-02f, 2.63446532e-02f, -2.09773835e-02f, -3.96873280e-02f, -6.32298589e-02f, 1.45123564e-02f, -1.30998001e-01f, 2.43306346e-03f, -3.93033698e-02f, -5.36508635e-02f,
  3.17536003e-04f, 5.90621792e-02f, -7.94833004e-02f, -7.37047009e-03f, -1.00592887e-02f, -1.18246622e-01f, -1.10244498e-01f, -1.15644984e-01f, -1.38138339e-01f, -2.87198462e-02f,
  -5.38386926e-02f, -1.35678694e-01f, -1.52075931e-01f, -3.12252771e-02f, -2.40740050e-02f, -9.03337747e-02f, -9.20070559e-02f, -1.96512938e-01f, -4.10525464e-02f, -1.35681674e-01f,
  -4.31984216e-01f, -1.45534471e-01f, -2.02536970e-01f, -9.30698812e-02f, 1.38074696e-01f, -7.16125667e-02f, -1.26017123e-01f, -5.88913001e-02f, -4.37762849e-02f, -1.49562299e-01f,
  8.55578482e-03f, 1.29355872e-02f, -7.66544938e-02f, -1.24572605e-01f, -3.70544642e-02f, -7.33547136e-02f, -1.03177130e-01f, -2.10197717e-01f, -1.88308626e-01f, 2.57903952e-02f,
  4.98807579e-02f, -1.07415773e-01f, -9.98958573e-02f, -1.46801695e-01f, -8.30244273e-02f, -6.47161677e-02f, -6.54056966e-02f, -5.59241995e-02f, -1.66254133e-01f, -1.25185490e-01f,
  -2.76940405e-01f, -2.32038096e-01f, -1.42511413e-01f, -1.27423227e-01f, -7.93690328e-03f, -1.95454955e-01f, -2.14811325e-01f, -1.43314525e-01f, -3.91162671e-02f, -8.41277242e-02f,
  -1.01566603e-02f, -1.61410704e-01f, 5.69342822e-03f, -5.84930778e-02f, -1.70376763e-01f, -1.79033250e-01f, -1.04766533e-01f, -1.79562271e-01f, -1.34595305e-01f, -8.29403922e-02f,
  4.03422639e-02f, -5.18076345e-02f, -1.87448233e-01f, -7.09366500e-02f, -1.09420687e-01f, 3.42612201e-03f, -1.74616724e-01f, -1.04081810e-01f, -2.32252523e-01f, -2.95856059e-01f,
  -8.70649964e-02f, 1.36040181e-01f, 1.77157968e-01f, 5.46922609e-02f, 7.74607435e-02f, 1.87462166e-01f, 1.05773814e-01f, 8.79390165e-02f, 5.39394394e-02f, 7.08608776e-02f,
  1.37041301e-01f, 1.14092812e-01f, 4.43555824e-02f, 1.40318811e-01f, 1.26977921e-01f, 1.56201690e-01f, 2.14223489e-01f, 1.53115258e-01f, 5.49226254e-02f, 1.27630576e-01f,
  1.10354222e-01f, 1.37206957e-01f, 2.18399748e-01f, 1.53471336e-01f, 1.13159217e-01f, 1.71847224e-01f, 1.66297421e-01f, 1.64397776e-01f, 6.61506131e-02f, 9.94054303e-02f,
  -2.13027939e-01f, -6.23510033e-03f, -1.00561291e-01f, -1.77364126e-01f, -7.41785243e-02f, -9.31191966e-02f, -9.83151570e-02f, -1.11287840e-01f, -1.03942394e-01f, -1.68829843e-01f,
  -1.10600300e-01f, -6.61704019e-02f, -7.56845847e-02f, -4.06522416e-02f, -3.07455119e-02f, -1.59532294e-01f, -9.40227956e-02f, -9.85896215e-02f, -4.64802831e-02f, -1.42904714e-01f,
  -9.86179486e-02f, -1.72562510e-01f, -2.58227408e-01f, -1.23899087e-01f, -1.33125499e-01f, -1.04432799e-01f, -1.92693710e-01f, -1.91162333e-01f, -2.09326655e-01f, -3.35949570e-01f,
  -2.77194381e-01f, 3.35305959e-01f, -8.05383027e-02f, -9.80864763e-02f, -2.15462431e-01f, -3.91294584e-02f, 1.42682806e-01f, 3.57641801e-02f, -8.76975283e-02f, -9.41245258e-02f,
  -8.16169232e-02f, -1.93414539e-01f, -1.64512381e-01f, 4.07888442e-02f, 4.80005927e-02f, 8.58622417e-02f, 2.67191883e-02f, -1.01087853e-01f, -4.85978574e-02f, -2.54219584e-02f,
  9.35892686e-02f, 3.79626788e-02f, 1.35256439e-01f, 7.76094347e-02f, 9.21980441e-02f, -1.60660550e-01f, 7.85795376e-02f, -1.29003599e-02f, 4.32525240e-02f, 2.58306656e-02f,
  -2.74813741e-01f, 2.23669142e-01f, -1.64193988e-01f, 9.72596183e-02f, -9.84022673e-03f, -3.73770180e-03f, -5.55080660e-02f, 2.13874560e-02f, 9.25396234e-02f, 2.80791651e-02f,
  -5.25712408e-02f, 5.38884774e-02f, 2.06555575e-02f, 8.66619647e-02f, -4.52326909e-02f, 1.74108893e-02f, 3.98827009e-02f, 1.08377412e-02f, 7.24477042e-03f, 1.33979172e-01f,
  5.09354435e-02f, -8.54202434e-02f, -1.60156071e-01f, 2.10346263e-02f, 1.31232157e-01f, -3.41695398e-02f, 1.10057697e-01f, 1.01808749e-01f, 1.09492401e-02f, -2.47932933e-02f,
  2.71991007e-02f, -1.04106687e-01f, 1.53305409e-02f, 6.39384985e-02f, -5.63993677e-02f, -5.49887009e-02f, -6.57194182e-02f, -4.88164462e-02f, 9.74140316e-02f, 7.36947870e-03f,
  -5.17469160e-02f, 4.52774903e-03f, 3.14173140e-02f, -1.99479032e-02f, -4.21449356e-02f, 1.20373359e-02f, -9.26365238e-03f, 2.94163972e-02f, 4.62216251e-02f, 8.96287430e-03f,
  4.04194370e-02f, -3.47637199e-02f, -3.77989709e-02f, 4.65309098e-02f, 1.07236847e-01f, -3.10094729e-02f, -3.83371487e-02f, 2.25477200e-02f, -3.33132148e-02f, 2.26045074e-03f,
  -1.86543331e-01f, 1.29526332e-01f, -1.59998268e-01f, 1.79741792e-02f, -5.22428751e-02f, 3.07783559e-02f, -7.03842193e-02f, 9.91475657e-02f, -1.65798571e-02f, -4.53508198e-02f,
  7.66654452e-03f, 2.74378601e-02f, 2.93903295e-02f, 4.08243239e-02f, 4.49457727e-02f, -5.76798841e-02f, -5.97337410e-02f, -9.59170237e-02f, 1.11305483e-01f, -2.98201777e-02f,
  -3.33648585e-02f, -1.52872980e-01f, -1.45049483e-01f, -5.09399660e-02f, 2.00568908e-03f, -1.56586036e-01f, -6.81992993e-02f, -1.77941546e-01f, -6.05368465e-02f, -1.69517711e-01f,
  -2.11365446e-01f, 1.44086797e-02f, 3.44286971e-02f, -7.33816624e-02f, -7.47061297e-02f, -1.34423912e-01f, -6.01104647e-03f, -1.21032000e-01f, -1.16645798e-01f, -6.19445816e-02f,
  -2.27926867e-04f, -2.18743924e-02f, -1.00486182e-01f, 9.22784433e-02f, 8.17645192e-02f, 7.06511289e-02f, 6.35526702e-02f, -1.48832500e-02f, -4.81725903e-03f, 6.26371503e-02f,
  1.42046437e-02f, 6.41602948e-02f, 7.84563497e-02f, 8.09327886e-02f, -2.74757277e-02f, -1.61698665e-02f, 5.01256771e-02f, 3.33996005e-02f, 3.62016968e-02f, 2.19470337e-01f,
  8.23524669e-02f, 4.39394638e-02f, -4.02137674e-02f, 6.41338006e-02f, -8.01575109e-02f, -4.79434524e-03f, -1.14908382e-01f, 4.57452387e-02f, -9.12406147e-02f, 3.16945128e-02f,
  -2.26208605e-02f, 4.78367135e-02f, -8.20707828e-02f, -2.78408956e-02f, 9.81863290e-02f, 4.32915464e-02f, -1.86558459e-02f, 1.17143907e-01f, -6.31575286e-02f, 5.23577668e-02f,
  5.66862375e-02f, -1.19800176e-02f, -6.08695745e-02f, -1.39729649e-01f, -5.59122227e-02f, -3.42035815e-02f, -4.76050116e-02f, -4.95644547e-02f, -1.06931314e-01f, -2.56554652e-02f,
  9.43508446e-02f, -4.60595936e-02f, -1.03355780e-01f, -1.90865416e-02f, -1.80309433e-02f, -7.00887591e-02f, 6.71350434e-02f, 3.72354612e-02f, 4.95486334e-02f, -5.48725724e-02f,
  -3.24688330e-02f, 1.19927801e-01f, 5.37493117e-02f, -7.50945124e-04f, 4.13582288e-02f, 3.67238000e-02f, 2.21538940e-03f, 4.53482475e-03f, 1.61320288e-02f, 4.11241725e-02f,
  9.21214819e-02f, -1.10666104e-01f, -4.42643985e-02f, 1.04896143e-01f, 8.49687681e-03f, -2.38852911e-02f, -5.89862019e-02f, 3.92072946e-02f, 6.33553118e-02f, -2.46244436e-03f,
  -2.35932797e-01f, -4.85927835e-02f, -2.00371630e-02f, 1.25736464e-02f, -8.92577395e-02f, -1.40416786e-01f, -1.97585057e-02f, -7.85667598e-02f, -6.27412423e-02f, -7.75327608e-02f,
  -6.46359771e-02f, -7.63648823e-02f, 2.75310706e-02f, -2.73766369e-02f, -3.10376845e-03f, -8.75601918e-02f, -1.20439880e-01f, -1.44310826e-02f, -1.09471641e-01f, -1.75552741e-01f,
  -1.46029055e-01f, -2.22712532e-01f, -2.52950698e-01f, -2.41634220e-01f, -1.87928647e-01f, -1.01692460e-01f, -2.06530258e-01f, -1.54865712e-01f, -1.67381316e-01f, -1.56065404e-01f,
  -2.68981576e-01f, -4.11794409e-02f, 3.44430447e-01f, -1.38307750e-01f, -1.38666376e-01f, -5.15427589e-02f, -9.01294053e-02f, -1.82069570e-01f, -2.38713071e-01f, -7.65191913e-02f,
  -8.92035440e-02f, -1.77572787e-01f, -4.78422642e-02f, 3.31293158e-02f, 2.31256662e-03f, 1.90753043e-01f, 2.32468784e-01f, 5.53668849e-02f, -6.77869022e-02f, -1.03519619e-01f,
  -1.10704288e-01f, -2.52361476e-01f, -9.08918902e-02f, -1.38706341e-01f, -1.28053606e-01f, -8.48333463e-02f, 2.19487958e-02f, -9.09756646e-02f, 2.68308297e-02f, -2.15439890e-02f,
  5.04387915e-03f, -1.73226371e-02f, -1.57826588e-01f, -5.09919487e-02f, -9.55850258e-02f, 6.93276012e-03f, -1.06193304e-01f, -5.14136888e-02f, -1.19919248e-01f, -8.85386765e-02f,
  -1.64245218e-01f, -8.35333616e-02f, -1.30376875e-01f, -6.51261955e-02f, -1.37745500e-01f, -1.66401640e-02f, -4.10405472e-02f, -2.04217830e-03f, -5.93541414e-02f, 6.23079427e-02f,
  4.30081040e-02f, -3.13569456e-02f, -9.46580525e-03f, -6.34064004e-02f, 8.61731544e-02f, -1.75867882e-02f, -1.43929839e-01f, -2.97092926e-02f, 8.63729343e-02f, -4.06362601e-02f,
  6.37957156e-02f, 4.87774797e-02f, -2.85631344e-02f, -1.40595911e-02f, -1.53226629e-01f, -6.06050156e-02f, -2.44223094e-03f, -4.92695197e-02f, -1.72844306e-02f, -1.04236342e-01f,
  -3.41786705e-02f, -1.40442215e-02f, -6.70675561e-03f, 2.09993757e-02f, 3.42391171e-02f, 5.29814176e-02f, 3.67247388e-02f, -5.16774170e-02f, 3.37654389e-02f, -1.99577976e-02f,
  -4.83820327e-02f, 8.49555060e-02f, -9.59408097e-03f, -3.16024832e-02f, 1.05379172e-01f, 1.02289364e-01f, -3.37799527e-02f, -1.46057811e-02f, -2.64602434e-03f, -6.06307248e-03f,
  -4.19872403e-01f, 4.26531397e-02f, -1.47533044e-01f, -1.12862438e-01f, -4.04375838e-03f, -7.97647759e-02f, -1.07337065e-01f, -4.68822047e-02f, -1.49499774e-01f, -3.98647785e-02f,
  -2.95821037e-02f, -8.01974386e-02f, -8.20825547e-02f, -8.17327574e-02f, -1.70384154e-01f, -6.05227314e-02f, -2.03762203e-01f, -4.68586683e-02f, -1.58099867e-02f, -1.11637816e-01f,
  -3.60683575e-02f, -1.44950837e-01f, -1.75362766e-01f, -1.80053800e-01f, -1.20122194e-01f, -1.43261045e-01f, -1.17045417e-01f, -1.14899576e-01f, -1.06078856e-01f, -2.61397302e-01f,
  1.84905767e-01f, -2.85318732e-01f, -9.58617893e-04f, -3.24844658e-01f, 1.00396611e-01f, 1.84362561e-01f, 2.48272926e-01f, 8.04830939e-02f, -6.77173659e-02f, -1.32336229e-01f,
  -5.26189394e-02f, -1.81891292e-01f, -2.25164950e-01f, -1.68159455e-01f, -1.42750787e-02f, -6.27786890e-02f, -1.93490922e-01f, -1.37032464e-01f, 1.50622621e-01f, 1.11236624e-01f,
  -7.08619878e-02f, -1.97068274e-01f, -2.21290812e-01f, -2.61507958e-01f, -3.43213409e-01f, -2.06064165e-01f, -3.36864889e-01f, -3.00670534e-01f, -2.01419517e-01f, -4.65273142e-01f,
  -2.37042353e-01f, -1.22444190e-01f, -6.90898597e-02f, -2.49708429e-01f, -9.32497308e-02f, -9.84402075e-02f, -1.39696896e-01f, -2.03742296e-01f, -1.85896575e-01f, -1.42802238e-01f,
  -1.82311252e-01f, -1.00007735e-01f, -1.36677697e-01f, -1.89630479e-01f, -8.80720913e-02f, -7.23212212e-02f, -1.19928464e-01f, -9.63985100e-02f, -1.04019977e-01f, -8.10708925e-02f,
  -1.20706052e-01f, -1.46208808e-01f, -1.00902542e-02f, -1.44488305e-01f, -1.61437437e-01f, -1.16324365e-01f, -1.42060474e-01f, -9.03099030e-02f, -7.70960301e-02f, -1.25280321e-01f,
  7.68434927e-02f, 4.89071310e-02f, 1.35541543e-01f, 1.32355960e-02f, 9.69462469e-02f, 8.68406892e-02f, 1.87857319e-02f, 1.29006699e-01f, 1.33297727e-01f, 2.73327138e-02f,
  6.50368556e-02f, 1.47369608e-01f, 3.18724625e-02f, 1.48586512e-01f, 6.26752451e-02f, 4.77877147e-02f, 3.45926322e-02f, 1.17238440e-01f, 8.45492780e-02f, 1.20902002e-01f,
  1.06772259e-01f, 1.36081114e-01f, 8.24740753e-02f, 1.13610573e-01f, 1.63269430e-01f, 1.12774804e-01f, 8.49138349e-02f, 1.34610251e-01f, 1.28259823e-01f, 4.08961177e-02f,
  -2.82822371e-01f, 7.21241608e-02f, -2.82620102e-01f, -1.31576374e-01f, -1.22952402e-01f, -1.25110611e-01f, -1.90913036e-01f, -1.10154882e-01f, -8.54443833e-02f, -1.77667797e-01f,
  -4.77781370e-02f, -6.47951141e-02f, -1.90513313e-01f, -1.45363554e-01f, -1.28260314e-01f, -8.10029879e-02f, -1.45425916e-01f, -1.83885381e-01f, -1.68005720e-01f, -2.17120901e-01f,
  -1.95679858e-01f, 3.67600694e-02f, 2.76555065e-02f, -9.45554748e-02f, -1.12725496e-01f, -1.29550278e-01f, -7.55503252e-02f, -9.13923010e-02f, 2.29986794e-02f, -1.42422132e-02f,
  -3.93147498e-01f, -2.69164920e-01f, -1.70048535e-01f, -4.63587016e-01f, -2.32563376e-01f, 6.36679605e-02f, 1.01218402e-01f, -5.24515519e-03f, -2.33707666e-01f, -2.27034673e-01f,
  3.49674523e-02f, 1.21512309e-01f, -6.10575341e-02f, -5.25050983e-02f, -4.83079180e-02f, -6.91633075e-02f, -2.22140908e-01f, -2.14750290e-01f, 1.69909522e-02f, 1.53413536e-02f,
  -9.56542045e-02f, -2.86911845e-01f, -2.67110854e-01f, -1.11443691e-01f, -1.57874882e-01f, -8.68013278e-02f, -3.12723339e-01f, -2.29564294e-01f, -9.16882381e-02f, -2.45081604e-01f,
  8.66832137e-02f, -2.47468594e-02f, -1.05213588e-02f, -1.72542870e-01f, -1.10886447e-01f, -1.21972419e-01f, -5.58780991e-02f, -7.70142749e-02f, -1.51137244e-02f, 9.09814553e-04f,
  -3.83500755e-02f, 2.61237435e-02f, 1.20449057e-02f, -2.42828391e-02f, -5.58008347e-03f, 9.30984505e-03f, -4.02352735e-02f, -1.56342730e-01f, -7.07448274e-02f, -1.09796233e-01f,
  -1.39883295e-01f, -1.81205004e-01f, -2.03084111e-01f, -1.09123223e-01f, 5.51660080e-03f, -2.99424753e-02f, 3.87334032e-03f, 4.19972762e-02f, -2.48654969e-02f, -1.22535147e-01f,
  1.45104225e-03f, 8.60961974e-02f, 8.95133466e-02f, 3.86525877e-02f, 4.66999635e-02f, 1.16523631e-01f, 9.29427966e-02f, 1.00281164e-01f, 1.64662704e-01f, 1.54441655e-01f,
  1.17003672e-01f, 1.03011884e-01f, 1.78558320e-01f, 1.07336774e-01f, 7.61389881e-02f, 7.36941025e-02f, 5.96238114e-02f, 1.35054678e-01f, 7.09451512e-02f, 4.98705544e-02f,
  2.26320028e-02f, 1.56064704e-01f, 1.01171378e-02f, 1.15692072e-01f, 1.53804079e-01f, 1.10834286e-01f, 4.85175364e-02f, 1.53557926e-01f, 4.03279252e-02f, -1.73909310e-02f,
  -1.50236472e-01f, -2.86767501e-02f, -5.62596805e-02f, -2.10569538e-02f, -1.26119375e-01f, -1.63748469e-02f, 2.01195646e-02f, -1.14067286e-01f, -7.43031576e-02f, 1.05741143e-03f,
  -1.40215112e-02f, -4.83891815e-02f, 4.95347008e-02f, -2.12055389e-02f, -1.76941268e-02f, 1.81692559e-02f, -2.03188106e-01f, -1.24260180e-01f, -2.11599562e-02f, -9.92366672e-02f,
  -1.40393391e-01f, -2.64877945e-01f, -2.46716306e-01f, -2.36824509e-02f, -4.15857546e-02f, -9.99223292e-02f, -8.15484077e-02f, -1.21402435e-01f, -5.57235889e-02f, -2.72138000e-01f,
  -4.55366105e-01f, -1.09283641e-01f, 4.55122203e-01f, -3.08080792e-01f, 6.12020046e-02f, 4.63501424e-01f, 4.51303601e-01f, 2.57339507e-01f, -1.75984189e-01f, 4.45235446e-02f,
  -9.91420150e-02f, -2.59945303e-01f, -2.67361283e-01f, -5.34789562e-02f, 8.49441066e-02f, 2.50890672e-01f, 2.27246791e-01f, 2.04272904e-02f, 1.77011579e-01f, 4.89650331e-02f,
  -1.15861222e-01f, -1.71679050e-01f, -8.73074979e-02f, -5.27610593e-02f, -2.27776825e-01f, -1.36334792e-01f, 2.86370404e-02f, 8.03314149e-02f, 1.12300359e-01f, -2.09558696e-01f,
  3.84446084e-02f, 1.42474741e-01f, -1.57546252e-02f, -1.76173538e-01f, 9.20652691e-03f, -7.92497918e-02f, 5.39782457e-02f, -4.05166447e-02f, -5.63267693e-02f, -8.67160503e-04f,
  9.23190173e-03f, 5.74556936e-04f, -8.99037719e-02f, 4.05631438e-02f, 9.29663889e-03f, 1.41961994e-02f, 3.46733220e-02f, 2.53239814e-02f, -4.94422503e-02f, 4.35217097e-02f,
  -2.79894024e-02f, 7.96349421e-02f, 6.90729022e-02f, 9.60649773e-02f, 2.00642854e-01f, -6.90203235e-02f, 6.38198927e-02f, 9.60840937e-03f, 1.66677207e-01f, -1.15590654e-01f,
  6.54594302e-02f, 7.19356686e-02f, 8.36039558e-02f, 5.93676381e-02f, 5.77243380e-02f, 6.92503992e-03f, 6.53330460e-02f, -1.19724497e-02f, 4.86854874e-02f, -2.52991375e-02f,
  4.28928547e-02f, 1.23394746e-02f, 4.70411666e-02f, -6.11060448e-02f, 6.44058315e-03f, 7.12375995e-03f, 1.32630998e-02f, -4.87023517e-02f, -2.64356732e-02f, 5.13275713e-02f,
  -1.03815794e-02f, 1.09451460e-02f, 2.21772250e-02f, -3.86033803e-02f, 8.90084729e-02f, 3.01748980e-02f, 3.26241478e-02f, -3.65762739e-04f, -2.25900859e-03f, 2.15318035e-02f,
  -3.04165840e-01f, 1.72648281e-01f, -2.43642151e-01f, -4.65649925e-02f, -7.81000778e-02f, -3.14613152e-03f, -1.25380039e-01f, -6.45552054e-02f, -2.82738768e-02f, -1.02560986e-02f,
  3.99494693e-02f, -3.34878787e-02f, 2.65338365e-02f, -3.66907474e-03f, 2.91481195e-03f, 1.98740661e-02f, -9.91051570e-02f, -8.58184397e-02f, -2.10897326e-02f, 2.09985618e-02f,
  2.51454301e-02f, 5.40802255e-02f, -1.04854770e-01f, -7.78941065e-02f, -5.20289950e-02f, -1.75174117e-01f, 3.03101167e-02f, -5.24869524e-02f, 9.37924236e-02f, -1.91866919e-01f,
  -4.66429323e-01f, 4.69545946e-02f, 6.29654229e-02f, -4.01153602e-02f, 3.09304595e-01f, 2.22630948e-01f, 4.30112600e-01f, 2.16095135e-01f, 2.04125151e-01f, 1.26945928e-01f,
  -1.24409080e-01f, -2.72473663e-01f, -2.78386563e-01f, -1.61109522e-01f, -1.79057509e-01f, 1.77865192e-01f, 1.39366820e-01f, -5.92137799e-02f, -1.08488820e-01f, 1.64467003e-02f,
  1.62428785e-02f, -4.53290045e-02f, -2.09093124e-01f, 5.60880452e-02f, 1.52353227e-01f, -5.85399121e-02f, 1.12322785e-01f, 8.94421563e-02f, 1.97835878e-01f, 1.03540458e-02f,
  -1.67958513e-01f, 1.25739068e-01f, 2.27611009e-02f, 2.24841456e-03f, 2.42937338e-02f, -6.54248968e-02f, 4.85097207e-02f, 1.93756595e-02f, -3.21015976e-02f, 6.31466061e-02f,
  -3.19049209e-02f, -6.10806383e-02f, -8.76723304e-02f, 4.60730586e-03f, 1.00818403e-01f, 1.41551435e-01f, 7.47839212e-02f, 3.03602293e-02f, -4.51882146e-02f, 9.33520943e-02f,
  -2.19064355e-02f, 1.04967967e-01f, -6.81602350e-03f, 1.38060585e-01f, 2.35442538e-02f, -8.50344673e-02f, 4.47959788e-02f, 1.73069820e-01f, 1.08957671e-01f, 1.51759163e-01f,
  -3.79240699e-02f, -1.76770389e-02f, 8.09383299e-03f, -1.34649500e-01f, -3.47845517e-02f, -1.28173139e-02f, 4.54265289e-02f, -2.02644989e-02f, 6.01118605e-04f, 1.27803599e-02f,
  -9.52548683e-02f, -6.17387854e-02f, -6.28909543e-02f, 3.59917991e-03f, -9.18044150e-02f, -2.38605756e-02f, -6.28382191e-02f, -6.99434727e-02f, -7.75659308e-02f, -8.82505700e-02f,
  -6.27493933e-02f, 5.87846264e-02f, -7.75614157e-02f, 3.27661559e-02f, -6.25231117e-02f, 2.56624855e-02f, -6.75589144e-02f, -2.63828989e-02f, -2.82822717e-02f, 7.27882683e-02f,
  -1.81640554e-02f, -2.95855030e-02f, -5.64558096e-02f, 5.73409535e-02f, 5.61911315e-02f, 4.54997718e-02f, 4.14849557e-02f, -3.84893641e-02f, 1.24002704e-02f, 2.70804744e-02f,
  3.43165435e-02f, -1.01673016e-02f, 7.98364431e-02f, -1.13953371e-02f, 1.08412787e-01f, 6.26470745e-02f, 6.06497750e-02f, -7.10899234e-02f, 1.29644230e-01f, 7.27197081e-02f,
  7.70285875e-02f, 4.42703553e-02f, -9.08347815e-02f, 1.89924631e-02f, 1.59608141e-01f, 1.05342967e-02f, -4.74145869e-03f, 1.08103253e-01f, 1.46926828e-02f, 6.48760125e-02f,
  2.75498509e-01f, 2.37047166e-01f, -4.91988212e-01f, -1.62457287e-01f, -2.60182440e-01f, -7.00010136e-02f, 2.46866018e-01f, 2.38585651e-01f, 3.88314016e-02f, 7.05818161e-02f,
  -4.08085063e-02f, 1.62516329e-02f, -3.04738488e-02f, -4.65769991e-02f, 1.40262783e-01f, 8.10612589e-02f, -5.61437048e-02f, -1.74928114e-01f, 1.62202003e-03f, 4.76844562e-03f,
  9.02744569e-03f, 5.59402630e-02f, 1.33445427e-01f, 1.28035411e-01f, -5.53239472e-02f, -1.66665271e-01f, -1.44143954e-01f, -2.19422311e-01f, -1.41019579e-02f, -7.48230889e-02f,
  -3.35685253e-01f, 2.08939612e-03f, -6.13600947e-02f, 6.89782053e-02f, -1.88442141e-01f, 1.11719690e-01f, 6.11056434e-03f, -1.77598018e-02f, 2.16846708e-02f, 5.64243495e-02f,
  -8.39107260e-02f, 9.08128992e-02f, -7.78183388e-03f, -4.34637591e-02f, -4.61754715e-03f, 6.72126636e-02f, 7.91019425e-02f, 1.09666489e-01f, -4.14675847e-02f, 6.34157732e-02f,
  -4.14404199e-02f, -1.51449174e-01f, -1.09338835e-01f, -5.52581325e-02f, 8.86105001e-03f, -1.29288867e-01f, -6.28163218e-02f, 3.99961844e-02f, -6.03017397e-02f, 1.61753684e-01f,
  1.27957333e-02f, -7.36515075e-02f, 5.30855060e-02f, 1.01418778e-01f, 4.59440909e-02f, -6.94068745e-02f, 4.08394784e-02f, -3.45926657e-02f, -1.16252042e-02f, -1.33966273e-02f,
  1.03625481e-03f, 1.19773671e-02f, 1.38300434e-02f, 4.77213673e-02f, -5.31686246e-02f, 9.22491122e-03f, -1.28843170e-02f, 2.43833866e-02f, -3.49485576e-02f, 5.51223829e-02f,
  -6.32499456e-02f, -5.50867580e-02f, -3.04683782e-02f, 6.23712875e-02f, 6.04824722e-02f, 3.63460667e-02f, 4.97382917e-02f, 3.56338844e-02f, 4.95680033e-05f, 2.68138833e-02f,
  -5.89758530e-02f, 2.92609297e-02f, -6.28629848e-02f, 2.05299612e-02f, -5.67950755e-02f, -8.91962275e-02f, -3.01983561e-02f, 5.00741228e-02f, -2.75934525e-02f, -7.48312054e-03f,
  -4.71540242e-02f, 3.77052613e-02f, 8.63424130e-03f, -6.69593737e-02f, -7.95026869e-03f, 7.89509118e-02f, -9.52441711e-03f, -8.02832320e-02f, -5.59979379e-02f, -7.21061453e-02f,
  7.39447251e-02f, -6.33681333e-03f, 3.08515795e-04f, -3.52996439e-02f, -2.97079105e-02f, -1.11153036e-01f, -8.58145952e-02f, -5.64818569e-02f, -3.55378613e-02f, 7.73632824e-02f,
  2.20987320e-01f, 3.72787565e-01f, 1.77064762e-01f, -9.83197242e-02f, -7.22148791e-02f, -1.37888819e-01f, 2.11581931e-01f, 9.89249647e-02f, -1.92694571e-02f, 6.72941878e-02f,
  1.80431291e-01f, -9.09964517e-02f, -3.72124054e-02f, -2.03974053e-01f, -9.90027562e-02f, 2.09962711e-01f, 4.47926745e-02f, -2.43386030e-01f, -3.60100329e-01f, -1.77804127e-01f,
  -2.34897673e-01f, -2.92756013e-03f, -1.35645211e-01f, -1.12779714e-01f, 9.70639586e-02f, -7.43677393e-02f, 7.11236000e-02f, 9.63979065e-02f, -2.40989402e-02f, 4.84108832e-03f,
  9.61919576e-02f, 1.35262996e-01f, -2.67269313e-01f, -8.48424435e-02f, -8.93058702e-02f, 1.39976693e-02f, -4.27164547e-02f, 1.67054851e-02f, -1.39926344e-01f, -5.78538217e-02f,
  -1.37217358e-01f, -1.46355838e-01f, -1.39238909e-01f, -5.81168197e-03f, -6.82181939e-02f, 3.57573852e-02f, -1.03778832e-01f, 3.82126402e-03f, -8.60317126e-02f, 9.93671417e-02f,
  -1.99064277e-02f, -6.85046837e-02f, 7.84682781e-02f, -2.97736507e-02f, -3.45266201e-02f, -2.01065660e-01f, 7.10892454e-02f, 4.27266099e-02f, -2.49206927e-03f, 9.49710682e-02f,
  -8.00947696e-02f, 5.38383983e-02f, 3.00263520e-02f, 2.90939454e-02f, 1.16759755e-01f, 1.39758643e-02f, -1.36542432e-02f, 7.62020722e-02f, 2.86566950e-02f, 1.04527235e-01f,
  3.99681227e-03f, 2.20833365e-02f, 5.32908551e-02f, 1.44446701e-01f, -4.04523723e-02f, 3.38234268e-02f, 7.06750676e-02f, 3.90131585e-02f, 1.20754704e-01f, 4.29552235e-02f,
  6.95508122e-02f, 9.61969197e-02f, -1.78259593e-02f, 1.77894309e-02f, 8.56313482e-02f, 6.26701564e-02f, -2.25237906e-02f, 7.34273195e-02f, 2.75767874e-03f, 1.55606657e-01f,
  -1.42207935e-01f, -2.04784110e-01f, 8.70349538e-03f, -5.61933108e-02f, -1.03527963e-01f, -2.94469912e-02f, -5.45677394e-02f, -1.03020117e-01f, -2.49413922e-02f, -4.44382951e-02f,
  -8.89187828e-02f, 2.98149660e-02f, 1.49460137e-02f, -1.07574701e-01f, -1.00118399e-01f, -5.70791252e-02f, -5.60312234e-02f, -6.77583069e-02f, -6.86776778e-03f, -2.75161043e-02f,
  -7.23375753e-02f, -7.17515945e-02f, -7.65137672e-02f, -1.13206590e-02f, -5.72696142e-02f, -2.07347155e-01f, -1.03069562e-02f, -3.89362574e-02f, -1.02895319e-01f, 3.69139984e-02f,
  1.48986980e-01f, 2.03840345e-01f, 1.98894307e-01f, 1.06942222e-01f, 7.38224611e-02f, 3.44321318e-02f, 1.85230970e-01f, 1.48262307e-01f, 1.11149615e-02f, -3.80901955e-02f,
  3.68717201e-02f, -4.90814894e-02f, 2.48600412e-02f, 7.30257109e-02f, 1.03914343e-01f, 7.06604943e-02f, 1.88298360e-01f, 1.57594353e-01f, 1.04796879e-01f, 1.07060976e-01f,
  1.10943206e-01f, 2.16578320e-01f, 1.51415274e-01f, 1.24903701e-01f, 1.43065199e-01f, 8.91297087e-02f, 1.88852564e-01f, 2.85014898e-01f, 1.05639696e-01f, 1.70987546e-01f,
  8.83435737e-03f, 2.98317462e-01f, -2.02241726e-02f, 1.12638526e-01f, 5.71516268e-02f, 1.08473293e-01f, 1.57447636e-01f, 1.72941417e-01f, 9.29301977e-02f, 8.63480195e-02f,
  1.62853494e-01f, 1.37767404e-01f, 8.11981708e-02f, 1.97104290e-01f, 1.05753019e-01f, 1.39612213e-01f, 2.64072448e-01f, 7.80771822e-02f, 1.39238596e-01f, 8.20584148e-02f,
  9.40520391e-02f, 7.43904263e-02f, 1.44104347e-01f, 4.33730818e-02f, 1.96193174e-01f, 1.86895318e-02f, 5.11043034e-02f, 1.48532912e-01f, 2.01409161e-01f, 1.38534576e-01f,
  -2.15587407e-01f, -2.24287570e-01f, -5.10440506e-02f, -5.90115748e-02f, -1.98748097e-01f, -1.96317479e-01f, -5.58275208e-02f, -5.47051467e-02f, -1.52988270e-01f, -2.37863809e-01f,
  -1.88677967e-01f, -1.35693789e-01f, -2.12078810e-01f, -2.22423062e-01f, -2.46297583e-01f, -8.33031833e-02f, -1.05902053e-01f, -1.62176803e-01f, -1.88089103e-01f, -6.20244220e-02f,
  -1.72522038e-01f, -1.38586119e-01f, -7.00788870e-02f, -2.10485414e-01f, -2.50181407e-01f, -1.62377253e-01f, -1.09091379e-01f, -1.87936515e-01f, -1.41676590e-01f, -1.77724063e-01f,
  -5.66328987e-02f, 4.72573861e-02f, -3.11609525e-02f, 6.17259890e-02f, 1.63876951e-01f, 9.59856063e-02f, 3.45383659e-02f, 1.61141753e-01f, 1.14546090e-01f, 1.90015331e-01f,
  1.74025074e-01f, 6.72235787e-02f, 2.27342937e-02f, 1.13640971e-01f, 9.45609957e-02f, 9.09422040e-02f, 2.77233161e-02f, 6.32483065e-02f, 1.15099244e-01f, 4.83153611e-02f,
  8.62978175e-02f, 1.01304702e-01f, -7.02627674e-02f, -2.55293250e-02f, 3.63436714e-02f, 1.59019120e-02f, 7.61548802e-02f, 2.81829759e-02f, -4.16010730e-02f, -9.63018835e-03f,
  -2.48860553e-01f, 1.67869374e-01f, -4.67622168e-02f, -2.70279408e-01f, -2.73611635e-01f, -3.12606901e-01f, -1.28182575e-01f, -1.50117949e-01f, -2.10739195e-01f, -2.18216870e-02f,
  -1.93964750e-01f, -1.86318904e-01f, 1.12742539e-02f, 1.41454801e-01f, 2.04907760e-01f, 1.17814988e-01f, 1.11283287e-01f, 1.66640922e-01f, 7.30996132e-02f, -7.52527267e-02f,
  1.17424458e-01f, 8.79239291e-02f, 7.22899213e-02f, -3.18530649e-02f, -5.42093404e-02f, -3.51236574e-02f, 5.54267801e-02f, -1.97864007e-02f, 1.44913256e-01f, 1.86522827e-01f,
  5.47920875e-02f, -2.00322837e-01f, -5.23622222e-02f, -4.75342758e-02f, 8.21194146e-03f, 8.06388706e-02f, 7.13556260e-02f, 6.32619485e-02f, 3.02339485e-03f, 1.45417301e-03f,
  -5.89595065e-02f, -5.46368584e-02f, -1.00126639e-01f, -3.15763280e-02f, 5.36057204e-02f, 3.19074243e-02f, 1.36533916e-01f, 2.79010814e-02f, 2.32932270e-02f, 5.00466712e-02f,
  1.34112924e-01f, -7.34413639e-02f, -3.52817791e-04f, -1.23758875e-02f, 4.36006039e-02f, 6.01040944e-02f, -2.57446952e-02f, -5.57611845e-02f, 1.01753935e-01f, 2.37051025e-01f,
  2.65611503e-02f, 1.56292096e-02f, -4.60105762e-02f, -2.62806527e-02f, 4.38473746e-03f, -3.24856155e-02f, -2.49867160e-02f, -3.51505615e-02f, 9.23548788e-02f, -2.18990296e-02f,
  6.78437203e-03f, 1.04256244e-02f, -1.14241699e-02f, -2.21812096e-03f, 5.60398623e-02f, 1.62454182e-03f, 1.70282312e-02f, 8.97161961e-02f, 3.31883766e-02f, 2.99551561e-02f,
  -1.51219899e-02f, 1.86130833e-02f, 3.63187119e-03f, 1.04892869e-02f, 8.43512192e-02f, -5.03764786e-02f, -4.79267016e-02f, -1.80465654e-02f, 4.57093753e-02f, -3.87741067e-02f,
  3.55077386e-02f, -1.11181214e-01f, 2.38151457e-02f, 8.86643454e-02f, -5.28714135e-02f, -1.66093502e-02f, 4.87184227e-02f, -3.61071005e-02f, -1.17397659e-01f, 3.45197096e-02f,
  -9.00181849e-03f, -4.98833470e-02f, 4.51582074e-02f, 1.18855081e-01f, -8.24397430e-02f, -6.91007674e-02f, 4.94048037e-02f, -1.73078496e-02f, -4.90691885e-02f, 7.85960108e-02f,
  -1.29071306e-02f, -3.29227448e-02f, -1.12464696e-01f, -7.92694762e-02f, -3.36588686e-03f, -1.17415776e-02f, 1.02334842e-01f, -9.64087900e-03f, -1.73600819e-02f, 1.30247608e-01f,
  1.48001194e-01f, 9.53224376e-02f, 2.18526438e-01f, 2.79795915e-01f, 1.99556142e-01f, 9.64017659e-02f, 1.09704815e-01f, 9.24726054e-02f, 9.19970796e-02f, 1.86022237e-01f,
  1.17084466e-01f, 2.90432870e-02f, 1.57238990e-02f, 3.53006944e-02f, -4.49341163e-02f, 5.56272781e-03f, 1.55061483e-01f, 7.49996817e-03f, 4.54861782e-02f, 1.12456165e-01f,
  1.08182870e-01f, 2.44999334e-01f, 1.19972929e-01f, 1.58908859e-01f, 6.85598776e-02f, 1.17788635e-01f, 1.27613112e-01f, 1.94495887e-01f, 5.04070222e-02f, 8.81736651e-02f,
  6.12217896e-02f, 3.65027227e-02f, -9.36853960e-02f, 3.66772525e-02f, 2.03676466e-02f, -9.62199420e-02f, 3.99094969e-02f, -1.29134908e-01f, -2.45113485e-03f, 4.76842187e-03f,
  6.49335515e-03f, -1.32231591e-02f, 6.72228858e-02f, -4.53879777e-03f, 7.13518411e-02f, -9.35123637e-02f, -8.90715271e-02f, -7.90423304e-02f, 4.68095392e-02f, 3.57385576e-02f,
  5.30870855e-02f, 5.91219962e-02f, -1.34605020e-01f, -9.31282341e-02f, -7.61731295e-03f, -3.22212055e-02f, -7.53913482e-04f, -1.28990814e-01f, -7.02261776e-02f, -4.59748693e-02f,
  -8.81377310e-02f, -1.02744393e-01f, 4.14713956e-02f, -2.30206028e-02f, -3.47195752e-02f, 2.56947018e-02f, -4.23157662e-02f, 5.58759794e-02f, 3.57250832e-02f, 3.16785499e-02f,
  3.47800106e-02f, 1.37285807e-03f, -4.88682825e-04f, 5.56595474e-02f, 5.53002628e-03f, 9.21883732e-02f, 8.61257538e-02f, -4.56862003e-02f, -2.03133766e-02f, -4.71631251e-02f,
  5.09515814e-02f, 3.72893624e-02f, -1.34875942e-02f, -3.00967637e-02f, -4.91980650e-03f, 3.29279043e-02f, 1.24790817e-01f, -8.79225414e-03f, -2.29357295e-02f, 5.50199263e-02f,
  -1.74230278e-01f, 9.93818566e-02f, 8.65788478e-03f, -1.48480102e-01f, -1.12102494e-01f, -8.22261497e-02f, -7.54436990e-03f, -1.48445830e-01f, -6.58003464e-02f, -1.16175506e-03f,
  3.29507291e-02f, 2.16165241e-02f, -5.27386218e-02f, 1.43565927e-02f, -6.63470626e-02f, -2.72204056e-02f, -4.67980765e-02f, 5.02292104e-02f, 8.94053560e-03f, -2.08777804e-02f,
  -3.46109457e-02f, -7.61152729e-02f, -2.41999567e-01f, -1.81946561e-01f, -1.38961941e-01f, -1.62153803e-02f, -6.00475594e-02f, -1.85067922e-01f, -1.16428457e-01f, -2.23586902e-01f,
  1.94289669e-01f, -7.04398453e-02f, -1.11683376e-01f, 1.78856403e-02f, 2.24803519e-02f, -4.56794053e-02f, -2.10200012e-01f, -5.86004741e-02f, 4.39796597e-03f, -1.08221695e-01f,
  8.46602246e-02f, 3.87167037e-02f, -8.95970613e-02f, -1.03636563e-01f, -1.51177272e-01f, -2.08059967e-01f, -2.63007462e-01f, -6.98192194e-02f, -1.53912753e-01f, -4.07923907e-02f,
  1.62838325e-02f, -2.02215761e-02f, 7.39270747e-02f, 6.77937567e-02f, -1.15688391e-01f, 3.80711593e-02f, -7.55289719e-02f, 2.83651762e-02f, -1.03758328e-01f, -1.63549930e-01f,
  -3.82457435e-01f, 1.98031500e-01f, 3.11728586e-02f, 1.04907349e-01f, 7.01481625e-02f, 1.01316050e-01f, 1.54783130e-01f, 1.03217520e-01f, 1.94342837e-01f, 1.41548187e-01f,
  1.51775956e-01f, 9.26365182e-02f, 2.95647066e-02f, 8.74713734e-02f, 1.30545616e-01f, 1.47508174e-01f, 2.49971375e-02f, 1.08130008e-01f, 2.26264503e-02f, -3.12089343e-02f,
  1.01076819e-01f, 2.55241292e-04f, 4.99707162e-02f, 8.88296738e-02f, 5.31015396e-02f, 6.19773157e-02f, 9.39280093e-02f, 3.67117375e-02f, 1.90688267e-01f, 2.81634163e-02f,
  -1.47908226e-01f, -3.08402767e-03f, -3.45539041e-02f, 7.56678581e-02f, -2.74190642e-02f, 1.53625175e-01f, 6.67255931e-03f, 1.73445009e-02f, -1.53769022e-02f, 7.92963058e-02f,
  -1.81809254e-02f, 1.56593900e-02f, -2.70759799e-02f, -2.08349638e-02f, -2.15084143e-02f, -3.45525481e-02f, 6.85578808e-02f, -6.53183088e-04f, -6.45508384e-03f, 4.94148862e-03f,
  4.03349362e-02f, -6.57981168e-03f, 6.65226430e-02f, 2.43105441e-02f, 4.52551816e-04f, 1.16428724e-02f, 3.23577970e-02f, -1.17190806e-02f, 3.22354697e-02f, 1.19886041e-01f,
  3.41479667e-02f, 2.09233850e-01f, 2.06969175e-02f, 6.56871051e-02f, 2.84014735e-02f, 7.22678453e-02f, 6.99518025e-02f, 1.47896916e-01f, 1.60443485e-01f, 6.02026954e-02f,
  1.14391267e-01f, -2.15322599e-02f, 2.54665744e-02f, 6.20619692e-02f, 6.17042631e-02f, -4.84618545e-03f, -1.13220196e-02f, 1.06360838e-02f, 2.80772764e-02f, 8.94587338e-02f,
  3.16088460e-02f, 5.60561642e-02f, -1.03001177e-01f, 4.77303155e-02f, 4.51623239e-02f, 3.95975821e-02f, 9.32228640e-02f, -1.38587477e-02f, 1.28807174e-02f, -3.98822576e-02f,
  2.37163287e-02f, -2.61627790e-03f, 2.22158581e-01f, 1.29429415e-01f, -8.36560130e-03f, 1.67665213e-01f, 1.94851711e-01f, -8.51782446e-04f, -1.16117023e-01f, -2.08661705e-02f,
  -1.53366148e-01f, -2.11404964e-01f, -1.65519938e-01f, -1.22334182e-01f, -2.40187738e-02f, 1.70163810e-01f, 1.30204901e-01f, 3.95638607e-02f, 4.03363965e-02f, 1.33224996e-02f,
  7.80189224e-03f, 1.42134920e-01f, 1.15331963e-01f, -2.91880481e-02f, 8.02986100e-02f, 7.13359788e-02f, 1.20523840e-01f, 6.57516643e-02f, 4.13075201e-02f, 1.02181345e-01f,
  -5.69984540e-02f, 3.43512557e-02f, -3.89958620e-02f, -1.26175925e-01f, -1.09627679e-01f, -1.28998071e-01f, 4.73787077e-02f, 6.93987459e-02f, -7.66232684e-02f, 7.96248913e-02f,
  -2.82688327e-02f, -1.21913500e-01f, -6.81472942e-02f, -6.90447018e-02f, -5.99093772e-02f, -7.37410113e-02f, 3.73299941e-02f, -6.78110942e-02f, 1.59053970e-02f, 5.57854660e-02f,
  -1.17715485e-01f, 1.00058213e-01f, 1.74237043e-01f, 4.80842516e-02f, 1.30173028e-01f, 6.76814467e-02f, 1.37783751e-01f, 7.42540285e-02f, 6.13567159e-02f, 1.25986218e-01f,
  -5.70393801e-02f, -4.29443419e-02f, -1.18385211e-01f, -2.10365988e-02f, -3.10099646e-02f, -4.89342073e-03f, -4.72281352e-02f, -2.63299104e-02f, -4.50637657e-03f, -4.54798043e-02f,
  -6.36144960e-03f, -9.85640511e-02f, -1.47312209e-02f, 2.41078772e-02f, 5.25591429e-03f, 2.44514029e-02f, -2.06741709e-02f, 5.46736596e-03f, 1.38630360e-01f, -6.29834970e-03f,
  2.98062041e-02f, 1.14601001e-01f, -1.82422530e-02f, -1.46575700e-02f, -1.65302828e-02f, -6.63736556e-03f, -8.29240773e-03f, 2.80279014e-02f, 2.86692102e-02f, 1.49206473e-02f,
  -1.66271385e-02f, -3.78117412e-02f, 2.16310397e-02f, -1.23127429e-02f, -7.79390708e-03f, 1.74992555e-03f, 9.99869220e-03f, -1.49571691e-02f, -9.54073668e-02f, 5.10044396e-02f,
  5.67719415e-02f, 9.68789011e-02f, 8.22561979e-02f, 6.22075275e-02f, 5.95243014e-02f, 3.29378434e-02f, 6.83450475e-02f, 6.03810921e-02f, -1.65994894e-02f, 7.35141784e-02f,
  1.18464142e-01f, 6.29375353e-02f, 1.75514206e-01f, 6.78871293e-03f, 1.64128132e-02f, 3.29554416e-02f, 7.64928162e-02f, 9.50995088e-02f, 1.47643670e-01f, 1.88078001e-01f,
  -4.20026451e-01f, 1.09567799e-01f, 2.80081779e-01f, -2.67990947e-01f, -3.26903224e-01f, -1.99124396e-01f, -1.55088305e-01f, -5.68617731e-02f, -1.59905389e-01f, 1.72936376e-02f,
  -1.83425948e-01f, -2.63177067e-01f, -1.37539640e-01f, -7.09179090e-03f, -4.82277647e-02f, 1.19043760e-01f, 1.75539758e-02f, -7.47948810e-02f, -2.64740497e-01f, -2.47218788e-01f,
  -1.18235774e-01f, -1.58721834e-01f, -1.48275658e-01f, -2.78824437e-02f, 2.30513960e-02f, -6.87039942e-02f, 1.52315944e-01f, -5.18416613e-02f, -3.51894647e-02f, 9.14131328e-02f,
  1.92115769e-01f, -1.16586126e-01f, -7.60407448e-02f, -2.20831960e-01f, 3.17246020e-02f, -2.37377807e-02f, -2.73725111e-02f, 8.04339796e-02f, -1.03983134e-01f, -1.66726671e-02f,
  -1.62921593e-01f, -5.85987680e-02f, -1.00798607e-02f, -9.49719734e-03f, -1.35007039e-01f, -1.82173979e-02f, 1.65529307e-02f, 5.81750274e-02f, -6.42257407e-02f, 5.92679381e-02f,
  -7.75989890e-02f, -1.53573945e-01f, -1.85288921e-01f, -6.29816204e-02f, -1.41319567e-02f, -1.96142629e-01f, -9.15813372e-02f, -8.81115049e-02f, -3.79618220e-02f, 3.56070958e-02f,
  -2.80983951e-02f, 1.60352886e-01f, 5.04183136e-02f, 9.70358774e-02f, 5.10574728e-02f, 2.39092298e-02f, 1.00938082e-01f, 2.79697999e-02f, 1.66220181e-02f, 1.94665745e-01f,
  1.09353036e-01f, -1.27803748e-02f, 9.32381228e-02f, 2.93675885e-02f, 7.64689595e-02f, 4.31780741e-02f, 7.45522529e-02f, 1.90565065e-01f, 5.25133908e-02f, -6.17820024e-03f,
  1.31488085e-01f, 9.83391702e-02f, 6.25377968e-02f, 2.22180769e-01f, 4.85683233e-02f, -7.91993737e-03f, 1.22866131e-01f, 1.63239792e-01f, 4.86276187e-02f, 5.08411340e-02f,
  8.46372619e-02f, -2.36775920e-01f, -1.20904408e-01f, -4.91601191e-02f, -3.54101546e-02f, -1.13006666e-01f, -8.59981701e-02f, -1.21999137e-01f, -1.30547702e-01f, -1.49659991e-01f,
  -1.29790902e-01f, -5.53204827e-02f, -7.84123316e-02f, -3.74087016e-03f, -9.65244547e-02f, -1.71974361e-01f, -7.85071701e-02f, -2.13191494e-01f, -2.85125207e-02f, -3.57900001e-02f,
  -4.65588793e-02f, -1.91222548e-01f, -1.69377923e-01f, -3.40020545e-02f, -1.71390265e-01f, -1.80853888e-01f, -2.07540896e-02f, -1.60613149e-01f, -1.42527178e-01f, -9.31407809e-02f,
  1.93277970e-01f, -1.52600795e-01f, -3.95989537e-01f, 2.32446700e-01f, 1.50778189e-01f, -3.62055004e-01f, -4.31066126e-01f, -1.38002694e-01f, 1.74561679e-01f, 9.97463707e-03f,
  -7.90017396e-02f, 8.86904367e-04f, -2.26668250e-02f, -1.43820629e-01f, -1.83719665e-01f, -1.10973887e-01f, 7.37461224e-02f, -6.88671693e-02f, -3.00865471e-01f, -1.42077759e-01f,
  1.58592716e-01f, 8.23500380e-02f, 3.14498842e-02f, 6.52015805e-02f, 2.64422536e-01f, 1.38065785e-01f, 1.01801150e-01f, 2.93665603e-02f, 3.19105620e-03f, 2.30885774e-01f,
  -9.63499248e-02f, -5.47645018e-02f, -5.61766438e-02f, 1.01148084e-01f, 4.55025882e-02f, -3.20309252e-02f, 6.95934752e-04f, -4.57098112e-02f, 7.40538538e-02f, 5.75561747e-02f,
  2.71783378e-02f, -5.07558845e-02f, 4.06656116e-02f, 1.10807955e-01f, 9.08273384e-02f, 5.93597367e-02f, 6.57155663e-02f, 7.85080791e-02f, -1.13176227e-01f, -5.68040274e-02f,
  -3.35833319e-02f, -2.99189836e-02f, -1.27420321e-01f, -1.62232265e-01f, -3.81697081e-02f, -7.20798671e-02f, -3.14285010e-02f, -8.05304274e-02f, -8.18371177e-02f, 5.57336286e-02f,
  3.90305324e-03f, -2.29037590e-02f, 3.49518880e-02f, 3.95883396e-02f, 3.22181382e-03f, -2.97383498e-02f, 5.62881678e-02f, 2.13366225e-02f, -3.52715924e-02f, 3.05474363e-02f,
  -1.74670238e-02f, -4.72171083e-02f, -2.90223341e-02f, -6.16415665e-02f, 3.77696566e-02f, 7.71098584e-02f, -9.02774930e-02f, -8.60590935e-02f, -1.42216682e-02f, -2.31606588e-02f,
  -1.22259930e-02f, 6.91036135e-02f, 1.49980754e-01f, -3.38552110e-02f, -2.54841009e-03f, -5.44820055e-02f, 9.43123829e-03f, -8.21319669e-02f, -5.26738167e-02f, -2.18154062e-02f,
  8.86998475e-02f, -2.13404447e-01f, 5.20462729e-02f, 3.39971073e-02f, 1.13156818e-01f, 8.69486481e-02f, 5.86759634e-02f, -1.03101991e-02f, 7.32782036e-02f, -1.14965297e-01f,
  -9.80034098e-02f, 2.67790370e-02f, -9.87953022e-02f, -4.48791422e-02f, -8.15102085e-02f, 2.27105189e-02f, 1.62824333e-01f, 5.41572124e-02f, -5.45027554e-02f, 2.01979857e-02f,
  3.48707587e-02f, -1.42707853e-02f, -1.88203491e-02f, -4.43961471e-03f, 7.34357536e-02f, 3.47056217e-03f, -1.07417166e-01f, 2.35064439e-02f, -1.26868010e-01f, -4.34503518e-02f,
  3.15493613e-01f, -2.33364835e-01f, -3.14623386e-01f, -2.45430067e-01f, -1.66450322e-01f, -3.80992144e-02f, -2.38564059e-01f, -8.60213861e-02f, -2.58531934e-03f, -2.60648251e-01f,
  -9.73208770e-02f, 5.90122901e-02f, -3.07094529e-02f, -3.29847336e-02f, -3.07298154e-02f, -1.01321898e-01f, -2.00102955e-01f, 4.39597182e-02f, -3.32643068e-03f, -8.58621821e-02f,
  -1.55543998e-01f, -5.28217033e-02f, 1.57982484e-01f, 3.04746777e-02f, -8.45376998e-02f, -4.27797809e-02f, -2.00642064e-01f, -1.54397534e-02f, -4.17058542e-02f, -1.69177338e-01f,
  -4.32267725e-01f, 8.12399387e-02f, 9.47306082e-02f, 1.87948123e-01f, 6.46848381e-02f, 5.59763275e-02f, 9.31128263e-02f, 8.17500204e-02f, 1.62401676e-01f, 4.28887904e-02f,
  7.15340301e-02f, 6.89253137e-02f, -3.18491608e-02f, -3.81836146e-02f, -5.67143634e-02f, 7.36766309e-02f, 7.07151145e-02f, 2.41658129e-02f, 6.11028485e-02f, -5.01591188e-04f,
  4.39984500e-02f, -4.56617549e-02f, 8.94198418e-02f, 3.45524698e-02f, -1.25606498e-02f, 1.34803087e-01f, 2.86866222e-02f, 6.31291606e-03f, 4.02223431e-02f, -1.26305893e-01f,
  -3.81771512e-02f, -6.55512586e-02f, -2.77988948e-02f, 5.37667908e-02f, 6.08647242e-02f, 5.76985180e-02f, -9.12289545e-02f, -3.12180836e-02f, -8.14716965e-02f, 8.69418532e-02f,
  -1.83853079e-02f, -4.75160107e-02f, -1.47605762e-01f, -3.35147008e-02f, -1.37429997e-01f, 1.53574347e-02f, -1.07197126e-03f, -4.24084477e-02f, 7.91749507e-02f, 7.40794465e-02f,
  6.47906512e-02f, 3.34287621e-02f, -1.06658027e-01f, -1.88007131e-02f, -2.78799981e-02f, -1.74015030e-01f, -7.85963088e-02f, -9.31424275e-03f, -3.57199013e-02f, 4.38845307e-02f,
  -1.27605185e-01f, 2.17008591e-01f, -6.51083440e-02f, 1.22801624e-01f, -6.70519695e-02f, 7.82910883e-02f, -2.71703191e-02f, 8.20987001e-02f, 2.83709858e-02f, -5.68430349e-02f,
  5.21963164e-02f, -4.19494994e-02f, -2.76665520e-02f, -3.26191671e-02f, -1.58978496e-02f, 7.63530955e-02f, 3.81071381e-02f, 2.45834179e-02f, 4.54159454e-02f, -9.05800052e-03f,
  3.49372551e-02f, -5.75675443e-02f, 5.12244664e-02f, 6.28114492e-02f, 8.75059739e-02f, 7.23870695e-02f, -1.06691234e-01f, -1.19653847e-02f, 1.01394460e-01f, -9.54506919e-02f,
  3.05014908e-01f, 1.01499081e-01f, -3.64600234e-02f, 2.14655846e-02f, 3.56541276e-02f, -5.22074252e-02f, -1.47349149e-01f, 8.93087536e-02f, 1.31751448e-02f, -1.65685248e-02f,
  2.20021293e-01f, 1.14511929e-01f, 6.49351552e-02f, 4.75409441e-02f, -5.21449931e-03f, -2.03001544e-01f, -1.41491666e-01f, -1.85411274e-01f, -7.41273686e-02f, -4.99860495e-02f,
  6.12723343e-02f, -4.48690765e-02f, -9.26097333e-02f, -1.03723362e-01f, -6.12769835e-02f, -1.16896413e-01f, -2.13971406e-01f, -5.86515963e-02f, -2.41680056e-01f, -3.47754747e-01f,
  4.43435162e-02f, 1.75100893e-01f, 6.75867125e-02f, 5.22236824e-02f, -6.43167943e-02f, -3.90504077e-02f, 2.13281661e-02f, 7.75637105e-02f, 5.39998487e-02f, 6.90167397e-02f,
  -2.51674876e-02f, 9.20869932e-02f, 9.47877541e-02f, -6.20818846e-02f, 5.30460142e-02f, -4.00002599e-02f, 5.00849588e-03f, 2.17229724e-02f, 6.72263280e-02f, 5.80513626e-02f,
  1.80156007e-02f, -3.56245488e-02f, -1.16575263e-01f, 5.62821962e-02f, -6.91846535e-02f, -6.01267405e-02f, 4.04466875e-03f, -8.62976462e-02f, 2.41001602e-02f, -1.60762474e-01f,
  -6.90032616e-02f, 2.11993083e-02f, -1.55655062e-02f, 6.19036891e-02f, 5.21682110e-03f, 2.78005116e-02f, 4.49512200e-03f, 4.11982611e-02f, -8.32629129e-02f, -5.26364297e-02f,
  1.76764540e-02f, -1.72720570e-02f, -1.70289092e-02f, -9.10949484e-02f, -1.01063289e-02f, -8.38920698e-02f, -1.91813409e-02f, -6.79674223e-02f, -8.19518939e-02f, -7.80399796e-03f,
  -2.76358109e-02f, -2.00843196e-02f, -2.45066136e-02f, -1.52865555e-02f, 6.98198273e-04f, -2.35325098e-02f, -8.27597268e-03f, 1.08748011e-01f, 3.23796123e-02f, -6.09699078e-03f,
  2.18973178e-02f, 3.72129912e-03f, 1.74482819e-02f, 1.74321290e-02f, -3.07028573e-02f, -3.41750495e-02f, -4.02946845e-02f, 5.44568598e-02f, 5.54190055e-02f, -4.68327664e-02f,
  6.56537041e-02f, -3.55660822e-03f, 1.10349029e-01f, 5.76106785e-03f, 1.33294463e-02f, -1.70931369e-02f, 5.89438230e-02f, -5.00733703e-02f, -7.53702819e-02f, 8.05650055e-02f,
  3.00181732e-02f, -1.49024919e-01f, -3.40153649e-02f, -1.22793727e-01f, 3.19718271e-02f, -7.30069056e-02f, -7.28243887e-02f, -9.30815861e-02f, -1.47403911e-01f, -1.66594744e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.63435972e-01f, -4.09399033e-01f, 7.33930767e-02f, 3.44145358e-01f, 4.30001557e-01f, 3.85549396e-01f, 1.18079178e-01f, 1.34782314e-01f, 3.86263967e-01f, 2.11428836e-01f,
  1.73249133e-02f, 3.69844407e-01f, 2.59673595e-01f, 3.30328345e-01f, 2.34617203e-01f, 4.22498614e-01f, 5.31564593e-01f, 3.16306531e-01f, 1.39145702e-01f, 2.52399713e-01f,
  1.37059808e-01f, -5.86242368e-03f, -1.43260583e-01f, 1.05562523e-01f, 1.79121390e-01f, 3.91968876e-01f, 2.28687838e-01f, 3.49930711e-02f, 1.50323689e-01f, 2.84003437e-01f,
  8.68559629e-02f, -3.29857498e-01f, 1.92307413e-01f, -1.13660023e-01f, -1.92487925e-01f, -1.68931395e-01f, -1.22119617e-02f, -1.36854261e-01f, -1.83611840e-01f, 4.65716198e-02f,
  -2.03179717e-02f, -1.60796225e-01f, -3.23683284e-02f, -6.46290332e-02f, -1.28713787e-01f, -1.86181977e-01f, -9.55045745e-02f, -2.43895110e-02f, 1.03658803e-01f, -7.16013089e-02f,
  -3.52448523e-02f, 1.51725888e-01f, 8.91884416e-02f, 1.76612750e-01f, 1.15966998e-01f, 1.45564690e-01f, -1.20873779e-01f, -3.57535407e-02f, 8.76077171e-03f, -6.15026914e-02f,
  2.92747587e-01f, 1.60535842e-01f, 2.21412078e-01f, 6.10219911e-02f, 5.39027452e-02f, 1.18457086e-01f, 1.63957536e-01f, 1.42481461e-01f, 1.02535263e-01f, 4.53562140e-02f,
  1.54492408e-01f, 2.33048230e-01f, 2.48439740e-02f, -2.87479330e-02f, 1.40280858e-01f, 5.83480112e-03f, 5.74480519e-02f, 4.95214830e-04f, -4.21507284e-02f, -1.14151455e-01f,
  5.88457696e-02f, 6.59250766e-02f, -1.93381086e-01f, 3.21386935e-04f, -6.34222627e-02f, 1.90857291e-01f, 6.40580580e-02f, 6.53775111e-02f, 8.78612697e-02f, 2.37656204e-04f,
  1.73163950e-01f, 2.34471291e-01f, 1.86940446e-01f, -3.38402577e-04f, -1.59102947e-01f, -1.14209868e-01f, 2.03034636e-02f, -7.12241307e-02f, -1.09042145e-01f, 9.82473418e-03f,
  -5.27273975e-02f, -2.39664316e-01f, -2.49418482e-01f, -1.47215948e-02f, 1.19729377e-02f, -4.49632928e-02f, -1.55389965e-01f, 3.09928656e-02f, 9.01022702e-02f, 2.34164707e-02f,
  3.47038847e-03f, 2.30698586e-01f, 3.20122629e-01f, 1.88365102e-01f, 1.60508916e-01f, 2.51417279e-01f, 1.09467134e-01f, 4.18265201e-02f, 9.24263522e-02f, -4.95120250e-02f,
  6.21798992e-01f, 7.37579584e-01f, 1.19763918e-01f, 3.37568492e-01f, 1.50583312e-01f, 3.25705498e-01f, 5.52722156e-01f, 4.70651090e-01f, 2.67022848e-01f, 2.38659039e-01f,
  2.89924681e-01f, 3.08494091e-01f, 3.19889605e-01f, 3.12835038e-01f, 3.12998235e-01f, 3.63710761e-01f, 1.73677817e-01f, 9.96229127e-02f, -3.26781906e-02f, 2.10179836e-01f,
  1.82011053e-01f, 2.69217938e-01f, 1.14878669e-01f, 1.46195158e-01f, 2.38161102e-01f, 1.55735463e-01f, 1.03367478e-01f, 2.62555361e-01f, 2.25882933e-01f, 1.97157532e-01f,
  -3.12101901e-01f, 1.81556910e-01f, -1.51308164e-01f, -9.71938446e-02f, -1.43163800e-01f, 5.05581163e-02f, -6.01636022e-02f, -1.67109475e-01f, -1.08078785e-01f, -9.04567316e-02f,
  -5.37237674e-02f, -2.87459157e-02f, -7.63905048e-02f, -8.43841136e-02f, -1.75506577e-01f, -1.25344232e-01f, -1.00557879e-01f, -5.65266721e-02f, 1.93635393e-02f, -5.29414639e-02f,
  -3.31399031e-02f, -3.08453012e-02f, -1.71158135e-01f, -8.01891908e-02f, 6.18116744e-02f, -1.83756262e-01f, -1.17627524e-01f, -5.48726097e-02f, -1.22957662e-01f, -1.15850498e-03f,
  3.70694958e-02f, 1.66985258e-01f, -7.46337473e-02f, -3.19089480e-02f, 1.22014908e-02f, -7.69136474e-02f, -1.47032753e-01f, -3.96485887e-02f, 8.23431984e-02f, -1.86517444e-02f,
  -2.06572443e-01f, -1.34264797e-01f, -3.87655981e-02f, -1.44648507e-01f, -7.30895177e-02f, -1.17403559e-01f, -7.37397075e-02f, -4.06104559e-03f, -1.57581165e-01f, -1.33622617e-01f,
  -5.10899834e-02f, -4.80884984e-02f, -1.71009079e-01f, -7.08612502e-02f, -1.10277295e-01f, -4.45684008e-02f, -3.89191210e-02f, -9.81771573e-02f, -4.18309607e-02f, 5.92430122e-02f,
  2.14097351e-02f, -1.94577664e-01f, -4.70526405e-02f, 1.98852628e-01f, -2.62144860e-02f, -9.90220811e-03f, 7.48263821e-02f, -9.22117680e-02f, -1.21760406e-01f, -4.50096317e-02f,
  -1.92147736e-02f, -1.05844028e-01f, 8.27605501e-02f, -3.00873332e-02f, -1.55280888e-01f, -7.44537041e-02f, 9.43411440e-02f, 1.69495121e-01f, 1.40436618e-02f, -3.31824422e-02f,
  5.53875193e-02f, -3.70594971e-02f, -1.29698649e-01f, 1.97259430e-02f, -1.99734000e-03f, -1.12008844e-02f, -1.56614259e-01f, -3.89883183e-02f, -1.61090493e-01f, -5.38757071e-02f,
  8.09691608e-01f, -7.65878260e-01f, 2.19119206e-01f, 3.41375947e-01f, 4.03812766e-01f, 4.20542568e-01f, 1.97076559e-01f, 2.29701802e-01f, 1.91621661e-01f, -1.55759091e-02f,
  -1.36108235e-01f, -6.49845526e-02f, -8.82563367e-03f, -1.07328489e-01f, -1.33001134e-01f, -1.55591071e-01f, 1.23003140e-01f, 1.11660965e-01f, 2.25858271e-01f, -1.16938883e-02f,
  -1.84138611e-01f, -9.11051258e-02f, -5.98600581e-02f, -1.77562051e-02f, -2.84194797e-01f, -5.28120883e-02f, -6.36849254e-02f, -1.99263528e-01f, -2.58707225e-01f, -4.36083108e-01f,
  -6.02130890e-01f, -1.76217668e-02f, 1.25372171e-01f, -1.53667390e-01f, -1.50644094e-01f, -1.76938966e-01f, -1.34852156e-02f, -1.03744581e-01f, -1.23989128e-01f, -1.43245935e-01f,
  -9.50347353e-03f, 1.72654856e-02f, -6.46005273e-02f, -7.44648352e-02f, 8.21774229e-02f, -4.74123955e-02f, -1.64252818e-01f, -8.77466202e-02f, -1.63271546e-01f, -1.88356489e-01f,
  -2.67773747e-01f, 3.09165362e-02f, -4.84330729e-02f, -7.19175562e-02f, -9.65396408e-03f, 5.46307564e-02f, -1.05991140e-01f, 4.87629771e-02f, -3.86959761e-02f, 4.30678278e-02f,
  -2.04895571e-01f, -3.40401858e-01f, -1.30761951e-01f, 9.46946219e-02f, 1.11379951e-01f, 7.93349966e-02f, -2.67389938e-02f, 1.41128385e-02f, 1.20202089e-02f, -8.79410356e-02f,
  -7.58203343e-02f, 7.32716396e-02f, 4.27821130e-02f, 8.34416598e-03f, -1.46503434e-01f, -8.15849751e-02f, -1.29179314e-01f, -2.26155445e-01f, -1.09168082e-01f, -6.40871376e-02f,
  1.39742475e-02f, -1.93009749e-01f, -2.18792871e-01f, -2.79788345e-01f, -1.53971121e-01f, -9.30558965e-02f, -1.65587440e-01f, -1.80134118e-01f, 5.81627786e-02f, -1.61594838e-01f,
  -6.06327295e-01f, 4.40536767e-01f, 6.34653568e-02f, -8.37589726e-02f, 3.04624084e-02f, -1.12359032e-01f, -1.69755276e-02f, 4.28753458e-02f, 1.55646047e-02f, 2.95689180e-02f,
  1.89465154e-02f, 3.21136937e-02f, -4.94734757e-02f, -6.51389584e-02f, 2.85668105e-01f, 2.77837571e-02f, -1.30648673e-01f, 1.31684825e-01f, -1.70941919e-01f, -1.78875774e-01f,
  -2.42166996e-01f, 7.58023337e-02f, 1.53493777e-01f, 1.84857666e-01f, 2.22707167e-01f, 1.97734550e-01f, -4.42996994e-02f, 1.12129070e-01f, 2.26695389e-01f, 1.30612001e-01f,
  9.25277829e-01f, 5.24385571e-01f, -1.63382798e-01f, 3.52414072e-01f, -3.08551490e-01f, -3.36042851e-01f, -2.87082136e-01f, 2.06659466e-01f, 2.18204156e-01f, 2.22401232e-01f,
  1.22331843e-01f, 1.46756470e-01f, 7.83112943e-02f, -2.04925588e-03f, 5.34871407e-02f, -3.41525972e-02f, 7.10425824e-02f, 1.47056818e-01f, -1.78884957e-02f, -8.96014795e-02f,
  -9.60135758e-02f, 1.83189914e-01f, 2.08602399e-01f, 1.71479836e-01f, 1.18597902e-01f, -3.16859633e-02f, 4.79421355e-02f, -2.04723269e-01f, -3.19285065e-01f, -5.17616235e-02f,
  -3.88835907e-01f, -5.98258898e-02f, 1.80236340e-01f, 2.73764908e-01f, 6.14024550e-02f, 3.63043010e-01f, -1.44523662e-02f, 2.26551414e-01f, 1.46508127e-01f, 3.01563516e-02f,
  2.07291916e-02f, 6.82575032e-02f, 4.08745147e-02f, 1.47554353e-02f, 2.93390322e-02f, 1.28840515e-02f, 8.92667249e-02f, -7.76250213e-02f, -1.10979468e-01f, -1.15392648e-01f,
  -1.52822677e-02f, -1.09003931e-01f, -2.35203534e-01f, -1.03427269e-01f, -4.46415208e-02f, -1.25601754e-01f, -6.25510514e-02f, -9.44213346e-02f, 2.70241853e-02f, 8.39829445e-02f,
  -1.05703056e-01f, 1.18610084e-01f, -1.42141506e-01f, -7.71518871e-02f, -1.26229540e-01f, 5.13916686e-02f, -1.08508602e-01f, -7.96871707e-02f, -1.99002754e-02f, 1.79872498e-01f,
  3.88147682e-02f, -1.51643634e-01f, -1.97893173e-01f, 1.28549889e-01f, 1.67293146e-01f, -2.69827489e-02f, -1.18276291e-01f, 2.66888570e-02f, -1.91550389e-01f, -9.96976569e-02f,
  -1.29047304e-01f, 2.63825171e-02f, 1.03927195e-01f, -4.75876778e-02f, 3.95031795e-02f, 4.15409282e-02f, 1.05738923e-01f, -4.58677299e-02f, 8.30511898e-02f, 2.95136217e-02f,
  -2.16854960e-01f, -3.83736074e-01f, -3.52581441e-02f, -6.82738721e-02f, -1.22533195e-01f, 1.68433219e-01f, -2.22541705e-01f, -1.30628765e-01f, 7.35542178e-02f, -1.96927011e-01f,
  -8.03589225e-02f, 1.00963689e-01f, -5.39062023e-02f, -8.95095468e-02f, 9.74316373e-02f, 2.84673937e-04f, -2.03160476e-02f, 4.86031286e-02f, -5.17181531e-02f, 8.21583048e-02f,
  2.13536486e-01f, 1.53273463e-01f, -2.39278190e-02f, 1.00094289e-01f, -7.07418248e-02f, 1.35395611e-02f, 2.71269921e-02f, 6.02640361e-02f, -5.06364629e-02f, 2.83104658e-01f,
  -9.00427938e-01f, 5.56739271e-01f, 6.86112881e-01f, -2.54746586e-01f, 9.65870842e-02f, -3.83948721e-03f, 1.06036216e-01f, -1.71511263e-01f, -7.23914877e-02f, 1.82947457e-01f,
  -1.20788785e-02f, -3.44511002e-01f, 1.89166725e-01f, 6.24945089e-02f, -4.73954864e-02f, 5.26057899e-01f, 4.89926189e-01f, 2.71626338e-02f, -5.35885811e-01f, -6.86897755e-01f,
  -3.22515965e-01f, -3.98740709e-01f, -5.13088584e-01f, -1.58412635e-01f, 2.30013445e-01f, -5.11665568e-02f, 5.88538289e-01f, 1.72038808e-01f, 1.74140304e-01f, 6.72354221e-01f,
  3.07994839e-02f, 2.04956099e-01f, 5.14380559e-02f, -6.87097907e-02f, 1.32632524e-01f, -1.74204186e-02f, 2.67097559e-02f, 2.37183601e-01f, 1.98461965e-01f, 1.75652787e-01f,
  8.26114640e-02f, 2.46496662e-01f, 1.11242175e-01f, 1.47337541e-01f, -7.00805262e-02f, -2.23757029e-01f, 2.27561086e-01f, 7.82377943e-02f, 8.39620382e-02f, -5.96497320e-02f,
  1.42488018e-01f, -4.19131339e-01f, -1.45386308e-01f, 1.01580992e-01f, 3.01198781e-01f, -4.80137914e-01f, -1.40923373e-02f, -2.42559418e-01f, -2.90844172e-01f, -6.96867108e-02f,
  -1.43918678e-01f, 1.26416728e-01f, 1.00529127e-01f, 1.98398754e-01f, 1.00093139e-02f, 2.17106625e-01f, 2.09778339e-01f, -4.18730825e-03f, -9.34785046e-03f, 2.34545693e-02f,
  1.84029583e-02f, -2.73121685e-01f, 9.38549265e-02f, 2.07563162e-01f, 9.62964608e-04f, -2.49595065e-02f, -2.38054059e-02f, -6.58731759e-02f, -3.04447077e-02f, 1.58161089e-01f,
  -7.81502351e-02f, 1.37763340e-02f, -1.23643786e-01f, -7.11911619e-02f, 2.37244323e-01f, 5.61230183e-02f, -5.58976345e-02f, -3.37625332e-02f, -8.21182132e-02f, -3.45000885e-02f,
  -1.73855230e-01f, 2.56229699e-01f, -1.35372402e-02f, 7.77352080e-02f, 1.60543635e-01f, 2.21426021e-02f, -2.69272365e-02f, -8.75707939e-02f, 6.17005229e-02f, -2.45166406e-01f,
  -1.27567321e-01f, 5.31819239e-02f, 9.97865275e-02f, 5.80487251e-02f, -3.32090139e-01f, -5.28458543e-02f, -1.55956298e-01f, -1.91713750e-01f, -1.81534186e-01f, -3.05927079e-02f,
  2.68545374e-02f, -6.57322884e-01f, -6.98895574e-01f, -2.95935035e-01f, -4.51181114e-01f, -6.66009128e-01f, -3.78061146e-01f, -4.38610017e-01f, -3.95125180e-01f, -6.28133774e-01f,
  9.80976403e-01f, 3.51355933e-02f, 1.55290350e-01f, 1.41295581e-03f, -3.26369077e-01f, -2.49159098e-01f, -3.34890515e-01f, -1.46155283e-01f, -6.23229742e-02f, -8.15874804e-03f,
  6.21316722e-03f, 2.50107907e-02f, 2.40997467e-02f, 5.40243015e-02f, 1.98363066e-01f, -4.37097400e-02f, -1.95688650e-01f, 2.75860161e-01f, 2.20425367e-01f, -2.14664601e-02f,
  -1.21978745e-01f, -2.40137596e-02f, 2.12700173e-01f, 1.10212550e-01f, -9.40864831e-02f, 2.07108464e-02f, -8.93274248e-02f, -2.08596721e-01f, -1.61701947e-01f, 2.87944581e-02f,
  7.94553161e-02f, 3.23177665e-01f, -1.76884495e-02f, 7.41470456e-02f, 1.25829294e-01f, 8.30375999e-02f, 1.85054898e-01f, -6.76746741e-02f, -1.24915637e-01f, -9.72173288e-02f,
  -5.60830231e-04f, 1.16156787e-01f, 4.41435575e-02f, -1.17987499e-01f, -1.50306240e-01f, 1.53285526e-02f, 2.27212645e-02f, -5.10057434e-02f, 3.21791433e-02f, -7.61508569e-02f,
  5.09561673e-02f, -6.54416298e-03f, -1.60655767e-01f, -1.63372472e-01f, 1.12504579e-01f, 1.68397948e-02f, -9.47098657e-02f, -1.54645033e-02f, 8.68859515e-02f, 1.51102683e-02f,
  -2.09446996e-01f, 4.12827358e-02f, 1.61066160e-01f, -1.71149839e-02f, 4.86861765e-02f, -4.69442867e-02f, -1.08649209e-01f, -2.00168833e-01f, 1.39636695e-01f, 7.03942105e-02f,
  -2.41309494e-01f, -4.61636521e-02f, -5.82097806e-02f, -5.78416921e-02f, 1.64165750e-01f, -6.16360679e-02f, 1.65615547e-02f, 8.85409266e-02f, 1.15276575e-01f, 1.16355792e-01f,
  9.72118378e-02f, -4.91409935e-02f, -6.06763959e-02f, -1.64327561e-03f, -1.16779104e-01f, -3.82824726e-02f, -7.85613619e-03f, -9.58575460e-04f, -8.26413259e-02f, -5.05108647e-02f,
  -3.17265093e-01f, 5.24376512e-01f, 1.51116461e-01f, 2.69806117e-01f, 5.71515672e-02f, 6.48062751e-02f, 3.44753712e-01f, 2.87515111e-03f, -1.23494379e-01f, -1.02096761e-03f,
  -4.69344035e-02f, 1.60875946e-01f, 9.09164771e-02f, 6.07733289e-03f, -2.51715966e-02f, 8.25726017e-02f, 5.75932004e-02f, 7.22520128e-02f, 4.32187244e-02f, -1.09740958e-01f,
  -8.74207392e-02f, -1.70418844e-01f, -2.30181776e-02f, -1.19609289e-01f, 7.89505895e-03f, 7.60199875e-02f, -8.23504180e-02f, -1.42851863e-02f, -5.16323484e-02f, -1.98402435e-01f,
  6.26960456e-01f, -7.42491521e-03f, 2.68870831e-01f, 3.10701162e-01f, -3.09930831e-01f, -7.87621975e-01f, -1.08713269e+00f, -4.46949035e-01f, 1.27149597e-01f, -4.39669564e-02f,
  -2.93045461e-01f, -5.12150005e-02f, 1.79900572e-01f, -9.93902832e-02f, -3.23932916e-01f, -4.21504267e-02f, 2.22797319e-01f, 3.00624520e-02f, -5.26664972e-01f, -5.98281980e-01f,
  -2.16066152e-01f, 7.62252286e-02f, 2.15052471e-01f, 7.77662033e-03f, 5.51446021e-01f, 1.64138228e-01f, 4.53253001e-01f, 3.67285013e-01f, 4.38868674e-03f, 6.71152651e-01f,
  4.06660497e-01f, 3.92371088e-01f, -3.74826282e-01f, 1.18495539e-01f, 2.10230827e-01f, 6.77237958e-02f, -4.75448146e-02f, 4.80449140e-01f, -9.30007994e-02f, 1.09654497e-02f,
  -1.01079149e-02f, -1.18767262e-01f, 6.53346255e-02f, -1.40373677e-01f, -9.74169448e-02f, -3.20790142e-01f, 1.22528866e-01f, -3.66430245e-02f, 2.08187237e-01f, -1.48664054e-03f,
  -2.32774794e-01f, 1.31170545e-02f, -5.75485565e-02f, -3.07393074e-01f, 4.26158346e-02f, 2.47491132e-02f, -1.46080106e-01f, -2.43407264e-02f, -2.17254922e-01f, 4.59299982e-01f,
  -8.71732906e-02f, 3.48510668e-02f, -1.38396807e-02f, 4.95365523e-02f, -1.70764089e-01f, 7.55157992e-02f, 2.63282657e-02f, -5.44539616e-02f, 3.77825014e-02f, -4.12888527e-02f,
  -2.11401671e-01f, -4.44859527e-02f, 4.44088280e-02f, -1.05037428e-01f, -5.06279022e-02f, 8.15352499e-02f, -1.64145231e-01f, 8.06089863e-03f, -6.29120469e-02f, -3.83286700e-02f,
  -4.79211435e-02f, 5.01859598e-02f, 2.48776719e-01f, 1.85209103e-02f, 6.07972741e-02f, 7.67855495e-02f, 2.58861423e-01f, -8.21940508e-03f, 1.22105733e-01f, 4.14874554e-02f,
  -1.49062097e-01f, -6.40392601e-01f, 1.24554098e-01f, 2.01271176e-02f, 7.31145814e-02f, 3.00848354e-02f, -5.40520027e-02f, -2.53138334e-01f, 2.09518950e-02f, -3.27451587e-01f,
  -3.94015670e-01f, -1.33812457e-01f, 2.23979890e-01f, -1.96846217e-01f, -3.61729115e-01f, -1.84486002e-01f, -1.69402465e-01f, -2.95035899e-01f, -2.15283155e-01f, 6.75185248e-02f,
  -9.83102918e-02f, -4.53311622e-01f, -3.11453432e-01f, -2.65172869e-01f, -3.14510018e-02f, -5.36236703e-01f, -3.82700384e-01f, -3.79219890e-01f, -7.04547524e-01f, -4.26089048e-01f,
  -6.81234300e-01f, -6.65742934e-01f, -1.04201041e-01f, -3.21940571e-01f, -2.08493277e-01f, -3.61593068e-01f, -6.56660199e-01f, 6.33493289e-02f, 1.85850769e-01f, -5.99214077e-01f,
  -3.26619059e-01f, -8.83056745e-02f, -3.98349315e-01f, -1.24971040e-01f, -2.87215531e-01f, -7.32268631e-01f, -5.84762096e-01f, -2.57865071e-01f, 3.02459002e-01f, 8.07232130e-03f,
  -2.39609122e-01f, -1.07269198e-01f, 2.83004045e-01f, 4.78128456e-02f, -3.69389713e-01f, -1.47245020e-01f, -3.03030699e-01f, -3.40642363e-01f, -3.64807159e-01f, -8.69936287e-01f,
  -4.37513739e-01f, 4.84581031e-02f, 2.42779613e-01f, 2.32801610e-03f, 5.37057174e-03f, 8.77893493e-02f, -1.82909951e-01f, 1.52551040e-01f, -1.21876433e-01f, -2.13435754e-01f,
  -5.63721508e-02f, 1.52313784e-01f, 1.20991528e-01f, -7.05361590e-02f, 7.06020556e-03f, 7.98010901e-02f, 2.48211503e-01f, 2.51106203e-01f, -8.01976323e-02f, 3.53146419e-02f,
  -3.16509396e-01f, -2.52416730e-01f, -4.61945832e-01f, 1.46588892e-01f, 4.67042446e-01f, 1.41761631e-01f, 5.15796721e-01f, 3.11489046e-01f, 7.59671777e-02f, -7.55693734e-01f,
  7.01830387e-02f, -4.29529063e-02f, 1.50743902e-01f, 1.18140690e-01f, 1.06356256e-01f, 1.33329891e-02f, -6.15115352e-02f, -1.98614478e-01f, 1.53228730e-01f, 4.98745516e-02f,
  3.80591536e-03f, -3.38757485e-02f, 1.21748164e-01f, -1.20714553e-01f, -1.25834808e-01f, -1.01433590e-01f, -9.99122709e-02f, -1.66831687e-01f, -2.71688532e-02f, 3.73722278e-02f,
  -1.36221305e-01f, -8.96414071e-02f, 1.57585233e-01f, -7.77265942e-03f, 1.06555194e-01f, 2.07809299e-01f, 4.52857278e-02f, 1.40491128e-01f, 1.19969491e-02f, 9.26363654e-03f,
  -1.69672340e-01f, 6.19943380e-01f, -6.93432629e-01f, -1.07354619e-01f, -2.09051311e-01f, 1.41060010e-01f, -1.93999454e-01f, 2.35353664e-01f, -2.09107608e-01f, -1.05420604e-01f,
  2.14338931e-03f, -2.41328910e-01f, 1.52706746e-02f, 1.25376284e-01f, -1.25762835e-01f, 2.08594278e-02f, -2.71711737e-01f, -2.77160108e-01f, -2.10448369e-01f, 9.36141089e-02f,
  -3.12995948e-02f, -4.72876102e-01f, -6.55712187e-01f, -3.40103805e-01f, -1.58126071e-01f, -4.13866192e-01f, -2.29613155e-01f, -1.27218410e-01f, -4.24741805e-01f, -8.82932544e-01f,
  9.98641849e-01f, -4.13964421e-01f, 4.09395337e-01f, 2.07041949e-01f, 2.58628666e-01f, 1.83831766e-01f, 1.89652778e-02f, -1.36160001e-01f, 1.20711774e-01f, -2.78783143e-02f,
  3.54362838e-02f, 2.78473377e-01f, 1.00697123e-01f, 3.53084728e-02f, 5.28062358e-02f, -2.21525088e-01f, 2.76060607e-02f, 1.99664474e-01f, 2.64506608e-01f, 3.67382392e-02f,
  -1.22097135e-01f, -5.62815219e-02f, 3.55917513e-02f, -6.18311837e-02f, -1.14915095e-01f, 1.16074622e-01f, -1.26225084e-01f, -3.69304395e-03f, -1.26175657e-01f, -1.15808763e-01f,
  -2.40341097e-01f, 1.00221857e-01f, 6.88506812e-02f, 6.19747378e-02f, 3.55112143e-02f, 6.74765185e-03f, -1.62875131e-02f, -5.33632524e-02f, -5.91545776e-02f, -2.69551992e-01f,
  -1.18517712e-01f, -2.09398903e-02f, 5.68199810e-03f, -5.24933152e-02f, -9.42653790e-02f, -1.39276590e-02f, 4.73231543e-03f, -3.91724706e-02f, -1.29975677e-01f, -1.34409532e-01f,
  -7.33352676e-02f, 1.45314097e-01f, 1.07907943e-01f, -2.38409564e-02f, 2.39737201e-02f, 2.72051901e-01f, 7.46985525e-02f, -1.34317223e-02f, 1.54017612e-01f, -4.56445366e-02f,
  1.99343458e-01f, 3.02619159e-01f, 2.18488187e-01f, 1.49997711e-01f, 8.37384090e-02f, 5.35523519e-02f, 9.44838449e-02f, -1.19599029e-01f, 2.15369463e-01f, 7.11663738e-02f,
  -2.05147658e-02f, 7.14533925e-02f, 1.11087538e-01f, -4.68366854e-02f, 1.67002231e-01f, 1.00664064e-01f, -1.48106180e-02f, -3.84893194e-02f, 5.86981140e-02f, -3.41808014e-02f,
  2.56104339e-02f, -3.37398946e-02f, -1.61918681e-02f, -1.62567675e-01f, -1.49775997e-01f, 3.50368768e-02f, 3.94785181e-02f, -8.27611145e-03f, -6.00232184e-02f, 2.54913028e-02f,
  -4.52068835e-01f, 2.25706741e-01f, 7.09709451e-02f, -7.05873743e-02f, -7.70838186e-02f, -5.07867597e-02f, 2.06213742e-01f, -6.32093400e-02f, -2.05334574e-01f, -2.33744010e-01f,
  -4.96762134e-02f, 1.64135695e-02f, 6.53119907e-02f, -4.11737412e-02f, 8.19027498e-02f, -1.00995488e-02f, -3.72475423e-02f, 9.20694992e-02f, -7.97838792e-02f, -3.31224687e-02f,
  -1.14004351e-01f, 1.59114748e-01f, 6.75407052e-02f, 4.25295047e-02f, 1.07511535e-01f, 2.52168298e-01f, 5.95650710e-02f, 6.96994662e-02f, 1.41228139e-01f, -8.73193368e-02f,
  -8.40622842e-01f, 2.96952724e-01f, 1.06589742e-01f, 3.22094485e-02f, -6.15168996e-02f, -4.93237764e-01f, -4.84549940e-01f, -6.05471313e-01f, -2.67340362e-01f, 3.23646724e-01f,
  1.84123814e-01f, -2.31922623e-02f, 4.84159663e-02f, -2.91954875e-01f, -5.46133578e-01f, -1.49787828e-01f, -2.14973181e-01f, -6.03503585e-01f, -7.97674596e-01f, -5.19430935e-01f,
  -1.14954405e-01f, -2.49909386e-01f, -3.17368656e-01f, -2.04333067e-01f, 3.82391602e-01f, 1.81350365e-01f, 2.38665864e-01f, 5.72371408e-02f, 9.81208831e-02f, 4.60556269e-01f,
  6.38670564e-01f, -2.64767468e-01f, -1.86712220e-01f, -1.14587843e-01f, 6.73151538e-02f, -1.06314402e-02f, -1.41346604e-01f, 2.67856270e-02f, -8.56081545e-02f, -1.43096698e-02f,
  3.04306000e-02f, 3.10213771e-02f, -7.59053007e-02f, 4.84055132e-02f, -7.17056915e-02f, -8.30288902e-02f, 8.30191895e-02f, -1.22821674e-01f, 1.39867850e-02f, 2.73655891e-01f,
  1.51377037e-01f, 5.58828115e-02f, -1.08017616e-01f, -7.14376271e-02f, -1.36167780e-01f, -8.36149827e-02f, 1.35741830e-01f, -6.14428557e-02f, -5.32866344e-02f, 1.42226264e-01f,
  -1.38647363e-01f, 9.99216959e-02f, -5.42202592e-03f, 5.18844463e-02f, 3.61149050e-02f, 6.43820735e-03f, -2.72017643e-02f, 7.20563456e-02f, -1.69844717e-01f, -1.16157369e-03f,
  1.03036046e-01f, 9.24774166e-03f, -7.77323097e-02f, 9.23188552e-02f, 1.35807827e-01f, -5.01035452e-02f, 3.61584052e-02f, 1.04090750e-01f, -4.46983576e-02f, 6.21383311e-03f,
  -5.49251437e-02f, -1.46815762e-01f, 8.09429884e-02f, -1.38292134e-01f, 7.52013698e-02f, -4.22582179e-02f, -5.23099266e-02f, -8.21388215e-02f, -1.28212973e-01f, -6.95507973e-02f,
  3.81824136e-01f, -4.03533369e-01f, 3.37763846e-01f, -1.25234425e-01f, -3.07762995e-02f, 1.83193743e-01f, 2.07022101e-01f, -2.16302481e-02f, 1.22167222e-01f, 7.38990912e-03f,
  -2.34686315e-01f, 2.30862130e-03f, 1.72516614e-01f, 1.19681239e-01f, -6.05779476e-02f, 7.74279013e-02f, 1.28358901e-01f, 6.16799667e-02f, -8.86106640e-02f, 3.03269297e-01f,
  4.44690175e-02f, -7.00577721e-03f, 2.91264802e-02f, 1.23761492e-02f, -2.61086202e-03f, -1.52135745e-01f, 2.51770169e-01f, 1.48559913e-01f, -1.26794443e-01f, 2.69957006e-01f,
  -1.04515219e+00f, 4.70830828e-01f, -1.16078801e-01f, -5.57311177e-01f, 5.34338236e-01f, 3.57279539e-01f, 3.08523685e-01f, -4.59135771e-01f, -4.61986750e-01f, 8.04798380e-02f,
  4.04339135e-01f, 1.45932036e-02f, -8.65702406e-02f, 1.13122113e-01f, -9.51237511e-03f, 5.13576627e-01f, 5.10131359e-01f, -2.12960958e-01f, -3.71193051e-01f, 4.62963395e-02f,
  4.50508833e-01f, -2.48455703e-01f, -4.95055079e-01f, -2.69973248e-01f, 3.49010825e-02f, 1.09632112e-01f, 3.60422395e-02f, 8.99610892e-02f, 5.98394632e-01f, 4.50604677e-01f,
  1.00959994e-01f, -5.20913422e-01f, 9.48493108e-02f, 4.48028371e-02f, 1.44563690e-01f, -3.60571772e-01f, -2.01487660e-01f, -2.71241009e-01f, 1.18540339e-01f, -1.28474325e-01f,
  1.54918581e-01f, 1.29442453e-01f, 2.01546445e-01f, -4.56243046e-02f, -2.96230733e-01f, -2.61167854e-01f, -3.38553727e-01f, -5.13235748e-01f, -4.83969957e-01f, -1.74098939e-01f,
  6.77927554e-01f, 3.43702525e-01f, -2.60617614e-01f, -1.17008440e-01f, -3.75997394e-01f, -2.75017291e-01f, -3.63425612e-01f, -5.08208632e-01f, -5.89956999e-01f, -6.99991941e-01f,
  3.60808894e-02f, 1.13114439e-01f, -3.05543337e-02f, -6.93167299e-02f, -2.49274280e-02f, 5.07245287e-02f, 1.32509783e-01f, 2.56069392e-01f, 7.02921003e-02f, -3.33621539e-02f,
  -2.69649327e-02f, -1.26631230e-01f, -1.11267120e-01f, -1.21570185e-01f, -5.19991154e-03f, -5.16551845e-02f, -6.13728724e-02f, -1.18718348e-01f, 5.08719757e-02f, -6.99989498e-02f,
  -2.41476931e-02f, -9.92513150e-02f, -4.15177420e-02f, -1.54783070e-01f, 1.47504851e-01f, 9.00558289e-03f, 8.58714506e-02f, 1.01618804e-01f, -2.27541909e-01f, 6.55840486e-02f,
  -6.02846265e-01f, 3.38141471e-01f, -2.87310123e-01f, -1.31108686e-01f, 1.49737835e-01f, -1.82101363e-03f, 3.87924686e-02f, 8.30358341e-02f, -7.14869574e-02f, -2.24892333e-01f,
  -1.45084038e-01f, -1.96025833e-01f, 1.86483592e-01f, 6.09682612e-02f, -4.88261655e-02f, -5.21853119e-02f, 3.67326856e-01f, 5.90932965e-02f, 4.56160642e-02f, -6.80641755e-02f,
  -1.37716979e-01f, -1.31132007e-01f, -3.64058167e-01f, -8.05101097e-02f, -5.89918867e-02f, -2.75464207e-01f, -3.04912984e-01f, -2.70431191e-01f, -3.06149393e-01f, -3.61911833e-01f,
  2.18562499e-01f, 3.74249250e-01f, 5.76663494e-01f, 1.63615420e-01f, 7.39476323e-01f, 8.36184844e-02f, -4.28203493e-01f, -7.01118469e-01f, -1.10135116e-01f, 3.51615660e-02f,
  6.03515923e-01f, 2.30713159e-01f, 1.70813456e-01f, -3.19814593e-01f, -9.26545382e-01f, -6.35350287e-01f, -3.12934875e-01f, -6.31164789e-01f, -7.81956553e-01f, -5.06804883e-01f,
  -1.89725980e-01f, -1.42902687e-01f, -3.72259229e-01f, -3.97021472e-01f, 3.62350702e-01f, 1.28995419e-01f, 4.85065699e-01f, 3.71727735e-01f, 1.98704287e-01f, 4.18373466e-01f,
  1.59580052e-01f, 1.69666916e-01f, -2.60729432e-01f, 3.78285125e-02f, 4.66222644e-01f, -2.85793692e-01f, -1.83384225e-01f, -2.14476176e-02f, 8.98776352e-02f, -6.23897277e-02f,
  4.19039339e-01f, -1.38474638e-02f, 2.76514441e-01f, 1.22212917e-02f, -2.04482123e-01f, -2.32731864e-01f, -2.36316174e-01f, -5.66425562e-01f, -1.01000108e-01f, -1.29910246e-01f,
  2.22615018e-01f, 5.24556339e-01f, 3.90685678e-01f, -2.17753112e-01f, -1.28116071e-01f, 2.83113718e-01f, 1.33724958e-01f, -1.19701922e-01f, -7.52758458e-02f, -1.11611545e-01f,
  -2.21637979e-01f, 1.32518202e-01f, 9.76373907e-03f, 3.67207974e-02f, -8.84561762e-02f, 2.19362751e-01f, 4.60269749e-02f, -6.92163706e-02f, -1.35288760e-01f, -7.69116953e-02f,
  3.43992300e-02f, 5.69331422e-02f, -8.82444605e-02f, -1.06346443e-01f, 3.89345326e-02f, 1.87068939e-01f, 4.35227640e-02f, -1.72983572e-01f, 1.40614778e-01f, -5.24540059e-02f,
  5.13831638e-02f, 1.67790782e-02f, 3.70222509e-01f, -2.07485437e-01f, 7.62998909e-02f, 1.53486070e-03f, 7.68932179e-02f, 1.83299519e-02f, 1.32230744e-01f, 8.30993727e-02f,
  -9.72304046e-02f, -5.06960936e-02f, -1.53359890e-01f, -4.39590394e-01f, 6.26593754e-02f, 2.37556204e-01f, 1.73061624e-01f, -5.19383028e-02f, 2.57468730e-01f, -9.97043103e-02f,
  2.39832257e-03f, -6.43476173e-02f, 1.77950576e-01f, -2.55907886e-02f, -2.85458177e-01f, 5.64177595e-02f, -1.72272369e-01f, 2.15648204e-01f, -1.16191609e-02f, 2.26610839e-01f,
  -8.52618553e-03f, -4.42433089e-01f, -2.27127478e-01f, -1.60739735e-01f, -7.80933350e-02f, 8.40485562e-03f, -9.26139280e-02f, -1.38321713e-01f, -1.53638527e-01f, -5.06415009e-01f,
  -1.41008937e+00f, -1.11719156e-02f, 2.51884371e-01f, -6.75966442e-01f, 2.67613530e-01f, 6.46113694e-01f, 6.44482672e-01f, 1.09070562e-01f, -2.80300528e-01f, -2.84878463e-01f,
  -2.13971853e-01f, -2.85431057e-01f, -2.34583408e-01f, 4.91555780e-02f, 1.53477952e-01f, 2.42605105e-01f, 2.71651179e-01f, -6.07155897e-02f, 2.80912906e-01f, 4.68894333e-01f,
  2.28790537e-01f, -2.80237585e-01f, -4.02216166e-01f, -8.37089494e-02f, -3.94687206e-01f, -3.43984038e-01f, -1.77927226e-01f, -1.57045051e-01f, 1.70590863e-01f, -3.72844249e-01f,
  -9.85904872e-01f, -5.62106848e-01f, 5.06345153e-01f, -2.68613875e-01f, -2.38581479e-01f, -2.74154454e-01f, -6.85223565e-02f, -1.01995297e-01f, -2.64943719e-01f, -1.23925738e-01f,
  -2.90421963e-01f, 6.57384768e-02f, -2.29255617e-01f, -2.03064919e-01f, -1.94392934e-01f, -5.20199595e-04f, 9.06479806e-02f, 9.36665852e-03f, -3.79856937e-02f, 2.77427644e-01f,
  2.92766303e-01f, 4.75557037e-02f, -1.58094734e-01f, 5.95468283e-01f, 3.26440305e-01f, -1.50432467e-01f, -2.01833472e-01f, -2.84060799e-02f, 1.20134711e-01f, -8.35282922e-01f,
  -1.13268085e-02f, 3.96220610e-02f, 4.54979902e-03f, -4.06305455e-02f, -1.60112202e-01f, -9.50101316e-02f, 7.10317865e-02f, 1.70697197e-01f, -9.67868343e-02f, -1.43236697e-01f,
  2.50981987e-01f, 1.23169422e-02f, 1.05251022e-01f, -9.05101448e-02f, -8.38962123e-02f, -1.31744385e-01f, -3.77337672e-02f, -5.76500781e-02f, 6.53515905e-02f, 1.63468942e-02f,
  -8.87676477e-02f, 3.29678617e-02f, 1.01521984e-01f, -1.75057799e-02f, 7.08247125e-02f, 2.03424752e-01f, -1.17958285e-01f, -5.69855981e-02f, -1.38661250e-01f, -1.17682137e-01f,
  -5.83120763e-01f, 6.62340105e-01f, -5.84175110e-01f, -6.76000416e-02f, -3.05433869e-01f, 1.60705552e-01f, -8.94877836e-02f, -2.81819161e-02f, -2.47996990e-02f, -1.69453174e-01f,
  1.71168223e-01f, -1.09309681e-01f, -1.59956008e-01f, 1.67303473e-01f, -6.61677942e-02f, -1.92268029e-01f, -1.44716069e-01f, -1.50860384e-01f, 2.83242464e-01f, 6.90221041e-02f,
  1.09214664e-01f, 3.35725546e-02f, -5.81766069e-01f, -1.33995712e-01f, -9.62262228e-02f, -6.16565406e-01f, -5.13749838e-01f, -1.38837025e-01f, -2.80955434e-01f, -9.79108036e-01f,
  1.26593158e-01f, 2.42778540e-01f, -2.40471527e-01f, 3.55825245e-01f, 3.59696269e-01f, -2.52488684e-02f, -2.16153488e-01f, -2.12071374e-01f, -2.56222993e-01f, -2.56483167e-01f,
  -2.67378181e-01f, 3.08887810e-02f, -3.14213514e-01f, -1.52436912e-01f, -1.93784669e-01f, -7.11533502e-02f, 5.93448021e-02f, -3.51186469e-03f, 1.62274554e-01f, 3.92541558e-01f,
  4.06735957e-01f, 2.02424571e-01f, 7.73167163e-02f, 2.10659236e-01f, 3.96856487e-01f, 1.57564744e-01f, -2.64441431e-01f, 8.80112797e-02f, 6.46029115e-02f, 5.23117840e-01f,
  -1.46430442e-02f, 1.94092780e-01f, -1.12544186e-01f, 1.44596651e-01f, 2.12258369e-01f, 3.49155329e-02f, 8.96690860e-02f, -2.25960277e-02f, 1.15128614e-01f, 6.73602847e-03f,
  1.42634943e-01f, 1.05758391e-01f, -8.43811557e-02f, 1.85784489e-01f, 8.74870867e-02f, 2.12663133e-02f, -9.14091095e-02f, -1.94698736e-01f, -1.76528633e-01f, 3.61273699e-02f,
  3.09280396e-01f, 2.78887331e-01f, -1.31545261e-01f, -2.39358112e-01f, -2.18000814e-01f, -2.01040179e-01f, -9.41416472e-02f, 1.27532274e-01f, -3.81720245e-01f, -3.48373055e-02f,
  -1.41074434e-01f, -4.94652195e-03f, -4.98095192e-02f, 6.35097995e-02f, 5.14450558e-02f, -6.78844824e-02f, 1.53345823e-01f, 1.39833376e-01f, -2.62547396e-02f, 3.29544038e-01f,
  -4.51912023e-02f, 7.26974569e-03f, 1.14103302e-01f, 4.75576743e-02f, -3.14917788e-02f, 1.22464843e-01f, 2.65612841e-01f, -1.78405881e-01f, -1.37049466e-01f, -1.03863031e-01f,
  4.82806973e-02f, -3.55334431e-02f, -4.58565019e-02f, 2.21794788e-02f, 5.79700768e-02f, -5.49003184e-02f, 2.22225830e-01f, 1.37974605e-01f, -3.44244577e-02f, 4.58237045e-02f,
  -4.73498344e-01f, -3.93653750e-01f, 1.31502286e-01f, 5.23074679e-02f, 7.22462386e-02f, -2.15907857e-01f, 6.51108939e-03f, 6.76174611e-02f, 2.10108206e-01f, -5.42588346e-02f,
  3.75561379e-02f, -9.61519927e-02f, -3.12506735e-01f, 1.06006172e-02f, -1.26340240e-02f, -3.62217799e-02f, 1.56620797e-02f, -2.57737711e-02f, -3.56507674e-02f, 2.35747382e-01f,
  -6.93023577e-02f, -1.76872373e-01f, -3.79549593e-01f, -3.35636795e-01f, -1.44240156e-01f, -3.22713017e-01f, -4.34984416e-01f, -6.10090159e-02f, -7.17962265e-01f, -4.00600582e-01f,
  1.38691336e-01f, 3.97195429e-01f, 6.51912510e-01f, 3.17916907e-02f, 2.81825364e-01f, 6.47479668e-02f, -2.25358441e-01f, 2.56443359e-02f, 2.04908937e-01f, 1.00738935e-01f,
  2.81605907e-02f, -4.40340161e-01f, 1.06674388e-01f, -3.86294633e-01f, -4.08461511e-01f, -3.90001163e-02f, -1.26705449e-02f, -3.16509485e-01f, -5.50282538e-01f, -6.74462438e-01f,
  -6.77043378e-01f, -3.33237588e-01f, -2.17202932e-01f, 6.56972453e-02f, 2.88589388e-01f, -4.46203314e-02f, 5.15508771e-01f, 2.52563804e-01f, 8.49585161e-02f, 9.33008566e-02f,
  9.26355794e-02f, 7.81543970e-01f, -2.87389427e-01f, -1.74958095e-01f, 1.34166285e-01f, -6.28879070e-02f, -2.93044411e-02f, 2.83669263e-01f, -3.10681220e-02f, 5.09875901e-02f,
  -1.18794693e-02f, -1.31613746e-01f, 1.01376228e-01f, -5.38480617e-02f, -1.44115668e-02f, -1.48431391e-01f, 4.77735437e-02f, -4.52025682e-02f, 8.25113654e-02f, 9.80759691e-03f,
  -4.91346598e-01f, -1.12853810e-01f, 4.83178377e-01f, 1.37561679e-01f, 2.87193358e-01f, -3.66976053e-01f, 2.39307195e-01f, 2.06272155e-01f, 3.36396396e-01f, 1.32812291e-01f,
  -1.21901430e-01f, 7.40705281e-02f, -3.81064899e-02f, 1.18053749e-01f, -2.93214351e-01f, 2.06728559e-02f, 7.68721476e-02f, -8.40788782e-02f, 2.08578706e-02f, -7.91261420e-02f,
  5.51042147e-03f, 6.48710430e-02f, 5.87216998e-03f, 6.10609911e-03f, 4.92585711e-02f, 5.84912971e-02f, -7.20421001e-02f, -2.09423378e-01f, 1.04792871e-01f, 8.15456957e-02f,
  -1.79171354e-01f, -8.30689743e-02f, 1.32594764e-01f, -4.56097797e-02f, 7.50805959e-02f, 7.84453750e-02f, -1.16982035e-01f, -9.07110944e-02f, 4.99054603e-02f, -5.41168563e-02f,
  -3.14227074e-01f, -1.87560216e-01f, -1.29025161e-01f, -1.30036056e-01f, 5.92950955e-02f, 1.02940656e-01f, 1.95949282e-02f, 3.39895338e-02f, 2.14226365e-01f, -1.13264956e-01f,
  1.74436957e-01f, -1.94987640e-01f, 9.51080844e-02f, -1.30860075e-01f, -2.70990640e-01f, 8.21280628e-02f, -2.61342019e-01f, -1.19579233e-01f, -1.75825417e-01f, 2.78962497e-02f,
  -1.07070506e-01f, -4.63370860e-01f, -4.96230155e-01f, -2.09259138e-01f, 1.06246181e-01f, -5.99767148e-01f, -1.59817785e-01f, -2.27876678e-01f, -4.44702417e-01f, -4.90757167e-01f,
  -5.93178570e-02f, -5.86185277e-01f, -5.26022762e-02f, -2.50722498e-01f, -2.41139665e-01f, -6.30528927e-01f, -9.58900094e-01f, -4.87750202e-01f, -1.32667094e-01f, -1.55446574e-01f,
  -1.84076950e-02f, 1.38867065e-01f, -7.93917179e-02f, 1.28670380e-01f, -3.56888287e-02f, -4.77120250e-01f, -1.40431076e-01f, 4.12247270e-01f, 4.91581500e-01f, 4.46733713e-01f,
  2.54451662e-01f, 3.23039114e-01f, 5.56669354e-01f, 3.81778300e-01f, 2.36466527e-01f, 1.28099591e-01f, -6.11002818e-02f, 2.12012470e-01f, 7.41980746e-02f, 3.98799360e-01f,
  4.23806846e-01f, 1.22443900e-01f, -2.00342014e-01f, 2.02482253e-01f, 3.02791834e-01f, 8.64582881e-02f, 8.53315890e-02f, 2.01519415e-01f, 2.92906798e-02f, 4.10592332e-02f,
  3.23719114e-01f, 2.48121843e-01f, -7.63228908e-02f, 1.84962064e-01f, -8.36455263e-03f, 3.56236100e-02f, 1.44805461e-01f, 1.00734524e-01f, -1.72741815e-01f, 8.98376405e-02f,
  4.35588509e-02f, -1.13721304e-02f, -2.20607549e-01f, -3.37667197e-01f, -2.80097932e-01f, 1.19638674e-01f, -3.58965062e-02f, 2.23112687e-01f, -1.41934648e-01f, -2.07554325e-02f,
  -4.36726883e-02f, 5.40996715e-02f, -2.55328603e-02f, 2.40743556e-03f, 6.34573922e-02f, -7.21868351e-02f, 5.82031123e-02f, -4.88342345e-02f, 5.21270856e-02f, -9.60951895e-02f,
  -1.70672297e-01f, -6.25377661e-03f, 1.98022708e-01f, 3.65882404e-02f, 1.54738098e-01f, 1.40932528e-02f, 8.29671621e-02f, 7.37770693e-04f, 1.43546805e-01f, 4.89049368e-02f,
  1.46709383e-02f, -3.51327248e-02f, 5.50396517e-02f, 9.91916955e-02f, 1.00579232e-01f, 2.22633854e-01f, 1.68209732e-01f, 1.85582533e-01f, 5.17185628e-02f, 6.35130480e-02f,
  -5.08390963e-01f, -1.52424470e-01f, -1.32188141e-01f, 1.02089919e-01f, -1.00481331e-01f, 3.36984359e-02f, 1.07175196e-02f, 8.93739462e-02f, -2.93901912e-03f, 4.58079353e-02f,
  6.33785427e-02f, -2.18594730e-01f, -1.10390417e-01f, 1.68215066e-01f, 2.31305603e-02f, -1.28079191e-01f, 1.02745451e-01f, 3.23754400e-02f, -2.47794524e-01f, 2.19446495e-01f,
  -2.88410217e-01f, -3.80622059e-01f, -5.54672062e-01f, -7.23917305e-01f, -2.07672447e-01f, -2.42816925e-01f, -2.76255399e-01f, -1.78308383e-01f, -6.06326401e-01f, -9.00932670e-01f,
  1.12840887e-02f, 4.94584054e-01f, -2.87033290e-01f, 3.07746232e-01f, -1.38086736e-01f, -3.05537641e-01f, 6.51143566e-02f, 3.02590013e-01f, 4.38181013e-01f, 6.03739917e-01f,
  -6.73415288e-02f, -5.90588629e-01f, -3.66381705e-01f, -4.84917164e-01f, -4.42296565e-01f, 2.54340082e-01f, 1.39239533e-02f, -6.19579673e-01f, -9.63176548e-01f, -5.01439691e-01f,
  -3.83787692e-01f, -3.62743318e-01f, -4.95476186e-01f, -2.15396106e-01f, 2.65005171e-01f, -5.40909171e-01f, 1.47404149e-01f, -1.12184472e-01f, -4.11237895e-01f, 4.03398462e-02f,
  -1.07868172e-01f, 1.21838242e-01f, -2.43378162e-01f, -1.38818890e-01f, 5.39034307e-02f, 6.16803542e-02f, -1.36426196e-01f, 9.84383449e-02f, -3.13550420e-02f, 1.83900014e-01f,
  -3.60776298e-02f, 7.67224878e-02f, -7.60103315e-02f, -8.38756636e-02f, 4.42917272e-02f, -1.62564993e-01f, 1.91536665e-01f, -8.48265439e-02f, -2.80660149e-02f, 2.80913800e-01f,
  4.54919562e-02f, -1.17702119e-01f, -4.83672582e-02f, 8.17401856e-02f, 1.91963166e-01f, -2.15085313e-01f, 7.79148936e-02f, 1.28327280e-01f, -7.80402049e-02f, 3.94161910e-01f,
  2.53968745e-01f, 1.71252787e-01f, 2.40231007e-02f, 4.78743352e-02f, 1.56017855e-01f, -4.93481308e-02f, 3.60522084e-02f, 2.50893850e-02f, -4.73507456e-02f, 9.59808975e-02f,
  1.45378664e-01f, 1.18196681e-01f, 2.71340758e-02f, 7.89948329e-02f, -8.56512040e-03f, -4.03728560e-02f, -1.31284446e-01f, 1.03278175e-01f, 4.48075086e-02f, 8.71956050e-02f,
  -3.89828607e-02f, 3.03288121e-02f, -1.22136630e-01f, -7.81217068e-02f, -2.87287384e-02f, 8.53125528e-02f, 1.33281797e-01f, -6.69714883e-02f, 1.13658503e-01f, -2.56681070e-02f,
  -1.33844048e-01f, -5.58726788e-01f, 2.10869327e-01f, 3.05251367e-02f, 2.16576412e-01f, 9.77029949e-02f, 3.15377116e-02f, 1.01480193e-01f, 6.43560737e-02f, 1.39680266e-01f,
  -1.06709309e-01f, 8.97084028e-02f, 3.94732039e-03f, 9.34334248e-02f, -1.62534103e-01f, 9.81548727e-02f, 1.88472942e-01f, -1.50112750e-03f, 1.67212412e-02f, 2.34304532e-01f,
  3.64219457e-01f, -2.13041082e-02f, -4.53528613e-02f, 6.21501692e-02f, 1.43874407e-01f, -3.38617980e-01f, -1.89891949e-01f, -2.34378409e-02f, -1.96257636e-01f, 3.98296326e-01f,
  1.01978469e+00f, 3.81645501e-01f, 3.96240145e-01f, 1.43520519e-01f, 3.53381112e-02f, 2.69693844e-02f, 1.09793119e-01f, 1.88166156e-01f, 5.32270931e-02f, 1.40977427e-01f,
  8.56386572e-02f, 1.31343409e-01f, 1.35877490e-01f, 1.86988220e-01f, 2.41878092e-01f, 2.00574785e-01f, 1.30371049e-01f, 2.43241638e-01f, 3.14599216e-01f, 1.83273345e-01f,
  -6.89548776e-02f, 7.63856247e-02f, 1.75131902e-01f, 1.30823031e-01f, 9.72860381e-02f, -2.81684212e-02f, 3.86030152e-02f, 8.71790424e-02f, 1.50908306e-01f, 2.46051475e-01f,
  2.10965618e-01f, 3.41771573e-01f, -5.09106442e-02f, -1.19978048e-01f, -8.31510648e-02f, -1.35795295e-01f, 6.35076314e-02f, -9.61582810e-02f, -3.10506448e-02f, -5.06149558e-03f,
  -1.24539837e-01f, 6.54054014e-03f, 6.20496459e-02f, -2.45066155e-02f, -9.75676104e-02f, -1.08526899e-02f, -1.36146592e-02f, 8.28535557e-02f, 4.10962813e-02f, -6.32081330e-02f,
  -1.11340754e-01f, -1.23920023e-01f, 2.15503573e-02f, 8.12151283e-02f, 8.95026326e-02f, -1.23688638e-01f, 1.55550484e-02f, 6.66508600e-02f, 8.54382068e-02f, 1.18019372e-01f,
  8.14042613e-02f, 1.15686245e-01f, 3.28870326e-01f, 2.28206009e-01f, 2.36669227e-01f, 1.61875561e-01f, -1.08129960e-02f, 8.09142590e-02f, 1.69276539e-02f, 1.24078117e-01f,
  1.99805535e-02f, 1.47543505e-01f, -1.14786103e-02f, -9.22170952e-02f, 1.49569418e-02f, -2.67135967e-02f, -1.51630685e-01f, -1.55404702e-01f, 6.00839369e-02f, -3.19116190e-02f,
  7.36851022e-02f, -5.46615981e-02f, -1.56457443e-02f, 4.84055728e-02f, -2.29886681e-01f, -5.64451814e-02f, -7.61475191e-02f, -1.35163531e-01f, -7.86406994e-02f, -1.13143861e-01f,
  -4.88901556e-01f, -1.42062888e-01f, 1.11265652e-01f, 5.99820651e-02f, 2.73858439e-02f, -2.47869901e-02f, 6.87823743e-02f, -1.97027400e-01f, -1.93303674e-01f, -8.27468857e-02f,
  -2.73009744e-02f, 1.45594412e-02f, -6.83038235e-02f, -1.09171420e-01f, -9.50899422e-02f, -8.40944946e-02f, 1.40704457e-02f, -1.40390396e-01f, -1.30159140e-01f, -8.93453062e-02f,
  -2.23643303e-01f, -1.50900543e-01f, -1.25179395e-01f, -1.70666352e-01f, -1.61769167e-01f, -1.49540320e-01f, -7.69240409e-02f, -4.12333496e-02f, -1.30182087e-01f, -2.03460708e-01f,
  4.66787338e-01f, 8.98610577e-02f, -1.60331357e+00f, 7.90242851e-01f, 1.26567885e-01f, -2.61787891e-01f, -2.24773306e-02f, 4.48980659e-01f, 5.25421739e-01f, 1.47581697e-01f,
  -1.58794820e-01f, -1.32319912e-01f, -3.32700640e-01f, -1.81823239e-01f, -4.63868380e-01f, -2.93592185e-01f, -2.36710072e-01f, -8.12805176e-01f, -3.86100411e-01f, 3.34292471e-01f,
  8.45745981e-01f, 7.38786936e-01f, 4.11272943e-01f, -1.56859448e-03f, 3.09728116e-01f, 1.66931972e-02f, -2.98132062e-01f, -7.00995773e-02f, -4.22973543e-01f, -1.95240498e-01f,
  -7.84177661e-01f, -2.93219268e-01f, -4.34063643e-01f, -1.16016664e-01f, -2.34250560e-01f, -2.30398387e-01f, -1.83142781e-01f, -2.01512367e-01f, -7.90268704e-02f, -6.49674162e-02f,
  -8.85000899e-02f, -3.36643420e-02f, 6.08969219e-02f, 2.65930351e-02f, 9.37736183e-02f, -1.15972936e-01f, 6.01844862e-02f, -3.69422287e-01f, -4.13931191e-01f, -4.50999707e-01f,
  2.33594701e-01f, -3.68244439e-01f, -8.15548003e-01f, -2.50483125e-01f, -4.07205075e-01f, -3.42410445e-01f, -3.13376397e-01f, -3.69216591e-01f, -6.86745942e-01f, 1.60560027e-01f,
  1.07031398e-01f, 1.33394916e-02f, 1.70638531e-01f, 7.16985092e-02f, 3.63181233e-01f, 8.15511644e-02f, 1.34450406e-01f, 1.32649556e-01f, 3.62638868e-02f, 1.04211904e-01f,
  -1.64205134e-01f, -1.38598472e-01f, -5.35702379e-03f, -4.05410677e-02f, 8.27218145e-02f, -1.33550584e-01f, -1.43121988e-01f, 4.99755144e-02f, -1.64988488e-01f, 1.73643142e-01f,
  4.56964597e-02f, -1.69939727e-01f, -6.50207186e-03f, -1.61243454e-01f, -1.61237434e-01f, -2.87362725e-01f, -1.40886545e-01f, 1.13663599e-01f, 1.70012727e-01f, -1.56972334e-01f,
  7.62350500e-01f, -2.65616953e-01f, 2.44771298e-02f, -1.20894507e-01f, -3.93112972e-02f, -1.68410957e-01f, 9.78518873e-02f, 3.91995646e-02f, 3.69182155e-02f, 3.02110203e-02f,
  -2.49084368e-01f, -6.50695115e-02f, 1.71948880e-01f, 1.90080240e-01f, 9.99787971e-02f, 1.51821673e-01f, 1.82256654e-01f, -9.30009782e-02f, 2.24684351e-04f, 4.91709225e-02f,
  3.83942455e-01f, 2.43230149e-01f, 1.62150547e-01f, -1.27596129e-02f, 2.76971430e-01f, 1.27131995e-02f, 6.98480830e-02f, 1.01227731e-01f, -3.33508044e-01f, 7.90626287e-01f,
  7.39834487e-01f, -4.97013688e-01f, -3.90511751e-01f, -2.82043636e-01f, -4.39409465e-01f, -4.16525930e-01f, -7.24869967e-01f, -1.01190940e-01f, 1.12654768e-01f, -6.33766770e-01f,
  -2.55774166e-02f, 1.10431647e+00f, 7.55849719e-01f, 7.04657733e-01f, 5.37542582e-01f, -8.87422025e-01f, -9.65391219e-01f, 1.07642122e-01f, 7.50134051e-01f, 4.35715288e-01f,
  6.37682900e-02f, -1.86189815e-01f, 1.68500647e-01f, 1.28569141e-01f, -4.07958508e-01f, 1.73792481e-01f, -7.15238392e-01f, -3.69622052e-01f, -2.73353845e-01f, -7.85194218e-01f,
  2.68269688e-01f, -1.69200361e-01f, 1.49731591e-01f, 3.61714214e-01f, -7.06372708e-02f, 1.82697065e-02f, -7.46172741e-02f, -1.42528251e-01f, -1.35520985e-02f, -2.71563947e-01f,
  1.19022103e-02f, 2.30786383e-01f, 8.01427513e-02f, 1.26386970e-01f, -3.09413344e-01f, 5.61220646e-02f, 7.85368215e-03f, 4.68129888e-02f, 1.14331516e-02f, -6.73209578e-02f,
  5.53351752e-02f, -1.03638526e-02f, 1.49609253e-01f, -3.30415636e-01f, -1.92753989e-02f, 1.78624302e-01f, -3.72995347e-01f, 1.06218532e-02f, -1.17813393e-01f, -6.94805622e-01f,
  -6.93762898e-02f, 8.90265964e-03f, -1.16523221e-01f, -3.78630571e-02f, 3.98280136e-02f, 2.50392593e-02f, -1.30545476e-03f, 4.74137180e-02f, 4.00491469e-02f, -7.37901330e-02f,
  1.69671848e-01f, -6.72832206e-02f, 3.32661928e-03f, -3.43990736e-02f, 7.99108855e-03f, -7.98751861e-02f, -4.60791737e-02f, -1.59033373e-01f, 3.51256132e-02f, -4.75961454e-02f,
  1.82412878e-01f, 1.23268686e-01f, 8.94506741e-03f, 1.18538015e-01f, -1.41220272e-01f, 4.94469292e-02f, 5.05187139e-02f, 4.07705083e-02f, 1.55237675e-01f, -9.93619040e-02f,
  3.11585307e-01f, 1.25662491e-01f, -1.49227321e-01f, 1.70928985e-01f, -9.34543237e-02f, -6.13601990e-02f, -3.30523342e-01f, -1.87466994e-01f, 8.65161419e-02f, 1.96854606e-01f,
  3.53147909e-02f, 1.59213170e-01f, -1.07042708e-01f, -1.06193736e-01f, -9.74644423e-02f, -5.73000722e-02f, -9.83755440e-02f, 7.17420205e-02f, -1.45365268e-01f, -1.08713813e-01f,
  -2.57941395e-01f, -4.32491340e-02f, 3.06442589e-01f, -5.31161651e-02f, -2.41324306e-02f, 2.85568535e-01f, -2.80115902e-01f, 1.94228794e-02f, 1.92094818e-01f, -4.86679971e-01f,
  -5.09836733e-01f, -1.62611216e-01f, -1.17741561e+00f, -1.04279482e+00f, -7.11799860e-01f, -4.37848084e-02f, 1.97903916e-01f, -8.58050659e-02f, -4.64015484e-01f, -3.84933084e-01f,
  7.65665947e-03f, -2.76416183e-01f, -5.13541102e-01f, -1.53612494e-01f, 2.48985231e-01f, 8.33794102e-03f, -5.51599920e-01f, -4.72120494e-01f, -2.65844405e-01f, -1.04855336e-01f,
  -1.44412979e-01f, -5.71510077e-01f, -4.84719008e-01f, -4.88973022e-01f, -6.25973523e-01f, -4.73809570e-01f, -7.83341646e-01f, -5.73825300e-01f, -2.13556930e-01f, -7.00678825e-01f,
  -4.27695751e-01f, -4.90398407e-01f, 6.44060550e-03f, -3.19981985e-02f, -2.96010196e-01f, 3.01177194e-03f, -2.63696909e-02f, -3.53388518e-01f, -1.25606492e-01f, -2.77080268e-01f,
  -2.59950221e-01f, -8.48036539e-03f, -3.20477039e-01f, -2.04207122e-01f, -3.83262128e-01f, -1.35733292e-01f, -2.71706700e-01f, -1.74511403e-01f, 1.79074779e-02f, 1.73714370e-01f,
  1.30915314e-01f, 1.22500926e-01f, 1.26168402e-02f, 2.60289937e-01f, 1.87867641e-01f, 5.87370172e-02f, 7.79331475e-02f, 3.86282057e-02f, 4.75222841e-02f, -4.19754051e-02f,
  8.92380998e-02f, 4.88219298e-02f, 1.18105824e-03f, 1.91717874e-02f, 2.28867620e-01f, 6.82355985e-02f, -1.79507568e-01f, -2.61078496e-02f, 1.96903497e-01f, -3.65941972e-02f,
  -1.15073510e-02f, 1.19191699e-01f, -4.59744297e-02f, 8.24121535e-02f, -7.78503343e-02f, -2.09290348e-02f, 2.62501568e-01f, 7.35606849e-02f, -7.94392526e-02f, 7.12511912e-02f,
  2.45144460e-02f, -1.65947471e-02f, -5.48813567e-02f, 1.29385605e-01f, 1.56453282e-01f, -3.31220664e-02f, 1.36805296e-01f, 1.15365699e-01f, -1.08503208e-01f, 1.11251667e-01f,
  -4.02313441e-01f, 2.12977782e-01f, 2.36237720e-02f, 6.16265833e-02f, -7.40514845e-02f, -1.32193118e-01f, -1.92560449e-01f, -6.44449101e-05f, -3.41036618e-01f, -7.02867135e-02f,
  1.19366452e-01f, 1.00082606e-01f, -2.08258718e-01f, 3.22718136e-02f, -8.68551731e-02f, 3.28262784e-02f, 3.03104311e-01f, -1.61669720e-02f, 2.04328939e-01f, 2.10713595e-01f,
  1.81814030e-01f, 3.34089994e-01f, 3.20563823e-01f, 2.96470404e-01f, 2.35762894e-01f, 2.38193437e-01f, 7.99990073e-02f, 1.72680214e-01f, 2.62058675e-01f, 2.54388392e-01f,
  -4.14939642e-01f, -1.16307592e+00f, 6.40739977e-01f, -2.70784199e-01f, 1.13236494e-01f, 1.71622455e-01f, -5.64660847e-01f, -3.04769844e-01f, -1.67914227e-01f, -7.69238472e-01f,
  -5.53758383e-01f, -3.56543548e-02f, 8.71918499e-02f, 5.17906696e-02f, -6.47164136e-02f, -6.06931150e-01f, -7.95819014e-02f, 6.95001006e-01f, 8.73365045e-01f, 1.39290124e-01f,
  -4.11370993e-01f, -1.16844952e-01f, 1.87859297e-01f, 2.18942195e-01f, -2.87914515e-01f, 2.07849964e-01f, 5.97670265e-02f, -2.09014222e-01f, -3.50348711e-01f, -5.60181439e-01f,
  2.75103927e-01f, -4.51466352e-01f, 2.07308620e-01f, -1.02875508e-01f, 1.19447913e-02f, -3.64601205e-04f, -4.14406210e-02f, 7.41938800e-02f, -1.83626294e-01f, -1.53751075e-01f,
  -2.22101912e-01f, -8.71272478e-03f, 1.78113222e-01f, 6.38705194e-02f, -1.09404184e-01f, -1.19375791e-02f, 2.43260600e-02f, 8.01737756e-02f, 1.07236691e-01f, -1.64858162e-01f,
  -4.34200644e-01f, -1.75479814e-01f, 1.98094159e-01f, 4.16044816e-02f, -3.47168930e-02f, 3.77805114e-01f, -1.30732745e-01f, -6.36800826e-02f, 2.75305837e-01f, -2.76420414e-01f,
  4.91743386e-02f, 1.16256341e-01f, 3.96088585e-02f, 3.42141837e-02f, 8.70664883e-03f, 5.68013042e-02f, -3.86998244e-02f, -9.54553485e-02f, 1.20384745e-01f, 5.47597446e-02f,
  -3.27204354e-02f, -1.65081888e-01f, 5.36759607e-02f, -9.60911140e-02f, -2.66634524e-02f, 7.80285196e-03f, -1.90903470e-02f, -1.35033816e-01f, 2.44815974e-03f, -1.79425001e-01f,
  -6.48593381e-02f, 7.79839326e-03f, 1.26875797e-02f, 9.49131791e-03f, -9.61346850e-02f, -7.96864852e-02f, -3.09102423e-03f, 4.51471843e-02f, -6.87939078e-02f, -1.73842013e-02f,
  3.77476551e-02f, 2.05048785e-01f, -1.64355487e-01f, 9.26131383e-03f, -6.56829029e-02f, -1.47479564e-01f, -4.20308497e-04f, -2.10466702e-03f, -7.05738831e-03f, 1.11919433e-01f,
  3.97794647e-03f, -5.95368557e-02f, 8.43892321e-02f, 5.95952682e-02f, 1.87075749e-01f, 1.39220789e-01f, -2.06520304e-01f, -2.83789132e-02f, -3.33310924e-02f, -1.26744192e-02f,
  -3.18246931e-02f, 2.36905478e-02f, -7.93419406e-03f, 2.05506921e-01f, 1.21463193e-02f, 4.30914044e-01f, 1.79380193e-01f, 1.67253584e-01f, 2.28997320e-01f, -2.90485740e-01f,
  2.75266796e-01f, 6.56178519e-02f, 4.27778274e-01f, 1.09842792e-01f, 9.67438817e-02f, 3.15860897e-01f, 3.70420247e-01f, 3.21041703e-01f, 5.34577481e-02f, 8.40229169e-02f,
  -3.64535630e-01f, -5.15205204e-01f, -4.48284179e-01f, -2.45732829e-01f, 2.29760893e-02f, 2.37020567e-01f, 2.56947488e-01f, 2.25156114e-01f, 1.46645412e-01f, 1.48539335e-01f,
  -9.97568890e-02f, 1.06835384e-02f, 2.88594551e-02f, -5.56976208e-03f, -6.44198954e-02f, -2.29319394e-01f, -7.72026554e-02f, -2.48963684e-02f, 7.00802803e-02f, 4.66105305e-02f,
  1.85210500e-02f, 2.57543504e-01f, -3.57065529e-01f, -4.13164139e-01f, -2.97783673e-01f, 6.41939566e-02f, 5.85168898e-02f, -8.61297455e-03f, 1.86662339e-02f, 1.48387074e-01f,
  -1.31187350e-01f, -4.56517190e-02f, 1.14884395e-02f, 2.60903668e-02f, 1.10141635e-01f, 1.99477851e-01f, 1.07304722e-01f, 1.24319114e-01f, 5.35798520e-02f, 4.79964204e-02f,
  -7.37363622e-02f, 1.35286421e-01f, 1.84270397e-01f, -3.07004116e-02f, -1.04742728e-01f, -2.56583765e-02f, -7.41818622e-02f, -6.70210123e-02f, 7.41659403e-02f, -4.81008971e-03f,
  -3.27579200e-01f, -1.49053559e-01f, -2.44210422e-01f, 2.95474827e-02f, 4.44862545e-02f, 8.83973613e-02f, 2.39959806e-01f, 5.99441417e-02f, -2.80420836e-02f, 1.42216370e-01f,
  1.97567850e-01f, 1.27567843e-01f, 2.54533470e-01f, 9.05034617e-02f, -7.75520056e-02f, 1.23660646e-01f, 2.39110425e-01f, 2.29432750e-02f, -6.14781119e-02f, -4.61037941e-02f,
  1.03366904e-01f, 1.20109037e-01f, -2.71097776e-02f, 6.30536675e-02f, 1.73770458e-01f, 6.69095963e-02f, -8.62389430e-03f, 4.65069665e-03f, -7.31237084e-02f, 1.79057702e-01f,
  -3.38151991e-01f, -1.64563537e-01f, -2.35852987e-01f, 4.08583600e-03f, 3.38808447e-02f, -3.16558331e-02f, -1.97951302e-01f, -2.20142286e-02f, 3.60438377e-02f, 6.50122538e-02f,
  2.65548863e-02f, -4.64740267e-04f, 2.77421363e-02f, 1.18411973e-01f, 8.14729929e-02f, 1.38641596e-01f, -1.14154413e-01f, 5.71302362e-02f, 9.74234752e-03f, 1.05725706e-01f,
  9.60909110e-03f, 9.45092216e-02f, 1.93768099e-01f, 8.84302333e-02f, -6.90014958e-02f, -5.87909259e-02f, 3.32728177e-02f, 5.93655668e-02f, 2.03867361e-01f, 8.88702199e-02f,
  8.18712115e-01f, 2.01717928e-01f, -2.21332595e-01f, 2.53952295e-02f, 2.84695555e-03f, 2.65166789e-01f, 2.78557956e-01f, 2.26804584e-01f, 2.42361296e-02f, 1.81502715e-01f,
  2.36170739e-01f, 2.32686967e-01f, 1.91547528e-01f, 1.24051571e-01f, 1.57952696e-01f, -3.47619802e-02f, -1.05217718e-01f, 4.31909524e-02f, -5.53478859e-02f, 1.52380437e-01f,
  1.00533262e-01f, 2.01402694e-01f, 1.49207294e-01f, 9.05414745e-02f, -1.32962391e-01f, -8.80388170e-02f, 1.10281505e-01f, 1.69753119e-01f, 9.96224880e-02f, -1.95702478e-01f,
  -2.56457359e-01f, 2.38020122e-01f, -1.28314748e-01f, -1.28358519e-02f, 9.20803249e-02f, 4.18282673e-03f, 6.15420006e-03f, 6.19087368e-02f, 1.59876764e-01f, -1.34701347e-02f,
  -9.16009322e-02f, -6.51514977e-02f, 6.83654919e-02f, 3.64259467e-03f, 9.37429965e-02f, -4.41362634e-02f, -5.37529662e-02f, 5.18064089e-02f, 9.16662961e-02f, 7.13850046e-03f,
  -2.83288341e-02f, 1.17450953e-01f, 7.42557943e-02f, -5.52428588e-02f, 5.24368137e-02f, 4.48137559e-02f, 5.69854267e-02f, -8.21490772e-03f, 4.90349866e-02f, -5.95148690e-02f,
  2.20170423e-01f, 3.38284910e-01f, 3.64804268e-01f, 2.20665768e-01f, 2.33643234e-01f, 8.04963410e-02f, -1.61902040e-01f, -2.94640474e-02f, 1.48648322e-01f, 7.40613043e-02f,
  -2.17946202e-01f, 3.60984474e-01f, 3.45725596e-01f, 2.35309839e-01f, 2.17596099e-01f, 2.91505605e-01f, 1.00206815e-01f, 3.05933237e-01f, 3.37669820e-01f, 3.50284278e-01f,
  8.14599916e-03f, -8.18017498e-03f, 1.64659292e-01f, -1.44807734e-02f, -1.69683602e-02f, 7.93548375e-02f, 1.90531418e-01f, 2.38001421e-01f, 2.19344005e-01f, 3.19744498e-01f,
  -1.79233342e-01f, 4.95930701e-01f, -1.43409684e-01f, -3.09114039e-01f, -5.00910133e-02f, -1.36525035e-01f, 7.34744594e-03f, -5.44849262e-02f, -6.18572533e-02f, -1.44292563e-01f,
  -2.63944209e-01f, -1.15725629e-01f, 2.58706603e-02f, 7.57370666e-02f, 3.91526818e-02f, -1.34488314e-01f, 7.17706680e-02f, -6.89887777e-02f, -2.02985778e-02f, -2.32093021e-01f,
  -8.65317658e-02f, 1.19471364e-02f, -1.43758044e-01f, -1.12417631e-01f, 1.36066945e-02f, -9.82447565e-02f, -1.15774684e-01f, 1.33619702e-03f, 6.37960434e-02f, -1.21290199e-02f,
  -9.12248269e-02f, 1.96221888e-01f, 2.86243439e-01f, -1.46665454e-01f, 7.41941810e-01f, 7.47340083e-01f, 7.26149917e-01f, 1.52771980e-01f, -3.02496880e-01f, 1.28305033e-01f,
  2.32354909e-01f, -2.60924041e-01f, -4.02398825e-01f, -2.98144132e-01f, -2.42218539e-01f, 1.48199290e-01f, 1.91955224e-01f, -9.52649266e-02f, -9.62653384e-02f, 2.41501391e-01f,
  2.14258492e-01f, -5.35817584e-03f, -1.41763434e-01f, -1.10620745e-01f, 2.72154715e-02f, -3.14705789e-01f, 7.87522420e-02f, 2.87534446e-01f, 4.17650074e-01f, 5.19899232e-03f,
  1.64931770e-02f, 1.48465216e-01f, -2.12887555e-01f, -5.14559262e-02f, 7.92192817e-02f, -3.88123214e-01f, -1.19495004e-01f, -2.54417241e-01f, -6.14125952e-02f, -2.03741938e-01f,
  9.98399332e-02f, 4.54243235e-02f, 9.53630283e-02f, 1.43864095e-01f, 2.10217655e-01f, 1.14295721e-01f, 4.39297743e-02f, -2.93272257e-01f, -3.03986728e-01f, -1.05598576e-01f,
  1.79866865e-01f, 4.46567297e-01f, 2.24817127e-01f, 2.24743336e-02f, -2.31243238e-01f, -2.91748974e-03f, 1.68830335e-01f, -5.75034730e-02f, -3.47766131e-02f, -3.73269826e-01f,
  -1.90421179e-01f, 1.87257320e-01f, 8.74317065e-02f, -7.37303644e-02f, -3.46402712e-02f, -1.49874210e-01f, -1.50530443e-01f, 1.32338792e-01f, 1.74903601e-01f, 6.08691461e-02f,
  -9.78494659e-02f, -4.74055894e-02f, -1.41721159e-01f, -3.25550467e-01f, -1.79697692e-01f, -1.09308017e-02f, 7.79983252e-02f, -1.64831430e-01f, 7.69547746e-02f, -6.11426495e-02f,
  6.66638836e-02f, -4.71629295e-03f, -1.11896381e-01f, -6.14251755e-02f, -9.62156653e-02f, -2.43563905e-01f, -2.94243276e-01f, -1.35365829e-01f, -1.35410294e-01f, -2.77925450e-02f,
  -4.28086430e-01f, 2.08794206e-01f, -5.31901002e-01f, -1.82141840e-01f, 2.21358746e-01f, 8.76876339e-02f, 1.57704216e-03f, 4.48991582e-02f, 2.07401454e-01f, -3.52887899e-01f,
  1.01648010e-01f, -1.85243964e-01f, -2.70907898e-02f, 4.69421595e-02f, 4.37084548e-02f, -4.57930602e-02f, 1.97442189e-01f, -1.70718759e-01f, -1.57475099e-01f, -9.77219194e-02f,
  -9.57600996e-02f, 7.98611194e-02f, -1.55742630e-01f, -1.91288635e-01f, -4.22458827e-01f, -3.53373647e-01f, -1.04324952e-01f, -7.33247325e-02f, -3.05833668e-02f, -3.17630917e-01f,
  1.48444965e-01f, -4.31011319e-01f, -4.60201859e-01f, -3.61671180e-01f, -2.95970231e-01f, -2.29642242e-01f, -2.93390304e-01f, -2.35107411e-02f, -1.09557644e-01f, -1.77042380e-01f,
  3.07857823e-02f, 1.55152455e-01f, -5.49143068e-02f, -1.18265539e-01f, -1.94106981e-01f, -5.01809418e-01f, -3.38616431e-01f, -4.20707434e-01f, -5.74371405e-02f, -2.64012907e-02f,
  -1.87467784e-01f, -3.55968893e-01f, -1.56021878e-01f, -1.13192588e-01f, -3.15077573e-01f, -6.89844638e-02f, -3.16414475e-01f, -1.81285724e-01f, -1.76800981e-01f, -5.58986545e-01f,
  -3.34081918e-01f, 2.14805886e-01f, 1.10217802e-01f, 6.56574517e-02f, -7.87755940e-03f, 1.23913944e-01f, -2.23613121e-02f, 1.07489653e-01f, 4.48222011e-02f, -2.02377923e-02f,
  9.24116746e-02f, 7.20719397e-02f, 3.51937078e-02f, 8.84958208e-02f, 3.28514501e-02f, 1.63802981e-01f, 1.43588766e-01f, 1.49327070e-01f, 7.11578727e-02f, -2.66108159e-02f,
  1.24166764e-01f, 1.31696776e-01f, 1.21554218e-01f, 2.06018254e-01f, 1.70265883e-01f, 2.63564855e-01f, 1.60025090e-01f, 2.20762625e-01f, 2.49077782e-01f, 2.07493439e-01f,
  -5.60684726e-02f, 2.13115707e-01f, 8.83076191e-02f, 2.46291161e-01f, 1.45830765e-01f, 1.72571808e-01f, 1.18756287e-01f, 1.69531420e-01f, 1.23493664e-01f, -5.61993830e-02f,
  -1.30376499e-02f, -4.15531918e-03f, 1.23256065e-01f, -7.83994868e-02f, -1.20645456e-01f, -6.55342713e-02f, 1.01503059e-01f, 6.24981262e-02f, -1.86115096e-04f, 1.09723166e-01f,
  3.54648978e-02f, 6.82680234e-02f, -1.87927336e-01f, -1.22026116e-01f, 7.83401579e-02f, 1.61497071e-02f, -3.58578376e-02f, 1.14197256e-02f, 3.83686870e-02f, -3.87440994e-02f,
  1.51708871e-01f, -6.42739013e-02f, -3.44674774e-02f, 8.14459324e-02f, 6.22115610e-03f, -7.21742511e-02f, -4.60109748e-02f, -1.24633946e-01f, -1.35446033e-02f, -2.01898888e-02f,
  1.81118846e-02f, -2.38477681e-02f, -4.40250263e-02f, 8.30293968e-02f, -4.69048060e-02f, 9.10261273e-03f, 1.88609019e-01f, 1.12846933e-01f, 1.03484668e-01f, -9.79997963e-02f,
  -1.25665024e-01f, 1.86943904e-01f, 6.10213205e-02f, 1.16356760e-01f, 1.81901842e-01f, 1.37724310e-01f, -6.50254786e-02f, 1.03290882e-02f, 9.02648363e-03f, -2.29639877e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.61365998e-01f, 1.09372839e-01f, 6.89884484e-01f, 6.30894542e-01f, 4.71753210e-01f, 5.60879052e-01f, 5.88060319e-01f, 5.85005343e-01f, 7.38066018e-01f, 7.14822114e-01f,
  3.75715405e-01f, 3.95091265e-01f, 8.80459428e-01f, 4.07355845e-01f, 4.49305326e-01f, 6.01457715e-01f, 6.39480770e-01f, 4.96382326e-01f, 9.37889159e-01f, 6.41284347e-01f,
  5.92522085e-01f, 9.64967787e-01f, 7.77695298e-01f, 6.79587901e-01f, 5.37548602e-01f, -1.10129513e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.06277592e-01f, 2.32214499e-02f, -4.35461588e-02f, -2.06085518e-02f, 5.93307316e-02f, 1.50079980e-01f, -4.03974727e-02f, -2.17006162e-01f, -2.37529531e-01f, 1.36352524e-01f,
  -1.02052964e-01f, -1.14197232e-01f, -1.05810717e-01f, 2.87789479e-02f, -2.04443708e-01f, -1.32542208e-01f, -1.29000157e-01f, -3.59913893e-02f, -1.80257544e-01f, 9.59120914e-02f,
  -1.20496400e-01f, -1.30860403e-01f, -4.76840399e-02f, 1.73631981e-02f, -7.96885043e-03f, -2.13916466e-01f, -2.29308575e-01f, -4.29911673e-01f, -9.51580852e-02f, -2.17288315e-01f,
  -1.03514999e-01f, -6.74733520e-02f, -2.56010979e-01f, -9.38490853e-02f, 1.52656371e-02f, -2.35789001e-01f, -8.12992007e-02f, -1.17571957e-01f, 8.23963359e-02f, 5.86014315e-02f,
  -8.00319463e-02f, -5.42222783e-02f, 9.23766941e-03f, -1.69526294e-01f, 1.01445848e-02f, -3.87139410e-01f, -7.75721520e-02f, 4.93726879e-02f, 1.49929717e-01f, -2.38598779e-01f,
  -3.29831183e-01f, -3.00985694e-01f, -9.82412323e-02f, 2.72566248e-02f, 2.46863127e-01f, 2.76144296e-01f, 3.34970839e-02f, 1.96898058e-01f, 1.23810932e-01f, -7.91190118e-02f,
  -3.09693273e-02f, 4.36142869e-02f, -4.80556451e-02f, 1.34875566e-01f, -1.64657220e-01f, -5.12090981e-01f, -1.06251808e-02f, -2.24829800e-02f, 2.42607445e-01f, -2.02562232e-02f,
  -1.49481907e-01f, 1.51464164e-01f, -2.08712488e-01f, 1.22259244e-01f, -6.47314033e-03f, -7.94354528e-02f, 1.33545637e-01f, 9.18723345e-02f, 1.02115482e-01f, -1.25528768e-01f,
  -2.35931605e-01f, -2.82293439e-01f, 2.03778222e-01f, 3.08788177e-02f, 2.51385778e-01f, 6.11848608e-02f, -1.64186314e-01f, 8.56743157e-02f, 2.37009123e-01f, 6.83133975e-02f,
  1.00654021e-01f, 2.97754347e-01f, -1.72405660e-01f, -7.95955509e-02f, -1.21250525e-01f, -5.02848439e-02f, -3.21560651e-02f, 6.98634759e-02f, -3.61639768e-01f, 2.47361753e-02f,
  8.94691944e-02f, -6.48799632e-03f, -4.08062577e-01f, -2.37176090e-01f, -4.79404926e-01f, -3.55080850e-02f, -1.02988076e+00f, 8.57110918e-02f, -7.41165400e-01f, 4.82710361e-01f,
  -3.18857014e-01f, -5.17219245e-01f, -5.76412082e-01f, -5.29596329e-01f, 4.03810263e-01f, 3.31807733e-01f, -2.61403233e-01f, 4.51545209e-01f, -2.90761143e-01f, -1.30731687e-01f,
  3.78405035e-01f, 3.98264766e-01f, 5.77667542e-02f, 4.53790352e-02f, -5.10752439e-01f, -5.41084886e-01f, -3.91707063e-01f, 4.47159559e-01f, -1.99448112e-02f, 5.51740592e-03f,
  -5.87314740e-02f, -6.85817301e-02f, 4.28320607e-03f, -1.29346224e-02f, 6.54458907e-03f, 1.04341060e-01f, 1.85660586e-01f, -1.34103775e-01f, 9.27751735e-02f, 2.32234523e-01f,
  1.27142906e-01f, 7.26781487e-02f, 9.85739678e-02f, -1.81931615e-01f, -3.05561498e-02f, -4.13450506e-03f, 4.66111414e-02f, 2.44635314e-01f, 4.71995398e-02f, 9.54469591e-02f,
  3.27598341e-02f, -3.01205873e-01f, -9.42797773e-03f, 1.69188485e-01f, 3.34632844e-02f, 1.56069458e-01f, 6.63356781e-02f, -1.64693162e-01f, -2.02196568e-01f, 1.51029468e-01f,
  1.67989060e-01f, -8.70972052e-02f, -2.07175016e-02f, -4.92190607e-02f, 2.31853295e-02f, -1.56145310e-02f, -1.21497512e-01f, -1.83444560e-01f, 1.95696697e-01f, -4.59422171e-03f,
  -5.00296839e-02f, -7.20091909e-02f, -1.77612260e-01f, -1.57605067e-01f, -3.06808203e-02f, 2.32193749e-02f, 1.68504506e-01f, -2.39413857e-01f, 1.18172280e-01f, -6.00011982e-02f,
  2.24021673e-01f, 9.06173959e-02f, -2.20197022e-01f, -1.54529124e-01f, -2.08038554e-01f, 2.50522226e-01f, -3.07601281e-02f, 3.98322493e-02f, 3.12949032e-01f, -6.94549009e-02f,
  -3.01646739e-01f, -9.11996663e-02f, -1.99173614e-01f, -1.09631643e-01f, -6.31835088e-02f, -3.37207951e-02f, -2.10696578e-01f, -2.29941428e-01f, 1.23427220e-01f, 6.71124756e-02f,
  -6.70748502e-02f, 8.17393288e-02f, 6.59145787e-02f, 2.19794422e-01f, -6.70058131e-02f, 1.83407784e-01f, 3.40144157e-01f, 1.84695840e-01f, 9.42561030e-02f, -1.86513543e-01f,
  1.26369610e-01f, 2.80758273e-02f, -2.39056572e-01f, -2.24111713e-02f, 2.11929763e-03f, 2.00278446e-01f, 7.85779059e-02f, -2.18068630e-01f, -2.65085697e-01f, 9.31837708e-02f,
  -1.93512976e-01f, -1.68763533e-01f, -1.67431712e-01f, 5.84531464e-02f, 5.73487207e-03f, -2.45488212e-01f, -1.43207327e-01f, -7.98845589e-02f, -1.41064345e-03f, 2.36616910e-01f,
  3.54262218e-02f, 2.42618229e-02f, 2.37527087e-01f, -2.43301559e-02f, -7.33265638e-01f, 2.00386867e-01f, -6.84023380e-01f, -5.04529737e-02f, 5.00041544e-01f, -7.73335338e-01f,
  -6.02422953e-01f, -1.94457740e-01f, -1.20723033e+00f, -4.56415892e-01f, -7.74468541e-01f, -5.45067668e-01f, -9.47135925e-01f, 4.89448428e-01f, -4.03291464e-01f, 1.10042799e+00f,
  4.24462676e-01f, 1.41386166e-01f, -3.02822709e-01f, 2.21921489e-01f, -3.25667620e-01f, 1.73383176e-01f, 9.94477347e-02f, 1.01525813e-01f, 6.15317300e-02f, 1.17889948e-01f,
  -1.57799602e-01f, 2.32079718e-02f, -8.88810083e-02f, 1.51790932e-01f, 4.75832559e-02f, -7.34224841e-02f, 1.13373533e-01f, -1.42426267e-01f, -2.90353119e-01f, -3.40643935e-02f,
  -2.01971587e-02f, 4.35138727e-03f, 2.17686072e-01f, 2.30252162e-01f, 1.61208630e-01f, 2.85081696e-02f, 6.58596382e-02f, 2.17213156e-03f, -8.24472234e-02f, 1.87903211e-01f,
  8.26779604e-02f, 1.31019220e-01f, -9.15421471e-02f, 2.32375860e-02f, 4.86475751e-02f, -2.75021195e-02f, -3.69004793e-02f, -9.88015383e-02f, 4.98231277e-02f, 6.33941367e-02f,
  5.43732494e-02f, 2.78426278e-02f, 7.30959028e-02f, 1.77500680e-01f, 1.45672306e-01f, 5.61634749e-02f, -1.02660740e-02f, 4.16012928e-02f, 1.49976119e-01f, 5.54526970e-02f,
  2.11573854e-01f, 3.74095291e-02f, 2.53208607e-01f, -8.10177550e-02f, 1.27065312e-02f, 4.48890142e-02f, 4.30580880e-03f, -2.59227037e-01f, -1.97040904e-02f, 1.19601481e-01f,
  -3.61234635e-01f, -2.39608377e-01f, 4.68884967e-02f, 3.52497935e-01f, 8.42047185e-02f, 3.25327218e-01f, 2.63895243e-01f, 4.44357879e-02f, -3.25381130e-01f, -2.56748140e-01f,
  -2.58515745e-01f, -7.58934394e-02f, 4.17569041e-01f, -3.06107014e-01f, 1.81879535e-01f, -2.17735082e-01f, -1.24881854e-02f, 3.17500502e-01f, -2.73364753e-01f, 2.22018927e-01f,
  1.58533603e-01f, 2.59168416e-01f, -1.35140210e-01f, -3.85204166e-01f, -7.04965591e-02f, 2.93090194e-01f, -9.21619982e-02f, -1.64290741e-01f, 2.00093493e-01f, 2.24778175e-01f,
  1.36355430e-01f, 1.78020105e-01f, 2.89769381e-01f, -1.18984163e-01f, -7.31083527e-02f, 1.25687957e-01f, -2.09745929e-01f, -1.75149530e-01f, -1.23559579e-01f, 1.00457050e-01f,
  1.65547252e-01f, 2.08214492e-01f, 1.53149188e-01f, 2.07584891e-02f, 1.20906547e-01f, 3.54975201e-02f, 2.01831773e-01f, -8.22443366e-02f, -1.65449437e-02f, -7.32683361e-01f,
  -3.90090831e-02f, 2.41771594e-01f, 2.05802575e-01f, 3.29178303e-01f, 1.64858401e-01f, 3.70649397e-01f, 2.35333353e-01f, -4.83639359e-01f, -2.83617437e-01f, -4.24366415e-01f,
  5.73783100e-01f, -6.45947933e-01f, -1.73153073e-01f, 6.43539667e-01f, -5.40761054e-01f, -1.68887749e-01f, -7.48142421e-01f, -9.00746435e-02f, -1.06592190e+00f, 6.26408100e-01f,
  -4.09112483e-01f, -4.86292057e-02f, -4.89221632e-01f, -8.07064548e-02f, -1.24907838e-02f, -1.51398227e-01f, -3.63968126e-03f, -7.88450092e-02f, -1.18141182e-01f, 1.26064941e-01f,
  2.20697336e-02f, -1.55794114e-01f, -2.25259408e-01f, -2.97356844e-01f, -5.19470312e-03f, 1.85098365e-01f, 2.62735248e-01f, 7.40868971e-02f, 8.71482119e-02f, 1.91000834e-01f,
  -7.77488053e-02f, -2.43870139e-01f, 8.64635035e-02f, -5.64114526e-02f, -2.40266055e-01f, -6.19716980e-02f, -1.00811161e-01f, 2.13619992e-01f, 1.80785190e-02f, -1.53792337e-01f,
  -4.21636730e-01f, -2.75397927e-01f, -2.32463911e-01f, -2.60788172e-01f, -5.11755235e-03f, 8.16577002e-02f, 4.81957421e-02f, 5.77948568e-03f, 1.13278637e-02f, 2.08795264e-01f,
  -1.08502440e-01f, -1.61444470e-01f, -6.67189240e-01f, -1.13064423e-01f, -3.26877832e-02f, 8.13531131e-03f, -7.01193437e-02f, -3.86891067e-02f, 6.08747751e-02f, 2.39182502e-01f,
  -2.63764441e-01f, 1.06043719e-01f, -1.61979884e-01f, 3.37529898e-01f, 1.57783419e-01f, 5.85413948e-02f, 3.17558385e-02f, 4.44733836e-02f, 1.21131554e-01f, 2.27120385e-01f,
  -2.22696155e-01f, 1.33353600e-03f, -1.83169097e-01f, 9.37568620e-02f, -2.76453197e-01f, -1.19509742e-01f, 3.88320237e-01f, -4.44087863e-01f, 1.60208363e-02f, 3.31469387e-01f,
  -1.39206707e-01f, 4.65378240e-02f, 4.83295947e-01f, -1.41797230e-01f, -4.39559855e-02f, 3.17496598e-01f, 5.95338881e-01f, -1.49027377e-01f, -2.51607448e-01f, -1.85880825e-01f,
  1.77121937e-01f, 8.75997916e-02f, 3.61155331e-01f, -2.45817021e-01f, -3.68339211e-01f, 5.75706422e-01f, -4.04047519e-02f, 1.02303579e-01f, 3.61746222e-01f, 1.11292839e-01f,
  1.79130957e-01f, 3.39275688e-01f, 1.96287185e-01f, 5.36406159e-01f, 2.69050956e-01f, 2.63965428e-01f, 5.42599447e-02f, -1.06080428e-01f, 1.04861818e-01f, -1.59583658e-01f,
  -1.16180256e-01f, -3.20190843e-03f, 4.73935865e-02f, -6.41730428e-01f, 2.02837750e-01f, 2.09331974e-01f, -2.14873552e-01f, -5.30429125e-01f, -7.48382866e-01f, -8.83451700e-01f,
  4.77757752e-01f, -4.64558005e-01f, -1.29510331e+00f, 5.12808412e-02f, -2.99441695e-01f, -1.36854813e-01f, 7.51187265e-01f, -2.04047337e-01f, 6.61382139e-01f, -7.91009307e-01f,
  -7.03999698e-02f, -3.36285889e-01f, 2.48179082e-02f, -3.72505277e-01f, -1.44700933e+00f, -6.70147300e-01f, 5.53017914e-01f, -2.94635594e-01f, 1.75676718e-01f, -2.02895761e-01f,
  1.25971332e-01f, -6.05208538e-02f, 3.87893878e-02f, 1.08099729e-02f, -2.22493857e-01f, -3.54227945e-02f, 5.13014533e-02f, -6.83616102e-02f, -1.18494458e-01f, -8.58224928e-02f,
  -8.44942704e-02f, -6.96697235e-02f, 1.05735518e-01f, -2.83830136e-01f, -1.97738990e-01f, -5.18186055e-02f, 1.61533758e-01f, -2.07617238e-01f, -6.92699999e-02f, 9.86087322e-02f,
  -1.12421721e-01f, -1.78168476e-01f, 1.04451540e-03f, 5.53505011e-02f, 1.79897889e-01f, -5.77825755e-02f, -2.94602588e-02f, -4.66809869e-02f, -3.34846489e-02f, 1.67722747e-01f,
  2.81169708e-03f, 2.28610873e-01f, 1.03899524e-01f, 7.62757519e-03f, -1.18789047e-01f, 6.36507273e-02f, 1.16157591e-01f, 1.17666483e-01f, 9.10486728e-02f, -1.90708078e-02f,
  2.21669242e-01f, -6.71980679e-02f, -1.15517408e-01f, -1.80933312e-01f, 1.07785061e-01f, -5.25402687e-02f, 1.64710488e-02f, -9.38396715e-03f, -1.03499912e-01f, -1.60567790e-01f,
  -7.12487195e-03f, 1.85351282e-01f, -1.32347062e-01f, 2.30408441e-02f, -1.06847689e-01f, -1.80745974e-01f, 2.87973017e-01f, 1.45113587e-01f, 2.69904554e-01f, -2.26461709e-01f,
  -1.77364409e-01f, 8.44813883e-02f, -5.45383096e-02f, -1.50188193e-01f, 9.70913246e-02f, 3.26963179e-02f, -1.28621846e-01f, 6.77803680e-02f, -5.83472587e-02f, 2.00031474e-02f,
  -9.82891768e-02f, 2.49466356e-02f, -4.81281318e-02f, -6.87340796e-02f, -1.88199222e-01f, 8.40342864e-02f, -8.00427198e-02f, -6.86409101e-02f, -1.57759562e-02f, 9.93486494e-02f,
  1.19244695e-01f, -1.65662795e-01f, 2.79747695e-02f, -1.68765411e-01f, 6.33808449e-02f, 1.52485788e-01f, -2.20358912e-02f, -8.09130147e-02f, -8.69994983e-03f, -3.01772803e-01f,
  6.31481037e-02f, 8.72414634e-02f, 2.28788033e-01f, -1.46408498e-01f, 1.89343363e-01f, -1.29318342e-01f, -1.64838761e-01f, -3.02774906e-01f, 3.02587152e-01f, -1.86597288e-01f,
  1.27948135e-01f, 2.76197195e-01f, 8.52612108e-02f, 9.60871875e-02f, 1.01362124e-01f, 1.56203315e-01f, -2.93978035e-01f, 6.03620559e-02f, 5.07027864e-01f, -1.78487882e-01f,
  6.46721005e-01f, 1.56526938e-01f, -3.54907811e-02f, 5.24088681e-01f, -3.25865507e-01f, 5.26629031e-01f, -2.69518524e-01f, -6.18299544e-01f, 6.78591728e-01f, -2.34970272e-01f,
  5.40554583e-01f, -4.55706507e-01f, -5.27082145e-01f, -4.03568119e-01f, -3.85294497e-01f, -8.07598680e-02f, 2.82798987e-02f, -2.35723823e-01f, -8.84585798e-01f, -1.31527662e-01f,
  3.59162688e-02f, 2.80700475e-01f, 5.06242886e-02f, 5.52931689e-02f, 1.31561995e-01f, 3.13832998e-01f, 1.58317208e-01f, 9.52145904e-02f, 7.02092722e-02f, 2.08733350e-01f,
  1.88176796e-01f, 8.61117989e-02f, -9.29564759e-02f, 9.00978372e-02f, 6.83468059e-02f, 2.71385740e-02f, 1.62346512e-01f, 4.19458561e-02f, 2.16612034e-02f, 8.34887102e-03f,
  2.35999394e-02f, 5.74614033e-02f, -3.97876054e-02f, 1.49017021e-01f, -5.02988659e-02f, 1.24465123e-01f, 1.16418995e-01f, 2.22660661e-01f, 1.47774100e-01f, 1.21035621e-01f,
  2.67108679e-01f, 8.99481475e-02f, 9.29416791e-02f, 1.76324680e-01f, -4.14176062e-02f, -1.32559717e-01f, 2.26693577e-03f, 4.49309824e-03f, 9.76058375e-03f, 2.33066186e-01f,
  -4.41783518e-02f, 8.25839937e-02f, -6.56842627e-03f, 1.20907426e-01f, -1.29356697e-01f, 2.96724796e-01f, 1.84674665e-01f, 9.22547281e-02f, 2.28857100e-02f, 1.55834168e-01f,
  5.19403629e-02f, 8.25041160e-03f, -2.79945340e-02f, -2.59342760e-01f, -1.42302632e-01f, -1.64718866e-01f, 1.47281811e-01f, -1.29612282e-01f, 9.28500295e-03f, -1.87127843e-01f,
  1.18720300e-01f, -1.13354519e-01f, 3.04370135e-01f, 4.06161070e-01f, 3.37955244e-02f, -3.22342902e-01f, -3.27254413e-04f, 1.06263347e-01f, -5.26198208e-01f, -1.03635699e-01f,
  -2.71125406e-01f, -7.59512186e-02f, -7.73841664e-02f, -1.22376263e-01f, -2.22877666e-01f, -8.45852494e-02f, -7.50338659e-02f, 1.57257348e-01f, 1.48003921e-03f, -1.24491595e-01f,
  2.78596312e-01f, -3.85611922e-01f, -7.97663629e-02f, -1.23980299e-01f, -1.12853600e-02f, -1.14253804e-01f, -2.71234840e-01f, -1.74431708e-02f, -3.31416219e-01f, -4.00553614e-01f,
  -9.69921350e-02f, 3.76672029e-01f, 1.38357148e-01f, -1.24036096e-01f, 1.07813943e-02f, -5.73458113e-02f, 2.16000259e-01f, 6.03464432e-03f, -3.34514212e-03f, 3.46294612e-01f,
  3.45163018e-01f, 1.89050704e-01f, -2.47215822e-01f, 1.73215538e-01f, -1.97289302e-03f, 4.18124497e-01f, -9.33301032e-01f, -3.35024923e-01f, 1.66677028e-01f, -2.99773246e-01f,
  -7.91272402e-01f, 2.83667929e-02f, -3.11901331e-01f, -9.46658850e-01f, -9.04768407e-01f, -5.76864839e-01f, -6.84514761e-01f, -6.72091007e-01f, 3.72339576e-01f, -2.18989462e-01f,
  1.38053143e+00f, -5.21697402e-01f, 2.13600427e-01f, -8.45927179e-01f, -3.50475430e-01f, 3.35232556e-01f, -2.85359234e-01f, -1.27552643e-01f, -9.57214390e-04f, 5.42603396e-02f,
  -5.98960742e-03f, -6.70731291e-02f, -1.08841956e-01f, 3.67174745e-02f, -8.14958196e-03f, -9.64091644e-02f, -9.82194319e-02f, 2.21149903e-02f, -1.55643702e-01f, 1.86101109e-01f,
  9.17242244e-02f, -7.00157061e-02f, -7.46988431e-02f, 2.34112665e-02f, -8.97983760e-02f, 6.20383285e-02f, -2.82441601e-02f, 7.69258365e-02f, 2.19542384e-02f, 2.05176815e-01f,
  -3.87664139e-02f, -2.30977282e-01f, 9.33127999e-02f, -3.95415388e-02f, -1.37768760e-01f, 1.05388179e-01f, -7.39473850e-02f, 1.80193871e-01f, -2.59976778e-02f, -2.62414604e-01f,
  1.76970400e-02f, -2.02735774e-02f, -1.51077315e-01f, -1.48426846e-01f, -1.37305614e-02f, -6.14719950e-02f, 7.64976069e-02f, 1.33819088e-01f, -5.55716529e-02f, -6.46096766e-02f,
  -9.14900228e-02f, 5.71703315e-02f, -8.64455327e-02f, 8.78157839e-02f, 2.09815741e-01f, -3.66418511e-02f, -5.48675768e-02f, -3.08123846e-02f, 3.54695916e-02f, 1.94160998e-01f,
  -8.35642293e-02f, 3.52159768e-01f, 1.26626909e-01f, -2.82322019e-01f, 4.17828299e-02f, -2.14961972e-02f, 3.12863678e-01f, -2.06148773e-01f, 1.17152855e-01f, 2.52824336e-01f,
  4.96722192e-01f, -4.99580391e-02f, -9.74808484e-02f, -1.62178110e-02f, 2.16249861e-02f, 1.20611362e-01f, -1.51100144e-01f, 3.97311389e-01f, 2.01951548e-01f, 7.75853470e-02f,
  1.67090416e-01f, 3.90343964e-01f, 2.60573864e-01f, 8.91062543e-02f, -2.58055598e-01f, -2.64248878e-01f, -1.55740321e-01f, 2.83820361e-01f, 2.97628373e-01f, 1.90186307e-01f,
  3.15931171e-01f, -3.60286832e-01f, 2.43428692e-01f, 3.23819101e-01f, 1.50071830e-01f, -1.57192916e-01f, -7.66072571e-02f, -1.32371932e-01f, -9.21197236e-02f, 3.00198108e-01f,
  3.65060240e-01f, 1.94404736e-01f, 3.43197435e-01f, 1.54549986e-01f, -2.96312809e-01f, 1.60360947e-01f, 1.81659192e-01f, 1.91226155e-01f, -1.61384225e-01f, -1.73446238e-01f,
  -7.21780717e-01f, 2.00730026e-01f, -4.53702867e-01f, 2.48210356e-01f, 2.32172891e-01f, 3.81974906e-01f, 6.68069005e-01f, -7.27695286e-01f, -4.40252036e-01f, -3.44104096e-02f,
  -1.14765167e+00f, -7.96669960e-01f, -6.03639483e-01f, 3.59362215e-01f, 2.79184371e-01f, 3.47106934e-01f, -1.17661163e-01f, 4.67120528e-01f, -8.55715454e-01f, -9.78149951e-01f,
  -4.39861119e-01f, -3.98552507e-01f, 3.95969093e-01f, -2.36985326e-01f, -5.75008690e-01f, -6.46188140e-01f, -1.24916479e-01f, -1.11382447e-01f, 1.87012777e-02f, -8.08231905e-02f,
  -3.44585814e-02f, -2.83476204e-01f, 6.36329427e-02f, -3.13156960e-03f, -4.93596634e-03f, -3.42936993e-01f, -7.69958794e-02f, -5.78394271e-02f, -4.29835953e-02f, -8.45751539e-02f,
  -6.31152317e-02f, -2.07157001e-01f, 5.62011153e-02f, 5.37723303e-02f, -1.18489176e-01f, -4.31313440e-02f, -1.52641207e-01f, -1.74605519e-01f, -2.22191885e-01f, -2.98003346e-01f,
  1.11397684e-01f, -2.20939994e-01f, 8.02072510e-02f, -2.30771855e-01f, -2.30121866e-01f, -5.50416820e-02f, -7.22494796e-02f, -8.00499246e-02f, -6.45811111e-02f, -6.90788627e-02f,
  -4.30219769e-02f, -9.56308991e-02f, 1.18069965e-02f, 7.64787346e-02f, -1.59694538e-01f, -7.20602050e-02f, 2.86421422e-02f, -4.16968092e-02f, -3.53894830e-02f, -7.45109990e-02f,
  -1.71233609e-01f, -3.44554603e-01f, 3.20620276e-02f, 1.33770227e-01f, 3.61654051e-02f, -2.20379412e-01f, -1.74043477e-01f, -1.29394472e-01f, -1.77996770e-01f, -1.04027130e-01f,
  6.50059432e-02f, -1.85493618e-01f, 2.61717349e-01f, 1.88638046e-01f, 1.34727255e-01f, 9.67276469e-02f, -1.96397379e-01f, 2.10745588e-01f, -3.86628769e-02f, 5.53342178e-02f,
  1.23091429e-01f, 6.91783614e-03f, 8.95219669e-02f, -1.18632622e-01f, -2.26146411e-02f, 1.35668263e-01f, 3.22722644e-02f, -4.50982898e-02f, -9.29660723e-02f, -1.75645381e-01f,
  1.51473567e-01f, -5.50505482e-02f, -1.12611890e-01f, -1.75020933e-01f, -9.03545767e-02f, -2.10310906e-01f, -1.73530132e-01f, 7.24607408e-02f, -2.24682570e-01f, 2.58871198e-01f,
  1.66715637e-01f, 1.22073054e-01f, 9.55398455e-02f, -1.27451912e-01f, 5.05643636e-02f, 2.43352950e-02f, 2.05485344e-01f, 2.03006104e-01f, -3.19452770e-02f, 1.50807306e-01f,
  -3.53522636e-02f, 9.11896601e-02f, -1.76786453e-01f, -9.01899068e-04f, 7.12256581e-02f, 2.15168774e-01f, -8.34032148e-02f, -5.99284060e-02f, 4.66725022e-01f, 8.21673349e-02f,
  -2.77346671e-01f, -4.07587230e-01f, 6.47906303e-01f, -2.56261975e-01f, -5.34177184e-01f, -7.00155914e-01f, -3.67115974e-01f, -2.49860823e-01f, 6.69538438e-01f, -1.68315381e-01f,
  6.47201896e-01f, 2.59474605e-01f, -2.26332769e-01f, -9.30160582e-01f, -6.33183718e-01f, -2.11738512e-01f, 3.47684175e-01f, -7.13317752e-01f, -7.13936925e-01f, -4.69850063e-01f,
  -1.05755076e-01f, -4.64550853e-01f, 1.27347350e-01f, -4.49546486e-01f, 1.01436928e-01f, 8.77572596e-03f, 8.42014179e-02f, 1.31835371e-01f, 4.18440029e-02f, -2.81522516e-02f,
  1.66329872e-02f, 2.67050825e-02f, -3.06849271e-01f, -3.96590866e-02f, 1.28446937e-01f, 1.61025375e-01f, 2.93650925e-01f, 1.04113765e-01f, 2.29017451e-01f, 3.07759605e-02f,
  1.18745998e-01f, 1.15513348e-03f, 3.31038721e-02f, -1.88009545e-01f, 1.55995637e-01f, -1.48006752e-01f, -9.57772415e-03f, 2.15254811e-04f, 4.78480337e-03f, 6.65610731e-02f,
  1.44521445e-01f, -1.58546418e-01f, -1.26771390e-01f, 3.16740423e-01f, 2.84824669e-01f, -2.09564239e-01f, -1.01739801e-02f, -1.61418393e-01f, -1.71370164e-01f, 6.44184649e-02f,
  -6.11789152e-02f, 4.68012085e-03f, 1.71830952e-01f, 8.65563527e-02f, -5.13413455e-03f, 1.46550480e-02f, 1.08621763e-02f, 4.19601500e-02f, 4.22856659e-02f, 1.59562662e-01f,
  -3.08093727e-01f, 4.13375720e-03f, 1.80519596e-01f, 4.17131558e-02f, -1.29340559e-01f, -1.65968373e-01f, 1.16948359e-01f, 3.04373413e-01f, -2.52992123e-01f, 9.33304150e-03f,
  -1.97082549e-01f, 4.96331453e-02f, 1.95430562e-01f, -3.97777826e-01f, 3.07226270e-01f, -1.07883602e-01f, 4.41897333e-01f, 2.33736321e-01f, 1.09472767e-01f, -3.42463642e-01f,
  1.44313946e-01f, -4.16277675e-03f, 4.43603277e-01f, 4.27871555e-01f, 3.68443578e-01f, -1.83995754e-01f, 3.55970562e-01f, -2.20919192e-01f, 1.28073245e-01f, 9.78725031e-02f,
  1.21814013e-01f, -8.49929079e-02f, -6.13097548e-01f, 3.90367717e-01f, -2.37595573e-01f, -3.88732612e-01f, -2.83050507e-01f, -1.30114630e-01f, -3.29538882e-01f, -2.30036914e-01f,
  -4.28949744e-02f, 1.56776890e-01f, -1.64969683e-01f, 2.58363783e-01f, 2.89485604e-01f, -2.91557223e-01f, -3.00301582e-01f, 1.35731669e-02f, -2.82317311e-01f, -2.82502145e-01f,
  -2.84503996e-01f, 3.95389259e-01f, -2.51146346e-01f, -2.53939629e-01f, -2.28186727e-01f, -3.75369161e-01f, 1.38812155e-01f, -4.81856763e-01f, 5.92151284e-01f, -2.48952121e-01f,
  -2.26366058e-01f, -2.82002419e-01f, -2.99780041e-01f, -3.87418866e-01f, 2.78654903e-01f, -9.60858583e-01f, -1.93660095e-01f, -7.41616130e-01f, -5.38450032e-02f, 4.40347880e-01f,
  -5.58809757e-01f, -5.45511067e-01f, -5.76510429e-01f, -1.83538780e-01f, 5.10223433e-02f, -1.07703161e+00f, -3.59627962e-01f, 8.62353563e-01f, 4.17045891e-01f, -7.13043287e-02f,
  3.94274205e-01f, -1.87976643e-01f, 3.28197293e-02f, 9.62850675e-02f, -6.67131767e-02f, -1.69663012e-01f, 1.72272790e-02f, -3.74790579e-01f, -1.70708299e-01f, 7.02463016e-02f,
  1.22830875e-01f, -1.43573917e-02f, 1.90686435e-01f, -1.07691567e-02f, 1.21145835e-02f, -5.00318147e-02f, -7.45419785e-02f, 4.93373163e-02f, 1.24911040e-01f, 1.27500862e-01f,
  1.82935432e-01f, 1.52048916e-01f, -4.79267538e-02f, -2.70779669e-01f, 1.86542451e-01f, 2.80028492e-01f, 2.76225917e-02f, 1.07571706e-01f, -3.52968313e-02f, -2.17589453e-01f,
  1.75598219e-01f, -2.28176177e-01f, -9.44720209e-03f, 2.32840464e-01f, 5.44385090e-02f, 3.53272222e-02f, -1.73069924e-01f, 1.49162576e-01f, -2.71888196e-01f, -5.40009737e-02f,
  -2.80423075e-01f, -1.35074049e-01f, -3.00122276e-02f, 5.59448749e-02f, 1.03787370e-02f, 1.16351210e-01f, -3.63131575e-02f, -4.12169062e-02f, -9.75476429e-02f, 1.16184384e-01f,
  -2.79293418e-01f, -1.90271512e-01f, 3.96653116e-02f, 1.09010525e-01f, 1.72864981e-02f, -3.04537594e-01f, 3.35776776e-01f, 2.12996513e-01f, 2.54030854e-01f, -1.00395337e-01f,
  -2.70913094e-01f, 2.60357738e-01f, -2.01572672e-01f, 1.32313371e-01f, -5.33897579e-01f, -3.28511506e-01f, -3.08522701e-01f, 2.89177954e-01f, -3.46667796e-01f, 2.23906472e-01f,
  -1.84153765e-01f, -4.45652694e-01f, -1.65113330e-01f, -2.25821227e-01f, -2.90949613e-01f, -1.12264104e-01f, 9.68791917e-02f, -1.90348268e-01f, 2.72012409e-02f, 2.11343303e-01f,
  -4.49582666e-01f, -4.55285534e-02f, 1.04112893e-01f, -1.21997982e-01f, -4.54165600e-02f, 1.18718892e-01f, -1.87551603e-01f, -1.39636964e-01f, -4.78451625e-02f, -2.00002685e-01f,
  -1.18685804e-01f, -5.53293705e-01f, -3.32929105e-01f, -3.10247183e-01f, -9.25889239e-02f, 3.92469764e-03f, 9.91158374e-03f, 1.52384639e-01f, 6.71343729e-02f, -2.64969200e-01f,
  -1.40261188e-01f, 3.79537553e-01f, -1.09988727e-01f, 2.22594365e-01f, -7.44105428e-02f, -3.24249715e-01f, 3.36860232e-02f, -8.77987519e-02f, -1.54467553e-01f, 1.67846709e-01f,
  3.86111915e-01f, -4.67513949e-01f, 1.73398182e-01f, 7.01670885e-01f, 5.55315197e-01f, 8.56119335e-01f, -7.27776170e-01f, 5.52485704e-01f, -3.95627499e-01f, 5.89865446e-01f,
  -2.88020015e-01f, -2.92517543e-01f, -3.19406241e-02f, -1.90710276e-01f, -8.23717952e-01f, -1.17204869e+00f, -6.99931383e-01f, 1.23772651e-01f, 1.68891132e-01f, -4.24378157e-01f,
  9.81399193e-02f, 1.67474467e-02f, 2.33849764e-01f, 1.07740730e-01f, 2.28341475e-01f, 7.56389555e-03f, -2.69685071e-02f, 9.99526605e-02f, 2.76612699e-01f, 2.30003059e-01f,
  -2.79150426e-01f, -1.32263139e-01f, 6.53781444e-02f, -7.58093363e-03f, -2.99442887e-01f, 4.28661779e-02f, -1.79017633e-01f, 3.97921205e-02f, -1.17545538e-01f, -2.00359002e-01f,
  1.06822290e-01f, -1.58899147e-02f, 5.77487890e-03f, 2.29018517e-02f, 5.80332875e-02f, -1.99806988e-02f, 8.09516460e-02f, 4.45069164e-01f, 2.43015438e-01f, 8.05061609e-02f,
  8.52582417e-03f, -3.27096842e-02f, 2.81205750e-03f, 2.90840715e-02f, 1.05628423e-01f, 2.33184695e-02f, -9.00257379e-03f, -2.21805777e-02f, 3.43462437e-01f, 2.28892520e-01f,
  -4.11957540e-02f, 1.64729074e-01f, -6.46960065e-02f, -7.70011246e-02f, -2.45726183e-01f, 2.20263600e-01f, 3.09554130e-01f, -1.19121738e-01f, -1.05417378e-01f, 2.13515371e-01f,
  2.74189144e-01f, 1.17899068e-02f, 8.36851224e-02f, 9.57829878e-03f, -2.00968012e-01f, -1.36027738e-01f, -3.98299277e-01f, -1.25921652e-01f, -2.74010032e-01f, -2.02697277e-01f,
  -1.54799968e-01f, -2.56336480e-01f, -5.45971274e-01f, 3.32001559e-02f, 2.17111900e-01f, 6.37483537e-01f, -2.03384176e-01f, -3.24704111e-01f, 3.68906200e-01f, -1.50239527e-01f,
  -3.34099740e-01f, -8.66267830e-02f, 4.70538646e-01f, -7.81263784e-02f, -2.97128022e-01f, -1.63425267e-01f, 1.87993705e-01f, 3.20509225e-01f, -6.77931383e-02f, -3.69331092e-01f,
  -5.75300157e-01f, 1.04141617e+00f, -5.40900469e-01f, -2.94754148e-01f, -3.11169446e-01f, -1.43191591e-01f, -2.61368245e-01f, -3.36228758e-02f, 1.74571961e-01f, -2.94383883e-01f,
  -1.22424632e-01f, -4.93187845e-01f, 5.78014329e-02f, -1.60565257e-01f, 3.51833522e-01f, -1.64864779e-01f, -5.10679662e-01f, 2.01413836e-02f, 2.67571509e-01f, -6.19048119e-01f,
  -5.32050431e-01f, -1.72275871e-01f, 2.51550488e-02f, -3.56279433e-01f, -3.28465939e-01f, -9.37712073e-01f, -1.96779147e-01f, -5.12817323e-01f, -5.16096890e-01f, -1.01550794e+00f,
  -9.66745913e-01f, 8.10935318e-01f, 3.17774899e-03f, -5.79561472e-01f, -7.23916650e-01f, -2.95954674e-01f, -6.91529632e-01f, -5.77974200e-01f, -7.60818303e-01f, -6.10586256e-02f,
  -3.79696995e-01f, 4.38831568e-01f, 4.76552583e-02f, 6.73138380e-01f, -4.95906174e-01f, -3.12110335e-01f, -6.96047693e-02f, -1.27452165e-01f, -4.82411683e-02f, 1.58084091e-02f,
  -4.20171283e-02f, 1.28502637e-01f, -2.03938857e-02f, 1.61870420e-01f, 4.47865836e-02f, -2.95678675e-01f, 9.37992632e-02f, 1.31917745e-01f, -1.16201989e-01f, -3.80683362e-01f,
  7.44637847e-02f, -7.54266754e-02f, -1.03893496e-01f, 1.06333084e-01f, -3.08408320e-01f, -7.77673125e-02f, -2.91755676e-01f, -2.99142927e-01f, -2.46484876e-02f, 8.87958258e-02f,
  1.38221458e-01f, 1.42267153e-01f, 3.48870680e-02f, 8.01783055e-02f, 1.08463436e-01f, 9.14427638e-02f, 1.00545414e-01f, -2.67168134e-01f, -2.71587640e-01f, 6.67218715e-02f,
  -2.77304612e-02f, 1.74967945e-01f, 1.53130934e-01f, -3.70561630e-02f, 1.92006469e-01f, 6.33633733e-02f, -8.26404393e-02f, 5.50014488e-02f, 5.36820851e-02f, -1.25203073e-01f,
  -9.52951908e-02f, 3.09929270e-02f, 4.45556417e-02f, 2.01501884e-02f, 6.52294233e-03f, 9.78763774e-02f, -8.28829557e-02f, 5.82368262e-02f, 1.57904059e-01f, 3.71727645e-01f,
  1.00957416e-01f, -1.21350802e-01f, -2.63389032e-02f, 5.28047919e-01f, -3.79200995e-01f, -2.82081962e-01f, 1.22127421e-01f, -1.62582695e-01f, -2.73292959e-01f, 1.30637705e-01f,
  1.99805781e-01f, 1.40651092e-01f, 1.91032723e-01f, 2.60346621e-01f, 4.42841239e-02f, 1.15299582e-01f, -2.60357857e-01f, 1.91773802e-01f, 2.05938652e-01f, 4.01402684e-03f,
  2.20006958e-01f, -5.94771430e-02f, 1.35963485e-01f, 4.88914549e-02f, -1.18317850e-01f, 3.53638679e-02f, 7.13485718e-01f, 2.85530984e-01f, 3.30771804e-01f, 7.07749128e-01f,
  7.09094405e-02f, -8.64584348e-04f, 3.88220727e-01f, 5.25508560e-02f, 9.22642127e-02f, 2.86294967e-01f, -1.03493243e-01f, 5.63507676e-01f, 2.35209033e-01f, 6.20126314e-02f,
  4.53466773e-01f, 2.71532834e-01f, -3.11842322e-01f, 2.05380976e-01f, 1.70897633e-01f, 2.55227149e-01f, -1.62806958e-01f, -2.54711181e-01f, -1.33774191e-01f, 2.35483840e-01f,
  -8.14195216e-01f, 2.06004545e-01f, -1.89235613e-01f, -4.78949577e-01f, 5.57662994e-02f, -6.03196993e-02f, -3.26916873e-01f, -2.69619584e-01f, 1.15206477e-03f, -2.81486839e-01f,
  -1.11385547e-01f, 6.02792501e-01f, -8.83112103e-02f, -2.75852501e-01f, 6.53264105e-01f, -8.81914139e-01f, -2.38789748e-02f, 1.87332720e-01f, -9.01649833e-01f, -3.42303365e-01f,
  -5.40242732e-01f, -5.28507471e-01f, 5.29014468e-01f, 4.49024469e-01f, 8.47356558e-01f, -9.58964899e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.02254011e-01f, -1.56540409e-01f, 2.18915641e-01f, -1.85340904e-02f, -1.22868083e-01f, 1.28509663e-02f, 1.28510101e-02f, 1.17435962e-01f, -3.90845612e-02f, 1.95953120e-02f,
  2.40893930e-01f, 3.00719012e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    