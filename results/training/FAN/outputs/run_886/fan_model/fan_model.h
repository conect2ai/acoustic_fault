/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.24612072e-01f, -2.91189641e-01f, -8.96327272e-02f, -6.62842914e-02f, -1.20436050e-01f, -8.36114436e-02f, -1.18096292e-01f, 1.12770878e-01f, 1.20922729e-01f, -1.33859053e-01f,
  -7.54601806e-02f, 1.65659323e-01f, 1.43887311e-01f, 1.30741119e-01f, 1.86776519e-01f, -1.20530605e-01f, -1.24406539e-01f, 2.31298581e-01f, 4.13053095e-01f, 1.78754449e-01f,
  9.39351320e-02f, 1.01907402e-01f, 8.17692131e-02f, 6.05600476e-02f, -1.94804251e-01f, -4.47714552e-02f, -9.93093699e-02f, -1.25914648e-01f, -3.25233005e-02f, -2.11196035e-01f,
  -2.55319238e-01f, -1.66672140e-01f, 1.60430834e-01f, -2.37007011e-02f, -1.01575747e-01f, 8.11665207e-02f, -2.41806218e-03f, -1.05670415e-01f, -9.39550437e-03f, -9.28571522e-02f,
  2.85038147e-02f, 3.06058545e-02f, -6.22477829e-02f, -5.72744291e-03f, -1.61752570e-02f, 1.17851784e-02f, -3.05162705e-02f, 1.30872011e-01f, 6.08520731e-02f, -5.24138846e-02f,
  -7.32030421e-02f, -7.88355321e-02f, -1.74362019e-01f, 4.56242897e-02f, -4.92498577e-02f, 1.17608182e-01f, -1.34202361e-01f, -7.10886270e-02f, 3.48815247e-02f, -1.02901131e-01f,
  7.85756856e-02f, 4.83548716e-02f, 2.73719057e-03f, 1.85657712e-03f, -2.93067433e-02f, 1.83733702e-02f, -3.29103582e-02f, -4.56976071e-02f, 3.10781263e-02f, -8.05379525e-02f,
  7.76535198e-02f, 1.70368720e-02f, 8.69404003e-02f, 9.03125678e-04f, -3.34664769e-02f, -3.87379602e-02f, -9.81243327e-03f, -4.54937443e-02f, 4.95542539e-03f, 2.91800275e-02f,
  6.77297339e-02f, -1.92136094e-02f, -4.16675620e-02f, -5.57615247e-04f, -3.19867022e-02f, 8.35386291e-03f, 1.25275990e-02f, 5.53617217e-02f, -3.22420262e-02f, -5.39522134e-02f,
  -1.34814516e-01f, 1.32676423e-01f, -1.89679780e-03f, 4.74812537e-02f, -2.27888022e-02f, -4.85812537e-02f, -2.38467585e-02f, 2.47853547e-02f, -1.27609093e-02f, 4.30318043e-02f,
  -1.82666518e-02f, 8.17731991e-02f, -6.19247630e-02f, -2.52033137e-02f, 6.17676079e-02f, -4.90655042e-02f, -6.14945814e-02f, -3.08333468e-02f, 5.43785393e-02f, -9.94435325e-02f,
  -3.22953276e-02f, 4.71046846e-03f, 9.40531269e-02f, 8.58880207e-02f, 3.58074978e-02f, 1.43371791e-01f, -2.43561417e-02f, 3.59030925e-02f, 1.16605744e-01f, -2.85068550e-03f,
  2.58014917e-01f, -1.72289416e-01f, -2.86646217e-01f, 1.00393509e-02f, -1.34222224e-01f, -2.20754698e-01f, -2.80136406e-01f, -2.69547924e-02f, 1.23774864e-01f, -1.89815640e-01f,
  1.27288148e-01f, 2.68162668e-01f, 2.44757026e-01f, 2.34317496e-01f, -1.28346235e-02f, -2.99131900e-01f, -3.50239813e-01f, -9.37915500e-03f, 1.46141768e-01f, 7.82072619e-02f,
  -3.67378667e-02f, -4.61403653e-02f, 1.99405983e-01f, 4.66602780e-02f, -1.37354601e-02f, 1.63719401e-01f, -2.06313938e-01f, 7.89524391e-02f, -1.04180619e-01f, -4.62626293e-02f,
  -1.25739872e-02f, 1.53359100e-01f, -3.68301524e-03f, 5.32808676e-02f, 6.94759041e-02f, -3.45716141e-02f, -9.40553397e-02f, 5.01797497e-02f, 7.36463666e-02f, 4.16180072e-03f,
  7.25234253e-03f, 1.76518988e-02f, -1.18019097e-02f, 5.35664819e-02f, -4.03170735e-02f, 3.42241898e-02f, -1.04233902e-02f, -3.56041342e-02f, -2.49757487e-02f, -3.27952430e-02f,
  1.24063101e-02f, 2.44557224e-02f, 2.17325017e-02f, -1.29449666e-01f, 7.59664699e-02f, 2.47302018e-02f, -5.71772980e-04f, 8.34622309e-02f, -1.95935015e-02f, 5.14715090e-02f,
  1.16058365e-02f, -2.33646128e-02f, 1.42188082e-02f, -3.65786739e-02f, 3.47666740e-02f, 2.37021577e-02f, -3.45403813e-02f, -1.47814760e-02f, 5.26387654e-02f, 3.82833704e-02f,
  -1.43096028e-02f, -8.63640336e-04f, -6.10884726e-02f, 3.06472415e-03f, -1.42023731e-02f, 8.49185605e-03f, -1.03513878e-02f, -1.12955444e-01f, 7.23495036e-02f, -1.99019406e-02f,
  1.08676389e-01f, -5.28237075e-02f, 2.56358255e-02f, 1.78919137e-02f, -5.43311499e-02f, 1.44991744e-02f, 4.43863943e-02f, -2.49213912e-02f, 3.70753556e-02f, 2.54436154e-02f,
  1.63120851e-02f, 3.44310030e-02f, -5.73852398e-02f, 8.62197205e-02f, 3.09479460e-02f, 1.67968627e-02f, 1.76776741e-02f, -1.54143954e-02f, 9.22756195e-02f, -5.62988929e-02f,
  5.63502647e-02f, 6.31445199e-02f, -1.08557120e-02f, 7.51442369e-03f, 1.14740785e-02f, 5.75949736e-02f, 7.90014118e-03f, 5.63541278e-02f, -1.82777029e-02f, -6.79500178e-02f,
  -1.45201445e-01f, 3.69728031e-03f, 2.94401962e-02f, -9.41330567e-02f, -3.11133033e-03f, 4.69200090e-02f, -8.27843770e-02f, -6.04356714e-02f, 1.47209065e-02f, -1.83608964e-01f,
  -2.73327231e-01f, 2.49484405e-02f, -6.58199489e-02f, 6.16149120e-02f, -5.75750433e-02f, -3.56701761e-02f, -2.15539962e-01f, -1.53826430e-01f, 6.43240064e-02f, -5.49021736e-03f,
  2.58997828e-02f, -4.59221117e-02f, 5.78125902e-02f, 7.50921294e-03f, -1.59273207e-01f, -8.61549377e-02f, 1.00863732e-01f, 4.79258336e-02f, -9.42596197e-02f, 7.45787024e-02f,
  1.09948792e-01f, 6.16187975e-02f, -3.25533785e-02f, -1.45853069e-02f, 6.91474751e-02f, 6.79251105e-02f, 2.11762916e-02f, 1.58250123e-01f, 6.36224598e-02f, 2.73585171e-01f,
  1.75907165e-02f, -7.53348693e-02f, 2.55409777e-02f, 1.87424589e-02f, 2.66665239e-02f, -1.00099221e-01f, -4.50581945e-02f, 5.08585051e-02f, 2.22262577e-03f, -7.41794854e-02f,
  2.68618725e-02f, 5.75995781e-02f, 3.43971029e-02f, 1.91325471e-02f, 4.51002382e-02f, -4.01277840e-02f, 2.88923662e-02f, -5.32117523e-02f, 4.38068584e-02f, -3.29734161e-02f,
  9.25393701e-02f, 8.04654695e-03f, -1.44223034e-01f, 3.58642489e-02f, -2.16456316e-02f, -4.89675142e-02f, 4.62814867e-02f, -1.92554668e-02f, 2.96908356e-02f, -5.14007034e-03f,
  -3.12919641e-04f, 7.66598731e-02f, 9.77053419e-02f, -6.53968975e-02f, 2.32697036e-02f, 1.63588878e-02f, 9.19301882e-02f, 1.08634522e-02f, 1.69644691e-02f, -2.37836223e-02f,
  3.78533602e-02f, -4.79396433e-02f, 6.52648732e-02f, -8.76580551e-03f, -4.84437831e-02f, 6.88673854e-02f, 9.56346765e-02f, -7.84501135e-02f, -2.98765972e-02f, -3.40911187e-02f,
  -6.25712350e-02f, -4.12972718e-02f, -2.15153769e-02f, 1.38545875e-02f, 5.23897149e-02f, 9.89688784e-02f, -3.52914594e-02f, -4.54494124e-03f, -6.07329607e-02f, 8.47332776e-02f,
  -1.73877567e-01f, -1.59246594e-01f, 3.70116271e-02f, -6.41335675e-04f, -3.40282805e-02f, 5.35661466e-02f, -1.93921439e-02f, 1.00415526e-02f, -2.34761592e-02f, 3.23132426e-02f,
  -9.79732536e-03f, -6.30262047e-02f, -6.30170666e-03f, 7.45352879e-02f, -3.30864899e-02f, 3.08942869e-02f, -1.26162004e-02f, -4.52160612e-02f, -6.32609501e-02f, -5.94350919e-02f,
  5.95230004e-03f, 3.43575981e-03f, -1.22219145e-01f, 3.43172438e-02f, 2.03709360e-02f, 6.80222875e-04f, -2.16053310e-03f, -6.18807934e-02f, -1.27884805e-01f, -7.85965845e-02f,
  -3.96249920e-01f, -1.80251002e-01f, -1.39607906e-01f, -6.12138538e-03f, 8.24230760e-02f, -7.65634552e-02f, -2.24506602e-01f, -1.03470825e-01f, 5.92374336e-03f, -9.41948444e-02f,
  -7.48240054e-02f, 1.39495447e-01f, 1.67940617e-01f, 5.00884801e-02f, -8.56694356e-02f, -6.12438954e-02f, -5.32566197e-02f, 5.10157086e-02f, -2.63885688e-03f, 6.30652457e-02f,
  1.08199582e-01f, -7.89213832e-03f, -1.64664283e-01f, 8.88046771e-02f, 5.98381609e-02f, 8.18230957e-02f, -6.85997233e-02f, 1.95540339e-02f, 1.49647370e-02f, 6.42110631e-02f,
  -1.18682357e-02f, -2.84492999e-01f, 1.89046338e-01f, 1.20558470e-01f, 5.64538781e-03f, -8.23221505e-02f, 3.45192626e-02f, -5.71815446e-02f, 2.71197688e-03f, -8.69678259e-02f,
  -1.49578173e-02f, 9.22397617e-03f, 5.30222841e-02f, 9.89931747e-02f, -8.01827908e-02f, 5.18010221e-02f, 4.34408560e-02f, -5.65708950e-02f, -1.19152687e-01f, -9.92999896e-02f,
  1.33305848e-01f, 8.22104886e-03f, 1.72563475e-02f, 2.82672998e-02f, -6.91730678e-02f, -1.38520626e-02f, -1.21638076e-02f, 6.24020360e-02f, -1.24421064e-02f, -8.18088502e-02f,
  -2.09813695e-02f, 2.54241247e-02f, 7.27394596e-02f, -1.06170522e-02f, -2.24199109e-02f, 9.11443681e-02f, 6.57094596e-03f, 4.08617668e-02f, -5.28234653e-02f, -8.66340287e-03f,
  2.89068483e-02f, -2.95798648e-02f, 5.04677743e-02f, -9.63511392e-02f, 1.24477651e-02f, 5.03325425e-02f, 6.52376888e-03f, 3.62997465e-02f, 2.98876055e-02f, 3.86167280e-02f,
  4.03946601e-02f, 6.11306094e-02f, -2.19820645e-02f, 3.98869775e-02f, -1.88194830e-02f, -2.15208177e-02f, 8.34298655e-02f, -4.68681529e-02f, -2.20460203e-02f, -5.86094521e-02f,
  2.99468394e-02f, -7.01968297e-02f, -7.45707378e-02f, 2.71574892e-02f, -5.89707792e-02f, 7.59281740e-02f, -5.83587177e-02f, -2.58583296e-02f, -3.91342081e-02f, 4.42889035e-02f,
  8.09711870e-03f, -9.58027765e-02f, -9.56881605e-03f, 7.85219222e-02f, -4.12936024e-02f, -6.39358014e-02f, 1.19021703e-02f, 1.33923879e-02f, -6.42156415e-03f, 2.94177122e-02f,
  -4.29743528e-02f, 3.11380178e-02f, -7.19531178e-02f, 1.28769865e-02f, 8.15024152e-02f, 4.78499457e-02f, 5.32282032e-02f, 4.79032286e-03f, -3.45984288e-02f, -1.57249525e-01f,
  -2.05372378e-01f, 2.18718424e-01f, 1.14919856e-01f, -5.16243726e-02f, -3.19383573e-03f, -1.12601273e-01f, 3.96526977e-02f, -5.25665991e-02f, -1.25663996e-01f, 8.18785504e-02f,
  1.03814267e-01f, 6.95124641e-02f, 4.98750992e-02f, 7.15175867e-02f, 4.93188165e-02f, -2.92892437e-02f, 1.04572624e-01f, -9.53985825e-02f, -1.25012323e-01f, -1.77464515e-01f,
  4.31641191e-02f, -7.68011883e-02f, -1.46127015e-01f, -2.31771544e-02f, -8.90840515e-02f, -1.12443656e-01f, 8.44802856e-02f, -2.37530135e-02f, 1.20218292e-01f, 8.36445950e-03f,
  5.60762398e-02f, 1.49986759e-01f, -8.56526196e-03f, 5.55805452e-02f, -5.51918242e-03f, 9.55610257e-03f, 3.09381504e-02f, 6.63672909e-02f, 2.00515985e-02f, 1.43142221e-02f,
  4.41024452e-02f, 2.04396825e-02f, 1.04764655e-01f, -4.75353897e-02f, -9.33653712e-02f, -1.10046111e-01f, 4.82790098e-02f, 3.07890568e-02f, -5.99773452e-02f, 3.82728800e-02f,
  1.45488650e-01f, 4.28110734e-02f, -6.49075657e-02f, 4.58877198e-02f, 7.35971630e-02f, 2.59418581e-02f, -5.70801385e-02f, -9.66499671e-02f, -1.10909671e-01f, -8.76124650e-02f,
  -6.86875917e-03f, 4.06594016e-02f, -2.48831324e-02f, 3.17105614e-02f, -7.25370925e-03f, -1.26373135e-02f, 1.42077710e-02f, 7.65028670e-02f, -1.84474271e-02f, -3.63797434e-02f,
  7.82780349e-02f, -8.32965225e-02f, 5.78121766e-02f, 4.77155074e-02f, -3.31298709e-02f, 1.34160025e-02f, -2.25462485e-02f, 2.44939467e-03f, 9.51051190e-02f, -2.01019179e-02f,
  -4.58283909e-02f, -2.31055245e-02f, 3.56616010e-03f, 2.42428053e-02f, 5.25391474e-02f, 3.22229811e-03f, -4.45646979e-03f, -1.28618870e-02f, -5.71110696e-02f, -8.82947166e-03f,
  -2.10933521e-01f, 2.02819139e-01f, -1.60758063e-01f, -3.70503254e-02f, 3.31081357e-03f, 7.63339596e-03f, -3.21037285e-02f, -1.58657711e-02f, 2.06442699e-02f, -7.68763348e-02f,
  8.62846598e-02f, 4.69831424e-03f, 7.64385462e-02f, -3.82147916e-02f, -5.52137569e-02f, -3.02720275e-02f, -2.36928016e-02f, 1.11356936e-02f, -9.42708403e-02f, -2.26187520e-02f,
  6.94101956e-03f, -1.34386852e-01f, -1.39305800e-01f, -6.66417554e-02f, -5.10652475e-02f, -1.97650626e-01f, -1.18843041e-01f, -2.21812814e-01f, -1.87484547e-01f, -2.77081221e-01f,
  -4.77516681e-01f, -4.70005065e-01f, 1.66771531e-01f, -6.21210448e-02f, 3.64336371e-02f, 6.20868877e-02f, -1.95989907e-01f, -7.69439936e-02f, -7.46176168e-02f, -2.22029388e-01f,
  3.35329846e-02f, 1.93172574e-01f, 2.10131675e-01f, 2.22500861e-01f, 2.09176525e-01f, -2.53592972e-02f, -1.45083562e-01f, 1.39326230e-01f, 3.16470116e-01f, 1.51214540e-01f,
  -5.40083908e-02f, -1.28446996e-01f, -2.11246107e-02f, -4.10499796e-02f, -2.37026706e-01f, -1.67174079e-02f, -1.19663902e-01f, -1.38011023e-01f, -9.26988199e-02f, -2.60569930e-01f,
  1.39416575e-01f, -2.33480468e-01f, 3.06141973e-01f, -5.12225442e-02f, 3.59634236e-02f, -1.47761554e-02f, 4.41643968e-02f, 1.14756441e-02f, 2.31892392e-02f, -6.52703643e-02f,
  3.32506746e-02f, 1.96722616e-02f, -2.13729236e-02f, -1.88968126e-02f, -9.94037278e-03f, 9.53890160e-02f, -3.53007056e-02f, 3.33748385e-02f, 7.68071413e-02f, 4.62408401e-02f,
  -7.75756240e-02f, -8.91912207e-02f, 1.07101001e-01f, 6.81310222e-02f, 7.66393617e-02f, 1.09466851e-01f, 2.97250077e-02f, 8.05886090e-03f, 4.45125699e-02f, -2.06070319e-01f,
  1.38708130e-02f, -3.32628787e-02f, 7.99592584e-03f, -6.45323023e-02f, 1.90377515e-02f, -1.87495782e-03f, 5.08389845e-02f, -3.68696218e-03f, -2.53851386e-03f, -1.87523440e-02f,
  1.71635393e-02f, -1.94930304e-02f, 2.31487434e-02f, -3.93586196e-02f, -2.40288954e-03f, -3.13816145e-02f, 4.22399454e-02f, -9.01868492e-02f, 4.33121696e-02f, -3.75678274e-03f,
  4.75855730e-02f, 7.14047700e-02f, -3.12447101e-02f, 2.15180349e-02f, 2.25787554e-02f, -5.14697656e-02f, 6.66925311e-03f, 1.73630621e-02f, -3.43264565e-02f, -3.32695507e-02f,
  5.65927923e-02f, 2.44794235e-01f, -9.54811722e-02f, 5.98203093e-02f, 2.68800110e-02f, -3.08887591e-03f, -4.62383265e-03f, -2.24571042e-02f, -7.48241171e-02f, -4.34797034e-02f,
  7.93595463e-02f, -2.97903344e-02f, -3.66441645e-02f, -1.13765616e-02f, 9.50426385e-02f, 2.25578193e-02f, -7.01166987e-02f, 1.26833603e-01f, 5.81572950e-02f, -6.79379776e-02f,
  -1.11637421e-01f, 9.38401371e-02f, 1.23815909e-01f, 6.73328936e-02f, -8.48310068e-03f, 8.55414495e-02f, 4.07326184e-02f, 3.74775529e-02f, 2.04320312e-01f, -1.21385552e-01f,
  -2.24379357e-02f, 5.95528400e-03f, 1.74441278e-01f, -1.22285895e-01f, -1.34973198e-01f, -5.81664443e-02f, 1.12708211e-01f, -7.80737102e-02f, -7.12080160e-03f, -1.20109275e-01f,
  -2.02717260e-01f, -1.56843126e-01f, -9.17146653e-02f, 4.13170792e-02f, 3.32792550e-02f, 1.24543481e-01f, 1.72211275e-01f, 1.27007946e-01f, 1.20881177e-01f, -1.04272693e-01f,
  -7.30428696e-02f, 8.27679560e-02f, 1.28424510e-01f, -3.06853764e-02f, -1.98702812e-02f, -1.63518433e-02f, 1.72142982e-01f, 4.39401343e-02f, -7.98798539e-03f, 1.39578670e-01f,
  1.23296700e-01f, -1.65493190e-01f, 3.61266471e-02f, -1.40798628e-01f, -6.19285032e-02f, 5.86544797e-02f, -5.91630451e-02f, 4.85186391e-02f, -7.66262189e-02f, -9.33920220e-03f,
  -1.76418230e-01f, -5.65898940e-02f, -6.35623783e-02f, -9.05064195e-02f, -7.04169869e-02f, 5.12945140e-03f, 6.76319748e-02f, 1.04948811e-01f, 7.98335299e-02f, -6.98481873e-02f,
  -1.82828173e-01f, -7.08952099e-02f, 3.23840789e-02f, -4.99912240e-02f, 9.80482027e-02f, 2.75840666e-02f, 3.72695699e-02f, 7.57742375e-02f, 1.34122625e-01f, 2.19255611e-01f,
  4.42541130e-02f, -2.75010727e-02f, -1.33610908e-02f, -1.56390052e-02f, 4.39975876e-03f, 1.10074657e-03f, -3.91674228e-02f, -3.29347923e-02f, 3.80537584e-02f, 8.72637406e-02f,
  -7.83019420e-03f, -9.30337701e-03f, -1.66376267e-04f, 2.79671550e-02f, -2.47483514e-02f, -8.59884918e-02f, 6.26592785e-02f, 4.17943224e-02f, -7.57909054e-03f, 2.79052909e-02f,
  -6.20785840e-02f, 7.61804134e-02f, -3.37149925e-03f, 4.46652956e-02f, -3.86890732e-02f, -5.12786536e-03f, 6.63866699e-02f, -2.67253187e-03f, -1.15990583e-02f, -7.47069940e-02f,
  9.70348865e-02f, -6.98125139e-02f, 4.40447628e-02f, 8.07512738e-03f, -6.12125807e-02f, -4.69441526e-02f, 8.02257843e-03f, -5.34336157e-02f, -9.72118005e-02f, 5.66465892e-02f,
  -7.19210133e-02f, -6.56120852e-02f, -1.00755371e-01f, 4.92882840e-02f, 5.14817275e-02f, -9.90196038e-03f, -2.44147498e-02f, 5.47940331e-03f, 2.10532174e-02f, -3.25551145e-02f,
  5.41292727e-02f, 8.39639679e-02f, 9.51108783e-02f, 1.61530063e-01f, -1.80499852e-02f, 2.26513250e-03f, 1.54588103e-01f, 1.65387988e-01f, 1.39688432e-01f, 3.31096798e-01f,
  1.69205457e-01f, -1.74075335e-01f, 8.76672342e-02f, 2.73038268e-01f, 1.28042921e-01f, -4.26687934e-02f, -1.48834288e-01f, -1.63643718e-01f, 8.77872184e-02f, 7.84673393e-02f,
  -6.28859401e-02f, -7.80625567e-02f, -1.70666855e-02f, 1.00571476e-01f, 6.44273683e-02f, 9.26710069e-02f, 3.12401682e-01f, 2.03927204e-01f, 1.40447006e-01f, 2.51222104e-02f,
  -3.36063094e-02f, 7.38720000e-02f, 1.34027153e-01f, 1.35104939e-01f, 5.45757189e-02f, 2.53257919e-02f, 1.80006400e-02f, 8.57060254e-02f, 4.03412022e-02f, 2.12299258e-01f,
  1.96520854e-02f, -2.07748920e-01f, 1.15012676e-01f, 3.45525630e-02f, -8.15729871e-02f, -1.00915814e-02f, -7.83580989e-02f, -3.01785152e-02f, -1.19115889e-01f, 7.09138736e-02f,
  -2.18445994e-02f, 2.31019426e-02f, 7.31883869e-02f, -6.66266158e-02f, 2.33775135e-02f, 6.27403855e-02f, 8.76125693e-02f, 1.00593105e-01f, -2.04281639e-02f, -2.08931062e-02f,
  -7.21803457e-02f, -8.13086927e-02f, 2.09233798e-02f, 2.36464366e-02f, -1.29119948e-01f, 5.00374623e-02f, -1.42712578e-01f, -1.39585108e-01f, -5.22531122e-02f, -2.95638689e-03f,
  4.87873778e-02f, -2.54618414e-02f, 2.32737176e-02f, -9.54973511e-03f, 8.12876076e-02f, -6.00839891e-02f, 4.32051681e-02f, 2.72830669e-02f, -2.52426439e-03f, 5.23669720e-02f,
  -8.33611353e-04f, -2.11789533e-02f, -4.77724820e-02f, 4.77439053e-02f, 5.49378283e-02f, 4.26880755e-02f, -5.60418889e-02f, -3.06910481e-02f, 4.61851768e-02f, 4.06693369e-02f,
  -8.00370239e-03f, 7.46770250e-03f, -5.75818308e-02f, -4.18225676e-02f, -6.76363753e-03f, 5.58515452e-02f, -4.80705835e-02f, 8.08056071e-03f, -3.01976930e-02f, 9.31299571e-03f,
  6.90886155e-02f, -1.69534102e-01f, 6.21471554e-02f, 5.82676344e-02f, 3.61433849e-02f, -3.87344211e-02f, -3.65020372e-02f, 4.31386977e-02f, 3.43750007e-02f, -4.93313223e-02f,
  -9.04597193e-02f, -4.83921058e-02f, -3.37745138e-02f, -5.02388924e-04f, 7.31342211e-02f, -1.67550296e-02f, -1.52466381e-02f, 4.30190973e-02f, 8.11459124e-02f, -2.14727763e-02f,
  7.57246837e-02f, 2.28254423e-02f, 1.07033037e-01f, -4.76574935e-02f, 8.74663442e-02f, 5.62247634e-02f, -9.16616693e-02f, 1.86887644e-02f, -5.13229072e-02f, -3.20577435e-02f,
  -9.05886143e-02f, -2.55298048e-01f, -1.61668733e-01f, -3.10419828e-01f, -2.04575643e-01f, -1.11424744e-01f, -5.75083457e-02f, -5.23857176e-02f, -2.68986598e-02f, -1.05583988e-01f,
  -1.05788238e-01f, 2.34012622e-02f, 1.97625495e-02f, 9.22353342e-02f, 1.27634928e-01f, -1.46812454e-01f, -8.85165036e-02f, 7.13815317e-02f, 9.88071486e-02f, -3.00128125e-02f,
  -1.45742774e-01f, -1.10243544e-01f, -4.42530997e-02f, 1.18214659e-01f, -3.95655110e-02f, -8.61843824e-02f, -1.38812304e-01f, -1.14225700e-01f, -5.96860126e-02f, -2.34628335e-01f,
  -7.25887876e-05f, -1.45164309e-02f, 8.93030539e-02f, 2.09412016e-02f, -9.44825634e-02f, 1.55925062e-02f, -6.15048339e-04f, 1.23098008e-01f, 8.62260982e-02f, 7.45563880e-02f,
  3.66690423e-04f, -5.63506782e-02f, 5.60845956e-02f, -8.05962458e-02f, -1.35842524e-02f, -3.64608020e-02f, -9.67611279e-03f, 2.83238925e-02f, -7.50422105e-02f, -1.14288300e-01f,
  -2.07680181e-01f, -1.26239434e-01f, 1.13256149e-01f, 9.93720964e-02f, 7.21058669e-03f, 3.85878086e-02f, 9.07045137e-03f, 7.59680271e-02f, 3.58348945e-03f, 1.11489287e-02f,
  -3.99222821e-02f, 7.68185258e-02f, 7.76351383e-03f, 1.07834733e-03f, -4.00100574e-02f, 3.90949566e-03f, 3.86134237e-02f, -8.93419757e-02f, 9.35857892e-02f, 4.91950214e-02f,
  4.30090949e-02f, -3.87373455e-02f, -6.03781529e-02f, -1.85414925e-02f, -9.38573480e-03f, 2.01568566e-02f, 3.18420231e-02f, -8.13788548e-02f, -1.90766843e-03f, -3.13595422e-02f,
  -1.90473180e-02f, 8.96008313e-03f, 1.26368711e-02f, -3.44202481e-02f, -5.17256074e-02f, -2.17476636e-02f, 3.57218981e-02f, 1.04783118e-01f, -3.52185220e-02f, -6.39759842e-03f,
  9.14171115e-02f, 8.99203569e-02f, -1.45916110e-02f, 4.26062243e-03f, -2.52518672e-02f, 8.01964179e-02f, -1.18463151e-01f, 6.01956993e-02f, 2.39149220e-02f, -6.32508248e-02f,
  -5.88022843e-02f, -3.30490293e-03f, -6.17689863e-02f, 8.56770724e-02f, 1.07862532e-01f, -2.84611341e-03f, 3.80040496e-03f, -1.26001507e-01f, 1.06655084e-01f, -6.11177757e-02f,
  -1.27672311e-02f, 1.23501524e-01f, 1.47474676e-01f, 6.96584657e-02f, -2.09665764e-03f, -7.49536883e-03f, 1.16639391e-01f, 5.60112298e-02f, 1.85203642e-01f, 1.48291603e-01f,
  -3.28152510e-03f, 9.41149071e-02f, 1.07590728e-01f, -3.43674980e-02f, -9.55722108e-02f, -2.09314391e-01f, -1.85053512e-01f, -1.69098645e-01f, -1.84749924e-02f, 5.93566932e-02f,
  -4.43998985e-02f, 2.70985253e-02f, -3.54572013e-02f, 6.13463297e-02f, 4.72625494e-02f, 3.49908024e-02f, 1.58983916e-01f, 5.72948996e-03f, -2.13096127e-01f, -2.20907539e-01f,
  -6.02619350e-02f, 2.69184839e-02f, 7.06472024e-02f, 4.81963828e-02f, 3.19691598e-02f, -1.08350530e-01f, 2.08007604e-01f, 1.42069474e-01f, 1.63604364e-01f, 2.91241914e-01f,
  -2.69843861e-02f, 1.26981214e-01f, -1.11486077e-01f, 1.12007195e-02f, 1.03638798e-01f, 4.50794399e-03f, 7.71404186e-04f, 2.89783478e-02f, -9.02127847e-03f, -5.48371626e-03f,
  4.05712500e-02f, 1.02950208e-01f, 2.58299727e-02f, 1.12648919e-01f, -3.55162397e-02f, 5.12856022e-02f, 5.70851490e-02f, 1.12799980e-01f, 1.25438318e-01f, -1.49471043e-02f,
  4.75766398e-02f, 1.18393950e-01f, 4.67892699e-02f, -7.53366947e-02f, 5.41122369e-02f, -5.13480417e-03f, 1.55844481e-03f, 9.16450694e-02f, -4.63763662e-02f, 1.02726661e-01f,
  -5.77099286e-02f, 5.41293398e-02f, -1.37932263e-02f, 3.49288136e-02f, -5.55651262e-02f, 2.87980903e-02f, 4.89228256e-02f, -6.12849444e-02f, -1.21328533e-02f, -9.14016552e-03f,
  4.69656289e-02f, 9.53261647e-03f, 4.64750566e-02f, 1.37933129e-02f, -1.36043755e-02f, 7.13272244e-02f, 6.29675090e-02f, 2.03763787e-03f, 6.49238145e-03f, -5.18062338e-03f,
  -3.17994356e-02f, 5.80272488e-02f, 2.28394251e-02f, -1.12970760e-02f, 9.11876857e-02f, 2.24881787e-02f, 2.79279593e-02f, 3.10509093e-02f, 2.46816780e-02f, 4.40786444e-02f,
  -1.28535122e-01f, 3.58841643e-02f, -3.40084694e-02f, -1.15775302e-01f, -7.48463301e-03f, 6.74609765e-02f, -6.08001556e-03f, 2.67067682e-02f, 2.44871154e-02f, -5.68143241e-02f,
  -4.48021255e-02f, -7.19873309e-02f, -1.86210088e-02f, -3.11074443e-02f, -8.13065395e-02f, -8.27639177e-02f, -3.29251438e-02f, -8.87449756e-02f, 1.90527029e-02f, 3.72217670e-02f,
  -4.61312681e-02f, -1.72038332e-01f, -2.10949138e-01f, -6.42126724e-02f, -4.65546846e-02f, -2.33705044e-01f, -1.21193528e-01f, -1.05880156e-01f, -1.88668951e-01f, -3.00992668e-01f,
  -6.70391321e-02f, 8.15996900e-03f, 3.69321629e-02f, -1.59666240e-01f, -6.46255584e-03f, 7.81880766e-02f, 2.06210777e-01f, 1.38543710e-01f, -1.02833524e-01f, -3.37646045e-02f,
  -5.06751947e-02f, -1.38914794e-01f, 1.54506427e-03f, 1.05372500e-02f, 1.68267041e-01f, 1.29031688e-01f, 1.56776354e-01f, 9.25962552e-02f, 7.57481009e-02f, 2.73660105e-03f,
  2.97035854e-02f, -6.70584887e-02f, -4.49655913e-02f, 1.64547823e-02f, -1.46414354e-01f, -1.63608581e-01f, -1.12367660e-01f, -2.58466601e-02f, 3.92582901e-02f, -1.43226832e-01f,
  -4.21366662e-01f, -1.02611789e-02f, -1.85336079e-02f, 8.10020790e-02f, -1.18367016e-01f, -2.01353431e-02f, 1.14962934e-02f, 2.57592089e-02f, 4.85503711e-02f, -4.25039083e-02f,
  -3.63368192e-03f, 9.91069060e-03f, -5.32697700e-02f, -7.35320300e-02f, 6.75977841e-02f, -2.34021097e-02f, 3.60696241e-02f, 8.16056654e-02f, 4.24161181e-02f, -3.75741273e-02f,
  6.06360734e-02f, -5.57346977e-02f, 1.47975814e-02f, 2.56234221e-02f, 1.03490211e-01f, 1.98375992e-02f, 5.28032221e-02f, -5.80043346e-03f, 5.23373969e-02f, -1.44607127e-01f,
  3.15949060e-02f, -2.73002684e-02f, 3.00399074e-03f, 3.61034200e-02f, -4.09695394e-02f, 1.75844505e-02f, -5.10868840e-02f, 2.37395875e-02f, -2.68101674e-02f, -2.68236361e-02f,
  -2.64426880e-02f, 3.57731543e-02f, -7.48162344e-02f, 3.23303905e-03f, -9.82594639e-02f, -3.93446200e-02f, 4.41977866e-02f, -3.90016362e-02f, -1.07619064e-02f, 3.18217650e-02f,
  1.93408243e-02f, -7.03485161e-02f, -2.98693720e-02f, -3.28704454e-02f, 1.28589898e-01f, 4.21536230e-02f, 2.35592593e-02f, -9.73910931e-03f, -8.54988396e-02f, 2.70413216e-02f,
  -2.66127467e-01f, 2.29616717e-01f, -5.53122535e-02f, -5.52667826e-02f, -1.00659309e-02f, 2.93658804e-02f, -5.28386198e-02f, 6.62121549e-02f, 2.05052886e-02f, -6.90200254e-02f,
  1.77223627e-02f, 2.94360500e-02f, -9.65049639e-02f, -3.17549258e-02f, -4.77787778e-02f, -1.75478850e-02f, 1.72651336e-02f, 4.59095351e-02f, 6.02345206e-02f, 2.38201246e-02f,
  8.38347450e-02f, -1.33179035e-02f, -7.62254745e-02f, -2.42164768e-02f, -2.48384904e-02f, -6.98192939e-02f, -1.06262267e-01f, -1.89384259e-03f, 4.50138152e-02f, -1.29007638e-01f,
  -2.62059290e-02f, -1.02801941e-01f, 2.28352964e-01f, -9.37190428e-02f, -2.22223163e-01f, -1.52260393e-01f, -1.62053332e-01f, -4.44655642e-02f, -1.88935187e-03f, -1.97936967e-01f,
  -9.87229273e-02f, 1.16067424e-01f, 1.76845416e-01f, 2.60367095e-01f, 1.69299811e-01f, -7.95012340e-02f, -1.25990227e-01f, 2.23414540e-01f, 2.90674478e-01f, -3.92552800e-02f,
  -5.92701174e-02f, -1.67218879e-01f, -4.36596991e-03f, 1.29509896e-01f, -1.55121580e-01f, 3.97192538e-02f, -8.27627406e-02f, -5.44903912e-02f, -7.38134012e-02f, -7.19947815e-02f,
  1.42177135e-01f, 8.86166096e-02f, 1.48461372e-01f, -4.95713204e-02f, -2.19391529e-02f, -1.93564799e-02f, -9.29433107e-02f, 9.66709182e-02f, -9.22738835e-02f, -8.61131623e-02f,
  -4.80725095e-02f, -3.22047323e-02f, -3.45284236e-03f, 1.87079590e-02f, -9.88861844e-02f, 3.30611914e-02f, -4.55885418e-02f, 1.08918793e-01f, 1.45674542e-01f, 7.40431249e-02f,
  -1.16008744e-01f, -1.67395577e-01f, -1.57675799e-03f, 9.86601561e-02f, 5.42242266e-02f, 8.08426887e-02f, 6.67368472e-02f, 1.16645291e-01f, 1.49637356e-01f, -6.38285279e-02f,
  -6.50381893e-02f, 1.07066743e-02f, 3.65088545e-02f, 4.80433404e-02f, -4.27804552e-02f, -4.43474352e-02f, 6.28278637e-03f, -7.51278251e-02f, 6.64867386e-02f, -2.70382483e-02f,
  3.78821269e-02f, -2.60076020e-02f, -1.28409686e-03f, 4.24883887e-02f, 4.18038853e-03f, -7.04529183e-03f, 1.10809151e-02f, 6.06018193e-02f, -4.88494672e-02f, 2.82741431e-03f,
  -1.38509204e-03f, 3.11757289e-02f, -4.11308035e-02f, 5.80137745e-02f, -5.96277267e-02f, 6.60104901e-02f, -4.51579243e-02f, 9.58697423e-02f, -5.07060029e-02f, -8.50144327e-02f,
  -1.11958012e-01f, 1.80838481e-01f, -6.23977929e-02f, 7.15214238e-02f, -1.03690401e-01f, -4.28534150e-02f, 1.35593368e-02f, -1.70928463e-02f, -3.19500305e-02f, 4.77734618e-02f,
  1.75029971e-02f, 5.85482866e-02f, 4.15264070e-02f, -1.26534756e-02f, -2.33875830e-02f, 2.44873837e-02f, -8.45742822e-02f, 8.50942880e-02f, 5.32359444e-02f, -2.33192230e-03f,
  -1.02200650e-01f, -7.15581030e-02f, -4.25345860e-02f, 9.01335478e-02f, 2.74842978e-03f, -8.23312718e-03f, 2.45488659e-02f, -4.06370200e-02f, -2.22554971e-02f, -1.75037801e-01f,
  3.90786767e-01f, 1.10752903e-01f, -8.33452716e-02f, 7.32693896e-02f, 9.13429540e-03f, 1.48392364e-01f, 1.52769163e-01f, 2.10927725e-01f, 3.07334289e-02f, 3.48924566e-03f,
  2.39404328e-02f, -6.47924170e-02f, -1.42778575e-01f, -4.23977934e-02f, 9.30652544e-02f, -1.56298243e-02f, -2.05584630e-01f, -1.44234613e-01f, 3.86038050e-02f, -1.36979213e-02f,
  -3.79467532e-02f, -5.83721101e-02f, 9.92675722e-02f, -8.21486190e-02f, -3.83122228e-02f, -1.60128057e-01f, 1.75511148e-02f, 1.65377054e-02f, -9.98680070e-02f, -1.93429813e-01f,
  1.03468955e-01f, 2.32755497e-01f, 1.35238329e-03f, 9.11043200e-04f, -4.90345471e-02f, 6.04099259e-02f, 1.18647009e-01f, -4.73162755e-02f, 7.50510674e-03f, 3.81080993e-02f,
  1.68292653e-02f, 2.03639828e-02f, -2.27489490e-02f, -8.39389116e-03f, 7.24008158e-02f, 1.01579942e-01f, -5.79741262e-02f, 5.20440526e-02f, -2.74568070e-02f, 5.18900268e-02f,
  -9.63612273e-02f, 6.48176000e-02f, 1.82596520e-01f, -4.97345766e-03f, 1.18924759e-01f, -5.38018458e-02f, 4.51081134e-02f, -1.78599078e-02f, 8.06766674e-02f, 1.50280088e-01f,
  -2.15822458e-02f, 6.10303804e-02f, 2.30588596e-02f, 7.46456580e-03f, 6.97051063e-02f, -8.17188025e-02f, -6.83332384e-02f, 3.55055369e-02f, 2.21865121e-02f, -4.91761491e-02f,
  -2.73165852e-02f, 2.71939784e-02f, -1.06250504e-02f, 6.46088272e-02f, -2.44245064e-02f, 6.93535283e-02f, -2.18599150e-03f, -7.88532011e-03f, 1.93383507e-02f, 2.90971389e-03f,
  -3.15785743e-02f, -3.20130326e-02f, -2.03326400e-02f, 3.73132899e-02f, 1.99879240e-02f, 5.57159409e-02f, -3.06499861e-02f, 4.58153114e-02f, -6.64274965e-04f, -2.99230572e-02f,
  1.17512099e-01f, -1.95449188e-01f, -2.16987021e-02f, -1.01540340e-02f, 1.28504289e-02f, -2.60525215e-02f, -1.03637382e-01f, -1.14302216e-02f, -6.88523846e-03f, 1.79767609e-02f,
  1.43228592e-02f, 4.90045473e-02f, 1.77906454e-02f, -3.72738615e-02f, -3.27148139e-02f, 5.15955873e-02f, -6.31460994e-02f, -5.30694351e-02f, -1.41096767e-02f, 8.98595527e-02f,
  -1.73956715e-02f, 1.50818899e-01f, 8.15095603e-02f, 1.08739138e-01f, 1.01847388e-03f, 8.33245739e-02f, 1.65919557e-01f, 1.21253334e-01f, 1.26824975e-01f, 1.49177760e-01f,
  2.46071160e-01f, -2.08614886e-01f, -3.50942314e-01f, 6.86096549e-02f, -1.67011842e-02f, -4.72742170e-02f, -8.35874528e-02f, -2.45560706e-02f, 1.17263906e-01f, -2.28785165e-02f,
  -1.26859948e-01f, 1.31076485e-01f, 1.05293907e-01f, 4.03445587e-03f, 3.88090201e-02f, -4.31259908e-02f, -1.97471883e-02f, -3.25524285e-02f, 1.12497486e-01f, 1.71904549e-01f,
  2.74379589e-02f, 5.49352989e-02f, 7.08949417e-02f, 3.46344411e-02f, -1.50166573e-02f, 3.18873972e-02f, -1.14019550e-01f, -1.08256347e-01f, -3.34860869e-02f, -2.36655861e-01f,
  -3.36132497e-01f, -1.52883589e-01f, 9.45985764e-02f, 8.36436227e-02f, -1.12925461e-02f, 1.89149901e-02f, 5.18407263e-02f, -1.16987191e-01f, 3.45724747e-02f, -3.72791588e-02f,
  -6.53283969e-02f, 9.49898642e-03f, 1.48299441e-03f, -2.02695802e-02f, -1.08696684e-01f, -1.17658474e-03f, -7.02831596e-02f, -8.84983614e-02f, 1.16442144e-02f, -6.44549951e-02f,
  -8.05832073e-03f, -1.26887515e-01f, -4.11120094e-02f, -1.04687504e-01f, -9.21779647e-02f, 3.98686007e-02f, -7.40714446e-02f, -1.01897597e-01f, -1.76026579e-02f, -1.92351684e-01f,
  3.09382360e-02f, -4.05430086e-02f, -1.03425805e-03f, -1.90020353e-02f, 5.28772511e-02f, 5.03970962e-03f, 6.75438950e-03f, 2.78467927e-02f, 5.21790422e-02f, -1.36886891e-02f,
  -5.58637083e-03f, -8.14831927e-02f, 1.30612040e-02f, -6.37193734e-04f, -1.00043761e-02f, -6.41524494e-02f, 3.69804204e-02f, 5.43623185e-03f, 6.12007864e-02f, -1.88620389e-02f,
  -4.41823192e-02f, 4.70969528e-02f, -3.88179049e-02f, -4.38405760e-02f, 4.57907878e-02f, -2.98032463e-02f, -1.84717178e-02f, 2.88076177e-02f, 8.85205995e-03f, 7.17218444e-02f,
  2.39684042e-02f, 1.48115724e-01f, -3.01725306e-02f, 5.93039244e-02f, -7.16730654e-02f, -1.02717448e-02f, -5.56728616e-02f, 5.23009822e-02f, -2.57429923e-03f, -3.61331180e-02f,
  -3.25692259e-02f, 3.61873657e-02f, -5.60984462e-02f, 9.72243212e-03f, 2.46707220e-02f, 1.14557082e-02f, 8.10195729e-02f, 6.04695752e-02f, 4.88044731e-02f, -8.07022229e-02f,
  -5.25245853e-02f, 1.34967193e-01f, 1.67542607e-01f, -8.75881687e-03f, -3.41181718e-02f, 1.99057788e-01f, -1.38958609e-02f, 7.36283287e-02f, 1.04596868e-01f, 1.72869444e-01f,
  2.68924981e-01f, 2.00944226e-02f, 2.79877394e-01f, 2.97329068e-01f, 2.08924234e-01f, 1.06236540e-01f, 8.44349414e-02f, -1.97825395e-02f, -1.96672883e-02f, -4.41339277e-02f,
  1.72933489e-02f, 9.88205820e-02f, 1.44026369e-01f, 4.29553054e-02f, -4.20580106e-03f, -1.03142923e-02f, 1.92798793e-01f, 2.10118204e-01f, 1.33594587e-01f, 2.44969148e-02f,
  -4.50357012e-02f, 9.65461954e-02f, 1.79116428e-01f, 3.80974710e-02f, 3.12849991e-02f, 9.07269269e-02f, 6.01129383e-02f, -4.96759219e-03f, -1.06568551e-02f, 1.22041047e-01f,
  7.25253299e-02f, 2.04551384e-01f, 9.13526490e-02f, -4.92525548e-02f, 6.54528057e-03f, -9.49254259e-02f, 4.58743013e-02f, 7.32612237e-02f, -3.03157810e-02f, 2.43455954e-02f,
  3.79241109e-02f, -8.47716779e-02f, 1.14105400e-02f, -8.11677892e-03f, 4.63998085e-03f, 9.01257098e-02f, -3.17757316e-02f, 7.52178133e-02f, -6.06257729e-02f, -5.96859008e-02f,
  -8.05163756e-02f, 4.63033915e-02f, 8.35990161e-02f, -1.27888605e-01f, -4.27117851e-03f, 7.94030875e-02f, 1.08361384e-02f, -4.11485694e-02f, -1.03736296e-01f, -1.17960550e-01f,
  -5.67560084e-02f, -7.09190369e-02f, -6.32118583e-02f, 3.25781293e-02f, -6.76260889e-02f, -4.50378433e-02f, -3.19068432e-02f, -4.58361767e-02f, -4.58802395e-02f, 7.63191143e-03f,
  -1.87573507e-02f, -3.65273654e-02f, 1.06264293e-01f, 4.92214151e-02f, 2.46153120e-02f, 2.34564357e-02f, -8.10112804e-02f, 1.31447883e-02f, -3.00985370e-02f, -3.24983411e-02f,
  3.11049037e-02f, -1.90936197e-02f, 4.76809032e-02f, -4.69799377e-02f, -1.96969300e-03f, 1.43652468e-03f, 2.87272017e-02f, 1.27981137e-02f, 6.05112985e-02f, -5.21421991e-03f,
  -7.05441087e-02f, 7.12297559e-02f, 6.03816696e-02f, -4.50352905e-03f, -1.04552954e-02f, -6.52614534e-02f, 7.33499974e-02f, -7.89867789e-02f, 7.69237801e-02f, 1.88228656e-02f,
  -7.80620873e-02f, 3.87924388e-02f, 2.38870531e-02f, -4.01883125e-02f, -4.56254650e-03f, -1.44791817e-02f, -3.11059020e-02f, 5.84305599e-02f, -7.77387843e-02f, -4.92160842e-02f,
  -3.91539186e-02f, -2.90724672e-02f, 3.07132099e-02f, -9.67140347e-02f, 3.05537716e-03f, 1.10465422e-01f, -1.63037181e-02f, -3.58640999e-02f, -4.88605238e-02f, -1.68357328e-01f,
  -6.91152871e-01f, -1.76551774e-01f, 8.73203352e-02f, -2.05650643e-01f, -1.13536924e-01f, -1.11589335e-01f, -8.17843676e-02f, -1.55310094e-01f, -1.00437462e-01f, -1.02983125e-01f,
  -1.79875828e-02f, 8.71734694e-03f, 7.87553005e-03f, 8.85493904e-02f, 4.76417057e-02f, -7.14366734e-02f, -9.02193412e-02f, 1.45979691e-02f, -2.96404622e-02f, 3.15127559e-02f,
  6.17137328e-02f, -1.51122525e-01f, -5.14024720e-02f, 2.95080040e-02f, 1.04654990e-01f, 8.02443549e-02f, 1.12268180e-01f, 2.97653712e-02f, 7.48346075e-02f, 6.94581643e-02f,
  2.17112780e-01f, -2.12738574e-01f, 3.64533230e-03f, -2.53028329e-02f, 3.33597101e-02f, 4.47842904e-04f, -3.49810310e-02f, 4.62800041e-02f, 5.81374057e-02f, -5.68808056e-02f,
  -9.51622799e-03f, 4.14402001e-02f, 2.87415199e-02f, 1.21525414e-01f, -6.35702536e-02f, 1.29680969e-02f, -4.39579450e-02f, 5.00338823e-02f, 7.38924071e-02f, -4.18099351e-02f,
  1.62105888e-01f, -4.27528694e-02f, -2.09226422e-02f, -2.34905109e-02f, -3.92422751e-02f, 4.48052138e-02f, 8.95882249e-02f, 1.29234895e-01f, 3.09519507e-02f, 3.56463864e-02f,
  -3.69464569e-02f, 8.82844999e-03f, 3.65641229e-02f, -3.48666385e-02f, -3.17293629e-02f, -1.42030967e-02f, -5.38509674e-02f, -4.59705070e-02f, 1.70670785e-02f, -1.49031524e-02f,
  3.42008173e-02f, -3.52497548e-02f, -2.57061217e-02f, -8.77833739e-02f, 9.89928395e-02f, -5.35229221e-02f, -1.60053149e-02f, 8.31430079e-04f, 7.36771077e-02f, -5.31158559e-02f,
  3.02810804e-03f, 1.64949894e-02f, -9.84440837e-03f, 2.18552947e-02f, 6.04063235e-02f, 3.04242019e-02f, -6.86204582e-02f, 7.29566216e-02f, 4.11221050e-02f, -3.22804749e-02f,
  -1.33335158e-01f, 2.64062937e-02f, -5.76427542e-02f, -8.14710781e-02f, 6.83469921e-02f, 6.45206943e-02f, -1.61813591e-02f, 4.18418944e-02f, -3.10849175e-02f, 4.71121818e-02f,
  4.39936928e-02f, -1.97384302e-02f, -5.49777448e-02f, 2.02685446e-02f, -3.72063345e-03f, -5.94355864e-04f, -1.26245424e-01f, -1.60703436e-02f, -5.44681810e-02f, -2.50423346e-02f,
  -7.65843466e-02f, -9.59930867e-02f, -2.14945916e-02f, -5.82081191e-02f, -1.01120144e-01f, -1.06517203e-01f, 1.25316856e-02f, -8.26764759e-03f, 2.01387256e-02f, -1.75909147e-01f,
  4.05640230e-02f, 1.46181136e-01f, 6.70462921e-02f, 1.00353412e-01f, -1.41961411e-01f, -4.69212770e-04f, -1.16571195e-01f, -1.33055985e-01f, 3.00927390e-03f, -1.98501721e-02f,
  1.50021851e-01f, 1.87746435e-01f, 1.33094162e-01f, 6.96867406e-02f, 5.62997423e-02f, -2.13664882e-02f, -1.75726086e-01f, 2.97954772e-02f, -6.78987280e-02f, 1.07621681e-02f,
  -7.65321702e-02f, -1.16229001e-02f, -1.05234303e-01f, -9.92328078e-02f, 3.61280479e-02f, 2.00839676e-02f, -5.51944599e-02f, 2.26335600e-02f, 6.05648048e-02f, -6.09457958e-03f,
  2.32604101e-01f, 8.98157060e-03f, -4.92459275e-02f, 6.95249289e-02f, -4.63941582e-02f, -4.33298433e-03f, 2.76426859e-02f, 3.37960720e-02f, -2.99723558e-02f, -2.34581605e-02f,
  -1.49747096e-02f, 6.24031499e-02f, 9.23491828e-03f, -1.08465031e-01f, 1.35164289e-02f, -8.57239664e-02f, -4.09912206e-02f, -1.13524579e-01f, 2.55459491e-02f, -3.67080234e-02f,
  6.85267374e-02f, -4.58728410e-02f, 1.54887572e-01f, 1.87323019e-02f, 7.96343200e-03f, 8.52593482e-02f, 8.31377655e-02f, 1.61523875e-02f, -9.82889235e-02f, -3.01655438e-02f,
  5.39826006e-02f, -1.43424813e-02f, 6.88736141e-02f, 3.66348736e-02f, 2.54912768e-02f, -3.45413201e-02f, 1.79579128e-02f, 5.73047437e-02f, -9.13907886e-02f, 4.65242676e-02f,
  -8.65871981e-02f, 4.76703793e-02f, 4.99694012e-02f, 7.63669237e-02f, -6.06116988e-02f, -4.59244475e-02f, -2.47256123e-02f, -1.56837683e-02f, -2.37099975e-02f, -6.62030131e-02f,
  6.41113743e-02f, 2.43932530e-02f, -4.42006551e-02f, 1.15020648e-02f, -6.91558272e-02f, 1.09148491e-02f, -7.72294477e-02f, -2.52530761e-02f, 6.51550889e-02f, -3.50668654e-02f,
  1.80217221e-01f, -4.13781032e-02f, 1.82215184e-01f, 6.27189949e-02f, -2.02712286e-02f, 8.88780691e-03f, 6.50647655e-02f, 1.05505399e-02f, 7.55925477e-02f, 9.57149938e-02f,
  1.02294102e-01f, 2.65254583e-02f, -1.97375640e-02f, 1.76383536e-02f, -1.74772795e-02f, -1.42386146e-02f, -1.43849954e-01f, -2.53279749e-02f, -3.30899954e-02f, -2.65554804e-02f,
  -6.13875389e-02f, -4.12201881e-02f, 6.86102882e-02f, 3.87319177e-02f, 9.12108645e-02f, -6.85005030e-03f, 1.30439445e-01f, -5.10354601e-02f, 9.15849432e-02f, -7.23582059e-02f,
  5.94459713e-01f, 9.37892944e-02f, -4.71931649e-03f, 1.65798068e-01f, -7.68889561e-02f, -2.00883627e-01f, -2.33075768e-01f, -5.09816743e-02f, 4.95308191e-02f, 1.73066780e-01f,
  1.56827152e-01f, 6.06050864e-02f, 2.04014801e-03f, 4.06742655e-02f, -9.42425579e-02f, -1.69109747e-01f, -2.86625803e-01f, -7.72078931e-02f, -1.58699632e-01f, -5.42539544e-02f,
  1.24531472e-03f, -1.01684043e-02f, 9.94638577e-02f, -1.17965098e-02f, 4.55773510e-02f, -5.45995124e-02f, 3.09543163e-02f, 6.15776442e-02f, -1.14672203e-02f, 7.99927115e-03f,
  1.10832445e-01f, 3.36657524e-01f, -1.26935095e-01f, -5.21476902e-02f, 1.13240100e-01f, 6.24951459e-02f, 4.24611866e-02f, -2.27718093e-02f, 9.92542580e-02f, -9.95590538e-03f,
  1.20287426e-01f, 2.40894873e-02f, 8.93298313e-02f, -3.65906991e-02f, -4.47382126e-03f, 4.92167324e-02f, 1.04407417e-02f, 6.23236001e-02f, -1.07562110e-01f, 1.90038029e-02f,
  -1.41712174e-01f, 1.04617655e-01f, 6.60145804e-02f, -7.75935734e-03f, -9.84429196e-02f, -2.50896420e-02f, 4.63057160e-02f, 7.47624738e-03f, 1.25046605e-02f, 8.22636634e-02f,
  -8.55484903e-02f, 7.61813074e-02f, 4.25769873e-02f, 1.57243889e-02f, -6.17289767e-02f, 4.81555760e-02f, -4.65603620e-02f, 1.65146682e-03f, -6.79088831e-02f, 1.69181433e-02f,
  -1.48494272e-02f, 8.56857300e-02f, -2.81875599e-02f, -2.19412372e-02f, 1.98787369e-04f, -2.72452459e-02f, 5.56767061e-02f, -7.50591233e-02f, 2.94669662e-02f, -7.67127518e-03f,
  4.67206091e-02f, 1.63794737e-02f, 3.73154543e-02f, -1.46412449e-02f, -8.62659980e-03f, -6.94536092e-03f, -2.08660848e-02f, 3.28373387e-02f, 2.32884716e-02f, 5.52786700e-02f,
  -3.61745283e-02f, -8.90030190e-02f, 1.04879268e-01f, 2.49959677e-02f, -7.08745494e-02f, 2.15732958e-02f, 6.03307597e-02f, 4.91265133e-02f, 2.73132678e-02f, 4.58024517e-02f,
  -5.41852154e-02f, -1.49742216e-02f, 2.07790881e-02f, 2.31545581e-03f, -5.02947830e-02f, -6.35775477e-02f, -2.39900034e-02f, 1.28539847e-02f, -3.58533184e-03f, 2.05670744e-02f,
  -7.49274855e-03f, -1.54984310e-01f, -5.79904206e-02f, -1.01990148e-01f, -4.38638665e-02f, -4.20778319e-02f, -5.73838130e-02f, 2.26287935e-02f, -3.86592560e-02f, 3.42317075e-02f,
  -4.08395603e-02f, -6.47707134e-02f, -2.75233597e-01f, -1.17783882e-01f, -1.41374916e-01f, -2.34691828e-01f, -2.82777101e-01f, -9.80614200e-02f, -2.23139673e-02f, -1.06641218e-01f,
  -4.10837159e-02f, 8.72677714e-02f, 1.75738022e-01f, 6.90364987e-02f, -7.39864558e-02f, -1.89355433e-01f, -1.60076410e-01f, -1.19958874e-02f, -9.47035998e-02f, -1.33138686e-01f,
  -1.69488993e-02f, -2.51574777e-02f, -6.90471604e-02f, -1.81113686e-02f, 5.22006266e-02f, 9.73507613e-02f, -3.03019416e-02f, 6.61118180e-02f, -6.85103610e-02f, -2.15629376e-02f,
  -1.18919030e-01f, -2.03318655e-01f, 5.07427892e-03f, -3.91984731e-02f, -2.34792288e-02f, 9.76235718e-02f, 2.41866708e-02f, 9.18273181e-02f, -6.90497411e-03f, -2.26254594e-02f,
  -2.91188713e-02f, 8.54227599e-03f, 9.49228853e-02f, 2.59499587e-02f, 3.26384455e-02f, 5.20700850e-02f, 9.52885207e-03f, -3.66992224e-03f, -3.66494134e-02f, -4.56816591e-02f,
  4.63046469e-02f, -9.39234346e-02f, -1.03476591e-01f, 3.89192589e-02f, -1.98197290e-02f, 2.22098939e-02f, -8.44467953e-02f, -2.85792109e-02f, -7.68759400e-02f, -2.28166040e-02f,
  -1.87674351e-02f, -1.70215555e-02f, -4.86949757e-02f, -3.32672289e-03f, -8.68590898e-04f, 2.00583087e-03f, -4.66400087e-02f, -3.36237922e-02f, -9.85076092e-03f, 3.20941433e-02f,
  2.87812371e-02f, -9.84625444e-02f, 7.65906274e-02f, 3.60117247e-03f, 1.07526453e-02f, -3.29828039e-02f, 3.40620428e-02f, -5.61911501e-02f, -2.10885927e-02f, 4.30135317e-02f,
  1.04808072e-02f, 1.83194466e-02f, 4.52081114e-02f, 5.70421889e-02f, 2.40342785e-02f, -1.93963461e-02f, -6.12411946e-02f, -7.50332326e-02f, 5.91215678e-02f, -1.27872890e-02f,
  2.95846134e-01f, -1.52214020e-01f, 9.69004929e-02f, 5.66146821e-02f, -4.56464477e-02f, 5.76154180e-02f, -2.82555781e-02f, 9.23053101e-02f, 7.75241479e-02f, 5.69716170e-02f,
  -1.09590359e-01f, -9.99677368e-03f, 5.68142757e-02f, -5.14886901e-02f, -6.99441065e-04f, -1.04791678e-01f, 1.73075814e-02f, 8.92511681e-02f, 4.50484417e-02f, -3.66955027e-02f,
  5.70040196e-02f, 5.02623804e-03f, 7.81309903e-02f, 2.02197321e-02f, -6.48714006e-02f, -4.52169850e-02f, 4.61468138e-02f, 7.06162453e-02f, -4.27886620e-02f, 1.11497290e-01f,
  -4.51908214e-03f, 4.38930653e-02f, -1.61768198e-01f, 1.91309843e-02f, 1.31508350e-01f, 2.28771083e-02f, 3.99400294e-02f, 3.91900688e-02f, 1.08146779e-01f, -4.29505445e-02f,
  7.68082961e-02f, -6.39662519e-03f, -1.27946600e-01f, -1.82159171e-01f, -1.72948688e-01f, -1.66110620e-01f, -1.44460127e-01f, -2.14023903e-01f, -1.64912254e-01f, 8.91879573e-02f,
  -5.51717989e-02f, 7.48443380e-02f, -7.65460916e-03f, 6.82156235e-02f, 1.23908250e-02f, -9.53264460e-02f, 1.03461137e-02f, 4.67485897e-02f, -1.04861846e-02f, -2.35333234e-01f,
  -2.13720948e-01f, 8.27520415e-02f, -3.12129734e-03f, -1.34675335e-02f, -6.88354447e-02f, -3.00821569e-03f, -2.52882726e-02f, 9.44312885e-02f, 2.86744423e-02f, -6.07661083e-02f,
  -2.79442631e-02f, -3.49249244e-02f, 7.01311743e-03f, 2.61070896e-02f, 6.19053356e-02f, 2.61776857e-02f, 7.55980164e-02f, -6.26405254e-02f, 6.24930207e-03f, 1.06632225e-01f,
  3.71382982e-02f, 2.11683195e-03f, -9.71222594e-02f, -1.56774446e-02f, 4.92027402e-02f, -4.17718776e-02f, 7.97934681e-02f, 2.86719259e-02f, -7.24306405e-02f, -1.92251448e-02f,
  -4.83174734e-02f, -8.49439055e-02f, 4.05143853e-03f, 6.18302599e-02f, -5.91313839e-03f, 4.86013887e-04f, -2.58679781e-02f, -7.96794966e-02f, 4.72118184e-02f, -5.07434271e-02f,
  3.22086848e-02f, 3.64188962e-02f, -3.74473445e-02f, 3.91712002e-02f, 2.47221300e-03f, -1.11088753e-02f, -1.76713914e-02f, 2.66630929e-02f, 2.60189772e-02f, 5.08664250e-02f,
  -2.44275611e-02f, 2.91868392e-02f, -4.60658669e-02f, -7.65980594e-03f, -5.76414466e-02f, -1.67944711e-02f, -6.04348555e-02f, 9.92818326e-02f, 7.40654618e-02f, 9.42765027e-02f,
  1.16763569e-01f, 2.30308659e-02f, -1.58251151e-02f, -9.53643546e-02f, 2.15144437e-02f, 9.51251574e-03f, -5.04781306e-03f, 2.16253009e-02f, 4.03684936e-02f, -1.32701853e-02f,
  1.21364288e-01f, 3.78003567e-02f, -3.91579941e-02f, -4.26858440e-02f, 5.50308414e-02f, -2.19482332e-02f, -9.19126440e-03f, -2.87242867e-02f, 2.33083870e-02f, 3.69903073e-02f,
  1.96857713e-02f, 6.09303918e-03f, -5.65897934e-02f, 3.00686043e-02f, 6.03830442e-02f, -5.90803176e-02f, -5.49983270e-02f, -1.21971155e-02f, -1.12268932e-01f, 4.95042838e-02f,
  -2.18882680e-01f, -2.44785845e-02f, -3.87430899e-02f, -1.33720055e-01f, 1.16599031e-01f, 1.91822648e-01f, 2.29239911e-01f, 7.61389956e-02f, -1.55272586e-02f, -1.10515907e-01f,
  2.19602939e-02f, 3.31432708e-02f, 1.91324912e-02f, 6.49473369e-02f, 6.88686818e-02f, 1.26024604e-01f, 6.65991828e-02f, 1.00024708e-01f, 4.44494858e-02f, 6.22163415e-02f,
  5.26625291e-02f, -1.78464249e-01f, -1.79387793e-01f, -4.52228040e-02f, -1.67508706e-01f, -4.72316006e-03f, -8.51533711e-02f, -5.30700013e-02f, 4.69160341e-02f, -7.20059127e-02f,
  -3.28929722e-01f, 4.51340452e-02f, -3.23412265e-03f, -3.45023423e-02f, -1.89015046e-02f, -9.76231396e-02f, -3.74338850e-02f, -1.23042293e-01f, -9.31120943e-03f, -5.35447896e-02f,
  6.57947967e-03f, -7.28308186e-02f, 5.36388010e-02f, 3.30375060e-02f, -4.94945832e-02f, -9.50635131e-03f, -5.18330149e-02f, -3.07364017e-02f, 3.97385135e-02f, -6.44513592e-02f,
  1.15838550e-01f, 6.74371421e-02f, 1.61050662e-01f, 7.62237385e-02f, 6.55774698e-02f, 2.40689479e-02f, 6.08245516e-03f, 2.83636861e-02f, 2.97370329e-02f, -7.24576488e-02f,
  -9.78843216e-03f, 1.25024673e-02f, 6.88512027e-02f, -4.12003621e-02f, -2.39780843e-02f, 5.98737672e-02f, -2.77614240e-02f, -2.47077253e-02f, 1.23681175e-02f, -1.49891397e-03f,
  7.39503875e-02f, 5.12886718e-02f, -4.80559729e-02f, -1.21904295e-02f, -1.10157765e-03f, -4.64519821e-02f, 8.34737048e-02f, -6.70679212e-02f, 2.49909586e-03f, 2.98592504e-02f,
  -1.78698152e-02f, 4.62718634e-03f, 2.09014490e-02f, 1.27821602e-02f, 6.50496930e-02f, 4.14355919e-02f, -1.75312068e-02f, -3.71864960e-02f, 3.04807741e-02f, 6.45801798e-02f,
  -1.93777278e-01f, 1.88599303e-01f, -9.08114016e-02f, 4.53122742e-02f, -7.29838759e-03f, -1.00606075e-02f, 1.52621539e-02f, -4.81564142e-02f, 1.18591674e-02f, -1.34026539e-02f,
  7.21222442e-03f, -1.08894259e-02f, -1.26642827e-02f, -2.62102727e-02f, 4.08279337e-02f, 4.29044701e-02f, -2.17506452e-03f, 8.37961659e-02f, 6.14116676e-02f, -3.86389829e-02f,
  -7.95715079e-02f, 2.97884084e-02f, 4.65139300e-02f, 2.93138158e-02f, 9.42448527e-02f, 1.11073576e-01f, -4.06176522e-02f, -7.62940794e-02f, 5.37078306e-02f, -1.22020885e-01f,
  7.48079866e-02f, -2.09795967e-01f, -1.03423752e-01f, 1.04301222e-01f, -3.49035449e-02f, -1.85819402e-01f, -3.43798935e-01f, -1.54013410e-01f, 6.54868335e-02f, -3.94493230e-02f,
  1.21226996e-01f, 2.54850894e-01f, 1.81639597e-01f, 7.62244388e-02f, -2.51723845e-02f, -1.07936263e-01f, -1.56481162e-01f, -1.96002685e-02f, -6.44586310e-02f, 4.69757360e-04f,
  9.35672298e-02f, 2.58629285e-02f, 4.07329910e-02f, 6.93794191e-02f, 4.79841754e-02f, 1.64360031e-01f, -5.82516147e-03f, -4.63080071e-02f, -4.95672897e-02f, 6.22477196e-02f,
  1.32592604e-01f, -2.11285964e-01f, 3.48335393e-02f, 1.18022151e-01f, -1.12192938e-02f, 4.78807017e-02f, 9.15496126e-02f, 2.33730022e-02f, 4.91716526e-02f, -2.23308802e-02f,
  2.49145348e-02f, 1.01036340e-01f, 2.58144364e-03f, 7.75150731e-02f, -4.93834950e-02f, -7.28990287e-02f, -3.26761678e-02f, -3.27164754e-02f, -8.35806429e-02f, -1.34145081e-01f,
  7.05558341e-03f, -1.05702780e-01f, -5.79941981e-02f, -1.06999703e-01f, -1.56065777e-01f, 7.63636874e-03f, -8.69042650e-02f, -1.49549529e-01f, -9.71660111e-03f, -1.53440043e-01f,
  3.23341750e-02f, -1.34425194e-04f, 1.08945249e-02f, -1.91068593e-02f, 3.80850323e-02f, 5.84291108e-02f, -2.46480256e-02f, -2.99487710e-02f, 3.72676887e-02f, 3.80038992e-02f,
  -1.03719393e-02f, 1.09106880e-02f, 1.13963252e-02f, 2.47499440e-02f, 4.36417386e-03f, -7.40192831e-02f, -9.01142657e-02f, 6.27199560e-02f, 7.98781961e-02f, -2.57906727e-02f,
  2.42246781e-02f, -6.99193729e-03f, -5.26054613e-02f, 1.49189243e-02f, 4.95182350e-02f, -5.37861884e-02f, -4.45899516e-02f, 7.24301562e-02f, -1.46365986e-04f, -3.19765471e-02f,
  2.46777266e-01f, 5.65879454e-04f, 1.39413163e-01f, -1.60969459e-02f, -3.62171456e-02f, 8.04478079e-02f, 2.14566253e-02f, -6.71214610e-03f, 2.28606723e-02f, -4.99216765e-02f,
  1.94982998e-02f, -3.07650119e-02f, 1.45702362e-02f, -1.81187093e-02f, 3.09493076e-02f, 1.90188065e-02f, 5.93589013e-03f, -3.56493518e-02f, 4.24110256e-02f, 3.38720866e-02f,
  9.11892056e-02f, 7.94142578e-03f, -2.12560687e-02f, 3.21013629e-02f, -4.30371650e-02f, 1.27550110e-01f, 6.86101168e-02f, -1.74848903e-02f, -1.05380408e-01f, 2.62872927e-04f,
  1.47805348e-01f, 5.56907766e-02f, -8.09440166e-02f, 6.12955838e-02f, 6.18579127e-02f, 1.65350735e-01f, 2.81928688e-01f, 1.20911136e-01f, 1.02419563e-01f, 2.08875388e-02f,
  1.56342722e-02f, -1.20932877e-01f, -9.52087492e-02f, -5.76999746e-02f, -6.34678006e-02f, -6.14767373e-02f, -1.51974529e-01f, -1.09060951e-01f, -8.15934613e-02f, 1.50722951e-01f,
  5.31640090e-03f, 1.84830520e-02f, -1.08338557e-01f, 3.30023207e-02f, -2.69372687e-02f, -3.88044976e-02f, -8.76273587e-02f, -1.41593618e-02f, -6.46413043e-02f, -1.36057764e-01f,
  -9.56026912e-02f, 2.43593603e-02f, -5.43726720e-02f, -7.70193636e-02f, -9.64380205e-02f, -3.23929004e-02f, 5.91581268e-03f, -1.16478793e-01f, -6.48857420e-03f, -9.38625783e-02f,
  -3.99859212e-02f, 7.36050084e-02f, 3.34368320e-03f, 4.95845415e-02f, 8.26806054e-02f, 8.48581567e-02f, -1.22706063e-01f, -5.99699793e-03f, -9.18455422e-02f, -9.34454519e-03f,
  7.74240121e-03f, -1.29338866e-02f, 1.10181808e-01f, 1.01997249e-01f, 8.25102776e-02f, -8.36936757e-02f, 2.37934329e-02f, -5.21802269e-02f, -5.25163114e-02f, -4.97965962e-02f,
  4.25245725e-02f, 5.04505672e-02f, 6.40992634e-03f, 4.53810878e-02f, -1.30378455e-02f, -3.58075276e-02f, 8.44416954e-03f, -2.51801144e-02f, -4.90201600e-02f, 6.34958372e-02f,
  4.58033234e-02f, -7.69920973e-03f, -1.07737519e-02f, 5.91953509e-02f, 1.30292447e-02f, 2.39184741e-02f, 6.53432235e-02f, -4.44924757e-02f, 4.39715013e-02f, -5.94252720e-02f,
  -3.92963812e-02f, -8.16220138e-03f, 4.98598777e-02f, -8.08861256e-02f, -4.77977470e-03f, -7.70737976e-02f, -4.63172123e-02f, 8.30603912e-02f, -2.18603127e-02f, 6.03410648e-03f,
  7.92634487e-02f, -1.52875930e-02f, -5.95663376e-02f, 1.31550701e-02f, 3.02720559e-03f, -1.41763724e-02f, -5.41961230e-02f, 1.12859497e-03f, -9.63396952e-02f, 5.13185300e-02f,
  9.94406939e-02f, 3.01887095e-02f, -4.65285406e-02f, 4.91654016e-02f, -2.05820501e-02f, 7.13946968e-02f, -6.48187548e-02f, 2.77355891e-02f, 5.96931949e-02f, 4.37786207e-02f,
  1.42383091e-02f, 6.41819686e-02f, 4.57448289e-02f, -1.19475694e-02f, 5.80061413e-02f, 1.57205928e-02f, 5.38677387e-02f, -1.38098737e-02f, -1.08194761e-02f, 2.74233539e-02f,
  -2.68182307e-01f, 1.98944882e-01f, 3.71862262e-01f, -7.30378404e-02f, 3.49989124e-02f, 3.02128196e-01f, 4.74857807e-01f, 6.33142740e-02f, -1.59694567e-01f, 5.62466606e-02f,
  -9.73685458e-02f, -3.15536946e-01f, -2.14775100e-01f, -1.11062303e-01f, -7.50433421e-03f, 3.51601452e-01f, 3.27654511e-01f, 5.88680431e-02f, -1.31419137e-01f, -3.23712043e-02f,
  -9.49129239e-02f, -1.16149232e-01f, -1.84039101e-01f, -2.83337459e-02f, 1.18559161e-02f, -1.16511971e-01f, 1.23170100e-01f, 7.28455931e-02f, 9.92634818e-02f, 9.50025842e-02f,
  1.47315979e-01f, 3.17065008e-02f, -3.03870346e-02f, -6.65789470e-02f, 4.37766723e-02f, -6.08428828e-02f, 3.14333066e-02f, 7.47731980e-03f, -3.52684632e-02f, 9.24932491e-03f,
  -5.76668866e-02f, -7.47799426e-02f, 3.76625359e-02f, 1.81964319e-02f, -3.72507945e-02f, 3.53835635e-02f, 2.45051049e-02f, 8.16543028e-03f, -1.35969343e-02f, -7.96268508e-03f,
  -4.16514650e-02f, -1.87801234e-02f, 2.37144399e-02f, 1.02805130e-01f, -2.14369409e-02f, -1.07616358e-01f, -3.73137812e-03f, -9.15974379e-02f, -7.81272911e-03f, -6.26951382e-02f,
  9.81302932e-03f, 1.62137281e-02f, -1.43369951e-03f, -1.80918239e-02f, -3.64471506e-03f, 5.92697226e-02f, 1.35116996e-02f, -1.99336023e-03f, -2.55025197e-02f, 1.61533221e-03f,
  -1.74065027e-02f, -5.97170480e-02f, 1.59028564e-02f, 3.38229835e-02f, -4.31850255e-02f, -1.85368322e-02f, 6.68041408e-02f, -1.75156612e-02f, -8.84442311e-03f, 3.31625603e-02f,
  -1.32984361e-02f, 9.13781077e-02f, 1.63199361e-02f, -2.16916837e-02f, 4.24142145e-02f, 5.12117706e-02f, -6.87255412e-02f, -7.51204193e-02f, -4.42720577e-02f, -4.81033558e-03f,
  -1.80672541e-01f, 2.62764040e-02f, -5.47453612e-02f, -1.81098804e-02f, 1.13585163e-02f, -1.81257240e-02f, -2.33633369e-02f, -6.00688206e-03f, 1.98132657e-02f, 4.56443541e-02f,
  4.87506902e-03f, -3.72538269e-02f, 5.00128493e-02f, 3.19905877e-02f, 1.56266484e-02f, 3.09858378e-02f, 7.15566007e-03f, -4.65732906e-03f, 2.67456230e-02f, -5.00359200e-02f,
  -1.30143929e-02f, 3.38497385e-02f, -8.79055783e-02f, -2.23951675e-02f, -7.67112523e-02f, 1.83169767e-02f, 7.53360018e-02f, 3.21207717e-02f, 3.55264917e-03f, 6.42947033e-02f,
  4.93110955e-01f, 2.03631874e-02f, 1.83437075e-02f, 4.27471958e-02f, -1.56794608e-01f, -1.73210770e-01f, -1.00332044e-01f, -3.96942161e-02f, 3.11143342e-02f, 1.00468714e-02f,
  -1.35161832e-01f, -9.43417698e-02f, -4.57208492e-02f, -7.72091523e-02f, 5.35261594e-02f, 7.69132972e-02f, 9.60276127e-02f, 1.24949552e-01f, -5.79538643e-02f, -1.25597984e-01f,
  -1.81998447e-01f, 5.09197861e-02f, 1.94110975e-01f, 5.42786382e-02f, -2.29636841e-02f, -1.86724618e-01f, -2.89327335e-02f, 6.66731820e-02f, -1.21141113e-01f, 1.04471594e-02f,
  9.58127007e-02f, 1.46498069e-01f, -4.57360223e-02f, -2.75700400e-03f, -6.09948710e-02f, 1.37911618e-01f, 4.11813892e-02f, 8.58480856e-02f, 2.84185987e-02f, 1.74852014e-02f,
  3.28368135e-02f, -2.77341288e-02f, -3.72717567e-02f, 5.75646199e-02f, 1.59381688e-01f, 9.47334543e-02f, 3.47585976e-02f, 9.74925905e-02f, -1.93287041e-02f, 4.97529730e-02f,
  -1.57769054e-01f, -2.87559908e-02f, -1.54972204e-03f, 2.33157780e-02f, -4.06931266e-02f, 1.80098810e-03f, -6.24055602e-02f, 3.04245818e-02f, -7.11564273e-02f, 1.47633225e-01f,
  -6.90150410e-02f, -7.11380243e-02f, 3.69876660e-02f, 7.54834861e-02f, -5.35662547e-02f, 5.36112152e-02f, -1.23430705e-02f, -7.26133510e-02f, -6.88681528e-02f, 7.92612359e-02f,
  4.29803832e-03f, 7.63959112e-03f, 1.23079428e-02f, 3.70503440e-02f, 3.49065661e-03f, -1.40076960e-02f, 1.68940742e-02f, -3.11446246e-02f, 6.53960109e-02f, 6.09187037e-02f,
  5.37939891e-02f, 6.90190913e-03f, 5.94310947e-02f, 3.75560075e-02f, 5.09977923e-04f, -3.50174680e-02f, 1.96201187e-02f, -1.29833035e-02f, -7.19100609e-02f, -6.09741174e-02f,
  2.89818551e-02f, -1.25381917e-01f, 6.62745088e-02f, 2.27812398e-02f, 1.78771690e-02f, -1.26247164e-02f, -7.93707967e-02f, -3.81982028e-02f, 3.45468372e-02f, 2.65427064e-02f,
  -3.61396186e-02f, 7.04433322e-02f, 9.61782858e-02f, -4.39261198e-02f, -3.78441587e-02f, -1.95474215e-02f, 3.91290635e-02f, 5.02554625e-02f, -1.29080964e-02f, -8.44938830e-02f,
  -6.82555288e-02f, 8.49428326e-02f, -7.93236075e-04f, -4.95257452e-02f, -1.96860135e-02f, -1.09497197e-01f, -3.17954421e-02f, -7.87588675e-03f, 5.89904487e-02f, 1.30620867e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.59468257e-01f, -4.41859774e-02f, -2.59457022e-01f, 2.74442118e-02f, -5.62245138e-02f, -1.65503755e-01f, 7.26974662e-03f, 8.24402720e-02f, 1.07067212e-01f, -2.70968042e-02f,
  -7.55105391e-02f, 4.13790271e-02f, -1.18878365e-01f, -3.21794786e-02f, 6.71636462e-02f, 2.05115024e-02f, -7.44798854e-02f, -2.75115930e-02f, -6.83931857e-02f, 5.24251118e-05f,
  -3.92784104e-02f, 1.78569425e-02f, 7.39226416e-02f, 1.32309690e-01f, -4.01692130e-02f, -2.12114919e-02f, -6.60469607e-02f, -6.25265539e-02f, -1.28894811e-02f, -1.86680868e-01f,
  -2.57700503e-01f, -1.18364781e-01f, 7.49895722e-02f, 9.41793919e-02f, 1.25601422e-02f, -3.99096720e-02f, -5.49065731e-02f, 1.10540971e-01f, 8.18888377e-03f, 1.67589933e-02f,
  -5.29614277e-02f, 7.86527842e-02f, -2.18252260e-02f, -7.02499151e-02f, 6.71709925e-02f, 2.68595349e-02f, -3.46351899e-02f, -2.99534071e-02f, 7.11945817e-02f, -6.17181323e-02f,
  5.20901009e-02f, 3.42354663e-02f, -1.52370296e-02f, 2.64184326e-02f, -5.06512932e-02f, -1.02857217e-01f, -9.13087726e-02f, 3.24273519e-02f, 4.95961718e-02f, 3.32362913e-02f,
  -4.38049845e-02f, -1.03772804e-01f, -1.69369355e-02f, -5.08322753e-02f, 7.37898275e-02f, 2.31548753e-02f, -3.88458446e-02f, -3.95240374e-02f, 5.75221982e-03f, 2.40770597e-02f,
  7.58204702e-03f, -6.61988184e-02f, 7.55113438e-02f, -9.35959164e-03f, -5.08311465e-02f, -8.21490958e-02f, 8.61868113e-02f, 4.91747633e-02f, -5.61200231e-02f, 4.01021130e-02f,
  2.14175656e-02f, -5.64117357e-02f, 1.69843771e-02f, -4.23162580e-02f, 1.22920396e-02f, 2.78231353e-02f, 4.63631563e-02f, -8.62218365e-02f, 1.51238451e-02f, -7.41602555e-02f,
  1.52817473e-01f, -4.27566431e-02f, -5.09829819e-02f, 9.31930467e-02f, -6.91731498e-02f, -2.99880151e-02f, -3.29755656e-02f, 9.86406133e-02f, -5.31187803e-02f, 4.63414527e-02f,
  -5.34740500e-02f, -6.37937114e-02f, -5.05006537e-02f, 1.58045720e-02f, 2.70329975e-02f, 3.29635479e-02f, 1.57772362e-01f, -2.01783031e-02f, -5.13442792e-02f, -2.34008171e-02f,
  7.17110038e-02f, 2.77768318e-02f, 5.54014407e-02f, -1.26495343e-02f, -5.03871590e-03f, 1.89305246e-02f, -2.39725504e-03f, -1.32528935e-02f, 3.07918116e-02f, 2.53470540e-01f,
  4.71057147e-02f, 4.91412804e-02f, -1.61641091e-01f, 1.18506290e-01f, -4.59466651e-02f, -6.58146068e-02f, 2.37326808e-02f, 4.56266366e-02f, 2.95756422e-02f, -4.29474562e-02f,
  -4.81647812e-02f, 3.69282290e-02f, 6.36223555e-02f, 4.35616821e-02f, -8.38641673e-02f, -9.41710994e-02f, -3.00142192e-03f, -5.73365502e-02f, -1.05602726e-01f, -3.43933143e-02f,
  1.24337055e-01f, 9.14557800e-02f, -1.13088591e-02f, -3.61474007e-02f, -2.84326244e-02f, -2.70128548e-02f, -1.60780996e-02f, -7.20994547e-02f, -6.54466599e-02f, -4.90175337e-02f,
  -1.27922148e-01f, -3.70765179e-02f, 6.56525046e-02f, -6.07040338e-02f, -8.00483376e-02f, -2.45998632e-02f, 7.47778788e-02f, 9.23906511e-04f, 8.63298699e-02f, 6.87348992e-02f,
  1.77236199e-02f, -3.34013067e-02f, 9.68355983e-02f, 3.94468009e-02f, 9.06689689e-02f, -1.34843243e-02f, -3.94561142e-02f, -7.14467242e-02f, 3.46846618e-02f, 3.47588696e-02f,
  -5.52435666e-02f, -6.79430738e-02f, -2.17640866e-02f, -2.02240385e-02f, -6.07464788e-03f, -1.81513689e-02f, -7.84939751e-02f, 9.36026946e-02f, -4.47996333e-02f, 1.10017814e-01f,
  3.74517888e-02f, -5.87703474e-02f, -6.29063547e-02f, -2.17344109e-02f, -6.18034303e-02f, 1.84995346e-02f, 6.02877466e-03f, 1.05971679e-01f, -5.33871837e-02f, -5.14350273e-02f,
  5.39392196e-02f, -8.45801458e-02f, 2.21806485e-02f, 1.71456169e-02f, -5.36856614e-02f, -7.99431801e-02f, -2.78826375e-02f, 4.31878380e-02f, -9.47515741e-02f, 9.46552083e-02f,
  1.49281034e-02f, -1.04803964e-01f, -8.78865793e-02f, -9.34341922e-03f, 2.95449831e-02f, -1.18713249e-02f, 6.53247610e-02f, 3.63431014e-02f, 8.36501718e-02f, 5.92039488e-02f,
  1.34435445e-01f, -8.14206153e-02f, -3.58043723e-02f, -3.18216123e-02f, -5.10827601e-02f, -8.34047273e-02f, -4.11420614e-02f, -1.03465408e-01f, -3.81775349e-02f, 3.80013660e-02f,
  -3.17478441e-02f, 5.58838136e-02f, 1.89228132e-02f, 1.58239994e-02f, -2.26342250e-02f, 5.27023524e-02f, 5.75612858e-02f, -9.69470516e-02f, 1.73518416e-02f, 1.92332361e-02f,
  7.14001730e-02f, -7.44970888e-02f, 6.44730404e-02f, -5.14903218e-02f, 4.79326844e-02f, 2.75275987e-02f, -4.93380763e-02f, 2.87909396e-02f, 1.87724493e-02f, 7.62085542e-02f,
  5.01446053e-02f, 4.22735512e-02f, -2.10906304e-02f, 8.24658647e-02f, -1.33501023e-01f, -1.92350492e-01f, -2.25164652e-01f, -1.14987515e-01f, 6.92910627e-02f, -6.45017438e-03f,
  -1.92499645e-02f, 3.75906676e-02f, 6.64135348e-03f, 5.13071418e-02f, -7.49465227e-02f, -5.25258761e-03f, 1.22904703e-01f, 7.07529634e-02f, -5.09197488e-02f, -1.06553406e-01f,
  -3.44875902e-02f, -7.56939128e-03f, -4.72326577e-02f, 5.10465913e-02f, 4.70062420e-02f, 2.71084271e-02f, 1.00245573e-01f, 5.52040301e-02f, 7.45786056e-02f, 2.30627820e-01f,
  -7.43736234e-03f, -4.44647260e-02f, -4.65811454e-02f, 1.74619369e-02f, -6.41022772e-02f, -5.12647741e-02f, 3.75437699e-02f, 3.29026673e-03f, 4.73246500e-02f, -6.18934594e-02f,
  -5.94761223e-02f, -1.50654949e-02f, 5.24547286e-02f, -4.36167829e-02f, 6.58403896e-03f, -4.35003173e-03f, 6.36995491e-03f, 3.57280448e-02f, -1.89073030e-02f, 9.17584728e-03f,
  -2.33243480e-02f, -9.74931046e-02f, 1.58618391e-02f, -3.87896001e-02f, -7.66915679e-02f, -8.53106380e-02f, -4.81517315e-02f, -3.09867524e-02f, -5.40451929e-02f, 8.81578773e-02f,
  8.92472193e-02f, -4.90826853e-02f, 7.21273497e-02f, -6.54047430e-02f, -3.72432731e-02f, 4.52993773e-02f, 7.48154297e-02f, -1.77261047e-02f, 9.14337020e-03f, 8.51805508e-02f,
  5.38329035e-02f, -1.20591866e-02f, -8.33903924e-02f, 2.39459029e-03f, 4.80737723e-02f, -8.93397853e-02f, -3.97968180e-02f, 3.81832458e-02f, 3.04392893e-02f, 6.38772920e-02f,
  -2.57426985e-02f, -7.35049248e-02f, 6.71273693e-02f, -9.82168391e-02f, 8.14402476e-02f, -8.50177743e-03f, -1.01398215e-01f, 2.10382361e-02f, -6.75302073e-02f, -6.01265877e-02f,
  7.56375026e-03f, -1.17539980e-01f, 9.10034478e-02f, -6.61850348e-02f, 2.08548512e-02f, 5.88338152e-02f, -5.16477227e-02f, 3.91768403e-02f, -7.52602220e-02f, 6.36199862e-02f,
  -3.63311209e-02f, -1.04588740e-01f, 1.99585781e-02f, -9.25396159e-02f, -7.19187558e-02f, -5.04057072e-02f, 2.41348352e-02f, -3.81735750e-02f, 4.98122443e-03f, 2.76874099e-02f,
  -5.62413558e-02f, -7.21297115e-02f, -8.51976648e-02f, -1.16434738e-01f, -5.19762821e-02f, -6.28164709e-02f, -8.04924890e-02f, -2.85022762e-02f, -6.37266040e-02f, -1.41017929e-01f,
  3.78779680e-01f, 9.25679058e-02f, 3.84343266e-02f, 2.50160992e-02f, -2.32766911e-01f, -2.49262407e-01f, -1.15080625e-01f, 5.12842983e-02f, -2.28925757e-02f, -4.30339165e-02f,
  -1.96117818e-01f, -1.82954706e-02f, -2.30805594e-02f, -9.40636173e-03f, 1.96589351e-01f, 1.53438106e-01f, 9.63353440e-02f, 1.51357025e-01f, 1.23004571e-01f, -5.04870303e-02f,
  -1.32618338e-01f, -3.51168551e-02f, 1.19667493e-01f, 1.23783745e-01f, -3.32597154e-03f, -2.28753351e-02f, -7.16927350e-02f, 2.27027317e-03f, -1.05210096e-01f, 9.09550339e-02f,
  -5.85994199e-02f, 7.70719200e-02f, 2.21708789e-02f, 2.14426685e-03f, -8.01249221e-02f, 9.19031948e-02f, 7.59097040e-02f, 5.30739091e-02f, 6.12168610e-02f, 1.58183351e-02f,
  2.01785453e-02f, 1.16019947e-02f, -5.88466087e-03f, -4.56595421e-02f, -7.38937333e-02f, -5.50407097e-02f, 1.30428508e-01f, 1.61445603e-01f, 1.21071659e-01f, -2.87630670e-02f,
  -3.41800079e-02f, -1.05324097e-01f, 2.69042924e-02f, -1.28478765e-01f, -2.04980411e-02f, -7.46584088e-02f, 3.89657244e-02f, -1.48408012e-02f, -2.59740762e-02f, 1.02097824e-01f,
  -4.12062407e-02f, -9.48604941e-03f, -1.13527477e-02f, -1.31011419e-02f, 9.26272050e-02f, -9.39427838e-02f, 4.05672789e-02f, -2.09732279e-02f, -1.61648989e-02f, 8.35099369e-02f,
  -3.13179344e-02f, 5.17188758e-02f, -5.41460998e-02f, 4.66726236e-02f, 5.72608598e-02f, 1.89944357e-02f, -6.94408193e-02f, 6.63848519e-02f, -5.71119525e-02f, -6.44483790e-02f,
  2.08844990e-02f, 1.76564336e-03f, 5.77249564e-03f, -2.44631730e-02f, 4.57933992e-02f, -3.67877260e-02f, -4.63696457e-02f, -5.30783236e-02f, -1.13546168e-02f, 1.03125304e-01f,
  -4.33045439e-03f, -1.41033113e-01f, -7.81848654e-03f, 1.23572774e-01f, -3.48626189e-02f, 5.95435388e-02f, -4.24552187e-02f, 5.16277030e-02f, -4.49043177e-02f, -7.35692456e-02f,
  -2.20265798e-02f, 5.95983863e-02f, 1.79481991e-02f, 4.82997019e-03f, -2.43794229e-02f, -2.14169081e-02f, 2.64852736e-02f, 1.45864841e-02f, -3.57600078e-02f, -6.69196993e-02f,
  1.65278204e-02f, -7.18608797e-02f, 3.70537527e-02f, 4.71179076e-02f, -4.35102135e-02f, -1.03599370e-01f, -1.71223388e-03f, -9.92414728e-02f, 2.15960834e-02f, 1.41299991e-02f,
  -2.37274632e-01f, -9.41389129e-02f, 1.36744216e-01f, -1.72617123e-01f, 8.28981474e-02f, 1.15767889e-01f, 4.17917371e-02f, 4.61342148e-02f, -2.64463332e-02f, -1.68371536e-02f,
  1.10331997e-02f, -5.52493483e-02f, -2.13925131e-02f, -3.72406244e-02f, 3.53182070e-02f, -7.92339221e-02f, -8.83335397e-02f, 1.14638768e-01f, 7.36855716e-02f, 1.30016729e-01f,
  6.18561953e-02f, 2.09237542e-02f, -2.82709487e-02f, 5.49121089e-02f, -4.78380322e-02f, 1.65624954e-02f, -3.15358490e-02f, -1.19249888e-01f, -7.36198053e-02f, -1.20929092e-01f,
  3.44932079e-01f, -2.23560333e-02f, 3.18029374e-02f, -9.68793705e-02f, 5.01028188e-02f, 4.27133478e-02f, 2.71854103e-02f, -9.65595841e-02f, -2.05887202e-03f, 4.70683351e-02f,
  -6.92641269e-03f, -6.05399013e-02f, -4.24052626e-02f, 8.66688266e-02f, -1.41361414e-03f, 3.26217450e-02f, -1.27794132e-01f, -3.06474566e-02f, -9.10221487e-02f, -8.25927258e-02f,
  -1.08407333e-01f, -1.12064712e-01f, 1.03093773e-01f, 1.10244295e-02f, -2.98605021e-02f, 5.38664870e-02f, 6.01704568e-02f, 8.82147718e-03f, -1.84217840e-03f, -3.54086682e-02f,
  -7.92834088e-02f, -1.82788540e-02f, -3.55837792e-02f, -1.25094329e-03f, 5.48111796e-02f, 2.26226170e-02f, 4.24642935e-02f, 6.23224862e-02f, 1.58218071e-02f, 9.12503451e-02f,
  -3.57914902e-02f, 3.21278423e-02f, 1.77033544e-02f, -1.05227698e-02f, -7.66119957e-02f, -5.81956729e-02f, -7.09829554e-02f, -4.61978950e-02f, 4.84504402e-02f, -9.25299246e-03f,
  1.41481077e-02f, 1.13189518e-02f, -9.15071368e-02f, -1.60217080e-02f, -4.16756459e-02f, 1.37704955e-02f, 4.96307202e-02f, 4.88273464e-02f, 4.34854999e-02f, 3.05662956e-03f,
  2.13789850e-01f, -1.00197539e-01f, 3.60894315e-02f, 5.11846021e-02f, -6.76563829e-02f, -7.29333386e-02f, -1.00174911e-01f, 4.86385683e-03f, -6.30061887e-03f, 8.90269801e-02f,
  -3.96981183e-03f, -3.09968758e-02f, 3.10383867e-02f, -2.14221217e-02f, 1.02163859e-01f, -2.31395196e-02f, -8.30731466e-02f, -5.84853999e-03f, -1.02447040e-01f, -3.06993760e-02f,
  -5.09142093e-02f, 1.32840648e-01f, 6.02194369e-02f, 1.73975289e-01f, 8.87290612e-02f, 1.19278701e-02f, 1.57086626e-01f, 3.73763852e-02f, 3.97971012e-02f, 1.20127447e-01f,
  1.90195605e-01f, 1.67636380e-01f, 1.36970073e-01f, 7.26769865e-02f, 1.30497441e-01f, 2.63345633e-02f, 1.76510364e-01f, 1.93948448e-02f, 1.36168033e-01f, 1.32245645e-01f,
  1.83835983e-01f, 9.21399742e-02f, 1.51360497e-01f, 1.26433447e-01f, 4.72389236e-02f, 1.35024115e-01f, 7.13584647e-02f, 5.74509380e-03f, -3.25942896e-02f, 2.84359995e-02f,
  1.03511609e-01f, 1.85141023e-02f, 1.57398731e-02f, 6.07679412e-02f, -4.99924533e-02f, 1.15881480e-01f, 9.71714333e-02f, -7.04993680e-03f, 8.79793242e-02f, 6.32863492e-02f,
  8.91278908e-02f, 1.03892386e-02f, 1.47029757e-02f, -7.58369192e-02f, -5.36263436e-02f, -3.94233167e-02f, 4.69422201e-03f, -1.49770752e-02f, -6.06536828e-02f, -1.08655386e-01f,
  -2.12477930e-02f, -1.40028615e-02f, -1.33279795e-02f, -7.15296045e-02f, -4.62493626e-04f, -6.30573882e-03f, 4.38628010e-02f, -6.42368868e-02f, 4.43637222e-02f, 4.00810651e-02f,
  -2.72941147e-03f, -1.99244116e-02f, 9.63481814e-02f, -5.82357869e-02f, 1.00865386e-01f, -2.80992524e-03f, 5.18446043e-02f, 5.63494302e-02f, 1.76686211e-03f, -1.03924470e-02f,
  -2.50033084e-02f, 6.48468286e-02f, 2.48718318e-02f, 3.75578962e-02f, 9.54117775e-02f, -3.60906981e-02f, 2.90647062e-04f, 8.16469546e-03f, -3.97694781e-02f, 1.56894997e-02f,
  4.96319234e-02f, 4.42849174e-02f, 5.71187809e-02f, -7.67462701e-02f, -1.02091655e-02f, -4.17953245e-02f, 9.81353410e-03f, 8.58291313e-02f, 3.50704938e-02f, 1.06466347e-02f,
  5.37176244e-03f, -8.17067847e-02f, 4.26198952e-02f, -5.82341887e-02f, 1.79160256e-02f, -2.07810514e-02f, -5.26629724e-02f, 2.31698845e-02f, 6.49905279e-02f, 2.76160594e-02f,
  -9.36328098e-02f, 6.28766268e-02f, -1.38298469e-02f, 4.43651201e-03f, 4.43036072e-02f, -2.55461540e-02f, 1.32719539e-02f, -4.17497009e-02f, -1.16830431e-01f, 4.60395254e-02f,
  5.33392131e-02f, 5.50506711e-02f, -3.08723990e-02f, -8.45077820e-03f, -3.05183083e-02f, -5.82049042e-02f, 3.88153791e-02f, -5.32471528e-03f, -1.19336694e-02f, -4.83138561e-02f,
  -2.12883800e-02f, 5.48877418e-02f, -3.03188711e-02f, 6.50745630e-02f, 7.76831247e-03f, -7.41933808e-02f, -4.49916124e-02f, -1.09614648e-01f, -9.02433768e-02f, -1.84098410e-03f,
  5.02073914e-02f, -2.68900543e-02f, -4.87766229e-02f, 6.54342547e-02f, 2.84428243e-02f, 3.09906248e-02f, 1.55466005e-01f, -1.82303339e-02f, 2.25326582e-03f, 5.51485568e-02f,
  7.25848377e-02f, 5.86635582e-02f, -1.21651785e-02f, 4.64935116e-02f, 3.56450602e-02f, 1.19588174e-01f, 5.88525496e-02f, -7.71699697e-02f, -6.34252578e-02f, -4.93069477e-02f,
  3.93522084e-02f, -9.85764340e-02f, 4.99732718e-02f, -7.98784271e-02f, -4.53823470e-02f, -7.24784061e-02f, -3.71185280e-02f, 3.12120616e-02f, 1.20710079e-02f, 9.17328987e-03f,
  -6.51736036e-02f, -2.63795014e-02f, 8.21747109e-02f, 1.88293811e-02f, 8.13513994e-03f, -5.49894618e-03f, 7.65364319e-02f, 7.05839992e-02f, -8.34710523e-02f, 5.90024069e-02f,
  3.24976817e-02f, -6.07775375e-02f, 9.43239257e-02f, 6.14718609e-02f, 1.21980542e-02f, -5.72898611e-02f, -4.71609347e-02f, 3.34877074e-02f, 1.17639460e-01f, 7.15491027e-02f,
  9.54646841e-02f, -2.33477037e-02f, 6.51143789e-02f, 5.12205809e-02f, -9.60490014e-03f, 3.86350118e-02f, -2.27422360e-02f, 4.52853478e-02f, -1.30242864e-02f, -1.03590358e-02f,
  1.87413804e-02f, 2.10166723e-02f, 2.30584238e-02f, 5.85243367e-02f, -8.36044699e-02f, 2.31784265e-02f, -6.68380708e-02f, 3.47197279e-02f, 1.66321229e-02f, -5.04598245e-02f,
  4.39100666e-03f, -7.24166781e-02f, -5.13077937e-02f, 2.64376085e-02f, -1.62326433e-02f, 5.12067676e-02f, 6.87267818e-03f, 2.47908141e-02f, 3.11223557e-03f, 2.77475845e-02f,
  5.13042361e-02f, -5.81425265e-04f, 6.75360933e-02f, 6.20941911e-03f, 3.03564630e-02f, 8.89424160e-02f, 7.40263164e-02f, 1.68771502e-02f, 6.82595596e-02f, 4.96114530e-02f,
  -9.24370363e-02f, 4.50935140e-02f, -1.00356363e-01f, -2.88698673e-02f, 6.95427954e-02f, -3.93902287e-02f, -6.05637347e-03f, 8.71672411e-04f, -5.81386648e-02f, 1.15724066e-02f,
  4.62915748e-02f, -4.04249020e-02f, -1.82118807e-02f, 5.24017066e-02f, -1.10090319e-02f, -4.46070470e-02f, -7.55268708e-02f, 2.10814420e-02f, 1.18335627e-01f, 9.71956775e-02f,
  8.03492889e-02f, 4.62474599e-02f, -7.34786736e-03f, 2.35910248e-02f, -8.07659104e-02f, -5.24929576e-02f, -5.92920221e-02f, 2.77950391e-02f, 4.28692214e-02f, 4.38967766e-03f,
  -3.63885075e-01f, 1.26649365e-01f, -1.15909405e-01f, -1.20530143e-01f, 1.36000797e-01f, 1.98561683e-01f, 1.16150737e-01f, -8.19830690e-03f, 3.62010142e-05f, 8.72006938e-02f,
  1.18872538e-01f, 2.83178855e-02f, -7.93453828e-02f, 3.05016455e-03f, -9.53884870e-02f, -6.19853139e-02f, -8.05806443e-02f, -1.75420418e-01f, 6.57082796e-02f, 1.67540923e-01f,
  3.74380611e-02f, 1.48277255e-02f, -2.43395805e-01f, -1.13312013e-01f, 3.73608805e-02f, 2.24246550e-02f, -1.27961323e-01f, -1.47085249e-01f, -9.58780106e-03f, -1.15791552e-01f,
  -1.33265510e-01f, -8.01892355e-02f, 9.51194614e-02f, -6.71432987e-02f, -8.87737796e-03f, -5.60848564e-02f, -1.91472396e-02f, -1.16624638e-01f, 2.62725428e-02f, -1.83697545e-03f,
  8.55178237e-02f, -1.68186370e-02f, -6.17798157e-02f, -4.16496396e-02f, -8.92570391e-02f, -1.44330319e-02f, 1.00295525e-02f, -1.55467018e-01f, -1.41530842e-01f, -6.72135055e-02f,
  -3.32684256e-02f, -7.14800805e-02f, -2.10212469e-01f, -1.06630728e-01f, -1.28579661e-01f, -1.22482844e-01f, -1.11900166e-01f, -1.41841948e-01f, -1.89839572e-01f, -1.92383304e-01f,
  -6.76152781e-02f, 3.07641346e-02f, 9.42770019e-03f, 2.38130987e-02f, -8.39584693e-03f, 2.69066039e-02f, 1.25587760e-02f, -2.72799786e-02f, -2.18091393e-03f, -2.88154352e-02f,
  5.02178520e-02f, 1.07822418e-02f, 7.06797093e-02f, -7.87612274e-02f, 1.90176181e-02f, 1.88864358e-02f, 7.32370839e-03f, -3.85400243e-02f, -6.74272776e-02f, 1.47863254e-02f,
  -5.62280556e-03f, 2.21217871e-02f, 5.07192649e-02f, 2.05379929e-02f, -1.67555399e-02f, -7.05170911e-03f, 1.97711792e-02f, 2.14765668e-02f, -7.36993328e-02f, -3.85263041e-02f,
  -1.55894279e-01f, 7.09903166e-02f, -1.48215309e-01f, -2.45809089e-02f, -6.98266774e-02f, -3.60838994e-02f, 3.23520787e-02f, 1.92193314e-02f, 1.18697993e-01f, -5.17901517e-02f,
  -5.13423607e-02f, -2.94677597e-02f, -2.70670336e-02f, -2.12719794e-02f, -4.49774899e-02f, -6.48524091e-02f, -4.75935079e-02f, -9.51200947e-02f, 1.42966891e-02f, 5.14157414e-02f,
  -8.22714940e-02f, -5.84345609e-02f, -1.62053600e-01f, -1.81340903e-01f, -2.67638769e-02f, -2.25840226e-01f, -1.73163280e-01f, -1.34591803e-01f, -1.84804857e-01f, -2.80517876e-01f,
  -6.39066547e-02f, -7.10377283e-03f, -1.47897556e-01f, -9.26120281e-02f, -8.30962509e-02f, 2.44806018e-02f, 9.54795331e-02f, 1.13133207e-01f, 7.94913024e-02f, 9.78675298e-03f,
  -6.56854585e-02f, -9.10793841e-02f, -7.09492806e-03f, 1.64180230e-02f, -9.01336372e-02f, 3.77317369e-02f, -1.18295483e-01f, -1.21229179e-01f, -1.56682417e-01f, -1.94492247e-02f,
  -9.69224498e-02f, -8.10591280e-02f, -1.32470414e-01f, -9.79883247e-04f, 3.20752747e-02f, -5.19472780e-03f, -8.94201025e-02f, -5.48592024e-02f, 3.42730880e-02f, -1.41882986e-01f,
  3.48224416e-02f, -1.43474424e-02f, -6.57940283e-02f, -4.97598350e-02f, -6.85426220e-03f, 5.66232076e-04f, 1.03937417e-01f, 7.86420032e-02f, 3.01412633e-03f, 8.57235044e-02f,
  -3.39951143e-02f, 1.02349974e-01f, -7.85097629e-02f, 1.11592017e-01f, 7.70166740e-02f, 1.10925741e-01f, 1.34069890e-01f, 8.70693922e-02f, -5.81202097e-02f, 2.70660333e-02f,
  -8.41439795e-03f, 9.91947725e-02f, -5.64872809e-02f, 2.52437629e-02f, -4.44595069e-02f, -1.23386085e-01f, 1.16978616e-01f, 9.38198194e-02f, -5.58557920e-03f, 5.38390549e-03f,
  1.85121112e-02f, 5.63315488e-02f, 8.04196149e-02f, -1.44498842e-03f, 4.70443964e-02f, -4.53836191e-03f, -4.00696024e-02f, -2.33449116e-02f, 3.72792669e-02f, 1.07383862e-01f,
  -8.25267192e-03f, -1.14320563e-02f, 9.34324190e-02f, 6.38656726e-04f, 6.24188520e-02f, 1.03739100e-02f, -3.98126543e-02f, -4.77833822e-02f, 3.78026739e-02f, -4.13238555e-02f,
  1.71929821e-02f, -6.02412298e-02f, -3.42134386e-02f, 4.94339168e-02f, 7.67470077e-02f, -2.10540611e-02f, 2.23219730e-02f, -6.09353594e-02f, -8.63850638e-02f, -1.37050390e-01f,
  -6.13748841e-02f, -1.34316668e-01f, -6.21536002e-03f, -1.33259565e-01f, -1.96220223e-02f, 1.10029191e-01f, -3.06008458e-02f, -6.62089065e-02f, -1.13448063e-02f, 8.80040228e-02f,
  2.92060561e-02f, 1.14207625e-01f, -4.55023348e-02f, -2.85310820e-02f, -3.45469266e-02f, 6.16764538e-02f, 9.28945690e-02f, -9.05472413e-02f, -5.44573292e-02f, 1.19853586e-01f,
  8.16934481e-02f, 9.47083682e-02f, 2.29825880e-02f, 1.99681912e-02f, 8.76426399e-02f, 1.71298161e-02f, -8.06675255e-02f, -6.43287413e-03f, -9.39178988e-02f, -7.35049555e-03f,
  5.82221001e-02f, -4.28584069e-02f, 1.66039303e-01f, 1.40746720e-02f, 1.52680427e-01f, 1.86239019e-01f, 2.07506314e-01f, -1.60603598e-02f, 1.74705740e-02f, 4.07945812e-02f,
  5.48204232e-04f, 5.77084860e-03f, 5.76336123e-02f, -2.94749290e-02f, -3.63633558e-02f, -8.93808343e-03f, 5.36413640e-02f, -5.27386107e-02f, 1.44864107e-02f, 1.40142992e-01f,
  9.68585312e-02f, 3.87672894e-03f, 4.33950014e-02f, -4.12297137e-02f, 8.87808111e-03f, -6.08771220e-02f, -3.78622115e-02f, 2.26600282e-02f, 8.41783434e-02f, -3.15649100e-02f,
  8.28769058e-02f, 4.54884730e-02f, 8.62641856e-02f, -5.88749424e-02f, -4.11868729e-02f, -2.84540374e-02f, -9.90463495e-02f, -1.34146670e-02f, -1.22195072e-02f, -6.37487546e-02f,
  3.28312628e-02f, -7.80643150e-02f, -2.79461853e-02f, -8.42674542e-03f, 4.60298918e-02f, 1.24264983e-02f, -2.62512956e-02f, -5.03524765e-02f, -5.08743264e-02f, -6.50144368e-03f,
  -1.04525313e-01f, -6.35890067e-02f, 1.27580268e-02f, -3.49424896e-03f, -9.20346007e-02f, -1.73710771e-02f, 2.54363362e-02f, 9.46514867e-03f, -2.39625629e-02f, -1.11359693e-01f,
  4.30550314e-02f, -6.70161322e-02f, 6.19488321e-02f, -7.76241813e-03f, 7.04788044e-02f, -2.25838646e-02f, 6.28531426e-02f, -3.66113000e-02f, 3.01470421e-02f, 1.30891695e-03f,
  2.53188293e-02f, 4.19228114e-02f, -3.17840315e-02f, 7.00014681e-02f, -5.75350672e-02f, 7.56021068e-02f, -8.23709518e-02f, -3.19355056e-02f, 7.20882788e-02f, -2.36786599e-03f,
  1.14393085e-01f, 4.17297706e-02f, -3.92383449e-02f, -1.81794055e-02f, 5.46942726e-02f, 5.59721068e-02f, 3.52096371e-02f, 2.62171123e-02f, 4.76827994e-02f, -2.92297676e-02f,
  1.35769293e-01f, 4.96336855e-02f, 3.64198312e-02f, -3.05426810e-02f, -1.03250466e-01f, 2.61138193e-02f, 2.60191709e-02f, 5.22403454e-04f, -3.07435226e-02f, -2.96731237e-02f,
  6.23881407e-02f, 5.49047552e-02f, -1.71271451e-02f, -6.68620765e-02f, -5.44699542e-02f, 4.13750298e-02f, 5.19062579e-03f, -4.88138944e-02f, -5.07390834e-02f, 2.17234343e-03f,
  5.38779683e-02f, -2.95290723e-02f, 4.76651601e-02f, 1.01192541e-01f, -5.17854355e-02f, -2.25505177e-02f, 2.17513517e-02f, -2.88053080e-02f, 5.45461513e-02f, 1.41591787e-01f,
  1.04173049e-01f, 1.38002560e-01f, 1.27651950e-03f, -1.62896365e-02f, 7.70460581e-04f, -9.04542655e-02f, 6.27452210e-02f, 3.31862122e-02f, 4.14036401e-02f, -2.54953615e-02f,
  -1.05103634e-01f, 1.41679430e-02f, -4.16427776e-02f, 7.47027472e-02f, 1.28879741e-01f, 1.01209082e-01f, 3.60319689e-02f, 3.79835218e-02f, 9.93940979e-02f, 1.19388826e-01f,
  3.56521383e-02f, 5.84053285e-02f, 1.22617282e-01f, 8.85602832e-02f, 8.65082145e-02f, 1.58956239e-03f, -2.04778295e-02f, 1.53247528e-02f, -4.18059863e-02f, 2.01771140e-01f,
  -5.53209297e-02f, 1.54766217e-02f, -1.35719240e-01f, -8.69684108e-03f, -9.54589993e-02f, -5.60520440e-02f, 6.44309893e-02f, -5.21967635e-02f, -8.09700787e-02f, 9.61312279e-03f,
  -2.83134100e-03f, -5.04228733e-02f, -1.65839400e-02f, -2.90541258e-02f, 9.21892524e-02f, 5.00141308e-02f, 3.81161422e-02f, -3.15353572e-02f, -6.76446259e-02f, -6.94201812e-02f,
  5.33115231e-02f, -5.79206506e-03f, -1.01901725e-01f, -1.16308294e-01f, -7.20302761e-02f, -9.69871506e-02f, -3.62919383e-02f, -4.73806411e-02f, -8.48143324e-02f, 6.62851855e-02f,
  -1.92256644e-02f, 1.49447303e-02f, -5.55457138e-02f, 5.74384443e-02f, -5.42501621e-02f, -3.59562784e-02f, 7.91492090e-02f, 2.37732492e-02f, -4.62032184e-02f, 6.56922460e-02f,
  -8.29511043e-03f, -5.29614240e-02f, -3.54314335e-02f, -1.18504986e-02f, 2.34943815e-02f, 5.14202639e-02f, -6.44794628e-02f, -4.37066779e-02f, 3.62580968e-03f, 2.47752145e-02f,
  2.11727973e-02f, -2.47117281e-02f, 4.36929166e-02f, 2.03630757e-02f, -2.96934955e-02f, -1.99990142e-02f, -1.37938485e-02f, -1.55536868e-02f, 2.55473191e-03f, -5.72490655e-02f,
  -1.49100751e-01f, -1.62086725e-01f, 3.57736163e-02f, 4.00357507e-02f, -1.17988829e-02f, -8.08545128e-02f, 1.86429247e-02f, -1.02875412e-01f, 2.75986250e-02f, -1.38645461e-02f,
  1.89365295e-03f, 5.31001687e-02f, 4.99457046e-02f, 7.15283081e-02f, -5.43727726e-02f, 3.87798138e-02f, 7.31973574e-02f, -3.06439083e-02f, -3.74520868e-02f, 1.67431030e-02f,
  -1.74209122e-02f, -1.18482344e-01f, -3.11935134e-02f, -7.39819854e-02f, -2.83997785e-02f, 2.57382798e-03f, -9.70105156e-02f, -3.99080925e-02f, -9.36330780e-02f, -4.91016991e-02f,
  3.18242133e-01f, 3.90199684e-02f, -4.50446270e-02f, 8.96442160e-02f, -4.53735702e-03f, -2.33688891e-01f, -1.98144734e-01f, -2.40882829e-01f, 5.35852313e-02f, -3.04183606e-02f,
  1.00854775e-02f, 4.26198952e-02f, 6.77690804e-02f, -1.43967912e-01f, -1.98820263e-01f, -2.28627920e-02f, -4.00730446e-02f, 3.77004370e-02f, -1.66657344e-01f, -7.24413395e-02f,
  -8.39367434e-02f, -2.87566427e-03f, 9.65375900e-02f, 2.27103196e-02f, 1.24539830e-01f, -7.64222667e-02f, 9.44886431e-02f, 9.93625373e-02f, -7.41017461e-02f, 2.58892536e-01f,
  2.30711892e-01f, 1.58971831e-01f, -1.01718478e-01f, 4.95401844e-02f, 5.89758120e-02f, -5.67304082e-02f, -5.74480072e-02f, -5.09247789e-03f, -2.68549826e-02f, -2.94305012e-02f,
  2.33330987e-02f, -6.34433627e-02f, 3.08584254e-02f, -5.70717826e-02f, -9.25418139e-02f, -2.73246933e-02f, -6.45102337e-02f, -1.03816960e-03f, -1.04378825e-02f, -6.36649728e-02f,
  7.52722397e-02f, -2.62241010e-02f, -3.26475352e-02f, -7.21120313e-02f, -1.47049269e-03f, -5.29134683e-02f, -2.42971908e-02f, -2.63143275e-02f, -1.07070334e-01f, -3.63373645e-02f,
  -2.73550693e-02f, 3.38564962e-02f, -9.92068350e-02f, -1.44778276e-02f, -2.69845594e-02f, 3.53207365e-02f, 1.27010292e-03f, -5.85933477e-02f, 1.47982817e-02f, -5.61717898e-02f,
  -6.17935248e-02f, -1.62987821e-02f, -3.91868055e-02f, 4.11433019e-02f, 1.16696879e-02f, 5.29917516e-02f, 2.18704585e-02f, -1.04643717e-01f, -7.69868344e-02f, 8.04384947e-02f,
  -2.35169437e-02f, 7.74951512e-03f, 6.72672316e-02f, -4.54439931e-02f, -1.01797923e-01f, 1.57717634e-02f, 1.43378135e-02f, 3.54150906e-02f, -4.04684842e-02f, 5.23223020e-02f,
  1.66685618e-02f, -1.87108442e-01f, 3.52653712e-02f, -5.56522161e-02f, 7.72913769e-02f, 3.29679530e-03f, 1.02864511e-01f, -8.23713690e-02f, 6.61924481e-03f, -4.89392243e-02f,
  -3.21744867e-02f, 1.85703058e-02f, -4.45637777e-02f, -1.09259877e-02f, -2.20491011e-02f, 6.89290790e-03f, -9.10392404e-03f, -6.07795781e-03f, -3.22974846e-02f, -1.22426217e-02f,
  -1.12946056e-01f, -1.58141211e-01f, 8.35612975e-03f, -1.09227940e-01f, -9.58246812e-02f, -3.50926518e-02f, -1.44962519e-01f, 8.63171555e-03f, -1.35474607e-01f, -1.41495153e-01f,
  -6.87712952e-02f, 6.83117099e-03f, -3.56212825e-01f, -1.21604316e-01f, 1.08188728e-03f, 5.88950291e-02f, -1.08751711e-02f, -3.11330780e-02f, 2.80320682e-02f, -6.94946200e-02f,
  -9.19689909e-02f, -7.78699666e-02f, -1.13582902e-01f, -1.63154364e-01f, -2.52822667e-01f, -3.27367723e-01f, -2.47049630e-01f, -3.48225534e-01f, -1.30367294e-01f, -9.04934295e-03f,
  -1.04494661e-01f, -5.92751130e-02f, -5.04565835e-02f, -2.36612353e-02f, 1.11513473e-01f, 3.61254066e-02f, -1.03818536e-01f, -8.99475962e-02f, -8.00290611e-03f, -1.66976675e-01f,
  -2.56255329e-01f, 7.16766715e-02f, -8.13569967e-03f, 2.03434192e-02f, 3.18305977e-02f, 3.13702524e-02f, -4.00855578e-02f, -1.28975846e-02f, -3.88120711e-02f, -3.07785105e-02f,
  -8.32128748e-02f, -1.10416384e-02f, -4.05424573e-02f, 8.19075480e-02f, -4.99616303e-02f, -8.82247090e-02f, 8.45442712e-03f, -4.36371863e-02f, -1.04616918e-01f, 5.46984933e-02f,
  -8.40873718e-02f, -1.12097345e-01f, -1.10281408e-01f, -7.94210657e-03f, 9.71310213e-02f, -6.43747346e-03f, 1.34553403e-01f, 4.82201502e-02f, 3.00515853e-02f, 1.13766484e-01f,
  5.00592999e-02f, -6.59261718e-02f, -3.99695430e-03f, 6.11405671e-02f, -5.55581134e-03f, 4.01436128e-02f, 1.47183016e-02f, -1.66245922e-02f, -4.76843771e-03f, 5.81384636e-03f,
  -1.91375669e-02f, -1.06913112e-01f, -7.98691586e-02f, 4.32455800e-02f, -5.82341477e-02f, -5.22047430e-02f, -5.91172390e-02f, -1.99345332e-02f, -3.46903726e-02f, 4.68238592e-02f,
  -4.90509570e-02f, 9.47873816e-02f, 5.04093431e-02f, -1.05455397e-02f, -4.42681983e-02f, -4.29599434e-02f, 4.01636623e-02f, 5.37485555e-02f, -5.54194115e-02f, -1.05446137e-01f,
  1.27325514e-02f, -1.17096528e-01f, -1.21668443e-01f, 4.87071909e-02f, -3.89654897e-02f, -2.27816366e-02f, -9.67352241e-02f, -1.06793523e-01f, -2.68742908e-02f, 1.88725311e-02f,
  -6.70956075e-03f, -3.03470809e-02f, -1.03941806e-01f, 1.26751689e-02f, -1.22386133e-02f, 5.24795726e-02f, 4.73956279e-02f, -1.01976551e-01f, -4.51676100e-02f, 3.97741869e-02f,
  5.90906963e-02f, -1.36420310e-01f, -7.32906759e-02f, -2.10157260e-02f, 1.09012000e-01f, -2.14376509e-01f, -1.09535992e-01f, -1.15442630e-02f, -1.14941545e-01f, -8.57732221e-02f,
  -3.70639302e-02f, -1.49927855e-01f, -4.44849953e-02f, 5.54638728e-02f, 1.21524967e-02f, 1.08905211e-02f, -9.02087539e-02f, -7.05082342e-02f, 7.66107738e-02f, 5.13236150e-02f,
  -6.36900514e-02f, 7.30151981e-02f, -4.81773131e-02f, 3.12203616e-02f, -1.33403961e-03f, 2.00621150e-02f, -5.75616397e-02f, 7.05977231e-02f, -5.09894527e-02f, -3.65343243e-02f,
  5.00678495e-02f, 7.72050843e-02f, 3.09125781e-02f, -3.52938473e-02f, -5.80424257e-02f, 6.65156469e-02f, -1.45294843e-02f, -5.14232144e-02f, -9.29100811e-02f, 2.98471358e-02f,
  -2.29467526e-02f, 4.01833840e-02f, 1.06883921e-01f, -4.01071794e-02f, -4.67889830e-02f, -2.14673840e-02f, 7.25759044e-02f, -1.63843706e-02f, 1.07221091e-02f, 3.35278586e-02f,
  -1.04024028e-02f, 1.85818095e-02f, 3.98775823e-02f, 4.24742587e-02f, 1.36456070e-02f, -2.10767724e-02f, -2.66531557e-02f, 6.50785714e-02f, -7.34194815e-02f, -2.79357377e-02f,
  6.21307939e-02f, -5.52726090e-02f, 7.50570372e-02f, -3.76612693e-02f, -5.38827591e-02f, 1.09239500e-02f, 5.99396322e-03f, 2.73760222e-02f, 8.64259899e-02f, -3.69349383e-02f,
  3.62001732e-02f, -1.15861744e-01f, -4.70704511e-02f, 9.86685082e-02f, -1.36256348e-02f, -5.77094443e-02f, 1.53263267e-02f, -4.64877859e-02f, -4.48576082e-03f, -4.92683016e-02f,
  2.59595718e-02f, 3.89427654e-02f, 7.80259520e-02f, 1.21793887e-02f, -9.13095251e-02f, -5.28061949e-02f, -1.06859242e-03f, 5.04824258e-02f, 2.62897350e-02f, -5.43136187e-02f,
  1.46045620e-02f, 4.75905500e-02f, 5.56763597e-02f, -6.15561716e-02f, -7.90058896e-02f, 4.13032398e-02f, -5.62396124e-02f, 3.84700485e-02f, 8.83803740e-02f, -2.44024792e-03f,
  -3.15917172e-02f, 1.05274111e-01f, 7.94602185e-02f, -3.07200886e-02f, 4.63157035e-02f, -1.04230212e-03f, 1.96468737e-02f, 3.04224179e-03f, 5.32174893e-02f, 3.80302817e-02f,
  9.61308032e-02f, 3.86976749e-02f, -4.85298932e-02f, 7.25840330e-02f, 5.31188175e-02f, -1.22404296e-03f, -3.59360985e-02f, -6.31882949e-03f, 8.24513733e-02f, -3.11500262e-02f,
  -3.57662328e-02f, 1.16578355e-01f, 5.46547249e-02f, -1.37728984e-02f, 1.03231996e-01f, 4.40809131e-02f, 2.08869949e-02f, 4.79799360e-02f, -5.58985770e-02f, 7.24226683e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.67468950e-01f, 7.92778283e-03f, 4.60053608e-02f, 1.43741891e-01f, 4.11487445e-02f, 1.87569000e-02f, 9.22991484e-02f, 2.18909025e-01f, 1.17874727e-01f, 8.17696452e-02f,
  8.24596137e-02f, 1.43910825e-01f, 1.45753771e-01f, -9.85837076e-03f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  8.54318887e-02f, 6.00519739e-02f, -6.46892712e-02f, -5.86470263e-03f, -4.47574146e-02f, -1.06923461e-01f, 7.20297024e-02f, -3.03889122e-02f, -2.73327500e-01f, 8.29508454e-02f,
  -2.29300205e-02f, 1.39152899e-01f, 9.18873325e-02f, 5.76606505e-02f, -1.38209894e-01f, 5.57672605e-02f, 1.33829996e-01f, -1.53283551e-01f, 2.55888905e-02f, 7.23763481e-02f,
  -1.17845118e-01f, -2.07653735e-02f, 1.66240901e-01f, -1.30054250e-01f, 7.08120316e-02f, -2.25386977e-01f, -8.01107436e-02f, -2.17673779e-02f, -1.81854479e-02f, 6.49142358e-03f,
  -7.16035664e-02f, -1.81644961e-01f, -1.11412846e-01f, -3.32117341e-02f, -3.72327007e-02f, 5.74875586e-02f, -1.52728856e-01f, 1.21758386e-01f, -6.37614802e-02f, 7.05053136e-02f,
  1.32154301e-01f, 1.45151109e-01f, -7.36461803e-02f, -1.37534454e-01f, -2.24115569e-02f, -1.57977212e-02f, 4.61144596e-02f, 9.37655047e-02f, -5.50516136e-03f, -1.55291677e-01f,
  -1.16438821e-01f, 1.04634881e-01f, 4.84168530e-02f, -3.55078503e-02f, 3.82490992e-03f, 1.27782628e-01f, -1.07741505e-01f, 7.60317817e-02f, 1.46070093e-01f, -3.49310488e-02f,
  1.36353388e-01f, 4.41697277e-02f, 1.60677701e-01f, -9.78929773e-02f, 1.08319536e-01f, 1.84093282e-01f, -2.50151884e-02f, -7.11351112e-02f, -1.18044309e-01f, -1.11769967e-01f,
  -1.04600579e-01f, 2.07640335e-01f, 2.57792145e-01f, -2.01036021e-01f, -9.02807191e-02f, 1.08335137e-01f, -9.95531306e-03f, 1.83231384e-01f, 5.97522780e-02f, 9.11847651e-02f,
  -5.57528920e-02f, 2.12142020e-01f, -4.92092259e-02f, 1.81976333e-02f, 1.42039508e-01f, 4.48747836e-02f, -5.63909626e-03f, 2.48776078e-01f, 1.14916600e-01f, -1.48090675e-01f,
  -8.04131925e-02f, -5.32765035e-03f, -1.51350483e-01f, -1.54009178e-01f, -1.97859928e-01f, 2.29058698e-01f, 5.44455610e-02f, 1.15587324e-01f, 1.05089717e-01f, -1.73650607e-01f,
  -8.22957680e-02f, 9.09048691e-02f, -2.94067353e-01f, -5.15289931e-03f, 2.96674240e-02f, 2.44417973e-02f, 1.29038528e-01f, -1.31490573e-01f, -1.99188162e-02f, -3.59178931e-01f,
  3.03908698e-02f, 2.18106899e-02f, 3.47439311e-02f, 2.64840543e-01f, -3.67434993e-02f, 6.64644018e-02f, -2.41995789e-02f, 1.34421676e-01f, 2.09352095e-02f, -6.96569532e-02f,
  -1.83555499e-01f, -2.90530205e-01f, 1.43903002e-01f, 3.61239277e-02f, 5.80609329e-02f, 1.70348078e-01f, 2.49420069e-02f, -1.40072912e-01f, -1.26043111e-01f, 9.63270650e-05f,
  -1.13341473e-01f, 6.02460168e-02f, -1.30039349e-01f, -1.34404600e-01f, 5.78285381e-02f, -1.01044878e-01f, 7.44886473e-02f, -1.00727767e-01f, 1.36942685e-01f, 9.14664865e-02f,
  3.71904373e-02f, -1.01172201e-01f, -9.75853726e-02f, -7.97081143e-02f, 1.26359344e-01f, -5.32310009e-02f, 1.27932712e-01f, -7.28242546e-02f, 9.94570702e-02f, -3.38595957e-02f,
  9.18568671e-02f, -2.59231012e-02f, -1.46344766e-01f, 4.49789390e-02f, -9.71367508e-02f, 6.52726963e-02f, -1.89325050e-01f, 3.29677053e-02f, -2.34466448e-01f, -3.72174196e-02f,
  1.84223309e-01f, -1.30205303e-01f, 1.42827302e-01f, 1.71357304e-01f, -1.28895462e-01f, 3.42896171e-02f, -5.86928502e-02f, 1.19514294e-01f, -2.75220841e-01f, -1.18611790e-01f,
  -4.76743430e-02f, -2.04901934e-01f, 9.61241052e-02f, 2.24009380e-01f, -2.46626437e-01f, 6.97109699e-02f, 1.74716890e-01f, 1.93539187e-01f, 4.72579300e-02f, -1.57522693e-01f,
  -5.87330088e-02f, 5.71974888e-02f, -1.16051957e-01f, 2.35952344e-02f, 1.19477689e-01f, 1.02463551e-02f, 8.89683589e-02f, -1.14174567e-01f, 9.36038643e-02f, -6.90881610e-02f,
  1.64920324e-03f, -8.79410952e-02f, 1.89533215e-02f, -1.32240564e-01f, -7.86304325e-02f, 6.95899501e-02f, -1.22722648e-01f, 3.15768719e-02f, -7.45395795e-02f, 3.42602096e-03f,
  5.52260540e-02f, -5.88085018e-02f, -1.67571470e-01f, 7.10784644e-02f, -9.60324407e-02f, 2.12901145e-01f, 8.01437497e-02f, -1.27394840e-01f, -5.85156009e-02f, -1.35600520e-02f,
  9.74578485e-02f, -7.05300719e-02f, -1.71804056e-02f, 1.64161220e-01f, -8.09478760e-02f, -1.10697232e-01f, -9.73397691e-04f, 1.90333515e-01f, -2.42449760e-01f, 9.60679725e-02f,
  2.09578261e-01f, -2.84357015e-02f, 3.22074652e-01f, 1.31201878e-01f, 5.86495437e-02f, 2.66818911e-01f, -2.20760092e-01f, -3.43028344e-02f, 5.70512153e-02f, -5.36329225e-02f,
  -6.96377382e-02f, -3.91653292e-02f, 9.71620828e-02f, -5.77691346e-02f, -4.65340495e-01f, 2.51439679e-03f, -5.47580086e-02f, 2.65290648e-01f, 2.65201763e-03f, 2.96953712e-02f,
  3.19126070e-01f, -2.58916080e-01f, -1.35996029e-01f, -1.19243205e-01f, -1.64307252e-01f, -2.75715232e-01f, 2.52571970e-01f, -1.46159053e-01f, 7.08226785e-02f, 2.46452391e-01f,
  -3.59947123e-02f, 6.56068772e-02f, -2.91899815e-02f, -2.33261988e-01f, 3.41417827e-02f, 9.09047276e-02f, -5.74369095e-02f, -9.91945788e-02f, 2.77056191e-02f, 3.34307849e-02f,
  -4.85424176e-02f, -7.95999989e-02f, -9.37700048e-02f, -6.52744398e-02f, -2.72957385e-01f, -3.38193551e-02f, -4.65494953e-02f, -8.92500579e-02f, -3.45135331e-02f, 2.59445719e-02f,
  1.44305900e-01f, -8.34321082e-02f, -4.30938080e-02f, -1.32217988e-01f, -4.25844640e-02f, 7.44592249e-02f, -1.47885695e-01f, 2.91829985e-02f, 1.63901240e-01f, -2.01134067e-02f,
  2.81964112e-02f, -1.03444912e-01f, -1.24449193e-01f, 7.24854022e-02f, 4.37629223e-02f, -7.99265280e-02f, -1.04141710e-02f, -3.97755727e-02f, 1.82402134e-01f, -6.90942928e-02f,
  -1.35331511e-01f, -2.11013183e-01f, -2.82012641e-01f, -9.56354022e-04f, -3.04338057e-02f, 5.73459789e-02f, -7.44298920e-02f, 9.17059463e-03f, -9.64754820e-02f, -1.29926324e-01f,
  -5.36953658e-03f, -4.20268439e-02f, 1.77055076e-01f, -4.21216972e-02f, 1.36657313e-01f, -5.73728886e-03f, -1.17650799e-01f, 9.07591879e-02f, 6.80962726e-02f, -1.60787359e-01f,
  7.30204210e-02f, 6.13015331e-02f, -1.57133952e-01f, -8.64726305e-02f, -2.12130159e-01f, 7.37232342e-02f, 2.14272857e-01f, 8.86582136e-02f, -2.06534594e-01f, 1.14358701e-01f,
  6.52164444e-02f, 4.16581929e-02f, 1.53398409e-01f, -1.20949689e-02f, -3.48274894e-02f, 1.63565025e-01f, -8.90181139e-02f, -7.95748904e-02f, 1.68157853e-02f, 1.82597429e-01f,
  -3.66836749e-02f, -5.71337044e-02f, 1.17783308e-01f, -2.67228857e-02f, 5.94197810e-02f, -9.67329890e-02f, 1.78743094e-01f, 1.21506147e-01f, 1.61661003e-02f, 2.54506357e-02f,
  7.60804787e-02f, -7.32243136e-02f, 8.07128754e-03f, -1.77497327e-01f, 1.48649156e-01f, 5.66151738e-02f, -3.76585685e-02f, -2.23241985e-01f, -1.25715524e-01f, 5.87791279e-02f,
  2.07480080e-02f, -6.47800714e-02f, -2.05194727e-01f, 1.56046540e-01f, -1.75696090e-01f, 1.83784693e-01f, -1.86509565e-01f, 9.36795399e-02f, 3.09226096e-01f, 2.40131728e-02f,
  -1.90929458e-01f, -1.50841847e-01f, 3.15020569e-02f, -8.68957490e-02f, 3.16813946e-01f, 1.98757827e-01f, 1.44403828e-02f, 2.01473355e-01f, -1.21929251e-01f, -1.39491543e-01f,
  1.63917333e-01f, 1.76858619e-01f, -2.10046127e-01f, -1.33984610e-01f, -1.49921477e-01f, 8.59472081e-02f, 1.07755072e-01f, 3.23173374e-01f, 1.42084673e-01f, 6.02991739e-03f,
  7.73045607e-03f, -1.21980853e-01f, 2.75360376e-01f, 1.25422865e-01f, 3.68653499e-02f, 2.95599122e-02f, 7.02824667e-02f, 5.25266565e-02f, -7.50387982e-02f, 1.20403036e-01f,
  2.99614351e-02f, 9.19937342e-02f, 1.68809921e-01f, -1.51765242e-01f, -1.06137820e-01f, 1.17277550e-02f, -1.33856037e-03f, -2.36166697e-02f, 7.09863678e-02f, -8.88329148e-02f,
  -3.87538620e-03f, 1.27112597e-01f, 1.28376648e-01f, 8.56722370e-02f, 1.54283002e-01f, -5.93256764e-03f, 2.63128672e-02f, 1.43178120e-01f, -8.18433985e-03f, 2.98225999e-01f,
  -2.39855479e-02f, -4.90566455e-02f, 1.09508090e-01f, -2.57457107e-01f, 2.77620673e-01f, 2.11012721e-01f, 8.04789960e-02f, 2.03183517e-01f, -2.56409019e-01f, -1.02259718e-01f,
  -7.97137916e-02f, 7.26898164e-02f, 6.81288540e-02f, -1.63566973e-02f, 1.07926443e-01f, -1.41907394e-01f, -1.71175554e-01f, -3.29724327e-02f, -2.72452943e-02f, 5.56268357e-02f,
  1.97220728e-01f, -2.72402968e-02f, 8.99807736e-02f, -1.03912525e-01f, 1.00041471e-01f, -2.62629427e-02f, 2.03231983e-02f, 3.13558504e-02f, 1.27669036e-01f, -7.27386400e-02f,
  1.82774346e-02f, -1.63334176e-01f, 6.45735711e-02f, 1.46843016e-01f, -2.90255044e-02f, -1.79070204e-01f, -1.43766209e-01f, 8.52357373e-02f, -5.39576486e-02f, 5.95785603e-02f,
  -1.40526248e-02f, -3.86970416e-02f, -4.78863865e-02f, 1.18080415e-01f, 7.97259808e-02f, 1.18411154e-01f, 1.93325087e-01f, 1.13646023e-01f, -4.99243028e-02f, -1.48368329e-01f,
  -2.03251898e-01f, 1.46653309e-01f, -5.54141477e-02f, 3.86218652e-02f, 1.01564042e-02f, 3.44430804e-02f, 2.74820253e-02f, -5.31650893e-02f, -8.84153470e-02f, 9.58799943e-02f,
  -8.37726817e-02f, 1.93295628e-01f, -4.48057503e-02f, -1.04542241e-01f, 1.92136079e-01f, 1.83995694e-01f, 3.22458334e-02f, 2.19294086e-01f, -1.48961693e-01f, -1.92759275e-01f,
  -3.14820558e-02f, -1.09396912e-01f, 3.58316869e-01f, 2.19736025e-02f, -3.47080566e-02f, -2.25564718e-01f, -9.94973406e-02f, 8.29137489e-03f, 1.32278264e-01f, -1.47326812e-01f,
  3.12231872e-02f, 1.93690717e-01f, 1.77471414e-01f, -9.94091183e-02f, 6.64899573e-02f, -1.80356383e-01f, -2.68691570e-01f, 3.81158069e-02f, -8.00938928e-04f, 9.35711488e-02f,
  8.31382126e-02f, 1.06946953e-01f, -1.55797854e-01f, -9.80961472e-02f, 4.51293886e-02f, -5.77325523e-02f, 8.76530632e-02f, -1.19982325e-01f, 5.45846969e-02f, 3.74883190e-02f,
  1.33834362e-01f, -3.36333290e-02f, -2.41203740e-01f, -1.00255169e-01f, -1.14081040e-01f, -1.31685480e-01f, 2.04655945e-01f, 1.92011241e-02f, -2.28918102e-02f, -5.04829474e-02f,
  -2.30290353e-01f, 1.72837511e-01f, 9.07050520e-02f, 1.27019554e-01f, -3.62620354e-02f, -9.44401398e-02f, 1.08793164e-02f, -8.86694565e-02f, -5.68961389e-02f, -6.26134053e-02f,
  -6.36979891e-03f, -1.43776849e-01f, -9.27068107e-03f, 1.24895771e-04f, -1.38057442e-02f, -1.62802339e-01f, 8.02052990e-02f, 8.62337872e-02f, 4.13011611e-01f, -7.90892809e-04f,
  1.62927181e-01f, 1.55485988e-01f, 2.28456095e-01f, -3.25723261e-01f, -2.36620411e-01f, -9.05383751e-02f, 1.42357379e-01f, -1.42910853e-02f, 1.88783750e-01f, 1.08568102e-01f,
  8.82186219e-02f, -7.24025816e-03f, 3.62597816e-02f, 2.29641572e-01f, 2.80094326e-01f, 7.02005159e-03f, 3.83919440e-02f, 1.03454620e-01f, 1.42566711e-01f, -1.77023523e-02f,
  -3.41913670e-01f, -2.15072826e-01f, -7.78083131e-02f, 5.71055152e-02f, -1.43850952e-01f, -2.18903884e-01f, -2.53282990e-02f, 1.16618492e-01f, 1.41295567e-01f, 6.78817406e-02f,
  -2.27837041e-02f, 4.83954102e-02f, -2.41126120e-03f, 1.94933072e-01f, 1.82103634e-01f, 9.59293619e-02f, -1.24548224e-03f, 2.35511318e-01f, -4.30566346e-04f, -1.07485346e-01f,
  9.68394428e-03f, 1.60180107e-01f, -8.51132348e-02f, 5.71510792e-02f, 1.94168985e-01f, 9.35470406e-03f, 1.53965252e-02f, 1.37987882e-01f, 1.52603939e-01f, -1.41261593e-02f,
  -5.00700017e-03f, -4.60424758e-02f, 1.49778515e-01f, 1.60363689e-01f, 1.93645265e-02f, 8.36921111e-02f, -2.34842282e-02f, -7.35915229e-02f, -5.43208793e-02f, 1.21488675e-01f,
  -1.44995183e-01f, -1.60092905e-01f, -2.65072733e-01f, -8.47336277e-02f, -3.32841009e-01f, -1.28436059e-01f, -3.80872488e-01f, 2.35961631e-01f, -4.48151194e-02f, 1.18837833e-01f,
  -1.41616449e-01f, 2.22331583e-02f, -3.79715502e-01f, 2.78391570e-01f, 7.92474076e-02f, -1.29459456e-01f, -3.26876342e-01f, -4.89355251e-02f, 9.16557759e-02f, -1.35308757e-01f,
  1.82438210e-01f, -2.59145826e-01f, -1.21899188e-01f, 1.11247629e-01f, 6.52464703e-02f, 1.05508760e-01f, 9.81016830e-02f, 9.71984789e-02f, -1.12181166e-02f, -9.14997980e-03f,
  -5.59277348e-02f, -6.81860670e-02f, 5.59375994e-02f, -1.18320949e-01f, 1.19431309e-01f, 8.90626311e-02f, 8.78186710e-03f, -2.35507693e-02f, 6.32643253e-02f, -6.89950809e-02f,
  -1.98686734e-01f, -1.04840465e-01f, -7.06138909e-02f, -1.73755869e-01f, 1.08069673e-01f, -1.42422482e-01f, -1.45540982e-01f, 1.15920387e-01f, 2.61552930e-02f, 5.85855842e-02f,
  -1.46375135e-01f, -6.40267953e-02f, 1.32197335e-01f, -7.52144009e-02f, -1.96605638e-01f, -5.19377105e-02f, 7.35585615e-02f, 3.98736410e-02f, -1.86259210e-01f, -3.73351164e-02f,
  -1.64898351e-01f, -5.99422166e-03f, -4.18464914e-02f, -1.42033860e-01f, 6.29450455e-02f, -1.84268877e-01f, 1.51945591e-01f, -9.88894850e-02f, 9.05914009e-02f, 4.87693548e-02f,
  2.05686549e-03f, -2.54726022e-01f, -2.74169505e-01f, -9.46993083e-02f, 6.00911751e-02f, -1.22543104e-01f, -3.00822407e-02f, 6.08130954e-02f, -1.06702253e-01f, -1.26703411e-01f,
  -1.30891025e-01f, 7.52353072e-02f, 6.34708479e-02f, -7.03935772e-02f, 1.38520986e-01f, -1.12860970e-01f, -1.20832413e-01f, 8.80161822e-02f, -4.44387533e-02f, -3.28333937e-02f,
  4.23129462e-02f, 1.02564931e-01f, -4.55465764e-02f, -3.26344557e-02f, -4.32479195e-02f, -2.14351844e-02f, 4.26909849e-02f, 1.78371206e-01f, 1.70021832e-01f, -1.13843670e-02f,
  -1.44705735e-02f, -1.48240060e-01f, 2.65428424e-01f, 3.74243967e-02f, 1.89257115e-02f, 1.87011167e-01f, -1.39579382e-02f, -1.06384568e-01f, -1.94775566e-01f, -1.94087073e-01f,
  2.14104410e-02f, -1.30333053e-02f, 4.44782451e-02f, -1.52034149e-01f, 2.68455129e-02f, -8.28402340e-02f, -2.17774376e-01f, 1.18625142e-01f, 3.79481688e-02f, -8.88881385e-02f,
  4.23638634e-02f, -1.73603699e-01f, 1.45902634e-01f, 4.36562411e-02f, -6.65739998e-02f, 5.54435812e-02f, -9.22029689e-02f, 1.37824252e-01f, -4.36277464e-02f, -3.87780726e-01f,
  -2.66739130e-01f, 1.19324550e-01f, -1.72143146e-01f, 1.94672823e-01f, -2.69142061e-01f, -1.84822366e-01f, 9.10511166e-02f, -1.55320302e-01f, 2.03658044e-01f, -8.84215385e-02f,
  -1.24280892e-01f, -1.57678157e-01f, -2.97051221e-01f, 3.16675633e-01f, -1.08663283e-01f, -5.32890372e-02f, 7.72224143e-02f, -2.32284322e-01f, 3.25413235e-02f, -6.48429543e-02f,
  -2.61577189e-01f, -7.20437765e-02f, 1.65297002e-01f, 9.26655009e-02f, -2.95368254e-01f, -6.75659850e-02f, 8.15657824e-02f, -6.77261949e-02f, -1.09382994e-01f, -5.83508722e-02f,
  -1.15283445e-01f, 3.34226410e-03f, 1.89983696e-02f, 3.73980938e-03f, -1.46864839e-02f, 1.46823063e-01f, -1.32826446e-02f, -2.20425390e-02f, -8.96080285e-02f, -2.26081144e-02f,
  8.49404112e-02f, 1.01078358e-02f, 1.01411037e-01f, 1.94604412e-01f, 1.14046805e-01f, -4.51723896e-02f, 1.66123528e-02f, -5.77028655e-02f, -2.72108451e-03f, -3.72026078e-02f,
  2.22701967e-01f, 4.77617234e-02f, -3.85617614e-02f, 1.26803786e-01f, 8.24548826e-02f, 2.44666055e-01f, 1.17266186e-01f, 6.65938780e-02f, 1.43171415e-01f, 8.82698521e-02f,
  1.76570103e-01f, 7.48446807e-02f, -1.05423130e-01f, 2.76283532e-01f, 1.28866717e-01f, 5.96735589e-02f, 2.60466766e-02f, -1.64353624e-02f, 4.88017797e-02f, 2.32207313e-01f,
  7.24124759e-02f, 8.01587254e-02f, -1.77041873e-01f, -5.78161664e-02f, 2.52830654e-01f, 8.24026987e-02f, 2.58837283e-01f, -1.55717105e-01f, -9.98896360e-02f, -8.48512799e-02f,
  2.80096233e-02f, -2.74203755e-02f, 5.46619557e-02f, -8.68214592e-02f, 1.05383553e-01f, -1.03443444e-01f, -1.79092437e-01f, 1.54256925e-01f, 1.83550730e-01f, 5.62848821e-02f,
  1.00609109e-01f, 1.85850292e-01f, -4.87030037e-02f, -1.28656715e-01f, -3.58181447e-02f, -1.37738764e-01f, 1.38221964e-01f, -9.18116271e-02f, 1.20556600e-01f, -3.20066512e-02f,
  1.11734167e-01f, 8.96439701e-02f, -9.39586908e-02f, 6.88946545e-02f, -6.16456345e-02f, 8.87961760e-02f, -1.09083429e-01f, 5.69514818e-02f, -1.77097395e-01f, -6.79649189e-02f,
  3.77932340e-02f, -1.94777712e-01f, -1.40816227e-01f, -9.00306478e-02f, 4.48075160e-02f, 1.34352282e-01f, 1.37832284e-01f, -1.01816744e-01f, -4.23699059e-02f, 1.64422378e-01f,
  1.14129845e-03f, -1.42579094e-01f, 4.01651338e-02f, -6.66644946e-02f, 7.41666183e-02f, 1.22608513e-01f, -1.80831403e-02f, 2.02402189e-01f, 2.34965920e-01f, 1.12284012e-01f,
  2.45095313e-01f, -9.69377160e-03f, 2.37059653e-01f, 7.07174540e-02f, -3.78407687e-02f, 1.88476324e-01f, -1.18231149e-02f, -2.18548760e-01f, 8.01605806e-02f, -1.81136042e-01f,
  -7.44801909e-02f, -4.21465673e-02f, 2.34808058e-01f, 6.42132536e-02f, -4.40352820e-02f, 2.47204676e-01f, 3.00134206e-03f, -1.04541577e-01f, 1.83184087e-01f, -1.41689152e-01f,
  -2.60163397e-01f, -6.51988238e-02f, -1.07023962e-01f, -6.43505342e-03f, 1.47757202e-01f, -1.20903611e-01f, 1.61889717e-02f, -1.21810399e-01f, -1.62375525e-01f, 3.14121209e-02f,
  5.39807715e-02f, -1.11999556e-01f, -5.24236709e-02f, 1.38581648e-01f, 2.68689524e-02f, 2.90985443e-02f, 1.39026763e-02f, -1.74182002e-02f, 4.99645546e-02f, -6.71035498e-02f,
  -6.15311079e-02f, -1.78168491e-01f, -8.04298595e-02f, 5.78838661e-02f, 2.28959043e-02f, -4.20624344e-03f, -5.69908544e-02f, -1.36735797e-01f, -6.96079507e-02f, -6.92178085e-02f,
  1.31498665e-01f, 2.06559282e-02f, 4.43750024e-02f, -8.45897421e-02f, 3.88184190e-02f, 7.73028354e-04f, -3.25051770e-02f, 7.74014369e-02f, 5.83700798e-02f, -1.21206185e-02f,
  -1.21331535e-01f, -1.11219965e-01f, 3.14915292e-02f, 2.19713107e-01f, -7.82990605e-02f, 2.24660009e-01f, -2.90311664e-01f, 1.00410327e-01f, 1.80079132e-01f, -1.71226293e-01f,
  2.34628648e-01f, -6.70596808e-02f, 1.21951103e-02f, 7.97754433e-03f, -3.09374034e-01f, 3.12390327e-01f, 1.08052082e-02f, -2.52779499e-02f, 2.21826226e-01f, -1.99387476e-01f,
  -1.71979874e-01f, -1.96798757e-01f, -6.31028414e-02f, -2.13710442e-01f, -6.98226094e-02f, 2.31266007e-01f, -4.53610672e-03f, 2.03147437e-02f, 1.50722206e-01f, 2.19886735e-01f,
  -1.07125789e-01f, -4.95902225e-02f, 2.97598802e-02f, -1.76080137e-01f, -5.26193604e-02f, -3.71883251e-02f, 1.25828326e-01f, 2.80919194e-01f, -3.45664024e-02f, -9.30989832e-02f,
  1.00174941e-01f, 5.56539036e-02f, -7.00406879e-02f, 1.40308917e-01f, -1.89057365e-01f, -2.40290482e-02f, 1.11668162e-01f, -3.28143314e-02f, 6.81537688e-02f, -2.02101901e-01f,
  -4.48883474e-02f, -5.41732535e-02f, -1.18489459e-01f, -7.72007406e-02f, 2.59793550e-01f, 1.08016163e-01f, -1.16586007e-01f, -7.10291490e-02f, 1.20816164e-01f, 6.51659667e-02f,
  9.69656110e-02f, -2.77274568e-02f, 7.32246488e-02f, 7.32990280e-02f, 5.76437116e-02f, -1.08407803e-01f, -6.25785142e-02f, 9.17751808e-03f, 1.62777696e-02f, 1.83865443e-01f,
  7.15434402e-02f, 1.81669757e-01f, 2.42275983e-01f, -1.57386772e-02f, 3.23488712e-01f, 8.79343320e-03f, 5.01149595e-02f, -2.52084672e-01f, -1.27496377e-01f, 2.73262978e-01f,
  7.49657080e-02f, 6.78835735e-02f, -1.27277095e-02f, -1.96363754e-03f, -5.92088252e-02f, 4.23524855e-03f, 1.87057105e-03f, -2.19038770e-01f, 1.21659562e-02f, 2.18391880e-01f,
  -1.30245924e-01f, -1.93180904e-01f, 1.75948143e-01f, -2.70719826e-02f, 9.72229168e-02f, -1.74059439e-02f, -1.57068819e-01f, -2.22680226e-01f, -1.57569632e-01f, -5.12318946e-02f,
  1.27058446e-01f, 2.08085790e-01f, -2.97530115e-01f, -5.49067669e-02f, -2.32504047e-02f, -1.77974869e-02f, -4.16697422e-03f, -1.67416185e-01f, -1.28331576e-02f, -9.00362339e-03f,
  7.38176256e-02f, -5.71154477e-03f, 1.25175258e-02f, -8.44845250e-02f, 1.71745628e-01f, -4.90999930e-02f, -7.16239959e-03f, -1.81039453e-01f, 7.85752609e-02f, 1.28198788e-01f,
  2.88890712e-02f, -4.17624600e-02f, -1.81667149e-01f, -1.94882974e-01f, -8.36066455e-02f, -2.30931882e-02f, -5.07700182e-02f, -1.76690683e-01f, 5.66254742e-02f, 6.83783591e-02f,
  1.51897311e-01f, 1.01552248e-01f, -9.21162292e-02f, 8.15799087e-02f, -2.89861202e-01f, -2.29027301e-01f, 7.11180270e-02f, -1.61749139e-01f, 1.43862709e-01f, -1.98793858e-01f,
  -1.52525976e-01f, 1.55869260e-01f, 9.96518657e-02f, 1.29452422e-02f, -1.82905152e-01f, 1.12233922e-01f, 3.65076452e-01f, -1.01418048e-02f, 7.79776499e-02f, -2.03654617e-01f,
  2.09555447e-01f, -5.46071641e-02f, -3.89588892e-01f, 1.04003750e-01f, 2.24443853e-01f, 8.32973644e-02f, 5.56577146e-02f, 1.18796639e-01f, -2.01443747e-01f, 2.57635582e-02f,
  3.71092418e-03f, -5.59957661e-02f, -6.83465824e-02f, -7.85013065e-02f, 2.44601872e-02f, 2.83279985e-01f, 2.33983859e-01f, 1.99331231e-02f, -8.28597844e-02f, -9.92072225e-02f,
  8.48724768e-02f, -1.89100146e-01f, -1.03243448e-01f, -3.90319675e-02f, -4.08076756e-02f, -2.64547002e-02f, -6.85724020e-02f, -5.15815504e-02f, -4.55891117e-02f, 1.25205070e-01f,
  -3.04981451e-02f, -4.50208643e-03f, -1.12244703e-01f, -2.12925836e-03f, 1.11154445e-01f, 4.66143526e-03f, -2.02411413e-01f, -1.11067064e-01f, 2.33247876e-02f, -1.07272297e-01f,
  -6.82212114e-02f, -2.03961417e-01f, 2.72223428e-02f, -1.79594662e-02f, -1.36413621e-02f, -1.13442309e-01f, 3.05792671e-02f, 7.11248741e-02f, -6.72782063e-02f, -8.44210386e-02f,
  -8.79944712e-02f, -1.05345115e-01f, -1.25000566e-01f, 7.35004172e-02f, -7.71370833e-04f, 1.19882815e-01f, 2.50657629e-02f, 1.75028190e-01f, 6.27052039e-02f, -1.21066093e-01f,
  1.10657766e-01f, -1.17631346e-01f, -5.17252497e-02f, 1.31910756e-01f, -1.83812603e-01f, 1.65402904e-01f, 3.81096117e-02f, 3.80364545e-02f, -1.36017101e-02f, -2.91259047e-02f,
  -1.48164138e-01f, -9.42650363e-02f, -6.07357100e-02f, 6.55677021e-02f, 1.31096825e-01f, 1.02114193e-01f, 2.09562462e-02f, 1.32335410e-01f, 2.51234025e-02f, 7.32141137e-02f,
  1.67853668e-01f, -1.46432286e-02f, 1.63516060e-01f, 1.01155862e-02f, -4.06731442e-02f, -1.98139232e-02f, -4.91688587e-02f, 2.14279629e-02f, -1.09781817e-01f, -5.35972007e-02f,
  2.97995973e-02f, 2.98102759e-03f, -9.87254754e-02f, 6.68882877e-02f, -2.13841237e-02f, -4.05684710e-02f, 4.79424894e-02f, 8.92134979e-02f, 1.52304024e-02f, -1.01119258e-01f,
  9.66856405e-02f, -5.13260290e-02f, -3.70718166e-02f, 4.67938446e-02f, 4.15677577e-02f, -1.32963866e-01f, 1.05157323e-01f, 3.08234096e-02f, -3.31032902e-01f, 1.08061917e-02f,
  -8.46047997e-02f, 9.18136910e-02f, -7.89742172e-02f, 5.73428869e-02f, 1.48690507e-01f, 1.32782921e-01f, 4.13429476e-02f, 2.09531292e-01f, -8.51527601e-02f, 7.58064389e-02f,
  1.35779589e-01f, 1.01782106e-01f, -1.62475154e-01f, -1.19886711e-01f, -2.38211170e-01f, -2.52270848e-01f, 5.76817896e-03f, 3.60029563e-02f, -2.81030059e-01f, 1.36962280e-01f,
  2.50472844e-01f, -1.31517455e-01f, 1.08935513e-01f, -2.09164545e-02f, -4.74104546e-02f, 7.88443089e-02f, -2.13173069e-02f, -5.20292409e-02f, -8.12026486e-02f, 1.88244209e-01f,
  3.99240702e-02f, -4.41066734e-02f, -7.14566484e-02f, -4.29432616e-02f, -6.45604879e-02f, -7.53512159e-02f, 1.00282490e-01f, 8.93769786e-02f, 1.63800359e-01f, -6.83597624e-02f,
  3.16199325e-02f, -2.55540878e-01f, -9.07468349e-02f, 1.39309242e-01f, -2.43180003e-02f, 1.28103700e-03f, -6.32571802e-02f, -7.93278441e-02f, 1.54934349e-02f, -6.77446052e-02f,
  1.30704507e-01f, -4.92790751e-02f, -8.32181051e-02f, -5.42210750e-02f, -1.12723388e-01f, 7.45655671e-02f, 6.36426434e-02f, 7.49714747e-02f, -4.09423076e-02f, -1.10355109e-01f,
  7.48313442e-02f, -2.37552688e-01f, -3.39471847e-01f, -6.00550734e-02f, -1.61244199e-01f, 1.16874583e-01f, 4.50680256e-02f, 1.84065863e-01f, 9.68180671e-02f, -2.69794930e-02f,
  -1.06056422e-01f, -1.63245909e-02f, -1.92665365e-02f, 1.63627356e-01f, -9.96874347e-02f, 2.29763642e-01f, -7.45325759e-02f, 4.20900583e-02f, -5.70556731e-04f, -2.67140776e-01f,
  -1.02165259e-01f, -9.14195552e-03f, -3.24833840e-01f, 5.84686510e-02f, 3.03002387e-01f, 2.42672458e-01f, 1.56862177e-02f, 5.68209514e-02f, -9.63347033e-02f, 1.06690980e-01f,
  1.94697961e-01f, -8.31883177e-02f, 2.65964810e-02f, -1.28389895e-01f, -4.61373776e-02f, 1.04961395e-01f, 2.07715929e-02f, -4.72197920e-04f, -2.51174629e-01f, -1.64570063e-01f,
  -2.58721248e-03f, -1.13296092e-01f, -9.02421400e-02f, 8.48504156e-02f, 1.68673649e-01f, 4.26284149e-02f, 1.88292786e-02f, -1.52399242e-01f, -3.29281658e-01f, 8.34708363e-02f,
  1.98682658e-02f, 4.15094048e-02f, 1.11258142e-01f, 2.78972406e-02f, 7.76269883e-02f, 8.90891850e-02f, -5.17885089e-02f, -2.64038835e-02f, -1.36357263e-01f, -1.10063180e-01f,
  8.81682634e-02f, 1.61324501e-01f, 7.29431631e-03f, -3.52751091e-02f, -4.10081595e-02f, 3.04501563e-01f, 7.76913166e-02f, 7.25008771e-02f, 6.73124939e-02f, -1.47616684e-01f,
  2.09452555e-01f, -2.73964014e-02f, 2.10877359e-01f, -9.41319391e-02f, -1.14218861e-01f, 1.37782633e-01f, 1.66362345e-01f, -8.65682140e-02f, 1.89064726e-01f, 2.99040794e-01f,
  -8.57109874e-02f, -5.14331423e-02f, -2.24850833e-01f, -2.27825288e-02f, -2.06449181e-01f, 3.09707075e-02f, -1.80051737e-02f, -5.05392291e-02f, 1.84749693e-01f, 2.11472169e-01f,
  1.12543823e-02f, 6.39886782e-02f, 4.05684412e-02f, 2.16883585e-01f, -5.11907302e-02f, 1.52809232e-01f, 7.56921619e-02f, -1.41567543e-01f, -9.14176330e-02f, 5.36409579e-02f,
  2.06075177e-01f, -5.27579784e-02f, -2.25682348e-01f, 1.02447435e-01f, 5.18025607e-02f, 1.68410063e-01f, -3.50899734e-02f, 8.40989221e-03f, 3.49485576e-02f, -7.66329467e-02f,
  1.40618652e-01f, 7.54329562e-02f, 7.38533512e-02f, -1.06701322e-01f, 6.71043098e-02f, -4.57910262e-02f, -1.14910901e-01f, -8.06991234e-02f, 1.00569494e-01f, 7.85392001e-02f,
  -1.30785421e-01f, -1.35939166e-01f, -1.48740977e-01f, -1.17519777e-02f, 1.84809102e-03f, -9.46589634e-02f, -9.88346338e-02f, 1.65378630e-01f, -8.00989866e-02f, -2.85103440e-01f,
  8.06874633e-02f, 1.25286877e-01f, -7.53063038e-02f, 2.44693056e-01f, -3.66070151e-01f, -5.82137741e-02f, 1.16709426e-01f, -2.88150817e-01f, 2.46602565e-01f, -1.36352122e-01f,
  -1.66747674e-01f, -5.53695746e-02f, -1.72299549e-01f, -4.19893814e-03f, -1.37676924e-01f, 4.16363701e-02f, 8.96987319e-02f, -2.08101585e-03f, -1.42246082e-01f, -1.53362870e-01f,
  4.85836305e-02f, -1.07025795e-01f, -5.21030612e-02f, 1.86268330e-01f, 7.33368145e-03f, -6.41109571e-02f, 5.10644093e-02f, 1.78075865e-01f, -2.27150738e-01f, 1.51904775e-02f,
  -3.99192423e-02f, -2.48750508e-01f, -1.68341592e-01f, -1.89023659e-01f, 1.57576397e-01f, 2.70264477e-01f, -1.40533432e-01f, -7.09181949e-02f, 7.83124268e-02f, 1.06679007e-01f,
  -2.11939402e-02f, 3.73592898e-02f, -2.05085471e-01f, 1.33476751e-02f, 2.59631127e-03f, -9.25527699e-03f, 7.70714283e-02f, 5.05694672e-02f, 9.54042003e-02f, -1.41823734e-03f,
  -4.18419950e-02f, -9.80637893e-02f, 1.29604200e-02f, 1.45334974e-02f, -6.40009195e-02f, 5.51925600e-02f, 6.81790337e-03f, -6.77303178e-03f, -6.18927479e-02f, 4.97004651e-02f,
  1.62044927e-01f, -9.77350995e-02f, -3.29167210e-02f, -2.31308714e-01f, -1.68784916e-01f, -1.34209752e-01f, -1.15013674e-01f, -8.12104046e-02f, -2.90006310e-01f, 3.84076312e-02f,
  -4.27922569e-02f, -1.09649457e-01f, -1.00985162e-01f, 5.25676385e-02f, -3.86036783e-01f, 2.89623111e-01f, 9.17525515e-02f, 4.56774831e-02f, -3.00524563e-01f, 1.99037194e-02f,
  -1.21702582e-01f, -1.61108851e-01f, -3.33385286e-03f, 1.86545089e-01f, -1.37310535e-01f, 2.21899495e-01f, 2.99302101e-01f, 3.25382425e-04f, -7.76919052e-02f, 1.19435020e-01f,
  -1.16131805e-01f, 2.41379198e-02f, 8.92957002e-02f, -4.80017334e-04f, -5.02460077e-02f, 1.34246179e-03f, -5.64001948e-02f, 1.72464639e-01f, -6.50511831e-02f, 1.49180070e-02f,
  -1.19296476e-01f, -2.48364974e-02f, -5.53286076e-02f, -5.28002717e-02f, -1.90310068e-02f, -1.53929785e-01f, -2.01498702e-01f, -1.22725144e-01f, 5.46343587e-02f, -1.89440787e-01f,
  -9.12662894e-02f, 7.42757600e-03f, -5.37521467e-02f, -6.89546391e-02f, -8.73146057e-02f, -2.92494567e-03f, -9.70022604e-02f, -1.64310113e-01f, -1.25600412e-01f, -1.90418333e-01f,
  1.08551390e-01f, -4.22297232e-02f, -5.04597463e-02f, -7.01925457e-02f, 1.55454432e-03f, -1.16803527e-01f, -7.47334659e-02f, -1.27776623e-01f, -1.47684917e-01f, 1.19295873e-01f,
  -1.23079956e-01f, 1.88009471e-01f, -1.53719252e-02f, -1.52655110e-01f, -7.69189093e-03f, -5.52932248e-02f, 1.87094688e-01f, 2.42411166e-01f, 1.38156980e-01f, -1.97074004e-02f,
  -2.20463201e-01f, 5.15153185e-02f, 1.59120455e-01f, -7.11580068e-02f, -9.13595334e-02f, -1.97291613e-01f, -8.61154944e-02f, 2.67940968e-01f, -3.10795903e-01f, -5.02700359e-02f,
  2.28228509e-01f, -1.60619933e-02f, -1.72306493e-01f, -9.57580581e-02f, -8.97402912e-02f, 1.33225741e-02f, 3.03224958e-02f, 3.99137251e-02f, -5.88365272e-02f, 2.47993439e-01f,
  -1.88594032e-02f, -8.98407102e-02f, 1.39580399e-01f, -1.48512304e-01f, 1.43973306e-01f, 8.60892609e-02f, -1.03000499e-01f, 2.05565454e-03f, -4.60298322e-02f, -3.85897681e-02f,
  -1.99849550e-02f, -3.11322566e-02f, 7.35605434e-02f, 1.05454437e-01f, -8.56324099e-03f, -1.31868526e-01f, 1.82271495e-01f, 7.13645071e-02f, 7.51067176e-02f, -2.14465201e-01f,
  -7.87685364e-02f, -2.21753567e-02f, -1.25911161e-01f, 1.38794139e-01f, -1.81461006e-01f, -1.28266230e-01f, 7.14700297e-02f, -1.89166546e-01f, -1.14024349e-01f, -5.56181595e-02f,
  -1.37528613e-01f, 2.19007254e-01f, 2.00949788e-01f, -7.42610693e-02f, -2.62814701e-01f, -2.43912175e-01f, -1.02675848e-01f, 2.98818462e-02f, 9.02713165e-02f, -7.53897205e-02f,
  -1.14606649e-01f, 4.80795987e-02f, -4.10118736e-02f, 2.55939960e-01f, 1.80683032e-01f, 1.30445570e-01f, -2.84582645e-01f, 1.45780623e-01f, 2.95490265e-01f, -1.82336774e-02f,
  5.41610904e-02f, -1.17893992e-02f, 9.38501209e-02f, 8.45134482e-02f, 2.97082812e-02f, 3.52775574e-01f, 1.89726323e-01f, 5.20889685e-02f, -1.05869375e-01f, 2.29449421e-01f,
  1.63360462e-02f, 1.78719983e-02f, -1.18428007e-01f, -2.59273767e-01f, -2.10128315e-02f, 2.74539497e-02f, 1.35013714e-01f, 1.28593773e-01f, -6.12708218e-02f, -7.60051459e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.66228592e-01f, 2.52575845e-01f, 2.77280640e-02f, -6.58453396e-03f, 1.53226184e-03f, 2.20487386e-01f, -6.20240439e-03f, 3.42127122e-02f, 2.37938076e-01f, 1.17830951e-02f,
  3.05561032e-02f, 4.12406325e-02f, 1.31780013e-01f, 2.16784924e-01f, -7.44821280e-02f, -7.06999004e-02f, 1.95031315e-01f, -1.34798908e-03f, 1.69373378e-01f, 2.22463068e-02f,
  6.27283901e-02f, -2.99053248e-02f, -6.15581647e-02f, 1.99747160e-01f, 1.33971617e-01f, -6.23642057e-02f, 2.37832051e-02f, 8.88125524e-02f, 6.94933757e-02f, 1.34920195e-01f,
  -1.61382273e-01f, -4.87175845e-02f, -3.25421184e-01f, 3.21627468e-01f, -8.33869725e-02f, -3.55328462e-04f, -1.40944511e-01f, -2.58221235e-02f, -1.07037768e-01f, -3.39227319e-01f,
  2.35809926e-02f, -8.77401531e-02f, 1.77760553e-02f, 1.68159798e-01f, 2.77187914e-01f, 1.40853422e-02f, -6.95071667e-02f, 5.52823208e-02f, -1.12116173e-01f, -9.48434472e-02f,
  5.20534180e-02f, 2.07996503e-01f, 9.50032175e-02f, -6.61241785e-02f, -1.77721232e-01f, -7.87378624e-02f, -2.84479503e-02f, 3.62314314e-01f, 2.97398090e-01f, -9.90270637e-03f,
  -1.01337068e-01f, 5.17949648e-02f, 4.81014729e-01f, -1.62121445e-01f, 1.47987232e-01f, 1.53997064e-01f, 1.30186737e-01f, 1.12726897e-01f, 5.20676151e-02f, 6.65822476e-02f,
  2.65587717e-01f, 1.69290885e-01f, -5.05708046e-02f, -6.58424571e-02f, 1.28701687e-01f, 1.09783530e-01f, 3.68072949e-02f, 6.68306276e-02f, 1.43033266e-01f, 1.96823493e-01f,
  6.98819831e-02f, -9.42872278e-03f, 1.60366461e-01f, 5.32988645e-02f, -4.55104187e-02f, 3.14048454e-02f, 9.44005847e-02f, 3.97542818e-03f, 6.99660704e-02f, 1.49931073e-01f,
  -6.51280805e-02f, 8.59088078e-02f, -3.88032421e-02f, 1.93368316e-01f, -2.23331764e-01f, 1.68537259e-01f, 3.25595349e-01f, -2.62205899e-01f, 1.00244850e-01f, 2.23468259e-01f,
  1.49045408e-01f, -7.61771873e-02f, -1.53043186e-02f, 2.87058800e-01f, -8.09755623e-02f, -2.27539718e-01f, 8.63893628e-02f, -1.67547017e-01f, -1.19025029e-01f, 3.78367640e-02f,
  -1.44038886e-01f, -8.17360356e-02f, 2.62499526e-02f, 1.06649421e-01f, -2.71208715e-02f, -1.43380985e-01f, 1.06395178e-01f, 2.07448661e-01f, -1.19192399e-01f, 3.42986248e-02f,
  1.59063369e-01f, -1.62611365e-01f, -3.20429094e-02f, -8.79012272e-02f, 1.69013605e-01f, 1.21961303e-01f, -1.36755213e-01f, 1.45700783e-01f, 1.07097559e-01f, 5.43313771e-02f,
  -1.89468861e-02f, -3.55500579e-02f, 5.72142715e-04f, 6.62574545e-04f, 5.59583195e-02f, 9.04949978e-02f, -1.38146847e-01f, -1.74123608e-02f, 1.54188396e-02f, 1.10213555e-01f,
  1.31612808e-01f, 4.11048234e-02f, -1.45692050e-01f, 3.01703643e-02f, 6.03133924e-02f, -5.78930639e-02f, 2.49304194e-02f, -1.47937715e-01f, 3.82133722e-02f, 1.13012590e-01f,
  1.01630082e-02f, 8.82892609e-02f, -4.59438227e-02f, 1.07482605e-01f, -5.69211133e-02f, 8.90202224e-02f, 4.97426428e-02f, -6.53140470e-02f, -2.96871573e-01f, 3.49929966e-02f,
  1.17650554e-01f, 1.84569471e-02f, 7.75136426e-02f, -1.66953266e-01f, -1.63184509e-01f, 5.27914725e-02f, 1.03658929e-01f, -1.44766420e-01f, -1.87349305e-01f, 1.64317861e-01f,
  7.72560760e-02f, 1.02228150e-01f, 3.17908637e-02f, -9.66977179e-02f, 4.72151004e-02f, -1.26397505e-01f, -1.28188491e-01f, 1.42064601e-01f, 1.47039130e-01f, 5.78700081e-02f,
  1.86405241e-01f, 5.67736775e-02f, -1.68857649e-01f, 1.03809983e-01f, -3.31202261e-02f, 5.37723769e-03f, 8.29230323e-02f, -1.21569321e-01f, 3.63416411e-02f, -4.12895679e-02f,
  1.47107095e-01f, -1.30962618e-02f, -1.44614756e-01f, 1.37192205e-01f, -8.12400356e-02f, -3.99251916e-02f, 1.42991439e-01f, -4.54959497e-02f, 1.15514979e-01f, 4.29185666e-02f,
  -8.09172243e-02f, 6.51682988e-02f, 1.45524129e-01f, -8.26941244e-03f, 1.37052342e-01f, -1.10502541e-02f, 1.89740956e-02f, -1.79551598e-02f, -2.32779365e-02f, -5.73944785e-02f,
  1.75167210e-02f, -1.71295647e-02f, 5.03402837e-02f, -4.43157814e-02f, -8.28893781e-02f, 1.34823201e-02f, -5.20291254e-02f, -4.08282243e-02f, 1.25577554e-01f, -1.24680728e-01f,
  -1.53422013e-01f, 2.71198079e-02f, -2.18228921e-02f, 1.42395683e-02f, -2.77575385e-02f, 6.94508180e-02f, -3.09754051e-02f, 1.24953523e-01f, 2.45663766e-02f, 1.76412493e-01f,
  -5.33461757e-02f, 1.46728739e-01f, -5.71066998e-02f, -9.96275630e-05f, -9.40087996e-03f, 9.45908651e-02f, 2.96749361e-02f, 6.03212416e-02f, -1.04747042e-01f, 9.66836959e-02f,
  -1.08670965e-01f, -7.14890212e-02f, -6.02714196e-02f, -5.44018261e-02f, -4.93429191e-02f, -4.99907881e-02f, -1.03974022e-01f, 2.11455241e-01f, -2.36782767e-02f, 2.66449694e-02f,
  -2.19211522e-02f, 1.22277528e-01f, -7.71775097e-02f, -8.69745091e-02f, -6.55623078e-02f, -7.44549111e-02f, -9.90054011e-03f, 1.36227190e-01f, 5.78188263e-02f, -1.43735146e-03f,
  1.17402062e-01f, -1.43407822e-01f, -3.85895520e-02f, 3.93330343e-02f, -7.04935592e-05f, -5.89715578e-02f, 1.56124815e-01f, 2.31759413e-03f, 1.55185491e-01f, -4.96541411e-02f,
  3.35458629e-02f, -1.46048414e-02f, 8.09758529e-02f, 2.71590613e-03f, 1.34749532e-01f, 1.55458674e-01f, 5.11122234e-02f, 6.02725595e-02f, 9.04780701e-02f, 1.72382504e-01f,
  8.87707919e-02f, -6.81425631e-03f, -4.58884686e-02f, -1.68574005e-01f, -8.85920301e-02f, 4.89696376e-02f, 2.58566856e-01f, 1.02429956e-01f, -5.56270359e-03f, 1.44510567e-01f,
  3.50453779e-02f, 9.55790654e-02f, 3.42432261e-01f, 9.13899094e-02f, -8.61151740e-02f, -4.49954020e-03f, 2.34293610e-01f, 1.93370860e-02f, -1.30524278e-01f, 7.71744251e-02f,
  -1.89601049e-01f, -1.08298175e-01f, -1.81349106e-02f, -1.11029677e-01f, 2.03318149e-03f, 1.13600671e-01f, -1.22814827e-01f, -1.00071974e-01f, 4.98120487e-02f, 4.75356393e-02f,
  2.19081298e-01f, 5.40970899e-02f, -5.47084622e-02f, -7.15636015e-02f, -1.05021156e-01f, 3.74166556e-02f, -1.19686976e-01f, -7.99106285e-02f, 3.62196341e-02f, 7.80101717e-02f,
  -3.21343765e-02f, 5.05407341e-02f, 1.76269993e-01f, 3.90662299e-03f, 6.77230731e-02f, -2.85043679e-02f, 2.11966664e-01f, -7.76744261e-03f, -3.09230927e-02f, -7.26710185e-02f,
  1.93217546e-01f, 2.01497879e-02f, 2.16290146e-01f, -5.33076338e-02f, -4.25432250e-02f, 1.86448008e-01f, 3.02096121e-02f, 1.18365347e-01f, -2.86866594e-02f, 8.87824595e-03f,
  9.01236758e-02f, -7.89392143e-02f, 2.04706624e-01f, 7.94294104e-02f, 4.38582599e-02f, 1.93667918e-01f, 1.82061747e-01f, -3.01976711e-01f, -7.00628012e-02f, -1.42263353e-01f,
  1.82914779e-01f, 8.93606097e-02f, 7.89581239e-03f, 8.48239660e-02f, -2.46078089e-01f, -1.19374506e-01f, 1.84489876e-01f, 2.61307150e-01f, -6.06960580e-02f, 4.25370075e-02f,
  -1.69570446e-01f, 2.49948695e-01f, 2.18998909e-01f, 9.72669497e-02f, -1.51926726e-01f, 1.31979212e-01f, -4.31940332e-02f, -5.81485219e-02f, -1.48769412e-02f, 1.31489888e-01f,
  4.63666208e-03f, -1.51758948e-02f, -1.00909442e-01f, 2.36623675e-01f, 7.78766423e-02f, 2.79315144e-01f, 3.95241603e-02f, -1.67888373e-01f, -6.93497807e-02f, 9.22973678e-02f,
  1.43982680e-03f, 5.87132154e-03f, -7.13883862e-02f, -9.21541676e-02f, 2.76693374e-01f, 1.76149413e-01f, 2.81340978e-03f, 3.23947996e-01f, -2.13727029e-03f, 1.90168753e-01f,
  1.22023299e-02f, 1.39180124e-01f, 1.35096714e-01f, -8.49654805e-03f, 8.27708095e-03f, 6.93436190e-02f, -8.16960707e-02f, 2.59641230e-01f, 2.47410554e-02f, 1.54949188e-01f,
  8.30417573e-02f, 5.51088788e-02f, 2.76467979e-01f, 2.62789309e-01f, -8.46763253e-02f, 5.84503449e-02f, 1.55712679e-01f, 2.09125817e-01f, 5.14935330e-03f, 3.04787653e-03f,
  -1.64232582e-01f, 1.30305767e-01f, 1.66910306e-01f, 2.17976406e-01f, -1.29918203e-01f, -5.50662279e-02f, 3.43493134e-01f, -9.61369798e-02f, 2.63019681e-01f, 2.29482889e-01f,
  -2.73770362e-01f, -4.16429728e-01f, 9.32876468e-02f, 1.36506632e-01f, 2.07953051e-01f, -9.38252807e-02f, -2.31821150e-01f, -1.59218192e-01f, -1.06324725e-01f, 1.24903888e-01f,
  6.57207295e-02f, -1.84333533e-01f, 1.48552537e-01f, -1.27975628e-01f, 7.84235969e-02f, 9.41280834e-03f, 4.51751873e-02f, 5.72120957e-02f, 1.61342192e-02f, -5.17937206e-02f,
  -7.50629464e-03f, 1.70349941e-01f, -5.30335121e-02f, 5.92995472e-02f, 1.31517619e-01f, -2.49200314e-02f, -4.32419963e-02f, 9.97496471e-02f, -3.54873314e-02f, -1.02370799e-01f,
  1.09979801e-01f, -4.94223051e-02f, -8.96111950e-02f, 1.13853484e-01f, 1.33833447e-02f, -7.85471499e-02f, 9.69358087e-02f, -1.05450146e-01f, -7.75770545e-02f, -1.07200285e-02f,
  -1.14026539e-01f, 9.84056965e-02f, -1.11481428e-01f, -1.08299531e-01f, 1.26482844e-01f, 8.28905180e-02f, -8.02311227e-02f, 1.03482306e-02f, -3.58526818e-02f, -1.11852162e-01f,
  -8.15019384e-03f, 1.56478677e-02f, -6.91960305e-02f, 6.64718077e-02f, 9.82203037e-02f, -2.31887084e-02f, 1.65546462e-02f, -1.24818712e-01f, 1.89591292e-03f, 4.05588225e-02f,
  -2.97500715e-02f, -8.00980255e-02f, 3.91326174e-02f, -8.11675936e-02f, 6.70219958e-02f, -7.58289322e-02f, 1.50790373e-02f, -1.25624463e-02f, -8.86668637e-02f, 7.97686353e-02f,
  -8.93698931e-02f, -7.89396539e-02f, 7.35250488e-02f, 1.28382572e-03f, -2.25164350e-02f, 7.94896036e-02f, -9.01940167e-02f, -8.71519744e-02f, -1.03333868e-01f, -8.74759979e-04f,
  9.13602393e-03f, 5.65222651e-02f, -9.68899578e-02f, 1.09108143e-01f, 5.57720810e-02f, 2.48870086e-02f, -1.22160755e-01f, 1.26637265e-01f, -9.48892087e-02f, -4.85133156e-02f,
  -5.92774525e-02f, -6.93433639e-03f, 2.86066644e-02f, -1.27659962e-01f, 2.96102297e-02f, 4.42897752e-02f, 2.59608150e-01f, -1.55516341e-01f, -2.03171354e-02f, -2.19568387e-02f,
  -1.50321558e-01f, 9.67856646e-02f, 9.82560590e-02f, 1.13180906e-01f, 3.56068723e-02f, -7.83679783e-02f, -7.16094393e-03f, 1.02651507e-01f, -6.64448738e-02f, 9.88266915e-02f,
  -1.12981781e-01f, 8.28250870e-02f, -2.31563821e-02f, 6.86676893e-03f, 1.66698784e-01f, -1.63035795e-01f, 1.49275035e-01f, 3.80375120e-03f, 3.47820342e-01f, 3.72757390e-02f,
  7.39943385e-02f, -7.43549243e-02f, 1.77711993e-01f, 2.85234116e-02f, -2.43648976e-01f, 2.16504950e-02f, -2.03884810e-01f, -1.71882644e-01f, -8.11822654e-04f, 5.40056564e-02f,
  2.63938159e-02f, -1.53386533e-01f, 8.22308008e-03f, 1.39144689e-01f, 9.43555608e-02f, 1.62229717e-01f, 1.52726054e-01f, -2.42188931e-01f, 1.98292598e-01f, 1.06898628e-01f,
  -2.62093961e-01f, -3.90908197e-02f, 8.76369551e-02f, 2.05340713e-01f, -7.60558397e-02f, -1.18582197e-01f, 2.57853806e-01f, 1.13036253e-01f, -9.18234661e-02f, 4.03183885e-02f,
  6.54295981e-02f, 1.53661042e-01f, 1.56600785e-03f, 1.17984578e-01f, 3.01805615e-01f, -7.08913356e-02f, 7.56696984e-02f, 1.81863442e-01f, -2.19258089e-02f, 1.52323425e-01f,
  1.09913550e-01f, -1.13108099e-01f, -8.38319305e-03f, 3.57134491e-02f, -1.06134027e-01f, 3.78873236e-02f, 5.44195101e-02f, 2.81098206e-02f, 2.05462769e-01f, 1.40299693e-01f,
  4.90229391e-02f, 1.25447497e-01f, -3.84695455e-02f, 5.77679127e-02f, -7.11839721e-02f, 7.46992305e-02f, 2.33726110e-02f, -7.99786374e-02f, 1.52294785e-01f, 2.30448350e-01f,
  -2.48220060e-02f, -3.78672063e-01f, -4.29273359e-02f, 1.92347355e-02f, -6.47434965e-02f, 1.54582456e-01f, -4.23471570e-01f, -1.21135026e-01f, -4.96247113e-02f, 2.30477974e-02f,
  1.88078135e-01f, -2.51505047e-01f, -2.31671110e-01f, -3.65295522e-02f, -1.51446164e-01f, -3.96831073e-02f, -2.09484279e-01f, 6.34621531e-02f, 1.96959570e-01f, 3.13259140e-02f,
  5.79933934e-02f, -1.20967172e-01f, -2.96377931e-02f, 9.60450619e-03f, -4.49764058e-02f, 2.27242470e-01f, -7.47248679e-02f, -3.39382850e-02f, 1.89518079e-01f, -1.99809261e-02f,
  -7.47159636e-03f, 8.87484625e-02f, 1.89212952e-02f, -7.04364404e-02f, 1.07674584e-01f, -9.58065018e-02f, 1.12633780e-01f, 3.61988425e-01f, 5.54829687e-02f, 2.18268465e-02f,
  -6.34386390e-02f, 1.80217341e-01f, 1.80158660e-01f, 1.06652446e-01f, 1.58986598e-01f, 1.86211348e-01f, 1.07762098e-01f, 1.95356354e-01f, 1.52890801e-01f, 1.28460042e-02f,
  1.42840549e-01f, 3.55381742e-02f, 1.42145138e-02f, -1.70929343e-01f, -2.04519276e-02f, 1.34320706e-01f, 9.54958722e-02f, 1.58228502e-01f, -1.12249345e-01f, 1.69895098e-01f,
  9.19516310e-02f, 1.35107320e-02f, 4.14716117e-02f, -5.69046363e-02f, 1.07483506e-01f, 2.22366452e-01f, -1.12137692e-02f, -2.30460048e-01f, -2.85089642e-01f, 1.67030357e-02f,
  -2.16144100e-01f, 9.49918032e-02f, 8.25929716e-02f, 6.59936666e-02f, -9.73392725e-02f, 5.04747517e-02f, 7.94309527e-02f, 1.38247639e-01f, 2.09079936e-01f, 1.07091203e-01f,
  -3.39714676e-01f, -8.81223530e-02f, 6.58545122e-02f, -6.14355803e-02f, -4.14669700e-02f, -1.70953616e-01f, 1.17424494e-02f, 4.47657369e-02f, -5.49362563e-02f, 3.23083282e-01f,
  3.01960558e-01f, -3.51649895e-02f, -4.70032953e-02f, 3.11009258e-01f, -1.10045224e-01f, 1.21605933e-01f, -9.62880179e-02f, -2.44130358e-01f, -1.27537102e-01f, 8.24296251e-02f,
  3.51231582e-02f, 1.06026359e-01f, 1.99263301e-02f, -1.87525395e-02f, -2.37019937e-02f, 5.12931049e-02f, -4.66542467e-02f, 4.33430485e-02f, 9.10746828e-02f, -3.92693505e-02f,
  1.10535480e-01f, 1.36501089e-01f, 5.89917414e-02f, 6.89912587e-02f, -1.19453467e-01f, -4.05512936e-02f, 7.41665885e-02f, 1.24107845e-01f, 1.05016693e-01f, -1.28648132e-01f,
  -3.00631970e-02f, 7.24672824e-02f, 2.07649078e-02f, 6.16333727e-03f, 1.43370226e-01f, 3.77394259e-02f, 1.57273009e-01f, 1.17804408e-01f, 1.45179391e-01f, -4.00640398e-01f,
  -1.33127928e-01f, 3.78810801e-02f, -5.97344600e-02f, 2.22294733e-01f, 4.55280114e-03f, 5.03876545e-02f, -2.34612882e-01f, 5.60712069e-02f, -5.54062799e-02f, -3.15850973e-02f,
  -1.12177776e-02f, 1.13907628e-01f, -2.86630243e-01f, 2.36420333e-02f, 9.23848152e-02f, 1.31303081e-02f, 1.06857300e-01f, -1.69234723e-02f, 1.77992970e-01f, 5.42071946e-02f,
  2.74590217e-02f, -7.27671459e-02f, 1.02308668e-01f, -4.00535949e-02f, -3.97790186e-02f, -2.68516038e-02f, 1.02737837e-01f, -1.54553980e-01f, 1.29259646e-01f, -2.11205203e-02f,
  1.10309385e-01f, 1.85194984e-01f, -1.25592970e-03f, 2.47381479e-02f, -1.02844045e-01f, -3.15910242e-02f, 1.09386846e-01f, -1.35953622e-02f, -4.13202532e-02f, 7.52270073e-02f,
  1.23508401e-01f, 1.28661901e-01f, 3.49483974e-02f, 5.92249855e-02f, -7.38372654e-02f, 3.65281291e-02f, 1.41064795e-02f, 5.79976626e-02f, -1.23436697e-01f, 1.72641978e-01f,
  1.28512561e-01f, 7.51988366e-02f, -2.05835365e-02f, -5.39799929e-02f, -9.35007483e-02f, 1.02371305e-01f, 1.20003127e-01f, 2.52640285e-02f, 8.57881084e-02f, -6.62883446e-02f,
  1.03119463e-01f, 1.28325939e-01f, 2.02183232e-01f, -1.32771924e-01f, 1.08135775e-01f, 1.70135945e-01f, 1.93045028e-02f, -4.08524610e-02f, -1.49183199e-01f, -1.73645347e-01f,
  -6.11637346e-02f, 3.34725603e-02f, -4.91191857e-02f, -2.59255499e-01f, -1.08041517e-01f, -9.86261442e-02f, 6.60515279e-02f, -1.94888577e-01f, 9.46152136e-02f, 3.76542704e-03f,
  1.48484800e-02f, 2.46644706e-01f, -3.35314982e-02f, -1.13674209e-01f, 2.94463873e-01f, -3.07438374e-02f, -2.34366402e-01f, -1.46914586e-01f, 5.76109327e-02f, -6.64096028e-02f,
  4.92446460e-02f, -1.33181959e-01f, 1.37472406e-01f, -6.30477583e-03f, -4.07822393e-02f, 1.62043795e-01f, 3.35807763e-02f, 5.32050170e-02f, -1.06277473e-01f, 2.49036998e-01f,
  3.86095829e-02f, 6.21096119e-02f, 1.61180273e-01f, 2.95277555e-02f, -2.07986441e-02f, -6.64112493e-02f, -3.05515584e-02f, 2.07143635e-01f, -6.42326027e-02f, 2.30930448e-01f,
  -3.56782824e-02f, 1.57728389e-01f, 1.56635821e-01f, 5.32654449e-02f, -5.64750135e-02f, 2.08206382e-02f, 1.40024498e-01f, 8.44100937e-02f, 1.54904708e-01f, 1.77625105e-01f,
  -1.56099141e-01f, 1.70316294e-01f, 1.80972323e-01f, -1.54194206e-01f, 1.90079495e-01f, 5.07516274e-03f, 1.02736145e-01f, 5.21844588e-02f, -1.78359032e-01f, -1.98470235e-01f,
  -6.25459775e-02f, -1.16796400e-02f, -1.90571785e-01f, 4.34476882e-02f, 8.19149464e-02f, 6.98721558e-02f, -2.13650897e-01f, -7.74658024e-02f, -3.03169578e-01f, 1.24589927e-01f,
  2.99627393e-01f, -3.69649865e-02f, -3.15940261e-01f, -1.04413219e-01f, 5.19554690e-02f, -2.00954527e-01f, 2.52940357e-01f, 7.66674057e-02f, -1.37023896e-01f, 2.32613102e-01f,
  2.90518068e-02f, 1.26090199e-01f, 2.58445203e-01f, 2.84579564e-02f, -1.55694023e-01f, -3.45539413e-02f, 1.26094431e-01f, -2.07727905e-02f, -1.13907039e-01f, -7.37492517e-02f,
  7.92494491e-02f, 1.93119735e-01f, -1.89665277e-02f, -4.51369630e-03f, -3.34358625e-02f, 3.66058350e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.74022261e-02f, 2.34447077e-01f, 1.25778005e-01f, 1.43632114e-01f, 1.18745983e-01f, 7.63826147e-02f, 1.31726474e-01f, 7.86502808e-02f, 1.65738568e-01f, -2.19174288e-03f,
  1.52419254e-01f, 6.12768903e-02f, 2.83640400e-02f, 1.00250162e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  1.12043172e-01f, -1.22151494e-01f, -5.73949106e-02f, 1.17397554e-01f, -2.17410967e-01f, -2.86238045e-01f, 7.37194642e-02f, 2.49837060e-03f, -4.81497616e-01f, 4.06265184e-02f,
  -2.47178301e-01f, -5.58913350e-01f, -2.59565234e-01f, 5.09607494e-02f, -2.16605842e-01f, -5.86326778e-01f, 8.12571049e-02f, 6.92885602e-04f, 6.19904324e-03f, -2.64544815e-01f,
  1.88863307e-01f, -4.26889092e-01f, -2.04791889e-01f, 1.13399059e-01f, -3.67039517e-02f, 7.20372796e-02f, -3.21263552e-01f, -2.47891665e-01f, 7.15033412e-02f, -1.39799610e-01f,
  -1.51084840e-01f, -9.66851041e-02f, 2.71372616e-01f, 2.61211693e-01f, -2.23411232e-01f, 3.65430087e-01f, -1.40033722e-01f, 1.52034312e-01f, 2.04781786e-01f, -1.81307286e-01f,
  2.67443359e-02f, 2.70028651e-01f, 2.34316692e-01f, -4.80618700e-02f, -9.46457013e-02f, -2.12011471e-01f, -3.86522226e-02f, -1.86085045e-01f, 3.46535072e-02f, -1.57681897e-01f,
  4.20261830e-01f, -1.90193489e-01f, 1.10440180e-02f, 7.71035925e-02f, -6.68666363e-02f, -8.17879960e-02f, -4.34608579e-01f, 3.88753824e-02f, 5.90239286e-01f, -2.85335332e-01f,
  -2.30167240e-01f, -1.14386037e-01f, 2.11470544e-01f, 3.02764028e-02f, 1.43768549e-01f, 3.33083332e-01f, 1.05039209e-01f, 1.36090100e-01f, 2.16234103e-01f, -7.83300549e-02f,
  1.81760475e-01f, 2.92750541e-02f, 1.10565290e-01f, 4.74985212e-01f, 2.86973894e-01f, -3.47172737e-01f, -2.55561173e-01f, 2.99816765e-02f, -3.62835862e-02f, 1.53987944e-01f,
  2.86529899e-01f, -7.33035663e-03f, -1.82732902e-02f, 1.32162049e-01f, 1.02831339e-02f, 4.68085445e-02f, 1.59026593e-01f, -1.23631448e-01f, 2.67776668e-01f, -6.00662604e-02f,
  -4.57801312e-01f, -1.86645240e-01f, -3.38724852e-01f, -1.97622567e-01f, 2.75433868e-01f, 2.15560570e-01f, -3.23433965e-01f, 5.70716023e-01f, 2.23293435e-02f, -1.84183151e-01f,
  2.56927181e-02f, -9.93312299e-02f, -1.43360734e-01f, -2.97414601e-01f, -3.97241443e-01f, 8.98517668e-02f, -2.36113556e-02f, -2.89199620e-01f, -3.36911619e-01f, 4.48036939e-01f,
  -2.43900910e-01f, -1.09129719e-01f, 1.35920309e-02f, 5.78002572e-01f, -3.30777287e-01f, -7.32543990e-02f, 2.93593039e-03f, 2.89353609e-01f, 1.46085486e-01f, 6.78698778e-01f,
  -5.33634186e-01f, 1.39525920e-01f, 2.09178329e-01f, -3.28167081e-01f, 2.75372505e-01f, -2.45366961e-01f, -1.31925598e-01f, -1.42823989e-02f, 8.18146244e-02f, 2.07967609e-01f,
  1.17461853e-01f, 3.67369920e-01f, -1.67216420e-01f, 2.60089993e-01f, 1.66092053e-01f, -2.16947004e-01f, 1.41685739e-01f, 2.93591321e-02f, -2.31898874e-01f, 1.35751337e-01f,
  -1.47000998e-01f, 8.27987343e-02f, 3.66379261e-01f, -7.86493346e-02f, 1.88625425e-01f, -1.77839816e-01f, 3.03225238e-02f, -1.38547355e-02f, 2.43657619e-01f, 3.21759343e-01f,
  -2.50262111e-01f, 1.53089380e-02f, -2.08338216e-01f, -4.38370138e-01f, 5.01508191e-02f, -2.33773887e-01f, -1.20363139e-01f, -3.46232384e-01f, -2.34063286e-02f, 2.15951577e-01f,
  5.20737886e-01f, -5.87474220e-02f, -3.66572648e-01f, -2.48048469e-01f, -2.42961466e-01f, 1.52834088e-01f, 2.12509409e-01f, 2.20932171e-01f, 3.35869431e-01f, -1.26169682e-01f,
  -2.75099367e-01f, -4.89703454e-02f, -2.96608686e-01f, 7.96894953e-02f, -2.12444621e-03f, -4.50664699e-01f, -2.01041535e-01f, -2.34564215e-01f, -1.06266011e-02f, 3.05113435e-01f,
  -2.74255335e-01f, 3.18387523e-02f, 2.67111778e-01f, -2.47514650e-01f, 4.07133192e-01f, -9.51159000e-03f, -3.47499460e-01f, -3.96293342e-01f, 2.00309809e-02f, -7.13017136e-02f,
  -1.54247256e-02f, -1.61134049e-01f, -7.56141841e-02f, 1.10589355e-01f, 2.53469199e-01f, -9.01383236e-02f, -1.43875062e-01f, -2.55734831e-01f, 1.33758545e-01f, 2.38326285e-02f,
  2.74978250e-01f, 2.20294207e-01f, 6.70275316e-02f, 2.19871596e-01f, 1.92061022e-01f, 2.12784484e-01f, -2.31249750e-01f, -1.65133432e-01f, -2.93411791e-01f, 5.20869084e-02f,
  1.07496707e-02f, -8.76105577e-02f, -1.17164375e-02f, -2.24100187e-01f, 2.64392346e-01f, 9.93568897e-02f, -5.50342202e-01f, 4.55101579e-02f, -3.74476105e-01f, 4.54743281e-02f,
  4.70764756e-01f, -2.52031446e-01f, 1.95331872e-01f, 3.55479829e-02f, -2.17384342e-02f, 6.57574683e-02f, 7.40770996e-02f, 2.92730425e-02f, -1.61891952e-01f, 1.20080493e-01f,
  -1.10624358e-01f, -3.94436181e-01f, -3.34525138e-01f, -6.69226170e-01f, -9.98950228e-02f, 2.74237633e-01f, -3.08497101e-01f, -4.11926895e-01f, -2.42408186e-01f, -2.77122315e-02f,
  3.61147374e-01f, -1.45816758e-01f, 5.88542879e-01f, -2.97979504e-01f, -1.72589391e-01f, -9.15252939e-02f, 3.53248627e-03f, -2.27144599e-01f, 2.36851543e-01f, 3.52075845e-02f,
  -3.26969922e-01f, -2.92673022e-01f, -3.73166144e-01f, 1.51969165e-01f, -5.50563261e-02f, -1.53977543e-01f, -1.66394543e-02f, 5.10655940e-02f, -1.64404809e-01f, 3.11225075e-02f,
  -6.27430975e-02f, -8.76274928e-02f, -1.19472891e-01f, -2.85151333e-01f, 2.52039209e-02f, 9.31437034e-03f, -2.31734309e-02f, 3.71447593e-01f, 1.37232810e-01f, -9.23772231e-02f,
  3.43218952e-01f, 2.08761990e-01f, 1.08255908e-01f, 1.14390388e-01f, -5.49260378e-02f, -2.57436670e-02f, -3.58530760e-01f, 5.54586232e-01f, 7.33736902e-02f, 3.47636938e-01f,
  -2.52000779e-01f, 4.59797680e-02f, 2.11214393e-01f, 7.99330100e-02f, -3.55692476e-01f, -1.99112207e-01f, 2.95532227e-01f, -2.75932372e-01f, 3.16109657e-01f, 2.79346615e-01f,
  1.13915429e-01f, 2.77929574e-01f, -2.19111949e-01f, 1.71090346e-02f, 8.49392116e-02f, -6.88257664e-02f, -3.61149698e-01f, 2.76072592e-01f, -1.21185496e-01f, -2.51800716e-01f,
  -2.49127299e-01f, -2.01076746e-01f, -2.12880135e-01f, -8.39009061e-02f, -2.64692187e-01f, -3.31343204e-01f, 4.57689524e-01f, -3.16742748e-01f, 1.42203152e-01f, -3.62172313e-02f,
  -3.28668440e-03f, -1.72549516e-01f, -2.78450936e-01f, -7.05317557e-02f, 1.11674361e-01f, 4.78751123e-01f, -4.19400632e-01f, 3.32036555e-01f, 3.14520955e-01f, -3.39262098e-01f,
  -1.18177697e-01f, 1.12626199e-02f, 3.06648854e-02f, -7.79898465e-02f, -6.24056868e-02f, -3.01411778e-01f, 1.56081632e-01f, 2.70510077e-01f, 1.92903921e-01f, -6.09818161e-01f,
  -2.33304370e-02f, -2.39179239e-01f, -2.69135565e-01f, 9.39707533e-02f, 8.15818682e-02f, -1.77324206e-01f, 9.64226499e-02f, -1.51380628e-01f, 1.44806668e-01f, 1.05600700e-01f,
  1.04441285e-01f, 1.84603631e-01f, 6.17721118e-02f, -5.28364420e-01f, 2.73829818e-01f, -2.52975672e-02f, 1.99984223e-01f, -1.25086918e-01f, -3.82404625e-01f, 3.22694099e-03f,
  1.91480950e-01f, 1.91160202e-01f, 1.29237011e-01f, -4.32770163e-01f, 3.72869670e-01f, 9.54083875e-02f, -4.71589774e-01f, 1.21717453e-01f, -2.74563670e-01f, -2.12019309e-01f,
  -3.97356182e-01f, 1.74217120e-01f, -1.60888508e-01f, -4.39873971e-02f, -2.63131559e-01f, -1.87554821e-01f, -4.93663102e-02f, 2.64462620e-01f, -1.44344956e-01f, 2.89610445e-01f,
  3.58137429e-01f, -1.37795821e-01f, 3.78334761e-01f, 1.30848698e-02f, -3.27933729e-01f, -7.12480173e-02f, -9.19114426e-02f, 1.96111891e-02f, 2.03971826e-02f, 7.72094801e-02f,
  3.91729623e-01f, -9.81293991e-02f, 1.34885624e-01f, 4.50906873e-01f, -5.00362255e-02f, -2.41630539e-01f, -4.29264121e-02f, -3.85707498e-01f, -3.89690585e-02f, -7.11494982e-02f,
  1.47597596e-01f, 1.08278342e-01f, -9.08246785e-02f, -1.09872120e-02f, -2.16233343e-01f, -1.15206063e-01f, -1.66046008e-01f, 1.85507387e-02f, -5.08514464e-01f, -1.83611080e-01f,
  1.93967093e-02f, -6.00450151e-02f, 5.78028411e-02f, 1.48532689e-01f, -1.84896171e-01f, -3.23942810e-01f, 2.04041332e-01f, 1.99782431e-01f, 6.95794001e-02f, -4.67966273e-02f,
  2.76461422e-01f, 4.05207336e-01f, -6.93552643e-02f, -2.54619610e-03f, -5.58975041e-01f, -2.27587312e-01f, 8.49175751e-02f, -3.97931069e-01f, 1.38375089e-01f, -1.85065106e-01f,
  3.44603896e-01f, 2.35924616e-01f, -3.60781491e-01f, 1.62205905e-01f, 3.33447367e-01f, 1.99372873e-01f, -4.56367247e-02f, -8.09777156e-03f, 3.79049718e-01f, 2.46575087e-01f,
  2.86564231e-01f, -1.43438861e-01f, 1.61589026e-01f, 4.13299501e-01f, -4.14666831e-01f, 5.44166327e-01f, 1.49125591e-01f, -1.00268982e-01f, 1.46185681e-01f, 1.87999308e-01f,
  -7.71427974e-02f, -4.45267782e-02f, -5.83845340e-02f, 2.21446365e-01f, 3.18596810e-01f, -2.89640278e-01f, -3.28422129e-01f, -2.96850801e-01f, -1.78083599e-01f, -3.17704938e-02f,
  -1.36168292e-02f, 1.95448279e-01f, 1.16629250e-01f, 1.02633268e-01f, 1.37347400e-01f, 2.24253699e-01f, 9.91032422e-02f, 2.38949880e-02f, 6.98667616e-02f, 1.11153416e-01f,
  1.04320079e-01f, -7.96122029e-02f, 2.15952769e-01f, 1.61564261e-01f, -1.19102284e-01f, 1.10032313e-01f, -6.29562885e-02f, 9.75878537e-02f, -2.19418943e-01f, 1.40675426e-01f,
  4.68847156e-02f, 1.29619706e-03f, -4.15639281e-01f, 2.21020177e-01f, -6.68826580e-01f, 1.82896838e-01f, 3.59947383e-01f, 3.93102318e-01f, 8.23051184e-02f, -2.26389527e-01f,
  -4.37427685e-02f, -1.71141755e-02f, -5.47185302e-01f, -1.74523920e-01f, 1.18890546e-01f, -3.33516061e-01f, -4.03157622e-01f, 1.07810967e-01f, 1.29977375e-01f, -2.99461126e-01f,
  1.69961065e-01f, 3.37041855e-01f, 1.23582110e-01f, 4.20671314e-01f, -4.29007150e-02f, 9.63114947e-02f, 6.63874924e-01f, -3.06839764e-01f, -3.15179974e-01f, 3.44551712e-01f,
  1.15273986e-02f, -1.41610776e-03f, -8.40818277e-04f, -2.79301673e-01f, 5.39668500e-01f, 1.18460611e-01f, 1.31721096e-02f, -4.11302447e-02f, -3.31466764e-01f, 5.07780872e-02f,
  -2.21564993e-01f, -1.06248960e-01f, 1.26332343e-01f, -1.09946892e-01f, 1.87320039e-01f, -6.62785545e-02f, 1.75885409e-01f, -2.92497650e-02f, -4.08407748e-01f, -1.86053917e-01f,
  -4.48372811e-01f, -2.75425404e-01f, -2.44097799e-01f, 3.38296086e-01f, 3.02328765e-02f, -1.10406645e-01f, 1.49484560e-01f, 1.91941395e-01f, -5.42145483e-02f, 9.66407657e-02f,
  -1.78672269e-01f, -1.85198635e-02f, -8.68056715e-02f, -6.71141148e-02f, -2.10791051e-01f, -3.59663069e-02f, 2.76225179e-01f, -2.19175860e-01f, 2.27612883e-01f, 1.83834881e-01f,
  5.41633368e-01f, 2.31056854e-01f, 1.27771810e-01f, 3.22059602e-01f, -4.98888612e-01f, -4.15306419e-01f, 4.08237338e-01f, -3.01968455e-01f, -1.09222047e-01f, 1.45058826e-01f,
  -2.42946856e-02f, -1.80908769e-01f, 9.13173482e-02f, -3.32290232e-01f, 8.46854062e-04f, 3.70065331e-01f, 3.54860693e-01f, 7.62609616e-02f, -2.24357694e-01f, 4.39140350e-01f,
  -2.94834435e-01f, 2.34187007e-01f, -2.07061633e-01f, 1.56482726e-01f, -1.85441166e-01f, -1.15245931e-01f, -3.14900763e-02f, -8.77409475e-04f, 9.57384929e-02f, -2.55346764e-02f,
  -3.67455482e-01f, -1.44177422e-01f, 1.26491636e-01f, -2.19390824e-01f, -1.16427660e-01f, 5.38615108e-01f, -2.11460739e-02f, 1.28624305e-01f, 5.27101047e-02f, -2.83806771e-01f,
  1.60047516e-01f, 2.51197875e-01f, 8.10714364e-02f, -1.29695550e-01f, 1.70983136e-01f, 1.77618608e-01f, 1.02256089e-02f, 8.38664547e-02f, 1.71655104e-01f, 3.00848991e-01f,
  -9.56756249e-02f, 8.12861719e-04f, -2.14124516e-01f, -3.45894508e-02f, 4.86712065e-03f, 3.45424116e-02f, -1.39177181e-02f, -8.01119357e-02f, -3.30539867e-02f, -8.30215588e-03f,
  6.39827922e-02f, 1.70331463e-01f, 2.51467288e-01f, -6.73744082e-02f, -4.16255027e-01f, 2.95044541e-01f, -2.91303426e-01f, -2.58195668e-01f, 2.97270656e-01f, 4.20066625e-01f,
  -3.34751695e-01f, -9.82712656e-02f, 3.83025080e-01f, -3.56026813e-02f, 1.03552833e-01f, 5.26587963e-01f, 2.85035968e-01f, 5.39428830e-01f, -1.43270910e-01f, -2.63319403e-01f,
  -3.81012172e-01f, -2.29700163e-01f, 5.73746383e-01f, -5.17289080e-02f, -1.89568460e-01f, -1.40231609e-01f, -9.66501758e-02f, 1.27177872e-02f, 5.06805591e-02f, 3.31692770e-02f,
  -3.54087651e-01f, -3.06212127e-01f, 3.62322986e-01f, 1.16521679e-01f, 6.69163465e-02f, 3.72533113e-01f, -2.15230972e-01f, -5.65481223e-02f, 3.67571086e-01f, -1.46181419e-01f,
  5.46293240e-03f, -3.14168297e-02f, -3.93667400e-01f, -1.06959067e-01f, 2.04103217e-01f, 3.06335270e-01f, -2.09077090e-01f, -1.56733561e-02f, 2.21573472e-01f, 2.83599049e-01f,
  5.25320694e-02f, -1.92292258e-01f, 1.32992893e-01f, 4.61361669e-02f, 4.87488844e-02f, 7.13170767e-02f, -4.25797582e-01f, -3.39167081e-02f, 7.39201382e-02f, 2.71443695e-01f,
  4.53345254e-02f, -9.31881666e-02f, 1.04950458e-01f, -2.46075198e-01f, 3.49010639e-02f, 9.84749049e-02f, 3.60995978e-01f, -2.81337202e-01f, 4.62431043e-01f, 1.61732882e-01f,
  -3.51391912e-01f, 3.14930439e-01f, -3.92548501e-01f, -1.42515898e-01f, 1.29545201e-02f, -1.10529572e-01f, -3.60150397e-01f, 2.15187669e-01f, 2.53770351e-01f, -1.64381832e-01f,
  -3.79992165e-02f, -3.86678725e-01f, -2.68534780e-01f, -2.74932116e-01f, 2.00934663e-01f, -6.84823394e-02f, -1.35111764e-01f, -9.93179306e-02f, -2.68174469e-01f, -1.28614247e-01f,
  -8.38577673e-02f, -4.36377257e-01f, -2.25155696e-01f, -6.96743559e-03f, 4.34336334e-01f, 1.98844686e-01f, -3.07167619e-01f, 4.62741079e-03f, 4.01316136e-01f, -1.27537727e-01f,
  -4.06647652e-01f, 2.22942904e-01f, 2.56657630e-01f, -1.46991953e-01f, -2.93915831e-02f, 1.40021101e-01f, -1.44930571e-01f, -2.06532344e-01f, -1.48545187e-02f, -2.79506519e-02f,
  2.33442504e-02f, 2.54223883e-01f, 1.75959423e-01f, -1.43101722e-01f, 1.52784660e-01f, -9.07292124e-03f, 1.79490864e-01f, -5.08942068e-01f, 8.47930908e-02f, 1.65444821e-01f,
  1.24522723e-01f, -6.87690303e-02f, -5.34329563e-02f, -2.20848590e-01f, 2.32384071e-01f, 5.53685613e-02f, -2.32155025e-01f, 1.81843340e-01f, 1.15879744e-01f, 2.83621728e-01f,
  2.99137831e-01f, 2.91081369e-01f, -3.48769844e-01f, -1.55897643e-02f, 2.63719261e-01f, -4.11278665e-01f, -6.48640394e-02f, 6.98398007e-03f, 3.40917200e-01f, 2.91726530e-01f,
  5.60831785e-01f, -2.95060843e-01f, -3.05886954e-01f, 3.51188123e-01f, -7.67906755e-02f, 1.66256174e-01f, 3.75767022e-01f, 1.67954445e-01f, 3.70790780e-01f, -2.56964564e-01f,
  2.02251703e-01f, 3.99909914e-01f, 2.25268245e-01f, 2.03953877e-01f, -5.59908189e-02f, 1.53004155e-01f, -2.25125223e-01f, 2.48448744e-01f, 1.56636667e-02f, 4.67987470e-02f,
  -2.66325742e-01f, -7.88051635e-02f, -1.54816046e-01f, 2.44295254e-01f, 1.75189972e-01f, 2.91437596e-01f, -2.31004432e-01f, 4.54548806e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  2.98761129e-02f, 2.60170014e-03f, -9.86363441e-02f, 9.07464325e-02f, -2.16390844e-02f, -7.44215176e-02f, -3.53842340e-02f, -1.20903859e-02f, 8.07558298e-02f, -5.61498515e-02f,
  7.98809379e-02f, -7.99129382e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    