/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.01625204e-01f, 7.53010511e-02f, 2.21664369e-01f, -2.68976148e-02f, -1.54083222e-01f, 6.65435418e-02f, 6.37244433e-02f, -9.05132219e-02f, -3.93138260e-01f, -4.36969958e-02f,
  -5.45183122e-02f, 1.08782120e-01f, 1.70830816e-01f, 1.40107479e-02f, 4.42854881e-01f, 1.74402818e-01f, -1.05687641e-02f, 5.83223067e-02f, -5.21399677e-02f, 1.70256123e-01f,
  6.63899705e-02f, 8.62396881e-02f, 4.43705916e-01f, 1.45050883e-02f, 5.65738194e-02f, -2.05331966e-02f, 2.14372754e-01f, 7.82333687e-02f, 5.48763685e-02f, -7.43504390e-02f,
  1.48159461e-02f, -1.10215686e-01f, 6.20651655e-02f, -4.93027922e-03f, -1.01910077e-01f, -6.87144622e-02f, 1.03067480e-01f, 5.50476760e-02f, 2.11327653e-02f, 7.44341165e-02f,
  6.46647662e-02f, -3.23123969e-02f, -4.52619009e-02f, 9.99588370e-02f, -1.07448287e-01f, 3.96511964e-02f, -7.04544783e-02f, -4.16667350e-02f, 1.21250777e-02f, 5.20564243e-02f,
  -2.96045793e-03f, 4.93934676e-02f, 1.92443710e-02f, -1.15782887e-01f, -1.03711359e-01f, 2.36345623e-02f, -8.72708112e-02f, 9.12080035e-02f, 1.66369341e-02f, -5.45373037e-02f,
  -8.92443303e-03f, 7.64160678e-02f, -1.82869677e-02f, 5.76222204e-02f, 5.14920577e-02f, -3.15834545e-02f, 1.39184088e-01f, 7.20791379e-03f, 2.02861503e-02f, 3.31662446e-02f,
  -1.71481036e-02f, 1.16136044e-01f, -8.45737234e-02f, 2.62782145e-02f, -3.61126214e-02f, 4.45058122e-02f, 1.35324329e-01f, 3.00598866e-03f, -2.03194041e-02f, 1.24101844e-02f,
  -2.22960319e-02f, 2.24215481e-02f, -6.06114715e-02f, 1.94083210e-02f, 1.29742259e-02f, 7.55934268e-02f, -1.92841403e-02f, -3.27800773e-02f, 5.69991022e-02f, 8.30481648e-02f,
  -9.53801870e-02f, 5.32246567e-02f, -1.29611380e-02f, -5.52909728e-03f, 8.11391026e-02f, 8.39023441e-02f, -6.28979877e-02f, -1.88269336e-02f, -8.27886688e-05f, 2.33341730e-03f,
  -2.83858161e-02f, -3.89540032e-03f, -6.33303747e-02f, -6.46593720e-02f, 6.90442845e-02f, -5.46404123e-02f, 7.50685185e-02f, 4.83871874e-04f, 2.29810458e-02f, -6.90836785e-03f,
  6.51899576e-02f, -6.47683740e-02f, -4.11850736e-02f, -5.81019744e-02f, -3.57985869e-02f, -1.06840525e-02f, 6.18070289e-02f, -8.88677537e-02f, -9.25976783e-03f, -9.35385190e-03f,
  2.32108757e-01f, -1.42503455e-01f, -1.09492525e-01f, 3.92282307e-02f, 2.18189657e-01f, 3.69654834e-01f, 3.83268982e-01f, 3.19998823e-02f, 6.73037171e-02f, -8.67802557e-03f,
  1.71303198e-01f, 4.39146487e-03f, -7.65576810e-02f, 3.70570302e-01f, -6.27389364e-03f, -5.68455122e-02f, 7.55851641e-02f, 1.36530280e-01f, -5.39406836e-02f, -1.63082890e-02f,
  -5.37125655e-02f, 1.19130932e-01f, 1.83383953e-02f, -5.16856536e-02f, 7.90724605e-02f, -1.18341133e-01f, -1.41816333e-01f, 2.25097407e-02f, -1.51525721e-01f, 5.65336868e-02f,
  2.78805733e-01f, -6.33096099e-02f, -4.72990870e-02f, -3.37795578e-02f, 4.86910380e-02f, 5.15836254e-02f, 2.74404604e-02f, 4.91870642e-02f, -1.19002275e-02f, 8.38357061e-02f,
  -6.97735101e-02f, 5.22907451e-02f, 2.80690640e-02f, -4.10454348e-02f, 5.91938421e-02f, 4.56188992e-02f, -2.77712289e-02f, -1.12571532e-03f, 2.26675603e-03f, 6.90066218e-02f,
  3.38207334e-02f, 7.54026249e-02f, -1.16432197e-02f, -1.99529510e-02f, -4.53531370e-02f, 4.30776030e-02f, 3.04028280e-02f, 2.41927877e-02f, -1.51228067e-02f, -1.00643672e-02f,
  -3.88310961e-02f, -2.14511547e-02f, 1.12931095e-02f, 2.92737838e-02f, -4.96156178e-02f, -1.54814022e-02f, -7.24893883e-02f, 4.58745994e-02f, -3.17124724e-02f, -5.84158022e-03f,
  6.15251362e-02f, -1.08631644e-02f, 1.06706331e-02f, 6.40740339e-03f, -1.06843710e-02f, -3.84627916e-02f, -1.08400043e-02f, -6.90189830e-04f, 7.93828219e-02f, -2.73035392e-02f,
  2.22200695e-02f, 3.78389936e-03f, -2.48898100e-02f, 7.75265321e-03f, 8.51520523e-02f, 6.50130620e-04f, 1.27892178e-02f, -3.13251764e-02f, -1.28997406e-02f, -8.31618235e-02f,
  -1.03550322e-01f, -2.58535802e-01f, -2.69861277e-02f, 3.12989876e-02f, -1.00212455e-01f, -3.45037393e-02f, -5.62941320e-02f, -6.48590550e-03f, -5.42400666e-02f, -3.73623259e-02f,
  7.77864829e-02f, -4.33537662e-02f, -6.98966067e-03f, 4.48147282e-02f, -5.15263565e-02f, 2.14944016e-02f, 2.25664936e-02f, -5.70394583e-02f, 6.76175812e-03f, -8.34807977e-02f,
  -6.78853840e-02f, -2.54752431e-02f, 4.71391017e-03f, 2.40907446e-02f, 8.53424333e-03f, 5.85605018e-03f, 1.32897515e-02f, 2.67150882e-03f, 1.96507070e-02f, -2.32323650e-02f,
  -7.98923135e-01f, 3.14262807e-01f, -2.98608243e-01f, -8.33535716e-02f, -3.22741687e-01f, 1.84264302e-01f, -2.74516642e-01f, -8.65295529e-02f, -1.18631855e-01f, 2.32314169e-01f,
  -1.15982726e-01f, 1.63318500e-01f, -1.52505431e-02f, -2.40134709e-02f, -1.09351933e-01f, 2.11431757e-01f, -8.63608196e-02f, -4.47288342e-02f, 2.04411596e-02f, -1.05450638e-02f,
  -1.72226969e-02f, -7.65079483e-02f, -7.65533298e-02f, -5.36544584e-02f, -1.08407237e-01f, -1.42856732e-01f, -4.24341373e-02f, -8.00473616e-03f, 2.76048575e-03f, 2.88448930e-02f,
  -1.47936851e-01f, -1.75315991e-01f, -2.21786425e-01f, 1.87989678e-02f, -1.00671984e-01f, -3.32636014e-02f, 1.83009151e-02f, -9.02399272e-02f, -1.79597177e-02f, 3.04568298e-02f,
  5.95581383e-02f, 3.24420212e-03f, -3.08455955e-02f, -9.97713860e-03f, 2.27442645e-02f, -1.25941925e-03f, 3.89464870e-02f, 6.04417883e-02f, 3.30460183e-02f, 2.41330806e-02f,
  5.30339666e-02f, 6.01547994e-02f, -1.86995436e-02f, 5.19763976e-02f, -2.26252805e-02f, -1.53697571e-02f, -2.43733954e-02f, -8.77800211e-02f, 1.15204239e-02f, 9.17567872e-03f,
  3.49383913e-02f, -8.49320963e-02f, 3.02309748e-02f, -3.66117321e-02f, -3.52724344e-02f, -4.36577853e-03f, -2.81011406e-03f, -2.99042575e-02f, -5.39560504e-02f, -1.70687828e-02f,
  -6.70994222e-02f, -1.50910094e-02f, -2.20904183e-02f, -3.87977250e-02f, 2.14521457e-02f, -5.22275157e-02f, -6.52608601e-03f, 2.88464967e-02f, 1.18376045e-02f, -2.11311691e-02f,
  -2.04544552e-02f, -4.82449634e-03f, 4.21620440e-03f, 2.53172182e-02f, -2.57185437e-02f, -3.83033440e-03f, 5.11768050e-02f, 6.77860454e-02f, -3.33973020e-02f, -3.14287934e-03f,
  2.18266055e-01f, 1.53338924e-01f, 1.01378940e-01f, -2.65659634e-02f, 4.56930697e-02f, -1.48851832e-03f, -5.97828301e-03f, 4.22665365e-02f, 5.62043786e-02f, -4.94306274e-02f,
  3.37010622e-02f, -5.63223734e-02f, 9.61866602e-03f, -7.04979450e-02f, 2.92805731e-02f, 3.13265696e-02f, 3.88419852e-02f, -2.41743755e-02f, -2.89682373e-02f, -1.02904672e-02f,
  -5.48072457e-02f, -2.26351302e-02f, 3.62293199e-02f, -6.72273561e-02f, -2.59934049e-02f, -1.26769789e-03f, 6.75571151e-03f, 8.11277032e-02f, 3.70132998e-02f, -4.57533486e-02f,
  2.38454849e-01f, -2.31859311e-01f, 1.58033237e-01f, 9.04436931e-02f, 1.00162633e-01f, -1.43624634e-01f, -5.14214858e-02f, -1.33962810e-01f, -6.64522201e-02f, -3.24615031e-01f,
  -2.51673386e-02f, -3.91536951e-02f, -7.81868026e-02f, -2.37891585e-01f, 3.88670146e-01f, 5.56029640e-02f, -1.24181956e-01f, -1.54225528e-01f, 5.73320389e-02f, -9.02100429e-02f,
  2.84905016e-01f, -3.26107740e-02f, 1.47866771e-01f, 3.06106545e-02f, 7.43860472e-03f, -5.35716154e-02f, 1.15615249e-01f, 1.23897478e-01f, -1.43864483e-01f, 2.40190458e-02f,
  -1.92919672e-01f, -8.31925198e-02f, -5.13639376e-02f, -7.66866952e-02f, -1.11017548e-01f, 6.33330597e-03f, -5.04128039e-02f, 1.02403507e-01f, 6.60995319e-02f, -3.47894803e-02f,
  1.98138431e-02f, 4.71919402e-02f, 1.44754918e-02f, 1.14196539e-02f, -7.99895152e-02f, -3.39101590e-02f, -8.31574202e-03f, -1.60547346e-02f, 8.90890788e-03f, -5.53175900e-03f,
  -1.42577933e-02f, -3.87650877e-02f, -2.43671965e-02f, -2.46203616e-02f, 1.12367049e-01f, -3.97584140e-02f, 3.64985280e-02f, 6.62278607e-02f, -6.87093288e-02f, -1.61385164e-01f,
  1.19750656e-01f, 2.55379584e-02f, -3.73397022e-02f, -2.27776691e-02f, 1.36944950e-02f, 2.26648655e-02f, -5.40597700e-02f, -7.11918855e-03f, 1.90261863e-02f, -1.30492300e-02f,
  -6.91752881e-02f, 1.07109696e-02f, -2.66597420e-02f, 4.67083510e-03f, -3.24807968e-03f, -1.66030787e-02f, -2.10181307e-02f, -8.38111117e-02f, -6.97692409e-02f, 2.43536588e-02f,
  -1.40703134e-02f, -1.34600920e-03f, -5.09220622e-02f, 6.49749935e-02f, 3.32074659e-03f, 7.41469488e-02f, 4.83810529e-03f, -6.08937291e-04f, 2.85025742e-02f, 1.06596895e-01f,
  -3.01798224e-01f, -7.06761181e-02f, 9.50998534e-03f, -4.76876833e-02f, -4.90375422e-02f, -2.77631991e-02f, 6.43988922e-02f, -3.75064425e-02f, 8.38099886e-03f, -7.63534009e-03f,
  8.66768067e-04f, -8.60829949e-02f, -1.10996133e-02f, -1.26730679e-02f, 6.08694367e-02f, 9.50964226e-04f, 2.23899130e-02f, -6.87150136e-02f, -2.32644789e-02f, -5.68889491e-02f,
  -2.77558789e-02f, 4.33580764e-02f, 1.60578750e-02f, 1.98587980e-02f, 3.85650508e-02f, 1.57751497e-02f, -5.39110927e-03f, 2.77618598e-02f, 2.05784235e-02f, 7.45737255e-02f,
  -2.34847799e-01f, -2.15096921e-01f, -3.28336895e-01f, -4.17723842e-02f, -3.84334326e-02f, 2.81279851e-02f, -4.29928117e-03f, -1.03289939e-01f, -2.30220571e-01f, 1.46339655e-01f,
  2.33818442e-01f, -4.20698464e-01f, 2.65335720e-02f, 9.64474082e-02f, -7.14596361e-02f, 1.14649348e-01f, 1.58823863e-01f, -3.10690608e-02f, -1.35933533e-01f, 6.28568977e-02f,
  1.68718100e-02f, 2.12188110e-01f, 2.74003595e-02f, 1.58809766e-01f, 3.76139209e-02f, -2.15420678e-01f, 2.43835166e-01f, -3.44459973e-02f, 1.45013863e-02f, -4.80928570e-02f,
  -1.40732527e-01f, -3.65158394e-02f, -7.81212561e-03f, -8.26264992e-02f, 5.08087687e-02f, 9.51892883e-02f, -1.85226128e-02f, 1.60029195e-02f, -1.56011316e-03f, -6.31694943e-02f,
  3.71868052e-02f, 3.63156088e-02f, -2.39563230e-02f, -2.30864082e-02f, -4.23010364e-02f, -1.23209342e-01f, -6.10933304e-02f, 6.21193321e-03f, -1.49384513e-02f, -5.24763763e-02f,
  2.54475884e-03f, -7.72904530e-02f, 4.99758683e-02f, 3.06229643e-03f, -4.52402197e-02f, -1.96774919e-02f, -4.94915321e-02f, 3.33013758e-02f, -1.72590271e-01f, -6.65267631e-02f,
  8.78397971e-02f, 2.43704915e-02f, 2.92654671e-02f, -2.24401429e-02f, 1.03669306e-02f, -7.98816793e-03f, 4.67692316e-02f, 4.37617786e-02f, 1.06333066e-02f, 3.50278318e-02f,
  2.43340880e-02f, 2.65904181e-02f, 1.50131881e-02f, 4.26243767e-02f, 3.52572538e-02f, 2.36751558e-03f, 2.66123638e-02f, -5.63960709e-02f, -7.34552965e-02f, 5.85897863e-02f,
  -1.13789402e-02f, -1.89276170e-02f, -2.36281715e-02f, 9.57798306e-03f, -3.53036225e-02f, -5.33748455e-02f, -1.76229291e-02f, -3.69781628e-02f, 1.58075709e-02f, 7.33328313e-02f,
  1.43010393e-01f, 1.98645845e-01f, -2.86772363e-02f, -4.96730171e-02f, -7.08609670e-02f, -1.99766438e-02f, 4.92653586e-02f, -1.98172547e-05f, 8.30556229e-02f, 2.36266367e-02f,
  4.10627797e-02f, -1.01150596e-03f, -3.41041083e-03f, 7.62635693e-02f, -3.35584208e-02f, 1.27377242e-01f, 9.66431648e-02f, -5.42701557e-02f, 6.68053702e-02f, -2.42907293e-02f,
  1.82731766e-02f, 2.46137064e-02f, -3.38788033e-02f, 5.10554165e-02f, 9.13855955e-02f, 5.89135326e-02f, 5.28726168e-03f, -7.67537206e-02f, 8.20518062e-02f, -2.83769686e-02f,
  -6.41619444e-01f, -4.26435135e-02f, 1.21371925e-01f, -3.23135167e-01f, -9.58913639e-02f, 1.45096749e-01f, 7.19767436e-03f, -1.61436737e-01f, -2.15578303e-01f, 6.33572042e-02f,
  1.78621095e-02f, -1.21429220e-01f, 3.33237015e-02f, -2.59491801e-02f, -4.17161345e-01f, 8.38920474e-02f, -7.06760064e-02f, -7.60547258e-03f, -4.16126996e-02f, -9.70987082e-02f,
  -6.98753297e-02f, -8.25541615e-02f, 6.67755157e-02f, 2.92926058e-02f, -5.57673164e-02f, 1.09067962e-01f, -9.99893546e-02f, 1.54203519e-01f, 7.14782160e-03f, 3.22234072e-03f,
  1.63530588e-01f, -1.29239829e-02f, 3.20337601e-02f, 2.14203466e-02f, 1.65714175e-02f, 5.74821047e-02f, 8.90248343e-02f, 3.33232917e-02f, -1.62356701e-02f, -1.29098799e-02f,
  -1.39418636e-02f, -2.21801642e-02f, -5.09544611e-02f, -4.63527348e-03f, 1.99042205e-02f, -1.65398847e-02f, 3.76330726e-02f, 5.23446836e-02f, 1.52724972e-02f, 4.80746403e-02f,
  5.18129244e-02f, 6.03395887e-02f, 2.89814267e-02f, 3.25524397e-02f, 3.66829033e-03f, 6.93383021e-03f, 3.24891098e-02f, 2.16333382e-02f, 3.95083800e-03f, -2.92595401e-02f,
  1.61365699e-02f, -7.13657364e-02f, 2.54684594e-02f, 2.37662680e-02f, -3.44291925e-02f, -9.17031337e-03f, -3.77923772e-02f, -1.04325428e-03f, 2.14290747e-04f, -1.51115833e-02f,
  -1.10227126e-03f, -7.30777308e-02f, -1.62995979e-02f, 3.21211033e-02f, -3.89313623e-02f, -3.97543162e-02f, -1.35301994e-02f, -2.07733996e-02f, -3.72294672e-02f, -5.17555736e-02f,
  5.23785576e-02f, -1.45913688e-02f, 5.57433069e-02f, 3.30692600e-03f, 2.97895409e-02f, -5.06278910e-02f, 3.27203143e-03f, -1.62991490e-02f, -3.96928973e-02f, -2.70055532e-02f,
  -1.27821073e-01f, -3.43748003e-01f, -5.28757721e-02f, -2.02854164e-02f, 2.33831606e-03f, -6.48984909e-02f, -5.41897267e-02f, -1.54642044e-02f, -2.29561776e-02f, -4.93229069e-02f,
  1.78645011e-02f, 3.06241922e-02f, 4.37939987e-02f, 3.44346347e-03f, -1.29058938e-02f, -1.99757610e-03f, -5.76599203e-02f, -6.30240962e-02f, -3.39302793e-02f, -5.69627956e-02f,
  -4.75214794e-04f, -3.62898186e-02f, 1.53968027e-02f, 5.33357495e-03f, -2.05579586e-02f, 3.98551039e-02f, -9.79905277e-02f, -8.38294066e-03f, 9.29368753e-03f, 7.49370158e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.83514589e-01f, 5.63822277e-02f, -3.15993845e-01f, -9.55609232e-02f, 6.04715385e-02f, 1.73895568e-01f, 7.76780099e-02f, 8.67231712e-02f, -3.58844787e-01f, 2.36433432e-01f,
  5.97233586e-02f, -2.22987924e-02f, -1.52877241e-01f, -2.06673697e-01f, -5.51284790e-01f, -4.10267979e-01f, -1.18743330e-01f, 1.69304863e-01f, -1.14439733e-01f, 2.33574450e-01f,
  9.81713906e-02f, 2.79025994e-02f, -3.40641379e-01f, 1.01537220e-01f, 3.53181809e-01f, 1.76489174e-01f, 2.77048022e-01f, 8.17511529e-02f, 3.36864203e-01f, -1.43710166e-01f,
  4.94592115e-02f, -1.93465054e-01f, -1.63910910e-02f, -2.13683359e-02f, 1.31532207e-01f, 1.85617641e-01f, 2.15364069e-01f, -7.02620596e-02f, -1.51057303e-01f, 5.57442270e-02f,
  1.16760023e-01f, -7.86208175e-03f, -2.01371382e-03f, -1.12480462e-01f, 1.49258435e-01f, -5.53146079e-02f, -1.27668843e-01f, -1.12842388e-01f, -6.35110140e-02f, -7.85346478e-02f,
  -9.04389843e-02f, 1.48664974e-02f, 1.14105448e-01f, 4.68023941e-02f, -2.43121013e-02f, -3.83659415e-02f, -6.64472431e-02f, 7.57642165e-02f, 1.30031809e-01f, -3.54321413e-02f,
  6.77740201e-02f, 1.25724956e-01f, -3.22013013e-02f, 1.07881896e-01f, -9.83647257e-02f, 1.74053926e-02f, -8.14439133e-02f, 3.69000584e-02f, -1.25805914e-01f, -1.92731190e-02f,
  3.79233696e-02f, -4.77400534e-02f, 2.12056171e-02f, 7.72562698e-02f, 5.01319580e-02f, -9.64793190e-02f, 8.08270574e-02f, 6.78066984e-02f, -1.47498073e-02f, -4.75663245e-02f,
  -5.58967143e-02f, 4.47051190e-02f, -3.28810290e-02f, 1.85761243e-01f, 7.62778893e-02f, 1.22247357e-02f, 1.54882267e-01f, -7.39743980e-03f, 7.66488016e-02f, 3.91380675e-02f,
  1.21606082e-01f, 1.33634895e-01f, -1.21549845e-01f, 1.63408667e-02f, -5.30579500e-02f, -3.68061359e-03f, -2.25570261e-01f, 1.10683041e-02f, 1.08577155e-01f, 8.49085487e-03f,
  1.89284608e-01f, 2.32356749e-02f, 2.38507986e-01f, 4.39220034e-02f, -5.59325628e-02f, -6.37303386e-03f, 1.37945294e-01f, -3.39300632e-02f, 2.01247916e-01f, 1.07280411e-01f,
  7.67040029e-02f, 1.71466336e-01f, -4.72949594e-02f, -2.88942680e-02f, 9.93578136e-02f, 6.63696378e-02f, 5.47546856e-02f, -3.22082564e-02f, 1.34323046e-01f, -1.84970628e-02f,
  -2.79099017e-01f, 9.46323574e-02f, -2.70310849e-01f, -2.62896687e-01f, 1.10176153e-01f, -3.80320728e-01f, -3.10931683e-01f, 3.45813744e-02f, -3.18675339e-02f, 2.68436879e-01f,
  4.46741059e-02f, 2.15265095e-01f, 9.11443159e-02f, -2.48115256e-01f, -5.65725386e-01f, -1.76178738e-01f, -6.34447038e-01f, -1.58688411e-01f, -8.98504555e-02f, -7.75533542e-02f,
  -2.04553545e-01f, -7.84489792e-03f, -4.32839453e-01f, 9.89770070e-02f, -4.99093831e-02f, 1.17891483e-01f, 1.28741622e-01f, 1.74808621e-01f, -5.55572771e-02f, -8.65394622e-02f,
  -2.52857834e-01f, 2.35106111e-01f, 8.09376538e-02f, -1.51262991e-02f, -2.14791149e-01f, 5.38517945e-02f, -3.77226248e-02f, 8.52268338e-02f, -5.10482378e-02f, 6.41913116e-02f,
  -3.27208848e-03f, 4.47535031e-02f, 3.83244418e-02f, 1.00044340e-01f, 9.88206565e-02f, 1.26337528e-01f, -4.33350131e-02f, -2.12937951e-01f, 4.63334881e-02f, 7.99591988e-02f,
  -4.28659394e-02f, -6.72887452e-03f, -2.09695511e-02f, 1.40128424e-02f, -6.37236089e-02f, 7.39796236e-02f, -9.85310227e-02f, 1.42952040e-01f, -4.24848534e-02f, -1.84268076e-02f,
  -7.19784796e-02f, 9.85323414e-02f, -9.48568061e-02f, 6.38331249e-02f, -1.40661830e-02f, 4.79824934e-03f, 4.46338346e-03f, 7.86310062e-02f, 5.36400825e-03f, 5.93699999e-02f,
  -7.42671490e-02f, 4.49044779e-02f, 2.87492927e-02f, -1.12728246e-01f, -3.80604640e-02f, 1.14225941e-02f, -1.49158984e-02f, -1.80241391e-02f, -6.09816276e-02f, -1.40806168e-01f,
  3.33040208e-02f, -9.42178667e-02f, -2.83535849e-02f, -1.19958697e-02f, 5.52047528e-02f, 1.04021400e-01f, 8.81217271e-02f, -6.20563142e-02f, 6.31931610e-03f, -4.72418927e-02f,
  -6.25704974e-02f, -8.72227252e-02f, 1.43209891e-02f, 1.14133582e-02f, 6.78621978e-02f, -8.66734907e-02f, -1.25135437e-01f, 3.92919891e-02f, -6.31202832e-02f, -9.00519863e-02f,
  7.08940849e-02f, -7.93971494e-02f, -4.19759154e-02f, -3.04902736e-02f, -1.70943141e-03f, -5.32682054e-02f, 2.97251940e-02f, 4.01110463e-02f, -7.16859251e-02f, -6.66359514e-02f,
  1.91742685e-02f, 3.96640562e-02f, 2.48831362e-02f, 3.82334441e-02f, -9.05771554e-03f, -8.88198316e-02f, 3.90790589e-02f, -3.01562686e-04f, -1.99733321e-02f, -1.09471105e-01f,
  -5.35459280e-01f, -2.97337472e-01f, -5.19240558e-01f, 1.78594351e-01f, 9.52968076e-02f, 2.63446301e-01f, -1.90592408e-01f, -4.80255038e-02f, -8.13121572e-02f, 2.09074944e-01f,
  8.17694291e-02f, 7.87374973e-02f, -4.93267000e-01f, 4.87221658e-01f, 1.10525765e-01f, -2.09150329e-01f, 3.85705590e-01f, 3.71128544e-02f, -1.66323110e-01f, -2.45808721e-01f,
  -4.63256985e-02f, 4.58805233e-01f, -1.37626514e-01f, 2.09795862e-01f, 8.24778993e-03f, -4.52009402e-02f, 1.08830780e-01f, -2.35459805e-01f, 4.29536968e-01f, 3.06761503e-01f,
  2.59558082e-01f, -3.66086394e-01f, -1.44426703e-01f, -7.01674744e-02f, -4.13088351e-02f, 3.63433473e-02f, -1.30372673e-01f, 5.13469093e-02f, 2.47420743e-04f, -1.41496539e-01f,
  -5.31214215e-02f, 9.58822966e-02f, 9.70278606e-02f, -6.93267733e-02f, -7.50934286e-03f, 3.40306982e-02f, 2.16994882e-02f, -9.27781463e-02f, -1.26611650e-01f, -1.13442801e-01f,
  -1.19868532e-01f, -7.40451217e-02f, -6.58039972e-02f, 8.84022117e-02f, -5.37611991e-02f, -5.71016744e-02f, 5.23995571e-02f, -9.78439450e-02f, -7.98162222e-02f, 6.01446852e-02f,
  -7.55248815e-02f, -1.02998301e-01f, -1.17093071e-01f, 1.38556473e-02f, -9.31253433e-02f, 5.80535010e-02f, -9.52306911e-02f, 4.75191362e-02f, -6.92649484e-02f, 6.47844970e-02f,
  3.88219627e-03f, -3.20040137e-02f, -6.49459567e-03f, 2.53904741e-02f, -2.34527849e-02f, -3.72729823e-02f, -1.06270805e-01f, 9.40947607e-02f, -4.08633016e-02f, 4.93214279e-02f,
  1.01442738e-02f, -8.30462947e-03f, 4.62735221e-02f, -6.88472241e-02f, -2.80006472e-02f, -5.83833605e-02f, 1.04967475e-01f, -3.16964202e-02f, -6.77439049e-02f, -5.19813448e-02f,
  -3.19259673e-01f, -2.81092346e-01f, 1.74975932e-01f, 9.19679627e-02f, 3.86906900e-02f, 2.56508421e-02f, 1.23908045e-03f, 4.01549600e-02f, -4.70585860e-02f, 3.77229927e-03f,
  -3.29682119e-02f, -2.29878165e-02f, 2.70301849e-03f, 2.52285395e-02f, 1.16766490e-01f, -6.15732297e-02f, -1.65773872e-02f, 1.38660461e-01f, 5.24200611e-02f, 6.56419769e-02f,
  2.28177421e-02f, 4.40574884e-02f, 2.55764164e-02f, -7.67459571e-02f, 1.63063914e-01f, -2.14709640e-02f, -8.30064043e-02f, 3.75881866e-02f, 6.81275055e-02f, 3.52977030e-02f,
  1.25820652e-01f, 8.52263689e-01f, 2.92869985e-01f, 2.27967203e-01f, -4.81883772e-02f, -4.19490814e-01f, -5.48172891e-01f, 3.20253134e-01f, -1.57325327e-01f, 2.21734434e-01f,
  -1.56762436e-01f, 1.86981648e-01f, -1.51596725e-01f, 1.02941521e-01f, -5.13843417e-01f, -1.73673987e-01f, -1.34823844e-01f, -3.42685953e-02f, -1.04935683e-01f, 2.17420429e-01f,
  -3.94162498e-02f, -1.03562646e-01f, 6.50891811e-02f, 4.99576442e-02f, 1.85790420e-01f, 2.31870860e-01f, -2.45424267e-02f, 5.25041409e-02f, 2.52610117e-01f, 4.25819494e-02f,
  -2.95305610e-01f, 8.01889524e-02f, 1.64423779e-01f, -3.84314954e-02f, -4.38259430e-02f, -2.39500552e-02f, 1.20226024e-02f, -3.34110558e-02f, -2.98282634e-02f, 2.38448326e-02f,
  -1.97759625e-02f, -4.29027900e-02f, 6.58470159e-03f, -2.11840086e-02f, 1.89041737e-02f, 1.12613380e-01f, 3.11000533e-02f, 4.60773595e-02f, 1.41048059e-02f, 3.30733508e-03f,
  1.16791531e-01f, 3.86333689e-02f, 2.35903561e-02f, 1.11832656e-02f, 1.21747479e-01f, -3.04621328e-02f, -3.20319496e-02f, 3.18265706e-02f, 3.68390195e-02f, 1.44671742e-02f,
  -1.40339211e-02f, -1.18337825e-01f, 1.77058931e-02f, -5.47772087e-02f, 2.54966244e-02f, -9.88196358e-02f, -2.76912153e-02f, -6.59577921e-02f, -1.19422786e-02f, -4.31474224e-02f,
  2.17411201e-02f, 2.72671711e-02f, -3.63227054e-02f, -5.95391355e-02f, 2.39110813e-02f, 3.92332822e-02f, -9.77053195e-02f, -3.83695960e-02f, -3.92437652e-02f, -9.64416284e-03f,
  -1.33810937e-02f, -7.03856573e-02f, -9.49118473e-03f, -7.83506129e-03f, -6.51883557e-02f, 2.91985888e-02f, 3.28236371e-02f, 5.68461530e-02f, -3.65694426e-03f, -4.47092764e-02f,
  -4.05582972e-02f, 2.81004071e-01f, -1.81809086e-02f, 7.54049979e-03f, -4.83567491e-02f, 1.18975816e-02f, -4.87263799e-02f, 8.89153033e-02f, -1.13337785e-02f, -5.34356683e-02f,
  3.16905677e-02f, -7.13951588e-02f, -4.58978228e-02f, 2.31576636e-02f, 2.52854526e-02f, -2.10480541e-02f, 5.25014214e-02f, 2.06105448e-02f, 5.50614260e-02f, 8.37119296e-02f,
  -3.35783213e-02f, -2.75017861e-02f, -7.38021135e-02f, 3.07373479e-02f, -2.58262660e-02f, -1.52579080e-02f, -3.40960687e-03f, 3.58849429e-02f, -1.45765776e-02f, -8.06515589e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  9.79830623e-02f, -8.77892599e-02f, -4.91117537e-01f, 2.12553442e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.59683377e-02f, 1.68508872e-01f, 6.87986732e-01f, 2.07115889e-01f, -2.53776819e-01f, -2.10856453e-01f, 3.29102725e-01f, -2.39831313e-01f, 1.57166511e-01f, -5.40937781e-01f,
  4.40435469e-01f, -6.59772800e-03f, 3.94345671e-01f, -1.13733947e-01f, 4.89445001e-01f, 6.09889627e-01f, -5.64139038e-02f, 3.26850027e-01f, -3.27857405e-01f, -2.45470911e-01f,
  1.67745516e-01f, -3.02953690e-01f, 3.84962112e-01f, 5.04246950e-01f, 3.81272212e-02f, 4.03983984e-03f, 2.61327982e-01f, 7.54833072e-02f, -6.81103617e-02f, -9.01810452e-02f,
  3.03081840e-01f, -1.82858288e-01f, 7.17147812e-02f, 5.76157048e-02f, -4.14557517e-01f, 1.56999603e-01f, -4.99569532e-03f, 1.67526767e-01f, -7.04948008e-02f, 7.38959983e-02f,
  2.62028843e-01f, -3.61693799e-01f, 5.30722320e-01f, -5.04991591e-01f, 3.06729734e-01f, -1.01388745e-01f, 1.90823823e-01f, -4.44226652e-01f, -2.03433067e-01f, 1.04031116e-02f,
  -1.47596717e-01f, -2.25709304e-01f, 3.04153681e-01f, -4.27656800e-01f, 1.86703891e-01f, -4.39964384e-01f, 5.48155546e-01f, 4.65542078e-01f, 3.64826471e-02f, 3.23978126e-01f,
  -5.25175989e-01f, 4.50183094e-01f, 2.23633364e-01f, -2.42970567e-02f, 1.95774838e-01f, 3.48610580e-02f, 1.20864555e-01f, 9.70460474e-02f, 3.57230157e-01f, 7.19781443e-02f,
  -2.99640805e-01f, -2.15026870e-01f, 6.33829951e-01f, -3.43489498e-01f, 2.56596416e-01f, 1.03442080e-01f, -8.18047300e-02f, 5.00488102e-01f, 1.75147429e-01f, -6.20214641e-01f,
  4.14488703e-01f, 1.34116843e-01f, -2.76593883e-02f, 2.71578997e-01f, 2.71804154e-01f, -8.37657228e-02f, -5.06276250e-01f, -8.57222453e-02f, -1.41113341e-01f, 4.13666874e-01f,
  -7.00585902e-01f, -4.59761828e-01f, -1.77685440e-01f, 3.20590258e-01f, -4.85599935e-01f, -1.66492946e-02f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.92420834e-01f, 9.60264266e-01f, -9.78977159e-02f, 1.85757920e-01f, -4.72247228e-02f, 3.43642175e-01f, 1.07247777e-01f, 6.54662013e-01f, 1.73257813e-01f, 2.34163508e-01f,
  -5.23699522e-01f, 1.40233338e+00f, -3.49173665e-01f, -3.93814385e-01f, 6.13624394e-01f, 1.49660200e-01f, -3.06178749e-01f, -3.17533255e-01f, 2.48122409e-01f, -1.68392405e-01f,
  4.87950832e-01f, -5.44129349e-02f, 6.79657996e-01f, 2.09206626e-01f, -8.46860170e-01f, 4.13817227e-01f, 5.83426595e-01f, -4.02353346e-01f, 2.96928525e-01f, -8.34240675e-01f,
  5.33145607e-01f, 3.03452969e-01f, 3.16140115e-01f, 4.89865094e-01f, -4.04135376e-01f, 3.16662610e-01f, 5.00859022e-01f, 4.22654927e-01f, -3.94007027e-01f, 8.10792983e-01f,
  -6.59898043e-01f, 4.46266830e-02f, -4.45438683e-01f, -1.05118656e+00f, -2.42040716e-02f, -7.51391888e-01f, 5.84348023e-01f, -4.21328694e-01f, 3.88141692e-01f, 8.47535610e-01f,
  5.78273654e-01f, 2.12310314e-01f, -3.44145149e-01f, 1.82259664e-01f, -1.78011388e-01f, 3.54549199e-01f, 3.77789766e-01f, -1.17875111e+00f, 3.31196457e-01f, 7.96571910e-01f,
  3.91674608e-01f, 2.86206126e-01f, 5.81922770e-01f, 3.46872121e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  4.29789633e-01f, 2.29763985e-02f, 4.12466913e-01f, 4.98348087e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -7.31827796e-01f, 1.88202754e-01f, 5.86726367e-02f, -1.48432527e-03f, 2.74325609e-02f, -1.60535991e-01f, 2.37441584e-01f, -4.22705531e-01f, 3.67207646e-01f, -3.99116755e-01f,
  3.18333596e-01f, -1.70286782e-02f, -6.81221426e-01f, -5.85317254e-01f, 1.54945478e-01f, 2.89795518e-01f, -6.48309067e-02f, -6.61064088e-01f, -5.12415469e-01f, 1.10316224e-01f,
  3.78751941e-02f, 3.44723225e-01f, 1.25713140e-01f, 8.24557245e-01f, -4.90517437e-01f, -4.88566637e-01f, -7.06157446e-01f, -2.76188433e-01f, 6.59967780e-01f, 5.14338315e-01f,
  -1.14489153e-01f, -6.61765113e-02f, -6.11045957e-01f, -6.78552687e-01f, -5.41856766e-01f, 3.21332924e-02f, -3.14273536e-01f, 8.45791120e-03f, 7.40821183e-01f, 4.84802365e-01f,
  -2.12790251e-01f, -2.92583317e-01f, -4.20858592e-01f, -3.96089047e-01f, -1.80760890e-01f, 3.28153491e-01f, -1.06415577e-01f, 4.13917989e-01f, 1.55794378e-02f, -1.01027980e-01f,
  -2.14783967e-01f, 3.55402231e-01f, 3.88229996e-01f, -2.45458767e-01f, -2.41850540e-01f, 3.89926493e-01f, 5.81732392e-01f, -5.57363331e-01f, -2.44194031e-01f, -1.60482720e-01f,
  4.58758742e-01f, -9.85187367e-02f, 5.22848904e-01f, -3.51165980e-01f, 4.08374399e-01f, 4.51489061e-01f, 3.80599290e-01f, 2.17889361e-02f, 1.74124509e-01f, -1.20586731e-01f,
  -5.67948580e-01f, -4.20509189e-01f, 2.04814330e-01f, 4.39733863e-01f, 9.48539153e-02f, 6.21548474e-01f, -8.78058001e-02f, 4.56657201e-01f, 3.67394567e-01f, -3.72035325e-01f,
  -3.05321395e-01f, -3.78639281e-01f, -5.28824508e-01f, -2.49662027e-01f, 1.18603095e-01f, 4.05607074e-01f, -1.33682400e-01f, -2.93095380e-01f, -4.33598310e-01f, 7.78617850e-03f,
  -8.83769572e-01f, 3.64448130e-01f, 1.40938135e-02f, 6.07399225e-01f, 3.02270800e-01f, -2.10553333e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  6.43571317e-01f, -2.60751918e-02f, -3.10957134e-01f, 1.06843445e-03f, 3.59425932e-01f, -2.97818035e-01f, 1.42015016e+00f, 1.41800857e+00f, 7.94150770e-01f, 6.36981606e-01f,
  1.30882871e+00f, -1.16594660e+00f, 1.19186425e+00f, 3.97958100e-01f, 4.53726619e-01f, 5.83611131e-01f, -2.55966216e-01f, 8.20590183e-02f, 6.15336299e-01f, 1.05183053e+00f,
  7.49549210e-01f, 6.14900216e-02f, -1.09143305e+00f, 3.22702438e-01f, 9.75275695e-01f, -2.05215287e+00f, 5.23750007e-01f, -4.61189955e-01f, 8.39581728e-01f, -2.21149981e-01f,
  1.56030524e+00f, 5.89431465e-01f, 5.73974788e-01f, 4.72974956e-01f, 8.52746546e-01f, 8.71596813e-01f, -2.87847742e-02f, 6.31303847e-01f, -7.98977554e-01f, -2.44947806e-01f,
  -1.49692726e+00f, 6.91401303e-01f, -9.13561463e-01f, 3.99115205e-01f, 7.61674762e-01f, 1.24627817e+00f, -4.63096559e-01f, -2.58316696e-01f, 1.16515005e+00f, 1.43685371e-01f,
  7.79675364e-01f, 1.96578056e-01f, 2.01256678e-01f, 4.90959466e-01f, 4.01626736e-01f, -9.90856647e-01f, -1.09384060e+00f, 1.23531199e+00f, 1.00896966e+00f, 1.21461821e+00f,
  1.02639687e+00f, -1.09589517e+00f, -6.41664386e-01f, 1.09587109e+00f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  1.16520129e-01f, 4.32396114e-01f, 6.41070008e-01f, 6.27394259e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  1.01416564e+00f, 2.49579236e-01f, 2.80514270e-01f, 2.94114649e-01f, -6.25023246e-01f, -1.79332411e+00f, -4.97589022e-01f, 6.09079599e-01f, 5.56833446e-01f, 8.76510859e-01f,
  -7.65093744e-01f, 4.25273687e-01f, 7.41582096e-01f, -2.04702958e-01f, -1.31855428e+00f, -3.98986697e-01f, 4.62626547e-01f, 5.04391432e-01f, -6.04632139e-01f, 5.54690540e-01f,
  6.21277153e-01f, 1.63980472e+00f, 1.40072954e+00f, 1.08161867e+00f, 1.08786917e+00f, 9.91373003e-01f, -1.28921330e+00f, -7.13275731e-01f, 3.91311347e-01f, 3.44157815e-01f,
  -7.89512157e-01f, -1.84078836e+00f, -8.87081385e-01f, -9.98654783e-01f, -2.12698624e-01f, -7.84251928e-01f, 1.25531763e-01f, -6.02723598e-01f, -6.46770418e-01f, -1.39481044e+00f,
  4.66839284e-01f, -9.40567613e-01f, 7.16152370e-01f, 2.82670498e-01f, 6.09365046e-01f, 2.27173731e-01f, -3.11257184e-01f, -1.73055649e+00f, 4.08451483e-02f, -7.58808479e-02f,
  3.31743985e-01f, -1.22686851e+00f, 6.08528554e-01f, 3.93854752e-02f, 1.08861315e+00f, -8.22408795e-01f, 7.76047230e-01f, 6.44660354e-01f, -8.51367831e-01f, -4.45248634e-01f,
  -1.90364674e-01f, -1.67373598e+00f, -7.43220329e-01f, 7.76159525e-01f, -6.17172003e-01f, 8.69491220e-01f, 3.09699357e-01f, 7.73922324e-01f, 8.03484201e-01f, 2.51971334e-02f,
  -1.34749150e+00f, 9.44277525e-01f, -1.10828555e+00f, -3.87131162e-02f, -3.12128454e-01f, -7.86140561e-01f, 1.47097096e-01f, -7.00611949e-01f, 3.19515169e-01f, 2.27871165e-01f,
  8.28599036e-01f, 2.86953300e-02f, 4.33704257e-01f, 6.45037949e-01f, 5.57234704e-01f, 4.38834250e-01f, 1.28497243e+00f, -1.50569022e+00f, -1.20953727e+00f, 1.10452425e+00f,
  1.47495067e+00f, -1.12522280e+00f, -1.49378911e-01f, 3.82584065e-01f, -1.00535905e+00f, -1.94328576e-01f, 1.26896310e+00f, 1.17368329e+00f, -1.25073862e+00f, -9.29897904e-01f,
  -8.64561439e-01f, 4.01750952e-01f, -3.19297701e-01f, -8.47822949e-02f, -8.83249044e-01f, 2.71421336e-02f, 2.02128917e-01f, 9.84270692e-01f, -1.24843836e+00f, 6.95944905e-01f,
  -2.36326158e-01f, -1.39393640e+00f, 9.66667891e-01f, -8.30234826e-01f, -7.05173492e-01f, 2.83739090e-01f, -5.51227212e-01f, 7.75458038e-01f, -2.87062317e-01f, -1.30855143e+00f,
  -1.17043841e+00f, -1.24309409e+00f, 1.41412592e+00f, -7.23745108e-01f, -1.60676730e+00f, -1.30621505e+00f, 5.23738921e-01f, 4.48019654e-01f, -7.53542483e-02f, 3.29692326e-02f,
  6.48598850e-01f, 4.30991739e-01f, 7.11455822e-01f, -7.29756713e-01f, -1.08426678e+00f, 1.00824952e+00f, 1.45078826e+00f, -1.52163720e+00f, 1.30970669e+00f, 7.66656518e-01f,
  -1.21580184e+00f, -4.49688286e-01f, 1.00347328e+00f, -8.20071220e-01f, -1.70334053e+00f, -1.55705178e+00f, 1.04517007e+00f, -4.18918550e-01f, -1.21593319e-01f, -6.95829615e-02f,
  8.94108713e-02f, 8.15009594e-01f, -1.25706363e+00f, 1.29074454e+00f, 5.47577262e-01f, 6.01023555e-01f, -7.15794802e-01f, 2.63864815e-01f, 6.89151943e-01f, -7.22531974e-01f,
  -1.51636267e+00f, -1.43825501e-01f, -2.57646054e-01f, -3.05375248e-01f, -6.57906711e-01f, -1.01541209e+00f, 3.59430045e-01f, -1.29818904e+00f, 8.42091858e-01f, -1.67881560e+00f,
  -8.79868984e-01f, -8.83448124e-01f, -3.66621077e-01f, 4.08659369e-01f, -1.81160581e+00f, 1.88530777e-02f, 7.27961123e-01f, 1.73713908e-01f, -5.93425155e-01f, 6.84579909e-01f,
  -6.45522535e-01f, 5.86817086e-01f, 8.10587347e-01f, 1.44992888e+00f, 9.03534472e-01f, -8.24463427e-01f, -1.30913746e+00f, 1.52342856e+00f, -1.12321651e+00f, -6.15561381e-02f,
  -1.58294037e-01f, 3.98798287e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -4.78805192e-02f, 3.33774686e-01f, -5.66384196e-01f, 6.79078549e-02f, -1.77229822e-01f, 1.72445402e-02f, 3.29944819e-01f, 4.84878808e-01f, 7.84504354e-01f, 5.09298183e-02f,
  -2.68432796e-01f, 2.25834623e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    