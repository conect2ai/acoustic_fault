/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.46097767e-01f, -2.77367890e-01f, 1.41508251e-01f, -3.72306794e-01f, -4.26300392e-02f, 2.40257923e-02f, -3.74901921e-01f, 2.40799040e-03f, 7.63827637e-02f, -1.96813643e-01f,
  -2.04339474e-01f, -1.04750909e-01f, -2.57396787e-01f, -3.64176899e-01f, 5.29762916e-02f, -1.07432298e-01f, -2.53243446e-01f, -1.97824612e-01f, 1.96589619e-01f, -1.67181194e-01f,
  6.62925243e-02f, -2.81790942e-01f, 2.22832263e-02f, 1.52179822e-01f, -7.00711980e-02f, 1.88547999e-01f, -1.71220601e-01f, 9.63725001e-02f, -2.52122618e-02f, 6.42079934e-02f,
  -6.02842905e-02f, -9.69182849e-02f, 1.16212338e-01f, -1.96125242e-03f, -3.84002812e-02f, 4.16588075e-02f, -6.31118799e-03f, 2.16949638e-02f, 5.77867702e-02f, -2.05858462e-02f,
  -6.78945035e-02f, -6.77881809e-03f, -2.76198331e-03f, -3.14762234e-03f, -1.07797692e-02f, 1.01974748e-01f, 1.07396811e-01f, 5.33351004e-02f, -5.42273521e-02f, 7.53077939e-02f,
  7.15646222e-02f, 8.59164670e-02f, 4.74458262e-02f, -2.32332442e-02f, 5.37964469e-03f, -8.95523131e-02f, 9.57152098e-02f, 2.85656378e-02f, 1.71453785e-02f, 2.96592209e-02f,
  1.32592484e-01f, -6.58977963e-03f, 6.82890639e-02f, -1.29884491e-02f, 1.94797758e-02f, 2.12369137e-03f, -2.47794278e-02f, 5.09292707e-02f, -9.82491001e-02f, -2.32728366e-02f,
  1.89373195e-02f, -1.03561588e-01f, 4.87642176e-02f, -9.68977138e-02f, 3.05233672e-02f, -1.03643231e-01f, -5.54957939e-03f, -1.26998439e-01f, 8.16982910e-02f, 1.83335841e-02f,
  -9.41007808e-02f, -3.52150500e-02f, -6.03915146e-03f, -2.08819378e-02f, 4.60721739e-02f, -1.18064493e-01f, -3.82864065e-02f, -7.15813562e-02f, -2.02066321e-02f, -1.84766985e-02f,
  -3.68957907e-01f, -2.87644118e-01f, 2.19235979e-02f, -1.44640245e-02f, -3.47130969e-02f, 6.44874945e-02f, 6.23486787e-02f, 1.24821149e-01f, -5.58990380e-03f, -3.72240916e-02f,
  3.57839884e-03f, 1.31960427e-02f, 1.45066828e-01f, -6.66804388e-02f, 3.76483761e-02f, -1.18096471e-01f, -4.92146164e-02f, -7.26787299e-02f, -8.90940353e-02f, -6.31028190e-02f,
  -5.97276613e-02f, 2.84773484e-02f, 2.14646354e-01f, -3.52342315e-02f, 9.85730663e-02f, 2.96185222e-02f, 4.64903191e-03f, 8.80768895e-02f, -2.59551257e-02f, -1.51734442e-01f,
  -7.21162081e-01f, -3.69304150e-01f, 1.31450817e-01f, -1.67913973e-01f, -2.69366056e-01f, -2.73203164e-01f, 1.05930135e-01f, -1.73043296e-01f, -4.77940232e-01f, -5.47747985e-02f,
  1.17441669e-01f, -1.97391212e-01f, 2.44315922e-01f, -1.86141938e-01f, 3.08097154e-01f, 4.14773002e-02f, 1.60980262e-02f, -4.10864130e-02f, -1.13588050e-01f, -1.80722132e-01f,
  -3.75260133e-03f, -1.02272458e-01f, 3.75766337e-01f, -1.81333199e-01f, -1.48255900e-01f, -7.47294873e-02f, 3.72259021e-01f, 5.46942987e-02f, 1.01341926e-01f, 2.20776796e-02f,
  8.03884342e-02f, -2.91981161e-01f, -5.48049472e-02f, -6.04418889e-02f, -7.14398772e-02f, 5.89915179e-02f, 2.22158819e-01f, 2.90581398e-03f, 2.82113608e-02f, -2.49400530e-02f,
  3.39071173e-03f, -7.22452700e-02f, -1.05011344e-01f, -8.73682201e-02f, -1.67208478e-01f, -1.20689049e-01f, -1.42371625e-01f, 1.25496626e-01f, -4.82644215e-02f, -6.20246604e-02f,
  7.70865902e-02f, 4.21083495e-02f, -1.83239102e-03f, -5.45349605e-02f, -3.95735428e-02f, -1.33919477e-01f, 1.20865844e-01f, 1.23976372e-01f, -1.22545529e-02f, -1.44090533e-01f,
  -1.31296054e-01f, -4.46653701e-02f, 7.26948977e-02f, -1.61278099e-02f, -2.20351331e-02f, -4.29145209e-02f, -1.26426235e-01f, 3.84969488e-02f, -9.60681885e-02f, -5.45677319e-02f,
  -1.52878901e-02f, -1.57723099e-01f, -1.64050683e-02f, 5.49399182e-02f, 1.59082599e-02f, -3.89295332e-02f, 3.35466978e-03f, -2.52693947e-02f, -7.96815902e-02f, 5.56678288e-02f,
  1.03163317e-01f, 1.15774563e-02f, 3.94324176e-02f, 1.77583452e-02f, 4.40666899e-02f, 6.86225966e-02f, -1.28325764e-02f, -4.89001628e-03f, 6.56860322e-02f, 9.31299627e-02f,
  1.04058988e-01f, -1.07618952e-02f, 4.03844789e-02f, -1.14424678e-03f, 2.19848044e-02f, -1.52867436e-02f, -6.34936765e-02f, -3.70901860e-02f, 2.94256173e-02f, -4.52947542e-02f,
  -2.45529320e-02f, 2.91021224e-02f, 1.65570244e-01f, 4.15242426e-02f, 9.14484710e-02f, 1.32611483e-01f, 2.80444413e-01f, 6.57268912e-02f, 1.61454946e-01f, -4.17491198e-02f,
  1.23506889e-03f, 1.03957215e-02f, -1.02459297e-01f, 5.40524684e-02f, 2.62498930e-02f, 1.65757284e-01f, -6.95423335e-02f, -1.10195480e-01f, 7.62419775e-02f, 6.20406307e-02f,
  -5.57509840e-01f, 2.15369478e-01f, 4.87751871e-01f, -4.24351037e-01f, -1.28868550e-01f, -2.78491288e-01f, -4.24084634e-01f, -8.06697756e-02f, -2.63274312e-01f, 1.12411670e-01f,
  -8.67945701e-02f, 8.61792564e-02f, 5.11246882e-02f, -5.25432937e-02f, -5.16983390e-01f, 2.39874616e-01f, -4.03242886e-01f, -1.35771737e-01f, 1.98898628e-01f, -1.87611938e-01f,
  -3.09394896e-02f, -8.77837241e-02f, -2.57566869e-02f, 9.80325118e-02f, -5.79315834e-02f, 6.19602837e-02f, 1.01925842e-01f, 2.71259874e-01f, -1.06145494e-01f, -1.52485624e-01f,
  -1.04819298e-01f, -1.52842358e-01f, 1.65625259e-01f, -5.29350899e-02f, -2.26427186e-02f, -9.80134159e-02f, -4.45771217e-02f, 6.06256798e-02f, -7.61401607e-03f, 7.12095900e-03f,
  -1.56157818e-02f, 2.84029786e-02f, 7.26701692e-02f, 1.17224762e-02f, -1.55200943e-01f, 1.03718072e-01f, -4.59148400e-02f, 5.72820008e-02f, 4.67492379e-02f, 3.70107107e-02f,
  1.81481972e-01f, -4.27048728e-02f, -7.51502020e-03f, 1.97869502e-02f, -1.83145925e-02f, 6.96848426e-03f, 1.13091528e-01f, 4.08048779e-02f, -9.17932913e-02f, -2.85305157e-02f,
  -2.40960382e-02f, 3.81122157e-02f, 1.10306658e-01f, -7.38740265e-02f, -5.12326136e-02f, -1.32416729e-02f, 1.59834847e-01f, -6.95363283e-02f, 1.03029914e-01f, -3.61945778e-02f,
  -1.11096844e-01f, 7.42440224e-02f, -6.99615553e-02f, -1.89702343e-02f, -6.39599785e-02f, -2.74046250e-02f, -2.22472232e-02f, 2.35453770e-02f, -3.42575535e-02f, -7.38115832e-02f,
  4.04535569e-02f, -2.65694819e-02f, 1.36021540e-01f, 5.73878251e-02f, -3.48210372e-02f, 7.57055059e-02f, 9.94905680e-02f, 3.66326086e-02f, -8.06087852e-02f, 2.16187462e-02f,
  -9.82561111e-02f, -9.58755321e-04f, -1.60137890e-03f, -3.87797430e-02f, 7.79556334e-02f, -1.80812813e-02f, 9.19326916e-02f, 7.62703037e-03f, -9.50144455e-02f, -8.16368461e-02f,
  -9.99343395e-02f, -6.10838197e-02f, 1.57511304e-03f, -2.52706057e-04f, 9.54543650e-02f, 4.81278040e-02f, -1.84487239e-01f, 4.59229462e-02f, -6.66552708e-02f, 1.82662476e-02f,
  -3.92475873e-02f, 7.13683739e-02f, 3.63861062e-02f, -6.08774871e-02f, -1.28196955e-01f, -9.99915153e-02f, -2.72658676e-01f, 1.08692653e-01f, 2.61228662e-02f, 1.56062812e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.54562092e-01f, -4.33904499e-01f, 7.05513954e-01f, 1.14406824e-01f, 6.53329134e-01f, 6.26778245e-01f, 8.65326285e-01f, 3.11086565e-01f, 1.00783575e+00f, -9.70388353e-01f,
  -5.41691959e-01f, -5.39374828e-01f, 1.42817900e-01f, -7.34820664e-01f, 9.10945892e-01f, 5.58241844e-01f, 9.39421207e-02f, -1.16009675e-01f, 6.48136020e-01f, -3.23848575e-02f,
  2.08430484e-01f, -4.92482483e-01f, -2.42466107e-02f, -5.54283559e-01f, -2.25139946e-01f, -2.51695186e-01f, -6.20207489e-01f, 1.72831938e-01f, -1.12076330e+00f, -2.91783232e-02f,
  3.84483896e-02f, 1.52238142e-02f, -4.91531268e-02f, -1.25294626e-01f, -5.23544662e-02f, -1.40574962e-01f, -1.56796709e-01f, -1.74165573e-02f, 8.02758709e-02f, 5.53493798e-02f,
  -1.61241397e-01f, -6.56254683e-03f, -1.69274956e-01f, 7.21831545e-02f, 2.20478088e-01f, 1.80427749e-02f, -4.30484768e-03f, -7.74144307e-02f, -1.81338623e-01f, 6.25348836e-02f,
  7.76219144e-02f, 7.72326514e-02f, 2.33361959e-01f, -2.79567987e-01f, 1.64065987e-01f, -4.43506017e-02f, -3.00314487e-03f, -1.72299724e-02f, 3.21003906e-02f, 1.69790890e-02f,
  5.63658141e-02f, 2.55983621e-01f, -1.25797138e-01f, -5.18280081e-02f, 4.06488916e-03f, -5.84600903e-02f, -1.00845158e-01f, -6.73870817e-02f, 1.40755877e-01f, -4.24194150e-02f,
  -6.62404671e-02f, -7.27963448e-02f, 8.51187631e-02f, 8.02656859e-02f, -3.35636102e-02f, 1.96677800e-02f, -7.37981275e-02f, -8.17705989e-02f, 7.74792433e-02f, 9.07916576e-02f,
  1.05889030e-01f, 1.57190606e-01f, 6.64607286e-02f, -1.08478792e-01f, -6.14688769e-02f, 6.43503442e-02f, -1.81158364e-01f, 7.25801364e-02f, 1.06577896e-01f, -1.47624239e-01f,
  1.20961592e-02f, -4.47620273e-01f, -6.24422133e-02f, -3.73804986e-01f, -2.19086111e-01f, -3.00129354e-01f, 1.56036496e-01f, -3.50156203e-02f, 1.59710318e-01f, 1.38778128e-02f,
  -1.34002298e-01f, -1.16775401e-01f, 7.03903846e-03f, -2.63453964e-02f, 2.64383368e-02f, 2.87053622e-02f, -2.00820908e-01f, -9.10819396e-02f, -6.62115887e-02f, -2.31301233e-01f,
  -1.68914601e-01f, -4.09321301e-02f, -4.30370271e-02f, -5.59330285e-02f, -3.15166563e-01f, -1.42972454e-01f, -1.64446712e-01f, -6.78519011e-02f, -7.28463009e-02f, -1.71920639e-02f,
  -1.06752396e+00f, 2.30055422e-01f, -5.46745360e-01f, 3.42264138e-02f, -4.48011428e-01f, -1.04494977e+00f, -3.03500175e-01f, -4.09902662e-01f, -1.14979550e-01f, 5.67893744e-01f,
  1.81580156e-01f, -1.24042206e-01f, 4.91336852e-01f, 3.82222444e-01f, -8.93706977e-01f, 8.99080396e-01f, -5.23786187e-01f, 1.01446182e-01f, -2.17694826e-02f, -5.33547997e-01f,
  -3.53078812e-01f, -2.73189723e-01f, -4.84596789e-02f, -3.16730529e-01f, -4.94062901e-01f, -3.49038541e-01f, 1.15768731e-01f, -2.46015340e-01f, -9.78422090e-02f, -1.27232850e-01f,
  -5.63667178e-01f, -9.98449624e-02f, -2.13936027e-02f, 5.85141294e-02f, -3.01750779e-01f, -2.53954589e-01f, -1.10679701e-01f, 3.35323848e-02f, -2.61796471e-02f, 5.99544905e-02f,
  1.10332847e-01f, -1.51456833e-01f, 5.09093814e-02f, 1.07463591e-01f, -6.79046810e-02f, -1.91396624e-01f, -1.48392068e-02f, -7.10921735e-02f, 1.36690829e-02f, 3.49968411e-02f,
  1.40259014e-02f, 9.09011737e-02f, -9.23395231e-02f, 2.36909479e-01f, 4.96411249e-02f, -1.93989985e-02f, -9.54289883e-02f, -5.03959693e-02f, -3.09289187e-01f, -2.00751379e-01f,
  -6.33055046e-02f, -9.58988443e-03f, -3.86089720e-02f, 1.87479466e-01f, -1.14554971e-01f, 1.97712034e-01f, -1.18510216e-01f, 1.55832812e-01f, -1.27752960e-01f, -7.04751089e-02f,
  -1.24489382e-01f, 4.28977935e-03f, 2.96573117e-02f, -3.25404890e-02f, -8.77440050e-02f, 1.13346025e-01f, -5.65517172e-02f, 3.78140318e-03f, 1.15344012e-02f, -5.11164591e-02f,
  7.26758875e-03f, -5.48321530e-02f, 2.32507989e-01f, 2.12830747e-03f, -1.50507823e-01f, 3.88599113e-02f, 8.70731622e-02f, 2.44722459e-02f, 6.91869780e-02f, -3.07678699e-01f,
  -1.06348598e+00f, -1.06188977e+00f, -9.23740398e-03f, -1.27352595e-01f, -1.03743635e-01f, -1.19466372e-01f, 1.60415933e-01f, -2.27953047e-02f, -2.61078387e-01f, -2.19579443e-01f,
  -6.98736086e-02f, 1.93825722e-01f, -3.38281363e-01f, 3.01713161e-02f, -1.31923109e-01f, -1.79285079e-01f, -5.41065857e-02f, -5.27987629e-02f, -3.08201730e-01f, -1.83704853e-01f,
  -1.14144303e-01f, -1.54572621e-01f, -1.28238657e-02f, -2.21424513e-02f, 2.19906017e-01f, -9.39409137e-02f, -1.96074948e-01f, 1.17256142e-01f, -1.56438097e-01f, -6.66092411e-02f,
  7.29004920e-01f, -4.53302562e-01f, -1.02426827e+00f, 4.82834084e-03f, 5.68203092e-01f, 9.37557161e-01f, 1.92379475e-01f, 1.24815181e-01f, -2.36057952e-01f, 4.34191704e-01f,
  5.23555577e-01f, -9.20267582e-01f, -6.42220616e-01f, 8.82713199e-01f, 1.44461647e-01f, -4.50041920e-01f, 7.12690771e-01f, 2.50436097e-01f, -1.78699538e-01f, 2.51746416e-01f,
  8.47254097e-02f, 1.05222881e+00f, -3.76083642e-01f, 4.34133559e-01f, 6.26236618e-01f, -4.37727481e-01f, 4.27871436e-01f, -4.99052763e-01f, 4.68329340e-01f, 1.66401282e-01f,
  1.45102337e-01f, 3.87434959e-02f, -8.74039233e-02f, -2.31831402e-01f, 7.09175617e-02f, 1.55880317e-01f, -5.80168255e-02f, -2.20111012e-01f, -8.58941749e-02f, -1.03840284e-01f,
  -1.56952098e-01f, -9.62915868e-02f, -4.64813001e-02f, -5.97896911e-02f, 2.32011035e-01f, 9.08435881e-02f, 6.87074335e-03f, -9.76826772e-02f, -2.30278432e-01f, -2.93231271e-02f,
  -2.19451368e-01f, -4.74031381e-02f, 5.79608977e-02f, -1.30439311e-01f, -1.73948675e-01f, -1.63472727e-01f, -5.54435998e-02f, -1.97730869e-01f, 1.77528158e-01f, 5.26999049e-02f,
  9.02547613e-02f, -1.71651002e-02f, -2.80012190e-02f, -4.16967757e-02f, 7.48467818e-02f, 1.10161975e-01f, 1.13718577e-01f, 2.58193891e-02f, -5.14964163e-02f, 5.81905432e-02f,
  -5.54967672e-02f, 2.07036734e-02f, -3.59965041e-02f, 1.35992944e-01f, 1.69394746e-01f, 7.25670308e-02f, -1.00054018e-01f, -5.73915392e-02f, -2.26729527e-01f, 3.84350345e-02f,
  -5.98459039e-04f, -8.48625787e-03f, 1.38469011e-01f, -7.37270787e-02f, -1.65147539e-02f, -1.69366315e-01f, 1.99938849e-01f, -4.81629856e-02f, -1.60714105e-01f, 2.99477037e-02f,
  -6.15993626e-02f, -1.56833023e-01f, -2.44509935e-01f, -1.44024879e-01f, -7.52869397e-02f, 2.47575268e-01f, 3.43721583e-02f, 6.53198957e-02f, -1.10142320e-01f, 1.61346838e-01f,
  5.08589782e-02f, 1.40533375e-04f, 6.99579120e-02f, 2.88331490e-02f, -9.32049081e-02f, 2.38390952e-01f, -8.67072418e-02f, -1.52495429e-01f, 1.66666642e-01f, 2.83772638e-03f,
  1.12253405e-01f, 8.81630108e-02f, 7.00019151e-02f, 3.91422734e-02f, 9.94743407e-02f, -5.59659526e-02f, 7.02364892e-02f, -1.25855282e-01f, 9.75525379e-02f, -1.77691430e-01f,
  -4.67489511e-01f, -1.58069447e-01f, -7.96091914e-01f, -1.90140635e-01f, 3.97371590e-01f, -1.05066788e+00f, -5.47704160e-01f, 1.68209195e-01f, -2.06181780e-01f, 3.84122729e-01f,
  -1.06384724e-01f, -2.65765190e-01f, 4.43573713e-01f, -1.10467768e+00f, -7.25683630e-01f, -5.50109804e-01f, -7.37703383e-01f, -5.66591322e-01f, 1.42867044e-01f, 1.13238730e-01f,
  -1.75582767e-01f, -3.79798189e-02f, -7.01282620e-01f, 5.89974225e-01f, -3.39175731e-01f, 4.52904850e-01f, 1.03036571e+00f, 4.40879047e-01f, -8.52466226e-02f, -1.06292263e-01f,
  -4.59560961e-01f, 2.84703553e-01f, -8.52615237e-02f, -2.27403253e-01f, -1.30537406e-01f, 7.66462982e-02f, -5.71956746e-02f, -7.87769854e-02f, -8.97816792e-02f, -6.62073642e-02f,
  1.23389199e-01f, 1.46023229e-01f, -1.97352692e-01f, 6.74325451e-02f, 1.11571029e-01f, 2.54816525e-02f, -2.76906580e-01f, -1.74986511e-01f, -5.82751967e-02f, -3.61706167e-01f,
  -3.88916790e-01f, -9.28914770e-02f, 1.09309435e-01f, 1.47916675e-01f, 6.99856952e-02f, -2.94913836e-02f, -1.73658401e-01f, -1.72740594e-02f, -7.58758038e-02f, 3.41567351e-03f,
  1.61227509e-01f, 8.35963637e-02f, -3.31324041e-02f, -1.40270859e-01f, -1.60629116e-02f, -4.31556441e-03f, 5.21407761e-02f, 1.36085618e-02f, 1.17242582e-01f, -1.39764756e-01f,
  -2.25681961e-02f, 2.78222933e-02f, 5.25799319e-02f, 2.94607878e-02f, 1.24883316e-01f, 9.40342695e-02f, -2.30189636e-02f, 2.14391407e-02f, -6.95225298e-02f, -2.02468559e-01f,
  2.54562497e-01f, -3.19571234e-02f, 6.49937391e-02f, 1.00091964e-01f, -5.90108708e-02f, 1.37056991e-01f, 1.64878100e-01f, -8.79616067e-02f, 9.05887261e-02f, 2.08103627e-01f,
  8.02776143e-02f, 5.13994098e-01f, 1.03771202e-01f, 8.65926221e-02f, -1.67947486e-02f, -3.31664383e-02f, -2.29850903e-01f, -2.17532456e-01f, 2.59846628e-01f, 3.22553515e-02f,
  1.96412802e-01f, 1.10290334e-01f, 1.42219812e-01f, -1.05779417e-01f, 4.24468331e-02f, -1.30940937e-02f, 3.10803384e-01f, 1.54617041e-01f, 2.69198477e-01f, 2.06239089e-01f,
  4.00349617e-01f, 2.45486528e-01f, 3.31875309e-02f, 6.32544607e-02f, -8.97150394e-03f, 2.41647527e-01f, 1.81841508e-01f, 1.18743982e-02f, 1.57481208e-01f, 3.48411910e-02f,
  -9.45434332e-01f, 7.61191607e-01f, 5.84465742e-01f, -8.60687375e-01f, 2.59274244e-01f, 1.19413979e-01f, -7.24671841e-01f, 6.07673466e-01f, -7.67997026e-01f, 9.20784846e-03f,
  -3.52467000e-01f, -3.28372508e-01f, 1.87529877e-01f, -5.23064673e-01f, -7.93798268e-01f, -5.18337607e-01f, -5.84941268e-01f, -4.16913867e-01f, -3.59439731e-01f, 1.93985149e-01f,
  -2.69862235e-01f, -5.13289511e-01f, 1.71568036e-01f, 4.17900175e-01f, 2.52910644e-01f, 4.84811157e-01f, 7.68756270e-02f, 5.90132952e-01f, 2.03287289e-01f, -1.05784029e-01f,
  -1.11031115e-01f, -1.00649916e-01f, 2.64782012e-01f, 2.00651754e-02f, 2.34019652e-01f, 7.57523254e-02f, -1.22635126e-01f, -1.05439790e-01f, -1.17332963e-02f, -2.65291393e-01f,
  -2.20758066e-01f, -7.58147165e-02f, -3.03992391e-01f, -1.92558151e-02f, 1.67652369e-01f, 7.57615417e-02f, 3.24415378e-02f, 1.59574896e-01f, 7.30069578e-02f, -6.23422377e-02f,
  -1.04352701e-02f, 3.77375372e-02f, 2.47343816e-02f, -7.81452209e-02f, 7.67661110e-02f, -1.97209255e-03f, -1.15584694e-01f, 1.34923235e-01f, -8.90503172e-03f, -1.03472568e-01f,
  -3.93288769e-02f, -2.20395923e-01f, 4.94512841e-02f, 2.68254951e-02f, -2.47127656e-02f, 5.90578578e-02f, -1.96824491e-01f, -6.71444321e-03f, 1.14308894e-02f, 3.34833488e-02f,
  9.50505771e-03f, -6.89042434e-02f, -1.35758206e-01f, -8.77690762e-02f, -8.81369337e-02f, -9.42050144e-02f, 6.99757487e-02f, 2.84795761e-02f, -2.10207656e-01f, 8.36607888e-02f,
  -2.12699026e-01f, 2.73297471e-03f, 8.63642246e-02f, 4.72750142e-02f, -1.15794651e-01f, -9.26912855e-03f, 2.83731725e-02f, 1.88589334e-01f, -2.28771362e-02f, 7.47389123e-02f,
  1.03632316e-01f, 2.79750973e-01f, -3.10486443e-02f, -8.81511942e-02f, -1.63618326e-01f, -3.40877958e-02f, -1.62354141e-01f, 2.30454549e-01f, -1.11735284e-01f, -6.36613965e-02f,
  1.53997421e-01f, 5.72335571e-02f, 9.93661135e-02f, 1.51620042e-02f, -1.65981259e-02f, 8.27665851e-02f, -2.06317052e-01f, -1.26737639e-01f, -2.89781149e-02f, 1.12861060e-01f,
  1.22433685e-01f, -2.17110887e-01f, -1.88224554e-01f, 2.95338291e-03f, -6.49413615e-02f, -1.01735629e-01f, 9.98558849e-02f, -1.42998859e-01f, 3.35927010e-02f, -8.08591321e-02f,
  2.26113692e-01f, -1.84758082e-01f, 2.91556776e-01f, 6.48850501e-01f, -2.52363354e-01f, -5.46372652e-01f, -6.28273964e-01f, -1.99485764e-01f, -6.06526196e-01f, -5.64927101e-01f,
  3.32362065e-03f, 2.40583643e-01f, -3.83026510e-01f, 7.37302601e-01f, 1.25552905e+00f, -2.59949006e-02f, 5.34967780e-01f, 2.87962765e-01f, -1.97761059e-02f, 8.38439465e-02f,
  3.61224204e-01f, 4.67697054e-01f, 7.06941247e-01f, 5.19265771e-01f, 3.31917703e-01f, 4.44923520e-01f, 8.57412279e-01f, 1.97869435e-01f, 8.23761404e-01f, 4.58956331e-01f,
  -2.64037251e-01f, -1.28905594e-01f, -1.56585515e-01f, -8.14967081e-02f, 1.12839984e-02f, -1.85746506e-01f, 2.30991524e-02f, 3.68256480e-01f, 3.41099352e-02f, -6.35870770e-02f,
  4.03927080e-02f, 1.21488452e-01f, 1.04645386e-01f, -1.66164871e-04f, -1.36598527e-01f, -9.29222107e-02f, -4.09300327e-02f, -2.59061575e-01f, -1.54381007e-01f, -1.86997369e-01f,
  -1.28907904e-01f, -3.83927487e-02f, -1.16744787e-01f, 1.20871164e-01f, 1.91017106e-01f, -2.57739812e-01f, -1.95264727e-01f, -9.77707729e-02f, -9.07835960e-02f, -1.32153094e-01f,
  1.15084514e-01f, -1.00031100e-01f, -2.24204540e-01f, -8.42357427e-02f, -6.52483897e-03f, -1.18037924e-01f, 1.10361435e-01f, 5.64856753e-02f, -1.26292378e-01f, -2.48548165e-02f,
  -8.67353100e-03f, 1.41752604e-02f, -1.26104072e-01f, -9.41414312e-02f, 3.91841978e-02f, -1.85912788e-01f, -2.24437937e-02f, 4.83044870e-02f, -1.56531975e-01f, 2.04118248e-02f,
  1.82912759e-02f, 8.82617757e-02f, -1.44389391e-01f, 2.72699706e-02f, -2.50834942e-01f, 5.62912896e-02f, 1.38308540e-01f, 1.27683859e-02f, -7.69452676e-02f, 5.48421256e-02f,
  2.47009069e-01f, 6.54322624e-01f, -3.16139380e-03f, -2.25366116e-01f, -1.09565243e-01f, 5.28257601e-02f, 1.06405959e-01f, 2.02844903e-01f, 3.26002598e-01f, -5.60516976e-02f,
  6.01518415e-02f, -6.07861839e-02f, -1.18816667e-03f, 5.32322079e-02f, 1.63300216e-01f, 7.84017965e-02f, 9.08738151e-02f, 7.84285590e-02f, 2.14482084e-01f, 3.14932942e-01f,
  1.13155365e-01f, -1.83447197e-01f, 2.09365770e-01f, -1.69849843e-01f, 1.58859327e-01f, 5.89540675e-02f, -4.97684591e-02f, -4.34322841e-02f, 2.57951081e-01f, 1.15452483e-01f,
  6.62195146e-01f, 8.92673552e-01f, 7.76501715e-01f, 1.21322346e+00f, -8.26256931e-01f, -5.24997473e-01f, 8.42708200e-02f, 2.01040134e-01f, 9.16034162e-01f, 2.39971429e-01f,
  -7.45676756e-01f, 1.16059148e+00f, -3.87757033e-01f, 3.08617294e-01f, -4.23205703e-01f, -3.21212977e-01f, 6.55817837e-02f, 1.76694021e-01f, 2.30487019e-01f, 3.36934119e-01f,
  1.00132249e-01f, -6.29222929e-01f, -1.99826032e-01f, -3.82930219e-01f, 9.77806300e-02f, 5.88630199e-01f, -4.63406384e-01f, -1.32804736e-01f, 1.44490585e-01f, -3.14879298e-01f,
  -2.94578344e-01f, 3.63401026e-01f, 7.12313280e-02f, 2.65450716e-01f, -1.68250367e-01f, -1.00461237e-01f, 1.18396141e-01f, 1.74174123e-02f, -5.31936698e-02f, 1.16537392e-01f,
  1.01390831e-01f, 1.01197653e-01f, -1.94222443e-02f, 2.09151376e-02f, 2.66296625e-01f, 9.17481855e-02f, 1.34679601e-01f, -5.17751276e-02f, 2.37267837e-01f, 5.51585741e-02f,
  8.14145580e-02f, 1.26443982e-01f, 7.32188970e-02f, 1.50926292e-01f, 3.04575175e-01f, 3.59962732e-02f, 1.50155336e-01f, 5.05572222e-02f, 2.22017661e-01f, 1.72165915e-01f,
  -1.70033365e-01f, 1.60512365e-02f, -7.74728209e-02f, -5.97457290e-02f, 8.23940039e-02f, -7.44196102e-02f, 1.60757199e-01f, -1.92991644e-01f, 1.46939933e-01f, -1.10780075e-01f,
  -1.61161065e-01f, 2.07068160e-01f, 1.57513916e-02f, -6.27956167e-02f, -1.33663341e-01f, 1.79254279e-01f, -9.99349803e-02f, -7.62249157e-02f, 2.18173936e-02f, 2.07898067e-03f,
  3.15496065e-02f, -7.28830695e-02f, 5.86704239e-02f, -1.05493881e-01f, -7.22671598e-02f, 6.82393387e-02f, 8.15000162e-02f, 1.60347581e-01f, -2.78103240e-02f, -2.48404801e-01f,
  -9.19101685e-02f, 5.76323807e-01f, 2.48581506e-02f, 8.02778676e-02f, 1.16302587e-01f, 1.28088221e-02f, -8.08252767e-03f, 3.74381430e-02f, 2.25904822e-01f, -3.85938548e-02f,
  -6.50371239e-02f, 2.62478404e-02f, -3.45764719e-02f, -5.99505119e-02f, -8.68590698e-02f, 1.28378078e-01f, 8.76574218e-02f, 8.58174711e-02f, -1.22074649e-01f, -4.67695594e-02f,
  6.79981038e-02f, 3.28801610e-02f, -1.39548192e-02f, -3.48667502e-02f, -7.98320770e-02f, -1.49302751e-01f, 7.67642781e-02f, 1.62129581e-01f, -1.41562447e-01f, 8.57081264e-03f,
  2.10543275e-01f, -1.08734453e+00f, 3.87388200e-01f, 5.21293998e-01f, 4.53015536e-01f, 1.63637191e-01f, 4.13536489e-01f, -4.95369345e-01f, -4.58420992e-01f, -8.05690944e-01f,
  -1.55815065e-01f, 3.83068472e-01f, -6.29659355e-01f, -2.17291042e-01f, 3.22321430e-02f, -7.10385025e-01f, -2.17556119e-01f, 1.34270648e-02f, -1.88070163e-01f, -1.46661073e-01f,
  9.32782888e-02f, -3.78477603e-01f, 3.21939856e-01f, -3.96684796e-01f, 2.21798584e-01f, 2.84563720e-01f, 1.30974740e-01f, 3.20643812e-01f, 4.38483804e-01f, 2.69662201e-01f,
  -1.13301784e-01f, -1.20090172e-01f, 4.37681898e-02f, -5.89100681e-02f, -1.45675585e-01f, 1.48317143e-01f, 6.13101572e-02f, 3.11133385e-01f, 4.73916501e-01f, 3.15353312e-02f,
  2.85489317e-02f, 1.58380717e-01f, 7.46797845e-02f, 2.24029496e-01f, 4.30072322e-02f, 1.16894409e-01f, 1.65506214e-01f, 1.40112549e-01f, 7.72309154e-02f, 9.70099345e-02f,
  8.69030058e-02f, 1.03673255e-02f, 7.23393410e-02f, 7.62385130e-02f, 9.81002450e-02f, -1.93671393e-03f, 3.21798660e-02f, 5.45013174e-02f, -7.25793317e-02f, 1.38707593e-01f,
  -1.58546627e-01f, 4.77697980e-03f, -1.31919831e-01f, -5.43811508e-02f, 8.77219811e-02f, 1.45672962e-01f, -3.25509310e-02f, 3.77486832e-02f, 2.43091926e-01f, -1.02159686e-01f,
  7.75982291e-02f, 1.45969301e-01f, -1.27833068e-01f, 1.12507127e-01f, 2.80108582e-02f, 3.44486255e-03f, 2.41780505e-01f, 1.31866440e-01f, 7.63798282e-02f, -6.30344376e-02f,
  -2.48501636e-02f, -4.49057557e-02f, -2.00876087e-01f, 1.28634095e-01f, -2.67228365e-01f, 7.53902420e-02f, -3.17751989e-02f, 2.73207892e-02f, 5.29478006e-02f, 1.13645934e-01f,
  -6.91328108e-01f, -9.80354428e-01f, -1.28368020e-01f, 1.69474259e-01f, -4.75219637e-02f, 1.03372090e-01f, -1.65195867e-01f, -1.64105982e-01f, -3.62703234e-01f, -1.49021149e-01f,
  1.79392710e-01f, 2.65259653e-01f, -2.61214018e-01f, 1.70538455e-01f, -3.86789208e-03f, -1.11554615e-01f, -1.42434418e-01f, 3.93018406e-03f, 3.62776481e-02f, -6.78728372e-02f,
  -6.02247491e-02f, 3.99325490e-02f, 8.33791345e-02f, 1.64812937e-01f, 4.17769924e-02f, 2.88125910e-02f, 1.33073805e-02f, 2.17371453e-02f, 5.28427884e-02f, -1.14344202e-01f,
  -2.07785678e+00f, 9.58570421e-01f, 3.09540242e-01f, -2.51418293e-01f, -1.62857156e-02f, 9.35804307e-01f, 6.04675531e-01f, 3.00582886e-01f, 3.77943456e-01f, 6.41969979e-01f,
  1.38777599e-01f, -1.63481310e-01f, 7.53566444e-01f, 4.88752872e-01f, -1.03960223e-01f, 7.40456104e-01f, 1.09079696e-01f, 2.11607546e-01f, 3.48583847e-01f, -1.79415256e-01f,
  -1.85795456e-01f, 3.13578218e-01f, -1.86246961e-01f, 5.24889350e-01f, -3.15627068e-01f, -3.68723482e-01f, -5.37103713e-01f, 2.68047303e-01f, -3.06076944e-01f, 2.31186792e-01f,
  -6.45388484e-01f, -7.52287060e-02f, -4.43461180e-01f, -6.42518699e-02f, -3.04041892e-01f, -1.04687966e-01f, -1.14057772e-01f, 2.05034196e-01f, -6.32810816e-02f, 1.28061986e-02f,
  -7.70710707e-02f, 6.28616810e-02f, 5.55446520e-02f, 1.28438873e-02f, 3.89581397e-02f, -6.53298423e-02f, 2.34444067e-02f, -1.25029728e-01f, 1.31801873e-01f, -1.53676867e-01f,
  7.02820346e-02f, -1.14440158e-01f, -2.03143731e-01f, 1.02558188e-01f, -1.29754901e-01f, 1.73282415e-01f, 4.11675647e-02f, -1.68925658e-01f, -1.98301777e-01f, 3.02445702e-02f,
  9.34559759e-03f, 7.14206100e-02f, 2.58996859e-02f, -1.30426899e-01f, 1.50709406e-01f, -5.56583479e-02f, -1.36456238e-02f, -3.37403901e-02f, -3.98996212e-02f, -1.11173756e-01f,
  -1.07550107e-01f, -2.08706737e-01f, 1.31230941e-03f, 5.69463475e-03f, -4.39031795e-02f, -3.13324220e-02f, 2.25366466e-02f, -3.34306657e-02f, -2.61652600e-02f, -1.93492740e-01f,
  1.76096812e-01f, 8.05832818e-02f, -4.01194766e-03f, -1.96488678e-01f, 2.69273445e-02f, 3.97551544e-02f, -1.41094727e-02f, -5.85034490e-03f, 5.49090989e-02f, -3.15672569e-02f,
  1.52007933e-03f, 8.12932625e-02f, 1.12203717e-01f, -9.55620334e-02f, 4.54441309e-02f, 6.61198050e-02f, -6.44634943e-03f, -3.49023670e-01f, 2.37392470e-01f, 2.60457508e-02f,
  -3.87082435e-02f, -8.24501440e-02f, -2.90429950e-01f, 4.32353467e-02f, 1.90899745e-01f, 2.16044202e-01f, 7.75984116e-03f, 3.61599624e-02f, -9.52480510e-02f, -8.49646982e-03f,
  -3.02933335e-01f, 1.52589574e-01f, 9.28625539e-02f, -6.10765396e-03f, -8.78059492e-02f, -2.28337497e-01f, -1.36392266e-01f, 4.04972620e-02f, 6.68665394e-02f, 2.64025517e-02f,
  1.53125077e-01f, -3.58331472e-01f, -8.17519519e-03f, -6.45571351e-01f, -3.08668494e-01f, -7.76928142e-02f, 2.60433733e-01f, -5.88983297e-01f, -8.28303337e-01f, -2.08859190e-01f,
  -5.23986220e-01f, 6.35302365e-01f, 7.02724397e-01f, -8.28732252e-01f, 1.13362885e+00f, 5.23821592e-01f, -6.79288507e-01f, -8.82555395e-02f, -4.31185901e-01f, -5.56801498e-01f,
  -1.91283152e-01f, -5.99520981e-01f, 2.17091531e-01f, -5.08097470e-01f, -4.77899224e-01f, -4.84971404e-01f, -6.68166345e-03f, 1.33029282e-01f, -6.32393003e-01f, 8.53454992e-02f,
  -2.36431524e-01f, 5.63193336e-02f, -3.92715782e-02f, 2.02275291e-01f, -1.39294162e-01f, 1.90376252e-01f, -5.96366357e-03f, 4.12854284e-01f, -3.41618359e-02f, -4.74618636e-02f,
  2.98487425e-01f, 2.65546679e-01f, -2.31181517e-01f, 3.75915676e-01f, -2.89626271e-01f, -1.89587250e-01f, -7.73173347e-02f, -2.32047573e-01f, -1.98830329e-02f, 4.26269323e-02f,
  -2.48316266e-02f, -2.03564376e-01f, -2.61389881e-01f, -9.79775712e-02f, -3.25292498e-02f, -3.46214861e-01f, 2.65944630e-01f, 3.27234864e-01f, 2.36397572e-02f, -9.83244628e-02f,
  -1.66006982e-01f, 5.96974418e-02f, 9.36551616e-02f, -1.27096837e-02f, 2.10308939e-01f, -1.14486396e-01f, 1.25594258e-01f, -2.31378376e-02f, -4.00827080e-02f, 1.35017410e-01f,
  -1.21337891e-01f, 1.13527626e-01f, 1.89485326e-02f, 2.17272528e-02f, -1.69186503e-01f, 2.14706082e-03f, 1.46328926e-01f, -1.11447861e-02f, -2.79413402e-01f, -5.14417738e-02f,
  -3.49710248e-02f, -6.96885260e-03f, 1.06392011e-01f, -4.99730706e-02f, -4.89633344e-02f, 1.43247277e-01f, -4.04611416e-02f, 1.26926005e-01f, -1.72404304e-01f, 1.41657263e-01f,
  -2.52160609e-01f, 1.53560936e-01f, -9.07284692e-02f, 5.58358878e-02f, 5.47189936e-02f, -3.21227573e-02f, 3.83633934e-02f, -1.96638599e-01f, -1.43410861e-01f, 7.41340965e-02f,
  -3.12491089e-01f, 4.65513580e-02f, -1.12762727e-01f, -1.82762057e-01f, -1.66440625e-02f, -3.12754244e-01f, 4.11527306e-02f, 3.68858576e-02f, -4.75205407e-02f, -2.19641611e-01f,
  3.55162099e-02f, 1.37890130e-01f, 1.58331707e-01f, -9.93659198e-02f, 6.44974858e-02f, 2.03806803e-01f, 7.98909441e-02f, 9.19968411e-02f, 1.77756518e-01f, -1.26438513e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  1.32862806e+00f, 1.67197868e-01f, 1.05016172e+00f, 8.11906755e-01f, 1.76881051e+00f, 6.31712377e-01f, 1.08659685e+00f, 1.31285644e+00f, 1.18264735e+00f, 8.29006732e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  6.09694272e-02f, -5.91159225e-01f, 1.02563381e+00f, -1.46778417e+00f, 1.48915625e+00f, 3.74172896e-01f, -1.50790560e+00f, 1.31854010e+00f, 3.90567750e-01f, -1.23153436e+00f,
  -5.76538682e-01f, -9.28893209e-01f, -8.70933354e-01f, -6.03144050e-01f, 7.03692853e-01f, -6.47136569e-01f, -1.23811948e+00f, 4.99396980e-01f, -9.69113648e-01f, -8.74481380e-01f,
  -1.16319668e+00f, -9.64767575e-01f, -9.46839035e-01f, -8.72136831e-01f, 1.39381206e+00f, -3.01807344e-01f, -5.95283747e-01f, 5.52691631e-02f, -1.12269485e+00f, -1.63801610e+00f,
  1.10475972e-01f, 9.09353271e-02f, 4.97611374e-01f, -6.61487356e-02f, -3.33242744e-01f, 1.27914846e+00f, -3.83388065e-02f, 4.42479432e-01f, -1.14545858e+00f, -4.86134112e-01f,
  5.43944478e-01f, -7.46451855e-01f, -6.05845749e-01f, 5.68475783e-01f, -1.13454008e+00f, 1.13268125e+00f, -1.15663123e+00f, -1.00890326e+00f, -1.26312733e-01f, -4.45885807e-02f,
  -1.06084514e+00f, -1.33045033e-01f, -8.94267857e-01f, -4.42690194e-01f, -1.11892653e+00f, 7.32161820e-01f, -1.40450895e+00f, 7.42167354e-01f, 4.99929786e-01f, -8.71967554e-01f,
  9.90120843e-02f, -1.19821107e+00f, 3.87021273e-01f, -3.32206070e-01f, 2.07434103e-01f, 5.38363397e-01f, -2.37555698e-01f, 1.48900700e+00f, 1.08350444e+00f, 1.46674240e+00f,
  1.23331562e-01f, -3.02596360e-01f, -6.66856527e-01f, -1.66445482e+00f, 1.08657789e+00f, -3.62357259e-01f, -5.38656414e-01f, -2.57658690e-01f, 7.38656938e-01f, 1.28882930e-01f,
  5.17830253e-01f, 3.97826493e-01f, 1.93842575e-01f, -1.42848730e+00f, -1.12397635e+00f, -1.40930605e+00f, 3.44090670e-01f, -1.03472400e+00f, -9.41377223e-01f, -6.72857583e-01f,
  -1.58726001e+00f, -4.74828109e-02f, 9.23331380e-01f, -1.29500151e+00f, 9.45275962e-01f, 4.60524768e-01f, 3.18287760e-01f, 3.96541208e-02f, -4.48360920e-01f, 4.00487423e-01f,
  -1.34921765e+00f, -8.32719147e-01f, 1.20801163e+00f, -3.62785846e-01f, 3.55130643e-01f, 1.14136733e-01f, -5.90088785e-01f, -1.29058719e+00f, -1.19285686e-02f, 6.14458978e-01f,
  -1.78882444e+00f, -1.47985697e+00f, -7.00159371e-01f, -2.43369460e-01f, 6.94365725e-02f, 4.84696925e-01f, 3.27912956e-01f, 5.96013248e-01f, 3.16907793e-01f, 8.73101711e-01f,
  -9.38507020e-01f, 6.24640048e-01f, -9.77627695e-01f, -9.45968255e-02f, -2.36275494e-01f, -8.34404349e-01f, -8.91200662e-01f, 7.25708187e-01f, -6.66192293e-01f, -4.22523737e-01f,
  5.41206002e-01f, -3.87101889e-01f, 2.98897266e-01f, 5.07587232e-02f, -8.18199992e-01f, -6.22790635e-01f, -5.23355901e-01f, 2.25534290e-01f, 1.73921779e-01f, 1.10826647e+00f,
  5.10733664e-01f, -5.43096304e-01f, -9.12313938e-01f, -9.95571971e-01f, 1.72460541e-01f, -2.25286648e-01f, 3.73412937e-01f, 1.16092518e-01f, 1.34352553e+00f, -2.02290580e-01f,
  6.68309271e-01f, -8.49110782e-01f, -8.48674655e-01f, -1.04316664e+00f, -1.26230001e+00f, 3.82052106e-03f, -1.32579482e+00f, 8.94248188e-01f, -5.41695774e-01f, 9.16992128e-01f,
  3.14936966e-01f, 3.34803522e-01f, 6.74856484e-01f, 4.42223996e-01f, 6.88902378e-01f, 6.84641361e-01f, -9.32127833e-01f, -8.59012306e-01f, 1.53633565e-01f, 1.09388125e+00f,
  7.97752917e-01f, -9.54612255e-01f, -7.10373223e-01f, 2.20392495e-01f, -1.41917717e+00f, -9.26207721e-01f, 3.24014306e-01f, -3.18942279e-01f, 4.73328829e-02f, 3.31645668e-01f,
  -4.68138814e-01f, 9.97110009e-01f, -6.65607393e-01f, 2.86500633e-01f, -9.28566515e-01f, -9.91935432e-01f, 7.35999703e-01f, -9.12222385e-01f, 1.32609200e+00f, 5.18942952e-01f,
  -8.59786749e-01f, -5.62267661e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  5.40464699e-01f, 3.42183739e-01f, -3.82515639e-01f, -7.19126940e-01f, 3.46486360e-01f, 3.46568227e-01f, 2.72947937e-01f, -4.54160929e-01f, -2.63735086e-01f, -6.86613917e-02f,
  -1.44743681e-01f, -5.15734889e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    