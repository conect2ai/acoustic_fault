/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.90696120e-01f, -4.96987253e-02f, -1.07401036e-01f, -2.75084853e-01f, -2.63441596e-02f, 3.22623760e-01f, 3.50529015e-01f, 5.33475447e-03f, -1.05043285e-01f, 3.86346519e-01f,
  2.39319563e-01f, 1.29461465e-02f, 3.38172615e-01f, -2.77495682e-02f, -6.58438280e-02f, 1.46823943e-01f, -1.00820310e-01f, 5.80715463e-02f, -2.34935014e-03f, -8.48858580e-02f,
  -2.10313514e-01f, 9.17736813e-02f, -1.21871628e-01f, -5.11788167e-02f, -3.87035199e-02f, -1.08126588e-01f, -5.45775630e-02f, 2.34305169e-02f, -5.72011024e-02f, -2.49725720e-03f,
  5.85705750e-02f, 8.61980319e-02f, -8.77102837e-02f, 5.36751822e-02f, -3.91687006e-02f, 2.28473432e-02f, -4.41058949e-02f, 1.87371224e-02f, 3.79424393e-02f, 5.20889722e-02f,
  2.75108889e-02f, -1.40867075e-02f, -3.68821137e-02f, -2.63409186e-02f, 2.64992025e-02f, -6.74728230e-02f, -4.39693294e-02f, -1.72778759e-02f, 2.60727629e-02f, 6.08411543e-02f,
  -7.14688972e-02f, 9.98908281e-03f, 1.60237439e-02f, 3.87326851e-02f, -2.26446670e-02f, -2.31240559e-02f, 3.32184359e-02f, -2.10141931e-02f, -7.46363625e-02f, -9.59504247e-02f,
  1.63281895e-02f, 1.47514641e-02f, -8.77502561e-02f, -5.44978480e-04f, -7.87309855e-02f, 2.58961432e-02f, 3.38157490e-02f, -5.34278117e-02f, -1.73470065e-01f, 1.96306296e-02f,
  -4.13781479e-02f, -7.61983320e-02f, -4.56196964e-02f, -1.40824309e-02f, 4.89343069e-02f, 9.67753213e-03f, -4.06443141e-02f, 4.99350466e-02f, -2.74488423e-02f, -4.30243723e-02f,
  -2.56272145e-02f, -3.70373353e-02f, -3.76718566e-02f, 7.83179551e-02f, 8.73533357e-03f, 7.21351616e-03f, -3.00834682e-02f, 2.04661582e-03f, 2.00813711e-02f, -1.76531672e-02f,
  1.86934888e-01f, -1.38704702e-01f, 8.54147896e-02f, 6.48839446e-03f, 3.82573204e-03f, -7.31730163e-02f, -1.63886715e-02f, -6.65438101e-02f, -2.61042360e-02f, -1.67219937e-02f,
  -4.27334681e-02f, 6.07160181e-02f, -2.38549020e-02f, 4.70166877e-02f, 1.84842944e-02f, -2.37789527e-02f, 8.83683339e-02f, -4.83138822e-02f, 3.62334810e-02f, 1.08084269e-02f,
  -9.14179999e-03f, 6.35785833e-02f, 3.02892961e-02f, -1.21994153e-01f, 1.00624137e-01f, 5.58467247e-02f, -5.26192486e-02f, -4.47713174e-02f, 3.72436903e-02f, 1.31430328e-02f,
  2.19265342e-01f, -2.61139959e-01f, 2.56780554e-02f, 4.08800125e-01f, -6.05153888e-02f, -1.60506263e-01f, -1.02734342e-01f, 1.86854869e-01f, 1.24066606e-01f, -4.40482460e-02f,
  2.41885960e-01f, -2.51262665e-01f, 7.51022100e-02f, 3.53293329e-01f, 2.97629148e-01f, -3.70370061e-03f, 3.71550351e-01f, -1.71876084e-02f, 1.59275800e-01f, 9.38780233e-02f,
  1.41255394e-01f, 2.01281697e-01f, 1.31241471e-01f, 9.40212086e-02f, -4.08899412e-02f, -1.48741052e-01f, 9.92050767e-02f, -3.61080430e-02f, 8.80245939e-02f, -2.13986889e-01f,
  5.61952256e-02f, -4.71034795e-02f, -2.22755726e-02f, -1.98312879e-01f, -1.02407467e-02f, -1.09723836e-01f, -6.96020275e-02f, -1.62285700e-01f, 2.75721475e-02f, -4.64748405e-02f,
  -1.30584575e-02f, 1.58376582e-02f, -4.10302123e-03f, 4.64503914e-02f, 2.11301427e-02f, 2.69855130e-02f, -7.54994573e-03f, 1.04572691e-01f, 2.05347836e-02f, 1.34863779e-02f,
  -7.83165023e-02f, -5.88880340e-03f, 2.51123495e-02f, -4.16392535e-02f, -1.58349387e-02f, 7.64245465e-02f, -4.88721533e-03f, -6.32896498e-02f, -4.95317839e-02f, -1.24726854e-02f,
  -1.66534424e-01f, 3.48092280e-02f, 2.80946251e-02f, 3.87285352e-02f, 3.16142775e-02f, 1.43799148e-02f, 8.65025222e-02f, 2.48196069e-02f, 2.98112314e-02f, 5.77342398e-02f,
  7.73371011e-02f, 8.71108100e-03f, 5.42387739e-03f, -7.20365532e-03f, 9.56184417e-02f, -6.38073757e-02f, 6.00511162e-03f, -8.41006115e-02f, 8.06860104e-02f, -4.29263338e-02f,
  6.54235259e-02f, -2.86179297e-02f, -2.36108173e-02f, 4.73704375e-03f, 4.55934405e-02f, 4.04663123e-02f, 6.31047115e-02f, 5.04115783e-03f, 7.30487034e-02f, -9.97176841e-02f,
  -1.29290566e-01f, -4.59350310e-02f, 7.45462328e-02f, -2.49845982e-02f, 1.46846473e-03f, 1.16829261e-01f, 1.96196348e-03f, -4.22794186e-02f, -8.33674222e-02f, -4.71551642e-02f,
  -6.04205579e-02f, 8.27184971e-03f, -9.67062339e-02f, -1.74929667e-02f, 8.26269090e-02f, -7.66207511e-03f, 1.40314968e-02f, 3.25409882e-02f, 8.20871722e-03f, 1.38439506e-01f,
  -1.07327355e-02f, -4.79776636e-02f, 7.60356430e-03f, -3.98853049e-02f, 4.16231379e-02f, -6.05873652e-02f, -3.06639094e-02f, -1.29908770e-02f, -3.84054147e-02f, 1.18280817e-02f,
  -9.37173292e-02f, 1.11099765e-01f, -3.24571311e-01f, 1.78469345e-02f, -3.24227363e-01f, 4.31684591e-02f, -1.44333497e-01f, 5.71805872e-02f, -3.89656514e-01f, 3.55759621e-01f,
  1.81338251e-01f, -2.44221896e-01f, 1.66157246e-01f, 2.44252235e-01f, -2.68935293e-01f, 1.21628843e-01f, 1.21201508e-01f, 9.52108111e-03f, -1.83698416e-01f, 4.68421029e-03f,
  -3.42128761e-02f, 2.67952025e-01f, -2.99816695e-03f, 1.64389223e-01f, 1.06346108e-01f, -4.72817905e-02f, 1.50309369e-01f, -1.44483507e-01f, 2.51573145e-01f, -7.97214359e-02f,
  1.41228754e-02f, 2.52886824e-02f, -4.10481915e-02f, -5.53971492e-02f, 8.67581367e-02f, -3.32534686e-02f, 1.68361925e-02f, -1.06224552e-01f, -1.27793923e-01f, -5.86020388e-03f,
  1.37281762e-02f, -3.67923900e-02f, 6.82419762e-02f, -4.24957387e-02f, -4.47167046e-02f, 2.16102675e-02f, -5.45731671e-02f, 1.53792407e-02f, -4.71992977e-02f, -1.00043580e-01f,
  3.14045064e-02f, 9.75015201e-03f, 7.93836266e-02f, -1.78145710e-02f, -8.32232386e-02f, -5.33887967e-02f, 5.87861389e-02f, 1.92118194e-02f, 4.15570242e-03f, -7.71087706e-02f,
  2.00991631e-02f, -5.99143989e-02f, -7.13561103e-03f, 5.44531718e-02f, 3.19525860e-02f, 2.58724447e-02f, 2.47319564e-02f, 6.11314513e-02f, -5.15337959e-02f, 3.43256705e-02f,
  2.29952838e-02f, -6.96540326e-02f, -4.85503301e-02f, -4.35732119e-02f, 9.00533646e-02f, -1.54057879e-03f, -3.82302999e-02f, 2.82796696e-02f, -3.49248387e-02f, -2.94867288e-02f,
  2.90079098e-02f, -3.54713537e-02f, 2.06321031e-02f, 2.93132346e-02f, 6.61794245e-02f, -4.31567505e-02f, 4.58355136e-02f, 2.26904470e-02f, -8.85800719e-02f, -5.56960097e-03f,
  2.70770658e-02f, 1.73742920e-01f, -3.81995291e-02f, -4.91828322e-02f, -2.37371717e-02f, 7.19688162e-02f, -1.01142423e-02f, 3.50808874e-02f, 1.05371319e-01f, 8.46721232e-02f,
  -5.03714383e-02f, 3.28084417e-02f, -1.15406243e-02f, 6.39250036e-03f, -7.08310008e-02f, 5.52100502e-02f, -7.79935159e-03f, 2.51248050e-02f, 4.52340767e-02f, 2.75899747e-05f,
  1.03619270e-01f, 2.50278525e-02f, 2.25289259e-03f, 5.42839952e-02f, 9.55878794e-02f, 8.45236704e-02f, -1.17815956e-02f, -1.21765994e-01f, -7.73618296e-02f, -6.06094524e-02f,
  2.88929671e-01f, -3.16893756e-01f, -2.56447613e-01f, -2.20686793e-02f, 3.31745654e-01f, 2.96640694e-01f, 2.39058763e-01f, 3.30008045e-02f, -8.38370845e-02f, -9.84167010e-02f,
  3.73818260e-03f, -1.54103398e-01f, -4.89833020e-02f, -1.48356944e-01f, 6.19499385e-02f, -2.58877188e-01f, 3.31319645e-02f, 9.17217731e-02f, -6.78670872e-03f, 1.61311775e-02f,
  -4.21383244e-04f, 1.18154041e-01f, -1.69012114e-01f, -1.81561168e-02f, 6.90422626e-03f, -1.04688093e-01f, -5.53413518e-02f, -1.55664712e-01f, -4.98526655e-02f, 1.31266834e-02f,
  7.58597441e-03f, -9.75572243e-02f, -9.43674445e-02f, -9.93306488e-02f, -1.53898010e-02f, 3.53660174e-02f, 2.31595393e-02f, 2.64270864e-02f, 6.78004790e-03f, -1.70443871e-03f,
  -2.78972741e-02f, 1.84549962e-03f, -6.10833667e-05f, -5.68492189e-02f, 9.33304206e-02f, -1.57711972e-02f, 5.87645844e-02f, 2.88594514e-04f, -9.55517367e-02f, -4.21185009e-02f,
  -4.28449064e-02f, -1.85952280e-02f, 4.29714620e-02f, -6.56950772e-02f, -6.03206754e-02f, -4.05169465e-02f, -9.03618336e-03f, -2.26240009e-02f, 8.48969668e-02f, 2.22048946e-02f,
  1.23576457e-02f, 6.09219540e-03f, -1.96666904e-02f, -2.60313805e-02f, -3.28853354e-03f, 2.98500918e-02f, 5.37244417e-02f, 2.48129643e-03f, -2.24761162e-02f, 3.04954071e-02f,
  3.16768736e-02f, 4.18729708e-02f, 3.73762213e-02f, 1.13546304e-01f, 7.53916726e-02f, 9.10782721e-03f, 7.80450925e-02f, 2.78183352e-02f, 4.42645214e-02f, 3.93523648e-02f,
  -2.32515242e-02f, 4.75026444e-02f, -4.35721390e-02f, 8.63944665e-02f, -9.97303892e-03f, 2.93245260e-02f, -6.55338913e-02f, -4.16534245e-02f, 2.09259018e-02f, 8.02390799e-02f,
  -1.21739119e-01f, -2.17014641e-01f, -5.24954274e-02f, 5.47302403e-02f, -4.48274091e-02f, -2.25340724e-02f, -3.41571309e-02f, 7.19822273e-02f, 1.46351866e-02f, 6.17000880e-03f,
  6.15571328e-02f, 6.56958595e-02f, 4.39342558e-02f, 9.15825665e-02f, -2.77283676e-02f, 2.34393664e-02f, -3.52469273e-02f, -2.54899058e-02f, 7.92173296e-02f, 1.21050626e-02f,
  7.20115080e-02f, 1.41024873e-01f, 3.17857191e-02f, 9.42336246e-02f, 2.45317947e-02f, -2.41511017e-02f, 2.30754204e-02f, -1.70556884e-02f, -3.55617050e-03f, -3.02565265e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.08208060e+00f, 5.01331151e-01f, -1.03838384e-01f, -4.16009009e-01f, 1.26328468e-01f, -3.89578670e-01f, -2.13486090e-01f, 7.82907009e-02f, -4.10097033e-01f, -9.38652828e-03f,
  -4.80680391e-02f, -2.41582826e-01f, 2.90354371e-01f, 7.60150477e-02f, -2.34026507e-01f, 2.17980787e-01f, -2.97707021e-01f, -3.72403860e-01f, 1.97290778e-01f, -4.81838100e-02f,
  -3.72719355e-02f, 1.87478527e-01f, -1.13128133e-01f, 3.46378237e-01f, -1.12832807e-01f, -8.27421714e-03f, -1.88053399e-01f, 2.24356309e-01f, -1.59143195e-01f, 9.82687697e-02f,
  -2.41826862e-01f, -2.31443703e-01f, -6.01383895e-02f, -1.81341067e-01f, -1.80233166e-01f, -1.96677327e-01f, -2.43073761e-01f, -1.92542523e-02f, 1.58175528e-01f, 1.30767915e-02f,
  -2.92578544e-02f, 2.32482539e-03f, 9.67288762e-02f, 1.13549180e-01f, -5.85271884e-03f, -4.46732081e-02f, 5.55746108e-02f, -1.14445224e-01f, 5.06636091e-02f, 1.45166531e-01f,
  1.06946662e-01f, 7.05346372e-03f, -2.16906056e-01f, -5.97730428e-02f, -1.77334610e-03f, -7.00194687e-02f, -1.32722870e-01f, 6.87756315e-02f, -1.58802897e-01f, -7.74054080e-02f,
  -3.77907902e-02f, -1.76428661e-01f, 6.59016222e-02f, -6.43024668e-02f, 6.05254583e-02f, 3.30780521e-02f, 9.72172543e-02f, 8.18971265e-03f, 8.94949492e-03f, -1.92571301e-02f,
  -1.34174287e-01f, 1.29135758e-01f, 1.16512060e-01f, -1.17917068e-01f, 4.90471534e-02f, -1.60382316e-01f, 8.92824121e-03f, -4.47510257e-02f, -9.46250632e-02f, 9.99531373e-02f,
  -1.20237462e-01f, 4.66241781e-03f, -3.25774886e-02f, -8.92620236e-02f, 3.12466938e-02f, 5.52267954e-02f, -1.77307706e-02f, -1.13447219e-01f, -7.68151060e-02f, -1.76656786e-02f,
  -4.33119833e-01f, -4.43289846e-01f, -9.37236622e-02f, -5.28087420e-03f, -1.19079620e-01f, 3.17238234e-02f, 5.23970760e-02f, 1.15216961e-02f, -1.69859812e-01f, 2.56610401e-02f,
  -9.45812538e-02f, -9.12673697e-02f, -1.16134167e-01f, 5.98884746e-02f, 5.15195057e-02f, -1.82903633e-02f, -2.63869222e-02f, -1.12003371e-01f, -9.69145671e-02f, 4.77918312e-02f,
  -1.42917886e-01f, 3.40641622e-04f, 7.42208883e-02f, 1.26726588e-03f, -7.14126900e-02f, -1.55171752e-01f, -1.26214996e-02f, -2.11826898e-02f, 6.59295768e-02f, -1.34020783e-02f,
  1.04504555e-01f, -1.52754895e-02f, -5.19687891e-01f, 1.14036154e-03f, 6.34708777e-02f, 6.78248107e-02f, -2.22565532e-01f, 1.59843877e-01f, -4.39822942e-01f, 1.90031543e-01f,
  2.12126538e-01f, -2.05708101e-01f, -2.60263801e-01f, 4.59042758e-01f, 3.41302514e-01f, -3.67934495e-01f, 4.59078401e-01f, 1.08867459e-01f, -2.74776340e-01f, 3.41427088e-01f,
  1.56872153e-01f, 6.78038418e-01f, 8.88556689e-02f, 5.47339618e-01f, 1.17542028e-01f, 7.63729289e-02f, 5.54599643e-01f, -4.92248461e-02f, 4.43689048e-01f, 2.08698824e-01f,
  -9.48672555e-03f, -7.44277760e-02f, -2.70537436e-02f, -5.74208274e-02f, 1.92573205e-01f, 1.68104306e-01f, 2.12858617e-02f, 6.78352267e-02f, -1.47139460e-01f, -1.09273471e-01f,
  -5.30448817e-02f, 4.58827335e-03f, 5.14211878e-02f, -2.11365856e-02f, -1.66706555e-02f, -3.52655351e-02f, -1.15334600e-01f, -1.75769135e-01f, -9.25360546e-02f, -5.74482568e-02f,
  -1.88686058e-01f, -1.64719358e-01f, -8.63959491e-02f, -7.44738132e-02f, -1.53983667e-01f, -2.44567953e-02f, -1.07161298e-01f, -1.46323135e-02f, -1.91146508e-01f, 8.91202092e-02f,
  1.76891774e-01f, -3.93700041e-02f, -7.10656568e-02f, 2.72769574e-02f, -1.82244871e-02f, -5.05940169e-02f, -1.06465630e-02f, 9.66472402e-02f, -2.07915413e-03f, 2.60728579e-02f,
  6.63343410e-04f, 3.92746814e-02f, 2.36015990e-02f, 9.58515555e-02f, 4.25938107e-02f, -8.73743445e-02f, -2.35829484e-02f, 1.17996261e-01f, 2.79214121e-02f, 1.17139943e-01f,
  -2.73167398e-02f, -4.12905775e-02f, 1.12568401e-02f, -5.49883582e-02f, -5.10113202e-02f, -1.82873216e-02f, -6.88813161e-03f, 5.09708971e-02f, -7.71667287e-02f, 5.74597493e-02f,
  1.46677226e-01f, 3.67629290e-01f, -2.69894656e-02f, -1.37194380e-01f, 4.12458666e-02f, 2.40498751e-01f, -5.76215610e-03f, 1.03373401e-01f, 6.96426630e-02f, -6.30204286e-03f,
  1.46973774e-01f, -2.79662199e-02f, 1.20067419e-02f, 6.23651221e-03f, 1.10077709e-01f, 2.84292772e-02f, 7.20603615e-02f, -5.06522076e-04f, 8.85015056e-02f, 1.01099573e-01f,
  4.19470929e-02f, -1.47075513e-02f, -3.16891521e-02f, -1.59421042e-02f, -5.48314564e-02f, 2.06168555e-02f, 1.12023607e-01f, 4.83886637e-02f, 1.15358412e-01f, 1.46707855e-02f,
  -2.40760863e-01f, 1.53784350e-01f, -5.35442054e-01f, -2.31528327e-01f, -5.59414029e-01f, -7.21563250e-02f, -3.05549443e-01f, -6.55579492e-02f, -5.74922785e-02f, 1.70017391e-01f,
  -3.79009217e-01f, 3.32969874e-02f, 3.42071980e-01f, 7.12220045e-03f, 1.76843911e-01f, 4.41299081e-01f, -1.86025336e-01f, 4.93185930e-02f, 1.07943401e-01f, -4.26098891e-02f,
  -7.21460627e-03f, -1.19612098e-01f, 1.70164526e-01f, -1.25953943e-01f, -2.61499643e-01f, -2.02612966e-01f, 8.24843273e-02f, -4.66263115e-01f, -2.38019690e-01f, -2.54876047e-01f,
  -2.64972776e-01f, -4.67603832e-01f, -2.84564584e-01f, 7.53833912e-03f, -1.02678791e-01f, 3.55385877e-02f, -1.48562908e-01f, -2.61194892e-02f, -1.41314834e-01f, -1.09145436e-02f,
  1.79557186e-02f, -2.27466878e-02f, 1.00817934e-01f, -1.49353174e-02f, -2.72393860e-02f, -9.24645215e-02f, 7.52748623e-02f, -7.56381229e-02f, -4.52837124e-02f, -1.60152279e-02f,
  9.53080431e-02f, -5.89258485e-02f, -8.25345367e-02f, 1.24416344e-01f, -6.35815337e-02f, -8.55129808e-02f, 4.11628187e-02f, -1.56797189e-02f, -3.37087587e-02f, -1.56828295e-02f,
  5.35147972e-02f, -5.86052202e-02f, -8.53350163e-02f, -1.14940755e-01f, 3.87706831e-02f, 4.51744273e-02f, -4.72926274e-02f, 1.51064675e-02f, 6.95197508e-02f, -4.69743386e-02f,
  -6.87346831e-02f, 9.33474004e-02f, 1.59097508e-01f, 1.86693609e-01f, 5.19157611e-02f, -6.15004003e-02f, 6.43060058e-02f, -7.75401434e-03f, -7.01159462e-02f, 5.03339209e-02f,
  5.09217791e-02f, 7.56860077e-02f, 5.61277680e-02f, 5.35792820e-02f, -1.34746939e-01f, 1.27561301e-01f, 1.36626326e-02f, 4.92534041e-02f, -4.41454723e-02f, 6.71899840e-02f,
  -1.58172861e-01f, -3.11834127e-01f, -6.35412857e-02f, -8.70117620e-02f, 7.41837248e-02f, 2.93607321e-02f, 6.85953051e-02f, -5.31445853e-02f, -9.99336988e-02f, -1.11798353e-01f,
  -8.24808627e-02f, 4.08970658e-03f, -6.44734576e-02f, -1.10528514e-01f, 1.14360467e-01f, 1.76652119e-01f, -1.45451978e-01f, -2.42612734e-02f, -7.42240027e-02f, -1.91378836e-02f,
  4.36853804e-02f, -7.30810240e-02f, 1.23044081e-01f, 9.30755883e-02f, 1.67665146e-02f, -1.24475919e-02f, -1.69715058e-04f, -3.25589180e-02f, -1.53762594e-01f, -1.00790644e-02f,
  -1.03431177e+00f, 4.64725614e-01f, 6.24048829e-01f, -2.52960548e-02f, 2.82387882e-01f, 8.66563857e-01f, 7.15335906e-01f, 3.04009169e-01f, 3.87168050e-01f, 3.88132006e-01f,
  1.79051813e-02f, -2.78217345e-01f, 1.48693457e-01f, 1.70558989e-01f, 2.04820439e-01f, 3.74797165e-01f, 3.83079261e-01f, 1.27770245e-01f, 1.13039494e-01f, -2.07622647e-02f,
  1.78427119e-02f, 1.28058806e-01f, 1.36796996e-01f, 5.07769687e-03f, -1.43486768e-01f, -3.46437842e-01f, -2.43680645e-02f, 1.48437265e-02f, -1.98917806e-01f, 1.23519845e-01f,
  -2.87155449e-01f, -2.34069988e-01f, -1.55262157e-01f, 1.36019900e-01f, 5.18849045e-02f, 9.66315717e-02f, 6.46744668e-02f, -2.73787826e-02f, -3.05732861e-02f, -2.14754278e-03f,
  -1.20106041e-02f, -4.43592072e-02f, -3.00502451e-03f, 3.34525667e-02f, 2.88302600e-02f, 1.28088087e-01f, -8.27774114e-04f, -1.27803243e-03f, -6.20534793e-02f, -2.87531056e-02f,
  1.77768916e-01f, -1.04903979e-02f, 1.34851336e-02f, 7.47163221e-02f, 1.08362911e-02f, -6.93094777e-03f, 1.31223500e-01f, -8.91466886e-02f, 3.63466814e-02f, 4.06882539e-02f,
  1.60955563e-02f, 5.18688560e-03f, 1.39107421e-01f, -7.40402937e-02f, 5.05959615e-02f, -9.98911560e-02f, 6.55402914e-02f, -8.16149861e-02f, -5.74125871e-02f, 3.30310687e-02f,
  7.10457284e-03f, 3.07893511e-02f, 3.74101326e-02f, 8.87388885e-02f, 6.27662009e-03f, -4.73729707e-02f, -1.25882015e-01f, 7.24214083e-03f, 1.04646958e-01f, -1.06471054e-01f,
  1.52522316e-02f, 1.59983635e-02f, -1.71107948e-02f, -2.14147959e-02f, -1.64964497e-02f, 2.21239217e-02f, 6.30158633e-02f, 7.97676444e-02f, 2.67554279e-02f, -1.53912663e-01f,
  2.54467547e-01f, 9.71299261e-02f, -1.75881937e-01f, -6.08857572e-02f, -4.61687669e-02f, 8.43196586e-02f, -9.56091955e-02f, 6.95898831e-02f, 1.36977658e-01f, -2.50028167e-02f,
  9.04463455e-02f, -9.03282315e-02f, 2.72033270e-02f, -1.97279118e-02f, -7.17885122e-02f, 1.78897098e-01f, 3.99706513e-02f, 1.02022499e-01f, -1.55335069e-02f, -7.75939152e-02f,
  -1.02347024e-01f, -2.04396211e-02f, -1.59934267e-01f, -2.09604621e-01f, -2.69106030e-02f, -6.99543059e-02f, -1.96117200e-02f, -5.76475970e-02f, 1.09018616e-01f, 5.17949834e-02f,
  -4.03808802e-01f, -5.93698695e-02f, -1.10833235e-01f, -6.55591011e-01f, -1.03822015e-02f, -3.87933522e-01f, -5.67154109e-01f, 4.49343324e-02f, -2.05038283e-02f, 4.24944818e-01f,
  -1.60767272e-01f, 1.37079153e-02f, 4.43040878e-02f, -6.56792939e-01f, -7.21015811e-01f, -2.80175716e-01f, -6.84201896e-01f, -2.23414063e-01f, -9.92610082e-02f, -3.60804200e-01f,
  -2.73507804e-01f, -6.11451447e-01f, -4.35296208e-01f, 6.26344234e-03f, -3.22065651e-01f, 2.26009160e-01f, 4.57029462e-01f, 2.46796116e-01f, 2.92289965e-02f, -4.46548313e-02f,
  -1.05055250e-01f, 5.40534109e-02f, 1.33152246e-01f, 4.41554189e-02f, 7.59651214e-02f, 5.27229570e-02f, 1.13988496e-01f, -4.86380123e-02f, 8.29030126e-02f, -8.25576410e-02f,
  -4.56708390e-03f, 1.75042206e-03f, -1.75808102e-01f, 7.26929009e-02f, -1.09490953e-01f, 9.72127169e-03f, -1.15024433e-01f, 1.22588530e-01f, -6.98335096e-02f, -2.07013130e-01f,
  -1.75199628e-01f, -3.68332863e-02f, -8.65307748e-02f, 8.06454793e-02f, -3.45329428e-03f, -2.06105765e-02f, -8.53948817e-02f, -9.44360159e-03f, 9.25512984e-03f, -2.42287591e-02f,
  -1.90551858e-02f, 2.22892426e-02f, -1.78801090e-01f, 3.83139066e-02f, -6.74012750e-02f, 1.09315172e-01f, -5.33343144e-02f, 1.49776423e-02f, 2.78764609e-02f, 2.21748892e-02f,
  5.96661456e-02f, 6.18491694e-02f, 8.58608484e-02f, -2.99466942e-02f, -7.83412680e-02f, 9.14110690e-02f, -1.35782212e-01f, 8.41542613e-03f, -1.68413416e-01f, 3.96187305e-02f,
  -1.95960347e-02f, -5.76224774e-02f, 3.63833494e-02f, -4.61116470e-02f, -1.31684288e-01f, 9.63426009e-02f, 9.86832082e-02f, -7.46440962e-02f, 4.34817560e-02f, 6.83601131e-04f,
  -1.95418820e-02f, 1.84470758e-01f, -7.15591684e-02f, 8.94030835e-03f, 8.20014179e-02f, 1.82291307e-02f, -7.84948841e-02f, -3.46301198e-02f, -5.11580557e-02f, -8.85893703e-02f,
  6.01575822e-02f, 5.41932769e-02f, 9.37833041e-02f, -1.05900437e-01f, 4.82329801e-02f, 1.05133519e-01f, 4.53920327e-02f, 1.12683646e-01f, -5.52343167e-02f, 7.64314383e-02f,
  8.80986005e-02f, 2.00981766e-01f, -1.00623362e-01f, -5.71566038e-02f, 7.99051002e-02f, 1.43822143e-02f, 7.70322457e-02f, 1.71285346e-01f, -7.43335932e-02f, -4.48754206e-02f,
  -1.22183032e-01f, 6.74939334e-01f, 2.36524746e-01f, 4.82938290e-01f, -5.33100367e-01f, -1.18766040e-01f, 3.14848840e-01f, -1.21281527e-01f, 1.70376539e-01f, 3.28086555e-01f,
  -3.51734012e-02f, 2.20355868e-01f, 8.62388015e-02f, 2.29413211e-01f, -8.34459662e-02f, 4.76642072e-01f, 1.93423569e-01f, 3.45381573e-02f, -6.84336796e-02f, 1.19414590e-01f,
  2.55660452e-02f, 9.26987901e-02f, -5.69810197e-02f, -1.55048385e-01f, -1.93539217e-01f, 5.58860712e-02f, 3.49423550e-02f, 2.38444284e-02f, -7.74017200e-02f, -1.91707581e-01f,
  4.30433117e-02f, 1.66102722e-01f, -4.65948880e-02f, 2.20041163e-02f, 7.21272677e-02f, -1.75208598e-01f, 4.37612645e-02f, -6.14873692e-03f, -6.37154207e-02f, -2.03037132e-02f,
  1.44600809e-01f, -1.54460907e-01f, 2.07531247e-02f, -5.81815578e-02f, -1.68657526e-01f, -1.29432559e-01f, -7.50624239e-02f, -1.60932571e-01f, -4.67441864e-02f, -8.91598240e-02f,
  -6.86688051e-02f, 2.15478092e-02f, 1.09182633e-02f, 5.75805083e-02f, -6.53804862e-04f, 6.31598607e-02f, 3.93244289e-02f, 4.72429916e-02f, -6.25974759e-02f, -4.70704958e-02f,
  8.11841786e-02f, -3.28102447e-02f, -1.49748717e-02f, -5.38862832e-02f, -7.79201388e-02f, -5.55610517e-03f, 4.26212475e-02f, -5.87586127e-02f, 4.43335995e-02f, -5.79707511e-02f,
  6.45939708e-02f, -9.66255590e-02f, -3.38483825e-02f, -3.41217816e-02f, -4.82243448e-02f, 4.45088930e-02f, 9.18726437e-03f, -7.63859525e-02f, -1.69955324e-02f, -1.20638972e-02f,
  2.10860502e-02f, -6.13363236e-02f, -1.05163455e-01f, -3.82484198e-02f, -3.10541838e-02f, -2.63361353e-02f, -1.90767959e-01f, -9.48208198e-02f, -2.82826126e-02f, 8.67366716e-02f,
  2.90659845e-01f, 4.41111833e-01f, 2.40834430e-01f, 1.44006819e-01f, 8.14084634e-02f, -3.11966892e-02f, 4.12837975e-02f, -2.52121016e-02f, 1.51281223e-01f, 3.42614986e-02f,
  -1.58111267e-02f, 5.20023443e-02f, -4.04495699e-03f, -1.03565022e-01f, 1.10213019e-01f, 5.83902076e-02f, 2.66815908e-02f, 1.64769739e-02f, 1.29185587e-01f, 3.24339867e-02f,
  -5.96575402e-02f, 8.00348520e-02f, 6.67519867e-02f, -4.59626690e-02f, 4.65977704e-03f, 1.16602674e-01f, -2.45874245e-02f, 4.07462046e-02f, -7.02780634e-02f, 1.13509625e-01f,
  5.40536761e-01f, 4.03495550e-01f, 2.64844954e-01f, 2.20961675e-01f, -3.27879101e-01f, 2.99118131e-01f, 5.28608300e-02f, 3.71228814e-01f, 3.73055518e-01f, 2.43865371e-01f,
  -3.12405735e-01f, 6.31509960e-01f, 4.70420113e-03f, 5.68423420e-02f, -2.66743213e-01f, -2.85203874e-01f, -1.16679519e-01f, 5.75086586e-02f, 1.75067171e-01f, 1.30268693e-01f,
  -1.50122046e-01f, -4.37581748e-01f, -2.97585458e-01f, -1.80745661e-01f, 3.16952675e-04f, 1.30004317e-01f, -5.03824055e-01f, -8.24360847e-02f, -5.61774671e-02f, -2.48361260e-01f,
  -2.33239025e-01f, 1.49952322e-01f, 2.27767564e-02f, 2.05916122e-01f, -7.64311254e-02f, 1.17856835e-03f, -4.27141450e-02f, -9.13095176e-02f, 1.41145280e-02f, 2.44599983e-01f,
  1.41444042e-01f, 1.84962526e-02f, 7.69994780e-02f, 3.86095531e-02f, 1.05152696e-01f, 2.36113295e-01f, 1.09374292e-01f, 3.48794647e-02f, 1.12919718e-01f, 9.19440985e-02f,
  2.03995243e-01f, 9.83973294e-02f, -2.70954240e-02f, -7.92926028e-02f, -4.00283607e-05f, -8.94039869e-02f, 3.04674972e-02f, -5.41217700e-02f, -7.86616933e-03f, 1.61658805e-02f,
  -9.93162170e-02f, 5.88122606e-02f, -6.11308180e-02f, 7.84784406e-02f, 6.16705790e-03f, 5.20099420e-04f, -6.46788776e-02f, -1.65509686e-01f, 1.47469761e-02f, -6.52192011e-02f,
  4.43530269e-02f, 1.22998774e-01f, 1.48031652e-01f, 1.19458169e-01f, 2.80265678e-02f, -2.90129632e-02f, -7.67285526e-02f, -1.10800583e-02f, 2.89037470e-02f, 5.75250275e-02f,
  1.05961882e-01f, -8.96202698e-02f, 4.19586897e-02f, -5.05674370e-02f, -2.08075698e-02f, 1.04811899e-01f, 1.10709853e-01f, 1.82262942e-01f, -4.77279611e-02f, -1.75537035e-01f,
  -8.85837302e-02f, 3.69600728e-02f, -4.78853434e-02f, 2.33258400e-02f, 2.74130944e-02f, 2.28401981e-02f, -1.52799189e-01f, 1.77007258e-01f, -1.05442271e-01f, -2.85883006e-02f,
  -5.25927916e-02f, 2.89199445e-02f, -1.03434563e-01f, -6.96438551e-02f, -1.52790062e-02f, -1.13267727e-01f, -1.86367854e-02f, -4.33265232e-02f, -1.62187144e-01f, -2.12129541e-02f,
  6.99287876e-02f, -7.21802190e-02f, -1.65558979e-01f, -4.54144366e-02f, -4.30764370e-02f, -7.55394697e-02f, 1.84190661e-01f, 1.09581701e-01f, -9.43302736e-02f, -8.37297738e-02f,
  3.85256171e-01f, -2.35347614e-01f, -1.12399787e-01f, -3.46378118e-01f, -1.89480424e-01f, 1.09360084e-01f, 3.27150166e-01f, -3.81061465e-01f, -4.97130573e-01f, -2.01600358e-01f,
  -1.14600390e-01f, 1.77663475e-01f, 4.57334965e-01f, -3.06691825e-01f, 7.17831254e-01f, 2.61268824e-01f, -2.99188197e-01f, -1.05411313e-01f, 1.17568513e-02f, -6.18140846e-02f,
  -8.22146609e-02f, -2.76919872e-01f, 3.36518846e-02f, -2.82571673e-01f, -1.55075729e-01f, -2.09184676e-01f, -2.90079974e-02f, 2.17160851e-01f, -3.94953370e-01f, 7.11714178e-02f,
  2.66098958e-02f, 2.89643258e-02f, -1.44441232e-01f, 4.52811606e-02f, 6.22867979e-02f, 4.59906608e-02f, 7.92440400e-02f, 3.18237841e-01f, 1.28022298e-01f, 2.72266213e-02f,
  9.06387568e-02f, 9.05588549e-03f, -1.93776891e-01f, 1.63742155e-02f, -2.11390018e-01f, -3.95456441e-02f, -8.61539617e-02f, 4.77983020e-02f, -1.18096180e-01f, 1.82675034e-01f,
  4.81458344e-02f, 6.67529851e-02f, -1.54025778e-01f, -1.77299976e-01f, -1.79472521e-01f, -3.76254618e-02f, 1.88306291e-02f, 1.32826552e-01f, -2.40144301e-02f, 4.37704660e-03f,
  -1.08356282e-01f, 6.05567507e-02f, 2.16268480e-01f, 7.10389437e-03f, -6.22037472e-03f, -4.48539071e-02f, 4.86360081e-02f, 1.61759444e-02f, -5.76830767e-02f, 2.42425203e-02f,
  -5.06793782e-02f, -3.79297100e-02f, 6.03166446e-02f, -2.24214979e-03f, 8.53836462e-02f, -2.02344190e-02f, 1.00972369e-01f, -1.43703036e-02f, -1.39971329e-02f, 2.45262012e-02f,
  4.04384080e-03f, 2.24003978e-02f, 2.73525957e-02f, -1.87890962e-01f, 8.28554016e-03f, 4.95407023e-02f, -1.35703534e-01f, -5.29883243e-03f, 4.49878797e-02f, 1.08284801e-01f,
  -8.59329998e-02f, -1.16742902e-01f, -1.00738823e-01f, 9.48417466e-04f, -1.03423214e-02f, 7.14430511e-02f, -9.21167806e-03f, -1.09358706e-01f, -1.37161568e-01f, 6.07558899e-02f,
  -1.09540246e-01f, 6.63925186e-02f, 1.52752548e-01f, -4.20475155e-02f, -4.39346172e-02f, -9.82906669e-02f, 6.02103397e-02f, 8.87280796e-03f, -1.05918884e-01f, 5.02290912e-02f,
  3.70421633e-02f, 2.77998179e-01f, -3.11603788e-02f, -2.75510140e-02f, -1.47863939e-01f, 7.91265443e-03f, 4.58952077e-02f, 3.44492011e-02f, -1.08572669e-01f, 3.15479003e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.31873751e-01f, 2.37791419e-01f, 1.67275593e-01f, 6.36344850e-01f, 4.65153694e-01f, 3.50961059e-01f, 3.48923594e-01f, 5.03328264e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.20423400e-01f, -2.85687327e-01f, 4.23744619e-01f, -4.99749333e-02f, -5.61310232e-01f, 1.50773078e-01f, -1.45408392e-01f, -2.26393715e-01f, 5.11798680e-01f, 1.51019525e-02f,
  -4.21634793e-01f, 8.99864286e-02f, -3.05501688e-02f, 8.66896436e-02f, 3.83452177e-01f, -4.27318484e-01f, 3.99661176e-02f, 3.27344716e-01f, 3.71907860e-01f, 6.32128641e-02f,
  4.88796860e-01f, -4.09731627e-01f, -3.82339895e-01f, -3.47366929e-01f, 3.94753873e-01f, -3.18652302e-01f, 8.37866589e-02f, 1.12555854e-01f, -1.50237411e-01f, -4.51664142e-02f,
  2.16196910e-01f, -1.86322667e-02f, -5.82028031e-01f, -1.28582388e-01f, -2.44947791e-01f, -2.07781971e-01f, -7.93802664e-02f, -2.16579977e-02f, 4.79629427e-01f, -4.73072618e-01f,
  9.67292264e-02f, 1.27818417e-02f, 3.21680456e-01f, -2.99123615e-01f, 2.10529625e-01f, -1.12035431e-01f, 1.06846310e-01f, 3.58569510e-02f, -2.37388223e-01f, 1.32116675e-01f,
  8.14608634e-02f, -5.87345613e-03f, 1.86535716e-03f, -2.76178747e-01f, -4.08636093e-01f, -4.53323513e-01f, -2.67117880e-02f, -4.34042245e-01f, 3.46506119e-01f, 2.15506360e-01f,
  -2.27033675e-01f, 2.21483245e-01f, -4.92575228e-01f, 4.52432454e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  7.01311231e-01f, 3.98314983e-01f, 1.32450595e-01f, 5.30697942e-01f, -2.86797613e-01f, 7.55398214e-01f, -2.70155907e-01f, 1.19178116e+00f, -4.64328021e-01f, 7.71668017e-01f,
  -6.44174159e-01f, 6.06791712e-02f, 3.12397212e-01f, -3.10389727e-01f, -1.60149992e-01f, 4.65665936e-01f, -1.47278890e-01f, 2.95372933e-01f, 3.50254983e-01f, 3.13469529e-01f,
  2.36401990e-01f, 3.29229593e-01f, -2.80372240e-02f, -4.95092809e-01f, 8.06089103e-01f, 6.07955337e-01f, 4.19315577e-01f, 1.30010831e+00f, -3.01896632e-01f, 4.26071942e-01f,
  6.31362319e-01f, 3.68060946e-01f, 4.52845514e-01f, 4.30238664e-01f, -5.52398711e-02f, 5.40218771e-01f, 1.17078090e+00f, -4.02818501e-01f, 6.87174737e-01f, 2.08451599e-01f,
  7.82361627e-01f, 4.13126975e-01f, 1.17490329e-01f, 2.33670712e-01f, 7.00517833e-01f, 5.14372662e-02f, -3.41771930e-01f, 1.24794699e-01f, 2.36511171e-01f, 7.01774776e-01f,
  -5.88456810e-01f, 3.58983666e-01f, 7.47506380e-01f, 2.56942123e-01f, -4.46577549e-01f, 2.54681528e-01f, -2.42269754e-01f, -1.58951774e-01f, 9.18103755e-01f, 1.16064990e+00f,
  -5.53104460e-01f, 4.74970907e-01f, -2.22577691e-01f, 9.98299778e-01f, 6.56775475e-01f, 7.46613443e-01f, 1.80247113e-01f, 3.16503465e-01f, -7.78126955e-01f, 7.85254687e-02f,
  -9.55040157e-01f, 2.73770899e-01f, -7.85165489e-01f, -7.15721607e-01f, 8.50019082e-02f, 6.98817521e-02f, -4.34133738e-01f, 5.31075716e-01f, 9.41002846e-01f, 2.85152555e-01f,
  6.23448789e-01f, 1.77105874e-01f, 1.13245749e+00f, 2.95648694e-01f, -5.67026377e-01f, -2.50835270e-01f, -1.28122151e-01f, 7.06843138e-02f, 6.63585246e-01f, 5.42703211e-01f,
  -3.06738794e-01f, 1.40553012e-01f, 8.21019173e-01f, 1.57506049e-01f, 8.74037743e-01f, -2.26372853e-01f, -3.44355583e-01f, -9.83529463e-02f, -4.86475527e-02f, -4.93144169e-02f,
  -1.53356984e-01f, 1.19317599e-01f, 2.07064405e-01f, -4.49189514e-01f, -1.59081429e-01f, 3.64920169e-01f, 4.14568156e-01f, 4.03210014e-01f, -4.33881164e-01f, 1.08751500e+00f,
  5.61728597e-01f, -2.22898304e-01f, 6.02324367e-01f, 5.92475057e-01f, 6.74409270e-01f, 3.60379964e-01f, -1.49852410e-01f, -7.73905873e-01f, -7.16409922e-01f, -7.36742258e-01f,
  3.55363637e-01f, -2.17602819e-01f, 6.19849741e-01f, -1.07491342e-03f, 9.00584459e-01f, -1.03028268e-01f, 3.96261632e-01f, 4.43618745e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  6.69526219e-01f, 6.32019520e-01f, 3.49859267e-01f, 5.87313950e-01f, 4.37209785e-01f, 6.84441090e-01f, 4.59800392e-01f, 2.18006700e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.03597838e-01f, 4.91122991e-01f, 5.12546122e-01f, 3.93192098e-02f, -6.04270399e-01f, 4.45610642e-01f, -4.44067627e-01f, -1.06937535e-01f, 1.38805121e-01f, 1.07842842e-02f,
  5.00989616e-01f, 1.78322628e-01f, 8.43754783e-02f, -2.84536630e-01f, -1.06163099e-01f, -2.12800294e-01f, -4.40933138e-01f, 3.29150528e-01f, -4.36001807e-01f, 6.19848035e-02f,
  -4.79003668e-01f, -4.89087522e-01f, 7.14709461e-01f, -2.58871585e-01f, -2.81156544e-02f, -1.29640788e-01f, 3.51676166e-01f, 2.22021323e-02f, -2.69186705e-01f, -1.39389075e-02f,
  2.36029267e-01f, -9.15690288e-02f, -2.69612581e-01f, -2.25255340e-01f, -2.77531296e-01f, -1.65427737e-02f, 1.48661643e-01f, 4.56582576e-01f, 4.04449135e-01f, 4.09275413e-01f,
  -3.63694310e-01f, 2.57178217e-01f, -9.92299616e-02f, -1.54238001e-01f, 1.22602312e-02f, -3.30000699e-01f, 1.36228085e-01f, 3.30864668e-01f, 2.62344062e-01f, 8.25721398e-02f,
  1.75207481e-01f, 1.23338312e-01f, -1.63878843e-01f, -1.23316124e-01f, 3.87901694e-01f, -5.08703828e-01f, -1.31518707e-01f, -8.60312805e-02f, 3.41176569e-01f, -9.08776745e-02f,
  -3.92232805e-01f, 4.78523970e-02f, 2.41383672e-01f, -2.22612277e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  8.60770941e-01f, 1.12255603e-01f, 9.16492999e-01f, 4.90356266e-01f, 9.43783164e-01f, -6.55722678e-01f, -3.21160674e-01f, -8.78915727e-01f, 1.07785058e+00f, 9.72751260e-01f,
  1.05598390e-01f, 3.56106877e-01f, -3.02622110e-01f, 2.74221092e-01f, 7.26729870e-01f, -7.93593585e-01f, 2.07776159e-01f, 3.26600164e-01f, -2.05180854e-01f, 6.78719059e-02f,
  6.31195158e-02f, 1.22273512e-01f, 3.43378037e-01f, -1.70079112e-01f, -2.40627319e-01f, 8.26275498e-02f, -1.98767617e-01f, 2.42187276e-01f, 4.63838875e-01f, -2.30479270e-01f,
  1.10700405e+00f, -5.06292820e-01f, 4.63762492e-01f, 7.32236564e-01f, 4.24842954e-01f, 6.64328188e-02f, -8.18041027e-01f, -2.53806829e-01f, -1.09928799e+00f, -6.85087740e-01f,
  1.41992104e+00f, -1.18454196e-01f, 7.00215027e-02f, 3.98707569e-01f, 9.40577149e-01f, 4.58713651e-01f, -7.80588746e-01f, 3.97992253e-01f, -1.76340248e-02f, -3.38004887e-01f,
  -2.25061122e-02f, 1.75531909e-01f, -6.50706828e-01f, 2.11769849e-01f, 5.04563630e-01f, 8.20572376e-01f, -1.43639132e-01f, 6.44607365e-01f, 1.24709737e+00f, 5.75744748e-01f,
  -1.15618289e+00f, 2.68957734e-01f, -1.85619637e-01f, 5.79957724e-01f, 3.86775076e-01f, -7.90427208e-01f, -1.22019826e-02f, 6.46090269e-01f, 9.58624244e-01f, 4.96597350e-01f,
  2.38614708e-01f, -2.07548022e-01f, -6.22627139e-01f, 4.07784402e-01f, -1.08760521e-02f, -4.00266916e-01f, 4.72517639e-01f, 9.00113106e-01f, 3.50600004e-01f, 6.57507241e-01f,
  1.77881747e-01f, -3.69519088e-03f, -7.21828565e-02f, -1.47090703e-01f, 6.92342103e-01f, 1.40580311e-01f, 6.63020134e-01f, -9.37537909e-01f, 1.20685883e-01f, -2.90626157e-02f,
  4.74895298e-01f, -1.39407456e+00f, 1.22696318e-01f, 1.01187754e+00f, 4.98435870e-02f, 3.60476822e-01f, -1.14186004e-01f, 3.65482599e-01f, -3.60035479e-01f, 8.16752538e-02f,
  -1.85954660e-01f, 8.82335842e-01f, -1.05538301e-01f, 8.71947467e-01f, -4.20957476e-01f, 5.86496472e-01f, -1.68031067e-01f, 1.03374469e+00f, 1.23078263e+00f, 3.43746615e-05f,
  4.95743990e-01f, 4.95023638e-01f, -9.65786934e-01f, -4.44617830e-02f, -8.51627529e-01f, -4.37724054e-01f, -5.77725053e-01f, 6.99957162e-02f, 5.46396077e-01f, 4.02635574e-01f,
  1.46105513e-01f, 1.51225880e-01f, 1.33939266e-01f, -3.51600908e-02f, -4.23571356e-02f, 3.63220781e-01f, -8.89245987e-01f, 9.54373419e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  7.19560802e-01f, 9.88627076e-02f, 2.60666430e-01f, 2.16212362e-01f, 1.78817332e-01f, 4.45474565e-01f, 1.94656625e-01f, -1.86462011e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -3.58278513e-01f, 4.58036736e-02f, -2.42871195e-01f, 2.83001989e-01f, 2.50184268e-01f, 9.04138386e-01f, 5.65548539e-01f, 5.05179942e-01f, 1.11569874e-02f, 3.62147331e-01f,
  -1.52514672e+00f, 5.04256785e-01f, -7.29180694e-01f, -3.47897679e-01f, 3.42569947e-01f, -5.57627439e-01f, -4.43302304e-01f, -3.87764350e-02f, 2.62259185e-01f, 9.48296022e-03f,
  2.63254344e-01f, 7.87391782e-01f, -6.15711451e-01f, 5.72439611e-01f, 4.66112077e-01f, 1.14232697e-01f, 1.79484591e-01f, 3.87405932e-01f, -6.65956080e-01f, -9.81258094e-01f,
  -5.59957922e-01f, -4.09711808e-01f, 5.94873786e-01f, 2.59519875e-01f, -6.82554722e-01f, 6.04188561e-01f, 1.40888393e-01f, -5.16190231e-01f, -1.89230293e-01f, 1.23077370e-01f,
  5.71243048e-01f, -1.08023655e+00f, 4.49693084e-01f, -5.66651225e-01f, -4.63010430e-01f, 3.85584891e-01f, -1.27216935e+00f, -8.57786417e-01f, 1.89761948e-02f, -5.70739843e-02f,
  2.65746087e-01f, -2.46880934e-01f, -5.12142956e-01f, 6.48175061e-01f, 4.05172884e-01f, 6.70342386e-01f, -8.50169301e-01f, -1.82474315e-01f, -9.63324010e-01f, 3.41445178e-01f,
  4.18055028e-01f, 6.14686191e-01f, -3.27733755e-01f, 9.79414284e-02f, -1.23386703e-01f, 2.35108808e-01f, 2.63596833e-01f, 5.52356660e-01f, -3.66337188e-02f, -5.82109332e-01f,
  7.27062941e-01f, -5.39753199e-01f, -9.97835472e-02f, -1.27322447e+00f, -1.17397733e-01f, 5.06769180e-01f, 4.68054175e-01f, -6.04936898e-01f, -1.39434874e-01f, -1.92890644e-01f,
  4.44923878e-01f, 1.08806405e-03f, -1.15190297e-01f, -1.45780474e-01f, 3.14169943e-01f, -1.90676048e-01f, 4.61787552e-01f, -7.07091451e-01f, -2.50244498e-01f, 2.76033878e-01f,
  -2.59503156e-01f, -3.07779819e-01f, 3.93821001e-01f, -1.05719972e+00f, 5.51213384e-01f, -9.94498670e-01f, 2.59175420e-01f, -3.82493526e-01f, -1.03247706e-02f, 7.88702592e-02f,
  6.25580490e-01f, -6.24213755e-01f, -7.54260063e-01f, -9.43816543e-01f, 3.24112326e-01f, 1.54995635e-01f, 6.08074784e-01f, -1.60093904e+00f, -2.47515976e-01f, -4.54575002e-01f,
  7.93874487e-02f, -9.17970657e-01f, 4.36159819e-01f, 4.76211905e-02f, -4.00930524e-01f, -3.17487717e-01f, -6.96538568e-01f, 6.48635745e-01f, 5.04470095e-02f, -8.50875914e-01f,
  -1.07780659e+00f, -5.55145591e-02f, 3.01499832e-02f, 3.78592968e-01f, -1.24473795e-01f, -3.30115557e-01f, -8.39284249e-03f, 7.40315735e-01f, 2.02790171e-01f, 1.54458150e-01f,
  5.40662825e-01f, -2.14354739e-01f, -7.73151875e-01f, 2.96115339e-01f, -1.04936749e-01f, 6.21439159e-01f, 5.47614336e-01f, 4.22581971e-01f, -9.48159337e-01f, -4.63987440e-01f,
  4.27311927e-01f, 5.33461034e-01f, -5.43679595e-01f, -3.46386760e-01f, -4.75704879e-01f, 1.21529892e-01f, 2.98693240e-01f, -5.41150391e-01f, -3.59178871e-01f, -5.23572564e-01f,
  -9.20979753e-02f, -6.71251714e-02f, -4.59702075e-01f, -4.67602968e-01f, 5.82390010e-01f, -5.82426600e-02f, -1.13121665e+00f, -6.09894812e-01f, 3.69825631e-01f, 5.38664460e-02f,
  -2.06895173e-01f, -1.74408369e-02f, -3.06695700e-02f, -4.45667952e-01f, 4.19638455e-01f, 2.05143347e-01f, -6.19664967e-01f, 4.91454870e-01f, -4.26781625e-01f, -1.76169947e-01f,
  5.16169190e-01f, 2.73582876e-01f, -3.66304696e-01f, 5.37084460e-01f, -8.45784903e-01f, -5.02338074e-02f, 5.06888377e-03f, -1.75549448e-01f, 1.76846385e-01f, 1.05143912e-01f,
  -3.47107410e-01f, -2.34435171e-01f, 3.91625702e-01f, -4.58092570e-01f, -4.68165070e-01f, 1.78475585e-02f, -3.00339371e-01f, -8.63028586e-01f, 6.28599107e-01f, 7.13152349e-01f,
  2.01432914e-01f, -1.93809196e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.89128637e-01f, 8.71544182e-02f, -1.40093729e-01f, -2.68696487e-01f, -6.30600974e-02f, 1.28761724e-01f, 2.50479221e-01f, -3.96498144e-01f, 2.08285645e-01f, 1.50790662e-01f,
  1.84697047e-01f, -2.28637829e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    