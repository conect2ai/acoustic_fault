/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.83056349e-01f, 1.02852844e-02f, -7.28817582e-02f, 1.80610359e-01f, -1.80201918e-01f, -1.59976453e-01f, -2.16190845e-01f, -9.41166133e-02f, -2.51864716e-02f, -3.01069096e-02f,
  -4.81720977e-02f, 1.21369109e-01f, -7.01726275e-03f, -1.20711803e-01f, -2.45614871e-01f, -2.34803110e-01f, -1.45786688e-01f, 4.13209796e-02f, 4.82880324e-03f, -7.93228224e-02f,
  1.22686096e-01f, 1.42491341e-01f, 1.95443794e-01f, 7.79718533e-02f, 4.90402468e-02f, 1.67947143e-01f, 1.63957670e-01f, 5.01036309e-02f, -1.14630155e-01f, 1.94063082e-01f,
  -1.84446529e-01f, -5.48913726e-04f, -1.52326941e-01f, 5.10294065e-02f, 2.11913027e-02f, 4.45642322e-02f, -1.11562684e-01f, 6.35332987e-02f, -7.60521740e-02f, 2.27865465e-02f,
  -7.38086328e-02f, -1.18719734e-01f, -7.57385865e-02f, 9.61445179e-03f, -6.22043759e-02f, -1.36340141e-01f, 5.84767871e-02f, -6.08919784e-02f, -4.18935902e-02f, 4.25417529e-04f,
  -9.20342207e-02f, -1.09664463e-01f, -1.30014822e-01f, -1.25507593e-01f, -1.59778804e-01f, -1.35616288e-01f, -2.34871320e-02f, 3.86972800e-02f, -3.04683074e-02f, 1.46964446e-01f,
  5.58288731e-02f, 7.43465172e-03f, 3.76093946e-02f, 7.16607645e-02f, 3.98687497e-02f, -6.79413183e-03f, 1.36781856e-03f, 6.50124624e-02f, 1.13239758e-01f, -3.01357396e-02f,
  5.61677210e-04f, 8.94186050e-02f, 5.40790260e-02f, 8.02643001e-02f, 6.91538602e-02f, 3.07065807e-02f, -1.93218142e-02f, 1.06244860e-02f, 5.04868478e-02f, 1.18633218e-01f,
  6.90172985e-02f, -7.36852437e-02f, 4.90241311e-02f, -2.90354993e-02f, 9.38107893e-02f, 2.24475879e-02f, -3.17804590e-02f, -1.24346865e-02f, 1.80452019e-02f, -4.08771477e-04f,
  5.10694571e-02f, -1.41826451e-01f, -1.36436373e-01f, -1.58583969e-02f, -1.30565226e-01f, -7.26766363e-02f, -6.99338391e-02f, -3.33398618e-02f, -1.26582727e-01f, -1.49633046e-02f,
  -5.44884764e-02f, -1.21565484e-01f, -1.55658469e-01f, -9.79364589e-02f, -1.52490541e-01f, -1.20511971e-01f, 1.03929162e-03f, -1.57151651e-02f, -1.12222105e-01f, -3.03646736e-02f,
  -6.46988582e-03f, -1.61328956e-01f, -6.39686063e-02f, -1.12130135e-01f, -7.90193006e-02f, -1.23409621e-01f, -2.08982468e-01f, -5.95774986e-02f, -2.57750452e-01f, -6.04145043e-03f,
  -8.13714862e-02f, 3.18141371e-01f, -1.23638257e-01f, 4.63991277e-02f, 1.80050135e-01f, 1.14345156e-01f, 2.70353764e-01f, -3.31539065e-02f, -1.28619418e-01f, 5.51082529e-02f,
  1.69602886e-01f, -1.13254316e-01f, -7.03326538e-02f, -2.52970066e-02f, 3.23352739e-02f, 2.18516551e-02f, -6.26427606e-02f, -9.27783325e-02f, -1.49077713e-01f, 1.06926598e-02f,
  1.48350641e-01f, 1.14305928e-01f, 4.91579697e-02f, -1.18730679e-01f, 5.85935488e-02f, -7.43764788e-02f, 7.48893544e-02f, -5.87725788e-02f, -2.74334103e-02f, -2.38066435e-01f,
  -5.18316403e-02f, -1.68123562e-02f, 7.08082784e-03f, -2.89899576e-02f, -7.12096039e-03f, -6.78777844e-02f, 5.24848402e-02f, -1.24529619e-02f, 6.69848621e-02f, -1.77794918e-02f,
  -8.26974027e-03f, 5.33647947e-02f, -5.52842282e-02f, 4.90027480e-02f, -2.86825281e-02f, -5.88658676e-02f, 4.98346500e-02f, -1.45842806e-01f, -1.01786733e-01f, 1.46967079e-02f,
  1.02785610e-01f, 1.53691694e-01f, 9.62519050e-02f, 8.24350864e-02f, -5.73819913e-02f, -8.14490095e-02f, 1.12893909e-01f, -8.85376856e-02f, -7.75336996e-02f, -4.66301292e-02f,
  -7.95536768e-03f, 2.15041135e-02f, 1.84292886e-02f, -5.38230166e-02f, -7.08442181e-02f, -2.49597933e-02f, -9.03766602e-02f, 6.79574683e-02f, -1.39590064e-02f, -3.48519236e-02f,
  -9.07470435e-02f, -2.53465418e-02f, 1.71539690e-02f, -8.02157298e-02f, 9.22266208e-03f, 8.34743083e-02f, 5.78163639e-02f, 5.51402643e-02f, 2.97621191e-02f, 1.08066879e-01f,
  -4.00429824e-03f, -4.77537587e-02f, -9.72080976e-02f, -5.65659180e-02f, 1.41660739e-02f, 2.93621719e-02f, -7.98823312e-04f, 1.14466302e-01f, -2.98454911e-02f, 1.16410121e-01f,
  1.74405277e-01f, 1.55523971e-01f, -9.36860070e-02f, 4.02391749e-03f, 1.02802552e-01f, 1.75239872e-02f, 6.34939447e-02f, -7.28844404e-02f, 4.93200421e-02f, 5.72226010e-02f,
  1.15620181e-01f, 9.60644633e-02f, 1.02583289e-01f, 3.79389897e-02f, 5.37598729e-02f, -5.40931784e-02f, 8.49960148e-02f, 2.27753259e-02f, -1.78766567e-02f, -2.81794593e-02f,
  1.03669576e-01f, 4.98694219e-02f, 1.39900878e-01f, 9.42886695e-02f, -5.53482883e-02f, -9.31180641e-02f, 7.42408037e-02f, -3.14632766e-02f, 1.19068369e-01f, 9.76201072e-02f,
  -1.47249117e-01f, -2.05209494e-01f, 5.22176921e-02f, -1.70366704e-01f, 2.25635156e-01f, 3.40679318e-01f, 3.49015236e-01f, 1.34359390e-01f, -4.65358682e-02f, -1.42032191e-01f,
  1.15191583e-02f, -1.43867850e-01f, -2.01471776e-01f, -9.72261280e-02f, 1.20429337e-01f, -9.23840031e-02f, -1.43232211e-01f, 2.20548045e-02f, 2.29505032e-01f, 2.42565870e-01f,
  -5.34720719e-03f, 2.26452351e-02f, 3.65142263e-02f, -1.04459025e-01f, -2.50527114e-01f, -1.58699825e-01f, -1.73242107e-01f, -4.05133814e-02f, 1.07951025e-02f, -1.75179258e-01f,
  -1.82694629e-01f, 6.09665290e-02f, 8.94687250e-02f, -1.04157478e-01f, 8.01275484e-03f, -3.04417238e-02f, -3.32266726e-02f, -4.68464419e-02f, -1.05083399e-01f, -1.27777100e-01f,
  -8.35443735e-02f, -4.19101417e-02f, -1.19287118e-01f, -1.29517047e-02f, -3.57623771e-02f, 4.04199921e-02f, 1.23084122e-02f, 1.51783312e-02f, -7.93385804e-02f, -7.84163643e-03f,
  -1.03671245e-01f, 4.04397957e-02f, 5.74485213e-03f, 1.73325036e-02f, 8.11352767e-03f, -4.77158800e-02f, -2.60282326e-02f, 1.43862730e-02f, 4.61441018e-02f, -1.18189506e-01f,
  -5.80244176e-02f, -2.34523844e-02f, 1.06413901e-01f, -6.16098605e-02f, 5.02362587e-02f, 6.96579739e-02f, -5.53959310e-02f, 9.25779156e-03f, 4.03676070e-02f, 6.90596253e-02f,
  2.73865014e-02f, 7.56213963e-02f, 5.22867553e-02f, 4.15206403e-02f, 2.90124137e-02f, 1.06464393e-01f, 1.03633970e-01f, -4.05932255e-02f, 1.02932546e-02f, 5.32468073e-02f,
  7.64164627e-02f, 9.86902267e-02f, 9.60953161e-03f, 1.16882600e-01f, 1.80425830e-02f, 6.73397407e-02f, 6.01427257e-02f, 3.00761275e-02f, 1.23998433e-01f, 9.01158527e-02f,
  -2.08083525e-01f, 2.10712612e-01f, -2.38073617e-01f, -9.71856862e-02f, -2.58668605e-02f, 3.21390014e-03f, 3.06949932e-02f, -3.50553617e-02f, -1.69700198e-02f, 3.06242760e-02f,
  9.16693266e-03f, -7.45733678e-02f, 2.44869962e-02f, 1.80260204e-02f, 6.27251565e-02f, -4.58622817e-03f, 1.24149742e-02f, -1.36989266e-01f, 1.77906547e-02f, -8.81818123e-03f,
  -1.71530396e-02f, -4.09904309e-02f, 5.69991507e-02f, -5.48384003e-02f, 5.10505736e-02f, -4.39942442e-02f, 3.38923149e-02f, -5.62146632e-03f, 7.79138803e-02f, -8.55039656e-02f,
  1.02460392e-01f, -3.01906884e-01f, 3.32227051e-01f, -1.44774333e-01f, -3.21504474e-02f, 6.53973073e-02f, -1.06430627e-01f, 2.49288809e-02f, 4.79205474e-02f, -1.96359485e-01f,
  -1.93279535e-01f, -6.36540875e-02f, 3.74469757e-02f, 8.66470560e-02f, 1.74554065e-01f, 2.96416059e-02f, 1.84243530e-01f, 2.88527787e-01f, 2.03216270e-01f, 8.93344134e-02f,
  -2.09313825e-01f, -6.93383962e-02f, 1.30608559e-01f, -4.97310609e-03f, -1.73058599e-01f, -3.77882905e-02f, -3.04085035e-02f, 1.59709472e-02f, -7.94306695e-02f, -1.26093877e-02f,
  6.18224367e-02f, -7.63447136e-02f, 1.53391268e-02f, -1.06578227e-02f, -3.01264063e-03f, 7.66656175e-02f, -4.73231003e-02f, -3.43809091e-02f, -4.05574264e-03f, -1.14802957e-01f,
  -1.42812476e-01f, -4.48342413e-02f, -1.26335293e-01f, -4.01377268e-02f, -6.23746477e-02f, 4.16659471e-03f, 6.80888370e-02f, 7.46080354e-02f, 8.47159186e-04f, -7.13319927e-02f,
  -1.34288654e-01f, -1.14904903e-01f, 6.90011159e-02f, 4.38337699e-02f, -2.29077321e-02f, 1.30823746e-01f, -8.57898593e-03f, 1.35052064e-02f, 7.41388798e-02f, 3.67934257e-02f,
  7.39559084e-02f, 1.29435277e-02f, 8.19202289e-02f, 1.78348063e-03f, 3.51394452e-02f, 9.42153782e-02f, 9.56187863e-03f, 2.81233471e-02f, 8.88865665e-02f, -4.06636447e-02f,
  -2.38802116e-02f, 1.02294451e-02f, 1.09534813e-02f, 1.05095327e-01f, 9.40414071e-02f, 5.76930270e-02f, 4.25874032e-02f, 5.06205261e-02f, 1.01950526e-01f, 7.47711286e-02f,
  9.87692084e-03f, 4.37794626e-02f, 9.72385481e-02f, -4.29134257e-02f, 6.17501847e-02f, 9.48460102e-02f, 8.76938701e-02f, 9.07416567e-02f, -3.36502194e-02f, 9.47561637e-02f,
  -9.00156498e-02f, 8.75837281e-02f, -4.35615256e-02f, -4.97397706e-02f, -1.27942950e-01f, -1.44957881e-02f, -5.91350384e-02f, -3.60869132e-02f, -1.10260218e-01f, -6.97431788e-02f,
  -4.27255593e-02f, -4.63600978e-02f, -1.26287178e-03f, -1.21643178e-01f, 6.90082386e-02f, -4.72675776e-03f, -8.73128325e-02f, 1.67490877e-02f, -4.82284427e-02f, -8.05100203e-02f,
  -1.49204388e-01f, 3.95223573e-02f, 2.44220197e-02f, -3.69693124e-04f, 2.33372245e-02f, 5.94461523e-02f, 1.12372629e-01f, 1.17762923e-01f, 8.24253261e-02f, -3.03572752e-02f,
  9.13577452e-02f, 3.75734448e-01f, 7.67052025e-02f, 2.70060915e-02f, -1.45965800e-01f, -4.03281301e-03f, 1.82907939e-01f, 1.59946859e-01f, 9.27663222e-02f, 6.67302087e-02f,
  -8.99078846e-02f, -2.31546193e-01f, -1.64260253e-01f, -1.06409416e-01f, -1.34351179e-02f, 2.11412311e-01f, 1.25137269e-01f, -1.69702515e-01f, -1.77744955e-01f, -6.24675825e-02f,
  1.69122145e-02f, -3.46970372e-02f, -1.07698500e-01f, 7.07885474e-02f, 8.21513310e-02f, -1.35261729e-01f, 9.74467993e-02f, 4.84934822e-02f, 1.09614417e-01f, 4.76146415e-02f,
  -4.40104194e-02f, 2.18092930e-03f, -1.37458384e-01f, -1.52089342e-01f, -1.53556868e-01f, 5.25660217e-02f, 6.16622865e-02f, -9.94619075e-03f, 4.86925151e-03f, 2.95933262e-02f,
  -4.70013209e-02f, -2.00043507e-02f, 3.70516852e-02f, 5.73015586e-02f, -3.04253921e-02f, -6.18491136e-02f, 1.40597415e-03f, -1.18136995e-01f, -9.30858701e-02f, 1.83445346e-02f,
  -3.53264716e-03f, -1.01661012e-01f, -1.78688452e-01f, 1.72439795e-02f, -8.44505951e-02f, -1.15606211e-01f, 2.71460749e-02f, -9.57772136e-02f, -9.05262586e-03f, 1.12011924e-01f,
  3.70987132e-02f, 3.48567474e-03f, 7.22246021e-02f, -1.49305658e-02f, 6.18942343e-02f, 8.95832032e-02f, 5.54639660e-03f, 6.01229444e-02f, 4.66629304e-02f, 1.10159695e-01f,
  2.39944477e-02f, -1.95939969e-02f, -3.18364776e-03f, 5.19525856e-02f, 1.29881561e-01f, 4.85599367e-03f, 1.25521094e-01f, -9.03526135e-03f, -1.13672961e-03f, 5.47260605e-02f,
  5.71501767e-03f, -5.63024059e-02f, 7.34355673e-02f, 2.60069706e-02f, 9.59288478e-02f, 8.82392824e-02f, 9.13284346e-02f, 5.57068922e-03f, 1.06268898e-02f, 5.74088730e-02f,
  2.31303219e-02f, -2.68779576e-01f, -3.62343788e-02f, -3.10188960e-02f, -5.43098338e-02f, -3.16462107e-02f, 2.15917286e-02f, 1.93682648e-02f, -1.02489263e-01f, -3.16070789e-03f,
  -2.37881541e-02f, -5.24455234e-02f, -4.25364971e-02f, -1.69777758e-02f, -9.63635892e-02f, -5.28242663e-02f, 1.08133547e-01f, -7.62685463e-02f, -8.15762505e-02f, -1.87651813e-02f,
  4.57022898e-03f, 1.08830705e-01f, 5.15291728e-02f, 5.05452231e-02f, -1.79883856e-02f, -1.24882013e-01f, -3.03190574e-02f, -2.63248216e-02f, 1.28101464e-02f, 2.00850949e-01f,
  1.94749951e-01f, -1.77861944e-01f, 3.35735604e-02f, -3.63102518e-02f, -1.54099464e-01f, -1.23761281e-01f, -2.57640183e-01f, -1.02816880e-01f, 2.85943337e-02f, -6.40920401e-02f,
  -7.42960498e-02f, 2.71116316e-01f, 1.84033632e-01f, 1.98208272e-01f, 1.04513504e-01f, -3.40472907e-02f, 1.14463910e-01f, 1.78877085e-01f, 2.67883539e-01f, -2.08144076e-02f,
  6.39157891e-02f, 9.16409567e-02f, 7.70892277e-02f, 1.19563945e-01f, -1.05088569e-01f, 1.15762822e-01f, -1.18265882e-01f, -9.22551081e-02f, -3.64063308e-02f, 1.13691084e-01f,
  1.14208639e-01f, -9.50526893e-02f, 5.58756925e-02f, 1.26157552e-01f, -7.35479668e-02f, 2.31628516e-03f, 4.08122269e-03f, -7.36569660e-03f, -1.44785345e-02f, -4.57768813e-02f,
  2.65937354e-02f, 3.44951218e-03f, -4.50221114e-02f, -4.22784388e-02f, -1.11627458e-02f, -6.02757148e-02f, 1.47253191e-02f, 4.85861674e-02f, 1.20485075e-01f, 6.03084918e-03f,
  -1.03115059e-01f, -1.21857755e-01f, -7.01164231e-02f, 5.78388534e-02f, -3.13169174e-02f, 1.07875168e-01f, 1.31961890e-02f, -8.84267762e-02f, 7.42495507e-02f, -2.28740200e-02f,
  5.92441186e-02f, 5.21106869e-02f, -7.29731768e-02f, 4.88657579e-02f, -2.68521365e-02f, 3.65821086e-02f, -7.78228790e-02f, -1.49995955e-02f, -7.58579373e-02f, 2.84779128e-02f,
  4.23774123e-02f, -8.22378509e-03f, -7.20242457e-03f, 1.49293840e-02f, -3.71338911e-02f, 6.99673742e-02f, -4.39608060e-02f, -6.24235533e-03f, -3.26067023e-02f, -7.94145241e-02f,
  6.21338263e-02f, -3.29921320e-02f, 4.59393896e-02f, -4.95614782e-02f, -3.00682988e-02f, 6.20179623e-02f, -6.18209913e-02f, 1.19163841e-02f, -1.89156402e-02f, -1.00569546e-01f,
  1.24227762e-01f, 3.11778393e-02f, 1.23981521e-01f, 1.12016335e-01f, 1.78693216e-02f, 7.20698107e-03f, -9.05155316e-02f, -5.80695495e-02f, 1.84466168e-02f, 3.49771641e-02f,
  -1.47879776e-02f, 9.12697613e-02f, 4.31311950e-02f, -6.57486555e-04f, 8.30637142e-02f, 2.20034993e-03f, -5.85666597e-02f, 3.79590690e-02f, 1.01251163e-01f, -4.76540066e-02f,
  6.02318347e-02f, 7.60104060e-02f, 1.50815681e-01f, 5.84151149e-02f, 7.33602867e-02f, 1.54914394e-01f, 1.94021463e-02f, 2.93469243e-02f, 2.62891073e-02f, 8.62261876e-02f,
  3.77374113e-01f, 5.58802150e-02f, -1.54343545e-01f, 1.09254263e-01f, 1.92075837e-02f, -5.39270863e-02f, -2.17795465e-02f, 1.17080778e-01f, 1.90485999e-01f, -4.79312390e-02f,
  1.22608900e-01f, 1.78092360e-01f, 3.26994359e-02f, 5.53159975e-02f, 8.13741907e-02f, -1.04539357e-01f, -1.37195483e-01f, -1.78695485e-01f, 5.59895784e-02f, 1.06243365e-01f,
  -9.50194746e-02f, 2.67292801e-02f, -4.95114960e-02f, -4.76207770e-02f, -1.97994739e-01f, -1.52286917e-01f, -2.32835218e-01f, -1.37773454e-01f, -1.97051629e-01f, -2.78151244e-01f,
  -1.07719973e-01f, 2.04949737e-01f, 1.19875155e-01f, 7.64703602e-02f, 1.38772622e-01f, 3.76372002e-02f, 1.40467584e-01f, 2.12177988e-02f, 7.05793723e-02f, -2.45829783e-02f,
  5.29982224e-02f, 1.05420366e-01f, 4.40466143e-02f, 4.53974418e-02f, 9.91163552e-02f, 7.25203529e-02f, 2.94870441e-03f, 8.23244900e-02f, -1.33044450e-02f, 3.97210382e-02f,
  1.14376932e-01f, 4.95907385e-03f, -5.43613844e-02f, 3.88845168e-02f, 7.98701029e-03f, -4.37405929e-02f, -7.58653432e-02f, -7.03996569e-02f, 2.79756505e-02f, -3.45584266e-02f,
  -1.07615635e-01f, -6.34476990e-02f, -2.70427056e-02f, -2.53515225e-02f, 3.55186611e-02f, 1.28957042e-02f, -9.78388707e-04f, -7.46659935e-02f, 2.75480039e-02f, -5.89394420e-02f,
  1.09836254e-02f, -5.42188203e-03f, 3.18284817e-02f, -8.39037821e-02f, -1.56807944e-01f, 4.36681807e-02f, -1.17600737e-02f, -1.06982090e-01f, -1.22003421e-01f, -3.06231230e-02f,
  -9.37909260e-02f, 6.35627238e-03f, 1.42291738e-02f, -6.46026954e-02f, -2.40668580e-02f, -9.79399383e-02f, 4.98935021e-02f, -4.77086827e-02f, -5.03306882e-03f, 6.94548786e-02f,
  1.03208169e-01f, 8.48970339e-02f, 1.35093639e-02f, 8.40081424e-02f, -1.82652734e-02f, 5.48628680e-02f, 1.76935864e-03f, 4.03366759e-02f, 1.64234534e-01f, 5.54467663e-02f,
  5.58698922e-02f, 7.83058405e-02f, 4.95049804e-02f, 4.96891215e-02f, 6.47771508e-02f, -2.00175475e-02f, 1.15831204e-01f, 7.40663707e-02f, 6.48617670e-02f, 7.62205049e-02f,
  4.42971326e-02f, -2.99522411e-02f, -4.04862277e-02f, 2.32587382e-02f, 1.68903191e-02f, 6.84319511e-02f, 1.03186648e-02f, -1.14732102e-01f, -7.70496875e-02f, -7.23840296e-02f,
  -1.44143239e-01f, -1.96566030e-01f, -3.19276154e-01f, -2.18028277e-01f, -8.48569945e-02f, -3.76504362e-02f, -8.56663138e-02f, -4.21504751e-02f, 8.16159919e-02f, -8.20683166e-02f,
  5.92486486e-02f, 4.73803617e-02f, 6.25865981e-02f, -4.06232383e-03f, -7.29240030e-02f, -5.76684140e-02f, -1.80958718e-01f, -6.07286133e-02f, 3.30054015e-02f, 6.63357601e-02f,
  1.32438187e-02f, -1.18508816e-01f, -1.67819053e-01f, -1.30192399e-01f, -1.26278162e-01f, -1.95792109e-01f, -2.93997377e-01f, -2.04724148e-01f, -2.34153196e-01f, -3.29562545e-01f,
  -2.95522541e-01f, -1.45172805e-01f, 4.72776778e-02f, 1.67919993e-01f, -2.32801270e-02f, 2.48902524e-03f, -1.05710566e-01f, 5.18839024e-02f, 4.72869016e-02f, 1.30853578e-02f,
  -4.39910330e-02f, 1.20640859e-01f, -3.67313437e-03f, -4.50469218e-02f, -1.05762511e-01f, -4.35401732e-03f, 6.26076013e-02f, -9.62948129e-02f, -9.53137428e-02f, 1.23710753e-02f,
  -9.60475206e-03f, -1.24058425e-01f, -1.78923115e-01f, 3.13223787e-02f, -1.92090288e-01f, -9.61725190e-02f, -2.00516731e-01f, -2.18830422e-01f, -1.91853151e-01f, -1.51513711e-01f,
  -9.38492045e-02f, 6.57132268e-02f, 1.46114916e-01f, 5.40224239e-02f, 6.07293993e-02f, 1.14771210e-01f, -3.49796563e-02f, -1.86515786e-02f, 4.27383035e-02f, 1.36940628e-01f,
  6.69008568e-02f, 7.46406466e-02f, -2.06970870e-02f, -1.75803434e-02f, 1.14325531e-01f, 8.46731514e-02f, 2.95097195e-02f, 1.97920799e-02f, 3.01603135e-02f, -1.39576639e-03f,
  -2.25362051e-02f, 6.46883920e-02f, 1.11067630e-01f, -2.59586684e-02f, -1.83270816e-02f, -1.04750872e-01f, 5.05958945e-02f, 1.53504461e-01f, 2.76415981e-02f, 1.45436138e-01f,
  4.89944257e-02f, 8.32787249e-03f, 4.27988940e-04f, -9.02133249e-03f, -8.49408954e-02f, 6.19208515e-02f, -3.69730182e-02f, 1.83929838e-02f, 1.15833404e-02f, -7.20382705e-02f,
  -1.24073952e-01f, -9.48334113e-02f, -8.77652913e-02f, -9.59925726e-03f, -7.08658993e-02f, 2.81950515e-02f, -5.09855971e-02f, -1.70280132e-02f, -4.00278494e-02f, -7.79917240e-02f,
  2.48589087e-02f, -3.45070511e-02f, 9.18703387e-04f, 2.83257347e-02f, -1.55635789e-01f, 1.76510168e-03f, -6.63354173e-02f, -1.89583540e-01f, -8.04041103e-02f, -4.43292111e-02f,
  7.25416690e-02f, -3.07519794e-01f, -2.35646725e-01f, -8.78000855e-02f, -1.63139656e-01f, -2.21086159e-01f, -2.33028561e-01f, -4.31041270e-02f, -4.85305376e-02f, -2.47991711e-01f,
  -2.12710604e-01f, 6.30738884e-02f, 1.07197940e-01f, 1.32317215e-01f, 1.64355300e-02f, -2.54004508e-01f, -1.86841458e-01f, 1.30631953e-01f, 2.83485860e-01f, -1.66080659e-03f,
  -1.91307981e-02f, 6.78626224e-02f, 1.98742360e-01f, 1.38123527e-01f, -1.67088538e-01f, 1.00567013e-01f, -2.56414771e-01f, -9.56175774e-02f, -2.08709061e-01f, -2.21846610e-01f,
  -9.19230208e-02f, -3.46625954e-01f, 9.14636254e-03f, -5.31911179e-02f, -2.05391362e-01f, 2.14595590e-02f, -7.88520500e-02f, -1.08903818e-01f, -7.53648728e-02f, -1.13826253e-01f,
  -2.08797991e-01f, -2.63661668e-02f, -9.83681753e-02f, -5.12876995e-02f, -4.35085110e-02f, -6.23608492e-02f, -4.92896326e-02f, -8.60787481e-02f, -9.46220011e-02f, -1.23091891e-01f,
  -2.30781764e-01f, -2.05588654e-01f, -2.07454205e-01f, -1.14450417e-01f, -1.46210358e-01f, -4.95810211e-02f, -1.81940824e-01f, -1.04980864e-01f, -1.68731406e-01f, -3.32297906e-02f,
  9.07148570e-02f, 1.24230944e-01f, 1.38149634e-01f, 6.51315674e-02f, 6.37836605e-02f, 5.19641042e-02f, 3.09791956e-02f, 4.27763052e-02f, 1.59344167e-01f, 1.15953118e-01f,
  9.92049575e-02f, -3.66258472e-02f, 1.11723714e-01f, -3.89322499e-03f, 1.30543187e-01f, 5.67544289e-02f, 6.76894486e-02f, 9.42630172e-02f, 1.06949084e-01f, 2.82528456e-02f,
  1.02433994e-01f, 5.84315211e-02f, 4.17273045e-02f, 1.28641322e-01f, 3.70240607e-03f, 6.84248284e-03f, 1.23410322e-01f, 1.61333725e-01f, 1.69310614e-01f, -1.33165764e-02f,
  1.44033507e-01f, -1.28119588e-01f, -8.39460362e-03f, 5.22717685e-02f, -1.04003102e-01f, -1.24750417e-02f, 2.20784638e-03f, -7.63914585e-02f, -1.30848050e-01f, -1.72353871e-02f,
  -1.28270105e-01f, 1.08306529e-02f, -3.75995301e-02f, -8.41347128e-02f, -1.05907973e-02f, 7.52614764e-03f, -1.25042677e-01f, -9.50523615e-02f, -1.46377102e-01f, -3.18678580e-02f,
  -1.58887550e-01f, 1.54549899e-02f, 6.75141886e-02f, -5.17333895e-02f, -7.89730325e-02f, 1.00120500e-01f, 6.78412542e-02f, 2.32286248e-02f, 6.54898882e-02f, 1.31558627e-01f,
  1.53091207e-01f, 9.75453034e-02f, 4.63865921e-02f, 2.33275250e-01f, 2.70568728e-01f, 1.95974201e-01f, 1.47219315e-01f, 1.66016221e-01f, 1.58421710e-01f, 1.42963365e-01f,
  1.33267492e-01f, -2.44750809e-02f, 5.78887202e-02f, 3.98618029e-03f, 1.34437799e-01f, 1.50570821e-03f, 4.52155247e-02f, 3.42196901e-03f, 1.66228071e-01f, 7.83807263e-02f,
  1.56741232e-01f, 1.07898064e-01f, 3.87513712e-02f, 1.10160381e-01f, 7.85096064e-02f, 5.50301112e-02f, 4.14739251e-02f, 8.28853026e-02f, 1.03168391e-01f, -3.83016723e-03f,
  1.07292607e-02f, 6.40757531e-02f, -3.02766846e-03f, -3.02495789e-02f, -1.90157332e-02f, -9.32427794e-02f, 8.68286565e-03f, 4.10200208e-02f, -5.82880899e-02f, 1.46470396e-02f,
  -9.35708880e-02f, -8.74500424e-02f, -4.15035896e-02f, 1.44105107e-02f, 5.97875714e-02f, -3.21769319e-03f, -8.47780779e-02f, -3.58552113e-02f, -3.75584736e-02f, -1.33477181e-01f,
  2.50370614e-02f, -4.13135365e-02f, 1.10171018e-02f, -4.86358721e-03f, 5.42320535e-02f, -2.94588953e-02f, -6.17482066e-02f, -2.62544900e-02f, -1.30708694e-01f, -8.06265324e-03f,
  6.14425465e-02f, 4.28659879e-02f, -3.91604081e-02f, 3.15340385e-02f, 1.77616533e-02f, -6.73262775e-02f, -2.33121254e-02f, -6.55149110e-03f, 5.71054555e-02f, -2.09945459e-02f,
  5.44181205e-02f, -6.43751249e-02f, 1.09750427e-01f, 8.40463489e-03f, -4.69567440e-03f, -7.26472512e-02f, 2.06712633e-02f, -2.23627184e-02f, 5.70933754e-03f, 1.93136819e-02f,
  -4.61039357e-02f, -6.00615032e-02f, 4.59323190e-02f, 2.54179575e-02f, 2.81628571e-03f, 2.61770301e-02f, 1.27682146e-02f, -5.89658692e-02f, 8.35625678e-02f, 1.87703930e-02f,
  9.13216248e-02f, 1.50057524e-02f, -1.84188038e-02f, 9.50090587e-03f, -3.28403041e-02f, -6.96876645e-02f, -6.67883903e-02f, -1.33518428e-01f, -1.30022585e-01f, 2.79902294e-02f,
  -6.88156858e-02f, -1.08007647e-01f, 2.81980690e-02f, 1.70350689e-02f, -4.26624417e-02f, 3.55015360e-02f, -1.06521301e-01f, 5.92654273e-02f, -2.62492448e-02f, -5.18537499e-02f,
  -1.35916516e-01f, -6.44427910e-03f, -1.26425736e-02f, -1.51106670e-01f, -3.25257182e-02f, -1.95324514e-02f, -1.49522632e-01f, -7.26376995e-02f, -3.16767283e-02f, -3.77494581e-02f,
  -4.43051040e-01f, -8.16792324e-02f, 2.80742168e-01f, -7.57327527e-02f, 9.69650745e-02f, 1.23471208e-01f, 8.98089036e-02f, -8.89442712e-02f, -9.43720564e-02f, -9.22643244e-02f,
  -2.30620459e-01f, -2.06122681e-01f, -1.70255587e-01f, -1.15550928e-01f, 7.87084997e-02f, 4.09047119e-02f, 2.40989372e-01f, 2.31099069e-01f, 4.51283976e-02f, -9.96315256e-02f,
  -4.57028858e-02f, -3.00154332e-02f, -1.08304285e-01f, -1.01436958e-01f, -1.03573747e-01f, -8.26538540e-03f, 1.12789698e-01f, 9.58085135e-02f, -1.05788790e-01f, -1.36697814e-02f,
  -1.52080104e-01f, -1.40969202e-01f, 7.15636164e-02f, -7.38375112e-02f, 5.15950918e-02f, -8.57611373e-03f, -2.32245903e-02f, 3.84215862e-02f, -8.06900710e-02f, 2.80494299e-02f,
  3.28737777e-03f, -1.58176705e-01f, -3.57568301e-02f, -5.96136004e-02f, -1.58151109e-02f, 3.53296697e-02f, 5.19419834e-02f, 9.34883133e-02f, 8.88866782e-02f, -1.13180518e-01f,
  -1.10842407e-01f, 4.95667383e-02f, 7.47194141e-02f, -3.65870893e-02f, 4.67384122e-02f, 2.52204742e-02f, -9.68602970e-02f, -6.23658970e-02f, 1.60666257e-02f, -1.79646909e-01f,
  1.43363792e-02f, 1.33197838e-02f, 3.28887021e-03f, 6.81810305e-02f, 4.97600287e-02f, 5.23475222e-02f, 2.84039676e-02f, 3.72814722e-02f, 1.56935621e-02f, -3.82861262e-03f,
  8.58804360e-02f, -4.19686735e-02f, 2.38909479e-02f, 7.00833127e-02f, 8.42509940e-02f, 8.32169056e-02f, 6.55638650e-02f, 6.05361387e-02f, 9.47962850e-02f, 8.80337507e-02f,
  -1.37395160e-02f, 1.43025041e-01f, 1.46472409e-01f, 1.00124516e-01f, 1.08731106e-01f, 1.60545260e-01f, -1.77481528e-02f, 4.38141525e-02f, -1.77608524e-02f, 6.43572137e-02f,
  -2.06368372e-01f, 1.18754357e-01f, -6.73563480e-02f, -8.81927758e-02f, -4.81879078e-02f, -1.65887587e-02f, -1.25923485e-01f, 7.63871446e-02f, -5.90440780e-02f, -7.12379394e-03f,
  -6.42472208e-02f, -1.16581470e-02f, 2.97170188e-02f, -5.65270521e-02f, -6.59798905e-02f, 4.02075611e-02f, -1.32701755e-01f, 1.64304581e-02f, -8.83647874e-02f, -3.58031541e-02f,
  -2.41332259e-02f, -1.18951306e-01f, -7.10960403e-02f, -2.07820553e-02f, -4.82159182e-02f, -3.55706662e-02f, 1.36442035e-02f, -7.86640123e-02f, -7.34311044e-02f, -1.83112890e-01f,
  1.24444440e-01f, -2.87022263e-01f, -9.76612344e-02f, -7.32570142e-02f, -4.92893793e-02f, 1.53318897e-03f, -1.47154465e-01f, 1.03270523e-01f, 1.75702602e-01f, -1.42160624e-01f,
  -1.32040009e-01f, 7.92956799e-02f, 1.23934023e-01f, -1.85488034e-02f, 1.06487952e-01f, -1.58898264e-01f, -4.18997817e-02f, 1.10368766e-01f, 1.71887428e-01f, 1.42196804e-01f,
  -9.42488164e-02f, 5.10979146e-02f, 1.76163055e-02f, -1.56100988e-02f, -7.08567500e-02f, -4.44535315e-02f, -2.76020449e-02f, -4.94416989e-02f, -1.59243226e-01f, -1.93604320e-01f,
  -3.30694951e-02f, -1.64870784e-01f, 2.89305579e-02f, 5.33888862e-03f, -2.72397939e-02f, 4.33709323e-02f, 3.91609082e-03f, 6.37203306e-02f, 5.02551943e-02f, -9.75645930e-02f,
  3.05688381e-02f, -1.07187880e-02f, 7.78454682e-03f, 3.14667001e-02f, -4.63893861e-02f, -3.28646526e-02f, -5.66066355e-02f, 4.90756147e-02f, -2.65051406e-02f, -2.38061305e-02f,
  -1.13649204e-01f, -5.93410470e-02f, -1.09238699e-02f, 8.39151070e-03f, -1.49118155e-02f, 1.30994827e-01f, -9.74896923e-02f, 3.83230485e-02f, -4.27941931e-03f, -1.09945908e-01f,
  4.79421811e-03f, 5.25003038e-02f, 1.17304344e-02f, -1.58944204e-02f, 3.84110101e-02f, 4.33183238e-02f, -1.27295135e-02f, -5.10330610e-02f, 7.61570558e-02f, 1.09204939e-02f,
  2.39885990e-02f, 6.66469708e-03f, 2.35348027e-02f, -3.51523384e-02f, -5.00538060e-03f, 4.34883870e-02f, -6.38244525e-02f, 7.59325270e-03f, -1.88727316e-03f, -1.15914270e-02f,
  6.80375993e-02f, 1.40876342e-02f, 6.43044785e-02f, -8.28103125e-02f, -4.76172343e-02f, 1.85122751e-02f, 9.53157544e-02f, 6.97670430e-02f, -1.88154820e-02f, -1.77028831e-02f,
  -5.91352349e-03f, 1.78637624e-01f, -3.30098113e-03f, 3.45998593e-02f, 7.01932237e-02f, 6.06263289e-03f, -5.25812916e-02f, -2.67185345e-02f, -8.48537758e-02f, 1.21426480e-02f,
  -1.48114190e-02f, 4.93034050e-02f, -5.20825945e-02f, 9.38756391e-02f, 6.04511760e-02f, 2.78708618e-03f, 1.62024628e-02f, 7.93259442e-02f, -1.86550580e-02f, -7.56146461e-02f,
  -4.14227732e-02f, 1.10548094e-01f, 5.22576161e-02f, -1.03852656e-02f, 7.56970346e-02f, 2.36025508e-02f, 8.22867379e-02f, 1.26428276e-01f, 1.41256750e-01f, 6.99966848e-02f,
  4.78723586e-01f, 2.21659899e-01f, 8.51477161e-02f, 3.90571170e-02f, -3.52226160e-02f, 5.64539246e-02f, 1.48331240e-01f, 1.87149912e-01f, 6.50933310e-02f, 1.82565246e-02f,
  -6.70505837e-02f, -1.77840084e-01f, -1.69362366e-01f, -1.21726185e-01f, 8.04065242e-02f, 6.31192476e-02f, 7.18705952e-02f, -5.45459166e-02f, -1.91913381e-01f, -1.34402752e-01f,
  -1.07672893e-01f, -7.00013414e-02f, -5.95428748e-04f, -1.09078154e-01f, -7.54383057e-02f, -1.38631180e-01f, -9.71886292e-02f, 2.38247123e-02f, -4.75041606e-02f, 1.10164143e-01f,
  -8.55102316e-02f, 2.49788091e-01f, -9.02988538e-02f, -1.23915002e-01f, 7.58178020e-03f, 1.50164999e-02f, -7.59971142e-02f, -3.44406366e-02f, 6.00326769e-02f, 2.74201985e-02f,
  1.14648603e-02f, -9.31170434e-02f, -1.00179493e-01f, -8.56986940e-02f, 5.81532810e-03f, -5.22343144e-02f, 8.53735059e-02f, -2.96858493e-02f, 2.08283192e-03f, 4.99312393e-02f,
  -7.05087110e-02f, 1.47747807e-02f, 4.38772887e-02f, -3.50752845e-02f, 2.26939991e-02f, -4.30436693e-02f, 3.54425237e-02f, 2.56825462e-02f, -7.34513775e-02f, 1.52671620e-01f,
  1.04207927e-02f, 3.52043025e-02f, 1.20164454e-02f, 7.59578031e-03f, 1.22847982e-01f, -2.73124576e-02f, 6.27865493e-02f, 2.84658745e-02f, 4.25654203e-02f, 4.96366918e-02f,
  7.79392868e-02f, 4.81132828e-02f, -4.34146300e-02f, 1.15682870e-01f, -1.50061110e-02f, 1.29437581e-01f, 7.99469501e-02f, 6.20997958e-02f, 4.00500707e-02f, 1.49909645e-01f,
  3.62374932e-02f, 9.41241682e-02f, -4.68599349e-02f, 1.31418556e-02f, 1.22356541e-01f, 3.98203768e-02f, 2.91947592e-02f, 4.71429043e-02f, 1.13386326e-01f, 8.07937309e-02f,
  -1.73601896e-01f, -1.24143660e-01f, 3.62586528e-02f, 4.87402901e-02f, 2.33035516e-02f, -1.04901940e-01f, -4.30179425e-02f, -1.19321711e-01f, -2.22679768e-02f, -9.84588116e-02f,
  -8.57101381e-02f, -3.28140743e-02f, -2.77786050e-02f, -6.23258054e-02f, -8.84192958e-02f, -1.13325752e-03f, 3.76743800e-03f, 2.68612858e-02f, -4.32134047e-02f, -1.25426114e-01f,
  -2.88203973e-02f, -8.57212208e-03f, 1.99190695e-02f, -6.10391721e-02f, -1.10258139e-03f, -6.47058859e-02f, -7.23845959e-02f, -6.62599411e-03f, -9.40853637e-03f, 2.89761350e-02f,
  7.34541565e-02f, -4.26305085e-02f, 9.84774083e-02f, -4.78161126e-02f, 6.80521056e-02f, 2.38335341e-01f, 3.18656027e-01f, 1.18278675e-01f, -6.89922050e-02f, -9.76407994e-03f,
  -8.86494890e-02f, -8.08837488e-02f, -5.13796769e-02f, 4.99502085e-02f, 1.35277346e-01f, 1.97983354e-01f, 8.55496824e-02f, 5.20167947e-02f, 1.63430683e-02f, 7.59885237e-02f,
  3.55912223e-02f, -1.22142248e-01f, -1.43292740e-01f, -1.22841321e-01f, -6.12881258e-02f, 9.78300441e-03f, -1.07196994e-01f, -1.15845323e-01f, -3.80306542e-02f, -3.87536623e-02f,
  -9.19644311e-02f, -2.95877224e-03f, 7.09920451e-02f, 8.17141235e-02f, 5.46434894e-02f, 1.25067169e-02f, 6.73674559e-03f, 6.10631779e-02f, 1.09615125e-01f, 5.87137863e-02f,
  2.20842585e-02f, 1.09841555e-01f, -3.36143114e-02f, -1.70843992e-02f, 8.68281275e-02f, 2.48922445e-02f, -8.31771269e-03f, -4.89847362e-02f, 4.32147346e-02f, 4.84715924e-02f,
  5.98438419e-02f, -4.95181754e-02f, 1.46191895e-01f, 9.04387906e-02f, 1.07647620e-01f, -1.02469129e-02f, 1.73067637e-02f, -4.32103649e-02f, 9.18653831e-02f, -3.84531803e-02f,
  -3.07623073e-02f, 1.83615349e-02f, 4.35816199e-02f, 8.11856985e-03f, 4.24408466e-02f, -4.77543101e-02f, 1.91434361e-02f, -3.16332728e-02f, -3.80381234e-02f, -6.37145806e-03f,
  3.79552282e-02f, -3.87361422e-02f, -2.13033296e-02f, -1.03662357e-01f, -5.93919903e-02f, 3.51577625e-02f, -1.38083575e-02f, 4.90331538e-02f, 4.87677343e-02f, 5.33123314e-02f,
  -3.71350870e-02f, 1.94362365e-02f, -4.88974899e-02f, 2.81249452e-02f, 5.88303432e-02f, -3.42569239e-02f, 6.11880049e-02f, -3.61792766e-03f, -8.25962499e-02f, -7.15434030e-02f,
  -2.50348508e-01f, 2.67551333e-01f, 1.12132870e-01f, 1.03759263e-02f, 1.55187054e-02f, -1.35873016e-02f, 4.62606223e-03f, 7.91746471e-03f, 4.66273986e-02f, 7.33812451e-02f,
  -1.40828232e-03f, 8.69242623e-02f, -3.86578329e-02f, 4.70963493e-02f, 3.73152308e-02f, 5.14574116e-03f, 1.52145520e-01f, 8.13038945e-02f, 8.46084133e-02f, 2.60876399e-02f,
  8.96919742e-02f, 1.30177796e-01f, 1.54736504e-01f, 8.12955573e-02f, 5.50317615e-02f, 1.45876691e-01f, 1.46649688e-01f, 5.21663018e-02f, 2.02972800e-01f, 1.15282461e-01f,
  3.79027307e-01f, -1.70094594e-01f, 2.35093907e-01f, 1.13373324e-01f, -1.62215546e-01f, -8.75073969e-02f, -2.38420457e-01f, -8.46540183e-02f, -5.98652475e-02f, -1.41678363e-01f,
  -8.58715028e-02f, 8.20601285e-02f, 1.92609653e-01f, 4.00350355e-02f, 1.56740397e-01f, -1.01274535e-01f, -5.91111854e-02f, 3.36788416e-01f, 2.62078017e-01f, -8.18299130e-02f,
  -2.21113876e-01f, 4.20748666e-02f, 1.29764482e-01f, 1.63746569e-02f, -1.56388909e-01f, 2.82396488e-02f, 8.32051337e-02f, -7.76334703e-02f, -1.51995614e-01f, -5.62460572e-02f,
  1.63191557e-01f, -2.84770485e-02f, 9.00324807e-02f, -8.93284380e-02f, -3.00106667e-02f, 1.19174130e-01f, -9.43039171e-03f, 1.10665567e-01f, -7.58999288e-02f, -2.45480076e-03f,
  -7.70894438e-03f, -5.75329699e-02f, 7.77323963e-03f, -1.05709940e-01f, -6.07535169e-02f, -5.78145608e-02f, 8.47856179e-02f, 1.95740853e-02f, 1.08918786e-01f, -3.44666429e-02f,
  -1.66884407e-01f, -6.89865043e-03f, 1.02802731e-01f, -1.49443103e-02f, 1.69791386e-03f, -4.21555266e-02f, -1.92584451e-02f, -4.98834923e-02f, 3.64717208e-02f, -7.01125860e-02f,
  -1.02721108e-02f, -6.67014048e-02f, 5.84475212e-02f, -3.01753003e-02f, -1.76495444e-02f, -9.92870480e-02f, 4.09693085e-02f, -6.16677105e-02f, 7.68970549e-02f, 3.68168280e-02f,
  -9.55324899e-03f, 4.57945578e-02f, 5.51152006e-02f, -2.02637147e-02f, -5.84197138e-03f, -6.00134656e-02f, -9.22254752e-03f, -7.31844921e-04f, -2.37387549e-02f, -1.88765433e-02f,
  5.75849377e-02f, 1.60391331e-02f, 4.25371416e-02f, 3.32377702e-02f, -3.87395807e-02f, -3.82755622e-02f, -6.98704273e-02f, 2.18123570e-02f, 9.91768911e-02f, -6.13455474e-02f,
  -8.74780584e-03f, 1.34051517e-01f, 1.88579801e-02f, 8.38817507e-02f, -3.16763893e-02f, -6.57193810e-02f, -3.58500443e-02f, 8.86285827e-02f, 5.53241707e-02f, 1.98798515e-02f,
  -4.54164632e-02f, 8.16031396e-02f, -7.57670030e-02f, -9.77355018e-02f, -2.11129859e-02f, 3.84523324e-03f, -9.68210995e-02f, 4.95133996e-02f, 6.66192314e-03f, 2.42778026e-02f,
  -5.95508777e-02f, -8.37188959e-02f, 4.50780205e-02f, 1.63602270e-02f, 2.79357117e-02f, 6.31087320e-03f, 4.52046022e-02f, -1.84266828e-02f, 3.63921374e-02f, 1.10025844e-02f,
  1.41691640e-01f, -2.59763181e-01f, 1.42242804e-01f, 4.12208363e-02f, 2.44346872e-01f, 2.16331914e-01f, 1.65069222e-01f, 1.72126904e-01f, -2.91203745e-02f, -1.47500671e-02f,
  -4.78408951e-03f, -3.63358185e-02f, -8.68718103e-02f, -9.69538167e-02f, 9.34205279e-02f, -1.23450123e-01f, 5.03864475e-02f, 1.21622033e-01f, 4.01619412e-02f, 4.63513024e-02f,
  -1.26221642e-01f, 2.66310852e-03f, -1.38037903e-02f, 1.15259383e-02f, -1.97895721e-01f, -4.95505752e-03f, -1.24045476e-01f, -7.66661093e-02f, -8.55305418e-02f, -2.87701428e-01f,
  -2.38388434e-01f, -1.05545558e-01f, 3.88160571e-02f, -1.28684402e-01f, -8.82717296e-02f, -1.52273938e-01f, -3.73056531e-02f, -4.30782177e-02f, -1.07365577e-02f, -5.82086667e-02f,
  -8.47013146e-02f, -7.61041865e-02f, -1.26522943e-01f, -9.48012099e-02f, 2.80333627e-02f, 1.99622177e-02f, -1.47670299e-01f, -1.90933701e-02f, -6.40692636e-02f, -1.60347372e-01f,
  -1.46916807e-01f, -7.09281070e-03f, 4.11978438e-02f, 1.56417321e-02f, -6.87653944e-02f, 8.31868052e-02f, 9.60166659e-03f, -7.09437579e-02f, -2.47827433e-02f, -1.88941419e-01f,
  2.23795827e-02f, 9.00844038e-02f, 7.19528645e-02f, 2.80055823e-03f, -2.10188515e-02f, 2.61862557e-02f, 2.62407139e-02f, -1.23032723e-02f, 7.81447068e-02f, -3.11511122e-02f,
  5.97612523e-02f, 8.28299597e-02f, 3.09199635e-02f, 4.37768549e-03f, -7.73526728e-02f, 7.99349174e-02f, 2.24863961e-02f, -9.77041125e-02f, -1.98563486e-02f, -8.08224156e-02f,
  4.08938229e-02f, 8.96813124e-02f, -1.33894831e-02f, -3.99655625e-02f, -1.68507919e-02f, 8.73180330e-02f, -1.53672341e-02f, 7.20466748e-02f, -6.77675307e-02f, -5.64098582e-02f,
  -8.03914592e-02f, 1.55923396e-01f, -1.58752665e-01f, -1.71645164e-01f, 4.38730717e-02f, -1.25782669e-01f, -1.45378947e-01f, -7.10056722e-02f, -4.80564833e-02f, -2.27412786e-02f,
  -8.22778121e-02f, -2.45044511e-02f, -1.99455526e-02f, -1.06356457e-01f, -3.41942310e-02f, 1.16044693e-02f, -1.45018145e-01f, 4.32286598e-02f, -4.17780168e-02f, -9.24341083e-02f,
  -7.60910986e-03f, -1.03322016e-02f, 1.23253725e-01f, 3.34504768e-02f, -7.12169111e-02f, 1.42078847e-02f, 5.22101261e-02f, 4.75454368e-02f, 4.69550677e-02f, 6.70808973e-03f,
  -2.95004547e-01f, 1.20347597e-01f, -4.94224066e-03f, -2.98738122e-01f, -2.42470816e-01f, -8.58023241e-02f, -1.04221597e-01f, -1.11576572e-01f, -2.11252302e-01f, -8.04457217e-02f,
  -1.13586590e-01f, -1.00979052e-01f, -1.82900116e-01f, -1.45661822e-02f, 4.18437831e-02f, -8.54202807e-02f, -1.06007278e-01f, -6.91645667e-02f, 3.40455621e-02f, 5.69675975e-02f,
  1.23344744e-02f, 1.09849609e-02f, -8.65253732e-02f, -1.01072593e-02f, 7.19386116e-02f, -1.23539083e-01f, 4.90442477e-02f, 7.46344477e-02f, 1.45938456e-01f, 1.52143776e-01f,
  1.99264228e-01f, 7.20123723e-02f, -1.08922854e-01f, -5.99505119e-02f, 2.38299109e-02f, 1.04967430e-02f, -2.73345485e-02f, -2.57449839e-02f, -4.88736443e-02f, -7.72375911e-02f,
  2.41141953e-03f, 8.32039490e-02f, 1.71228629e-02f, -3.58181894e-02f, -1.17214397e-01f, -2.15834752e-02f, -7.49897584e-02f, 6.14968687e-03f, -1.08261243e-01f, 9.93268862e-02f,
  6.50475621e-02f, -1.18150979e-01f, -1.31091431e-01f, -2.70357784e-02f, 9.47159231e-02f, -1.79691285e-01f, 5.19178659e-02f, 3.64577360e-02f, -1.06442325e-01f, 5.55064306e-02f,
  -3.36751305e-02f, 2.93031558e-02f, 1.16312519e-01f, 1.14531172e-02f, 4.42106742e-03f, 4.69793454e-02f, -5.05486615e-02f, 3.46775204e-02f, 5.79011850e-02f, 2.75379024e-03f,
  6.09489903e-02f, -6.86818361e-02f, 6.80971071e-02f, 7.21784309e-02f, -1.99720007e-03f, 5.29668219e-02f, 3.12817656e-02f, 1.05051072e-02f, 1.41583428e-01f, -2.61159260e-02f,
  1.56030431e-01f, 6.22671172e-02f, 4.14913939e-03f, 1.37483358e-01f, 8.54638368e-02f, 6.57997727e-02f, 8.55295211e-02f, 5.98581955e-02f, 6.79370239e-02f, 1.59246530e-02f,
  -3.20263654e-01f, -1.15353890e-01f, -1.20298401e-01f, 6.15967438e-02f, 1.40269622e-02f, -3.82007025e-02f, -6.58904836e-02f, -2.44076699e-02f, -1.05349489e-01f, 5.33928722e-02f,
  -5.84006570e-02f, -8.85737911e-02f, -6.63079545e-02f, 1.29429922e-02f, -7.47492462e-02f, -6.18441030e-02f, -3.60925421e-02f, -1.66809425e-01f, -1.03793927e-02f, -5.62208965e-02f,
  -2.36122832e-02f, -1.71578035e-01f, -1.32998183e-01f, -2.40423635e-01f, -1.52406216e-01f, -2.11275071e-01f, -4.27998863e-02f, -4.20207493e-02f, -2.00471967e-01f, -1.72824800e-01f,
  9.41861272e-02f, 2.96713471e-01f, 5.58440052e-02f, 1.03464788e-02f, -6.78573921e-02f, 4.62236255e-02f, 2.01197833e-01f, 1.83839142e-01f, -2.81141046e-02f, -7.41172507e-02f,
  -2.45146849e-03f, -5.45947663e-02f, -1.71758085e-01f, 4.39554416e-02f, 1.40218167e-02f, 8.94630775e-02f, 3.93819921e-02f, 1.70582347e-02f, 1.28705442e-01f, 1.74542218e-01f,
  -5.28339483e-03f, 1.34443775e-01f, 1.34975582e-01f, 1.58038765e-01f, 5.92361577e-02f, -1.34083748e-01f, 3.94448005e-02f, 1.84811920e-01f, 1.92407556e-02f, 3.58857065e-02f,
  -6.03005737e-02f, 1.99795216e-01f, -1.06522940e-01f, -8.15262794e-02f, 7.81029612e-02f, -2.90766507e-02f, -6.40090108e-02f, 7.29209790e-03f, -4.16866615e-02f, 4.94036786e-02f,
  -4.23879214e-02f, 2.31768563e-03f, -9.88607481e-03f, 1.05120465e-01f, 5.77494614e-02f, 8.10667314e-03f, -4.56324406e-02f, 9.28402469e-02f, 7.54469335e-02f, 4.10424583e-02f,
  -8.08529407e-02f, 5.71947396e-02f, -9.07543674e-03f, -2.38632206e-02f, -1.13079678e-02f, -6.03104867e-02f, -2.13760287e-02f, 5.44824190e-02f, -1.37096485e-02f, 8.74803811e-02f,
  -3.58879007e-02f, 1.08938858e-01f, 9.95573625e-02f, 1.10941954e-01f, -2.58516856e-02f, 1.94678809e-02f, 4.65042926e-02f, 1.14836749e-02f, 1.45396329e-02f, 3.49178687e-02f,
  9.67829153e-02f, 3.82704251e-02f, 1.48724765e-01f, 4.59673535e-03f, -5.23198433e-02f, 6.41982853e-02f, 2.54647974e-02f, 9.02715325e-02f, -6.19240701e-02f, 5.42197078e-02f,
  -3.89801408e-03f, 6.66002557e-02f, 8.79678652e-02f, 8.49548131e-02f, -4.34783213e-02f, -2.99531091e-02f, 1.20483153e-01f, 1.33431092e-01f, -2.27729827e-02f, 9.67889950e-02f,
  -2.18819439e-01f, 3.26111354e-03f, -1.19962938e-01f, -6.58018216e-02f, -8.52889474e-03f, -7.55706728e-02f, -5.60651347e-03f, 1.94607638e-02f, -4.54571396e-02f, -1.07781980e-02f,
  -1.62442513e-02f, 9.43010226e-02f, 4.39331084e-02f, 4.77092005e-02f, 2.99900770e-02f, -7.33101815e-02f, -8.90022516e-02f, -9.47213694e-02f, -5.01589142e-02f, 1.64536908e-02f,
  -1.10280424e-01f, -1.46445081e-01f, -2.22800240e-01f, -1.46269321e-01f, 2.64163502e-03f, -1.55743852e-01f, -9.59417745e-02f, -8.75187963e-02f, -1.45994335e-01f, -8.08572471e-02f,
  -1.37455896e-01f, 8.77381936e-02f, 2.08051950e-01f, 1.57253668e-02f, 2.70024538e-01f, 2.85600215e-01f, 3.77634972e-01f, 4.57170531e-02f, 2.10943762e-02f, 1.07808933e-01f,
  -5.03938906e-02f, -1.38058171e-01f, -1.80299893e-01f, -1.12132519e-01f, -1.36013091e-01f, 1.22786976e-01f, 1.29965335e-01f, -8.87960643e-02f, -3.44415158e-02f, 7.45718554e-02f,
  8.76471922e-02f, 4.71976697e-02f, 7.60432258e-02f, 1.08942896e-01f, 1.44820243e-01f, 3.48196328e-02f, 1.52941078e-01f, 6.81879297e-02f, 1.40843362e-01f, -7.50020985e-03f,
  1.44286841e-01f, 1.27212843e-02f, 1.55297011e-01f, 9.31311771e-02f, 1.61897540e-01f, 9.24826637e-02f, 1.71647474e-01f, 1.60287991e-01f, 8.13086033e-02f, 1.92668974e-01f,
  8.13777596e-02f, 7.29416907e-02f, 4.49705496e-02f, 4.63603586e-02f, 1.95231065e-01f, 1.85547039e-01f, 1.47571042e-01f, -1.11184632e-02f, 1.79328814e-01f, 2.03291968e-01f,
  6.94644451e-02f, 1.90860525e-01f, 2.07848459e-01f, 2.40569159e-01f, 3.80375087e-02f, 1.13826416e-01f, 2.37112001e-01f, 1.21100239e-01f, 8.23349804e-02f, 1.61476940e-01f,
  -4.40189801e-02f, -1.03238851e-01f, -1.36938775e-02f, -4.58758734e-02f, -1.35478958e-01f, -3.65481861e-02f, -1.36171535e-01f, -9.76717249e-02f, -5.90561144e-02f, 2.55801925e-03f,
  -1.09938301e-01f, -3.89772728e-02f, -3.66987735e-02f, -1.30608767e-01f, -1.45102799e-01f, -6.57484010e-02f, -8.59897956e-02f, -6.28333492e-03f, -1.04800895e-01f, -3.92192742e-03f,
  -1.88976064e-01f, -1.28349271e-02f, -8.67014937e-03f, -8.38439763e-02f, -9.07140672e-02f, -7.67199919e-02f, -1.64280176e-01f, -8.85963440e-02f, -6.16456158e-02f, -7.19671100e-02f,
  4.81239222e-02f, 1.64180011e-01f, 1.08692117e-01f, -5.64841628e-02f, 1.19420730e-01f, 1.59158200e-01f, 5.13358451e-02f, 9.39082801e-02f, 8.51661935e-02f, 1.73906863e-01f,
  8.78870487e-02f, -1.73908491e-02f, 1.61103517e-01f, 1.14253275e-01f, 9.54698473e-02f, 1.27366692e-01f, 1.17464691e-01f, 1.31147861e-01f, 1.57652289e-01f, 1.50454566e-01f,
  1.95540637e-01f, 1.61749378e-01f, 6.51950091e-02f, 1.50534734e-01f, 2.88066361e-02f, 3.66996154e-02f, 1.03007630e-01f, 2.76289493e-01f, 2.01723710e-01f, 2.64538914e-01f,
  -3.84851068e-01f, 2.74963588e-01f, -1.05796665e-01f, 1.48586882e-02f, 3.24658230e-02f, 1.29933938e-01f, 2.18268096e-01f, 2.11498514e-01f, 6.08472079e-02f, 1.25120312e-01f,
  1.96435228e-01f, 1.76291971e-03f, 1.18748583e-01f, 1.60632022e-02f, -3.68669517e-02f, 9.68903750e-02f, 9.48516652e-02f, -1.73567832e-01f, -2.00052485e-01f, -1.46157861e-01f,
  -8.35338309e-02f, -1.01911962e-01f, -2.02610552e-01f, -9.92121100e-02f, 4.68663080e-03f, -1.23288006e-01f, -3.88539582e-02f, -1.50439635e-01f, -7.63510913e-02f, -1.71910912e-01f,
  -2.15429589e-01f, 9.08800140e-02f, 5.24851754e-02f, -2.91747060e-02f, 1.34665057e-01f, 4.17312384e-02f, 1.00303642e-01f, 5.31216599e-02f, 1.31924763e-01f, 5.64553291e-02f,
  1.14158064e-01f, 1.11528046e-01f, 7.58292852e-03f, -1.41327912e-02f, -1.10709835e-02f, -1.71600133e-02f, 1.74904436e-01f, -1.26419645e-02f, 6.01914003e-02f, 3.15296948e-02f,
  1.60305589e-01f, -1.80666614e-02f, -8.29199776e-02f, 2.39146557e-02f, 2.71364152e-02f, -7.42611811e-02f, 6.81263357e-02f, -1.39834687e-01f, -1.29439101e-01f, -1.11681551e-01f,
  -1.23098724e-01f, -2.83814445e-02f, -4.89035770e-02f, -2.14373283e-02f, -4.18153815e-02f, 2.01038923e-02f, 4.33532447e-02f, 8.14360753e-03f, -1.07873067e-01f, -4.67041731e-02f,
  -8.26079398e-03f, -8.64401534e-02f, -7.29172081e-02f, -1.12850800e-01f, -8.41394067e-02f, -5.23046590e-02f, -1.38937876e-01f, -3.02402321e-02f, -2.37685349e-02f, 3.86294797e-02f,
  -1.88818146e-02f, -9.14744809e-02f, -3.98120694e-02f, -8.72620568e-02f, -4.30799462e-02f, -7.87625015e-02f, -7.32794479e-02f, 4.07076627e-02f, -5.50487973e-02f, -3.74650247e-02f,
  1.93481203e-04f, 1.81137770e-01f, -2.77493652e-02f, 4.62894067e-02f, 1.03885747e-01f, 1.30142150e-02f, -2.44046319e-02f, 7.55629092e-02f, 4.93643545e-02f, 7.05304518e-02f,
  -4.13467623e-02f, 4.35052719e-03f, 1.00209005e-01f, 1.05423138e-01f, 2.45121457e-02f, 2.82751918e-02f, 1.38645127e-01f, -4.08936851e-03f, 5.10413647e-02f, 1.83429420e-02f,
  9.87769738e-02f, -9.58995298e-02f, -1.68671250e-01f, 4.94135469e-02f, 5.13090799e-03f, -5.46096973e-02f, -8.79634246e-02f, -1.79980062e-02f, -6.10223264e-02f, -1.37906551e-01f,
  -2.61108994e-01f, 9.32045802e-02f, 2.36312985e-01f, 3.52628180e-04f, -1.68454051e-02f, 5.01375273e-02f, 2.42251247e-01f, 7.08570853e-02f, 3.34454812e-02f, 1.73745394e-01f,
  -1.33613735e-01f, -6.79380819e-02f, 2.05942336e-03f, 1.29567802e-01f, 8.06210786e-02f, 3.35298568e-01f, 2.83624113e-01f, 1.49874806e-01f, 1.05921276e-01f, 2.60600895e-02f,
  6.68686554e-02f, 3.37850526e-02f, -6.37024045e-02f, 5.59880026e-02f, -3.37050967e-02f, 4.68148142e-02f, 1.20018432e-02f, 4.66439361e-03f, -2.69187335e-03f, 2.08060354e-01f,
  1.08983867e-01f, -2.13120043e-01f, -1.09169986e-02f, -1.46706179e-01f, -8.91871378e-02f, -4.45433296e-02f, -6.25808984e-02f, -1.54244872e-02f, -3.87678370e-02f, 6.32633362e-03f,
  -1.05046686e-02f, -4.58723120e-02f, -1.06695630e-01f, -2.23870333e-02f, -1.50930118e-02f, -8.38359371e-02f, -3.00549846e-02f, 2.51469179e-03f, -2.27665771e-02f, 2.89534498e-02f,
  -1.49200503e-02f, 3.37745249e-02f, -7.05458522e-02f, 2.84086410e-02f, -6.54127151e-02f, -6.24740906e-02f, -9.93672684e-02f, -1.29717335e-01f, -1.41314745e-01f, -8.70048329e-02f,
  -1.28695229e-02f, 2.86492873e-02f, -2.21448280e-02f, 5.47370613e-02f, 1.58727635e-02f, 1.45520911e-01f, 1.03415057e-01f, 3.74484323e-02f, -2.47967808e-04f, 5.09487204e-02f,
  1.11525007e-01f, 1.45852391e-03f, 1.03414632e-01f, 4.64374684e-02f, 1.10943198e-01f, 1.31566629e-01f, 8.58791452e-03f, 1.80515647e-01f, 3.52223329e-02f, 8.05320367e-02f,
  6.46768659e-02f, 8.84159654e-02f, 7.18612671e-02f, 9.33228061e-02f, 5.84202306e-03f, 7.15497136e-02f, 1.12671904e-01f, -6.60270080e-02f, 4.20290232e-02f, 1.51638940e-01f,
  -1.76423132e-01f, -9.12783295e-02f, 2.60927938e-02f, 4.72103246e-02f, 4.65796627e-02f, -5.45318611e-02f, -6.81499988e-02f, 7.10213929e-02f, -5.75005636e-02f, -2.50713173e-02f,
  -3.45505737e-02f, 5.39493514e-03f, -8.76201615e-02f, -4.81750444e-02f, 4.10548039e-02f, -7.69762844e-02f, 1.27959341e-01f, 6.79012313e-02f, 3.69468592e-02f, -1.36949178e-02f,
  -3.73580977e-02f, 1.43025964e-01f, 1.21337801e-01f, -1.85965765e-02f, -2.35833582e-02f, 1.31204119e-02f, 9.97276306e-02f, -9.61025134e-02f, 8.83623585e-03f, 1.39658883e-01f,
  1.78174168e-01f, 1.10450715e-01f, 6.95199966e-02f, 1.18857391e-01f, -7.24552851e-03f, 7.58808330e-02f, 1.59824625e-01f, 1.45305432e-02f, 3.56660523e-02f, -3.55011821e-02f,
  -4.58433330e-02f, -1.53008908e-01f, -1.01181023e-01f, -1.06311418e-01f, -5.50266244e-02f, 1.16557591e-01f, 2.56090730e-01f, 1.15703426e-01f, 1.08717427e-01f, 6.83714673e-02f,
  1.82313949e-01f, 2.83706546e-01f, 2.53878891e-01f, 1.73804417e-01f, 1.48029357e-01f, 1.14353336e-02f, 2.00420409e-01f, 1.62363961e-01f, 5.01336791e-02f, 1.83985814e-01f,
  -1.73871577e-01f, -2.34424621e-02f, 6.04962297e-02f, 9.13170576e-02f, 6.75605014e-02f, 1.54066011e-01f, 8.41827597e-03f, 7.18859062e-02f, 2.99334358e-02f, 1.79807529e-01f,
  1.15351051e-01f, 4.47650701e-02f, 1.46210849e-01f, 4.76590656e-02f, 2.25849852e-01f, 5.47710918e-02f, 1.78275272e-01f, 2.51422942e-01f, 1.34466484e-01f, 1.20755993e-01f,
  1.17476255e-01f, 1.85548067e-01f, 3.91278341e-02f, 8.06257427e-02f, -8.14446900e-03f, 1.62124645e-03f, 8.08851123e-02f, 1.30290508e-01f, 4.59166132e-02f, 1.44179821e-01f,
  9.34593938e-03f, -6.59936219e-02f, -6.08570874e-02f, -1.02841064e-01f, -7.99135342e-02f, -9.56998914e-02f, -1.00993969e-01f, -1.31954834e-01f, 5.18751293e-02f, -1.06236838e-01f,
  -1.73629940e-01f, 3.27415741e-03f, -8.24834257e-02f, -2.20423155e-02f, -1.10552713e-01f, -5.84223792e-02f, -1.06572039e-01f, 1.52939977e-02f, -7.95032829e-02f, -3.19444351e-02f,
  -6.81453664e-03f, -8.52153972e-02f, -1.23224162e-01f, -8.43054131e-02f, -6.50589243e-02f, -1.38879836e-01f, -6.87124580e-02f, -1.76502779e-01f, -7.03232884e-02f, -8.26036707e-02f,
  2.98498143e-02f, 6.16029128e-02f, 1.70016184e-01f, 7.52654299e-02f, 2.42360622e-01f, 1.97864756e-01f, 7.31092840e-02f, 1.32924467e-01f, 4.40430455e-02f, 1.76565573e-01f,
  8.84942934e-02f, 8.97494778e-02f, 3.95166986e-02f, 9.86745805e-02f, 1.88262939e-01f, 1.30675599e-01f, 1.63149163e-01f, 1.12606823e-01f, 1.69162035e-01f, 1.52763888e-01f,
  2.11916029e-01f, 1.13299720e-01f, 4.96413186e-02f, 1.90156475e-01f, 1.34294406e-01f, 1.38053745e-01f, 9.85893086e-02f, 1.63709342e-01f, 9.82813388e-02f, 1.98510796e-01f,
  -3.05046499e-01f, 2.88319945e-01f, 2.52364933e-01f, 8.96513388e-02f, 2.13600680e-01f, 1.63575590e-01f, 2.73921549e-01f, -1.74139868e-02f, -1.15790427e-01f, 1.78582177e-01f,
  3.71114425e-02f, -5.62309809e-02f, -1.49459809e-01f, -1.57492206e-01f, -4.91186194e-02f, 1.69454500e-01f, 2.57152170e-01f, -7.75366575e-02f, -1.41454607e-01f, 2.22245557e-03f,
  5.03519457e-03f, -2.91774478e-02f, -1.37617394e-01f, -1.64024364e-02f, 8.79852921e-02f, -4.90706302e-02f, 1.92460746e-01f, 5.59259169e-02f, 1.52300894e-01f, 3.42105091e-01f,
  2.50654608e-01f, 8.76334459e-02f, -6.75507188e-02f, 4.61258134e-03f, 4.31376360e-02f, 1.81124732e-02f, 7.86203295e-02f, -1.26473582e-03f, 7.81255290e-02f, 2.81197578e-02f,
  3.05057317e-02f, 8.38126764e-02f, 1.38372272e-01f, 6.00512289e-02f, 7.36830309e-02f, -1.56383272e-02f, 1.31108873e-02f, 7.61731043e-02f, 4.72552478e-02f, 1.43818542e-01f,
  2.17566222e-01f, 1.98364407e-01f, 1.34112746e-01f, 1.33631647e-01f, 1.08032651e-01f, 9.00509879e-02f, 1.61336586e-01f, 1.34492069e-01f, -1.97372809e-02f, 1.33602843e-01f,
  -2.60853698e-03f, -1.13460068e-02f, -2.66719349e-02f, -6.29558936e-02f, -1.12698585e-01f, -5.45415878e-02f, -9.66660827e-02f, -2.13368349e-02f, -1.52273878e-01f, -7.68463016e-02f,
  -1.05536692e-01f, 2.27689110e-02f, -1.13901854e-01f, -1.33496881e-01f, -6.66219294e-02f, 4.11506034e-02f, -6.37179464e-02f, -1.10576868e-01f, -9.13718417e-02f, -4.14156392e-02f,
  -4.52036038e-02f, -1.48106784e-01f, -5.08794524e-02f, -1.65645018e-01f, -7.57803097e-02f, 1.08177671e-02f, -5.76209165e-02f, -6.10909723e-02f, -1.59186944e-01f, -1.18383378e-01f,
  -1.44024834e-01f, 1.07475311e-01f, 3.07298042e-02f, -1.04189880e-01f, 1.75832465e-01f, 7.66523108e-02f, 1.43424630e-01f, 6.68380633e-02f, 6.07678518e-02f, -3.54518555e-02f,
  -1.23539064e-02f, 4.53858823e-02f, 3.89877558e-02f, -1.29667986e-02f, 2.74579842e-02f, 7.43808672e-02f, 9.00046714e-03f, 6.97447881e-02f, -5.61947972e-02f, -1.29828891e-02f,
  -4.07634676e-02f, -4.98747341e-02f, -6.30543521e-03f, -2.12978199e-02f, 3.05772275e-02f, -5.74918129e-02f, 2.01360155e-02f, -8.34481642e-02f, -1.13341942e-01f, -5.53171709e-02f,
  -1.23183534e-01f, -6.30932376e-02f, 1.27954885e-01f, 3.86625230e-02f, 3.69326100e-02f, 6.80480525e-02f, 3.11701782e-02f, 3.83888977e-03f, -1.64572243e-02f, -1.22214057e-01f,
  -1.65955186e-01f, -1.33881703e-01f, -2.00815946e-01f, -1.37390107e-01f, -3.26919893e-04f, 9.76354182e-02f, 1.02662787e-01f, 1.11214064e-01f, 1.00507379e-01f, -1.06212027e-01f,
  -7.44349211e-02f, 8.27903226e-02f, 2.08657980e-02f, -3.28400396e-02f, 5.93438298e-02f, 9.14623681e-03f, -7.81505033e-02f, -5.60538061e-02f, -2.62301378e-02f, 6.90757409e-02f,
  -7.76166394e-02f, -2.04678223e-01f, 6.30242005e-02f, -8.95508081e-02f, -5.24570271e-02f, -6.74977973e-02f, -9.75347403e-03f, -7.08736703e-02f, -1.02392867e-01f, 2.85181473e-03f,
  -1.53378338e-01f, -5.57897389e-02f, -8.03498477e-02f, -1.04821876e-01f, -6.76405728e-02f, -1.74561385e-02f, 6.10306598e-02f, -9.00893752e-03f, -1.08203381e-01f, -1.74107682e-02f,
  2.15750989e-02f, 3.18987528e-03f, 8.29443559e-02f, 4.30526286e-02f, 3.28781642e-02f, -5.89286089e-02f, -5.08384220e-02f, -1.23083048e-01f, 3.31380963e-02f, -5.62723130e-02f,
  -1.04367938e-02f, 1.18129112e-01f, -1.32074580e-02f, -9.10178944e-02f, 6.92114159e-02f, 2.16505472e-02f, 1.20749773e-05f, 4.48595956e-02f, -4.69828919e-02f, 6.91512153e-02f,
  -2.09048577e-02f, -9.29024536e-03f, -2.71393433e-02f, 8.60894322e-02f, 3.46345641e-02f, 7.92041570e-02f, -6.18356764e-02f, -4.22499143e-02f, -1.01635326e-02f, -5.95539808e-02f,
  -6.93475381e-02f, 4.25535738e-02f, -8.23920965e-02f, -7.49215707e-02f, 3.08606364e-02f, -3.23209837e-02f, -1.98774301e-02f, -1.15349737e-03f, 3.92385237e-02f, 3.52905691e-02f,
  -2.35176235e-01f, -1.82881236e-01f, -1.43476665e-01f, 1.03193121e-02f, -5.29312529e-02f, -5.75056598e-02f, -1.52526006e-01f, -6.01958372e-02f, -6.97965249e-02f, -5.39273471e-02f,
  -1.57498226e-01f, -9.76759791e-02f, -6.67435154e-02f, -7.22819567e-02f, -6.93387762e-02f, -2.10180730e-02f, 6.65560039e-03f, -9.58170667e-02f, -6.67343587e-02f, -9.20723155e-02f,
  3.60918641e-02f, 1.27821937e-01f, 5.70080951e-02f, -9.56672356e-02f, 3.88302505e-02f, 4.58228923e-02f, -6.72810450e-02f, -3.80065963e-02f, -6.53743446e-02f, 6.55235574e-02f,
  3.73103470e-01f, -6.25636354e-02f, 6.40289932e-02f, 1.48643553e-01f, -1.07435204e-01f, -1.13769948e-01f, -1.46805989e-02f, -6.03399947e-02f, -5.39910980e-02f, 5.88012710e-02f,
  -3.37038971e-02f, -1.01464074e-02f, 1.16937608e-01f, 6.80657253e-02f, 2.20587075e-01f, -3.43405381e-02f, 1.75351053e-01f, 3.11031073e-01f, 1.24736302e-01f, 3.03064715e-02f,
  -9.23866481e-02f, 4.26964946e-02f, 1.99689656e-01f, 2.52398886e-02f, -1.14827372e-01f, -1.06022961e-01f, 4.45289314e-02f, 9.17137861e-02f, -5.89151308e-02f, -3.51608954e-02f,
  3.16978968e-03f, 9.84365046e-02f, -3.98105383e-02f, -1.30443992e-02f, -5.57968840e-02f, 2.88152453e-02f, 1.20347468e-02f, -1.07942976e-01f, -3.93535569e-02f, -6.25163764e-02f,
  -1.30477518e-01f, -1.24543421e-02f, -9.17414948e-03f, -5.85392155e-02f, -9.22842473e-02f, 4.88658389e-03f, 4.12614681e-02f, -5.20966575e-03f, -4.79156412e-02f, 5.83064230e-03f,
  -1.29666608e-02f, 4.22530435e-02f, 2.35927645e-02f, 4.32267264e-02f, -1.29173815e-01f, 1.34221548e-02f, 3.19308788e-02f, -9.18172225e-02f, 6.94515109e-02f, -2.89347358e-02f,
  6.00259118e-02f, 6.68822750e-02f, 1.07533662e-02f, -4.83626723e-02f, 1.44303422e-02f, 2.56428961e-02f, 3.28986831e-02f, 7.52211586e-02f, 2.39140969e-02f, -5.64411916e-02f,
  -1.42114598e-03f, 1.10701788e-02f, 3.20737101e-02f, 5.86614944e-02f, -8.94970074e-02f, 4.01497260e-02f, -1.48206223e-02f, -6.38769791e-02f, 2.02439912e-02f, 4.09714356e-02f,
  4.97181043e-02f, 4.58056154e-03f, 2.07214933e-02f, 4.74259891e-02f, -2.05593929e-03f, 9.03820843e-02f, -1.39100188e-02f, -2.69745756e-02f, -6.58788681e-02f, -4.47663404e-02f,
  -7.93900490e-02f, 1.32210851e-01f, 9.17765573e-02f, -4.64256555e-02f, -1.54824685e-02f, -4.98197600e-02f, -6.28895536e-02f, 3.66701721e-03f, 2.95494180e-02f, 4.26698625e-02f,
  -8.74951556e-02f, -6.17699102e-02f, 3.10565904e-02f, -1.01881504e-01f, -7.44451135e-02f, -7.82261044e-02f, -9.56610367e-02f, 1.19520552e-01f, -3.60552035e-02f, -7.56121427e-02f,
  3.56553867e-03f, 3.44520807e-02f, 3.35161127e-02f, -6.28564134e-02f, 3.85685116e-02f, 1.29171327e-01f, -1.04549602e-01f, 6.46955986e-03f, -2.93140784e-02f, -7.22152591e-02f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.73750710e-01f, 1.44886477e-02f, -3.87137860e-01f, 1.95596561e-01f, 8.32550079e-02f, 1.49049193e-01f, 1.49153039e-01f, 2.36893073e-01f, 2.28222921e-01f, 1.02443723e-02f,
  -8.88717845e-02f, -8.44224263e-03f, -2.15313792e-01f, -1.62775159e-01f, 1.37640527e-02f, -1.48927078e-01f, -1.75306462e-02f, -1.35400712e-01f, 6.34652078e-02f, 1.12698846e-01f,
  8.49273577e-02f, 1.68721512e-01f, 2.41449535e-01f, 1.69017673e-01f, 3.79043482e-02f, 2.78545599e-02f, -1.45280570e-01f, -1.35250568e-01f, -1.79238960e-01f, -2.07388267e-01f,
  -5.50651789e-01f, -3.43193077e-02f, 2.80445889e-02f, 8.66714865e-02f, -1.10360876e-01f, 1.13312349e-01f, -1.73994228e-02f, 3.71260126e-03f, 2.06767485e-01f, 1.58450142e-01f,
  -7.99018983e-03f, -3.88548449e-02f, -2.75953729e-02f, 5.65552451e-02f, 1.30781114e-01f, 7.32254004e-03f, 3.84997167e-02f, 6.00298755e-02f, -1.22734167e-01f, -1.34267569e-01f,
  -1.36191756e-01f, -1.95444804e-02f, -7.42632896e-02f, -5.57314232e-02f, -4.99700718e-02f, -9.31339413e-02f, 5.55923134e-02f, 3.26094627e-02f, -6.53679073e-02f, 2.72676833e-02f,
  -2.54306853e-01f, 4.38610166e-02f, -1.55560955e-01f, 5.78439720e-02f, 9.16464552e-02f, 3.22920345e-02f, 1.68230738e-02f, 1.04808606e-01f, 2.34561488e-02f, 1.61795706e-01f,
  7.39316270e-02f, -1.47900105e-01f, -1.87989116e-01f, 5.92946038e-02f, 7.15905847e-03f, -1.52615234e-01f, 2.11405642e-02f, -3.40871140e-02f, -2.30446905e-01f, -2.36768126e-02f,
  -1.29986331e-01f, -6.83699101e-02f, -2.06475798e-02f, -1.63018063e-01f, -1.11835063e-01f, -5.65947816e-02f, 2.81351395e-02f, 6.67208619e-03f, 7.25241229e-02f, 7.65011385e-02f,
  -1.04161337e-01f, -4.23795760e-01f, -9.88158882e-02f, 4.39301990e-02f, -7.31433034e-02f, 8.97066202e-03f, -2.33539999e-01f, -5.18139750e-02f, 6.46445751e-02f, 4.76062447e-02f,
  -2.36821137e-02f, -6.83893561e-02f, -1.14440270e-01f, 9.67639014e-02f, 7.51164332e-02f, 3.00767403e-02f, 2.25907122e-03f, -4.65299189e-02f, -1.19520293e-03f, -1.27839416e-01f,
  5.39037585e-02f, 1.04998231e-01f, 1.40434638e-01f, 9.06375274e-02f, 9.57390592e-02f, 7.26845860e-02f, 8.56726170e-02f, 1.12591743e-01f, 5.18031567e-02f, 2.89004028e-01f,
  -5.56821585e-01f, -1.45517632e-01f, 2.57244915e-01f, -3.91937792e-03f, 1.51746705e-01f, 8.23440775e-02f, 1.38168544e-01f, 1.11358032e-01f, -5.77279143e-02f, -1.83956660e-02f,
  -2.08391547e-02f, 1.11707002e-01f, 1.37154236e-01f, 1.39881298e-01f, 5.76535463e-02f, 2.51739681e-01f, 2.64771223e-01f, 1.47418201e-01f, 1.35621399e-01f, 1.12402327e-01f,
  1.14121228e-01f, -2.32836157e-02f, -1.17651694e-01f, 2.42988486e-02f, 4.94913757e-02f, 1.06740229e-01f, -6.20651096e-02f, 5.61357029e-02f, -4.07120027e-02f, 8.74242857e-02f,
  3.36988419e-01f, -2.58184552e-01f, 1.97463948e-02f, -1.93623751e-01f, -6.27437308e-02f, -1.20588139e-01f, 1.00143738e-02f, -1.33758048e-02f, -2.05100290e-02f, 6.70829648e-03f,
  2.75020394e-02f, -1.53194234e-01f, -1.98217146e-02f, -7.67144486e-02f, -7.04236850e-02f, -1.45050168e-01f, -2.13626370e-01f, -5.07027581e-02f, -4.09409329e-02f, -7.29841441e-02f,
  2.41114125e-02f, 6.82275593e-02f, 1.34409979e-01f, 4.76755984e-02f, 5.47642186e-02f, -4.67164554e-02f, -2.04922389e-02f, -6.40107095e-02f, 4.10523862e-02f, -3.34461592e-02f,
  1.04007423e-01f, 2.40149256e-02f, 1.26259878e-01f, -8.17205664e-03f, 1.32246921e-02f, -2.23191287e-02f, -9.61076934e-03f, 1.29574820e-01f, 2.19558179e-02f, 1.13697741e-02f,
  6.78399429e-02f, 7.91454464e-02f, 8.36527720e-02f, -6.71513006e-02f, 4.36487682e-02f, 8.23519379e-02f, 4.17213999e-02f, 8.69102590e-03f, -2.17581689e-02f, 5.34463674e-02f,
  3.43623050e-02f, 1.09309666e-02f, -1.27518997e-01f, 2.83955839e-02f, -6.28356040e-02f, -2.92461342e-03f, 4.18756865e-02f, -8.04753080e-02f, -1.45368036e-02f, -5.38040660e-02f,
  2.97587067e-01f, -4.63737622e-02f, 6.33089393e-02f, 5.89095913e-02f, -1.18020847e-01f, -2.22320557e-01f, 8.87111127e-02f, -5.56492470e-02f, -9.26963836e-02f, -3.21080722e-02f,
  -2.67496007e-03f, -2.59932503e-02f, -5.16284518e-02f, -3.20228301e-02f, 1.32882129e-03f, -6.99230060e-02f, -1.41001657e-01f, 2.88505591e-02f, 1.18798219e-01f, -6.31595850e-02f,
  -5.26613407e-02f, 3.23053300e-02f, 2.30820432e-01f, 1.27823532e-01f, 9.68129858e-02f, 1.26288220e-01f, 1.70917571e-01f, 1.17919594e-01f, 1.42077461e-01f, -1.03183566e-02f,
  5.05516052e-01f, -6.46197498e-01f, 4.88745123e-02f, 1.62141621e-01f, -9.48346779e-03f, 4.16876562e-02f, -3.80527318e-01f, 8.22552070e-02f, 1.13939643e-01f, -1.55863747e-01f,
  -2.13327389e-02f, 5.08950174e-01f, 4.33716655e-01f, 3.00940782e-01f, 1.21304467e-01f, -2.80961812e-01f, -2.72087127e-01f, 2.37147659e-01f, 4.22449619e-01f, -1.22609355e-01f,
  -1.40534088e-01f, -1.57172397e-01f, 3.12029682e-02f, -5.36864586e-02f, -2.09059238e-01f, 1.14954770e-01f, -1.82436988e-01f, -2.83110946e-01f, -2.84504443e-01f, -3.14043224e-01f,
  2.28188440e-01f, -2.26319641e-01f, 1.22500472e-01f, -1.00336157e-01f, -7.50966519e-02f, -5.75408749e-02f, -1.96544826e-02f, -8.50570723e-02f, -9.06484351e-02f, -1.80327639e-01f,
  -6.11206368e-02f, -1.23579122e-01f, -5.13059348e-02f, -7.50320330e-02f, -5.61916009e-02f, -5.55708259e-02f, -2.01611310e-01f, -3.86191159e-02f, -9.32834819e-02f, -1.40424475e-01f,
  -2.13043869e-01f, -2.31679708e-01f, 9.90844667e-02f, -7.16264993e-02f, 1.91024356e-02f, 2.82103382e-02f, -1.00970849e-01f, -1.59720937e-03f, 2.40484141e-02f, -7.50789270e-02f,
  3.45058404e-02f, 1.49939796e-02f, -8.44560191e-02f, 3.34264077e-02f, -5.32897748e-02f, -2.67139953e-02f, -4.72573973e-02f, 6.30692393e-02f, 3.89584005e-02f, -5.40269315e-02f,
  7.90808443e-03f, 6.26786277e-02f, 8.32885057e-02f, -6.30945638e-02f, -5.94015010e-02f, -1.22753941e-01f, -7.02455789e-02f, -9.92767140e-03f, 2.90429089e-02f, 8.55100341e-03f,
  1.02879619e-02f, -2.03042887e-02f, -5.72478920e-02f, 5.29199746e-03f, -1.46334931e-01f, 9.31615233e-02f, 4.34325747e-02f, -5.52485995e-02f, 8.13201368e-02f, -1.12768047e-01f,
  3.72062415e-01f, -4.08453681e-02f, 1.41003415e-01f, -2.99970917e-02f, -1.70380138e-02f, 4.19411017e-03f, -1.33083656e-01f, -8.87795985e-02f, -2.36362759e-02f, 2.17234697e-02f,
  -8.34386721e-02f, 4.02985886e-02f, -8.37965161e-02f, -3.24133821e-02f, -3.67200747e-02f, 3.19885951e-03f, -1.65512428e-01f, -2.97073461e-02f, -1.08041592e-01f, -5.80444597e-02f,
  -1.90050140e-01f, 5.33141159e-02f, 2.95015037e-01f, 2.54125237e-01f, -5.63521683e-02f, 2.95972317e-01f, 1.32140219e-01f, 1.14231333e-01f, 1.42053530e-01f, 7.48475045e-02f,
  -5.72874367e-01f, 9.38330442e-02f, 5.08222222e-01f, -4.69827205e-01f, 6.36763871e-02f, 1.75762400e-01f, 6.20534644e-02f, -1.98604628e-01f, -1.97040051e-01f, 2.85886414e-02f,
  1.36980414e-01f, -2.91417331e-01f, -2.26436868e-01f, -2.63284504e-01f, -1.83645636e-01f, 2.30054557e-01f, 1.92749336e-01f, -7.28581548e-02f, -3.60636026e-01f, -3.08446795e-01f,
  -3.18672866e-01f, -4.26127672e-01f, -3.68863374e-01f, -7.93473125e-02f, -2.44481146e-01f, -2.17384800e-01f, 1.11547902e-01f, -7.33689889e-02f, 1.56197444e-01f, 8.98042843e-02f,
  2.34913989e-03f, 1.29973337e-01f, 5.38440328e-03f, -2.05685701e-02f, 2.65165213e-02f, 3.59618068e-02f, 2.53196917e-02f, -8.09861273e-02f, 5.64388856e-02f, 1.05878919e-01f,
  6.47369847e-02f, -9.23108216e-03f, -6.38574138e-02f, 7.88406655e-03f, 2.68369894e-02f, 3.67796496e-02f, 2.02607457e-02f, 1.10182492e-02f, 8.11421946e-02f, 7.01563656e-02f,
  1.61680311e-01f, 6.99342266e-02f, 1.83449104e-01f, 1.19252898e-01f, 6.80113584e-02f, -3.79037634e-02f, 1.35530174e-01f, -1.13439020e-02f, 2.16338933e-01f, -3.19846906e-02f,
  -3.85887660e-02f, 7.94740841e-02f, 4.26151007e-02f, -1.32795349e-01f, -7.76252523e-02f, 1.76649354e-02f, -3.16463858e-02f, 2.14864835e-02f, 2.30414718e-02f, -8.09059516e-02f,
  -6.77501038e-02f, 1.00658201e-01f, -5.63855506e-02f, -4.90550362e-02f, -3.64959496e-03f, -3.92877162e-02f, 8.15204903e-02f, -3.16108577e-02f, 9.90880281e-02f, -5.19146845e-02f,
  -1.55926257e-01f, 5.58201559e-02f, 7.74277151e-02f, -2.51396038e-02f, 1.77947640e-01f, 4.79370840e-02f, 1.72309861e-01f, 4.65078764e-02f, 7.05042556e-02f, 1.96906462e-01f,
  -4.10192102e-01f, 3.24779689e-01f, -2.18890741e-01f, -3.98509838e-02f, 6.05871193e-02f, 1.81837305e-01f, 5.12133576e-02f, -2.20653415e-02f, 3.01444773e-02f, -1.16057679e-01f,
  3.90686095e-02f, -1.50395602e-01f, 5.56498915e-02f, -5.07439580e-03f, -8.86529759e-02f, 3.76103050e-03f, -3.97160165e-02f, -8.12553316e-02f, 1.25482544e-01f, 1.03395373e-01f,
  4.61033657e-02f, 3.22702974e-02f, -8.85065347e-02f, -4.22925986e-02f, -7.00046197e-02f, -4.91290062e-04f, -1.59584180e-01f, -2.25110929e-02f, 9.50911641e-02f, -2.18699634e-01f,
  -7.08427548e-01f, -3.09176371e-02f, 3.71119231e-01f, -2.22238630e-01f, -1.45457536e-01f, -2.27236599e-01f, -3.04468255e-02f, -3.07012260e-01f, -1.56040534e-01f, 2.13720322e-01f,
  -2.50057261e-02f, -2.38260522e-01f, -5.27876019e-02f, -1.66767657e-01f, -2.61558592e-01f, 1.45312175e-01f, 1.28288707e-02f, -8.74630809e-02f, -3.98532540e-01f, -5.00926793e-01f,
  -3.95704031e-01f, -3.71047229e-01f, -4.08280164e-01f, -2.35038891e-01f, 1.23167492e-01f, -1.28843740e-01f, 1.54769763e-01f, -6.44146279e-02f, -1.05073854e-01f, 1.83482811e-01f,
  3.49768430e-01f, -3.49639565e-01f, 5.34063554e-04f, -2.27535546e-01f, -7.83656389e-02f, -4.53666300e-02f, -2.01325174e-02f, 3.46790738e-02f, 2.40791868e-02f, 8.04953575e-02f,
  -2.32477803e-02f, -6.12418167e-02f, -3.39499675e-03f, -2.68024225e-02f, -1.52451731e-02f, 8.27179402e-02f, 1.09677343e-02f, -7.50011206e-02f, -1.03623115e-01f, 1.35142937e-01f,
  -2.22434774e-02f, -5.86446188e-02f, 8.80870000e-02f, -8.32413603e-03f, -6.03011735e-02f, -8.45855772e-02f, -4.16661315e-02f, -1.27053946e-01f, -2.11645514e-02f, 9.33855250e-02f,
  1.43723443e-01f, 1.35016829e-01f, -2.60569286e-02f, -4.33825180e-02f, 7.90026113e-02f, 8.45323130e-02f, 4.27233689e-02f, 5.73856244e-03f, -1.22248352e-01f, -4.14744243e-02f,
  3.86034101e-02f, 3.49684805e-02f, 4.35367273e-03f, 1.17499158e-02f, -1.26773715e-02f, -8.25226493e-03f, -1.08971618e-01f, 1.40582845e-02f, 7.96532780e-02f, -2.02874057e-02f,
  -1.18894309e-01f, -9.84321833e-02f, 4.71297950e-02f, -4.82897870e-02f, -1.20785505e-01f, -9.95706320e-02f, 2.16950625e-02f, -3.63082737e-02f, 1.87554490e-02f, -9.69367325e-02f,
  1.95765551e-02f, -1.50044113e-01f, 1.32258713e-01f, -2.59835217e-02f, -5.00984564e-02f, 1.92952773e-03f, 8.27774704e-02f, -8.66364017e-02f, 8.67845714e-02f, 4.00069207e-02f,
  2.15994008e-02f, 6.67642057e-02f, 8.27661008e-02f, 4.73009758e-02f, 1.30692601e-01f, 3.26348543e-02f, -9.60561167e-03f, 6.06632233e-02f, 4.39516502e-03f, 1.43794730e-01f,
  4.35340889e-02f, -2.44458187e-02f, 1.24535225e-01f, 1.28791437e-01f, 4.35527638e-02f, 9.57260951e-02f, 8.52199718e-02f, 1.06429636e-01f, 1.08630054e-01f, 2.46443763e-01f,
  -2.56275594e-01f, -5.87940037e-01f, 1.70996398e-01f, -4.42878790e-02f, 2.22039908e-01f, 4.47389364e-01f, 8.48806351e-02f, 9.13814902e-02f, -8.31047073e-03f, -2.24059418e-01f,
  -3.96272242e-01f, -3.43019754e-01f, -3.46159756e-01f, -1.79212794e-01f, -1.68991700e-01f, -9.49679315e-02f, 1.01835690e-01f, 2.14649096e-01f, 2.76118934e-01f, 2.24966884e-01f,
  3.34079564e-02f, -7.12698139e-03f, -9.66806933e-02f, 5.43527529e-02f, -2.42327422e-01f, -6.91711456e-02f, -1.05710879e-01f, 2.85139270e-02f, -8.26233402e-02f, -3.23005617e-01f,
  -4.29270864e-02f, 8.68210867e-02f, -3.64917330e-03f, 2.98502650e-02f, 6.71098754e-02f, -1.25559151e-01f, 9.24948528e-02f, 5.32149039e-02f, 5.78435697e-02f, 2.00869590e-02f,
  1.07712932e-01f, -7.36677721e-02f, 5.82942776e-02f, 7.14972019e-02f, 2.44312678e-02f, 6.89880028e-02f, -8.69084522e-03f, -4.45808694e-02f, 4.73385453e-02f, 3.31801213e-02f,
  -7.37223253e-02f, -9.57922637e-03f, 8.34335983e-02f, 1.68736696e-01f, 5.67155555e-02f, 4.86262590e-02f, -1.92497559e-02f, 1.30960017e-01f, 1.62859872e-01f, 2.93231406e-03f,
  4.59778532e-02f, -1.22960135e-01f, 1.56365350e-01f, 2.36933157e-02f, 9.23139080e-02f, 9.23350826e-03f, 5.28392196e-02f, 2.50283461e-02f, 3.81367654e-03f, -8.82380307e-02f,
  1.51831629e-02f, -2.07033940e-02f, -5.72315864e-02f, 1.12416018e-02f, -7.72079155e-02f, -1.32873893e-01f, 1.80879533e-02f, -2.56206952e-02f, 3.31819616e-02f, 5.57919368e-02f,
  -6.60956278e-02f, -2.94210166e-02f, 3.24496813e-02f, 3.13501172e-02f, 2.50777956e-02f, 5.51793501e-02f, -3.41909826e-02f, 3.25083584e-02f, -1.93634219e-02f, -1.71923712e-01f,
  -2.07828611e-01f, 1.75876796e-01f, -1.58621594e-01f, -1.66670933e-01f, 3.29360589e-02f, -1.19411968e-01f, -6.54678941e-02f, -4.06087115e-02f, 3.68863791e-02f, 5.42823076e-02f,
  8.08335245e-02f, -1.38510969e-02f, -7.19019920e-02f, -2.77701318e-02f, 1.39287114e-01f, -3.62004945e-03f, -1.00885190e-01f, -1.73045561e-01f, 7.68161938e-02f, -3.27157825e-02f,
  -1.17496960e-02f, 1.31642655e-01f, 4.04039063e-02f, 6.46684244e-02f, 8.16113725e-02f, -1.03169749e-03f, -4.60626222e-02f, 9.18138400e-02f, 1.48581728e-01f, -4.68516685e-02f,
  5.87496459e-01f, 1.99244112e-01f, -6.30116642e-01f, 2.90728241e-01f, -3.88266534e-01f, -4.56791550e-01f, -3.11658770e-01f, 4.60090004e-02f, 9.04865041e-02f, 3.49108204e-02f,
  2.07243506e-02f, 5.05424254e-02f, 5.13655087e-03f, -2.31003404e-01f, -2.51464546e-01f, -2.19111189e-01f, -3.69926840e-01f, -4.54075277e-01f, -4.98816490e-01f, -3.94759297e-01f,
  -1.17904209e-01f, -2.06636963e-03f, -2.05049347e-02f, -1.85173407e-01f, 7.80705086e-05f, -2.37607852e-01f, -3.29032838e-01f, -2.18964830e-01f, -3.80457282e-01f, -1.68424860e-01f,
  -3.18665981e-01f, -3.52589227e-02f, -1.84830695e-01f, -6.14787405e-03f, 1.64488405e-02f, 1.74246103e-01f, -4.27260697e-02f, -3.63069400e-02f, 1.26848459e-01f, -2.51849910e-04f,
  6.62207752e-02f, -6.03701361e-02f, 4.33745943e-02f, -2.37860054e-01f, -6.94998950e-02f, -5.24660908e-02f, -1.21992871e-01f, -2.96322823e-01f, -1.93661645e-01f, -5.76956980e-02f,
  -2.07430556e-01f, -1.83325112e-01f, -5.99237680e-02f, -1.97881386e-01f, -2.35887051e-01f, -1.86253875e-01f, -2.29717284e-01f, -3.07866156e-01f, -4.10530120e-01f, 1.09646589e-01f,
  1.16176695e-01f, 7.70531595e-02f, -1.03792541e-01f, -9.31605026e-02f, 2.36894563e-01f, -4.66358736e-02f, 3.34146880e-02f, -1.06183305e-01f, -7.64758373e-03f, 1.80259198e-02f,
  2.14253180e-02f, -6.44976199e-02f, 5.24346791e-02f, 4.63708378e-02f, -6.92704543e-02f, -3.33931819e-02f, 4.63007130e-02f, -1.68136265e-02f, 8.74745548e-02f, -6.32620454e-02f,
  -8.25122148e-02f, -2.00579483e-02f, -7.52266450e-03f, 6.78637996e-02f, -1.36931613e-01f, -3.49266566e-02f, 2.67716777e-02f, -4.27749865e-02f, -7.58756325e-02f, -8.62537473e-02f,
  2.95512825e-01f, -1.23390168e-01f, 2.98634678e-01f, 8.27566832e-02f, -4.58057709e-02f, -7.58305565e-02f, 1.24849528e-01f, 5.08273765e-02f, 1.33334711e-01f, 1.77828610e-01f,
  -1.98583901e-01f, 1.73840553e-01f, 8.63884985e-02f, -8.47974420e-02f, -8.58093277e-02f, -1.36001825e-01f, -9.59545933e-03f, -1.32531777e-01f, -1.66800946e-01f, 1.02536775e-01f,
  1.18986636e-01f, -3.92169319e-02f, 2.15285659e-01f, 2.23858535e-01f, 7.77245983e-02f, 2.57500950e-02f, 9.54863653e-02f, -2.17887852e-02f, -8.35971534e-02f, 4.08416569e-01f,
  7.85249233e-01f, 5.13175488e-01f, -8.49432766e-01f, 4.95753706e-01f, -2.90763289e-01f, -6.30417883e-01f, -2.07564205e-01f, -8.51562619e-03f, 2.56722540e-01f, 2.59552836e-01f,
  -2.58374363e-01f, -3.22518289e-01f, -3.51305574e-01f, -4.67371941e-01f, -4.19987559e-01f, -8.65158960e-02f, -1.20528035e-01f, -4.82306540e-01f, -6.97921038e-01f, -1.58164248e-01f,
  3.25506926e-01f, 5.99507987e-01f, 4.01874453e-01f, 4.19496298e-02f, 3.17468554e-01f, -7.45612532e-02f, -2.96186004e-02f, 2.34459162e-01f, -1.29047558e-01f, 2.15422750e-01f,
  -2.25757986e-01f, 1.42357662e-01f, -6.45078003e-01f, -3.68999951e-02f, -3.08740377e-01f, 1.57951599e-03f, -1.82514921e-01f, -1.92658186e-01f, -1.73945099e-01f, 3.22527476e-02f,
  -2.75422037e-01f, -2.21540585e-01f, -2.97801495e-01f, -8.16028193e-02f, 1.27449408e-01f, -4.03972641e-02f, 2.10665554e-01f, -1.68636486e-01f, -2.43707493e-01f, -1.55547678e-01f,
  8.45462680e-02f, 2.33294908e-02f, -5.12315869e-01f, -2.80811608e-01f, -3.87965471e-01f, -3.46513659e-01f, -2.05657840e-01f, -3.16577464e-01f, -4.74192679e-01f, 4.11248028e-01f,
  2.23747529e-02f, -1.72121406e-01f, 5.53374663e-02f, 1.46075949e-01f, 1.52793095e-01f, -1.41944200e-01f, 4.16647568e-02f, -1.33603783e-02f, -1.14442706e-01f, -5.83552048e-02f,
  -1.10948466e-01f, -1.46853402e-01f, -1.40218616e-01f, 1.21346816e-01f, -4.77453023e-02f, -9.09242108e-02f, -1.18828565e-01f, 1.65128425e-01f, -2.31935028e-02f, -3.01515236e-02f,
  -6.16080686e-02f, -4.22066860e-02f, 9.48550180e-03f, 5.04099652e-02f, -7.51568079e-02f, -4.15961109e-02f, 5.95626421e-03f, -7.52153024e-02f, -1.13991857e-01f, 8.97810310e-02f,
  2.17905030e-01f, -3.87412578e-01f, 1.01206467e-01f, -1.17844082e-01f, -5.25024459e-02f, -1.25118509e-01f, 6.30192235e-02f, -3.34007517e-02f, -1.05514608e-01f, 4.39949296e-02f,
  -2.21369848e-01f, -1.04043908e-01f, -2.01187078e-02f, -9.88673642e-02f, -7.56038725e-02f, -1.08145684e-01f, 1.15604848e-01f, -5.74110225e-02f, -2.02900216e-01f, -1.39044682e-02f,
  3.19084018e-01f, 8.43729749e-02f, 1.37229279e-01f, -7.62633607e-02f, 8.68006423e-02f, -1.28654331e-01f, -1.32480532e-01f, -1.96972266e-01f, -2.58795798e-01f, 6.38039947e-01f,
  7.17973769e-01f, 1.10571995e-01f, 1.96834370e-01f, 2.29683459e-01f, 6.74640089e-02f, 2.88499184e-02f, -1.86095893e-01f, -2.56940862e-03f, 9.20379981e-02f, 1.67731687e-01f,
  2.75474727e-01f, 1.59522280e-01f, 1.54993385e-01f, 1.40517652e-01f, 1.46339342e-01f, 2.52525397e-02f, -3.15876044e-02f, 1.93210363e-01f, 2.29451939e-01f, 2.58707613e-01f,
  7.25321919e-02f, 6.49127960e-02f, 3.40196401e-01f, 1.44570842e-01f, 8.56574401e-02f, 1.17823035e-01f, 7.19610136e-03f, 9.10853520e-02f, 8.55056643e-02f, 3.89924049e-02f,
  2.62305379e-01f, 2.18374938e-01f, -1.20629437e-01f, 4.91730636e-03f, 4.11364324e-02f, 5.08766621e-03f, 1.97728500e-02f, -6.79012686e-02f, -1.23465126e-02f, -1.31202042e-01f,
  -5.30221909e-02f, 3.10131665e-02f, -4.45997752e-02f, 2.64405496e-02f, 7.98134804e-02f, 2.07206700e-02f, 1.80336051e-02f, -4.82972041e-02f, -9.21321288e-02f, 8.63068029e-02f,
  3.38203087e-02f, 2.19866168e-03f, 1.10353641e-02f, 3.01784603e-03f, 4.77602109e-02f, 1.44523382e-01f, -9.78261046e-03f, 9.22688320e-02f, 5.00588417e-02f, 6.38389960e-03f,
  1.59993529e-01f, 1.54304266e-01f, 2.94506013e-01f, 1.97198406e-01f, 2.43448168e-01f, 1.66565150e-01f, 8.52025207e-03f, 8.64440799e-02f, -1.28181987e-02f, 1.11354321e-01f,
  2.18350627e-02f, 1.07279852e-01f, 9.22142565e-02f, 1.33113027e-01f, 1.12425208e-01f, 1.94352344e-01f, 1.83737546e-01f, 1.57075580e-02f, 7.93648064e-02f, 9.34966281e-02f,
  2.64695622e-02f, -1.13258115e-03f, 3.37783247e-02f, 1.12819225e-02f, 1.68654144e-01f, 2.15321258e-01f, 2.23471612e-01f, 1.52693108e-01f, 1.70002460e-01f, 1.64366394e-01f,
  -5.05922198e-01f, 1.30092092e-02f, 8.24613944e-02f, -5.04829772e-02f, 2.32820269e-02f, 1.49469664e-02f, 3.02692764e-02f, -3.06467470e-02f, -7.55210295e-02f, -1.65546685e-01f,
  -2.89743282e-02f, 6.75702002e-03f, -1.69048920e-01f, -1.01223469e-01f, -5.65287285e-02f, -1.78858832e-01f, 2.13969070e-02f, -1.50532350e-01f, -3.58749218e-02f, -1.12226278e-01f,
  -1.80834994e-01f, -1.16706714e-01f, -1.38853729e-01f, -2.27651253e-01f, 1.81626342e-02f, -2.72394177e-02f, -6.05226345e-02f, -2.58056838e-02f, -3.57750989e-02f, -1.71391726e-01f,
  2.88873821e-01f, -1.98181599e-01f, 3.55918795e-01f, 2.09942669e-01f, 2.49045864e-01f, 1.57598957e-01f, 8.16452503e-02f, 4.71989997e-02f, 2.37499755e-02f, -5.03790081e-02f,
  -1.03667058e-01f, -2.72862375e-01f, -2.11686462e-01f, -2.13201955e-01f, -1.62440658e-01f, 6.71850517e-02f, 1.08304307e-01f, 1.08184710e-01f, 4.71607409e-02f, -7.07976595e-02f,
  -1.62110448e-01f, 6.83086663e-02f, 2.27498859e-02f, -1.00318067e-01f, -6.52511343e-02f, -1.01517625e-01f, 1.20341904e-01f, 7.57570490e-02f, -3.11945863e-02f, 1.31047726e-01f,
  7.41384849e-02f, 3.01535036e-02f, -2.13662505e-01f, -2.75163352e-01f, 3.39011103e-02f, -8.67330730e-02f, -3.55347358e-02f, 5.18889818e-03f, -4.63026166e-02f, -1.39097283e-02f,
  -6.67079613e-02f, 3.89050953e-02f, -1.00078031e-01f, 5.63179106e-02f, 6.78196549e-02f, 1.11593321e-01f, -7.33713061e-02f, -1.78664662e-02f, -4.56942096e-02f, -1.26350492e-01f,
  9.19487048e-03f, 1.05587803e-01f, 1.36585131e-01f, -3.87092195e-02f, -1.12082683e-01f, -9.96796861e-02f, -8.00589174e-02f, 1.66107074e-03f, -2.87365504e-02f, 7.96816405e-03f,
  -1.02141730e-01f, -1.19034141e-01f, -1.46564208e-02f, 1.49136141e-01f, -5.81942536e-02f, 2.49176826e-02f, 1.26991346e-01f, 1.29669636e-01f, 9.13307965e-02f, 1.60160244e-01f,
  1.23581260e-01f, 9.91173983e-02f, 1.52443305e-01f, 1.70969918e-01f, 1.35616362e-01f, 1.99503705e-01f, 1.24110222e-01f, 1.14161335e-01f, -8.03794153e-03f, 5.14793657e-02f,
  -6.43376820e-03f, 1.53465435e-01f, 1.31011814e-01f, 1.41486183e-01f, 8.36692080e-02f, 1.53218269e-01f, 1.33034453e-01f, 3.90613824e-02f, 3.10704522e-02f, 5.49297556e-02f,
  -4.26821262e-02f, -3.15004438e-01f, -1.82246268e-02f, 1.56102665e-02f, 8.28979909e-02f, -2.64391936e-02f, -1.85571052e-02f, 6.80853799e-02f, 7.70184919e-02f, 5.63112684e-02f,
  4.64226604e-02f, 7.22108632e-02f, 2.02856143e-03f, -4.74675670e-02f, 1.63927436e-01f, 1.35781825e-01f, 3.81419882e-02f, -3.25776748e-02f, -2.88926028e-02f, 9.14325714e-02f,
  -1.04602508e-01f, 3.36113051e-02f, 1.67955995e-01f, -4.07675430e-02f, -4.29442227e-02f, 1.04172915e-01f, 3.98779847e-02f, -4.03681435e-02f, -8.03582184e-03f, 2.39658710e-02f,
  -8.48475546e-02f, -4.03604686e-01f, -1.34709999e-01f, -1.56614110e-02f, -4.04441118e-01f, -4.41936016e-01f, -4.32047844e-01f, 9.52953659e-03f, -1.68691337e-01f, -5.95761359e-01f,
  -6.51301146e-01f, -2.12492943e-01f, -1.02290072e-01f, 2.14408580e-02f, 1.15866043e-01f, -3.21992248e-01f, -2.95949578e-02f, 5.22113919e-01f, 5.51743627e-01f, 4.93164808e-02f,
  -1.06879741e-01f, 2.39674553e-01f, 4.54944581e-01f, 4.88337785e-01f, 1.00574583e-01f, 1.20662831e-01f, -2.79755332e-02f, 8.17531496e-02f, -1.83122113e-01f, 1.05806328e-01f,
  -4.87701029e-01f, 1.26294106e-01f, 4.30721343e-02f, 1.31966487e-01f, -2.27471650e-01f, 8.78385752e-02f, -1.09144673e-01f, 5.61697483e-02f, -6.33060560e-02f, 1.83822848e-02f,
  -2.35816672e-01f, -1.02918958e-02f, -6.87630251e-02f, -6.47573918e-02f, 1.61582641e-02f, 1.73417866e-01f, 2.20485330e-01f, 3.82758617e-01f, 1.20643310e-01f, -1.70810672e-03f,
  -2.56338894e-01f, -1.27403796e-01f, -3.15104052e-02f, 2.12306678e-02f, 1.97800606e-01f, 1.93775222e-01f, 1.15270860e-01f, 4.60231960e-01f, 2.18366221e-01f, 1.03077061e-01f,
  -9.31187794e-02f, 1.93261728e-02f, -2.17455804e-01f, -1.40166029e-01f, -1.65698126e-01f, -1.88503116e-01f, 1.49771884e-01f, -3.01077012e-02f, -4.12725732e-02f, 4.86049168e-02f,
  6.27637953e-02f, 1.15963246e-03f, 1.60356760e-01f, 1.34136304e-01f, 1.54331937e-01f, -3.41730751e-02f, -3.29135405e-03f, 5.14361709e-02f, 7.30592459e-02f, -1.18743367e-01f,
  8.61552730e-02f, 1.32081343e-03f, -1.49579957e-01f, 1.12762086e-01f, 1.07802008e-03f, 1.80094138e-01f, -4.61379737e-02f, -4.06882651e-02f, -3.91902216e-02f, -1.01467729e-01f,
  -4.88065928e-01f, 1.92853548e-02f, -4.50034291e-01f, 1.81188151e-01f, -1.33323506e-01f, 1.77330509e-01f, -2.16481835e-02f, -8.88810754e-02f, -2.15145536e-02f, -7.89024085e-02f,
  -7.80811999e-03f, -4.14404310e-02f, -2.20636114e-01f, 5.79301715e-02f, 1.07717318e-02f, -1.03040405e-01f, -3.99252743e-01f, -1.20067969e-01f, -3.07494476e-02f, -6.63729087e-02f,
  -4.74337190e-02f, -2.38147005e-01f, -5.24952173e-01f, -5.81619918e-01f, -3.11451107e-01f, -2.00833499e-01f, -6.27408400e-02f, -8.06551054e-02f, -3.81891847e-01f, -4.67456341e-01f,
  4.58013713e-01f, 1.90332636e-01f, 4.82635558e-01f, 1.19518645e-01f, -3.81943770e-02f, -1.98527444e-02f, 5.40678091e-02f, -1.35140121e-01f, -3.18941474e-01f, -6.88356161e-02f,
  -2.03958690e-01f, -2.62433946e-01f, -2.00229570e-01f, -1.43187180e-01f, 1.83475286e-01f, 2.42057979e-01f, 2.89416641e-01f, 4.96586412e-01f, 3.44921619e-01f, 4.98671383e-02f,
  3.86145376e-02f, 2.34638020e-01f, 4.17172253e-01f, 1.65948421e-01f, -4.52274233e-02f, -7.09896609e-02f, 9.56398845e-02f, 1.32192940e-01f, 2.20937550e-01f, 3.19309145e-01f,
  -8.30475539e-02f, 8.76073465e-02f, -2.61290789e-01f, -1.59797847e-01f, -3.14467885e-02f, 6.65124580e-02f, -2.70728171e-02f, 5.19958660e-02f, -9.36661363e-02f, 1.31624207e-01f,
  1.02322847e-01f, 9.48380586e-03f, -5.45357317e-02f, 2.80801998e-03f, 1.55482572e-02f, -2.85024326e-02f, 1.20009474e-01f, 1.58480465e-01f, 2.44852086e-03f, 2.64597870e-02f,
  -8.92452374e-02f, 1.18827321e-01f, 2.34020561e-01f, -9.47685093e-02f, -7.02921301e-02f, -1.71599954e-01f, -1.21686868e-02f, -7.85052031e-02f, 3.73080513e-03f, 7.15355668e-03f,
  -2.86714554e-01f, 2.21146718e-01f, 1.79892913e-01f, 9.57216993e-02f, 7.20046908e-02f, -7.23852962e-02f, 2.60962490e-02f, 7.12643415e-02f, 1.36222050e-01f, 2.79176563e-01f,
  4.43058833e-02f, -1.82403048e-04f, 1.20118134e-01f, -1.33404046e-01f, -1.54493481e-01f, 1.79292597e-02f, 2.26733387e-01f, -6.61449507e-02f, 1.50499806e-01f, -2.90823460e-04f,
  -5.13882153e-02f, -1.72807206e-03f, -2.06230223e-01f, 1.78689547e-02f, -1.33431688e-01f, -1.43588528e-01f, -1.59160584e-01f, -7.98108801e-02f, -5.57416938e-02f, -7.63819665e-02f,
  -4.80994761e-01f, -3.27480026e-02f, -2.98759997e-01f, -1.20233200e-01f, -9.16076005e-02f, -6.02684431e-02f, -1.05867989e-01f, 8.96868482e-03f, -5.27618378e-02f, 1.84623210e-03f,
  1.55890048e-01f, -8.00775439e-02f, -7.58542046e-02f, 3.37052904e-02f, -2.01577440e-01f, -2.97027767e-01f, -5.65204658e-02f, -1.77576710e-02f, -1.34202419e-03f, 8.25169124e-03f,
  1.27352327e-01f, 4.17302251e-02f, -1.92415655e-01f, -3.31687182e-01f, -3.60364288e-01f, -4.48027968e-01f, -1.60709023e-01f, -3.32457602e-01f, -2.70052165e-01f, -1.92040995e-01f,
  2.89640129e-01f, -3.15107584e-01f, 2.02447295e-01f, 2.86118656e-01f, 1.20514967e-01f, -3.07409108e-01f, -8.08950722e-01f, -3.32217842e-01f, 2.11952850e-01f, -3.51646960e-01f,
  -2.23036632e-02f, 5.51981807e-01f, 3.00829530e-01f, 9.04317424e-02f, -3.87249529e-01f, -6.85558498e-01f, -4.47654575e-01f, 4.08956110e-02f, 1.11549035e-01f, -3.80663991e-01f,
  -2.33362690e-01f, -2.63972767e-02f, 6.91886470e-02f, 4.25703935e-02f, 4.87214513e-02f, 2.39190221e-01f, -1.81800742e-02f, 1.01692371e-01f, -2.69014329e-01f, -1.94927920e-02f,
  -9.80846286e-02f, 8.45046714e-02f, -4.05252054e-02f, 1.51270241e-01f, 1.42900839e-01f, -8.51210728e-02f, -9.36554521e-02f, 8.85858238e-02f, 8.78777541e-03f, -8.83394554e-02f,
  1.25358462e-01f, -1.55657046e-02f, 1.18366197e-01f, -8.75063823e-04f, -1.51435152e-01f, -2.11710721e-01f, 1.36524728e-02f, -4.50100005e-02f, 5.06702438e-02f, -1.43540412e-01f,
  -1.51229352e-01f, 5.41203171e-02f, 1.11668691e-01f, -1.39419481e-01f, -7.62269050e-02f, 2.85743833e-01f, 2.03895811e-02f, -4.23947945e-02f, -1.47316888e-01f, -2.48977855e-01f,
  -2.02985145e-02f, 1.33261815e-01f, -2.15465389e-02f, 8.80669430e-02f, -8.59825984e-02f, 7.53369927e-02f, 1.44855138e-02f, -1.83507755e-01f, -4.14970368e-02f, -1.66288260e-02f,
  7.40695223e-02f, -5.64602064e-03f, -3.91012691e-02f, -2.40670472e-01f, 9.99082550e-02f, -1.24355005e-02f, 1.60468742e-02f, -2.05470294e-01f, -1.02124609e-01f, 7.52404984e-03f,
  1.22348167e-01f, 2.99376976e-02f, 1.04592495e-01f, -3.77173945e-02f, -1.25164106e-01f, 1.02878690e-01f, 1.22072220e-01f, 2.66050361e-02f, 6.68843538e-02f, -3.25585417e-02f,
  2.95444518e-01f, 3.53581384e-02f, -1.27248004e-01f, -1.20024435e-01f, -1.50025010e-01f, 2.28064246e-02f, -3.59777622e-02f, -2.15479545e-02f, 2.30420381e-01f, 7.53842890e-02f,
  -1.85469806e-01f, -8.48056450e-02f, -2.94900388e-02f, -1.18616782e-02f, -2.61511058e-01f, -1.02460101e-01f, -3.02191854e-01f, 1.26748577e-01f, -4.03911471e-02f, 6.74688593e-02f,
  -1.93776518e-01f, -2.71978289e-01f, -1.58164144e-01f, -1.62849367e-01f, -8.83048624e-02f, 7.42277130e-02f, -1.57562062e-01f, -2.21274227e-01f, -2.46951997e-01f, -5.70563734e-01f,
  -1.42500386e-01f, 4.56004329e-02f, -4.70756620e-01f, -1.06438324e-01f, 2.93458104e-01f, 3.85593712e-01f, 4.70191717e-01f, 3.54140252e-01f, -5.36784157e-02f, -6.64079189e-02f,
  1.91269621e-01f, 1.51296943e-01f, -2.53154397e-01f, 5.50485887e-02f, 3.45456935e-02f, -1.27499595e-01f, -3.58683854e-01f, -2.17740685e-01f, 2.63922304e-01f, 5.49055815e-01f,
  2.49791726e-01f, -4.91315611e-02f, -1.32313803e-01f, -1.21586315e-01f, -3.37634295e-01f, -2.34158233e-01f, -4.77941960e-01f, -8.38148966e-02f, 2.18048934e-02f, -3.43060851e-01f,
  -3.91831726e-01f, -1.64160188e-02f, 7.70875663e-02f, 2.34454554e-02f, -2.33445898e-01f, -2.82850385e-01f, -1.74744539e-02f, -2.38941178e-01f, 7.10083637e-03f, -2.96988964e-01f,
  -9.72115174e-02f, -2.53681047e-03f, -1.64320786e-02f, -6.77608028e-02f, 5.33689512e-03f, 1.80201754e-01f, -1.37955651e-01f, -1.84440836e-01f, -2.67984539e-01f, -1.10211231e-01f,
  1.45409480e-01f, 1.23934880e-01f, -1.45379543e-01f, -6.72206804e-02f, -2.31258810e-01f, -2.94296026e-01f, -6.61307499e-02f, -7.71790519e-02f, -1.26139224e-01f, -4.13650215e-01f,
  7.20603839e-02f, 1.59994531e-02f, 8.48484486e-02f, 7.75426477e-02f, 8.00411105e-02f, -6.43231794e-02f, -3.95818315e-02f, 8.08283985e-02f, 2.21961271e-02f, 1.06984943e-01f,
  1.81422923e-02f, -2.66191885e-02f, 4.45637964e-02f, 6.78317342e-03f, -2.52997607e-01f, 3.93687934e-02f, 1.13728538e-01f, -1.40395135e-01f, -1.01592444e-01f, -8.18731859e-02f,
  -3.95539356e-03f, -9.57647562e-02f, -2.22670630e-01f, 7.32904673e-02f, -7.75971115e-02f, -1.24663733e-01f, -4.24914435e-02f, 1.15018837e-01f, 1.39976799e-01f, 2.21506809e-03f,
  -2.08205730e-01f, 1.23209760e-01f, -3.14123362e-01f, 1.56509742e-01f, -4.29292880e-02f, -1.44836083e-01f, -5.59304021e-02f, 2.08430365e-02f, -9.08770114e-02f, 1.34433731e-01f,
  1.32539004e-01f, 3.36682461e-02f, -2.48419017e-01f, 1.05388254e-01f, 1.81258008e-01f, -1.63474649e-01f, -3.07856593e-03f, -1.52104087e-02f, 4.98214141e-02f, -6.48161769e-02f,
  -2.31905535e-01f, 5.20002879e-02f, -2.08966717e-01f, -9.84517261e-02f, -4.46725227e-02f, -2.20465615e-01f, -3.63761783e-01f, -3.92634496e-02f, -2.10870624e-01f, -3.80776078e-01f,
  -6.27645135e-01f, 4.91787732e-01f, 1.52548909e-01f, -4.79176939e-01f, -1.02918871e-01f, 3.03347647e-01f, 4.88671869e-01f, 3.39214861e-01f, -1.74350470e-01f, -2.42728442e-01f,
  -2.18029603e-01f, -2.59681702e-01f, -1.85643286e-01f, -2.77023762e-02f, 2.68379718e-01f, 2.69692183e-01f, 1.78201735e-01f, 8.34604949e-02f, 1.35653183e-01f, 2.31723264e-01f,
  1.13136999e-01f, -1.42396301e-01f, -1.53247833e-01f, -3.32408063e-02f, -2.71446228e-01f, -1.82067230e-01f, -2.81142533e-01f, -2.05153406e-01f, 9.36729610e-02f, -2.70291060e-01f,
  -5.05822539e-01f, -2.64335364e-01f, 2.47949120e-02f, -2.92308390e-01f, -3.72811407e-01f, -1.29708886e-01f, 9.51549858e-02f, -1.87925471e-03f, 9.80627015e-02f, -3.49143613e-03f,
  -2.98895478e-01f, 2.01460235e-02f, -2.78141290e-01f, -1.10027559e-01f, -1.97793141e-01f, -2.09884439e-02f, -2.18040124e-02f, 3.56495939e-02f, -4.30439152e-02f, 2.94957273e-02f,
  1.98560119e-01f, -3.54483306e-01f, -3.52741569e-01f, 1.44432336e-01f, 1.25827014e-01f, -1.38821602e-01f, 5.82724661e-02f, -2.91802734e-02f, 1.45011067e-01f, -3.55924666e-01f,
  5.75892851e-02f, 7.19770864e-02f, 6.69515952e-02f, 1.58215329e-01f, -2.17248760e-02f, -7.44023025e-02f, 3.28340270e-02f, 5.35499901e-02f, -3.59868743e-02f, -9.63913500e-02f,
  6.97299242e-02f, -1.45457424e-02f, 1.17572002e-01f, -5.13357595e-02f, -9.89147648e-02f, -4.15146165e-03f, 8.02833363e-02f, 3.60959172e-02f, -6.35531098e-02f, 6.89351484e-02f,
  1.04166448e-01f, -4.18896526e-02f, -7.96226338e-02f, 1.36428759e-01f, -1.44262984e-02f, 1.24806061e-01f, -1.24531694e-01f, -3.81895304e-02f, -7.66276494e-02f, 2.98026316e-02f,
  -4.28142399e-01f, 2.61214077e-01f, -4.20166850e-01f, 8.49067718e-02f, -2.35702530e-01f, 2.16939449e-02f, -1.10634468e-01f, 6.04246072e-02f, 2.74007209e-03f, -3.17859873e-02f,
  2.13822439e-01f, 1.78335123e-02f, -2.39680529e-01f, 9.93153527e-02f, -2.73595631e-01f, -1.53715849e-01f, -2.48534381e-01f, -2.90729582e-01f, -4.47450066e-03f, -2.16292068e-01f,
  3.93102281e-02f, -1.15700774e-01f, -5.77335656e-01f, -2.64536291e-01f, -3.84156592e-02f, -4.23954338e-01f, -3.96101713e-01f, -1.53884843e-01f, -8.68661031e-02f, -3.16773146e-01f,
  5.44285476e-01f, -3.56537849e-01f, -2.58745223e-01f, -4.46230695e-02f, -9.88565087e-02f, -1.55974384e-02f, -1.48393705e-01f, -1.19143181e-01f, -5.92116602e-02f, -1.89624578e-01f,
  -5.34623489e-02f, 1.81429401e-01f, 1.61473677e-01f, 1.46137983e-01f, 4.70740162e-02f, -3.60945970e-01f, -2.32054278e-01f, 2.26478577e-02f, 1.64042950e-01f, 8.54987949e-02f,
  -9.28710550e-02f, -1.28127262e-01f, 3.34805399e-02f, -1.39939323e-01f, -3.51253271e-01f, -1.43915638e-01f, -2.10797340e-01f, -2.01654032e-01f, -2.69667923e-01f, -4.41950053e-01f,
  -8.74711387e-03f, 3.71533409e-02f, 5.25426269e-02f, -1.33170038e-01f, -1.05771691e-01f, 6.81350231e-02f, 1.07585356e-01f, -7.02665001e-02f, -9.16021243e-02f, 1.46415578e-02f,
  3.97872999e-02f, -1.21584395e-02f, -9.53952596e-03f, -8.15943629e-02f, -1.72785949e-02f, -7.04066455e-02f, 1.08794637e-01f, -1.12315104e-03f, -7.23381415e-02f, -6.77025840e-02f,
  -1.29683152e-01f, 7.26967752e-02f, 1.00319840e-01f, 1.05815426e-01f, 1.51223049e-01f, 6.74143359e-02f, 4.61611487e-02f, 6.05214350e-02f, 1.21351317e-01f, 9.25226808e-02f,
  -1.54640839e-01f, 4.78583388e-02f, 2.10960750e-02f, 2.08083913e-01f, 1.03872865e-01f, 1.04426891e-01f, 6.44837692e-02f, 3.14987265e-02f, 9.97189730e-02f, 5.55489138e-02f,
  -1.08422406e-01f, -1.91800985e-02f, 3.83048095e-02f, -2.98178028e-02f, -1.06172897e-01f, 2.09157523e-02f, 4.30613793e-02f, -3.20289545e-02f, -6.06322624e-02f, 9.28535964e-03f,
  9.68464091e-02f, -1.87366545e-01f, -2.27767169e-01f, -5.82551211e-02f, -7.83127323e-02f, -2.30932869e-02f, -1.15319438e-01f, 6.00786321e-02f, -5.12822904e-02f, -1.67829901e-01f,
  4.31855582e-02f, 2.14927509e-01f, 9.78414714e-02f, -5.06452695e-02f, 1.12073515e-02f, -3.88767458e-02f, 6.31588995e-02f, -9.94502008e-02f, -1.83913782e-01f, -7.54208118e-02f,
  6.63515255e-02f, 3.60851437e-02f, 8.70990604e-02f, 9.48438123e-02f, 5.57293072e-02f, 1.36042222e-01f, 6.70293942e-02f, 7.62372613e-02f, 6.22571446e-03f, -1.37490034e-01f,
  -1.39907315e-01f, 1.50782570e-01f, 1.35763392e-01f, 7.40094483e-02f, 6.51512146e-02f, 2.28998765e-01f, 1.79090604e-01f, 4.41426039e-02f, 1.56972900e-01f, 4.76099327e-02f,
  5.81650257e-01f, 4.59747344e-01f, 2.13535741e-01f, 2.31077731e-01f, 1.71217650e-01f, 3.62220883e-01f, 4.50059325e-01f, 3.67067397e-01f, 9.16355550e-02f, 1.71944812e-01f,
  2.62010098e-01f, 4.82962653e-02f, 1.90318286e-01f, 7.03622028e-02f, 1.10768758e-01f, 1.16552971e-01f, 7.07599744e-02f, 6.98271766e-02f, 2.34319945e-04f, -2.16804966e-02f,
  8.11356455e-02f, 1.61580324e-01f, 5.32205626e-02f, 1.80482380e-02f, 4.98305336e-02f, 5.81117384e-02f, 1.89820807e-02f, 8.54142830e-02f, 1.40068531e-01f, -1.09045498e-01f,
  -1.86642110e-01f, 1.65199280e-01f, -1.53045475e-01f, -1.12422958e-01f, -8.85556713e-02f, -3.67292529e-03f, 3.68895978e-02f, -1.53729329e-02f, -3.80097516e-02f, -4.93179038e-02f,
  -9.07355100e-02f, -5.65887317e-02f, 3.36957537e-02f, 1.67010389e-02f, 2.63007414e-02f, 9.56507307e-03f, 2.05846373e-02f, -3.24183442e-02f, 1.12959258e-02f, -4.98625562e-02f,
  -2.55195368e-02f, -5.22788167e-02f, -2.77755428e-02f, 4.34358716e-02f, -5.59794232e-02f, 9.21996683e-03f, 8.99380371e-02f, 2.19641626e-02f, 4.00861427e-02f, -8.94140638e-03f,
  -5.45140728e-03f, 7.64651224e-03f, 2.17672084e-02f, 8.65440592e-02f, 7.67835230e-02f, -1.25176176e-01f, -1.01692311e-01f, 6.71478659e-02f, -5.31806145e-03f, 6.52636737e-02f,
  -3.14522423e-02f, -9.01683643e-02f, -1.03745526e-02f, -1.25260213e-02f, -1.43472031e-01f, -1.53253689e-01f, -1.06431104e-01f, -1.51521221e-01f, -7.39214122e-02f, -5.10439686e-02f,
  -8.81875306e-02f, -1.12925068e-01f, -1.49509311e-01f, -1.47988915e-01f, -1.05069779e-01f, -1.83322914e-02f, -1.47799775e-01f, -1.03566542e-01f, 1.43170441e-02f, -2.19321176e-02f,
  -2.01911911e-01f, 1.23273782e-01f, -1.76550090e-01f, -6.77345097e-02f, 2.04327926e-02f, -3.13495062e-02f, -3.97613086e-02f, -1.43380553e-01f, -2.88443966e-03f, -6.19461723e-02f,
  -4.08574939e-02f, -1.07883871e-01f, -8.21351539e-03f, 3.42540592e-02f, -1.54580161e-01f, 1.07090827e-02f, -2.34065484e-02f, 1.31598771e-01f, -1.18344702e-01f, -1.54602945e-01f,
  -1.52048811e-01f, -7.79745355e-03f, -3.64161804e-02f, 1.21038323e-02f, 4.16388810e-02f, -1.69583447e-02f, -3.43485363e-02f, -1.36352852e-01f, -9.85544398e-02f, -6.64836168e-02f,
  -6.23442650e-01f, -3.18610042e-01f, -1.15758345e-01f, -1.45594195e-01f, 4.26972002e-01f, -2.57856905e-01f, -7.38224030e-01f, -5.79369366e-01f, 1.41402790e-02f, -1.18540555e-01f,
  3.85731280e-01f, 2.39794075e-01f, -8.42323229e-02f, -1.96410287e-02f, -5.01981318e-01f, -4.40155178e-01f, -1.16389021e-01f, -1.50774449e-01f, -1.05274625e-01f, 1.91195309e-01f,
  2.27432787e-01f, 1.22870475e-01f, -7.19572157e-02f, 3.79398055e-02f, 2.86483884e-01f, 1.30286306e-01f, 1.80569664e-01f, 2.20361635e-01f, 1.02076352e-01f, 2.80259073e-01f,
  -1.35488674e-01f, -2.96263099e-01f, 9.49390158e-02f, 3.42278570e-01f, 3.25623840e-01f, -1.75046340e-01f, -1.56142220e-01f, 9.67510194e-02f, -1.07990019e-01f, -1.82181045e-01f,
  2.98811316e-01f, 7.61008188e-02f, 1.21586733e-01f, 7.30056536e-06f, -7.53187686e-02f, -3.03811073e-01f, -2.19369620e-01f, -2.80433506e-01f, -3.13661665e-01f, 3.55833210e-02f,
  4.34571296e-01f, 1.85725406e-01f, -2.10782915e-01f, -2.76617467e-01f, -3.54206145e-01f, 7.09533840e-02f, -5.80318123e-02f, 1.49558904e-02f, -3.59871358e-01f, -3.72763336e-01f,
  -3.83270234e-02f, 1.29722014e-01f, -3.49555188e-03f, -9.92296115e-02f, -7.91622996e-02f, -2.40935832e-02f, -2.96821985e-02f, 1.47120282e-02f, 3.13770957e-02f, -1.34832203e-01f,
  -2.20154040e-02f, -3.25388610e-02f, -3.66901373e-03f, -3.47242244e-02f, 5.11124805e-02f, -3.98353562e-02f, 6.10441044e-02f, 4.01364379e-02f, 2.15968285e-02f, -3.47073637e-02f,
  1.28202364e-02f, -5.61417118e-02f, 1.04289860e-01f, -1.17841877e-01f, 5.93135171e-02f, 3.67681384e-02f, 6.24833405e-02f, -9.52910185e-02f, 9.11453739e-02f, 1.38155684e-01f,
  -1.25055179e-01f, 1.95141330e-01f, -1.73646584e-01f, -9.66716856e-02f, -8.83543864e-03f, 1.19165041e-01f, 1.07909620e-01f, 8.34634379e-02f, -1.13314502e-02f, -1.81659922e-01f,
  -9.27343443e-02f, -1.38264984e-01f, -8.05166960e-02f, -6.53544292e-02f, -7.39251077e-02f, 4.22282554e-02f, -1.24901384e-01f, -7.07364604e-02f, -1.27317235e-01f, 1.71566028e-02f,
  -2.82148480e-01f, -3.52315724e-01f, -3.73802930e-01f, -4.41624016e-01f, -1.21523291e-01f, -1.59605265e-01f, -1.54205069e-01f, -1.81087181e-01f, -3.77302825e-01f, -5.64694047e-01f,
  -6.97348595e-01f, -1.19203039e-01f, 1.12037882e-01f, -4.81882602e-01f, -2.53008932e-01f, 2.22423524e-01f, 3.18579823e-01f, 1.12958230e-01f, -2.23536924e-01f, -1.64353728e-01f,
  -4.01070148e-01f, -2.77871102e-01f, -1.70856208e-01f, 2.22218797e-01f, 3.61537457e-01f, 1.93090916e-01f, 3.35346311e-01f, 3.34788620e-01f, 3.26551765e-01f, 1.06378324e-01f,
  5.91674000e-02f, -1.05941005e-01f, -6.32901788e-02f, 1.65187806e-01f, -2.30311558e-01f, -4.64069881e-02f, -7.81708881e-02f, -1.01523265e-01f, 9.79105160e-02f, -1.31893912e-02f,
  -4.79224622e-01f, -2.66575962e-01f, 2.52554297e-01f, -1.71082944e-01f, -1.29593983e-01f, -6.88971300e-03f, 3.22977789e-02f, -1.43389320e-02f, -3.22400220e-02f, 1.46838620e-01f,
  -2.60195345e-01f, -1.67705491e-02f, -3.13494772e-01f, 1.63141787e-02f, -3.00460279e-01f, -3.10117267e-02f, 1.61190242e-01f, 3.17387909e-01f, 1.68226033e-01f, 3.54683362e-02f,
  2.04643875e-01f, -2.96292245e-01f, -3.97890836e-01f, 1.33849546e-01f, -2.43298244e-02f, -2.45717764e-02f, -2.13726655e-01f, 6.21702243e-03f, 1.12363268e-02f, -1.89069852e-01f,
  -1.51194245e-01f, -5.31094484e-02f, -1.00611774e-02f, -8.92080273e-03f, -4.96943109e-03f, 8.55192021e-02f, 3.83757018e-02f, 3.29060555e-02f, -4.04851399e-02f, -6.41381890e-02f,
  4.91156876e-02f, 6.32176525e-04f, 5.92635758e-02f, -1.31794438e-01f, -5.58965541e-02f, -4.94314618e-02f, 4.92083691e-02f, 1.84647739e-01f, 3.37373689e-02f, -3.62799899e-03f,
  -1.13227464e-01f, 4.01938036e-02f, -5.38711771e-02f, 2.86251873e-01f, 1.04283676e-01f, 1.61725342e-01f, -1.10936858e-01f, 3.77141796e-02f, -1.34312347e-01f, 6.85942918e-03f,
  -3.07509303e-01f, 3.90782773e-01f, -1.87084273e-01f, 8.69770069e-03f, -2.30373636e-01f, 2.30286829e-02f, -1.00257948e-01f, 4.07909714e-02f, -1.42898932e-01f, 8.99689272e-02f,
  -6.30757436e-02f, 6.25620484e-02f, -2.14496404e-01f, 1.13652065e-01f, -1.27066046e-01f, -8.52461755e-02f, -4.69529862e-03f, 1.02044223e-02f, 5.35050631e-02f, -1.36829019e-01f,
  6.31335229e-02f, 1.76809151e-02f, -4.40707296e-01f, 9.96423885e-03f, -2.87720293e-01f, -1.79648682e-01f, -2.93979108e-01f, -2.12321565e-01f, -4.96816747e-02f, -3.14378828e-01f,
  4.65729296e-01f, 4.12732691e-01f, 3.53075266e-02f, -8.03895760e-03f, 3.92387025e-02f, 8.55208933e-02f, 2.18646899e-01f, -3.75208184e-02f, -1.69793703e-02f, 7.39630982e-02f,
  1.20871656e-01f, -6.31230250e-02f, -1.49583951e-01f, -1.25667095e-01f, -2.82405247e-03f, 7.13647082e-02f, 5.75277098e-02f, -1.38028990e-02f, -1.58986393e-02f, -1.23043349e-02f,
  1.04594797e-01f, 1.70809254e-01f, 1.74497128e-01f, 2.25603804e-02f, 2.47217655e-01f, -1.07743226e-01f, -2.41477042e-02f, 2.13774115e-01f, 9.14480165e-02f, 3.13174158e-01f,
  6.54891431e-02f, 3.55179965e-01f, -4.86485243e-01f, -2.15291209e-03f, 4.80492897e-02f, -1.19679086e-01f, -4.85933535e-02f, -9.71604362e-02f, -1.18106492e-01f, -3.37337554e-02f,
  1.17398083e-01f, -4.62819710e-02f, 1.53999224e-01f, -4.83603701e-02f, -4.42599393e-02f, -9.76853222e-02f, -8.17031190e-02f, 8.05682167e-02f, -4.97586802e-02f, -6.35218248e-02f,
  1.28952160e-01f, 1.27086028e-01f, 6.50604442e-02f, -1.22420922e-01f, 2.25781631e-02f, -2.53685385e-01f, 4.29919139e-02f, -3.66895944e-02f, -2.08333746e-01f, 3.30908317e-03f,
  -4.77545261e-01f, -3.00776456e-02f, -6.45040274e-02f, -1.46947727e-01f, -1.31103516e-01f, -1.94424883e-01f, -6.66309372e-02f, 5.15142120e-02f, 4.91456352e-02f, -2.99193915e-02f,
  -1.59228459e-01f, -2.66099244e-01f, -1.23413198e-01f, -1.80867806e-01f, -1.19291641e-01f, 3.88681553e-02f, 4.52577183e-03f, -1.51324153e-01f, -1.98789593e-02f, -1.22207865e-01f,
  7.92231709e-02f, -9.62118991e-03f, -6.47412837e-02f, -2.66034938e-02f, -1.68217957e-01f, -2.04874083e-01f, -2.54113674e-01f, -1.47648677e-01f, -1.72704116e-01f, 5.64588048e-03f,
  -1.10889174e-01f, -2.93866158e-01f, -2.12663352e-01f, 7.46429488e-02f, 2.42718354e-01f, 1.40113095e-02f, 1.40030310e-01f, -8.50640014e-02f, 1.00620255e-01f, -2.43851170e-02f,
  1.83364525e-01f, 3.34983170e-02f, 1.53976858e-01f, 1.36026915e-03f, -8.70230123e-02f, -2.86663286e-02f, 1.14584953e-01f, -3.44041246e-03f, -1.40064269e-01f, 7.40230689e-03f,
  -8.27653110e-02f, -1.04978688e-01f, -3.33988607e-01f, -2.77142078e-01f, -2.53561378e-01f, -3.22664529e-01f, -2.59804279e-01f, -7.44438022e-02f, -1.62120476e-01f, -2.28942752e-01f,
  -2.30389349e-02f, -4.49375778e-01f, -2.91419387e-01f, -3.24299634e-01f, -3.29749554e-01f, -3.28313053e-01f, -4.70878124e-01f, -2.78049886e-01f, -2.38623042e-02f, -5.66566229e-01f,
  -2.23589972e-01f, 1.18261397e-01f, -9.64539647e-02f, -1.99667171e-01f, -2.36093983e-01f, -4.91860926e-01f, -3.72216314e-01f, -3.29626143e-01f, -1.31755874e-01f, -2.96594501e-01f,
  -5.06843388e-01f, -4.41813022e-01f, -1.91423371e-01f, -2.60681003e-01f, -2.97341883e-01f, -1.21914037e-01f, -2.62003630e-01f, -3.60078961e-01f, -1.89068213e-01f, -4.85774726e-01f,
  -4.68045890e-01f, 1.50290132e-01f, 8.13259706e-02f, 1.87496915e-01f, -1.85104102e-01f, 1.81267679e-01f, -3.81826311e-02f, 1.21962637e-01f, 8.02674592e-02f, -1.24743795e-02f,
  -5.61949387e-02f, 4.30498309e-02f, 1.00072445e-02f, 2.51648836e-02f, -1.10525094e-01f, -1.38370041e-02f, 4.41799164e-02f, 1.80070885e-02f, 1.23022702e-02f, -3.78509983e-02f,
  -1.32758659e-03f, 1.72361527e-02f, 1.29498988e-02f, -4.57055084e-02f, 1.09060861e-01f, 5.82812876e-02f, 1.46328732e-02f, 1.17115848e-01f, 3.33904475e-02f, -2.55875528e-01f,
  -1.18492827e-01f, -5.80621101e-02f, -9.22911838e-02f, -3.03706098e-02f, -4.15309481e-02f, -1.50275258e-02f, -8.67061391e-02f, 4.60124249e-03f, -1.32100191e-02f, -1.05236463e-01f,
  -7.23884255e-02f, -5.75405881e-02f, 1.01266086e-01f, -9.40524265e-02f, 1.18543161e-02f, -9.97635871e-02f, -1.17849521e-01f, -1.76687434e-01f, -1.37825966e-01f, 3.66504900e-02f,
  9.65892803e-04f, 9.79138911e-02f, -1.15640998e-01f, -1.21558309e-01f, 1.13561833e-02f, -7.96357691e-02f, -5.82478615e-03f, -9.05379746e-03f, -1.34393096e-01f, 9.47014540e-02f,
  -2.15968341e-01f, 4.04780135e-02f, -1.71646237e-01f, 1.22364081e-01f, 3.40509005e-02f, 5.26167750e-02f, 6.10118099e-02f, 1.02577358e-01f, 1.71008781e-01f, -1.43365800e-01f,
  -5.34579083e-02f, -1.52585596e-01f, -4.73839641e-02f, -6.95739686e-02f, -5.77984750e-02f, 2.26691067e-02f, -1.04839638e-01f, -5.54802455e-02f, 1.15303427e-01f, 2.41041034e-02f,
  -1.18404351e-01f, -1.29882619e-01f, -1.54920137e-02f, 7.37126393e-04f, 4.08818834e-02f, 1.34772554e-01f, -2.34508410e-01f, -7.66462535e-02f, -1.51901960e-01f, -4.40620035e-01f,
  4.17930245e-01f, 1.33649513e-01f, 5.02797902e-01f, 1.38688460e-01f, 1.08637512e-01f, -1.33505538e-01f, -4.20868039e-01f, -4.45075661e-01f, 3.22798491e-02f, -1.70593753e-01f,
  1.11751193e-02f, -2.03755349e-02f, 1.29984617e-01f, -2.07041189e-01f, -4.40608025e-01f, -3.48085582e-01f, -4.86440882e-02f, 8.39357302e-02f, -3.76259685e-01f, -6.26279294e-01f,
  -3.93599898e-01f, -3.53157930e-02f, 1.40103221e-01f, -1.71205290e-02f, 1.35143489e-01f, 8.10859278e-02f, 3.72568011e-01f, 3.70338470e-01f, 1.03635602e-01f, 2.85394847e-01f,
  8.97521228e-02f, 4.18051243e-01f, -2.42628276e-01f, -1.29154669e-02f, 2.32201964e-01f, -9.86621454e-02f, -1.46478534e-01f, 1.74505040e-01f, -1.64953053e-01f, -1.13411121e-01f,
  1.20590836e-01f, -1.16446681e-01f, 1.35550395e-01f, -1.65690348e-01f, -7.44872764e-02f, -2.74261236e-01f, 1.14005618e-01f, -8.88647512e-02f, -4.42338400e-02f, -3.95261198e-02f,
  -2.48928979e-01f, 6.89533278e-02f, 3.37205797e-01f, -1.34971857e-01f, 1.20528921e-01f, 1.39798775e-01f, 2.43883595e-01f, 8.96165743e-02f, 1.62804380e-01f, 1.92348361e-02f,
  -1.18982360e-01f, 1.51322380e-01f, 2.37099007e-02f, 9.23889279e-02f, -1.88815758e-01f, -5.03745163e-03f, 1.03310555e-01f, -5.46823852e-02f, -2.88131926e-02f, -7.81763569e-02f,
  -8.42360780e-02f, -1.31454274e-01f, -6.61162436e-02f, 1.08897397e-02f, 1.25506697e-02f, 9.84773412e-02f, 9.96907614e-03f, 2.05439832e-02f, 1.00842386e-01f, -8.62259418e-02f,
  5.82393147e-02f, -3.45635414e-02f, 1.98078483e-01f, -3.35961729e-02f, 1.12519804e-02f, 1.51124269e-01f, 4.76722792e-03f, 2.00851634e-02f, 9.33483317e-02f, 1.67170949e-02f,
  -1.71591282e-01f, 1.80441126e-01f, -1.96727440e-01f, -1.35026067e-01f, 6.18938655e-02f, 5.53811267e-02f, 1.54306605e-01f, -1.21208638e-01f, 2.41856754e-01f, -1.20430700e-01f,
  -3.61924917e-02f, 7.40460828e-02f, 1.87269554e-01f, -1.93493105e-02f, -2.99348146e-01f, -1.41938210e-01f, -1.91698536e-01f, -2.02850088e-01f, -4.29839641e-02f, 1.83988467e-03f,
  -1.06407620e-01f, -3.84777248e-01f, -2.59682536e-01f, -2.52992690e-01f, -3.99288759e-02f, -2.48215005e-01f, -5.74586801e-02f, -1.79530412e-01f, -1.90415621e-01f, -4.32250977e-01f,
  -7.26246595e-01f, -4.34084862e-01f, -2.52418816e-01f, -3.01596895e-02f, 3.94312710e-01f, -2.99726367e-01f, -6.32965922e-01f, -6.04147613e-01f, 4.78411615e-02f, -2.89720148e-01f,
  9.68522280e-02f, 3.18641692e-01f, 5.87273110e-03f, 7.56403282e-02f, -4.08861607e-01f, -2.09488973e-01f, 3.39800008e-02f, -1.42353073e-01f, 5.78693077e-02f, 1.88204527e-01f,
  4.64741588e-01f, 2.77722806e-01f, 8.68658423e-02f, 8.87345225e-02f, 3.10694665e-01f, 3.20633173e-01f, 9.42477062e-02f, 2.41671890e-01f, -7.38965068e-03f, 7.07435533e-02f,
  -3.64828795e-01f, -5.15670121e-01f, 2.82430351e-01f, 2.70579636e-01f, 1.67501196e-01f, -3.31341445e-01f, -1.21042363e-01f, 5.98946214e-02f, 5.76408207e-02f, 1.50981518e-02f,
  1.96068540e-01f, 3.46365906e-02f, 1.90475300e-01f, 7.07478002e-02f, 1.00613087e-01f, -2.20926642e-01f, 6.02585301e-02f, -2.98212379e-01f, -4.05487806e-01f, -2.56386459e-01f,
  4.81376350e-01f, 3.48379537e-02f, -3.57419819e-01f, -3.12966585e-01f, -3.61543149e-01f, 8.26477781e-02f, -2.85670459e-01f, -2.98489571e-01f, -4.48645473e-01f, -6.33180976e-01f,
  -4.08922322e-02f, 1.47204712e-01f, 1.56263951e-02f, -1.23577036e-01f, -4.82950769e-02f, -3.98845188e-02f, 1.20954074e-01f, 1.36303440e-01f, 3.99441682e-02f, -7.97849447e-02f,
  -7.47018531e-02f, -2.03599669e-02f, -6.02683276e-02f, -6.14415444e-02f, 6.31384626e-02f, 9.59988683e-02f, 1.13926185e-02f, -2.45660283e-02f, 9.59546566e-02f, -7.90764317e-02f,
  -2.29287725e-02f, -1.23854481e-01f, 2.93866873e-01f, -6.65376410e-02f, -1.47975609e-01f, -8.11555535e-02f, -5.72476909e-02f, 3.63422148e-02f, 9.63593945e-02f, -4.26712707e-02f,
  -2.28841007e-02f, 3.49119097e-01f, -2.08428100e-01f, 1.73799414e-02f, 7.50138536e-02f, 2.29741335e-01f, 4.25089300e-02f, 7.11230375e-03f, 3.18294019e-02f, -1.06338888e-01f,
  -1.51236311e-01f, -4.78296168e-02f, 6.15587309e-02f, 1.44496128e-01f, 4.41152155e-02f, -1.36398450e-01f, 6.88109100e-02f, -1.08447755e-02f, 4.08437429e-03f, 1.57439232e-01f,
  -3.92646156e-02f, -2.93003947e-01f, -4.09781724e-01f, -4.39610958e-01f, -6.72580078e-02f, -2.02328593e-01f, -1.70921877e-01f, -2.69435078e-01f, -4.19592172e-01f, -6.16279125e-01f,
  1.80461213e-01f, 2.93523371e-01f, -1.50458679e-01f, 1.61366418e-01f, -9.76395905e-02f, -2.18235791e-01f, -1.89637244e-01f, -2.01618105e-01f, 1.01997957e-01f, 1.98531613e-01f,
  -9.67600718e-02f, -2.16645934e-02f, 1.06517943e-02f, -1.20370574e-01f, -1.71153590e-01f, 7.06413239e-02f, 2.10769385e-01f, 1.16788685e-01f, 3.06794196e-02f, 2.22065404e-01f,
  3.17062229e-01f, 2.27129728e-01f, 2.00491771e-01f, 1.20042175e-01f, 3.23984742e-01f, 1.35912985e-01f, 1.40774056e-01f, 1.83254898e-01f, 1.73175991e-01f, 4.39947009e-01f,
  1.01993345e-01f, -3.91517341e-01f, -2.45372057e-02f, -9.53556523e-02f, -3.84894609e-02f, 1.36418462e-01f, 8.59207883e-02f, -2.52532642e-02f, 1.35202128e-02f, 1.51982456e-01f,
  -1.11766070e-01f, 1.73300188e-02f, -9.91744250e-02f, -2.92652976e-02f, -1.37254419e-02f, -1.17001846e-01f, -1.14455909e-01f, -9.50092152e-02f, -2.45633632e-01f, -1.69890866e-01f,
  3.99857089e-02f, -4.46616560e-02f, -1.56016037e-01f, -2.31681228e-01f, -1.59741536e-01f, -1.43702149e-01f, -1.79631546e-01f, -1.84371486e-01f, -2.97099680e-01f, 7.81182125e-02f,
  -3.44677269e-02f, 5.07144667e-02f, 5.69070838e-02f, 2.48248577e-02f, 1.80664480e-01f, 1.57210097e-01f, 1.73324823e-01f, 1.03511751e-01f, 1.06959991e-01f, 1.91313237e-01f,
  1.03530884e-01f, 1.26294658e-01f, 1.46399781e-01f, 1.15138173e-01f, 2.01015789e-02f, 9.28315148e-02f, 1.79585770e-01f, -5.84822893e-02f, -1.63997952e-02f, 1.14390410e-01f,
  7.91185349e-02f, 1.61704998e-02f, 1.37287423e-01f, 7.49861938e-04f, -1.55812607e-03f, -7.94463698e-03f, 1.63694516e-01f, 1.10746399e-01f, 6.80477172e-02f, 9.72256511e-02f,
  4.31001753e-01f, -4.77519810e-01f, 2.42113277e-01f, 5.86931631e-02f, 1.66823678e-02f, -1.23408309e-03f, 1.04058310e-01f, 5.63668348e-02f, 1.33494005e-01f, 2.31467500e-01f,
  -6.06726110e-03f, -1.31697850e-02f, 2.35404242e-02f, 5.82209602e-02f, 2.36000851e-01f, 7.95647502e-02f, 4.93998751e-02f, 2.23435909e-02f, -1.27190948e-01f, 6.16857708e-02f,
  -9.40065160e-02f, 3.69033106e-02f, -1.00318938e-02f, -6.84910938e-02f, 3.88806760e-02f, 8.84395987e-02f, 3.40707302e-02f, 1.07945740e-01f, -1.20627306e-01f, 2.81079829e-01f,
  -4.81804848e-01f, 5.31372368e-01f, -4.88226295e-01f, 3.42869371e-01f, 1.42848976e-02f, -3.10797393e-01f, 2.23575130e-01f, 3.37856889e-01f, 3.26208144e-01f, 2.02910066e-01f,
  -1.26476035e-01f, -3.52587134e-01f, 4.70145978e-02f, -2.09616110e-01f, -2.70358384e-01f, 4.07695442e-01f, 5.15521348e-01f, -4.94995236e-01f, -8.82056057e-01f, -4.03446019e-01f,
  2.51481742e-01f, 1.86868548e-01f, -2.08733469e-01f, -2.87314691e-02f, 3.63084733e-01f, 1.73198685e-01f, 2.57532924e-01f, 5.43563254e-03f, 9.69951786e-03f, 2.69014448e-01f,
  -5.09802639e-01f, -3.41374248e-01f, -7.95534775e-02f, -2.85070658e-01f, -1.60796747e-01f, -3.13229740e-01f, -1.84809178e-01f, -2.53105521e-01f, -2.61645585e-01f, -5.43770902e-02f,
  -3.02210033e-01f, -3.66652429e-01f, -3.30157757e-01f, 8.10759738e-02f, -1.67180017e-01f, -1.77059487e-01f, 1.11599147e-01f, -2.11038619e-01f, -8.10237080e-02f, -5.16997039e-01f,
  4.57360484e-02f, -5.83698094e-01f, -5.16690791e-01f, 3.53991427e-02f, -1.99429885e-01f, -4.78303969e-01f, -1.03840195e-01f, -2.88256884e-01f, -2.27344781e-01f, 2.45226696e-01f,
  7.77339935e-02f, -5.58986254e-02f, -1.20703727e-02f, 1.48543835e-01f, 2.13586792e-01f, 4.79305796e-02f, 9.40049663e-02f, 2.79360954e-02f, -1.09415807e-01f, -7.13336281e-03f,
  -1.08130053e-01f, 7.40363728e-04f, -8.82794783e-02f, -1.26578867e-01f, -2.10126396e-02f, -2.46993937e-02f, -7.46642128e-02f, 1.66190714e-01f, -7.07508903e-03f, -9.21540931e-02f,
  3.48999910e-02f, 2.89617921e-03f, -9.75763202e-02f, 7.42761195e-02f, 7.57926181e-02f, -1.62737221e-02f, 1.17875844e-01f, -2.56175213e-02f, 4.57588583e-02f, 5.10282032e-02f,
  5.36093235e-01f, -9.62479338e-02f, 1.23858914e-01f, 1.39674708e-01f, 8.12013261e-03f, -7.38241896e-02f, 1.59171209e-01f, 4.53558937e-03f, -2.19159480e-02f, -2.30601177e-01f,
  -2.52598494e-01f, -1.80979177e-01f, 1.47081748e-01f, -6.19850494e-02f, -2.99025267e-01f, -1.03702657e-01f, 3.61839592e-01f, 6.85342699e-02f, 1.42748162e-01f, -3.65304090e-02f,
  5.91498196e-01f, 2.13442538e-02f, -3.40873487e-02f, 1.51251808e-01f, 1.21063918e-01f, -1.70441583e-01f, 1.37633085e-01f, 6.32371381e-02f, -1.98071271e-01f, 7.31996179e-01f,
  5.51018417e-01f, 4.49820310e-01f, 1.24872766e-01f, 2.14440182e-01f, 2.41037950e-01f, 3.01824600e-01f, 4.31941330e-01f, 3.16664159e-01f, 1.43830419e-01f, 1.95756406e-01f,
  1.72591999e-01f, -2.30476528e-01f, -1.11780412e-01f, -1.65425122e-01f, -7.90124387e-02f, 8.69299918e-02f, -8.13815445e-02f, -4.99652810e-02f, 2.19688634e-03f, 3.05949356e-02f,
  -2.14213450e-02f, 2.84418166e-01f, 2.58055955e-01f, 1.03244081e-01f, -5.19286990e-02f, -1.82783604e-01f, 5.26218414e-02f, 2.09369913e-01f, 2.48616282e-02f, -3.14376891e-01f,
  -4.25092757e-01f, 3.06675315e-01f, -7.56001472e-02f, -7.56277740e-02f, -5.74470544e-03f, 6.70171902e-02f, -5.01371101e-02f, -1.28566101e-01f, 9.17081907e-02f, -5.32999486e-02f,
  -1.02602005e-01f, -4.20870781e-02f, -1.27726629e-01f, 5.81714809e-02f, 3.03751975e-02f, -7.40241334e-02f, 1.11025460e-02f, -1.01377450e-01f, -1.85429767e-01f, -1.46661386e-01f,
  -6.37020767e-02f, 2.48991884e-03f, 3.89696993e-02f, -3.37104686e-02f, -4.50390726e-02f, -9.92718041e-02f, 8.29784274e-02f, -1.37854286e-03f, 5.90847507e-02f, 8.40105787e-02f,
  -4.03190792e-01f, -9.53640193e-02f, -9.94332358e-02f, -9.52175781e-02f, -1.08231634e-01f, -7.51543567e-02f, -6.39672279e-02f, 8.94164518e-02f, -8.00847635e-03f, 2.22698599e-02f,
  4.20804732e-02f, -1.57364398e-01f, -8.84444341e-02f, -4.09964472e-02f, -1.83972180e-01f, -9.14038159e-03f, 1.84819773e-02f, -9.56985429e-02f, -1.28735363e-01f, -9.67091247e-02f,
  -8.49993899e-02f, 9.48491693e-02f, -3.79322805e-02f, -9.29841399e-02f, -1.78124905e-01f, -1.06597476e-01f, -7.23067746e-02f, -1.35570541e-01f, -1.78744958e-04f, 7.07051307e-02f,
  -1.79670125e-01f, -2.40243122e-01f, -9.81871039e-02f, 7.51256049e-02f, 2.52542980e-02f, -6.58880323e-02f, -1.61856845e-01f, -4.39096019e-02f, 5.96292168e-02f, -1.05809167e-01f,
  6.91729635e-02f, -1.00415036e-01f, -1.33208454e-01f, -8.17035437e-02f, 6.39953017e-02f, 1.82163883e-02f, -3.49901691e-02f, -8.07470363e-03f, -1.46873549e-01f, -9.48621258e-02f,
  -4.01697755e-02f, 3.61237638e-02f, 5.38230427e-02f, 1.88090317e-02f, -9.95188057e-02f, 2.01333668e-02f, 1.79388132e-02f, 3.32705677e-03f, 2.87478026e-02f, 1.78273275e-01f,
  3.34965467e-01f, -3.61178339e-01f, -4.81794104e-02f, -1.70214456e-02f, -6.44799620e-02f, 9.62273851e-02f, -1.25522748e-01f, -9.79495123e-02f, -9.05168802e-02f, -2.43608207e-01f,
  -8.33918229e-02f, -1.02272533e-01f, -2.31258556e-01f, -1.26585901e-01f, -1.65674120e-01f, -2.25248039e-01f, -2.15858638e-01f, -1.09884121e-01f, 3.89213301e-02f, -5.04747294e-02f,
  -1.50156006e-01f, -4.80516665e-02f, 4.06593978e-02f, -2.26722136e-02f, -1.13918491e-01f, -1.25574157e-01f, -2.28159338e-01f, -1.83502913e-01f, -2.13353872e-01f, -2.25616112e-01f,
  -1.40118264e-02f, 1.55389071e-01f, 1.57867018e-02f, 7.44112656e-02f, 9.06051546e-02f, -3.04680113e-02f, 1.29150018e-01f, -5.11534065e-02f, -5.88619970e-02f, 6.63371291e-03f,
  -5.14841042e-02f, 7.21950606e-02f, 1.45910308e-01f, 4.76343259e-02f, 1.76311046e-01f, 1.45597577e-01f, 6.99584559e-02f, 4.19689110e-03f, 3.00467238e-02f, -1.03650570e-01f,
  5.85588142e-02f, 1.72988012e-01f, 7.63821453e-02f, 5.03122136e-02f, 9.27110910e-02f, 1.54799476e-01f, 1.38368919e-01f, 1.67213157e-01f, 1.80368021e-01f, 9.94952172e-02f,
  9.85812396e-02f, 5.89030273e-02f, 1.28926665e-01f, 5.54006733e-02f, -1.27695678e-02f, 1.20382924e-02f, 5.22170141e-02f, 4.38727736e-02f, -4.97337766e-02f, 1.09639004e-01f,
  7.54403174e-02f, 1.53555330e-02f, 5.90745620e-02f, 3.02331969e-02f, 7.40292072e-02f, -5.71214072e-02f, -6.65809959e-02f, 3.28108594e-02f, 2.98105963e-02f, 6.05345611e-03f,
  3.39298323e-02f, 4.28406931e-02f, 8.08194652e-02f, 7.73651004e-02f, 1.10969216e-01f, 1.69345200e-01f, 5.69124967e-02f, -2.72653662e-02f, -5.68283536e-02f, 2.49104761e-02f,
  1.04554765e-01f, 3.18304867e-01f, 9.34943743e-03f, -1.20214328e-01f, -1.99423637e-02f, -1.36085358e-02f, 1.21802688e-02f, -1.59655184e-01f, -3.34005095e-02f, -2.51545962e-02f,
  -8.24988335e-02f, -8.51342082e-02f, 1.17455170e-01f, 6.16335273e-02f, 8.29315037e-02f, 6.60810098e-02f, 1.09263726e-01f, 4.46100384e-02f, -1.20083511e-01f, -1.06908336e-01f,
  1.66545380e-02f, 4.11414281e-02f, 4.50857468e-02f, 2.74782032e-02f, 6.37946278e-02f, 5.93565516e-02f, 1.50859524e-02f, 1.60067782e-01f, 1.59972176e-01f, -6.40557036e-02f,
  7.41746247e-01f, 1.55547142e-01f, 9.87102240e-02f, 2.34192595e-01f, -3.68767120e-02f, -8.63409340e-02f, -2.79588103e-02f, 3.24469097e-02f, 1.84453297e-02f, 1.82101220e-01f,
  6.31808415e-02f, 1.62307575e-01f, 2.98614115e-01f, 9.64027941e-02f, 1.46961316e-01f, -2.22878046e-02f, -4.75543737e-02f, 2.10576206e-01f, 1.03745602e-01f, 9.88014862e-02f,
  -1.14678303e-02f, 8.29605982e-02f, 1.73187912e-01f, 1.82738960e-01f, 2.08912306e-02f, 9.08833146e-02f, -2.13833600e-02f, -6.58709854e-02f, -4.07348908e-02f, -1.08776093e-01f,
  -2.18246371e-01f, 1.41857922e-01f, 1.08398749e-02f, 9.40534547e-02f, -1.14385538e-01f, 4.08902913e-02f, 1.17830515e-01f, 3.74505036e-02f, -1.57216731e-02f, -1.53696481e-02f,
  -1.14347816e-01f, -6.64159507e-02f, -5.26227094e-02f, -9.17414725e-02f, -1.27489686e-01f, -1.86636150e-02f, -7.52342865e-02f, 3.09717692e-02f, 1.18872836e-01f, -7.85533637e-02f,
  -1.06651060e-01f, -9.16127935e-02f, -3.64782335e-03f, -1.42453304e-02f, 1.26815572e-01f, -4.83061783e-02f, 7.14187101e-02f, 3.61943617e-02f, 8.76866207e-02f, 2.01845751e-03f,
  1.14679761e-01f, 5.37710637e-02f, 1.11546218e-01f, 1.76257119e-02f, 1.94637612e-01f, 8.26407969e-02f, -9.63266101e-03f, -6.83906823e-02f, 7.51170814e-02f, 7.85788000e-02f,
  -3.59290577e-02f, 1.11281946e-01f, 3.77553068e-02f, 4.49518627e-03f, 1.00916624e-01f, -1.71244740e-02f, -1.92126408e-01f, -5.42291254e-02f, 3.96655649e-02f, -1.02317385e-01f,
  6.02386706e-02f, -9.76520106e-02f, -1.15670830e-01f, -6.38997853e-02f, -9.08842161e-02f, 3.40877357e-03f, 1.08680263e-01f, -4.51354682e-03f, -5.27986838e-03f, -7.70634189e-02f,
  -4.67892855e-01f, 1.71387315e-01f, 1.02532387e-01f, 1.13719162e-02f, -4.91112694e-02f, -1.27728671e-01f, 4.36840653e-02f, -1.06337350e-02f, -1.09101892e-01f, -1.43227756e-01f,
  -1.81816474e-01f, 2.47758012e-02f, 6.91719726e-02f, 1.91129260e-02f, -1.44448549e-01f, -4.02444638e-02f, -8.70921239e-02f, 3.00659072e-02f, -3.13570201e-02f, -1.21598162e-01f,
  -5.00103682e-02f, -5.33648394e-02f, -4.86199670e-02f, -7.93108568e-02f, -6.30754679e-02f, -1.99707830e-03f, -9.43322629e-02f, -4.84056324e-02f, -3.02278064e-03f, -2.74764057e-02f,
  5.22415042e-01f, 4.13501769e-01f, 2.40089387e-01f, 5.14029339e-02f, -1.04502983e-01f, -2.63655663e-01f, -2.55224794e-01f, -7.73145482e-02f, -6.53783083e-02f, 1.31678013e-02f,
  1.78354103e-02f, -1.21135358e-02f, -2.07643062e-02f, -3.71665508e-02f, -6.00288436e-02f, -6.93594888e-02f, 2.96066683e-02f, 1.09379567e-01f, -1.10396676e-01f, 1.56030487e-02f,
  -6.74350634e-02f, 6.22530887e-03f, 1.01080522e-01f, 4.55565341e-02f, 3.02269161e-01f, 1.59053743e-01f, 2.21468166e-01f, 1.72947153e-01f, 2.31119394e-01f, 5.67771196e-01f,
  3.64492089e-01f, 3.17024082e-01f, -4.41402614e-01f, 1.55126667e-02f, 1.61913574e-01f, 1.56251550e-01f, 3.48508880e-02f, 1.35285661e-01f, 8.07735696e-03f, 5.10118194e-02f,
  1.05887339e-01f, 1.90975204e-01f, 1.94762126e-02f, 4.37157676e-02f, 4.28933278e-02f, -5.50280884e-02f, -3.20097171e-02f, 4.07408327e-02f, -1.43042088e-01f, 1.24768112e-02f,
  -5.06134750e-03f, 4.00261395e-02f, -1.15359016e-01f, -2.95104057e-01f, -9.33533758e-02f, -1.71658531e-01f, 4.75059897e-02f, 2.50257492e-01f, -1.89332172e-01f, 3.21579754e-01f,
  5.89535870e-02f, 9.73747745e-02f, 1.54620528e-01f, 2.11063236e-01f, 8.53660107e-02f, 1.28559321e-01f, 1.62660733e-01f, -3.54588628e-02f, -6.21600412e-02f, 2.06874251e-01f,
  9.08730179e-02f, -2.56358460e-02f, 2.21569650e-02f, 4.79547530e-02f, -3.48071158e-02f, 1.58327714e-01f, 6.55977428e-02f, -7.66971335e-02f, -1.05799161e-01f, -3.33591327e-02f,
  1.33905550e-02f, -1.95624474e-02f, 7.93035701e-02f, 6.66690841e-02f, 8.14187005e-02f, 1.78363696e-02f, 2.11544409e-01f, 1.16983250e-01f, 5.28582633e-02f, 1.74755424e-01f,
  -3.29664558e-01f, -6.50022626e-01f, 8.33414793e-02f, 9.01818946e-02f, 1.55301750e-01f, -6.38757413e-03f, 5.85239008e-02f, 2.72381399e-03f, 5.42617440e-02f, -1.10269509e-01f,
  -1.43702412e-02f, 3.07384245e-02f, -5.47008142e-02f, -1.04597978e-01f, -1.21552199e-01f, -5.63065000e-02f, 1.17366910e-01f, -1.32393673e-01f, -2.30435282e-01f, 1.67936727e-01f,
  -8.23957175e-02f, -4.85955536e-01f, -4.67036307e-01f, -3.63165855e-01f, -1.79215670e-01f, -4.67127055e-01f, -2.89528370e-01f, -1.26518354e-01f, -3.73789757e-01f, -4.08137560e-01f,
  6.68860912e-01f, 3.08098435e-01f, -9.25592408e-02f, 1.32949442e-01f, -2.53284991e-01f, -2.48151630e-01f, -2.10348349e-02f, 1.11342892e-01f, 1.22238882e-01f, 1.66092753e-01f,
  1.04330868e-01f, 1.76644593e-01f, 2.17632890e-01f, 5.53874411e-02f, 1.92833692e-01f, -8.81358236e-02f, -5.77701442e-02f, 4.82005700e-02f, 1.68727338e-02f, -9.94709730e-02f,
  4.53169160e-02f, 8.97764936e-02f, 1.23411223e-01f, 1.20583542e-01f, -3.03914659e-02f, 2.01208424e-02f, -4.42203920e-04f, -1.11989014e-01f, -5.93217053e-02f, -1.12782521e-02f,
  -2.45372102e-01f, 1.26374036e-01f, 8.58753622e-02f, 1.25629976e-02f, 1.62079483e-01f, 2.20874295e-01f, 1.00952581e-01f, 7.92241171e-02f, 3.00054681e-02f, -1.30690113e-01f,
  2.17469130e-02f, -5.68326050e-03f, -5.36655523e-02f, 2.59323940e-02f, -7.06186891e-02f, 7.74495350e-03f, 8.21902230e-03f, 1.20025776e-01f, -1.79101638e-02f, 3.26047130e-02f,
  -8.30481797e-02f, -2.57724579e-02f, -1.37366876e-01f, 1.23367282e-02f, 9.79715437e-02f, -2.50732200e-03f, 5.71268275e-02f, 2.75551863e-02f, 5.76607659e-02f, 8.37052241e-02f,
  -1.95109509e-02f, -1.73633453e-03f, 2.69956663e-02f, -4.16202880e-02f, -4.84683588e-02f, -1.60531476e-01f, -1.50151238e-01f, -8.61772597e-02f, 4.54704557e-03f, -9.65563506e-02f,
  -1.61351293e-01f, -1.21295787e-02f, 3.93388420e-02f, -2.55582407e-02f, -4.82682437e-02f, -5.74621670e-02f, -8.19037259e-02f, -6.96439762e-03f, -1.55439913e-01f, 2.75013912e-02f,
  9.41431150e-03f, -1.21040046e-01f, -5.44047449e-03f, -1.38259113e-01f, -1.13806285e-01f, -1.35813236e-01f, -1.33043036e-01f, -7.79111311e-02f, -5.07876463e-02f, -3.45778726e-02f,
  -8.19601417e-02f, 1.10810678e-02f, 7.28806928e-02f, 1.41137153e-01f, 8.85837376e-02f, 7.93377459e-02f, -1.47268940e-02f, -1.23317735e-02f, -1.36427298e-01f, -1.40298977e-01f,
  -2.30589230e-02f, 6.81067631e-02f, 9.91445333e-02f, 8.20479169e-02f, -4.46206927e-02f, -1.82098914e-02f, 2.08351269e-01f, 1.14975497e-01f, 1.80077646e-02f, 4.64890823e-02f,
  1.20316356e-01f, 2.60804221e-02f, -7.70955458e-02f, -4.51671444e-02f, -2.12094542e-02f, -6.66386932e-02f, -1.43586937e-02f, -5.82202263e-02f, -8.71342868e-02f, 9.86469164e-03f,
  2.83593804e-01f, 1.55083746e-01f, -1.74513347e-02f, 3.13110888e-01f, 2.17454240e-01f, -5.96280061e-02f, 3.52904648e-02f, 2.96924025e-01f, 3.53224725e-01f, 2.24326968e-01f,
  -2.54868686e-01f, -4.35932904e-01f, -2.61760056e-01f, -3.24042946e-01f, -2.97659963e-01f, 1.01996094e-01f, 3.21207106e-01f, -2.34247223e-01f, -3.96341622e-01f, -2.48293743e-01f,
  -1.03184052e-01f, 1.03319608e-01f, -8.20437893e-02f, -2.79164338e-03f, 3.08124155e-01f, -2.24764412e-03f, 1.12858534e-01f, 5.73479896e-03f, -1.64174870e-01f, 3.62408251e-01f,
  -2.50401676e-01f, 3.72940093e-01f, -2.76564807e-01f, -1.14450283e-01f, -1.37323111e-01f, -2.79437080e-02f, -1.60498731e-02f, 1.26631245e-01f, -1.44154774e-02f, 1.74142703e-01f,
  -1.05475716e-01f, -1.26185000e-01f, -1.38427198e-01f, -1.17437370e-01f, -4.29043956e-02f, -1.45191133e-01f, -4.03236747e-02f, -4.56085131e-02f, -3.24581824e-02f, -5.07807098e-02f,
  -2.51294017e-01f, -6.67437911e-02f, -7.76983500e-02f, 9.71147865e-02f, -4.34853174e-02f, -1.68421611e-01f, -6.64826110e-02f, 4.89206519e-03f, -1.27916887e-01f, 3.93065006e-01f,
  1.14899531e-01f, -3.25788110e-02f, 9.82446969e-03f, 6.29654601e-02f, -4.57161851e-02f, -3.91508080e-02f, 1.42786369e-01f, 5.68737611e-02f, -3.16241495e-02f, 1.63997665e-01f,
  6.97411771e-04f, -7.35298693e-02f, 5.76409101e-02f, 1.06953658e-01f, 2.88088480e-03f, 1.50772080e-01f, 8.81511644e-02f, 5.82389347e-02f, 2.35238895e-02f, 1.43361405e-01f,
  -6.36617020e-02f, 1.57183986e-02f, -4.42665070e-02f, 9.02039111e-02f, -1.52680548e-02f, 7.36389821e-03f, -6.34662807e-02f, -3.73848304e-02f, 1.30433217e-01f, 9.65142697e-02f,
  -8.25613365e-02f, -3.87857288e-01f, 1.06976740e-01f, 1.55563876e-01f, 1.31339252e-01f, -1.43214136e-01f, -4.20020483e-02f, 3.40199172e-02f, 1.50427476e-01f, 9.16552767e-02f,
  -1.59796804e-01f, -2.90668793e-02f, 1.11999111e-02f, -6.99871182e-02f, -9.23196822e-02f, 6.00112937e-02f, -1.17752187e-01f, 6.99796379e-02f, -3.54238637e-02f, 9.16558206e-02f,
  1.80243656e-01f, 1.01402640e-01f, 2.85774171e-02f, 2.47933552e-01f, 1.42810583e-01f, -1.55394986e-01f, -3.25712264e-02f, 1.38044387e-01f, -2.06584185e-01f, 3.68816674e-01f,
  -2.38087416e-01f, 1.09711319e-01f, 6.14279866e-01f, -2.38613561e-01f, -4.81966466e-01f, -2.30943620e-01f, -3.84948194e-01f, -1.05990939e-01f, -7.03984424e-02f, 1.05109982e-01f,
  -2.23970592e-01f, -1.96472466e-01f, 7.51347989e-02f, -6.41929507e-02f, 1.44245811e-02f, 3.39953363e-01f, 4.16523337e-01f, 2.97226340e-01f, -2.64191717e-01f, -4.74202424e-01f,
  -3.74394059e-01f, -3.02050203e-01f, 8.90753511e-03f, 1.19874790e-01f, 1.06764562e-01f, -4.81847636e-02f, 4.11129594e-01f, 2.59617846e-02f, 1.85363203e-01f, 5.49913704e-01f,
  2.60494918e-01f, 2.99731433e-01f, 2.93015558e-02f, -1.29946992e-01f, 3.56885977e-02f, 8.52279067e-02f, 4.66138683e-02f, 3.56813788e-01f, 2.77027357e-02f, 2.61972666e-01f,
  -2.28168562e-01f, 2.72100773e-02f, -2.19754130e-01f, 4.88025732e-02f, -1.12282440e-01f, -2.56014705e-01f, 1.07387125e-01f, 3.50282609e-01f, 1.47754535e-01f, 1.04369879e-01f,
  -3.55645329e-01f, -3.91948819e-01f, -4.18740213e-02f, 4.03095447e-02f, 2.43913561e-01f, -2.70458370e-01f, -1.58399753e-02f, 1.21023282e-01f, 1.06944144e-01f, 2.92271107e-01f,
  3.14612500e-02f, -6.66679293e-02f, 1.98963918e-02f, 1.84483528e-01f, -5.22965826e-02f, -3.67462710e-02f, -4.86744978e-02f, -4.23056409e-02f, 5.97403981e-02f, -7.91593716e-02f,
  6.11282289e-02f, -9.54114273e-02f, -5.05758822e-02f, 7.86801521e-03f, -6.37991354e-02f, -4.66618054e-02f, -7.16972947e-02f, 6.44702166e-02f, 2.19754651e-02f, 7.54777715e-02f,
  -6.81414232e-02f, 1.95519235e-02f, -5.76808229e-02f, 1.13358289e-01f, 1.43032745e-01f, 1.17376626e-01f, -6.82771876e-02f, -2.22236842e-01f, -1.31244883e-01f, -1.71487167e-01f,
  -3.13803524e-01f, -7.68859312e-02f, 9.60599110e-02f, 9.27603245e-02f, -8.79725534e-03f, 2.08558198e-02f, -5.42981736e-02f, -1.44314557e-01f, -1.45507514e-01f, -9.36573371e-02f,
  -1.79176539e-01f, -7.40431920e-02f, 1.38208419e-01f, 1.83376893e-02f, -3.44867289e-01f, -1.18942402e-01f, -2.87082374e-01f, -2.79239327e-01f, -2.38298967e-01f, -1.40145525e-01f,
  -1.76177397e-01f, -4.94134784e-01f, -6.13455534e-01f, -2.82353908e-01f, -3.72672647e-01f, -7.09794223e-01f, -2.95069396e-01f, -3.98853362e-01f, -5.15248001e-01f, -4.63052005e-01f,
  -4.82634902e-01f, -4.90988702e-01f, -2.45537721e-02f, 3.17377336e-02f, 3.51224869e-01f, 2.45771646e-01f, 2.26182416e-01f, 1.12707868e-01f, 1.16119839e-01f, -4.87912111e-02f,
  -7.13632442e-03f, 1.67356282e-01f, 8.00581723e-02f, 1.08564973e-01f, 4.60419543e-02f, 9.60802957e-02f, 1.99667677e-01f, 2.37272337e-01f, 2.82672822e-01f, 1.58854574e-01f,
  1.69812948e-01f, 7.03341961e-02f, -1.49335504e-01f, -9.55949724e-03f, 1.29437968e-02f, 1.14661463e-01f, 4.46156897e-02f, -2.19617002e-02f, 1.88016333e-02f, 1.44246995e-01f,
  2.48996004e-01f, -2.46039554e-01f, 1.12903945e-01f, -1.25891522e-01f, -2.18476117e-01f, -1.38334632e-01f, -1.07151270e-01f, -1.64620474e-01f, -1.23440668e-01f, -7.54629225e-02f,
  -1.33594722e-01f, -5.03250249e-02f, -1.18944198e-02f, -8.13822448e-02f, -1.50116771e-01f, -3.01968064e-02f, -2.23451585e-01f, -3.01011670e-02f, -7.73196742e-02f, -9.99064073e-02f,
  -5.71414307e-02f, -2.20000315e-02f, 1.65588841e-01f, 7.92467222e-02f, 7.43565336e-02f, 2.69706286e-02f, -1.35268476e-02f, -2.92970333e-02f, 5.01495786e-02f, 8.26622471e-02f,
  1.29552595e-02f, -4.28880788e-02f, 9.56025533e-03f, 9.42158997e-02f, 1.17951147e-01f, 1.71083324e-02f, 1.13795131e-01f, 1.40726775e-01f, 1.45110503e-01f, -5.06592356e-02f,
  9.84436423e-02f, 1.25396550e-01f, 7.98018649e-02f, 6.51982278e-02f, 2.11940706e-02f, -1.05799668e-01f, -4.70281541e-02f, 5.71709946e-02f, -5.69714978e-03f, 1.80066947e-03f,
  1.58063322e-03f, 8.16318542e-02f, -3.30048315e-02f, -2.86813602e-02f, -8.50661471e-02f, -2.54959725e-02f, 8.99738222e-02f, -5.94546646e-02f, -1.09285451e-01f, 5.42607717e-03f,
  2.41554558e-01f, -1.42037971e-02f, 1.75947174e-01f, 2.30417624e-02f, -3.35890427e-02f, -1.08605340e-01f, 5.22644818e-02f, -7.66622201e-02f, -1.04866177e-01f, 2.76370086e-02f,
  5.08150272e-02f, -1.40234947e-01f, 8.72321427e-03f, 7.73267299e-02f, 3.31647098e-02f, 9.64694619e-02f, -3.82773653e-02f, 1.23953387e-01f, 7.48173818e-02f, -4.83200550e-02f,
  -6.60186186e-02f, 7.89006725e-02f, 1.60463676e-01f, 9.70463455e-02f, 1.60238817e-01f, 2.12966785e-01f, 2.16317549e-01f, 9.52790678e-02f, 1.28313720e-01f, 8.03944990e-02f,
  7.09780455e-01f, -2.29348555e-01f, -6.13554418e-01f, 8.58314857e-02f, -9.74275097e-02f, -2.48881206e-01f, -1.57206818e-01f, -4.63882573e-02f, 1.01643190e-01f, 2.77788565e-02f,
  1.76681027e-01f, 2.84901321e-01f, 2.62577891e-01f, 1.35518879e-01f, 1.34354413e-01f, -2.77114213e-01f, -2.16609195e-01f, -1.66991904e-01f, 1.36921689e-01f, 4.13270928e-02f,
  1.40149191e-01f, 2.18691394e-01f, 2.37127811e-01f, 1.37192219e-01f, -2.04725459e-01f, -4.62150387e-02f, -3.11113089e-01f, -2.17465863e-01f, -9.72543657e-02f, -3.48855764e-01f,
  -3.48093241e-01f, -1.39628639e-02f, -1.32187381e-02f, 1.53978527e-01f, 1.65604129e-02f, 6.47975579e-02f, 1.97119061e-02f, -1.96552612e-02f, 1.33598804e-01f, -4.26424369e-02f,
  -1.40266083e-02f, -3.46461013e-02f, -5.52892722e-02f, -1.19205318e-01f, -1.22026749e-01f, 1.87174100e-02f, -1.28567129e-01f, -9.89151672e-02f, 6.62914142e-02f, 1.69300754e-02f,
  -9.34103429e-02f, -6.96316883e-02f, -1.35834813e-01f, -1.60566017e-01f, -5.86650148e-02f, -8.18526223e-02f, -2.01009452e-01f, -1.14374980e-01f, -6.67059198e-02f, -1.30859047e-01f,
  1.54589757e-01f, 1.53576031e-01f, 9.42288712e-02f, 1.65904090e-02f, 1.32249743e-01f, 2.56309542e-03f, 2.87140477e-02f, 1.16876289e-01f, 5.78235425e-02f, -2.15891190e-02f,
  -8.99726972e-02f, 4.52481695e-02f, 2.53553130e-02f, 3.15034650e-02f, 1.20455883e-01f, 9.61236060e-02f, 2.31777970e-02f, 1.48718715e-01f, 7.53275380e-02f, 1.54771343e-01f,
  9.76216942e-02f, 4.83870991e-02f, 9.37999189e-02f, 9.97352302e-02f, 5.93985394e-02f, 2.73964298e-03f, 3.89767103e-02f, 1.60425141e-01f, 4.40709479e-02f, 4.55295071e-02f,
  8.38892236e-02f, 7.36957416e-02f, 1.50950504e-02f, 1.06163144e-01f, -1.22005180e-01f, -6.32317215e-02f, -3.08149178e-02f, -1.47844041e-02f, 3.45920138e-02f, 6.21273108e-02f,
  -1.59365647e-02f, 6.99765384e-02f, -1.01681396e-01f, 1.93532966e-02f, -9.64226499e-02f, -8.11051130e-02f, -4.52708639e-03f, 8.33745003e-02f, -2.88153775e-02f, 6.61989450e-02f,
  -2.34971847e-02f, 2.55390499e-02f, 1.41636562e-02f, 3.39297056e-02f, -6.80722967e-02f, 8.79926682e-02f, 3.02674342e-02f, 2.50876453e-02f, 1.46173490e-02f, -3.59974056e-02f,
  -5.58654726e-01f, 1.06988527e-01f, 2.58976221e-01f, -1.52809126e-02f, -2.57102642e-02f, -1.08907759e-01f, -6.68844506e-02f, -4.98886220e-02f, 2.67630108e-02f, 1.26555696e-01f,
  1.31277859e-01f, 7.28625879e-02f, -3.70594412e-02f, 1.28442317e-01f, 1.37965390e-02f, 1.23398259e-01f, 7.19242841e-02f, -1.03748310e-03f, -8.38665739e-02f, -6.80331420e-03f,
  -5.55338115e-02f, -5.38728684e-02f, 2.50020288e-02f, -4.79434542e-02f, 2.82072693e-01f, 4.71874960e-02f, 1.69931278e-01f, 1.68436453e-01f, 1.37516797e-01f, 1.97166070e-01f,
  5.46480715e-01f, 6.46475106e-02f, -4.14775275e-02f, 1.68631952e-02f, 3.44584435e-02f, 2.42039841e-02f, 3.23548168e-02f, 1.04118086e-01f, 9.75274108e-03f, 1.36124432e-01f,
  1.22934520e-01f, 5.32902628e-02f, 1.82264559e-02f, 2.18914784e-02f, -6.70873513e-03f, 9.17608142e-02f, -1.81865655e-02f, 6.65501505e-02f, 1.07123807e-01f, 1.27057254e-01f,
  4.73955311e-02f, 7.54747391e-02f, 4.48021702e-02f, 5.15744975e-03f, -1.53776556e-01f, -1.24770597e-01f, -1.92746501e-02f, 3.75489630e-02f, -4.74372618e-02f, -1.10719547e-01f,
  -2.53596231e-02f, -2.01911591e-02f, 2.67105158e-02f, -1.54910535e-01f, -1.64152279e-01f, -2.41814926e-02f, -2.01364253e-02f, -1.49570256e-02f, -4.82360795e-02f, -1.03622459e-01f,
  -3.54548320e-02f, -9.02404413e-02f, 5.77231832e-02f, -5.53643927e-02f, -3.60337016e-03f, 1.38537675e-01f, -2.65284199e-02f, 6.68162033e-02f, 2.56874021e-02f, -4.27948125e-03f,
  -7.39277864e-04f, 1.10070668e-02f, 1.89640447e-01f, 3.77107710e-02f, 1.62839174e-01f, -1.35989739e-02f, 7.35383108e-02f, 2.31673513e-02f, 9.10950452e-03f, -4.10608202e-02f,
  4.47010607e-01f, -1.48380548e-01f, -5.96938469e-02f, 5.73342443e-02f, 8.57465789e-02f, 1.48532659e-01f, -5.90919740e-02f, 1.17881767e-01f, 1.83247238e-01f, -1.70462613e-03f,
  3.65518895e-03f, 1.19253984e-02f, 3.39753665e-02f, 4.67987768e-02f, -1.64520629e-02f, -2.46268231e-02f, -6.31489232e-03f, -2.59678308e-02f, 1.38460025e-01f, 1.61540583e-01f,
  -1.00246361e-02f, -6.00010231e-02f, 4.84188795e-02f, 3.26438844e-02f, -1.08921401e-01f, 3.10301897e-03f, 3.24635506e-02f, 1.36328340e-02f, -6.92863166e-02f, -5.27248681e-02f,
  -6.23929381e-01f, 7.55217597e-02f, -1.46950632e-01f, -3.31663460e-01f, 9.34043080e-02f, 2.61278749e-01f, 4.35418338e-01f, 4.15222675e-01f, 6.81628287e-02f, 3.00259322e-01f,
  4.44778055e-02f, -2.07242176e-01f, -2.43520722e-01f, -1.46673620e-01f, 2.27690972e-02f, 4.67146665e-01f, 2.52236038e-01f, -8.49736631e-02f, -8.13731030e-02f, 1.93324208e-01f,
  3.04249562e-02f, -2.57375032e-01f, -3.05290043e-01f, -2.40297049e-01f, -6.50140196e-02f, -1.99831948e-01f, -1.53368130e-01f, -2.55337030e-01f, -5.33472858e-02f, -8.50061476e-02f,
  7.94401243e-02f, -2.64554262e-01f, 9.59500223e-02f, -1.35654658e-01f, -9.05408785e-02f, 7.53270788e-03f, 8.50462094e-02f, 3.84873264e-02f, 6.00161813e-02f, 1.01675093e-02f,
  -1.16785176e-01f, 5.33199636e-03f, -1.54645085e-01f, -5.89590035e-02f, -9.44561064e-02f, 1.16714928e-02f, 3.02177388e-02f, -5.76959252e-02f, -3.84586379e-02f, 7.33377934e-02f,
  1.02103375e-01f, -3.70862521e-02f, 5.07438183e-02f, 8.64613280e-02f, 3.49061377e-02f, -1.06903188e-01f, -6.87671676e-02f, -4.04440388e-02f, -5.03940247e-02f, -8.92744213e-02f,
  3.61713916e-01f, 1.38403520e-01f, -4.68284301e-02f, -7.30151832e-02f, -8.27089250e-02f, -4.96837907e-02f, 2.77223662e-02f, -1.50260687e-01f, -1.02829643e-01f, 2.79249940e-02f,
  3.49708088e-02f, -6.96875853e-03f, -1.60910219e-01f, 3.57725774e-04f, -1.65752098e-01f, 6.93068199e-04f, -5.68557791e-02f, 1.75233968e-02f, -7.75070339e-02f, -1.32509112e-01f,
  -1.44442767e-01f, 6.14812486e-02f, -1.44131720e-01f, 1.78009132e-03f, 9.52591002e-02f, -1.06274821e-01f, -3.83541174e-02f, -1.14831425e-01f, 6.26362711e-02f, -2.96898820e-02f,
  -1.34888351e-01f, -1.07767090e-01f, 6.13877997e-02f, -1.00639716e-01f, -1.43939599e-01f, 6.61518751e-03f, -2.94839591e-01f, -2.66757160e-02f, -1.29693225e-01f, 2.48934440e-02f,
  -8.70686956e-03f, -1.09016031e-01f, -1.03523463e-01f, 1.32662326e-01f, 6.96515515e-02f, -2.08258294e-02f, 9.77961696e-04f, 2.91366633e-02f, 2.58355942e-02f, 1.39392212e-01f,
  6.45640343e-02f, 5.58241531e-02f, -1.52992802e-02f, 9.25511196e-02f, 7.71539733e-02f, -3.86312939e-02f, 1.06089987e-01f, 1.75009996e-01f, 9.63085666e-02f, 1.15592234e-01f,
  -5.52995265e-01f, -2.67449558e-01f, -2.11431414e-01f, -6.07114077e-01f, -5.31694114e-01f, -1.23951182e-01f, -1.76661596e-01f, -1.61167175e-01f, -3.97921622e-01f, -3.07020605e-01f,
  3.29352587e-01f, 4.13817763e-01f, 2.24226803e-01f, 4.78849083e-01f, 5.83870351e-01f, -1.42686188e-01f, -3.25397968e-01f, -2.44242605e-02f, 2.76667446e-01f, 1.20198600e-01f,
  -6.76586032e-02f, -3.55436742e-01f, -2.14175209e-01f, -1.02707088e-01f, -4.66137737e-01f, -3.77315395e-02f, -3.19928169e-01f, -3.53944749e-01f, -1.46137904e-02f, -3.98157150e-01f,
  3.08841854e-01f, -3.31444800e-01f, 1.71892673e-01f, 1.33586928e-01f, -2.13866353e-01f, 1.89941272e-01f, -8.91801789e-02f, -1.40117407e-01f, -7.74129182e-02f, -1.23942688e-01f,
  -2.72804618e-01f, -3.46175842e-02f, 6.59415359e-03f, 4.54069823e-02f, -2.63153195e-01f, 2.73158047e-02f, -1.96641892e-01f, 4.22785394e-02f, 2.70743538e-02f, 1.40724167e-01f,
  9.09262374e-02f, -3.08107734e-02f, -6.75549963e-03f, 1.10190414e-01f, -6.95881173e-02f, 6.75109029e-02f, -5.00939600e-02f, -1.41194656e-01f, -5.85498055e-03f, -4.63324904e-01f,
  -6.62681237e-02f, 1.12959007e-02f, -3.72380391e-02f, -7.05862343e-02f, 5.91611490e-02f, -4.12661918e-02f, -1.51006831e-02f, 1.83241777e-02f, -4.81556095e-02f, -3.77937593e-02f,
  5.31087965e-02f, -4.35588472e-02f, 1.65068489e-02f, 9.72083677e-03f, 1.17122330e-01f, -8.28609839e-02f, 2.71719322e-02f, 9.34541821e-02f, -7.70175681e-02f, -9.61780995e-02f,
  4.50764634e-02f, -1.08310357e-01f, -4.63357568e-02f, 5.53827547e-02f, 6.63518161e-02f, -7.67919198e-02f, -7.55419880e-02f, 1.08583085e-01f, -8.60766470e-02f, -5.20091653e-02f,
  2.43914753e-01f, 3.91907454e-01f, 1.93307754e-02f, 9.44399536e-02f, -1.80503070e-01f, -9.45622250e-02f, -8.90417323e-02f, 1.20367147e-02f, 4.47251573e-02f, 3.04754302e-02f,
  -2.70048659e-02f, 1.11549720e-02f, -1.35246754e-01f, -1.23553962e-01f, -2.28084903e-02f, 1.25490755e-01f, 3.42449583e-02f, -8.87152106e-02f, 1.42754734e-01f, -6.52858019e-02f,
  2.49652248e-02f, -3.49935107e-02f, 1.28653541e-01f, 1.66580528e-01f, -7.55786449e-02f, 1.27907783e-01f, 2.83285882e-02f, 1.38754681e-01f, 2.49901801e-01f, -1.51799038e-01f,
  -5.32249033e-01f, 2.79900044e-01f, 7.30397999e-02f, -3.49412233e-01f, 1.08716764e-01f, 2.83700168e-01f, 6.71896279e-01f, -4.33170004e-04f, -4.85247314e-01f, 1.85449451e-01f,
  1.97896492e-02f, -3.41549754e-01f, -2.83193767e-01f, -2.11225465e-01f, 1.35967374e-01f, 5.51403522e-01f, 2.63550967e-01f, -1.15690649e-01f, -3.88940483e-01f, -1.49378940e-01f,
  4.89601679e-02f, -2.27694049e-01f, -3.82641882e-01f, -1.97864190e-01f, -1.20736949e-01f, -3.25788587e-01f, 1.44794524e-01f, -4.77059744e-02f, 1.73379019e-01f, -1.37158141e-01f,
  4.82535809e-01f, 2.14837030e-01f, -4.66266386e-02f, -3.08838069e-01f, 1.03572085e-01f, -3.21082659e-02f, 5.90871349e-02f, -2.52309978e-01f, -1.91526830e-01f, -1.21967345e-01f,
  -1.41453385e-01f, -1.81953534e-01f, -3.37226619e-03f, 4.33976166e-02f, 8.16644058e-02f, -9.68795717e-02f, -7.01865852e-02f, 5.01948595e-02f, -5.32640237e-03f, 4.15317118e-02f,
  -7.86099359e-02f, 1.23172298e-01f, 5.39226420e-02f, 7.58023327e-03f, -1.85890660e-01f, -1.02297753e-01f, 8.82538334e-02f, -2.25701258e-01f, -9.97100919e-02f, -1.84329879e-02f,
  -1.04896510e-02f, -4.97412086e-02f, -1.26296282e-01f, 3.57047166e-03f, 1.97222009e-02f, 8.39825496e-02f, -4.31624986e-02f, 2.97948606e-02f, 7.78575018e-02f, 8.03661793e-02f,
  -4.52720821e-02f, 8.17422122e-02f, 6.07516989e-03f, 1.82481986e-02f, -1.48950607e-01f, -6.30899519e-02f, 8.89198408e-02f, 5.19944690e-02f, -5.32668978e-02f, -4.11760360e-02f,
  -1.52486460e-02f, -5.71554862e-02f, -9.95387435e-02f, 5.41523919e-02f, -2.06913389e-02f, -8.95052478e-02f, -6.95344945e-03f, -1.37240365e-01f, -1.30863279e-01f, -2.76902458e-03f,
  3.01209569e-01f, 2.26226360e-01f, 1.08412996e-01f, 2.23764013e-02f, 9.78864208e-02f, -1.88918959e-03f, -1.54619245e-02f, -3.92430015e-02f, -8.55592117e-02f, -1.50212273e-01f,
  -2.34116614e-01f, -9.87612307e-02f, 1.41620591e-01f, 5.42430580e-02f, -6.26195297e-02f, -1.01551004e-01f, 2.00053692e-01f, 4.24139900e-03f, -1.77414995e-02f, 1.28809556e-01f,
  6.23469800e-02f, 4.26405631e-02f, 1.51997834e-01f, 1.26222327e-01f, 5.78889288e-02f, -1.12111486e-01f, 2.39476919e-01f, 1.17295265e-01f, 4.16813269e-02f, 3.07823390e-01f,
  6.07147217e-01f, -5.55924363e-02f, -1.27743766e-01f, 2.44467869e-01f, 1.50485426e-01f, -1.45530514e-02f, 6.96028844e-02f, 1.36985257e-01f, 2.36600235e-01f, 5.44254370e-02f,
  2.27168858e-01f, 3.05965155e-01f, 2.20915854e-01f, 1.93279520e-01f, 5.29154763e-02f, -6.53733760e-02f, -9.32889879e-02f, -6.19553663e-02f, 1.47045031e-01f, 2.03870870e-02f,
  -6.06893972e-02f, -4.09371518e-02f, 7.15116560e-02f, 2.71173846e-03f, -1.17075384e-01f, 3.66273113e-02f, -8.92670825e-02f, -1.70746297e-01f, -1.55097261e-01f, -1.22220404e-01f,
  -4.10246015e-01f, 3.60920647e-04f, 6.22029081e-02f, -4.40454297e-02f, -1.09336935e-01f, 4.29725945e-02f, 8.90274271e-02f, -2.30796933e-02f, 4.18336242e-02f, 9.64021031e-03f,
  -9.99409482e-02f, 1.00686820e-02f, -9.88628492e-02f, -8.64373967e-02f, -1.19510569e-01f, -7.22768679e-02f, 3.35401967e-02f, 1.74447952e-03f, 4.47578318e-02f, -7.15093836e-02f,
  -8.84191170e-02f, -8.33498612e-02f, -1.22554619e-02f, 5.75855151e-02f, 8.86598304e-02f, 3.05733997e-02f, 4.46009599e-02f, -7.35615417e-02f, 4.96275499e-02f, 3.34107876e-02f,
  5.21450862e-02f, 3.22822593e-02f, 1.32877111e-01f, 4.11728434e-02f, -1.00947767e-02f, 5.82066774e-02f, 3.94072197e-03f, -6.02816753e-02f, 4.53773290e-02f, -9.76476520e-02f,
  -1.23019561e-01f, 8.87837559e-02f, 5.99375218e-02f, -3.42058055e-02f, 6.65055960e-02f, 5.43243997e-03f, -6.09483682e-02f, -5.25589511e-02f, 2.83379015e-02f, -4.85451482e-02f,
  2.14628670e-02f, -1.71027407e-02f, -6.59516826e-02f, -3.76017354e-02f, 3.78981121e-02f, 2.97977943e-02f, 4.86347303e-02f, 7.20504448e-02f, 7.39358142e-02f, -4.92085293e-02f,
  -4.75580916e-02f, 2.01834351e-01f, 8.20694789e-02f, -4.24967743e-02f, -8.41794834e-02f, -6.95203990e-02f, -1.75761264e-02f, -1.73342191e-02f, -2.43057590e-02f, -1.35502994e-01f,
  -6.67205006e-02f, 3.46078724e-02f, -5.02839014e-02f, -8.80267248e-02f, -5.16552739e-02f, 3.29505168e-02f, -6.39636740e-02f, -3.43140624e-02f, 3.47841941e-02f, -1.00928739e-01f,
  -8.87959823e-02f, 1.03595257e-02f, -1.69524667e-03f, 8.85077789e-02f, 2.61227675e-02f, 7.65131488e-02f, 2.69044396e-02f, -1.10850651e-02f, 5.98936155e-02f, 4.61550429e-02f,
  -8.26775849e-01f, 3.31397980e-01f, 2.20776156e-01f, -7.30435014e-01f, -1.47918999e-01f, 9.28770751e-02f, 2.98649073e-01f, -2.72490382e-01f, -4.30437565e-01f, 2.61242896e-01f,
  2.32256979e-01f, -2.71272689e-01f, -1.16492987e-01f, -1.62145570e-01f, -2.65724212e-01f, 8.22917596e-02f, -1.23859152e-01f, -4.41329896e-01f, -5.41379035e-01f, -2.33042672e-01f,
  -2.69043267e-01f, -3.33078444e-01f, -5.31337142e-01f, -2.52501726e-01f, -2.07067523e-02f, -1.32833198e-01f, 1.93686798e-01f, -1.86624959e-01f, 2.02144876e-01f, -3.53126377e-02f,
  4.53462303e-01f, -9.28606316e-02f, -9.07169580e-02f, -2.88441271e-01f, 8.04761425e-02f, -6.85575977e-02f, 8.78090113e-02f, -1.35733351e-01f, 2.16235663e-03f, 6.08857982e-02f,
  -7.56780952e-02f, -2.17147786e-02f, -2.03207314e-01f, -3.39017585e-02f, -1.02480292e-01f, -1.26042768e-01f, -2.62096614e-01f, -1.59916595e-01f, -1.37415081e-01f, 3.52313429e-01f,
  1.58279970e-01f, -6.42026886e-02f, 8.76941234e-02f, 2.47445777e-01f, 1.49145797e-01f, -9.49812308e-02f, 2.70635247e-01f, 3.92719498e-03f, 7.11506680e-02f, 2.01074108e-01f,
  -4.84562553e-02f, -1.41663859e-02f, -4.62534130e-02f, -1.96038894e-02f, -7.46906502e-03f, -1.38940930e-01f, 2.20799409e-02f, -4.83515626e-03f, 9.20160580e-03f, 3.85740139e-02f,
  -1.51137300e-02f, 2.09122241e-01f, 3.76031622e-02f, 9.80067924e-02f, -2.89033018e-02f, -1.89730644e-01f, -1.64633319e-02f, 1.49284750e-01f, 3.88284922e-02f, -9.76784155e-02f,
  -8.80902633e-02f, 4.84090932e-02f, -5.49714006e-02f, 2.43594386e-02f, 1.27738863e-01f, -6.57097995e-02f, -7.42283687e-02f, 4.24474515e-02f, -6.04337007e-02f, -1.01784043e-01f,
  -2.95047481e-02f, -5.64296320e-02f, 8.26057643e-02f, -2.21904382e-01f, 2.69338991e-02f, 8.97271410e-02f, 3.14355642e-02f, 2.85021625e-02f, 4.19629477e-02f, 4.65360805e-02f,
  -1.39343329e-02f, 2.11709714e-03f, 1.70674950e-01f, 7.94286877e-02f, -9.42117423e-02f, 2.74582729e-02f, -1.44767597e-01f, -8.86522830e-02f, 4.94042039e-02f, 1.21696174e-01f,
  7.00237304e-02f, -1.74689069e-02f, -9.06567201e-02f, 1.53965697e-01f, 1.05647855e-01f, -2.02800289e-01f, 3.19537550e-01f, 2.88531154e-01f, 8.89621899e-02f, 2.26299256e-01f,
  -7.13547528e-01f, 1.12502284e-01f, -4.95851964e-01f, -5.16301334e-01f, -2.63391286e-01f, -3.00995588e-01f, 2.13533983e-01f, 1.46675766e-01f, -1.37787327e-01f, -2.38068588e-02f,
  1.60588622e-01f, 3.01495381e-02f, -1.89545348e-01f, 3.66596952e-02f, -4.34560552e-02f, -6.65150583e-02f, -3.30147803e-01f, -5.26267886e-01f, -4.98036109e-02f, 3.06472749e-01f,
  6.23800606e-02f, -1.66497067e-01f, -2.83427864e-01f, -1.31247446e-01f, 1.88252446e-03f, -2.51798406e-02f, -2.23334432e-01f, -2.28050470e-01f, -1.14288040e-01f, -4.68980610e-01f,
  3.48502636e-01f, -4.00389761e-01f, -4.18460704e-02f, -1.36309475e-01f, 6.17264286e-02f, -7.79338703e-02f, -5.41796573e-02f, -2.46934500e-02f, -9.85475350e-03f, -5.45910038e-02f,
  -2.10388392e-01f, -4.84963655e-02f, -2.27692332e-02f, -1.52871003e-02f, -2.24662963e-02f, 7.37020513e-03f, 6.15480402e-03f, -1.41633525e-01f, 3.10120396e-02f, 1.64893717e-01f,
  -1.13573186e-02f, -2.71421820e-01f, -1.29909918e-01f, 1.38468415e-01f, 1.07541345e-01f, -1.70678809e-01f, 2.57035851e-01f, -4.26247809e-03f, -5.69715053e-02f, -2.26189531e-02f,
  1.28138557e-01f, -4.06304188e-03f, -1.39270648e-02f, 4.86071706e-02f, 1.34408191e-01f, -1.44705743e-01f, -7.45744407e-02f, 1.26860991e-01f, -1.53045775e-02f, 1.91172332e-01f,
  8.87123644e-02f, 7.90233612e-02f, -4.59487848e-02f, -1.68548245e-03f, -5.63139543e-02f, -1.02047205e-01f, -5.12694344e-02f, 1.62191898e-01f, -3.95321026e-02f, -8.35007578e-02f,
  -1.92380607e-01f, -2.06756219e-02f, -8.65033269e-02f, 7.24348947e-02f, -1.42566979e-01f, -2.06485502e-02f, -6.00128658e-02f, 2.18467265e-02f, 6.64951354e-02f, -1.71516370e-02f,
  2.59581506e-01f, -2.87978917e-01f, 1.21103860e-01f, 6.65129581e-03f, -1.32804170e-01f, -8.82527325e-03f, -1.01998881e-01f, -1.78927707e-03f, -1.79205492e-01f, 9.40398946e-02f,
  -5.09824324e-03f, 3.63990143e-02f, 1.78841501e-02f, 6.67965785e-02f, 2.35466901e-02f, 1.64287612e-02f, 8.35121572e-02f, -3.55275273e-02f, -1.49029896e-01f, 1.37420937e-01f,
  1.00823142e-01f, -1.88098893e-01f, 1.31392982e-02f, 3.52134332e-02f, 4.92515713e-02f, -1.37761548e-01f, 1.92464635e-01f, 1.91879332e-01f, -2.25906987e-02f, 2.75946409e-01f,
  -4.87529784e-01f, 5.51794589e-01f, 1.81435660e-01f, -3.55382919e-01f, 3.27784538e-01f, 1.86510846e-01f, 2.47071892e-01f, -2.82675803e-01f, -5.00768363e-01f, 3.32252085e-02f,
  3.13694000e-01f, 2.19296198e-02f, -8.76476988e-02f, -9.34751034e-02f, -2.47138310e-02f, 6.78027347e-02f, 9.01047811e-02f, -9.44955051e-02f, -1.51544049e-01f, 9.49584916e-02f,
  2.13772178e-01f, -8.53465870e-03f, -2.40451530e-01f, -2.53609806e-01f, -9.93753746e-02f, 4.76930439e-02f, 3.16900909e-02f, 2.37758830e-01f, 3.47637087e-01f, 3.04996550e-01f,
  1.56570837e-01f, -8.32830817e-02f, -1.30326107e-01f, -3.35747413e-02f, 1.64269641e-01f, -3.93698186e-01f, -1.77188769e-01f, -1.15192108e-01f, 1.04015402e-01f, -1.35893390e-01f,
  2.41898760e-01f, 9.67536792e-02f, 2.15595625e-02f, -3.61261964e-02f, -1.91050947e-01f, -2.34352693e-01f, -1.74350977e-01f, -2.21880898e-01f, -3.07169229e-01f, -1.49976835e-01f,
  4.91800576e-01f, 4.95098293e-01f, -2.40286868e-02f, -1.83156326e-01f, -3.88599932e-01f, -6.34623924e-03f, -5.47654442e-02f, -1.27454758e-01f, -2.78443485e-01f, -3.32149178e-01f,
  -2.32687462e-02f, 1.49881989e-01f, 5.77646270e-02f, 3.54105793e-02f, 6.00252450e-02f, 5.18336855e-02f, 1.50734723e-01f, 1.24640293e-01f, 4.59128991e-04f, -1.04130423e-02f,
  -3.61987688e-02f, -4.71013077e-02f, -1.83245972e-01f, -1.11757912e-01f, 2.85737645e-02f, 7.02319443e-02f, 2.14944333e-02f, 8.05667019e-04f, 1.52794719e-01f, -6.00222386e-02f,
  -1.52168712e-02f, -5.65823577e-02f, -2.57296134e-02f, -2.01329440e-01f, 8.25178102e-02f, 1.23861125e-02f, -5.93977720e-02f, -6.98692575e-02f, -9.29881558e-02f, 7.26941228e-02f,
  -2.98203617e-01f, 4.27165866e-01f, -1.91397563e-01f, -7.38842115e-02f, 1.50843173e-01f, -1.59516811e-01f, -7.80361891e-02f, 7.45908394e-02f, 5.55113442e-02f, -1.60402909e-01f,
  1.24077037e-01f, 1.82046462e-02f, -1.25489375e-02f, -3.43785696e-02f, -2.66505778e-01f, -8.42573866e-02f, 1.96821839e-01f, -6.83595166e-02f, -2.35392570e-01f, -1.92463771e-01f,
  -7.83533305e-02f, -1.85356468e-01f, -3.34625661e-01f, -3.69169265e-01f, -2.97556788e-01f, -3.14818293e-01f, -1.01833098e-01f, -1.98539287e-01f, -1.64429948e-01f, -3.09356302e-01f,
  -1.71827942e-01f, -1.68856353e-01f, -5.25232494e-01f, -5.92059195e-01f, -4.02720153e-01f, -9.86238047e-02f, 1.68174937e-01f, 8.26665908e-02f, -8.80600363e-02f, -1.74225330e-01f,
  -7.45745972e-02f, 2.97365189e-02f, -1.55751601e-01f, 7.16364458e-02f, 3.47583629e-02f, -1.40918329e-01f, -3.54842395e-01f, -1.42108589e-01f, 1.19508386e-01f, 1.96210578e-01f,
  1.54775083e-01f, -2.61422545e-01f, -2.05027297e-01f, -1.88640326e-01f, -3.15244764e-01f, -2.37005860e-01f, -4.46963400e-01f, -2.27850318e-01f, 2.08245553e-02f, -3.51461053e-01f,
  -5.33437133e-01f, -1.17849313e-01f, 3.00414413e-02f, 3.11275348e-02f, -2.33629540e-01f, -1.09469585e-01f, 1.70731843e-02f, -9.50338915e-02f, -5.55384858e-03f, -1.85342252e-01f,
  -2.15816066e-01f, -2.06053015e-02f, -2.27571353e-02f, -1.80009604e-01f, -1.81454450e-01f, 2.80215610e-02f, -2.02619895e-01f, -6.24684617e-02f, -3.63574922e-02f, 1.61952928e-01f,
  1.97439268e-01f, 4.99043465e-02f, -1.15902402e-01f, 7.36909499e-03f, 1.10099360e-01f, -1.31622357e-02f, -4.08296399e-02f, 3.75794582e-02f, 3.66591737e-02f, -1.56850725e-01f,
  1.03247933e-01f, 3.94754782e-02f, 9.32582691e-02f, 3.99161056e-02f, 9.85984951e-02f, 4.25199866e-02f, -1.07763238e-01f, -3.49608101e-02f, 9.14665312e-02f, 2.78518908e-03f,
  -4.91189212e-02f, -1.55073833e-02f, 4.99103777e-02f, -7.44004324e-02f, -9.19375196e-02f, 1.95213445e-02f, 9.96059254e-02f, 1.27625838e-02f, 8.55016187e-02f, 4.03858609e-02f,
  1.09369576e-01f, 1.36694327e-01f, -7.96188489e-02f, 9.46577564e-02f, 1.91315815e-01f, -4.15759683e-02f, 8.01578760e-02f, 1.74283698e-01f, 5.56961298e-02f, 9.79694203e-02f,
  -3.87599975e-01f, 7.31226876e-02f, -4.74651642e-02f, 4.24508154e-02f, -3.95078063e-02f, -2.87870634e-02f, -1.39115930e-01f, -4.13953029e-02f, -2.10380927e-01f, -5.14459386e-02f,
  1.09939210e-01f, 8.85013044e-02f, -8.44421461e-02f, 2.23064683e-02f, -4.48070653e-02f, 8.95787776e-02f, 1.20689668e-01f, 4.24933136e-02f, 5.93608581e-02f, 1.79696858e-01f,
  1.67344511e-01f, 2.59691507e-01f, 6.38938174e-02f, -2.28537340e-02f, 1.19525678e-01f, 6.87607005e-02f, 6.71578273e-02f, 1.08117461e-01f, 3.46400291e-02f, 9.14640874e-02f,
  1.85526878e-01f, 2.59871602e-01f, -3.51713449e-01f, 2.16910735e-01f, -1.19482189e-01f, -2.78387755e-01f, -2.49896422e-02f, 3.35096158e-02f, 1.29833147e-01f, 1.50060564e-01f,
  2.06106175e-02f, -3.54204774e-01f, -3.04380476e-01f, -3.92373472e-01f, -3.30882639e-01f, -9.18835700e-02f, -1.97693363e-01f, -5.76632380e-01f, -6.65105820e-01f, -3.19946349e-01f,
  -1.67553663e-01f, -1.13396510e-01f, -1.94503218e-01f, -1.79247305e-01f, -8.49748310e-03f, -2.48845190e-01f, -7.42236152e-02f, -8.83366615e-02f, -2.69920439e-01f, -1.70714259e-01f,
  -2.74406046e-01f, 3.84522369e-03f, -5.07700294e-02f, 9.80128795e-02f, 3.52290384e-02f, 1.59703493e-01f, 7.81523287e-02f, 1.42389789e-01f, 1.16003625e-01f, 8.40781555e-02f,
  6.11886121e-02f, 1.92993209e-02f, -1.09424610e-02f, -4.30699140e-02f, 3.94157246e-02f, -1.37358578e-02f, 1.56144321e-01f, 6.03815354e-02f, 1.21446192e-01f, 1.09524444e-01f,
  1.19451530e-01f, -3.49904634e-02f, 1.28383398e-01f, 6.87611848e-02f, 8.22921023e-02f, -5.60183823e-02f, 7.96546191e-02f, -9.35471151e-03f, 1.60583500e-02f, 7.16119781e-02f,
  1.21322903e-03f, 9.95274037e-02f, 1.43301543e-02f, -5.31216115e-02f, 2.10453853e-01f, 1.77495465e-01f, -5.16901445e-03f, 7.72943273e-02f, 2.99623255e-02f, 1.36995360e-01f,
  2.70248204e-01f, -1.96304563e-02f, 6.56304508e-02f, 1.95500832e-02f, -1.08423524e-01f, 1.13765113e-02f, -4.04276513e-02f, 7.41558149e-02f, 1.41467243e-01f, 9.22640935e-02f,
  7.49894381e-02f, 7.82382861e-02f, -4.61705786e-04f, -4.72800396e-02f, 6.23403564e-02f, 3.50283049e-02f, 2.59275432e-03f, -2.73268688e-02f, -4.60682511e-02f, -5.46516851e-02f,
  5.99789321e-02f, -2.03133821e-01f, -7.44094560e-03f, 9.98038892e-03f, 9.31155905e-02f, 8.49896297e-02f, -7.28773251e-02f, 3.81279062e-03f, 4.72985283e-02f, -4.75131683e-02f,
  2.99495552e-02f, -1.86886229e-02f, -1.02531351e-03f, 3.48052569e-02f, -9.46153551e-02f, 4.25751088e-03f, 1.83983758e-01f, 6.97536692e-02f, -7.17706159e-02f, 1.64402425e-01f,
  2.03401580e-01f, 1.28298029e-01f, 9.71201733e-02f, 8.73358995e-02f, 1.80330239e-02f, -9.53997970e-02f, -3.14946435e-02f, 6.48043603e-02f, -1.32649332e-01f, 7.85551295e-02f,
  2.36801520e-01f, -3.54963273e-01f, -2.19625697e-01f, 1.98895440e-01f, 2.02569336e-01f, 2.33428001e-01f, 2.27032289e-01f, 2.59025991e-01f, 8.32837671e-02f, -2.73613371e-02f,
  -2.43863836e-01f, -2.24278256e-01f, -1.94409013e-01f, -2.48342872e-01f, -4.48875688e-02f, 2.17863247e-02f, -1.72715127e-01f, -6.54665008e-02f, 1.10497065e-01f, 2.18429476e-01f,
  1.57958448e-01f, 2.33122855e-01f, 1.91584304e-01f, 8.37498009e-02f, 1.90967675e-02f, -1.30887777e-01f, -2.29866683e-01f, 1.52370539e-02f, -2.43212953e-01f, -2.93141752e-01f,
  -1.36409104e-01f, 1.98757760e-02f, -4.65432135e-03f, -1.73660621e-01f, -8.37623030e-02f, 4.32957970e-02f, -7.26248994e-02f, -4.88699712e-02f, 1.39780622e-02f, 4.10612412e-02f,
  1.37739554e-02f, 2.08118837e-03f, 6.05959222e-02f, 6.73959628e-02f, 4.39495966e-02f, 1.14886008e-01f, -1.79998241e-02f, 3.78639624e-02f, -1.38608947e-01f, -9.46725085e-02f,
  -1.17995605e-01f, -3.25565375e-02f, 5.06476946e-02f, 1.46236795e-03f, -5.62047400e-02f, -3.87576930e-02f, 2.42728349e-02f, 3.23915333e-02f, -1.17440164e-01f, 6.17374778e-02f,
  2.76507493e-02f, 1.28742859e-01f, -8.88734758e-02f, 3.55449840e-02f, -5.80345206e-02f, 8.06266218e-02f, 1.24249719e-01f, 8.19253176e-02f, 5.27715385e-02f, -4.85653058e-03f,
  -1.04223967e-01f, -1.77741811e-01f, -8.54576752e-02f, -1.24666030e-02f, -1.17793776e-01f, -3.44804600e-02f, -3.49720344e-02f, -9.52622145e-02f, -2.92016543e-03f, -7.44339377e-02f,
  -9.85072106e-02f, -4.50696284e-03f, -3.02787628e-02f, 1.52863162e-02f, -8.93045813e-02f, -8.02999586e-02f, -9.75442901e-02f, -6.20126585e-03f, -3.10719311e-02f, 9.01883245e-02f,
  1.79130450e-01f, -2.60097325e-01f, -4.88615073e-02f, -8.76999721e-02f, -1.05869368e-01f, -1.65416375e-01f, -2.17398420e-01f, -1.54470757e-01f, -1.61317009e-02f, 1.11863904e-01f,
  -2.66466476e-02f, 8.22569206e-02f, 6.45551756e-02f, 7.95592815e-02f, 1.97083756e-01f, 9.05838888e-03f, -1.66692823e-01f, -8.12478513e-02f, -1.27334043e-01f, 8.66120011e-02f,
  2.14582607e-02f, 7.81353563e-03f, 1.25216872e-01f, 6.18442409e-02f, 7.92570263e-02f, 5.24422266e-02f, 1.08058013e-01f, 3.93274724e-02f, -2.21747681e-02f, 2.87493646e-01f,
  -6.54357553e-01f, -5.76421559e-01f, 3.00777763e-01f, 1.03107363e-01f, -1.85599968e-01f, -2.74797767e-01f, -6.08711243e-01f, 1.83565076e-02f, 3.02048773e-01f, -2.07255408e-01f,
  -1.58646345e-01f, -1.30259991e-01f, -2.45975815e-02f, 7.21124634e-02f, -8.16101860e-03f, -1.90343112e-01f, 2.54640318e-02f, 2.43136331e-01f, 1.46429405e-01f, -2.52973616e-01f,
  -3.30985546e-01f, -2.00037882e-02f, 2.72468418e-01f, 1.37986526e-01f, -2.34323770e-01f, -2.38829941e-01f, 1.07421666e-01f, -2.53176212e-01f, -4.90614325e-01f, -5.32284975e-01f,
  -1.70800686e-01f, -1.03317268e-01f, 1.29751682e-01f, -1.25265151e-01f, 5.40762804e-02f, -1.32827774e-01f, -1.80530593e-01f, 2.70461410e-01f, -7.14781880e-02f, 1.54205814e-01f,
  5.64528331e-02f, 1.52454689e-01f, -2.35920604e-02f, -6.68404102e-02f, 6.14946596e-02f, 2.49114004e-03f, 4.68504608e-01f, 3.08225989e-01f, 1.91576019e-01f, 9.58389342e-02f,
  -3.33633870e-01f, -3.06002498e-01f, -2.45459117e-02f, 1.35454565e-01f, 2.05779865e-01f, 2.61695355e-01f, -1.62175149e-01f, -1.83699489e-01f, 4.52281013e-02f, -6.11060381e-01f,
  -9.39585455e-03f, -3.00304331e-02f, 3.03293485e-02f, 4.08510715e-02f, -1.87917762e-02f, 1.60042450e-01f, 2.10630689e-02f, -1.06515601e-01f, -5.59657775e-02f, 9.59424376e-02f,
  1.09948799e-01f, -2.59585027e-02f, -1.28088901e-02f, -7.20534846e-02f, -5.83813004e-02f, 7.71681592e-02f, -1.08031392e-01f, 6.85591102e-02f, 6.92205727e-02f, -7.67819136e-02f,
  -4.00914699e-02f, -1.56077623e-01f, 1.31783068e-01f, -5.46903489e-03f, -3.78559455e-02f, 2.19514295e-01f, 8.45165849e-02f, 1.46777630e-02f, 2.09033474e-01f, 7.78867006e-02f,
  1.70387015e-01f, 1.56054154e-01f, -3.67123872e-01f, -2.45322171e-03f, -6.40764832e-02f, 1.56422958e-01f, -2.28997208e-02f, 3.57837267e-02f, -6.29864335e-02f, -1.05903409e-01f,
  6.45928010e-02f, 1.44864861e-02f, -1.41905453e-02f, 1.29180446e-01f, -1.07435631e-02f, 3.63078602e-02f, -8.11939873e-03f, -2.28163242e-01f, -1.45810470e-02f, 4.49266322e-02f,
  8.71949196e-02f, -1.71655849e-01f, -2.42912397e-01f, -2.45189637e-01f, -1.83151439e-01f, -2.42829829e-01f, -2.73138940e-01f, -3.09017330e-01f, -4.01775569e-01f, -5.64286768e-01f,
  -3.78263623e-01f, -4.43998933e-01f, 3.06544304e-01f, -5.81672847e-01f, 7.34398002e-03f, 4.24223185e-01f, 2.97344774e-01f, 7.94266444e-03f, -1.21448092e-01f, 9.89542454e-02f,
  -6.75992146e-02f, -1.79891452e-01f, -1.66655391e-01f, 9.86778922e-03f, 5.62733039e-02f, 2.40232289e-01f, 1.58088088e-01f, 8.22888613e-02f, 1.36027813e-01f, 5.01917638e-02f,
  -2.83994943e-01f, -4.31243002e-01f, -2.36672983e-01f, -1.77363798e-01f, -4.10507470e-01f, -5.84704466e-02f, -1.84432074e-01f, -1.42326325e-01f, 1.54090211e-01f, -3.04305285e-01f,
  1.51758283e-01f, -1.08250238e-01f, 3.56746726e-02f, -1.06621265e-01f, -2.18001857e-01f, 4.55350094e-02f, -3.10980473e-02f, -1.38897389e-01f, 1.93166360e-03f, 6.80597425e-02f,
  -1.16361037e-01f, -1.44195184e-01f, -6.39885589e-02f, -1.18679568e-01f, -3.53991427e-02f, -8.97512808e-02f, -1.59103110e-01f, -1.37511864e-01f, -6.27329648e-02f, 4.86838855e-02f,
  -5.73284589e-02f, 7.02166855e-02f, 8.52268562e-02f, 5.48101701e-02f, -5.04343100e-02f, 6.94842115e-02f, 6.91964403e-02f, 3.29244770e-02f, 8.27746168e-02f, -9.11975577e-02f,
  -1.61093980e-01f, 6.74217865e-02f, 7.86667690e-02f, -7.56882057e-02f, 5.73188588e-02f, 5.09107625e-03f, -5.59403114e-02f, -3.58093739e-03f, -9.98474509e-02f, -1.09468542e-01f,
  -2.06663221e-01f, 2.82804738e-03f, -7.26760775e-02f, -7.86464661e-02f, -6.76279888e-02f, -1.03768319e-01f, 1.14404999e-01f, -1.59316227e-01f, -1.73344184e-02f, -9.99833569e-02f,
  -1.21637054e-01f, -2.48561166e-02f, -1.63392693e-01f, -1.10776745e-01f, 1.27434824e-02f, -1.00338750e-01f, -5.11598885e-02f, 5.91153512e-04f, -1.41731948e-01f, -9.47155803e-02f,
  -3.40753883e-01f, 1.18012860e-01f, -9.73399263e-03f, -1.08227737e-01f, -6.68109506e-02f, -4.92564216e-02f, -6.72371238e-02f, 1.17420219e-02f, 4.44836952e-02f, 1.20640121e-01f,
  -1.29753882e-02f, 4.34712693e-02f, -1.16240405e-01f, -2.04082146e-01f, -8.44314843e-02f, -2.21757665e-02f, -3.91757600e-02f, -5.00648171e-02f, 1.44601790e-02f, -5.35493977e-02f,
  -1.46793678e-01f, 7.92751536e-02f, 1.10414900e-01f, 1.39279336e-01f, 5.78311048e-02f, 2.63645470e-01f, 1.17425628e-01f, 1.43093899e-01f, 1.82248190e-01f, 6.70650527e-02f,
  -6.20455146e-01f, -1.51707038e-01f, -6.66011008e-04f, -2.99314737e-01f, -7.84241632e-02f, 1.03207350e-01f, 1.65669650e-01f, 8.42514485e-02f, -1.06541842e-01f, -1.86296776e-01f,
  1.05047531e-01f, 4.49348539e-02f, -1.46633804e-01f, -8.41645971e-02f, -2.95084894e-01f, -3.51738393e-01f, -3.78573865e-01f, -2.10805237e-01f, 1.44572049e-01f, 2.60840148e-01f,
  2.19851471e-02f, -2.28971705e-01f, -1.79979116e-01f, -1.47671834e-01f, 2.88936440e-02f, -1.88704915e-02f, -2.48680383e-01f, -2.58981615e-01f, -1.16027303e-01f, -3.89542222e-01f,
  2.33772829e-01f, 1.43150032e-01f, 2.57728491e-02f, -1.40193209e-01f, 2.89890170e-02f, -4.73018326e-02f, -1.19960494e-02f, 6.72007799e-02f, 3.99111584e-02f, 1.90204922e-02f,
  9.36234146e-02f, 5.71412295e-02f, 1.39146689e-02f, 1.16289027e-01f, 8.52768198e-02f, 8.88126567e-02f, 1.72101706e-02f, -1.32094815e-01f, -9.23869088e-02f, 1.84057891e-01f,
  1.01866066e-01f, -5.54170720e-02f, -6.22477615e-03f, -2.98771504e-02f, 1.23017311e-01f, -7.75378803e-03f, 2.39760458e-01f, 1.22445613e-01f, 3.95656601e-02f, -1.46672070e-01f,
  9.11191572e-03f, -7.99553916e-02f, -5.77128455e-02f, -2.34424751e-02f, 8.97057354e-02f, -6.66672960e-02f, -5.19546457e-02f, 3.98486853e-02f, 1.63381137e-02f, 9.33448449e-02f,
  1.23756245e-01f, 1.58444676e-03f, 1.23537913e-01f, -1.53085917e-01f, 2.91055255e-02f, -1.19946236e-02f, -4.89526689e-02f, -8.78050700e-02f, 5.25861382e-02f, 3.27220894e-02f,
  1.22708879e-01f, 1.12500876e-01f, 7.61082321e-02f, 1.32969886e-01f, 1.34389833e-01f, 4.34790179e-03f, 5.06492965e-02f, 1.27774119e-01f, 9.08025876e-02f, 1.23742493e-02f,
  1.78560689e-01f, -1.77744165e-01f, -1.22970417e-01f, -6.39662966e-02f, -1.18326964e-02f, -1.85584556e-02f, -8.72491002e-02f, -1.16571244e-02f, 1.39377341e-02f, 7.66575262e-02f,
  2.36607432e-01f, 1.22733852e-02f, -1.13873400e-01f, 1.17041588e-01f, 9.29872841e-02f, 2.47315243e-02f, -1.41718596e-01f, -1.26654118e-01f, -1.10327201e-02f, 1.98062763e-01f,
  -5.92473596e-02f, -1.38580367e-01f, -1.08649403e-01f, -1.41183734e-01f, 1.60802901e-01f, -9.53749642e-02f, 5.05504347e-02f, 2.32926950e-01f, -9.31373537e-02f, -2.46681824e-01f,
  3.09181601e-01f, 2.49760598e-01f, 2.27259934e-01f, -1.08088955e-01f, -1.91006199e-01f, -2.17339277e-01f, -1.01794720e-01f, 1.10589489e-01f, 5.54554649e-02f, 5.79659566e-02f,
  7.85980970e-02f, 1.26092672e-01f, 2.93465734e-01f, 2.68580198e-01f, 2.24831015e-01f, 1.35933667e-01f, 6.37584627e-02f, 2.48338640e-01f, 1.20680936e-01f, 1.92514043e-02f,
  2.29100045e-02f, -7.06481189e-02f, -1.35717085e-02f, 1.05382361e-01f, 6.08664565e-02f, -3.42230499e-03f, 7.39032850e-02f, -1.02048658e-01f, -2.10752096e-02f, 9.12946686e-02f,
  -1.12708798e-02f, -9.02004018e-02f, 6.62075356e-02f, -2.78896410e-02f, 4.96514216e-02f, 7.18064532e-02f, 7.85633083e-03f, 7.18203187e-02f, -6.81033507e-02f, -6.61634281e-02f,
  -6.59523234e-02f, 5.96548170e-02f, -2.43500732e-02f, 1.05982805e-02f, -7.86002725e-02f, 4.23399284e-02f, 1.74449533e-02f, -1.58451628e-02f, 9.08707753e-02f, 1.07561246e-01f,
  1.01318769e-01f, -1.04059108e-01f, -6.01407029e-02f, -1.12680281e-02f, -9.04012918e-02f, 2.06299908e-02f, -1.04214132e-01f, 6.39098361e-02f, 5.71264476e-02f, 2.68526375e-02f,
  6.66264743e-02f, 1.86323822e-01f, 3.53209600e-02f, 1.32959550e-02f, -7.19378516e-02f, -3.55765074e-02f, -1.40161157e-01f, -1.19661838e-01f, 4.12807725e-02f, -1.12936944e-02f,
  -9.92194936e-02f, -5.69095835e-02f, -6.62143975e-02f, -1.56886131e-03f, 1.49231434e-01f, 3.70851867e-02f, 7.53478110e-02f, 1.03220353e-02f, -1.28852800e-01f, -5.03230793e-03f,
  -1.13184698e-01f, 1.31774871e-02f, -8.55369791e-02f, 3.24713364e-02f, -3.20235603e-02f, -5.67590073e-02f, 6.68566823e-02f, 9.45176780e-02f, 1.94964241e-02f, 1.37549182e-02f,
  -2.19097622e-02f, 4.13910858e-02f, 1.34317189e-01f, 5.99348880e-02f, -5.53289726e-02f, 8.25704634e-02f, 3.00559942e-02f, -1.34341747e-01f, -1.05197072e-01f, -1.31278992e-01f,
  -3.06926519e-02f, 1.51598200e-01f, -4.47793677e-02f, -3.19904946e-02f, -1.07473694e-01f, -2.73905275e-03f, -1.77378617e-02f, 8.13812837e-02f, -2.91485954e-02f, 9.38192531e-02f,
  1.01317056e-01f, -6.04899898e-02f, 6.93909600e-02f, -2.34589688e-02f, -8.76001120e-02f, 2.08884804e-03f, 3.65047492e-02f, -9.85827073e-02f, 8.17043241e-03f, -1.17154106e-01f,
  6.48638248e-01f, 9.53056365e-02f, -6.00443244e-01f, 1.79882184e-01f, -4.84304100e-01f, -6.30446851e-01f, -6.10935152e-01f, -1.78765699e-01f, 6.43416569e-02f, -2.23153606e-01f,
  -6.22907169e-02f, -3.37637663e-02f, 1.76494494e-01f, -1.71527311e-01f, -3.95970121e-02f, -2.95670092e-01f, -3.90415967e-01f, -3.22993308e-01f, -6.06000125e-01f, -5.99682927e-01f,
  -4.66107309e-01f, -3.54764730e-01f, -1.84029162e-01f, -1.23012103e-01f, -1.70355022e-01f, -1.90356761e-01f, -1.66304588e-01f, -2.91009396e-01f, -2.28995472e-01f, -1.81213960e-01f,
  -3.80387515e-01f, 1.57736346e-01f, -2.68594861e-01f, 2.88744699e-02f, -1.17114224e-01f, 1.02228150e-01f, 8.18636385e-04f, 3.61375809e-02f, 1.69549540e-01f, 6.58318400e-02f,
  1.02575138e-01f, -1.27665356e-01f, 5.85832708e-02f, 2.00667437e-02f, -1.49670050e-01f, -3.96879539e-02f, -2.51857191e-01f, -1.32145062e-01f, -5.70384040e-02f, -1.89197928e-01f,
  -1.54293686e-01f, 4.06483151e-02f, 1.85802370e-01f, 7.53588825e-02f, -1.29436366e-02f, 8.59599467e-03f, -1.74590379e-01f, -1.60104215e-01f, -3.78104262e-02f, 1.73467100e-01f,
  2.22694613e-02f, 2.19543651e-01f, -8.22464973e-02f, -1.69492051e-01f, -2.08631046e-02f, -4.46172804e-02f, 1.34587124e-01f, -7.76633695e-02f, -4.10636626e-02f, -1.51606977e-01f,
  -9.66133028e-02f, 3.69969644e-02f, -1.19826049e-01f, 1.68132305e-01f, -1.36979595e-01f, -1.55463338e-01f, 1.25370905e-01f, 3.49228531e-02f, -3.30683403e-02f, -1.90207046e-02f,
  -3.26890610e-02f, -3.75278518e-02f, 1.34633794e-01f, 3.53251696e-02f, -3.73644615e-03f, 4.70945276e-02f, 6.76403046e-02f, -3.98579240e-02f, -4.62812297e-02f, -8.39125589e-02f,
  2.34968275e-01f, -6.70469701e-02f, 2.57926345e-01f, 1.09958917e-01f, -7.16232508e-02f, -8.39528814e-02f, 2.99802311e-02f, -6.14266321e-02f, 5.15458398e-02f, 2.27664821e-02f,
  -2.67766356e-01f, 4.49579246e-02f, 7.97216743e-02f, -4.17126529e-02f, -2.60650396e-01f, -1.11533888e-01f, -1.01784237e-01f, -1.57364070e-01f, -9.24184620e-02f, -2.31705546e-01f,
  -7.61526302e-02f, 3.25725339e-02f, 2.95401931e-01f, 6.08958863e-02f, 1.09792762e-01f, 1.66975230e-01f, -1.07824512e-01f, -1.52725488e-01f, 1.78193316e-01f, 2.71771520e-01f,
  -3.01262401e-02f, 4.82197940e-01f, 5.03766537e-02f, -4.11735952e-01f, 1.01846702e-01f, 3.22044522e-01f, 6.03137732e-01f, 2.20430955e-01f, -2.59164989e-01f, 3.81239355e-02f,
  1.35182828e-01f, -3.85835916e-01f, -3.64194065e-01f, -1.54235482e-01f, 1.77569136e-01f, 2.08874032e-01f, -8.60641673e-02f, -1.14485465e-01f, -4.54423428e-02f, 1.49116516e-01f,
  4.31357361e-02f, -1.37918619e-02f, -1.09932631e-01f, -2.52689511e-01f, -3.56467247e-01f, -4.16092902e-01f, -1.75568581e-01f, -8.38966295e-02f, 1.30426601e-01f, -3.20307910e-01f,
  -1.51729196e-01f, 3.95712286e-01f, -1.19748011e-01f, -1.29813075e-01f, 1.81073368e-01f, -7.40129873e-03f, 1.27779156e-01f, -1.33898318e-01f, -3.68939596e-03f, -8.58335719e-02f,
  -9.54495147e-02f, 7.26116216e-03f, -7.16687217e-02f, -4.12535742e-02f, 5.33219986e-02f, 4.00528535e-02f, -2.68000644e-02f, -1.13533810e-03f, -2.91868090e-03f, 1.85039327e-01f,
  1.75326407e-01f, 1.54761046e-01f, 1.86821043e-01f, 2.25653991e-01f, 8.52443203e-02f, 2.45329961e-02f, 1.80854246e-01f, 4.66291532e-02f, 1.66157752e-01f, -1.53711796e-01f,
  7.47689977e-02f, -2.56570801e-02f, -1.16030015e-02f, -6.66688532e-02f, 4.43939939e-02f, -3.20282690e-02f, -1.42436326e-01f, -6.25849813e-02f, 2.08221842e-02f, 3.35377008e-02f,
  -3.50306183e-03f, 9.09386352e-02f, 2.00729929e-02f, 6.61120415e-02f, -1.73970386e-01f, 5.54341786e-02f, 6.49396181e-02f, 1.53510869e-01f, -2.80345231e-02f, 3.89354303e-02f,
  6.08767346e-02f, -2.44736467e-02f, -1.02522713e-03f, 8.41597393e-02f, 6.54399469e-02f, 5.33029363e-02f, -5.76006733e-02f, 2.99074370e-02f, 2.91467346e-02f, 1.50565535e-01f,
  -3.70404869e-01f, 4.75110024e-01f, -2.39198655e-01f, -4.83705066e-02f, -4.75058295e-02f, 6.41692281e-02f, -6.72713947e-03f, 4.36597764e-02f, -3.14519703e-02f, -7.56750628e-02f,
  6.24609888e-02f, -7.21062794e-02f, 9.07119270e-03f, -1.34468330e-02f, -1.06758453e-01f, -6.34572506e-02f, 2.14967310e-01f, -1.40991524e-01f, 6.00205921e-03f, -1.34994863e-02f,
  5.23941182e-02f, -5.15152253e-02f, -8.07087198e-02f, -1.79849759e-01f, 1.07742548e-01f, -2.01172516e-01f, -7.15768561e-02f, -7.74753243e-02f, 4.33738753e-02f, -2.96940934e-02f,
  5.32800019e-01f, 5.14887869e-01f, 4.37180012e-01f, -1.44382909e-01f, -1.70850486e-01f, -1.20329849e-01f, 6.27489164e-02f, 7.72518218e-02f, -1.24427065e-01f, 1.93710849e-01f,
  5.55001609e-02f, -4.60850388e-01f, -1.41627908e-01f, -5.12960963e-02f, 3.39575000e-02f, 1.06446281e-01f, 1.44116476e-01f, -1.28976619e-02f, -3.54318976e-01f, -4.92964685e-01f,
  -3.98363203e-01f, -7.01236799e-02f, 1.13513179e-01f, 1.10471860e-01f, 1.53431490e-01f, -2.52304614e-01f, 3.33597451e-01f, 3.19774359e-01f, 1.60331145e-01f, 1.53666243e-01f,
  1.14357695e-01f, 5.99192739e-01f, -6.07522726e-01f, -2.68677324e-01f, 1.40876755e-01f, 7.50614181e-02f, -9.50243920e-02f, 3.26449037e-01f, -2.52748616e-02f, -1.53694088e-02f,
  4.62975986e-02f, 1.84331127e-02f, 6.84760362e-02f, 6.73891082e-02f, -1.06618935e-02f, -1.86734393e-01f, 1.52906403e-01f, 9.67146456e-02f, 4.25214022e-02f, 1.22284755e-01f,
  -3.52881819e-01f, -5.54428510e-02f, 2.21761361e-01f, 4.47995216e-02f, 1.05156682e-01f, -3.27145696e-01f, 1.45697773e-01f, 1.46411415e-02f, 1.22588851e-01f, 3.31544012e-01f,
  -1.26548618e-01f, 1.74641550e-01f, 8.62780511e-02f, 2.09708601e-01f, -5.22290431e-02f, 1.60956699e-02f, -2.25083400e-02f, -7.75971562e-02f, -9.21205729e-02f, 1.32582724e-01f,
  3.68456990e-02f, -3.38483341e-02f, 1.64074436e-01f, 7.81220570e-02f, -1.93745732e-01f, 4.34962921e-02f, -8.61452743e-02f, 1.26421317e-01f, 4.78610918e-02f, 9.32195485e-02f,
  -1.86326623e-01f, -1.03113614e-01f, 1.10810958e-01f, -1.95763614e-02f, -9.38973948e-02f, -9.75801572e-02f, -5.51954396e-02f, 7.13906884e-02f, 2.14053085e-03f, -1.12901181e-02f,
  -3.22422624e-01f, -1.44853238e-02f, -2.11463511e-01f, -5.52623421e-02f, 1.95312515e-01f, 1.64146841e-01f, -1.97972991e-02f, 4.02780846e-02f, -2.36861072e-02f, -1.00576341e-01f,
  -7.35512748e-02f, 9.99705493e-03f, 2.95349866e-01f, -9.92666110e-02f, -2.80049205e-01f, -1.22775391e-01f, -9.73903611e-02f, -1.99737281e-01f, -1.81690201e-01f, -1.65108833e-02f,
  -3.70351374e-02f, -2.90319949e-01f, -4.72890615e-01f, -2.33569145e-01f, -2.33449101e-01f, -6.29255772e-01f, -1.10423356e-01f, -2.70417750e-01f, -1.54555708e-01f, -1.09474674e-01f,
  -4.02265489e-01f, -5.84792018e-01f, 2.08143488e-01f, 2.43627027e-01f, 3.26643258e-01f, 4.35601294e-01f, 4.54717547e-01f, 1.64704263e-01f, 1.61774606e-01f, 7.03114644e-02f,
  -4.97498542e-01f, -4.79152888e-01f, -3.97521377e-01f, -3.24586540e-01f, -1.30605668e-01f, 3.66980255e-01f, 5.22866368e-01f, 2.65250236e-01f, 7.98220783e-02f, 8.18504989e-02f,
  3.40993442e-02f, -3.19229141e-02f, -1.38454497e-01f, 1.91431155e-03f, 5.27756475e-02f, 1.98857281e-02f, 7.72384554e-02f, 3.53921913e-02f, -1.04142375e-01f, 6.41509071e-02f,
  -4.41439033e-01f, -4.10465509e-01f, 1.42546907e-01f, -2.20971510e-01f, -1.50555983e-01f, -7.25191161e-02f, 6.01709038e-02f, -8.28222632e-02f, -6.97738230e-02f, -6.33384287e-02f,
  -1.33784547e-01f, -1.32945716e-01f, -1.19823582e-01f, -7.88690820e-02f, 8.69039744e-02f, 1.81798004e-02f, -1.15325287e-01f, -8.86251703e-02f, -1.54741138e-01f, -1.74713448e-01f,
  -1.50519565e-01f, -1.55113144e-02f, 3.95361893e-02f, 4.49199900e-02f, -2.83304881e-03f, -1.78417712e-02f, -1.76950723e-01f, -3.23879085e-02f, 1.04214400e-02f, -5.92632107e-02f,
  3.90734076e-02f, -3.23919728e-02f, -6.86384514e-02f, 3.01180780e-02f, 6.14165887e-03f, 6.59873262e-02f, 1.07049480e-01f, -2.25287572e-01f, 3.31304334e-02f, -2.67388746e-02f,
  -2.19200682e-02f, -8.67395401e-02f, -6.60312548e-02f, -1.01919971e-01f, -3.90477441e-02f, 2.32656859e-02f, 4.03093658e-02f, -2.06993014e-01f, -1.04460783e-01f, 4.44025546e-03f,
  4.20498289e-02f, 2.50004642e-02f, -1.08491115e-01f, 2.74520200e-02f, 2.27785055e-02f, -3.06237172e-02f, -2.25798730e-02f, -2.99947187e-02f, 1.88692342e-02f, 8.88991430e-02f,
  -1.59261197e-01f, -1.07072823e-01f, 8.03288072e-02f, -2.74238233e-02f, 5.39245605e-02f, -2.09875390e-01f, -1.61506027e-01f, -6.49893880e-02f, -7.22593293e-02f, 8.66476819e-03f,
  -1.61405191e-01f, -6.81484267e-02f, -1.45163521e-01f, 5.25114909e-02f, 2.06506461e-01f, 1.26407743e-01f, -9.07674730e-02f, 9.92990583e-02f, -5.79903759e-02f, 2.98902132e-02f,
  8.19020495e-02f, 2.09234804e-01f, 2.63292253e-01f, 3.05509139e-02f, 2.75206640e-02f, 1.71041802e-01f, 3.34199257e-02f, 1.64955288e-01f, 1.21898964e-01f, 3.14528316e-01f,
  2.16597676e-01f, 3.20776612e-01f, -6.01513684e-01f, 3.17721069e-01f, -1.04635358e-01f, -3.49324048e-01f, -5.95796853e-02f, 3.20881754e-02f, 3.18658292e-01f, 2.66134322e-01f,
  -2.15801653e-02f, -3.08917999e-01f, -3.76412094e-01f, -4.07707840e-01f, -6.17405713e-01f, -2.03668669e-01f, -2.75791407e-01f, -6.30357027e-01f, -5.74036419e-01f, -1.66600168e-01f,
  -4.91532125e-02f, -9.80639011e-02f, -1.64571106e-01f, -8.69833529e-02f, 2.29311123e-01f, -1.29136011e-01f, -5.28586246e-02f, -4.04401496e-02f, -2.77138978e-01f, 2.64044814e-02f,
  -2.60968179e-01f, -9.54233669e-03f, -2.13815719e-01f, -3.19135599e-02f, 1.35069072e-01f, 1.28079578e-01f, -1.98037643e-03f, 1.86131839e-02f, 1.55865267e-01f, 6.61526918e-02f,
  1.02995988e-02f, 1.65063053e-01f, -2.57142652e-02f, -1.27308875e-01f, -6.35133237e-02f, -1.45989731e-01f, -8.16105977e-02f, -1.83432087e-01f, -1.84292179e-02f, 8.99660364e-02f,
  1.53447196e-01f, -1.69151515e-01f, -3.16877335e-01f, -1.08003104e-02f, -8.59174505e-02f, -1.81760490e-01f, -1.17418896e-02f, 8.69130045e-02f, -2.78047889e-01f, 3.42019856e-01f,
  1.86967731e-01f, 1.82157770e-01f, -2.01126002e-02f, 8.99702013e-02f, 7.77365863e-02f, 9.83673632e-02f, 2.20226217e-02f, 2.82277633e-02f, -1.01936556e-01f, 4.33394238e-02f,
  2.83162706e-02f, 1.40004560e-01f, 2.60824580e-02f, 1.64960220e-03f, -5.83057255e-02f, 4.02695220e-03f, 6.02050237e-02f, 1.31106764e-01f, -2.61545070e-02f, -4.46062535e-02f,
  -6.70424998e-02f, -8.47954825e-02f, 3.28888036e-02f, 1.57076865e-02f, -4.43019383e-02f, 5.68776056e-02f, 8.67345631e-02f, 2.66099758e-02f, -1.72659531e-02f, -3.18716951e-02f,
  9.65125486e-02f, -3.57994467e-01f, 1.34730160e-01f, -1.67724401e-01f, 8.97026435e-03f, 9.27685201e-02f, 1.20371774e-01f, 6.22903183e-02f, 8.57620165e-02f, 7.36912191e-02f,
  -5.06228842e-02f, 1.60821006e-01f, -5.40254964e-03f, -8.06915611e-02f, -1.60323218e-01f, -1.78923272e-02f, 1.51304379e-01f, -3.15837376e-02f, -2.31511816e-02f, 2.09747955e-01f,
  1.34450078e-01f, -5.87669499e-02f, -1.81991175e-01f, -1.26165435e-01f, 1.19563140e-01f, -2.28625581e-01f, -2.36471146e-01f, -1.10919565e-01f, -3.89230460e-01f, 2.39633128e-01f,
  -3.84571165e-01f, -4.48701084e-01f, -7.39257216e-01f, 4.29900765e-01f, 4.73289371e-01f, -3.00011300e-02f, -3.66400212e-01f, -3.42906654e-01f, 2.92867392e-01f, -1.20778099e-01f,
  1.64186642e-01f, 4.47549969e-01f, 3.41551691e-01f, 1.44661695e-01f, -3.22543979e-01f, -2.92180002e-01f, 9.94589459e-03f, 5.39650628e-03f, 9.00256485e-02f, 1.80862784e-01f,
  4.90231067e-01f, 2.59730846e-01f, -3.50510217e-02f, 2.33084112e-02f, 3.54223907e-01f, 3.81753027e-01f, 4.54665534e-03f, 2.23377839e-01f, -1.12993363e-02f, 1.80793494e-01f,
  -3.30238283e-01f, -4.29744631e-01f, 6.76654726e-02f, 3.73982221e-01f, 1.80713385e-01f, -2.22349688e-01f, -2.64964461e-01f, -1.95136666e-01f, -3.06916963e-02f, -1.63986549e-01f,
  1.06182128e-01f, -1.16331905e-01f, 1.47547290e-01f, -9.74610634e-03f, -1.72934487e-01f, -3.56757611e-01f, -2.02954382e-01f, -3.78737956e-01f, -3.74380291e-01f, -3.56920213e-01f,
  5.36494255e-01f, 3.31806481e-01f, -4.19890106e-01f, -3.17432344e-01f, -4.16081220e-01f, 4.22552153e-02f, -3.83778036e-01f, -2.73717433e-01f, -7.11143792e-01f, -4.81416196e-01f,
  5.32166427e-03f, -4.30930406e-02f, -5.17823622e-02f, -1.20729186e-01f, 1.25780031e-01f, 3.62774730e-02f, 1.14070646e-01f, 2.24675953e-01f, -1.50715634e-02f, -1.24225996e-01f,
  5.54368347e-02f, -1.03076562e-01f, 2.65588122e-03f, -4.91887257e-02f, 9.19666514e-02f, -1.48963720e-01f, -1.37789678e-02f, -1.52040139e-01f, -7.44395852e-02f, -5.60568133e-03f,
  -1.43618956e-01f, -8.05694163e-02f, -9.27534141e-03f, 6.21615686e-02f, -9.63181332e-02f, -1.98153853e-01f, -7.53067061e-02f, 1.10686392e-01f, 7.43103847e-02f, -1.54484689e-01f,
  1.33500844e-01f, -2.34359086e-01f, -1.33964032e-01f, -1.68945268e-01f, 2.39355396e-02f, 1.35149479e-01f, 5.31576201e-02f, -1.00511678e-01f, 5.87868690e-02f, -9.31752622e-02f,
  -2.59298325e-01f, -2.15419874e-01f, -7.43538886e-02f, -5.16415164e-02f, -5.15476689e-02f, -2.21228469e-02f, 6.88429968e-03f, 1.74652413e-01f, -2.26892326e-02f, 1.20216375e-02f,
  1.19909279e-01f, -7.82358721e-02f, -8.45056176e-02f, -1.21478543e-01f, -1.14177510e-01f, 7.11561367e-02f, -2.09922478e-01f, -1.98837981e-01f, -4.30136293e-01f, -4.73110855e-01f,
  6.93395317e-01f, -3.83279175e-01f, -5.94068110e-01f, 3.44187021e-02f, -4.55179751e-01f, -4.45689738e-01f, -4.71442491e-01f, -1.15384776e-02f, -5.15762120e-02f, -4.27617490e-01f,
  -2.41848156e-01f, 1.47263944e-01f, -1.27028927e-01f, -8.19339454e-02f, 1.36928231e-01f, -4.53207254e-01f, -4.18369949e-01f, -2.58680689e-03f, 2.38097772e-01f, 1.50064901e-01f,
  8.67071003e-02f, 2.52142102e-01f, 2.82145262e-01f, 8.09849501e-02f, -3.00454915e-01f, -3.68330255e-02f, -5.33209324e-01f, -2.78169155e-01f, -2.53755957e-01f, -3.52843195e-01f,
  -4.41374034e-01f, -4.34061825e-01f, -1.75931394e-01f, 2.45860666e-01f, -1.58982947e-01f, 1.24521680e-01f, 4.83071357e-02f, -4.21279781e-02f, 4.20717634e-02f, -2.00445965e-01f,
  -3.53765152e-02f, 1.11930966e-01f, -3.95111041e-03f, -1.84797347e-01f, 1.34381289e-02f, 1.01432391e-01f, 6.11131676e-02f, -1.06000323e-02f, -1.60666496e-01f, -2.28652060e-01f,
  -1.36625960e-01f, -2.50481684e-02f, -1.57534122e-01f, -8.40506777e-02f, -1.50822386e-01f, 1.33417115e-01f, -3.33658993e-01f, -1.36015847e-01f, -9.29701775e-02f, -1.59982100e-01f,
  -4.03370261e-02f, -1.27842948e-01f, -3.19115445e-02f, 5.71953952e-02f, 8.87999013e-02f, -7.73748755e-02f, -1.15978345e-01f, -1.06899533e-02f, -9.73652825e-02f, -4.29988094e-02f,
  1.13653746e-02f, -6.90212175e-02f, 6.70565106e-03f, -1.08451918e-01f, 6.96315151e-03f, -8.86564255e-02f, -5.62792197e-02f, 3.85412457e-03f, 6.70769960e-02f, 1.12222843e-01f,
  -2.35095364e-03f, -9.84973013e-02f, -3.62031236e-02f, 1.63617209e-01f, -1.24328762e-01f, -4.43056896e-02f, -6.92294464e-02f, -3.52469529e-03f, 4.05168347e-03f, -1.33358046e-01f,
  2.86165401e-02f, 3.18691060e-02f, -9.92763638e-02f, 5.76013587e-02f, -5.89279691e-03f, -1.55472700e-02f, -1.97327271e-01f, 3.61081325e-02f, 3.33401151e-02f, -2.38860026e-02f,
  -1.21609382e-01f, 1.29904643e-01f, -1.35329545e-01f, -9.41165090e-02f, 6.16829060e-02f, 5.76506481e-02f, 2.28008553e-01f, -3.88353355e-02f, -5.84965944e-02f, 8.68081208e-03f,
  -6.97046984e-03f, 1.90483332e-01f, 2.68696070e-01f, 4.93158847e-02f, -8.29275791e-03f, 2.21003443e-01f, -8.45676288e-02f, -1.50977373e-01f, 1.25995055e-01f, 1.94148019e-01f,
  -6.10753417e-01f, 2.25084230e-01f, -5.36583006e-01f, -2.58051217e-01f, 2.14565128e-01f, 2.61796623e-01f, 4.09440875e-01f, 9.58511159e-02f, -2.92102080e-02f, 1.99417025e-01f,
  1.13458872e-01f, 3.49639505e-02f, -2.15544496e-02f, 1.97367400e-01f, 1.96042910e-01f, 3.48683119e-01f, 2.04567522e-01f, -2.05718055e-01f, -2.81824887e-01f, -2.67967060e-02f,
  3.00286442e-01f, -2.45080322e-01f, -4.18219984e-01f, -1.59853250e-01f, -9.54856202e-02f, -2.03162357e-02f, -7.25971684e-02f, -5.68812005e-02f, 1.92383498e-01f, 1.02672242e-01f,
  -2.27925315e-01f, -2.72686064e-01f, -2.06938654e-01f, -2.34054595e-01f, -3.01203519e-01f, -1.62632748e-01f, -7.77387023e-02f, -1.85802028e-01f, 4.80648763e-02f, -1.84335887e-01f,
  -2.16612831e-01f, -1.93579998e-02f, -6.93521276e-03f, -6.29269257e-02f, -1.79176137e-01f, -6.92808852e-02f, -2.13046744e-01f, -1.99709669e-01f, -5.73914684e-02f, -1.59605518e-01f,
  5.81277549e-01f, 7.90198818e-02f, -2.23944813e-01f, 1.74822554e-01f, 1.46179572e-01f, -1.86897814e-01f, -1.31433308e-01f, -8.83625299e-02f, -9.23306867e-02f, -2.10734949e-01f,
  1.01251654e-01f, 1.42986523e-02f, 5.05678803e-02f, -2.19581015e-02f, 8.88686180e-02f, 2.93192118e-02f, 4.72324863e-02f, 2.66332000e-01f, 7.70557597e-02f, -3.17707448e-03f,
  7.71382544e-03f, -6.21056650e-03f, -1.00404173e-01f, 3.71749140e-02f, -8.69201869e-02f, -3.03451065e-02f, 1.23909198e-01f, 5.15893102e-02f, 1.26149371e-01f, 2.33224239e-02f,
  -3.33086029e-02f, -2.80530117e-02f, -1.33489132e-01f, 1.13951184e-01f, 2.20485836e-01f, 1.00224271e-01f, 1.59995556e-02f, -1.09827325e-01f, -1.85067192e-01f, 5.94613813e-02f,
  -1.99770123e-01f, 5.73345535e-02f, -3.03182244e-01f, 2.57154144e-02f, 1.51571417e-02f, -7.68267363e-03f, 3.24834809e-02f, 1.21563978e-01f, -1.76662896e-02f, -1.60769418e-01f,
  -5.73651455e-02f, -5.55392802e-02f, 1.17566518e-01f, 1.12912178e-01f, -1.50305480e-01f, -1.57182906e-02f, 2.07078755e-01f, 1.05665512e-01f, 2.15082705e-01f, -6.31962121e-02f,
  2.20578656e-01f, 5.18063121e-02f, -1.19510762e-01f, -7.69299194e-02f, 1.81947425e-01f, -8.54626149e-02f, -2.94347614e-01f, -2.30491623e-01f, -9.77606252e-02f, -7.92772546e-02f,
  -6.64841294e-01f, 5.95570922e-01f, 5.67048132e-01f, -6.51870891e-02f, 3.41484219e-01f, 4.15654719e-01f, 4.23936039e-01f, 2.13282898e-01f, 1.23231567e-01f, 9.15966481e-02f,
  8.43362287e-02f, -1.83289647e-01f, 6.49688169e-02f, -6.46559075e-02f, -1.72381759e-01f, 2.87100792e-01f, 2.71091700e-01f, -3.76850247e-01f, -5.28079152e-01f, -5.37883878e-01f,
  -2.29744762e-01f, -3.83361071e-01f, -5.38316607e-01f, -3.23310912e-01f, 1.38243318e-01f, -4.96957190e-02f, 1.56678200e-01f, 2.95890551e-02f, 8.34844410e-02f, -4.75443825e-02f,
  -2.89268434e-01f, 3.02846223e-01f, -2.05007210e-01f, -2.27818713e-01f, 5.85819781e-03f, -2.09247425e-01f, 4.65254709e-02f, -9.65389162e-02f, 1.62067171e-02f, -2.09646281e-02f,
  5.51496372e-02f, -9.09110811e-03f, 1.10076718e-01f, -1.13428561e-02f, -1.03766948e-01f, -1.21276304e-01f, -1.50037706e-02f, -1.98113859e-01f, -1.41828328e-01f, 7.52993748e-02f,
  5.76965604e-03f, -1.80334181e-01f, 9.55251697e-03f, 2.09565967e-01f, 8.08381066e-02f, -3.28785449e-01f, 8.84528682e-02f, -4.00187761e-01f, -2.97738373e-01f, -3.68592143e-01f,
  -1.97439164e-01f, -7.34168291e-02f, -4.44668159e-02f, 2.55034901e-02f, -9.45446193e-02f, 1.15908019e-01f, 1.24349706e-01f, -3.09817269e-02f, -7.63882473e-02f, -1.57245129e-01f,
  1.15072072e-01f, 9.35277995e-03f, 9.88250598e-02f, 1.92455724e-01f, -1.40315548e-01f, -9.28155705e-02f, 2.01873062e-03f, -7.05826748e-03f, -5.37540130e-02f, -3.09917554e-02f,
  -6.71494454e-02f, 1.01994589e-01f, 8.19442198e-02f, -3.61552276e-02f, 1.73761308e-01f, 5.49722761e-02f, -1.53615981e-01f, -7.75711089e-02f, -7.24913701e-02f, 1.31342068e-01f,
  -2.62947232e-01f, -1.07941791e-01f, -9.39245969e-02f, -7.61367902e-02f, 4.29079682e-02f, -3.35550532e-02f, -3.11383214e-02f, -9.05216858e-02f, 1.76281884e-01f, -7.74160214e-03f,
  3.65539230e-02f, -7.35996887e-02f, 2.14013502e-01f, -1.03978641e-01f, -2.81647950e-01f, 1.71406772e-02f, -2.74657100e-01f, -9.64969024e-02f, -1.08611248e-01f, -1.03048883e-01f,
  3.53716612e-02f, -4.64245379e-01f, -4.67367887e-01f, -4.03234996e-02f, -2.42249653e-01f, -3.97506863e-01f, -2.42131040e-01f, -4.62357283e-01f, -3.02632779e-01f, -5.15793622e-01f,
  -2.28500575e-01f, -3.03171486e-01f, 2.01615170e-01f, 3.04510236e-01f, 1.02003947e-01f, -1.10267192e-01f, -2.79843420e-01f, -1.46674782e-01f, -5.53022474e-02f, -5.87486662e-02f,
  -2.15581611e-01f, -1.85900629e-02f, 2.59673297e-02f, -3.86354700e-02f, -5.88878356e-02f, 1.11360677e-01f, 1.44547835e-01f, 1.15759447e-01f, 3.98534462e-02f, -6.13541193e-02f,
  4.41479832e-02f, 1.48471087e-01f, 4.34917994e-02f, -3.69395688e-02f, 1.70648433e-02f, 8.52075294e-02f, 1.07991472e-02f, 3.92051376e-02f, -2.91195530e-02f, 1.86078206e-01f,
  1.42686129e-01f, -2.00498894e-01f, 1.87524818e-02f, -1.83692008e-01f, -1.31382897e-01f, -2.09212244e-01f, -3.21639120e-03f, -9.57477372e-03f, -9.45256427e-02f, 9.38132405e-03f,
  -7.55815506e-02f, -7.29343891e-02f, -1.57483101e-01f, -1.46920949e-01f, -1.54975668e-01f, -1.75544247e-01f, -7.61914402e-02f, -9.81360301e-02f, -2.00319648e-01f, -8.58254805e-02f,
  -4.18368541e-02f, -1.53743088e-01f, -2.06442967e-01f, -1.27785414e-01f, -2.31835067e-01f, -3.23692337e-03f, -1.67242378e-01f, -1.75476030e-01f, -5.17032892e-02f, -1.21651903e-01f,
  -1.47527367e-01f, -2.19598010e-01f, -2.85176963e-01f, -1.32758901e-01f, -1.02163898e-02f, -6.36894926e-02f, -4.60020676e-02f, -6.18097819e-02f, -9.93511528e-02f, -7.00524524e-02f,
  -4.42534983e-02f, 2.93497685e-02f, -2.09052563e-02f, 9.53460708e-02f, -1.10037833e-01f, -1.72978103e-01f, -2.06861511e-01f, -1.12936467e-01f, -1.98306799e-01f, -2.04729214e-01f,
  -9.42336023e-02f, -1.78056002e-01f, -7.83725679e-02f, -2.05095097e-01f, -1.23762257e-01f, -9.43055674e-02f, -7.31458664e-02f, -2.13733852e-01f, -7.59142684e-03f, -3.63009013e-02f,
  4.28527631e-02f, -3.69196478e-03f, 2.16762021e-01f, -7.97353983e-02f, 8.21428746e-02f, -6.33303970e-02f, 1.77054014e-02f, 3.05171777e-02f, 6.32604063e-02f, 2.61442270e-03f,
  -8.49812105e-02f, -2.09481195e-02f, 2.41721608e-02f, 9.16794091e-02f, 1.22926064e-01f, 1.59797028e-01f, -4.59572747e-02f, 8.91147628e-02f, 3.19981202e-02f, -1.09899372e-01f,
  4.45794761e-02f, 1.29647851e-01f, 1.82262555e-01f, 2.44433865e-01f, 9.86059755e-02f, 1.93149954e-01f, 2.24962056e-01f, 2.61086728e-02f, 1.35080740e-01f, 2.40881115e-01f,
  1.46397073e-02f, 1.34923637e-01f, -2.10922927e-01f, 2.27410689e-01f, 2.13067189e-01f, -2.16460213e-01f, -4.38827872e-01f, -4.41971689e-01f, 9.15059149e-02f, 1.34038225e-01f,
  2.01654881e-01f, 2.41852109e-03f, -9.60923508e-02f, -3.02405596e-01f, -6.99091375e-01f, -5.37146866e-01f, -3.49633306e-01f, -5.88949621e-01f, -7.13536024e-01f, -3.69580299e-01f,
  5.83975539e-02f, -1.36510894e-01f, -3.84585738e-01f, -2.11312294e-01f, 4.71392035e-01f, 8.12203363e-02f, 1.41955376e-01f, 1.03222482e-01f, 8.27604234e-02f, 4.36095476e-01f,
  6.29978999e-02f, 3.33018489e-02f, -1.94751456e-01f, -8.37400258e-02f, 6.84353411e-02f, 8.59842077e-02f, -5.89398779e-02f, -1.03322402e-01f, 7.63980746e-02f, -1.53488696e-01f,
  1.32788762e-01f, -6.13150559e-02f, -2.33954266e-02f, 3.27852257e-02f, -2.19821662e-01f, -1.94060400e-01f, -2.09655315e-01f, -4.41910774e-01f, -2.09863201e-01f, 5.67940855e-03f,
  1.98228255e-01f, 1.27130300e-01f, -3.58675659e-01f, -2.41704032e-01f, -3.12127024e-01f, -3.51849273e-02f, -1.41779795e-01f, 5.13456799e-02f, -2.29615033e-01f, 5.35687432e-02f,
  -7.30993506e-03f, -1.03715464e-01f, 2.71944609e-02f, 1.66458283e-02f, -8.39280635e-02f, 1.70870289e-01f, -4.34272029e-02f, -1.11424461e-01f, -1.46472231e-02f, 3.91197838e-02f,
  1.15864761e-02f, 6.79055601e-02f, -1.09412245e-01f, -3.22772376e-02f, -7.10082129e-02f, -2.42527556e-02f, 1.23010641e-02f, -1.56717032e-01f, -1.79378614e-01f, 3.16841714e-02f,
  1.12754637e-02f, -4.61736098e-02f, 1.50332093e-01f, -1.56539172e-01f, -5.69362659e-03f, 8.45794659e-03f, 7.25811794e-02f, -6.33227527e-02f, -1.19184159e-01f, 1.33697316e-01f,
  9.89407673e-02f, -1.45692289e-01f, 2.19506696e-01f, -2.40960956e-01f, -1.08257167e-01f, 2.48892322e-01f, 1.76330000e-01f, -1.50761530e-02f, 1.27835140e-01f, -8.90350491e-02f,
  -1.51071176e-01f, -5.69464453e-02f, -2.76298486e-02f, -2.56864750e-03f, -1.43520877e-01f, -3.92122939e-02f, -8.25744271e-02f, 4.22559902e-02f, -1.52211264e-01f, 2.44381860e-01f,
  -9.20744017e-02f, -3.35516930e-01f, -3.41089100e-01f, -1.02244571e-01f, -2.39992008e-01f, -3.14392239e-01f, -1.39431924e-01f, -6.83745891e-02f, -3.88374239e-01f, -1.31988615e-01f,
  4.21833813e-01f, 2.04060495e-01f, 1.10426702e-01f, 6.37065917e-02f, 5.00622503e-02f, 6.52535111e-02f, 2.42109552e-01f, 1.65907666e-01f, 6.67120144e-02f, 1.85465738e-01f,
  2.50794381e-01f, 8.91084522e-02f, 7.28366897e-02f, 5.85435331e-02f, 1.26051694e-01f, 2.06387267e-02f, -2.02615201e-01f, 2.86103860e-02f, 1.23970769e-01f, 5.01880534e-02f,
  1.19276389e-01f, 1.57344609e-01f, 2.92201489e-01f, -4.74271849e-02f, -4.61458452e-02f, -6.24856837e-02f, -1.55207869e-02f, 6.29124343e-02f, 5.30694053e-02f, -2.14501172e-01f,
  3.38772953e-01f, 2.61736274e-01f, -5.02859801e-02f, -7.13777319e-02f, -1.07864134e-01f, -5.71901202e-02f, -2.93812118e-02f, -4.82767075e-02f, -4.84167226e-02f, -5.70287406e-02f,
  -1.13350414e-01f, 4.55561616e-02f, 9.75924879e-02f, 9.94687304e-02f, 4.20377124e-03f, 1.30366934e-02f, -1.03953891e-02f, -1.38545156e-01f, -1.92202851e-02f, -1.14321364e-02f,
  -3.38064879e-02f, -1.06799364e-01f, 6.73216283e-02f, 5.51948361e-02f, -1.11221634e-01f, -3.74622792e-02f, -5.51886484e-02f, 2.49719713e-02f, -5.79191633e-02f, -1.02228120e-01f,
  -9.51649398e-02f, -1.03365742e-01f, -2.63717100e-02f, -1.29806295e-01f, 9.14943125e-03f, -7.94268474e-02f, -6.14837930e-02f, -3.74682397e-02f, -6.01878576e-02f, -4.83957715e-02f,
  6.15508258e-02f, 1.56446010e-01f, 7.18429983e-02f, 1.18240654e-01f, 1.88797042e-02f, 1.15395943e-02f, 4.42020856e-02f, 4.91228662e-02f, 9.57937073e-03f, 1.29017457e-01f,
  1.00009395e-02f, 1.23031316e-02f, 1.53745124e-02f, -4.35274765e-02f, -5.30780181e-02f, -8.22385103e-02f, -7.86578655e-03f, 6.82024285e-02f, 1.48585021e-01f, -1.10420911e-02f,
  2.91428089e-01f, 2.42385507e-01f, -1.28810599e-01f, -9.70690399e-02f, -2.54925881e-02f, -4.60784547e-02f, 4.87287566e-02f, -1.06058307e-01f, -5.85324876e-02f, -2.21676603e-02f,
  -9.04963091e-02f, 1.97398942e-02f, 1.27946824e-01f, -7.49030290e-03f, -1.08052135e-01f, 1.37962531e-02f, -1.68461934e-01f, -7.95621574e-02f, -1.67262226e-01f, -1.71537355e-01f,
  -1.38404280e-01f, -1.07720070e-01f, 3.28269117e-02f, -1.50969237e-01f, -1.29569978e-01f, -1.53639644e-01f, -1.14401780e-01f, -4.69283126e-02f, 6.22330382e-02f, -8.48672017e-02f,
  5.27302861e-01f, -4.41221744e-01f, -6.33174360e-01f, 2.74183661e-01f, -1.25385314e-01f, -4.30538766e-02f, -7.89079592e-02f, 4.23065484e-01f, 3.17840010e-01f, -1.55854315e-01f,
  -3.31853241e-01f, -2.47285053e-01f, -4.96031642e-01f, -1.96355000e-01f, -1.33889705e-01f, -3.44437897e-01f, -3.08334291e-01f, -1.27075866e-01f, 2.28749216e-01f, 2.31056452e-01f,
  2.04395041e-01f, 2.88696408e-01f, 2.30144203e-01f, 1.64113462e-01f, -8.32675323e-02f, -6.07382506e-02f, -2.34715939e-01f, -2.06296593e-01f, -3.10481280e-01f, -4.10497278e-01f,
  -3.36618423e-01f, -1.41895413e-01f, 2.55952217e-02f, 7.19095990e-02f, -9.84362662e-02f, 5.99042065e-02f, -4.29697223e-02f, -2.20158864e-02f, 2.32477020e-03f, -2.38187060e-01f,
  -2.47087121e-01f, -6.96349069e-02f, -6.68851063e-02f, -1.98203668e-01f, 1.11110359e-01f, 2.80188061e-02f, 1.57284409e-01f, -1.15960941e-01f, -1.39013484e-01f, -1.70003980e-01f,
  -2.28765368e-01f, -2.84132063e-01f, -2.31476113e-01f, -2.57524122e-02f, -2.62756012e-02f, -1.15761265e-01f, -2.05117986e-01f, -1.21070221e-02f, -9.04816836e-02f, 1.03586711e-01f,
  9.66453808e-04f, -6.88379034e-02f, 1.42924771e-01f, 1.81151330e-01f, 1.22193724e-01f, 3.19869667e-02f, -4.06414410e-03f, -9.85580534e-02f, -2.07120422e-02f, -2.37876200e-03f,
  -5.43349609e-02f, -3.80807109e-02f, 5.74776717e-03f, 3.75561113e-03f, -9.92270559e-02f, -1.47264615e-01f, -1.47776119e-03f, 2.31484957e-02f, -1.05888821e-01f, -4.51703519e-02f,
  2.12865286e-02f, -6.42915666e-02f, 6.64357990e-02f, -4.66175191e-02f, -6.42612427e-02f, -2.87988614e-02f, -9.95532423e-02f, -5.63131012e-02f, -2.77265515e-02f, 4.91444357e-02f,
  3.45357835e-01f, -7.40585551e-02f, 1.46137718e-02f, 4.52497825e-02f, -8.00490659e-03f, 1.01035662e-01f, 4.65701409e-02f, 1.58947423e-01f, -2.03627348e-01f, -1.46295935e-01f,
  -1.51046678e-01f, -4.15772907e-02f, -1.95417970e-01f, -1.01844482e-01f, 1.73767537e-01f, -4.47697304e-02f, 1.27256930e-01f, -8.14437717e-02f, 4.87176701e-02f, 9.89999846e-02f,
  -1.40037574e-02f, 2.06034377e-01f, 2.86580533e-01f, 9.86589119e-02f, 1.29646420e-01f, 1.15589924e-01f, 1.87585894e-02f, 3.74550298e-02f, 9.31771621e-02f, 3.62900406e-01f,
  -6.48240805e-01f, -2.52017021e-01f, 9.74203199e-02f, -4.43961710e-01f, 3.02763041e-02f, -1.72835156e-01f, -4.84882563e-01f, -2.70919204e-01f, -4.18712310e-02f, -1.95098191e-01f,
  1.30914599e-01f, 1.83880538e-01f, -1.22276023e-01f, -1.35997772e-01f, -6.03190780e-01f, -5.68609834e-01f, -4.53371704e-01f, -2.27744296e-01f, -5.44051789e-02f, 6.55713081e-02f,
  1.27324298e-01f, -6.72760382e-02f, -2.00027376e-01f, 2.63871718e-02f, 4.16389890e-02f, 5.07886149e-02f, 2.01504081e-02f, 4.19199746e-03f, -1.29752666e-01f, -1.44137368e-01f,
  6.48049414e-02f, -1.15267992e-01f, 3.71690243e-01f, 3.46165486e-02f, 2.96573162e-01f, 5.18541671e-02f, -3.69865942e-04f, 9.33864415e-02f, -1.28504157e-01f, -3.84522378e-02f,
  9.90155637e-02f, 1.24728568e-01f, -1.01569302e-01f, 1.61422729e-01f, -7.89694414e-02f, -6.33542910e-02f, -1.19707718e-01f, -1.26157030e-01f, -5.08178100e-02f, 1.35834485e-01f,
  -7.15998411e-02f, -2.08698347e-01f, -4.33397204e-01f, -1.15960248e-01f, 7.15755671e-02f, 2.56956182e-03f, 2.14312285e-01f, 2.88936824e-01f, -1.73369914e-01f, -3.56158763e-01f,
  4.66540866e-02f, -1.12670623e-02f, 1.04163237e-01f, -3.46808955e-02f, -5.95062179e-03f, 6.82221502e-02f, -8.72062594e-02f, 6.28243806e-03f, 1.09969229e-01f, -4.71412539e-02f,
  -9.87519249e-02f, 1.51383439e-02f, -2.84408145e-02f, -9.76441577e-02f, -1.50183320e-01f, -1.35786653e-01f, -1.51251882e-01f, -9.52334851e-02f, -6.21014014e-02f, 6.88288286e-02f,
  6.72071651e-02f, -4.85709682e-02f, 1.03027627e-01f, 3.15736681e-02f, 8.10590852e-03f, 7.58025125e-02f, 2.46174619e-01f, 1.70275822e-01f, 1.93848133e-01f, 4.90717255e-02f,
  -5.23861609e-02f, 1.92183599e-01f, -3.69777828e-01f, 3.85615751e-02f, -1.64451718e-01f, 3.48753363e-01f, 5.73825836e-02f, -4.33953106e-03f, 2.37496924e-02f, 1.04251921e-01f,
  9.83473659e-02f, -1.47058606e-01f, -7.53661394e-02f, 2.09119037e-01f, 7.86595643e-02f, -8.77873134e-03f, -2.50215948e-01f, -1.18522933e-02f, -2.15942785e-01f, 1.43898040e-01f,
  -3.15505028e-01f, -5.64190507e-01f, -7.17988968e-01f, -4.68727440e-01f, -7.69846588e-02f, -4.81668502e-01f, -2.50834227e-01f, -2.86259260e-02f, -5.04602492e-01f, -7.09368587e-01f,
  2.02627212e-01f, -1.55493677e-01f, 1.50613457e-01f, 3.34183544e-01f, 2.54043669e-01f, 1.78053916e-01f, 6.49838448e-02f, 1.50411665e-01f, 3.10860842e-01f, 2.47638345e-01f,
  2.22768322e-01f, 1.36740446e-01f, 1.10482365e-01f, 1.64361387e-01f, 1.05214134e-01f, 1.05739478e-02f, 9.57331061e-02f, 5.99390864e-02f, 7.69065320e-02f, 1.28358424e-01f,
  -8.23523384e-04f, -5.76094314e-02f, -2.31950004e-02f, 1.72703546e-02f, 8.76451805e-02f, 1.16889246e-01f, 7.44277313e-02f, -8.18773583e-02f, 4.59212326e-02f, -2.28895620e-02f,
  -1.85456291e-01f, -1.47504479e-01f, 8.98818225e-02f, -6.33467138e-02f, -8.45361874e-02f, 5.66236768e-03f, 3.84543091e-02f, -7.07855672e-02f, -1.75550163e-01f, -9.98252705e-02f,
  -5.67169674e-02f, -5.91221228e-02f, -3.12717482e-02f, -1.08251430e-01f, -1.85542002e-01f, -1.00641094e-01f, 6.76886784e-03f, -5.23015559e-02f, -6.01028875e-02f, 4.26588878e-02f,
  4.14377861e-02f, 2.01236568e-02f, 7.93353915e-02f, 3.45919542e-02f, -2.60379398e-03f, 5.47027700e-02f, -9.04343501e-02f, -9.47393551e-02f, 4.88936603e-02f, -1.33008137e-02f,
  1.76314518e-01f, 8.60699788e-02f, 7.73631856e-02f, 2.13890169e-02f, 7.09803402e-02f, 6.32830486e-02f, -9.07555148e-02f, -4.99892458e-02f, 6.49214014e-02f, 1.05480857e-01f,
  7.69367162e-03f, -4.47448194e-02f, 3.36641818e-02f, 9.45717916e-02f, 1.38228104e-01f, -4.12073545e-02f, 2.37597320e-02f, -4.27054949e-02f, -1.79113895e-02f, 4.60019596e-02f,
  -4.23903950e-03f, -6.05548881e-02f, -8.78897384e-02f, -1.96622480e-02f, 5.68321645e-02f, -6.73235301e-03f, 3.37894298e-02f, -4.09511011e-03f, 6.48595095e-02f, 6.98394608e-03f,
  5.30337133e-02f, 1.42622024e-01f, 3.74569446e-02f, -1.22060962e-01f, -5.21111861e-02f, -1.34713486e-01f, 7.23474622e-02f, -1.41478166e-01f, -9.78778601e-02f, -1.17155887e-01f,
  -1.12444922e-01f, -6.61090463e-02f, -8.57627839e-02f, 2.66000945e-02f, 2.52181608e-02f, 6.43427074e-02f, 5.29228384e-03f, 1.08002522e-03f, -1.02855898e-01f, 1.27371727e-02f,
  4.18864042e-02f, 1.07741907e-01f, 1.84535518e-01f, 1.32492781e-01f, 1.36319041e-01f, 1.04728304e-01f, 1.17741525e-01f, 5.67388013e-02f, 2.61224583e-02f, 2.25180879e-01f,
  6.55372322e-01f, -5.03006518e-01f, -7.24236667e-02f, 9.43190511e-03f, -3.40331733e-01f, -3.86046439e-01f, -5.01370788e-01f, -2.45173752e-01f, 2.74083707e-02f, -1.07797571e-01f,
  -4.94191684e-02f, 6.35691499e-03f, 4.00519259e-02f, 7.82538801e-02f, 1.45284131e-01f, -1.92684188e-01f, -1.17867567e-01f, 3.20423961e-01f, 1.63403079e-01f, 1.20121889e-01f,
  2.34196484e-02f, 3.51264700e-02f, 1.60101354e-01f, 2.34299198e-01f, 7.34527856e-02f, 1.53096497e-01f, -1.27550870e-01f, -9.47036147e-02f, -4.04251879e-03f, 1.87462986e-01f,
  1.06833458e-01f, 1.13939546e-01f, 1.99780062e-01f, 6.62538484e-02f, 2.95429211e-02f, 1.44219309e-01f, 1.20664917e-01f, -4.69448753e-02f, -2.71432810e-02f, -1.49646863e-01f,
  2.79526617e-02f, 5.88954128e-02f, 8.86482969e-02f, 3.24123837e-02f, -1.14287911e-02f, -3.21433209e-02f, -2.70739440e-02f, -3.18366215e-02f, 4.38894592e-02f, -7.88948610e-02f,
  -1.14524156e-01f, -1.53741047e-01f, -6.98451996e-02f, -1.55155182e-01f, 1.00717872e-01f, 5.17726727e-02f, -6.86269999e-02f, -3.95452492e-02f, -5.90278730e-02f, -9.33834687e-02f,
  -1.11775830e-01f, -2.56006364e-02f, 4.45970707e-02f, -8.76403227e-02f, -6.62568584e-02f, -2.47125812e-02f, -2.37382688e-02f, -2.01706067e-01f, 6.26852289e-02f, -1.37246996e-02f,
  -1.21169969e-01f, -5.66963553e-02f, 2.66326461e-02f, -1.13981500e-01f, 2.41748057e-02f, -5.58565557e-02f, -3.54740806e-02f, 4.43080589e-02f, 1.38295978e-01f, 3.34722325e-02f,
  3.16629931e-02f, -5.11469133e-02f, 7.06834812e-03f, -1.82413287e-03f, 7.12555945e-02f, -3.24549600e-02f, 8.89142901e-02f, -9.49203447e-02f, 4.93789352e-02f, -1.23023633e-02f,
  -2.69146919e-01f, 3.62991780e-01f, 2.55031019e-01f, 2.17769355e-01f, 9.66513231e-02f, 7.61466846e-02f, 1.05129823e-01f, 6.24001678e-03f, 3.07437945e-02f, -8.16397276e-03f,
  -1.26550253e-02f, 9.38458666e-02f, 4.76204492e-02f, 4.26642187e-02f, -1.88347679e-02f, 6.09548017e-02f, 6.97960407e-02f, -1.50895969e-03f, -6.93448484e-02f, -5.13886735e-02f,
  -9.32105929e-02f, -1.51473716e-01f, -4.02770657e-03f, -1.68824792e-01f, -5.80047490e-04f, 1.36867270e-01f, -8.33838210e-02f, 3.86801064e-02f, 6.89181089e-02f, -2.16672704e-01f,
  3.29149574e-01f, -2.58668602e-01f, -4.68300059e-02f, 3.41601551e-01f, 3.23447645e-01f, 3.20339262e-01f, 1.21778041e-01f, 1.32235140e-01f, 2.33173355e-01f, 1.82481855e-01f,
  9.53601077e-02f, 1.40462950e-01f, 8.93689394e-02f, 2.06938237e-02f, 1.04331926e-01f, 3.54627930e-02f, -3.20973843e-02f, 1.29787460e-01f, 2.16544792e-01f, 1.52247474e-01f,
  1.22451700e-01f, 9.50704142e-02f, -9.44793224e-02f, 3.89821902e-02f, 1.49902385e-02f, 9.70688015e-02f, 3.18113305e-02f, -7.16669261e-02f, -4.86214831e-02f, -3.19016315e-02f,
  -8.76067132e-02f, -1.59300759e-01f, 4.10377495e-02f, 4.75480855e-02f, -3.31650712e-02f, -5.42001128e-02f, -2.25569066e-02f, -6.59968555e-02f, -1.62726149e-01f, -1.59066454e-01f,
  -1.93831995e-02f, -1.34154573e-01f, -8.14072564e-02f, -5.88607341e-02f, -1.14776857e-01f, -9.38667953e-02f, -7.27156699e-02f, -1.33614272e-01f, -2.63316855e-02f, -4.62754853e-02f,
  -3.61329950e-02f, -1.45406332e-02f, 8.52508564e-03f, 7.98751041e-02f, 2.86381803e-02f, -7.56566450e-02f, -4.93504927e-02f, 4.50818939e-03f, -8.56977180e-02f, 3.48985591e-03f,
  2.06285760e-01f, 1.15572073e-01f, 1.34655118e-01f, 5.18534984e-03f, -5.04475273e-02f, -7.91472048e-02f, 1.72761409e-03f, 1.26526147e-01f, 4.62412089e-02f, -3.38625386e-02f,
  8.52088109e-02f, 2.46316381e-02f, 4.33964022e-02f, -2.24617459e-02f, 1.82465330e-01f, 1.34194180e-01f, -6.90284595e-02f, -4.26370725e-02f, 1.08681947e-01f, 1.16346784e-01f,
  1.30093411e-01f, 1.53346220e-02f, -5.54419234e-02f, -8.04024399e-04f, -5.61953746e-02f, -4.14756220e-03f, 1.40752137e-01f, 4.52757962e-02f, 3.19838226e-02f, 3.38652693e-02f,
  5.91255538e-02f, 3.34645510e-02f, 5.07784821e-02f, -1.09361187e-01f, -1.34260416e-01f, 4.95144129e-02f, 1.25989288e-01f, 2.20696442e-02f, -1.78665340e-01f, -6.77871928e-02f,
  -7.30104148e-02f, 5.20869941e-02f, 4.70265485e-02f, -1.02475934e-01f, 7.07816705e-02f, 4.58439291e-02f, 5.35168909e-02f, -5.67535907e-02f, -5.95431738e-02f, -7.61877373e-02f,
  7.87932575e-02f, 1.15188591e-01f, 9.81690213e-02f, 1.43620327e-01f, 2.97881924e-02f, 1.71246395e-01f, 4.62743752e-02f, 1.14590198e-01f, 4.56159189e-02f, 1.72600061e-01f,
  -1.33842468e-01f, -5.58351517e-01f, -2.59848952e-01f, -3.26894730e-01f, -5.61093032e-01f, -4.36370254e-01f, -8.13642144e-01f, -4.19627130e-01f, -3.18610519e-01f, -5.10901928e-01f,
  -1.77273855e-01f, 4.18548822e-01f, 3.62866193e-01f, 2.96220273e-01f, 2.49837309e-01f, -5.52016318e-01f, -4.93241310e-01f, 5.16151823e-02f, 2.52839267e-01f, -3.20212305e-01f,
  -2.68472254e-01f, -1.66049406e-01f, 2.11656809e-01f, 1.35003075e-01f, -2.62109280e-01f, 1.67876840e-01f, -7.15471208e-02f, -7.55560249e-02f, -8.18336159e-02f, -3.42389226e-01f,
  1.94784984e-01f, -2.47706741e-01f, 3.67404073e-02f, -3.73466611e-02f, -2.83270963e-02f, 9.20488760e-02f, -1.02395304e-01f, 7.57189617e-02f, -1.69688673e-03f, -1.28291801e-01f,
  -9.19347554e-02f, -1.22750467e-02f, 2.71067321e-01f, -3.07267215e-02f, -1.39648110e-01f, -8.45070407e-02f, -6.24205582e-02f, 4.96748686e-02f, 1.62965767e-02f, -1.31806180e-01f,
  -1.24342173e-01f, -2.78794974e-01f, 1.80675358e-01f, -6.12699091e-02f, -1.28612846e-01f, 4.19049859e-02f, -1.65308118e-02f, -8.74996185e-02f, 1.27716795e-01f, -1.06662303e-01f,
  -1.33821622e-01f, 4.88122143e-02f, -5.13973050e-02f, 1.50836874e-02f, 1.28101647e-01f, -1.45523772e-02f, 1.25113189e-01f, 1.11956798e-01f, 4.74656112e-02f, 8.71923342e-02f,
  3.98900248e-02f, -3.51567753e-02f, 3.19952657e-03f, 3.49549577e-02f, -4.46845964e-02f, 1.10941865e-01f, 1.71894934e-02f, 1.68439507e-01f, 1.44526362e-01f, -1.06829524e-01f,
  -1.62421241e-01f, 1.38432598e-02f, 5.69663271e-02f, 7.35496953e-02f, -1.79970205e-01f, 8.06973428e-02f, 9.70011670e-03f, 6.08648062e-02f, 4.48386297e-02f, -1.04424216e-01f,
  3.88887405e-01f, 1.15302369e-01f, -5.38294390e-02f, 4.89170291e-02f, 3.30916680e-02f, -3.52673270e-02f, -6.07890114e-02f, -8.68058857e-03f, 2.97748111e-02f, -6.41964674e-02f,
  -1.63644701e-01f, -6.84381872e-02f, 8.66332129e-02f, -7.68236294e-02f, -2.40048636e-02f, -5.10843005e-03f, -2.96113994e-02f, 1.45545527e-01f, 2.68667042e-02f, -2.23956898e-01f,
  -8.35918114e-02f, -1.28221130e-02f, 1.02974832e-01f, 1.13438770e-01f, 5.84701225e-02f, 2.45599508e-01f, 6.75943270e-02f, 1.09923452e-01f, 1.76172778e-01f, 3.42077687e-02f,
  -5.23877203e-01f, 9.41093490e-02f, 1.29803061e-01f, 5.38012013e-02f, 4.83355522e-01f, 1.40431419e-01f, -1.58519208e-01f, -2.99267679e-01f, -9.65043753e-02f, -1.10558800e-01f,
  1.02680489e-01f, 2.07917154e-01f, 2.78607368e-01f, 1.46134853e-01f, -2.33990267e-01f, 1.28204256e-01f, 3.69139194e-01f, -1.09293610e-01f, -3.90801340e-01f, -1.25985995e-01f,
  1.14352286e-01f, -6.37237206e-02f, -3.18066686e-01f, -1.76038593e-01f, 6.83880374e-02f, 6.71629235e-02f, 1.73234895e-01f, 1.95045799e-01f, 1.27687320e-01f, 3.41562599e-01f,
  -2.74453342e-01f, -4.33492362e-01f, -1.00570329e-01f, 3.47616076e-02f, 2.43899003e-01f, -4.05804664e-01f, -3.50703597e-01f, -2.00994402e-01f, -1.56627633e-02f, -2.34924033e-01f,
  8.54727104e-02f, -9.59784910e-02f, 2.86824495e-01f, 9.21715982e-03f, -1.92551970e-01f, -2.48512045e-01f, -1.32689759e-01f, -2.49842659e-01f, -2.73110628e-01f, -3.17539871e-01f,
  4.79343623e-01f, 1.62215054e-01f, -1.50921702e-01f, -1.14935681e-01f, -2.44061679e-01f, 9.19086114e-02f, -1.92764476e-01f, -4.46096331e-01f, -4.73653793e-01f, -5.00287831e-01f,
  -4.74628024e-02f, 5.87190017e-02f, 1.10595547e-01f, 7.75505006e-02f, -1.23261347e-01f, 1.02956779e-01f, 1.26670748e-01f, 8.39722231e-02f, 8.83144215e-02f, 4.58181798e-02f,
  1.84766144e-01f, -8.46403614e-02f, -9.02353674e-02f, -1.35005593e-01f, 6.41269684e-02f, 7.63695873e-03f, -5.70848659e-02f, -5.33976033e-02f, 9.37201455e-02f, -1.00831881e-01f,
  2.50160787e-02f, -3.06088850e-02f, 7.47674331e-02f, -1.52566671e-01f, 7.27237165e-02f, -3.00822705e-02f, -1.79919317e-01f, -7.13082850e-02f, -2.81444639e-02f, -1.37923881e-01f,
  -1.86335310e-01f, 3.76452543e-02f, -2.09901989e-01f, -1.36863992e-01f, 1.06303260e-01f, 1.91005021e-02f, 1.29026145e-01f, -2.66896505e-02f, 6.14019409e-02f, -1.99821547e-01f,
  -2.10439175e-01f, -1.92202449e-01f, 7.25109950e-02f, 8.08517355e-03f, -7.59692788e-02f, -2.83468086e-02f, 2.10607350e-01f, 7.08269849e-02f, -1.70430467e-02f, 7.37364963e-02f,
  2.26390436e-01f, -3.16641092e-01f, -1.80271879e-01f, -3.58043648e-02f, 3.55795055e-04f, -2.43212417e-01f, -1.63063154e-01f, -3.22530180e-01f, -2.21722424e-01f, -5.60372889e-01f,
  7.55127788e-01f, 3.60404640e-01f, -2.11042464e-01f, 2.40190804e-01f, -8.64220187e-02f, 1.12118058e-01f, 3.67188543e-01f, 2.76183724e-01f, 2.51446664e-01f, 2.85336852e-01f,
  8.97824466e-02f, 1.57280207e-01f, 3.03170592e-01f, 1.65609285e-01f, 1.25053570e-01f, 1.50343001e-01f, 1.24661498e-01f, -1.81464776e-02f, 9.62967724e-02f, 2.72399224e-02f,
  2.07919508e-01f, 2.11255655e-01f, 7.72341043e-02f, 1.76995084e-01f, -7.12306872e-02f, 9.77653489e-02f, 1.87729262e-02f, -9.73897800e-02f, -9.47253630e-02f, -1.16506228e-02f,
  -2.69299805e-01f, 3.82004827e-02f, -1.89986050e-01f, -8.21113363e-02f, -6.53361380e-02f, 1.28264189e-01f, -4.98311333e-02f, -3.36213671e-02f, 9.43465084e-02f, 7.32852817e-02f,
  -1.27422228e-01f, 7.21629383e-03f, 1.27864525e-01f, -1.13930643e-01f, -7.97325745e-02f, -1.41454577e-01f, 2.77415588e-02f, 4.63676751e-02f, -3.35990973e-02f, -6.82001039e-02f,
  -7.81426504e-02f, -1.03421159e-01f, -2.11746722e-01f, -7.26176202e-02f, -2.83911563e-02f, -4.14022878e-02f, -9.26199928e-02f, -5.42553663e-02f, -1.23120874e-01f, -1.52703207e-02f,
  1.22929916e-01f, 3.50419916e-02f, 7.47072324e-02f, 1.23211510e-01f, 9.84120965e-02f, 1.98242906e-02f, -6.64775744e-02f, 1.84902344e-02f, 9.56297815e-02f, 5.71148805e-02f,
  -8.55096802e-02f, 4.91546988e-02f, -3.97879183e-02f, 1.99458208e-02f, 9.38028246e-02f, 5.45570254e-02f, -9.16913450e-02f, 3.00830510e-02f, 5.50930053e-02f, 8.12643394e-03f,
  -3.59507687e-02f, -6.85321912e-02f, 1.56466872e-03f, 5.91888689e-02f, 4.25750986e-02f, -3.67987789e-02f, 1.03445463e-01f, 1.24150395e-01f, 1.74455717e-01f, 1.19133875e-01f,
  -2.73681115e-02f, 9.43078250e-02f, -5.87870888e-02f, 2.73551941e-02f, -2.31187463e-01f, -1.46716267e-01f, 3.63498107e-02f, -8.98644030e-02f, -2.54042763e-02f, -2.78469492e-02f,
  -4.50263545e-02f, 6.75551668e-02f, 2.32460015e-02f, 2.43465770e-02f, -1.78881548e-02f, -1.33524790e-01f, -6.43080696e-02f, -1.32145442e-03f, -4.32409011e-02f, -2.17395693e-01f,
  5.60018122e-02f, -4.27686609e-03f, -1.44251391e-01f, -1.42443538e-01f, -1.71470508e-01f, 3.23695093e-02f, -1.54356107e-01f, -1.14836236e-02f, 1.46508599e-02f, 5.99655323e-02f,
  -1.60856366e-01f, 2.30612699e-03f, 2.57412344e-02f, 1.38370454e-01f, 1.94701493e-01f, 2.08373472e-01f, 1.00055791e-01f, 7.14360997e-02f, 2.20514804e-01f, 1.63955629e-01f,
  1.15309879e-01f, 3.28618854e-01f, 1.56620890e-01f, 2.72149205e-01f, 1.32308900e-01f, 3.17746907e-01f, 3.58305484e-01f, 1.11129269e-01f, 5.13979606e-02f, 1.40904754e-01f,
  1.48993358e-01f, 1.81634314e-02f, -1.53080896e-01f, 1.01244934e-01f, 2.91272491e-01f, 2.19395712e-01f, 1.63653135e-01f, 1.37186632e-01f, 9.28999409e-02f, 2.78876692e-01f,
  1.77268356e-01f, -9.21858400e-02f, 1.34704307e-01f, 6.01313561e-02f, -1.09067030e-01f, -1.69634327e-01f, -1.11702979e-01f, -1.32260084e-01f, -6.95409849e-02f, -2.49892753e-02f,
  6.25327229e-02f, -8.67851973e-02f, 8.33767280e-02f, 6.00479369e-04f, -1.91158563e-01f, -1.69837952e-01f, -7.45676644e-03f, 1.83646511e-02f, 1.35732427e-01f, 1.43614963e-01f,
  1.19288862e-01f, 4.34860624e-02f, 7.64100701e-02f, 4.30351011e-02f, 6.66495413e-02f, 8.66471529e-02f, -5.75715341e-02f, 9.04872268e-02f, -1.08178677e-02f, 2.29473342e-03f,
  3.22440326e-01f, 6.76644668e-02f, 1.72861695e-01f, 1.98705539e-01f, 3.83963063e-02f, 1.17226459e-01f, 4.53469567e-02f, 9.30111110e-02f, 5.63759878e-02f, -4.29650284e-02f,
  8.93259868e-02f, 9.90115404e-02f, 3.43850628e-02f, -9.13806912e-03f, 6.07240312e-02f, 4.78186943e-02f, 5.55894598e-02f, 4.98454534e-02f, -5.46978042e-02f, 1.34602740e-01f,
  1.21466599e-01f, 2.39731409e-02f, -1.44432530e-01f, -3.05862948e-02f, 9.05468389e-02f, -3.76080945e-02f, 5.29969670e-02f, 4.16311920e-02f, -3.11552268e-02f, -1.05076589e-01f,
  -1.12656675e-01f, 3.80191579e-02f, 1.49073169e-01f, 1.49763688e-01f, 1.05022788e-02f, -2.03627422e-01f, 1.36908382e-01f, -8.21081772e-02f, -1.80892929e-01f, -3.12327477e-03f,
  -7.89424405e-02f, -2.74634603e-02f, -2.18147859e-02f, -3.88464481e-02f, -6.20947182e-02f, -1.12394266e-01f, 2.15893816e-02f, 1.30426079e-01f, 1.31838080e-02f, -2.14833058e-02f,
  -4.22502346e-02f, -8.14211592e-02f, -4.14126180e-02f, 5.74846119e-02f, -2.71468908e-02f, 4.50852402e-02f, -7.66477212e-02f, -4.48284261e-02f, -1.72811031e-01f, -2.42179975e-01f,
  -5.58193505e-01f, -2.42444143e-01f, -1.61291391e-01f, 6.97276974e-03f, -4.40470390e-02f, -2.00433046e-01f, -5.17044544e-01f, -3.40154082e-01f, -5.14368974e-02f, -4.27118428e-02f,
  1.13193147e-01f, 6.74987584e-02f, 3.39247426e-03f, -2.01066196e-01f, -4.81269032e-01f, -4.33278948e-01f, -3.88603717e-01f, -4.63484555e-01f, -2.66379625e-01f, -1.31694883e-01f,
  -1.18387848e-01f, -3.17378104e-01f, -3.61363322e-01f, -1.90138936e-01f, 2.93758631e-01f, 1.90558657e-01f, 1.25972619e-02f, -7.02240765e-02f, -6.08242899e-02f, 1.09151505e-01f,
  2.54842937e-01f, 1.01976268e-01f, -8.43684468e-03f, -6.72496781e-02f, -4.28393632e-02f, -8.00997689e-02f, -7.49138594e-02f, 6.56908527e-02f, 2.38292869e-02f, 5.08645782e-03f,
  7.00542033e-02f, -4.11027968e-02f, -9.20539126e-02f, -1.74622312e-02f, 4.02982756e-02f, 1.05381198e-01f, 1.20067865e-01f, 8.65563005e-02f, 9.91617739e-02f, 5.91889955e-02f,
  6.50261005e-04f, 3.00247245e-03f, 1.26203716e-01f, -2.18627229e-02f, 1.65380761e-02f, 9.40481052e-02f, 4.67308685e-02f, 1.67957664e-01f, 4.55449410e-02f, 3.17207985e-02f,
  -1.91327527e-01f, 5.04263416e-02f, 8.53561610e-02f, 1.57294542e-01f, 1.16946653e-01f, 1.47790641e-01f, 7.75262192e-02f, -5.71521111e-02f, -1.71928167e-01f, 1.36882439e-02f,
  1.66013777e-01f, -4.99159805e-02f, -1.88429430e-02f, -7.37406164e-02f, -6.24355897e-02f, -7.97866136e-02f, -3.41315828e-02f, 5.46340272e-02f, -2.67393366e-02f, 1.40911207e-01f,
  4.42770682e-02f, 1.13618067e-02f, -4.58387192e-03f, 1.36498094e-01f, 1.16791166e-01f, -3.27688828e-02f, -6.83443621e-02f, 2.89881285e-02f, -1.28169894e-01f, -3.99987251e-02f,
  1.83598042e-01f, -2.31296852e-01f, 1.43424243e-01f, -3.49788480e-02f, 1.24713734e-01f, 1.50482029e-01f, 1.81832224e-01f, 1.17264427e-01f, 2.03159124e-01f, 8.69328305e-02f,
  1.08066797e-01f, -4.62992378e-02f, -5.75341843e-02f, -9.45868250e-03f, 6.74174260e-03f, -1.56586785e-02f, 3.45842615e-02f, 3.26306559e-02f, -2.66150367e-02f, 1.53846219e-01f,
  -4.19671945e-02f, -9.38459635e-02f, -1.73648652e-02f, 1.24837972e-01f, 3.03272028e-02f, 3.00190952e-02f, 6.19803369e-02f, 2.26472318e-02f, 8.55699778e-02f, -3.49584483e-02f,
  5.72095692e-01f, -4.08453375e-01f, 2.82830060e-01f, 2.19117105e-01f, -1.97777614e-01f, -3.10663193e-01f, -4.10127044e-01f, -9.59328488e-02f, 8.36056918e-02f, -1.47370324e-01f,
  -3.27037334e-01f, -6.30966201e-02f, -3.47041376e-02f, 1.78397819e-01f, 2.68665761e-01f, -6.63377251e-03f, 3.41419607e-01f, 5.44342220e-01f, 4.27405924e-01f, 9.49765518e-02f,
  1.10793030e-02f, 1.63962826e-01f, 4.00441587e-01f, 1.68100700e-01f, -8.83518830e-02f, 1.00963034e-01f, 3.43124033e-03f, -5.61524443e-02f, -1.42804220e-01f, 2.86827624e-01f,
  -1.38870507e-01f, -1.84360534e-01f, 5.85197061e-02f, -1.57759711e-02f, -1.37034208e-01f, -6.61405846e-02f, -2.99907196e-02f, 1.02575384e-01f, -6.67039603e-02f, -1.79235432e-02f,
  -8.09377506e-02f, 6.38045594e-02f, -5.87785691e-02f, -1.02503680e-01f, -8.25453699e-02f, -4.03163806e-02f, 1.51954487e-01f, 1.90482751e-01f, 1.11979835e-01f, -1.72041371e-01f,
  -3.88206951e-02f, -1.38768733e-01f, 4.40061931e-03f, -8.54522139e-02f, -9.93928239e-02f, 1.32552713e-01f, -2.14383602e-02f, -4.95409481e-02f, -2.38176505e-03f, -3.60132717e-02f,
  6.17976859e-03f, -5.67440912e-02f, -6.45905659e-02f, 5.44037893e-02f, 1.03110053e-01f, -8.60960931e-02f, 1.06440142e-01f, -1.66967569e-03f, -3.31472121e-02f, -5.91242537e-02f,
  -6.21273043e-03f, 1.12223402e-01f, 8.98274258e-02f, -4.83838618e-02f, -1.04059599e-01f, 6.55402094e-02f, -9.90247354e-02f, -1.22096548e-02f, -1.43366352e-01f, -2.28793845e-02f,
  7.68359974e-02f, 8.65580216e-02f, 9.70907807e-02f, 9.83275697e-02f, -7.58818444e-03f, 1.44795701e-01f, 7.00485855e-02f, -3.04808151e-02f, -1.13364488e-01f, 4.35393564e-02f,
  -5.33485450e-02f, 6.37819022e-02f, 2.18719952e-02f, 2.49879225e-03f, -7.26809278e-02f, -2.93507483e-02f, -3.85032631e-02f, 6.23911619e-02f, -6.65740222e-02f, -2.03070626e-01f,
  -2.08042920e-01f, -4.00549266e-03f, -2.68579982e-02f, -1.43641559e-02f, 9.39398482e-02f, -3.90377045e-02f, -1.05823882e-01f, 6.96229562e-02f, 5.95366023e-02f, -2.43063774e-02f,
  -3.90783846e-02f, -3.11842430e-02f, 9.53246430e-02f, -1.22300155e-01f, -8.06832165e-02f, 1.21718593e-01f, 4.98075858e-02f, -6.20104708e-02f, 9.00411531e-02f, -6.68130517e-02f,
  2.86061257e-01f, 1.31995827e-01f, 5.19021861e-02f, 1.61659971e-01f, 1.98851451e-01f, 2.27595478e-01f, 1.84399828e-01f, 2.28167549e-01f, 8.61194655e-02f, 1.73865706e-01f,
  1.15833260e-01f, -6.87422082e-02f, 1.54171670e-02f, -7.45545253e-02f, 8.00301060e-02f, 1.25519082e-01f, -3.50112692e-02f, -2.14739367e-02f, -1.01661906e-01f, -1.34853005e-01f,
  -6.24169745e-02f, 3.78459543e-02f, 1.00320570e-01f, 3.52751687e-02f, -9.42924619e-02f, -2.28620227e-02f, 1.38108596e-01f, 4.43485416e-02f, 9.57418606e-02f, -2.28923708e-01f,
  -7.13025928e-02f, 1.41262323e-01f, -7.37151057e-02f, 5.33635058e-02f, 6.57367781e-02f, 1.64207414e-01f, 1.18642114e-01f, 1.42854182e-02f, 1.55563597e-02f, 3.72266024e-02f,
  8.34543109e-02f, 9.99490023e-02f, 1.56984761e-01f, -1.95873696e-02f, 1.39223412e-01f, 1.54646128e-01f, -3.42207141e-02f, -1.00245113e-02f, 5.43665923e-02f, 6.85390318e-03f,
  -3.25098224e-02f, -6.30331337e-02f, -1.18616205e-02f, -4.25180867e-02f, -1.40511543e-02f, 2.10026838e-02f, 6.91942871e-02f, -1.52420178e-02f, -9.89036169e-03f, 3.97540517e-02f,
  6.95079267e-02f, 1.81085572e-01f, 4.23259102e-02f, -3.30359824e-02f, 1.19613828e-02f, 1.77175641e-01f, 1.24680005e-01f, 2.68015508e-02f, 7.38149881e-02f, 2.10754648e-01f,
  1.57972947e-01f, 4.86917235e-02f, 2.85952330e-01f, 6.38760552e-02f, 2.42169380e-01f, 1.08878829e-01f, 7.87929893e-02f, 1.71389937e-01f, 2.88527191e-01f, 2.72440374e-01f,
  -1.51385032e-02f, 2.23550126e-01f, 3.08424801e-01f, 1.22658022e-01f, 9.92121622e-02f, 4.97064069e-02f, 1.63518898e-02f, 1.06369756e-01f, 2.18807012e-01f, 1.50072813e-01f,
  6.79985480e-03f, 1.86989427e-01f, -3.42902131e-02f, -1.33566350e-01f, 7.89930969e-02f, 7.99703971e-02f, 1.23921139e-02f, -1.58571992e-02f, 9.30118039e-02f, 5.78615367e-02f,
  8.11876263e-03f, -3.05792838e-02f, 1.17620334e-01f, 9.24417675e-02f, -4.46034446e-02f, 7.55342543e-02f, -1.08501188e-01f, -1.30486935e-01f, 2.23342166e-03f, 7.36895800e-02f,
  -6.51308894e-02f, -2.14502998e-02f, -5.12813684e-03f, 1.34913893e-02f, 5.86375035e-03f, 1.77983101e-02f, -1.08623832e-01f, -1.15875393e-01f, 1.25858188e-02f, 2.44551282e-02f,
  -3.66577089e-01f, -3.28956768e-02f, -1.48785487e-01f, -2.70102590e-01f, -1.40247885e-02f, 1.26702845e-01f, 1.16899088e-01f, 1.31063446e-01f, -6.65627941e-02f, -3.45060565e-02f,
  -8.73854384e-02f, -3.11499894e-01f, -2.59160638e-01f, -1.54747814e-01f, -1.10240309e-02f, 1.55235641e-02f, -2.27718637e-03f, -4.59039807e-02f, 3.20046395e-02f, 5.37698492e-02f,
  -1.00777388e-01f, -1.80471793e-01f, -1.70278743e-01f, -2.28140932e-02f, -2.72600740e-01f, -2.03553453e-01f, -8.22087526e-02f, -6.18349873e-02f, -9.08179432e-02f, -1.71665713e-01f,
  -1.61537498e-01f, 1.77223533e-02f, 3.37302461e-02f, 1.89797238e-01f, 6.10936619e-02f, 1.18850760e-01f, 1.38006151e-01f, 1.67216554e-01f, 1.73239917e-01f, 5.00087366e-02f,
  4.24114503e-02f, 1.63616389e-02f, 9.70786437e-02f, 5.40455384e-03f, 1.09154433e-01f, 1.15529276e-01f, 4.16834243e-02f, 6.53733090e-02f, -1.91770475e-02f, 4.34309617e-02f,
  -2.23995075e-02f, 1.31278366e-01f, -6.54096343e-03f, 1.21306121e-01f, 1.75890982e-01f, 3.15969028e-02f, 1.03957012e-01f, 2.63174810e-02f, 5.87683655e-02f, 1.03501722e-01f,
  2.31005087e-01f, 7.76561256e-03f, 1.03930682e-02f, 2.79694162e-02f, -5.48751168e-02f, 1.03748322e-01f, -8.50861147e-03f, 1.14613265e-01f, 3.58615667e-02f, -5.97565807e-03f,
  1.15214385e-01f, -4.59818356e-02f, -6.08270839e-02f, 1.68278411e-01f, 1.25161812e-01f, -8.68370757e-02f, 1.23141324e-02f, 9.01187658e-02f, 1.09882310e-01f, -9.68793854e-02f,
  9.17147100e-03f, 3.24761234e-02f, -3.10750641e-02f, 1.34588003e-01f, 9.42492336e-02f, 6.94250613e-02f, -7.31860613e-03f, 1.15865357e-01f, 6.70602694e-02f, -9.20357034e-02f,
  -2.56074756e-01f, 3.52862291e-02f, -9.50521380e-02f, -1.43315002e-01f, -1.15669733e-02f, 1.16911471e-01f, -1.25098377e-01f, 3.71910557e-02f, 1.38332129e-01f, 2.71654804e-03f,
  1.10846229e-01f, -8.66415724e-03f, 2.90585938e-03f, 8.17370713e-02f, 8.99835080e-02f, 2.09854953e-02f, 5.28471656e-02f, -8.07199702e-02f, -2.95877960e-02f, 2.49522682e-02f,
  -1.30582433e-02f, -3.88891809e-02f, -1.00557476e-01f, 6.29785210e-02f, -1.03012389e-02f, -8.73986855e-02f, 5.40136062e-02f, 6.90856995e-03f, 3.33137698e-02f, 1.47334501e-01f,
  -4.51509692e-02f, 1.19482331e-01f, -1.19471163e-01f, 2.14762494e-01f, 2.24785909e-01f, 2.55890399e-01f, 4.02762979e-01f, 2.21875504e-01f, 2.63838381e-01f, 1.51656657e-01f,
  1.64663106e-01f, 1.46377921e-01f, 1.35244593e-01f, 2.32621983e-01f, 2.45692700e-01f, 2.63252079e-01f, 1.79536656e-01f, -2.89182470e-04f, -6.96827769e-02f, -4.01960546e-03f,
  7.88567811e-02f, 1.17832549e-01f, -1.45701721e-01f, -2.56891865e-02f, 1.49124442e-02f, -4.64932695e-02f, 1.15008846e-01f, -4.74602170e-02f, 6.82290867e-02f, -6.26936555e-02f,
  -3.84166807e-01f, 2.43494678e-02f, -2.19122972e-02f, -8.61424431e-02f, -2.23795101e-02f, -5.87391816e-02f, -8.43821466e-02f, 1.56505499e-02f, -6.34066761e-02f, 2.63059493e-02f,
  -5.37589788e-02f, -5.08991443e-02f, 3.68595980e-02f, 3.57676335e-02f, 3.31720188e-02f, -6.94772825e-02f, -7.70159960e-02f, 5.86047955e-02f, 1.85963303e-01f, 3.04896552e-02f,
  1.16445772e-01f, 4.91221361e-02f, 1.46013111e-01f, 1.01850972e-01f, 2.18745455e-01f, -4.59033698e-02f, 4.89216372e-02f, -7.87358284e-02f, 7.00149536e-02f, 5.58977053e-02f,
  2.86773324e-01f, 1.17984582e-02f, -4.57727425e-02f, 3.38299237e-02f, 1.28903672e-01f, -2.56864466e-02f, -6.51985705e-02f, 9.11752135e-03f, 1.84748724e-01f, -2.28683837e-02f,
  -1.51176574e-02f, 1.82458330e-02f, 1.27973646e-01f, -1.31314307e-01f, -1.61311448e-01f, -2.39711311e-02f, -5.67760430e-02f, -1.00927770e-01f, -1.17685914e-01f, 8.48815870e-03f,
  -3.00005302e-02f, -1.76964253e-02f, -1.13189466e-01f, -7.10859373e-02f, -3.24433036e-02f, 7.74012432e-02f, 7.52167553e-02f, 1.53317414e-02f, 3.01336795e-02f, 7.09107937e-03f,
  1.45138592e-01f, 4.88501601e-02f, 3.85384671e-02f, -2.06869431e-02f, -1.24632299e-01f, -1.34793848e-01f, 3.92040517e-03f, -9.48671475e-02f, -6.30449355e-02f, -1.81544647e-02f,
  -2.36463808e-02f, -5.16246893e-02f, -3.14455992e-03f, -5.79894707e-02f, -7.46990591e-02f, -4.72762100e-02f, -1.39694922e-02f, -2.60427799e-02f, 1.08913712e-01f, 3.82923260e-02f,
  -7.80109540e-02f, 1.22659862e-01f, 5.16599566e-02f, 9.45163965e-02f, 9.70213339e-02f, 2.76478436e-02f, -1.72110507e-03f, -1.18792593e-01f, -6.15978390e-02f, -6.88878000e-02f,
  -5.29569611e-02f, -2.97661841e-01f, -6.10391703e-03f, 1.03718266e-01f, -2.44346932e-01f, -2.69462168e-01f, -4.03947562e-01f, -2.24896446e-01f, -7.47874752e-02f, 4.12250757e-02f,
  -1.38872042e-01f, -2.69600190e-02f, 8.72883350e-02f, -7.15485066e-02f, -3.02543133e-01f, 5.37506454e-02f, 9.41364793e-04f, -1.69949397e-01f, -4.58185196e-01f, -5.65510571e-01f,
  -4.86798406e-01f, -3.21836323e-01f, -4.21929091e-01f, -2.85877466e-01f, -1.15745664e-01f, -8.40709731e-02f, 4.33077030e-02f, -1.69371113e-01f, -2.42398813e-01f, -7.95451552e-02f,
  2.21034601e-01f, -2.10891724e-01f, 4.17458154e-02f, -4.59428094e-02f, -7.78280348e-02f, 8.17737952e-02f, 1.51398433e-02f, -5.49244508e-02f, 9.29888785e-02f, 5.19506522e-02f,
  -2.38429531e-02f, 4.86589670e-02f, 4.10530791e-02f, -3.41302343e-02f, 5.26199490e-02f, -3.05362022e-03f, 2.84196418e-02f, -1.00148804e-01f, -1.45484954e-02f, -3.21683288e-02f,
  -2.63852673e-03f, -2.36290358e-02f, 3.57496999e-02f, -4.37561907e-02f, 3.54966074e-02f, 3.85694019e-02f, -8.37705359e-02f, -9.55641568e-02f, 2.75869910e-02f, 1.35114461e-01f,
  -1.28499582e-01f, 1.93541318e-01f, 6.00851104e-02f, -1.08640797e-01f, 1.46815762e-01f, 1.23052374e-01f, 1.22956626e-01f, 8.50544646e-02f, -1.12978369e-01f, -2.78180167e-02f,
  -1.06951306e-02f, 2.55685020e-02f, -7.65199633e-03f, 3.82904150e-02f, -2.14000326e-02f, 4.20709811e-02f, -5.50258830e-02f, -3.56338210e-02f, 2.01858748e-02f, 3.74793299e-02f,
  6.08280748e-02f, 1.01659611e-01f, 6.79887235e-02f, 8.89476505e-04f, -1.56143337e-01f, -7.26647349e-03f, -1.04451828e-01f, -9.32026580e-02f, -7.67636672e-02f, 7.94067457e-02f,
  1.48449436e-01f, -2.29830459e-01f, 2.14793548e-01f, -3.94403674e-02f, 1.05806269e-01f, 6.77229390e-02f, -6.32869750e-02f, -3.57821397e-02f, 6.18245713e-02f, -5.61507158e-02f,
  -1.14734225e-01f, -4.99679968e-02f, 7.10891411e-02f, 7.07421675e-02f, 5.81729524e-02f, -3.66289951e-02f, -3.08414996e-02f, 7.49029312e-03f, 3.51060778e-02f, 8.63876268e-02f,
  6.54813424e-02f, 5.59762605e-02f, 2.47297779e-01f, 1.72157750e-01f, 1.87877957e-02f, 1.08772665e-01f, 8.59568268e-02f, 1.26674026e-01f, 4.35952656e-02f, 1.51604414e-01f,
  1.72572777e-01f, -3.87487322e-01f, -4.96826440e-01f, -4.79106843e-01f, -2.23783657e-01f, -6.08290620e-02f, -1.14315182e-01f, 7.14893267e-02f, -4.44097146e-02f, -4.72879648e-01f,
  -1.28127903e-01f, 2.96544850e-01f, -1.49328291e-01f, 1.19739100e-01f, 2.85078436e-01f, -5.49500704e-01f, -3.86019796e-01f, -1.10405758e-01f, 4.29149121e-01f, 3.33576858e-01f,
  4.22177985e-02f, -9.78836194e-02f, 5.07789329e-02f, 8.53475928e-03f, -3.80873710e-01f, -1.62467569e-01f, -4.24562812e-01f, -3.27998966e-01f, -1.18781596e-01f, -5.74376941e-01f,
  -3.38109642e-01f, 1.78285807e-01f, 9.02171507e-02f, 2.50179738e-01f, -2.30487525e-01f, 1.05830505e-01f, 5.97829372e-02f, -1.59748837e-01f, 7.22410455e-02f, -1.65544495e-01f,
  4.97142226e-02f, 3.00599128e-01f, 1.01605013e-01f, 3.52251865e-02f, 8.31527486e-02f, 7.98892081e-02f, -1.44703031e-01f, 1.49921224e-01f, -9.16861445e-02f, -6.27939478e-02f,
  -2.20336635e-02f, 8.15541819e-02f, 2.66045555e-02f, 1.64616648e-02f, 4.64290120e-02f, 7.80101791e-02f, -1.95356339e-01f, 8.04825723e-02f, 1.88461076e-02f, -4.62460130e-01f,
  -2.13293917e-02f, -1.96357578e-01f, -3.68516929e-02f, 1.29253268e-01f, 4.54458036e-02f, 5.21657802e-02f, -9.40809101e-02f, 5.17449044e-02f, 1.02735810e-01f, -7.99028873e-02f,
  8.38928148e-02f, -1.81115549e-02f, 6.93310797e-02f, -8.69694203e-02f, -1.28817394e-01f, 8.33435208e-02f, -7.29639083e-02f, 1.40624866e-03f, 4.48554978e-02f, -8.35589841e-02f,
  3.69906146e-03f, 2.52074450e-02f, 1.29587087e-03f, 1.10966302e-02f, -3.71904187e-02f, -5.22389077e-02f, 6.93211332e-02f, 6.46331161e-02f, 1.86035354e-02f, 2.64005479e-03f,
  -1.15775652e-01f, 2.16260865e-01f, -3.28758746e-01f, 5.64179197e-02f, -6.42645881e-02f, -1.32294402e-01f, -1.67589039e-01f, -1.01781800e-01f, -1.02284856e-01f, -2.54613943e-02f,
  1.80911377e-01f, 1.37244016e-01f, -9.77203697e-02f, -4.16424451e-03f, -5.18862717e-03f, 1.08490422e-01f, -5.38174435e-02f, -1.89319123e-02f, 1.90215215e-01f, -1.21176563e-01f,
  -2.69468963e-01f, 8.84668976e-02f, 2.00804174e-01f, -5.82552515e-02f, 7.01254904e-02f, 8.92794058e-02f, -2.02166751e-01f, -1.29468799e-01f, 1.42005250e-01f, -4.01220769e-01f,
  6.49034560e-01f, 1.04467228e-01f, 3.69134694e-01f, 2.21668363e-01f, 2.39291683e-01f, 2.42025539e-01f, 2.99005181e-01f, 1.64116248e-01f, 1.07475571e-01f, 9.05492716e-03f,
  1.95745870e-01f, 6.00138493e-02f, -8.51255059e-02f, -1.42860442e-01f, -1.43669188e-01f, -7.33761713e-02f, -1.51669741e-01f, 5.68706319e-02f, -3.57400626e-03f, 9.92266461e-02f,
  -1.47634804e-01f, -1.48219848e-02f, 6.62568212e-02f, -3.27207074e-02f, 3.90197895e-02f, 1.46719133e-02f, 2.82382499e-02f, 7.92482421e-02f, -8.63776207e-02f, -2.36384630e-01f,
  -9.21111554e-02f, 2.32731372e-01f, -1.54979527e-01f, -1.74715847e-01f, 5.51084243e-02f, -7.74788186e-02f, -5.51203778e-03f, -3.03011644e-03f, -6.25640601e-02f, -2.19609097e-01f,
  -1.17576113e-02f, 5.08607887e-02f, -2.96051856e-02f, -1.83598232e-02f, 7.41357207e-02f, -5.42329513e-02f, -1.53115066e-03f, -2.86433869e-03f, -2.23673191e-02f, -6.91402778e-02f,
  -4.84618358e-02f, 2.14818567e-01f, 1.05035335e-01f, -5.27801700e-02f, 7.21073896e-02f, -4.90505286e-02f, 1.14356391e-01f, 2.09784731e-02f, 1.03141563e-02f, -6.21484965e-02f,
  -2.90013966e-03f, 1.15574196e-01f, 1.89122111e-01f, 1.12639636e-01f, -1.99267808e-02f, 1.24979824e-01f, -3.17834057e-02f, -1.03223380e-02f, -1.28584569e-02f, 1.08750544e-01f,
  -6.65871128e-02f, 7.86090493e-02f, 5.83402142e-02f, -9.00170207e-03f, 1.35804310e-01f, 4.86564599e-02f, 1.57594651e-01f, -5.06598465e-02f, 1.54765034e-02f, -1.21426933e-01f,
  -3.21867727e-02f, -9.38159674e-02f, -4.78616497e-03f, 6.08101487e-03f, 2.17095986e-02f, 3.75650674e-02f, -3.21951276e-03f, -6.20998070e-02f, 1.58111274e-01f, -3.95318605e-02f,
  -3.34890753e-01f, 1.38937294e-01f, -4.18594852e-02f, -6.42099977e-02f, 8.96938816e-02f, 7.21341297e-02f, 1.25454322e-01f, -8.95316079e-02f, -1.34073079e-01f, -1.42549217e-01f,
  -3.16551328e-02f, -1.03280852e-02f, 1.24857306e-01f, -1.10733449e-01f, 5.60413152e-02f, -6.12396412e-02f, 2.96106078e-02f, 1.61880344e-01f, -1.36315748e-01f, -1.51872812e-02f,
  -3.60597968e-02f, 1.45889908e-01f, 1.91650346e-01f, 1.04324650e-02f, 8.48434195e-02f, 6.71521053e-02f, -3.93321365e-02f, -3.15520503e-02f, 5.23288101e-02f, -1.06918693e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  3.97018671e-01f, 4.37758148e-01f, 6.67095363e-01f, 5.27846456e-01f, 4.47659910e-01f, 4.29250389e-01f, 5.15044272e-01f, 4.72788095e-01f, 3.18043917e-01f, 3.69091719e-01f,
  3.28999192e-01f, 6.12368345e-01f, 4.75386292e-01f, 1.61973894e-01f, 2.59591758e-01f, 3.22321534e-01f, 1.62235960e-01f, 3.80602658e-01f, 4.12673533e-01f, 2.51427412e-01f,
  9.71483588e-02f, 6.09895527e-01f, 3.10004383e-01f, 3.62964928e-01f, 5.84337354e-01f, 4.60719913e-01f, 1.68686152e-01f, 5.54710269e-01f, 2.89310068e-01f, 3.33600670e-01f,
  6.23328567e-01f, 4.37084377e-01f, 4.59274650e-01f, 5.50460100e-01f, 9.78200287e-02f, 4.53477055e-01f, 5.50559700e-01f, 6.64526582e-01f, 4.92511988e-01f, 4.74064380e-01f,
  4.03848588e-01f, 2.46146083e-01f, 8.55659172e-02f, 3.37021708e-01f, 5.24803698e-01f, 4.41840291e-01f, 4.64378715e-01f, 1.86130986e-01f, 2.58814663e-01f, 3.14071864e-01f,
  4.23833519e-01f, 5.94457626e-01f, 7.52034485e-01f, 4.01218921e-01f, 2.50084758e-01f, 3.49663764e-01f, 2.52496779e-01f, 9.19490010e-02f, 5.31789184e-01f, 1.71909109e-01f,
  4.66917008e-01f, 4.88465667e-01f, 3.73514712e-01f, 3.80845606e-01f, 5.52788615e-01f, 2.71652579e-01f, 4.14431840e-01f, 2.33045980e-01f, 6.09649360e-01f, 1.14760667e-01f,
  2.55455017e-01f, 7.10882664e-01f, 2.98918486e-01f, 7.81604275e-02f, 9.39023197e-02f, 3.97374302e-01f, 1.62044570e-01f, 4.80390400e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.08859807e-01f, -1.21889776e-02f, -2.89922506e-01f, -9.51715279e-03f, -9.71017499e-03f, 7.28931054e-02f, -3.32802624e-01f, 2.44264863e-02f, -1.51119158e-01f, -6.32954249e-03f,
  -1.34190813e-01f, -1.69366762e-01f, -9.98926908e-02f, -8.72234553e-02f, -7.08023366e-03f, 2.38875914e-02f, -8.77079740e-02f, -2.03637689e-01f, 1.70752984e-02f, -5.55534624e-02f,
  -3.44792336e-01f, -6.66094339e-03f, -2.04488009e-01f, -3.02906334e-01f, -9.07354355e-02f, -1.48440106e-02f, 1.59958890e-03f, 2.87747443e-01f, -1.34651795e-01f, -2.64503807e-01f,
  -7.71174878e-02f, -1.05938777e-01f, -1.67467073e-01f, 1.78617999e-01f, 1.68710388e-02f, -1.74348101e-01f, 4.80495170e-02f, -1.49908438e-01f, -3.57300304e-02f, -7.85310939e-02f,
  3.82894985e-02f, 8.52876678e-02f, 1.84483722e-01f, 2.96968669e-02f, 9.28314216e-03f, -7.83769712e-02f, 4.68007512e-02f, -1.46818995e-01f, -7.64087513e-02f, -1.19848028e-01f,
  -4.01800126e-02f, -2.31856018e-01f, 1.06715728e-02f, -2.53025830e-01f, -4.01052445e-01f, 1.89921752e-01f, 2.57824212e-02f, -1.09853908e-01f, -9.37042311e-02f, -5.17070651e-01f,
  4.08672214e-01f, -2.00597599e-01f, 9.32028443e-02f, 7.80140877e-01f, 2.59170204e-01f, 1.91659868e-01f, -2.36857701e-02f, 1.37193754e-01f, 7.33270720e-02f, -2.62945652e-01f,
  1.58170521e-01f, -5.08875728e-01f, 2.12257415e-01f, -3.16000968e-01f, -5.36456764e-01f, -3.49614114e-01f, 2.16661870e-01f, -1.83475524e-01f, -2.77464718e-01f, -2.06824187e-02f,
  -4.41683143e-01f, -6.15678489e-01f, -1.62955135e-01f, 1.61118805e-01f, -4.51002494e-02f, -9.70314518e-02f, 8.89800787e-02f, -5.77282667e-01f, -2.90294504e-03f, -1.32315412e-01f,
  2.29309425e-01f, -3.44590515e-01f, 2.74141788e-01f, 1.24131441e-01f, 9.99853238e-02f, 1.62690967e-01f, -1.87055171e-01f, 2.67834812e-01f, -1.10916093e-01f, -1.11402839e-01f,
  6.49738312e-02f, -7.37465441e-01f, -2.40551382e-01f, 1.10040329e-01f, 2.79924333e-01f, 3.00697982e-01f, -9.32680145e-02f, -3.86154622e-01f, -3.88045520e-01f, -8.33287537e-02f,
  4.66410827e-04f, 3.80973160e-01f, 1.22078441e-01f, -2.48370007e-01f, 1.61938258e-02f, -2.13733111e-02f, 6.99100494e-02f, -3.84457529e-01f, -2.83573896e-01f, -1.52729034e-01f,
  1.59329981e-01f, -1.54178530e-01f, -3.36951852e-01f, 1.16438650e-01f, 3.84115539e-02f, -3.14766467e-01f, 4.65738058e-01f, -2.94749290e-02f, 2.95410864e-02f, 2.27129906e-02f,
  1.26857147e-01f, 1.23284839e-01f, 9.46420338e-03f, -1.56776533e-01f, -2.29644217e-02f, -3.50097418e-02f, -2.93203350e-02f, -1.97524443e-01f, 2.29090713e-02f, -1.68282434e-01f,
  1.61255583e-01f, 1.66475520e-01f, -6.08573528e-03f, 3.14891860e-02f, -2.74901390e-02f, -2.01039072e-02f, 3.82486396e-02f, 1.30347043e-01f, 9.50120110e-03f, 7.88838640e-02f,
  -1.91300020e-01f, 7.61846527e-02f, 9.63177066e-03f, -2.02126518e-01f, -1.98412448e-01f, -5.39346859e-02f, 1.94449618e-01f, -2.63349235e-01f, 1.68810949e-01f, 2.30287522e-01f,
  -1.96080208e-02f, -9.81729291e-03f, 1.60237208e-01f, -1.94158599e-01f, 2.61804283e-01f, 6.36759326e-02f, 1.20808817e-01f, 3.02298576e-01f, 3.26293141e-01f, -2.58290708e-01f,
  -2.07224861e-01f, -2.98916310e-01f, -7.37063438e-02f, -9.80513245e-02f, -1.90174416e-01f, -1.02692850e-01f, -1.81989670e-01f, 1.77703619e-01f, 6.51025549e-02f, -4.95906640e-03f,
  4.63827521e-01f, -7.53696561e-02f, -3.48396063e-01f, -4.63704579e-02f, 1.92540407e-01f, -5.82627892e-01f, 1.85108647e-01f, -1.77477568e-01f, -2.50589371e-01f, -3.18296611e-01f,
  3.75647724e-01f, 1.18221402e-01f, -5.58066547e-01f, 3.38126928e-01f, 8.92348289e-02f, -7.26907194e-01f, -2.02147827e-01f, -8.59602466e-02f, 2.97694802e-01f, -2.09759668e-01f,
  -5.98962247e-01f, -1.88071713e-01f, -1.11574042e+00f, 1.40597895e-02f, 8.45758393e-02f, 5.21646798e-01f, -3.92490536e-01f, 5.45506589e-02f, -5.79476893e-01f, -4.15267020e-01f,
  9.51408222e-02f, 3.75194818e-01f, -2.12954938e-01f, -3.92601460e-01f, 4.63072360e-01f, -5.79689145e-01f, 2.79093742e-01f, -4.02348638e-01f, -3.97345871e-01f, -4.51002806e-01f,
  2.70373434e-01f, -1.10543914e-01f, -8.29036236e-02f, -1.15564480e-01f, -3.74831110e-02f, -3.16520661e-01f, 8.80822353e-03f, 4.59229618e-01f, -9.83188450e-02f, -6.45557225e-01f,
  -6.06691003e-01f, -6.01327121e-01f, 1.23766854e-01f, 4.22143012e-01f, -2.01178193e-01f, -2.75728494e-01f, 3.31380405e-02f, -5.00915110e-01f, 1.93857491e-01f, 5.93607537e-02f,
  -7.08959341e-01f, 1.57339036e-01f, 2.23368347e-01f, 1.67818442e-01f, 4.31220084e-01f, -1.36916637e-01f, 2.02356502e-01f, 9.42898691e-02f, -8.96685123e-02f, 1.53768703e-01f,
  -1.25209466e-02f, -7.76534155e-02f, 6.08426332e-02f, 7.11236373e-02f, 5.58111548e-01f, 2.40755707e-01f, -3.16096609e-03f, 8.07971433e-02f, 3.16394307e-02f, 2.55137738e-02f,
  -4.75056879e-02f, 8.82995799e-02f, 1.95648983e-01f, 2.27213368e-01f, 7.15966746e-02f, 2.13292092e-01f, 2.02012062e-03f, 8.90985429e-02f, 3.66257243e-02f, 1.67975407e-02f,
  -1.12877779e-01f, 7.61206523e-02f, 2.52731647e-02f, 2.12982535e-01f, -2.46463902e-02f, 9.15740132e-02f, 1.67863294e-01f, 1.15978690e-02f, 2.85115123e-01f, 2.22945154e-01f,
  1.08983135e-02f, 2.09531084e-01f, -1.29291877e-01f, 2.07548663e-01f, 3.60628545e-01f, -2.89346248e-01f, 2.37893432e-01f, 7.10270181e-02f, -3.63314375e-02f, 1.90576389e-01f,
  -9.44404751e-02f, 3.71935666e-01f, 1.96264908e-01f, -2.92126805e-01f, -9.77148488e-02f, 3.04371864e-01f, -3.25640179e-02f, -3.90172414e-02f, 2.10846856e-01f, -7.20383525e-02f,
  -1.03867650e-01f, -7.27551244e-03f, 4.65862639e-03f, -2.20915854e-01f, 4.36676145e-02f, 2.00621501e-01f, -1.18530653e-01f, -4.49327603e-02f, 1.08568981e-01f, -1.09281987e-02f,
  -1.04540763e-02f, 1.73642814e-01f, -5.34651041e-01f, -7.70142913e-01f, -9.33692232e-02f, -1.99835926e-01f, 5.26701868e-01f, 2.17814744e-01f, 4.51472551e-01f, -4.83156949e-01f,
  2.39775747e-01f, -1.15882205e-02f, -2.05659285e-01f, 1.45587623e-01f, 5.62984705e-01f, -3.89449835e-01f, -7.28212297e-02f, 3.71354878e-01f, 3.29339743e-01f, -3.70321602e-01f,
  -1.74055442e-01f, -3.86212856e-01f, 1.16838478e-01f, -2.05924347e-01f, -4.24172342e-01f, -2.36337562e-03f, -5.10603070e-01f, 3.43915552e-01f, -2.35447556e-01f, 1.28290597e-02f,
  3.02138068e-02f, -1.72380984e-01f, 5.08025102e-02f, -2.59867907e-01f, 1.17904563e-02f, -2.29244858e-01f, -3.03655475e-01f, -4.97991107e-02f, -4.31373984e-01f, -3.26076359e-01f,
  -1.53959601e-03f, 5.43492973e-01f, 2.52022520e-02f, -1.55439317e-01f, 1.87602397e-02f, -6.12054706e-01f, -1.29902840e-01f, 3.03013213e-02f, -3.83823812e-02f, -5.22659063e-01f,
  1.63803454e-02f, 1.20653473e-01f, -2.47960046e-01f, -4.22582656e-01f, 9.91275236e-02f, -5.86783767e-01f, -2.48554558e-01f, -9.81389657e-02f, 1.77391410e-01f, -1.61839426e-01f,
  3.25687915e-01f, -1.43761992e-01f, 2.77962297e-01f, 1.93012252e-01f, -3.32107127e-01f, -9.31886286e-02f, -2.12487444e-01f, 4.70388383e-01f, 2.05844551e-01f, 1.41485840e-01f,
  -4.01269943e-02f, -2.07268491e-01f, -7.73709267e-02f, -2.23670393e-01f, 3.44471596e-02f, 1.43508557e-02f, -1.45138279e-01f, -3.72603089e-02f, 2.12916490e-02f, -1.05096430e-01f,
  9.64578614e-03f, -1.41615629e-01f, 9.51718390e-02f, -1.39590546e-01f, -9.58393365e-02f, -4.35561612e-02f, -7.12421909e-02f, 8.85398164e-02f, -3.27286907e-02f, 6.47012591e-02f,
  -1.55692607e-01f, -1.03254259e-01f, -3.26413028e-02f, -2.28049353e-01f, 2.40312263e-01f, 3.50816622e-02f, -4.07454148e-02f, -1.10036224e-01f, -1.51723981e-01f, -2.30175510e-01f,
  1.04600832e-01f, 3.14372838e-01f, 4.85252216e-02f, 1.46112442e-01f, -1.83942080e-01f, 1.29642025e-01f, 1.45857587e-01f, -2.75046527e-01f, -1.12411901e-01f, 1.39940158e-01f,
  2.07317434e-02f, -4.87075113e-02f, 2.10707307e-01f, -3.80395591e-01f, -7.60208815e-02f, 2.27060899e-01f, 1.16738357e-01f, 1.94874063e-01f, 5.07639274e-02f, 2.97371298e-02f,
  -1.36901140e-01f, 2.39345968e-01f, 1.79273228e-03f, -3.30332331e-02f, -4.84331757e-01f, -2.36601517e-01f, -4.07875448e-01f, 6.42021775e-01f, 1.77120417e-01f, 1.91033944e-01f,
  -2.59140790e-01f, -8.17868352e-01f, -1.51789159e-01f, -2.73188323e-01f, -2.84684986e-01f, -1.10851917e-02f, -5.74253917e-01f, 2.45801017e-01f, 5.10610580e-01f, -3.48787755e-01f,
  -2.19599307e-01f, 7.53277093e-02f, 4.96343821e-01f, -3.70789856e-01f, -1.06774000e-02f, -4.94685680e-01f, 6.97353333e-02f, -3.62707675e-01f, -1.26874551e-01f, -3.77182782e-01f,
  -2.27002367e-01f, -1.85871735e-01f, -2.65023738e-01f, -4.05341297e-01f, -4.51309890e-01f, 2.75817007e-01f, -2.15172991e-01f, -3.43927711e-01f, -4.53095138e-01f, 4.00829494e-01f,
  3.17670494e-01f, 4.68511909e-01f, -2.95300514e-01f, 3.53911132e-01f, 1.49221271e-01f, 4.76300865e-01f, 3.75109762e-01f, -1.37493134e-01f, -5.71445048e-01f, -1.15861315e-02f,
  6.25419676e-01f, 9.04452354e-02f, -1.16186313e-01f, -2.35822141e-01f, 5.52583337e-01f, -7.59468880e-03f, 2.38236770e-01f, -1.02861486e-01f, -6.86421990e-01f, -4.05550778e-01f,
  4.25761908e-01f, 2.66830951e-01f, -3.02459300e-01f, -1.83329191e-02f, -2.17484668e-01f, -4.57974643e-01f, 4.86302078e-02f, -5.29940315e-02f, -4.69172865e-01f, -1.84008062e-01f,
  -2.03350574e-01f, 6.11418970e-02f, -1.83135614e-01f, -3.86466354e-01f, -1.48469239e-01f, -2.10164160e-01f, -1.31045908e-01f, 3.44123960e-01f, -1.68229878e-01f, -1.31261259e-01f,
  4.31740060e-02f, -3.11114073e-01f, -3.30700874e-02f, -1.15846597e-01f, 3.67683768e-01f, 4.49161232e-02f, -5.24396375e-02f, -6.21409761e-03f, -2.91264039e-02f, -4.26813737e-02f,
  7.11802989e-02f, -6.21958785e-02f, -6.22362643e-02f, 2.25735493e-02f, 9.20883287e-03f, -1.63399249e-01f, -6.16731420e-02f, 9.97622982e-02f, -4.59489822e-02f, -1.07003592e-01f,
  7.78181553e-02f, -1.04023382e-01f, -1.59516633e-01f, -4.99816239e-02f, 1.83829367e-01f, -8.98433402e-02f, -5.07721044e-02f, 7.11408406e-02f, -7.47681260e-02f, -1.21696547e-01f,
  -6.16042279e-02f, 5.63886687e-02f, -2.50106335e-01f, 2.37913549e-01f, 2.50569940e-01f, 3.90317850e-02f, -1.60102278e-01f, 1.70717254e-01f, 1.83147304e-02f, 5.47969937e-02f,
  -2.57695973e-01f, -1.78949788e-01f, -6.83556125e-02f, -6.05134759e-03f, -2.67145373e-02f, 1.51334077e-01f, 2.36635044e-01f, -2.53484875e-01f, -1.81857437e-01f, -4.52115424e-02f,
  -2.22127900e-01f, -1.03346922e-01f, -9.11935568e-02f, -7.92171434e-02f, -6.07530167e-03f, 2.17725798e-01f, 3.58214200e-01f, -2.77094543e-01f, 5.59043139e-02f, -1.16199858e-01f,
  -2.14207366e-01f, 3.06429639e-02f, -8.03953633e-02f, -7.93019235e-01f, 3.12327236e-01f, -5.05601346e-01f, -2.16355503e-01f, -2.23021835e-01f, 1.57449231e-01f, 1.62218541e-01f,
  -5.98561108e-01f, -2.13725597e-01f, 1.20406859e-01f, 4.87527400e-01f, 1.32322803e-01f, -4.70442533e-01f, 2.69351542e-01f, 4.92211804e-02f, -1.04619160e-01f, -2.78594285e-01f,
  1.55927077e-01f, 1.76945813e-02f, 4.29864258e-01f, 4.07521844e-01f, -7.92174041e-02f, -3.28185827e-01f, 1.65743932e-01f, -5.52237257e-02f, -1.92030370e-01f, -3.20383519e-01f,
  5.31277508e-02f, 1.74659148e-01f, -6.66663274e-02f, -3.18079382e-01f, -2.20123604e-01f, 2.58568615e-01f, -2.93752849e-01f, 2.44367301e-01f, -1.81262687e-01f, 4.75910306e-02f,
  1.10857859e-01f, 8.79914835e-02f, -2.64428794e-01f, 5.03753245e-01f, -2.65782356e-01f, 2.14760467e-01f, -2.13297784e-01f, -4.31718498e-01f, -1.85184568e-01f, 4.06204432e-01f,
  -1.44482106e-01f, 3.35874319e-01f, -2.75937259e-01f, -2.66275883e-01f, 9.16355774e-02f, 8.44326541e-02f, -3.56102347e-01f, -6.47905320e-02f, -4.17698361e-03f, 1.28326684e-01f,
  -1.51310548e-01f, 1.28943190e-01f, 3.10807109e-01f, -2.34211445e-01f, 9.25282836e-02f, -1.63120508e-01f, 9.29963887e-02f, 2.80728579e-01f, -3.61639589e-01f, 1.17113568e-01f,
  1.68574363e-01f, -6.43841624e-02f, 8.77650306e-02f, 1.23279534e-01f, 2.62534693e-02f, 2.60485679e-01f, 4.28555980e-02f, 5.98378927e-02f, 1.53802395e-01f, 3.90095785e-02f,
  -4.11339141e-02f, 3.17868404e-02f, -5.35017923e-02f, 5.02650738e-02f, 6.91536441e-02f, 3.89664769e-02f, 1.20219894e-01f, 2.24488720e-01f, 1.08881205e-01f, 2.05609500e-01f,
  1.90828934e-01f, 6.20049834e-02f, 1.44050224e-02f, -3.77457701e-02f, 1.94072843e-01f, 3.29414487e-01f, 2.59533018e-01f, -1.71119481e-01f, -3.08035195e-01f, 3.37938577e-01f,
  5.54324947e-02f, 2.18714222e-01f, 3.67396355e-01f, 1.84292659e-01f, -1.12510294e-01f, -3.44288230e-01f, -4.25010845e-02f, 5.68462238e-02f, -3.37716378e-02f, -1.53365806e-01f,
  -1.85367182e-01f, -2.98357576e-01f, -5.60504906e-02f, -4.21187952e-02f, 9.85950902e-02f, 1.56384632e-02f, 1.11595996e-01f, -3.70702267e-01f, -9.20050815e-02f, -7.57185444e-02f,
  3.50664437e-01f, -3.48906249e-01f, -1.41272247e-01f, -3.77581418e-01f, 6.03586845e-02f, -1.98031470e-01f, 4.41502333e-01f, 9.30756867e-01f, -1.84111148e-01f, -2.22105071e-01f,
  -5.65359175e-01f, -3.75355810e-01f, -5.81113100e-01f, -1.26693621e-01f, -3.30503106e-01f, -1.90759525e-01f, 4.78768833e-02f, -2.82882601e-01f, -2.99927771e-01f, -1.85450613e-01f,
  -3.15097988e-01f, -5.79819143e-01f, -1.36789363e-02f, 4.39074188e-01f, 8.04675281e-01f, 1.84950486e-01f, -2.07987219e-01f, -2.85632331e-02f, -4.40253466e-01f, 6.06233999e-02f,
  3.65878493e-01f, -5.57885289e-01f, -1.56326413e-01f, 3.00788671e-01f, -4.48637363e-03f, 9.97129232e-02f, -2.84989536e-01f, 1.43635184e-01f, 1.21488713e-01f, -9.44138840e-02f,
  1.15512326e-01f, -3.30549300e-01f, 4.41429578e-02f, 3.82629126e-01f, 1.88876584e-01f, -9.22348946e-02f, -3.77380818e-01f, -2.89913565e-01f, -7.49003084e-04f, 2.69804865e-01f,
  9.13591757e-02f, -3.80867243e-01f, -1.86803356e-01f, 4.75448847e-01f, 4.66595963e-02f, 2.73901492e-01f, 7.78788924e-02f, -8.26559484e-01f, 2.04860866e-02f, 2.64199581e-02f,
  3.25495005e-01f, 4.23254192e-01f, -3.09817851e-01f, -4.45057489e-02f, -2.98232049e-01f, -2.52535231e-02f, -5.38279787e-02f, -3.04747224e-01f, 4.20364559e-01f, -3.92022729e-01f,
  -2.23575532e-01f, -5.01420572e-02f, 1.38192132e-01f, 8.32263827e-02f, 6.37903810e-02f, 1.62654936e-01f, -3.57552320e-01f, -4.60092455e-01f, -1.43675759e-01f, -1.39238775e-01f,
  -1.26636848e-01f, 9.93122309e-02f, 6.10604845e-02f, 1.76629275e-01f, 1.43678665e-01f, -1.56296894e-01f, 5.86347701e-03f, 3.45472060e-02f, 3.39298174e-02f, 1.56245818e-02f,
  3.39297764e-02f, -6.95048273e-02f, 6.21253513e-02f, -5.41336723e-02f, -1.31644532e-01f, -2.35057808e-02f, 3.88562828e-02f, 1.02314260e-02f, 9.31808949e-02f, 2.30043121e-02f,
  -1.45655740e-02f, -6.55506551e-02f, -7.41202980e-02f, 2.63330579e-01f, -2.65313715e-01f, -3.41358066e-01f, 1.00675769e-01f, 2.86229968e-01f, 6.80908412e-02f, -2.22943112e-01f,
  -1.93410441e-01f, -6.91806227e-02f, 1.38400301e-01f, -1.16086684e-01f, -2.42867738e-01f, 3.15604985e-01f, -8.25759768e-02f, 1.95445865e-01f, -3.83128315e-01f, 2.77976215e-01f,
  1.58170417e-01f, -2.19094232e-01f, -2.02997252e-01f, 9.88256782e-02f, 2.22415552e-01f, 5.05029783e-02f, 1.24513082e-01f, 2.24697798e-01f, -4.76942733e-02f, -1.59045011e-01f,
  -3.60731602e-01f, -4.81066763e-01f, -2.44871810e-01f, -5.36313295e-01f, -3.99984151e-01f, 4.28125262e-01f, 1.89244062e-01f, 8.15491080e-02f, 5.12043059e-01f, 3.86636317e-01f,
  -2.34368503e-01f, -5.11152983e-01f, 2.42088437e-02f, -1.83378190e-01f, -5.01132533e-02f, -5.48489749e-01f, 1.51988357e-01f, 2.25597024e-01f, -2.77238011e-01f, 1.47430211e-01f,
  -6.37587130e-01f, 2.61230946e-01f, -2.55078107e-01f, -4.40345332e-02f, -2.77069479e-01f, 1.22310393e-01f, 5.57764530e-01f, 1.38607681e-01f, 2.79584557e-01f, 6.13454580e-01f,
  -4.82951194e-01f, -2.75830507e-01f, 7.65563622e-02f, -2.48291090e-01f, -3.09925079e-01f, -3.50525260e-01f, -1.19123749e-01f, -3.32403004e-01f, -2.00798124e-01f, -3.32001358e-01f,
  -1.97654188e-01f, -2.02206925e-01f, -1.18935697e-01f, -2.78420478e-01f, -1.36647224e-01f, -2.24987879e-01f, 1.91188022e-01f, -3.64701241e-01f, -6.61132395e-01f, 4.77597922e-01f,
  -3.05546731e-01f, -2.31597587e-01f, -5.96988797e-01f, -3.74187678e-01f, -3.09802890e-01f, -3.21325123e-01f, 4.19841968e-02f, -4.31463152e-01f, -5.39652482e-02f, -3.16685796e-01f,
  -5.61027467e-01f, -4.45481926e-01f, 4.12490666e-01f, -3.46541077e-01f, -4.81338173e-01f, -5.74877679e-01f, 1.72979951e-01f, -8.01240373e-03f, -5.65353930e-01f, 2.18035504e-01f,
  -3.16019744e-01f, -2.26393119e-01f, -8.06461796e-02f, -2.46458754e-01f, -2.11183354e-01f, -3.04866999e-01f, -2.05590233e-01f, 2.78500151e-02f, -1.46514803e-01f, -3.54192667e-02f,
  -2.26119086e-01f, -7.79228657e-02f, -1.63318753e-01f, 1.80392727e-01f, -8.59512761e-02f, -2.19515413e-01f, -1.13298178e-01f, -1.45938545e-01f, -1.83371305e-01f, 3.32739670e-03f,
  -1.58285230e-01f, -4.73890733e-03f, -1.47406429e-01f, -4.95733283e-02f, -1.00190006e-02f, -2.14573890e-01f, -2.75819629e-01f, -1.59747358e-02f, -2.91607052e-01f, -2.25472614e-01f,
  -8.64862725e-02f, -7.58169889e-02f, -7.04914331e-02f, -6.20743856e-02f, -1.20818473e-01f, -6.54270127e-02f, 5.50361089e-02f, -9.40122083e-02f, -4.33619954e-02f, -1.66155100e-01f,
  3.45454998e-02f, 6.68276325e-02f, -6.31078407e-02f, -5.09738289e-02f, 2.28798524e-01f, -2.22182915e-01f, -4.47209403e-02f, -4.87918295e-02f, -1.20137737e-03f, -1.82211027e-02f,
  2.82843292e-01f, 2.17192531e-01f, 1.98130459e-02f, -4.14433554e-02f, 2.38468930e-01f, -1.40002266e-01f, -2.39135206e-01f, 2.40614519e-01f, -1.73027188e-01f, -1.17160760e-01f,
  -1.02365933e-01f, 3.31508443e-02f, -1.72008350e-01f, 1.33088097e-01f, -4.50266659e-01f, -2.07823515e-01f, -6.90840483e-02f, -1.31797135e-01f, -2.91860044e-01f, 2.14509755e-01f,
  4.04028296e-01f, -4.08525199e-01f, 5.70685454e-02f, -1.19335055e-01f, 3.75619739e-01f, -4.13610823e-02f, -2.79850841e-01f, -2.06610337e-01f, 1.65798515e-01f, 2.22738516e-02f,
  6.55638754e-01f, -2.47231767e-01f, -1.59259424e-01f, -1.37370035e-01f, -1.67113513e-01f, -7.62796775e-02f, 3.07121396e-01f, -8.91748816e-02f, 2.22879156e-01f, -4.05245006e-01f,
  1.36232853e-01f, 1.08244188e-01f, -3.93917888e-01f, 4.84805405e-01f, -1.09693147e-01f, -2.45762587e-01f, -3.56437266e-01f, 1.81923151e-01f, -2.76413649e-01f, -1.74497351e-01f,
  -1.56166330e-01f, -1.32118598e-01f, -2.00278506e-01f, -1.91917121e-01f, -9.13326815e-03f, -1.34006470e-01f, -2.70216018e-01f, -3.72036129e-01f, 4.17310715e-01f, -1.36428237e-01f,
  2.37162620e-01f, -1.34187177e-01f, 4.62558806e-01f, 5.63297570e-01f, -2.52517145e-02f, -7.96212628e-02f, -4.14467752e-01f, -3.58479559e-01f, -2.65014380e-01f, 1.47089735e-02f,
  -2.38016129e-01f, -6.23648576e-02f, -1.22334853e-01f, 4.40748036e-01f, -1.93441994e-02f, 3.40710521e-01f, -2.32520461e-01f, -1.30512431e-01f, -1.34029230e-02f, -1.48552150e-01f,
  1.95998579e-01f, -2.15941116e-01f, -9.39546600e-02f, -2.50415683e-01f, 4.23303545e-02f, 4.24814187e-02f, 9.09138843e-02f, -1.29570812e-01f, 1.20258078e-01f, 1.28838241e-01f,
  1.37650684e-01f, 3.94257270e-02f, 8.99404138e-02f, 3.28995995e-02f, 3.38809527e-02f, 2.82603763e-02f, 6.21070117e-02f, -3.28336582e-02f, 1.11845896e-01f, 3.58653106e-02f,
  -8.69848803e-02f, 6.57661855e-02f, -1.50105327e-01f, -1.71970874e-01f, 4.31720763e-02f, 2.43231487e-02f, 1.84068486e-01f, -1.60049990e-01f, 1.36719957e-01f, -1.19711317e-01f,
  -8.10386613e-02f, 2.78141588e-01f, 3.31523836e-01f, -5.93989938e-02f, 1.07672632e-01f, -2.11037144e-01f, -1.64264157e-01f, 4.47171740e-02f, 2.20571682e-01f, 2.23715857e-01f,
  2.17838421e-01f, 6.77203909e-02f, 2.23116949e-01f, 8.12436417e-02f, 3.10153127e-01f, -2.67245680e-01f, -3.12740326e-01f, 3.54388624e-01f, -2.75321424e-01f, 2.42449164e-01f,
  3.06273729e-01f, 4.52330559e-02f, 2.47395843e-01f, 1.28443986e-01f, 1.52467072e-01f, 1.59720883e-01f, 2.97423154e-01f, -1.38456300e-02f, 5.13369404e-02f, 4.07010794e-01f,
  -4.79834884e-01f, -4.70721960e-01f, -1.35769872e-02f, 3.78377944e-01f, -1.57620981e-01f, 2.47922435e-01f, -3.92520398e-01f, -1.46427631e-01f, -2.70157158e-01f, 4.76499386e-02f,
  -1.88289136e-01f, -2.02527910e-01f, 4.79779392e-02f, -2.39631251e-01f, -1.76353276e-01f, -5.01371443e-01f, -1.37422264e-01f, 1.94071829e-01f, -2.25059211e-01f, 2.45409459e-01f,
  6.82607144e-02f, -2.05443591e-01f, -2.55510181e-01f, -3.11343312e-01f, 4.13943082e-01f, -1.24155007e-01f, 2.31417507e-01f, -3.32420141e-01f, -1.75690070e-01f, 9.44021568e-02f,
  -5.04379451e-01f, 2.77833100e-02f, -3.41290534e-02f, -3.41192484e-01f, -3.69710982e-01f, -1.27523229e-01f, -4.55938965e-01f, -3.94785374e-01f, 3.73292983e-01f, -3.52453083e-01f,
  3.82454485e-01f, -1.85069278e-01f, -2.68828452e-01f, -5.60720265e-01f, -1.95709273e-01f, -4.32987779e-01f, 1.15691280e+00f, -3.40028167e-01f, -1.88126758e-01f, 1.47535339e-01f,
  -5.76242268e-01f, -1.51528537e-01f, 1.77160710e-01f, -2.62776315e-01f, -2.36982360e-01f, 5.93719423e-01f, -2.15397805e-01f, 7.43703172e-02f, -7.72865862e-02f, 1.47269830e-01f,
  -2.13570699e-01f, -8.98455977e-02f, -1.71532199e-01f, -8.09748247e-02f, -2.77824998e-01f, 2.65042156e-01f, 4.86249067e-02f, -1.23054788e-01f, -7.45849982e-02f, 1.95306927e-01f,
  -2.79375225e-01f, 1.75339207e-01f, -4.09665257e-02f, 6.97843451e-03f, 9.64298286e-03f, -1.38250023e-01f, -1.65007990e-02f, 9.75325406e-02f, 3.30549106e-02f, 1.72527581e-01f,
  4.85345721e-02f, 4.84424531e-02f, 1.21233821e-01f, 7.00038001e-02f, -2.86347419e-03f, -1.69610143e-01f, 1.36558130e-01f, -1.06146008e-01f, 3.07845380e-02f, -2.74058077e-02f,
  -2.70119850e-02f, -5.28872609e-02f, -9.70252417e-03f, 4.75233048e-03f, -3.46752219e-02f, 9.22447594e-04f, 1.17543736e-03f, 1.79626539e-01f, -8.93260539e-02f, -2.94104904e-01f,
  -2.69312859e-01f, -2.51341403e-01f, 2.53722575e-02f, 3.70784141e-02f, -3.08425557e-02f, -8.83189365e-02f, 2.61637866e-02f, -2.44601592e-01f, -2.51583278e-01f, -1.91861242e-01f,
  -1.70336723e-01f, -1.20956190e-01f, -1.40647963e-01f, 2.29632586e-01f, 1.70828979e-02f, -7.73601905e-02f, -2.12181598e-01f, -1.38281226e-01f, -1.03346854e-01f, 1.02836974e-01f,
  -2.00201124e-01f, -3.88190262e-02f, -3.71068269e-01f, 3.50819081e-02f, -2.84275651e-01f, -7.38261119e-02f, -1.61948174e-01f, -3.54432076e-01f, 1.08437315e-01f, 2.79962599e-01f,
  2.74379134e-01f, 8.55138972e-02f, -2.31756866e-01f, -1.56774111e-02f, 3.96852136e-01f, -8.75147581e-02f, -6.79962993e-01f, -3.33786421e-02f, -2.38555178e-01f, 5.67289650e-01f,
  -5.25482714e-01f, -1.96936522e-02f, -1.01008512e-01f, 2.69480050e-01f, 4.91190583e-01f, 3.12840432e-01f, -3.85573745e-01f, -2.90241450e-01f, 5.02492127e-04f, -1.80349186e-01f,
  3.84314150e-01f, -8.13574251e-03f, -7.05316514e-02f, -1.46060035e-01f, -5.63871954e-03f, 1.62222356e-01f, 1.68339983e-01f, -4.98680800e-01f, -6.04372144e-01f, -1.11345828e-01f,
  -2.92657405e-01f, -1.42637566e-01f, -5.46519458e-01f, 4.57889676e-01f, -1.48056135e-01f, -1.68009195e-02f, -3.96360546e-01f, -7.49890387e-01f, -3.78973603e-01f, -8.29761550e-02f,
  -2.45530128e-01f, -1.45421222e-01f, -2.03441739e-01f, -2.28095397e-01f, -4.77609038e-01f, 3.82688284e-01f, 5.00155270e-01f, -1.67822521e-02f, 3.54472250e-02f, -4.49887931e-01f,
  2.78270662e-01f, 6.58141673e-01f, -1.66819111e-01f, -4.43173081e-01f, 1.57343596e-01f, -1.37964398e-01f, 3.09126258e-01f, 1.89439021e-02f, -6.16892338e-01f, 3.89439285e-01f,
  -2.30670393e-01f, 1.52313888e-01f, 3.63848120e-01f, -7.27232918e-02f, -1.75083488e-01f, -2.70811558e-01f, -3.42094272e-01f, -4.94597286e-01f, -3.90117645e-01f, -1.26951095e-02f,
  1.45479839e-03f, -1.58336889e-02f, 1.11939482e-01f, 1.41663045e-01f, 2.35707574e-02f, -3.29257324e-02f, 1.55194908e-01f, 1.66516617e-01f, -6.26614839e-02f, 3.68140079e-02f,
  1.28009424e-01f, 7.85063058e-02f, 2.96829622e-02f, 8.91452059e-02f, 1.14452258e-01f, 8.11451003e-02f, 8.06290805e-02f, -5.45893013e-02f, -5.47362529e-02f, 9.21394452e-02f,
  4.17845286e-02f, -1.31044006e-02f, 4.37940471e-02f, 1.58861533e-01f, 5.61767956e-03f, -2.12107360e-01f, 1.95746288e-01f, -1.06123783e-01f, 1.46249652e-01f, 7.71906972e-02f,
  2.06063345e-01f, -2.88896501e-01f, 2.44367942e-02f, 2.36858204e-01f, -1.07860133e-01f, -5.89361787e-02f, -1.15843248e-02f, -2.96095341e-01f, -2.67601795e-02f, 6.36452883e-02f,
  -1.01582855e-01f, 1.39852434e-01f, -1.26864582e-01f, 1.21167354e-01f, -1.88803792e-01f, 2.15842918e-01f, -2.31932446e-01f, -2.21698135e-01f, -1.27790883e-01f, -2.03954414e-01f,
  -4.17255074e-01f, 3.79983842e-01f, 2.89438218e-01f, -3.04366142e-01f, 4.33305532e-01f, -5.46823561e-01f, 4.53062840e-02f, -4.44738746e-01f, -1.01116188e-01f, -1.37388200e-01f,
  -2.55577832e-01f, -2.25142926e-01f, -2.38924146e-01f, -1.22565202e-01f, -2.54800409e-01f, 9.82891619e-02f, -2.85948187e-01f, -3.53569478e-01f, -2.16088757e-01f, -2.34852523e-01f,
  -6.05980754e-01f, -3.59161258e-01f, -2.94604659e-01f, 2.50268519e-01f, 3.12558323e-01f, -3.17835659e-01f, -1.81146860e-01f, -2.24198014e-01f, -8.39615390e-02f, -4.35882062e-01f,
  -3.33286166e-01f, -3.35447818e-01f, 1.86311752e-01f, -3.27213764e-01f, 1.10557288e-01f, 1.63459897e-01f, 4.64532256e-01f, 4.13485318e-01f, -2.59940922e-01f, 4.75344896e-01f,
  6.01515889e-01f, -2.23787308e-01f, -1.84405163e-01f, -4.78883147e-01f, 2.73094364e-02f, -3.13671619e-01f, 2.04860568e-01f, 3.70303363e-01f, 1.90734431e-01f, -3.10169607e-01f,
  -4.36232150e-01f, -3.01030844e-01f, -1.84338719e-01f, -3.93060774e-01f, -1.79405808e-01f, -3.96005213e-01f, -2.99741983e-01f, -2.05739021e-01f, 1.41874671e-01f, -4.54209656e-01f,
  1.71077028e-01f, -2.39491999e-01f, -8.10358375e-02f, -1.60821870e-01f, -4.38814044e-01f, -8.19332451e-02f, 3.10051739e-01f, -2.28404298e-01f, -1.86525896e-01f, -3.15579444e-01f,
  2.23959148e-01f, -2.41022512e-01f, -1.96505412e-01f, -3.12179953e-01f, -4.20982003e-01f, 2.42791340e-01f, -3.74111861e-01f, -3.15169960e-01f, 4.03538756e-02f, 2.84631774e-02f,
  7.17700645e-02f, -5.45995263e-03f, 8.03499073e-02f, -1.03641540e-01f, 4.85058874e-02f, -8.19513276e-02f, -2.68772215e-01f, 3.56063135e-02f, 2.32826080e-03f, -1.02535233e-01f,
  -6.69001490e-02f, 2.67705098e-02f, 1.15712211e-01f, 1.23314232e-01f, -2.67922711e-02f, 1.22176111e-02f, -3.49133722e-02f, 1.99496433e-01f, 1.40585706e-01f, 1.43724933e-01f,
  -9.77961197e-02f, 8.74915943e-02f, 4.46557254e-02f, -1.98243782e-01f, 4.37396944e-01f, 2.73948818e-01f, -5.05677983e-02f, 9.19941813e-02f, -3.48382056e-01f, 4.28784378e-02f,
  -1.85414776e-01f, -2.67209053e-01f, 1.37072653e-01f, 1.36526629e-01f, -2.40724295e-01f, 2.31751442e-01f, 2.47639194e-01f, -1.43648937e-01f, 2.69005507e-01f, -2.24824362e-02f,
  2.10847706e-01f, 1.89652592e-01f, 1.37426540e-01f, -5.97466230e-02f, -3.78432199e-02f, 1.77394941e-01f, 1.08972780e-01f, 1.00361980e-01f, -2.53194565e-04f, -2.57388830e-01f,
  -3.34749609e-01f, 3.10932487e-01f, -5.50538935e-02f, 1.00868471e-01f, -3.74863371e-02f, -5.56170978e-02f, 9.43988115e-02f, 2.47045845e-01f, -4.67498004e-01f, 3.80631506e-01f,
  -2.92046160e-01f, 2.88092107e-01f, 1.78941220e-01f, -1.35981157e-01f, 2.59676814e-01f, -2.35198274e-01f, -4.79407161e-01f, 4.73833948e-01f, -2.69400060e-01f, 4.21388477e-01f,
  -4.06120896e-01f, -4.44521874e-01f, -4.67421353e-01f, 5.05302966e-01f, 8.76071155e-02f, -3.99867930e-02f, -3.70275485e-03f, -1.03651606e-01f, 1.04256816e-01f, -2.46448249e-01f,
  -3.98220122e-01f, -1.40900105e-01f, -1.20671093e-01f, -3.71140093e-01f, -8.61952305e-02f, 5.88656843e-01f, -2.38417611e-01f, 2.09726110e-01f, -2.42216796e-01f, 2.84449965e-01f,
  -2.97931731e-01f, 1.42395839e-01f, 1.76145583e-01f, -1.80006489e-01f, 4.59866151e-02f, 8.84735212e-02f, -2.86036521e-01f, -7.90142715e-02f, 5.39753258e-01f, 5.57520390e-01f,
  -4.30439115e-01f, -2.89431572e-01f, -6.19055390e-01f, -2.75938421e-01f, -1.89965487e-01f, 3.83530021e-01f, -6.08109951e-01f, -3.37419420e-01f, 4.00181770e-01f, -3.35199058e-01f,
  -2.84259737e-01f, -3.05629432e-01f, -5.62236726e-01f, -1.54358357e-01f, -1.39595449e-01f, -4.80430536e-02f, 1.42557383e-01f, -2.40658298e-01f, -3.59130502e-01f, -4.29450035e-01f,
  1.90730453e-01f, -2.38713063e-02f, -5.12635484e-02f, -2.28719562e-01f, 5.32307066e-02f, 3.45090896e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.44967699e-01f, 1.20161757e-01f, 1.67830829e-02f, -1.02860853e-01f, -1.40991256e-01f, 3.15156728e-02f, 1.92515533e-02f, -5.40314391e-02f, -6.27617911e-02f, 3.24111357e-02f,
  8.95887911e-02f, 2.78925579e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    