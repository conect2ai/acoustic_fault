/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.81935126e-01f, -3.65705401e-01f, 4.94659171e-02f, -2.04729274e-01f, 1.40067413e-01f, -1.97402611e-01f, -1.01232581e-01f, -1.15982793e-01f, -1.35469317e-01f, -2.91679621e-01f,
  -2.25509908e-02f, -1.11496896e-01f, -1.40982345e-01f, -1.50130287e-01f, -8.19962025e-02f, -1.94680929e-01f, -4.27442603e-02f, -9.16946903e-02f, -1.81464590e-02f, -5.63026071e-02f,
  8.31445977e-02f, -1.10272638e-01f, 5.85742593e-02f, -1.17833596e-02f, 1.52765855e-01f, 3.85367833e-02f, 4.31333110e-02f, 7.20153153e-02f, 9.65921283e-02f, -4.07520384e-02f,
  3.04520857e-02f, -8.87672082e-02f, 1.44990131e-01f, -2.78530717e-02f, -4.67321202e-02f, 3.08721550e-02f, 1.02854902e-02f, 2.76318286e-02f, 3.59249450e-02f, -1.07887574e-03f,
  -6.49736496e-03f, -1.98699953e-03f, -4.95499708e-02f, -2.72527449e-02f, 1.35182319e-02f, 3.92771848e-02f, 2.68240226e-03f, -5.35937957e-03f, 3.27388868e-02f, -1.79284848e-02f,
  -1.09445136e-02f, -3.92602012e-02f, 2.98472885e-02f, -3.33080366e-02f, 4.53716964e-02f, -5.57393916e-02f, -5.44272922e-02f, 8.58768914e-03f, 2.10901126e-02f, -4.72086407e-02f,
  2.57798843e-02f, -2.63763219e-02f, -6.27957331e-03f, -2.19063051e-02f, -3.09810955e-02f, 7.05606788e-02f, -2.98227165e-02f, 2.12405436e-02f, 2.61471774e-02f, -1.08282231e-02f,
  3.48339579e-03f, 2.53505353e-02f, -4.73822560e-03f, 3.60201411e-02f, -3.50132436e-02f, 4.97132502e-02f, -7.80922640e-03f, -4.83711204e-03f, 2.54591405e-02f, -7.99603853e-03f,
  -5.98085928e-04f, 3.30562121e-03f, 5.30797020e-02f, -1.15318224e-03f, 2.13822834e-02f, -9.49825905e-03f, -2.15338413e-02f, 4.54549044e-02f, 5.51393144e-02f, 5.04155364e-03f,
  -2.36416742e-01f, -3.13475192e-01f, -7.26483837e-02f, 9.66485068e-02f, 1.46436999e-02f, 2.32869145e-02f, -4.07163650e-02f, 4.13468517e-02f, -8.26732889e-02f, 1.64287966e-02f,
  3.46920788e-02f, 4.30152602e-02f, 5.03112469e-03f, 1.53518924e-02f, -3.99714820e-02f, -6.42997995e-02f, -6.06883131e-02f, 6.17063232e-02f, -6.17738068e-02f, -1.94255766e-02f,
  5.55061735e-02f, -1.02697005e-02f, -1.28283873e-02f, 3.18661109e-02f, 3.19072455e-02f, 6.52404204e-02f, 1.00826491e-02f, 2.58527845e-02f, -1.72131769e-02f, -3.58869173e-02f,
  7.43060708e-02f, 4.48884740e-02f, -1.03354059e-01f, 3.20829600e-01f, 2.97101811e-02f, -2.65465766e-01f, -2.07884759e-01f, 8.59902650e-02f, -3.23859625e-03f, 4.23982739e-03f,
  3.71361780e-03f, 1.31200135e-01f, -1.37699712e-02f, 9.59469229e-02f, 2.49199301e-01f, 5.56353442e-02f, 2.96578538e-02f, 1.48459040e-02f, 9.06202570e-02f, 1.00305162e-01f,
  1.12253554e-01f, 4.60993499e-02f, 8.89455006e-02f, 4.86688353e-02f, 9.77680366e-03f, 9.63756368e-02f, 2.23735094e-01f, 1.13759898e-01f, 4.47397828e-02f, -8.03576037e-03f,
  -2.09792688e-01f, -2.01448724e-02f, 1.14333052e-02f, -2.52474658e-02f, 2.88253780e-02f, -5.28525226e-02f, -4.69966270e-02f, -2.41887290e-02f, -7.29097007e-03f, 2.98298672e-02f,
  -1.90823786e-02f, -6.07692346e-04f, -1.24309100e-02f, 5.96817546e-02f, -5.75938597e-02f, 5.12913540e-02f, -5.24762161e-02f, 2.12330315e-02f, -1.76346228e-02f, -3.37548032e-02f,
  1.75985955e-02f, 2.53418623e-03f, -7.69459351e-04f, -1.33560393e-02f, 2.22173072e-02f, 1.28914546e-02f, -7.43667781e-03f, -8.77598766e-03f, 2.25716904e-02f, -6.60453085e-03f,
  1.64883435e-02f, 8.23217817e-03f, -3.10384948e-02f, 8.00698251e-03f, -3.44757698e-02f, 4.09754505e-03f, -8.49387888e-03f, -4.45569567e-02f, 7.19197169e-02f, 3.13351825e-02f,
  -2.05694959e-02f, 3.66293155e-02f, 1.77526679e-02f, -1.17265200e-02f, 1.69822276e-02f, -4.34338152e-02f, -4.60057799e-03f, 1.73010118e-02f, -1.30017074e-02f, -6.08504657e-03f,
  2.88519114e-02f, -4.71791485e-03f, -3.30667235e-02f, -1.02136560e-01f, -3.69161218e-02f, 4.72913086e-02f, -3.10645089e-03f, 1.74741559e-02f, 4.62107398e-02f, -2.68585160e-02f,
  5.88500947e-02f, 2.28901044e-01f, 1.09717026e-02f, -2.19121352e-02f, -1.30124735e-02f, 2.99794134e-03f, 4.63952795e-02f, -7.14868307e-03f, 3.24669257e-02f, -2.04540286e-02f,
  4.67274245e-03f, -5.61292330e-03f, 1.08572999e-02f, 3.65430042e-02f, 2.02924851e-02f, 1.04602147e-03f, 4.59001213e-03f, 6.32558158e-03f, 5.94758242e-02f, 8.79150629e-02f,
  3.92065533e-02f, -2.65737362e-02f, 2.66198479e-02f, -2.45280825e-02f, -1.23856449e-02f, -3.80470417e-02f, -5.67992358e-03f, -1.60437059e-02f, -9.56330914e-03f, -3.03948503e-02f,
  5.60743570e-01f, -1.45467659e-02f, 1.79736093e-01f, -6.35964051e-02f, 1.01149641e-01f, 2.77328670e-01f, 8.54134858e-02f, -5.26361354e-02f, 5.75313158e-02f, 4.70285723e-03f,
  1.30912200e-01f, 3.55840325e-02f, -3.59326787e-02f, -7.76399747e-02f, 6.47563413e-02f, -9.14509147e-02f, 2.42853630e-02f, -1.10975243e-02f, -2.78551355e-02f, 5.64227588e-02f,
  -5.93404705e-03f, -3.73925045e-02f, -6.25524893e-02f, -4.57217544e-02f, 1.46852992e-02f, 2.31894143e-02f, 1.01225890e-01f, -6.76213801e-02f, -2.83774268e-02f, 6.36109039e-02f,
  4.21918137e-03f, 6.81501180e-02f, 6.69186264e-02f, 2.55891327e-02f, 2.76499018e-02f, 7.42063671e-02f, 7.52158463e-02f, 8.87021516e-03f, -6.21954873e-02f, -3.82749215e-02f,
  3.97218317e-02f, -9.40723997e-03f, -1.33091304e-03f, -6.03497550e-02f, 1.71510614e-02f, -3.56659591e-02f, -3.92738692e-02f, -4.06095535e-02f, -3.31660956e-02f, -2.16501355e-02f,
  -7.45769590e-02f, 4.36791545e-03f, -1.36524774e-02f, -1.12298718e-02f, -4.39389125e-02f, -4.67169890e-03f, 7.07687065e-02f, 2.44266652e-02f, 3.83629873e-02f, 2.30526738e-02f,
  8.52320939e-02f, 2.87934598e-02f, -4.21493314e-03f, -1.40698971e-02f, 4.31902371e-02f, -4.51061055e-02f, 4.23246762e-03f, -1.28082158e-02f, -3.33531350e-02f, 1.48337390e-02f,
  1.14091476e-02f, -1.03362733e-02f, -9.59660672e-03f, 9.57025867e-03f, -7.97328353e-03f, 1.61607545e-02f, 2.28962917e-02f, 2.68382598e-02f, 9.24031157e-03f, -3.94721236e-03f,
  -2.15935390e-02f, 1.71095561e-02f, 3.23903072e-03f, 1.52253788e-02f, 2.40588654e-02f, -1.23164179e-02f, 2.69144475e-02f, -6.59224540e-02f, -3.44247818e-02f, 3.37339789e-02f,
  3.06865312e-02f, 1.56504944e-01f, -3.04296538e-02f, 1.08386762e-02f, -3.04370001e-02f, -1.18694932e-03f, -6.79332912e-02f, 7.62366131e-03f, 1.70304887e-02f, 3.40983532e-02f,
  3.68641317e-02f, -7.34965736e-03f, 4.88199852e-02f, -1.14747920e-04f, 7.12381303e-02f, 3.91196087e-02f, 3.96239534e-02f, 1.62224714e-02f, 1.20066619e-02f, -1.24662677e-02f,
  -1.01775536e-02f, 7.89894313e-02f, -1.17441332e-02f, -5.63447189e-04f, 2.34950148e-02f, -2.15765573e-02f, 8.51007551e-03f, -1.75061580e-02f, 5.23898751e-02f, 4.71684849e-03f,
  3.70158494e-01f, -4.14158925e-02f, -1.26398981e-01f, 1.51633114e-01f, 1.26730546e-01f, 1.73587278e-01f, 1.90119058e-01f, 9.99995098e-02f, 2.22370103e-01f, -4.68160659e-02f,
  1.12943515e-01f, -9.70896184e-02f, -8.42421595e-03f, 9.14319977e-02f, 2.18237281e-01f, 4.22658399e-02f, 1.39486805e-01f, -4.85901460e-02f, 7.55499825e-02f, 8.64777565e-02f,
  9.41504240e-02f, 1.27854854e-01f, -8.64836201e-02f, 6.38270900e-02f, 2.39430275e-02f, -6.97173774e-02f, 1.60967056e-02f, -6.67469157e-03f, -1.17105477e-01f, 1.78156756e-02f,
  -2.04787590e-02f, -1.86171997e-02f, -2.62272521e-03f, -2.47832034e-02f, -1.63913183e-02f, -1.06242308e-02f, -3.49182263e-02f, 4.94362367e-03f, 3.87139665e-03f, -4.17449661e-02f,
  -6.35534106e-03f, -2.61674989e-02f, -9.46251955e-03f, 1.99600146e-03f, 6.59467652e-02f, 4.05298024e-02f, -1.62729770e-02f, -1.76982768e-02f, 1.93342995e-02f, -2.55821813e-02f,
  -4.26151641e-02f, -3.75916995e-02f, 5.54212322e-03f, -4.23293188e-02f, -1.00670327e-02f, 2.23702025e-02f, -7.88839906e-03f, -8.16368163e-02f, -1.45857073e-02f, 4.37651165e-02f,
  4.77637947e-02f, 3.66269462e-02f, -6.42982963e-03f, -6.71552569e-02f, -1.58641711e-02f, 1.27040511e-02f, -4.66023311e-02f, -5.69134671e-03f, 8.66603479e-03f, 7.23006427e-02f,
  -2.41172453e-03f, 3.06248385e-03f, 1.79278310e-02f, -3.74270137e-03f, -9.17165540e-03f, 2.25076508e-02f, 3.18310522e-02f, -6.40725046e-02f, 5.81588037e-02f, -1.21073257e-02f,
  -2.25045066e-03f, 5.75663149e-02f, -2.69720443e-02f, -3.84602807e-02f, 2.48252098e-02f, -9.48934630e-03f, -1.00679407e-02f, -2.58872174e-02f, 5.50970100e-02f, 5.99217750e-02f,
  -9.10171494e-02f, 1.16787180e-01f, 2.82275248e-02f, 4.75330837e-02f, 4.75155516e-03f, -3.25278491e-02f, -4.86413809e-03f, 8.06447864e-03f, -6.70252182e-03f, 3.33077461e-02f,
  -1.11850416e-02f, -5.34989499e-03f, 2.52697319e-02f, 7.34452903e-03f, -6.90277573e-03f, 2.94881035e-02f, -1.06362654e-02f, 2.35835239e-02f, -1.09844143e-02f, -2.00269185e-02f,
  -1.83873344e-02f, -2.28238422e-02f, 1.03502776e-02f, -9.26071871e-03f, 7.61987350e-04f, -4.26543318e-02f, -5.76721039e-03f, 1.20493909e-02f, 1.27106840e-02f, -2.25204788e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.86905693e-02f, 1.76654950e-01f, -2.77559031e-02f, -1.53855607e-01f, 6.57631364e-03f, 6.14854507e-02f, 1.25962466e-01f, 1.71242014e-01f, 1.71502933e-01f, 6.16749786e-02f,
  -1.29759744e-01f, -7.20279217e-02f, -2.19788998e-02f, -4.32610065e-02f, -3.31282690e-02f, 1.03912257e-01f, 5.28157912e-02f, -1.54766798e-01f, 8.33837986e-02f, -1.18314117e-01f,
  2.08049659e-02f, -8.32507983e-02f, -5.18602356e-02f, 9.62894782e-02f, -8.70644897e-02f, -1.21775620e-01f, -1.80472165e-01f, -7.32411351e-03f, -5.91731034e-02f, 5.23184501e-02f,
  -5.58988675e-02f, 2.92818658e-02f, -8.35827962e-02f, 8.23343396e-02f, 8.81792232e-03f, -7.07385093e-02f, -6.03987016e-02f, 1.57186277e-02f, -2.09162850e-02f, -1.36378743e-02f,
  -5.33473901e-02f, -1.25475377e-02f, 4.11685035e-02f, -2.23069116e-02f, 6.35409281e-02f, -6.94994181e-02f, 1.00755692e-02f, -6.26963377e-02f, 2.43977550e-02f, -1.62570775e-02f,
  -2.39658654e-02f, -1.59524739e-01f, 1.45530216e-02f, -4.07409295e-02f, -1.07452087e-02f, 3.81582119e-02f, -4.93352935e-02f, -9.70831215e-02f, -3.79207954e-02f, 1.04667116e-02f,
  -5.10182567e-02f, 1.11206643e-01f, 9.77887064e-02f, 2.94070020e-02f, 4.76715863e-02f, 5.40939458e-02f, -4.58639711e-02f, -2.67934538e-02f, -7.51749650e-02f, -5.54700121e-02f,
  9.35273152e-03f, -9.79360715e-02f, 3.85256000e-02f, 1.51400117e-03f, -7.05831498e-02f, -3.88761563e-03f, -2.13426072e-02f, -8.83089751e-02f, -6.74517751e-02f, 1.69830024e-02f,
  3.85358110e-02f, -4.78319377e-02f, 3.56498696e-02f, 5.63315377e-02f, -2.24975776e-02f, 7.91030179e-04f, -5.05888499e-02f, -2.61731837e-02f, -1.20260324e-02f, 6.73648790e-02f,
  8.87337178e-02f, 1.16122894e-01f, -2.97815297e-02f, -8.90388638e-02f, 4.98519838e-02f, 1.21030034e-02f, 3.64101455e-02f, -6.16802908e-02f, 2.45321523e-02f, -6.52694888e-03f,
  -1.75284594e-02f, 2.00339351e-02f, -1.86198931e-02f, -4.67912555e-02f, 4.12739404e-02f, 4.24376205e-02f, 9.72336307e-02f, -6.07226929e-03f, 6.04022890e-02f, -4.16790433e-02f,
  -5.43536358e-02f, -6.82335580e-03f, 2.34623663e-02f, -2.03546276e-03f, -5.65402545e-02f, -3.82931083e-02f, 9.62395146e-02f, -5.70303835e-02f, -3.71602550e-02f, 2.36496106e-02f,
  1.38443470e-01f, -2.01893523e-01f, 1.38966545e-01f, 4.01108474e-01f, 2.58027148e-02f, -1.25084370e-01f, -3.27966452e-01f, 1.14328809e-01f, -1.34302095e-01f, -2.48298675e-01f,
  3.45258154e-02f, -8.04654509e-02f, -2.93814868e-01f, 1.79192960e-01f, 2.39232808e-01f, -1.70691356e-01f, 1.75117269e-01f, 3.82798202e-02f, -4.15059598e-03f, 1.40395612e-01f,
  2.37460524e-01f, 2.45505244e-01f, 1.79707140e-01f, 2.04874456e-01f, 2.36577109e-01f, 2.16194302e-01f, 1.71427965e-01f, -1.23184398e-01f, 2.90787369e-01f, 3.27741802e-02f,
  9.54835266e-02f, 3.42316031e-02f, -1.72973890e-02f, 1.89812146e-02f, 6.04184419e-02f, 2.50444822e-02f, 6.50154352e-02f, 6.43175393e-02f, 3.02289017e-02f, -6.35589585e-02f,
  -3.32202390e-02f, 7.67251104e-02f, 6.21463582e-02f, 3.16622816e-02f, 9.33042467e-02f, 5.73494621e-02f, -1.02364030e-02f, -7.56852180e-02f, -3.48058231e-02f, 2.49228291e-02f,
  -4.47776094e-02f, 6.90522045e-03f, 9.85960737e-02f, -4.63158078e-02f, 2.09925976e-02f, 5.85127287e-02f, -1.11245243e-02f, -7.15042651e-02f, 4.19145636e-03f, 6.35682140e-03f,
  2.26526465e-02f, 4.11753450e-03f, -3.23417075e-02f, -9.42571647e-03f, 1.47410706e-02f, -2.83539295e-02f, -7.07789045e-03f, -2.79444922e-02f, -4.50251475e-02f, 2.97069382e-02f,
  6.00844994e-02f, 1.00611746e-02f, 5.28113218e-04f, -5.09312004e-02f, 7.43887061e-03f, -5.84253930e-02f, 6.42998889e-02f, -3.47652286e-02f, -9.33726318e-03f, -2.29988620e-02f,
  -2.71145683e-02f, 1.84219126e-02f, 3.58527824e-02f, 5.17495982e-02f, 1.38142181e-03f, 1.50869284e-02f, 4.68416028e-02f, -4.18745689e-02f, 2.30173171e-02f, -3.14220637e-02f,
  1.81294307e-02f, 6.12792186e-02f, -1.41126430e-02f, -2.28771232e-02f, -2.21683048e-02f, 5.32983467e-02f, 2.34859493e-02f, 8.42330530e-02f, 5.84022664e-02f, 3.77626196e-02f,
  3.57960239e-02f, -8.39789733e-02f, 1.43109318e-02f, 2.67468877e-02f, 1.05277315e-01f, -5.21832481e-02f, 3.61997262e-02f, 6.18917011e-02f, -2.61771702e-03f, 1.95525754e-02f,
  1.76064810e-03f, 1.02058910e-02f, 1.14612728e-02f, 4.32211868e-02f, -2.19656024e-02f, -2.02267673e-02f, 2.81362366e-02f, -5.06692380e-02f, 4.97912876e-02f, -6.78142309e-02f,
  -2.01403901e-01f, -1.80278882e-01f, -1.11556508e-01f, -7.97851533e-02f, -3.26041766e-02f, -4.36761945e-01f, -4.21986043e-01f, -1.60378456e-01f, 1.77418604e-01f, -6.46101981e-02f,
  -7.99612626e-02f, 2.05696076e-01f, 1.24167278e-01f, -2.70971209e-01f, 1.36311397e-01f, 2.60692954e-01f, -3.58606428e-01f, -1.45646274e-01f, 1.35021940e-01f, -1.48409158e-01f,
  4.18228284e-02f, -2.08201811e-01f, -5.32313474e-02f, -1.06380343e-01f, -2.67366916e-01f, 3.39392610e-02f, 7.89246559e-02f, -2.05486223e-01f, -1.78215489e-01f, -9.60762426e-02f,
  -1.83325596e-02f, 1.83257684e-01f, -2.96401605e-02f, -4.44414727e-02f, -1.94799546e-02f, -2.80811805e-02f, -4.95978445e-02f, 3.26906517e-02f, 1.77095886e-02f, -1.57392193e-02f,
  -1.11690555e-02f, 5.33399321e-02f, -1.05349943e-02f, 6.77052932e-03f, -5.06732753e-03f, 3.04464772e-02f, -1.49365449e-02f, 1.29624717e-02f, -2.64597200e-02f, -1.04450369e-02f,
  -1.15547711e-02f, -4.82936017e-02f, -7.36191571e-02f, -1.09006939e-02f, 3.05289533e-02f, 6.32653432e-03f, 8.45701322e-02f, -5.68990894e-02f, 1.55426878e-02f, -2.43699532e-02f,
  2.40947083e-02f, 7.20270500e-02f, -5.90448305e-02f, -1.14726638e-02f, 3.06987055e-02f, -1.35581503e-02f, 5.94108962e-02f, -6.15667133e-03f, 2.22054701e-02f, 3.97380330e-02f,
  1.14420587e-02f, 3.38895470e-02f, -9.09573457e-04f, 4.93280264e-03f, -8.56173187e-02f, 5.92113435e-02f, -2.47882176e-02f, 1.37880435e-02f, -6.85684532e-02f, 2.78848205e-02f,
  -7.15950597e-03f, -4.42466661e-02f, 4.14474458e-02f, -1.14116520e-02f, 4.68307845e-02f, 1.11498050e-01f, -4.29440103e-03f, 2.69471165e-02f, -3.42827365e-02f, -5.28100841e-02f,
  -3.36054191e-02f, 1.28661375e-02f, -5.18708192e-02f, -5.02807163e-02f, 7.74644688e-02f, -5.81950434e-02f, -3.27628404e-02f, -3.55918109e-02f, 9.24840663e-03f, -5.33915162e-02f,
  -3.49821933e-02f, -8.53462070e-02f, -1.95035338e-02f, 1.18964901e-02f, 2.35473234e-02f, 1.83122512e-02f, -4.22630273e-02f, 1.63836572e-02f, -4.14260253e-02f, 3.84915210e-02f,
  4.43139253e-03f, 3.27383121e-03f, 8.87686908e-02f, 5.05680824e-03f, 5.38117252e-02f, -3.98168080e-02f, -3.13307978e-02f, -3.40978894e-03f, 4.56173792e-02f, 1.09722689e-02f,
  3.76757383e-01f, -1.10259559e-02f, 4.54189889e-02f, 8.02395791e-02f, 3.34139429e-02f, 4.83827069e-02f, 8.25451512e-04f, 9.39933863e-03f, 2.21832078e-02f, -7.80590251e-02f,
  -5.86235262e-02f, -7.78878061e-03f, -3.89791690e-02f, -1.04146041e-01f, 1.35842234e-01f, -1.20899482e-02f, 8.55705142e-02f, 5.72335497e-02f, -4.99590337e-02f, -5.80598414e-02f,
  -8.53169784e-02f, 6.35895133e-02f, 2.93734260e-02f, -2.85618342e-02f, -1.41093293e-02f, 6.98776171e-02f, 2.02502739e-02f, 3.41435894e-02f, -8.13040808e-02f, 9.46880654e-02f,
  -3.37568335e-02f, 2.02679099e-03f, -9.56327245e-02f, -1.40695229e-01f, 6.35083765e-02f, -6.02691919e-02f, -4.85784635e-02f, 8.58510584e-02f, 1.97484810e-02f, 1.69778168e-02f,
  -1.19881108e-01f, 4.57436591e-02f, 2.33962536e-02f, 1.33008316e-01f, -1.85105987e-02f, 1.98325720e-02f, 3.39370966e-02f, -9.73270312e-02f, 4.49028797e-02f, 9.94851626e-03f,
  -7.50721199e-03f, 3.24534699e-02f, 3.94793740e-03f, 5.82046360e-02f, -3.80418487e-02f, 5.62974326e-02f, -3.33983451e-02f, 3.62603366e-02f, -8.86465311e-02f, 5.33313416e-02f,
  2.13662488e-03f, -6.50285836e-03f, 6.20386302e-02f, 3.99554260e-02f, 1.04661481e-02f, -4.25212681e-02f, 3.26465741e-02f, 2.23125946e-02f, 6.49307370e-02f, -7.65128136e-02f,
  3.57588753e-03f, -8.50691833e-03f, -8.34978223e-02f, -4.03005891e-02f, 7.90469423e-02f, -5.07049523e-02f, -2.41216701e-02f, -3.58594768e-02f, -3.56440917e-02f, 3.73624302e-02f,
  -3.80469635e-02f, -1.75867639e-02f, 5.91107756e-02f, 1.35086715e-01f, -2.23419014e-02f, 2.41008978e-02f, 5.35857305e-02f, 7.95173794e-02f, -5.08862957e-02f, -5.46541214e-02f,
  3.26587930e-02f, 1.06494211e-01f, -7.08717182e-02f, 8.62731889e-04f, 4.83445227e-02f, -4.50550951e-03f, 8.17456990e-02f, 2.79656872e-02f, 1.17359951e-01f, -6.12548180e-02f,
  -6.24088980e-02f, -3.70769054e-02f, -6.10099249e-02f, 1.31362574e-02f, -8.10567439e-02f, -1.73755120e-02f, -1.22439070e-03f, 3.73346955e-02f, 4.71732207e-02f, -1.15316762e-02f,
  -2.48879287e-02f, 1.43948225e-02f, 7.93416500e-02f, 1.03049097e-03f, 3.21765952e-02f, 7.02920854e-02f, -3.51590216e-02f, 3.58305462e-02f, 9.86114144e-03f, 5.03994189e-02f,
  6.33595213e-02f, -3.28937709e-01f, -3.97656634e-02f, 1.16528198e-01f, 1.04568087e-01f, 3.98820564e-02f, 1.67999506e-01f, 2.93919514e-03f, 1.54408524e-02f, -1.09363727e-01f,
  7.75992349e-02f, -1.34191364e-02f, -1.32309631e-01f, -1.06206788e-02f, 2.31928617e-01f, -1.12094127e-01f, 7.42502809e-02f, 7.39087835e-02f, 1.09413255e-03f, -1.33289704e-02f,
  7.04089925e-02f, 2.96451221e-03f, -5.60708791e-02f, 4.97202203e-02f, 1.07929073e-02f, 5.69460541e-02f, 8.71618837e-02f, 7.34003112e-02f, 1.70563146e-01f, 1.54929414e-01f,
  -1.01584837e-01f, -9.31875333e-02f, 1.97495483e-02f, -4.42036241e-02f, 2.32745800e-02f, -2.92855836e-02f, 5.59988059e-02f, 1.01372637e-02f, 3.35339122e-02f, 3.27696055e-02f,
  3.99506651e-02f, -5.12012616e-02f, 3.62847224e-02f, 6.46980703e-02f, 4.55425717e-02f, -4.78429310e-02f, -1.39958365e-02f, -8.80804434e-02f, 4.05067839e-02f, -3.54698338e-02f,
  -2.87158843e-02f, 2.43868995e-02f, -4.51850221e-02f, 6.47120103e-02f, -5.15150465e-02f, 3.03664384e-03f, 1.43014814e-03f, -2.33971328e-02f, -3.95711623e-02f, 4.87231137e-03f,
  8.10336396e-02f, 7.63690472e-02f, -3.73108573e-02f, 4.03292775e-02f, -8.41230527e-03f, -3.22552174e-02f, -8.84167999e-02f, 2.08031926e-02f, 2.76197176e-02f, -4.85670380e-02f,
  -3.27353589e-02f, -8.16814825e-02f, 1.88032892e-02f, -9.98744220e-02f, 4.25941609e-02f, -5.08320443e-02f, 5.39440513e-02f, 3.51224802e-02f, 7.74241537e-02f, 6.58301190e-02f,
  -1.13823200e-02f, 5.60869388e-02f, -2.68112365e-02f, 4.23928201e-02f, -9.16760117e-02f, -5.29749971e-03f, 6.41057715e-02f, -5.42697161e-02f, 8.32820386e-02f, 3.33983749e-02f,
  -1.87655479e-01f, -2.25206479e-01f, 3.83929051e-02f, 1.86900739e-02f, 4.03731018e-02f, 2.52524149e-02f, -4.22831327e-02f, -2.56176144e-02f, -7.32180402e-02f, -1.04512468e-01f,
  6.59983698e-03f, 1.17371827e-01f, -3.59503813e-02f, 1.94781274e-02f, -3.21733998e-04f, 2.90222298e-02f, 1.89360511e-02f, -7.33844265e-02f, -6.69749361e-03f, -2.71502472e-02f,
  -3.15606408e-02f, -4.38996591e-02f, 1.00916736e-01f, -4.78342623e-02f, -1.96028017e-02f, -5.84173650e-02f, 3.12035112e-03f, 2.02744883e-02f, -9.44627682e-04f, -2.16653794e-02f,
  7.54867494e-01f, 1.53788596e-01f, 2.46753544e-01f, 3.84938359e-01f, 3.49880680e-02f, -7.37761036e-02f, 5.99302389e-02f, 9.05114412e-02f, 4.56480742e-01f, 8.00475106e-03f,
  -1.69660151e-01f, 2.62261182e-01f, -1.43267423e-01f, 1.06266461e-01f, -2.96580940e-01f, -1.23815157e-01f, 2.91159451e-02f, 1.60355672e-01f, 9.89958495e-02f, 4.69623581e-02f,
  8.51362944e-02f, -8.00276622e-02f, -2.13013962e-02f, -1.18032582e-01f, 9.36642513e-02f, 9.33180004e-02f, -3.78939033e-01f, -2.54268438e-01f, 2.32605617e-02f, -1.29396021e-01f,
  8.38370249e-02f, 1.11784264e-01f, 2.97544077e-02f, -6.30314974e-03f, -1.04558533e-02f, 1.01718847e-02f, -1.00833476e-01f, -9.98805612e-02f, 1.24388114e-01f, 6.16362840e-02f,
  5.81625775e-02f, -2.04209052e-02f, 5.24505787e-02f, -5.35459891e-02f, 8.58956128e-02f, 8.36187676e-02f, 6.66038543e-02f, 9.56469923e-02f, -2.55736951e-02f, 3.79301570e-02f,
  9.57016647e-02f, 1.16475731e-01f, 1.50943045e-02f, -2.31916457e-02f, 4.05341685e-02f, 6.56281188e-02f, -2.97620590e-03f, -3.42656560e-02f, 3.58238779e-02f, 2.45306045e-02f,
  -1.00030094e-01f, -5.95609173e-02f, -3.10721286e-02f, 2.17746347e-02f, -4.75622527e-03f, -4.12274664e-03f, 5.53685799e-02f, 3.41688581e-02f, 4.43727449e-02f, 1.71837676e-02f,
  6.48203790e-02f, 1.06262555e-02f, 3.68706286e-02f, 8.61011818e-03f, 2.00453363e-02f, 6.22758083e-02f, -2.60876399e-02f, 4.92867455e-02f, 1.04080988e-02f, -9.29494482e-03f,
  2.66769789e-02f, -4.92955633e-02f, -1.29314857e-02f, -5.10431128e-03f, -9.95082222e-03f, 2.40455642e-02f, -2.23228037e-02f, 5.48978038e-02f, -5.38204014e-02f, -8.30726326e-02f,
  -6.89229444e-02f, -2.57820934e-01f, 5.37443049e-02f, -6.23233197e-03f, -3.13712209e-02f, 9.60798655e-03f, 5.64981587e-02f, 4.12611067e-02f, -6.04325943e-02f, -1.97127629e-02f,
  -1.91136487e-02f, 4.13757525e-02f, -5.95791079e-02f, 1.31282518e-02f, -5.18157631e-02f, -2.02740282e-02f, -1.00723639e-01f, -7.98583552e-02f, -4.67490926e-02f, -4.96797124e-03f,
  3.13740596e-02f, -1.12526678e-01f, -7.80075416e-03f, 3.99288721e-02f, 4.42030579e-02f, -6.75865263e-02f, 4.56647091e-02f, 2.03723032e-02f, -3.88130769e-02f, -8.66970271e-02f,
  -3.53254467e-01f, 1.25150308e-01f, -2.20429018e-01f, -2.12082475e-01f, 4.72114235e-02f, -3.13335001e-01f, -2.50110835e-01f, 6.13924768e-03f, -4.59678434e-02f, 1.86927557e-01f,
  -1.20557547e-01f, 1.50922939e-01f, -2.20365405e-01f, -1.58788010e-01f, -6.69311583e-01f, -3.58426422e-01f, -2.84855962e-01f, -7.17804879e-02f, -1.28510281e-01f, 2.03188285e-02f,
  -1.84838682e-01f, -1.14718191e-01f, -3.43396723e-01f, 1.10567972e-01f, 1.36186659e-01f, 2.56813318e-01f, 2.27703918e-02f, 1.07807875e-01f, 1.09406784e-01f, 2.53156424e-02f,
  -5.47740385e-02f, 9.13016275e-02f, 1.29736543e-01f, 2.52068117e-02f, -8.53966922e-02f, 6.35347441e-02f, 3.66217382e-02f, -2.10020486e-02f, -8.47723708e-03f, -5.90680242e-02f,
  7.06089437e-02f, 5.26952669e-02f, -9.63778608e-03f, 3.77840474e-02f, 8.67549852e-02f, 7.16046542e-02f, 5.35070747e-02f, -1.20371254e-03f, 3.23943421e-02f, -9.17198882e-03f,
  -6.65915310e-02f, -5.92415873e-03f, -1.50954369e-02f, -1.07685607e-02f, -8.59599262e-02f, 6.78390786e-02f, -4.55685928e-02f, 4.43297997e-02f, 1.58410501e-02f, 1.58278290e-02f,
  2.01977901e-02f, 3.47242020e-02f, -2.52723880e-02f, 3.77297588e-02f, -3.50162946e-02f, 6.30782470e-02f, -2.86537968e-02f, -2.30747182e-02f, 2.15077531e-02f, -4.57079187e-02f,
  -7.10454304e-03f, -1.81108918e-02f, -2.62961700e-03f, 1.35795753e-02f, -2.52358168e-02f, 8.50894954e-03f, -1.36076072e-02f, 9.93874017e-03f, -4.55844849e-02f, -3.99702322e-03f,
  -2.60714833e-02f, -3.33478935e-02f, -7.97413010e-03f, -4.42471318e-02f, -6.23395331e-02f, 3.85890603e-02f, 3.64122838e-02f, 4.72732298e-02f, -4.15115803e-02f, -5.01069017e-02f,
  -1.25728860e-01f, 4.00011502e-02f, -1.64315645e-02f, 2.51257326e-02f, 2.91787647e-02f, -2.87879240e-02f, -6.56725541e-02f, 2.69066133e-02f, -3.06470823e-02f, 1.71967112e-02f,
  2.62784362e-02f, 3.38677573e-03f, -3.15258885e-03f, -3.98635305e-03f, -2.83343215e-02f, 1.30156782e-02f, -4.52955067e-02f, 2.24758200e-02f, 1.23088714e-03f, 3.52927111e-02f,
  7.24322647e-02f, 6.38643056e-02f, 5.17398007e-02f, -3.56649607e-02f, 3.58089395e-02f, -2.31069345e-02f, 1.08112730e-02f, 7.42382929e-03f, 4.83326949e-02f, 1.02427965e-02f,
  3.51840049e-01f, 1.10296369e-01f, -2.32426107e-01f, 1.39820993e-01f, 1.35176867e-01f, 1.91691086e-01f, 9.91352275e-02f, 5.38966767e-02f, -1.39025506e-03f, 1.88629419e-01f,
  1.28766745e-01f, -4.05821167e-02f, -2.54150033e-01f, 2.21738189e-01f, 1.08736217e-01f, -1.20338365e-01f, 3.18596274e-01f, 2.06696108e-01f, -4.14983928e-02f, 1.40009567e-01f,
  1.18830428e-03f, 3.85492355e-01f, -5.48769347e-02f, 5.77866696e-02f, 1.68536007e-01f, -3.68993245e-02f, 1.11574396e-01f, -1.73138410e-01f, 1.99912339e-01f, 3.71031389e-02f,
  5.06742187e-02f, -2.17196923e-02f, 2.40579396e-02f, -2.78676730e-02f, 6.15663491e-02f, -3.13337403e-03f, -1.03430934e-01f, -1.40563184e-02f, -4.33103964e-02f, 1.55559918e-02f,
  -1.05853612e-02f, -4.14183810e-02f, 3.11630443e-02f, -1.94186084e-02f, -1.73984058e-02f, -2.98817251e-02f, 3.17709707e-02f, -4.36462685e-02f, -3.21500972e-02f, -2.42427215e-02f,
  1.02251982e-02f, -5.48185199e-04f, 2.74305493e-02f, -4.35016826e-02f, 1.52707379e-02f, 1.72486808e-02f, -1.97478700e-02f, -8.95747766e-02f, 7.67375482e-03f, 2.62106373e-03f,
  4.99685407e-02f, 5.18414099e-03f, 6.64617047e-02f, 5.92676401e-02f, 2.05329880e-02f, 6.38784468e-02f, 6.06275424e-02f, -1.47635639e-02f, -1.99847203e-02f, -2.94750910e-02f,
  -2.70107668e-02f, 4.15075496e-02f, -2.74474192e-02f, 2.76913475e-02f, -1.46224936e-02f, 6.95688426e-02f, -3.61043890e-03f, 5.38666286e-02f, -5.90648726e-02f, -6.96386723e-03f,
  3.34227979e-02f, -1.90792959e-02f, 4.54049371e-02f, 1.14883413e-03f, 1.02290499e-03f, -1.61994118e-02f, -2.85102259e-02f, 2.24801619e-02f, -4.90306243e-02f, 1.64556771e-03f,
  4.86668162e-02f, -4.53914739e-02f, -1.12678390e-03f, 1.18935786e-01f, -1.10184871e-01f, 7.57508213e-03f, 1.16651934e-02f, -4.01841290e-02f, 7.07630906e-03f, 9.69060361e-02f,
  5.88507531e-03f, 6.78325444e-02f, -2.01490298e-02f, -1.73388831e-02f, 5.17161470e-03f, 9.45291221e-02f, 3.89722921e-03f, 1.31976213e-02f, 8.33807439e-02f, 3.07214539e-02f,
  3.37817818e-02f, 3.68383303e-02f, -2.70898882e-02f, 4.38431501e-02f, 6.52468652e-02f, -5.24230488e-03f, 1.52782779e-02f, -9.29667149e-04f, -1.87101979e-02f, -2.62721609e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.05480641e-01f, -1.64301917e-02f, -2.13216931e-01f, 4.14898023e-02f, 7.83563554e-02f, 4.01182733e-02f, 1.62001610e-01f, 3.43787484e-02f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  2.11084917e-01f, -5.72819531e-01f, 1.68208525e-01f, -7.05083087e-02f, 5.12182415e-01f, 2.07547113e-01f, 1.41601339e-01f, -3.66498739e-01f, -1.82141483e-01f, 3.24243486e-01f,
  2.70690948e-01f, -1.28387264e-03f, 5.02772033e-02f, -2.95603245e-01f, 4.16034967e-01f, -2.09210142e-01f, 1.24153867e-01f, 2.90192813e-01f, 5.83455525e-02f, -1.94216669e-01f,
  3.38647306e-01f, 3.34266238e-02f, 3.05151790e-01f, -1.55459285e-01f, 2.06338584e-01f, -2.37341538e-01f, -3.79371166e-01f, 6.85018674e-02f, 4.99404361e-03f, 1.39868841e-01f,
  2.94597894e-01f, -4.71000582e-01f, 2.05792367e-01f, 1.10879533e-01f, -1.19874500e-01f, -2.63411105e-02f, 3.01501602e-01f, 4.59259078e-02f, -4.02534336e-01f, 1.08837396e-01f,
  1.73264936e-01f, -2.76920974e-01f, 3.57878327e-01f, 1.14090992e-02f, 1.67405292e-01f, -3.57021272e-01f, 2.84070998e-01f, -1.90649822e-01f, 2.54733413e-02f, -2.28781924e-01f,
  4.32043038e-02f, 3.49254966e-01f, -1.65342286e-01f, -1.61991850e-01f, -4.35131490e-01f, -3.49185653e-02f, -3.17388445e-01f, 2.18970448e-01f, 3.47547144e-01f, -3.38190764e-01f,
  3.92849326e-01f, -4.47239548e-01f, 1.63564160e-01f, 3.91597807e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.84106308e-01f, 6.19480371e-01f, 6.15556121e-01f, -1.31969467e-01f, 6.34917080e-01f, 1.29451618e-01f, 4.19223547e-01f, 2.96711177e-01f, -6.68293983e-03f, 3.74418572e-02f,
  -3.25333327e-01f, 1.93483397e-01f, 2.44728968e-01f, 6.63462162e-01f, -7.06243049e-03f, 2.08199292e-01f, 3.14628661e-01f, 6.37172282e-01f, 3.04346323e-01f, 4.75204676e-01f,
  -2.63463371e-02f, -2.99304783e-01f, -8.53440836e-02f, -5.77365875e-01f, 1.66697413e-01f, -5.12489200e-01f, 2.62861311e-01f, -2.29737848e-01f, -1.71154365e-01f, 2.53567129e-01f,
  6.58964336e-01f, -3.57587069e-01f, 3.31728876e-01f, 4.02038723e-01f, 7.37648383e-02f, 1.18395813e-01f, 6.13192499e-01f, 3.94986682e-02f, 2.88273960e-01f, -7.97135308e-02f,
  -2.12631747e-01f, 6.33207932e-02f, -2.12501317e-01f, 1.97761804e-01f, 2.99034417e-01f, 3.00455391e-01f, 3.00620377e-01f, 9.52856019e-02f, -1.05824351e-01f, -7.33013898e-02f,
  -1.33179128e-02f, 1.68867052e-01f, 2.42064193e-01f, -4.12202952e-03f, -9.18620676e-02f, -2.09246174e-01f, -3.06717366e-01f, 2.79461592e-01f, -2.43990973e-01f, 6.56445995e-02f,
  2.27691382e-01f, 1.45240948e-01f, 3.66375953e-01f, 9.75171626e-02f, 2.59493381e-01f, 2.35822186e-01f, 3.87544297e-02f, 3.95607442e-01f, 3.50423604e-01f, -2.30637580e-01f,
  -3.69816683e-02f, -1.90891087e-01f, 1.10452190e-01f, -3.16052824e-01f, -7.70244226e-02f, -1.52292728e-01f, 6.89006075e-02f, -2.26290554e-01f, 4.47099686e-01f, -2.76889443e-01f,
  -2.39015996e-01f, -6.66619539e-02f, -1.24119051e-01f, -7.36188143e-02f, 2.03809841e-03f, -1.44475356e-01f, 1.37652919e-01f, 1.25013903e-01f, -1.64197326e-01f, 1.69219896e-01f,
  7.43431672e-02f, 1.64888725e-01f, 1.57780424e-01f, 2.45146360e-02f, -1.32638499e-01f, -2.57384658e-01f, -2.31124014e-01f, 3.45377140e-02f, -2.97579933e-02f, -2.50166595e-01f,
  -1.51545405e-02f, 2.59321272e-01f, -1.35418534e-01f, 8.07600841e-02f, -1.02065757e-01f, -1.30740538e-01f, 6.48678541e-02f, -9.97739136e-02f, -1.41625300e-01f, 5.42541184e-02f,
  1.76375762e-01f, -1.40751243e-01f, 3.19459468e-01f, -4.47044261e-02f, 2.70418711e-02f, 2.94934779e-01f, 7.98857808e-02f, 1.22780174e-01f, -8.22725222e-02f, 4.64636013e-02f,
  2.04732995e-02f, 3.98393005e-01f, 2.54550904e-01f, 1.13609277e-01f, 5.41098118e-02f, 1.39985308e-02f, -1.77425966e-01f, -8.85626208e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.60751218e-01f, 3.75012189e-01f, -3.20142880e-03f, -1.86778978e-01f, 3.45212847e-01f, -7.13332221e-02f, -2.21029073e-01f, 9.26683694e-02f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  4.69748937e-02f, 2.21251324e-01f, -2.77135402e-01f, -1.73592776e-01f, -3.69539738e-01f, -1.44479156e-01f, 5.68782568e-01f, 4.55444425e-01f, -5.95576584e-01f, 1.82941556e-01f,
  -2.53173709e-01f, -2.63395995e-01f, 1.16730809e-01f, -2.74294168e-01f, -2.08037227e-01f, 1.19206883e-01f, 1.19763553e-01f, -1.28820166e-01f, -6.62701502e-02f, 1.12895675e-01f,
  -6.53387785e-01f, 3.61849219e-01f, -2.57991076e-01f, -8.46819580e-01f, 2.85080284e-01f, 2.44483352e-01f, -1.56847462e-01f, -7.98062459e-02f, -2.98227459e-01f, -1.61386095e-02f,
  8.55177268e-02f, 7.38943368e-02f, -1.05562441e-01f, -2.97901511e-01f, -7.66368806e-02f, 5.13858302e-03f, 4.26034123e-04f, 4.55095202e-01f, 3.61347616e-01f, -2.51523912e-01f,
  -2.49338850e-01f, 5.55373251e-01f, 7.64756501e-02f, 1.68891236e-01f, 3.41144323e-01f, 4.91288863e-02f, 2.61735737e-01f, -1.87198520e-01f, 1.05420880e-01f, -1.73668116e-01f,
  1.01943076e-01f, 2.36635551e-01f, -4.29605961e-01f, 5.07998407e-01f, 5.37706129e-02f, -5.98521709e-01f, 1.56640485e-01f, 4.41515297e-01f, 9.26709250e-02f, -1.95168465e-01f,
  2.19376102e-01f, -4.01642034e-03f, 1.04611002e-01f, -2.70737141e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.62723735e-01f, 3.24730664e-01f, -3.80475409e-02f, -4.31599841e-02f, -3.09841763e-02f, 8.27552751e-02f, 3.39180350e-01f, -8.74491502e-03f, -3.03849101e-01f, 6.35561228e-01f,
  6.98220283e-02f, -4.52185869e-02f, 3.32217544e-01f, 1.20549478e-01f, 1.49144635e-01f, 8.00453350e-02f, 6.82105795e-02f, 7.03437865e-01f, 6.87838197e-01f, 7.56690323e-01f,
  -8.40997636e-01f, -5.98317742e-01f, -4.03754324e-01f, 2.01138169e-01f, -1.23113273e-02f, 7.51022622e-02f, -3.88378054e-01f, -3.54574502e-01f, -1.57534420e-01f, -4.94788997e-02f,
  -2.06893876e-01f, 1.93883806e-01f, -7.91817084e-02f, 3.78386617e-01f, 1.48494437e-01f, 3.61790597e-01f, -5.36456704e-01f, -3.32712501e-01f, -2.82810450e-01f, -6.22688010e-02f,
  3.04463923e-01f, -2.55712062e-01f, 2.85179049e-01f, 1.02334954e-02f, -3.39950114e-01f, -2.65959483e-02f, -2.62564957e-01f, 3.00166935e-01f, 7.29542851e-01f, 1.68439180e-01f,
  3.84084672e-01f, 4.96341109e-01f, 3.11623812e-02f, 9.45186436e-01f, 3.59939694e-01f, -6.25239730e-01f, 9.95529890e-01f, 4.79810029e-01f, 7.00094342e-01f, 2.59501755e-01f,
  5.03436327e-01f, 6.72913203e-03f, -3.19379151e-01f, 8.92511383e-02f, -3.02666053e-02f, 1.53427953e-02f, 1.45914122e-01f, -5.37058972e-02f, 2.56678045e-01f, 3.08918059e-01f,
  -2.52256483e-01f, -2.68445045e-01f, 4.63567376e-01f, 8.87288228e-02f, 3.86504859e-01f, 2.80246623e-02f, -5.99826537e-02f, -1.93703368e-01f, -8.75086412e-02f, 1.17742077e-01f,
  5.73808253e-01f, 4.97490138e-01f, 2.57323409e-04f, -3.88462655e-02f, 7.17732072e-01f, 3.89108099e-02f, 2.87069023e-01f, 8.06933284e-01f, -4.06104093e-03f, 8.36887777e-01f,
  -4.83034402e-02f, 1.80945694e-01f, 3.12573075e-01f, -1.72310755e-01f, -3.11605539e-02f, 3.60033363e-01f, 2.24913657e-01f, -1.60125121e-01f, 1.67657912e-01f, -2.08453804e-01f,
  2.61115313e-01f, -1.85825005e-01f, 7.38733709e-02f, 1.21156171e-01f, 2.88858414e-01f, -7.64856711e-02f, -2.37764180e-01f, 1.91715240e-01f, -2.64057308e-01f, 1.87526986e-01f,
  3.06123681e-02f, 7.85923377e-02f, -5.00806049e-02f, 1.26383588e-01f, 1.38365343e-01f, 1.53899133e-01f, 3.81019503e-01f, -5.56671619e-01f, -5.83617203e-02f, 6.13798678e-01f,
  7.25715384e-02f, -9.27967578e-02f, 1.46950498e-01f, 1.81657642e-01f, 2.30702668e-01f, -1.79291051e-02f, 1.86176673e-01f, 1.72742441e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  3.32522333e-01f, 7.44659364e-01f, 3.68601859e-01f, 4.79118526e-01f, -5.34655564e-02f, 4.95357394e-01f, -2.30218587e-03f, 3.93706381e-01f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -2.42219344e-01f, 1.04714282e-01f, -2.38421887e-01f, -3.02546859e-01f, -2.69936442e-01f, 4.46233958e-01f, 4.57056731e-01f, 8.88269305e-01f, -1.25240713e-01f, -3.26386869e-01f,
  8.94414540e-03f, 4.99536544e-01f, 3.21339779e-02f, -4.00630236e-01f, -3.19647282e-01f, -3.96946013e-01f, -1.31975049e-02f, 3.77433635e-02f, 2.09286641e-02f, 3.79716675e-03f,
  -4.50472951e-01f, 7.82414496e-01f, -1.36344135e-02f, 7.36858428e-01f, -1.15737341e-01f, -1.27799362e-02f, -1.36588603e-01f, 4.64211524e-01f, 3.13238680e-01f, -4.39592928e-01f,
  2.61702184e-02f, -3.97486746e-01f, -3.87374222e-01f, -3.57066929e-01f, 7.01606870e-02f, -1.60959050e-01f, 4.76954550e-01f, 4.52006102e-01f, 2.90363163e-01f, 4.57115322e-01f,
  3.55178267e-01f, 2.56917655e-01f, 2.42052555e-01f, -1.98758300e-03f, -1.65489599e-01f, -1.73121482e-01f, -1.82478905e-01f, -3.34374249e-01f, -1.85792118e-01f, -4.13333923e-01f,
  -4.63182241e-01f, -4.62952822e-01f, -4.27811503e-01f, 5.88103354e-01f, 1.94776639e-01f, 6.01775646e-01f, -1.22147061e-01f, -2.75945008e-01f, -3.38602662e-02f, 2.83391178e-01f,
  3.17498356e-01f, -3.72460186e-01f, 1.89552218e-01f, -4.94313657e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  4.71873999e-01f, 4.70018297e-01f, 2.01437622e-01f, 1.50178388e-01f, -3.16717118e-01f, 2.01416880e-01f, -8.03106278e-03f, -6.32686093e-02f, -1.09984301e-01f, 7.92078555e-01f,
  5.55505380e-02f, -4.32570539e-02f, -3.07098866e-01f, 1.55505374e-01f, 1.94805026e-01f, 1.11985296e-01f, 3.81358951e-01f, 3.76849860e-01f, 8.56636763e-01f, 6.50984168e-01f,
  -3.67314547e-01f, 9.63788569e-01f, -4.06984299e-01f, 8.81912112e-01f, -1.55618757e-01f, 1.13499522e+00f, 6.62598789e-01f, 7.10953534e-01f, -6.70159992e-04f, -5.56991220e-01f,
  -8.77040848e-02f, -2.13444844e-01f, 1.19636931e-01f, 2.35984579e-01f, -1.48674905e-01f, 2.54895359e-01f, -2.56859004e-01f, -3.64169270e-01f, -3.42087269e-01f, -1.94155067e-01f,
  -2.12484375e-01f, 4.64618266e-01f, 3.85855258e-01f, -3.51611227e-02f, -8.39053988e-02f, 7.10057421e-03f, 1.07652225e-01f, 1.64910406e-01f, 1.52943477e-01f, 3.84221792e-01f,
  -9.82565582e-02f, 1.86861023e-01f, -5.05085647e-01f, 1.63541526e-01f, 5.03185630e-01f, 3.45209874e-02f, 2.37416372e-01f, -8.47420573e-01f, -2.97174811e-01f, 1.39161813e+00f,
  3.19394439e-01f, 5.54444730e-01f, -1.55982643e-01f, 2.40123477e-02f, 1.24813341e-01f, -4.90762061e-03f, 5.21589592e-02f, -3.13663810e-01f, -4.18832637e-02f, 3.43157440e-01f,
  2.77992070e-01f, 4.65250820e-01f, -4.01189597e-03f, -9.27262604e-02f, -1.90363690e-01f, 9.15785849e-01f, -7.77775422e-02f, 7.40955351e-03f, 1.83808617e-02f, -2.68476456e-01f,
  -1.65820837e-01f, -4.03296649e-01f, -2.85067201e-01f, 4.34338823e-02f, -9.05410498e-02f, 1.22546569e-01f, -5.02209008e-01f, -4.80126977e-01f, 5.46435639e-03f, -6.56529069e-02f,
  1.89237654e-01f, 7.03711152e-01f, 3.86463493e-01f, 2.10766140e-02f, 2.34858319e-01f, 1.89117372e-01f, 8.73394534e-02f, 6.02232337e-01f, 4.62250710e-01f, 5.40302038e-01f,
  1.15083599e+00f, -6.12810731e-01f, 4.54546988e-01f, 5.92357993e-01f, 6.96182787e-01f, 2.71318704e-01f, -3.44216377e-01f, 7.25487024e-02f, -4.63172287e-01f, 1.03602421e+00f,
  -1.31763250e-01f, 1.54311180e-01f, 4.92117137e-01f, 3.69942218e-01f, 3.12936395e-01f, 7.20778033e-02f, 1.14541024e-01f, -2.97241479e-01f, -5.43852508e-01f, -1.73936173e-01f,
  6.24325797e-02f, 1.39171258e-01f, 2.93034494e-01f, -3.31314296e-01f, -1.19874753e-01f, 4.93360072e-01f, 1.12197630e-01f, 2.44614884e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  4.21687692e-01f, 4.29213852e-01f, 3.55594277e-01f, 3.05358976e-01f, -3.07573229e-02f, -9.24326554e-02f, 6.38409317e-01f, 1.27316415e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  3.00192572e-02f, 3.07505935e-01f, 3.62312585e-01f, -3.94730628e-01f, -7.61875570e-01f, -7.66386688e-01f, 5.84336936e-01f, -3.53347231e-03f, 3.34909439e-01f, 3.39080900e-01f,
  3.96180376e-02f, -7.47748733e-01f, -3.21623653e-01f, -4.16630685e-01f, 6.88674867e-01f, 2.68826783e-01f, 2.88958967e-01f, 5.79538047e-01f, 2.00815484e-01f, -2.53093429e-02f,
  -6.00853205e-01f, 3.29612970e-01f, -1.26764432e-01f, -5.43064475e-01f, 4.42591161e-01f, 7.91752100e-01f, 4.11498189e-01f, -4.48597282e-01f, -5.02419293e-01f, 1.11004151e-01f,
  -6.85099006e-01f, 2.48064697e-01f, -2.62470394e-01f, 5.59563637e-01f, -6.65113151e-01f, -1.04266196e-01f, -9.48326826e-01f, -8.13885987e-01f, -7.20907390e-01f, -8.35582852e-01f,
  -2.08779722e-02f, -2.34538823e-01f, -3.15641053e-02f, 5.90573311e-01f, -3.14462274e-01f, 4.94828910e-01f, -3.90961885e-01f, 1.65748611e-01f, 6.37378037e-01f, 2.18034148e-01f,
  7.11316392e-02f, -2.97291934e-01f, -1.75432533e-01f, -6.86185718e-01f, 2.33552963e-01f, -6.66112721e-01f, -2.65585035e-01f, -1.15201437e+00f, -4.10527289e-01f, 3.76953095e-01f,
  1.46013498e-01f, -3.95560414e-02f, 6.65474832e-01f, 1.78415962e-02f, 6.85064197e-01f, 6.37664199e-01f, -2.19170097e-02f, 6.95070177e-02f, -3.44874859e-02f, 5.77497959e-01f,
  3.41647238e-01f, -2.59086907e-01f, 1.29716516e-01f, 2.27639586e-01f, -7.65442774e-02f, 1.83591902e-01f, 1.23736784e-01f, -4.24032927e-01f, 6.25518084e-01f, -1.21574946e-01f,
  6.66230857e-01f, -1.50275484e-01f, -1.12350710e-01f, 9.23786998e-01f, 4.92044449e-01f, 6.82225347e-01f, 5.85967839e-01f, 3.67454231e-01f, 3.11459541e-01f, 1.14954913e+00f,
  -2.28429496e-01f, -5.15111744e-01f, 8.67878571e-02f, -2.06695810e-01f, -4.27164316e-01f, -2.33697131e-01f, -2.62470007e-01f, -1.65628329e-01f, -9.47825909e-02f, -6.69627070e-01f,
  4.47855800e-01f, 1.60792209e-02f, 4.17265445e-01f, 5.67359924e-01f, -5.15341103e-01f, 7.26534903e-01f, -1.55301809e-01f, -7.17949048e-02f, 3.42799842e-01f, 6.04782999e-01f,
  -1.08040321e+00f, -2.31740385e-01f, -7.23724365e-01f, -7.71065056e-01f, 1.33347780e-01f, -4.25411254e-01f, -3.24878454e-01f, -2.13567644e-01f, 7.20258057e-02f, 2.65876234e-01f,
  -2.10092753e-01f, -7.49768972e-01f, -3.94845009e-01f, -2.65353113e-01f, -4.66510355e-01f, -2.05571279e-01f, 1.17016685e+00f, 1.10511415e-01f, -7.61926770e-01f, -8.86665583e-01f,
  -4.00565833e-01f, -4.74423945e-01f, -3.68015707e-01f, -9.41487312e-01f, -4.18385953e-01f, -1.56362072e-01f, 5.08442342e-01f, -6.96119189e-01f, 5.03050447e-01f, -8.79707515e-01f,
  -1.25166327e-01f, 1.75963119e-01f, 1.57186076e-01f, 8.12357545e-01f, -2.96624571e-01f, -7.80776620e-01f, 1.81928039e-01f, 4.62583929e-01f, 7.36777008e-01f, 3.13633382e-01f,
  -1.34658232e-01f, 7.27498651e-01f, 1.09870143e-01f, 4.31996673e-01f, 1.16155140e-01f, 6.03525400e-01f, 2.59879678e-01f, -3.79338950e-01f, -2.82273203e-01f, -9.09359977e-02f,
  2.71322489e-01f, 4.99591798e-01f, -2.90160328e-01f, 7.03110158e-01f, 8.16228628e-01f, 9.31127965e-01f, -2.80843854e-01f, 3.29256892e-01f, -1.45437628e-01f, -7.28255272e-01f,
  -3.12201709e-01f, 7.62797713e-01f, 3.68109286e-01f, 6.88128034e-03f, 5.33945560e-02f, -1.58637673e-01f, -1.31569505e-01f, -6.83337867e-01f, -2.85836379e-03f, -4.92952257e-01f,
  2.65315384e-01f, 2.09684834e-01f, 3.79693240e-01f, 8.04683089e-01f, -4.13518906e-01f, -5.65403402e-01f, -2.51943499e-01f, 7.50449836e-01f, 5.14181376e-01f, 4.08427924e-01f,
  -6.33420408e-01f, -1.07689992e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.45031899e-01f, 1.92154616e-01f, 2.72472173e-01f, -7.75496364e-02f, 1.74730405e-01f, -1.01622529e-01f, -1.58448517e-01f, 5.10915890e-02f, 4.28170890e-01f, -1.91111639e-01f,
  -1.91432372e-01f, -3.27864438e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    