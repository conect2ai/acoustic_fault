/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.24945924e-01f, -3.71392548e-01f, -2.08952241e-02f, 1.91927701e-01f, -1.44333802e-02f, -9.40226689e-02f, -4.41241801e-01f, -2.31810838e-01f, 2.40684431e-02f, -3.35730731e-01f,
  1.07438974e-01f, 4.52184200e-01f, 3.56524974e-01f, 2.34273419e-01f, -3.28567773e-02f, -3.13193768e-01f, -1.32879913e-01f, 2.25745156e-01f, 3.32731158e-01f, 1.07448034e-01f,
  2.03681029e-02f, 2.36129481e-02f, 1.72604337e-01f, 1.23666659e-01f, -2.32111111e-01f, 2.34922573e-01f, -2.15820208e-01f, -1.12008207e-01f, -7.45207295e-02f, -9.65150595e-02f,
  -7.11604804e-02f, -2.05637008e-01f, 2.00527444e-01f, 1.64915085e-01f, 6.41547963e-02f, -8.53297263e-02f, -4.42048311e-02f, -7.69635364e-02f, 3.36059593e-02f, -8.38806201e-03f,
  4.11620848e-02f, 6.35139504e-03f, 4.70725335e-02f, 1.11392438e-02f, -1.47816062e-01f, 5.44086434e-02f, -8.96814540e-02f, -2.98383962e-02f, 1.70869585e-02f, -1.14312470e-01f,
  1.91671148e-01f, 8.40309411e-02f, -6.66028783e-02f, -1.45781767e-02f, -5.78416698e-02f, 2.02908367e-01f, -2.89554950e-02f, -4.69067134e-02f, 1.06264455e-02f, -1.80731103e-01f,
  4.39926460e-02f, 4.90419625e-04f, 3.20018344e-02f, -2.09182259e-02f, -2.61310693e-02f, -1.60011817e-02f, -2.12386679e-02f, -2.08888040e-03f, 1.54024055e-02f, -8.64729583e-02f,
  1.43587338e-02f, -3.45706493e-02f, -2.00967286e-02f, -8.11079741e-02f, 6.11112416e-02f, -5.28072752e-02f, -2.19779997e-03f, -3.18502411e-02f, 8.32269341e-02f, -1.11525662e-01f,
  2.91105118e-02f, -3.95329809e-03f, -2.36441605e-02f, 5.91758126e-03f, -2.33216975e-02f, 4.12417538e-02f, 1.30313858e-02f, -2.73636840e-02f, -1.49252852e-02f, -3.82467620e-02f,
  -8.25015381e-02f, 2.78177589e-01f, -3.06396261e-02f, -1.09104365e-02f, 1.01485979e-02f, 5.41041791e-02f, 9.10037756e-02f, 1.15841627e-01f, 5.18018715e-02f, 3.81004922e-02f,
  6.04870841e-02f, 9.24696922e-02f, -1.69163551e-02f, 1.14704752e-02f, 1.38069138e-01f, 2.28347406e-02f, 5.11508659e-02f, 5.60611598e-02f, 2.19789144e-04f, -4.12056334e-02f,
  -7.01377075e-03f, -8.40402469e-02f, 7.50709996e-02f, -4.40288056e-03f, 2.79796440e-02f, 6.77441582e-02f, -5.32268882e-02f, -2.10577082e-02f, 5.33359796e-02f, -1.63844466e-01f,
  6.86002597e-02f, -3.26888680e-01f, -3.05823740e-02f, -4.63953674e-01f, -1.16892084e-01f, 1.61704928e-01f, -1.26112282e-01f, 7.53292590e-02f, 4.18296456e-02f, -2.17574269e-01f,
  1.48131792e-02f, 1.62623469e-02f, -1.04172587e-01f, 9.70981419e-02f, 1.84076339e-01f, -2.32570961e-01f, -3.06744248e-01f, -1.99351809e-03f, 3.86606961e-01f, 2.12990567e-01f,
  -7.30125457e-02f, -1.12328231e-01f, 1.21067300e-01f, 1.19631685e-01f, -2.95359492e-01f, -3.69491056e-02f, -9.71231684e-02f, -3.08801699e-02f, 2.63005327e-02f, -9.26044285e-01f,
  -1.02371790e-01f, -1.63716540e-01f, 5.05149253e-02f, -6.35876581e-02f, -4.06316202e-03f, 5.99269941e-02f, 8.89141019e-03f, -8.03916454e-02f, 2.20770780e-02f, -4.05242853e-02f,
  -4.32920270e-02f, 6.71441257e-02f, -9.91934910e-02f, 3.76768932e-02f, 1.35965096e-02f, 5.94274253e-02f, 3.77814211e-02f, -1.22723933e-02f, -3.11651872e-03f, -7.51248561e-03f,
  -1.64258942e-01f, -1.26694083e-01f, -6.24265298e-02f, 3.68180871e-02f, 1.15286872e-01f, 3.55715603e-02f, -3.02448906e-02f, 2.44415272e-03f, 1.23973928e-01f, -2.09643155e-01f,
  2.25823019e-02f, -6.77355677e-02f, 1.43051315e-02f, -2.67848074e-02f, 1.28780911e-02f, 2.00651698e-02f, -7.05251098e-02f, 2.78777257e-02f, -1.75024029e-02f, 3.34470998e-03f,
  3.07564195e-02f, 2.04710308e-02f, 4.73729987e-03f, 2.74345614e-02f, -4.48365770e-02f, -1.07352901e-02f, 1.74808558e-02f, -7.13688089e-03f, 5.41424239e-03f, 1.39516126e-02f,
  1.27888238e-02f, 1.60236154e-02f, -1.94201432e-02f, -1.88536774e-02f, -2.77688745e-02f, -4.12277877e-02f, 4.75711562e-03f, 8.79027247e-02f, 4.01409902e-02f, 2.36108014e-03f,
  1.17473982e-01f, 1.96666166e-01f, -1.67993575e-01f, 3.30947451e-02f, -5.91292664e-05f, 1.79610250e-03f, -8.60980079e-02f, 4.09314558e-02f, -3.15639451e-02f, -2.38997228e-02f,
  2.59138606e-02f, 1.66601464e-02f, 3.41168232e-02f, 5.13877859e-03f, 4.47080769e-02f, -2.15425249e-02f, 1.85698103e-02f, -1.04455557e-03f, 2.40487736e-02f, -1.42985594e-03f,
  -3.09497900e-02f, 7.87080675e-02f, 8.09011236e-02f, 2.09884178e-02f, -5.20922393e-02f, -2.94755045e-02f, 9.53933150e-02f, 5.53151034e-02f, 1.08755626e-01f, 1.62434373e-02f,
  1.64195284e-01f, -1.31148100e-01f, 4.15266573e-01f, -3.80356424e-02f, 1.17198199e-01f, 1.78290099e-01f, -1.91122055e-01f, -1.80673867e-01f, -3.17082144e-02f, 4.91919331e-02f,
  1.83842301e-01f, 1.75840095e-01f, 1.47088602e-01f, 4.10986505e-02f, -9.63662937e-02f, -4.37415838e-02f, -1.46844983e-01f, -4.81485613e-02f, 4.16888595e-02f, -1.09400265e-01f,
  -2.13937193e-01f, -3.34639043e-01f, -2.42838830e-01f, -1.52619630e-01f, 3.92858274e-02f, 2.47148857e-01f, 2.00612739e-01f, 4.99007106e-02f, 1.00209720e-01f, 5.73063083e-02f,
  4.33666378e-01f, 1.59537777e-01f, -2.06576865e-02f, -1.21659033e-01f, 3.07377260e-02f, -2.19642427e-02f, -5.47714904e-02f, 5.84038682e-02f, 2.88265757e-02f, -1.02018483e-01f,
  5.11835180e-02f, -2.84686461e-02f, 1.49624040e-02f, -1.18425369e-01f, -2.10496932e-02f, -9.93073210e-02f, -1.35729626e-01f, -6.05230853e-02f, 7.64197186e-02f, 1.48400232e-01f,
  -6.82485476e-02f, -7.76076224e-03f, 1.58160999e-01f, -1.21887982e-01f, 2.55482621e-03f, 6.90653324e-02f, -7.31901601e-02f, 2.09412407e-02f, 2.53028553e-02f, -1.14236757e-01f,
  -3.71669605e-02f, 2.07952224e-02f, 3.68091762e-02f, -3.72218937e-02f, -1.39268190e-02f, 3.54417674e-02f, 3.42541970e-02f, -5.31142345e-04f, -3.73022035e-02f, 3.28298621e-02f,
  -2.73647252e-02f, 1.33064657e-01f, -8.76993034e-03f, 4.92041521e-02f, 4.05326411e-02f, 6.30148500e-03f, 2.91110650e-02f, -4.37040254e-02f, 6.40722662e-02f, 2.30557807e-02f,
  -2.20688749e-02f, 6.81370348e-02f, 5.79756647e-02f, -3.00236922e-02f, 5.03095463e-02f, -5.44560794e-03f, 1.02253884e-01f, -1.37582375e-02f, 2.03643832e-02f, 2.50258134e-03f,
  -3.95784900e-02f, -2.08613053e-02f, 3.70934494e-02f, -1.20166345e-02f, 4.95761819e-02f, -2.36146413e-02f, -1.20680602e-02f, -5.52037023e-02f, 4.63514142e-02f, -6.64891899e-02f,
  -2.62631141e-02f, -6.48307949e-02f, -4.06280234e-02f, -6.40962049e-02f, -4.08936366e-02f, -2.85377055e-02f, -9.36533436e-02f, 1.34805396e-01f, -1.15801461e-01f, -3.10850999e-04f,
  -1.48002639e-01f, 6.29653176e-03f, 4.46704254e-02f, 3.85123752e-02f, 1.49867579e-03f, 1.10967636e-01f, 9.65742096e-02f, 4.77246605e-02f, 4.47555035e-02f, -1.72408298e-01f,
  5.56471467e-01f, -1.43258780e-01f, -2.92503387e-01f, 2.82055318e-01f, -4.12513912e-01f, -4.49805081e-01f, -6.70218587e-01f, 3.58419940e-02f, 2.87030876e-01f, -2.98719794e-01f,
  -4.14334200e-02f, 1.76378623e-01f, 2.53240943e-01f, 1.43007904e-01f, 5.87930791e-02f, -4.07499820e-01f, -2.20672905e-01f, 1.84590682e-01f, 6.71128854e-02f, -2.06165984e-01f,
  -8.53341520e-02f, 1.98523864e-01f, 4.55475420e-01f, 1.59410864e-01f, -1.35778308e-01f, -5.79881575e-03f, -1.39753044e-01f, 9.26888548e-03f, -1.00974709e-01f, 8.67363357e-04f,
  -5.11940271e-02f, 8.35172832e-02f, -9.40363407e-02f, 7.04424605e-02f, -8.09449628e-02f, 7.03473464e-02f, -2.01589405e-03f, 6.11327961e-02f, -2.66100075e-02f, 4.20166971e-03f,
  -4.85147648e-02f, 3.66665907e-02f, 4.71965931e-02f, 3.81643437e-02f, -2.50968933e-02f, -4.82323803e-02f, 1.18108019e-01f, 1.49856359e-01f, 7.83875119e-03f, -7.55963847e-02f,
  -9.97806713e-02f, -8.03687125e-02f, -1.68484777e-01f, -1.28923580e-01f, -4.95853536e-02f, -1.99793968e-02f, -4.80147190e-02f, 9.03586522e-02f, -8.32490698e-02f, 1.80724397e-01f,
  1.22686476e-02f, -2.53950413e-02f, -6.34090379e-02f, 1.04225781e-02f, -2.66825985e-02f, 3.11207175e-02f, -1.37671707e-02f, 2.00189743e-02f, -1.03786187e-02f, 9.11481120e-03f,
  3.30381244e-02f, 4.79919743e-03f, 4.74128462e-02f, -7.10636331e-03f, 2.52119750e-02f, -1.51186930e-02f, -1.26849925e-02f, 4.15083813e-03f, 4.83285785e-02f, 1.57407504e-02f,
  3.13083939e-02f, -2.06719767e-02f, 1.77902300e-02f, 4.24977988e-02f, -2.13520564e-02f, 5.11345081e-02f, 3.63458507e-02f, -8.71539582e-03f, 3.84999551e-02f, -2.76806522e-02f,
  1.99974954e-01f, -1.05781555e-01f, 1.10786207e-01f, 2.34948322e-02f, 8.20076093e-03f, 5.12607507e-02f, -7.94662684e-02f, 3.67937796e-02f, 4.44971621e-02f, 2.37245169e-02f,
  -2.99365763e-02f, -3.87238478e-03f, -6.89964592e-02f, -3.18991356e-02f, -6.94366246e-02f, -3.18598039e-02f, -5.15204370e-02f, -2.15259809e-02f, 4.42418568e-02f, 3.77170965e-02f,
  5.41460402e-02f, -1.04646608e-01f, -3.26533653e-02f, 3.67593542e-02f, 8.14220682e-02f, -1.53317647e-02f, -2.04824090e-01f, -3.83394845e-02f, -1.26878455e-01f, -1.70406863e-01f,
  2.27812052e-01f, -2.64088333e-01f, -9.35323164e-02f, 4.02686819e-02f, -5.53211793e-02f, 8.43605623e-02f, 1.02148525e-01f, 4.82091159e-02f, 1.11879252e-01f, -1.25394389e-02f,
  -1.13011733e-01f, 3.37991044e-02f, 7.82240629e-02f, 8.55093598e-02f, 3.81230637e-02f, 5.95391095e-02f, -8.76900181e-02f, 6.26512319e-02f, 1.88568711e-01f, 5.54745160e-02f,
  1.02588393e-01f, -9.31991823e-03f, 2.25793850e-02f, -8.57195631e-02f, -4.64959405e-02f, 3.24722469e-01f, -8.73787776e-02f, -2.57074893e-01f, -1.06190108e-01f, -1.48970127e-01f,
  -1.29621029e-01f, -2.26281941e-01f, 1.80758610e-01f, 9.67502780e-03f, -2.19991758e-01f, 3.44731659e-02f, -3.29810083e-02f, -9.63867605e-02f, -4.62855697e-02f, -5.52825704e-02f,
  -1.44492239e-01f, -1.10890344e-01f, -1.15437016e-01f, -5.13714179e-02f, -1.31996647e-01f, -1.63394976e-02f, -1.30796984e-01f, -8.85656178e-02f, -4.21329178e-02f, -1.03485202e-02f,
  -1.41776040e-01f, -1.97620034e-01f, -1.63164914e-01f, -1.11047618e-01f, -1.76675439e-01f, -2.74524949e-02f, -1.57949463e-01f, -2.06561491e-01f, -1.69640929e-01f, -1.21499464e-01f,
  2.01642662e-02f, 1.43624181e-02f, -2.93316506e-02f, -3.16981636e-02f, 6.42078072e-02f, -1.30723966e-02f, -2.32584663e-02f, 2.46459935e-02f, 2.56918985e-02f, 5.89560997e-03f,
  -7.24177249e-03f, 4.21528183e-02f, -8.74238741e-03f, -4.51651812e-02f, 2.70909518e-02f, -5.29076904e-02f, 4.84422371e-02f, 2.85980627e-02f, -6.86464980e-02f, 6.45012110e-02f,
  4.33699377e-02f, -4.84933844e-03f, 2.19545979e-02f, -2.12293006e-02f, 1.60020683e-02f, 2.01615449e-02f, -3.20616784e-03f, 7.75534939e-03f, 5.49518429e-02f, -4.91138594e-03f,
  2.04398915e-01f, 1.45920590e-02f, -2.09504627e-02f, -1.47294709e-02f, 7.72003010e-02f, -4.57899421e-02f, -7.03521967e-02f, -7.26279942e-03f, -2.04159785e-02f, 3.42357880e-03f,
  1.00600598e-02f, 2.22191168e-03f, -8.52056593e-02f, -9.18876678e-02f, 4.94797379e-02f, 5.14424518e-02f, -7.61395991e-02f, 7.49817938e-02f, -4.19262350e-02f, -1.48677099e-02f,
  1.22916955e-03f, 1.80466339e-01f, 3.02671224e-01f, 1.50674105e-01f, 4.53913771e-02f, 2.62416601e-01f, 1.95398703e-01f, 1.77490652e-01f, 2.64040560e-01f, 5.95640302e-01f,
  -6.24239922e-01f, 8.27149451e-02f, -3.65154445e-02f, -1.69434473e-01f, 1.30242065e-01f, -1.82831272e-01f, -9.72979367e-02f, -1.59437880e-01f, -2.73390133e-02f, 1.62535891e-01f,
  2.34396890e-01f, 5.39515987e-02f, 4.66559008e-02f, 8.31532329e-02f, -4.60394233e-01f, -1.96447536e-01f, -3.06251973e-01f, -4.07426268e-01f, -3.91341895e-01f, -9.86229181e-02f,
  1.49772391e-01f, -3.41518372e-02f, -2.25639671e-01f, -6.75323233e-02f, 1.57891303e-01f, 1.60356328e-01f, 1.69005856e-01f, 3.82268503e-02f, 2.18373477e-01f, 1.57997996e-01f,
  6.55132756e-02f, -1.58440232e-01f, -1.14071563e-01f, -3.16823064e-03f, 8.59761983e-02f, -7.35490844e-02f, -5.80822490e-02f, -3.48168761e-02f, 4.31049652e-02f, -5.44138588e-02f,
  7.24876523e-02f, 2.09643617e-02f, -1.24259889e-01f, 8.65028724e-02f, -2.18508150e-02f, -5.16752340e-02f, -4.27543372e-02f, -1.88242689e-01f, -7.56804124e-02f, -3.58325467e-02f,
  1.71366706e-01f, -3.91062759e-02f, -1.93091124e-01f, -6.86583109e-03f, -1.91161826e-01f, -8.33207369e-02f, 8.88553858e-02f, -1.42752469e-01f, -1.17413454e-01f, -3.50979231e-02f,
  -1.95682608e-02f, -1.88399479e-02f, 2.70693097e-02f, 2.73219906e-02f, 1.93370450e-02f, 5.03255129e-02f, 7.11631356e-03f, 8.78026038e-02f, 1.05471192e-02f, -1.04359677e-03f,
  1.19241402e-02f, 5.41934883e-03f, 5.58266565e-02f, -9.73333269e-02f, 1.04986824e-01f, -5.32733761e-02f, -4.46015410e-03f, -2.66134236e-02f, 3.44896736e-03f, 4.88015227e-02f,
  -2.54635401e-02f, -3.51889525e-03f, 2.56670602e-02f, 6.07253648e-02f, -5.23306131e-02f, -2.84729376e-02f, -8.51912610e-03f, 6.17181100e-02f, 2.04800870e-02f, -8.35838553e-04f,
  1.34760290e-01f, -9.92809907e-02f, -6.24202751e-02f, -1.13815561e-01f, -2.00112239e-02f, 2.66051590e-02f, 5.54860309e-02f, -3.00387386e-02f, 7.12914988e-02f, -1.70563012e-02f,
  -7.53136352e-02f, -6.29355013e-02f, 3.75991575e-02f, 3.82645242e-02f, -6.94560185e-02f, -1.10775214e-02f, -2.44516730e-02f, -1.42692879e-03f, 1.06278174e-02f, 6.03439892e-03f,
  -2.01252177e-02f, -1.27873808e-01f, -1.29406735e-01f, -5.83781376e-02f, -5.04369661e-02f, -1.34045079e-01f, 5.68965599e-02f, 1.02360718e-01f, -2.20108464e-01f, -4.41655936e-03f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.88633639e-01f, -1.26370683e-01f, -1.75933570e-01f, 8.61903504e-02f, 2.09480658e-01f, 1.17935963e-01f, 1.23446405e-01f, 1.63115799e-01f, 1.69263229e-01f, 7.35969935e-03f,
  1.27467355e-02f, 2.59365052e-01f, 2.46194959e-01f, 1.30192548e-01f, 1.08118072e-01f, 2.09428415e-01f, 1.42871410e-01f, 9.76268798e-02f, 7.84308389e-02f, 8.14771578e-02f,
  2.18822658e-02f, -7.56106675e-02f, -2.80973136e-01f, 6.28633797e-02f, -1.38695035e-02f, 1.01387464e-01f, -2.85637416e-02f, -9.58413780e-02f, -7.00095221e-02f, 1.22573413e-01f,
  -1.87803745e-01f, -2.12080285e-01f, 1.94371998e-01f, 9.91712436e-02f, -1.45099714e-01f, -1.45174101e-01f, 5.75977825e-02f, -1.37060806e-01f, -1.18801653e-01f, -1.58006214e-02f,
  -4.02620388e-03f, -5.31900600e-02f, 7.31740892e-02f, -8.24779794e-02f, -1.00131221e-01f, -6.04444221e-02f, -3.15607265e-02f, -4.21024375e-02f, 1.47336930e-01f, -5.07318117e-02f,
  1.65999025e-01f, -1.53457932e-02f, -1.07777558e-01f, 7.80020431e-02f, 1.09411567e-01f, 1.34928212e-01f, -3.62070568e-04f, 3.43937129e-02f, 9.90199894e-02f, 8.21604766e-03f,
  6.10659122e-02f, -2.72069406e-03f, 5.71280047e-02f, 9.13752709e-03f, 9.30803344e-02f, 7.03357607e-02f, -4.88982499e-02f, 4.65728864e-02f, 1.04320481e-01f, -6.57373369e-02f,
  3.44628170e-02f, 6.17062934e-02f, 6.71591908e-02f, 1.49616927e-01f, 6.50186688e-02f, -2.92967483e-02f, -3.41874510e-02f, 2.06341334e-02f, 8.49122275e-03f, -4.83700708e-02f,
  5.22266421e-03f, -3.84906717e-02f, -1.00988984e-01f, 4.66258917e-03f, 1.99489575e-02f, 3.70487943e-02f, -1.22003444e-02f, -1.98115297e-02f, -2.45903637e-02f, -1.11219930e-02f,
  -9.33395848e-02f, 1.16800599e-01f, 1.87502593e-01f, -2.54951082e-02f, -1.16559699e-01f, -1.26269013e-01f, 1.16719931e-01f, -5.03115803e-02f, -1.29329890e-01f, -4.00239415e-02f,
  -8.22435468e-02f, -2.23704148e-02f, -7.33871982e-02f, -2.57858206e-02f, -6.21910393e-02f, -2.06574015e-02f, -6.33901656e-02f, 8.41998383e-02f, 5.11803627e-02f, -2.51409058e-02f,
  1.25135307e-03f, 7.66847655e-02f, -7.18510151e-03f, 1.95191711e-01f, 1.46649629e-01f, -1.10557824e-02f, -4.58789878e-02f, -4.31070700e-02f, -4.39035445e-02f, 3.76773998e-02f,
  -2.86080182e-01f, 2.62540013e-01f, -5.24019264e-02f, -2.52919614e-01f, -1.52666926e-01f, -4.73422818e-02f, 9.00444165e-02f, -6.82945624e-02f, -2.01568499e-01f, 3.59409563e-02f,
  5.84233478e-02f, -6.33394867e-02f, 8.41263160e-02f, 1.40642710e-02f, -1.74954329e-02f, 9.10019428e-02f, -2.39723697e-02f, -1.77580804e-01f, -4.35380861e-02f, -1.25853062e-01f,
  -3.47127840e-02f, -3.09371687e-02f, -7.69177005e-02f, -1.71213560e-02f, -2.57518291e-02f, -3.65998112e-02f, 4.48085740e-03f, -8.76895785e-02f, -1.17024548e-01f, -9.63361487e-02f,
  2.97097027e-01f, -2.53488749e-01f, -1.08137764e-01f, -1.19970672e-01f, 4.62922603e-02f, -1.32369790e-02f, 2.60452973e-03f, -2.14470997e-02f, 3.01052742e-02f, 6.30836785e-02f,
  -1.13784112e-01f, 1.60837434e-02f, -9.23962891e-02f, 5.05455434e-02f, 6.06415607e-02f, -4.46590148e-02f, -3.92081663e-02f, -8.83748457e-02f, -3.20376828e-02f, 1.31718799e-01f,
  6.91262782e-02f, -1.35920703e-01f, -1.70610286e-02f, -2.35274397e-02f, -1.10189617e-01f, -6.11361600e-02f, 2.51182280e-02f, -4.70696427e-02f, -8.90812874e-02f, 1.54456258e-01f,
  1.98497456e-02f, 2.65975781e-02f, -3.92984673e-02f, -1.51726007e-02f, 6.08608164e-02f, 5.42450175e-02f, -3.58806439e-02f, 2.68523265e-02f, 4.58439961e-02f, 9.63650793e-02f,
  3.52069549e-02f, -6.01271950e-02f, -1.52825434e-02f, 1.06339626e-01f, -7.37299696e-02f, -8.28646198e-02f, -1.64007880e-02f, 8.20315257e-02f, -5.36123328e-02f, -1.34474235e-02f,
  6.81689102e-03f, -1.38657421e-01f, 4.45603840e-02f, -3.64903128e-03f, -1.26774132e-01f, -5.98753132e-02f, -6.90662935e-02f, 2.73425821e-02f, 6.03632741e-02f, -2.31129806e-02f,
  2.81995595e-01f, -2.93783724e-01f, 8.11664164e-02f, -6.98161172e-03f, -1.51013851e-01f, -3.80045287e-02f, -4.28695716e-02f, -9.95941684e-02f, -1.30262464e-01f, 4.17942256e-02f,
  -1.20503694e-01f, 1.09471548e-02f, 1.65312946e-01f, -4.14414844e-03f, 4.90137376e-02f, 2.75545591e-03f, 5.16198799e-02f, -2.04083417e-02f, -5.06011993e-02f, -3.90909687e-02f,
  -3.26908603e-02f, 8.66748020e-02f, 2.19452962e-01f, 2.14751661e-01f, 9.32820234e-03f, -5.59812374e-02f, 2.85438567e-01f, 2.74857003e-02f, 8.31500664e-02f, 4.61187124e-01f,
  -8.55360448e-01f, -2.36900494e-01f, -1.36276335e-01f, -4.28099543e-01f, -5.03424592e-02f, 1.54948860e-01f, -1.46996714e-02f, 4.16166745e-02f, -8.20958316e-02f, -7.34454617e-02f,
  4.22204472e-02f, -5.47652245e-02f, -8.82573873e-02f, -6.67097420e-02f, -9.75969583e-02f, -5.61203957e-02f, -2.37416849e-01f, -3.22759718e-01f, -8.60020891e-02f, 1.05896749e-01f,
  -9.00748745e-02f, -3.37507784e-01f, -3.93252879e-01f, -5.63551076e-02f, 1.03937380e-01f, -7.56714940e-02f, -1.20704174e-01f, -1.70454696e-01f, 1.13609642e-01f, -1.69662550e-01f,
  8.03762078e-02f, 4.86871265e-02f, 8.81507620e-02f, -7.95231313e-02f, -1.27352178e-01f, 7.65587622e-03f, 8.80496018e-03f, -2.20214110e-02f, 3.35271694e-02f, -5.87088242e-02f,
  -3.06448918e-02f, 1.04709476e-01f, -8.32349360e-02f, 1.93961486e-02f, -1.11961566e-01f, -3.43388319e-02f, -3.46365497e-02f, -1.20392293e-01f, 9.68408771e-03f, 1.83338836e-01f,
  4.85341586e-02f, 1.12983026e-01f, 2.68768929e-02f, 7.88527951e-02f, 1.70899585e-01f, 5.54576591e-02f, 8.06160457e-03f, 2.21404970e-01f, 1.05234414e-01f, -8.58492255e-02f,
  1.51076866e-02f, 3.34425867e-02f, 8.16268921e-02f, -4.08925712e-02f, -2.93022284e-04f, -4.84807510e-03f, -5.07907383e-02f, -5.54596027e-03f, 5.78722432e-02f, -7.61635974e-02f,
  5.90334162e-02f, -8.01723637e-03f, 7.63588492e-03f, -5.80673032e-02f, -5.13745621e-02f, -1.96362361e-02f, -2.71388926e-02f, -2.96338033e-02f, 4.80432585e-02f, -7.59825706e-02f,
  7.01326237e-04f, 7.98663199e-02f, -2.50264872e-02f, 1.11866938e-02f, 1.93054676e-02f, -5.97243123e-02f, -2.56886762e-02f, 1.13391228e-01f, -3.84877995e-02f, 5.68214990e-02f,
  -1.72015369e-01f, -1.19081559e-02f, -1.11416273e-01f, 5.58765344e-02f, -4.25511263e-02f, 1.19312974e-02f, -6.59140497e-02f, -6.97118975e-03f, -4.63077351e-02f, 9.97151509e-02f,
  9.46663693e-02f, -3.22645046e-02f, -4.20823880e-02f, 5.69348298e-02f, -1.86953302e-02f, 1.02290623e-01f, -6.25754148e-03f, -1.09381914e-01f, 1.02866039e-01f, 7.39220381e-02f,
  1.46835027e-02f, -5.83729893e-02f, -1.06898509e-01f, -2.27503330e-02f, 4.96609844e-02f, -5.68349175e-02f, 7.01573864e-02f, -2.24203691e-02f, 4.65391725e-02f, -1.53709188e-01f,
  -3.25394839e-01f, -2.81947628e-02f, 3.11647832e-01f, -9.21691507e-02f, 7.43290270e-03f, 1.10963479e-01f, 1.04137152e-01f, -4.14942801e-02f, -1.85938895e-01f, -1.49449497e-01f,
  3.19050886e-02f, -1.47021443e-01f, -3.78469191e-02f, 7.33308941e-02f, 1.25838026e-01f, 9.55002941e-03f, 1.29823864e-01f, 1.04887620e-01f, 1.79127276e-01f, -1.88615788e-02f,
  -8.00619274e-02f, -5.83546795e-02f, 4.32423390e-02f, 6.63080812e-02f, -5.67195229e-02f, -8.26153755e-02f, 9.92486477e-02f, 2.18891948e-02f, 6.83635753e-03f, -1.68729186e-01f,
  -1.48483306e-01f, 2.28144918e-02f, -3.85017530e-03f, -1.85055628e-01f, 7.48973414e-02f, 5.76558942e-03f, -8.87264535e-02f, 5.75933196e-02f, -1.44749992e-02f, 3.80871743e-02f,
  -1.02402382e-02f, -7.58684501e-02f, 6.37107566e-02f, -1.96132921e-02f, 7.45519027e-02f, -7.45311901e-02f, -1.35523616e-03f, 5.36412895e-02f, 1.21920608e-01f, 4.92513105e-02f,
  -7.95942470e-02f, -4.76019122e-02f, -1.29198618e-02f, 1.41671464e-01f, 6.24079406e-02f, 1.67434644e-02f, 7.22165126e-03f, -1.61697192e-03f, 4.93720965e-03f, -1.16764650e-01f,
  -3.79050374e-02f, 5.64137585e-02f, -1.56339090e-02f, 2.23802477e-02f, -5.79781532e-02f, 3.74752171e-02f, -3.97247858e-02f, 3.53946909e-02f, 1.76726226e-02f, -4.32398021e-02f,
  7.52787068e-02f, 1.49098234e-02f, 2.77925916e-02f, -5.39046787e-02f, -1.87477842e-02f, 1.39661683e-02f, 1.67971069e-03f, 9.85186733e-03f, 3.25465016e-02f, 1.44846803e-02f,
  2.15747692e-02f, 2.79953368e-02f, -3.05057541e-02f, 4.67927679e-02f, 8.78968835e-03f, -5.19396178e-03f, -4.04171553e-03f, -7.12538213e-02f, -1.14286214e-01f, -5.44709004e-02f,
  -1.87016830e-01f, 3.90377015e-01f, -1.77972361e-01f, -8.10876638e-02f, -6.50991406e-03f, -5.39363436e-02f, 7.09548965e-02f, 1.86230652e-02f, 1.08043198e-02f, -2.43377201e-02f,
  -5.55610806e-02f, 3.57946083e-02f, 5.57643455e-03f, 2.34373379e-02f, -5.79058491e-02f, 1.82259008e-02f, -5.17890602e-02f, -3.37478407e-02f, 6.77117854e-02f, -1.02425091e-01f,
  3.62203531e-02f, -1.24075457e-01f, -8.98535699e-02f, -1.24177814e-01f, -4.03517298e-02f, -1.15369618e-01f, 1.39933759e-02f, -1.00823417e-01f, -2.37120148e-02f, -3.22605789e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.13879018e-01f, 1.38196632e-01f, 3.60761166e-01f, 2.09747612e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  8.03918764e-02f, -2.50274211e-01f, 6.07741140e-02f, 4.80487011e-03f, 2.12862082e-02f, -9.42621604e-02f, -9.21023637e-02f, -1.45002142e-01f, -2.04953983e-01f, -3.48904908e-01f,
  -5.40289730e-02f, 8.07235420e-01f, -9.01439860e-02f, -2.77522445e-01f, 5.19590378e-01f, -1.08825520e-01f, 3.02205980e-01f, -7.87239134e-01f, 3.15803945e-01f, 2.76202168e-02f,
  1.65600494e-01f, 4.62196290e-01f, -3.45857114e-01f, -9.07956243e-01f, -7.10013449e-01f, 6.85083032e-01f, -4.46728647e-01f, -2.82403111e-01f, -3.71198356e-02f, -3.31625104e-01f,
  -6.52189250e-04f, -2.03303337e-01f, -3.59659433e-01f, 1.93903580e-01f, -1.35587379e-01f, 3.99852902e-01f, 9.76687670e-02f, -2.61372924e-01f, -1.22323044e-01f, -3.51125032e-01f,
  3.62779409e-01f, 6.81527197e-01f, -6.22333229e-01f, 5.78503251e-01f, -2.36995861e-01f, -5.41885979e-02f, 2.78679460e-01f, -2.26765737e-01f, 2.69522101e-01f, 3.79605681e-01f,
  -3.40087563e-01f, 2.76873913e-03f, -1.25261605e-01f, -7.60550573e-02f, 4.81918871e-01f, 9.54199851e-01f, 5.43906279e-02f, 1.42727673e-01f, 6.93549454e-01f, 3.14373016e-01f,
  3.03519636e-01f, 1.84061244e-01f, 3.99699569e-01f, -1.79686263e-01f, 1.21190995e-01f, 1.49550930e-01f, -9.13330913e-02f, -1.61108226e-01f, -3.75179559e-01f, -3.76381367e-01f,
  -5.74411571e-01f, -1.63095877e-01f, 4.14277971e-01f, -1.16874564e+00f, 2.63028234e-01f, -1.69967115e-01f, -2.79415082e-02f, -7.12604895e-02f, -9.16249081e-02f, 3.38154361e-02f,
  -4.17902529e-01f, 2.23191276e-01f, -1.16544023e-01f, -2.03090653e-01f, 3.73861462e-01f, -2.01162964e-01f, -4.26637381e-01f, 3.69323343e-01f, -1.85352549e-01f, -9.12417412e-01f,
  -5.70177853e-01f, -3.02097768e-01f, -1.57844678e-01f, -3.52041453e-01f, 3.23002070e-01f, 6.64067924e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.67242992e-01f, 5.82853436e-01f, 7.40628839e-01f, 1.46349356e-01f, -3.06868792e-01f, -3.99516642e-01f, -1.29756474e+00f, -2.36302853e-01f, 1.29411593e-01f, -6.18998110e-01f,
  -8.50336254e-01f, -1.08671224e+00f, -4.58505809e-01f, -3.81523341e-01f, 2.36968607e-01f, 7.90432245e-02f, 2.29695439e-01f, -5.93648925e-02f, 4.27095741e-01f, -5.88266738e-02f,
  -4.66162920e-01f, -6.37984693e-01f, 4.61105376e-01f, 6.96386516e-01f, 9.08589005e-01f, -5.09251416e-01f, 5.31588614e-01f, -3.62697005e-01f, 5.38419306e-01f, 1.69647664e-01f,
  9.64190543e-01f, -3.86301100e-01f, 4.90373582e-01f, -4.73168880e-01f, -3.30186635e-01f, -4.84986603e-01f, 5.60054064e-01f, 2.79681265e-01f, -2.18775526e-01f, -4.02780250e-02f,
  -5.82835436e-01f, -8.76241446e-01f, -1.60854086e-01f, -7.87190571e-02f, 5.60832739e-01f, -1.29825436e-02f, 6.92914486e-01f, 2.20917284e-01f, 6.01927280e-01f, 1.04823029e+00f,
  1.79144472e-01f, 5.46986103e-01f, -2.79770523e-01f, 2.35896885e-01f, -8.28911781e-01f, 2.11248428e-01f, -2.76861280e-01f, -7.92301714e-01f, 7.49861658e-01f, 3.89497519e-01f,
  -2.74077773e-01f, 9.67959464e-01f, 1.16471767e-01f, -2.10363328e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  8.06552052e-01f, 6.27312899e-01f, -1.02452926e-01f, 1.13614492e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -9.57618415e-01f, 3.37210685e-01f, -3.21537405e-02f, -6.60037696e-02f, -7.71102488e-01f, 2.86079377e-01f, 7.40732729e-01f, 3.45585883e-01f, 9.21033978e-01f, 9.40059066e-01f,
  -3.47145677e-01f, 6.70482814e-01f, -1.02474654e+00f, 5.57056665e-01f, 4.25690621e-01f, -4.53532636e-01f, 2.30116993e-01f, 4.66611117e-01f, 2.51105040e-01f, -1.11694619e-01f,
  1.79029763e-01f, -5.73856354e-01f, -8.04794252e-01f, -5.43847561e-01f, -1.11275768e+00f, 3.96615922e-01f, -1.02789901e-01f, -8.27597797e-01f, -8.59977603e-01f, 1.11663759e+00f,
  -1.72331259e-01f, -7.01905847e-01f, 5.21273613e-01f, 9.17563438e-01f, 7.76267767e-01f, 9.50845003e-01f, -9.80200648e-01f, 6.98808670e-01f, -8.97730827e-01f, 3.47521268e-02f,
  -2.39866421e-01f, 4.00679231e-01f, -6.65756404e-01f, 4.31737155e-01f, -2.85681516e-01f, -7.56551266e-01f, -3.40799838e-01f, -6.04529560e-01f, -9.46199834e-01f, 9.81785655e-02f,
  2.50318944e-01f, -2.23470971e-01f, 5.84106266e-01f, -1.09720385e+00f, 2.31065765e-01f, -5.34274280e-01f, 4.45808053e-01f, 2.39453807e-01f, 5.61885774e-01f, 4.73858446e-01f,
  3.33851486e-01f, 3.38191360e-01f, 6.05613887e-01f, 2.28896290e-01f, 2.67787278e-02f, 4.73469138e-01f, -1.25550210e+00f, -2.01843470e-01f, 1.70238361e-01f, 2.47467726e-01f,
  1.18284988e+00f, -7.50991344e-01f, 1.00909483e+00f, 2.97726959e-01f, -4.57381546e-01f, 6.40520751e-01f, 4.29646790e-01f, 6.56171620e-01f, -5.34744859e-01f, 1.00096121e-01f,
  3.06691438e-01f, 8.92327249e-01f, 2.73042083e-01f, -8.65483359e-02f, 2.43462250e-01f, -1.82640761e-01f, 3.47653218e-02f, -2.01741010e-01f, -4.92294341e-01f, 6.25701904e-01f,
  -4.04565930e-01f, -8.65720332e-01f, -4.37747300e-01f, -7.23829389e-01f, -1.49932772e-01f, 1.37367141e+00f, 1.44292593e-01f, -9.70197380e-01f, 2.92815417e-01f, -4.36191797e-01f,
  3.18184793e-01f, 5.27970612e-01f, -5.06548464e-01f, -3.44763696e-01f, 1.86971411e-01f, -6.21710598e-01f, -4.37955111e-01f, -2.41446882e-01f, 1.18789744e+00f, -5.60947537e-01f,
  -1.54300526e-01f, -6.12826765e-01f, 1.41560137e-01f, -6.00820839e-01f, -2.35816985e-01f, 4.47531581e-01f, 1.13160983e-01f, 5.85913146e-03f, -8.29273537e-02f, 4.31298196e-01f,
  -9.48245883e-01f, -3.91645283e-02f, 6.83071017e-02f, 5.18823028e-01f, -2.63092726e-01f, -4.13867742e-01f, 1.32905018e+00f, -3.67669463e-01f, 2.85752982e-01f, -1.16703743e-02f,
  -6.70430064e-01f, 7.63228461e-02f, -3.23944688e-01f, 4.35621083e-01f, -3.40482801e-01f, -6.83309197e-01f, -9.41594720e-01f, 1.88822020e-02f, 1.27412784e+00f, 2.11405188e-01f,
  5.85468650e-01f, 5.04361868e-01f, -3.55319738e-01f, 3.79549086e-01f, 3.68578553e-01f, -5.98448157e-01f, -8.84844214e-02f, 7.45962024e-01f, -4.24084477e-02f, 5.72569892e-02f,
  5.81142604e-01f, 1.07528913e+00f, 9.82986510e-01f, -1.08679593e+00f, -6.87313318e-01f, -1.11450601e+00f, -8.62099975e-02f, -3.91832203e-01f, -4.06865835e-01f, -2.56785363e-01f,
  1.04842469e-01f, -1.19213319e+00f, -9.97436941e-02f, -1.72397271e-01f, 2.68121630e-01f, -2.48222589e-01f, 7.29305521e-02f, -3.84217888e-01f, 7.10716769e-02f, 5.62403761e-02f,
  5.68794012e-01f, -5.01807928e-01f, -9.67758894e-01f, 3.44688118e-01f, -1.77615374e-01f, 1.20260644e+00f, -1.00705609e-01f, 3.47880572e-01f, 2.27970287e-01f, -5.84740698e-01f,
  2.33928617e-02f, -6.46616578e-01f, -3.70512679e-02f, 4.75375831e-01f, -2.98050735e-02f, -5.36725521e-01f, 1.14834762e+00f, 9.55853462e-01f, 1.23130727e+00f, -6.83256447e-01f,
  -2.15483800e-01f, 8.13738629e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.76324368e-01f, 3.77102882e-01f, 4.25189584e-01f, -3.57269466e-01f, 1.30738601e-01f, -5.94901340e-03f, -2.84904569e-01f, -1.99716225e-01f, -4.41687644e-01f, 4.08420742e-01f,
  -4.64789122e-01f, -6.00458272e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    