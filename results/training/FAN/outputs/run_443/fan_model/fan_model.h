/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.77104282e-01f, 5.94418943e-01f, -3.04819107e-01f, 1.39316440e-01f, -4.69286405e-02f, 1.88027963e-03f, 6.94490597e-02f, 7.37771019e-02f, 2.54549235e-01f, 5.65286815e-01f,
  -5.65142632e-02f, 1.32494807e-01f, -7.33871236e-02f, 3.31765294e-01f, -6.54820979e-01f, -2.14326419e-02f, 7.74541497e-02f, 2.15451494e-01f, -2.50136312e-02f, 2.14268323e-02f,
  -3.95111553e-02f, 7.46257007e-02f, -2.54454583e-01f, 4.68866862e-02f, -7.31121227e-02f, -1.59163005e-03f, -1.16987616e-01f, -1.22077353e-01f, 4.98115756e-02f, -1.22769170e-01f,
  5.71643263e-02f, 2.04286948e-01f, 3.90964374e-02f, 3.07552312e-02f, 6.80546742e-03f, -8.22247490e-02f, 1.38533674e-02f, -1.44962743e-01f, -1.54234141e-01f, 2.47111581e-02f,
  -4.75133173e-02f, 3.20429094e-02f, 3.99327949e-02f, -7.67919049e-02f, 2.06382021e-01f, 1.86197385e-02f, -1.72190387e-02f, -4.76564914e-02f, 1.38771951e-01f, -4.58044261e-02f,
  -4.21811305e-02f, -6.79696351e-02f, -2.41893195e-02f, -2.01233197e-02f, -8.41373652e-02f, 4.54671308e-02f, 1.08591896e-02f, -9.29066837e-02f, 7.86082894e-02f, 2.61871904e-01f,
  -2.50428654e-02f, 1.97883565e-02f, -7.55676031e-02f, -5.81015237e-02f, -7.75584951e-03f, -2.03164965e-02f, 5.22887520e-02f, -5.52071743e-02f, -1.99987856e-03f, -1.86233278e-02f,
  3.54625983e-03f, -2.27619614e-02f, 1.70944165e-02f, 5.45296967e-02f, 8.44091699e-02f, 1.08515531e-01f, -5.23267351e-02f, -3.10596153e-02f, 5.47700673e-02f, -1.90077052e-01f,
  -4.17862460e-03f, 3.20007093e-02f, 4.17530909e-02f, -4.98116724e-02f, 8.50690603e-02f, -1.50707722e-01f, -2.45417729e-02f, 3.10243629e-02f, -4.85456139e-02f, -1.21529736e-01f,
  6.94508627e-02f, 1.43874884e-01f, 8.72081425e-03f, 1.47045990e-02f, 4.04013507e-02f, 3.98937836e-02f, -1.33215666e-01f, 8.41903985e-02f, 3.89704071e-02f, -5.69589511e-02f,
  3.17805037e-02f, -8.79037753e-03f, 6.05370328e-02f, -1.43278809e-03f, -1.09528966e-01f, 3.35279219e-02f, 2.29113386e-03f, 4.10329178e-03f, -2.11003870e-01f, -3.88222048e-04f,
  5.56499548e-02f, 6.45463243e-02f, -5.52722886e-02f, 1.37009677e-02f, -1.68994546e-03f, -3.44032794e-02f, -2.80458224e-03f, 1.24524951e-01f, -1.24188825e-01f, -8.92233849e-03f,
  4.60070848e-01f, -1.19319685e-01f, 1.60742208e-01f, -1.25513487e-02f, 3.05577099e-01f, 3.14306170e-01f, 1.65225163e-01f, 1.96221530e-01f, 2.62192607e-01f, -3.12485099e-01f,
  3.92909348e-03f, -1.66248083e-01f, -1.26502052e-01f, -4.60374206e-02f, 5.66488743e-01f, 1.65345624e-01f, 2.86271930e-01f, 7.73827881e-02f, 8.85802582e-02f, 1.66183189e-01f,
  7.52614811e-02f, -3.21117230e-02f, -3.10920645e-02f, -1.27629802e-01f, -1.74577475e-01f, -6.40153661e-02f, -5.65023758e-02f, 4.06239815e-02f, -2.50856936e-01f, 9.26552787e-02f,
  1.77567557e-01f, -6.32069856e-02f, -1.84891000e-01f, -8.75365138e-02f, 8.27343948e-03f, -4.16523544e-03f, 5.11161573e-02f, -2.33655758e-02f, -2.40831133e-02f, -2.72551775e-02f,
  -1.95141494e-01f, -4.75414051e-03f, -1.70423299e-01f, -4.34073992e-02f, 4.41991426e-02f, -7.37609714e-02f, -2.33918596e-02f, -4.24891040e-02f, -7.73487836e-02f, 9.85448137e-02f,
  -5.13102561e-02f, 4.68237214e-02f, -1.79944187e-02f, 7.46529400e-02f, -2.94488785e-03f, -9.12118480e-02f, 8.86929557e-02f, 1.59547791e-01f, 1.14370957e-01f, 3.23185474e-02f,
  2.17727758e-02f, 2.02756748e-01f, -8.26681852e-02f, 9.30544641e-03f, 2.92354394e-02f, -1.05371177e-01f, -1.85639355e-02f, -7.36431256e-02f, -2.81680562e-02f, 1.20139271e-01f,
  -5.62796788e-03f, -1.34745259e-02f, 4.70741801e-02f, -8.28849673e-02f, -4.95202877e-02f, -5.38882539e-02f, 2.63772104e-02f, 4.41139709e-04f, 2.21995190e-02f, 3.90045792e-02f,
  -2.28363406e-02f, 1.02836877e-01f, -3.87927182e-02f, 1.02079108e-01f, 4.40331399e-02f, 5.15938252e-02f, -1.42265841e-01f, 2.21334472e-02f, 5.07808626e-02f, -5.00377417e-02f,
  3.78789485e-01f, 1.96430728e-01f, 9.44782514e-03f, -2.79505011e-02f, 8.44837949e-02f, -3.07519995e-02f, 3.83596085e-02f, -5.37442102e-04f, 1.22475535e-01f, -2.61965487e-03f,
  6.97612613e-02f, -1.28343076e-01f, 1.51604563e-01f, 6.02120869e-02f, 5.61288616e-04f, 3.73111479e-02f, 1.22271758e-02f, 8.97781458e-03f, 6.62394464e-02f, 5.69715770e-03f,
  -2.40163021e-02f, -8.34646374e-02f, -9.15174857e-02f, -1.00818910e-01f, -5.63489273e-02f, -4.64871489e-02f, 3.19856219e-02f, -2.91166920e-02f, -8.55951980e-02f, 6.16084635e-02f,
  1.08861223e-01f, 1.41275898e-01f, -1.78490445e-01f, 2.79515237e-01f, 2.05810219e-01f, 2.21085280e-01f, 1.56334013e-01f, 2.47777835e-01f, 9.81334001e-02f, 1.68922514e-01f,
  1.07979909e-01f, 1.18244819e-01f, -2.08295450e-01f, 3.57626528e-01f, -2.69094437e-01f, 1.23745836e-02f, 2.80095220e-01f, 2.41005272e-01f, 5.82472328e-03f, 1.01213820e-01f,
  -4.18557040e-02f, 2.37608939e-01f, -5.78813218e-02f, 6.42606318e-02f, 1.81789339e-01f, 5.00939600e-02f, -2.25260913e-01f, -2.58835435e-01f, 1.26729444e-01f, -3.08943745e-02f,
  -8.12790170e-02f, 1.65533755e-04f, 7.34014735e-02f, -1.43003151e-01f, -7.26143569e-02f, -1.19995907e-01f, -1.28348917e-01f, -1.14116795e-01f, -2.17100829e-02f, 6.46062866e-02f,
  2.20469069e-02f, 1.11900501e-01f, 7.28455335e-02f, 1.01247393e-02f, 2.37759459e-03f, -7.86871687e-02f, 1.54584676e-01f, 1.76003203e-01f, 1.31438956e-01f, 3.26044522e-02f,
  5.18506803e-02f, 3.37592475e-02f, -2.03804579e-04f, 9.74893048e-02f, -5.00211827e-02f, 1.81487009e-01f, 2.31753830e-02f, -1.34032592e-02f, 1.99629762e-03f, 7.63032958e-02f,
  7.30738044e-02f, -1.01046525e-01f, -1.69597529e-02f, 5.18482625e-02f, -2.65518744e-02f, 1.51653467e-02f, -6.28030859e-03f, -8.29179659e-02f, -9.34343040e-02f, -2.54038926e-02f,
  1.15840271e-01f, 3.53767388e-02f, 8.23047459e-02f, -5.33886030e-02f, 1.07489126e-02f, 1.61752012e-02f, -4.79953596e-04f, 7.65638575e-02f, 6.98403269e-02f, 1.54274061e-01f,
  7.89335966e-02f, -3.98781858e-02f, 6.94754198e-02f, -8.93946886e-02f, 2.18072366e-02f, -1.06284551e-01f, -7.56310001e-02f, 4.34170701e-02f, -2.46348213e-02f, -1.19343773e-01f,
  -1.25918716e-01f, -3.85419667e-01f, -7.02152727e-03f, 3.69272232e-02f, 1.98489856e-02f, 3.71297263e-02f, -2.30393726e-02f, 1.02437615e-01f, -1.18859105e-01f, 5.23887649e-02f,
  -6.95134997e-02f, -1.50742140e-02f, -1.28732964e-01f, 1.65776983e-02f, 2.39614304e-02f, 1.45035563e-02f, -7.47585744e-02f, -1.17066160e-01f, -1.50511786e-01f, 1.95010211e-02f,
  1.12680830e-02f, -5.56096062e-02f, -6.50249273e-02f, 2.56416295e-02f, -6.16261847e-02f, -2.37928145e-02f, -3.33788805e-02f, -1.39658200e-03f, -1.20721366e-02f, -1.66076850e-02f,
  6.26489297e-02f, 1.94351047e-01f, -3.87953579e-01f, 1.00088485e-01f, -5.58590181e-02f, -9.57807340e-03f, 2.40498990e-01f, -6.77323490e-02f, 2.16457933e-01f, 3.66071761e-01f,
  4.14217949e-01f, 9.48664770e-02f, 3.53564501e-01f, 4.90990609e-01f, -4.15541083e-01f, 3.82990599e-01f, -8.94384310e-02f, 8.94829258e-02f, 1.55451626e-01f, -1.36810377e-01f,
  -1.97330028e-01f, 2.87739575e-01f, -1.60954401e-01f, -1.58796966e-01f, 1.86168365e-02f, -3.35023016e-01f, -8.06957632e-02f, -2.10111514e-02f, 1.93005372e-02f, -3.88553664e-02f,
  7.89461285e-02f, 2.23532587e-01f, -5.71421459e-02f, 4.44352627e-02f, -1.66485757e-01f, -5.47120795e-02f, -1.04459196e-01f, -3.86606604e-02f, -7.81515017e-02f, 2.71087009e-02f,
  5.22568785e-02f, -1.12764880e-01f, -5.61764352e-02f, -1.80764813e-02f, 5.80755137e-02f, -5.34715727e-02f, -4.57822531e-02f, 8.54139552e-02f, 6.36594146e-02f, 2.77962144e-02f,
  5.73305786e-02f, -4.94114421e-02f, 3.72157954e-02f, -7.18768761e-02f, -1.01910301e-01f, -1.42309302e-02f, -7.60158896e-02f, -9.15167332e-02f, 1.04217373e-01f, -1.47926524e-01f,
  4.06264886e-02f, 4.65632640e-02f, 8.25740490e-03f, 1.65799484e-01f, -5.62330335e-02f, 6.69416934e-02f, 1.42256200e-01f, 1.84867401e-02f, -3.40761170e-02f, 3.54839023e-03f,
  2.13094596e-02f, -4.82644029e-02f, 1.61778003e-01f, 4.00298424e-02f, 6.74109235e-02f, 1.86540913e-02f, 2.10347977e-02f, -4.34365618e-04f, 4.67587784e-02f, 1.23331152e-01f,
  6.77689835e-02f, -4.58956808e-02f, -2.77858712e-02f, 1.80758797e-02f, 7.00171068e-02f, -6.77514970e-02f, 5.19752987e-02f, 2.54798532e-02f, -9.28023923e-03f, -4.89386283e-02f,
  -3.68064642e-02f, -8.31436589e-02f, 6.55865818e-02f, -5.40873501e-03f, 9.57327262e-02f, -2.53872890e-02f, 1.27914101e-01f, -3.14955898e-02f, -3.82855646e-02f, -1.72305815e-02f,
  -1.39347136e-01f, 9.17648990e-03f, -5.41633973e-03f, 7.95179699e-03f, -8.81005228e-02f, 4.01618816e-02f, 5.98577932e-02f, -1.65714219e-01f, -5.42291142e-02f, -3.38376313e-02f,
  -9.49888751e-02f, 5.35048693e-02f, -6.47859555e-03f, -8.71915296e-02f, -9.95105598e-03f, -1.60403214e-02f, -7.56253004e-02f, 3.62594472e-03f, -2.85672303e-02f, 1.55335397e-01f,
  -3.78161371e-01f, 2.72809833e-01f, -1.58345506e-01f, 3.47484291e-01f, -3.00254554e-01f, 4.29582715e-01f, 1.54425934e-01f, 1.82481542e-01f, -2.48772010e-01f, 3.18094045e-01f,
  1.91300824e-01f, 5.62812248e-03f, 1.71749637e-01f, 4.88892794e-01f, 2.18469307e-01f, 2.20900178e-01f, 2.61937618e-01f, 1.60217583e-01f, -2.14149877e-01f, 2.42915582e-02f,
  -9.51373670e-03f, 3.54828238e-01f, 1.82747811e-01f, 4.69793938e-02f, 2.47654971e-02f, 2.63639875e-02f, 1.24237590e-01f, -9.72784460e-02f, 2.73358256e-01f, 1.23363771e-01f,
  -3.08102425e-02f, -1.77543923e-01f, -8.36948752e-02f, -3.85965593e-02f, 7.37786070e-02f, -5.30344201e-04f, -4.39174054e-03f, -2.84171533e-02f, -3.31160389e-02f, 3.68188061e-02f,
  -2.84441505e-02f, -4.41965871e-02f, 7.97368288e-02f, 8.20848066e-03f, -1.11947156e-01f, -3.22454982e-02f, -7.24843843e-03f, -7.36501487e-03f, -1.64999962e-02f, -2.51239911e-02f,
  -7.28923604e-02f, -5.76068508e-03f, -6.73002331e-03f, 2.13243812e-02f, -7.82892406e-02f, -2.46097781e-02f, 3.72857973e-02f, 1.67273115e-02f, -1.01359561e-02f, -1.44177834e-02f,
  5.39815463e-02f, -4.46313201e-03f, -8.33005607e-02f, 2.22703032e-02f, -1.54534224e-02f, -2.11390369e-02f, 3.79604846e-02f, 2.88690478e-02f, -1.00003453e-02f, 7.45716272e-03f,
  -3.35611328e-02f, -8.47489049e-04f, 1.26563841e-02f, 5.79254888e-02f, 1.90484393e-02f, 4.04888429e-02f, -3.46226282e-02f, 2.80469600e-02f, -7.24864155e-02f, -2.94331964e-02f,
  1.17946947e-02f, 1.67644881e-02f, 2.57091951e-02f, -1.51727321e-02f, 9.83237401e-02f, 2.78318860e-03f, 7.94250518e-02f, 1.03012123e-03f, 3.54276486e-02f, 6.20621853e-02f,
  2.90222138e-01f, 4.43026811e-01f, 8.43484327e-02f, -5.01813833e-03f, -2.62844209e-02f, -1.03567459e-01f, -3.99051793e-02f, 1.07986577e-01f, 7.00175390e-02f, -3.65164801e-02f,
  -5.14348270e-03f, 4.95881587e-02f, 2.33368576e-02f, 2.86970916e-03f, 1.05304187e-02f, 3.77810299e-02f, -3.90435643e-02f, -3.36614810e-02f, 7.12078214e-02f, 5.06190658e-02f,
  1.12365760e-01f, -6.64384197e-03f, -6.10406883e-02f, -3.47378515e-02f, 5.43891750e-02f, -1.75800102e-04f, -2.04047244e-02f, -1.32690445e-01f, 5.44656487e-03f, 2.85946727e-02f,
  -2.94537067e-01f, 3.19109172e-01f, 3.33029069e-02f, -5.88287376e-02f, -2.69634515e-01f, -2.48003960e-01f, -1.14277519e-01f, -3.00206449e-02f, 1.20703161e-01f, 1.26588047e-01f,
  9.27644670e-02f, 7.86801204e-02f, 3.19894940e-01f, 1.03331976e-01f, -2.42264926e-01f, 4.49562758e-01f, -2.37206861e-01f, 4.71736453e-02f, 1.77391410e-01f, -1.94963515e-01f,
  3.19628827e-02f, -1.03057094e-01f, 9.23730955e-02f, -1.49859682e-01f, -2.43087873e-01f, -8.20003152e-02f, -3.57135087e-01f, -1.57456979e-01f, -2.42722154e-01f, -5.63470945e-02f,
  7.81556517e-02f, 2.19032004e-01f, 2.17678794e-03f, 1.17224522e-01f, -4.40674685e-02f, -1.21604152e-01f, -1.82820737e-01f, -5.63519448e-02f, 2.00291108e-02f, 6.76018521e-02f,
  -1.23421587e-02f, 2.81765684e-02f, 1.26948208e-01f, -1.49574773e-02f, -9.34835002e-02f, -3.05121001e-02f, 1.81250460e-02f, 1.11936688e-01f, 1.17371291e-01f, 9.75529104e-02f,
  1.17293850e-01f, 9.25077647e-02f, -1.75306514e-01f, 1.03884400e-03f, -2.92527433e-02f, 2.27937121e-02f, -5.08546829e-02f, 3.11270193e-03f, -5.75889982e-02f, -8.27824175e-02f,
  -2.19188835e-02f, 1.02062384e-02f, 4.03366871e-02f, -9.13033169e-03f, 2.84000542e-02f, -5.45991957e-02f, 3.84204625e-03f, 9.37457830e-02f, -3.30345370e-02f, -1.62221640e-02f,
  -7.67783821e-02f, -2.74308976e-02f, -1.47540830e-02f, -6.08027205e-02f, -3.04205734e-02f, 2.84874365e-02f, -1.20030381e-01f, 5.24195917e-02f, -1.13647006e-01f, -4.31974828e-02f,
  -7.33278226e-03f, -4.47544344e-02f, 4.40553650e-02f, -1.06121480e-01f, 2.29023416e-02f, -5.25752008e-02f, 6.27270788e-02f, 3.97681892e-02f, 4.97782715e-02f, -1.50238663e-01f,
  -1.81358084e-02f, -4.16893512e-02f, 1.08528890e-01f, -9.50623676e-03f, 7.09557533e-02f, 1.53175509e-02f, 1.23249918e-01f, -5.50518744e-02f, -2.20295470e-02f, 5.41937363e-04f,
  -5.81159033e-02f, -2.36193333e-02f, -1.35464430e-01f, 5.58820320e-03f, -3.50560732e-02f, -2.91892458e-02f, -2.92875804e-02f, -1.16651811e-01f, -2.22973868e-01f, 2.24843342e-02f,
  -1.40859291e-01f, -1.10563494e-01f, 6.15904443e-02f, -1.16601907e-01f, -8.48014876e-02f, -1.53839765e-02f, -1.22003995e-01f, 8.18521306e-02f, -2.35923491e-02f, 1.51370950e-02f,
  -4.27432090e-01f, 6.38115823e-01f, 2.52210498e-01f, -5.24709001e-02f, -2.00924009e-01f, -1.84365977e-02f, -2.28002205e-01f, 2.48096526e-01f, -4.02178824e-01f, 3.80079359e-01f,
  2.54968584e-01f, 1.55692592e-01f, 2.09443986e-01f, 2.32110694e-01f, -3.95928472e-01f, 7.23179057e-02f, 1.01161741e-01f, 1.16686234e-02f, -1.58332661e-01f, 1.74838498e-01f,
  3.68293971e-02f, 7.76776448e-02f, 1.77133203e-01f, -8.40719510e-03f, 1.60305962e-01f, 1.03100680e-01f, -2.93642581e-02f, -3.77407819e-02f, 1.75623119e-01f, 8.16766322e-02f,
  4.10610959e-02f, 3.86357531e-02f, 4.97529767e-02f, -2.59487703e-02f, 1.25985101e-01f, 9.42617059e-02f, -1.15917800e-02f, -5.25717139e-02f, -9.15857255e-02f, 4.06598151e-02f,
  -5.30845225e-02f, -2.66606193e-02f, -1.06722834e-02f, -2.20437199e-02f, -4.88459207e-02f, -2.95432191e-02f, -7.12037738e-03f, 8.27329084e-02f, 4.99855280e-02f, 2.36685667e-02f,
  9.04021878e-03f, 1.61337763e-01f, 2.20627990e-02f, 6.95855543e-02f, -3.21136788e-02f, -1.07354090e-01f, -5.23590185e-02f, 1.00968175e-01f, 3.87818553e-02f, -1.84265953e-02f,
  5.66540882e-02f, -9.28132422e-03f, 2.82613393e-02f, -4.47602049e-02f, 1.10427942e-03f, 3.23263742e-03f, -6.39575906e-03f, 8.23970363e-02f, -3.91759314e-02f, 9.90487412e-02f,
  -4.39883322e-02f, 1.21275997e-02f, 8.96748975e-02f, -9.23262909e-02f, 4.39494923e-02f, 3.04938331e-02f, -1.62752151e-01f, 4.26631905e-02f, 2.51935050e-03f, 1.79013964e-02f,
  2.74095088e-02f, -1.01662830e-01f, 1.04054421e-01f, 6.03936948e-02f, 2.41849688e-03f, -3.69713106e-03f, 5.74676879e-02f, 1.13111310e-01f, 3.31655629e-02f, -7.98145160e-02f,
  1.96134120e-01f, 1.84003472e-01f, 4.63702269e-02f, 3.84792723e-02f, -8.69876370e-02f, 1.41712204e-02f, -1.66241787e-02f, -2.36877259e-02f, -2.83380179e-03f, -3.18246372e-02f,
  2.99909413e-02f, 3.10886111e-02f, 1.21483486e-02f, -5.86302094e-02f, -4.56601344e-02f, 7.39221424e-02f, 5.41429967e-04f, -1.19884923e-01f, -7.12951198e-02f, 7.86948055e-02f,
  6.86236098e-03f, -9.89047065e-02f, -8.21472406e-02f, -3.05757904e-03f, 4.18546721e-02f, 1.09265313e-01f, 7.11880624e-02f, -9.50426757e-02f, 3.88937467e-03f, -7.27539584e-02f,
  6.13915801e-01f, -1.36668347e-02f, 2.73531824e-02f, 7.44076818e-02f, 4.69709575e-01f, 5.61147630e-01f, 3.58703509e-02f, 2.26157650e-01f, -2.38226458e-01f, -7.44821429e-02f,
  -2.18492895e-02f, -9.12186783e-03f, -1.46615788e-01f, 5.95272295e-02f, -2.03426704e-02f, -4.79012042e-01f, -2.56517902e-02f, -1.63104653e-01f, -6.67818040e-02f, 3.53619084e-02f,
  1.55297086e-01f, 4.32675369e-02f, 1.39038920e-01f, 1.99289899e-02f, 4.55677539e-01f, 1.87103495e-01f, -7.54217617e-05f, -9.03532580e-02f, 2.52765834e-01f, -4.02420461e-02f,
  1.58525184e-02f, -4.38897349e-02f, 5.69482818e-02f, -8.53431076e-02f, 1.92777738e-01f, 6.18305355e-02f, 6.72537833e-03f, -4.80937921e-02f, -5.08473217e-02f, -5.94304465e-02f,
  -1.26160055e-01f, 3.56091633e-02f, 1.01354932e-02f, -3.20506059e-02f, 1.16044909e-01f, -5.28536439e-02f, 3.24541703e-02f, 7.09646344e-02f, 5.33371568e-02f, 2.40468577e-01f,
  2.90275533e-02f, 2.80008204e-02f, 1.10822983e-01f, -1.38613626e-01f, 1.25755161e-01f, 7.71958707e-03f, 5.55066429e-02f, 7.27959499e-02f, -4.49045561e-02f, 1.17277622e-01f,
  1.74377207e-02f, 8.08683932e-02f, 1.49556771e-02f, -6.95263920e-03f, -2.24413965e-02f, 8.38681869e-03f, -6.95186108e-02f, 1.83775686e-02f, 1.49434321e-02f, 9.46114734e-02f,
  -1.89486425e-02f, 3.16257626e-02f, 1.48677891e-02f, 1.08990602e-01f, 3.71189341e-02f, 2.85516232e-02f, -1.63034480e-02f, -1.94705036e-02f, 3.68697941e-02f, 1.29853055e-01f,
  -1.43568233e-01f, -4.63956185e-02f, -1.00176064e-02f, -5.30880913e-02f, -3.40665430e-02f, 5.10499626e-02f, 6.98644891e-02f, 4.50254492e-02f, 4.89050476e-03f, 4.90671629e-03f,
  -1.08310014e-01f, -1.60172001e-01f, -5.05950935e-02f, 4.04329263e-02f, -2.40537316e-01f, 4.97596823e-02f, -8.55794027e-02f, 8.01353827e-02f, -7.25882575e-02f, -6.62606210e-02f,
  9.39552188e-02f, -1.92757510e-02f, -5.81778474e-02f, 2.28727572e-02f, -6.46406040e-02f, 1.62834078e-01f, -1.72668070e-01f, -8.84257182e-02f, 7.04668416e-03f, -3.07997279e-02f,
  1.42069859e-03f, 1.26685891e-02f, -9.36879292e-02f, 5.55161163e-02f, -2.04430874e-02f, 3.56633253e-02f, 8.16253275e-02f, 3.68248224e-02f, -4.50294539e-02f, -1.56429067e-01f,
  -7.38990828e-02f, 4.88655806e-01f, 2.39567459e-01f, -4.56429124e-02f, 1.95799634e-01f, 4.06692147e-01f, -1.09177016e-01f, 2.28252694e-01f, 3.02963853e-01f, -5.12367263e-02f,
  -2.20422819e-02f, -8.63484368e-02f, 1.26536172e-02f, 2.79096421e-02f, -2.92791337e-01f, 1.21172361e-01f, -8.59065428e-02f, 1.57992635e-03f, 2.56308317e-01f, -9.93520096e-02f,
  7.00555369e-02f, -1.36256382e-01f, -5.49240522e-02f, 2.64734536e-01f, 1.32696539e-01f, 7.81104863e-02f, -6.41821384e-01f, 1.36389807e-01f, -1.37586743e-01f, 2.44996343e-02f,
  1.29495844e-01f, 2.73676157e-01f, 2.09992044e-02f, 5.28135113e-02f, -1.43387401e-03f, -4.89759184e-02f, -4.14774828e-02f, -1.06465966e-01f, 4.70215753e-02f, 7.56735057e-02f,
  -2.00892575e-02f, 6.72923625e-02f, 5.02302451e-03f, 8.31810385e-02f, 1.53660044e-01f, 5.44581041e-02f, 1.59125656e-01f, 1.33795187e-01f, 5.38430028e-02f, 1.08975194e-01f,
  1.94562405e-01f, 1.64836138e-01f, -3.98419537e-02f, -4.13892325e-03f, -3.12346984e-02f, 8.92856866e-02f, 1.33805284e-02f, -4.46887612e-02f, 3.59792523e-02f, 7.87292123e-02f,
  3.81430164e-02f, -5.29633043e-03f, 6.09274860e-03f, 1.27775064e-02f, 1.76724661e-02f, 1.32570211e-02f, 4.10228297e-02f, -5.83042130e-02f, 9.83003452e-02f, -3.99458669e-02f,
  -6.73786104e-02f, 8.49084835e-03f, 4.88360226e-02f, 2.07224190e-02f, -2.83396970e-02f, -3.72812562e-02f, -7.14306682e-02f, 7.72732496e-02f, -7.87827969e-02f, -1.35619804e-01f,
  2.56542098e-02f, -7.80341821e-03f, -8.64612535e-02f, -1.11804102e-02f, 9.47615504e-02f, 4.49330471e-02f, 8.23629946e-02f, 1.48686051e-01f, -6.25503287e-02f, -1.28940672e-01f,
  -1.54046163e-01f, -1.22909263e-01f, -2.54936311e-02f, 7.84784481e-02f, -5.50130308e-02f, -5.68969250e-02f, 8.08997229e-02f, 3.37045752e-02f, 1.17294751e-02f, -6.53888062e-02f,
  1.07563632e-02f, -2.58312020e-02f, -1.72676295e-02f, -1.46833044e-02f, -1.10800028e-01f, 3.09155118e-02f, -8.75016451e-02f, -1.48997679e-01f, -1.83943331e-01f, -7.04803765e-02f,
  -1.06488407e-01f, -1.01666637e-01f, -6.18733354e-02f, 1.40317995e-02f, -4.42537367e-02f, -1.00439668e-01f, -1.12307612e-02f, 4.04906906e-02f, 2.18879394e-02f, -2.86788866e-02f,
  3.06373626e-01f, -1.67593852e-01f, -5.81251800e-01f, 8.24712813e-02f, 4.15011317e-01f, 4.13978100e-01f, 1.16190173e-01f, 5.97975589e-02f, 1.35189161e-01f, 5.49663976e-02f,
  2.96533525e-01f, -3.68557334e-01f, 4.09566239e-02f, -1.04617164e-01f, -1.14257284e-01f, -1.45261154e-01f, 3.82212810e-02f, -3.97211611e-02f, -7.90539980e-02f, 3.74420471e-02f,
  9.49821714e-03f, 3.77348572e-01f, -2.81612456e-01f, 8.92086551e-02f, 1.19130164e-01f, -1.50478363e-01f, 3.77417319e-02f, -1.41268998e-01f, 1.73647046e-01f, -1.63933456e-01f,
  2.26354912e-01f, -1.55960277e-01f, -1.89124290e-02f, -7.86417276e-02f, 4.34874296e-02f, -1.27327312e-02f, 3.40064056e-02f, -1.31951317e-01f, -6.55946461e-03f, -3.77344601e-02f,
  7.01114954e-03f, -2.20837072e-02f, -3.43777984e-02f, -2.65614539e-02f, 1.55808747e-01f, 1.53342979e-02f, -5.61026223e-02f, -2.64552161e-02f, -3.46072763e-02f, 2.41333097e-02f,
  -5.08647077e-02f, -4.57877479e-02f, 4.81464490e-02f, -4.40479629e-02f, -1.22745279e-02f, 5.21152690e-02f, -1.39330298e-01f, -8.44638720e-02f, 5.42204008e-02f, 2.33897567e-02f,
  -5.03759719e-02f, -1.78225692e-02f, -4.19632681e-02f, 1.70320421e-02f, 5.73888794e-02f, -4.79301624e-02f, 2.35893633e-02f, 4.49778847e-02f, -2.49948781e-02f, 7.08771497e-02f,
  8.80892128e-02f, -1.52181750e-02f, 3.87918390e-02f, 8.42734948e-02f, 1.05583698e-01f, 4.93561365e-02f, 4.12148573e-02f, -2.03284062e-02f, 2.78439820e-02f, 7.32571557e-02f,
  -1.21448144e-01f, 9.45504084e-02f, -2.28527542e-02f, 9.08947885e-02f, -3.91700454e-02f, -9.41184722e-03f, -3.44803499e-04f, -7.00830519e-02f, -5.03529459e-02f, 8.74807462e-02f,
  3.36001128e-01f, -9.42070112e-02f, -8.92423540e-02f, 7.62799010e-02f, -1.63383142e-03f, 3.88795845e-02f, -6.96039870e-02f, -3.31567265e-02f, -3.07343453e-02f, 1.69647429e-02f,
  -3.24027352e-02f, 1.35869592e-01f, 8.17481801e-02f, 8.31061900e-02f, -3.70995663e-02f, 5.88884242e-02f, -4.52368986e-03f, 6.70177117e-02f, 8.66984650e-02f, -5.37861921e-02f,
  8.00244790e-03f, 1.98662467e-02f, -4.80669215e-02f, 7.11509287e-02f, -1.69793461e-02f, 2.20700558e-02f, 1.10380948e-01f, -3.03919800e-02f, -4.40849513e-02f, -5.82010075e-02f,
  -1.27908438e-01f, 2.03153849e-01f, 7.73138599e-03f, 1.76880211e-01f, 2.84280241e-01f, 2.19680160e-01f, 2.63822079e-01f, 1.50110096e-01f, 5.76533079e-01f, 1.35571852e-01f,
  2.20984325e-01f, -1.65224180e-01f, 4.75747325e-02f, 4.86553870e-02f, -1.13397807e-01f, 4.57500815e-02f, -4.05142270e-02f, -1.48888990e-01f, -7.34784827e-02f, -3.38133186e-01f,
  -1.58864260e-01f, 2.26598065e-02f, -3.33562732e-01f, -2.21653014e-01f, -1.72147647e-01f, -1.70553535e-01f, -1.80973411e-01f, -8.07240680e-02f, -1.58430293e-01f, 1.29704535e-01f,
  -3.19469236e-02f, 1.48142263e-01f, 1.42808389e-02f, -2.50912141e-02f, 5.15823960e-02f, 1.39486909e-01f, -4.10012081e-02f, 5.10340789e-03f, -5.10178916e-02f, -1.22978017e-02f,
  -6.90781474e-02f, -1.41548663e-01f, -1.13519775e-02f, 1.35002539e-01f, 6.41754717e-02f, 8.13331902e-02f, -1.05486266e-01f, 1.29388779e-01f, -4.21978459e-02f, -1.35135710e-01f,
  -4.59317677e-03f, 4.97490913e-02f, 4.54204250e-03f, 3.72824706e-02f, 2.87785344e-02f, 1.32235900e-01f, 9.75919813e-02f, -3.77832092e-02f, -7.15595633e-02f, 1.16358913e-01f,
  -1.47656025e-02f, -2.36033625e-03f, -5.47812879e-02f, 1.00825325e-01f, -8.34674686e-02f, 6.63664192e-02f, -2.21430454e-02f, -5.46281487e-02f, -8.71055387e-03f, 1.02451677e-02f,
  1.49468258e-01f, 2.73260679e-02f, 4.75936383e-02f, 7.53963646e-03f, -8.54999125e-02f, 9.23228636e-02f, -5.51550388e-02f, -7.99731314e-02f, 7.05382377e-02f, 6.60344884e-02f,
  1.14183851e-01f, -8.95099938e-02f, -5.99418618e-02f, 7.04432353e-02f, 5.15847728e-02f, -1.85390729e-02f, 5.40814474e-02f, 1.06067665e-01f, -6.43760338e-02f, -1.15805864e-01f,
  1.45022675e-01f, 1.51877075e-01f, 2.38561649e-02f, -5.72319962e-02f, -1.32360339e-01f, -1.04309469e-01f, 2.68502235e-02f, 2.47046035e-02f, 1.47775514e-02f, 6.49191663e-02f,
  4.33513112e-02f, 1.65140443e-02f, -6.23938907e-03f, -8.96682739e-02f, -1.22862421e-01f, 4.57211733e-02f, -6.07483760e-02f, 8.55132043e-02f, 1.05233051e-01f, 5.37981875e-02f,
  -5.07474132e-02f, -2.74535902e-02f, -1.41754910e-01f, -1.20294355e-02f, -3.07560321e-02f, 3.30911428e-02f, -7.76128918e-02f, -4.99612950e-02f, 7.61656836e-02f, -8.52451995e-02f,
  -7.33131826e-01f, -1.96524084e-01f, -3.07309031e-01f, -3.42241347e-01f, 4.90409881e-02f, -3.10618848e-01f, -5.49241424e-01f, 3.35801765e-03f, -2.27159992e-01f, 1.84199214e-01f,
  -1.66642770e-01f, 1.12934574e-01f, -1.86234027e-01f, -1.45003259e-01f, -4.65882242e-01f, -1.76483735e-01f, -2.89734185e-01f, -1.10995434e-01f, 1.73998566e-03f, 3.29784974e-02f,
  -1.67856395e-01f, 2.81478725e-02f, -3.35765392e-01f, 2.26207927e-01f, -1.22831687e-01f, 5.37682846e-02f, 2.28815719e-01f, 3.39087285e-02f, 2.71621764e-01f, 3.03590521e-02f,
  -8.26573372e-02f, -1.55856684e-02f, -4.20011692e-02f, 2.91331578e-02f, -5.88846542e-02f, 4.34808843e-02f, 3.28430645e-02f, 4.08634208e-02f, -7.51070380e-02f, 3.15989256e-02f,
  -3.37510668e-02f, -2.45548170e-02f, -2.36466918e-02f, 2.65359860e-02f, -4.21371199e-02f, 6.80975243e-02f, -3.96271423e-02f, -8.85555595e-02f, 2.67953146e-02f, -1.18831620e-01f,
  -7.58574829e-02f, -2.34450866e-02f, -4.68770675e-02f, 1.79945394e-01f, -4.43221331e-02f, -6.03274330e-02f, -5.65586565e-03f, 2.39333324e-02f, -2.86477245e-02f, 1.50321247e-02f,
  4.84952442e-02f, 3.79840545e-02f, -6.27540350e-02f, 2.57325880e-02f, -2.63208337e-02f, 5.34471199e-02f, -6.58884943e-02f, 7.18033984e-02f, 3.02985795e-02f, 9.16277152e-03f,
  1.60801690e-02f, -3.15242889e-03f, 1.59059186e-02f, -5.62912039e-02f, 2.71008667e-02f, -2.32659862e-03f, -6.61808848e-02f, 1.17252164e-01f, -5.40880896e-02f, -9.12816375e-02f,
  2.38245651e-02f, 2.80557238e-02f, 3.01535763e-02f, 1.88758376e-03f, -4.25191149e-02f, -2.46178266e-03f, 7.75760040e-02f, 2.15234496e-02f, -7.76044326e-03f, -1.17389269e-01f,
  5.70531823e-02f, 1.74452230e-01f, 5.65188425e-03f, 7.48554021e-02f, 2.21865401e-02f, -1.31306015e-02f, -7.79918358e-02f, 6.68578744e-02f, 7.58181736e-02f, -6.37220889e-02f,
  4.33830023e-02f, 3.95840220e-03f, 8.37371573e-02f, -3.03658005e-03f, 7.59235993e-02f, -9.45769772e-02f, -1.94121455e-03f, 1.02032006e-01f, 2.43159793e-02f, 3.03324088e-02f,
  6.76768273e-02f, -2.24242955e-02f, -2.65129115e-02f, -6.61646798e-02f, 1.08182644e-02f, 4.11511250e-02f, -1.69862397e-02f, -7.06381798e-02f, 3.16758379e-02f, 2.36110613e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.18057334e-01f, -1.24870455e+00f, 4.08496261e-01f, 5.73217832e-02f, 4.20915633e-01f, 7.27662504e-01f, 9.83671367e-01f, -1.48926616e-01f, -2.90676683e-01f, -4.29349154e-01f,
  1.96883217e-01f, -3.78999233e-01f, -2.15632230e-01f, 3.71319145e-01f, 8.92165005e-01f, 9.82509926e-02f, 3.92517507e-01f, 2.03829899e-01f, -1.21546492e-01f, -3.40454549e-01f,
  4.33736593e-02f, 2.83343554e-01f, 5.04205167e-01f, -2.50543952e-01f, 1.38737813e-01f, -4.60586041e-01f, -8.45515355e-02f, 4.92069945e-02f, 3.99726853e-02f, 4.67382669e-01f,
  -4.44982886e-01f, -4.69965100e-01f, 1.19030803e-01f, -8.81452113e-02f, 7.85622224e-02f, 5.94434999e-02f, 1.55130878e-01f, 2.95851886e-01f, 1.06716059e-01f, 1.00558912e-02f,
  -3.03990077e-02f, 5.45205250e-02f, 1.61737800e-01f, 4.12849225e-02f, -1.37358189e-01f, -9.24569368e-02f, -6.80565089e-02f, 3.74149606e-02f, -1.64999634e-01f, 1.22682080e-01f,
  -3.52834212e-03f, 1.10689856e-01f, -5.48334941e-02f, 4.94439229e-02f, 1.01652622e-01f, 3.77770849e-02f, 9.40574780e-02f, 2.15654865e-01f, -1.01636901e-01f, 1.36957094e-01f,
  4.54790890e-02f, -1.79374758e-02f, -1.42395869e-01f, -5.83118945e-02f, -3.98344174e-02f, -1.04249539e-02f, 1.96310524e-02f, 1.58617467e-01f, -8.10072049e-02f, 8.16684142e-02f,
  2.65018679e-02f, -1.21700145e-01f, -1.74661521e-02f, 3.46675143e-02f, 7.69882426e-02f, -4.84486073e-02f, -5.74813895e-02f, -1.57379493e-01f, -2.30012443e-02f, 1.81052496e-03f,
  -3.38422544e-02f, 3.70492525e-02f, 6.60981834e-02f, -5.99891238e-04f, -6.12696240e-05f, 1.68166950e-01f, -4.91956547e-02f, 4.15259972e-02f, -2.99952850e-02f, 1.61703214e-01f,
  -1.42202330e+00f, -1.08983922e+00f, -9.55629423e-02f, 6.49728859e-03f, -1.70107950e-02f, -1.05672270e-01f, -5.94830848e-02f, -1.31016029e-02f, -2.40133390e-01f, 6.36160523e-02f,
  -1.51273549e-01f, -3.59346578e-03f, -2.12788776e-01f, -2.73992736e-02f, 1.70867629e-02f, -3.98458056e-02f, -1.35983825e-01f, -1.58672005e-01f, -8.95489603e-02f, -2.73265719e-01f,
  -1.79652050e-01f, -1.96187779e-01f, 2.59570360e-01f, -1.79502741e-01f, 1.06749080e-01f, 1.53413147e-01f, -3.60166103e-01f, -5.38193621e-02f, 5.97107857e-02f, 7.84909874e-02f,
  1.02467060e+00f, -4.72586155e-01f, -2.37287432e-01f, 9.29348528e-01f, 4.32876527e-01f, -5.99561572e-01f, -7.71033406e-01f, 5.04397571e-01f, 4.12547678e-01f, -6.49018347e-01f,
  2.37274423e-01f, -4.18410331e-01f, -4.98877108e-01f, 6.83772922e-01f, 9.38927591e-01f, -3.34509641e-01f, 7.26758301e-01f, 1.37763634e-01f, 2.02771291e-01f, 4.23068315e-01f,
  8.14148486e-01f, 9.29076314e-01f, 4.22635913e-01f, 4.54215407e-01f, 3.63280654e-01f, 1.80939212e-01f, 4.38434541e-01f, -5.88533282e-01f, 2.41327181e-01f, -3.85927595e-02f,
  -1.15773983e-01f, 1.55502528e-01f, 1.54763376e-02f, -1.50553167e-01f, 5.40229492e-02f, -6.33195266e-02f, -3.16336900e-01f, -2.02938393e-01f, -1.98438335e-02f, -4.72900979e-02f,
  -2.65062541e-01f, 2.23517358e-01f, 1.06804550e-01f, 1.50685227e-02f, 1.38406858e-01f, 2.95064449e-02f, 1.63277566e-01f, -2.21141484e-02f, -2.41525501e-01f, 6.43843561e-02f,
  -4.28443886e-02f, 2.62484215e-02f, 1.92660883e-01f, -2.07737237e-02f, 9.46912766e-02f, 5.33315390e-02f, -2.01281130e-01f, -1.63241744e-01f, -1.24184778e-02f, 9.43060964e-02f,
  1.35259360e-01f, -2.41835356e-01f, 1.33206695e-02f, 1.60224196e-02f, 4.83932123e-02f, 1.06972367e-01f, 9.09822434e-02f, -2.25205626e-02f, -5.29867643e-03f, -4.38739285e-02f,
  1.31027699e-01f, 1.17903829e-01f, 9.51248556e-02f, -3.88157479e-02f, 7.79538825e-02f, 7.54795596e-02f, -1.10398985e-01f, 4.04980220e-02f, 8.47734511e-02f, 1.19335510e-01f,
  -3.97855975e-02f, 1.00676715e-01f, -1.46749079e-01f, -7.95090292e-03f, -5.00714183e-02f, 2.87016276e-02f, 5.13950512e-02f, -1.37593765e-02f, -8.25701132e-02f, -8.97163376e-02f,
  1.60598531e-02f, 4.35836352e-02f, -1.91722170e-01f, -1.09657846e-01f, -1.04436800e-01f, 1.51717320e-01f, 1.87851563e-02f, 2.29967758e-01f, 2.15189867e-02f, 3.22665088e-02f,
  -1.66389011e-02f, -6.97039217e-02f, -4.70570475e-02f, 8.43121782e-02f, -3.53595316e-02f, 8.32717493e-02f, -7.27715120e-02f, -2.08033007e-02f, 1.07615083e-01f, 1.74599096e-01f,
  -1.51675474e-02f, -1.48462281e-01f, -7.47959763e-02f, 1.53438002e-01f, 7.85959214e-02f, -1.81995615e-01f, 1.07555002e-01f, -3.75238284e-02f, 6.04304895e-02f, 2.38584261e-02f,
  -7.11687863e-01f, 1.11679258e-02f, 4.76144344e-01f, -1.17380404e+00f, 4.35330987e-01f, -3.03921610e-01f, -5.64718902e-01f, -1.06112808e-02f, -1.30635053e-01f, -6.94946647e-01f,
  -3.19466054e-01f, -7.85505101e-02f, 5.98608375e-01f, -8.25333416e-01f, 4.07796383e-01f, 4.64447588e-01f, -9.07758534e-01f, -7.85578847e-01f, 3.67409796e-01f, -5.38317025e-01f,
  -1.67515174e-01f, -5.28731406e-01f, 9.22857523e-02f, 5.19007668e-02f, -4.38287348e-01f, -7.09503666e-02f, -2.95119435e-01f, 3.78951281e-01f, -6.53391957e-01f, 3.63416821e-01f,
  -3.82394016e-01f, -4.43228722e-01f, 2.04437841e-02f, 2.93848198e-02f, -1.71728298e-01f, 5.89996167e-02f, -3.31427276e-01f, 3.45486790e-01f, -4.89669889e-02f, -1.13611951e-01f,
  1.02589270e-02f, 1.12006046e-01f, -1.14822537e-01f, 2.17694268e-01f, -4.55978215e-02f, 2.22861301e-02f, 4.18849550e-02f, -1.37785338e-02f, 1.27420574e-01f, 7.57582933e-02f,
  2.15770230e-01f, 3.88399288e-02f, -4.77004498e-02f, -1.59935147e-01f, 3.50706547e-01f, -2.20269803e-02f, -5.87827303e-02f, 8.95478129e-02f, -1.33849055e-01f, -1.05988614e-01f,
  -1.32154590e-02f, 1.74845979e-01f, -1.32838283e-02f, 3.70668732e-02f, 1.37910210e-02f, 6.81236461e-02f, -6.46142215e-02f, 9.87446774e-03f, -3.64271700e-02f, -5.48341535e-02f,
  -1.27618462e-01f, -7.12503940e-02f, -9.39409528e-03f, -1.89755395e-01f, -1.84337825e-01f, -1.09310366e-01f, -1.82342939e-02f, -4.54562008e-02f, 1.44048836e-02f, 6.31564781e-02f,
  -1.26164988e-01f, 1.15220703e-01f, 5.49380891e-02f, -1.00056395e-01f, -4.01003920e-02f, 2.69998789e-01f, -4.76799719e-02f, 6.32437121e-04f, 3.82992029e-02f, 8.07653815e-02f,
  -7.54183352e-01f, -1.01150250e+00f, 1.19307123e-01f, -1.10515118e-01f, -7.14158863e-02f, -9.00097862e-02f, 1.00422405e-01f, 1.20934611e-02f, -1.32614091e-01f, -1.05427913e-01f,
  -2.77241349e-01f, -2.84874916e-01f, -3.47393565e-02f, -7.29364008e-02f, 3.56105529e-02f, -4.94590811e-02f, -2.07959294e-01f, -1.16923437e-01f, -3.05031389e-01f, 1.96575727e-02f,
  -1.99596643e-01f, -4.75152843e-02f, 1.24618895e-01f, -1.52483642e-01f, -1.68594718e-01f, -2.63490051e-01f, -1.11294106e-01f, 5.59077077e-02f, -3.78035903e-02f, 7.18407556e-02f,
  -1.40017498e+00f, 8.00795376e-01f, 3.31636518e-01f, -5.49250722e-01f, 1.09726176e-01f, -2.95316249e-01f, -3.13031584e-01f, 5.95196247e-01f, -4.46943462e-01f, 7.65635550e-01f,
  1.12477459e-01f, -6.68256462e-01f, 4.08517987e-01f, -3.65629852e-01f, -1.13041985e+00f, -3.72289032e-01f, -4.59570169e-01f, -3.41679662e-01f, -3.65910321e-01f, 2.48808786e-01f,
  -2.40355745e-01f, -3.94697078e-02f, 1.73036590e-01f, 7.00875700e-01f, 3.82972300e-01f, 2.59600937e-01f, 5.93761504e-01f, 4.99141932e-01f, 1.84148952e-01f, -3.13138038e-01f,
  -1.76384822e-01f, 2.49671519e-01f, 9.73278880e-02f, -1.23874374e-01f, 1.44618005e-01f, 7.83431754e-02f, -4.05454589e-03f, -1.68353274e-01f, -1.18055776e-01f, -1.18645035e-01f,
  -7.14301914e-02f, 4.08054553e-02f, -1.64245024e-01f, 7.34761655e-02f, -5.45230806e-02f, 1.40249003e-02f, 6.11619763e-02f, -2.75831262e-04f, 4.39180285e-02f, -1.24691866e-01f,
  7.14364126e-02f, -1.04637399e-01f, -1.46463722e-01f, -1.84744596e-01f, 1.18340082e-01f, -1.34909675e-01f, -9.75804329e-02f, -6.66230498e-03f, 9.96298902e-03f, -1.62018582e-01f,
  -1.46517426e-01f, -4.97730114e-02f, 2.25925948e-02f, 1.08750045e-01f, -1.47044629e-01f, 1.41670167e-01f, -5.89353628e-02f, -1.60497487e-01f, -5.78270257e-02f, 8.44543651e-02f,
  8.48383084e-02f, -9.51748863e-02f, -3.58671099e-02f, -5.37597900e-03f, -1.12469308e-01f, -1.04811639e-01f, -2.22121030e-02f, -3.01466906e-03f, -8.30047056e-02f, 9.60908085e-02f,
  5.12383580e-02f, -1.22401647e-01f, 1.00355148e-01f, 6.46519437e-02f, -1.06678316e-02f, 3.03505864e-02f, 9.32601187e-03f, 8.23689103e-02f, 1.28349476e-02f, -5.35928011e-02f,
  1.31170928e-01f, 4.00333703e-01f, 9.24655423e-02f, -1.40220523e-01f, 5.35017736e-02f, 7.39127845e-02f, -4.68398146e-02f, -3.90425473e-02f, 1.97031926e-02f, 1.95812248e-02f,
  9.77752730e-02f, 3.41365188e-02f, -3.69383357e-02f, -2.45508388e-01f, -1.02140069e-01f, 3.70823294e-02f, 1.17697664e-01f, -1.51703879e-01f, 1.51260525e-01f, 1.40639767e-01f,
  3.41198891e-01f, 4.80455384e-02f, -3.12878907e-01f, 9.04756486e-02f, 1.42014110e-02f, 7.93391913e-02f, 1.24882765e-01f, -3.77418101e-03f, 8.85174200e-02f, 7.76126161e-02f,
  9.38639104e-01f, -1.36127993e-01f, 6.10028028e-01f, 4.51728135e-01f, -2.01691255e-01f, -4.67463374e-01f, 2.14115039e-01f, -6.56530201e-01f, 3.14429671e-01f, -4.00363386e-01f,
  -3.92953753e-01f, 9.09459949e-01f, 7.72189349e-02f, -4.06729430e-01f, 3.13945293e-01f, 2.45273951e-02f, -4.27335799e-01f, 1.57473058e-01f, -2.29025230e-01f, -2.84517348e-01f,
  -8.88163969e-02f, -1.01866376e+00f, 1.23473689e-01f, -9.29165542e-01f, 5.90412989e-02f, -6.54713064e-02f, -3.08616281e-01f, -1.60375670e-01f, -4.66351748e-01f, -1.61162212e-01f,
  -6.43609837e-02f, -2.10545495e-01f, 1.09146588e-01f, -3.42203863e-02f, -2.27447435e-01f, 1.31161168e-01f, 1.83438703e-01f, 1.11299120e-01f, 2.92039532e-02f, 1.50646478e-01f,
  2.94335157e-01f, -3.12823951e-02f, -7.74058476e-02f, 3.36990207e-02f, 3.57842334e-02f, -6.72183931e-02f, 1.25685766e-01f, 2.36128151e-01f, 5.42398132e-02f, 2.71976769e-01f,
  2.59926379e-01f, 4.75621223e-02f, 1.05999019e-02f, -3.86260776e-03f, 1.24080621e-01f, -1.06428541e-01f, 1.25708640e-01f, 3.38657349e-01f, 2.42517933e-01f, 2.69183982e-02f,
  -4.67656180e-02f, -2.33113050e-01f, -5.15187308e-02f, 8.41850508e-03f, -1.67206973e-01f, 1.06796867e-03f, 3.00082657e-02f, -1.88032128e-02f, 8.77526030e-02f, -1.32924309e-02f,
  -6.59961328e-02f, 4.69882786e-02f, -1.67269260e-01f, 1.36534929e-01f, -4.47672270e-02f, 3.23986523e-02f, 1.47983789e-01f, 1.50138482e-01f, 1.54913086e-02f, 2.60965154e-02f,
  -5.94651178e-02f, -5.56104183e-02f, 2.69713756e-02f, 7.93619156e-02f, -1.64457008e-01f, -2.64910217e-02f, -8.58609527e-02f, 2.47006699e-01f, 1.08555658e-02f, 2.27514915e-02f,
  -2.61460215e-01f, -9.38611269e-01f, -2.03699782e-01f, 3.38825807e-02f, 1.18100464e-01f, -1.89640056e-02f, -2.37546731e-02f, -1.37439920e-02f, -1.10756457e-01f, -1.47203773e-01f,
  -6.40013367e-02f, 1.00770369e-01f, -3.12208757e-03f, 1.42177880e-01f, -4.62051407e-02f, -1.10772654e-01f, 7.02121481e-03f, -2.31886372e-01f, -1.17806979e-01f, -6.89192191e-02f,
  1.03241071e-01f, 1.21617906e-01f, 9.54035074e-02f, 1.07311346e-02f, -3.85951740e-03f, 1.03465751e-01f, 1.33126959e-01f, 1.84838325e-02f, 2.95263175e-02f, -7.02184439e-02f,
  -1.36487317e+00f, 6.25608385e-01f, 3.87984663e-02f, -4.49360125e-02f, -7.74879754e-01f, 9.71768618e-01f, 4.25061285e-01f, -6.10211752e-02f, 6.20342977e-02f, 6.47350848e-01f,
  -2.73454517e-01f, -3.47068101e-01f, 6.18755102e-01f, 3.21881682e-01f, 5.81429899e-01f, 9.00322318e-01f, 4.47245508e-01f, 2.34694958e-01f, 4.97398339e-02f, -1.59558281e-01f,
  -1.54788774e-02f, -1.28974974e-01f, 4.13103402e-01f, -2.01055035e-03f, -6.35299623e-01f, -3.89749020e-01f, -4.62303370e-01f, -2.63096571e-01f, -1.33978799e-01f, -2.60458231e-01f,
  -5.56555092e-01f, -6.84563041e-01f, -5.45158207e-01f, -7.69522786e-02f, -1.68901861e-01f, -8.63532797e-02f, 5.32695018e-02f, -1.25929579e-01f, -2.35355809e-01f, -9.04566124e-02f,
  -7.77756274e-02f, 2.99164336e-02f, -1.88384205e-01f, 3.06567755e-02f, -7.19194338e-02f, -7.97980055e-02f, 1.62022293e-01f, -5.91773354e-02f, -1.08970098e-01f, 1.84150755e-01f,
  1.60570815e-01f, 5.25644347e-02f, 8.49986076e-02f, 3.03948730e-01f, -1.32378280e-01f, -4.80547585e-02f, 2.45716125e-01f, 2.28003468e-02f, 2.34733392e-02f, 6.12729080e-02f,
  5.51970005e-02f, 9.53576248e-03f, 3.23863775e-02f, -7.77333900e-02f, -4.47923467e-02f, -1.71311945e-01f, 1.00233540e-01f, -5.04678823e-02f, 5.83830103e-02f, 6.94502518e-02f,
  -1.35552004e-01f, -1.56073600e-01f, -9.27158296e-02f, 1.66123122e-01f, 2.80042123e-02f, 5.39698899e-02f, -1.15000699e-02f, -1.98440626e-01f, 2.33307168e-01f, 9.23791379e-02f,
  -1.38391793e-01f, 8.45964551e-02f, -1.02134869e-01f, 1.35288447e-01f, -5.12962565e-02f, 1.07324347e-02f, 1.26569280e-02f, 1.05674170e-01f, -1.27084702e-01f, -1.95304900e-02f,
  1.22739244e-02f, -2.27001086e-01f, -1.97666928e-01f, -6.94967657e-02f, 1.40217736e-01f, 1.80563740e-02f, 9.47411358e-03f, -3.99262719e-02f, 3.72124687e-02f, -4.67877090e-02f,
  -1.20777778e-01f, 1.10438846e-01f, -4.53650355e-02f, -1.38304103e-02f, 1.72085717e-01f, 1.86525822e-01f, -1.50702633e-02f, -8.79671946e-02f, -3.48027013e-02f, -3.47720049e-02f,
  -2.20660195e-01f, -3.97796035e-02f, 2.35875189e-01f, 1.78704076e-02f, -2.53827348e-02f, -3.72753739e-02f, -1.46618173e-01f, 7.17238709e-02f, -5.53950518e-02f, 1.16189294e-01f,
  9.64968324e-01f, 6.74953043e-01f, 9.60541010e-01f, 1.03605473e+00f, -4.12316799e-01f, 8.66318494e-03f, 4.51960415e-01f, 5.70213437e-01f, 1.28453982e+00f, -2.34791443e-01f,
  -6.71497643e-01f, 4.90546077e-01f, -2.76024252e-01f, 8.77658352e-02f, -3.69369447e-01f, -1.84137151e-01f, 4.23290342e-01f, 5.80957271e-02f, 3.28240067e-01f, 4.86016095e-01f,
  3.97345960e-01f, -7.42660820e-01f, -2.00472102e-01f, -4.27729905e-01f, 1.72662109e-01f, 4.69673574e-01f, -8.07423890e-01f, -2.71200091e-01f, -4.25963283e-01f, -4.33232427e-01f,
  -1.47368550e-01f, 3.13793957e-01f, 8.46409276e-02f, 1.50437087e-01f, 1.70477539e-01f, -8.35027322e-02f, -2.01655284e-01f, -2.24903986e-01f, 6.97040558e-02f, 9.14012343e-02f,
  4.76567335e-02f, -4.71818075e-02f, 2.33695850e-01f, -1.08645514e-01f, 1.49587706e-01f, 1.88933775e-01f, 5.28841354e-02f, 7.56490007e-02f, 7.75740668e-02f, -3.22066247e-02f,
  1.74130529e-01f, 1.24587953e-01f, 1.31425858e-01f, -8.92035291e-02f, 1.38343185e-01f, 2.01358363e-01f, 2.70725656e-02f, -5.59590496e-02f, 1.22560291e-02f, 1.03434458e-01f,
  1.02376454e-01f, -1.43049508e-02f, -1.86027437e-01f, -1.19901314e-01f, -9.57742184e-02f, -8.52465406e-02f, -5.09993695e-02f, -3.52414772e-02f, 6.61139265e-02f, -4.12723087e-02f,
  4.29756939e-02f, -9.44834575e-02f, 8.75490829e-02f, 1.53252944e-01f, 1.86158961e-03f, 1.49323985e-01f, -2.29401663e-01f, -1.08680174e-01f, 1.68635055e-01f, 1.23400576e-02f,
  -3.93977128e-02f, -6.97587878e-02f, 5.74681163e-02f, -1.44132897e-01f, -1.25456810e-01f, -2.63211094e-02f, 1.36258468e-01f, 8.84895176e-02f, -8.05379748e-02f, -6.19458444e-02f,
  6.53692633e-02f, 3.47045571e-01f, 1.14890903e-01f, -1.18587218e-01f, -3.48680490e-03f, -8.02879184e-02f, 1.04630977e-01f, 2.36596540e-01f, 8.39956403e-02f, 8.64886045e-02f,
  -3.53414528e-02f, 2.48963945e-02f, -8.04425031e-02f, -1.92733914e-01f, 2.50019673e-02f, -5.43763265e-02f, -8.07702392e-02f, -3.59041579e-02f, 6.85063079e-02f, -7.13191852e-02f,
  -4.74810712e-02f, -8.32958221e-02f, 1.59148708e-01f, -1.20449858e-02f, -2.86601167e-02f, -1.54966906e-01f, 1.35591179e-01f, 3.87341604e-02f, -9.81525630e-02f, 1.06156610e-01f,
  5.66687584e-01f, 2.08591014e-01f, -7.24186778e-01f, -6.31990254e-01f, 2.81802677e-02f, 1.11220443e+00f, 1.18334249e-01f, -6.58614784e-02f, -3.15142542e-01f, 6.81224763e-01f,
  6.17592707e-02f, 2.06805065e-01f, -3.57999019e-02f, 2.00990051e-01f, 5.53915262e-01f, 3.92571509e-01f, 4.57237929e-01f, 2.03271776e-01f, -3.78385216e-01f, 1.89543352e-01f,
  -1.02709718e-01f, 7.33609557e-01f, -5.81386149e-01f, -4.58954694e-03f, 3.17613512e-01f, -7.19382644e-01f, -2.19787448e-03f, -4.70622897e-01f, -3.46190929e-02f, 2.14277327e-01f,
  -7.84540642e-03f, -6.42685816e-02f, -1.27460390e-01f, -1.75611638e-02f, 1.71980098e-01f, 3.08820643e-02f, 6.26629218e-02f, 7.26663917e-02f, -3.90091032e-01f, 6.72977604e-03f,
  2.54220277e-01f, -5.39516471e-02f, 6.26418963e-02f, -1.57357305e-01f, 8.73672143e-02f, -2.24142835e-01f, -1.79250523e-01f, -7.27422386e-02f, -1.71315402e-01f, 5.77403456e-02f,
  -1.90159425e-01f, -1.84309334e-01f, -2.46270485e-02f, -1.95542909e-03f, -2.16004506e-01f, -1.77386284e-01f, 1.42252613e-02f, 4.26518582e-02f, 1.65335968e-01f, 2.30060458e-01f,
  2.35897452e-01f, 2.80781627e-01f, 1.53727129e-01f, -1.32785439e-01f, 2.57727858e-02f, -1.92813680e-01f, 3.37007493e-02f, -1.01325355e-01f, -1.83514226e-02f, 1.04149848e-01f,
  -6.59725163e-03f, -1.58070624e-01f, -7.16379732e-02f, 1.77006036e-01f, 1.02751851e-01f, -3.78789492e-02f, -9.90293846e-02f, 1.00392923e-01f, -1.93703026e-01f, -2.47746427e-02f,
  -1.06211580e-01f, 1.35470539e-01f, 9.71633121e-02f, -6.43225908e-02f, -5.97994179e-02f, -3.83326225e-02f, 1.46671399e-01f, 2.17610504e-02f, -2.34001562e-01f, 5.49093001e-02f,
  1.13101728e-01f, 5.41045666e-01f, -1.10877715e-01f, -5.74394129e-02f, 5.53853847e-02f, 3.76936406e-01f, 8.02212507e-02f, 1.55708328e-01f, 7.79922381e-02f, 2.41713300e-01f,
  6.77298903e-02f, -5.98153882e-02f, 2.76536912e-01f, -1.59050494e-01f, -2.24388763e-01f, 3.02213639e-01f, 2.34930649e-01f, -6.71212897e-02f, -8.05226341e-02f, -1.19490653e-01f,
  1.22980643e-02f, 2.78486490e-01f, -2.77981292e-02f, -1.79347489e-02f, 7.18100965e-02f, 2.15836525e-01f, 1.63308144e-01f, -1.59135059e-01f, 1.83805719e-01f, -9.66974273e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.22438323e+00f, 8.34024727e-01f, 7.66732633e-01f, 1.44376707e+00f, 1.26731646e+00f, 6.22093439e-01f, 1.22681153e+00f, 1.03985488e+00f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -4.62817997e-01f, 3.61300230e-01f, -2.14438245e-01f, -1.02773368e+00f, -9.65338409e-01f, -3.30086291e-01f, -4.82823789e-01f, -5.70026517e-01f, 2.83963293e-01f, 2.98090518e-01f,
  4.63538021e-01f, 1.79418951e-01f, 5.66557229e-01f, -1.06092930e+00f, 6.40867651e-01f, 2.16330037e-01f, 4.52531904e-01f, 7.55300283e-01f, 7.94920206e-01f, -5.73611021e-01f,
  -1.02262700e+00f, 4.30489555e-02f, 3.42809200e-01f, -1.51490852e-01f, 4.95325625e-01f, -1.00980139e+00f, -1.22792339e+00f, 1.90476716e-01f, -5.90245605e-01f, 9.39381242e-01f,
  -1.19757354e+00f, -1.39743656e-01f, 1.79486439e-01f, 7.35825300e-02f, -5.36181331e-01f, -3.87517929e-01f, -6.90569520e-01f, 3.89546543e-01f, 4.58417773e-01f, 6.93907917e-01f,
  4.06224132e-01f, -1.18372154e+00f, -5.15513122e-01f, 3.50711942e-01f, 6.42221689e-01f, 8.43806624e-01f, 6.89980268e-01f, 1.06716108e+00f, 3.08932126e-01f, -7.61411905e-01f,
  9.78105307e-01f, 1.19297040e+00f, -4.48069066e-01f, 9.64248657e-01f, 6.26981556e-01f, -6.43646538e-01f, -2.38491520e-01f, 3.80832642e-01f, -3.86233807e-01f, -8.86466801e-01f,
  -7.99163103e-01f, -2.30930045e-01f, -1.22647870e+00f, 9.47687924e-01f, -7.08109885e-02f, 6.84660450e-02f, -4.53858942e-01f, -2.42862478e-01f, 3.56657147e-01f, -8.47745359e-01f,
  -1.99275110e-02f, -1.00316279e-01f, -2.78216690e-01f, 2.06749931e-01f, 1.26207232e-01f, 3.37302148e-01f, -6.44901752e-01f, -9.49136093e-02f, 8.28145623e-01f, -7.01680899e-01f,
  6.37599885e-01f, 7.93867335e-02f, -1.05958271e+00f, 4.00336366e-03f, -5.78248918e-01f, 6.89468622e-01f, -8.29903603e-01f, 6.72182500e-01f, 8.15168798e-01f, 8.29919934e-01f,
  -8.93913686e-01f, -5.95922947e-01f, -1.24215090e+00f, -7.32721031e-01f, -1.31149471e+00f, -6.23038650e-01f, -6.31376624e-01f, -1.04730594e+00f, 1.74073547e-01f, -3.42417479e-01f,
  -4.19374913e-01f, 5.05465381e-02f, -1.37026817e-01f, -7.96922967e-02f, -1.53735250e-01f, 2.55813420e-01f, 2.24781752e-01f, -9.85939145e-01f, 4.95108187e-01f, -3.28655481e-01f,
  -7.10474104e-02f, 1.27052379e+00f, -8.39513838e-01f, 1.19707477e+00f, 2.39652414e-02f, -9.35741603e-01f, 9.80134666e-01f, -1.97709829e-01f, 7.90486336e-01f, 6.43895805e-01f,
  -1.17767334e+00f, -5.06602824e-01f, 7.64816225e-01f, 8.30997527e-01f, -1.10761678e+00f, -5.43786585e-01f, -4.16060954e-01f, -1.06572831e+00f, 4.41473782e-01f, 7.87711382e-01f,
  2.76888311e-01f, 4.07984942e-01f, 9.21756566e-01f, 2.33256876e-01f, 4.87418473e-01f, 7.53232479e-01f, -1.06497610e+00f, -2.94605970e-01f, -6.25996172e-01f, 1.32404697e+00f,
  -6.86184108e-01f, 4.43808705e-01f, -1.52219385e-01f, -5.57095706e-01f, -2.42172554e-01f, 7.18589485e-01f, 6.40137196e-01f, 2.91600525e-01f, 9.91085649e-01f, -8.96202624e-01f,
  -4.77599233e-01f, -4.09120828e-01f, 1.98918551e-01f, -7.76012599e-01f, 6.48560643e-01f, 1.85168520e-01f, -5.64775229e-01f, 4.15569752e-01f, -3.45194757e-01f, -2.99878836e-01f,
  4.51737136e-01f, -7.87650526e-01f, 6.31683409e-01f, 5.56142092e-01f, 7.83464372e-01f, 1.62988037e-01f, 3.91112119e-01f, 2.88257480e-01f, 1.70729890e-01f, 7.50121653e-01f,
  -7.30331361e-01f, 3.64167750e-01f, 1.06691658e+00f, 8.11850965e-01f, -2.58531645e-02f, 4.07869697e-01f, 1.25539625e+00f, -2.97969468e-02f, -7.92323172e-01f, -1.04499030e+00f,
  7.66284823e-01f, -2.20382065e-01f, 5.99772871e-01f, -6.75287962e-01f, -6.28002882e-01f, -8.09928954e-01f, -1.01716280e+00f, -1.40454936e+00f, -2.20783383e-01f, 5.57352066e-01f,
  9.41946983e-01f, 2.26166517e-01f, 5.47258675e-01f, -1.46035135e-01f, -2.96612620e-01f, -2.46440247e-01f, -1.32857990e-02f, 1.81982201e-02f, -7.45646358e-01f, -3.86155158e-01f,
  1.04422472e-01f, -5.61458245e-03f, 3.17144901e-01f, -9.39848125e-01f, -6.78799570e-01f, 4.75597590e-01f, 4.72833753e-01f, 2.05403869e-03f, -1.37257898e+00f, -3.75181198e-01f,
  -9.70385909e-01f, 6.45006478e-01f, 4.98923630e-01f, 9.53149438e-01f, 9.12466407e-01f, -4.70326960e-01f, 1.21726923e-01f, 5.12840450e-01f, -4.06771570e-01f, -5.61280608e-01f,
  1.99831545e-01f, -1.07832706e+00f, 7.02280104e-01f, -9.92385209e-01f, 1.67312682e-01f, -8.63136277e-02f, -9.64995265e-01f, 3.05649061e-02f, -8.60247254e-01f, -6.95718288e-01f,
  -4.23271596e-01f, -8.29195082e-01f, -1.85328349e-01f, -2.85728127e-01f, -7.79590756e-02f, -1.24222375e-01f, -4.58498985e-01f, -3.66371661e-01f, -4.32371765e-01f, -3.01904157e-02f,
  -2.33784810e-01f, 5.52363753e-01f, -8.56461585e-01f, -3.15539896e-01f, -3.85027289e-01f, -4.59495246e-01f, -5.41629791e-01f, 1.16858411e+00f, -1.22969639e+00f, 1.39189601e-01f,
  9.46665049e-01f, -1.01700616e+00f, 8.53648663e-01f, -5.28296828e-02f, -1.09034324e+00f, 1.88299164e-01f, -2.41042167e-01f, 5.16883492e-01f, 3.12907934e-01f, -6.98361099e-02f,
  -5.81413209e-01f, 2.02691734e-01f, -6.09997392e-01f, 2.87655264e-01f, -3.00449312e-01f, -3.11156154e-01f, -7.98472106e-01f, 8.19489881e-02f, -5.17399430e-01f, 9.43883229e-03f,
  -8.73149872e-01f, -6.91698253e-01f, 5.10856688e-01f, -1.70979634e-01f, 9.60567832e-01f, 6.18642010e-02f, -6.84336364e-01f, -1.05875206e+00f, -5.66435874e-01f, 3.03395778e-01f,
  -1.19154847e+00f, 9.91590738e-01f, -5.14411390e-01f, 2.71292090e-01f, -6.99070334e-01f, -7.45266378e-01f, 2.99328238e-01f, -5.20490944e-01f, -1.13571620e+00f, -5.89134693e-02f,
  5.35233319e-01f, 2.50674963e-01f, 2.81408638e-01f, 4.20178413e-01f, -2.33805627e-01f, 3.87742549e-01f, 4.03509110e-01f, 1.62774563e-01f, 6.48127615e-01f, -5.91905057e-01f,
  -6.54872179e-01f, 4.69265610e-01f, -8.46871257e-01f, -5.13761103e-01f, -1.12057559e-01f, -5.37571669e-01f, -3.60664248e-01f, 2.33581498e-01f, -1.12878513e+00f, -4.83392000e-01f,
  -8.49518418e-01f, -5.84899426e-01f, 8.43176961e-01f, -1.09409857e+00f, 1.03698224e-01f, -1.16679990e+00f, 8.45354557e-01f, -5.01763403e-01f, -1.00039518e+00f, -2.35406250e-01f,
  5.67383885e-01f, 5.00035584e-01f, 3.59728664e-01f, 3.76204878e-01f, 5.06506085e-01f, -6.92550465e-03f, 3.19444150e-01f, 1.86289504e-01f, 3.77963156e-01f, -1.51007682e-01f,
  4.96355921e-01f, -5.91390252e-01f, 6.14510298e-01f, -6.58860683e-01f, -9.47614491e-01f, -1.15578246e+00f, -3.21350187e-01f, -1.41178489e+00f, 3.16474199e-01f, 9.27193999e-01f,
  -1.01903093e+00f, 9.21105266e-01f, -1.26482606e-01f, 8.19488704e-01f, -5.44708967e-01f, -1.27698243e+00f, -9.16165471e-01f, 9.64795709e-01f, -4.64638650e-01f, -7.55143166e-01f,
  -5.73951244e-01f, -4.77419095e-03f, -1.47950366e-01f, 1.24456681e-01f, -5.99260032e-02f, 3.48834336e-01f, 3.21948707e-01f, 2.94175804e-01f, 5.09946309e-02f, -2.88817942e-01f,
  -9.87187400e-02f, 2.84775104e-02f, 6.26418829e-01f, 7.02546000e-01f, 5.20570695e-01f, -1.00222397e+00f, 6.94968700e-01f, -3.06817651e-01f, -5.34720957e-01f, 2.16932237e-01f,
  1.04485416e+00f, 7.24497974e-01f, 4.66126412e-01f, -5.08121133e-01f, -3.83694053e-01f, 1.37054041e-01f, -1.30637884e+00f, -9.56772447e-01f, -1.02426946e+00f, -1.17768623e-01f,
  1.17091954e+00f, -1.14078009e+00f, 8.98907125e-01f, -7.40324438e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  6.25243364e-03f, 2.34376460e-01f, -9.85013247e-02f, -7.97775388e-02f, 7.64426365e-02f, 2.00178117e-01f, 1.03171937e-01f, 1.06875077e-01f, -1.87204942e-01f, -8.43855217e-02f,
  2.19908521e-01f, -4.83601540e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    