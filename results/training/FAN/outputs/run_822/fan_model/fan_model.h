/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.64203167e-01f, -1.00370564e-01f, -2.28340045e-01f, -3.59262705e-01f, -8.48172605e-02f, 7.11237313e-03f, -2.34356169e-02f, 1.91334277e-01f, -1.22932762e-01f, -1.66562170e-01f,
  2.84837484e-02f, 4.92891781e-02f, -2.77125929e-02f, 6.31667003e-02f, 3.03075579e-03f, -1.78288668e-01f, -3.19871515e-01f, -6.15757406e-02f, 5.07903136e-02f, 7.52901286e-03f,
  -1.78747192e-01f, -2.01430410e-01f, -8.11993331e-02f, 1.83393545e-02f, -2.29271621e-01f, -1.00835241e-01f, -1.91497982e-01f, 6.17197729e-05f, -4.73923385e-02f, -3.44738036e-01f,
  -2.14900166e-01f, 1.29737839e-01f, 1.69334218e-01f, -4.55756448e-02f, -7.88391288e-03f, 8.01782832e-02f, -3.87663487e-03f, 5.50710149e-02f, 2.27523334e-02f, 3.40815373e-02f,
  -1.55944908e-02f, 2.57508457e-02f, -5.33959977e-02f, 8.62047821e-03f, 2.12998028e-04f, -1.96161214e-02f, 4.22287323e-02f, -2.07500402e-02f, 5.26167359e-03f, 2.18976699e-02f,
  -9.48472470e-02f, 5.89707904e-02f, 1.33158967e-01f, 7.85504505e-02f, 5.75290248e-02f, 1.14806406e-01f, 5.40879592e-02f, 4.69356589e-02f, 1.84911802e-01f, -1.28756210e-01f,
  -7.02791885e-02f, 1.19488491e-02f, 4.04052399e-02f, 9.20462701e-03f, 1.94415450e-02f, 4.45455611e-02f, -1.85220651e-02f, 1.35163469e-02f, 2.88227834e-02f, -4.08880040e-02f,
  -2.67204642e-02f, -6.14756718e-02f, -4.17879410e-02f, -9.92546324e-03f, -5.82834147e-02f, -1.30768837e-02f, 2.66786572e-02f, -5.57742566e-02f, 2.69071925e-02f, 2.13554557e-02f,
  -3.71739827e-02f, 9.49744433e-02f, -5.60159571e-02f, 6.56701848e-02f, 1.48600724e-03f, -8.75346363e-02f, 3.07365377e-02f, 9.48744491e-02f, 6.65744990e-02f, 5.49643710e-02f,
  9.04976055e-02f, 1.73615530e-01f, -9.92966145e-02f, 5.50931729e-02f, -6.64160401e-02f, -2.69767251e-02f, -2.50965683e-03f, 1.03562213e-02f, 4.35714005e-03f, 2.44887397e-02f,
  7.28168637e-02f, -7.07874820e-02f, 1.54478252e-02f, 3.34841758e-02f, 9.24611464e-03f, 4.25299220e-02f, -5.79433627e-02f, -1.23919375e-01f, 1.03766741e-02f, -7.07964450e-02f,
  -8.68174732e-02f, -9.05393064e-03f, 5.03498763e-02f, 2.82361712e-02f, 2.93649938e-02f, 1.13445669e-02f, 6.00463822e-02f, 6.27102256e-02f, 1.04051642e-01f, -1.20451279e-01f,
  1.05477318e-01f, -4.71414858e-03f, -1.56403258e-01f, -9.00523290e-02f, -1.68369085e-01f, 1.25917509e-01f, 1.58281773e-01f, 1.87273824e-03f, -6.34143427e-02f, 5.56564182e-02f,
  -1.61797702e-01f, 2.68508750e-03f, 1.11177333e-01f, 1.37240723e-01f, 2.16684446e-01f, 2.08028629e-01f, 3.32800373e-02f, 1.28163457e-01f, 2.16661617e-01f, 1.68157116e-01f,
  4.07875478e-02f, 8.03502575e-02f, 1.03530757e-01f, -1.08988218e-01f, -1.16464145e-01f, -7.73365200e-02f, -1.62703782e-01f, -5.03097437e-02f, -7.65113756e-02f, -1.58063784e-01f,
  8.22793692e-02f, -2.09030941e-01f, 7.66631663e-02f, 2.21744999e-02f, -1.04989685e-01f, -2.62966491e-02f, 2.59846766e-02f, 1.25197051e-02f, -9.05490071e-02f, 2.85817124e-02f,
  8.03531334e-02f, -5.17730117e-02f, -4.74362969e-02f, 4.86514438e-03f, 1.52828032e-02f, 1.65834993e-01f, 1.23763487e-01f, 1.02063969e-01f, 1.20858029e-01f, -5.81593672e-03f,
  -7.09058866e-02f, -3.83146815e-02f, -3.39660458e-02f, 9.73358471e-03f, -4.65835035e-02f, 9.73583385e-02f, -7.83816054e-02f, -1.65389273e-02f, -6.23429706e-03f, 2.59326026e-02f,
  5.20838797e-02f, -7.25464523e-02f, -4.46142722e-03f, -3.59967798e-02f, 7.19310194e-02f, 5.31668775e-02f, -9.09470953e-03f, 8.20929557e-02f, 1.77580491e-02f, 7.36273974e-02f,
  3.83638218e-03f, -4.63896580e-02f, -1.09037878e-02f, 1.79793350e-02f, -7.80511945e-02f, -2.83219367e-02f, -3.11890990e-02f, 2.44237240e-02f, -3.25851515e-02f, 2.68877111e-02f,
  1.24552129e-02f, -7.21449638e-03f, 3.23985657e-03f, 3.53348851e-02f, -2.50098575e-02f, -9.73279774e-02f, 2.07613222e-02f, -9.31289941e-02f, 2.25481186e-02f, -9.57012549e-03f,
  3.22487384e-01f, 3.10765505e-02f, 7.20598772e-02f, 1.87404931e-01f, 1.16793558e-01f, -6.83441572e-03f, -1.42574869e-02f, -2.70205103e-02f, -3.44027802e-02f, -3.82772530e-03f,
  -2.71478631e-02f, 2.97258459e-02f, -1.32191787e-02f, -1.64003558e-02f, 1.07146740e-01f, 1.00788036e-02f, 4.72773910e-02f, 7.55856037e-02f, 4.06841077e-02f, -3.62869203e-02f,
  -5.59614301e-02f, 1.28773749e-01f, 3.16349804e-01f, 1.94724187e-01f, -5.75478971e-02f, 4.99978736e-02f, 9.81949568e-02f, 1.73941627e-01f, 2.54946411e-01f, 3.30598623e-01f,
  -1.61671847e-01f, -4.27571118e-01f, 2.09401324e-01f, -2.16845676e-01f, -2.56363899e-01f, -6.56133965e-02f, -1.39462411e-01f, -4.92487997e-02f, -1.24696679e-01f, -3.54734600e-01f,
  -9.92651507e-02f, 2.25641280e-01f, 2.35888243e-01f, 4.31409776e-01f, 3.69776011e-01f, -1.96812212e-01f, -2.27744088e-01f, 4.18941826e-01f, 6.95887864e-01f, 2.78625906e-01f,
  -1.49816081e-01f, -6.19352609e-02f, 2.04107836e-02f, 7.05381110e-02f, -2.26443157e-01f, 8.48489031e-02f, -2.56054789e-01f, -2.34338418e-01f, -2.93398630e-02f, -3.08259457e-01f,
  1.84728384e-01f, -6.57901540e-02f, 2.40644678e-01f, 3.63315991e-03f, -1.31713357e-02f, 7.25367367e-02f, 4.33359109e-02f, 2.59433761e-02f, -6.60088137e-02f, -4.65875715e-02f,
  -1.09075487e-01f, 5.35441302e-02f, 1.00226723e-01f, 1.07959593e-02f, -4.84245420e-02f, 2.74029430e-02f, -9.20295864e-02f, 1.69502139e-01f, 1.42241284e-01f, 5.07553890e-02f,
  -1.12295419e-01f, -2.02668041e-01f, 1.57677475e-02f, 1.91563496e-03f, 1.18098207e-01f, 1.68372855e-01f, -5.02171516e-02f, 5.45492619e-02f, 2.33775303e-01f, -1.64908350e-01f,
  3.98269035e-02f, -4.85443398e-02f, -3.58563140e-02f, -1.91288404e-02f, -6.74987882e-02f, -6.76664384e-03f, -7.41408160e-03f, -3.33296619e-02f, -1.33297006e-02f, -1.06693422e-02f,
  5.32343090e-02f, -5.14821894e-02f, 1.67536233e-02f, -7.85511881e-02f, -3.52534070e-03f, -2.02275384e-02f, 5.75794987e-02f, -6.42589629e-02f, 5.87068982e-02f, -6.66363016e-02f,
  1.30505353e-01f, 3.56346481e-02f, -1.46760002e-01f, 1.05888508e-01f, -3.98025252e-02f, 5.43948784e-02f, -4.51399619e-03f, 3.02412659e-02f, 2.64112055e-02f, -8.49286243e-02f,
  -1.43660411e-01f, 2.69138157e-01f, -3.14400718e-02f, 1.13978699e-01f, -5.41557670e-02f, -1.52426055e-02f, -1.09586529e-02f, 7.63884280e-03f, -2.87868101e-02f, -6.59069885e-03f,
  6.74559474e-02f, 4.22515534e-02f, -7.16096386e-02f, 1.62495002e-02f, 8.89388844e-02f, -2.23641284e-02f, -1.74060598e-01f, -2.12619696e-02f, 3.25727439e-03f, -9.95816961e-02f,
  -1.34499684e-01f, -2.78469734e-02f, 1.59511968e-01f, -3.29470448e-02f, 7.91648030e-02f, 1.04420505e-01f, 9.39549431e-02f, 5.79118766e-02f, 1.23710908e-01f, -1.65791020e-01f,
  7.79280141e-02f, -3.17144990e-01f, 5.45590445e-02f, 5.71292788e-02f, 8.81204531e-02f, 2.31673777e-01f, 9.78019163e-02f, 7.02553019e-02f, 1.00897476e-01f, -1.51191041e-01f,
  -3.83182436e-01f, -1.72576442e-01f, -9.37808603e-02f, 8.52579176e-02f, 1.90930888e-01f, 2.35678017e-01f, 2.82454252e-01f, 3.80083352e-01f, 4.70469147e-01f, 1.11457616e-01f,
  6.95275217e-02f, 7.60155320e-02f, 9.41429883e-02f, 2.16079533e-01f, -2.43593320e-01f, -1.50533304e-01f, -1.42562717e-01f, 3.77469920e-02f, -3.35415266e-02f, -1.43592983e-01f,
  -2.74178267e-01f, -9.79732648e-02f, 1.53650701e-01f, -3.96907777e-02f, -2.45645754e-02f, 8.38157460e-02f, 4.72761840e-02f, 4.49335948e-02f, -3.83907929e-02f, -4.72109802e-02f,
  -1.26780540e-01f, -3.26251611e-02f, 5.92993014e-02f, -5.24932705e-02f, 1.97571721e-02f, -6.06818646e-02f, 9.92310047e-02f, 2.96588652e-02f, 9.31860283e-02f, 8.66231695e-03f,
  -1.77668869e-01f, 3.26763242e-02f, 5.54653676e-03f, 1.22244403e-01f, 2.28811949e-02f, 6.53967708e-02f, 1.42877793e-03f, -1.14911236e-02f, 5.51625900e-02f, -1.06377840e-01f,
  2.79053133e-02f, -4.46691811e-02f, 2.83694845e-02f, -7.31586814e-02f, -1.65423229e-02f, -7.93346837e-02f, 6.24250285e-02f, -9.17508751e-02f, 4.66324762e-02f, -1.76104736e-02f,
  -1.12186344e-02f, 2.44580992e-02f, -1.25860404e-02f, 1.87004427e-03f, -5.44799231e-02f, 1.70056615e-03f, 4.87417541e-02f, -3.23303752e-02f, 4.37697768e-02f, -1.36526274e-02f,
  -6.30210340e-02f, 1.60842463e-02f, -1.44536346e-02f, -1.31006225e-03f, 2.00581402e-02f, 3.19704898e-02f, -3.41703696e-03f, 3.52432542e-02f, -2.13687588e-02f, 2.22044028e-02f,
  -2.06118003e-01f, 1.89761639e-01f, -1.06377050e-01f, 6.94876686e-02f, -3.01592723e-02f, -7.00491741e-02f, -1.45399645e-01f, 3.51976715e-02f, -4.64529060e-02f, -1.28962405e-04f,
  -5.02234437e-02f, 9.16830376e-02f, -9.51346830e-02f, -4.59371917e-02f, 8.77026585e-04f, -2.57669371e-02f, -7.37677515e-02f, -3.89501452e-02f, 4.35301960e-02f, -1.72035575e-01f,
  2.42702216e-02f, 1.17564738e-01f, 2.97300071e-02f, -5.07198609e-02f, 3.67894396e-03f, 1.88834369e-01f, -9.30734277e-02f, -9.53205973e-02f, 2.33451977e-01f, -1.39863059e-01f,
  4.18337047e-01f, 1.77684754e-01f, -6.68590842e-03f, 2.00476855e-01f, -4.65441085e-02f, -3.26830864e-01f, -3.90796363e-01f, -1.79014608e-01f, 1.17474357e-02f, -8.60614851e-02f,
  2.15737969e-01f, 1.67158067e-01f, 1.59118995e-01f, -4.78159487e-02f, -5.64642958e-02f, -2.33388290e-01f, -1.73411801e-01f, 3.00680082e-02f, -6.27857670e-02f, -2.42214188e-01f,
  -1.67830512e-01f, 8.10468197e-02f, 2.01588348e-01f, -4.18612733e-02f, 3.60306876e-04f, -1.00565530e-01f, -3.73117179e-02f, 1.39544338e-01f, 7.58017376e-02f, 4.44592647e-02f,
  1.06915578e-01f, 5.06683886e-01f, -1.53737068e-01f, 1.05247311e-01f, 2.62738373e-02f, -5.89097589e-02f, -6.75811023e-02f, 4.54432778e-02f, 1.00832749e-02f, 4.33692597e-02f,
  -4.26134211e-04f, 1.29005136e-02f, 1.40520841e-01f, -4.87097763e-02f, -5.89363277e-02f, -1.43779453e-03f, -4.94088121e-02f, 2.70737875e-02f, -6.03994429e-02f, -1.41552677e-02f,
  4.69326274e-03f, 1.40814111e-01f, 8.46040100e-02f, 2.32559419e-03f, -3.75942029e-02f, 5.83014898e-02f, 6.95862342e-04f, 9.26659331e-02f, -5.25671802e-02f, -2.37774421e-02f,
  -8.82519111e-02f, 3.51329446e-02f, 2.63889246e-02f, 5.22070713e-02f, -3.00387945e-02f, 2.74531334e-03f, 6.82464093e-02f, -6.62305728e-02f, 5.59801459e-02f, -7.15567693e-02f,
  4.38388959e-02f, 9.62276943e-03f, -9.11994185e-03f, -6.88074343e-03f, 6.58604736e-03f, 6.57307431e-02f, -4.81323339e-02f, -6.11142293e-02f, 4.78308275e-02f, 3.30653638e-02f,
  3.86031605e-02f, -3.98797565e-04f, 6.09008642e-03f, -4.73013520e-02f, 8.96781310e-02f, 5.76307103e-02f, -7.52197653e-02f, 4.82598692e-02f, 4.58062366e-02f, 3.00854035e-02f,
  -2.21864983e-01f, 6.57560751e-02f, 1.13976449e-02f, -3.90183702e-02f, 2.00025104e-02f, 1.53289633e-02f, 6.31494373e-02f, -1.00359181e-03f, 4.27947566e-02f, -2.90452242e-02f,
  8.54376517e-03f, 2.66431123e-02f, 3.45086632e-03f, 1.37620009e-02f, 1.77746788e-02f, -9.25712213e-02f, -5.52706532e-02f, -4.45157196e-03f, -6.95483834e-02f, -6.71379119e-02f,
  -4.13625613e-02f, -2.05994219e-01f, -4.83677797e-02f, -1.23305812e-01f, -5.78697063e-02f, -7.56857097e-02f, -1.60161629e-01f, -1.69685096e-01f, -2.53996372e-01f, -4.55096155e-01f,
  -1.72347322e-01f, -4.20178235e-01f, -2.77411073e-01f, -7.23545477e-02f, -1.66543141e-01f, -3.07954937e-01f, -4.97298717e-01f, -1.44382402e-01f, 7.58127719e-02f, -2.15739980e-01f,
  -3.76899503e-02f, 3.74083489e-01f, 2.45560542e-01f, 2.52650797e-01f, 7.45917782e-02f, -2.73624092e-01f, -2.10463449e-01f, -3.25628631e-02f, 1.77331671e-01f, 3.13176848e-02f,
  8.07573795e-02f, -4.09799442e-02f, 1.72621503e-01f, 1.27883628e-01f, -1.87077358e-01f, 2.51261275e-02f, -1.52466014e-01f, -6.64661080e-02f, -1.45479694e-01f, -2.96505272e-01f,
  -2.02409655e-01f, -2.06446305e-01f, 1.60669938e-01f, 8.77644122e-02f, 6.37820363e-02f, 1.10670343e-01f, 2.20052898e-02f, 2.66280398e-02f, 8.01465362e-02f, -5.71637824e-02f,
  6.39839843e-02f, 6.38061538e-02f, 2.70066783e-02f, 1.07438834e-02f, -4.77090403e-02f, -1.91600788e-02f, -3.48734669e-02f, -8.26209709e-02f, -4.81370315e-02f, 6.39254376e-02f,
  1.14066377e-02f, -5.45238219e-02f, -3.45137157e-02f, -1.30373508e-01f, -1.23869926e-01f, 1.32029667e-03f, -1.14037268e-01f, -1.89353511e-01f, -1.50057882e-01f, -3.36634725e-01f,
  -4.09871154e-02f, -3.52518703e-03f, -3.65401469e-02f, 1.92299951e-02f, -3.32521535e-02f, 3.59268226e-02f, -3.16054299e-02f, -6.57379478e-02f, 1.58780143e-02f, -2.74179000e-02f,
  7.59293661e-02f, -3.48153152e-02f, 5.03814109e-02f, -9.70142111e-02f, -2.27428018e-03f, -5.37172854e-02f, -8.22546184e-02f, -1.98357683e-02f, -4.53236373e-03f, 4.86956313e-02f,
  -3.78897190e-02f, 3.17033641e-02f, 3.65702137e-02f, -3.82023156e-02f, -3.66048254e-02f, -6.19045235e-02f, 6.66872505e-03f, 4.00993712e-02f, 5.06271049e-02f, 1.97650138e-02f,
  2.45003328e-01f, 1.90982357e-01f, -9.29085463e-02f, 2.70379037e-02f, -4.18160595e-02f, 2.08701729e-03f, -3.46382633e-02f, 1.78183615e-02f, 1.79029871e-02f, -4.61376198e-02f,
  -1.38240901e-03f, -6.80088699e-02f, -7.97434002e-02f, 1.62044093e-02f, 1.48527818e-02f, -6.13227487e-02f, 1.88638587e-02f, 2.98187463e-03f, 5.50056696e-02f, 8.07405487e-02f,
  -1.98007780e-04f, -3.26175764e-02f, 6.19688444e-02f, 5.37331253e-02f, 4.31552641e-02f, 9.36501771e-02f, -8.52055196e-03f, -6.48000836e-02f, 8.77457932e-02f, -1.13957644e-01f,
  -3.57247263e-01f, 2.27388486e-01f, 5.34205079e-01f, 1.05189392e-02f, -1.56010650e-02f, 1.45713508e-01f, 1.20458469e-01f, -1.52371243e-01f, -1.27443641e-01f, 1.98304817e-01f,
  -1.16287827e-01f, -1.71752140e-01f, -5.93255386e-02f, -4.70431149e-02f, 8.11975375e-02f, 4.43776697e-01f, 4.60045755e-01f, 1.73385710e-01f, -2.21982636e-02f, -1.53097034e-01f,
  -1.87755227e-02f, 6.14901595e-02f, -3.85998189e-02f, -6.52830601e-02f, -4.39908775e-03f, -1.01571195e-01f, 2.46453971e-01f, 4.81870696e-02f, 5.50545417e-02f, 1.71169505e-01f,
  3.07884365e-01f, -1.70734555e-01f, -1.63314175e-02f, -1.82637021e-01f, 7.93292895e-02f, 5.40733384e-03f, 2.78354771e-02f, 1.38842002e-01f, 5.12249917e-02f, 8.94911215e-02f,
  1.42277181e-01f, 5.53562678e-03f, 7.88045079e-02f, -6.11048453e-02f, 8.90686642e-03f, 2.17358097e-02f, 4.91884425e-02f, 8.75986293e-02f, 1.21510237e-01f, 8.19320753e-02f,
  -1.65065434e-02f, 1.00896858e-01f, 1.17850229e-01f, -6.30774423e-02f, -1.61143839e-02f, 1.17536835e-01f, 9.04088542e-02f, -1.15446322e-01f, -6.87705725e-02f, 1.87263917e-02f,
  3.11974455e-02f, 2.60888860e-02f, -6.13218658e-02f, -3.18505056e-02f, 7.90512748e-03f, 3.25190239e-02f, -2.45296676e-03f, 2.42740158e-02f, -6.98927790e-02f, -1.16784181e-02f,
  -3.90062258e-02f, 1.78687517e-02f, 1.40884938e-02f, 2.77610449e-03f, 4.11768109e-02f, 3.47663835e-02f, -1.04035147e-01f, 2.63369828e-02f, 7.88393021e-02f, -4.65616249e-02f,
  2.49875300e-02f, -1.38722435e-02f, 4.38088700e-02f, 4.52757755e-04f, -2.58407257e-02f, -1.38251120e-02f, 8.35087430e-03f, -6.21189885e-02f, 3.07009518e-02f, -9.21959151e-03f,
  -4.77125533e-02f, 3.53469998e-02f, 9.85431150e-02f, -1.37070976e-02f, 6.12029657e-02f, 2.96847924e-04f, -1.40728196e-02f, 3.80003639e-02f, -3.46841998e-02f, 2.89795026e-02f,
  -7.89452046e-02f, -2.20482573e-02f, 2.33929232e-02f, -7.10373074e-02f, -3.56964841e-02f, -1.17485888e-01f, 9.00259390e-02f, -6.62544926e-06f, -2.96144113e-02f, -3.87700871e-02f,
  4.35789041e-02f, 6.72874274e-03f, 1.11940853e-01f, 6.48164824e-02f, -6.42442033e-02f, -3.48972790e-02f, 2.15371802e-01f, 3.38203013e-02f, 1.63237616e-01f, 1.31671533e-01f,
  -1.19487783e-02f, -1.52415549e-02f, 5.58440566e-01f, -8.12713727e-02f, -1.79951802e-01f, -1.60079047e-01f, -2.07118452e-01f, -2.17271656e-01f, -1.33019134e-01f, -7.65315024e-03f,
  -1.56010315e-01f, -1.32884949e-01f, -5.05172722e-02f, 8.28972831e-02f, 5.55543564e-02f, 4.40152101e-02f, 1.60966247e-01f, 3.10602486e-01f, 4.08458896e-02f, -1.20518476e-01f,
  -1.37105986e-01f, 4.79857698e-02f, 5.72853796e-02f, 6.22845367e-02f, -8.83804075e-03f, -5.01586646e-02f, 2.02989489e-01f, 1.82807982e-01f, 1.15392946e-01f, 2.93532759e-01f,
  2.35097647e-01f, 2.20373586e-01f, -4.35664691e-02f, -6.33516582e-03f, 1.05049036e-01f, 5.51242307e-02f, -1.06449582e-01f, 1.24876976e-01f, -3.42919603e-02f, -5.36039881e-02f,
  8.83402899e-02f, 4.28251512e-02f, 3.73754054e-02f, 4.90084440e-02f, -1.21841598e-02f, -1.61712375e-02f, 1.63792625e-01f, 1.68927804e-01f, 1.12060510e-01f, 3.86832952e-02f,
  -6.01143949e-02f, 5.56790344e-02f, 1.02166541e-01f, -5.78060821e-02f, 2.82675475e-02f, 1.06471695e-01f, 3.61165814e-02f, 7.84218758e-02f, 1.07662968e-01f, 8.33159033e-03f,
  -3.32674980e-02f, 2.84639802e-02f, -2.87006376e-03f, -2.36410741e-02f, -5.79372197e-02f, -1.81187782e-02f, 3.36139798e-02f, -6.08198419e-02f, -4.01647538e-02f, -9.65789333e-03f,
  3.81681100e-02f, -5.19412421e-02f, -8.28502029e-02f, -1.09710051e-02f, 1.51727423e-02f, 3.39466482e-02f, -2.88755801e-02f, -1.69283040e-02f, -8.93172529e-03f, -6.53614476e-02f,
  -1.71768386e-02f, 2.77713854e-02f, 5.68920262e-02f, -4.75285724e-02f, 7.18191043e-02f, 3.00497040e-02f, 2.88588852e-02f, -4.43081595e-02f, -5.62231839e-02f, 7.07404763e-02f,
  -3.01366866e-01f, 1.74654216e-01f, -5.46865165e-02f, 4.21923064e-02f, 3.29038799e-02f, 3.50356475e-02f, 1.10086486e-01f, -4.68073972e-02f, 1.74792539e-02f, -2.80753383e-03f,
  1.08059188e-02f, 2.50681415e-02f, 4.48224060e-02f, -9.42549761e-03f, -5.79500236e-02f, -2.68671345e-02f, -7.22016320e-02f, 2.22154204e-02f, -2.36758944e-02f, -4.84371409e-02f,
  -6.06181379e-03f, -1.99789420e-01f, -2.41268635e-01f, -1.49694502e-01f, -5.20092957e-02f, -1.06811792e-01f, -1.45724609e-01f, -1.23966992e-01f, -1.20365664e-01f, -4.30678725e-01f,
  -8.37719560e-01f, 1.22042950e-02f, 2.05711544e-01f, -1.57209218e-01f, 6.66166097e-02f, 1.36252180e-01f, 2.24994868e-02f, -1.70693740e-01f, -1.37525007e-01f, 6.91318065e-02f,
  -5.56672290e-02f, -8.06741863e-02f, -8.66657794e-02f, 5.31681366e-02f, -1.00653164e-01f, 1.24993213e-01f, 2.02948526e-01f, 3.20913084e-02f, 2.11623162e-02f, 1.10678963e-01f,
  6.55536354e-02f, -1.27686962e-01f, -2.61856973e-01f, -3.04545090e-02f, 2.19131261e-01f, 7.06896558e-02f, 9.16569456e-02f, 2.07934026e-02f, 1.08707726e-01f, 3.70748162e-01f,
  2.34739453e-01f, -2.01431543e-01f, 6.84904866e-03f, -4.75627892e-02f, 2.34448304e-03f, 1.07835615e-02f, 6.14664555e-02f, 5.47305606e-02f, -5.82964718e-02f, -5.95528111e-02f,
  -4.62387800e-02f, -6.92743659e-02f, 1.95121951e-02f, -2.98757874e-03f, -7.99387470e-02f, -1.14606852e-02f, -1.91698316e-02f, -1.46576524e-01f, -1.01022422e-02f, 5.44134155e-02f,
  7.43203014e-02f, 6.33702353e-02f, -6.86300769e-02f, -1.14927508e-01f, -8.75430331e-02f, -3.85317169e-02f, -1.06085517e-01f, -4.53721434e-02f, -1.82276666e-01f, -1.54851332e-01f,
  -2.34972648e-02f, -3.56802046e-02f, 7.10985512e-02f, -3.39615121e-02f, -2.96357647e-03f, 1.39328670e-02f, 1.14875190e-01f, -3.83045413e-02f, 2.56149638e-02f, 2.85588354e-02f,
  4.67273965e-02f, 1.59883313e-02f, 7.93047249e-03f, -5.86445071e-02f, 1.61241237e-02f, 1.31519921e-02f, -5.70326671e-03f, 1.87867377e-02f, -2.38167904e-02f, 1.84258260e-02f,
  -7.09671229e-02f, -3.49820517e-02f, -2.90120649e-03f, 6.92127272e-02f, 3.55038419e-02f, 2.11239010e-02f, -7.92473555e-02f, 7.70264566e-02f, -8.05943087e-02f, -2.36927113e-03f,
  -2.73678988e-01f, -5.96297765e-03f, -5.78457536e-03f, -5.78967035e-02f, 3.74082439e-02f, -9.02236253e-03f, -2.59652436e-02f, -1.65747888e-02f, 7.47150509e-04f, -5.74412234e-02f,
  -4.72789332e-02f, -8.61205757e-02f, -5.89852296e-02f, 9.90272164e-02f, 2.04290207e-02f, -1.27116675e-02f, -1.06355056e-01f, 7.42763430e-02f, 9.00285020e-02f, -1.25025287e-02f,
  -3.39405499e-02f, -5.08056544e-02f, -1.50240615e-01f, 4.31589857e-02f, -2.66934410e-02f, -1.25806406e-01f, 5.72891831e-02f, 1.93368867e-02f, -4.02736142e-02f, -1.33986279e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.89346555e-02f, 4.31921035e-01f, -1.22449510e-02f, 1.89370718e-02f, 5.34183951e-03f, 4.41948846e-02f, 4.01684612e-01f, 3.39113563e-01f, 5.74898869e-02f, 5.54937758e-02f,
  -1.08485900e-01f, -2.54828840e-01f, -4.68487218e-02f, -7.99511969e-02f, 1.42372027e-01f, 2.83737808e-01f, 2.53816426e-01f, -8.27357825e-03f, -1.44690707e-01f, -1.65053219e-01f,
  5.82828447e-02f, -6.35585487e-02f, -1.15303986e-01f, 5.35459854e-02f, 1.01519525e-02f, -5.56934066e-02f, 1.01966269e-01f, 1.89165045e-02f, 2.08636001e-02f, 1.47140920e-01f,
  -3.59389275e-01f, 1.63401037e-01f, -2.57558763e-01f, -1.57386750e-01f, -7.75460973e-02f, -4.59346827e-03f, -5.61274886e-02f, 3.63079607e-02f, 4.30737063e-02f, -3.63334119e-02f,
  -9.71790962e-03f, -1.17146559e-01f, 1.29461391e-02f, 6.35660440e-02f, 3.83585878e-02f, -7.78471306e-02f, 1.16201155e-01f, 2.15985309e-02f, 4.25529256e-02f, -7.93834031e-02f,
  -7.11692199e-02f, -2.94142198e-02f, -6.63836021e-03f, -1.13730486e-02f, 1.90455443e-03f, -1.85086891e-01f, -3.95354768e-03f, -5.47922775e-02f, 4.65407558e-02f, 9.28116143e-02f,
  -1.39012083e-01f, 4.91553284e-02f, -8.16327184e-02f, 6.71269223e-02f, 2.58716960e-02f, 9.69477594e-02f, 3.03737372e-02f, -5.48866726e-02f, 1.23909523e-03f, 7.19164982e-02f,
  -2.52623912e-02f, -9.65336934e-02f, 2.74360515e-02f, -6.53895438e-02f, -5.39278500e-02f, 1.51476664e-02f, -2.82779187e-02f, 6.47503138e-02f, -9.94706303e-02f, 8.06374941e-03f,
  4.97546280e-03f, 1.05848322e-02f, -3.63309868e-02f, 3.18467878e-02f, 1.82843767e-02f, 4.09110747e-02f, -3.50786410e-02f, -3.51149738e-02f, 9.76774562e-03f, -5.60528338e-02f,
  -9.59121510e-02f, -3.24025273e-01f, -6.22101314e-02f, 7.30404556e-02f, -7.64346421e-02f, -1.04438096e-01f, -3.55643667e-02f, -8.55611563e-02f, -1.76952165e-02f, 1.23172170e-02f,
  -1.31723121e-01f, 6.43353313e-02f, -5.03852665e-02f, -2.80547626e-02f, -3.09287030e-02f, -8.42495188e-02f, -6.28821179e-02f, 3.59729081e-02f, -6.76108301e-02f, 1.92479677e-02f,
  2.97069587e-02f, 2.57428866e-02f, -1.25894934e-01f, 6.55529276e-02f, 2.69810800e-02f, -2.46583462e-01f, -7.15621114e-02f, 1.27941892e-02f, -1.31744146e-01f, -1.86569970e-02f,
  4.65651870e-01f, -1.25934914e-01f, 8.80975798e-02f, 3.22954684e-01f, 3.11935365e-01f, 2.00063795e-01f, 7.16983899e-02f, 1.30072068e-02f, 1.93081826e-01f, 1.84251517e-02f,
  1.86660346e-02f, -8.33564922e-02f, -1.45961627e-01f, -1.54976010e-01f, -6.01047911e-02f, -1.74451880e-02f, -2.13953815e-02f, 8.16790983e-02f, 7.80954361e-02f, 5.84165715e-02f,
  -1.21755516e-02f, 1.44307762e-01f, 4.88366447e-02f, -7.39570484e-02f, -1.21955752e-01f, -4.23500836e-02f, -1.10071152e-01f, -7.86075145e-02f, -1.81519613e-01f, -1.09389439e-01f,
  -1.35536045e-01f, -1.28050884e-02f, 1.04113370e-02f, -3.19109596e-02f, 1.16886534e-02f, -1.05599828e-01f, 1.12691978e-02f, -9.77968350e-02f, 3.90230902e-02f, -9.38837044e-03f,
  -5.04228994e-02f, -6.84987232e-02f, -5.68671972e-02f, -1.48033537e-02f, 4.25364971e-02f, -6.97391778e-02f, -1.53221786e-01f, -1.24721557e-01f, -4.94667403e-02f, -2.13842675e-01f,
  -1.61896750e-01f, 1.18253291e-01f, 1.21897116e-01f, -8.52814596e-03f, -1.11276574e-01f, 3.53459790e-02f, -4.95662279e-02f, -1.84758663e-01f, 2.35154610e-02f, -1.43913198e-02f,
  -9.57844406e-02f, 5.80059700e-02f, -7.73876393e-03f, -1.27600068e-02f, 3.84056084e-02f, 4.86598723e-02f, 3.05113178e-02f, 6.30895719e-02f, -1.27508659e-02f, 4.45464104e-02f,
  -5.37479296e-02f, -5.31183742e-02f, -2.00335234e-02f, 5.58024533e-02f, -6.71154410e-02f, 3.34459059e-02f, 7.13328049e-02f, -6.35726824e-02f, -2.74956562e-02f, 4.71935235e-02f,
  -7.94838089e-03f, 3.44862719e-03f, -1.89750399e-02f, -1.21839322e-01f, -1.23577542e-03f, -6.28069118e-02f, -3.72120515e-02f, -5.92889637e-02f, 1.82943493e-02f, 8.94758850e-02f,
  -1.04413845e-01f, -1.62318759e-02f, 6.70237541e-02f, -9.92813334e-02f, 8.50516856e-02f, -3.51702161e-02f, -2.15357095e-02f, -5.72348684e-02f, -3.99363935e-02f, -6.67043449e-03f,
  -4.70015872e-03f, -7.94647112e-02f, -5.16575277e-02f, -2.15017907e-02f, 1.56611010e-01f, 1.23811312e-01f, 1.52000529e-03f, -7.42588332e-03f, -1.44879460e-01f, -6.32057637e-02f,
  -1.12715364e-01f, 2.48365879e-01f, 2.49379084e-01f, 1.31585449e-01f, 5.64896725e-02f, 3.27156991e-01f, 5.92224859e-02f, 1.18020579e-01f, 1.05030775e-01f, 2.16193542e-01f,
  -2.46897206e-01f, -1.70129957e-03f, 2.38463301e-02f, -1.96791850e-02f, 6.57477602e-03f, -1.05293505e-01f, -2.27806687e-01f, -1.40445262e-01f, -1.22696962e-02f, 6.89219981e-02f,
  -9.93427821e-03f, 5.50625809e-02f, 9.50106382e-02f, -7.00016564e-04f, -2.41562471e-01f, -1.97118208e-01f, -3.69242221e-01f, -2.91346878e-01f, -2.35507578e-01f, -6.27699122e-02f,
  -1.13124929e-01f, -1.38427258e-01f, -1.62148446e-01f, -1.78178266e-01f, 2.31147870e-01f, 1.23686269e-01f, 1.22125037e-01f, 7.45910257e-02f, -1.43436685e-01f, 8.95669758e-02f,
  6.44161403e-01f, 2.07742415e-02f, -1.03873700e-01f, -1.12058342e-01f, 1.02978811e-01f, -4.52822857e-02f, 7.36254081e-02f, 4.21467833e-02f, -1.21784594e-03f, 1.35970162e-02f,
  -1.90316234e-02f, -9.56539586e-02f, 6.73377439e-02f, 1.24101132e-01f, 4.31190990e-02f, 2.83982176e-02f, -1.06211253e-01f, -1.53171659e-01f, -3.94357778e-02f, 1.14173733e-01f,
  -1.08228356e-01f, -1.58122644e-01f, -2.16144491e-02f, -5.51113114e-02f, -2.71337889e-02f, -8.49304199e-02f, 3.82485054e-02f, -1.58173162e-02f, -4.19694595e-02f, 1.95179075e-01f,
  -2.36473773e-02f, 7.05190226e-02f, -3.37662399e-02f, 2.06692587e-03f, -7.54894316e-02f, 1.70302074e-02f, 1.50189949e-02f, -1.04724038e-02f, 2.77337022e-02f, -2.53433594e-03f,
  5.82426740e-03f, -1.64407399e-02f, -1.77048128e-02f, -1.92544721e-02f, 9.71782603e-04f, -3.06749493e-02f, -4.95492406e-02f, -1.39368400e-02f, -6.82438165e-02f, -7.90745541e-02f,
  -2.85846703e-02f, 2.57469881e-02f, 1.13054581e-01f, 9.01082754e-02f, -7.56834596e-02f, -9.62347910e-02f, -8.67924094e-02f, -2.06939615e-02f, 8.47987551e-03f, -9.92986653e-03f,
  5.23605168e-01f, -3.08838844e-01f, 7.46396109e-02f, -3.97226624e-02f, 2.88457572e-02f, 4.93011959e-02f, 2.62015555e-02f, -7.74757564e-02f, 2.52931025e-02f, 2.73738913e-02f,
  7.28981271e-02f, 2.26796549e-02f, 4.36225161e-02f, -1.67099237e-02f, 1.11455312e-02f, -4.66685630e-02f, -2.29538724e-01f, -1.02994498e-02f, -1.48793653e-01f, 6.13076463e-02f,
  1.94479246e-02f, -1.12811096e-01f, -9.37400535e-02f, 8.65108669e-02f, 8.70663896e-02f, 4.25827736e-03f, 2.13338614e-01f, 7.86173493e-02f, -3.16657382e-03f, 8.49612951e-02f,
  -3.73578042e-01f, 3.75453323e-01f, 4.09817308e-01f, -4.48682398e-01f, 2.03224838e-01f, 4.10106510e-01f, 4.82502401e-01f, -7.22510740e-03f, -3.15030098e-01f, 1.62758753e-01f,
  2.71630883e-01f, -1.21808894e-01f, -2.23320231e-01f, -1.78355232e-01f, -6.31964207e-02f, 9.15927589e-02f, 7.14929923e-02f, -2.71615982e-01f, -2.18135357e-01f, -3.30375172e-02f,
  -8.72813314e-02f, -2.68157184e-01f, -3.49007457e-01f, -2.32664719e-01f, -4.69996110e-02f, -2.61221796e-01f, 1.03746414e-01f, -2.99753118e-02f, 2.67661870e-01f, 1.85020659e-02f,
  3.65291268e-01f, 2.08161801e-01f, -2.01374710e-01f, -1.56214833e-01f, 1.43440768e-01f, -1.40463129e-01f, -4.24632896e-03f, -9.11483988e-02f, 2.11044680e-02f, 2.84891902e-03f,
  3.35676000e-02f, -1.00878634e-01f, -3.90739217e-02f, 3.13952044e-02f, -2.80640423e-02f, -1.87209994e-02f, -3.01382039e-02f, -1.04786515e-01f, -4.77218442e-02f, 2.01895207e-01f,
  1.39000446e-01f, 1.50464460e-01f, 2.34532222e-01f, 8.64683464e-02f, 1.02965027e-01f, -7.07744667e-03f, 1.45780206e-01f, 9.06669274e-02f, 1.87082946e-01f, -1.69159472e-01f,
  3.24251130e-03f, -1.62027392e-03f, 7.45874969e-03f, -3.66954170e-02f, -1.61959361e-02f, -3.28225456e-03f, -5.24026453e-02f, 2.62073409e-02f, -7.01287687e-02f, -2.80542132e-02f,
  1.74465531e-03f, 1.21390052e-01f, 1.14806071e-02f, -9.83233601e-02f, -2.60775294e-02f, 6.21666498e-02f, 5.70982043e-03f, 2.89283954e-02f, 5.02938814e-02f, 7.69753195e-03f,
  -2.94132773e-02f, 1.27858862e-01f, -3.07587311e-02f, 7.45429425e-03f, 1.44938052e-01f, -8.09008349e-03f, 1.29337590e-02f, 5.27938642e-02f, 2.31249388e-02f, 9.03383419e-02f,
  -3.45380217e-01f, 2.64391840e-01f, -1.28195763e-01f, -2.17770010e-01f, 3.57881114e-02f, 6.41958192e-02f, 6.22324012e-02f, 2.18453333e-02f, -7.14387558e-03f, -7.41663054e-02f,
  1.21081300e-01f, 1.54686710e-02f, 4.15499993e-02f, -1.84804760e-02f, -4.32032160e-02f, -1.96603592e-02f, 1.49260578e-03f, -1.81116596e-01f, 2.58702599e-02f, 1.24934927e-01f,
  5.96540719e-02f, 1.72033068e-03f, -2.20424756e-01f, -7.06225857e-02f, -2.34064646e-02f, -7.64057264e-02f, 7.38370791e-02f, -8.34111869e-02f, -5.44022433e-02f, -2.41923854e-01f,
  -3.89339805e-01f, -1.16382398e-01f, -1.51057228e-01f, -2.00554475e-01f, 2.61382908e-02f, 1.69044852e-01f, 2.62549371e-01f, 1.88753769e-01f, -1.31087929e-01f, -1.09714150e-01f,
  -9.23930332e-02f, -2.17386186e-01f, -2.03785613e-01f, -1.53450504e-01f, -9.71383601e-02f, 4.42977138e-02f, -8.11820105e-02f, -2.27890164e-01f, -1.27637565e-01f, -1.65153369e-02f,
  2.26138569e-02f, -2.26481408e-01f, -3.05853784e-01f, -2.20274046e-01f, -1.06695041e-01f, -2.85357386e-01f, -2.77862519e-01f, -2.22780094e-01f, -1.75876990e-01f, -2.68841684e-01f,
  -1.94472179e-01f, -1.19926363e-01f, -3.50610241e-02f, -5.65497875e-02f, -1.48501461e-02f, -6.38527796e-02f, -5.03034741e-02f, 5.28574316e-03f, 3.65301967e-02f, -8.91863555e-02f,
  -2.74578445e-02f, 1.30306827e-02f, -7.80299231e-02f, 3.71440463e-02f, 5.52269742e-02f, 7.39635900e-02f, 6.28892705e-02f, -1.07671462e-01f, -2.42145415e-02f, 1.64779663e-01f,
  5.16724363e-02f, -9.10259187e-02f, -1.59516990e-01f, 2.37271283e-02f, 7.00980872e-02f, -2.22719282e-01f, -1.43643618e-01f, -1.61628440e-01f, -6.27837032e-02f, -1.87851876e-01f,
  9.62284803e-02f, 2.60406416e-02f, 9.27713886e-02f, 1.51982279e-02f, 4.85773198e-02f, 3.65106203e-02f, -8.01810175e-02f, 1.00069623e-02f, -3.59912701e-02f, 3.40119889e-03f,
  -6.36420473e-02f, 5.02073579e-02f, -2.54006926e-02f, 7.58678932e-03f, -5.88378049e-02f, 7.32056797e-03f, -7.19827935e-02f, -4.20445204e-02f, -9.46407989e-02f, -1.68756545e-02f,
  -1.68112125e-02f, 3.05015873e-03f, -2.79853446e-03f, -3.45538445e-02f, 2.47384720e-02f, 5.24514392e-02f, -1.56133147e-02f, 1.92611814e-02f, 1.00216381e-02f, -7.24343881e-02f,
  -1.83589846e-01f, 6.67411387e-02f, -1.63457170e-01f, -8.25414807e-02f, -4.76441346e-02f, -7.02015460e-02f, -9.05071348e-02f, -3.48462872e-02f, -9.32391658e-02f, 5.15781567e-02f,
  8.65777805e-02f, 2.00815946e-02f, 1.14737749e-02f, 3.52488905e-02f, 5.45593798e-02f, -5.84809482e-03f, -1.66485999e-02f, -1.69580266e-01f, -9.00724903e-02f, 3.40845771e-02f,
  -3.46846841e-02f, -1.34592623e-01f, -3.32766414e-01f, -1.28997386e-01f, -1.39267355e-01f, -2.19863057e-01f, -2.60292053e-01f, -2.22028911e-01f, -3.02303165e-01f, -2.68999666e-01f,
  4.82804291e-02f, -3.12744337e-03f, -9.28379372e-02f, 1.90855548e-01f, 1.91183373e-01f, 1.25046849e-01f, 1.87576875e-01f, 1.83807731e-01f, 2.39693195e-01f, 2.52058655e-01f,
  2.46298671e-01f, 3.72560769e-01f, 3.14230621e-01f, 2.92840034e-01f, 2.69537896e-01f, 1.31141946e-01f, -9.08770226e-03f, 1.17781192e-01f, 8.60273540e-02f, 4.28613387e-02f,
  6.39549941e-02f, -6.23628870e-03f, -2.99403723e-02f, 3.60234194e-02f, 4.13090885e-02f, 2.59378441e-02f, 1.54407723e-02f, -7.90478662e-02f, 4.42459015e-03f, -4.05956171e-02f,
  -1.59255683e-01f, 4.18870561e-02f, 1.73254266e-01f, 5.49701676e-02f, -5.66408446e-04f, -9.73357409e-02f, 4.46141846e-02f, -4.63316366e-02f, -1.36122435e-01f, -1.10640429e-01f,
  -3.56786139e-02f, -8.24936107e-02f, 4.01054919e-02f, -8.20811242e-02f, -1.20509081e-01f, -2.31593498e-03f, 4.36659111e-03f, -1.74375926e-03f, 1.16310410e-01f, 6.93269074e-03f,
  8.02857205e-02f, 2.34378781e-02f, -4.17641699e-02f, -1.48043614e-02f, 1.45451501e-01f, 9.96458754e-02f, -7.48315919e-03f, -3.82780582e-02f, 1.90664344e-02f, 4.03509326e-02f,
  9.33910161e-02f, 9.14267004e-02f, 1.61658898e-01f, 3.52065675e-02f, 9.49192792e-02f, -2.54265014e-02f, -6.14516214e-02f, 8.40205476e-02f, 1.32049872e-02f, -7.55386660e-03f,
  2.66521778e-02f, -8.59915838e-03f, 1.26975596e-01f, 5.82388490e-02f, -6.92578685e-03f, 3.94601095e-03f, 7.93855917e-03f, 7.12655559e-02f, -4.19665016e-02f, -6.17113300e-02f,
  6.54200837e-02f, -7.50019848e-02f, -3.23647931e-02f, -8.01805332e-02f, -4.60642111e-03f, 4.89261076e-02f, 4.22955267e-02f, -5.05724549e-02f, 3.80391479e-02f, -7.92812482e-02f,
  -7.44588524e-02f, 1.18250802e-01f, 2.95606032e-02f, 1.17744533e-02f, -1.16926223e-01f, -1.51094213e-01f, 4.32874709e-02f, -1.10531196e-01f, -9.84741598e-02f, -8.00146088e-02f,
  -1.23595081e-01f, 5.97923901e-03f, -8.52338299e-02f, -1.53061837e-01f, -3.10139880e-02f, -1.03711963e-01f, -3.72941308e-02f, 2.47145835e-02f, 1.71549078e-02f, -1.36900833e-02f,
  5.04113559e-04f, -4.09407616e-02f, -5.70090078e-02f, 6.39986694e-02f, 3.80863994e-02f, 8.81650224e-02f, -9.15043056e-03f, -9.55249146e-02f, 4.06832434e-03f, -8.89751688e-02f,
  -8.19238648e-02f, 6.40996918e-02f, -2.73998797e-01f, 3.72346193e-01f, 4.47902888e-01f, 1.14320427e-01f, 9.71536115e-02f, -1.17331162e-01f, 3.44708450e-02f, 1.34174094e-01f,
  2.44339779e-01f, 2.95062184e-01f, 1.34776413e-01f, 2.30460148e-02f, -1.91792175e-01f, -1.28466245e-02f, 1.27287373e-01f, -1.80809990e-01f, -1.73293099e-01f, 5.74323125e-02f,
  2.57695526e-01f, 2.05957502e-01f, -4.55658138e-02f, 2.34306678e-02f, 2.75454193e-01f, 2.58307397e-01f, -2.41592117e-02f, 1.79123402e-01f, 1.94103569e-01f, 2.65459239e-01f,
  -4.46464941e-02f, -1.47580892e-01f, -1.76261276e-01f, 1.69504240e-01f, 1.14089258e-01f, -8.54545236e-02f, -1.19463585e-01f, -2.26794749e-01f, -2.82699224e-02f, -1.35456592e-01f,
  1.96689174e-01f, 6.04489967e-02f, 3.79626825e-02f, 2.77698524e-02f, -5.49349263e-02f, -5.93267493e-02f, -1.79862425e-01f, -2.61143416e-01f, -2.77687222e-01f, -3.93243171e-02f,
  3.46682191e-01f, 2.33118862e-01f, -9.20534357e-02f, -2.81898528e-01f, -1.31868437e-01f, 5.22770025e-02f, -8.19695964e-02f, -1.19464502e-01f, -2.42316663e-01f, -1.08757988e-01f,
  4.71906457e-03f, -3.42764482e-02f, -1.09555162e-02f, -1.33068869e-02f, -1.76932476e-02f, 4.58860323e-02f, -2.08148900e-02f, 9.71123353e-02f, -6.59386367e-02f, -1.06328400e-02f,
  -5.36608025e-02f, -5.64974211e-02f, -6.71685934e-02f, -8.39111954e-02f, -6.94633694e-03f, 2.76532620e-02f, 4.37652273e-03f, 4.09093499e-02f, -7.63371438e-02f, -7.14208260e-02f,
  -3.12337046e-03f, 2.62333974e-02f, -6.32255822e-02f, -9.21083987e-03f, -1.42759446e-03f, -1.01026811e-01f, -3.33527150e-03f, 5.08201160e-02f, 5.21248486e-03f, 8.15989356e-03f,
  -3.75921503e-02f, -2.00813666e-01f, -7.88397640e-02f, -6.36554286e-02f, 1.25285432e-01f, -6.82971030e-02f, 1.34353280e-01f, -3.92287001e-02f, 1.03434078e-01f, -7.27449656e-02f,
  3.89626250e-02f, -3.18690725e-02f, 9.97325778e-03f, -5.99562898e-02f, -6.40116483e-02f, -1.06913365e-01f, -9.37102456e-03f, -2.33432148e-02f, -1.00359350e-01f, -8.67521837e-02f,
  -2.64442042e-02f, -1.42048478e-01f, -1.56307191e-01f, -1.44433439e-01f, -3.11283227e-02f, -4.01791707e-02f, -1.13700144e-01f, -1.10872060e-01f, -2.64271200e-01f, -3.06843460e-01f,
  3.89602125e-01f, -1.42359352e-02f, 2.76017457e-01f, -3.18309814e-02f, -1.85345918e-01f, -3.00606936e-01f, -3.24106187e-01f, -1.46600783e-01f, -1.44081693e-02f, -3.78627144e-02f,
  -1.86143935e-01f, -3.76889929e-02f, -1.01704657e-01f, -1.09984130e-02f, 7.78799653e-02f, -2.15171389e-02f, 1.36705503e-01f, 3.28356445e-01f, 3.56394589e-01f, 2.45824113e-01f,
  8.75361264e-02f, 2.06251889e-01f, 3.04234147e-01f, 1.82797372e-01f, 4.52110432e-02f, 3.67601067e-02f, 7.34420717e-02f, 3.28985490e-02f, 1.80561785e-02f, 3.29496861e-01f,
  4.64758098e-01f, -1.94948837e-02f, 2.78959386e-02f, -7.13726133e-02f, 3.76373716e-02f, 5.68049811e-02f, 2.82859406e-03f, -4.69311625e-02f, -1.00253776e-01f, -1.34247104e-02f,
  -9.41962898e-02f, 5.38005307e-02f, -1.23951219e-01f, -2.40581762e-02f, 8.18370730e-02f, -6.36222288e-02f, 7.88034797e-02f, 2.09319461e-02f, 5.86673096e-02f, 2.01658551e-02f,
  -1.17249779e-01f, 4.15574235e-04f, 2.19212379e-02f, -1.13560423e-01f, -1.13006830e-01f, -6.86550811e-02f, -1.53970625e-02f, 1.36118867e-02f, -5.76511510e-02f, 1.04560897e-01f,
  3.74274366e-02f, 1.28515456e-02f, 2.32179668e-02f, 1.96672957e-02f, 4.23966795e-02f, 5.30980974e-02f, -1.63572282e-02f, 2.02875100e-02f, -1.09755537e-02f, 3.10916943e-03f,
  -4.66251336e-02f, 7.89956935e-03f, 2.53221882e-03f, 7.48485923e-02f, -2.76666787e-02f, 1.69823524e-02f, 9.55815837e-02f, -2.17084847e-02f, -6.73850775e-02f, 5.73358312e-02f,
  8.54064077e-02f, 5.17032556e-02f, 1.03386752e-02f, -2.62946486e-02f, 5.56833260e-02f, -9.30916984e-03f, 1.61275536e-01f, -6.53618947e-02f, -2.31350809e-02f, -2.95998286e-02f,
  -1.98298156e-01f, -4.15744603e-01f, 1.81924984e-01f, 6.37219623e-02f, -2.29384806e-02f, 9.75309219e-03f, -6.97690248e-02f, -1.85071640e-02f, -2.62875017e-02f, 7.69882202e-02f,
  2.41120253e-03f, 1.04579637e-02f, -7.70123117e-03f, -2.62479372e-02f, 1.03475988e-01f, 2.16395315e-02f, -2.88410205e-02f, -3.52401310e-03f, 8.79772007e-03f, -6.20729700e-02f,
  -8.64368677e-02f, 4.02371697e-02f, -9.43948552e-02f, -1.14448443e-01f, -1.01224616e-01f, 5.01083471e-02f, -4.58351523e-02f, -4.87853810e-02f, -2.80110240e-02f, 4.37938608e-02f,
  6.89142644e-02f, 1.31550744e-01f, 8.96285400e-02f, 2.45016720e-02f, -1.43939823e-01f, -2.14025989e-01f, -1.84217513e-01f, -3.10062170e-02f, -9.48658064e-02f, 9.49257687e-02f,
  6.35609031e-02f, 7.05693895e-03f, 8.12248513e-02f, 5.06489798e-02f, -1.07184350e-01f, -6.48261383e-02f, 5.59448004e-02f, -3.77641208e-02f, -1.46342695e-01f, -1.90723896e-01f,
  -1.11975901e-01f, 9.53270271e-02f, 1.49822906e-01f, 4.08389010e-02f, -8.50281399e-03f, -3.16040404e-02f, 1.66395511e-02f, 8.27663243e-02f, -4.82043698e-02f, 1.08731516e-01f,
  -8.59622359e-02f, -6.57768473e-02f, -1.38611868e-02f, 7.57450517e-03f, 4.89947498e-02f, -9.29614529e-02f, -8.02002400e-02f, -1.07605942e-03f, 7.13301823e-02f, 6.79184422e-02f,
  1.77859478e-02f, 4.32193885e-03f, -6.36007637e-02f, -1.21939613e-03f, -8.94658491e-02f, 3.99759673e-02f, -2.69240662e-02f, 6.24935888e-02f, 5.26422262e-02f, 2.15568300e-02f,
  8.24389514e-03f, -9.68439206e-02f, 6.43761456e-02f, 7.28806620e-03f, -6.60492629e-02f, 5.02954274e-02f, -1.97495501e-02f, 2.81188935e-02f, -1.10088237e-01f, 1.90878101e-03f,
  5.75270541e-02f, -1.87015943e-02f, -2.89226454e-02f, 5.14557883e-02f, 6.33407012e-02f, 1.97977759e-02f, 7.06563070e-02f, 1.08090758e-01f, 1.21253878e-01f, 5.22691049e-02f,
  -7.51924142e-02f, 4.62912917e-02f, 7.95825943e-02f, 4.16872166e-02f, 6.55850023e-02f, 5.49348034e-02f, 7.99661055e-02f, 1.02661148e-01f, 4.55222130e-02f, 8.40343609e-02f,
  7.76768550e-02f, 9.82133150e-02f, 2.89925132e-02f, 8.59492943e-02f, 6.65269420e-02f, 4.97197099e-02f, 7.29390010e-02f, 9.81017798e-02f, 9.30010900e-02f, -5.78241283e-03f,
  3.25876512e-02f, 1.06616318e-01f, -1.28309447e-02f, -2.99074166e-02f, -4.34087925e-02f, -6.19615056e-03f, 1.47948097e-02f, -4.01320793e-02f, -6.42812699e-02f, -1.02760218e-01f,
  -3.47606349e-03f, -1.73480958e-02f, -5.16187996e-02f, -2.60060951e-02f, -1.02094471e-01f, -5.65288179e-02f, 8.06713756e-03f, -8.09065998e-02f, 3.01770549e-02f, -7.11953118e-02f,
  -6.94549037e-03f, 2.74410397e-02f, 3.79843451e-02f, 3.36144269e-02f, -7.50460252e-02f, -4.18324135e-02f, -4.36487198e-02f, -1.26812562e-01f, -5.39586283e-02f, 2.71788295e-02f,
  1.53077498e-01f, 1.69741169e-01f, -6.55631274e-02f, -2.66693652e-01f, -1.96542338e-01f, -6.82756826e-02f, -8.47993717e-02f, -1.52987897e-01f, -1.57736555e-01f, -1.76529808e-03f,
  2.25705832e-01f, 2.63561040e-01f, 2.99713224e-01f, 2.01929778e-01f, 1.34037614e-01f, 6.19651601e-02f, -1.40034318e-01f, -8.61210078e-02f, -1.28900725e-02f, -2.57615328e-01f,
  -1.36085629e-01f, -1.77289248e-01f, -4.44812961e-02f, -1.79684639e-01f, -1.43190905e-01f, 6.38349801e-02f, -7.71962851e-02f, -1.56768307e-01f, -1.11679189e-01f, -7.24482313e-02f,
  2.82704055e-01f, 8.60969909e-03f, 8.04869458e-02f, -5.22781760e-02f, -1.16360478e-01f, -2.77460343e-03f, 5.74539863e-02f, -9.69948992e-02f, 2.40284652e-02f, 2.12078188e-02f,
  -5.37452064e-02f, -6.44335672e-02f, -7.51419738e-02f, -1.22037888e-01f, -3.73241417e-02f, -3.55765857e-02f, -1.25878796e-01f, -1.41334623e-01f, -9.59443972e-02f, -4.18446548e-02f,
  -6.59245253e-02f, -1.99937057e-02f, 8.93701315e-02f, 9.35041532e-02f, -5.84074482e-02f, 9.61554572e-02f, -3.50464322e-02f, -2.66182330e-02f, -2.02153772e-02f, -1.62813842e-01f,
  -1.44708809e-02f, 1.26249090e-01f, 1.11480011e-03f, -3.52275446e-02f, 1.40665472e-01f, 4.87273419e-03f, -1.77648719e-02f, 4.32114154e-02f, 1.05160754e-02f, 1.87440980e-02f,
  2.34807804e-02f, -2.19047312e-02f, 2.18605250e-02f, 7.77781010e-02f, 5.44821359e-02f, 1.99762303e-02f, -2.50366740e-02f, 4.24464457e-02f, 4.23368514e-02f, 3.05177979e-02f,
  -2.23577097e-02f, -6.13193661e-02f, -3.72573771e-02f, -4.56928052e-02f, -3.43649113e-03f, -4.17255051e-03f, 4.67657112e-02f, -6.56632185e-02f, 2.11468209e-02f, -1.24852285e-01f,
  1.23762317e-01f, 9.06088799e-02f, 2.04641670e-01f, 6.74392581e-02f, -1.35416791e-01f, -1.04409508e-01f, -6.14062045e-03f, -5.85127436e-02f, 5.86122740e-03f, 2.97310133e-03f,
  -8.42548087e-02f, 5.04602455e-02f, 1.32898986e-01f, -7.95271099e-02f, -5.14989607e-02f, 6.11340627e-02f, 6.33674935e-02f, 9.88470614e-02f, 5.12678549e-02f, -1.64061174e-01f,
  -1.27093583e-01f, 4.67152521e-02f, 3.16975892e-01f, 1.51339710e-01f, 4.14316840e-02f, 1.16389021e-01f, 2.05202386e-01f, 4.88187559e-02f, 1.28023401e-01f, 1.09195806e-01f,
  6.03728473e-01f, 5.86863458e-01f, 3.15050125e-01f, -3.99953015e-02f, -1.15405791e-01f, -2.88969022e-03f, 2.69721150e-01f, 1.00381941e-01f, -2.26515858e-03f, 1.30377844e-01f,
  5.42127341e-02f, -9.64805037e-02f, -6.87084273e-02f, -6.93886802e-02f, 9.49355513e-02f, 3.71490978e-02f, -3.18957083e-02f, -2.92114876e-02f, -2.37402506e-02f, -1.56902298e-01f,
  -1.09016776e-01f, -1.46749960e-02f, 2.73116529e-01f, 1.00196578e-01f, -4.58968617e-02f, -1.86047688e-01f, 1.07794181e-01f, 1.37227237e-01f, -1.93798263e-02f, -5.29346317e-02f,
  2.63081286e-02f, 5.52225530e-01f, -3.36313993e-01f, -1.44559547e-01f, -8.81570578e-03f, 1.44442692e-01f, -6.40276587e-03f, 9.13014635e-02f, -6.74020126e-02f, 2.33946629e-02f,
  -9.60659757e-02f, -7.30816945e-02f, -7.79476762e-02f, 3.48400697e-02f, -9.55816172e-03f, 9.16400179e-03f, 9.11176875e-02f, 8.75064656e-02f, -3.91269810e-02f, 9.77154672e-02f,
  -1.13141321e-01f, 2.54860353e-02f, 1.19353682e-01f, -8.96072984e-02f, 9.03772265e-02f, -2.10951924e-01f, 4.96779382e-02f, 3.43271904e-02f, -9.84535739e-03f, 1.51372805e-01f,
  -1.17975764e-01f, -3.13090943e-02f, 6.84385095e-03f, 2.38274615e-02f, -6.68166205e-02f, -7.64199421e-02f, -4.47011739e-02f, -6.54546022e-02f, -6.97027519e-02f, 7.69858658e-02f,
  -1.46541130e-02f, -7.01671392e-02f, 1.26372068e-03f, 3.03137563e-02f, -1.93786785e-01f, 3.41090350e-03f, 6.89968187e-03f, 1.14220688e-02f, -7.57126883e-02f, -3.63603681e-02f,
  -5.18748350e-02f, -1.90388504e-02f, -3.31215076e-02f, 9.95339453e-03f, -2.61102850e-03f, -5.66177908e-03f, -7.83354491e-02f, -8.79126228e-03f, 9.72771198e-02f, -4.12570573e-02f,
  -1.73905104e-01f, -1.39715388e-01f, -2.04262316e-01f, 1.49600849e-01f, 1.12955362e-01f, 1.31301032e-02f, -1.14480413e-01f, 7.45419413e-02f, -1.72937363e-02f, 1.11462884e-02f,
  9.02949497e-02f, 7.05012828e-02f, 6.16916977e-02f, -2.06807978e-03f, -1.29740596e-01f, -8.65898356e-02f, -7.89165124e-02f, -3.73297818e-02f, -8.21359679e-02f, -3.98207735e-03f,
  -4.65112925e-02f, -4.50692400e-02f, -9.33513045e-02f, -1.06359191e-01f, -5.29444851e-02f, -2.43123159e-01f, -8.53860229e-02f, -8.86818767e-02f, 2.75733043e-03f, 1.45040974e-02f,
  1.64477482e-01f, 2.52878834e-02f, 5.05620576e-02f, 2.96733290e-01f, -4.69236486e-02f, -5.22106171e-01f, -6.87892020e-01f, -1.88374922e-01f, 1.54825911e-01f, 1.91423821e-03f,
  5.70860915e-02f, -1.02493456e-02f, -7.24441232e-03f, -1.69342071e-01f, -4.02227402e-01f, -2.32741848e-01f, -5.60992472e-02f, -1.24082796e-01f, -2.36890346e-01f, -3.32526177e-01f,
  4.50436538e-03f, 1.54074028e-01f, 1.36535719e-01f, -6.40488267e-02f, 3.35789412e-01f, 1.39881447e-01f, 2.64291734e-01f, 2.26798519e-01f, 6.14447184e-02f, 3.76386434e-01f,
  1.17918983e-01f, 1.00863896e-01f, -1.79588392e-01f, 6.26705140e-02f, 1.54404998e-01f, 7.79187903e-02f, -6.09659255e-02f, 1.79248601e-01f, -4.31329980e-02f, -3.94166671e-02f,
  -1.14243291e-02f, 1.73285902e-02f, 1.48006417e-02f, -1.71879679e-02f, -3.58148254e-02f, -6.51146919e-02f, 4.74662818e-02f, -3.24249826e-02f, 1.97003707e-02f, -5.35883978e-02f,
  -3.28759365e-02f, -5.13416380e-02f, -6.63600191e-02f, -3.88714522e-02f, -6.80911019e-02f, 9.46971700e-02f, -7.76953772e-02f, -3.93607607e-03f, -8.51241723e-02f, 2.20720798e-01f,
  1.08070504e-02f, -1.89684313e-02f, -1.91200692e-02f, -4.41200323e-02f, 1.16575481e-02f, 7.75008369e-03f, 2.75815837e-02f, -1.06351271e-01f, -3.25061195e-02f, 8.03092420e-02f,
  -6.82986602e-02f, -8.42574518e-03f, 9.02858898e-02f, 1.54694552e-02f, 4.49319035e-02f, 7.41277728e-03f, -4.29640450e-02f, -1.19136386e-01f, -1.73848460e-03f, 7.56413788e-02f,
  1.65148806e-02f, -4.47993167e-02f, 4.96217534e-02f, 6.73720706e-03f, 2.02783123e-02f, 3.36510278e-02f, 2.69849524e-02f, 2.06370391e-02f, 6.60855472e-02f, 6.86969534e-02f,
  1.26042068e-01f, -3.00293058e-01f, 1.39735565e-01f, -7.25511461e-02f, 9.69306156e-02f, 1.03305867e-02f, 1.32732883e-01f, 1.48022827e-02f, 8.50514546e-02f, -4.03870316e-03f,
  -9.41867456e-02f, -7.45431036e-02f, -5.70755601e-02f, -8.13944042e-02f, -1.23920307e-01f, -5.53994142e-02f, -3.51463705e-02f, -4.19891477e-02f, -1.16551071e-01f, 7.81921521e-02f,
  -1.20803818e-01f, -2.56670386e-01f, -2.46921763e-01f, -2.23544061e-01f, 4.91800252e-03f, -2.16110304e-01f, -2.11974695e-01f, -2.56147832e-02f, -2.13016108e-01f, -1.90206856e-01f,
  4.82383907e-01f, 2.34173700e-01f, 4.43465188e-02f, 1.34510681e-01f, -1.72265358e-02f, 5.26138283e-02f, -2.07385793e-02f, -6.28816560e-02f, -1.13228126e-03f, 1.78252444e-01f,
  1.18943863e-01f, 6.36557192e-02f, -4.53786850e-02f, -7.69363791e-02f, 1.92975216e-02f, 1.28865734e-01f, 4.86141182e-02f, 1.38343900e-01f, -2.74872240e-02f, 1.02466404e-01f,
  1.65865067e-02f, 1.48339376e-01f, 1.06807791e-01f, 1.61799848e-01f, 1.26311287e-01f, 1.04057327e-01f, -5.94691411e-02f, 1.10893756e-01f, 6.56346902e-02f, 2.27713764e-01f,
  1.54611677e-01f, 2.49414593e-01f, -7.53265247e-02f, -6.20917417e-02f, -8.28245729e-02f, 9.69704241e-02f, 1.10449001e-01f, -1.00888290e-01f, -6.05183607e-03f, -4.75566089e-02f,
  2.19549891e-02f, 7.12911561e-02f, 3.74860317e-02f, -3.67270708e-02f, 1.24303671e-02f, -5.64792529e-02f, 4.95411046e-02f, -8.98153186e-02f, -6.26377687e-02f, 5.87798748e-03f,
  -6.81283772e-02f, 8.03885311e-02f, -1.05468743e-01f, -1.88676491e-02f, -3.31714526e-02f, -1.30750105e-01f, -9.39815715e-02f, 2.93237921e-02f, -1.38856918e-01f, 1.25554234e-01f,
  -4.40379381e-02f, -4.26383354e-02f, 7.24231452e-03f, 1.75061785e-02f, 9.01623070e-02f, 3.87805863e-04f, 9.89501271e-03f, 5.00580445e-02f, 9.86090228e-02f, -4.55500931e-02f,
  -8.19036365e-02f, 8.31845179e-02f, -1.33480188e-02f, 2.48876736e-02f, 4.59216312e-02f, -5.94544075e-02f, -6.41068444e-02f, 9.50802192e-02f, -2.52197962e-02f, 1.24948714e-02f,
  1.36212297e-02f, -5.60551994e-02f, -4.58797552e-02f, -7.95351937e-02f, 2.03294959e-03f, -4.82074507e-02f, 3.93169783e-02f, 9.20109525e-02f, 8.85777641e-03f, 2.61925347e-02f,
  -1.35834292e-01f, -1.31581664e-01f, 5.78198768e-02f, -5.14203962e-03f, 4.93545756e-02f, -3.59542631e-02f, 5.99774048e-02f, -8.31245035e-02f, 1.66170876e-02f, 1.45631739e-05f,
  -7.93990940e-02f, 1.61652118e-02f, -4.57170559e-03f, 5.36876135e-02f, 4.16515954e-02f, -3.03751044e-02f, 1.22840255e-02f, 3.93102206e-02f, -1.25356719e-01f, -3.12355347e-02f,
  -4.25507724e-02f, -9.05087814e-02f, -1.48243513e-02f, -1.97295263e-01f, 2.03783326e-02f, -1.13083884e-01f, -1.89547874e-02f, -1.55890778e-01f, -7.93479681e-02f, 1.50884353e-02f,
  5.04657745e-01f, -9.45515465e-03f, 2.90714920e-01f, 2.15723008e-01f, 1.30065531e-01f, 2.21879259e-01f, 2.60114908e-01f, 1.36124954e-01f, 3.63657326e-02f, 2.18833928e-04f,
  -9.65225399e-02f, -2.76406556e-01f, -1.34786084e-01f, -2.05117136e-01f, 7.88175836e-02f, 1.20954640e-01f, 1.44563466e-01f, 1.83675811e-01f, 1.45607844e-01f, 2.83975955e-02f,
  -7.66519904e-02f, 1.98922958e-02f, 2.47420281e-01f, 3.90958637e-02f, -8.32961723e-02f, -1.38995022e-01f, 5.29859178e-02f, 7.29577169e-02f, -3.70660014e-02f, -5.22545427e-02f,
  -8.54657069e-02f, 3.22605878e-01f, -5.80974743e-02f, -2.83405900e-01f, -1.39849901e-01f, 4.86921472e-03f, 9.15790559e-04f, -8.74271616e-02f, 2.50244588e-02f, -3.45924869e-02f,
  -7.69246966e-02f, -7.07007274e-02f, -8.06177184e-02f, -8.90383124e-02f, 1.39369503e-01f, 6.79269945e-03f, -1.26595106e-02f, -3.91300581e-02f, -3.53734493e-02f, -3.42203565e-02f,
  -1.97311834e-01f, 9.35015008e-02f, 1.31427288e-01f, 4.71033454e-02f, 1.37292156e-02f, -7.65977725e-02f, 8.30011070e-02f, -4.65515479e-02f, 1.11006372e-01f, -8.16273987e-02f,
  -1.41914748e-02f, -5.81484213e-02f, -4.58980165e-02f, 5.40638156e-02f, -3.13041237e-04f, 3.49924602e-02f, 5.16218469e-02f, -3.86806391e-02f, 8.00671801e-02f, 8.58459100e-02f,
  8.67706463e-02f, 1.12789810e-01f, 9.76952687e-02f, -1.29546560e-02f, -7.11435229e-02f, 5.66237681e-02f, 6.37685359e-02f, -8.20478201e-02f, 6.05485998e-02f, 9.10746690e-04f,
  8.71744901e-02f, 1.48947090e-01f, -2.15455610e-02f, -2.87873205e-02f, 7.84551818e-03f, 1.01463022e-02f, 4.43713777e-02f, -1.94979236e-02f, -1.95953548e-02f, 6.72038496e-02f,
  -7.25285336e-02f, 1.32927611e-01f, -9.45755243e-02f, -1.46004796e-01f, 4.62354310e-02f, -1.29196256e-01f, 8.28292128e-03f, -3.26388702e-02f, -9.26654339e-02f, -2.02763863e-02f,
  -3.80141358e-03f, -4.02787104e-02f, 3.49410437e-02f, -2.70767249e-02f, 1.65811658e-01f, 1.42250163e-02f, -2.15181768e-01f, 5.39456569e-02f, -4.45585996e-02f, -5.61462715e-03f,
  -1.91941887e-01f, 8.20500404e-02f, 1.94398522e-01f, 5.49058951e-02f, -6.12427630e-02f, 1.15587510e-01f, 6.12746067e-02f, -3.97995859e-02f, 1.37767941e-01f, 1.54793970e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.35211188e-01f, 4.51851606e-01f, 2.17883155e-01f, 4.99190420e-01f, 2.98865497e-01f, -7.77894855e-02f, 1.80579528e-01f, 3.56462002e-01f, 7.97180235e-02f, 2.62099802e-01f,
  1.99943200e-01f, 4.44034457e-01f, 1.01586908e-01f, 3.90529633e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -5.96895456e-01f, 1.75032504e-02f, 9.72623229e-02f, 2.37371236e-01f, 2.21687734e-01f, -7.64840662e-01f, -1.02455866e+00f, -5.50179295e-02f, 3.57561171e-01f, 6.74482957e-02f,
  -2.65228897e-01f, 7.44325340e-01f, -7.73463845e-02f, 1.27752006e-01f, -1.27377752e-02f, 3.76880914e-01f, -5.91324806e-01f, -9.48745161e-02f, -3.76498818e-01f, -1.97149098e-01f,
  1.80595726e-01f, -5.21582186e-01f, 7.96528280e-01f, -5.96215017e-03f, -2.76416451e-01f, -2.42843851e-01f, -1.57665610e-01f, -3.80613089e-01f, -1.36292100e-01f, 3.06665078e-02f,
  -9.55091715e-02f, -1.24423116e-01f, -4.32892114e-01f, 2.14824438e-01f, -1.82664499e-01f, 2.77122349e-01f, 3.12679499e-01f, -5.38963735e-01f, 1.68579817e-01f, 3.85629594e-01f,
  -1.62429839e-01f, 2.20020160e-01f, 5.72690666e-01f, 9.99715865e-01f, 2.77499020e-01f, 1.55871093e-01f, 5.35439849e-01f, -6.18253767e-01f, -5.66522181e-01f, -8.30640554e-01f,
  -2.73006052e-01f, 3.80634636e-01f, -2.77007818e-01f, -3.90345037e-01f, -4.43097860e-01f, 6.01914585e-01f, 9.87339690e-02f, -3.51567455e-02f, 3.91359143e-02f, 7.61176944e-01f,
  -1.51134744e-01f, -4.25668061e-01f, 3.39710951e-01f, 1.62840977e-01f, 6.05576634e-01f, 1.96706355e-01f, -7.44383484e-02f, 2.16889128e-01f, 3.79518121e-01f, 2.84149408e-01f,
  6.42594159e-01f, -2.48650864e-01f, 4.94417936e-01f, -1.26494154e-01f, -3.15224558e-01f, 8.93604994e-01f, 6.69086993e-01f, 6.07478201e-01f, 7.37577677e-01f, 2.82901563e-02f,
  9.23066497e-01f, 2.50059754e-01f, -3.34274620e-01f, -3.32706451e-01f, -4.29673076e-01f, -2.61073202e-01f, -4.26996909e-02f, -1.36479393e-01f, -3.93121690e-01f, 1.94040075e-01f,
  2.70155311e-01f, -3.20219517e-01f, -1.33994147e-01f, 3.50008458e-01f, -3.56437832e-01f, -5.48840910e-02f, -1.11891262e-01f, -7.34192729e-02f, 1.42430305e-01f, 6.28523808e-03f,
  1.89128637e-01f, 3.17930192e-01f, 6.18613325e-03f, 1.74709842e-01f, -3.31234366e-01f, 3.29022855e-01f, -2.17784166e-01f, -1.14519820e-01f, 1.30760804e-01f, -3.99461657e-01f,
  2.19929531e-01f, -4.14053947e-01f, -9.23936814e-02f, 8.55849028e-01f, -9.65120941e-02f, -2.50790536e-01f, -3.98164719e-01f, 1.12948477e+00f, 6.88512802e-01f, -8.73587281e-02f,
  -2.69242108e-01f, -1.74457997e-01f, -1.17974743e-01f, 3.56426165e-02f, -3.15405518e-01f, -7.09447443e-01f, -1.04778865e-02f, -1.93135232e-01f, 4.76037152e-02f, -4.92111176e-01f,
  -1.70559540e-01f, -5.51964283e-01f, -1.62028432e-01f, -8.27617347e-02f, -1.14498101e-01f, 3.58457834e-01f, -5.01134619e-03f, 5.56950629e-01f, -5.65208077e-01f, -7.01117277e-01f,
  -3.38124275e-01f, 4.04660553e-01f, 2.09940329e-01f, -6.02572799e-01f, 1.26324251e-01f, 1.49815366e-01f, 1.42726406e-01f, -1.37117341e-01f, 6.84954524e-01f, 1.70885816e-01f,
  2.06783980e-01f, 1.89381644e-01f, -4.74717706e-01f, -4.55216080e-01f, 7.92684481e-02f, -9.25618783e-02f, 1.85521960e-01f, 8.28088880e-01f, -2.94992328e-01f, -2.63700128e-01f,
  4.43308175e-01f, 4.73390430e-01f, 2.79529780e-01f, 2.97598124e-01f, 6.28944218e-01f, 5.69265127e-01f, 3.54137391e-01f, -3.51731807e-01f, 3.96159291e-02f, 2.60348052e-01f,
  5.77687740e-01f, -1.23087108e+00f, -5.22114515e-01f, -6.38264596e-01f, 4.57688183e-01f, -4.86317515e-01f, -6.93608522e-01f, -9.05520797e-01f, 1.23700760e-01f, 3.18940759e-01f,
  9.83212590e-02f, -6.50874496e-01f, 2.04040647e-01f, 8.17203075e-02f, 3.39598954e-02f, -3.06254208e-01f, 2.56048411e-01f, 1.21356174e-01f, 7.70998299e-02f, 1.52755454e-01f,
  1.54631928e-01f, 1.88976508e-02f, -1.64922193e-01f, -7.76424557e-02f, 2.29365766e-01f, 1.36572719e-01f, -2.58579582e-01f, 1.83457229e-02f, -6.04440942e-02f, -5.78917921e-01f,
  8.98261592e-02f, -5.59119999e-01f, -9.91058424e-02f, -7.79594630e-02f, 2.00117841e-01f, 2.88584530e-01f, -8.56269002e-01f, 1.26091123e-01f, 2.92132735e-01f, -3.96395335e-03f,
  4.31945741e-01f, -3.70805323e-01f, -8.78661126e-02f, -4.50902790e-01f, -4.70832020e-01f, -3.80406559e-01f, -4.34652299e-01f, 8.21555793e-01f, -9.25675686e-03f, -1.33159786e-01f,
  6.74974501e-01f, 3.24803710e-01f, 4.72688228e-01f, 2.13061050e-02f, -2.79574931e-01f, 4.96388860e-02f, -2.20176816e-01f, -4.40287173e-01f, 1.45445392e-01f, -1.02142014e-01f,
  7.74656311e-02f, 9.79034677e-02f, -7.70221710e-01f, -4.18480724e-01f, -5.17184101e-02f, -2.50485897e-01f, 2.24747226e-01f, -2.33663738e-01f, -2.73912311e-01f, 4.29565579e-01f,
  -1.86393529e-01f, 4.83557314e-01f, 7.48245955e-01f, -4.23896238e-02f, -7.70105496e-02f, -1.75459415e-01f, 8.82030725e-02f, 5.29583454e-01f, 7.55431592e-01f, -5.64765334e-01f,
  -1.24502480e-01f, -2.83250846e-02f, -5.40973127e-01f, -1.71164677e-01f, -9.34627354e-02f, -2.99479157e-01f, 4.38603848e-01f, -6.29950166e-02f, 8.75602216e-02f, -3.28821361e-01f,
  -5.07446587e-01f, 9.62560251e-02f, 2.09326204e-02f, 1.36178076e-01f, 2.99584746e-01f, -1.52443483e-01f, 4.11916882e-01f, -1.74482137e-01f, 7.48502553e-01f, -5.65597057e-01f,
  -6.94862127e-01f, 5.13772368e-01f, -4.02019680e-01f, -2.19522193e-01f, 6.05483353e-02f, 8.74135733e-01f, -1.59775689e-01f, -3.07097882e-01f, -1.28803730e-01f, -3.07903796e-01f,
  -3.62516105e-01f, 3.08673084e-01f, -3.44284952e-01f, -1.70097351e-01f, -3.88782769e-01f, -2.74595857e-01f, 6.75520152e-02f, 8.11522484e-01f, -4.59308513e-02f, -3.62064958e-01f,
  -9.27170739e-02f, -2.00412333e-01f, -3.49530190e-01f, 6.19860351e-01f, 1.11242436e-01f, 1.44051423e-03f, -9.60573107e-02f, -3.76941293e-01f, -3.27746630e-01f, -4.35679018e-01f,
  -5.39100468e-01f, 6.26234591e-01f, -1.55253150e-02f, -1.29007131e-01f, 3.29770356e-01f, 3.32232773e-01f, -5.22588074e-01f, 2.11209431e-02f, 1.34212241e-01f, 2.03552749e-02f,
  -3.62857193e-01f, -1.51535422e-01f, 9.51901734e-01f, 3.17558497e-01f, 1.69812098e-01f, -1.67579934e-01f, -3.89848977e-01f, 7.40624070e-01f, 2.78935581e-01f, -5.22841394e-01f,
  2.11919680e-01f, -1.37800545e-01f, -8.76762271e-02f, -3.98750186e-01f, -2.58536756e-01f, 3.18811208e-01f, -8.91702026e-02f, -1.76983610e-01f, 3.06686997e-01f, 2.47138619e-01f,
  5.90188861e-01f, 5.77273786e-01f, -5.09210527e-01f, -5.99582791e-01f, 3.02722394e-01f, 6.81100190e-01f, -1.65805042e-01f, 4.01174217e-01f, -2.01438576e-01f, -2.05658808e-01f,
  9.27047074e-01f, -6.57503977e-02f, -4.19187844e-01f, -7.23559409e-02f, -2.26247713e-01f, 1.32841215e-01f, -5.71913943e-02f, 6.06848001e-01f, -1.65026382e-01f, -1.79333389e-01f,
  -1.71953619e-01f, -1.65938780e-01f, 1.42767727e-01f, -1.36583462e-01f, -4.13869947e-01f, 4.34714556e-02f, -1.12122402e-01f, -3.70046705e-01f, 1.08586401e-01f, 1.13224104e-01f,
  7.38902912e-02f, 8.81110355e-02f, -1.42879829e-01f, -4.61543381e-01f, 1.42190129e-01f, 4.19992417e-01f, -4.45584714e-01f, 2.57285357e-01f, 3.94807100e-01f, -4.71242756e-01f,
  3.39571089e-01f, 7.90077969e-02f, -2.45247409e-01f, 7.77746856e-01f, 1.70879103e-02f, -2.28612259e-01f, 2.64042914e-02f, -4.11212862e-01f, 3.39161754e-02f, 4.00557704e-02f,
  8.30412567e-01f, -5.27525604e-01f, 2.39017874e-01f, 5.39299667e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.51145950e-01f, 2.21081764e-01f, 3.60636085e-01f, 1.83718037e-02f, -3.02589592e-02f, 3.15329790e-01f, -2.11379841e-01f, -2.79479567e-02f, -1.68994535e-02f, -9.05479863e-02f,
  -3.04825045e-02f, -1.58667460e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    