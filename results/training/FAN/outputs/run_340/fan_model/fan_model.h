/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.78009257e-01f, 3.72552983e-02f, 1.23041190e-01f, 6.97897747e-02f, -3.50424945e-02f, -2.57612556e-01f, -1.82142287e-01f, 1.42716840e-01f, 1.07998982e-01f, -8.30694363e-02f,
  -1.58989429e-01f, 3.40445861e-02f, 1.37968004e-01f, -8.12972113e-02f, 1.23995729e-01f, 1.43338993e-01f, -1.30132079e-01f, -1.66040942e-01f, 4.53802906e-02f, -1.25523861e-02f,
  1.24025978e-01f, -2.76977085e-02f, 8.47887322e-02f, 8.64447374e-03f, -8.96074101e-02f, -2.17449535e-02f, 8.73540193e-02f, 1.85111221e-02f, -8.62618610e-02f, -1.03557922e-01f,
  -5.40358312e-02f, 5.06700277e-02f, -3.21226604e-02f, 2.18579452e-02f, -4.71688211e-02f, -4.70005572e-02f, -5.88165596e-02f, 2.59603262e-02f, 1.54202720e-02f, -1.93693135e-02f,
  -3.85270864e-02f, -4.53112014e-02f, 4.33689766e-02f, 7.34161660e-02f, -3.40412706e-02f, -2.61621736e-02f, 5.13055548e-02f, -8.30427557e-02f, 1.41155794e-02f, 4.12683561e-02f,
  4.25144993e-02f, -8.92961305e-03f, -1.80366058e-02f, -1.04369350e-01f, 4.58788946e-02f, -4.06244770e-02f, -9.56659764e-02f, -2.26784497e-02f, -7.01378882e-02f, 1.07957974e-01f,
  1.74576510e-02f, -2.29377169e-02f, -6.38962016e-02f, -1.38447648e-02f, -1.04167424e-02f, -2.40507517e-02f, -6.97064251e-02f, 6.55575469e-02f, -5.83144240e-02f, -1.15765510e-02f,
  5.33560440e-02f, -5.10808825e-02f, 2.42495947e-02f, -3.59741673e-02f, 5.86197525e-02f, 5.51773515e-03f, -4.04165499e-02f, 5.29016592e-02f, 4.16882671e-02f, 4.43910174e-02f,
  7.95116574e-02f, 5.17419763e-02f, 6.17351010e-02f, 3.45568880e-02f, 2.38498598e-02f, -1.03158038e-02f, -5.27068935e-02f, 6.09323233e-02f, 3.58068645e-02f, 5.46845645e-02f,
  -2.45263092e-02f, 1.91900074e-01f, 5.86198363e-03f, -9.19632688e-02f, 2.39102286e-03f, -1.53239844e-02f, 1.49408700e-02f, 2.45492719e-02f, 1.06996022e-01f, 7.41042048e-02f,
  9.85958241e-03f, 1.89494062e-02f, -3.34075987e-02f, -2.02820394e-02f, -5.02795540e-02f, 2.92553324e-02f, 3.88746075e-02f, 2.87195351e-02f, -4.20322828e-02f, -4.38592434e-02f,
  1.97564214e-02f, -4.54356037e-02f, 1.25227673e-02f, 2.64413133e-02f, -6.05523326e-02f, 4.28282283e-02f, -2.75613973e-04f, 3.08451913e-02f, 7.54351169e-03f, -9.43125691e-03f,
  -2.70985633e-01f, 4.21865046e-01f, 1.80274546e-01f, -1.33829881e-02f, -2.20825076e-01f, 1.59864593e-03f, -3.18739489e-02f, 3.02875359e-02f, -9.82866064e-02f, 2.43927464e-01f,
  4.13566828e-02f, 9.07868892e-02f, 2.80128509e-01f, -3.65158431e-02f, -1.76030740e-01f, 1.55079573e-01f, -9.99165550e-02f, 7.37255141e-02f, -6.03080504e-02f, 1.48121223e-01f,
  -1.51043266e-01f, -7.00410306e-02f, 2.41701230e-02f, 6.46207407e-02f, 1.85881332e-02f, -1.64872054e-02f, 5.86872399e-02f, 1.23663254e-01f, -3.56205855e-03f, -7.65035395e-04f,
  -7.33630359e-02f, 6.99971765e-02f, -1.46791898e-02f, 3.07413805e-02f, 3.81333604e-02f, -7.04434980e-03f, -6.80177957e-02f, 4.74459026e-03f, -1.11899726e-01f, -5.07370755e-02f,
  2.79941652e-02f, -2.29582246e-02f, -1.17585808e-02f, -4.13119309e-02f, -9.45475549e-02f, -3.95805910e-02f, -3.73370610e-02f, -2.90641468e-02f, 5.31239286e-02f, 1.48067605e-02f,
  6.07647561e-02f, 4.26756814e-02f, -4.66012619e-02f, 3.74550633e-02f, -3.83040346e-02f, 1.46127967e-02f, 2.08993778e-02f, 3.25064957e-02f, 1.72057431e-02f, -1.00999307e-02f,
  3.57157066e-02f, -5.47569664e-03f, 6.01622276e-03f, 3.17162238e-02f, -1.27915442e-02f, -2.79168580e-02f, 1.74367819e-02f, -8.12607072e-03f, -3.80783454e-02f, 8.21231157e-02f,
  -8.19650441e-02f, 1.68565661e-02f, -2.39053071e-02f, -9.44437087e-03f, 5.38725071e-02f, -4.91662510e-03f, 4.58612479e-02f, 3.03233806e-02f, 9.81052406e-03f, -8.38435963e-02f,
  2.45365809e-04f, -1.51911611e-02f, 1.30024180e-02f, -3.36637050e-02f, 1.63417608e-02f, 2.44601574e-02f, 1.15335658e-02f, 3.51243652e-02f, 2.43432634e-02f, 2.20282003e-02f,
  1.22583672e-01f, 2.87547112e-01f, 7.75239058e-03f, -4.86619212e-02f, 3.07170190e-02f, -2.20358782e-02f, 4.55700569e-02f, -4.05457243e-02f, 5.55859543e-02f, 8.63329917e-02f,
  4.91577052e-02f, -7.97136053e-02f, 2.59214956e-02f, 3.97960730e-02f, 4.58641909e-02f, 5.02596535e-02f, 6.37504235e-02f, -2.44013630e-02f, -1.88830197e-02f, -1.26404604e-02f,
  -3.00564691e-02f, 1.91276036e-02f, -2.21062079e-02f, -5.16433679e-02f, -6.58885483e-03f, -1.93620622e-02f, -4.01697010e-02f, 5.81052061e-03f, 4.86907698e-02f, 3.01720742e-02f,
  -2.97413528e-01f, 1.85123935e-01f, -9.75191519e-02f, -1.32531971e-01f, -1.85858652e-01f, -4.05736752e-02f, -7.01203048e-02f, -3.71540822e-02f, -1.53401261e-02f, 1.56772211e-01f,
  1.36034161e-01f, -1.30727708e-01f, 1.13699347e-01f, 3.48218717e-02f, -6.92423657e-02f, 2.18301743e-01f, 5.97213842e-02f, 9.21362713e-02f, -9.81065109e-02f, -9.01016444e-02f,
  -9.54856128e-02f, 1.05436385e-01f, 5.35237342e-02f, 7.00191632e-02f, -1.10232137e-01f, -8.27474520e-02f, 1.16904616e-01f, -8.15336853e-02f, 1.02489822e-01f, 1.45227360e-02f,
  -1.28760919e-01f, 9.99877602e-03f, 2.57122833e-02f, -1.11116879e-01f, -1.21490993e-01f, 3.92716452e-02f, -7.11585134e-02f, -1.94349531e-02f, -1.41242640e-02f, 1.60433985e-02f,
  -1.81781370e-02f, -6.99485838e-02f, 3.85789759e-02f, 7.45454878e-02f, -8.53681713e-02f, -2.35790852e-02f, -1.71658751e-02f, 3.66010442e-02f, -1.04232006e-01f, -5.67734949e-02f,
  -6.96171373e-02f, 6.22331165e-02f, 3.12249344e-02f, 5.25145642e-02f, -5.30707836e-02f, 1.95920877e-02f, -4.53945547e-02f, 1.23712365e-02f, -1.47570968e-02f, -2.07394361e-02f,
  3.35557275e-02f, -5.56330532e-02f, -3.23533313e-04f, 4.00002226e-02f, 3.93487215e-02f, -2.78581809e-02f, 7.59248883e-02f, -5.11754770e-03f, 7.76242614e-02f, 5.39531186e-03f,
  -6.88105822e-02f, 1.14693437e-02f, -7.07056792e-03f, 3.93823311e-02f, -2.31501441e-02f, -1.36464965e-02f, -6.18536118e-03f, -3.70876901e-02f, -5.18756360e-02f, -2.87146103e-02f,
  2.07171347e-02f, -9.58610252e-02f, 8.57979655e-02f, -5.68447374e-02f, 1.42391091e-02f, 2.46739518e-02f, 1.44709889e-02f, 7.06509128e-02f, 2.79722642e-02f, 1.35741839e-02f,
  -1.46090046e-01f, -7.53552839e-03f, -5.74441347e-03f, 2.27904879e-02f, -2.17999076e-03f, -3.76448259e-02f, 2.68472191e-02f, -4.54725884e-02f, -3.27055752e-02f, -8.77033174e-02f,
  -9.13910847e-03f, 5.36515042e-02f, -7.16930479e-02f, -4.49033678e-02f, -5.01898630e-03f, 4.38231453e-02f, 1.76459700e-02f, 6.62519708e-02f, 2.36285087e-02f, 5.13214804e-02f,
  9.49892178e-02f, 4.74854000e-02f, 8.23101476e-02f, 1.88095570e-02f, 1.76455416e-02f, 7.04367878e-03f, 6.88622938e-03f, 4.00714502e-02f, 2.33680923e-02f, 6.35401756e-02f,
  2.15514079e-01f, 6.91551268e-02f, -2.31865123e-01f, 1.15992405e-01f, -1.81427673e-02f, -3.23486924e-02f, -7.43189901e-02f, -1.23081878e-01f, 8.14868584e-02f, 4.09260280e-02f,
  3.53588685e-02f, 2.75316954e-01f, -1.06162317e-01f, -4.48365510e-02f, -1.41127571e-01f, -8.55184812e-03f, -7.35029578e-02f, 1.20026849e-01f, -2.09483858e-02f, 1.19768545e-01f,
  -9.54422355e-02f, 2.00218111e-02f, -2.76592255e-01f, -1.10543907e-01f, -7.22546577e-02f, -6.55602664e-02f, -4.56533805e-02f, -1.47559971e-01f, -8.90182108e-02f, -4.79194112e-02f,
  -3.99600267e-02f, 7.79513195e-02f, 3.15840915e-02f, -1.41533650e-02f, -8.08451548e-02f, 4.61089648e-02f, 1.74032839e-03f, -3.62689123e-02f, 2.72116959e-02f, 2.61449721e-02f,
  7.16156587e-02f, -9.32703726e-03f, 1.84138808e-02f, -2.98405960e-02f, -6.56607933e-03f, 2.94787511e-02f, -5.02379127e-02f, -1.59261096e-02f, -7.71854147e-02f, -4.99804951e-02f,
  -1.01302743e-01f, 1.12353247e-02f, -7.32776523e-02f, -1.79833639e-02f, -3.72847170e-02f, 3.24787423e-02f, -1.85111910e-03f, -3.26720695e-03f, 1.01462394e-01f, 9.72845033e-02f,
  4.91454564e-02f, -1.05267905e-01f, -5.30348942e-02f, -2.87902895e-02f, -6.13479838e-02f, -6.23132065e-02f, 3.14764045e-02f, -4.41861600e-02f, 3.38624306e-02f, -7.32665211e-02f,
  -4.63602832e-03f, -7.67056039e-03f, 4.92232628e-02f, -5.43188229e-02f, 1.20189590e-02f, 9.22580715e-03f, -9.70349740e-03f, -5.01742326e-02f, -1.09708607e-01f, -2.06715185e-02f,
  -2.15205010e-02f, -4.02945504e-02f, 3.92670706e-02f, 2.67446917e-02f, 5.34777828e-02f, 1.57177597e-02f, -8.71519186e-03f, 8.47911928e-03f, -1.77636910e-02f, -1.93065908e-02f,
  -9.71324462e-03f, 1.47630095e-01f, -5.41119315e-02f, 6.25498267e-03f, -2.50356598e-03f, -2.32522748e-02f, -4.25360650e-02f, -8.28619208e-03f, 4.06178972e-03f, -6.50246628e-03f,
  4.70065847e-02f, 8.36971998e-02f, -2.46387664e-02f, 1.03587583e-02f, -5.33297621e-02f, -3.06160981e-03f, 5.53111732e-02f, -1.07928598e-02f, 6.42412230e-02f, 9.20619536e-03f,
  4.35252003e-02f, 2.34019682e-02f, -1.03966706e-02f, 1.82667896e-02f, 7.61589184e-02f, 6.87593743e-02f, 6.00365177e-02f, -4.19296660e-02f, 9.34637897e-03f, -3.67846228e-02f,
  -1.45817146e-01f, -1.02843590e-01f, -5.08577153e-02f, 1.31480813e-01f, 5.58738075e-02f, 2.24936783e-01f, 1.65972129e-01f, 6.13247044e-02f, 8.48808512e-02f, -1.13065548e-01f,
  1.64052788e-02f, -1.10531539e-01f, 3.35631855e-02f, 1.36047453e-01f, 4.38973099e-01f, 1.71199590e-01f, 1.69876158e-01f, 1.16324849e-01f, 1.07598072e-02f, -4.92757820e-02f,
  1.27281621e-01f, 1.22282803e-01f, 8.53509009e-02f, -1.73540078e-02f, -4.05139364e-02f, -1.23184875e-01f, 3.84288654e-02f, -3.80684659e-02f, 2.40474287e-02f, 2.23196913e-02f,
  -1.59543633e-01f, -7.49090239e-02f, -5.13596646e-02f, -3.71260233e-02f, 1.44586721e-02f, -8.42200071e-02f, -5.53322546e-02f, 7.46965036e-02f, -2.98476890e-02f, 1.06755793e-02f,
  -7.59990364e-02f, -6.95725996e-03f, 4.42073010e-02f, 2.20135935e-02f, -9.98396128e-02f, 6.49896357e-03f, -3.43510509e-02f, 4.08797152e-02f, -4.98505048e-02f, 4.76370677e-02f,
  3.32151279e-02f, -2.03758385e-02f, -2.23457310e-02f, -1.07721873e-02f, 1.45187313e-02f, 2.66247690e-02f, 3.02227493e-02f, -3.00778933e-02f, -2.71364097e-02f, 7.89435357e-02f,
  3.12603973e-02f, 5.32279871e-02f, 1.81762292e-03f, -5.18326499e-02f, 9.63808876e-03f, -5.14134988e-02f, 1.31881982e-03f, -3.32919769e-02f, 1.96235571e-02f, -1.38819311e-02f,
  3.54314856e-02f, -3.78954001e-02f, -9.68241040e-03f, 5.10874726e-02f, 2.79183704e-02f, -4.34594154e-02f, -4.24754731e-02f, -6.52376562e-02f, 1.08045444e-01f, -4.86197975e-03f,
  3.38536389e-02f, -1.70495901e-02f, 7.02908486e-02f, -5.98326102e-02f, 8.15346763e-02f, 1.22496048e-02f, 3.17761712e-02f, 4.77254391e-02f, 2.39046495e-02f, 5.81487976e-02f,
  -2.90880185e-02f, 6.12905473e-02f, -4.06487137e-02f, -4.30118404e-02f, -6.04543574e-02f, 8.84485198e-04f, -1.73527598e-02f, -1.43772010e-02f, 3.99320647e-02f, 9.59123075e-02f,
  4.51293215e-02f, -3.59900631e-02f, 5.69281466e-02f, -1.88701823e-02f, 2.59081479e-02f, 6.28679171e-02f, 6.47435011e-03f, 5.09653650e-02f, 4.00538333e-02f, -3.75061408e-02f,
  -2.08582524e-02f, -2.11504605e-02f, 4.54548001e-02f, 1.74766630e-02f, 7.48030550e-04f, 5.66064082e-02f, 1.87186673e-02f, 2.70141177e-02f, 5.92468716e-02f, 7.33302906e-02f,
  -1.96813971e-01f, -3.63670401e-02f, -4.26870473e-02f, -1.01296127e-01f, -3.40457372e-02f, -1.20826557e-01f, -5.25238998e-02f, 1.00565188e-01f, 9.33494568e-02f, 6.18679672e-02f,
  2.56356094e-02f, -1.75417840e-01f, 1.10986292e-01f, 2.24175882e-02f, -1.68804526e-02f, 2.29014486e-01f, 4.95680384e-02f, -1.22313879e-01f, 1.13451406e-02f, 4.72135991e-02f,
  -1.64513011e-02f, 1.03736632e-01f, -4.75801118e-02f, 3.94773623e-03f, -1.88939095e-01f, -4.95546870e-02f, 5.79722561e-02f, 5.98917007e-02f, -1.30363494e-01f, 2.13791113e-02f,
  -2.67668255e-02f, 6.44716844e-02f, -8.90970901e-02f, 1.38484510e-02f, -5.62824160e-02f, 1.94963925e-02f, -4.18555513e-02f, -1.28550408e-02f, 7.72554055e-02f, 2.99277510e-02f,
  -7.49847069e-02f, 9.85537618e-02f, -3.94089520e-02f, 6.48960024e-02f, 4.21548784e-02f, -1.56998802e-02f, 2.14258749e-02f, 5.99160325e-04f, -3.56130637e-02f, -4.33323532e-02f,
  -5.10346368e-02f, -6.18178323e-02f, -4.44526374e-02f, -1.79141499e-02f, -6.49420545e-02f, -9.64380242e-03f, 1.47656761e-02f, -3.55790905e-03f, 2.58054901e-02f, -1.94632784e-02f,
  5.91335371e-02f, 4.64902744e-02f, 4.69892584e-02f, 2.62913648e-02f, 4.91134785e-02f, 1.91811826e-02f, 1.53391454e-02f, -8.97210091e-03f, 5.37380502e-02f, 7.35439127e-04f,
  -5.29082529e-02f, 5.67421131e-02f, -2.16891197e-03f, -4.66661863e-02f, -1.92839727e-02f, -2.24405639e-02f, -8.58308896e-02f, -5.80293983e-02f, -4.62768078e-02f, -7.49472305e-02f,
  -2.66920682e-02f, 1.32346256e-02f, 4.28350493e-02f, 6.14124648e-02f, 3.68571393e-02f, -3.46139446e-02f, 1.40513880e-02f, -8.76521617e-02f, 8.36832747e-02f, -3.37436609e-02f,
  7.32871518e-02f, 1.81711897e-01f, 1.26610612e-02f, -1.42318318e-02f, -3.24821807e-02f, -2.04214565e-02f, 8.09388906e-02f, -2.58014761e-02f, 9.67795774e-02f, 5.79627305e-02f,
  -3.98543067e-02f, -4.92812619e-02f, -2.33123302e-02f, -2.81384084e-02f, 3.83447111e-02f, -2.34691203e-02f, -4.80914079e-02f, 1.02447895e-02f, 1.76872183e-02f, 2.52054837e-02f,
  -5.51587306e-02f, -4.95988652e-02f, 1.00699306e-01f, 3.37467827e-02f, -2.46692635e-02f, 2.56609675e-02f, -4.78877202e-02f, -5.80818243e-02f, -2.46834103e-02f, -4.43789773e-02f,
  1.72956809e-02f, 1.65916219e-01f, 9.20790210e-02f, 8.01766664e-02f, 9.26847979e-02f, -8.94584879e-02f, -1.19197801e-01f, 1.62737444e-01f, 1.43432647e-01f, 4.27891575e-02f,
  -2.96749771e-02f, -6.70287162e-02f, -1.68064106e-02f, -9.21502858e-02f, -4.77178007e-01f, -2.51414269e-01f, -2.16057539e-01f, -1.56150192e-01f, 1.00463226e-01f, 4.68617566e-02f,
  5.47965765e-02f, -9.21397880e-02f, -1.14332899e-01f, 9.64090675e-02f, 1.64886996e-01f, 2.01989025e-01f, -5.99270500e-02f, 1.31491601e-01f, -3.31758186e-02f, -1.84089899e-01f,
  -6.88432083e-02f, 7.91953728e-02f, 2.97551602e-02f, 6.88352948e-03f, 6.43506274e-02f, 1.27673568e-02f, -4.04177681e-02f, -6.00966625e-02f, -1.57387927e-02f, 4.08253446e-02f,
  -3.93759459e-02f, 1.50672961e-02f, -4.56887148e-02f, -1.52816102e-02f, 1.65325720e-02f, 2.66282586e-05f, 4.03402150e-02f, 2.56736130e-02f, 4.56610098e-02f, 1.15377996e-02f,
  5.80002107e-02f, -1.40267070e-02f, 3.44403237e-02f, -1.98094938e-02f, -5.18746115e-02f, 2.66488809e-02f, -6.57332316e-02f, 1.53793069e-02f, -6.68637268e-03f, -4.17756587e-02f,
  -2.86070127e-02f, -5.46707362e-02f, 1.32655418e-02f, -6.38311803e-02f, -2.62327362e-02f, 3.66136879e-02f, -5.90014122e-02f, -3.94450165e-02f, 1.73003860e-02f, -4.82485071e-02f,
  -2.56592631e-02f, 6.13883100e-02f, -2.94491742e-02f, 1.31211895e-02f, 6.71854196e-03f, -1.55661302e-03f, -4.12230007e-02f, 3.69996615e-02f, 1.70960054e-02f, 4.43297960e-02f,
  5.69313727e-02f, -8.67177173e-02f, -1.93918478e-02f, -1.25441933e-03f, 1.29094976e-03f, -2.59633455e-02f, -3.44151668e-02f, -2.10188385e-02f, 1.36732645e-02f, -1.60773136e-02f,
  -2.67053097e-02f, 4.07943688e-02f, 6.17743134e-02f, 2.82624811e-02f, 1.37441447e-02f, -4.57933843e-02f, -7.47354478e-02f, -4.09500785e-02f, 2.80240867e-02f, 2.37938277e-02f,
  1.46843856e-02f, 7.08533637e-03f, 3.23880538e-02f, -1.25304135e-02f, -2.48650685e-02f, -5.04551120e-02f, -9.03930515e-02f, 3.79359163e-02f, -2.48205685e-03f, -3.93893905e-02f,
  4.33899835e-03f, 2.58275250e-04f, -1.90677568e-02f, 4.91935983e-02f, 1.98735036e-02f, 1.96296275e-02f, 5.97493071e-03f, 3.73520032e-02f, -3.92525680e-02f, 1.42747769e-02f,
  -5.89301325e-02f, -8.76492336e-02f, -1.86530411e-01f, -3.33621174e-01f, 8.04401468e-03f, -4.51785559e-03f, -2.43152186e-01f, -1.08174227e-01f, -2.56053090e-01f, -2.18257215e-02f,
  -3.44882347e-02f, -1.63453758e-01f, 7.72499666e-02f, -1.72140896e-01f, -5.45505956e-02f, 4.69101220e-02f, -2.22180903e-01f, -2.20856577e-01f, -3.73771042e-02f, -1.25848740e-01f,
  -1.82590634e-02f, -2.95756031e-02f, 1.94098651e-02f, 5.66743277e-02f, -3.32374834e-02f, 3.66574787e-02f, 6.38381615e-02f, 2.02901870e-01f, -9.40042585e-02f, 4.50378843e-02f,
  3.40241976e-02f, -1.56803355e-01f, -1.10836774e-01f, -5.54785319e-02f, 7.64252571e-03f, 6.96925353e-03f, -6.24104366e-02f, 5.24472408e-02f, -7.08491914e-03f, -2.88846921e-02f,
  -1.91590656e-02f, -5.56782074e-02f, -9.59852487e-02f, 3.57795740e-03f, -2.08794307e-02f, -5.15397489e-02f, -2.57509667e-02f, -1.13948667e-02f, 2.87094582e-02f, -1.57359634e-02f,
  -8.45971033e-02f, -6.75595254e-02f, -7.49190226e-02f, -5.55684492e-02f, 8.92504398e-03f, 5.37678525e-02f, 2.09572129e-02f, 6.84645819e-03f, -3.83345373e-02f, -8.89154747e-02f,
  3.14468443e-02f, 1.59452595e-02f, -1.16411652e-02f, 6.96520209e-02f, -1.35630723e-02f, 8.32975283e-02f, -1.05447890e-02f, 2.10840087e-02f, 1.27436090e-02f, 5.25074713e-02f,
  -7.69805461e-02f, 2.19380800e-02f, -2.79627908e-02f, 8.39891378e-04f, -4.84726690e-02f, 2.83829626e-02f, 1.37691898e-02f, 2.11610328e-02f, -6.43227100e-02f, -3.85865420e-02f,
  4.61644791e-02f, 7.95218442e-03f, -4.54495177e-02f, 6.33387491e-02f, -1.98794734e-02f, 6.29345030e-02f, 5.82767837e-02f, 6.20120876e-02f, 6.96676299e-02f, 1.59290917e-02f,
  -8.91265571e-02f, -1.29999176e-01f, -3.61327305e-02f, -1.75979733e-02f, 3.40192690e-02f, -2.99400073e-02f, 4.42813151e-02f, -2.55125239e-02f, -5.79891428e-02f, 1.86966322e-02f,
  -3.84522416e-03f, 3.92230190e-02f, -2.53426377e-02f, -3.91336121e-02f, 2.62234583e-02f, -6.73832297e-02f, 7.25094900e-02f, -2.21481025e-02f, -4.55867834e-02f, 8.17922130e-02f,
  -4.82914448e-02f, 4.79316786e-02f, 1.94917601e-02f, -3.17233577e-02f, -3.75043601e-02f, -3.78579646e-02f, 5.53866941e-03f, -2.42847186e-02f, 6.79662377e-02f, 2.08220519e-02f,
  -1.41187415e-01f, 3.74975383e-01f, -6.83525577e-02f, 9.68289748e-02f, -1.82598412e-01f, -1.34727210e-01f, -4.43849936e-02f, -1.95135898e-03f, -9.02181678e-03f, 3.16464126e-01f,
  -2.69878358e-02f, 2.05907524e-01f, -3.15025635e-02f, 1.70974061e-01f, -2.70807743e-01f, -6.36901781e-02f, 2.20018014e-01f, 2.30934069e-01f, 1.98584162e-02f, 1.61341310e-01f,
  -5.35134971e-03f, 1.03776127e-01f, 6.83722124e-02f, 6.90487921e-02f, 1.35123208e-01f, 1.08865105e-01f, -9.20571014e-03f, -2.92164925e-02f, 9.02578086e-02f, -1.11430518e-01f,
  -1.01512864e-01f, -8.12821276e-03f, -2.61786561e-02f, -2.89003700e-02f, 5.52753583e-02f, -4.80384193e-02f, 7.16720745e-02f, -2.53204111e-04f, -1.80384852e-02f, 2.76759081e-03f,
  -7.45729171e-03f, 2.62864307e-02f, 3.54976277e-03f, -1.83817279e-02f, -4.48877700e-02f, 4.40739607e-03f, 7.37527832e-02f, 4.67746593e-02f, -4.06937078e-02f, -7.27791488e-02f,
  -2.64142863e-02f, 9.49453115e-02f, -2.07302161e-02f, 7.37159476e-02f, -4.39970605e-02f, -8.34553503e-03f, -2.42379475e-02f, -3.10272314e-02f, 8.58516544e-02f, 1.97790768e-02f,
  2.05198713e-02f, 2.13814173e-02f, -1.94584634e-02f, -6.23333529e-02f, 3.49494489e-03f, -9.62406471e-02f, 3.31775844e-02f, -5.70701668e-03f, 1.72561314e-02f, -1.85545138e-03f,
  7.78675498e-03f, 1.51911359e-02f, -6.43542483e-02f, -1.00998348e-02f, -5.18326834e-03f, -3.39865088e-02f, 1.91451348e-02f, -4.36935807e-04f, 6.17492720e-02f, 2.72793025e-02f,
  1.67447925e-02f, 3.58827296e-03f, 2.18641423e-02f, 8.22704509e-02f, -5.73307369e-03f, -2.80509926e-02f, 5.89565225e-02f, -2.88936086e-02f, 1.92446914e-03f, 3.25666331e-02f,
  1.30693316e-01f, 2.25096464e-01f, -2.33752225e-02f, -6.50194958e-02f, 2.31451541e-02f, 5.46279773e-02f, 6.07072711e-02f, -2.40219701e-02f, -2.01501139e-02f, -2.27196924e-02f,
  6.98566809e-02f, 4.76919152e-02f, 5.52009642e-02f, 3.26331370e-02f, -2.82332692e-02f, -3.91007848e-02f, -3.06573622e-02f, 4.06682938e-02f, 5.15435934e-02f, 1.02427386e-01f,
  -1.78824458e-02f, -4.32369001e-02f, 4.02602106e-02f, -4.47824411e-02f, 1.67314634e-02f, -4.22021225e-02f, 5.09568825e-02f, 5.86130731e-02f, 7.84513075e-03f, 6.31628186e-02f,
  -3.24962646e-01f, 1.18843451e-01f, -1.77581757e-01f, -2.24579901e-01f, -2.37815417e-02f, -2.78306335e-01f, -2.66513735e-01f, -3.02634127e-02f, 1.28563652e-02f, 2.45799288e-01f,
  5.89898340e-02f, -1.03665501e-01f, 2.22534940e-01f, -1.69804096e-01f, -4.63670135e-01f, 7.39221415e-03f, -2.22632751e-01f, -3.66293862e-02f, 2.51655858e-02f, -4.07734774e-02f,
  -8.01848527e-03f, -8.03775936e-02f, -7.47099146e-02f, 9.65491757e-02f, -1.55011460e-01f, 2.94875316e-02f, 7.99694657e-02f, 6.16646670e-02f, -6.94600493e-02f, -1.43304944e-01f,
  -1.34234861e-01f, 8.33586678e-02f, 3.05883866e-02f, -4.35956679e-02f, 2.41151340e-02f, -2.80251470e-03f, -1.64065957e-02f, -7.52817690e-02f, -1.09273568e-02f, 5.92408665e-02f,
  2.98758075e-02f, -3.32038314e-03f, -5.21008559e-02f, 4.08654772e-02f, -4.83701155e-02f, -2.48152036e-02f, 4.00665700e-02f, -6.43500080e-03f, -1.13405269e-02f, -5.88180311e-02f,
  -3.99031714e-02f, -2.04738174e-02f, 3.65264677e-02f, 3.69510315e-02f, -4.02705260e-02f, -2.67352071e-02f, -3.61813419e-02f, -2.03643199e-02f, -3.33577883e-03f, -4.42239121e-02f,
  -4.92797606e-02f, 2.16101706e-02f, 1.34416809e-03f, -5.23508117e-02f, -1.04644867e-02f, 4.57659699e-02f, 2.48837899e-02f, 4.23845500e-02f, 3.83526199e-02f, 2.05748025e-02f,
  -6.36138674e-03f, 1.12996472e-03f, -6.09250506e-03f, -1.65145807e-02f, -7.52718793e-03f, -3.12097892e-02f, -3.38251144e-02f, 6.07319213e-02f, 6.27273275e-03f, 1.50352279e-02f,
  -1.72887985e-02f, -7.92775601e-02f, 3.99453230e-02f, 4.52918233e-03f, -8.57815053e-03f, -1.13267181e-02f, 4.06344086e-02f, -3.12080793e-02f, -1.20495986e-02f, -4.84766588e-02f,
  -3.34978513e-02f, 1.31481692e-01f, 3.43046673e-02f, 3.49138528e-02f, 2.28535123e-02f, -3.38119618e-03f, -4.91042882e-02f, -8.21244717e-03f, -4.26972993e-02f, -3.67330089e-02f,
  2.63070664e-03f, -1.66655816e-02f, 7.13073909e-02f, -4.74800169e-02f, 2.93832496e-02f, 3.87402587e-02f, 3.64705874e-03f, -2.07509827e-02f, -2.58967876e-02f, 5.14172316e-02f,
  3.10096778e-02f, 8.15624222e-02f, -2.07076315e-02f, 2.42985245e-02f, 2.34760139e-02f, -1.11987512e-03f, -9.29572061e-03f, -5.49967960e-02f, -9.73362301e-04f, 2.51095742e-02f,
  -1.46586560e-02f, -6.71363249e-02f, 1.50521100e-01f, 2.98602879e-01f, -1.36725336e-01f, -3.25155929e-02f, -4.52035330e-02f, 2.23672439e-04f, 3.11048687e-01f, -1.29773274e-01f,
  -1.13295130e-01f, -2.31032595e-02f, -1.63429379e-01f, 1.45508543e-01f, 1.09009165e-02f, 2.71524582e-02f, 1.37222245e-01f, -1.42874653e-02f, 1.19825594e-01f, 8.21347907e-02f,
  9.60685387e-02f, 3.43054496e-02f, 1.08400650e-01f, 5.36011085e-02f, -2.95127891e-02f, 1.15330713e-02f, -2.35019043e-01f, -1.53194383e-01f, -7.42624104e-02f, -4.58077826e-02f,
  -1.35098577e-01f, 1.26834437e-01f, 2.85107344e-02f, 2.01006774e-02f, -7.57982358e-02f, -7.62962773e-02f, -1.07597828e-01f, -5.85992262e-02f, 6.56637847e-02f, 2.67154761e-02f,
  -2.99849827e-02f, -1.51484674e-02f, 2.04235874e-02f, 4.93826494e-02f, -2.34514866e-02f, 3.46239619e-02f, 2.32672989e-02f, -3.35663408e-02f, -1.11419233e-02f, -2.42785737e-03f,
  4.20807973e-02f, 3.01630180e-02f, 6.90949783e-02f, 3.26931849e-02f, 4.96015884e-02f, -2.08908841e-02f, 3.07082385e-02f, -9.71645117e-02f, -1.02219721e-02f, 1.01394266e-01f,
  3.52669992e-02f, -4.43156175e-02f, 3.81484814e-03f, 2.69757453e-02f, -2.21903063e-03f, 6.08052453e-03f, -5.19005433e-02f, -1.39121618e-02f, -4.85721268e-02f, -1.40518211e-02f,
  -2.26494204e-02f, 7.86373913e-02f, 5.90079464e-02f, 3.12100034e-02f, 2.90618446e-02f, -9.32811853e-03f, 1.09138107e-02f, 3.51781637e-04f, 4.28653024e-02f, 3.23489495e-02f,
  1.20320600e-02f, -4.22907323e-02f, 2.83623822e-02f, -6.26427829e-02f, 8.92328564e-03f, -3.03721591e-03f, -1.55585296e-02f, 6.25102315e-03f, 7.16647357e-02f, -3.73781472e-03f,
  -2.89574414e-01f, -8.80242735e-02f, 5.45069389e-02f, -5.45818731e-02f, -2.89834803e-03f, -2.96282694e-02f, 7.26583973e-02f, 5.57565279e-02f, -4.19473909e-02f, 4.51315055e-03f,
  -7.95153975e-02f, -1.86262168e-02f, -2.46372167e-02f, -2.06710515e-03f, -9.87503305e-03f, -6.12719432e-02f, -4.52749245e-02f, -6.49973825e-02f, 1.45374322e-02f, -6.33308664e-02f,
  -8.72673616e-02f, -9.17885453e-02f, -8.97288136e-03f, 2.72617042e-02f, 7.40936399e-03f, 4.34223982e-03f, -6.25146925e-02f, 2.75517479e-02f, -1.04812570e-01f, -2.70677656e-02f,
  5.65999597e-02f, 5.72102666e-02f, -8.75182897e-02f, -7.61259720e-03f, -4.61119935e-02f, -2.24704249e-03f, 5.79362586e-02f, -6.26310930e-02f, 2.12093014e-02f, 1.56996384e-01f,
  1.21026658e-01f, 5.96149005e-02f, 1.40297100e-01f, 2.71769673e-01f, 9.43112969e-02f, 1.89173520e-01f, 3.05190414e-01f, 1.86145023e-01f, -3.54981944e-02f, 1.39425516e-01f,
  6.99312165e-02f, 1.53948039e-01f, 9.09072831e-02f, -3.32929939e-02f, 1.75540354e-02f, -1.22699000e-01f, -2.61789709e-02f, -9.43515077e-02f, -1.04533639e-02f, 4.17639874e-02f,
  1.09798767e-01f, 6.94572181e-02f, 8.14303160e-02f, 4.02533775e-03f, 4.77131717e-02f, 6.61220551e-02f, -5.97471073e-02f, 6.12984970e-03f, 7.71224080e-03f, -6.41606301e-02f,
  -1.90327223e-02f, 9.09032580e-03f, -7.25020394e-02f, 3.44413407e-02f, -3.43611687e-02f, 1.08457832e-02f, -7.01015294e-02f, 6.91046044e-02f, -6.02820739e-02f, -1.76340826e-02f,
  -4.68519293e-02f, -2.61675753e-02f, -3.83128412e-02f, -4.56841104e-02f, -4.01732996e-02f, -1.30192796e-02f, -5.04326001e-02f, 8.50835145e-02f, 2.27686781e-02f, 3.76583301e-02f,
  1.18220627e-01f, -1.49504449e-02f, -4.48923931e-02f, -7.24894777e-02f, -4.47543524e-02f, -5.86914830e-02f, -3.98132950e-02f, -2.02177353e-02f, -8.06577653e-02f, 2.22365186e-02f,
  -2.53096651e-02f, -6.01754673e-02f, -1.60470288e-02f, -7.73872286e-02f, 3.55334058e-02f, -6.00724183e-02f, -6.78265318e-02f, 2.70398967e-02f, 2.50733532e-02f, -3.93928848e-02f,
  4.35446315e-02f, -3.32751051e-02f, 8.49930197e-02f, -8.62568021e-02f, -1.58736333e-02f, -6.25657365e-02f, 5.56654967e-02f, -6.56968281e-02f, 3.42440903e-02f, -7.69055560e-02f,
  1.68147281e-01f, 6.14973716e-02f, 1.19198961e-02f, -5.98191768e-02f, -6.03301376e-02f, 4.61270884e-02f, -3.45622040e-02f, 3.95189710e-02f, -8.89335480e-03f, 4.72350754e-02f,
  -4.15602066e-02f, -5.48229478e-02f, 2.32942984e-03f, -5.78982495e-02f, 1.98220070e-02f, 5.06871054e-03f, 3.99844721e-02f, -4.04315591e-02f, 1.18858805e-02f, -1.21130608e-02f,
  -2.51803622e-02f, -4.15729433e-02f, -6.82014376e-02f, -1.20361177e-02f, -5.93200512e-02f, -9.18948092e-03f, -7.28318468e-02f, -4.68476824e-02f, 4.03547147e-03f, -7.51421228e-02f,
  1.55650645e-01f, -7.73314945e-03f, -2.71303393e-02f, 6.17972985e-02f, -3.81035842e-02f, 8.34820345e-02f, -1.48229152e-01f, -1.49142807e-02f, -4.81784046e-02f, -1.65760025e-01f,
  -7.25402907e-02f, 7.93477222e-02f, -1.03144825e-01f, 9.90711376e-02f, 3.22332770e-01f, 2.24301785e-01f, 1.28856391e-01f, -4.78701703e-02f, 1.13827430e-01f, -1.27817944e-01f,
  1.68028295e-01f, -3.61120664e-02f, 1.69164047e-01f, -1.18358567e-01f, -2.67582536e-02f, -8.93973634e-02f, 8.72172043e-03f, -5.59481792e-02f, -8.51401035e-03f, 1.21227875e-01f,
  3.06094866e-02f, -6.88392073e-02f, -8.23590085e-02f, -3.03986249e-03f, 8.21764022e-02f, -2.20439564e-02f, -7.86765665e-02f, -1.30770216e-02f, -1.48524307e-02f, 2.64747515e-02f,
  2.57998127e-02f, 5.06730117e-02f, 1.08483713e-02f, 4.60408516e-02f, -3.51373814e-02f, -4.86564189e-02f, 2.53307279e-02f, -3.16239446e-02f, 1.77915639e-03f, 7.09450245e-03f,
  -3.46939899e-02f, 3.38576660e-02f, -5.35341129e-02f, -2.39036717e-02f, 8.24295282e-02f, 2.09549908e-02f, 4.92180958e-02f, -3.15783732e-02f, -5.08113801e-02f, 5.35670780e-02f,
  -2.91552637e-02f, 1.08683866e-03f, -1.10738492e-02f, -2.96242506e-04f, 6.61239177e-02f, -1.50975799e-02f, 1.60196591e-02f, -8.51454679e-03f, 7.46806711e-03f, -2.83467993e-02f,
  4.69923839e-02f, -3.73520218e-02f, -9.36171226e-03f, 2.14837380e-02f, -5.93116023e-02f, 3.99370911e-03f, 6.78889230e-02f, 4.31617759e-02f, 2.41388418e-02f, 8.98903832e-02f,
  -3.80344316e-02f, 7.51890093e-02f, 2.44807154e-02f, -3.65109853e-02f, -1.69067550e-02f, 4.18503471e-02f, -5.05327284e-02f, 3.93896848e-02f, -2.24879216e-02f, 1.64558049e-02f,
  -4.56234403e-02f, 1.06045241e-02f, -5.36264479e-02f, -2.53088549e-02f, -4.12524119e-02f, -2.89721135e-02f, 5.49626127e-02f, -4.70626960e-03f, 8.54625329e-02f, -2.30836477e-02f,
  -6.63897172e-02f, -1.05021968e-02f, -3.60969603e-02f, -1.61327440e-02f, 7.13708550e-02f, 1.94162279e-02f, -6.94495663e-02f, 1.12336557e-02f, -8.10027793e-02f, -1.67119373e-02f,
  -9.08289924e-02f, 3.81568410e-02f, -5.01489565e-02f, -5.27188107e-02f, 3.57881398e-03f, -8.80942270e-02f, 5.88851832e-02f, -3.05633657e-02f, 1.71965770e-02f, 2.07600687e-02f,
  2.01197967e-01f, 1.61870375e-01f, -4.90826927e-02f, 8.99783988e-03f, -1.86298881e-02f, 3.87278013e-02f, -9.36990511e-03f, 1.07509926e-01f, 4.42619771e-01f, 1.28477082e-01f,
  -8.91972482e-02f, 6.52371943e-02f, 3.33033758e-03f, -6.19747266e-02f, -2.91633066e-02f, 4.94135730e-02f, 8.75836760e-02f, 1.51510648e-02f, 9.63260606e-02f, -9.12596136e-02f,
  6.72066584e-02f, -1.88903093e-01f, -2.38018259e-01f, -1.53047472e-01f, -4.39990535e-02f, 2.48567797e-02f, -1.62328079e-01f, -1.25115871e-01f, -1.74568176e-01f, -4.56454344e-02f,
  -7.12394267e-02f, 1.26093730e-01f, 4.31304425e-02f, -1.53538361e-02f, -5.35482317e-02f, -5.09399697e-02f, 9.28845908e-03f, -6.77291751e-02f, -2.53276378e-02f, 1.77358987e-03f,
  3.47129479e-02f, -7.96302259e-02f, 4.59604664e-03f, -2.49818191e-02f, 2.29522381e-02f, -2.04972792e-02f, -1.32588530e-02f, 3.05339564e-02f, -2.30642147e-02f, -2.49499790e-02f,
  -6.67008944e-03f, -2.54167640e-03f, -7.97333047e-02f, 8.89210962e-03f, -9.42434836e-03f, 4.72889422e-03f, 3.19960155e-02f, -6.84395954e-02f, 5.24948128e-02f, 7.46197030e-02f,
  1.05778337e-01f, 1.77221373e-02f, -5.53940376e-03f, -6.96958750e-02f, -2.94344276e-02f, -8.79502110e-03f, -4.34720106e-02f, -5.02064303e-02f, -2.57297475e-02f, -6.61554486e-02f,
  1.64444558e-02f, -6.57736361e-02f, 3.78184468e-02f, -2.30192300e-02f, 3.93599793e-02f, 1.27672879e-02f, -4.22900319e-02f, 1.62816439e-02f, 6.02780543e-02f, 2.00724974e-02f,
  3.80270332e-02f, 5.52443191e-02f, -2.15258487e-02f, -3.62529270e-02f, -1.13576576e-02f, -3.03735621e-02f, -2.92651970e-02f, -1.51185608e-02f, -8.95842910e-02f, 4.58618393e-03f,
  1.25941873e-01f, 2.15325505e-01f, -3.88789326e-02f, 6.72404021e-02f, 3.72801013e-02f, -6.34226501e-02f, 2.96502598e-02f, -4.02866639e-02f, 5.52824326e-02f, 3.66339944e-02f,
  5.43494755e-03f, 4.67060544e-02f, 2.35398207e-02f, -8.23042169e-02f, -9.30864215e-02f, 8.01878721e-02f, -8.83527920e-02f, 7.50050768e-02f, 1.09661538e-02f, -8.09582844e-02f,
  -2.35455558e-02f, 7.58336438e-03f, 2.72870995e-02f, -3.06343264e-03f, 1.93946976e-02f, -1.64569896e-02f, -1.76203288e-02f, 3.34612839e-02f, -5.20482548e-02f, 2.48053689e-02f,
  2.33937785e-01f, -3.88137512e-02f, 1.32555470e-01f, 1.78976670e-01f, -2.15125814e-01f, -2.91540504e-01f, 3.04327123e-02f, -1.57664165e-01f, -2.94265114e-02f, -8.53259340e-02f,
  -9.79556888e-02f, 2.49344870e-01f, -4.12849598e-02f, -6.92917854e-02f, 1.34867057e-01f, 7.11701519e-04f, -1.34540230e-01f, -3.76950167e-02f, -3.72902676e-02f, -3.89974192e-02f,
  7.72040784e-02f, -9.53592211e-02f, 6.76884875e-02f, -1.61898583e-01f, -3.90085094e-02f, 1.43689319e-01f, 1.37852892e-01f, 1.52215250e-02f, 4.60274294e-02f, -4.80861291e-02f,
  -8.56457725e-02f, 9.35078189e-02f, -3.45221907e-02f, 6.23236187e-02f, 3.22850868e-02f, -6.46468103e-02f, -7.86689483e-03f, 9.16821137e-02f, 4.23628911e-02f, 6.05302863e-02f,
  -1.35931745e-02f, 6.85819983e-02f, 5.29019572e-02f, 1.74742248e-02f, -7.77003318e-02f, -1.55899078e-02f, 3.66609404e-03f, -4.57661860e-02f, -2.07164120e-02f, -5.27327098e-02f,
  9.02183801e-02f, -4.05798107e-02f, 6.79130778e-02f, 4.37830947e-02f, -5.46014449e-03f, 7.80856609e-03f, -2.66949683e-02f, -2.99041793e-02f, 8.10766518e-02f, 6.08957410e-02f,
  3.01693920e-02f, -2.94462238e-02f, 4.97900993e-02f, -3.71683226e-03f, -4.54145856e-02f, -5.58284298e-02f, 6.42998442e-02f, -1.24441367e-02f, 6.71185255e-02f, 1.98723841e-02f,
  7.94152766e-02f, -2.34640092e-02f, -7.51199797e-02f, 5.21710776e-02f, -3.61140147e-02f, 8.70975852e-03f, 5.67046478e-02f, 8.08847770e-02f, 2.01221164e-02f, -3.53388824e-02f,
  -4.84681986e-02f, -4.32593096e-03f, 2.63859704e-02f, 4.33603823e-02f, -8.68937075e-02f, 4.82062846e-02f, -1.65355112e-02f, 2.88832579e-02f, -5.35852648e-02f, 1.30029693e-02f,
  -1.25941262e-01f, 1.17031962e-01f, -2.21110992e-02f, 5.97441122e-02f, 1.83125157e-02f, -3.63386795e-02f, 9.79846995e-03f, -5.12657277e-02f, 5.73246554e-03f, -1.67118311e-02f,
  -7.80980010e-03f, -4.63597104e-02f, 3.65981162e-02f, -3.16876806e-02f, 1.05104810e-02f, -6.41203001e-02f, 5.87042607e-02f, 3.88436974e-03f, 3.46989073e-02f, 5.44187725e-02f,
  -8.87886342e-03f, 2.27865614e-02f, 8.42931271e-02f, -1.93156824e-02f, -3.32790054e-02f, 6.01302385e-02f, 3.01466621e-02f, 9.69343930e-02f, 7.94558451e-02f, 2.41942201e-02f,
  -3.21361482e-01f, 2.76293993e-01f, 2.05265760e-01f, -8.55353400e-02f, -2.18732744e-01f, 1.09391503e-01f, 7.37863556e-02f, -4.45472300e-02f, 4.88947183e-02f, 1.15018904e-01f,
  -5.67725487e-02f, 1.87807647e-03f, 2.13019237e-01f, 1.45143285e-01f, 8.78958628e-02f, 2.70004719e-01f, 7.16452673e-02f, 2.50918586e-02f, -7.55920447e-03f, -7.17366412e-02f,
  -8.67605507e-02f, -3.35128345e-02f, 1.23020232e-01f, -1.27165047e-02f, -1.48386776e-01f, 2.34386716e-02f, -1.85048152e-02f, -3.62504348e-02f, -4.50019091e-02f, -9.03238654e-02f,
  1.07379921e-01f, -9.04968232e-02f, -6.07783161e-02f, 2.26090383e-03f, 4.38094279e-03f, -1.24138243e-01f, 4.03267108e-02f, -4.25193924e-03f, -3.55031565e-02f, 2.50297692e-02f,
  -6.25226647e-02f, -6.69417977e-02f, 3.78457382e-02f, 5.82196265e-02f, -1.13839634e-01f, -5.87010710e-03f, 3.79824720e-04f, -1.11133168e-02f, 5.73496334e-02f, -4.39207517e-02f,
  -4.23057610e-03f, 4.48405221e-02f, -9.10831243e-02f, 1.84009671e-02f, 4.72476818e-02f, -5.33410199e-02f, 7.32759982e-02f, -1.42976008e-02f, -2.45109163e-02f, -2.02759970e-02f,
  -2.95801234e-04f, -4.74510975e-02f, 4.54339273e-02f, 2.97491532e-02f, -7.34138265e-02f, -2.33554076e-02f, 1.14470087e-02f, 3.07253897e-02f, -4.72775586e-02f, 7.22783385e-03f,
  -3.02479193e-02f, -6.35335818e-02f, -8.05653483e-02f, 3.65426913e-02f, -3.63585539e-02f, 2.62965746e-02f, 3.95699218e-02f, -1.93293560e-02f, -1.72516033e-02f, -2.59111496e-03f,
  4.25015539e-02f, 3.92530300e-02f, -3.34212221e-02f, 4.36678471e-04f, 1.42401531e-02f, -6.12007007e-02f, -1.12880785e-02f, -1.52574889e-02f, -1.10519761e-02f, -3.04458458e-02f,
  9.00766850e-02f, 1.34936228e-01f, 8.50967094e-02f, 4.76612002e-02f, 1.25652039e-02f, 3.73272747e-02f, -5.64626139e-03f, -2.71654688e-02f, 1.01397321e-01f, 5.30206971e-02f,
  6.88402681e-03f, 3.54177691e-02f, 7.64653832e-03f, 1.05634006e-02f, 1.01986818e-01f, 2.72320304e-02f, 5.71198985e-02f, 1.49312206e-02f, -5.53864017e-02f, 6.20495975e-02f,
  1.69774927e-02f, -4.16793115e-03f, 3.68240997e-02f, 2.41112597e-02f, -7.29751289e-02f, -7.74093671e-03f, -4.88362573e-02f, 4.76560444e-02f, -1.86011009e-02f, -2.06091944e-02f,
  -2.09941521e-01f, -3.40510875e-01f, -2.75554061e-01f, 6.63128868e-03f, 8.41065571e-02f, -7.99168795e-02f, -1.15756594e-01f, -5.80267385e-02f, -2.23631442e-01f, -1.35083973e-01f,
  1.53358012e-01f, -2.38935545e-01f, -3.03302854e-02f, 6.12370446e-02f, 1.09851614e-01f, 9.82320011e-02f, 1.81502312e-01f, 6.51351586e-02f, 6.59336075e-02f, 4.74261977e-02f,
  1.32105827e-01f, 3.95634204e-01f, 1.06475547e-01f, 1.97986975e-01f, 5.81402816e-02f, 1.49050085e-02f, 1.88311622e-01f, -1.80766657e-02f, 1.04574069e-01f, 3.00412383e-02f,
  7.43014589e-02f, -2.36236621e-02f, -5.20466864e-02f, -1.07484207e-01f, -2.76872776e-02f, -2.64349747e-02f, 2.26048697e-02f, 2.93518938e-02f, 4.17923890e-02f, -3.13110352e-02f,
  -2.61159427e-02f, 1.54252518e-02f, 1.11614922e-02f, 5.89203537e-02f, -2.53701657e-02f, -5.93443066e-02f, 4.53461595e-02f, -3.28494273e-02f, -6.04006536e-02f, -8.43386203e-02f,
  -4.45768461e-02f, -7.37759918e-02f, 2.22804248e-02f, 3.80142219e-02f, -4.58995849e-02f, -4.88019250e-02f, -2.80486606e-02f, -1.99748911e-02f, -3.41261551e-02f, -4.71781902e-02f,
  -2.25005411e-02f, 1.43370067e-03f, 3.56737226e-02f, -3.10518667e-02f, 2.55155154e-02f, 1.76442806e-02f, 4.40999158e-02f, 5.08634150e-02f, -4.80619073e-02f, 3.76921706e-02f,
  -1.68825947e-02f, -3.48216780e-02f, 1.09718740e-02f, -1.99647993e-02f, 4.43573520e-02f, -4.29375842e-02f, -1.00851366e-02f, -1.14839580e-02f, -3.91881205e-02f, 9.88136046e-03f,
  3.83474194e-02f, -1.38692828e-02f, -2.59124842e-02f, 5.47745079e-03f, -5.64321876e-02f, 8.06588773e-03f, -6.11498207e-02f, -6.12165183e-02f, -8.94553587e-03f, 1.98642556e-02f,
  4.81435061e-02f, 6.50659055e-02f, 4.13192622e-02f, 2.84309629e-02f, 7.69483000e-02f, 3.55612338e-02f, 4.07893397e-02f, 2.03586742e-02f, -2.53293198e-02f, 5.15184412e-03f,
  -1.01543991e-02f, 7.19232857e-02f, -2.14166734e-02f, -2.47460082e-02f, 8.12052377e-03f, -3.61892916e-02f, -3.10360920e-02f, 1.69921282e-03f, 2.11177617e-02f, 3.24188210e-02f,
  7.27745658e-03f, 3.51834707e-02f, -3.39876153e-02f, 4.93204519e-02f, 6.99674487e-02f, 1.89644694e-02f, -7.15756323e-03f, -1.00662038e-01f, 2.79354807e-02f, -3.88379730e-02f,
  3.82655531e-01f, -1.48384050e-01f, 1.20901324e-01f, 3.07707727e-01f, 7.02398419e-02f, -4.35340069e-02f, 7.81687722e-02f, -3.39569598e-02f, 1.89064220e-01f, -2.52527803e-01f,
  -4.18952741e-02f, 9.27822441e-02f, -2.93898016e-01f, 8.73420462e-02f, 2.19413817e-01f, -2.43010879e-01f, 8.95177796e-02f, -8.12210049e-03f, -5.37690558e-02f, 1.00305006e-01f,
  1.69127002e-01f, 2.02374198e-02f, 8.66512135e-02f, -3.55522297e-02f, 9.80060771e-02f, 2.38387242e-01f, 9.58567485e-02f, -7.58100748e-02f, 5.32504655e-02f, -3.73296291e-02f,
  4.95225238e-03f, -3.17984559e-02f, 5.29888496e-02f, -8.95451233e-02f, -1.62756983e-02f, -8.96554720e-03f, 6.03860915e-02f, -2.11906666e-03f, 6.39368221e-02f, -1.77538302e-02f,
  1.69955827e-02f, -2.21634284e-02f, 4.46431674e-02f, 6.37881830e-03f, 5.46860807e-02f, 8.02969038e-02f, -1.18071940e-02f, 1.95762459e-02f, -2.80388296e-02f, 2.84723775e-03f,
  8.06747600e-02f, -3.18423025e-02f, 7.79936910e-02f, -5.91435358e-02f, 4.72034663e-02f, 7.81290531e-02f, 2.34304257e-02f, 5.28915189e-02f, -1.15292780e-02f, 4.09572646e-02f,
  2.22267527e-02f, 5.71252741e-02f, -3.79752219e-02f, -4.07576188e-02f, 3.46746184e-02f, 6.48710737e-03f, -4.81531434e-02f, 5.57654072e-03f, 2.64589805e-02f, -3.69803421e-02f,
  -1.94642041e-02f, 7.22439736e-02f, -1.75149590e-02f, 1.52744399e-02f, 2.97054760e-02f, 5.76129882e-03f, 8.45792145e-03f, -8.10363889e-02f, 2.64991373e-02f, 7.10285828e-02f,
  -4.27634781e-03f, -9.00770538e-03f, -6.89444765e-02f, -3.63208316e-02f, -5.13690384e-03f, -5.49453348e-02f, -1.70437805e-02f, -5.81744276e-02f, 6.68161809e-02f, -1.61283463e-02f,
  -1.18218392e-01f, 4.30101305e-02f, -5.51203154e-02f, 4.24939096e-02f, -1.15139429e-02f, 1.88667420e-02f, 3.49541125e-03f, 1.95679162e-02f, 4.87211160e-02f, -6.49690628e-03f,
  6.74778223e-02f, 1.36857647e-02f, 1.90225635e-02f, 3.34794563e-03f, -4.46665920e-02f, -9.47696902e-03f, -2.88929678e-02f, 3.73056866e-02f, 1.29749060e-01f, 3.71623226e-02f,
  -6.96344301e-03f, 3.55739854e-02f, 7.22833052e-02f, 9.13388357e-02f, -4.72825430e-02f, -8.00258294e-03f, 1.47732291e-02f, 1.33891813e-02f, -4.96153254e-03f, -3.31143700e-02f,
  -1.46591932e-01f, -2.17939585e-01f, -6.83783814e-02f, -9.83801335e-02f, 5.66281239e-03f, 2.25119311e-02f, 4.28911708e-02f, -1.33276507e-01f, -2.52727214e-02f, -4.05599363e-02f,
  7.11973235e-02f, -1.55033782e-01f, 2.59715080e-01f, -1.28246278e-01f, 1.69827208e-01f, 2.97909468e-01f, -5.27320951e-02f, 3.99972498e-02f, 9.77314711e-02f, -1.53594241e-01f,
  -4.72648256e-02f, -1.15746401e-01f, 6.38959557e-02f, -1.18735507e-01f, -2.57479012e-01f, -1.41656578e-01f, -9.15740058e-02f, 1.05738312e-01f, -1.64428189e-01f, 7.39254132e-02f,
  8.58350843e-03f, -7.40379617e-02f, -3.14791948e-02f, -1.90080479e-02f, -4.09851689e-03f, -6.91539748e-03f, 1.91713509e-03f, 3.80748585e-02f, 4.30540070e-02f, 3.65151353e-02f,
  -4.79727723e-02f, 3.57138105e-02f, -3.24011408e-02f, 8.56456980e-02f, -9.76549760e-02f, -7.16655627e-02f, 5.09417877e-02f, 1.52647076e-02f, -9.03244168e-02f, -8.83059949e-03f,
  -6.63197488e-02f, 2.25693919e-02f, -1.03460550e-01f, 4.15990800e-02f, 9.10604969e-02f, 7.03742430e-02f, -5.28247058e-02f, -1.21244602e-03f, -2.54504960e-02f, -9.39282030e-02f,
  -4.14901339e-02f, 3.98827605e-02f, 7.86562487e-02f, -1.37518323e-03f, 8.13382585e-03f, -6.23790659e-02f, -3.22013460e-02f, 6.23770989e-02f, 1.24436170e-02f, 2.32309122e-02f,
  1.63813739e-03f, -4.99272421e-02f, 5.75618967e-02f, -5.41388541e-02f, 2.75841691e-02f, -6.76340833e-02f, 4.55217883e-02f, 1.31425960e-02f, -6.76858053e-02f, 4.44933847e-02f,
  2.32732091e-02f, -3.51390280e-02f, 7.50211999e-02f, 1.14989337e-02f, -3.40879858e-02f, 6.96910024e-02f, -5.05639054e-03f, -3.83930095e-02f, -4.67081927e-02f, 3.39580625e-02f,
  2.26031076e-02f, -3.54295969e-02f, 2.77003720e-02f, -4.14198294e-04f, 2.29805987e-03f, 1.55006237e-02f, -2.79761087e-02f, -5.00848144e-02f, 1.72142517e-02f, -5.34637496e-02f,
  -1.29371146e-02f, 6.59651235e-02f, 1.64697673e-02f, 6.21395595e-02f, 5.92623390e-02f, -1.35466270e-03f, -6.89559057e-02f, 2.30799913e-02f, 5.00993915e-02f, 4.09472315e-03f,
  -5.09463400e-02f, -8.10785070e-02f, 4.71988730e-02f, 4.35934290e-02f, -6.14081956e-02f, -6.16119020e-02f, 6.96444185e-03f, 2.55358517e-02f, -2.79778223e-02f, 5.32619059e-02f,
  -1.22826390e-01f, 7.13753477e-02f, 3.13008428e-01f, -1.78904340e-01f, -3.66885886e-02f, -7.45485350e-02f, -1.99915037e-01f, -3.58183049e-02f, 6.16913289e-03f, -2.52132453e-02f,
  -1.48604557e-01f, 8.32928792e-02f, 7.41190091e-02f, -1.22434460e-01f, -3.37850660e-01f, -4.80974056e-02f, -2.59353906e-01f, -1.41480044e-01f, 1.16678901e-01f, -1.56600311e-01f,
  2.51792595e-02f, -2.40721658e-01f, 8.60152617e-02f, 7.34876990e-02f, -1.68678537e-02f, 7.30643719e-02f, -1.42815351e-01f, 1.50328904e-01f, -2.88858190e-02f, -3.13165374e-02f,
  -4.37464602e-02f, -3.28337438e-02f, 2.04510316e-02f, 4.70471159e-02f, -9.12460871e-03f, 5.34941675e-03f, 2.75311321e-02f, 3.72275710e-02f, -1.09948758e-02f, 9.07234754e-03f,
  -6.17437400e-02f, 3.42938378e-02f, 6.90211505e-02f, 4.42204177e-02f, 3.66445305e-03f, 5.52167073e-02f, 1.00612648e-01f, 9.86252204e-02f, 1.47622721e-02f, 2.97928061e-02f,
  5.73466010e-02f, 6.74953312e-02f, 2.72713453e-02f, -2.95729435e-04f, 8.12607817e-03f, 2.51683183e-02f, 1.14515759e-02f, 4.98258658e-02f, 8.18138011e-03f, 3.08538340e-02f,
  5.16307866e-03f, -9.29683745e-02f, -4.81611677e-02f, -5.47404252e-02f, -6.53823614e-02f, 4.40323427e-02f, -2.72679478e-02f, -4.74458039e-02f, 2.46244911e-02f, -8.31790343e-02f,
  -4.80588265e-02f, -7.70395175e-02f, 1.38997403e-03f, -6.16241284e-02f, -4.51019034e-02f, -2.75256019e-02f, -3.61277871e-02f, -5.14102727e-02f, 6.53354451e-03f, 8.64485279e-03f,
  -3.86285186e-02f, -3.67270298e-02f, -1.86847448e-02f, -4.14082520e-02f, -1.89305954e-02f, 1.30761024e-02f, -1.18384734e-02f, 6.82214424e-02f, 4.65789102e-02f, -7.66191483e-02f,
  -3.20211828e-01f, -2.71877617e-01f, 2.48893676e-03f, -8.26640576e-02f, -4.80968989e-02f, -4.21677157e-02f, -1.08859027e-02f, 3.98169905e-02f, -7.42367096e-03f, -4.37080786e-02f,
  7.41520002e-02f, -2.56889332e-02f, -6.07590079e-02f, -2.22934820e-02f, -1.03212185e-02f, -5.33959717e-02f, -1.25848800e-01f, -2.43558735e-02f, -1.11436002e-01f, -4.34026122e-02f,
  -3.56685766e-03f, -5.52230142e-02f, 4.64905538e-02f, -4.48091626e-02f, -3.91951464e-02f, -2.09358539e-02f, -3.69191654e-02f, 1.82787217e-02f, -1.39731197e-02f, 2.99225580e-02f,
  -4.14946645e-01f, 2.33420767e-02f, 3.30646746e-02f, -2.12080717e-01f, -1.63552299e-01f, -1.60087273e-01f, 3.36485058e-02f, -1.67869717e-01f, -8.58417451e-02f, 5.20542525e-02f,
  -6.41563088e-02f, 2.31616478e-02f, 3.10293198e-01f, -6.67108223e-02f, -1.50647461e-01f, 1.70060143e-01f, -1.10445119e-01f, -1.32467151e-02f, 8.82216264e-03f, -1.81927621e-01f,
  -1.58239841e-01f, -1.89598724e-01f, -4.31618951e-02f, -1.33397803e-02f, -2.53537804e-01f, -5.13343215e-02f, -1.02224521e-01f, 1.38409734e-01f, -1.07069105e-01f, 1.84422191e-02f,
  -1.48884863e-01f, -1.47432759e-01f, -3.72737050e-02f, 7.82817230e-02f, -9.43038985e-02f, -3.05794762e-03f, 8.16301182e-02f, 1.44062430e-01f, -2.31229817e-03f, 1.51706804e-02f,
  2.95723006e-02f, -4.72949585e-03f, -2.24773679e-02f, 8.63746777e-02f, -6.87239617e-02f, 5.98434135e-02f, 1.56326089e-02f, -5.06400084e-03f, -7.15478789e-04f, -7.88014755e-02f,
  -2.86419131e-03f, 1.16632308e-03f, 1.79385580e-02f, 8.79127719e-03f, 4.75198515e-02f, -2.88169608e-02f, 1.21638589e-02f, 6.70868978e-02f, -4.23555858e-02f, 1.30035467e-02f,
  5.34534715e-02f, 4.36875932e-02f, 3.41339819e-02f, -1.01933079e-02f, 1.87807847e-02f, -3.57074924e-02f, 1.86211453e-03f, 6.69082552e-02f, -3.02196015e-03f, -3.39826308e-02f,
  -6.39494136e-02f, -5.10870181e-02f, -1.60858370e-02f, 4.42071222e-02f, -5.31260297e-02f, -5.09778149e-02f, 6.35994896e-02f, -4.30395752e-02f, -1.83791723e-02f, -1.28165828e-02f,
  7.48431683e-02f, -2.95215193e-02f, 2.73268912e-02f, -3.72099131e-03f, 2.59462890e-04f, 2.20181793e-03f, 4.26396308e-03f, 5.55422083e-02f, 3.47146653e-02f, -5.42806387e-02f,
  -2.15656698e-01f, -3.37490663e-02f, 7.02418238e-02f, -1.72916278e-02f, 7.24232495e-02f, -3.65374461e-02f, -6.64286222e-03f, -2.68712640e-02f, 7.16084987e-03f, -2.54277065e-02f,
  -5.70282666e-03f, 7.35748792e-04f, 3.45950923e-03f, 2.67872047e-02f, 1.45792086e-02f, -7.90707767e-02f, -3.90674993e-02f, 5.19080423e-02f, -5.95538020e-02f, -5.54486029e-02f,
  -6.23176806e-02f, 2.69338712e-02f, -1.01314085e-02f, -6.48507699e-02f, -3.49336676e-02f, 3.62245343e-03f, -6.50511459e-02f, 4.94465455e-02f, 2.06964128e-02f, -1.33479405e-02f,
  1.01096906e-01f, 1.71859294e-01f, 3.70478071e-02f, -2.80117095e-02f, -3.93658839e-02f, 2.55142510e-01f, 1.00798629e-01f, 1.49837911e-01f, 5.34411669e-02f, 1.36622600e-02f,
  -9.53614935e-02f, -1.03671357e-01f, 7.88916871e-02f, 3.34964544e-02f, 2.56424755e-01f, 2.18700826e-01f, 9.39167514e-02f, 6.64669946e-02f, 5.22682555e-02f, 1.50222018e-01f,
  1.47460505e-01f, 6.18762039e-02f, 9.53949988e-02f, 4.77893736e-05f, 6.11162707e-02f, 1.64141506e-02f, -1.64407551e-01f, -5.89625053e-02f, -8.18675309e-02f, 2.23523825e-02f,
  -7.02162236e-02f, 1.16551295e-01f, -2.50557214e-02f, 3.11522465e-02f, 9.08303410e-02f, -8.70720893e-02f, -2.72128847e-03f, 3.63003858e-03f, -1.10126749e-01f, -1.06119607e-02f,
  -2.19905376e-02f, -6.87878877e-02f, -5.90869822e-02f, 1.53224228e-03f, 1.31515134e-02f, -3.17751132e-02f, 3.73449847e-02f, -8.88430551e-02f, 2.12336872e-02f, 9.61866975e-02f,
  -3.95986252e-03f, 2.38591712e-02f, -4.02577296e-02f, 3.35918032e-02f, 6.44221753e-02f, 9.80085414e-03f, -2.48107761e-02f, -4.29578312e-03f, 8.07615817e-02f, 8.89421850e-02f,
  2.84069106e-02f, 1.07843149e-02f, 5.58931269e-02f, -4.13627438e-02f, 7.41111860e-02f, 2.29328480e-02f, 2.57334560e-02f, 1.91390868e-02f, -2.57472992e-02f, 6.27525151e-02f,
  3.54833007e-02f, 2.00274307e-02f, 7.33141927e-03f, 2.73415111e-02f, -3.84366401e-02f, -1.93237513e-03f, -7.72064105e-02f, -5.41306771e-02f, -2.24834252e-02f, -1.43726114e-02f,
  -5.09160608e-02f, 1.61864366e-02f, -1.62504744e-02f, -1.10351890e-02f, 6.52572662e-02f, -5.20721786e-02f, -8.04179460e-02f, 9.13885087e-02f, 1.20893456e-02f, 1.12394765e-02f,
  7.09063783e-02f, 2.94999689e-01f, -1.19206849e-02f, -4.72598746e-02f, -5.14793433e-02f, 6.48627356e-02f, 4.10452969e-02f, 1.09082297e-03f, 1.06531858e-01f, 1.41172066e-01f,
  -4.60481234e-02f, 5.19036595e-03f, 2.28093583e-02f, -3.83258276e-02f, -4.82255146e-02f, 3.36281732e-02f, -4.14613597e-02f, -6.86647545e-04f, -2.56099831e-03f, -2.48944331e-02f,
  -1.90332346e-02f, -6.31966144e-02f, 2.33967490e-02f, -3.70885842e-02f, 3.67126204e-02f, -3.06189083e-03f, 1.04876488e-01f, -2.88855117e-02f, 2.22539455e-02f, -4.53707725e-02f,
  3.70777547e-02f, -1.50968030e-01f, 1.92549080e-01f, -3.22013535e-02f, -1.46157578e-01f, 6.08213060e-02f, 1.03687160e-01f, -1.59366190e-01f, -1.07898943e-01f, -7.69274905e-02f,
  7.25741610e-02f, 1.10082261e-01f, 1.13633946e-01f, 1.34611920e-01f, 1.58323631e-01f, 2.09740326e-01f, -1.28194783e-03f, 5.92079647e-02f, -6.20370097e-02f, -1.33273527e-01f,
  -7.33878138e-03f, -1.66608468e-01f, 2.27161482e-01f, -3.01748574e-01f, 2.60113999e-02f, -9.49122906e-02f, -1.18948132e-01f, 4.26551253e-02f, 3.33377868e-02f, -5.47528379e-02f,
  -1.03466332e-01f, -3.91860940e-02f, 6.35387301e-02f, -6.90672919e-02f, 4.06369306e-02f, 6.59525469e-02f, 3.04190796e-02f, 3.19248177e-02f, -2.13112086e-02f, 1.60328038e-02f,
  8.08904991e-02f, -1.97765511e-02f, -1.52376918e-02f, -6.10949881e-02f, -4.04095836e-02f, 4.93703187e-02f, 6.15001172e-02f, 9.64839235e-02f, 2.16330700e-02f, 7.60310069e-02f,
  3.89497988e-02f, 7.71825835e-02f, 4.80257981e-02f, -1.17261866e-02f, 9.01486799e-02f, -1.41685875e-02f, 1.07638270e-01f, 1.02889501e-01f, -5.17961718e-02f, -4.09896811e-03f,
  -2.58820672e-02f, -2.29199734e-02f, 6.03269786e-03f, 5.74166328e-02f, -6.20479323e-02f, 5.22867553e-02f, -7.11894874e-03f, -3.92774530e-02f, 3.81752849e-02f, 2.50326768e-02f,
  -3.23050246e-02f, 6.79708496e-02f, -6.79514334e-02f, 4.22579944e-02f, 3.23401019e-02f, -5.18123657e-02f, 2.40715984e-02f, -6.50973618e-02f, 1.02976030e-02f, 8.93500373e-02f,
  -7.26216007e-03f, -1.91636116e-03f, 5.31375669e-02f, 3.09577789e-02f, 6.59976900e-03f, -1.31190037e-02f, -1.71526037e-02f, -1.84242744e-02f, 6.82387082e-03f, 1.05711846e-02f,
  -1.90696806e-01f, -2.88592964e-01f, -5.29240221e-02f, -6.88864663e-02f, -8.56980905e-02f, -8.14962015e-03f, -3.19228694e-02f, 2.66876705e-02f, -6.98252767e-02f, -2.27505155e-02f,
  -7.79581964e-02f, -6.79562334e-03f, -9.71486121e-02f, 6.80646151e-02f, -2.48170029e-02f, -7.08755925e-02f, -9.57300328e-03f, -4.10352908e-02f, -1.02896720e-01f, -5.24797440e-02f,
  8.95523932e-03f, -5.98042421e-02f, 2.51497142e-02f, -8.07259418e-03f, 1.04851564e-02f, 3.27003896e-02f, -1.31972760e-01f, 2.23189946e-02f, 1.55345043e-02f, 3.49953994e-02f,
  -1.97680164e-02f, 1.03313066e-01f, 1.99484199e-01f, 5.76088801e-02f, 3.57116088e-02f, -1.20205777e-02f, -3.23681891e-01f, 5.97433373e-02f, -4.03610095e-02f, -5.02359197e-02f,
  -2.46668041e-01f, 1.31247371e-01f, -2.46053010e-01f, -8.47690105e-02f, -2.60387480e-01f, -2.27524653e-01f, -1.57602672e-02f, -1.11651905e-02f, 7.04837143e-02f, -7.16307908e-02f,
  7.33688623e-02f, -2.38019571e-01f, 5.10117563e-04f, 1.66155323e-01f, -4.42991629e-02f, 2.69288719e-01f, -7.71855041e-02f, 9.75755453e-02f, 1.76831603e-01f, -2.88928673e-02f,
  -3.20232660e-02f, -1.63529828e-01f, 2.40456080e-03f, 1.27929136e-01f, -6.90459087e-02f, 2.28633340e-02f, 8.15644786e-02f, -3.77872698e-02f, 2.60619018e-02f, 3.71571109e-02f,
  7.99376331e-03f, 5.64473011e-02f, 4.66156416e-02f, -3.01362369e-02f, 3.54022123e-02f, 7.07470998e-02f, 8.74635652e-02f, 4.02309261e-02f, 6.24619760e-02f, 6.24875426e-02f,
  -6.49004281e-02f, 7.54817054e-02f, 1.37218125e-02f, 1.13070346e-01f, -5.54769393e-03f, 9.44616366e-03f, 5.88834435e-02f, 2.94554867e-02f, 6.22509457e-02f, 1.44547075e-02f,
  -5.77871781e-03f, 4.80389036e-02f, 1.01852426e-02f, -8.09271913e-03f, -2.93254144e-02f, -4.57544858e-03f, 3.79575789e-02f, 3.45784873e-02f, 2.22553797e-02f, -4.98940572e-02f,
  -1.71876270e-02f, 4.99955425e-03f, 3.40774618e-02f, -5.16163604e-03f, 3.96570489e-02f, -4.89361994e-02f, 7.90886208e-03f, -8.34121369e-03f, 8.07766542e-02f, 3.36746540e-04f,
  4.34817560e-03f, -4.46231589e-02f, 1.68493260e-02f, -2.88920552e-02f, -4.82738540e-02f, -4.10206951e-02f, 8.81087407e-02f, -1.05501786e-02f, 7.58744180e-02f, -3.02368831e-02f,
  -4.81968448e-02f, -1.82862759e-01f, 2.83258408e-02f, 3.93077731e-02f, -2.17023063e-02f, -1.91123877e-02f, -6.85260743e-02f, 4.17059511e-02f, -3.58678550e-02f, -5.77082969e-02f,
  5.72409704e-02f, -1.10987173e-02f, 4.29247878e-02f, 9.36012948e-05f, 5.87176019e-03f, -2.51470730e-02f, -1.97567679e-02f, 5.70227839e-02f, 6.54692156e-03f, -3.87133919e-02f,
  3.73415090e-02f, -1.88442189e-02f, 1.17386505e-02f, -3.27945948e-02f, 4.88639474e-02f, -1.36506530e-02f, -4.63089906e-02f, 1.02605587e-02f, 1.58741716e-02f, 4.32824306e-02f,
  -1.58793867e-01f, 2.58380085e-01f, -1.53729260e-01f, 9.51270312e-02f, 5.14284335e-02f, 1.10394731e-01f, 1.01149082e-01f, 1.55681446e-01f, 1.94685385e-01f, 2.71475285e-01f,
  8.19632858e-02f, 6.13493798e-03f, 8.16123653e-03f, 9.68226790e-02f, -1.34981528e-01f, -6.39380068e-02f, 5.94317615e-02f, 1.11564733e-01f, -6.92265201e-03f, 1.01285249e-01f,
  -5.68682998e-02f, 1.06247835e-01f, -2.06773385e-01f, 1.42227590e-01f, 1.46454554e-02f, -1.01208135e-01f, -1.17879800e-01f, -3.60519737e-02f, 1.00049004e-01f, -9.63209718e-02f,
  -2.74760500e-02f, 8.98238719e-02f, -8.09103623e-02f, -3.06198504e-02f, -3.70716788e-02f, -8.36645663e-02f, -8.39637518e-02f, -1.26572251e-01f, -9.86263528e-02f, -3.04068881e-03f,
  2.06041336e-03f, -3.26779708e-02f, -2.97291111e-02f, 1.63313374e-02f, 5.31747416e-02f, 8.24184939e-02f, -5.42375669e-02f, -1.49928639e-02f, 6.67098016e-02f, -4.97305505e-02f,
  -2.80607026e-02f, 3.74721587e-02f, 6.14327081e-02f, 1.61342546e-02f, 5.12002632e-02f, 4.69515547e-02f, -1.88743155e-02f, -2.13650577e-02f, 1.12087458e-01f, 5.15740775e-02f,
  -2.89185848e-02f, -3.18977833e-02f, -4.22529802e-02f, -2.76376568e-02f, 7.54521182e-03f, -1.59115251e-02f, -3.94376703e-02f, -8.76010209e-02f, -3.32061686e-02f, 5.87612502e-02f,
  -4.01997454e-02f, 5.26112616e-02f, 1.20361419e-02f, -4.07027416e-02f, -6.64123744e-02f, -2.91807596e-02f, -1.08559750e-01f, 3.59728150e-02f, 5.88658862e-02f, 1.70064457e-02f,
  -2.80190185e-02f, -1.74273904e-02f, 3.38715427e-02f, -7.73801804e-02f, -7.26939738e-02f, -2.41561979e-02f, 2.98158936e-02f, 6.71204776e-02f, 2.36114971e-02f, -1.34586301e-02f,
  8.96831229e-02f, 2.61381149e-01f, 6.16901554e-02f, -3.47951747e-04f, -1.35170827e-02f, 6.51922897e-02f, -3.10461782e-02f, 4.26148921e-02f, 7.07530007e-02f, 2.78433394e-02f,
  -4.71886694e-02f, 2.21270137e-02f, 3.62959467e-02f, 6.20934255e-02f, -4.32438105e-02f, 1.05520986e-01f, 7.50529114e-04f, 3.37397270e-02f, 4.90533486e-02f, 2.09222026e-02f,
  5.67083023e-02f, 6.24043681e-02f, -8.00628215e-03f, -3.91124785e-02f, 4.05599326e-02f, 2.46191621e-02f, -6.33940473e-03f, 3.97177115e-02f, -4.56492342e-02f, 9.24050510e-02f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.26048897e-02f, 2.69413322e-01f, 3.35913420e-01f, 4.59704958e-02f, 1.13032989e-01f, 2.17274323e-01f, 9.57323387e-02f, 1.52566254e-01f, 2.20312014e-01f, 3.83402221e-02f,
  -2.26998404e-01f, 1.05646625e-01f, -1.90970138e-01f, 6.04758412e-02f, -1.94612779e-02f, 6.21032827e-02f, 2.14452781e-02f, -1.96205415e-02f, 1.31597623e-01f, -7.19005466e-02f,
  -5.24781272e-02f, -1.71637282e-01f, -2.00469382e-02f, -1.50734231e-01f, -2.28915382e-02f, 1.61950346e-02f, -2.75008649e-01f, -4.91523109e-02f, -8.18493441e-02f, 3.77309285e-02f,
  -6.60264725e-03f, 2.62814406e-02f, 3.45171839e-02f, -1.16799558e-02f, 4.03198563e-02f, 2.91160308e-04f, -5.66849411e-02f, -8.64168257e-02f, 3.19004171e-02f, 4.04915959e-02f,
  -4.47506122e-02f, 6.93555027e-02f, 6.28948510e-02f, -2.98394468e-02f, 1.04480766e-01f, 1.66902989e-02f, 3.21036503e-02f, 3.87231894e-02f, 2.02733800e-02f, 6.80335686e-02f,
  1.18894368e-01f, 1.16134420e-01f, 9.23823863e-02f, 1.52595816e-02f, -6.05108868e-03f, 2.59517320e-02f, -3.28343688e-03f, 9.35048833e-02f, 1.21203639e-01f, 1.17105097e-01f,
  -7.34637901e-02f, 8.87827352e-02f, 6.33409694e-02f, 8.04610029e-02f, -5.78856692e-02f, 5.85988723e-03f, 1.00858612e-02f, 3.37701142e-02f, 5.78375859e-03f, -7.92526267e-03f,
  -2.89682969e-02f, 5.34763522e-02f, 5.29648773e-02f, 5.28659225e-02f, -2.02907119e-02f, -6.47042319e-02f, -9.19594094e-02f, -3.51881757e-02f, 1.38368187e-02f, -7.42112473e-02f,
  -1.12520218e-01f, -4.46781032e-02f, -4.63123769e-02f, -4.40301485e-02f, 6.83268681e-02f, -4.99735810e-02f, 2.23431475e-02f, 8.36474001e-02f, -5.65404221e-02f, -1.20973215e-01f,
  5.48727885e-02f, -3.53301577e-02f, -5.48661388e-02f, -8.20583403e-02f, -4.56850743e-03f, 3.74144912e-02f, 6.72191754e-02f, 9.75605398e-02f, 4.40860204e-02f, -6.78291023e-02f,
  -8.00414607e-02f, -5.45084253e-02f, 3.55247110e-02f, -1.40228961e-03f, 6.68498427e-02f, -1.26245590e-02f, 5.47582507e-02f, -7.60260224e-02f, 8.42579231e-02f, 2.48895166e-03f,
  -8.14562961e-02f, -4.63625155e-02f, -3.98892500e-02f, -4.59718779e-02f, -4.67689745e-02f, 1.30580356e-02f, 3.19888555e-02f, -1.74459890e-02f, -3.14994082e-02f, 7.90364146e-02f,
  -1.64349437e-01f, 1.30694985e-01f, 3.13765317e-01f, -1.67372465e-01f, 2.81850602e-02f, 1.45225212e-01f, 1.11875929e-01f, -1.31846964e-01f, -1.71844169e-01f, -1.22111730e-01f,
  -1.76182255e-01f, 3.37246731e-02f, 6.20063469e-02f, -3.62382606e-02f, 1.30159870e-01f, -4.74292040e-02f, -1.36337504e-01f, 3.80322076e-02f, 8.07998553e-02f, -9.31926146e-02f,
  -1.16481490e-01f, -1.58684790e-01f, 3.91368242e-03f, -2.74591129e-02f, -3.47931981e-02f, -2.20101792e-02f, -1.90196350e-01f, 7.83581436e-02f, 2.85314675e-02f, 3.28836986e-03f,
  7.85335451e-02f, -4.36497219e-02f, 1.39460564e-01f, 1.42844632e-01f, -5.22911772e-02f, -5.33212088e-02f, -3.51867154e-02f, 1.07543960e-01f, 7.02744648e-02f, -7.85995391e-04f,
  6.80695921e-02f, -4.06415854e-03f, -8.79460424e-02f, -5.70093766e-02f, -7.65708536e-02f, -2.57689599e-02f, -4.46822122e-02f, 1.07526951e-01f, 9.24945325e-02f, 4.50581275e-02f,
  1.00619659e-01f, 8.32720399e-02f, -1.42261898e-02f, -9.11089107e-02f, -3.65275554e-02f, 5.72533952e-03f, -2.15440840e-02f, 1.10480562e-01f, -4.74485047e-02f, -3.09430193e-02f,
  -6.79538026e-02f, -4.72711287e-02f, 6.97065443e-02f, -7.60904774e-02f, 2.11913213e-02f, -1.20396875e-01f, 5.19088991e-02f, -8.30695182e-02f, 7.43510202e-02f, -1.80973820e-02f,
  -6.78154780e-03f, -5.74043505e-02f, 2.53408607e-02f, 2.94138417e-02f, -4.69966829e-02f, -6.50033578e-02f, 5.39756455e-02f, 7.47727603e-02f, 3.95069569e-02f, -3.55134346e-02f,
  -5.30152507e-02f, -5.26505634e-02f, -7.05403015e-02f, 6.42719911e-03f, 6.88420236e-03f, 5.89991957e-02f, 5.30817248e-02f, 9.61466599e-03f, -6.22282065e-02f, 8.57621580e-02f,
  8.49357992e-02f, -3.22461762e-02f, 1.75267346e-02f, -8.70506540e-02f, 1.44424722e-01f, -7.57990852e-02f, 5.22652008e-02f, -8.25478360e-02f, 3.74647565e-02f, 1.88509095e-02f,
  -8.44595656e-02f, -3.07698268e-02f, -4.24827682e-03f, -8.22611898e-02f, -6.29742965e-02f, 4.55251411e-02f, 8.91820807e-03f, -3.84785444e-03f, 2.50193123e-02f, -8.72268621e-03f,
  1.74546037e-02f, -8.85767713e-02f, -3.10818851e-02f, -5.11092097e-02f, -3.84594314e-02f, -1.22644780e-02f, -2.55557727e-02f, -4.42697667e-02f, 1.08599067e-01f, -3.33604869e-03f,
  -1.07074820e-01f, 2.34116212e-01f, 8.74244957e-04f, -1.08213320e-01f, -1.65645103e-03f, -2.36822039e-01f, -2.53914874e-02f, 1.18485212e-01f, 1.07939586e-01f, 1.47335827e-01f,
  6.63614720e-02f, 8.28228742e-02f, 1.42789200e-01f, -5.52219152e-02f, -2.28638619e-01f, -1.00765176e-01f, -2.76599824e-01f, -3.36556472e-02f, 5.93629666e-02f, -6.68092445e-02f,
  -1.63761288e-01f, -4.91770431e-02f, -1.40900716e-01f, 6.09678403e-02f, 4.61600572e-02f, 1.48705961e-02f, -1.04686515e-02f, 1.20929733e-01f, -9.75166634e-02f, 6.09796159e-02f,
  -7.86225870e-02f, 5.89477248e-04f, 3.12661566e-02f, 5.25778718e-02f, -9.22473297e-02f, -7.17995912e-02f, -1.01446033e-01f, 3.56735587e-02f, 5.67436852e-02f, 4.42117155e-02f,
  7.78255314e-02f, 1.74799562e-02f, 2.21776161e-02f, 6.02009036e-02f, 4.83287908e-02f, -4.74889129e-02f, -1.34974606e-02f, -3.68817039e-02f, 8.86112675e-02f, 2.21527908e-02f,
  -5.82595803e-02f, -4.12874520e-02f, -1.40350237e-02f, -1.43669229e-02f, -1.70378871e-02f, 3.32425535e-02f, -2.75151674e-02f, -3.49620432e-02f, 1.31828208e-02f, 2.47994550e-02f,
  -6.38832524e-02f, 2.51223203e-02f, 5.47818169e-02f, 1.18506262e-02f, 8.25131983e-02f, -2.90601961e-02f, -2.48826593e-02f, -3.60444188e-02f, -1.34548331e-02f, 5.06006554e-02f,
  6.89006001e-02f, 7.09024891e-02f, 3.10741533e-02f, -2.72623096e-02f, 9.87454224e-03f, -2.66771428e-02f, 4.66985032e-02f, -5.53550422e-02f, -1.06668778e-01f, 2.07185815e-03f,
  1.52440881e-02f, -9.89490449e-02f, -1.28525607e-02f, -1.00096472e-01f, -5.99920303e-02f, 2.82498300e-02f, 1.45735275e-02f, 4.98474091e-02f, 5.19637614e-02f, -4.77787033e-02f,
  -1.28422767e-01f, -6.14860691e-02f, 8.64830520e-03f, 5.69275692e-02f, 3.66422581e-04f, -4.10579480e-02f, -7.91041739e-03f, 8.06070343e-02f, -4.03150506e-02f, 8.38383138e-02f,
  -1.04643732e-01f, 2.22603846e-02f, -5.72219118e-02f, -3.04666813e-02f, 5.79018109e-02f, -1.10388942e-01f, -8.89312848e-02f, -2.37101596e-02f, -2.65453588e-02f, -4.14365269e-02f,
  -1.45610888e-02f, -5.50573841e-02f, -8.44093598e-03f, 5.80271371e-02f, 5.43176979e-02f, -4.25276719e-02f, 3.42636816e-02f, -6.60967082e-02f, 4.37018834e-02f, 3.76472250e-02f,
  1.84378371e-01f, -2.71721054e-02f, -1.46747231e-01f, -6.27539605e-02f, -9.28950757e-02f, 1.52261779e-01f, -6.92665111e-03f, 5.84936850e-02f, -2.14628819e-02f, 9.05194283e-02f,
  -2.28056926e-02f, 8.08180273e-02f, -8.28678627e-03f, 7.93274269e-02f, 5.10828048e-02f, 3.94664519e-02f, 9.73346308e-02f, -7.10254861e-03f, -3.99401598e-02f, 1.10202864e-01f,
  -1.79442838e-02f, 8.85657519e-02f, -6.04773797e-02f, 7.12174550e-02f, -6.26232326e-02f, 3.38807404e-02f, -1.55497529e-02f, -1.30809490e-02f, 9.21367779e-02f, -5.04343584e-02f,
  2.69370545e-02f, 6.91551566e-02f, -7.47383386e-02f, 3.44144851e-02f, -8.48493427e-02f, 8.29223841e-02f, 9.55727417e-03f, 8.30698460e-02f, -7.94425085e-02f, -6.95059299e-02f,
  -5.25611779e-03f, 1.90137438e-02f, 6.52720928e-02f, 5.52574582e-02f, -4.14986536e-02f, -4.60337773e-02f, -5.25209606e-02f, -6.02779239e-02f, -4.40996476e-02f, -6.05996810e-02f,
  -7.82008618e-02f, -6.04077838e-02f, -3.32365464e-03f, -7.85052329e-02f, 3.43289599e-02f, -7.83272311e-02f, -3.44532356e-02f, 4.40094322e-02f, 8.47661719e-02f, 6.08434901e-03f,
  -7.36319041e-03f, 4.62177768e-02f, -2.96559203e-02f, -4.45321612e-02f, 5.90174943e-02f, -2.85532270e-02f, -9.28937644e-02f, 7.41435960e-02f, 3.46597470e-02f, -3.13556977e-02f,
  -3.81792188e-02f, 2.17123586e-03f, 3.24191488e-02f, 6.47842232e-03f, -7.63668939e-02f, 4.97181602e-02f, 3.24609131e-02f, -4.75369245e-02f, -1.63491350e-02f, -1.54621266e-02f,
  -8.00286084e-02f, -2.44805478e-02f, -4.22881953e-02f, 2.47955136e-02f, -1.15423566e-02f, 5.47898412e-02f, -2.45045349e-02f, 7.01919869e-02f, -5.24074631e-03f, -3.99360945e-03f,
  -2.07571965e-02f, 1.05834492e-01f, -8.67466852e-02f, 6.23905705e-03f, 2.73921955e-02f, -4.52765748e-02f, -3.36174890e-02f, -5.31343669e-02f, -7.30696395e-02f, 6.79676086e-02f,
  2.03636400e-02f, -1.11378282e-01f, 6.75912425e-02f, 2.93568405e-03f, 6.07588366e-02f, -2.30632313e-02f, -4.06143963e-02f, 1.47611694e-02f, 2.99402084e-02f, 3.88958901e-02f,
  -5.89329330e-03f, 5.76227978e-02f, -1.65449809e-02f, -7.48984807e-04f, 1.11858174e-02f, 5.97758926e-02f, 2.40641460e-02f, -5.13849109e-02f, -4.04080898e-02f, 7.15804920e-02f,
  -9.99827459e-02f, 1.98071270e-04f, -1.86261386e-02f, 1.02964193e-01f, 4.19190079e-02f, -2.12523863e-01f, -1.20175883e-01f, 1.59708392e-02f, -3.60976048e-02f, 3.81159894e-02f,
  -2.26246454e-02f, -2.00758260e-02f, -5.93139008e-02f, -4.36859168e-02f, -1.55895501e-01f, -3.35099809e-02f, -7.45421723e-02f, -1.34946689e-01f, -7.02043548e-02f, 7.71503448e-02f,
  6.63210675e-02f, 9.76751968e-02f, -4.36180308e-02f, -2.85001267e-02f, 7.83779249e-02f, 1.68906450e-01f, 1.49348110e-01f, 3.91547382e-03f, 4.01504934e-02f, 2.43013613e-02f,
  -6.53610975e-02f, 9.98496488e-02f, -8.28893948e-03f, -8.46267939e-02f, 5.04170693e-02f, -9.33098421e-02f, -9.06440318e-02f, -2.98974309e-02f, -4.57923561e-02f, -2.58954205e-02f,
  -7.07216022e-05f, 2.61902455e-02f, 1.41681386e-02f, 3.12966295e-02f, -1.08032711e-02f, -4.83285375e-02f, -2.00307891e-02f, 1.38830440e-02f, 7.59760141e-02f, 5.86859994e-02f,
  8.03900287e-02f, -3.41118537e-02f, 1.04060218e-01f, 8.55148062e-02f, 4.10368219e-02f, -1.26606273e-02f, -8.23636875e-02f, -4.24577706e-02f, 2.37142500e-02f, -4.43006381e-02f,
  -4.68743369e-02f, 1.33308684e-02f, -6.44076467e-02f, -4.43702601e-02f, 6.74393475e-02f, -6.90161213e-02f, 1.83062758e-02f, -7.01265708e-02f, -3.94529589e-02f, 1.65515430e-02f,
  -3.15180048e-02f, 1.47616873e-02f, -7.93424249e-02f, 7.39713833e-02f, 8.25739801e-02f, -6.01449572e-02f, 1.38332108e-02f, 7.72870099e-03f, -1.35376574e-02f, -9.75972190e-02f,
  -1.57549756e-03f, -4.97841351e-02f, 8.08424726e-02f, 2.06482727e-02f, -5.37718646e-03f, 3.87066826e-02f, 5.28666237e-03f, 3.60618494e-02f, -1.65358111e-02f, -3.34498212e-02f,
  5.70389330e-02f, 1.78484038e-01f, 3.67660522e-02f, 1.38807315e-02f, -9.73603502e-03f, 5.27147688e-02f, 3.15414481e-02f, -2.29092501e-02f, 1.98637266e-02f, 8.54393318e-02f,
  2.94244532e-02f, -4.59374115e-02f, -7.92250857e-02f, -5.31560443e-02f, -1.30704725e-02f, -2.62422282e-02f, 5.06963953e-02f, 7.50378296e-02f, -2.91469749e-02f, -4.21989374e-02f,
  -4.39569168e-02f, -4.15265076e-02f, 7.70367458e-02f, -2.50944849e-02f, 5.48101552e-02f, -1.78948808e-02f, -6.93257898e-03f, 7.01715872e-02f, -6.93913549e-02f, 3.37824114e-02f,
  1.45130262e-01f, -1.24518843e-02f, 5.44022731e-02f, -1.96043745e-01f, -1.03051320e-01f, -6.50262237e-02f, -1.09152488e-01f, -4.11058031e-02f, -7.56268715e-03f, 3.05543747e-02f,
  -2.58833300e-02f, -7.36070201e-02f, 9.69419777e-02f, -1.64767995e-01f, 1.60250768e-01f, 1.71058983e-01f, -1.68464586e-01f, 3.12490016e-02f, -8.32332522e-02f, -1.84124038e-01f,
  -9.27884653e-02f, -1.18269213e-01f, -8.38977545e-02f, -5.92820756e-02f, -9.12268832e-02f, 1.55036096e-02f, 5.02205975e-02f, 3.73663078e-03f, -5.50772436e-02f, 2.40337159e-02f,
  3.66437919e-02f, 1.43011389e-02f, -5.55563457e-02f, -6.22119056e-03f, 5.30098937e-02f, -2.81386599e-02f, 7.14306459e-02f, -3.32276262e-02f, -1.52830714e-02f, -4.15388010e-02f,
  2.52399705e-02f, 2.63915192e-02f, -1.83508508e-02f, 7.24457130e-02f, -1.21160537e-01f, -1.31437732e-02f, -1.39976609e-02f, -3.19011062e-02f, -9.53035355e-02f, 2.43421271e-02f,
  -1.69489980e-02f, 2.16346644e-02f, 1.98763758e-02f, 8.99011642e-02f, 3.48580368e-02f, -7.37984776e-02f, -2.07081288e-02f, 4.07362022e-02f, -3.66848893e-02f, 2.47969944e-03f,
  8.76950771e-02f, 1.55805787e-02f, 9.16343406e-02f, 3.79577503e-02f, 2.40810327e-02f, -4.09855396e-02f, -8.77410546e-02f, -3.21457116e-03f, -2.81433295e-02f, -6.72827065e-02f,
  1.08411266e-02f, -2.85864193e-02f, 5.63581511e-02f, 7.84430355e-02f, 3.59255038e-02f, 7.91722685e-02f, -9.04404074e-02f, 7.37948492e-02f, -1.66175365e-02f, -4.01093252e-03f,
  -5.10983169e-02f, -6.63520098e-02f, 2.39990856e-02f, -4.17908579e-02f, -1.44504653e-02f, 2.78177522e-02f, 1.94378309e-02f, -2.52714735e-02f, 9.83952638e-03f, 2.98562758e-02f,
  -2.99510863e-02f, -1.06050387e-01f, 4.86446060e-02f, 4.47247960e-02f, -9.26004257e-03f, -3.77629814e-03f, 3.85460481e-02f, 4.64271009e-02f, 2.12587956e-02f, -3.72292474e-02f,
  -7.31381681e-03f, 4.99105304e-02f, 1.99360284e-03f, -1.88274160e-02f, -1.02395535e-01f, 1.90023258e-02f, -1.01669371e-01f, -6.33883402e-02f, -5.81861883e-02f, -3.35639305e-02f,
  4.74766036e-03f, 4.82015200e-02f, 3.80229317e-02f, -7.04145655e-02f, 1.19779445e-02f, 2.32841466e-02f, -4.03995328e-02f, -3.95259960e-03f, 5.33245280e-02f, -9.07349139e-02f,
  1.23026622e-02f, -8.05026386e-03f, 1.21041358e-01f, 6.66209534e-02f, -3.02860104e-02f, 7.67536461e-03f, -6.85804188e-02f, 4.93495725e-02f, 1.54806254e-02f, -6.41413406e-02f,
  -1.09730862e-01f, -2.21181624e-02f, -1.72451660e-02f, -9.89012048e-02f, 1.49362817e-01f, 1.05759069e-01f, -7.10122064e-02f, -9.85376015e-02f, 1.38448626e-01f, 8.21519643e-02f,
  9.81606841e-02f, -1.07463963e-01f, 1.26418799e-01f, -4.55733314e-02f, 6.30180165e-02f, 2.72205239e-03f, 9.43960696e-02f, 7.35902265e-02f, -6.31583706e-02f, -1.16748765e-01f,
  5.02441004e-02f, 4.76529747e-02f, -4.76298071e-02f, 3.60107236e-02f, -5.24423532e-02f, -4.48921025e-02f, -8.00528303e-02f, -3.16477455e-02f, 1.01919562e-01f, 5.04655875e-02f,
  4.79002558e-02f, 3.53070758e-02f, -5.48563674e-02f, 5.69938216e-03f, 6.36360273e-02f, 9.73944962e-02f, -2.60057896e-02f, 1.67035032e-02f, -5.70580587e-02f, -6.15467206e-02f,
  3.75363789e-02f, -3.40297185e-02f, 4.07631956e-02f, 5.08551337e-02f, -3.93060967e-02f, -8.25268626e-02f, -9.56877694e-02f, -5.40608764e-02f, 2.51627862e-02f, -7.12633580e-02f,
  3.57744582e-02f, 7.84160346e-02f, 8.68623704e-02f, 9.42560658e-02f, -1.25787966e-02f, 4.83039655e-02f, 2.40147468e-02f, 3.38707678e-02f, -4.84755673e-02f, 5.59386574e-02f,
  -1.65855717e-02f, 9.41153392e-02f, -3.78207639e-02f, -2.86007524e-02f, -8.79587047e-03f, 6.18295819e-02f, 3.06685641e-02f, -6.98046982e-02f, -8.22233185e-02f, -4.01128381e-02f,
  -3.37147228e-02f, -5.93828820e-02f, -5.88711947e-02f, -4.64414321e-02f, -5.85312322e-02f, 7.22545758e-02f, 9.35510844e-02f, 2.18924154e-02f, 6.05258234e-02f, -6.85947090e-02f,
  -6.55701011e-02f, -1.01282960e-02f, -5.02285585e-02f, -1.10311836e-01f, 8.72597694e-02f, -1.99124310e-02f, -7.04762414e-02f, -8.48997012e-02f, 1.34262368e-02f, -3.19877341e-02f,
  2.18656119e-02f, 4.40079644e-02f, 5.80572300e-02f, -5.41097261e-02f, -4.82239202e-02f, 1.46626718e-02f, -4.50402275e-02f, -6.96500717e-03f, -7.93459341e-02f, 3.48620266e-02f,
  -6.31608889e-02f, 5.30203804e-02f, -6.69915602e-02f, -8.48064870e-02f, -9.00538787e-02f, 6.44939095e-02f, 7.79407099e-02f, 3.36198732e-02f, -6.51678443e-03f, 3.98122333e-02f,
  -5.83574474e-02f, 1.16797023e-01f, -3.70898247e-02f, -8.14715698e-02f, 6.87514544e-02f, 1.20785266e-01f, -5.57249896e-02f, 7.39700124e-02f, 9.11282003e-02f, 7.18503967e-02f,
  -2.70601194e-02f, 1.50399923e-01f, -9.83537808e-02f, 7.84988627e-02f, 4.19337787e-02f, 5.21998443e-02f, 2.27681957e-02f, 6.82009682e-02f, -6.09022938e-02f, -2.99928244e-03f,
  -1.41595053e-02f, 9.46064517e-02f, -1.28724992e-01f, 2.25124834e-03f, 7.00010136e-02f, -5.56709543e-02f, -1.39412850e-01f, 1.05698043e-02f, -3.32957655e-02f, 4.11734581e-02f,
  -4.46566567e-03f, -5.95246069e-02f, -5.63615039e-02f, 4.37998184e-04f, 3.98334265e-02f, 4.01669443e-02f, -7.04836249e-02f, -5.92379756e-02f, 4.52561257e-03f, -2.58138087e-02f,
  -5.95666952e-02f, 2.29427870e-02f, 6.27272055e-02f, 9.85373557e-02f, 1.33250980e-02f, -5.03716543e-02f, 6.96476400e-02f, 7.47718289e-02f, 8.07555206e-03f, 8.48905519e-02f,
  2.99053919e-02f, -3.29283662e-02f, 3.75336199e-03f, -1.70108397e-02f, 1.07748024e-02f, 7.90842846e-02f, 1.10904805e-01f, -7.15955198e-02f, 1.15098571e-02f, -4.78066914e-02f,
  6.20666295e-02f, 6.50557801e-02f, -7.04134554e-02f, -8.16793218e-02f, 8.78366381e-02f, 6.70155138e-02f, -2.08177082e-02f, 5.53497523e-02f, -1.73218790e-02f, -4.48762849e-02f,
  -4.65549901e-02f, -4.18429561e-02f, 7.35359266e-02f, -7.84386247e-02f, 6.71899766e-02f, -2.09253305e-03f, 4.21120077e-02f, -2.43138261e-02f, 5.99229634e-02f, -5.02898768e-02f,
  2.24913750e-02f, 8.16598386e-02f, -4.93618175e-02f, 2.38803532e-02f, -2.38981452e-02f, -2.87702065e-02f, -4.94819172e-02f, -7.52139241e-02f, 5.68672903e-02f, -2.26997957e-02f,
  1.28926694e-01f, 1.00699328e-01f, -1.80402584e-02f, 2.92554405e-02f, -1.03072282e-02f, 2.89283469e-02f, 7.12887496e-02f, -3.48906126e-03f, 1.90806482e-02f, -4.49656509e-02f,
  -2.18220223e-02f, 3.09460349e-02f, 9.68310609e-02f, 1.20361503e-02f, -3.00913025e-02f, 6.56563938e-02f, 7.52241313e-02f, -2.34459359e-02f, 4.42047343e-02f, 2.90607326e-02f,
  -2.51179915e-02f, 4.25740927e-02f, -4.06470038e-02f, 1.18416473e-02f, -6.53745681e-02f, 6.95478916e-02f, 5.69856353e-02f, 3.94269042e-02f, -4.24141586e-02f, -4.81572784e-02f,
  -1.89948436e-02f, 1.26534402e-01f, 1.91058218e-01f, 1.36729106e-01f, -1.96664911e-02f, 1.04918480e-02f, 9.53759998e-02f, -4.54081520e-02f, -1.39181867e-01f, -2.20530927e-02f,
  1.17153488e-01f, 1.41268015e-01f, 6.18954822e-02f, -2.10602637e-02f, 5.45477495e-02f, 1.04998335e-01f, 5.65874279e-02f, 9.98031870e-02f, 2.73837149e-02f, 1.05587300e-02f,
  8.83109346e-02f, 8.42132270e-02f, 1.27384335e-01f, -7.92842433e-02f, 7.63105452e-02f, 1.86587386e-02f, 1.02160640e-01f, 4.24552560e-02f, -1.52118364e-02f, -6.47533163e-02f,
  -8.66673663e-02f, 6.27988502e-02f, 9.75356251e-02f, -9.76982936e-02f, -6.59633279e-02f, 1.57885700e-02f, 9.53031927e-02f, -7.08185043e-03f, -1.79574341e-02f, 5.66471443e-02f,
  -5.59062958e-02f, -6.34005740e-02f, 3.86593640e-02f, -7.39616230e-02f, -1.07657962e-01f, -7.01696128e-02f, 8.03672150e-02f, -1.20986756e-02f, 9.68524590e-02f, 7.46169612e-02f,
  1.10249907e-01f, 5.16601354e-02f, 7.09274113e-02f, 7.49406293e-02f, 2.10830141e-02f, -8.20794851e-02f, 8.26274324e-03f, -3.27778980e-02f, -8.56765583e-02f, -8.24465156e-02f,
  -2.93991398e-02f, 1.94196701e-02f, 7.02697784e-02f, 4.37899120e-02f, -2.40328778e-02f, -6.79031461e-02f, -6.35266444e-03f, -1.32168003e-03f, 8.54754522e-02f, -2.22226474e-02f,
  -4.91403677e-02f, -4.70273793e-02f, -4.09396924e-02f, 4.18037102e-02f, -7.17754066e-02f, 2.65967455e-02f, 3.55632491e-02f, 1.32759791e-02f, 4.07133177e-02f, -4.87375110e-02f,
  -5.93493767e-02f, -3.59107368e-02f, 4.12337296e-02f, 3.32093909e-02f, 3.52142639e-02f, 6.42067119e-02f, -1.82992127e-02f, -2.12315228e-02f, -2.19734348e-02f, -7.73416534e-02f,
  -8.07442330e-03f, 5.78636676e-02f, 9.79701802e-03f, -1.18642894e-03f, 9.58247036e-02f, 7.21997693e-02f, 1.63558442e-02f, 3.15282829e-02f, 6.83445781e-02f, -3.61468294e-03f,
  -1.59917828e-02f, 2.16224845e-02f, -5.58609143e-02f, 8.87852833e-02f, -9.30538028e-02f, 2.90895086e-02f, 6.30719736e-02f, -2.54635904e-02f, 9.53048393e-02f, 5.63076213e-02f,
  2.79933345e-02f, -7.06122955e-03f, 1.78926848e-02f, -9.60067660e-02f, -5.34597822e-02f, 2.47037746e-02f, 2.73834784e-02f, -3.80080640e-02f, -9.58176255e-02f, -5.32682501e-02f,
  -5.01142116e-03f, -1.01593643e-01f, -3.24804746e-02f, -4.25662287e-02f, 4.55896407e-02f, 1.41169757e-01f, -8.74092206e-02f, 6.68170005e-02f, -9.08781216e-02f, -5.49380146e-02f,
  3.53698968e-03f, -1.59837648e-01f, -8.14014822e-02f, 3.94855887e-02f, -3.17337811e-02f, 1.31570902e-02f, 5.90177439e-02f, 6.06189631e-02f, -1.42373405e-02f, 9.95514616e-02f,
  6.44686520e-02f, -9.85758752e-02f, -3.57023478e-02f, 4.27633263e-02f, -5.67817874e-03f, 4.20137569e-02f, -4.24872860e-02f, -4.07945141e-02f, 5.14399000e-02f, 7.39844367e-02f,
  3.13636251e-02f, 2.22156458e-02f, -2.25818548e-02f, 1.09656062e-02f, 1.31077766e-01f, 9.39912051e-02f, -1.59691423e-02f, -1.11150146e-01f, -5.64512163e-02f, -1.06980372e-02f,
  4.60447073e-02f, -6.02602661e-02f, -3.26529257e-02f, 7.79752270e-04f, -6.89962283e-02f, -2.50982512e-02f, 4.95796427e-02f, -8.79509822e-02f, 9.24122557e-02f, 7.10599124e-02f,
  4.27595116e-02f, -9.11610574e-03f, -3.57779562e-02f, -3.92250195e-02f, 1.80016365e-02f, -5.89392707e-02f, -1.98289361e-02f, -6.85879514e-02f, 4.65572774e-02f, -7.11378902e-02f,
  -2.03859597e-03f, 7.86925480e-02f, 3.36144678e-02f, -4.16792184e-02f, 3.15446518e-02f, 3.23020667e-02f, 2.18043383e-03f, 8.48577991e-02f, 5.22790737e-02f, 5.46506271e-02f,
  8.29988439e-03f, -5.78161255e-02f, 5.79603622e-03f, 1.07013434e-01f, -2.93289009e-03f, -6.73382878e-02f, 5.26915528e-02f, 7.39820227e-02f, 2.82210950e-02f, -5.79950493e-03f,
  6.08531088e-02f, 5.44685647e-02f, 7.28439018e-02f, -6.93887919e-02f, -1.47875790e-02f, 3.79761681e-02f, -1.00172749e-02f, -1.44650824e-02f, -6.56936201e-04f, 5.56114763e-02f,
  -2.32979469e-02f, 8.07841942e-02f, -2.21308470e-02f, -5.40509447e-02f, 9.34019014e-02f, 7.33290911e-02f, 3.17016803e-02f, 4.52932157e-02f, 2.55271420e-02f, 4.50459160e-02f,
  8.14753026e-02f, 4.25283164e-02f, 2.17650458e-02f, 2.98300944e-02f, -3.74873169e-02f, 3.83019708e-02f, 7.46022984e-02f, 8.46882910e-02f, -4.50560637e-02f, 2.61216536e-02f,
  -7.79115036e-02f, 3.74577828e-02f, -8.74809455e-03f, -1.08244037e-03f, 6.35412857e-02f, 6.14039898e-02f, -6.17822260e-02f, 4.37427163e-02f, -9.55392718e-02f, 6.76565170e-02f,
  2.83126980e-01f, -3.11899722e-01f, -2.78949261e-01f, 1.21666849e-01f, 1.17900327e-01f, 1.54330298e-01f, 1.60470098e-01f, 2.13343631e-02f, -7.02305958e-02f, -8.45893994e-02f,
  2.00469792e-01f, -2.03067169e-01f, -1.04404196e-01f, 2.85190463e-01f, 2.21181408e-01f, -2.95404345e-02f, 2.42295682e-01f, 1.21631861e-01f, -8.71819034e-02f, -3.71874347e-02f,
  7.69839436e-02f, 1.86966836e-01f, -8.09405968e-02f, 4.85337153e-03f, 1.56678408e-01f, -3.43865566e-02f, 2.24956106e-02f, -1.89417779e-01f, 1.39911070e-01f, 8.87993276e-02f,
  1.29015639e-01f, -4.31909300e-02f, -3.98217048e-03f, -4.28571133e-03f, -4.42197733e-02f, -3.46855745e-02f, -1.69346370e-02f, -1.41770886e-02f, 4.26167399e-02f, 7.50314668e-02f,
  -2.58758999e-02f, 7.56950155e-02f, 3.60211544e-02f, -7.97313731e-03f, -4.04398859e-04f, -8.98626596e-02f, -4.89350501e-03f, -6.10989779e-02f, -1.25030130e-02f, 1.50728528e-03f,
  -1.00324206e-01f, 4.28630859e-02f, -3.14843580e-02f, -3.43640223e-02f, -1.81281492e-02f, -6.24383017e-02f, -1.60020236e-02f, -3.86644788e-02f, -3.84558663e-02f, -2.21819989e-02f,
  3.49793732e-02f, -7.69432932e-02f, 2.74845008e-02f, 4.79262136e-02f, -3.48362792e-03f, -2.16478133e-03f, 6.92676678e-02f, -9.12142079e-03f, -5.14685214e-02f, -8.67842510e-03f,
  -5.83919510e-02f, 1.15437135e-02f, -2.05429383e-02f, 7.38881156e-02f, 2.47245878e-02f, -5.16136885e-02f, -6.08093776e-02f, -4.59565967e-02f, 5.43154590e-03f, -7.98543543e-02f,
  2.66412012e-02f, 3.44818388e-03f, 2.07553469e-02f, 3.34089585e-02f, -3.48746292e-02f, -6.68976381e-02f, 5.69881760e-02f, 5.13209961e-02f, 3.87418345e-02f, 4.93789511e-03f,
  -4.34040464e-02f, -1.57759398e-01f, -3.13486010e-02f, 2.78953779e-02f, -8.09700415e-02f, 2.50925892e-03f, -7.20068663e-02f, -7.38888383e-02f, -9.79449833e-04f, 1.44080259e-02f,
  1.54936127e-02f, -5.06824488e-03f, 6.52149990e-02f, 4.33835797e-02f, 6.06239848e-02f, 1.00952089e-02f, -5.15256114e-02f, -2.29484532e-02f, -1.62192490e-02f, -2.29653772e-02f,
  -7.97717497e-02f, -6.49397224e-02f, -5.14806695e-02f, 3.92175429e-02f, 2.51137856e-02f, 6.61921576e-02f, -4.75364253e-02f, -6.96673840e-02f, 2.95872148e-02f, -1.01763256e-01f,
  8.08544308e-02f, 9.82162878e-02f, 4.62734029e-02f, 1.00387029e-01f, -4.71924767e-02f, -1.39322579e-01f, -1.34057269e-01f, 2.53964216e-02f, -9.59443524e-02f, -2.61090957e-02f,
  7.69334286e-02f, 1.06123000e-01f, -6.07907586e-02f, 3.99230011e-02f, -1.25566185e-01f, -5.17187938e-02f, -7.73523524e-02f, 1.06787903e-03f, -1.09263659e-01f, 2.15572283e-01f,
  5.92364259e-02f, -9.56073776e-03f, 4.22948506e-03f, 1.42533690e-01f, 6.14055209e-02f, 1.10980123e-01f, 2.12528720e-01f, 1.53775170e-01f, 1.88004553e-01f, 3.95986475e-02f,
  -4.86105718e-02f, 1.19524384e-02f, -7.49054598e-03f, -5.78491539e-02f, 1.09297536e-01f, 7.98920244e-02f, -4.66137640e-02f, -7.56630599e-02f, 6.41065165e-02f, -4.50995192e-02f,
  -1.36548644e-02f, 1.08368564e-02f, -5.65673858e-02f, -4.77981418e-02f, 7.71579072e-02f, 3.10361106e-03f, 6.74377233e-02f, 8.45163316e-02f, -3.22078615e-02f, -2.18323376e-02f,
  2.66306363e-02f, 1.03777960e-01f, -4.93579842e-02f, 9.15393606e-02f, 9.10117477e-02f, 5.72275966e-02f, -2.53718924e-02f, 2.26507280e-02f, 2.94478741e-02f, -1.54446643e-02f,
  1.08281309e-02f, -1.50129013e-02f, 3.93285863e-02f, -1.15490869e-01f, -1.09890588e-02f, -8.84071663e-02f, 3.63022499e-02f, 4.92481515e-02f, -6.88410029e-02f, -1.14953546e-02f,
  -7.87666664e-02f, -6.80270344e-02f, -1.07601471e-01f, -1.71476733e-02f, -1.57028660e-02f, -6.21369146e-02f, -5.95623627e-02f, -3.50604467e-02f, -7.92474151e-02f, -7.11581185e-02f,
  -3.22965346e-02f, -7.76179358e-02f, 4.27315012e-02f, -7.00280741e-02f, -1.23456202e-01f, 2.39540357e-02f, -6.24753861e-03f, -7.36939255e-03f, -4.73351702e-02f, 7.97748938e-02f,
  8.24513137e-02f, 2.03033313e-01f, -1.41052948e-02f, -6.19343221e-02f, -3.57553139e-02f, 2.87958831e-02f, -4.03813906e-02f, -7.89921358e-02f, 1.05061136e-01f, -6.25845268e-02f,
  -2.18976792e-02f, 6.60861433e-02f, -2.43034344e-02f, 2.05867793e-02f, 1.10025052e-03f, -2.09360830e-02f, -1.73550262e-03f, -1.64275859e-02f, -3.58325876e-02f, 9.90113169e-02f,
  1.34939682e-02f, -1.39356209e-02f, 1.15884515e-02f, -2.50625610e-03f, 5.36211096e-02f, 8.10073093e-02f, 8.25275928e-02f, 6.01784252e-02f, 1.00312963e-01f, -7.74960965e-03f,
  8.71941596e-02f, -3.12045440e-02f, -1.39960609e-02f, -8.10292661e-02f, -3.87548357e-02f, -2.84361225e-02f, -9.95051190e-02f, 6.57425821e-02f, -2.21732855e-02f, -1.12350225e-01f,
  1.06804343e-02f, 4.00234666e-03f, -3.15174554e-03f, -1.46285728e-01f, -2.06217598e-02f, 5.00149839e-02f, -1.06476888e-01f, 2.11031195e-02f, -2.63527688e-02f, 3.59985530e-02f,
  -9.33111161e-02f, -1.15578294e-01f, 4.25187014e-02f, 4.58818525e-02f, 9.32747219e-03f, -8.80327821e-02f, 6.66430146e-02f, 3.64197008e-02f, -8.06990415e-02f, -7.26175159e-02f,
  4.04399224e-02f, -4.96400744e-02f, 2.47510113e-02f, 5.35074547e-02f, -6.94365203e-02f, 1.10437043e-01f, 7.40663111e-02f, -1.89891756e-02f, -7.03946650e-02f, 3.49097066e-02f,
  5.52110747e-02f, -6.90720156e-02f, 8.73953104e-02f, 1.66019239e-02f, -4.23004059e-03f, 2.07597073e-02f, 9.75536257e-02f, -3.60667333e-02f, 5.85355563e-03f, -5.45824319e-02f,
  -1.14610074e-02f, 8.07974860e-02f, -7.50175714e-02f, -7.32577965e-02f, 6.95609748e-02f, -9.32831913e-02f, 3.68312225e-02f, 1.25218993e-02f, -7.83832045e-04f, -4.89377044e-02f,
  4.67595793e-02f, -6.62209466e-03f, 2.08894275e-02f, -8.29261243e-02f, 8.61496478e-02f, -7.43593182e-03f, 2.87132002e-02f, -2.44655386e-02f, -4.22217660e-02f, -1.64861474e-02f,
  -8.94764289e-02f, 6.44069985e-02f, -8.62646252e-02f, -5.89176789e-02f, -5.27322106e-02f, -8.40371996e-02f, 2.90632695e-02f, -7.77108222e-02f, 7.15368316e-02f, 8.94506741e-03f,
  1.66651560e-03f, -2.52668466e-02f, -1.48644065e-02f, -2.00567748e-02f, -8.93053263e-02f, 7.69617781e-02f, -5.32101914e-02f, -1.01612965e-02f, 7.88399503e-02f, 8.91088918e-02f,
  -4.94319275e-02f, -9.58826691e-02f, 7.37531483e-02f, 1.01496587e-02f, 4.53449525e-02f, 6.23280108e-02f, 6.11766838e-02f, -4.95958924e-02f, -8.79951715e-02f, 7.64501467e-02f,
  7.80064911e-02f, 2.34763082e-02f, -4.40767370e-02f, 6.22106995e-03f, -8.35771561e-02f, 4.34506126e-02f, -6.04923852e-02f, 5.16172461e-02f, -5.86144114e-03f, 7.19640255e-02f,
  4.97438796e-02f, 6.69974238e-02f, -3.78661454e-02f, -3.08420565e-02f, 6.52373955e-02f, 2.84479503e-02f, -3.17830592e-02f, 8.66159971e-04f, 5.78006282e-02f, 1.07007567e-02f,
  -8.70716348e-02f, -3.76093499e-02f, 1.36440424e-02f, 7.77723491e-02f, -1.07825443e-01f, 2.97998972e-02f, -2.32386366e-02f, -3.14443931e-02f, -5.87339476e-02f, -1.12529710e-01f,
  -1.68395806e-02f, 5.04319035e-02f, -8.06568004e-03f, 8.93822759e-02f, 1.33714288e-01f, 1.06400112e-02f, 2.96938270e-02f, 7.94082880e-02f, 1.08627744e-01f, 3.65690254e-02f,
  5.48828021e-02f, 6.67305849e-03f, 1.66927993e-01f, 7.13912863e-03f, -3.35689671e-02f, 1.64689235e-02f, 1.45638555e-01f, 9.60120037e-02f, 7.94418380e-02f, 1.14074670e-01f,
  -3.60672250e-02f, 6.55964240e-02f, -2.21915320e-02f, -7.08830580e-02f, 2.02907808e-03f, 5.47241382e-02f, -1.57791357e-02f, 4.87157628e-02f, -5.58290910e-03f, -4.96254265e-02f,
  -4.69650663e-02f, 9.67810154e-02f, 3.61647177e-03f, 9.37505513e-02f, -9.28594470e-02f, 1.98514238e-02f, -6.22420013e-02f, -8.64038989e-02f, 7.55009055e-02f, -1.05275303e-01f,
  1.58707751e-03f, -9.91092548e-02f, 4.62697074e-02f, -3.12618092e-02f, 5.15885055e-02f, 5.36685400e-02f, 6.13014884e-02f, -7.31185870e-03f, 1.37647735e-02f, 2.21844520e-02f,
  -1.01451032e-01f, 9.85631794e-02f, 9.56607461e-02f, -5.32020023e-03f, -3.90660875e-02f, 8.36215988e-02f, -4.13969308e-02f, -8.00584555e-02f, 7.64006525e-02f, 6.13159798e-02f,
  -9.20764823e-03f, 3.40892337e-02f, 3.50005478e-02f, 5.34812771e-02f, 2.50043757e-02f, 4.70082462e-02f, 6.09632069e-03f, 8.89277607e-02f, 1.80444419e-02f, 2.72565726e-02f,
  -2.84663751e-03f, -2.30594948e-02f, -6.32006600e-02f, -1.48313837e-02f, 7.37754181e-02f, -3.36839743e-02f, 8.07305723e-02f, -7.59593099e-02f, -2.14038733e-02f, -5.57673015e-02f,
  -3.43967900e-02f, 1.35087907e-01f, 5.08415811e-02f, -7.58522823e-02f, 1.13343028e-02f, -1.05531327e-01f, 6.39167801e-02f, -3.33522111e-02f, 9.89699550e-03f, -4.49560918e-02f,
  -1.08350543e-02f, -1.69515482e-03f, -9.34766680e-02f, 9.34670791e-02f, 3.32949683e-02f, -3.75748873e-02f, 1.36317182e-02f, -5.94198741e-02f, -4.51996848e-02f, -8.12535435e-02f,
  -7.11100250e-02f, 3.14139538e-02f, -3.53932343e-02f, 2.20614057e-02f, 8.64690244e-02f, 7.51366839e-02f, -7.51755908e-02f, -5.86522184e-02f, 4.69444990e-02f, 1.86472554e-02f,
  2.27415904e-01f, -1.21943608e-01f, -1.15127593e-01f, 1.10923149e-01f, 1.71489790e-01f, -2.14072485e-02f, -1.09138899e-01f, 2.02974919e-02f, -1.03073657e-01f, 1.80992275e-03f,
  7.35955089e-02f, -1.21722398e-02f, -3.23605120e-01f, 2.57529765e-01f, 2.83743173e-01f, -2.25988746e-01f, 1.78494364e-01f, 4.13052849e-02f, -1.81710925e-02f, 7.50477910e-02f,
  1.01669110e-01f, 3.49260122e-01f, -3.09566106e-03f, 2.65935004e-01f, 1.22693032e-01f, 1.21924132e-01f, 1.99632823e-01f, -1.64947093e-01f, 3.16034883e-01f, 9.65685621e-02f,
  1.80338463e-03f, 1.48207741e-02f, -6.45109862e-02f, -3.77002098e-02f, -1.65788345e-02f, 4.55673598e-02f, 1.82424311e-03f, -3.83794568e-02f, 5.51455095e-02f, -1.77594572e-02f,
  -5.09594046e-02f, 9.45497751e-02f, -8.90630204e-03f, -7.89495632e-02f, 5.49108163e-02f, 5.83580928e-03f, 6.64917082e-02f, -1.05933093e-01f, -8.06516260e-02f, -3.47915068e-02f,
  -4.21129726e-02f, -2.23007496e-03f, 3.79592180e-02f, 1.17982673e-02f, -3.58130671e-02f, 9.41915959e-02f, -3.07113938e-02f, -7.71776140e-02f, 3.01115289e-02f, 1.03481479e-01f,
  4.65209410e-02f, -6.54417872e-02f, 3.54754589e-02f, -1.13137495e-02f, 3.30832377e-02f, -2.59818975e-03f, 4.79921885e-02f, 3.69292796e-02f, -1.17244637e-02f, 8.58166628e-03f,
  4.08574119e-02f, 5.23399748e-02f, 5.02635017e-02f, 1.15071340e-02f, 4.29600589e-02f, -4.66950685e-02f, 4.85806018e-02f, 5.69856130e-02f, -7.23824054e-02f, -7.21803978e-02f,
  -8.13996568e-02f, 6.16188869e-02f, 4.88302205e-04f, 4.30485904e-02f, 6.04880275e-03f, -3.49810012e-02f, 6.14039674e-02f, 1.97401941e-02f, -3.22516263e-02f, -4.13728543e-02f,
  8.25482234e-03f, 6.84633553e-02f, -1.12260301e-02f, -4.34192643e-02f, 7.01885894e-02f, 3.85912918e-02f, 7.27341336e-04f, 9.30195004e-02f, -5.49744926e-02f, 2.90959980e-02f,
  9.71948579e-02f, -7.47362301e-02f, 3.53301018e-02f, 1.73274614e-02f, 4.04120125e-02f, -1.65663976e-02f, 4.88951206e-02f, 5.09566516e-02f, 4.74460497e-02f, 3.19839418e-02f,
  3.78814451e-02f, -2.54843347e-02f, -2.94428468e-02f, -7.87090808e-02f, -9.09667090e-03f, -8.52617547e-02f, 1.53872920e-02f, -1.50151160e-02f, 1.01889119e-01f, -8.13433602e-02f,
  9.92179140e-02f, 1.72927961e-01f, 5.08452617e-02f, 8.53862092e-02f, -1.63906246e-01f, 1.70416199e-02f, 1.14109775e-03f, -3.57410088e-02f, -6.26311898e-02f, 8.29194188e-02f,
  5.60201854e-02f, 1.12279385e-01f, -6.78802207e-02f, 3.19386162e-02f, -4.08737455e-03f, -8.74633193e-02f, 1.51062593e-01f, 5.54588735e-02f, -1.82504635e-02f, 2.02720448e-01f,
  4.65489030e-02f, 2.47384589e-02f, 5.11217155e-02f, -2.29463484e-02f, 9.89179388e-02f, 8.59624799e-03f, 8.38335231e-02f, 6.11494780e-02f, 9.28743035e-02f, 3.34568182e-03f,
  -6.88387081e-02f, 9.32327956e-02f, 9.88394991e-02f, 5.66226207e-02f, -1.00648450e-02f, -5.69727793e-02f, -7.87857100e-02f, -1.27462307e-02f, -6.88474923e-02f, -5.31132109e-02f,
  6.78155124e-02f, 1.94476768e-02f, 8.86805803e-02f, 7.03456951e-03f, -4.14980389e-03f, 6.92356825e-02f, 4.44259010e-02f, -6.81670681e-02f, -2.24131010e-02f, 9.26450416e-02f,
  -6.23683855e-02f, 6.26702444e-04f, -6.35098144e-02f, 6.89431205e-02f, -4.13416252e-02f, -4.76016384e-03f, -4.93180789e-02f, 9.35339257e-02f, 3.94835062e-02f, 8.73111263e-02f,
  4.20913957e-02f, -6.35275915e-02f, 1.12827132e-02f, -9.70126912e-02f, 5.54555692e-02f, -5.07097133e-02f, 5.28939404e-02f, -9.68067423e-02f, 3.08957584e-02f, -3.58936824e-02f,
  2.72923596e-02f, 7.23426044e-02f, 8.99963547e-03f, -3.88349257e-02f, -6.00956334e-03f, 1.22576756e-02f, 7.18660327e-03f, 6.88934922e-02f, 8.01292807e-02f, 1.77768413e-02f,
  -4.21457458e-03f, 7.24367797e-02f, -8.25339109e-02f, -3.87363392e-03f, -8.46999884e-02f, -2.02738158e-02f, 8.33034962e-02f, 5.53478561e-02f, -4.58653383e-02f, 5.52613810e-02f,
  1.28796855e-02f, 2.77767181e-01f, 1.12469390e-01f, -2.88147088e-02f, 2.67450437e-02f, 8.87928084e-02f, 9.30595323e-02f, 7.21527860e-02f, 7.68807903e-02f, 2.05874238e-02f,
  -2.55500767e-02f, 7.22626550e-03f, 7.23666027e-02f, -6.85128495e-02f, -2.00134553e-02f, 1.46936029e-01f, 5.99302934e-04f, 7.49363452e-02f, -3.91386189e-02f, -5.77209629e-02f,
  -5.84727563e-02f, -4.66227047e-02f, 1.62344649e-02f, 1.76357944e-02f, -1.71559956e-02f, 5.22065349e-02f, 3.59891057e-02f, 2.32103420e-03f, 1.32251559e-02f, -1.33527182e-02f,
  1.86317749e-02f, -5.57313524e-02f, 2.20657259e-01f, 9.61086154e-02f, -4.12572436e-02f, -3.85193601e-02f, -6.04237430e-02f, 2.60274503e-02f, -8.28278139e-02f, 1.52662247e-02f,
  -3.38679776e-02f, 2.47736555e-02f, 2.07691565e-02f, 7.73871988e-02f, 9.97148268e-03f, 3.20873857e-02f, -7.73596838e-02f, 1.00135081e-03f, -1.55847184e-02f, 7.32199773e-02f,
  3.23290862e-02f, -4.85945679e-02f, 6.25358000e-02f, 1.50260553e-02f, 9.46904048e-02f, 8.84118676e-02f, -1.23846933e-01f, -3.27340998e-02f, 2.11119652e-02f, -6.94805831e-02f,
  3.89745533e-02f, -7.05707148e-02f, -3.63536067e-02f, -2.04759464e-02f, -2.59022638e-02f, -2.77086142e-02f, -1.88046563e-02f, 2.08631177e-02f, 7.19047487e-02f, -2.10151225e-02f,
  7.01801181e-02f, 8.92411266e-03f, -1.84766464e-02f, -3.09011936e-02f, -3.24175358e-02f, -2.62412298e-02f, 4.73154197e-03f, 8.89168680e-02f, -3.47288549e-02f, 8.62559676e-02f,
  1.30784377e-01f, -9.78771225e-03f, 3.90619375e-02f, -7.32069090e-02f, -4.82911579e-02f, 7.20119011e-03f, 4.44663077e-04f, 8.74539241e-02f, 5.63943796e-02f, 8.14976916e-02f,
  9.63599309e-02f, 5.00663146e-02f, -7.45141357e-02f, -1.12091914e-01f, 4.57697585e-02f, 3.63694057e-02f, -6.37315735e-02f, 8.58391598e-02f, 2.44456977e-02f, 4.79591042e-02f,
  1.55653038e-06f, 6.51461259e-02f, -3.29810977e-02f, -9.17400718e-02f, -7.46209100e-02f, -6.62299618e-02f, -2.94911154e-02f, -7.78611228e-02f, 1.84377879e-02f, 7.77336359e-02f,
  9.75779258e-03f, -4.53346083e-03f, 3.12667936e-02f, 3.39233503e-02f, -3.56319472e-02f, 1.57619454e-02f, 9.32387821e-03f, -1.28723979e-02f, -5.66311218e-02f, 2.89620254e-02f,
  -8.22847243e-03f, -8.77248496e-02f, 1.75694805e-02f, 5.97570054e-02f, -5.91239780e-02f, -5.44946529e-02f, 4.49424423e-02f, 2.14685760e-02f, -3.73655036e-02f, -5.20734116e-02f,
  -7.04791620e-02f, -3.33715789e-02f, -2.82461718e-02f, 4.96298708e-02f, 5.50706312e-02f, 4.65709530e-02f, -4.58399951e-02f, 3.35264727e-02f, 2.42126826e-02f, -2.29313336e-02f,
  -4.25003096e-02f, 6.64211363e-02f, -7.89117441e-02f, 6.88884482e-02f, 4.97660823e-02f, -8.57955962e-02f, -4.62761968e-02f, 5.60286455e-02f, 4.34460305e-02f, 7.16903359e-02f,
  1.02362474e-02f, -1.12625904e-01f, -5.75297959e-02f, -1.42478779e-01f, 1.24726593e-01f, 1.46480724e-01f, 4.53748405e-02f, -2.27675643e-02f, -1.26445174e-01f, 6.76206872e-02f,
  5.66210523e-02f, -1.59405380e-01f, 8.23468529e-03f, -1.76886588e-01f, -1.91125825e-01f, -2.22673908e-01f, 4.22396213e-02f, -7.54646286e-02f, -1.87123507e-01f, 8.91574696e-02f,
  -4.02375013e-02f, -2.58743577e-02f, -4.18682173e-02f, 5.36197908e-02f, 3.56549770e-03f, 1.26500100e-01f, 2.38035202e-01f, 7.26013482e-02f, 1.18990786e-01f, 4.47050445e-02f,
  -6.99510947e-02f, -9.20385495e-02f, -1.27300220e-02f, 1.25840120e-02f, 8.65383446e-02f, 1.37721613e-01f, 4.52652611e-02f, 4.44566794e-02f, 7.14904964e-02f, -2.26330925e-02f,
  9.67996493e-02f, 5.68462014e-02f, -1.06327794e-01f, -7.09113851e-02f, -5.55016659e-02f, 1.09184887e-02f, 5.90861728e-03f, -2.62409747e-02f, -1.06633939e-02f, 2.85441317e-02f,
  -1.05561286e-01f, -6.05581366e-02f, 6.23223837e-03f, -1.73823517e-02f, -7.54312798e-02f, -4.20035087e-02f, 5.35251684e-02f, 1.05568379e-01f, 1.74720343e-02f, -5.38329855e-02f,
  -2.77821906e-02f, 7.49999434e-02f, -9.16552246e-02f, -5.31958602e-02f, 4.20832187e-02f, -5.26881441e-02f, 1.46852182e-02f, -7.38789793e-03f, -3.42146643e-02f, -1.67294145e-02f,
  7.81921949e-03f, -2.06331499e-02f, 7.39592761e-02f, 4.07385789e-02f, 8.62755999e-03f, -1.88348684e-02f, 5.27176075e-02f, -3.95949930e-02f, 4.76708962e-03f, -1.77190918e-02f,
  6.24244194e-03f, -1.57464594e-02f, 7.93159753e-02f, 6.69521615e-02f, 1.10643702e-02f, -9.24879313e-03f, 5.39941853e-03f, -2.02612877e-02f, 3.36162336e-02f, -4.42544334e-02f,
  -7.09820306e-03f, 8.07969719e-02f, -6.35472164e-02f, 3.41298105e-03f, 1.29815880e-02f, 9.42570269e-02f, -3.10424455e-02f, -7.41738677e-02f, -2.85145883e-02f, -4.90604863e-02f,
  7.97470957e-02f, 7.14743361e-02f, 7.28247017e-02f, 4.36642766e-02f, 1.19656315e-02f, -4.37229984e-02f, -9.42130282e-04f, 8.77919495e-02f, 9.24975798e-02f, -1.33106159e-02f,
  1.15092441e-01f, 1.44041866e-01f, -5.29892147e-02f, -5.82484975e-02f, 1.95509028e-02f, 1.58753674e-02f, -8.45750910e-04f, 1.05466291e-01f, 2.41519720e-03f, -1.33229559e-02f,
  -1.58509493e-01f, 2.96251979e-02f, -1.50653720e-01f, 4.26859856e-02f, -2.05760915e-03f, -4.73200865e-02f, 7.67217353e-02f, 6.24486618e-02f, 1.57168895e-01f, 1.29496932e-01f,
  3.48542258e-02f, -1.01041414e-01f, 7.07649589e-02f, 1.81246325e-02f, -1.04682371e-01f, 9.62639004e-02f, -8.77478272e-02f, -1.44766783e-03f, 1.17971553e-02f, -1.07875876e-02f,
  -2.68446170e-02f, 6.23812713e-02f, -8.30573440e-02f, -4.41922201e-03f, -5.76816797e-02f, -8.67480934e-02f, 4.69288294e-04f, 1.03583395e-01f, -7.66607821e-02f, -8.85449871e-02f,
  -6.96501881e-02f, 8.65365639e-02f, 6.13308735e-02f, 8.13131332e-02f, -7.08096698e-02f, -9.96381715e-02f, -1.22522429e-01f, -6.24595247e-02f, -2.58420464e-02f, -2.04554610e-02f,
  2.89556868e-02f, -3.82418521e-02f, 4.78910245e-02f, -5.51769063e-02f, -4.61524688e-02f, -2.80901417e-02f, -4.68344726e-02f, -3.77931371e-02f, 1.55863492e-02f, 2.51152217e-02f,
  6.51484057e-02f, -9.08258557e-02f, 5.55950999e-02f, -8.66353791e-03f, -8.97673741e-02f, 5.91755323e-02f, -7.90567398e-02f, -8.10543895e-02f, -1.01554081e-01f, -1.91601031e-02f,
  -4.67514358e-02f, -4.54397462e-02f, -1.91835668e-02f, -6.82367431e-03f, 5.12091257e-02f, 6.56647012e-02f, -1.18807936e-02f, -3.48387510e-02f, 1.55978967e-02f, 1.58582553e-02f,
  -4.47528176e-02f, -8.77654273e-03f, -5.01072034e-02f, 3.02022113e-03f, 6.35844916e-02f, -5.02354316e-02f, 2.11029258e-02f, 8.75163078e-02f, -6.42338917e-02f, 5.61107881e-03f,
  6.26503825e-02f, -2.80826725e-02f, 1.29282596e-02f, 1.91464515e-05f, 3.38336278e-04f, -6.34487569e-02f, 3.67871001e-02f, -4.15055826e-03f, -5.18930592e-02f, 4.04115804e-02f,
  -1.17472723e-01f, -8.93722922e-02f, 5.72849102e-02f, 2.54962724e-02f, -7.47527480e-02f, 2.50477064e-02f, -7.50339180e-02f, 5.84684685e-02f, 6.73024729e-02f, -2.07343977e-02f,
  -9.44438428e-02f, 3.82053368e-02f, -7.00877756e-02f, 3.04943137e-02f, -6.26328439e-02f, -4.12721410e-02f, 5.84672280e-02f, 4.47922833e-02f, -1.59718916e-02f, -4.31731232e-02f,
  5.84910959e-02f, 3.55754942e-02f, -1.66915972e-02f, 2.09239759e-02f, -6.30861223e-02f, 3.06117330e-02f, 5.27329892e-02f, -3.19076963e-02f, -2.80526113e-02f, -7.64064863e-02f,
  -1.09535769e-01f, 4.73356508e-02f, -1.00375742e-01f, -1.95611089e-01f, 1.81561746e-02f, -2.13373110e-01f, -8.23355764e-02f, -1.30080819e-01f, 1.42294049e-01f, 6.03197962e-02f,
  5.75061701e-02f, 4.45424020e-02f, 1.57658383e-01f, -1.46443233e-01f, -8.65824521e-02f, 1.68203041e-01f, -2.82938868e-01f, -1.37295559e-01f, 3.05274948e-02f, -2.04338402e-01f,
  -1.32838756e-01f, -1.07157148e-01f, -4.81629819e-02f, -2.86170263e-02f, -9.04207826e-02f, -7.59806558e-02f, -1.48790590e-02f, 4.51552719e-02f, -1.87380403e-01f, 4.14064899e-02f,
  -1.43445373e-01f, 8.74853134e-02f, 3.12953964e-02f, 6.00605868e-02f, -1.61633238e-01f, -7.65987113e-02f, -3.52644846e-02f, 6.18496910e-02f, -3.57773947e-03f, 1.01182936e-02f,
  -9.96556506e-02f, 1.00118138e-01f, -9.53026712e-02f, 6.31132126e-02f, -2.13346984e-02f, -1.30789485e-02f, -2.81121582e-03f, -1.11556023e-01f, 6.17869124e-02f, 8.30748230e-02f,
  4.95451055e-02f, -7.24309534e-02f, -9.36803371e-02f, 5.24030291e-02f, 2.56310850e-02f, 5.75051233e-02f, 6.48181187e-03f, -6.92310231e-03f, -7.47425184e-02f, 4.95757870e-02f,
  -5.47698364e-02f, -1.68995503e-02f, 4.05251011e-02f, 8.68902132e-02f, -7.58148357e-02f, 3.95719148e-02f, -3.24300081e-02f, 5.17607406e-02f, -1.99354570e-02f, 2.80892085e-02f,
  -6.07742816e-02f, -1.15874549e-02f, -1.91275068e-02f, -7.41344690e-02f, -3.10734119e-02f, -1.09068975e-02f, -7.15069324e-02f, 3.86268273e-02f, -4.99346219e-02f, 2.72947308e-02f,
  5.82063124e-02f, 8.94225296e-03f, -4.17363010e-02f, 5.10758981e-02f, 1.39284385e-02f, 2.57018935e-02f, 7.44483992e-02f, -7.16148615e-02f, 7.37444907e-02f, 5.66399507e-02f,
  -9.88452360e-02f, -5.11658043e-02f, -4.65291739e-03f, 7.87588581e-02f, -6.28740117e-02f, -4.12926078e-03f, -6.04895577e-02f, -3.88092920e-02f, -3.27477045e-02f, 4.52425368e-02f,
  1.79061610e-02f, -5.83476201e-02f, 1.84092149e-02f, 8.57935324e-02f, 6.46977080e-03f, -6.26589954e-02f, -6.82781488e-02f, -2.37055775e-02f, -1.36426436e-02f, -9.81511250e-02f,
  4.72965725e-02f, -5.40200993e-02f, 4.59365994e-02f, -6.58739209e-02f, -8.59827325e-02f, -7.98676610e-02f, -1.12485610e-01f, 7.87116215e-02f, 7.89077953e-03f, -4.75991314e-04f,
  1.95207655e-01f, -7.19603151e-02f, -1.26516923e-01f, -2.27449350e-02f, 9.74966772e-03f, -9.43378732e-02f, 1.98348723e-02f, 8.81064013e-02f, 1.38277516e-01f, -2.50682831e-02f,
  -1.13493735e-02f, 1.09233879e-01f, -4.41760607e-02f, -1.23332087e-02f, 4.44913581e-02f, -1.87138412e-02f, 1.78876314e-02f, -3.78138013e-02f, -3.14284884e-03f, -1.14012072e-02f,
  1.00866191e-01f, 1.17991008e-01f, 1.08620692e-02f, 5.05470857e-03f, -2.56274231e-02f, -1.13169387e-01f, -5.44077270e-02f, -1.45922722e-02f, -6.63970485e-02f, 1.32312505e-02f,
  8.15872028e-02f, 2.32660286e-02f, 8.18175077e-03f, 6.58640265e-02f, -3.49754877e-02f, 1.46724647e-02f, -1.09409243e-01f, 6.18896796e-04f, -2.67673936e-02f, 3.17797177e-02f,
  -9.89302918e-02f, -2.77659181e-03f, 3.39328721e-02f, 5.22056893e-02f, 1.13836098e-02f, 5.06544933e-02f, -1.90230384e-02f, 4.37370874e-02f, -8.12042579e-02f, -6.14994243e-02f,
  -1.33519331e-02f, 6.61538690e-02f, 4.23854031e-02f, -3.86171881e-03f, -2.56373249e-02f, -3.20530310e-02f, 2.52994504e-02f, -3.84039208e-02f, -5.87900952e-02f, 4.78899814e-02f,
  1.04296319e-01f, 2.93023959e-02f, 8.00378323e-02f, 2.59799026e-02f, -5.56649677e-02f, -4.63493317e-02f, 3.75276767e-02f, 8.15746281e-03f, 7.41885528e-02f, -3.46315913e-02f,
  -8.25005025e-02f, -3.98222618e-02f, -1.13001661e-02f, 6.49238452e-02f, 4.24344242e-02f, 3.46753448e-02f, 1.34899700e-02f, -4.77650687e-02f, -5.48387095e-02f, -9.71766636e-02f,
  5.12018241e-02f, 1.34863118e-02f, 2.05137786e-02f, -5.26084229e-02f, -9.76730511e-02f, -6.93542277e-03f, 8.27253014e-02f, 9.30693522e-02f, -6.66887388e-02f, -5.14343865e-02f,
  -3.23709957e-02f, 1.30498126e-01f, -1.56580296e-03f, 3.02689355e-02f, -6.03441102e-03f, 4.24886793e-02f, 6.93752663e-04f, 5.75868338e-02f, 2.02004379e-03f, -6.22550957e-02f,
  4.71979827e-02f, -3.11757959e-02f, -9.00018364e-02f, -3.84273864e-02f, -1.07527003e-01f, -8.28163524e-04f, -9.64598954e-02f, 2.75642233e-04f, -9.17603225e-02f, -9.42099020e-02f,
  1.02769788e-02f, 4.68528047e-02f, -6.62758648e-02f, -2.53872368e-02f, -5.51061705e-02f, -8.57086480e-02f, 3.07867210e-02f, -6.38858974e-02f, -4.06849012e-02f, -7.12453872e-02f,
  1.75941840e-01f, 5.54620549e-02f, -1.11001275e-01f, 9.79173463e-03f, -1.86165318e-01f, -8.12813565e-02f, -1.97473675e-01f, -1.03627471e-02f, -6.45678937e-02f, -1.14218425e-02f,
  -2.63389591e-02f, 1.27741322e-01f, 9.85682532e-02f, 8.11715890e-03f, 9.05502662e-02f, 1.30282521e-01f, -9.03060883e-02f, -7.32775554e-02f, -1.97383221e-02f, -8.14646259e-02f,
  3.70292701e-02f, -7.56997988e-02f, -7.07055181e-02f, -8.82528722e-02f, -3.67653556e-02f, 4.78621684e-02f, 5.12928665e-02f, -1.43167764e-01f, -1.35174781e-01f, -6.29382879e-02f,
  6.50790185e-02f, 5.73829263e-02f, 4.04766127e-02f, 7.41099659e-03f, -5.92336580e-02f, 6.29766285e-02f, 4.53272387e-02f, -2.90237907e-02f, 2.80746836e-02f, 2.16516238e-02f,
  -3.96971852e-02f, 7.79012293e-02f, 8.00394863e-02f, 3.04910634e-02f, 5.60719743e-02f, -1.17152184e-02f, -7.64582679e-03f, 5.59531301e-02f, -8.47192481e-02f, 2.39026174e-02f,
  -4.95831519e-02f, 2.00268831e-02f, 5.79887293e-02f, -3.36403679e-03f, 7.32045993e-02f, -4.39864621e-02f, -4.61327918e-02f, -4.11444902e-02f, -7.16218576e-02f, 7.05698133e-02f,
  -4.43714894e-02f, 5.15039526e-02f, -5.16258627e-02f, 4.36197221e-02f, 1.02569803e-03f, 4.82585877e-02f, -7.64030218e-02f, -5.29645942e-02f, -1.91253219e-02f, 6.42260090e-02f,
  -1.07233919e-01f, 3.65508795e-02f, -4.54060771e-02f, 2.86442526e-02f, -1.81089453e-02f, 9.24727768e-02f, -2.93143801e-02f, -6.06250949e-03f, -7.76998177e-02f, -6.68365583e-02f,
  -8.24926198e-02f, 2.26707049e-02f, -9.33308899e-02f, -7.26040304e-02f, -3.32689695e-02f, 2.02376693e-02f, -2.98856739e-02f, -3.95072848e-02f, 9.14806779e-03f, -3.87871936e-02f,
  3.84198455e-03f, -9.53702703e-02f, 3.69031020e-02f, -7.17116743e-02f, 3.81870829e-02f, -7.78619200e-03f, 7.73965493e-02f, -4.22369801e-02f, -3.10187880e-02f, 6.25038967e-02f,
  -1.03210807e-02f, 4.46401276e-02f, -4.07983586e-02f, 9.34000909e-02f, -6.87672645e-02f, 8.35878402e-02f, 5.65342978e-02f, -3.50867584e-02f, -7.98299387e-02f, 5.80446003e-03f,
  5.20430021e-02f, 2.21004654e-02f, 3.87844108e-02f, 1.44674350e-02f, 1.08660981e-01f, 4.85716760e-02f, 1.81478113e-02f, 8.38039815e-02f, 2.80315634e-02f, -8.04363564e-02f,
  -2.07538754e-02f, 1.96002901e-01f, 8.51625279e-02f, 1.11277863e-01f, 7.96654075e-03f, 2.38682539e-03f, 6.89180344e-02f, -7.36224949e-02f, -1.58442501e-02f, 1.72904015e-01f,
  7.84683749e-02f, 1.48013949e-01f, 2.29865164e-02f, 2.06092060e-01f, -1.26453862e-02f, -2.47411523e-02f, 6.60087392e-02f, 1.52479514e-01f, -1.02938026e-01f, -8.03172588e-03f,
  2.06895005e-02f, 8.54541585e-02f, -3.03659234e-02f, -7.73003548e-02f, 1.28046855e-01f, 7.39041045e-02f, 7.88827837e-02f, 4.00840631e-03f, 1.72512427e-01f, 8.89357645e-03f,
  -6.49799779e-02f, 4.33231294e-02f, -1.75761934e-02f, -3.56741548e-02f, 3.68801318e-02f, 4.45343107e-02f, 2.46529859e-02f, 2.28119753e-02f, 3.43024507e-02f, -5.23129106e-02f,
  1.06578209e-01f, -2.94827837e-02f, 2.61376761e-02f, 2.26523653e-02f, -8.28183517e-02f, -1.71674788e-02f, 9.63169485e-02f, -1.92829855e-02f, 1.46409823e-02f, 4.64043617e-02f,
  1.00758605e-01f, -4.00287807e-02f, -4.82159778e-02f, 1.83860697e-02f, 1.19911823e-02f, -4.17248197e-02f, -7.50317872e-02f, -6.02700794e-03f, 1.06826521e-01f, 3.65926288e-02f,
  -2.37011071e-02f, -3.16556729e-02f, -1.79180782e-02f, 8.56736302e-02f, -6.67199790e-02f, 2.44129915e-02f, 1.61534280e-03f, 2.79193055e-02f, -3.24050256e-04f, -6.20306470e-02f,
  -5.27581535e-02f, 7.77980611e-02f, 7.28141963e-02f, -7.41806999e-02f, 1.62061676e-02f, -4.42365371e-02f, 3.99018489e-02f, 5.79850823e-02f, 1.47813708e-02f, 5.95262945e-02f,
  1.51662277e-02f, -7.96931908e-02f, -5.39012291e-02f, 2.53858697e-02f, -7.88106397e-02f, -7.09300861e-02f, -8.27350020e-02f, 8.31996799e-02f, -1.01721734e-01f, 6.29909383e-03f,
  -4.15708572e-02f, 1.18926903e-02f, 1.88977271e-02f, -5.65253086e-02f, -4.48883623e-02f, 3.20064835e-02f, 4.34576012e-02f, -5.14433952e-04f, -7.47955516e-02f, 4.07947786e-02f,
  9.14706439e-02f, 6.27964363e-02f, 7.96653852e-02f, -4.66001220e-02f, 6.98000565e-02f, -7.97215700e-02f, -8.27726275e-02f, 8.17296654e-02f, -6.99408874e-02f, 2.66024079e-02f,
  -2.95973755e-02f, 5.85500300e-02f, -5.58733493e-02f, -2.59061810e-02f, 8.56130868e-02f, 8.81263167e-02f, 2.20724717e-02f, -3.35790664e-02f, 1.06059395e-01f, 9.89825800e-02f,
  -9.51237381e-02f, -7.40051195e-02f, -1.22548565e-01f, -9.17481631e-02f, 5.35777397e-02f, 4.42638844e-02f, -8.07540342e-02f, 7.50694051e-03f, -1.62145495e-01f, 1.89469099e-01f,
  2.03891575e-01f, -1.67285413e-01f, -2.56753545e-02f, -1.31469548e-01f, -1.94678038e-01f, -1.42975196e-01f, 7.58270025e-02f, -4.73358743e-02f, -6.29720464e-02f, 7.97776058e-02f,
  -9.63613689e-02f, 1.48001999e-01f, 2.77267862e-02f, 1.78118512e-01f, 5.94595745e-02f, 7.56557509e-02f, 1.18747249e-01f, 3.95162664e-02f, 1.05648689e-01f, -8.57212022e-02f,
  5.89737967e-02f, -7.72459880e-02f, -7.73395300e-02f, 2.74463054e-02f, 1.38482928e-01f, 3.58998552e-02f, 6.39727712e-02f, -7.30127767e-02f, 4.97152582e-02f, 6.55389205e-02f,
  4.49024551e-02f, -1.29254162e-02f, -3.12909223e-02f, -1.00733437e-01f, -1.74046289e-02f, -6.31541312e-02f, -6.36523962e-02f, 2.58689709e-02f, -9.31150392e-02f, -7.02191964e-02f,
  4.48296517e-02f, -1.03835640e-02f, 3.89557257e-02f, -5.66210523e-02f, 2.99102664e-02f, 1.72644965e-02f, 4.95613478e-02f, -1.22799529e-02f, -6.42914549e-02f, -4.54219338e-03f,
  2.33766027e-02f, -1.30057856e-02f, 3.05403974e-02f, -1.79708339e-02f, -4.78464440e-02f, -3.91106866e-02f, -4.98885773e-02f, 3.51470411e-02f, 1.28600411e-02f, 8.79551992e-02f,
  4.97191548e-02f, -1.40559683e-02f, -1.10697277e-01f, -5.11257304e-03f, -1.36842849e-02f, -8.30604881e-02f, 1.91522557e-02f, 7.17822090e-02f, 4.65201680e-03f, 3.05788442e-02f,
  -2.16201264e-02f, 6.20455928e-02f, -6.70698285e-02f, 4.24416624e-02f, -1.15171574e-01f, 8.76799449e-02f, 4.21404317e-02f, 2.80662812e-02f, 2.03224532e-02f, 2.47406177e-02f,
  1.02500007e-01f, 1.30720675e-01f, 1.08970448e-01f, -1.22580633e-01f, 8.80594254e-02f, 1.20421141e-01f, 7.63917789e-02f, -2.68967580e-02f, -1.04961507e-02f, -1.85387526e-02f,
  1.35005325e-01f, 6.63302913e-02f, 4.95946407e-02f, 8.28633830e-02f, -4.97143380e-02f, 4.78473194e-02f, -1.91982128e-02f, -3.38925538e-03f, -3.59979756e-02f, -4.68033254e-02f,
  6.79721683e-02f, 3.73543100e-03f, -2.57090181e-02f, 5.28401732e-02f, 7.82802105e-02f, 5.95572852e-02f, -2.56243255e-02f, -6.16777502e-02f, -5.57425581e-02f, -7.66038056e-03f,
  -1.43199667e-01f, -8.50171298e-02f, 7.45885819e-02f, -6.71217665e-02f, -8.34076703e-02f, 2.46863794e-02f, 6.84096888e-02f, -1.39864057e-01f, -4.99252081e-02f, 7.27071464e-02f,
  4.47125323e-02f, -7.39615485e-02f, 3.10234204e-02f, -9.71829221e-02f, 1.20278828e-01f, -3.79432994e-03f, 2.17791162e-02f, -3.07009555e-02f, 2.79017016e-02f, -5.04790992e-02f,
  -1.70773100e-02f, -4.69440259e-02f, -4.02199030e-02f, -1.05823271e-01f, -2.12502703e-02f, 5.53775541e-02f, -7.72550851e-02f, -2.68115979e-02f, -7.32506812e-02f, 1.05344258e-01f,
  4.15132679e-02f, -9.66825485e-02f, -8.29218924e-02f, 2.90345028e-02f, -3.29035372e-02f, 1.49220377e-02f, 5.64223155e-02f, 1.11431599e-01f, -5.37780151e-02f, 3.02520562e-02f,
  2.67758742e-02f, -8.50513130e-02f, -4.32090163e-02f, -4.74849343e-02f, 9.98301897e-03f, 3.79070789e-02f, -3.82571146e-02f, -7.32534453e-02f, 6.85869381e-02f, 5.77549972e-02f,
  -6.44673780e-02f, -5.05684875e-02f, 2.24714018e-02f, 4.71580513e-02f, -8.62782747e-02f, -3.07964124e-02f, 6.93161115e-02f, 5.77869229e-02f, -5.61207384e-02f, -7.25506339e-03f,
  8.30874145e-02f, 7.55745918e-02f, -8.57020840e-02f, 3.05569209e-02f, -9.87448841e-02f, 3.24776545e-02f, -8.05892199e-02f, 5.38005568e-02f, -7.57190734e-02f, -3.94627564e-02f,
  -2.78214719e-02f, -4.53710146e-02f, -2.30751298e-02f, -7.12874159e-02f, -5.42183183e-02f, -4.09225337e-02f, -6.30435944e-02f, -1.38828950e-02f, 1.01275578e-01f, 5.40105216e-02f,
  -6.00469336e-02f, -1.77513883e-02f, 1.00039065e-01f, -5.27864397e-02f, 1.03528708e-01f, 8.45653191e-02f, 8.90539587e-02f, -4.55503948e-02f, 1.63177773e-02f, 1.84436161e-02f,
  -8.15577805e-02f, -3.16378474e-02f, -9.00518522e-02f, 6.86464533e-02f, -1.72295105e-02f, -4.01422791e-02f, -7.49811064e-03f, -1.86322406e-02f, -4.53636469e-03f, -3.91417406e-02f,
  6.78212643e-02f, -2.49176268e-02f, 2.52840724e-02f, 2.92412546e-02f, 4.17814497e-03f, -1.09229004e-02f, -7.64086545e-02f, -2.04689335e-03f, -4.61048866e-03f, -7.67733380e-02f,
  -7.61872381e-02f, -5.84381819e-02f, 4.55218852e-02f, 4.61029448e-02f, 1.77653302e-02f, 7.49168638e-03f, -7.82246068e-02f, 1.35935098e-02f, 9.47633535e-02f, 9.66341421e-02f,
  1.61325485e-01f, -1.50648952e-01f, -4.21752036e-02f, 1.45103499e-01f, 1.10706642e-01f, -5.07878736e-02f, 8.25684331e-03f, 1.81274623e-01f, 3.02721441e-01f, -1.49722844e-01f,
  6.32609576e-02f, -9.01242271e-02f, -9.19925570e-02f, 1.75222065e-02f, -7.03385323e-02f, 5.32365404e-02f, -3.51188667e-02f, -5.45484722e-02f, 8.60904828e-02f, 8.62981826e-02f,
  8.61080512e-02f, 3.68842594e-02f, -1.15936317e-01f, -8.90614614e-02f, 5.50025254e-02f, -3.52900960e-02f, -1.46427993e-02f, -4.67986129e-02f, -1.15662336e-01f, -7.46857896e-02f,
  1.09285070e-02f, 1.39442449e-02f, -5.04699834e-02f, -5.22513501e-02f, 7.31722042e-02f, 5.09262718e-02f, -4.52032350e-02f, 1.43317608e-02f, -4.61866111e-02f, 3.12375743e-02f,
  -9.49020609e-02f, -4.59323116e-02f, -5.56354262e-02f, 7.31929392e-02f, 1.76030807e-02f, 7.54965320e-02f, -2.46036071e-02f, 6.07533865e-02f, 3.07591036e-02f, -9.91275236e-02f,
  1.88881624e-02f, -4.08677682e-02f, 3.02369576e-02f, -1.68677326e-02f, -4.64249291e-02f, 8.72957930e-02f, -2.45180223e-02f, -8.02771673e-02f, 2.80994568e-02f, -2.70367954e-02f,
  -1.00972325e-01f, 3.64010781e-02f, 5.58804050e-02f, 6.67567849e-02f, -1.10906297e-02f, -5.48114181e-02f, 5.95050454e-02f, -1.41009670e-02f, 5.58900535e-02f, 1.71396006e-02f,
  6.57135844e-02f, -6.31003231e-02f, -3.50683741e-02f, 8.64130333e-02f, -2.03641583e-04f, -8.58646911e-03f, 1.05334297e-02f, 5.70782349e-02f, 2.25014202e-02f, 7.44852796e-02f,
  -6.07071891e-02f, 1.48570281e-03f, -6.77915337e-03f, -4.20569442e-02f, -5.74247837e-02f, 4.43429239e-02f, -7.82744214e-02f, 6.06419072e-02f, -4.22583632e-02f, 4.40288410e-02f,
  4.68951231e-03f, -1.06718250e-01f, -2.99876966e-02f, -5.40516414e-02f, -7.92214181e-03f, -3.81288268e-02f, 1.16064455e-02f, 3.89995761e-02f, -8.70513320e-02f, 7.96983391e-02f,
  -4.52971756e-02f, 1.11120410e-01f, 4.34069932e-02f, -1.70525499e-02f, -2.98488867e-02f, 3.59367840e-02f, -5.26452214e-02f, -4.54916060e-02f, 2.68034022e-02f, -9.34052467e-02f,
  1.18326358e-02f, -1.09108463e-02f, 3.37310769e-02f, -2.07057063e-04f, -3.75453681e-02f, -7.67115057e-02f, 3.56177390e-02f, -5.70999905e-02f, 3.93722318e-02f, -3.19783911e-02f,
  -9.37071592e-02f, -9.95442346e-02f, -2.72543747e-02f, -2.00677186e-01f, 5.86470924e-02f, -1.51333762e-02f, -1.58353627e-01f, -8.62655714e-02f, -1.24315932e-01f, -9.28979367e-02f,
  -8.80670324e-02f, -9.08273906e-02f, 4.44015600e-02f, -5.45355976e-02f, -5.71605489e-02f, -5.03199734e-02f, -9.44072306e-02f, -1.63064852e-01f, -5.92241473e-02f, -1.27906293e-01f,
  1.58593021e-02f, -3.05576194e-02f, 4.20928821e-02f, -2.06607878e-02f, -1.04328422e-02f, 3.44710089e-02f, 7.86158442e-02f, 1.98179092e-02f, -1.18113138e-01f, 6.77313209e-02f,
  -7.52646849e-02f, -4.19182777e-02f, -1.06117032e-01f, -9.36620757e-02f, 3.91464308e-02f, 2.86190156e-02f, -6.35966361e-02f, -2.08544433e-02f, -9.30982828e-02f, -7.19584450e-02f,
  -3.25816572e-02f, 2.61736736e-02f, 9.29992367e-03f, -4.46968377e-02f, -9.25142094e-02f, 2.98843812e-02f, 2.74832640e-02f, 8.41393843e-02f, -8.32592696e-02f, 3.03147137e-02f,
  -7.24259391e-02f, 8.62443894e-02f, -3.50951515e-02f, 1.02110848e-01f, -6.54948577e-02f, 8.52297619e-02f, -1.06914435e-02f, -6.50276020e-02f, -3.14787030e-02f, -4.21545953e-02f,
  -8.97604227e-02f, 3.65697127e-03f, -4.71126214e-02f, -1.35584436e-02f, 4.77672815e-02f, -6.98182061e-02f, -1.69236585e-02f, 6.71213418e-02f, -8.56174715e-03f, -8.87256935e-02f,
  1.35785919e-02f, -4.11358811e-02f, 3.51396091e-02f, 5.10190278e-02f, -2.70517431e-02f, 2.69170124e-02f, -3.84197235e-02f, -7.80886859e-02f, -2.05109436e-02f, -3.86024937e-02f,
  -5.04881553e-02f, 6.47298247e-02f, 1.73616074e-02f, -5.83200436e-03f, 7.52735958e-02f, 6.85825795e-02f, 2.40848381e-02f, -9.32394236e-04f, 3.05475574e-02f, 6.47376254e-02f,
  5.35664335e-02f, -7.00626001e-02f, -5.23284217e-03f, 3.27331237e-02f, -6.62089214e-02f, -4.37664762e-02f, -9.49183330e-02f, 7.19218403e-02f, -1.29010435e-02f, 1.55638140e-02f,
  -1.48433475e-02f, -6.70294762e-02f, 2.16551311e-03f, -7.61878490e-02f, -3.29925902e-02f, -1.11360446e-01f, 1.22277113e-02f, -1.79455597e-02f, -3.15185897e-02f, 1.07221054e-02f,
  -6.00766614e-02f, 1.16004767e-02f, 4.75983359e-02f, -1.40578449e-02f, -2.32323147e-02f, 7.44924769e-02f, 7.81275481e-02f, 1.03616072e-02f, 5.78906685e-02f, -8.35512131e-02f,
  -5.92074916e-02f, -7.72518888e-02f, 7.14985803e-02f, -9.33480635e-02f, 2.42961254e-02f, 2.29103073e-01f, 1.73351988e-01f, -2.87180021e-02f, 4.15448621e-02f, -9.78099033e-02f,
  -7.05721378e-02f, -4.19998653e-02f, 1.05765447e-01f, 4.69904877e-02f, 6.67249337e-02f, 8.00510198e-02f, -2.81205848e-02f, -5.84994107e-02f, 1.93994921e-02f, 2.02819016e-02f,
  6.90322043e-03f, -7.75268376e-02f, 2.26548314e-02f, -1.29062548e-01f, -1.29555851e-01f, -8.85500833e-02f, -7.55867809e-02f, 7.58391172e-02f, -5.48998192e-02f, -7.20704272e-02f,
  1.27966359e-01f, -4.18527201e-02f, 1.99660230e-02f, -1.62356365e-02f, -4.16691862e-02f, -3.09040789e-02f, -6.33374825e-02f, -5.79703040e-02f, -7.42943957e-03f, -8.20243061e-02f,
  -1.94506235e-02f, -4.42005657e-02f, -4.35001077e-03f, -3.16886865e-02f, 1.03555424e-02f, 4.29956168e-02f, 4.19897698e-02f, -8.59984457e-02f, -3.42315622e-02f, -4.44702245e-03f,
  8.50045457e-02f, -6.84695244e-02f, -4.68016863e-02f, -4.96537471e-03f, 1.92858204e-02f, -5.39007857e-02f, 6.67322353e-02f, 6.67521209e-02f, -9.66935307e-02f, -8.43138844e-02f,
  -3.05897091e-02f, 1.78893954e-02f, -4.51079421e-02f, 3.04966979e-02f, 2.31680945e-02f, -5.14061116e-02f, 6.31787931e-04f, 2.11161096e-02f, 8.26103687e-02f, -1.37715833e-02f,
  4.64827828e-02f, -2.76834667e-02f, 5.78010716e-02f, -4.52969112e-02f, -6.50606900e-02f, -4.96228784e-03f, 7.86616653e-02f, -8.44170675e-02f, -4.39243987e-02f, -8.75350907e-02f,
  4.78902385e-02f, 4.45148721e-02f, 2.36914828e-02f, -1.98954232e-02f, 6.64049983e-02f, -7.28996098e-02f, -3.88123877e-02f, -7.63283893e-02f, -9.87621304e-03f, 9.66061950e-02f,
  -1.72367804e-02f, 1.42489197e-02f, 1.01229973e-01f, -8.34409967e-02f, 8.06642026e-02f, -3.85020450e-02f, 5.17297424e-02f, -6.71577454e-02f, 2.15611495e-02f, 3.69280460e-03f,
  1.91748235e-02f, 6.23570196e-02f, 6.58535305e-03f, -1.16436779e-02f, 4.79288623e-02f, 3.98435853e-02f, 2.59649791e-02f, -7.54385814e-02f, 1.82096977e-02f, -6.85948133e-02f,
  -8.37274864e-02f, 5.68652786e-02f, -6.91681355e-02f, -9.45286602e-02f, 4.72233966e-02f, 6.38646190e-04f, -6.95892647e-02f, 6.25338927e-02f, -3.89793441e-02f, -3.50834094e-02f,
  -1.25634968e-01f, -6.61845133e-02f, 1.07540324e-01f, 3.14988592e-03f, -1.07918441e-01f, -5.09374067e-02f, -2.34137848e-02f, -2.31364509e-03f, -1.09746039e-01f, -5.09863123e-02f,
  9.43830162e-02f, -1.69801582e-02f, 1.56176444e-02f, 8.74039829e-02f, -3.69099341e-03f, -1.10705994e-01f, 2.83703413e-02f, 4.08781841e-02f, 3.42452005e-02f, 3.11780460e-02f,
  1.84224807e-02f, 2.45087445e-02f, 2.76107341e-02f, 9.62411314e-02f, -3.82459201e-02f, 8.86250436e-02f, 1.30463079e-01f, 2.35849340e-02f, 1.65591851e-01f, -4.50834371e-02f,
  -1.23958979e-02f, 2.78397668e-02f, 2.24675168e-03f, 6.96293563e-02f, -5.45667633e-02f, -5.55376261e-02f, 8.97419155e-02f, 4.80500311e-02f, 7.22909123e-02f, -9.54260584e-03f,
  -7.21288249e-02f, -1.47788962e-02f, -1.01746805e-01f, -8.89079124e-02f, 2.89877299e-02f, -2.97318138e-02f, -1.04518987e-01f, 2.47074466e-04f, -5.58694415e-02f, 4.12328355e-02f,
  -5.58362305e-02f, -2.12927051e-02f, 9.35411640e-03f, -3.19595560e-02f, 4.36925404e-02f, 2.18756180e-02f, 1.97367631e-02f, -5.26994513e-03f, -7.32829422e-02f, 6.80137053e-02f,
  7.66998604e-02f, -1.03844725e-01f, -4.46273610e-02f, -3.52936611e-02f, -9.38729718e-02f, 9.54904314e-03f, 4.09535281e-02f, -1.77203752e-02f, -6.36094064e-02f, -4.41564396e-02f,
  -6.22402690e-02f, -8.30119550e-02f, 5.97766675e-02f, 2.31148433e-02f, -7.16810673e-02f, -1.89269744e-02f, -2.95209344e-02f, -3.54837067e-02f, 6.74758181e-02f, -1.92642491e-02f,
  6.67591095e-02f, 2.92733107e-02f, 3.44427787e-02f, -3.96236628e-02f, -9.09823552e-02f, -3.16577591e-02f, -5.11647016e-02f, 3.15161906e-02f, 2.69135293e-02f, 1.50048528e-02f,
  3.04274689e-02f, -2.44006384e-02f, -6.86530694e-02f, -1.93991233e-02f, -6.63426891e-02f, 8.15539733e-02f, 7.77418390e-02f, -2.98629962e-02f, 4.18609120e-02f, 1.90351494e-02f,
  -4.71137315e-02f, -2.55607720e-02f, -1.40181568e-03f, 5.00805229e-02f, 6.95529282e-02f, 1.62790902e-02f, -4.28371765e-02f, -7.48799816e-02f, 8.92789941e-03f, 3.88220400e-02f,
  9.04151201e-02f, -6.50505498e-02f, 1.18311653e-02f, 3.79545018e-02f, -1.33402031e-02f, 4.46204841e-02f, 7.63051677e-03f, -3.48716117e-02f, -6.68330640e-02f, -3.44627537e-02f,
  -2.35667348e-01f, 6.41672686e-02f, -1.75495476e-01f, -1.12554871e-01f, -3.53051908e-02f, 1.33068174e-01f, 7.17605352e-02f, 4.28987518e-02f, -1.12961717e-01f, 7.28687365e-03f,
  1.53425127e-01f, -6.40449896e-02f, -1.05310477e-01f, 2.13868424e-01f, 6.66867197e-02f, 2.46035401e-02f, 1.93287283e-01f, 4.77222688e-02f, -1.26948236e-02f, -5.41314334e-02f,
  7.08760172e-02f, 1.00746907e-01f, 7.80206025e-02f, 7.35249966e-02f, 5.99126294e-02f, -7.80837312e-02f, -4.07093130e-02f, -1.00013800e-01f, 2.09524974e-01f, 1.43607527e-01f,
  -2.36778869e-03f, -1.21791251e-01f, -5.39731309e-02f, 1.30225241e-03f, -5.30839115e-02f, -7.74615929e-02f, -2.68394314e-02f, -4.03400175e-02f, 1.39643960e-02f, -3.94155495e-02f,
  3.47309969e-02f, -3.27195227e-02f, 3.25101055e-02f, -8.46453477e-04f, -8.92240554e-03f, 3.92730422e-02f, -7.03234822e-02f, 5.11355102e-02f, -1.79202529e-03f, -2.74892133e-02f,
  -9.28272400e-03f, -9.87909443e-05f, -1.20421899e-02f, 3.82090621e-02f, 7.02863513e-03f, 5.18713333e-02f, 3.87881952e-03f, -9.60556418e-03f, 1.01994023e-01f, 8.58253017e-02f,
  -4.08912683e-03f, -9.12605785e-03f, -4.48759980e-02f, 2.63121724e-02f, 3.38215567e-02f, 4.23918888e-02f, -1.88386831e-02f, 2.09270623e-02f, 2.28130873e-02f, 3.05674262e-02f,
  -7.88831152e-03f, -4.82225120e-02f, 6.37296587e-02f, -9.70515609e-03f, -2.82963552e-02f, -4.11588624e-02f, 7.83906728e-02f, 3.02155707e-02f, 5.50882779e-02f, 8.08279030e-03f,
  2.72598979e-03f, -2.06530895e-02f, -2.24347925e-03f, 6.95130602e-02f, -6.31152019e-02f, -1.08341798e-02f, 7.50785181e-03f, -5.97034656e-02f, -3.75097641e-03f, 1.54577987e-02f,
  5.66324294e-02f, -3.63915004e-02f, -4.64901477e-02f, 3.10935592e-03f, -6.42208531e-02f, 6.94224685e-02f, 7.89664388e-02f, 5.08754067e-02f, -7.37928674e-02f, 3.99585776e-02f,
  -4.84290645e-02f, 2.33785268e-02f, -3.16331442e-03f, 4.97907549e-02f, -7.96822645e-03f, -7.24945441e-02f, 3.88185270e-02f, -3.10136266e-02f, 8.13457370e-03f, -2.47428901e-02f,
  -5.08814119e-02f, 4.03695777e-02f, 7.47603029e-02f, 3.81196290e-02f, 2.48996783e-02f, -2.96890456e-03f, -5.88405691e-02f, 6.75055608e-02f, -4.32647690e-02f, 8.10577814e-03f,
  1.59404334e-02f, -1.59762844e-01f, -7.82628283e-02f, 1.61359638e-01f, -1.79817993e-02f, 1.87255964e-01f, 1.53689384e-01f, 2.68496424e-02f, 2.34263375e-01f, 5.78667447e-02f,
  -5.44247851e-02f, 6.92034978e-03f, -1.83422938e-01f, 5.32876551e-02f, 1.01191968e-01f, 4.79018837e-02f, 1.17468581e-01f, 1.12315923e-01f, 9.72592533e-02f, 4.55362350e-02f,
  9.65651423e-02f, 5.68553917e-02f, -1.68229386e-01f, -5.31107858e-02f, -1.07928939e-01f, -7.32724965e-02f, -1.31500393e-01f, -1.44663379e-01f, 6.92268983e-02f, -4.18154150e-02f,
  9.35745463e-02f, -5.37147839e-03f, -9.89579260e-02f, -5.57329915e-02f, 8.03963933e-03f, 7.50934258e-02f, -2.35430449e-02f, -5.30341528e-02f, -6.44288808e-02f, -6.46114796e-02f,
  2.08915025e-03f, 4.11457121e-02f, 5.19591831e-02f, -8.28902796e-02f, 5.20297028e-02f, 4.24495749e-02f, 5.55520579e-02f, -1.53327640e-02f, 2.93319076e-02f, 4.65616211e-03f,
  -2.95727700e-02f, -8.36438537e-02f, 6.31495239e-03f, 2.51282100e-02f, 3.84251364e-02f, -4.69132401e-02f, 7.02493191e-02f, -7.26809166e-03f, -6.68548122e-02f, 8.37118477e-02f,
  5.21746874e-02f, 5.27897142e-02f, 1.26904165e-02f, 7.51623586e-02f, 1.33113572e-02f, 6.09356947e-02f, 2.53389087e-02f, -5.30322641e-02f, 3.91884856e-02f, 1.55207794e-02f,
  5.51607311e-02f, -3.02674323e-02f, 8.68090764e-02f, 5.74540570e-02f, 1.98724326e-02f, 1.72805996e-03f, 1.45111661e-02f, 4.05949093e-02f, 5.48610389e-02f, -1.97611079e-02f,
  3.84163968e-02f, 6.80939779e-02f, -4.14557755e-02f, -6.70562387e-02f, -3.00327335e-02f, 3.45124714e-02f, -1.52871348e-02f, -4.54687104e-02f, 4.96093696e-03f, -5.31777516e-02f,
  4.86132726e-02f, 1.19108155e-01f, 5.61903156e-02f, 2.50304583e-03f, 7.92941600e-02f, -3.91296744e-02f, 8.46926793e-02f, -2.30656099e-02f, 5.37435040e-02f, 8.95673111e-02f,
  -5.00732921e-02f, -4.89388555e-02f, 5.29019423e-02f, -7.72738969e-03f, 5.92875071e-02f, -8.72777626e-02f, 7.66004696e-02f, 7.44219348e-02f, 4.58380245e-02f, -7.17056319e-02f,
  -5.61167300e-03f, 5.51335774e-02f, 4.35255617e-02f, 4.69515324e-02f, 3.64715680e-02f, 1.31621724e-02f, 2.61579291e-03f, -8.09359699e-02f, -4.26818319e-02f, 6.31230772e-02f,
  9.38545763e-02f, -1.50631309e-01f, 6.00623190e-02f, 8.44278038e-02f, -4.02458794e-02f, 2.78289691e-02f, 2.06174254e-01f, -2.12593168e-01f, 2.20840028e-03f, -1.53856471e-01f,
  -6.49871379e-02f, 1.82863101e-01f, -2.95387674e-03f, -9.22403857e-02f, 2.05059528e-01f, -3.72314826e-03f, 2.87795626e-02f, 6.33225888e-02f, -9.41925719e-02f, -2.73433025e-03f,
  -7.95652792e-02f, -1.20194070e-02f, -6.00380935e-02f, -1.42706051e-01f, -7.14173391e-02f, -9.43998992e-02f, -9.84565318e-02f, -3.26514058e-02f, -2.92217899e-02f, -1.57573149e-02f,
  9.33649298e-03f, 2.25705039e-02f, 5.19806407e-02f, 5.79975098e-02f, 2.19032560e-02f, -5.35575263e-02f, 1.10917702e-01f, 1.25735641e-01f, -2.47490779e-02f, -3.40847410e-02f,
  -4.81592268e-02f, 7.04054832e-02f, -1.89644713e-02f, -1.47667015e-02f, -4.86529283e-02f, -1.68221556e-02f, 3.96181978e-02f, 1.20811313e-02f, 7.20562935e-02f, 6.05059080e-02f,
  5.61547205e-02f, 7.85795972e-02f, -2.46174764e-02f, 3.01293861e-02f, 2.59829313e-02f, -4.53411648e-03f, -3.21780629e-02f, 7.56537402e-03f, 5.18559106e-02f, 7.72214681e-03f,
  7.03410432e-02f, 2.60486547e-02f, -6.46900088e-02f, -5.56043461e-02f, 3.02489735e-02f, -4.44155419e-03f, -4.38732021e-02f, 1.06985539e-01f, 4.04728353e-02f, 4.53631133e-02f,
  7.85932988e-02f, -3.52149742e-04f, 7.37275928e-02f, 5.79288974e-03f, -2.75210701e-02f, -3.07894088e-02f, -2.36020535e-02f, -1.08525358e-01f, -6.73261881e-02f, 2.73871217e-02f,
  -2.67432835e-02f, 1.02954797e-01f, -3.17785256e-02f, -8.41423869e-03f, -2.62528639e-02f, 2.93580443e-02f, -7.10736066e-02f, 7.52514526e-02f, 1.02128433e-02f, 8.04428160e-02f,
  -8.52679089e-02f, -2.36226786e-02f, -1.64748300e-02f, 1.23496316e-02f, 8.34213197e-02f, 4.06330489e-02f, -5.47521636e-02f, 1.73430499e-02f, -7.76502118e-03f, 7.62020200e-02f,
  -2.40293667e-02f, 2.48959921e-02f, -2.61171558e-03f, 4.45500501e-02f, -3.09902267e-03f, -4.01497036e-02f, -1.27966097e-02f, 2.02825256e-02f, -3.18135656e-02f, 1.36364382e-02f,
  2.61764671e-03f, 2.32534576e-02f, 9.82256830e-02f, -7.48927072e-02f, -3.37383151e-02f, -9.91053432e-02f, -1.01136863e-02f, -9.49647650e-03f, -4.29276228e-02f, -8.70840177e-02f,
  -1.21895537e-01f, 5.99955209e-03f, -9.73534808e-02f, -1.09460428e-01f, -1.16003081e-02f, -5.16525693e-02f, -1.14326864e-01f, 1.87501740e-02f, 1.38962353e-02f, 1.60069808e-01f,
  -8.65340829e-02f, 1.02819562e-01f, 1.50840813e-02f, -6.36062399e-02f, -3.31457183e-02f, 7.70880003e-03f, -6.94582835e-02f, 3.74997817e-02f, -4.96128276e-02f, 3.93297747e-02f,
  -1.49083763e-01f, -6.51222840e-02f, -1.42589035e-02f, -2.57147085e-02f, -1.57775171e-02f, 6.71460405e-02f, 4.83109429e-02f, -7.93123692e-02f, -9.35433358e-02f, -6.35877699e-02f,
  7.84377530e-02f, 4.21827957e-02f, 1.56812347e-03f, -1.70360021e-02f, -5.92975207e-02f, -3.42047513e-02f, -3.19734514e-02f, -3.54623422e-02f, 4.80315983e-02f, -1.31339170e-02f,
  5.30039631e-02f, 1.05071925e-01f, -8.20747390e-02f, -5.83744980e-02f, 4.50595170e-02f, 6.11035414e-02f, -7.83941746e-02f, 9.55132023e-02f, 6.78969324e-02f, 4.94007729e-02f,
  -3.35429376e-03f, -8.31913128e-02f, -1.02975722e-02f, 8.37548450e-02f, -1.73077509e-02f, -6.71159700e-02f, -1.34844324e-02f, -3.75464223e-02f, 2.84887647e-04f, -2.96019558e-02f,
  3.76053266e-02f, 5.37245572e-02f, 1.13707399e-02f, -5.08600771e-02f, -1.68418940e-02f, -2.32134946e-02f, -1.26277041e-02f, 3.13582420e-02f, 4.18948941e-02f, 4.24353890e-02f,
  1.01695791e-01f, -7.26376846e-02f, -4.51474376e-02f, -6.70545846e-02f, -4.47099060e-02f, -7.29362816e-02f, -7.75391757e-02f, -3.90195809e-02f, -8.68820027e-02f, -3.00351307e-02f,
  4.19078842e-02f, 6.93060905e-02f, 4.74756695e-02f, 3.80694270e-02f, -8.41545314e-02f, 1.10218171e-02f, -3.98605466e-02f, 3.37963216e-02f, -8.48207921e-02f, 6.59155771e-02f,
  3.46869640e-02f, -5.66298328e-03f, 8.21957141e-02f, 1.13440298e-01f, -4.50310707e-02f, -7.97604844e-02f, 2.15334222e-02f, -4.56888080e-02f, 3.56018879e-02f, -4.21723612e-02f,
  4.75293212e-02f, -2.36675772e-03f, -7.20333830e-02f, -8.71918499e-02f, -9.41119418e-02f, -5.66940755e-02f, 1.51050426e-02f, -3.50831673e-02f, -4.71227989e-02f, 2.72772741e-02f,
  -5.74885681e-02f, 1.73319075e-02f, -2.21762974e-02f, 3.65531333e-02f, 3.54885012e-02f, 3.38803940e-02f, -5.75152487e-02f, 4.82715480e-02f, 2.28238162e-02f, 3.14213894e-02f,
  -9.96049643e-02f, 1.58669561e-01f, 7.47716846e-03f, -9.77551118e-02f, 7.91431591e-02f, -1.05245978e-01f, 9.76411346e-03f, 7.37391040e-02f, 1.06216609e-01f, 1.91531554e-02f,
  -7.72598833e-02f, -1.08376918e-02f, -4.46051694e-02f, -1.34887882e-02f, -2.08023846e-01f, 5.46817370e-02f, -6.33151904e-02f, -1.36701629e-01f, 2.09424365e-02f, -4.87788282e-02f,
  -7.66698271e-02f, -7.74660707e-02f, 7.61118308e-02f, 9.27997637e-04f, 6.60378635e-02f, -1.60902757e-02f, -8.86489898e-02f, 8.54784623e-02f, 2.53359787e-02f, 6.73110113e-02f,
  2.02426757e-03f, 3.45239788e-02f, 1.38197750e-01f, 9.26464126e-02f, 5.97673431e-02f, -4.49476615e-02f, 7.17787147e-02f, -2.35414039e-02f, -2.65989378e-02f, 2.48251297e-02f,
  7.95110390e-02f, -1.35346996e-02f, 1.07444152e-02f, -2.87870672e-02f, 5.54814190e-02f, -3.17006707e-02f, 9.32360217e-02f, 5.37380427e-02f, 4.22563292e-02f, -4.13214602e-02f,
  2.64621805e-02f, 8.93554389e-02f, -4.49815020e-02f, -9.92073491e-02f, -4.23850864e-03f, 7.73958787e-02f, -1.06166132e-01f, -3.94001789e-02f, -1.01755962e-01f, -7.60243833e-02f,
  7.07819965e-03f, 6.93553761e-02f, 5.44888452e-02f, -4.59689125e-02f, -7.66665675e-03f, -3.87859007e-04f, 3.73821445e-02f, -5.07785715e-02f, 3.48562002e-02f, 6.24822453e-02f,
  3.50805745e-02f, 7.42003694e-02f, 7.74743557e-02f, -1.14402212e-02f, -6.01767674e-02f, 7.42529035e-02f, -3.84327881e-02f, -8.50982666e-02f, 1.76050458e-02f, 6.67557120e-02f,
  5.61326630e-02f, 8.84411260e-02f, 8.34875107e-02f, -4.85290252e-02f, 2.72386018e-02f, 3.97305563e-02f, 1.45839239e-02f, -1.20682055e-02f, 9.37812552e-02f, -1.09134182e-01f,
  -5.58844544e-02f, -7.87023231e-02f, 1.52947102e-02f, 3.36194970e-02f, 3.37943994e-02f, -2.50847321e-02f, 5.36229499e-02f, 1.08314261e-01f, -3.42995040e-02f, -9.33096632e-02f,
  4.84398827e-02f, -2.23009121e-02f, -1.02968723e-01f, 6.74005672e-02f, 1.99472625e-02f, -3.07857599e-02f, -1.16832857e-03f, -6.28474876e-02f, -1.32030658e-02f, 1.37559595e-02f,
  -3.56582971e-03f, -7.28964247e-03f, -8.14761445e-02f, -3.50868851e-02f, 6.16594143e-02f, 6.30645035e-03f, 1.16229644e-02f, 8.13359320e-02f, -7.64944330e-02f, -9.98725072e-02f,
  1.01219840e-01f, 9.31627676e-02f, -4.07280512e-02f, 6.07062541e-02f, -3.44588459e-02f, -7.04742372e-02f, 1.04343526e-01f, -6.32907525e-02f, 1.07291847e-01f, 3.05122081e-02f,
  3.74516509e-02f, 3.84761542e-02f, 2.16482952e-02f, 1.63453922e-01f, -9.47638974e-02f, -5.66499978e-02f, -3.33328471e-02f, 6.92011341e-02f, 5.55724315e-02f, 3.45316045e-02f,
  7.54352054e-03f, 8.49545226e-02f, -8.10484141e-02f, -4.45532799e-02f, 1.08385228e-01f, -8.84493515e-02f, -1.22171871e-01f, 5.45492992e-02f, -3.67523469e-02f, 7.28826597e-02f,
  -1.41212810e-02f, 4.99248644e-03f, 1.00428043e-02f, 3.46682742e-02f, 7.95551017e-02f, 3.44545901e-04f, -2.63496861e-02f, -1.46796682e-03f, 3.30987535e-02f, -8.06039646e-02f,
  7.08486885e-02f, -4.50087003e-02f, -4.42856625e-02f, -4.56471816e-02f, -3.91050652e-02f, 7.11461455e-02f, -9.99549180e-02f, -1.40513787e-02f, 1.74690224e-02f, -3.41487154e-02f,
  4.83834185e-02f, -3.62192653e-02f, -6.36192113e-02f, -2.33336017e-02f, -9.35587510e-02f, -5.88774271e-02f, 6.82456121e-02f, -7.56813213e-02f, 1.61760859e-02f, 6.34144396e-02f,
  -2.33840384e-02f, -5.18647619e-02f, 8.11326802e-02f, -4.98193949e-02f, 5.99496886e-02f, 6.68262318e-02f, 4.49600704e-02f, 1.06833242e-02f, 7.97230229e-02f, 2.33156960e-02f,
  1.69950835e-02f, 8.44628885e-02f, 4.97150160e-02f, 5.59820086e-02f, 3.35539654e-02f, -7.30121648e-03f, -5.19415876e-03f, -9.63780750e-03f, 3.20441835e-02f, -1.15003400e-01f,
  4.41159122e-02f, 2.31751781e-02f, 5.79542220e-02f, -7.62662441e-02f, -2.11135205e-02f, 1.66848823e-02f, 1.17661670e-01f, -9.30873007e-02f, 2.24697068e-02f, -1.29652331e-02f,
  -2.92899404e-02f, -5.04417531e-02f, -3.55928876e-02f, 8.19828268e-03f, 4.44589928e-02f, 8.77392665e-03f, 6.99256137e-02f, 1.09832343e-02f, -9.04919282e-02f, 2.38627419e-02f,
  -1.30891893e-02f, -7.83684850e-02f, -7.17053264e-02f, 7.25120679e-02f, -5.06177396e-02f, 1.02280900e-01f, 7.94674978e-02f, -1.07590817e-02f, -9.02384147e-02f, -6.72240257e-02f,
  -7.34419376e-02f, 2.62925886e-02f, -1.93563029e-02f, -1.92782953e-02f, -1.74248479e-02f, 7.20047355e-02f, -6.06344789e-02f, 4.89500426e-02f, -2.79939882e-02f, -9.80622917e-02f,
  -4.02787700e-02f, 2.15055496e-02f, -6.76081181e-02f, 1.96900051e-02f, -2.45452374e-02f, -3.03411692e-01f, -2.74329394e-01f, -4.79888134e-02f, 1.04482770e-01f, -5.58684394e-03f,
  2.99041951e-03f, 9.13989320e-02f, 5.03927295e-04f, -1.38093472e-01f, 8.65492076e-02f, 1.50499910e-01f, -1.56363949e-01f, -3.87373567e-02f, -3.99417356e-02f, -7.91070051e-03f,
  1.02987610e-01f, 4.13645320e-02f, -3.60030308e-02f, -8.47311970e-03f, -9.95580703e-02f, 1.17308805e-02f, 1.44064382e-01f, -1.09182402e-01f, -1.59633085e-01f, 4.06433716e-02f,
  -3.75921689e-02f, -3.43869962e-02f, -1.01487041e-01f, -7.26222321e-02f, -3.04370224e-02f, -1.24319598e-01f, -1.20476611e-01f, 1.84944291e-02f, -6.23733290e-02f, -4.85871658e-02f,
  1.99966896e-02f, 1.50641399e-02f, -1.98923964e-02f, 2.51821242e-02f, -3.84877808e-02f, 2.10210662e-02f, 2.49371659e-02f, -2.02301727e-03f, 5.94872981e-02f, 2.37186719e-02f,
  -3.04131806e-02f, 2.75839400e-02f, -7.51512572e-02f, -6.50862753e-02f, 1.56288184e-02f, -1.04394555e-01f, -8.81412178e-02f, 3.14407237e-02f, -4.68669720e-02f, -3.68403420e-02f,
  -2.05357671e-02f, -3.63384187e-02f, -5.77810854e-02f, 5.94906397e-02f, -2.10906398e-02f, 2.17683949e-02f, -5.66653796e-02f, -2.90735681e-02f, -1.15466947e-02f, -5.47976494e-02f,
  -6.45133182e-02f, -2.26742849e-02f, 8.72785971e-02f, 1.17751937e-02f, -3.58141884e-02f, -3.45907360e-02f, 2.67213006e-02f, 3.80812436e-02f, 2.68933885e-02f, 6.32519126e-02f,
  1.75118120e-03f, -4.10619453e-02f, 6.74706623e-02f, 2.31837630e-02f, 5.34267835e-02f, 1.75365750e-02f, 3.29032168e-02f, 2.34108232e-02f, 1.08541204e-02f, 1.25868730e-02f,
  -1.09729163e-01f, 1.19001374e-01f, -1.28890609e-03f, 2.41700113e-02f, 1.58426687e-02f, -4.94019315e-02f, 8.53314996e-02f, -6.78516254e-02f, -7.03109056e-02f, -4.18451317e-02f,
  -9.31631997e-02f, -8.51144642e-02f, 5.41593991e-02f, 8.15136954e-02f, 3.10192201e-02f, -4.39205803e-02f, 9.30006430e-03f, -8.37318320e-03f, -3.52210854e-03f, 7.28111267e-02f,
  4.61734831e-02f, -6.25477284e-02f, -3.45384143e-02f, -2.29256712e-02f, 8.86752307e-02f, -9.46146697e-02f, 6.90761209e-03f, 8.81128237e-02f, 7.67459394e-04f, 3.11082937e-02f,
  8.65657628e-02f, -4.19125929e-02f, -1.34852752e-01f, 4.85684350e-02f, 1.15692183e-01f, 2.49141753e-01f, 9.29770842e-02f, -1.32329827e-02f, -1.60683040e-02f, -3.53961401e-02f,
  1.16690777e-01f, -4.96028066e-02f, -1.50822163e-01f, 1.32960871e-01f, 8.92908797e-02f, -3.56074870e-02f, 1.17657118e-01f, 1.93340123e-01f, -8.40415359e-02f, -5.77532016e-02f,
  -2.18714476e-02f, 2.13234991e-01f, -7.66784623e-02f, 6.77472129e-02f, 2.97763720e-02f, -8.51621106e-02f, 1.14425525e-01f, -1.37429848e-01f, 9.14998651e-02f, 1.53723821e-01f,
  1.54301012e-02f, -1.83863603e-02f, -7.07420632e-02f, 5.63695766e-02f, -4.57389131e-02f, 3.12107820e-02f, -6.89910492e-03f, 5.03430218e-02f, -4.07518372e-02f, 7.93229192e-02f,
  2.46905144e-02f, -7.72848085e-04f, 9.66359600e-02f, 5.09440415e-02f, 6.82099909e-02f, 1.40179498e-02f, -2.63703205e-02f, -4.87185605e-02f, -1.18670296e-02f, -7.48021081e-02f,
  -4.52622697e-02f, 5.90488948e-02f, -2.73665637e-02f, -5.36727235e-02f, -3.28627564e-02f, 5.84520549e-02f, -2.37571131e-02f, -7.34233335e-02f, 7.20974132e-02f, 5.42036556e-02f,
  -5.50334975e-02f, 6.40887469e-02f, -3.17309946e-02f, -1.13569498e-02f, -8.17392096e-02f, 2.64514163e-02f, 3.24111246e-02f, 1.27368877e-02f, -8.87257755e-02f, 8.15861970e-02f,
  -2.58889832e-02f, -8.12508687e-02f, 5.46153970e-02f, 5.68576083e-02f, 7.90317506e-02f, 5.83970826e-03f, 5.08794673e-02f, 5.15187159e-02f, 5.84684685e-02f, 4.89473678e-02f,
  3.99001613e-02f, -6.59666285e-02f, -2.36737709e-02f, 8.50271620e-03f, 1.63022580e-03f, 1.50293093e-02f, -3.37186679e-02f, -8.95899758e-02f, -4.27201688e-02f, -2.80858539e-02f,
  7.35348240e-02f, -1.84883419e-02f, -2.54501458e-02f, 4.30196263e-02f, -6.86929375e-02f, 3.27249281e-02f, -5.55675142e-02f, -3.91612351e-02f, 7.23065436e-02f, 4.04256880e-02f,
  4.12265398e-03f, 7.43761435e-02f, -5.66452593e-02f, 8.15888196e-02f, 3.82681750e-02f, 1.02240741e-01f, 1.39791961e-03f, 5.53561747e-03f, 7.01885223e-02f, 1.49544822e-02f,
  -9.70413238e-02f, 8.47849622e-02f, 8.56589600e-02f, -4.23548603e-03f, 5.20061515e-03f, -3.78569514e-02f, 1.95269343e-02f, 6.95840269e-02f, -4.46665511e-02f, 6.71945810e-02f,
  2.72508472e-01f, -2.39025578e-01f, 2.43441552e-01f, 2.43261814e-01f, 3.75049040e-02f, 8.23877081e-02f, 2.06161305e-01f, -1.70037493e-01f, -1.10623511e-02f, -1.98506549e-01f,
  -3.32245342e-02f, 1.22956619e-01f, -3.47297154e-02f, 5.86519353e-02f, 2.14725398e-02f, -1.44617796e-01f, -9.22210142e-02f, 9.01312828e-02f, 5.66909323e-03f, 5.03646359e-02f,
  1.13042720e-01f, -1.46712437e-01f, -5.59333758e-03f, -3.50006849e-01f, 7.42761493e-02f, -8.61777663e-02f, -4.02444638e-02f, 5.49678355e-02f, -5.42561002e-02f, 3.06257941e-02f,
  -1.02362663e-01f, 3.82142849e-02f, 8.08247775e-02f, 1.84093211e-02f, -1.42510962e-02f, 7.60278106e-02f, -3.26274224e-02f, 1.06380068e-01f, 4.72040363e-02f, -5.50995171e-02f,
  5.95108122e-02f, -3.68714556e-02f, 3.88570093e-02f, 4.21182737e-02f, 2.96142884e-02f, 1.87097732e-02f, -3.44023444e-02f, -3.28643247e-02f, -1.59588736e-02f, -1.59734786e-02f,
  9.61249322e-02f, -1.97095331e-02f, 8.51708651e-02f, 5.27336001e-02f, 7.62315392e-02f, 3.24772224e-02f, 8.20220336e-02f, 1.99132208e-02f, -4.97567989e-02f, -4.46237996e-02f,
  7.59538077e-03f, -9.84537750e-02f, -5.93165979e-02f, -5.04763797e-02f, -5.24957851e-02f, 3.65275337e-04f, -1.95116419e-02f, 3.68276499e-02f, -4.59033214e-02f, 6.51019067e-02f,
  3.02864984e-03f, 8.05477053e-02f, -5.48834354e-03f, -4.03702930e-02f, -4.73995358e-02f, 5.77833876e-02f, 1.17328018e-01f, -4.12201090e-03f, 7.49491453e-02f, -1.02058304e-02f,
  -3.94670218e-02f, 3.79653126e-02f, 3.30314711e-02f, -2.88972203e-02f, -7.48164207e-02f, -1.19329395e-03f, -3.81912291e-02f, 6.75008297e-02f, 7.78942332e-02f, 1.59245078e-02f,
  -2.46101677e-01f, -2.54778445e-01f, -9.58359390e-02f, -3.61201987e-02f, -4.55041938e-02f, -1.16289884e-01f, 7.80727342e-02f, -4.61688638e-02f, -5.96270226e-02f, -3.04357391e-02f,
  -1.44502250e-02f, 2.21149325e-02f, -7.52534643e-02f, 3.51929329e-02f, -2.68664397e-02f, -3.88241224e-02f, 8.80739093e-02f, 1.76526997e-02f, 9.12182033e-03f, -9.55233648e-02f,
  -4.21483219e-02f, 6.20456189e-02f, 7.64208436e-02f, -7.54218325e-02f, 1.63885280e-02f, -8.04518422e-05f, 4.44447994e-02f, 2.09621508e-02f, -3.85245541e-03f, -7.85733610e-02f,
  -1.72341436e-01f, -3.64897996e-02f, -1.81738496e-01f, -7.35358000e-02f, 1.73467800e-01f, 2.51504093e-01f, -8.26616362e-02f, 9.96416584e-02f, -2.03238979e-01f, 1.54390056e-02f,
  6.77688271e-02f, -3.68078947e-02f, -2.61153668e-01f, 1.51000932e-01f, 4.61517163e-02f, -8.51353481e-02f, 1.98131055e-01f, 1.59975584e-03f, 7.18906894e-03f, -4.90087867e-02f,
  6.55408576e-02f, 1.94481611e-01f, 2.31898446e-02f, 2.25329280e-01f, 3.34723340e-03f, 3.83431576e-02f, 4.57618907e-02f, 1.69020798e-02f, 1.57914594e-01f, 4.17199060e-02f,
  -2.55208351e-02f, -8.36208165e-02f, -3.88424955e-02f, -2.64632367e-02f, -1.22210369e-01f, -1.14089347e-01f, -1.03529587e-01f, 3.35062947e-03f, -7.92650059e-02f, 3.94594595e-02f,
  -1.19300708e-01f, 3.12536620e-02f, 7.41322413e-02f, 2.25150697e-02f, -6.38526380e-02f, -5.62346838e-02f, 6.65181130e-02f, -6.31845817e-02f, -6.39080703e-02f, 7.90427178e-02f,
  1.46039994e-02f, 6.47097751e-02f, -4.43853484e-03f, 9.84829962e-02f, 3.80721845e-04f, 9.54746269e-03f, -3.99076678e-02f, 2.85155587e-02f, 4.70676497e-02f, 6.02813251e-02f,
  8.46931189e-02f, -2.11521164e-02f, -6.70249946e-03f, -3.47356801e-03f, 5.90960868e-02f, -1.10602463e-02f, 6.11812398e-02f, -2.38184705e-02f, -3.52718942e-02f, 5.51407374e-02f,
  -5.51273115e-03f, 7.67383724e-03f, -6.61747232e-02f, 3.83956321e-02f, 5.23284785e-02f, -1.71492959e-03f, 2.44578216e-02f, 7.33255967e-02f, -6.14594445e-02f, 4.91723716e-02f,
  -8.13619792e-02f, 2.57181264e-02f, 3.03504243e-02f, 6.66053668e-02f, -1.61241170e-03f, 4.36638063e-03f, 6.42451197e-02f, -3.09972111e-02f, -1.25868078e-02f, -6.29919022e-02f,
  -1.48169339e-01f, -2.11750075e-01f, -5.98826744e-02f, -3.57640833e-02f, -6.65478632e-02f, -3.57084684e-02f, -1.36973131e-02f, 7.83184618e-02f, 1.31564392e-02f, -5.71655631e-02f,
  -6.69411346e-02f, 4.16352414e-02f, 8.25869516e-02f, -8.53493363e-02f, 1.34379938e-02f, -6.75408468e-02f, -8.67247060e-02f, -8.62674136e-03f, -6.76692054e-02f, -1.36405090e-02f,
  -2.95225885e-02f, -2.10512970e-02f, 2.57168543e-02f, 5.48660010e-02f, 4.98542450e-02f, 1.98325579e-04f, -4.83263880e-02f, 2.26058941e-02f, 8.30794647e-02f, -4.18661647e-02f,
  1.36803882e-03f, -9.69419181e-02f, 8.42426941e-02f, -1.45112500e-01f, -5.77017516e-02f, 5.28286472e-02f, 4.23941948e-02f, -1.17552385e-01f, 3.61305587e-02f, -4.78052534e-02f,
  -5.06885089e-02f, 1.74387559e-01f, 2.10047722e-01f, -1.75528407e-01f, 2.28134960e-01f, 1.92149907e-01f, -2.27315441e-01f, -8.95920917e-02f, -2.70699267e-03f, -6.78931326e-02f,
  -1.62456725e-02f, -1.63403556e-01f, 2.13957932e-02f, -1.66862637e-01f, -1.83952153e-01f, -1.32127166e-01f, -5.12550473e-02f, 9.23221856e-02f, -1.83391601e-01f, 1.97768081e-02f,
  -1.77159011e-01f, -1.03658400e-01f, -1.45303518e-01f, -6.58625886e-02f, -8.53501037e-02f, -1.14924513e-01f, 5.40822968e-02f, 7.23851323e-02f, 1.99577566e-02f, 3.31287757e-02f,
  1.06073529e-01f, -6.91488087e-02f, -1.04815848e-01f, 4.75456676e-04f, -8.01591426e-02f, -9.88678187e-02f, -3.14237960e-02f, -1.19616456e-01f, 6.65525422e-02f, 2.84445249e-02f,
  1.57902986e-02f, -5.31688519e-02f, -3.91673930e-02f, -4.81407642e-02f, -5.88472523e-02f, -5.53124547e-02f, -2.87701096e-02f, 6.17518835e-03f, -7.39495084e-02f, -8.94093364e-02f,
  4.46464028e-03f, 6.53696433e-02f, -3.94955203e-02f, 1.76709443e-02f, 7.20894188e-02f, -2.27985810e-02f, 7.79338107e-02f, -5.20870835e-02f, -7.76947215e-02f, 4.28568050e-02f,
  -2.26375386e-02f, 2.20591668e-02f, -9.76711661e-02f, 4.17417511e-02f, -6.02217205e-02f, -1.65494923e-02f, -5.15933447e-02f, 5.61960116e-02f, -4.33542393e-02f, -1.90962944e-02f,
  7.72048235e-02f, -4.14100513e-02f, 9.16158408e-03f, -3.00824903e-02f, -6.60283193e-02f, 1.89188961e-02f, 2.54954305e-02f, -1.75923482e-02f, 1.32124024e-02f, 2.82296762e-02f,
  -1.67558178e-01f, -1.32807001e-01f, -9.76371393e-03f, -2.61167949e-03f, 2.46861316e-02f, -3.67954746e-02f, -1.99372787e-03f, 4.24929447e-02f, -2.15067901e-02f, -2.25476697e-02f,
  -1.58845782e-02f, 2.30514575e-02f, -4.99541946e-02f, 3.74192633e-02f, 1.09065443e-01f, 2.83342344e-03f, 1.97889181e-04f, 5.31291366e-02f, -6.84286803e-02f, -5.34695797e-02f,
  -8.26668181e-03f, 5.78024006e-03f, -2.93921791e-02f, -8.77797138e-04f, -6.71977997e-02f, -3.16114053e-02f, 8.10987949e-02f, 1.08711934e-02f, -5.79831600e-02f, -1.37387086e-02f,
  5.23399226e-02f, 5.29851839e-02f, 4.65585142e-02f, 1.98632926e-01f, 8.79552215e-02f, 8.71621072e-02f, 9.00763944e-02f, 9.04118568e-02f, 3.14560950e-01f, -1.28610164e-01f,
  -6.29335642e-02f, 1.06868707e-02f, -5.84236765e-03f, 3.98726538e-02f, 5.60561307e-02f, 5.30727655e-02f, 1.40406638e-01f, 1.22551762e-01f, 2.03255326e-01f, 1.29464669e-02f,
  2.79087177e-03f, -1.32503761e-02f, -1.91542789e-01f, -1.43679425e-01f, -1.59354195e-01f, -5.50944954e-02f, -1.68936223e-01f, -7.75050148e-02f, -1.52317300e-01f, 8.07506293e-02f,
  2.28227824e-02f, 8.91443044e-02f, -8.09516162e-02f, -6.52000308e-02f, -2.88504381e-02f, -8.11566934e-02f, 7.69355819e-02f, -5.86715993e-03f, 6.53562769e-02f, 9.46514234e-02f,
  -3.21212932e-02f, 6.28631711e-02f, 6.80324659e-02f, -3.75370979e-02f, 4.94369753e-02f, -7.77633414e-02f, -3.81022096e-02f, -7.53407776e-02f, -3.25884447e-02f, -9.54177156e-02f,
  -1.08270034e-01f, -7.22329319e-02f, 7.09744841e-02f, 5.18153496e-02f, 3.75732258e-02f, -5.70566989e-02f, -3.50568742e-02f, 5.78134805e-02f, 9.50101457e-05f, -1.31431746e-03f,
  8.56885500e-03f, 6.83529973e-02f, -6.39568642e-02f, 6.72501251e-02f, 4.89632413e-03f, 2.31997063e-03f, -5.92251606e-02f, -4.51517366e-02f, 5.76239601e-02f, -3.59181501e-02f,
  3.67204733e-02f, -4.88021150e-02f, -1.20693650e-02f, -4.61539999e-03f, 2.91605331e-02f, -1.75205898e-02f, 5.39421197e-03f, 6.19891286e-03f, -2.48757116e-02f, -3.53008434e-02f,
  -3.27539593e-02f, -3.21487933e-02f, -8.42124894e-02f, -3.35690752e-02f, -6.59401016e-03f, 1.06823277e-02f, 4.58661355e-02f, 2.37933509e-02f, 2.46001817e-02f, -3.38996239e-02f,
  3.77897881e-02f, 1.31761819e-01f, 1.45622808e-02f, -5.00788912e-02f, 9.30374712e-02f, 3.11463326e-02f, 2.26191431e-02f, 7.13297129e-02f, 2.05765273e-02f, 5.31895459e-02f,
  -3.64400856e-02f, -2.02562418e-02f, -1.89660746e-03f, 2.24522185e-02f, 3.14518763e-03f, 5.63685931e-02f, 2.86660306e-02f, 7.85593241e-02f, -3.27581279e-02f, -3.74674462e-02f,
  2.05006432e-02f, 9.69004110e-02f, 3.19671780e-02f, -5.95275611e-02f, 4.74732742e-02f, 1.92822851e-02f, 4.52904925e-02f, -2.40380671e-02f, 2.40743440e-02f, 4.74558622e-02f,
  -1.00751668e-01f, 8.26260597e-02f, 2.29222432e-01f, 1.85948268e-01f, -3.58747877e-02f, -3.01159263e-01f, -2.91932404e-01f, 4.25253585e-02f, -1.05239898e-01f, -1.45593241e-01f,
  -1.20408148e-01f, 1.98091537e-01f, -2.16239661e-01f, 6.79140836e-02f, 1.03519313e-01f, -8.51995423e-02f, 5.18153347e-02f, -7.33707845e-02f, 5.12605943e-02f, 1.80052415e-01f,
  1.38312414e-01f, -4.17493321e-02f, 2.66258001e-01f, 1.56628177e-01f, 1.30752191e-01f, 1.93414718e-01f, 3.94423231e-02f, 2.01221853e-02f, 2.67382979e-01f, 3.31925899e-02f,
  3.34935002e-02f, 7.72995949e-02f, 4.00890298e-02f, -4.54117507e-02f, -5.39674088e-02f, -8.58726501e-02f, 9.09649879e-02f, -3.28512937e-02f, 4.33776602e-02f, -4.01332751e-02f,
  6.86586723e-02f, 5.21434657e-02f, 9.97193605e-02f, 4.67692240e-04f, 2.42162589e-02f, 9.64908749e-02f, 5.74982762e-02f, -5.21422401e-02f, 9.31781456e-02f, -3.05891316e-02f,
  -2.99053788e-02f, 8.54323879e-02f, 7.63584375e-02f, -4.11861055e-02f, 1.10655101e-02f, -6.98878169e-02f, 1.47490567e-02f, 4.53471392e-03f, 5.76569214e-02f, -2.34931391e-02f,
  -6.74979836e-02f, -3.25644836e-02f, -1.00383244e-01f, 6.57673031e-02f, -7.94788264e-03f, 2.98791081e-02f, -1.47824548e-02f, 3.57433967e-02f, 3.93282846e-02f, 1.28429960e-02f,
  8.28935504e-02f, 9.76139605e-02f, 4.93486822e-02f, 1.80928130e-02f, 1.56779494e-02f, 3.44239958e-02f, 7.85341933e-02f, -6.32202104e-02f, 2.88177887e-03f, 1.29758701e-01f,
  6.16162270e-02f, -4.95370440e-02f, 6.58258423e-02f, -5.63938692e-02f, -2.56005805e-02f, 2.26930678e-02f, 9.82090756e-02f, 8.50184262e-03f, 1.33817801e-02f, 3.12903672e-02f,
  -1.21952333e-01f, 1.39590159e-01f, 3.48906331e-02f, 4.26596850e-02f, -5.10758953e-03f, 3.03284843e-02f, -4.11106683e-02f, 7.40959272e-02f, -2.48942226e-02f, -7.83370435e-02f,
  1.15907732e-02f, 7.13319778e-02f, -7.68347159e-02f, -8.69576354e-03f, 4.08083573e-02f, -3.05318250e-03f, 4.09593172e-02f, 4.75270003e-02f, 2.21076445e-03f, 1.15281425e-01f,
  8.28841254e-02f, -1.32896462e-02f, -1.87998600e-02f, 3.28756347e-02f, 1.66775864e-02f, 5.09244241e-02f, 2.31141411e-02f, -5.48429228e-02f, -6.35049399e-03f, -2.51168758e-02f,
  1.54929534e-01f, 1.28565375e-02f, -7.42359832e-02f, -3.44321458e-03f, -8.50894526e-02f, -5.03862649e-02f, -1.11260243e-01f, -5.13398554e-03f, 9.96265039e-02f, 3.86515409e-02f,
  9.52265866e-04f, 1.53392786e-02f, -4.56131473e-02f, -1.21737979e-01f, 7.51620829e-02f, 1.55413657e-01f, 9.08676833e-02f, 8.44253674e-02f, -1.24660227e-02f, -2.03738678e-02f,
  -6.15952387e-02f, -1.46493599e-01f, -1.76539183e-01f, -1.42597556e-01f, -9.15843770e-02f, -1.26857400e-01f, -8.58910531e-02f, -1.22494541e-01f, -1.39871553e-01f, -1.42481446e-01f,
  -1.09871678e-01f, -2.07566172e-02f, -3.40287648e-02f, 1.90115515e-02f, 7.78848231e-02f, -9.85407755e-02f, -2.35521165e-03f, -1.11338437e-01f, -3.44898477e-02f, 9.48615447e-02f,
  6.90663308e-02f, 2.27710232e-02f, 9.01811570e-02f, 6.89195991e-02f, 5.85012287e-02f, -6.03071228e-02f, -6.63477331e-02f, -4.73099835e-02f, -1.37728704e-02f, 2.11938769e-02f,
  9.47561208e-03f, -4.01372463e-02f, -5.70241548e-02f, -1.25566302e-02f, 3.53740230e-02f, 5.23869731e-02f, 9.96376202e-02f, 9.76934005e-03f, -3.39183696e-02f, 7.16656633e-03f,
  4.90442738e-02f, 4.14125957e-02f, -3.19970697e-02f, 1.29014226e-02f, -8.69651362e-02f, -9.93413404e-02f, 2.07551960e-02f, 4.94463928e-02f, 3.79717760e-02f, 8.94157030e-03f,
  7.92578235e-02f, -2.25563180e-02f, -4.26441208e-02f, -6.32618880e-03f, 8.55483189e-02f, 8.26651528e-02f, 6.44518584e-02f, 7.42892846e-02f, -6.70216680e-02f, -7.45613948e-02f,
  -6.77368864e-02f, 7.26504698e-02f, -7.51365051e-02f, 4.57220003e-02f, 1.13741793e-02f, -1.86742060e-02f, -2.41803844e-03f, -2.82987114e-02f, -7.42491856e-02f, -4.72522043e-02f,
  1.14667818e-01f, 8.75186250e-02f, -5.02002314e-02f, -8.72281659e-03f, -7.71559253e-02f, -4.24165912e-02f, 5.23755625e-02f, 6.80141747e-02f, -3.82687040e-02f, -3.98230813e-02f,
  -4.65059876e-02f, 4.79043536e-02f, -1.26465727e-02f, 2.14959588e-03f, -2.02134792e-02f, -3.44770923e-02f, -6.56211842e-03f, -7.67114526e-03f, 4.25592884e-02f, -9.78438333e-02f,
  -8.16272944e-02f, 9.82660055e-02f, 4.76790667e-02f, 9.23657492e-02f, 2.23939139e-02f, 3.46706435e-02f, 3.55496891e-02f, 3.01555898e-02f, -4.07206379e-02f, -1.75103443e-04f,
  1.03732809e-01f, 2.32807934e-01f, 1.92990109e-01f, 1.13900587e-01f, -2.88974289e-02f, -1.88132212e-01f, -6.91116452e-02f, -5.16097434e-02f, -2.70533804e-02f, -4.27685753e-02f,
  4.64799106e-02f, 1.44393638e-01f, -5.28977178e-02f, 1.02687687e-01f, -3.34703624e-02f, 1.77158918e-02f, -6.08176291e-02f, -8.43275264e-02f, -3.08277011e-02f, -2.76194569e-02f,
  8.72755200e-02f, -1.52324468e-01f, 8.02447870e-02f, 6.13208376e-02f, 1.08091086e-01f, 1.79947272e-01f, -9.11203548e-02f, -2.82953270e-02f, -7.47112483e-02f, -5.70065267e-02f,
  5.28773665e-02f, 1.19375736e-01f, 1.55972308e-02f, 6.43993169e-03f, 4.05266248e-02f, 1.19814361e-02f, -4.05273922e-02f, 3.32474709e-02f, 4.94718105e-02f, -3.19174752e-02f,
  -5.47313690e-02f, -8.17851275e-02f, 6.10126108e-02f, 3.66203263e-02f, 6.05903640e-02f, -1.20114768e-02f, 3.95115875e-02f, 3.42738107e-02f, 5.08675650e-02f, 1.29098579e-01f,
  -1.06560234e-02f, -4.51465920e-02f, 6.47284314e-02f, -7.36789480e-02f, 2.28885282e-02f, 3.15617882e-02f, 2.99875773e-02f, 4.97427508e-02f, 4.58223149e-02f, -3.89473327e-03f,
  5.85922897e-02f, -9.08038840e-02f, -8.46252069e-02f, -2.87856674e-03f, -9.59029347e-02f, -1.37600610e-02f, -6.37038425e-02f, -6.76282272e-02f, -3.49319214e-03f, -2.28740647e-02f,
  -4.52530645e-02f, -3.77054326e-02f, -1.58026777e-02f, 1.09001733e-02f, -7.21966103e-02f, 2.47436594e-02f, 2.44052075e-02f, -8.89865905e-02f, -1.37952128e-02f, -5.54539412e-02f,
  -8.88724551e-02f, -1.45174935e-03f, 6.62378520e-02f, 8.94909054e-02f, 5.03475890e-02f, -1.55746704e-02f, 6.45588562e-02f, 4.01671529e-02f, 6.96004778e-02f, -2.80327592e-02f,
  -8.80845487e-02f, 5.30029610e-02f, -2.50621084e-02f, 4.47829440e-02f, -7.40423873e-02f, -8.75363275e-02f, -5.09028956e-02f, -3.38523984e-02f, -6.67995960e-02f, 4.99168634e-02f,
  -3.61463502e-02f, 2.40117833e-02f, 2.13063415e-02f, -5.07355854e-02f, -6.06127642e-03f, -5.63521311e-02f, 2.09617838e-02f, 1.01976991e-02f, -7.81852230e-02f, 8.13296065e-02f,
  2.04738770e-02f, -2.77981739e-02f, 2.07622629e-02f, -7.43136033e-02f, -9.06345099e-02f, -5.49562834e-02f, -2.95582134e-02f, 4.30004559e-02f, 6.66721836e-02f, 2.77143437e-02f,
  4.98624407e-02f, 4.62600263e-03f, -1.35297865e-01f, -1.79024428e-01f, -5.13807088e-02f, -4.90766764e-02f, -9.38406214e-02f, -4.44034301e-02f, -1.37661442e-01f, 4.57329154e-02f,
  1.66681055e-02f, -1.68884426e-01f, -2.87276716e-03f, -6.28813058e-02f, -9.39826593e-02f, -2.46701483e-02f, 3.40050273e-02f, -7.48978630e-02f, -3.62970866e-03f, 2.86954101e-02f,
  6.97497465e-03f, 8.40927660e-02f, 3.61696668e-02f, 8.54021981e-02f, 6.69151917e-02f, -6.89335391e-02f, -2.52815671e-02f, 7.07065985e-02f, -9.20743570e-02f, -7.57669955e-02f,
  -5.67585081e-02f, 2.16898695e-02f, -2.98656877e-02f, -5.14797978e-02f, 3.67930382e-02f, -8.49893410e-03f, -2.44835820e-02f, -8.04660618e-02f, -5.03569134e-02f, -2.67635901e-02f,
  1.36585943e-02f, -6.97966069e-02f, -6.69302195e-02f, 5.69735318e-02f, -2.11963300e-02f, 3.85836884e-02f, 3.92745696e-02f, 4.00781371e-02f, -2.55919038e-03f, -6.76764622e-02f,
  -2.17922106e-02f, 3.02772243e-02f, 5.97921051e-02f, 3.03217694e-02f, 2.58984808e-02f, 8.10720995e-02f, 2.66705714e-02f, 7.20913038e-02f, -7.61372373e-02f, -1.11428648e-01f,
  9.00165662e-02f, 8.05257633e-02f, -5.72489668e-03f, 6.83219656e-02f, -2.97603700e-02f, -1.23840487e-02f, 7.82990903e-02f, -7.53472373e-02f, -1.56596228e-02f, 2.58722696e-02f,
  1.25866691e-02f, 4.87076417e-02f, -8.16100687e-02f, -7.93265700e-02f, -1.79160219e-02f, 6.39756098e-02f, 3.83471213e-02f, 8.75997841e-02f, -2.70479266e-02f, 6.35260195e-02f,
  -1.51707663e-03f, 2.35153409e-03f, -9.58848819e-02f, 2.40339730e-02f, 3.49696260e-03f, 7.86474049e-02f, 6.67776614e-02f, 4.63489331e-02f, -7.14338124e-02f, -5.05345454e-03f,
  8.30171704e-02f, 6.18270971e-02f, -2.66832467e-02f, 1.12536727e-02f, -2.64742761e-03f, -5.51363640e-02f, -3.10104340e-02f, 1.87968183e-02f, -6.49011582e-02f, -4.59819473e-02f,
  -3.37702744e-02f, -7.31770471e-02f, -3.46175283e-02f, 8.44472460e-03f, -9.66274664e-02f, -3.67733836e-02f, -1.32659515e-02f, -1.09174527e-01f, -8.32369551e-03f, -3.83358300e-02f,
  6.88574687e-02f, -2.50487751e-03f, 3.57685640e-04f, -9.80071723e-02f, -1.47857517e-02f, -8.52220505e-02f, -7.50567243e-02f, -6.74330965e-02f, 9.07394141e-02f, 1.37284379e-02f,
  -3.27904403e-01f, 3.09723705e-01f, -7.59407207e-02f, -5.45759983e-02f, 1.11979850e-01f, 1.40723467e-01f, 1.43121220e-02f, 2.46520601e-02f, -5.04031070e-02f, 8.04713145e-02f,
  1.55713916e-01f, -3.74556221e-02f, 6.06688298e-02f, 3.04521266e-02f, -6.94199651e-02f, 2.45277762e-01f, 1.35530159e-01f, 8.86072516e-02f, 8.00565407e-02f, -4.52724211e-02f,
  3.09465118e-02f, 1.23432219e-01f, 8.47205296e-02f, 1.48014486e-01f, -3.90582867e-02f, -1.76091805e-01f, 7.10736669e-04f, -3.16266418e-02f, 3.49604972e-02f, -3.21604423e-02f,
  -4.67768963e-03f, -1.12329558e-01f, 3.68146449e-02f, -4.13648151e-02f, 2.12293421e-03f, -7.04284832e-02f, -7.33235404e-02f, 4.29877304e-02f, -3.72551009e-02f, 3.79226245e-02f,
  -2.97916047e-02f, -5.04139885e-02f, -2.39388887e-02f, -8.66635591e-02f, -1.80957634e-02f, 4.13417853e-02f, 6.21221587e-02f, 3.98164466e-02f, -3.86681966e-02f, 1.01592958e-01f,
  -4.42121224e-03f, 4.49411124e-02f, -3.40821110e-02f, 1.86345242e-02f, -4.32083569e-02f, -5.56615591e-02f, -1.58945639e-02f, -5.54145016e-02f, -8.08988884e-02f, 2.41774600e-03f,
  -1.06446654e-01f, -1.08127125e-01f, -3.30445692e-02f, 5.06939687e-05f, 5.50690442e-02f, -4.85891178e-02f, -4.73118052e-02f, 6.25227615e-02f, -5.06441742e-02f, 7.45176151e-02f,
  -2.88360454e-02f, -7.01333135e-02f, 3.42030637e-02f, 8.19323678e-03f, -7.85459019e-03f, -4.20754217e-02f, -7.78952613e-02f, -5.28743304e-02f, -5.52942939e-02f, -5.96289709e-03f,
  -5.14256023e-03f, -1.31152589e-02f, -4.28734068e-03f, 1.16046844e-02f, 2.44989935e-02f, -1.72446687e-02f, 3.48954499e-02f, 5.84364682e-03f, 3.10132559e-02f, -8.55978020e-03f,
  -1.48157589e-03f, -1.41205207e-01f, 1.92523107e-03f, 5.02853468e-02f, 4.39254604e-02f, 7.41871372e-02f, 6.94425926e-02f, -8.57431889e-02f, -2.90336250e-03f, -8.95094648e-02f,
  -5.18761575e-02f, 2.15129163e-02f, 8.55785329e-03f, 1.18867857e-02f, -8.24512690e-02f, 9.64890197e-02f, 1.15718488e-02f, -6.91054985e-02f, 4.28886600e-02f, -5.41449934e-02f,
  -1.73468813e-02f, -4.09382768e-02f, 5.07660843e-02f, 4.40547876e-02f, 8.77047144e-03f, -2.77944542e-02f, -4.67373729e-02f, 4.73323688e-02f, 3.62450583e-03f, 1.94680840e-02f,
  -7.56654069e-02f, -2.67777424e-02f, 3.01544778e-02f, -9.08145383e-02f, 1.03735812e-01f, 1.08973585e-01f, 1.89019814e-02f, 7.34354854e-02f, 5.46110086e-02f, -2.89313942e-02f,
  -3.71408998e-03f, 3.42515297e-02f, 1.51016831e-01f, -6.12879433e-02f, 2.23123729e-02f, 8.18956718e-02f, -5.51409461e-02f, 3.80427651e-02f, -2.81865336e-03f, -7.67984539e-02f,
  -4.37933989e-02f, 1.30378744e-02f, 1.29628092e-01f, 8.87967572e-02f, 7.57308155e-02f, -5.51138781e-02f, -1.03485137e-01f, 1.83262095e-01f, -6.85760230e-02f, 5.99970333e-02f,
  -2.79205050e-02f, 3.39573584e-02f, 8.70221108e-03f, 9.70662236e-02f, -8.93569142e-02f, -8.40164647e-02f, 8.39853212e-02f, -2.46766061e-02f, -7.67242461e-02f, 2.27340907e-02f,
  1.58196315e-02f, 7.34055266e-02f, -1.04759904e-02f, 4.92641628e-02f, 4.51072566e-02f, 4.10747193e-02f, 2.88356934e-02f, -2.48771906e-02f, 7.04627186e-02f, 1.93799492e-02f,
  -4.04025353e-02f, -4.93886136e-02f, 3.34397815e-02f, 4.83705848e-02f, -2.59244945e-02f, -7.74974450e-02f, 5.53577021e-02f, 6.88285008e-02f, 1.04162004e-02f, 2.02386938e-02f,
  -2.78278217e-02f, -4.59459908e-02f, -2.24484131e-02f, -3.79159302e-02f, -3.87980565e-02f, -1.88461412e-02f, -7.18192011e-03f, -2.53758766e-02f, -4.86182757e-02f, -7.72750229e-02f,
  1.47399176e-02f, 7.26390705e-02f, 4.25409451e-02f, 6.00505359e-02f, -3.70965190e-02f, -8.94765649e-03f, 5.61724231e-02f, -5.06362319e-02f, -3.64822447e-02f, -1.64429937e-02f,
  5.58779463e-02f, -2.68915459e-03f, 2.59390776e-03f, -2.60738824e-02f, -1.61604502e-03f, -1.94104314e-02f, -1.84711851e-02f, -7.48320296e-02f, 9.26860273e-02f, 2.21222136e-02f,
  -1.36537597e-01f, 4.04770207e-03f, 7.10585043e-02f, -1.66971311e-02f, 3.94990370e-02f, -1.10227428e-03f, -4.72159535e-02f, -9.16211978e-02f, 8.24882612e-02f, 9.44646597e-02f,
  3.53743955e-02f, 4.49955240e-02f, 1.14512239e-02f, -2.53071301e-02f, -5.91434054e-02f, -2.40987800e-02f, -9.87757072e-02f, 9.55747068e-03f, -3.17369355e-03f, 2.26961989e-02f,
  3.73945348e-02f, 2.41878107e-02f, 1.34402290e-02f, 6.67498782e-02f, -3.07037514e-02f, -7.23974854e-02f, -1.07309058e-01f, -2.30060220e-02f, -2.33683717e-02f, -6.86843023e-02f,
  1.18809856e-01f, -2.34758910e-02f, 1.86607577e-02f, 1.26727104e-01f, -6.84160292e-02f, -2.30412092e-03f, -3.83998714e-02f, 8.33591819e-02f, -1.14445975e-02f, 8.13055038e-03f,
  5.94373867e-02f, -2.95786876e-02f, 9.15231332e-02f, 9.36948955e-02f, 1.01198569e-01f, -1.61218103e-02f, 1.29195645e-01f, -9.86202434e-02f, 6.28836900e-02f, 1.65791944e-01f,
  -2.33777463e-02f, 8.54302645e-02f, 1.07819252e-01f, 5.20920455e-02f, 2.68615633e-02f, -6.84090331e-02f, 1.38761580e-01f, -1.97589416e-02f, -1.58442594e-02f, -8.19962844e-03f,
  7.40097277e-03f, 4.49768715e-02f, 6.55480614e-03f, -1.89877674e-02f, -5.06812856e-02f, 2.00669803e-02f, -5.84587045e-02f, 2.59104632e-02f, -1.00621888e-02f, -3.30277309e-02f,
  -3.37930433e-02f, -6.35782555e-02f, -2.58586071e-02f, -6.29408509e-02f, -2.41177287e-02f, 2.02367245e-03f, -7.23862126e-02f, -8.78685862e-02f, -1.57385133e-02f, 9.56499279e-02f,
  -1.23756034e-02f, -2.72833835e-02f, -5.55398054e-02f, -8.73097107e-02f, 8.40962026e-03f, -6.83920234e-02f, 7.25485086e-02f, -1.11698154e-02f, -3.02879419e-02f, 3.91638465e-03f,
  4.65831347e-02f, -3.01926825e-02f, 6.84638545e-02f, 2.49391012e-02f, 7.44097605e-02f, -3.77976112e-02f, 6.45831078e-02f, -1.00760376e-02f, 3.84763628e-02f, 6.54574903e-03f,
  -6.58247247e-02f, -2.89812330e-02f, -5.24287671e-02f, -1.00869618e-01f, -2.00953949e-02f, -4.14652191e-02f, -3.66162285e-02f, 3.44347358e-02f, -4.21332978e-02f, 5.14963008e-02f,
  -4.04554345e-02f, 1.06125269e-02f, -3.31785418e-02f, 1.05720095e-03f, -8.45476463e-02f, 6.85203224e-02f, -3.58967222e-02f, 8.16888511e-02f, 6.04975037e-02f, 3.12620476e-02f,
  6.97059780e-02f, 5.02519682e-02f, -4.82588680e-03f, -6.22414835e-02f, 6.34357929e-02f, -4.47466150e-02f, -3.49000208e-02f, 2.36868337e-02f, 8.27250928e-02f, -2.16380041e-02f,
  5.05097955e-02f, 1.69803277e-02f, -5.12462892e-02f, 3.76443355e-03f, 3.59685272e-02f, 1.05499990e-01f, 7.90875871e-03f, -3.21446769e-02f, 7.62074515e-02f, 4.13994826e-02f,
  4.94553745e-02f, -4.47286405e-02f, 7.44303241e-02f, 2.42279805e-02f, 7.11476579e-02f, 9.54275113e-03f, 1.62322670e-02f, -2.14531999e-02f, -2.76472084e-02f, 6.19361224e-03f,
  -1.88813314e-01f, 6.70972001e-03f, -1.21090055e-01f, -8.73782337e-02f, 1.17654763e-01f, -1.24636054e-01f, -1.06965058e-01f, 7.44840503e-02f, -1.64151758e-01f, 1.26183331e-01f,
  7.21257702e-02f, -1.83148146e-01f, -5.75992092e-02f, -2.06409350e-01f, -1.16024233e-01f, -1.84793234e-01f, -2.02032462e-01f, -1.32859677e-01f, -1.08415961e-01f, -3.25315073e-02f,
  -9.03282613e-02f, 5.24253808e-02f, -2.66359262e-02f, 1.79908350e-01f, 3.13183889e-02f, 1.11315131e-01f, 2.64376760e-01f, 1.34152338e-01f, 1.27046809e-01f, 7.19353482e-02f,
  -1.35343224e-01f, 3.27335335e-02f, 2.96261646e-02f, -1.85811799e-02f, -6.17257990e-02f, 6.80635795e-02f, 7.60157928e-02f, 2.92331539e-02f, 4.73366417e-05f, -8.48469064e-02f,
  5.64256646e-02f, -5.47552528e-03f, 3.36969458e-02f, 6.06143139e-02f, -5.77007607e-02f, 4.88177985e-02f, -1.40313283e-02f, -7.81578496e-02f, -1.97978839e-02f, -1.12709943e-02f,
  -9.86521393e-02f, -1.95408687e-02f, 5.17377071e-02f, -2.72801723e-02f, 2.53575854e-03f, 4.07701991e-02f, 4.42302451e-02f, 6.01688214e-02f, 4.64835763e-02f, 2.22171526e-02f,
  6.32455796e-02f, -4.29487303e-02f, -8.61708820e-02f, -3.07702329e-02f, -3.64269130e-02f, 7.80202225e-02f, -3.59380385e-03f, 1.29642375e-02f, 1.49066681e-02f, 6.93004876e-02f,
  9.43137929e-02f, -6.05427362e-02f, 1.74181592e-02f, 2.94328900e-03f, -4.44710813e-02f, -6.48765191e-02f, 8.93592733e-05f, -1.03703262e-02f, -8.46110005e-03f, -9.06571820e-02f,
  3.19833262e-03f, 6.27103075e-03f, -3.99373099e-02f, 7.02107847e-02f, 9.22571681e-03f, -4.36221994e-02f, -1.45264715e-03f, -9.75409523e-02f, 5.13640419e-03f, -1.89111754e-02f,
  1.23628423e-01f, 1.30405664e-01f, -1.39584029e-02f, 5.42558581e-02f, 6.19380316e-03f, -6.42936230e-02f, -5.13286479e-02f, 1.06316023e-02f, -2.23998539e-03f, -1.73292663e-02f,
  8.07463974e-02f, 1.12353843e-02f, 7.78801367e-02f, -2.45940275e-02f, 1.70618370e-02f, 4.16773558e-02f, 9.85001549e-02f, 5.93519807e-02f, 7.45242238e-02f, 9.53254465e-04f,
  8.47689658e-02f, -1.82667803e-02f, 4.61155437e-02f, -4.73721884e-02f, 7.53433853e-02f, -1.76577661e-02f, -5.93659393e-02f, -5.22430874e-02f, 7.22732395e-02f, 1.81717891e-02f,
  -3.03954948e-02f, 5.98651581e-02f, 2.12496355e-01f, 4.32190672e-02f, 9.80500411e-03f, 1.02793694e-01f, 9.27254781e-02f, 1.47192433e-01f, 2.91706026e-01f, -1.36198968e-01f,
  -1.00035064e-01f, -5.15554892e-03f, 3.16509232e-02f, -3.81349400e-02f, -7.83145055e-02f, -2.03641709e-02f, 1.29351884e-01f, -6.45801052e-02f, 7.47785345e-02f, -4.03006189e-03f,
  9.01274905e-02f, -1.79778576e-01f, -4.20433953e-02f, -1.43310636e-01f, 9.10207257e-02f, 2.96216141e-02f, -2.12685704e-01f, -3.91956419e-02f, -7.55674541e-02f, -3.65465656e-02f,
  2.20540464e-02f, 1.35523662e-01f, 1.11419305e-01f, 6.82237074e-02f, -3.90892401e-02f, -2.85945553e-02f, -8.84259641e-02f, -1.74276046e-02f, 1.05506383e-01f, 1.06255665e-01f,
  -4.58915941e-02f, -6.12831078e-02f, -7.02417791e-02f, -6.94088265e-02f, 2.73694079e-02f, -3.32134441e-02f, 8.78203735e-02f, 5.33653051e-02f, -8.99643986e-04f, -2.27909889e-02f,
  6.64510280e-02f, -5.52054755e-02f, 6.96211085e-02f, -7.52270296e-02f, -5.46206422e-02f, 5.14788516e-02f, 8.70006680e-02f, -7.87546262e-02f, -6.38610646e-02f, -2.65762452e-02f,
  -4.38099308e-03f, 6.79175258e-02f, 4.80860695e-02f, 7.03077763e-02f, -3.81408595e-02f, 1.88899413e-02f, 3.85908497e-04f, -3.85257736e-04f, -5.19773774e-02f, 5.38562909e-02f,
  -6.01354279e-02f, -6.80641830e-02f, -2.96523832e-02f, 3.37877385e-02f, -1.38403270e-02f, 7.03467429e-02f, -4.15545851e-02f, -2.56896168e-02f, 1.32390290e-01f, -4.99348491e-02f,
  3.11777182e-02f, -8.43925104e-02f, 2.14029569e-02f, -1.11975735e-02f, -1.38939209e-02f, 1.44286007e-02f, -5.51385619e-02f, -3.42662968e-02f, -3.28645706e-02f, -3.52714807e-02f,
  -5.16203716e-02f, -8.91960934e-02f, 5.98984808e-02f, 2.65775733e-02f, -9.83799547e-02f, 1.58703350e-03f, -7.36267641e-02f, 3.90674993e-02f, -1.51446564e-02f, -1.84976328e-02f,
  3.42823602e-02f, 6.07258938e-02f, 2.07082462e-02f, -7.84781203e-02f, -5.97248562e-02f, 5.15444130e-02f, -8.01457837e-02f, 6.50842935e-02f, -4.03531976e-02f, 5.50991632e-02f,
  3.16734798e-02f, -5.27943065e-03f, -2.28204597e-02f, 1.05697542e-01f, 1.41940417e-03f, 2.67855357e-02f, 2.44523250e-02f, -9.76770371e-03f, 2.23092008e-02f, 8.49358812e-02f,
  -5.20015992e-02f, -3.75679322e-02f, -3.11791729e-02f, 1.17530383e-01f, -2.99231019e-02f, -5.23756705e-02f, 9.52279121e-02f, 1.54969818e-03f, 1.33677647e-01f, -7.30816647e-02f,
  -5.12495153e-02f, 1.61299277e-02f, 1.99719463e-02f, 6.50360659e-02f, -5.70795033e-03f, 4.20262711e-03f, 1.51816651e-01f, -6.84012473e-02f, 6.91362545e-02f, -5.68122556e-03f,
  -6.24947064e-03f, -1.44096510e-02f, -2.44270116e-02f, -8.72848257e-02f, -6.29521310e-02f, 3.86888608e-02f, 4.29189876e-02f, 2.99818795e-02f, -5.60626760e-03f, 9.87713709e-02f,
  -5.66629646e-03f, -7.46570155e-03f, -6.27464652e-02f, 3.71438265e-02f, 8.17511454e-02f, -2.30284370e-02f, -6.68814927e-02f, -5.56266904e-02f, 9.88412648e-02f, 2.18977407e-02f,
  2.27496047e-02f, -8.11188594e-02f, -5.62421307e-02f, -6.32455423e-02f, -4.59869578e-02f, -9.06910654e-03f, 1.23467315e-02f, 7.63244927e-02f, 2.48198723e-03f, 5.83882779e-02f,
  -5.54427803e-02f, 2.68190503e-02f, 3.12065743e-02f, 8.81503597e-02f, 3.96196684e-03f, 4.09849361e-02f, 1.48965502e-02f, 6.09989166e-02f, 6.20649457e-02f, 7.58937970e-02f,
  -3.82841714e-02f, 8.57783929e-02f, -6.73754737e-02f, -7.48510286e-02f, -4.94075082e-02f, -7.48889074e-02f, 5.18668145e-02f, -1.46416342e-02f, 5.99752776e-02f, -4.73404750e-02f,
  -7.84384087e-02f, -7.13263825e-02f, 8.44278187e-02f, 4.14479617e-03f, 3.30628343e-02f, -8.35610554e-02f, 2.21964717e-02f, -5.70191033e-02f, -7.28322519e-03f, -9.36334059e-02f,
  6.35476410e-02f, -4.18579541e-02f, 2.76622791e-02f, 1.48372655e-03f, 1.28307678e-02f, 1.99641474e-02f, -4.70224246e-02f, -1.85332764e-02f, 4.88381870e-02f, -3.12776715e-02f,
  1.13652259e-01f, 1.09303132e-01f, 9.47074518e-02f, -6.65475503e-02f, 1.53894778e-02f, 1.01302611e-02f, -3.26241180e-02f, 7.16827363e-02f, 1.19652823e-01f, -5.15694963e-04f,
  4.26257253e-02f, 3.72136571e-02f, 6.78995773e-02f, -6.88024163e-02f, 8.35488215e-02f, -5.59534580e-02f, 7.73294121e-02f, 6.65437356e-02f, 7.34740077e-03f, 5.15789725e-02f,
  6.08544145e-03f, -2.12557577e-02f, 5.64392358e-02f, -5.03346808e-02f, -8.70389119e-03f, 3.92247774e-02f, 8.01145360e-02f, 1.07863778e-02f, -5.43943644e-02f, 3.30455154e-02f,
  -3.38896513e-02f, -6.70130029e-02f, -1.41802076e-02f, -1.23001717e-01f, 9.38080028e-02f, 8.25279800e-04f, -6.90606236e-02f, -1.97219569e-02f, -6.36242330e-02f, 1.03027686e-01f,
  -6.42655492e-02f, -9.58217382e-02f, -1.36538163e-01f, -9.15736929e-02f, -1.15709379e-02f, -1.01161815e-01f, -3.07140630e-02f, -1.47559727e-02f, -6.97274283e-02f, -9.72737148e-02f,
  1.68615617e-02f, -2.44179508e-03f, -1.65113702e-01f, -3.64160389e-02f, 7.28385821e-02f, -4.11999598e-02f, 1.20011672e-01f, 1.38715506e-02f, 5.73092774e-02f, -5.24433143e-02f,
  -6.01472035e-02f, 5.31723388e-02f, -4.10607941e-02f, -8.81121382e-02f, 1.74979549e-02f, 1.07019432e-02f, 4.00824621e-02f, -1.16072865e-02f, -1.75854284e-02f, 1.34977438e-02f,
  -2.51064301e-02f, -3.11292103e-03f, -5.71921952e-02f, 8.18853155e-02f, -6.15342222e-02f, 2.69630682e-02f, 1.19560352e-02f, 4.04751264e-02f, 1.48333581e-02f, -4.24549840e-02f,
  -8.65924582e-02f, 2.52455883e-02f, 8.31396580e-02f, -5.74432313e-02f, 3.42852734e-02f, -4.04809676e-02f, 7.71826506e-02f, -5.05290478e-02f, 5.24516031e-02f, 7.52773806e-02f,
  3.93889323e-02f, 2.78762970e-02f, 6.03524372e-02f, -9.15944949e-03f, -4.76144850e-02f, 3.88278030e-02f, 3.24602351e-02f, -6.17552213e-02f, 4.52101827e-02f, 2.23956127e-02f,
  2.28418838e-02f, 7.07570389e-02f, -6.30563945e-02f, -8.66904780e-02f, -3.99288051e-02f, -1.55779654e-02f, -5.82459010e-02f, -2.30653826e-02f, -3.93545516e-02f, 4.95897084e-02f,
  6.34044111e-02f, -1.66306477e-02f, 7.01093450e-02f, -4.10450771e-02f, 5.97035475e-02f, 1.65701825e-02f, 2.33942289e-02f, 3.66393700e-02f, -6.94236457e-02f, 1.01551652e-01f,
  -1.75869949e-02f, 7.94140026e-02f, -1.65605359e-02f, 1.87779926e-02f, 5.88366501e-02f, 4.83691916e-02f, 5.22202775e-02f, 9.11399201e-02f, 5.42509258e-02f, 5.83208678e-03f,
  3.53198908e-02f, 7.88498297e-02f, 1.20984077e-01f, -7.22475350e-02f, -5.53760640e-02f, 3.13153490e-02f, 4.16240618e-02f, 3.20356116e-02f, 1.04754239e-01f, -2.05109790e-02f,
  4.21767235e-02f, 3.47945094e-02f, 1.19692124e-02f, -2.43522078e-02f, -5.82599491e-02f, 9.19824839e-02f, 5.06388843e-02f, -8.72621909e-02f, 1.27616711e-02f, 3.10752708e-02f,
  -2.63713747e-01f, 1.34813398e-01f, -3.20644602e-02f, -5.64991497e-02f, -1.57114029e-01f, -1.60254285e-01f, 5.22202067e-02f, -2.09977105e-02f, 1.03990614e-01f, 2.01068848e-01f,
  2.21925855e-01f, -1.08836815e-01f, 7.51596466e-02f, 3.06113511e-01f, -1.60478786e-01f, 1.53404638e-01f, 1.62364125e-01f, 9.15530995e-02f, -1.07179978e-03f, -7.62936026e-02f,
  -1.48736656e-01f, 1.05552278e-01f, 2.53531840e-02f, 5.27433679e-02f, -1.33790793e-02f, -5.77845164e-02f, 6.82767332e-02f, -7.69544616e-02f, 1.25324607e-01f, -7.24094212e-02f,
  -1.19514182e-01f, -6.59762695e-02f, -6.84304759e-02f, 6.45899400e-03f, -5.38406614e-03f, -1.10349888e-02f, 1.64047293e-02f, -8.02213028e-02f, -4.12962064e-02f, 2.92575080e-02f,
  -1.19406119e-01f, 1.78958606e-02f, 5.25185317e-02f, -2.30281875e-02f, -5.51834181e-02f, 7.76743442e-02f, 9.54586454e-03f, 6.02642484e-02f, 5.93611365e-03f, -9.61537883e-02f,
  -2.03848031e-04f, -6.11185357e-02f, -5.13859726e-02f, -9.96390544e-03f, 1.27119175e-03f, -1.16839958e-02f, 8.23919699e-02f, -9.46018994e-02f, -1.31810468e-03f, -9.38909873e-02f,
  3.12255304e-02f, 6.25104606e-02f, -3.66226323e-02f, -3.70825641e-02f, 4.62935567e-02f, 3.89141701e-02f, 4.80611473e-02f, 7.86227062e-02f, -6.86650164e-03f, 3.27837246e-04f,
  9.57931299e-03f, 5.87501228e-02f, -6.04300499e-02f, -2.67045461e-02f, -1.54322414e-02f, 3.70558649e-02f, -4.42920849e-02f, -6.24942221e-03f, 6.58294335e-02f, 9.05009080e-03f,
  -9.62610841e-02f, 2.32584849e-02f, 5.58831617e-02f, -1.07947653e-02f, 5.57367690e-02f, 1.77768022e-02f, 8.93417224e-02f, 5.63588217e-02f, -4.25720960e-02f, 3.93909067e-02f,
  -5.19769602e-02f, -2.06551477e-01f, -7.23972544e-02f, -7.07580298e-02f, 3.15864868e-02f, -3.53445075e-02f, 8.47949386e-02f, -9.07375142e-02f, -9.63686779e-02f, 9.69119743e-03f,
  5.26579935e-03f, 6.55849651e-02f, -2.42479127e-02f, -4.48619798e-02f, -3.18698003e-03f, 9.60767046e-02f, -3.50042768e-02f, 2.19394527e-02f, -7.99911171e-02f, -2.01121680e-02f,
  1.59411356e-02f, -2.33567469e-02f, -7.00245798e-02f, -1.07794032e-01f, 3.47806253e-02f, 6.92546517e-02f, 3.49690244e-02f, 1.97352786e-02f, 5.38060591e-02f, 8.24944302e-02f,
  3.53699289e-02f, -1.15291111e-01f, 3.70495766e-03f, 1.15184806e-01f, 4.27666232e-02f, 9.44425911e-02f, 1.43034548e-01f, -7.06325546e-02f, -7.04795495e-02f, 9.58451033e-02f,
  1.61828436e-02f, -7.30635598e-02f, 1.03579782e-01f, 3.01921777e-02f, -2.55877282e-02f, 8.68336484e-02f, 9.13577527e-02f, 1.39827371e-01f, -1.01902157e-01f, -7.38855973e-02f,
  1.43905049e-02f, 1.78175885e-02f, 1.06396385e-01f, -1.69174060e-01f, -4.95013967e-02f, -1.43508151e-01f, 7.27596581e-02f, -4.14650366e-02f, -5.35984859e-02f, 7.33993500e-02f,
  -6.60664290e-02f, -6.74805045e-02f, 3.60973040e-03f, -5.44405654e-02f, -1.02645963e-01f, -7.48253241e-02f, 1.25299513e-01f, 5.55766746e-02f, -9.46605876e-02f, -4.53606360e-02f,
  -6.48384318e-02f, 5.10231480e-02f, -4.71846014e-02f, 3.61982873e-03f, 5.15320860e-02f, 3.76304351e-02f, -1.09623797e-01f, 5.45498133e-02f, 7.28911832e-02f, -9.91200507e-02f,
  8.95612389e-02f, 5.63364625e-02f, 3.23035084e-02f, 4.85697389e-02f, 7.77422339e-02f, 6.16142862e-02f, 5.05587645e-02f, -2.81529054e-02f, -9.31672677e-02f, -7.41239563e-02f,
  -5.26924655e-02f, 7.02350289e-02f, 5.70963100e-02f, 2.32393946e-02f, -1.06697768e-01f, -3.21012661e-02f, -1.73993818e-02f, 5.18622622e-03f, 3.98150645e-02f, 1.06095979e-02f,
  -4.90973517e-02f, 6.06803573e-04f, 2.99695209e-02f, 2.62416508e-02f, 8.30320865e-02f, 6.12616837e-02f, 5.71074411e-02f, 9.55213699e-03f, -4.84549589e-02f, 7.46321529e-02f,
  -9.81868152e-03f, -8.89403448e-02f, -8.71564671e-02f, 9.11738798e-02f, -5.88606708e-02f, -3.18956189e-02f, -8.23072344e-02f, -2.61690021e-02f, 9.69113857e-02f, 4.75548990e-02f,
  -6.97317943e-02f, -7.62665868e-02f, -8.56339708e-02f, -7.71500692e-02f, 1.49150752e-02f, -2.29997132e-02f, -8.22967105e-03f, 3.35028619e-02f, 6.20275401e-02f, 6.81947842e-02f,
  -4.67181243e-02f, 6.44656122e-02f, -3.12780105e-02f, -4.30684872e-02f, 1.59881706e-03f, -8.47687572e-02f, -1.36937592e-02f, -3.89352720e-03f, -6.10714080e-03f, -9.34493914e-02f,
  6.20889068e-02f, -2.39998288e-02f, 2.52752118e-02f, 1.00576788e-01f, 6.23459695e-03f, 4.04748172e-02f, -8.42254085e-04f, -6.12133257e-02f, 6.23621903e-02f, 4.69213538e-02f,
  -9.76465046e-02f, -9.42360684e-02f, 2.00037986e-01f, -1.74963042e-01f, -3.06597687e-02f, 2.01482743e-01f, 1.14689969e-01f, -7.27339685e-02f, -1.48169219e-01f, -1.01470873e-01f,
  -9.65281129e-02f, -3.40819471e-02f, 9.12737846e-02f, -4.56398278e-02f, 2.10273638e-01f, 3.53284441e-02f, 4.64164279e-02f, -1.05079508e-03f, -5.82745746e-02f, -1.40744483e-03f,
  -1.14214178e-02f, -3.69433686e-02f, 9.94254500e-02f, -4.39010151e-02f, -1.55843124e-02f, -1.72778666e-01f, -6.78902715e-02f, 1.19496152e-01f, -1.42057523e-01f, 7.51689896e-02f,
  -8.47583786e-02f, -5.34447581e-02f, 4.95864153e-02f, 7.40571842e-02f, 4.06177109e-03f, 3.42570841e-02f, 5.46842292e-02f, 9.33391321e-03f, -4.00498509e-02f, 4.90559787e-02f,
  9.34977382e-02f, 1.86706949e-02f, -8.27407986e-02f, 7.77934641e-02f, 5.33049218e-02f, 7.55878817e-03f, -9.86726806e-02f, 1.46117853e-02f, -1.53816142e-03f, -1.35778217e-02f,
  5.63133061e-02f, 3.72661874e-02f, 4.10741568e-03f, -1.47220576e-02f, -8.08913261e-02f, 5.26438514e-03f, 5.97006716e-02f, 8.52140889e-04f, 9.58232284e-02f, 3.03335339e-02f,
  -4.24057320e-02f, 2.78790332e-02f, -6.16799966e-02f, 3.19646858e-02f, -1.46534937e-02f, -3.89270969e-02f, -4.89383191e-02f, 1.02537256e-02f, 2.45014895e-02f, -1.43647520e-03f,
  3.33000198e-02f, -8.57108831e-02f, 1.56321861e-02f, 3.01605668e-02f, -4.79205512e-02f, -7.41683319e-02f, 9.22572911e-02f, -7.54370093e-02f, 4.29823324e-02f, -4.52845916e-02f,
  -5.20977303e-02f, 4.23170105e-02f, -7.11703226e-02f, -9.80791375e-02f, 1.04918769e-02f, 7.85444339e-04f, -7.59877712e-02f, -2.74117421e-02f, -8.02578628e-02f, 7.64366686e-02f,
  -8.26651976e-02f, 4.77084108e-02f, -6.01162240e-02f, 5.91405705e-02f, 5.11508249e-02f, 3.02687613e-03f, -1.74649397e-03f, -8.82931128e-02f, 5.42157479e-02f, 4.71250042e-02f,
  4.62809810e-03f, 7.55978301e-02f, 7.60895535e-02f, 1.10110091e-02f, 2.24331859e-02f, -4.72698361e-02f, -2.68261712e-02f, -4.92279641e-02f, -3.73464786e-02f, -3.48027423e-02f,
  -6.82624504e-02f, -3.52336615e-02f, -3.79791185e-02f, 3.22126187e-02f, -5.20821959e-02f, 1.31958202e-02f, -6.45564422e-02f, -4.98969748e-04f, 1.69849619e-02f, 6.75006136e-02f,
  9.79183316e-02f, 1.46069288e-01f, -1.29816055e-01f, 5.22192009e-02f, -5.07306047e-02f, 1.59388781e-01f, 1.63643569e-01f, 3.44095975e-02f, -8.64854455e-02f, 2.20327407e-01f,
  1.37141049e-02f, -9.47958499e-04f, 2.01258436e-02f, 1.07935458e-01f, -5.05470559e-02f, -9.50867403e-03f, 1.34242445e-01f, 1.66133538e-01f, -3.06337066e-02f, 7.60176405e-02f,
  4.47808132e-02f, 1.67515516e-01f, -5.50228804e-02f, -4.13927846e-02f, 7.25290254e-02f, -8.93976167e-02f, 2.93577202e-02f, -1.16805121e-01f, 6.77063838e-02f, -4.23477143e-02f,
  7.18582049e-02f, 5.87711446e-02f, -5.22386096e-02f, 2.59568170e-02f, 2.83508934e-02f, 1.46224676e-02f, -6.28885999e-02f, -5.84357753e-02f, 2.83911172e-02f, -3.47220711e-02f,
  7.73743242e-02f, -1.46467946e-02f, -3.43767740e-02f, -1.04079815e-02f, -7.70644471e-02f, -5.26168868e-02f, 5.48530705e-02f, -6.03835545e-02f, 3.11963931e-02f, 1.09121643e-01f,
  -3.42888981e-02f, 6.36263192e-02f, 6.41301274e-02f, 4.64945845e-02f, -8.57920125e-02f, -7.83110410e-02f, -5.41488938e-02f, 3.45799290e-02f, 9.46987141e-03f, -4.42429855e-02f,
  5.96089140e-02f, -4.76647317e-02f, 4.95475233e-02f, 4.13112044e-02f, 5.80524541e-02f, -7.76145235e-02f, 5.81635162e-02f, 2.75863502e-02f, -8.22238065e-03f, -4.76655830e-03f,
  -4.91151810e-02f, 4.64371070e-02f, -4.28877622e-02f, 7.67812431e-02f, 1.05107687e-01f, 7.56259859e-02f, 3.65266539e-02f, 3.51753384e-02f, 5.43048270e-02f, 3.41226421e-02f,
  2.25203615e-02f, -8.35119113e-02f, 4.02809419e-02f, 5.57290250e-03f, 6.72235191e-02f, 1.64288711e-02f, 6.85675368e-02f, -1.42929684e-02f, 3.34388949e-02f, 5.53362779e-02f,
  1.23586819e-01f, 7.57802464e-03f, -6.68940842e-02f, 3.32647376e-03f, -9.63516012e-02f, -2.96905786e-02f, 1.91309731e-02f, 4.34198305e-02f, -7.21228891e-04f, 5.54613397e-02f,
  3.20851021e-02f, 3.04202363e-02f, -5.87887242e-02f, -2.64926590e-02f, 2.10343637e-02f, -1.64914187e-02f, -2.28285342e-02f, -7.61877969e-02f, 4.96241078e-02f, 5.30151948e-02f,
  6.52630702e-02f, 6.96073771e-02f, -4.70756739e-02f, 2.49065943e-02f, 9.79548991e-02f, 4.94446270e-02f, 2.28701178e-02f, -5.62459081e-02f, 1.04100257e-01f, 7.13674501e-02f,
  -8.03735554e-02f, 6.97199851e-02f, 3.07530575e-02f, 4.94556949e-02f, 1.64691526e-02f, 2.20460743e-02f, -5.05587719e-02f, 4.28041369e-02f, 1.95682216e-02f, 1.43890768e-01f,
  -3.34244259e-02f, 1.56506449e-01f, 1.40039958e-02f, -2.11433861e-02f, -1.23351842e-01f, 1.15055203e-01f, -9.36263129e-02f, 1.58553682e-02f, -2.42962018e-02f, -5.79315647e-02f,
  -1.46043733e-01f, -4.09601256e-02f, -4.78819013e-02f, 5.62019832e-02f, 2.86878869e-02f, 3.46962884e-02f, -1.26074776e-01f, 9.51542407e-02f, -1.51643202e-01f, -3.29815894e-02f,
  -7.36794397e-02f, -6.23142254e-03f, -2.15010606e-02f, 8.94587263e-02f, -9.83634591e-02f, -8.77297148e-02f, 5.89663014e-02f, -4.02297601e-02f, -4.85005267e-02f, 5.41439466e-02f,
  -6.12510461e-03f, -1.58887655e-02f, -5.43068051e-02f, 1.57823060e-02f, 1.06709346e-01f, 6.66324347e-02f, 3.00540924e-02f, -7.76005909e-02f, -1.79484896e-02f, -4.98307794e-02f,
  8.57406035e-02f, -4.37984876e-02f, -8.85375515e-02f, 2.61221197e-03f, 5.90856671e-02f, 4.38964413e-03f, -5.87369986e-02f, -1.10847935e-01f, -1.02183960e-01f, 3.54769044e-02f,
  6.03724159e-02f, -7.56965578e-02f, 5.92971481e-02f, 2.70217117e-02f, -4.81200032e-02f, 2.68205535e-02f, -4.33978848e-02f, -4.58053201e-02f, 2.40866711e-06f, 5.10634035e-02f,
  -2.01198850e-02f, 9.81072634e-02f, 1.05592877e-01f, -2.30734162e-02f, 4.46123704e-02f, 8.23446736e-02f, -9.17188153e-02f, -5.16561680e-02f, 7.20786378e-02f, 5.66682145e-02f,
  -1.77013539e-02f, -9.28402543e-02f, -1.41397305e-02f, 8.97620991e-02f, 8.19334760e-02f, 4.39326465e-03f, -7.56879002e-02f, 4.84681763e-02f, -5.59144595e-04f, 5.91582283e-02f,
  -9.72806364e-02f, 2.07019635e-02f, -5.04434146e-02f, 3.75716724e-02f, 5.88950794e-03f, -7.25073600e-03f, -1.75970811e-02f, -7.07673654e-02f, -4.42142412e-03f, -2.28747353e-02f,
  -5.77096194e-02f, -2.66939010e-02f, -2.68585291e-02f, 7.45212957e-02f, 8.26132670e-02f, -6.38773739e-02f, -8.15118328e-02f, 5.74063808e-02f, -2.47426201e-02f, 4.47267964e-02f,
  4.97383736e-02f, -5.25529273e-02f, -4.51476313e-02f, 1.78370569e-02f, 8.09890702e-02f, -8.47128183e-02f, -4.39334139e-02f, -1.58160720e-02f, -1.00181781e-01f, -3.53115425e-02f,
  6.95487397e-05f, -2.05159456e-01f, 1.63122088e-01f, 1.29685000e-01f, 2.63771676e-02f, 3.36099677e-02f, 1.31362587e-01f, 8.18257034e-02f, 6.62938505e-03f, -2.61266202e-01f,
  -5.91946431e-02f, -1.13639779e-01f, -6.26759082e-02f, 3.70127484e-02f, 1.62186339e-01f, -5.99826463e-02f, 5.75152300e-02f, -6.61549270e-02f, 1.10068820e-01f, -3.78553718e-02f,
  7.96519369e-02f, 7.27837346e-03f, 1.61189079e-01f, 8.12965725e-03f, -1.49044786e-02f, 2.35170051e-02f, -6.98449537e-02f, 2.63318908e-03f, -5.41156977e-02f, -7.40960389e-02f,
  3.16317044e-02f, -6.78134188e-02f, 5.18026948e-02f, -3.06042489e-02f, 9.43709910e-03f, 4.47650515e-02f, 7.75917321e-02f, 5.14702350e-02f, -4.47957776e-02f, 7.02669546e-02f,
  4.26506959e-02f, -6.94843978e-02f, 1.10556493e-02f, -1.42061419e-03f, 5.86150698e-02f, -2.89627034e-02f, 8.25936869e-02f, 1.08039148e-01f, -5.96254915e-02f, 1.14587164e-02f,
  -5.64460270e-02f, -3.75964120e-02f, 5.49710989e-02f, -4.26815934e-02f, -2.51877047e-02f, 5.69017828e-02f, 6.50510415e-02f, 7.14831846e-03f, 4.40292172e-02f, 3.78182940e-02f,
  -1.93487052e-02f, -6.55023679e-02f, -1.37702248e-03f, -1.52783087e-02f, 9.40817595e-03f, -4.50876392e-02f, -1.07252300e-02f, -6.66336939e-02f, -2.71634068e-02f, -7.70973191e-02f,
  -4.18980494e-02f, 6.04273938e-03f, -3.39901559e-02f, 4.58094664e-03f, -2.97295675e-02f, -1.74557865e-02f, -5.21756820e-02f, 6.90607280e-02f, 2.68731304e-02f, -1.47270560e-02f,
  5.96485920e-02f, 5.84348328e-02f, -5.76848574e-02f, 8.45917761e-02f, -4.36533205e-02f, 1.69571061e-02f, 3.46998759e-02f, -2.83927470e-02f, 4.46667448e-02f, -8.10493529e-02f,
  -1.27236083e-01f, -7.80076981e-02f, 5.14724338e-03f, -5.53172156e-02f, 6.54869294e-03f, -1.04413718e-01f, -2.73648687e-02f, -3.77282761e-02f, 9.03843902e-03f, -3.66531424e-02f,
  3.37995328e-02f, -5.65974682e-04f, -6.62042648e-02f, 4.12163651e-03f, -1.10105306e-01f, 1.38921719e-02f, -3.90623994e-02f, -6.99432492e-02f, -2.88016554e-02f, -5.34946732e-02f,
  4.20362485e-04f, -3.30383307e-03f, -6.05533570e-02f, 2.89996080e-02f, 2.52585523e-02f, -1.33403717e-02f, -3.78134958e-02f, -3.13197151e-02f, -1.23404674e-02f, 3.29801701e-02f,
  -2.08989084e-01f, 1.77907750e-01f, -2.06293792e-01f, 1.73623171e-02f, -2.47769222e-01f, 1.81978658e-01f, 2.43283078e-01f, -1.08279556e-01f, -4.00156006e-02f, 3.58063787e-01f,
  1.55766010e-01f, -1.07473068e-01f, 2.15375707e-01f, 1.65236160e-01f, -5.84358200e-02f, 2.51171023e-01f, 1.92421436e-01f, 1.34961635e-01f, 2.40136590e-02f, 5.47506399e-02f,
  -8.02600533e-02f, 1.38104200e-01f, 5.76207340e-02f, -8.41208324e-02f, -7.16681704e-02f, -1.11611180e-01f, -9.96778309e-02f, -1.58862635e-01f, 6.01486415e-02f, -2.17941925e-02f,
  -1.82395466e-02f, -5.00579216e-02f, -6.63990378e-02f, 6.91221207e-02f, -4.65583242e-03f, -4.28671688e-02f, -1.09031075e-03f, 3.04461457e-02f, -2.18415931e-02f, -8.38142186e-02f,
  7.29259625e-02f, -7.53532276e-02f, 2.30388530e-02f, -5.55447340e-02f, -5.53808932e-04f, -7.06639960e-02f, 2.37176921e-02f, -8.41037929e-02f, -6.13075728e-03f, -4.26499173e-02f,
  -8.20009783e-02f, -6.52302196e-03f, 1.36122731e-02f, 1.00283809e-01f, -9.88373980e-02f, 7.24939480e-02f, -3.12776528e-02f, -3.75568308e-02f, 4.92402650e-02f, -4.27686162e-02f,
  -8.55795071e-02f, -4.49777581e-02f, -1.70298796e-02f, 1.77813824e-02f, 5.53099141e-02f, 5.13457973e-03f, 2.80597173e-02f, -2.21179333e-02f, -6.51497766e-02f, -8.19581095e-03f,
  -4.24064919e-02f, -4.92200255e-02f, -5.30205714e-03f, 3.67220305e-02f, 5.88005269e-03f, 1.00892141e-01f, 1.29520344e-02f, -6.54082894e-02f, -3.35563198e-02f, 8.80109612e-03f,
  6.53646067e-02f, -3.29492092e-02f, -3.36061195e-02f, -3.86367366e-02f, 6.56607598e-02f, -7.39888474e-02f, -2.38562003e-02f, -2.83684991e-02f, 6.24749437e-02f, -7.38397390e-02f,
  5.23484405e-03f, -7.18532950e-02f, 2.87909172e-02f, 1.79623980e-02f, 8.21861252e-02f, -1.08168805e-02f, -3.83200869e-02f, -4.05938365e-03f, -5.10583110e-02f, 2.94064470e-02f,
  6.17747083e-02f, -5.13099246e-02f, -5.71007766e-02f, -6.70884177e-02f, 7.50971809e-02f, -4.48086932e-02f, 1.17440067e-01f, -5.92249038e-04f, 3.17082405e-02f, 3.56928110e-02f,
  5.87298758e-02f, 6.80920780e-02f, 1.32889813e-03f, 5.69842290e-03f, 5.73751964e-02f, 2.42611226e-02f, 1.99262463e-02f, -1.11437149e-01f, 2.03779829e-03f, -5.93088828e-02f,
  3.22068483e-02f, -3.71389054e-02f, -1.60568133e-01f, 1.05574392e-01f, 3.16253006e-02f, 2.36670896e-02f, -1.74618557e-01f, 5.49519062e-03f, -1.39302894e-01f, -1.59607660e-02f,
  1.46898642e-01f, -8.38910639e-02f, -1.50105774e-01f, 1.68908536e-01f, 1.28722295e-01f, -8.13785046e-02f, 2.19952706e-02f, 7.10910046e-03f, -9.05017406e-02f, 5.52895106e-02f,
  1.19331308e-01f, 1.61176473e-01f, 4.53551151e-02f, 2.21843198e-01f, 4.65292856e-02f, 1.40101328e-01f, 2.08572522e-01f, 9.16004032e-02f, 1.49820432e-01f, 1.54264569e-01f,
  3.24410610e-02f, -5.76250516e-02f, -6.11783145e-03f, 5.21230474e-02f, 4.24966961e-02f, 4.00741734e-02f, 1.52630899e-02f, 2.47367080e-02f, -1.16008455e-02f, -6.12022579e-02f,
  -7.09784925e-02f, -1.36691015e-02f, 7.12982342e-02f, 6.12784512e-02f, 6.02927841e-02f, 1.10447548e-01f, -5.42047434e-03f, 5.20493276e-02f, 3.55280261e-03f, -2.70492267e-02f,
  -5.35412356e-02f, -3.69653516e-02f, -9.84536600e-04f, -1.11405151e-02f, -4.29158024e-02f, -8.57787654e-02f, -3.33175249e-02f, 4.95792218e-02f, -6.78705722e-02f, 3.39226499e-02f,
  -4.08716276e-02f, 9.08432677e-02f, 6.51200339e-02f, 6.44612312e-03f, -7.32248127e-02f, -5.91828004e-02f, -7.64662921e-02f, 2.11721137e-02f, -8.16030949e-02f, 7.01451525e-02f,
  -4.63853069e-02f, 3.39723490e-02f, 1.75748561e-02f, -2.68694665e-02f, 1.78043116e-02f, -8.69029947e-03f, -5.60287349e-02f, -6.03501126e-02f, 2.49370821e-02f, 5.90969510e-02f,
  -5.97560927e-02f, -1.95636656e-02f, 7.87395015e-02f, -7.85047784e-02f, -4.89045195e-02f, -1.27888561e-05f, -1.95089001e-02f, 7.15491697e-02f, -1.94105450e-02f, 9.24679711e-02f,
  -4.39889776e-03f, 4.15934920e-02f, 4.57792543e-02f, -6.11178726e-02f, -7.17659947e-03f, -5.78495599e-02f, 2.10032817e-02f, 5.33383116e-02f, 5.57181723e-02f, 4.44786139e-02f,
  -4.05918844e-02f, -3.98973525e-02f, 8.86036232e-02f, 9.51874331e-02f, -4.24632020e-02f, 7.22808316e-02f, 1.93508831e-03f, 8.09235051e-02f, 5.52897714e-02f, -1.09066190e-02f,
  6.59773871e-02f, -2.92711947e-02f, -4.74319346e-02f, 2.07183044e-02f, 8.81868824e-02f, 4.36131023e-02f, 7.23174363e-02f, 7.15227053e-02f, -6.68221936e-02f, 4.39768732e-02f,
  3.30260694e-02f, 5.66474721e-02f, 2.05181926e-01f, -1.45327218e-03f, 1.25339344e-01f, 1.12103350e-01f, -6.67176172e-02f, 1.88636363e-01f, 1.46628216e-01f, -9.49409679e-02f,
  4.16179411e-02f, 5.02997227e-02f, -1.08752690e-01f, 1.71476863e-02f, -1.12952679e-01f, 1.24555202e-02f, 2.89192963e-02f, -1.01345323e-03f, 1.06440656e-01f, 7.62153566e-02f,
  3.82323042e-02f, -1.17864698e-01f, -9.23084691e-02f, -3.81564088e-02f, 7.48370513e-02f, -7.31011480e-02f, -6.64038807e-02f, -4.51815873e-02f, -4.89935838e-02f, 4.62982655e-02f,
  -5.46713620e-02f, -3.79653051e-02f, 9.26352367e-02f, -3.77869979e-02f, 2.76335999e-02f, 9.50352624e-02f, 8.70486442e-03f, -1.09121092e-01f, -5.72051071e-02f, -1.99566800e-02f,
  7.33400276e-03f, 7.64114084e-03f, 3.44115198e-02f, -8.17679465e-02f, 1.96864922e-02f, 7.50486925e-02f, 3.90138589e-02f, 8.67157429e-02f, 3.71414982e-02f, 9.38524678e-02f,
  5.52328601e-02f, -2.91668791e-02f, 5.65768071e-02f, 7.52226934e-02f, 4.35804054e-02f, -3.92756015e-02f, 7.40136858e-03f, -7.00636059e-02f, -3.35464180e-02f, 3.73671614e-02f,
  -7.96866193e-02f, -1.01404879e-02f, -2.00685542e-02f, 1.74154043e-02f, 1.90807432e-02f, -2.15465967e-02f, -7.16820583e-02f, -4.38527316e-02f, -6.58909157e-02f, -2.99581476e-02f,
  1.93253495e-02f, -1.71452556e-02f, -4.27697226e-02f, 8.37322176e-02f, -6.88243136e-02f, 4.49224096e-03f, 3.03514162e-03f, -1.78976152e-02f, -5.64201549e-02f, 4.55073081e-02f,
  -9.24255401e-02f, -5.98420054e-02f, 6.45328537e-02f, 1.62423458e-02f, -3.75514873e-03f, 2.12231576e-02f, 5.04850633e-02f, 2.34731939e-03f, 5.90378046e-02f, -1.79605465e-02f,
  4.51488197e-02f, -1.31084189e-01f, 1.05272299e-02f, -2.78984159e-02f, -2.55170818e-02f, 6.12421483e-02f, -5.80676757e-02f, -3.49755911e-03f, 7.39641115e-03f, 3.18266898e-02f,
  8.97122025e-02f, -9.34368894e-02f, -1.41556347e-02f, 6.19065277e-02f, -3.84449796e-03f, -1.94231072e-03f, 1.65290069e-02f, 8.38454254e-03f, -1.27970781e-02f, -3.93637344e-02f,
  3.55501822e-03f, 3.16715636e-03f, 2.06577107e-02f, 6.07589781e-02f, 2.46187747e-02f, -7.45841768e-03f, 2.85828803e-02f, -7.40034599e-03f, -5.85997570e-03f, -1.18900873e-02f,
  4.36822847e-02f, 8.48907512e-03f, 2.50892311e-01f, -1.29223168e-01f, 1.38728485e-01f, 1.33005276e-01f, -8.26970041e-02f, 1.97071239e-01f, 7.32853562e-02f, -1.47451103e-01f,
  -1.28602281e-01f, -5.22599891e-02f, 2.99451854e-02f, 1.64147012e-03f, -7.50441104e-02f, -1.22973481e-02f, -8.31410438e-02f, -1.10310897e-01f, 1.70754224e-01f, 1.54796587e-02f,
  -5.32545056e-03f, -1.92960292e-01f, 7.10934252e-02f, 4.94970456e-02f, -1.56707410e-02f, 7.41110742e-02f, -1.94326773e-01f, -4.94528152e-02f, -7.02558532e-02f, 4.34990637e-02f,
  -7.53988847e-02f, -9.35961008e-02f, 2.36061122e-02f, 1.09819539e-01f, -4.37931484e-03f, -1.98409539e-02f, -4.00336720e-02f, -7.99245238e-02f, 1.94843784e-02f, 9.20589045e-02f,
  -3.91579904e-02f, 3.27789932e-02f, 2.36994699e-02f, -4.63319346e-02f, -2.95712575e-02f, 1.61002558e-02f, 1.48789063e-01f, 5.51755987e-02f, 1.21185236e-01f, 5.96692078e-02f,
  1.56518131e-01f, -5.66899544e-03f, 2.26479676e-03f, -2.90688723e-02f, 4.58662659e-02f, 1.82175841e-02f, -6.37527481e-02f, -7.32933655e-02f, -2.99765263e-02f, -2.26542708e-02f,
  2.30844598e-02f, -2.69936696e-02f, -2.97670588e-02f, 9.03176293e-02f, -3.13599333e-02f, 8.91033858e-02f, 6.93027452e-02f, -6.02727272e-02f, 3.53006721e-02f, -1.25590283e-02f,
  4.99804318e-02f, -4.41723391e-02f, -4.32886789e-03f, 1.44973882e-02f, -7.27231652e-02f, 6.18405789e-02f, 3.82281505e-02f, 7.66231343e-02f, 3.25802937e-02f, 6.32208958e-02f,
  5.33784628e-02f, 8.28349125e-03f, 2.70550605e-02f, 9.14012566e-02f, -5.87109774e-02f, -5.14665954e-02f, 3.49644870e-02f, 2.07476988e-02f, 3.23968418e-02f, 2.32705567e-02f,
  -1.32246122e-01f, -2.12122321e-01f, -8.24298412e-02f, -1.85361002e-02f, 2.29731835e-02f, -4.17148247e-02f, 2.71384511e-02f, 1.00168101e-01f, -6.62668347e-02f, 5.54739237e-02f,
  -1.02697257e-02f, 2.10638400e-02f, -1.74726956e-02f, -8.12579598e-03f, 3.78587805e-02f, 7.60057196e-02f, -4.48192134e-02f, -1.29325628e-01f, 7.35521957e-04f, 5.87986037e-02f,
  -2.57503744e-02f, -3.41559537e-02f, 1.48601579e-02f, -6.73128068e-02f, -6.13688454e-02f, -2.82741878e-02f, -1.20961100e-01f, 2.17869151e-02f, -2.33132336e-02f, 1.22774560e-02f,
  -1.37562186e-01f, 1.06594913e-01f, 4.63867970e-02f, 3.31758782e-02f, -4.30648886e-02f, 1.23152751e-02f, -1.37956850e-02f, 6.40143454e-02f, 7.46667013e-02f, 6.46518841e-02f,
  1.82112120e-02f, 6.75140247e-02f, 2.23723650e-02f, -6.98091015e-02f, 7.97639862e-02f, -3.30204666e-02f, -5.36453947e-02f, 3.02916020e-02f, 1.23841129e-02f, 1.25607923e-01f,
  4.74695079e-02f, 2.35139113e-02f, 1.08839504e-01f, 5.33284508e-02f, 2.26083584e-02f, -4.78589274e-02f, 1.58837840e-01f, 4.29822356e-02f, 4.71813679e-02f, -9.51325893e-03f,
  -1.04487240e-01f, 8.21314752e-02f, 2.87204552e-02f, -9.59023237e-02f, 7.62097985e-02f, -6.13867491e-02f, 1.98895298e-02f, -4.24720198e-02f, 5.55015355e-02f, 5.31426519e-02f,
  -7.40713254e-02f, -7.85232931e-02f, -3.39307189e-02f, -2.97048241e-02f, 2.88748872e-02f, -6.60308525e-02f, -3.75944823e-02f, -5.31013384e-02f, 1.16579644e-02f, -9.20900702e-02f,
  -8.27835221e-03f, 1.63798537e-02f, -8.18807781e-02f, 2.56388243e-02f, 7.89619833e-02f, -5.00500500e-02f, 5.36240749e-02f, -5.65187866e-03f, -7.53251910e-02f, 7.71503672e-02f,
  -1.52331758e-02f, 5.42657962e-03f, -1.45923663e-02f, 5.01005270e-04f, 7.09531605e-02f, 9.34032649e-02f, -4.18503731e-02f, -5.15314043e-02f, -4.13982645e-02f, -8.41729417e-02f,
  -8.43848810e-02f, -9.25394967e-02f, -1.88223701e-02f, 7.04647005e-02f, 5.49798682e-02f, -9.69981179e-02f, 2.75444556e-02f, -8.16876814e-02f, 7.24138245e-02f, -6.95046782e-02f,
  4.63576503e-02f, -9.55059007e-03f, 2.44517233e-02f, -5.58355497e-03f, -3.46521735e-02f, 2.65859291e-02f, -1.92245003e-02f, -2.63708364e-02f, 6.26662299e-02f, 4.23819236e-02f,
  5.58445789e-02f, 1.66411325e-01f, -2.14124694e-02f, -7.63347223e-02f, 8.05613250e-02f, -7.22637028e-02f, 6.94961697e-02f, -7.91469291e-02f, 1.35900170e-01f, -5.17963693e-02f,
  3.23974378e-02f, -3.91855612e-02f, 4.00248952e-02f, 3.52739021e-02f, 5.83887799e-03f, 1.22477356e-02f, 9.07515809e-02f, -2.13451069e-02f, 6.72765151e-02f, 9.68571976e-02f,
  7.62195559e-03f, -1.59398559e-02f, 2.48365011e-02f, -8.03921968e-02f, -7.73336440e-02f, 2.97160875e-02f, 6.72144815e-02f, -1.88546199e-02f, 4.39338200e-02f, -1.12214861e-02f,
  1.84815809e-01f, -4.11763877e-01f, 1.56098217e-01f, 2.38334879e-01f, 1.49651602e-01f, 1.04112998e-01f, 1.26623049e-01f, -4.52079661e-02f, 1.06820278e-01f, -3.66576999e-01f,
  -8.19914639e-02f, -1.64258614e-01f, -1.57468423e-01f, -7.53332675e-02f, 1.39274076e-01f, -9.95790213e-02f, -5.27332649e-02f, -1.59792081e-02f, 4.79349755e-02f, 5.14699593e-02f,
  4.84326407e-02f, -6.39328547e-03f, -2.49174181e-02f, -1.76930726e-01f, 1.04345970e-01f, -4.52419817e-02f, -9.77138653e-02f, 5.56764193e-02f, 1.67395901e-02f, 4.22424898e-02f,
  2.25009844e-02f, -2.12039426e-02f, -3.40686627e-02f, -8.24894309e-02f, 6.88820938e-03f, -1.03724115e-01f, -6.52026311e-02f, -4.94871847e-02f, 1.62475213e-01f, 3.89183238e-02f,
  -6.36430308e-02f, 1.48694254e-02f, -1.85823049e-02f, 9.09600034e-02f, -1.07990596e-02f, 6.38417974e-02f, 7.40410760e-02f, 2.21863724e-02f, 4.82284799e-02f, 6.31108508e-02f,
  -4.19338159e-02f, 6.45376146e-02f, -2.80931555e-02f, -4.28807288e-02f, 8.89038891e-02f, 9.73602477e-03f, -4.51354608e-02f, -2.24593077e-02f, -2.93428469e-02f, 3.39307003e-02f,
  -1.03409640e-01f, -6.45631254e-02f, 3.54537293e-02f, 5.57301752e-02f, 8.71116221e-02f, 4.56129014e-02f, 4.71194126e-02f, 3.32343914e-02f, 4.41955104e-02f, 6.68793451e-03f,
  -7.76346698e-02f, 5.10949604e-02f, 3.00103389e-02f, 2.47604474e-02f, 1.19315973e-02f, 2.36158050e-03f, -3.05530727e-02f, 1.24470713e-02f, 6.61661625e-02f, -5.59386648e-02f,
  -4.24367812e-04f, -8.34152624e-02f, 8.79313704e-03f, 1.59970205e-02f, 2.93590594e-02f, 6.48063049e-02f, -1.99781172e-02f, 1.63410380e-02f, -2.16469504e-02f, 7.30926618e-02f,
  -1.17636658e-01f, -2.50841409e-01f, 3.49696726e-02f, -6.09699599e-02f, 1.74072124e-02f, -1.84687283e-02f, -5.72562888e-02f, -5.49082756e-02f, -1.29009977e-01f, -1.38715226e-02f,
  -7.30936974e-03f, -3.62249427e-02f, -2.52913050e-02f, 5.85915036e-02f, -3.67782339e-02f, -1.81809869e-02f, 2.64036581e-02f, -8.98442417e-02f, -8.14158320e-02f, -3.80207449e-02f,
  4.33240645e-02f, 6.43988373e-03f, -2.11951183e-03f, -3.47125269e-02f, -9.42171216e-02f, -4.20835912e-02f, -2.69052684e-02f, -8.12076032e-02f, -1.48462849e-02f, -7.24339858e-02f,
  -5.30248880e-02f, 4.38737646e-02f, 1.28229097e-01f, 1.09263450e-01f, -9.21724550e-03f, 8.96825120e-02f, 8.71108398e-02f, 1.12182170e-01f, 2.24677160e-01f, -1.23790227e-01f,
  -1.13677166e-01f, 6.99236849e-03f, -1.70655772e-02f, -2.55208090e-03f, 5.35168871e-02f, -2.13327184e-02f, 1.31402701e-01f, 4.64283042e-02f, 2.66713798e-02f, -6.63168170e-03f,
  2.10559554e-02f, -9.58831310e-02f, -1.19717747e-01f, -5.12393527e-02f, -5.28153256e-02f, 2.32279785e-02f, -1.89140350e-01f, -6.80878609e-02f, -6.29290715e-02f, 5.10389991e-02f,
  -2.55229063e-02f, 6.43437682e-03f, -8.97393525e-02f, 8.09188262e-02f, -7.12570921e-02f, 5.07225133e-02f, 7.47285634e-02f, 1.07262339e-02f, 4.67912592e-02f, -4.16300818e-02f,
  8.89963359e-02f, 2.35031825e-02f, 7.46729970e-02f, -7.35557601e-02f, 6.59883544e-02f, 1.38635980e-02f, 7.81756341e-02f, 9.97058395e-03f, 9.96216200e-03f, 5.24835698e-02f,
  -3.97834890e-02f, 7.01294616e-02f, -1.98500603e-02f, 6.37535155e-02f, -6.73582032e-02f, 1.09097669e-02f, 7.72173256e-02f, -2.58138999e-02f, 5.55853471e-02f, 1.50711481e-02f,
  2.11431496e-02f, 1.75333880e-02f, -1.02263652e-01f, -3.19835320e-02f, -4.47709970e-02f, 5.91895878e-02f, 1.87766477e-02f, -1.01170294e-01f, 4.28860895e-02f, 3.89644839e-02f,
  3.66702825e-02f, -1.35628255e-02f, -5.44641837e-02f, -8.73715729e-02f, 2.24344283e-02f, -4.41535860e-02f, -7.08645582e-02f, -1.71783250e-02f, -3.44958827e-02f, -7.32169822e-02f,
  6.61810860e-02f, 2.68834103e-02f, 2.53002346e-02f, 5.46232611e-02f, -6.61050007e-02f, 2.41218470e-02f, 3.62687483e-02f, 1.11205317e-02f, 5.05539030e-02f, -1.26006454e-03f,
  5.13547994e-02f, 1.01049311e-01f, -6.58952743e-02f, -9.45892558e-03f, 1.19036855e-02f, -4.41688150e-02f, 8.54046121e-02f, 3.26576009e-02f, -3.44748944e-02f, -2.19239052e-02f,
  8.71803984e-02f, -6.06240667e-02f, -6.29159883e-02f, 1.65295284e-02f, -1.16048893e-03f, -5.98224998e-02f, 3.43855061e-02f, -3.42304781e-02f, 1.89402997e-02f, -4.92142467e-03f,
  -8.94411281e-02f, 4.63195965e-02f, -6.78174794e-02f, -1.06190266e-02f, -4.54584956e-02f, -1.01268649e-01f, -5.60071543e-02f, -1.11449361e-02f, 1.79898497e-02f, -1.66779254e-02f,
  2.82168854e-02f, -5.80693595e-02f, -1.89599872e-01f, -1.67812660e-01f, -1.95719063e-01f, -1.39352545e-01f, -2.46742740e-01f, -1.06398664e-01f, 6.63084164e-02f, -8.21788311e-02f,
  -1.41039684e-01f, 9.47431773e-02f, -7.28781754e-03f, -2.75670022e-01f, 1.52523965e-01f, 1.31448388e-01f, -5.76897636e-02f, -1.19796254e-01f, -4.47434671e-02f, -1.88860342e-01f,
  -6.49604574e-02f, -1.88917607e-01f, -1.40700459e-01f, -2.04459861e-01f, -2.30417341e-01f, -2.22826060e-02f, 1.02019429e-01f, -2.13510171e-01f, -6.43603727e-02f, -6.42421991e-02f,
  -7.96966180e-02f, -7.20956251e-02f, -5.03718220e-02f, 8.93455651e-03f, 6.26441240e-02f, -6.33421391e-02f, 1.62661057e-02f, 1.54930400e-02f, 4.05223332e-02f, -7.46010058e-03f,
  8.56120214e-02f, -6.17543384e-02f, -4.34972793e-02f, -4.54437770e-02f, 2.17259601e-02f, -3.78290154e-02f, -2.35153977e-02f, -1.16935521e-02f, 1.30093629e-02f, -1.13036847e-02f,
  2.31490340e-02f, 3.18370238e-02f, 4.08045650e-02f, -2.89012156e-02f, 2.31577661e-02f, -1.29858535e-02f, 8.04624259e-02f, 7.48157278e-02f, 9.84554552e-03f, 2.91201249e-02f,
  4.25909385e-02f, 4.18168381e-02f, -3.41615640e-02f, -6.08548038e-02f, -5.90030998e-02f, -8.72649401e-02f, 4.37824987e-02f, -3.08627784e-02f, 5.68438284e-02f, 2.11092662e-02f,
  -4.41644266e-02f, 5.61390109e-02f, -5.46402670e-02f, 6.07187040e-02f, -2.55708136e-02f, 1.54641783e-02f, -3.30823436e-02f, -3.24498266e-02f, 3.19340564e-02f, 7.60311261e-02f,
  1.76072249e-03f, 3.40214092e-03f, 1.74286701e-02f, 4.85156141e-02f, -1.36183323e-02f, -3.33709419e-02f, 4.41730581e-02f, 7.24066794e-02f, 8.62867236e-02f, -3.15339603e-02f,
  -9.69838258e-03f, -2.45309938e-02f, 3.64715643e-02f, -5.99795058e-02f, 1.51605234e-02f, 6.98706731e-02f, -6.39012456e-02f, -6.71474561e-02f, -6.55043572e-02f, 2.86001544e-02f,
  -2.36016214e-02f, 3.77784334e-02f, 1.02402084e-02f, -9.22356546e-03f, 5.07875495e-02f, 7.43130371e-02f, 5.46924770e-02f, 9.80845094e-02f, 7.81455860e-02f, 2.63633244e-02f,
  -1.05301728e-02f, -6.16137609e-02f, -2.61598881e-02f, 1.16021790e-01f, -5.66153321e-03f, 1.30734118e-02f, 6.83180243e-02f, -6.93034306e-02f, 1.25143170e-01f, -2.00053807e-02f,
  2.35329624e-02f, -4.99551464e-03f, 1.34366928e-02f, -3.66032347e-02f, 3.03070936e-02f, 1.81661442e-01f, 7.77274668e-02f, -1.00484550e-01f, -7.73407072e-02f, -1.23017803e-01f,
  2.23738570e-02f, 3.48147191e-02f, 1.92662701e-01f, -8.72287676e-02f, 2.35288545e-01f, 1.24818012e-01f, -4.95535694e-02f, 3.14575732e-02f, -8.67867246e-02f, -4.44631977e-03f,
  -1.28711209e-01f, -1.45463482e-01f, -3.29688168e-03f, -1.32230535e-01f, 3.01589612e-02f, -9.70256254e-02f, -7.22413212e-02f, -1.85023677e-02f, -9.73751582e-03f, 1.32038668e-01f,
  -9.24616084e-02f, -1.24655746e-01f, 3.04507893e-02f, 4.12707888e-02f, -2.96545364e-02f, 3.61624695e-02f, 1.08798929e-01f, 1.32495975e-02f, -6.96166828e-02f, 3.20773050e-02f,
  4.54357117e-02f, -8.18059295e-02f, -6.78961948e-02f, -2.01883223e-02f, -1.16705924e-01f, -1.03472605e-01f, 4.30165902e-02f, -9.55599919e-02f, -6.63147401e-03f, -5.49502186e-02f,
  6.32679388e-02f, -9.84981433e-02f, -1.27525665e-02f, 9.22446847e-02f, 4.14689668e-02f, 2.91442722e-02f, 4.45553334e-03f, 5.05056828e-02f, 7.24215955e-02f, -6.20593131e-02f,
  -7.41840377e-02f, 7.03111514e-02f, 5.98713383e-02f, 2.49286201e-02f, 5.95298782e-02f, 4.22021560e-02f, 5.00395074e-02f, -7.99826980e-02f, -7.00205266e-02f, 7.73301050e-02f,
  2.65701544e-02f, -7.43769333e-02f, -1.62703097e-02f, -3.72850820e-02f, 1.10633271e-02f, 2.51275003e-02f, -5.96599840e-03f, 1.74500339e-03f, 6.16254136e-02f, -9.76854376e-03f,
  -3.90913896e-02f, -7.91082457e-02f, -6.30682260e-02f, 7.74384215e-02f, 7.62889534e-02f, -4.17939760e-03f, -1.05155185e-01f, -3.56335863e-02f, -4.87036668e-02f, 8.73563737e-02f,
  2.97827926e-02f, -1.75152272e-01f, -8.69084895e-02f, 1.14500737e-02f, -4.05242555e-02f, 6.04565106e-02f, 4.53252979e-02f, 7.41501674e-02f, 4.38136831e-02f, -1.14962064e-01f,
  -3.40135433e-02f, -6.08253740e-02f, 1.78975500e-02f, -2.00535636e-02f, -1.05859470e-02f, -1.04441568e-02f, 5.22946753e-02f, -4.31194417e-02f, 8.10412616e-02f, -2.35673096e-02f,
  5.24129719e-02f, -9.41754058e-02f, 3.21162678e-02f, -9.21825767e-02f, 5.00866808e-02f, -6.94620656e-03f, 6.68988377e-02f, -5.17861061e-02f, 4.17453889e-03f, 3.30806710e-02f,
  -3.06633443e-01f, 1.74907267e-01f, 5.92651144e-02f, -1.72764018e-01f, 1.64228771e-02f, -1.44659907e-01f, -6.63838834e-02f, 2.13339850e-02f, 6.86444715e-02f, 1.09164715e-02f,
  1.92323089e-01f, -2.58587431e-02f, 1.85863897e-01f, -3.56169231e-02f, -2.26725921e-01f, -3.11560696e-03f, -1.30919799e-01f, -6.42919615e-02f, -5.96763603e-02f, -5.52351363e-02f,
  -1.25252411e-01f, 1.32030159e-01f, 4.34589870e-02f, 1.48234382e-01f, -5.84858842e-02f, 2.10058745e-02f, -8.16887841e-02f, 2.29938731e-01f, -6.72855377e-02f, 1.55371740e-01f,
  5.61062573e-03f, 9.61665902e-03f, -1.27456084e-01f, -9.35358256e-02f, -1.66818038e-01f, -1.41374439e-01f, -8.89621526e-02f, 2.58124992e-02f, 3.59061686e-03f, -8.80172551e-02f,
  3.39888558e-02f, 1.83161832e-02f, 3.97490114e-02f, 6.55941963e-02f, 2.87279282e-02f, 7.35494569e-02f, -3.00445128e-02f, 4.68174927e-02f, -1.64291803e-02f, 7.58958608e-02f,
  5.81834465e-02f, -1.17417267e-02f, -9.69049111e-02f, -6.79396316e-02f, -6.02602176e-02f, 7.69271031e-02f, -8.25521275e-02f, 2.63933484e-02f, -1.42050534e-02f, 1.28242262e-02f,
  5.47975786e-02f, -2.32033320e-02f, 2.37885322e-02f, 5.94534725e-02f, -4.51089330e-02f, 2.59174430e-03f, 5.88064641e-03f, -3.16346176e-02f, -4.36165296e-02f, -2.68726647e-02f,
  3.46659161e-02f, -8.12378712e-03f, 5.51729016e-02f, -1.02288239e-01f, -5.99353351e-02f, -1.06500663e-01f, 1.94020178e-02f, 2.03455947e-02f, -3.43858376e-02f, 3.22497971e-02f,
  1.00937873e-01f, -5.01137637e-02f, 9.82699096e-02f, -9.57187638e-03f, -4.92936149e-02f, -2.07516216e-02f, -5.87548241e-02f, -2.29306091e-02f, -5.80821037e-02f, -5.26319891e-02f,
  -9.81136933e-02f, -6.92792460e-02f, -9.37585086e-02f, -7.70524750e-03f, -1.81387237e-03f, 3.05253407e-03f, 5.81985712e-02f, -4.37269621e-02f, -1.08902551e-01f, -2.81923660e-03f,
  -1.16530128e-01f, -1.02212019e-01f, -4.94293310e-02f, -3.60686183e-02f, -4.06155959e-02f, 4.22604196e-02f, 9.51131526e-03f, -1.11648090e-01f, -4.82552266e-03f, -3.59055176e-02f,
  -6.65077269e-02f, 7.47222733e-03f, -4.54889163e-02f, 7.36488844e-04f, -1.89744439e-02f, -5.25140613e-02f, 2.39293780e-02f, -6.98971525e-02f, 4.70370799e-02f, 6.32323325e-02f,
  -2.79076874e-01f, 9.87072960e-02f, 7.69060478e-02f, -9.29261446e-02f, 1.43894196e-01f, 5.90228103e-02f, 2.04986567e-03f, 1.63175777e-01f, -3.04432884e-02f, -7.50914589e-02f,
  -8.41269568e-02f, -7.46701360e-02f, 7.84395188e-02f, 2.93354373e-02f, -4.19761278e-02f, 1.00312822e-01f, 1.89339612e-02f, -9.19602886e-02f, 7.33842328e-03f, -8.34876895e-02f,
  -7.07282051e-02f, -8.15874338e-03f, 4.15312909e-02f, 1.58959076e-01f, -6.60490990e-02f, -1.00277670e-01f, -7.56431371e-02f, 6.85561299e-02f, -3.60103510e-02f, 6.29587695e-02f,
  -8.28649700e-02f, -9.78132188e-02f, -2.43220739e-02f, -8.17372575e-02f, -1.04250677e-01f, -6.95670024e-02f, -9.60469767e-02f, 4.16637994e-02f, 1.66609380e-02f, 3.80662791e-02f,
  -3.34550105e-02f, 8.55637565e-02f, -7.02243373e-02f, 5.06026261e-02f, 2.50042733e-02f, 6.00548163e-02f, -2.79445052e-02f, -9.44929384e-03f, 3.65896635e-02f, -2.34797541e-02f,
  6.59135729e-02f, 8.38014763e-03f, -1.53737627e-02f, -8.97132754e-02f, 7.36681605e-03f, -2.49303374e-02f, 4.73797880e-03f, -5.91961406e-02f, 2.45608613e-02f, -3.52887549e-02f,
  -4.24140915e-02f, -9.13237408e-02f, 5.20929955e-02f, -1.42573090e-02f, 5.39040193e-03f, -3.21285427e-02f, -3.18693207e-03f, -4.72033322e-02f, 3.49970944e-02f, -1.59727894e-02f,
  -4.92098071e-02f, -1.42128728e-02f, 9.68459062e-03f, -3.49195264e-02f, 3.13729756e-02f, 1.74688771e-02f, 2.27259528e-02f, -2.81916931e-02f, 1.50940223e-02f, -5.59892654e-02f,
  -5.43648824e-02f, 7.31312484e-02f, -2.91889291e-02f, -3.96443009e-02f, 5.26348576e-02f, -3.20376679e-02f, -4.95929122e-02f, 7.14167804e-02f, -2.46971250e-02f, -4.87771332e-02f,
  -4.30155769e-02f, -1.03252828e-01f, -3.68866399e-02f, 2.47716885e-02f, 9.63050034e-03f, 3.81254815e-02f, -4.39832434e-02f, 6.24267943e-02f, -6.52026162e-02f, 2.17714477e-02f,
  -1.81663278e-02f, -1.99424161e-04f, -2.65655890e-02f, 7.93491229e-02f, -6.90359026e-02f, -6.58780336e-02f, -4.61669676e-02f, -1.53605128e-02f, -6.72548413e-02f, -1.64681915e-02f,
  6.97555467e-02f, 4.76829745e-02f, 3.53541113e-02f, -9.23948735e-02f, 6.18617609e-03f, -5.68431988e-02f, -2.78516505e-02f, 7.58507997e-02f, -1.35258511e-02f, -1.26017472e-02f,
  7.69602731e-02f, 1.26550972e-01f, 1.46464044e-02f, -5.30614778e-02f, -5.00214547e-02f, -1.11948863e-01f, 2.05493672e-03f, 1.94269288e-02f, 1.56372681e-01f, 1.04819864e-01f,
  -2.31146696e-03f, 2.58801460e-01f, -8.82480014e-03f, 2.29273085e-02f, -3.05220068e-01f, -4.42229398e-02f, -1.64233536e-01f, -9.97714400e-02f, 6.60831705e-02f, -2.87259985e-02f,
  -8.98046196e-02f, -1.29137993e-01f, -9.51461494e-02f, -7.90940672e-02f, 2.69640740e-02f, 8.67568851e-02f, -1.53620288e-01f, 9.89620686e-02f, -2.72899568e-02f, -1.07660688e-01f,
  3.84461205e-03f, 3.63796279e-02f, -2.94263363e-02f, -3.10839619e-02f, -1.20262966e-01f, -6.61123618e-02f, 8.71232804e-03f, 1.82891767e-02f, 6.55322820e-02f, 5.28067872e-02f,
  1.15390681e-01f, 8.80210698e-02f, 3.06982547e-02f, 9.98430103e-02f, 9.55423340e-02f, 2.41215713e-02f, 7.76276663e-02f, -2.00150302e-03f, 2.10189875e-02f, -1.11615686e-02f,
  -2.43876483e-02f, -7.68165514e-02f, -8.21103752e-02f, 3.16982158e-02f, -2.29373742e-02f, 5.78891709e-02f, 2.66422089e-02f, -5.60289919e-02f, -7.65232071e-02f, -7.08052367e-02f,
  -1.89483631e-02f, 5.40227480e-02f, 2.80641876e-02f, -2.89315153e-02f, 4.35333811e-02f, 2.74096103e-03f, 2.78893858e-03f, -2.76593678e-02f, 4.38415147e-02f, -2.35307589e-02f,
  -7.36334026e-02f, -8.63290951e-03f, -6.36410899e-03f, 3.65890451e-02f, 2.88322549e-02f, 9.81153697e-02f, -9.01468620e-02f, -7.17941448e-02f, -6.15189597e-02f, -1.08975485e-01f,
  -2.45397631e-02f, -5.63530736e-02f, 8.57662186e-02f, 5.51027469e-02f, -5.72302639e-02f, 3.92035618e-02f, -6.21882640e-02f, -7.81596676e-02f, -1.27711461e-03f, 5.22895753e-02f,
  -3.99781018e-02f, 8.67001936e-02f, 1.10809237e-01f, 6.93620592e-02f, -7.26564834e-03f, 1.45270452e-02f, 6.69614375e-02f, -4.91988473e-03f, 3.97901759e-02f, -1.23535395e-02f,
  -1.00271955e-01f, -1.74107477e-02f, 5.54262735e-02f, -4.09376658e-02f, -4.09222506e-02f, 5.39257675e-02f, 7.52036422e-02f, 2.01187357e-02f, 2.23972015e-02f, 2.78254785e-02f,
  7.79724270e-02f, 7.23194182e-02f, 1.87782533e-02f, 3.46041992e-02f, 4.19279784e-02f, 2.45630965e-02f, 5.96385300e-02f, 4.38011959e-02f, -1.65145211e-02f, -4.52349186e-02f,
  5.32587804e-03f, 8.11447203e-02f, 3.75485350e-03f, -6.69419125e-04f, -1.75507665e-01f, -3.73581843e-03f, -2.17258446e-02f, -9.44313109e-02f, -7.68262893e-02f, 5.55229001e-02f,
  -1.20540395e-01f, 7.69115165e-02f, -6.02929899e-03f, -1.47902388e-02f, 7.46221468e-02f, 1.71102419e-01f, -4.53657545e-02f, 6.14999793e-02f, -8.26073438e-02f, -1.20156236e-01f,
  -6.97092339e-02f, -1.25712469e-01f, -5.78484274e-02f, -1.14104159e-01f, 1.48494355e-02f, -7.02395812e-02f, 4.26640026e-02f, -8.07275698e-02f, -7.69472495e-02f, -3.33640259e-04f,
  -1.01901349e-02f, -5.16116396e-02f, 3.57265281e-03f, -6.02905056e-04f, -4.49885838e-02f, 1.35382172e-02f, 2.06043050e-02f, -2.97139748e-03f, -2.89737806e-02f, -2.96103675e-03f,
  1.07528143e-01f, -4.42087464e-03f, -8.75189230e-02f, -5.35789914e-02f, -5.02529889e-02f, -9.34556872e-02f, -9.63992905e-03f, 4.34635840e-02f, -1.10665876e-02f, 8.36054608e-02f,
  -1.91092759e-03f, -2.95116808e-02f, 4.90780286e-02f, 7.46010244e-02f, -2.88811196e-02f, -8.67743790e-03f, -5.81224784e-02f, 3.40201426e-04f, -8.49927589e-03f, 3.45540643e-02f,
  -1.05199501e-01f, 7.31322542e-02f, 2.52928082e-02f, -5.57547435e-02f, -4.01764102e-02f, -6.78372309e-02f, 2.29420587e-02f, -4.07107435e-02f, 1.38350800e-02f, -2.93099061e-02f,
  -1.44743202e-02f, -2.13246830e-02f, -8.56456608e-02f, 8.53688419e-02f, 5.84553927e-02f, 5.99763356e-02f, -1.35182086e-02f, 8.56945664e-02f, -4.83597927e-02f, -5.15728034e-02f,
  -2.40679365e-03f, -4.29226533e-02f, 7.37334341e-02f, 5.32310195e-02f, -7.10038766e-02f, 7.23170862e-02f, 5.67703620e-02f, 9.60189626e-02f, 9.04147923e-02f, -4.00790758e-02f,
  6.47344589e-02f, -8.65682364e-02f, 3.68399359e-02f, 5.14315292e-02f, -7.58765936e-02f, -1.14763705e-02f, -7.15981470e-03f, 6.53340593e-02f, -3.99225950e-02f, 6.70337379e-02f,
  -2.81108115e-02f, 5.70026487e-02f, 4.62410934e-02f, -4.26449114e-03f, 1.63123328e-02f, 2.51755901e-02f, -6.77074343e-02f, 4.48604748e-02f, 5.64276502e-02f, -3.66651751e-02f,
  4.15596319e-03f, 5.74927554e-02f, 1.02147311e-01f, -4.27987166e-02f, -5.40949851e-02f, 6.03917427e-02f, -5.04549127e-03f, -1.81981064e-02f, 1.83299761e-02f, 7.70731568e-02f,
  -5.30465730e-02f, 9.86432508e-02f, -1.11707546e-01f, 7.41997659e-02f, -8.50346461e-02f, -6.52048290e-02f, -7.70778731e-02f, -1.19619399e-01f, -6.87540621e-02f, 9.26736072e-02f,
  1.19185410e-01f, -1.31497517e-01f, 4.62874398e-03f, 1.58369169e-01f, -6.19862825e-02f, 3.67169380e-02f, -3.51477368e-03f, -8.21520574e-03f, -1.22708373e-01f, -1.04961373e-01f,
  -2.04651169e-02f, 6.84872940e-02f, -6.27014264e-02f, 6.61168545e-02f, -2.80917846e-02f, -2.43103430e-02f, 8.86093527e-02f, -1.48297579e-03f, 1.52680706e-02f, -1.67315658e-02f,
  -3.61879654e-02f, 4.54759412e-02f, -7.89694022e-03f, -7.09594712e-02f, -2.14333609e-02f, 1.75467320e-03f, -6.71447590e-02f, -6.25104979e-02f, -8.19218606e-02f, -6.31946772e-02f,
  4.46744263e-02f, -7.49128684e-02f, -1.00799657e-01f, -7.91497603e-02f, 4.71209064e-02f, -3.41251749e-03f, -5.31951934e-02f, 4.49418500e-02f, -6.90027177e-02f, -3.38955410e-02f,
  3.76993492e-02f, -1.44954992e-03f, 7.33095855e-02f, 2.13143346e-03f, -1.30465580e-03f, 7.10595027e-02f, 5.92506938e-02f, 1.42301898e-02f, -1.27420332e-02f, -3.53742950e-02f,
  8.21977630e-02f, -2.37412211e-02f, 9.08853561e-02f, 2.76446119e-02f, -6.91201687e-02f, 3.83023210e-02f, 6.05693385e-02f, -5.71884587e-02f, 1.20907398e-02f, -6.65862635e-02f,
  -6.63867593e-02f, 8.11180323e-02f, -6.68300316e-02f, 6.73898831e-02f, -7.30420500e-02f, 4.16601561e-02f, 1.23997442e-02f, -1.88235403e-03f, -2.27730144e-02f, 2.37217303e-02f,
  1.46766985e-02f, 2.22512744e-02f, -2.86618099e-02f, -3.37452702e-02f, -8.29387680e-02f, -6.84692040e-02f, -7.14251548e-02f, 1.03311483e-02f, -6.13663234e-02f, 1.01976786e-02f,
  3.41423824e-02f, -1.18748613e-01f, -7.72957578e-02f, -8.39003250e-02f, 6.86404482e-02f, 4.43689898e-02f, -3.30339596e-02f, -7.10626319e-02f, -5.50854160e-03f, -2.12482344e-02f,
  -4.25915606e-02f, -5.40903807e-02f, -1.39994556e-02f, -5.59605174e-02f, -1.00487888e-01f, 2.85704173e-02f, 5.80776669e-02f, 5.31907268e-02f, 6.68411180e-02f, 2.31782608e-02f,
  6.38041645e-02f, 5.51831722e-02f, 8.79445858e-03f, 3.61776203e-02f, -7.74638802e-02f, -2.72297729e-02f, -7.53039047e-02f, -2.42742598e-02f, -8.36427510e-02f, -7.77531713e-02f,
  2.82882489e-02f, 1.26501903e-01f, 8.99079666e-02f, 2.10677668e-01f, -1.40043646e-01f, -1.63587853e-01f, -1.50314152e-01f, -9.33284238e-02f, 1.31686062e-01f, -3.86120491e-02f,
  -1.07228547e-01f, 1.28529176e-01f, -1.45715371e-01f, 4.06440794e-02f, 4.37763296e-02f, 2.94041336e-02f, 3.83485928e-02f, 4.36881222e-02f, 1.47233918e-01f, 1.37896966e-02f,
  1.24606118e-01f, 1.48364436e-02f, 1.24168634e-01f, 2.85210777e-02f, 6.29719645e-02f, 1.64398208e-01f, 1.03267245e-02f, 6.76991371e-03f, 2.61907447e-02f, 6.01344779e-02f,
  6.75084293e-02f, 6.72569722e-02f, 1.00695141e-01f, 1.33457733e-02f, -4.36971569e-03f, 4.52706739e-02f, -5.19966595e-02f, 3.26133743e-02f, -5.33860698e-02f, 8.23447555e-02f,
  8.72870237e-02f, 8.59752148e-02f, -1.76542625e-03f, 3.36717516e-02f, -7.54597858e-02f, 4.51495051e-02f, -6.89724088e-02f, 5.05400859e-02f, 8.32139477e-02f, -9.05208290e-02f,
  3.95421237e-02f, 3.90340909e-02f, 7.50467107e-02f, -2.19626864e-03f, -2.07328498e-02f, 4.53532971e-02f, 7.31237754e-02f, 3.29470783e-02f, 1.01028658e-01f, -1.94258466e-02f,
  9.38904211e-02f, -4.99694720e-02f, -3.65068991e-04f, 9.76143964e-03f, 3.62215899e-02f, 9.48442593e-02f, 2.14753207e-02f, -2.05659699e-02f, 2.64907293e-02f, 3.31461020e-02f,
  -1.79016050e-02f, -6.40154481e-02f, -5.23641668e-02f, 6.22302331e-02f, 6.06672727e-02f, -7.87140429e-02f, 6.59926161e-02f, 5.83433695e-02f, 9.74173173e-02f, -2.68899407e-02f,
  5.14168292e-02f, -4.74562794e-02f, -2.69365031e-03f, -2.48712748e-02f, 2.30556587e-03f, -3.74269150e-02f, 2.94658486e-02f, -1.36689274e-02f, -8.95096175e-03f, -4.98108342e-02f,
  6.86946511e-02f, 2.48216856e-02f, 1.08947977e-01f, 7.43159652e-02f, -6.94367439e-02f, -4.30892892e-02f, -2.53381096e-02f, -4.44221236e-02f, 4.93861698e-02f, 2.84815840e-02f,
  -3.26275229e-02f, 7.37102553e-02f, 4.83678505e-02f, 4.67574298e-02f, -4.43068109e-02f, -3.33608650e-02f, -4.52235043e-02f, 7.65566230e-02f, 8.66321772e-02f, 1.00477412e-01f,
  4.77770716e-02f, -4.57472913e-02f, -7.98732266e-02f, -3.23115140e-02f, 7.99311176e-02f, 5.10198474e-02f, -5.58759049e-02f, -2.86966972e-02f, 1.61635294e-03f, 7.84531608e-02f,
  -1.71545580e-01f, 2.49663502e-01f, 4.03639525e-02f, -1.24893039e-01f, 7.88754448e-02f, 7.56511614e-02f, 3.75137553e-02f, 1.20461062e-01f, 3.57674813e-04f, 1.04935497e-01f,
  -1.21493213e-01f, -3.74575667e-02f, 1.06541634e-01f, -5.49581908e-02f, -1.01706438e-01f, -1.06924297e-02f, -5.15876198e-03f, 8.82039685e-03f, 5.22373393e-02f, 2.00201124e-02f,
  5.01493178e-02f, -1.50420666e-01f, -3.32355425e-02f, -2.66513526e-02f, -1.18990108e-01f, 4.49382439e-02f, -1.84356347e-01f, -5.76892383e-02f, -4.27732170e-02f, -9.83848609e-03f,
  1.92095488e-02f, 5.92803862e-03f, 6.90227665e-04f, 2.26709899e-02f, 3.97499129e-02f, 4.28824089e-02f, -6.48725852e-02f, 4.24311459e-02f, 6.31129518e-02f, -8.03672746e-02f,
  -2.08559688e-02f, 6.57047331e-02f, -4.38828021e-02f, 4.49518152e-02f, 5.39002530e-02f, -2.18185075e-02f, 4.55016792e-02f, 3.23723666e-02f, 8.71889293e-02f, 8.64731614e-03f,
  1.60551688e-03f, 8.06045160e-02f, 3.55430804e-02f, 7.53137097e-02f, 7.47792721e-02f, -1.07781624e-03f, 7.88756460e-02f, -5.83168177e-04f, -5.45843095e-02f, 3.84245776e-02f,
  -7.33985230e-02f, 5.11969812e-02f, 9.86215845e-03f, 4.37887833e-02f, -7.79642537e-02f, -2.26678718e-02f, -5.54648563e-02f, 2.67571323e-02f, -8.96955375e-03f, -1.04960501e-01f,
  2.63359472e-02f, 5.07056154e-02f, -3.99628058e-02f, 7.66264682e-04f, 5.02315760e-02f, -7.25934654e-02f, 7.12401140e-03f, 3.48497964e-02f, -3.50949937e-03f, -3.15620424e-03f,
  6.16108887e-02f, -3.23190950e-02f, 4.38790061e-02f, 1.83852427e-02f, -5.81893250e-02f, 7.00968131e-02f, -5.48795052e-02f, 8.67474526e-02f, -5.87781705e-02f, -5.68514280e-02f,
  -9.93501116e-03f, -4.74660806e-02f, -5.47770374e-02f, 1.86616778e-02f, -1.32935802e-02f, -3.60229090e-02f, 2.13738167e-04f, 6.29027635e-02f, -1.12576902e-01f, 1.83916651e-02f,
  -4.80511598e-02f, -2.77531333e-02f, -8.11079070e-02f, -6.46976158e-02f, -2.19858903e-02f, -2.80087311e-02f, -1.11616896e-02f, 2.17094412e-03f, 7.71833397e-03f, -8.39459971e-02f,
  1.40496073e-02f, 7.08050579e-02f, -4.93570641e-02f, 2.79925589e-04f, -8.07430688e-03f, -9.66710895e-02f, -4.40373607e-02f, 6.43074587e-02f, -8.83661881e-02f, -1.37348007e-02f,
  1.82575792e-01f, -1.97650790e-01f, -1.86953302e-02f, 1.10642672e-01f, 7.44559690e-02f, 1.48828626e-01f, 1.87446594e-01f, 8.49270895e-02f, 5.41182607e-02f, 9.34804883e-03f,
  9.10653770e-02f, 5.15298061e-02f, -6.06088005e-02f, 4.21023108e-02f, 3.24913673e-02f, -3.35079171e-02f, 2.63270736e-02f, 6.55546337e-02f, -2.30379310e-02f, 8.20358321e-02f,
  9.56154689e-02f, 1.23962790e-01f, -9.95448157e-02f, -1.66121364e-01f, 6.39345422e-02f, -6.92073107e-02f, -1.21589959e-01f, -1.20038398e-01f, -1.46024600e-01f, -6.09460892e-03f,
  9.83680487e-02f, 1.93840452e-02f, 6.39607534e-02f, -1.00828379e-01f, -2.95931436e-02f, 7.93673471e-02f, -4.90825213e-02f, 5.59740588e-02f, -3.41747366e-02f, 7.52406474e-03f,
  -4.07163054e-02f, -1.73671916e-02f, 1.51341874e-02f, 2.84773968e-02f, -3.70655060e-02f, -8.51729587e-02f, 2.15826463e-02f, 1.06775068e-01f, -3.42376605e-02f, -7.28596449e-02f,
  -4.58024926e-02f, -3.55064943e-02f, 1.04624145e-01f, 1.08923996e-03f, -6.61351979e-02f, -2.88658887e-02f, -6.52927235e-02f, -3.15940529e-02f, -4.87108678e-02f, 8.39459375e-02f,
  2.81501450e-02f, 5.71626760e-02f, 8.70126486e-02f, 3.07772830e-02f, -1.09002562e-02f, 4.57106084e-02f, -6.81123585e-02f, -3.73128504e-02f, 6.15608990e-02f, -1.58456117e-02f,
  -6.27098754e-02f, 3.65089788e-03f, 1.27210291e-02f, -2.70089898e-02f, 3.36362161e-02f, -5.51489815e-02f, 1.61694549e-02f, -8.79394859e-02f, -5.30312210e-02f, -5.21090180e-02f,
  -3.22737135e-02f, -7.80366063e-02f, 8.63040760e-02f, -5.00288084e-02f, -9.24393476e-04f, -3.66033949e-02f, 5.47940806e-02f, 8.63344446e-02f, -2.80354201e-04f, 3.98978181e-02f,
  -3.99044715e-02f, -4.35385481e-02f, 7.22026080e-02f, -5.33165708e-02f, -4.83793691e-02f, 7.08948225e-02f, 7.62538752e-03f, 1.03484683e-01f, -4.67337295e-02f, 6.24987520e-02f,
  3.59586366e-02f, -1.90606676e-02f, 4.49278243e-02f, 3.43884272e-03f, -8.42972770e-02f, -2.60725655e-02f, 4.35825251e-02f, 3.58965583e-02f, 5.71598001e-02f, 1.91356540e-02f,
  -1.09454738e-02f, 3.07796337e-02f, 1.41849769e-02f, -4.47230041e-02f, -5.07306010e-02f, 7.29796663e-02f, 4.89686206e-02f, -3.85440290e-02f, 3.14919488e-03f, -3.69818956e-02f,
  -3.16819288e-02f, -1.26162857e-01f, 1.08101234e-01f, -1.98835414e-03f, -6.94817901e-02f, 1.33295208e-02f, -1.08329497e-01f, -5.86250126e-02f, -1.43151999e-01f, -1.72406733e-01f,
  -1.06173679e-02f, 3.85795608e-02f, -6.41758591e-02f, 1.20564416e-01f, 1.05784513e-01f, 3.75681594e-02f, 8.32953863e-03f, 1.27568990e-01f, -1.99167822e-02f, 7.38152536e-03f,
  1.10798456e-01f, -3.15737277e-02f, 1.88747093e-01f, 1.56358123e-01f, 3.60741131e-02f, 8.75337273e-02f, 1.34228438e-01f, 9.06356052e-02f, 1.98763907e-01f, 1.21579550e-01f,
  -8.80312547e-02f, 7.37047847e-03f, 5.59882540e-03f, -1.84065774e-02f, -5.42656779e-02f, 4.67315018e-02f, -1.66107509e-02f, -6.82137581e-03f, -6.30691424e-02f, -5.55395521e-02f,
  -5.68071455e-02f, -1.74100492e-02f, 8.22707266e-02f, -4.30601053e-02f, 1.69493482e-02f, 7.41591677e-02f, -4.37857620e-02f, -5.99855483e-02f, -1.57500058e-02f, 1.87942851e-02f,
  -4.87114601e-02f, 1.99193358e-02f, 2.49213036e-02f, -7.64594181e-03f, 3.27233113e-02f, 1.69787686e-02f, 1.78134944e-02f, -1.71686970e-02f, -6.15867525e-02f, -5.90050593e-02f,
  2.36237533e-02f, 2.24237572e-02f, 5.76472422e-03f, 6.49392009e-02f, -5.21133021e-02f, -3.39349397e-02f, 7.65425712e-02f, -6.71536326e-02f, 7.13543966e-02f, -8.73237625e-02f,
  -5.77031411e-02f, 3.28457505e-02f, -4.70384955e-02f, -7.40185231e-02f, 5.73172569e-02f, 6.93052486e-02f, 1.35654099e-02f, -8.01166594e-02f, -5.65329082e-02f, 1.35915922e-02f,
  -5.64614590e-03f, -7.74795040e-02f, -5.50241284e-02f, 4.32527959e-02f, 5.29027060e-02f, 2.13121739e-03f, 5.58687560e-02f, 6.06595315e-02f, 3.59196328e-02f, 7.76601897e-04f,
  -1.04858048e-01f, -9.49110687e-02f, -1.73542388e-02f, -1.05654933e-01f, -1.71942431e-02f, -4.92511839e-02f, 7.61265606e-02f, 5.82337826e-02f, 3.22290920e-02f, -1.30268764e-02f,
  -4.83279787e-02f, 6.70983791e-02f, -5.65368906e-02f, -5.33859134e-02f, 3.60003673e-03f, -7.83632174e-02f, 4.32162471e-02f, -9.50947870e-03f, 6.67554066e-02f, 5.98835945e-03f,
  2.49681412e-03f, 3.77195291e-02f, -3.39716412e-02f, 1.27792656e-02f, 8.98265280e-04f, 5.16349413e-02f, 5.28776692e-03f, 6.76566735e-02f, -2.16330662e-02f, 2.77458946e-03f,
  8.81643519e-02f, 3.26046869e-02f, 4.18102695e-03f, 1.64225295e-01f, -2.11661421e-02f, -7.76432455e-02f, -9.90816113e-03f, 2.27620639e-02f, 1.40897915e-01f, -2.19285134e-02f,
  -9.13477466e-02f, 1.56935137e-02f, -9.35152993e-02f, 8.70121121e-02f, -7.17512891e-02f, -1.42971441e-01f, 1.06216893e-01f, -8.39966089e-02f, 9.21226665e-03f, 2.20668446e-02f,
  -1.38204743e-03f, -8.52631778e-02f, 1.01938203e-01f, -1.09074913e-01f, 1.07033394e-01f, 5.92344515e-02f, 2.61422759e-03f, 8.19253400e-02f, 9.33206603e-02f, -3.38787474e-02f,
  -2.60589011e-02f, -1.97155271e-02f, -5.10605946e-02f, 1.11544386e-01f, 6.22525699e-02f, 4.50367923e-04f, -2.12795585e-02f, 2.81101489e-03f, -3.10390405e-02f, 3.09316386e-02f,
  1.44161917e-02f, -1.17195072e-02f, 4.52450700e-02f, -7.86091760e-02f, 4.56657968e-02f, 6.19303547e-02f, -3.17365956e-03f, 8.07006583e-02f, 5.37953563e-02f, -8.50129575e-02f,
  8.59003216e-02f, -6.46937490e-02f, 1.84158925e-02f, -2.55418047e-02f, 4.66625877e-02f, -5.03230989e-02f, 3.15278508e-02f, 7.78006613e-02f, 5.20314910e-02f, 2.35043764e-02f,
  -5.36217429e-02f, -6.25000596e-02f, -6.24635164e-03f, 8.73691738e-02f, 3.94563377e-02f, -5.38679510e-02f, 3.45761180e-02f, 1.83632020e-02f, 7.27754012e-02f, 3.53112072e-02f,
  -3.04651055e-02f, 8.16600397e-02f, -1.31136486e-02f, -5.44396043e-02f, 6.86121779e-03f, -7.36987293e-02f, -1.79036893e-02f, 9.74253006e-03f, -8.17106292e-02f, -7.00569674e-02f,
  6.39885440e-02f, 7.23625496e-02f, -5.32856807e-02f, -1.79153699e-02f, -2.69083474e-02f, -9.01083797e-02f, -3.99237648e-02f, -3.80295888e-02f, -5.87461479e-02f, -2.19755322e-02f,
  1.40363136e-02f, -3.37981172e-02f, -5.06503880e-02f, 1.59213494e-04f, 6.42646030e-02f, 2.51155067e-02f, 1.69472478e-03f, -5.70695773e-02f, 4.95046787e-02f, 7.33549967e-02f,
  7.08066225e-02f, 4.48140092e-02f, 3.06707416e-02f, 2.45721582e-02f, 5.59627973e-02f, 1.38315456e-02f, -1.79040059e-02f, -7.88131133e-02f, 3.26985717e-02f, -1.08506039e-01f,
  7.86100999e-02f, -2.19564326e-02f, -4.63295504e-02f, 3.99371469e-03f, -1.38531802e-02f, -6.65092990e-02f, -1.03248423e-02f, 8.47343877e-02f, -3.46265957e-02f, -2.76599154e-02f,
  -2.51725525e-01f, 1.00741945e-01f, -1.15359671e-01f, -7.40610734e-02f, -1.43501446e-01f, 2.26816926e-02f, 1.59340680e-01f, -1.98740773e-02f, -2.34479811e-02f, 1.01572670e-01f,
  5.48087247e-02f, -1.11634567e-01f, 8.76831859e-02f, 1.01499967e-01f, -6.39238656e-02f, 1.28725693e-01f, 3.57733034e-02f, 1.09749511e-01f, -6.64631128e-02f, -7.81946406e-02f,
  -3.05159204e-02f, 7.99142197e-02f, -4.60732169e-02f, -2.48198155e-02f, -7.14437217e-02f, -1.58300772e-01f, -8.42115730e-02f, -1.05746917e-01f, 2.16701776e-02f, -7.36696497e-02f,
  7.03374390e-03f, -8.65012631e-02f, -5.44966348e-02f, -1.18190154e-01f, 1.08095352e-02f, -6.67952895e-02f, -7.83058479e-02f, -5.52212149e-02f, 2.63636764e-02f, 2.72595715e-02f,
  -1.01906590e-01f, 9.64593980e-03f, 3.10877524e-02f, 5.80668636e-03f, -7.33487383e-02f, -6.64756447e-02f, -7.40242302e-02f, 3.29164229e-02f, 7.47134164e-02f, -3.65239978e-02f,
  8.18800554e-03f, -9.83580947e-03f, -4.43906374e-02f, 7.19106495e-02f, 4.12868559e-02f, -8.41342062e-02f, 7.54709989e-02f, -4.81488258e-02f, 3.59312259e-02f, -1.96354855e-02f,
  -2.29491554e-02f, -1.01995317e-03f, 3.06176823e-02f, -4.77816612e-02f, -7.09875226e-02f, 4.22295555e-02f, 8.21253881e-02f, -6.17105030e-02f, 1.64853856e-02f, -2.62673199e-03f,
  2.30593048e-02f, 9.22645722e-03f, 2.11172849e-02f, -8.65246076e-03f, -3.72757227e-03f, 8.93696547e-02f, 1.76373571e-02f, -7.34565780e-02f, 8.71982612e-03f, -7.73811266e-02f,
  -1.87168214e-02f, 6.22018576e-02f, -6.28666878e-02f, -2.47546937e-03f, 6.69477284e-02f, 4.19939570e-02f, -5.36930934e-02f, 7.60222152e-02f, 6.36006892e-02f, -8.97497088e-02f,
  -1.15238793e-01f, -8.13477039e-02f, -3.70956622e-02f, 1.04630301e-02f, 2.01791227e-02f, 5.09783775e-02f, -1.13813141e-02f, 7.17812628e-02f, -7.80870616e-02f, -9.55565050e-02f,
  5.95139451e-02f, -2.20268816e-02f, -1.97977386e-02f, -6.31324425e-02f, -3.52282301e-02f, 1.03631313e-03f, 6.12405688e-02f, -5.26508056e-02f, -1.10273687e-02f, -8.70774314e-02f,
  6.31705821e-02f, -5.15888520e-02f, 7.77923316e-02f, -5.95114455e-02f, 1.31982844e-02f, 5.30796908e-02f, -3.46358195e-02f, 2.70766914e-02f, -3.87995280e-02f, -5.02940826e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  2.22378135e-01f, 2.27095142e-01f, 8.58580470e-02f, -1.67660583e-02f, 1.42989397e-01f, 1.24451675e-01f, 1.06609520e-02f, 7.94020295e-03f, 9.64253843e-02f, -3.02070584e-02f,
  2.50920266e-01f, 6.64524063e-02f, -4.61447127e-02f, 6.16087392e-02f, 2.45068789e-01f, 7.36667514e-02f, -2.33050492e-02f, 1.02386825e-01f, -1.12294517e-02f, 1.07635446e-01f,
  6.20976044e-03f, -1.95165854e-02f, 9.92247313e-02f, 1.70285672e-01f, -3.06142103e-02f, 8.99585187e-02f, 1.75620198e-01f, 1.63274139e-01f, -3.19060721e-02f, 7.27247670e-02f,
  7.38811269e-02f, 6.22977056e-02f, 2.36236528e-02f, 9.14954022e-03f, 8.72666091e-02f, 6.14881963e-02f, 1.81150988e-01f, 2.13446647e-01f, 1.14161842e-01f, 2.19117090e-01f,
  1.44842610e-01f, 2.48277649e-01f, 4.44304049e-02f, 1.36310175e-01f, 3.35328914e-02f, 1.17568053e-01f, 5.92011400e-03f, 3.17457058e-02f, 1.43169507e-01f, 1.31914005e-01f,
  6.93592876e-02f, -1.34933656e-02f, 7.22458959e-02f, 2.15340848e-03f, 7.51075372e-02f, 1.67315960e-01f, 3.27182934e-02f, 1.16327979e-01f, 1.67770863e-01f, 7.68427029e-02f,
  1.41586915e-01f, 1.46443337e-01f, -1.11735379e-02f, 1.36583909e-01f, -2.13544555e-02f, 5.97717427e-02f, 1.16337039e-01f, 3.58943343e-02f, 1.13008179e-01f, 1.58260316e-01f,
  7.08733425e-02f, 8.33122507e-02f, 1.02670826e-02f, 5.58595732e-02f, 1.30428702e-01f, 4.48484235e-02f, 5.99913858e-02f, 1.14651635e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -5.49294055e-02f, -7.05277622e-02f, -3.86684775e-01f, 1.33303955e-01f, 3.38231362e-02f, 4.94543575e-02f, -2.17329245e-03f, 1.17116101e-01f, -1.41804609e-02f, 1.24328203e-01f,
  4.44154702e-02f, -1.86831623e-01f, -1.99380219e-02f, 1.72330186e-01f, -5.26792295e-02f, -2.15825289e-01f, -4.93290126e-02f, -1.27352059e-01f, -1.15927845e-01f, 6.94190115e-02f,
  -1.01218753e-01f, 1.02090344e-01f, -1.69404969e-01f, -1.06398255e-01f, -4.08205502e-02f, -2.42282376e-01f, 1.17161810e-01f, 3.94151121e-01f, -1.54676571e-01f, 6.02805614e-02f,
  1.41264364e-01f, -2.30039611e-01f, -6.51213527e-02f, 3.07678431e-01f, 1.78604320e-01f, 1.56977326e-01f, 2.50752091e-01f, -9.10915434e-02f, -5.92096150e-03f, -1.45372301e-01f,
  3.83502334e-01f, 2.39960343e-01f, -3.22584957e-01f, 1.36453286e-01f, -1.68898568e-01f, 3.87832195e-01f, -1.85100567e-02f, 3.03065926e-01f, -3.11111748e-01f, 6.45715445e-02f,
  -1.44092903e-01f, -1.33567512e-01f, -8.42826962e-02f, -5.32334112e-02f, -2.82906294e-02f, 1.29793603e-02f, -1.07123487e-01f, -7.06559941e-02f, 1.22057311e-01f, -1.38419606e-02f,
  1.04340941e-01f, -2.35373408e-01f, -1.42082378e-01f, 2.33271029e-02f, -3.06131124e-01f, -1.30065858e-01f, -1.68110225e-02f, -8.20120722e-02f, 1.45828187e-01f, 4.31151055e-02f,
  -1.17975213e-01f, -1.70264468e-02f, 1.76499814e-01f, 1.11307219e-01f, 7.25894943e-02f, -5.51595315e-02f, -9.79102254e-02f, 6.65682331e-02f, 1.07334308e-01f, 2.42790401e-01f,
  1.97146107e-02f, -1.06061555e-01f, 6.94877878e-02f, 2.41621993e-02f, 8.44392702e-02f, -6.15381487e-02f, 9.03497562e-02f, -2.36379006e-03f, 1.77550653e-03f, -1.35888562e-01f,
  -1.37341961e-01f, -2.18496099e-01f, -5.83040603e-02f, -8.17234889e-02f, 4.07839008e-02f, 3.40215057e-01f, -7.50801116e-02f, -4.39663604e-02f, -1.17649488e-01f, -2.24435087e-02f,
  -4.20464426e-02f, -1.53645992e-01f, 5.59779346e-01f, 2.90661991e-01f, -6.89258948e-02f, 1.74827054e-01f, 5.17330840e-02f, -5.12903072e-02f, 6.55255437e-01f, -1.04855508e-01f,
  -1.64138719e-01f, -2.48522446e-01f, -3.09769902e-02f, -1.91753373e-01f, -9.60820094e-02f, -8.77613202e-02f, 4.03349921e-02f, 5.98384216e-02f, -1.46202194e-02f, -1.70850933e-01f,
  1.60125390e-01f, 2.44202390e-01f, -7.74035677e-02f, 5.65914400e-02f, -3.61725464e-02f, -4.01671790e-02f, -3.93419713e-02f, 4.50473577e-01f, -7.98223391e-02f, 2.11411968e-01f,
  1.40292034e-01f, 1.04304954e-01f, -1.24776393e-01f, 2.27943510e-02f, 3.18724774e-02f, -1.86518684e-01f, 8.00400004e-02f, 1.06327139e-01f, -5.75895049e-02f, -2.25398108e-01f,
  7.53082335e-02f, 5.07298969e-02f, -2.28484701e-02f, 5.61877564e-02f, 8.34658518e-02f, 2.60485679e-01f, 1.19561777e-01f, -4.26485002e-01f, -1.83882475e-01f, -3.01591288e-02f,
  9.61024463e-02f, -1.85749367e-01f, -2.08491459e-01f, -1.52183995e-01f, -4.16837856e-02f, 7.97859207e-02f, 1.93801954e-01f, -5.17048426e-02f, -3.84191163e-02f, -3.61138672e-01f,
  5.08598052e-02f, 1.17235906e-01f, -3.55106175e-01f, -3.05211097e-01f, 3.70044082e-01f, 8.91609117e-02f, 8.57803747e-02f, -2.37957761e-01f, -1.34915784e-01f, 2.73533344e-01f,
  -3.99906933e-02f, -2.12451786e-01f, -4.58791077e-01f, -5.51276028e-01f, 2.72144854e-01f, -2.34059140e-01f, -4.12306875e-01f, 2.19738871e-01f, -9.42956656e-02f, -2.62112737e-01f,
  -1.37491181e-01f, 2.50339419e-01f, -5.86916544e-02f, 9.73029137e-02f, -6.69971630e-02f, 1.63554147e-01f, 5.83981685e-02f, 8.43919069e-02f, 4.64149505e-01f, 1.09619964e-02f,
  8.67715180e-02f, -1.22888803e-01f, 4.13284987e-01f, 9.88995433e-02f, -1.22648783e-01f, -3.26590016e-02f, -4.48261797e-02f, -1.08011208e-01f, 2.40580648e-01f, 1.42258063e-01f,
  1.65339082e-01f, 1.67988911e-01f, -1.53311908e-01f, -2.33658720e-02f, -3.86234149e-02f, -1.04797855e-01f, -8.29958320e-02f, 2.58275419e-01f, 1.28456667e-01f, -4.97662229e-03f,
  -1.20067485e-01f, -2.13357255e-01f, 1.65897563e-01f, -1.42658100e-01f, 3.41185868e-01f, -3.01474482e-01f, 2.09916562e-01f, -2.31751472e-01f, -1.91665925e-02f, -3.28430504e-01f,
  2.38462854e-02f, -9.11834762e-02f, 2.12422192e-01f, 2.33358920e-01f, -6.52773231e-02f, 1.12068109e-01f, -1.20981403e-01f, -2.27987364e-01f, -7.03219995e-02f, 7.90983140e-02f,
  3.76072600e-02f, -4.82481122e-02f, -1.77606530e-02f, 3.67323518e-01f, -2.12530166e-01f, -2.35122368e-01f, 1.43256605e-01f, 1.59401163e-01f, 6.56883568e-02f, -6.24848381e-02f,
  -6.34064674e-02f, -2.73673475e-01f, -9.82961804e-02f, -9.87844244e-02f, 9.60905701e-02f, -5.31561002e-02f, -1.04919605e-01f, -6.74538463e-02f, 1.02519360e-03f, 3.98857929e-02f,
  -2.16794640e-01f, -2.10983709e-01f, 2.86409616e-01f, -1.48108840e-01f, -1.31963506e-01f, 1.07001327e-02f, 4.29055691e-02f, -3.77450526e-01f, 6.10272884e-02f, 2.87420722e-03f,
  -4.30259109e-02f, -7.85470605e-02f, -1.67972967e-01f, 6.50400966e-02f, 1.17276281e-01f, -2.35339344e-01f, 2.94599915e-03f, -1.79749392e-02f, -8.19459110e-02f, -2.32418060e-01f,
  4.64691743e-02f, -1.08958177e-01f, -2.99012035e-01f, -1.70792624e-01f, -9.05785784e-02f, -1.16126440e-01f, -1.04404978e-01f, -1.87066365e-02f, 6.34245947e-02f, -8.84144083e-02f,
  7.12036341e-02f, -2.29856595e-01f, -4.59591568e-01f, -2.62406953e-02f, -3.89149748e-02f, 9.40903425e-02f, -1.04303084e-01f, -1.53211057e-01f, 4.43621213e-03f, -1.28381833e-01f,
  -3.20296884e-01f, 2.60033399e-01f, -1.30273446e-01f, 1.47951439e-01f, -3.92788261e-01f, 8.20687599e-03f, -2.06298947e-01f, 3.22685897e-01f, 2.58068413e-01f, -7.03381747e-02f,
  -1.06517062e-01f, -1.57176942e-01f, -1.77926719e-01f, -7.71611482e-02f, 2.86778629e-01f, -2.64588416e-01f, -1.57897279e-01f, -1.78050712e-01f, -2.68367138e-02f, 3.32598425e-02f,
  -2.65337750e-02f, -1.31898850e-01f, -1.71115637e-01f, -1.36295166e-02f, -9.36618000e-02f, 1.21309198e-02f, 4.04942930e-01f, -5.40399961e-02f, -3.30649763e-02f, 1.23116508e-01f,
  6.17819369e-01f, -1.46883562e-01f, 2.65932344e-02f, 4.12974954e-02f, -1.26926845e-03f, -8.67626816e-02f, -6.60411045e-02f, -7.43616819e-02f, -8.58060666e-04f, -3.22942593e-04f,
  3.16335354e-03f, -6.16529137e-02f, 1.12565741e-01f, -1.43081471e-01f, 1.04262508e-01f, 2.19613001e-01f, 1.73606738e-01f, 4.34769914e-02f, -8.62418860e-02f, -1.50253242e-02f,
  -5.36242090e-02f, 9.37033817e-03f, 3.07491928e-01f, 2.47237086e-02f, 4.66790348e-01f, -8.64733309e-02f, -4.87620309e-02f, 2.37564281e-01f, -1.66607305e-01f, -1.05580389e-01f,
  -1.03203170e-01f, -1.44110486e-01f, -1.31331176e-01f, -9.20233876e-02f, 1.18711077e-01f, -2.38174289e-01f, 6.24243217e-03f, 4.72881310e-02f, 2.39486005e-02f, -4.72149113e-03f,
  -3.18932012e-02f, -1.34488896e-01f, -7.28124306e-02f, 7.70610124e-02f, -1.46589637e-01f, 3.31718564e-01f, -1.27156571e-01f, -1.46359861e-01f, -8.81007463e-02f, 1.79870948e-01f,
  1.03343884e-02f, -9.72575843e-02f, -1.08645745e-01f, -1.73716154e-02f, 1.75279044e-02f, -1.72327787e-01f, -9.00467411e-02f, 2.02277806e-02f, 7.33778253e-02f, -1.50421605e-01f,
  -8.67530480e-02f, 2.76224762e-01f, 2.82283127e-02f, -1.08179495e-01f, -2.61372589e-02f, -1.63624033e-01f, 6.86927065e-02f, -2.13326942e-02f, -1.70103326e-01f, -7.92432129e-02f,
  -1.39710307e-01f, -1.38398036e-01f, 1.31679729e-01f, -3.19762409e-01f, 1.06567204e-01f, -7.00064609e-03f, -1.58283532e-01f, 1.03063956e-01f, -3.34995203e-02f, 5.14784344e-02f,
  1.21565685e-01f, -1.83483765e-01f, 5.41349500e-02f, -1.03277944e-01f, -2.27474049e-01f, -1.04520544e-01f, -1.82577893e-02f, -5.32216169e-02f, 2.95492932e-02f, 1.20175786e-01f,
  1.68756470e-01f, 2.06203744e-01f, 7.25859031e-02f, -3.49343151e-01f, 1.85437262e-01f, 3.75828087e-01f, 2.48372138e-01f, 6.31329557e-03f, 3.03198904e-01f, -7.75395557e-02f,
  -1.52034670e-01f, -2.79703110e-01f, -4.92848344e-02f, -8.07033703e-02f, -3.62077616e-02f, -1.22097805e-01f, -2.76972204e-01f, 6.17041960e-02f, 2.86542296e-01f, 3.72594476e-01f,
  -2.87898034e-01f, -3.49800915e-01f, 2.02859994e-02f, 1.95628658e-01f, -2.48876512e-01f, -4.13817167e-02f, 5.63404262e-01f, -2.62825582e-02f, 1.77484825e-01f, -3.18355262e-02f,
  -8.43158886e-02f, -4.07849438e-02f, -9.45830420e-02f, -1.84469342e-01f, -1.87831655e-01f, -4.77275066e-02f, 4.44592498e-02f, -3.55192535e-02f, -2.16282815e-01f, -7.05388412e-02f,
  -2.48070601e-02f, -9.52398703e-02f, 2.91087508e-01f, 4.65587974e-01f, 1.91068314e-02f, -1.18982121e-01f, -1.51018441e-01f, 2.96383705e-02f, -6.70390353e-02f, 4.57520187e-02f,
  7.51129612e-02f, -8.05135593e-02f, -4.37908135e-02f, -8.42672810e-02f, -2.88478509e-02f, -1.24006309e-01f, 1.17506191e-01f, 2.70714968e-01f, 1.22220591e-01f, 1.95694357e-01f,
  -1.32454246e-01f, -1.02392063e-01f, -1.32766031e-02f, 2.53487509e-02f, -1.28090665e-01f, -5.81147894e-02f, -1.55738145e-01f, 6.76074624e-02f, 1.65761471e-01f, 1.40696540e-01f,
  1.22698911e-01f, -7.21068978e-02f, 2.28796050e-01f, -1.87587412e-03f, -7.95316994e-02f, 1.15811834e-02f, 2.03971446e-01f, -1.85915798e-01f, -1.40623420e-01f, -1.26749605e-01f,
  2.39524305e-01f, -1.79676309e-01f, -4.83504906e-02f, -8.83923620e-02f, 1.56981945e-02f, 1.02276333e-01f, 4.92280126e-02f, -4.77949604e-02f, -1.54867321e-01f, -2.36555800e-01f,
  -2.12613896e-01f, 6.03563905e-01f, 2.00825199e-01f, 3.59459221e-01f, -1.61496252e-01f, 1.13168262e-01f, -1.29847050e-01f, 1.02609783e-01f, -8.34975392e-02f, -1.11507609e-01f,
  -8.36696550e-02f, 2.85290498e-02f, 1.47245556e-01f, 1.78004220e-01f, 4.67451178e-02f, -1.68366954e-01f, 1.40167505e-01f, 1.29441097e-01f, 3.03299934e-01f, 1.21379144e-01f,
  -1.78398397e-02f, 5.04887879e-01f, 1.31147563e-01f, 1.99298300e-02f, 1.21894993e-01f, 1.49342027e-02f, 5.94588108e-02f, -2.00066436e-02f, -2.06823587e-01f, 1.26968637e-01f,
  1.11612283e-01f, -8.45330283e-02f, 5.17493337e-02f, 6.76655173e-02f, 6.70419335e-02f, 2.58961886e-01f, -3.40412650e-03f, -1.75247677e-02f, 1.26671731e-01f, 1.00622848e-01f,
  -4.51770633e-01f, 1.42531618e-01f, 5.86708635e-02f, 2.56141834e-03f, 3.30057621e-01f, -2.38108858e-01f, 8.47133324e-02f, 3.72895226e-02f, -1.56436473e-01f, 1.48401052e-01f,
  -7.17632398e-02f, -3.66078526e-01f, 2.83822626e-01f, 1.77491419e-02f, -4.34436202e-01f, 2.56575733e-01f, 5.24926364e-01f, 3.63024205e-01f, 2.67805040e-01f, 2.07353234e-01f,
  2.77959436e-01f, -1.14231743e-01f, 3.71065676e-01f, 4.11878794e-01f, -1.72992665e-02f, -7.84371197e-02f, -1.82744592e-01f, 1.41766310e-01f, 1.03507474e-01f, -2.19834261e-02f,
  2.32489649e-02f, 9.65967998e-02f, -2.79656023e-01f, -1.11918896e-01f, 1.18721925e-01f, -1.00028217e-02f, -1.77029014e-01f, -1.67144486e-03f, 9.25321206e-02f, -8.43775645e-02f,
  -3.87158878e-02f, 7.43256956e-02f, -1.01651989e-01f, -9.25536156e-02f, -1.80932492e-01f, 2.08520275e-02f, 8.15188810e-02f, -1.63574085e-01f, 1.65494561e-01f, 1.64579675e-01f,
  2.00350117e-02f, 1.53988674e-01f, -2.55048424e-01f, -1.79391518e-01f, -3.91364433e-02f, 1.40403658e-01f, -1.52606532e-01f, -1.77160904e-01f, -1.74040973e-01f, -2.61680692e-01f,
  2.94453740e-01f, 9.60896388e-02f, -1.80017322e-01f, 2.83521004e-02f, -1.31338894e-01f, -6.02599373e-03f, 1.03943527e-01f, 3.23586822e-01f, 1.72023147e-01f, -3.67014632e-02f,
  -1.45107776e-01f, 2.08610252e-01f, -1.65036559e-01f, -5.52986413e-02f, -7.71654397e-02f, -8.27319399e-02f, 2.54094839e-01f, -1.80801600e-01f, 3.56629603e-02f, 9.78111476e-02f,
  -1.01505354e-01f, -7.78658390e-02f, 1.87907338e-01f, 4.04467851e-01f, -2.54677366e-02f, 3.00151552e-03f, 4.61832210e-02f, -5.80323786e-02f, 1.24514498e-01f, 2.15280369e-01f,
  4.09802496e-01f, -1.70570925e-01f, -4.14812937e-03f, -1.33060545e-01f, -5.54445535e-02f, 2.67120659e-01f, -2.00394362e-01f, 1.30990937e-01f, -1.66198149e-01f, 8.12324658e-02f,
  6.90151379e-02f, 1.39195591e-01f, 1.22853003e-01f, 1.47038065e-02f, 1.33341461e-01f, 2.23412346e-02f, 1.01678051e-01f, -6.51942641e-02f, 3.01096261e-01f, 9.44425240e-02f,
  1.50715321e-01f, 1.74654558e-01f, 9.02644098e-02f, -3.08396339e-01f, 6.43161638e-03f, -6.30322471e-02f, 1.85539946e-01f, 8.82458463e-02f, 7.26200193e-02f, 1.48639530e-01f,
  2.36581862e-01f, -1.08869612e-01f, 1.96423143e-01f, 1.50750399e-01f, 4.75208834e-02f, 7.38569424e-02f, 1.09847002e-01f, -7.01534599e-02f, 2.44174570e-01f, 2.28099659e-01f,
  1.12875663e-01f, -9.42107067e-02f, -2.98913211e-01f, 2.26640612e-01f, -2.32565135e-01f, 2.49017537e-01f, 2.20872328e-01f, 1.07119046e-01f, 4.77990419e-01f, 5.73224947e-02f,
  3.17499071e-01f, -3.84288281e-01f, 7.19431369e-03f, 5.56512624e-02f, -4.57763880e-01f, 6.60702959e-02f, 3.65296960e-01f, -2.56520540e-01f, -1.55894026e-01f, 3.93183976e-01f,
  3.96874458e-01f, 6.35563955e-02f, -8.22365060e-02f, 1.47770837e-01f, 1.26787145e-02f, -1.13838449e-01f, -2.14624871e-02f, 1.36414587e-01f, -6.08763397e-02f, -2.55670119e-03f,
  -2.68689126e-01f, -6.75009713e-02f, -6.57637715e-02f, 8.75168294e-02f, -1.04296692e-01f, 1.90032706e-01f, -1.06266715e-01f, -1.85654268e-01f, 1.08402900e-01f, -1.03425950e-01f,
  4.10370603e-02f, 2.31401976e-02f, -1.03034250e-01f, -2.20659330e-01f, 2.90616136e-02f, 9.83462902e-04f, -1.84197336e-01f, 1.64046884e-01f, -2.29328778e-02f, -1.08412288e-01f,
  3.76036346e-01f, 1.08830571e-01f, 7.43166590e-03f, -7.16046691e-02f, 1.02245271e-01f, -1.64262522e-02f, 5.57187237e-02f, -1.29489660e-01f, -2.73740619e-01f, 1.36678711e-01f,
  4.97703880e-01f, -1.84377342e-01f, 2.99490392e-01f, -1.05900250e-01f, -4.30505499e-02f, -5.93526661e-02f, -4.28655148e-02f, 5.62648475e-03f, -1.69337019e-01f, 2.10535094e-01f,
  1.93867624e-01f, -2.09264718e-02f, -1.45070910e-01f, -7.96467289e-02f, 1.30978554e-01f, 5.33107668e-02f, 9.70488265e-02f, -1.02512330e-01f, 1.85973302e-01f, -2.01902822e-01f,
  3.70419137e-02f, -1.06627829e-01f, 1.25714242e-01f, -2.28944913e-01f, 3.48950535e-01f, 1.21258162e-01f, -1.03735887e-02f, -1.67822123e-01f, 2.11637397e-03f, 8.80323052e-02f,
  1.02017149e-01f, -2.04219878e-01f, 1.10232577e-01f, 1.35067746e-01f, 4.02428024e-02f, -1.89485833e-01f, 3.91849056e-02f, 6.86072633e-02f, 3.12158428e-02f, -2.99494743e-01f,
  -1.38804838e-01f, -3.60227451e-02f, 1.08249344e-01f, 5.49317375e-02f, 8.92969519e-02f, 4.25428450e-02f, -5.67297786e-02f, 2.07040068e-02f, -2.57507980e-01f, -5.04866466e-02f,
  1.91161484e-02f, 1.43582553e-01f, 6.96673840e-02f, 1.88814495e-02f, 2.66432673e-01f, -2.33508632e-01f, 1.16247080e-01f, 1.37268558e-01f, -8.08158144e-02f, 1.44147471e-01f,
  2.30978224e-02f, 4.79673371e-02f, 2.01998189e-01f, 1.18532814e-01f, -5.62222242e-01f, -2.57839531e-01f, -2.20409390e-02f, 3.93384360e-02f, -3.45953405e-02f, 2.78089881e-01f,
  -2.53642559e-01f, -3.83665413e-01f, -2.98359782e-01f, 3.25302213e-01f, -1.17432140e-01f, 3.13576236e-02f, 3.64772439e-01f, -9.20651481e-02f, -4.29637164e-01f, -1.01997644e-01f,
  3.62623513e-01f, -7.73360282e-02f, 2.04641819e-02f, -4.25505072e-01f, 1.11375131e-01f, 2.37436946e-02f, -2.82691121e-02f, -7.08223581e-02f, 1.63698837e-01f, -2.43256643e-01f,
  -1.13219850e-01f, -1.28251687e-01f, -2.03379840e-02f, -1.16764210e-01f, 1.49582818e-01f, -1.47231147e-01f, -8.32826644e-02f, 3.91120687e-02f, 2.33071104e-01f, -1.72159329e-01f,
  -1.07010799e-02f, -1.57481432e-01f, -3.36070992e-02f, -1.79475799e-01f, 3.66320685e-02f, -1.40452176e-01f, 7.84695745e-02f, -4.41733301e-02f, 1.33499265e-01f, -1.97167471e-02f,
  -2.07580030e-01f, -2.94539407e-02f, -1.44194573e-01f, 4.58359957e-01f, -5.76618202e-02f, 4.44637835e-02f, -1.40452191e-01f, -2.36497119e-01f, 2.20047459e-01f, 5.78448176e-02f,
  -1.32681683e-01f, 4.34219241e-02f, 6.10523522e-02f, -3.66125576e-04f, 1.01236766e-02f, 3.88554573e-01f, -5.85084744e-02f, -1.61453515e-01f, 2.26491436e-01f, -1.29641742e-01f,
  9.96607244e-02f, 6.82641612e-03f, -4.18831892e-02f, -1.26104206e-01f, -6.28334796e-03f, 7.26002641e-03f, -1.28063574e-01f, 3.51807922e-01f, 6.61724657e-02f, -9.74231362e-02f,
  -1.53204679e-01f, 6.89229146e-02f, -1.69223815e-01f, -8.17784220e-02f, -5.98644167e-02f, 3.05794984e-01f, -2.56085634e-01f, -1.25205532e-01f, 2.13909209e-01f, 2.91568905e-01f,
  -1.85752049e-01f, 5.73408902e-01f, 1.60651311e-01f, -1.52254581e-01f, -1.46685377e-01f, -1.52943566e-01f, 1.44390594e-02f, -4.77218702e-02f, -1.34540096e-01f, -5.95734008e-02f,
  -4.59627695e-02f, -5.33903353e-02f, 3.07900488e-01f, -1.48788571e-01f, 1.20457724e-01f, -1.00532025e-01f, -1.18831456e-01f, -5.98143553e-03f, 3.24826278e-02f, -4.36008573e-02f,
  8.32243860e-02f, -1.28212810e-01f, -3.31171937e-02f, -1.05225414e-01f, -1.88710108e-01f, -1.51435480e-01f, 3.34543735e-02f, -6.20469190e-02f, -1.57475457e-01f, -1.72445118e-01f,
  -6.69089183e-02f, 3.83326150e-02f, -1.17230592e-02f, -2.05153265e-05f, -2.08418101e-01f, 3.56153361e-02f, -9.12798643e-02f, -7.80883506e-02f, -4.25849631e-02f, 4.48381342e-03f,
  -1.38016880e-01f, 2.96691656e-01f, -9.67820808e-02f, 1.34007186e-01f, 2.34349340e-01f, -1.26788005e-01f, 9.60783958e-02f, -1.14853151e-01f, 2.77127266e-01f, -8.34514275e-02f,
  3.10854018e-01f, -6.58070818e-02f, -1.28724709e-01f, 2.25692153e-01f, 2.41445079e-01f, 2.01158479e-01f, -1.46781905e-02f, 8.44421331e-03f, -7.20884055e-02f, 2.18686789e-01f,
  1.32175133e-01f, 2.12984115e-01f, -1.15702599e-01f, 5.46199754e-02f, 6.72021508e-02f, -2.18039617e-01f, -1.46615937e-01f, -6.72263801e-02f, 3.70520428e-02f, -1.56050343e-02f,
  3.67412381e-02f, 3.70462537e-01f, 1.45337999e-01f, -6.79624528e-02f, -9.38382298e-02f, -2.41694394e-02f, -1.74201906e-01f, -1.07983164e-01f, 1.62474364e-01f, -2.32472178e-02f,
  -5.28451018e-02f, -1.77426502e-01f, -7.52262250e-02f, -1.46374717e-01f, 2.45981803e-03f, 4.39135432e-01f, 8.78760666e-02f, 3.01524043e-01f, -6.19769804e-02f, -1.75762445e-01f,
  4.18580174e-02f, -1.04908226e-03f, 2.40730554e-01f, -1.12660753e-03f, -1.29848272e-01f, 1.17715513e-02f, 3.66970040e-02f, 7.83185214e-02f, 1.37200892e-01f, -4.38116901e-02f,
  -1.37446657e-01f, 4.07097638e-01f, -1.44708231e-01f, -2.86760367e-02f, -8.81522074e-02f, 4.02387828e-01f, 1.76149525e-03f, 6.12295419e-02f, 3.04383069e-01f, 1.14696510e-02f,
  3.70140187e-02f, -9.03345719e-02f, -1.12533920e-01f, -1.46630958e-01f, -8.92711803e-03f, -5.62069602e-02f, -3.65715958e-02f, 4.79601994e-02f, -2.58070007e-02f, -7.90217891e-02f,
  2.93759983e-02f, -1.26378119e-01f, -1.64787695e-02f, -1.21621720e-01f, -1.24588557e-01f, -3.22442539e-02f, -1.35398909e-01f, 4.23412547e-02f, -1.06597528e-01f, -3.46336467e-03f,
  -1.14365490e-02f, 6.42821729e-01f, 1.46003693e-01f, -1.30230278e-01f, -6.37476593e-02f, 6.80434331e-02f, 2.39765167e-01f, 2.24072840e-02f, 8.60731602e-02f, 2.23164055e-02f,
  -5.78787811e-02f, -1.25076463e-02f, -1.09383821e-01f, -5.34098037e-03f, -1.81454033e-01f, -4.06491719e-02f, -3.43739726e-02f, -1.01025678e-01f, 9.69428867e-02f, -8.07828084e-02f,
  2.74623893e-02f, -6.82323948e-02f, -1.50584862e-01f, 1.26921505e-01f, 1.51226044e-01f, 4.30816524e-02f, -4.51279618e-02f, -1.25048518e-01f, -1.19210646e-01f, 5.59227839e-02f,
  2.62395851e-02f, -1.16870701e-01f, -1.27336100e-01f, -7.29405461e-03f, -4.15572971e-02f, -7.20245317e-02f, 3.40140089e-02f, 6.74066469e-02f, 6.56905249e-02f, 4.05342668e-01f,
  3.13941002e-01f, 9.27593112e-02f, -1.88711122e-01f, 1.01409920e-01f, 1.32932454e-01f, 1.61578581e-02f, -1.33732855e-01f, 1.91544846e-01f, -4.74058948e-02f, 8.59365836e-02f,
  1.65620744e-01f, 7.45860934e-02f, -2.13843435e-01f, 3.04309189e-01f, 1.13316320e-01f, 2.49838948e-01f, 2.85864174e-01f, -1.98144540e-01f, -2.35478938e-01f, -2.51316369e-01f,
  1.87487751e-01f, -1.15371071e-01f, 1.33735053e-02f, 1.45913940e-03f, -1.69535086e-01f, -1.92162633e-01f, -1.40502661e-01f, -8.01598504e-02f, 3.08458477e-01f, -1.21259652e-01f,
  1.80939972e-01f, -1.43215731e-01f, 2.55901724e-01f, 7.17559451e-05f, -2.15138063e-01f, 3.90224606e-01f, 7.48990802e-03f, 2.11577177e-01f, 2.97571093e-01f, 3.00036341e-01f,
  9.65494588e-02f, -1.08455919e-01f, -1.09123051e-01f, -1.07883655e-01f, 9.92852729e-03f, -9.99868289e-03f, 9.63482633e-02f, 5.46267852e-02f, -2.18848400e-02f, -6.66636229e-02f,
  -5.56670688e-02f, -1.55115843e-01f, 1.89132676e-01f, -5.28761595e-02f, -8.78318623e-02f, -9.78606790e-02f, -8.49883407e-02f, 1.45811392e-02f, 4.39277152e-03f, 1.82681277e-01f,
  -1.85489014e-01f, -1.68287098e-01f, -1.95025936e-01f, -1.24391623e-01f, -4.58531491e-02f, 5.80337465e-01f, 1.44825261e-02f, 2.42011935e-01f, -1.09488210e-02f, -9.75490734e-03f,
  2.27540731e-02f, 2.56025493e-01f, 1.53044969e-01f, -4.39827777e-02f, 9.64894965e-02f, -7.49998167e-02f, 2.84801726e-03f, -9.25440714e-02f, -1.08010866e-01f, -7.26425648e-03f,
  -9.06151310e-02f, 4.53308821e-02f, -2.25898042e-01f, 2.65534461e-01f, -9.95238274e-02f, -4.30482216e-02f, 2.67088532e-01f, -1.70486674e-01f, 1.67185310e-02f, -1.10641263e-01f,
  -1.74342096e-01f, -1.39759546e-02f, -1.26258895e-01f, -1.16840690e-01f, -4.86993194e-02f, -7.44437892e-03f, 2.87866801e-01f, -8.21804255e-02f, -1.77705199e-01f, 1.99400634e-01f,
  1.22443683e-01f, -1.55375198e-01f, 7.65432930e-03f, 5.46774082e-02f, -3.78351123e-03f, 2.05606222e-02f, 1.00424670e-01f, -7.69595429e-03f, -1.56490803e-02f, 2.00530469e-01f,
  -1.84445262e-01f, -3.38300280e-02f, 1.37969211e-01f, 1.50134146e-01f, 3.92143056e-02f, 1.82505190e-01f, 6.25907034e-02f, 1.49592787e-01f, 2.26800442e-01f, 2.14290410e-01f,
  -1.24024250e-01f, 1.88516006e-01f, 9.60670039e-02f, -3.08095422e-02f, -2.84837037e-01f, -5.94739169e-02f, -7.62984902e-02f, -2.90651023e-02f, -1.31848752e-01f, -1.23858176e-01f,
  -1.35124177e-01f, 1.32976919e-01f, -1.38409808e-01f, -3.67437661e-01f, 9.25301239e-02f, -3.96575183e-01f, -4.29074198e-01f, -2.33200341e-01f, -3.71901542e-02f, 6.73826411e-02f,
  -2.70077884e-01f, 2.25862905e-01f, -1.16896048e-01f, -1.75573006e-02f, 1.53944090e-01f, 3.10849786e-01f, -5.42656779e-02f, 1.97886974e-01f, -9.17426646e-02f, 4.65038538e-01f,
  -2.33924463e-01f, -4.94256765e-01f, -1.81820974e-01f, 2.91682780e-01f, -1.39945820e-01f, -1.23630844e-01f, -1.40501171e-01f, 1.01763152e-01f, 8.34342167e-02f, -1.80696115e-01f,
  2.24296004e-01f, -1.18037462e-01f, 9.57523957e-02f, -2.01852098e-02f, 4.31667678e-02f, 7.04271719e-02f, -2.42884085e-01f, -1.75334796e-01f, 1.12749375e-01f, -1.37580782e-02f,
  -1.09094411e-01f, 7.80781209e-02f, -5.53200617e-02f, -1.18677378e-01f, 9.45793912e-02f, -2.63063550e-01f, 1.70138747e-01f, -1.55151770e-01f, 3.20334584e-02f, 2.11092800e-01f,
  4.92017977e-02f, -1.41244680e-01f, -1.24362163e-01f, 3.62959683e-01f, -1.11787319e-01f, -8.41751099e-02f, 2.80292816e-02f, -1.33175090e-01f, -8.89038388e-03f, 5.07804990e-01f,
  -2.01479271e-01f, 4.24470633e-01f, -1.20047495e-01f, -2.10415214e-01f, -1.16867177e-01f, -3.42330299e-02f, -2.67244736e-03f, -1.55539677e-01f, 1.26810387e-01f, 2.96830628e-02f,
  -4.73128185e-02f, -9.71250683e-02f, -3.69893238e-02f, -3.01081818e-02f, -2.35220462e-01f, 2.42282659e-01f, 3.67258966e-01f, -7.59030133e-02f, -1.80860292e-02f, 1.78086922e-01f,
  -1.51229501e-01f, -1.31359503e-01f, -1.68423057e-01f, -3.60619202e-02f, -8.77510104e-03f, 3.43223572e-01f, -5.13207316e-02f, -4.55427989e-02f, 3.81645739e-01f, -1.83904078e-02f,
  -7.84592628e-02f, -8.85567591e-02f, 1.08432621e-01f, -5.45164496e-02f, -1.78470090e-01f, -1.33095086e-01f, 1.47967622e-01f, 1.02144800e-01f, -7.82762247e-04f, -2.42015105e-02f,
  5.32940589e-02f, 4.94724959e-02f, 2.06706747e-01f, 1.13803439e-01f, 5.90368882e-02f, 8.93021077e-02f, 1.91284418e-02f, -1.83855500e-02f, 7.31306672e-02f, -6.21065423e-02f,
  -2.39794150e-01f, -2.67305374e-02f, -1.43792853e-01f, 4.76033129e-02f, 1.76716998e-01f, 1.01340733e-01f, 1.98016495e-01f, 2.01691538e-01f, 1.57550439e-01f, 2.76620626e-01f,
  2.21093401e-01f, 7.53387883e-02f, -6.45441115e-02f, 8.16305950e-02f, 1.46675944e-01f, -2.25665033e-01f, 4.73435819e-02f, 2.86897505e-03f, 7.22608864e-02f, -3.51848394e-01f,
  -1.68965198e-02f, 3.52043509e-01f, 2.94922352e-01f, 7.30813816e-02f, 5.12476087e-01f, -4.93188560e-01f, -2.92803049e-01f, -3.75943482e-01f, -1.26134023e-01f, -1.59179121e-01f,
  -2.19687134e-01f, 9.69026759e-02f, -5.11978418e-02f, -1.07063912e-01f, -4.84138839e-02f, -4.51106802e-02f, -2.52043247e-01f, -3.98411483e-01f, 2.37018257e-01f, 2.06323788e-01f,
  -1.06893972e-01f, -1.39249906e-01f, -8.08060840e-02f, -4.74594273e-02f, 1.74830675e-01f, -2.07998622e-02f, -1.43656065e-03f, -1.17241880e-02f, -1.36962980e-01f, 1.10965349e-01f,
  -1.52647689e-01f, 2.28733957e-01f, 8.50356966e-02f, -9.27967280e-02f, -1.55732641e-02f, -3.57336998e-02f, -8.05972964e-02f, 5.37948728e-01f, -6.29156083e-02f, -1.94710135e-01f,
  -1.85178101e-01f, -1.32160246e-01f, -6.30380437e-02f, 4.93127435e-01f, 2.48612836e-02f, -3.68621945e-02f, 1.75807059e-01f, -6.31906688e-02f, 1.25132173e-01f, 5.56129962e-04f,
  1.86375454e-02f, -1.84021890e-01f, 5.10387346e-02f, -9.22427550e-02f, -1.46786034e-01f, -1.43295527e-01f, 2.84301843e-02f, -1.14431106e-01f, 1.67641453e-02f, -2.69476444e-01f,
  -1.64707288e-01f, -8.86108726e-02f, 2.40348093e-02f, -2.07335413e-01f, 1.52843267e-01f, -1.68003038e-01f, -1.24198072e-01f, -1.40427068e-01f, 5.01651108e-01f, -7.94776902e-02f,
  6.03493750e-02f, 2.82959759e-01f, -1.56573564e-01f, 5.13136089e-02f, -4.92218956e-02f, -1.21524855e-02f, -1.41045302e-01f, -1.69423699e-01f, -1.26679093e-01f, 7.09614083e-02f,
  2.67780982e-02f, -1.15757957e-01f, 1.07676506e-01f, -1.40757933e-01f, 9.17595625e-03f, 4.69795614e-02f, -1.31004438e-01f, -1.23143189e-01f, -1.49536222e-01f, -1.80046335e-02f,
  -5.65600991e-02f, 3.26532796e-02f, -1.66744605e-01f, -4.96157892e-02f, -1.07284794e-02f, -9.63846669e-02f, 8.18218198e-03f, -4.59113345e-02f, -2.21205615e-02f, 1.45709962e-01f,
  1.05999753e-01f, 1.03822701e-01f, -1.51330009e-01f, -5.89829832e-02f, -5.67728132e-02f, -8.20214823e-02f, 1.31693995e-02f, 2.34058157e-01f, 1.60166562e-01f, -1.96061302e-02f,
  1.25813007e-01f, -6.10677246e-03f, 6.79556206e-02f, 9.44216698e-02f, -3.47901106e-01f, 1.24716863e-01f, -1.60567701e-01f, -1.19628593e-01f, 1.25602812e-01f, 2.32310989e-03f,
  9.01605189e-02f, -2.88062871e-01f, 1.22199520e-01f, -8.78632218e-02f, 1.73866495e-01f, -1.44056424e-01f, 2.45341435e-01f, -5.13646781e-01f, -4.46733564e-01f, 3.50851804e-01f,
  -2.40877002e-01f, 3.65280479e-01f, -1.38598541e-03f, 7.94760361e-02f, -1.17635913e-01f, -2.13744342e-01f, 7.02134892e-02f, 2.73387611e-01f, -9.91447195e-02f, -5.04976571e-01f,
  2.09022015e-01f, -3.87969196e-01f, 3.57255250e-01f, -5.23991436e-02f, -1.73836663e-01f, 1.51784584e-01f, 5.12784541e-01f, 3.17021087e-02f, 3.55831057e-01f, 1.56663924e-01f,
  1.22281089e-01f, -3.79530131e-03f, 7.75170699e-03f, -4.16206522e-03f, 1.41615504e-02f, 5.34460694e-02f, 1.49741828e-01f, -1.46850482e-01f, -2.60566950e-01f, 1.17403619e-01f,
  9.78546515e-02f, -2.06524342e-01f, -1.32456034e-01f, 1.09828658e-01f, 1.87250167e-01f, -8.67837891e-02f, -1.29175067e-01f, -8.08175802e-02f, -1.19121429e-02f, 9.36707407e-02f,
  2.48670861e-01f, -1.07950605e-01f, -8.10906887e-02f, -1.17583334e-01f, -8.63374919e-02f, -1.99230984e-01f, 5.17287999e-02f, -9.87426564e-02f, -5.48804142e-02f, 1.05277665e-01f,
  7.12688491e-02f, 1.54282257e-01f, 1.22512810e-01f, -9.68724042e-02f, -1.47574231e-01f, 2.80399561e-01f, -2.18522130e-03f, -1.08632140e-01f, -7.97123685e-02f, 2.70886362e-01f,
  2.16777064e-02f, 3.12833995e-01f, -1.51709184e-01f, -1.36357680e-01f, -1.09907940e-01f, -1.49922743e-01f, -2.38269180e-01f, 2.00229675e-01f, -6.65823072e-02f, -2.13659424e-02f,
  -5.18286275e-03f, -6.09877370e-02f, -1.42782092e-01f, 5.47667556e-02f, 9.22671929e-02f, -4.23646942e-02f, -1.37053117e-01f, -1.46950319e-01f, 2.31570274e-01f, 1.98828503e-01f,
  -1.05203398e-01f, 1.65926926e-02f, 1.25673622e-01f, -5.59497997e-02f, -2.00463571e-02f, -1.37787268e-01f, -1.47143230e-01f, 3.15882236e-01f, 1.04716584e-01f, -1.33860400e-02f,
  1.31882340e-01f, 1.56875670e-01f, 5.06094545e-02f, 4.62337397e-02f, 2.11442590e-01f, -1.60630077e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.11863660e-02f, 3.54753248e-02f, 1.69607457e-02f, -4.12965901e-02f, 1.86520815e-03f, 1.93518158e-02f, 3.21103223e-02f, -5.40937409e-02f, -1.06156394e-01f, -3.75508778e-02f,
  7.15949088e-02f, 5.38070500e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    