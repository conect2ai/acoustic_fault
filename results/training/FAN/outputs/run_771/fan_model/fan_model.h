/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.39959578e-02f, -1.03519179e-01f, 6.32543042e-02f, -3.98812480e-02f, -1.66149572e-01f, -4.71023694e-02f, -4.40472551e-02f, -2.26038080e-02f, 2.47893594e-02f, -1.59411356e-02f,
  -2.58599162e-01f, -1.88952666e-02f, 1.89356580e-01f, 1.34238005e-01f, 1.66831896e-01f, 8.73245075e-02f, 2.54871726e-01f, 3.33607733e-01f, 2.85982877e-01f, -7.59599730e-02f,
  -4.00908431e-03f, 3.43491919e-02f, 4.54988629e-02f, 4.40571494e-02f, 3.25406864e-02f, 8.29219520e-02f, 1.54976407e-02f, -1.31861120e-01f, -1.06319420e-01f, -7.88725540e-02f,
  9.29224193e-02f, -3.37074935e-01f, 6.73720613e-02f, -2.81294510e-02f, 1.49591481e-02f, 5.48866726e-02f, 1.88730340e-02f, -2.87748035e-02f, 4.12232019e-02f, 1.93381663e-02f,
  1.20484000e-02f, 6.16769083e-02f, 1.18177131e-01f, -3.26289572e-02f, 1.43083464e-02f, 6.57492429e-02f, 5.29970974e-02f, 7.87821338e-02f, 7.48678744e-02f, -8.75854194e-02f,
  -8.42365474e-02f, -1.43765703e-01f, -2.55378466e-02f, -1.27581105e-01f, 1.98968723e-02f, 1.21824127e-02f, -3.29500064e-02f, -1.27275392e-01f, -6.84240460e-02f, -1.64720565e-02f,
  7.21480548e-02f, 2.29876004e-02f, -2.12182896e-03f, -1.12640318e-02f, 7.71847665e-02f, 2.20329873e-02f, 7.66356662e-02f, 7.04723969e-02f, -3.14668491e-02f, 5.52675202e-02f,
  -2.26129964e-03f, -1.11844398e-01f, -2.03166530e-02f, 5.82007226e-03f, -1.59210674e-02f, -8.24849010e-02f, -7.60234445e-02f, 6.13899566e-02f, -1.90566189e-03f, -7.54861385e-02f,
  2.53135152e-02f, 3.68132703e-02f, -2.38705967e-02f, -4.49280404e-02f, -8.17360505e-02f, 6.81257434e-03f, 6.45524189e-02f, -6.24499358e-02f, 1.94933601e-02f, -6.84738532e-02f,
  2.15562269e-01f, -8.48646834e-02f, 1.19007207e-01f, 4.19705026e-02f, 7.80669227e-02f, 2.69569922e-02f, -7.51210464e-05f, -6.99378252e-02f, -1.40843019e-01f, 5.27246273e-04f,
  -8.63605067e-02f, 7.18747675e-02f, -5.90107217e-02f, -7.77000487e-02f, -7.84749538e-03f, -7.84028545e-02f, 1.61924604e-02f, 3.94764282e-02f, 9.74379573e-03f, -4.31773029e-02f,
  1.05637431e-01f, 1.15726873e-01f, 2.76462674e-01f, 1.39013886e-01f, -8.74933507e-03f, 1.41727298e-01f, 1.84824958e-01f, 9.70808640e-02f, 2.38875434e-01f, 3.82441342e-01f,
  2.25258470e-02f, 4.19641696e-02f, 4.80754375e-01f, -1.73823163e-01f, 2.14205787e-01f, 3.96805257e-01f, 5.47937810e-01f, -1.52513999e-02f, -2.18142226e-01f, -1.06714211e-01f,
  3.74214873e-02f, -1.87849060e-01f, 8.77515040e-03f, -7.46374279e-02f, 6.32601380e-02f, 1.81497827e-01f, 2.24211082e-01f, 1.35937706e-01f, 1.82555184e-01f, -3.18129401e-04f,
  -5.28588817e-02f, -2.81900093e-02f, -1.33394048e-01f, -5.56037538e-02f, -1.63550794e-01f, -1.80107988e-02f, -6.71909377e-03f, -7.72544593e-02f, -5.26884124e-02f, -2.54344285e-01f,
  6.97336122e-02f, 3.10847163e-03f, 1.47729933e-01f, -6.82724044e-02f, 2.24012993e-02f, -4.03991826e-02f, 1.69346221e-02f, -7.93413743e-02f, 2.31134426e-02f, -6.17009886e-02f,
  -3.31880804e-03f, -1.59270942e-01f, 3.46352309e-02f, -1.30615413e-01f, -8.81949365e-02f, 3.39275971e-02f, -1.19104281e-01f, -1.15122125e-01f, 5.83027489e-02f, -7.31253102e-02f,
  -1.05515249e-01f, 7.46375918e-02f, 2.65266180e-01f, 4.17875350e-02f, 1.09027855e-01f, 4.06833971e-03f, 5.64019009e-02f, -7.82967284e-02f, 2.83306977e-03f, -2.77230650e-01f,
  -3.15848086e-03f, -2.72669047e-02f, 6.06939197e-03f, -4.46933769e-02f, -1.96519345e-02f, -3.27359848e-02f, -8.20467249e-03f, -4.84182360e-03f, -5.74405752e-02f, -1.47419586e-03f,
  2.13085450e-02f, 9.19495057e-03f, -6.42646700e-02f, 4.94552590e-02f, -6.62859902e-02f, -6.16690842e-04f, 2.25243866e-02f, 5.10890095e-04f, -1.59930959e-02f, -4.52300580e-03f,
  -4.86619063e-02f, 3.75345983e-02f, -4.62909276e-03f, -9.82794259e-03f, 6.00678194e-03f, 1.22212619e-02f, 6.26108497e-02f, -8.58327076e-02f, 6.03933726e-03f, -5.45635894e-02f,
  -8.68824348e-02f, 2.44047523e-01f, -9.90214571e-02f, -7.38852397e-02f, 3.13699022e-02f, -2.93110590e-03f, 4.05541547e-02f, -8.14845636e-02f, 1.68814119e-02f, 7.82326385e-02f,
  1.12225488e-01f, 5.64491376e-02f, 4.28048968e-02f, -1.72666423e-02f, 9.36394557e-02f, -2.47963890e-03f, -3.61211412e-02f, 8.33511502e-02f, -4.25739698e-02f, -3.23192589e-02f,
  1.79735001e-03f, 9.16088074e-02f, 1.75083503e-01f, 1.12532690e-01f, 4.58118170e-02f, 2.27123991e-01f, 1.49709225e-01f, 1.05621591e-01f, 3.14504147e-01f, 2.27636904e-01f,
  -2.33522400e-01f, -3.17951471e-01f, -5.69962375e-02f, -4.02974665e-01f, 2.07872435e-01f, 3.77963275e-01f, 3.32273871e-01f, 1.06364563e-01f, -2.21030079e-02f, -1.69584677e-01f,
  1.00208037e-01f, 6.71782345e-02f, -7.35010952e-02f, 1.07025824e-01f, 1.91287562e-01f, -3.28546017e-02f, -9.66413505e-03f, -1.94358416e-02f, 2.29144260e-01f, 1.94987774e-01f,
  1.91301368e-02f, -1.46748707e-01f, -2.32327789e-01f, -1.18956722e-01f, -2.99554348e-01f, 2.25586165e-02f, -2.14179739e-01f, -1.31908566e-01f, 9.86985639e-02f, -3.70729268e-01f,
  -3.28597397e-01f, -2.95797084e-02f, 1.21098250e-01f, 3.99636030e-02f, -4.29319404e-02f, -1.02098688e-01f, 5.79013154e-02f, -1.40084341e-01f, 1.07595790e-02f, -4.88459468e-02f,
  -4.54343446e-02f, 9.38282534e-03f, 8.91583338e-02f, -4.96935733e-02f, -1.01695217e-01f, -5.25735430e-02f, -2.40913723e-02f, 6.43897941e-03f, -2.15402022e-02f, -4.19184193e-02f,
  1.60122365e-02f, 1.12100489e-01f, 5.46721853e-02f, 1.07134789e-01f, 1.51548877e-01f, 2.27001563e-01f, 1.98174659e-02f, 8.05157721e-02f, 2.97059536e-01f, -2.04712674e-01f,
  -1.42454086e-02f, -1.08997747e-02f, 1.05931945e-01f, -4.56867963e-02f, 2.87530366e-02f, 1.79540142e-02f, -2.89500430e-02f, 1.07137393e-02f, 7.80671686e-02f, -5.62632680e-02f,
  2.45129485e-02f, 3.58666591e-02f, 2.18226500e-02f, -7.48043656e-02f, 2.56796330e-02f, -2.55129822e-02f, 2.21678484e-02f, -2.01781709e-02f, 2.20112372e-02f, -2.52561606e-02f,
  3.45997624e-02f, 4.15550880e-02f, -4.54110056e-02f, 4.39074729e-03f, 5.63717932e-02f, -3.20476666e-02f, -1.43720442e-02f, 3.15606520e-02f, -6.96728602e-02f, -1.94583647e-02f,
  -1.81179047e-01f, 4.55290705e-01f, -1.96545005e-01f, -9.85566340e-03f, -3.39390012e-03f, -2.90550943e-02f, -2.69210320e-02f, 1.95971802e-02f, -3.71822231e-02f, -4.30235751e-02f,
  1.06046893e-01f, -3.03084124e-02f, -5.64392470e-02f, 3.79038439e-03f, 6.00165427e-02f, 7.34646544e-02f, 3.60226594e-02f, -1.24140661e-02f, 3.47480737e-02f, -6.24152645e-02f,
  -6.64409325e-02f, 2.97296811e-02f, -2.96841916e-02f, -3.04430611e-02f, 3.40273902e-02f, 1.01278365e-01f, -5.91164306e-02f, -5.41068017e-02f, 1.87466457e-01f, -3.03468347e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.10633171e-01f, -1.06961153e-01f, 9.38111320e-02f, 2.81232744e-01f, 4.32253450e-01f, 4.45221424e-01f, 4.01160598e-01f, 2.50301868e-01f, 1.08712457e-01f, 1.58081546e-01f,
  -2.35962570e-01f, -3.24439377e-01f, -3.05118382e-01f, -4.07355040e-01f, -1.43865079e-01f, 1.22399583e-01f, 1.67345434e-01f, 3.19682136e-02f, -3.75651591e-03f, 1.43016338e-01f,
  -4.37057577e-02f, 1.09788351e-01f, 7.53870755e-02f, -6.25698790e-02f, -1.38885736e-01f, -7.79753402e-02f, -9.65858325e-02f, -1.41870350e-01f, -1.30771190e-01f, -2.15938121e-01f,
  -3.27808231e-01f, -5.87210581e-02f, 6.46470785e-02f, -6.72003925e-02f, -6.83008283e-02f, 5.34869097e-02f, 1.52243018e-01f, -1.27415404e-01f, -5.11148013e-02f, 1.03226185e-01f,
  -1.76752508e-01f, -5.15530035e-02f, -1.81459114e-01f, -9.31847654e-03f, 1.24152251e-01f, -1.42319882e-02f, 7.82151707e-03f, -5.56849279e-02f, -2.90868908e-01f, -2.51777470e-01f,
  -1.99246973e-01f, 1.79066826e-02f, 6.85359910e-02f, 7.86777993e-04f, -1.58613622e-01f, -7.19869584e-02f, -2.02578664e-01f, -2.18300194e-01f, -5.52047491e-02f, 2.12203711e-02f,
  -9.33632627e-03f, -4.78453860e-02f, -9.38001797e-02f, 4.47070561e-02f, 9.98078808e-02f, -5.20775728e-02f, -2.44109482e-02f, -3.22730504e-02f, 7.97079802e-02f, 1.13643460e-01f,
  -1.17766950e-03f, 5.08454591e-02f, 5.61719714e-03f, 3.59578133e-02f, -1.05678789e-01f, -1.06642172e-02f, 1.62714161e-02f, -6.99301623e-03f, 5.85008450e-02f, 7.95337111e-02f,
  3.69480588e-02f, -4.50830348e-03f, 1.91111658e-02f, -5.68459854e-02f, 3.08559882e-03f, -5.84111027e-02f, 1.61708035e-02f, -2.91135684e-02f, 1.41510470e-02f, 6.89921752e-02f,
  1.23513393e-01f, -8.34510382e-03f, 1.06131500e-02f, -1.12947412e-01f, -3.22253183e-02f, -7.83635005e-02f, -9.19789001e-02f, 3.66301276e-03f, -1.05370253e-01f, 5.32235019e-02f,
  -1.00611337e-01f, -6.70090988e-02f, -4.62956429e-02f, -3.62252956e-03f, 2.47352108e-01f, 1.69899747e-01f, 1.20050739e-03f, -1.14031155e-02f, -1.24332033e-01f, -6.56667203e-02f,
  -9.54643339e-02f, 2.51767755e-01f, 3.33232582e-01f, 1.30127683e-01f, -3.38350162e-02f, 2.85173506e-01f, 1.36332750e-01f, 8.47249106e-02f, 3.26464027e-01f, 5.23858488e-01f,
  5.75136602e-01f, 8.27531517e-01f, 3.78550410e-01f, -1.58650443e-01f, -2.91914016e-01f, 9.94867533e-02f, 4.69983667e-01f, 1.38714597e-01f, -2.30248824e-01f, 1.49343535e-01f,
  -2.86481902e-03f, -4.77660894e-01f, -3.06618631e-01f, -1.73238307e-01f, 1.93317488e-01f, 2.75606364e-01f, 1.97197154e-01f, -3.99090424e-02f, -2.56444931e-01f, -1.09973907e-01f,
  -3.83146673e-01f, -1.80846304e-01f, 7.55981579e-02f, 2.39673294e-02f, -5.34920245e-02f, -4.13752317e-01f, 2.02612907e-01f, 1.48901284e-01f, 3.64455730e-02f, 6.78741857e-02f,
  3.11584044e-02f, 6.91777468e-01f, -4.36759114e-01f, -2.98112541e-01f, -8.31297860e-02f, 1.02918103e-01f, 4.32180911e-02f, 6.70150742e-02f, -1.47188427e-02f, 5.62629215e-02f,
  -1.03248999e-01f, -6.19142689e-02f, -7.20373821e-03f, -6.09871112e-02f, 1.20194994e-01f, 3.63714546e-02f, 1.31444797e-01f, 1.43997252e-01f, -7.72068053e-02f, 7.93812945e-02f,
  -2.27581561e-01f, -1.76351145e-02f, 1.03852697e-01f, 5.53443059e-02f, 1.64669216e-01f, -2.56216228e-01f, 1.06240049e-01f, 4.83897477e-02f, 1.40693992e-01f, 1.63607016e-01f,
  -8.29472393e-02f, 1.66116636e-02f, 5.31178247e-03f, 3.33915912e-02f, -1.56429950e-02f, -6.74970523e-02f, 2.21077837e-02f, 2.55066827e-02f, -5.23815528e-02f, 3.40715759e-02f,
  -1.57936644e-02f, -1.63087994e-02f, 2.22083908e-02f, 7.54699751e-04f, -1.26904920e-01f, 4.17674109e-02f, 1.22208241e-02f, 3.07199843e-02f, -1.07314456e-02f, -1.05008269e-02f,
  -1.11455992e-01f, 4.66379784e-02f, 2.47364951e-04f, -5.74959889e-02f, -2.43453626e-02f, 7.19157187e-03f, -1.07028633e-02f, -7.37415552e-02f, 5.55143878e-02f, 3.04124709e-02f,
  -4.71392125e-01f, -1.56342208e-01f, -1.23043977e-01f, 6.47298098e-02f, 1.00162625e-01f, -7.81670064e-02f, -1.51247293e-01f, 9.70037058e-02f, -4.13161516e-02f, 5.60849905e-02f,
  1.30071258e-02f, -4.59535234e-02f, 1.32578671e-01f, -4.15277444e-02f, -1.75418407e-01f, -1.26910329e-01f, -2.43976023e-02f, -1.20635003e-01f, -1.33387730e-01f, -3.32749374e-02f,
  -9.08548012e-02f, -1.37959346e-01f, -2.08649918e-01f, -1.82101920e-01f, -7.76323751e-02f, -4.64762837e-01f, -1.85435563e-02f, -1.93313360e-01f, -1.78856030e-01f, -8.26352164e-02f,
  6.68754816e-01f, 1.77247554e-01f, -8.42349052e-01f, 8.01175460e-02f, -4.23528850e-01f, -5.07275224e-01f, -1.98281571e-01f, 1.26337230e-01f, 1.31926998e-01f, 9.58436206e-02f,
  -3.78615595e-02f, -4.61641811e-02f, 6.12569638e-02f, -2.38973312e-02f, -2.74854433e-02f, -2.18679219e-01f, -3.04587543e-01f, -2.59829730e-01f, -4.19306844e-01f, -3.36090893e-01f,
  -1.76359132e-01f, -5.35238832e-02f, -1.09493367e-01f, -5.23019433e-02f, -2.00638533e-01f, -1.77958027e-01f, -2.31577903e-01f, -2.95970529e-01f, -1.87374115e-01f, -2.56113172e-01f,
  -7.01072037e-01f, -1.65901762e-02f, -1.28202409e-01f, 1.48480520e-01f, -1.34434775e-01f, 5.42170219e-02f, -7.50118345e-02f, -1.92840490e-02f, 5.67560550e-04f, -1.03215203e-02f,
  -9.69068557e-02f, -5.47621101e-02f, -1.29421279e-02f, -1.62733063e-01f, -1.32609800e-01f, -1.14281744e-01f, 7.17647225e-02f, -1.11680754e-01f, -1.17868176e-02f, -9.63872597e-02f,
  -9.78475809e-02f, -2.74856389e-01f, -1.74117729e-01f, -5.91935553e-02f, -8.55810270e-02f, -4.59555238e-02f, -8.70775282e-02f, -1.26783699e-01f, -7.71954134e-02f, 3.45953330e-02f,
  -2.96944585e-02f, -1.80583727e-02f, -5.21149971e-02f, 8.82575586e-02f, 5.96105233e-02f, -3.83282118e-02f, 2.40305886e-02f, 3.48118832e-03f, -8.88442714e-03f, -4.49847896e-03f,
  1.98307242e-02f, -1.16639659e-02f, 2.95211058e-02f, 4.83284704e-02f, -8.64232928e-02f, -5.85035235e-03f, -3.71701121e-02f, 7.12096021e-02f, -2.17282102e-02f, -3.77989635e-02f,
  -6.47499636e-02f, -3.42811421e-02f, -2.23620404e-02f, -5.68970479e-02f, -7.92878717e-02f, -5.06468825e-02f, 5.01167700e-02f, 1.13303058e-01f, 3.05838045e-02f, 6.00784458e-02f,
  3.84092152e-01f, -4.77610193e-02f, 1.50498942e-01f, 1.16279803e-01f, -1.16486870e-01f, 2.58363802e-02f, 3.88584323e-02f, 5.41064814e-02f, 4.36963104e-02f, -4.61738780e-02f,
  -1.08834445e-01f, 3.79847698e-02f, 6.61741644e-02f, -7.56679028e-02f, -9.04801190e-02f, -2.58740392e-02f, 1.93770722e-01f, -4.75550815e-02f, 2.13210937e-02f, 6.55406900e-03f,
  1.66447818e-01f, 1.58433035e-01f, 2.69373745e-01f, 1.59083888e-01f, 2.76213940e-02f, 5.98733574e-02f, -9.47392806e-02f, 4.82624955e-02f, 6.98805377e-02f, 3.39085162e-01f,
  3.23959589e-01f, -1.86278567e-01f, -4.79949266e-01f, 1.97294414e-01f, 2.09750738e-02f, 9.33177248e-02f, -5.65566868e-02f, 2.91379601e-01f, 1.41679570e-01f, -1.31140156e-02f,
  -2.03250702e-02f, 1.09908722e-01f, -7.09670037e-02f, -5.96353076e-02f, -9.69330370e-02f, -4.17156756e-01f, -3.66884381e-01f, -1.82645589e-01f, 8.65132734e-02f, 1.49309888e-01f,
  5.62444851e-02f, 4.80573438e-02f, 1.19165167e-01f, 3.09883188e-02f, 2.45375670e-02f, -4.67382185e-02f, -1.51038721e-01f, -3.77495587e-02f, -3.29240590e-01f, -3.83080095e-01f,
  -4.06682104e-01f, 2.29346752e-01f, -4.92475852e-02f, -2.30952203e-02f, -4.42622006e-02f, 1.19697768e-02f, -1.98776256e-02f, 4.66894209e-02f, 6.69145808e-02f, -6.77853823e-02f,
  -4.11952985e-03f, 2.16676015e-02f, 6.46070540e-02f, 4.84730937e-02f, 1.10403217e-01f, 6.61782175e-02f, 1.05273714e-02f, 2.25260388e-02f, -9.67977270e-02f, -3.13889720e-02f,
  1.61184147e-02f, 5.82513884e-02f, 3.63994502e-02f, -4.52203229e-02f, 5.71425557e-02f, -2.12750975e-02f, -8.75380412e-02f, 9.53620374e-02f, -8.81326273e-02f, -8.89141634e-02f,
  -6.77692145e-02f, -1.19601719e-01f, 1.67266384e-03f, 3.65432650e-02f, 8.76920149e-02f, -5.70257939e-02f, -4.53387573e-02f, -2.69541657e-03f, 6.93071112e-02f, 1.36641618e-02f,
  2.66507193e-02f, -5.47405034e-02f, 4.53815125e-02f, -2.56114937e-02f, -4.32971567e-02f, -1.01291724e-01f, -7.45344092e-04f, -1.60756726e-02f, -2.74238102e-02f, -3.03644221e-02f,
  -5.24560884e-02f, -2.70578619e-02f, -1.89499743e-02f, -2.88872644e-02f, -1.39065474e-01f, -5.12209237e-02f, 2.18037609e-02f, 6.37223870e-02f, 4.61944416e-02f, 5.76780587e-02f,
  2.35760719e-01f, -1.28228828e-01f, -1.06321588e-01f, 1.05326585e-01f, -3.29161473e-02f, -3.84775661e-02f, 2.60484889e-02f, -2.44168397e-02f, -4.43462133e-02f, 9.68180746e-02f,
  4.82328236e-02f, 7.60635957e-02f, 6.92878366e-02f, 1.78909767e-03f, 5.32089695e-02f, 8.48417357e-02f, 6.65220805e-03f, -8.15748274e-02f, -1.23932205e-01f, 4.76254597e-02f,
  -1.12972679e-02f, -1.18254796e-01f, -2.50739101e-02f, -1.43096790e-01f, 1.04559496e-01f, -1.61298528e-01f, -7.40406737e-02f, -7.73206130e-02f, -1.91874295e-01f, -1.29011227e-02f,
  -2.95282185e-01f, 1.24044009e-01f, -5.67758918e-01f, 1.35607272e-01f, 2.97462583e-01f, -1.04074910e-01f, -2.12473217e-02f, -2.29918733e-01f, -5.58265410e-02f, 6.73214272e-02f,
  2.28226662e-01f, 1.01676844e-01f, 1.22485857e-04f, -1.70465812e-01f, -2.48564303e-01f, -1.07417233e-01f, 1.38509750e-01f, -2.65161067e-01f, -3.67290676e-01f, -4.14707959e-02f,
  3.81520331e-01f, 1.63213134e-01f, -1.60317555e-01f, 2.97653358e-02f, 2.99090177e-01f, 2.14295432e-01f, -6.35582060e-02f, 1.19979143e-01f, 1.67817593e-01f, 3.78827631e-01f,
  -2.17955261e-01f, -2.58763105e-01f, -8.40440840e-02f, 1.88214287e-01f, 1.21964954e-01f, -1.43682778e-01f, -7.97787532e-02f, -1.40488684e-01f, -5.13725765e-02f, -1.07293397e-01f,
  5.64424954e-02f, -5.83697930e-02f, 9.52093005e-02f, -8.97002444e-02f, -8.45111534e-02f, -1.37687400e-01f, -2.04482928e-01f, -3.54850441e-01f, -3.00601840e-01f, -1.33534059e-01f,
  2.02907652e-01f, 1.37890518e-01f, -2.60498106e-01f, -2.87321627e-01f, -2.35073566e-01f, -1.59685295e-02f, -3.03599685e-01f, -1.48468584e-01f, -4.11952436e-01f, -2.11682737e-01f,
  1.89578196e-03f, -4.55703475e-02f, 3.31090167e-02f, 1.62184257e-02f, 4.60410230e-02f, 3.46396081e-02f, 6.66196123e-02f, 7.31863752e-02f, -1.65001489e-02f, 1.38083668e-02f,
  1.78147703e-02f, -3.72330472e-02f, -2.82706246e-02f, -7.13855848e-02f, 3.21401134e-02f, -3.57688591e-02f, 3.62121090e-02f, -1.79802962e-02f, -2.86626201e-02f, -1.70271248e-02f,
  -5.91329597e-02f, -5.90896569e-02f, 3.76807638e-02f, -4.45823371e-02f, -5.49007878e-02f, -7.04055727e-02f, 3.16445306e-02f, -1.00199662e-01f, -3.88790891e-02f, -3.25796865e-02f,
  -1.16970679e-02f, -6.72328994e-02f, -7.75797144e-02f, -6.12799544e-03f, 7.20749572e-02f, -1.01813450e-02f, 7.51455054e-02f, -8.37138742e-02f, 2.44535357e-02f, -1.22167930e-01f,
  2.77660862e-02f, -1.37978807e-01f, 3.12997811e-02f, -3.81992050e-02f, -5.75052574e-02f, -1.24672718e-01f, 1.39503002e-01f, -8.72379243e-02f, -7.90520385e-02f, -7.10611194e-02f,
  6.46859631e-02f, -7.19280541e-02f, -9.07510296e-02f, -2.46494263e-01f, -4.23668921e-02f, -8.31111819e-02f, -2.96107262e-01f, -2.05038562e-01f, -3.37046236e-01f, -1.98717341e-01f,
  -2.36956432e-01f, -3.96862663e-02f, 2.33286500e-01f, -3.17436785e-01f, 9.24045444e-02f, 8.58576223e-02f, -1.40398830e-01f, -2.03408867e-01f, -1.15644418e-01f, -1.56735495e-01f,
  1.23404555e-01f, -3.01712280e-04f, -6.90571666e-02f, -1.33897081e-01f, -7.62557909e-02f, -1.00751244e-01f, -2.24291116e-01f, -1.70794174e-01f, 3.02753728e-02f, -6.53691366e-02f,
  -1.33296028e-01f, -1.86278597e-01f, -1.06323481e-01f, -2.00356826e-01f, -1.84878856e-01f, -1.81695089e-01f, -1.22419618e-01f, -8.01825151e-02f, -1.03308678e-01f, -2.30522707e-01f,
  -1.21012948e-01f, 1.35713130e-01f, 1.13672189e-01f, -4.36577871e-02f, 8.17985758e-02f, 2.47940924e-02f, -2.29562428e-02f, -9.55335349e-02f, 1.07007258e-01f, -8.30944180e-02f,
  9.20712873e-02f, -2.18974799e-02f, -1.39937736e-02f, -1.90731219e-03f, -9.56360921e-02f, -2.24009287e-02f, -5.69828972e-02f, -5.27247302e-02f, 6.34072796e-02f, 1.41564794e-02f,
  1.09998956e-02f, 8.45492166e-03f, 3.10009047e-02f, -1.48465922e-02f, 2.28422806e-02f, -3.66274528e-02f, -5.93816601e-02f, -1.66949093e-01f, -7.38941953e-02f, -3.13001364e-01f,
  1.04497876e-02f, 3.00748390e-03f, 8.88989121e-02f, 1.27825735e-03f, -7.77322873e-02f, 6.03898987e-02f, -1.00144230e-01f, 3.68596390e-02f, -5.27445190e-02f, -1.84995832e-03f,
  -8.65485147e-03f, 2.57869251e-02f, 1.30379442e-02f, -1.07607178e-01f, -3.13616209e-02f, -5.00172451e-02f, 1.03799598e-02f, -6.31997585e-02f, 3.15189138e-02f, 1.51573843e-03f,
  -8.36493745e-02f, -1.89197250e-02f, 2.87650954e-02f, 8.73241946e-03f, -4.78344113e-02f, 5.84515650e-03f, -1.03894889e-03f, 1.13465235e-01f, -5.60776293e-02f, 6.42394274e-02f,
  -4.16035086e-01f, 3.47411603e-01f, -1.82875782e-01f, -2.08848849e-01f, -3.77622992e-02f, 4.83280681e-02f, -2.68008877e-02f, 7.17386976e-02f, 3.01156472e-02f, -4.33125198e-02f,
  -4.87825051e-02f, -5.98026663e-02f, -1.12834953e-01f, -8.30169022e-02f, 5.35015948e-04f, -1.57229975e-01f, -1.63912714e-01f, -9.27095339e-02f, -7.86231235e-02f, -1.11790128e-01f,
  -5.78917153e-02f, -2.08571255e-01f, -3.45671773e-01f, -1.56284034e-01f, -2.25594252e-01f, -2.44166240e-01f, -9.43240300e-02f, -1.88482299e-01f, -2.14654237e-01f, -5.10074079e-01f,
  6.73716247e-01f, -6.45985305e-01f, -1.19450532e-01f, -1.87688664e-01f, -4.79384691e-01f, -1.77670881e-01f, -5.21438420e-01f, 1.95591408e-03f, 1.31854704e-02f, -5.08681595e-01f,
  -4.09057587e-01f, 6.80795833e-02f, 1.21394604e-01f, 2.24995360e-01f, 3.68120730e-01f, -2.63506174e-01f, -2.28131190e-01f, 5.86086571e-01f, 8.82226765e-01f, 3.59206676e-01f,
  -9.04783309e-02f, 1.71444058e-01f, 5.19835591e-01f, 2.03128651e-01f, -2.94345289e-01f, -3.26594152e-02f, -2.92399317e-01f, -4.37029526e-02f, -2.11356610e-01f, -3.68526399e-01f,
  -2.55579323e-01f, -1.27278030e-01f, 2.42890149e-01f, 3.12342010e-02f, -2.00000033e-01f, 7.83027038e-02f, -1.20924696e-01f, 1.85898840e-02f, -9.06160101e-03f, -5.81588522e-02f,
  -1.54171020e-01f, -1.90134663e-02f, 2.85412278e-03f, -9.03663337e-02f, 1.73188206e-02f, 7.69665884e-03f, 8.04305002e-02f, 2.23135859e-01f, 9.02707577e-02f, -1.84542656e-01f,
  -3.01759928e-01f, -1.52032241e-01f, 6.96942508e-02f, 7.27234920e-03f, 1.13191586e-02f, 1.59738153e-01f, -1.33994594e-01f, 7.96648338e-02f, 1.60757929e-01f, -2.31852844e-01f,
  -3.44595350e-02f, -3.96967754e-02f, 7.81960040e-03f, 3.80173400e-02f, 4.45164256e-02f, -5.69415130e-02f, 3.18661220e-02f, -2.24874765e-02f, 2.83223875e-02f, -2.53345259e-02f,
  2.76383050e-02f, -5.83785726e-03f, -4.81317304e-02f, -1.71150044e-02f, -7.49484673e-02f, -2.70404834e-02f, 4.01799716e-02f, -6.95692822e-02f, 3.04766856e-02f, 2.80466322e-02f,
  3.15848030e-02f, 5.07358424e-02f, -9.00172144e-02f, 1.54453376e-02f, -3.32134999e-02f, 4.84644212e-02f, 8.31680372e-03f, 6.90429360e-02f, 6.20478243e-02f, -6.71750084e-02f,
  -2.35921577e-01f, 3.00054103e-01f, -1.64709702e-01f, 1.60675317e-01f, -1.04055196e-01f, 1.12867979e-02f, -1.80325359e-01f, 4.58407626e-02f, -6.09084964e-02f, 2.59962995e-02f,
  2.75489837e-02f, 6.16581813e-02f, -1.27186507e-01f, 4.09949496e-02f, 1.19543836e-01f, 9.21731908e-03f, -1.79663777e-01f, 1.98878720e-02f, 9.12187994e-03f, -1.21146992e-01f,
  -1.39981389e-01f, 2.78923307e-02f, 9.16492939e-02f, -5.51777631e-02f, -4.22287583e-02f, 1.09211251e-01f, -1.79333627e-01f, -7.17100501e-02f, 1.31174445e-01f, -3.34955573e-01f,
  -8.34852159e-01f, 1.66302159e-01f, -3.12522411e-01f, -3.53278309e-01f, 1.63825110e-01f, 4.49922085e-01f, 6.25112236e-01f, 3.08237702e-01f, -1.31449252e-01f, 6.57101944e-02f,
  -1.35103077e-01f, -2.18786657e-01f, -2.75700808e-01f, -4.02002782e-02f, 1.21586703e-01f, 3.97826612e-01f, 2.68190980e-01f, -1.28407970e-01f, -1.05212340e-02f, 9.65397283e-02f,
  3.13525975e-01f, -1.29737422e-01f, -3.51555914e-01f, -6.82101771e-02f, -9.95549746e-03f, -1.48336207e-02f, -2.43007392e-01f, -2.12369502e-01f, -6.65922009e-04f, -6.60953403e-04f,
  -3.58494937e-01f, -4.25049990e-01f, 6.58726320e-02f, -1.91440016e-01f, -1.58960894e-01f, -1.08369000e-01f, -1.75583176e-02f, -1.97568223e-01f, -1.06209189e-01f, -3.72729674e-02f,
  -1.56319782e-01f, -8.59366283e-02f, -2.08284155e-01f, 3.40842009e-02f, -1.23784758e-01f, -4.30200696e-02f, -4.90924492e-02f, -1.98130131e-01f, -1.82594866e-01f, -5.55203967e-02f,
  1.83659956e-01f, -4.97871637e-02f, -1.45239115e-01f, 8.41806084e-02f, 4.52845059e-02f, -2.02275500e-01f, -1.31389335e-01f, -8.92644003e-02f, -4.13599834e-02f, -5.18864058e-02f,
  8.37049559e-02f, 1.73604768e-02f, 4.33770716e-02f, -4.07948233e-02f, 4.53293175e-02f, -9.90098529e-03f, 7.08097443e-02f, 3.70962806e-02f, 2.62837689e-02f, -3.15193795e-02f,
  1.23187657e-02f, -6.22816235e-02f, 5.68892248e-02f, -6.40771315e-02f, -9.65471044e-02f, -2.94646826e-02f, 1.73084084e-02f, 7.70359561e-02f, 7.76785007e-03f, -2.72836424e-02f,
  -8.59676078e-02f, -1.74258519e-02f, -1.11134142e-01f, 2.35919468e-02f, 5.13758808e-02f, -1.25155486e-02f, 9.03077144e-03f, -8.28295294e-03f, -4.56355363e-02f, -4.51519340e-02f,
  -1.16853982e-01f, -6.45347312e-02f, -6.81898370e-02f, 6.09457344e-02f, -9.34770033e-02f, -8.17991868e-02f, -7.00688809e-02f, -4.16095071e-02f, -1.34250268e-01f, 1.39386272e-02f,
  -7.02554767e-04f, -4.19224054e-02f, -3.62468436e-02f, 1.15736768e-01f, -9.53551289e-03f, 6.08064346e-02f, 1.69636458e-01f, 7.16261799e-03f, 1.18816361e-01f, 1.01214126e-01f,
  1.21518545e-01f, 1.66482463e-01f, 6.77261055e-02f, 1.28780812e-01f, 5.17276376e-02f, -1.18968077e-01f, 8.55926722e-02f, 5.19503728e-02f, 4.08432819e-02f, 3.30076903e-01f,
  -8.01923692e-01f, -1.59319013e-01f, -1.92249820e-01f, -4.67129469e-01f, -2.76898384e-01f, -1.17108457e-01f, -7.33253509e-02f, -1.29151596e-02f, -1.68540224e-01f, -1.43505275e-01f,
  -4.35130633e-02f, 1.97368506e-02f, -2.69460157e-02f, -8.19651112e-02f, -2.23091155e-01f, -2.49804005e-01f, -3.82747412e-01f, -5.32797456e-01f, -2.57488251e-01f, -1.96799815e-01f,
  -2.86750585e-01f, -4.79096025e-01f, -6.01333797e-01f, -2.56227702e-01f, -1.61512531e-02f, -8.64954218e-02f, -9.09413919e-02f, -1.48387298e-01f, -1.48857534e-01f, -1.53716698e-01f,
  5.63135386e-01f, -1.00765191e-01f, 6.47559986e-02f, -1.51972309e-01f, 1.44045344e-02f, 6.03834614e-02f, -1.12481695e-03f, 1.45049570e-02f, -4.16738912e-02f, -3.52723189e-02f,
  -1.24147460e-01f, -6.60559908e-02f, 5.41904233e-02f, -2.53114458e-02f, -2.21560150e-02f, -7.09000453e-02f, -1.04064383e-01f, -2.13945806e-01f, -2.81383079e-02f, 8.71485993e-02f,
  -7.38432631e-02f, -2.35022292e-01f, -5.97325452e-02f, 1.26067236e-01f, 1.07858449e-01f, -3.74127179e-02f, 9.26047787e-02f, 7.52112195e-02f, 5.35217226e-02f, 1.55114964e-01f,
  -6.95400760e-02f, 3.67523618e-02f, 3.93200144e-02f, -3.13891750e-03f, -4.79113646e-02f, 1.26235038e-02f, 5.91499992e-02f, -4.87436354e-02f, -1.87581200e-02f, 3.18327956e-02f,
  4.32124063e-02f, 2.50412934e-02f, 3.44915763e-02f, -1.95440277e-02f, 4.58515473e-02f, -7.74020031e-02f, -4.79114838e-02f, 1.58725977e-02f, 5.57497377e-03f, -6.83708787e-02f,
  -5.68793602e-02f, 4.87836190e-02f, -6.30941093e-02f, 5.91811873e-02f, -9.31655914e-02f, -5.28077595e-02f, 5.38537279e-03f, 7.33181462e-02f, -4.15056385e-02f, -7.88246095e-02f,
  3.35329443e-01f, -2.21800655e-01f, 5.75936697e-02f, 1.82543024e-02f, -6.64887205e-02f, 3.31966244e-02f, -4.58871247e-03f, -6.31453097e-02f, 3.29665989e-02f, 1.14678238e-02f,
  4.87649776e-02f, 1.06444163e-02f, -3.95904481e-03f, 2.38256007e-02f, -9.31835994e-02f, 2.86026616e-02f, -1.89158335e-01f, -8.14874470e-02f, 2.68653920e-03f, 1.07107185e-01f,
  -8.85230154e-02f, -5.87948933e-02f, -5.04021859e-03f, 1.70345232e-01f, 1.05719253e-01f, 3.07396296e-02f, 1.78714544e-01f, 2.54581958e-01f, 8.79976973e-02f, -1.80790257e-02f,
  4.28703845e-01f, 4.23843980e-01f, 1.09933361e-01f, 2.78753132e-01f, 2.41512731e-01f, 2.72147715e-01f, 3.93859893e-01f, 3.81046265e-01f, 2.04149529e-01f, 2.47037172e-01f,
  -1.58322472e-02f, 1.38022989e-01f, 8.27988610e-02f, 1.51552930e-01f, 3.19568843e-01f, 2.80503273e-01f, 2.07979649e-01f, 1.53075591e-01f, -1.54620793e-03f, -7.67538417e-03f,
  9.23434347e-02f, 7.96433091e-02f, -1.14648290e-01f, 7.85675198e-02f, 1.35763049e-01f, 6.95676059e-02f, -9.51809213e-02f, 2.26639099e-02f, 9.14025493e-03f, 1.63184524e-01f,
  1.79604068e-02f, 2.88166344e-01f, 1.20557696e-02f, -1.45467341e-01f, -1.61981463e-01f, -2.06667148e-02f, -3.18301059e-02f, -2.27918923e-01f, -9.66214612e-02f, 1.69710368e-02f,
  -1.16699263e-01f, -8.30344111e-02f, -8.19272455e-03f, -1.72405526e-01f, -1.51948333e-01f, -6.00868575e-02f, -8.21916386e-02f, 3.96784442e-03f, 7.13938251e-02f, 6.73168525e-02f,
  -8.50601047e-02f, -9.42756832e-02f, -1.39710486e-01f, -6.43685907e-02f, 1.94995344e-01f, -3.06307129e-03f, 3.26252021e-02f, -9.20971483e-03f, -1.07226223e-01f, 1.29837379e-01f,
  4.85372134e-02f, 4.34047058e-02f, 8.35713968e-02f, 1.98271461e-02f, 5.80688156e-02f, 1.45772668e-02f, -1.84707120e-02f, -5.42220436e-02f, 5.75816259e-02f, -4.04291181e-03f,
  5.98335546e-03f, 2.04533106e-03f, 5.02069220e-02f, 3.09363827e-02f, -1.46523528e-02f, 2.26518488e-03f, 1.64600722e-02f, 7.51061831e-03f, 2.56352965e-02f, -4.47049849e-02f,
  1.35421362e-02f, -5.00235669e-02f, -5.14254868e-02f, -9.15085338e-03f, -2.39272565e-02f, 3.23110889e-03f, -1.73379518e-02f, -2.93396991e-02f, -6.43873736e-02f, -1.51600121e-02f,
  -3.75759304e-01f, -5.07668331e-02f, 1.59923092e-01f, 1.28581151e-01f, -1.76505465e-02f, -7.70154595e-02f, 9.41108167e-02f, -6.63336739e-02f, -6.98864758e-02f, -4.11788560e-02f,
  -1.14954509e-01f, 5.91752604e-02f, 3.94227989e-02f, -7.75374919e-02f, -4.19994593e-02f, -1.53795198e-01f, -5.58875427e-02f, 8.86364654e-02f, -1.38897523e-02f, -6.86253831e-02f,
  5.52093312e-02f, -3.07805892e-02f, -1.41204849e-01f, 5.85587099e-02f, -1.76869649e-02f, -6.76607415e-02f, -7.78338313e-02f, -1.08444236e-01f, -4.09728289e-02f, -1.11326694e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  7.32284963e-01f, 7.21208334e-01f, 3.65614861e-01f, 1.23717017e-01f, 4.52342957e-01f, 3.56377333e-01f, 9.26664233e-01f, 7.44362235e-01f, 3.61458957e-01f, 2.37437025e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -5.49477100e-01f, -6.23378456e-01f, -3.72585505e-01f, -1.94520608e-01f, -1.11881368e-01f, 5.52779377e-01f, -3.63200009e-01f, -7.02531993e-01f, 3.82656276e-01f, 1.08389497e+00f,
  -1.55155271e-01f, 2.56879479e-01f, 7.90525436e-01f, 9.33621749e-02f, 4.47903872e-01f, -5.37902601e-02f, 1.31772891e-01f, 1.38668582e-01f, -1.62585005e-01f, 6.91817939e-01f,
  5.60241222e-01f, 7.86349952e-01f, 1.64542317e-01f, -6.42800033e-01f, 1.08364582e+00f, 4.88514192e-02f, -6.83545232e-01f, -2.28188351e-01f, 9.88950312e-01f, -7.92078435e-01f,
  3.77988964e-02f, 8.60548735e-01f, 5.43829858e-01f, 6.54145241e-01f, 6.12797201e-01f, 1.01539537e-01f, -5.27107656e-01f, 3.48002434e-01f, -6.00021064e-01f, -2.44576082e-01f,
  -4.28940713e-01f, -2.03631282e-01f, -2.98100531e-01f, 4.58537608e-01f, 1.32322168e+00f, -2.95719743e-01f, -6.49220347e-01f, -6.05958462e-01f, -3.59424293e-01f, 4.05070126e-01f,
  -7.77313232e-01f, -4.07603651e-01f, -1.22844882e-01f, 1.02818143e+00f, 4.22294550e-02f, 3.01156700e-01f, -2.08852410e-01f, -5.30483365e-01f, -1.15333520e-01f, 6.49428844e-01f,
  -4.44568127e-01f, 1.03134942e+00f, 5.45466483e-01f, -3.79812837e-01f, -1.17447302e-01f, -5.47697604e-01f, 5.99628925e-01f, -7.01635301e-01f, -5.40190041e-01f, -6.05295122e-01f,
  -4.51527268e-01f, 4.19023305e-01f, 3.26731652e-01f, 7.79366568e-02f, 4.70288992e-02f, 4.09985542e-01f, -9.19446766e-01f, -6.27095103e-01f, 8.22085500e-01f, -8.57462659e-02f,
  6.11378908e-01f, 2.53527224e-01f, 3.14630121e-01f, 5.66982985e-01f, -1.90330461e-01f, -6.74192131e-01f, 6.73837781e-01f, -1.41579941e-01f, 1.46524191e+00f, 2.32946113e-01f,
  2.84999132e-01f, -6.00210845e-01f, -5.37175834e-01f, 2.55299658e-01f, -2.32131913e-01f, -2.45235581e-02f, 2.54397541e-01f, 1.32326558e-01f, -5.76660693e-01f, -3.91218700e-02f,
  -7.83166885e-01f, -8.08929920e-01f, -5.50032318e-01f, 1.21757758e+00f, -2.13865697e-01f, -1.98587880e-01f, -5.50941706e-01f, -6.64449573e-01f, 5.21971405e-01f, -1.57867670e-01f,
  -2.88986444e-01f, 4.18842793e-01f, 1.67880565e-01f, -7.64260953e-03f, -1.13713793e-01f, 4.21950743e-02f, 1.76198542e-01f, 5.57872236e-01f, -2.41793633e-01f, -2.87735432e-01f,
  -2.61166599e-02f, 1.07450308e-02f, 8.14280272e-01f, -4.40186948e-01f, -5.81661999e-01f, 1.06063533e+00f, -3.91023785e-01f, 6.23684406e-01f, -9.36662480e-02f, -8.35226059e-01f,
  2.38604680e-01f, 6.73610628e-01f, 6.45995140e-01f, 4.13655609e-01f, 1.34819543e+00f, -2.94962317e-01f, -3.84838820e-01f, -4.29371595e-01f, -1.79276705e-01f, -2.12395236e-01f,
  3.43074620e-01f, 4.45214808e-01f, -3.89341742e-01f, -1.13351397e-01f, 2.24663898e-01f, -3.23662877e-01f, -9.74092726e-03f, -6.57185137e-01f, -1.05555665e+00f, -1.16289306e+00f,
  -4.00654435e-01f, -3.03177863e-01f, -1.40926719e-01f, -4.77385335e-03f, 1.19429958e+00f, 1.55365154e-01f, -2.92743176e-01f, -5.57515919e-01f, -5.75787127e-01f, -7.74228200e-02f,
  -5.32790065e-01f, 3.03088188e-01f, 5.18269897e-01f, 9.47471619e-01f, 7.75290012e-01f, -6.95232451e-01f, 7.70137832e-02f, -1.71425924e-01f, -3.84895891e-01f, -2.87408441e-01f,
  -3.54680389e-01f, -4.17776465e-01f, -5.37608683e-01f, 4.01078522e-01f, 1.10833156e+00f, -5.28195620e-01f, 3.98841733e-03f, -2.88132638e-01f, 4.88581181e-01f, -4.97207552e-01f,
  1.17620957e+00f, 3.24543953e-01f, 1.83604553e-01f, 1.36411870e+00f, -5.95146492e-02f, 2.80730575e-01f, -3.16615075e-01f, 1.84076563e-01f, -6.57894135e-01f, -9.12215635e-02f,
  -4.29501265e-01f, 2.64494896e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -6.23469651e-01f, -8.99132267e-02f, 2.22840682e-01f, -2.37343609e-01f, -2.37074360e-01f, 9.41398963e-02f, 1.09650474e-02f, -5.01029670e-01f, -1.59773275e-01f, 6.97949827e-01f,
  5.37796393e-02f, -2.48623773e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    