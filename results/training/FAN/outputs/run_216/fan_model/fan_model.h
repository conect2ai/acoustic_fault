/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.95232451e-01f, 2.23871693e-02f, -2.35600561e-01f, 8.44570845e-02f, -1.33221984e-01f, -8.79454836e-02f, -1.48213834e-01f, -1.80836558e-01f, -2.33190089e-01f, -4.28859219e-02f,
  -1.43662184e-01f, 1.59602854e-02f, -3.05246592e-01f, 9.86581296e-02f, -1.72193974e-01f, 3.38924443e-03f, 9.24802572e-03f, -9.99204293e-02f, 1.19535983e-01f, -8.86476114e-02f,
  2.61106342e-02f, 4.50355336e-02f, -6.88531250e-03f, 2.97131743e-02f, -1.67463794e-01f, 6.24193624e-02f, -8.31029564e-02f, 7.07997475e-03f, 2.95370594e-02f, 9.95444804e-02f,
  6.73772022e-03f, 1.01971641e-01f, -3.21357399e-02f, -2.38981731e-02f, -8.89482573e-02f, -8.57160613e-02f, -2.09688097e-02f, 2.87023801e-02f, 5.83231635e-02f, 1.27694169e-02f,
  -3.05972737e-03f, 3.54721211e-02f, 3.77435610e-02f, 5.03497273e-02f, -1.31560443e-02f, 4.20360789e-02f, 4.06880453e-02f, -1.03399698e-02f, 5.00332238e-03f, 5.26504330e-02f,
  3.80188506e-03f, 6.40599057e-02f, -8.68223200e-04f, 1.39837172e-02f, -2.45521925e-02f, 4.83752005e-02f, 9.53071471e-03f, -2.35738326e-02f, 1.63298529e-02f, 4.76709753e-02f,
  6.23896047e-02f, -4.52042483e-02f, 1.36534525e-02f, -3.17497812e-02f, -1.21732028e-02f, -2.03159582e-02f, 1.14068179e-03f, 4.19134013e-02f, 3.27754803e-02f, -6.16630837e-02f,
  9.32139903e-03f, -5.59507124e-02f, -3.89123522e-02f, 4.51749982e-03f, 5.51380627e-02f, -4.43546399e-02f, 4.63436581e-02f, -4.45773378e-02f, -1.53176179e-02f, -2.33726203e-02f,
  -1.22860437e-02f, -7.41900802e-02f, -1.33030787e-02f, 3.35917212e-02f, -8.02286807e-03f, -2.20038053e-02f, -1.24181872e-02f, 2.11756248e-02f, 3.90176922e-02f, -1.86699778e-02f,
  -1.87311381e-01f, -2.20612168e-01f, 4.58574705e-02f, 2.85457615e-02f, 7.71608874e-02f, 6.67435229e-02f, 1.49160698e-02f, 2.53794864e-02f, 3.57935876e-02f, 2.34517585e-02f,
  1.93613619e-02f, -3.20110433e-02f, -9.24250707e-02f, 2.91844662e-02f, 3.49016748e-02f, -2.00036690e-02f, -2.66708769e-02f, -6.61446154e-02f, -2.46252567e-02f, 4.95646498e-04f,
  1.54057788e-02f, -2.42517013e-02f, 8.54720026e-02f, -4.43549715e-02f, 4.06066403e-02f, -2.07001362e-02f, -1.42045328e-02f, 4.28390764e-02f, 1.30452514e-02f, -6.71729892e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.45478973e-02f, 9.89082754e-02f, -2.12642953e-01f, -1.41506968e-02f, 1.67571813e-01f, -1.06147096e-01f, -9.52781513e-02f, 1.43623531e-01f, -1.95803910e-01f, 2.02835590e-01f,
  3.58893812e-01f, -8.39160532e-02f, -1.15385409e-02f, 1.73203737e-01f, 2.17435379e-02f, -1.47689758e-02f, 1.73711047e-01f, -1.26940310e-02f, -1.28959909e-01f, 1.56705573e-01f,
  -1.56111084e-02f, 2.98963666e-01f, -6.85420185e-02f, 1.49781972e-01f, 9.94523168e-02f, -7.39826113e-02f, 1.80070937e-01f, -1.22681387e-01f, 1.73213035e-01f, 6.69383723e-03f,
  -1.68225262e-02f, 7.48138353e-02f, -4.48843390e-02f, -1.08241364e-01f, 1.31605223e-01f, 1.27220184e-01f, -9.29589197e-02f, -2.49234606e-02f, -5.67234829e-02f, -6.12578914e-02f,
  2.96950396e-02f, 3.53641696e-02f, -8.23823269e-03f, -7.96939656e-02f, -1.68390479e-02f, -2.97071002e-02f, -7.67323188e-03f, -7.35509843e-02f, -3.51170823e-02f, 1.86857879e-02f,
  -8.59359577e-02f, 2.71592215e-02f, 1.53145287e-02f, -2.41968501e-02f, -7.45089948e-02f, -6.68075085e-02f, -1.26701444e-01f, -3.37030180e-02f, 5.77869527e-02f, -9.73232910e-02f,
  4.95780818e-02f, -9.34285671e-02f, 2.07290389e-02f, -8.74996856e-02f, 2.80240942e-02f, 3.21855880e-02f, -6.18804363e-04f, -1.06565496e-02f, -9.73794386e-02f, 1.10864349e-01f,
  -1.15438309e-02f, -7.44192898e-02f, 4.37365100e-02f, 2.22607590e-02f, -1.57294814e-02f, 3.86716723e-02f, -2.09073070e-02f, 4.75251004e-02f, -1.57758780e-02f, -4.16298062e-02f,
  -1.57939959e-02f, 2.24833265e-02f, 9.21341218e-03f, -1.01615246e-02f, 2.28705276e-02f, -4.35564481e-03f, 2.91545205e-02f, 1.09102596e-02f, -4.85198386e-02f, 2.67798174e-02f,
  1.39750391e-01f, 1.47716776e-01f, -1.14102669e-01f, 1.80486403e-02f, -1.03288420e-01f, 6.45533130e-02f, 4.25465358e-03f, 3.68094631e-03f, -2.62763016e-02f, 4.43650112e-02f,
  8.61863121e-02f, -4.49638441e-02f, 9.05194804e-02f, 2.05544401e-02f, -4.82422076e-02f, 3.91033366e-02f, 9.58967358e-02f, -5.23231626e-02f, 5.37937842e-02f, 3.10951788e-02f,
  8.06526244e-02f, 6.15350790e-02f, -2.73053385e-02f, 1.33369137e-02f, -3.29102911e-02f, 5.01081720e-02f, 4.15910920e-03f, 5.21915033e-03f, 5.91488443e-02f, 5.76679595e-02f,
  -5.14281809e-01f, 5.47137596e-02f, -2.86302984e-01f, -2.26419508e-01f, -4.79618400e-01f, -3.63721341e-01f, -2.37515256e-01f, -8.18633065e-02f, 2.32975021e-01f, 2.33678505e-01f,
  -9.29321945e-02f, 8.39209259e-02f, 4.36621398e-01f, -2.37472385e-01f, 3.62775475e-02f, 4.40940589e-01f, -2.78071105e-01f, -3.98367308e-02f, -5.20131700e-02f, -2.39019901e-01f,
  -2.55330175e-01f, -2.55689353e-01f, -3.57568301e-02f, -2.39050865e-01f, -5.47726095e-01f, -2.35564098e-01f, -9.25524086e-02f, -2.16325819e-01f, -3.91133666e-01f, -1.63571864e-01f,
  -6.40207231e-02f, 1.05273627e-01f, -1.17644690e-01f, 3.81271690e-02f, -1.56412467e-01f, -8.26619416e-02f, -1.59556612e-01f, -9.44701433e-02f, -7.37035945e-02f, -3.87313217e-02f,
  2.27636825e-02f, 5.07901236e-02f, -2.48762388e-02f, 4.16940339e-02f, -1.74039509e-02f, 8.40610918e-03f, 2.26351265e-02f, -5.89159243e-02f, 1.73312966e-02f, 7.40930019e-03f,
  2.11204663e-02f, -2.44243499e-02f, -4.06285822e-02f, 7.80721754e-02f, -1.06343456e-01f, -3.51882130e-02f, 5.11185303e-02f, 7.24871606e-02f, -5.21942526e-02f, -5.93466796e-02f,
  -8.62432271e-02f, -3.72160948e-03f, 6.33533020e-03f, 9.30538997e-02f, -3.31715457e-02f, -2.27167215e-02f, -3.08959354e-02f, 4.45707887e-03f, -3.67185436e-02f, -3.13450433e-02f,
  -7.14645386e-02f, -3.05963643e-02f, 2.07263082e-02f, -2.15580314e-02f, -3.89393717e-02f, 6.86925948e-02f, -4.73540323e-03f, -3.09520978e-02f, 1.18285902e-02f, -5.04157878e-02f,
  9.14088041e-02f, 8.44957754e-02f, -2.96279844e-02f, 8.93800613e-03f, -2.89120395e-02f, 5.71238026e-02f, -6.71525253e-03f, 1.59997027e-04f, -3.34329680e-02f, -5.33980653e-02f,
  -1.32384896e-01f, -3.83289042e-03f, 5.01289032e-02f, -1.09536864e-01f, 2.46675722e-02f, -5.93863130e-02f, -2.99768653e-02f, -1.07189707e-01f, -4.54356931e-02f, 3.12319994e-02f,
  -3.07478979e-02f, 1.61501821e-02f, -1.22600675e-01f, -3.93949784e-02f, -4.01771627e-02f, -4.83702198e-02f, -4.18574251e-02f, -3.32078268e-03f, -8.94235000e-02f, -7.07265437e-02f,
  -1.49233304e-02f, 4.88386787e-02f, 5.86236753e-02f, -4.96961400e-02f, -1.13635920e-01f, 8.34845658e-03f, -5.33533096e-02f, 1.17808888e-02f, -8.76576081e-02f, 5.17561659e-02f,
  2.22790375e-01f, -9.95153561e-02f, 2.24093243e-01f, 1.48574620e-01f, 2.35848296e-02f, -1.49558708e-01f, 9.27768648e-02f, -4.53313477e-02f, -1.11746877e-01f, -2.84130603e-01f,
  -6.71095327e-02f, -1.13639548e-01f, 5.99991009e-02f, 1.93206891e-02f, 2.39486456e-01f, -5.49464673e-03f, -9.91014093e-02f, -1.19503766e-01f, 1.72560886e-01f, 1.25134528e-01f,
  1.77464113e-01f, -4.95172553e-02f, 2.70079106e-01f, -1.68480307e-01f, -9.11401212e-02f, -5.55325672e-02f, 3.77421267e-02f, -5.31683303e-03f, -9.30880159e-02f, -1.10077538e-01f,
  -9.03546214e-02f, 2.66948324e-02f, 5.73381372e-02f, -5.37748449e-02f, -1.16140191e-02f, -4.19371109e-03f, -2.59855911e-02f, -2.58598030e-02f, -3.25703435e-02f, 6.42809346e-02f,
  3.54882292e-02f, -1.58397872e-02f, -9.65678990e-02f, 2.29042186e-03f, -2.97727957e-02f, -1.14664078e-01f, -3.36334445e-02f, 1.56325363e-02f, -3.51981893e-02f, 6.83714002e-02f,
  7.43635893e-02f, 4.78744507e-02f, 4.64168703e-03f, -1.26673594e-01f, 1.08412793e-02f, -3.09490543e-02f, -2.03307755e-02f, 1.35209948e-01f, 4.20187823e-02f, -3.00524477e-02f,
  -4.44201939e-02f, 1.14506751e-01f, -4.21749093e-02f, 4.93890196e-02f, -3.82483192e-02f, 7.03133047e-02f, -3.11508533e-02f, -3.11045665e-02f, -4.09337729e-02f, -6.60689548e-02f,
  -2.11775508e-02f, -2.52031665e-02f, -9.68109965e-02f, -7.88766295e-02f, 3.76084894e-02f, -4.08837870e-02f, -8.75875633e-03f, -1.12734787e-01f, 4.36735479e-03f, -4.80257012e-02f,
  2.30050702e-02f, 4.17411886e-02f, 6.78901821e-02f, -1.00528516e-01f, 8.94303694e-02f, 8.60855728e-02f, -1.53376963e-02f, 3.83097269e-02f, 1.68800671e-02f, -1.86612569e-02f,
  -1.69209227e-01f, 4.04037163e-02f, 5.25755528e-03f, 1.11625288e-02f, -5.59676737e-02f, -5.12411818e-02f, 6.21359237e-02f, -3.54766473e-02f, -2.81356964e-02f, 4.54638600e-02f,
  2.15665307e-02f, -2.30414979e-02f, -4.96878922e-02f, -1.87386684e-02f, 3.19808796e-02f, -2.34342441e-02f, 8.47816989e-02f, -9.69566256e-02f, -3.52069512e-02f, 5.74194230e-02f,
  9.82174184e-03f, -9.61933360e-02f, -2.33098641e-02f, -2.04284093e-03f, 1.46289859e-02f, 3.48707773e-02f, 1.96998194e-02f, -3.65736485e-02f, -5.72028570e-02f, 1.73601974e-02f,
  3.33646178e-01f, 2.38764044e-02f, 7.28390962e-02f, 1.29586235e-01f, -6.61074221e-02f, -3.10847551e-01f, -1.33566216e-01f, 1.04336552e-01f, -1.10333830e-01f, -2.28498261e-02f,
  8.04030150e-02f, -2.47384071e-01f, 1.41905114e-01f, 2.32992806e-02f, 7.74275288e-02f, -8.58594328e-02f, 6.99006170e-02f, 1.01867393e-02f, -8.56839027e-03f, 2.29427382e-01f,
  1.21967345e-01f, 2.21259445e-01f, 1.12006322e-01f, 1.74638316e-01f, 1.23165227e-01f, 1.98859811e-01f, 1.78253487e-01f, 5.95193319e-02f, 8.31444189e-02f, -1.39076278e-01f,
  -5.10767139e-02f, 9.05483216e-02f, -5.89688197e-02f, 5.45042800e-04f, 5.88324927e-02f, 4.04475853e-02f, 2.71693710e-02f, -7.15414658e-02f, 4.30179052e-02f, 9.76115689e-02f,
  -7.22371936e-02f, 4.07777168e-02f, 1.79533642e-02f, -1.81290545e-02f, 5.08773364e-02f, -3.13244686e-02f, -1.88479442e-02f, 3.05257645e-02f, -3.17525528e-02f, -2.76070945e-02f,
  5.62449954e-02f, 1.62819568e-02f, -1.04061738e-02f, 2.88939439e-02f, 1.65896546e-02f, -9.72804707e-03f, -3.43862288e-02f, -7.11567625e-02f, -3.47317345e-02f, -4.92763221e-02f,
  1.20131068e-01f, -1.54747562e-02f, -2.04734020e-02f, 3.59670189e-03f, -4.25930731e-02f, 6.96319193e-02f, 5.67028522e-02f, -3.19812284e-03f, 1.20494030e-02f, 1.51623534e-02f,
  -8.89215767e-02f, 1.97626371e-02f, -3.61531079e-02f, 2.62742266e-02f, 6.14730418e-02f, -4.19655927e-02f, -3.98649424e-02f, -5.26598766e-02f, 3.88898253e-02f, -9.09331068e-02f,
  1.85303818e-02f, 1.62021983e-02f, -7.24715367e-02f, 4.42587510e-02f, -2.29017250e-02f, -6.24919683e-02f, 8.87913480e-02f, 6.05341122e-02f, 3.93866710e-02f, 4.11293842e-03f,
  1.11884430e-01f, 2.11606309e-01f, -3.00264102e-03f, -1.10009909e-01f, -1.12051561e-01f, 9.18166130e-04f, 2.09285989e-02f, -2.93726064e-02f, 8.05114135e-02f, 8.77484307e-02f,
  1.36710657e-02f, -3.36073921e-03f, 9.79332998e-02f, 6.95222169e-02f, -7.01824874e-02f, 2.24167444e-02f, 4.64320108e-02f, -9.74499583e-02f, -3.47998440e-02f, 1.55041628e-02f,
  2.68740999e-03f, -2.62628552e-02f, -4.81246151e-02f, -2.28684619e-02f, 3.20634693e-02f, 4.89339158e-02f, -6.76040277e-02f, 4.05529179e-02f, 9.27970335e-02f, -2.33089346e-02f,
  -6.22224331e-01f, 5.21484017e-01f, 5.18220484e-01f, -3.82079840e-01f, 6.03304170e-02f, 3.02236646e-01f, -2.46599123e-01f, 2.49447212e-01f, -2.29842976e-01f, -2.88454369e-02f,
  -1.70614734e-01f, 6.16437942e-03f, 1.31110474e-01f, 7.42051378e-02f, -1.83484718e-01f, 9.09022093e-02f, -1.21540025e-01f, -1.58827007e-01f, 1.69442698e-01f, -2.91775819e-02f,
  -1.14737963e-02f, -1.60661623e-01f, 3.05829227e-01f, 2.72265106e-01f, 7.70084783e-02f, 4.98482808e-02f, -1.70244172e-01f, 1.81338310e-01f, 9.75852162e-02f, -1.79163690e-04f,
  -1.83507562e-01f, -1.14642747e-01f, 9.18337982e-03f, 1.46713376e-01f, -5.06354906e-02f, -2.69860611e-03f, -1.83524191e-02f, -7.15272725e-02f, -5.27095161e-02f, 6.44919351e-02f,
  1.35917088e-03f, 5.00764064e-02f, -4.69300114e-02f, 2.80899415e-03f, 5.18190078e-02f, 9.26735923e-02f, 1.19585544e-01f, 9.40224230e-02f, 7.50474110e-02f, 1.38004586e-01f,
  7.11477473e-02f, 4.75514494e-02f, 3.54605354e-02f, -6.39931932e-02f, 3.39039639e-02f, -4.19599637e-02f, 3.86003265e-03f, 6.01518974e-02f, 2.48881485e-02f, 1.71175983e-03f,
  -5.99611877e-03f, -1.09929107e-01f, -7.42023718e-03f, -2.01596990e-02f, 1.57577638e-02f, -9.22914594e-03f, -1.22881290e-02f, -6.09170608e-02f, -6.20391546e-03f, -1.70930084e-02f,
  -2.58597862e-02f, -2.92803869e-02f, 3.01899891e-02f, -5.62375747e-02f, -6.04772791e-02f, -4.38887365e-02f, 1.67382378e-02f, 2.54286602e-02f, -1.20342700e-02f, -2.06174888e-02f,
  -1.87760629e-02f, -4.09510219e-03f, -2.33172476e-02f, -5.10269925e-02f, 7.97542464e-03f, 3.08890212e-02f, 6.50402233e-02f, 2.93946937e-02f, -6.03145398e-02f, -6.09007739e-02f,
  -3.43951285e-01f, -4.09276187e-01f, -2.69459020e-02f, -1.15479730e-01f, 1.39687834e-02f, -4.33945879e-02f, 7.70898769e-03f, 5.31915389e-03f, -6.20481670e-02f, -4.98900004e-02f,
  5.80170890e-03f, -2.50416603e-02f, -5.55414930e-02f, -5.43943532e-02f, -1.11099640e-02f, -9.31800529e-02f, -1.34240225e-01f, -4.99359593e-02f, -1.38039887e-01f, 5.26908450e-02f,
  -3.04889940e-02f, -7.76551813e-02f, -8.28940347e-02f, 6.43072203e-02f, -5.27409539e-02f, -1.19570583e-01f, -6.05806969e-02f, 3.91210131e-02f, -6.44241199e-02f, 3.93349007e-02f,
  1.57464847e-01f, -7.65208364e-01f, 2.32919976e-01f, 5.33610880e-01f, 3.02550554e-01f, -3.37037966e-02f, 1.20142013e-01f, -1.06723316e-01f, -6.61027059e-02f, -6.78662479e-01f,
  2.18980666e-02f, -6.20323755e-02f, -1.98512390e-01f, -2.37217937e-02f, 4.42379862e-01f, -3.02175105e-01f, -7.31974170e-02f, -6.69300854e-02f, -6.28935918e-02f, -7.09494576e-02f,
  2.57192463e-01f, 1.43702447e-01f, 2.49469951e-01f, -9.24788266e-02f, 2.16675550e-01f, 2.35930691e-03f, 6.64973259e-02f, 8.26104060e-02f, 8.84599835e-02f, 1.45974293e-01f,
  9.98860039e-03f, -9.82199460e-02f, 1.05877362e-01f, 2.85137258e-02f, -1.35777444e-01f, 4.20898497e-02f, 5.00877900e-03f, 2.96371561e-02f, 1.16723523e-01f, -8.50502476e-02f,
  -4.84590605e-03f, 5.69999330e-02f, -3.85528919e-03f, 6.97221458e-02f, 3.92974354e-02f, 8.94613266e-02f, 6.18134886e-02f, 2.23768149e-02f, 2.03436278e-02f, 6.57641143e-02f,
  -2.93353032e-02f, -4.44533639e-02f, 1.00681722e-01f, -1.04402557e-01f, 8.07139054e-02f, 6.67561814e-02f, -2.09821425e-02f, 5.01305871e-02f, -2.98101697e-02f, -8.15962777e-02f,
  -1.11766115e-01f, -6.02048077e-02f, -5.25242975e-03f, 5.18827103e-02f, 1.69237424e-02f, 1.00065552e-01f, -1.22473752e-02f, -2.88304314e-02f, 1.02290288e-02f, -1.18107600e-02f,
  2.87347510e-02f, 7.10123926e-02f, 2.42824256e-02f, 5.36362603e-02f, 5.23854829e-02f, -9.85339470e-03f, 7.06968829e-02f, -1.39453821e-02f, -5.10252975e-02f, 2.91999169e-02f,
  -5.33916801e-02f, 1.83349065e-02f, -7.32080415e-02f, 3.18665802e-02f, 3.76415974e-03f, 1.28966449e-02f, -1.22519266e-02f, -1.35365119e-02f, 8.43312684e-03f, 6.68305308e-02f,
  -2.13856384e-01f, -5.33652127e-01f, -7.69161955e-02f, 3.47130187e-02f, -1.08836107e-01f, -1.21290512e-01f, -1.50481975e-02f, -1.24726994e-02f, -8.89517814e-02f, -5.57876239e-03f,
  -4.83670505e-03f, 5.00732213e-02f, -7.03250319e-02f, 5.66227511e-02f, 8.82458314e-02f, -1.20413281e-01f, -4.28591035e-02f, -3.77004147e-02f, 7.96239451e-02f, -6.34298548e-02f,
  6.21849336e-02f, -7.42234811e-02f, -5.81786269e-03f, 8.73095915e-02f, -1.65933799e-02f, -7.27034584e-02f, -6.00798465e-02f, -9.45650414e-03f, -4.34604771e-02f, -8.21125954e-02f,
  -1.54596612e-01f, 4.89565684e-03f, -2.46646628e-01f, 2.26258293e-01f, 8.56053457e-02f, -9.78346094e-02f, -1.99041381e-01f, 8.33111107e-02f, -1.61727041e-01f, 1.22849427e-01f,
  4.80522849e-02f, 2.68273819e-02f, -2.79864758e-01f, 2.82330215e-01f, 1.57800406e-01f, -6.93629906e-02f, 2.47348770e-01f, 1.21945657e-01f, -5.84051237e-02f, 5.76947704e-02f,
  2.18565040e-03f, 3.74573320e-01f, 1.66233242e-01f, 2.38178983e-01f, 9.20483842e-02f, 1.58611890e-02f, 2.83948302e-01f, -1.59350067e-01f, 2.78953016e-01f, 1.42184377e-01f,
  1.43925883e-02f, 1.80121278e-03f, -6.98278844e-02f, 2.33445819e-02f, 5.76843359e-02f, -1.14395469e-02f, 7.05107749e-02f, 9.12590623e-02f, 6.15309784e-03f, -8.81541744e-02f,
  1.00839054e-02f, -1.23654259e-02f, 2.79874839e-02f, 4.43149991e-02f, 4.52043042e-02f, 5.13192527e-02f, 3.52488384e-02f, 4.49491255e-02f, -1.75982919e-02f, -3.65061872e-02f,
  -5.49969263e-02f, 2.58390438e-02f, 8.03041160e-02f, 2.67765094e-02f, -8.48321766e-02f, 7.21840234e-03f, -1.91948540e-03f, -7.61785591e-03f, 7.58058801e-02f, 1.00102544e-01f,
  4.00578557e-03f, -1.98113522e-03f, 9.16060992e-03f, -1.18151559e-02f, 9.53986943e-02f, 1.55382017e-02f, 9.40333121e-03f, 6.45824298e-02f, 1.32400885e-01f, 7.14879483e-02f,
  5.66364080e-02f, -2.76133679e-02f, -2.19075829e-02f, -6.89787716e-02f, -5.88531094e-03f, -7.41120502e-02f, -7.20423739e-03f, 3.41699980e-02f, 7.64911473e-02f, -7.91108161e-02f,
  -5.04077747e-02f, 5.95240034e-02f, -6.86926916e-02f, 4.75790016e-02f, 1.34576475e-02f, -1.97390299e-02f, 7.39704296e-02f, 2.93258275e-03f, -3.74824065e-03f, 9.44944024e-02f,
  -1.16874821e-01f, -7.70686194e-02f, 6.44888356e-02f, 9.00453851e-02f, 6.02256460e-03f, 1.82420406e-02f, -6.70431256e-02f, -4.47460264e-02f, -6.88258410e-02f, -2.97145005e-02f,
  -4.26590033e-02f, 1.14328027e-01f, -4.30563614e-02f, 1.08000271e-01f, -2.61382833e-02f, -6.40170416e-03f, 4.20587277e-03f, 4.85319495e-02f, -2.14721654e-02f, 1.00666232e-01f,
  -2.22037863e-02f, 7.10592568e-02f, -2.44031865e-02f, -3.87294888e-02f, 6.23858571e-02f, 4.31336351e-02f, 4.50032018e-02f, -6.28330037e-02f, 1.73048660e-01f, 6.35239715e-03f,
  -9.82421637e-02f, -1.69307142e-02f, -3.13284062e-02f, 3.71679246e-01f, -8.52736644e-03f, -4.85948056e-01f, -3.99349183e-01f, 1.02644980e-01f, -9.63759795e-02f, -2.31316313e-02f,
  9.39878598e-02f, 1.11296810e-01f, 8.25749151e-03f, 1.37507245e-01f, 1.22266240e-01f, -6.82513742e-03f, 5.69944419e-02f, -9.88697112e-02f, 8.44861753e-03f, 1.33987203e-01f,
  2.55101979e-01f, 9.97730419e-02f, 3.78184617e-01f, 2.16843531e-01f, 2.60990616e-02f, 2.02096239e-01f, 4.33957577e-01f, 6.92525730e-02f, 2.41285577e-01f, 1.10747010e-01f,
  -1.75986797e-01f, -7.06597930e-03f, 3.37518677e-02f, -7.60394782e-02f, 1.15778156e-01f, -4.40640785e-02f, -4.02477244e-03f, 4.03121784e-02f, -9.03609395e-03f, 8.22911784e-02f,
  -5.43095209e-02f, -5.70058078e-02f, -3.84210162e-02f, 3.40604596e-02f, -7.45232254e-02f, -1.54651888e-02f, -2.94776093e-02f, 2.31702104e-02f, -5.47527336e-02f, -7.96634052e-03f,
  3.44702601e-02f, 5.25575764e-02f, 4.57663909e-02f, 7.37944851e-03f, -2.60243341e-02f, -1.30685151e-01f, -4.09383979e-03f, -3.49112526e-02f, -4.15190384e-02f, 4.67985459e-02f,
  -3.58692324e-03f, 3.62776816e-02f, -3.20115197e-03f, 7.11039305e-02f, -6.47619925e-03f, 1.03657609e-02f, -6.35149181e-02f, -1.56354662e-02f, 1.73933171e-02f, -6.39158906e-03f,
  2.19486393e-02f, 7.41232783e-02f, -1.44501384e-02f, 7.10383058e-03f, -9.75857228e-02f, -4.54340279e-02f, 1.86332949e-02f, 7.66938180e-02f, 9.08883195e-03f, -5.45455003e-03f,
  6.03690408e-02f, -4.10225764e-02f, 3.28149945e-02f, -8.84429887e-02f, -5.87537102e-02f, 8.87767002e-02f, 1.58797093e-02f, -6.26554638e-02f, -1.24109564e-02f, -4.86578792e-02f,
  -6.65277094e-02f, 2.60526627e-01f, -5.96582852e-02f, -3.54840234e-02f, 1.30385030e-02f, -8.22002813e-03f, 3.38055985e-03f, 9.66500212e-03f, 2.35515255e-02f, -1.20279398e-02f,
  5.85010089e-02f, 7.23327696e-02f, -8.54770280e-03f, -2.63915733e-02f, 5.73437139e-02f, -1.75074097e-02f, 2.83823665e-02f, 6.77114576e-02f, 5.87008931e-02f, 1.56190559e-01f,
  7.76807405e-03f, -1.04222879e-01f, 7.39067420e-02f, -3.02338740e-03f, 2.77022179e-03f, 1.22001646e-02f, -3.53894867e-02f, -9.15974844e-03f, -8.16013142e-02f, 2.34394744e-02f,
  -3.33714515e-01f, 1.18957162e-01f, -1.11581892e-01f, -1.40137672e-01f, 1.66784570e-01f, -2.93557435e-01f, -7.23674595e-02f, 2.75725368e-02f, 4.13756743e-02f, 1.91156149e-01f,
  5.43208607e-02f, -1.99520290e-01f, 1.03391968e-01f, -1.44082889e-01f, -5.36296487e-01f, -5.92458248e-02f, -3.90344769e-01f, -2.08630458e-01f, -1.18494049e-01f, -1.30806357e-01f,
  -1.35850117e-01f, 5.10374121e-02f, -8.11138600e-02f, 1.30318269e-01f, -7.15002194e-02f, 3.55456918e-02f, 1.04219191e-01f, 1.77731663e-01f, 1.33981407e-02f, -6.12141192e-02f,
  -2.52384786e-03f, 1.85079277e-01f, 1.05868563e-01f, -4.85999286e-02f, -6.68620095e-02f, -1.92278400e-02f, -9.00261402e-02f, -4.16748933e-02f, 7.09798411e-02f, -4.19546962e-02f,
  -2.61916444e-02f, -2.20026318e-02f, -8.45564231e-02f, 9.15740710e-03f, 4.15079780e-02f, 4.85047996e-02f, -4.03001346e-02f, -4.49322648e-02f, -2.54132319e-03f, -7.69621059e-02f,
  -8.88808668e-02f, -1.68237947e-02f, -9.55850631e-02f, -4.27719764e-02f, -7.65140057e-02f, 4.21436429e-02f, -1.06993340e-01f, 2.50513330e-02f, 1.04978010e-02f, 1.22670364e-02f,
  3.75474319e-02f, -7.39433691e-02f, -4.32791114e-02f, -6.50146455e-02f, -5.42788096e-02f, 1.09129474e-02f, -2.76413914e-02f, -7.07257837e-02f, -7.65646473e-02f, 4.68364917e-02f,
  1.25341711e-03f, 8.49990547e-03f, 7.10571408e-02f, -8.13066438e-02f, -1.20587282e-01f, 4.39549759e-02f, -2.91548632e-02f, 2.92317700e-02f, -1.35048836e-01f, -3.24331895e-02f,
  9.44389701e-02f, 2.16476843e-02f, 7.51903504e-02f, 2.97099166e-02f, -7.04435213e-03f, 3.61945443e-02f, 1.20111986e-03f, -3.15870270e-02f, 4.13036980e-02f, -1.49995433e-02f,
  9.74527299e-02f, 3.41789760e-02f, -3.96918505e-02f, 8.70671123e-02f, -3.18285711e-02f, -1.12207122e-02f, -1.00069635e-01f, -5.47128431e-02f, -8.50557014e-02f, -1.69952046e-02f,
  -5.29697798e-02f, 2.60805972e-02f, -3.69711146e-02f, 3.64023820e-02f, 3.26741934e-02f, -1.46664598e-03f, -3.85253713e-03f, 8.28310847e-02f, 3.74769121e-02f, -2.88220756e-02f,
  4.64765318e-02f, -3.31181660e-02f, -3.06517072e-02f, 3.30509469e-02f, 4.39174473e-02f, 1.66060850e-02f, -9.27767679e-02f, -5.52154444e-02f, 1.48545848e-02f, -3.52563038e-02f,
  5.45864224e-01f, 1.93920508e-01f, 2.43540108e-01f, 5.45465231e-01f, 4.95588854e-02f, -3.03906444e-02f, -4.06645052e-02f, 1.62296489e-01f, 6.53878927e-01f, -1.38665121e-02f,
  -2.10863769e-01f, 3.13911200e-01f, -3.82511050e-01f, 2.03993186e-01f, -2.62745738e-01f, -1.65543109e-01f, 1.59931127e-02f, 5.63425012e-02f, 1.43992439e-01f, 1.42577529e-01f,
  9.75504294e-02f, -2.54181445e-01f, -1.60838813e-01f, -3.72773856e-01f, 9.41048414e-02f, 1.11782268e-01f, -3.71965796e-01f, -2.49818265e-01f, 4.98522213e-03f, -1.85099334e-01f,
  5.61454333e-02f, 2.23283842e-01f, 1.58160403e-02f, -1.09210359e-02f, -5.12387119e-02f, -1.93363186e-02f, -7.94322938e-02f, -8.16729143e-02f, 4.70170490e-02f, 2.79506613e-02f,
  -2.17193970e-03f, -2.20764671e-02f, 6.63950071e-02f, -6.50399327e-02f, 9.98102874e-02f, 8.54694024e-02f, 7.26540238e-02f, 1.22382589e-01f, 8.64600316e-02f, 3.58128212e-02f,
  4.08071280e-02f, 3.82446945e-02f, 6.69416115e-02f, -2.76766866e-02f, 2.38640551e-02f, -7.84601609e-04f, -1.00634964e-02f, 2.84826066e-02f, 5.28897084e-02f, 6.23759255e-02f,
  -9.55390260e-02f, -4.73925956e-02f, -8.48292187e-02f, 2.21510641e-02f, -3.70616801e-02f, 4.09191959e-02f, -8.20729733e-02f, -1.58891454e-02f, 3.25172730e-02f, 9.36241879e-04f,
  8.96640215e-03f, 6.56054989e-02f, -5.04038334e-02f, 3.04539055e-02f, 3.57865915e-02f, 6.55042082e-02f, -5.22774085e-03f, -2.10688403e-03f, -1.51577806e-02f, 7.20743313e-02f,
  -2.14830227e-02f, -6.71744049e-02f, -5.26353270e-02f, -5.32742888e-02f, -2.14940365e-02f, 4.90898686e-03f, 1.81574635e-02f, 1.27030686e-01f, 3.41556640e-03f, -1.10772051e-01f,
  -1.06734730e-01f, -1.10167459e-01f, -4.41172794e-02f, -1.47863887e-02f, -5.91765763e-03f, -9.91807785e-03f, 5.31011121e-03f, 7.47510269e-02f, -2.93563735e-02f, -4.12946045e-02f,
  -2.44450383e-02f, 2.73955930e-02f, -7.50584900e-03f, 9.26270261e-02f, -9.27219242e-02f, -2.77188718e-02f, -3.23908664e-02f, -5.57613485e-02f, -7.47466460e-02f, -6.54011667e-02f,
  -5.26549388e-03f, -4.68675010e-02f, 2.19448674e-02f, 2.00624820e-02f, -1.93771888e-02f, -6.19375668e-02f, 4.95696068e-02f, -4.49810475e-02f, -5.98756820e-02f, 4.14885674e-03f,
  -4.74537671e-01f, 1.24570996e-01f, 1.40814288e-02f, 5.76774105e-02f, -1.06755398e-01f, 1.33441418e-01f, 3.34448040e-01f, -4.17809710e-02f, 5.27355867e-03f, 3.21212322e-01f,
  3.16979140e-01f, -6.93013519e-02f, 1.41399175e-01f, 2.84955233e-01f, 7.78277218e-02f, 1.46200821e-01f, 2.38512561e-01f, 2.72157431e-01f, -1.65570229e-01f, -1.85148269e-02f,
  -2.92487796e-02f, 2.35430613e-01f, 1.84044421e-01f, -1.21176727e-01f, 4.03018780e-02f, -2.27769434e-01f, 1.09194480e-01f, -1.89504668e-01f, 1.14113621e-01f, 4.43948954e-02f,
  -3.64657119e-02f, -2.24332899e-01f, 4.39649150e-02f, -1.32339587e-02f, -3.77155002e-03f, -4.68560122e-02f, -2.58971378e-02f, -8.27791169e-02f, -5.78552075e-02f, -4.48093042e-02f,
  -7.96419680e-02f, -1.21527165e-01f, -9.59924459e-02f, -2.04945244e-02f, -4.91207428e-02f, -3.67707526e-03f, -3.14773689e-03f, 5.54228611e-02f, 5.33791594e-02f, -4.83092107e-02f,
  -9.91653278e-03f, 2.63255108e-02f, 5.03049195e-02f, 6.41346350e-02f, 7.87220821e-02f, 2.12420840e-02f, 3.97372618e-02f, -2.97111887e-02f, -1.87415555e-02f, -2.79115513e-04f,
  -1.25904053e-01f, -6.22079289e-03f, 4.99340426e-03f, 9.76208597e-02f, -2.30397545e-02f, 3.67905386e-02f, 3.56509909e-02f, 3.96168232e-02f, 2.66497582e-02f, 3.97501327e-02f,
  -3.09681706e-02f, 4.21627499e-02f, -2.42150016e-02f, -9.15264618e-03f, 8.23647156e-02f, 3.21287178e-02f, -2.38626525e-02f, -2.04158835e-02f, -4.71691489e-02f, 4.07264717e-02f,
  -2.11417936e-02f, -1.14857458e-01f, 7.22059235e-02f, 6.54051751e-02f, -5.02396002e-02f, 4.68596555e-02f, 7.21422434e-02f, 8.87267143e-02f, 2.22390592e-02f, 6.79358281e-03f,
  4.70809229e-02f, -1.06631499e-02f, -1.41344815e-02f, -5.57033457e-02f, -1.22203212e-02f, -3.47378738e-02f, 2.79733352e-02f, 3.85948680e-02f, -6.87398240e-02f, -1.13979997e-02f,
  -5.45935258e-02f, 2.04364303e-02f, 3.40349376e-02f, -1.37533213e-03f, 9.55819059e-03f, 5.71130365e-02f, -2.53963657e-02f, 2.91724894e-02f, 7.47526288e-02f, -6.39462518e-03f,
  3.50910686e-02f, -6.48048297e-02f, -7.88347051e-02f, 7.90760946e-03f, -1.21194152e-02f, 4.17347737e-02f, -1.14142410e-02f, -9.60984677e-02f, 1.51176413e-03f, -3.62221524e-02f,
  -6.96214736e-02f, 3.60829055e-01f, -5.65746427e-02f, 5.44892671e-03f, 7.38812536e-02f, -2.89737374e-01f, -2.26613835e-01f, 1.29255906e-01f, -1.85967870e-02f, 1.83500722e-01f,
  -1.46812247e-03f, 2.61944652e-01f, 2.13337075e-02f, -1.93794563e-01f, -7.90315986e-01f, -3.78423125e-01f, -4.10656899e-01f, -5.70505485e-02f, -4.35707718e-02f, 3.33524980e-02f,
  -1.81972355e-01f, -1.36093184e-01f, -1.84986636e-01f, 2.09258378e-01f, 1.82394475e-01f, 2.96177953e-01f, 1.09223440e-01f, 2.19481200e-01f, -1.01029044e-02f, -1.39506590e-02f,
  -8.25694650e-02f, 4.78247404e-02f, 8.15381035e-02f, 5.66256456e-02f, -1.38428062e-02f, -1.91089418e-02f, 2.70703882e-02f, 2.45838556e-02f, 2.56220717e-03f, -3.82308848e-02f,
  7.85304680e-02f, -1.58534385e-02f, 5.22385091e-02f, 2.92352475e-02f, 4.29042801e-02f, 1.02751158e-01f, 5.06529994e-02f, 6.57717362e-02f, 1.23914152e-01f, -2.06819065e-02f,
  2.35583987e-02f, -5.65610118e-02f, -1.83157867e-03f, -3.16964239e-02f, 1.78746022e-02f, -1.57207213e-02f, -7.89679661e-02f, -6.89351335e-02f, 1.55193144e-02f, -3.74012664e-02f,
  -8.84777158e-02f, 2.88941562e-02f, -3.12296767e-02f, 8.39566365e-02f, 4.48749624e-02f, 5.32442704e-02f, -3.39817479e-02f, -6.55956892e-03f, 3.99770215e-03f, 9.07038525e-03f,
  1.66533589e-02f, 7.59001356e-03f, -5.66665195e-02f, 1.75567381e-02f, 6.50729388e-02f, -3.62351350e-02f, -3.46886367e-02f, 4.14995290e-02f, -7.97815174e-02f, -2.66824868e-02f,
  3.54197342e-03f, -3.63796614e-02f, -4.48860154e-02f, 1.98015273e-02f, -4.03942913e-02f, 4.88665421e-03f, 8.43899474e-02f, 8.04351196e-02f, 3.37054953e-03f, -1.18723493e-02f,
  -1.29980356e-01f, -9.33583826e-02f, 3.65084969e-02f, 3.28091234e-02f, -3.68011110e-02f, 1.04807820e-02f, -1.21122580e-02f, 2.75060302e-03f, -2.19708886e-02f, -3.09699848e-02f,
  4.07673009e-02f, -3.54375578e-02f, 1.39048207e-03f, -5.36078494e-03f, -9.51678529e-02f, -4.86074090e-02f, -4.03212234e-02f, 6.56391680e-02f, -2.04548594e-02f, -7.40399808e-02f,
  1.22730881e-01f, -8.06840428e-04f, -5.32377362e-02f, -1.06130540e-02f, -7.92874373e-04f, 4.86245099e-03f, 6.62631541e-02f, 7.57831410e-02f, -2.36280784e-02f, -5.72122633e-03f,
  -1.43119186e-01f, -1.73636347e-01f, -8.01097527e-02f, 2.03761365e-02f, -2.48000696e-02f, -5.37129454e-02f, 1.45133629e-01f, -2.28803441e-01f, -1.00858636e-01f, -2.80750617e-02f,
  -5.63065968e-02f, 1.58429563e-01f, -1.59181759e-01f, 2.09059626e-01f, 9.52785015e-02f, 7.01703504e-02f, -9.48351342e-03f, 1.48493946e-01f, 2.63480991e-02f, -1.80937275e-01f,
  -8.50952044e-02f, 1.15530685e-01f, 6.30191192e-02f, -8.01976363e-04f, 9.05462354e-02f, 1.81538444e-02f, 1.07505597e-01f, 1.07885092e-01f, 1.17562048e-01f, 1.29719794e-01f,
  -1.17448971e-01f, -1.04259662e-01f, -1.23552501e-01f, -4.36630063e-02f, -3.70485708e-02f, -4.25810367e-02f, 7.78293312e-02f, 7.05929399e-02f, -5.29477410e-02f, 2.21028067e-02f,
  1.01146981e-01f, 9.02109221e-02f, 6.44364432e-02f, 3.71317677e-02f, -5.49089201e-02f, -1.30255535e-01f, 2.50597042e-03f, -4.32590358e-02f, -1.21589310e-01f, -5.06586991e-02f,
  -4.35599796e-02f, -7.52850920e-02f, -1.11788824e-01f, -5.73826861e-03f, 7.36065507e-02f, -2.31328066e-02f, -1.80229805e-02f, 4.92327511e-02f, 5.48997987e-03f, 3.21548097e-02f,
  -3.78012583e-02f, 4.78871986e-02f, -7.93160498e-02f, 2.24523637e-02f, -1.27633512e-01f, 1.21725695e-02f, -7.57065937e-02f, 3.94923873e-02f, -4.94967476e-02f, -5.91600910e-02f,
  3.03084552e-02f, -2.96799038e-02f, -4.88421787e-03f, -5.67535385e-02f, -5.43112382e-02f, 2.56025046e-02f, 1.03528611e-01f, 1.12744300e-02f, -3.57002094e-02f, 3.84577475e-02f,
  -3.43849361e-02f, 2.04034485e-02f, 4.23448868e-02f, -9.03330892e-02f, 4.02409807e-02f, 4.02769595e-02f, -7.00102299e-02f, -1.13968309e-02f, -2.23070700e-02f, -3.77642810e-02f,
  -1.62020043e-01f, -2.26952359e-01f, -1.22497246e-01f, -4.29288186e-02f, 1.06597669e-01f, 3.49335633e-02f, 5.44796176e-02f, -7.23119751e-02f, 4.14707661e-02f, -7.16006607e-02f,
  4.96910885e-02f, -6.51201084e-02f, 5.81972934e-02f, -3.60684320e-02f, 8.08745250e-02f, -2.87244525e-02f, -2.04617213e-02f, 3.07115242e-02f, 5.01037166e-02f, -1.26445098e-02f,
  -6.86895028e-02f, 8.97682272e-03f, -3.72918695e-02f, -1.93629023e-02f, -1.49750095e-02f, 7.28791719e-03f, -1.99884251e-02f, -7.58286864e-02f, -3.53356525e-02f, 1.07917428e-01f,
  4.00749557e-02f, 1.02339029e-01f, 2.45114900e-02f, 1.31718591e-01f, 1.57366112e-01f, -2.33021870e-01f, -2.72486713e-02f, 1.19720355e-01f, -4.21610326e-02f, -2.20874883e-02f,
  -9.20239463e-02f, -1.03109725e-01f, -1.02865495e-01f, -2.73615330e-01f, -2.39186808e-01f, -3.56936783e-01f, -5.81963584e-02f, -1.16879173e-01f, -1.23623587e-01f, 1.01132639e-01f,
  7.44794458e-02f, -4.85707484e-02f, 1.73730284e-01f, 3.28748912e-01f, 1.20706022e-01f, 3.66919994e-01f, 2.51820326e-01f, 1.44055814e-01f, 1.08576238e-01f, -2.19166026e-01f,
  -1.55401394e-01f, -4.80990708e-02f, -3.45239379e-02f, -1.32002518e-01f, 1.49235189e-01f, 2.18551280e-03f, -1.18966540e-02f, -8.38129073e-02f, 3.58881764e-02f, -1.13442158e-02f,
  -5.59690292e-04f, -2.61719506e-02f, -3.72122265e-02f, -3.18248682e-02f, 7.84017667e-02f, 5.58576658e-02f, -1.11942701e-02f, 5.43267168e-02f, 1.19141294e-02f, 2.08085701e-02f,
  5.11163920e-02f, 1.04096821e-02f, -5.82252778e-02f, -6.58918545e-02f, 1.60347857e-02f, 6.39135158e-03f, 4.33068611e-02f, 4.26851697e-02f, 3.73917185e-02f, 4.72810678e-02f,
  -1.20270010e-02f, -1.02230292e-02f, -5.87724941e-03f, -4.73677963e-02f, 7.44949188e-03f, 3.55426334e-02f, -2.51858998e-02f, 4.90404479e-02f, -4.72972542e-02f, -6.69612810e-02f,
  6.24082284e-04f, -6.25170991e-02f, 5.20850793e-02f, 1.50706833e-02f, 6.59932569e-02f, 1.23548303e-02f, 2.92574577e-02f, -1.87721588e-02f, 3.71334702e-02f, 8.20079520e-02f,
  1.87783372e-02f, -1.53987945e-04f, 1.30641768e-02f, 5.04483469e-03f, -8.09531659e-02f, 4.08745371e-02f, -3.49265672e-02f, -8.47916976e-02f, 4.70003709e-02f, 3.66194621e-02f,
  2.97370236e-02f, 1.04051605e-01f, 1.68386549e-02f, -7.34264776e-02f, 3.81181985e-02f, -1.28084784e-02f, -1.33032367e-01f, -1.78551450e-02f, 3.65538001e-02f, -1.13518037e-01f,
  1.60210431e-01f, 3.69856134e-02f, -1.40834767e-02f, -1.07495524e-01f, 1.91404019e-02f, 4.24950756e-02f, -4.53862734e-02f, 4.14682515e-02f, 6.76879883e-02f, 4.14826013e-02f,
  5.42115755e-02f, -5.36701595e-03f, 7.32094347e-02f, 5.16076051e-02f, 4.77504022e-02f, 7.98176453e-02f, 9.26118996e-03f, 6.73813820e-02f, -2.66452320e-02f, -1.98004972e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.29989752e-01f, 4.04927075e-01f, 2.46312037e-01f, 2.96590161e-02f, 3.55226755e-01f, 3.08297545e-01f, 2.01601073e-01f, 2.20771693e-02f, 2.09098831e-01f, 3.80524606e-01f,
  1.35401279e-01f, 3.90659183e-01f, 9.25244167e-02f, 4.71834987e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  4.04253095e-01f, -2.22396106e-01f, -1.83304530e-02f, -2.03358606e-01f, 3.24238211e-01f, 8.59609991e-02f, 6.88907802e-02f, -3.60871792e-01f, -2.66178101e-01f, 2.03365475e-01f,
  -1.22320466e-01f, -3.17193031e-01f, 4.80408758e-01f, -3.60545337e-01f, -2.49935701e-01f, 1.38943642e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.47765505e-01f, 1.39063299e-01f, -1.79373294e-01f, 8.51505816e-01f, -5.80983534e-02f, -2.89903224e-01f, -1.39028668e-01f, 1.98197603e-01f, 4.13606048e-01f, -1.58742860e-01f,
  -2.61155158e-01f, -8.49890113e-02f, 1.22064389e-01f, -1.36318684e-01f, 1.93205789e-01f, -2.22796760e-02f, 2.70905167e-01f, -2.34766051e-01f, -2.09320754e-01f, 6.26579523e-01f,
  2.47434169e-01f, -1.92621008e-01f, 5.05768545e-02f, 2.54997462e-01f, -3.38098615e-01f, 1.25572547e-01f, -1.22642659e-01f, 6.16234422e-01f, -2.53315896e-01f, -3.11681569e-01f,
  4.30332609e-02f, -9.38673131e-03f, -3.65168154e-02f, 3.47389042e-01f, 1.22355953e-01f, -8.05489570e-02f, 1.65147707e-01f, 1.37331352e-01f, 4.24380451e-01f, -1.90240592e-01f,
  -7.75742084e-02f, -1.75761715e-01f, -1.44560561e-01f, -1.81643870e-02f, 1.22104250e-01f, -9.29422006e-02f, -5.30894995e-02f, 1.66174963e-01f, 1.05737634e-01f, -5.04253387e-01f,
  1.77911282e-01f, -7.28168264e-02f, 2.73129940e-01f, 2.29248628e-01f, 1.40231043e-01f, -2.14420572e-01f, 1.80364475e-01f, 2.54418284e-01f, -1.80304363e-01f, -1.12521522e-01f,
  3.18038732e-01f, -2.05386013e-01f, -7.90179670e-02f, 2.55587190e-01f, -2.54275143e-01f, 4.46871251e-01f, 4.60632443e-01f, 2.73327470e-01f, -9.28878412e-02f, 3.51018250e-01f,
  -1.24443807e-01f, 1.79801196e-01f, 2.50764459e-01f, 5.34875154e-01f, 6.61816299e-01f, -4.40215826e-01f, 4.53311205e-01f, 4.58418638e-01f, 1.50387540e-01f, 7.90908262e-02f,
  9.67052802e-02f, 3.98910582e-01f, -3.37838084e-01f, -2.10249141e-01f, -1.07890032e-01f, 1.27938762e-01f, 7.08573461e-01f, -8.93963724e-02f, -9.25617069e-02f, -1.62262172e-01f,
  6.87598884e-02f, 9.49723303e-01f, -2.64356166e-01f, 5.77369153e-01f, 2.18127724e-02f, 1.71549797e-01f, 5.92707992e-01f, -4.95871663e-01f, -5.93190528e-02f, -3.65280896e-01f,
  4.62595969e-01f, 3.61003995e-01f, -3.66286039e-01f, 1.22410583e+00f, 6.00058734e-01f, 6.80149138e-01f, -1.72124028e-01f, 4.79444295e-01f, 5.38856396e-03f, 3.07918429e-01f,
  -1.47722531e-02f, 6.26789570e-01f, 4.95734185e-01f, 3.22944105e-01f, 1.04742430e-01f, -8.26749578e-02f, -1.28956407e-01f, -3.28148007e-01f, 7.36457527e-01f, -2.29645416e-01f,
  1.49490923e-01f, -2.74310946e-01f, 5.08054972e-01f, 4.68522608e-01f, 7.42904991e-02f, 7.88148165e-01f, -2.42175013e-01f, 4.67186242e-01f, 2.02927992e-01f, 5.61056212e-02f,
  5.14969826e-01f, -8.63468349e-02f, 3.95272486e-02f, 4.90899265e-01f, 1.63761139e-01f, -1.87787771e-01f, 2.60705262e-01f, 3.80845279e-01f, -2.21021280e-01f, -2.86616951e-01f,
  4.76453274e-01f, 1.65867403e-01f, -6.50691763e-02f, -8.21451768e-02f, -5.55506498e-02f, 2.99263030e-01f, -5.31733185e-02f, 2.32051879e-01f, 1.30762741e-01f, 2.78324354e-02f,
  3.04828852e-01f, -8.29197317e-02f, 2.46672332e-03f, -9.38162059e-02f, 1.54144235e-03f, -1.48993015e-01f, 2.10131362e-01f, -2.33039692e-01f, -1.70039967e-01f, -1.05379149e-01f,
  -1.47862643e-01f, 3.19089413e-01f, 5.91929220e-02f, 4.33821529e-01f, 3.35392058e-02f, 3.59886140e-02f, -3.05013031e-01f, 1.49144247e-01f, 2.47412622e-02f, 1.99980661e-01f,
  6.52756333e-01f, -3.05818431e-02f, -2.44433939e-01f, 5.18544257e-01f, -2.12159961e-01f, 5.00842094e-01f, -8.35947618e-02f, 1.91124622e-02f, -4.22869250e-02f, 2.15437368e-01f,
  3.41407239e-01f, -1.76012665e-01f, -1.06973166e-03f, 6.73220038e-01f, 5.59332930e-02f, 1.87561601e-01f, 1.47957742e-01f, -6.76143821e-03f, -3.00411910e-01f, 2.31357124e-02f,
  -2.03342840e-01f, 3.43231440e-01f, 2.72303283e-01f, 5.33729613e-01f, -3.60773563e-01f, 8.86126518e-01f, 3.71324755e-02f, -2.97660530e-01f, 4.91908401e-01f, 6.45691156e-01f,
  2.45763063e-01f, 2.25896105e-01f, 2.28928372e-01f, -5.11375368e-01f, 3.19884002e-01f, -5.94518781e-02f, 5.35932302e-01f, -3.99009734e-01f, -2.33496085e-01f, 7.33309627e-01f,
  -8.73180032e-02f, 3.32786798e-01f, 3.22948731e-02f, -1.06706485e-01f, 7.02308118e-01f, -2.99515366e-03f, 2.64346987e-01f, 3.65575999e-01f, 6.07145689e-02f, -1.95936605e-01f,
  -6.59028888e-02f, 7.80128539e-02f, 2.96898395e-01f, 8.24074168e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  5.99576414e-01f, 3.30329329e-01f, 9.35539901e-02f, 2.43046746e-01f, 1.78257123e-01f, 5.75619459e-01f, 6.21151209e-01f, 5.75107634e-01f, 2.88037777e-01f, 1.95149183e-01f,
  2.53082186e-01f, 3.13759506e-01f, 4.14619237e-01f, 3.30844671e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.46682578e-01f, 7.48689994e-02f, 1.98872060e-01f, -5.36850058e-02f, -2.09214702e-01f, 1.05671860e-01f, 1.18657827e-01f, -1.90791368e-01f, 1.53472811e-01f, -4.59000826e-01f,
  1.80485576e-01f, 2.30562612e-01f, 2.74706542e-01f, 2.27261353e-02f, -7.72953406e-02f, 9.49198287e-03f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  4.22517389e-01f, -9.77406800e-02f, 4.10942346e-01f, 4.64146137e-01f, 8.64269659e-02f, -3.43947977e-01f, -5.14122238e-03f, 6.69656813e-01f, -4.60479498e-01f, 7.53053188e-01f,
  -9.10913646e-02f, 9.26561803e-02f, 4.61240709e-01f, 3.91610451e-02f, 5.12952626e-01f, 5.87683916e-01f, -1.06752627e-01f, -3.13273072e-01f, 1.59918457e-01f, -3.01665843e-01f,
  -5.23064435e-02f, -3.48792039e-02f, -1.10427231e-01f, -2.06447914e-01f, 5.41333139e-01f, -2.46356964e-01f, -2.93609351e-01f, 3.24883051e-02f, -1.43592462e-01f, 3.65765512e-01f,
  1.68811008e-01f, -2.69359231e-01f, -5.33019781e-01f, -4.88548279e-01f, -8.33251402e-02f, -2.66761959e-01f, -2.36093268e-01f, -2.32214946e-02f, 4.68943745e-01f, 4.25208807e-01f,
  2.09584404e-02f, 5.18323541e-01f, -2.61638880e-01f, -2.80964881e-01f, 5.88283062e-01f, 2.08920866e-01f, 1.44595608e-01f, 1.40077204e-01f, -1.51328534e-01f, 7.31940418e-02f,
  8.24145749e-02f, -1.43355317e-02f, 1.30048677e-01f, -1.44191489e-01f, -4.04549569e-01f, 8.28740180e-01f, -1.93349067e-02f, 6.81282640e-01f, 1.04534432e-01f, -1.14773996e-01f,
  -2.17468545e-01f, -2.34218895e-01f, 1.20688632e-01f, 1.41291559e-01f, -5.96672446e-02f, -1.18982857e-02f, 5.40168822e-01f, -2.94290274e-01f, 3.13879699e-01f, -2.79497921e-01f,
  7.25238860e-01f, -2.48135880e-01f, -1.93636976e-02f, 1.98739350e-01f, 2.77866006e-01f, 4.13695037e-01f, 1.26390666e-01f, -1.38402373e-01f, 1.05395126e+00f, 7.17238843e-01f,
  -1.46826968e-01f, -1.77751377e-01f, -1.41670629e-02f, -3.06542875e-04f, -6.70913281e-03f, 1.25955030e-01f, -2.42069602e-01f, 5.07017970e-01f, 3.32216948e-01f, 1.84220001e-01f,
  -1.40238807e-01f, -7.40878563e-03f, -2.34380305e-01f, -2.47469649e-01f, -2.32226402e-01f, -1.19660653e-01f, -2.91216463e-01f, 5.41832484e-02f, 1.00071430e-01f, -2.19912291e-01f,
  2.31416505e-02f, 1.79679960e-01f, 5.75946450e-01f, -1.08181201e-01f, 1.41048744e-01f, 2.85752982e-01f, 2.41645306e-01f, -5.08935042e-02f, 4.95945632e-01f, -7.87905306e-02f,
  1.82489827e-01f, 2.71913320e-01f, 9.69281018e-01f, 4.84798551e-01f, 3.32468390e-01f, -7.10044950e-02f, 6.51192293e-02f, 3.01514387e-01f, -2.78538316e-01f, 1.86943665e-01f,
  7.33074790e-04f, 5.22347540e-02f, 1.55260831e-01f, 1.02806248e-01f, -6.18869424e-01f, -3.64405125e-01f, 6.25281215e-01f, -2.77544670e-02f, 6.47614121e-01f, 5.36498547e-01f,
  3.41197312e-01f, -1.75233796e-01f, -1.36851951e-01f, 5.53786874e-01f, 1.91519871e-01f, -2.90789098e-01f, 2.84556985e-01f, 3.30556720e-01f, 6.22898340e-01f, 8.53209496e-02f,
  -2.32130617e-01f, -3.47964495e-01f, 4.71178889e-02f, -3.17146033e-01f, 6.35134280e-01f, 1.69754960e-02f, -1.05006196e-01f, 3.48752588e-01f, -1.90501317e-01f, 2.25305498e-01f,
  -2.95203477e-01f, 1.26062945e-01f, 1.35935223e+00f, 5.61160862e-01f, 8.04100484e-02f, -3.28265458e-01f, 1.96081281e-01f, 3.26838762e-01f, -2.84440935e-01f, -2.92226672e-01f,
  3.51630807e-01f, -1.04101777e-01f, 3.24662864e-01f, 6.70018852e-01f, -3.30113292e-01f, 1.79514408e-01f, -3.62854302e-01f, -1.58306465e-01f, 5.22208273e-01f, -4.20542836e-01f,
  -4.58405375e-01f, 1.07579241e-02f, -1.25641629e-01f, 4.19093758e-01f, 6.63234055e-01f, -7.49846995e-02f, 3.14928740e-01f, -3.22102010e-01f, 7.66142547e-01f, 4.97712702e-01f,
  -1.47774965e-01f, -4.06499386e-01f, -3.36722761e-01f, -1.49501130e-01f, 5.19662261e-01f, -3.17125708e-01f, -5.18583238e-01f, -7.06700236e-02f, 1.03379756e-01f, 3.42306346e-02f,
  3.43531251e-01f, -2.70128638e-01f, -1.57047346e-01f, -1.96703717e-01f, -1.47978753e-01f, 2.35187247e-01f, 1.49673924e-01f, 5.87427616e-02f, -3.78093630e-01f, 5.80091238e-01f,
  4.43701267e-01f, 2.35549241e-01f, 5.59173562e-02f, 1.24429829e-01f, -1.37547895e-01f, 3.38501483e-01f, -2.10698154e-02f, 3.78246784e-01f, -3.11971664e-01f, 2.51827925e-01f,
  9.12914053e-02f, -3.02018732e-01f, 5.29817939e-02f, -9.40803960e-02f, 5.73399007e-01f, -4.69186783e-01f, 1.02339017e+00f, -4.47606057e-01f, 2.42339253e-01f, 5.61996028e-02f,
  -1.75358102e-01f, 1.16910376e-01f, 5.86292386e-01f, 2.42452845e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  4.95884746e-01f, 3.10491342e-02f, 2.69148834e-02f, 7.54129216e-02f, 5.05547971e-02f, -1.02354169e-01f, -2.61980444e-01f, 7.61959016e-01f, 6.85195565e-01f, 6.69295371e-01f,
  2.52463460e-01f, 3.88093889e-01f, -1.62112713e-01f, 1.98419634e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  2.19063088e-01f, 8.74879584e-02f, 1.94113687e-01f, 2.97662038e-02f, -1.69420302e-01f, -7.30185285e-02f, 9.31863606e-01f, -1.98804006e-01f, 1.19315181e-02f, 4.27633166e-01f,
  1.05240554e-01f, -9.40210283e-01f, -2.49493033e-01f, -3.29494804e-01f, -5.09271026e-01f, 2.80200362e-01f, 7.04310477e-01f, 4.73488331e-01f, -6.30518973e-01f, 5.75176236e-05f,
  -4.54984188e-01f, -4.32957381e-01f, 6.18695654e-02f, -1.81570485e-01f, -1.50070861e-01f, 6.10603929e-01f, 1.04420304e+00f, 3.63587916e-01f, -3.63529354e-01f, -2.85083503e-01f,
  -4.05647337e-01f, 2.33894646e-01f, -6.03409886e-01f, 2.23777309e-01f, -5.48287988e-01f, 5.65219343e-01f, 2.32833669e-01f, -2.50103086e-01f, 3.37779224e-01f, 2.09675685e-01f,
  2.54181772e-01f, -2.68513381e-01f, -3.05043161e-01f, -9.15075466e-02f, 1.48027465e-01f, 4.11657631e-01f, 1.83351636e-02f, 6.77770913e-01f, -2.93813676e-01f, -1.27049861e-02f,
  4.11041766e-01f, 1.67951554e-01f, 9.66856897e-01f, 5.89304492e-02f, 4.96793866e-01f, -1.96596950e-01f, 2.97945738e-01f, -2.70753443e-01f, -5.42484343e-01f, -7.31567025e-01f,
  -4.81735528e-01f, -4.18159664e-01f, -1.03172801e-01f, -4.75110143e-01f, -9.41580236e-02f, -5.35429776e-01f, 8.30366492e-01f, -2.45845199e-01f, -3.13338161e-01f, 1.76322311e-01f,
  3.74281108e-01f, -7.37593174e-02f, -7.24257976e-02f, 4.96315837e-01f, -5.41446581e-02f, -3.25186074e-01f, -2.24980116e-01f, -4.88947272e-01f, 5.06035388e-01f, -4.41233605e-01f,
  6.10541701e-01f, -1.29655167e-01f, 5.77731431e-01f, -3.67635250e-01f, -3.39937955e-01f, 9.18344110e-02f, -3.43859255e-01f, 2.90654123e-01f, -3.08749467e-01f, 7.62733042e-01f,
  5.05557537e-01f, 2.56402314e-01f, 4.14849579e-01f, 7.09031940e-01f, -3.79263610e-01f, -7.56102026e-01f, 2.88555384e-01f, 1.33540779e-01f, -3.38957101e-01f, 2.65260488e-01f,
  1.62441488e-02f, -3.39483857e-01f, -7.92932749e-01f, 1.66209742e-01f, -3.98280233e-01f, -3.77261192e-01f, -4.51144934e-01f, 9.85288739e-01f, 1.47466823e-01f, 3.58336240e-01f,
  2.61909306e-01f, -7.00168163e-02f, -3.03969711e-01f, 4.53258038e-01f, 2.67008454e-01f, -1.88134879e-01f, 1.50546461e-01f, -4.57888633e-01f, 6.88889921e-01f, 1.77149951e-01f,
  2.28388041e-01f, -5.51725209e-01f, -3.29499394e-01f, -4.66423035e-01f, 4.61471856e-01f, 3.86604428e-01f, -1.76006213e-01f, 2.36857727e-01f, -8.05765569e-01f, 1.59775510e-01f,
  -6.35524750e-01f, 2.77563818e-02f, -1.37098178e-01f, 1.60253242e-01f, -4.32778388e-01f, -5.23819886e-02f, 4.00851041e-01f, -4.96845037e-01f, 4.09434766e-01f, 4.41647857e-01f,
  1.09699510e-01f, -5.55329740e-01f, 3.73545513e-02f, 7.45629430e-01f, 4.02902961e-01f, 7.67314509e-02f, -3.89116943e-01f, 3.86734933e-01f, -4.58182096e-01f, -4.32901144e-01f,
  -1.74255356e-01f, -3.92709255e-01f, -4.47631508e-01f, 4.11044568e-01f, 3.71848680e-02f, 1.17984660e-01f, 9.43618298e-01f, 4.87508774e-01f, -1.86007962e-01f, 2.85676479e-01f,
  6.79900795e-02f, -6.65759683e-01f, 4.00378257e-01f, -1.27012774e-01f, 4.18028176e-01f, -9.20614451e-02f, -6.06569164e-02f, -2.24161386e-01f, 2.37167731e-01f, -4.90042299e-01f,
  2.45734036e-01f, 5.51703155e-01f, -4.85435545e-01f, -3.89191002e-01f, -2.06665948e-01f, -4.08890426e-01f, -6.22300565e-01f, -2.70511359e-01f, 9.10390243e-02f, -1.84877872e-01f,
  3.68735313e-01f, 8.91991019e-01f, -3.10370743e-01f, 3.46303970e-01f, -3.90973777e-01f, -3.06533039e-01f, -2.82859683e-01f, 2.26505384e-01f, -2.08363906e-01f, -2.63148695e-01f,
  4.25650328e-01f, -4.49605435e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  2.01362997e-01f, 3.73952329e-01f, -5.66803634e-01f, -4.46864009e-01f, 2.75379866e-01f, 8.33716273e-01f, -1.32922113e-01f, -4.72498864e-01f, -4.62487459e-01f, 5.20994127e-01f,
  2.68088579e-01f, -1.37812093e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    