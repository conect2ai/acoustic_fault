/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.66353786e-01f, 9.16268155e-02f, 1.21702395e-01f, 2.91844726e-01f, -8.33371188e-03f, -1.95526749e-01f, -2.44644985e-01f, 6.44145831e-02f, 1.45026863e-01f, -2.33644113e-01f,
  -9.17338952e-02f, 1.00112401e-01f, -4.08971518e-01f, 2.28396371e-01f, 1.45942211e-01f, -1.26361743e-01f, 1.88888296e-01f, 1.89402350e-03f, 1.03076890e-01f, 8.28512982e-02f,
  1.26091674e-01f, 6.88395426e-02f, 1.00991599e-01f, 9.56516564e-02f, 1.65834308e-01f, 1.24661013e-01f, 1.06164433e-01f, -4.29726392e-02f, 1.88653588e-01f, 3.58405001e-02f,
  2.11619027e-02f, 4.21659052e-02f, 5.17837442e-02f, 4.50265221e-02f, 3.30691662e-04f, -7.56064430e-02f, 2.26828200e-03f, -7.34884068e-02f, -1.72646903e-02f, 7.64009368e-04f,
  -4.90088910e-02f, 6.26862571e-02f, 7.60903135e-02f, -5.38091026e-02f, 4.07732055e-02f, 1.14057258e-01f, 6.74876794e-02f, 2.13336851e-02f, 5.94617687e-02f, -2.95747444e-02f,
  3.70337665e-02f, 7.00849444e-02f, 1.77816804e-02f, 2.25278456e-02f, 1.03873508e-02f, 5.23482002e-02f, 3.06756012e-02f, -1.97050758e-02f, 1.29854605e-01f, 8.09245184e-02f,
  -2.76575871e-02f, -9.20137316e-02f, -6.12347573e-03f, -4.34013195e-02f, -1.18260495e-02f, -3.57431173e-02f, -3.10885776e-02f, -2.69295815e-02f, 4.47931401e-02f, -1.34248417e-02f,
  6.66033663e-03f, 2.84251422e-02f, -2.83046538e-04f, -3.68349254e-02f, -2.12918352e-02f, -4.86738747e-03f, -9.94067490e-02f, -3.61302011e-02f, 7.41716698e-02f, 6.26412360e-03f,
  -1.25187421e-02f, -1.28728077e-02f, 5.32426778e-03f, 1.17697539e-02f, -1.16727799e-02f, 1.48889329e-02f, 4.90063913e-02f, 2.18246896e-02f, -2.78762411e-02f, -3.69514003e-02f,
  4.54495773e-02f, 1.07733093e-01f, -5.47691248e-02f, -1.16360812e-02f, -2.69849692e-02f, 4.68207616e-03f, 6.66190172e-04f, 6.56038150e-02f, 8.26511532e-02f, 1.95005834e-02f,
  -2.79442091e-02f, -1.62350386e-02f, -1.79610420e-02f, -1.33913318e-02f, -4.19175922e-04f, 4.00109999e-02f, -7.20300600e-02f, 4.58985828e-02f, 2.50373594e-02f, 2.96779349e-02f,
  -4.40880023e-02f, -1.38785720e-01f, -3.20753679e-02f, 3.00453007e-02f, -1.23459185e-02f, -4.71886024e-02f, 1.83140226e-02f, 2.00169850e-02f, -9.20304935e-03f, 1.56109256e-03f,
  -3.32466185e-01f, 1.31569922e-01f, -6.55297488e-02f, -1.10438175e-01f, -3.07046622e-01f, -7.11787790e-02f, 1.34166121e-01f, -1.81101710e-01f, 5.35362549e-02f, 1.86609671e-01f,
  6.24445230e-02f, -3.55455354e-02f, 2.86102384e-01f, -7.45253414e-02f, -2.03765824e-01f, 3.66427779e-01f, -5.10503761e-02f, 7.62852877e-02f, -2.51403842e-02f, -1.78583786e-01f,
  -1.67377919e-01f, -1.06263734e-01f, -1.09652579e-01f, -1.30788311e-01f, -1.42519921e-01f, -1.67998999e-01f, -4.01240252e-02f, 2.40117591e-02f, -1.60909235e-01f, -1.44340284e-02f,
  5.98721728e-02f, 1.53964460e-02f, -3.56526449e-02f, 7.80585855e-02f, -8.18764120e-02f, -8.02496374e-02f, 3.25075984e-02f, 7.14478269e-02f, -2.67386492e-02f, 1.67046994e-04f,
  3.74373198e-02f, -7.34311491e-02f, -7.70368576e-02f, 2.85579134e-02f, -2.08949912e-02f, -1.91782154e-02f, -1.77795440e-03f, 5.00664562e-02f, 6.40470162e-03f, -9.01254863e-02f,
  1.21834259e-02f, 5.85573018e-02f, -2.52980310e-02f, 6.81254789e-02f, -4.92540523e-02f, -5.40942103e-02f, -2.60135904e-02f, -9.49362367e-02f, 7.97605515e-02f, -1.61917344e-01f,
  -6.21119589e-02f, -5.42670004e-02f, -8.37696134e-04f, 4.03494723e-02f, 2.89395219e-03f, 4.54400200e-03f, 7.10693449e-02f, -7.04556704e-02f, 2.93478314e-02f, 8.94652773e-03f,
  2.82816542e-03f, -4.38097306e-02f, 4.95016053e-02f, -1.80491563e-02f, -2.45340411e-02f, -2.23839581e-02f, 3.28083597e-02f, 3.75726931e-02f, -5.25135472e-02f, -2.94784084e-02f,
  6.20029494e-02f, 8.29199329e-03f, 7.48447748e-03f, -2.52483203e-03f, 7.32983947e-02f, -3.67078446e-02f, 2.10878369e-03f, 2.58243829e-02f, -1.78313460e-02f, -4.91273850e-02f,
  3.17838751e-02f, -4.92917076e-02f, -5.26592396e-02f, 2.90325675e-02f, 1.21991649e-01f, 2.03136564e-03f, 5.05755804e-02f, -4.96417396e-02f, 2.29144730e-02f, -7.59660639e-03f,
  -2.72979345e-02f, 4.59364541e-02f, 6.22021221e-02f, 5.19055268e-03f, 5.20674549e-02f, -2.10033208e-02f, 8.62187073e-02f, 4.73735891e-02f, -2.71127354e-02f, -5.53922653e-02f,
  -1.43082077e-02f, 2.82718502e-02f, -3.65645848e-02f, -7.43632987e-02f, -1.23430202e-02f, -1.46066339e-03f, -6.80731684e-02f, -5.38719520e-02f, 8.01812485e-03f, 5.67109287e-02f,
  -9.60233808e-02f, 3.46944124e-01f, -1.26600906e-01f, -3.25843602e-01f, 1.14161290e-01f, 1.45507291e-01f, -1.89993247e-01f, 1.30253106e-01f, -2.13441804e-01f, 2.92224377e-01f,
  9.06184018e-02f, 5.63872978e-03f, 2.71626208e-02f, 1.13037169e-01f, -2.33658642e-01f, -1.00380830e-01f, 3.39426398e-02f, -1.20134279e-02f, -8.67479444e-02f, 1.63982123e-01f,
  -1.06255189e-01f, 1.73553675e-01f, -1.00080915e-01f, 2.12126628e-01f, 9.67746451e-02f, -3.68544981e-02f, 6.88384920e-02f, -1.03785498e-02f, 1.70961976e-01f, 1.63462814e-02f,
  -5.76217659e-03f, 9.40689594e-02f, -6.63268939e-02f, -6.65430874e-02f, 6.04356416e-02f, 4.61267158e-02f, -4.35200892e-02f, -2.29826737e-02f, -1.26114205e-01f, 7.46037886e-02f,
  -3.90726253e-02f, 3.95646505e-02f, 4.16584797e-02f, -3.29186320e-02f, -2.55175121e-02f, -2.56784577e-02f, -3.46451364e-02f, 6.24656351e-03f, 5.56363445e-03f, -1.79682896e-02f,
  -3.00994460e-02f, 4.84576337e-02f, -3.97104956e-02f, 6.03198893e-02f, -3.96568738e-02f, -1.57788955e-02f, -2.19039898e-02f, 1.26601858e-02f, 5.72834164e-02f, 5.79769053e-02f,
  1.14777893e-01f, -5.65862991e-02f, -6.21509105e-02f, -2.35383287e-02f, -1.91383734e-02f, 1.44308619e-02f, -1.65199302e-02f, 3.55405696e-02f, -1.17515825e-01f, 5.72649278e-02f,
  3.62092219e-02f, -3.72571982e-02f, 4.41066921e-03f, -3.84081081e-02f, -1.12683140e-02f, -4.15438600e-02f, -5.95206097e-02f, 1.03938662e-01f, -1.30271837e-02f, -5.64799570e-02f,
  -3.48708816e-02f, 1.42248608e-02f, 1.18667688e-02f, -6.68269722e-03f, 1.12798624e-02f, -3.91783528e-02f, 6.73674420e-02f, 2.96674389e-03f, -5.11070108e-03f, -2.44761370e-02f,
  1.84998825e-01f, 3.10347319e-01f, -4.34520841e-02f, 3.07546295e-02f, -8.05308670e-03f, 6.90247640e-02f, -1.79263589e-03f, 2.95754597e-02f, 4.88472031e-03f, 5.97346164e-02f,
  2.38140952e-02f, -5.49199991e-02f, 7.72616044e-02f, -7.75487954e-03f, -4.04710099e-02f, 5.54731861e-02f, 4.61402051e-02f, 1.06045948e-02f, 3.18887420e-02f, 9.00141299e-02f,
  3.52299735e-02f, 4.09179181e-02f, -3.05920443e-03f, 4.81105503e-03f, 3.03750914e-02f, 6.94477856e-02f, 3.21288444e-02f, -2.43032202e-02f, 4.83068451e-02f, -2.72477772e-02f,
  -1.48284376e-01f, 1.15799852e-01f, -2.80881375e-01f, -2.56170273e-01f, 5.57186864e-02f, -9.96065363e-02f, -1.89630538e-01f, 1.10656992e-01f, 6.37080986e-03f, 1.13983274e-01f,
  1.73105806e-01f, -8.24801475e-02f, 2.90080458e-01f, -1.03704520e-02f, 1.42404616e-01f, 1.62229076e-01f, -1.09897658e-01f, -1.33197993e-01f, 3.57334130e-02f, -2.51920763e-02f,
  -3.65694463e-02f, 1.63931996e-01f, 2.80677620e-02f, 1.57033131e-01f, -4.13553379e-02f, -6.63098320e-02f, 1.80446818e-01f, 1.20769724e-01f, -8.75021741e-02f, 6.58990641e-04f,
  2.44784411e-02f, 1.03174783e-01f, 3.93200330e-02f, -5.64608425e-02f, -3.22945900e-02f, -2.62050778e-02f, -3.05680241e-02f, -6.49490999e-03f, -8.07344075e-03f, -3.60062309e-02f,
  -3.32010537e-02f, 3.46382894e-02f, -9.72734094e-02f, -3.18874121e-02f, -4.13789973e-02f, 2.42497809e-02f, -6.32130057e-02f, -2.12179981e-02f, -2.96915905e-03f, 9.51579958e-03f,
  7.15424344e-02f, -9.02549401e-02f, -3.38765606e-02f, -1.12552211e-01f, -8.08891729e-02f, -2.41563004e-02f, -7.97593966e-02f, 4.19565216e-02f, 4.46917154e-02f, 4.72654700e-02f,
  1.19828321e-01f, -7.15076998e-02f, -5.68214469e-02f, -8.78075585e-02f, -6.92650899e-02f, -9.21490267e-02f, -8.78892392e-02f, -8.67045671e-03f, -6.11494109e-02f, 1.02071084e-01f,
  -2.32845973e-02f, -5.07027991e-02f, 1.07053265e-01f, -1.49292266e-02f, -2.12477241e-02f, -1.26197841e-02f, -4.73190732e-02f, 2.92119775e-02f, -5.10972030e-02f, -3.67485685e-03f,
  4.67934348e-02f, -6.52117655e-03f, -4.16167267e-03f, -1.37316016e-02f, 4.14205417e-02f, 8.38628560e-02f, -3.83743942e-02f, -2.73863729e-02f, -2.14999598e-02f, -7.92238563e-02f,
  2.00019583e-01f, 1.67391062e-01f, 6.72111809e-02f, -4.49959338e-02f, -2.66234316e-02f, 1.27216145e-01f, -6.89211860e-02f, -4.62305658e-02f, 7.87071660e-02f, 2.42084879e-02f,
  -5.48363365e-02f, -1.13390774e-01f, 3.76939066e-02f, 2.46170424e-02f, -2.63758488e-02f, 4.15786430e-02f, -4.65940721e-02f, 5.82865626e-03f, 6.91453144e-02f, -6.32936209e-02f,
  -4.35905270e-02f, 6.64955601e-02f, -9.25986916e-02f, -1.68092530e-02f, -1.00191697e-01f, 6.48937598e-02f, 2.23675538e-02f, -5.09812171e-03f, -4.71365545e-03f, -5.19704167e-03f,
  -9.42465290e-02f, -1.45746216e-01f, -1.55331776e-01f, 1.97712898e-01f, 1.42055333e-01f, -2.57850438e-01f, -3.42202365e-01f, 9.95150059e-02f, -2.51902174e-02f, -2.64907926e-02f,
  2.09634826e-01f, -3.85971725e-01f, -1.07587822e-01f, 1.29432157e-01f, -1.38768539e-01f, 7.52630979e-02f, 1.87250916e-02f, -6.77620769e-02f, -9.89817604e-02f, -2.63165757e-02f,
  1.54181376e-01f, 2.83859015e-01f, 1.74697816e-01f, 1.72131419e-01f, 1.11839920e-01f, 7.74790486e-03f, 2.34905854e-01f, -1.07555866e-01f, 6.67796060e-02f, -9.06894356e-02f,
  8.61498178e-04f, 9.89706367e-02f, -2.34017777e-03f, -7.78096542e-02f, 6.04118630e-02f, 2.34065447e-02f, -2.71960557e-03f, -1.36691019e-01f, -8.15005600e-02f, -9.83852446e-02f,
  -5.87042086e-02f, 3.88013273e-02f, -2.52784882e-02f, -2.55895145e-02f, 1.30067542e-02f, 6.17008023e-02f, 4.07518670e-02f, 4.81110886e-02f, 1.96366329e-02f, 7.05569386e-02f,
  -2.87566930e-02f, 4.68354579e-03f, 6.73048273e-02f, 2.79333219e-02f, -7.93176144e-03f, 5.32295406e-02f, -5.64420633e-02f, -2.79839151e-02f, 3.06023452e-02f, -3.19978036e-03f,
  6.97732642e-02f, -4.56112213e-02f, 1.90630518e-02f, -3.33037525e-02f, -7.76270777e-02f, 1.09966531e-01f, -5.89488596e-02f, -1.90919347e-03f, -4.06954810e-02f, 1.99915301e-02f,
  6.53976668e-03f, -3.42706963e-02f, 6.13687262e-02f, -1.77407023e-02f, 3.15967086e-03f, -3.61773558e-02f, -5.19516617e-02f, 3.79678868e-02f, -5.35543030e-03f, -1.21539142e-02f,
  -8.02378207e-02f, 3.28667499e-02f, -2.36882158e-02f, 3.41106392e-02f, -9.79875103e-02f, -5.93438223e-02f, 5.17278425e-02f, 6.16785735e-02f, 4.12240364e-02f, 3.62381432e-03f,
  -6.31916374e-02f, -5.43321203e-03f, -6.47471771e-02f, -4.26355610e-03f, -6.42738491e-02f, 6.34710193e-02f, 1.85004883e-02f, -1.39334367e-03f, -7.72113353e-02f, -1.06388040e-01f,
  7.95026645e-02f, 2.21573506e-02f, -2.09880457e-03f, 4.20095287e-02f, -4.33342606e-02f, 6.73294663e-02f, -4.69276346e-02f, -1.73010025e-02f, 5.88139594e-02f, -4.51257378e-02f,
  1.35824615e-02f, 1.38742896e-02f, -2.81584822e-02f, 5.21884933e-02f, 3.06967683e-02f, -9.19977494e-04f, -1.61599703e-02f, -1.77699924e-02f, 2.09524743e-02f, 4.97764610e-02f,
  2.27196991e-01f, -1.12222463e-01f, -1.48578376e-01f, 1.47267282e-01f, 2.62386650e-01f, 5.76817952e-02f, 5.52089624e-02f, -2.71592792e-02f, 1.56798065e-01f, -1.93009913e-01f,
  1.59974154e-02f, -2.23948583e-01f, -2.10305408e-01f, 2.29764683e-03f, 2.10774783e-02f, -2.21007451e-01f, 7.99182057e-02f, -4.43910062e-02f, 1.18691117e-01f, 5.96526228e-02f,
  2.25272570e-02f, 1.60482123e-01f, -1.87142432e-01f, 1.27974853e-01f, 2.22079933e-01f, 1.33352563e-01f, 2.18742296e-01f, 9.71827954e-02f, 8.17278475e-02f, 1.04500823e-01f,
  1.01339430e-01f, -3.78926285e-02f, -2.13257931e-02f, -6.85342550e-02f, 5.78273907e-02f, -5.34824096e-02f, 3.33592258e-02f, -8.29122737e-02f, 5.04468046e-02f, -6.40265793e-02f,
  -7.48939887e-02f, -2.42852420e-02f, 2.07193922e-02f, -1.63024403e-02f, 1.18197367e-01f, -4.91604302e-03f, -3.63565013e-02f, 7.09969201e-04f, -4.65223230e-02f, -4.81353290e-02f,
  -8.56573805e-02f, -9.31966752e-02f, 4.79124412e-02f, 2.22579055e-02f, 1.61121525e-02f, 8.36391374e-02f, -3.09810396e-02f, 8.18209630e-03f, 4.49033119e-02f, 1.40917525e-01f,
  -2.68974658e-02f, 9.57914349e-03f, -1.66202839e-02f, 1.68444812e-02f, 4.69727218e-02f, 3.59991565e-03f, 3.38936858e-02f, -4.51313518e-02f, 2.51179114e-02f, 6.20380677e-02f,
  9.02819708e-02f, -3.41823883e-02f, -7.89593998e-03f, 1.88486092e-02f, 2.20525973e-02f, 8.94442853e-03f, -1.35375350e-03f, 3.33734751e-02f, 6.52335882e-02f, -4.10401039e-02f,
  3.08478437e-03f, 1.14867399e-02f, -3.51693928e-02f, -5.23570366e-02f, 2.69114841e-02f, 2.35002916e-02f, -4.61811610e-02f, -2.64214836e-02f, -2.54754070e-03f, 3.97179909e-02f,
  2.45299459e-01f, 1.48542792e-01f, 3.05518620e-02f, 4.45650965e-02f, 5.67438640e-03f, -1.99848078e-02f, -7.65527859e-02f, 1.63781643e-02f, 1.71018228e-01f, -1.66908279e-02f,
  -3.65589117e-03f, -1.77781054e-04f, 7.01450482e-02f, 5.09488359e-02f, -5.02384081e-02f, -7.77360424e-03f, 1.00356191e-02f, 1.84311941e-02f, 1.03708319e-01f, 5.03895171e-02f,
  -5.18446416e-02f, -3.22415233e-02f, -8.42219070e-02f, 5.82740903e-02f, -5.84390312e-02f, 7.41804317e-02f, 5.74896112e-02f, -4.70021032e-02f, 1.50469122e-02f, -9.42143649e-02f,
  -7.72631690e-02f, -8.13729987e-02f, 1.31206363e-01f, -4.00156155e-02f, 8.26576725e-02f, -6.98947906e-02f, -3.71023357e-01f, 8.32796767e-02f, 7.40550458e-02f, -2.11286917e-01f,
  -1.62405357e-01f, 3.49426158e-02f, -2.06204027e-01f, -1.46447942e-01f, -4.35746722e-02f, -1.22288726e-01f, -1.36113793e-01f, -1.24310657e-01f, 8.02427083e-02f, -8.02358016e-02f,
  1.11853540e-01f, -1.74159467e-01f, -3.32069322e-02f, 9.75207612e-02f, -8.00692141e-02f, 1.51616231e-01f, -1.08210884e-01f, 3.30481604e-02f, 3.89496796e-02f, -1.70686503e-03f,
  -1.65507309e-02f, -6.31838515e-02f, 4.38384674e-02f, 7.93192089e-02f, -8.40246007e-02f, -3.88272069e-02f, 4.79226857e-02f, -6.71624988e-02f, -5.43036032e-04f, -2.28841007e-02f,
  1.15519343e-02f, 1.54545426e-01f, 2.00557485e-02f, 2.88383267e-03f, 6.22534938e-02f, 9.81390923e-02f, 5.93504421e-02f, -1.60282701e-02f, 6.08764105e-02f, -5.62024023e-03f,
  -1.79822370e-02f, 5.18795401e-02f, 1.07812090e-02f, -4.71972674e-03f, 6.37091175e-02f, 1.71826202e-02f, 2.13787658e-03f, -6.86438195e-03f, 9.25535243e-03f, 2.62866840e-02f,
  -7.12024197e-02f, -1.90536082e-02f, -4.55933623e-02f, 4.59326543e-02f, -1.37007743e-01f, 3.68684009e-02f, -1.85522251e-02f, 1.00919921e-02f, 1.09633459e-02f, 6.43040286e-03f,
  2.50613950e-02f, 1.96000692e-02f, 3.64591517e-02f, 5.64660132e-03f, -3.94096561e-02f, 3.70908226e-03f, 4.10344303e-02f, 8.73479433e-03f, 2.25278549e-02f, 4.86552492e-02f,
  -2.23568734e-02f, 1.04771620e-02f, -4.17498611e-02f, 4.31224257e-02f, -6.66856347e-03f, -8.88963696e-04f, 6.50589243e-02f, 4.15933579e-02f, -2.21697818e-02f, -1.36464480e-02f,
  -1.54323041e-01f, -2.89372236e-01f, -2.15867870e-02f, 8.03810582e-02f, 2.24354910e-03f, -2.14734804e-02f, 2.54348516e-02f, 7.89251551e-02f, -4.51125279e-02f, -7.26733059e-02f,
  7.87962824e-02f, -8.04919470e-03f, 2.22862344e-02f, 4.72722091e-02f, 1.25320693e-02f, -3.17076035e-02f, -7.58320466e-02f, 1.67597719e-02f, -2.77393572e-02f, 1.98185481e-02f,
  -2.01934408e-02f, -2.55617760e-02f, 7.26349726e-02f, -5.34741906e-03f, 2.44555082e-02f, -2.40432657e-02f, -5.44809503e-03f, 5.72624914e-02f, 3.85640282e-03f, 2.12036688e-02f,
  -4.61217523e-01f, 5.63285537e-02f, -1.74272612e-01f, -3.79367501e-01f, -1.40258864e-01f, 8.46924260e-02f, -8.70795995e-02f, -8.11460614e-02f, -2.67104894e-01f, 3.32363397e-01f,
  7.87810460e-02f, -2.66436636e-01f, 1.98275790e-01f, -5.41456230e-02f, -3.46369386e-01f, 1.62484050e-01f, -6.44761473e-02f, -5.86025454e-02f, -6.58934563e-02f, -1.51367873e-01f,
  -1.68511569e-01f, 2.35997643e-02f, -1.46092787e-01f, 1.02231823e-01f, -1.13416649e-01f, -1.28553689e-01f, 9.89479572e-02f, -6.08152593e-04f, 4.62857448e-02f, 2.87579722e-03f,
  -5.82005270e-02f, -1.66277424e-01f, 2.57934760e-02f, -3.92138883e-02f, -3.18371058e-02f, 4.39635590e-02f, 1.11060450e-02f, -2.89418735e-03f, -4.05281000e-02f, -3.78045514e-02f,
  -5.51088364e-04f, -1.44308489e-02f, -2.60365177e-02f, 1.29984124e-02f, -5.59896901e-02f, -7.02266768e-02f, -3.32577564e-02f, 5.03876582e-02f, -6.12696856e-02f, -9.79207829e-03f,
  -4.28411700e-02f, -5.00991009e-02f, -6.00337051e-03f, 3.08446903e-02f, -4.79957275e-02f, -4.01036702e-02f, 4.19623926e-02f, 1.10504925e-05f, -3.97132635e-02f, -8.94307122e-02f,
  1.63349416e-03f, 2.35348511e-02f, 4.82809581e-02f, -3.93987522e-02f, -4.08082455e-03f, -8.42776988e-03f, 2.02688500e-02f, 5.23254788e-03f, -1.46866692e-02f, -3.56014222e-02f,
  -3.15323807e-02f, -1.05439313e-02f, -4.40306626e-02f, 4.12857160e-03f, -2.57172529e-02f, -3.19849364e-02f, -3.69940093e-03f, 8.41777399e-02f, -6.75953552e-02f, 1.29524739e-02f,
  -9.58004594e-03f, -6.02951683e-02f, 1.87108405e-02f, 3.94392051e-02f, -4.94488806e-04f, -5.42217121e-02f, 1.12835979e-02f, 3.12492065e-03f, -2.86793523e-02f, -2.61032879e-02f,
  -2.41329521e-02f, -3.54918204e-02f, 1.45030295e-04f, -8.36636499e-02f, 4.75317650e-02f, 1.50852092e-02f, 2.08107848e-02f, -9.80471540e-03f, -3.00923754e-02f, 3.58405896e-02f,
  2.54776655e-03f, -3.78632848e-03f, 1.83483530e-02f, 6.12645783e-02f, -2.44758558e-02f, 6.98872507e-02f, -3.01853265e-03f, -1.22885257e-02f, -5.63726872e-02f, -1.16566224e-02f,
  2.54666489e-02f, -7.17695057e-03f, -7.96811432e-02f, -1.16850308e-03f, 3.13511938e-02f, -4.68486100e-02f, -3.15683596e-02f, 7.07411848e-04f, -6.71785185e-03f, 5.43918088e-02f,
  1.90462336e-01f, -9.67171192e-02f, 1.50273768e-02f, -2.91327760e-02f, -1.47316858e-01f, 8.15241188e-02f, 9.67515036e-02f, -6.74551725e-02f, -1.93591014e-01f, 1.22472700e-02f,
  1.64158553e-01f, 2.14822497e-02f, 1.60603106e-01f, -1.02352751e-02f, 3.48174423e-01f, 1.44495621e-01f, 8.11753646e-02f, 5.89821413e-02f, -2.05455095e-01f, 1.73620190e-02f,
  4.29428881e-03f, 8.36302862e-02f, 2.28342310e-01f, -9.78185162e-02f, 8.38808790e-02f, -1.48962021e-01f, 2.56131947e-01f, -1.74005508e-01f, 5.45921586e-02f, -2.34786943e-02f,
  1.08828634e-01f, -7.27537647e-02f, 4.55892161e-02f, 8.70875195e-02f, 5.73562980e-02f, -1.99254751e-02f, 9.92122144e-02f, -1.60174835e-02f, -6.12486601e-02f, -3.50162461e-02f,
  2.00298559e-02f, 1.12706218e-02f, -2.43482478e-02f, -6.32369220e-02f, -5.43534420e-02f, -3.05888546e-03f, -2.15263814e-02f, -2.09690668e-02f, 7.62332976e-03f, -3.67613696e-02f,
  5.50800674e-02f, 3.35491784e-02f, 4.10171971e-02f, 4.04603407e-02f, 8.92572552e-02f, -7.65610933e-02f, 1.11401817e-02f, 3.12188994e-02f, 8.77790749e-02f, -6.89479709e-02f,
  1.86172116e-03f, -1.41325980e-01f, -4.00488228e-02f, -3.93944094e-03f, 1.64427049e-02f, 1.87917817e-02f, 6.93523586e-02f, 8.26746672e-02f, 1.47175975e-02f, 1.44051388e-01f,
  -8.83089006e-03f, -3.26268561e-02f, -1.02504969e-01f, -6.18862174e-02f, -4.39107306e-02f, -1.45241534e-02f, 5.35043441e-02f, -2.67542861e-02f, -1.69257424e-03f, -1.96784642e-02f,
  -5.47326542e-02f, 6.47654291e-04f, 9.62765217e-02f, 4.05162126e-02f, 2.42379662e-02f, 2.22041435e-03f, -6.68632761e-02f, -3.19865867e-02f, -1.24593480e-02f, 8.90063494e-02f,
  1.78819165e-01f, 1.94760021e-02f, 2.21508425e-02f, 7.55344927e-02f, 4.35037166e-02f, 5.45671880e-02f, -7.63500556e-02f, -7.37591414e-03f, 6.84295595e-02f, 3.18502150e-02f,
  -3.32653224e-02f, -1.16222920e-02f, 1.37437150e-01f, -3.41481864e-02f, 2.71689594e-02f, 1.00705840e-01f, 1.75821166e-02f, 1.32254185e-02f, 4.05562632e-02f, -3.51930335e-02f,
  1.18324637e-01f, 5.02508320e-02f, -2.29344424e-02f, 4.04379256e-02f, 6.06953911e-02f, 6.72645122e-02f, 3.00689768e-02f, -5.21673225e-02f, 2.05652621e-02f, -1.04607278e-02f,
  1.34715989e-01f, -1.01884484e-01f, -1.18638529e-02f, -2.58519948e-02f, 2.11280629e-01f, 1.31129935e-01f, 1.41869292e-01f, 1.63982704e-01f, 3.27499717e-01f, -1.79940119e-01f,
  5.16400151e-02f, -1.72595546e-01f, -2.04560366e-02f, -1.46458536e-01f, -2.00304538e-01f, -1.15255423e-01f, -1.60734698e-01f, -4.66375537e-02f, 9.83294174e-02f, -2.19448544e-02f,
  -1.91639755e-02f, -1.50848031e-01f, -2.62482613e-01f, -4.22679782e-02f, -4.61614355e-02f, 9.91417095e-02f, -1.83756694e-01f, 1.15103364e-01f, -1.78049386e-01f, 3.26121831e-03f,
  -6.47616088e-02f, 9.76514444e-02f, 2.94451769e-02f, -1.96921751e-02f, 1.38604781e-02f, 7.78946802e-02f, -9.62941162e-03f, 2.16284040e-02f, 8.15249756e-02f, 2.40314892e-03f,
  -7.43857175e-02f, -6.54693600e-03f, -5.92922047e-02f, -1.86968725e-02f, 9.51638371e-02f, -7.57021504e-03f, 3.27776037e-02f, 5.42378537e-02f, -2.13285186e-03f, 1.11169145e-02f,
  -2.56776735e-02f, 4.20820639e-02f, 3.95315252e-02f, -4.52454276e-02f, 5.10046594e-02f, 3.72866690e-02f, 3.96412238e-03f, -2.98164692e-02f, -2.48995479e-02f, -1.85569434e-03f,
  -1.03269946e-02f, 8.10216442e-02f, -2.47317012e-02f, -1.38263488e-02f, 3.07262950e-02f, 5.44202840e-03f, -3.76832150e-02f, -3.41270529e-02f, 7.04565942e-02f, -2.12163683e-02f,
  1.56730954e-02f, 4.81106192e-02f, 7.12278783e-02f, 8.98916796e-02f, -1.70603991e-02f, 2.96496763e-03f, -3.20449248e-02f, -3.75945331e-03f, -6.40172232e-03f, 2.60034599e-03f,
  4.04519513e-02f, 2.08186116e-02f, -2.75196098e-02f, -3.18150036e-02f, -5.19852005e-02f, 4.17856276e-02f, 1.38188954e-02f, 2.05742568e-02f, 3.86239029e-02f, -2.52797920e-02f,
  5.78702334e-03f, 8.12958926e-04f, 4.95204702e-02f, -8.51187017e-03f, -1.82429273e-02f, -3.98460440e-02f, -2.52084304e-02f, 1.66208446e-02f, 2.04399228e-02f, 2.96083856e-02f,
  -4.22921106e-02f, 4.77493135e-03f, -1.50557896e-02f, 1.84137560e-02f, -7.52947256e-02f, -2.11518891e-02f, -6.09576404e-02f, 4.29287963e-02f, -4.29779328e-02f, 6.94960309e-03f,
  -1.68581754e-02f, 2.18007043e-02f, -1.00096250e-02f, 4.98454161e-02f, -5.27683320e-03f, 1.69506564e-03f, -1.88857189e-03f, 9.91679262e-03f, -2.15965267e-02f, -1.62165556e-02f,
  3.74617010e-01f, -2.83687502e-01f, -6.29835352e-02f, 3.34134281e-01f, 1.64078221e-01f, 4.00857218e-02f, 8.10966045e-02f, -9.76948366e-02f, 3.12964320e-02f, -2.53178746e-01f,
  3.34853768e-01f, -2.19869494e-01f, -3.26668099e-02f, 2.39428177e-01f, 2.90721267e-01f, 3.21081616e-02f, 1.67495191e-01f, 7.05361692e-03f, -1.50866985e-01f, 3.68614793e-02f,
  8.67372826e-02f, 3.25669557e-01f, 1.49001136e-01f, -1.30189702e-01f, 7.24086985e-02f, -1.96209937e-01f, 2.37667952e-02f, -1.30442739e-01f, 1.68511849e-02f, 2.90359855e-02f,
  3.69417891e-02f, 2.87911594e-02f, -1.68355722e-02f, -9.73447338e-02f, 3.40188444e-02f, -1.47648165e-02f, -2.07934659e-02f, -2.62574083e-03f, 5.97553030e-02f, -7.44203776e-02f,
  -3.04950215e-02f, 3.97716165e-02f, -2.90738456e-02f, -6.32278062e-03f, 3.34075317e-02f, -5.20239919e-02f, -1.00507997e-02f, -1.05537055e-02f, 2.14072387e-03f, 3.25703584e-02f,
  5.94975464e-02f, -5.92926471e-03f, 5.59179150e-02f, -5.06710969e-02f, 2.51631029e-02f, 1.06801977e-03f, -1.05830915e-02f, -3.70627455e-02f, -4.60753813e-02f, 2.77454080e-03f,
  -5.47546986e-03f, -1.24054467e-02f, -3.28406203e-03f, -2.41881609e-02f, 3.73585299e-02f, 1.30846817e-02f, 2.05227863e-02f, -2.52062529e-02f, -3.95262949e-02f, 1.33438120e-02f,
  6.87053241e-03f, 4.12966795e-02f, 3.28629725e-02f, 5.50698210e-03f, 1.55560775e-02f, -3.55473310e-02f, -1.80732626e-02f, -1.21075669e-02f, 3.22099403e-02f, -1.43472934e-02f,
  7.62864901e-03f, 6.90004304e-02f, -3.63019109e-02f, -1.32186862e-03f, -2.64144763e-02f, 8.38523358e-03f, -2.20606849e-02f, -2.68663447e-02f, -6.42758533e-02f, 6.89878762e-02f,
  -1.75174102e-02f, -9.72059593e-02f, -5.27813472e-02f, -4.23123538e-02f, -5.36947697e-02f, 2.56234631e-02f, 7.89187290e-03f, -6.20661713e-02f, -6.38501272e-02f, 2.32415879e-03f,
  -2.30488405e-02f, -5.40010352e-03f, 1.23370802e-02f, 6.01501651e-02f, -3.94367799e-02f, 1.47023099e-02f, 1.80180762e-02f, 1.82224382e-02f, 8.37961677e-03f, -4.18597497e-02f,
  8.45825579e-03f, 3.37974192e-03f, -4.67323232e-03f, -2.52158530e-02f, 5.36851771e-03f, 1.10523757e-02f, -4.05534200e-04f, -4.12897998e-03f, 5.58176897e-02f, 1.05919112e-02f,
  3.64181459e-01f, -1.15309112e-01f, -2.90463883e-02f, -7.07451254e-02f, 1.24362871e-01f, -1.53735012e-01f, -1.33698627e-01f, -3.58838066e-02f, -2.13137239e-01f, -1.47899270e-01f,
  -1.47893161e-01f, 1.65353999e-01f, -2.34501496e-01f, -1.60326838e-01f, 9.84403193e-02f, -2.89785862e-01f, 3.57846431e-02f, -8.55515078e-02f, 2.14298144e-02f, 1.05609767e-01f,
  4.04150635e-02f, 1.24483682e-01f, 5.85201159e-02f, 1.49793461e-01f, 1.30937368e-01f, 2.09406614e-01f, 1.95138246e-01f, 3.37507352e-02f, 1.07586361e-01f, 8.81895870e-02f,
  9.91357788e-02f, -8.58273953e-02f, 1.61768213e-01f, 5.38943596e-02f, 1.46251842e-01f, -3.92466597e-03f, -1.64989680e-02f, -2.63211057e-02f, 4.29403521e-02f, 1.29776383e-02f,
  -1.99947935e-02f, -1.13568432e-03f, 5.66037521e-02f, -1.89205725e-02f, 2.60542501e-02f, 2.65680458e-02f, -5.58594940e-03f, -1.15602165e-02f, -9.07197595e-03f, -7.83016980e-02f,
  -3.83612923e-02f, -1.03730112e-02f, 8.71693483e-04f, -2.39439923e-02f, 4.66549583e-02f, 1.64789949e-02f, -1.60702914e-02f, 4.05456349e-02f, 4.83466014e-02f, 5.06342463e-02f,
  -1.22843301e-02f, -1.62931290e-02f, -2.02593748e-02f, -4.01541367e-02f, 1.06969122e-02f, -2.43131053e-02f, -7.63740996e-03f, -1.54181067e-02f, 2.07041614e-02f, -3.68650891e-02f,
  5.23101576e-02f, -1.39223058e-02f, -8.22728500e-03f, 1.90022849e-02f, 3.00049204e-02f, -1.99955469e-03f, 2.67945565e-02f, 3.22188549e-02f, 1.42582050e-02f, -3.84501442e-02f,
  -7.38844648e-02f, -3.25994641e-02f, 2.35301889e-02f, -1.07790558e-02f, 2.38205679e-02f, 4.22664434e-02f, -5.16158417e-02f, -7.57144764e-02f, -2.02999264e-02f, 4.55613472e-02f,
  4.31580693e-02f, 4.54405285e-02f, 5.73266335e-02f, 3.07492688e-02f, -1.25214905e-02f, -4.54952195e-03f, -4.40092869e-02f, 3.61908898e-02f, 2.94479523e-02f, -5.68461679e-02f,
  8.88608322e-02f, 2.54745595e-03f, 1.16170086e-01f, -8.48396774e-03f, -2.36038864e-02f, 3.20463516e-02f, 5.27262092e-02f, 5.06867014e-04f, 7.73767903e-02f, 4.29589637e-02f,
  4.62306663e-02f, 1.00784097e-02f, -3.63960564e-02f, 4.66652922e-02f, 1.87106356e-02f, 2.43992191e-02f, 5.88171370e-02f, 2.95437966e-02f, -2.94550005e-02f, -4.41316478e-02f,
  -5.53785086e-01f, 7.13485181e-02f, -8.66695493e-02f, -3.46678287e-01f, 7.21626217e-03f, -1.92997843e-01f, -2.87781358e-01f, 3.23759355e-02f, -1.30989388e-01f, 1.49570152e-01f,
  5.38197495e-02f, -5.84743135e-02f, 2.56545931e-01f, -2.01839954e-01f, -2.74507910e-01f, 2.15462878e-01f, -3.52036327e-01f, -1.20648101e-01f, 7.25968182e-02f, -1.38663635e-01f,
  -6.26768172e-02f, -1.34781435e-01f, -5.23910448e-02f, 1.56915829e-01f, -1.86606213e-01f, 2.76570395e-02f, 3.05828620e-02f, 1.76012397e-01f, -1.82475597e-01f, -6.51938561e-03f,
  4.76884171e-02f, 7.49397427e-02f, 8.74963216e-03f, 3.90457660e-02f, -8.22988302e-02f, -2.87683271e-02f, -4.14731875e-02f, -1.42211430e-02f, -1.57643370e-02f, -4.18117037e-03f,
  -1.10285506e-02f, 2.57227197e-02f, -3.69874164e-02f, 4.67023402e-02f, -6.08240776e-02f, -5.24361385e-03f, 2.96911467e-02f, -2.82996129e-02f, 3.70982774e-02f, -3.16808708e-02f,
  -2.41606132e-04f, -1.79248489e-02f, -8.85736272e-02f, -1.54785840e-02f, -6.01846650e-02f, -2.38974262e-02f, -4.42177877e-02f, -1.56618655e-04f, -5.42439818e-02f, -4.28432748e-02f,
  -7.21756881e-03f, -2.21440266e-03f, 1.91315543e-02f, 2.54954249e-02f, 9.01173335e-03f, 1.66910589e-02f, 2.51155929e-03f, 3.55659202e-02f, -2.84209773e-02f, -4.03056713e-03f,
  -2.11482085e-02f, -1.72811318e-02f, 8.00321158e-03f, -3.74844223e-02f, -4.39694971e-02f, -4.05982807e-02f, -1.97645426e-02f, 1.56690255e-02f, -7.69986436e-02f, -1.03093218e-02f,
  4.70496267e-02f, -6.88138651e-03f, 4.25649099e-02f, 1.74989440e-02f, 2.83665620e-02f, -3.24029312e-03f, 6.22557476e-03f, -3.46977264e-02f, -9.38112615e-04f, -6.32158443e-02f,
  -2.99444310e-02f, -2.89000124e-02f, 6.55082241e-03f, -7.30306888e-03f, 4.91656065e-02f, -1.19514978e-02f, -2.29604430e-02f, -2.80914847e-02f, 1.87788531e-02f, -4.72903810e-03f,
  -4.35452871e-02f, -3.08211185e-02f, 5.22390753e-03f, 1.26645882e-02f, -3.21677662e-02f, -5.73090324e-03f, -4.02586311e-02f, -4.60343855e-03f, -5.33803478e-02f, 2.20105425e-02f,
  6.26662560e-03f, 7.75506208e-03f, 5.57103381e-03f, 1.63080227e-02f, -2.89144702e-02f, -1.29117835e-02f, -4.92748246e-02f, -2.90308427e-02f, 2.13413369e-02f, 1.81323271e-02f,
  2.03059930e-02f, -2.62354165e-01f, -1.99549884e-01f, 1.91638187e-01f, 1.39037833e-01f, 2.77405709e-01f, 2.75395125e-01f, -5.74576156e-03f, 9.51157659e-02f, 6.89499527e-02f,
  2.09343791e-01f, 1.69335470e-01f, -1.24309786e-01f, 2.59938449e-01f, 3.08925152e-01f, 3.15291435e-02f, 1.95401281e-01f, 1.46813363e-01f, -7.69637600e-02f, -3.75580601e-02f,
  5.54416627e-02f, 2.38766298e-01f, 1.73576754e-02f, -9.26088691e-02f, 4.82810289e-02f, -1.59681723e-01f, -2.28557196e-02f, -9.43502486e-02f, 7.90191367e-02f, 2.01887429e-01f,
  -1.04110524e-01f, -1.17535815e-01f, 6.98337331e-02f, -1.04895635e-02f, -2.15799650e-04f, 1.59845743e-02f, -6.38950989e-02f, 2.73377337e-02f, -1.96813308e-02f, 3.26141752e-02f,
  3.18344012e-02f, 1.30580477e-02f, 8.23441520e-02f, 2.45122705e-02f, -4.90610525e-02f, -3.07316668e-02f, -5.13074957e-02f, 3.57601903e-02f, -7.16210008e-02f, 2.72098556e-02f,
  1.24152303e-02f, 1.11662606e-02f, 6.71614846e-03f, 8.28517824e-02f, 6.34493353e-03f, 7.15061575e-02f, -6.55901339e-03f, 6.76267073e-02f, -1.35634989e-02f, 1.33367153e-02f,
  2.61056423e-02f, -2.48799007e-02f, 2.31994968e-02f, -1.20554501e-02f, -1.54958926e-02f, 4.73056687e-03f, -1.61475316e-02f, 3.98370251e-03f, -3.57833765e-02f, -2.87888129e-03f,
  2.58732829e-02f, -2.56048553e-02f, 3.58113870e-02f, 1.90899223e-02f, 2.09516715e-02f, -2.58724354e-02f, -3.99066247e-02f, -4.06735912e-02f, 9.07465257e-03f, 4.07129228e-02f,
  1.86405680e-03f, -1.00961123e-02f, 4.14066054e-02f, -4.53749970e-02f, 4.74453643e-02f, 7.42636248e-02f, -5.11251502e-02f, -1.61170661e-02f, -2.78934352e-02f, 7.90213794e-03f,
  -1.83091357e-01f, -1.76539227e-01f, 2.65990105e-02f, -1.92384403e-02f, -4.17717583e-02f, 8.57706815e-02f, -2.43523195e-02f, 1.48413405e-02f, -9.66873672e-03f, -6.39134878e-03f,
  2.41915639e-02f, -6.21795421e-03f, -2.17756014e-02f, 2.31924374e-02f, 8.61465372e-03f, 2.98555139e-02f, -9.28424951e-03f, 3.13731916e-02f, 7.14298263e-02f, -4.99189980e-02f,
  -6.70579374e-02f, -8.59232396e-02f, 5.75517043e-02f, 6.43154653e-03f, 5.66043220e-02f, 1.09305074e-02f, -8.94892402e-03f, -3.98480939e-03f, -3.67240161e-02f, 1.60166691e-03f,
  3.56676579e-01f, -3.53446990e-01f, 2.11875483e-01f, 1.85281098e-01f, 2.33423397e-01f, -1.51066586e-01f, -5.29672466e-02f, -3.92759591e-02f, 2.42095422e-02f, -3.62489313e-01f,
  6.37131780e-02f, -2.84921825e-01f, -5.95999770e-02f, 3.29147503e-02f, 2.79808968e-01f, 6.64150119e-02f, 1.24385536e-01f, -7.91852027e-02f, 6.72595948e-02f, 2.15177625e-01f,
  2.61433542e-01f, 2.02300563e-01f, 2.88996607e-01f, 8.66568685e-02f, 1.14859484e-01f, -6.52786195e-02f, -3.77581343e-02f, -5.65304123e-02f, -9.94090661e-02f, -1.58773914e-01f,
  3.40763517e-02f, 2.69877017e-01f, 8.01195055e-02f, -3.05022094e-02f, 1.31360710e-01f, -1.37723694e-02f, -8.38143975e-02f, -2.21638158e-02f, 7.73928612e-02f, 4.06557880e-03f,
  -1.16284251e-01f, -8.37603863e-03f, -5.91934659e-02f, 1.35574946e-02f, 2.96576768e-02f, -7.53991455e-02f, -3.88606116e-02f, -1.78977884e-02f, 1.55474450e-02f, 5.73240826e-03f,
  -1.93455815e-02f, -1.89747456e-02f, 6.86275735e-02f, -3.09519898e-02f, 5.58028147e-02f, -7.28640780e-02f, 7.86159933e-03f, -9.27013382e-02f, -3.18366960e-02f, 3.04404716e-03f,
  -3.03549934e-02f, 3.19194468e-03f, -5.96583239e-04f, -9.91907064e-03f, 1.90228242e-02f, 1.08724851e-02f, -1.26198269e-02f, -6.66868910e-02f, 1.72051471e-02f, 8.63258727e-03f,
  -7.34966435e-03f, 1.02979662e-02f, 3.36438417e-02f, 4.85439114e-02f, -2.64003295e-02f, 4.86467313e-03f, 7.86084980e-02f, 3.67012573e-04f, 6.60532154e-03f, 1.83841139e-02f,
  -3.69340703e-02f, 5.21325693e-02f, -8.19579512e-02f, -1.24627980e-03f, -1.76211470e-03f, -2.61568353e-02f, 1.19098939e-03f, -4.53152917e-02f, 1.93192717e-02f, 9.09387483e-04f,
  -1.31311491e-01f, -1.25765344e-02f, -2.96904631e-02f, -6.55874535e-02f, -5.86396419e-02f, 2.11274847e-02f, 1.47090256e-02f, -3.48814065e-03f, -7.28170201e-02f, 6.20339960e-02f,
  -2.57081017e-02f, -4.22602929e-02f, 6.65771663e-02f, 1.27595784e-02f, -2.82584410e-02f, -2.04400644e-02f, 7.55481701e-03f, -4.98798899e-02f, 7.69880190e-02f, -7.37913400e-02f,
  1.17709776e-02f, 6.42768219e-02f, -6.69979826e-02f, 1.32459542e-03f, -5.53669222e-03f, -8.78872052e-02f, -1.48998173e-02f, -3.22611742e-02f, 5.55833150e-03f, -3.63788977e-02f,
  -1.28149450e-01f, 4.44030426e-02f, 3.42537969e-01f, 1.90036872e-03f, -2.12225482e-01f, -2.70026363e-02f, 9.95898172e-02f, -1.00437552e-01f, 2.30648592e-01f, -9.60097164e-02f,
  -1.18572190e-01f, 2.57810522e-02f, 1.66326597e-01f, -2.28002653e-01f, -5.86684272e-02f, 2.02939615e-01f, -6.62504137e-02f, -1.13335721e-01f, 6.48359880e-02f, -5.13206720e-02f,
  8.53648111e-02f, -2.70635217e-01f, 6.63432702e-02f, -1.52796537e-01f, -1.89377561e-01f, 6.05758987e-02f, -2.34082654e-01f, 1.32013857e-01f, -2.31320173e-01f, -1.40345395e-01f,
  -8.51305127e-02f, 6.05441630e-02f, 2.96558347e-02f, 2.12220699e-02f, -6.53398186e-02f, -4.25146520e-02f, 4.03445549e-02f, 2.93398164e-02f, 8.93495977e-03f, -2.04165448e-02f,
  -1.81809757e-02f, -6.14262857e-02f, -6.18261658e-02f, 4.31207605e-02f, 3.07651144e-02f, 2.74387896e-02f, -4.26889546e-02f, 1.26340175e-02f, 1.75654124e-02f, 1.96974520e-02f,
  1.03699952e-01f, 3.38502638e-02f, 6.42205775e-02f, -1.38739161e-02f, 8.60291645e-02f, 6.93020448e-02f, 4.59184907e-02f, 1.70005336e-02f, -4.77798432e-02f, -2.12837216e-02f,
  3.84487696e-02f, 4.96622398e-02f, -9.76900477e-03f, -3.68448868e-02f, 9.16624907e-03f, -3.40546481e-02f, 4.26977426e-02f, -5.69938309e-02f, -2.24773083e-02f, -2.08530538e-02f,
  -4.19336408e-02f, -1.99570116e-02f, -2.66871620e-02f, 3.80386598e-02f, -1.09514501e-02f, 2.51110923e-02f, 1.64337717e-02f, -5.03988415e-02f, 2.16168370e-02f, -5.16937226e-02f,
  2.06849501e-02f, 3.10537089e-02f, 1.92241631e-02f, -3.28829251e-02f, 8.48025531e-02f, 9.66477674e-03f, 6.31193742e-02f, 4.06679884e-02f, 1.18255159e-02f, -4.22216132e-02f,
  -2.10632190e-01f, -1.04863845e-01f, 1.94901675e-02f, -7.19165653e-02f, -4.48485427e-02f, -6.47917390e-02f, 4.81425002e-02f, -1.85123477e-02f, 9.01276525e-03f, 2.00420395e-02f,
  -4.90326108e-03f, -5.57686388e-02f, -2.91597415e-02f, -2.29131021e-02f, 1.94063708e-02f, -5.03557874e-03f, -4.03225422e-03f, -3.91242988e-02f, -9.20919180e-02f, -7.95284286e-02f,
  -2.54779104e-02f, -3.14767733e-02f, 1.94881670e-02f, -1.31182810e-02f, -5.64183258e-02f, -4.37202267e-02f, -4.46042456e-02f, 7.09779114e-02f, -9.34375376e-02f, 3.91618572e-02f,
  3.33115578e-01f, -3.48488033e-01f, -1.80654958e-01f, 1.35927051e-01f, -9.27994549e-02f, 1.03253454e-01f, 2.05261484e-01f, -1.60707340e-01f, 1.11441150e-01f, 2.80212630e-02f,
  2.10311890e-01f, 1.02903843e-01f, 1.86232850e-02f, 1.94382280e-01f, 3.51092070e-01f, 1.98058069e-01f, 2.00090319e-01f, 2.66113967e-01f, 1.77499503e-02f, -6.22120732e-03f,
  1.32413864e-01f, 7.87169039e-02f, -7.34027326e-02f, -2.92375118e-01f, -9.57660004e-02f, -2.03244641e-01f, 6.37815222e-02f, -2.52404183e-01f, 4.63252179e-02f, -2.92633567e-03f,
  -5.52212521e-02f, -7.65925553e-03f, -3.05785500e-02f, -1.13572605e-01f, 4.72047403e-02f, 3.92816998e-02f, 4.59467769e-02f, -2.55026892e-02f, -5.09852208e-02f, -5.11449426e-02f,
  3.59513350e-02f, 4.12806347e-02f, 6.58751838e-03f, -1.86880492e-02f, -3.63438725e-02f, -7.96581134e-02f, 1.96642280e-02f, -2.65599173e-02f, -7.11195767e-02f, 4.35744636e-02f,
  -1.16143022e-02f, 8.45326111e-02f, 7.20828995e-02f, 6.00907095e-02f, 6.47770539e-02f, 5.38231954e-02f, -5.67946490e-03f, 1.48012005e-02f, 2.79579703e-02f, 6.21248819e-02f,
  5.49344718e-02f, 1.01707997e-02f, -1.91289615e-02f, -1.35609536e-02f, -4.92223203e-02f, -5.25968485e-02f, 2.09373403e-02f, -5.43268956e-03f, -5.03727719e-02f, -1.13719320e-02f,
  3.84981669e-02f, -2.94013042e-02f, 2.47246847e-02f, 4.99894693e-02f, 5.23748174e-02f, -2.70652622e-02f, -1.31145734e-02f, 7.29929283e-02f, -8.15826282e-03f, 1.07199270e-02f,
  -1.56534985e-02f, 3.07893287e-03f, -4.49736156e-02f, 3.16058919e-02f, -4.10957411e-02f, -2.46777926e-02f, 5.02801351e-02f, -7.18140453e-02f, -3.62556837e-02f, 4.59205247e-02f,
  1.28331020e-01f, 8.17149132e-02f, -1.37437321e-03f, -6.89176936e-03f, -7.83182979e-02f, -3.21336016e-02f, 1.48179447e-02f, 5.78697363e-04f, -6.84891939e-02f, -2.04785448e-02f,
  1.06722387e-02f, -3.90996672e-02f, -2.70647500e-02f, 2.63020936e-02f, 2.77749803e-02f, 8.76602456e-02f, 7.98620954e-02f, -2.58407183e-02f, 3.66379321e-02f, 5.46721779e-02f,
  7.79967802e-03f, 3.39386202e-02f, -6.47199377e-02f, -7.59410858e-02f, 4.89366651e-02f, 6.58398643e-02f, 3.36477272e-02f, -7.76636600e-02f, 3.50091681e-02f, 6.24149069e-02f,
  -2.06777617e-01f, 5.04708588e-01f, 5.14197387e-02f, 7.72561803e-02f, -1.45587832e-01f, -8.19548219e-02f, 4.10644189e-02f, 9.68078002e-02f, 1.17607124e-01f, 3.90683979e-01f,
  1.23444116e-02f, 1.46663427e-01f, 1.15720443e-01f, 1.46856323e-01f, -2.58317232e-01f, 7.47884288e-02f, -1.09177940e-01f, 1.23479189e-02f, -1.04456276e-01f, -1.60181597e-01f,
  -1.51543319e-01f, -1.06750213e-01f, -1.63664550e-01f, -1.28364652e-01f, -3.57314162e-02f, -5.05022965e-02f, -8.37272033e-02f, -4.81289700e-02f, 3.15184481e-02f, 8.67186021e-03f,
  3.65988985e-02f, 2.04005931e-02f, 4.86850552e-02f, -2.23455429e-02f, -7.02553913e-02f, 1.82129871e-02f, -2.55535580e-02f, -4.15088087e-02f, -5.42478748e-02f, -1.11841997e-02f,
  -9.68837924e-03f, 3.96805257e-03f, 1.91520210e-02f, 6.90196361e-03f, 3.28003652e-02f, 5.37267625e-02f, 1.10898362e-02f, -3.22515294e-02f, 2.86057238e-02f, 4.67269719e-02f,
  -6.57073082e-03f, 7.77710229e-02f, -1.49424013e-03f, 2.16496829e-02f, -1.00888656e-02f, 5.74527197e-02f, 4.94138002e-02f, 2.11205892e-02f, 5.77056371e-02f, 8.06306973e-02f,
  1.49700912e-02f, -5.43345250e-02f, 6.14232430e-03f, -2.43058000e-02f, 4.05458286e-02f, 5.91267133e-03f, 1.30399019e-02f, -8.25817138e-03f, -2.07124520e-02f, 5.90101220e-02f,
  2.39786170e-02f, 6.75184205e-02f, -6.58657700e-02f, 8.90157942e-04f, -3.43586691e-02f, 5.74354269e-03f, -5.32521382e-02f, -3.82802188e-02f, -3.65687944e-02f, 6.68462482e-04f,
  -3.89424115e-02f, -5.27684540e-02f, 1.32597275e-02f, -1.55203845e-02f, 3.73922428e-03f, 1.87519297e-03f, -2.95228884e-02f, 7.42512867e-02f, -7.45561644e-02f, -4.39653508e-02f,
  2.81499196e-02f, -4.56371680e-02f, -2.97001638e-02f, 1.92223843e-02f, -6.82531390e-04f, -1.74756683e-02f, -3.28709334e-02f, 2.27796119e-02f, 1.18895350e-02f, -8.72504860e-02f,
  -3.24955806e-02f, 1.99095961e-02f, -4.18231152e-02f, -1.94181930e-02f, -8.33282620e-02f, 7.08422530e-03f, -7.52429292e-02f, -2.50367299e-02f, -1.16345048e-01f, 1.28005976e-02f,
  1.19030727e-02f, -1.50389262e-02f, 6.63269777e-03f, -4.73027937e-02f, -1.58562921e-02f, 2.73226164e-02f, -4.00538184e-02f, 6.89010993e-02f, -3.92657593e-02f, 7.42050260e-02f,
  5.08754194e-01f, -8.59816894e-02f, 8.95032659e-02f, 1.86906308e-02f, 1.09693542e-01f, 6.59350976e-02f, 1.63806498e-01f, -6.94292560e-02f, -1.13709450e-01f, -2.39106104e-01f,
  -5.33080138e-02f, 1.26575544e-01f, 3.13110128e-02f, -1.35872588e-01f, 2.05049947e-01f, -9.14704204e-02f, -9.52083468e-02f, -7.29501098e-02f, 6.04475401e-02f, 7.98307918e-03f,
  7.66239241e-02f, -6.71930760e-02f, -6.48995163e-03f, -1.27481014e-01f, 1.93999156e-01f, 7.88698867e-02f, -1.32912591e-01f, -2.73497012e-02f, -9.38703194e-02f, 6.34748116e-02f,
  5.94134592e-02f, -1.61734764e-02f, -3.86478715e-02f, -5.17434254e-02f, -9.11970157e-03f, 1.16864489e-02f, 3.84716801e-02f, 3.35159339e-02f, 4.29685935e-02f, -2.27334891e-02f,
  3.68495062e-02f, 2.58759428e-02f, -1.72174983e-02f, 1.55785326e-02f, 7.92256966e-02f, -1.87010933e-02f, 2.18048971e-02f, 2.97675229e-04f, 3.60540412e-02f, 6.07329234e-02f,
  6.70649623e-03f, 1.03652276e-01f, 3.09759211e-02f, 1.19914012e-02f, -1.80861801e-02f, 4.43558842e-02f, 3.85952964e-02f, 6.09842017e-02f, -7.38920551e-03f, -4.68319245e-02f,
  4.73037884e-02f, 6.81348220e-02f, 8.41173679e-02f, -5.70246065e-03f, 1.42395403e-03f, 2.28868444e-02f, 5.00598587e-02f, -1.53203895e-02f, 6.57899603e-02f, -1.79999433e-02f,
  7.71153602e-04f, -5.46254858e-04f, -6.61489442e-02f, -3.77109908e-02f, 1.47674894e-02f, 1.26883043e-02f, 1.97882317e-02f, 3.85109149e-02f, -3.39712948e-02f, 1.89242270e-02f,
  -2.03821361e-02f, 7.64158601e-03f, -2.66932622e-02f, 3.27351503e-03f, -3.31836082e-02f, -4.73498106e-02f, -6.45088628e-02f, -2.47088186e-02f, -6.37927875e-02f, 7.16470405e-02f,
  -1.13504559e-01f, -2.29426920e-01f, -9.31992158e-02f, -3.61887515e-02f, -3.73750143e-02f, 2.76029091e-02f, -5.85277826e-02f, -7.14776106e-03f, -8.69516283e-02f, -5.46430089e-02f,
  -3.85467634e-02f, 5.56252971e-02f, -4.81767878e-02f, -1.03992810e-02f, -1.60782095e-02f, -1.12079315e-01f, 5.05097862e-03f, 1.21743055e-02f, -4.06483337e-02f, -3.97949144e-02f,
  -3.61992605e-02f, -6.80451607e-03f, 7.67476633e-02f, -2.79537477e-02f, -8.20401534e-02f, 2.27976386e-02f, -2.58635506e-02f, -3.72107560e-03f, 6.72152713e-02f, -9.48954672e-02f,
  -3.87638420e-01f, 1.01663671e-01f, -7.02321762e-03f, -3.47694419e-02f, -2.53391623e-01f, -3.55380714e-01f, -1.69164628e-01f, -1.62206396e-01f, 4.33673263e-02f, 2.37630084e-01f,
  -9.62616056e-02f, 6.24992885e-02f, 6.24131523e-02f, -1.41883686e-01f, -1.46418214e-01f, 1.94473997e-01f, -4.97038402e-02f, 3.64793986e-02f, 3.73652913e-02f, -6.94610104e-02f,
  -1.16403319e-01f, -1.71823516e-01f, -2.43303981e-02f, 1.73756443e-02f, -2.57347167e-01f, 4.87815551e-02f, 1.28112763e-01f, 1.78094786e-02f, -2.68269964e-02f, -9.79331657e-02f,
  -1.74718052e-01f, 5.73851392e-02f, 6.01807088e-02f, -2.87289005e-02f, -4.84134667e-02f, -6.76793838e-03f, -4.46121618e-02f, 1.41852517e-02f, 1.76913012e-02f, -5.48879877e-02f,
  1.12981526e-02f, -5.80607587e-03f, -2.57175416e-03f, 7.08587393e-02f, -6.64351881e-02f, -4.92876582e-02f, -6.35521784e-02f, -5.46559580e-02f, -3.57799754e-02f, -4.36449237e-02f,
  -3.16901095e-02f, -4.38799895e-03f, -4.02049869e-02f, 3.75246666e-02f, 2.52052695e-02f, -1.12277328e-03f, 3.70542556e-02f, 9.14532784e-03f, -4.93792184e-02f, -9.14975721e-03f,
  4.91672605e-02f, 8.22730437e-02f, -2.59634992e-03f, -7.89489299e-02f, -2.57811267e-02f, -2.33065747e-02f, -1.06786247e-02f, -1.31517285e-02f, 6.31934479e-02f, -1.10720145e-02f,
  3.86769674e-03f, 2.27266434e-03f, -1.75108071e-02f, -4.51186523e-02f, 3.79762575e-02f, -1.33995339e-02f, 5.63147031e-02f, -3.39725316e-02f, -1.12555374e-03f, 6.98998012e-03f,
  -1.51965711e-02f, -2.70627476e-02f, 2.35581814e-04f, -3.11751384e-02f, -4.72143032e-02f, 3.62648405e-02f, -2.19958718e-03f, 1.62191167e-02f, 1.44368794e-03f, -3.10358908e-02f,
  -2.41445880e-02f, 2.18074352e-01f, 6.35813475e-02f, -3.16566825e-02f, 1.30191863e-01f, 5.98541163e-02f, 2.63853949e-02f, -1.34977438e-02f, 2.78698467e-02f, -3.54922488e-02f,
  3.74313891e-02f, 1.72116701e-02f, -1.08441450e-02f, 8.77643586e-04f, 4.45198566e-02f, -3.37829776e-02f, 1.25175770e-02f, 4.02556323e-02f, 4.01677750e-03f, 2.44581699e-02f,
  -3.69213000e-02f, -7.63884652e-03f, 2.75458340e-02f, 4.68595698e-03f, 6.07880652e-02f, -3.27642285e-03f, -3.94933559e-02f, 1.51432855e-02f, 3.02260090e-03f, 4.75901254e-02f,
  -1.19528748e-01f, 3.12068939e-01f, -1.87341079e-01f, -1.51811644e-01f, -8.03242773e-02f, 4.35087681e-02f, 1.15965433e-01f, 6.97328299e-02f, -1.08309887e-01f, 3.15793931e-01f,
  1.19564846e-01f, 7.07060844e-02f, 1.98374167e-01f, 8.27570856e-02f, -3.15438956e-01f, -4.90145348e-02f, 3.22538242e-02f, 4.90610674e-02f, -7.79765099e-02f, 1.23972982e-01f,
  -6.68332353e-02f, 1.25004472e-02f, -3.23014371e-02f, -1.15675963e-02f, 8.07648897e-02f, -4.83044237e-02f, -6.77603707e-02f, -9.06339288e-02f, 4.04282473e-02f, -6.39113635e-02f,
  1.49320692e-01f, 3.95491123e-02f, 8.50560740e-02f, 3.96849066e-02f, 8.52268413e-02f, 7.60353729e-02f, -3.91948298e-02f, -5.60446680e-02f, -7.83401281e-02f, 7.02276919e-03f,
  8.79370719e-02f, -5.24044558e-02f, -1.95895433e-02f, 5.22390753e-03f, 2.15274449e-02f, 2.31505614e-02f, 2.30935197e-02f, 3.60864513e-02f, 1.54483402e-02f, -1.11245476e-02f,
  7.57011697e-02f, 6.92801550e-02f, 3.41082141e-02f, 8.20222497e-03f, -8.77018645e-02f, 2.20454335e-02f, -7.51431137e-02f, -4.28529829e-02f, 1.75214689e-02f, -4.07084264e-02f,
  -8.82837921e-02f, -8.62677116e-03f, 1.95511356e-02f, 5.24598658e-02f, 2.47458667e-02f, 1.52387125e-02f, 5.46010099e-02f, 4.69040684e-03f, -1.25516113e-02f, 3.71620394e-02f,
  2.18020659e-02f, -1.04654562e-02f, 2.88771968e-02f, 5.65493479e-02f, 4.41456586e-03f, -2.50220974e-03f, -2.20540073e-03f, 1.96462665e-02f, 1.05193546e-02f, 9.29569302e-04f,
  -7.94245582e-03f, 2.59965174e-02f, 6.33850098e-02f, -1.77569631e-02f, 1.04758078e-02f, -1.69608854e-02f, 4.00211141e-02f, -1.35504417e-02f, 5.59451059e-02f, -1.76222455e-02f,
  2.47096598e-01f, 5.03491126e-02f, 8.89193192e-02f, 1.46931037e-01f, 4.23026681e-02f, 1.83569100e-02f, -5.78275062e-02f, -1.62745453e-02f, 1.78792456e-03f, 8.28590523e-03f,
  4.77420203e-02f, 6.91004321e-02f, 1.93808153e-02f, -4.66803685e-02f, -4.93560657e-02f, -1.72117092e-02f, 4.53829989e-02f, 3.32818693e-03f, 1.02606928e-02f, 1.59166679e-02f,
  8.74990821e-02f, -1.99523717e-02f, -2.78878212e-02f, -3.21775042e-02f, -2.86799800e-02f, 7.13204294e-02f, -3.11472453e-02f, -4.06627208e-02f, -1.13143073e-02f, 9.26149150e-05f,
  9.59357321e-02f, 2.00074166e-01f, -2.16797397e-01f, -1.39212132e-01f, 8.87801275e-02f, -1.64548650e-01f, -1.42845646e-01f, -1.87036749e-02f, -1.02573067e-01f, 1.57001585e-01f,
  9.86330062e-02f, 1.19934976e-01f, 4.97147739e-02f, -6.76183328e-02f, -1.30628824e-01f, -1.38316378e-01f, -1.59500390e-01f, -2.03355830e-02f, -2.64513567e-02f, 7.67995268e-02f,
  -1.40880212e-01f, 4.86555845e-02f, -1.53846726e-01f, 1.09136112e-01f, 4.40662354e-02f, -9.82850511e-03f, 9.32553783e-02f, 7.74567425e-02f, 5.94589710e-02f, 7.10344911e-02f,
  4.35779206e-02f, 1.16330422e-01f, -9.64686498e-02f, 4.45503108e-02f, -4.58856523e-02f, -3.42078917e-02f, 1.12907346e-02f, 2.42177211e-02f, -9.02717002e-04f, 5.34283221e-02f,
  1.33020198e-02f, 3.76886241e-02f, 7.96216354e-03f, -2.98691615e-02f, -2.04244070e-02f, 3.30038071e-02f, -1.91390123e-02f, -1.23982029e-02f, 1.25575326e-02f, 5.83869871e-03f,
  -1.00515500e-01f, -4.90934215e-02f, -1.01780012e-01f, 4.95567173e-03f, -5.14033549e-02f, 3.02537698e-02f, -1.23329453e-01f, -2.25019432e-03f, 1.85099524e-02f, -5.72502464e-02f,
  7.26272585e-03f, -3.72720733e-02f, -6.31068349e-02f, -7.42291892e-03f, 5.12995496e-02f, 2.21871603e-02f, -9.87753551e-03f, 3.23083550e-02f, 3.72723714e-02f, 5.41891642e-02f,
  1.69685297e-02f, -1.67938955e-02f, 2.00534314e-02f, -7.58930296e-02f, -1.85577143e-02f, 5.56459231e-03f, 1.01245865e-02f, 8.89202580e-02f, -5.03170080e-02f, -2.86496151e-02f,
  7.66745359e-02f, -1.55699244e-02f, 8.32680520e-03f, 6.87993094e-02f, 3.37980166e-02f, -3.78419110e-03f, -4.82999533e-02f, -1.44490786e-02f, 3.28774340e-02f, -4.45405766e-02f,
  1.38420537e-01f, 1.80464387e-01f, 1.60404993e-03f, 1.01999387e-01f, 1.02186166e-01f, -1.88450012e-02f, -5.11150174e-02f, 1.26315812e-02f, 7.33269751e-02f, 1.89791489e-02f,
  5.83904603e-06f, -2.12169196e-02f, 4.15979140e-02f, 3.22877653e-02f, -4.93694237e-03f, -4.72379811e-02f, -2.69090906e-02f, 1.77350605e-03f, 1.34048536e-02f, 1.35032371e-01f,
  2.31477786e-02f, 1.04611121e-01f, -3.30236964e-02f, 3.98785174e-02f, 3.45604606e-02f, 2.71895826e-02f, 1.03522509e-01f, -1.99667122e-02f, 1.77137144e-02f, -4.47506234e-02f,
  1.78113639e-01f, 1.72374189e-01f, 5.59827648e-02f, -1.49822429e-01f, 1.47708952e-01f, 2.70113528e-01f, 2.24882513e-02f, 2.16785029e-01f, 2.94932276e-01f, -1.71524376e-01f,
  -1.50842682e-01f, -1.54868051e-01f, -2.95326244e-02f, -7.64518976e-02f, 6.50082231e-02f, 1.05544224e-01f, 9.44612324e-02f, 8.43157917e-02f, 2.10187927e-01f, 1.54538713e-02f,
  3.97376753e-02f, -1.41960949e-01f, -1.57311082e-01f, -4.47337851e-02f, 6.93099871e-02f, 1.63507946e-02f, -1.50238931e-01f, -3.65533829e-02f, -1.93488523e-01f, 4.22684252e-02f,
  1.67559847e-01f, 4.19332311e-02f, -1.43931776e-01f, 1.74534712e-02f, 4.45032418e-02f, 1.30537571e-02f, -3.10227694e-03f, -5.52043580e-02f, -2.95361616e-02f, -5.30299805e-02f,
  -5.26119322e-02f, -1.70420427e-02f, -1.27559388e-02f, -8.60072002e-02f, 7.86923841e-02f, 2.72283480e-02f, 1.49161797e-02f, 1.16402969e-01f, -2.05213912e-02f, 2.61636470e-02f,
  9.70260706e-03f, 4.50608470e-02f, -4.05674316e-02f, 2.82089300e-02f, -5.11134379e-02f, 3.67897539e-03f, -1.24308476e-02f, 3.77528928e-02f, 4.72361743e-02f, 5.42464070e-02f,
  -8.04780331e-03f, 8.20817426e-02f, -6.79069087e-02f, -4.29846458e-02f, 5.04606729e-03f, 3.27728502e-02f, -6.89405501e-02f, -5.69025613e-02f, -7.99339823e-03f, -5.93022406e-02f,
  1.19960532e-02f, 2.56041866e-02f, 1.06785476e-01f, 3.36666778e-02f, 2.81359511e-03f, 1.40136539e-03f, -2.22167410e-02f, -4.69489116e-03f, 1.14816196e-01f, 3.93783376e-02f,
  -2.29581930e-02f, 5.69565184e-02f, -4.86757234e-02f, -4.98887375e-02f, 4.90324683e-02f, 5.66273890e-02f, 2.99184360e-02f, -3.95133346e-03f, 2.45708935e-02f, -2.81294696e-02f,
  2.92838216e-01f, 1.66641906e-01f, -6.61699427e-03f, -8.88777003e-02f, 3.26316394e-02f, -8.24676529e-02f, 3.88683565e-02f, -4.28543147e-03f, 1.11824580e-01f, -9.49529931e-02f,
  2.94161979e-02f, -1.67289063e-01f, 9.45261940e-02f, -1.87287405e-02f, -3.04778535e-02f, 1.89475641e-02f, -6.25519678e-02f, 1.88604812e-04f, 4.30816114e-02f, -2.10325848e-02f,
  -9.88878235e-02f, 9.71583184e-03f, -1.09084100e-01f, -4.58987430e-03f, -9.96518508e-02f, -9.90596879e-03f, 8.36385321e-03f, -4.69589420e-02f, -2.74745654e-02f, 1.98736433e-02f,
  -1.75734267e-01f, 2.61206388e-01f, -1.78994253e-01f, -9.01772156e-02f, 9.16954726e-02f, -8.25141966e-02f, -3.98480862e-01f, -1.48563134e-02f, -2.45966449e-01f, 9.68474224e-02f,
  8.64468887e-02f, -1.90634608e-01f, 4.09337133e-03f, 1.85918566e-02f, 1.01108104e-01f, 1.76077142e-01f, 1.31028086e-01f, -8.83515365e-03f, -6.05874918e-02f, 9.32573751e-02f,
  3.09622381e-02f, 2.76088893e-01f, 5.42581454e-02f, 1.81106210e-01f, 1.20115897e-03f, -5.16731553e-02f, 2.33340740e-01f, -1.07307330e-01f, 7.81596377e-02f, 1.81287304e-02f,
  -7.86953345e-02f, -8.79964828e-02f, -1.85554385e-01f, -1.09987691e-01f, 1.82314962e-02f, -9.60205272e-02f, -8.01642835e-02f, -2.54651941e-02f, -6.37145787e-02f, -5.76582365e-02f,
  5.46172215e-03f, 3.88816744e-02f, -5.44496700e-02f, -2.17157099e-02f, -5.27872257e-02f, -7.80367181e-02f, -4.79989164e-02f, -1.63614582e-02f, -4.67666574e-02f, 1.83273386e-02f,
  -4.20457907e-02f, 7.28790835e-02f, 7.62769654e-02f, 2.22729072e-02f, 9.75491665e-03f, 1.57899391e-02f, 2.09798217e-02f, -4.02513221e-02f, 4.82437760e-02f, 5.20234229e-03f,
  6.67331070e-02f, 8.77081603e-02f, 5.23246452e-02f, -9.09915119e-02f, 8.68351478e-03f, -1.46596262e-03f, 6.66256901e-03f, -1.69481728e-02f, -7.72878081e-02f, 5.92476800e-02f,
  -1.58201419e-05f, -3.28300148e-02f, -4.99061160e-02f, -3.81394513e-02f, 1.77509021e-02f, 1.11276228e-02f, 4.65171672e-02f, -7.85773620e-03f, -3.79929841e-02f, -6.70877248e-02f,
  -8.54324177e-03f, 2.16918867e-02f, -9.90233123e-02f, -1.49586666e-02f, 4.62144576e-02f, -2.88010817e-02f, 3.04445624e-02f, -3.12902108e-02f, 1.42705450e-02f, 4.30257060e-02f,
  2.40299419e-01f, 1.94792241e-01f, -8.79578590e-02f, -3.50885093e-02f, -4.62566093e-02f, 4.23070602e-02f, -2.66694762e-02f, 5.68636060e-02f, 4.32128608e-02f, -3.44643816e-02f,
  1.51359644e-02f, -2.86389105e-02f, 6.48450777e-02f, -3.23713981e-02f, 5.45987710e-02f, 3.08242403e-02f, 4.53804955e-02f, -1.98894273e-02f, 2.88979597e-02f, 3.77396196e-02f,
  4.69728597e-02f, 1.40985688e-02f, -3.62210050e-02f, -5.02108932e-02f, 5.13174161e-02f, 6.10904247e-02f, 1.95955541e-02f, 2.71161478e-02f, 1.26475021e-01f, 5.79923131e-02f,
  -8.73502046e-02f, 1.47255743e-02f, -1.00144945e-01f, -2.73698330e-01f, -8.18442181e-02f, 4.23447788e-01f, 2.07810819e-01f, -2.71508899e-02f, -1.07087739e-01f, 2.04000190e-01f,
  -6.67704716e-02f, -2.64765441e-01f, 9.08562839e-02f, -1.26022380e-02f, 1.88841239e-01f, 1.75824299e-01f, 1.89483970e-01f, 7.16426373e-02f, -9.97460261e-02f, 4.96306792e-02f,
  -4.95262705e-02f, 3.73872090e-03f, -5.80796525e-02f, -4.83496934e-02f, -6.67966381e-02f, -2.05018550e-01f, -6.37759781e-03f, -8.56167972e-02f, -2.56585795e-02f, -6.20494336e-02f,
  9.91602838e-02f, -2.67422080e-01f, -2.24997364e-02f, 4.14210968e-02f, 8.87151584e-02f, 6.80440217e-02f, 6.67093992e-02f, 2.26464085e-02f, -4.61578183e-02f, -5.05906856e-03f,
  7.17516094e-02f, -3.79368924e-02f, -3.46715823e-02f, -4.01458740e-02f, 5.89371063e-02f, -8.04992020e-02f, -1.59250889e-02f, -5.34885889e-03f, -6.37931079e-02f, -3.64012271e-02f,
  -1.52093368e-02f, 7.80020133e-02f, 3.40136439e-02f, 4.95985560e-02f, -7.74548762e-03f, -5.31128235e-02f, 2.84378510e-02f, 5.31324372e-02f, 4.47641201e-02f, 9.43152606e-03f,
  -8.68866444e-02f, -1.64009817e-02f, 1.23074558e-02f, -2.36935690e-02f, -3.57074328e-02f, -4.42442074e-02f, 6.52205124e-02f, 3.99168245e-02f, 9.34507046e-03f, 2.70459428e-02f,
  3.50526050e-02f, -2.66151410e-02f, -5.14392555e-02f, 5.65958507e-02f, 8.55077803e-03f, 1.76443085e-02f, 4.03973497e-02f, -4.13204543e-02f, 1.06195651e-01f, -4.10746075e-02f,
  -6.40125126e-02f, 8.31880793e-02f, 3.04045770e-02f, 1.21916614e-01f, 1.72799751e-02f, 1.71432011e-02f, -1.73643418e-02f, 2.40788199e-02f, 3.45995277e-02f, 5.77278920e-02f,
  3.01447004e-01f, 1.17595844e-01f, 5.87269198e-03f, 5.70334308e-02f, 2.01665200e-02f, 4.94614840e-02f, -3.64309587e-02f, 3.27656530e-02f, 2.33037416e-02f, 7.43104704e-03f,
  -8.95449892e-03f, 9.17757079e-02f, 1.88465379e-02f, 1.87254492e-02f, 8.56820401e-03f, 3.42064537e-02f, -1.43382763e-02f, 2.53310222e-02f, 4.28694822e-02f, 1.61153153e-02f,
  2.84465831e-02f, -9.40663368e-03f, 6.77106380e-02f, 1.87500864e-02f, 9.64746699e-02f, -1.31020905e-03f, -6.18079044e-02f, -7.98801519e-03f, 4.80252579e-02f, 1.34944450e-02f,
  -4.60852729e-03f, -9.49846059e-02f, -1.13713734e-01f, -2.17034683e-01f, 2.76792705e-01f, 4.48905647e-01f, 1.03941094e-02f, 8.91553462e-02f, -9.09304023e-02f, -9.35318694e-02f,
  5.32446094e-02f, -1.69739187e-01f, -1.61078870e-02f, -1.51432410e-01f, 1.76986784e-01f, -9.74816680e-02f, -3.54475193e-02f, -1.01478286e-01f, -1.96750853e-02f, -7.84683973e-03f,
  5.53629547e-03f, 1.46869168e-01f, -1.33066669e-01f, 2.38289341e-01f, 5.71908206e-02f, -4.97621894e-02f, -8.71661119e-03f, 2.40175221e-02f, 5.12981340e-02f, 3.01238392e-02f,
  1.51800781e-01f, -1.10772863e-01f, -5.14248461e-02f, -3.23919877e-02f, 7.72647411e-02f, 3.96861136e-03f, -1.28925219e-02f, -3.75509821e-03f, -1.50696542e-02f, 2.50582099e-02f,
  3.26537751e-02f, 5.48445433e-02f, 1.88920330e-02f, -6.15107603e-02f, 2.96065006e-02f, 2.71245018e-02f, -1.88113414e-02f, 1.78328194e-02f, 1.42230289e-02f, -3.76708843e-02f,
  -3.22298817e-02f, 1.01157939e-02f, -2.01665144e-02f, -2.26098001e-02f, -1.29824430e-02f, -1.80288553e-02f, -8.27531219e-02f, -4.55744006e-03f, 7.36273229e-02f, -4.37381258e-03f,
  9.14810300e-02f, -1.81432180e-02f, -4.39132191e-02f, -2.28787605e-02f, 5.63424341e-02f, 3.94750983e-02f, -2.38783099e-02f, 4.16143946e-02f, -7.12968037e-02f, 5.72771877e-02f,
  9.06289965e-02f, -8.03053081e-02f, 3.47960666e-02f, 4.34296243e-02f, -9.63700041e-02f, -2.25104839e-02f, 3.17694359e-02f, 1.88248307e-02f, 5.09097299e-04f, -2.73563601e-02f,
  -2.26145722e-02f, 5.39537556e-02f, -1.51312705e-02f, 1.32209435e-02f, 3.58590223e-02f, -2.66201738e-02f, 1.56538673e-02f, -5.85747370e-03f, -1.42527223e-02f, 8.17009434e-02f,
  2.36637309e-01f, 1.09474473e-01f, -8.08625540e-04f, 6.04590774e-02f, -8.37138016e-03f, -2.96924030e-03f, -5.52789085e-02f, -3.02951620e-03f, 8.44365209e-02f, 4.35568616e-02f,
  3.67369060e-03f, -2.57205907e-02f, 9.23728645e-02f, -4.39725071e-02f, -1.27302716e-02f, 4.67080064e-02f, -3.02274805e-03f, -3.76960379e-03f, 5.92098422e-02f, 7.06756040e-02f,
  2.24539395e-02f, 1.05347447e-01f, -2.07703002e-02f, 8.84899311e-03f, 4.48807748e-03f, 5.07428162e-02f, 2.36352459e-02f, -7.77422115e-02f, 6.28619716e-02f, 3.56385927e-03f,
  -4.55581069e-01f, 2.94406921e-01f, 1.34553954e-01f, -8.52992833e-02f, 5.57591766e-02f, -1.37808874e-01f, -1.71898842e-01f, 1.97288021e-01f, -1.77262694e-01f, 1.33735061e-01f,
  8.68874788e-02f, -2.28308409e-01f, 1.36449546e-01f, -1.15539366e-03f, -2.89337814e-01f, -8.41839537e-02f, -1.86242580e-01f, -1.61709309e-01f, -2.41918284e-02f, 7.70706087e-02f,
  -7.29014203e-02f, 5.81156388e-02f, 1.23812586e-01f, 1.44885495e-01f, 8.87013748e-02f, 9.33967605e-02f, 1.48677751e-01f, 1.35169551e-01f, 9.54504013e-02f, -1.03417806e-01f,
  -6.14263043e-02f, 6.27334192e-02f, 4.33053263e-02f, -2.45620497e-02f, -1.25473654e-02f, 1.94663759e-02f, -8.11592583e-03f, -4.30169627e-02f, -1.90523695e-02f, 8.02150182e-03f,
  -5.40261976e-02f, -4.16422747e-02f, -3.62293236e-02f, 7.85554387e-03f, -4.40777130e-02f, 3.77931744e-02f, 3.06102820e-02f, 3.36420909e-03f, 1.92764457e-02f, -2.80792937e-02f,
  -4.86778328e-03f, -5.23584560e-02f, -5.03970981e-02f, -8.11486915e-02f, -1.42125962e-02f, -4.45044450e-02f, -8.13475344e-03f, -2.24344451e-02f, -4.33664620e-02f, -8.12331513e-02f,
  -6.51356131e-02f, -5.35032302e-02f, 4.50423285e-02f, 3.93459685e-02f, 1.66656096e-02f, 8.37083161e-02f, 1.74569916e-02f, 5.29969111e-03f, -2.82654967e-02f, 1.33760748e-02f,
  -3.85152129e-03f, 2.88371798e-02f, 5.13456296e-03f, -1.62528474e-02f, -7.83926621e-03f, 3.19449184e-03f, -3.34009342e-02f, 3.39678046e-03f, -4.25510630e-02f, 3.09512690e-02f,
  3.18733752e-02f, -9.79658496e-03f, 1.57100931e-02f, -8.32240854e-04f, -1.07350051e-02f, 3.66084203e-02f, 5.86868413e-02f, 4.66230698e-02f, 5.25237471e-02f, -2.52481899e-03f,
  -9.18484479e-03f, 9.05518606e-02f, 4.88147177e-02f, -2.84188129e-02f, 1.62119325e-02f, 8.77808779e-03f, -3.27272899e-02f, -5.84822968e-02f, -2.65442710e-02f, 5.96437864e-02f,
  -6.26781657e-02f, 3.38323452e-02f, 7.13079609e-03f, -8.87440611e-03f, -1.41529711e-02f, 9.47537646e-03f, -4.26387042e-03f, -1.62492059e-02f, -2.48295255e-02f, 1.45013165e-02f,
  5.98268546e-02f, 5.50077390e-03f, -4.36854698e-02f, 5.15078241e-03f, -9.72673669e-03f, -3.22493017e-02f, -4.51733917e-02f, 3.66600393e-03f, -1.38659757e-02f, -2.65761781e-02f,
  1.92907169e-01f, 2.75776386e-01f, -1.39263168e-01f, 5.47787137e-02f, -2.12372746e-02f, -5.68723269e-02f, -1.22916393e-01f, 5.43975793e-02f, 2.30012149e-01f, 2.75121797e-02f,
  -1.05793484e-01f, 2.37611651e-01f, -9.01761129e-02f, -1.29783198e-01f, -2.02092469e-01f, -9.85080451e-02f, -1.74310192e-01f, 5.69466911e-02f, 2.04975512e-02f, 2.17563640e-02f,
  -2.16346122e-02f, -3.12932618e-02f, -2.84953326e-01f, 4.80392426e-02f, -7.56560564e-02f, 8.65289569e-02f, -1.24900162e-01f, -6.52448460e-02f, -9.51268002e-02f, -4.00974974e-02f,
  5.26529141e-02f, 4.09621298e-02f, -9.09134455e-04f, 1.86267290e-02f, -1.03717133e-01f, -5.80822527e-02f, -7.06555471e-02f, -4.45836931e-02f, -6.10982589e-02f, -3.92325297e-02f,
  9.69159529e-02f, 2.40861531e-02f, 1.05850417e-02f, 3.11511625e-02f, 1.07073188e-01f, 3.45955603e-02f, -4.69843764e-03f, -7.14949891e-02f, 4.93089035e-02f, -7.38639534e-02f,
  -1.56659614e-02f, -3.45039368e-02f, -8.01614523e-02f, -2.51169149e-02f, -2.79991291e-02f, 6.36766199e-03f, -5.39166369e-02f, -2.12530810e-02f, 2.57755909e-02f, 5.30767106e-02f,
  -1.04388230e-01f, 4.98283878e-02f, -1.56679098e-02f, 7.10080713e-02f, 8.71476135e-04f, 5.60873561e-03f, -3.11964527e-02f, -7.02301711e-02f, 6.70369063e-03f, 7.88318180e-03f,
  -1.70018859e-02f, 2.01463513e-02f, -3.48491734e-03f, -1.41649935e-02f, 1.70198344e-02f, -1.11798057e-02f, -4.16708887e-02f, 7.28614107e-02f, 6.97418721e-03f, -5.12511544e-02f,
  -1.15506044e-02f, -2.22714785e-02f, -1.86851900e-02f, 3.63243707e-02f, 8.64212681e-03f, -3.70192900e-02f, -1.04667833e-02f, -1.06818425e-02f, 1.13804601e-02f, -5.53379999e-03f,
  2.19263360e-01f, 9.26237777e-02f, 6.86020255e-02f, 9.13262144e-02f, 6.55880868e-02f, 2.79734302e-02f, -3.12941894e-02f, 6.82287440e-02f, 1.73780276e-03f, 1.59870721e-02f,
  -3.11682485e-02f, -3.88862658e-03f, 5.66521473e-03f, 2.80156117e-02f, 2.33721712e-05f, -3.86600196e-03f, -3.27729844e-02f, 3.49488072e-02f, -3.14163566e-02f, 1.29324710e-02f,
  -3.92838789e-04f, -1.24303903e-02f, -6.54584467e-02f, -3.93564161e-03f, -1.48601579e-02f, -2.17019431e-02f, 9.10340026e-02f, 4.34461534e-02f, -2.23924723e-02f, -3.96048576e-02f,
  1.48181379e-01f, 7.50851035e-02f, 1.11097261e-01f, 3.94164585e-02f, -2.68805981e-01f, 1.42508805e-01f, -1.37465462e-01f, -1.33453012e-01f, 3.72686274e-02f, -2.61922590e-02f,
  -6.68282509e-02f, 3.49938959e-01f, -5.23284636e-02f, 2.09111631e-01f, 2.75123119e-01f, 1.87930942e-01f, 3.47023070e-01f, 2.03761533e-01f, 1.01184249e-01f, 9.53608379e-02f,
  1.10604964e-01f, -1.38981670e-01f, -2.67549325e-02f, -1.66883335e-01f, -2.49746621e-01f, -9.67478901e-02f, -1.73027977e-01f, -1.67057604e-01f, 8.56177043e-03f, 6.43042102e-02f,
  6.67603165e-02f, -4.15805839e-02f, -8.32384378e-02f, 4.64287437e-02f, -2.53456575e-03f, -6.48251623e-02f, 2.18749475e-02f, -5.66226244e-03f, 2.21313369e-02f, 4.15714681e-02f,
  4.96785268e-02f, 5.29153459e-02f, 5.78388460e-02f, 1.06754936e-02f, -6.35734126e-02f, 4.15751571e-03f, 2.26702057e-02f, -1.70988161e-02f, -2.48740558e-02f, 4.01526205e-02f,
  -1.05294902e-02f, 9.73709822e-02f, 8.56507495e-02f, 9.80793834e-02f, 6.91215927e-03f, 6.54686987e-02f, 2.04676222e-02f, 3.02362815e-03f, 2.38940250e-02f, 1.82164763e-03f,
  -8.33489839e-03f, 2.52106749e-02f, 1.03209130e-02f, -3.44298892e-02f, -3.34634148e-02f, -7.28486627e-02f, 3.17991003e-02f, -2.98052444e-03f, 2.20787991e-02f, -1.26881981e-02f,
  3.35405655e-02f, -1.01017309e-02f, -2.35884115e-02f, -1.48986587e-02f, 3.99740599e-02f, -3.67473066e-02f, 5.93438856e-02f, -2.31594630e-02f, -4.60340641e-03f, -1.45267565e-02f,
  -6.05862513e-02f, 1.44551536e-02f, 2.47713155e-03f, -6.42869100e-02f, -1.71126183e-02f, -5.60314320e-02f, -2.95946747e-02f, -4.17823978e-02f, -8.21764022e-02f, -5.79382107e-03f,
  4.60135750e-02f, 1.17124788e-01f, -2.73241308e-02f, -8.16197786e-03f, 3.09619214e-02f, -2.00576074e-02f, -1.32218404e-02f, 2.53739916e-02f, 5.05591333e-02f, 1.74901839e-02f,
  3.25600393e-02f, -3.65128033e-02f, 3.20007429e-02f, 5.75742088e-02f, 2.19195951e-02f, -3.36069167e-02f, 2.34250482e-02f, -4.29694133e-04f, 3.39993685e-02f, 7.96614215e-02f,
  -4.65433933e-02f, 1.79789234e-02f, 2.13957168e-02f, -8.92757028e-02f, -4.33962531e-02f, -4.19905595e-02f, 2.16827057e-02f, -2.32361313e-02f, 4.91129793e-03f, 2.50478275e-02f,
  1.19571999e-01f, 2.38343418e-01f, 2.00815752e-01f, -6.51812330e-02f, -1.51900038e-01f, 2.32135221e-01f, 1.41707331e-01f, 2.06197314e-02f, 8.81267339e-02f, 7.04589635e-02f,
  -4.96317409e-02f, -7.75145590e-02f, 8.40336364e-03f, -2.41588145e-01f, -2.11273104e-01f, -1.45531267e-01f, -1.73070639e-01f, -1.67146578e-01f, -2.68185049e-01f, -1.20281309e-01f,
  -1.90247104e-01f, -3.10467511e-01f, -1.82204500e-01f, -2.56985426e-01f, -1.91224068e-01f, -2.79319249e-02f, -1.35270312e-01f, -1.60187145e-03f, -3.37723233e-02f, -8.92642587e-02f,
  1.31934300e-01f, 2.92884801e-02f, 5.60444826e-03f, 9.85108316e-02f, -9.97952297e-02f, 6.51481003e-02f, -4.74422909e-02f, -6.64315298e-02f, 2.07497575e-03f, 1.75107289e-02f,
  5.81263527e-02f, -9.32784230e-02f, -2.65715867e-02f, 2.55924892e-02f, 7.21477270e-02f, 1.94427805e-04f, -5.48660457e-02f, 2.80198064e-02f, 2.40998473e-02f, 2.94493791e-02f,
  -9.07923467e-03f, 6.35670498e-03f, 9.57508311e-02f, 1.99344978e-02f, -4.26892638e-02f, 9.13377702e-02f, 6.76565021e-02f, -4.00035363e-03f, -7.55199092e-03f, 4.90349196e-02f,
  1.20429518e-02f, 1.89010184e-02f, -3.99904232e-03f, -3.02777137e-03f, -3.72917503e-02f, -1.03689050e-02f, 2.36153454e-02f, -5.80875166e-02f, -4.10058908e-02f, -2.26772167e-02f,
  -1.85661986e-02f, -5.24083972e-02f, -8.31846800e-03f, 8.40678513e-02f, -3.76586877e-02f, 5.84294721e-02f, -3.53530087e-02f, -2.34901048e-02f, -3.62976305e-02f, -2.40634084e-02f,
  -4.97677214e-02f, 7.56236762e-02f, -4.29435484e-02f, -1.26299271e-02f, 3.17896865e-02f, -1.59555692e-02f, 3.13676596e-02f, 7.65151903e-02f, -4.69336193e-03f, -1.80352386e-02f,
  1.68693155e-01f, -6.17900006e-02f, -4.76094261e-02f, 2.06437279e-02f, -7.11155385e-02f, -5.37167378e-02f, -6.32161051e-02f, -6.06189109e-02f, 5.06937094e-02f, -1.95553415e-02f,
  3.27297836e-03f, -1.24296220e-03f, 8.84798989e-02f, 3.62249761e-04f, -5.27892523e-02f, 2.45710816e-02f, -5.46252774e-03f, 9.76523086e-02f, 9.75865964e-03f, -5.76780289e-02f,
  1.06479833e-02f, -1.11471854e-01f, -7.13826716e-02f, -7.30355233e-02f, -3.20419148e-02f, -1.46864755e-02f, 3.31931636e-02f, 7.61841098e-03f, -8.95267501e-02f, -4.68621813e-02f,
  1.44831330e-01f, -1.31827712e-01f, 2.14178368e-01f, 2.07321554e-01f, -2.94093132e-01f, 1.19984008e-01f, 1.35719508e-01f, -1.23073034e-01f, 1.94764897e-01f, -2.95074344e-01f,
  -6.55115470e-02f, 2.28739753e-01f, 4.81026173e-02f, 5.93181923e-02f, 3.25307399e-01f, 2.63183594e-01f, 1.90498963e-01f, 1.70277938e-01f, 1.22797839e-01f, -3.62103432e-02f,
  2.32117735e-02f, -2.23177105e-01f, -5.45849949e-02f, -2.52646416e-01f, -2.01682448e-01f, -1.94349084e-02f, -2.57747293e-01f, -1.43796941e-02f, -1.09555550e-01f, -8.48987624e-02f,
  1.05588287e-01f, -7.54654454e-03f, -4.28892970e-02f, 2.81328019e-02f, -5.54437637e-02f, -8.06896389e-02f, 6.73606433e-03f, 3.67340036e-02f, 4.87138145e-02f, 1.79130994e-02f,
  2.77040955e-02f, 9.70378518e-03f, 5.06914593e-02f, 2.17724964e-02f, -7.13348314e-02f, -1.10309012e-02f, 2.09183376e-02f, -2.50696409e-02f, 5.57498634e-03f, 3.66444662e-02f,
  1.24098258e-02f, 3.93313318e-02f, -1.11008459e-03f, 6.45699725e-02f, 8.59099329e-02f, 4.28792052e-02f, -2.77655534e-02f, 4.20307331e-02f, 1.77369099e-02f, 1.39140841e-02f,
  -7.42923990e-02f, -2.33877022e-02f, 3.70886963e-04f, 1.49039701e-02f, 3.71331796e-02f, -3.59281786e-02f, 1.62041113e-02f, -3.23517248e-02f, 9.53678787e-02f, 1.16279023e-02f,
  9.72198788e-03f, 9.92520340e-03f, -1.07026091e-02f, -4.00107764e-02f, -4.90026213e-02f, -4.48044389e-02f, 3.03811743e-03f, 2.93439366e-02f, 4.45154272e-02f, -1.98868547e-05f,
  -2.47334167e-02f, -2.14059255e-03f, -1.07828658e-02f, -2.59936694e-02f, -3.97878587e-02f, 5.83422929e-02f, -3.71679626e-02f, 4.62937984e-04f, 2.32966375e-02f, -2.21009483e-03f,
  9.59063135e-03f, -6.14963509e-02f, 4.51700874e-02f, 2.04348583e-02f, 2.48464923e-02f, -4.70366925e-02f, -1.24569973e-02f, 2.60897516e-03f, 6.51116967e-02f, -1.26326540e-02f,
  -4.05596048e-02f, -9.59647298e-02f, 1.86047144e-02f, 4.58284318e-02f, 3.25794779e-02f, -9.90384147e-02f, 3.33499052e-02f, -2.13587098e-02f, -1.04446046e-01f, -5.84656792e-03f,
  -7.59494230e-02f, -3.46750878e-02f, -4.84136045e-02f, -1.35418307e-02f, -5.10311350e-02f, -1.37806982e-02f, -1.29973823e-02f, -4.77357674e-03f, -3.65534378e-03f, 2.02948377e-02f,
  3.25244844e-01f, -3.62498909e-01f, 1.89399168e-01f, 3.58457072e-03f, 1.65721662e-02f, -1.75823525e-01f, 5.59211485e-02f, -1.39961213e-01f, -3.37075032e-02f, -3.18635613e-01f,
  2.02991031e-02f, -1.67966876e-02f, 1.63733348e-01f, -2.98632383e-01f, 3.44074219e-01f, 1.08189873e-01f, -2.71444350e-01f, -1.91094205e-01f, 8.74365345e-02f, -1.65235326e-02f,
  1.08876847e-01f, -1.58379644e-01f, 1.20821416e-01f, -1.93810239e-01f, -4.23511043e-02f, -1.77394114e-02f, 8.61368701e-02f, 1.80259407e-01f, -2.44699687e-01f, 1.52457468e-02f,
  -1.06251352e-01f, -8.89293663e-03f, -2.85097789e-02f, 1.96773466e-02f, 5.82526512e-02f, 1.10721895e-02f, 1.81988869e-02f, 1.00096270e-01f, 8.60271528e-02f, -3.88290826e-03f,
  -4.75635426e-03f, 1.92628093e-02f, -5.02380282e-02f, 2.59243306e-02f, -5.87049127e-02f, -2.24787351e-02f, 4.87094792e-03f, -2.26379707e-02f, -4.04164046e-02f, 6.41574934e-02f,
  6.18760213e-02f, -4.92510013e-03f, -3.71988746e-03f, -5.23430556e-02f, 9.43675041e-02f, 4.04545153e-03f, -1.63487755e-02f, 3.45876291e-02f, -6.35522678e-02f, -1.12701945e-01f,
  6.15967028e-02f, -2.63940152e-02f, 1.27414493e-02f, 2.66613606e-02f, -5.77236433e-03f, 4.93037850e-02f, -5.17095923e-02f, 2.23519485e-02f, 6.61961734e-02f, -8.85088276e-03f,
  1.41893998e-02f, 1.20368432e-02f, -4.83025201e-02f, -1.13035599e-02f, 2.90244371e-02f, -6.67131096e-02f, 9.92590487e-02f, 1.37081984e-02f, 2.29999069e-02f, 1.94754656e-02f,
  2.42120605e-02f, -1.16061615e-02f, 5.77498740e-03f, -9.04565956e-03f, -4.85915430e-02f, 1.01667494e-01f, -1.25838937e-02f, -5.28297108e-03f, -2.68381275e-03f, 4.00576442e-02f,
  -5.52703254e-02f, -1.27117202e-01f, 1.30371433e-02f, -6.60778284e-02f, -4.54677865e-02f, 3.65452468e-03f, -1.24471271e-02f, -6.44390956e-02f, 1.06386309e-02f, 1.97544601e-02f,
  -2.84589902e-02f, 8.25197250e-03f, -1.69296488e-02f, -1.80130769e-02f, -3.16500776e-02f, -3.45730805e-04f, 2.86079627e-02f, 8.37054290e-03f, -8.44405033e-03f, -4.56268005e-02f,
  -2.51502395e-02f, 4.24201833e-03f, 1.58096477e-02f, -7.32672885e-02f, -7.01638684e-02f, 3.15758213e-02f, -4.68432680e-02f, -1.76481996e-02f, 8.22602306e-03f, -4.72033843e-02f,
  3.72530133e-01f, -1.11354485e-01f, -2.84340605e-02f, 1.45626664e-01f, 1.52355820e-01f, 2.10284933e-01f, 2.79229909e-01f, 4.66385446e-02f, -6.54692873e-02f, -6.98800460e-02f,
  1.30922526e-01f, -5.82437404e-02f, 3.60071920e-02f, 8.34179744e-02f, 4.02955502e-01f, -8.84281024e-02f, 2.15154931e-01f, 3.84999402e-02f, -1.01362385e-01f, 1.63381070e-01f,
  6.10956736e-02f, 2.33522296e-01f, 1.20853692e-01f, -1.60964981e-01f, 1.63380116e-01f, -1.44802496e-01f, 1.55299574e-01f, -1.23081133e-01f, 2.37735752e-02f, 6.07492700e-02f,
  1.60557196e-01f, -9.74843726e-02f, -6.46576881e-02f, -8.59253109e-02f, 1.14107467e-01f, -3.99428653e-03f, 6.90795407e-02f, 4.86852415e-03f, 3.24366726e-02f, -7.29978736e-03f,
  -4.34983149e-02f, -3.20597216e-02f, -3.48244980e-02f, -7.66489059e-02f, -6.07408583e-02f, -4.00772206e-02f, -3.00707612e-02f, -2.47815531e-02f, -5.15834093e-02f, 3.89270601e-03f,
  -4.61204536e-02f, -4.21325630e-03f, 5.29297031e-02f, -6.94792345e-02f, 7.16877962e-03f, -3.87756824e-02f, 1.66478530e-02f, -2.64101997e-02f, -2.81849671e-02f, -2.02176124e-02f,
  -1.30566284e-01f, 2.62882002e-02f, 4.50390344e-03f, 2.30308082e-02f, 5.49176782e-02f, 2.12897304e-02f, -1.09006595e-02f, -8.15997366e-03f, 3.12654562e-02f, 6.36308864e-02f,
  2.05278900e-02f, 4.37741261e-03f, -2.87332367e-02f, 2.24986374e-02f, 1.09223630e-02f, 7.82996882e-03f, 2.88432334e-02f, 5.08705014e-03f, 1.45073095e-02f, -1.87317319e-02f,
  -1.56517066e-02f, 3.40888239e-02f, 1.33967223e-02f, -2.25543939e-02f, -9.84534342e-03f, 8.17417204e-02f, -3.28141600e-02f, 7.89894816e-03f, 2.13354873e-03f, 9.49768201e-02f,
  2.54278213e-01f, 1.01876244e-01f, 1.89661514e-02f, -1.23904971e-02f, -3.66360173e-02f, -2.87801828e-02f, -5.59530109e-02f, -5.78381345e-02f, 7.20227435e-02f, 3.45277712e-02f,
  2.00300850e-02f, 1.85791552e-02f, 4.34433967e-02f, 6.88042771e-03f, 3.52085456e-02f, 8.68784040e-02f, 5.72121702e-02f, 2.64497977e-02f, 4.41034548e-02f, 2.58375946e-02f,
  4.57584672e-02f, 1.53822584e-05f, -6.04613349e-02f, -1.69566609e-02f, -3.32455076e-02f, 3.33826952e-02f, 4.34221234e-03f, -6.92284778e-02f, -2.13916209e-02f, -3.76347676e-02f,
  1.28634393e-01f, 4.36111502e-02f, -1.68125536e-02f, -1.36310384e-01f, 1.35250106e-01f, 1.61961839e-01f, 1.22169323e-01f, -4.75811325e-02f, -1.16837263e-01f, 1.21232487e-01f,
  1.27243344e-02f, 4.23351489e-02f, -6.25405014e-02f, -1.42932847e-01f, -3.61463875e-01f, -2.10266635e-01f, -1.60183415e-01f, 1.44532714e-02f, -1.05615035e-01f, -2.17501298e-02f,
  -7.91476667e-02f, -1.66117940e-02f, -1.66964889e-01f, 2.40466688e-02f, 1.78498134e-01f, 1.50539605e-02f, -8.70600715e-02f, 5.99062815e-02f, 5.82524799e-02f, 6.09675832e-02f,
  -1.00931209e-02f, -2.54155584e-02f, 3.79380450e-04f, -1.62833072e-02f, -3.06589659e-02f, 8.17099437e-02f, 6.65389746e-02f, 1.22483377e-03f, -7.88047761e-02f, -2.94416603e-02f,
  3.88167500e-02f, -6.97739646e-02f, -1.62966270e-02f, -1.17858937e-02f, 9.31138769e-02f, -5.82716521e-03f, -1.14267692e-03f, 5.19398339e-02f, 4.31158161e-03f, 5.00933826e-02f,
  -1.16020143e-02f, -6.00583199e-03f, 2.72030253e-02f, -4.58214208e-02f, -3.63624748e-03f, -1.18994212e-04f, -1.32219782e-02f, 2.80166846e-02f, 2.08279602e-02f, -1.07088201e-02f,
  -1.70948133e-02f, 4.41304483e-02f, 6.35864660e-02f, -8.46967380e-03f, 3.15831555e-03f, -1.46398712e-02f, 3.22501361e-02f, 3.74651067e-02f, 9.44748148e-03f, 2.67913342e-02f,
  -3.28448191e-02f, -1.56673999e-03f, 1.11083919e-02f, 1.49890222e-02f, 1.53756645e-02f, 7.77919171e-03f, -2.25713644e-02f, 5.62568977e-02f, -1.91206019e-02f, -7.51694664e-03f,
  2.57615605e-03f, -3.66401039e-02f, 6.16315529e-02f, 3.01176049e-02f, -2.15624850e-02f, -6.54902589e-03f, -4.10896959e-03f, 2.22817957e-02f, -3.79959233e-02f, 2.82561705e-02f,
  -6.44461140e-02f, -8.68508443e-02f, -1.30636049e-02f, 2.09044479e-03f, -1.99729484e-02f, 1.43305464e-02f, 1.95557810e-02f, -1.83957610e-02f, -2.69551110e-02f, 3.07893823e-03f,
  -2.26243977e-02f, 1.42460242e-02f, 3.14134806e-02f, 1.57204289e-02f, -6.58619255e-02f, -4.13392438e-03f, 1.67446770e-02f, -3.81997344e-03f, -1.31120076e-02f, -1.32354386e-02f,
  2.90592387e-02f, 1.97449941e-02f, -5.18335141e-02f, 1.65578406e-02f, 3.85861769e-02f, 8.22825730e-02f, 2.38378365e-02f, 3.99706066e-02f, -2.26038937e-02f, -1.88435391e-02f,
  4.79990155e-01f, -1.91360399e-01f, 7.54412934e-02f, 1.75465792e-01f, 8.24465528e-02f, -3.65475059e-01f, -1.06605627e-01f, -1.83782410e-02f, 2.90253490e-01f, -2.65148640e-01f,
  -8.40187147e-02f, 1.03451461e-01f, -2.99013741e-02f, -2.58704394e-01f, -6.81557059e-02f, -1.52556852e-01f, -1.34636849e-01f, -8.81880820e-02f, 1.23278596e-01f, 5.65488115e-02f,
  1.12557650e-01f, -2.00516373e-01f, -9.57532227e-02f, -1.36926264e-01f, 2.90954653e-02f, 9.10723731e-02f, -5.26017323e-02f, 4.15539332e-02f, -2.07979903e-01f, -1.08209118e-01f,
  -5.93101084e-02f, 8.08985308e-02f, 3.06559540e-02f, -4.83729132e-02f, -1.52401961e-02f, -1.42292641e-02f, -6.85311630e-02f, -2.34283078e-02f, 4.55096550e-02f, 1.62030496e-02f,
  1.49994316e-02f, 2.24293880e-02f, 7.89165404e-03f, -6.34508813e-03f, 4.33455519e-02f, 3.54397371e-02f, 2.60394067e-02f, -1.79555323e-02f, 3.84679064e-04f, 2.17443742e-02f,
  7.16278479e-02f, -2.94108223e-02f, 1.02006970e-02f, -4.18023728e-02f, 2.73119640e-02f, 2.82815993e-02f, -8.30626339e-02f, 1.70393195e-02f, -2.34834012e-03f, 1.14946738e-02f,
  2.11250167e-02f, -1.17761446e-02f, 1.77423842e-02f, -3.45845930e-02f, -1.22653302e-02f, 4.08938974e-02f, 1.80796646e-02f, -6.60684481e-02f, 4.54805903e-02f, -2.98841279e-02f,
  4.99827638e-02f, 2.67845038e-02f, -1.89022850e-02f, -8.46786797e-03f, 3.23687270e-02f, -7.26498058e-03f, 1.88374482e-02f, -1.30957887e-02f, 7.27089942e-02f, -1.35118805e-03f,
  1.62813216e-02f, 1.35451071e-02f, -5.14102727e-03f, 1.35984682e-02f, -6.67284057e-02f, 1.53181395e-02f, -1.82631873e-02f, 6.86368439e-03f, -7.29956292e-03f, 9.61699430e-03f,
  -1.42796502e-01f, -9.00956914e-02f, 2.41783280e-02f, -3.17868926e-02f, 1.25847794e-02f, 2.80155577e-02f, -8.05118680e-03f, -1.22517142e-02f, 2.27931123e-02f, 1.05836047e-02f,
  -1.89782139e-02f, 2.43133418e-02f, -9.31574963e-03f, -1.19335074e-02f, -1.67779140e-02f, -5.15189245e-02f, -3.26807983e-02f, 4.96777408e-02f, -2.84731872e-02f, -9.50744189e-03f,
  9.68419574e-03f, 3.42375971e-02f, -2.56163273e-02f, 1.12450495e-02f, -1.89638548e-02f, -1.15890373e-02f, -7.01971678e-03f, 5.61981089e-02f, -2.52613239e-02f, 2.13407930e-02f,
  2.34340876e-01f, -3.42957228e-01f, -7.42098615e-02f, -1.84279010e-02f, 3.02982658e-01f, 1.97559580e-01f, -5.81169389e-02f, 2.18164045e-02f, -1.69667870e-01f, -2.78679818e-01f,
  1.16754442e-01f, -2.05844507e-01f, -1.16508491e-01f, -1.87004656e-02f, 2.61092752e-01f, -1.22533157e-01f, 1.10345051e-01f, 2.72206236e-02f, 4.64970917e-02f, 9.59049389e-02f,
  8.60192254e-02f, 2.36805826e-01f, 6.77064806e-02f, 1.46852776e-01f, 1.81496501e-01f, 3.88940352e-05f, 1.14074349e-01f, -2.42261253e-02f, 6.39751852e-02f, 6.26466423e-02f,
  -2.06980649e-02f, -8.36318508e-02f, 1.72468722e-02f, 1.13462964e-02f, 4.03733328e-02f, 2.25539915e-02f, 4.84667271e-02f, 8.00613761e-02f, 6.51225401e-03f, -1.87535882e-02f,
  6.43646270e-02f, 5.26002832e-02f, -2.69569363e-03f, -1.76727790e-02f, -1.83227748e-04f, -6.39096787e-03f, -3.25863808e-02f, 4.21801060e-02f, -9.58034024e-02f, -8.69969092e-03f,
  -4.74725105e-02f, 3.32038477e-02f, 9.38151479e-02f, -2.39651985e-02f, 6.73576631e-03f, 2.21761279e-02f, -1.56225786e-02f, -1.23018064e-02f, 2.65778359e-02f, -2.35908721e-02f,
  4.72491235e-02f, 2.74377633e-02f, 2.45091543e-02f, 2.93072928e-02f, -4.37304676e-02f, 2.27718633e-02f, 4.90233861e-02f, 3.14737894e-02f, -2.63122451e-02f, 1.71714909e-02f,
  1.38602136e-02f, -2.37634834e-02f, 7.98850320e-04f, -4.27118735e-03f, -1.54457185e-02f, -3.48440954e-03f, 8.24102685e-02f, -3.77546921e-02f, -2.17122342e-02f, 2.50192955e-02f,
  1.59764197e-02f, 1.38669740e-03f, -6.86689094e-02f, 2.65389495e-02f, 4.21697237e-02f, -1.50079897e-03f, -3.23016867e-02f, -7.71429092e-02f, -1.39885126e-02f, 7.43664503e-02f,
  -8.45322162e-02f, -2.05852315e-01f, -8.97927955e-02f, 1.89687370e-03f, -6.26303330e-02f, 6.48595616e-02f, 5.12351235e-03f, 3.47998738e-02f, 1.37976408e-02f, 7.53851235e-03f,
  3.54073383e-02f, -1.46061573e-02f, 4.14383188e-02f, 4.34838459e-02f, 4.83451150e-02f, -4.01547663e-02f, -2.37110592e-02f, -2.73244455e-02f, 5.26047349e-02f, -7.27113569e-04f,
  8.94012395e-03f, 2.29137056e-02f, 1.65172992e-03f, 6.61945567e-02f, 3.28550003e-02f, 1.32671127e-03f, 5.76826651e-03f, -3.46422642e-02f, 7.43198842e-02f, 8.16676579e-03f,
  2.09071532e-01f, 7.90016949e-02f, 1.48683742e-01f, 1.56211600e-01f, 6.83504045e-02f, -1.24013960e-01f, -7.74548873e-02f, -1.18761711e-01f, -1.60893127e-01f, -4.28865850e-02f,
  -1.17864430e-01f, 2.71437347e-01f, -2.91884631e-01f, 1.30079448e-01f, 3.85790803e-02f, -2.76884377e-01f, 2.76144519e-02f, -1.62506104e-02f, -5.00338599e-02f, 5.69801219e-02f,
  1.19575020e-02f, 6.22738004e-02f, -7.14086294e-02f, 1.98235903e-02f, 2.69379675e-01f, 1.76663294e-01f, 2.82979399e-01f, 6.69634864e-02f, 3.91015381e-01f, 1.19212732e-01f,
  -4.44267876e-02f, -6.41932264e-02f, 3.79283428e-02f, -8.49774852e-03f, -7.04381568e-03f, -4.60878946e-02f, 1.23004310e-01f, 3.48263681e-02f, -6.69298097e-02f, -2.38051843e-02f,
  -2.28286386e-02f, 6.97151795e-02f, 6.23114631e-02f, -9.57361981e-02f, 3.43335932e-03f, 1.12037845e-01f, 7.46768415e-02f, 2.15405179e-03f, 5.91237098e-02f, -3.51958238e-02f,
  1.63911469e-02f, 2.49688569e-02f, 3.86909097e-02f, 1.42719284e-01f, 8.46858099e-02f, 6.16861461e-03f, 3.98238227e-02f, 1.15205400e-01f, 9.94513333e-02f, 5.19562662e-02f,
  -1.60124470e-02f, -2.98727769e-02f, -4.18288782e-02f, -7.54053220e-02f, -4.62256074e-02f, 2.58423598e-03f, -2.28887964e-02f, -4.86679003e-02f, 1.01023642e-02f, 1.18367178e-02f,
  1.93510042e-03f, -3.99020538e-02f, 2.72553042e-03f, -4.14665751e-02f, -5.42513318e-02f, -3.95269878e-02f, -2.40018126e-02f, 5.43586165e-02f, 2.30841190e-02f, -5.41491546e-02f,
  -1.21937720e-02f, 3.98069918e-02f, 6.44484069e-03f, 2.84266304e-02f, -5.13341762e-02f, 4.95335599e-03f, 7.66924247e-02f, 1.17990281e-03f, -4.78608087e-02f, -1.04941791e-02f,
  1.65763780e-01f, 1.88191459e-01f, -6.40398413e-02f, 8.72237608e-02f, -2.09424961e-02f, 2.19270773e-02f, 5.29649714e-03f, 3.87798585e-02f, 3.48695107e-02f, -2.76423004e-02f,
  -7.53016211e-03f, 1.14416573e-02f, 1.42432824e-01f, 3.78640294e-02f, -3.66290435e-02f, 3.34431119e-02f, 4.75725234e-02f, 1.04829080e-01f, 2.06264928e-02f, 5.16206073e-03f,
  1.53148286e-02f, -2.33562980e-02f, -1.12174675e-01f, 1.31854173e-02f, -2.48825806e-03f, -1.12022422e-02f, -8.13240942e-04f, -1.04631232e-02f, 9.88598913e-02f, 5.21219410e-02f,
  1.60635069e-01f, -1.93150062e-02f, 3.67855400e-01f, -1.06436335e-01f, -1.47997379e-01f, 1.05751142e-01f, 5.52088469e-02f, -2.26930261e-01f, 8.54613725e-03f, -1.93331853e-01f,
  -2.34077737e-01f, 4.23998013e-02f, 4.58305217e-02f, -3.15397590e-01f, 4.02144454e-02f, 4.07651663e-02f, -2.27059796e-01f, -6.40346855e-02f, -1.60009768e-02f, -1.41602904e-01f,
  4.82686013e-02f, -3.73517752e-01f, 1.06624262e-02f, -2.10135236e-01f, -1.34575397e-01f, 4.77115363e-02f, -1.82469666e-01f, 1.11590184e-01f, -1.81605116e-01f, -3.78615111e-02f,
  1.12965321e-02f, -3.56856957e-02f, 8.02464932e-02f, 9.64784250e-02f, 2.51313318e-02f, 4.54191864e-02f, 1.20319948e-01f, 3.86898629e-02f, 1.84301287e-02f, 1.75016336e-02f,
  7.18961656e-02f, -2.32272930e-02f, -5.84845655e-02f, 3.11853178e-02f, -2.42251307e-02f, 6.83422908e-02f, -2.76518054e-02f, 5.24197742e-02f, -3.32424976e-02f, 4.15567867e-02f,
  5.10836914e-02f, 9.18667987e-02f, 2.09763478e-02f, -3.05106472e-02f, 2.65328716e-02f, -2.73902714e-02f, 5.74507341e-02f, 7.94495121e-02f, -7.21547054e-04f, -2.50955671e-02f,
  -1.01735117e-02f, 2.57939976e-02f, 7.71916797e-03f, -2.36122854e-04f, -1.35413278e-02f, -4.14406545e-02f, -6.19066469e-02f, -2.22880002e-02f, 3.74586955e-02f, -2.10077669e-02f,
  -2.82089580e-02f, 4.40143123e-02f, -2.93846391e-02f, -1.55224465e-02f, 2.43018810e-02f, 5.91638200e-02f, 8.29410478e-02f, -1.93069186e-02f, -3.81935108e-03f, 6.98150555e-03f,
  1.96629185e-02f, -3.65467221e-02f, 1.60861444e-02f, 2.92174574e-02f, 5.28916121e-02f, 8.72523896e-03f, -9.89451557e-02f, 2.08357461e-02f, -6.44594133e-02f, 2.24905536e-02f,
  -1.25879601e-01f, -1.01489820e-01f, 1.95357651e-02f, -6.04749806e-02f, -1.02536590e-03f, 4.99772429e-02f, 4.32048254e-02f, -3.51151340e-02f, -2.02720519e-03f, -3.04430537e-02f,
  2.50270497e-03f, 4.73560877e-02f, -1.44630030e-03f, -6.38239607e-02f, -3.35533805e-02f, -2.09528934e-02f, 1.50756715e-02f, 2.03559790e-02f, -2.32683425e-03f, -7.03721046e-02f,
  -3.46879736e-02f, -2.64658444e-02f, 6.43600523e-02f, -1.68371014e-02f, -9.45615843e-02f, -5.21640619e-03f, -2.38586143e-02f, 2.72053424e-02f, -1.03608314e-02f, -1.38687743e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.89743280e-01f, 8.53568688e-02f, -2.26042315e-01f, -5.33616841e-02f, -1.08831540e-01f, 1.77936137e-01f, 1.23134866e-01f, 1.67349670e-02f, 2.96649523e-02f, 2.96734542e-01f,
  2.15091363e-01f, 5.65540642e-02f, 1.30283132e-01f, 2.21387178e-01f, -6.17577657e-02f, 9.88531709e-02f, 1.26180440e-01f, 1.15376048e-01f, -4.42035832e-02f, 1.05552264e-01f,
  -3.83663177e-02f, 2.24555239e-01f, -4.88593653e-02f, 2.89408471e-02f, 1.12258777e-01f, -1.16595931e-01f, -1.91739909e-02f, -1.36846215e-01f, 7.32820407e-02f, 1.06927985e-02f,
  1.52375903e-02f, 4.24480252e-02f, -2.35701166e-02f, -2.78255530e-02f, -9.57536139e-03f, -5.74616203e-03f, -1.76006965e-02f, -7.85881281e-02f, -1.14069544e-01f, -1.57475155e-02f,
  5.93256839e-02f, 3.69068497e-04f, 3.37747447e-02f, -3.28488424e-02f, -1.77765805e-02f, -4.52895164e-02f, 4.28849412e-03f, 1.47535512e-02f, -1.00420034e-02f, 7.14104250e-02f,
  1.45297581e-02f, -6.42966777e-02f, 1.84155498e-02f, -2.92371381e-02f, -3.09175416e-03f, -9.31272469e-03f, 1.59155671e-02f, 5.29750541e-04f, 1.60271674e-02f, -5.08968271e-02f,
  -1.17901864e-03f, 5.20663895e-02f, 1.10100145e-02f, 1.78990234e-02f, -2.56238170e-02f, -8.19920003e-02f, 4.91892174e-02f, -6.32433221e-03f, -2.55699754e-02f, 1.89373642e-02f,
  -2.21341290e-02f, -2.85195634e-02f, 3.02349497e-03f, 2.90471446e-02f, 6.68585747e-02f, 4.65308204e-02f, -6.66545995e-04f, 3.24725285e-02f, -1.62790436e-02f, 5.51466830e-02f,
  -1.42633310e-02f, 2.10225508e-02f, 2.32189260e-02f, 3.97881456e-02f, 7.85363186e-03f, 3.59051935e-02f, 7.38991797e-02f, 4.76242416e-02f, -3.46484818e-02f, 2.31509190e-03f,
  6.66350573e-02f, 8.82270634e-02f, 1.91272218e-02f, -8.35356638e-02f, -8.10243264e-02f, 1.38166891e-02f, 2.91684438e-02f, -2.44712699e-02f, 3.47536467e-02f, -1.50260543e-02f,
  6.06549680e-02f, -2.87932716e-02f, 3.00410460e-03f, 2.59346142e-02f, -4.91578840e-02f, 8.09621736e-02f, 3.44621204e-02f, -6.50266036e-02f, 1.32396156e-02f, 5.38142361e-02f,
  2.07719654e-02f, 2.29869448e-02f, 1.17482720e-02f, -3.58412750e-02f, 6.90158037e-03f, 1.58010144e-02f, 6.13224544e-02f, 1.60145294e-03f, 6.14978746e-03f, -4.29549478e-02f,
  1.20746531e-01f, -4.39496823e-02f, -2.17575833e-01f, -2.78741658e-01f, -9.09378007e-02f, -2.88285941e-01f, -2.48723119e-01f, -3.75399552e-02f, 3.44982743e-02f, 6.26063272e-02f,
  1.85635183e-02f, -1.17449924e-01f, 9.95567963e-02f, -2.77798951e-01f, -1.54134974e-01f, 1.78534593e-02f, -3.46308082e-01f, -2.38812238e-01f, 9.30865388e-03f, -1.66955784e-01f,
  -2.61138380e-02f, -6.41563535e-02f, -2.22012773e-01f, 3.64068188e-02f, -1.59557968e-01f, 1.22614438e-02f, 1.26155421e-01f, 6.16116449e-02f, -1.54656515e-01f, -2.40514744e-02f,
  -1.25124738e-01f, 6.75209016e-02f, -2.93070935e-02f, -8.85421410e-04f, -4.80174161e-02f, -2.52221338e-03f, -7.29693696e-02f, -2.67650709e-02f, 2.45165229e-02f, -3.68975215e-02f,
  -7.66644254e-02f, 2.01370977e-02f, -2.41310168e-02f, 9.77495387e-02f, 4.13243950e-04f, -1.24593712e-02f, -9.62255523e-03f, -2.61539388e-02f, -1.17566764e-01f, -9.98703646e-04f,
  -9.71402526e-02f, -5.58765195e-02f, -2.38932706e-02f, -3.44477147e-02f, 4.27893139e-02f, -1.07616801e-02f, -6.97607994e-02f, -1.03214368e-01f, 1.87320113e-02f, 2.93704495e-03f,
  8.40101484e-03f, 3.89661058e-03f, -5.58519969e-03f, 1.13067105e-01f, -9.21168830e-03f, -3.13062593e-02f, 3.87735814e-02f, -2.58811321e-02f, 2.53313463e-02f, -4.32979353e-02f,
  -7.33044446e-02f, 1.60014629e-02f, 5.38235269e-02f, -4.24709953e-02f, -4.92423847e-02f, -5.41388951e-02f, -6.66594580e-02f, 3.52882892e-02f, -7.86373317e-02f, -5.53884655e-02f,
  9.39554349e-02f, -1.48007888e-02f, -3.79703343e-02f, 7.08094519e-03f, -2.06868015e-02f, 1.66684818e-02f, 3.36903147e-02f, -4.15491574e-02f, 2.66033616e-02f, 2.08674744e-02f,
  -2.26541031e-02f, 3.84174362e-02f, -9.02578421e-03f, 4.14843149e-02f, -5.31874672e-02f, -2.85085267e-03f, -1.47487354e-02f, -2.58702058e-02f, -5.77045009e-02f, 5.46956109e-03f,
  -5.13221212e-02f, -1.02860115e-01f, 4.74893264e-02f, 7.41006508e-02f, 8.55918787e-03f, -6.09211856e-03f, 1.70109309e-02f, -8.21675360e-03f, -1.62357509e-01f, 4.45798747e-02f,
  -2.15551220e-02f, -1.36615597e-02f, -1.72792934e-02f, -8.30597058e-02f, -6.77463040e-03f, 2.37254146e-02f, 1.77283809e-02f, -1.40118152e-02f, 3.61252986e-02f, -2.33519878e-02f,
  2.58637190e-01f, -3.61143589e-01f, 1.28008708e-01f, 2.18395725e-01f, 2.30196878e-01f, -3.35230865e-02f, 2.59831190e-01f, 1.86401494e-02f, 3.20666254e-01f, -3.38323593e-01f,
  -1.53863966e-01f, -4.31579463e-02f, -4.89660427e-02f, -1.39120668e-01f, 3.08226824e-01f, 9.23397467e-02f, -5.14789969e-02f, 3.53870057e-02f, 1.41634941e-01f, -4.15269509e-02f,
  8.97271261e-02f, -1.13200650e-01f, 4.05521207e-02f, -2.43846506e-01f, -1.06976807e-01f, -5.40882125e-02f, -1.32819757e-01f, 5.21086529e-02f, -2.51049787e-01f, 5.35662137e-02f,
  -1.07936420e-01f, 7.85296224e-03f, -3.47829908e-02f, -5.07557467e-02f, -7.03478158e-02f, -1.34189678e-02f, 7.00855553e-02f, 5.94885163e-02f, 8.75089839e-02f, 8.20244383e-03f,
  -1.11305341e-02f, 1.52600911e-02f, -6.68876916e-02f, 1.56140495e-02f, 5.07383794e-03f, 6.98897615e-03f, 2.28319429e-02f, -5.04521765e-02f, 2.56590396e-02f, 3.17891240e-02f,
  5.88119477e-02f, -7.47213140e-02f, -8.20274279e-02f, -5.81726804e-02f, -1.35889901e-02f, 8.23129993e-03f, 3.55864912e-02f, -3.80933471e-02f, -4.52591525e-03f, 6.19145185e-02f,
  8.11488181e-02f, 2.37071645e-02f, -1.30493157e-02f, 1.85483713e-02f, 2.38222536e-03f, 2.16593761e-02f, -1.60471676e-03f, -1.25555554e-02f, -2.22171657e-02f, 1.06541859e-02f,
  -2.13158578e-02f, -1.84991360e-02f, 5.59068285e-02f, 3.28422226e-02f, 4.84811217e-02f, 1.92594603e-02f, -3.16036791e-02f, -3.61014493e-02f, -1.02307200e-02f, 2.16023363e-02f,
  1.64382644e-02f, 2.40272973e-02f, -6.04203045e-02f, 1.19197056e-01f, -2.26073451e-02f, 7.69687584e-03f, -6.74287081e-02f, -4.52309176e-02f, 4.37245183e-02f, -2.76105776e-02f,
  -2.25221023e-01f, -1.70613706e-01f, -7.20372796e-02f, -1.07779931e-02f, 1.82947684e-02f, -1.04437247e-01f, 5.28738722e-02f, -1.47170555e-02f, -5.40566593e-02f, 4.10367139e-02f,
  -1.71866640e-02f, -2.61315070e-02f, -1.75682958e-02f, 5.13721444e-02f, -5.30977286e-02f, 2.53694579e-02f, 1.06519125e-02f, -1.19367793e-01f, -3.81679125e-02f, -5.22276945e-02f,
  -4.03233841e-02f, 4.36022645e-03f, -1.41773196e-02f, -8.85859877e-03f, -6.04613237e-02f, -7.25882426e-02f, -2.91002076e-02f, -2.56720353e-02f, 4.89378460e-02f, -2.34600492e-02f,
  -2.28682086e-01f, 2.77684867e-01f, 1.33784920e-01f, -1.25249818e-01f, 2.30011791e-01f, 4.36974376e-01f, -1.71236880e-02f, 2.38785475e-01f, 2.12761015e-01f, 1.46235302e-02f,
  7.65045434e-02f, -1.05101183e-01f, -4.03965823e-02f, -8.30202028e-02f, 1.93280846e-01f, 8.06754548e-03f, 1.23342454e-01f, 3.12040206e-02f, 5.58977108e-03f, -4.96211201e-02f,
  -4.85772081e-02f, -4.53906618e-02f, -2.28637099e-01f, -3.11861858e-02f, -6.06002286e-02f, -1.64497480e-01f, -1.90211102e-01f, -1.40012354e-01f, -8.59193951e-02f, 5.50806336e-02f,
  -1.34307370e-02f, -7.72844553e-02f, -1.71293303e-01f, -3.27549167e-02f, 5.76362200e-02f, -4.65092808e-02f, 4.63433079e-02f, 2.69430391e-02f, -4.14830409e-02f, 4.28135172e-02f,
  -5.53316586e-02f, -6.41808212e-02f, 4.51922342e-02f, 1.65942237e-02f, -1.29587660e-02f, 6.43296391e-02f, -2.20362656e-02f, 2.28055194e-02f, -4.75555174e-02f, 3.25744487e-02f,
  2.24178042e-02f, 6.94567338e-02f, 2.92986482e-02f, 8.18682015e-02f, -1.32360319e-02f, -4.18340042e-02f, 1.69127081e-02f, -7.64794415e-03f, 6.89354464e-02f, -6.88527664e-03f,
  1.57266762e-02f, 1.22678168e-01f, -1.90608501e-02f, 1.84505973e-02f, -1.43372761e-02f, 3.40713784e-02f, -2.59102904e-03f, 2.51906179e-02f, -3.84356566e-02f, -1.99111793e-02f,
  -2.34070737e-02f, -6.40748218e-02f, 4.61737718e-03f, 1.84698794e-02f, -1.24458717e-02f, -6.57519475e-02f, -2.88132280e-02f, -3.81445736e-02f, 5.94194606e-02f, 2.85098013e-02f,
  1.24862161e-03f, 5.94896525e-02f, -9.32974815e-02f, 1.88958608e-02f, -1.06137735e-03f, -4.16047610e-02f, 6.50099516e-02f, -1.01794908e-02f, 3.74417868e-03f, 2.44651157e-02f,
  2.08809823e-01f, 3.32564116e-01f, -5.60596287e-02f, -7.84426332e-02f, -7.08509237e-02f, 2.22896226e-02f, 5.93976974e-02f, 1.23378530e-01f, 8.73272493e-02f, 5.22594824e-02f,
  1.46142682e-02f, -7.41628259e-02f, 1.22085676e-01f, -7.47120678e-02f, -1.67749301e-02f, 1.54854655e-01f, -2.64066719e-02f, 2.77016386e-02f, 1.15335047e-01f, 5.28730266e-02f,
  7.84457009e-03f, -4.72769365e-02f, 1.33226477e-02f, 1.01352118e-01f, 4.48155142e-02f, -3.66384014e-02f, 9.74176303e-02f, -7.77082071e-02f, 2.44685039e-02f, 5.53379171e-02f,
  1.58823580e-01f, -6.28491119e-02f, -2.59817421e-01f, -1.99722424e-01f, 4.05541733e-02f, -3.39161724e-01f, -2.19039977e-01f, -1.77998558e-01f, 6.64634407e-02f, -6.93751425e-02f,
  -8.49988014e-02f, 1.56148314e-01f, 2.02679634e-01f, -1.95674270e-01f, -1.36104897e-02f, 1.22665077e-01f, -2.65599102e-01f, -4.02233005e-02f, 1.19623788e-01f, -8.77243504e-02f,
  -4.28529941e-02f, -3.91177982e-02f, -1.13104716e-01f, -6.66160211e-02f, -1.67071685e-01f, -9.65760723e-02f, 1.23967240e-02f, -5.41848801e-02f, -1.91368371e-01f, 5.34033589e-02f,
  -3.30345258e-02f, 4.51405384e-02f, -1.76370610e-02f, -3.79709378e-02f, -1.10821776e-01f, 2.26022005e-02f, -4.66404185e-02f, 9.25258547e-03f, 1.23207361e-01f, -1.60133075e-02f,
  6.21403679e-02f, 1.24487266e-01f, 2.96311965e-03f, 7.90612474e-02f, 3.58451270e-02f, -5.30664288e-02f, 6.18360844e-03f, -2.26603150e-02f, 4.85306606e-02f, -3.78347710e-02f,
  -1.40552334e-02f, -1.83788612e-02f, -2.38404367e-02f, 3.75486389e-02f, 3.37256379e-02f, -5.12556471e-02f, -4.66160029e-02f, -1.16801718e-02f, -6.83107898e-02f, 1.19435415e-02f,
  -2.88310349e-02f, 2.86481306e-02f, 3.77127761e-03f, 2.10709241e-03f, 2.96978727e-02f, 6.33634180e-02f, -9.87465121e-03f, 3.61629687e-02f, -2.69467533e-02f, -4.11126111e-03f,
  7.16237053e-02f, 3.81848179e-02f, 5.48328552e-03f, -6.28045052e-02f, -5.41529655e-02f, 6.94872960e-02f, 5.27681634e-02f, -3.95174660e-02f, 1.93057526e-02f, -6.10991083e-02f,
  2.46934295e-02f, -3.94018851e-02f, 5.70039749e-02f, -5.79409488e-02f, -6.60183057e-02f, 6.26716763e-02f, 4.21448089e-02f, -4.48014960e-02f, -9.80124697e-02f, 3.07358224e-02f,
  -6.72713891e-02f, -1.70144349e-01f, 2.45295512e-03f, 2.59541515e-02f, -4.40720804e-02f, -4.29866165e-02f, -1.96134951e-02f, -3.51639464e-02f, -4.18510959e-02f, -2.47809254e-02f,
  -6.05316535e-02f, 7.85507169e-03f, -2.07063612e-02f, -8.78376327e-03f, 7.21245036e-02f, -3.56388465e-02f, 2.94569898e-02f, 7.37094283e-02f, -4.92230020e-02f, -2.46100351e-02f,
  1.34267770e-02f, 5.37840538e-02f, 5.93394451e-02f, 4.07703854e-02f, 2.11193189e-02f, -1.82569083e-02f, -3.09675708e-02f, 6.52650148e-02f, -1.21353427e-02f, 3.05322129e-02f,
  -7.10801035e-03f, -2.13388398e-01f, -1.71259731e-01f, -8.36554840e-02f, 3.60950418e-02f, 4.98421118e-02f, -2.01586321e-01f, 4.36725467e-02f, -2.31702939e-01f, -4.57964465e-02f,
  2.39479858e-02f, -1.57617345e-01f, -2.32349366e-01f, -2.00679787e-02f, 7.30315745e-02f, -2.89249241e-01f, 1.61205590e-01f, 1.04148582e-01f, -9.62126255e-02f, 1.37753755e-01f,
  3.41871195e-02f, 1.51142105e-01f, 3.84029001e-02f, 3.06844026e-01f, 9.38351825e-02f, 1.77213535e-01f, 2.91092396e-01f, 6.72208071e-02f, 2.82618552e-01f, 5.56920916e-02f,
  -4.21634130e-02f, -1.27275690e-01f, -1.65888947e-02f, 1.22115221e-02f, 6.36545494e-02f, 3.84927318e-02f, 1.23620234e-01f, -3.43562737e-02f, 5.51960617e-03f, -4.80411462e-02f,
  1.66923311e-02f, 4.43519130e-02f, -2.67863423e-02f, 7.98458979e-03f, 1.45990252e-02f, 2.19105761e-02f, -2.22485717e-02f, -6.90202117e-02f, -6.54998375e-03f, -1.16858058e-01f,
  -1.48280829e-01f, -6.29797727e-02f, 4.53244783e-02f, -1.72269177e-02f, -8.70281272e-03f, -4.38093999e-03f, 5.71154570e-03f, 3.66213880e-02f, -1.37256747e-02f, 1.48141086e-02f,
  -1.62869936e-03f, 2.90848650e-02f, -3.60230356e-02f, -1.15384519e-01f, -2.12595202e-02f, 1.45431068e-02f, -1.97286461e-03f, 1.34317176e-02f, -6.48825765e-02f, 3.16113643e-02f,
  2.33396664e-02f, -1.64064113e-02f, -5.08652674e-03f, -4.65991013e-02f, 4.59581502e-02f, -9.83357523e-03f, 5.63713424e-02f, 4.63148206e-03f, 2.06227563e-02f, -8.78036320e-02f,
  -1.03805996e-01f, 5.81989549e-02f, -4.13443288e-03f, 2.11321823e-02f, -7.54069444e-03f, -1.43660810e-02f, 1.21499356e-02f, 3.19810808e-02f, -3.16007808e-02f, 1.25224069e-02f,
  4.47837859e-02f, 1.68990597e-01f, -2.04391889e-02f, 1.30094737e-02f, -3.14013846e-02f, 3.76755334e-02f, -1.93946213e-02f, 7.42893480e-03f, 9.01072323e-02f, 6.32070601e-02f,
  1.20715030e-01f, -2.97502294e-04f, -3.13649811e-02f, -4.23507355e-02f, 7.75259882e-02f, 5.08432686e-02f, 3.95862274e-02f, 7.40159154e-02f, 1.26245528e-01f, 3.91401723e-02f,
  5.86744361e-02f, -4.74089943e-02f, 2.89910100e-02f, -7.76508301e-02f, 3.60116288e-02f, -1.52463121e-02f, 1.42660020e-02f, 3.21121067e-02f, -3.96459829e-03f, -2.18474064e-02f,
  1.71264634e-01f, 1.80555478e-01f, -1.41388088e-01f, -2.18873352e-01f, -9.67531726e-02f, 3.19153130e-01f, 8.14408511e-02f, 5.25358059e-02f, 7.38704056e-02f, 1.18022889e-01f,
  -5.81513271e-02f, 1.13861538e-01f, 1.84497386e-02f, -4.48665097e-02f, 3.49577740e-02f, 3.75051238e-02f, 2.50243116e-04f, 2.75752433e-02f, -1.60897523e-02f, 8.39913711e-02f,
  -5.91415018e-02f, 9.71684083e-02f, -3.11686695e-01f, 1.38760805e-01f, -2.31466163e-02f, 5.97291254e-03f, -2.17204392e-01f, -4.97679189e-02f, -3.52564380e-02f, 6.08296774e-04f,
  -9.14244875e-02f, 3.05905305e-02f, -2.63152048e-02f, 6.56233281e-02f, 2.29580025e-03f, 1.78318396e-02f, -7.30439648e-02f, 2.26706383e-03f, -1.03064597e-01f, 5.83609147e-03f,
  3.84476930e-02f, 9.01058763e-02f, 9.66802090e-02f, -2.43583117e-02f, 1.55655779e-02f, 4.63247262e-02f, -4.87624109e-02f, -8.45238715e-02f, 5.05278120e-03f, -1.38620446e-02f,
  -4.81677614e-02f, 1.66615974e-02f, -3.22819836e-02f, -3.46140377e-02f, -4.02952023e-02f, -1.52458437e-02f, 3.06075905e-02f, -2.67067831e-02f, 2.52063870e-02f, 7.34447092e-02f,
  8.32266435e-02f, -9.35544842e-04f, 8.96593332e-02f, 5.13355285e-02f, -7.22423047e-02f, -5.30706458e-02f, -1.39457220e-02f, -1.10274907e-02f, 6.26994222e-02f, 5.38690761e-02f,
  -1.86846275e-02f, -4.53785136e-02f, -3.38678882e-02f, 6.31759688e-02f, -1.59223266e-02f, 4.51561771e-02f, -1.20721674e-02f, 1.47910258e-02f, -4.00642529e-02f, -5.40721342e-02f,
  -6.15581945e-02f, -3.89906042e-03f, 3.79818939e-02f, -1.50759637e-01f, 2.73289485e-03f, -6.95953369e-02f, 4.66991439e-02f, -9.19639245e-02f, -4.71116528e-02f, 3.36602218e-02f,
  9.72287953e-02f, 2.81673282e-01f, 8.53736922e-02f, 8.39972720e-02f, -1.77707020e-02f, 9.05353054e-02f, 6.47861809e-02f, 2.70315502e-02f, 4.52534780e-02f, 1.37902454e-01f,
  3.68182990e-03f, 2.79405154e-02f, 1.80539861e-02f, -4.39631827e-02f, -1.96330808e-02f, 1.04092419e-01f, -2.90516093e-02f, -7.78182298e-02f, -5.37089407e-02f, 1.51470006e-02f,
  -6.20325794e-03f, 8.29222277e-02f, 1.00444611e-02f, -6.03782833e-02f, 3.97133082e-02f, -2.23878142e-03f, 8.64059329e-02f, -4.16287184e-02f, -6.08831272e-02f, -6.91084564e-02f,
  -2.51263559e-01f, 1.32691696e-01f, 9.81238112e-02f, 2.57702172e-01f, -4.57563728e-01f, 1.95453316e-02f, 3.75739902e-01f, -1.74307674e-01f, 1.84885085e-01f, 2.43382558e-01f,
  -1.01687163e-01f, -3.26781236e-02f, 1.69112056e-01f, 9.61483866e-02f, -7.37104639e-02f, 3.59338075e-01f, 2.90844530e-01f, 3.01602811e-01f, 1.60115212e-02f, 7.87763372e-02f,
  3.72816320e-03f, -2.57708095e-02f, 1.01784982e-01f, -1.63653061e-01f, -1.69765815e-01f, -2.83688400e-02f, -1.26565188e-01f, -1.29196823e-01f, -9.44239050e-02f, -1.53261334e-01f,
  4.83437181e-02f, -8.85117352e-02f, -1.79069806e-02f, 9.98471230e-02f, 1.66217368e-02f, 2.99012009e-03f, 3.12921926e-02f, -1.29172951e-02f, 1.51416231e-02f, -3.30010336e-03f,
  2.43354868e-02f, -9.03311558e-03f, 5.53041995e-02f, 3.41704078e-02f, -2.67421678e-02f, -4.77328412e-02f, -1.54038817e-02f, -4.76290621e-02f, -1.45736558e-03f, -1.08090080e-01f,
  5.94163164e-02f, 8.32467433e-03f, -1.22647900e-02f, 9.72402766e-02f, -3.25352661e-02f, 5.30203618e-02f, 7.36606941e-02f, 1.53450137e-02f, 2.10179631e-02f, 2.38773357e-02f,
  -6.51435629e-02f, 1.30886316e-01f, 1.54082133e-02f, -4.26161569e-03f, -1.38130700e-02f, 1.69227738e-02f, 1.94603764e-02f, -4.26717289e-02f, 6.30093440e-02f, 4.40059267e-02f,
  2.60900129e-02f, -3.07735577e-02f, -4.08230498e-02f, 5.60370646e-02f, -4.51944390e-04f, 2.83579230e-02f, 3.12984437e-02f, -1.44824479e-02f, 6.60981089e-02f, -2.78161522e-02f,
  5.72326928e-02f, 9.21841245e-03f, 3.68307956e-04f, -5.14900312e-03f, 6.37287349e-02f, 3.85705307e-02f, -1.45978276e-02f, -5.11794072e-03f, 1.24810766e-02f, 4.07318249e-02f,
  7.77411386e-02f, 2.33759597e-01f, 6.08473457e-02f, 7.06457766e-03f, 1.38755202e-01f, -9.17816013e-02f, 1.01936776e-02f, -3.09026111e-02f, 7.64240175e-02f, 1.34537453e-02f,
  -5.15271425e-02f, 5.05278520e-02f, 2.73324344e-02f, -5.91610782e-02f, 8.26011524e-02f, 6.28498718e-02f, 1.92423493e-01f, 1.00514024e-01f, 1.02472760e-01f, -4.37134542e-02f,
  4.26761508e-02f, 7.04653263e-02f, 5.74015193e-02f, 6.44206721e-03f, -2.65696924e-02f, 4.60930057e-02f, -1.06381118e-01f, -7.56499474e-04f, -7.56121799e-02f, 1.27030388e-01f,
  3.63649011e-01f, 1.48280546e-01f, 1.55928537e-01f, 3.46750677e-01f, 4.56067249e-02f, -7.92359263e-02f, -3.69096771e-02f, 2.91526437e-01f, 6.10750735e-01f, -1.52843997e-01f,
  -7.17222765e-02f, -1.20873414e-01f, -1.14830337e-01f, -8.85712951e-02f, 3.63180228e-02f, 3.11906599e-02f, 1.11296974e-01f, -1.03272460e-01f, 2.85374850e-01f, -9.65011716e-02f,
  1.61228478e-01f, -2.94004232e-01f, -1.68127030e-01f, -2.51682550e-01f, -1.64949983e-01f, 8.97452161e-02f, -3.11432064e-01f, -1.39327079e-01f, -2.61934996e-01f, -1.17942490e-01f,
  -2.80856080e-02f, 1.71746939e-01f, -1.78081039e-02f, 4.16223519e-02f, 1.40393883e-01f, -1.43410051e-02f, -5.34758233e-02f, -1.48363322e-01f, 8.92622024e-02f, 8.69980007e-02f,
  -8.29882547e-03f, -4.24859188e-02f, 1.44943520e-02f, -1.01264216e-01f, 7.31447414e-02f, 8.21645197e-04f, 5.68484627e-02f, 9.78416726e-02f, -8.67165625e-02f, -5.44375740e-02f,
  -4.66084257e-02f, 7.62054175e-02f, 9.98093784e-02f, 6.02423660e-02f, 3.29978094e-02f, 6.62650689e-02f, 5.43600414e-03f, -8.11149031e-02f, 2.38746051e-02f, 1.02199458e-01f,
  -1.92929972e-02f, 7.55157024e-02f, -6.32546991e-02f, 3.65635455e-02f, -2.18485035e-02f, 1.11987144e-01f, -2.17119101e-02f, -4.41009104e-02f, 1.55226350e-01f, -9.19930860e-02f,
  1.67725736e-03f, 7.41466181e-03f, 1.18531749e-01f, -6.61728904e-02f, 2.92632319e-02f, 4.14129645e-02f, -5.22368439e-02f, 6.91175163e-02f, 1.33004129e-01f, -7.93593004e-02f,
  -1.08748235e-01f, -3.92741524e-02f, -2.77608279e-02f, -5.10072149e-03f, -3.63494493e-02f, 3.13137546e-02f, -1.01667419e-01f, 7.48413708e-03f, 4.84567285e-02f, -1.02917351e-01f,
  4.77649905e-02f, 1.71418428e-01f, 7.71721229e-02f, -6.27093837e-02f, 3.29545029e-02f, -2.15311418e-03f, 5.02492394e-03f, 3.03641856e-02f, 2.51226611e-02f, -2.13484876e-02f,
  -2.31728870e-02f, -2.16445643e-02f, -3.27278301e-02f, -9.57456045e-03f, 4.29672981e-03f, -7.56456330e-03f, 1.37672713e-02f, 6.55293167e-02f, -1.33266365e-02f, -4.03201729e-02f,
  -1.10878401e-01f, 5.92203401e-02f, -6.70059770e-03f, 9.68849007e-03f, 4.87838574e-02f, -3.78692746e-02f, -9.83847678e-03f, 4.11240431e-03f, -6.19599521e-02f, 8.23807567e-02f,
  6.83202175e-03f, 4.56246696e-02f, 2.69589067e-01f, -3.47675011e-02f, 5.77608449e-03f, 1.36944994e-01f, 5.10208346e-02f, -9.32192132e-02f, -2.88216770e-01f, 7.85989612e-02f,
  1.38368243e-02f, 2.56154299e-01f, 2.88865399e-02f, -1.03487760e-01f, -2.40293458e-01f, -1.87761277e-01f, -8.90080035e-02f, -3.11770216e-02f, -1.05598539e-01f, -4.68242094e-02f,
  -7.17046410e-02f, -2.91575462e-01f, 1.97782964e-02f, -2.04024464e-01f, 1.45460397e-01f, 5.78596592e-02f, -3.85919400e-02f, 1.08247899e-01f, 1.38829678e-01f, -1.85923520e-02f,
  -1.09898783e-02f, -1.04576826e-01f, 1.23889603e-01f, 3.35313380e-02f, 7.82463816e-04f, 9.40570235e-02f, 1.55307367e-01f, 4.25340384e-02f, 1.19926177e-01f, 1.97487604e-02f,
  1.23134851e-01f, 7.40443938e-04f, 3.04234680e-02f, -8.89138598e-03f, -1.51588507e-02f, 3.29046622e-02f, 6.60901740e-02f, 8.87883678e-02f, 3.83184012e-03f, 8.53026807e-02f,
  6.54659197e-02f, 1.39903307e-01f, 1.10424019e-03f, -7.16788182e-03f, -1.51378848e-02f, -7.14945002e-03f, 7.56459087e-02f, 1.45724222e-01f, 2.01168638e-02f, -4.13830727e-02f,
  2.89671514e-02f, -5.47300316e-02f, -4.09701243e-02f, -8.95268172e-02f, -5.23677468e-02f, 3.73750553e-02f, -5.68602420e-02f, 3.81340012e-02f, -6.46874215e-03f, -9.19523463e-03f,
  3.75350378e-02f, 1.00784816e-01f, -6.68256730e-02f, -9.30093527e-02f, -4.71563786e-02f, 9.95455589e-03f, 5.84962852e-02f, 7.53450394e-02f, 3.80081311e-02f, 1.43886041e-02f,
  -1.64512787e-02f, -7.18550105e-03f, -3.75036299e-02f, -4.59253378e-02f, -7.47080520e-02f, -1.13146352e-02f, 5.96205180e-04f, -1.53739266e-02f, 2.45026089e-02f, -3.85675617e-02f,
  -1.64411087e-02f, -1.41050369e-01f, -1.12405114e-01f, 2.47290567e-03f, -5.97593002e-02f, 1.30965784e-01f, -1.08778916e-01f, -6.17990978e-02f, 5.41877002e-02f, -1.00047633e-01f,
  6.19296394e-02f, -7.40738260e-03f, -1.77741982e-02f, 2.63345484e-02f, -5.69167957e-02f, -2.11114977e-02f, -1.91064924e-02f, 1.54576143e-02f, 4.70935926e-02f, 3.39620188e-02f,
  -9.92213376e-03f, 6.89281970e-02f, -8.60288274e-03f, -3.18059586e-02f, -2.81500611e-02f, -4.01703045e-02f, 2.41423883e-02f, 6.17518798e-02f, 7.52461329e-02f, 1.15100965e-01f,
  -2.63528138e-01f, -2.60043025e-01f, 1.89377829e-01f, 8.11934844e-02f, -4.32113595e-02f, -3.86527367e-02f, 1.08211413e-01f, -3.47566903e-01f, -3.06816846e-01f, -2.61374563e-01f,
  -1.02964491e-02f, 1.80793166e-01f, -5.03617637e-02f, 2.58715332e-01f, 4.84556973e-01f, 7.76667148e-02f, -6.37164190e-02f, 3.50632407e-02f, 1.81944249e-03f, -1.56246841e-01f,
  5.36429286e-02f, 8.64318460e-02f, 2.95188546e-01f, 2.87543274e-02f, 1.36307850e-01f, 1.39978349e-01f, 3.03647101e-01f, 3.40905726e-01f, 3.48822355e-01f, 2.85023063e-01f,
  -6.11417443e-02f, -1.42171472e-01f, -2.66229105e-03f, -4.20356803e-02f, -1.20782152e-01f, 1.26249753e-02f, 1.19122840e-01f, 2.52258956e-01f, 1.01865269e-01f, -3.52437533e-02f,
  -8.18644185e-03f, 2.60950513e-02f, 4.41045389e-02f, 8.48298594e-02f, -9.51839015e-02f, 3.72431264e-03f, -6.01968765e-02f, -6.15898892e-02f, -6.38366118e-02f, -5.43212034e-02f,
  -8.26796815e-02f, -2.27901414e-02f, -2.46345513e-02f, 8.20622742e-02f, 1.21672899e-01f, -4.16967124e-02f, 5.63759776e-03f, 1.59207254e-03f, -2.97137420e-03f, -8.55248235e-03f,
  -1.20724499e-01f, -1.19754691e-02f, -5.46193346e-02f, 1.16744656e-02f, -1.28816273e-02f, -5.19199530e-03f, -2.94475518e-02f, 2.75577642e-02f, 1.14573367e-01f, -1.99474487e-02f,
  -1.03302635e-01f, -7.18280822e-02f, -5.09556532e-02f, -7.54544735e-02f, -1.00154132e-01f, -1.13683589e-01f, 8.92746225e-02f, 3.40728275e-02f, -5.36529720e-02f, 5.16478829e-02f,
  7.09588733e-03f, 1.16660982e-01f, -4.96430062e-02f, 4.64457572e-02f, -1.29270241e-01f, -5.56737073e-02f, -5.00145870e-05f, -7.94813782e-02f, 3.14387195e-02f, 6.45405278e-02f,
  -9.16640740e-03f, 1.55498674e-02f, 8.55285898e-02f, -3.51433456e-02f, 9.68335755e-03f, -1.09443702e-01f, 4.62244451e-02f, 2.23765448e-02f, 1.81615576e-02f, -3.40625905e-02f,
  -9.18367207e-02f, -6.06471486e-03f, -4.83505875e-02f, 4.65382226e-02f, 5.04768156e-02f, -1.04662441e-01f, 3.67529280e-02f, -2.46902276e-02f, -7.21300766e-03f, -4.05869894e-02f,
  3.80569249e-02f, 3.75532433e-02f, 1.05485283e-01f, 2.83144764e-03f, -3.74472365e-02f, 1.88235324e-02f, -4.27700765e-02f, -5.31187207e-02f, 8.25530738e-02f, 1.13298796e-01f,
  1.54269829e-01f, 1.34413034e-01f, -3.01155541e-02f, -4.05590795e-03f, -1.90581962e-01f, 5.57753071e-02f, 1.73127115e-01f, -1.69172347e-01f, -2.70521075e-01f, 2.34045476e-01f,
  1.40143007e-01f, 1.06637282e-02f, 9.41176042e-02f, 1.66219592e-01f, -3.59634072e-01f, -5.05948588e-02f, 1.14117667e-01f, 2.16511309e-01f, -6.36922047e-02f, 7.53846169e-02f,
  -1.05454519e-01f, -7.98728615e-02f, -8.92573851e-04f, -1.15752399e-01f, 2.31638044e-01f, 3.12384572e-02f, 9.98494029e-02f, -3.39667574e-02f, 1.33630961e-01f, -1.07290827e-01f,
  1.46481292e-02f, -3.15846018e-02f, 2.27637403e-02f, -3.03381924e-02f, 3.63703854e-02f, 1.18406795e-01f, 1.47138193e-01f, -3.42167504e-02f, -1.38041452e-01f, -2.47041509e-02f,
  3.10954005e-02f, -8.61148536e-02f, -6.67612478e-02f, -1.13110878e-01f, 4.63984385e-02f, -6.96345866e-02f, -9.65222195e-02f, 1.55330732e-01f, -9.88184381e-03f, 7.38442391e-02f,
  -3.17743868e-02f, 1.26648024e-01f, 1.33173347e-01f, 4.68468815e-02f, -4.74119857e-02f, -4.62416373e-02f, 1.66555488e-04f, 9.92466956e-02f, 2.32660379e-02f, -6.85307384e-02f,
  -3.44811380e-02f, 6.17241263e-02f, 4.47305776e-02f, 3.83028351e-02f, -1.34379402e-01f, 9.85150225e-03f, 4.16476689e-02f, -1.40687255e-02f, -4.08130027e-02f, -5.45224827e-03f,
  -1.94649789e-02f, -3.72852758e-02f, -2.35747695e-02f, 1.54869091e-02f, -1.49408018e-03f, -2.32344326e-02f, 4.76005226e-02f, 1.69618111e-02f, -4.63988297e-02f, 2.05236841e-02f,
  3.03068776e-02f, -9.05059949e-02f, -5.95313348e-02f, 1.77471504e-01f, 2.12856475e-02f, -7.43001550e-02f, -4.17838395e-02f, 2.40912586e-02f, -1.44109363e-02f, -4.39852057e-03f,
  -1.33763412e-02f, -7.36590177e-02f, -5.38753383e-02f, -5.12932204e-02f, 4.24639508e-02f, 7.12746903e-02f, 3.00080050e-02f, -9.93581936e-02f, 2.29768176e-03f, -8.12150910e-02f,
  -1.37783801e-02f, 1.08828440e-01f, 1.22352310e-01f, -5.56922220e-02f, -9.88606364e-02f, -5.78126572e-02f, 3.11912224e-03f, -2.21861843e-02f, 2.09592804e-02f, -3.21270078e-02f,
  4.97027636e-02f, -3.98495756e-02f, -4.71940860e-02f, 3.41988876e-02f, 3.44833992e-02f, 1.19113959e-01f, -3.05423867e-02f, -1.07029207e-01f, 4.83941771e-02f, -4.99252714e-02f,
  -3.24624777e-01f, 7.62460828e-02f, -1.19304374e-01f, -1.38584435e-01f, 2.39098981e-01f, 4.01004016e-01f, 1.19667756e-03f, 7.14340806e-02f, -1.86301470e-01f, 1.25982491e-02f,
  1.68886125e-01f, -1.44456089e-01f, -5.64364232e-02f, 1.60181075e-01f, 1.50822133e-01f, 7.10307881e-02f, 9.32894647e-02f, 4.19941209e-02f, -5.26052751e-02f, -8.16234723e-02f,
  2.96520675e-03f, 2.12779686e-01f, 7.64270425e-02f, 1.07843682e-01f, 5.04132397e-02f, -8.39752853e-02f, 2.58194413e-02f, -1.42104387e-01f, 1.61535949e-01f, 1.03037573e-01f,
  3.14374976e-02f, -2.26170555e-01f, -8.99845958e-02f, -6.03932291e-02f, 8.34616646e-03f, -7.14784414e-02f, -4.76927087e-02f, -1.66030526e-02f, -7.17013329e-02f, 3.29252109e-02f,
  -9.14142355e-02f, 1.78877935e-02f, 2.59450860e-02f, -1.00990972e-02f, 1.45544419e-02f, 3.74772660e-02f, 1.33673370e-01f, 1.62502136e-02f, 3.79931787e-03f, 5.89637607e-02f,
  2.62627825e-02f, 3.11504193e-02f, 1.68516953e-02f, 7.74862617e-02f, 6.66706041e-02f, 8.12984332e-02f, -2.73850188e-02f, -3.71238105e-02f, 1.14754312e-01f, 5.53761199e-02f,
  -2.24710144e-02f, -8.30239207e-02f, 7.71255493e-02f, 2.57792212e-02f, -2.07897127e-02f, 3.63730192e-02f, -7.23589677e-03f, 1.73917618e-02f, -6.78482652e-02f, 1.12926504e-02f,
  2.34561879e-02f, -1.75329316e-02f, -5.95819158e-03f, -2.25398354e-02f, 8.52069166e-03f, -4.58635837e-02f, -4.28917445e-02f, 7.19775632e-03f, -6.46624640e-02f, -1.98854413e-02f,
  -6.00499250e-02f, 2.81494968e-02f, 7.33171403e-02f, -2.40826583e-03f, 5.07520186e-03f, 1.72416810e-02f, -7.58383889e-03f, 4.90683019e-02f, -1.05905468e-02f, -3.45224026e-03f,
  -3.27793695e-02f, -1.36874706e-01f, 5.12171127e-02f, 9.78187844e-02f, -2.84358896e-02f, 2.07960475e-02f, -6.28349110e-02f, 1.00266412e-01f, 2.36077439e-02f, -2.99617555e-03f,
  -1.44254938e-02f, -2.14948747e-02f, -3.58319096e-03f, -3.50657944e-03f, -8.87093414e-03f, 5.82097396e-02f, -5.10859638e-02f, -6.46992028e-02f, -9.97694395e-03f, 8.82221386e-03f,
  -4.33204100e-02f, 1.17970305e-02f, -1.34684341e-02f, 5.32135665e-02f, 1.19168572e-02f, 2.37605143e-02f, 3.67145538e-02f, -2.28788275e-02f, 9.40962881e-02f, -1.61092058e-02f,
  -8.12310427e-02f, -6.30287826e-02f, 1.54789165e-01f, 1.11790352e-01f, 1.39574498e-01f, 2.32365057e-01f, 2.77128935e-01f, 2.22448200e-01f, 3.97390306e-01f, -2.18514260e-02f,
  4.68267463e-02f, -2.05554053e-01f, 6.83538318e-02f, 6.87031150e-02f, 3.63797657e-02f, 1.68739825e-01f, 1.43454283e-01f, 3.75186317e-02f, 1.71093822e-01f, 8.25465657e-03f,
  1.06094792e-01f, -2.04299502e-02f, 3.22873294e-02f, -1.35807097e-01f, -4.26217057e-02f, -4.33502086e-02f, -1.40530109e-01f, 2.32968088e-02f, -1.42007470e-01f, 4.05468531e-02f,
  -1.97021738e-02f, 1.79751329e-02f, -1.05349869e-01f, -1.34353731e-02f, 4.03296500e-02f, -2.24795397e-02f, -1.21876989e-02f, 3.63062858e-03f, 5.60429208e-02f, 1.85784362e-02f,
  -8.24453961e-03f, -6.90441057e-02f, -6.70003518e-03f, 4.74574640e-02f, 4.59217615e-02f, -2.76011731e-02f, -3.42020877e-02f, 3.44818421e-02f, 4.05798666e-02f, -1.93894655e-02f,
  -4.34647845e-05f, 4.09104303e-03f, 1.48648042e-02f, 8.55242368e-03f, 1.99608281e-02f, -9.73602466e-04f, 2.59330329e-02f, -2.46261731e-02f, -6.52783215e-02f, 2.07449012e-02f,
  3.67459953e-02f, 2.51324177e-02f, -8.73460695e-02f, -2.38306280e-02f, -9.13605653e-03f, 3.06362379e-02f, 6.12335140e-03f, -5.12960479e-02f, 5.52188605e-03f, -1.35996267e-02f,
  4.34126072e-02f, -1.96679179e-02f, 9.95186716e-03f, 3.20138633e-02f, 7.06625730e-02f, 3.96213979e-02f, -7.69600645e-03f, -9.28287953e-03f, 5.75236371e-03f, -6.65271329e-03f,
  1.18102767e-02f, 4.53241579e-02f, -2.82938266e-03f, -2.33312808e-02f, -2.12845318e-02f, 1.72831435e-02f, 5.10130031e-03f, 2.52826605e-02f, 1.84737910e-02f, -2.61181463e-02f,
  -1.39568727e-02f, -6.72232406e-03f, -3.77930813e-02f, -4.01325040e-02f, -5.67311645e-02f, -5.99024333e-02f, 2.10826583e-02f, -1.58307869e-02f, 1.04306852e-02f, 5.42349368e-02f,
  -1.23411668e-02f, -1.90598816e-02f, -6.85211048e-02f, 4.19463776e-02f, -5.11723682e-02f, 3.45267579e-02f, -2.91914539e-03f, 2.87064854e-02f, -1.22731496e-02f, -6.12011813e-02f,
  -5.66173717e-02f, -4.17644531e-02f, -2.00858992e-02f, -4.94869426e-03f, -2.19626129e-02f, -8.24447647e-02f, -6.53394163e-02f, 6.03299439e-02f, -2.70038769e-02f, -1.10907452e-02f,
  -1.45358831e-01f, -1.00168377e-01f, 1.92107990e-01f, -3.71218264e-01f, -7.23064020e-02f, 2.67562062e-01f, -3.74224856e-02f, -1.17252469e-01f, -1.70715645e-01f, -1.71508312e-01f,
  -2.49848470e-01f, 8.39203522e-02f, 2.06497312e-01f, -3.11233371e-01f, 5.37673712e-01f, 2.27712005e-01f, -1.93010271e-01f, -1.19038515e-01f, -1.17388718e-01f, -2.01376259e-01f,
  -7.60245770e-02f, -2.71665573e-01f, 1.10375084e-01f, -1.42370149e-01f, -2.84827352e-01f, -2.20733181e-01f, -1.19996086e-01f, 3.62935732e-03f, -2.33073384e-01f, -8.38591978e-02f,
  4.91809985e-03f, -1.13007315e-01f, 7.81525746e-02f, 9.71172526e-02f, 3.12790386e-02f, 2.58147623e-02f, -1.65368174e-03f, 1.69129744e-01f, -3.38208638e-02f, 1.29630277e-02f,
  -1.00120285e-03f, 7.42397010e-02f, -9.49861258e-02f, 8.80559310e-02f, -1.09802634e-01f, -1.10737517e-01f, 1.81083605e-02f, -1.86619684e-02f, 6.88354969e-02f, 2.87354346e-02f,
  -1.30056571e-02f, -2.20124908e-02f, -9.65114012e-02f, 7.05047622e-02f, -9.64903086e-02f, -7.05565959e-02f, 8.89384449e-02f, 8.62501636e-02f, -1.69966649e-03f, -5.94642647e-02f,
  3.59314829e-02f, 1.37047812e-01f, -5.19634895e-02f, -5.71735166e-02f, -2.89321709e-02f, -9.23770517e-02f, -6.56828210e-02f, -4.84226011e-02f, -1.15598105e-01f, -1.36631638e-01f,
  -6.10450581e-02f, 4.38043196e-03f, -3.40338349e-02f, -3.74875241e-03f, -2.78688259e-02f, -1.79936122e-02f, 5.10921068e-02f, 2.04557250e-03f, -1.15129463e-01f, 5.42823272e-03f,
  -1.26752540e-01f, 2.24605985e-02f, -4.67657074e-02f, -2.22990513e-02f, 4.06850874e-02f, 1.75289549e-02f, -5.01112975e-02f, 1.03402652e-01f, 8.42939410e-03f, 3.75276878e-02f,
  8.61616954e-02f, -5.47854938e-02f, -5.06879054e-02f, 4.04808931e-02f, 5.92663474e-02f, 6.08268045e-02f, -1.44624813e-02f, -7.25480616e-02f, -4.93370183e-02f, -2.66999379e-02f,
  -1.00233965e-01f, 4.32204604e-02f, -5.02625480e-02f, -6.00048981e-04f, 1.59474481e-02f, -3.94983543e-03f, 5.30609526e-02f, -8.39596316e-02f, 4.52912878e-03f, -2.25809310e-02f,
  -8.71208608e-02f, -2.86978409e-02f, 2.99447309e-02f, -4.10194844e-02f, -8.10053125e-02f, -1.13910912e-02f, 4.63276654e-02f, 2.35787351e-02f, 9.40377545e-03f, 5.13604023e-02f,
  -1.57528266e-01f, -3.00792940e-02f, -3.34722668e-01f, -1.39681175e-01f, 5.08530848e-02f, -3.70327830e-01f, -1.88354224e-01f, -1.19741447e-01f, -6.88083936e-03f, 1.59982011e-01f,
  5.65946326e-02f, -2.47339066e-02f, 1.53501987e-01f, -2.27575913e-01f, -3.58457774e-01f, 8.20125861e-05f, -3.18596125e-01f, -8.60261917e-02f, 4.35784869e-02f, -8.99457932e-02f,
  -1.39631286e-01f, 2.20920462e-02f, -2.27313489e-01f, 1.15831003e-01f, -1.00235544e-01f, 4.29059863e-02f, 1.89119428e-01f, 4.54384647e-02f, -1.37874603e-01f, 2.22597867e-02f,
  -1.24752410e-01f, 4.27635610e-02f, -1.11511853e-02f, -9.51611530e-03f, -9.15142819e-02f, 3.92662697e-02f, 6.16442785e-03f, -4.08241199e-03f, 3.41096967e-02f, -5.21939583e-02f,
  1.65973511e-02f, 3.37184109e-02f, -1.92556810e-02f, 9.15597975e-02f, 1.28837791e-03f, -3.66930142e-02f, -5.97901866e-02f, -7.22157508e-02f, -2.06763539e-02f, -1.04301147e-01f,
  -8.58577415e-02f, -6.30807951e-02f, -5.95620908e-02f, 3.11813690e-02f, -2.41647735e-02f, -1.44474511e-03f, -1.01658255e-01f, 2.23629605e-02f, -5.10048978e-02f, -2.35367808e-02f,
  -3.74988071e-03f, 3.60626578e-02f, -4.56457306e-03f, 6.86257193e-03f, 5.10260835e-03f, 2.08349247e-02f, 1.73363462e-02f, 7.48019591e-02f, 7.57307410e-02f, -4.60021198e-02f,
  -1.11651309e-02f, 1.07014151e-02f, 2.35140119e-02f, -4.22783755e-02f, -3.95965613e-02f, 1.13752373e-02f, 7.28383288e-03f, 5.03937528e-02f, -4.75247316e-02f, -7.30041191e-02f,
  4.95197438e-02f, -1.58682596e-02f, 9.61153675e-03f, 1.25700608e-02f, -2.80411821e-02f, 1.71273351e-02f, 3.23800072e-02f, -6.20239303e-02f, -1.52056839e-03f, -1.45886671e-02f,
  -7.88349435e-02f, -5.88060170e-02f, 1.21684987e-02f, 4.77431081e-02f, 7.60813383e-03f, -2.28010193e-02f, -1.68985352e-02f, 9.12384596e-03f, -2.87454650e-02f, 2.72932388e-02f,
  5.46441860e-02f, -1.10323345e-02f, -2.63381377e-02f, 2.52284855e-02f, -1.70125216e-02f, -2.64886674e-02f, 6.84872793e-04f, 4.12717313e-02f, -1.38337072e-02f, -5.60004525e-02f,
  2.39660069e-02f, 3.43308896e-02f, -6.28125994e-03f, 5.94213642e-02f, 1.92441400e-02f, 2.15126555e-02f, -8.20261333e-03f, 3.07107307e-02f, 2.67564077e-02f, 1.44279031e-02f,
  -3.98205407e-02f, 4.34438199e-01f, 4.32221174e-01f, 9.67273712e-02f, -2.00436592e-01f, -1.95265144e-01f, -2.79372424e-01f, 2.58568257e-01f, -5.53475358e-02f, -4.42267396e-02f,
  -2.11782288e-02f, 1.13239706e-01f, 1.08132817e-01f, 1.80481642e-01f, 8.06807354e-02f, 6.76084980e-02f, 2.97059547e-02f, 1.28419483e-02f, 1.26779392e-01f, 2.63145775e-01f,
  1.11837268e-01f, -1.11523658e-01f, 3.33798766e-01f, 1.37688339e-01f, 2.14283645e-01f, 1.87147051e-01f, 5.90718910e-02f, 1.34701356e-01f, 1.43044785e-01f, -7.07184598e-02f,
  -6.90295920e-02f, 1.81277953e-02f, 1.02198288e-01f, 1.93329323e-02f, 7.38110021e-02f, -5.15461601e-02f, 3.86242270e-02f, -6.15692548e-02f, -7.50907063e-02f, 1.70212574e-02f,
  -2.68954542e-02f, -2.50125211e-02f, -2.06987765e-02f, -3.20053212e-02f, 8.70039687e-03f, 7.41987228e-02f, 8.75497833e-02f, 5.91990203e-02f, 4.85190637e-02f, 9.16688144e-02f,
  1.18029833e-01f, 7.85752684e-02f, 8.18747580e-02f, 3.38814557e-02f, 7.10281655e-02f, -5.37140109e-02f, -5.67851327e-02f, 3.85440700e-02f, 6.08337410e-02f, 2.12168377e-02f,
  -8.04150328e-02f, -2.62400713e-02f, -3.21615040e-02f, 6.48690090e-02f, 7.15362467e-03f, -6.83816075e-02f, 5.13847061e-02f, 6.00690534e-03f, -5.78480996e-02f, -4.30986695e-02f,
  -8.17934703e-03f, 9.62186456e-02f, -6.12760000e-02f, -6.71757236e-02f, -8.46362486e-03f, -6.80262968e-02f, -6.15329631e-02f, 2.85408483e-03f, 1.78534649e-02f, 3.74195278e-02f,
  -6.42106757e-02f, 4.82957903e-03f, -2.96615027e-02f, 2.57395487e-03f, -6.43934608e-02f, 5.30793332e-02f, 7.21787661e-02f, 2.02956758e-02f, 4.97250184e-02f, 5.78570105e-02f,
  -1.08327782e-02f, 2.20537022e-01f, -3.88359725e-02f, -7.51380771e-02f, 4.98543307e-03f, 8.76737013e-02f, -4.01014052e-02f, 1.01072937e-01f, -1.93833914e-02f, 2.10442804e-02f,
  2.78595351e-02f, -3.35246809e-02f, -6.70988709e-02f, -2.03012843e-02f, 1.68126710e-02f, -1.42193865e-03f, -4.79140356e-02f, -6.10981882e-02f, 1.05464505e-02f, 9.67022330e-02f,
  5.51881492e-02f, -5.78343794e-02f, 4.74522710e-02f, 7.05132436e-04f, -1.72381047e-02f, -6.22562468e-02f, -2.13107057e-02f, -5.51669151e-02f, 4.77133058e-02f, 7.24181980e-02f,
  2.20438704e-01f, -2.67424345e-01f, -3.50537114e-02f, -1.29706100e-01f, 5.40437028e-02f, -1.05955109e-01f, -2.50048805e-02f, -2.10860297e-01f, -4.94218096e-02f, -2.65709877e-01f,
  -7.02183172e-02f, 2.54583433e-02f, 1.07621714e-01f, -1.97609797e-01f, 2.75528848e-01f, 1.60150126e-01f, -1.66653231e-01f, -1.10386454e-01f, 8.47099796e-02f, -1.23354420e-01f,
  -1.03531694e-02f, -2.11116016e-01f, 1.12255681e-02f, -3.10278028e-01f, -1.48106039e-01f, -1.52950391e-01f, -2.49080732e-02f, -4.95329946e-02f, -2.13049382e-01f, 5.92915379e-02f,
  4.40952033e-02f, 8.55277292e-03f, 4.42245975e-02f, -1.40446639e-02f, -6.48381338e-02f, -3.58996913e-02f, -2.34003291e-02f, -1.09500263e-03f, 7.34088644e-02f, -8.23474023e-03f,
  -3.40209082e-02f, 8.91931559e-05f, -7.57200792e-02f, 9.27395839e-03f, -8.00710842e-02f, -6.45003766e-02f, -1.46387536e-02f, 6.08328283e-02f, -8.21262449e-02f, 6.25991970e-02f,
  2.45592277e-02f, 2.95836423e-02f, 8.92790332e-02f, -3.97082418e-02f, 2.53067911e-02f, -4.01755422e-02f, 8.07433948e-02f, 3.94007601e-02f, 2.03542095e-02f, -1.41223967e-02f,
  -1.13003485e-01f, 6.18210807e-02f, 3.17730568e-02f, -1.15929041e-02f, 1.71216410e-02f, 1.35924686e-02f, 7.17710657e-03f, 2.55946238e-02f, 5.80075346e-02f, 4.24294583e-02f,
  2.58062817e-02f, -1.50032388e-02f, 8.23571440e-03f, 4.04934399e-03f, -4.98753712e-02f, 3.28032933e-02f, 1.83151308e-02f, -1.83827449e-02f, -1.30711040e-02f, 4.02973145e-02f,
  5.78551441e-02f, -2.65987702e-02f, 1.96334179e-02f, -8.13571960e-02f, -7.47584179e-02f, 5.61184362e-02f, -1.44807650e-02f, 8.85725720e-04f, 4.52306420e-02f, 2.82333400e-02f,
  -6.37044292e-03f, -1.61656052e-01f, -5.99232651e-02f, -7.81811848e-02f, -1.76082291e-02f, 1.12106595e-02f, -4.76528183e-02f, -9.24438834e-02f, 1.80046831e-03f, -3.58020072e-03f,
  -1.06846474e-01f, -5.28605990e-02f, -2.08428837e-02f, -2.23168116e-02f, -3.61404978e-02f, -2.90277116e-02f, -4.01640274e-02f, -2.33828695e-03f, -3.30635905e-02f, 1.09875994e-02f,
  -2.48770583e-02f, -3.23360041e-02f, 1.62301995e-02f, -2.23971764e-03f, -1.21540472e-01f, 2.50245277e-02f, 8.40655621e-03f, 1.10338824e-02f, -4.39497195e-02f, -6.90085962e-02f,
  -9.49468538e-02f, -2.57887423e-01f, -1.23872552e-02f, 1.82972979e-02f, 1.45869717e-01f, -7.43595436e-02f, -1.80445239e-01f, 1.44281313e-01f, -2.29676843e-01f, -1.61323607e-01f,
  -1.38263023e-02f, -2.84176022e-01f, -1.73303246e-01f, -2.19797239e-01f, 4.29767743e-02f, -3.28712642e-01f, 6.38830736e-02f, -6.59871921e-02f, -4.01460659e-03f, 2.10537076e-01f,
  1.39671981e-01f, 1.41102031e-01f, 1.20673105e-01f, 2.42624268e-01f, 5.64543158e-02f, 2.70488918e-01f, 2.55312353e-01f, 5.04676104e-02f, 1.66457966e-01f, -8.23027268e-02f,
  6.46300009e-03f, -7.19894916e-02f, 4.99945059e-02f, -1.08600877e-01f, 2.55089939e-01f, 2.69142464e-02f, 4.65477034e-02f, -7.17379898e-02f, 1.37071852e-02f, 6.04096521e-03f,
  2.73459647e-02f, 7.56556634e-03f, -4.15896997e-02f, -7.00024143e-02f, -3.16289142e-02f, 4.20586281e-02f, -1.32902218e-02f, 4.02673148e-02f, -1.38045967e-01f, -1.09368891e-01f,
  -6.34322092e-02f, -3.37288752e-02f, 2.12533865e-02f, -2.60539204e-02f, 2.02765372e-02f, -6.88850181e-03f, -1.22277085e-02f, 1.68669468e-03f, -6.35590106e-02f, -3.33909020e-02f,
  -3.49885486e-02f, 3.22616585e-02f, 1.08543318e-02f, -5.13922535e-02f, -2.51307022e-02f, -6.29976625e-03f, -3.38731296e-02f, 2.57783160e-02f, -1.81786567e-02f, -3.53124775e-02f,
  4.46944200e-02f, -1.17789553e-02f, -1.14262246e-01f, -8.33328720e-03f, 7.17017278e-02f, -2.12161914e-02f, 4.97859146e-04f, -1.60648972e-02f, 1.49701154e-02f, -1.94788491e-03f,
  -3.65589708e-02f, 3.39363962e-02f, -6.19441830e-02f, -3.18751149e-02f, -3.09318677e-02f, 5.08835763e-02f, 6.00249618e-02f, -2.08427832e-02f, 7.46354982e-02f, 1.16126647e-03f,
  2.09209681e-01f, 1.72519594e-01f, 5.50459586e-02f, -3.19729000e-02f, -1.48119340e-02f, 4.09498159e-03f, 8.63931607e-03f, -4.58311997e-02f, 1.89637598e-02f, 1.60692027e-03f,
  1.72212616e-01f, 4.51061651e-02f, 4.10511903e-02f, -2.25776490e-02f, 7.48330206e-02f, 6.76075667e-02f, 9.24992375e-03f, 9.31763649e-02f, 7.86888152e-02f, 1.32231265e-01f,
  1.02809258e-01f, 7.68937096e-02f, 6.75206073e-03f, 4.47946116e-02f, 7.66371936e-02f, -7.53056072e-03f, 3.91137339e-02f, 2.96108685e-02f, -1.06086120e-01f, -3.82917635e-02f,
  -7.11924136e-01f, 1.05831094e-01f, -1.46838248e-01f, -2.97067352e-02f, -2.13886867e-03f, 1.47089124e-01f, -2.35388521e-02f, -3.31592187e-02f, -2.57401884e-01f, 1.60639271e-01f,
  1.93619668e-01f, -2.26598352e-01f, -1.62749551e-02f, 2.16557309e-01f, -1.04608320e-01f, 1.45812258e-01f, 1.04984343e-01f, 1.78760123e-02f, -2.25882065e-02f, -1.34895995e-01f,
  -4.87241484e-02f, 2.30566069e-01f, 9.29974392e-02f, 1.42155766e-01f, -4.66217054e-03f, -1.17437109e-01f, 9.01640058e-02f, -8.14300999e-02f, 2.46243358e-01f, 9.02674347e-02f,
  -1.01390064e-01f, -2.64271468e-01f, -1.13423772e-01f, -6.28652498e-02f, -6.83143809e-02f, -5.87643273e-02f, -3.25146765e-02f, 3.88995409e-02f, -7.03178272e-02f, -5.54752573e-02f,
  -4.18177471e-02f, 1.81905031e-02f, 4.62502725e-02f, -4.53588888e-02f, -1.16696030e-01f, -2.57218536e-02f, 4.44188528e-02f, 5.86232357e-02f, -1.39879119e-02f, 4.09308486e-02f,
  2.34072953e-02f, 4.00735289e-02f, 3.62336822e-02f, 7.07003772e-02f, 6.34166598e-02f, 4.61644456e-02f, 5.33819012e-02f, -5.61867431e-02f, -2.27291300e-03f, -3.38155292e-02f,
  7.89665559e-04f, 4.14114539e-03f, 3.81598175e-02f, -1.98682025e-02f, -1.96643583e-02f, 1.12224363e-01f, 3.03148814e-02f, -5.03099784e-02f, -3.44548486e-02f, 2.58251112e-02f,
  1.11968694e-02f, -9.25743673e-03f, -4.09080368e-03f, -4.38277982e-03f, -1.53254382e-02f, -7.78020872e-03f, -4.35238220e-02f, -5.10585681e-02f, -7.26863043e-03f, 1.61090586e-02f,
  -1.23098993e-03f, -6.81896582e-02f, 3.77477445e-02f, 5.01722917e-02f, -1.25570856e-02f, -1.61155649e-02f, -2.71247309e-02f, -1.02102058e-03f, 4.62690778e-02f, 2.56278925e-02f,
  -3.54749739e-01f, -3.61589760e-01f, -1.56594999e-02f, 4.30350145e-03f, -3.71738560e-02f, -4.10885960e-02f, -3.50074731e-02f, 4.95089823e-03f, 3.80353304e-03f, -4.55084480e-02f,
  -4.16142568e-02f, 5.22429682e-02f, 5.62471896e-03f, -3.49888665e-04f, -3.20023149e-02f, 3.09818387e-02f, -2.69552153e-02f, -5.44841439e-02f, -9.85617097e-03f, -1.91182345e-02f,
  -3.97252925e-02f, -3.98592092e-02f, -2.44002789e-03f, 2.62219254e-02f, 4.15350758e-02f, 7.53142983e-02f, -8.55049863e-02f, 6.98794946e-02f, 2.47872658e-02f, 2.68301126e-02f,
  -1.93068072e-01f, 8.78033936e-02f, -2.72069901e-01f, 7.73591222e-03f, 8.26161578e-02f, -1.27121612e-01f, 1.17221713e-01f, 8.35893303e-02f, 1.39412850e-01f, 2.59286106e-01f,
  2.60637432e-01f, 1.94809418e-02f, 2.67927855e-01f, 1.69245705e-01f, -2.74432182e-01f, 1.19819760e-01f, -1.72368541e-01f, 5.99048696e-02f, 7.93801900e-03f, 3.76003757e-02f,
  -4.63968106e-02f, 2.38034680e-01f, -2.13846445e-01f, 1.47579834e-01f, -1.00904003e-01f, -1.29209518e-01f, -1.27664447e-01f, 4.60692197e-02f, -1.38058469e-01f, 1.97634026e-02f,
  2.95448843e-02f, 2.53135443e-01f, -4.93550450e-02f, 5.03979437e-02f, -2.16098592e-01f, -7.05625787e-02f, -1.27651244e-01f, -1.26438204e-03f, -2.75632627e-02f, -1.11266109e-03f,
  -3.19014005e-02f, 5.67374658e-03f, 5.18827401e-02f, 1.14680901e-01f, 5.59421144e-02f, 6.48407367e-05f, -1.48487054e-02f, -1.33233309e-01f, 3.20774168e-02f, -7.37718865e-02f,
  -3.70712131e-02f, -1.21878415e-01f, -1.13520861e-01f, 2.97652893e-02f, -3.88012230e-02f, 4.73001786e-02f, -6.74307495e-02f, -7.35711008e-02f, -1.10864468e-01f, -9.80610028e-02f,
  3.28255049e-03f, -2.36236546e-02f, 5.58881089e-02f, 2.57100053e-02f, -1.93308126e-02f, 9.58937220e-03f, 3.32227536e-02f, -6.72807591e-03f, -2.34767469e-03f, -3.04252449e-02f,
  2.79778764e-02f, 6.98909461e-02f, 6.22584075e-02f, -5.81773333e-02f, -2.04069149e-02f, -2.43148487e-02f, 2.64602769e-02f, 6.07500412e-02f, -4.82106172e-02f, -1.10050797e-01f,
  1.22510970e-01f, -4.50773118e-03f, 7.92422295e-02f, 1.37290964e-02f, 1.65866297e-02f, 2.23695580e-02f, 3.39804888e-02f, -9.27296430e-02f, 6.14469824e-03f, 1.94603093e-02f,
  -4.76168096e-02f, -2.11952440e-02f, 9.75270569e-02f, 1.46324813e-01f, -7.17778504e-02f, 2.16105394e-02f, -4.57174294e-02f, -2.57622562e-02f, -5.03407046e-02f, 9.80596319e-02f,
  -3.93848456e-02f, 2.88663767e-02f, -1.24091379e-01f, 5.22780903e-02f, -5.44400923e-02f, -7.70488940e-03f, -2.23766547e-02f, -3.60183269e-02f, -5.13038076e-02f, -4.03464399e-02f,
  -5.12811467e-02f, 5.39633371e-02f, -3.53396870e-02f, 5.81296086e-02f, -3.74609716e-02f, -4.46484722e-02f, 2.13548150e-02f, 4.65903506e-02f, -7.06778690e-02f, -3.34790014e-02f,
  -1.34052828e-01f, 1.38666406e-01f, -1.63914308e-01f, -4.11417894e-02f, -8.73806700e-03f, -4.72479999e-01f, -2.76862890e-01f, 2.02199677e-03f, 3.06231584e-02f, 5.11533879e-02f,
  1.29928086e-02f, 1.10881306e-01f, 1.71324387e-01f, -2.08706155e-01f, -3.42786759e-01f, -9.66759250e-02f, -2.68903852e-01f, -1.92077801e-01f, 5.77292442e-02f, 1.35525074e-02f,
  7.84768537e-02f, 2.15726607e-02f, -9.46935862e-02f, 9.71933007e-02f, -1.32429466e-01f, 1.36285856e-01f, 2.10008696e-01f, 4.05750200e-02f, -1.12666599e-01f, -4.31804955e-02f,
  -1.63457081e-01f, 1.94255456e-01f, -2.37049125e-02f, -3.75728607e-02f, -3.02045941e-02f, -4.55555506e-02f, -7.32512698e-02f, -6.06346726e-02f, -3.80647741e-02f, -1.61707047e-02f,
  4.46575545e-02f, 9.58821699e-02f, 5.55020422e-02f, 3.19225341e-02f, -6.96375370e-02f, 1.05954381e-02f, 1.52550300e-03f, -5.09161614e-02f, 5.08883549e-03f, -6.67961836e-02f,
  -2.32713930e-02f, 8.24295543e-03f, 1.99666005e-02f, 7.43895918e-02f, 7.64655769e-02f, -6.43500462e-02f, -1.08713903e-01f, 2.12499667e-02f, 1.56348404e-02f, -1.53601663e-02f,
  8.81723389e-02f, 3.45066525e-02f, -4.35484983e-02f, -7.27055445e-02f, 6.32149307e-03f, 4.22984362e-02f, -2.70583071e-02f, 5.82177145e-03f, 2.84989551e-02f, -2.37356350e-02f,
  -3.73311788e-02f, 2.77579799e-02f, -5.39225526e-02f, -8.60684142e-02f, 2.15545334e-02f, 3.74518856e-02f, 9.61270183e-03f, -2.51988065e-03f, 1.12646604e-02f, -4.13354188e-02f,
  5.78619055e-02f, -7.83208162e-02f, 2.17927098e-02f, -6.75059156e-03f, -3.07799000e-02f, 9.02270079e-02f, 9.41068158e-02f, -6.31532744e-02f, -3.37014906e-02f, -1.14079844e-02f,
  3.01355124e-02f, 2.49269634e-01f, 1.03117362e-01f, 8.01791996e-03f, 3.17757092e-02f, -5.09715751e-02f, -4.15581316e-02f, -3.67533900e-02f, 3.13027091e-02f, -1.59230661e-02f,
  7.79876439e-03f, 1.50519540e-03f, 3.19051445e-02f, -3.23348120e-02f, -3.48144658e-02f, -7.60665610e-02f, 1.13986433e-01f, 1.49805561e-01f, 6.58132285e-02f, 9.38794762e-02f,
  1.34747863e-01f, 6.17902465e-02f, 3.49612311e-02f, -1.02509661e-02f, 1.73090715e-02f, 3.89030017e-02f, 3.60337086e-02f, -3.81837003e-02f, 5.34699932e-02f, 1.12206144e-02f,
  -2.37987846e-01f, -1.11757843e-02f, -2.94203758e-01f, 1.51068056e-02f, 2.69500822e-01f, -3.06560546e-01f, 2.02289969e-02f, 1.41897902e-01f, 1.70339812e-02f, 1.50266737e-01f,
  6.83977008e-02f, -2.70207733e-01f, 7.99945518e-02f, -2.94908553e-01f, -4.53478009e-01f, -2.67908782e-01f, -2.94624269e-01f, -2.80294299e-01f, -7.49422163e-02f, -2.21564174e-02f,
  -6.55718371e-02f, 1.62441060e-01f, -1.44749224e-01f, 3.81147802e-01f, 9.12578478e-02f, 1.94510192e-01f, 2.94552803e-01f, 2.41160601e-01f, -4.00369391e-02f, -1.77979397e-04f,
  -1.86351389e-01f, 6.60601258e-02f, 4.52965647e-02f, -7.81635344e-02f, -2.10692976e-02f, 1.17358200e-01f, -5.46344593e-02f, 6.71385834e-03f, -7.41108432e-02f, -3.56176086e-02f,
  4.63071186e-03f, 1.35746337e-02f, -3.34531367e-02f, 4.32794467e-02f, 6.89856187e-02f, 4.15279418e-02f, -1.13550566e-01f, -7.98974484e-02f, 3.12862098e-02f, -1.55024782e-01f,
  -4.89091277e-02f, -9.25445929e-02f, -8.37676041e-03f, -5.60884811e-02f, -6.32264763e-02f, -3.06346305e-02f, -5.84339611e-02f, -4.47733104e-02f, -8.74260906e-03f, -5.50177097e-02f,
  -3.33901169e-03f, 8.49086940e-02f, 6.79733902e-02f, -2.44630780e-03f, -1.49784843e-02f, 3.15991007e-02f, 2.70762704e-02f, 3.38661112e-02f, -5.63435815e-03f, 7.56378518e-03f,
  3.07384469e-02f, 1.63651127e-02f, 1.94815807e-02f, -5.31916693e-02f, 1.10128298e-02f, 4.09601517e-02f, 2.86758114e-02f, -3.32144834e-02f, 1.14881173e-02f, -2.71241106e-02f,
  3.14968713e-02f, -3.00278869e-02f, 4.90782224e-02f, 6.22014664e-02f, -6.96837083e-02f, -3.56601104e-02f, 7.38830678e-03f, -1.01563625e-01f, -6.81775669e-03f, 7.83196464e-02f,
  -5.46490103e-02f, 1.81313127e-01f, 5.92844523e-02f, 3.69920209e-02f, -2.95531526e-02f, 7.71207549e-03f, -6.06361702e-02f, -4.94813994e-02f, 2.30644587e-02f, 6.21418953e-02f,
  3.14006396e-02f, 3.24458890e-02f, 2.35801283e-02f, -2.43223663e-02f, 2.59738192e-02f, 6.10480197e-02f, 6.65517002e-02f, -7.83109758e-03f, 2.03837976e-01f, 3.28793819e-03f,
  4.80383672e-02f, 4.44310866e-02f, 4.51668128e-02f, 8.93348753e-02f, 2.03821119e-02f, 1.87018756e-02f, 1.71265919e-02f, -1.60091445e-02f, 2.36548055e-02f, -3.68347690e-02f,
  1.23801917e-01f, 3.42977852e-01f, 5.79848774e-02f, 2.63663888e-01f, -1.62086487e-02f, -4.15984727e-02f, 1.37843275e-02f, 9.76613462e-02f, 1.18132278e-01f, 6.65523345e-04f,
  -2.47394871e-02f, 1.07249044e-01f, 2.64915917e-02f, 1.75093353e-01f, 2.57249027e-01f, 2.35633012e-02f, 2.10090682e-01f, 7.39345793e-03f, 8.14234987e-02f, 2.60808289e-01f,
  1.20806381e-01f, 2.11066470e-01f, 9.29499790e-02f, 8.96234587e-02f, 9.30504426e-02f, -2.24363040e-02f, 9.39389691e-02f, -9.14938152e-02f, 2.22499555e-04f, -6.91998377e-02f,
  -5.70062511e-02f, 8.23557451e-02f, -1.10132117e-02f, -5.90788312e-02f, 4.33950834e-02f, -4.33139503e-02f, -8.87081847e-02f, -4.48475145e-02f, -2.04843916e-02f, -5.26811220e-02f,
  6.11813087e-03f, -1.77253783e-02f, -1.21126743e-02f, 2.93293763e-02f, -4.33359109e-02f, 3.22169960e-02f, 4.56518382e-02f, -3.32231931e-02f, 1.74511950e-02f, 4.86006178e-02f,
  6.89630210e-02f, 1.54505847e-02f, 1.94271374e-02f, 2.82727033e-02f, -1.73217023e-03f, 9.36237071e-03f, 1.91551149e-02f, -2.16865111e-02f, -3.13781947e-02f, 7.59959891e-02f,
  -2.81102620e-02f, 8.71991292e-02f, 3.97230014e-02f, -3.68203335e-02f, 9.78958458e-02f, 1.12186326e-03f, -7.52574671e-03f, -6.10593185e-02f, -2.44458988e-02f, 6.88048899e-02f,
  -3.29239317e-03f, 5.59289306e-02f, 1.51779559e-02f, 1.51440389e-02f, 8.99783894e-02f, 4.10828012e-04f, -6.90998137e-02f, -5.00695407e-02f, 1.08611407e-02f, 3.10000461e-02f,
  -1.26714157e-02f, 6.05795234e-02f, 4.46499512e-02f, -1.05188332e-01f, -4.34546359e-02f, -2.98489574e-02f, -2.50302744e-03f, 6.32649213e-02f, -2.87625864e-02f, 4.93706167e-02f,
  1.22359209e-01f, 2.82811403e-01f, 4.93028760e-03f, -6.67068064e-02f, -1.33206125e-03f, 6.91091865e-02f, 4.36264239e-02f, 3.58982757e-02f, 1.15188822e-01f, 4.66004647e-02f,
  -1.22366054e-02f, -2.14966387e-02f, -1.19512528e-02f, -2.34888047e-02f, 1.01300310e-02f, 1.07174657e-01f, 3.19701508e-02f, 2.74595805e-02f, 6.56702295e-02f, 6.38462827e-02f,
  5.95805161e-02f, 1.33640114e-02f, 4.59022932e-02f, 1.88971702e-02f, -2.87736789e-03f, -1.43642686e-02f, 5.03107347e-03f, -1.83246043e-02f, 1.30594606e-02f, 3.57759371e-02f,
  2.66119212e-01f, -1.79267913e-01f, -1.99668929e-01f, 4.65427972e-02f, 1.37716323e-01f, 2.22324133e-01f, -3.12376712e-02f, 1.53861623e-02f, 9.06075165e-02f, -1.30068511e-01f,
  -5.54877073e-02f, 8.86051506e-02f, -4.68938172e-01f, 1.75046474e-01f, 2.34404683e-01f, -1.99835122e-01f, 1.78528160e-01f, 8.41746628e-02f, 6.24829270e-02f, -5.11012748e-02f,
  1.11122839e-01f, 2.08286509e-01f, -1.90238550e-01f, 1.00344032e-01f, 1.49067109e-02f, -4.16196436e-02f, -1.19702883e-01f, -1.63044021e-01f, 1.24646053e-01f, 1.51789948e-01f,
  2.87752878e-02f, 3.61446431e-03f, 2.94046029e-02f, 9.65648592e-02f, -9.75249782e-02f, 3.27826701e-02f, 1.85445398e-02f, -1.41797448e-02f, 8.23812932e-02f, -2.96333265e-02f,
  -1.03248887e-01f, 1.34871691e-01f, 4.62233908e-02f, 7.86407106e-03f, 1.53051496e-01f, 8.15267041e-02f, -3.68529523e-04f, -4.47491519e-02f, -1.03802821e-02f, -1.70953140e-01f,
  -6.66625649e-02f, 1.84377283e-02f, 5.16711846e-02f, 1.19512388e-02f, -9.87185389e-02f, 1.50257513e-01f, 5.09716980e-02f, -1.22978479e-01f, -2.68137995e-02f, 1.06833965e-01f,
  -5.23587205e-02f, -3.83708663e-02f, -7.43394271e-02f, 5.12976246e-03f, -1.51549131e-02f, 1.20626641e-02f, 1.11672573e-01f, 1.17212804e-02f, -5.23928599e-03f, -1.21952128e-02f,
  3.64403836e-02f, 6.27861843e-02f, -2.99199838e-02f, 1.08982958e-01f, 8.46002251e-02f, 6.09729439e-02f, -1.60454269e-02f, -6.77712336e-02f, -5.45266196e-02f, 5.29856272e-02f,
  4.15921099e-02f, 7.73473158e-02f, -1.36164604e-02f, -5.62079288e-02f, 1.09296262e-01f, -8.92031714e-02f, -2.40315255e-02f, -1.34870242e-02f, -1.05669782e-01f, -6.40542656e-02f,
  -3.98261510e-02f, -9.42903608e-02f, 2.50450838e-02f, 7.12085292e-02f, -5.96880494e-03f, 1.04595631e-01f, 8.74804631e-02f, 4.38522249e-02f, 9.52139497e-02f, 3.88446562e-02f,
  -8.21848866e-03f, 3.99103723e-02f, -9.82559007e-03f, 3.84177864e-02f, 6.73324689e-02f, -4.49244715e-02f, -4.64819893e-02f, 7.05447644e-02f, -1.98477693e-02f, -5.85860685e-02f,
  -2.30616275e-02f, 1.24748923e-01f, 1.10160030e-01f, 7.18220696e-02f, -4.78902599e-03f, -2.27388348e-02f, 9.65631753e-02f, -1.78841297e-02f, -9.25657898e-02f, 3.67221683e-02f,
  3.02361637e-01f, -1.60007700e-01f, -1.81083918e-01f, 2.81849474e-01f, 5.98342679e-02f, 1.92930192e-01f, 1.00505523e-01f, 1.32010788e-01f, 3.37682992e-01f, 1.00640997e-01f,
  1.85567543e-01f, -1.96828961e-01f, -1.40098602e-01f, 3.94049555e-01f, -4.26676450e-03f, -1.31546259e-02f, 3.95132691e-01f, 1.72223121e-01f, 1.27171474e-02f, 1.29209474e-01f,
  8.51598158e-02f, 2.61603355e-01f, -1.45887896e-01f, 1.36307506e-02f, 4.24314067e-02f, -1.34222612e-01f, -1.18686832e-01f, -3.20291966e-01f, 5.84922768e-02f, -1.20045982e-01f,
  9.21310559e-02f, 3.20972055e-02f, -1.10053368e-01f, -1.88336335e-02f, 9.63861793e-02f, -8.53949506e-03f, -8.61309916e-02f, -1.36097372e-01f, -1.45513132e-01f, -7.96011928e-03f,
  -5.60036786e-02f, -2.42872648e-02f, 1.32787138e-01f, -6.71946704e-02f, 3.54536064e-02f, -2.06728764e-02f, 7.48307556e-02f, 3.59858274e-02f, -4.32236753e-02f, -7.15997964e-02f,
  -6.28733784e-02f, -1.95429102e-02f, 7.64861181e-02f, -7.25103691e-02f, -5.51603958e-02f, 5.71990274e-02f, -4.64158058e-02f, -1.55900776e-01f, 6.37956113e-02f, 3.63686588e-03f,
  -3.14480029e-02f, -7.76351541e-02f, -2.00491026e-02f, 4.21221703e-02f, 6.19553998e-02f, 1.75624117e-02f, 4.31180298e-02f, 5.87855242e-02f, 5.05166277e-02f, 3.52791557e-03f,
  8.78206417e-02f, 4.04382423e-02f, 8.62149894e-02f, -3.40483971e-02f, 4.96072061e-02f, -8.91536474e-04f, -7.80438110e-02f, 3.01399920e-02f, 7.52898827e-02f, 3.14594433e-02f,
  -3.67022790e-02f, 4.51659523e-02f, -1.08897611e-01f, -2.01397631e-02f, 3.96190882e-02f, -4.01173793e-02f, 1.02198988e-01f, 7.41459653e-02f, 5.56813627e-02f, -4.61856797e-02f,
  -1.92198425e-03f, -1.08460829e-01f, -2.09563859e-02f, -1.51573597e-02f, -1.29191810e-03f, 8.12958032e-02f, 7.81088471e-02f, 1.05087422e-02f, -5.94602898e-02f, 4.77883443e-02f,
  7.96446130e-02f, -2.52357870e-03f, 5.91758043e-02f, 1.48071600e-02f, -1.25369038e-02f, 1.30196093e-02f, 7.62147009e-02f, -9.08609107e-03f, 3.15720029e-02f, -6.12487756e-02f,
  -2.21731197e-02f, 5.54107279e-02f, 1.09771239e-02f, 4.72609103e-02f, 6.57756031e-02f, -5.42572215e-02f, 1.51340356e-02f, 2.71205623e-02f, -2.59599984e-02f, -7.83041760e-05f,
  1.49195239e-01f, -1.19804025e-01f, -2.37775564e-01f, -3.73769887e-02f, -1.51518196e-01f, 1.88718915e-01f, 4.15677816e-01f, -1.57266349e-01f, -1.83233351e-01f, 1.82371289e-01f,
  2.73157418e-01f, -5.80003150e-02f, 2.27857918e-01f, 3.63013983e-01f, 1.05840199e-01f, 1.88073546e-01f, 2.58961737e-01f, 2.05056161e-01f, -1.66924134e-01f, -3.52226235e-02f,
  -1.30147263e-01f, 2.22256199e-01f, 1.46665812e-01f, -2.23371953e-01f, 1.56884968e-01f, -2.77593225e-01f, 4.67725508e-02f, -7.44242594e-02f, 7.76171032e-03f, 4.40480821e-02f,
  1.46714911e-01f, -4.82339971e-02f, -2.42353994e-02f, -8.77568349e-02f, 1.66120306e-02f, 5.71252853e-02f, 1.20885022e-01f, 8.50376934e-02f, 4.60052527e-02f, 4.19781171e-02f,
  7.54071623e-02f, -1.13674380e-01f, -4.98391651e-02f, 9.29760095e-03f, -2.62479074e-02f, -3.74607518e-02f, -5.76310046e-02f, -5.23743592e-03f, -1.49976490e-02f, 2.88165100e-02f,
  -7.26985920e-04f, -3.90228373e-03f, -5.05314302e-03f, 2.11924836e-02f, -7.79145360e-02f, -3.46345417e-02f, 4.03252337e-03f, -1.22758057e-02f, -4.01348993e-02f, -3.92511040e-02f,
  5.21053486e-02f, -4.26150719e-03f, 4.45635468e-02f, 4.07664999e-02f, -5.11518903e-02f, 1.14209950e-02f, 1.80095080e-02f, -4.56357328e-03f, -6.49281442e-02f, 2.64086667e-02f,
  -5.06056920e-02f, -1.34453587e-02f, 4.66911308e-02f, 2.14119721e-02f, 6.16996586e-02f, 1.83504783e-02f, -2.90935598e-02f, 6.09176280e-03f, -1.79576036e-02f, -6.85876831e-02f,
  -2.64224093e-02f, -1.55923795e-02f, 3.16671804e-02f, 4.78386320e-02f, 1.00733094e-01f, 2.88898237e-02f, 5.01236543e-02f, 1.82535648e-02f, 3.08606331e-03f, -2.68621407e-02f,
  1.44264307e-02f, -1.33543923e-01f, -1.35676907e-02f, -2.79676411e-02f, -1.07643932e-01f, 8.96354392e-03f, 2.01980174e-02f, -2.75436398e-02f, -3.03882044e-02f, 1.53736202e-02f,
  -2.27433220e-02f, 8.93444463e-04f, -1.01495683e-01f, 2.13377904e-02f, -9.73374248e-02f, 3.87125090e-02f, 1.12844914e-01f, -4.14652862e-02f, 3.18047069e-02f, -9.21387225e-02f,
  -3.13342474e-02f, 8.21464974e-03f, -1.33113964e-02f, 4.36992384e-03f, -5.13301347e-04f, 4.81395461e-02f, -7.05882758e-02f, -5.06590381e-02f, -6.77094702e-03f, 1.55159002e-02f,
  -9.10466239e-02f, -4.03935730e-01f, -1.88850448e-01f, -9.18921083e-02f, 2.02197954e-01f, 2.13480547e-01f, -5.79861253e-02f, -1.32330403e-01f, -2.72742331e-01f, -6.87210634e-02f,
  -6.54058233e-02f, -1.98232338e-01f, -2.75823653e-01f, -1.83863625e-01f, -1.97687801e-02f, -3.23266089e-01f, -2.73826979e-02f, -4.89417426e-02f, -2.52507180e-01f, -7.28609622e-04f,
  -3.00383810e-02f, -2.43209954e-02f, -6.91495091e-02f, 1.40092880e-01f, 5.42164370e-02f, 2.21327633e-01f, 3.32562745e-01f, 1.28649324e-01f, 2.75511712e-01f, 3.66385430e-02f,
  -4.02800329e-02f, -2.15911582e-01f, -7.72676393e-02f, 2.91248448e-02f, 9.05666500e-02f, 1.40609071e-01f, 1.20713256e-01f, 3.56530473e-02f, 5.17672710e-02f, -2.65819412e-02f,
  8.25837106e-02f, -2.68745068e-02f, -5.48189916e-02f, -1.99788697e-02f, 1.18862959e-02f, 1.40400901e-02f, 7.31640588e-03f, -5.98411774e-03f, -7.62926787e-02f, -7.57289007e-02f,
  -1.00335374e-01f, 2.63012536e-02f, 2.54375078e-02f, 6.26520291e-02f, 1.20294429e-02f, 2.02479847e-02f, 1.24824002e-01f, 1.18080162e-01f, -3.59579897e-03f, 7.12123662e-02f,
  1.07443556e-02f, 8.47706199e-02f, 1.94184296e-02f, -1.32061914e-01f, -4.71656546e-02f, -5.91444923e-03f, -3.55122387e-02f, -2.19919942e-02f, -3.50147188e-02f, 9.08251572e-03f,
  7.12930039e-02f, -2.77580209e-02f, -9.27717686e-02f, 7.07708076e-02f, 3.78502160e-02f, -5.40664382e-02f, -4.64598089e-03f, 4.78034951e-02f, 5.27260229e-02f, -3.34368572e-02f,
  -8.81687105e-02f, 6.61691800e-02f, 8.76171589e-02f, 4.51502204e-02f, -9.40153226e-02f, 7.26893172e-02f, 6.18707463e-02f, -3.94861121e-03f, 6.11796090e-03f, 5.33622392e-02f,
  1.30945832e-01f, 5.91644086e-02f, -5.19317836e-02f, 6.99956389e-03f, -8.93414319e-02f, 3.58092338e-02f, -1.32893085e-01f, -2.50602867e-02f, 3.41538899e-03f, -3.50151286e-02f,
  1.64770558e-01f, 9.28323492e-02f, 1.45106211e-01f, 2.41700783e-02f, 3.02882250e-02f, 1.54935624e-02f, 7.36993104e-02f, 1.61735013e-01f, 3.66106555e-02f, 3.97573113e-02f,
  1.10199578e-01f, 1.31287441e-01f, -9.33414698e-02f, 4.29991223e-02f, 6.68136999e-02f, 9.41915661e-02f, 8.14195797e-02f, 4.89684045e-02f, 1.64971431e-03f, -1.30389417e-02f,
  2.45166525e-01f, 8.92480537e-02f, -7.59233981e-02f, 8.10947865e-02f, -4.00158316e-02f, -1.09260097e-01f, -1.63863897e-01f, 1.14191487e-01f, -1.63360402e-01f, -9.31970309e-03f,
  9.31268856e-02f, -5.64177409e-02f, -6.93454444e-02f, 2.37853497e-01f, 1.51965261e-01f, -7.15398192e-02f, 1.80918485e-01f, 9.11765397e-02f, -3.86169776e-02f, 1.88370764e-01f,
  1.49107918e-01f, 2.37777039e-01f, 1.43409312e-01f, 1.77843198e-01f, 1.18115522e-01f, 9.59504619e-02f, 2.14787811e-01f, -5.19713052e-02f, 1.89414695e-01f, 1.58744752e-02f,
  2.96692066e-02f, 2.68947259e-02f, 1.35221984e-02f, -6.70894980e-02f, 3.51707749e-02f, 5.74577898e-02f, -1.21678319e-02f, -1.33529259e-02f, -2.61456743e-02f, -7.01630581e-03f,
  -1.73720103e-02f, 6.28191754e-02f, 4.97408248e-02f, -3.62435468e-02f, 1.29790930e-02f, 1.28122382e-02f, 5.50018018e-03f, -1.25555888e-01f, -6.73056021e-02f, 7.66612291e-02f,
  -7.90280700e-02f, -4.05251607e-02f, -2.62407959e-02f, -1.55850295e-02f, -7.16184303e-02f, -2.27397215e-02f, -1.95797831e-02f, 3.77619527e-02f, -4.34668586e-02f, 2.40501985e-02f,
  1.60548791e-01f, -6.04288615e-02f, 1.69649310e-02f, 1.84745051e-03f, -4.18633819e-02f, 5.24233049e-03f, -4.44182567e-02f, -2.34987661e-02f, -3.37129422e-02f, 4.51363474e-02f,
  -6.59395196e-03f, 1.63042098e-02f, 4.07808606e-04f, 3.28465737e-02f, 9.23075378e-02f, -2.41418928e-02f, -1.03999861e-03f, -4.04204894e-03f, -1.47659918e-02f, -2.60750595e-02f,
  -4.10700329e-02f, -6.20830199e-03f, -1.71853472e-02f, -3.88075635e-02f, -4.82532158e-02f, -5.95386587e-02f, 8.28677490e-02f, 2.51536984e-02f, 1.13139814e-03f, 6.88317865e-02f,
  1.06949002e-01f, 1.92068040e-01f, 1.91085215e-03f, -1.92503296e-02f, -1.79476384e-02f, 4.99996804e-02f, 3.65944095e-02f, 2.55798548e-02f, 7.64382258e-02f, 4.64471243e-02f,
  9.54847336e-02f, -2.93201469e-02f, 3.03792860e-02f, 7.22191483e-03f, 5.37511660e-04f, 3.60015072e-02f, -2.43623555e-02f, -7.04945549e-02f, -1.63805354e-02f, 1.33765131e-01f,
  1.45739317e-03f, -2.56563574e-02f, -3.60033736e-02f, -6.43325001e-02f, 4.17687511e-03f, -6.08803071e-02f, 1.10371094e-02f, 2.93744188e-02f, 1.18075311e-02f, -5.74204314e-04f,
  2.04912484e-01f, -2.63619751e-01f, -2.27671742e-01f, -1.98954761e-01f, -1.03882462e-01f, -1.52730122e-01f, -1.97951928e-01f, -2.07805097e-01f, -1.43615857e-01f, -1.18145883e-01f,
  -1.70325756e-01f, 9.50157717e-02f, 8.64997655e-02f, -2.07698196e-01f, 3.01431835e-01f, 2.41833165e-01f, -1.89431876e-01f, -2.97216587e-02f, -5.02739288e-02f, -1.44821450e-01f,
  -3.58406194e-02f, -7.65431449e-02f, -3.80704962e-02f, -1.59318909e-01f, -1.77192599e-01f, -7.04781637e-02f, 1.31299302e-01f, -5.46913221e-02f, -1.19238809e-01f, -3.19848843e-02f,
  -9.73581597e-02f, -5.66357076e-02f, -7.52254128e-02f, 5.75036258e-02f, -1.36519000e-02f, -2.36428380e-02f, 4.16032001e-02f, 5.54589555e-02f, -3.62415332e-04f, -2.24629436e-02f,
  1.12058438e-01f, 1.12499692e-01f, -4.61696982e-02f, 1.18420891e-01f, -5.74727505e-02f, -9.62511525e-02f, 5.83547121e-03f, -4.85459231e-02f, -2.12638285e-02f, 5.98825440e-02f,
  -4.73912768e-02f, 1.36377783e-02f, -9.61497054e-02f, 1.82886142e-02f, -7.34379888e-03f, -7.56742945e-03f, 3.96084487e-02f, 6.63063154e-02f, 5.79035729e-02f, 2.52109040e-02f,
  -2.23885104e-02f, 1.26217440e-01f, 6.70654029e-02f, -4.25438257e-03f, -3.38316485e-02f, -2.54929103e-02f, -2.06379257e-02f, 4.85433415e-02f, -7.14733778e-03f, -1.68349911e-02f,
  -2.46543661e-02f, -9.21860412e-02f, -1.31816473e-02f, 3.06335371e-03f, 2.99253762e-02f, 6.69802874e-02f, -2.41156258e-02f, -3.50370668e-02f, -5.99761903e-02f, -1.30592203e-02f,
  1.12278340e-02f, 1.15137547e-02f, 6.77849632e-04f, 2.25821305e-02f, 1.72699206e-02f, 4.91077639e-02f, -7.09221661e-02f, 2.43293885e-02f, -1.04326144e-01f, 2.35655811e-02f,
  -4.36403789e-02f, -8.78391713e-02f, -6.86117634e-02f, -5.00559770e-02f, -2.80434024e-02f, 3.98534648e-02f, -2.71274429e-02f, -9.34051648e-02f, 4.32523945e-03f, -4.76819947e-02f,
  6.35372009e-04f, 2.87631191e-02f, -2.99002398e-02f, 4.08798717e-02f, -2.19107680e-02f, -6.62388727e-02f, 2.98865475e-02f, -3.32950763e-02f, -1.10894460e-02f, -1.98030137e-02f,
  -4.47759591e-02f, 1.53980777e-03f, 9.07732323e-02f, 7.54112890e-03f, 7.50145502e-03f, 5.72278425e-02f, 4.26704511e-02f, 2.79296655e-03f, 3.88657153e-02f, 3.26283905e-03f,
  1.49195641e-01f, 1.85462683e-01f, 9.80679840e-02f, 1.12977356e-01f, 2.30776638e-01f, -2.24972606e-01f, 3.03337611e-02f, 5.43701798e-02f, 1.71523601e-01f, -1.42335787e-01f,
  6.25160560e-02f, 8.85620713e-02f, -4.04609228e-03f, 3.36731225e-02f, -3.05323064e-01f, -1.30646586e-01f, -2.18387499e-01f, -3.57827060e-02f, 1.06947571e-01f, 4.70899232e-03f,
  -4.72796112e-02f, 2.50427984e-02f, -7.29238987e-02f, 7.63874352e-02f, 1.21121280e-01f, 5.67829758e-02f, -2.45398730e-01f, 2.80287620e-02f, 1.03339637e-02f, 2.05245651e-02f,
  -2.61401720e-02f, 6.87172636e-02f, 2.02872884e-02f, -5.08491173e-02f, -4.97951582e-02f, -3.15875821e-02f, -5.22029884e-02f, 5.40139079e-02f, 3.53593417e-02f, 2.62871035e-04f,
  4.39232439e-02f, -3.97643708e-02f, 2.05222070e-02f, 6.25394657e-02f, 2.01519094e-02f, 5.31009473e-02f, 1.14607766e-01f, 6.98442012e-02f, 3.51328962e-02f, -8.76622181e-03f,
  1.13676652e-01f, -3.93258110e-02f, -9.77418721e-02f, -3.52550559e-02f, 1.00045884e-02f, 5.02707586e-02f, -6.16575889e-02f, -8.48653689e-02f, -2.27589067e-02f, 7.47909944e-04f,
  -1.84568353e-02f, -2.87365820e-02f, -3.29536642e-03f, 2.99956258e-02f, 5.61961830e-02f, 5.98222204e-02f, -1.09167546e-02f, -1.89082883e-02f, -3.50123979e-02f, -2.18914617e-02f,
  -4.14066315e-02f, 3.21523696e-02f, 7.29991496e-02f, -2.65020207e-02f, -3.64414714e-02f, -6.40693232e-02f, -1.25923138e-02f, 2.71926429e-02f, -2.95517058e-03f, -1.49271023e-02f,
  4.66567092e-02f, -1.93467569e-02f, 1.96787473e-02f, -4.19427529e-02f, -7.05601126e-02f, 3.15848961e-02f, 4.20215391e-02f, 3.91915366e-02f, -2.33954005e-02f, -2.17206627e-02f,
  -3.68367761e-01f, -3.02338064e-01f, -8.37497786e-02f, -4.16017836e-03f, -2.50881817e-02f, -7.98494145e-02f, 4.63743741e-03f, -2.46097660e-03f, -1.05984986e-01f, -8.47287942e-03f,
  4.15046932e-03f, -2.97743478e-03f, -6.93283454e-02f, -3.30718830e-02f, -2.66801231e-02f, 3.65555957e-02f, 1.57971811e-02f, -1.64458789e-02f, -1.11521147e-01f, -8.02158713e-02f,
  -7.42043555e-02f, 4.46551889e-02f, -4.54810262e-02f, 1.81553829e-02f, -2.13410631e-02f, -6.80194702e-03f, 7.17306882e-03f, 5.07930294e-02f, 1.20874792e-02f, 1.66987535e-02f,
  1.09827414e-01f, -1.58465445e-01f, 1.19926505e-01f, 3.57772186e-02f, -1.74156785e-01f, -4.35687043e-02f, 1.07566513e-01f, -2.23949224e-01f, -7.42174312e-02f, -1.64436087e-01f,
  -9.69745889e-02f, 2.66392589e-01f, 1.56837344e-01f, -1.64893135e-01f, 3.15452963e-01f, 1.79899395e-01f, -1.17145024e-01f, 3.70828621e-02f, -6.92868307e-02f, -1.03316061e-01f,
  -3.42386290e-02f, -2.02386573e-01f, 1.01641696e-02f, -3.40932995e-01f, -2.01270849e-01f, -1.79821074e-01f, -1.65942125e-02f, 2.44038124e-02f, -1.44098833e-01f, 3.91770899e-02f,
  -1.69761702e-01f, -1.38247102e-01f, -5.42887338e-02f, -5.77431172e-02f, -1.20150685e-01f, 2.11997833e-02f, 1.09723642e-01f, 1.19330056e-01f, -5.21716056e-03f, 5.55556156e-02f,
  1.21603712e-01f, -3.54565457e-02f, -5.60022630e-02f, 4.41135168e-02f, -9.29605216e-02f, 9.50107072e-03f, -3.08871586e-02f, -5.96604384e-02f, -2.16253214e-02f, 2.80593382e-03f,
  1.16977878e-02f, -4.29214127e-02f, -1.12171024e-01f, 3.29189375e-02f, 1.10864706e-01f, -1.26867712e-01f, 8.71696845e-02f, 1.36577591e-01f, 4.33386005e-02f, -2.84922123e-02f,
  -5.24089788e-04f, 4.66006175e-02f, 9.39452834e-03f, -7.09937811e-02f, -2.22902726e-02f, -9.13827792e-02f, 4.57581542e-02f, 2.46607699e-02f, -4.90762591e-02f, -6.23666309e-02f,
  -5.99576011e-02f, 8.59115571e-02f, -2.36814693e-02f, 2.95081753e-02f, -7.51710981e-02f, 7.67144710e-02f, 6.76657930e-02f, -3.40892524e-02f, -7.02277049e-02f, -3.15219462e-02f,
  -7.64005035e-02f, 1.51182078e-02f, 2.24455241e-02f, -4.44705365e-03f, -6.25162199e-03f, 5.50553538e-02f, -5.22804931e-02f, -1.01074623e-02f, 9.22336522e-03f, 5.04466221e-02f,
  -1.65375113e-01f, -1.07008740e-01f, -3.61444913e-02f, -1.26253804e-02f, 3.29441614e-02f, 5.16753171e-05f, 3.86570171e-02f, 1.36240874e-03f, -5.23013547e-02f, 2.33251061e-02f,
  -5.08715473e-02f, -7.52657978e-03f, 2.83853561e-02f, 4.77367863e-02f, -3.82058993e-02f, -1.74629986e-02f, 3.29894833e-02f, 4.45664786e-02f, -2.18684226e-02f, -8.48388299e-02f,
  -2.07480416e-02f, 5.52914292e-02f, -6.41139597e-02f, 3.79024143e-03f, 1.10315182e-03f, -5.62448837e-02f, 4.82371524e-02f, 5.98092787e-02f, 4.98152114e-02f, 2.52519967e-03f,
  -6.01171458e-04f, 3.08357149e-01f, 2.78814971e-01f, -1.08811915e-01f, -9.98648629e-03f, 8.18789676e-02f, -1.45053506e-01f, 1.04982726e-01f, 1.55126145e-02f, 5.56600355e-02f,
  -1.50157928e-01f, 2.21212730e-01f, -1.19961634e-01f, 1.28311127e-01f, -1.83339611e-01f, -9.56819952e-02f, -6.31662115e-05f, 3.45457904e-02f, -4.52066511e-02f, -2.32176296e-02f,
  -3.82027850e-02f, -2.32716665e-01f, 6.63578585e-02f, -1.55090131e-02f, 1.28588557e-01f, 6.76862150e-02f, -1.93602934e-01f, -7.00526834e-02f, 9.89643410e-02f, -4.12186637e-04f,
  1.02487870e-01f, -1.82086229e-02f, 1.33705124e-01f, 1.01371586e-01f, -7.16564769e-04f, 8.91365635e-04f, 4.64357771e-02f, 1.55044999e-03f, -4.40473333e-02f, 3.76268402e-02f,
  8.88003595e-03f, 3.17260362e-02f, 3.82457934e-02f, 4.60093915e-02f, 7.49837235e-02f, 1.21435568e-01f, 4.54643853e-02f, 1.98542979e-02f, 1.18942909e-01f, 8.46532211e-02f,
  7.41393641e-02f, 1.29856169e-01f, 4.31930460e-02f, -3.29881087e-02f, 3.37210596e-02f, -3.93847190e-02f, 1.30376816e-02f, 4.66029719e-02f, 3.10607329e-02f, 5.52026369e-02f,
  -4.06244174e-02f, -3.06890775e-02f, 2.24833796e-03f, -1.07153086e-02f, -4.08910513e-02f, 3.16947289e-02f, 4.84316610e-02f, 2.21024957e-02f, -3.91898043e-02f, -3.98926586e-02f,
  -4.40452769e-02f, 1.34753622e-02f, -3.73676680e-02f, 3.84438187e-02f, -3.13967429e-02f, 7.09713921e-02f, 3.61439437e-02f, 2.88144425e-02f, -5.28845983e-03f, -1.03025334e-02f,
  -7.25396946e-02f, -4.60914858e-02f, -3.86926904e-02f, -6.86080800e-03f, 6.38244455e-05f, -9.72654112e-03f, -5.51046990e-02f, 1.04921430e-01f, -5.40888086e-02f, -6.97526857e-02f,
  -1.07316636e-01f, -2.42270648e-01f, -3.68685648e-02f, 2.92457398e-02f, -3.37255863e-03f, 2.44419444e-02f, -2.02188585e-02f, 1.09793358e-01f, -3.71160619e-02f, -5.42532504e-02f,
  2.51503624e-02f, -1.39383050e-02f, -1.17476713e-02f, 2.56291442e-02f, -2.78898934e-03f, -5.88240381e-03f, -1.22623451e-01f, -9.37608331e-02f, -6.99231401e-02f, -2.56294142e-02f,
  4.49206354e-03f, 6.56730495e-03f, -2.38395184e-02f, -3.89448665e-02f, 1.10729840e-02f, -9.74476039e-02f, 4.45960602e-03f, 4.93442230e-02f, -5.17782494e-02f, 2.82324515e-02f,
  3.47729057e-01f, -3.10566723e-01f, -2.34541699e-01f, 2.07163483e-01f, 2.12711737e-01f, 9.85345319e-02f, 1.06293932e-01f, 4.23192568e-02f, 1.59533080e-02f, -8.14999491e-02f,
  1.73084438e-01f, -1.54455364e-01f, -1.45169526e-01f, 3.21181744e-01f, 2.96099246e-01f, -9.68694910e-02f, 2.49300256e-01f, 2.82683484e-02f, -5.38635142e-02f, 7.09429383e-02f,
  1.59388915e-01f, 2.89688975e-01f, -1.73620190e-02f, -4.26146947e-03f, 1.56293437e-01f, -9.33543369e-02f, 5.86610287e-02f, -1.34262934e-01f, 1.01973109e-01f, 4.37261239e-02f,
  5.88543387e-03f, 8.31847489e-02f, 1.51123907e-02f, -6.06164262e-02f, 8.27707723e-03f, -8.26966390e-03f, -7.25495368e-02f, 2.16630418e-02f, 4.96960245e-02f, 2.09906301e-03f,
  -1.54264560e-02f, 3.07195028e-03f, 4.31894697e-02f, 4.17576032e-03f, 6.10146746e-02f, 3.97158116e-02f, 2.29831506e-02f, -7.09313750e-02f, -6.82474598e-02f, 1.58648733e-02f,
  -1.05608944e-02f, 3.23251076e-02f, 3.44335027e-02f, -2.68168729e-02f, 4.04683240e-02f, 2.80683488e-02f, -8.82033408e-02f, -7.16296136e-02f, -2.07647961e-02f, -5.36686694e-03f,
  -8.98284372e-03f, -3.86565626e-02f, -4.99596708e-02f, -7.47650163e-03f, 2.14311797e-02f, 5.62900975e-02f, -4.19309689e-03f, -1.53464982e-02f, -4.40053232e-02f, 1.19314706e-02f,
  2.83444002e-02f, 3.80481742e-02f, 1.96058527e-02f, 1.05380397e-02f, 5.28879575e-02f, -5.26886582e-02f, -1.28804231e-02f, 3.06994910e-03f, 3.84062380e-02f, 2.01703776e-02f,
  -2.91824341e-02f, 3.34340073e-02f, -7.27792736e-03f, 1.28548658e-02f, 5.87868690e-02f, 1.02387117e-02f, 6.10043332e-02f, -1.62355357e-03f, 3.58327962e-02f, -4.26673256e-02f,
  2.01300420e-02f, -1.40655532e-01f, -4.66843173e-02f, 1.21468250e-02f, 1.15264747e-02f, 2.06138529e-02f, -1.61720179e-02f, -3.12976725e-02f, -5.93515895e-02f, 1.88184232e-02f,
  7.04480335e-02f, -6.64390698e-02f, -5.77341393e-02f, 1.82244815e-02f, -3.16902157e-03f, 1.06736214e-03f, -1.46248667e-02f, -2.49515604e-02f, 3.25989462e-02f, 3.81282419e-02f,
  3.01055443e-02f, 5.28444676e-03f, -1.70077775e-02f, -3.14786918e-02f, 5.37256487e-02f, -2.36219969e-02f, -3.20788398e-02f, -6.01334730e-03f, -3.94259058e-02f, -5.24625294e-02f,
  -4.66299117e-01f, -2.41867796e-01f, -2.88312137e-01f, 2.69542243e-02f, 2.20979303e-02f, 4.35776412e-02f, -4.63402942e-02f, -8.83850306e-02f, -1.94662705e-01f, 1.53551415e-01f,
  1.53177127e-01f, -1.14745244e-01f, -2.12176308e-01f, 2.98184276e-01f, -7.79227912e-02f, -9.69645977e-02f, 1.17900200e-01f, 9.12218988e-02f, -7.35298023e-02f, -1.80025801e-01f,
  -4.19480018e-02f, 1.85399592e-01f, -3.64693813e-02f, 1.20683976e-01f, 6.47681532e-03f, 8.46143067e-03f, 1.06673032e-01f, -8.54647607e-02f, 2.71680415e-01f, 1.87976956e-01f,
  -7.91833550e-02f, -1.73546404e-01f, -5.41970879e-02f, -1.36942510e-02f, -2.86572054e-02f, 1.61357000e-02f, -5.28930090e-02f, 6.13218406e-03f, -1.66821163e-02f, 3.95277366e-02f,
  3.13916355e-02f, 8.01594835e-03f, 5.61992116e-02f, -1.99978682e-03f, -5.14188483e-02f, -9.54651274e-03f, -5.04380502e-02f, -4.19029593e-02f, -9.66181383e-02f, -5.70199117e-02f,
  -8.50012153e-02f, 2.30119489e-02f, -4.99044964e-03f, 3.51600945e-02f, -4.57386822e-02f, 3.80487181e-02f, 4.01566625e-02f, -8.55978504e-02f, 2.75301486e-02f, -4.43737209e-02f,
  2.28830725e-02f, -2.97945496e-02f, -1.11738563e-01f, 3.31817046e-02f, -2.10055034e-03f, 5.24028502e-02f, 1.80153865e-02f, 1.66638941e-02f, -1.28890052e-02f, -9.00512263e-02f,
  3.12521830e-02f, -1.14742387e-02f, 5.60408607e-02f, -7.59295654e-03f, 2.02981550e-02f, 3.06839752e-03f, -1.30678667e-02f, 6.38396479e-03f, -1.10719815e-01f, 5.17879203e-02f,
  -1.25602409e-02f, -4.27301181e-03f, -4.78709526e-02f, -1.13811549e-02f, 4.50284556e-02f, -1.12839431e-01f, 5.91543466e-02f, -1.34227321e-01f, 2.01022346e-03f, 3.56979109e-02f,
  -2.75621295e-01f, -2.92558223e-01f, -3.46211456e-02f, 4.28001732e-02f, 1.77250709e-02f, -3.18838060e-02f, 3.23650837e-02f, 4.77592181e-03f, -7.49539807e-02f, -1.81920379e-02f,
  -4.99226153e-02f, 7.60771036e-02f, -2.36877762e-02f, 2.19152495e-02f, 9.36224759e-02f, -2.40935842e-04f, 1.95419658e-02f, 8.85820668e-03f, -1.86420344e-02f, 2.90093366e-02f,
  -4.10566516e-02f, -6.00155517e-02f, 7.06846192e-02f, -3.89597900e-02f, 8.96475241e-02f, 7.04229530e-03f, -5.62733151e-02f, -1.14902640e-02f, 7.04443976e-02f, -6.23123068e-03f,
  2.51927733e-01f, -7.11848140e-02f, 2.15812191e-01f, 4.34107155e-01f, -4.77321334e-02f, -3.17630768e-01f, -2.20711917e-01f, 6.69467896e-02f, 2.59405822e-01f, -2.62195021e-01f,
  -1.79237857e-01f, 1.70056835e-01f, -4.07528102e-01f, 2.32416794e-01f, -4.66119200e-02f, -2.75610656e-01f, 1.70457810e-01f, 4.48428281e-02f, 7.52722174e-02f, 6.85551912e-02f,
  2.33398512e-01f, -3.43310609e-02f, 9.70535874e-02f, 6.63432032e-02f, 1.83893606e-01f, 2.26947531e-01f, 6.72407821e-02f, -1.46752838e-02f, 1.99583694e-01f, -5.12877898e-03f,
  1.89448474e-04f, 6.50202855e-02f, 8.51535946e-02f, 3.49515937e-02f, 2.84932405e-02f, -3.38526145e-02f, -3.58812436e-02f, -5.96922152e-02f, 3.14833000e-02f, 2.54874025e-02f,
  -5.56920320e-02f, 2.93809418e-02f, 8.27751160e-02f, 2.92775594e-02f, 7.53270835e-02f, 1.53088942e-01f, 7.67875016e-02f, -3.69354635e-02f, 5.08532189e-02f, 4.86688279e-02f,
  6.57805577e-02f, 1.56997759e-02f, 1.46318004e-02f, 2.64826640e-02f, -2.82479040e-02f, -2.32682563e-03f, 7.22518489e-02f, 4.92552407e-02f, 6.68337122e-02f, 7.66380429e-02f,
  -6.80959448e-02f, -7.43530393e-02f, -3.60855758e-02f, 1.09100267e-01f, 5.14052957e-02f, 1.23169157e-03f, -2.80856695e-02f, -2.31167804e-02f, -1.36662079e-02f, -4.61157784e-02f,
  8.67368355e-02f, 5.45691028e-02f, 5.48397563e-02f, 6.47175163e-02f, 9.69412830e-03f, 7.64331743e-02f, 5.79921412e-04f, 3.17696445e-02f, 2.85343658e-02f, 4.65600789e-02f,
  -4.81055826e-02f, -4.30373475e-02f, 1.33497445e-02f, 2.21025813e-02f, -2.90079620e-02f, -4.23621312e-02f, -2.19404325e-02f, 1.77178700e-02f, -7.47232651e-03f, 1.03410510e-02f,
  -2.57087260e-01f, -6.13994189e-02f, -6.39717877e-02f, 4.61294875e-03f, 6.78202603e-03f, 1.33703453e-02f, 4.60654460e-02f, 5.56336939e-02f, -7.57970214e-02f, -6.67794701e-03f,
  -6.01693243e-02f, 3.03351469e-02f, -2.69629769e-02f, 5.74950390e-02f, -3.13758217e-02f, 3.51771154e-02f, -7.28247175e-03f, 2.78516230e-03f, -3.09935794e-03f, 7.27104470e-02f,
  4.83320374e-03f, -1.46143526e-01f, 2.87782066e-02f, 3.62247005e-02f, -1.47476867e-02f, -3.32772397e-02f, 3.17824781e-02f, 2.06645373e-02f, 4.53001224e-02f, 3.40177789e-02f,
  -3.32591146e-01f, 5.41112840e-01f, 2.87604570e-01f, -7.43641779e-02f, 1.38996422e-01f, 1.62785649e-01f, -1.21849157e-01f, 1.26281843e-01f, 1.05002552e-01f, -9.60396677e-02f,
  -2.00375170e-01f, 1.73709974e-01f, -9.62245837e-02f, 9.43156518e-03f, -1.98862061e-01f, -1.47880808e-01f, -1.50239289e-01f, -4.08023074e-02f, 1.31507888e-01f, -2.87296399e-02f,
  -2.86698621e-03f, -1.09781049e-01f, -7.43877068e-02f, 2.35450357e-01f, 9.61971581e-02f, 6.89128414e-02f, -3.61053079e-01f, 1.62793145e-01f, 1.25501743e-02f, 1.70868292e-01f,
  -1.54408231e-01f, -1.29025012e-01f, -1.69015780e-01f, -9.12352428e-02f, -1.30115807e-01f, -7.49949738e-02f, -7.42387921e-02f, -3.48331444e-02f, -5.96193783e-02f, 5.55820717e-03f,
  3.02715078e-02f, 3.76476790e-03f, 3.26279141e-02f, 4.04651053e-02f, 6.11124618e-04f, 2.37791575e-02f, 7.25081861e-02f, 1.65196694e-02f, 3.54880169e-02f, 6.38548806e-02f,
  1.65740535e-01f, 5.22236228e-02f, -8.87357369e-02f, -3.00964694e-02f, 3.62471975e-02f, -1.03144282e-02f, 4.93918248e-02f, 1.03212729e-01f, 3.36302705e-02f, 2.00198926e-02f,
  2.60741953e-02f, -1.65955331e-02f, -2.06882078e-02f, -1.04230650e-01f, 5.95606528e-02f, 7.66712278e-02f, -2.46511330e-03f, -5.26944436e-02f, 4.25277948e-02f, -6.99280426e-02f,
  -4.20388356e-02f, -2.15699468e-02f, 1.67687684e-02f, -3.56016271e-02f, -1.19615765e-02f, -7.50912502e-02f, -4.93281595e-02f, 4.77385670e-02f, 2.63675414e-02f, -5.58092911e-03f,
  -1.47174019e-02f, -3.66636142e-02f, 1.75564922e-02f, -4.85391617e-02f, -3.61072607e-02f, 3.47142369e-02f, -5.80607802e-02f, 1.22105125e-02f, -7.53636658e-02f, 4.02979515e-02f,
  -2.36118704e-01f, -1.91855609e-01f, -8.14190805e-02f, -6.94431216e-02f, 3.08511965e-02f, -5.45367710e-02f, 3.29024298e-03f, 1.99352182e-03f, -7.87162259e-02f, -2.18206905e-02f,
  -3.69295925e-02f, -5.28424494e-02f, -5.00629842e-03f, 9.52165065e-05f, 3.42832617e-02f, -7.30633512e-02f, -6.26940206e-02f, -5.57630621e-02f, -1.07259624e-01f, 2.62006614e-02f,
  -3.10506299e-02f, -6.31489307e-02f, -1.06229283e-01f, -5.65212145e-02f, -2.76661646e-02f, -7.02065900e-02f, 3.05725671e-02f, 3.07701975e-02f, -2.85285413e-02f, -1.83995033e-03f,
  6.75983727e-02f, 2.85868526e-01f, -7.81815946e-02f, 4.10686731e-02f, 1.07073551e-02f, 2.86012948e-01f, 2.39207655e-01f, 7.68547207e-02f, 1.77184030e-01f, 1.82759166e-01f,
  -1.17017040e-02f, 1.68492079e-01f, 3.37987207e-02f, 1.23467162e-01f, 1.42092854e-01f, 2.62703579e-02f, 1.44613713e-01f, 1.30560905e-01f, 5.36032021e-02f, 1.05138317e-01f,
  -1.87318735e-02f, 1.98081061e-01f, -8.30299109e-02f, 4.52881716e-02f, 9.72609408e-03f, -9.78170112e-02f, -1.06147617e-01f, -7.10867643e-02f, -4.49202769e-02f, 6.40878603e-02f,
  -1.78939328e-02f, 4.61952314e-02f, -6.53965101e-02f, -4.10045162e-02f, -6.57583028e-02f, 1.26784248e-02f, -4.33818176e-02f, -5.25068957e-03f, -6.82433769e-02f, -2.52295304e-02f,
  3.93250026e-02f, 2.91866865e-02f, 9.73162502e-02f, 6.48962334e-02f, 6.42110929e-02f, -4.85825539e-02f, -3.83062288e-02f, -4.61030193e-02f, 5.72750531e-03f, 3.84921357e-02f,
  -5.89314699e-02f, -8.16086084e-02f, -3.67655717e-02f, 3.06756999e-02f, 2.79574865e-03f, -5.71438577e-03f, 5.87111786e-02f, 5.49604883e-03f, 7.24378824e-02f, 5.46697192e-02f,
  8.54673907e-02f, 4.94213216e-02f, 5.62228523e-02f, -4.20730039e-02f, 3.28691453e-02f, -7.23773614e-02f, 3.88021290e-05f, -1.23166125e-02f, 1.17993765e-02f, 5.33993095e-02f,
  -9.14186165e-02f, -3.34354583e-03f, -2.14529634e-02f, 4.35384959e-02f, 5.52282631e-02f, 3.56517583e-02f, -3.22414190e-02f, -2.22887844e-02f, -5.34983762e-02f, -8.03744495e-02f,
  -9.68247000e-03f, -2.55711097e-03f, 1.05412461e-01f, -6.07509054e-02f, -1.22039709e-02f, 1.07708247e-02f, 3.59384948e-03f, -3.50014009e-02f, -8.26307610e-02f, -3.68663147e-02f,
  1.93747371e-01f, 3.62057865e-01f, 1.60885379e-02f, 6.96951598e-02f, -3.34764794e-02f, 6.33378103e-02f, 6.09607510e-02f, 7.01309294e-02f, 6.86169490e-02f, 9.17515308e-02f,
  2.79110409e-02f, -2.40997821e-02f, -2.18714159e-02f, -8.27599131e-03f, -1.48581089e-02f, 6.33005351e-02f, -2.53457902e-03f, 2.28760508e-03f, -3.80161889e-02f, 7.02195093e-02f,
  -2.29346510e-02f, 3.22071202e-02f, 2.74917576e-02f, 7.21352466e-04f, 3.37586589e-02f, 7.77739286e-03f, 9.38167721e-02f, -3.02634388e-02f, 7.40688341e-03f, -1.38456402e-02f,
  -4.44053292e-01f, -2.22006012e-02f, -8.97326469e-02f, 1.67339444e-01f, -1.22938171e-01f, -1.52679920e-01f, -1.64119780e-01f, 3.39679699e-03f, -1.97397023e-01f, 4.85349540e-03f,
  3.31039317e-02f, -8.60684738e-02f, -4.21881750e-02f, 3.17794859e-01f, 2.20672846e-01f, 1.45874456e-01f, 2.60691643e-01f, 1.06528953e-01f, 1.31779209e-01f, 6.05754629e-02f,
  1.82057455e-01f, 2.54378706e-01f, 2.79816121e-01f, 2.19896451e-01f, 4.76534627e-02f, 9.46258754e-02f, 1.27647251e-01f, 6.57237228e-03f, 2.03354612e-01f, 1.07402885e-02f,
  -7.01120272e-02f, -4.33238931e-02f, 1.16085736e-02f, -4.49507125e-02f, -1.91368219e-02f, -4.57274131e-02f, -3.91573273e-02f, -2.54892129e-02f, 2.50044111e-02f, -2.16475572e-03f,
  -7.35523254e-02f, 3.22624221e-02f, 4.60377894e-02f, -1.24360677e-02f, -7.42878392e-02f, -1.72810443e-02f, -5.52272005e-03f, -4.66759801e-02f, -2.61923894e-02f, -1.88125689e-02f,
  -2.76842136e-02f, 5.21229878e-02f, 7.05812685e-03f, 3.83614562e-02f, -5.14238477e-02f, -5.07074818e-02f, 4.83219959e-02f, -5.61680607e-02f, 1.10219931e-02f, -2.68516764e-02f,
  1.90441739e-02f, -3.49542755e-03f, 1.17477179e-02f, 3.51078175e-02f, -1.26505308e-02f, 1.30518759e-02f, 1.14598041e-02f, 3.41089852e-02f, 2.11100318e-02f, 2.03493815e-02f,
  3.98115367e-02f, 3.52918021e-02f, -5.01615666e-02f, -3.67476270e-02f, 2.50029955e-02f, -4.63095587e-03f, 4.04364951e-02f, 2.49230443e-03f, -3.36553082e-02f, 8.10462087e-02f,
  -1.93567276e-02f, -4.94538359e-02f, -1.40064000e-03f, -4.05597221e-03f, 3.43829393e-02f, -2.77969316e-02f, 5.80090052e-03f, -3.23392637e-02f, -6.26493767e-02f, -3.33464295e-02f,
  -1.75423026e-01f, -5.67886094e-03f, -1.36764236e-02f, -1.08154498e-01f, 3.39609534e-02f, -3.05430172e-03f, 5.95041253e-02f, -2.13076733e-03f, -2.86586173e-02f, -1.90696120e-02f,
  -2.47119870e-02f, 2.44278368e-02f, -3.68109159e-02f, -9.94116254e-03f, 7.90132210e-02f, -8.79976675e-02f, 7.89145939e-03f, 1.14696636e-03f, -1.63964462e-02f, 4.49696966e-02f,
  -1.03398934e-02f, -2.19019074e-02f, 8.57251361e-02f, -1.14541268e-02f, 3.44877690e-02f, -3.93816382e-02f, -4.63051423e-02f, -1.92921888e-02f, 6.20201007e-02f, 7.08759576e-02f,
  -2.79704660e-01f, 2.40467161e-01f, -1.58177450e-01f, 2.21927643e-01f, -2.58193433e-01f, 2.39211798e-01f, 3.00781697e-01f, -6.44895956e-02f, 2.08554119e-01f, 2.61705875e-01f,
  3.06473114e-02f, 3.94930169e-02f, 8.64463001e-02f, 2.62264639e-01f, 1.39428750e-02f, 2.84841329e-01f, 2.73705900e-01f, 2.55343050e-01f, 1.30263455e-02f, -1.10889068e-02f,
  -7.36051938e-03f, 1.36611238e-01f, -8.57215077e-02f, -2.91545987e-02f, -1.23598590e-01f, -1.05954520e-01f, -1.59408644e-01f, -1.35904193e-01f, -1.74268801e-02f, -3.69673967e-02f,
  4.23860364e-02f, -7.37680867e-02f, -7.21235871e-02f, 6.02389239e-02f, 2.03610081e-02f, -3.29102986e-02f, -6.43017748e-03f, -4.16306965e-02f, -1.91985611e-02f, 2.83962954e-02f,
  3.75116244e-02f, -3.22465450e-02f, 6.16103746e-02f, -5.63353598e-02f, -3.54789346e-02f, -5.55971377e-02f, -6.96046278e-02f, -2.14013439e-02f, 1.10252956e-02f, -7.09769577e-02f,
  -1.53062474e-02f, -3.79708149e-02f, -2.05209330e-02f, 1.08028091e-01f, -2.26417203e-02f, 3.38474065e-02f, 7.82081187e-02f, -6.99893236e-02f, -5.76263713e-03f, -1.42973717e-02f,
  -1.00866228e-01f, 8.34205821e-02f, -6.47023832e-03f, -2.66584009e-02f, 4.85079400e-02f, 1.68630257e-02f, 9.97464824e-03f, 1.52181713e-02f, -1.26683796e-02f, -8.20827764e-03f,
  2.54198890e-02f, -6.75195307e-02f, 2.09903717e-03f, 7.46924663e-03f, 2.79477891e-02f, 3.88497487e-02f, -5.05848192e-02f, -3.73084135e-02f, 7.20906188e-04f, -1.12049460e-01f,
  2.84544900e-02f, 4.29540537e-02f, 3.70113947e-03f, -1.61334649e-02f, 4.19494063e-02f, -5.26601449e-02f, 3.59431878e-02f, -2.11755782e-02f, -3.74901332e-02f, -2.89053768e-02f,
  1.99994713e-01f, 1.99182630e-01f, 3.37010808e-02f, 5.94002828e-02f, 6.52848035e-02f, -2.07991116e-02f, 4.67791706e-02f, -1.80519447e-02f, 5.60191087e-02f, 1.69037003e-03f,
  -7.62998220e-03f, 4.99693342e-02f, 1.91005075e-03f, -1.07752286e-01f, -1.00916729e-03f, 3.74899954e-02f, 1.04396753e-01f, 4.04020399e-02f, 1.73056778e-02f, -6.11242950e-02f,
  -5.42560369e-02f, 4.65097055e-02f, -1.51741561e-02f, 4.10436839e-02f, 1.35277351e-02f, -2.13590059e-02f, -2.68550534e-02f, -6.75923005e-02f, -7.53933424e-03f, 5.23064919e-02f,
  -5.56735933e-01f, 6.87352270e-02f, -6.85760081e-02f, -1.16258144e-01f, -1.63133234e-01f, -1.42341048e-01f, -2.34196350e-01f, -5.26468456e-02f, -6.34043962e-02f, 1.14365235e-01f,
  -1.38758626e-02f, -5.07751182e-02f, 5.53341620e-02f, 4.02178196e-03f, 7.43778795e-02f, 2.86356151e-01f, -6.55722478e-03f, -3.92896757e-02f, 5.89016937e-02f, -2.33073115e-01f,
  -2.06419360e-02f, -8.60706642e-02f, 6.16152622e-02f, -2.03448553e-02f, -1.60224393e-01f, -1.17438026e-01f, 2.30199937e-02f, -6.20741658e-02f, -1.54486042e-03f, 4.97229397e-02f,
  -1.64008990e-01f, -2.03435048e-01f, -1.98226273e-01f, -4.47106250e-02f, -7.75599107e-02f, -1.08372010e-01f, -2.18659118e-02f, -4.49374467e-02f, -5.15238047e-02f, 2.99639441e-02f,
  -6.01714626e-02f, 7.36618275e-03f, -2.84715500e-02f, 2.29575206e-02f, -3.58009115e-02f, 6.25508977e-03f, 4.48879935e-02f, -9.52238776e-03f, -3.35632227e-02f, 5.97406328e-02f,
  -2.52747573e-02f, 1.07733011e-01f, -2.73635592e-02f, 6.57637715e-02f, -3.20091727e-03f, -1.51559990e-02f, 7.20785335e-02f, -2.13356148e-02f, 2.00500134e-02f, 2.03317739e-02f,
  6.82434067e-02f, -6.19519055e-02f, -3.84419188e-02f, -4.34293672e-02f, 3.43682766e-02f, 3.86017710e-02f, -3.69672216e-02f, 1.23867700e-02f, 2.45184358e-03f, 1.83115862e-02f,
  6.61122426e-02f, -8.56411085e-02f, -9.92736872e-03f, 3.66355292e-02f, 1.07036449e-03f, 8.90112575e-03f, -3.33152078e-02f, -5.31880111e-02f, 7.62666166e-02f, 2.11038459e-02f,
  -8.00898373e-02f, 1.28713716e-02f, 2.45378166e-02f, 4.08932529e-02f, -2.09823735e-02f, -3.08420928e-03f, -4.26006056e-02f, 5.97511791e-02f, -8.04169476e-03f, -4.76889312e-02f,
  -2.92488486e-01f, -2.16285333e-01f, -1.50215313e-01f, -2.55376697e-02f, -4.00041938e-02f, 4.17325199e-02f, -1.72572210e-02f, 8.85361526e-03f, -5.60345761e-02f, -4.20916341e-02f,
  -3.14815342e-02f, 7.29193166e-03f, -1.31904008e-02f, 2.08956171e-02f, -4.46136668e-03f, 2.12025400e-02f, -3.24862748e-02f, -6.76047243e-03f, -9.50895622e-02f, -3.98265608e-02f,
  -3.64395306e-02f, -1.45605365e-02f, -3.47580714e-03f, 5.32589341e-03f, -2.54872050e-02f, -1.44772241e-02f, -6.29394427e-02f, 4.23602797e-02f, -2.21429076e-02f, -3.63157131e-03f,
  -9.35555995e-02f, 1.02718748e-01f, -1.34412482e-01f, 1.43383041e-01f, 2.09798366e-01f, 3.51713300e-01f, 1.66550457e-01f, 2.46360660e-01f, 2.29575887e-01f, 8.25465247e-02f,
  2.16994375e-01f, -1.58069372e-01f, -4.50702235e-02f, 2.35255614e-01f, 2.73095686e-02f, 1.00658379e-01f, 2.05352858e-01f, 1.40592396e-01f, 2.73728371e-02f, 7.71304965e-02f,
  5.18573113e-02f, 1.31478131e-01f, -1.34647936e-01f, -9.75796860e-03f, 3.03250682e-02f, -1.09046452e-01f, -1.27953634e-01f, -2.29559898e-01f, 5.47176111e-04f, 4.51011583e-02f,
  5.65380491e-02f, 2.33006533e-02f, -2.84452718e-02f, -1.24736212e-01f, -6.35331273e-02f, -8.33521262e-02f, -9.57117900e-02f, -6.65920153e-02f, -8.40347484e-02f, 3.84843070e-03f,
  -1.89088937e-02f, -5.16162603e-04f, 2.41887588e-02f, -4.56620567e-02f, -3.60674933e-02f, -1.28317550e-02f, 3.42813060e-02f, 9.12584513e-02f, 7.16054589e-02f, -6.61889911e-02f,
  1.77315976e-02f, 6.14303052e-02f, 4.55069952e-02f, 2.66509969e-02f, 2.27675401e-03f, 6.24212623e-02f, -1.27631593e-02f, 3.95912901e-02f, 5.48110977e-02f, 1.23041272e-02f,
  -8.15163553e-02f, -2.46010884e-03f, -2.38543861e-02f, -3.62803675e-02f, -5.16035333e-02f, 4.53770049e-02f, 2.83876881e-02f, -1.32980179e-02f, -1.62700098e-02f, -5.64927049e-03f,
  6.38440251e-02f, 1.06613152e-02f, 1.12643398e-01f, -7.40264058e-02f, 2.59784162e-02f, 1.54707702e-02f, 2.43987348e-02f, 4.89084981e-02f, 4.36235890e-02f, 6.92914575e-02f,
  -8.55848342e-02f, 2.65103299e-02f, -2.02216348e-03f, -7.11484998e-02f, -3.06674168e-02f, 1.56406909e-02f, -2.44468488e-02f, 8.11829939e-02f, 2.61115469e-02f, -7.53346831e-02f,
  6.03132918e-02f, -7.21158534e-02f, 6.19150065e-02f, 2.07413826e-03f, -1.01595387e-01f, -4.11997922e-03f, -9.62143205e-03f, 2.28801370e-02f, -5.42175099e-02f, 2.67146062e-03f,
  -1.90783106e-03f, -3.13582271e-02f, -5.23973033e-02f, -2.58962195e-02f, -4.91370335e-02f, 1.44695938e-01f, -1.68044884e-02f, 3.47626302e-03f, -1.39567759e-02f, -1.75690297e-02f,
  -1.15500540e-01f, -1.03557520e-02f, -8.13455693e-03f, 3.87325659e-02f, 3.01525556e-02f, -3.04947291e-02f, -1.74870761e-03f, 5.00395223e-02f, -4.70167622e-02f, 5.22655360e-02f,
  -6.96154535e-02f, -1.97813898e-01f, 2.45315745e-01f, -1.84827477e-01f, 3.49784821e-01f, 2.14858398e-01f, 1.85763836e-01f, 7.59535730e-02f, 6.23347573e-02f, -2.88109273e-01f,
  -1.06897317e-01f, -8.77482444e-02f, 1.79584235e-01f, -2.52229899e-01f, 2.29537740e-01f, 1.36530578e-01f, -1.74787253e-01f, -1.52605012e-01f, 1.37890369e-01f, -1.75638571e-02f,
  3.10157388e-02f, -1.17150299e-01f, 6.76100627e-02f, -5.45313358e-02f, -1.58169046e-02f, -1.41558230e-01f, -2.03441948e-01f, 1.65705413e-01f, -2.74677455e-01f, 7.92295411e-02f,
  -6.04797155e-02f, -1.31726727e-01f, -8.07141811e-02f, -7.71567971e-02f, -5.34151159e-02f, 2.59202328e-02f, -4.52259332e-02f, 1.07742600e-01f, 3.49132977e-02f, 6.86663622e-03f,
  -4.80131619e-02f, -3.56815197e-02f, -1.98924672e-02f, -1.12357335e-02f, 6.31526206e-03f, -5.24157137e-02f, 4.94739898e-02f, 3.95822003e-02f, 3.56767625e-02f, 7.16200322e-02f,
  8.08783919e-02f, 3.76325734e-02f, 7.08426675e-03f, -8.79965350e-02f, 5.39983138e-02f, -5.84138334e-02f, 1.73732061e-02f, 3.00209057e-02f, -2.02039387e-02f, -2.07494777e-02f,
  -4.04160805e-02f, 4.35746135e-03f, 2.45273882e-03f, -4.95390892e-02f, 7.75806664e-04f, 5.10819517e-02f, -5.40568903e-02f, -2.64172330e-02f, 8.40117708e-02f, 1.28453467e-02f,
  1.43377930e-02f, -4.97231185e-02f, 3.97507921e-02f, 3.31705324e-02f, -4.88669090e-02f, -6.72696531e-02f, -2.07514223e-02f, 8.10539629e-03f, 3.90452147e-02f, 5.11885323e-02f,
  6.53467467e-03f, 2.73698997e-02f, 1.02522522e-01f, -8.02581850e-03f, -2.57418752e-02f, 3.53625976e-02f, -7.65930191e-02f, 1.79598108e-02f, -2.29544993e-02f, 8.52874741e-02f,
  -2.06475273e-01f, -2.91783839e-01f, -4.82638441e-02f, -1.15603760e-01f, -7.81003237e-02f, -7.42757767e-02f, -3.16302776e-02f, -3.87352780e-02f, -3.28537188e-02f, 6.65512010e-02f,
  -5.54374978e-02f, -4.62132469e-02f, -1.19500263e-02f, 5.21230744e-03f, 1.60528580e-03f, 5.55366976e-03f, -1.50702121e-02f, -4.75062355e-02f, -1.04242019e-01f, -7.33942017e-02f,
  -1.15647158e-02f, -3.51486839e-02f, 1.34170540e-02f, -1.05678188e-02f, -4.77892943e-02f, -4.16338854e-02f, -4.63674627e-02f, -1.79274715e-02f, 8.72812420e-02f, -1.10966032e-02f,
  -4.50768232e-01f, 2.98613399e-01f, 1.01792835e-01f, -2.99139738e-01f, 2.51680553e-01f, 1.61783248e-01f, -1.09937310e-01f, 2.53604233e-01f, 5.23309931e-02f, -1.03358679e-01f,
  -7.39184991e-02f, -1.97102249e-01f, 1.82268620e-01f, -1.14304408e-01f, -1.15376031e-02f, 4.92029898e-02f, -1.56563208e-01f, -2.13686585e-01f, 1.50060311e-01f, -1.25207648e-01f,
  -1.23318620e-02f, -4.86342944e-02f, 5.75496480e-02f, 2.72834718e-01f, 1.14440722e-02f, 3.82263958e-02f, -1.10458829e-01f, 1.99777320e-01f, -7.50730857e-02f, 4.68600132e-02f,
  -1.27278781e-03f, -6.68585896e-02f, 1.50295004e-01f, 1.05980679e-01f, 1.60074234e-02f, -4.74377051e-02f, -1.07038945e-01f, 3.62709276e-02f, 6.91456348e-02f, 9.78834555e-02f,
  -2.05057766e-02f, 8.98666084e-02f, -2.15478311e-03f, 5.98413832e-02f, 9.36498940e-02f, 1.05307676e-01f, 7.54740387e-02f, 2.59671118e-02f, 7.88671523e-02f, 2.22447366e-02f,
  2.42108703e-02f, 3.57047506e-02f, -3.86954546e-02f, -5.84175736e-02f, 3.51993777e-02f, 5.88906370e-02f, -7.07609430e-02f, -6.24818914e-02f, -5.39277084e-02f, -2.68677715e-02f,
  -1.56347100e-02f, 7.18769506e-02f, 3.24143656e-02f, 4.47563268e-02f, -1.20670814e-02f, -1.85424387e-02f, 9.15518496e-03f, -3.99392955e-02f, 1.01414666e-01f, -3.50963622e-02f,
  -4.59643006e-02f, -2.08347183e-06f, -7.40245776e-03f, -3.89621779e-02f, -6.55441582e-02f, -3.26203890e-02f, -7.44853765e-02f, -7.43212476e-02f, 2.28341054e-02f, -6.76186979e-02f,
  -1.91787928e-02f, -1.38407890e-02f, -4.52901516e-03f, 4.48088609e-02f, 5.88529259e-02f, 1.49250990e-02f, -1.58024002e-02f, -6.69169426e-02f, 2.64141280e-02f, -2.27083787e-02f,
  -1.16434358e-01f, -2.21211210e-01f, 1.09484091e-01f, 2.99875047e-02f, 1.54710989e-02f, 1.94632150e-02f, 3.60233113e-02f, 1.51989199e-02f, 9.82476622e-02f, 9.16768238e-03f,
  6.03436828e-02f, -7.85574969e-03f, -9.10903588e-02f, 4.47629718e-04f, -4.50108349e-02f, 2.06602328e-02f, -1.02095693e-01f, -3.59344259e-02f, -3.62786129e-02f, -7.91023951e-03f,
  -8.78432989e-02f, -5.78560121e-02f, -2.22590310e-03f, 7.36953244e-02f, -3.18308175e-02f, -6.43368661e-02f, -7.89520368e-02f, 7.14555150e-03f, -4.95520495e-02f, -2.35082023e-02f,
  -1.18346684e-01f, 2.01148078e-01f, 2.00955078e-01f, 1.52497282e-02f, -7.12486133e-02f, -2.40792185e-01f, -1.12365074e-01f, 3.93700339e-02f, -5.79907782e-02f, 2.09428415e-01f,
  -8.24127048e-02f, 1.64627448e-01f, -6.31885976e-02f, -1.23375423e-01f, -3.78695279e-01f, -2.56412715e-01f, -1.11710012e-01f, 3.39133828e-03f, -8.25107768e-02f, 1.60331860e-01f,
  -1.01879716e-01f, -2.31953159e-01f, -3.38676535e-02f, 2.16747131e-02f, 1.11640938e-01f, 2.39134088e-01f, 8.70728418e-02f, 4.40075547e-02f, 1.17402904e-01f, -1.08350947e-01f,
  1.18055078e-03f, 6.35147244e-02f, 1.50759071e-01f, 4.89174873e-02f, 2.53891405e-02f, 1.56085910e-02f, 4.35657101e-03f, -1.20497197e-02f, -5.13237566e-02f, 1.51449107e-02f,
  5.76557070e-02f, 3.97058949e-02f, 1.31309908e-02f, -5.11348695e-02f, 1.68128572e-02f, 3.63544226e-02f, 5.73301427e-02f, 6.27855733e-02f, 7.69485608e-02f, 2.74965586e-03f,
  1.18951902e-01f, 1.90807153e-02f, 5.55459782e-02f, 6.55544996e-02f, 4.62450422e-02f, -2.19314825e-03f, -2.21864600e-02f, 6.86191916e-02f, 5.56092821e-02f, -2.87768692e-02f,
  -7.48678744e-02f, -5.48083521e-02f, -7.55183622e-02f, -6.79216757e-02f, -7.28286430e-02f, 1.39334062e-02f, -5.98917156e-02f, -1.37326932e-02f, -2.09310967e-02f, 3.28953378e-02f,
  1.72820110e-02f, 2.65402161e-02f, -1.60158761e-02f, 3.19204703e-02f, -5.87958097e-03f, -6.41924217e-02f, 2.86531411e-02f, 3.26461904e-02f, 1.77587438e-02f, 8.07046965e-02f,
  4.58090156e-02f, -6.69064596e-02f, 6.81732642e-03f, -3.64961848e-03f, -1.16882913e-01f, 2.03184877e-02f, 2.15252955e-02f, 4.64475416e-02f, -5.39635355e-03f, 6.31573275e-02f,
  1.05643660e-01f, 1.45609349e-01f, 1.08119734e-01f, 6.27265945e-02f, 3.19852494e-02f, 5.22892550e-02f, -7.73345381e-02f, 6.29098713e-02f, 1.67026259e-02f, -7.44328052e-02f,
  5.67957647e-02f, 5.85940219e-02f, 1.84428077e-02f, -4.93630208e-03f, 2.40921061e-02f, 3.04563995e-02f, 7.38517195e-02f, 2.60458682e-02f, 1.11915424e-01f, 9.82193947e-02f,
  1.36925146e-01f, 9.49347764e-03f, -3.01594008e-02f, -1.73787214e-03f, 3.43491174e-02f, 5.31815775e-02f, 2.69967336e-02f, 1.38021931e-02f, 5.21281920e-02f, 4.27541025e-02f,
  1.32368840e-02f, 8.84445235e-02f, -2.21910045e-01f, -1.36546493e-01f, 4.62424681e-02f, 2.57182568e-01f, 6.62318803e-03f, -1.10888399e-01f, -2.87539274e-01f, 5.71448207e-02f,
  2.40273148e-01f, -3.03197503e-01f, 1.23977982e-01f, 3.23232651e-01f, -2.86420826e-02f, 2.49312341e-01f, 2.07523510e-01f, 1.73773736e-01f, 5.79535626e-02f, 1.86248701e-02f,
  -6.62626475e-02f, 3.59134942e-01f, 1.52175248e-01f, 1.61815152e-01f, 1.97812513e-01f, -1.41342461e-01f, 8.93119425e-02f, -8.13016668e-02f, 9.06883478e-02f, 8.47775787e-02f,
  3.21087539e-01f, -7.80237932e-03f, 1.15147509e-01f, -9.94910719e-04f, 5.53917186e-03f, 4.74423915e-02f, 1.65172666e-02f, -5.35628833e-02f, -6.39718696e-02f, -8.48262757e-03f,
  -1.51084185e-01f, -5.70177548e-02f, 4.58248891e-02f, 3.69476620e-03f, -2.67844535e-02f, -5.46395732e-03f, 6.97552785e-02f, 4.25338633e-02f, -5.60246930e-02f, 9.10927914e-03f,
  -4.35079113e-02f, -2.08062138e-02f, -8.63850638e-02f, 1.13693317e-02f, -1.26737237e-01f, -1.27099112e-01f, -8.75802413e-02f, -7.62627944e-02f, 8.89461394e-03f, -1.11055605e-01f,
  -3.23410816e-02f, 3.84605527e-02f, 1.17469899e-01f, 8.16552192e-02f, 2.28196345e-02f, 1.20612001e-02f, -4.97277267e-02f, 5.51968962e-02f, -8.31227824e-02f, 5.28961942e-02f,
  -2.36637257e-02f, -8.67147371e-02f, -8.05895552e-02f, 2.12254450e-02f, 6.71996847e-02f, 2.17447579e-02f, -1.53640732e-02f, -1.05788489e-03f, -6.32342603e-03f, 7.50568882e-02f,
  -1.39012719e-02f, -3.52198966e-02f, 5.26845232e-02f, 1.48575408e-02f, 1.68650001e-02f, -7.53391683e-02f, -4.96556936e-03f, 4.11724709e-02f, -5.51702268e-03f, 3.90990870e-03f,
  4.54742536e-02f, -1.80685833e-01f, 6.85310513e-02f, 1.80251809e-04f, 9.52847824e-02f, 1.54734075e-01f, 2.37994995e-02f, 3.89131568e-02f, 4.98948246e-02f, 4.38737161e-02f,
  -4.50970344e-02f, -7.70558603e-03f, -6.12494163e-02f, 4.00026441e-02f, 8.17882176e-03f, 2.02708077e-02f, -1.10232487e-01f, -6.66694045e-02f, -9.34211537e-02f, -7.14376941e-02f,
  2.82983873e-02f, -5.77373393e-02f, -4.86536771e-02f, 5.77638336e-02f, -5.07191569e-02f, -1.08211115e-01f, 1.66706461e-02f, -6.31320179e-02f, -1.61099117e-02f, -4.86612171e-02f,
  6.27344191e-01f, 8.83325934e-02f, 2.66096056e-01f, 2.56706178e-01f, 1.27185598e-01f, -1.13436535e-01f, 4.71187569e-02f, 1.07419565e-01f, 1.60287201e-01f, -7.22735152e-02f,
  -1.29588351e-01f, 1.95094272e-02f, -1.91393957e-01f, 6.98400438e-02f, -2.77193069e-01f, -2.27506444e-01f, -3.45085748e-02f, -4.05494310e-02f, 3.94738913e-02f, 5.17878793e-02f,
  1.08355870e-02f, -2.38124609e-01f, 2.35224646e-02f, -1.72839820e-01f, 2.91995555e-01f, 2.00610489e-01f, -2.14152992e-01f, -1.08153358e-01f, -6.11982401e-03f, -2.00417295e-01f,
  9.81243998e-02f, 1.61212146e-01f, 1.83920130e-01f, -2.81738006e-02f, 2.64606513e-02f, 4.98561785e-02f, 2.12729145e-02f, -5.82494549e-02f, 5.17080873e-02f, 6.67941011e-03f,
  4.55209278e-02f, 2.63562948e-02f, -2.54438147e-02f, -1.17329694e-01f, 1.43439427e-01f, 5.39499894e-02f, 9.80296806e-02f, 1.05964556e-01f, 7.55474046e-02f, 1.46113649e-01f,
  1.35145470e-01f, 1.44063801e-01f, 3.08543257e-02f, -7.51460297e-03f, 6.68587163e-02f, 7.13058338e-02f, -3.94459218e-02f, 2.02407781e-02f, 1.47464592e-03f, 6.36046007e-02f,
  5.49946167e-03f, -7.76342526e-02f, -1.56134199e-02f, 4.64246571e-02f, -6.87684119e-02f, 7.90854692e-02f, -1.18003689e-01f, -2.65947320e-02f, -2.14186106e-02f, -3.99609655e-02f,
  5.54201473e-03f, 9.30033345e-03f, -1.83368120e-02f, 1.68388858e-02f, 8.77811480e-03f, 6.47596344e-02f, -5.85816242e-02f, -6.48272261e-02f, 1.61679368e-02f, 4.94287759e-02f,
  -6.16617166e-02f, -4.30482849e-02f, -3.74408402e-02f, 7.46691367e-03f, -8.19465816e-02f, -7.52968937e-02f, 3.02133076e-02f, 4.82704975e-02f, 2.45333537e-02f, -1.03310063e-01f,
  -2.45724246e-01f, -2.92715520e-01f, 9.33494885e-03f, -1.97400823e-02f, -7.97412097e-02f, 4.90015484e-02f, -4.54410911e-02f, 2.83367224e-02f, -5.94405681e-02f, -2.36655697e-02f,
  6.60027862e-02f, 5.88313453e-02f, -4.65966351e-02f, -1.33997053e-02f, -1.13235988e-01f, -5.75293265e-02f, -4.66770157e-02f, -5.88325560e-02f, -6.06207624e-02f, -1.91176850e-02f,
  3.35059464e-02f, -2.89749652e-02f, -2.83487160e-02f, 6.99661076e-02f, 2.40866356e-02f, -2.88883150e-02f, -4.86915410e-02f, -1.53446924e-02f, -8.50298926e-02f, -5.10143228e-02f,
  -6.64554000e-01f, 2.71456927e-01f, 2.22239330e-01f, -2.44708434e-01f, 9.48380388e-04f, 2.80692484e-02f, 7.00618327e-02f, 1.05949380e-02f, -1.56896502e-01f, 9.63578597e-02f,
  1.26706004e-01f, -1.27588332e-01f, 2.65207261e-01f, 1.24778122e-01f, -1.76547855e-01f, 2.22201228e-01f, -1.09161608e-01f, -8.23027343e-02f, 1.74398683e-02f, -1.51344523e-01f,
  -1.02876738e-01f, -1.73195661e-03f, 1.09033756e-01f, 9.91890505e-02f, -6.35061190e-02f, -6.66004866e-02f, -4.68267724e-02f, 2.08030850e-01f, -6.57420978e-02f, 1.33514807e-01f,
  -1.68106109e-01f, -2.43027449e-01f, -6.81121275e-02f, -7.32116327e-02f, -1.11469775e-01f, -7.06985593e-02f, -5.23722125e-03f, 8.45204014e-03f, -4.47876826e-02f, -1.08638350e-02f,
  2.22384371e-02f, -1.21816760e-02f, -6.11763932e-02f, -2.28772070e-02f, -5.05588911e-02f, -2.28022542e-02f, 9.51114669e-02f, 5.10508902e-02f, 4.38833348e-02f, 4.15264145e-02f,
  4.68632877e-02f, 1.06004708e-01f, -2.56899968e-02f, 4.08044318e-03f, 2.78761629e-02f, 7.65531212e-02f, -5.16799232e-03f, 2.32800618e-02f, -1.35840461e-01f, -2.94684991e-02f,
  -1.89167317e-02f, -5.56529239e-02f, -1.80596262e-02f, 2.87188981e-02f, 6.50087669e-02f, -3.45127247e-02f, -3.04940473e-02f, 9.66964196e-03f, 2.08237721e-03f, 3.29574980e-02f,
  4.53633554e-02f, -8.49513263e-02f, -1.00526124e-01f, -5.68172485e-02f, -1.70670450e-02f, -2.92546637e-02f, 5.03451154e-02f, -5.88325784e-03f, 7.62291625e-02f, -3.26615945e-03f,
  -5.58404578e-03f, -2.50867102e-02f, 1.90304276e-02f, -5.22176223e-03f, 3.77310961e-02f, 3.14741321e-02f, 2.82371044e-02f, -1.87019724e-02f, -3.29330489e-02f, -9.16874874e-03f,
  -3.59588951e-01f, -3.36476147e-01f, -9.33516771e-03f, -8.74825642e-02f, -5.44872731e-02f, -8.58881995e-02f, 4.84571122e-02f, -5.94736226e-02f, -7.73087218e-02f, -8.83550942e-02f,
  -1.23334058e-01f, -3.85947861e-02f, -1.03832223e-01f, -2.61134226e-02f, 5.27939536e-02f, -2.29582433e-02f, 6.66146353e-03f, -4.08827253e-02f, -6.35581091e-02f, -3.67143080e-02f,
  2.55593676e-02f, 1.47815356e-02f, 2.73872577e-02f, -1.00260757e-01f, -6.90473989e-02f, -3.73156443e-02f, -1.11690357e-01f, -2.93508247e-02f, -5.95559739e-02f, 4.61314581e-02f,
  2.41394520e-01f, 9.21753645e-02f, 1.70471862e-01f, 1.15321137e-01f, -4.47440967e-02f, -1.55383095e-01f, -1.36868909e-01f, -1.40338484e-02f, 2.12779015e-01f, 5.12391068e-02f,
  -1.64818034e-01f, 1.63449183e-01f, -1.30801037e-01f, 3.31757143e-02f, -1.62481532e-01f, -6.67596608e-02f, -1.30226329e-01f, -2.27487758e-02f, 1.23603959e-02f, -1.26397625e-01f,
  -1.41021898e-02f, -3.18112463e-01f, -2.65185479e-02f, -2.39830956e-01f, 2.23774295e-02f, 5.55182770e-02f, -1.20483279e-01f, -1.66847289e-01f, -8.51263572e-03f, -1.08589619e-01f,
  5.30998707e-02f, 5.76533638e-02f, 7.19385296e-02f, 4.03463915e-02f, 1.97516885e-02f, -1.02898041e-02f, -4.58752401e-02f, -6.77172393e-02f, -7.94788525e-02f, 6.08352013e-02f,
  4.39251289e-02f, 2.30818312e-03f, -1.36761749e-02f, -4.53354977e-02f, 2.51070336e-02f, 6.48644939e-02f, 9.85021144e-02f, 1.34074330e-01f, -3.41214985e-03f, 1.07809581e-01f,
  -2.98047103e-02f, 1.04472548e-01f, 1.44973807e-02f, 2.21092738e-02f, 5.66906407e-02f, 3.68610471e-02f, -2.88173053e-02f, 3.94292995e-02f, 3.63890119e-02f, 3.57430913e-02f,
  -5.79900667e-03f, -7.57680982e-02f, -4.20468301e-02f, 1.76417530e-02f, -1.12832859e-01f, -3.99192981e-03f, -5.93635216e-02f, -1.52686471e-02f, 2.39907540e-02f, 4.72197048e-02f,
  -6.34965226e-02f, 8.82105082e-02f, -3.94959711e-02f, -5.26573090e-03f, -1.56543989e-04f, 5.33486567e-02f, -4.76646051e-02f, -5.03109442e-03f, -2.12283731e-02f, 2.67478283e-02f,
  -9.28452760e-02f, -3.08463797e-02f, -2.40042321e-02f, 1.24556404e-02f, -3.50301228e-02f, 5.28500229e-02f, 6.45038858e-02f, 1.05948418e-01f, 8.01807344e-02f, -1.29335135e-01f,
  -1.39145374e-01f, -2.16485262e-01f, 4.87529978e-05f, 4.26245481e-02f, -5.86677715e-02f, 1.29450746e-02f, -4.50990982e-02f, 3.54959592e-02f, -9.07610059e-02f, -1.52656417e-02f,
  4.08390351e-02f, 1.57209653e-02f, -1.23744998e-02f, 4.18164879e-02f, -7.63498768e-02f, -2.53339801e-02f, -5.70095144e-02f, 7.93956686e-03f, -1.39918342e-01f, 4.13911156e-02f,
  -2.22443677e-02f, -6.42083585e-02f, -1.89164688e-03f, 1.42783983e-05f, -2.45688055e-02f, 2.88159885e-02f, -3.25322598e-02f, 7.02447966e-02f, -8.96608159e-02f, -4.35620584e-02f,
  -3.80598724e-01f, -2.86741927e-02f, 3.50273460e-01f, -3.28206211e-01f, 1.35011092e-01f, 2.43024260e-01f, 9.17775780e-02f, -3.45237069e-02f, -1.49787754e-01f, -1.98049366e-01f,
  -3.20331194e-02f, -7.89368749e-02f, 1.74627557e-01f, -1.83780864e-01f, 2.23443732e-01f, 1.01628803e-01f, -1.30460635e-01f, -1.45315260e-01f, 7.30839819e-02f, -7.40332082e-02f,
  -2.14518257e-03f, -5.66170104e-02f, 1.71732157e-01f, -1.56053770e-02f, 1.22019835e-02f, -9.50012133e-02f, -2.90359743e-02f, 1.90606117e-01f, -1.22899584e-01f, 9.79752690e-02f,
  3.04608364e-02f, -1.97095111e-01f, 3.33272479e-02f, 3.98449115e-02f, 7.20485253e-03f, 1.22129591e-02f, -1.40202446e-02f, 6.96993470e-02f, -5.01282252e-02f, -5.39696999e-02f,
  -2.30948459e-02f, 6.96955398e-02f, -1.13731116e-01f, 4.53505628e-02f, -2.00146772e-02f, 1.37555087e-02f, 9.28515196e-02f, 4.82507460e-02f, 4.14838493e-02f, 1.17977351e-01f,
  9.93210450e-02f, 2.44227834e-02f, 5.04199043e-02f, -5.15632331e-02f, 8.94284472e-02f, -9.05564800e-03f, 2.16204636e-02f, 3.07246726e-02f, -2.50357315e-02f, -4.69027385e-02f,
  -6.26131892e-02f, -2.74297153e-03f, 4.89707999e-02f, 2.39153542e-02f, 9.28823370e-03f, -1.90206263e-02f, -1.64198745e-02f, 6.78472919e-03f, -2.72046379e-03f, -8.12583696e-03f,
  -9.92581435e-03f, 1.04482584e-02f, 1.10441083e-02f, -3.48325148e-02f, -3.45424227e-02f, -3.91786024e-02f, 1.85296368e-02f, -4.27567735e-02f, 2.80003008e-02f, 8.03365745e-03f,
  1.47582777e-03f, 1.21580157e-02f, 2.26269546e-03f, -9.72391665e-03f, 2.50941217e-02f, 5.36794476e-02f, -9.59793199e-03f, 4.56521200e-04f, -2.85794437e-02f, 1.07119583e-01f,
  -4.62104604e-02f, -2.32333377e-01f, 3.42050008e-02f, -4.61746659e-03f, -4.50740382e-02f, 3.22457217e-02f, 1.93708185e-02f, -1.50696207e-02f, -3.25336196e-02f, -6.25565425e-02f,
  -8.89079422e-02f, -3.51730473e-02f, -3.01216114e-02f, 5.18929139e-02f, 3.59709673e-02f, 5.74844852e-02f, -5.99959455e-02f, -7.86821470e-02f, -2.09801700e-02f, -3.35869789e-02f,
  -6.39096787e-03f, -8.16172063e-02f, 5.26756682e-02f, -3.52563709e-02f, -4.32797894e-02f, -1.11958673e-02f, -9.15228426e-02f, -1.39526557e-02f, -3.39138545e-02f, -9.11859516e-03f,
  -5.93220862e-03f, -3.54864448e-01f, 4.27774340e-02f, -3.00923407e-01f, 1.91260159e-01f, 3.45869392e-01f, 2.02763066e-01f, -1.41005367e-01f, -4.30253237e-01f, -1.80266380e-01f,
  1.55838236e-01f, 3.27254646e-02f, 1.24876876e-03f, -5.71962446e-03f, 3.76420736e-01f, -1.29531384e-01f, -7.33137950e-02f, 8.84094238e-02f, -1.23086460e-01f, -3.87489796e-02f,
  -7.16489702e-02f, 4.58708331e-02f, 8.37257951e-02f, 4.15509567e-03f, 9.55950990e-02f, -7.06158802e-02f, 1.06404506e-01f, 2.38935515e-01f, 1.20675750e-01f, 1.98634967e-01f,
  5.14796861e-02f, -2.04125881e-01f, -4.25197780e-02f, 2.08994485e-02f, 9.01733860e-02f, 4.67698984e-02f, 7.94512853e-02f, 2.05254778e-01f, -2.05100924e-02f, -3.98781244e-03f,
  1.63486730e-02f, 9.95484367e-03f, -8.57800990e-02f, 2.51245461e-02f, -8.04064125e-02f, -8.87701958e-02f, -7.57418498e-02f, -1.08918689e-01f, -2.58303210e-02f, 2.78991740e-02f,
  -7.93075189e-02f, -8.85158703e-02f, -1.12593263e-01f, -8.34496543e-02f, -8.31944197e-02f, -7.64739141e-02f, -1.08734407e-01f, 1.89896494e-01f, -1.21092945e-01f, 1.26567809e-02f,
  3.77143808e-02f, 6.06222451e-02f, -1.17234625e-02f, 8.89775518e-04f, 1.46990875e-02f, -1.60565730e-02f, -7.80460797e-03f, -7.09742075e-04f, 4.41405065e-02f, 3.42770014e-04f,
  -7.08052367e-02f, -7.69494846e-03f, -6.15724996e-02f, -8.41608495e-02f, 2.85852198e-02f, -1.64965138e-01f, 5.55682518e-02f, 3.55634242e-02f, -3.96116972e-02f, -2.66906545e-02f,
  -7.90912285e-02f, 1.23434300e-02f, 4.79183905e-02f, -5.75994775e-02f, 1.70248374e-03f, 7.40939453e-02f, -3.67331803e-02f, 5.46643510e-02f, -7.46781230e-02f, 8.91610608e-02f,
  -2.69533298e-03f, -1.45938948e-01f, -4.36368361e-02f, -1.84139665e-02f, 7.25278556e-02f, 3.00560389e-02f, 2.39377562e-02f, -4.91367504e-02f, 9.71381273e-03f, 3.49974819e-02f,
  6.33403212e-02f, -2.01402940e-02f, -3.34338881e-02f, 8.14092066e-03f, 3.99339758e-02f, -5.51664904e-02f, -1.34870876e-02f, 1.10653630e-02f, -2.06280090e-02f, 7.83296861e-03f,
  -1.03827447e-01f, -9.04970989e-02f, 3.95312123e-02f, -3.13991830e-02f, -8.58751535e-02f, 2.63535660e-02f, -3.38961259e-02f, -3.58464778e-03f, 3.52764055e-02f, 4.24318900e-03f,
  -1.37378141e-01f, 5.14384389e-01f, 2.94979364e-01f, 3.68462861e-01f, -1.51234910e-01f, -4.67576355e-01f, -9.24276710e-02f, 8.46515223e-02f, 1.70501322e-01f, 1.11010462e-01f,
  4.46599834e-02f, 3.24950248e-01f, 7.79177770e-02f, 1.86524034e-01f, -2.45674685e-01f, -9.96663198e-02f, -2.61558406e-02f, -6.89652329e-03f, 8.20434466e-03f, 1.30199715e-01f,
  1.24828108e-02f, 1.21014208e-01f, 9.40646455e-02f, 3.26686762e-02f, 5.78517243e-02f, 1.97964922e-01f, -1.74800977e-02f, 1.22112401e-01f, 5.77914827e-02f, -7.06828162e-02f,
  -1.62039757e-01f, 2.93898195e-01f, 1.39286732e-02f, -3.83158587e-02f, -5.40300161e-02f, -1.20195344e-01f, 9.98307113e-03f, 4.10099253e-02f, 2.67000403e-02f, 2.73514222e-02f,
  -2.39560492e-02f, -4.32091616e-02f, -2.31719799e-02f, -9.82213113e-03f, -2.57993750e-02f, 4.17393558e-02f, 1.66851040e-02f, -5.99481128e-02f, 1.52271762e-01f, -4.06418219e-02f,
  8.52150843e-02f, -1.00569213e-02f, -2.46386491e-02f, 6.49592206e-02f, -5.56711899e-03f, 2.79068202e-02f, -1.63376518e-02f, -4.05970821e-03f, 1.49965100e-02f, -7.56476121e-03f,
  1.13250971e-01f, -5.87549955e-02f, 5.51649593e-02f, 2.18483768e-02f, 4.82837185e-02f, 7.07766935e-02f, 6.53814524e-02f, -8.77854601e-02f, 3.92659046e-02f, -3.04404739e-02f,
  -7.56207705e-02f, 1.14277368e-02f, -6.70860987e-03f, -7.67203420e-02f, 4.61931340e-02f, 1.09564491e-01f, -3.83366905e-02f, -5.57387471e-02f, -1.03398059e-02f, -8.04977491e-02f,
  1.28530338e-01f, -3.53970639e-02f, 4.33836654e-02f, -2.04138666e-01f, -4.91100214e-02f, 9.24377814e-02f, 6.88372776e-02f, 4.54182401e-02f, 2.86316220e-02f, -1.05586499e-01f,
  -8.84643942e-02f, 2.69997656e-01f, -2.18955018e-02f, -3.89579460e-02f, 7.55561367e-02f, -6.06846139e-02f, 5.07129282e-02f, -6.08723909e-02f, 1.14250071e-01f, -3.05489376e-02f,
  -4.98592257e-02f, -9.70575064e-02f, -1.12769306e-01f, -4.55729924e-02f, 1.49668483e-02f, 4.60087508e-02f, 1.42802624e-02f, 1.53495511e-02f, 2.18201410e-02f, 1.68025531e-02f,
  -1.77066866e-02f, 9.38266292e-02f, -1.41814882e-02f, -4.84251529e-02f, -8.49544033e-02f, 5.41400239e-02f, 2.39123330e-02f, -2.85128858e-02f, 1.47034200e-02f, -3.81697062e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.32352039e-01f, 2.15884522e-01f, 3.39569151e-01f, 2.17949048e-01f, 1.00125432e-01f, 2.23252848e-01f, 2.58090496e-01f, 1.36257052e-01f, 2.22460389e-01f, 2.24562138e-01f,
  1.91838816e-01f, 2.92320043e-01f, 1.90337420e-01f, 2.17911571e-01f, 2.27376848e-01f, 1.28181726e-01f, 2.47943178e-01f, 1.68280363e-01f, 2.84033567e-01f, 3.04408491e-01f,
  2.02404901e-01f, 2.94348240e-01f, 2.85757184e-01f, 2.10687935e-01f, 2.00692728e-01f, 3.06517273e-01f, 1.83668017e-01f, 2.14424625e-01f, 1.28764689e-01f, 9.50483307e-02f,
  2.11048573e-01f, 2.57673115e-01f, 2.31700107e-01f, 2.54723579e-01f, 2.09449694e-01f, 3.01040113e-01f, 2.27934152e-01f, 1.35557175e-01f, 2.18139365e-01f, 1.58758312e-01f,
  1.71130255e-01f, 1.90614998e-01f, 3.01979333e-01f, 1.60848379e-01f, 2.82758504e-01f, 1.62928417e-01f, 2.21153915e-01f, 2.03312367e-01f, 1.89474627e-01f, 2.01628387e-01f,
  2.98393011e-01f, 2.84942508e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -3.41475531e-02f, -3.73523504e-01f, -8.62559006e-02f, -1.26837730e-01f, 1.21833384e-01f, -2.49811858e-01f, -2.55709827e-01f, -4.04613942e-01f, 6.01607114e-02f, -1.00447737e-01f,
  1.27457932e-01f, -3.70769739e-01f, 1.29623428e-01f, -7.27084931e-03f, -1.16704507e-02f, 1.62615344e-01f, 3.75914089e-02f, -1.15383841e-01f, -2.00336576e-01f, -1.11721560e-01f,
  -1.23558402e-01f, -1.06491171e-01f, 4.48715128e-02f, 1.59316808e-02f, -2.34279886e-01f, -1.52565300e-01f, 7.50667676e-02f, -2.08043367e-01f, 5.49754165e-02f, -3.71216200e-02f,
  -6.50703162e-02f, -1.59524485e-01f, 1.14309542e-01f, 1.64535362e-02f, -3.18766266e-01f, -8.82507488e-02f, -2.15054184e-01f, -3.82765383e-02f, -2.83324867e-01f, 3.37978601e-01f,
  -7.66243190e-02f, -1.02734774e-01f, 1.92783028e-01f, -4.07937527e-01f, -2.11685255e-01f, 2.97285378e-01f, 1.63626969e-01f, -3.57135952e-01f, 6.61326051e-02f, -2.57004917e-01f,
  1.65269494e-01f, 2.53537655e-01f, -1.72827646e-01f, 1.38201371e-01f, 1.53033540e-01f, 2.21227288e-01f, -3.42828423e-01f, 1.93474680e-01f, 2.65382171e-01f, -2.67893881e-01f,
  -3.36701542e-01f, 1.15280926e-01f, 1.09496869e-01f, -3.75926435e-01f, 2.25437358e-01f, -3.34486872e-01f, -2.18528155e-02f, 4.39884923e-02f, -1.60061773e-02f, -1.84745029e-01f,
  -1.40181199e-01f, -1.22255616e-01f, -1.92200676e-01f, -3.19279671e-01f, -2.99017429e-01f, -1.46297812e-01f, 1.32525951e-01f, -3.31953824e-01f, -2.79235244e-01f, -2.00962141e-01f,
  -1.87907383e-01f, -2.92318255e-01f, -2.67075270e-01f, 4.79804814e-01f, -3.10764015e-01f, -1.02812283e-01f, -6.57217950e-02f, 3.45408142e-01f, 1.47795185e-01f, 1.46069765e-01f,
  -2.96279103e-01f, 1.31356288e-02f, -1.76054761e-01f, -1.52443990e-01f, -8.37904736e-02f, 5.01220644e-01f, 1.45522445e-01f, -1.92995042e-01f, -1.12072282e-01f, -1.17659427e-01f,
  -4.54431772e-01f, 1.01250529e-01f, 4.11635965e-01f, -2.63146996e-01f, -1.48246288e-01f, -1.39888436e-01f, -2.10431010e-01f, -4.96553071e-02f, -3.63410860e-02f, -3.21907066e-02f,
  3.67636770e-01f, -1.77821711e-01f, -3.94526452e-01f, -1.39114082e-01f, 3.21013391e-01f, 4.04439867e-01f, 3.94864053e-01f, 2.05428615e-01f, -4.65921760e-01f, -2.08918065e-01f,
  -9.73433852e-02f, 3.90417457e-01f, -4.57873456e-02f, 3.34795356e-01f, -4.92219143e-02f, -1.23007081e-01f, -3.69861186e-01f, 9.01503861e-02f, 3.10229599e-01f, 3.32454443e-01f,
  -1.37877882e-01f, -1.70725912e-01f, 5.79144470e-02f, 1.66825250e-01f, -2.11033970e-01f, 3.63791078e-01f, -2.31358126e-01f, 8.98304880e-02f, -1.16540685e-01f, 1.69767290e-01f,
  2.61561163e-02f, -3.31329256e-01f, -3.83216143e-02f, -3.63477051e-01f, -2.13314518e-01f, 1.50290966e-01f, -1.33937791e-01f, -4.63348590e-02f, 1.66426301e-01f, -1.64579779e-01f,
  1.64678797e-01f, -2.91560084e-01f, -1.35579348e-01f, -1.60249993e-01f, -9.58556775e-03f, 1.77245498e-01f, 6.86579719e-02f, 1.72948256e-01f, 2.02701092e-01f, -1.09928839e-01f,
  -3.35537404e-01f, 1.07438743e-01f, -1.71610519e-01f, -2.81324629e-02f, 2.97775239e-01f, -3.52517724e-01f, 1.73078120e-01f, -1.92120999e-01f, 4.56189513e-01f, 3.68534207e-01f,
  9.95528176e-02f, 4.49417263e-01f, -2.93887258e-01f, 1.94544289e-02f, 2.68973172e-01f, -1.58355176e-01f, 3.65143001e-01f, 1.32389545e-01f, -3.26169968e-01f, -2.33928077e-02f,
  -6.19974621e-02f, -4.64996994e-01f, 2.32352421e-01f, 6.88755214e-02f, 2.05954522e-01f, -4.85177517e-01f, 4.48523045e-01f, 3.30960095e-01f, 3.36032063e-01f, 3.30329448e-01f,
  3.51665348e-01f, 4.02893931e-01f, -1.27690151e-01f, 1.24810122e-01f, 1.13862671e-01f, -3.58803421e-01f, -2.27662697e-01f, -2.17609316e-01f, 3.10998559e-01f, 1.56137049e-01f,
  -3.20184737e-01f, 3.45858216e-01f, 2.97811568e-01f, -1.54466957e-01f, 3.84514779e-01f, 1.85668692e-01f, -5.65937459e-01f, 2.75136113e-01f, 1.16522284e-02f, 1.11918844e-01f,
  2.52498984e-01f, -3.07813406e-01f, -4.27657574e-01f, -2.04823047e-01f, -4.01792139e-01f, 2.20699489e-01f, 3.53399694e-01f, -6.34274557e-02f, -1.80540010e-01f, -1.41554818e-01f,
  -4.41238992e-02f, -3.23780961e-02f, -1.39021173e-01f, -1.31300054e-02f, 1.21430755e-01f, -2.72899389e-01f, -2.70748138e-01f, 2.18875721e-01f, 1.77134156e-01f, 3.01354140e-01f,
  3.53288233e-01f, -1.29788801e-01f, 2.86295503e-01f, 1.44767389e-01f, -5.07008582e-02f, -4.61917251e-01f, -6.67509958e-02f, 3.43767703e-01f, -1.34613752e-01f, -5.14114976e-01f,
  -2.55116910e-01f, 3.64098459e-01f, -1.26500532e-01f, 7.20177516e-02f, -3.90249938e-01f, 3.61752719e-01f, -2.03432158e-01f, -2.84241676e-01f, -5.47464013e-01f, 3.10500622e-01f,
  4.66248617e-02f, -5.12952805e-01f, -1.95173115e-01f, -1.79618508e-01f, 1.36434346e-01f, -3.08044136e-01f, -1.94270417e-01f, -2.98505008e-01f, 1.40231237e-01f, 8.21386371e-03f,
  -1.77157968e-02f, -8.73129219e-02f, -2.33361293e-02f, -8.52654502e-02f, 3.64603661e-03f, 3.96567248e-02f, -1.66589707e-01f, -7.49662146e-02f, -1.71275854e-01f, -3.09191227e-01f,
  -4.18088958e-02f, -2.13605523e-01f, -1.03064775e-01f, -2.44920015e-01f, 6.72161728e-02f, -4.52819392e-02f, -2.22276524e-01f, 5.27638048e-02f, -1.83717161e-02f, 1.69724748e-01f,
  6.94813207e-02f, -3.17929350e-02f, -8.74178261e-02f, -8.72249007e-02f, -1.65413499e-01f, -2.25196496e-01f, -1.13286100e-01f, 1.47470176e-01f, 8.13933164e-02f, -1.53532833e-01f,
  1.75278280e-02f, -3.25760871e-01f, -1.47284493e-01f, -1.43637270e-01f, 2.15008706e-01f, -4.48216647e-02f, -1.92047268e-01f, -2.50569999e-01f, 1.83653861e-01f, 7.65796602e-02f,
  3.42837244e-01f, -9.81203094e-02f, -1.46425501e-01f, -1.11908764e-01f, 1.14182800e-01f, 1.93396240e-01f, -1.13233611e-01f, 2.13091418e-01f, 1.70686796e-01f, -1.38324216e-01f,
  -4.67725657e-02f, -1.80741534e-01f, 9.61157158e-02f, -1.72556743e-01f, -2.46638417e-01f, -8.41029659e-02f, -2.13856041e-01f, 7.74593130e-02f, -2.10256472e-01f, 7.99265280e-02f,
  -1.53997123e-01f, -1.13971829e-01f, 1.59073502e-01f, -1.07248724e-01f, 2.99723931e-02f, -1.42019391e-01f, 2.74879043e-03f, -6.16839677e-02f, -1.37136579e-01f, 9.36689377e-02f,
  9.47126523e-02f, -2.54057974e-01f, -3.50236923e-01f, -1.72168329e-01f, -4.69387360e-02f, -3.22809190e-01f, -9.01126042e-02f, 4.17859852e-01f, -2.85325021e-01f, -2.45647907e-01f,
  -3.19156349e-01f, -6.05121441e-02f, 3.84236097e-01f, -3.54197532e-01f, 2.02358648e-01f, -2.73715615e-01f, -9.88063291e-02f, -1.14207692e-01f, -4.25464422e-01f, -1.95032686e-01f,
  1.64231122e-01f, 2.29715392e-01f, -1.84357762e-01f, -2.97237992e-01f, -2.75310017e-02f, -1.59299061e-01f, 5.41629136e-01f, 1.99925169e-01f, -1.21056259e-01f, 3.12015742e-01f,
  1.08557932e-01f, 8.29679053e-03f, -7.44867548e-02f, -1.25987247e-01f, 6.53364062e-02f, 3.41500431e-01f, 4.53987747e-01f, 3.27046752e-01f, 7.62402825e-03f, -2.90256232e-01f,
  3.40022057e-01f, -1.34631678e-01f, 1.90464333e-02f, -1.06805854e-01f, -3.62367511e-01f, -1.16627984e-01f, -1.55781060e-01f, 1.90552101e-02f, -2.19245404e-01f, -1.35791317e-01f,
  -1.23164125e-01f, -1.51308104e-01f, 2.74633974e-01f, -3.59208077e-01f, -5.61599433e-02f, -3.33411470e-02f, -1.14386948e-02f, -9.71675068e-02f, -1.80960134e-01f, 7.11874515e-02f,
  -6.51846500e-03f, -1.58650145e-01f, -2.99693942e-01f, -4.22175042e-02f, -2.24911109e-01f, 1.69985652e-01f, -4.36893135e-01f, -1.12423733e-01f, -1.80072248e-01f, 1.31612942e-01f,
  -3.03470373e-01f, -1.03996605e-01f, -2.18879208e-02f, -5.54353222e-02f, -9.65689719e-02f, -1.63013801e-01f, -8.24032649e-02f, -9.82971340e-02f, -4.86337617e-02f, 2.31063291e-02f,
  -2.06934363e-01f, -1.57036111e-01f, -2.54484653e-01f, 1.59899935e-01f, -1.66795939e-01f, 8.09674338e-02f, -3.38522345e-01f, -1.90918557e-02f, 1.11607924e-01f, -1.60071388e-01f,
  5.02945073e-02f, 1.37528524e-01f, -1.74931630e-01f, 2.80754954e-01f, 1.78414822e-01f, 1.92362979e-01f, -3.36425863e-02f, -2.17367887e-01f, 9.22008455e-02f, 8.83343965e-02f,
  -1.90720648e-01f, 1.28933445e-01f, 8.96683782e-02f, -3.08417082e-01f, 1.20797619e-01f, -1.43067434e-01f, 1.19560957e-01f, 1.51476428e-01f, -6.17613792e-02f, 2.48046607e-01f,
  -2.40105420e-01f, 2.47794196e-01f, 1.34944588e-01f, 1.78176641e-01f, -2.79969364e-01f, -1.17580153e-01f, -4.49808359e-01f, -1.50497869e-01f, 2.23043159e-01f, 2.16130227e-01f,
  -2.85599470e-01f, 1.84109703e-01f, -2.46293709e-01f, -1.04904711e-01f, -1.87790185e-01f, 2.01006621e-01f, 1.08957164e-01f, -2.21500084e-01f, -3.32329333e-01f, -1.42932683e-01f,
  -2.92058550e-02f, 2.91537374e-01f, -1.96738854e-01f, -2.95948237e-01f, 2.56346524e-01f, -4.23661172e-01f, 1.68647528e-01f, -1.53407723e-01f, -2.91509032e-01f, -1.68998674e-01f,
  -1.86573982e-01f, -2.22207442e-01f, -1.77577391e-01f, -2.05843642e-01f, -3.10665756e-01f, 4.21877801e-01f, -1.53231218e-01f, -2.69868404e-01f, -4.49900985e-01f, 1.70814112e-01f,
  5.31744361e-01f, 3.89796019e-01f, 4.55159783e-01f, -1.73113152e-01f, -2.76899952e-02f, -2.27566540e-01f, -1.26637042e-01f, -5.67534685e-01f, -1.35970607e-01f, -2.37670347e-01f,
  4.46129620e-01f, -2.48692021e-01f, -1.47813065e-02f, -8.92481431e-02f, 1.66841283e-01f, -1.68322280e-01f, 3.33539307e-01f, 8.39510933e-03f, -1.38962135e-01f, -1.74255103e-01f,
  2.09688526e-02f, -2.04299539e-01f, 6.65389523e-02f, 3.19802344e-01f, 1.30213425e-01f, -2.59411577e-02f, -2.24811986e-01f, 3.57500404e-01f, -1.51056364e-01f, 1.66685395e-02f,
  -2.67432719e-01f, 3.96032244e-01f, 1.47280023e-01f, 1.26489609e-01f, 2.16750950e-01f, 1.29173025e-01f, 5.85841760e-03f, -1.09583184e-01f, 1.79316252e-02f, 1.70064241e-01f,
  1.13276774e-02f, 1.41962664e-02f, 3.43470499e-02f, -9.88770500e-02f, 1.66090969e-02f, 2.33831182e-01f, -7.33768791e-02f, -7.26772770e-02f, 2.16196924e-02f, -1.37530699e-01f,
  1.74885496e-01f, 1.62492722e-01f, 1.42703623e-01f, 1.51388660e-01f, -4.51810025e-02f, 3.02219540e-02f, 8.03943202e-02f, -4.45052013e-02f, 1.86104596e-01f, -8.25768244e-03f,
  2.39842996e-01f, -3.92993420e-01f, 2.45929480e-01f, 2.79229999e-01f, 1.78851232e-01f, 1.16629787e-01f, 1.43940687e-01f, -6.20252043e-02f, 5.81228249e-02f, -3.61622386e-02f,
  -5.16326018e-02f, 1.05867190e-02f, 8.32937434e-02f, 1.89610258e-01f, -4.15104479e-02f, -2.24103495e-01f, 2.79867828e-01f, 3.39510649e-01f, -1.00360997e-01f, -2.77126543e-02f,
  -4.05436188e-01f, -2.54889786e-01f, 5.58826506e-01f, -2.53930539e-01f, 4.04894203e-02f, 2.77197659e-01f, -5.50565720e-01f, -2.50036508e-01f, -1.03591785e-01f, -8.25527757e-02f,
  -1.27350584e-01f, -3.07146966e-01f, 2.84378976e-01f, 1.52206779e-01f, 2.51001835e-01f, 1.92176774e-01f, 4.32377279e-01f, -3.31515223e-01f, -4.88659926e-02f, -2.06159234e-01f,
  6.58498406e-02f, 1.24439888e-01f, -3.90736908e-01f, -6.72770366e-02f, -3.66711527e-01f, 5.87434648e-03f, -3.70302230e-01f, 3.43575925e-01f, -2.11825356e-01f, -1.20946117e-01f,
  -1.76898137e-01f, 2.73861349e-01f, -3.47499341e-01f, -8.48087296e-03f, 8.33529234e-02f, -3.41019958e-01f, -1.14666633e-01f, 5.91950230e-02f, 3.91631052e-02f, -2.87557632e-01f,
  3.45636964e-01f, 1.07779019e-01f, 3.85703683e-01f, -4.37226146e-01f, 3.48902196e-01f, 2.12001819e-02f, 1.32890373e-01f, 3.02519977e-01f, -2.03931332e-01f, -5.25145829e-01f,
  -5.77643514e-01f, -1.34549424e-01f, -1.21780604e-01f, -6.06509864e-01f, -4.46665674e-01f, -1.93304867e-01f, -4.15917300e-03f, -1.94429129e-01f, -6.51317164e-02f, -1.61201313e-01f,
  2.89484918e-01f, -3.25069100e-01f, -1.51199594e-01f, -2.73614645e-01f, 4.57582295e-01f, -1.56989858e-01f, 1.85770199e-01f, -2.57537931e-01f, 3.58909279e-01f, 4.06662188e-02f,
  3.41712177e-01f, 4.59439158e-01f, -1.40253574e-01f, 3.16132754e-01f, -1.36838362e-01f, 3.85828286e-01f, 7.40619898e-02f, 4.58146513e-01f, 1.71060428e-01f, -2.86992133e-01f,
  -6.61667362e-02f, 6.09400868e-02f, 3.09367657e-01f, 2.78873622e-01f, -1.01810046e-01f, -9.79070663e-02f, 1.57767877e-01f, 1.93436965e-01f, 1.65796522e-02f, -1.80552043e-02f,
  3.73774052e-01f, -7.66999200e-02f, 8.24819878e-02f, 3.07140589e-01f, 4.40550774e-01f, 3.29919010e-01f, 2.08164945e-01f, 2.64483899e-01f, 2.49916494e-01f, 2.44114667e-01f,
  9.03581604e-02f, 7.92268068e-02f, -4.04871047e-01f, 2.85615504e-01f, -6.45438880e-02f, 2.44969636e-01f, 8.17580801e-03f, 7.83758014e-02f, -1.48556158e-01f, 2.57024288e-01f,
  -2.12883845e-01f, 3.00465256e-01f, 3.07704329e-01f, 1.50650188e-01f, 2.52722561e-01f, 6.53407797e-02f, -1.99633524e-01f, 3.97531390e-01f, 2.99456473e-02f, 2.40311697e-01f,
  -9.19694304e-02f, -1.08122721e-01f, -3.66351634e-01f, 5.84859289e-02f, -3.60791683e-01f, -2.16448694e-01f, -2.87058741e-01f, 1.55913725e-01f, -1.10054366e-01f, -7.34829977e-02f,
  -2.11106181e-01f, 2.76858717e-01f, -2.83639789e-01f, 2.77821183e-01f, 4.01096016e-01f, 1.84585750e-01f, -1.95280001e-01f, 1.68300092e-01f, -9.99462530e-02f, -1.29554838e-01f,
  2.15134203e-01f, -1.40056536e-01f, 2.64336109e-01f, 5.95390834e-02f, -4.24405724e-01f, 3.52962703e-01f, 3.82246107e-01f, 3.20129156e-01f, 4.46643889e-01f, -3.30867887e-01f,
  6.07461743e-02f, -1.79260552e-01f, -1.01276197e-01f, -3.65111679e-01f, 1.74677789e-01f, 9.69098955e-02f, 3.73614356e-02f, -3.09868753e-01f, 5.60692288e-02f, 3.36340934e-01f,
  -3.17382105e-02f, -4.79595289e-02f, 3.94270241e-01f, 4.74812239e-01f, 3.62188876e-01f, -3.89015883e-01f, 8.08191746e-02f, -2.76982695e-01f, -3.15099806e-01f, 2.48162821e-01f,
  2.26547137e-01f, -2.59852707e-01f, -1.55367076e-01f, -2.77073294e-01f, -3.44280481e-01f, -6.12895489e-01f, 1.39879927e-01f, -3.60515453e-02f, -2.32092112e-01f, 2.37076327e-01f,
  1.05978698e-01f, 6.13795519e-02f, -2.04181179e-01f, -1.09037533e-01f, -2.34489664e-01f, -2.85629779e-02f, -2.99699873e-01f, 7.18887970e-02f, -1.33067295e-01f, -2.81974107e-01f,
  -5.12701213e-01f, -6.08810820e-02f, 5.77136129e-02f, 3.60943675e-01f, -3.27377498e-01f, 4.41357732e-01f, -1.99496865e-01f, 6.27914369e-02f, -1.79891765e-01f, -1.41675666e-01f,
  -9.59571972e-02f, -5.22458315e-01f, -4.27632093e-01f, -3.51741791e-01f, -2.17747003e-01f, -3.39084297e-01f, -3.08958352e-01f, 9.46874917e-02f, 1.78733706e-01f, -1.73060581e-01f,
  -2.21138120e-01f, -6.89512193e-02f, 1.13983460e-01f, -3.91369946e-02f, 4.70633283e-02f, -3.10920268e-01f, 6.87097311e-02f, -2.40112782e-01f, -2.52816409e-01f, -9.70138162e-02f,
  -1.32131904e-01f, 1.21819697e-01f, -3.81422162e-01f, 1.00624278e-01f, -4.44449252e-03f, 7.13408068e-02f, -2.48479676e-02f, -2.08573654e-01f, -8.62815902e-02f, -1.39631674e-01f,
  -2.52096578e-02f, -1.35233805e-01f, 1.87001213e-01f, -6.69225827e-02f, 2.67000142e-02f, 1.57459676e-01f, -1.64056078e-01f, 1.96512654e-01f, -7.08357915e-02f, 1.51225835e-01f,
  1.31715983e-01f, 7.07384795e-02f, -2.52821892e-01f, 1.08842313e-01f, 3.08889896e-01f, 2.07716078e-01f, 3.79618198e-01f, -2.56259918e-01f, -3.83857876e-01f, -9.88500938e-02f,
  3.77951115e-01f, 2.95979470e-01f, 1.16535939e-01f, -1.99555859e-01f, -1.20926514e-01f, 3.26297641e-01f, 1.96296409e-01f, 8.18068441e-03f, -2.21488371e-01f, 1.07590824e-01f,
  4.03570592e-01f, 1.66135907e-01f, -1.73506841e-01f, -3.17092180e-01f, 2.58762896e-01f, -2.69078672e-01f, -2.34685153e-01f, -2.41196796e-01f, 1.38707131e-01f, -2.83075094e-01f,
  -2.90918887e-01f, -4.81347144e-02f, -8.41413960e-02f, -1.24854306e-02f, -3.68421555e-01f, 6.52735010e-02f, -1.73127919e-01f, 3.75846118e-01f, 1.88360617e-01f, -4.87224013e-02f,
  4.47769642e-01f, 3.46398175e-01f, -3.15105736e-01f, 1.33276656e-01f, -9.24851894e-02f, 7.89385587e-02f, 4.23398823e-01f, -9.88119170e-02f, -6.25029877e-02f, -1.92445353e-01f,
  -2.25750566e-01f, -2.47355312e-01f, 5.03804743e-01f, -3.70744020e-01f, -6.84867620e-01f, -1.76408559e-01f, -1.52595952e-01f, 3.48618120e-01f, -5.17865062e-01f, -1.00793436e-01f,
  -3.06046516e-01f, 1.36343703e-01f, 1.06769338e-01f, -3.32153797e-01f, 2.40740869e-02f, -1.57369658e-01f, 2.64718026e-01f, 4.03746963e-02f, 2.29542747e-01f, 4.66628253e-01f,
  -1.20348439e-01f, -1.03224389e-01f, -2.05890924e-01f, -3.99921000e-01f, 2.96649039e-01f, -1.40469536e-01f, -3.19161154e-02f, 3.28647345e-01f, -3.33287895e-01f, 3.30986559e-01f,
  -1.85130402e-01f, -2.62803018e-01f, -3.38054985e-01f, -1.59778774e-01f, -1.12397023e-01f, 2.72741586e-01f, 2.45169520e-01f, 1.89939603e-01f, -3.10989648e-01f, 5.56865260e-02f,
  5.42567134e-01f, -4.10699815e-01f, 2.66808122e-01f, -1.25490144e-01f, -3.14649403e-01f, -3.23400736e-01f, -1.17167011e-01f, -1.03247918e-01f, -9.16237757e-02f, -1.09965853e-01f,
  5.30499555e-02f, -4.13092524e-02f, -1.00421235e-01f, -9.76996645e-02f, 8.41758773e-02f, -1.06819421e-01f, 1.23328241e-02f, -8.17851052e-02f, -1.42253771e-01f, -9.11530405e-02f,
  1.90670550e-01f, -2.91805938e-02f, 2.34109797e-02f, 1.12333335e-01f, 1.08878583e-01f, -2.11692020e-01f, -8.83001760e-02f, 1.07873954e-01f, 8.11762176e-04f, -2.87591685e-02f,
  -6.73978925e-02f, -1.44002616e-01f, -4.37702350e-02f, -1.38114497e-01f, 3.54706831e-02f, -1.67400807e-01f, 6.55951500e-02f, -2.09867954e-01f, -1.64901748e-01f, -4.94209118e-02f,
  -1.01792999e-01f, -1.42106239e-03f, -1.33247167e-01f, -1.19244859e-01f, 1.53549284e-01f, 1.16634332e-01f, -1.75896093e-01f, 1.60717100e-01f, 4.58393283e-02f, -1.57212615e-01f,
  1.92123413e-01f, 9.62083340e-02f, 4.98393029e-02f, -5.20552434e-02f, -1.66532099e-01f, 7.35708922e-02f, 1.69376388e-01f, -4.20762524e-02f, -2.02792242e-01f, -1.36971539e-02f,
  1.88148960e-01f, -3.18378932e-03f, 5.31454161e-02f, 2.37449154e-01f, -2.53332525e-01f, 1.23478666e-01f, 4.84125949e-02f, 1.90616176e-01f, -3.15458607e-03f, -1.45764425e-01f,
  -1.65583834e-01f, 1.22493744e-01f, 3.75974327e-02f, -1.59464180e-01f, 6.21423610e-02f, 1.89787269e-01f, -2.31992751e-01f, -2.26701319e-01f, 2.12857917e-01f, -2.04457432e-01f,
  1.18740544e-01f, -2.96375602e-02f, -9.10141841e-02f, 4.37634677e-01f, 1.64732069e-01f, 6.62174961e-03f, 4.34224069e-01f, -1.18874386e-01f, -5.58105223e-02f, -1.74958825e-01f,
  2.31922314e-01f, -1.54076114e-01f, 4.31171292e-03f, -2.09426120e-01f, -1.33019477e-01f, -2.31301486e-01f, 3.57967347e-01f, 2.38135323e-01f, -1.02253094e-01f, 3.75168860e-01f,
  -5.74908815e-02f, -2.24320531e-01f, -9.54961032e-02f, 3.10276419e-01f, -1.79077789e-01f, -9.58228409e-02f, 2.18299925e-02f, -1.77040353e-01f, -3.03670436e-01f, -1.57236159e-02f,
  -1.49073303e-01f, 4.70160246e-01f, -1.14195734e-01f, 3.33365321e-01f, -6.31321892e-02f, -1.60864413e-01f, -9.55800265e-02f, 1.19307175e-01f, -3.36564153e-01f, -1.10441603e-01f,
  -3.55627462e-02f, -2.17270374e-01f, 3.21122348e-01f, -1.58903629e-01f, 7.07873330e-02f, -2.42522359e-02f, -1.10798344e-01f, -2.79673010e-01f, -2.08728269e-01f, -4.94323485e-02f,
  2.39588797e-01f, -4.26883921e-02f, -2.64360249e-01f, -1.63202465e-01f, -3.21104527e-01f, -5.38632832e-02f, 5.05043492e-02f, 1.32287428e-01f, -1.62878588e-01f, 3.91904786e-02f,
  -2.54677283e-03f, -9.67491269e-02f, 6.86160615e-03f, -1.67199612e-01f, 5.74625283e-02f, -5.34432195e-02f, -1.16432784e-02f, 8.53485614e-02f, -8.49580169e-02f, 6.82070702e-02f,
  3.10633611e-02f, -5.55413291e-02f, 5.20006977e-02f, 1.04465142e-01f, 1.17781803e-01f, 9.01087373e-02f, 1.11500576e-01f, -1.63947076e-01f, -1.56719565e-01f, 6.96366280e-02f,
  -5.36288545e-02f, -6.77956119e-02f, 2.82123685e-03f, -2.62866855e-01f, 1.23384371e-01f, -8.99726972e-02f, -7.74834156e-02f, -2.46026099e-01f, -1.16505809e-02f, 9.16313305e-02f,
  -2.87117928e-01f, -1.46018147e-01f, 1.98118657e-01f, -2.19707102e-01f, 8.20030570e-02f, 2.45383903e-01f, 2.01315850e-01f, 2.92860009e-02f, -1.60191908e-01f, -2.44182214e-01f,
  2.86876768e-01f, -2.21133530e-01f, 3.65836322e-02f, 1.38472676e-01f, -1.25633955e-01f, -2.53930569e-01f, 2.10753649e-01f, 4.70591942e-03f, -9.08320472e-02f, -8.19063112e-02f,
  -1.37852520e-01f, 2.30319172e-01f, -1.25650272e-01f, 1.61328807e-01f, -1.99759394e-01f, 2.50251800e-01f, -1.73769251e-01f, -2.83909321e-01f, 3.06084573e-01f, -1.12838045e-01f,
  1.31693378e-01f, -2.26935342e-01f, -6.36601374e-02f, 2.34597653e-01f, 1.77873775e-01f, -2.67760754e-01f, 1.28296226e-01f, -5.97799383e-02f, 1.43703207e-01f, -2.30401456e-01f,
  -3.41523513e-02f, -1.07369035e-01f, -2.18639418e-01f, -8.11137632e-02f, -1.70309082e-01f, 2.28620082e-01f, -1.25466228e-01f, 7.39224255e-02f, 8.14527348e-02f, -1.58430979e-01f,
  2.37726331e-01f, -1.35877103e-01f, -2.61856794e-01f, -7.15618879e-02f, -1.26072749e-01f, -1.96687460e-01f, 5.56618154e-01f, -2.29514703e-01f, 2.62951583e-01f, -2.51264453e-01f,
  -3.02658498e-01f, 2.89130926e-01f, 7.28069991e-02f, 4.55108166e-01f, -4.58085001e-01f, -8.56384858e-02f, -1.74800351e-01f, -1.31813273e-01f, 4.01907027e-01f, -1.95047304e-01f,
  -1.63789138e-01f, -1.77654564e-01f, -1.20695159e-01f, 6.51424602e-02f, -3.36405486e-01f, 2.82411069e-01f, -1.54074743e-01f, 2.25293506e-02f, 3.03656220e-01f, -1.39304608e-01f,
  -1.18044265e-01f, -2.50462711e-01f, -1.54623717e-01f, -1.14229307e-01f, 1.55654103e-01f, -1.90904558e-01f, -1.52802646e-01f, -5.55302352e-02f, -1.24989688e-01f, -1.12368867e-01f,
  -2.23473147e-01f, 5.28407454e-01f, 1.50038838e-01f, 7.03689381e-02f, -1.97829247e-01f, 2.23133825e-02f, -5.60504422e-02f, 1.63608670e-01f, 7.63332611e-03f, 1.52656168e-01f,
  -5.52101247e-03f, 2.69711673e-01f, -9.96748134e-02f, 2.30901942e-01f, 1.88129619e-01f, 2.45978814e-02f, 4.58062701e-02f, 2.09092069e-02f, 4.84668612e-02f, -5.01836017e-02f,
  -2.31487960e-01f, 3.92136164e-02f, 3.68999466e-02f, 3.25790569e-02f, 1.19101234e-01f, 9.10515490e-04f, 7.54571846e-03f, 1.07283399e-01f, 6.11421000e-03f, -8.99966583e-02f,
  2.09039301e-01f, 4.93245646e-02f, -1.55223370e-01f, -3.63124996e-01f, -5.97848333e-02f, 1.03214480e-01f, 1.07590124e-01f, 2.70747095e-02f, -4.20928411e-02f, -1.65248305e-01f,
  -3.72371763e-01f, 7.16819912e-02f, -1.82271093e-01f, -8.36030990e-02f, -3.84012938e-01f, -1.31913036e-01f, -1.80901274e-01f, -2.94841766e-01f, 3.66572827e-01f, 5.90434596e-02f,
  4.23165798e-01f, -3.62529755e-02f, -2.75630236e-01f, 3.25689554e-01f, 1.52443975e-01f, 1.20574556e-01f, 3.96564186e-01f, -3.12596381e-01f, 2.77773112e-01f, -1.95519760e-01f,
  -2.11154282e-01f, -2.86381263e-02f, -2.03011081e-01f, -3.02718550e-01f, 6.13912046e-02f, 5.53626847e-03f, -3.14985633e-01f, -3.10764283e-01f, 3.36639062e-02f, 5.96297905e-03f,
  3.03726465e-01f, 3.58706921e-01f, 2.68659472e-01f, 6.33362010e-02f, 8.61286297e-02f, 2.58864164e-01f, -7.19710737e-02f, 2.68793911e-01f, -2.35818639e-01f, -3.90456468e-01f,
  3.49081933e-01f, -4.03550595e-01f, 9.00210366e-02f, -2.54724681e-01f, -3.65722746e-01f, 9.87191275e-02f, -4.72486407e-01f, 2.87671685e-01f, 5.42146325e-01f, 1.15417100e-01f,
  -1.55510545e-01f, 1.68723036e-02f, 4.37510610e-01f, -1.55662522e-01f, -1.70748338e-01f, 3.46343488e-01f, -4.01819408e-01f, -1.79382190e-01f, -2.02981293e-01f, -1.97720557e-01f,
  -1.36978999e-01f, -2.97782630e-01f, -2.40986332e-01f, -4.60758775e-01f, 2.53648490e-01f, 1.13546930e-01f, -2.81997055e-01f, 1.78842753e-01f, -7.57071450e-02f, 4.72682327e-01f,
  -2.88510919e-01f, 2.48993980e-03f, -1.10775590e-01f, -3.73369575e-01f, -1.79577217e-01f, -1.17889449e-01f, -2.27390483e-01f, -2.57401168e-01f, -2.83708721e-01f, -3.65552276e-01f,
  3.95263672e-01f, -4.42251503e-01f, -1.00743279e-01f, -2.76493400e-01f, -2.53256828e-01f, 1.04392521e-01f, -3.07944059e-01f, 3.61667514e-01f, 5.28259158e-01f, -1.07844114e-01f,
  1.49602264e-01f, 1.54143035e-01f, -1.57832503e-01f, 1.33348897e-01f, 1.87390879e-01f, 7.87763298e-02f, 1.51083618e-01f, -1.26543894e-01f, 2.29214102e-01f, 1.47817701e-01f,
  6.77989647e-02f, 1.14733241e-01f, 2.18762875e-01f, -9.58613530e-02f, 1.58638522e-01f, 8.60477090e-02f, 1.32246777e-01f, 1.95686817e-01f, 2.40590386e-02f, 1.67479441e-01f,
  1.14238665e-01f, 4.45831455e-02f, 4.83688079e-02f, 2.06028461e-01f, 2.30101719e-01f, -1.23470919e-02f, 7.05582127e-02f, 7.89337680e-02f, -9.68442857e-02f, 8.69870707e-02f,
  -2.45937452e-01f, -5.89746656e-03f, 2.50836760e-01f, -1.07777022e-01f, 7.35427532e-03f, 2.48762399e-01f, 8.40047300e-02f, 8.33901465e-02f, -3.12208891e-01f, -1.64342582e-01f,
  2.13672429e-01f, 2.09610790e-01f, 2.65956998e-01f, 3.44933361e-01f, 2.93807336e-03f, 3.49738240e-01f, -1.84849855e-02f, 2.17735380e-01f, -3.35055321e-01f, 3.04517418e-01f,
  4.08416152e-01f, -3.09301943e-01f, -4.21804726e-01f, -2.77556866e-01f, -1.30021751e-01f, -1.43086314e-01f, -1.68067411e-01f, 1.28552958e-01f, 2.87004501e-01f, 3.05489957e-01f,
  1.36271855e-02f, 3.69548976e-01f, 2.93738961e-01f, 3.96561861e-01f, 2.69452840e-01f, 4.47067954e-02f, -3.06459874e-01f, 2.47275621e-01f, -2.38357052e-01f, -5.94656654e-02f,
  -2.30557807e-02f, 3.26197326e-01f, -6.60955757e-02f, 1.18307494e-01f, 2.09562674e-01f, -7.17998371e-02f, -3.93485241e-02f, 1.01956688e-01f, -1.68046474e-01f, 2.13322356e-01f,
  -2.76926875e-01f, 3.56334031e-01f, 9.31226015e-02f, -5.58885075e-02f, -1.32977203e-01f, 2.28985205e-01f, -2.64873475e-01f, 2.73976803e-01f, -4.87653762e-02f, -1.70875356e-01f,
  -2.12415740e-01f, 1.24012984e-01f, -2.70240635e-01f, -1.82010844e-01f, 3.93755883e-01f, -1.23893261e-01f, -2.89385915e-01f, 1.79907247e-01f, 4.31449473e-01f, -2.74798036e-01f,
  -1.92494035e-01f, -1.12427128e-02f, -2.41305187e-01f, 5.60769022e-01f, -6.81130737e-02f, -7.66318366e-02f, -3.60187352e-01f, -1.88811347e-01f, -3.06182414e-01f, -1.63754493e-01f,
  5.46733588e-02f, -3.30579966e-01f, -4.73289788e-01f, -2.46084958e-01f, -2.91064024e-01f, -1.37769997e-01f, -2.49539316e-01f, -2.46130690e-01f, -1.78894192e-01f, -2.19839588e-01f,
  2.77567238e-01f, -3.35320234e-01f, -6.66713342e-02f, -2.57851332e-01f, -1.76321536e-01f, -1.42522901e-01f, 2.14293882e-01f, -4.26828206e-01f, 6.73638433e-02f, 1.49834454e-01f,
  6.09731935e-02f, -2.30317414e-01f, 3.83332223e-02f, 1.14098541e-01f, 6.30093589e-02f, 1.10714927e-01f, 4.91750278e-02f, 1.60866931e-01f, -1.04499876e-01f, 1.10713266e-01f,
  1.90467283e-01f, 1.39958598e-02f, 1.47507370e-01f, 7.58482367e-02f, 8.43474194e-02f, -2.68799793e-02f, -2.41993088e-02f, -4.44124192e-02f, 1.59874931e-02f, 1.09815381e-01f,
  1.51035562e-01f, -7.45572224e-02f, -8.98519158e-03f, -7.12446123e-02f, 1.98953524e-01f, -3.28768813e-03f, 1.47959515e-01f, 1.15986383e-02f, 1.80787042e-01f, 9.88683850e-02f,
  -3.24151758e-03f, -5.86950220e-02f, -7.36118555e-02f, -3.64571984e-04f, -7.25944806e-03f, -1.00285947e-01f, 2.38290042e-01f, -1.17207356e-01f, -1.09903852e-03f, -2.81316876e-01f,
  -2.85297126e-01f, -2.63278872e-01f, 2.05923796e-01f, -2.21491873e-01f, -2.08144948e-01f, 1.77178122e-02f, -2.66488343e-01f, 1.78748697e-01f, -1.52553245e-01f, -1.68948352e-01f,
  -2.92759091e-01f, 1.59321249e-01f, -2.16442510e-01f, 3.49055648e-01f, 2.19432712e-01f, -9.28260684e-02f, 2.28205875e-01f, 3.58940251e-02f, -1.66063718e-02f, -3.41102123e-01f,
  -1.85997486e-01f, -3.59792233e-01f, 1.14239305e-02f, 2.40076691e-01f, 1.71321809e-01f, 3.31637621e-01f, 9.30184275e-02f, -2.60892421e-01f, -2.58186579e-01f, 2.90276796e-01f,
  9.36388522e-02f, -2.52669454e-01f, 3.12306195e-01f, 2.21784443e-01f, 4.05210303e-03f, -1.80065647e-01f, -1.47029221e-01f, -3.29119802e-01f, -5.84266670e-02f, -1.78749606e-01f,
  1.01153599e-02f, -5.18268570e-02f, 1.07805163e-01f, 3.53477389e-01f, -1.81733787e-01f, 3.41250360e-01f, -2.17717007e-01f, -3.70310843e-01f, -2.20221341e-01f, -2.07650870e-01f,
  2.83657044e-01f, -1.59340933e-01f, -3.46392095e-01f, -2.15401515e-01f, -2.85263956e-01f, -2.45659165e-02f, -4.42468882e-01f, -1.02926172e-01f, -4.11544852e-02f, -1.37895718e-01f,
  -1.06387213e-01f, -1.62815765e-01f, -5.64762689e-02f, -2.10764930e-01f, 2.61383057e-01f, 4.16851640e-02f, 5.39955556e-01f, -3.19717735e-01f, -3.08326837e-02f, 3.27451080e-01f,
  3.58453363e-01f, -6.61624819e-02f, -2.14126393e-01f, -2.48846754e-01f, -2.32931823e-01f, -2.97111213e-01f, -2.35034645e-01f, -1.52145445e-01f, 3.68950844e-01f, -1.26799166e-01f,
  5.61152637e-01f, -2.04629794e-01f, 4.98092562e-01f, -3.30328405e-01f, -1.64460644e-01f, 3.80686611e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.78222468e-02f, -4.57649268e-02f, -5.06067909e-02f, 3.44327353e-02f, -6.00620285e-02f, 1.55780446e-02f, 6.89899102e-02f, 1.52684255e-02f, -3.77991283e-03f, 8.05906504e-02f,
  2.86120586e-02f, 1.25635401e-04f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    