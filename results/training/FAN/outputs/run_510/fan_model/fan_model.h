/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.19288149e-02f, -4.53695953e-02f, 9.38409269e-02f, 1.06935948e-01f, -6.30940646e-02f, 1.25119463e-01f, 2.96098769e-01f, -9.87156630e-02f, 2.43864357e-02f, -1.99419223e-02f,
  8.75041634e-02f, 1.12475380e-01f, -5.79809733e-02f, 1.84201047e-01f, 1.95909351e-01f, 9.55191329e-02f, 1.70447558e-01f, 7.50162452e-02f, -5.52069880e-02f, -4.87459004e-02f,
  -6.56604245e-02f, 1.10783026e-01f, 6.76936731e-02f, -2.10359678e-01f, 8.46348405e-02f, -9.11139324e-02f, -2.19463021e-01f, -1.32361606e-01f, 7.82686397e-02f, -2.18599215e-02f,
  1.73070624e-01f, -4.44491766e-02f, 1.50014227e-02f, 3.29108313e-02f, -2.89038904e-02f, -2.72508897e-02f, 5.29427305e-02f, 7.93501586e-02f, -4.52457694e-03f, 1.39148999e-02f,
  4.43323255e-02f, -2.18891259e-02f, -8.11817031e-03f, 2.43621808e-03f, -3.27834748e-02f, 4.55266088e-02f, 5.58503494e-02f, 1.07803740e-01f, 1.16388910e-02f, 8.65550041e-02f,
  5.04797958e-02f, 4.85441647e-02f, -1.56762060e-02f, 8.36650431e-02f, 6.04351796e-02f, 6.58707544e-02f, 8.35416242e-02f, -2.88076606e-02f, 3.56824603e-03f, 2.48580854e-02f,
  -5.38598262e-02f, -4.68985178e-02f, -1.02434911e-01f, -3.33497114e-03f, 1.31302653e-02f, 3.21025923e-02f, 2.68021356e-02f, 1.27441771e-02f, 8.56223051e-03f, -6.62303567e-02f,
  -9.74029116e-03f, 4.02814820e-02f, -4.05212352e-03f, 4.34473455e-02f, 6.24065101e-02f, 1.79433115e-02f, -2.17057653e-02f, -9.91334990e-02f, 4.82140705e-02f, 5.37551790e-02f,
  6.18770299e-03f, -1.74281336e-02f, 2.14843475e-03f, 2.76377853e-02f, 4.17928621e-02f, -5.35563529e-02f, -3.09949610e-02f, -8.79480410e-03f, -8.66969749e-02f, -4.90795169e-03f,
  -2.67942604e-02f, -2.45990425e-01f, -2.28402447e-02f, -5.84912766e-03f, 6.33942410e-02f, 4.35452387e-02f, 3.82409431e-03f, -9.63285044e-02f, -6.06015883e-02f, -1.81766152e-02f,
  -4.91750613e-02f, -6.98553585e-03f, -6.95748255e-02f, -2.34466000e-03f, -4.79354383e-03f, -7.93439150e-02f, -8.28670785e-02f, -5.40156439e-02f, 9.15702432e-02f, -5.53337075e-02f,
  -2.28069182e-02f, -4.25345525e-02f, 4.66094427e-02f, 1.71890371e-02f, -7.99522623e-02f, 5.25049716e-02f, 5.54122124e-03f, 2.66121980e-02f, 3.34598846e-03f, 4.27963212e-02f,
  1.79149553e-01f, -4.07727361e-02f, -1.93948299e-01f, 9.93838832e-02f, 1.07262924e-01f, 1.20030269e-01f, -4.83459905e-02f, 6.07834123e-02f, -1.27166301e-01f, 8.16904977e-02f,
  1.33044749e-01f, -1.85478345e-01f, -1.60342082e-01f, 9.18005481e-02f, 3.48020829e-02f, -8.69474635e-02f, 3.14290039e-02f, 4.93427664e-02f, -2.16583274e-02f, 4.31648493e-02f,
  2.42587738e-02f, 9.13395360e-02f, 3.06825768e-02f, 7.77956322e-02f, -1.05475076e-02f, 5.50309047e-02f, 1.01266488e-01f, -6.11891672e-02f, 4.41517569e-02f, -4.77794670e-02f,
  6.90447465e-02f, 7.51429871e-02f, -2.15104204e-02f, -3.90926078e-02f, 1.53159872e-01f, -2.30456088e-02f, -5.68129160e-02f, -8.78301784e-02f, 6.15716614e-02f, 8.00843723e-03f,
  -2.62869671e-02f, 2.14659725e-03f, 5.60177080e-02f, -2.57557333e-02f, -9.09399763e-02f, 1.20180305e-02f, -1.72064938e-02f, 5.90826795e-02f, -4.22952175e-02f, -9.49223340e-02f,
  -4.35553081e-02f, -3.09446827e-02f, 5.63783422e-02f, 4.34734188e-02f, 4.45421003e-02f, 4.71019559e-02f, 6.89229555e-03f, -8.21797624e-02f, 4.58604433e-02f, -9.10170749e-03f,
  6.44793883e-02f, -1.90345589e-02f, -2.41038855e-03f, 3.97627540e-02f, -5.14059775e-02f, 1.23039909e-01f, -6.67190403e-02f, 7.15427697e-02f, 1.49099566e-02f, 4.90945764e-02f,
  1.48917943e-01f, 3.70322391e-02f, 8.14071968e-02f, -6.84853643e-02f, 3.21682803e-02f, -1.18455281e-02f, -5.57874935e-03f, 1.43931257e-02f, 3.57715078e-02f, 6.08435012e-02f,
  1.95523854e-02f, 2.89358646e-02f, 2.82166451e-02f, 1.00520821e-02f, -3.30216549e-02f, -5.84957339e-02f, -6.76428294e-03f, -3.57095189e-02f, -6.04183525e-02f, -1.04841227e-02f,
  6.32735193e-02f, 4.59356457e-02f, 1.76877137e-02f, -3.11485305e-03f, -7.65897334e-02f, 8.26914236e-02f, -1.40424771e-02f, -9.34925117e-03f, -6.76616058e-02f, 1.00791333e-02f,
  1.26775270e-02f, 5.18417619e-02f, 4.60182801e-02f, -1.49811367e-02f, 8.40987191e-02f, -2.87244730e-02f, 6.10888116e-02f, -1.50350826e-02f, 5.91930375e-02f, -2.77573499e-03f,
  1.40048645e-03f, -2.16816589e-02f, 7.03835685e-05f, 9.08132643e-02f, 2.57584881e-02f, -2.85541583e-02f, 6.45885840e-02f, 6.91266581e-02f, -2.53217984e-02f, -4.25837114e-02f,
  2.35042527e-01f, -1.84420869e-01f, 1.92049429e-01f, 9.56892129e-03f, -5.89780249e-02f, 1.10969342e-01f, 5.78811541e-02f, -6.65915832e-02f, 3.01434509e-02f, -1.47604197e-01f,
  -8.51805881e-02f, 6.34086132e-02f, 1.09861657e-01f, -2.90853288e-02f, 3.70314062e-01f, 8.31509084e-02f, 6.43918887e-02f, 2.85149720e-02f, 5.91341108e-02f, 2.10627634e-03f,
  3.96064222e-02f, -1.08353473e-01f, 2.66672671e-01f, -2.33464882e-01f, -5.95382489e-02f, -1.15380697e-01f, -7.13822469e-02f, 1.91700291e-02f, -1.54616237e-01f, -3.01300101e-02f,
  6.86402470e-02f, 7.75663508e-03f, -4.96887155e-02f, 6.82687610e-02f, 7.78929591e-02f, -1.20772943e-02f, -2.16666283e-03f, 1.65849291e-02f, 1.25070265e-03f, 5.48984855e-02f,
  -2.46766536e-03f, -5.34125082e-02f, 1.17286388e-02f, -1.74485985e-02f, -4.02459130e-02f, 6.56937361e-02f, -7.56888762e-02f, 1.69064291e-02f, -1.29202856e-02f, 8.28226805e-02f,
  3.59590538e-02f, 1.17717469e-02f, 1.16711654e-01f, 6.56365901e-02f, 2.58995630e-02f, 2.69057304e-02f, 2.33530123e-02f, 2.37050373e-02f, 3.67336795e-02f, 3.72684225e-02f,
  1.84835382e-02f, 3.19056548e-02f, -9.97746214e-02f, 4.65079024e-02f, -6.94054663e-02f, -5.89539409e-02f, 5.88879287e-02f, -4.83944044e-02f, 5.19771799e-02f, -1.94813907e-02f,
  -1.60864647e-02f, 2.76690014e-02f, -8.06088299e-02f, 1.70871206e-02f, -3.58538963e-02f, -1.33461254e-02f, 4.35832217e-02f, 3.54861952e-02f, 1.10630551e-03f, 1.04877390e-02f,
  -1.54323298e-02f, 5.37160225e-02f, -9.88939032e-02f, 1.55174928e-02f, 3.86835821e-02f, 7.19539672e-02f, 6.24996750e-03f, -5.85057884e-02f, 5.77584803e-02f, 8.23617075e-03f,
  3.31130512e-02f, -2.57458091e-02f, 4.02587503e-02f, -1.77678354e-02f, -5.31557575e-02f, 2.24530380e-02f, -7.85893761e-03f, -7.88313448e-02f, -3.30771157e-03f, -2.48094765e-03f,
  6.30900115e-02f, 7.00946758e-03f, -1.67339034e-02f, -2.25114413e-02f, -2.14610086e-03f, -2.90768426e-02f, 2.30693948e-02f, -2.57430524e-02f, 4.93098125e-02f, -3.45183536e-02f,
  -7.47976303e-02f, -1.38294250e-02f, 2.37573534e-02f, -4.74337712e-02f, 1.62826292e-02f, -5.95768504e-02f, 4.02628072e-02f, -1.16119459e-01f, -6.83152303e-02f, 5.49953952e-02f,
  1.26733527e-01f, -2.31462549e-02f, -3.99361178e-02f, -7.07456330e-03f, -1.13538583e-03f, 2.17725173e-01f, 1.81239828e-01f, -3.78730707e-02f, 1.75471991e-01f, 3.82485166e-02f,
  -8.85067284e-02f, 7.21400827e-02f, 8.41595829e-02f, -1.27026690e-02f, 1.97724581e-01f, 2.27536723e-01f, 8.18148255e-02f, 6.30958527e-02f, 4.01437506e-02f, -5.17249666e-02f,
  8.48623291e-02f, -9.35586691e-02f, -9.88374278e-02f, -1.84253797e-01f, -9.31389630e-02f, -1.48688823e-01f, -2.29572937e-01f, -8.30722600e-02f, -2.21134976e-01f, -4.21732962e-02f,
  8.85707587e-02f, 6.05618320e-02f, -1.77855212e-02f, -1.70568167e-03f, 2.78585870e-02f, 6.04647724e-03f, 3.93917859e-02f, -2.16535665e-02f, -1.88753603e-03f, -6.18068762e-02f,
  3.93570215e-02f, 4.80575487e-02f, -2.18451414e-02f, 3.13707851e-02f, 5.33818267e-02f, 1.70465782e-02f, 3.86055280e-03f, -4.72123399e-02f, -2.94400677e-02f, -2.47284025e-02f,
  -2.04460477e-04f, 4.95472848e-02f, -8.39663669e-02f, -4.74448055e-02f, -1.86493453e-02f, 5.76224700e-02f, -7.18309432e-02f, 1.74300149e-02f, 1.04644028e-02f, 2.04971097e-02f,
  1.69661343e-02f, -2.23369468e-02f, -8.49101767e-02f, -3.85353975e-02f, 3.28794792e-02f, -5.71676232e-02f, 8.18100050e-02f, -4.71672826e-02f, 6.41290704e-03f, 3.32357399e-02f,
  -5.61020744e-04f, -6.69929087e-02f, 4.95961271e-02f, 1.37765780e-02f, -3.70109603e-02f, 6.49441872e-03f, 9.66632366e-03f, -3.37630622e-02f, -3.95952947e-02f, -6.33806288e-02f,
  5.21411970e-02f, -4.33928100e-03f, -5.60625866e-02f, -1.38825513e-02f, -4.45448272e-02f, -7.29679540e-02f, -7.21736113e-03f, 1.82902738e-02f, -5.95038272e-02f, -8.84446141e-04f,
  8.84733051e-02f, 1.33341393e-02f, -3.68547067e-02f, -3.41552251e-04f, 4.90857149e-03f, -2.32848432e-02f, -9.82452929e-03f, 5.27629629e-02f, 3.35362889e-02f, 1.36411246e-02f,
  -1.13614853e-02f, -7.23882169e-02f, 6.39433563e-02f, -6.73447549e-02f, -3.89566533e-02f, -1.39534986e-02f, 2.54285578e-02f, -6.66199028e-02f, -8.37246142e-03f, 4.61392291e-02f,
  -1.07232705e-01f, 7.14998168e-05f, 2.17198953e-02f, -1.07028462e-01f, -3.40693817e-02f, -6.69064820e-02f, -5.42456992e-02f, -2.23553684e-02f, 2.25476343e-02f, 7.62836784e-02f,
  -1.03988377e-02f, -1.53944209e-01f, 5.53764962e-03f, -6.93330690e-02f, 1.54618010e-01f, 6.80795535e-02f, 6.16073161e-02f, -2.43693460e-02f, -1.22222416e-01f, -6.88695908e-02f,
  -1.83468070e-02f, 3.29867043e-02f, -1.25819087e-01f, -1.01567335e-01f, -6.89148009e-02f, -2.11410671e-01f, -1.09946512e-01f, -8.59528482e-02f, -1.92020535e-02f, -2.17160415e-02f,
  1.10548995e-02f, 4.73939086e-04f, -5.84427938e-02f, 3.87755036e-02f, 9.95247588e-02f, 6.72599599e-02f, -1.30467907e-01f, 6.78075925e-02f, -1.40444972e-02f, 1.43405214e-01f,
  -6.06891662e-02f, -1.65762138e-02f, 1.04681954e-01f, 3.87254283e-02f, -2.07436476e-02f, 6.64904267e-02f, 4.53522317e-02f, 1.21808499e-01f, 9.92648453e-02f, -2.86731794e-02f,
  7.31754676e-02f, 1.02097042e-01f, 3.09824524e-03f, 5.29150814e-02f, 5.05281575e-02f, 4.60299887e-02f, 9.20378193e-02f, 1.14401482e-01f, 1.55495107e-01f, 3.14722247e-02f,
  4.71103564e-02f, 3.58519480e-02f, -1.82158798e-02f, -8.10358748e-02f, 1.46421231e-02f, -7.71179982e-03f, -5.01606651e-02f, 8.21778830e-03f, 9.99909174e-03f, 1.21904549e-03f,
  -5.05448459e-03f, -8.40116385e-03f, 1.06139378e-04f, -1.82262249e-02f, -5.88276424e-02f, -2.76973341e-02f, 3.20713334e-02f, -4.39819269e-04f, 6.92745950e-03f, -1.50147229e-02f,
  -2.65885890e-02f, 4.33543290e-04f, 4.06804010e-02f, 4.00233129e-03f, 2.64235530e-02f, -3.10792904e-02f, 4.99460399e-02f, 3.57360803e-02f, 2.64766272e-02f, 6.87893108e-02f,
  4.02881652e-02f, 3.01248692e-02f, -6.02002181e-02f, -4.47090250e-03f, 2.51206011e-02f, 5.32770790e-02f, 3.76646668e-02f, -4.49934043e-03f, 6.43731058e-02f, -2.94662570e-03f,
  -1.72871694e-01f, -3.42200816e-01f, -8.39973800e-03f, 4.44878452e-02f, -6.15409352e-02f, 4.54411395e-02f, -7.24927858e-02f, -6.24993779e-02f, -4.51400951e-02f, -6.65293261e-02f,
  4.70937714e-02f, 3.42329182e-02f, -2.88325176e-02f, 1.80929843e-02f, -8.98331124e-03f, -4.13203835e-02f, -9.19626132e-02f, -1.90811511e-02f, -1.87665671e-02f, -5.44405207e-02f,
  8.15807842e-03f, -5.68899186e-03f, -3.69643085e-02f, 4.64381650e-02f, 2.00670604e-02f, 4.42672707e-03f, -3.30077372e-02f, -2.28205640e-02f, -2.63990462e-03f, 2.50066407e-02f,
  3.23172778e-01f, -1.46943435e-01f, -8.04903731e-03f, 1.23190440e-01f, 1.94492504e-01f, 1.27128586e-01f, -3.31051648e-02f, 1.59554482e-01f, -8.44920427e-03f, 1.08735234e-01f,
  1.10526010e-01f, 2.81588119e-02f, -9.77722704e-02f, -1.27552748e-01f, -6.52446703e-04f, -2.04616889e-01f, 1.15406502e-03f, 3.27083617e-02f, -8.51120576e-02f, 4.65452671e-02f,
  2.54103523e-02f, -1.35369487e-02f, -8.80334452e-02f, 4.15034732e-03f, 2.03857616e-01f, 1.05607972e-01f, 1.16162777e-01f, 1.44784490e-03f, 1.12479627e-01f, 1.37528721e-02f,
  9.64543372e-02f, 1.64409369e-01f, 6.23630956e-02f, 1.30056575e-01f, 7.30626434e-02f, -4.04447652e-02f, -3.41830477e-02f, -1.53413392e-03f, 1.18327560e-02f, 4.58463058e-02f,
  -3.85499187e-02f, 4.46837731e-02f, 2.19160765e-02f, 6.86252341e-02f, 1.06769882e-01f, 1.24942467e-01f, 1.61447842e-02f, 5.17143905e-02f, -3.03464402e-02f, 3.38174449e-03f,
  -4.90592532e-02f, 5.78397028e-02f, -3.80837768e-02f, 1.82654355e-02f, 2.33964454e-02f, 5.08332951e-03f, -5.63068949e-02f, -2.09962297e-02f, 7.14474395e-02f, 4.42918614e-02f,
  4.73739766e-02f, -5.57018369e-02f, -1.97444204e-02f, 1.48876915e-02f, -4.90634553e-02f, 7.25818723e-02f, 1.57044735e-02f, -5.42157814e-02f, 4.67311032e-02f, 4.91816252e-02f,
  1.75362900e-02f, 1.63463857e-02f, 2.74942387e-02f, 3.75531428e-02f, -4.04406525e-02f, 2.03269962e-02f, -2.03137592e-04f, -1.76724307e-02f, -9.41089541e-02f, -3.92475305e-03f,
  -5.98876663e-02f, 8.85815360e-03f, -3.70674133e-02f, -8.91923532e-02f, 4.38784398e-02f, -1.21526485e-02f, 4.24147286e-02f, 3.41968387e-02f, 3.63258272e-02f, -5.15715070e-02f,
  1.30461931e-01f, 1.18194021e-01f, -5.48729263e-02f, 1.29038408e-01f, 1.05849415e-01f, 8.90574455e-02f, -3.20162028e-02f, 4.13729288e-02f, -3.30464728e-02f, 1.40284831e-02f,
  2.19245665e-02f, 1.18381612e-01f, 8.57504856e-05f, 4.07020785e-02f, -6.91536367e-02f, -6.02566265e-02f, -1.19303718e-01f, 2.51840390e-02f, 7.28672668e-02f, 5.99439070e-02f,
  1.12358876e-01f, -1.32204089e-02f, -4.04210202e-02f, -1.19218491e-02f, 4.22504023e-02f, 8.27526972e-02f, 4.04819921e-02f, -4.84034717e-02f, 2.47153975e-02f, 1.22948512e-02f,
  2.72547424e-01f, 1.63759872e-01f, 4.25998122e-02f, 1.47528782e-01f, 1.62413955e-01f, -1.75279491e-02f, -7.35558644e-02f, 1.26353651e-01f, 1.59001406e-02f, -1.13488398e-01f,
  4.63871434e-02f, -1.46538932e-02f, -1.83281064e-01f, 4.43601096e-03f, -6.66309595e-02f, -2.06463754e-01f, 3.22056934e-02f, 4.26199026e-02f, -6.84881434e-02f, 8.15491527e-02f,
  3.79522075e-03f, 1.12158768e-01f, 3.38280424e-02f, 1.41583577e-01f, 4.10668217e-02f, 6.88640848e-02f, -3.63384709e-02f, -2.42637796e-03f, 6.42121509e-02f, -7.61212024e-04f,
  1.43494651e-01f, 1.68078825e-01f, -3.48869041e-02f, 6.73311651e-02f, 5.40185049e-02f, 3.00774164e-02f, 1.67306643e-02f, -1.09691165e-01f, -1.11011311e-01f, 2.99552083e-02f,
  -5.20572923e-02f, -7.51005812e-03f, -4.30281274e-02f, -8.96774381e-02f, 9.03229639e-02f, 5.24804415e-03f, -5.22612520e-02f, -6.75572921e-03f, 2.15601772e-02f, 5.01545109e-02f,
  -5.02339378e-02f, 1.28963245e-02f, -1.35787232e-02f, 2.60710687e-04f, 2.16573607e-02f, 2.14067046e-02f, 5.35912067e-02f, -6.37810156e-02f, -1.12875784e-02f, 3.72791402e-02f,
  6.96870014e-02f, -3.94675434e-02f, -4.80223708e-02f, -6.56126142e-02f, 4.91456278e-02f, -5.73033607e-03f, -3.96442004e-02f, 1.93873455e-03f, 2.09851447e-03f, 1.10446706e-01f,
  -8.81060865e-03f, 6.26784042e-02f, -1.09150643e-02f, -2.81680916e-02f, 2.10919343e-02f, 5.64113036e-02f, -6.90934621e-03f, -4.82210442e-02f, 4.58195768e-02f, 2.00872514e-02f,
  -8.46348703e-03f, -4.24246453e-02f, 6.28990233e-02f, 5.20965457e-02f, 4.32756320e-02f, -9.53314081e-02f, -5.30770570e-02f, -3.99549603e-02f, 2.79227309e-02f, 2.05210149e-02f,
  9.53815952e-02f, 1.77543804e-01f, 2.27061864e-02f, 8.39813128e-02f, -6.78040013e-02f, -3.72835360e-02f, 5.26920659e-03f, -3.22321057e-02f, 2.00158190e-02f, -6.32270128e-02f,
  2.27524042e-02f, 2.34477669e-02f, 8.78061131e-02f, -1.00008985e-02f, -8.86360258e-02f, 2.72109788e-02f, -9.07248061e-04f, 8.63848906e-03f, -4.06877557e-03f, 6.53569549e-02f,
  5.70630282e-02f, -3.32743279e-03f, -1.85671002e-02f, 1.15551896e-01f, 4.12814394e-02f, 1.90128870e-02f, 3.14113609e-02f, 1.10790223e-01f, -3.45646800e-03f, -7.72260223e-03f,
  8.97276103e-02f, 3.59867126e-01f, -4.81712595e-02f, -1.92958921e-01f, -1.27287582e-01f, -1.16273584e-02f, -1.60051033e-01f, -8.62035528e-02f, -1.53396428e-01f, 1.43211052e-01f,
  -4.43562753e-02f, 7.65846819e-02f, 6.48048073e-02f, -1.10725813e-01f, -8.35439097e-03f, 7.31274486e-02f, -7.34162107e-02f, 2.44550928e-02f, 5.70562966e-02f, 4.86817509e-02f,
  5.88050112e-03f, -4.14089188e-02f, -6.10171556e-02f, 7.14320168e-02f, 9.44389105e-02f, 1.39624834e-01f, 3.64689678e-02f, 1.08073980e-01f, -3.27294767e-02f, -5.68866655e-02f,
  9.55042616e-02f, 2.45029368e-02f, -4.51392680e-02f, -4.17180173e-02f, 7.39989504e-02f, 3.66639271e-02f, 8.96287188e-02f, -8.83154850e-03f, -2.16835849e-02f, -5.33820726e-02f,
  1.25825718e-01f, 8.37890580e-02f, -7.78699701e-04f, -1.81658231e-02f, 5.86087536e-03f, -6.82872860e-03f, -3.71012688e-02f, 4.43130471e-02f, -3.59353796e-02f, 2.06924714e-02f,
  2.16744617e-02f, 7.57124424e-02f, 1.05305165e-01f, 3.94625179e-02f, 1.60054956e-02f, 8.01057220e-02f, 7.51032308e-02f, 2.13560313e-02f, 1.05706684e-01f, 4.32783961e-02f,
  -4.26384211e-02f, 6.48036376e-02f, -1.33388331e-02f, -5.86480163e-02f, -7.77980387e-02f, -1.00722216e-01f, -1.93694830e-02f, -7.29736239e-02f, -1.51750594e-02f, 3.71221080e-02f,
  1.81357488e-02f, -2.63167489e-02f, 3.12738530e-02f, -4.62396815e-02f, -3.81909236e-02f, -1.62183493e-02f, 9.60926414e-02f, 1.86007190e-02f, 3.22476514e-02f, 2.03066855e-03f,
  -8.05663690e-02f, -1.50346654e-02f, -3.01268492e-02f, 1.71044585e-03f, 3.33002098e-02f, 7.90521689e-03f, 1.59117226e-02f, 2.49044225e-02f, -7.96180293e-02f, -4.36503589e-02f,
  3.32433522e-01f, 2.77261555e-01f, 9.47572216e-02f, 2.46257707e-02f, 6.77288696e-02f, 8.68375674e-02f, 5.59681095e-02f, 4.59756842e-03f, 3.87595408e-02f, -8.34379420e-02f,
  9.96051803e-02f, -1.22880796e-02f, 6.01909757e-02f, 2.86435392e-02f, -1.77215261e-03f, 4.78841327e-02f, 2.68509053e-02f, 3.90660986e-02f, 1.10228553e-01f, 1.00477628e-01f,
  6.55327365e-02f, -2.68786103e-02f, 1.90638546e-02f, 1.96249876e-02f, -5.99776721e-03f, 6.93741962e-02f, 7.64821023e-02f, -1.40653653e-02f, -8.32062215e-02f, 4.12316918e-02f,
  -3.47328424e-01f, 2.29423165e-01f, 6.02059402e-02f, -8.86436403e-02f, -3.31816566e-03f, 2.68602163e-01f, -1.74819697e-02f, 7.74012432e-02f, 1.67006627e-01f, 1.39854088e-01f,
  -3.40356156e-02f, 5.36265271e-03f, 4.75631431e-02f, 1.13057569e-01f, -1.98155165e-01f, 1.80942193e-01f, -1.38143413e-02f, 1.19296275e-02f, 9.85206738e-02f, -1.20250449e-01f,
  2.04071160e-02f, 9.74266231e-03f, 5.86143620e-02f, 8.36031958e-02f, -1.04431704e-01f, -6.97492659e-02f, -2.01688990e-01f, -2.98984833e-02f, -3.80410217e-02f, -1.27359927e-02f,
  -9.56470147e-02f, -5.55593148e-02f, -8.11447389e-03f, 9.47053283e-02f, 1.34165641e-02f, -8.15278292e-03f, 3.21280994e-02f, -3.59705016e-02f, -5.74384145e-02f, 6.92883730e-02f,
  1.01126470e-02f, -7.71261230e-02f, 1.55425379e-02f, 2.47090794e-02f, 6.59334660e-02f, 5.75010180e-02f, -2.22146492e-02f, -5.29361330e-02f, 3.54431830e-02f, -4.71918173e-02f,
  4.52643372e-02f, 5.13559692e-02f, -7.16084987e-02f, 1.66182388e-02f, -5.06379940e-02f, 1.72682852e-02f, -2.20448393e-02f, 2.30363552e-02f, 4.02243845e-02f, -1.00059817e-02f,
  5.60916215e-02f, -2.79544089e-02f, 6.29851371e-02f, 1.07554402e-02f, -1.26986615e-02f, 2.87756305e-02f, 1.26876794e-02f, -6.26977533e-02f, 1.45512205e-02f, -2.48152092e-02f,
  -2.79515726e-03f, -3.43374908e-02f, 3.56136486e-02f, 6.78852201e-02f, -5.32910004e-02f, -1.67963374e-02f, 1.84893869e-02f, -1.68871842e-02f, -4.10551690e-02f, -1.55339539e-02f,
  3.64501365e-02f, 2.31930986e-02f, 2.50315350e-02f, 2.76851673e-02f, 1.05367620e-02f, -4.99469191e-02f, -2.74319779e-02f, -3.15456651e-02f, -4.49607335e-02f, -5.46854101e-02f,
  7.55190551e-02f, 1.47692457e-01f, 2.94212233e-02f, -1.43066263e-02f, 2.68284939e-02f, 3.87272649e-02f, 4.13817279e-02f, 1.65371615e-02f, 5.23944795e-02f, -1.14606656e-02f,
  6.85823942e-03f, 1.41150150e-02f, 1.10102877e-01f, -5.50700538e-02f, 2.95731210e-04f, -4.27264795e-02f, -2.14554556e-02f, -5.63884266e-02f, -3.29370536e-02f, -8.20056163e-03f,
  -4.36079837e-02f, -3.14323194e-02f, -4.12635654e-02f, -1.32084321e-02f, 5.10057956e-02f, -3.55304331e-02f, 2.35710619e-03f, -6.21518716e-02f, 3.07208765e-02f, -3.48942019e-02f,
  1.71951637e-01f, 1.33906743e-02f, -7.19152763e-02f, -8.75994191e-02f, -1.96658045e-01f, -3.86801094e-01f, -2.37251431e-01f, -6.72181025e-02f, -1.61872610e-01f, -1.04360757e-02f,
  -7.74871260e-02f, 1.17817111e-02f, 1.03122316e-01f, -2.01525703e-01f, -1.57290399e-01f, -1.14241485e-02f, -2.60810137e-01f, -1.58643067e-01f, 6.11725599e-02f, 3.26640643e-02f,
  7.98446462e-02f, -4.10847440e-02f, -1.26792146e-02f, 1.36011750e-01f, -9.72906053e-02f, 1.41425326e-01f, 1.57458991e-01f, 9.10135359e-02f, -4.71691079e-02f, -9.68612358e-02f,
  -2.77943518e-02f, 1.48461998e-01f, 2.29823440e-02f, -1.48658641e-02f, -2.29598172e-02f, -4.21539098e-02f, 4.47320868e-04f, -1.30639806e-01f, 1.01578541e-01f, -9.78181511e-02f,
  9.24771186e-03f, 3.62251699e-02f, -3.96568552e-02f, -2.09441371e-02f, -4.67898473e-02f, -3.05608381e-02f, 4.06194292e-03f, -8.06177780e-02f, 5.35722077e-02f, -4.46013249e-02f,
  -4.96276580e-02f, -4.97571193e-02f, 9.39134415e-03f, 1.27970241e-02f, 1.75649375e-02f, 8.14650487e-03f, 5.80167100e-02f, -7.16887191e-02f, -2.29979642e-02f, -7.05704540e-02f,
  5.29916994e-02f, -2.17417311e-02f, 3.58112231e-02f, 1.64040811e-02f, 2.06814557e-02f, 7.01594353e-02f, -3.00367009e-02f, 2.64935084e-02f, 5.37468679e-02f, 4.17874679e-02f,
  -8.30235928e-02f, 3.48352678e-02f, 3.32862958e-02f, 4.17335331e-02f, -6.36403486e-02f, 4.86739464e-02f, 5.72894292e-04f, -2.92108860e-02f, -7.53407553e-02f, -1.77726690e-02f,
  1.41342711e-02f, -3.13181579e-02f, -2.03038026e-02f, 1.31186880e-02f, -2.85076946e-02f, -4.52652872e-02f, -3.91928814e-02f, 4.18269960e-03f, -3.35111953e-02f, -8.05345848e-02f,
  4.30202708e-02f, 1.61356822e-01f, 1.22342375e-03f, 1.48649123e-02f, 1.81869064e-02f, -4.95898053e-02f, 3.53569314e-02f, -6.29742723e-03f, 2.93576065e-02f, 1.72826275e-02f,
  -1.51107470e-02f, -4.31920886e-02f, 7.58659989e-02f, 1.76314674e-02f, -2.71932427e-02f, -9.06087533e-02f, 2.82220822e-02f, -1.83177032e-02f, -3.45819183e-02f, 5.71505278e-02f,
  5.87605760e-02f, 5.95731363e-02f, -4.77954894e-02f, 1.36814732e-02f, -2.24128254e-02f, -4.55376431e-02f, -3.84789780e-02f, 4.65955548e-02f, -2.73534246e-02f, -7.93317631e-02f,
  -1.08173378e-01f, 1.42669946e-01f, 1.42577216e-01f, -1.73260912e-01f, -7.13929720e-03f, -8.82396400e-02f, 8.30106735e-02f, -1.32184848e-01f, -6.17705286e-03f, 7.57401809e-02f,
  -1.18519060e-01f, 1.83508262e-01f, 1.04997173e-01f, -7.41891861e-02f, -9.78134871e-02f, 1.52069658e-01f, -9.53247771e-02f, 4.94556054e-02f, -1.46919321e-02f, -1.82682667e-02f,
  -6.99854568e-02f, -2.14771539e-01f, 7.40372911e-02f, -6.91465437e-02f, -6.77843466e-02f, 3.29257846e-02f, -1.02894440e-01f, 6.73601255e-02f, -2.17672035e-01f, 5.29551022e-02f,
  2.26022229e-02f, -2.19341740e-03f, 6.71044439e-02f, 4.72405553e-02f, -1.08649626e-01f, -3.47414277e-02f, 7.85447285e-03f, 6.69027790e-02f, -2.25091726e-02f, -6.65007383e-02f,
  6.67190179e-02f, 1.45148998e-02f, -3.23458612e-02f, -4.34244201e-02f, 2.82591973e-02f, 7.61825368e-02f, 7.90776685e-02f, -5.36351884e-03f, 6.86924718e-03f, 4.71360274e-02f,
  -6.36362657e-03f, -3.22339945e-02f, -6.89719841e-02f, 1.08038262e-02f, -9.29401368e-02f, 1.34137208e-02f, 1.52415736e-02f, 4.24759323e-03f, -6.70806095e-02f, -3.70968096e-02f,
  3.81032676e-02f, 1.32919541e-02f, 3.71733047e-02f, 7.71205360e-03f, 4.15746197e-02f, 4.67843264e-02f, 2.26026755e-02f, 7.21548274e-02f, 3.99026573e-02f, 4.39572148e-02f,
  -7.67221674e-02f, -1.19538847e-02f, -1.31518524e-02f, -5.25893867e-02f, -5.79762720e-02f, -2.10768124e-03f, -7.06687663e-03f, 7.17984140e-02f, -6.96877092e-02f, -5.69983572e-02f,
  1.11862317e-01f, 2.20238939e-02f, 8.20278190e-03f, -2.07229201e-02f, -3.54923233e-02f, -1.81369316e-02f, 3.56852151e-02f, 5.98694803e-03f, 6.48596138e-02f, -2.24432070e-02f,
  -4.13844958e-02f, -1.18866496e-01f, 4.79263216e-02f, -1.19052352e-02f, 6.01112135e-02f, 4.57549915e-02f, -3.12332287e-02f, -5.79362400e-02f, -6.55865744e-02f, -3.67727829e-03f,
  -4.41323556e-02f, -1.49687622e-02f, -1.17267638e-01f, 1.52963800e-02f, 3.78748495e-03f, -1.10550672e-01f, -6.65412396e-02f, -2.39421632e-02f, -1.22317048e-02f, -3.64257060e-02f,
  -2.22139005e-02f, 1.41165713e-02f, 2.45854370e-02f, -2.60631330e-02f, -8.69542640e-03f, -5.47710881e-02f, -8.39622691e-02f, 4.19404954e-02f, -4.40758169e-02f, 7.66055807e-02f,
  1.97559834e-01f, -2.11988658e-01f, -2.12356430e-02f, 3.47598977e-02f, -5.81150092e-02f, 1.70368910e-01f, 1.89494893e-01f, -4.02388424e-02f, 1.85869396e-01f, -2.18314007e-01f,
  1.69414263e-02f, -6.74554333e-02f, -3.14610712e-02f, 3.38536277e-02f, 1.43973410e-01f, 2.03359291e-01f, 4.62576263e-02f, -7.80541124e-03f, 1.36000007e-01f, -1.84019446e-01f,
  9.91352275e-02f, -8.75845104e-02f, 7.05824420e-03f, -1.33070022e-01f, -1.54321820e-01f, -4.19264063e-02f, -2.89870530e-01f, -5.59945107e-02f, -1.10635653e-01f, -5.68462498e-02f,
  7.94631839e-02f, 1.89734753e-02f, -6.26433715e-02f, 1.77834705e-02f, -5.88184781e-03f, -6.78956211e-02f, -4.33430672e-02f, -1.22376410e-02f, 6.70639500e-02f, -6.71536028e-02f,
  -6.31077960e-02f, 3.80866602e-02f, 4.59136218e-02f, 5.35641946e-02f, 2.47030472e-03f, 1.50613859e-02f, -1.13058062e-02f, 3.86385880e-02f, -3.49853225e-02f, 8.12917948e-03f,
  2.00662669e-02f, 1.70151051e-02f, -6.87234290e-03f, -7.43008628e-02f, 3.98879088e-02f, -7.18784109e-02f, 6.37958944e-02f, -5.20120859e-02f, -3.01920250e-02f, 7.91363642e-02f,
  -4.32792790e-02f, 1.21261142e-02f, 3.37131098e-02f, 6.66576717e-03f, 5.81122609e-03f, 5.87128662e-02f, 1.36905219e-02f, -7.37305405e-03f, 7.85377715e-03f, -5.57631329e-02f,
  -4.29378822e-02f, 4.16411906e-02f, -5.03856055e-02f, -2.00146046e-02f, -3.84689048e-02f, -3.07614207e-02f, 2.89466046e-02f, -9.05737057e-02f, 2.51310300e-02f, 6.63845986e-02f,
  -2.95740236e-02f, -2.32082158e-02f, 2.50727665e-02f, -8.45677853e-02f, -1.09795928e-02f, -7.48828147e-03f, -4.37629633e-02f, -1.35167642e-03f, -4.43669893e-02f, 6.82753697e-02f,
  -1.11254983e-01f, -1.67404249e-01f, 6.29522186e-03f, -2.59201811e-03f, -4.54178117e-02f, -1.96519941e-02f, 6.48892894e-02f, 1.49767958e-02f, -1.34869954e-02f, -2.25191060e-02f,
  -4.85092998e-02f, -4.68848832e-02f, -1.01925597e-01f, -3.46851051e-02f, 3.04122344e-02f, 5.79834804e-02f, -5.31166866e-02f, 4.21971977e-02f, -9.77756754e-02f, -1.62651390e-02f,
  -6.30263388e-02f, -8.85797888e-02f, 2.53153499e-02f, 6.99428767e-02f, -9.85343680e-02f, -5.61448485e-02f, -8.14820081e-02f, 3.15722302e-02f, 1.34676788e-02f, -7.44425207e-02f,
  1.21478587e-01f, 2.71538019e-01f, 1.01954751e-01f, 4.27625626e-02f, -9.69877280e-03f, -1.49916619e-01f, -4.62851971e-02f, 2.49675810e-01f, 1.66519478e-01f, 1.93918869e-01f,
  -6.14814237e-02f, -9.09582824e-02f, 5.69217326e-03f, -7.04852790e-02f, -2.99547911e-01f, -1.14362046e-01f, -1.26358092e-01f, -6.31781146e-02f, 3.09465602e-02f, -8.97726975e-04f,
  -3.23394723e-02f, -5.22498973e-02f, -9.91116986e-02f, 7.14393985e-03f, -2.50883983e-03f, 1.48146734e-01f, -3.52637768e-02f, -7.49607745e-04f, -9.42594111e-02f, -6.31491095e-02f,
  8.20137560e-02f, 1.42826602e-01f, 2.40712805e-04f, 8.67508352e-02f, 1.93720125e-02f, -1.31413683e-01f, 4.33847010e-02f, 2.09427420e-02f, 1.50740007e-02f, 9.03493911e-02f,
  -2.81694625e-02f, 6.29818961e-02f, -7.44620264e-02f, 5.29877096e-03f, -3.23085161e-03f, 6.35571107e-02f, -1.11574605e-02f, 3.06187756e-02f, 1.66504998e-02f, -1.02697305e-01f,
  2.86606867e-02f, -1.82030033e-02f, -7.88959116e-02f, 2.60313554e-03f, -1.98893081e-02f, 2.04856396e-02f, -6.39963821e-02f, -1.06332198e-01f, -3.93611528e-02f, 1.68218128e-02f,
  -1.51255783e-02f, -5.91636449e-02f, 5.43444278e-03f, 2.81174146e-02f, 3.92975360e-02f, -5.22550046e-02f, 2.54961289e-02f, -5.81667349e-02f, 5.04810736e-03f, -9.57775190e-02f,
  -1.02511831e-01f, 3.66780199e-02f, -4.14315648e-02f, -8.22935998e-02f, -7.47844926e-04f, 5.65387942e-02f, -3.90438624e-02f, 2.91669779e-02f, -8.31577405e-02f, -8.86815935e-02f,
  7.78652774e-03f, 3.28738941e-04f, -4.51280698e-02f, 2.03385931e-02f, 2.84522716e-02f, 4.69602272e-02f, -4.67392709e-03f, 6.21931665e-02f, -6.64876774e-02f, -1.61135290e-02f,
  1.93336621e-01f, 1.96602225e-01f, 5.82067780e-02f, 9.85759050e-02f, -1.11099429e-01f, -5.39586730e-02f, -5.64893298e-02f, -4.93251765e-03f, 7.78343454e-02f, -2.61346977e-02f,
  -1.97633170e-02f, 6.11297525e-02f, -2.59509664e-02f, -3.70445289e-02f, -2.03435812e-02f, -4.49572019e-02f, -3.72902304e-02f, 9.37620923e-02f, 8.11717287e-02f, 2.35045925e-02f,
  -3.36203054e-02f, -2.43526325e-03f, 2.01658309e-02f, 1.52667798e-02f, 8.74991640e-02f, -6.10381775e-02f, 1.01334617e-01f, 2.68508345e-02f, 1.84905827e-02f, -3.35395825e-03f,
  -2.99588621e-01f, -7.14751482e-02f, -1.26940951e-01f, -3.10499966e-01f, 1.95912793e-02f, 7.16587827e-02f, -8.56989250e-03f, -6.39067292e-02f, -1.21748023e-01f, -1.11703891e-02f,
  3.32036354e-02f, -1.58513412e-01f, 1.59486085e-01f, -2.74455070e-01f, -2.52939969e-01f, -4.50974237e-03f, -9.44008529e-02f, -1.08359262e-01f, -4.01431620e-02f, -9.27316397e-02f,
  -2.96664312e-02f, -8.85648504e-02f, -1.58444718e-01f, 3.27133387e-02f, -8.50442126e-02f, 4.19685729e-02f, 6.04011938e-02f, 1.36935025e-01f, -3.74167785e-02f, -3.90824266e-02f,
  -3.46568879e-03f, -3.44038755e-02f, -1.09354585e-01f, 1.82889234e-02f, 6.23237193e-02f, -2.79116388e-02f, -3.04989088e-02f, -1.52909039e-02f, 8.89913552e-03f, 6.33377302e-03f,
  1.83672793e-02f, -8.71535242e-02f, -4.98320200e-02f, 5.50956354e-02f, 4.32028994e-02f, -4.69438545e-02f, -9.91645604e-02f, -2.85692066e-02f, -3.84824798e-02f, -1.05338357e-01f,
  -1.22582890e-01f, -5.30434847e-02f, 7.74882510e-02f, 6.06019050e-02f, -3.18782367e-02f, -2.94927172e-02f, 3.47640850e-02f, 8.14010948e-03f, 1.91832241e-02f, -4.41798605e-02f,
  -4.72661033e-02f, -1.64260790e-02f, -5.16836420e-02f, -3.73434797e-02f, 3.91940586e-03f, 1.16209248e-02f, 9.65978801e-02f, 2.87058149e-02f, -8.15770309e-03f, -2.06885319e-02f,
  5.26300147e-02f, 3.86933684e-02f, -3.61887589e-02f, 4.05948684e-02f, 4.63128909e-02f, -6.02465868e-03f, -2.81457864e-02f, -1.67768802e-02f, -2.69341413e-02f, -6.15305407e-03f,
  1.06797507e-02f, 5.67541383e-02f, 3.52594368e-02f, 1.00617725e-02f, 3.17720324e-02f, 5.47461137e-02f, 2.79533602e-02f, 5.56376241e-02f, 7.87201151e-02f, 7.48618767e-02f,
  3.42937931e-02f, -4.82273549e-02f, 3.32010463e-02f, -1.45729836e-02f, 9.42866504e-02f, 3.18453200e-02f, 1.73674952e-02f, -4.27574068e-02f, 2.26949155e-02f, 3.30040306e-02f,
  1.40768932e-02f, 4.60288078e-02f, 1.02767810e-01f, 2.42084321e-02f, 2.10822634e-02f, 3.05347946e-02f, 7.32367635e-02f, -2.36086771e-02f, -3.66899818e-02f, -5.48594818e-02f,
  -1.01148181e-01f, -4.33152318e-02f, -2.94596590e-02f, -5.18639162e-02f, -1.33713223e-02f, 1.84236735e-03f, -4.49186042e-02f, 4.25973069e-03f, -2.05919165e-02f, 6.23468757e-02f,
  1.94387794e-01f, -1.25139961e-02f, -6.81363717e-02f, 1.19014867e-02f, 1.53026238e-01f, -3.86096351e-02f, -1.81452200e-01f, 1.06315844e-01f, 2.43302703e-01f, -4.29854952e-02f,
  -1.11474872e-01f, 1.93270762e-02f, 8.15371610e-03f, -2.28804454e-01f, -1.20489947e-01f, -1.20499954e-01f, -1.31999895e-01f, 7.77411088e-02f, 1.10370949e-01f, 1.31065771e-02f,
  4.00693528e-02f, -1.31002977e-01f, -1.78632960e-01f, -4.33474779e-02f, 4.49839421e-02f, -1.92494951e-02f, -8.11190158e-02f, -3.99751179e-02f, -2.06757098e-01f, -6.48494512e-02f,
  -2.06289254e-02f, -2.26675514e-02f, 8.11397284e-03f, 7.75755057e-03f, 9.79542267e-04f, 3.94057892e-02f, -1.16493925e-01f, 3.03207140e-04f, 1.51137570e-02f, -4.32363711e-02f,
  1.91664714e-02f, -6.89256564e-02f, -2.58879759e-03f, -2.18475759e-02f, 1.10542132e-02f, -2.09273342e-02f, 2.96065975e-02f, -5.60776405e-02f, 3.22793275e-02f, -2.39003506e-02f,
  -5.78974411e-02f, -1.35589382e-02f, 5.11171743e-02f, -6.80554882e-02f, -5.37747927e-02f, 6.13540113e-02f, -9.30962488e-02f, 3.67318578e-02f, -9.34776217e-02f, -5.71944937e-02f,
  4.63641286e-02f, 2.00319327e-02f, -4.62502576e-02f, 8.67897645e-02f, -7.47021707e-03f, -4.36692387e-02f, -8.68325606e-02f, -2.87535954e-02f, -1.85776185e-02f, 1.75030204e-03f,
  -4.50687930e-02f, 7.32237622e-02f, -1.74226072e-02f, -1.06081646e-03f, 4.98953760e-02f, 1.59837138e-02f, -3.60044390e-02f, -6.27088249e-02f, 3.50632705e-02f, 1.85278803e-02f,
  -9.46035385e-02f, -9.00188908e-02f, 2.02656854e-02f, 9.04794559e-02f, -5.52663617e-02f, 5.36398739e-02f, -7.25116506e-02f, -4.09568846e-03f, -2.83002649e-02f, -4.41276580e-02f,
  -3.73910880e-04f, -2.67397482e-02f, -1.77801447e-03f, -7.99224675e-02f, 3.43746282e-02f, 1.51370205e-02f, -8.41902569e-02f, 4.59157974e-02f, -5.30938879e-02f, -1.95375606e-02f,
  -3.44766490e-02f, -1.38118844e-02f, -6.40097857e-02f, -9.03266110e-03f, 3.62750180e-02f, 6.03651488e-03f, -4.78651896e-02f, -4.92951386e-02f, -2.36358829e-02f, 8.17290694e-02f,
  -1.11060560e-01f, -7.05963820e-02f, 4.60700728e-02f, -3.64071988e-02f, 3.27227786e-02f, -3.63891870e-02f, 1.02201983e-01f, -2.06247550e-02f, 2.29085889e-02f, 2.09079944e-02f,
  2.86496710e-03f, -1.19230926e-01f, 1.93673983e-01f, -1.13201439e-01f, 1.67485163e-01f, -1.34761482e-01f, -1.72648028e-01f, 5.53606153e-02f, 1.60665866e-02f, -2.76377976e-01f,
  -1.22889817e-01f, 1.15591750e-01f, -2.61119325e-02f, -1.82605267e-01f, 1.04720928e-01f, -2.00778339e-02f, -2.24962562e-01f, -1.16694808e-01f, 2.86057889e-02f, -2.86157336e-02f,
  1.01420417e-01f, -2.06372924e-02f, -3.11561543e-02f, 6.40503615e-02f, 6.51363209e-02f, 8.12667608e-02f, -8.33514631e-02f, 8.30752477e-02f, -9.24774110e-02f, 2.54841987e-02f,
  -1.87028080e-01f, -3.88109349e-02f, -2.15595402e-02f, -5.11311777e-02f, -2.10990421e-02f, 2.53400789e-03f, -4.59509529e-02f, 3.34003381e-02f, 4.18136716e-02f, -4.95560504e-02f,
  5.85672492e-03f, 5.11223190e-02f, 8.06844234e-02f, 3.02620083e-02f, -4.44207378e-02f, 9.91376266e-02f, -8.47431272e-03f, -2.32248306e-02f, -4.46425229e-02f, -2.90643033e-02f,
  9.56825074e-03f, -4.30557353e-04f, -3.48355882e-02f, -4.00839187e-02f, 3.22548300e-02f, -3.52785662e-02f, 4.57188766e-03f, 7.03807250e-02f, 4.26505096e-02f, 1.38396500e-02f,
  1.20699905e-01f, 2.65878886e-02f, 2.60196254e-03f, 4.52139005e-02f, -2.24031843e-02f, 2.93722171e-02f, -4.46050651e-02f, -1.31412987e-02f, -1.25274807e-02f, -7.93382749e-02f,
  -6.27943203e-02f, -8.03668872e-02f, 2.68164892e-02f, -6.11169375e-02f, -1.92554779e-02f, -9.46227908e-02f, 5.23567498e-02f, -2.66733598e-02f, 3.05307340e-02f, -7.47865364e-02f,
  -2.59412620e-02f, 9.39623415e-02f, -1.84469856e-02f, -3.59389186e-02f, 1.99963059e-02f, -1.46245994e-02f, -5.01128547e-02f, -7.61034479e-03f, -3.30158509e-02f, 8.21211487e-02f,
  -2.31527463e-01f, -1.35260805e-01f, -1.03687393e-02f, -1.04785353e-01f, -7.34711066e-02f, -5.99569827e-02f, -2.79806182e-02f, 9.32562072e-03f, -1.25535093e-02f, 3.00249606e-02f,
  -5.56928180e-02f, -1.02632865e-01f, -3.57894674e-02f, -7.18022734e-02f, -6.96532726e-02f, -5.65149747e-02f, -5.48487157e-03f, -3.56661767e-04f, 1.15535234e-03f, -6.39469028e-02f,
  -6.16961308e-02f, 1.03013543e-02f, 5.33027686e-02f, -4.99688350e-02f, 1.61763572e-03f, -4.01081443e-02f, 5.51192090e-02f, -9.11118910e-02f, -3.74980979e-02f, 4.91556711e-02f,
  -6.95747808e-02f, -6.31960183e-02f, 4.26586755e-02f, -1.11487638e-02f, 3.25616226e-02f, -1.03103824e-01f, -1.13485396e-01f, -1.31431535e-01f, 2.35749222e-02f, -1.03730567e-01f,
  3.88625870e-03f, -1.42573882e-02f, -3.68780941e-02f, -1.40339106e-01f, -4.55811657e-02f, -1.64834056e-02f, -1.04222558e-01f, 5.33447973e-02f, 2.60262806e-02f, -1.35794446e-01f,
  2.22190358e-02f, -1.45241320e-01f, 3.27582806e-02f, -1.08688556e-01f, 1.71725601e-02f, -2.27723783e-03f, -4.00497727e-02f, 2.42354311e-02f, 8.15933943e-03f, -6.73129689e-03f,
  2.73584295e-02f, -5.02515137e-02f, 5.21974750e-02f, 5.80826104e-02f, -4.46236022e-02f, -2.81774718e-02f, 4.85987365e-02f, -2.91165952e-02f, 7.82294944e-02f, 3.86560615e-03f,
  -8.61505140e-03f, 1.89212300e-02f, -5.04746521e-03f, 2.88730189e-02f, -1.00018224e-02f, -1.22622270e-02f, 5.36245778e-02f, -5.46671376e-02f, -1.80834699e-02f, 5.87857850e-02f,
  5.26600033e-02f, 6.81412220e-02f, -4.43215705e-02f, -8.24014992e-02f, -2.94317380e-02f, 3.93487886e-03f, 4.86911051e-02f, -1.30708851e-02f, 9.11148787e-02f, -1.07716734e-03f,
  -2.22785324e-02f, -2.10764594e-02f, 7.19047561e-02f, 2.58144159e-02f, 2.23124567e-02f, 5.34687899e-02f, 7.21238628e-02f, -6.04299307e-02f, 2.53638905e-02f, 5.12989014e-02f,
  -3.12258918e-02f, 7.28646517e-02f, 2.03613308e-04f, 6.27419651e-02f, 2.02970337e-02f, 1.53321773e-02f, -1.48019092e-02f, 7.08922148e-02f, 1.69808399e-02f, 7.65752420e-02f,
  -2.12193914e-02f, -4.09002602e-02f, 6.45001084e-02f, 1.04459897e-01f, 7.83554390e-02f, 5.19414013e-03f, 5.69612794e-02f, 1.81087274e-02f, -1.97187196e-02f, -5.54365478e-02f,
  -6.26027435e-02f, -1.64134398e-01f, -2.39675231e-02f, 5.29012978e-02f, 5.15526421e-02f, -7.64280558e-02f, -6.56050593e-02f, -1.43882120e-02f, -8.56218338e-02f, 1.85653591e-03f,
  -1.76570062e-02f, 3.58264172e-03f, -7.64536187e-02f, 5.16041480e-02f, 1.02642449e-02f, -2.70867068e-02f, 2.61263493e-02f, -4.38193120e-02f, -6.66528344e-02f, -5.41429557e-02f,
  -3.49793583e-02f, -1.06827794e-02f, 4.37846668e-02f, 3.11508868e-02f, 5.45327291e-02f, -3.53435203e-02f, -8.96811262e-02f, 5.36125898e-02f, -4.03514095e-02f, -5.37698120e-02f,
  7.67419562e-02f, 8.04124027e-02f, 1.82298377e-01f, 2.15165988e-01f, 1.53836593e-01f, -1.30826101e-01f, -5.88375777e-02f, 1.44246474e-01f, 1.37125671e-01f, -5.30168340e-02f,
  -4.89614904e-02f, -1.10290735e-03f, -2.19242260e-01f, 5.57202436e-02f, -1.33914500e-01f, -2.16625974e-01f, 1.20138153e-01f, -1.51175540e-02f, 1.38317347e-02f, 2.37493403e-02f,
  7.80632570e-02f, 9.97346714e-02f, 8.45071077e-02f, 1.96448699e-01f, 1.27292648e-01f, 2.01465145e-01f, 1.46985620e-01f, -1.05651394e-01f, 1.08215176e-01f, -5.04737124e-02f,
  -1.02564387e-01f, -8.93489048e-02f, 6.42190799e-02f, -6.59226030e-02f, 6.88150451e-02f, 9.72531457e-03f, 2.42875591e-02f, -7.38098845e-02f, -5.02134999e-03f, -6.16716668e-02f,
  -5.54181971e-02f, 4.64736931e-02f, -5.08582555e-02f, 1.56146835e-03f, 6.19436763e-02f, 4.07128744e-02f, -4.02983986e-02f, 5.42014465e-02f, 3.29833291e-02f, -5.33751212e-02f,
  6.29101023e-02f, 2.22637318e-03f, 9.49585289e-02f, 4.67398167e-02f, 6.51364401e-02f, -3.05138994e-02f, -1.36660843e-03f, -1.35895042e-02f, -6.59283549e-02f, -5.06694661e-03f,
  -7.37088770e-02f, -1.51685476e-02f, 3.73380035e-02f, -9.64596402e-04f, -1.76588278e-02f, 3.97658907e-02f, 5.52135073e-02f, 2.90260259e-02f, 2.69532837e-02f, -3.64374034e-02f,
  1.00437999e-01f, 1.32349813e-02f, -3.65895256e-02f, -5.45340478e-02f, 3.61066638e-03f, -3.89118493e-02f, 3.18215936e-02f, -6.91616461e-02f, 4.36469167e-02f, 1.52737619e-02f,
  -1.85674708e-03f, -5.84671646e-03f, 9.73081123e-03f, 6.88617909e-03f, -3.06720659e-02f, -1.08427452e-02f, 1.90056302e-02f, -1.96060613e-02f, -4.68812250e-02f, 5.27126435e-03f,
  8.26012939e-02f, 1.46462739e-01f, -6.20170720e-02f, -4.27157898e-03f, 5.97655261e-03f, 7.01115429e-02f, 8.35816143e-04f, 2.43323948e-02f, 4.13912460e-02f, 1.23881679e-02f,
  1.00558987e-02f, -7.46465772e-02f, -9.64802504e-03f, -6.14456572e-02f, -5.09375185e-02f, -2.71501318e-02f, -5.79598881e-02f, 7.43730739e-02f, 8.88448209e-02f, 1.58854835e-02f,
  -1.75511129e-02f, -1.10096425e-01f, -5.47164679e-02f, 7.95163140e-02f, -1.88434497e-02f, 5.54545410e-02f, 2.53309086e-02f, -4.27759439e-03f, 4.74930089e-03f, 8.55870247e-02f,
  3.58572036e-01f, -4.88213729e-03f, -1.05935358e-01f, 8.68441164e-02f, 4.33334187e-02f, 9.63249207e-02f, 2.11969823e-01f, 3.35972123e-02f, 8.44305679e-02f, -3.22583206e-02f,
  1.16353527e-01f, -7.31120631e-02f, 1.12368397e-01f, -2.15039756e-02f, 2.33178228e-01f, 3.11797708e-02f, 1.17118537e-01f, -5.01275919e-02f, -7.20136762e-02f, 1.43289074e-01f,
  4.30438519e-02f, -1.37732262e-02f, -2.91749593e-02f, -1.84970006e-01f, -1.16263854e-03f, -4.20454182e-02f, 1.19537162e-03f, -1.45864263e-01f, -5.30845672e-02f, -1.27929658e-01f,
  4.26788582e-03f, 1.52232079e-02f, 3.26196514e-02f, -8.35651308e-02f, 3.71107645e-02f, 3.32580805e-02f, -5.89861460e-02f, -7.50873908e-02f, -2.15953030e-02f, -7.78645352e-02f,
  -3.85669470e-02f, -5.03437556e-02f, -7.08110258e-02f, -8.50421041e-02f, 1.50445327e-02f, 1.90127790e-02f, -8.63794014e-02f, -4.80121933e-02f, 2.96116304e-02f, -2.67678946e-02f,
  2.65925638e-02f, -7.95892626e-02f, -1.30593050e-02f, -2.52441075e-02f, -1.13512866e-01f, 3.17008421e-02f, -6.39472576e-03f, -9.01007932e-03f, 6.71389455e-04f, -1.06255621e-01f,
  -8.25850964e-02f, 2.04455536e-02f, 6.74657002e-02f, 1.27502736e-02f, 3.95556353e-02f, 2.54130270e-02f, 4.74769808e-02f, -4.49379124e-02f, 2.75844987e-02f, 2.07458772e-02f,
  5.13408892e-02f, 9.25059337e-03f, -9.16481391e-03f, 5.05088493e-02f, 7.54388720e-02f, 3.23598757e-02f, -4.58468087e-02f, -4.50078361e-02f, 1.13973056e-03f, 4.24154177e-02f,
  9.59389806e-02f, 5.16459905e-02f, -2.56857872e-02f, 2.32807789e-02f, -2.49447022e-02f, 6.67126477e-02f, -1.03536323e-01f, -2.29542218e-02f, 6.88275024e-02f, -4.03426774e-03f,
  1.85304642e-01f, 2.92480458e-03f, 1.23629661e-03f, -3.47144976e-02f, -2.89729182e-02f, -1.23339653e-01f, 1.16022620e-02f, -4.96140867e-02f, -1.06726438e-02f, 8.16703662e-02f,
  -3.67700160e-02f, -1.08571695e-02f, 1.02229066e-01f, 4.46304195e-02f, -4.55880016e-02f, -3.95279415e-02f, 8.76141712e-02f, -3.86065729e-02f, -1.85031295e-02f, -5.98793328e-02f,
  -3.39295082e-02f, 9.30389911e-02f, -5.13570271e-02f, 1.77437551e-02f, -2.66731735e-02f, -4.92234540e-04f, 7.01775402e-02f, 3.53489444e-02f, -5.74252494e-02f, -5.59612736e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.01759586e-02f, -2.36814022e-01f, 3.19487244e-01f, -6.78314315e-03f, 2.45073006e-01f, 2.00496405e-01f, 2.63615936e-01f, -7.01080412e-02f, -1.03877902e-01f, -2.34783515e-01f,
  -2.01672595e-02f, -1.67390332e-02f, 1.62415117e-01f, -2.50076592e-01f, 3.31459820e-01f, 8.22870061e-02f, -3.90840247e-02f, -1.73333228e-01f, 3.49357501e-02f, -1.11738250e-01f,
  -4.75724638e-02f, -2.49432027e-01f, 1.61666051e-01f, -3.13229591e-01f, -3.47408094e-02f, -1.05576366e-01f, -4.83676605e-02f, 1.27074212e-01f, -2.45968476e-01f, 6.62413463e-02f,
  -5.98327033e-02f, 1.71460246e-03f, 2.19282862e-02f, -9.96018946e-02f, -2.93982513e-02f, -5.98556660e-02f, 8.16242546e-02f, 2.19616741e-01f, 1.65147372e-02f, 1.71857607e-02f,
  9.65680054e-04f, 4.92117554e-02f, -1.61201537e-01f, 4.00224924e-02f, -6.16956539e-02f, 4.30441462e-02f, 3.50584909e-02f, -1.98618267e-02f, 2.30321456e-02f, 8.50374401e-02f,
  9.98995081e-03f, 1.63162649e-02f, -6.90500531e-03f, -2.78430805e-02f, 7.83500075e-02f, 2.79775336e-02f, -5.36969863e-03f, 8.32415968e-02f, -4.20199847e-03f, -7.93912113e-02f,
  -3.30289453e-03f, 2.89133890e-03f, 5.75575931e-03f, -5.30406386e-02f, 1.82821490e-02f, -6.75163046e-02f, 5.73136786e-04f, 9.02966596e-03f, 6.15864173e-02f, 5.45264818e-02f,
  1.68866385e-02f, 2.17037797e-02f, 4.38439287e-02f, 4.79365606e-03f, -8.96871984e-02f, -3.32187973e-02f, 1.71330222e-03f, 3.87077704e-02f, -6.99169934e-02f, -7.06178993e-02f,
  -1.74746662e-02f, 5.78457164e-03f, 6.50267974e-02f, -1.32005662e-02f, 2.44345199e-02f, 4.12882678e-02f, -8.95369500e-02f, -2.94587080e-04f, -2.90422142e-02f, 4.59009036e-02f,
  -2.03888983e-01f, -2.80998945e-01f, 2.47619879e-02f, 1.63507797e-02f, -8.88481438e-02f, -9.97799169e-03f, 3.77837867e-02f, -9.39411968e-02f, -3.29148769e-02f, 2.03796439e-02f,
  -2.14069840e-02f, -1.89740546e-02f, 3.13274674e-02f, 7.26031289e-02f, -3.25718671e-02f, -2.33666413e-02f, -7.01060221e-02f, -8.94949213e-02f, -4.97783646e-02f, -3.19135301e-02f,
  2.94258259e-02f, -4.91806082e-02f, 6.16821647e-02f, -7.08967969e-02f, -1.01259712e-03f, 2.86000315e-02f, 4.66010645e-02f, 6.51802868e-02f, 7.12410659e-02f, 1.51887592e-02f,
  -8.36572275e-02f, 2.15222344e-01f, -2.04686150e-01f, -1.11642556e-04f, -1.92927435e-01f, 2.34938309e-01f, 2.38993019e-01f, -7.55789578e-02f, 8.32110643e-02f, 2.93155134e-01f,
  2.55456686e-01f, 1.40727535e-01f, 2.42442101e-01f, 4.04082149e-01f, 1.10696450e-01f, 1.70725048e-01f, 1.85769811e-01f, 1.51840001e-01f, -1.24496236e-01f, 2.14990407e-01f,
  -1.28984168e-01f, 2.99928367e-01f, -5.89981396e-03f, -7.09526464e-02f, 9.96199623e-02f, -2.21810743e-01f, 1.95355825e-02f, -2.01680791e-02f, 1.29186019e-01f, 8.33410248e-02f,
  4.44078892e-02f, 3.33621725e-02f, -2.34710258e-02f, 1.54323019e-02f, 1.59018375e-02f, -8.20921361e-02f, -1.01796538e-02f, -9.89139378e-02f, 4.29709479e-02f, 2.12338492e-02f,
  3.04707550e-02f, -7.95148686e-02f, 1.34359956e-01f, 2.22534128e-02f, 1.91480331e-02f, -1.15202442e-01f, 7.04607787e-03f, 1.27718657e-01f, 2.82677114e-02f, -3.85342799e-02f,
  -8.96948669e-03f, -5.11329435e-02f, 2.03401390e-02f, 4.22236398e-02f, -2.59877015e-02f, 9.36456919e-02f, 5.40972799e-02f, -6.91360533e-02f, 2.90402919e-02f, 2.34211180e-02f,
  2.62706075e-02f, 4.24130969e-02f, 7.53465155e-03f, 5.31610548e-02f, 1.72983855e-02f, -4.23335433e-02f, 3.74701694e-02f, 8.29667822e-02f, -6.30423576e-02f, 4.02991362e-02f,
  3.89575325e-02f, -3.44876461e-02f, 8.19972996e-03f, -1.58230923e-02f, 2.49747988e-02f, -2.24450249e-02f, 1.90166302e-03f, -2.50642858e-02f, -5.95028587e-02f, -2.94395704e-02f,
  7.38744345e-03f, -2.82159988e-02f, 3.91195789e-02f, 3.25999446e-02f, 4.66101877e-02f, -1.18291937e-01f, 1.79042481e-02f, 5.07098064e-02f, -1.30181732e-02f, -7.30820522e-02f,
  1.31536767e-01f, 2.92354003e-02f, 1.93528384e-02f, 1.00828027e-02f, -3.00107319e-02f, -7.46279880e-02f, 2.27052849e-02f, 2.45328285e-02f, -6.24173172e-02f, 4.24399674e-02f,
  -9.70775858e-02f, 5.10166064e-02f, -1.63132194e-02f, 3.40651125e-02f, -3.52638997e-02f, 4.30201441e-02f, 9.11399946e-02f, -6.97193816e-02f, -1.38675459e-02f, 2.92476714e-02f,
  1.70428269e-02f, -6.03154711e-02f, -1.07814604e-02f, -4.28752340e-02f, 3.75809781e-02f, 7.14111105e-02f, -5.94612993e-02f, -6.20336458e-02f, -1.18614644e-01f, 7.57662207e-02f,
  -1.46947309e-01f, -9.58876908e-02f, -2.46951163e-01f, -1.16243273e-01f, -1.67567343e-01f, -3.31128716e-01f, -2.93181449e-01f, -6.03534468e-02f, -7.52794221e-02f, 1.38444632e-01f,
  -1.20458499e-01f, 1.64635666e-02f, 1.52899757e-01f, -1.07005738e-01f, -6.04326278e-02f, 2.44936734e-01f, -8.87927338e-02f, 4.15427536e-02f, 1.84960011e-02f, -9.51683223e-02f,
  3.73626500e-02f, -1.43940464e-01f, 1.56684797e-02f, -4.63260710e-02f, -1.71718493e-01f, -3.64018679e-02f, -2.34562112e-03f, -1.74118042e-01f, -4.66703065e-02f, -2.38899514e-02f,
  -1.33729260e-02f, -2.01901738e-02f, -1.74130797e-01f, -4.90180328e-02f, -3.68756950e-02f, 4.11895402e-02f, -1.34373203e-01f, -7.72247612e-02f, 4.12994400e-02f, -2.19951272e-02f,
  -5.66565059e-02f, -2.74138190e-02f, -7.25135282e-02f, -2.66238145e-04f, -1.28514189e-02f, -2.10815761e-02f, 2.53943801e-02f, -6.27731148e-04f, -5.38860075e-02f, 4.70439605e-02f,
  -1.48160204e-01f, 1.06041953e-02f, 6.60625175e-02f, 1.11181632e-01f, -6.98701304e-04f, -8.59812647e-02f, -3.98712754e-02f, -6.87652677e-02f, -9.28898752e-02f, -2.27704048e-02f,
  -9.66901407e-02f, -5.25451787e-02f, -8.67275894e-02f, -5.43784872e-02f, -2.02865880e-02f, 9.84116942e-02f, -6.60285726e-02f, 6.14442900e-02f, -2.04776358e-02f, 8.28561634e-02f,
  3.73548009e-02f, 3.31981480e-02f, 2.58334372e-02f, 1.77392121e-02f, -2.56001279e-02f, 1.98289901e-02f, 4.07856293e-02f, -2.03706063e-02f, 4.06329297e-02f, 4.18262258e-02f,
  5.03554754e-03f, 4.94292676e-02f, -2.46841386e-02f, 7.32119009e-02f, -8.34617615e-02f, 1.73683222e-02f, 6.50311634e-02f, 1.34537159e-03f, 4.50296067e-02f, 2.25867257e-02f,
  2.47263480e-02f, -1.66440427e-01f, 1.87629811e-03f, -3.61303985e-02f, -1.02291629e-01f, -2.35111285e-02f, -3.50340561e-04f, -8.09079111e-02f, -9.87478271e-02f, -1.32250860e-01f,
  -3.67752872e-02f, -4.91810702e-02f, 2.83079455e-03f, -3.50759551e-02f, -3.94611470e-02f, 6.05860818e-03f, 6.03917837e-02f, 8.85170102e-02f, 4.75348420e-02f, -1.13704406e-01f,
  6.98372349e-02f, -4.41824980e-02f, 5.75896725e-02f, -3.85148637e-02f, 2.88851783e-02f, -1.32013792e-02f, -6.17685867e-03f, -1.30918585e-02f, 4.74248920e-03f, -5.59832044e-02f,
  -9.62820090e-03f, 1.16920806e-01f, -7.66437203e-02f, -5.70803136e-02f, -1.44399792e-01f, -6.99306577e-02f, -9.26483572e-02f, -2.20141392e-02f, 1.69946805e-01f, 1.21731766e-01f,
  -2.14577705e-01f, 3.00396115e-01f, -1.93350855e-02f, -1.64695889e-01f, 1.76937208e-01f, 1.93229795e-01f, 3.65709253e-02f, -1.09311445e-02f, 2.29045134e-02f, -9.87837538e-02f,
  -7.13826045e-02f, -1.71767756e-01f, -2.50452995e-01f, -1.83699116e-01f, -3.41140330e-01f, -4.30671796e-02f, -1.07697360e-01f, -1.49060175e-01f, -1.25441283e-01f, -7.99208060e-02f,
  -3.73060890e-02f, 3.44566070e-02f, -1.40507445e-01f, 6.74197217e-03f, -4.20808829e-02f, -5.31801172e-02f, 3.03316712e-02f, 3.31812538e-02f, 4.28265780e-02f, 2.61808317e-02f,
  6.71709552e-02f, -1.39218774e-02f, 9.80114192e-02f, -4.50733490e-02f, -5.49002886e-02f, 2.87269964e-03f, 3.95210907e-02f, -8.19245130e-02f, 3.45431045e-02f, -3.77078690e-02f,
  -3.33037302e-02f, 2.18714215e-02f, -6.09948225e-02f, -7.28007359e-03f, 5.72950281e-02f, -1.04594417e-01f, 1.32845407e-02f, -1.12791017e-01f, -4.59294952e-02f, 1.14841685e-01f,
  -6.77126125e-02f, 2.37439908e-02f, 3.46372835e-02f, -4.72637452e-02f, -5.35895862e-02f, -5.87641783e-02f, 5.65575473e-02f, -7.35333934e-02f, -3.38435508e-02f, -1.20882139e-01f,
  1.84140168e-02f, -8.06896314e-02f, -1.01800531e-01f, 1.72504392e-02f, 4.67859209e-02f, 4.02433611e-02f, -3.81325446e-02f, -3.70380059e-02f, 3.99008356e-02f, 1.41640417e-02f,
  -2.45150905e-02f, 5.70376329e-02f, 1.69391967e-02f, -1.99595429e-02f, 5.75161427e-02f, -5.92504181e-02f, -4.13605794e-02f, 5.82869910e-02f, -4.23606411e-02f, -6.20946065e-02f,
  -7.84563739e-03f, 1.61300823e-01f, 6.19620830e-02f, 5.88692799e-02f, -5.78517541e-02f, 3.50688547e-02f, 2.93054525e-02f, -5.78830056e-02f, 1.22829646e-01f, -5.36899194e-02f,
  3.84506918e-02f, 4.55114581e-02f, 7.91274756e-03f, -8.18443075e-02f, 1.14591435e-01f, 3.25751863e-02f, 4.80606146e-02f, 7.52511770e-02f, 7.32422844e-02f, -9.87575501e-02f,
  -2.67886799e-02f, 1.00041389e-01f, 7.97945037e-02f, -5.07834069e-02f, -5.49759381e-02f, 1.94397406e-04f, 1.39969379e-01f, 1.62413791e-02f, 4.73851785e-02f, 7.57019743e-02f,
  3.84204686e-01f, 8.13035294e-02f, 1.97628006e-01f, 2.19447941e-01f, -4.18829620e-02f, 1.62936360e-01f, 1.21630594e-01f, 8.09502676e-02f, 3.32410246e-01f, 3.08779906e-02f,
  -1.74482226e-01f, 2.28795394e-01f, -1.33014217e-01f, 2.41706371e-02f, -1.65878713e-01f, -9.61085185e-02f, 5.60347550e-02f, -4.32130992e-02f, 5.00040594e-03f, 8.67365822e-02f,
  3.64983678e-02f, -1.80302992e-01f, 8.48234165e-03f, -1.19653091e-01f, 9.86345932e-02f, 9.77635235e-02f, -2.80684739e-01f, -1.10097595e-01f, -9.31058899e-02f, -9.32028219e-02f,
  5.42811714e-02f, -1.53198773e-02f, -2.82598194e-02f, 1.24150384e-02f, -1.58310682e-03f, 4.90929186e-03f, 6.69638738e-02f, -4.82251681e-02f, 2.46109832e-02f, 6.02992624e-02f,
  5.80818430e-02f, -5.78389084e-03f, 8.28323439e-02f, 1.06175868e-02f, 7.98813403e-02f, 2.24842746e-02f, 4.81003523e-02f, 3.28634158e-02f, 1.16800547e-01f, -1.27440793e-02f,
  1.37898922e-01f, 9.94610135e-04f, 9.16494727e-02f, 6.70212954e-02f, -3.59138809e-02f, -8.29195697e-03f, 8.48934501e-02f, 1.93514731e-02f, -1.33543704e-02f, -1.16581535e-02f,
  -9.10278782e-02f, -7.64301643e-02f, -2.21419963e-04f, 8.03669319e-02f, 1.13545246e-01f, -5.25647402e-02f, 1.13827381e-02f, -4.00446393e-02f, 7.95506313e-02f, -5.05480729e-02f,
  8.77932236e-02f, -3.35602090e-02f, -1.93783324e-02f, 9.64499339e-02f, -1.73567347e-02f, 9.94241238e-02f, 1.02371812e-01f, -4.12043445e-02f, 2.19286841e-04f, -3.95703092e-02f,
  -3.49334255e-02f, -1.06860094e-01f, 2.13097688e-02f, 2.36761626e-02f, 1.03677034e-01f, 1.17292739e-02f, 5.16007356e-02f, 1.68106124e-01f, 8.45240708e-03f, -1.49856046e-01f,
  -1.37278751e-01f, -8.84949639e-02f, -1.48114590e-02f, -4.64444095e-03f, 1.35663226e-02f, -2.88557331e-03f, -4.61149663e-02f, 1.01110088e-02f, 4.19341177e-02f, 2.51219346e-04f,
  -6.84981048e-02f, 2.83464836e-03f, 4.69606817e-02f, 9.16794781e-03f, -1.86886487e-03f, -9.61477403e-03f, 8.39523077e-02f, -7.12873116e-02f, -5.04545867e-02f, -1.13785073e-01f,
  -3.63043956e-02f, 5.37316315e-02f, 3.66794541e-02f, -7.38167688e-02f, 5.42305363e-03f, -1.13184839e-01f, -2.75222808e-02f, -4.79209647e-02f, 7.66228810e-02f, -1.48467720e-02f,
  1.30511299e-01f, 3.56006086e-01f, 1.13882117e-01f, 3.74107584e-02f, -7.81478062e-02f, 2.82226130e-02f, 5.63290417e-02f, 8.50933045e-02f, 5.76287620e-02f, 1.00797661e-01f,
  -1.50142983e-01f, 3.06209385e-01f, -9.31392461e-02f, 1.51606500e-01f, -2.34546557e-01f, -9.42462236e-02f, -1.84219316e-01f, -7.15876669e-02f, 2.98855063e-02f, -3.59390751e-02f,
  -5.97637817e-02f, -1.98264956e-01f, -3.09854820e-02f, -4.32049856e-02f, 4.42788973e-02f, 1.15282282e-01f, -2.17047736e-01f, -1.01942830e-02f, 1.23769036e-02f, 8.38301554e-02f,
  1.14736862e-01f, 9.62609649e-02f, 1.11758158e-01f, 7.98153058e-02f, 1.05817327e-02f, -1.10961460e-01f, 5.03302664e-02f, 4.48517650e-02f, -5.14485538e-02f, 4.32310672e-03f,
  3.72224450e-02f, -5.27573042e-02f, 4.74654287e-02f, -8.73607993e-02f, -1.08386308e-01f, 9.83544216e-02f, -2.56786719e-02f, 1.13328965e-02f, 1.73262805e-01f, 4.64965403e-02f,
  2.78770495e-02f, -1.55063830e-02f, -1.76162608e-02f, 2.27905381e-02f, 7.46462271e-02f, 8.08542967e-02f, 1.29410774e-01f, 7.73538835e-04f, 3.41644511e-02f, -4.44147140e-02f,
  -1.05875850e-01f, -9.40370262e-02f, -8.07974115e-03f, -4.00523469e-02f, 7.17703924e-02f, 3.56750824e-02f, 6.91770688e-02f, -8.16944521e-04f, -9.41537768e-02f, 4.18373831e-02f,
  4.30111997e-02f, 1.17388251e-03f, -5.86097501e-02f, -1.12142339e-01f, -1.98030584e-02f, -3.02853454e-02f, -2.68547833e-02f, -1.05591424e-01f, -4.22320142e-02f, 3.80563289e-02f,
  -5.42521663e-02f, -1.13763744e-02f, -8.18923041e-02f, -7.91445449e-02f, 7.39876404e-02f, 2.29225103e-02f, 7.88063854e-02f, 4.27398235e-02f, 1.39306355e-02f, -7.65532209e-03f,
  2.90175974e-02f, -1.61012664e-01f, 1.46862671e-01f, 9.95898992e-02f, 3.48649570e-03f, -6.07043244e-02f, -3.52475345e-02f, 1.15099479e-03f, -2.69441660e-02f, -4.42777276e-02f,
  -9.86065790e-02f, -5.55232018e-02f, 3.58971730e-02f, -8.26895609e-02f, -5.67170642e-02f, -7.00425729e-02f, 5.32825105e-02f, 9.85924527e-03f, -9.58417729e-02f, -1.01663396e-01f,
  -1.90691035e-02f, 7.12393597e-02f, -9.98758245e-03f, 4.64047901e-02f, -1.63995817e-01f, -1.06577002e-01f, 3.75113524e-02f, 3.59645337e-02f, -7.49303699e-02f, -1.21010251e-01f,
  -4.49806862e-02f, -4.44745496e-02f, -6.63991943e-02f, -1.91780999e-01f, -8.74602422e-02f, -1.64619058e-01f, -2.25928262e-01f, -1.10326588e-01f, 1.22971021e-01f, -5.50246239e-02f,
  -1.41645595e-01f, 1.09066013e-02f, 5.17020412e-02f, -1.37076601e-01f, 2.69446164e-01f, 2.48519570e-01f, -2.12322652e-01f, -1.41570106e-01f, 8.18407312e-02f, -2.32076421e-01f,
  -3.23323980e-02f, -1.95474625e-01f, 6.59185648e-02f, -1.69234663e-01f, -2.56644130e-01f, -9.79454294e-02f, 1.92233305e-02f, -2.33727410e-01f, -5.01349382e-02f, -9.13045555e-02f,
  2.02379245e-02f, -7.78750284e-03f, 8.06532726e-02f, 6.11833073e-02f, -3.31391878e-02f, -3.89991924e-02f, -1.08608343e-01f, 8.18953738e-02f, 3.69252264e-02f, -7.09787011e-03f,
  -5.65516502e-02f, 4.39667553e-02f, 6.09525591e-02f, -3.62682454e-02f, -3.27786468e-02f, -3.69035155e-02f, -2.07028445e-02f, -4.33357479e-03f, 9.87649336e-03f, -3.98474932e-02f,
  -2.54224725e-02f, -1.75351221e-02f, -8.96504298e-02f, 5.25564142e-02f, -3.12223029e-03f, -1.17206061e-02f, 9.84661877e-02f, 1.03784882e-01f, 7.24494681e-02f, -5.65038100e-02f,
  3.66135277e-02f, -4.32941318e-03f, 6.43365979e-02f, -3.32487449e-02f, -9.14412364e-02f, -8.05409402e-02f, -5.86835258e-02f, -2.55679712e-02f, 4.64059971e-02f, -9.27171577e-03f,
  6.06135800e-02f, 1.07065998e-01f, -4.98563945e-02f, -4.01922576e-02f, -7.52189234e-02f, -5.98332621e-02f, 8.97066742e-02f, 3.80825773e-02f, -4.76260968e-02f, 4.59132716e-03f,
  2.79416814e-02f, 3.73426341e-02f, 9.44155268e-03f, 6.53973669e-02f, -2.05882937e-02f, -1.95790902e-02f, -3.38312611e-02f, 3.39388452e-03f, 6.82862550e-02f, -3.68305668e-02f,
  -3.03241294e-02f, 6.99368641e-02f, 1.69662479e-03f, -2.34428272e-02f, 6.14502206e-02f, 6.26198053e-02f, 2.47335602e-02f, 3.61085236e-02f, 7.03227669e-02f, -4.44705524e-02f,
  -7.04849511e-02f, 1.29914773e-03f, 2.41540466e-02f, -1.32368980e-02f, 7.88894389e-03f, -1.42769674e-02f, -9.92436986e-03f, 9.81677324e-02f, 2.86654551e-02f, 5.77249750e-02f,
  -2.19088998e-02f, 4.35110852e-02f, 1.25340503e-02f, 4.50512068e-03f, 9.22365487e-02f, -7.87191913e-02f, -4.82679531e-03f, 1.35726601e-01f, 4.93107969e-03f, 1.04374494e-02f,
  -1.10224687e-01f, 1.38304010e-01f, 1.42295295e-02f, -5.83046190e-02f, 2.00557798e-01f, -1.24442033e-01f, -1.36454359e-01f, 1.26415431e-01f, -1.97805185e-02f, 1.19806536e-01f,
  -1.09144291e-02f, 1.76409811e-01f, 4.03079949e-02f, -4.68922369e-02f, -4.34776276e-01f, -1.87443674e-01f, -2.18688086e-01f, -1.27476424e-01f, -7.88730532e-02f, 8.13975930e-02f,
  -2.52099037e-01f, -1.01841725e-01f, -1.90023988e-01f, -1.22545557e-02f, 9.44020748e-02f, 1.12678677e-01f, -2.63720173e-02f, 5.75901195e-02f, 7.75078088e-02f, -1.13279134e-01f,
  -2.22432949e-02f, 1.08913831e-01f, 1.04728110e-01f, 2.48475373e-02f, -5.48501797e-02f, 3.37043777e-02f, 3.49045359e-02f, 9.43689723e-04f, -1.17607079e-01f, -1.42445052e-02f,
  -8.92150868e-03f, -1.78882003e-01f, 1.13411155e-02f, -4.92253825e-02f, -4.22243997e-02f, -8.09266865e-02f, 3.51858251e-02f, 1.29043683e-01f, -1.68167837e-02f, 2.28475357e-04f,
  2.03980543e-02f, -5.29280864e-03f, 7.51028508e-02f, -1.48303986e-01f, 2.12322101e-02f, -1.87167786e-02f, -2.51074601e-02f, -2.86563090e-03f, -4.41328511e-02f, -7.22133815e-02f,
  -4.93510477e-02f, 6.60971925e-02f, 2.60739699e-02f, 1.94443651e-02f, 9.74241495e-02f, -7.09623005e-03f, -7.18188379e-03f, -1.85538530e-02f, -2.13780385e-02f, -3.24592069e-02f,
  -1.13521637e-02f, 9.14603025e-02f, 1.39270080e-02f, 1.07305283e-02f, -1.23733245e-02f, 7.42939338e-02f, 1.57858301e-02f, 3.88907231e-02f, -5.20703122e-02f, 5.71749918e-02f,
  1.10938847e-01f, 2.98116673e-02f, 4.35067415e-02f, 2.62360983e-02f, -4.66931462e-02f, -5.67868352e-02f, -3.67582147e-03f, -1.37985311e-02f, -6.81912154e-02f, -4.19836529e-02f,
  4.09171358e-02f, 5.06450608e-03f, 1.23004608e-01f, -1.23596741e-02f, -3.91356386e-02f, 7.17022121e-02f, 4.69074734e-02f, -3.79728451e-02f, 1.41456621e-02f, 4.32233401e-02f,
  1.31585270e-01f, 7.60507304e-03f, 1.04542203e-01f, 6.94312796e-04f, -8.89989808e-02f, 1.70960613e-02f, 3.79682481e-02f, -1.67520866e-02f, -5.46753779e-03f, -5.94448298e-03f,
  3.54921371e-02f, 6.24113977e-02f, -4.30066586e-02f, -4.34082496e-04f, -1.30952289e-02f, -2.02186517e-02f, 5.68286180e-02f, -4.02804054e-02f, 3.79532538e-02f, -1.18461818e-01f,
  1.14506379e-01f, 2.43589804e-01f, 2.01008841e-01f, 1.36197135e-01f, -1.88696817e-01f, -2.02737272e-01f, 2.87811924e-03f, -9.20315012e-02f, 7.43864775e-02f, 1.26324967e-01f,
  -9.97507945e-02f, 1.92404702e-01f, -1.02071464e-01f, 1.14349499e-01f, -2.43600905e-02f, -1.45836756e-01f, 5.53455949e-02f, 3.59394625e-02f, 4.04188819e-02f, 1.10665262e-01f,
  -2.43585389e-02f, -2.34888256e-01f, 3.14899050e-02f, -1.45776182e-01f, 1.46517470e-01f, 2.24749506e-01f, -2.45924620e-03f, -7.99003392e-02f, 1.88766643e-01f, -6.49698302e-02f,
  -2.75804847e-02f, 1.46378356e-03f, 1.17183477e-01f, 4.90111895e-02f, -2.74698623e-02f, -6.69031579e-04f, 5.47537655e-02f, -3.54293957e-02f, -1.94134433e-02f, -3.68148163e-02f,
  6.44644424e-02f, -8.90784338e-02f, 7.07582310e-02f, -9.92885698e-03f, -4.01127487e-02f, 1.00335963e-01f, 1.11979596e-01f, 1.04206696e-01f, -1.83218196e-02f, 5.79312369e-02f,
  9.67580155e-02f, 1.81297958e-02f, 5.60581200e-02f, 7.92520195e-02f, 1.33825198e-01f, 6.97309896e-03f, 4.73998580e-03f, 1.26256466e-01f, 9.17857140e-02f, 1.84637625e-02f,
  -2.02717073e-02f, -6.55641546e-03f, 1.91791065e-03f, -5.46030365e-02f, 4.94386889e-02f, 4.47796360e-02f, -1.68780740e-02f, 1.98854245e-02f, 7.67452419e-02f, -6.80766776e-02f,
  -1.38535956e-02f, 3.33239362e-02f, -1.58887729e-02f, 3.11030261e-02f, 2.93346662e-02f, 6.99032322e-02f, -6.51142420e-03f, -3.25755924e-02f, 5.14092445e-02f, 7.14285113e-03f,
  -7.71494731e-02f, 2.76907310e-02f, -7.74816936e-03f, -4.07410190e-02f, -9.91926342e-02f, -7.77521431e-02f, -1.11841457e-02f, -4.41307276e-02f, 1.18166553e-02f, -4.14514504e-02f,
  7.98748434e-02f, 1.33371800e-01f, 1.03509903e-01f, 2.28924137e-02f, -4.15387899e-02f, 4.45615798e-02f, -2.00583902e-03f, 1.03454880e-01f, 1.15654632e-01f, 2.24936707e-03f,
  -5.47533780e-02f, 6.70985272e-03f, 8.06619599e-03f, -7.73198158e-02f, 3.75511684e-02f, 1.40683008e-02f, 2.36092848e-04f, 2.53245644e-02f, 2.12696753e-02f, -2.64278278e-02f,
  -5.36496341e-02f, 1.09211253e-02f, 5.68984486e-02f, -5.37564978e-03f, 7.12185949e-02f, 1.01178803e-01f, 6.94001326e-03f, 1.49404481e-01f, -5.54601252e-02f, 4.10620756e-02f,
  3.39308567e-02f, -3.31677586e-01f, -2.92454034e-01f, 8.22230801e-02f, 2.59931892e-01f, 1.08038500e-01f, 6.81406036e-02f, 1.79904342e-01f, -5.82642183e-02f, -1.86366513e-02f,
  -5.77708147e-02f, -1.04776517e-01f, -3.29657257e-01f, 1.48770168e-01f, 1.49576560e-01f, -2.28706971e-01f, 1.21606804e-01f, -5.66665344e-02f, -9.69298035e-02f, -6.61654919e-02f,
  1.60440132e-01f, 2.29311287e-01f, -1.21132672e-01f, 8.83544683e-02f, 3.52867916e-02f, 4.38534934e-03f, 8.80858526e-02f, -1.76971689e-01f, 1.83761328e-01f, 1.24652512e-01f,
  1.12679429e-01f, -5.89355193e-02f, 9.24162045e-02f, 2.87055061e-03f, -5.74133098e-02f, 3.95959318e-02f, -1.07737007e-02f, -8.59435946e-02f, 4.94623855e-02f, -6.04194589e-02f,
  1.91149209e-03f, 2.28961650e-02f, 1.02202997e-01f, 2.36921781e-03f, 9.04204175e-02f, 2.69692447e-02f, 2.02969369e-02f, -2.66093817e-02f, -2.88003087e-02f, -1.45154387e-01f,
  -1.09755002e-01f, 6.30560517e-02f, -2.62356456e-02f, -6.26056120e-02f, -8.84360168e-03f, 3.12518468e-03f, 1.41004473e-02f, -1.11546956e-01f, -1.66179147e-03f, 5.63822538e-02f,
  -3.05185448e-02f, 2.32475605e-02f, -8.39613304e-02f, 2.88663362e-03f, -1.23843446e-01f, -5.98292658e-03f, 1.28887668e-01f, -9.56488959e-03f, -6.20296933e-02f, -5.75774610e-02f,
  -4.21707472e-03f, -8.04533213e-02f, -4.20814902e-02f, 1.21711688e-02f, 7.51502812e-02f, 9.30729061e-02f, 7.10371062e-02f, 4.13750112e-02f, -6.50870726e-02f, -2.14118473e-02f,
  -3.75765227e-02f, -6.34072497e-02f, -4.20511067e-02f, 3.50213656e-03f, -4.12287638e-02f, -1.09046146e-01f, 1.69881154e-02f, -8.23474955e-03f, 3.57861407e-02f, 1.04304831e-02f,
  -4.11180407e-02f, -1.75794467e-01f, 3.94775160e-03f, 6.22286648e-02f, -7.26905689e-02f, -3.31546627e-02f, -5.91625832e-02f, -2.33103335e-02f, -6.08175993e-02f, -6.70064837e-02f,
  1.05764374e-01f, 9.76628810e-02f, 7.09805116e-02f, -1.10162839e-01f, 7.81247765e-02f, -1.64897125e-02f, 2.51712166e-02f, -5.76286726e-02f, 1.59403294e-01f, 4.57841046e-02f,
  -9.65454727e-02f, -1.23569474e-03f, 3.48619074e-02f, 4.03061211e-02f, 1.10090002e-01f, -3.47223654e-02f, 8.21904838e-02f, -7.76925609e-02f, -9.43284016e-03f, 4.86277528e-02f,
  1.34285212e-01f, -3.36608380e-01f, -8.55092600e-04f, 1.65037125e-01f, 3.74431815e-03f, -1.93055943e-01f, -2.77593434e-01f, 1.20836720e-01f, 1.46824038e-02f, -2.30691299e-01f,
  2.87523288e-02f, -2.00862177e-02f, -2.21837446e-01f, 5.28558530e-02f, 2.55974442e-01f, -2.05231532e-01f, 1.76755041e-01f, 5.17780334e-03f, 7.99504071e-02f, 3.77842076e-02f,
  2.13798061e-01f, 1.37217075e-01f, 2.42001712e-01f, 1.86783180e-01f, 5.04720584e-02f, 1.72028884e-01f, 1.31964922e-01f, 2.31031813e-02f, 2.57773280e-01f, 1.56049177e-01f,
  -3.19439769e-02f, 5.88808283e-02f, -3.17418315e-02f, -1.78357735e-02f, -5.31770959e-02f, -5.16167283e-02f, -9.55883507e-03f, 7.64911324e-02f, 1.33608222e-01f, 1.50342053e-02f,
  -7.74205029e-02f, 4.62447777e-02f, 5.57924993e-02f, -3.29561420e-02f, 7.27249542e-03f, 4.16775271e-02f, 2.30661277e-02f, -2.42266133e-02f, 1.35364160e-02f, -2.77129225e-02f,
  -1.59607939e-02f, 5.13603771e-03f, 2.15934440e-02f, -1.23466160e-02f, 5.02759889e-02f, 1.29173905e-01f, -7.64985755e-03f, 2.70903911e-02f, -4.49010218e-03f, -2.28535347e-02f,
  -1.16628576e-02f, -8.23513493e-02f, -2.56177355e-02f, 1.81309152e-02f, 1.45592904e-02f, -5.29268384e-02f, -2.40968540e-02f, -1.11699374e-02f, -6.49767518e-02f, -4.52580415e-02f,
  -3.37373167e-02f, 1.32533625e-01f, 9.64496110e-04f, -1.16097286e-01f, 6.11285353e-03f, -5.05546331e-02f, 6.11100288e-04f, 4.65440750e-02f, 2.65034591e-03f, -4.49904054e-02f,
  -1.52796973e-02f, 4.89530638e-02f, -2.27044113e-02f, -2.03817198e-03f, -4.28304151e-02f, -9.82310623e-03f, -4.12903391e-02f, 4.27768892e-03f, 3.22915092e-02f, -1.97123494e-02f,
  -9.61162969e-02f, -1.02209292e-01f, -9.10455082e-03f, 5.70236631e-02f, -5.32717891e-02f, -1.13761023e-01f, 6.27408177e-02f, 6.08099177e-02f, 5.51126637e-02f, 1.57326944e-02f,
  -2.92401351e-02f, 1.05279058e-01f, -1.64701678e-02f, 1.44868627e-01f, 7.88029805e-02f, -1.03588281e-02f, 6.59890249e-02f, 1.42526794e-02f, 1.06257290e-01f, 2.67958082e-02f,
  5.06079979e-02f, -5.42122535e-02f, 8.37555528e-02f, 4.73630652e-02f, -5.18512577e-02f, -6.32565692e-02f, -5.47994114e-02f, -8.38083476e-02f, -8.39543063e-03f, 5.93476444e-02f,
  -8.72063711e-02f, 1.60981700e-01f, 1.90273181e-01f, -7.36608207e-02f, -6.37971684e-02f, -1.53150946e-01f, -1.41040489e-01f, 2.99503678e-03f, -2.09523529e-01f, 1.78408891e-01f,
  -8.31959397e-02f, 1.67148739e-01f, -3.95161584e-02f, -1.20515592e-01f, -3.31744999e-01f, -1.51815727e-01f, -2.84174792e-02f, -6.68618754e-02f, -1.95735157e-01f, 2.06773892e-01f,
  8.08752179e-02f, -2.08265215e-01f, 7.69443065e-02f, 1.47572840e-02f, 5.14222309e-02f, 2.42572188e-01f, 8.11031312e-02f, 7.72378594e-02f, 1.83486432e-01f, -1.00283578e-01f,
  4.34034200e-06f, 6.22888580e-02f, 9.98546705e-02f, 5.97507060e-02f, 1.23038992e-01f, 1.11341931e-01f, 4.13384624e-02f, -8.51584151e-02f, 1.50912656e-02f, 1.05120456e-02f,
  4.34637368e-02f, -9.36162844e-02f, -1.37677714e-01f, -1.09598398e-01f, -4.14645113e-02f, 1.22276820e-01f, 8.06799009e-02f, 4.64821747e-03f, 1.24815419e-01f, 5.42533994e-02f,
  1.81184426e-01f, 5.83724119e-03f, 4.61826362e-02f, 5.53107746e-02f, 5.86637519e-02f, -2.32467148e-02f, -1.87370367e-02f, 1.21845849e-01f, 5.04326709e-02f, -1.21608116e-02f,
  2.39490811e-02f, 5.05479313e-02f, -4.22610976e-02f, 7.37164617e-02f, 2.15728804e-02f, 8.56470491e-04f, 6.29266798e-02f, -1.12235148e-05f, 6.93841428e-02f, 1.67703368e-02f,
  1.11313025e-02f, 2.99866274e-02f, -9.86981094e-02f, 1.89682376e-02f, -4.03205417e-02f, -5.00604184e-03f, -5.78553975e-02f, 8.94650817e-02f, -6.02620728e-02f, 2.00850610e-02f,
  -2.39969287e-02f, -7.16076121e-02f, 5.60178682e-02f, -6.98829889e-02f, -1.44364893e-01f, -5.97947091e-02f, 4.69361879e-02f, 2.96750013e-02f, 2.51434483e-02f, 1.92054939e-02f,
  5.72327450e-02f, 1.87848017e-01f, 1.84724771e-03f, -7.21551618e-03f, 9.85961221e-03f, 1.90709941e-02f, -2.91830990e-02f, 2.43333783e-02f, -4.63255867e-02f, 1.76813512e-04f,
  1.07336126e-01f, 4.15763594e-02f, 4.76323292e-02f, 1.76117644e-02f, -6.86354563e-02f, -4.15183865e-02f, -3.05994507e-02f, -4.04442549e-02f, 6.66337609e-02f, 1.14263408e-02f,
  8.78282636e-02f, 1.84373127e-03f, -3.09629645e-02f, -7.03563690e-02f, 2.74683777e-02f, -3.79720256e-02f, 2.25947443e-02f, 6.08254783e-03f, 6.45236149e-02f, -1.22222314e-02f,
  -6.26090288e-01f, 4.13088351e-01f, -1.22442663e-01f, -1.33764714e-01f, 6.06684713e-03f, -7.13836476e-02f, -1.96002409e-01f, 8.91992152e-02f, -7.63003230e-02f, -8.36545900e-02f,
  -1.01908520e-01f, -8.61474052e-02f, -2.61700433e-02f, 4.22959439e-02f, -4.08009142e-02f, 2.30871752e-01f, -7.02058002e-02f, -2.05223963e-01f, 8.37097988e-02f, -6.37639761e-02f,
  1.86674781e-02f, -5.85802719e-02f, -1.60027426e-02f, 2.05362469e-01f, -1.62804320e-01f, -4.57784235e-02f, -1.77189544e-01f, 2.25003138e-02f, -1.59388587e-01f, 4.41959947e-02f,
  -2.86712885e-01f, -2.96521366e-01f, -1.47854909e-01f, -1.52857020e-01f, -1.11527212e-01f, -1.13400981e-01f, -1.41885221e-01f, -8.65643173e-02f, -8.03052112e-02f, -7.60718854e-03f,
  -2.57305074e-02f, 7.08954856e-02f, -6.88585564e-02f, 1.29971713e-01f, -2.83251796e-02f, -4.58825305e-02f, 1.30849645e-01f, -5.67246601e-02f, 3.46551202e-02f, 1.29677057e-01f,
  5.00013344e-02f, -6.03601746e-02f, -6.55785128e-02f, -2.74033099e-02f, 8.81809145e-02f, -2.83604544e-02f, -2.67478935e-02f, -6.63167015e-02f, -9.79162827e-02f, -7.74281193e-03f,
  -5.10457112e-03f, 7.88377970e-02f, 3.78891528e-02f, 9.30828676e-02f, 2.61982367e-03f, 5.20280041e-02f, 1.10264886e-02f, -4.22554016e-02f, -1.67850703e-02f, 2.28749048e-02f,
  1.88772362e-02f, -4.94842120e-02f, 3.88917513e-02f, -3.20002213e-02f, 6.21217024e-03f, -3.25593874e-02f, 5.70145901e-04f, -5.90415075e-02f, 8.91161859e-02f, -1.30139552e-02f,
  -2.96532996e-02f, -5.89079484e-02f, -2.80558709e-02f, -8.53580311e-02f, 4.17154618e-02f, 2.24046167e-02f, -6.31455481e-02f, 7.00650513e-02f, -3.34972069e-02f, -6.67560399e-02f,
  -2.33169183e-01f, -3.16496819e-01f, -9.29711759e-02f, -1.00546375e-01f, 6.46423772e-02f, -4.33692709e-02f, 1.04143168e-03f, 8.33670981e-03f, -6.73813075e-02f, 1.39624262e-02f,
  -7.68981799e-02f, 4.27498110e-02f, -4.61841673e-02f, -4.89485543e-03f, 1.17836138e-02f, 2.44322624e-02f, -6.39025420e-02f, 1.41763482e-02f, -1.34777501e-02f, 4.76480555e-03f,
  4.96422220e-03f, -2.80817617e-02f, -6.38186187e-02f, -1.19393012e-02f, -3.85437869e-02f, -9.26038399e-02f, -1.16298245e-02f, -1.07804323e-02f, -7.41274934e-03f, 3.25904042e-03f,
  3.34135033e-02f, 1.01297759e-01f, 2.04620361e-01f, 4.83628958e-02f, -1.77138865e-01f, -6.76772371e-02f, -8.66476595e-02f, -3.33681256e-02f, 1.34246528e-01f, 1.20635867e-01f,
  3.04874964e-02f, 3.01128477e-01f, -3.77713852e-02f, 1.30668566e-01f, -1.82257563e-01f, -9.08171162e-02f, -2.06432968e-01f, -3.97870280e-02f, 1.56110423e-02f, -1.18362987e-02f,
  -1.75894693e-01f, -1.09149314e-01f, -1.30654827e-01f, 2.13447008e-02f, 6.75387383e-02f, 1.01949297e-01f, -2.05441117e-01f, -5.47705628e-02f, 8.59579518e-02f, -3.15176882e-02f,
  -1.22206233e-01f, 1.74929187e-01f, 3.99510041e-02f, 1.24673076e-01f, 4.18499857e-02f, -3.37697789e-02f, -8.56386572e-02f, -5.51306456e-02f, 5.90267554e-02f, 5.96625246e-02f,
  6.99082911e-02f, -1.55219166e-02f, 9.44451988e-02f, -3.76135446e-02f, 5.86727262e-03f, 6.41477853e-02f, -6.93461373e-02f, -8.56901556e-02f, 1.03615068e-01f, 8.43393579e-02f,
  8.25905353e-02f, 2.34784465e-02f, -5.40139787e-02f, 8.09826925e-02f, -5.92214204e-02f, 1.98925026e-02f, -1.25953797e-02f, -1.35990202e-01f, -1.31502552e-02f, -1.32632898e-02f,
  1.80954710e-02f, -5.59970327e-02f, -5.72747663e-02f, 8.90324414e-02f, -3.94095406e-02f, 7.37161040e-02f, -2.40624733e-02f, 4.27927561e-02f, -6.37566820e-02f, -6.08730167e-02f,
  -1.17900550e-01f, -5.08191576e-03f, -2.67042257e-02f, -3.58413719e-02f, 1.02032861e-02f, 3.03997211e-02f, 2.61573102e-02f, 6.08311072e-02f, -2.38937736e-02f, -2.96542272e-02f,
  5.50816581e-02f, -2.74850745e-02f, -2.79079210e-02f, -1.01428270e-01f, 5.35876432e-04f, -3.61386351e-02f, 1.30993510e-02f, 6.85202256e-02f, 1.39872096e-02f, -6.35386631e-02f,
  -2.98189372e-01f, -2.24304590e-02f, -9.07822922e-02f, 3.78347747e-03f, -6.15622513e-02f, -1.19738534e-01f, -3.69993933e-02f, 7.58701414e-02f, -1.36991039e-01f, 2.57840008e-02f,
  5.28058559e-02f, -3.38593349e-02f, -2.09876057e-02f, -7.87012354e-02f, 1.35952495e-02f, 7.42447600e-02f, -3.58760990e-02f, 4.34593037e-02f, -3.21397036e-02f, -9.68208537e-02f,
  -3.79332565e-02f, 6.15577474e-02f, 2.28600856e-02f, 6.68206513e-02f, -1.60438672e-01f, 2.27515819e-03f, 4.69381064e-02f, 5.53502291e-02f, -1.69209037e-02f, -1.44968200e-02f,
  2.27232888e-01f, -2.66054958e-01f, -2.04928532e-01f, 4.06776480e-02f, 7.45887086e-02f, -1.87201295e-02f, -1.43496394e-01f, -7.83946645e-03f, -1.58073485e-01f, -1.51004970e-01f,
  9.75007042e-02f, -2.42029615e-02f, -1.98091134e-01f, 2.84254789e-01f, 2.26616919e-01f, -1.25212222e-01f, 2.26132169e-01f, -3.36422957e-02f, -5.85445911e-02f, 2.35120598e-02f,
  1.27461374e-01f, 3.25663447e-01f, 3.67000164e-03f, 1.44662306e-01f, 1.26278490e-01f, 7.61867315e-02f, 2.81408764e-02f, -1.40497491e-01f, 1.39080286e-01f, 5.22266850e-02f,
  5.81584722e-02f, 2.77502872e-02f, -2.61688754e-02f, 7.56968856e-02f, 3.86205356e-04f, 5.31843938e-02f, -1.00980200e-01f, 6.69121444e-02f, -8.68713111e-02f, 9.42987055e-02f,
  -3.74171175e-02f, 1.75912455e-02f, 2.26445813e-02f, -4.67224121e-02f, 3.62860262e-02f, -3.64686698e-02f, -8.35128408e-03f, -1.22925729e-01f, -8.65482464e-02f, 1.52043700e-01f,
  -1.29046753e-01f, 1.10098009e-03f, -1.22452110e-01f, 4.26885951e-03f, -5.68051152e-02f, -6.25168963e-04f, -1.19069658e-01f, -1.26327493e-03f, -9.56339613e-02f, 5.01536801e-02f,
  9.30814072e-02f, -3.00570540e-02f, 2.69937329e-02f, -2.72632437e-03f, 6.36637583e-02f, 1.09752625e-01f, -4.03996669e-02f, 6.88124914e-03f, 1.31170852e-02f, 3.61349657e-02f,
  7.55794123e-02f, -4.08683792e-02f, -6.16701208e-02f, 2.08806135e-02f, 6.85374588e-02f, -7.56111592e-02f, -5.21439761e-02f, -6.47774758e-03f, -8.21604282e-02f, -8.40541720e-02f,
  -8.71656910e-02f, 8.48907158e-02f, -4.95087430e-02f, -6.94655403e-02f, 5.75835966e-02f, 7.43889362e-02f, 1.55587047e-01f, -1.13053210e-02f, -4.95843254e-02f, -9.22875926e-02f,
  6.79353848e-02f, -3.68119660e-03f, -1.94257833e-02f, -5.78559823e-02f, -8.03264305e-02f, 8.14219564e-02f, -1.02381326e-01f, 5.58249839e-02f, -4.15513618e-03f, -3.85183515e-03f,
  1.58813596e-01f, -7.15934560e-02f, 4.96167354e-02f, 3.26176621e-02f, -4.75550368e-02f, 7.82081634e-02f, -4.62749563e-02f, -2.22190320e-02f, -6.17743051e-03f, -3.52916978e-02f,
  -8.62385426e-03f, 1.14964144e-02f, -2.77457144e-02f, -7.80820400e-02f, 5.91761880e-02f, -4.65418324e-02f, 1.56466616e-03f, 7.15390360e-03f, -1.49190202e-02f, -1.34348407e-01f,
  1.77718192e-01f, 8.52076188e-02f, 1.74696654e-01f, 2.79107749e-01f, 2.27150396e-01f, 2.50714302e-01f, 1.49379119e-01f, 1.85409725e-01f, 3.99168611e-01f, -8.24220851e-02f,
  -7.03357207e-03f, -3.46052647e-02f, -1.49317548e-01f, 6.11090101e-02f, -6.81986511e-02f, 1.30398750e-01f, 1.35912657e-01f, 7.51203969e-02f, 1.57368645e-01f, 3.65406238e-02f,
  1.09789699e-01f, -1.18610375e-01f, -3.20844442e-01f, -1.82098120e-01f, -4.63507958e-02f, -1.30644850e-02f, -3.28052342e-01f, -1.24923900e-01f, -1.69708177e-01f, 6.03034534e-02f,
  1.08412104e-02f, 6.03241809e-02f, -1.25941575e-01f, 6.87936172e-02f, -9.38762724e-02f, -7.06540570e-02f, 1.13941589e-02f, -1.12183191e-01f, -6.04747683e-02f, 4.43725055e-03f,
  -5.56883626e-02f, 1.87784117e-02f, -6.84063789e-03f, -4.31863964e-02f, 9.86625329e-02f, -3.44847925e-02f, 2.38310527e-02f, 5.05465306e-02f, -8.88462886e-02f, -1.01247124e-01f,
  -1.04988240e-01f, -3.55067030e-02f, 4.31897156e-02f, -6.47712424e-02f, -6.36349395e-02f, 6.34508356e-02f, 4.32106704e-02f, 4.42163670e-04f, 1.02008367e-02f, 1.29502285e-02f,
  1.62824779e-03f, 1.25477135e-01f, 1.04054064e-02f, -9.71521437e-02f, -5.02275340e-02f, -6.08684868e-02f, -3.24422382e-02f, 4.02612276e-02f, 8.89339298e-02f, -3.99953164e-02f,
  2.11933237e-02f, 8.13712180e-03f, 3.51398140e-02f, -4.93135639e-02f, 4.34009172e-03f, 5.01428507e-02f, -2.98666395e-02f, 1.20263934e-01f, 3.77047807e-02f, -6.91228136e-02f,
  -6.32656273e-03f, -1.27117606e-02f, -4.43138927e-02f, -5.77840284e-02f, -8.71776342e-02f, 3.34058814e-02f, 3.84640321e-02f, 5.93847968e-02f, -4.45080027e-02f, -2.94603724e-02f,
  1.01514652e-01f, 1.49149150e-01f, 2.21625846e-02f, -1.24382256e-02f, -7.76917115e-02f, 3.24274600e-02f, 1.62087157e-02f, 1.56461503e-02f, -2.17844453e-02f, 1.02354642e-02f,
  4.18046378e-02f, 8.40071682e-03f, 6.63218573e-02f, -4.45400141e-02f, -6.63930029e-02f, 3.20507139e-02f, -3.51831876e-02f, 2.34521739e-02f, -4.03451547e-02f, 1.36063027e-03f,
  -5.75089492e-02f, 8.35192353e-02f, -5.96415363e-02f, -9.81768686e-03f, 2.37544086e-02f, -2.26815441e-03f, 5.54660847e-03f, -4.78849858e-02f, -4.87141088e-02f, -8.08431208e-02f,
  -3.73272419e-01f, 1.07615478e-01f, -2.36878052e-01f, -9.18987319e-02f, 6.60203099e-02f, -2.12760285e-01f, -3.05007976e-02f, -8.95453393e-02f, -8.48923549e-02f, 2.27796286e-01f,
  3.87025848e-02f, -3.06039840e-01f, 1.68473288e-01f, -2.32323542e-01f, -3.48913193e-01f, -8.80968422e-02f, -1.89337924e-01f, -1.38828978e-01f, -1.56927537e-02f, -1.41901508e-01f,
  -1.69846579e-01f, 3.98164336e-03f, -3.51404041e-01f, -4.46220934e-02f, -1.42081618e-01f, 7.02726170e-02f, 1.88717231e-01f, -6.04491942e-02f, -1.32824615e-01f, -1.84988365e-01f,
  -7.20774569e-03f, 2.60122065e-02f, 2.50017969e-03f, -1.60158187e-01f, -8.42403322e-02f, -7.90740848e-02f, 1.33038522e-03f, 6.45617768e-02f, -5.39424736e-03f, -1.25289381e-01f,
  4.01788065e-03f, -1.32274050e-02f, 3.30405659e-03f, -8.05278346e-02f, 7.08412975e-02f, -2.30254158e-02f, 7.61553273e-02f, -2.51499005e-02f, -1.46149416e-02f, -1.11335218e-01f,
  -2.22787000e-02f, 5.29547781e-02f, 1.00420360e-02f, -3.65869440e-02f, -1.27788424e-03f, -2.05166005e-02f, -3.90405543e-02f, -2.58095786e-02f, -1.15765547e-02f, 1.98303126e-02f,
  2.28399690e-02f, -3.37062404e-02f, -7.69958179e-03f, 7.31922174e-03f, 1.07108220e-01f, -3.12468410e-02f, 5.98563664e-02f, 6.12065718e-02f, -1.00736907e-02f, 6.00913949e-02f,
  2.43017655e-02f, -3.94432656e-02f, -2.16601267e-02f, -2.35992502e-02f, 3.02159563e-02f, -1.88693870e-02f, -2.57304814e-02f, 2.95026936e-02f, -2.49961745e-02f, -5.27009927e-02f,
  4.79261465e-02f, -4.72873449e-02f, -1.39895559e-03f, 7.30160028e-02f, 4.32171486e-02f, -6.78294003e-02f, -2.79316446e-03f, -1.62613783e-02f, 8.25278312e-02f, -1.99259538e-02f,
  -2.08066236e-02f, 1.09526560e-01f, 1.53571041e-02f, 6.97878525e-02f, -2.85262540e-02f, 2.01359745e-02f, 7.99647719e-03f, -9.63879451e-02f, 1.26835527e-02f, 4.97968644e-02f,
  -2.00953800e-02f, -3.55919078e-02f, -7.90900886e-02f, -1.72454063e-02f, -1.54271803e-03f, -1.34720942e-02f, 6.07049046e-03f, -9.43531319e-02f, 1.18961828e-02f, -5.55000529e-02f,
  3.67927272e-03f, 8.43367130e-02f, -4.05929312e-02f, 1.08329780e-01f, 2.93141790e-03f, -1.64026860e-02f, 2.71538552e-02f, 2.56611388e-02f, 7.55749270e-02f, 6.19812645e-02f,
  -3.03740799e-01f, -2.37661645e-01f, -2.23755136e-01f, 3.61678228e-02f, 8.86724740e-02f, 2.20961779e-01f, 1.83860898e-01f, -6.60119206e-02f, -1.72597811e-01f, 9.30604935e-02f,
  1.43780425e-01f, -5.84453437e-03f, -1.07071027e-01f, 2.03959003e-01f, 1.42975673e-01f, -2.15079933e-02f, 1.87506616e-01f, 1.04024030e-01f, -1.02101997e-01f, -1.18686095e-01f,
  -9.39701274e-02f, 1.63517967e-01f, 8.60670879e-02f, 4.92293462e-02f, 5.89335114e-02f, -4.16809916e-02f, 9.59542114e-03f, -6.39513582e-02f, 1.20871529e-01f, 1.99262351e-02f,
  3.62217911e-02f, -1.73538879e-01f, -7.49706700e-02f, -9.53381658e-02f, -1.55181279e-02f, -2.39617769e-02f, 4.35626432e-02f, 8.03299993e-03f, -1.60008147e-02f, -2.32907534e-02f,
  7.07743615e-02f, -7.48000145e-02f, 1.44142076e-01f, -3.43126394e-02f, -4.09119055e-02f, 3.46512571e-02f, 2.74333153e-02f, 3.45226983e-03f, -6.35740533e-02f, -4.33348343e-02f,
  -7.95145631e-02f, -4.83336672e-03f, 4.98393178e-02f, 8.00477061e-03f, -2.64561679e-02f, -3.44744511e-02f, 3.70372050e-02f, 7.54661635e-02f, 6.97504506e-02f, 4.34443168e-02f,
  1.99840851e-02f, -1.92064550e-02f, -8.93558040e-02f, -2.93617602e-02f, -3.71621028e-02f, -1.13905128e-02f, 4.04477715e-02f, 4.27976549e-02f, 2.89275087e-02f, -9.48856771e-02f,
  -6.45502657e-02f, 1.22616686e-01f, 2.48782244e-02f, 9.79536679e-03f, -2.58355346e-02f, 8.48522857e-02f, -1.59350149e-02f, 5.80281466e-02f, 5.24852090e-02f, 7.05284113e-03f,
  -9.84701365e-02f, -4.18100208e-02f, -4.41213548e-02f, 1.88968834e-02f, -4.19320464e-02f, 2.18189135e-03f, -4.81908862e-03f, 6.40079472e-03f, -4.62378524e-02f, -1.12391263e-02f,
  -5.92404343e-02f, -7.79850185e-02f, 4.32839021e-02f, 1.34667441e-01f, -1.40417442e-02f, 2.89150514e-02f, -5.72940037e-02f, -2.42315810e-02f, -3.72444279e-02f, -1.20251872e-01f,
  7.26530980e-03f, 6.85007824e-03f, -4.50170301e-02f, 7.68483728e-02f, 8.49430487e-02f, -1.62939858e-02f, 4.40210886e-02f, 2.93581206e-02f, 4.41997610e-02f, 1.28383806e-04f,
  6.27820417e-02f, 1.00741601e-02f, 2.95398496e-02f, 1.03493943e-03f, 1.52638540e-01f, 5.81098162e-02f, -3.12708877e-02f, 7.26683587e-02f, 6.25519678e-02f, -1.22201014e-02f,
  4.24251407e-01f, 1.44444108e-01f, 1.65809810e-01f, 2.24577114e-01f, 2.87551917e-02f, -5.55355428e-03f, 1.77441746e-01f, 1.54563086e-03f, 3.95056009e-01f, -1.27905831e-01f,
  -7.91384503e-02f, 8.26114863e-02f, -1.30354673e-01f, 1.35093361e-01f, -1.73176423e-01f, -1.36649176e-01f, 1.17542282e-01f, 3.12347971e-02f, 1.02436259e-01f, -3.14671430e-03f,
  1.28212556e-01f, -1.59430265e-01f, -8.50444734e-02f, -2.51785398e-01f, 1.86441079e-01f, 9.43682119e-02f, -1.82042107e-01f, -1.26236662e-01f, -1.49842873e-01f, -1.28720790e-01f,
  6.49867281e-02f, 4.07121144e-02f, 1.11081541e-01f, -2.47463714e-02f, 1.52938266e-03f, 6.55089915e-02f, -6.89461380e-02f, -7.41796345e-02f, 5.78751490e-02f, 1.40432501e-02f,
  -1.60898396e-03f, -1.14113614e-01f, 3.18475664e-02f, 4.58125062e-02f, 1.45606890e-01f, 1.00126907e-01f, 8.46346766e-02f, 1.30064756e-01f, -2.13526431e-02f, -3.89384590e-02f,
  5.90322316e-02f, 8.95652547e-02f, 1.15129128e-01f, -1.94453560e-02f, 6.07521720e-02f, 9.48481411e-02f, -3.77802476e-02f, -4.88127433e-02f, 4.91552204e-02f, 6.76506758e-02f,
  5.09621669e-03f, 1.04117235e-02f, -7.55228624e-02f, 3.06426641e-02f, -9.82207712e-03f, 4.98718843e-02f, -7.30588064e-02f, -8.58791247e-02f, -1.40686454e-02f, 2.07803398e-02f,
  9.17184576e-02f, 5.59347086e-02f, 6.78533688e-02f, 5.57352938e-02f, 1.76728405e-02f, -2.29907408e-02f, 7.01997429e-03f, -1.84695777e-02f, 2.04835106e-02f, 5.64545989e-02f,
  1.19161554e-01f, 1.46254776e-02f, -8.17139521e-02f, 2.45951694e-02f, -4.12170775e-02f, -6.24625832e-02f, -3.96304624e-03f, 2.88917609e-02f, 1.17214415e-02f, -3.03031206e-02f,
  -7.92636424e-02f, -1.58748597e-01f, 4.36736416e-04f, 1.46124624e-02f, -5.30928038e-02f, -2.72613652e-02f, 4.38875034e-02f, -9.27013718e-03f, 1.42518934e-02f, -2.04569194e-02f,
  -2.16082279e-02f, 2.88648773e-02f, -2.22030263e-02f, 1.35655757e-02f, -6.90231845e-02f, -7.26144984e-02f, -3.59971598e-02f, -2.96794232e-02f, -4.61239219e-02f, -3.81134637e-02f,
  -4.27089147e-02f, -3.99409905e-02f, -1.18795671e-02f, 1.07052214e-02f, 4.80801724e-02f, -7.11195692e-02f, 4.22386751e-02f, 7.32518584e-02f, -8.51699412e-02f, 7.51557248e-03f,
  -3.69471461e-01f, 2.22979635e-01f, -1.68389514e-01f, -3.12591717e-02f, -3.51026841e-02f, 1.97989911e-01f, 2.63420314e-01f, -1.34010479e-01f, 4.39225603e-03f, 3.51562589e-01f,
  1.90463975e-01f, -2.12302089e-01f, -1.16441278e-02f, 3.67173970e-01f, -2.04915613e-01f, 1.04369797e-01f, 1.72526330e-01f, 1.72404453e-01f, -1.33594155e-01f, -1.11565411e-01f,
  -8.80194604e-02f, 2.46939257e-01f, -3.60911265e-02f, -2.29280684e-02f, 7.77452663e-02f, -1.24654166e-01f, 1.14663422e-01f, -2.31954709e-01f, 1.08896501e-01f, -1.34092644e-02f,
  1.28591850e-01f, -1.44640785e-02f, 2.58740708e-02f, -1.27961263e-02f, -8.81198794e-02f, -4.77123968e-02f, -4.59419824e-02f, -1.20685928e-01f, -6.44791126e-02f, -1.04663737e-01f,
  -2.57855039e-02f, -3.00294105e-02f, -1.75713270e-03f, 1.37658007e-02f, -1.14492595e-01f, 2.43590903e-02f, -2.37703938e-02f, -2.97901854e-02f, 5.57605922e-03f, -2.41279453e-02f,
  2.06729807e-02f, 9.52513069e-02f, 2.02836730e-02f, 3.28587294e-02f, -4.71519902e-02f, 3.18213068e-02f, 3.09882741e-02f, -5.33155128e-02f, -2.51444019e-02f, -5.76420687e-02f,
  -1.07206125e-02f, -7.68988878e-02f, 6.02770075e-02f, 3.21210213e-02f, -6.21325523e-03f, 1.98496077e-02f, -1.72804911e-02f, 5.46934921e-03f, -4.27561328e-02f, 4.49024606e-03f,
  -3.66636179e-03f, -2.04867050e-02f, -3.71342041e-02f, -3.31738293e-02f, 3.08945160e-02f, 3.78618129e-02f, 3.78091000e-02f, 5.71968872e-03f, -2.21928358e-02f, 6.19026693e-03f,
  5.84548302e-02f, -3.58139127e-02f, 7.04139024e-02f, 5.52308261e-02f, -8.10256153e-02f, -1.52339172e-02f, 6.07704883e-03f, 1.54391732e-02f, 6.66113272e-02f, -1.11706033e-01f,
  1.01964258e-01f, -7.97371045e-02f, -2.74901297e-02f, 5.79705760e-02f, 2.12535970e-02f, 6.14090264e-02f, -6.31658137e-02f, 1.02723727e-03f, 2.26183385e-02f, -2.25666165e-02f,
  -2.12201346e-02f, -8.33333135e-02f, -1.61976069e-02f, -9.34973434e-02f, -1.20250762e-01f, 7.73867816e-02f, 1.42305000e-02f, 4.26051840e-02f, 1.37160681e-02f, -2.98666786e-02f,
  1.96916964e-02f, 5.20438328e-02f, -4.53954190e-02f, 3.41922306e-02f, 4.49877325e-03f, 1.63672154e-03f, -9.74762079e-04f, -7.68971890e-02f, -1.78298820e-02f, 8.32424760e-02f,
  3.05849433e-01f, 1.37060568e-01f, 4.28584889e-02f, 2.00966507e-01f, -2.01924220e-01f, -3.03365082e-01f, -2.67348140e-01f, 7.31864050e-02f, 1.57207742e-01f, -2.95600723e-02f,
  -1.04678296e-01f, 1.46556541e-01f, 1.19236805e-01f, 5.41280247e-02f, 2.34112710e-01f, 1.14218041e-01f, 1.76712856e-01f, -4.71788757e-02f, 7.26694837e-02f, 2.67174970e-02f,
  2.41192222e-01f, -2.93213800e-02f, 4.61580344e-02f, 6.21575639e-02f, 4.78419056e-03f, 3.56470607e-02f, 1.89354405e-01f, 2.10519675e-02f, -1.50527721e-02f, -3.99222039e-02f,
  -9.43422914e-02f, 6.90653697e-02f, -1.09687797e-03f, 4.20151390e-02f, -3.59771447e-03f, -7.75971338e-02f, -1.64392069e-02f, -8.31675828e-02f, -3.06969192e-02f, 5.35593741e-02f,
  -3.22522633e-02f, -4.18027192e-02f, -2.19340492e-02f, 6.15645796e-02f, -1.61643270e-02f, -4.78394926e-02f, -1.00987228e-02f, 1.31003615e-02f, 1.06539801e-02f, 9.22093913e-02f,
  -6.98923413e-03f, -7.27907941e-02f, -7.95677379e-02f, 4.01160419e-02f, 1.04334220e-01f, 4.87547554e-02f, 1.51647558e-03f, 7.07529336e-02f, -5.06395288e-02f, 4.98398095e-02f,
  5.61320484e-02f, 5.51452041e-02f, 2.96788048e-02f, -1.08849019e-01f, 7.18553513e-02f, 2.78364755e-02f, 4.16785330e-02f, -6.02057390e-02f, 1.24887126e-02f, 2.36946344e-02f,
  -1.54871941e-02f, 5.27516790e-02f, 1.15008159e-02f, -1.05426903e-03f, 1.16467915e-01f, -2.29364056e-02f, 6.53886050e-03f, -1.94317094e-04f, -5.33093791e-03f, 3.52432802e-02f,
  1.96046662e-02f, -1.15465214e-02f, 7.70037547e-02f, -3.88236232e-02f, -1.68125443e-02f, 1.75413750e-02f, 8.42545554e-02f, -2.59046238e-02f, -7.14800581e-02f, -4.57517132e-02f,
  1.43867075e-01f, 2.69979477e-01f, 2.43359208e-02f, -4.88159582e-02f, 7.25268275e-02f, -1.54628195e-02f, 1.02591596e-03f, 1.19508971e-02f, 1.18117578e-01f, 2.75720488e-02f,
  -8.52012858e-02f, -1.75864603e-02f, -2.54091080e-02f, 4.88634519e-02f, 6.13425532e-03f, 1.76436275e-01f, 6.90882728e-02f, 1.27706036e-01f, -2.79804114e-02f, 3.28974351e-02f,
  4.76486497e-02f, -1.09670445e-01f, -7.17784837e-03f, -8.78406018e-02f, -3.46450359e-02f, -1.89814270e-02f, -2.31577437e-02f, -4.26518284e-02f, -2.35646088e-02f, 6.47009909e-02f,
  -6.57265931e-02f, -1.83119446e-01f, -1.18986860e-01f, -1.66143492e-01f, -1.29829898e-01f, -3.36664796e-01f, -2.22309202e-01f, -3.93222496e-02f, 1.49194375e-01f, 1.62313564e-03f,
  2.98234150e-02f, 1.12842537e-01f, 1.21071644e-01f, -1.01564609e-01f, 8.02089050e-02f, 5.62541187e-02f, -2.98181772e-01f, -1.42712459e-01f, 3.23152333e-03f, -2.12498650e-01f,
  -3.98155004e-02f, -1.33554831e-01f, -3.06038614e-02f, -1.16665043e-01f, -1.44263089e-01f, -3.95666659e-02f, 1.98783964e-01f, -1.30210266e-01f, -2.29984373e-01f, -2.80220173e-02f,
  -4.09431346e-02f, 1.17389515e-01f, -2.25015804e-02f, 1.04907855e-01f, -5.46385418e-04f, -1.34104088e-01f, -4.85029221e-02f, 3.54503356e-02f, -2.80535128e-02f, 6.60059555e-03f,
  -8.92785843e-03f, 7.90396705e-02f, 3.61801386e-02f, 3.23031545e-02f, -6.78612590e-02f, -4.12593596e-03f, 6.94683418e-02f, -9.20064561e-03f, 2.13281829e-02f, 8.94044265e-02f,
  -8.50806478e-03f, -7.28991106e-02f, -4.84417230e-02f, 2.79796664e-02f, 4.98135202e-02f, 8.53220560e-03f, 3.49773318e-02f, 2.46441215e-02f, 3.18038426e-02f, -8.73904228e-02f,
  5.60289957e-02f, 8.41924772e-02f, -3.00348904e-02f, 2.30287272e-03f, 4.74588200e-02f, -6.27145171e-02f, -3.65972612e-03f, -1.21426983e-02f, -4.18846607e-02f, -3.31267528e-02f,
  4.74925619e-03f, 1.54565014e-02f, -8.96471739e-03f, -8.57015252e-02f, -7.53408968e-02f, -1.03189377e-02f, 4.79792170e-02f, -9.68375430e-03f, -1.26180753e-01f, 2.84655672e-02f,
  -2.02424489e-02f, -4.48946767e-02f, 3.52073982e-02f, -1.49490833e-02f, -5.33521771e-02f, 1.19838916e-01f, -2.11965851e-02f, 6.25130311e-02f, 9.84561518e-02f, -3.24993674e-03f,
  -9.44331363e-02f, -5.85789979e-02f, 2.75734775e-02f, 6.37691468e-02f, 8.30854923e-02f, 1.42389005e-02f, -2.49424623e-03f, -1.03628971e-01f, -5.40313199e-02f, -3.94002907e-02f,
  2.77740089e-03f, 1.83198694e-02f, -5.46276160e-02f, -3.69110256e-02f, -7.64599070e-02f, -4.15300541e-02f, -1.22890525e-01f, -2.69542914e-02f, -6.10335357e-02f, -8.83546695e-02f,
  -4.26303074e-02f, -6.60377182e-03f, 1.19263664e-01f, 3.65756042e-02f, -4.34663482e-02f, 3.65464650e-02f, -5.80144227e-02f, -6.00190423e-02f, 5.12932055e-03f, 6.74685389e-02f,
  -4.09688413e-01f, 1.88105509e-01f, 9.79637429e-02f, -6.07855543e-02f, -4.19072583e-02f, -2.17282046e-02f, -8.16089064e-02f, 1.99683666e-01f, 6.97112978e-02f, 2.32879356e-01f,
  -2.17458326e-02f, 1.00354075e-01f, -1.34424353e-02f, 3.53814811e-02f, -3.26898664e-01f, -3.97829972e-02f, -1.63695991e-01f, -1.23869613e-01f, 1.50514329e-02f, -6.56197667e-02f,
  -1.12855926e-01f, -1.74119025e-01f, -6.82937205e-02f, 7.23737711e-03f, -5.21630384e-02f, 3.53709087e-02f, -2.70968825e-01f, -1.14397086e-01f, -2.18393989e-02f, -5.05903810e-02f,
  1.53716793e-02f, 1.84754550e-01f, 6.68966118e-03f, 2.05934923e-02f, -1.83211043e-01f, 5.83442673e-02f, -1.61089242e-01f, -5.80856577e-02f, 6.40145540e-02f, 3.60822938e-02f,
  -1.20879315e-01f, 5.05888350e-02f, -3.51713076e-02f, 6.67747185e-02f, 1.60365120e-01f, 1.24877073e-01f, -1.42083727e-02f, 7.43467063e-02f, -4.50687483e-02f, 1.14745870e-02f,
  -6.17521815e-02f, 8.81023481e-02f, 5.08400165e-02f, -3.03033385e-02f, -8.19935352e-02f, 6.25963211e-02f, 8.59094411e-02f, 3.64710297e-03f, -8.30551330e-03f, 1.67982057e-02f,
  1.95048768e-02f, -9.02313739e-02f, -3.06206755e-02f, 7.66736194e-02f, -1.78188980e-02f, 4.97361869e-02f, -9.17148143e-02f, 3.31589133e-02f, 6.95358440e-02f, -4.51996587e-02f,
  5.56504875e-02f, 6.57379478e-02f, 1.10854685e-01f, -9.18783993e-03f, 5.13427891e-02f, 4.94453311e-03f, -9.08998698e-02f, -2.97530834e-02f, 8.74746367e-02f, -1.06414873e-02f,
  1.74366459e-02f, -3.21348496e-02f, 1.06428660e-01f, 1.43242069e-02f, 6.76864833e-02f, -1.13256805e-01f, 3.18360515e-02f, 3.30641195e-02f, -1.00622632e-01f, -1.32968798e-01f,
  -7.25053027e-02f, -1.21655762e-02f, -1.12316257e-03f, 1.56861115e-02f, -1.07641883e-01f, -2.20073834e-02f, -5.43815829e-02f, -1.04851760e-01f, -5.04939519e-02f, -7.12351426e-02f,
  -7.80249387e-02f, -2.34990921e-02f, -1.56537443e-01f, -5.36356643e-02f, 5.32293767e-02f, 7.51125952e-03f, -6.65233582e-02f, -1.02497324e-01f, -4.32389863e-02f, 5.58582284e-02f,
  -2.94439830e-02f, -7.57964849e-02f, -6.99207594e-04f, -4.66007255e-02f, -3.14207412e-02f, 4.61069457e-02f, 2.20590439e-02f, 4.20159213e-02f, -5.01033999e-02f, 7.15614483e-02f,
  5.66839054e-02f, 3.92569155e-01f, 4.71378975e-02f, 2.82065660e-01f, 2.35522032e-01f, 1.96061298e-01f, 1.19000770e-01f, 1.27599671e-01f, 3.58379245e-01f, 7.88124874e-02f,
  1.25029413e-02f, 1.82304218e-01f, -5.24311364e-02f, 9.31695402e-02f, 1.08062632e-01f, -5.55991894e-03f, 2.73125708e-01f, 1.00861505e-01f, 7.17774034e-02f, 8.39314759e-02f,
  9.93553475e-02f, 1.69791833e-01f, -1.04951024e-01f, -8.15573335e-02f, -2.91512646e-02f, -6.91591278e-02f, -1.09005883e-01f, -1.59201100e-01f, -7.77560472e-02f, 6.84833974e-02f,
  1.40856067e-03f, -1.25106480e-02f, -6.66007474e-02f, -1.15971789e-01f, -8.36801007e-02f, -8.99019167e-02f, -8.52872655e-02f, 3.88870621e-03f, -7.27876052e-02f, -4.70257811e-02f,
  7.17720687e-02f, -4.60274443e-02f, 6.26487657e-02f, 3.43419984e-02f, 2.15915050e-02f, 3.53150815e-03f, 8.53362214e-03f, -9.09434557e-02f, 1.27286064e-02f, -4.15023863e-02f,
  -8.73263627e-02f, 6.69912547e-02f, 6.22423217e-02f, 1.99413262e-02f, -7.59445652e-02f, -1.54422596e-02f, 5.41100204e-02f, -4.08198535e-02f, 2.44040936e-02f, 3.07029188e-02f,
  3.78571860e-02f, -2.87752859e-02f, -1.28198072e-01f, 5.69975376e-02f, -4.80605429e-03f, -7.66288638e-02f, 1.10365376e-01f, 8.35426524e-03f, 3.84737365e-02f, 4.38394696e-02f,
  -6.00724146e-02f, 1.21607654e-01f, 6.20133281e-02f, 4.95880805e-02f, 9.10214633e-02f, 2.45176861e-03f, -3.40084881e-02f, 2.18469538e-02f, 1.60536706e-01f, -6.31266311e-02f,
  -3.84940475e-04f, 5.52224293e-02f, -7.49630183e-02f, -6.65877089e-02f, 8.29277784e-02f, 1.31423175e-02f, 3.81757244e-02f, -6.89699873e-03f, -3.28909070e-03f, 9.13875774e-02f,
  1.36079162e-01f, 3.08692098e-01f, -2.18895096e-02f, -4.53890152e-02f, 5.90701886e-02f, 7.09452434e-04f, 1.01269133e-01f, 6.12348802e-02f, 4.20795269e-02f, 4.12646458e-02f,
  4.22648480e-03f, 5.73489480e-02f, 2.70899315e-03f, 5.03427833e-02f, 3.75829861e-02f, 5.42294495e-02f, -1.14715444e-02f, 6.55919174e-03f, 5.50235212e-02f, -5.04168831e-02f,
  -4.43172865e-02f, 2.85661849e-03f, -6.12011105e-02f, 5.23028634e-02f, -4.81797084e-02f, -8.33782479e-02f, 5.52429706e-02f, -7.08207786e-02f, 3.08323186e-02f, -1.10419840e-03f,
  1.58838645e-01f, -8.08605030e-02f, -1.64375260e-01f, 1.19270526e-01f, -1.35796472e-01f, 3.62428464e-02f, -1.23682112e-01f, 6.71025589e-02f, -1.29639819e-01f, 1.14254713e-01f,
  1.07499219e-01f, -6.89605474e-02f, -3.31247710e-02f, 2.68417507e-01f, 7.93211833e-02f, 8.35488178e-03f, 2.13295296e-01f, 1.39540374e-01f, -3.54620554e-02f, 1.46483704e-01f,
  1.06003828e-01f, 2.64241040e-01f, -4.13437821e-02f, 2.05420598e-01f, 7.49950856e-02f, -7.86851645e-02f, 1.94257185e-01f, -1.54763028e-01f, 1.56946033e-01f, 1.97339505e-02f,
  1.46368137e-02f, -5.56433648e-02f, 3.94683667e-02f, 3.73592488e-02f, 6.63270894e-03f, 1.29894391e-02f, 2.33175326e-02f, 7.14338049e-02f, 3.09888944e-02f, -1.14732966e-01f,
  -4.68809344e-02f, 1.58919226e-02f, 1.18990943e-01f, -7.70429373e-02f, 2.16872618e-02f, -2.57014181e-04f, 5.83737344e-02f, -3.08451448e-02f, -5.06416038e-02f, -4.39392962e-02f,
  -3.41553576e-02f, -1.24698550e-01f, -1.45131256e-02f, -4.86643985e-02f, -5.79235889e-02f, -7.15942830e-02f, -4.61230846e-03f, -2.91873105e-02f, -6.41291440e-02f, 4.92561050e-02f,
  4.36946489e-02f, 1.44646941e-02f, 6.88600838e-02f, 8.47693235e-02f, 6.88193440e-02f, 5.29647581e-02f, 3.52382362e-02f, -8.02491382e-02f, 9.29136295e-05f, 6.04597572e-03f,
  -9.63896886e-03f, 8.47285986e-02f, 7.86831230e-02f, -8.51215515e-03f, -2.11378885e-03f, 7.75470808e-02f, 5.82919046e-02f, -9.10856947e-03f, -8.71737897e-02f, 5.38268834e-02f,
  8.43682438e-02f, -7.41014956e-04f, 4.39393409e-02f, -4.13637683e-02f, 1.03779301e-01f, -1.35954976e-01f, -1.07436553e-02f, -3.60775031e-02f, -1.17943093e-01f, -1.59980431e-02f,
  1.10954680e-01f, 1.18208967e-01f, -7.78482109e-02f, -3.86827812e-02f, 2.22179201e-02f, 1.44817173e-01f, 2.12341547e-02f, 9.08357427e-02f, 3.96582810e-03f, 2.63131969e-02f,
  -2.17220956e-03f, -8.97570029e-02f, -5.14650494e-02f, -1.80581920e-02f, -8.74945447e-02f, -1.13011621e-01f, -4.47625434e-03f, -3.06189284e-02f, 6.80449381e-02f, 3.83140333e-02f,
  -1.63656473e-02f, 2.71632280e-02f, 2.86146235e-02f, -9.86962616e-02f, 2.34736241e-02f, -6.11385331e-02f, -2.98413727e-02f, -9.23601910e-02f, 1.00303687e-01f, -1.85246747e-02f,
  -2.97774803e-02f, -1.39634818e-01f, 7.21269026e-02f, -4.62876558e-02f, -6.75979406e-02f, 1.30185932e-01f, 2.65751064e-01f, -1.95568606e-01f, -1.43830121e-01f, -1.65806368e-01f,
  -6.73681200e-02f, 3.70013379e-02f, 1.36148974e-01f, -1.67618897e-02f, 3.44765216e-01f, 1.84922606e-01f, 3.17551419e-02f, 1.07331268e-01f, 5.17438278e-02f, -1.15360215e-01f,
  -9.04572010e-02f, -1.10908464e-01f, 1.09447166e-01f, -2.31781125e-01f, -7.00843111e-02f, -9.76850390e-02f, -2.37805489e-02f, 1.52526334e-01f, -1.54083595e-01f, 5.90330996e-02f,
  1.55023605e-01f, 8.07323083e-02f, 3.58646512e-02f, 4.02045297e-03f, 9.94029492e-02f, 1.84860602e-02f, 1.23398170e-01f, 2.83069052e-02f, -2.56571285e-02f, -7.77126476e-02f,
  1.22064106e-01f, 1.73424035e-02f, 8.45436659e-03f, -5.07224426e-02f, -1.04680985e-01f, -7.70681575e-02f, -1.73034891e-02f, -4.31069955e-02f, -1.92416459e-02f, -1.04415424e-01f,
  1.86846256e-02f, -5.43202460e-02f, 5.91651201e-02f, -1.98699459e-02f, -2.32120715e-02f, -4.09495123e-02f, 8.78090486e-02f, 1.11566663e-01f, -3.97294015e-02f, -9.86180678e-02f,
  -1.08621337e-01f, 4.89104912e-02f, -9.29266308e-03f, -7.08655715e-02f, 5.10490499e-02f, -1.27555370e-01f, -1.07642971e-02f, -8.34088679e-03f, -4.53359708e-02f, 4.99645472e-02f,
  -1.03209652e-01f, -2.38646772e-02f, 8.25480279e-03f, 2.85688695e-02f, -9.02304053e-02f, -8.70851800e-02f, 5.56189939e-02f, -7.54744112e-02f, -7.12191388e-02f, 1.35163469e-02f,
  3.44153680e-02f, -3.04391026e-03f, 4.44976054e-02f, 5.91662303e-02f, -4.44488972e-03f, 5.68499155e-02f, -5.78336231e-02f, -6.97255954e-02f, -8.10275227e-02f, 2.35018190e-02f,
  1.08527429e-01f, -3.06129176e-03f, -3.21913022e-03f, -3.83989103e-02f, -6.13058032e-03f, 1.00893974e-01f, 5.09687215e-02f, -4.52599712e-02f, 1.17290728e-01f, -6.43953010e-02f,
  -7.46953338e-02f, -2.35149357e-02f, -5.14529310e-02f, -5.65991998e-02f, 2.11127698e-02f, -8.41071531e-02f, -6.10272400e-02f, 1.06785849e-01f, -1.76370498e-02f, -1.07518286e-01f,
  -1.28779843e-01f, 4.10445072e-02f, -1.46557204e-02f, 1.38160307e-03f, -3.87935862e-02f, -4.61832853e-03f, -4.21606228e-02f, -3.91885974e-02f, -7.90312700e-03f, -1.77811254e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.02484214e-01f, 1.15917765e-01f, 1.17701963e-02f, 1.94182500e-01f, 1.28633648e-01f, 1.36672243e-01f, -3.15297693e-02f, 1.74300924e-01f, 5.45556545e-02f, 6.39848039e-02f,
  6.14663288e-02f, 1.29403993e-01f, 8.03681016e-02f, -1.05902078e-02f, 9.62334573e-02f, 5.60884997e-02f, 1.69449896e-01f, 8.44579041e-02f, 1.30679414e-01f, 1.10213503e-01f,
  1.98658764e-01f, -3.89185478e-03f, 1.56513557e-01f, 2.33399898e-01f, 1.40230387e-01f, 1.97897375e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.12575106e-01f, 2.83705574e-02f, 1.65540889e-01f, -8.62510204e-02f, 7.79023841e-02f, 1.73599884e-01f, -2.49409229e-02f, -4.52236534e-04f, -4.18795496e-02f, -9.50463563e-02f,
  -1.23946900e-02f, -9.19064209e-02f, 9.50519890e-02f, -4.34877686e-02f, 4.39411122e-03f, 1.16206877e-01f, -4.39837053e-02f, -2.13448759e-02f, 6.69619739e-02f, -9.41741168e-02f,
  7.71612823e-02f, 1.56038836e-01f, 4.97165248e-02f, -1.93943098e-01f, 1.96932316e-01f, 1.54497519e-01f, 1.38523981e-01f, -1.83668196e-01f, -1.80904325e-02f, 3.66919003e-02f,
  -5.27342074e-02f, 1.49253085e-01f, -1.21917665e-01f, 6.50808290e-02f, -6.07485585e-02f, 4.03913446e-02f, 1.28572673e-01f, 2.61250794e-01f, -1.46299982e-02f, 7.29962289e-02f,
  1.52881265e-01f, 1.61106795e-01f, 5.94751257e-03f, -2.34831646e-01f, 1.60556197e-01f, -1.66026995e-01f, 1.02875978e-01f, -1.05924390e-01f, -1.48937449e-01f, -7.45689869e-02f,
  -2.00735539e-01f, -4.61752601e-02f, -6.25733808e-02f, 2.34469131e-01f, 7.83610642e-02f, 1.30895795e-02f, 1.45780489e-01f, -8.54561180e-02f, 3.03076893e-01f, 1.32229310e-02f,
  -2.10771009e-01f, 2.48616382e-01f, 3.37851532e-02f, 1.49222529e-02f, 1.17525354e-01f, -9.96793061e-02f, 7.29586706e-02f, 5.10949828e-02f, 1.05325051e-01f, 3.37045453e-02f,
  -1.21294066e-01f, -7.34771490e-02f, -1.37164056e-01f, -1.66603401e-01f, -4.02525626e-02f, -8.44210461e-02f, -7.85933435e-02f, 4.31998167e-03f, 7.82216340e-02f, 4.69817780e-02f,
  6.31197914e-02f, -4.96207103e-02f, 2.15944834e-03f, 2.36462831e-01f, -1.34158015e-01f, 2.25554973e-01f, 1.28821805e-01f, -2.22235128e-01f, -1.67759687e-01f, -5.60247041e-02f,
  1.00226626e-02f, 1.62709989e-02f, -1.94148928e-01f, 1.27573341e-01f, 1.85078844e-01f, -1.85363665e-01f, 4.62158676e-03f, -1.36597574e-01f, 2.91875619e-02f, 7.11389026e-03f,
  -1.01772569e-01f, 5.19788265e-02f, 1.22033648e-01f, 1.46776199e-01f, 8.74399170e-02f, 1.70128748e-01f, -1.11394480e-01f, -8.91309511e-03f, 2.26651609e-01f, -1.51387468e-01f,
  -1.76418975e-01f, -5.31189479e-02f, 8.18024650e-02f, -1.17329722e-02f, -1.21548316e-02f, -2.26887882e-01f, -1.03125885e-01f, 1.57623962e-01f, -1.97062731e-01f, 1.16678283e-01f,
  -5.17025925e-02f, 1.28312841e-01f, -1.34826735e-01f, 8.16180930e-02f, -9.52277258e-02f, 3.48918624e-02f, 5.10728098e-02f, 1.31982878e-01f, 1.30036220e-01f, -3.14819887e-02f,
  -7.11396486e-02f, 9.46191922e-02f, 1.18378766e-01f, -1.65559992e-01f, -6.39563128e-02f, -3.68775129e-02f, -3.85631360e-02f, 3.76390778e-02f, 5.32518551e-02f, 1.00356862e-01f,
  1.66602875e-03f, 3.92749235e-02f, 5.19836582e-02f, -1.71086099e-02f, 1.40023172e-01f, 1.47166774e-01f, -5.89545853e-02f, -4.92889956e-02f, -1.78792253e-02f, 6.97415322e-02f,
  2.77610626e-02f, 1.72063187e-01f, -4.92268428e-02f, -2.62401134e-01f, -1.72498763e-01f, 1.59257408e-02f, -6.71812594e-02f, 4.33112346e-02f, 9.56771225e-02f, -1.20924726e-01f,
  2.09052235e-01f, -4.53743199e-03f, 1.53903104e-02f, 1.65212736e-01f, -1.44595101e-01f, -1.96408227e-01f, 9.44624990e-02f, -7.25286379e-02f, 1.36408612e-01f, 1.41218796e-01f,
  -8.63573551e-02f, -4.74223755e-02f, 2.33698830e-01f, -8.30774084e-02f, -1.49984151e-01f, 6.43656030e-02f, -9.71460491e-02f, 3.78861139e-03f, 2.03868255e-01f, 1.05186611e-01f,
  -1.36346072e-01f, -1.89059705e-01f, 9.45549607e-02f, 2.94238925e-02f, -2.70027578e-01f, 1.07386060e-01f, 1.15779582e-02f, 2.74173558e-01f, 1.07294217e-01f, -1.80671483e-01f,
  -1.28339410e-01f, 9.26263444e-03f, -9.02411640e-02f, -3.46160568e-02f, -6.75277635e-02f, 1.61057606e-01f, 1.01126701e-01f, -7.11810365e-02f, 9.38214138e-02f, 1.08786728e-02f,
  7.56648555e-02f, -4.16707397e-02f, -1.20617352e-01f, 2.71739308e-02f, -1.04039229e-01f, 6.00881875e-02f, 7.45652849e-03f, -1.27814725e-01f, -8.49000551e-03f, 2.70603392e-02f,
  -1.06880896e-01f, -1.27267540e-01f, 5.71015477e-02f, -8.74874145e-02f, 1.07675888e-01f, -1.08713716e-01f, -1.92421637e-02f, -1.54952034e-01f, 8.60695988e-02f, -5.50641119e-02f,
  1.40549541e-01f, -1.07870243e-01f, -1.80936471e-01f, -7.19911531e-02f, 1.23454593e-01f, -6.39995933e-02f, -7.81342164e-02f, -4.41672094e-02f, -8.07395503e-02f, 1.19322546e-01f,
  1.00512810e-01f, 1.76834280e-03f, 2.09899038e-01f, -9.93554518e-02f, -2.60641605e-01f, -9.21110213e-02f, 4.92749214e-02f, 1.47996023e-01f, -1.77703112e-01f, -4.90169749e-02f,
  -3.56162526e-02f, 2.83465963e-02f, 1.46790147e-01f, -1.49194285e-01f, 6.00827001e-02f, -1.63984030e-01f, 2.76303381e-01f, 1.18582241e-01f, -2.33390942e-01f, 2.16172114e-01f,
  -1.15523664e-02f, 2.66627789e-01f, -7.10656494e-02f, -1.17158599e-01f, 8.08678344e-02f, 1.03740305e-01f, -7.56429061e-02f, -7.83335268e-02f, 4.58825156e-02f, -6.68321550e-02f,
  9.20425206e-02f, 4.10113968e-02f, 5.32542616e-02f, 6.52883714e-03f, -1.22241408e-01f, -7.63889849e-02f, -9.32448059e-02f, -7.66235366e-02f, 6.85212836e-02f, -8.00543875e-02f,
  -2.75693629e-02f, -4.62556370e-02f, -1.26662150e-01f, -1.22787818e-01f, -5.41654825e-02f, -1.33537382e-01f, 1.42230913e-01f, -9.65771154e-02f, 7.72935450e-02f, -1.00333594e-01f,
  2.03811586e-01f, 2.92492718e-01f, 1.85489357e-01f, 1.41393870e-01f, -9.87955481e-02f, -2.63796225e-02f, 1.33612752e-01f, 1.20076858e-01f, -2.57011801e-01f, 1.58968449e-01f,
  9.76810083e-02f, -1.17263813e-02f, 9.46185887e-02f, 6.70019984e-02f, -2.37531573e-01f, -1.03269972e-01f, -4.89591323e-02f, 4.26447019e-02f, 2.31325313e-01f, 1.15902789e-01f,
  -9.95357931e-02f, 1.96537860e-02f, 1.53202370e-01f, -2.11673118e-02f, 1.45495348e-02f, 1.01642400e-01f, -5.88758886e-02f, -2.99737714e-02f, -5.44738099e-02f, 2.01305524e-01f,
  -1.26095012e-01f, -2.80354824e-02f, 2.15985879e-01f, -5.55661693e-02f, 6.66031688e-02f, -2.07105160e-01f, -1.24639519e-01f, 2.61524588e-01f, 4.02577445e-02f, -1.42864510e-01f,
  1.48683056e-01f, 7.36864731e-02f, 7.54344612e-02f, 7.54612461e-02f, -1.16853222e-01f, -2.69561522e-02f, -3.72440815e-02f, 1.32243931e-01f, 7.21453875e-02f, -4.98981588e-02f,
  -2.65348777e-02f, 1.70111179e-01f, 1.27323018e-02f, -4.69711088e-02f, -2.82718427e-02f, 2.40950175e-02f, 1.58289131e-02f, 2.91437767e-02f, 3.02603822e-02f, -1.39080584e-01f,
  -1.65719375e-01f, -2.85682268e-02f, 1.55034650e-03f, 4.90700714e-02f, -2.02759579e-01f, -7.73695111e-02f, 7.32114241e-02f, 1.11500539e-01f, 1.32393330e-01f, 1.32378846e-01f,
  5.84915355e-02f, 1.30222991e-01f, 1.64042652e-01f, -2.08762623e-02f, 1.67496935e-01f, -3.78378332e-02f, 2.47138850e-02f, -2.62909800e-01f, -1.20633639e-01f, -1.04368083e-01f,
  2.44171303e-02f, 1.76141709e-01f, -4.32470776e-02f, 2.21765354e-01f, 1.91576108e-01f, 4.95910235e-02f, 1.67601302e-01f, -7.64674619e-02f, -1.48966521e-01f, -7.64010921e-02f,
  2.41453737e-01f, 2.29086384e-01f, -1.64776489e-01f, 7.17513412e-02f, 4.03764360e-02f, 1.26676504e-02f, 1.26211215e-02f, -1.97687864e-01f, 4.76002740e-03f, 2.18516022e-01f,
  1.55635610e-01f, -3.39225121e-02f, -1.29845098e-01f, -6.74679652e-02f, -5.53113744e-02f, 1.12851992e-01f, 2.01660678e-01f, -1.22738302e-01f, -5.94918393e-02f, 2.35234648e-01f,
  -7.55494833e-02f, 4.80393209e-02f, -3.72278988e-02f, -1.16773918e-01f, 4.47876304e-02f, 3.14004384e-02f, 2.05503121e-01f, -1.16898865e-02f, -7.57744536e-02f, 9.35167149e-02f,
  -1.61663920e-01f, -1.50892898e-01f, 6.37680665e-03f, -1.49150744e-01f, 2.78967284e-02f, 1.33565277e-01f, 4.97058928e-02f, -1.52239770e-01f, 2.44221926e-01f, 1.59490019e-01f,
  2.09781975e-01f, -1.47511736e-01f, 1.72945097e-01f, 3.21859261e-03f, 2.05074608e-01f, 2.72151232e-01f, -9.32989791e-02f, 2.44164318e-01f, 1.90730393e-02f, -7.85927549e-02f,
  1.82172209e-02f, 2.56865561e-01f, 2.87639629e-02f, 1.21321790e-01f, -3.54556441e-02f, 1.58436969e-01f, 9.63493735e-02f, -4.92698587e-02f, 9.81124490e-02f, -1.08968206e-01f,
  1.74572915e-01f, -1.63731664e-01f, -1.65340558e-01f, -1.56741834e-03f, -2.46401235e-01f, 3.98664176e-02f, 3.17479707e-02f, 2.46179730e-01f, -2.66852140e-01f, -7.60427490e-02f,
  2.48885170e-01f, -4.93995473e-02f, 2.58314103e-01f, 2.12578505e-01f, -1.72619328e-01f, 1.72037557e-01f, -8.09175223e-02f, -6.34419248e-02f, 6.40016794e-02f, 8.37085471e-02f,
  2.65706033e-01f, -6.88623339e-02f, 4.88719009e-02f, 1.77172258e-01f, -5.61413132e-02f, -1.42602352e-02f, 6.20804876e-02f, -1.25790209e-01f, -4.94816806e-03f, 1.00048125e-01f,
  1.96112439e-01f, 3.46712931e-03f, 1.03824161e-01f, 2.24653864e-03f, -5.92713654e-02f, 7.13783083e-03f, 3.81321833e-02f, 5.17777577e-02f, -4.04214934e-02f, 1.05987839e-01f,
  7.84715936e-02f, -2.60490417e-01f, -7.15146437e-02f, 1.14723198e-01f, 1.78378940e-01f, 1.69059575e-01f, 1.00397810e-01f, -8.80721882e-02f, -7.57221952e-02f, 1.67170063e-01f,
  -3.61353415e-03f, -1.02281757e-01f, -1.17726624e-01f, -3.02494057e-02f, 2.40148176e-02f, 3.58132310e-02f, -1.57556400e-01f, 2.53455490e-01f, 7.39020556e-02f, 2.21831247e-01f,
  6.09591091e-03f, -1.48839355e-01f, 2.28981540e-01f, -1.78137362e-01f, 1.24550454e-01f, -5.82152717e-02f, 4.97215576e-02f, 1.62443474e-01f, -1.90726705e-02f, -1.71486840e-01f,
  -3.53489928e-02f, 2.60580808e-01f, -4.43442427e-02f, -4.84255068e-02f, -4.96232770e-02f, 1.16041154e-01f, 2.18550399e-01f, 8.86607617e-02f, 4.82813343e-02f, 2.54723459e-01f,
  1.40333220e-01f, -2.88822828e-03f, 1.50571644e-01f, -9.81450006e-02f, 2.44173855e-01f, -4.57315296e-02f, -5.74904606e-02f, -2.07623690e-01f, -1.66093633e-01f, 2.25585755e-02f,
  3.19792167e-03f, -1.28695831e-01f, 3.85076255e-02f, 1.07286070e-02f, 7.14122355e-02f, 4.33891229e-02f, 4.70013730e-02f, -3.72166112e-02f, 1.05522713e-02f, 7.10474476e-02f,
  -1.06490757e-02f, -5.66772297e-02f, -6.51042759e-02f, 1.05121687e-01f, 1.79553181e-01f, -1.86245903e-01f, -1.94267064e-01f, -1.16601668e-01f, 1.39543101e-01f, 3.29406142e-01f,
  -1.05422944e-01f, 9.05859545e-02f, -1.17148533e-01f, 4.36403081e-02f, 2.54581738e-02f, -9.59304422e-02f, -2.18684807e-01f, -4.33157235e-02f, 9.65323001e-02f, -6.37874976e-02f,
  -2.78648257e-01f, 1.37885898e-01f, 1.73595086e-01f, 1.44522697e-01f, -4.30644378e-02f, 3.53607386e-02f, 1.37161300e-01f, -3.28255421e-03f, 6.48813322e-02f, -1.76971436e-01f,
  -1.70304015e-01f, -1.23459958e-01f, 2.66450226e-01f, -3.23202498e-02f, -1.88830867e-01f, 1.26354620e-01f, -3.44620906e-02f, -5.51869795e-02f, -7.82940909e-02f, 1.50774315e-01f,
  1.47680894e-01f, 5.87991960e-02f, 2.16747478e-01f, 1.89355955e-01f, 1.56287923e-02f, -5.28655797e-02f, -2.73319408e-02f, -3.30827315e-03f, -2.30132136e-02f, 8.64360016e-03f,
  2.54275091e-02f, -7.91869909e-02f, -9.93014947e-02f, 4.91506197e-02f, -1.31191676e-02f, -2.29934826e-01f, -1.41297072e-01f, -1.42057911e-01f, 8.96656513e-03f, -3.85984331e-02f,
  5.05821034e-02f, -1.25720337e-01f, 1.01527289e-01f, -7.92944878e-02f, 1.18423924e-01f, -1.90539375e-01f, -5.18624596e-02f, -1.34428367e-01f, -1.63559541e-02f, -1.27334461e-01f,
  9.23415720e-02f, -1.54423833e-01f, 2.36190945e-01f, 1.93465114e-01f, 1.71737492e-01f, -1.56637117e-01f, -1.25664055e-01f, -1.34399254e-02f, 1.56242073e-01f, 1.46571482e-02f,
  -8.89631063e-02f, -4.00945283e-02f, -2.66143344e-02f, 4.63314056e-02f, -2.12019756e-01f, -2.35224143e-02f, 1.96317345e-01f, 6.22485131e-02f, -2.93249786e-01f, -2.23301783e-01f,
  -1.29145170e-02f, 1.92555472e-01f, -7.32136611e-03f, -8.52360204e-02f, -1.06756993e-01f, -3.99742872e-02f, -1.01540916e-01f, 8.51162244e-03f, -1.29691735e-02f, 2.73995344e-02f,
  2.94957548e-01f, -7.25502744e-02f, -1.57173976e-01f, 2.03233644e-01f, 1.33597702e-01f, 1.53158233e-01f, 9.83595699e-02f, 1.20536096e-01f, -6.60464093e-02f, -4.79333177e-02f,
  1.18329957e-01f, 3.23337577e-02f, 2.26828352e-01f, 1.17143065e-01f, -4.27173711e-02f, -3.21535356e-02f, -1.68739259e-02f, -1.19676106e-02f, -3.09968665e-02f, -8.40580761e-02f,
  3.61966006e-02f, 4.72535081e-02f, 1.61060933e-02f, 1.53754190e-01f, 1.52355388e-01f, -8.91748890e-02f, -4.03481685e-02f, 9.77914855e-02f, 9.32106301e-02f, 4.39928956e-02f,
  9.44836512e-02f, -1.62282243e-01f, 1.12809632e-02f, -5.14808930e-02f, -1.52634103e-02f, 8.45283791e-02f, 3.05599660e-01f, 2.37761959e-01f, -8.02384913e-02f, 2.37746760e-02f,
  -1.58507809e-01f, 2.20443711e-01f, 7.92942792e-02f, 5.13264351e-02f, -1.47045076e-01f, 3.19275223e-02f, 1.17638027e-02f, 1.80563610e-03f, -1.53935716e-01f, 9.70285609e-02f,
  2.29270473e-01f, 2.20084533e-01f, -5.87697327e-02f, 5.41581437e-02f, 1.33993581e-01f, 2.08345309e-01f, -2.98541058e-02f, -1.80615962e-01f, -3.00091475e-01f, 1.88961044e-01f,
  2.22231299e-01f, -1.67468581e-02f, 1.39471963e-01f, 2.03370616e-01f, 1.04169354e-01f, 7.55433366e-02f, -6.96564838e-02f, 2.05418780e-01f, -4.85655939e-04f, -1.62862148e-02f,
  1.91645995e-01f, 2.06570685e-01f, 6.24786429e-02f, -1.01758786e-01f, 9.78983864e-02f, -4.68851291e-02f, 1.78697795e-01f, 3.63928527e-02f, 3.61347087e-02f, 2.40360554e-02f,
  9.52337775e-03f, 4.76169251e-02f, -1.12102166e-01f, 2.24227365e-02f, 3.80075388e-02f, 1.35856986e-01f, 9.46738571e-02f, -6.54774830e-02f, -1.92234423e-02f, 9.42257494e-02f,
  7.32588246e-02f, 4.82001007e-02f, 1.17310271e-01f, 1.50071084e-01f, 1.29163817e-01f, -8.03270712e-02f, -2.54339781e-02f, -8.98264050e-02f, 1.58405811e-01f, 1.33963913e-01f,
  8.29764232e-02f, -5.29673733e-02f, -1.45783290e-01f, -1.95961967e-01f, -5.27406670e-02f, 1.27272859e-01f, -1.54428348e-01f, -2.12778524e-01f, -2.54977316e-01f, -1.15489140e-01f,
  1.72475547e-01f, 1.84462160e-01f, -1.89184234e-01f, 2.36315578e-01f, -1.57261893e-01f, 1.97004676e-02f, 4.47983928e-02f, -5.69404475e-02f, -1.06663905e-01f, 7.11728862e-05f,
  6.21850677e-02f, -2.16547307e-02f, 6.37223572e-02f, 1.51763126e-01f, -1.13927752e-01f, -2.63039261e-01f, 6.13606200e-02f, 2.94919163e-01f, -7.47791398e-03f, 6.82421848e-02f,
  2.06874683e-01f, 1.00814551e-01f, 1.17373262e-02f, -1.39563918e-01f, -1.33048287e-02f, 2.61115104e-01f, 1.93406060e-01f, -4.06043716e-02f, -1.04519799e-01f, -4.45494242e-02f,
  -1.56881019e-01f, -3.47850821e-03f, -5.22226691e-02f, -2.57124985e-03f, -3.74919958e-02f, 4.04249728e-02f, 1.44348338e-01f, -2.84274220e-02f, 2.40621734e-02f, -1.83647707e-01f,
  5.02289571e-02f, -1.22332685e-01f, -8.02314058e-02f, -7.69610181e-02f, -9.78715941e-02f, -1.06938161e-01f, -8.73604976e-03f, -1.43639177e-01f, 7.22356513e-02f, -1.57982796e-01f,
  -1.38044655e-01f, 1.04118265e-01f, 8.25374648e-02f, 5.62781282e-02f, -5.24271792e-03f, -1.65760309e-01f, 3.34068954e-01f, 7.17987120e-02f, -7.11321086e-02f, 7.77621865e-02f,
  -2.80319639e-02f, 4.53875139e-02f, 3.79726961e-02f, 4.78234291e-02f, 2.01749057e-01f, 6.05105013e-02f, 3.44381928e-02f, -1.68878227e-01f, 8.72781500e-02f, -9.74972174e-02f,
  -8.87796506e-02f, -1.17241486e-03f, 1.23517886e-01f, 9.47270840e-02f, -4.60585356e-02f, 2.75840312e-02f, -8.35089162e-02f, 4.42387946e-02f, -2.22685829e-01f, 1.00512616e-01f,
  7.62322396e-02f, -1.34460598e-01f, 3.11428964e-01f, -3.08548734e-02f, 4.39875089e-02f, 1.25195114e-02f, 1.67174920e-01f, 2.43391097e-01f, 6.48136660e-02f, 3.04685999e-02f,
  6.15413822e-02f, -1.84954405e-01f, -7.24119768e-02f, -1.10122621e-01f, -1.93474650e-01f, 1.18840031e-01f, 1.56359568e-01f, -1.29267737e-01f, 5.39209507e-02f, -3.16612422e-03f,
  5.03279679e-02f, 7.40494207e-02f, -1.34585313e-02f, 1.08001940e-01f, -4.20401506e-02f, -6.83526089e-03f, 6.37691766e-02f, 6.30379915e-02f, 1.38351053e-01f, 1.89037606e-01f,
  6.59957901e-02f, -1.11542270e-01f, 1.85424656e-01f, -2.31884703e-01f, -1.07797300e-02f, 1.12420917e-01f, 3.17423120e-02f, -1.35212606e-02f, -1.18632734e-01f, 1.25316590e-01f,
  -1.54994622e-01f, 5.46802878e-02f, -4.06272113e-02f, -1.03048505e-02f, 2.85713464e-01f, -7.90819973e-02f, 5.73467836e-03f, -1.04657961e-02f, -3.22856992e-01f, -7.76960328e-02f,
  7.55204409e-02f, 9.03177727e-03f, -3.91503796e-02f, -1.96938425e-01f, -1.81283817e-01f, -3.12774926e-02f, -2.37387046e-01f, 1.04899526e-01f, -2.20401525e-01f, 1.96114674e-01f,
  1.32098300e-02f, -9.42310616e-02f, 1.22325405e-01f, -2.93475972e-03f, 4.28986922e-02f, -2.69114792e-01f, 2.40521237e-01f, 9.95153636e-02f, -3.05608958e-01f, 1.72243044e-01f,
  -3.06947529e-01f, -1.49566874e-01f, -3.34350914e-02f, -1.43896624e-01f, 1.34836867e-01f, 1.46115735e-01f, -5.23738191e-02f, 1.52657079e-02f, 4.02151942e-02f, -2.96651907e-02f,
  2.13554054e-02f, -1.26391128e-01f, -3.31449024e-02f, -7.02195913e-02f, 7.28330910e-02f, -7.42319748e-02f, -9.30475295e-02f, 1.68184623e-01f, -5.78465834e-02f, 2.21600443e-01f,
  -6.89528361e-02f, -1.12732135e-01f, 2.72467285e-02f, -1.70839112e-02f, -1.35866493e-01f, 2.16292173e-01f, 1.51421577e-01f, 1.01577967e-01f, 1.68849468e-01f, -1.69353485e-02f,
  1.25035550e-02f, -1.46592408e-01f, -1.66720986e-01f, -2.22628564e-02f, -2.49046847e-01f, 3.45980711e-02f, 1.93982437e-01f, -1.37165964e-01f, -1.12972029e-01f, -1.49641365e-01f,
  -2.99098969e-01f, 2.65902504e-02f, -1.78615227e-01f, 2.21500352e-01f, 5.89733198e-02f, 1.44776076e-01f, -3.11409850e-02f, -1.13006778e-01f, 3.00277285e-02f, 8.43906775e-03f,
  -1.54975653e-01f, -2.64140844e-01f, -3.07954960e-02f, 1.46773532e-01f, 4.59849574e-02f, -2.70221204e-01f, -1.28823236e-01f, -4.47098799e-02f, 1.66224763e-01f, 1.22662634e-01f,
  -4.33217585e-02f, 1.70878187e-01f, 1.54505759e-01f, 2.26775616e-01f, -2.00726554e-01f, -5.54234497e-02f, 3.46730016e-02f, -1.85781084e-02f, 5.60958013e-02f, 1.84374318e-01f,
  7.26771504e-02f, 9.99315083e-03f, -2.10365392e-02f, 1.15612313e-01f, -4.58142310e-02f, -5.29541336e-02f, -1.06677383e-01f, -5.29526658e-02f, 4.93957959e-02f, -6.40436113e-02f,
  -1.80708259e-01f, -6.21901453e-02f, 1.00104744e-02f, -7.26695731e-02f, -9.47682336e-02f, -1.53665632e-01f, 4.26306799e-02f, 9.07772556e-02f, -1.64711382e-02f, -7.26399273e-02f,
  1.10479280e-01f, 1.28646255e-01f, 5.06295599e-02f, 7.85131007e-02f, -1.06794968e-01f, -5.83009459e-02f, -1.34799689e-01f, 1.75287530e-01f, 1.38661098e-02f, 7.60551542e-02f,
  3.50146629e-02f, 1.47427227e-02f, 1.92942955e-02f, -1.29856870e-01f, -1.83297750e-02f, -2.74058264e-02f, -1.22083984e-01f, -1.18059956e-01f, -4.36402112e-02f, 1.79786503e-01f,
  7.68022463e-02f, -2.25812458e-02f, -4.81572822e-02f, -1.16150305e-01f, 1.80751294e-01f, -1.29328549e-01f, -1.80610761e-01f, 2.29756925e-02f, 1.55080155e-01f, 3.20501253e-02f,
  2.24511787e-01f, -1.16091833e-01f, 1.64242074e-01f, -8.81106257e-02f, 1.54629588e-01f, 1.40318155e-01f, -2.05641299e-01f, 1.22048385e-01f, -8.37800801e-02f, 1.96198642e-01f,
  6.21616691e-02f, 2.76274178e-02f, 9.44857225e-02f, 9.88747925e-03f, 3.24872769e-02f, 3.07837036e-02f, 1.58947110e-01f, -7.20737576e-02f, -5.73124252e-02f, 2.03737989e-02f,
  -1.51911899e-01f, 2.52408697e-03f, -9.60799754e-02f, -1.60632879e-02f, 4.37642969e-02f, 1.17143601e-01f, -7.00847618e-03f, 4.97437902e-02f, -1.32935224e-02f, 6.16714582e-02f,
  -6.48236945e-02f, -1.72906205e-01f, 1.52643427e-01f, 1.66177586e-01f, 9.29897651e-03f, 2.08252892e-01f, 1.54962853e-01f, -1.66274086e-01f, 1.49763348e-02f, -1.16300017e-01f,
  -1.52795911e-01f, -4.76192981e-02f, -1.18941523e-01f, -3.81354466e-02f, 4.33430485e-02f, -1.65645462e-02f, 3.16508003e-02f, -2.88195312e-01f, -1.30623490e-01f, 3.72280702e-02f,
  -5.23711368e-02f, -7.28068128e-03f, 2.97346041e-02f, 6.66293204e-02f, 5.07717952e-02f, 7.52488896e-03f, -1.04668319e-01f, -1.25744835e-01f, 1.71775326e-01f, -1.92835093e-01f,
  -1.80081688e-02f, 1.09424844e-01f, 2.07221434e-01f, -1.19477607e-01f, -4.03728001e-02f, 2.57536620e-02f, 1.82537641e-02f, -1.38261050e-01f, -4.16887775e-02f, 8.39033723e-02f,
  -2.17276067e-01f, 1.12522334e-01f, 7.74141327e-02f, 8.24443400e-02f, -8.71181339e-02f, 1.87492073e-02f, 5.49359769e-02f, 2.26296380e-01f, 1.37545362e-01f, -4.60628904e-02f,
  7.50688836e-02f, 9.24525689e-03f, -5.83691336e-02f, -7.91654065e-02f, -2.76186373e-02f, 2.92068943e-02f, 1.38963684e-02f, -2.13101804e-02f, 1.10433407e-01f, 1.95791107e-02f,
  8.14785808e-02f, 1.70244008e-01f, -6.11389615e-02f, -1.11761898e-01f, -5.79281896e-02f, 6.93277940e-02f, -4.34995443e-02f, 1.35615602e-01f, -1.39052913e-01f, 1.52888060e-01f,
  2.16900468e-01f, -1.84385493e-01f, -8.41600746e-02f, -2.14128286e-01f, 1.46554008e-01f, 6.07676879e-02f, -1.01000533e-01f, 2.03057170e-01f, 2.96376795e-02f, -5.61677068e-02f,
  1.17998458e-01f, 1.30065698e-02f, -2.26231053e-01f, -3.57228629e-02f, -2.49948725e-01f, 1.33053124e-01f, 1.47617623e-01f, 1.05885558e-01f, 8.79508704e-02f, 9.76721346e-02f,
  -2.04420522e-01f, -2.50037014e-02f, 1.34572282e-01f, -2.40967363e-01f, -3.01940311e-02f, -3.67914140e-02f, -1.75377697e-01f, 1.24098221e-02f, -6.47206232e-03f, -1.40205964e-01f,
  -2.29859963e-01f, 9.19901654e-02f, 5.78812975e-03f, 1.27659123e-02f, -1.83735117e-01f, 9.83602479e-02f, -3.20172720e-02f, 7.51674622e-02f, -6.91381320e-02f, -2.67658494e-02f,
  -2.19024435e-01f, 2.12220028e-01f, -1.02183439e-01f, -5.35361059e-02f, -1.50764346e-01f, 8.55973065e-02f, 9.68368724e-02f, -2.49351133e-02f, 6.64520711e-02f, 1.54696843e-02f,
  2.39885282e-02f, 1.03120901e-01f, -5.55548165e-03f, 9.44582075e-02f, -3.40484418e-02f, -1.19182140e-01f, -6.86134994e-02f, 7.92617202e-02f, -1.13122828e-01f, 1.54269978e-01f,
  -8.05424750e-02f, -1.07342817e-01f, -1.13108933e-01f, -2.22934247e-03f, 9.60814394e-03f, 2.25646436e-01f, -2.61770207e-02f, -5.34075536e-02f, 5.43742515e-02f, -1.19856790e-01f,
  2.04473380e-02f, 1.12717293e-01f, 1.30569311e-02f, -5.54951876e-02f, 1.02609642e-01f, 1.59930766e-01f, 1.97910950e-01f, 1.56144768e-01f, -2.16480330e-01f, -9.81911179e-03f,
  2.60149956e-01f, -3.42978328e-01f, 8.98202807e-02f, 8.91104713e-02f, -6.64400160e-02f, 3.82999256e-02f, 1.89642817e-01f, 1.88356359e-02f, 8.85287300e-02f, -1.42779708e-01f,
  -1.05671018e-01f, 1.34799033e-01f, 9.77985635e-02f, 1.45622477e-01f, -1.43665716e-01f, -1.26069397e-01f, 5.16832769e-02f, -2.03118771e-01f, -8.70940909e-02f, -2.92634994e-01f,
  -1.50017500e-01f, 2.21872464e-01f, 5.09578316e-03f, -2.02517316e-01f, -2.58688748e-01f, 7.98091292e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.22306608e-01f, 4.04442400e-02f, 2.09493652e-01f, -1.24442801e-01f, 8.25003684e-02f, 1.72945917e-01f, 2.69992333e-02f, 2.06805989e-01f, 6.66872486e-02f, -1.98018655e-01f,
  5.84289730e-02f, 1.49610534e-01f, 2.73151785e-01f, 1.97569504e-02f, 6.73096348e-03f, 2.02757001e-01f, -1.46624949e-02f, -2.02229872e-01f, 2.64886856e-01f, -2.82205284e-01f,
  -3.82853672e-02f, 1.61991075e-01f, 6.20636605e-02f, -2.81927079e-01f, -4.48370315e-02f, 1.27555549e-01f, 2.39195883e-01f, -1.30687580e-02f, 2.78315157e-01f, -6.12164102e-02f,
  -9.99687519e-03f, 2.73186415e-01f, -3.55361998e-02f, 2.37048678e-02f, 8.51806626e-02f, 2.41642408e-02f, 2.01663256e-01f, 1.80051520e-01f, -3.85966785e-02f, 9.63676721e-02f,
  2.34867752e-01f, 2.95132965e-01f, -1.06575027e-01f, -2.42223665e-01f, 2.40087911e-01f, -3.33769508e-02f, -2.83409338e-02f, -2.46413410e-01f, 1.08411707e-01f, 3.04201171e-02f,
  -1.09344617e-01f, -1.20358951e-01f, 1.97845012e-01f, 6.02605566e-02f, 1.12986483e-01f, -2.11746514e-01f, -2.41991520e-01f, -1.91872820e-01f, 2.76214123e-01f, 2.45701566e-01f,
  -2.12966055e-01f, 3.32605004e-01f, 6.61302209e-02f, -7.87949413e-02f, 3.07366043e-01f, 1.45973131e-01f, 1.81500494e-01f, 2.52238542e-01f, 2.31858436e-02f, 1.03499763e-01f,
  1.95502132e-01f, 1.77971393e-01f, 1.77525431e-02f, 2.96827387e-02f, 4.23703305e-02f, 3.11271071e-01f, 2.12331548e-01f, 3.01304698e-01f, 1.83039736e-02f, 5.63440621e-02f,
  1.19176127e-01f, 1.92821294e-01f, 2.08016008e-01f, -1.31298192e-02f, -2.57049352e-01f, 4.34241332e-02f, 1.74705014e-01f, -2.51151681e-01f, -1.47101060e-01f, -7.02385306e-02f,
  2.18046948e-01f, 4.37001556e-01f, -1.08541474e-02f, 8.38263035e-02f, 6.91219643e-02f, 1.81583688e-02f, 1.74609631e-01f, -2.31316179e-01f, -1.71671420e-01f, 1.05495639e-02f,
  -7.73235261e-02f, -1.59494579e-01f, 3.90714258e-02f, 1.79832190e-01f, 1.24484569e-01f, 1.87873662e-01f, -1.86147019e-02f, 2.74733096e-01f, 2.30672061e-01f, 5.10816425e-02f,
  2.51635551e-01f, -4.70567644e-02f, -1.80722207e-01f, 2.34147102e-01f, 3.80728662e-01f, 1.75846368e-01f, -1.60081849e-01f, -5.69560379e-02f, 1.77363858e-01f, -2.59042997e-02f,
  -5.14653847e-02f, 3.93000245e-01f, 1.11229420e-01f, 1.32008567e-01f, 2.27267176e-01f, 1.00914054e-01f, 3.18036824e-02f, 1.11346528e-01f, 1.85648039e-01f, 2.21808821e-01f,
  2.21344128e-01f, 5.10964617e-02f, 2.13061020e-01f, 2.44782761e-01f, 2.70813078e-01f, 2.81349689e-01f, 2.20851883e-01f, 1.96204096e-01f, 1.61249220e-01f, -4.92843799e-02f,
  2.97703087e-01f, -4.79018921e-03f, 1.38557568e-01f, 2.64591485e-01f, 1.50005355e-01f, -1.08672669e-02f, 2.93647975e-01f, -2.33056262e-01f, 1.33422509e-01f, 6.76648272e-03f,
  -2.70216584e-01f, -1.83781072e-01f, 1.88843459e-01f, 2.01986313e-01f, 2.53956854e-01f, -8.09758157e-02f, 2.56365180e-01f, -2.53601104e-01f, -1.37765795e-01f, 2.73408979e-01f,
  -2.11708963e-01f, 5.94079047e-02f, 6.87314272e-02f, 4.09497246e-02f, 3.09624255e-01f, -5.91396987e-02f, -2.20612466e-01f, -2.83773039e-02f, -1.48495376e-01f, 1.32732481e-01f,
  2.92814344e-01f, 1.83135029e-02f, -1.29234418e-01f, 1.76038980e-01f, 3.13711911e-01f, -1.35203496e-01f, 4.60554548e-02f, 2.96145350e-01f, -2.31424451e-01f, -3.16840224e-02f,
  -1.37878835e-01f, 2.32140556e-01f, 7.38712102e-02f, -2.23295689e-02f, 2.67775327e-01f, -4.23434786e-02f, 2.55794168e-01f, -1.76652774e-01f, 7.81983435e-02f, 2.80962050e-01f,
  2.14447808e-02f, -1.54215157e-01f, 5.28906621e-02f, 1.75508246e-01f, 1.08147457e-01f, 1.29837915e-01f, 1.32336617e-01f, 1.88007474e-01f, 1.08931109e-01f, -9.34181828e-03f,
  2.07483977e-01f, 2.27930158e-01f, 8.76940191e-02f, -2.88896728e-02f, -2.84104850e-02f, -8.45751315e-02f, 1.64083779e-01f, 8.07938054e-02f, 1.49133384e-01f, 3.29440653e-01f,
  2.15220958e-01f, -3.07918042e-01f, -1.41486600e-01f, -3.41951638e-01f, -2.64591396e-01f, 4.46111053e-01f, 2.07530037e-01f, -5.84037527e-02f, -1.88298859e-02f, 2.19532058e-01f,
  1.64910540e-01f, 9.61891040e-02f, -1.22743100e-01f, 9.70080271e-02f, 2.93912679e-01f, 2.61288911e-01f, 1.92058578e-01f, 2.34080911e-01f, -5.16124852e-02f, -3.05094838e-01f,
  -1.58291701e-02f, -3.72275203e-01f, -2.24351864e-02f, -1.27139583e-01f, 1.36560634e-01f, 2.30248004e-01f, -2.40366742e-01f, 4.84860003e-01f, 1.72757700e-01f, 6.28068149e-02f,
  -1.66525811e-01f, 2.86827534e-01f, 2.93105394e-01f, 1.24429435e-01f, -8.19999129e-02f, 1.58941392e-02f, 2.41155326e-01f, -7.31531233e-02f, 1.42524645e-01f, -1.19654220e-02f,
  -2.87670642e-01f, -7.99559429e-02f, 3.45639706e-01f, -2.94900775e-01f, -2.14214191e-01f, -2.31938064e-01f, 1.18970849e-01f, 1.46620035e-01f, 1.77242815e-01f, 4.16516699e-02f,
  2.09112898e-01f, 9.03447270e-02f, 2.12354645e-01f, 3.54792550e-02f, 2.09773779e-01f, 2.01134607e-01f, 1.37481228e-01f, 1.61086246e-01f, 1.21669076e-01f, 6.39388636e-02f,
  2.93485105e-01f, 2.47053549e-01f, 1.97891131e-01f, 5.30133508e-02f, 2.60034651e-02f, -2.08734106e-02f, 1.43497705e-01f, -2.25649513e-02f, 2.36480590e-02f, 1.05376758e-01f,
  2.11074546e-01f, 3.13799858e-01f, 9.26942527e-02f, -3.28903794e-02f, 2.45576492e-03f, -1.49705768e-01f, 1.15091287e-01f, 1.73883647e-01f, 1.37207815e-02f, 2.71504670e-01f,
  3.45826000e-02f, -1.39641017e-01f, 2.60074377e-01f, 1.84144139e-01f, 3.92894464e-04f, -4.36030179e-02f, -1.58850536e-01f, -4.86924080e-03f, 1.67725563e-01f, 1.49172749e-02f,
  -1.91547319e-01f, 1.79377884e-01f, 7.35606700e-02f, 2.52431840e-01f, 1.60286218e-01f, 2.38469213e-01f, -1.99661508e-01f, -1.24362268e-01f, 1.54630587e-01f, 4.20297354e-01f,
  7.70067945e-02f, -1.58772338e-02f, 3.67034554e-01f, -8.10627416e-02f, 1.30926535e-01f, -1.74704760e-01f, -7.17814118e-02f, 3.94149989e-01f, 2.46257201e-01f, 1.80154257e-02f,
  9.29037780e-02f, 3.40132304e-02f, 1.27628297e-01f, 2.31925383e-01f, 1.27675906e-01f, 1.56119734e-01f, 1.34269714e-01f, 3.22675519e-02f, 2.23669574e-01f, 2.61260662e-02f,
  1.89979881e-01f, 2.84960330e-01f, 7.00014317e-03f, -1.98297407e-02f, 2.19576448e-01f, 1.12759955e-02f, 6.43700510e-02f, 1.24580719e-01f, 1.99051932e-01f, -7.97783658e-02f,
  -1.72555268e-01f, -1.80462867e-01f, -1.43882856e-01f, 1.43828914e-01f, -1.24082379e-01f, 4.28622775e-02f, 6.56780377e-02f, 2.82350481e-01f, -1.92851480e-02f, 2.38082647e-01f,
  -2.19316378e-01f, 3.42784896e-02f, 9.51014236e-02f, 5.67991398e-02f, -2.94643790e-02f, 5.40980697e-03f, 3.05754077e-02f, -2.97464371e-01f, -4.60274033e-02f, -1.50227413e-01f,
  -1.13121241e-01f, 6.55341670e-02f, 1.73301160e-01f, 3.90079498e-01f, 4.72162180e-02f, 3.69793028e-01f, 1.12516671e-01f, -1.12875476e-01f, -1.04194008e-01f, 1.12637565e-01f,
  2.26309091e-01f, 3.27268660e-01f, -1.55828729e-01f, 3.05762477e-02f, 1.34092465e-01f, -1.42063931e-01f, 7.08804503e-02f, -2.17673890e-02f, -1.34870499e-01f, 1.19535699e-01f,
  4.10978913e-01f, 3.35170738e-02f, -1.90614447e-01f, -1.11421891e-01f, 2.11299911e-01f, 1.55724496e-01f, 3.62243861e-01f, 4.59279530e-02f, 2.00546727e-01f, -4.61418815e-02f,
  1.47217408e-01f, 2.23120764e-01f, 7.31676212e-03f, 3.26489843e-02f, 2.52333730e-01f, 8.04192349e-02f, 2.95976341e-01f, 3.29202116e-02f, 7.93242678e-02f, 1.54988736e-01f,
  8.53196308e-02f, 5.34771197e-03f, 4.33210656e-02f, -1.26763612e-01f, -7.53461523e-03f, 1.47108331e-01f, 2.30264470e-01f, -9.41128358e-02f, -1.16207860e-01f, 2.77256388e-02f,
  4.05991860e-02f, 2.58620769e-01f, -2.27714196e-01f, -1.13629505e-01f, 3.67162228e-01f, 9.59199816e-02f, -7.99138993e-02f, 5.22255823e-02f, 2.50485599e-01f, 3.26395668e-02f,
  -8.94418284e-02f, 2.90375054e-02f, 2.35591471e-01f, -1.16267830e-01f, 8.49845633e-02f, 1.53252140e-01f, 8.65448117e-02f, -6.87492192e-02f, 3.19141150e-01f, -2.51352459e-01f,
  1.54692829e-01f, 5.07176248e-03f, 4.74606343e-02f, -8.56809020e-02f, 2.62281507e-01f, 1.25916647e-02f, -1.79978777e-02f, 1.58667415e-01f, 1.75666455e-02f, -1.23090871e-01f,
  1.55639112e-01f, -9.50134695e-02f, 2.34901115e-01f, 1.46102995e-01f, 1.04187384e-01f, 2.25229129e-01f, -5.24794087e-02f, -1.58069935e-03f, -7.39363283e-02f, 1.45401776e-01f,
  1.60539463e-01f, 5.69769628e-02f, 1.15450375e-01f, 1.29984409e-01f, 1.82971939e-01f, 7.74495304e-02f, 1.70353651e-01f, 5.97038195e-02f, 1.73538387e-01f, -9.87614915e-02f,
  7.55336415e-03f, -5.99972066e-03f, 1.79921120e-01f, 6.38663024e-02f, 1.63594469e-01f, 3.80831398e-02f, 1.59393966e-01f, -1.56842798e-01f, 3.36154640e-01f, -1.22349426e-01f,
  -3.37027490e-01f, 1.67662516e-01f, 2.96598136e-01f, 9.83975232e-02f, -8.73637721e-02f, -2.69554913e-01f, 2.42913276e-01f, -2.83126771e-01f, -8.54500905e-02f, -1.22617353e-02f,
  2.94627212e-02f, -1.81596186e-02f, 1.25016853e-01f, -5.29690124e-02f, 3.13940614e-01f, -1.23173177e-01f, 1.85398869e-02f, -6.33148104e-02f, 1.98816687e-01f, 1.00279868e-01f,
  -9.81764272e-02f, -2.08589822e-01f, 1.46837533e-01f, 2.31007025e-01f, -5.36303893e-02f, 4.67312157e-01f, 4.20819551e-01f, 1.27245430e-02f, -1.19321607e-01f, -2.33216673e-01f,
  2.83199012e-01f, -1.61376163e-01f, 3.41919422e-01f, 2.83471882e-01f, -1.29562750e-01f, -1.02814566e-02f, 2.20225558e-01f, -5.73079623e-02f, -1.58218294e-01f, 1.51617071e-02f,
  2.48771712e-01f, -1.88399032e-01f, -5.95713370e-02f, -1.58276379e-01f, 9.51850042e-02f, 1.48679376e-01f, 2.58723170e-01f, -1.31035119e-01f, 1.54223377e-02f, -1.86366156e-01f,
  9.45892464e-03f, -3.09238255e-01f, -2.43854504e-02f, 2.48068631e-01f, 1.32028535e-01f, 1.97467536e-01f, 2.57353872e-01f, -1.55949801e-01f, 1.20810769e-01f, -2.99412385e-02f,
  -1.41750872e-01f, -2.91550392e-03f, 1.50151342e-01f, -3.72817032e-02f, 2.73276299e-01f, -5.73738962e-02f, 2.84158260e-01f, 1.61758393e-01f, 1.42866984e-01f, 1.67596847e-01f,
  -1.27023414e-01f, 4.69918549e-02f, -3.22828218e-02f, 1.05275720e-01f, -8.24072883e-02f, -4.02680747e-02f, -2.63824701e-01f, -9.43240970e-02f, -3.55585158e-01f, 2.26224825e-01f,
  -3.33999991e-01f, 2.80567229e-01f, 3.13769989e-02f, -1.66274235e-01f, -2.70686626e-01f, 6.11513890e-02f, -1.83718577e-01f, -1.35222197e-01f, -2.19234779e-01f, 2.62706261e-02f,
  -3.35122287e-01f, -1.70348421e-01f, -7.83920661e-03f, -2.34089300e-01f, 3.64056796e-01f, -2.17737015e-02f, -1.22695221e-02f, 8.65291804e-02f, -5.28689288e-02f, 2.55227983e-01f,
  1.08255185e-02f, 6.57368600e-02f, -1.80471346e-01f, 2.01249123e-01f, 1.04310535e-01f, 3.46504450e-02f, 1.32502690e-02f, 5.93715608e-02f, -3.57058505e-03f, 2.99458593e-01f,
  7.30834305e-02f, -4.41949703e-02f, 3.63243259e-02f, 2.01644346e-01f, 1.52098224e-01f, -7.26766288e-02f, -5.00308536e-02f, 2.18284920e-01f, 1.27335966e-01f, 1.04613617e-01f,
  1.53849065e-01f, -3.28307785e-02f, 2.34466761e-01f, 2.82874227e-01f, 1.59213245e-01f, 9.53142941e-02f, 1.66514501e-01f, -1.70058191e-01f, -1.36880446e-02f, -1.50780737e-01f,
  -2.72719920e-01f, -2.75211185e-01f, -1.96886316e-01f, 8.79405737e-02f, -1.57667622e-01f, 2.35430580e-02f, -3.79717298e-04f, -2.03073815e-01f, 3.50919589e-02f, -2.01095015e-01f,
  -1.62008733e-01f, 7.29089603e-02f, -1.96494758e-01f, -1.16368242e-01f, -1.40820161e-01f, 2.09328130e-01f, 3.19863319e-01f, 1.53444067e-01f, -2.39094704e-01f, 1.40931174e-01f,
  1.28175333e-01f, 5.84056042e-02f, -2.24521950e-01f, 1.27808362e-01f, 5.49409948e-02f, -9.43009630e-02f, 2.92736471e-01f, 4.25193496e-02f, 3.06114703e-01f, -1.82629243e-01f,
  2.06608519e-01f, 2.61654049e-01f, -2.84679800e-01f, 4.31083173e-01f, -6.58144206e-02f, 2.76714742e-01f, 3.36540669e-01f, 1.04233123e-01f, 1.50747702e-01f, 4.34183702e-02f,
  -5.79497255e-02f, -4.12308834e-02f, -1.41464733e-02f, 1.50740698e-01f, 1.74033001e-01f, -2.78894845e-02f, -5.19204475e-02f, 9.32841077e-02f, 1.31961063e-01f, -2.76198804e-01f,
  -1.42840734e-02f, 8.64291117e-02f, 1.29509151e-01f, -1.88132946e-03f, -5.09869382e-02f, -6.94037229e-02f, 2.26654634e-01f, -2.32676342e-02f, -2.23141406e-02f, 9.55221802e-02f,
  -5.93758048e-03f, -6.93553239e-02f, 8.00589845e-02f, -6.47231638e-02f, -1.97796434e-01f, -1.03325039e-01f, -4.11032625e-02f, 3.04563195e-02f, -3.32625210e-02f, 1.10336460e-01f,
  -1.66038588e-01f, 4.50070128e-02f, 1.42090991e-02f, -1.51907459e-01f, -3.43616813e-01f, -8.41122568e-02f, -1.67243138e-01f, 1.73478425e-01f, -2.27598865e-02f, 3.49159122e-01f,
  4.77553010e-01f, 1.82826966e-01f, -2.52987802e-01f, 5.71611105e-03f, 2.33470544e-01f, -3.10053001e-03f, -1.58181623e-01f, 9.94865000e-02f, -2.85387933e-01f, -1.93185005e-02f,
  3.63750346e-02f, 1.87264867e-02f, 1.22320615e-01f, -1.99140497e-02f, 4.92616028e-01f, 2.17163101e-01f, -1.04477793e-01f, 3.90863597e-01f, -8.68354663e-02f, 2.54113346e-01f,
  2.90071338e-01f, 9.77634937e-02f, 1.67701561e-02f, 9.08048376e-02f, 1.40157819e-01f, 7.06146881e-02f, 2.77874053e-01f, 2.24612519e-01f, 2.44325027e-01f, 1.44211411e-01f,
  1.82322189e-01f, 6.10214695e-02f, 1.54487016e-02f, 1.18658975e-01f, 2.88917959e-01f, 2.24895582e-01f, 1.16114624e-01f, 2.59289742e-01f, 1.36845827e-01f, 2.02836446e-03f,
  4.78084758e-02f, 1.22883543e-01f, 1.03458889e-01f, 2.51726806e-01f, -8.40636250e-03f, 2.67161787e-01f, 3.38876545e-01f, -1.20374382e-01f, 2.87795290e-02f, 2.53895074e-02f,
  -1.85535531e-02f, 2.02201396e-01f, -3.10028702e-01f, -1.16309859e-01f, 3.13193053e-01f, -3.13333608e-02f, -1.58300772e-01f, -1.70528054e-01f, -3.04080576e-01f, -2.45554969e-01f,
  -1.11526839e-01f, 2.97255814e-01f, 1.04616612e-01f, 3.61681581e-01f, 2.50917748e-02f, 1.59684271e-01f, 1.29265130e-01f, 1.61143422e-01f, -6.52093664e-02f, -6.16737865e-02f,
  -1.10962808e-01f, 7.71129131e-02f, -1.13929138e-01f, -1.46452770e-01f, 2.08334923e-01f, -4.65404987e-02f, 1.71773985e-01f, 3.15624356e-01f, -1.47456199e-01f, 3.23848724e-02f,
  6.88737705e-02f, 1.02561370e-01f, 1.34496659e-01f, -1.82876736e-01f, 8.52614418e-02f, 4.07801032e-01f, 2.22083941e-01f, 1.34421378e-01f, 1.28302038e-01f, 1.06331289e-01f,
  2.35103354e-01f, 1.63225099e-01f, 2.43913621e-01f, 1.61744341e-01f, 1.55340508e-01f, -4.96201515e-02f, 1.45808369e-01f, 6.93592057e-02f, 2.98750281e-01f, 1.41544759e-01f,
  2.70225823e-01f, 2.54077166e-01f, 2.36423686e-01f, 1.07153118e-01f, 1.22942634e-01f, -9.46032442e-03f, 1.00707762e-01f, 9.75755751e-02f, 6.51930794e-02f, 1.95671231e-01f,
  2.72559345e-01f, 5.46307601e-02f, 9.17543247e-02f, -5.94564974e-02f, -3.63426879e-02f, -2.15858266e-01f, -1.26251429e-01f, -2.63857991e-02f, 3.74222845e-01f, -1.63529277e-01f,
  1.50182530e-01f, 2.54462928e-01f, 2.55435724e-02f, -3.11271548e-02f, -2.87702054e-01f, 2.74801493e-01f, 3.30133647e-01f, 2.04474792e-01f, 1.72499925e-01f, 1.35118544e-01f,
  1.19967438e-01f, -1.70600399e-01f, 1.32397279e-01f, -3.06525201e-01f, -1.73080474e-01f, 2.23007023e-01f, 1.24201234e-02f, -2.96220869e-01f, 7.35363662e-02f, -7.14150518e-02f,
  2.57451326e-01f, 3.24160725e-01f, 1.67962408e-03f, -2.53059492e-02f, 2.94792913e-02f, 1.09767452e-01f, 1.14688203e-01f, 2.23856643e-01f, -5.14951423e-02f, 7.38151073e-02f,
  1.42719492e-01f, 3.16926956e-01f, 2.33420208e-02f, 1.27195820e-01f, -3.09144482e-02f, 2.37865463e-01f, 9.17775184e-02f, -1.10012226e-01f, 1.87278330e-01f, 1.69834092e-01f,
  1.07666872e-01f, 1.56124979e-01f, 1.58430621e-01f, 1.96444109e-01f, -3.89962755e-02f, 1.38802469e-01f, 1.29135204e-02f, -6.54719025e-02f, 8.29464272e-02f, 1.19210280e-01f,
  2.00237885e-01f, -1.72579680e-02f, -1.55879304e-01f, 1.32493764e-01f, 9.21199024e-02f, 8.61025900e-02f, -2.52913952e-01f, -1.15138665e-01f, -1.74320057e-01f, 1.33794412e-01f,
  -7.85062611e-02f, 2.35690355e-01f, 8.73983204e-02f, -2.78852314e-01f, 2.57227063e-01f, -2.67875969e-01f, 2.00841531e-01f, 1.92700952e-01f, -1.21177882e-01f, -1.75827563e-01f,
  2.55793273e-01f, 5.81672676e-02f, 2.60551840e-01f, -1.49527967e-01f, -1.42588705e-01f, 5.86894378e-02f, 3.36116664e-02f, 3.18195932e-02f, -7.35028386e-02f, -1.82238165e-02f,
  -2.06357166e-02f, 3.42982449e-02f, 2.70115018e-01f, -9.79853421e-02f, 4.62417677e-02f, -3.26043516e-01f, 9.09682065e-02f, 1.85043752e-01f, -2.67704219e-01f, 4.39424999e-02f,
  -1.43493950e-01f, 1.51589647e-01f, 9.27247852e-02f, -3.21294576e-01f, -1.66042864e-01f, 2.53085703e-01f, 3.15991491e-02f, -3.02882312e-04f, -2.09555402e-01f, -7.57654160e-02f,
  7.36762881e-02f, 2.08301991e-01f, 6.69033527e-02f, -2.81544048e-02f, -6.09080540e-03f, 2.86795229e-01f, -1.13939859e-01f, -1.05462268e-01f, -2.37452790e-01f, 9.39858705e-02f,
  6.16477802e-02f, 7.84679800e-02f, 1.63766742e-01f, 6.00693040e-02f, 3.81529145e-03f, 3.03935081e-01f, 9.00456496e-03f, 1.60040140e-01f, 8.47865082e-03f, 2.65185535e-01f,
  1.80863738e-01f, 1.36671633e-01f, -3.39241207e-01f, -4.39059287e-01f, -1.61877833e-02f, -1.46335557e-01f, 3.41185570e-01f, -2.99558222e-01f, -2.55118370e-01f, 1.17315568e-01f,
  1.31043985e-01f, 1.14259683e-01f, -1.77207831e-02f, 1.88623086e-01f, 2.65428603e-01f, -8.64845514e-02f, -2.28207901e-01f, 2.55027525e-02f, 1.56365409e-01f, -1.84772126e-02f,
  -1.67953316e-02f, -3.09607357e-01f, -2.86320657e-01f, 4.25995171e-01f, 3.55529398e-01f, -4.25350040e-01f, -3.60506147e-01f, -6.25345558e-02f, 1.14665009e-01f, 1.03310302e-01f,
  -2.16537371e-01f, 5.42189479e-02f, 2.65603900e-01f, -1.17469691e-01f, -1.78859934e-01f, -1.00440402e-02f, -4.86407280e-01f, -1.59606308e-01f, 9.35286060e-02f, 2.33293504e-01f,
  4.61314581e-02f, 1.06057189e-01f, 1.60782784e-01f, -6.48699626e-02f, 2.53538992e-02f, 4.62054312e-02f, 2.21859023e-01f, 2.53614574e-03f, -4.85623372e-04f, -5.82984537e-02f,
  2.00564656e-02f, 3.30239013e-02f, 2.13620588e-01f, 7.81615824e-02f, 2.11682394e-01f, 1.42670512e-01f, 2.09730551e-01f, 1.80851147e-01f, 6.68779537e-02f, -2.00219080e-01f,
  1.70366824e-01f, -2.14514494e-01f, -1.08421706e-01f, -8.91736001e-02f, 8.71472433e-02f, 1.61124572e-01f, 1.29225060e-01f, -1.73113421e-01f, 1.13019630e-01f, -3.37761164e-01f,
  -1.98021933e-01f, 7.53147453e-02f, -3.90445851e-02f, -5.61978966e-02f, -7.21879229e-02f, -2.40109473e-01f, 2.14316383e-01f, 2.24647000e-01f, -3.00358355e-01f, 1.15921609e-01f,
  -3.06592844e-02f, 1.40611559e-01f, -2.55876273e-01f, -1.52462512e-01f, -1.40232116e-01f, 4.12760004e-02f, -2.72153039e-02f, 2.95023531e-01f, 2.76960880e-01f, 2.84743961e-02f,
  -1.33082986e-01f, -3.42805684e-01f, 3.08052480e-01f, 1.03051320e-01f, 1.54271349e-01f, 2.25156352e-01f, -1.32101536e-01f, 2.67604411e-01f, 2.40506664e-01f, -1.02569431e-01f,
  -8.19634721e-02f, 3.69038135e-01f, 2.06708357e-01f, -4.21772711e-02f, 3.81958000e-02f, 1.43696532e-01f, -5.26204742e-02f, 3.00140768e-01f, 2.51512200e-01f, -1.80443898e-02f,
  2.34243572e-01f, 2.33911142e-01f, 2.55857140e-01f, 1.63038999e-01f, 7.65647814e-02f, 5.76067604e-02f, 1.78348079e-01f, 1.40654415e-01f, 2.93651402e-01f, 1.55861810e-01f,
  2.64513612e-01f, 3.80575061e-01f, 6.40940964e-02f, 1.23688363e-01f, -1.00167967e-01f, -2.32126936e-01f, -9.62697268e-02f, 1.92708507e-01f, -1.25247821e-01f, -3.74895446e-02f,
  -1.55290395e-01f, 2.09191024e-01f, -1.30089477e-01f, 2.24743932e-02f, -1.51604503e-01f, -1.74913153e-01f, 3.76897693e-01f, -4.59858924e-02f, 2.62504420e-03f, -1.15728818e-01f,
  -2.13559642e-01f, -2.52460957e-01f, 7.83961117e-02f, 5.41505739e-02f, -8.60563293e-02f, -8.51183161e-02f, 5.55627681e-02f, 1.58965379e-01f, -1.89073190e-01f, 3.44241768e-01f,
  3.46712880e-02f, 1.79771170e-01f, -1.67609617e-01f, 2.72870243e-01f, 1.88514695e-01f, 9.42495018e-02f, -1.35323584e-01f, -2.24906355e-01f, 3.22317630e-01f, 2.21254051e-01f,
  -2.39794180e-01f, 3.13014507e-01f, -1.80036619e-01f, -5.25740385e-02f, 3.94989103e-01f, -1.48374394e-01f, -5.73008917e-02f, 9.12511572e-02f, -1.24161005e-01f, -1.35667071e-01f,
  -1.35430887e-01f, -1.42526984e-01f, -3.59071121e-02f, -9.15707741e-03f, -1.23027805e-02f, -5.44875953e-03f, -1.46163418e-03f, -6.24802299e-02f, 3.51058552e-03f, -1.77032262e-01f,
  -3.49281356e-02f, -1.69711933e-01f, 2.90149283e-02f, -2.09841564e-01f, -1.74210742e-01f, -7.81815127e-02f, -2.04695672e-01f, -7.37588555e-02f, -4.46778052e-02f, -7.60657936e-02f,
  3.18918899e-02f, 4.71269265e-02f, 6.21808693e-02f, 1.31947305e-02f, 3.24334912e-02f, 8.50122701e-03f, 3.35054062e-02f, -3.08020767e-02f, 1.94348190e-02f, -1.04568854e-01f,
  -1.62528921e-02f, 1.35283485e-01f, -1.04258746e-01f, -8.51353779e-02f, 6.28483994e-03f, 1.07374333e-01f, -1.36201218e-01f, 8.05299506e-02f, 1.18704021e-01f, -8.43936726e-02f,
  -1.40544772e-01f, -1.48406073e-01f, 2.50412971e-02f, 8.37188959e-02f, -1.38225749e-01f, 1.04398783e-02f, -2.75332510e-01f, -1.24666132e-01f, -2.95236353e-02f, 8.29909742e-02f,
  -8.50276724e-02f, 1.30371423e-02f, 6.23611622e-02f, -1.21621512e-01f, 1.22689288e-02f, 1.19519524e-01f, 4.71917505e-04f, -5.32045141e-02f, -5.10703027e-03f, -1.15449667e-01f,
  -5.45561723e-02f, 3.66512053e-02f, 2.74569273e-01f, 1.08403392e-01f, 2.51634091e-01f, 1.59869403e-01f, 4.61571515e-02f, 1.45706475e-01f, 1.70060888e-01f, 7.89217278e-02f,
  1.85744837e-01f, 6.17728643e-02f, 1.09681591e-01f, 2.12218598e-01f, 7.84383342e-02f, 1.18315533e-01f, 7.26601481e-02f, 4.45003994e-02f, 1.37100399e-01f, 1.21619195e-01f,
  1.58499971e-01f, 6.46714717e-02f, -2.24540710e-01f, 2.80618042e-01f, 8.62201452e-02f, 3.08384150e-02f, -7.67346751e-03f, 1.17332831e-01f, -2.51000058e-02f, -2.31134724e-02f,
  -9.08021405e-02f, 1.25202715e-01f, 1.51187301e-01f, -7.74243549e-02f, -7.32176602e-02f, 1.71070248e-01f, 2.35537723e-01f, 1.31090954e-01f, 4.57545854e-02f, -2.48713866e-02f,
  2.54013330e-01f, -1.69246539e-01f, -2.01535493e-01f, 2.47165799e-01f, 3.56440037e-01f, 3.07546020e-01f, 2.63022184e-01f, 1.00038894e-01f, 2.84790397e-01f, -1.55255660e-01f,
  -6.08809665e-02f, 9.91323218e-02f, 5.02227210e-02f, 1.86824590e-01f, -2.26651467e-02f, 1.36653811e-01f, -1.84340104e-01f, -2.03926906e-01f, 2.75855511e-01f, -2.79655755e-01f,
  1.94384724e-01f, 6.41046986e-02f, 1.25856906e-01f, 1.24182999e-01f, -8.31400231e-02f, 1.36319309e-01f, 2.80113071e-01f, 1.50713384e-01f, 7.89910480e-02f, 1.94215670e-01f,
  6.67476282e-02f, 4.48664427e-02f, 1.43700287e-01f, -1.32136149e-02f, 1.69311121e-01f, 2.53258169e-01f, 2.18501613e-01f, 1.50581092e-01f, 1.69861659e-01f, 7.06260800e-02f,
  4.99431677e-02f, 2.81232625e-01f, 1.40376672e-01f, 1.56183302e-01f, 1.21485747e-01f, 2.26760447e-01f, -7.46787935e-02f, 2.14731172e-01f, 2.21711248e-01f, 4.14120369e-02f,
  -8.24238881e-02f, 1.20876990e-01f, -9.71026123e-02f, -5.01102321e-02f, -1.11101292e-01f, 1.57271519e-01f, 2.86314338e-01f, 3.45707275e-02f, -1.96023643e-01f, 1.66732341e-01f,
  -2.51519084e-02f, 1.58835441e-01f, 1.32211614e-02f, 1.19169608e-01f, 3.66965085e-01f, -1.57003418e-01f, -1.62285134e-01f, -1.63354333e-02f, 4.13760126e-01f, 9.48114172e-02f,
  -6.61616400e-02f, -1.48061544e-01f, 2.09646821e-01f, -7.28875622e-02f, -1.62494466e-01f, 2.14258190e-02f, -1.25812784e-01f, 2.37122864e-01f, -2.27871567e-01f, 2.61628032e-01f,
  -4.22966063e-01f, -2.19162509e-01f, 3.67149711e-01f, -3.26215923e-02f, -7.63006285e-02f, -6.73513710e-02f, 7.60601535e-02f, 1.48090020e-01f, -2.70804703e-01f, 1.09405722e-02f,
  7.76002705e-02f, 4.93653417e-02f, 8.81154835e-02f, 3.46100554e-02f, 8.36871285e-03f, -7.15965331e-02f, 5.15267551e-02f, 1.40770316e-01f, 1.05917543e-01f, -8.10177624e-02f,
  -1.23854503e-02f, 6.61086589e-02f, 3.86829898e-02f, 1.35990694e-01f, 1.32090241e-01f, 5.99336587e-02f, -1.78356655e-02f, 1.84888825e-01f, 4.35775705e-02f, -3.47746283e-01f,
  -7.11992756e-02f, 6.59756809e-02f, 1.20288864e-01f, -9.52283591e-02f, -9.18239951e-02f, -1.58161238e-01f, 5.66145778e-02f, 3.20088267e-01f, 1.78443462e-01f, 1.19255139e-02f,
  -5.40031679e-02f, -6.59011444e-03f, 1.44623190e-01f, 2.30875462e-01f, 1.99367419e-01f, 7.65389204e-03f, -2.64510419e-02f, -3.26315254e-01f, 4.90838401e-02f, -1.08525082e-01f,
  2.59826154e-01f, 2.86780000e-01f, -1.49348155e-01f, -8.10827315e-02f, 3.75218451e-01f, 3.93044278e-02f, -2.13938206e-01f, -9.26737413e-02f, 5.99014685e-02f, 3.80123295e-02f,
  4.14341807e-01f, 9.74093378e-02f, 7.01159388e-02f, 3.78429703e-02f, 1.51267424e-01f, -4.46479693e-02f, -3.91132951e-01f, -9.87446308e-02f, 4.54556011e-03f, 1.81658581e-01f,
  3.06512415e-01f, 4.70679030e-02f, 9.82429534e-02f, 1.09050475e-01f, 1.73729911e-01f, 2.00694352e-01f, 2.66998023e-01f, 1.02329165e-01f, 1.77569777e-01f, 4.62047011e-02f,
  2.48012021e-02f, 1.98610187e-01f, 3.59895229e-02f, 3.77761453e-01f, 1.00312203e-01f, 2.08008081e-01f, -3.57902842e-03f, 2.50487804e-01f, 7.53713101e-02f, 1.51828185e-01f,
  1.25471085e-01f, 1.48540765e-01f, 2.11204767e-01f, 3.85379434e-01f, -1.17445365e-01f, 2.48204082e-01f, 1.30705640e-01f, 1.32801399e-01f, -2.98363656e-01f, -1.57769501e-01f,
  -1.10438429e-01f, -1.22826872e-02f, -3.35833371e-01f, 1.52844146e-01f, 1.29310384e-01f, -1.95168257e-01f, -1.61191393e-02f, -2.84786671e-01f, -7.61452988e-02f, 8.37831721e-02f,
  -2.81272978e-01f, 1.09292954e-01f, 3.65474373e-01f, 2.12915525e-01f, -4.86058816e-02f, 8.60899240e-02f, 1.83756664e-01f, 1.96987897e-01f, -1.03301734e-01f, -2.20209330e-01f,
  7.70222247e-02f, 2.07378808e-03f, 5.63803203e-02f, 1.77655771e-01f, 2.82923249e-03f, 2.75299717e-02f, 1.98119762e-03f, -7.47902766e-02f, -3.54815900e-01f, 2.05037758e-01f,
  6.20806254e-02f, 7.17433766e-02f, -3.28737721e-02f, -2.24139512e-01f, 4.93161306e-02f, 5.99280372e-02f, -1.05739556e-01f, 1.96398899e-01f, 2.65218824e-01f, 1.29851103e-01f,
  1.32785067e-01f, 5.92098720e-02f, 1.33773237e-01f, 2.08450928e-01f, 2.27419630e-01f, -3.30935866e-02f, 2.74377972e-01f, 2.73426145e-01f, 1.50015190e-01f, -5.65795088e-03f,
  1.67473510e-01f, 7.19965622e-02f, 1.80160657e-01f, 2.96238482e-01f, 1.29890934e-01f, 2.04769865e-01f, 7.58947730e-02f, -1.54242134e-02f, 1.42753720e-01f, 1.43984169e-01f,
  -3.23234033e-03f, 8.73533785e-02f, 7.52807036e-02f, 2.97036976e-01f, -2.68720537e-01f, -3.37761402e-01f, -4.58318889e-02f, -1.62659064e-01f, 1.00731015e-01f, -1.47600234e-01f,
  -1.02042280e-01f, 1.87966317e-01f, 2.16836393e-01f, 1.70442805e-01f, 1.01284698e-01f, 1.46678507e-01f, 3.66970062e-01f, -5.23323156e-02f, -2.68236339e-01f, -1.77922659e-02f,
  1.58464864e-01f, -2.73871310e-02f, -7.09922612e-02f, -7.86910281e-02f, -9.22529399e-02f, 2.12656975e-01f, 2.94221520e-01f, 3.12104095e-02f, -1.58763349e-01f, -1.35736614e-01f,
  3.18048120e-01f, 1.98431090e-01f, 8.00096244e-02f, 1.08587235e-01f, 2.23211408e-01f, -2.37530783e-01f, 1.10898353e-01f, -5.57754114e-02f, -2.05653459e-01f, 3.55761722e-02f,
  1.40374541e-01f, 2.95796841e-02f, 1.44629747e-01f, 1.72937214e-01f, 3.34941931e-02f, 6.40474483e-02f, 2.09582299e-01f, 2.46101152e-02f, 1.32337049e-01f, -1.39447534e-02f,
  1.49822593e-01f, 8.96985456e-02f, 3.02715786e-02f, 1.36844873e-01f, -7.30813146e-02f, 1.43016040e-01f, 2.06831783e-01f, 9.81586054e-02f, 1.23748913e-01f, 1.49635240e-01f,
  1.17118783e-01f, 2.47390829e-02f, 2.00283319e-01f, 1.72393858e-01f, 7.07277358e-02f, 2.88971066e-01f, -3.49529348e-02f, 2.30021328e-02f, -3.59675646e-01f, -3.55888218e-01f,
  -2.38205314e-01f, 7.40414187e-02f, 2.73257643e-01f, -2.47157142e-01f, 1.01069463e-02f, -8.79833102e-02f, 1.60301670e-01f, 3.06791086e-02f, -8.21454749e-02f, 7.63704181e-02f,
  3.85522962e-01f, -1.28146529e-01f, -1.31697163e-01f, -1.80711187e-02f, -1.64879079e-03f, 2.93573979e-02f, 2.12142374e-02f, -6.58502206e-02f, -1.09670229e-01f, 3.44682068e-01f,
  1.24667831e-01f, -2.30418876e-01f, 1.72378328e-02f, -2.08696276e-01f, 2.61569917e-01f, -7.41879866e-02f, -8.30664411e-02f, 2.05050319e-01f, 8.78849775e-02f, -2.18799021e-02f,
  -1.00593016e-01f, -2.52205431e-01f, -3.64893861e-02f, -6.18627146e-02f, -2.58856229e-02f, 2.00182140e-01f, 2.48046845e-01f, 6.14202395e-02f, 2.50469334e-02f, 1.11255392e-01f,
  -5.58037795e-02f, 6.35193586e-02f, 7.87969008e-02f, 2.37918839e-01f, 1.49586886e-01f, 2.68023717e-03f, 1.68777406e-01f, 3.30556929e-01f, 8.84352718e-03f, 2.89186716e-01f,
  -2.17282623e-02f, -2.65964083e-02f, 2.95373481e-02f, 4.04489338e-02f, 1.04576752e-01f, -1.17664067e-02f, -3.07878673e-01f, 4.88671400e-02f, 1.86995238e-01f, -1.43307924e-01f,
  -3.34078819e-01f, -3.03221911e-01f, -2.08980843e-01f, 3.40514153e-01f, -2.52559036e-01f, 2.57635504e-01f, -2.61853752e-03f, -6.47014603e-02f, 2.28891954e-01f, -1.52927220e-01f,
  7.73282629e-03f, -1.02381691e-01f, -1.20712191e-01f, -2.45500088e-01f, 2.50034124e-01f, 1.79285929e-02f, 5.43487519e-02f, 9.55245420e-02f, -1.04287244e-01f, 1.04562052e-01f,
  3.06457818e-01f, -8.27005878e-03f, 2.11710744e-02f, -3.19920123e-01f, 2.94723175e-02f, 5.56363538e-03f, 3.36879760e-01f, 2.18499064e-01f, -2.55158961e-01f, -2.66618039e-02f,
  7.39068771e-03f, 1.05928153e-01f, -2.43895918e-01f, -2.90886350e-02f, 9.29748919e-03f, 1.46816924e-01f, 2.93621033e-01f, -7.26231337e-02f, -1.75016716e-01f, 2.43858442e-01f,
  8.88777450e-02f, 1.16202772e-01f, 5.27179576e-02f, 8.75839964e-02f, 1.94480747e-01f, 1.82938039e-01f, 1.42302051e-01f, -9.58195049e-03f, 3.52063170e-03f, -1.36202142e-01f,
  -1.91240702e-02f, 1.18501566e-01f, 1.46830931e-01f, 8.69246125e-02f, 2.31979668e-01f, -1.30493753e-02f, 1.12048887e-01f, 6.10660389e-02f, 1.60837874e-01f, -1.91659361e-01f,
  2.13070914e-01f, -5.99959455e-02f, -9.06948000e-02f, -8.75903443e-02f, 1.90472737e-01f, 1.01970904e-01f, 1.16118565e-01f, -1.90601915e-01f, -1.58367064e-02f, -1.24635741e-01f,
  -2.87518173e-01f, -8.62988532e-02f, -1.90170094e-01f, -2.62639612e-01f, -2.80575633e-01f, -1.82957619e-01f, 1.78663716e-01f, 3.19631845e-02f, -3.43230009e-01f, 3.25453699e-01f,
  2.01797530e-01f, -1.18937455e-01f, -3.14570457e-01f, -2.94663161e-01f, -5.76258637e-02f, 2.92366166e-02f, -3.33080180e-02f, 1.52006015e-01f, 2.36730590e-01f, 1.28399149e-01f,
  -3.93680260e-02f, -3.94963801e-01f, 3.80359292e-01f, -2.43133664e-01f, 1.39354793e-02f, 1.34905949e-01f, -3.53143752e-01f, 1.32838309e-01f, 1.57484114e-01f, -1.49411887e-01f,
  -1.95723698e-01f, 6.49818107e-02f, 2.42834613e-01f, -1.76680591e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.78525299e-01f, 2.67033666e-01f, 8.72867331e-02f, 1.27486005e-01f, 1.75606653e-01f, 1.33833557e-01f, 1.63345724e-01f, 2.26878554e-01f, -2.88689081e-02f, 1.59009233e-01f,
  1.07259110e-01f, 1.12981245e-01f, 1.54634804e-01f, 7.89069980e-02f, -4.72978912e-02f, 1.19227260e-01f, 1.29038692e-01f, -3.67261581e-02f, 1.68303713e-01f, 3.33752520e-02f,
  2.15577558e-01f, 2.25866169e-01f, 2.62767076e-01f, 6.34863926e-03f, 1.79573044e-01f, 7.59810358e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  5.94191030e-02f, -2.64869146e-02f, -7.58211911e-02f, 2.16021538e-02f, 5.38747422e-02f, -6.74535930e-02f, 7.76667893e-02f, 3.19117382e-02f, 1.71377569e-01f, -7.10451305e-02f,
  -7.03170970e-02f, -9.30015072e-02f, 2.60275719e-03f, 4.57818657e-02f, 2.49991223e-01f, -2.45551467e-02f, 1.36692002e-02f, 1.59964457e-01f, 4.06249352e-02f, 9.92657989e-02f,
  4.48507033e-02f, -7.09569454e-02f, -1.53057083e-01f, 1.20292185e-02f, 2.51966327e-01f, 1.64891049e-01f, -5.64898700e-02f, 1.74033627e-01f, -1.06577650e-01f, -9.43796709e-02f,
  -1.03905559e-01f, -1.39236569e-01f, -1.46321282e-01f, -7.73479119e-02f, -5.58803342e-02f, -1.63024157e-01f, 1.95984587e-01f, 1.23079285e-01f, 7.19020963e-02f, 7.84974694e-02f,
  -2.91816108e-02f, -1.40686005e-01f, 1.05606936e-01f, 1.77857596e-02f, 7.84997046e-02f, -3.54687981e-02f, 1.63930222e-01f, -2.36369744e-01f, -2.52649784e-01f, 8.34773406e-02f,
  5.95013723e-02f, 1.21290989e-01f, -1.12092800e-01f, -1.28891185e-01f, -1.07050963e-01f, -1.17997192e-02f, 1.94207743e-01f, 1.50910914e-01f, 7.23648742e-02f, 1.05221726e-01f,
  -3.30313183e-02f, -5.56668751e-02f, 1.20293394e-01f, -5.21740988e-02f, -8.56015161e-02f, 6.02504611e-02f, -1.87372059e-01f, 3.31577816e-04f, -5.92607558e-02f, -2.85559539e-02f,
  -3.41196060e-02f, 2.79939920e-02f, 1.13171846e-01f, 6.04473352e-02f, -1.26292398e-02f, 1.93038173e-02f, -1.39881521e-01f, -2.38680318e-02f, -2.21894793e-02f, -8.69749486e-02f,
  -6.15253299e-02f, -2.33773631e-03f, 1.37189195e-01f, -1.37841150e-01f, 3.58341523e-02f, 1.11658787e-02f, -1.43960059e-01f, -5.60596073e-03f, 1.75816372e-01f, -1.33726135e-01f,
  -9.77407321e-02f, 1.21272415e-01f, -9.44398716e-02f, 1.84671998e-01f, -1.69335842e-01f, -8.95444453e-02f, -1.32549539e-01f, -2.20852584e-01f, -1.45136580e-01f, -6.11116104e-02f,
  -9.51287672e-02f, 5.96164577e-02f, 8.72751996e-02f, 1.69813618e-01f, 7.68355057e-02f, 4.89081815e-02f, -9.60325077e-02f, 9.51879025e-02f, 4.99815084e-02f, -1.67164087e-01f,
  5.99359442e-03f, -1.40433898e-02f, -1.73225731e-01f, -6.56787455e-02f, -4.45845649e-02f, -1.62368035e-03f, -1.60344243e-01f, -3.31807025e-02f, 6.83999285e-02f, 1.10800028e-01f,
  -2.84951013e-02f, -3.26317176e-03f, 7.00276867e-02f, -7.74685889e-02f, -1.16987534e-01f, -1.93246976e-02f, 2.41382644e-01f, -2.25256812e-02f, -6.00102693e-02f, -1.49031812e-02f,
  -6.44923449e-02f, -3.02212592e-02f, -4.05702647e-03f, -1.66901588e-01f, -8.13452899e-02f, 9.64098796e-02f, 4.01500985e-02f, 2.81507261e-02f, 6.74435198e-02f, -1.48598254e-01f,
  1.03321575e-01f, 7.16061145e-02f, -1.26493871e-01f, -7.94757530e-03f, -2.33477801e-02f, 3.56113277e-02f, 4.92264144e-03f, -1.99803278e-01f, -3.58240418e-02f, 6.15357310e-02f,
  9.37530100e-02f, -1.33604124e-01f, 1.64733723e-01f, -2.14501359e-02f, 1.17908595e-02f, 7.04210550e-02f, 1.63121730e-01f, -4.90607992e-02f, -1.60919547e-01f, 7.18337595e-02f,
  -2.55224705e-02f, -2.20012695e-01f, -2.64041759e-02f, 3.23489122e-02f, -2.08424404e-02f, 1.28435520e-02f, 1.73125252e-01f, 1.33200958e-01f, 1.90359056e-01f, 1.26049714e-03f,
  -3.22654471e-02f, 8.58936831e-02f, 5.04123643e-02f, 4.15789932e-02f, -1.28008708e-01f, 1.26434863e-02f, -4.83725667e-02f, -2.18411982e-01f, -8.45531002e-02f, 4.33553085e-02f,
  -2.07352102e-01f, -1.26157911e-03f, -9.68010873e-02f, 9.56672728e-02f, 1.14809185e-01f, -1.84799641e-01f, 5.24601378e-02f, -6.82046711e-02f, -4.75317053e-02f, 1.02151856e-02f,
  -4.43126913e-03f, 1.11244947e-01f, 1.58165738e-01f, -1.26300007e-01f, 1.48345277e-01f, 3.66516225e-02f, -1.79450996e-02f, 1.29831806e-01f, -1.24465302e-02f, 1.26722217e-01f,
  -5.74300177e-02f, 4.54856344e-02f, -1.36296853e-01f, 1.15274014e-02f, -3.24456058e-02f, 6.99460655e-02f, 5.27484342e-02f, 1.21792674e-01f, -8.88446718e-02f, 9.30779427e-02f,
  9.72701386e-02f, 1.40603051e-01f, 1.49948165e-01f, 7.28710219e-02f, -9.07333717e-02f, -1.06245883e-01f, -1.05574645e-01f, 6.61610588e-02f, -5.36564030e-02f, -6.29346818e-02f,
  -1.30346324e-02f, 3.08775716e-02f, 1.62269801e-01f, -8.74913856e-02f, 1.47854626e-01f, 1.78200573e-01f, -1.74794465e-01f, -2.04682052e-01f, 4.83081788e-02f, -5.56291938e-02f,
  -1.21349216e-01f, -6.44440278e-02f, 1.42739136e-02f, -2.02792399e-02f, 1.47136509e-01f, -4.42807600e-02f, -2.50170659e-02f, 2.78880727e-02f, 1.27874007e-02f, -1.13376401e-01f,
  1.38808146e-01f, 1.26320556e-01f, 6.41814694e-02f, -8.71565118e-02f, 2.63668209e-01f, 1.13943070e-01f, -2.66732574e-02f, 2.92635504e-02f, -1.44929558e-01f, -6.84548393e-02f,
  -7.88328201e-02f, -2.58514620e-02f, 1.11112788e-01f, 1.55968904e-01f, -3.50258946e-02f, 6.24232367e-03f, -8.82826596e-02f, 1.45281106e-01f, -1.84774444e-01f, -1.28367007e-01f,
  2.00524516e-02f, -1.42124265e-01f, -1.01969771e-01f, -3.10389437e-02f, 4.66345204e-03f, 1.38290152e-01f, 1.66049916e-02f, -3.84669490e-02f, -4.10115235e-02f, 5.08388653e-02f,
  1.23276696e-01f, 1.35587469e-01f, -6.23691129e-03f, 3.53399776e-02f, -6.04348592e-02f, -1.16913781e-01f, 1.60905421e-02f, 4.01769206e-02f, -1.56265393e-01f, -8.39575082e-02f,
  1.93536118e-01f, 1.10034727e-01f, 5.98311909e-02f, 2.85853177e-01f, -1.44136429e-01f, 1.50600612e-01f, 6.51087686e-02f, -1.66077781e-02f, -1.18331835e-01f, -6.15968369e-02f,
  2.63919104e-02f, 7.96907768e-02f, 6.38294816e-02f, 9.30828881e-03f, 9.35731903e-02f, 1.14888638e-01f, 7.91279674e-02f, 6.47936165e-02f, -1.16185129e-01f, 1.53111815e-01f,
  1.69176698e-01f, 5.94463898e-03f, -1.08656742e-01f, 8.59676376e-02f, -4.87374477e-02f, 2.36616544e-02f, -1.25185717e-02f, -5.43614514e-02f, -8.53317827e-02f, -1.22325234e-01f,
  -1.59881309e-01f, 1.49753675e-01f, 1.64690316e-01f, 1.75766006e-01f, -4.77891043e-02f, -2.08766032e-02f, -8.58070180e-02f, -3.96667868e-02f, 4.41148365e-03f, -2.22249746e-01f,
  -1.12980194e-01f, 6.33447766e-02f, -3.31559926e-02f, 9.42647085e-02f, -5.26940264e-02f, 1.56912543e-02f, -4.02048528e-02f, -1.67141199e-01f, -9.27095786e-02f, -9.39752683e-02f,
  6.53919280e-02f, -1.03296638e-01f, 1.65987127e-02f, 1.48737459e-02f, -1.28276898e-02f, -4.72559482e-02f, -4.37087789e-02f, -2.18147740e-01f, 9.30907801e-02f, 8.07754323e-03f,
  1.36752456e-01f, -1.36708602e-01f, -2.45609328e-01f, 5.61840497e-02f, -7.07325786e-02f, 1.98684216e-01f, 1.05070649e-02f, -1.97133884e-01f, -1.37460187e-01f, -2.26281703e-01f,
  7.38466009e-02f, -8.79656523e-03f, -2.98766702e-01f, -1.27149627e-01f, -1.74938858e-01f, -5.27280979e-02f, -2.82361712e-02f, -7.23348334e-02f, 1.29952207e-01f, -1.40891282e-03f,
  1.34660468e-01f, -5.58751002e-02f, 5.45847341e-02f, -1.50566369e-01f, -6.41497225e-02f, 2.74327327e-03f, -1.54308975e-01f, -1.48644477e-01f, 8.56026709e-02f, -7.37208202e-02f,
  4.34503034e-02f, -1.20018147e-01f, 1.25700533e-01f, -9.37942639e-02f, -2.23635420e-01f, 1.06080376e-01f, 1.57644346e-01f, 1.79452851e-01f, -1.11919068e-01f, 1.07773349e-01f,
  1.00922659e-01f, -2.02730708e-02f, 4.45170514e-02f, -6.05514124e-02f, 1.43070798e-02f, -3.55344974e-02f, 7.96846971e-02f, -8.08353946e-02f, -5.05105332e-02f, -1.74291804e-01f,
  -5.41749299e-02f, -1.60318613e-01f, -4.52655600e-03f, -4.14047986e-02f, -2.30838507e-02f, -1.44022629e-01f, 1.71007663e-02f, -9.22633260e-02f, 9.41947252e-02f, 1.10776629e-02f,
  4.51660641e-02f, 1.82858109e-02f, -2.15710670e-01f, 1.27784442e-02f, -7.08277822e-02f, 6.85599446e-02f, -3.39251161e-02f, 1.82093859e-01f, 8.25153291e-02f, -2.37171371e-02f,
  -6.04950227e-02f, 1.48116291e-01f, 1.93379581e-01f, 1.84686795e-01f, 6.50387257e-02f, 2.41290592e-02f, -5.38829081e-02f, 9.38690156e-02f, 5.20714372e-02f, 4.47439253e-02f,
  -8.70081261e-02f, 1.48551073e-02f, 1.19568408e-01f, 1.22403905e-01f, -4.86642309e-02f, -1.13512285e-01f, -4.08175588e-02f, 1.10991627e-01f, 4.36616503e-02f, -7.57194683e-02f,
  2.18965247e-01f, 1.84333488e-01f, 3.17627415e-02f, 8.28785077e-02f, -9.61906612e-02f, -2.08790034e-01f, -1.88557759e-01f, 2.42069624e-02f, -6.68911412e-02f, -5.43028489e-02f,
  5.84168956e-02f, -9.72922295e-02f, 5.71425334e-02f, 5.37011176e-02f, -1.96238413e-01f, -6.40651882e-02f, 1.57687869e-02f, 1.33986130e-01f, -1.02082491e-01f, 1.73980191e-01f,
  -1.45429045e-01f, 1.84051059e-02f, -8.86186957e-02f, 3.21275927e-02f, -9.87686664e-02f, -6.65091872e-02f, -7.57183284e-02f, -5.02208294e-03f, -6.86644018e-03f, -3.90987024e-02f,
  5.31527810e-02f, 1.13270983e-01f, 8.36111903e-02f, 4.98528443e-02f, -1.71847437e-02f, -8.48650411e-02f, 1.08234748e-01f, -8.44338611e-02f, 2.19436690e-01f, 1.19712643e-01f,
  -1.24378912e-01f, 1.14627387e-02f, 1.18640430e-01f, 5.95680624e-02f, 5.60093485e-03f, -1.32225710e-03f, -7.87163008e-05f, -3.23845111e-02f, -1.52635932e-01f, 2.11014785e-03f,
  -9.09710899e-02f, -5.17271087e-02f, -1.39937833e-01f, -1.73211507e-02f, 1.09851368e-01f, 1.63707688e-01f, -7.92686194e-02f, -2.79647317e-02f, -2.31830496e-02f, 8.65834206e-03f,
  -6.69110641e-02f, -1.02266572e-01f, 1.72860950e-01f, -9.14834514e-02f, -1.23759471e-01f, -1.46110132e-01f, -4.05869912e-03f, -3.95122170e-02f, 1.84597939e-01f, 9.90052819e-02f,
  -6.51065931e-02f, -1.37938574e-01f, -1.65647686e-01f, 1.81295112e-01f, 1.65973172e-01f, 2.12090716e-01f, 6.29531965e-02f, 2.64729541e-02f, 1.18591979e-01f, 9.86304432e-02f,
  1.25240356e-01f, -1.99422941e-01f, 5.66180609e-02f, 1.03426958e-02f, -1.28646735e-02f, -9.84060019e-02f, 1.33710518e-01f, 1.40524015e-01f, 1.46803901e-01f, -1.10793784e-01f,
  1.62921026e-01f, 6.97045177e-02f, -4.02234495e-02f, -4.47943509e-02f, 9.10811722e-02f, -9.69915465e-02f, -2.98923142e-02f, -1.36503011e-01f, -8.20895135e-02f, -3.75647694e-02f,
  -2.35811677e-02f, 1.77688301e-01f, -1.74276833e-03f, -1.93937197e-01f, -2.42037736e-02f, 6.73278943e-02f, -1.32349342e-01f, 1.85920358e-01f, 1.36067241e-01f, -5.14980257e-02f,
  1.16707087e-01f, 1.50947526e-01f, 9.04492382e-03f, 9.47466642e-02f, -1.36434242e-01f, -1.95977613e-01f, -1.52495638e-01f, -1.89702883e-01f, 1.02555137e-02f, 8.04602131e-02f,
  1.25371709e-01f, -4.51491550e-02f, 1.95117325e-01f, -9.30855889e-03f, 2.91087199e-02f, 5.18911220e-02f, 3.83997224e-02f, 4.26427685e-02f, 4.41046916e-02f, -6.36844411e-02f,
  1.95161343e-01f, -4.50001322e-02f, -3.94885726e-02f, -2.12279946e-01f, -1.30503446e-01f, -5.99050298e-02f, -9.85397398e-03f, -8.38575810e-02f, 4.96954210e-02f, -1.97933447e-02f,
  -7.77025744e-02f, -3.45681198e-02f, -3.87785546e-02f, -1.43182725e-01f, -2.67869651e-01f, 1.72551259e-01f, -8.64927396e-02f, 6.43115342e-02f, 7.13270083e-02f, 3.86907868e-02f,
  -1.15201198e-01f, 9.51954275e-02f, -4.84553240e-02f, -1.40752837e-01f, -1.19946249e-01f, -2.21709665e-02f, -1.72562953e-02f, -1.73577592e-02f, 2.74351053e-02f, -6.76695723e-03f,
  -7.97874928e-02f, 6.25855103e-02f, 1.49763986e-01f, -1.49943471e-01f, -1.10299401e-01f, 8.12503174e-02f, 1.90663263e-01f, -8.90406221e-02f, 9.44829583e-02f, -1.02413855e-01f,
  -1.94217160e-01f, -2.97325253e-02f, -3.12026739e-02f, -1.62141532e-01f, -4.50537354e-02f, -1.67010456e-01f, 1.80957928e-01f, -1.10417888e-01f, -3.59061435e-02f, 2.32782081e-01f,
  8.40453245e-03f, 1.82270765e-01f, 1.81260295e-02f, -1.51540086e-01f, 9.57430676e-02f, 1.33960852e-02f, 1.42435962e-02f, -1.12662017e-01f, 6.16372265e-02f, -1.21002965e-01f,
  -1.82479635e-01f, 2.15509981e-02f, -3.87917832e-02f, 4.20385823e-02f, 7.52479881e-02f, 1.16914660e-01f, 5.13293967e-02f, -7.41482377e-02f, 6.80563524e-02f, -1.31503558e-02f,
  -1.21638011e-02f, -1.51623078e-02f, -4.49115522e-02f, 7.05765793e-03f, -2.36143768e-01f, 1.64844960e-01f, 3.08978204e-02f, 1.60147518e-01f, 4.68118414e-02f, 8.72336775e-02f,
  -3.87295969e-02f, -5.01494929e-02f, -8.54853913e-02f, -1.51413545e-01f, -3.08661424e-02f, -1.47281498e-01f, -1.01545610e-01f, 7.49641061e-02f, 2.15155296e-02f, 1.16289079e-01f,
  5.56678697e-02f, 8.40301216e-02f, 2.76111532e-02f, 1.28825128e-01f, 1.58941180e-01f, -1.00180097e-01f, -7.06886575e-02f, 1.42468616e-01f, 1.65513158e-01f, -2.17159271e-01f,
  6.35740384e-02f, 5.91424033e-02f, -1.35673374e-01f, -6.60103038e-02f, 5.84734790e-02f, 1.43376842e-01f, 1.20134585e-01f, 1.13170944e-01f, 4.33993898e-02f, -1.12425148e-01f,
  -1.32331327e-01f, 1.26499653e-01f, -1.85883686e-01f, 1.92323159e-02f, -1.89309772e-02f, -1.10043257e-01f, 7.87493885e-02f, -6.68019196e-03f, -2.54100710e-01f, 5.55628203e-02f,
  -1.62152290e-01f, 1.28004923e-01f, 4.01662774e-02f, 1.02080047e-01f, 2.02165451e-02f, 6.05413318e-02f, -1.69886976e-01f, 3.20562720e-02f, 7.88898841e-02f, -1.27868727e-01f,
  8.72512385e-02f, 2.61765476e-02f, -8.69017914e-02f, -1.46619782e-01f, -7.81200677e-02f, 1.04941782e-02f, 1.51878282e-01f, 2.21934438e-01f, 8.29087719e-02f, 1.22436233e-01f,
  -4.63621989e-02f, -4.75753359e-02f, -4.13947031e-02f, -2.80635655e-01f, 2.35100649e-02f, 8.42320845e-02f, 5.37698530e-02f, -1.03226393e-01f, -1.69014826e-01f, -9.76463035e-02f,
  6.81026131e-02f, -4.50560860e-02f, 4.05984484e-02f, -5.60971024e-03f, -6.27716109e-02f, 7.71808848e-02f, 1.42440736e-01f, 4.68752570e-02f, -6.11296147e-02f, 1.08678788e-01f,
  1.24606580e-01f, 3.89383845e-02f, -6.46883845e-02f, 3.82774845e-02f, 1.22868501e-01f, 7.83519149e-02f, 6.83390051e-02f, -1.29194528e-01f, -1.03382990e-01f, 1.40221521e-01f,
  7.95265213e-02f, -1.09345101e-01f, -1.16944462e-01f, -1.68039143e-01f, -8.52305964e-02f, -7.86492229e-02f, 2.01251656e-02f, 1.59918010e-01f, 1.10346749e-01f, 1.84521034e-01f,
  1.84267357e-01f, 1.62142500e-01f, 1.15482947e-02f, -9.50615183e-02f, -8.79382864e-02f, -1.53930292e-01f, -5.06034726e-03f, -1.11128196e-01f, 3.72885354e-02f, -7.35118315e-02f,
  2.38612875e-01f, 5.10910675e-02f, 1.69661790e-01f, 1.04491465e-01f, 7.05309883e-02f, 1.28136367e-01f, 2.15475261e-02f, -6.17196783e-02f, 1.77979004e-02f, -9.73038748e-02f,
  1.24150410e-01f, 1.28584262e-03f, -6.76238462e-02f, 9.47303623e-02f, -2.25540865e-02f, 1.10585347e-01f, 5.09801582e-02f, -7.94519484e-02f, 7.01129809e-02f, -1.55695260e-01f,
  1.66819438e-01f, -1.24610029e-01f, 2.17724144e-02f, -1.98304042e-01f, 4.79890928e-02f, 7.06984326e-02f, 9.27180871e-02f, -1.62193358e-01f, -7.30117857e-02f, -8.04103538e-02f,
  1.46052331e-01f, 1.19673461e-03f, 2.69817933e-02f, -7.69000426e-02f, -1.26364484e-01f, 3.96552682e-02f, -6.70843422e-02f, -6.70037419e-02f, -1.81907892e-01f, -1.00483127e-01f,
  -1.39375970e-01f, 7.62488246e-02f, -1.13216951e-01f, 1.51054084e-01f, 3.33690420e-02f, -1.20547421e-01f, 3.51306573e-02f, -3.64451320e-03f, -4.81782444e-02f, 5.05736545e-02f,
  1.12958364e-01f, -1.07033879e-01f, -8.10246393e-02f, -1.88153684e-01f, -5.76013848e-02f, 2.03438088e-01f, -1.12562276e-01f, -1.83512866e-01f, -9.61713865e-02f, 2.29894713e-01f,
  1.41982660e-01f, 4.43880036e-02f, -4.03916575e-02f, 2.87497770e-02f, 3.16223413e-01f, -5.17760068e-02f, 9.46022198e-02f, -1.01503663e-01f, 1.29345044e-01f, -1.65737405e-01f,
  2.47437194e-01f, -8.28876048e-02f, 8.66369903e-02f, -4.94176149e-02f, 1.11491688e-01f, -6.64745495e-02f, 7.72389695e-02f, -1.74558446e-01f, 7.76172206e-02f, 1.71251930e-02f,
  -1.11609504e-01f, -1.97816923e-01f, 6.25360534e-02f, -1.07132047e-01f, -4.95028421e-02f, 9.09847766e-02f, -1.34023249e-01f, 1.45151131e-02f, -1.03766717e-01f, 1.42308801e-01f,
  3.93450679e-03f, -1.58457369e-01f, 5.44220172e-02f, -8.00071135e-02f, -2.58322768e-02f, 4.81350981e-02f, 6.50085956e-02f, 1.25310570e-02f, -6.71943724e-02f, 1.24287372e-02f,
  1.97435357e-02f, -2.25770995e-01f, 1.08204782e-01f, 6.90775961e-02f, 1.29477218e-01f, -1.40888691e-01f, 1.29088774e-01f, -1.11988075e-01f, -5.79540730e-02f, -1.57918930e-02f,
  1.27839461e-01f, -1.59418404e-01f, -1.98982894e-01f, 1.41037423e-02f, 2.09485635e-01f, 1.18356764e-01f, 1.13552220e-01f, 1.45023793e-01f, 2.05524955e-02f, 1.14024971e-02f,
  -1.02027003e-02f, 6.84521198e-02f, -1.94988832e-01f, -5.93262501e-02f, -2.06202313e-01f, 1.24762632e-01f, 2.24796198e-02f, 1.23484775e-01f, -4.90508266e-02f, 1.45132884e-01f,
  -1.33680001e-01f, -8.33901763e-02f, 6.61800057e-02f, 1.78060874e-01f, 1.85596496e-01f, -6.26575574e-02f, 1.13979533e-01f, 9.40503478e-02f, -9.96802226e-02f, -1.43851936e-01f,
  1.53368145e-01f, 6.85057119e-02f, -5.25800139e-02f, 1.52537629e-01f, 1.74997389e-01f, -7.69624189e-02f, -7.57359192e-02f, 1.37430340e-01f, 3.05645540e-02f, 6.22201748e-02f,
  4.61348109e-02f, 1.21217361e-03f, -1.29565105e-01f, -1.20165065e-01f, 1.03066400e-01f, 1.25858858e-01f, -6.05497062e-02f, -3.94854657e-02f, -5.37180789e-02f, -6.24406189e-02f,
  5.77794425e-02f, -5.64784706e-02f, 1.25755742e-01f, -2.50301547e-02f, 3.45288254e-02f, -1.89827085e-01f, -1.05769806e-01f, -6.88216463e-03f, -5.50928451e-02f, 9.50848609e-02f,
  7.31802285e-02f, -6.72746077e-02f, -3.14084813e-02f, 2.09008709e-01f, -1.83199540e-01f, 6.92664608e-02f, 1.14621237e-01f, -7.21810833e-02f, -1.87320426e-01f, 7.58133754e-02f,
  6.13454506e-02f, -3.06919012e-02f, -1.21587917e-01f, 9.56791826e-03f, -2.29552597e-01f, 4.57478240e-02f, -1.38856973e-02f, 1.53087825e-01f, -9.95323956e-02f, 4.93309572e-02f,
  3.52132767e-02f, -1.97942913e-01f, 8.48965794e-02f, 1.61995649e-01f, -2.80642062e-02f, 3.53631633e-03f, -1.53420702e-01f, -5.80184385e-02f, -1.67065904e-01f, -1.10251531e-01f,
  5.21763489e-02f, 7.61133283e-02f, 1.06565706e-01f, 1.51757732e-01f, -9.92327034e-02f, 3.23358886e-02f, -1.44175842e-01f, -1.15549333e-01f, 3.77880335e-02f, -1.98203534e-01f,
  6.81753233e-02f, -1.53002381e-01f, 8.19574669e-02f, -3.66636761e-03f, 3.97872068e-02f, 3.21006849e-02f, 1.25067150e-02f, 2.03933626e-01f, 1.26754671e-01f, -1.54469892e-01f,
  2.15210076e-02f, -6.47520274e-02f, 1.59666762e-01f, 3.79320905e-02f, -1.81853727e-01f, 1.39522180e-01f, -9.88471881e-02f, -8.16545710e-02f, -3.53789851e-02f, 8.20004009e-03f,
  -8.27977657e-02f, 1.53323933e-01f, 1.33311972e-01f, -2.05859672e-02f, -4.77933139e-02f, -1.42959341e-01f, 4.85271513e-02f, -1.39298752e-01f, 1.18672900e-01f, -2.37420544e-01f,
  -1.09707534e-01f, -4.95841615e-02f, 1.76830411e-01f, 9.31754708e-02f, -1.20154314e-01f, -1.27502978e-01f, -3.07934247e-02f, 1.88462719e-01f, -1.66432932e-01f, -9.96395797e-02f,
  -3.90401706e-02f, 6.06330447e-02f, -5.60364686e-02f, 2.01568678e-02f, -7.76823163e-02f, 1.52354255e-01f, 1.76852465e-01f, 7.50007480e-02f, 2.17280343e-01f, -9.25104320e-02f,
  1.53650269e-01f, 8.59236270e-02f, 2.93002039e-01f, 8.23509768e-02f, -9.02661774e-03f, -9.12228078e-02f, 6.78745359e-02f, -9.29303095e-02f, -4.59421985e-02f, 1.65449884e-02f,
  1.49291742e-03f, 1.21067129e-01f, 4.82822061e-02f, -1.27760898e-02f, -3.34490240e-02f, 2.50259452e-02f, 8.56316611e-02f, -1.88007895e-02f, -7.10025728e-02f, 1.60246491e-02f,
  6.08636066e-02f, 9.26653482e-03f, -8.44970569e-02f, 1.14583515e-01f, -1.46022350e-01f, -4.95674089e-02f, -4.65487130e-02f, 6.86656460e-02f, -1.51187573e-02f, 8.31059366e-02f,
  2.60045324e-02f, 1.30774423e-01f, 5.57954721e-02f, 3.93092074e-02f, 2.51860768e-02f, 4.42334674e-02f, 2.74567932e-01f, 8.33399668e-02f, -5.01337871e-02f, -2.54047930e-01f,
  1.26476437e-01f, -9.80205312e-02f, -6.25482574e-02f, 1.86814487e-01f, -3.45299579e-02f, -1.35509327e-01f, 2.37095430e-01f, 3.51633206e-02f, 1.96245819e-01f, -8.29802006e-02f,
  -1.37943253e-01f, 3.72504890e-02f, -2.07432806e-01f, 8.24234728e-03f, -1.10899210e-01f, 1.37796298e-01f, -7.57543966e-02f, -6.40102029e-02f, 3.64970155e-02f, -2.82660872e-02f,
  2.50705719e-01f, 1.43021375e-01f, -1.14484288e-01f, -1.63055286e-02f, -1.00661412e-01f, 4.90074754e-02f, -9.49255470e-03f, 2.09485248e-01f, 1.92719474e-01f, 8.82596150e-02f,
  -1.43558145e-01f, -1.74162373e-01f, 6.65085344e-03f, -9.60199535e-02f, -1.96920726e-02f, 1.46435931e-01f, -1.17816217e-01f, 6.05264865e-02f, 5.20899100e-03f, 1.12773225e-01f,
  -4.57802452e-02f, 5.22837945e-05f, 4.71415557e-02f, 3.44019756e-03f, 1.06446534e-01f, -1.59945145e-01f, 1.08891614e-01f, 1.16996216e-02f, 4.74994481e-02f, 1.06728375e-02f,
  1.02683954e-01f, -6.86269207e-03f, -1.87688600e-02f, -8.70479718e-02f, 1.69164240e-01f, 9.70122144e-02f, -1.79518655e-01f, -1.23425387e-01f, 5.91240190e-02f, -3.08952779e-02f,
  7.50077441e-02f, -8.83403122e-02f, 9.85205173e-03f, -1.85764823e-02f, 5.23334928e-03f, 2.21810713e-01f, -1.63861215e-02f, 6.07942455e-02f, -2.05434591e-01f, -3.45850363e-02f,
  -4.36092131e-02f, 1.72550559e-01f, -5.06571233e-02f, 1.64559484e-01f, 1.13756604e-01f, -1.21554792e-01f, 7.31254816e-02f, 1.90226838e-01f, 4.45762686e-02f, -1.21578522e-01f,
  -1.07025579e-01f, -4.61436734e-02f, 2.68775169e-02f, -8.05750266e-02f, 1.47885188e-01f, 9.42807421e-02f, 4.99257073e-03f, 2.03927398e-01f, -1.22876756e-01f, 8.24813396e-02f,
  -7.35092238e-02f, -2.73241997e-02f, -2.95316875e-02f, 1.22012816e-01f, -2.73302328e-02f, -1.35286823e-02f, 1.82714745e-01f, -2.21655425e-02f, -1.26280203e-01f, -1.93159521e-01f,
  2.13252291e-01f, 3.88521841e-03f, -1.01423310e-02f, 1.07214130e-01f, -2.95010898e-02f, -4.31213453e-02f, 9.83776748e-02f, -3.54098678e-02f, -1.03538543e-01f, -1.29435420e-01f,
  -1.21663421e-01f, -8.88023674e-02f, 9.16155870e-04f, 1.02854714e-01f, -3.72540369e-03f, 1.04743637e-01f, -7.02277347e-02f, -1.96857657e-02f, -7.34559670e-02f, -8.30247998e-02f,
  -1.46682963e-01f, 2.39804424e-02f, 8.07245821e-02f, -5.89002408e-02f, -3.71930115e-02f, 3.48530747e-02f, -5.67148440e-02f, -1.43007711e-02f, 1.29852936e-01f, 9.54589993e-02f,
  -2.34156474e-02f, -1.38525307e-01f, 2.34614298e-01f, -7.55290389e-02f, -1.25323042e-01f, 1.39884278e-01f, -4.99175210e-03f, 7.78671354e-02f, -6.74969237e-03f, -1.20617770e-01f,
  -6.51664510e-02f, -4.88416925e-02f, -1.37788787e-01f, -1.66188210e-01f, -3.02239452e-02f, -1.14443153e-01f, -1.05551548e-01f, 3.59731428e-02f, -3.70155717e-03f, -4.65487055e-02f,
  7.61531368e-02f, 2.21020758e-01f, 1.08004371e-02f, 6.48973659e-02f, 1.93363667e-01f, 6.75840452e-02f, 2.43281107e-02f, -6.44543394e-02f, -7.53837079e-02f, 4.38868105e-02f,
  -1.19772501e-01f, 2.18244776e-01f, 1.45824552e-01f, 1.13002494e-01f, 4.25376557e-02f, -9.18144509e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.41915575e-01f, -9.12375674e-02f, 5.90830259e-02f, 3.60171273e-02f, -6.28527021e-04f, -1.38357595e-01f, 1.62955746e-01f, 3.24195117e-01f, 1.35013521e-01f, -1.25395790e-01f,
  6.69262707e-02f, 1.37929007e-01f, 6.97503909e-02f, 5.10074049e-02f, -4.13079038e-02f, 1.28197283e-01f, -3.54891233e-02f, 1.65081471e-01f, 2.86471158e-01f, -2.70748943e-01f,
  -1.23995751e-01f, 2.60046095e-01f, 2.60132775e-02f, -4.11223248e-02f, 9.52299014e-02f, 1.06518120e-02f, -3.74182723e-02f, -1.95152923e-01f, -7.99709111e-02f, -7.16404319e-02f,
  -2.41635501e-01f, -4.69327457e-02f, 1.38878331e-01f, -1.30610570e-01f, -2.75018096e-01f, -2.37103507e-01f, -1.70380533e-01f, 3.27903509e-01f, -1.98807508e-01f, 1.54578254e-01f,
  5.61941117e-02f, 2.82453746e-01f, 3.37004685e-03f, 3.52663845e-01f, -8.22021887e-02f, -5.21020740e-02f, -3.72315675e-01f, -8.33603516e-02f, -1.98143721e-01f, 9.80139803e-03f,
  1.48587702e-02f, 1.60620898e-01f, 2.45001495e-01f, -2.44339347e-01f, 2.84358323e-01f, -1.74056783e-01f, 2.42338210e-01f, 1.81379810e-01f, -8.63944516e-02f, 7.82068297e-02f,
  1.10702634e-01f, 9.24201831e-02f, 2.20576584e-01f, -3.51399422e-01f, -6.63313940e-02f, 9.54021439e-02f, 1.09898880e-01f, 4.22924235e-02f, 1.57734111e-01f, 2.34632045e-02f,
  7.40913600e-02f, -2.71606833e-01f, 7.75331119e-03f, 8.91122967e-02f, 2.21863866e-01f, -2.29577154e-01f, 9.56497937e-02f, -9.39835981e-02f, 5.44616245e-02f, 1.50923520e-01f,
  -4.75400761e-02f, -1.29636168e-01f, -6.18712492e-02f, 3.52540433e-01f, -2.96525415e-02f, -1.87186524e-01f, -2.01147109e-01f, 2.27872789e-01f, 1.27469478e-02f, 3.63924235e-01f,
  4.63193329e-03f, -8.32796320e-02f, -3.29086870e-01f, 1.36409086e-04f, 9.15742666e-02f, -1.34948805e-01f, -2.50049651e-01f, 9.30350050e-02f, -1.09664453e-02f, 1.11117341e-01f,
  -2.18135819e-01f, -1.76879242e-01f, 1.23316802e-01f, -7.26344734e-02f, 2.23294884e-01f, -1.61037832e-01f, 2.56334871e-01f, 8.94593373e-02f, 2.64095664e-01f, 2.67029732e-01f,
  2.29786560e-02f, -1.60022363e-01f, -1.53760388e-01f, 2.88931847e-01f, 4.35403548e-02f, -3.57814491e-01f, 2.79916644e-01f, 2.74885148e-01f, -3.26995820e-01f, 5.77074885e-02f,
  3.23955983e-01f, 1.75868228e-01f, -2.28063032e-01f, 2.37332240e-01f, 3.66885304e-01f, 1.55476198e-01f, -1.14876390e-01f, 1.08262844e-01f, 2.23051041e-01f, 9.07071158e-02f,
  1.56454980e-01f, 2.79013962e-01f, 2.31981784e-01f, 1.87376559e-01f, 2.41978943e-01f, 2.59621412e-01f, 8.97878706e-02f, -4.33386452e-02f, 2.25480460e-02f, 3.66264433e-02f,
  1.71028584e-01f, 3.49951275e-02f, 3.24335359e-02f, 2.00409412e-01f, -9.12235957e-03f, 3.17568146e-02f, -6.09447844e-02f, 6.68377653e-02f, -2.11387023e-01f, -2.01445669e-01f,
  1.25666812e-01f, -1.21388748e-01f, -1.20880537e-01f, -3.13780196e-02f, 1.11496769e-01f, -2.92394400e-01f, -1.81420483e-02f, -1.63412809e-01f, 1.50878340e-01f, 2.02561229e-01f,
  6.69679940e-02f, -2.94989324e-03f, -1.50868267e-01f, 2.50784270e-02f, -1.86888799e-01f, 3.54271568e-02f, 2.51498044e-01f, -2.07689524e-01f, 2.21832961e-01f, -2.27657929e-02f,
  2.36867875e-01f, -1.82543188e-01f, -1.70149133e-01f, 5.41732073e-01f, 2.07253695e-02f, -6.08215779e-02f, -2.04652339e-01f, 4.59668273e-03f, 2.29953200e-01f, 4.09792662e-02f,
  4.26256061e-01f, 4.33239162e-01f, -5.34186922e-02f, -2.13449016e-01f, -8.97292495e-02f, -2.19511837e-01f, -1.69071686e-02f, 6.81434721e-02f, 4.78160292e-01f, 4.20490742e-01f,
  -2.80929923e-01f, 3.19330186e-01f, -4.29371605e-03f, 1.74148008e-01f, -1.92847863e-01f, 7.73521215e-02f, 3.48573513e-02f, 3.40530500e-02f, -2.35625654e-02f, -1.68329716e-01f,
  -7.63354376e-02f, 5.76508045e-02f, 3.14308032e-02f, -6.01983629e-02f, -7.66559020e-02f, 2.11880758e-01f, 1.16212159e-01f, 1.35169238e-01f, 2.22328022e-01f, -4.53774370e-02f,
  2.09548436e-02f, -8.95366296e-02f, 2.64102250e-01f, 5.44564798e-02f, -8.79545808e-02f, -7.34739229e-02f, 2.60827780e-01f, 1.19207792e-01f, 7.50592798e-02f, 3.92749727e-01f,
  -8.25980380e-02f, 2.63764799e-01f, -1.19706139e-01f, -4.38305400e-02f, -6.32356852e-02f, 1.42068332e-02f, 2.07539722e-01f, 2.75659233e-01f, 3.07241887e-01f, 6.36338815e-02f,
  1.11572728e-01f, 3.75937015e-01f, -7.54429176e-02f, -1.63795173e-01f, -2.36381013e-02f, 1.81655824e-01f, 2.74026185e-01f, -2.85948515e-01f, -3.02370228e-02f, 2.81843483e-01f,
  2.02799559e-01f, 2.56799370e-01f, 2.62564510e-01f, 2.13315606e-01f, -3.75986367e-01f, -3.15573849e-02f, 1.77104473e-01f, -6.49443790e-02f, 2.40696013e-01f, -2.14932840e-02f,
  4.69175637e-01f, 1.16046339e-01f, -1.02224261e-01f, 2.74751261e-02f, 4.71538424e-01f, -2.07423955e-01f, 1.83299944e-01f, 1.47165626e-01f, 1.13136008e-01f, 7.24861324e-02f,
  2.97378488e-02f, 7.10301474e-02f, -2.78261602e-02f, 2.64879744e-02f, -3.80532257e-02f, 9.15131792e-02f, 1.95311636e-01f, 1.95865214e-01f, 2.35836003e-02f, 7.49887154e-02f,
  2.47657940e-01f, -4.41054394e-03f, 1.40936270e-01f, -5.98127879e-02f, 2.51521409e-01f, 6.04562163e-02f, 5.71515337e-02f, -1.91197880e-02f, -3.28279525e-01f, -1.07452609e-01f,
  1.62072539e-01f, 1.99583061e-02f, -1.03067625e-02f, -1.28268646e-02f, -4.30171162e-01f, -7.94138834e-02f, 7.45781139e-02f, -3.30635190e-01f, -7.70144537e-02f, -4.88385325e-03f,
  -3.37585241e-01f, -5.78477047e-02f, 5.80181964e-02f, 1.14201456e-01f, -2.05285594e-01f, 5.76686971e-02f, 4.06527333e-02f, 1.56766623e-01f, 1.26473755e-01f, 6.99207559e-02f,
  2.36051992e-01f, -6.36257082e-02f, -3.34279031e-01f, -1.46267161e-01f, -4.46579993e-01f, 1.40111908e-01f, 2.19660103e-01f, 2.92566381e-02f, 9.64338109e-02f, -1.56844243e-01f,
  1.32728800e-01f, 1.01700462e-01f, 3.33352983e-01f, 3.20732892e-01f, -1.21926375e-01f, 3.97649616e-01f, 3.22890997e-01f, 1.44516692e-01f, 8.16370100e-02f, -9.71106142e-02f,
  2.05946833e-01f, 3.80871482e-02f, 1.40199855e-01f, -1.30750639e-02f, 4.43031453e-02f, 2.61374176e-01f, 1.49201870e-01f, 1.60022944e-01f, -1.53660357e-01f, -3.38911042e-02f,
  9.33372751e-02f, 2.29115963e-01f, 5.19247875e-02f, 1.37104228e-01f, 1.52822167e-01f, 1.05333686e-01f, -6.88163862e-02f, -6.93348348e-02f, -2.07910463e-02f, 5.66123202e-02f,
  2.28592157e-01f, 2.16939136e-01f, 3.10920132e-03f, -1.94836751e-01f, 1.86752275e-01f, -1.98078111e-01f, 4.87061255e-02f, -1.12484492e-01f, -1.13113880e-01f, -1.06905796e-01f,
  1.15318701e-03f, -1.59801677e-01f, -7.11099282e-02f, 1.81952372e-01f, -1.03543580e-01f, 1.13402449e-01f, 3.60064566e-01f, -1.16513982e-01f, -1.98198020e-01f, 1.13375321e-01f,
  -8.89928192e-02f, -7.10924715e-02f, -9.00874380e-03f, -5.62728830e-02f, 1.05229191e-01f, -9.40513015e-02f, -3.22625875e-01f, -4.72151265e-02f, -8.44942927e-02f, 2.32277326e-02f,
  2.05822542e-01f, 3.30165684e-01f, -6.19799122e-02f, -1.73489988e-01f, 1.22836038e-01f, -4.29746844e-02f, 2.52550781e-01f, 3.89655799e-01f, -2.47685328e-01f, 4.31589216e-01f,
  4.32743281e-02f, 2.94593602e-01f, 2.82894611e-01f, -1.85455289e-03f, 1.00906052e-01f, 1.45760298e-01f, 1.74109653e-01f, 1.45881996e-01f, 2.39439607e-01f, 1.71094790e-01f,
  1.66084260e-01f, 1.56691268e-01f, 1.44483313e-01f, -4.96403463e-02f, 6.03681207e-02f, 4.98789735e-02f, 5.18545248e-02f, 2.61738718e-01f, 3.06228828e-02f, 1.55598149e-01f,
  1.67740554e-01f, 9.63152498e-02f, 2.19881255e-02f, 5.72636947e-02f, 2.77205467e-01f, 1.85476348e-01f, -1.42496139e-01f, 4.66990657e-02f, -5.61109744e-02f, -2.17373729e-01f,
  9.02431831e-02f, -8.54928717e-02f, -2.68273920e-01f, 1.35017047e-03f, 6.01903610e-02f, -3.55101347e-01f, 2.89578944e-01f, 3.66814792e-01f, 1.29165888e-01f, -1.95892286e-02f,
  -6.70858622e-02f, -1.88991591e-01f, -3.35838079e-01f, -1.46205099e-02f, -2.34920666e-01f, -5.30277342e-02f, 2.77329504e-01f, -1.30422041e-01f, 3.89239192e-02f, 1.59269542e-01f,
  4.04509842e-01f, 1.86098635e-01f, 7.12731555e-02f, 3.44609231e-01f, 2.49105752e-01f, -2.57276054e-02f, 3.80963624e-01f, 6.64244546e-03f, 3.04205447e-01f, 2.29609720e-02f,
  5.64293843e-03f, 2.53337443e-01f, -1.11097530e-01f, 2.88399875e-01f, 2.45643377e-01f, 3.31367075e-01f, -1.75103649e-01f, 8.09591487e-02f, -7.89752603e-02f, 1.90283328e-01f,
  1.98904593e-02f, 5.17046042e-02f, 2.57232338e-01f, 2.01618136e-03f, -5.55484593e-02f, -2.36283019e-01f, -1.75518859e-02f, -4.80263419e-02f, 1.40356794e-01f, -8.91517997e-02f,
  -2.99446913e-03f, 1.54934347e-01f, -3.04905744e-03f, 2.48045892e-01f, 9.74336267e-02f, 1.24993868e-01f, -5.60662039e-02f, 2.28857666e-01f, 1.58447281e-01f, -2.46858403e-01f,
  -2.66905934e-01f, 2.39862144e-01f, -2.33091488e-01f, 4.25174564e-01f, -2.23236717e-02f, -1.61179259e-01f, -2.34314680e-01f, 2.50741895e-02f, 1.76714092e-01f, -2.02327251e-01f,
  -1.19360946e-01f, 1.77093640e-01f, 1.12448633e-01f, 1.13630161e-01f, -2.03526393e-01f, -8.47851783e-02f, 2.93710917e-01f, -1.87649146e-01f, 1.54882789e-01f, -3.55337203e-01f,
  3.11860323e-01f, -2.53645778e-01f, 1.62585065e-01f, 1.12642772e-01f, 2.47483879e-01f, -9.20085050e-03f, -2.06031486e-01f, 3.33854198e-01f, 3.01105767e-01f, -1.25237614e-01f,
  5.04642665e-01f, 2.38808692e-01f, -3.75236511e-01f, 1.41382637e-02f, 1.28394708e-01f, -4.27944362e-02f, -1.27895057e-01f, -2.51333751e-02f, 2.63041556e-01f, 3.01057070e-01f,
  -1.59684196e-01f, 2.98151970e-01f, 1.89942434e-01f, 5.32905348e-02f, -8.60794112e-02f, 9.48033780e-02f, 1.00450553e-01f, -2.21407950e-01f, 6.20992780e-02f, 1.71804070e-01f,
  2.28040740e-01f, 1.49626449e-01f, 1.66988432e-01f, -6.27918467e-02f, 9.62128714e-02f, -3.11394501e-03f, -6.90754801e-02f, 1.26831427e-01f, 4.77028266e-02f, 2.56367892e-01f,
  -3.23863328e-02f, -2.97664285e-01f, -2.46296927e-01f, 1.15891069e-01f, 3.01306754e-01f, -1.44925773e-01f, -2.11393982e-02f, -3.50560337e-01f, 1.84851095e-01f, 3.13889652e-01f,
  2.56994665e-01f, 3.83660555e-01f, -2.16062605e-01f, 1.52595341e-01f, 2.60716051e-01f, -1.93735018e-01f, 2.78892905e-01f, 9.05312672e-02f, -1.43262237e-01f, 6.07244112e-02f,
  1.71229869e-01f, 2.27535337e-01f, 1.61387343e-02f, 1.71821460e-01f, 8.78213197e-02f, 1.75477609e-01f, 1.77359179e-01f, 4.78114426e-01f, 5.54447286e-02f, 3.92827660e-01f,
  3.18897337e-01f, -2.55835541e-02f, 2.23977081e-02f, 2.26613805e-01f, -3.51805866e-01f, 4.39155608e-01f, 2.83950448e-01f, -3.10129523e-01f, -1.00939594e-01f, -2.56219476e-01f,
  4.06434566e-01f, -1.04793228e-01f, -1.16481669e-01f, -1.12799019e-01f, 3.16195607e-01f, 4.48208958e-01f, 2.55265236e-01f, -1.25522567e-02f, 6.48704320e-02f, 1.84344500e-01f,
  -1.53293952e-01f, -1.72323566e-02f, 1.67387575e-01f, 1.29163861e-01f, 4.64196987e-02f, -5.50938025e-02f, 1.04952537e-01f, -2.77062580e-02f, 1.22014940e-01f, 1.93976179e-01f,
  -7.33873621e-02f, 1.16190456e-01f, 1.68536142e-01f, -1.40145691e-02f, -9.67150331e-02f, 2.12593704e-01f, 2.19703823e-01f, 1.62422746e-01f, 2.73726702e-01f, -1.48214266e-01f,
  -2.78090775e-01f, 1.07684925e-01f, 9.64822844e-02f, -7.54106641e-02f, -1.26780391e-01f, -1.75615907e-01f, -9.52750593e-02f, -1.17157429e-01f, 1.14123471e-01f, 3.24761152e-01f,
  2.02580154e-01f, 4.00567144e-01f, 3.55919659e-01f, 2.52512753e-01f, 3.13042440e-02f, 2.04482749e-01f, -2.81131983e-01f, -2.26238817e-01f, -1.03217728e-01f, -1.96752653e-01f,
  2.37696335e-01f, -2.75782053e-03f, 3.89485836e-01f, 2.60459483e-01f, 3.00618231e-01f, 1.83289036e-01f, 3.67374808e-01f, 2.06134915e-01f, 9.94969755e-02f, -4.15918082e-02f,
  -4.41246741e-02f, -4.83520776e-02f, 4.18025702e-02f, 1.35799587e-01f, -6.82806596e-02f, 1.10065460e-01f, 1.00983709e-01f, 1.89667881e-01f, 1.06265888e-01f, 2.47073874e-01f,
  -1.35634607e-02f, -5.52309006e-02f, 1.27017900e-01f, 5.12302406e-02f, 2.90832698e-01f, 9.42732543e-02f, 8.97379890e-02f, 1.77606925e-01f, -4.25469223e-03f, -8.31226930e-02f,
  2.49020159e-01f, -1.06024370e-02f, 2.33580247e-01f, 1.29107729e-01f, 3.50857303e-02f, 1.80389091e-01f, 1.69408336e-01f, -3.76844220e-02f, 6.22268058e-02f, 2.23910794e-01f,
  -3.34425002e-01f, -1.14837758e-01f, -7.86813721e-02f, 6.34439662e-02f, -1.24717735e-01f, -7.12777767e-03f, 1.70552477e-01f, -4.30309564e-01f, 4.36130278e-02f, -1.77743271e-01f,
  3.43279630e-01f, 2.24195719e-01f, 8.77708718e-02f, -2.34933853e-01f, -1.03876695e-01f, -3.07643950e-01f, -2.83791959e-01f, -1.26464128e-01f, 2.67481148e-01f, -2.69293755e-01f,
  1.51541501e-01f, 1.35457382e-01f, 1.92404583e-01f, -1.89621896e-01f, 1.67573974e-01f, 5.23650825e-01f, -3.81757736e-01f, -3.28006037e-02f, -1.32449895e-01f, -1.46210879e-01f,
  1.08113788e-01f, -2.36733317e-01f, 2.90306419e-01f, 2.05440715e-01f, -9.26408619e-02f, -5.88889718e-02f, -5.17382063e-02f, -7.19291568e-02f, 6.84396401e-02f, -1.84321016e-01f,
  3.72531414e-01f, 1.56153336e-01f, -3.86575818e-01f, 1.64218783e-01f, 2.00134609e-02f, 1.61388531e-01f, 1.06266430e-02f, -1.90528914e-01f, 1.39104709e-01f, 1.33726016e-01f,
  2.77215928e-01f, 2.64308769e-02f, 2.66075693e-02f, 6.39003441e-02f, 1.13242052e-01f, 9.03233588e-02f, 1.84400845e-03f, 3.01045865e-01f, 5.64332157e-02f, 1.36421621e-02f,
  1.84997261e-01f, 1.77348852e-01f, -1.37518898e-01f, 3.62233311e-01f, 3.20995718e-01f, -3.85558084e-02f, 1.36879772e-01f, -1.19405471e-01f, -1.26922786e-01f, 2.55018055e-01f,
  6.70218691e-02f, 1.36575341e-01f, 8.60832036e-02f, 1.26123965e-01f, -4.90057468e-02f, -2.54549325e-01f, -6.34644777e-02f, 3.11794847e-01f, 1.67273551e-01f, 8.83735195e-02f,
  2.54865021e-01f, 1.41514480e-04f, 1.47976980e-01f, 2.07387403e-01f, -2.34729543e-01f, -1.98445275e-01f, 1.22276284e-02f, -2.60562062e-01f, 1.40920237e-01f, -1.69899493e-01f,
  5.61877608e-01f, 2.22325757e-01f, 3.60261500e-01f, 1.63674474e-01f, 4.25877124e-01f, -1.65939680e-03f, 1.05190441e-01f, -6.89539984e-02f, 8.03689733e-02f, -2.34597236e-01f,
  1.01889990e-01f, 1.72711179e-01f, -5.27409501e-02f, 8.90273675e-02f, -8.20227992e-03f, 1.81703925e-01f, 1.75984539e-02f, 4.86949347e-02f, 4.03255895e-02f, 2.53035337e-01f,
  -6.63056821e-02f, 4.39095683e-02f, 2.15615377e-01f, 1.82088651e-02f, 1.58952311e-01f, 3.76258306e-02f, 1.52676970e-01f, 2.67229408e-01f, 1.42327324e-01f, 9.38792620e-03f,
  -2.78858980e-03f, 7.27178063e-03f, 5.05620576e-02f, 1.28506068e-02f, 2.39662066e-01f, 1.65773079e-01f, 9.25490633e-02f, -1.63573101e-01f, 3.78652513e-02f, -1.78054832e-02f,
  3.62563580e-01f, -1.88321069e-01f, 2.69418120e-01f, -1.59753233e-01f, 1.45036817e-01f, 2.83822060e-01f, 2.49998033e-01f, 2.64670432e-01f, 6.92788288e-02f, 4.54407302e-04f,
  2.60593355e-01f, -3.06853741e-01f, 3.20319653e-01f, -1.73848167e-01f, 9.06081125e-03f, 1.14330731e-01f, 3.82839978e-01f, 2.54756570e-01f, 2.54257351e-01f, 2.47878283e-01f,
  2.01380998e-01f, 1.05821609e-01f, 1.85613766e-01f, 7.85502568e-02f, 2.98383206e-01f, 3.17896843e-01f, 1.60506830e-01f, 1.37894198e-01f, 1.02486007e-01f, 2.02690646e-01f,
  -5.60593724e-01f, 3.02585840e-01f, 1.53674290e-01f, -2.45807275e-01f, 1.89417824e-02f, -1.91320434e-01f, 4.43382055e-01f, -1.30128816e-01f, -7.48053715e-02f, -1.41952366e-01f,
  2.02885419e-01f, 2.71726310e-01f, 9.95249376e-02f, 2.09360689e-01f, 1.51104093e-01f, 1.98512003e-01f, -2.56986134e-02f, 3.33868474e-01f, 4.32157181e-02f, -2.45968793e-02f,
  -4.12069540e-03f, 1.36781901e-01f, 1.25760987e-01f, -6.57637976e-03f, -1.52055742e-02f, 2.07255840e-01f, 1.69742361e-01f, 1.74921826e-01f, 6.06890470e-02f, -1.71814747e-02f,
  1.44193456e-01f, -6.34475946e-02f, 2.59189636e-01f, 2.07818881e-01f, -1.59168229e-01f, -9.91102979e-02f, 1.30344585e-01f, -1.23150535e-01f, -4.93473262e-02f, 1.64384134e-02f,
  -2.48997584e-01f, -1.16381593e-01f, 1.88246161e-01f, -2.89747387e-01f, 1.84547782e-01f, 3.66551429e-01f, 4.82857898e-02f, 2.19281629e-01f, 3.70759130e-01f, -1.91418186e-01f,
  -2.82495022e-01f, 2.50654012e-01f, -1.55891687e-01f, -2.46220335e-01f, -2.49720216e-02f, 4.64660451e-02f, 6.41584173e-02f, -1.86460480e-01f, 1.39729574e-03f, 4.09688242e-02f,
  -9.31568146e-02f, 3.07567656e-01f, 1.24653742e-01f, 1.54767737e-01f, 8.07631239e-02f, 3.41768004e-02f, 1.47350863e-01f, 5.58618009e-02f, -6.13152348e-02f, 2.84333855e-01f,
  -1.22589275e-01f, 4.17363197e-01f, 1.11497268e-01f, 1.25779912e-01f, 3.61349970e-01f, 1.23999175e-02f, 8.40760693e-02f, 3.71195674e-02f, 1.56779975e-01f, 1.38626739e-01f,
  1.38432637e-01f, 2.85320073e-01f, 7.23624453e-02f, -1.51233450e-01f, 2.25952059e-01f, 8.44300762e-02f, 3.86243239e-02f, -5.36996126e-02f, 1.19232006e-01f, 2.58833300e-02f,
  2.05165800e-02f, -3.83613934e-03f, 1.83011979e-01f, 2.32129768e-01f, 2.70914316e-01f, 3.45031053e-01f, -1.71902239e-01f, -1.26395579e-02f, -3.90798859e-02f, 1.83783427e-01f,
  1.86626732e-01f, 4.17333454e-01f, 1.74246222e-01f, 1.57373659e-02f, -5.12058206e-04f, 3.35031807e-01f, 3.91267061e-01f, -2.33502146e-02f, -3.22815388e-01f, -2.05616299e-02f,
  -3.30507368e-01f, -2.45698050e-01f, -1.20407514e-01f, -7.86458030e-02f, 8.47710669e-02f, 1.40281126e-01f, 3.79744202e-01f, 2.14669872e-02f, 4.14896965e-01f, 6.45417795e-02f,
  2.68438727e-01f, -1.01648487e-01f, -3.33811715e-02f, -2.58106112e-01f, -1.17440030e-01f, 3.29530060e-01f, 1.99000612e-01f, -2.39298776e-01f, -2.55372941e-01f, 1.08154975e-01f,
  7.66084567e-02f, -1.25842914e-01f, 1.13906935e-01f, 3.50916177e-01f, -1.91612974e-01f, 1.91326980e-02f, 9.46953148e-02f, 3.09928581e-02f, -1.99193880e-01f, -1.37968242e-01f,
  4.14542407e-02f, 1.17753677e-01f, -2.44641796e-01f, 1.52412117e-01f, -3.41767306e-03f, -6.35075048e-02f, -1.66406766e-01f, 6.95962384e-02f, -1.92314327e-01f, -7.99799860e-02f,
  2.20462516e-01f, 9.87048000e-02f, -6.67234883e-02f, -5.05014956e-02f, 2.51545578e-01f, 2.13744000e-01f, 2.38719061e-01f, -9.77195427e-02f, -5.17768264e-02f, -2.15225011e-01f,
  1.05515465e-01f, 5.49471565e-02f, -1.30077273e-01f, -1.17478907e-01f, 3.20469588e-01f, -2.88730115e-01f, -8.65281001e-02f, -2.62649264e-02f, 7.77309760e-03f, -4.14002500e-02f,
  -1.87322989e-01f, -1.49360105e-01f, -3.75909135e-02f, -1.50721163e-01f, 1.68815091e-01f, 1.59127280e-01f, 9.72046107e-02f, 2.69763432e-02f, 2.06736624e-01f, 2.22897846e-02f,
  -1.61960199e-02f, 1.48700148e-01f, 1.30528957e-01f, 1.44615948e-01f, 2.35186800e-01f, 2.67498940e-01f, -4.41889882e-01f, 2.62635816e-02f, -1.59888282e-01f, -6.69391751e-02f,
  1.84204727e-01f, 9.22114477e-02f, 8.33384842e-02f, -1.07503720e-01f, 5.17712645e-02f, 1.56291768e-01f, 2.39966348e-01f, 1.68507531e-01f, 3.81011248e-01f, 4.24160548e-02f,
  2.55354732e-01f, 1.93602711e-01f, 2.89631307e-01f, -1.63538083e-01f, 3.83884162e-02f, 4.76383604e-02f, -1.15078978e-01f, 1.43801898e-01f, 1.28726423e-01f, 9.84469503e-02f,
  1.23117670e-01f, -1.82481453e-01f, -4.37159315e-02f, 2.07256734e-01f, -1.49109632e-01f, -2.60129958e-01f, -6.15201555e-02f, 1.08178936e-01f, 3.06137241e-02f, 1.36965066e-01f,
  1.29659235e-01f, 7.22770095e-02f, -1.90168053e-01f, 2.83110946e-01f, -5.76090291e-02f, -1.58050865e-01f, 3.04171622e-01f, 1.64943654e-02f, 8.08156282e-02f, 3.36897254e-01f,
  1.07837051e-01f, 2.07885280e-01f, 2.46928915e-01f, 2.40511656e-01f, -1.48622483e-01f, 8.06443021e-03f, 1.62476464e-03f, -6.89869374e-02f, 2.09422663e-01f, 1.58283725e-01f,
  1.42414451e-01f, 2.32598633e-02f, 5.60382485e-01f, 2.98734069e-01f, 1.57161176e-01f, -8.89520869e-02f, 2.37507988e-02f, 9.34054777e-02f, 1.90746605e-01f, 1.58374235e-01f,
  2.46274889e-01f, 2.98072454e-02f, 4.03271228e-01f, 2.16341287e-01f, 1.87657133e-01f, 8.05581063e-02f, -3.11358452e-01f, 2.18395740e-01f, 3.00962497e-02f, -7.57792890e-02f,
  -1.16978334e-02f, -3.59761901e-02f, 3.62633049e-01f, -1.08383037e-02f, -1.60618082e-01f, -2.54763454e-01f, 9.97890979e-02f, 9.25353169e-02f, 1.22511141e-01f, 2.90551502e-02f,
  1.18157595e-01f, 3.12121771e-02f, 1.44594744e-01f, 2.28054315e-01f, -2.11957581e-02f, 2.05842033e-02f, 1.17284827e-01f, 2.20382866e-02f, 3.22171450e-02f, 1.78893566e-01f,
  -2.25645490e-02f, -7.18437210e-02f, 5.28663360e-02f, 5.56975380e-02f, 1.75633952e-01f, 3.28872874e-02f, 2.16618523e-01f, 2.25052223e-01f, -3.20394993e-01f, -1.13059193e-01f,
  -3.06914538e-01f, 2.26786733e-01f, 2.58431554e-01f, 9.24579203e-02f, 2.53041118e-01f, -1.26984268e-01f, 8.05938467e-02f, 3.11231285e-01f, 4.61587250e-01f, 1.45834550e-01f,
  -1.19365983e-01f, -2.29537338e-01f, -2.83288509e-01f, -2.83614755e-01f, -3.55802178e-01f, -3.62127185e-01f, 1.01393886e-01f, 9.00693834e-02f, 4.27294374e-01f, 2.31803551e-01f,
  4.14431810e-01f, 2.27151319e-01f, 6.60684034e-02f, 2.08582863e-01f, -2.74170458e-01f, -7.02883452e-02f, -1.70955017e-01f, -4.34323922e-02f, -1.14717372e-02f, -2.48013288e-01f,
  9.25358459e-02f, 2.60393858e-01f, -7.75220096e-02f, -1.32424133e-02f, 2.82421529e-01f, 1.97398365e-01f, 5.43554053e-02f, -9.30954441e-02f, 1.00401431e-01f, -1.58847626e-02f,
  -1.08669668e-01f, -5.05583882e-02f, 2.17492878e-01f, 4.87571433e-02f, -2.14305837e-02f, 2.26382345e-01f, -1.47896945e-01f, 2.12467879e-01f, -4.32884553e-03f, 1.21959031e-01f,
  -2.07789436e-01f, 1.17502518e-01f, 7.21175373e-02f, 1.84121534e-01f, 4.34591956e-02f, 4.71374718e-03f, 2.42362954e-02f, 9.31938067e-02f, 2.67795250e-02f, -3.07477657e-02f,
  -2.83801500e-02f, -3.80984634e-01f, 1.19302623e-01f, 3.19166780e-01f, 2.24601656e-01f, -2.85296172e-01f, -1.17793083e-02f, -4.83280003e-01f, -1.27544388e-01f, -1.66690916e-01f,
  -1.62337855e-01f, -1.59605384e-01f, 1.09904304e-01f, -2.06007630e-01f, 3.80607665e-01f, 2.73043334e-01f, 2.94963926e-01f, 3.72564763e-01f, 9.42395777e-02f, 4.38685752e-02f,
  -3.63065630e-01f, 2.78766779e-03f, -1.66896388e-01f, -1.33040711e-01f, -8.53533819e-02f, -1.59995407e-02f, -1.24653138e-01f, 2.69607455e-01f, -5.08503541e-02f, 3.29127699e-01f,
  1.79301485e-01f, 5.66362962e-02f, -3.99485677e-02f, 4.32660758e-01f, 2.58735329e-01f, 7.49960691e-02f, 2.83420324e-01f, 3.60912234e-02f, -7.68411756e-02f, -2.37325668e-01f,
  -8.08551610e-02f, 3.45431000e-01f, -5.56712933e-02f, 2.81053543e-01f, 2.01737568e-01f, 3.01364481e-01f, 9.53068305e-03f, 1.73293248e-01f, 5.59755713e-02f, 1.53937697e-01f,
  2.49309897e-01f, -2.19786465e-02f, 1.93672299e-01f, -3.14960489e-03f, 2.19777733e-01f, 1.30693451e-01f, 1.14381656e-01f, 1.41986445e-01f, 1.69603258e-01f, 2.11534485e-01f,
  -8.25025886e-03f, 8.54469836e-02f, 1.17665775e-01f, 1.61014512e-01f, 2.15118587e-01f, 7.84887448e-02f, -2.24142313e-01f, -2.81278372e-01f, 9.18144584e-02f, -1.74291003e-02f,
  -6.27137721e-02f, 1.68235227e-01f, 7.53616393e-02f, -2.46699616e-01f, -2.51450628e-01f, 2.12551326e-01f, 1.43671840e-01f, 3.13429683e-02f, -8.95874798e-02f, -1.73462972e-01f,
  8.65854770e-02f, -1.09523885e-01f, -2.66743302e-01f, 6.43521324e-02f, 9.24640670e-02f, 3.39965671e-02f, 2.05257326e-01f, 1.53348774e-01f, 2.94619739e-01f, 3.29483300e-03f,
  -1.73720950e-03f, 2.09062263e-01f, 2.19103292e-01f, -1.61765769e-01f, -2.32859001e-01f, 2.12494731e-01f, 2.00623244e-01f, -4.25837710e-02f, 3.07369139e-02f, 1.87877804e-01f,
  -8.72852504e-02f, -7.84210786e-02f, 1.94621328e-02f, 1.33923337e-01f, -1.32212386e-01f, -2.26792283e-02f, 3.64805609e-01f, 2.02690244e-01f, -3.79228771e-01f, 3.63681763e-01f,
  1.45065695e-01f, 9.79666635e-02f, 4.13529985e-02f, 1.00131951e-01f, -3.59748229e-02f, 3.37586924e-02f, 1.05531655e-01f, 1.78830311e-01f, 1.11325487e-01f, 4.31163907e-02f,
  -6.57076910e-02f, -3.33619900e-02f, 2.41096601e-01f, 2.03877047e-01f, -1.25257045e-01f, 1.03020787e-01f, -6.54817373e-02f, 1.62521511e-01f, -6.34422526e-02f, -2.30154172e-01f,
  -1.09728724e-01f, 2.69082516e-01f, 2.65722841e-01f, -2.59771436e-01f, -1.27537429e-01f, -4.30567294e-01f, -9.51549690e-03f, -1.11592740e-01f, 1.63133323e-01f, 1.52060822e-01f,
  -1.04126386e-01f, 3.20590250e-02f, 3.48721653e-01f, 2.89868802e-01f, 2.01171622e-01f, 1.42390236e-01f, 8.94173235e-02f, -3.02511696e-02f, -1.97418943e-01f, 4.17351536e-02f,
  -3.45574766e-02f, 2.45155573e-01f, -9.31615159e-02f, 2.21608639e-01f, -1.28696397e-01f, 1.41050205e-01f, 1.85322210e-01f, 4.07798350e-01f, 4.75849539e-01f, 6.98912516e-02f,
  2.18636990e-01f, 3.19895625e-01f, 1.74243823e-01f, 1.34743378e-01f, 3.10876012e-01f, -2.75092036e-01f, -2.98163831e-01f, -2.58282274e-01f, 2.02494916e-02f, -5.50020188e-02f,
  4.75558033e-03f, 3.10668886e-01f, 5.89785613e-02f, 1.52901784e-01f, 1.36527950e-02f, 3.79849039e-03f, -7.12060183e-02f, -1.31683871e-01f, -1.15506597e-01f, -1.81872860e-01f,
  -1.08726416e-02f, -1.93773825e-02f, 9.11439508e-02f, -1.63151577e-01f, -1.24881886e-01f, -9.24690515e-02f, 6.76439777e-02f, -2.98471265e-02f, -1.29717797e-01f, -3.59418429e-02f,
  -1.55629769e-01f, -3.94355729e-02f, -1.00867495e-01f, 6.39736131e-02f, -7.22922385e-02f, -9.89418179e-02f, -1.35591194e-01f, -1.62797123e-02f, -8.00699368e-02f, -1.23950792e-03f,
  -5.28496802e-02f, -2.26815380e-02f, 7.35762492e-02f, -7.19122589e-02f, 2.94381883e-02f, 1.43865168e-01f, -1.32097289e-01f, -7.72137567e-02f, -3.00679337e-02f, 3.54637764e-02f,
  -2.10297391e-01f, 8.02780911e-02f, -4.92692851e-02f, -1.56122789e-01f, -4.60931137e-02f, 9.53774825e-02f, -9.03129280e-02f, 7.77901858e-02f, 5.73520781e-03f, 2.45498195e-02f,
  1.53488755e-01f, -7.37714209e-03f, 3.96317281e-02f, -8.88509024e-03f, 5.78835942e-02f, -4.76375893e-02f, 1.11583292e-01f, 4.79646474e-02f, -7.60001466e-02f, -5.81225604e-02f,
  -1.05064638e-01f, 7.45099261e-02f, 3.10392398e-02f, -1.46322325e-01f, 6.53326735e-02f, -7.57747665e-02f, -1.67771429e-01f, -3.05145048e-02f, 2.28905335e-01f, 9.40418057e-03f,
  5.56818508e-02f, 1.65728465e-01f, 7.63955265e-02f, 7.41327405e-02f, 1.12774581e-01f, 2.90871322e-01f, 2.70623416e-01f, -1.00917414e-01f, 1.38286099e-01f, 2.19642371e-01f,
  1.24427348e-01f, 8.74349922e-02f, 1.07116498e-01f, 2.33069956e-01f, 1.15949519e-01f, 1.03790529e-01f, 2.07582846e-01f, -2.69687414e-01f, -3.39182496e-01f, 1.68320715e-01f,
  -8.74091312e-02f, -4.13179956e-02f, 1.67630866e-01f, -3.82120945e-02f, -1.01787664e-01f, -9.55014527e-02f, -1.07099377e-01f, -1.26523718e-01f, -1.56099170e-01f, 1.08161062e-01f,
  3.24107051e-01f, -1.34797946e-01f, -2.42964357e-01f, -3.67094100e-01f, -7.49000609e-02f, 3.75745416e-01f, -3.26313585e-01f, 8.97486061e-02f, 8.81693233e-03f, 5.08906841e-01f,
  7.76271448e-02f, 3.67256045e-01f, -6.70952499e-02f, 1.26460478e-01f, -3.48211706e-01f, -7.07810372e-02f, -1.43811166e-01f, -6.43709525e-02f, -4.46327925e-02f, 1.66789532e-01f,
  3.24251920e-01f, -2.85512924e-01f, 3.39180261e-01f, -2.56155115e-02f, 2.90158689e-01f, 1.72412053e-01f, 4.70510609e-02f, 3.52622159e-02f, 1.77092761e-01f, 2.72192806e-01f,
  7.92928785e-02f, -9.67948884e-02f, -1.54727504e-01f, 6.18553385e-02f, 1.48704514e-01f, -2.64014620e-02f, -1.30191045e-02f, 2.48881131e-01f, -5.89753874e-02f, -5.59264362e-01f,
  -2.54534990e-01f, 1.64167762e-01f, -1.72809243e-01f, -2.80858696e-01f, 6.46999702e-02f, -4.70192991e-02f, -6.70484081e-02f, -1.84901670e-01f, -1.11329682e-01f, -1.87327310e-01f,
  -3.64548057e-01f, 3.53984147e-01f, 1.76248685e-01f, -1.05705418e-01f, -1.95420429e-01f, 1.91386551e-01f, 3.32588032e-02f, 2.80953765e-01f, -4.60051037e-02f, 1.90980867e-01f,
  9.84851420e-02f, 1.27265334e-01f, 3.02611589e-01f, -3.03171929e-02f, -5.34605145e-01f, 2.77097702e-01f, -9.41960886e-02f, 2.67579347e-01f, -3.27407941e-02f, -4.06649083e-01f,
  2.13351920e-01f, 2.66942292e-01f, 3.16532820e-01f, -2.29242101e-01f, 1.15432471e-01f, -2.98700179e-03f, -2.55065039e-02f, 4.60054092e-02f, -6.56457664e-03f, 2.26401061e-01f,
  3.67225111e-01f, 2.15803221e-01f, 4.16752249e-02f, -2.36230373e-01f, -5.78264371e-02f, 1.48154840e-01f, -3.88085260e-03f, 1.74981002e-02f, 1.39429688e-01f, 9.87069830e-02f,
  -1.25505060e-01f, 1.64467484e-01f, 3.21344733e-02f, -4.30666395e-02f, -6.42376952e-03f, 1.46375060e-01f, -5.09889759e-02f, 6.05645450e-03f, 9.85179842e-02f, 9.43440199e-02f,
  5.46504464e-03f, -9.22382809e-03f, -5.44650257e-02f, 1.84133783e-01f, 1.37436166e-01f, 2.28151996e-02f, 2.42541105e-01f, 2.58897603e-01f, -5.15571013e-02f, 2.91090738e-02f,
  1.10045791e-01f, 1.14331499e-01f, 5.05902842e-02f, 9.21444222e-02f, 1.33352906e-01f, -1.55609563e-01f, 1.04226686e-01f, 2.19478905e-01f, -3.20234925e-01f, -1.08135611e-01f,
  1.59424067e-01f, 4.81768604e-03f, -9.67789143e-02f, 3.83047573e-02f, -2.92204052e-01f, -3.16605836e-01f, -1.94477469e-01f, -2.87568539e-01f, 8.60773101e-02f, 4.83663790e-02f,
  -1.37332855e-02f, 5.64392358e-02f, 2.56406385e-02f, -3.98989692e-02f, -2.33221352e-01f, -1.19859092e-01f, -9.97009203e-02f, -3.95868393e-03f, 4.17376310e-02f, 5.52732795e-02f,
  3.44859928e-01f, 2.89246496e-02f, -4.35338765e-01f, -1.72702998e-01f, -4.00957793e-01f, 8.54525715e-02f, 1.31918818e-01f, 3.00021440e-01f, 4.06195670e-01f, -5.04755974e-02f,
  7.07481951e-02f, 6.42148331e-02f, 2.95869738e-01f, 2.84187913e-01f, 7.04734698e-02f, 1.96813747e-01f, 3.61909121e-01f, 3.61929178e-01f, 2.58446515e-01f, -9.92897823e-02f,
  8.64015445e-02f, 4.85968739e-02f, 1.74333259e-01f, 4.00484800e-02f, 2.41029426e-01f, 6.03698604e-02f, 6.36607856e-02f, 2.59571075e-01f, 1.32179260e-01f, 2.20695082e-02f,
  8.04757923e-02f, 1.87952384e-01f, 2.88228616e-02f, 1.04878377e-02f, 8.65605623e-02f, 1.90490223e-02f, 3.16380374e-02f, 1.63977429e-01f, 3.28386486e-01f, -3.26667070e-01f,
  -2.87326604e-01f, 1.41562819e-01f, -8.71884078e-02f, -2.01508641e-01f, 3.20498437e-01f, -1.76374808e-01f, 1.12670630e-01f, -5.51204160e-02f, -1.39168471e-01f, 2.62722731e-01f,
  -1.55294416e-02f, -1.06194161e-01f, 2.74502575e-01f, -2.00125143e-01f, -2.22040772e-01f, -2.11064175e-01f, -6.40594587e-02f, 2.26527944e-01f, -2.69738853e-01f, 2.42182106e-01f,
  2.36989066e-01f, 3.64950597e-01f, 2.53812581e-01f, 3.77917886e-01f, 4.19886746e-02f, 3.72050516e-02f, -2.25402892e-01f, 9.08568949e-02f, -1.70111567e-01f, 6.67739362e-02f,
  -1.76182255e-01f, 5.67114428e-02f, -3.80188882e-01f, -1.36998191e-01f, 4.51405227e-01f, -1.14123970e-01f, 2.27148488e-01f, 2.71442056e-01f, -3.22143291e-03f, 2.05859005e-01f,
  -6.80306405e-02f, -3.58990878e-02f, 1.73297137e-01f, -2.51010329e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -1.06003415e-02f, 1.86108783e-01f, 2.13655680e-01f, 1.40317738e-01f, 3.38262431e-02f, -3.55967553e-03f, 1.85117409e-01f, 1.05336420e-01f, 1.65193081e-01f, 1.59349650e-01f,
  1.40608832e-01f, 6.54989621e-03f, 1.06585331e-01f, -2.33364031e-02f, 1.76580325e-01f, 8.78682584e-02f, 7.15715364e-02f, 1.75573558e-01f, 4.95214425e-02f, 3.54152545e-02f,
  2.83236918e-03f, 3.04027982e-02f, 1.90121397e-01f, -1.56730786e-02f, 6.80415519e-03f, 9.25118625e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  3.26674320e-02f, 1.13582186e-01f, 8.59610438e-02f, 1.99763075e-01f, 1.70856401e-01f, -2.30187237e-01f, -6.64459392e-02f, 5.06244674e-02f, -4.01053280e-02f, -1.24138556e-01f,
  1.46912694e-01f, -6.23034760e-02f, -2.62074441e-01f, -7.77295753e-02f, 1.36357471e-01f, -8.01213384e-02f, -7.29547720e-03f, -1.10539891e-01f, -4.85453159e-02f, -4.00009006e-01f,
  -1.66213736e-01f, -1.15003079e-01f, 2.00039923e-01f, -1.39150605e-01f, -6.69542328e-02f, 3.72339673e-02f, -3.80359799e-01f, -2.58786172e-01f, 2.80344903e-01f, -2.04547852e-01f,
  1.50678366e-01f, -5.60075194e-02f, 9.93054360e-02f, -1.35140866e-01f, -3.99872428e-03f, 3.21289569e-01f, -1.08744865e-02f, 2.35707834e-01f, -2.22626999e-01f, -5.09813428e-01f,
  -3.21145475e-01f, 3.12690549e-02f, -3.31964940e-01f, 1.68882281e-01f, 6.80157393e-02f, -2.75497019e-01f, 1.53385639e-01f, 1.00969613e-01f, -2.62079269e-01f, 1.83357492e-01f,
  7.13060945e-02f, 2.05798060e-01f, -2.34118268e-01f, -1.88379601e-01f, -2.26623770e-02f, -3.68878126e-01f, 2.83534080e-01f, -3.60737473e-01f, 2.45331764e-01f, 1.04012422e-01f,
  -3.99104446e-01f, 1.69200018e-01f, -1.80032223e-01f, -1.47258192e-01f, 2.36762449e-01f, -2.53833681e-01f, 5.14382087e-02f, -1.85145169e-01f, 5.48535027e-02f, -5.59141785e-02f,
  3.13236415e-02f, 1.41071659e-02f, 1.69063702e-01f, 5.13472073e-02f, -1.35624707e-01f, -9.53508690e-02f, 1.32992864e-01f, 2.18930036e-01f, -1.11645244e-01f, 2.81410292e-03f,
  -5.79983145e-02f, 9.11367014e-02f, 9.34160799e-02f, -6.82397336e-02f, -2.11365327e-01f, -1.51092678e-01f, 1.93507597e-01f, -2.88995087e-01f, -3.88276279e-01f, 2.04471305e-01f,
  -2.14922488e-01f, 1.59985989e-01f, 1.46337718e-01f, -9.46172699e-02f, 1.22379713e-01f, -1.12288021e-01f, -2.79295772e-01f, -2.18008995e-01f, 9.61571038e-02f, 2.22688183e-01f,
  2.39004061e-01f, 2.42770299e-01f, -1.20932266e-01f, 6.78617135e-02f, 7.37122670e-02f, -1.11081347e-01f, -2.30373144e-01f, -2.82641560e-01f, 2.21588358e-01f, 2.50571936e-01f,
  6.63787648e-02f, 1.46435663e-01f, -1.61728114e-01f, 2.28956163e-01f, 1.13650724e-01f, -1.41936108e-01f, 1.45043824e-02f, -5.31200349e-01f, 1.54962316e-01f, -2.40899846e-01f,
  -1.01660267e-01f, 2.19204932e-01f, 7.59159699e-02f, -1.27265051e-01f, -3.20646435e-01f, -1.80651005e-02f, -3.83196622e-01f, -3.64853740e-01f, -1.38406962e-01f, -5.24790734e-02f,
  7.37592056e-02f, -1.66111469e-01f, -1.43559277e-01f, 1.25439376e-01f, -4.61617857e-02f, -3.34858559e-02f, 1.69072673e-02f, 5.08375131e-02f, -2.06207320e-01f, 3.97733375e-02f,
  4.54962291e-02f, 1.28526419e-01f, 3.93213006e-03f, -1.84405595e-01f, -1.28488883e-01f, -4.15003821e-02f, 6.31525666e-02f, -2.58733630e-01f, 1.60487533e-01f, -2.18662947e-01f,
  -8.92173275e-02f, -8.27725008e-02f, 2.91919149e-02f, -1.05782732e-01f, -2.39365533e-01f, -2.35810161e-01f, 1.37078002e-01f, -1.19170966e-02f, -1.21885046e-01f, 1.92289911e-02f,
  1.63057953e-01f, 9.25296471e-02f, -1.51466150e-02f, 2.77675271e-01f, -2.86385238e-01f, 4.97813802e-03f, -3.65906775e-01f, 1.87152296e-01f, 2.43616536e-01f, -3.49255413e-01f,
  1.74929239e-02f, -9.75775123e-02f, 1.88960165e-01f, 1.83849454e-01f, -1.92240439e-02f, -9.23242792e-02f, 2.58265048e-01f, -2.34410584e-01f, -3.37033063e-01f, -6.04682565e-02f,
  -3.77218485e-01f, 1.18548542e-01f, -4.35958713e-01f, -3.29905897e-02f, 3.55687559e-01f, 2.77437060e-03f, 1.85924694e-01f, -1.03989884e-01f, -1.38787255e-01f, -3.15109342e-02f,
  3.57763469e-03f, -3.66360486e-01f, -6.35760557e-03f, -1.16100140e-01f, -1.83632746e-01f, -4.81424630e-02f, 1.25547573e-01f, 5.23198470e-02f, 1.14543796e-01f, 1.29477233e-01f,
  1.66303962e-01f, -2.47148722e-01f, -6.63257837e-02f, 1.87703997e-01f, 1.15024410e-02f, -1.53520167e-01f, 4.21154611e-02f, -7.45330229e-02f, 1.40107915e-01f, 7.66086653e-02f,
  -2.26191461e-01f, -2.41190493e-01f, 1.25615612e-01f, 1.87115744e-01f, -3.11884254e-01f, 2.63861120e-01f, 4.65021543e-02f, 7.27269277e-02f, -2.31277183e-01f, -3.69976580e-01f,
  -1.96110066e-02f, 2.57359385e-01f, -1.28719300e-01f, 2.47305498e-01f, 4.77956943e-02f, 2.73563534e-01f, 1.52830005e-01f, 7.26579428e-02f, 3.55991662e-01f, -7.69949108e-02f,
  2.81268924e-01f, -1.95858330e-01f, -4.39366877e-01f, 6.16261847e-02f, -4.96016473e-01f, -2.01975703e-01f, -4.11495239e-01f, -5.18549941e-02f, 2.81079262e-01f, -2.50635058e-01f,
  -1.40784457e-01f, -1.81079060e-01f, 7.55249262e-02f, -4.52944040e-01f, -3.35426897e-01f, 5.78310043e-02f, -1.50360018e-02f, -9.23053101e-02f, -1.45341428e-02f, -4.27941740e-01f,
  2.46032044e-01f, -3.27482931e-02f, 2.22360477e-01f, -2.07082912e-01f, -1.09725669e-01f, 2.92080969e-01f, -7.30233714e-02f, -5.28603271e-02f, 2.69948721e-01f, 2.32327804e-01f,
  -1.68066368e-01f, -1.29610702e-01f, 1.41372219e-01f, -4.59231064e-02f, -1.63603708e-01f, 2.88548499e-01f, -6.91346824e-02f, 5.54031618e-02f, -3.44549827e-02f, -1.13007940e-01f,
  3.56325544e-02f, 1.57802582e-01f, 1.46119222e-01f, -7.30020776e-02f, 2.81296283e-01f, 2.63831139e-01f, 2.49542713e-01f, 3.95592861e-02f, -6.08165711e-02f, 3.54173221e-02f,
  -2.19137952e-01f, -1.20783344e-01f, 2.94081926e-01f, -4.53374013e-02f, -1.79195642e-01f, 4.81718481e-02f, 2.97545820e-01f, -2.27923706e-01f, 1.45510182e-01f, 1.03834286e-01f,
  1.06856443e-01f, 1.07502580e-01f, 1.64095834e-01f, -1.32552654e-01f, 5.58437295e-02f, -3.53408813e-01f, -2.49581501e-01f, 1.54709056e-01f, 1.10584997e-01f, 1.73330575e-01f,
  9.32432786e-02f, -3.17901045e-01f, -4.08860482e-03f, -7.14863837e-02f, -2.24560082e-01f, -7.18518952e-03f, 1.36135906e-01f, 1.26887441e-01f, -1.13801397e-01f, 2.23775193e-01f,
  -1.22919321e-01f, -1.58169404e-01f, 8.87216926e-02f, -7.28756711e-02f, -4.73167002e-02f, 2.17169747e-01f, 6.13842867e-02f, -5.16051769e-01f, 1.71383217e-01f, 2.08612695e-01f,
  -1.34795070e-01f, 2.18995929e-01f, 5.45448475e-02f, -1.99906006e-02f, -1.60927147e-01f, -1.08121755e-02f, 1.57079816e-01f, 1.00695416e-01f, 9.01412144e-02f, 1.01438053e-01f,
  1.77183971e-01f, 1.17860630e-01f, -1.58770204e-01f, 6.82193935e-02f, 2.17438847e-01f, 2.12497264e-02f, -1.34635434e-01f, -5.72863780e-02f, 7.89591298e-02f, 1.02055773e-01f,
  -5.46436608e-02f, -2.35053912e-01f, 1.19846880e-01f, 2.63463259e-01f, 2.52708495e-01f, 1.91852763e-01f, 2.83522487e-01f, -4.11630496e-02f, 1.12911306e-01f, -9.27237943e-02f,
  4.54274230e-02f, -1.68868303e-01f, -1.10416509e-01f, -2.31849644e-02f, -3.14448774e-01f, -2.37146854e-01f, 3.00030589e-01f, 2.52508938e-01f, -2.80838251e-01f, 1.93010628e-01f,
  -2.28107572e-01f, 2.87450492e-01f, 1.48211956e-01f, 4.28337045e-02f, 4.09781979e-03f, 1.25885040e-01f, -3.03161532e-01f, -1.25806019e-01f, -4.15840924e-01f, 7.91401267e-02f,
  -1.25246301e-01f, 1.63125068e-01f, 2.33848408e-01f, 1.41554447e-02f, 2.34967917e-01f, 6.67100474e-02f, -2.46901721e-01f, -1.38883427e-01f, -3.55899841e-01f, 1.60852134e-01f,
  -2.57434726e-01f, 2.71596372e-01f, -3.34546156e-02f, 7.79469125e-03f, 1.01022884e-01f, -1.95436731e-01f, -1.56688824e-01f, -2.06236944e-01f, 1.07474051e-01f, -7.39512919e-03f,
  -1.94589421e-01f, -3.82009931e-02f, 2.07811221e-01f, 4.68892604e-02f, -1.33471014e-02f, -4.91272211e-02f, -2.16995180e-02f, 8.96745250e-02f, 9.34750587e-02f, -1.51536679e-02f,
  -1.18171625e-01f, 3.32656801e-02f, -6.51326329e-02f, 1.57098532e-01f, -1.74644113e-01f, 5.39442189e-02f, 8.64849146e-03f, 1.55147716e-01f, 1.11077517e-01f, -1.90995470e-01f,
  1.64174154e-01f, -1.74139068e-01f, 8.90581086e-02f, 2.15312496e-01f, 8.10941309e-02f, 2.30157852e-01f, -3.31301600e-01f, -2.64355689e-01f, 1.90414548e-01f, -1.69165716e-01f,
  -3.56639236e-01f, 5.84265254e-02f, 1.23950867e-02f, 1.76117986e-01f, 4.37591448e-02f, -2.04037666e-01f, 7.26804063e-02f, 3.44484374e-02f, 1.83894873e-01f, 1.80821568e-01f,
  -4.50249225e-01f, -1.42023340e-01f, 2.81774044e-01f, 9.30195004e-02f, -4.91317689e-01f, -1.78882591e-02f, 2.03703791e-01f, 2.97098178e-02f, -3.46798092e-01f, 1.93819270e-01f,
  -5.23939192e-01f, 1.15654036e-01f, -2.65611649e-01f, -1.14686497e-01f, -4.62440163e-04f, -9.15308818e-02f, 1.73710451e-01f, -5.69252409e-02f, 3.51719856e-02f, 6.75445795e-02f,
  -2.07860097e-01f, -2.07471490e-01f, -1.43170223e-01f, 6.31914064e-02f, 8.04025978e-02f, -7.02049658e-02f, 7.55510405e-02f, -5.84595166e-02f, 7.12018237e-02f, -7.24897906e-02f,
  3.08409296e-02f, -1.80314258e-01f, -5.82668595e-02f, 1.07159756e-01f, -6.66887611e-02f, -5.91825768e-02f, 5.54824583e-02f, 1.43832579e-01f, 9.67258364e-02f, 1.74754679e-01f,
  -2.23165125e-01f, 1.24987677e-01f, -1.36434525e-01f, 2.34622091e-01f, 2.56406665e-01f, -6.23845905e-02f, -1.70085177e-01f, 1.85741857e-01f, 1.88065264e-02f, -1.54928997e-01f,
  5.30322567e-02f, -2.12520644e-01f, 4.39693443e-02f, -2.61681080e-01f, 1.35495688e-03f, -2.37569958e-01f, -2.10272565e-01f, -1.22616403e-01f, -1.03479862e-01f, 2.48067945e-01f,
  -2.70387590e-01f, 1.41343968e-02f, -3.96366984e-01f, -1.41054645e-01f, 1.81547329e-01f, 1.49506986e-01f, -1.27741292e-01f, 1.78721175e-01f, 1.84743494e-01f, -3.61070484e-01f,
  -2.84691900e-01f, 2.38836378e-01f, 3.16686481e-01f, -1.55575305e-01f, -2.50817090e-01f, -2.07817584e-01f, -5.93262389e-02f, -4.75361049e-02f, -3.10836256e-01f, 6.00446723e-02f,
  -1.10005036e-01f, -3.09760749e-01f, 7.10436478e-02f, 1.11966044e-01f, -1.52791083e-01f, 1.59890428e-01f, 3.44932415e-02f, 6.74140826e-02f, -7.37744719e-02f, -2.07896344e-02f,
  -2.07716778e-01f, 7.84079880e-02f, -1.13349274e-01f, 1.21007496e-02f, -4.64388989e-02f, -1.92968592e-01f, -2.38415712e-04f, 3.23467031e-02f, 7.67978281e-02f, 4.72008809e-02f,
  1.59027457e-01f, -9.39510763e-02f, -1.53931677e-01f, 2.34056041e-01f, 1.17350947e-02f, -3.15124579e-02f, 4.00631875e-01f, 5.74673973e-02f, -2.08653569e-01f, 8.10053349e-02f,
  2.31676057e-01f, -9.77398306e-02f, -2.99660772e-01f, -1.97421029e-01f, -1.50810137e-01f, -1.00549519e-01f, -6.05230592e-02f, -3.19089592e-01f, -4.40587439e-02f, 1.41759487e-02f,
  -3.05407852e-01f, 2.25946382e-01f, 2.06313089e-01f, -3.16896647e-01f, -2.17643693e-01f, -2.48436630e-01f, -3.43808442e-01f, 2.44103327e-01f, 6.20588958e-02f, -2.54228085e-01f,
  2.33565062e-01f, -2.42327407e-01f, 1.14432789e-01f, -4.12249148e-01f, 1.19017646e-01f, -1.03584431e-01f, 1.35005161e-01f, 1.93339691e-01f, -3.41880649e-01f, 2.26390496e-01f,
  -4.69981104e-01f, -9.91722792e-02f, -3.59308302e-01f, 1.05860248e-01f, -1.48568183e-01f, -2.98217982e-01f, 6.57034814e-02f, 5.03728576e-02f, -6.91248626e-02f, -4.05614451e-02f,
  1.26103848e-01f, 2.36439496e-01f, -2.30656520e-01f, -1.24780603e-01f, -1.81789085e-01f, -1.44057587e-01f, 8.61354098e-02f, -1.65296778e-01f, 1.59697682e-01f, -1.81868672e-01f,
  -1.82190403e-01f, -2.40526319e-01f, 8.32026377e-02f, 3.75078693e-02f, -6.82592094e-02f, 1.82364002e-01f, -2.51022249e-01f, -1.54314637e-01f, 2.27656558e-01f, -1.96722046e-01f,
  3.29045922e-01f, -5.81277981e-02f, 1.28842786e-01f, 5.33417165e-02f, 1.51539922e-01f, 7.32321367e-02f, -2.01247022e-01f, -1.44424200e-01f, 2.25660399e-01f, -2.17124492e-01f,
  3.28734703e-02f, -1.69831023e-01f, -1.16258070e-01f, -1.31391268e-03f, 1.88875869e-01f, -9.97093320e-02f, 2.71811299e-02f, -6.08325563e-02f, 2.07687929e-01f, 2.50832140e-01f,
  9.55168381e-02f, -6.81206435e-02f, -4.35618639e-01f, 2.31218904e-01f, -2.81742543e-01f, 1.19532794e-01f, -4.89026994e-01f, 2.05210730e-01f, -1.20052829e-01f, 1.81737449e-02f,
  -2.71052420e-01f, -4.11521524e-01f, 2.15230688e-01f, -5.23247756e-02f, 1.54002663e-02f, 4.96142693e-02f, 1.05389118e-01f, -3.27044517e-01f, 1.68594763e-01f, -5.29718306e-03f,
  -6.23025522e-02f, 1.70781374e-01f, 5.09077348e-02f, 8.35286453e-03f, 1.02940321e-01f, -1.29044503e-01f, -8.37777450e-04f, -1.66528136e-01f, -6.36887252e-02f, 5.70167638e-02f,
  9.28442702e-02f, -7.76658300e-03f, 1.54208109e-01f, 2.77378410e-01f, -1.07856113e-02f, 8.74011870e-03f, 3.63234058e-02f, 1.25980750e-01f, -1.22723624e-01f, -1.55301154e-01f,
  2.83671077e-02f, 1.91465586e-01f, 2.16786280e-01f, -3.48391712e-01f, -2.89079815e-01f, -1.98284552e-01f, 1.56740472e-02f, 2.08974496e-01f, -2.75719792e-01f, -2.56374717e-01f,
  -1.63395286e-01f, 1.68559179e-01f, -1.94665119e-01f, -2.30941176e-01f, 1.55699208e-01f, 1.84961170e-01f, -3.55446905e-01f, -1.42740473e-01f, -6.32044077e-02f, -3.27547550e-01f,
  1.86272070e-01f, -3.82161468e-01f, -1.95604533e-01f, -1.80374905e-02f, -3.41898575e-02f, -3.06750417e-01f, 1.42457843e-01f, -2.85215974e-01f, 2.12260604e-01f, -1.01123884e-01f,
  2.38176271e-01f, -2.96354204e-01f, 1.20760553e-01f, -7.04305321e-02f, 1.05009608e-01f, 2.47981191e-01f, -5.69020510e-02f, 8.57553035e-02f, 6.00844435e-02f, 5.39112538e-02f,
  5.44700511e-02f, -3.03780377e-01f, -2.60248929e-01f, 2.18857452e-01f, -1.04530908e-01f, 5.67913540e-02f, -4.86267498e-03f, 2.03012854e-01f, -1.73657715e-01f, 1.56789541e-01f,
  1.71726141e-02f, 1.57949746e-01f, -8.87772813e-02f, -4.66318801e-03f, -2.14300632e-01f, 9.96560827e-02f, -6.67211115e-02f, -1.37048647e-01f, 1.85361616e-02f, 1.79286808e-01f,
  -8.40390325e-02f, 4.34261002e-02f, 2.58329883e-02f, 8.53018463e-02f, 2.56937414e-01f, 1.84464216e-01f, -9.34047699e-02f, 1.89337447e-01f, 2.87093431e-01f, -6.68662190e-02f,
  1.48635447e-01f, 2.48160869e-01f, -2.66216934e-01f, 2.52446353e-01f, -2.94555068e-01f, 2.03202710e-01f, -2.37970144e-01f, 3.28120440e-01f, -1.12272300e-01f, -2.57174373e-01f,
  -1.80573478e-01f, -1.43430784e-01f, 2.95919627e-01f, 1.44883156e-01f, -3.29886705e-01f, -1.36359185e-01f, 2.57696688e-01f, 1.08161382e-01f, -7.19181076e-02f, -3.55470061e-01f,
  -2.22989216e-01f, -4.32554305e-01f, -2.39713982e-01f, -2.95343727e-01f, -8.52251425e-02f, -1.38231039e-01f, 2.30194524e-01f, -8.19649398e-02f, -2.23181486e-01f, 2.72925735e-01f,
  -3.42770487e-01f, 9.39499289e-02f, -3.79465133e-01f, -1.40055940e-01f, 1.98602244e-01f, 6.45098388e-02f, -6.85922429e-02f, 3.36306751e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.59527361e-02f, -8.27494562e-02f, -4.74365465e-02f, 7.65820593e-02f, -7.08361622e-03f, -3.90246697e-02f, -1.01336375e-01f, -1.12156421e-01f, 7.34854713e-02f, 5.87360412e-02f,
  1.80667471e-02f, -2.51858383e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    