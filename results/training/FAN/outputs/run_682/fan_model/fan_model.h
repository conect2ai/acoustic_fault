/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.84941262e-02f, 1.12410381e-01f, 2.52587199e-01f, 1.86241210e-01f, -6.78178295e-02f, -2.43469954e-01f, -5.60274720e-02f, -1.66348457e-01f, -2.24148631e-01f, 9.02516395e-02f,
  -9.50760692e-02f, -2.78494418e-01f, -9.42125320e-02f, -1.63230926e-01f, -1.41593754e-01f, 1.59037307e-01f, 1.46347940e-01f, 3.51257585e-02f, -3.14574599e-01f, -2.76551306e-01f,
  -2.54748732e-01f, -1.12749627e-02f, -8.22401792e-02f, -7.47575238e-02f, 1.00134745e-01f, -2.08899647e-01f, 1.03793763e-01f, 7.39879087e-02f, -1.47084761e-02f, 2.74051428e-01f,
  9.77755785e-02f, 3.30821685e-02f, -2.61835873e-01f, -1.27895698e-01f, -1.71371549e-01f, -1.87523082e-01f, -1.53429165e-01f, -6.99970722e-02f, -2.18252465e-01f, -3.62364575e-02f,
  -4.93123941e-02f, -1.89229310e-01f, -5.30028902e-02f, -1.56598687e-01f, -1.18944600e-01f, -1.83579758e-01f, -9.30641741e-02f, -4.62746322e-02f, -7.74604380e-02f, -1.16483517e-01f,
  -1.16325252e-01f, -2.17905238e-01f, -1.04766384e-01f, -1.62338436e-01f, -1.67496741e-01f, -1.85909480e-01f, -6.23223931e-02f, -1.99160665e-01f, -2.61297882e-01f, -4.67030294e-02f,
  8.94459486e-02f, 1.52161196e-02f, 1.06942676e-01f, 1.19390026e-01f, 1.51238754e-01f, 7.54091889e-02f, 6.47905692e-02f, 1.49999082e-01f, 3.28403264e-02f, 1.27158225e-01f,
  7.41274357e-02f, 1.14649363e-01f, 2.74220649e-02f, 1.31634012e-01f, 3.34726162e-02f, 2.18655802e-02f, -3.91877852e-02f, 1.34080529e-01f, 1.06228860e-02f, 2.15474106e-02f,
  8.42063427e-02f, -7.48476898e-03f, 7.72961602e-02f, 1.56226205e-02f, 3.97896655e-02f, 1.36063144e-01f, 2.70393118e-03f, -3.62283294e-03f, 1.45764157e-01f, 2.51123141e-02f,
  -4.04514909e-01f, -3.92880470e-01f, -1.35609403e-01f, -1.42497078e-01f, -4.35660779e-02f, -1.51320428e-01f, -1.51000649e-01f, -1.49941280e-01f, -1.50685236e-01f, -2.28470877e-01f,
  -1.74565524e-01f, -8.10296610e-02f, -1.45761192e-01f, -1.11910932e-01f, -1.18967190e-01f, -1.43700838e-01f, -1.98896807e-02f, -1.19920246e-01f, -1.50311545e-01f, -7.45153800e-02f,
  -8.44605640e-03f, -2.23775581e-01f, -2.17132002e-01f, -2.49221295e-01f, -2.62889326e-01f, -2.95407504e-01f, -2.52877802e-01f, -1.79304808e-01f, -2.89471865e-01f, -2.57696122e-01f,
  8.67530331e-02f, -9.71772149e-02f, -5.28904080e-01f, 2.57380068e-01f, 3.10706824e-01f, 1.55792221e-01f, 1.59828559e-01f, 8.07633474e-02f, 1.59087956e-01f, -1.62328258e-02f,
  -1.11144170e-01f, -1.24048404e-01f, -3.41214597e-01f, -2.95262933e-01f, -2.78930098e-01f, -8.50278512e-02f, -1.19016834e-01f, -2.80763268e-01f, -2.14528129e-01f, 3.30362409e-01f,
  2.44104609e-01f, 2.36513302e-01f, -4.27682884e-02f, -6.65709330e-03f, 2.08405107e-01f, 1.50257275e-02f, -1.98206276e-01f, 1.20400064e-01f, -7.99491778e-02f, 1.22525662e-01f,
  -1.88217849e-01f, -5.30435331e-02f, -1.07798174e-01f, 4.66122478e-02f, -1.82796142e-03f, -4.51588584e-03f, -1.41885336e-02f, -5.13529852e-02f, -4.77851508e-03f, -6.06717765e-02f,
  1.79611165e-02f, -5.58338733e-03f, 5.41877337e-02f, 3.62264998e-02f, -1.61175593e-03f, -8.11542124e-02f, -1.11408822e-01f, -1.78195715e-01f, -1.19226038e-01f, -7.77241066e-02f,
  1.97424889e-01f, 1.40268996e-01f, -2.02130154e-02f, -5.93140498e-02f, -1.83534205e-01f, -7.63699114e-02f, -1.36233866e-01f, -9.26284343e-02f, -1.71761230e-01f, -5.86536452e-02f,
  1.11931875e-01f, -8.13669935e-02f, 8.25773999e-02f, 1.78172961e-01f, 7.10284039e-02f, 2.52406877e-02f, -1.66394003e-02f, -6.35254523e-03f, 3.07999756e-02f, 7.57930875e-02f,
  -8.21275264e-02f, 1.13725429e-02f, -1.45055419e-02f, -4.10985984e-02f, 2.07945425e-02f, -5.99482730e-02f, -1.86818652e-02f, -1.94238555e-02f, 1.89490262e-02f, -1.21481922e-02f,
  -5.72602265e-03f, -1.77580174e-02f, 5.98672926e-02f, 6.20302337e-04f, -6.99273916e-03f, -8.58280286e-02f, -2.60008704e-02f, 8.74036700e-02f, -1.14751970e-02f, 8.04916918e-02f,
  -4.98478748e-02f, -3.47858667e-01f, 1.98222212e-02f, -2.82009542e-02f, 7.70831555e-02f, -3.67958471e-02f, 2.06127530e-03f, -7.71084875e-02f, 2.53883041e-02f, -9.55939889e-02f,
  3.46659822e-03f, -4.45536338e-02f, -1.24449119e-01f, 4.93561709e-03f, 4.78626154e-02f, 2.47975253e-02f, 6.69866130e-02f, 2.54555754e-02f, -8.36246312e-02f, 4.83182855e-02f,
  -2.60339659e-02f, 4.78773490e-02f, -1.08841240e-01f, -1.38359264e-01f, 3.92249227e-02f, -6.55622333e-02f, -5.28935529e-02f, -7.25180432e-02f, -9.60705578e-02f, 4.77282666e-02f,
  5.36600292e-01f, 3.83339263e-02f, -1.56609528e-02f, 1.44279078e-01f, -7.61401802e-02f, 2.67108262e-01f, 4.28493053e-01f, 2.72199363e-01f, 4.38254932e-03f, 1.08215779e-01f,
  -1.64404720e-01f, -3.15018356e-01f, -3.26926589e-01f, -2.41380572e-01f, 4.26784940e-02f, 1.24342605e-01f, 4.66305576e-02f, -3.56415808e-02f, 1.61492247e-02f, 2.51824796e-01f,
  5.41741736e-02f, 1.90610588e-01f, 2.05337405e-01f, 3.06569948e-03f, -6.09900206e-02f, -7.73491114e-02f, -8.70554447e-02f, -6.60329834e-02f, -1.38245791e-01f, -3.42657454e-02f,
  -7.89911076e-02f, -3.65927704e-02f, 2.57955864e-03f, -1.25021353e-01f, -2.25960299e-01f, 1.58308297e-02f, 6.58201054e-02f, -7.44396597e-02f, -3.51063348e-02f, -1.56018268e-02f,
  -9.49474722e-02f, -1.07555605e-01f, -9.72277671e-02f, -8.71068686e-02f, -7.74555421e-03f, 7.45873824e-02f, 1.82211422e-03f, -4.45490442e-02f, -7.68669397e-02f, -6.21280335e-02f,
  -6.42277375e-02f, -7.48015419e-02f, -7.86397315e-04f, -3.80101129e-02f, -1.45074651e-01f, -2.18137637e-01f, -4.38046977e-02f, 1.89641193e-02f, 8.68340023e-03f, 3.71677019e-02f,
  -1.65977515e-02f, -5.66456327e-03f, -8.58973935e-02f, 2.73575447e-02f, -3.98362763e-02f, -1.43808782e-01f, -1.11877974e-02f, -2.90619936e-02f, -4.16877493e-03f, 4.77259122e-02f,
  -7.73509145e-02f, -3.63640301e-02f, -7.82301202e-02f, 2.51619630e-02f, -3.39456648e-02f, -8.32168683e-02f, 7.05428272e-02f, 7.83187337e-03f, -8.39595571e-02f, 6.54839054e-02f,
  -8.35142657e-02f, -5.40375896e-02f, -4.09665667e-02f, -6.21206500e-02f, -3.83375911e-03f, -3.17795165e-02f, 5.42881191e-02f, -4.33705449e-02f, -2.36262158e-02f, -1.67570561e-02f,
  1.27742261e-01f, -1.92527786e-01f, 1.03393393e-02f, 4.87629957e-02f, -4.87036295e-02f, -7.31438473e-02f, -1.40080094e-01f, -6.75362051e-02f, -1.21561073e-01f, 5.19353040e-02f,
  -3.35824452e-02f, 1.44054899e-02f, -8.31311196e-02f, 3.70242521e-02f, 1.39965057e-01f, -2.38631247e-03f, 4.51986305e-02f, -1.71816889e-02f, 7.63876177e-03f, 4.68821153e-02f,
  3.83217353e-03f, 1.60049140e-01f, 2.15042800e-01f, 3.41620222e-02f, 3.43051814e-02f, 3.92750539e-02f, 1.39191076e-01f, 4.94810268e-02f, 1.49942338e-01f, 3.97088259e-01f,
  -4.66074586e-01f, 3.91631126e-01f, 2.19111219e-01f, -1.41608000e-01f, 1.59980312e-01f, 1.60560742e-01f, 3.59317154e-01f, -2.69841775e-03f, -1.75961927e-01f, 6.46136403e-02f,
  -6.42618388e-02f, -2.35568985e-01f, -2.68544883e-01f, -2.19719395e-01f, -4.31969427e-02f, 3.02287787e-01f, 3.12233478e-01f, -4.96983305e-02f, -3.43892753e-01f, -1.99928805e-01f,
  5.95233552e-02f, 4.42719571e-02f, -8.23199153e-02f, -3.97585146e-02f, 9.81087387e-02f, -5.10493666e-02f, 2.01669097e-01f, 1.31997734e-01f, 2.30790839e-01f, 2.28421211e-01f,
  -1.84882313e-01f, 1.28281429e-01f, -1.59778595e-01f, -2.36627422e-02f, 5.05433716e-02f, -6.33447319e-02f, 9.43723787e-03f, -5.07470332e-02f, 2.50926036e-02f, 1.88010763e-02f,
  3.18250619e-02f, 2.41136011e-02f, 1.46843260e-02f, 2.27067638e-02f, 4.83931005e-02f, 4.10814323e-02f, 9.12774280e-02f, -3.33786346e-02f, 1.58286409e-03f, 3.18170688e-03f,
  5.52764386e-02f, 9.91896912e-02f, -5.71314432e-02f, 3.17603275e-02f, 2.30067540e-02f, -5.52949235e-02f, 1.93635002e-02f, 1.11180861e-02f, 6.35970011e-02f, 3.63586433e-02f,
  -4.72865105e-02f, 6.76652044e-02f, 7.99227431e-02f, -2.59448495e-02f, 1.69376228e-02f, 5.37639158e-03f, 8.96491203e-03f, -5.15331142e-03f, -4.27292995e-02f, -2.81124692e-02f,
  1.88651178e-02f, 1.67451203e-02f, -3.05665992e-02f, -2.60319058e-02f, -3.83872911e-02f, 6.18931167e-02f, 1.95124205e-02f, 3.38086451e-04f, 2.68648355e-03f, 1.65166482e-02f,
  -6.52137101e-02f, -3.57873738e-02f, -7.90046602e-02f, -2.45677028e-02f, 4.76484820e-02f, -2.05135327e-02f, -2.74888147e-02f, 5.96098714e-02f, -7.50471056e-02f, 7.75550604e-02f,
  -2.88595051e-01f, 9.91633311e-02f, -2.10592113e-02f, -9.87151936e-02f, 3.14480290e-02f, 2.04480235e-02f, -2.21485142e-02f, -7.33207911e-02f, -8.24110676e-03f, 1.97860040e-03f,
  -1.67143010e-02f, -8.21827576e-02f, 4.06776415e-03f, 2.48898342e-02f, 5.42110810e-03f, -9.89659503e-02f, 8.72415155e-02f, -7.58821815e-02f, 3.47287767e-02f, 1.78893171e-02f,
  1.19786277e-01f, 2.03656461e-02f, -2.34227806e-01f, -1.01920664e-01f, -3.48861702e-02f, -2.16246262e-01f, -9.26182121e-02f, -3.24462987e-02f, -1.66408777e-01f, -6.12369664e-02f,
  -2.05840543e-01f, -3.28033268e-02f, -1.29492640e-01f, 4.23479713e-02f, 1.19418658e-01f, 2.42473811e-01f, 2.93610096e-01f, 1.82389721e-01f, 7.97643587e-02f, 5.45386784e-02f,
  -3.61943059e-02f, -6.73019141e-02f, 3.68762463e-02f, 1.33191809e-01f, 2.10282773e-01f, 2.62163579e-01f, 2.35703602e-01f, 6.30988404e-02f, 1.87618092e-01f, 2.47129425e-01f,
  1.95052981e-01f, 4.12810855e-02f, -3.37294154e-02f, -1.26975914e-03f, -6.26502931e-02f, 9.46652144e-02f, -4.04183790e-02f, 4.19781916e-02f, 1.84554756e-02f, -7.18632191e-02f,
  -1.73845068e-01f, -3.38631183e-01f, 3.31725776e-02f, -6.28600568e-02f, -9.76305678e-02f, 7.73640769e-03f, 4.32416573e-02f, -1.22633554e-01f, 2.09081732e-02f, 2.50679590e-02f,
  -3.28048132e-02f, -5.35251684e-02f, -4.12925109e-02f, -7.83523619e-02f, -2.94517092e-02f, -1.38809485e-02f, 4.77222651e-02f, 3.32537517e-02f, -5.53451432e-03f, 5.02553955e-03f,
  4.66403365e-02f, -7.98936654e-03f, 1.00156866e-01f, 5.85037991e-02f, -9.68697760e-03f, 4.26296238e-03f, -9.28895026e-02f, -9.67072472e-02f, 5.47708897e-03f, 8.61876085e-02f,
  -5.84647730e-02f, -1.07650697e-01f, -7.54368454e-02f, -2.61237901e-02f, 8.89349505e-02f, 9.43212025e-03f, -5.58602437e-02f, 1.95223596e-02f, -7.09088817e-02f, 2.28540450e-02f,
  -2.06250940e-02f, -1.15773425e-01f, -2.15969756e-02f, -8.37985873e-02f, -1.16759606e-01f, -9.59127098e-02f, -1.04830779e-01f, -2.74792723e-02f, -7.18708411e-02f, -7.08754361e-02f,
  -7.63263479e-02f, -2.11010277e-02f, -4.75140437e-02f, -4.84144688e-02f, -1.06538944e-01f, -1.63422093e-01f, -6.65744394e-02f, -1.20785221e-01f, -9.94287953e-02f, -1.81987301e-01f,
  8.61037299e-02f, -3.77803110e-02f, 1.89768784e-02f, 8.88587162e-02f, 1.10638477e-01f, 3.58506292e-02f, -3.18019688e-02f, 8.72552861e-03f, -3.05837896e-02f, 4.88854311e-02f,
  6.45941943e-02f, 1.17966784e-02f, 9.44052115e-02f, 5.56435250e-02f, 1.63295373e-01f, 8.60081762e-02f, 1.87921241e-01f, 1.60605162e-01f, 3.27661261e-02f, 1.25360042e-01f,
  7.09726885e-02f, 1.88847244e-01f, 2.43959367e-01f, 2.24142000e-01f, 8.52843747e-02f, 2.03497201e-01f, 8.73261094e-02f, 2.39210889e-01f, 2.20831901e-01f, 3.96330357e-01f,
  -9.40409582e-03f, -8.31558466e-01f, 5.14393449e-01f, 1.20798141e-01f, 1.25540182e-01f, -1.67142116e-02f, -4.54926074e-01f, -2.81415194e-01f, 2.11312063e-02f, -1.62560329e-01f,
  -2.87491828e-01f, 8.11167732e-02f, 1.51656806e-01f, -5.24236634e-02f, -1.19713433e-01f, -2.08726227e-01f, 2.65689552e-01f, 4.13979322e-01f, 4.20119703e-01f, -1.25553180e-02f,
  -6.38651624e-02f, -1.24366535e-02f, 2.80986559e-02f, 5.04493304e-02f, -4.26118216e-03f, 2.09121451e-01f, -3.06264572e-02f, 7.00227777e-03f, -1.50252834e-01f, 2.34898746e-01f,
  2.95356750e-01f, -1.81167379e-01f, 2.25631714e-01f, 9.98153351e-03f, 1.14499889e-02f, -5.99856535e-03f, 2.21095718e-02f, 6.77031279e-02f, 2.28334051e-02f, -1.80632100e-02f,
  -2.27508340e-02f, -5.79537526e-02f, 1.12295374e-01f, -5.66225909e-02f, -3.05083636e-02f, -1.45422742e-02f, -1.30313098e-01f, 4.01484072e-02f, 2.38315426e-02f, -1.69735208e-01f,
  -6.51828349e-02f, 4.81279083e-02f, 1.78601220e-01f, -1.13573328e-01f, -4.68008406e-02f, 1.91048428e-01f, -9.41271260e-02f, 3.20966495e-03f, -4.11043204e-02f, -3.87651362e-02f,
  -1.45795390e-01f, 4.21066433e-02f, -3.27110551e-02f, 5.73896877e-02f, -1.82752975e-03f, 4.48419824e-02f, 1.04299299e-01f, 1.50002353e-02f, -5.18355072e-02f, 6.06095344e-02f,
  8.24067593e-02f, 8.99435356e-02f, 5.17632701e-02f, 3.24810185e-02f, 5.38925529e-02f, 5.09237461e-02f, 9.22177434e-02f, -1.10106217e-02f, 9.02531371e-02f, 4.75012474e-02f,
  8.92910361e-02f, 1.66789591e-01f, -4.29433063e-02f, 6.42205849e-02f, 7.93485940e-02f, 8.48163366e-02f, 2.95522567e-02f, -4.88874177e-03f, -5.87746948e-02f, -6.68973252e-02f,
  -7.81312063e-02f, -2.80820653e-02f, 1.90230429e-01f, 1.78879744e-03f, 3.91020402e-02f, 5.40552996e-02f, 3.81081551e-02f, 1.72292795e-02f, 1.93900187e-02f, 1.06763151e-02f,
  3.74640990e-03f, -1.30936280e-02f, -8.14052671e-02f, 7.28335371e-03f, -1.28508182e-02f, -6.83027506e-02f, -1.09926306e-01f, 4.03158180e-02f, 1.47338342e-02f, -1.20309301e-01f,
  -1.36655778e-01f, 1.05375789e-01f, 9.59934518e-02f, 5.43235615e-02f, 4.14677970e-02f, 2.00293228e-01f, 5.47866262e-02f, 1.59788594e-01f, 1.58555225e-01f, -1.61354780e-01f,
  3.49144638e-02f, 5.49884848e-02f, -1.18530706e-01f, -1.81358725e-01f, -1.63733721e-01f, -8.52469802e-02f, -2.73104943e-02f, -1.07400669e-02f, -1.21065982e-01f, -7.20713064e-02f,
  1.97122023e-01f, 1.00841507e-01f, -1.11374363e-01f, -1.00951888e-01f, 1.12443149e-01f, -2.39463434e-01f, -1.76536515e-01f, -2.41699681e-01f, -1.26224920e-01f, -1.06955484e-01f,
  -1.82537645e-01f, -9.16238129e-02f, -1.66399613e-01f, -6.72021955e-02f, -1.83080032e-01f, -1.40427053e-01f, -1.38505965e-01f, -3.48800048e-02f, -6.07425831e-02f, -3.18083614e-01f,
  -1.56445459e-01f, 2.62016028e-01f, 6.13197796e-02f, 4.31074239e-02f, 1.66115479e-03f, 1.11832559e-01f, 1.67044178e-01f, 8.80019590e-02f, 1.14738226e-01f, 5.34337312e-02f,
  1.46868795e-01f, 1.09215431e-01f, 4.00577523e-02f, 3.65919322e-02f, -5.23454323e-02f, 5.22414595e-02f, 9.89471376e-03f, 4.55785282e-02f, -2.07742155e-02f, 1.24773085e-01f,
  -1.80143937e-02f, 6.71110153e-02f, 1.77154049e-01f, 1.26587883e-01f, 1.71028242e-01f, -1.93498787e-02f, 7.36254007e-02f, 1.75241023e-01f, 1.38172165e-01f, -6.25370219e-02f,
  -1.03543915e-01f, -4.32728678e-02f, -7.88424909e-02f, 1.36594474e-02f, -3.63221802e-02f, 5.86225949e-02f, -7.65931979e-02f, 4.77976166e-03f, -3.30748186e-02f, -1.12134591e-02f,
  -2.28707716e-02f, -1.21715307e-01f, -1.84229817e-02f, -6.94230124e-02f, -1.75293945e-02f, 6.59140721e-02f, -3.61227393e-02f, -7.11177289e-02f, 1.87940877e-02f, -6.36520656e-03f,
  -4.71446961e-02f, 8.93389210e-02f, -4.91448827e-02f, -5.66245522e-03f, 1.54249072e-02f, -6.22661747e-02f, 3.97047251e-02f, 2.31951699e-02f, 8.04039836e-02f, -2.93628853e-02f,
  -1.82121620e-02f, 2.18335539e-01f, -9.59191192e-03f, 1.15612559e-01f, -2.75009871e-02f, 4.29820418e-02f, 6.19574189e-02f, 7.77202249e-02f, 1.12891346e-01f, -1.54232578e-02f,
  1.38564214e-01f, -1.02345403e-02f, 4.17372473e-02f, -4.46251184e-02f, -6.51828498e-02f, 8.03413019e-02f, 3.61668156e-03f, -4.40690182e-02f, 2.52975952e-02f, -8.75431951e-03f,
  -5.30085526e-02f, 4.46477644e-02f, -3.72546166e-02f, 1.32222138e-02f, 5.61328381e-02f, 1.25346035e-02f, 7.19466805e-02f, 6.97144717e-02f, 1.53059848e-02f, -2.30786145e-01f,
  4.04232703e-02f, 3.47166717e-01f, 1.15778618e-01f, -1.02562018e-01f, 5.29067814e-02f, 2.00286344e-01f, 3.54662180e-01f, 6.03833236e-03f, -1.20996960e-01f, 8.13541859e-02f,
  -8.02786201e-02f, -3.99051458e-01f, -3.54409963e-01f, -2.78766751e-01f, -1.89589709e-01f, 3.07722002e-01f, 1.43501163e-01f, -3.67148854e-02f, -2.02952236e-01f, 1.38685545e-02f,
  -1.12937987e-02f, -2.25544851e-02f, -8.39942470e-02f, -1.21915527e-01f, 1.71204284e-01f, -7.63905495e-02f, 1.09819718e-01f, 1.32270485e-01f, 1.68999478e-01f, 2.62872577e-01f,
  6.31876709e-03f, 1.50357097e-01f, -2.67473340e-01f, -2.02277333e-01f, -6.07021376e-02f, -7.58959949e-02f, -7.93710351e-02f, -1.74821168e-01f, -1.15293801e-01f, -4.40527238e-02f,
  -1.79431558e-01f, -1.69026002e-01f, -1.28182665e-01f, -1.32600352e-01f, -6.22078516e-02f, -2.06112303e-02f, -4.53812443e-02f, -1.17126636e-01f, -2.18797997e-01f, -1.37351811e-01f,
  -1.21214636e-01f, -4.34753448e-02f, -2.16369089e-02f, -9.87559482e-02f, -1.67877927e-01f, -1.48427680e-01f, -4.68389317e-02f, -4.21967283e-02f, 3.03229503e-02f, 1.17459804e-01f,
  3.00669130e-02f, 4.64456081e-02f, 2.79326588e-02f, 3.89780290e-02f, 5.66792600e-02f, -1.48058096e-02f, 4.14272621e-02f, 7.25766942e-02f, 1.89810414e-02f, 9.17162821e-02f,
  1.27170430e-02f, 4.39713039e-02f, -1.25378370e-02f, 2.54265945e-02f, 2.65555810e-02f, 4.83552553e-02f, 5.42340539e-02f, 2.07202807e-02f, -2.51573566e-02f, 5.86109161e-02f,
  3.67206298e-02f, 8.38357024e-03f, 4.99459356e-02f, 1.05745591e-01f, 4.61248346e-02f, 2.42965911e-02f, 4.04771827e-02f, -3.02694403e-02f, 3.76878530e-02f, 1.20129585e-02f,
  -3.57849628e-01f, -3.14454883e-01f, 5.58563434e-02f, -7.23140091e-02f, -7.65963569e-02f, -5.91677018e-02f, -1.03281640e-01f, -5.79489470e-02f, -1.24336749e-01f, 7.51278736e-03f,
  -1.40059769e-01f, -6.79303110e-02f, -1.07273757e-01f, 7.06258696e-03f, -2.92222947e-02f, -4.21537906e-02f, -1.42190810e-02f, -2.75237462e-03f, -4.42423038e-02f, -6.84311837e-02f,
  2.73971874e-02f, 6.01719394e-02f, -1.02891326e-01f, 3.94106507e-02f, -1.41654193e-01f, -1.76124558e-01f, 1.78678483e-02f, -1.48437219e-02f, 7.67031964e-03f, 1.03857018e-01f,
  -4.21500877e-02f, -9.02534127e-02f, -2.72413313e-01f, 2.27850348e-01f, -5.34340814e-02f, -1.03916153e-01f, -2.43232884e-02f, -1.14942379e-01f, -3.48483771e-02f, -1.74360536e-03f,
  -2.32602984e-01f, -1.50107130e-01f, -2.87306726e-01f, -1.14230976e-01f, -1.68804049e-01f, -1.43241659e-01f, 3.63619328e-02f, -1.30772710e-01f, -8.52203220e-02f, 1.33422226e-01f,
  5.85127808e-02f, 2.73770150e-02f, 1.02004454e-01f, 6.18885085e-02f, 1.71355262e-01f, -8.15873314e-03f, -5.12917936e-02f, 1.18448183e-01f, 1.16731832e-02f, 2.52723396e-01f,
  -1.66340694e-01f, -1.01013757e-01f, -1.86237231e-01f, -9.91771519e-02f, -2.53658146e-01f, -1.06443807e-01f, -1.84056923e-01f, -1.10664159e-01f, -1.54566437e-01f, -1.59245208e-01f,
  -2.24676743e-01f, -6.40886351e-02f, -9.58820432e-02f, -6.21334575e-02f, -6.78445324e-02f, -3.95397469e-02f, -5.59198298e-02f, -9.43324491e-02f, -1.18643999e-01f, -2.04147592e-01f,
  -5.44487014e-02f, -1.98963299e-01f, -2.48362184e-01f, -2.57475853e-01f, -1.49387047e-01f, -1.99902251e-01f, -2.44934514e-01f, -1.04418486e-01f, -1.31578594e-01f, 9.23205018e-02f,
  1.42691016e-01f, -4.43717167e-02f, 6.92801178e-02f, 4.42083515e-02f, -2.48977654e-02f, -3.24883461e-02f, 1.30846366e-01f, 7.72915408e-02f, 1.95293128e-01f, 1.38150558e-01f,
  1.37410641e-01f, -3.64792608e-02f, 6.72552958e-02f, 1.11102752e-01f, 6.34422824e-02f, -1.50251547e-02f, 8.73369053e-02f, 1.39551014e-01f, 4.83931229e-02f, -4.69702762e-03f,
  -8.50901101e-03f, 2.35787947e-02f, 6.42419830e-02f, 9.54115391e-02f, 6.97602630e-02f, -2.70857606e-02f, -1.94514934e-02f, 1.88751686e-02f, -9.64128822e-02f, -5.96136153e-02f,
  -1.57093719e-01f, -2.06619397e-01f, -4.29114923e-02f, -3.34452018e-02f, -5.21078408e-02f, -1.56036317e-01f, -4.12563682e-02f, 1.22329989e-03f, -1.54729381e-01f, -1.50331810e-01f,
  -2.14721337e-01f, -4.34677564e-02f, -1.92722917e-01f, -1.23635046e-01f, -7.98722506e-02f, -1.05848581e-01f, -1.22291379e-01f, -1.11439880e-02f, -1.94003999e-01f, -1.13041066e-01f,
  -8.60857666e-02f, -8.43901858e-02f, -2.08060622e-01f, -2.72807091e-01f, -1.50919795e-01f, -3.16127360e-01f, -2.04282969e-01f, -2.18287542e-01f, -3.12311143e-01f, -5.18216006e-02f,
  -6.37447298e-01f, 3.01356446e-02f, 5.14888167e-01f, -3.05175334e-01f, 1.97786272e-01f, 2.40334079e-01f, 3.55377644e-01f, -8.07381049e-03f, -1.99845985e-01f, 2.24444959e-02f,
  -4.68128808e-02f, -2.53001481e-01f, -1.88188300e-01f, -6.34564832e-02f, 1.65241342e-02f, 2.71977603e-01f, 3.92959774e-01f, 2.48257250e-01f, 2.08094075e-01f, 1.77013949e-01f,
  9.75444634e-03f, -5.07633574e-02f, -1.19067214e-01f, 5.60576506e-02f, -3.81376632e-02f, -1.08970895e-01f, 2.18308970e-01f, 1.38658702e-01f, 1.77823037e-01f, 1.35688215e-01f,
  7.07044378e-02f, 2.47107558e-02f, -8.56765285e-02f, -1.46415830e-01f, -7.38728866e-02f, -8.19423199e-02f, -6.53720126e-02f, -1.61089282e-02f, -1.35827735e-01f, -9.77969617e-02f,
  1.93500035e-02f, -8.31302032e-02f, -1.04082733e-01f, -3.22049223e-02f, -7.77074173e-02f, -5.42580672e-02f, 1.17833139e-02f, -2.05346737e-02f, -3.78488004e-02f, 1.21055087e-02f,
  -7.80823603e-02f, 1.12737283e-01f, -8.27899668e-03f, -7.11212084e-02f, -1.97032131e-02f, 3.66585255e-02f, 2.57693585e-02f, -5.57132810e-02f, -1.08369393e-02f, -9.29495469e-02f,
  -8.82520601e-02f, 1.55594602e-01f, 1.71847224e-01f, 1.60736382e-01f, 2.95779146e-02f, 9.45953056e-02f, 1.00482076e-01f, 8.17961469e-02f, 8.11314583e-02f, 4.33703028e-02f,
  4.76858132e-02f, 8.88594240e-02f, 1.00529224e-01f, -1.63148111e-03f, 1.06264405e-01f, 1.28657758e-01f, 1.49742171e-01f, -8.12333915e-03f, 3.04399151e-02f, 7.40997419e-02f,
  1.28894523e-01f, 4.88608070e-02f, 5.79677261e-02f, 4.03343700e-02f, 1.96425453e-01f, 9.50161070e-02f, 1.30350634e-01f, 4.57448736e-02f, 1.01751171e-01f, 1.44690827e-01f,
  -3.81762922e-01f, 7.13600367e-02f, -1.93247125e-01f, -1.50383487e-01f, -9.94577855e-02f, -5.58248125e-02f, -1.58399627e-01f, -1.30256459e-01f, -9.20650065e-02f, -1.63940996e-01f,
  -7.95561001e-02f, -6.51199594e-02f, -1.19657174e-01f, 3.49244438e-02f, -1.19258665e-01f, -1.18174963e-01f, -2.02285677e-01f, -7.68537894e-02f, -3.19091789e-02f, -7.81209469e-02f,
  -1.80157945e-01f, -1.41714185e-01f, -1.12381913e-01f, -1.25444651e-01f, -5.99077940e-02f, -1.31305620e-01f, -3.06942668e-02f, -1.43506497e-01f, -8.82146880e-02f, -2.81082094e-01f,
  8.33760321e-01f, -2.72485137e-01f, -2.62961239e-01f, -5.35803139e-02f, -2.59723604e-01f, 3.59323137e-02f, 1.16593510e-01f, 2.54396290e-01f, -4.81365882e-02f, -1.02006339e-01f,
  -1.71939194e-01f, 7.94113278e-02f, -3.29179130e-02f, 1.07387841e-01f, 3.70859295e-01f, 2.82210466e-02f, -4.34209183e-02f, 9.84620824e-02f, 1.76491082e-01f, 6.35418519e-02f,
  -1.23570628e-01f, -6.96380436e-02f, 1.47700563e-01f, -8.22046623e-02f, -2.57712126e-01f, -5.14886305e-02f, -2.85286397e-01f, -2.66934216e-01f, -1.03449985e-01f, -3.66280466e-01f,
  -1.47583172e-01f, 6.82250634e-02f, 5.33454120e-02f, -5.52068986e-02f, -1.50004610e-01f, 3.63081880e-02f, -5.93365729e-03f, -1.09895416e-01f, -3.30951549e-02f, -1.30614629e-02f,
  -6.29482940e-02f, -3.10441088e-02f, 4.38991992e-04f, -1.04922913e-01f, -1.30946100e-01f, 1.14133833e-02f, -8.43001083e-02f, 4.99964394e-02f, -4.14928654e-03f, -1.02435924e-01f,
  -2.20246747e-01f, -2.17882451e-02f, 1.10201620e-01f, -1.09499164e-01f, -4.98995073e-02f, 6.81657717e-02f, -1.81845129e-02f, -1.15058243e-01f, -8.06851014e-02f, -1.75619107e-02f,
  -9.77526903e-02f, 5.70098832e-02f, -3.79467681e-02f, 3.69337387e-02f, 4.15308066e-02f, 3.27234827e-02f, 1.24608008e-02f, 4.21102419e-02f, 2.75154524e-02f, -1.26657775e-03f,
  3.34191136e-02f, 2.62839417e-03f, 5.77387214e-03f, 1.04984522e-01f, 2.77123805e-02f, 3.65449525e-02f, 4.45322581e-02f, -1.95244551e-02f, -5.10583036e-02f, -2.05557663e-02f,
  -3.15778237e-03f, 1.53195988e-02f, -3.11743766e-02f, -8.47193748e-02f, 8.86787474e-03f, 3.71430442e-02f, 3.83289196e-02f, 3.01051512e-02f, 1.91302747e-02f, 1.04481660e-01f,
  1.55463278e-01f, -2.15363875e-02f, 8.84103216e-03f, 4.76605482e-02f, -1.00883186e-01f, -5.68048283e-02f, -7.43310601e-02f, -1.66719601e-01f, -2.48203073e-02f, 4.03738692e-02f,
  -5.23656867e-02f, 8.37800428e-02f, -2.78534293e-02f, -1.19371660e-01f, 2.70498674e-02f, -1.09050525e-02f, -8.46335590e-02f, -3.19908820e-02f, -2.73535959e-02f, -8.79321024e-02f,
  -1.52421428e-03f, 6.15640245e-02f, 1.49675041e-01f, -2.05499940e-02f, 3.76348980e-02f, 7.20705539e-02f, -3.40801589e-02f, 5.00905961e-02f, 1.37337491e-01f, 1.51862189e-01f,
  4.29161131e-01f, -2.81611323e-01f, -4.78343695e-01f, -7.04926848e-02f, -1.03752375e-01f, 3.20469551e-02f, -1.52756721e-01f, -1.01955980e-03f, 2.20666155e-01f, -1.42500624e-01f,
  -4.98447232e-02f, 1.11474119e-01f, 1.51534751e-01f, 3.33553329e-02f, 1.41906098e-01f, -2.46315807e-01f, -2.08063364e-01f, 1.02417558e-01f, 2.23781809e-01f, 1.76528186e-01f,
  -8.48218519e-03f, 1.01023197e-01f, 7.19583854e-02f, -4.96476218e-02f, -2.78218508e-01f, 3.26614790e-02f, -2.36875653e-01f, -1.40150070e-01f, -1.61929011e-01f, -3.06502193e-01f,
  -1.39876842e-01f, -2.38275155e-01f, 8.21576267e-02f, 1.56166598e-01f, -6.51359633e-02f, 9.00382549e-02f, 7.48063251e-02f, 3.53272520e-02f, 3.53581691e-03f, -3.01159583e-02f,
  -8.43730569e-02f, 8.49016681e-02f, -6.52821884e-02f, 3.91318090e-02f, -6.49845526e-02f, -6.37478605e-02f, 4.19057645e-02f, -1.78307872e-02f, -3.87261547e-02f, -1.22488044e-01f,
  -5.44232652e-02f, 4.05463055e-02f, -2.15474181e-02f, -8.43889080e-03f, -1.96099724e-03f, 4.92785722e-02f, -1.43166497e-01f, -1.11387104e-01f, 1.20746352e-01f, -6.09150119e-02f,
  1.52263030e-01f, 4.79352288e-02f, -2.01469893e-03f, 1.14004444e-02f, 3.09719611e-03f, -8.16815719e-02f, -4.33222167e-02f, -4.52077165e-02f, 2.85909995e-02f, -6.65339315e-03f,
  -5.24563715e-02f, 3.71534713e-02f, 4.91939001e-02f, 1.26112262e-02f, -5.44023998e-02f, 9.42163635e-03f, -1.52928364e-02f, -5.89435324e-02f, 3.06922961e-02f, 7.71937147e-02f,
  7.09813908e-02f, -2.07696501e-02f, 1.24494713e-02f, 2.20564678e-02f, -1.88957229e-02f, 1.11996522e-02f, -1.10721728e-02f, 4.84257080e-02f, 2.68588252e-02f, 8.50075632e-02f,
  2.50723898e-01f, 2.11336732e-01f, 4.61684614e-02f, 6.08825013e-02f, 9.64732934e-03f, 2.03542784e-02f, -2.93931942e-02f, 1.35425692e-02f, -1.01311065e-01f, -3.46350186e-02f,
  9.46500897e-03f, 6.60006478e-02f, -7.09079504e-02f, -4.67919139e-03f, 1.24915034e-01f, 1.06193565e-01f, -1.40797962e-02f, 3.95633541e-02f, 5.70457242e-02f, -6.86069578e-02f,
  2.91361716e-02f, 8.62425119e-02f, 1.97796881e-01f, 7.07679391e-02f, 7.02315494e-02f, 2.46243387e-01f, 3.91904190e-02f, 1.24959596e-01f, 2.26529345e-01f, 1.42194092e-01f,
  -2.95202792e-01f, 2.74373561e-01f, -2.20883548e-01f, -7.55932033e-02f, 8.07830915e-02f, 1.60594895e-01f, 2.81730503e-01f, -8.99591818e-02f, 8.95648636e-03f, 1.41606137e-01f,
  4.08352762e-02f, 1.54904276e-01f, 1.72843575e-01f, 1.86759105e-03f, 7.85925090e-02f, 1.85862198e-01f, 1.84431836e-01f, -1.07134700e-01f, -2.23664016e-01f, -3.54215614e-02f,
  1.99458033e-01f, -4.41600233e-02f, -3.64112914e-01f, -2.23025978e-01f, -2.40484085e-02f, 1.00671008e-01f, -2.07164556e-01f, -1.48385257e-01f, 2.62160599e-02f, 1.31491408e-01f,
  5.78835420e-02f, -2.65652984e-01f, -7.35879736e-03f, 7.31611699e-02f, -1.64785713e-01f, -8.44512731e-02f, -3.76460552e-02f, -1.23912320e-01f, -1.05063550e-01f, -2.79208738e-02f,
  -1.51709858e-02f, -3.29661323e-03f, -1.09436430e-01f, -1.17531501e-01f, -1.57433599e-01f, -1.28260702e-01f, -1.85910538e-01f, -2.65204489e-01f, -1.16687164e-01f, -8.18105042e-03f,
  6.31021708e-02f, -1.79313589e-02f, -6.43781498e-02f, -1.47246346e-01f, -2.18106255e-01f, -1.42289415e-01f, -1.22657157e-01f, -1.70175761e-01f, -1.30951688e-01f, -1.21567465e-01f,
  2.72902753e-02f, -5.59561979e-03f, -1.95423141e-02f, -6.44089952e-02f, 8.73807445e-02f, 4.56348881e-02f, 6.87520206e-02f, 7.81396180e-02f, -3.81865986e-02f, 1.79439578e-02f,
  3.00382171e-02f, 4.84069176e-02f, -9.83130746e-03f, 1.32171482e-01f, 9.25257504e-02f, 2.49703564e-02f, 5.24371266e-02f, 6.68677464e-02f, -4.45029140e-02f, 3.68294753e-02f,
  1.66333281e-02f, -3.49349305e-02f, -3.41189280e-02f, -1.47506539e-02f, 4.70255911e-02f, -2.18234211e-02f, 3.04230843e-02f, -2.56907241e-03f, 1.06498236e-02f, -2.65851654e-02f,
  2.25271925e-01f, -2.84902789e-02f, 2.20802158e-01f, 3.34137455e-02f, 6.00696309e-03f, -8.97767693e-02f, 2.24425308e-02f, -2.16488410e-02f, -3.02397851e-02f, -2.36209910e-02f,
  -8.80429819e-02f, 5.83113870e-03f, 6.07950091e-02f, 7.74353277e-03f, 1.18404289e-03f, -2.61725448e-02f, 6.49474114e-02f, 1.04661807e-01f, 5.30691147e-02f, -1.24409705e-01f,
  3.71320993e-02f, 1.82172805e-01f, 3.08820248e-01f, 2.20072851e-01f, 4.80294004e-02f, 2.77068824e-01f, 1.54253051e-01f, 8.98424983e-02f, 1.47147730e-01f, 2.87203789e-01f,
  -7.07599759e-01f, -1.47494256e-01f, -2.45929822e-01f, -1.66724399e-01f, 1.31194502e-01f, -1.99851301e-02f, -4.54819500e-02f, -1.19299635e-01f, -7.02014342e-02f, -8.00718293e-02f,
  -2.43289378e-02f, -3.30701172e-02f, 4.15294245e-02f, -5.85330604e-03f, -4.44442360e-03f, -3.91429961e-02f, -2.70055998e-02f, -1.61622211e-01f, -1.95020020e-01f, -7.27536716e-03f,
  2.73428001e-02f, 3.58354859e-02f, -1.94789216e-01f, -5.12774736e-02f, -1.86975807e-01f, -9.91842225e-02f, -1.17267005e-01f, -1.75885156e-01f, -1.82509616e-01f, -2.67338783e-01f,
  -3.41953248e-01f, -2.82433003e-01f, -1.04030631e-01f, -8.07388574e-02f, -5.85187748e-02f, -1.85412258e-01f, -1.44100249e-01f, -1.87212527e-01f, -1.81620464e-01f, -1.21201567e-01f,
  -1.77611947e-01f, -1.15778983e-01f, -6.99555501e-02f, -1.35000095e-01f, -1.07310437e-01f, -1.37000486e-01f, -1.66093469e-01f, -1.57262042e-01f, -8.35370049e-02f, -1.89560920e-01f,
  -8.29191878e-02f, -2.39254415e-01f, -3.11799079e-01f, -1.88246310e-01f, -1.50656223e-01f, -1.32864594e-01f, -2.09411681e-01f, -2.70650297e-01f, -2.53070384e-01f, -3.65886420e-01f,
  4.82075177e-02f, 1.19378358e-01f, 5.47289886e-02f, -1.12201702e-02f, 5.75451255e-02f, 4.43119816e-02f, 6.31018728e-02f, 1.15641125e-01f, 4.39556502e-02f, 4.39729393e-02f,
  4.05771062e-02f, 1.04662776e-01f, 3.87028381e-02f, -1.79861439e-03f, 8.69463533e-02f, 2.47103013e-02f, 3.58737186e-02f, 6.91623539e-02f, 7.75579438e-02f, -1.88836791e-02f,
  -1.02504734e-02f, 6.61122203e-02f, 3.84331383e-02f, 8.82581400e-04f, 6.74488693e-02f, 1.52697740e-02f, 1.93070564e-02f, 4.30068038e-02f, 7.66427219e-02f, 5.24535589e-02f,
  7.93657228e-02f, 5.97914122e-03f, -2.21471563e-01f, -8.89358744e-02f, -4.12352346e-02f, -5.95223047e-02f, -7.25701004e-02f, -7.00393766e-02f, -5.83978593e-02f, -9.54636112e-02f,
  -8.90781358e-02f, -9.56003889e-02f, -8.12899172e-02f, 4.00016718e-02f, -4.20909263e-02f, -1.17707729e-01f, -3.78137454e-02f, -7.18083829e-02f, -6.60755783e-02f, -1.09769993e-01f,
  -2.84045227e-02f, -2.71383137e-01f, -3.81024837e-01f, -1.30191773e-01f, -1.34987310e-01f, -2.59933174e-01f, -1.88623443e-01f, -1.52352527e-01f, -2.69204557e-01f, -2.70325124e-01f,
  7.37047076e-01f, -1.49603322e-01f, -2.32800081e-01f, 3.53060007e-01f, -6.13811463e-02f, -2.72627294e-01f, -4.69887704e-01f, -2.42550939e-01f, 2.23597288e-01f, -7.58117437e-02f,
  1.39167793e-02f, 1.62606820e-01f, 2.14120865e-01f, -1.54653499e-02f, -1.15872649e-02f, -1.96430519e-01f, 1.56134600e-02f, 1.16206162e-01f, -1.91305533e-01f, -2.09353536e-01f,
  -4.96004298e-02f, 1.84728742e-01f, 3.74088854e-01f, 6.38815984e-02f, -3.36812511e-02f, 5.10646105e-02f, 5.51417284e-02f, 2.61585396e-02f, -1.49444699e-01f, 6.18564449e-02f,
  -8.07488486e-02f, -2.34828740e-02f, -8.56169984e-02f, 1.20050021e-01f, -1.25561565e-01f, 6.07296601e-02f, -1.75917372e-02f, -5.14383465e-02f, -3.51953991e-02f, 6.06495216e-02f,
  -2.20316811e-03f, -2.86204480e-02f, 2.95982230e-03f, -2.58546509e-02f, 1.59774609e-02f, 9.21254687e-04f, 6.94611967e-02f, -4.81097819e-03f, -4.92258258e-02f, -8.97134766e-02f,
  -1.98480263e-02f, 1.42754149e-02f, -1.24482089e-03f, -8.55466574e-02f, -1.53494194e-01f, 1.19848207e-01f, -8.30647722e-02f, -1.15518473e-01f, 2.51550344e-04f, -2.68015768e-02f,
  -3.24364491e-02f, -3.54232937e-02f, -5.63945137e-02f, -1.55721486e-01f, -6.75370917e-03f, -2.11692229e-02f, -1.71473585e-02f, 7.90425912e-02f, -8.72758105e-02f, -1.35413930e-02f,
  -8.20674896e-02f, 3.04584927e-03f, -3.84079926e-02f, 2.27559847e-03f, -1.03020566e-02f, -8.08175001e-03f, -3.22068594e-02f, -7.49024525e-02f, -6.69648871e-02f, -1.34419033e-03f,
  -3.62512544e-02f, -4.03638743e-02f, 2.13050433e-02f, -1.03079572e-01f, -3.43679264e-02f, 3.79289240e-02f, -6.73471093e-02f, -8.88094120e-03f, -9.38140973e-03f, 6.07357211e-02f,
  2.08058298e-01f, 7.00800866e-02f, 8.82871151e-02f, 2.56993379e-02f, 2.50226259e-02f, -4.20073941e-02f, -5.58544472e-02f, 1.11664059e-02f, 1.86292324e-02f, 1.87910744e-03f,
  -8.51438418e-02f, 1.70193780e-02f, -1.06545608e-03f, -4.94231191e-03f, -7.79698566e-02f, -4.04531769e-02f, 6.31545186e-02f, 4.53764275e-02f, -6.34007901e-02f, -2.14412287e-02f,
  2.29845867e-02f, 7.27924779e-02f, 2.31640220e-01f, -3.05342171e-02f, -8.29048455e-03f, 1.07535154e-01f, -8.07208121e-02f, -1.30395353e-01f, -8.25918168e-02f, 1.50539011e-01f,
  -3.84357750e-01f, 1.32923305e-01f, -2.99690068e-01f, 3.63463648e-02f, 4.37542200e-02f, -1.37055248e-01f, 5.85267954e-02f, -8.65598172e-02f, -8.16476643e-02f, 4.41434141e-03f,
  9.60424989e-02f, -1.03767559e-01f, -1.74302265e-01f, -3.43399107e-01f, -5.15627384e-01f, -2.85134345e-01f, -2.83800006e-01f, -6.03812218e-01f, -6.06635809e-01f, -2.75501341e-01f,
  -5.11953607e-02f, -2.34025776e-01f, -3.54069352e-01f, -2.14173660e-01f, 5.79168051e-02f, -1.36990756e-01f, 2.49339137e-02f, -1.82389691e-01f, -9.54484269e-02f, 4.87335026e-02f,
  -2.07577899e-01f, -7.97415003e-02f, -6.25147223e-02f, -8.73607546e-02f, -8.47290177e-03f, -8.91778395e-02f, -1.23441577e-01f, -1.74163252e-01f, -2.35198177e-02f, -2.15568300e-02f,
  -1.00919068e-01f, -1.27468944e-01f, -3.66472788e-02f, -1.21203318e-01f, -1.64646447e-01f, -1.51955217e-01f, -9.06276181e-02f, -2.69052744e-01f, -1.15520224e-01f, -8.26165229e-02f,
  5.12885221e-04f, -1.48293957e-01f, -1.61517248e-01f, -1.24095403e-01f, -8.58217627e-02f, -1.77182257e-01f, -2.17848979e-02f, -5.24634980e-02f, -2.11724401e-01f, 6.65747151e-02f,
  -8.43134001e-02f, -9.25574526e-02f, -1.08305858e-02f, 6.42722622e-02f, 4.49682149e-04f, -1.63780097e-02f, 9.83484983e-02f, -3.20612919e-03f, 4.42058453e-03f, 5.52972592e-02f,
  8.33330750e-02f, 1.41103148e-01f, -5.13620749e-02f, 1.25620082e-01f, 8.64280909e-02f, -4.39825282e-02f, 5.08283228e-02f, 6.65054619e-02f, 3.41347642e-02f, 3.37849334e-02f,
  -5.21869846e-02f, 7.85095021e-02f, 1.12679064e-01f, 2.81529576e-02f, 1.02293231e-01f, 2.25063805e-02f, 2.87436545e-02f, 4.95809913e-02f, -1.90271426e-03f, 5.73533848e-02f,
  2.78737466e-03f, -2.01755956e-01f, -2.02698670e-02f, -1.67920157e-01f, -1.06495231e-01f, -1.80300034e-03f, 9.20423493e-02f, -4.56517562e-02f, -1.51593890e-02f, -7.05716461e-02f,
  -4.31970842e-02f, -3.06991730e-02f, -4.19472009e-02f, -9.00972076e-03f, -4.21518385e-02f, -5.65049313e-02f, 5.74897453e-02f, -1.14248998e-01f, -7.99001902e-02f, 8.59377533e-03f,
  5.51279932e-02f, -8.70595798e-02f, -2.15572119e-01f, -2.64361389e-02f, -8.71378183e-02f, -2.25076035e-01f, -6.72273859e-02f, -1.29657174e-02f, -1.74108833e-01f, 7.00605661e-02f,
  -6.37450516e-01f, -2.22840920e-01f, 2.71087795e-01f, -1.63803577e-01f, 1.88994870e-01f, 8.13217610e-02f, -6.19503558e-02f, -7.72585906e-03f, 3.54129262e-02f, -1.24985889e-01f,
  5.89644015e-02f, 6.50304630e-02f, 2.09431946e-01f, 7.03293905e-02f, -3.26618478e-02f, 1.13856703e-01f, 2.14690745e-01f, 3.40595134e-02f, 4.46526669e-02f, -2.13304713e-01f,
  -7.50704035e-02f, -2.57637680e-01f, -1.65042147e-01f, -5.80809824e-02f, -3.34065318e-01f, -1.19862415e-01f, 3.58528197e-02f, -1.97058231e-01f, -1.35564104e-01f, -3.94658774e-01f,
  -1.01406813e-01f, -1.35857552e-01f, 1.86097234e-01f, -5.24398573e-02f, 1.34381242e-02f, 3.50582898e-02f, -7.12024048e-02f, 1.20618287e-02f, -4.69377674e-02f, -8.37708563e-02f,
  6.26182631e-02f, 7.02431146e-03f, 1.24183498e-01f, -5.21718292e-03f, -9.60547924e-02f, -3.53303924e-02f, -9.58029588e-04f, -1.30948424e-03f, -7.57699879e-03f, -6.14203513e-02f,
  8.19693580e-02f, -6.77997842e-02f, -5.62731028e-02f, 6.70593651e-03f, -3.55125027e-04f, 5.33341952e-02f, -3.34636122e-02f, -6.51206523e-02f, -4.30229418e-02f, -2.94737667e-01f,
  6.14212565e-02f, -7.12416880e-03f, 7.16197789e-02f, -4.58105244e-02f, -4.29815128e-02f, 3.95110957e-02f, 6.09837323e-02f, -4.09740806e-02f, -7.04097984e-05f, 1.68140233e-02f,
  -4.91896691e-03f, 2.46199593e-02f, 2.74446476e-02f, -1.42789064e-02f, 6.64708167e-02f, 6.45482615e-02f, -4.91678454e-02f, -4.05411497e-02f, 6.38968721e-02f, -4.90437970e-02f,
  -1.55177237e-02f, -3.33780237e-02f, 3.44011262e-02f, 2.73547340e-02f, -1.58363860e-02f, 5.90748712e-02f, 2.94559132e-02f, 7.11977631e-02f, 3.01326364e-02f, 5.74081652e-02f,
  -1.66996494e-01f, 4.17874813e-01f, -1.50185183e-01f, -8.33663270e-02f, -2.76640672e-02f, -2.19246596e-02f, 2.64824145e-02f, 2.08953395e-02f, 1.02572672e-01f, -9.19784009e-02f,
  -7.83434138e-03f, -1.36686834e-02f, -1.61193740e-02f, -3.91330048e-02f, 1.42620401e-02f, 5.57359718e-02f, 3.72960581e-03f, -2.06755791e-02f, -3.28807048e-02f, -4.65888083e-02f,
  6.75729150e-03f, -1.68702483e-01f, -2.04655543e-01f, -6.72295317e-02f, 5.78384241e-03f, -7.24566653e-02f, -4.85701524e-02f, -1.68159008e-01f, -5.53299449e-02f, -3.60486597e-01f,
  2.88017802e-02f, -1.07656017e-01f, -3.65775168e-01f, 3.98824424e-01f, -6.63622096e-02f, -2.63930202e-01f, -4.85826939e-01f, 6.38075732e-03f, 2.52613515e-01f, 7.08452165e-02f,
  3.44642885e-02f, 2.40720838e-01f, 1.49739265e-01f, 9.95366275e-02f, -1.20468572e-01f, -2.07390428e-01f, -7.49372840e-02f, -1.87598839e-01f, -2.23012194e-01f, -6.50727376e-02f,
  2.27712497e-01f, 2.39946797e-01f, 7.82847032e-02f, 1.57286733e-01f, 4.34611201e-01f, 1.57758355e-01f, 9.76725593e-02f, 1.74643517e-01f, -7.73956999e-02f, 3.14919680e-01f,
  -9.40312892e-02f, -2.45468728e-02f, -9.56510380e-02f, 9.69556049e-02f, 1.78894382e-02f, -5.68369702e-02f, -7.82345682e-02f, 3.26171517e-02f, 6.22746907e-03f, -1.82760283e-02f,
  1.69017822e-01f, 8.51177424e-03f, 3.73667367e-02f, 9.42496657e-02f, 3.46262753e-02f, 6.29346073e-02f, 9.37910005e-02f, -7.48850331e-02f, -1.33366941e-03f, 2.69207936e-02f,
  2.08228901e-01f, -3.63083044e-03f, -6.35006577e-02f, -4.97978888e-02f, -1.06172442e-01f, 2.36236081e-02f, -1.92129482e-02f, 6.84175873e-03f, -1.35362893e-01f, 7.92072192e-02f,
  -1.01758771e-01f, -7.25000352e-02f, 3.67392674e-02f, -7.03593865e-02f, 6.98405951e-02f, 1.54873042e-03f, -2.36380138e-02f, 6.05344847e-02f, -2.00577714e-02f, 8.36078897e-02f,
  -5.99107742e-02f, 8.11196957e-03f, -3.36540714e-02f, 5.78337349e-03f, 8.09274763e-02f, -2.98374947e-02f, 2.68204361e-02f, 1.13054377e-03f, 8.59162882e-02f, 1.84440147e-02f,
  3.12116761e-02f, -1.41638173e-02f, 6.36970028e-02f, 5.69653250e-02f, -7.37205222e-02f, -5.59445582e-02f, 2.09213011e-02f, 4.66517061e-02f, 1.22921400e-01f, 2.88121402e-02f,
  2.15162501e-01f, -3.38893265e-01f, 1.16059780e-01f, 4.56836224e-02f, 2.88654268e-02f, 4.17832732e-02f, 6.53841868e-02f, -2.99051069e-02f, 5.23492731e-02f, 1.51604377e-02f,
  -9.61766765e-02f, 4.19663787e-02f, 3.78047600e-02f, 9.29936469e-02f, -8.93652588e-02f, 6.25956059e-02f, 1.86296180e-01f, 6.84842989e-02f, -4.92491275e-02f, 2.42781844e-02f,
  1.03272371e-01f, -6.58424571e-02f, -6.99668825e-02f, -5.30283749e-02f, 1.42673790e-01f, 1.53260222e-02f, -1.38516529e-02f, -3.74268815e-02f, -2.20121190e-01f, -9.70496684e-02f,
  -5.48044406e-02f, 3.43475342e-01f, 4.23199743e-01f, -2.38505043e-02f, 8.76086801e-02f, 1.42442817e-02f, -1.77164242e-01f, -1.55336246e-01f, -8.95241201e-02f, -1.20946750e-01f,
  9.06161740e-02f, 1.45465340e-02f, 9.12179351e-02f, 1.13123290e-01f, -3.68943252e-02f, -1.77126020e-01f, -1.55487418e-01f, 4.82187457e-02f, -2.38489080e-02f, -8.63219723e-02f,
  -1.22019410e-01f, -7.70016536e-02f, -1.09955810e-01f, -1.75762609e-01f, -9.17695910e-02f, -1.42249450e-01f, 2.00120527e-02f, -5.67643754e-02f, -7.27533698e-02f, -7.23921731e-02f,
  2.10714385e-01f, 4.06820297e-01f, 6.93451287e-03f, -5.18243909e-02f, 9.87239778e-02f, -3.45607921e-02f, -5.03209159e-02f, 3.14912498e-02f, 4.56456803e-02f, 3.09336949e-02f,
  7.57934824e-02f, -5.65716773e-02f, -8.64443853e-02f, -7.05816671e-02f, -3.55689079e-02f, -6.38283268e-02f, -6.50385097e-02f, 9.54958126e-02f, 9.78280604e-03f, -3.66768502e-02f,
  -4.72019762e-02f, -7.71463588e-02f, 1.61704281e-03f, -6.16944619e-02f, 7.15841725e-02f, -9.42572057e-02f, 5.17067388e-02f, 1.12174181e-02f, -8.42899084e-02f, -1.18673481e-01f,
  -1.96505204e-01f, 6.92323968e-02f, 8.61583650e-03f, 6.23923503e-02f, -5.22671491e-02f, 2.73033176e-02f, 5.44116981e-02f, 5.08554429e-02f, -4.89967167e-02f, -1.18827336e-01f,
  3.66131328e-02f, 4.19330485e-02f, 4.81225364e-02f, -2.42206398e-02f, 5.86609505e-02f, 6.04906632e-03f, 2.72987951e-02f, -2.67631374e-02f, 4.61361147e-02f, -1.99129824e-02f,
  4.82528396e-02f, 5.60755804e-02f, 1.86751094e-02f, 2.27924436e-02f, 1.12511665e-02f, 2.81892158e-02f, -5.74781373e-03f, -1.96449794e-02f, -7.36816600e-02f, -1.02459788e-02f,
  -1.18681759e-01f, 4.30794172e-02f, -1.10125139e-01f, -1.48598747e-02f, 8.05283338e-02f, -2.11596396e-02f, 4.77078417e-03f, 4.03620861e-02f, 8.22609290e-02f, -1.80328432e-02f,
  2.57111285e-02f, 1.93745289e-02f, 8.51325318e-03f, 8.94054025e-03f, -6.67196661e-02f, -5.20990044e-02f, -1.23455293e-01f, -1.02590909e-02f, -9.32153091e-02f, -1.33250868e-02f,
  -1.32651106e-01f, -2.26819396e-01f, -1.07955374e-01f, -1.09919593e-01f, -9.89013612e-02f, -7.83834010e-02f, -8.83958712e-02f, -2.31000990e-01f, -2.46218950e-01f, -3.50792795e-01f,
  6.51692078e-02f, -1.65194303e-01f, -3.08911473e-01f, 4.00103420e-01f, 1.12138398e-01f, -3.69990736e-01f, -4.16810572e-01f, -1.13845974e-01f, 3.27852190e-01f, -6.25603870e-02f,
  -1.61406159e-01f, -1.02897927e-01f, -1.81406751e-01f, -2.63422102e-01f, -4.17022645e-01f, -1.49443105e-01f, 2.12400109e-02f, -1.72976807e-01f, -2.72014052e-01f, -9.20279622e-02f,
  1.92439795e-01f, 2.53872454e-01f, 1.81464374e-01f, 9.90803465e-02f, 4.05583322e-01f, 1.14495717e-01f, 1.33647457e-01f, 2.27419019e-01f, -2.57161468e-01f, 2.81221181e-01f,
  -2.27480829e-01f, -5.49616627e-02f, -5.04257157e-02f, -1.39789404e-02f, 1.04620971e-03f, -2.45905872e-02f, -3.75869200e-02f, 9.83067676e-02f, 1.72382109e-02f, 4.11071666e-02f,
  6.52729347e-02f, 3.71400490e-02f, 2.54036859e-02f, 6.57976344e-02f, -2.45926231e-02f, 2.09564879e-03f, 1.08145893e-01f, 4.42235582e-02f, -9.45768282e-02f, -8.18355381e-02f,
  3.92629951e-02f, 5.46585396e-02f, -1.92542702e-01f, -3.20189893e-02f, -6.00595064e-02f, -8.31961334e-02f, -8.47788602e-02f, 7.63357878e-02f, -1.19767182e-01f, 1.48056120e-01f,
  3.01446905e-03f, -1.42575577e-02f, -5.08693093e-03f, 7.55896196e-02f, -3.37638855e-02f, -2.16093659e-02f, -1.28257945e-02f, -1.58876507e-03f, -4.42404337e-02f, 7.77203068e-02f,
  -7.61765102e-03f, -3.24901566e-02f, 3.19057964e-02f, 4.59805503e-02f, 2.73438934e-02f, 2.25972515e-02f, -5.81708923e-02f, 5.77915600e-03f, -4.94453087e-02f, 4.38988842e-02f,
  2.15154495e-02f, -4.26710024e-02f, 1.33301109e-01f, 3.33815217e-02f, -9.42697935e-03f, 2.06772555e-02f, 7.79013646e-07f, 4.58320007e-02f, 8.63957256e-02f, 1.58663075e-02f,
  1.72741428e-01f, -1.96003333e-01f, -1.00324303e-03f, 3.08203902e-02f, 4.87625934e-02f, 2.42313668e-02f, -2.42414586e-02f, 3.53577249e-02f, -6.91674426e-02f, 3.72691974e-02f,
  -7.43426085e-02f, -8.62627178e-02f, -2.10603816e-04f, 1.15970122e-02f, 3.87288108e-02f, 1.40064918e-02f, 3.91005389e-02f, -5.10641076e-02f, -4.14893664e-02f, 1.31293729e-01f,
  6.23200610e-02f, -3.66094187e-02f, -1.17690131e-01f, -1.26618713e-01f, 3.98236178e-02f, -1.85341105e-01f, -1.11890115e-01f, -9.06316787e-02f, -2.42601737e-01f, 9.08690318e-02f,
  2.85083622e-01f, 8.13708156e-02f, 6.37194574e-01f, 3.54616493e-01f, -8.58158171e-02f, -1.61307305e-01f, -1.06548533e-01f, -1.26917183e-01f, -1.24697108e-02f, -6.92837581e-04f,
  -1.94477484e-01f, -2.95443445e-01f, 8.28378126e-02f, -1.09195411e-01f, -9.99793261e-02f, 1.96653292e-01f, 2.46619150e-01f, 2.62902290e-01f, 2.01220065e-02f, -2.38983169e-01f,
  -3.29181045e-01f, -4.14775759e-02f, -3.31126936e-02f, 5.80135360e-02f, 1.54544070e-01f, -1.68408994e-02f, 3.37298572e-01f, 1.42591402e-01f, -1.02043219e-01f, 3.67543727e-01f,
  3.63558799e-01f, 1.78001672e-01f, -1.83104932e-01f, -2.09778652e-01f, -5.64231817e-03f, -6.51310980e-02f, -9.87330452e-03f, 5.50126545e-02f, -1.00820415e-01f, 6.08062483e-02f,
  -5.64965568e-02f, -5.14959991e-02f, 2.21769027e-02f, -7.69012049e-02f, 7.34583884e-02f, 5.48337959e-02f, 1.61253046e-02f, 1.27975196e-01f, 3.73470262e-02f, 1.54826837e-02f,
  -1.19210139e-01f, -7.03658815e-03f, 6.98529184e-02f, 6.91117430e-06f, -3.81263271e-02f, -5.25208935e-02f, -7.26255327e-02f, -5.99541105e-02f, 1.33424625e-02f, 1.19584166e-01f,
  -1.30207147e-02f, 8.35470036e-02f, -6.25820756e-02f, -4.63974802e-03f, -6.62118047e-02f, 2.54124328e-02f, 4.82896483e-03f, 9.15141660e-04f, -9.78626460e-02f, 6.51350617e-02f,
  -9.09852609e-02f, -8.00165068e-03f, -5.39172404e-02f, 2.40626372e-02f, -1.29679888e-02f, 9.39190611e-02f, 4.18566167e-02f, -8.20862949e-02f, -9.89561602e-02f, -6.50162622e-02f,
  -5.63322157e-02f, 4.57378924e-02f, 9.89390463e-02f, -1.30228708e-02f, -4.79707308e-02f, 4.92864177e-02f, 1.10209826e-02f, -1.02218010e-01f, 1.17736245e-02f, 1.86277330e-02f,
  7.65101984e-03f, -2.88642883e-01f, 4.59873639e-02f, -4.21842411e-02f, 1.59842689e-02f, -8.65812004e-02f, 2.84685194e-03f, -2.59953141e-02f, -2.10664067e-02f, 5.93011675e-04f,
  -9.16915759e-02f, -9.02423486e-02f, -4.96600047e-02f, -6.34571835e-02f, -8.99300501e-02f, -1.44794419e-01f, -1.83673412e-01f, -1.80369932e-02f, -1.40807554e-01f, -2.33699549e-02f,
  -1.29038334e-01f, -4.17899638e-02f, -7.62517154e-02f, -1.94841586e-02f, -1.02791796e-02f, -7.30106682e-02f, -2.48897858e-02f, -1.36783523e-02f, -1.26355678e-01f, -6.30275980e-02f,
  9.36891735e-01f, -5.66201508e-01f, -1.39213204e-01f, 3.18543345e-01f, -2.23123074e-01f, -1.20760188e-01f, -5.17396450e-01f, 9.88160744e-02f, 2.90923029e-01f, -1.74184918e-01f,
  -2.70642132e-01f, 5.70044070e-02f, 1.29094794e-01f, -5.73979802e-02f, -3.12827453e-02f, -2.53699899e-01f, -2.08325922e-01f, 1.88406959e-01f, 3.03037405e-01f, -1.87794417e-02f,
  -1.96593180e-01f, 2.04643514e-02f, 3.81398320e-01f, 1.33418038e-01f, -1.39582783e-01f, 7.10482076e-02f, -1.08189113e-01f, -1.91692486e-01f, -2.94046849e-01f, -4.83201116e-01f,
  -1.52492970e-01f, -1.84527829e-01f, -6.53342204e-03f, 3.12738726e-03f, -1.21749029e-01f, 1.54416487e-01f, -3.21071409e-02f, 1.34677470e-01f, -4.37249914e-02f, 2.52660606e-02f,
  -1.17110454e-01f, -1.76479928e-02f, -2.69069429e-02f, -9.41406116e-02f, -6.63943514e-02f, 3.29010822e-02f, 8.00804496e-02f, 3.41240019e-02f, -3.63802388e-02f, -1.55319005e-01f,
  -2.94711053e-01f, -1.55008823e-01f, -1.54401734e-01f, -4.67707962e-02f, 2.35636625e-02f, 1.72207803e-02f, -5.12386449e-02f, 3.76065411e-02f, 7.48860389e-02f, 1.01240063e-02f,
  -3.10223568e-02f, 3.67770679e-02f, -7.78111583e-03f, 7.88589492e-02f, 3.83502990e-02f, 4.47731167e-02f, 9.58202109e-02f, 2.52707656e-02f, 1.13580592e-01f, 7.37321377e-02f,
  -4.59624076e-04f, 6.46147132e-03f, 4.16232497e-02f, 1.05473250e-01f, 4.44111563e-02f, 8.50023329e-02f, -6.50959741e-03f, 8.67247209e-02f, 3.72985862e-02f, 1.66357476e-02f,
  5.56412861e-02f, 6.55491725e-02f, 6.05693869e-02f, 2.92739496e-02f, -3.43249440e-02f, 1.31274283e-01f, 1.02179281e-01f, 9.28889886e-02f, 2.23656908e-01f, 8.59011039e-02f,
  1.37543350e-01f, -9.65960696e-02f, -8.09450671e-02f, -5.10025695e-02f, -4.31610867e-02f, -6.27733022e-02f, -1.62334502e-01f, -7.68330172e-02f, -5.50146475e-02f, -7.69186243e-02f,
  -1.35764614e-01f, 8.35281834e-02f, -8.84325877e-02f, -3.89430076e-02f, 2.27331948e-02f, -3.21724489e-02f, -1.14053115e-01f, -6.90450668e-02f, -1.25891413e-03f, -9.49099809e-02f,
  -4.12440673e-02f, 4.13304418e-02f, 1.57875434e-01f, 2.71809986e-03f, 4.43225401e-03f, 1.22305498e-01f, -9.32603329e-02f, -9.04041380e-02f, 4.08201925e-02f, 1.02198862e-01f,
  5.05534895e-02f, 1.33377209e-01f, 3.05564493e-01f, 2.52102107e-01f, 3.55062753e-01f, 1.65499792e-01f, 1.05042100e-01f, -7.04974905e-02f, 4.54270132e-02f, 8.08654130e-02f,
  1.88594125e-02f, -4.77622226e-02f, 7.17145950e-02f, 7.42490357e-03f, -1.54992282e-01f, 4.22323048e-02f, 1.27860561e-01f, 9.70407948e-02f, -1.87004022e-02f, 2.94696931e-02f,
  5.02644256e-02f, 1.46775380e-01f, 8.35943152e-04f, 1.19846798e-02f, 4.90744524e-02f, 4.00271267e-02f, 1.45916864e-01f, 1.13361515e-01f, -2.09253859e-02f, 8.03393722e-02f,
  3.14511299e-01f, -1.26261525e-02f, 4.08893973e-02f, -5.62604293e-02f, 1.45524368e-01f, -1.15454212e-01f, 9.55140814e-02f, -3.30563709e-02f, -8.06192458e-02f, 1.04848109e-01f,
  2.41176300e-02f, -2.76235621e-02f, -3.40065062e-02f, 3.31285819e-02f, 4.70169969e-02f, 1.58736564e-03f, -1.11264735e-01f, -7.83730969e-02f, 2.33398080e-02f, -1.31881097e-02f,
  -5.37592322e-02f, -3.11373211e-02f, -9.44867209e-02f, -4.62463722e-02f, -6.78072125e-02f, -1.13264881e-02f, 1.24829439e-02f, -9.56986025e-02f, -7.02991188e-02f, -3.43399146e-03f,
  8.91372040e-02f, 3.19627970e-02f, 2.16025932e-04f, -5.74986972e-02f, -5.58714336e-03f, -7.79028982e-04f, 8.97598937e-02f, 3.09485514e-02f, -5.88093586e-02f, 2.38951202e-02f,
  5.41167818e-02f, 1.02672651e-01f, -3.31222676e-02f, 6.00672662e-02f, 3.36579457e-02f, 9.75715443e-02f, 6.35155216e-02f, -2.58611445e-03f, -5.92759773e-02f, 2.28350051e-03f,
  -1.35248313e-02f, -9.61246528e-03f, 7.77852684e-02f, 3.95832062e-02f, 3.35037000e-02f, 5.11451326e-02f, 7.78202713e-02f, -1.92570109e-02f, 6.15739152e-02f, 3.40980198e-03f,
  2.03632727e-01f, -2.75156610e-02f, -3.23205963e-02f, -1.31626010e-01f, 4.45137993e-02f, -5.42793050e-02f, -3.11181489e-02f, -6.63776696e-02f, 1.64627135e-02f, -3.35362107e-02f,
  -9.07326341e-02f, 1.47723872e-02f, 4.74080220e-02f, -1.03221744e-01f, 3.06374002e-02f, -1.06134541e-01f, -4.21306007e-02f, 3.72810140e-02f, -1.15655929e-01f, -2.43220013e-02f,
  3.78244417e-03f, -7.73559213e-02f, -5.50881550e-02f, -9.82594416e-02f, -1.35097787e-01f, -5.71127608e-02f, -1.02542549e-01f, -8.70699808e-02f, -1.21092744e-01f, -4.52515222e-02f,
  1.57772020e-01f, 3.12724143e-01f, 6.78210199e-01f, -2.12452725e-01f, 1.42168533e-02f, 1.99006021e-01f, 3.26473475e-01f, -4.67447490e-02f, -1.53952748e-01f, 3.30513678e-02f,
  -4.01851162e-02f, -1.72998682e-01f, -1.84147701e-01f, -3.39025892e-02f, 4.56155352e-02f, 2.25166619e-01f, 5.40230647e-02f, 2.02534422e-01f, 1.93247959e-01f, -1.50797412e-01f,
  -2.29678512e-01f, -8.18371028e-02f, 2.21104342e-02f, -5.68666235e-02f, -1.19730152e-01f, -1.94868758e-01f, 1.30079463e-01f, 1.14100575e-01f, 1.65556416e-01f, 1.63012184e-02f,
  3.19450051e-01f, 6.15033247e-02f, -2.86676083e-02f, -2.00736612e-01f, 2.89788283e-02f, -2.05740631e-02f, 3.32175717e-02f, 1.31087815e-02f, -9.34533551e-02f, 2.26852968e-02f,
  -2.54925527e-02f, -5.58884293e-02f, -1.56617492e-01f, -4.27597836e-02f, -2.95716375e-02f, -3.83170322e-02f, -6.43696263e-02f, 1.51870698e-02f, -4.79779430e-02f, -5.53716198e-02f,
  -1.39253199e-01f, 7.33070821e-02f, 2.12760061e-01f, 9.66171622e-02f, 4.13981974e-02f, 7.06404671e-02f, 1.78749353e-01f, -4.27571833e-02f, 7.97755942e-02f, 2.16767169e-03f,
  9.06473864e-03f, 8.22824463e-02f, 6.38521323e-03f, 2.82183476e-02f, -1.68767329e-02f, 1.10400952e-01f, -3.13523784e-02f, -4.08938481e-03f, 7.86435977e-03f, 1.03147747e-02f,
  9.41841379e-02f, 3.08840666e-02f, 6.74463362e-02f, -1.29212113e-02f, -2.86624618e-02f, 1.92949232e-02f, 1.03224568e-01f, -4.55889851e-02f, -6.54335245e-02f, -6.68727532e-02f,
  -4.74204831e-02f, 4.53663990e-03f, -4.82292473e-02f, -4.95700203e-02f, -1.02031920e-02f, 6.22080676e-02f, -2.18845047e-02f, 1.03414489e-03f, 3.26260068e-02f, 7.08730966e-02f,
  7.02792928e-02f, -4.35577706e-02f, 5.70999878e-03f, -1.24646477e-01f, -9.29785967e-02f, -1.20390072e-01f, -4.19261716e-02f, -1.00882448e-01f, -7.13816136e-02f, 2.05476638e-02f,
  -4.86634783e-02f, -1.20618651e-02f, -9.12669227e-02f, 7.20328419e-03f, 1.75800752e-02f, -4.79925796e-02f, -3.90833877e-02f, -7.80151226e-03f, -3.09059396e-02f, 4.62782718e-02f,
  1.62862483e-02f, 6.24161325e-02f, 1.35044843e-01f, 9.72243026e-02f, 1.93582568e-02f, 4.25478965e-02f, 7.08114356e-02f, 3.07182185e-02f, 1.31158859e-01f, 1.24247402e-01f,
  -5.68211615e-01f, -2.91601360e-01f, -1.25817031e-01f, -4.47369702e-02f, 2.16524392e-01f, 1.02268904e-01f, -3.63381386e-01f, -7.49707967e-02f, 6.92557096e-02f, -1.08155273e-01f,
  2.84100085e-01f, 4.72989559e-01f, 2.94812202e-01f, 2.15187669e-01f, -7.19027519e-02f, -3.01439464e-01f, -3.53399426e-01f, -1.74469501e-01f, 1.16183057e-01f, 1.87328056e-01f,
  1.14747785e-01f, -1.19995467e-01f, -1.77206054e-01f, -1.77891105e-01f, 4.35933471e-02f, 1.60849020e-01f, -4.30926196e-02f, -1.20980322e-01f, 1.76330097e-02f, -6.67835250e-02f,
  1.47860095e-01f, -1.80571735e-01f, 1.27272949e-01f, 6.99854270e-02f, 1.10496782e-01f, -4.14049327e-02f, -6.45476207e-02f, -1.36807899e-03f, 9.19900313e-02f, -3.50484177e-02f,
  1.55175701e-01f, 1.17269836e-01f, 4.02290709e-02f, 1.06628291e-01f, -3.57779004e-02f, 3.18583623e-02f, -9.26300883e-02f, -8.75423700e-02f, -7.65514746e-02f, 2.20077001e-02f,
  3.78980115e-02f, -3.53420489e-02f, -1.51495115e-04f, 4.19383682e-02f, -7.06942379e-02f, 1.70254529e-01f, -6.83796173e-03f, 3.15655507e-02f, -1.13558330e-01f, -2.54613131e-01f,
  -1.47352755e-01f, -3.76323983e-02f, 4.56452407e-02f, -6.16248921e-02f, 7.34579414e-02f, 2.79211197e-02f, -4.30322438e-02f, 5.59513457e-02f, -7.81509280e-02f, -1.71505455e-02f,
  -3.84342074e-02f, 3.90293114e-02f, -2.83538760e-03f, -8.56270492e-02f, -4.50954698e-02f, -6.51462302e-02f, -4.35228199e-02f, -8.53496939e-02f, -4.67882166e-03f, -4.81051020e-03f,
  1.12977028e-02f, 1.16227216e-04f, -2.59356778e-02f, -5.62704285e-04f, -5.26218452e-02f, -6.52308837e-02f, -2.62277946e-02f, 8.05751532e-02f, 2.95966249e-02f, -4.97311689e-02f,
  5.64220920e-02f, 6.06724061e-02f, 3.40514407e-02f, 2.68751979e-02f, 6.32747635e-02f, 6.80814981e-02f, 5.07421456e-02f, 7.13662757e-03f, 1.31707937e-01f, -1.13634206e-02f,
  4.47307304e-02f, -4.87599894e-02f, 4.36005890e-02f, -2.14160774e-02f, 6.81722313e-02f, 3.30567881e-02f, -2.55782995e-03f, 3.81630026e-02f, -7.77035858e-03f, 6.94221333e-02f,
  -3.36185060e-02f, 2.03867722e-02f, 1.44555385e-03f, -9.17307287e-03f, 8.98875520e-02f, 9.75170583e-02f, -2.13183016e-02f, 3.07673719e-02f, 3.86330746e-02f, -1.64305925e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.24623275e-01f, -5.49216866e-01f, 9.44689848e-03f, -1.73466541e-02f, 1.65912807e-01f, 1.07571527e-01f, 8.24072286e-02f, -1.12451911e-01f, -1.26334667e-01f, -1.30139992e-01f,
  -9.93749052e-02f, 7.26713613e-02f, 9.08046588e-02f, 3.76175568e-02f, 4.86171544e-02f, 1.86477542e-01f, 1.20786384e-01f, 2.04577014e-01f, 4.16564852e-01f, 2.67791808e-01f,
  1.59290448e-01f, 1.12067498e-01f, -5.34099154e-03f, 4.37655337e-02f, 1.17032584e-02f, 3.11628103e-01f, -3.16062905e-02f, -5.77764958e-02f, -1.08310632e-01f, -7.33698234e-02f,
  5.57521701e-01f, -4.98122126e-01f, 2.92492174e-02f, -3.14435929e-01f, -1.28328606e-01f, -2.82481313e-01f, 2.07176507e-02f, -1.40502647e-01f, -2.67648697e-01f, -8.39992315e-02f,
  -2.45317906e-01f, -1.38123229e-01f, 1.55019024e-02f, -1.70305818e-02f, 2.70160232e-02f, -6.98402477e-03f, -1.56945139e-01f, -1.88390225e-01f, -1.67933986e-01f, -1.83631301e-01f,
  -1.08420901e-01f, -9.94156003e-02f, -7.10698292e-02f, -7.23277219e-03f, -1.05508059e-01f, 5.81567362e-02f, -1.37397349e-01f, -2.41908342e-01f, -1.33029833e-01f, -2.09771499e-01f,
  -2.78012808e-02f, 8.69910493e-02f, -1.33438557e-01f, -6.90682931e-03f, 6.46903068e-02f, 8.10223818e-02f, 2.76679814e-01f, 1.30682975e-01f, 2.29613319e-01f, 1.63032532e-01f,
  1.02083683e-01f, 6.80992082e-02f, -7.69366995e-02f, 8.44755694e-02f, -4.84505296e-02f, -2.57513225e-01f, -3.78760584e-02f, -3.73146608e-02f, -9.47645213e-03f, -1.42702147e-01f,
  2.15351749e-02f, -2.89192330e-02f, -1.47483274e-01f, -8.91529769e-02f, -2.00580090e-01f, -2.32325699e-02f, 2.63787601e-02f, -1.50567992e-02f, 3.14751454e-02f, -3.83880287e-02f,
  5.57335377e-01f, -1.99224651e-01f, 1.77083552e-01f, 4.40807868e-04f, 3.50680910e-02f, -5.82089685e-02f, 6.08421564e-02f, -9.49952677e-02f, 1.53546864e-02f, 2.33449675e-02f,
  -2.64714379e-03f, 2.49386951e-02f, 1.17636979e-01f, 1.22513175e-01f, 4.76534277e-01f, 9.11699533e-02f, -3.07340994e-02f, 1.05120100e-01f, 1.09549575e-02f, -5.52878641e-02f,
  -2.68423688e-02f, 1.61281347e-01f, 3.30348015e-01f, 2.23214224e-01f, 1.85996816e-01f, 3.18358243e-01f, 4.05579895e-01f, 1.07134201e-01f, 1.60408720e-01f, 3.83854121e-01f,
  1.82417083e+00f, 1.03732646e+00f, -5.99160254e-01f, 3.15155923e-01f, -4.78395343e-01f, -3.00277323e-01f, -2.94985883e-02f, 5.16509473e-01f, 3.92802835e-01f, 2.62988389e-01f,
  2.24989086e-01f, 3.16335440e-01f, 3.31474423e-01f, 1.01577848e-01f, 1.57685310e-01f, -5.52675128e-02f, -3.64200443e-01f, -2.77008891e-01f, -4.09172803e-01f, -3.01062644e-01f,
  -3.97870950e-02f, 6.64900988e-02f, 3.03160638e-01f, 2.88958140e-02f, 9.89382714e-02f, -8.38095471e-02f, 3.61828879e-02f, -1.64061546e-01f, -1.26899540e-01f, -8.92265514e-02f,
  -7.17043817e-01f, 9.74748656e-02f, -2.00411066e-01f, -1.85847674e-02f, -1.00768834e-01f, 2.21718073e-01f, 3.70008983e-02f, 1.83715537e-01f, 5.56479543e-02f, -6.96226582e-02f,
  -1.24233253e-02f, -1.75133850e-02f, 1.00631290e-03f, -3.13095562e-02f, -1.17320985e-01f, -1.53495908e-01f, 8.64290968e-02f, 1.17471896e-01f, -2.75528785e-02f, -8.83781612e-02f,
  1.87186692e-02f, -2.59187311e-01f, -2.19299033e-01f, -5.04944101e-02f, 4.28407490e-02f, -8.34171996e-02f, -1.41274109e-01f, -7.92381465e-02f, -8.89246389e-02f, 1.58380553e-01f,
  -7.76217878e-02f, 2.20429465e-01f, -1.56648934e-01f, -7.24977534e-03f, 4.18079719e-02f, 3.40208821e-02f, -3.19144949e-02f, 5.90643920e-02f, -7.99284037e-03f, 5.62604666e-02f,
  4.43721041e-02f, -1.55717000e-01f, -4.74834349e-03f, 5.37198875e-03f, -2.98298858e-02f, -2.57201549e-02f, -3.86725180e-02f, -1.72492534e-01f, -3.08859855e-01f, -5.89977540e-02f,
  -1.26405835e-01f, 7.16118589e-02f, 6.40064925e-02f, -1.84333801e-01f, -7.02219680e-02f, -4.06647511e-02f, -7.29137138e-02f, 1.63413472e-02f, 1.35192379e-01f, 1.55807048e-01f,
  1.94567949e-01f, -4.91669804e-01f, 4.18602526e-02f, 1.72408700e-01f, -8.50816667e-02f, 4.32678796e-02f, -5.41661903e-02f, -1.94563121e-01f, -1.21477492e-01f, -5.32133095e-02f,
  -6.97819963e-02f, 5.68999127e-02f, 4.95054647e-02f, -3.38587444e-04f, -1.60054490e-01f, -1.86359346e-01f, 7.25950599e-02f, 2.62122244e-01f, 3.46641205e-02f, -6.95647895e-02f,
  1.23580478e-01f, 1.04162410e-01f, 4.55293097e-02f, 1.89556032e-01f, 1.40005276e-01f, -2.16603279e-02f, -1.21878788e-01f, 1.32449148e-02f, -9.07016769e-02f, 2.82468319e-01f,
  1.20589364e+00f, 2.59095822e-02f, -5.23936749e-02f, 1.99681297e-01f, -3.36423635e-01f, -3.08887810e-01f, -4.87506121e-01f, -3.26006711e-01f, 1.70215189e-01f, 1.70059934e-01f,
  2.04633608e-01f, 4.49434161e-01f, 3.12241644e-01f, 1.41818613e-01f, 1.26539066e-01f, -3.25523578e-02f, 4.12750617e-02f, 4.04759765e-01f, 3.32434863e-01f, 2.68374771e-01f,
  3.57691884e-01f, 2.01869905e-01f, 2.85681367e-01f, 2.71705806e-01f, 2.88097322e-01f, 2.02363327e-01f, -4.21762047e-03f, -1.61843766e-02f, 1.75825045e-01f, 5.93337536e-01f,
  6.26179814e-01f, 1.17774814e-01f, -1.74851939e-02f, 5.80632240e-02f, -7.00265318e-02f, 8.94002095e-02f, 1.66968688e-01f, -2.02378631e-02f, -1.84791386e-02f, -1.15217008e-01f,
  -5.40669784e-02f, 9.81488228e-02f, 4.36462797e-02f, -2.86781136e-02f, -1.03190929e-01f, -1.31762139e-02f, -3.61854732e-02f, 3.21325883e-02f, -5.77231310e-02f, 1.44515648e-01f,
  1.22987151e-01f, 1.92453843e-02f, -2.81200945e-01f, -1.40455306e-01f, -3.67939994e-02f, 5.87032624e-02f, -4.19896282e-02f, 7.14386180e-02f, -2.01512724e-01f, 2.49136209e-01f,
  2.74236530e-01f, 5.41781560e-02f, 3.70663851e-01f, 3.53881717e-01f, 2.60395586e-01f, 3.28123748e-01f, 4.39042598e-02f, 9.73869637e-02f, 1.32919505e-01f, 5.85317276e-02f,
  1.18188523e-01f, 1.21977761e-01f, -1.68985296e-02f, 1.31460011e-01f, 2.06625000e-01f, -6.68441579e-02f, 4.38572243e-02f, 5.56011908e-02f, -1.01284355e-01f, -6.05526343e-02f,
  2.22699735e-02f, -1.02598123e-01f, -4.78438213e-02f, 8.47368985e-02f, -3.36077586e-02f, -6.13898635e-02f, 2.08137184e-01f, 5.10085709e-02f, -3.00480220e-02f, -9.74674337e-03f,
  -7.80499995e-01f, -4.84056294e-01f, 3.22671235e-01f, -1.42018363e-01f, -7.98905641e-03f, -6.87481761e-02f, 1.31255716e-01f, -4.98393364e-02f, -1.27776384e-01f, -6.17523417e-02f,
  -1.20964788e-01f, 3.74414399e-02f, -9.27691162e-02f, -1.38330519e-01f, -1.00679323e-01f, -1.07624769e-01f, 4.49338928e-02f, -6.64518774e-02f, -5.22342585e-02f, -7.47901127e-02f,
  -1.69838592e-01f, -2.87278235e-01f, -1.86240613e-01f, -2.19941407e-01f, -2.45128502e-03f, -6.32837564e-02f, -2.24027455e-01f, -1.68781988e-02f, -1.74329624e-01f, -7.78134465e-02f,
  -4.45250213e-01f, -6.19534925e-02f, -1.67437032e-01f, -3.75731289e-01f, 9.74836946e-01f, 2.28664666e-01f, -3.80894423e-01f, -2.69777983e-01f, 6.54185144e-03f, -3.91557217e-01f,
  6.85134590e-01f, 7.01927543e-01f, -2.30875328e-01f, -1.29325613e-01f, -1.27661979e+00f, -9.91769373e-01f, -1.13260365e+00f, -1.15218806e+00f, -4.82100308e-01f, 8.58605981e-01f,
  5.87326884e-01f, -1.37331799e-01f, -5.96620858e-01f, -1.40103847e-01f, 2.57311702e-01f, 2.03717537e-02f, 9.58369523e-02f, 3.17428589e-01f, 1.60101682e-01f, -1.03889756e-01f,
  -8.85608792e-02f, 1.38332412e-01f, 2.01114118e-01f, 1.82341516e-01f, 3.15719038e-01f, -3.97392273e-01f, -5.78575134e-02f, -9.34317112e-02f, 4.15088758e-02f, -3.14473659e-01f,
  5.20582259e-01f, 1.28479540e-01f, 2.07465976e-01f, 2.29730625e-02f, -2.10539680e-02f, -1.98973358e-01f, -2.02407032e-01f, -3.95923108e-01f, -5.61623871e-01f, 4.20802552e-03f,
  4.73615736e-01f, 5.38357258e-01f, -1.43741801e-01f, -2.84277260e-01f, -3.93465281e-01f, 3.83047871e-02f, 2.44754702e-01f, 3.68995875e-01f, -3.47170472e-01f, -3.40350032e-01f,
  3.50262746e-02f, -3.16684111e-03f, -1.81987882e-01f, -1.99760929e-01f, -7.05336109e-02f, 2.40090445e-01f, -9.74779427e-02f, 1.96388979e-02f, 1.50749415e-01f, -5.23944199e-02f,
  -1.02483697e-01f, 1.65270656e-01f, -8.15774053e-02f, -1.77118722e-02f, 3.17001082e-02f, 1.22690825e-02f, 1.57775685e-01f, -2.99534231e-01f, -1.08302608e-01f, -1.91134706e-01f,
  -1.40597418e-01f, 2.11027518e-01f, 1.60270751e-01f, -9.56940949e-02f, -5.44514135e-02f, -1.02376379e-01f, 2.26122022e-01f, 1.23221792e-01f, 1.54611900e-01f, 2.32310385e-01f,
  -1.74056187e-01f, 1.01689547e-01f, -3.26641917e-01f, -1.46937221e-01f, -1.44788921e-01f, 3.95543948e-02f, 1.14277437e-01f, -1.67823941e-01f, 1.44423515e-01f, -2.35047400e-01f,
  1.09050140e-01f, -2.96834946e-01f, -6.30685315e-02f, 3.82644795e-02f, -6.22823089e-02f, -7.09667727e-02f, -3.31592232e-01f, 5.98946922e-02f, -4.93786484e-02f, 2.33577475e-01f,
  -4.59956288e-01f, -6.41032696e-01f, -5.67099512e-01f, -5.19915462e-01f, -7.33452803e-03f, -3.43657553e-01f, -3.23279083e-01f, -1.58063889e-01f, -9.04602051e-01f, -1.09344721e+00f,
  -3.66269410e-01f, -3.04824769e-01f, 2.10013434e-01f, 6.16160035e-01f, 5.32878518e-01f, 4.71696705e-01f, 2.15156987e-01f, 1.58845261e-01f, 3.28493744e-01f, 2.32488319e-01f,
  2.77173936e-01f, 4.68584806e-01f, 4.36953008e-01f, 2.91182220e-01f, 3.09509516e-01f, 3.98436993e-01f, 4.78119433e-01f, 1.54808074e-01f, 1.56073675e-01f, 1.96202189e-01f,
  1.64791867e-01f, -1.18888006e-01f, -1.46331385e-01f, 1.18577860e-01f, 8.31522048e-02f, 2.41897583e-01f, 1.72762439e-01f, 1.26259148e-01f, 7.83082098e-03f, 1.71102583e-01f,
  -2.15466172e-01f, -2.32486531e-01f, 2.04568163e-01f, -1.00741565e-01f, -2.35651433e-01f, -2.91401029e-01f, 4.03354950e-02f, -2.21150428e-01f, -1.27067760e-01f, -8.95598084e-02f,
  -1.47241987e-02f, -1.86562777e-01f, 8.73207599e-02f, -1.14785759e-02f, -1.13031760e-01f, -1.49456620e-01f, -1.78205445e-01f, 4.13256139e-02f, 1.60103723e-01f, 1.12692684e-01f,
  1.07098773e-01f, 1.65830910e-01f, 8.80076364e-02f, 2.21547797e-01f, 1.01727676e-02f, 8.36018771e-02f, -6.33068979e-02f, -9.27184299e-02f, 5.53358011e-02f, -1.90387536e-02f,
  4.86292332e-01f, 1.99481234e-01f, 2.14766517e-01f, 2.00813621e-01f, -1.18529312e-02f, 9.51748639e-02f, 1.27897158e-01f, 1.37528047e-01f, 1.82762861e-01f, -2.19034180e-02f,
  5.32285087e-02f, 3.03114057e-01f, 1.16238452e-01f, 9.73908380e-02f, 2.20937729e-01f, 2.20681742e-01f, -1.01028413e-01f, 1.14231274e-01f, 1.10832848e-01f, 1.71276361e-01f,
  9.57364589e-02f, 2.43602823e-02f, -2.26691276e-01f, -1.55735165e-01f, 2.96173394e-02f, 1.58730686e-01f, 9.31320563e-02f, -6.56579211e-02f, -6.11883923e-02f, -1.65639400e-01f,
  3.13018948e-01f, 4.11849529e-01f, 4.90818992e-02f, 5.79705238e-02f, -9.21405777e-02f, -2.72040039e-01f, 1.27076566e-01f, -8.80848989e-03f, -2.05701604e-01f, 1.77340396e-02f,
  -7.15298802e-02f, -2.00935990e-01f, -1.64459318e-01f, -1.22378051e-01f, -8.63169804e-02f, -1.04228765e-01f, -1.63567923e-02f, 1.89453140e-01f, 8.90162960e-02f, 4.45942581e-02f,
  3.18594351e-02f, 1.09850489e-01f, 1.25399247e-01f, 1.72489554e-01f, 4.57175896e-02f, 1.71481088e-01f, -1.26858637e-01f, -1.76757097e-01f, -4.53548022e-02f, -2.14271605e-01f,
  1.09658098e+00f, 4.10269469e-01f, 3.50068480e-01f, 2.28207484e-01f, 2.63783425e-01f, 5.16712606e-01f, 7.04187453e-01f, 2.73077935e-01f, 8.62171277e-02f, 5.47627360e-02f,
  2.37079456e-01f, -7.50986338e-02f, 1.01650186e-01f, 1.56752206e-02f, 1.98529154e-01f, -1.05901726e-01f, -2.47923657e-01f, 1.14678871e-02f, 5.56526072e-02f, 1.06296511e-02f,
  -2.72879183e-01f, -1.77513823e-01f, -4.45601828e-02f, -1.97461605e-01f, -2.23084077e-01f, -2.38815114e-01f, 3.83108109e-03f, 5.36936224e-02f, 3.43723856e-02f, -5.00391781e-01f,
  -2.72566199e-01f, 3.51824462e-01f, -2.60216981e-01f, -7.62383118e-02f, 1.98801011e-02f, -2.89977998e-01f, -1.04571451e-02f, -1.67425290e-01f, -1.77173242e-01f, -2.55379647e-01f,
  -9.29679126e-02f, 3.07365060e-02f, 1.02303557e-01f, 1.17688691e-02f, 2.83062072e-05f, 7.41183832e-02f, 3.75969224e-02f, -5.50781004e-02f, 1.42068207e-01f, 1.29698634e-01f,
  -6.06417693e-02f, 3.08895130e-02f, 2.10793585e-01f, 1.39136925e-01f, 2.53247529e-01f, 2.10295934e-02f, 7.31083751e-02f, 3.99712473e-02f, 2.57327944e-01f, -1.11375086e-01f,
  -1.45521522e-01f, 3.28196771e-02f, 2.89496750e-01f, -5.62971868e-02f, 1.57897864e-02f, 1.32584766e-01f, -1.64076057e-03f, 1.03532284e-01f, 2.17401475e-01f, 4.13651951e-02f,
  2.23208535e-02f, 5.55432886e-02f, 1.18015170e-01f, 8.42131600e-02f, -3.49951126e-02f, 8.69709998e-02f, -1.56523101e-02f, 2.33153943e-02f, 2.40327224e-01f, 5.24329282e-02f,
  2.07581922e-01f, -1.24714402e-02f, -2.39543486e-02f, -2.61051394e-02f, -6.88422238e-03f, -8.99411514e-02f, -1.46114677e-01f, 4.71827714e-03f, -2.19879835e-03f, -5.54296188e-02f,
  -3.67288053e-01f, 3.88380587e-01f, -2.77199447e-01f, -5.83136640e-02f, 6.05317838e-02f, -8.56534690e-02f, 6.12605438e-02f, -2.31712893e-01f, -2.26693839e-01f, -2.72859365e-01f,
  -6.56737655e-04f, -5.66861480e-02f, 4.73616980e-02f, -4.90317941e-02f, -5.11800237e-02f, -8.59802663e-02f, -9.92566720e-02f, -7.46370703e-02f, -6.26982152e-02f, -2.16428280e-01f,
  -8.84062648e-02f, -1.53799906e-01f, 2.12265141e-02f, -1.30317556e-02f, -1.54403314e-01f, -1.45244285e-01f, -6.83656707e-02f, -4.39994261e-02f, 2.23921686e-01f, -2.32028365e-01f,
  5.57144046e-01f, -6.38634503e-01f, -2.57945359e-02f, -2.33772829e-01f, -6.51171267e-01f, -6.12181485e-01f, -9.13628340e-01f, -5.04845083e-01f, -1.82884112e-01f, -5.07009089e-01f,
  -4.14634466e-01f, 2.07634002e-01f, 3.90013129e-01f, 4.40190107e-01f, 5.32866597e-01f, -8.30085799e-02f, 1.07692353e-01f, 7.47472525e-01f, 5.66971481e-01f, -2.07779229e-01f,
  -2.48208612e-01f, 1.41765699e-01f, 4.63150501e-01f, 3.55957478e-01f, -8.04210827e-02f, 5.34416363e-02f, -1.16757996e-01f, -1.03460789e-01f, -1.37668997e-01f, 2.24201381e-01f,
  4.46240865e-02f, -3.47352936e-03f, 1.16313651e-01f, 2.73756891e-01f, 3.51242460e-02f, 1.14794955e-01f, -7.09123015e-02f, 1.98751893e-02f, -9.35385674e-02f, -1.10048339e-01f,
  2.52662636e-02f, 1.20043173e-01f, 2.04884797e-01f, 8.31271242e-03f, -1.80907354e-01f, -1.16766155e-01f, 7.63939917e-02f, 2.39895016e-01f, 2.51997173e-01f, -1.31283030e-01f,
  -1.02490313e-01f, -2.77378172e-01f, -2.39660308e-01f, -2.38954157e-01f, -8.28722566e-02f, 3.07111740e-01f, -3.26875560e-02f, 1.09204583e-01f, -1.11334836e-02f, -2.18168765e-01f,
  5.14617227e-02f, -7.57084191e-02f, -1.20035419e-03f, -1.08384259e-01f, -1.21215083e-01f, -1.54094279e-01f, -6.48962408e-02f, -1.64478913e-01f, 1.90267935e-01f, 3.23760398e-02f,
  -1.39746860e-01f, 2.64264084e-02f, -6.84790164e-02f, -9.70560387e-02f, 2.04917803e-01f, 3.52535322e-02f, -8.90553370e-02f, -9.23904404e-02f, 1.42044485e-01f, 7.75377676e-02f,
  1.55353680e-01f, 4.78313193e-02f, 5.17575219e-02f, 1.89934656e-01f, -9.43915695e-02f, -5.64207993e-02f, -9.48337745e-03f, -7.44666085e-02f, -8.53004903e-02f, -4.26534703e-03f,
  -4.74113792e-01f, 5.18506646e-01f, 8.42320099e-02f, 2.69732535e-01f, 6.86143488e-02f, 1.34689301e-01f, 1.00917570e-01f, 4.70311344e-02f, 4.28708941e-02f, -1.60902012e-02f,
  -4.35778163e-02f, 1.22859873e-01f, 8.25762525e-02f, 1.61674529e-01f, 9.08377487e-03f, -2.71456949e-02f, -5.82024343e-02f, 4.21533436e-02f, 1.34353414e-01f, -8.91185626e-02f,
  -1.81427971e-02f, -3.26429754e-01f, -1.87988117e-01f, -1.89521555e-02f, -1.19061239e-01f, 8.05892237e-03f, -1.23434804e-01f, -1.53704524e-01f, 3.27762067e-02f, -4.17993128e-01f,
  5.87355196e-01f, 2.30454966e-01f, 2.17015803e-01f, 2.39962071e-01f, 5.62472343e-01f, 2.98088878e-01f, 1.78218216e-01f, -2.33644977e-01f, -8.78397673e-02f, 1.58927843e-01f,
  3.19776207e-01f, 9.76226181e-02f, -5.02101667e-02f, -6.69534951e-02f, -7.53386170e-02f, -9.35491025e-02f, -1.02997862e-01f, 8.01874995e-02f, 1.79017261e-02f, 2.02606186e-01f,
  1.49695560e-01f, -7.47494958e-03f, 2.68342625e-03f, -1.37132749e-01f, 2.31996998e-01f, 1.21678074e-03f, 4.74649630e-02f, 3.72293055e-01f, 2.23420933e-01f, 7.20648989e-02f,
  3.41098756e-01f, 3.07493377e-02f, -4.46620554e-01f, 6.49757683e-02f, 1.55746162e-01f, -1.89486995e-01f, -2.40142480e-01f, -2.15773404e-01f, -8.79070982e-02f, -2.30894506e-01f,
  9.86899361e-02f, -3.39924432e-02f, 1.79824069e-01f, -9.83486995e-02f, -1.63644239e-01f, -1.86386958e-01f, -1.52850330e-01f, -3.39609534e-01f, -2.17088342e-01f, -1.38920814e-01f,
  -3.81677635e-02f, 2.71858841e-01f, 1.84571728e-01f, -2.64143854e-01f, 4.93851118e-02f, 1.86039180e-01f, 2.95574404e-02f, -3.46349478e-02f, -6.27075508e-02f, -1.25084117e-01f,
  -2.04646155e-01f, 1.61446720e-01f, 1.69622317e-01f, -1.41259134e-01f, 8.25571567e-02f, -5.42550124e-02f, -4.14272957e-02f, 1.91032574e-01f, 8.53327066e-02f, -1.18491217e-01f,
  -1.85382411e-01f, -1.09527908e-01f, -8.93627033e-02f, -1.87146276e-01f, -4.63226363e-02f, 8.35750178e-02f, -1.14206718e-02f, 2.91659608e-02f, 8.41775611e-02f, -1.55768201e-01f,
  1.16636880e-01f, 1.23151587e-02f, -2.48865392e-02f, -2.19019592e-01f, -2.16302887e-01f, 5.91843873e-02f, -8.74934494e-02f, 1.34530906e-02f, 5.04110660e-03f, -7.25624710e-02f,
  -3.87995452e-01f, -2.49768630e-01f, -2.50606865e-01f, -1.00104891e-01f, 2.82699525e-01f, 1.31996349e-01f, 7.70823434e-02f, 2.00414166e-01f, 2.57950485e-01f, -1.66055962e-01f,
  2.89608613e-02f, 1.42028406e-01f, -8.53940845e-02f, -2.67961323e-01f, -5.73321059e-02f, -8.97530615e-02f, 1.47222713e-01f, 1.06407359e-01f, -2.14796707e-01f, -2.01502636e-01f,
  -2.26377428e-01f, -3.02672647e-02f, 1.07960179e-01f, -2.80577242e-01f, -2.55449742e-01f, -8.82698819e-02f, -3.43458764e-02f, -1.60136923e-01f, -3.62446643e-02f, -2.29604766e-01f,
  -8.89894545e-01f, -4.02776450e-01f, -6.28086984e-01f, -6.90551341e-01f, -8.31934065e-02f, 4.12339360e-01f, 3.64789456e-01f, 4.00659680e-01f, -1.81514397e-01f, -4.65075970e-01f,
  -2.45812759e-01f, 1.81655452e-01f, -1.98586151e-01f, 2.15423062e-01f, 5.87494910e-01f, -1.00561105e-01f, -1.55134976e-01f, 1.62491053e-01f, 7.65116930e-01f, 8.06142628e-01f,
  5.14297903e-01f, -1.47220111e-02f, 9.65049416e-02f, 3.35298210e-01f, -5.72854400e-01f, -6.29762933e-02f, -6.20358050e-01f, -3.46713424e-01f, -1.17860027e-01f, -7.08401322e-01f,
  -1.05958235e+00f, -5.84294498e-01f, 3.29818010e-01f, 1.19093552e-01f, -2.71196514e-01f, 1.88465297e-01f, -1.91653892e-01f, -5.66023767e-01f, 1.25389084e-01f, -2.22478464e-01f,
  -3.29863727e-01f, 1.41066283e-01f, -1.49840355e-01f, 1.30114138e-01f, -5.22558764e-02f, 2.68450230e-01f, 1.01660332e-02f, 7.50755519e-02f, 8.70518014e-02f, 2.63799448e-03f,
  1.51971519e-01f, -2.90197819e-01f, -4.41239357e-01f, 1.66043192e-01f, 2.40520775e-01f, -4.59777415e-02f, -7.16874972e-02f, 8.91872942e-02f, 1.43709585e-01f, -7.26919234e-01f,
  -1.89609546e-02f, -4.52396572e-02f, -6.05187342e-02f, 1.33926375e-02f, 7.10114241e-02f, -6.43514693e-02f, -1.11563437e-01f, 2.59515226e-01f, 1.64205596e-01f, -4.37151231e-02f,
  2.91292846e-01f, -1.27279505e-01f, 1.58759162e-01f, 3.40316743e-02f, -7.35459924e-02f, -1.80570051e-01f, 1.17491119e-01f, 1.94853917e-01f, -4.70113717e-02f, -1.47672325e-01f,
  -8.63141865e-02f, -4.81479391e-02f, -2.12381154e-01f, 2.25250512e-01f, 1.32746184e-02f, 2.77147666e-02f, 7.27345124e-02f, 1.49507567e-01f, -8.16143379e-02f, 4.96097840e-02f,
  -3.51673603e-01f, 3.70845735e-01f, -6.19202137e-01f, 5.90606816e-02f, -5.33738256e-01f, -1.77357253e-02f, -3.19526851e-01f, 1.57070279e-01f, -2.65401632e-01f, -1.21723093e-01f,
  1.44654140e-01f, -6.08747788e-02f, -3.15063834e-01f, 2.14106813e-01f, -9.49813798e-03f, -4.57738899e-02f, 2.14236490e-02f, -4.69867811e-02f, 3.08480203e-01f, 4.83465791e-02f,
  5.87841272e-02f, 1.02104083e-01f, -2.07755774e-01f, 1.98174976e-02f, -1.04369372e-01f, -1.89236850e-01f, -3.52423370e-01f, -2.21317664e-01f, 4.34226431e-02f, -5.04379332e-01f,
  -8.36257041e-01f, 7.88931727e-01f, 9.96964127e-02f, -2.55670529e-02f, 1.71810791e-01f, 4.84246276e-02f, 2.75997579e-01f, -1.06445529e-01f, 1.52378142e-01f, 5.98278880e-01f,
  2.94652015e-01f, -3.36105525e-01f, 3.20519030e-01f, -2.85095889e-02f, -2.58583099e-01f, 7.87052751e-01f, 7.60695398e-01f, -3.84252667e-01f, -1.35764074e+00f, -1.03036308e+00f,
  2.57865377e-02f, -2.93319821e-01f, -6.22318685e-01f, -3.06393474e-01f, 5.48349619e-01f, 1.93167895e-01f, 7.16945469e-01f, 6.86182156e-02f, 5.78602925e-02f, 3.18943799e-01f,
  -3.14618319e-01f, 6.43902719e-02f, -2.72195995e-01f, -2.99379617e-01f, 4.72779870e-02f, -1.22351386e-01f, -1.34407729e-01f, 2.53251418e-02f, -2.44633382e-04f, -1.31144747e-01f,
  -9.44463760e-02f, -2.85770386e-01f, -1.00517236e-01f, -7.98759311e-02f, -2.64727920e-01f, -4.50378627e-01f, -2.63028834e-02f, -3.08244616e-01f, -5.71093410e-02f, -4.15406615e-01f,
  2.42127851e-01f, -3.11063617e-01f, -3.23238760e-01f, 2.35104620e-01f, 1.22170731e-01f, -4.14860964e-01f, -1.99556485e-01f, -5.59188843e-01f, -3.62004906e-01f, -1.42556757e-01f,
  1.52270779e-01f, -1.28060520e-01f, 1.22240491e-01f, 1.50988057e-01f, 7.25659952e-02f, 5.38909025e-02f, 9.82121825e-02f, 1.07468814e-01f, 2.76842356e-01f, -2.06591517e-01f,
  1.22003257e-01f, -9.81724709e-02f, -2.00333714e-01f, 3.71368736e-01f, 1.20782210e-02f, 4.38475423e-02f, -8.42367634e-02f, 8.22903886e-02f, -4.59077358e-02f, 4.15562838e-02f,
  -1.74068019e-01f, 5.84099703e-02f, 1.36749614e-02f, -2.03032777e-01f, 1.71168195e-03f, 6.22291677e-02f, 8.58386829e-02f, -1.64776772e-01f, -9.26819146e-02f, 1.18255071e-01f,
  -1.74430773e-01f, 1.43689871e-01f, 1.21931128e-01f, 2.62553189e-02f, 1.87082261e-01f, -1.73891690e-02f, 2.75787413e-01f, -1.47854909e-01f, -5.82768954e-03f, -3.90044600e-01f,
  -2.35320106e-01f, 3.36130634e-02f, 4.11616325e-01f, 5.20866774e-02f, -5.47555745e-01f, 1.30474985e-01f, 1.61910251e-01f, -1.28171667e-01f, 9.77671891e-02f, 4.28485572e-02f,
  1.63904294e-01f, -3.03339809e-01f, -4.74226236e-01f, 8.09846893e-02f, 1.65113155e-02f, -3.79973650e-01f, -4.11829531e-01f, -4.21496868e-01f, -4.55329642e-02f, 9.08724964e-02f,
  1.01471436e+00f, -6.63841069e-01f, 4.55751494e-02f, 1.44086152e-01f, 1.44883683e-02f, 2.67534643e-01f, -4.18296363e-03f, -6.11403622e-02f, 8.35429057e-02f, 1.17965303e-02f,
  4.37149182e-02f, 2.50015467e-01f, 1.15637906e-01f, -7.16786012e-02f, 2.69461628e-02f, -3.14750612e-01f, -3.90938520e-01f, 6.80249929e-02f, 3.55184644e-01f, 1.26463905e-01f,
  -2.58737862e-01f, -2.77811229e-01f, 4.93067242e-02f, -1.42598316e-01f, -3.31924856e-01f, -1.52543217e-01f, -2.76679486e-01f, -2.21642792e-01f, -4.08531308e-01f, -7.03041792e-01f,
  -2.70742565e-01f, 1.75391182e-01f, -1.76763418e-03f, -2.93157119e-02f, 2.37794011e-03f, -3.90140191e-02f, 7.20065534e-02f, -8.94330665e-02f, -1.54310297e-02f, 4.27895151e-02f,
  -8.97171348e-02f, -7.10667949e-03f, 1.16772771e-01f, 5.30927852e-02f, 7.02533452e-03f, 2.73790061e-02f, 1.62723377e-01f, 4.82536219e-02f, 2.62256227e-02f, -7.99879283e-02f,
  -1.20016254e-01f, 5.79890385e-02f, 2.35054687e-01f, 1.05709806e-01f, 2.26293981e-01f, 1.42383173e-01f, 2.04340415e-03f, 1.62946686e-01f, 2.45518327e-01f, 1.33039400e-01f,
  -4.85922303e-03f, 9.23041999e-02f, 1.96281344e-01f, 1.71544284e-01f, 2.69701332e-01f, 1.74207911e-01f, -1.10652177e-02f, 1.09240606e-01f, 1.05069652e-01f, 2.75928471e-02f,
  -4.99904975e-02f, 2.68536638e-02f, 1.12367436e-01f, 4.95566390e-02f, 1.65174343e-02f, -6.04100153e-02f, -1.26866382e-02f, -4.39092331e-02f, -3.58548611e-02f, 3.13434750e-02f,
  4.51649167e-02f, -4.29379083e-02f, -1.74179539e-01f, -1.54991582e-01f, -6.40962347e-02f, 4.28116620e-02f, -4.22403179e-02f, -1.00448847e-01f, -3.94273549e-02f, -7.36781731e-02f,
  -4.11219746e-01f, 3.87606174e-01f, 2.24383473e-02f, -4.41756798e-03f, -5.55721931e-02f, -5.84130809e-02f, 1.14175260e-01f, -1.64441273e-01f, -2.26118669e-01f, -5.55986539e-02f,
  -5.98181523e-02f, -1.57335829e-02f, -7.94450045e-02f, 3.15170214e-02f, 4.65538725e-02f, 1.26285106e-01f, 3.99018452e-03f, 1.03846624e-01f, -7.12205768e-02f, -2.87140936e-01f,
  -1.91317424e-01f, 1.67947173e-01f, 1.90669745e-01f, 2.03044429e-01f, 1.63042173e-01f, 2.07895085e-01f, 1.14831999e-01f, 1.12167401e-02f, 1.89107090e-01f, 2.12901738e-02f,
  -1.36294806e+00f, 4.48924631e-01f, -1.89724341e-01f, -6.41346633e-01f, -5.35008132e-01f, -3.00163925e-01f, 3.04681361e-01f, 1.76214322e-01f, -1.37605101e-01f, 3.00059468e-01f,
  2.04255819e-01f, -2.82660067e-01f, -2.70172376e-02f, -4.82873470e-02f, -3.89101386e-01f, 7.56345093e-02f, -3.96414340e-01f, -9.35301960e-01f, -7.87318826e-01f, -1.34795621e-01f,
  -1.51927829e-01f, -6.73025608e-01f, -8.19245160e-01f, -4.02096093e-01f, 2.53543824e-01f, -3.54944229e-01f, -9.53957886e-02f, -3.98295611e-01f, -5.27586564e-02f, -1.89545050e-01f,
  5.36449492e-01f, -4.25056696e-01f, -2.14420706e-02f, -2.14184731e-01f, 1.53764710e-01f, -4.64846268e-02f, -3.78511548e-02f, 6.70295581e-02f, 5.82318157e-02f, 2.06162885e-01f,
  -2.53630877e-01f, -5.10948896e-02f, -1.86402082e-01f, 2.09764779e-01f, -1.42750472e-01f, -4.78936061e-02f, 1.28944248e-01f, -7.51594007e-02f, 1.25905588e-01f, 5.24810851e-01f,
  3.39415103e-01f, -1.36015803e-01f, 5.31783663e-02f, 2.44211778e-01f, 6.11898154e-02f, -2.76425391e-01f, 3.27156305e-01f, 4.29782681e-02f, 7.95569941e-02f, 3.99850190e-01f,
  2.07616556e-02f, 4.36885536e-01f, 9.17759538e-02f, -3.36133875e-02f, 5.08181602e-02f, 9.30746049e-02f, -4.26576659e-02f, 1.51012659e-01f, -1.09656207e-01f, 8.01736936e-02f,
  1.99856222e-01f, 1.20231457e-01f, 7.74348080e-02f, -6.90505952e-02f, -5.08586615e-02f, -7.31196776e-02f, -6.40483275e-02f, 2.37540990e-01f, 9.15028527e-02f, -1.48153648e-01f,
  -5.53830639e-02f, 3.30439284e-02f, -7.31430724e-02f, 2.02880442e-01f, 1.28578482e-04f, 4.81790351e-03f, -2.53938213e-02f, 5.59442490e-02f, -8.10261220e-02f, -1.95754424e-01f,
  2.73854971e-01f, -4.28737700e-01f, -3.99028175e-02f, -1.39489606e-01f, -2.69074813e-02f, 1.61008090e-01f, 5.14292680e-02f, 7.31610060e-02f, -9.31566581e-02f, 9.11972225e-02f,
  -1.95219964e-02f, 2.62639634e-02f, 8.46779556e-04f, 1.95781156e-01f, -1.17007092e-01f, -1.88329779e-02f, 9.86601263e-02f, 1.60391945e-02f, -4.77136951e-03f, 1.29850134e-01f,
  2.32355490e-01f, -6.86906651e-02f, -8.01295042e-02f, 9.61894542e-02f, 9.14682299e-02f, -3.40041131e-01f, 2.52321482e-01f, 1.55242488e-01f, -7.40907714e-02f, 4.95613545e-01f,
  -4.66865182e-01f, -5.85012734e-01f, 3.44058871e-01f, -3.83591466e-02f, 5.26514590e-01f, 5.88513136e-01f, 5.22235513e-01f, 2.56638438e-01f, 3.76298912e-02f, 2.72335892e-04f,
  -4.80725795e-01f, -5.89420378e-01f, -5.12345552e-01f, -3.75304729e-01f, -1.13156654e-01f, 4.60661680e-01f, 6.23914540e-01f, 2.32649833e-01f, 1.27619103e-01f, 1.76924646e-01f,
  -6.78414851e-02f, -1.84746832e-01f, -4.35453266e-01f, -2.08793432e-01f, -1.01310022e-01f, -4.24464233e-02f, -4.58491743e-02f, -2.88229007e-02f, -3.23916040e-02f, -1.03692792e-01f,
  -4.86914873e-01f, -3.01866800e-01f, 1.88494906e-01f, -2.39759311e-01f, -1.40055001e-01f, -2.12384701e-01f, -6.62499443e-02f, -1.89073354e-01f, -1.59267336e-01f, 4.54760008e-02f,
  -1.50154024e-01f, -8.01256076e-02f, -6.41369522e-02f, 3.84235685e-03f, -1.23415329e-02f, 2.03826670e-02f, -7.56095201e-02f, -2.18963679e-02f, -2.37299185e-02f, -1.26866705e-03f,
  -1.31894916e-01f, 5.41244596e-02f, 1.42123371e-01f, 6.72232583e-02f, -3.76963057e-02f, 1.14104576e-01f, -2.34071743e-02f, 6.49554953e-02f, -3.51404808e-02f, -1.35253131e-01f,
  1.71221197e-01f, -3.66863981e-02f, -9.48979184e-02f, 5.67170279e-03f, 1.27232820e-02f, 9.52841267e-02f, 4.98241186e-03f, -1.45180598e-01f, -3.71734090e-02f, -7.81885535e-02f,
  -1.77737549e-02f, -4.40889271e-03f, -4.26163673e-02f, -1.04987331e-01f, -1.88257933e-01f, -1.18142627e-02f, 1.74054310e-01f, -2.27944046e-01f, -9.80082005e-02f, -2.73868032e-02f,
  -1.05623126e-01f, 1.01420775e-01f, -7.46862069e-02f, -8.76390934e-02f, 5.39932624e-02f, -8.01757723e-02f, -4.39717919e-02f, -8.01913291e-02f, 5.46094514e-02f, 1.47687599e-01f,
  -6.25230968e-01f, -4.03462276e-02f, 2.64789592e-02f, -1.32935122e-01f, -4.08159196e-02f, -2.05222666e-01f, -2.17649937e-01f, -7.08527640e-02f, 5.42272022e-03f, 5.24318777e-02f,
  -7.74710551e-02f, 2.54081786e-02f, -1.50776029e-01f, 3.90244611e-02f, 1.90059915e-01f, 2.01486563e-03f, -1.28066808e-01f, 6.89765066e-02f, 2.10963283e-02f, -6.52159238e-03f,
  -2.18745749e-02f, 2.11619094e-01f, 1.17702439e-01f, 2.89556608e-02f, 1.45396709e-01f, 1.94677010e-01f, 4.13176529e-02f, 9.98904034e-02f, 1.56451985e-01f, 9.72063169e-02f,
  4.78459716e-01f, 4.37291473e-01f, 2.68129528e-01f, 3.09051633e-01f, 1.13597833e-01f, 7.52639547e-02f, 2.67697424e-01f, 3.02713960e-01f, 7.00276811e-03f, 2.10512772e-01f,
  1.23561233e-01f, -4.07287598e-01f, -3.69687498e-01f, -2.27414310e-01f, -4.53660972e-02f, -8.03371817e-02f, -1.09081194e-01f, -3.25056016e-02f, -5.84326237e-02f, -7.10327236e-04f,
  -1.12518273e-01f, 3.03982437e-01f, 4.66622651e-01f, 1.66501060e-01f, -6.15762733e-03f, -4.29186493e-01f, 1.50234565e-01f, 2.75889903e-01f, -1.05953008e-01f, -2.03631237e-01f,
  -1.22617386e-01f, 3.74949515e-01f, -5.64748526e-01f, -1.45201325e-01f, 7.62463734e-02f, 2.14804947e-01f, 7.46579245e-02f, 1.04748689e-01f, 1.35328263e-01f, 1.40714303e-01f,
  -1.02654792e-01f, 9.65573490e-02f, 7.09707709e-03f, 1.18630655e-01f, 3.09828043e-01f, 7.21160844e-02f, 2.06740990e-01f, -2.55299602e-02f, -2.19025731e-01f, 2.44869478e-02f,
  -1.07320927e-01f, 6.56488016e-02f, 1.76081002e-01f, -8.42040256e-02f, -1.66819870e-01f, -2.29235128e-01f, -2.39946395e-02f, -5.74873947e-02f, -1.52422979e-01f, 2.98696626e-02f,
  -6.72272667e-02f, 1.50266439e-01f, -5.17739877e-02f, 1.34592019e-02f, 2.00181767e-01f, 8.23626816e-02f, 1.28297970e-01f, 1.37590291e-02f, 2.03500256e-01f, 4.06615257e-01f,
  1.96093768e-01f, 1.25141248e-01f, 4.70330387e-01f, 2.77933061e-01f, -1.95273291e-02f, 1.48103207e-01f, 3.24193358e-01f, 3.07762295e-01f, 2.39595622e-01f, 3.30913663e-01f,
  -8.68801996e-02f, 6.52676597e-02f, 1.51249260e-01f, 4.49704193e-02f, 9.01393443e-02f, -2.00668219e-02f, 5.32284789e-02f, 2.90618110e-02f, 1.29226685e-01f, 1.66579843e-01f,
  9.03859660e-02f, 1.38555422e-01f, -2.80322999e-01f, -1.68746158e-01f, 1.95798412e-01f, 1.62664950e-01f, -9.68952030e-02f, 1.54494150e-02f, 1.11310966e-01f, 1.45838469e-01f,
  2.73595843e-02f, 1.83324367e-01f, 2.36688405e-01f, 1.86188385e-01f, 1.67326495e-01f, -1.30669167e-02f, 1.21863201e-01f, 2.98214983e-02f, -1.25567988e-01f, 5.80129437e-02f,
  -8.72459486e-02f, -1.33687764e-01f, -6.48403838e-02f, -9.01207477e-02f, -1.01076327e-01f, -2.75598228e-01f, -2.27718987e-02f, -2.07812995e-01f, -1.08365752e-01f, 1.51023030e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  9.31207299e-01f, 1.47141838e+00f, 4.01274383e-01f, 2.48613685e-01f, 2.63859451e-01f, 8.07431400e-01f, 8.10911238e-01f, 4.87731874e-01f, 6.12070382e-01f, 9.69930470e-01f,
  8.33798230e-01f, 6.96557403e-01f, 1.04258180e+00f, 5.29113352e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -2.93159425e-01f, 6.95122629e-02f, -3.26243490e-02f, -5.36169223e-02f, -1.43761396e-01f, -3.10499638e-01f, -3.85744005e-01f, -3.47444862e-01f, -1.41200542e-01f, -5.16094081e-02f,
  2.25614652e-01f, -1.64860815e-01f, -9.51866582e-02f, -8.97396430e-02f, -6.24512974e-03f, -5.08720502e-02f, -4.10380252e-02f, 1.72131918e-02f, -9.55234244e-02f, 3.01321372e-02f,
  -6.20104194e-01f, -9.59890559e-02f, -2.70152897e-01f, -6.81530654e-01f, -2.88966298e-01f, -7.35643581e-02f, 6.60376012e-01f, -9.40694809e-02f, -4.57139850e-01f, -1.14207573e-01f,
  -2.95909762e-01f, -2.08852276e-01f, -1.56896517e-01f, 7.91797712e-02f, -1.79625824e-01f, -8.05767402e-02f, 4.69874978e-01f, -4.61711079e-01f, -1.78177876e-03f, -4.07235473e-01f,
  1.49676085e-01f, 8.64859074e-02f, 1.47817209e-01f, 2.60057449e-01f, 1.90385401e-01f, -2.44928986e-01f, 5.60430110e-01f, 1.69061702e-02f, -1.35605440e-01f, 1.06042132e-01f,
  -3.00606489e-01f, -1.89875826e-01f, -6.77356660e-01f, 6.07430220e-01f, -7.71628678e-01f, -2.94857562e-01f, -5.15610389e-02f, -9.67751622e-01f, 9.93949354e-01f, -1.41222978e+00f,
  6.18342817e-01f, -6.11249022e-02f, -1.03138661e+00f, -4.69688267e-01f, -2.02475511e-03f, -5.68151437e-02f, 2.08684325e-01f, -5.22541225e-01f, 1.43519327e-01f, 4.26337332e-01f,
  -3.47920060e-01f, -2.96897173e-01f, -1.43771216e-01f, -2.56188840e-01f, -5.20954847e-01f, -4.18492675e-01f, 2.68503040e-01f, 1.20425336e-01f, -8.75044391e-02f, 1.85503110e-01f,
  3.62753421e-01f, 1.72417492e-01f, 1.79804817e-01f, 1.41235709e-01f, -1.53990343e-01f, -5.89735448e-01f, -5.14158785e-01f, 1.49964273e-01f, 3.03988069e-01f, 1.05670325e-01f,
  -4.60631639e-01f, 1.03372969e-01f, -4.21227992e-01f, -3.03825899e-03f, 2.09692329e-01f, 1.77616328e-01f, -3.21776718e-01f, -2.24096864e-01f, -4.24152702e-01f, 6.47072673e-01f,
  -1.61169469e-02f, 1.01880655e-01f, -1.82345420e-01f, 6.62687778e-01f, -2.36637309e-01f, 2.88858026e-01f, -1.39023185e-01f, 5.76664694e-02f, -4.89949763e-01f, -1.97562888e-01f,
  4.27626312e-01f, -6.02646656e-02f, -3.51021856e-01f, 2.42278203e-01f, 1.22146361e-01f, 1.81609407e-01f, 2.43004352e-01f, -1.17229474e+00f, 7.24331811e-02f, 5.43820798e-01f,
  2.33854726e-01f, 1.15135945e-01f, 5.21278858e-01f, -1.61273181e+00f, 4.31826919e-01f, -5.41346490e-01f, -4.31449443e-01f, -4.75190312e-01f, 6.92044422e-02f, -6.33733794e-02f,
  2.96742860e-02f, 2.87970334e-01f, 1.88381836e-01f, -4.18698519e-01f, 2.41438285e-01f, 8.48076865e-02f, 5.30696288e-02f, 2.50419620e-02f, 2.62734801e-01f, 2.35403329e-01f,
  -2.16204017e-01f, -1.42112091e-01f, 5.95298111e-02f, -4.18052338e-02f, 1.20746039e-01f, 1.60538211e-01f, 1.95855990e-01f, 2.59173751e-01f, 3.86086375e-01f, 1.19111992e-01f,
  4.85386580e-01f, 1.77315235e-01f, 2.21141502e-01f, -5.13966121e-02f, -5.96250832e-01f, -3.14978451e-01f, -5.13001196e-02f, -2.79570132e-01f, 3.97720039e-01f, -4.89964753e-01f,
  -3.98486644e-01f, 1.68979745e-02f, 4.55932319e-01f, -3.91877830e-01f, 4.87322398e-02f, -5.43286741e-01f, 3.87777239e-01f, 3.35543752e-01f, -5.23853660e-01f, 5.01656532e-01f,
  1.43720910e-01f, 3.58915955e-01f, 3.57633144e-01f, 4.04415607e-01f, 4.54521775e-01f, 7.42667243e-02f, 7.61675537e-02f, 1.96272418e-01f, -3.93222608e-02f, -6.02079213e-01f,
  -2.44493455e-01f, -4.82320070e-01f, -3.80050875e-02f, -6.75519168e-01f, 6.31965995e-01f, -1.46426827e-01f, 7.56884873e-01f, -2.07078233e-01f, -2.00442616e-02f, -7.47473776e-01f,
  -3.64614815e-01f, 4.01287489e-02f, 2.31209286e-02f, -7.44578913e-02f, -6.07685111e-02f, -3.44774306e-01f, -9.58549902e-02f, -6.48150265e-01f, -4.01956700e-02f, -1.02826040e-02f,
  -7.59284049e-02f, -1.80859789e-01f, -5.15835136e-02f, -1.11241244e-01f, 9.43231955e-02f, -2.38757312e-01f, -4.76670772e-01f, -5.07420935e-02f, -6.92824006e-01f, -9.81258154e-02f,
  -3.62501919e-01f, -1.73649937e-01f, -5.86287379e-01f, -2.25374967e-01f, -1.98021829e-01f, 1.74604803e-02f, 2.22190581e-02f, -1.64315924e-02f, -5.44363916e-01f, -1.97737604e-01f,
  6.67244434e-01f, -8.26644227e-02f, -1.62082374e-01f, -2.76496798e-01f, 1.05137952e-01f, -1.86893657e-01f, 9.48579669e-01f, -3.30210477e-01f, -4.17219251e-01f, 5.00173688e-01f,
  2.86531877e-02f, -1.17141235e+00f, 1.48569882e-01f, -1.93920255e-01f, -1.21326089e+00f, 1.09350465e-01f, -1.05098701e+00f, -6.48632348e-01f, -1.67721272e+00f, -1.99188218e-01f,
  2.99864858e-01f, 1.80147588e-01f, -4.85319078e-01f, -1.92216074e+00f, -3.09920460e-01f, -3.43787819e-02f, -3.94251108e-01f, -7.65966550e-02f, -1.17063475e+00f, -6.20935023e-01f,
  3.94223511e-01f, 5.93158662e-01f, -3.65427375e-01f, 3.35037977e-01f, 6.70865476e-01f, -2.60077924e-01f, 2.63502747e-01f, 8.51990953e-02f, -7.19371140e-02f, 1.00468628e-01f,
  -2.42260128e-01f, -1.34993136e-01f, -5.72355986e-02f, -2.06357524e-01f, 3.03595886e-02f, 3.54365766e-01f, -3.48393112e-01f, 2.17339277e-01f, 2.59853125e-01f, -3.69670600e-01f,
  2.05578491e-01f, -3.68711948e-01f, -4.92525160e-01f, -3.58748958e-02f, -4.16188508e-01f, -1.35988757e-01f, 4.53873098e-01f, 5.46744585e-01f, 1.68837085e-01f, 1.56917214e-01f,
  -1.19062856e-01f, -1.16544878e-02f, -1.98041663e-01f, -2.23529860e-01f, 3.25513214e-01f, -2.23929197e-01f, 6.77622333e-02f, 4.23830062e-01f, -7.92251080e-02f, -1.85686365e-01f,
  -1.79190248e-01f, -3.85246724e-01f, -3.68313640e-01f, -4.43355471e-01f, 4.50539365e-02f, 2.12020710e-01f, 2.13758975e-01f, 6.10548437e-01f, 5.87280750e-01f, 2.81014889e-01f,
  6.08292043e-01f, 5.29212415e-01f, -6.69199303e-02f, -3.55295926e-01f, -2.69485354e-01f, 7.10841045e-02f, -5.62444150e-01f, 2.62564063e-01f, -5.51518440e-01f, 5.23098052e-01f,
  2.64999449e-01f, -2.25317538e-01f, -4.57722157e-01f, -9.02664602e-01f, -1.16958630e+00f, 5.96085489e-01f, -2.97326267e-01f, 4.54358488e-01f, -7.81996608e-01f, -9.93981510e-02f,
  1.67812720e-01f, 2.30350628e-01f, 5.22750467e-02f, 4.11538094e-01f, 1.02686375e-01f, 2.88914442e-01f, 3.55904013e-01f, 3.32456976e-01f, 3.43970656e-01f, -2.32990608e-01f,
  3.49499017e-01f, 2.00983211e-01f, 1.51564525e-02f, 1.22487620e-01f, -7.39353523e-02f, -1.92070946e-01f, -1.15445710e-03f, 1.61448613e-01f, 2.58207291e-01f, 2.43492126e-01f,
  2.42377490e-01f, 1.19257621e-01f, -6.64414465e-02f, 1.84093222e-01f, 1.12654880e-01f, -9.75991562e-02f, 4.40161705e-01f, 2.66778499e-01f, -3.47172946e-01f, 2.93364286e-01f,
  -8.56356800e-01f, 3.97349298e-02f, 1.56631321e-01f, 2.53790736e-01f, -3.66572261e-01f, 7.16274798e-01f, 5.49278677e-01f, 5.38225651e-01f, 7.12096170e-02f, 6.14260137e-01f,
  2.69117832e-01f, -5.67721426e-01f, 4.23761040e-01f, -7.19426394e-01f, 6.46782577e-01f, -5.33417583e-01f, 8.11229706e-01f, -5.35772204e-01f, -2.55690247e-01f, -2.90931314e-01f,
  4.36585350e-03f, 7.86025465e-01f, -4.07079846e-01f, -8.72257352e-01f, -3.94519061e-01f, -5.51922441e-01f, -9.98416483e-01f, -5.65672576e-01f, -4.59637552e-01f, 4.26271468e-01f,
  -3.24691445e-01f, 5.85185289e-02f, -2.35893905e-01f, 3.59917521e-01f, -1.54813930e-01f, 1.97352797e-01f, 7.46067315e-02f, 2.61126935e-01f, -6.09379215e-03f, 1.40954852e-01f,
  -1.63430586e-01f, -2.72233337e-01f, -2.34561995e-01f, -4.35437448e-02f, 1.89316556e-01f, -5.27123362e-02f, -2.32621565e-01f, -1.55201167e-01f, -4.94159237e-02f, -1.09932460e-01f,
  -3.46348435e-01f, 2.97702193e-01f, 1.53847024e-01f, -7.52625093e-02f, -6.03938103e-01f, 3.97516161e-01f, 1.36661604e-01f, 1.11165538e-01f, -5.07885516e-01f, -1.96909793e-02f,
  9.68618691e-02f, 2.96330452e-01f, 1.43377945e-01f, -4.35539514e-01f, -5.16554946e-03f, -3.53699207e-01f, 3.64244789e-01f, 4.43465821e-02f, 3.03113997e-01f, 7.50486255e-02f,
  -3.44328284e-01f, -3.18169534e-01f, -5.16961694e-01f, 1.99638888e-01f, -4.04229641e-01f, -4.14437711e-01f, 3.17780584e-01f, 2.71540821e-01f, 2.70911634e-01f, 2.93756515e-01f,
  9.62903500e-02f, 3.50230247e-01f, 2.64406353e-01f, -4.01109248e-01f, -6.24219418e-01f, 5.73473334e-01f, 7.66758978e-01f, -1.64227891e+00f, -7.02931285e-01f, -2.19117254e-01f,
  4.03471321e-01f, 9.22105983e-02f, -8.88410330e-01f, -4.94435132e-01f, -1.06470644e+00f, -9.65541840e-01f, -6.79011583e-01f, 5.54828495e-02f, -2.37702757e-01f, -3.43868762e-01f,
  5.69494441e-02f, -2.10723028e-01f, -2.12550834e-01f, 1.70715138e-01f, -3.85282159e-01f, -2.69769073e-01f, -2.95420766e-01f, -1.72381446e-01f, -1.97633803e-01f, -5.06645501e-01f,
  -1.59665897e-01f, -1.27439633e-01f, -1.25146836e-01f, 2.36540705e-01f, 7.20185712e-02f, 1.45909756e-01f, -7.70123079e-02f, -7.46364295e-02f, 1.06877953e-01f, -6.31287575e-01f,
  -1.05912052e-01f, -2.48412266e-01f, -1.45413382e-02f, -1.01952776e-01f, 2.00312048e-01f, -1.13841988e-01f, 1.51847303e-01f, 2.14703277e-01f, -1.06829219e-01f, -4.92660254e-02f,
  6.64666072e-02f, 4.85484675e-02f, 3.76528017e-02f, -2.78797120e-01f, -2.41898913e-02f, 3.46197218e-01f, 9.99559239e-02f, -1.01270795e-01f, -8.10387582e-02f, 2.69780129e-01f,
  2.60320991e-01f, 3.59964371e-02f, 1.55203015e-01f, -1.85425788e-01f, -4.35212821e-01f, 2.26793796e-01f, -4.24803793e-01f, -4.46963240e-04f, 1.75614476e-01f, -3.86344373e-01f,
  -5.13966918e-01f, -6.38206899e-01f, 5.22423327e-01f, -2.98967183e-01f, -2.47213572e-01f, -1.55753449e-01f, 2.44159326e-01f, 1.10466290e+00f, -5.34151435e-01f, -8.63163412e-01f,
  4.36969250e-01f, -7.19563365e-01f, -4.96742949e-02f, 1.69934079e-01f, -2.38571316e-01f, 1.01248793e-01f, -9.03976113e-02f, -4.85043108e-01f, 1.06271625e-01f, 4.65968698e-02f,
  1.69714153e-01f, 2.65518069e-01f, -6.24751858e-02f, -2.21132442e-01f, 3.70242745e-01f, -2.21851185e-01f, 4.51845288e-01f, -4.04978432e-02f, 1.78959787e-01f, -2.66227573e-01f,
  -2.13293940e-01f, 1.15482546e-01f, 1.47826478e-01f, 2.76217144e-02f, 2.02231243e-01f, 6.93542361e-02f, -2.21594974e-01f, -1.76182967e-02f, 3.64061773e-01f, 3.09412897e-01f,
  -2.93505847e-01f, 2.15346172e-01f, 7.84256399e-01f, -2.61350006e-01f, 4.05738801e-01f, 2.31079414e-01f, 1.28535153e-02f, 4.59382623e-01f, 4.29591388e-01f, 1.65300533e-01f,
  -1.50313675e-01f, -3.50869834e-01f, -4.01629061e-01f, -3.82047087e-01f, -3.30855995e-01f, -6.28345966e-01f, 4.64328192e-02f, 2.02035338e-01f, 5.01538277e-01f, 6.16701424e-01f,
  3.84765148e-01f, -2.63129354e-01f, 3.55371207e-01f, -9.22089636e-01f, -3.61954689e-01f, -4.24248397e-01f, -1.69483628e-02f, 3.23571712e-02f, -7.92780459e-01f, 1.57629624e-01f,
  -5.02872169e-01f, -4.12178189e-01f, 2.64725775e-01f, -1.23045897e+00f, 1.08207750e+00f, 2.12861568e-01f, -1.24595888e-01f, -1.40059769e-01f, 7.46580437e-02f, 7.05272406e-02f,
  -1.41572610e-01f, 1.38016716e-01f, -4.94920649e-02f, 2.94104218e-01f, -5.27953468e-02f, 9.07490402e-02f, -2.62728333e-01f, 8.11604667e-04f, 2.29047075e-01f, 3.79742712e-01f,
  -3.27073514e-01f, 2.46232554e-01f, 1.75574005e-01f, -7.22732723e-01f, 3.39550748e-02f, -3.88114303e-01f, 4.73412946e-02f, -2.70749301e-01f, -2.34628469e-01f, -8.52445811e-02f,
  6.04103565e-01f, 1.84451029e-01f, 5.43623090e-01f, -4.61495578e-01f, 6.01729751e-02f, -2.16872737e-01f, 1.50264576e-01f, -6.30900860e-02f, -4.40815650e-02f, 1.93133876e-01f,
  -1.13957413e-01f, -6.03604317e-01f, -3.50640655e-01f, -1.20369373e-02f, 2.84530908e-01f, 2.42923275e-01f, 5.63520432e-01f, -5.59660852e-01f, 2.82298028e-01f, 1.06390074e-01f,
  2.83209890e-01f, 3.12831402e-01f, -7.58955896e-01f, 1.78538501e-01f, -5.42473674e-01f, 2.27339789e-01f, 1.60267934e-01f, -5.44735849e-01f, 5.42748272e-01f, 9.98963058e-01f,
  -1.23283766e-01f, -1.01703405e+00f, 4.39693153e-01f, 4.41095561e-01f, -1.55113244e+00f, -3.22948098e-01f, -5.85231006e-01f, -8.97816956e-01f, -9.77667987e-01f, 9.45044085e-02f,
  8.69347453e-02f, -3.27511281e-01f, 1.29088596e-01f, 2.62658708e-02f, 6.42147809e-02f, 3.40715319e-01f, 2.82755315e-01f, 8.09350386e-02f, -6.61651790e-02f, 2.26664245e-01f,
  3.71825635e-01f, 3.48276347e-01f, -4.09276813e-01f, 2.69963503e-01f, -1.62205771e-01f, 3.04387480e-01f, 2.86074251e-01f, 1.79017767e-01f, 3.54085416e-01f, -3.24307740e-01f,
  4.28164959e-01f, 4.20652509e-01f, 7.42712975e-01f, 2.58248802e-02f, -1.85911179e-01f, -2.29132175e-01f, -4.59631175e-01f, 3.08046676e-02f, -4.18667853e-01f, 3.38772655e-01f,
  2.24598438e-01f, 2.02524103e-02f, -2.47871161e-01f, -1.93645179e-01f, -7.95447156e-02f, -1.04459532e-01f, 8.46123621e-02f, 4.52187240e-01f, 2.92577207e-01f, -9.13919151e-01f,
  2.66823798e-01f, -3.98960859e-01f, -2.70751268e-01f, -1.81734025e-01f, -5.48834443e-01f, -1.80957630e-01f, -6.74544215e-01f, 1.38632223e-01f, 6.89901292e-01f, 3.23645145e-01f,
  1.00830364e+00f, -1.05652523e+00f, -1.35671109e-01f, -5.61490655e-01f, -5.92676163e-01f, -4.22760308e-01f, -4.96880978e-01f, -2.49291852e-01f, -8.12501729e-01f, -4.49477643e-01f,
  -9.64872658e-01f, 4.74009067e-01f, -6.64436042e-01f, -8.02704871e-01f, -3.01614553e-02f, 1.06340580e-01f, -3.58649567e-02f, -6.91614524e-02f, -9.19769928e-02f, 6.28061593e-02f,
  3.72178793e-01f, -9.73944068e-02f, -2.70179454e-02f, -1.02849312e-01f, -1.58318281e-02f, -2.87096053e-02f, -5.86327724e-02f, 1.41542396e-02f, 5.57613149e-02f, 1.91629991e-01f,
  3.25346775e-02f, -1.56143025e-01f, 3.17157395e-02f, -6.31824285e-02f, 3.40918630e-01f, -1.73848331e-01f, -9.50651243e-02f, -3.24317068e-02f, -3.12737674e-01f, 1.56274319e-01f,
  6.52240142e-02f, 2.31661990e-01f, 3.91923815e-01f, -1.11675523e-01f, -7.96261191e-01f, 1.43038422e-01f, 1.53386056e-01f, -1.20726295e-01f, 4.02840585e-01f, 1.72873005e-01f,
  -2.81672746e-01f, -3.25470805e-01f, -9.02702883e-02f, -2.66556174e-01f, 7.52191395e-02f, -1.42081782e-01f, -5.90424597e-01f, 4.35553104e-01f, -5.56776583e-01f, 3.07035714e-01f,
  -7.96855330e-01f, 2.74375647e-01f, 4.29901361e-01f, -2.12581739e-01f, -5.83070099e-01f, -1.35144725e-01f, -7.37349212e-01f, -1.61111802e-01f, -4.30633694e-01f, 9.02791917e-01f,
  -6.40832543e-01f, 6.37984335e-01f, -6.56795323e-01f, -2.32130568e-02f, -2.34534010e-01f, -8.19859505e-01f, -2.01560229e-01f, 7.63646960e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  8.93408060e-02f, -3.31979215e-01f, 7.48921409e-02f, -2.78294832e-01f, 4.58750548e-03f, 2.87304133e-01f, -1.62281767e-01f, 2.20003836e-02f, -7.00764358e-02f, 2.72137672e-01f,
  -1.00521885e-01f, -1.28132120e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    