/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.60090372e-02f, 1.44594461e-02f, 3.25462699e-01f, -1.27777234e-01f, -3.85252871e-02f, 3.91796678e-02f, 1.93423152e-01f, -7.61678144e-02f, 1.52712032e-01f, -2.08181292e-01f,
  -1.13719448e-01f, -8.89230445e-02f, 3.02751482e-01f, -2.13081852e-01f, 2.43932202e-01f, 3.31913680e-01f, -1.80473149e-01f, -1.15264267e-01f, 1.47293225e-01f, -1.33821577e-01f,
  9.93629694e-02f, -1.93274781e-01f, 2.90901452e-01f, -1.92551002e-01f, -1.17961727e-01f, -3.66238281e-02f, -1.71566397e-01f, 1.41397536e-01f, -3.43685836e-01f, 3.39679001e-03f,
  6.38685897e-02f, 1.97238009e-02f, 2.19558422e-02f, 2.26469021e-02f, -5.19132689e-02f, -2.52128355e-02f, -1.23372428e-01f, 9.31947455e-02f, 6.97936416e-02f, -2.45814305e-02f,
  -4.46836241e-02f, -5.41819409e-02f, -4.97375131e-02f, -3.78497993e-03f, -6.75033629e-02f, -3.87395062e-02f, 3.31350565e-02f, 3.91502231e-02f, 5.77472858e-02f, 4.82670031e-02f,
  4.17784303e-02f, -4.28627878e-02f, -7.60480091e-02f, -8.96429867e-02f, 4.78433333e-02f, 1.33700920e-02f, 1.46689815e-02f, 3.67029756e-02f, -3.79708670e-02f, -1.23291705e-02f,
  -3.64615805e-02f, 1.17937168e-02f, 3.03344540e-02f, 2.96247602e-02f, 3.02334409e-02f, -6.27701357e-03f, -5.36830761e-02f, 1.36547592e-02f, 5.10882810e-02f, 2.07657311e-02f,
  2.57615112e-02f, -7.37232296e-03f, -4.03311364e-02f, -1.51268458e-02f, -2.71731503e-02f, 7.84633681e-03f, -4.12528432e-04f, -2.45092679e-02f, -2.86858907e-04f, 4.88808900e-02f,
  -2.72602327e-02f, 3.37116271e-02f, -8.34497041e-04f, 2.57530566e-02f, 2.59833708e-02f, 8.27805419e-03f, -7.00530931e-02f, 2.94598602e-02f, 2.93040238e-02f, -5.11407899e-03f,
  -7.25220665e-02f, -1.59531176e-01f, 1.71879157e-02f, -1.96672771e-02f, 5.23579307e-02f, -4.54433300e-02f, 4.53195125e-02f, -3.92097384e-02f, -1.14243161e-02f, 8.23326781e-03f,
  -1.20280169e-01f, 2.31077988e-02f, -6.90933913e-02f, 2.65414827e-02f, 3.92430201e-02f, 1.57386065e-02f, -5.73632419e-02f, -1.12316430e-01f, -7.60907009e-02f, -4.21228223e-02f,
  -1.34525727e-02f, -3.24035399e-02f, 8.05075765e-02f, 1.17964940e-02f, -8.27854946e-02f, -6.28720671e-02f, -3.22315693e-02f, 4.07598019e-02f, -8.60585868e-02f, -1.89656354e-02f,
  2.30307445e-01f, 1.79932982e-01f, -3.09034288e-01f, 6.72355667e-02f, 2.96278656e-01f, -3.15808579e-02f, -1.57287717e-01f, 2.26309627e-01f, 1.08578324e-01f, 1.63082704e-01f,
  1.29256487e-01f, 2.03882866e-02f, -1.36039570e-01f, 1.82570312e-02f, -1.91000149e-01f, -2.77054846e-01f, 5.72132692e-02f, -2.28102189e-02f, -2.57952437e-02f, 2.59850502e-01f,
  -1.77136268e-02f, 3.61372918e-01f, -2.17202112e-01f, 1.97439849e-01f, 1.29088402e-01f, 8.40103328e-02f, 1.52174070e-01f, -6.71421289e-02f, 4.47733440e-02f, -1.30497783e-01f,
  1.54163977e-02f, -3.68200764e-02f, 4.16180342e-02f, -8.45042467e-02f, 4.16484959e-02f, -2.78342310e-02f, -1.73056331e-02f, -1.10907637e-01f, -5.26866540e-02f, 2.16012001e-02f,
  6.22263318e-03f, 3.21788527e-02f, -2.83496957e-02f, -2.65833419e-02f, 5.74897118e-02f, -5.78512512e-02f, -5.76550700e-02f, 3.78768034e-02f, 6.92171138e-03f, -4.18714769e-02f,
  -8.82200971e-02f, -5.00065424e-02f, -4.80790772e-02f, -2.35124771e-02f, -4.82595712e-02f, -2.18610447e-02f, -5.57766557e-02f, -7.48998150e-02f, 2.16746479e-02f, 7.52921328e-02f,
  6.00384250e-02f, 4.61786501e-02f, -9.32037923e-03f, 2.54350454e-02f, 6.12890087e-02f, 2.36368850e-02f, 6.87756855e-03f, 8.81273241e-04f, -9.45593324e-03f, 7.44032189e-02f,
  3.44157591e-02f, 8.74172971e-02f, -2.02235803e-02f, 1.12903621e-02f, 6.41834810e-02f, 2.96648256e-02f, -3.29622403e-02f, 1.61999557e-02f, -1.39731197e-02f, -8.40051193e-03f,
  -4.66034338e-02f, 3.65280770e-02f, -7.50972365e-04f, 2.85300966e-02f, -1.46110998e-02f, -6.43383712e-03f, 7.15648234e-02f, 1.55562973e-02f, -2.32277601e-03f, 1.18393009e-03f,
  3.22644055e-01f, 2.52068728e-01f, 1.17837796e-02f, 1.08845502e-01f, 5.68200424e-02f, 5.87098449e-02f, 3.43548693e-02f, 1.23490123e-02f, 3.77544686e-02f, 2.40193624e-02f,
  4.48541380e-02f, 9.02751740e-03f, 2.70780027e-02f, -4.69771074e-03f, -2.22236402e-02f, 9.61464122e-02f, 3.02720964e-02f, 1.25643248e-02f, 1.21781148e-01f, 8.96559097e-03f,
  8.64821449e-02f, 2.41972450e-02f, -2.15683877e-02f, 7.18555376e-02f, 2.87685469e-02f, 2.22060531e-02f, 3.21833417e-02f, -6.45302907e-02f, -2.75982134e-02f, -2.92142238e-02f,
  -3.74665856e-01f, 2.43773445e-01f, -3.10217202e-01f, -3.79570007e-01f, -2.88001411e-02f, 3.09048407e-02f, -1.58918947e-01f, 1.15755439e-01f, -1.68614879e-01f, 3.27807665e-01f,
  1.74669638e-01f, -1.11178882e-01f, 3.02152634e-01f, 1.72256604e-02f, -2.63455957e-01f, 1.52952731e-01f, -9.08666104e-02f, -2.54571997e-02f, 3.51543501e-02f, -1.19829774e-02f,
  -1.13098748e-01f, 2.27586836e-01f, -1.65644526e-01f, 1.69528946e-01f, -1.48755714e-01f, -1.22654803e-01f, -1.44764036e-03f, 2.81216726e-02f, -4.10636552e-02f, -5.85680315e-03f,
  -9.15884823e-02f, 1.96554154e-01f, 8.82855710e-03f, 5.53553067e-02f, 1.79115292e-02f, -2.45514624e-02f, -8.68777707e-02f, 5.51259844e-03f, -8.06865320e-02f, 6.26089098e-03f,
  -4.42458093e-02f, -4.04852442e-02f, 5.63622126e-03f, -2.49560047e-02f, -4.57983986e-02f, -6.22355677e-02f, 2.00032745e-03f, -5.82647473e-02f, -5.97841404e-02f, -2.14136243e-02f,
  -3.83547954e-02f, -2.89736856e-02f, -6.19960018e-02f, 6.31433055e-02f, -3.00670881e-02f, 3.90698276e-02f, -7.08642602e-02f, -5.10428809e-02f, 3.55091467e-02f, -1.83781628e-02f,
  1.82927120e-02f, 2.92039607e-02f, 2.61485763e-02f, 1.33011993e-02f, -4.81833406e-02f, 3.14959958e-02f, 1.62790362e-02f, 4.19278592e-02f, -4.70803753e-02f, -1.38933328e-03f,
  -7.11788014e-02f, -3.01444940e-02f, 1.11443140e-02f, -5.90672120e-02f, -4.10553962e-02f, -1.07373213e-02f, -7.55736753e-02f, 5.50877601e-02f, -3.34206335e-02f, -4.75377366e-02f,
  1.08585814e-02f, -2.35587582e-02f, 5.74977510e-02f, -1.32142054e-02f, 8.89557414e-03f, -1.50098680e-02f, 3.09135094e-02f, -3.11618354e-02f, -6.47742972e-02f, -1.69935878e-02f,
  1.04788370e-01f, 1.01802237e-01f, 4.51728255e-02f, -2.10702438e-02f, -2.45983042e-02f, 6.50279298e-02f, -3.74080054e-02f, -4.32708263e-02f, 7.58318081e-02f, 2.75245048e-02f,
  8.19840431e-02f, -1.01563530e-02f, -6.66108774e-03f, -9.45236301e-04f, -3.48550789e-02f, 7.24791065e-02f, -2.60563265e-03f, -2.74700522e-02f, -1.06800403e-02f, 3.03223031e-03f,
  3.52746397e-02f, 1.33805983e-02f, -1.69877596e-02f, -4.46495712e-02f, -3.56146246e-02f, -4.01666462e-02f, -6.97766542e-02f, -2.08287523e-03f, -1.93364620e-02f, 3.99409421e-03f,
  2.08227918e-01f, -2.81522810e-01f, 9.78728011e-03f, -4.09588486e-01f, 1.35971069e-01f, -1.41834989e-01f, -1.72509536e-01f, -1.12779446e-01f, 7.59748369e-02f, -2.14320928e-01f,
  -1.41455546e-01f, 1.74620692e-02f, 2.57395152e-02f, -3.42416167e-01f, -7.46065900e-02f, -6.67558610e-02f, -2.90379494e-01f, -2.02780887e-01f, 2.23541915e-01f, -1.61395580e-01f,
  -4.02375087e-02f, -2.13427663e-01f, -1.11683153e-01f, -1.46217598e-02f, -2.46456582e-02f, 3.66513990e-02f, -1.37119085e-01f, 1.82169065e-01f, -1.57678425e-01f, 8.24104622e-02f,
  1.54339835e-01f, -7.22607002e-02f, 3.64503413e-02f, -2.74305828e-02f, -6.41454607e-02f, -5.76051883e-02f, -7.32253352e-03f, 9.24196392e-02f, 3.71964090e-02f, 4.49903980e-02f,
  4.11266387e-02f, 5.45013286e-02f, -1.72865447e-02f, 2.70827487e-02f, 1.15824398e-02f, 2.60132719e-02f, -1.03575252e-02f, -6.17851689e-03f, -7.56550906e-03f, -1.21715246e-02f,
  1.63749177e-02f, -6.41339496e-02f, -5.07479198e-02f, -7.70279169e-02f, 3.47438455e-02f, 1.61139984e-02f, -5.28068729e-02f, 2.93278787e-02f, -7.46020600e-02f, -2.88223140e-02f,
  -5.73775843e-02f, -1.76391136e-02f, -3.39734964e-02f, 6.34794533e-02f, -1.30012250e-02f, -8.23062845e-03f, -3.56446020e-03f, 7.69473193e-03f, 3.75915319e-02f, -3.53677757e-02f,
  7.67078577e-03f, -3.05750500e-02f, 3.61431763e-02f, -1.08515574e-02f, -2.85230707e-02f, -3.44174216e-03f, 1.91131812e-02f, -3.93402614e-02f, -1.40021341e-02f, 4.75380989e-03f,
  2.50917207e-02f, -4.17660177e-02f, 1.53470843e-03f, -3.21618430e-02f, -1.57297309e-02f, -5.52732917e-03f, -3.60534489e-02f, -1.12640178e-02f, 2.74799354e-02f, -1.08534284e-02f,
  -3.19165409e-01f, -4.09188271e-01f, -6.03842083e-03f, 3.82283470e-03f, -1.15414327e-02f, -8.49694386e-03f, -1.15620354e-02f, 1.49801001e-02f, -4.82179690e-04f, -2.20182398e-03f,
  -7.51874968e-02f, -6.67530894e-02f, -2.99591105e-02f, -1.47133553e-02f, -2.29839589e-02f, -1.22792285e-03f, -3.80550139e-02f, 1.17182406e-03f, -8.23077187e-02f, -7.25835189e-02f,
  -7.00956360e-02f, 5.68990447e-02f, 2.58143041e-02f, -1.29641993e-02f, -8.41521695e-02f, 2.05516219e-02f, 9.17812157e-03f, -1.56928468e-02f, -3.98816727e-02f, -1.37204602e-02f,
  -3.34887356e-01f, -1.95119996e-02f, -2.14772224e-01f, -2.17119798e-01f, 3.33007187e-01f, 7.33080953e-02f, -1.26045361e-01f, 2.46503800e-01f, -3.03828865e-01f, 1.52946606e-01f,
  1.62472963e-01f, -4.61256623e-01f, 4.28887196e-02f, -4.61947732e-02f, -2.41426319e-01f, -1.86776653e-01f, -1.41130686e-01f, -2.15503648e-01f, -1.69364586e-01f, 2.74620205e-02f,
  -8.28926489e-02f, 2.80395865e-01f, 7.69421384e-02f, 3.36768895e-01f, 1.92920282e-01f, -1.68410398e-03f, 3.36007893e-01f, 3.73711698e-02f, 1.41265526e-01f, 6.47706166e-02f,
  1.31429713e-02f, -7.87793547e-02f, 2.57576816e-02f, -5.48108071e-02f, 7.55767897e-02f, 9.21745449e-02f, -2.96813212e-02f, -3.36524062e-02f, -4.07455340e-02f, -5.51058836e-02f,
  -7.57373646e-02f, -3.56669798e-02f, -7.88722187e-02f, -1.41893774e-02f, 3.57660837e-02f, 1.62679497e-02f, -1.65916272e-02f, 6.40300065e-02f, -2.92016529e-02f, -2.44891029e-02f,
  -1.02916900e-02f, -3.32099665e-03f, -9.74075869e-03f, -7.99116045e-02f, -3.09573989e-02f, -7.16509074e-02f, -8.38900730e-02f, 3.38950567e-03f, -3.38430554e-02f, -4.62957434e-02f,
  2.48337910e-02f, -1.13892565e-02f, 2.01129504e-02f, -1.68080200e-02f, 4.54736035e-03f, 1.56322792e-02f, -3.43058184e-02f, 4.88868542e-02f, -7.98035860e-02f, 3.19252238e-02f,
  3.19727324e-02f, -4.21100780e-02f, 3.77991796e-02f, 4.24699187e-02f, -2.00700462e-02f, -1.06931161e-02f, -1.97735596e-02f, -1.51485181e-03f, 2.52716802e-02f, 2.09579915e-02f,
  -2.63632853e-02f, 3.88827883e-02f, 1.85315348e-02f, 6.44178614e-02f, 1.08654927e-02f, -4.19352055e-02f, 1.96825601e-02f, -1.09288320e-02f, -2.65773311e-02f, 3.72571647e-02f,
  7.19268098e-02f, 1.18233874e-01f, -2.89043691e-02f, -4.94443923e-02f, -8.34448487e-02f, 4.50742953e-02f, -2.10534036e-03f, -2.66792830e-02f, 2.39098556e-02f, 1.74578074e-02f,
  7.94175789e-02f, 3.07407826e-02f, 6.62226826e-02f, 3.75088071e-03f, -1.11825429e-02f, 5.35267480e-02f, -1.53408796e-02f, -1.04136001e-02f, 7.12127388e-02f, -4.89725219e-03f,
  5.30152172e-02f, 1.71154719e-02f, -3.18485536e-02f, 3.52756828e-02f, 8.18040501e-03f, 5.86542822e-02f, 4.57916446e-02f, -1.46510424e-02f, 6.63242936e-02f, -1.07717961e-02f,
  2.52905518e-01f, 2.55473685e-02f, 1.87824026e-01f, 2.85866231e-01f, 5.50994603e-03f, -2.39735633e-01f, -1.84954211e-01f, 1.15178704e-01f, 2.00236723e-01f, -2.40568593e-01f,
  -2.24696562e-01f, 1.63263798e-01f, -2.95454472e-01f, -9.54478160e-02f, 1.49737686e-01f, -1.94062948e-01f, -4.48873527e-02f, -1.36471063e-01f, 1.04309015e-01f, 1.27278551e-01f,
  2.25771740e-01f, -1.15592845e-01f, 9.60011706e-02f, 4.44515198e-02f, 7.88085684e-02f, 2.10914418e-01f, 2.94810329e-02f, -8.38620141e-02f, -2.36486476e-02f, -2.58934796e-02f,
  -9.41805020e-02f, 7.97172636e-02f, 8.86207297e-02f, 1.49982003e-02f, 2.89087966e-02f, -2.19326094e-03f, -8.74681100e-02f, -1.14627585e-01f, -1.09570753e-03f, 7.85400718e-03f,
  -9.15602408e-03f, 3.83494198e-02f, 2.33980156e-02f, 2.24304851e-02f, 1.10601475e-02f, 2.06678528e-02f, 1.68295614e-02f, 1.89440716e-02f, 6.38566762e-02f, 4.12927708e-03f,
  1.09225124e-01f, -6.43978501e-03f, 2.37619411e-02f, -1.27960145e-02f, 7.21404701e-02f, 4.90354672e-02f, 7.54780844e-02f, 1.40390713e-02f, -1.02708368e-02f, 1.02153860e-01f,
  3.20217647e-02f, -4.85452311e-03f, -1.21184871e-01f, -1.61432326e-02f, -2.97583230e-02f, -5.26358560e-02f, -3.32497545e-02f, -1.21783745e-02f, -3.95963201e-03f, -2.32012849e-02f,
  6.02436438e-03f, -2.33102180e-02f, -3.10816877e-02f, -5.57713676e-03f, -1.79795939e-02f, 3.37710581e-03f, 3.71597754e-03f, -4.34919298e-02f, 5.57076707e-02f, 3.49370390e-02f,
  -4.46795151e-02f, -2.71629728e-02f, -5.33541781e-04f, -5.56537174e-02f, -4.71491925e-02f, -3.21053974e-02f, 4.68449257e-02f, -2.93266270e-02f, 2.06874255e-02f, 6.11939759e-04f,
  -6.33761883e-02f, 1.24685250e-01f, 2.34569516e-02f, -5.10179512e-02f, -4.69484478e-02f, -8.48319530e-02f, -1.94146633e-02f, 6.29326552e-02f, 7.42092356e-02f, -1.48752134e-03f,
  -3.07631530e-02f, -3.82455923e-02f, 7.10219191e-03f, -4.81745489e-02f, -2.97162891e-03f, 1.36559978e-02f, 4.20735888e-02f, 1.05275884e-02f, 2.29177456e-02f, 4.70139943e-02f,
  -5.03977314e-02f, -4.34601568e-02f, 3.54298055e-02f, 7.92542472e-02f, 3.15307686e-03f, 1.94808817e-03f, 1.80033334e-02f, 2.06708908e-02f, -2.07390822e-02f, -1.16627300e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.00237781e-01f, -4.75088507e-01f, -4.72300500e-02f, -4.52796035e-02f, 9.68165025e-02f, 1.23339660e-01f, 4.11534220e-01f, -3.28945905e-01f, -3.68735105e-01f, -1.94290012e-01f,
  -1.05273547e-02f, 8.29598587e-03f, 1.93939745e-01f, -3.40678573e-01f, 3.68890643e-01f, 2.35934369e-02f, -1.62612334e-01f, 2.84167398e-02f, -2.01088160e-01f, 1.59690902e-02f,
  -1.81190353e-02f, -1.52520612e-01f, -3.15833539e-02f, -3.56686980e-01f, -4.56906529e-03f, -6.91458359e-02f, 1.97387323e-01f, 2.30546147e-01f, -1.70232356e-01f, 1.45450756e-01f,
  -1.42587945e-01f, -2.31702790e-01f, -7.64173791e-02f, -1.59529403e-01f, 5.21017872e-02f, 6.36821315e-02f, 1.62438869e-01f, 1.26849920e-01f, 2.95517910e-02f, -1.70111898e-02f,
  1.01056367e-01f, -1.72413606e-02f, -2.18785733e-01f, 4.18136008e-02f, -9.03029218e-02f, -2.17662975e-01f, -7.89103433e-02f, -1.21186391e-01f, -7.50140473e-02f, -4.88095693e-02f,
  6.35174215e-02f, -1.22354217e-02f, 4.49383967e-02f, -1.62474113e-04f, 4.57119048e-02f, -1.29436087e-02f, 3.03398315e-02f, 1.33061871e-01f, -8.15309212e-02f, -3.34786437e-02f,
  4.49582674e-02f, 1.14532627e-01f, 4.63327877e-02f, -1.34601533e-01f, -1.38590327e-02f, -9.12013799e-02f, -1.43936908e-04f, -6.32443130e-02f, -1.69322919e-02f, -1.73187405e-02f,
  1.15059586e-02f, -6.11055410e-04f, -4.06735839e-04f, 6.01925850e-02f, -2.60191374e-02f, 4.76795211e-02f, 7.16042370e-02f, 5.82017824e-02f, 2.35964581e-02f, -3.72557528e-02f,
  6.41983701e-03f, 3.26210260e-02f, -2.24289531e-03f, 5.89985028e-02f, -6.15921281e-02f, 9.91383940e-02f, 7.01645808e-03f, -2.08223984e-03f, -1.12524945e-02f, 7.43131787e-02f,
  5.28263152e-02f, 4.97449636e-02f, -1.48045212e-01f, 1.48236016e-02f, -2.33984999e-02f, -6.35162462e-03f, -7.93359503e-02f, -1.40144393e-01f, 8.79361406e-02f, -3.31964605e-02f,
  6.52028620e-02f, 6.42824620e-02f, -1.95374712e-02f, -3.92959863e-02f, 1.65653154e-02f, -1.55427661e-02f, 5.82172088e-02f, 1.53399436e-02f, 1.40202781e-02f, -1.80827323e-02f,
  4.78791669e-02f, 1.05260640e-01f, -4.95408243e-03f, -3.65234911e-02f, -5.43160588e-02f, 1.19526118e-01f, 6.31340640e-03f, 8.82972553e-02f, 1.78069621e-02f, -7.17825256e-03f,
  4.90201533e-01f, -3.06484908e-01f, -5.10291040e-01f, -1.09020367e-01f, 2.12632164e-01f, 3.40488017e-01f, 2.52730381e-02f, -1.99758094e-02f, -2.77930140e-01f, -9.43904743e-02f,
  1.81509554e-01f, -6.35634884e-02f, -3.28795373e-01f, 2.51316696e-01f, 3.20605189e-01f, -1.57379463e-01f, 3.31574380e-01f, 1.86730132e-01f, -1.13451563e-01f, 1.45062327e-01f,
  1.60703480e-01f, 5.43592393e-01f, -3.79768051e-02f, 2.80348867e-01f, 2.36350954e-01f, -5.46700731e-02f, 1.65126964e-01f, -1.31927818e-01f, 2.18337029e-01f, 3.11813384e-01f,
  8.70123133e-02f, -9.09704901e-03f, -2.70179883e-02f, -1.69563573e-02f, 6.64136037e-02f, 1.14136174e-01f, -8.97725001e-02f, 3.75963338e-02f, -6.45417720e-02f, -8.40497669e-03f,
  -5.55076189e-02f, 1.22414296e-02f, 7.09307864e-02f, -6.21837601e-02f, 1.15530930e-01f, 8.11206456e-03f, -7.64684752e-02f, -3.54555226e-03f, -1.49355218e-01f, 7.25604768e-04f,
  -1.26500592e-01f, -6.55511916e-02f, 1.19461538e-02f, -3.97755206e-02f, -1.35555744e-01f, 4.32846062e-02f, -1.08117273e-03f, -3.49256843e-02f, -3.20083052e-02f, 6.31617084e-02f,
  1.02130465e-01f, 4.12324183e-02f, -5.79799786e-02f, 2.99984906e-02f, 3.09439357e-02f, -1.52928913e-02f, 9.84043069e-03f, -1.47862546e-03f, -8.24211836e-02f, 1.36995884e-02f,
  -8.32835808e-02f, 2.91065276e-02f, -4.46500331e-02f, -2.89403088e-03f, 5.90977594e-02f, 1.68775450e-02f, 8.25740024e-02f, 4.43819277e-02f, -7.38207176e-02f, -4.03201729e-02f,
  -7.55064785e-02f, 8.07840303e-02f, -4.64183278e-02f, -1.81462411e-02f, 3.37658077e-02f, -4.41510379e-02f, 2.36639567e-02f, 8.59349966e-03f, -6.01087138e-02f, 7.19855819e-03f,
  -8.00977275e-03f, -1.03294238e-01f, -1.49760008e-01f, -2.12726053e-02f, -5.67608438e-02f, 1.71681538e-01f, 2.53326632e-02f, 5.53155988e-02f, -8.29699263e-02f, 5.68249729e-03f,
  3.37885879e-02f, -7.59733375e-03f, 3.10863089e-03f, 4.37276773e-02f, -6.25375360e-02f, 2.98645403e-02f, -5.57866581e-02f, -1.17056437e-01f, 2.43124785e-03f, 7.72884861e-02f,
  -1.78603381e-02f, -4.02870737e-02f, -4.38911654e-02f, -2.53904816e-02f, 1.12308273e-02f, 2.48630531e-02f, 5.67123331e-02f, -4.33584824e-02f, -1.62363779e-02f, -7.86942840e-02f,
  6.05846234e-02f, -1.46427274e-01f, -9.87657998e-03f, 2.06696257e-01f, 1.29073218e-01f, -9.20072291e-03f, 1.53100193e-01f, 8.59509110e-02f, 2.44165123e-01f, -1.83036160e-02f,
  6.07359037e-02f, -1.01217650e-01f, -1.52731135e-01f, 1.12185337e-01f, 3.43864933e-02f, 5.02745621e-02f, 2.13771343e-01f, 1.68781169e-02f, 5.40168658e-02f, 5.03749773e-02f,
  6.07564971e-02f, 7.00591654e-02f, -2.79979315e-02f, -1.37860496e-02f, -2.85298284e-02f, -2.11082250e-02f, 1.37301255e-02f, -2.38076001e-02f, -4.33596894e-02f, -1.16534963e-01f,
  5.82289975e-03f, 1.10684395e-01f, 3.26762646e-02f, 4.48533287e-03f, -1.45646157e-02f, 6.86341077e-02f, 2.80071273e-02f, 1.48110325e-02f, -4.98385429e-02f, 1.47512341e-02f,
  5.58381192e-02f, -2.79047210e-02f, -1.95612572e-03f, -8.97958577e-02f, -1.40182571e-02f, -7.68486038e-02f, -2.93820146e-02f, 2.21475400e-02f, -9.15042087e-02f, -5.85528128e-02f,
  -6.01047277e-02f, -7.54091935e-03f, -1.24366954e-02f, 3.09044737e-02f, 9.42051709e-02f, 2.69650072e-02f, -9.07688066e-02f, -4.37685624e-02f, 4.92918454e-02f, 6.56505451e-02f,
  -8.28156099e-02f, 7.00675100e-02f, 5.95755912e-02f, -1.63257457e-02f, 7.89988190e-02f, -5.21244146e-02f, 3.42752486e-02f, 1.57130752e-02f, 5.58886006e-02f, -4.66242246e-02f,
  -1.60509236e-02f, -4.07989174e-02f, -6.05143420e-02f, -2.35149134e-02f, 2.47696862e-02f, 4.74564731e-02f, -8.15759078e-02f, 6.29065260e-02f, 1.14620961e-01f, 6.03412502e-02f,
  -5.79371192e-02f, 8.03765655e-02f, -9.29072052e-02f, -7.51706809e-02f, 1.33032557e-02f, -6.13169605e-03f, 5.88430315e-02f, -3.92481498e-02f, 7.70154148e-02f, -8.00314397e-02f,
  -1.30425848e-03f, 4.40667011e-02f, 1.93491206e-02f, 7.23680109e-02f, -2.81799417e-02f, -4.53998744e-02f, 3.35339047e-02f, -2.18120161e-02f, 3.50929028e-03f, -5.66630252e-02f,
  -4.72218171e-03f, -4.39536991e-03f, -5.18451631e-02f, -2.36822553e-02f, -6.20260052e-02f, 3.12929079e-02f, -3.98322493e-02f, 1.10649705e-01f, 7.85366073e-02f, 6.67586830e-03f,
  4.55963872e-02f, 5.74562512e-02f, 6.12577982e-02f, 7.79247060e-02f, -1.32911857e-02f, -4.92977947e-02f, -7.71910250e-02f, -1.71760470e-02f, -2.67314855e-02f, -1.71336532e-02f,
  2.39096105e-01f, -4.29166496e-01f, -1.81991488e-01f, 2.38187537e-01f, 2.90140420e-01f, 1.85043048e-02f, 1.01120114e-01f, 2.04198897e-01f, -1.66055933e-01f, -2.61772722e-01f,
  1.97904974e-01f, -3.11749429e-01f, -2.31372714e-01f, 2.28810683e-01f, 3.68154079e-01f, -7.58166090e-02f, 2.22073972e-01f, 2.75278408e-02f, 8.51524919e-02f, 1.07497133e-01f,
  2.47743487e-01f, 3.02974939e-01f, 1.15579449e-01f, 1.72926992e-01f, 1.59446761e-01f, 5.75369932e-02f, 5.55496775e-02f, -2.76525300e-02f, 8.66890177e-02f, -5.09688631e-02f,
  -2.47478113e-02f, -2.41188072e-02f, 3.69926058e-02f, -7.97583759e-02f, -9.62466188e-03f, -3.38147278e-04f, -6.27940148e-02f, 7.11704716e-02f, 9.25568640e-02f, 8.59919786e-02f,
  3.70260770e-03f, -1.52822519e-02f, -5.59561327e-02f, 1.24417283e-02f, 1.25007834e-02f, 3.72374505e-02f, 7.21164048e-02f, -4.55564782e-02f, -9.62471869e-03f, 6.67458400e-02f,
  1.98336528e-03f, 6.53931797e-02f, -2.84811128e-02f, -1.00504689e-01f, 9.03885290e-02f, -6.99931756e-02f, -9.48064402e-02f, -7.29303956e-02f, 1.20405555e-02f, 5.16774841e-02f,
  4.04558703e-02f, -4.32234704e-02f, -2.80520041e-02f, 8.82516205e-02f, -1.40642468e-02f, 8.51241797e-02f, 6.14696518e-02f, 1.41244577e-02f, -7.35271648e-02f, 3.33916359e-02f,
  4.32445072e-02f, 1.06371112e-01f, -1.10482685e-02f, -5.23454919e-02f, -7.34496564e-02f, -4.39096317e-02f, -3.18282284e-02f, -4.40609088e-04f, 2.62629744e-02f, -2.46922486e-02f,
  -1.43468780e-02f, 5.79655496e-03f, -1.82433948e-02f, -5.71879745e-02f, -8.06548893e-02f, 2.94751972e-02f, 2.44602282e-03f, -3.61244217e-03f, -6.04848787e-02f, 6.82464689e-02f,
  -3.38506885e-02f, -8.71150866e-02f, 2.60126442e-02f, -9.72258151e-02f, -8.97974297e-02f, 4.31367196e-03f, -1.19308785e-01f, -2.08328310e-02f, 1.00939553e-02f, 4.97747606e-05f,
  -4.41376865e-02f, 8.68488289e-03f, 1.06819542e-02f, 2.65776999e-02f, 3.86902466e-02f, 5.51383980e-02f, -5.99580295e-02f, -5.53600257e-03f, 1.64636876e-02f, 6.58160448e-02f,
  -7.89865255e-02f, -1.39022851e-02f, -3.78279462e-02f, -1.30506344e-02f, 6.82031503e-03f, -3.11778821e-02f, -1.19854741e-01f, -1.87611002e-02f, 3.68948765e-02f, 4.47395863e-03f,
  2.77026594e-02f, -4.96963523e-02f, -9.95297059e-02f, -1.88503087e-01f, -1.71973675e-01f, 2.81232804e-01f, -5.30660264e-02f, 1.93257123e-01f, 1.07804492e-01f, 1.45953996e-02f,
  -2.50768512e-01f, -1.15465606e-03f, 1.56327724e-01f, -2.44713083e-01f, 2.12095350e-01f, 2.00133741e-01f, -3.16986479e-02f, -1.46908984e-01f, -1.15939984e-02f, -8.94883871e-02f,
  -6.74600378e-02f, -1.11059196e-01f, -2.70708025e-01f, -1.18514664e-01f, -3.60243887e-01f, -1.27345785e-01f, -2.77009606e-01f, -2.44484171e-01f, -1.99830562e-01f, -1.56866968e-01f,
  -8.23399425e-02f, 6.78164065e-02f, -3.23907658e-02f, 3.75340395e-02f, 1.09010778e-01f, -5.05476370e-02f, -1.07650124e-01f, -3.76512334e-02f, 9.05260351e-03f, 6.62402958e-02f,
  5.71301654e-02f, 9.43633020e-02f, 7.22462386e-02f, 4.75193299e-02f, -1.19512090e-02f, 4.60984483e-02f, -5.32935597e-02f, -9.29533318e-02f, -4.37681153e-02f, 2.19486561e-02f,
  -1.60269216e-01f, -2.92767584e-02f, -3.55324671e-02f, -4.74953279e-02f, -7.48817399e-02f, -8.91921744e-02f, 3.14284898e-02f, -1.16710164e-01f, -8.59440565e-02f, 5.38411252e-02f,
  -3.95538695e-02f, 5.84831089e-02f, 4.77736369e-02f, 5.41806109e-02f, -1.95656549e-02f, 8.98031809e-04f, 1.85938943e-02f, 1.13549329e-01f, -6.40245974e-02f, -8.95471498e-02f,
  -7.93663319e-03f, -4.86241579e-02f, 4.55168597e-02f, 6.08890466e-02f, -5.95534146e-02f, 6.77214637e-02f, -7.18131429e-03f, -1.26694993e-03f, -1.03393653e-02f, 3.93564776e-02f,
  7.64251919e-04f, 4.65676188e-02f, -9.97393578e-02f, -1.16808437e-01f, -8.69468134e-03f, 4.08500507e-02f, -5.02120815e-02f, 1.22025302e-02f, -5.15589789e-02f, -8.80920216e-02f,
  4.03555855e-02f, 2.62347221e-01f, 3.55308130e-02f, -2.92803552e-02f, 2.97972076e-02f, -8.83358880e-04f, 4.36187573e-02f, 2.01893356e-02f, -6.41701072e-02f, 4.49237339e-02f,
  2.25604940e-02f, 7.99288973e-02f, 3.99077460e-02f, 1.78233869e-02f, -4.70821783e-02f, -4.49688314e-03f, -2.57113539e-02f, -2.23129150e-02f, -6.66961372e-02f, 1.54567370e-02f,
  -7.33292401e-02f, -8.47312901e-03f, 4.86518582e-03f, -6.42025247e-02f, -1.38129694e-02f, 6.76609809e-03f, 1.58931948e-02f, -2.79935766e-02f, -9.16192904e-02f, 6.63671941e-02f,
  -3.90390456e-01f, 5.73098421e-01f, 5.76028585e-01f, -3.25862497e-01f, 1.64995641e-01f, 3.21526468e-01f, 5.71314916e-02f, 2.54206538e-01f, 9.32753235e-02f, -1.33075207e-01f,
  -1.55901581e-01f, 2.72986293e-01f, 1.06836267e-01f, -2.20396370e-02f, -2.08255544e-01f, -1.73871238e-02f, -4.98739295e-02f, -1.53796123e-02f, 2.48252556e-01f, -2.57253908e-02f,
  -1.49441436e-01f, -2.46012256e-01f, -2.54304782e-02f, 6.89137876e-02f, -7.74632692e-02f, 2.01840661e-02f, -4.24626023e-01f, 1.61156520e-01f, -8.15282613e-02f, 9.31102484e-02f,
  2.64310092e-02f, -1.33856669e-01f, 1.29915282e-01f, 1.87609643e-01f, -5.54693080e-02f, 4.81172055e-02f, 2.85010841e-02f, -4.33138460e-02f, 1.55998254e-02f, 8.02640766e-02f,
  -2.20307577e-02f, 5.33458292e-02f, -8.73246565e-02f, 1.14668682e-02f, 3.55647802e-02f, 4.84809615e-02f, 1.55372635e-01f, 8.42026994e-02f, 1.61123157e-01f, 1.48611024e-01f,
  2.03653395e-01f, 1.70655116e-01f, 3.80928116e-03f, -4.27719727e-02f, 1.90531947e-02f, 5.46200015e-02f, -4.94646579e-02f, -1.26640340e-02f, 1.16604730e-01f, 3.64213251e-02f,
  5.70865087e-02f, 1.78304315e-02f, -2.12413408e-02f, 8.87852535e-03f, 2.92600449e-02f, -3.91261727e-02f, -4.14897017e-02f, -1.04955584e-01f, -2.12079026e-02f, -4.30614315e-02f,
  -6.03512414e-02f, 9.52435844e-03f, -5.24472147e-02f, 3.40909287e-02f, -9.12293326e-03f, -9.83897299e-02f, -1.51444785e-03f, -5.16155288e-02f, 2.45428570e-02f, -1.17423117e-01f,
  -9.67885256e-02f, 4.88386713e-02f, -6.17872626e-02f, 4.56524603e-02f, -5.71541600e-02f, 1.83483269e-02f, 4.95820902e-02f, 1.41951084e-01f, -5.15358336e-02f, -3.30499075e-02f,
  1.82308722e-02f, -8.96722600e-02f, 4.61667310e-03f, 7.19969273e-02f, 2.66698115e-02f, 2.55604610e-02f, 5.92264086e-02f, 1.75350776e-03f, 2.53015235e-02f, -1.89201962e-02f,
  -4.45965969e-04f, -6.03130981e-02f, 6.76663443e-02f, -5.91861010e-02f, 7.95206651e-02f, 3.77644971e-02f, -1.12459958e-01f, 3.76695022e-03f, -2.71895379e-02f, -2.13617086e-03f,
  -8.45950504e-04f, -5.84562793e-02f, -1.06187254e-01f, -3.36134136e-02f, -1.55734131e-03f, -1.09171197e-01f, 6.35174755e-03f, 9.90772471e-02f, -3.46473753e-02f, 1.05711684e-01f,
  -2.84222424e-01f, 4.06330913e-01f, 4.02822457e-02f, -4.88699712e-02f, 7.22203478e-02f, -4.19146210e-01f, -1.97988033e-01f, 1.09078288e-01f, -2.05484241e-01f, 3.43261302e-01f,
  -2.26540072e-03f, 1.20315894e-01f, 3.70214432e-02f, -3.68218452e-01f, -8.59855890e-01f, -5.26892364e-01f, -3.29046756e-01f, -1.96908385e-01f, -2.52509028e-01f, 1.58577204e-01f,
  -2.10394368e-01f, -2.09032148e-01f, -1.58995748e-01f, 2.35172838e-01f, 1.76756158e-01f, 4.05446917e-01f, 2.77738154e-01f, 2.60105669e-01f, 1.88773364e-01f, -1.00315280e-01f,
  -1.59663722e-01f, 3.07774451e-02f, 1.42944679e-01f, -1.62985455e-02f, -2.90067997e-02f, 6.08789586e-02f, 5.06470352e-02f, -6.57698214e-02f, -3.62175554e-02f, -2.93280426e-02f,
  1.10110864e-01f, -1.86863169e-02f, -4.19791117e-02f, -1.25411376e-01f, 5.74106984e-02f, 7.37443119e-02f, 3.98695543e-02f, 3.76162529e-02f, 6.89137504e-02f, -5.13444096e-02f,
  1.97008569e-02f, 8.17766637e-02f, 2.64804568e-02f, 2.21104715e-02f, -5.23824506e-02f, -1.93144083e-02f, -5.94463199e-02f, 8.68847221e-02f, 3.72935459e-02f, -5.48647419e-02f,
  4.26986590e-02f, -8.34662002e-03f, -6.69208616e-02f, -6.94799796e-02f, -5.75464889e-02f, -6.23968430e-03f, 3.68693471e-03f, -1.27447881e-02f, -2.77646575e-02f, 1.07579576e-02f,
  -1.28056724e-02f, 3.14538814e-02f, -4.93778614e-03f, -2.15863381e-02f, -5.64010665e-02f, -4.97160181e-02f, 1.49896229e-02f, 3.44859213e-02f, -4.14742902e-02f, -3.51773866e-04f,
  3.45641188e-02f, -4.71344218e-02f, 5.39079728e-03f, 4.55841348e-02f, -1.35476932e-01f, -1.17459279e-02f, 2.14528479e-02f, -6.05526641e-02f, 1.96655504e-02f, -4.68564406e-02f,
  1.00657269e-01f, 3.41912329e-01f, -8.79210699e-03f, -4.87739295e-02f, 6.36393428e-02f, -2.83424575e-02f, -9.04592350e-02f, -4.00615968e-02f, -1.13970889e-02f, -6.92170113e-02f,
  9.85170901e-02f, 1.20986989e-02f, 1.06711574e-01f, 3.87162603e-02f, -6.40751645e-02f, 2.36478867e-03f, 8.74673873e-02f, -2.80703721e-03f, 4.52502407e-02f, 9.82973352e-02f,
  7.23312423e-02f, 5.41662760e-02f, -1.45881986e-02f, 5.43931201e-02f, 1.13625517e-02f, 1.14560463e-01f, 5.20492122e-02f, 3.57398167e-02f, 6.08749017e-02f, 5.92450090e-02f,
  -3.69512111e-01f, 1.34444207e-01f, -3.95276666e-01f, -1.49967924e-01f, -1.88383937e-01f, -2.76605159e-01f, 7.13799894e-02f, -9.15406272e-02f, 1.75258830e-01f, 4.62815911e-01f,
  3.29711676e-01f, 9.50011797e-03f, 3.58913809e-01f, 3.37124884e-01f, -3.31051111e-01f, 2.26482436e-01f, 4.18542400e-02f, 1.28366381e-01f, 1.01363482e-02f, -1.90314427e-01f,
  -1.37828559e-01f, 1.40340254e-01f, -1.47560522e-01f, 2.14228556e-02f, -1.08519047e-02f, -1.54098481e-01f, 7.76064619e-02f, -1.27296895e-01f, -9.43597108e-02f, -4.97304983e-02f,
  -7.87410364e-02f, -8.42524022e-02f, -1.60009060e-02f, -1.07801422e-01f, -1.14941478e-01f, -3.93196270e-02f, -1.30032614e-01f, -7.24768788e-02f, -4.69027050e-02f, 1.45029090e-02f,
  1.19388364e-02f, 4.36407840e-03f, 1.35716479e-02f, 6.22809529e-02f, 3.11669055e-02f, -3.92857678e-02f, -1.88521040e-03f, -2.10540481e-02f, -5.20481877e-02f, -1.34805322e-01f,
  5.50150909e-02f, -6.59499019e-02f, -7.39419982e-02f, -1.62573550e-02f, -3.31749059e-02f, 8.85941926e-03f, 2.04785038e-02f, -4.12098132e-02f, -1.05585717e-01f, -1.22716278e-01f,
  1.97740942e-02f, -2.05183495e-02f, 2.15159729e-02f, 4.55025695e-02f, -7.08858203e-03f, 3.87679935e-02f, 5.86551316e-02f, -1.11503052e-02f, -5.03800549e-02f, -6.44246936e-02f,
  -1.97108854e-02f, -4.14730869e-02f, 5.25769219e-02f, 4.33454067e-02f, 3.10292132e-02f, 8.14073905e-02f, 1.40549475e-02f, -4.48092930e-02f, 2.95406673e-02f, -7.30745792e-02f,
  9.65467002e-03f, -6.71121338e-03f, 1.95539128e-02f, 3.70530039e-02f, -4.48579863e-02f, 5.75618632e-03f, 9.90570337e-02f, 4.90132580e-03f, -2.08878331e-02f, -1.18264392e-01f,
  -2.86864549e-01f, -1.97146803e-01f, 2.51138620e-02f, 1.04228118e-02f, 6.56294972e-02f, -8.45884457e-02f, 6.36746809e-02f, -6.91338554e-02f, -3.31089683e-02f, 9.96112637e-03f,
  -1.18072182e-02f, -3.02861985e-02f, -1.49387047e-01f, 2.43676249e-02f, 1.69610325e-02f, -1.61140226e-02f, 8.72571692e-02f, -1.16261495e-02f, -6.86095729e-02f, -1.04105696e-01f,
  1.36256097e-02f, 1.62555482e-02f, -7.53296399e-03f, 5.21213189e-03f, -4.30735573e-02f, 7.23623931e-02f, -1.21818604e-02f, -4.68037166e-02f, -1.20357081e-01f, 4.47332114e-02f,
  -7.57069945e-01f, 4.58852828e-01f, -2.98771579e-02f, -1.95175156e-01f, 8.07544068e-02f, 1.10358283e-01f, -1.12879723e-02f, 5.60644530e-02f, -2.58627445e-01f, 1.81040391e-01f,
  1.37024865e-01f, -3.30823362e-01f, 2.39590988e-01f, 4.40312624e-02f, -1.78744614e-01f, 2.00608850e-01f, -3.72061692e-02f, -4.63917740e-02f, 5.00614233e-02f, -1.75906017e-01f,
  -6.42067119e-02f, 1.02457143e-01f, 1.69936329e-01f, 2.16812506e-01f, -1.33276135e-01f, -1.69622943e-01f, -7.91284516e-02f, 2.05796659e-01f, -2.96185259e-02f, 6.20379895e-02f,
  -1.03522450e-01f, -2.52804309e-01f, -2.72100419e-01f, -2.20024303e-01f, -1.05885774e-01f, -1.82234526e-01f, -8.67391080e-02f, -7.13443756e-02f, -5.57693653e-02f, -4.09997888e-02f,
  -5.98474592e-02f, -1.79960355e-02f, -6.49174005e-02f, -1.72697231e-02f, -9.52344835e-02f, -1.59729291e-02f, 7.43234381e-02f, 7.21934363e-02f, 1.11879990e-03f, 3.29496153e-02f,
  9.51856151e-02f, 5.08004092e-02f, 4.11405228e-02f, 7.82180112e-03f, -5.04227169e-03f, 3.97675112e-02f, 2.52656750e-02f, 2.71964259e-02f, -4.90283966e-02f, -3.74560319e-02f,
  -1.39916339e-03f, -2.55855247e-02f, -5.80360508e-03f, -1.35709047e-02f, 2.36524846e-02f, 5.83489984e-02f, -1.43305887e-03f, -5.01436330e-02f, -7.27888569e-02f, 4.17827512e-04f,
  -7.65062124e-03f, -2.55668648e-02f, -1.13681694e-02f, -3.54779810e-02f, -6.44567758e-02f, 4.78486018e-03f, 1.01075275e-02f, 2.19411962e-02f, 4.54880446e-02f, 8.02092850e-02f,
  3.65265906e-02f, 5.71437832e-03f, -1.50545835e-02f, -2.79809553e-02f, 1.62963860e-03f, 4.38480154e-02f, -2.05886569e-02f, 2.95843743e-02f, -2.88293939e-02f, -8.79041560e-04f,
  -2.19965979e-01f, -3.00738007e-01f, -1.54650301e-01f, -1.16671950e-01f, -3.83156538e-02f, -3.31452079e-02f, -4.77904975e-02f, -4.84028235e-02f, -9.05202553e-02f, -3.11159883e-02f,
  -7.05096796e-02f, -3.42231132e-02f, -8.42735171e-02f, -5.88800833e-02f, 4.17490564e-02f, -3.32598835e-02f, -7.70991147e-02f, -5.69250286e-02f, -9.88370627e-02f, -2.72406451e-02f,
  -8.14244449e-02f, -6.39963374e-02f, 5.89340366e-02f, 7.77119817e-03f, 1.27602974e-02f, -1.49666276e-02f, -1.19209938e-01f, -2.53630783e-02f, 9.43492260e-03f, 6.60690516e-02f,
  4.66141850e-02f, 1.43020600e-01f, 1.64890558e-01f, 8.64032060e-02f, -2.92135596e-01f, -4.83430892e-01f, -2.67791837e-01f, -7.18716532e-02f, -1.31081522e-01f, -8.61953795e-02f,
  4.71908040e-02f, 9.25336704e-02f, 1.96142018e-01f, 9.74229351e-02f, 2.85043478e-01f, 2.92315781e-01f, 1.13171458e-01f, 9.42802802e-02f, 8.32381323e-02f, 1.68504387e-01f,
  2.95297205e-01f, 6.88422397e-02f, 5.21946847e-01f, 8.70925114e-02f, 2.34916713e-02f, 6.05827123e-02f, 3.44104320e-01f, 1.00130968e-01f, 5.17334938e-02f, 2.13232860e-02f,
  -6.94008963e-03f, 9.01067406e-02f, 3.32694650e-02f, 4.59825527e-03f, 5.85524514e-02f, -5.22226468e-02f, -5.28881103e-02f, -8.64635874e-03f, -2.14899424e-02f, 5.51167317e-02f,
  -2.50640661e-02f, 1.52547853e-02f, -5.36807142e-02f, -9.39012095e-02f, -1.43692121e-01f, -4.32989039e-02f, 2.91981101e-02f, 8.69171396e-02f, -5.58668785e-02f, 3.41790989e-02f,
  3.81638668e-02f, 6.93912506e-02f, 7.85078760e-03f, -2.42073573e-02f, 5.55086657e-02f, -2.41686478e-02f, 2.98628993e-02f, 1.10625789e-01f, -1.01248056e-01f, -3.08237970e-02f,
  5.14446460e-02f, 1.53669566e-02f, -3.05457953e-02f, -9.57211107e-03f, -8.36436152e-02f, 6.79381564e-02f, -8.10084194e-02f, -3.64895165e-02f, -2.16249563e-03f, -2.07255725e-02f,
  -5.91686778e-02f, 2.85387542e-02f, -1.35010444e-02f, 7.74211832e-04f, 4.42649834e-02f, -2.62749679e-02f, -3.40636410e-02f, 7.07307756e-02f, -5.19973561e-02f, 7.37930685e-02f,
  -1.26081249e-02f, -2.06377059e-02f, -7.66247585e-02f, -3.52772400e-02f, 3.70170898e-03f, 9.81021971e-02f, 3.10992971e-02f, 1.21687343e-02f, 1.03357986e-01f, -5.32433111e-03f,
  1.21268496e-01f, 2.71815926e-01f, 2.82928348e-02f, -1.23894528e-01f, -5.42729488e-03f, 2.62109283e-02f, 7.62331113e-02f, 3.12929787e-02f, 4.46505984e-03f, 1.68412109e-03f,
  1.97986756e-02f, -2.77332533e-02f, -2.96084490e-02f, 4.82555553e-02f, -4.39701080e-02f, -1.08011737e-02f, -1.66136622e-02f, -6.44973069e-02f, -3.65093462e-02f, -6.75761933e-03f,
  2.11687516e-02f, -9.60884318e-02f, 4.09920402e-02f, -3.41075845e-02f, -8.20849650e-03f, -5.78820482e-02f, -5.00733033e-02f, -3.48164327e-02f, 7.35541731e-02f, 4.53895368e-02f,
  -7.61798918e-02f, 1.29468352e-01f, -1.11375004e-01f, -2.23879516e-01f, -1.35841355e-01f, -6.71113253e-01f, -4.83825654e-01f, -3.21464799e-02f, 2.68261641e-01f, 2.09816732e-03f,
  -5.95244728e-02f, 2.30905190e-01f, 2.35291496e-01f, -3.20007741e-01f, -2.33481199e-01f, 1.56324401e-01f, -6.02288842e-01f, -3.85121375e-01f, 9.61751565e-02f, -2.69671321e-01f,
  -1.32598653e-01f, -3.34383249e-01f, -1.03864811e-01f, 1.39046554e-02f, -3.92430544e-01f, 4.92573604e-02f, -7.22776651e-02f, 8.65804181e-02f, -2.81997383e-01f, -2.60695554e-02f,
  -8.13980401e-02f, 2.01917723e-01f, -1.56775564e-02f, 1.10332891e-01f, -1.70492887e-01f, -1.03698775e-01f, -7.36954063e-02f, 4.93607037e-02f, 9.88065153e-02f, 4.99443077e-02f,
  -5.28196879e-02f, 4.66634072e-02f, -2.81418972e-02f, 9.14367959e-02f, 2.98919948e-03f, 4.26691659e-02f, -4.74192202e-02f, -3.45978029e-02f, 9.08721685e-02f, 2.14676000e-02f,
  1.12192212e-02f, -3.31100076e-02f, -7.03419521e-02f, 3.14191282e-02f, -3.48206349e-02f, 1.28036430e-02f, -3.37255299e-02f, -5.07210754e-02f, -9.98962522e-02f, 7.36014694e-02f,
  4.50484194e-02f, -9.66393501e-02f, -1.52039779e-02f, -3.49447988e-02f, -1.61631089e-02f, 5.72553463e-02f, -1.09512629e-02f, 4.28036302e-02f, 6.58390820e-02f, -2.13480406e-02f,
  -3.43287438e-02f, 5.31933121e-02f, 3.63805592e-02f, -6.54536933e-02f, -7.13610724e-02f, 9.20215622e-03f, -1.99589562e-02f, -1.08354166e-02f, -4.70236987e-02f, -5.86103648e-03f,
  7.61538967e-02f, -1.39130484e-02f, -2.27932050e-03f, -8.51302594e-03f, -1.94749739e-02f, 7.39092529e-02f, -2.57818960e-02f, 1.16686346e-02f, -6.02351595e-03f, -8.82317033e-03f,
  -1.03985548e-01f, -7.44608417e-02f, 3.56574692e-02f, 4.19059955e-02f, -6.84309527e-02f, -1.38649251e-02f, -5.59808686e-02f, -5.95593117e-02f, -3.92295606e-02f, -4.08286788e-02f,
  -5.48358187e-02f, -8.28055143e-02f, -8.20223391e-02f, 8.80394131e-02f, -2.10436936e-02f, -8.92033949e-02f, -6.86003566e-02f, -3.46954055e-02f, -1.43761799e-01f, 7.58585706e-03f,
  -2.67144032e-02f, 2.41086986e-02f, 2.51610000e-02f, 3.07383407e-02f, 3.27214636e-02f, -3.30033824e-02f, -5.92790022e-02f, 7.73099437e-02f, -5.98489260e-03f, -3.30255218e-02f,
  -9.09484178e-02f, -1.25185117e-01f, -3.24280471e-01f, -1.99658662e-01f, -2.36182302e-01f, -8.70581493e-02f, -2.69829482e-01f, -1.17330603e-01f, -1.54732928e-01f, 8.31867084e-02f,
  -1.48858102e-02f, -3.53086032e-02f, -3.95075604e-02f, -8.10105577e-02f, 1.31380975e-01f, 1.85468554e-01f, 2.85259150e-02f, 1.27058461e-01f, 3.48759852e-02f, -2.72136211e-01f,
  2.53198966e-02f, -9.36262906e-02f, -1.45502212e-02f, 2.04437748e-02f, -2.76204944e-01f, -3.00742127e-02f, 1.73178121e-01f, -2.27938995e-01f, -6.13399856e-02f, -4.03195247e-02f,
  -8.74795243e-02f, -9.63010713e-02f, -8.02704766e-02f, -1.02923550e-01f, -1.31152317e-01f, -1.98141728e-02f, 3.49781401e-02f, 6.31452585e-03f, -3.21905911e-02f, -1.15048781e-01f,
  8.36758614e-02f, 2.60944683e-02f, -6.48656636e-02f, 6.77386746e-02f, 1.14468150e-02f, -1.77916940e-02f, 8.40163603e-02f, 7.64570832e-02f, -9.53721255e-02f, -9.32568535e-02f,
  -3.63383703e-02f, 3.89351579e-03f, 1.39692063e-02f, -9.11908876e-03f, 8.18946119e-03f, -2.01089866e-02f, -4.13350761e-02f, 4.72778305e-02f, 5.45701794e-02f, 5.38798720e-02f,
  1.47465710e-02f, 2.31317561e-02f, -1.60964206e-02f, -3.98098398e-03f, -1.91196278e-02f, -8.89378861e-02f, 2.06134617e-02f, 3.81317474e-02f, 8.27350169e-02f, -3.77553552e-02f,
  6.11508042e-02f, -4.19264138e-02f, -3.37088779e-02f, 4.47547249e-02f, -4.26472910e-02f, -5.71119934e-02f, 5.83273321e-02f, -3.21924663e-03f, 2.21837927e-02f, 2.42395829e-02f,
  3.21979560e-02f, 2.55901031e-02f, -1.69728789e-02f, 4.37743589e-02f, -2.84471549e-02f, -2.04295982e-02f, -2.79822736e-03f, -5.23367748e-02f, 4.60718423e-02f, -5.66010922e-02f,
  -6.10745586e-02f, -9.93384868e-02f, -1.00316502e-01f, 4.74306848e-03f, 2.67410949e-02f, -6.07642755e-02f, 6.31427690e-02f, 5.39101325e-02f, -2.22908761e-02f, -9.51564126e-03f,
  -1.21051017e-02f, -6.49412256e-03f, -1.42684542e-02f, -9.47374403e-02f, -2.09989697e-02f, 2.53300685e-02f, -4.07761820e-02f, 6.14508800e-02f, 1.37294848e-02f, 6.30684420e-02f,
  -4.59562987e-02f, -1.94892660e-02f, 7.95568600e-02f, 7.93063864e-02f, -3.33912224e-02f, 4.31131385e-02f, 6.35488471e-03f, 9.37382430e-02f, -8.53397138e-03f, -4.88148667e-02f,
  -2.34221164e-02f, 3.53429347e-01f, 2.60332644e-01f, -3.99339870e-02f, -2.46406049e-01f, -1.94091663e-01f, -1.53111383e-01f, 1.54558077e-01f, -1.56136304e-01f, 1.62060037e-01f,
  4.25760932e-02f, 1.26591623e-01f, -3.64446640e-02f, -7.15128556e-02f, -1.50571734e-01f, -6.45429343e-02f, -7.01562986e-02f, -7.40162283e-02f, 1.81971234e-03f, 3.54167491e-01f,
  -2.08224393e-02f, -1.38223633e-01f, 1.10162668e-01f, 2.22243890e-01f, 2.44199410e-01f, 3.03943753e-01f, 6.64886385e-02f, 9.28140581e-02f, 9.70452577e-02f, -9.42234844e-02f,
  -1.52848274e-01f, -7.38109602e-03f, 7.47824237e-02f, -6.63660765e-02f, 1.88111708e-01f, 1.84977621e-01f, -5.98220201e-03f, -8.75302628e-02f, 1.05529036e-02f, 8.19104817e-03f,
  4.75940518e-02f, 2.74929460e-02f, -3.85947563e-02f, -1.79641563e-02f, 6.06105179e-02f, 7.36276582e-02f, 1.37249976e-01f, 7.40370154e-02f, 3.62450331e-02f, 1.41298294e-01f,
  4.36262414e-02f, 8.46481472e-02f, 1.14929259e-01f, -1.59214027e-02f, 3.67825367e-02f, -2.86960676e-02f, 5.08818328e-02f, 3.07672452e-02f, 3.98976868e-03f, 5.25965095e-02f,
  7.19638988e-02f, -7.73244649e-02f, -2.85673570e-02f, -2.70255171e-02f, -5.69623336e-02f, -3.10516562e-02f, 7.88255706e-02f, -2.65952596e-03f, 3.98908183e-02f, -5.94054349e-02f,
  3.27535570e-02f, 4.19732109e-02f, -5.23341857e-02f, 1.20676737e-02f, 1.78676285e-02f, 1.70108359e-02f, 4.09469865e-02f, -1.27666099e-02f, 3.71326730e-02f, 9.76032838e-02f,
  -1.04327843e-01f, 1.04708998e-02f, 2.60056518e-02f, -5.35970628e-02f, 1.04643758e-02f, -7.17635229e-02f, 4.79133660e-03f, -2.55135763e-02f, -5.64907119e-02f, 2.79300492e-02f,
  1.30244687e-01f, 1.78838536e-01f, -1.79883430e-03f, -6.91936864e-03f, 4.12732102e-02f, 6.76395595e-02f, 4.31884229e-02f, 5.69797680e-02f, 6.15105666e-02f, 3.87436263e-02f,
  8.53095502e-02f, 3.30097266e-02f, 4.88755628e-02f, -3.43026668e-02f, -2.88167931e-02f, -3.44102159e-02f, 1.99440308e-03f, -8.76163691e-02f, 3.36639546e-02f, 1.58726841e-01f,
  1.64918378e-01f, 3.54539533e-03f, -2.79651135e-02f, -9.18762758e-02f, 6.11638352e-02f, 2.86291670e-02f, -6.81036897e-03f, 7.26841837e-02f, 7.18080997e-03f, 4.83762324e-02f,
  4.17560309e-01f, -2.50449091e-01f, 4.61754501e-01f, 5.24282575e-01f, 1.87175229e-01f, 7.97607005e-03f, 3.36723477e-01f, -3.72892879e-02f, 1.38564244e-01f, -2.53013730e-01f,
  -1.68406188e-01f, 2.38906324e-01f, -1.80581629e-01f, 3.19099287e-04f, -1.39908686e-01f, -3.35616648e-01f, -4.49881516e-02f, 1.24240248e-02f, 6.20236322e-02f, 8.02279077e-03f,
  1.46516308e-01f, -2.90683836e-01f, 6.29324764e-02f, -3.88191491e-01f, 2.51241028e-01f, 1.61687031e-01f, -2.52743632e-01f, -9.53621566e-02f, -7.43626282e-02f, -1.32432148e-01f,
  4.35665660e-02f, -1.79180969e-02f, 1.24684297e-01f, 4.30843942e-02f, 2.59657688e-02f, 2.38140859e-02f, 5.92343397e-02f, -2.59170551e-02f, 3.46261375e-02f, 1.08066939e-01f,
  2.65595987e-02f, 4.88920417e-03f, 6.43087626e-02f, -3.96604883e-04f, 5.06137386e-02f, 3.63553874e-02f, 1.47655740e-01f, 2.10696101e-01f, 1.03306308e-01f, 1.45488515e-01f,
  1.23641729e-01f, 1.39109045e-01f, 1.43674105e-01f, 1.43226413e-02f, 5.07823937e-02f, 8.23020935e-03f, 2.80031729e-02f, 3.63093652e-02f, -5.23173735e-02f, -3.29393111e-02f,
  2.85192225e-02f, -9.38202720e-04f, -3.17301676e-02f, 7.36793950e-02f, -3.28054689e-02f, 6.07964434e-02f, -3.67608480e-02f, 1.71884242e-02f, 3.70030031e-02f, -1.00047663e-01f,
  -4.55799848e-02f, 6.94327652e-02f, -1.70301534e-02f, 6.81460574e-02f, 3.12477946e-02f, 1.08257443e-01f, 7.37106204e-02f, -5.38268909e-02f, 6.26562238e-02f, 8.22820291e-02f,
  -2.87142377e-02f, -1.50935119e-02f, -8.77418071e-02f, 6.08149394e-02f, 5.72962919e-03f, 5.46454638e-02f, -9.91584081e-03f, 1.82367638e-02f, 5.55573367e-02f, 1.28804678e-02f,
  -3.02607477e-01f, -5.10155082e-01f, -1.00574538e-01f, -1.99819785e-02f, -1.63392141e-01f, -9.24784616e-02f, -7.98303559e-02f, 3.78130027e-03f, -1.15195975e-01f, -4.75440919e-02f,
  7.51941800e-02f, 7.99170807e-02f, -6.72775209e-02f, 2.31994037e-02f, -8.42482895e-02f, -9.14660320e-02f, -6.38467818e-02f, -1.04647771e-01f, -7.03205392e-02f, -6.25259429e-02f,
  5.64971603e-02f, -7.19221830e-02f, -6.11037388e-02f, 3.12803686e-02f, -4.36601155e-02f, 5.43046137e-03f, 2.22452474e-03f, -6.88618608e-03f, 5.62456017e-03f, 9.86427069e-03f,
  -2.69039094e-01f, 3.56410891e-02f, -1.11476615e-01f, -9.66161564e-02f, -1.76234707e-01f, 3.87540311e-01f, 4.07210797e-01f, -8.55166167e-02f, -1.22533605e-01f, 2.11918935e-01f,
  1.47181526e-01f, -7.64056593e-02f, 2.81885266e-01f, 6.99204281e-02f, 3.11584622e-01f, 4.49057221e-01f, 2.08459899e-01f, 3.23666781e-01f, -1.24183051e-01f, -2.63237618e-02f,
  -8.33282471e-02f, 1.25490025e-01f, 4.61787544e-02f, -1.75690889e-01f, -1.29046619e-01f, -3.48496407e-01f, -6.21182658e-02f, -4.20789346e-02f, -3.70762199e-02f, 3.61815915e-02f,
  -1.09536350e-01f, -2.30346084e-01f, -2.56725550e-02f, -6.53406233e-03f, -7.52455816e-02f, -4.56417091e-02f, 8.32721442e-02f, 2.77229380e-02f, -9.10342783e-02f, 4.03876603e-02f,
  3.98266539e-02f, -1.17528766e-01f, -7.64521584e-02f, -4.84140366e-02f, -8.48540738e-02f, -6.79990649e-02f, -7.29005039e-02f, 3.03735808e-02f, 8.07660539e-03f, 2.44248919e-02f,
  6.22202605e-02f, -2.74385437e-02f, -7.78233074e-03f, 1.16575599e-01f, -6.28983527e-02f, -3.06719299e-02f, 9.17777345e-02f, 1.34257844e-03f, -5.01962155e-02f, 1.66333653e-02f,
  -9.24832479e-04f, -2.43461356e-02f, 3.32115707e-03f, 8.62415880e-03f, 1.08654210e-02f, -9.30457376e-03f, 8.61222968e-02f, 3.47768553e-02f, 7.50575364e-02f, 6.24247491e-02f,
  -9.24426317e-02f, -5.36688194e-02f, -6.45110160e-02f, 8.24872311e-03f, 9.87711027e-02f, -2.80848909e-02f, 8.79245698e-02f, -1.02936707e-01f, -2.99646258e-02f, -4.73874062e-02f,
  -6.87699299e-03f, -3.14549915e-02f, -2.24561933e-02f, -2.43946444e-02f, 2.17648186e-02f, -3.22974287e-02f, -2.20397152e-02f, 1.29757943e-02f, 5.77352382e-02f, 4.72856015e-02f,
  -2.00299714e-02f, -1.36546090e-01f, 1.81452353e-02f, -9.52858552e-02f, 5.31918369e-03f, 2.38388404e-02f, -5.05211540e-02f, -7.38123730e-02f, 7.58028924e-02f, -7.75542781e-02f,
  -5.01026548e-02f, -3.83600034e-02f, 1.26210554e-02f, 4.05032979e-03f, -6.82199793e-03f, 1.40840253e-02f, 1.50979077e-03f, -5.59737645e-02f, 6.95620701e-02f, -5.46121262e-02f,
  -4.68304045e-02f, 8.54023397e-02f, 8.93263370e-02f, 3.19538899e-02f, 5.89447133e-02f, 3.55750136e-02f, -8.90739486e-02f, -5.55296876e-02f, 6.22753277e-02f, 5.64902648e-02f,
  -6.83024526e-02f, -1.20621525e-01f, 4.19394910e-01f, 1.47097856e-01f, 3.29668894e-02f, -7.31128752e-02f, 4.84295599e-02f, -2.03360170e-01f, -3.53315353e-01f, -3.61002028e-01f,
  2.98431441e-02f, 2.80435830e-01f, 6.47023022e-02f, 1.12047665e-01f, 4.35006708e-01f, 4.71750498e-02f, -4.04410847e-02f, 3.30477692e-02f, -4.73949760e-02f, 2.61366135e-03f,
  5.08924723e-02f, 8.23427439e-02f, 3.12790394e-01f, -5.30966446e-02f, 1.15736797e-01f, 2.19059046e-02f, 1.05172664e-01f, 2.69295663e-01f, 1.79664150e-01f, 2.01794699e-01f,
  -9.89674870e-03f, -9.62853059e-02f, -3.67925838e-02f, 2.63436511e-02f, -1.24336831e-01f, -2.67672632e-02f, 1.32930487e-01f, 1.29704580e-01f, 9.02455077e-02f, 5.19565772e-04f,
  1.44655621e-02f, 3.25907255e-03f, -3.36526111e-02f, 1.43123446e-02f, 8.57921317e-03f, 1.20598907e-02f, -2.94452459e-02f, 5.93160093e-02f, 4.84314859e-02f, 4.36504418e-03f,
  -4.99832593e-02f, 2.92269941e-02f, -1.12063484e-02f, 3.84793319e-02f, 2.64100861e-02f, -5.45760663e-03f, 2.13774890e-02f, 1.19660765e-01f, 2.26876494e-02f, -9.21849981e-02f,
  -1.97419291e-03f, -7.86185078e-03f, 5.14467247e-02f, 1.62195917e-02f, 1.08217515e-01f, -8.48415196e-02f, 1.04419790e-01f, -3.18920910e-02f, -4.84108515e-02f, 3.07160080e-03f,
  5.34053296e-02f, 1.59948580e-02f, -6.83910921e-02f, -3.46537642e-02f, -2.40060687e-02f, 5.96972695e-03f, 2.48236917e-02f, -4.76078875e-02f, -5.24161719e-02f, -9.70604792e-02f,
  -9.99541301e-03f, 8.48479196e-02f, -5.18029854e-02f, -2.61911880e-02f, -6.00181296e-02f, -8.72946717e-03f, -1.56559963e-02f, -2.81633977e-02f, -4.85395826e-02f, -6.47616433e-03f,
  -2.23493557e-02f, 5.96182309e-02f, 1.04408972e-02f, -6.00725859e-02f, -2.61663813e-02f, 9.72877908e-03f, 5.25646005e-03f, 6.62493557e-02f, 7.43902251e-02f, -5.13187274e-02f,
  -1.48792453e-02f, 6.41100258e-02f, 3.73930447e-02f, 2.03481913e-02f, 3.93337719e-02f, -7.25237047e-03f, 4.66969162e-02f, 3.01640481e-02f, 2.88692117e-02f, -2.38019181e-03f,
  -1.47728650e-02f, -4.08401489e-02f, -2.82729473e-02f, -3.93369645e-02f, -6.58007339e-02f, -6.46098852e-02f, 1.23613738e-02f, -4.76497859e-02f, 8.03496093e-02f, -4.53169569e-02f,
  -3.31995130e-01f, -3.94086480e-01f, -1.61437571e-01f, -1.09448381e-01f, 2.81137496e-01f, 2.34995410e-01f, -4.42251600e-02f, -1.93329737e-01f, -2.69231409e-01f, -1.75536916e-01f,
  -5.48096448e-02f, -2.33127415e-01f, -2.03348294e-01f, -8.96597952e-02f, -8.16585049e-02f, -1.31214157e-01f, -2.79450566e-02f, -1.74213927e-02f, -1.67238995e-01f, -1.49622649e-01f,
  -9.09204483e-02f, 7.97642916e-02f, -4.37828861e-02f, 2.57893950e-01f, -3.07059921e-02f, 1.66705877e-01f, 2.62283742e-01f, 2.65721858e-01f, 2.20384955e-01f, 1.53143436e-01f,
  -1.28833111e-02f, -2.97239661e-01f, -2.70153452e-02f, -2.62015034e-02f, 2.06335727e-02f, 6.82049617e-03f, 8.85284245e-02f, 1.30390644e-01f, 1.01561964e-01f, 5.32214046e-02f,
  3.59068215e-02f, 4.50929999e-02f, -2.92042107e-03f, -3.21844630e-02f, -3.51064326e-03f, -4.62207086e-02f, -2.98773926e-02f, -3.38023715e-02f, -8.28195661e-02f, -7.59269819e-02f,
  -1.29043698e-01f, -4.68039401e-02f, -5.25315031e-02f, 4.18994902e-03f, -8.97921063e-03f, 6.43463880e-02f, 1.04448445e-01f, -2.37587374e-03f, -5.47220819e-02f, 3.32854316e-02f,
  -3.40697356e-02f, 1.14295902e-02f, -2.08198372e-02f, -3.58505659e-02f, -7.05527216e-02f, 6.23280965e-02f, -9.95427952e-04f, 6.73198029e-02f, 8.12809020e-02f, -6.32410198e-02f,
  7.27709830e-02f, -6.81512803e-02f, -3.66298109e-02f, 2.85999961e-02f, 1.55489212e-02f, -5.15685119e-02f, 1.97143275e-02f, 6.57873228e-02f, -2.20164098e-02f, 3.59539948e-02f,
  -7.44564682e-02f, 7.88925290e-02f, -3.22491154e-02f, 8.67409483e-02f, 7.76596591e-02f, 2.48100329e-02f, 1.49843311e-02f, -9.62087885e-02f, -7.35494681e-03f, 2.12660655e-02f,
  9.81124192e-02f, -3.14001329e-02f, 1.54804885e-02f, 8.37191939e-02f, -3.66664268e-02f, 7.03249350e-02f, 5.00634871e-02f, -1.61742270e-02f, -5.90001196e-02f, -9.50017050e-02f,
  1.24653220e-01f, 1.06781811e-01f, -2.69026235e-02f, 8.03179666e-02f, 9.53919217e-02f, -1.02531798e-01f, -1.47430459e-02f, 1.12042703e-01f, 7.66142160e-02f, -2.14098282e-02f,
  4.47218157e-02f, 4.19717990e-02f, 2.89780851e-02f, -1.11519294e-02f, -1.35487169e-02f, 8.05056989e-02f, -3.08151506e-02f, 5.66801615e-02f, 7.93199465e-02f, 6.59084618e-02f,
  3.19202960e-01f, -4.97498751e-01f, -3.86286415e-02f, 4.28289920e-01f, 2.78152853e-01f, 4.05619331e-02f, 2.93608993e-01f, 7.98968449e-02f, 1.38471544e-01f, -2.21591800e-01f,
  1.76338598e-01f, -3.14285219e-01f, -1.71531543e-01f, -7.89264888e-02f, 1.44869521e-01f, -9.78422090e-02f, -8.82392749e-03f, -6.47961919e-04f, 1.16178051e-01f, 7.44692534e-02f,
  2.60685176e-01f, 3.90693247e-02f, -9.32510477e-03f, -1.48781106e-01f, 4.84645367e-02f, 3.59204449e-02f, 5.54288737e-02f, -1.36462059e-02f, -1.13839887e-01f, -1.68630295e-02f,
  5.06836660e-02f, 1.15427934e-01f, -3.11900340e-02f, 6.04041340e-03f, 6.05228618e-02f, 7.66891763e-02f, -6.95237070e-02f, -3.35263796e-02f, 1.94431588e-01f, 9.28360689e-03f,
  -1.12735093e-01f, 2.09115427e-02f, -4.62542428e-03f, -2.08131522e-02f, 1.18326016e-01f, 1.38149485e-02f, 5.32968231e-02f, 1.67627707e-02f, 3.60357389e-02f, -2.47307643e-02f,
  2.78133098e-02f, -1.28849195e-02f, 3.12964506e-02f, -1.09150872e-01f, 3.49084847e-02f, 5.86996339e-02f, 2.65956707e-02f, -5.11274226e-02f, 9.39846318e-03f, 5.51167130e-02f,
  -1.31309181e-01f, -2.30533537e-02f, -2.10391209e-02f, 3.99265140e-02f, 7.58862197e-02f, 8.52048323e-02f, -2.19138302e-02f, -3.34891714e-02f, -2.98640262e-02f, -5.22190332e-02f,
  1.03346363e-01f, 9.00507346e-03f, -3.07329260e-02f, 3.55803184e-02f, 8.95720944e-02f, -7.04422593e-02f, 6.98708296e-02f, -1.24684852e-02f, 9.25005302e-02f, -7.25161703e-03f,
  2.16254126e-02f, 2.88584474e-02f, -5.26210442e-02f, 1.40668964e-02f, -1.05953991e-01f, 4.64204736e-02f, -7.90098980e-02f, 3.88256088e-02f, 8.30083936e-02f, 4.89823520e-02f,
  -1.01568267e-01f, -3.13023657e-01f, -2.67009437e-02f, 1.38246076e-04f, 2.30798256e-02f, 1.34430630e-02f, -2.11535487e-02f, -5.01183607e-02f, -7.11849406e-02f, -3.40796933e-02f,
  9.44303069e-03f, 1.03676185e-01f, -8.75562243e-03f, 2.30286028e-02f, 1.53169269e-02f, 1.84236038e-02f, -2.58837119e-02f, 4.23439518e-02f, -6.19595125e-02f, -9.69770774e-02f,
  -1.36422301e-02f, 8.36667325e-03f, 4.20693308e-02f, 1.10909842e-01f, -4.41330709e-02f, 1.21210492e-03f, -4.27136570e-02f, 1.59542318e-02f, -1.33055791e-01f, -1.10819168e-01f,
  6.98929802e-02f, 1.04096830e-01f, -2.59435307e-02f, 2.29344696e-01f, 3.61604005e-01f, 4.93597478e-01f, 3.56653452e-01f, 3.21362644e-01f, 7.03302383e-01f, 7.05997273e-02f,
  8.12504720e-03f, 6.73666596e-02f, -1.77554876e-01f, 1.25370845e-01f, 2.28779763e-01f, 8.04339275e-02f, 4.57145065e-01f, 1.68955669e-01f, 2.58636832e-01f, 1.24836758e-01f,
  1.24212764e-01f, 1.65563032e-01f, -2.84346521e-01f, -1.72100589e-01f, 1.52896503e-02f, -6.91141039e-02f, -3.45332533e-01f, -2.30201080e-01f, -2.20397845e-01f, 1.29637569e-01f,
  -3.87875107e-03f, 1.46824390e-01f, -2.24872783e-01f, -1.23983555e-01f, -4.85418104e-02f, -1.15468867e-01f, -1.10058323e-01f, -1.48219019e-01f, 4.05223295e-02f, 4.77011278e-02f,
  1.09790824e-02f, -7.26409927e-02f, 1.14244111e-02f, -5.58310114e-02f, 6.97004795e-02f, -6.81435689e-02f, -3.76665033e-02f, 3.78118753e-02f, -1.86433699e-02f, -9.94248241e-02f,
  -6.64245188e-02f, -4.18227818e-03f, 7.17250258e-02f, 3.86160724e-02f, 2.32223701e-02f, -1.94267929e-03f, 3.44204828e-02f, 4.82752174e-02f, 7.25731328e-02f, 1.59273103e-01f,
  -1.84214078e-02f, 4.30858061e-02f, -7.18937367e-02f, -5.23838699e-02f, -6.05363660e-02f, -1.04719764e-02f, -3.03980373e-02f, -8.94228518e-02f, 1.05018010e-02f, -5.53942509e-02f,
  -2.65073199e-02f, 3.04331984e-02f, 1.00442261e-01f, -7.87375495e-03f, 6.79976046e-02f, 6.36570305e-02f, -8.06646869e-02f, 5.62234037e-02f, 7.87971541e-02f, 4.42619920e-02f,
  -6.86197132e-02f, 1.27367556e-01f, -7.88454637e-02f, -3.27298492e-02f, 2.01000571e-02f, -2.56099571e-02f, -2.13046521e-02f, -1.19996059e-03f, -3.32997181e-02f, -4.28994745e-02f,
  3.16270024e-01f, 3.71240169e-01f, 1.79537255e-02f, -6.47757873e-02f, -9.61041898e-02f, -5.69762029e-02f, 2.83791162e-02f, 1.03049785e-01f, 1.39242083e-01f, 1.33749768e-01f,
  3.85034718e-02f, -2.45872866e-02f, 9.50484769e-04f, -7.54774660e-02f, -4.82674763e-02f, 1.24696136e-01f, -1.49191702e-02f, 6.10235259e-02f, 1.07620969e-01f, -2.96314899e-02f,
  -6.79072067e-02f, 1.11148939e-01f, 2.16007847e-02f, -5.60992770e-03f, -1.96676478e-02f, -2.06682030e-02f, 1.27248704e-01f, -5.56092337e-02f, 1.94878820e-02f, 1.25896754e-02f,
  -1.38270751e-01f, -1.20031305e-01f, -3.32673602e-02f, 3.33716929e-01f, 6.47472590e-02f, -2.14484066e-01f, -3.48038346e-01f, 3.78658175e-02f, -2.02953756e-01f, -2.26289511e-01f,
  -3.39516029e-02f, -6.58855438e-02f, -3.55176777e-01f, 2.90572494e-01f, 2.83700556e-01f, -1.71993766e-02f, 1.80205062e-01f, 6.64023682e-02f, 9.16839615e-02f, 5.12428433e-02f,
  2.18283981e-01f, 4.47836250e-01f, 2.84997672e-01f, 3.05074215e-01f, 1.24064237e-01f, 1.72498003e-01f, 1.81161314e-01f, 2.50082035e-02f, 4.19132620e-01f, 1.34420618e-01f,
  -8.74804780e-02f, -3.53203304e-02f, -4.75508720e-02f, -4.13506553e-02f, -6.14707582e-02f, -5.64953089e-02f, -5.94799556e-02f, -3.01695913e-02f, -2.41578296e-02f, 1.32239228e-02f,
  -8.17790031e-02f, 3.43348049e-02f, 8.12952593e-02f, 3.21020670e-02f, -1.36159407e-02f, 3.97372432e-02f, 7.85597265e-02f, -1.30522370e-01f, -4.81174141e-02f, 2.44819894e-02f,
  -8.18688702e-03f, -1.79279689e-02f, 3.05355713e-02f, 6.74451664e-02f, 3.40059376e-03f, -7.72825722e-03f, -5.31918295e-02f, 4.53377068e-02f, 6.29775077e-02f, 1.07434459e-01f,
  -1.43571422e-02f, -5.64515591e-02f, -1.90958157e-02f, -3.07967812e-02f, 2.00698692e-02f, 4.33735475e-02f, -7.17441598e-03f, 5.91673031e-02f, -1.14471437e-02f, -7.66644329e-02f,
  2.80229747e-02f, -2.44631153e-02f, 8.49139318e-02f, 1.71492659e-02f, 5.89390136e-02f, -5.53347431e-02f, 1.52094411e-02f, 5.87158576e-02f, -1.96684208e-02f, 2.96870731e-02f,
  -6.12439886e-02f, 1.15334988e-02f, 4.77856658e-02f, 2.82330494e-02f, -1.13092670e-02f, -2.35244501e-02f, 2.28496529e-02f, -1.46032800e-03f, -2.10867799e-03f, 2.08694022e-02f,
  -5.80113903e-02f, 9.32935625e-02f, -6.87126443e-02f, -5.32640256e-02f, 4.03662072e-03f, -6.13620840e-02f, 2.02421788e-02f, 1.13781411e-02f, 6.71804920e-02f, -2.63184588e-02f,
  -1.01613745e-01f, 1.26061561e-02f, -1.25484532e-02f, 2.51957458e-02f, 4.46171574e-02f, -4.73487526e-02f, -2.89577786e-02f, 6.44779578e-02f, 2.55076252e-02f, 3.32067199e-02f,
  5.07009588e-02f, -1.33340005e-02f, 2.83176154e-02f, 7.17104301e-02f, 7.30065405e-02f, -5.42192310e-02f, 7.06288144e-02f, -3.31586488e-02f, 3.86951379e-02f, 5.96299302e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  3.63709927e-01f, 2.69948095e-01f, 6.51070401e-02f, 3.56937468e-01f, 2.77704626e-01f, 4.98614252e-01f, 4.73162621e-01f, 1.47319645e-01f, 3.00884098e-01f, 1.47436514e-01f,
  2.51444876e-01f, 8.27810913e-02f, 3.41376185e-01f, 4.55885321e-01f, 3.69561553e-01f, 1.37109324e-01f, 2.79277921e-01f, 1.67968303e-01f, 3.01747859e-01f, 1.79431606e-02f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  3.18182200e-01f, -1.57650355e-02f, -1.26884282e-01f, -3.26080084e-01f, -1.58062576e-05f, -5.37128448e-01f, -1.45505279e-01f, -4.96596426e-01f, 4.00663316e-01f, -6.72572792e-01f,
  1.31460324e-01f, -5.50189137e-01f, -2.41258606e-01f, -3.15823406e-01f, 5.76795675e-02f, -5.39161675e-02f, -1.43240973e-01f, -3.16995174e-01f, -1.90546036e-01f, 8.12199712e-01f,
  5.21673381e-01f, 2.34851956e-01f, -4.91408199e-01f, 2.78654218e-01f, -1.36463553e-01f, -1.54330820e-01f, 6.81212127e-01f, -2.48575553e-01f, -5.44674210e-02f, 9.91730019e-02f,
  -6.78045526e-02f, -1.44918263e-01f, -1.75268292e-01f, -3.38840216e-01f, 1.72725677e-01f, -2.95596659e-01f, 2.82244086e-01f, 2.39884764e-01f, -5.32845378e-01f, 7.48761356e-01f,
  4.51212525e-01f, -4.93700355e-01f, 4.27719474e-01f, -5.60360670e-01f, 4.21313830e-02f, 1.01868916e+00f, -2.19860557e-03f, 3.86867344e-01f, 1.77161321e-02f, -1.83587357e-01f,
  -4.08754945e-01f, -1.28147751e-02f, -1.87972292e-01f, 7.43078394e-03f, -2.47261986e-01f, 3.83888148e-02f, 4.72017890e-03f, -4.51766044e-01f, 2.34629452e-01f, -1.78366452e-01f,
  -3.21638912e-01f, -1.61666393e-01f, 6.60588801e-01f, -4.41041701e-02f, -3.85054052e-01f, 1.24120913e-01f, -1.71061084e-01f, 1.49192825e-01f, -1.28495753e-01f, -6.07376322e-02f,
  -4.70921904e-01f, -1.24571793e-01f, -3.42238694e-01f, -1.50372714e-01f, 1.33995395e-02f, 2.71173745e-01f, -1.80486023e-01f, 6.23708427e-01f, 8.23104579e-04f, 5.63611209e-01f,
  -1.54279903e-01f, -3.16206127e-01f, -2.16573432e-01f, -2.39694193e-01f, -1.28828913e-01f, -2.90942341e-01f, -3.40621680e-01f, 1.65732801e-01f, -4.76927489e-01f, -1.44160792e-01f,
  -2.46913448e-01f, 2.39940152e-01f, 5.86793661e-01f, 1.47263646e-01f, -1.17934451e-01f, 8.00283551e-01f, 9.46144909e-02f, 1.22525677e-01f, -4.14221257e-01f, -3.44552398e-01f,
  9.48204622e-02f, 3.07873804e-02f, -4.42201197e-02f, 2.73795128e-01f, 3.77571791e-01f, 5.26883900e-01f, 4.37099367e-01f, -2.22984508e-01f, -4.70184088e-01f, -4.07610625e-01f,
  -1.71421364e-01f, -2.14625269e-01f, -1.94923624e-01f, 2.11499244e-01f, 6.39228106e-01f, 5.25438428e-01f, 4.32794303e-01f, -3.65121305e-01f, 7.63924658e-01f, -2.27995142e-01f,
  1.37165431e-02f, -4.06732500e-01f, -3.32438350e-01f, -1.48477271e-01f, -2.67754886e-02f, -1.73385799e-01f, -3.87480170e-01f, 5.06002735e-03f, -2.24116936e-01f, -2.72591561e-01f,
  5.49209833e-01f, 4.84057724e-01f, 5.66627264e-01f, 2.09588215e-01f, 6.37424886e-01f, -7.30772555e-01f, 3.47416848e-01f, 6.03239834e-01f, 2.36957356e-01f, -6.53395057e-02f,
  -2.76391864e-01f, -1.07078597e-01f, -2.36318424e-01f, 9.57019031e-02f, 2.95804232e-01f, 9.20135975e-01f, -3.12043846e-01f, -3.44689637e-01f, 8.80553544e-01f, 1.70819029e-01f,
  -4.38378081e-02f, -7.66193913e-03f, 2.02433780e-01f, -8.96292180e-02f, 1.16650634e-01f, 7.19823167e-02f, 2.43856609e-01f, -3.43169808e-01f, -1.96945652e-01f, 1.85770020e-01f,
  2.84647197e-01f, 4.48698938e-01f, 2.15083495e-01f, 3.12135905e-01f, -1.88596010e-01f, 2.83005804e-01f, 7.70835727e-02f, -2.03119982e-02f, -5.10821901e-02f, -7.10330665e-01f,
  -8.48388016e-01f, 2.05271378e-01f, 8.85164291e-02f, -3.50664377e-01f, 1.17818475e-01f, -4.35124278e-01f, 6.46831930e-01f, 3.97262037e-01f, -4.64716524e-01f, -3.60872149e-02f,
  -3.49191725e-01f, -1.72808617e-01f, -2.60111362e-01f, -1.94641706e-02f, -7.02196509e-02f, -3.87930483e-01f, 2.28591099e-01f, 3.28405830e-03f, -2.25455090e-02f, -4.09875214e-01f,
  1.04467177e+00f, -1.21594511e-01f, 2.86966026e-01f, 1.43630683e-01f, -2.65863955e-01f, 1.18138231e-01f, -8.62785950e-02f, -1.16543934e-01f, 5.56174994e-01f, 1.07988216e-01f,
  -2.40839705e-01f, 3.69480968e-01f, 1.06387675e-01f, 5.13646066e-01f, -1.33703113e-01f, -9.73253138e-03f, 3.04676712e-01f, 5.33699214e-01f, -2.78070569e-02f, -2.90162057e-01f,
  -3.57388288e-01f, -4.13281061e-02f, -2.17582151e-01f, -2.49923468e-01f, -1.90290004e-01f, -3.17890108e-01f, -2.96972811e-01f, 8.17948282e-01f, -4.36147511e-01f, -4.46984589e-01f,
  -2.33056366e-01f, 8.22463691e-01f, 5.21835685e-01f, -2.35694736e-01f, -2.18151018e-01f, -2.67888069e-01f, -2.99283792e-03f, -5.13784647e-01f, -1.30646080e-01f, 7.11167231e-02f,
  1.84487209e-01f, -1.66655511e-01f, 1.38659358e-01f, 3.61397654e-01f, -3.20800304e-01f, 1.67780280e-01f, 5.16345575e-02f, -2.31333405e-01f, -1.42688468e-01f, -2.30152011e-01f,
  4.06462044e-01f, -3.79274756e-01f, -3.48762900e-01f, 1.38693064e-01f, -1.11002684e-01f, 3.56724381e-01f, 1.00055289e+00f, 5.85933626e-01f, -2.63264984e-01f, -3.19373965e-01f,
  6.67849788e-03f, -1.79680511e-01f, -7.85537437e-02f, -1.61694109e-01f, -2.56220847e-01f, -4.66395989e-02f, -1.62180796e-01f, -8.82221833e-02f, 8.57141837e-02f, -5.98847866e-01f,
  -6.84040636e-02f, -4.34233636e-01f, -1.45421356e-01f, 2.97317266e-01f, -1.51628137e-01f, -3.53006244e-01f, 2.70713091e-01f, 4.12962347e-01f, -9.13729966e-02f, -1.37049913e-01f,
  4.04325053e-02f, 3.11965078e-01f, -2.66873330e-01f, -2.60698527e-01f, 3.21980298e-01f, -2.76769251e-01f, -1.86088279e-01f, 8.14704239e-01f, -2.25219745e-02f, -1.53048009e-01f,
  4.45408285e-01f, -3.14267963e-01f, -2.69420475e-01f, 4.31474984e-01f, -2.67361104e-01f, -6.82052523e-02f, -4.93927300e-02f, 6.04427636e-01f, -3.92274350e-01f, -4.92430955e-01f,
  -5.25669642e-02f, 1.84419736e-01f, -8.79684165e-02f, 2.50692993e-01f, 3.57643068e-01f, -6.16582155e-01f, -4.77565050e-01f, 4.52760488e-01f, -4.39737916e-01f, -1.40375435e-01f,
  9.91329312e-01f, -1.15401722e-01f, -1.52860299e-01f, 1.68437973e-01f, -1.64280683e-01f, -1.38813168e-01f, -2.44167671e-01f, -2.75805205e-01f, -2.45716080e-01f, 1.46798864e-01f,
  -2.08654672e-01f, -1.41346499e-01f, -2.75867462e-01f, 3.91614437e-01f, 4.31345552e-01f, 5.88879526e-01f, 2.18539506e-01f, 1.96736544e-01f, -3.29325944e-01f, -3.01059604e-01f,
  -3.25266510e-01f, -1.26680076e-01f, 2.91273028e-01f, 4.32450294e-01f, -5.82647681e-01f, -6.10160045e-02f, -4.94427592e-01f, 5.97135603e-01f, 4.70880002e-01f, 9.95632559e-02f,
  5.83951175e-01f, 5.16461628e-03f, 3.64060342e-01f, -8.12604651e-02f, -4.99710143e-02f, 1.24188624e-02f, -1.64056391e-01f, -2.42529690e-01f, 1.03869104e+00f, -2.71106601e-01f,
  -4.81225401e-02f, -3.90462935e-01f, -3.51175308e-01f, 4.96674478e-02f, 3.15056026e-01f, -3.07035357e-01f, -1.57878667e-01f, -3.20989430e-01f, 6.06404543e-01f, 1.15333535e-01f,
  -1.83350101e-01f, -3.24876159e-01f, 4.08442587e-01f, 3.37422699e-01f, 3.12958002e-01f, 2.76851237e-01f, -8.47175494e-02f, -7.40713030e-02f, -2.66794711e-01f, -1.57627583e-01f,
  -4.03450847e-01f, 1.83173761e-01f, -5.96139073e-01f, 3.79936576e-01f, -3.32285911e-01f, -3.73233825e-01f, -1.65305510e-01f, -4.61947888e-01f, -3.95175815e-01f, 5.38693011e-01f,
  5.95647037e-01f, -2.25081414e-01f, -3.54926497e-01f, -1.06980331e-01f, 1.05758734e-01f, -1.57180503e-01f, 5.46219349e-01f, 6.92362487e-01f, -4.47039366e-01f, 7.21469671e-02f,
  -4.06226575e-01f, -2.77536124e-01f, -2.65338838e-01f, -2.33104035e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.13910228e-01f, -2.81600971e-02f, -2.85908550e-01f, -2.09413707e-01f, -1.24617657e-02f, 1.63060427e-01f, 5.44522516e-02f, -1.69649825e-01f, -2.56681532e-01f, 1.51716307e-01f,
  -2.30546538e-02f, -6.67117629e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    