/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.36450726e-01f, 5.65114729e-02f, -3.26977409e-02f, 2.37065464e-01f, -1.38041556e-01f, -2.35331193e-01f, -6.56539574e-03f, -1.20860860e-01f, 1.98142529e-01f, 2.87535647e-03f,
  -8.66964236e-02f, 2.27047965e-01f, -6.99218586e-02f, 2.68076314e-04f, -5.57663441e-02f, -4.25080396e-02f, 4.26634401e-02f, 1.57953978e-01f, 1.76984705e-02f, 9.18005630e-02f,
  7.79178515e-02f, -1.27541870e-01f, -1.88416883e-01f, -1.85168445e-01f, -1.25311688e-01f, 6.85230494e-02f, -1.17797673e-01f, -1.53106675e-01f, -2.35955883e-02f, -3.25613208e-02f,
  -3.40931751e-02f, 4.26378921e-02f, -3.76202315e-02f, -7.00733662e-02f, -3.54193971e-02f, -2.35970169e-02f, 2.18069367e-02f, -1.23513900e-02f, -1.17041599e-02f, 1.29988911e-02f,
  1.09698653e-01f, 4.36827950e-02f, 4.84127104e-02f, 3.08697168e-02f, 8.99462402e-02f, 2.67602596e-02f, 1.42468773e-02f, -7.92904347e-02f, -2.61976030e-02f, 5.33394422e-03f,
  -7.29831904e-02f, -1.91283580e-02f, 5.66397719e-02f, 4.54877503e-02f, 8.44290778e-02f, 5.55265136e-02f, 2.21504122e-02f, -3.10850833e-02f, -8.06825981e-03f, 3.15365382e-02f,
  7.76426569e-02f, 7.25838169e-03f, -5.47566265e-02f, -3.02153546e-02f, -6.21999148e-03f, -7.99603835e-02f, 2.70883422e-02f, -7.59837851e-02f, 5.32230139e-02f, -6.30778223e-02f,
  -2.45136134e-02f, 6.80834875e-02f, 1.17219426e-02f, -1.80577468e-02f, 8.99763927e-02f, 5.22544123e-02f, 2.49743573e-02f, 4.84877378e-02f, 2.35960092e-02f, -2.34360304e-02f,
  -1.78370979e-02f, -1.90774594e-02f, -1.83559284e-02f, -2.63640992e-02f, 1.98244801e-04f, 2.97155846e-02f, -1.91036593e-02f, -3.88799608e-02f, -4.37629409e-03f, -4.12352756e-02f,
  -2.95635108e-02f, 7.35738426e-02f, 9.97247058e-04f, 4.30217907e-02f, 3.41415666e-02f, -3.12547721e-02f, -1.40941925e-02f, 9.08162165e-03f, 4.53226604e-02f, 5.12082018e-02f,
  -4.98953015e-02f, 1.72088780e-02f, -1.38370087e-02f, -9.35879629e-03f, -5.53574366e-03f, -5.53725772e-02f, 1.19131263e-02f, 7.52704367e-02f, -2.06116196e-02f, -4.56754528e-02f,
  6.27411976e-02f, 1.00170597e-02f, -3.28233168e-02f, 6.63651293e-03f, 5.84157854e-02f, -9.46061499e-03f, -3.46841514e-02f, -4.73753139e-02f, -1.15632657e-02f, 2.27806643e-02f,
  9.58994776e-02f, 1.03830479e-01f, 5.27888015e-02f, 2.82182395e-01f, -1.39955983e-01f, 1.42333329e-01f, 2.37784326e-01f, -5.28437421e-02f, 2.61661649e-01f, 9.79699194e-02f,
  1.20529205e-01f, 1.78098753e-02f, 1.94681864e-02f, 2.90657133e-01f, 1.54104263e-01f, 1.81344286e-01f, 3.18162292e-01f, 1.19934648e-01f, 5.47315143e-02f, 1.45938769e-01f,
  7.73940906e-02f, 1.50357857e-01f, 7.27234706e-02f, -9.48941410e-02f, 6.19368516e-02f, 6.63908869e-02f, 6.86273724e-02f, -2.11361334e-01f, 1.06224298e-01f, -1.99133202e-01f,
  -3.27939838e-02f, -9.93023813e-02f, -4.01934385e-02f, -6.93267733e-02f, 1.14740245e-02f, -5.72659895e-02f, 4.52258065e-02f, -8.11551362e-02f, -3.23106833e-02f, -1.78011658e-03f,
  7.90641003e-04f, -3.46171074e-02f, 4.97913994e-02f, -1.70282461e-02f, -4.12167236e-03f, -1.00294845e-02f, -7.00595155e-02f, 3.06767467e-02f, -5.88166900e-02f, 2.79595151e-05f,
  -5.06256856e-02f, 8.29009712e-03f, -1.66386198e-02f, -1.39549179e-02f, 6.57858029e-02f, 9.06812772e-02f, -2.98613328e-02f, 3.50791998e-02f, 5.08391969e-02f, -3.40634994e-02f,
  3.05117592e-02f, 5.30128404e-02f, -3.71875763e-02f, -2.77888048e-02f, 1.29111868e-03f, -3.35817002e-02f, -1.63257513e-02f, -3.99404988e-02f, 2.04517879e-02f, 5.52384146e-02f,
  1.55978464e-02f, 6.86584488e-02f, -2.09881794e-02f, 5.51961288e-02f, 1.07417993e-01f, -2.10478418e-02f, -2.92644091e-02f, 1.81989502e-02f, 1.49891794e-01f, -4.22785338e-03f,
  -8.55274033e-03f, 2.72012614e-02f, 4.17809747e-02f, -2.50953455e-02f, -7.61117563e-02f, 2.46600043e-02f, 4.21925224e-02f, -5.83390445e-02f, 5.79299405e-02f, -9.07232538e-02f,
  1.30721077e-01f, 1.91684499e-01f, 2.63842270e-02f, -6.28075562e-04f, 1.88315753e-02f, 6.00425992e-03f, -3.44470181e-02f, -8.41409899e-03f, -8.68804902e-02f, -6.36657923e-02f,
  6.56496063e-02f, 3.16659957e-02f, 8.02411363e-02f, 1.29791265e-02f, -7.85440207e-02f, -4.22629565e-02f, 2.75056809e-02f, 4.99636941e-02f, 9.08513069e-02f, -4.63526845e-02f,
  -2.96642575e-02f, -1.63369195e-03f, -7.56788952e-03f, 2.79614925e-02f, 2.83701997e-02f, -4.18696133e-03f, 3.22596990e-02f, -2.14961693e-02f, 4.11675312e-02f, 4.92146835e-02f,
  -2.12384108e-02f, 4.80889492e-02f, -7.57310912e-02f, 7.36618936e-02f, -8.45774636e-02f, 3.10741782e-01f, 3.02866131e-01f, -2.06625480e-02f, -1.18134227e-02f, 1.28157645e-01f,
  1.30295798e-01f, -9.07877758e-02f, 6.23858497e-02f, 1.96728438e-01f, 2.03011826e-01f, 1.83101147e-01f, 2.19772503e-01f, 1.18612930e-01f, -1.06183015e-01f, 5.36377057e-02f,
  -4.99794222e-02f, 1.51848704e-01f, 7.36522302e-03f, -1.35726959e-01f, 1.05825462e-03f, -2.09784433e-01f, -1.26034647e-01f, -1.01416945e-01f, -7.52492994e-02f, 3.75095457e-02f,
  1.72308102e-01f, 4.47319411e-02f, 7.62907835e-03f, -1.10654673e-02f, -4.94140871e-02f, -4.98123188e-03f, 2.69543403e-03f, 1.81604158e-02f, 1.06168808e-02f, -6.41823709e-02f,
  4.60830070e-02f, 4.18209992e-02f, -1.85447372e-02f, -1.34037426e-02f, -1.69367325e-02f, -2.00246759e-02f, 2.42047850e-02f, 1.76883657e-02f, -3.58937718e-02f, -2.74810754e-02f,
  -8.24773684e-02f, 3.69001180e-02f, -3.66443326e-03f, 3.02186571e-02f, -1.00850247e-01f, 9.42254718e-03f, -2.63417023e-03f, -6.46698698e-02f, -5.05113825e-02f, -1.10709406e-02f,
  1.08445868e-01f, -6.61523417e-02f, -7.29587302e-02f, -6.69797659e-02f, -8.17755889e-03f, -1.14247069e-01f, -4.05809609e-03f, 4.85173985e-03f, -9.59962532e-02f, 5.22087328e-02f,
  2.33545154e-02f, 5.57200164e-02f, 8.20543244e-02f, -7.58523121e-04f, -2.69370489e-02f, 4.40598018e-02f, -1.87490173e-02f, -8.12954605e-02f, -2.42331438e-02f, -3.71248275e-02f,
  6.89207762e-02f, 8.83676391e-03f, -2.93657780e-02f, 6.63244724e-02f, 6.46211430e-02f, -6.69876561e-02f, 9.39308256e-02f, -8.59603360e-02f, -7.49612525e-02f, -8.72470140e-02f,
  1.09318852e-01f, 3.64604890e-02f, -4.95216437e-02f, 5.55979870e-02f, -1.64705198e-02f, -2.28018090e-02f, 7.46093541e-02f, 5.43372855e-02f, -4.17944379e-02f, 5.67600615e-02f,
  6.50746562e-03f, -8.26263353e-02f, -7.25842966e-03f, -5.26941521e-03f, -1.74404103e-02f, 2.27930602e-02f, -1.09998062e-02f, -2.68643741e-02f, 3.37752178e-02f, 5.07360958e-02f,
  5.63698448e-02f, -1.65533349e-02f, 4.16789278e-02f, -6.89909160e-02f, 7.22869299e-03f, -1.91227570e-02f, -2.47872174e-02f, -7.53899366e-02f, 3.15942466e-02f, 4.54379320e-02f,
  3.64426315e-01f, -3.00015390e-01f, -7.95210525e-02f, 2.15454251e-02f, 3.58440839e-02f, 5.56791993e-03f, -1.05934031e-02f, -4.25648838e-02f, 4.84611141e-03f, -1.31713316e-01f,
  1.05722025e-01f, 1.20392464e-01f, 9.63343121e-03f, -2.10671544e-01f, 3.12018871e-01f, -4.99854088e-02f, -7.42287468e-03f, 5.92528246e-02f, 8.61622170e-02f, 4.49166559e-02f,
  1.37163669e-01f, -4.49306220e-02f, -1.12184159e-01f, -1.87621951e-01f, -1.55304328e-01f, -4.84374277e-02f, 1.12114668e-01f, 3.74799185e-02f, -1.14538625e-01f, -1.77728590e-02f,
  3.77720110e-02f, -6.58841953e-02f, -8.77529830e-02f, 4.76853177e-02f, 6.35663643e-02f, 1.59898326e-02f, 1.03381194e-01f, 6.95484132e-02f, 4.58058603e-02f, 3.35350931e-02f,
  6.74705058e-02f, 1.96465999e-02f, -1.02373451e-01f, 7.66080432e-03f, -2.10990794e-02f, 4.37057763e-02f, 2.44331528e-02f, -5.30312173e-02f, -2.06222385e-02f, -6.36039441e-03f,
  -4.39084359e-02f, -3.29513401e-02f, 3.51036265e-02f, 1.06055573e-01f, -3.25861722e-02f, 3.88283432e-02f, -2.33920831e-02f, -1.14298640e-02f, -1.10080633e-02f, -3.04246303e-02f,
  -3.09000872e-02f, 9.64433476e-02f, -2.74902489e-03f, -7.84341421e-04f, -1.83373559e-02f, -2.25058906e-02f, -1.25693213e-02f, 2.69454122e-02f, 5.38769029e-02f, -1.12906480e-02f,
  1.01084165e-01f, -1.03533633e-01f, -6.56640753e-02f, 2.47830190e-02f, 4.85815443e-02f, -1.49510829e-02f, 1.17415704e-01f, 2.73123905e-02f, -1.75337365e-03f, -6.76676072e-03f,
  -3.06757446e-02f, 6.45756945e-02f, 1.30611649e-02f, 1.01252785e-02f, 2.35423874e-02f, 7.30303675e-02f, 4.01050188e-02f, 1.12828817e-02f, 8.23029317e-03f, 7.43567646e-02f,
  -8.37715641e-02f, -3.03147435e-02f, -6.29308373e-02f, -8.58518034e-02f, -3.72537374e-02f, -3.78215499e-02f, 4.22953032e-02f, -8.41132030e-02f, 6.55487627e-02f, 5.33723608e-02f,
  4.70813587e-02f, 1.71516538e-02f, 6.78664967e-02f, -7.04585612e-02f, 4.85969968e-02f, -1.55054592e-02f, 6.32451028e-02f, 3.08380015e-02f, -1.04949614e-02f, -1.37544628e-02f,
  4.72979508e-02f, 9.70896631e-02f, 2.06679814e-02f, -3.37414965e-02f, 1.15617044e-01f, 6.69425875e-02f, 3.72242332e-02f, -5.85260130e-02f, -3.42671685e-02f, -9.57677141e-03f,
  5.31774461e-02f, -2.95935888e-02f, 2.78091520e-01f, 6.22094385e-02f, 2.59561986e-02f, 4.70885336e-02f, 1.20564140e-01f, 9.37364399e-02f, 2.68939376e-01f, -1.36999696e-01f,
  -2.82501671e-02f, -9.58702564e-02f, 1.31493390e-01f, -1.64754435e-01f, 1.72784165e-01f, 1.52436316e-01f, -1.22137681e-01f, -1.20358691e-01f, 1.20766193e-01f, -1.66563123e-01f,
  5.87720685e-02f, -2.66607404e-01f, -6.97648153e-02f, -1.79919958e-01f, -1.64875746e-01f, -3.52629386e-02f, -2.37882420e-01f, 1.03891827e-01f, -2.40204737e-01f, 8.68601352e-03f,
  -5.76345325e-02f, 2.93794530e-03f, -4.07573506e-02f, 7.63406232e-02f, -2.64439583e-02f, 1.09621033e-01f, 1.76859330e-02f, 5.94790699e-03f, 5.19500189e-02f, -1.81815531e-02f,
  -3.38049117e-03f, -3.88646685e-02f, -1.00048520e-01f, 1.13668712e-02f, 1.50639370e-01f, 2.21034288e-02f, 9.54112597e-03f, 1.67569797e-02f, -5.88731794e-03f, 7.10212961e-02f,
  2.59601343e-02f, 6.75359890e-02f, -4.18965379e-03f, -1.12931412e-02f, 3.51010412e-02f, 5.65865543e-03f, 7.08538592e-02f, -6.73797280e-02f, -1.40824663e-02f, 5.82844280e-02f,
  3.37720774e-02f, 9.31659862e-02f, -4.55659106e-02f, 5.11241704e-03f, -8.13205838e-02f, -9.42385644e-02f, 1.76499747e-02f, -1.73999481e-02f, -2.01786086e-02f, 1.33637432e-03f,
  -1.02987982e-01f, -7.30798999e-03f, 3.04515120e-02f, 3.86246294e-02f, -2.20915396e-02f, 3.27766538e-02f, -6.27132058e-02f, 3.87238301e-02f, 5.48306443e-02f, -6.30099475e-02f,
  2.88133491e-02f, 2.01848373e-02f, -2.56512184e-02f, 1.47610633e-02f, 1.75956879e-02f, -2.57516261e-02f, 4.89989519e-02f, -5.77800302e-03f, 3.86455730e-02f, -5.08364514e-02f,
  -1.59179375e-01f, 1.14799589e-02f, -1.78456642e-02f, -1.32508064e-02f, 1.67324338e-02f, -1.00545086e-01f, -5.86754351e-04f, -1.45877246e-02f, 4.33900505e-02f, 1.04752779e-02f,
  -2.46668458e-02f, -2.89750602e-02f, 4.36331779e-02f, 3.37299518e-02f, -5.11545548e-03f, 6.10371232e-02f, -1.51359057e-02f, -3.23609374e-02f, -1.34569556e-02f, 6.36196462e-03f,
  -4.55049612e-02f, -5.94378747e-02f, -2.92434562e-02f, -2.76896488e-02f, -2.29654778e-02f, -3.39424908e-02f, 1.49821453e-02f, 8.23277459e-02f, 1.08775804e-02f, 1.40559478e-02f,
  -1.63312733e-01f, 2.26020634e-01f, -1.35066241e-01f, -8.84108394e-02f, -1.24181241e-01f, -1.67483553e-01f, -2.44109929e-01f, 7.72590116e-02f, 1.65884160e-02f, 2.49746934e-01f,
  1.23331152e-01f, -7.97548424e-03f, 5.42091727e-02f, 7.97735527e-02f, -3.51946622e-01f, -1.10804550e-01f, -8.34246650e-02f, 4.09126701e-03f, 1.89312417e-02f, -1.79798226e-03f,
  -1.15609907e-01f, 7.99444020e-02f, -2.26293162e-01f, 6.12020046e-02f, -5.83562367e-02f, 8.52991939e-02f, 1.76481586e-02f, -1.66577056e-01f, 9.93187353e-02f, -7.13532642e-02f,
  1.36876656e-02f, 1.03605920e-02f, 3.17971334e-02f, 5.01322336e-02f, -5.31335995e-02f, 2.17288490e-02f, 1.46361161e-02f, -3.32301557e-02f, -3.30910943e-02f, 4.90245558e-02f,
  -3.04902196e-02f, -2.02416833e-02f, -4.41346020e-02f, -4.77454774e-02f, 8.99792388e-02f, 4.89348695e-02f, -2.26356043e-03f, -7.99455028e-03f, -2.12045312e-02f, -6.67776316e-02f,
  -6.23477735e-02f, 7.89487958e-02f, -3.04074585e-02f, -1.06655881e-02f, -9.61627662e-02f, -3.59617727e-04f, -3.58283073e-02f, 7.79843703e-03f, 7.27447271e-02f, -8.45124573e-02f,
  -6.11441582e-02f, -7.98923522e-02f, -8.09352398e-02f, 1.10139564e-01f, -1.77431963e-02f, 5.16638272e-02f, 3.62714566e-02f, 1.08756041e-02f, -3.29062901e-02f, 3.01779620e-02f,
  6.55968413e-02f, 5.07429242e-02f, -2.88160015e-02f, 5.73673509e-02f, 9.52156037e-02f, -3.83397341e-02f, 2.72544380e-03f, 1.88987441e-02f, -3.45447846e-02f, 1.05761476e-02f,
  -5.23467846e-02f, 5.90751208e-02f, -2.07767226e-02f, 2.98172538e-03f, 1.08971982e-03f, -2.89308690e-02f, 5.14988191e-02f, 8.62625614e-02f, 3.58492061e-02f, -4.56782915e-02f,
  2.23939002e-01f, 1.28300905e-01f, 5.39642274e-02f, 1.43364295e-01f, 8.64888802e-02f, 6.93334788e-02f, -8.05526599e-03f, 8.43330994e-02f, 7.36247450e-02f, -9.00706127e-02f,
  7.54125193e-02f, 6.99619204e-02f, -2.56244447e-02f, -4.74834487e-05f, -4.25224788e-02f, -2.26460062e-02f, 5.88576682e-03f, 7.54114389e-02f, -5.00570014e-02f, 1.27867386e-01f,
  6.77878186e-02f, 7.38070020e-03f, -2.86732223e-02f, -2.43029092e-02f, 9.07075927e-02f, -1.94674749e-02f, 1.23512056e-02f, -2.41440907e-02f, -4.45725694e-02f, 9.86638740e-02f,
  -1.48170842e-02f, -1.74427301e-01f, -7.73347393e-02f, 2.73778677e-01f, 6.36862144e-02f, -4.24818620e-02f, 2.20430359e-01f, -3.72888669e-02f, 8.27259794e-02f, 6.22847080e-02f,
  5.25211431e-02f, -2.09063590e-01f, 8.56050998e-02f, -8.23997632e-02f, 6.80042729e-02f, 9.48688909e-02f, 3.78249437e-02f, -6.49170717e-03f, 9.53924144e-04f, 1.57670811e-01f,
  1.26309097e-01f, 1.59941226e-01f, 1.91270709e-02f, -1.58841312e-02f, -9.49413180e-02f, -7.08252341e-02f, 1.05386578e-01f, 4.04353477e-02f, -2.01757148e-01f, -8.27607736e-02f,
  -6.13944791e-02f, 1.62999094e-01f, -9.81922448e-02f, 2.88612247e-02f, 7.41208345e-02f, -2.83095110e-02f, -6.90254420e-02f, -8.35714266e-02f, 1.78270470e-02f, -5.31897806e-02f,
  4.49507758e-02f, -1.70274079e-02f, 5.40319309e-02f, 1.26308464e-02f, 7.74884522e-02f, -1.20172352e-01f, 7.33025074e-02f, -5.86244315e-02f, -5.06158061e-02f, -1.18363693e-01f,
  -1.20975494e-01f, -7.64133707e-02f, 6.87480047e-02f, 7.89013430e-02f, 3.83334421e-02f, 4.21904474e-02f, 3.27085108e-02f, -1.51032433e-02f, -3.04135215e-02f, -1.18857902e-02f,
  2.65428256e-02f, 9.72810760e-02f, -3.89863849e-02f, -5.56263663e-02f, 4.38909158e-02f, -6.45620376e-02f, 3.25101055e-02f, -2.32599676e-02f, -4.78465259e-02f, -4.12430167e-02f,
  6.21201470e-03f, -7.69468024e-02f, 6.04014359e-02f, 2.50598490e-02f, 1.10733621e-01f, -3.31478752e-02f, -6.82576746e-02f, -1.31605193e-01f, -4.26892797e-03f, 5.57945892e-02f,
  -2.51401644e-02f, 2.41735037e-02f, -5.08594234e-03f, 4.98941913e-02f, -3.29721160e-02f, 1.85654815e-02f, -5.47350533e-02f, -1.00226879e-01f, 5.49637526e-02f, 7.00648800e-02f,
  6.08024374e-02f, 2.45789811e-01f, -4.16281540e-03f, -6.59423023e-02f, 2.22399700e-02f, 3.60387526e-02f, 6.95117563e-02f, -9.61054862e-03f, 1.53681785e-01f, 1.09929100e-01f,
  7.10076932e-03f, 7.70418718e-02f, -3.57935764e-02f, -8.24239701e-02f, 5.24491705e-02f, -1.44901266e-02f, 7.31126368e-02f, 4.37894575e-02f, 3.80253494e-02f, 3.55776064e-02f,
  6.53864397e-03f, 4.39092703e-02f, -3.25998887e-02f, 1.60061866e-02f, 4.77738082e-02f, 4.29813303e-02f, 4.49203886e-03f, -6.14752881e-02f, 6.42127767e-02f, 5.40298820e-02f,
  1.63236737e-01f, -1.01382658e-03f, -2.35824883e-01f, 1.87679708e-01f, 5.22399209e-02f, -1.22587197e-01f, -1.78690240e-01f, 1.04575492e-01f, 1.43207878e-01f, 5.54579273e-02f,
  1.72837883e-01f, -2.43483782e-01f, -5.78755513e-03f, 1.04659207e-01f, 1.56306922e-01f, -2.97248550e-03f, 6.53807819e-02f, -1.16591476e-01f, -1.46654904e-01f, 8.13033879e-02f,
  1.40753910e-01f, 1.97819978e-01f, -4.35752422e-02f, 5.42036407e-02f, -4.26058881e-02f, 2.77678780e-02f, 9.68707502e-02f, -1.51460752e-01f, 2.19180491e-02f, -6.67103007e-02f,
  6.82874471e-02f, 7.67882243e-02f, -3.29358801e-02f, -5.25203608e-02f, 5.13167791e-02f, -5.11256941e-02f, 4.03817222e-02f, -1.16216883e-01f, -3.46829034e-02f, -5.75964265e-02f,
  -8.12123418e-02f, -1.65877491e-02f, -4.24819253e-02f, -2.76978631e-02f, -3.32848839e-02f, 1.16734849e-02f, -3.61024551e-02f, 1.02806538e-02f, -4.17063497e-02f, -2.98145209e-02f,
  -6.04457818e-02f, -1.94151234e-02f, 8.77373442e-02f, 1.23315826e-02f, -3.41627710e-02f, 5.71183041e-02f, -7.48264883e-03f, -4.25139368e-02f, -4.61545847e-02f, -6.89066425e-02f,
  -9.16041434e-02f, 6.35259366e-03f, -3.22113521e-02f, 5.87961935e-02f, 2.99558938e-02f, 8.91031045e-03f, 3.07180118e-02f, 6.15671799e-02f, 4.09890339e-02f, 1.96381435e-02f,
  8.23428631e-02f, -4.12976220e-02f, -6.68742927e-03f, -8.17434713e-02f, -1.08481627e-02f, -3.76108210e-06f, -6.13976642e-02f, 7.78170452e-02f, 2.93532629e-02f, -1.18753291e-03f,
  -2.75650918e-02f, -5.35260420e-03f, -4.00252230e-02f, 3.17895669e-03f, -6.73373565e-02f, 3.61094549e-02f, 6.49595633e-02f, -2.12833155e-02f, -8.66086483e-02f, -8.94108322e-03f,
  2.07813174e-01f, 1.24306969e-01f, -1.75845642e-02f, -5.35541624e-02f, -5.50352782e-02f, 6.08498491e-02f, -8.45652223e-02f, -3.70388068e-02f, -5.52562065e-02f, -9.05958861e-02f,
  -9.08102375e-03f, 6.60237074e-02f, 6.28794059e-02f, -2.48184446e-02f, -5.82396723e-02f, 6.48181513e-02f, 1.03537373e-01f, -4.75079194e-02f, 1.23590477e-01f, -5.15542515e-02f,
  7.64238313e-02f, 1.59693453e-02f, -1.62963364e-02f, -1.64937563e-02f, 2.25727260e-03f, -7.08326474e-02f, 1.06966250e-01f, -3.62470709e-02f, -1.87031832e-02f, 4.31279391e-02f,
  3.32410932e-01f, -6.39562905e-02f, 8.85293726e-03f, 4.65587266e-02f, 1.53962061e-01f, -1.91944465e-02f, -4.65180241e-02f, 8.82996321e-02f, 3.08785468e-01f, -4.20026369e-02f,
  -2.64305864e-02f, 1.27126020e-03f, -1.25502497e-01f, -1.62435025e-01f, -3.57795447e-01f, -1.89586371e-01f, -6.57245219e-02f, -1.35656938e-01f, 1.76626779e-02f, 5.45717776e-02f,
  -1.02950446e-01f, -2.14222685e-01f, -3.23879510e-01f, -1.03269167e-01f, 5.70245683e-02f, -3.74738616e-03f, -1.35722682e-01f, -1.29267387e-02f, -1.95503622e-01f, -1.58861443e-01f,
  -2.34916643e-03f, 1.50392562e-01f, 3.77701931e-02f, 5.28016128e-02f, -5.44987358e-02f, 6.57134056e-02f, 9.43108425e-02f, -6.52079061e-02f, 5.70031628e-02f, -2.98691005e-03f,
  -1.90839544e-02f, -7.09431395e-02f, 3.10259704e-02f, -1.37749389e-02f, 5.98307811e-02f, -3.21310870e-02f, 5.53695410e-02f, 8.18678960e-02f, 3.39261554e-02f, -6.20970726e-02f,
  -5.25019020e-02f, -3.80883068e-02f, 4.82198000e-02f, -2.91704293e-02f, 4.88720043e-03f, 1.40900701e-01f, 2.60054488e-02f, -3.92353386e-02f, -2.92636734e-03f, 7.80602321e-02f,
  -1.04249679e-02f, 9.79480240e-03f, -2.64433920e-02f, -9.67370123e-02f, 2.15682648e-02f, 2.07963567e-02f, -1.80789623e-02f, -3.77823077e-02f, 8.34336206e-02f, 2.47312915e-02f,
  1.06226496e-01f, 5.81094995e-02f, 1.24692693e-02f, 1.33206084e-01f, -2.62992997e-02f, -2.51215212e-02f, -2.15986911e-02f, -2.22808085e-02f, 2.74321120e-02f, 6.20997399e-02f,
  6.16782345e-03f, 3.57789956e-02f, -5.18240407e-02f, 3.27731832e-04f, -4.46185097e-02f, -4.14216630e-02f, 5.23841605e-02f, -9.36405640e-03f, 5.62698580e-02f, -1.10994883e-01f,
  -1.07330061e-01f, -2.13573992e-01f, 4.59834673e-02f, 6.67186314e-03f, -2.42470540e-02f, -2.15661917e-02f, -8.26199539e-03f, 6.91834912e-02f, -4.82405052e-02f, -2.68771127e-02f,
  1.83910076e-02f, 3.52258258e-03f, 1.75858587e-02f, 3.37299258e-02f, -3.66034620e-02f, -1.17763160e-02f, -4.83286045e-02f, -9.77300201e-03f, -1.93873085e-02f, -7.31461570e-02f,
  1.71363670e-02f, 5.02869859e-02f, -4.56369780e-02f, 5.63597158e-02f, 4.71301787e-02f, -6.03809729e-02f, 6.93409294e-02f, -1.21600628e-02f, -1.21276498e-01f, -1.09030865e-01f,
  -2.76157886e-01f, 2.70181239e-01f, -3.02044064e-01f, -6.23831637e-02f, -7.34724477e-02f, -4.98335883e-02f, -1.72499821e-01f, 1.39640167e-01f, -2.51834542e-01f, 1.45589158e-01f,
  8.33660830e-03f, -1.79341689e-01f, 5.52515946e-02f, -1.04297902e-02f, -1.76235169e-01f, -1.60475560e-02f, 1.54947462e-02f, 8.80455319e-03f, 6.01829626e-02f, 9.86470804e-02f,
  -7.18271583e-02f, 2.40765050e-01f, 6.64712042e-02f, 2.74189889e-01f, 6.73094541e-02f, 8.52467120e-02f, 2.29240865e-01f, 1.49267301e-01f, 8.08839276e-02f, 1.79651529e-02f,
  -9.72084999e-02f, -3.59110758e-02f, -5.86615577e-02f, -9.13501456e-02f, -5.02736717e-02f, 4.17429619e-02f, 7.38953352e-02f, 4.01926786e-02f, -1.03378976e-02f, -8.37019384e-02f,
  -7.46689960e-02f, -4.53490391e-02f, -4.81962673e-02f, -6.50006682e-02f, -4.09325212e-02f, -1.77915283e-02f, -6.23398311e-02f, -4.71242219e-02f, -6.48160502e-02f, 1.10895168e-02f,
  -2.15165988e-02f, -3.53764370e-02f, -4.79718717e-03f, -5.79187609e-02f, -7.17298165e-02f, -3.42957415e-02f, 1.52826011e-02f, -3.29448888e-03f, 5.45155779e-02f, -2.45161820e-02f,
  1.07525788e-01f, 9.55437422e-02f, 4.39111330e-02f, -3.52961905e-02f, -1.59892123e-02f, -8.59712213e-02f, 1.98056754e-02f, -4.28560115e-02f, -7.33620301e-02f, -5.10113277e-02f,
  -2.66407127e-03f, -3.53235230e-02f, -5.44881932e-02f, -6.12338036e-02f, 7.28083029e-02f, -5.72781600e-02f, -2.47378889e-02f, 2.05098763e-02f, -1.69590488e-02f, 3.87255810e-02f,
  4.35950570e-02f, 4.74543311e-02f, 1.11311655e-02f, -3.77928535e-03f, -1.81168839e-02f, -4.31214347e-02f, 6.50550872e-02f, -1.39735192e-01f, -7.64890909e-02f, 9.53524187e-02f,
  1.50297299e-01f, 1.91657722e-01f, 3.18131633e-02f, -4.07933854e-02f, -1.42488116e-02f, 1.40967499e-02f, -6.19971007e-02f, 2.42411494e-02f, -2.24265922e-03f, -2.75606755e-02f,
  6.32244200e-02f, -6.15051575e-02f, 3.09434235e-02f, -4.41990867e-02f, 4.04304899e-02f, -5.72853759e-02f, 8.73365998e-02f, 1.77541729e-02f, 4.92176935e-02f, 8.88298824e-02f,
  1.05892923e-02f, -4.26829308e-02f, 3.49528566e-02f, 4.07353602e-02f, 5.25143072e-02f, 7.51480162e-02f, -4.18580174e-02f, -1.13736019e-02f, 1.47441491e-01f, 7.40800798e-02f,
  3.84963453e-01f, 6.65461421e-02f, -1.10631734e-01f, -1.63992494e-02f, 1.11681893e-02f, 1.74531654e-01f, 3.15313548e-01f, -2.11439848e-01f, -3.94850671e-02f, -2.01492365e-02f,
  -4.39325757e-02f, 2.20345065e-01f, -1.28698517e-02f, -4.27986830e-02f, 6.02753833e-02f, -1.50882035e-01f, 1.00155964e-01f, 1.99228048e-01f, -1.56517163e-01f, 1.06172249e-01f,
  4.98123560e-03f, -4.88248318e-02f, -5.97660989e-02f, -1.03139415e-01f, 1.70292109e-01f, 2.67331302e-02f, -1.28623351e-01f, -5.31510338e-02f, 1.34308720e-02f, -9.72262060e-04f,
  -4.71301973e-02f, 1.26470393e-02f, 5.31184711e-02f, -9.80460644e-02f, 3.00856195e-02f, -2.57813726e-02f, 8.25882703e-02f, 8.88610817e-03f, -1.87232904e-02f, 1.74499229e-02f,
  4.26974334e-02f, -4.03812248e-03f, 3.09880208e-02f, -5.56138577e-04f, 2.99189966e-02f, -6.97993115e-02f, -6.70187026e-02f, 5.42752482e-02f, -1.13504849e-01f, 2.34153755e-02f,
  -2.15600189e-02f, 8.28744192e-03f, 1.08236931e-01f, -5.72709292e-02f, 2.33013965e-02f, -6.02060370e-03f, -2.14013550e-03f, 8.62100869e-02f, 4.58183624e-02f, 4.37569916e-02f,
  2.39195544e-02f, -3.87527458e-02f, -4.42000926e-02f, -5.56697547e-02f, -2.33747554e-03f, -3.49495560e-02f, -2.87005603e-02f, 5.56324720e-02f, 3.83353680e-02f, 1.79214440e-02f,
  -1.56126432e-02f, 1.01745054e-02f, -4.03851718e-02f, 1.48874382e-03f, -1.28045958e-02f, -1.87158566e-02f, 4.57851738e-02f, -1.61915105e-02f, 8.40902142e-03f, -4.18953262e-02f,
  -8.45519640e-03f, 3.61363329e-02f, -5.42905554e-02f, -1.86303258e-02f, -1.07821628e-01f, -1.84467901e-02f, -7.38360733e-03f, -7.59037677e-03f, 2.19348166e-02f, 6.78844824e-02f,
  4.29119617e-02f, -2.21741991e-03f, 1.31271239e-02f, -2.01211348e-02f, -9.68442336e-02f, 9.39933434e-02f, -1.76555738e-02f, 9.90772918e-02f, -4.36291620e-02f, -1.86943903e-03f,
  1.47518860e-02f, 4.47862707e-02f, 1.09606817e-01f, -6.23912811e-02f, -5.13033234e-02f, 1.47919925e-02f, 4.06788141e-02f, -5.32158427e-02f, 9.57762673e-02f, 2.58896835e-02f,
  -2.62477808e-03f, -3.25180478e-02f, -5.95144555e-03f, 2.83194706e-02f, -2.62748264e-02f, 5.85370436e-02f, 4.71246652e-02f, 1.15542123e-02f, -6.49087951e-02f, 4.11530137e-02f,
  -1.20190412e-01f, -6.35670274e-02f, 1.56610295e-01f, -1.55585825e-01f, -1.55380547e-01f, -1.28348604e-01f, -1.20894648e-02f, -1.78160101e-01f, 8.19561630e-02f, -4.79925983e-02f,
  -1.35352388e-01f, 1.81575999e-01f, 1.65199593e-01f, -1.26498058e-01f, 1.61618263e-01f, 1.43671632e-01f, -7.98451081e-02f, -1.13550657e-02f, -1.32469079e-02f, -8.25446174e-02f,
  -8.61072913e-02f, -9.29422230e-02f, -5.13162836e-02f, -1.57029435e-01f, -1.67658985e-01f, -2.03327555e-03f, 6.70731887e-02f, 1.52164474e-01f, -8.45666453e-02f, 1.71395019e-02f,
  -1.16671145e-01f, 5.97745292e-02f, 4.32664752e-02f, -2.09209844e-02f, -6.48085400e-02f, -4.83627990e-02f, -1.78663619e-02f, 9.36305895e-02f, 5.00833690e-02f, -8.00219849e-02f,
  -2.29912642e-02f, 5.15973791e-02f, -9.21893120e-02f, 6.60674796e-02f, -3.81900207e-03f, -2.44135391e-02f, -9.13766026e-03f, -6.55124187e-02f, 1.52846351e-02f, -2.67702602e-02f,
  -2.45518386e-02f, -4.82432172e-02f, -3.26445289e-02f, -9.48798954e-02f, 3.81961502e-02f, 8.21859241e-02f, 5.67115471e-02f, 5.07812686e-02f, -8.43880028e-02f, -6.10775538e-02f,
  -1.87404425e-04f, 1.60602126e-02f, -4.90035079e-02f, -1.14739135e-01f, 4.31357361e-02f, -9.83596146e-02f, 9.28720906e-02f, -5.34111671e-02f, 5.39422929e-02f, -5.17744124e-02f,
  -1.14830829e-01f, -4.87928838e-02f, -2.35140249e-02f, 5.58990892e-03f, -6.78027198e-02f, 6.87357504e-03f, -6.20669313e-02f, 1.52973803e-02f, -9.67956260e-02f, -1.63492013e-03f,
  7.43485168e-02f, 3.28128301e-02f, -1.07541829e-02f, -5.35060465e-02f, -3.60995196e-02f, 1.00185849e-01f, 3.17109749e-02f, -7.37778544e-02f, -5.16498508e-03f, 8.32298398e-02f,
  -6.22738115e-02f, -1.25541883e-02f, -7.59531036e-02f, -1.49638765e-02f, -4.11054445e-03f, -2.78893039e-02f, 7.29826838e-02f, -6.32838234e-02f, 9.15952318e-04f, -2.84928773e-02f,
  -9.79893059e-02f, 2.67681796e-02f, 6.28938302e-02f, 2.02426594e-02f, -3.47201154e-02f, 9.58652236e-03f, 4.81966473e-02f, 3.33564244e-02f, -2.42217258e-02f, -6.19338490e-02f,
  3.01857777e-02f, 1.54316251e-03f, 5.90597838e-02f, 6.49542734e-03f, -1.27632543e-01f, -2.15256829e-02f, -5.12165427e-02f, -4.46578152e-02f, 6.22712541e-03f, 1.18159212e-01f,
  1.19564526e-01f, -6.06740825e-02f, -1.89488560e-01f, 1.15036078e-01f, 5.73094375e-02f, 6.79202229e-02f, -1.48348927e-01f, 1.23370111e-01f, 9.57468078e-02f, -1.21870579e-03f,
  1.48441151e-01f, -2.60846794e-01f, -1.70523912e-01f, 2.13055864e-01f, 5.10019846e-02f, -1.12951271e-01f, 3.08088034e-01f, -1.16220340e-02f, 1.16148598e-01f, 3.93628664e-02f,
  6.51337579e-02f, 2.18633682e-01f, -7.61651024e-02f, 2.16369614e-01f, 2.98326593e-02f, 4.75234911e-02f, -6.19894229e-02f, -2.19854057e-01f, 1.58517554e-01f, -1.00873634e-01f,
  -1.69593152e-02f, -9.43912007e-03f, -2.68255938e-02f, -1.46938432e-02f, 8.46489668e-02f, -2.63954308e-02f, -1.60454474e-02f, -1.29084468e-01f, -7.20034316e-02f, 1.28062069e-02f,
  -1.62604153e-01f, -1.77114154e-03f, 2.66123237e-03f, -3.71179841e-02f, 6.58336328e-03f, 3.66042890e-02f, 1.03977360e-01f, 9.11620036e-02f, -5.09586111e-02f, -1.25784790e-02f,
  -7.06448629e-02f, -2.67147012e-02f, 1.12871245e-01f, -1.15405783e-01f, 4.41154949e-02f, 1.05280198e-01f, -5.09726033e-02f, -8.85457844e-02f, 8.52970593e-03f, 3.85860866e-03f,
  -6.01629950e-02f, -4.50081676e-02f, 7.83122145e-03f, 5.55261150e-02f, -5.75414971e-02f, 8.94021094e-02f, 4.91168462e-02f, 6.22921735e-02f, -6.08277917e-02f, 6.55202642e-02f,
  6.20991327e-02f, -1.08287204e-02f, 5.12160026e-02f, -1.43423351e-03f, -2.77310051e-02f, 5.22943735e-02f, -1.03034846e-01f, 2.42819991e-02f, 2.11830176e-02f, 1.34071887e-01f,
  -9.04374719e-02f, 4.91094962e-02f, -6.43914612e-03f, -7.24320337e-02f, 5.19931652e-02f, -5.50205866e-03f, -9.90233198e-03f, 2.42630970e-02f, 3.06750741e-02f, -9.11114365e-03f,
  -4.85214964e-02f, -9.42800194e-02f, -4.02173400e-02f, -3.55565436e-02f, -1.61636006e-02f, -2.98891924e-02f, -1.40444171e-02f, 8.45584348e-02f, -2.49805283e-02f, -2.47819163e-02f,
  9.10613313e-02f, 5.89129608e-03f, 8.88046101e-02f, 7.60976076e-02f, -5.68429194e-02f, -1.87703222e-02f, -7.61516988e-02f, -1.73583329e-02f, -2.88367700e-02f, 3.84059772e-02f,
  -9.08997431e-02f, 3.13522890e-02f, -1.37069188e-02f, 1.21336274e-01f, 6.79199621e-02f, -4.06113751e-02f, 2.15736143e-02f, -2.36271154e-02f, -3.57142352e-02f, -7.25277290e-02f,
  6.92745894e-02f, -5.09071350e-02f, 1.05595790e-01f, 3.04058082e-02f, 2.63102680e-01f, -8.03991407e-02f, -1.45856850e-02f, 1.93682522e-01f, 2.11785465e-01f, -1.24721125e-01f,
  6.92522898e-02f, -2.42295250e-01f, -4.32002693e-02f, 2.49100644e-02f, -2.26185501e-01f, -1.49310008e-01f, -1.50494367e-01f, -1.66306496e-01f, 9.94160920e-02f, 1.25649003e-02f,
  2.19709262e-01f, 6.31923601e-02f, 9.89941433e-02f, 8.18132386e-02f, 8.54988173e-02f, 1.37343779e-01f, 4.67150519e-03f, 5.96713945e-02f, 1.62184667e-02f, -1.18364811e-01f,
  4.54693921e-02f, 8.00552294e-02f, 2.14556642e-02f, -4.78743017e-03f, 1.13196559e-01f, -2.27060150e-02f, -2.54244264e-02f, 1.34968627e-02f, 1.10967778e-01f, 1.55704306e-03f,
  2.23433767e-02f, 1.08676322e-01f, -6.68780208e-02f, -1.93342064e-02f, 1.07870147e-01f, 4.60819043e-02f, 1.09314241e-01f, 9.52995867e-02f, 5.22155315e-02f, 9.88337398e-02f,
  7.25840330e-02f, 9.44344997e-02f, 5.52525632e-02f, -3.34814303e-02f, 9.85488389e-03f, 2.14967299e-02f, -3.79886990e-03f, 7.95530528e-02f, -5.55767193e-02f, 3.99167798e-02f,
  6.39978424e-02f, -1.42662339e-02f, -6.84922561e-02f, -8.30633640e-02f, -7.15714917e-02f, 7.42980316e-02f, -5.98990470e-02f, 1.57685932e-02f, -4.72344272e-02f, -6.85535222e-02f,
  1.96801852e-02f, -2.09396277e-02f, 9.45052207e-02f, 2.03083698e-02f, -9.79601406e-03f, 1.53162545e-02f, -1.37794241e-01f, -6.48285970e-02f, 5.68914786e-02f, 3.94792445e-02f,
  1.81436930e-02f, -1.98726840e-02f, -3.19668986e-02f, 3.07427044e-03f, -2.80278586e-02f, 8.53449851e-02f, 5.15534841e-02f, 3.38062756e-02f, 3.90950311e-03f, -7.80890658e-02f,
  -1.46746337e-01f, -8.10286999e-02f, -2.55554244e-02f, 6.58959150e-02f, -1.24866962e-01f, -2.25293860e-02f, -5.45958467e-02f, -4.93725948e-02f, 5.40507818e-03f, 2.89969686e-02f,
  6.41046911e-02f, 5.23268543e-02f, -1.23673327e-01f, -2.05598753e-02f, -4.02757712e-02f, -1.28468135e-02f, -4.75509930e-03f, -7.77747259e-02f, -9.46146697e-02f, 3.43703590e-02f,
  -2.46019079e-03f, -1.48682110e-03f, 3.97117529e-03f, 2.30420120e-02f, 4.19080965e-02f, 2.67254580e-02f, -1.18956938e-01f, 2.09053643e-02f, -9.84015502e-03f, 7.25775510e-02f,
  -4.53110665e-01f, -1.86946005e-01f, -9.52441767e-02f, -3.34197670e-01f, 2.75755413e-02f, 1.08721167e-01f, 8.92304331e-02f, -1.15842707e-01f, -1.99825749e-01f, 3.13135888e-03f,
  9.36636925e-02f, -1.48242816e-01f, 1.66264385e-01f, -1.58454895e-01f, 1.04593024e-01f, 3.28638814e-02f, -6.49281740e-02f, -5.32864891e-02f, -4.61598895e-02f, -1.12489581e-01f,
  -5.14747575e-02f, 1.25048310e-02f, 2.48621181e-02f, 4.09512147e-02f, -1.20459385e-01f, -1.67637065e-01f, 1.28319010e-01f, 9.36769173e-02f, 6.99645327e-03f, 3.94213572e-02f,
  -1.56582579e-01f, -1.94403172e-01f, -2.59994483e-03f, 1.79410875e-02f, 9.01395082e-02f, 6.82747141e-02f, -1.21884402e-02f, 8.69517475e-02f, 4.73698042e-02f, 2.48369318e-03f,
  1.55919353e-02f, -3.13036628e-02f, 9.49976314e-03f, -1.99354552e-02f, -1.07546085e-02f, -2.43227724e-02f, 6.16822438e-03f, 3.21820192e-02f, -5.48933037e-02f, 5.74674644e-02f,
  1.28891626e-02f, 1.20208960e-03f, 1.97270904e-02f, 3.78724560e-02f, 6.25084043e-02f, -7.72663206e-02f, -2.90967133e-02f, 4.11462970e-02f, -2.42179520e-02f, -3.66739221e-02f,
  5.61278537e-02f, -5.62166460e-02f, -1.11904768e-02f, -4.55369577e-02f, 5.04604541e-02f, 2.70591676e-02f, 5.50944097e-02f, 7.11633340e-02f, -7.19099829e-04f, 2.86567584e-02f,
  2.09485907e-02f, -7.21958652e-02f, -4.90866452e-02f, 2.72940304e-02f, -9.23613459e-03f, -9.24261659e-02f, 6.85603023e-02f, -3.93822938e-02f, 4.54301201e-03f, 7.28885643e-03f,
  -3.54082100e-02f, 7.60779949e-03f, 3.20297219e-02f, 2.71002539e-02f, 1.39276721e-02f, 8.33480954e-02f, -5.65251000e-02f, -2.83557288e-02f, 4.82580066e-02f, 8.38722587e-02f,
  -5.18527925e-02f, -2.50683516e-01f, 2.28119156e-04f, 3.70994136e-02f, -1.09861081e-03f, 5.39258234e-02f, -3.91309634e-02f, 1.78084206e-02f, 4.51950505e-02f, 6.79385616e-03f,
  1.92925669e-02f, -4.46926914e-02f, -5.83469570e-02f, 3.95705923e-02f, -8.17365758e-03f, 5.77798598e-02f, -5.94136417e-02f, 1.51992701e-02f, 2.75421925e-02f, -8.07117485e-03f,
  -1.87913720e-02f, -4.23046993e-03f, 6.57992214e-02f, -2.52644047e-02f, -4.20826562e-02f, 1.25965811e-02f, -7.26664811e-02f, -6.68851808e-02f, 1.07813925e-01f, -1.10275112e-02f,
  -3.27703446e-01f, 8.48591700e-03f, 2.93072797e-02f, -1.14858203e-01f, 1.26332164e-01f, -2.25518614e-01f, -5.13686193e-03f, -5.43351769e-02f, -4.41759229e-02f, 3.84681374e-02f,
  3.96467932e-02f, 1.11747754e-03f, 1.16548009e-01f, -1.69085324e-01f, -1.91915542e-01f, -1.94722220e-01f, -2.00052351e-01f, -1.08770460e-01f, -1.24363661e-01f, -1.54628502e-02f,
  -5.73418289e-02f, -1.73264444e-01f, 1.87846068e-02f, 2.88385954e-02f, 1.55727696e-02f, 9.05823037e-02f, 6.22578338e-03f, 1.71613276e-01f, -7.81160071e-02f, 3.62412035e-02f,
  1.33582316e-02f, 3.16037727e-03f, 1.28494531e-01f, 2.10543424e-02f, -1.82889476e-02f, 1.40231452e-03f, 9.97936279e-02f, -1.19898496e-02f, 3.20777893e-02f, -2.02042274e-02f,
  3.41022643e-03f, -1.88589618e-02f, -1.55790262e-02f, -2.00553406e-02f, -5.57680428e-02f, 5.45851402e-02f, 4.43086103e-02f, -1.15131158e-02f, -2.59063467e-02f, -7.62764812e-02f,
  4.45030704e-02f, -5.53037040e-02f, -6.95667639e-02f, -1.07722217e-02f, 2.48540360e-02f, 3.32979858e-03f, -1.62171740e-02f, 7.73191899e-02f, 2.11792849e-02f, -7.39877671e-02f,
  -3.40790302e-03f, -1.38601465e-02f, 5.11162616e-02f, 7.03016594e-02f, -5.23186661e-02f, 1.27270371e-02f, 5.42325638e-02f, -3.26531753e-02f, -2.75138933e-02f, 3.11870128e-02f,
  -5.04568629e-02f, 7.31953755e-02f, 3.08955181e-02f, -4.98556755e-02f, -3.04252747e-02f, 3.11036091e-02f, 7.75420154e-03f, 9.85623896e-02f, -8.81938115e-02f, 1.14437798e-02f,
  -7.51631614e-03f, 4.04804014e-02f, 6.89013302e-02f, -2.25735512e-02f, -4.29089628e-02f, 8.15549344e-02f, -7.19464719e-02f, 2.49949731e-02f, 3.31997424e-02f, 2.60299426e-02f,
  -4.55248058e-02f, -1.64647924e-03f, 9.66906473e-02f, -3.30408253e-02f, 3.60028185e-02f, 4.68536951e-02f, -4.67326827e-02f, -5.13609201e-02f, -3.66993994e-02f, -5.86961210e-02f,
  3.47798206e-02f, 4.03627120e-02f, -2.12511215e-02f, 4.25857827e-02f, 1.49949165e-02f, 3.59930331e-04f, -1.78091545e-02f, -3.62366363e-02f, 7.57478401e-02f, 2.77499408e-02f,
  1.36737668e-04f, -2.81619113e-02f, -4.28156815e-02f, -1.93584915e-02f, 2.04343200e-02f, 2.44086869e-02f, -4.97628599e-02f, -6.04601279e-02f, -2.87567098e-02f, 3.43772918e-02f,
  -2.00736046e-01f, 1.00667857e-01f, 1.22323386e-01f, 1.44431755e-01f, 1.39708415e-01f, -2.22623989e-01f, -1.30781949e-01f, 1.98046193e-01f, 6.65667206e-02f, 3.15592103e-02f,
  -1.59337044e-01f, 2.76653431e-02f, -2.67992854e-01f, -5.82375042e-02f, -3.06735396e-01f, -2.00225979e-01f, -9.05428752e-02f, 4.43373732e-02f, 7.38679394e-02f, 9.62796658e-02f,
  8.83929357e-02f, 3.98977548e-02f, -4.51666676e-02f, 3.22745174e-01f, 5.49236387e-02f, 1.56941861e-01f, 3.10832728e-02f, 6.04062863e-02f, 1.55654073e-01f, -7.67032132e-02f,
  1.45659025e-03f, 4.98417765e-02f, 1.22270986e-01f, -7.67975897e-02f, -3.64035107e-02f, -4.78984788e-02f, 4.91254628e-02f, 1.90991908e-02f, 5.19358367e-02f, 1.44249555e-02f,
  -1.06899716e-01f, -1.85979288e-02f, 2.02304013e-02f, 3.28464396e-02f, 7.85036311e-02f, -4.47725654e-02f, 1.56021016e-02f, -6.69313744e-02f, 5.38302474e-02f, -7.53290653e-02f,
  -1.09054998e-01f, -7.43145794e-02f, -6.85260147e-02f, 6.38685152e-02f, -7.54102925e-03f, 7.53796427e-03f, 3.25993658e-03f, -9.02502462e-02f, 1.50199253e-02f, -8.91697186e-04f,
  -8.09768289e-02f, 1.90235004e-02f, 2.92589292e-02f, 9.20650642e-03f, -2.16402914e-02f, 2.59980210e-03f, 9.88791436e-02f, 1.46412626e-02f, 1.14582363e-03f, -4.27260846e-02f,
  1.25350123e-02f, -4.52173166e-02f, 4.15669680e-02f, 5.87695576e-02f, 2.90220021e-03f, 8.71759430e-02f, 8.97468813e-03f, 3.53936553e-02f, -4.72305007e-02f, -3.77865992e-02f,
  4.56143878e-02f, -5.32207675e-02f, 3.52846645e-02f, 1.34352606e-03f, -5.76966302e-03f, 9.54330489e-02f, -3.22553935e-03f, 2.17669643e-02f, 4.06035744e-02f, -4.09559235e-02f,
  -1.38667300e-01f, 6.58477247e-02f, 6.68791682e-02f, 6.82377517e-02f, 2.73995977e-02f, 8.12489092e-02f, -3.67784500e-02f, -2.13545505e-02f, -2.79349461e-02f, 7.36598996e-03f,
  7.35957846e-02f, 3.33863646e-02f, 5.97513989e-02f, -6.75034747e-02f, -2.91948654e-02f, -2.24763695e-02f, -2.38406491e-02f, 1.73284914e-02f, 2.77554579e-02f, 7.55748749e-02f,
  9.32363980e-03f, 4.95736115e-03f, 2.12208405e-02f, 1.41110795e-03f, 1.64157785e-02f, -7.01887384e-02f, 7.71894827e-02f, 4.59982231e-02f, -1.24138491e-02f, 5.34559712e-02f,
  -3.56311202e-02f, -1.81952074e-01f, -2.82714039e-01f, -2.35437259e-01f, 1.74929932e-01f, 5.92133775e-02f, -1.70603946e-01f, -6.54356480e-02f, -1.56165808e-01f, -6.14966601e-02f,
  1.27420291e-01f, -1.04288235e-01f, -1.52647227e-01f, -1.11291826e-01f, -2.30936538e-02f, -2.03362703e-01f, 2.05120239e-02f, 2.00861022e-02f, -1.57665029e-01f, -9.25544649e-02f,
  -1.05802327e-01f, -1.70394070e-02f, -8.71913657e-02f, 1.31978085e-02f, -6.69266954e-02f, 4.77886908e-02f, 1.53349176e-01f, 1.25069898e-02f, 2.25231394e-01f, 6.15892187e-02f,
  -8.21352378e-02f, -4.58453782e-02f, -2.79326066e-02f, -8.78395289e-02f, 1.23625845e-02f, -3.36837862e-03f, 4.34818398e-03f, -4.00255322e-02f, 4.98574488e-02f, -1.06545269e-01f,
  2.54040044e-02f, 1.40742725e-03f, 5.84354904e-03f, -1.96404420e-02f, -1.59146246e-02f, -3.30051966e-02f, 3.37555562e-03f, 7.97089096e-03f, -1.02010995e-01f, -5.82832135e-02f,
  -3.94688509e-02f, 3.78888752e-03f, -4.12993357e-02f, -3.17612030e-02f, -4.12691534e-02f, -4.65418585e-02f, -2.58195642e-02f, 1.93081982e-02f, 4.26407345e-02f, -4.97353971e-02f,
  1.66856069e-02f, 1.05131507e-01f, -2.04750691e-02f, 3.59209627e-02f, -6.52153119e-02f, -5.24753071e-02f, -1.90583598e-02f, 7.38100186e-02f, -4.23069000e-02f, -5.39409928e-02f,
  1.66528728e-02f, 3.81474546e-03f, 6.11637766e-03f, -6.27995282e-02f, 6.79954514e-02f, -2.79670581e-02f, -4.00729403e-02f, 2.85878610e-02f, 6.44242465e-02f, 2.60868371e-02f,
  -9.08030942e-02f, 4.15547453e-02f, -3.41613218e-02f, 6.28163666e-02f, -6.81136027e-02f, 7.07751215e-02f, 7.19098225e-02f, -5.26080430e-02f, 4.97117154e-02f, 3.97679918e-02f,
  -6.42473251e-02f, -4.26836759e-02f, -3.40011008e-02f, 9.88605767e-02f, -3.96143496e-02f, 5.38456738e-02f, -5.72375208e-02f, 5.25896288e-02f, 7.24467123e-03f, 2.07362119e-02f,
  1.75593491e-03f, 1.26312522e-03f, 1.03588693e-01f, -2.27418658e-03f, 7.60895833e-02f, 9.92708653e-02f, 8.50774571e-02f, 9.54562649e-02f, 6.40889630e-02f, 1.54811591e-02f,
  -1.70233492e-02f, 5.08113690e-02f, -3.20511237e-02f, 1.73696429e-02f, 1.32178590e-01f, 8.00710320e-02f, -3.70940678e-02f, 4.76376489e-02f, 2.77880859e-02f, -8.69602188e-02f,
  9.67464298e-02f, 3.57042164e-01f, -8.80957767e-02f, -3.30576822e-02f, -1.53251454e-01f, -7.37075284e-02f, 7.80410916e-02f, -1.56014234e-01f, 1.25284895e-01f, 2.83271968e-01f,
  -2.01904643e-02f, 2.10732877e-01f, 5.25852218e-02f, 7.24068731e-02f, -2.33081609e-01f, 2.82021929e-02f, -1.14732653e-01f, 1.38968766e-01f, -8.45073760e-02f, 5.75884841e-02f,
  -8.28623697e-02f, -5.43203689e-02f, -2.43596137e-01f, -1.24706894e-01f, -1.94844790e-02f, -1.86344590e-02f, -8.60956847e-04f, -5.46188690e-02f, 1.28893703e-02f, 6.65483922e-02f,
  7.87696317e-02f, 9.81405303e-02f, -1.11096236e-03f, -1.52989188e-02f, -1.60336234e-02f, -2.40687863e-04f, -2.35066507e-02f, -1.91439744e-02f, -3.59822139e-02f, -2.11334927e-03f,
  2.96205445e-03f, -7.53777623e-02f, -2.37390455e-02f, -3.61884944e-02f, 1.49433464e-02f, -1.40722729e-02f, -1.26904473e-01f, -7.87203833e-02f, 1.14211105e-02f, -8.48210379e-02f,
  -1.21601326e-02f, -9.74158794e-02f, -7.28617683e-02f, -3.85741554e-02f, -1.10472836e-01f, 3.52467149e-02f, -6.77208304e-02f, 5.48566431e-02f, 3.82143334e-02f, -5.00771636e-03f,
  3.88421491e-02f, -1.22409398e-02f, -1.34317018e-03f, -4.66039926e-02f, 4.04057018e-02f, -2.78427340e-02f, -2.08384153e-02f, -2.81121284e-02f, 3.41390334e-02f, -3.94262113e-02f,
  5.00675105e-03f, -5.72913103e-02f, -2.49529779e-02f, -2.14116741e-02f, -1.17496019e-02f, 7.72898942e-02f, 2.62417849e-02f, -7.74104446e-02f, -6.18629297e-03f, -2.47798581e-02f,
  1.74914729e-02f, -3.82296108e-02f, -9.77896899e-03f, -6.83047697e-02f, -9.91277024e-03f, -3.98155227e-02f, -9.23881680e-03f, -5.86630926e-02f, -5.02349511e-02f, -4.29031923e-02f,
  7.55644813e-02f, 1.44339904e-01f, 4.29595523e-02f, 3.69000994e-02f, 1.01635769e-01f, -9.67506915e-02f, 1.22072012e-03f, -3.35163623e-02f, 8.25053453e-02f, -7.03136548e-02f,
  -9.04115885e-02f, -1.38070043e-02f, 7.11183622e-02f, 4.90541831e-02f, 7.16014057e-02f, -1.27061056e-02f, 4.13020700e-02f, 4.14493531e-02f, -5.27458638e-02f, 6.71210736e-02f,
  -7.52249360e-02f, 1.90656073e-02f, 2.44855438e-03f, -1.22966059e-01f, 1.39539819e-02f, -7.90225051e-04f, 6.98310807e-02f, 1.71567556e-02f, -9.03094262e-02f, 1.15450829e-01f,
  -2.09231853e-01f, 7.58916978e-03f, -9.30991024e-02f, -5.73112280e-04f, -8.58428180e-02f, -6.33955821e-02f, -1.20640196e-01f, -9.85988379e-02f, -2.24541947e-01f, 1.94014773e-01f,
  1.99993141e-02f, -1.29501503e-02f, -1.33251444e-01f, 2.37783536e-01f, -1.95617348e-01f, -2.07054481e-01f, 1.30032375e-01f, 1.37491614e-01f, -1.05548270e-01f, 9.10888463e-02f,
  -7.57814422e-02f, 1.32077426e-01f, -7.29734227e-02f, 1.58706486e-01f, 6.57106787e-02f, 4.72577997e-02f, 2.02240184e-01f, -9.79399681e-02f, 2.16119349e-01f, -7.18718115e-03f,
  5.60442209e-02f, -7.34444559e-02f, -3.58327106e-02f, -5.38515709e-02f, -3.05760838e-02f, 7.37899989e-02f, 7.17144981e-02f, -2.76307929e-02f, -9.59371799e-04f, -1.43851424e-02f,
  -4.22164798e-03f, 2.33075283e-02f, -5.89211695e-02f, 1.24988757e-04f, 2.49909554e-02f, 1.03710191e-02f, -4.53427667e-03f, 7.67613575e-02f, 4.04281840e-02f, -1.10363467e-02f,
  -1.41897589e-01f, 7.30861425e-02f, -1.12114465e-02f, 2.52102260e-02f, -1.34601304e-03f, -2.83454023e-02f, 5.59225455e-02f, 7.19456598e-02f, 1.28009012e-02f, -9.72799063e-02f,
  2.30549984e-02f, -2.13536005e-02f, 2.49224622e-03f, 1.46495998e-02f, -5.15537970e-02f, 2.63776798e-02f, 5.72987832e-02f, 8.12355131e-02f, -5.65902628e-02f, 5.57631440e-02f,
  3.65273878e-02f, 4.64837393e-03f, 6.04801737e-02f, 3.53034097e-03f, 6.90335035e-02f, -7.70517532e-03f, 5.47858365e-02f, -2.50998177e-02f, -6.27701283e-02f, -3.04437205e-02f,
  5.23716807e-02f, -7.66550899e-02f, 1.43393902e-02f, 6.93930173e-03f, -1.33772017e-02f, -7.61643350e-02f, 4.35933508e-02f, -8.36562142e-02f, -5.59555774e-04f, -3.68622094e-02f,
  8.21604058e-02f, -6.71081021e-02f, -4.03351635e-02f, 2.62839198e-02f, -6.88256249e-02f, -1.01943444e-02f, 3.39737185e-03f, -1.85823664e-02f, -2.63071302e-02f, -3.89552340e-02f,
  3.99189927e-02f, -4.44931425e-02f, 7.42026940e-02f, 3.72257456e-02f, -6.29562512e-02f, 1.73867289e-02f, 2.57625151e-02f, 6.66750595e-02f, 4.99993041e-02f, 5.62651642e-02f,
  1.23337850e-01f, -2.71510649e-02f, -3.87293510e-02f, 3.96558829e-02f, 3.72576038e-03f, 1.38203884e-02f, -4.34791762e-03f, -2.71121562e-02f, 6.96785226e-02f, 6.61741570e-02f,
  -4.02979665e-02f, 1.38467535e-01f, 1.36933342e-01f, -1.46394551e-01f, -1.04227051e-01f, -1.83237448e-01f, -9.03548598e-02f, 6.24287166e-02f, 2.04554185e-01f, -1.10567726e-01f,
  -1.89332321e-01f, 2.24875629e-01f, 9.34205875e-02f, -1.24601722e-01f, 3.57020274e-02f, 1.76384702e-01f, -1.70081973e-01f, -1.02815650e-01f, 8.49522203e-02f, -1.53581306e-01f,
  -1.67077929e-02f, -2.17837989e-01f, -9.28659141e-02f, 7.92064238e-03f, -3.93252959e-03f, 1.44325327e-02f, -1.12904638e-01f, 1.21019833e-01f, -1.48858562e-01f, 1.56635731e-01f,
  -8.83670971e-02f, 1.28650799e-01f, -7.98926502e-02f, -1.04231713e-02f, -4.94091352e-03f, -2.98473500e-02f, -4.36825901e-02f, 6.25528842e-02f, -6.06261380e-02f, -2.56852191e-02f,
  -4.50250171e-02f, -2.86641829e-02f, 2.78037861e-02f, 6.49349838e-02f, -1.66969020e-02f, -4.55895998e-02f, 2.47983038e-02f, -1.41600613e-02f, 1.13810850e-02f, 9.04828403e-03f,
  -3.47023904e-02f, 3.82780805e-02f, 4.04684097e-02f, 2.57827323e-02f, -9.98653993e-02f, -8.30023065e-02f, -6.83250092e-03f, -8.32265839e-02f, 8.22920501e-02f, -4.06936482e-02f,
  -5.20435646e-02f, 5.24240220e-03f, -4.34595756e-02f, 1.26470864e-01f, -7.22956881e-02f, -7.88865387e-02f, 7.78959021e-02f, 2.96486765e-02f, 1.37498882e-02f, -4.29247580e-02f,
  -3.42924483e-02f, -2.70073805e-02f, 1.32362872e-01f, -1.31640032e-01f, -5.86520545e-02f, 3.89916450e-02f, 6.78592473e-02f, 5.88749861e-03f, -1.38566149e-02f, -1.76074123e-03f,
  7.85772353e-02f, 5.00375479e-02f, -4.13886132e-03f, -5.84949739e-02f, 5.14712259e-02f, -1.05205951e-02f, -3.08735799e-02f, 2.68690921e-02f, -3.70965302e-02f, -2.03269720e-02f,
  5.31375930e-02f, 6.44667223e-02f, -1.26719838e-02f, -2.19957475e-02f, 1.22350514e-01f, 5.29558845e-02f, 1.13932714e-01f, -1.54345669e-02f, 5.50234690e-02f, 1.73063409e-02f,
  -2.20511891e-02f, -5.68793155e-02f, 1.36282772e-01f, -2.62972359e-02f, 3.13597955e-02f, -8.09032843e-02f, 4.96811345e-02f, 5.11574857e-02f, 1.41077731e-02f, -1.11133419e-01f,
  -1.07029788e-01f, -8.57303590e-02f, 4.57239710e-02f, -5.01693338e-02f, -1.61512177e-02f, -4.26812544e-02f, -5.52775338e-02f, -7.99548477e-02f, 1.55648991e-01f, 2.21210830e-02f,
  -2.15398803e-01f, -2.95464545e-01f, -2.13577002e-01f, -2.14197621e-01f, -8.29085484e-02f, 1.44449085e-01f, 2.77891964e-01f, -1.13344483e-01f, -2.40163043e-01f, 1.31341573e-02f,
  1.46370679e-01f, -1.91983417e-01f, 8.64894167e-02f, -7.06492886e-02f, 1.04176462e-01f, 9.51617882e-02f, -1.19591774e-02f, -5.71091101e-02f, -1.92323446e-01f, -4.83871177e-02f,
  -1.13660946e-01f, 8.93409550e-02f, -5.34672104e-02f, -4.61609922e-02f, -4.46227677e-02f, -4.93504480e-02f, 1.17819279e-01f, 1.29004404e-01f, 3.86400931e-02f, 6.71703815e-02f,
  -3.58068421e-02f, 6.45154342e-02f, -2.29673143e-02f, -2.16340423e-02f, -2.19546091e-02f, 1.65235456e-02f, 5.90278283e-02f, 1.37966126e-01f, -6.30820449e-03f, 3.60824130e-02f,
  -5.29847760e-03f, 9.76007208e-02f, -4.00310531e-02f, -5.16817234e-02f, -6.51256517e-02f, -5.69450371e-02f, -2.87795588e-02f, -3.71411555e-02f, -2.13707946e-02f, 5.68661205e-02f,
  -3.80805507e-02f, -6.66875467e-02f, 2.30090250e-03f, -1.53493714e-02f, -2.81602181e-02f, 2.10741125e-02f, -4.86650430e-02f, 2.57208552e-02f, 1.73876695e-02f, -6.76818937e-02f,
  6.98797405e-02f, -3.33559141e-02f, -6.16150117e-03f, -3.47337499e-02f, -1.97402518e-02f, 3.39227282e-02f, -5.15184812e-02f, 1.86301377e-02f, -2.36096997e-02f, 1.74365621e-02f,
  -2.37448551e-02f, 9.70732514e-03f, -5.69109544e-02f, -5.02017066e-02f, -3.03052291e-02f, 2.44970508e-02f, 1.56379230e-02f, 5.84617220e-02f, 1.49188582e-02f, -5.99933229e-02f,
  7.56550729e-02f, 2.99526453e-02f, -6.58751577e-02f, -2.22274265e-03f, 3.47404033e-02f, 1.80610921e-02f, -2.54257396e-02f, -1.45972380e-02f, -2.71911994e-02f, 3.14719342e-02f,
  6.28477260e-02f, -5.34822196e-02f, 8.47529396e-02f, 5.03594764e-02f, -8.11470905e-04f, 9.73493326e-03f, 3.43096331e-02f, -1.19891120e-02f, -6.16891542e-03f, 7.05078617e-02f,
  1.41738569e-02f, 3.29382941e-02f, -9.27612409e-02f, 6.21209443e-02f, 7.31146112e-02f, 1.29522569e-02f, 7.35604763e-02f, -2.58862376e-02f, -1.27104996e-02f, -7.46010020e-02f,
  8.36753398e-02f, 5.19490726e-02f, -1.22728795e-02f, -2.11104248e-02f, 3.28851007e-02f, 3.91091518e-02f, -1.10161133e-01f, -4.16594930e-02f, -2.20035724e-02f, -4.62465025e-02f,
  -6.80826977e-02f, -3.00188065e-01f, -7.36044943e-02f, -1.70225389e-02f, -1.66762341e-02f, -1.46477371e-01f, -9.04122442e-02f, -3.07246763e-02f, 4.59985854e-03f, -4.85265478e-02f,
  -6.48699328e-02f, 1.28599880e-02f, -2.72298362e-02f, -2.27073184e-03f, 2.92844474e-01f, 1.19311236e-01f, 9.23220348e-03f, -2.55105249e-03f, 1.00096643e-01f, -2.92460937e-02f,
  1.79184362e-01f, 3.21814641e-02f, 1.65262923e-01f, -3.28803174e-02f, -2.47355513e-02f, 4.61625978e-02f, 1.59268051e-01f, -7.73931518e-02f, -5.02474327e-03f, 7.91669637e-02f,
  -1.04438506e-01f, -1.65801287e-01f, -1.41566875e-03f, -6.00829199e-02f, -1.29972219e-01f, 4.74124961e-03f, -1.25166615e-02f, 8.39511156e-02f, -4.19339025e-03f, 3.31603400e-02f,
  -2.55499464e-02f, 1.27975224e-02f, 7.21613318e-02f, 2.30201054e-02f, -1.06462292e-01f, -9.69384834e-02f, -1.12419631e-02f, 7.14023132e-03f, -8.01867545e-02f, 6.86850399e-02f,
  2.56026927e-02f, -6.47340715e-02f, -3.44528421e-03f, 2.60212757e-02f, 2.11143978e-02f, -1.93402153e-02f, 3.17413062e-02f, 4.58829245e-03f, -5.51682822e-02f, -2.07810123e-02f,
  -5.46644069e-02f, 6.08132333e-02f, 7.21491575e-02f, -6.16993662e-03f, -1.05334632e-01f, 8.38138070e-03f, 1.08986823e-02f, 1.60186123e-02f, 2.17604507e-02f, -6.46383986e-02f,
  1.44706899e-02f, 8.17096159e-02f, -5.71192056e-02f, 3.72841731e-02f, 8.00801665e-02f, -6.55246526e-02f, 1.57916825e-02f, 5.03848344e-02f, 1.10710729e-02f, 1.31670907e-01f,
  2.52005309e-02f, 3.52073871e-02f, -7.08008111e-02f, -3.31783816e-02f, -1.67676155e-02f, 4.73508909e-02f, -9.08934698e-02f, -7.68530592e-02f, 2.78422479e-02f, 5.99049963e-02f,
  -1.24732800e-01f, -8.94973129e-02f, 8.52458030e-02f, -3.42214517e-02f, 4.26953360e-02f, -5.62085677e-03f, 3.59026417e-02f, -2.52625924e-02f, -6.99794367e-02f, -8.66811126e-02f,
  -8.48469958e-02f, 1.82268443e-03f, 3.39841880e-02f, -5.65236434e-02f, -2.49838773e-02f, 4.42986265e-02f, 5.36236912e-02f, -8.97306670e-03f, -3.25167142e-02f, 5.51197752e-02f,
  1.99990273e-02f, -5.88901378e-02f, 1.04882851e-01f, -2.54914211e-03f, -1.18848844e-03f, -2.67073158e-02f, -1.48844803e-02f, 2.43130568e-02f, 4.72206809e-02f, 4.05870453e-02f,
  -7.47755319e-02f, 2.05100924e-01f, 2.81379670e-01f, 1.36553004e-01f, -1.91541106e-01f, -7.23913237e-02f, -3.91462818e-02f, 3.06066144e-02f, 2.02640057e-01f, -3.94420438e-02f,
  1.49616981e-02f, 1.66625269e-02f, 1.22684315e-01f, 2.83758380e-02f, -5.73431402e-02f, 4.06795628e-02f, 5.62157445e-02f, 6.51986450e-02f, 5.07276319e-02f, 9.46341380e-02f,
  4.23547179e-02f, 7.82311261e-02f, 1.00824952e-01f, -5.65066151e-02f, 1.04833052e-01f, 2.71745119e-02f, -7.16184527e-02f, 1.62235182e-02f, -9.76262391e-02f, -1.07714534e-01f,
  -7.29716569e-02f, 1.08736269e-01f, 8.52605030e-02f, 4.99716587e-02f, -1.65577810e-02f, -1.48261935e-01f, -1.18477814e-01f, 7.12963939e-02f, 2.46246085e-02f, 4.78375629e-02f,
  1.23191020e-02f, 1.17016342e-02f, 2.42068525e-02f, -3.35542783e-02f, -3.39295119e-02f, 5.54136634e-02f, 2.81159766e-02f, -1.43757518e-02f, 1.51606519e-02f, 1.20097212e-02f,
  1.05853379e-01f, -5.09433374e-02f, 6.11834116e-02f, -5.33478446e-02f, -2.72561256e-02f, -1.55243715e-02f, 2.59407498e-02f, 2.69051027e-02f, -1.51905671e-01f, -2.58402638e-02f,
  -6.65031895e-02f, 7.74847949e-03f, 8.83154571e-02f, 8.88110772e-02f, -3.56365182e-02f, -4.06998210e-02f, -1.66522898e-02f, 7.72471773e-03f, 9.05747637e-02f, 8.68073478e-02f,
  3.62891890e-02f, 1.06611304e-01f, -4.05613892e-02f, -8.08232650e-02f, -3.78171094e-02f, 2.01824936e-03f, 6.11294433e-02f, 3.70637178e-02f, -2.04541218e-02f, -9.99206956e-03f,
  9.81124714e-02f, -3.07794381e-03f, 5.51646352e-02f, 3.44684273e-02f, 3.56963836e-02f, 2.40611956e-02f, 2.68182270e-02f, 9.40037146e-03f, 2.71865260e-02f, 1.34549122e-02f,
  -4.95350435e-02f, 1.14189900e-01f, 5.84773645e-02f, -3.89265083e-02f, 5.10548567e-03f, 1.20757846e-02f, -1.73353823e-03f, -5.47327064e-02f, 3.28533724e-02f, -7.20691755e-02f,
  -4.43983637e-02f, -2.27658655e-02f, -8.28897879e-02f, -6.56720400e-02f, -5.84805850e-03f, 1.59770735e-02f, 4.77488227e-02f, -9.59564522e-02f, -5.65288179e-02f, -9.26329270e-02f,
  -7.57253692e-02f, 8.32186639e-03f, 2.97653470e-02f, -4.07480970e-02f, -1.16557129e-01f, 5.22248447e-02f, -1.17594153e-02f, -2.87795197e-02f, 4.98095236e-04f, -5.60342260e-02f,
  2.65574962e-01f, -1.47652820e-01f, 2.57861093e-02f, -1.99049506e-02f, 1.24029376e-01f, 2.46626318e-01f, -1.12243341e-02f, -4.18310706e-03f, 1.00648753e-01f, -5.76366596e-02f,
  -1.36457175e-01f, -2.42456838e-01f, -3.94423641e-02f, -2.29767188e-01f, 1.85453728e-01f, 1.14416316e-01f, 1.29388243e-01f, -7.56900162e-02f, 1.19195692e-02f, 1.24951556e-01f,
  1.55357674e-01f, -8.03478807e-02f, 8.43526889e-03f, 4.31782641e-02f, -1.26440793e-01f, 1.14101004e-02f, -1.72309458e-01f, -8.50595459e-02f, -2.78273076e-01f, -5.52866235e-02f,
  1.99917287e-01f, 1.04656316e-01f, -1.43627822e-02f, 5.52408919e-02f, 1.25520527e-02f, 7.07169026e-02f, -2.96339709e-02f, -5.87020591e-02f, -4.00702655e-02f, -2.31777448e-02f,
  -2.87065357e-02f, -1.95997618e-02f, -2.62792427e-02f, 6.25355393e-02f, 1.06028654e-01f, -6.67135864e-02f, -1.35855868e-01f, 4.44529019e-02f, -1.01663478e-01f, 4.65087555e-02f,
  -1.97949577e-02f, -7.20006749e-02f, 1.21278409e-02f, -4.92525334e-03f, 1.56875942e-02f, 1.57623005e-03f, -1.64709203e-02f, -1.30957570e-02f, 2.39696484e-02f, 3.55973057e-02f,
  1.03687540e-01f, 2.32630614e-02f, -2.77222358e-02f, -6.11494072e-02f, -9.23958793e-02f, 2.71396786e-02f, -1.11392036e-01f, -6.21575303e-02f, -3.15968543e-02f, 2.88418215e-02f,
  8.04798976e-02f, 5.18538095e-02f, 5.46669438e-02f, 1.50503039e-01f, 9.22615081e-03f, 7.58827403e-02f, -3.46867852e-02f, -6.69815987e-02f, 8.65637511e-02f, -5.27018532e-02f,
  -2.49778591e-02f, 2.93892827e-02f, -7.79112279e-02f, -5.46998484e-03f, 8.48050192e-02f, -6.86046376e-04f, 9.39703826e-03f, 1.23730674e-01f, 2.14540865e-02f, 3.83455418e-02f,
  1.18600808e-01f, 1.27855465e-01f, -7.14850612e-03f, 3.43858711e-02f, -3.15353274e-02f, 2.91005187e-02f, 6.73320889e-02f, 1.16532268e-02f, 1.37452945e-01f, 1.12899840e-01f,
  2.94545945e-02f, -2.01628674e-02f, 5.03837951e-02f, 8.93443376e-02f, 1.93821341e-02f, 1.09763548e-01f, 8.17253292e-02f, -3.33412662e-02f, 5.07647134e-02f, -5.63476160e-02f,
  -2.83895060e-02f, 6.52631326e-03f, -1.31762013e-01f, 2.23170291e-03f, -2.53044330e-02f, -8.68241638e-02f, 1.33485436e-01f, 3.88697535e-02f, 1.55180437e-03f, -6.17189147e-02f,
  -3.02934229e-01f, 1.78169578e-01f, 1.35854706e-01f, 1.64653182e-01f, -1.75838605e-01f, 3.89366448e-01f, 2.05608368e-01f, 3.99835259e-02f, -7.60462135e-02f, -5.05833551e-02f,
  -7.17805773e-02f, -1.41334265e-01f, -8.00810289e-04f, 1.80016100e-01f, 1.15956470e-01f, 2.18695164e-01f, 2.49590129e-01f, 5.76313734e-02f, -4.10760827e-02f, 4.28608991e-03f,
  7.94230103e-02f, 6.96620792e-02f, 1.61003768e-01f, 6.99103847e-02f, -7.76785165e-02f, -8.07671919e-02f, -3.43414908e-03f, -1.10283613e-01f, 8.79885629e-02f, -8.58057011e-03f,
  1.04637727e-01f, -1.57830939e-01f, -4.65618484e-02f, 6.36356696e-02f, 1.02360278e-01f, -1.14719942e-02f, -3.83413322e-02f, -6.79503605e-02f, -1.07292339e-01f, 5.86940609e-02f,
  -2.01498978e-02f, -4.76126410e-02f, 1.47437602e-02f, 1.64999664e-02f, -3.56792882e-02f, 1.82261318e-02f, -6.02900125e-02f, 6.31088242e-02f, -7.98260607e-03f, -2.45192964e-02f,
  3.79504263e-02f, 3.99440432e-06f, -7.55796358e-02f, 6.21973388e-02f, 5.10022119e-02f, -2.89431363e-02f, 5.07117584e-02f, 4.17691283e-02f, 4.59586419e-02f, -9.80909448e-03f,
  -3.65257524e-02f, 4.03831191e-02f, -2.65330877e-02f, -3.19374539e-02f, 6.49584979e-02f, -8.93170461e-02f, -9.10715945e-03f, -4.39379290e-02f, -7.83304777e-03f, 3.61875980e-03f,
  -2.45520286e-03f, -2.34159157e-02f, -4.94563244e-02f, 9.42166969e-02f, 6.88219517e-02f, -4.42528091e-02f, 6.52615279e-02f, -1.62373949e-02f, -3.29888090e-02f, -2.06746836e-03f,
  2.49091312e-02f, 1.35845048e-02f, 5.56031428e-03f, -1.22432988e-02f, 8.15734193e-02f, 3.69198509e-02f, 5.60812280e-02f, -4.66230176e-02f, -4.72604670e-02f, -1.95591673e-02f,
  5.39791323e-02f, 1.32760420e-01f, 4.96147685e-02f, -1.76901650e-02f, 1.38374167e-02f, 1.59894712e-02f, 5.45824245e-02f, -5.16046509e-02f, 1.11477979e-01f, 9.55094956e-03f,
  -1.21179782e-02f, 8.04224461e-02f, 8.73596594e-02f, -3.92161757e-02f, 1.67872719e-02f, -7.18089286e-03f, -8.81410018e-03f, -5.89330913e-04f, 4.00305986e-02f, 3.82055379e-02f,
  -6.48865029e-02f, -6.93922043e-02f, 4.81691658e-02f, 2.49663349e-02f, -2.52910703e-02f, -2.70037726e-02f, -4.66722250e-02f, -6.25206977e-02f, -6.55281320e-02f, 3.23786139e-02f,
  1.95492238e-01f, -1.62597999e-01f, 1.78465489e-02f, 2.69288003e-01f, 3.48078683e-02f, 2.59819508e-01f, 3.16974193e-01f, -9.88044497e-03f, 9.57689732e-02f, -5.85733764e-02f,
  1.82156235e-01f, -1.08299322e-01f, 1.44558158e-02f, 2.62118787e-01f, 2.88324237e-01f, 3.88857909e-02f, 2.18082979e-01f, 3.61503959e-02f, 7.68390251e-03f, -6.38664979e-03f,
  6.68736696e-02f, 8.10005441e-02f, 1.60653174e-01f, -6.14109524e-02f, -2.43140236e-02f, -1.68412492e-01f, 3.70436534e-02f, -1.03071481e-01f, -1.06205694e-01f, -4.40214342e-03f,
  1.07745323e-02f, -9.09431279e-02f, -5.56898415e-02f, -9.27574560e-02f, 4.63117771e-02f, -1.24615720e-02f, 6.17788034e-03f, 5.41085042e-02f, -4.93017305e-03f, -3.72882886e-03f,
  4.14549224e-02f, 3.18823159e-02f, -5.59180304e-02f, -3.55267636e-02f, -3.07928566e-02f, 5.37117803e-03f, -6.81745261e-02f, 3.25412042e-02f, -4.18153917e-03f, -2.60504112e-02f,
  5.02269417e-02f, -8.61370936e-03f, 4.57479097e-02f, 2.24530548e-02f, 3.39536183e-02f, 6.36090897e-03f, 6.61581531e-02f, -4.59034853e-02f, -4.30963635e-02f, -2.25169435e-02f,
  -6.23190738e-02f, 7.74742216e-02f, 7.85829201e-02f, 8.24934170e-02f, -2.25927327e-02f, -2.44082306e-02f, -1.27357221e-03f, -4.70646657e-02f, -6.72055334e-02f, 1.19032925e-02f,
  6.93555102e-02f, 5.39908782e-02f, -2.77028214e-02f, -2.25706808e-02f, 2.26715822e-02f, 8.06890987e-03f, 1.68921910e-02f, -8.06181282e-02f, 6.14551231e-02f, 3.33661437e-02f,
  2.90167220e-02f, -1.76701450e-03f, 3.53971384e-02f, 9.05792415e-03f, 1.11250822e-02f, 6.78727254e-02f, 2.30730642e-02f, -4.84928314e-04f, 3.73438261e-02f, 1.17223710e-01f,
  1.35860443e-01f, 3.94778103e-02f, 8.08629673e-03f, -1.39514245e-02f, -6.30975664e-02f, 5.72120678e-03f, 1.01216093e-01f, -1.79909933e-02f, -3.75860408e-02f, 1.18829748e-02f,
  2.01974679e-02f, 7.09875822e-02f, 1.50353331e-02f, -5.43872416e-02f, 8.30928907e-02f, 3.78042087e-02f, 4.30344120e-02f, -6.79386854e-02f, -4.98080105e-02f, 3.59138213e-02f,
  7.85133317e-02f, -1.68111678e-02f, 5.99391758e-03f, -5.95439337e-02f, -2.41419896e-02f, 4.30771932e-02f, -1.65559389e-02f, 4.42643128e-02f, -5.25731444e-02f, 1.21926912e-03f,
  -8.98878127e-02f, -1.31510273e-01f, 8.99608880e-02f, -3.05740327e-01f, -1.39792254e-02f, -1.60857782e-01f, -2.87515730e-01f, -1.56766877e-01f, -2.34973058e-01f, -2.60409098e-02f,
  -8.86876956e-02f, -5.13714030e-02f, -1.54687330e-01f, -2.93703407e-01f, -3.30809578e-02f, -4.11805883e-02f, -2.05699697e-01f, 1.35805216e-02f, -5.59488423e-02f, -1.70378625e-01f,
  -1.41918799e-02f, -2.76957572e-01f, -5.15383109e-02f, -9.62637272e-03f, -8.00604075e-02f, 8.55381638e-02f, 9.92140993e-02f, 6.95660934e-02f, 1.20043837e-01f, 1.06755354e-01f,
  1.24929287e-02f, -1.14052214e-01f, -1.57908723e-02f, 3.15608047e-02f, -1.92846321e-02f, -5.11282647e-04f, 2.28300262e-02f, 3.29723917e-02f, 2.44864300e-02f, -1.69595645e-03f,
  7.64786229e-02f, 3.61383334e-02f, -1.42471661e-04f, -3.30911316e-02f, -4.78171594e-02f, 2.39750892e-02f, 6.74913824e-03f, 6.79099709e-02f, 1.59983244e-02f, -1.83674891e-03f,
  -8.29466879e-02f, 2.74303742e-02f, 1.64195951e-02f, 2.56333370e-02f, 2.01400388e-02f, -8.87538493e-02f, -2.39687096e-02f, 3.35596129e-02f, 1.68355759e-02f, -5.07358462e-02f,
  1.72351263e-02f, 2.65373252e-02f, -6.54389113e-02f, -3.79614793e-02f, -4.29801084e-02f, -1.92391090e-02f, 2.61672772e-02f, -1.26307728e-02f, 6.87772082e-03f, -2.56748335e-03f,
  1.63788290e-03f, 1.75545681e-02f, -6.21733395e-03f, -4.30863276e-02f, -2.09501181e-02f, 8.93912278e-03f, -1.84632407e-03f, -4.77335230e-02f, 4.76336256e-02f, 4.66157570e-02f,
  4.35766540e-02f, -7.40731275e-03f, 3.93810077e-03f, 9.98127088e-02f, -8.04187171e-03f, 3.65180112e-02f, -1.59666799e-02f, -5.11041880e-02f, -5.92914149e-02f, 4.53716628e-02f,
  -9.25103351e-02f, -5.12945354e-02f, -9.72465724e-02f, 1.28929326e-02f, 4.47923094e-02f, 3.81292887e-02f, 4.35187966e-02f, -8.19900781e-02f, 4.14862521e-02f, -1.07431300e-01f,
  -4.17942181e-03f, 7.42464652e-03f, 8.35105870e-03f, 1.53260287e-02f, 7.36902058e-02f, 2.69620642e-02f, -3.00044715e-02f, 8.38043243e-02f, -1.24002006e-02f, 7.55846277e-02f,
  5.30234203e-02f, 2.41589220e-03f, -9.53840278e-03f, 1.35459881e-02f, -3.33316135e-03f, 1.93784782e-03f, 3.04733645e-02f, 6.86904788e-02f, 8.11236203e-02f, 3.59421559e-02f,
  2.84786046e-01f, 3.77643071e-02f, 1.70220003e-01f, 1.19161606e-02f, -2.62788504e-01f, 7.82011971e-02f, 8.86448398e-02f, -2.40135252e-01f, 8.54486823e-02f, -9.95986834e-02f,
  -1.55962691e-01f, 3.59283507e-01f, -3.27645242e-02f, -2.28427704e-02f, 2.41148859e-01f, 9.35356393e-02f, 1.60761960e-02f, 1.74459875e-01f, -1.33841066e-02f, -5.48264086e-02f,
  9.00020357e-03f, -1.95170954e-01f, -7.86179677e-02f, -2.01491863e-01f, -1.78545848e-01f, -5.36628887e-02f, -1.67578280e-01f, -1.15127817e-01f, -5.81439137e-02f, 8.34304001e-03f,
  -4.04071808e-02f, -9.43359733e-02f, -5.43222241e-02f, 3.87841277e-02f, -7.35084414e-02f, -2.08917372e-02f, 1.22586757e-01f, 4.61043753e-02f, 4.06919010e-02f, -4.92514111e-02f,
  1.17802247e-01f, -1.31354202e-02f, 2.20293831e-02f, -6.94034100e-02f, -9.44524109e-02f, 1.21353483e-02f, 9.51478258e-03f, 8.50608572e-03f, 5.00870449e-03f, 5.12824543e-02f,
  -2.88221184e-02f, -2.00609453e-02f, 1.16160087e-01f, 1.26325294e-01f, 2.17837989e-02f, 5.57561442e-02f, 8.30779746e-02f, 1.09143294e-01f, 5.62482700e-03f, 9.93583631e-03f,
  -6.34208769e-02f, -7.58532062e-03f, -6.93323463e-02f, -1.22244498e-02f, -7.60689005e-02f, -3.28154564e-02f, 3.13722268e-02f, -1.44570237e-02f, -2.21860390e-02f, -2.19558901e-03f,
  1.61069594e-02f, 1.86820980e-02f, 1.35851232e-02f, 8.12624618e-02f, 1.84579508e-03f, -4.04091924e-02f, 5.31005822e-02f, 3.84417064e-02f, -1.95869356e-02f, -2.49779504e-02f,
  -2.20783912e-02f, 2.93184910e-02f, -5.85823022e-02f, -2.65027322e-02f, -5.66366650e-02f, 1.51433535e-02f, -5.64749315e-02f, 1.84749551e-02f, -4.22959812e-02f, 3.42126116e-02f,
  4.56857570e-02f, 5.70454169e-03f, -5.19286059e-02f, -3.14688347e-02f, 6.65913969e-02f, -7.26256520e-02f, 2.73797698e-02f, -1.82825141e-02f, 1.72867663e-02f, 1.53495828e-02f,
  -9.08193737e-02f, 3.56362052e-02f, 3.89485178e-03f, 1.10841431e-02f, 5.68592083e-03f, 5.64592071e-02f, 4.41276729e-02f, 3.55496481e-02f, -8.93533789e-03f, -1.24064004e-02f,
  -2.73537487e-02f, 5.38932867e-02f, -2.53559090e-02f, -3.91331539e-02f, 5.22403494e-02f, 3.11895926e-02f, -1.08589139e-02f, 3.28615494e-02f, 3.16994600e-02f, 5.07001467e-02f,
  -9.05230567e-02f, 1.33207411e-01f, -2.14327082e-01f, -5.34951352e-02f, 6.20754715e-03f, 1.26454294e-01f, 1.28745630e-01f, -1.08393572e-01f, -1.12726793e-01f, 1.39309883e-01f,
  1.17844380e-01f, -3.23416404e-02f, 1.93110362e-01f, -1.46647751e-01f, -2.62413442e-01f, 4.17048223e-02f, -8.17020088e-02f, 9.26200002e-02f, -1.19941838e-01f, 6.36915341e-02f,
  -1.36615381e-01f, 1.44884512e-01f, -1.86627269e-01f, -1.74502619e-02f, -6.68698177e-02f, -7.18993172e-02f, 1.54219344e-01f, 1.12983555e-01f, -2.31461064e-03f, -1.84002388e-02f,
  -3.97838764e-02f, 5.04964814e-02f, -7.10868761e-02f, 1.09683862e-02f, -8.93020332e-02f, 3.46097387e-02f, 3.97025384e-02f, 5.06086089e-02f, 2.59757005e-02f, 6.88576773e-02f,
  8.84332974e-03f, -1.20740354e-01f, -7.24827871e-02f, 3.59289460e-02f, -6.93057152e-03f, -1.35740176e-01f, -3.41312704e-03f, -6.39162213e-02f, -2.66969036e-02f, -1.01713605e-01f,
  -6.45718873e-02f, -1.31102949e-01f, 3.09559964e-02f, 3.89627414e-03f, 2.28404887e-02f, -3.31065208e-02f, -6.07713088e-02f, -3.84670645e-02f, -6.08244836e-02f, -2.82405205e-02f,
  4.08049487e-02f, -3.28434929e-02f, 6.14783950e-02f, -7.34566450e-02f, 1.06541656e-01f, 2.61145514e-02f, 3.19753177e-02f, -2.92996094e-02f, -6.71932055e-03f, -3.48379090e-02f,
  -4.03672755e-02f, 4.13559563e-02f, -1.35672139e-02f, -7.88778216e-02f, -2.74822358e-02f, -5.35166776e-03f, -1.53541574e-02f, 1.80917084e-02f, -6.28654808e-02f, -4.86478359e-02f,
  7.13410825e-02f, 4.08369116e-03f, 1.02469632e-02f, -8.05296749e-02f, 1.14221945e-02f, -6.68108538e-02f, -3.38029712e-02f, -5.80382496e-02f, -2.36157458e-02f, 1.71181932e-02f,
  1.53007224e-01f, 1.69680446e-01f, 4.77114916e-02f, -8.52018967e-03f, 1.12130105e-01f, -3.41899469e-02f, -6.72479495e-02f, -1.94756631e-02f, 5.76792634e-04f, -8.98991153e-03f,
  5.49914576e-02f, 7.65212476e-02f, 4.91481014e-02f, -1.04128784e-02f, -1.81462783e-02f, 2.98463050e-02f, 1.10614707e-03f, -4.91434000e-02f, 9.19322446e-02f, 1.81326568e-02f,
  -3.26303467e-02f, 7.63664246e-02f, -5.68172336e-03f, -5.58668748e-02f, -2.75061559e-02f, 2.61003766e-02f, 9.13389726e-04f, 1.09399408e-02f, -1.48195389e-03f, 2.38701645e-02f,
  -6.93825781e-02f, -7.19357133e-02f, 1.77325010e-01f, -8.81563798e-02f, 6.48463741e-02f, -7.03678802e-02f, -1.40623555e-01f, 1.00665733e-01f, 6.22719377e-02f, -2.17724824e-03f,
  -4.09569107e-02f, 7.88341556e-03f, -3.84174325e-02f, -2.86479294e-01f, -2.11295262e-01f, -1.44599810e-01f, -1.70619175e-01f, -7.87479728e-02f, 5.38250729e-02f, 9.30810273e-02f,
  -3.99925448e-02f, -3.10371459e-01f, -1.77658960e-01f, -1.03058755e-01f, 1.46185040e-01f, 2.17436776e-01f, -9.31321234e-02f, 6.35859594e-02f, -1.49612531e-01f, -1.65584400e-01f,
  -4.58208099e-03f, 9.37272329e-03f, 1.21596389e-01f, -8.03190395e-02f, -1.53585831e-02f, 4.12121229e-02f, 7.16448352e-02f, -2.35737301e-02f, 1.06416047e-01f, -3.37050706e-02f,
  -4.80501354e-02f, 2.70270295e-02f, -7.54817724e-02f, -7.13792592e-02f, -3.18814218e-02f, -5.78964911e-02f, 6.87257573e-02f, 1.94847938e-02f, 8.42074081e-02f, -7.58193657e-02f,
  -6.75224583e-05f, -1.10749193e-02f, 3.81321162e-02f, 6.58324212e-02f, 3.44106480e-02f, 2.97515132e-02f, 2.38468833e-02f, 4.26098071e-02f, -1.14461454e-02f, 7.52171651e-02f,
  -6.93821236e-02f, 8.87949541e-02f, -8.69685113e-02f, 2.27630660e-02f, 3.99273122e-04f, -4.35162820e-02f, -4.11826111e-02f, -5.53025305e-02f, 6.91336468e-02f, 7.86268804e-03f,
  2.01393981e-02f, -7.32359104e-03f, -2.61309352e-02f, -2.80179344e-02f, -1.65897422e-02f, 1.28075061e-02f, 4.50263396e-02f, -3.76771167e-02f, 4.96351644e-02f, -1.23232920e-02f,
  -7.01251402e-02f, 3.20357247e-03f, -4.84256493e-03f, -5.37128374e-02f, -9.56560969e-02f, 3.50494087e-02f, -4.19552848e-02f, 1.05350055e-02f, 9.12464224e-03f, 2.83207302e-03f,
  -2.12229323e-02f, -5.66850044e-02f, -1.41475564e-02f, -5.34787253e-02f, -3.63754388e-03f, -5.85107729e-02f, -2.92447321e-02f, 1.59685053e-02f, 4.84268330e-02f, 2.94144312e-03f,
  -4.23347019e-02f, 1.94698367e-02f, 6.80589527e-02f, 3.91410030e-02f, 5.29580750e-02f, 3.00885402e-02f, 3.46697010e-02f, 9.03052986e-02f, -5.27750747e-03f, 5.67199988e-03f,
  8.07261840e-02f, -4.39976379e-02f, 6.35101125e-02f, 5.41423075e-02f, -3.27230357e-02f, 1.91531293e-02f, 3.77893969e-02f, 1.48950676e-02f, 3.46515626e-02f, -3.67633924e-02f,
  1.75604343e-01f, -1.54162750e-01f, -8.97187218e-02f, 1.07942373e-01f, 1.39631763e-01f, -1.37445793e-01f, 1.18428007e-01f, 7.53861070e-02f, -1.59519449e-01f, -8.19258913e-02f,
  1.03586949e-01f, -1.18891872e-01f, 1.99383702e-02f, -5.07018417e-02f, -1.93956867e-01f, -2.14664117e-01f, -1.39182970e-01f, 3.32730338e-02f, -4.54912819e-02f, 8.02055597e-02f,
  2.16639601e-02f, 5.34129739e-02f, -8.76292810e-02f, 8.77435952e-02f, 1.51216567e-01f, 1.67223245e-01f, 1.84859350e-01f, 1.05388381e-01f, -2.78319977e-02f, 1.81726664e-02f,
  -1.08395010e-01f, 3.29226926e-02f, 2.88338382e-02f, -7.66728967e-02f, 8.17726739e-03f, 3.88026573e-02f, 4.24964428e-02f, 1.07651860e-01f, 1.34812994e-02f, -1.99157670e-02f,
  8.98004472e-02f, -3.64015764e-03f, 2.54401695e-02f, -3.62298973e-02f, 4.02848236e-02f, 9.51289851e-03f, -9.64143649e-02f, 1.06068850e-01f, 5.56638427e-02f, -4.25265096e-02f,
  1.38038062e-02f, -4.24164496e-02f, 6.62078038e-02f, -6.93847984e-02f, 1.93012748e-02f, 7.30768517e-02f, -6.21860586e-02f, 2.57390062e-03f, -6.95494637e-02f, -4.30564657e-02f,
  3.81246917e-02f, -4.19278396e-03f, 9.04531498e-03f, 6.45143986e-02f, -6.04308322e-02f, 8.29698816e-02f, -5.80946468e-02f, -2.92860856e-03f, -2.26324089e-02f, 1.14916991e-02f,
  2.82660592e-02f, 1.33439153e-02f, 2.59147640e-02f, -5.39001003e-02f, -1.00701645e-01f, 9.85043645e-02f, -4.29189354e-02f, 2.12206226e-02f, -5.23581505e-02f, -2.92871539e-02f,
  7.12675080e-02f, -8.92600939e-02f, -5.48233762e-02f, 5.88702038e-02f, 4.15589362e-02f, -3.98246683e-02f, -2.85119712e-02f, 1.35528548e-02f, 2.36462802e-02f, 7.55326301e-02f,
  -8.09972957e-02f, -1.85247689e-01f, -5.14900498e-02f, -1.09223993e-02f, -3.53950821e-02f, -8.38155299e-02f, -9.40963402e-02f, -2.81902812e-02f, -1.03654176e-01f, -5.37039787e-02f,
  -2.92223673e-02f, 9.56080779e-02f, 2.37827785e-02f, -4.88389097e-02f, 4.53802273e-02f, -9.58488286e-02f, 1.34697873e-02f, -6.75847977e-02f, 1.09505318e-02f, 2.00229557e-03f,
  4.63454090e-02f, 4.31415290e-02f, 1.23667321e-03f, 3.11447307e-02f, 4.82949466e-02f, 6.09512813e-02f, 1.88817084e-02f, -8.50427449e-02f, -4.91012679e-03f, 4.86709177e-03f,
  3.36791664e-01f, -1.88402887e-02f, 1.32419929e-01f, 2.39814609e-01f, 1.60317328e-02f, -1.11182034e-01f, -2.82074548e-02f, 5.47646731e-02f, 1.18003376e-01f, -7.98795670e-02f,
  2.77360156e-02f, 1.12405352e-01f, -2.29679734e-01f, 1.25658780e-01f, 6.05014488e-02f, -1.87594309e-01f, 2.16869816e-01f, 1.31857698e-03f, 8.41547828e-03f, 1.92887500e-01f,
  6.24493361e-02f, 1.30212903e-01f, -1.26358226e-03f, -5.96309230e-02f, 1.33062452e-01f, 7.55759478e-02f, 1.51667118e-01f, -7.42437225e-03f, 1.52413189e-01f, -5.68491630e-02f,
  2.23122034e-02f, -2.16984060e-02f, -3.42297070e-02f, 2.66909809e-03f, -2.77977344e-02f, 1.93650126e-02f, -1.32292015e-02f, 7.27894390e-03f, 6.80604801e-02f, -2.78026946e-02f,
  -9.50322449e-02f, 3.90764251e-02f, 2.41436018e-03f, 1.92377064e-02f, 8.24335888e-02f, -1.05365850e-02f, 4.97219972e-02f, 5.85187115e-02f, -4.85162577e-03f, 3.93965133e-02f,
  -9.77252331e-03f, -8.95971339e-03f, 5.23149893e-02f, -8.20709020e-02f, 6.42438978e-02f, -2.74237655e-02f, 2.51207035e-02f, 1.33837359e-02f, -1.02941934e-02f, 5.78529313e-02f,
  -3.95142324e-02f, 1.54380407e-02f, -2.54694503e-02f, -3.07168830e-02f, 1.54255498e-02f, 4.26894277e-02f, 2.95209419e-02f, 1.40104368e-02f, -4.11499143e-02f, -2.56832801e-02f,
  9.89181362e-03f, -2.36546658e-02f, 1.45358508e-02f, 5.14247222e-03f, 6.23909151e-03f, 4.59426045e-02f, -1.11912536e-02f, -6.48521855e-02f, -3.22860219e-02f, 3.37476358e-02f,
  -8.15322995e-02f, 9.08045396e-02f, 3.26342992e-02f, -2.95872390e-02f, -9.51787271e-03f, -4.57886681e-02f, 5.16501069e-02f, -4.66921329e-02f, 8.27471912e-03f, 6.01748452e-02f,
  -5.12482449e-02f, 7.69311488e-02f, -7.80909089e-03f, -9.45816115e-02f, -7.35201538e-02f, -7.38100633e-02f, 2.53388397e-02f, 1.09168842e-01f, 1.08234147e-02f, 7.30112568e-03f,
  -2.68084481e-02f, 4.42311540e-02f, -5.24161756e-02f, -8.17896519e-03f, 3.83193642e-02f, -7.95752481e-02f, 5.40416166e-02f, 1.22131333e-02f, 1.15664057e-01f, 2.42398195e-02f,
  6.53793439e-02f, -1.32487211e-02f, 4.88771908e-02f, 5.40655591e-02f, -1.51670808e-02f, -1.02749914e-01f, 5.28813601e-02f, -4.68800077e-03f, 1.61794794e-03f, -3.19779404e-02f,
  -2.57488787e-01f, -6.64155632e-02f, 2.25585103e-01f, -4.01222706e-02f, -2.65922517e-01f, -1.05788372e-02f, 1.07316576e-01f, -2.38171607e-01f, -2.36711204e-01f, -1.55169507e-02f,
  -7.67970532e-02f, 1.42362818e-01f, 1.25101656e-01f, 6.80724829e-02f, 1.39054149e-01f, 4.68055457e-02f, 1.69170857e-03f, 6.09870367e-02f, -1.39390826e-01f, -1.29278868e-01f,
  -6.29002824e-02f, -1.08384728e-01f, 1.88913479e-01f, -1.47121817e-01f, -1.04780860e-01f, -4.73665521e-02f, 1.33488337e-02f, 1.14975378e-01f, 1.27580106e-01f, 9.28923190e-02f,
  -1.42181382e-01f, -2.36853529e-02f, -3.44868004e-02f, 7.91334435e-02f, -1.00735642e-01f, 9.93277133e-03f, 1.26577958e-01f, 1.69975311e-01f, 8.97792354e-02f, 5.29651530e-02f,
  1.91009864e-02f, 2.34595282e-05f, -6.12555183e-02f, 5.26138507e-02f, -9.54433680e-02f, -4.19963561e-02f, -4.02511843e-02f, -3.77867185e-02f, 1.26820551e-02f, -1.64653473e-02f,
  7.66854435e-02f, -4.56415564e-02f, -5.55082150e-02f, -2.11618599e-02f, 4.45335135e-02f, 2.98201293e-02f, 1.00158229e-01f, 9.09456834e-02f, 7.96244144e-02f, -2.18431018e-02f,
  8.38751122e-02f, 3.71916704e-02f, 3.16405557e-02f, -1.59344506e-02f, -7.24397823e-02f, -7.89238792e-03f, 3.28437351e-02f, 1.11601740e-01f, -1.57669894e-02f, 2.26230193e-02f,
  -8.99491310e-02f, -4.56201583e-02f, -7.90045112e-02f, 4.45216633e-02f, 7.96445739e-03f, -3.05745490e-02f, 6.37631118e-02f, -3.03298067e-02f, -8.42461437e-02f, -4.63454127e-02f,
  6.68007955e-02f, -2.28022281e-02f, -1.12684183e-02f, 2.96701845e-02f, 2.96883415e-02f, -1.35498540e-02f, -3.19504552e-02f, -2.92214379e-02f, -7.79527909e-05f, -2.65874136e-02f,
  -1.84712812e-01f, -8.50663632e-02f, 1.30978264e-02f, -9.54599604e-02f, -4.80511226e-02f, -4.69045117e-02f, -1.30024739e-02f, -1.57619677e-02f, 1.43066999e-02f, -7.69596994e-02f,
  -4.93894145e-02f, 3.42794025e-04f, -4.26049680e-02f, -7.14959949e-02f, 8.60551372e-03f, -1.27402358e-02f, 4.72338982e-02f, -1.66363269e-02f, 9.73335188e-03f, -6.28078282e-02f,
  -3.75290564e-03f, 1.00488942e-02f, 9.63771157e-03f, -8.46487582e-02f, 4.31178249e-02f, -7.57441223e-02f, -2.39395387e-02f, 1.39867328e-02f, 1.40851885e-02f, 8.70739482e-03f,
  1.99173018e-01f, -2.42560372e-01f, -1.41671643e-01f, 2.45564565e-01f, -9.48844180e-02f, 1.36335328e-01f, 2.66705513e-01f, -1.93365589e-01f, 1.61376446e-01f, 1.08102690e-02f,
  2.13630110e-01f, 1.03979930e-01f, -8.48139673e-02f, 3.48574638e-01f, 2.49939993e-01f, 7.15078413e-02f, 2.95920372e-01f, 1.47103876e-01f, 1.46426484e-02f, -6.68443069e-02f,
  6.17568828e-02f, 6.37137145e-02f, 2.28458364e-02f, -1.79089621e-01f, 4.54306081e-02f, -1.28298059e-01f, -1.74465269e-01f, -1.71439633e-01f, 8.71260613e-02f, 1.07038766e-01f,
  1.71276890e-02f, -1.03330158e-01f, -7.93452859e-02f, 3.47691402e-02f, 4.99261320e-02f, 5.26127703e-02f, -2.84839440e-02f, 4.76907492e-02f, -2.70253532e-02f, 3.90456468e-02f,
  -3.05679310e-02f, -8.91174451e-02f, 5.03348261e-02f, 1.40153030e-02f, -8.03479832e-03f, 1.46588851e-02f, -2.54664421e-02f, 4.58659902e-02f, 2.09347531e-03f, 6.30832929e-03f,
  5.16571514e-02f, -2.84336172e-02f, -4.65832017e-02f, 5.69992652e-03f, 2.79382197e-03f, 2.71154549e-02f, 3.80051211e-02f, -3.58899273e-02f, 6.33575395e-02f, 5.11038229e-02f,
  1.45423757e-02f, -2.47905161e-02f, -7.62588680e-02f, 3.41202915e-02f, 1.73705015e-02f, 1.38299838e-02f, 5.30324429e-02f, 1.51963327e-02f, -6.70353621e-02f, -8.56492016e-03f,
  8.51595998e-02f, -2.77175419e-02f, 5.05130962e-02f, -7.11493194e-02f, 5.33366911e-02f, 5.51477559e-02f, 2.46346295e-02f, -2.19649710e-02f, 3.45042907e-02f, 4.26933318e-02f,
  2.22266205e-02f, -1.77309178e-02f, 3.06265466e-02f, -1.66238286e-02f, -2.65406948e-02f, -4.61243419e-03f, -5.41316047e-02f, -9.63437464e-03f, -3.14176790e-02f, 4.19857068e-04f,
  2.96172989e-03f, -1.78023174e-01f, 5.50463945e-02f, 7.81582594e-02f, 2.56152991e-02f, -7.46855438e-02f, 6.33597374e-02f, -3.12925391e-02f, -6.05953075e-02f, -6.84602857e-02f,
  -1.29248828e-01f, -2.16180217e-02f, -5.09500317e-02f, 5.97828627e-02f, 6.50407448e-02f, -2.44779587e-02f, -1.99391656e-02f, 1.90565474e-02f, 1.41290296e-02f, -2.21508890e-02f,
  -9.56107080e-02f, -1.67040732e-02f, 6.57101572e-02f, -9.99477040e-03f, 6.63947985e-02f, -7.33874599e-03f, -5.80248758e-02f, -3.19350399e-02f, 2.04736702e-02f, -5.04727699e-02f,
  2.11010184e-02f, 5.62808141e-02f, 6.80014640e-02f, 3.66758811e-03f, 2.76786268e-01f, 8.93417895e-02f, 9.74506214e-02f, 1.91618517e-01f, 4.23602790e-01f, -1.55240774e-01f,
  -1.27101734e-01f, -9.39196646e-02f, -1.34590477e-01f, -1.38415202e-01f, -1.25903457e-01f, -2.51262672e-02f, 3.28042880e-02f, 1.25937432e-01f, 2.82895148e-01f, -1.87757015e-01f,
  7.56865949e-04f, -1.06610611e-01f, -2.06569210e-01f, -9.85926837e-02f, -4.85042706e-02f, 1.80509202e-02f, -6.23867884e-02f, 4.43515442e-02f, -1.00608759e-01f, 1.24862619e-01f,
  -2.50752661e-02f, 1.38498634e-01f, -1.12834737e-01f, 4.13739458e-02f, 8.23958404e-03f, 9.41813439e-02f, -7.49343485e-02f, 1.17284611e-01f, 2.64874659e-02f, 3.76469679e-02f,
  -6.31784126e-02f, -7.09528178e-02f, 3.46541479e-02f, -2.49001198e-03f, 2.13713590e-02f, 3.31227761e-03f, 3.53551246e-02f, 1.01069517e-01f, -1.30734652e-01f, -7.50638247e-02f,
  1.73652396e-02f, -2.19574161e-02f, -1.90266222e-02f, -2.18052417e-02f, -9.04189348e-02f, 2.77566761e-02f, 2.35877689e-02f, 5.89022748e-02f, -1.53254792e-02f, 8.02615434e-02f,
  6.21466525e-02f, 1.67777702e-01f, -6.14751410e-03f, -1.14108091e-02f, 6.19721860e-02f, 2.17561536e-02f, -4.81559224e-02f, 1.01675903e-02f, 1.25627313e-02f, -8.30226243e-02f,
  -1.44592095e-02f, 5.88361658e-02f, 5.93133159e-02f, 3.56563106e-02f, 8.62929784e-03f, 2.89380886e-02f, -3.93399270e-03f, 4.05629463e-02f, 5.76703250e-02f, -2.23838966e-02f,
  6.57545344e-04f, -3.78089249e-02f, -3.32961828e-02f, 3.63865569e-02f, -2.75083613e-02f, 2.49960963e-02f, -1.82371028e-02f, -5.13212942e-02f, -1.31810848e-02f, -4.13125120e-02f,
  1.16854064e-01f, 1.88600868e-01f, -5.58659360e-02f, -7.89192840e-02f, -7.51078725e-02f, -8.88515413e-02f, -3.20750512e-02f, -3.53807248e-02f, 2.76546273e-02f, 1.70391481e-02f,
  3.75452265e-02f, -1.51963765e-02f, -1.39713625e-03f, -6.06246963e-02f, -8.48337635e-03f, 8.12426805e-02f, -8.24910775e-02f, 6.48145378e-02f, 3.96950282e-02f, -1.99712068e-02f,
  -7.86200240e-02f, 2.89920848e-02f, -6.73784763e-02f, 6.55546039e-02f, -1.66699775e-02f, -5.78199774e-02f, 7.55919591e-02f, -5.72270043e-02f, 1.97905879e-02f, 2.65045706e-02f,
  4.21486378e-01f, 1.53892770e-01f, 1.54125199e-01f, 2.01351807e-01f, -1.87788904e-02f, 1.86298653e-01f, 1.21951044e-01f, -1.60394926e-02f, 4.52234447e-02f, -6.42161965e-02f,
  -9.51633453e-02f, 1.98712513e-01f, -1.54820830e-01f, 1.19489975e-01f, 2.40401104e-01f, -2.29434408e-02f, 2.39179298e-01f, 4.04822901e-02f, 7.43616419e-03f, 1.23880401e-01f,
  9.37487260e-02f, -1.16136134e-01f, 8.18807259e-02f, -1.43022031e-01f, 1.03870578e-01f, -2.11221585e-03f, -2.39207566e-01f, -7.64914379e-02f, 6.38393089e-02f, 6.01478741e-02f,
  -1.96401067e-02f, 1.22676522e-03f, 2.13980973e-02f, 6.81939255e-03f, -3.61247137e-02f, -4.91958298e-02f, 3.26952408e-03f, -5.98854236e-02f, 5.23174368e-02f, 1.37180723e-02f,
  -1.34338066e-02f, 4.93413322e-02f, 6.35601953e-02f, 1.38026513e-02f, 2.54686009e-02f, 3.47840041e-02f, 1.20220989e-01f, 3.19626555e-02f, -1.04234330e-02f, 7.16882125e-02f,
  6.00839518e-02f, 9.55177546e-02f, -4.35678568e-03f, 5.21846525e-02f, -2.43183617e-02f, 3.96194458e-02f, 1.91079471e-02f, 1.58391730e-03f, 2.93628313e-02f, -9.15404130e-03f,
  1.24498401e-02f, -5.00436034e-03f, 2.77961548e-02f, 1.57458615e-02f, 7.33066723e-03f, -2.15712097e-02f, -2.90926248e-02f, 5.03568240e-02f, 1.21433875e-02f, -2.92596929e-02f,
  4.75675017e-02f, 4.85655516e-02f, -7.84077719e-02f, -1.44057814e-02f, 3.19907591e-02f, -3.92038897e-02f, 2.57151350e-02f, 9.20455158e-03f, 1.10850483e-02f, 5.00688627e-02f,
  -8.10954571e-02f, 2.06540823e-02f, -5.51586114e-02f, -6.32158667e-03f, -3.12383194e-02f, -8.53208825e-02f, 1.14478562e-02f, 4.27119955e-02f, -3.40750813e-02f, 3.42600457e-02f,
  -3.00379954e-02f, -2.77948622e-02f, -7.57988244e-02f, -2.89484821e-02f, -3.51825245e-02f, 9.38826501e-02f, 6.35938272e-02f, 8.99334550e-02f, 3.31070274e-02f, -4.33105715e-02f,
  3.03501226e-02f, 1.08542116e-02f, -5.04615940e-02f, -6.85362443e-02f, -1.74562726e-02f, -8.49427059e-02f, -9.35196280e-02f, 2.84184106e-02f, 2.67999135e-02f, -1.52950268e-02f,
  2.70843599e-02f, 1.88717898e-02f, 5.79362698e-02f, 4.13777381e-02f, -9.91995167e-03f, -1.34782409e-02f, 1.71109196e-02f, -8.01047310e-02f, -3.87241086e-03f, -1.43867899e-02f,
  2.50284582e-01f, -8.60612020e-02f, 1.87174812e-01f, -5.32283336e-02f, -1.17908031e-01f, -1.28300279e-01f, 2.41217017e-03f, -1.50465354e-01f, -1.27094775e-01f, -6.60504326e-02f,
  -5.89004420e-02f, 6.80042058e-02f, 1.58257559e-01f, -2.53648818e-01f, -1.60759196e-01f, -1.10094145e-01f, -1.21113598e-01f, -7.45764673e-02f, -1.05558068e-01f, 2.04399452e-02f,
  -9.22600999e-02f, -2.31734306e-01f, 2.97085065e-02f, -1.42940328e-01f, -1.60296611e-03f, 5.88408038e-02f, -1.09721012e-02f, 8.40968266e-03f, -1.65715784e-01f, -6.69274330e-02f,
  9.84994788e-03f, -1.82913113e-02f, 6.55538216e-02f, 2.98373047e-02f, 4.89297807e-02f, 1.26345277e-01f, 8.32318962e-02f, 5.64769991e-02f, 1.14810038e-02f, -9.46142226e-02f,
  6.40354604e-02f, -8.89830068e-02f, -6.88834935e-02f, 6.71635568e-02f, 8.18258431e-03f, -4.16030474e-02f, -8.58013183e-02f, 3.56901102e-02f, 1.69698242e-03f, 5.60769960e-02f,
  2.07428019e-02f, -1.92977339e-02f, -4.77073416e-02f, 2.35419180e-02f, 2.48984201e-03f, -1.49746105e-01f, -5.06471507e-02f, 3.96620259e-02f, -8.73867571e-02f, -7.24957362e-02f,
  -3.58642973e-02f, -9.53779742e-03f, 7.80754685e-02f, -1.09875361e-02f, -7.04320222e-02f, -3.17169018e-02f, -9.90912691e-02f, 1.98835526e-02f, -9.91543941e-03f, -5.71641363e-02f,
  -1.07169442e-01f, 7.33404141e-03f, -8.07465687e-02f, 2.26159263e-02f, 3.55157293e-02f, 6.39301762e-02f, 9.02350545e-02f, -4.06942330e-02f, 3.54311280e-02f, -4.26165611e-02f,
  -4.36613858e-02f, 3.27999853e-02f, -1.33536803e-02f, 7.23415241e-02f, -8.42675716e-02f, 2.54242010e-02f, -1.01251259e-01f, 1.09478896e-02f, -2.10425705e-02f, -1.56437121e-02f,
  7.76582025e-03f, 4.54990678e-02f, -5.28636873e-02f, 2.52529029e-02f, 2.76788920e-02f, 7.18364269e-02f, -1.15615632e-02f, 4.40557487e-02f, -6.35756478e-02f, -4.23110463e-02f,
  9.78818461e-02f, -3.40525582e-02f, 2.52639153e-03f, -2.18724944e-02f, -1.14673115e-01f, -3.68314941e-04f, -6.94370344e-02f, -3.01493239e-02f, -1.54906601e-01f, -4.18446846e-02f,
  8.89689773e-02f, -7.61587918e-02f, 1.43671697e-02f, -5.62145859e-02f, 6.15273975e-03f, 8.44702274e-02f, 2.54661567e-03f, 2.55104881e-02f, -6.75156042e-02f, -2.86174882e-02f,
  -1.21359758e-01f, -5.08407727e-02f, -9.47503969e-02f, -3.80244143e-02f, 9.00738388e-02f, -1.28363922e-01f, -3.07590783e-01f, 1.34387061e-01f, -2.79133052e-01f, -1.83984302e-02f,
  8.81533548e-02f, -1.16106763e-01f, -1.24086909e-01f, 3.31657045e-02f, -1.19972378e-01f, -1.76188290e-01f, 1.00282058e-01f, -8.64811614e-03f, -2.83406582e-02f, 5.54420277e-02f,
  6.34288788e-03f, 1.86966971e-01f, 1.66976377e-02f, 1.82691529e-01f, 4.87535298e-02f, 7.26201683e-02f, 2.84802824e-01f, -4.08507809e-02f, 2.36442640e-01f, 5.06875515e-02f,
  -8.34771246e-02f, -8.92392993e-02f, -1.13222666e-01f, -5.93519509e-02f, 1.37200400e-01f, -1.76158212e-02f, -4.63877581e-02f, 2.91357413e-02f, -5.88623062e-02f, 3.22397314e-02f,
  -3.47171612e-02f, -2.49648560e-02f, 4.77479324e-02f, -1.47330342e-02f, 4.25151326e-02f, -7.62176979e-03f, -5.26146665e-02f, 3.50889675e-02f, -5.41388169e-02f, -9.67027328e-04f,
  -5.80491275e-02f, 1.76930819e-02f, 5.00984229e-02f, -1.90694481e-02f, -9.32353288e-02f, 3.45544331e-02f, -2.48914659e-02f, -2.97164191e-02f, 9.82904807e-02f, 6.38931841e-02f,
  7.37422407e-02f, 5.58810402e-03f, 2.40638945e-03f, -5.90256937e-02f, -2.58871652e-02f, 3.22607271e-02f, -5.65431416e-02f, 3.26878317e-02f, -2.05164999e-02f, 4.29246277e-02f,
  8.36713538e-02f, 5.60334437e-02f, 1.45225562e-02f, -1.49580156e-02f, -4.35970686e-02f, 6.04642108e-02f, 8.25034305e-02f, -3.36218290e-02f, 1.73900891e-02f, -4.60120067e-02f,
  1.90615235e-03f, 5.77037446e-02f, -5.39919212e-02f, 1.06603205e-01f, 5.19468784e-02f, -5.71574904e-02f, 3.92069668e-02f, -2.43467768e-03f, -2.86952127e-03f, -3.62810306e-02f,
  7.21852779e-02f, 1.63537458e-01f, -1.77886896e-02f, -4.46029156e-02f, 7.88859744e-03f, 5.64105529e-03f, -6.16958588e-02f, 1.01994634e-01f, 6.91921776e-03f, 3.44894975e-02f,
  9.39398110e-02f, -2.00908333e-02f, 9.50678587e-02f, 3.96649539e-02f, 4.91475984e-02f, 1.20810596e-02f, 6.67574480e-02f, 2.88193617e-02f, 6.48366436e-02f, 2.33044103e-02f,
  1.28449529e-01f, 8.81997421e-02f, -5.49718142e-02f, 1.41879180e-02f, 1.42693505e-01f, 6.94958493e-02f, 8.36524367e-02f, -1.25566926e-02f, 6.07926063e-02f, -1.38454447e-02f,
  3.11185747e-01f, -3.33000749e-01f, -8.56664851e-02f, 2.15880945e-01f, -1.07412770e-01f, 1.56699523e-01f, 6.57498762e-02f, 3.03236349e-03f, 2.34726146e-01f, -1.86738297e-01f,
  1.13766462e-01f, -6.06171787e-04f, 1.52461426e-02f, 7.26883635e-02f, 2.87158579e-01f, 1.48661062e-01f, 1.99058518e-01f, 5.49975485e-02f, 1.07915662e-01f, -8.08557495e-03f,
  8.71848017e-02f, 1.48494929e-01f, -1.25588952e-02f, -9.11049992e-02f, -1.77612260e-01f, -1.03606299e-01f, -7.15367263e-03f, -2.70159375e-02f, -9.57750008e-02f, -6.50168490e-03f,
  -3.36971395e-02f, -8.44921544e-02f, -4.00585644e-02f, -2.33744457e-03f, 1.10620605e-02f, -9.82331410e-02f, -4.54556309e-02f, -5.54080009e-02f, 5.79423718e-02f, -3.32733686e-03f,
  2.66491808e-02f, -2.68373713e-02f, -2.18326263e-02f, 4.40957509e-02f, 3.71884555e-02f, -4.64414246e-02f, -6.97404221e-02f, -2.14273352e-02f, -2.53745485e-02f, -2.72116400e-02f,
  -2.84899175e-02f, -8.61252844e-02f, 2.76044421e-02f, -7.02443868e-02f, 4.06160131e-02f, -1.05192233e-02f, 7.34486058e-03f, -1.79127902e-02f, 7.17955530e-02f, 4.24180552e-03f,
  -1.30322622e-02f, -2.50117388e-02f, -7.94436503e-03f, -2.91073192e-02f, 9.94349271e-03f, 5.57124726e-02f, 1.00142499e-02f, -3.22538279e-02f, -2.59821508e-02f, -2.06212290e-02f,
  2.15921346e-02f, -1.83374749e-03f, 6.00434020e-02f, -4.75360900e-02f, 2.49244203e-03f, -2.15601679e-02f, -4.63724732e-02f, -3.26733366e-02f, 5.47917448e-02f, -3.57435532e-02f,
  -1.18089346e-02f, 3.13283652e-02f, -5.38242422e-03f, -1.21618556e-02f, -1.13085024e-02f, 1.23100551e-02f, 1.23387892e-02f, 6.58356398e-03f, -5.31576062e-03f, 1.04529252e-02f,
  -5.81177585e-02f, 1.22447200e-02f, 5.86830825e-02f, -3.94695513e-02f, 9.00349393e-03f, 2.01829802e-02f, -1.81426550e-03f, 7.34773092e-03f, 3.14797238e-02f, 2.30788812e-02f,
  -5.53407297e-02f, 1.09415120e-02f, 7.34277815e-03f, 4.20254990e-02f, -1.82176568e-02f, 2.17463057e-02f, -1.33949248e-02f, 2.46015359e-02f, 6.13972358e-02f, 1.04800910e-02f,
  -9.36843902e-02f, 2.06132680e-02f, 6.42550038e-03f, 1.02745043e-02f, -2.65851375e-02f, -6.74258126e-03f, -2.94000208e-02f, 8.68253130e-03f, 4.86429967e-02f, 5.68632968e-03f,
  -3.73809755e-01f, 2.86125571e-01f, -5.84413260e-02f, 1.98260099e-01f, -1.45477086e-01f, -7.15674013e-02f, -7.82240033e-02f, 1.36061892e-01f, 1.82501256e-01f, 1.57076910e-01f,
  -2.44231094e-02f, 1.01694249e-01f, -1.09677799e-01f, 9.67647210e-02f, -2.39635259e-01f, 1.81902602e-01f, -5.21170571e-02f, -3.67784053e-02f, 1.85765788e-01f, -4.50464040e-02f,
  1.02407984e-01f, 4.20964062e-02f, -9.65505987e-02f, 1.06689684e-01f, -1.10324159e-01f, -3.74877080e-02f, -2.00342685e-01f, 4.03703004e-02f, -1.03156611e-01f, -4.91635175e-03f,
  6.63884431e-02f, 9.61050168e-02f, -2.26445477e-02f, -8.37031081e-02f, -1.02854364e-01f, -9.61444452e-02f, -3.74072522e-04f, 1.98503304e-02f, 8.18421394e-02f, -4.31857351e-03f,
  1.20850168e-02f, -7.95583334e-03f, 4.53601815e-02f, 3.28432769e-02f, 3.50960158e-02f, 1.43216597e-02f, 4.16505747e-02f, -7.58636510e-03f, 1.15360662e-01f, -3.21165770e-02f,
  2.06787698e-02f, 8.10893029e-02f, 2.77871024e-02f, 1.57452598e-02f, -4.07341383e-02f, 3.68150920e-02f, -7.10265152e-03f, -2.72394307e-02f, 6.27873838e-02f, 2.56050564e-02f,
  -9.76228639e-02f, -5.00151794e-03f, 6.65885163e-03f, -4.42334302e-02f, 7.66214430e-02f, 1.15584778e-02f, -1.63736884e-02f, -7.32100531e-02f, -3.25882831e-03f, -5.16827069e-02f,
  -7.39551783e-02f, 1.69043895e-02f, 4.94743139e-02f, -1.77161191e-02f, -5.55137992e-02f, -1.80319808e-02f, -7.74173960e-02f, -1.86223874e-03f, 2.77198255e-02f, -5.74604720e-02f,
  6.76605999e-02f, 7.71745145e-02f, -8.10675621e-02f, -2.45993715e-02f, 7.01202601e-02f, -9.40571725e-02f, -2.50110198e-02f, 5.37739247e-02f, -8.11637472e-03f, -3.27731273e-03f,
  -5.61520010e-02f, 2.87565459e-02f, -4.99040261e-02f, 8.14537928e-02f, -2.10122801e-02f, 1.60205476e-02f, 9.03709978e-02f, -6.15232438e-02f, -4.95213829e-02f, 4.64664865e-03f,
  -7.50224805e-03f, -4.47496921e-02f, -2.06251889e-02f, -1.52349155e-02f, 1.16081033e-02f, -3.10797766e-02f, -1.24677550e-02f, 1.93338916e-02f, -2.77146213e-02f, -1.40702701e-03f,
  -4.16962057e-02f, -7.15442970e-02f, 2.36070044e-02f, 3.00230589e-02f, -1.10076414e-02f, -6.65236786e-02f, -4.18592952e-02f, 3.55035476e-02f, -3.51217873e-02f, -3.15176845e-02f,
  -6.26676455e-02f, -1.82215735e-01f, 2.26544842e-01f, -2.03358419e-02f, 2.47323643e-02f, 1.62014171e-01f, -1.28353592e-02f, 1.32856797e-02f, -1.54205523e-02f, -1.36111826e-01f,
  9.64689255e-03f, 5.66915274e-02f, -8.66231099e-02f, 7.49711096e-02f, 1.13041513e-02f, -9.39536002e-03f, -7.79416785e-02f, -8.00893903e-02f, -1.35072358e-02f, -1.49726972e-01f,
  8.78422707e-02f, -1.69628739e-01f, 1.49698287e-01f, 8.06057900e-02f, 4.62356135e-02f, 1.46907732e-01f, -1.48361266e-01f, 1.24585912e-01f, 2.70653181e-02f, 3.82627696e-02f,
  -1.08883053e-03f, 2.20392216e-02f, -1.47860739e-02f, 1.82697941e-02f, 5.50708808e-02f, 6.62250072e-02f, -4.78497744e-02f, 1.59326084e-02f, 7.30599612e-02f, 3.97816719e-03f,
  4.27561104e-02f, 4.75209989e-02f, 8.00946578e-02f, 2.06062924e-02f, -3.47983763e-02f, -5.41841204e-04f, 5.73749989e-02f, 8.04339349e-03f, 4.13643904e-02f, 7.85219446e-02f,
  -2.01632045e-02f, 3.48661020e-02f, 9.12810937e-02f, -4.15867120e-02f, 5.34979142e-02f, 5.13076484e-02f, 1.36773614e-03f, -6.33767527e-03f, -2.32400955e-03f, 9.44141205e-03f,
  7.59503767e-02f, 2.20682304e-02f, -3.20035070e-02f, -2.54883654e-02f, 2.50307024e-02f, -3.23049128e-02f, -7.53977373e-02f, -1.58816129e-02f, 6.61922991e-02f, -4.91448082e-02f,
  -7.04001188e-02f, 1.67199895e-02f, -7.34646842e-02f, -4.06675711e-02f, 1.00931926e-02f, -6.35822564e-02f, 4.51999642e-02f, -5.87296188e-02f, 1.84925534e-02f, -3.06474175e-02f,
  -5.60495593e-02f, 2.89058853e-02f, -4.26685512e-02f, 4.49934751e-02f, -1.88419297e-02f, -5.68742007e-02f, 1.59011148e-02f, -5.54967411e-02f, -4.20860499e-02f, 1.04615279e-02f,
  -2.98682511e-01f, -2.42459297e-01f, 5.80810122e-02f, 3.52046564e-02f, -3.66505161e-02f, -4.44443226e-02f, 4.32854444e-02f, -6.02860842e-03f, -3.30929384e-02f, -1.20946646e-01f,
  -3.42517160e-02f, -4.83521745e-02f, -2.41511222e-02f, -7.23624751e-02f, 5.14075495e-02f, 3.54007669e-02f, -9.63155851e-02f, -1.25009045e-01f, -1.46728214e-02f, 6.29583597e-02f,
  3.08005735e-02f, -1.11217462e-02f, 6.82488009e-02f, -5.33709265e-02f, -5.14676310e-02f, -8.10851827e-02f, -1.55943427e-02f, 3.21119949e-02f, 1.59977619e-02f, 4.60002758e-02f,
  -3.42923760e-01f, 7.32386783e-02f, -1.39207691e-01f, -1.56318143e-01f, -7.96660855e-02f, -1.27353877e-01f, -1.01032481e-02f, -3.53193916e-02f, -3.12450051e-01f, 2.06737056e-01f,
  5.51168881e-02f, 5.72352521e-02f, 1.34361938e-01f, 9.68845654e-03f, -2.14377135e-01f, 6.52146488e-02f, -9.22064576e-03f, 2.24437695e-02f, -5.67960851e-02f, -3.57988104e-02f,
  -1.59456283e-01f, -1.75578948e-02f, -2.16504317e-02f, 1.81536466e-01f, -9.57715437e-02f, -3.38144265e-02f, 2.02862471e-01f, 7.25085512e-02f, 1.33671775e-01f, 6.56861886e-02f,
  -1.16326839e-01f, -3.79843339e-02f, -2.39359345e-02f, 8.42560381e-02f, -1.15920808e-02f, 6.48678392e-02f, 1.17863536e-01f, 9.82307717e-02f, -4.02431451e-02f, 4.15662527e-02f,
  1.48224011e-02f, 3.82203199e-02f, -1.21231889e-02f, 3.19472235e-03f, 4.26688567e-02f, -7.43930563e-02f, -1.38675086e-02f, 2.08303481e-02f, -2.28068698e-02f, -5.75126335e-02f,
  -6.82750493e-02f, 5.90639412e-02f, -7.41225183e-02f, 8.42408091e-02f, 1.33302376e-01f, -1.21510141e-02f, 4.33724001e-02f, 2.79954262e-02f, 8.30753706e-03f, 4.39308733e-02f,
  5.93547784e-02f, 8.04887861e-02f, -7.10427249e-03f, -6.25232011e-02f, -7.30370311e-03f, -4.94681001e-02f, 6.77710325e-02f, 5.96937947e-02f, 1.50146065e-02f, -1.02968384e-02f,
  3.64938900e-02f, 4.14940268e-02f, -1.38650537e-02f, 2.48952140e-03f, 2.58990861e-02f, -8.85761604e-02f, 2.46229097e-02f, 6.20734207e-02f, 3.57353613e-02f, -3.26572582e-02f,
  -3.82863655e-04f, -5.77570871e-03f, 6.27289247e-03f, -5.77639602e-02f, -7.54901841e-02f, -2.68375687e-02f, 3.02645117e-02f, -4.09293994e-02f, -1.77725963e-02f, 5.49539775e-02f,
  1.56382456e-01f, 2.34569401e-01f, -8.07713065e-03f, 2.94775399e-03f, 5.27650937e-02f, 5.52760549e-02f, -1.89719647e-02f, -3.61855305e-03f, -4.79314476e-02f, -2.10612193e-02f,
  1.13243349e-01f, 3.08929347e-02f, 3.31526771e-02f, -2.55252086e-02f, -4.88048233e-03f, 3.52857374e-02f, 4.63205166e-02f, 1.82286166e-02f, 6.04955889e-02f, 9.73170996e-02f,
  6.63736686e-02f, 1.89011861e-02f, 1.96654331e-02f, 2.77243722e-02f, -1.46180168e-02f, 3.73348296e-02f, 4.45948057e-02f, 3.64776962e-02f, 9.02170166e-02f, 1.38741627e-04f,
  -3.01148474e-01f, 8.57618898e-02f, -1.35896713e-01f, 5.40342554e-02f, -2.25755528e-01f, -2.69829243e-01f, -1.18579410e-01f, -1.58958316e-01f, 3.90431844e-02f, 4.67275903e-02f,
  1.09410416e-02f, -4.40478697e-02f, 8.53312239e-02f, 1.00185260e-01f, -6.79234192e-02f, 1.94859698e-01f, -1.01270020e-01f, -3.15355584e-02f, 1.23925887e-01f, 2.96231806e-02f,
  2.83699054e-02f, 1.07022390e-01f, 3.59551646e-02f, 4.22262214e-02f, -2.12076008e-01f, 9.31637362e-02f, 4.47811224e-02f, 6.73958585e-02f, 3.79160861e-03f, -1.14342764e-01f,
  -9.95325074e-02f, -5.08220196e-02f, -1.39847904e-01f, -5.00006750e-02f, -1.72388554e-01f, -3.31334360e-02f, -2.08340082e-02f, 7.54962564e-02f, 1.36876730e-02f, 5.49438410e-02f,
  5.06608235e-03f, -2.33754795e-02f, -8.15828964e-02f, 9.16097686e-02f, -9.97906774e-02f, 1.68816317e-02f, 9.65351705e-03f, 2.08447445e-02f, -5.56267202e-02f, -1.63411200e-02f,
  -8.11654553e-02f, -1.07360020e-01f, -6.47956878e-02f, -5.66525608e-02f, -6.73991069e-02f, 3.49584292e-03f, -1.45857558e-02f, 1.74468029e-02f, -1.52037889e-01f, -1.12057790e-01f,
  1.28900465e-02f, 7.10957050e-02f, -5.86105846e-02f, -2.98452657e-02f, -9.41887498e-03f, -9.98381972e-02f, -7.49654844e-02f, -2.56561134e-02f, 1.53335454e-02f, -5.66792823e-02f,
  -1.01397283e-01f, -1.15521014e-01f, 4.26723734e-02f, -2.50699930e-02f, -2.17930861e-02f, -1.33283839e-01f, -5.29997889e-03f, 1.82843246e-02f, -1.13287099e-01f, 4.29440774e-02f,
  7.80884549e-02f, -2.16847714e-02f, -8.10927078e-02f, -5.51303849e-02f, 7.29913823e-03f, 8.30440968e-02f, 5.78788891e-02f, -1.22444576e-03f, -5.20587005e-02f, -2.35254839e-02f,
  -1.90601423e-01f, -5.90337776e-02f, -3.22281308e-02f, -1.35703102e-01f, 3.05928979e-02f, -7.88483247e-02f, 1.04031608e-01f, -8.51123556e-02f, 1.40166223e-01f, -8.18631947e-02f,
  -3.75351794e-02f, -3.96709368e-02f, -5.99546134e-02f, -2.01583169e-02f, 6.64750263e-02f, 9.20443386e-02f, 2.51765531e-02f, -2.61344556e-02f, -5.27968481e-02f, -9.68598872e-02f,
  -2.35076472e-02f, 1.81463007e-02f, -3.65557894e-02f, 5.54732792e-03f, -7.40668271e-03f, -7.02743456e-02f, -3.81139368e-02f, -3.17673478e-03f, -9.34673287e-03f, 1.47357779e-02f,
  -6.49514273e-02f, 4.20561843e-02f, 1.69224322e-01f, 1.26822308e-01f, 7.37619922e-02f, 5.06688803e-02f, -1.07048981e-01f, 1.41173586e-01f, 9.46894959e-02f, -2.46648535e-01f,
  -2.34889006e-03f, -1.04467951e-01f, 8.40807110e-02f, -1.14093952e-01f, 3.19082588e-01f, 2.13210210e-02f, -6.67004101e-03f, -8.32457468e-02f, 6.54765368e-02f, -9.93998870e-02f,
  1.34767011e-01f, -4.79754433e-02f, 1.28707185e-01f, -5.58676720e-02f, -3.10659297e-02f, 8.48977547e-03f, -1.52949378e-01f, 6.99881688e-02f, -1.09451309e-01f, 1.73756666e-02f,
  1.52694611e-02f, 9.53763649e-02f, 3.60923000e-02f, -4.49953191e-02f, -5.52918315e-02f, -5.49259968e-02f, -4.95896898e-02f, 6.38094097e-02f, 1.94092318e-02f, 4.12982181e-02f,
  -1.37128934e-01f, 7.67594278e-02f, 2.83471011e-02f, 5.00320606e-02f, -8.48618224e-02f, 6.01730160e-02f, 8.25525671e-02f, -1.84229948e-02f, 4.54952847e-03f, -3.86655480e-02f,
  2.86048651e-02f, -4.02556472e-02f, 2.94011869e-02f, -4.94294316e-02f, 4.36573289e-02f, 1.10781923e-01f, -1.11509018e-01f, -4.22204323e-02f, 8.22785776e-03f, 7.38851056e-02f,
  -9.86039788e-02f, -4.16867547e-02f, 2.70312708e-02f, -7.56697729e-02f, 7.20383003e-02f, 3.44637409e-02f, 3.75878513e-02f, -6.17843419e-02f, -1.04657910e-03f, -4.35956195e-02f,
  4.53603268e-02f, 3.95678915e-02f, -1.99711118e-02f, -6.63563609e-02f, 7.86026288e-03f, -1.74993544e-03f, -1.23730913e-01f, 1.69342402e-02f, -7.65026808e-02f, 4.88441512e-02f,
  -1.91366281e-02f, 8.41767266e-02f, -1.27662811e-02f, -1.24384440e-01f, -3.89423929e-02f, 1.24118123e-02f, -6.06501661e-02f, 6.29894212e-02f, 6.63795101e-04f, 5.98783121e-02f,
  -4.94754873e-03f, -9.13050994e-02f, 3.42473201e-03f, 9.66268331e-02f, -5.05069382e-02f, -4.73508611e-02f, 1.68452095e-02f, 2.16968693e-02f, 7.21434364e-03f, 2.92636156e-02f,
  -6.59598485e-02f, -2.86378395e-02f, -5.20585217e-02f, -6.19468503e-02f, 1.52375214e-02f, -3.09076328e-02f, -7.08580986e-02f, -1.31921684e-02f, -1.56663675e-02f, -4.97910902e-02f,
  -5.17262071e-02f, -7.38528147e-02f, -9.63471532e-02f, 4.52842116e-02f, -4.32551913e-02f, -1.00123540e-01f, -7.88103491e-02f, 2.45806575e-02f, -6.94475397e-02f, 4.26093154e-02f,
  3.93551797e-01f, -2.18564600e-01f, 1.64263308e-01f, 1.07972309e-01f, 1.77962050e-01f, -2.22712189e-01f, -9.12355632e-02f, -1.18036382e-01f, -1.05058728e-02f, -2.23326877e-01f,
  1.97521094e-02f, 2.15668213e-02f, -9.30350199e-02f, -9.70096961e-02f, 2.28339225e-01f, -1.28306895e-01f, -5.75141013e-02f, -6.00187853e-02f, 3.91314402e-02f, 2.61611342e-02f,
  5.29120751e-02f, -1.90590009e-01f, 7.12142512e-02f, -7.83129111e-02f, 1.46035179e-01f, 2.09666193e-01f, 1.57510489e-01f, 9.32937935e-02f, 8.49671364e-02f, 1.33200243e-01f,
  8.97136852e-02f, -6.46678656e-02f, -2.76096035e-02f, -1.33630615e-02f, -4.07544971e-02f, 6.09589415e-03f, -3.77052538e-02f, -6.38755923e-03f, 4.56710197e-02f, -5.73456986e-04f,
  -8.11577365e-02f, -9.81012061e-02f, -1.08869232e-01f, -2.85227094e-02f, 9.19384416e-03f, -3.23801152e-02f, 4.68251407e-02f, 9.14160255e-03f, 1.23484535e-02f, 4.71070968e-02f,
  4.97601647e-03f, 7.40847737e-02f, 2.79555228e-02f, 2.31204499e-02f, 4.42690589e-02f, -3.18352468e-02f, -1.39653966e-01f, -2.58463416e-02f, 1.15278540e-02f, -2.95097679e-02f,
  -1.14519494e-02f, -1.13786541e-01f, 3.74061726e-02f, 2.48913391e-04f, 2.93931700e-02f, -8.76696501e-03f, -4.50585149e-02f, -6.91463947e-02f, 4.61757137e-03f, -7.13768080e-02f,
  1.56912468e-02f, 1.29879359e-02f, -3.60906608e-02f, -7.03336531e-03f, -2.39505228e-02f, -3.55930477e-02f, -4.23946492e-02f, -1.59161203e-02f, -3.83608998e-03f, -7.43119884e-03f,
  4.19561453e-02f, -4.93348502e-02f, 7.50733493e-03f, 1.95605494e-02f, 3.05171008e-03f, 4.02594283e-02f, 6.60924017e-02f, 3.40634771e-02f, -5.48796318e-02f, 8.40673819e-02f,
  -1.16051205e-01f, -2.20481530e-01f, -5.73417395e-02f, -2.39815400e-03f, 1.78523787e-05f, -5.14098518e-02f, 7.29667675e-03f, 2.13497467e-02f, 1.23211471e-02f, -3.47655341e-02f,
  -2.07693893e-02f, -4.59615327e-02f, -9.41208191e-03f, -1.59963146e-02f, 2.82804295e-02f, -3.26250121e-02f, -1.71821099e-02f, 1.54470680e-02f, -1.43885547e-02f, -2.02332530e-03f,
  5.49250208e-02f, -9.88626182e-02f, 1.71762891e-02f, 7.15148123e-03f, -6.81346878e-02f, 4.05057110e-02f, 2.24644411e-02f, 3.80264632e-02f, 8.03898200e-02f, 2.20305398e-02f,
  -1.30047984e-02f, -2.99728602e-01f, -1.92411482e-01f, 9.79988836e-04f, -6.32256195e-02f, -5.28068133e-02f, 4.16173600e-02f, -1.84064046e-01f, -1.93359390e-01f, -1.26920789e-02f,
  1.25205338e-01f, -1.13827705e-01f, 2.73663960e-02f, 3.64928022e-02f, 2.03953490e-01f, 1.18883207e-01f, 8.22268128e-02f, 3.71319763e-02f, -1.42162189e-01f, -1.09680317e-01f,
  2.93303989e-02f, 1.57130539e-01f, 3.94480042e-02f, -1.38028532e-01f, -9.60028619e-02f, -1.87798128e-01f, 1.07651815e-01f, -1.39371688e-02f, 1.01385675e-01f, 8.81500617e-02f,
  7.37941861e-02f, -1.69275418e-01f, -1.12650946e-01f, -6.93166927e-02f, -4.52069417e-02f, 6.31848425e-02f, 3.56166102e-02f, 5.42404130e-02f, 1.84925960e-03f, 2.11342098e-03f,
  3.82584631e-02f, 3.83420624e-02f, -2.93166470e-02f, 3.38441767e-02f, 4.60512787e-02f, 6.16194587e-03f, 3.88751924e-03f, -2.46716645e-02f, -4.44321707e-02f, 3.62750925e-02f,
  -2.51109879e-02f, 3.23597994e-03f, -7.42565691e-02f, 1.25631206e-02f, -5.19686453e-02f, -7.01961815e-02f, -2.70789508e-02f, 1.01901377e-02f, 7.30452314e-03f, 3.87925543e-02f,
  -3.82414497e-02f, 3.90575230e-02f, 2.62476839e-02f, 1.47275804e-02f, -9.85315070e-03f, 1.97100788e-02f, -1.15017109e-02f, -7.12776836e-03f, -1.72284935e-02f, 4.66966294e-02f,
  -3.90710048e-02f, 7.46614188e-02f, -3.67831364e-02f, 3.23787071e-02f, -2.44861562e-02f, 3.39334086e-02f, 6.88010156e-02f, -7.00164735e-02f, -5.96068660e-03f, 4.64752503e-02f,
  -3.50306258e-02f, 2.34945081e-02f, 2.71765888e-02f, 1.95702557e-02f, -4.22358066e-02f, 5.72346225e-02f, -1.46506680e-02f, -8.71843251e-04f, 2.47491822e-02f, -1.61985774e-02f,
  -1.00925788e-02f, -7.97315612e-02f, -9.75912735e-02f, 4.59889136e-02f, 5.37767410e-02f, 3.63671295e-02f, -3.69986519e-02f, -2.20443085e-02f, -3.75529416e-02f, -4.78786463e-03f,
  -2.16644611e-02f, 3.19264904e-02f, -4.56899926e-02f, -5.92330797e-03f, 3.32022831e-02f, -2.93083899e-02f, 2.44700965e-02f, -4.50909920e-02f, 3.46689522e-02f, -1.33525692e-02f,
  8.54992867e-02f, 1.45023465e-02f, 3.97538021e-02f, -5.24706766e-02f, -4.93178852e-02f, 1.29041493e-01f, -2.09234413e-02f, -3.26600447e-02f, 2.80835871e-02f, -4.02616113e-02f,
  1.32667407e-01f, 6.36007413e-02f, -1.01196133e-01f, 1.28795311e-01f, -2.67012585e-02f, 3.09306569e-02f, 1.31044136e-02f, -7.12779015e-02f, 2.58176401e-02f, -3.46117350e-03f,
  -1.20362565e-01f, -5.97073548e-02f, -1.08427234e-01f, -1.74441449e-02f, 2.38809749e-01f, 1.45036355e-02f, 1.08874306e-01f, -3.03311329e-02f, -1.05782794e-02f, 1.88846122e-02f,
  5.80823086e-02f, 1.00882858e-01f, 9.97661054e-02f, -3.28226089e-02f, -2.06625629e-02f, 2.88889930e-02f, 2.35716984e-01f, 6.73641562e-02f, 1.52489915e-01f, -2.64538042e-02f,
  9.08830985e-02f, -4.79840208e-03f, -1.58822688e-03f, 4.26062569e-02f, -1.86126831e-03f, -5.17409854e-02f, 1.92242116e-02f, -5.86167835e-02f, 8.71438388e-05f, 1.77883599e-02f,
  -1.07697807e-01f, -1.13329090e-01f, 6.49830475e-02f, -8.54809880e-02f, 6.78075403e-02f, -8.29501729e-03f, 1.11415433e-02f, -3.78093608e-02f, -3.41698490e-02f, -5.74314110e-02f,
  -1.17630854e-01f, -5.60996234e-02f, 2.96416935e-02f, 1.90223828e-02f, 8.44273418e-02f, 3.16776931e-02f, -2.48898230e-02f, -2.31527025e-03f, 3.79983447e-02f, 6.47298321e-02f,
  2.95168832e-02f, 8.19156878e-03f, 6.07103202e-03f, -3.84258255e-02f, 1.67440865e-02f, -5.16802743e-02f, 1.57198701e-02f, 7.52430176e-03f, -4.94740382e-02f, 5.26552312e-02f,
  -1.21691555e-03f, -3.93729322e-02f, 4.30253707e-03f, 8.09039734e-03f, -3.39076892e-02f, 6.11897781e-02f, -7.27174943e-03f, -6.56160489e-02f, 2.75063235e-02f, -1.59316566e-02f,
  -2.90603898e-02f, -9.82412882e-03f, -5.95706105e-02f, -6.24714941e-02f, 1.25481822e-02f, 2.23552268e-02f, -2.32341141e-02f, -5.75044043e-02f, -4.87164482e-02f, 1.14814296e-01f,
  2.54488587e-01f, 1.57744631e-01f, 7.30088502e-02f, 8.40199087e-03f, 1.04314834e-01f, -6.34928467e-03f, 4.20888513e-02f, -7.02424720e-02f, 1.24608792e-01f, -7.28861988e-03f,
  6.23457432e-02f, -1.23098046e-02f, 5.58937304e-02f, 3.18920575e-02f, 7.57702589e-02f, 7.18295723e-02f, 1.24026485e-01f, 8.22452009e-02f, 1.28098369e-01f, -1.24902204e-02f,
  -4.43148538e-02f, -5.63631300e-03f, -2.24781726e-02f, 3.41868065e-02f, -7.65400901e-02f, 1.22331612e-01f, 3.49712521e-02f, 2.82718297e-02f, -3.59071651e-03f, -6.10623844e-02f,
  1.87681735e-01f, -3.24120492e-01f, 4.01390567e-02f, 5.60061168e-03f, 4.16615605e-02f, -2.88133413e-01f, -2.51276135e-01f, -1.42711401e-01f, -5.81847988e-02f, -1.92118660e-01f,
  -1.29671693e-01f, -6.44559413e-02f, -2.65445411e-01f, -2.12582365e-01f, -4.75721322e-02f, -1.72191426e-01f, -1.66153207e-01f, -1.59481689e-01f, -3.79385091e-02f, -9.63371024e-02f,
  8.73684213e-02f, -1.60911202e-01f, 1.97310839e-02f, -1.82545185e-03f, -6.21801801e-02f, 2.36860123e-02f, 1.44355921e-02f, -9.40983370e-03f, 9.10751596e-02f, -6.64653704e-02f,
  2.77038803e-03f, -7.75481714e-03f, 9.11529884e-02f, 4.71815951e-02f, 3.98383103e-02f, 9.26050618e-02f, 4.79467995e-02f, 5.52693307e-02f, 2.45706383e-02f, -6.79102316e-02f,
  -1.17371846e-02f, 7.82582685e-02f, 4.16390551e-03f, 3.77021618e-02f, -9.15778149e-03f, 1.59710273e-02f, -2.33993847e-02f, -1.48469647e-02f, -6.69772625e-02f, -1.10469632e-01f,
  5.24658617e-03f, 2.72675175e-02f, 7.55026340e-02f, -9.46059451e-02f, 1.75362900e-02f, 2.49758549e-02f, -5.44827133e-02f, 3.92635278e-02f, -8.81867856e-03f, -1.98237225e-02f,
  -3.21201496e-02f, 2.39602197e-02f, 1.01442663e-02f, 1.53469257e-02f, 8.88804346e-03f, 4.81669120e-02f, 1.97357740e-02f, -3.94925773e-02f, 9.00837872e-03f, -4.87971352e-03f,
  4.04399633e-02f, 5.62049635e-03f, -6.92000787e-04f, -7.43715167e-02f, 1.62594132e-02f, 3.24658887e-03f, 9.15960521e-02f, -4.46910150e-02f, 2.88179945e-02f, -4.40651104e-02f,
  1.24209430e-02f, -4.91620367e-03f, -3.04449685e-02f, 7.40127563e-02f, 7.72649981e-03f, -2.27561686e-02f, -4.80225496e-02f, 2.62455754e-02f, 2.76769213e-02f, 4.20899838e-02f,
  -2.22690865e-01f, -5.40133715e-02f, 8.42726044e-03f, 6.56782091e-03f, 4.74714786e-02f, 3.94057930e-02f, 2.76284739e-02f, -3.17562670e-02f, -5.67874536e-02f, 3.04006841e-02f,
  8.17427114e-02f, 6.15632832e-02f, 7.18675703e-02f, -5.68978256e-03f, -8.39985237e-02f, -5.01936413e-02f, -4.79341559e-02f, 2.77108643e-02f, -4.03029807e-02f, 1.15531404e-02f,
  4.85498086e-02f, -1.94957126e-02f, 4.03778814e-03f, -1.50845246e-02f, 3.01103946e-02f, 9.34491232e-02f, -3.96329351e-02f, -6.25968724e-03f, 3.10410094e-02f, 3.57393622e-02f,
  2.34011952e-02f, -2.00246717e-03f, -2.29976788e-01f, 7.16110738e-03f, 5.55893814e-04f, 1.11359186e-01f, -6.13113195e-02f, 3.96775901e-02f, -3.00782099e-02f, 2.08453566e-01f,
  6.15673847e-02f, -2.37266302e-01f, -1.63376078e-01f, 1.41227901e-01f, 2.60841893e-03f, -4.75577377e-02f, 1.80967242e-01f, 5.03930822e-02f, -1.72436208e-01f, -7.52540752e-02f,
  6.99064583e-02f, 2.34643459e-01f, 1.48366811e-02f, 7.67333955e-02f, 1.50118411e-01f, 3.64529602e-02f, 2.51242131e-01f, -9.71953273e-02f, 2.35086054e-01f, 7.76192397e-02f,
  4.07618359e-02f, 1.29797524e-02f, -1.75449264e-03f, -2.77314801e-02f, 1.76450223e-01f, -1.44219678e-02f, 9.88344550e-02f, -1.05260216e-01f, 8.60078186e-02f, 8.65312573e-03f,
  -2.32005096e-03f, -3.46732549e-02f, 4.86820601e-02f, -5.10976836e-02f, -4.67684977e-02f, 1.82361044e-02f, 8.22681189e-02f, 5.33921979e-02f, -9.49059054e-02f, 3.82377245e-02f,
  -6.28473312e-02f, 4.64051366e-02f, -1.26994273e-03f, 6.79094866e-02f, -9.27439556e-02f, 1.10732913e-01f, -4.10028473e-02f, -5.44271916e-02f, 3.75970080e-02f, 8.04560855e-02f,
  -8.60895365e-02f, -7.54882991e-02f, 6.65268153e-02f, 2.83814166e-02f, 2.93332729e-02f, 4.51562516e-02f, 1.47259876e-01f, 9.77397338e-02f, 1.74141631e-01f, -4.87345364e-03f,
  1.07810153e-02f, -1.28884399e-02f, -7.99748767e-03f, 8.35220292e-02f, 4.35843915e-02f, 1.50906644e-03f, 7.39902481e-02f, 1.57705218e-01f, 9.46299881e-02f, -4.10128199e-02f,
  -6.31057769e-02f, -7.01662377e-02f, 8.34872015e-03f, 8.33514854e-02f, 9.08781514e-02f, -3.45474631e-02f, -6.42324984e-02f, -6.04607761e-02f, -2.01673750e-02f, 3.58224511e-02f,
  2.06255987e-01f, 1.64481863e-01f, 8.24762136e-02f, 6.55716956e-02f, 1.68529153e-01f, 8.25022087e-02f, 1.35340840e-02f, -1.44725153e-02f, 8.60517249e-02f, -1.04886808e-01f,
  -2.29818746e-02f, -3.61021794e-02f, 9.59696025e-02f, 1.01132087e-01f, 8.96151066e-02f, 9.37814862e-02f, 5.60816266e-02f, -2.97398623e-02f, 5.81579432e-02f, 4.00870703e-02f,
  1.36221901e-01f, -5.26445843e-02f, -5.86834401e-02f, 6.30232543e-02f, 7.69290142e-03f, 1.87499989e-02f, 3.20895426e-02f, -7.20974952e-02f, 1.18285313e-01f, -3.04141175e-03f,
  -3.34922791e-01f, 1.84348688e-01f, -1.22769594e-01f, -1.01881303e-01f, -7.81221762e-02f, -1.57028243e-01f, -1.33510143e-01f, -3.97081748e-02f, -2.49805544e-02f, 2.52806604e-01f,
  1.98200792e-02f, 8.95144939e-02f, -4.07935819e-03f, 4.47936468e-02f, -3.11685354e-01f, 5.00689782e-02f, -6.78514391e-02f, 7.01436847e-02f, -7.77055509e-03f, 6.15578964e-02f,
  2.56542396e-02f, -1.06200688e-02f, -1.72296569e-01f, 1.12914927e-01f, -3.07963341e-02f, 6.93761185e-02f, 1.69839449e-02f, -1.14878595e-01f, 7.74980411e-02f, -5.55152446e-02f,
  -8.56036618e-02f, 1.10762283e-01f, -7.16869067e-03f, 1.10174254e-01f, -6.44535106e-03f, -2.58166119e-02f, -5.46681210e-02f, -1.37164474e-01f, -7.65238777e-02f, -5.21609485e-02f,
  5.93654402e-02f, 1.08029814e-02f, 7.58443102e-02f, 6.19357638e-03f, -1.75627582e-02f, 7.64114410e-02f, -4.08152826e-02f, -4.62541170e-03f, 2.58731861e-02f, -3.43526751e-02f,
  1.31898765e-02f, 5.49738668e-02f, -1.80343967e-02f, 6.89025670e-02f, -4.90487479e-02f, 1.05913924e-02f, 2.40108408e-02f, -4.81147654e-02f, 6.30747825e-02f, 4.34832275e-02f,
  -3.69678922e-02f, -5.40389493e-03f, 1.95844355e-03f, 6.47045905e-03f, -1.82467140e-02f, -2.39928402e-02f, -3.24085802e-02f, 3.60528864e-02f, -6.61802813e-02f, -2.09085271e-02f,
  3.33119258e-02f, -1.39297433e-02f, -3.30324247e-02f, -7.94204790e-03f, 2.36540511e-02f, 3.96979749e-02f, -5.95430359e-02f, 9.57130492e-02f, -9.29512642e-03f, 4.80343495e-03f,
  2.30034720e-02f, 1.86992325e-02f, -1.35770412e-02f, -4.86615226e-02f, -5.74651025e-02f, -2.97067408e-03f, 1.00857846e-01f, -1.49047608e-02f, -7.58043909e-03f, -3.93280685e-02f,
  9.72579792e-02f, 3.58607620e-02f, 1.06353186e-01f, 8.37863088e-02f, 1.60015374e-02f, 8.62304494e-02f, 9.16630775e-03f, 9.58847404e-02f, 5.84378839e-02f, 4.98357788e-02f,
  3.41246091e-03f, 5.59479110e-02f, 3.49208042e-02f, -1.09563462e-01f, 3.65055837e-02f, -1.59592237e-02f, -7.80256290e-04f, 9.58450958e-02f, -3.69309238e-03f, 8.85447934e-02f,
  -6.71097636e-03f, -2.18108557e-02f, 1.81259438e-02f, -2.95628607e-03f, 7.68593401e-02f, -7.06559792e-03f, 3.40561569e-02f, 2.59651057e-02f, -4.28282237e-03f, -1.56928990e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.34566501e-02f, -8.81063566e-02f, -1.75803229e-01f, -1.19224131e-01f, -1.63028147e-02f, -2.60191709e-01f, -2.64995158e-01f, -6.62447214e-02f, -4.53998074e-02f, -3.81169878e-02f,
  -6.19952641e-02f, 1.36913314e-01f, 1.31132349e-01f, -2.77942210e-01f, -4.98040393e-03f, 1.20116629e-01f, -2.97009140e-01f, -1.65394619e-01f, 7.20772818e-02f, -2.47910649e-01f,
  -1.44778237e-01f, -1.99974686e-01f, -7.99506009e-02f, -2.62184262e-01f, -2.14665800e-01f, 1.34804500e-02f, 1.45338297e-01f, 4.89875562e-02f, -2.04723299e-01f, -3.21011804e-02f,
  -1.17049888e-01f, -4.62808274e-02f, 3.51085700e-02f, -2.30218004e-02f, -1.67495739e-02f, 2.58020479e-02f, -2.02547573e-02f, 8.01536217e-02f, -1.33286826e-02f, -3.38809490e-02f,
  9.74935144e-02f, 2.94383336e-02f, -1.47735309e-02f, -5.92085868e-02f, 1.83139648e-02f, -4.19851318e-02f, 5.73506206e-02f, -4.25141351e-03f, 9.34885442e-02f, -2.54376512e-02f,
  -8.25689584e-02f, 1.70511678e-02f, -6.67249933e-02f, 7.39566237e-02f, 1.37279416e-02f, -1.51527643e-01f, -3.72943915e-02f, 4.26400267e-02f, -2.90603731e-02f, 5.20383473e-04f,
  -2.85298321e-02f, 2.99851000e-02f, 7.72502944e-02f, -1.77699029e-02f, -3.77717204e-02f, -6.81166723e-03f, -7.81756639e-02f, 7.51963183e-02f, 5.48049062e-02f, 1.06023766e-01f,
  -4.29601930e-02f, 2.23637894e-02f, -6.36512786e-02f, 4.34190445e-02f, 1.58533324e-02f, 4.58675474e-02f, -8.54512490e-03f, -7.82097038e-03f, -1.02544904e-01f, 1.50885992e-03f,
  1.31907225e-01f, -7.24416822e-02f, 3.95507626e-02f, 1.89588591e-02f, -4.47641499e-02f, 9.13305581e-02f, -4.53966903e-03f, -5.12830950e-02f, -7.48858452e-02f, -6.14567995e-02f,
  -5.58283105e-02f, -1.32980704e-01f, 6.42332584e-02f, 2.74302289e-02f, 2.73973551e-02f, -3.18530388e-02f, 1.62215792e-02f, 1.97067708e-02f, -3.66859734e-02f, -6.96777776e-02f,
  -9.74287093e-02f, 8.66580941e-03f, 6.42834008e-02f, 3.95251513e-02f, -2.91576236e-02f, -1.38643719e-02f, 9.76624191e-02f, 1.09919846e-01f, 7.39229918e-02f, -6.02970310e-02f,
  5.63640110e-02f, 1.45764038e-01f, 1.98218077e-02f, -8.81966352e-02f, -3.67906317e-02f, 9.94344503e-02f, 2.13289522e-02f, 7.15495199e-02f, 3.91467325e-02f, 2.59992783e-03f,
  2.34951809e-01f, 7.62559399e-02f, -2.34794825e-01f, -5.56053966e-02f, -1.95308939e-01f, 1.17638715e-01f, 6.91228732e-02f, -1.18195243e-01f, -1.19855389e-01f, 2.02386096e-01f,
  1.58681542e-01f, -1.16642959e-01f, 2.18680933e-01f, 2.83997655e-01f, -1.23980474e-02f, 2.67487049e-01f, 7.83130676e-02f, 7.68938363e-02f, 1.51077528e-02f, 1.17641576e-01f,
  1.84722356e-02f, 2.19645083e-01f, -3.91456150e-02f, 1.06963292e-01f, 1.08141758e-01f, -1.48258254e-01f, -7.94650912e-02f, -1.13823995e-01f, 7.14952275e-02f, -1.30221680e-01f,
  3.28914858e-02f, 1.93162620e-01f, 9.92699787e-02f, 1.82452872e-02f, 5.49886227e-02f, 1.87004104e-01f, 4.54078754e-03f, -4.00144234e-02f, -1.26463592e-01f, 5.72692081e-02f,
  -6.01502210e-02f, -5.50249964e-03f, 1.00835584e-01f, -7.17475861e-02f, -3.40145715e-02f, -1.24759763e-01f, 3.52043733e-02f, -1.18830979e-01f, -6.04342297e-02f, 2.97992267e-02f,
  -7.23934695e-02f, -7.09733143e-02f, -3.15531269e-02f, 2.90364809e-02f, -7.54448771e-02f, -3.77486795e-02f, -3.61840725e-02f, -1.33765200e-02f, 1.07843755e-02f, -4.33908366e-02f,
  2.43034903e-02f, -4.50974293e-02f, 1.77056596e-01f, 1.90871512e-03f, 4.01423834e-02f, 6.78902268e-02f, -4.18778211e-02f, -5.95231131e-02f, -1.08269125e-01f, 1.35870695e-01f,
  2.41810381e-02f, 4.26457962e-03f, -1.85387197e-03f, -4.92719747e-02f, 7.70831294e-03f, 7.39568919e-02f, -7.34275803e-02f, 6.85080662e-02f, -9.01620612e-02f, -6.21933900e-02f,
  -9.85639840e-02f, 2.04620622e-02f, 7.63849616e-02f, -3.39479297e-02f, -8.84245674e-04f, -5.18140160e-02f, 1.81852385e-01f, -2.32152753e-02f, -1.90228615e-02f, -2.23123860e-02f,
  6.37830347e-02f, 1.47760451e-01f, -6.72287196e-02f, -8.86393860e-02f, -1.12548014e-02f, 1.08595289e-01f, -6.52607754e-02f, 3.93913351e-02f, -5.22324927e-02f, 2.18828712e-02f,
  -6.30054846e-02f, -5.00721559e-02f, 3.90721336e-02f, -9.28116292e-02f, -1.27710536e-01f, 7.90135264e-02f, 1.24439141e-02f, -6.89376444e-02f, -1.51249170e-01f, -4.08343226e-02f,
  1.81882028e-02f, 6.64772317e-02f, -6.94605261e-02f, -1.27739087e-01f, -3.46058011e-02f, -8.21258128e-03f, -5.23720458e-02f, -7.65518919e-02f, 9.05152783e-02f, -7.18837604e-02f,
  -1.52773172e-01f, 3.00977111e-01f, -1.24374107e-01f, 1.65613845e-01f, -1.93912655e-01f, 3.89737338e-01f, 4.73079085e-01f, -6.77811950e-02f, 1.62102804e-01f, 3.76942098e-01f,
  1.43843681e-01f, 1.14797235e-01f, 2.33272567e-01f, 2.87142128e-01f, 5.26943617e-02f, 2.75847971e-01f, 2.47705370e-01f, 2.24924520e-01f, -1.91205461e-02f, -2.94917747e-02f,
  -4.52931263e-02f, 1.57254025e-01f, 8.41083154e-02f, -1.36662841e-01f, -8.03969130e-02f, -1.20606616e-01f, 2.98501682e-02f, -5.66047579e-02f, 9.49920267e-02f, 6.46088198e-02f,
  3.36345918e-02f, 4.40098420e-02f, -1.13351628e-01f, -3.94337066e-02f, -7.64407292e-02f, -4.27003764e-02f, 3.70199867e-02f, 2.70714555e-02f, -3.66420224e-02f, 1.87024008e-02f,
  -1.90703180e-02f, -2.05568746e-02f, 7.05091283e-02f, -1.21678626e-02f, -1.30314544e-01f, -4.65812460e-02f, -7.96292275e-02f, -6.99965730e-02f, 1.77077316e-02f, -4.91602346e-02f,
  -1.10277280e-01f, -6.38609231e-02f, 1.07841194e-02f, 8.54684785e-02f, -4.73028496e-02f, 5.58059700e-02f, 1.50737196e-01f, -8.23508054e-02f, 4.97007929e-02f, 8.07020590e-02f,
  -8.59390479e-03f, 1.32609278e-01f, -2.32312903e-02f, -7.38897733e-03f, -6.65058345e-02f, -1.52380476e-02f, 7.78139606e-02f, -2.29009371e-02f, 5.70847318e-02f, 1.15219234e-02f,
  -1.57864373e-02f, -3.35301161e-02f, 5.34319431e-02f, -1.81374811e-02f, 6.96907267e-02f, 5.01049589e-03f, -3.48605737e-02f, -1.27225593e-02f, 3.60351577e-02f, 1.77142711e-03f,
  8.01653117e-02f, 4.51042280e-02f, 6.38788119e-02f, 8.17346498e-02f, 1.30765457e-02f, -4.19419147e-02f, -5.04619302e-03f, 4.41110581e-02f, 6.71127439e-02f, 2.90719215e-02f,
  2.31894091e-01f, 2.64069378e-01f, 3.76961045e-02f, -1.01999648e-01f, 4.01044711e-02f, -9.04440433e-02f, 4.00828570e-02f, 5.13803549e-02f, 9.65324789e-02f, -3.06763593e-02f,
  -4.73698601e-02f, 3.09353154e-02f, -1.03593975e-01f, -1.55532584e-02f, 5.65724727e-03f, 7.13129267e-02f, 1.28706828e-01f, 8.18363354e-02f, 4.04222682e-02f, -9.68585238e-02f,
  1.27600245e-02f, 6.13230951e-02f, -2.90412945e-03f, -4.22168262e-02f, 3.82584594e-02f, -1.81357609e-03f, -1.03063755e-01f, -5.62155470e-02f, -4.99212518e-02f, 9.40087736e-02f,
  3.53625089e-01f, 2.89537460e-01f, 2.10820273e-01f, 1.89130992e-01f, -1.90088034e-01f, -2.24859521e-01f, -7.40738958e-02f, 3.22587453e-02f, -7.58774206e-02f, -5.36047481e-03f,
  2.34813262e-02f, 2.77758390e-01f, -1.65034100e-01f, 1.85421646e-01f, -1.66675091e-01f, -1.21084340e-01f, 2.45586690e-02f, 6.28690422e-02f, -1.17619485e-01f, 1.45149291e-01f,
  4.37850878e-02f, -1.59548685e-01f, 3.28404009e-02f, -1.86846219e-02f, 2.12490484e-01f, 2.53390908e-01f, 9.67512801e-02f, 1.06800050e-02f, 2.09081203e-01f, -1.89313725e-01f,
  -1.14038788e-01f, 1.18117630e-01f, 8.45429003e-02f, -2.02949606e-02f, -5.74123673e-02f, 1.34831881e-02f, 1.54920444e-02f, -8.54321122e-02f, -1.64643511e-01f, 4.08174507e-02f,
  -5.73740825e-02f, -1.04182310e-01f, -2.42717788e-02f, 6.02046289e-02f, -4.87772226e-02f, 4.44009006e-02f, 8.62670466e-02f, 4.50317822e-02f, 7.89955854e-02f, 1.42795756e-01f,
  1.82424605e-01f, 8.48301500e-02f, -1.27142901e-02f, 4.33541089e-02f, 6.01692759e-02f, -4.48257811e-02f, 2.47505438e-02f, 2.89909132e-02f, 1.08058877e-01f, 1.51256602e-02f,
  -2.80695991e-03f, -1.69466939e-02f, -5.98991588e-02f, 7.48766735e-02f, 5.52920178e-02f, -7.91420713e-02f, -7.87427872e-02f, -6.26332983e-02f, 2.07792153e-03f, -1.90751813e-02f,
  2.41473969e-02f, 1.53977305e-01f, -2.39851978e-02f, -2.82226205e-02f, 1.12374678e-01f, -3.54303606e-03f, -5.83099686e-02f, -2.95995735e-02f, 3.09702717e-02f, 1.06150962e-01f,
  1.07393645e-01f, -1.13806099e-01f, 6.88068382e-03f, 3.08701769e-03f, -1.19330332e-01f, -6.37255795e-03f, 1.50471523e-01f, 4.42689471e-02f, 3.01356930e-02f, -3.52761918e-03f,
  -5.25303967e-02f, 5.19255130e-03f, -7.58407265e-03f, 2.93867569e-02f, -1.02539435e-01f, 2.70817708e-02f, -3.99956144e-02f, -2.15696124e-03f, 7.53942579e-02f, -4.92187515e-02f,
  1.01757096e-02f, 2.21027341e-03f, -1.13362581e-01f, 2.90801525e-02f, -5.56006730e-02f, 6.21451018e-03f, 4.30844761e-02f, -1.39941418e-04f, 1.30368853e-02f, 5.99714480e-02f,
  8.17694589e-02f, -2.64966823e-02f, -3.47157121e-02f, -1.05561838e-01f, -4.50128876e-02f, -9.93141904e-02f, 1.20161138e-02f, -4.03428040e-02f, 8.30610543e-02f, -6.96475133e-02f,
  -4.01896745e-01f, 1.24823585e-01f, -2.56259859e-01f, 1.23462286e-02f, -1.64607882e-01f, -3.64769429e-01f, -2.13918462e-01f, -1.73846018e-02f, 1.88761353e-01f, 1.71430290e-01f,
  8.61982852e-02f, 4.04894464e-02f, 2.50400871e-01f, 1.95254121e-04f, -2.28015497e-01f, 1.12611160e-01f, -1.99508160e-01f, 1.98610723e-02f, -3.41938548e-02f, -5.88196889e-02f,
  -8.00239295e-02f, 8.41459557e-02f, -9.29305777e-02f, 5.42364642e-02f, -2.11603820e-01f, -5.67320921e-02f, -9.35336351e-02f, -1.68278381e-01f, -2.33396932e-01f, -1.12782851e-01f,
  -3.65631610e-01f, -1.52933255e-01f, -1.33607671e-01f, -1.25343442e-01f, -2.38526136e-01f, -1.23924747e-01f, -1.57494336e-01f, 7.76757374e-02f, -1.31876161e-03f, 7.41233081e-02f,
  3.33341956e-02f, 1.17685869e-01f, -3.99774536e-02f, 4.95787822e-02f, -8.83692354e-02f, 1.92981958e-03f, 8.68272223e-03f, -8.93847197e-02f, 3.62557825e-03f, 4.86038737e-02f,
  1.00812865e-02f, -1.15133055e-01f, -3.15172113e-02f, -4.33791950e-02f, -1.65176719e-01f, -1.36902496e-01f, -7.23263547e-02f, -5.93268871e-02f, -1.33259237e-01f, -1.15495354e-01f,
  1.65523821e-03f, 6.46615475e-02f, -4.15409878e-02f, 1.01557583e-01f, 7.95114972e-03f, -9.18381065e-02f, 1.16293672e-02f, 8.35515782e-02f, -5.94290234e-02f, 2.61276904e-02f,
  -3.94914187e-02f, -8.28498218e-04f, -3.60191166e-02f, -3.24053615e-02f, 4.94345091e-02f, 3.80644165e-02f, 1.52995549e-02f, 5.00337640e-03f, 3.29647921e-02f, -1.15136271e-02f,
  -2.40085600e-03f, 1.72655005e-02f, 8.90202262e-03f, -3.95002030e-02f, -1.14812791e-01f, 1.04479576e-02f, 2.32318044e-02f, -2.67772730e-02f, 3.50047858e-03f, -3.64736803e-02f,
  -3.74907941e-01f, -2.70508558e-01f, -7.37143233e-02f, -6.30925745e-02f, -1.89036131e-02f, 4.34910581e-02f, 1.03137139e-02f, -8.78833830e-02f, -7.83551708e-02f, -5.95114492e-02f,
  8.93084556e-02f, 4.97578233e-02f, -5.89915924e-02f, 9.91707146e-02f, 5.89677058e-02f, -3.40748020e-02f, -1.08652730e-02f, 1.41820917e-02f, -3.61159556e-02f, -1.01160154e-01f,
  -9.08541121e-03f, 8.61265361e-02f, 6.81343004e-02f, -7.04625845e-02f, -6.22577332e-02f, 3.76521982e-02f, 1.26951672e-02f, -8.61874819e-02f, -1.41635686e-01f, 4.81742015e-03f,
  -2.12914199e-01f, 7.65139461e-02f, 1.28346935e-01f, 2.15789706e-01f, -1.22011632e-01f, -1.64392367e-01f, -1.18305437e-01f, 1.56854361e-01f, -1.73958495e-01f, 5.21119051e-02f,
  1.96864083e-01f, 5.09342030e-02f, 2.19123945e-01f, 1.17617711e-01f, 1.55306071e-01f, 6.66889250e-02f, 2.09489480e-01f, -1.85996275e-02f, -9.20700803e-02f, 1.58010542e-01f,
  -4.34204116e-02f, 1.57410756e-01f, 1.58226728e-01f, 4.54487242e-02f, 2.78534442e-02f, 1.36443242e-01f, 2.60874867e-01f, 5.60731813e-02f, 9.95265022e-02f, -2.80338228e-02f,
  3.47771635e-03f, 1.47811025e-01f, -2.94163488e-02f, -3.41244973e-02f, 1.15778036e-01f, 9.33061615e-02f, 5.11795208e-02f, -7.06076389e-03f, -1.53404949e-02f, 1.20687105e-01f,
  -3.08648776e-02f, 8.15423131e-02f, -2.29524430e-02f, -6.10182136e-02f, -4.83882837e-02f, -8.51302892e-02f, 4.02659923e-03f, -6.10967241e-02f, -8.80476907e-02f, 3.38964537e-02f,
  -1.37475673e-02f, 9.67609361e-02f, 4.27634604e-02f, 7.78521821e-02f, 6.87830746e-02f, 7.81855956e-02f, -3.17208879e-02f, 7.51110762e-02f, -3.00033344e-03f, 4.16437127e-02f,
  -1.88818555e-02f, -2.50615198e-02f, -5.92025109e-02f, 3.68918367e-02f, -1.03200383e-01f, -2.70468201e-02f, -6.79842681e-02f, 5.53656369e-02f, -9.81969312e-02f, 5.70078231e-02f,
  -7.52144083e-02f, -1.90741438e-02f, 3.42303980e-03f, 7.87963942e-02f, -5.20379730e-02f, -4.29132804e-02f, -1.12377973e-02f, 1.25291292e-02f, -4.90998663e-02f, 7.40220100e-02f,
  2.46910937e-02f, -1.07345037e-01f, 3.28350961e-02f, 5.89865781e-02f, -8.28986764e-02f, 2.00789347e-02f, 7.48599544e-02f, -1.91640202e-02f, 9.05880332e-03f, 1.62451454e-02f,
  1.24385528e-01f, 3.05988431e-01f, 5.79163525e-03f, -1.28029156e-02f, 2.10809885e-04f, 1.01487646e-02f, -3.75764854e-02f, -9.96433757e-03f, 1.38112128e-01f, -1.24555556e-02f,
  -4.46593110e-03f, -8.97805616e-02f, 1.05903745e-01f, -1.23309158e-01f, 8.47413242e-02f, 2.56171841e-02f, 4.13745046e-02f, -5.86435460e-02f, 7.79596791e-02f, -6.75714982e-04f,
  1.25186905e-01f, -1.20072998e-01f, -6.33208752e-02f, 1.83706284e-02f, 7.21132010e-02f, 1.12639204e-01f, -1.16142645e-01f, -7.84834549e-02f, -1.66494697e-02f, 7.88176730e-02f,
  1.94860831e-01f, -1.01794243e-01f, -2.19246641e-01f, 5.84281757e-02f, 3.17716569e-01f, 2.01387823e-01f, 7.60947019e-02f, 1.30456597e-01f, 4.08474170e-02f, 5.22811674e-02f,
  1.41577229e-01f, -2.46213183e-01f, -2.03727633e-01f, 1.63003847e-01f, -6.30829260e-02f, -2.67696261e-01f, 2.49752834e-01f, 5.45010976e-02f, -1.28555894e-01f, -1.41092241e-02f,
  -1.21883102e-01f, 2.35674307e-01f, -2.49472111e-01f, 1.89749718e-01f, 1.95950061e-01f, -1.45013034e-01f, 1.49961356e-02f, -2.58300930e-01f, -4.21042778e-02f, 4.92467470e-02f,
  1.24199251e-02f, -6.77880421e-02f, 1.89372487e-02f, -6.83900807e-03f, -8.81508067e-02f, 2.44417768e-02f, 2.18049809e-02f, -1.16950855e-01f, -7.08506182e-02f, -1.86467960e-01f,
  -1.35595696e-02f, 4.98116622e-03f, -2.96437386e-02f, -7.13965520e-02f, -1.58486550e-03f, 1.34818237e-02f, -4.47793044e-02f, 7.27182701e-02f, -7.79648647e-02f, -1.43256411e-01f,
  -1.26007393e-01f, -5.68777099e-02f, 6.12470023e-02f, -6.88990578e-02f, -6.44682944e-02f, -1.55945942e-01f, -6.54097497e-02f, -9.37442482e-02f, 3.61659899e-02f, 8.43896996e-03f,
  9.26832203e-03f, 8.51515383e-02f, 3.96864340e-02f, 1.07673526e-01f, -2.00232752e-02f, -9.91223678e-02f, 9.63353589e-02f, -8.50383788e-02f, -1.55554891e-01f, 3.46800275e-02f,
  -1.02154613e-01f, 2.12318581e-02f, -4.70579639e-02f, 2.95556076e-02f, 1.14140250e-01f, 3.05496417e-02f, 4.27468568e-02f, 2.54480299e-02f, -4.91700619e-02f, 3.88033576e-02f,
  1.37326540e-02f, 5.51086627e-02f, -7.13903382e-02f, 1.97442882e-02f, 3.63613106e-03f, 3.27119455e-02f, 6.30596355e-02f, -2.28115004e-02f, -6.34420440e-02f, 6.63890168e-02f,
  1.25533313e-01f, -6.25825673e-02f, 1.76942926e-02f, 5.51308729e-02f, -2.16392636e-01f, 1.03224389e-01f, 5.26702143e-02f, 1.93074793e-02f, -2.53914092e-02f, -3.17751467e-02f,
  1.11690443e-02f, -9.99700930e-03f, -3.17685343e-02f, -1.62166432e-02f, -7.95788243e-02f, 5.57505004e-02f, -3.87513116e-02f, -3.39052174e-03f, 6.96209669e-02f, -1.12879284e-01f,
  1.60677910e-01f, -8.91546458e-02f, 1.19114919e-02f, 1.56542569e-01f, 1.04218051e-01f, -1.00137293e-01f, -1.06790654e-01f, -3.56152654e-02f, -8.86320602e-03f, 4.83681597e-02f,
  2.42966101e-01f, -2.18026623e-01f, -2.02536002e-01f, 1.66937767e-03f, 1.58966735e-01f, 1.37553230e-01f, -1.56217575e-01f, 1.00663505e-01f, -1.72266275e-01f, -6.90933540e-02f,
  5.05128279e-02f, -6.55904263e-02f, -2.60816067e-01f, 2.87414342e-01f, 1.98412895e-01f, -2.03499347e-01f, 2.77994186e-01f, 6.63189739e-02f, -1.04088217e-01f, 1.00247331e-01f,
  1.05158977e-01f, 3.30835849e-01f, 3.47691476e-02f, 2.79208601e-01f, 1.20268658e-01f, -7.46508911e-02f, 6.53639361e-02f, -3.42810377e-02f, 2.71224529e-01f, 1.28313795e-01f,
  3.17488126e-02f, -1.09254599e-01f, 2.45655631e-03f, -1.90189164e-02f, -1.98779497e-02f, 3.42496758e-04f, 2.79656867e-03f, 1.02462903e-01f, 7.95597956e-03f, -5.69050461e-02f,
  -3.71329323e-03f, 1.02409445e-01f, 3.59905660e-02f, 2.50952989e-02f, 1.41493157e-01f, 5.08796945e-02f, -1.12568540e-02f, -3.29493429e-03f, -1.19802114e-02f, -1.18966633e-02f,
  -1.44327119e-01f, -7.25754648e-02f, -1.27239034e-01f, -4.25292477e-02f, -1.47034258e-01f, 5.46989441e-02f, 1.93718134e-03f, -7.76051655e-02f, -3.58917154e-02f, -5.62245473e-02f,
  6.04848415e-02f, -5.65414429e-02f, -3.21634598e-02f, 7.04093650e-02f, -2.62520444e-02f, 4.03946899e-02f, -1.01371631e-02f, -2.64967289e-02f, 3.21408063e-02f, -3.19426805e-02f,
  -2.57411264e-02f, 1.00284852e-01f, 6.31739870e-02f, 5.14166206e-02f, 8.18241835e-02f, 2.60836678e-03f, -6.55471683e-02f, 3.61315906e-02f, -5.18280081e-02f, -9.70149413e-02f,
  6.29336610e-02f, 5.38386218e-02f, -4.92765047e-02f, -9.40110981e-02f, 3.57024223e-02f, -1.94845498e-02f, 5.16981073e-02f, 5.48125058e-02f, -6.70861453e-02f, -2.65339389e-02f,
  8.57610404e-02f, -8.70883763e-02f, -9.67756286e-03f, 2.26720180e-02f, -3.53376917e-03f, 8.63930359e-02f, 4.72867377e-02f, -2.05946565e-02f, 5.65959746e-03f, 1.74985118e-02f,
  -4.50362861e-02f, 4.62819859e-02f, 3.06621846e-02f, 2.48919670e-02f, -2.24225558e-02f, 1.55888533e-03f, -6.76096454e-02f, -6.49057701e-02f, 9.44206938e-02f, 1.04646310e-01f,
  -1.00119196e-01f, -5.51808067e-02f, 9.19522811e-03f, 4.67735995e-03f, -1.13353794e-02f, -1.28760353e-01f, -4.65392359e-02f, -5.04024476e-02f, 3.08702961e-02f, -3.84710240e-03f,
  1.61663488e-01f, 3.33025485e-01f, 1.48332804e-01f, 2.58510679e-01f, 8.70136730e-03f, -2.61717379e-01f, -2.03472286e-01f, 1.45892978e-01f, -1.13460958e-01f, 3.57879810e-02f,
  -5.82928173e-02f, 2.56811589e-01f, -8.73886235e-03f, 1.63188517e-01f, 1.08624436e-01f, -2.27592766e-01f, 2.55346864e-01f, 2.51852106e-02f, 3.22156474e-02f, 2.53005654e-01f,
  7.30789676e-02f, -6.94568753e-02f, 1.32631093e-01f, -3.38578573e-03f, 1.17248587e-01f, 1.17584907e-01f, 1.05686866e-01f, -5.68225514e-03f, 1.68679163e-01f, -5.87535426e-02f,
  3.78226712e-02f, -2.95943697e-04f, 1.08840279e-01f, -1.10110469e-01f, 6.91001862e-02f, -1.01882383e-01f, 4.96699288e-03f, -7.80671537e-02f, -1.30609214e-01f, 3.20522524e-02f,
  6.05351105e-02f, -4.10536155e-02f, -7.25690871e-02f, -1.28106937e-01f, 2.05518100e-02f, 2.33639926e-02f, -9.03065205e-02f, -7.46273324e-02f, 3.76746021e-02f, 3.99868153e-02f,
  -3.53704207e-02f, -7.76375830e-02f, 5.45145273e-02f, 5.96945509e-02f, -6.47339737e-03f, 3.83186266e-02f, 1.84508984e-03f, 4.31641340e-02f, 1.69303664e-03f, 1.25888065e-02f,
  1.12118155e-01f, 7.85208028e-03f, -7.29499087e-02f, -1.29133165e-01f, -2.99600549e-02f, 7.60903675e-03f, 6.49179891e-02f, 1.00078597e-03f, -2.13171188e-02f, -7.27665937e-03f,
  1.10893250e-02f, -9.28369642e-04f, -4.90261093e-02f, -7.52896219e-02f, 8.10553282e-02f, 4.82854396e-02f, -5.60213029e-02f, 2.98896693e-02f, 9.06685069e-02f, 3.22079584e-02f,
  -9.54279006e-02f, 2.45779678e-02f, 1.75560080e-02f, 1.03541072e-02f, 4.22869716e-03f, 3.72520015e-02f, -1.27575519e-02f, 7.27475435e-02f, 3.33830900e-02f, -2.68865246e-02f,
  4.06594202e-02f, 2.23393455e-01f, -5.87301217e-02f, 3.17051285e-03f, -7.79625252e-02f, -2.87533458e-03f, 6.33979887e-02f, -2.23193672e-02f, 6.59086183e-02f, -5.86381741e-03f,
  1.04206868e-01f, -7.20448121e-02f, -6.82254806e-02f, -1.23022959e-01f, 7.19270036e-02f, 7.92134255e-02f, -7.05625117e-02f, 6.30014250e-03f, 1.52628437e-01f, 6.28377274e-02f,
  7.60717094e-02f, -2.43387781e-02f, 5.47822379e-02f, -5.99524938e-02f, 2.77405474e-02f, 1.02229171e-01f, 1.25486255e-01f, -4.61178413e-03f, 6.79149255e-02f, 6.47575036e-02f,
  1.34038284e-01f, 2.19738737e-01f, 1.82220221e-01f, 3.01924676e-01f, -7.21379668e-02f, -2.74742723e-01f, -1.83782950e-01f, 1.53486058e-01f, 1.26283746e-02f, -5.18021099e-02f,
  -1.50572173e-02f, -8.01801030e-03f, 7.48360530e-02f, 9.38659683e-02f, -1.03333361e-01f, -1.31821260e-01f, -1.29075740e-02f, 3.93661708e-02f, -5.95110469e-02f, 2.35408485e-01f,
  1.21593870e-01f, 3.34678926e-02f, 1.26576975e-01f, 5.07918708e-02f, 1.44352481e-01f, 1.64895356e-01f, 1.13876626e-01f, 6.36858866e-02f, 1.30947232e-01f, -1.87988371e-01f,
  -1.57745093e-01f, 6.22821599e-02f, 6.43024892e-02f, -1.37573123e-01f, 1.12595044e-01f, 4.33290889e-03f, 3.58878635e-02f, -1.31803274e-01f, 4.77862358e-02f, 4.57670018e-02f,
  2.95852628e-02f, 1.73039082e-02f, -6.28958270e-02f, 3.80518176e-02f, 4.45391610e-02f, 1.21237800e-01f, -2.86191888e-02f, 1.46378716e-02f, -2.03375500e-02f, 1.21713810e-01f,
  4.92264964e-02f, -5.90536632e-02f, 4.39578407e-02f, -1.07589632e-01f, 4.81039621e-02f, 3.46170762e-03f, 3.91977206e-02f, -2.35403124e-02f, 4.15003598e-02f, -8.20623115e-02f,
  -3.89610864e-02f, -1.79744791e-02f, 3.80839668e-02f, 7.33261481e-02f, 2.08570939e-02f, 4.98342142e-02f, -9.08106714e-02f, -2.28515081e-02f, -8.64460971e-03f, -1.40537200e-02f,
  6.00407310e-02f, -2.82645952e-02f, -9.76808444e-02f, 1.32938400e-01f, 8.19313601e-02f, -2.65191980e-02f, -2.49846093e-02f, -1.96059607e-02f, 4.87667583e-02f, 8.52676108e-02f,
  -4.43450175e-02f, 2.99683791e-02f, -5.41178174e-02f, -1.02913849e-01f, -3.33497971e-02f, 3.72059718e-02f, 2.18923856e-02f, -6.34588227e-02f, -2.61341874e-02f, 9.14669111e-02f,
  -4.75322455e-02f, 1.56795114e-01f, -1.19495029e-02f, -6.21338673e-02f, 4.99074571e-02f, 1.67489774e-03f, -6.62572160e-02f, -9.08697471e-02f, 3.93080339e-02f, 1.03374876e-01f,
  2.17351434e-03f, 6.83904588e-02f, -1.51215158e-02f, 2.43163630e-02f, -5.34751045e-04f, 1.23506233e-01f, -3.31023000e-02f, 8.65260884e-03f, -7.62148127e-02f, 1.20668136e-01f,
  1.19861655e-01f, 3.08650434e-02f, -1.05474286e-01f, -3.58154289e-02f, 8.78533497e-02f, -3.89171317e-02f, 7.25366846e-02f, -4.61191870e-02f, 6.86080195e-03f, -8.51591453e-02f,
  -4.74603415e-01f, 5.57939038e-02f, -1.62214801e-01f, -2.66013771e-01f, -7.66639560e-02f, -2.61290520e-01f, -4.96218875e-02f, -1.21578038e-01f, -1.87694594e-01f, -8.58194456e-02f,
  -1.17507249e-01f, -1.15219532e-02f, 2.09794238e-01f, -1.41390592e-01f, 1.98414885e-02f, 1.54769853e-01f, -1.16213322e-01f, -1.93439648e-01f, -9.51250177e-03f, -8.21401328e-02f,
  9.62736644e-03f, -1.17117509e-01f, -3.90742905e-02f, 5.07639982e-02f, -1.81755811e-01f, -2.07120672e-01f, -1.79279782e-02f, 1.49804503e-01f, -2.22829446e-01f, -4.09803167e-02f,
  -1.97029307e-01f, -8.68650377e-02f, -1.16855346e-01f, -1.45807281e-01f, -1.80627391e-01f, -4.13136221e-02f, -5.82508482e-02f, 8.17005895e-03f, -1.16559997e-01f, 9.35842097e-03f,
  8.05656761e-02f, -3.10648535e-03f, -1.27676561e-01f, 8.71738568e-02f, 3.73866372e-02f, -8.70546922e-02f, -3.53988558e-02f, 1.00721130e-02f, -8.30540434e-02f, 9.25332457e-02f,
  2.34375615e-02f, -7.41565004e-02f, -2.94239298e-02f, 6.45085350e-02f, 1.61516398e-01f, -4.70395014e-02f, 1.02312295e-02f, 8.90133306e-02f, -1.25108743e-02f, -8.40663090e-02f,
  -2.43321694e-02f, -9.46041569e-02f, -5.98230585e-03f, -5.18982187e-02f, 4.97267358e-02f, -4.31086542e-03f, -9.60055515e-02f, -3.63759398e-02f, -4.51060161e-02f, 8.03678036e-02f,
  3.73233594e-02f, 6.84901103e-02f, 7.10066035e-02f, 6.87834099e-02f, 4.22780886e-02f, 4.33535501e-02f, -2.30776053e-02f, 4.60913517e-02f, -2.57702861e-02f, 3.88652533e-02f,
  -1.02570556e-01f, 4.98433337e-02f, 1.15316674e-01f, 4.85017933e-02f, -3.11698671e-02f, 3.16398218e-02f, 7.50274211e-02f, 1.28038317e-01f, -7.86633510e-03f, 4.68557179e-02f,
  -2.74114698e-01f, -1.17517583e-01f, -1.54934481e-01f, -1.28453583e-01f, -2.17852928e-02f, -7.76917040e-02f, -7.28420913e-02f, -1.74853615e-02f, -1.05261333e-01f, -8.64547193e-02f,
  -1.13664813e-01f, 8.48817602e-02f, -5.74529432e-02f, -2.28144787e-02f, 8.61969888e-02f, -1.20733052e-01f, -6.79591149e-02f, -5.59911206e-02f, -1.29262313e-01f, -1.14531875e-01f,
  -1.46443769e-01f, -1.30314827e-01f, 1.12072892e-01f, 6.42509237e-02f, 1.99106857e-02f, -7.05841482e-02f, -3.18574719e-02f, -5.07656373e-02f, 8.96764360e-03f, -1.45911295e-02f,
  -1.54384106e-01f, 2.85156488e-01f, 3.40951324e-01f, -2.03649439e-02f, -1.03216201e-01f, 2.41254151e-01f, 7.69777745e-02f, 1.60225615e-01f, 2.04630718e-01f, 1.72136873e-01f,
  -2.13571608e-01f, 2.17174113e-01f, 2.80504897e-02f, 1.12742661e-02f, -1.25089109e-01f, 7.73528069e-02f, 6.76436052e-02f, 1.26754101e-02f, 3.23569588e-02f, 7.68049955e-02f,
  -1.26366153e-01f, -1.69452429e-01f, 5.66862822e-02f, -1.50319457e-01f, -2.78250575e-02f, 1.31819040e-01f, -3.41523767e-01f, 5.99056073e-02f, 8.12989548e-02f, -1.76330581e-02f,
  1.45412236e-01f, -9.50455964e-02f, 7.46717155e-02f, 1.62955225e-01f, 3.28773521e-02f, -3.02112056e-03f, 4.02536360e-04f, -8.97846445e-02f, -2.98782047e-02f, -1.04838880e-02f,
  -4.08356711e-02f, 9.42150429e-02f, -2.64146328e-02f, -8.24772045e-02f, 7.83010423e-02f, 3.59124690e-02f, 1.52809054e-01f, 1.51181981e-01f, 1.35162249e-01f, 4.66303937e-02f,
  6.10475056e-02f, 1.84135228e-01f, 7.02798739e-02f, 9.16556045e-02f, 9.20942053e-02f, 4.04082276e-02f, 7.09491149e-02f, 2.88039688e-02f, 1.00434184e-01f, -1.72840543e-02f,
  -2.74344292e-02f, 7.35267550e-02f, 1.16603851e-01f, -1.27781192e-02f, 2.02283002e-02f, -1.27899617e-01f, -2.65955497e-02f, -1.97195888e-01f, 7.48530850e-02f, 7.32546672e-02f,
  2.28778254e-02f, 1.22665636e-01f, -4.23463881e-02f, 9.22771394e-02f, -7.65299723e-02f, -3.33149396e-02f, -4.37888838e-02f, -3.56578548e-03f, -4.56562825e-02f, -9.40025691e-03f,
  -1.38288453e-01f, -2.08719224e-02f, 2.42541712e-02f, -9.18070227e-02f, 1.04497813e-01f, 3.16455625e-02f, 4.64890413e-02f, 1.05530418e-01f, -4.16243412e-02f, 3.68809476e-02f,
  -8.29346105e-03f, 2.03967132e-02f, 3.75889577e-02f, 1.24637611e-01f, 6.67080060e-02f, 4.34747003e-02f, 9.83623415e-02f, -3.92892957e-03f, -7.56814927e-02f, -4.01845388e-02f,
  8.77183378e-02f, -2.93834005e-02f, 1.36949807e-01f, -7.90234581e-02f, 3.47613320e-02f, -6.73433840e-02f, -6.21252973e-03f, 1.02345653e-01f, -5.05481698e-02f, 2.12271661e-02f,
  -1.07964026e-02f, -4.01018001e-03f, 1.23016993e-02f, -5.13508692e-02f, -2.58506015e-02f, -2.02227738e-02f, -8.28307867e-02f, 1.26010135e-01f, 7.24842101e-02f, -7.54046589e-02f,
  -1.41420260e-01f, -4.04699981e-01f, 9.49492399e-03f, -1.26575166e-02f, 1.56711593e-01f, 2.31136829e-02f, 1.37073183e-02f, -1.40915453e-01f, -2.53664762e-01f, -2.91159153e-01f,
  -1.18284844e-01f, 1.69958882e-02f, -2.12076962e-01f, 5.15596569e-02f, 3.03074121e-01f, -1.37591008e-02f, -5.80079183e-02f, 2.13379320e-02f, 4.68590930e-02f, -8.72529298e-02f,
  1.47933826e-01f, 1.67744294e-01f, 1.57808915e-01f, -1.34403398e-03f, -4.01445962e-02f, -6.38085678e-02f, 6.67593926e-02f, 4.18351628e-02f, 2.43386596e-01f, 1.98366091e-01f,
  -1.90355450e-01f, -7.27062076e-02f, -4.55674604e-02f, -8.35558549e-02f, -1.05397642e-01f, -4.11644466e-02f, -2.41766404e-02f, 8.34641680e-02f, 8.28782693e-02f, -1.72832776e-02f,
  -1.19345449e-01f, 1.81291217e-03f, 3.28374803e-02f, 9.69725568e-03f, -8.50521699e-02f, 2.98003368e-02f, -4.20579985e-02f, -1.32742509e-01f, -8.54211971e-02f, -3.08467261e-03f,
  -1.00411937e-01f, 5.24361432e-02f, -3.99868600e-02f, -2.34186891e-02f, 5.60067445e-02f, 5.84670715e-02f, 1.00798428e-01f, 8.97983462e-02f, -2.42569167e-02f, -2.06198841e-02f,
  9.23675150e-02f, 2.71628983e-02f, -5.06731905e-02f, -3.62442657e-02f, 1.56470574e-02f, -2.41850019e-02f, -8.49574991e-03f, 7.32417107e-02f, 3.87354121e-02f, -7.06659257e-02f,
  6.44713789e-02f, -5.47734424e-02f, -1.42688900e-01f, -2.20134258e-02f, -3.27738599e-05f, 5.64697657e-05f, -1.36044128e-02f, -5.45665845e-02f, -3.91042270e-02f, 3.09184399e-02f,
  -2.79734600e-02f, 6.10043630e-02f, -1.08193606e-01f, 5.62610254e-02f, 4.29882854e-02f, -8.72005373e-02f, 4.61548753e-02f, -1.71176329e-01f, -3.41082886e-02f, 6.88930824e-02f,
  -3.09196144e-01f, -3.27183723e-01f, 3.59200537e-02f, -6.61930740e-02f, -3.70608158e-02f, -9.02327225e-02f, 4.31918427e-02f, -4.07440914e-03f, -1.12852387e-01f, -3.63333821e-02f,
  -1.98610313e-02f, 4.10727132e-03f, -3.19322199e-02f, -2.70821899e-02f, 8.20784122e-02f, -8.52895081e-02f, -6.32279068e-02f, -9.40826535e-03f, -6.76741451e-02f, -8.83179437e-03f,
  -8.26026872e-02f, 9.48516373e-03f, 7.55637661e-02f, 4.88535352e-02f, -2.56883241e-02f, -5.48157208e-02f, 4.03143559e-03f, -4.81595397e-02f, 9.74169970e-02f, 8.63996893e-03f,
  3.31517249e-01f, 3.97170752e-01f, 7.91704804e-02f, 3.44250984e-02f, -1.58606604e-01f, 4.77053076e-02f, -1.05721049e-01f, 2.00161934e-02f, -1.42741427e-01f, 7.14263394e-02f,
  -2.14520782e-01f, 2.18921155e-01f, -3.12791504e-02f, 2.27111682e-01f, -8.82714391e-02f, -1.40752047e-01f, 1.90563232e-01f, 4.79767844e-02f, -1.66774645e-01f, 1.75584465e-01f,
  4.13738303e-02f, -1.32061802e-02f, 2.88658198e-02f, -2.61930488e-02f, 1.72723353e-01f, 9.78293493e-02f, -1.29504368e-01f, -1.07535027e-01f, 1.46975666e-01f, 6.33890694e-03f,
  7.84297734e-02f, -1.22315111e-03f, 1.05450854e-01f, -5.23558706e-02f, 7.76466355e-03f, 7.10251331e-02f, 9.16671604e-02f, 7.81116411e-02f, -1.43215582e-01f, -3.31982449e-02f,
  1.27684504e-01f, -4.79409881e-02f, 1.03324823e-01f, 6.15591183e-03f, 1.10103926e-02f, 6.05489165e-02f, 5.04764095e-02f, -1.25566507e-02f, 5.64152189e-02f, 1.19688801e-01f,
  8.11124444e-02f, -2.76111644e-02f, 3.41547560e-03f, 7.51083419e-02f, 7.06189275e-02f, -7.91044440e-03f, 3.84929180e-02f, 8.78143981e-02f, -6.75425753e-02f, 7.91817904e-02f,
  8.03660527e-02f, -1.60778258e-02f, -9.38628167e-02f, -6.35111257e-02f, -1.90016888e-02f, -9.53321680e-02f, -5.21697439e-02f, -2.94556729e-02f, 3.14031728e-02f, 1.49872834e-02f,
  -6.70541078e-02f, -4.47220095e-02f, -1.09747477e-01f, 9.50201005e-02f, 2.25260276e-02f, -4.66178954e-02f, 8.53639767e-02f, -8.54272172e-02f, 4.76191044e-02f, -1.18290214e-02f,
  -1.68716908e-01f, 6.98153302e-02f, 5.23287728e-02f, 5.79477660e-02f, -1.98280700e-02f, -6.26714677e-02f, -9.61767510e-02f, 5.39017953e-02f, -4.71462049e-02f, -2.57748831e-02f,
  1.08952709e-01f, 1.41590565e-01f, -1.94752775e-02f, -3.44323413e-03f, 8.21184069e-02f, 8.38248208e-02f, -9.11027938e-02f, 1.99174374e-01f, 5.40661812e-02f, 7.75213689e-02f,
  6.75561205e-02f, -4.26833555e-02f, 4.54327650e-03f, 4.02966440e-02f, -2.44456585e-02f, -5.43583557e-03f, -5.02705425e-02f, -1.08895950e-01f, 2.04939228e-02f, 8.31351429e-02f,
  3.97675969e-02f, -4.74361191e-03f, 5.92982443e-03f, -4.59701866e-02f, -2.08039358e-02f, 3.82859036e-02f, -2.48972662e-02f, 7.30033591e-02f, 2.20168307e-02f, 1.58495619e-04f,
  1.13316774e-01f, -1.60676330e-01f, -1.50105581e-01f, -1.26092806e-01f, -1.82141766e-01f, -9.94589329e-02f, -1.32637064e-03f, -2.43599176e-01f, 6.97666854e-02f, -1.53738916e-01f,
  -1.46113977e-01f, 1.10028997e-01f, 1.02340616e-01f, -2.61137158e-01f, 3.63694459e-01f, 1.87717065e-01f, -1.26458943e-01f, 8.19215924e-02f, -1.01274587e-01f, -6.63376227e-02f,
  -8.19127113e-02f, -2.41221830e-01f, 7.21468939e-04f, -2.98232555e-01f, -2.51009792e-01f, -2.15028867e-01f, 9.75662470e-03f, -3.85603346e-02f, -2.00969368e-01f, -1.08591124e-01f,
  3.76258008e-02f, -1.05599985e-01f, 5.25901560e-03f, -6.65102005e-02f, 1.44595653e-02f, -9.95968468e-03f, 4.96783331e-02f, 5.26183993e-02f, 2.32551713e-02f, -1.59875620e-02f,
  1.01122454e-01f, 7.24048764e-02f, -4.93379608e-02f, 1.21319331e-02f, 4.95032482e-02f, 3.94497812e-02f, -4.14423719e-02f, 4.11462300e-02f, -4.92342189e-02f, -1.03030158e-02f,
  -7.54218325e-02f, 2.73855831e-02f, 5.83272651e-02f, 6.50849640e-02f, -2.95978412e-02f, -2.80525610e-02f, 7.23170117e-02f, 6.29155263e-02f, 5.05339876e-02f, 1.11691751e-01f,
  4.84050140e-02f, -2.06596660e-03f, 1.33118955e-02f, -2.30346574e-03f, 4.55883741e-02f, -3.01162973e-02f, -2.34262017e-03f, -9.27544311e-02f, -1.32058631e-03f, -2.68631172e-03f,
  -2.18171757e-02f, 4.94084135e-02f, 1.11729115e-01f, -7.36583769e-02f, -5.18410206e-02f, -1.19630536e-02f, 1.26502439e-02f, -2.37116981e-02f, 3.00745349e-02f, 6.91368431e-03f,
  3.51014026e-02f, 8.55071396e-02f, -6.33579716e-02f, -3.08418628e-02f, 1.18490912e-01f, -2.03334577e-02f, -2.24532969e-02f, 5.12935817e-02f, 2.20267713e-04f, 9.96873900e-02f,
  4.30213567e-03f, -7.37501904e-02f, -8.84985551e-02f, 4.52383459e-02f, -7.43764043e-02f, -3.45527567e-02f, 1.54738780e-02f, -1.43654183e-01f, 3.06928921e-02f, 1.38197104e-02f,
  6.72837719e-02f, -2.08761953e-02f, 4.56387512e-02f, 6.98433444e-02f, 7.89020434e-02f, -8.87552872e-02f, 1.12708628e-01f, 1.57135293e-01f, 3.42000127e-02f, 2.68011317e-02f,
  9.12401918e-03f, 3.72091159e-02f, 6.03184896e-03f, -2.54460648e-02f, 7.32071251e-02f, 2.59921397e-03f, 9.11243446e-03f, -3.84885184e-02f, 1.84490070e-01f, -3.08216624e-02f,
  -5.46183646e-01f, 2.59466767e-01f, -1.62770867e-01f, -1.29385456e-01f, -6.64641187e-02f, -7.44506121e-02f, -4.07531187e-02f, -4.93183173e-02f, -3.38822380e-02f, 2.04264402e-01f,
  1.72199726e-01f, -1.48832977e-01f, 1.43095538e-01f, 2.03400716e-01f, -2.76219547e-01f, 1.15387999e-01f, 2.44084876e-02f, -4.86542210e-02f, -3.48617770e-02f, -9.05246139e-02f,
  -1.46711111e-01f, 1.46541983e-01f, -8.62234905e-02f, 2.12836906e-01f, -3.96532379e-02f, -1.70376301e-01f, -4.80023995e-02f, 2.39782073e-02f, 1.19870983e-01f, 1.57477692e-01f,
  -2.15235233e-01f, -2.30850711e-01f, -1.31198838e-01f, -1.69722036e-01f, -1.13092497e-01f, -1.71067007e-02f, -9.28937271e-02f, -5.73122911e-02f, -6.22942857e-02f, 1.37228528e-02f,
  1.85729694e-02f, -7.71593228e-02f, 2.13001091e-02f, 1.11565664e-01f, 2.00392418e-02f, -8.09294451e-03f, -1.76306290e-03f, 1.11761674e-01f, 2.01154575e-02f, 7.69878328e-02f,
  5.22300899e-02f, -2.10911632e-02f, -7.04332590e-02f, 7.80202448e-02f, 3.52565981e-02f, 6.39422983e-02f, 1.14365295e-02f, 1.73034668e-02f, -5.96717820e-02f, -6.04385696e-02f,
  2.29128376e-02f, -8.54748711e-02f, -7.90950879e-02f, 1.10400878e-01f, 4.10069851e-03f, 1.62318796e-01f, 6.53927103e-02f, 2.90520228e-02f, -3.28048058e-02f, 2.85906270e-02f,
  8.46939012e-02f, 2.49166545e-02f, 1.29354438e-02f, -3.66024859e-02f, 3.54642384e-02f, 3.87627073e-02f, -1.79216673e-03f, -4.53863442e-02f, 1.55884504e-01f, -1.06947213e-01f,
  -8.91136453e-02f, -5.54412343e-02f, 6.03189245e-02f, -6.11897260e-02f, 1.91965085e-02f, -5.74273020e-02f, 7.73298321e-03f, 4.58780564e-02f, 8.61544628e-03f, -6.96342364e-02f,
  -4.37960863e-01f, -3.57657939e-01f, -4.71378267e-02f, 4.21434222e-03f, 2.72673499e-02f, -5.18221855e-02f, -4.76218686e-02f, -4.07827273e-02f, -1.05134085e-01f, -5.35625927e-02f,
  -1.18911669e-01f, -8.94925091e-03f, -8.70525688e-02f, -2.29175203e-03f, 6.67104051e-02f, 2.28790827e-02f, -1.64854731e-02f, -5.63988872e-02f, -2.18501817e-02f, 1.80817973e-02f,
  -6.33543655e-02f, -2.40168590e-02f, 3.61391306e-02f, 3.96493971e-02f, 5.56095503e-02f, -4.73899813e-03f, -3.50251831e-02f, 2.17903312e-02f, 2.81554051e-02f, 1.15754344e-01f,
  -4.79615033e-01f, 1.45044655e-01f, -1.21872462e-01f, -4.88249771e-02f, -2.06752092e-01f, -2.17567105e-02f, -4.40486595e-02f, -1.44630924e-01f, -2.04498336e-01f, 1.88577488e-01f,
  5.73245212e-02f, -2.72262752e-01f, 1.21843860e-01f, 1.63655967e-01f, -2.32701693e-02f, 2.14427248e-01f, 1.56347781e-01f, 9.54614431e-02f, 1.38311014e-02f, -1.50653183e-01f,
  -3.73025686e-02f, -6.60487562e-02f, 9.22994316e-02f, 1.61265340e-02f, -2.13989750e-01f, -6.31469339e-02f, -3.64824459e-02f, -1.59889460e-01f, -4.58064303e-02f, -6.09412417e-02f,
  -1.33541003e-01f, -6.47736862e-02f, -3.89135778e-02f, 6.37718290e-02f, -8.62481669e-02f, -1.08330607e-01f, 2.38411184e-02f, -6.65470213e-02f, 2.57915668e-02f, -1.56994447e-01f,
  -3.90065834e-02f, -1.41328527e-02f, 5.08062504e-02f, -1.08275943e-01f, 6.63594343e-03f, 4.65311576e-04f, 3.86150591e-02f, 1.88054238e-02f, -9.96510014e-02f, 3.85163389e-02f,
  -1.04213143e-02f, 1.37998223e-01f, 1.44064380e-02f, 1.50590584e-01f, -4.95350175e-02f, 5.83257340e-02f, 1.40463039e-01f, 1.52794714e-03f, 6.03413992e-02f, -8.41099620e-02f,
  2.93069463e-02f, -1.10124111e-01f, 1.25405518e-02f, 1.26446551e-02f, -8.59870017e-02f, 8.43722150e-02f, 2.52096877e-02f, 6.24726433e-03f, 7.08246306e-02f, 6.71895035e-03f,
  1.82078611e-02f, 5.68556935e-02f, -8.20770115e-02f, 1.21943951e-02f, -3.73562798e-02f, -2.95713521e-03f, -9.05396119e-02f, -1.03212073e-01f, 3.86607717e-03f, 1.19182900e-01f,
  -8.66221860e-02f, -6.44100010e-02f, 2.05184538e-02f, 3.65690961e-02f, 3.39617506e-02f, -1.27755895e-01f, -6.07903488e-02f, 1.22910008e-01f, 5.09498343e-02f, -9.55863073e-02f,
  -1.00784570e-01f, -3.08373421e-01f, -9.09879506e-02f, 2.84660440e-02f, -5.81868850e-02f, -4.60428465e-03f, 7.80875459e-02f, -1.49541255e-02f, 6.62883138e-03f, -6.63176458e-03f,
  -1.39552215e-02f, -2.15965118e-02f, -5.05187213e-02f, 1.34306373e-02f, 7.96401352e-02f, -4.83718264e-04f, 9.57382191e-03f, -3.63141969e-02f, 2.83867884e-02f, 9.78919119e-03f,
  1.25314638e-01f, -5.69819100e-02f, 2.65370049e-02f, 5.38654327e-02f, 4.36189994e-02f, -7.52102071e-03f, -4.32423241e-02f, 3.48543341e-04f, -4.49283719e-02f, 4.78017777e-02f,
  8.95547420e-02f, -2.98204422e-01f, -2.94405550e-01f, -1.08156137e-01f, 1.95332885e-01f, 1.85617700e-01f, -9.25747752e-02f, -3.35633680e-02f, -2.57852346e-01f, -1.26404658e-01f,
  1.43250888e-02f, -1.52878359e-01f, -2.56451249e-01f, -1.08688749e-01f, 3.83006260e-02f, -2.44318888e-01f, 9.92207900e-02f, -1.02099098e-01f, -4.74820361e-02f, 7.16789216e-02f,
  7.46301860e-02f, 1.20103762e-01f, -1.23313442e-01f, 2.64115572e-01f, 1.33305401e-01f, 2.00149164e-01f, 2.61521816e-01f, 1.11441292e-01f, 2.78949797e-01f, 5.66317104e-02f,
  7.54066259e-02f, -6.61805794e-02f, -5.23881204e-02f, -7.58655816e-02f, -1.14927655e-02f, 3.76112647e-02f, 9.58973393e-02f, 2.35078353e-02f, 7.55125731e-02f, 4.60815281e-02f,
  8.99316519e-02f, 7.42049441e-02f, 1.23323083e-01f, 2.67866068e-02f, 6.25627488e-03f, 4.39073220e-02f, -1.36637278e-02f, 2.92942636e-02f, 5.09026088e-02f, -1.42095998e-01f,
  -1.02926880e-01f, 2.74529923e-02f, 7.61731490e-02f, -7.36027658e-02f, 2.18681945e-03f, 5.02974400e-03f, 1.20274059e-01f, 8.94610360e-02f, 5.44155538e-02f, 4.11911793e-02f,
  2.41530184e-02f, 7.80560374e-02f, 2.10774057e-02f, 1.00291315e-02f, -7.18804821e-02f, -3.48618962e-02f, -4.57003228e-02f, 1.43160680e-02f, -6.94399625e-02f, -2.14934116e-03f,
  -1.06447302e-01f, 4.92441207e-02f, -5.91068864e-02f, 5.55259846e-02f, 1.81704424e-02f, -2.42814492e-03f, 5.55493422e-02f, 5.19910902e-02f, -1.52211310e-02f, -5.35626970e-02f,
  -5.44429719e-02f, 7.00257942e-02f, 6.62388355e-02f, -7.12207460e-04f, -4.36905362e-02f, -8.44299644e-02f, 5.25393300e-02f, 5.71813248e-03f, 1.47342943e-02f, -7.42116421e-02f,
  -1.85698718e-02f, 4.06322517e-02f, -1.16294980e-01f, 4.42369618e-02f, 8.47016796e-02f, 5.88368960e-02f, -1.32051989e-01f, -1.01071142e-01f, -7.23600090e-02f, -8.14529285e-02f,
  1.87399954e-01f, 2.07558144e-02f, -7.46777505e-02f, 8.51835757e-02f, 1.22146823e-01f, -4.92998473e-02f, -1.24375960e-02f, -1.88416168e-02f, 3.02275904e-02f, -3.99482735e-02f,
  4.52135615e-02f, 4.45202552e-02f, 2.26051752e-02f, 4.82474128e-03f, 1.23108886e-02f, 6.18352927e-02f, 1.28291279e-01f, 1.87956747e-02f, -6.98700920e-02f, 5.39493002e-02f,
  -2.31088251e-02f, -1.57219216e-01f, 2.73528099e-01f, 1.02070093e-01f, -1.14155591e-01f, -2.74530947e-01f, -7.06034303e-02f, 8.20741430e-02f, -1.92615345e-01f, -2.73623288e-01f,
  -3.02753653e-02f, 7.46709555e-02f, 3.16776782e-02f, 1.74840212e-01f, 4.47706878e-01f, 9.80283320e-03f, 1.11597724e-01f, 3.95281240e-03f, 1.10210352e-01f, 1.80556163e-01f,
  1.65125176e-01f, 2.23069370e-01f, 3.74789029e-01f, 2.43553057e-01f, 1.78643569e-01f, 6.92430213e-02f, 2.38992929e-01f, 2.23606899e-01f, 1.37889534e-01f, 6.34491295e-02f,
  1.30071798e-02f, 1.13384306e-01f, 1.24181889e-01f, -4.47979122e-02f, 9.49541703e-02f, -3.65929236e-03f, 1.17095783e-01f, 7.91784003e-02f, 7.25163296e-02f, 4.18450218e-03f,
  -2.39757150e-02f, -3.60171199e-02f, 2.89920941e-02f, 4.51260023e-02f, -1.34732291e-01f, -1.73097663e-02f, 4.36636694e-02f, -1.29439158e-03f, 3.38380300e-02f, -1.31732404e-01f,
  2.86397710e-02f, -9.02567729e-02f, -8.24059024e-02f, -6.50966763e-02f, 3.29848640e-02f, -2.17630714e-01f, -1.14615716e-01f, -1.49543267e-02f, -6.97396174e-02f, 3.64360660e-02f,
  4.92379852e-02f, -1.07279614e-01f, -1.36271343e-01f, -6.59908950e-02f, 2.38066241e-02f, -8.42505917e-02f, 2.25713309e-02f, -9.40899327e-02f, 7.45736249e-03f, -3.56642576e-03f,
  -7.03936070e-02f, -2.32835077e-02f, 3.03498972e-02f, -4.69082557e-02f, -1.78633854e-01f, -1.21711418e-01f, 8.75591263e-02f, 1.23117015e-01f, -3.99664082e-02f, 1.07246675e-02f,
  -1.17462762e-02f, 1.98515784e-02f, -3.24772485e-02f, -2.55434364e-02f, -1.29287809e-01f, -2.01522764e-02f, -3.77763249e-02f, -7.12958649e-02f, 3.10714785e-02f, 1.20844141e-01f,
  -5.94840348e-02f, 1.60693616e-01f, 2.84148660e-02f, -3.77012305e-02f, 2.29184586e-03f, -2.97811422e-02f, 5.83197288e-02f, -4.02136706e-02f, 3.27832960e-02f, 1.59359738e-01f,
  6.72768876e-02f, 4.65299636e-02f, -1.59475788e-01f, 3.18164900e-02f, 1.34899095e-02f, 2.96836924e-02f, 1.45771019e-02f, 5.44608347e-02f, 1.65519826e-02f, 1.15857631e-01f,
  -7.38074305e-03f, -7.98002109e-02f, 1.06525570e-02f, -1.08920708e-02f, 2.25872081e-02f, 3.38492580e-02f, -1.38881713e-01f, -1.10039525e-01f, 1.99528951e-02f, 1.03561133e-02f,
  -2.13398650e-01f, 2.99605072e-01f, 1.88658953e-01f, 3.08524668e-01f, -7.52913356e-02f, -2.57703930e-01f, -3.09126198e-01f, 1.26393855e-01f, -4.83152345e-02f, -1.35976383e-02f,
  -3.25696985e-03f, -3.80246248e-03f, 1.45246446e-01f, 1.30204767e-01f, 1.28262714e-01f, 1.18051238e-01f, 1.14151120e-01f, -9.67249125e-02f, 1.41803294e-01f, 1.68309957e-01f,
  1.93418115e-01f, 1.21570438e-01f, 2.35195011e-01f, 1.08333796e-01f, 1.30551709e-02f, 1.91753015e-01f, 3.27854186e-01f, 1.62398502e-01f, 1.55758664e-01f, 1.32147121e-04f,
  -1.55194879e-01f, 1.40183598e-01f, -6.32654969e-03f, -5.54613955e-02f, 3.06613580e-03f, -1.35248676e-01f, 1.98990852e-03f, -5.79801798e-02f, 4.60934341e-02f, -7.41829425e-02f,
  -3.82958278e-02f, -1.97433233e-02f, -1.84467360e-02f, 3.62577885e-02f, -1.50783658e-01f, -1.56852901e-02f, 6.53654942e-03f, -2.53516659e-02f, 6.90882504e-02f, -6.73906729e-02f,
  4.08298383e-03f, -1.26937060e-02f, 3.88720110e-02f, -7.23698288e-02f, 2.47223787e-02f, -1.98669583e-02f, -3.82594876e-02f, 8.03502351e-02f, -9.07892287e-02f, 1.19954292e-02f,
  -6.14872836e-02f, 3.78964730e-02f, -6.92519546e-02f, -1.26727698e-02f, 2.77644489e-02f, 1.91686451e-02f, -8.26282427e-03f, -4.64951582e-02f, 2.61580087e-02f, -3.86729278e-02f,
  4.40789871e-02f, 5.39440736e-02f, -4.40756939e-02f, -5.06587047e-03f, -1.73440333e-02f, 2.82882154e-02f, -6.95074871e-02f, -5.60490675e-02f, -6.17880151e-02f, -4.97642048e-02f,
  5.00466898e-02f, -9.02958512e-02f, 2.25457996e-02f, -1.13485985e-01f, -4.73603122e-02f, 4.18958366e-02f, 9.32644233e-02f, 7.12156435e-03f, 1.49692930e-02f, 4.38294783e-02f,
  -1.10545969e-02f, 2.42088512e-01f, 4.29347642e-02f, -3.02487761e-02f, 4.23367582e-02f, 2.34144107e-02f, 5.44314198e-02f, -1.51031069e-03f, -2.81843692e-02f, 1.12718768e-01f,
  -2.53117625e-02f, -7.94437751e-02f, 1.27796695e-01f, -4.24737819e-02f, 1.00001208e-02f, 1.27568692e-02f, 3.91761698e-02f, -2.95632482e-02f, -1.66502148e-02f, 1.09738283e-01f,
  1.06598124e-01f, -4.36600000e-02f, 4.40540873e-02f, 2.21638214e-02f, -3.92144248e-02f, -6.70328289e-02f, -5.43193705e-02f, -4.18461785e-02f, 2.01750901e-02f, 1.69338789e-02f,
  -5.20787001e-01f, 1.11080810e-01f, -2.30004996e-01f, -3.40749547e-02f, -1.05465399e-02f, -1.18007109e-01f, -7.23268166e-02f, -5.04967831e-02f, -3.63155343e-02f, 2.40910351e-01f,
  2.15233609e-01f, -1.14347637e-01f, 1.23566858e-01f, 1.01721101e-01f, -3.55043530e-01f, 1.09864689e-01f, 2.49104500e-02f, -8.46733898e-03f, -6.79157674e-02f, -6.77331239e-02f,
  -1.49922401e-01f, 1.27460733e-01f, -4.35367264e-02f, 1.27049401e-01f, -1.01716645e-01f, -1.41809769e-02f, 9.41042677e-02f, 3.42803970e-02f, 8.69865119e-02f, -9.88093540e-02f,
  -1.59466967e-01f, 5.87936491e-02f, -9.41192210e-02f, -1.25647321e-01f, -2.54406687e-02f, -9.84772816e-02f, -8.11332390e-02f, -5.61602339e-02f, 1.51745481e-02f, -9.52957571e-02f,
  -9.88578051e-02f, -1.67935528e-02f, 8.35064426e-02f, 3.53692770e-02f, -1.07637867e-01f, 9.22130346e-02f, 4.01799604e-02f, 4.34094854e-02f, -6.50317669e-02f, -4.07663845e-02f,
  9.90575831e-03f, -4.80508013e-03f, 2.65084002e-02f, 8.99650380e-02f, 4.57317494e-02f, 1.25449210e-01f, -2.51740813e-02f, -9.29400101e-02f, -4.02308032e-02f, -5.96507713e-02f,
  3.66157442e-02f, 2.05148682e-02f, -8.23056400e-02f, 4.18216176e-02f, -2.17356929e-03f, -6.66666925e-02f, -3.68960015e-02f, -3.66851650e-02f, -1.89052671e-02f, -3.00961733e-02f,
  2.04707161e-02f, -2.80423891e-02f, -2.76811104e-02f, 5.34487031e-02f, 6.90557659e-02f, -6.75183348e-03f, 4.90164496e-02f, -5.10369763e-02f, -2.34520026e-02f, -2.60837283e-02f,
  -1.61792692e-02f, 4.94407229e-02f, -1.72248799e-02f, -4.45390269e-02f, 2.08079051e-02f, -1.27769243e-02f, 7.13995919e-02f, -1.12689644e-01f, -1.69954041e-03f, -1.33177051e-02f,
  -8.55817720e-02f, 6.80105016e-02f, 1.03411309e-01f, -1.74535345e-02f, -4.66138199e-02f, -8.51232708e-02f, 7.11027458e-02f, -1.15929030e-01f, 4.20416705e-02f, 9.76748671e-03f,
  9.56346840e-03f, -4.95101213e-02f, 7.36315455e-03f, -3.08522843e-02f, -5.07163219e-02f, 3.23457606e-02f, -1.65126622e-02f, -4.21360880e-02f, -3.22596692e-02f, 4.19464102e-03f,
  9.84955430e-02f, 1.07468918e-01f, 3.11548915e-02f, 1.15541309e-01f, -7.13723991e-03f, 8.47391710e-02f, -7.71423802e-02f, -4.70095389e-02f, -7.33175725e-02f, -4.69304062e-02f,
  2.37063393e-01f, -2.50912845e-01f, -1.60434812e-01f, -9.99963880e-02f, -1.31385133e-01f, -3.25626105e-01f, -3.07877272e-01f, -8.71205032e-02f, 7.95159116e-02f, -1.54668882e-01f,
  -1.10224031e-01f, -2.31536739e-02f, 5.11737801e-02f, -1.81239873e-01f, 3.03826839e-01f, 1.73368216e-01f, -1.67357013e-01f, -1.47064805e-01f, 2.01462165e-01f, -1.88900113e-01f,
  1.18277758e-01f, -1.15317971e-01f, -3.94611992e-02f, -1.44098341e-01f, -2.67658651e-01f, -1.48275280e-02f, 1.04720339e-01f, -2.28917181e-01f, -2.18404740e-01f, -1.24399729e-01f,
  -4.78127562e-02f, 1.57338008e-01f, -4.42620404e-02f, 3.59388487e-03f, 1.20605174e-02f, 5.36414236e-02f, -1.80142537e-01f, -1.17381178e-01f, 2.69689094e-02f, -1.73832458e-02f,
  8.66312813e-03f, 1.69142574e-01f, -9.03318524e-02f, 8.02935287e-02f, -4.05257307e-02f, -2.19395831e-02f, -8.34866893e-03f, 6.86351210e-02f, -7.17481971e-02f, -3.73778567e-02f,
  -4.02545929e-02f, -2.11656932e-02f, 8.01737327e-03f, 1.55447396e-02f, 1.03193030e-01f, -2.32375506e-02f, -9.88342538e-02f, -9.75742340e-02f, 5.16046509e-02f, 5.15717454e-02f,
  9.99143929e-04f, 7.67486840e-02f, -1.31538408e-02f, -3.90050150e-02f, 1.08662872e-02f, -1.28574427e-02f, -6.38066754e-02f, -4.67401987e-04f, -1.71556864e-02f, -5.49049526e-02f,
  -6.18783496e-02f, -1.90439895e-02f, -3.95733118e-03f, -7.45616630e-02f, -6.83414862e-02f, -2.61976160e-02f, -2.62066089e-02f, -9.81604308e-02f, -3.62870693e-02f, -3.05182450e-02f,
  4.46175970e-03f, -5.68543449e-02f, -6.15852140e-02f, 2.03987118e-02f, -6.36821464e-02f, 2.37004235e-02f, 6.83428496e-02f, 2.07993463e-02f, 2.46971156e-02f, -3.68868150e-02f,
  -4.06978205e-02f, 7.50008747e-02f, 1.60648637e-02f, -9.95022804e-02f, -8.80994871e-02f, 2.79356577e-02f, 1.84196942e-02f, 5.51116914e-02f, -6.19951785e-02f, -1.08682234e-02f,
  -9.06971544e-02f, 1.05944853e-02f, -3.45201530e-02f, -3.06661818e-02f, -9.64364335e-02f, -2.45256983e-02f, -7.68265575e-02f, 6.18630089e-02f, -7.10374117e-03f, 6.55973926e-02f,
  -5.97429164e-02f, 3.26198973e-02f, 2.56124958e-02f, -5.82064465e-02f, 6.28661551e-03f, -2.10872646e-02f, -8.98080971e-03f, 2.47757901e-02f, -3.81414369e-02f, -2.76030246e-02f,
  2.30131879e-01f, 1.49655849e-01f, 2.22456798e-01f, 2.14018703e-01f, -1.24314696e-01f, -1.92410678e-01f, -2.55333245e-01f, -6.50839210e-02f, 8.71583447e-02f, -1.48193359e-01f,
  -2.14762703e-01f, 1.88279524e-01f, -2.66835183e-01f, 1.61278918e-01f, 2.46880457e-01f, -1.71608567e-01f, 2.35970736e-01f, -1.09925754e-01f, 6.22087307e-02f, 9.52119455e-02f,
  2.52295911e-01f, 1.33928135e-01f, 2.80075252e-01f, 1.22690715e-01f, 8.82939175e-02f, 1.24331243e-01f, 1.46049514e-01f, -2.39025112e-02f, 1.71635449e-01f, 3.73951718e-02f,
  7.32478574e-02f, 6.01000898e-02f, 5.61993457e-02f, -4.62948345e-02f, 8.12386721e-02f, -4.21715267e-02f, -9.37532187e-02f, -4.90479395e-02f, 4.44663763e-02f, -6.75897151e-02f,
  8.79322644e-03f, 2.55270321e-02f, 1.75517544e-01f, -1.50377033e-02f, 4.89287870e-03f, 9.21180844e-02f, -5.50686056e-03f, 1.11428022e-01f, -6.11970574e-02f, -6.64186925e-02f,
  8.44598189e-02f, 1.29445354e-02f, 9.41435061e-03f, 8.55783075e-02f, 1.48167670e-01f, 1.05702624e-01f, -4.51407069e-03f, -1.79301109e-02f, -2.26741051e-03f, 1.39026985e-01f,
  -7.07426518e-02f, -1.49400970e-02f, -5.94389215e-02f, 4.13987041e-03f, -1.28796231e-02f, 3.68337519e-02f, 7.34492615e-02f, -4.16684756e-03f, 9.62978750e-02f, -2.19693128e-02f,
  2.56161299e-02f, 1.07535474e-01f, -9.41419825e-02f, -7.51695409e-02f, 8.20881203e-02f, -1.81540987e-03f, 6.54562041e-02f, -7.48276412e-02f, -5.60542196e-02f, -1.70204993e-02f,
  -4.62607294e-02f, -6.20105863e-02f, 5.49463043e-03f, 1.87190305e-02f, -1.13288052e-01f, -7.94018954e-02f, -9.84335616e-02f, -9.99806076e-02f, 1.36001818e-02f, -1.48644093e-02f,
  6.32641837e-02f, 1.17769666e-01f, 2.85717938e-02f, 3.57816778e-02f, 6.98258728e-02f, 1.01734214e-01f, 7.71858469e-02f, 9.63343605e-02f, 1.11558519e-01f, -1.27199799e-01f,
  3.64978686e-02f, 8.35096911e-02f, -1.44752124e-02f, 6.82005063e-02f, 3.25087793e-02f, 7.77283683e-02f, -5.80023881e-03f, 1.12564281e-01f, 1.23368189e-01f, 7.70631805e-03f,
  -1.08417854e-01f, -4.23051044e-02f, 7.72012472e-02f, 1.05702162e-01f, 6.80637136e-02f, 2.77105998e-02f, 2.00192295e-02f, -3.31634954e-02f, -9.45387408e-02f, 1.36370376e-01f,
  -5.55222154e-01f, 1.88538000e-01f, 1.70168310e-01f, -2.66479105e-01f, -1.74715862e-01f, 2.87130803e-01f, 5.53841256e-02f, 1.05636641e-01f, 1.24008523e-03f, 1.83999509e-01f,
  -5.49865142e-02f, -2.49858350e-01f, 1.91284001e-01f, -1.34445429e-02f, 1.73914835e-01f, 2.52850980e-01f, 1.57380447e-01f, 7.24316016e-02f, -1.43522814e-01f, -1.79676354e-01f,
  -5.55501096e-02f, -1.59642175e-01f, 4.63119261e-02f, -1.26205549e-01f, -1.31976053e-01f, -7.32912347e-02f, -1.97088271e-01f, -1.40483633e-01f, -9.81926844e-02f, -1.40892029e-01f,
  -5.60739040e-02f, -2.13420182e-01f, -2.84741763e-02f, 2.75037158e-02f, -6.64074346e-02f, 6.84422553e-02f, -3.37790586e-02f, -7.12763593e-02f, -1.38190523e-01f, -5.05367294e-03f,
  -8.45557600e-02f, 4.01802640e-03f, -4.48709875e-02f, -3.87370884e-02f, -4.41938229e-02f, -5.39105646e-02f, 8.90236571e-02f, 2.97031179e-02f, 8.50679800e-02f, 3.19585986e-02f,
  9.16745812e-02f, 1.63175631e-02f, 9.66568962e-02f, 2.26035528e-02f, -6.07497580e-02f, -4.62967791e-02f, 6.64278194e-02f, -3.27195376e-02f, -6.31540939e-02f, 3.08745932e-02f,
  -1.27169356e-01f, 1.00007489e-01f, 8.56967270e-02f, 4.78093252e-02f, 6.13657609e-02f, -4.76992950e-02f, -3.15712616e-02f, -6.04672320e-02f, -9.29486975e-02f, -1.25136718e-01f,
  -6.67107776e-02f, 3.91306169e-02f, -5.20873070e-02f, -1.85176218e-03f, 1.74717663e-03f, 4.41126488e-02f, 3.05255176e-03f, -8.27711970e-02f, 1.05018578e-01f, 7.71676078e-02f,
  1.60011221e-02f, 2.29935013e-02f, -1.18375778e-01f, 2.80216560e-02f, -4.80131954e-02f, 9.04905125e-02f, -3.75827141e-02f, 4.22495864e-02f, -8.66887644e-02f, -4.48019467e-02f,
  -1.37861237e-01f, -2.30705097e-01f, -4.74235117e-02f, -1.91920131e-01f, 1.91669203e-02f, 4.42786030e-02f, 4.43105698e-02f, 2.36452632e-02f, -4.32634205e-02f, -6.92749247e-02f,
  -3.45467106e-02f, -2.17382852e-02f, -8.39790255e-02f, 2.17268523e-02f, 8.73050168e-02f, 6.58208281e-02f, -1.17860198e-01f, -8.92793573e-03f, -7.01692328e-02f, -1.46920048e-02f,
  -8.94906931e-03f, -5.10022901e-02f, -7.89139345e-02f, -9.99081507e-02f, 5.77199683e-02f, -2.90001929e-02f, 3.84437628e-02f, 4.66812029e-02f, -4.52552661e-02f, 9.99875069e-02f,
  -1.58003643e-01f, -2.94249028e-01f, 2.29543358e-01f, -1.68621168e-01f, 5.67655899e-02f, 2.26548538e-01f, 2.99340010e-01f, -2.84574002e-01f, -3.84172499e-01f, -1.74564898e-01f,
  9.92134809e-02f, 3.87320924e-03f, 3.29715461e-01f, -1.26892194e-01f, 3.05746943e-01f, 1.95010811e-01f, -5.68280183e-02f, 1.04455821e-01f, 1.27433250e-02f, -2.28357613e-02f,
  7.33935856e-04f, -2.75143292e-02f, 3.40292305e-01f, -1.66180521e-01f, 4.60016206e-02f, -1.21584497e-01f, 5.24155647e-02f, 1.13866650e-01f, -1.89817980e-01f, -2.14781556e-02f,
  1.14437774e-01f, -1.22061335e-01f, 1.21507138e-01f, -1.84922386e-02f, -8.35893005e-02f, 1.73499528e-02f, 1.05531827e-01f, 2.10352957e-01f, 4.33063582e-02f, -7.04921857e-02f,
  1.47251377e-03f, -1.13661684e-01f, -1.75058126e-01f, 8.83061066e-02f, -1.20944165e-01f, -1.36893615e-01f, -4.55440991e-02f, 4.88361344e-02f, 1.86426602e-02f, 7.89549351e-02f,
  1.32422999e-01f, -4.62225601e-02f, 1.00278474e-01f, -9.56478342e-02f, -5.11798263e-02f, -1.28622323e-01f, 9.83687341e-02f, 1.80139571e-01f, 6.81394711e-03f, -1.19924456e-01f,
  -6.13996945e-03f, 1.04098748e-02f, 1.66119803e-02f, 8.99160728e-02f, -2.68571521e-03f, 3.94835137e-03f, -3.18069160e-02f, 1.14905253e-01f, -3.55514586e-02f, -2.41550431e-02f,
  3.57967913e-02f, 3.81355686e-03f, 4.63280044e-02f, 6.30209669e-02f, -2.21731532e-02f, -5.42411990e-02f, 1.13428414e-01f, -1.10129882e-02f, 1.49889402e-02f, 1.53133916e-02f,
  -7.85043165e-02f, -1.99162178e-02f, 1.20234890e-02f, -8.25055316e-03f, -6.18917570e-02f, 1.18114635e-01f, -7.38978460e-02f, 7.64663517e-02f, 8.45850036e-02f, 7.77718201e-02f,
  3.15409862e-02f, -3.09033573e-01f, -4.51551229e-02f, 3.25414278e-02f, 5.89403175e-02f, 5.74810617e-02f, -3.48565131e-02f, -2.15909019e-01f, -2.02777553e-02f, 6.66241944e-02f,
  1.82537306e-02f, -7.72170024e-03f, -2.90616993e-02f, -6.78391159e-02f, -9.30274129e-02f, -9.39508677e-02f, 5.80056906e-02f, -7.99866579e-03f, 7.51055703e-02f, -1.94234028e-02f,
  -4.69268970e-02f, 2.93957461e-02f, -6.19806722e-02f, -1.99131854e-02f, -1.75505430e-02f, 5.27741499e-02f, -5.15271153e-04f, -1.02823330e-02f, -4.24541123e-02f, -3.12326383e-02f,
  4.16341983e-02f, -1.86923489e-01f, -3.25826734e-01f, -2.25026868e-02f, 8.43233541e-02f, 2.83994049e-01f, 4.97990996e-02f, 7.74917006e-02f, -9.72368121e-02f, 1.51335001e-01f,
  2.05515414e-01f, 5.48818521e-02f, -2.23947555e-01f, 2.32662544e-01f, 2.70198971e-01f, -8.62402171e-02f, 1.77764058e-01f, 9.19284746e-02f, -2.92600859e-02f, 8.95926580e-02f,
  4.26939428e-02f, 3.49464625e-01f, -2.33851373e-02f, 1.45916492e-01f, 1.79212958e-01f, -1.86643392e-01f, -2.66839974e-02f, -1.72143638e-01f, 2.67641783e-01f, 1.92970812e-01f,
  1.19679190e-01f, -1.31342830e-02f, -4.36351784e-02f, 1.12087149e-02f, -1.29684526e-02f, 4.91575897e-02f, -5.76784536e-02f, -1.74692646e-02f, 2.77366620e-02f, -4.78352867e-02f,
  -9.93778259e-02f, 4.34785672e-02f, 5.11922427e-02f, -2.85163894e-02f, -4.56079692e-02f, -1.03143431e-01f, -4.75618541e-02f, -2.44465210e-02f, -2.87614036e-02f, 6.34826720e-02f,
  -4.21985611e-02f, -9.49639305e-02f, 1.24541819e-02f, 4.65456136e-02f, 9.48070083e-03f, 6.49758205e-02f, -1.21456981e-01f, -9.01897624e-02f, -5.06542325e-02f, 6.24861233e-02f,
  5.79648577e-02f, 5.78804116e-04f, -6.58192188e-02f, -7.56121501e-02f, 9.41424351e-03f, 1.80438459e-02f, 9.12224129e-02f, -5.14184274e-02f, -9.25873872e-03f, 3.14593464e-02f,
  6.52289437e-03f, 5.95234968e-02f, 8.25663731e-02f, 9.31815132e-02f, 4.49483097e-02f, 4.83864322e-02f, 1.83534324e-02f, 8.70585367e-02f, -1.30503684e-01f, -1.63487829e-02f,
  4.76277545e-02f, 2.27325689e-02f, -5.61839622e-03f, -4.26993817e-02f, -2.46226583e-02f, 8.76769051e-03f, 1.03975318e-01f, 4.54199091e-02f, 3.08993999e-02f, -5.82746137e-03f,
  1.04431123e-01f, -1.03756003e-01f, -2.92613842e-02f, -4.40007560e-02f, -6.96008876e-02f, 8.81346408e-04f, 8.23831558e-02f, 2.64812671e-02f, 6.84970170e-02f, -3.54458131e-02f,
  6.81427047e-02f, -8.47642217e-03f, 5.70712872e-02f, 3.17394547e-02f, -3.90970670e-02f, 4.21591550e-02f, -2.29970776e-02f, 2.08521932e-02f, 3.41256373e-02f, 6.81807399e-02f,
  -7.36817792e-02f, -1.22291535e-01f, 4.62700613e-03f, -7.74614215e-02f, 3.69792618e-02f, 4.58934866e-02f, 2.19948385e-02f, -3.59690301e-02f, -1.01254769e-02f, 1.45423773e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.57308534e-01f, 1.51913375e-01f, 1.18902661e-01f, 2.26340845e-01f, 9.74443033e-02f, 3.31400111e-02f, 7.66433626e-02f, 1.55800000e-01f, 8.22487697e-02f, 1.70073092e-01f,
  1.76016033e-01f, 1.30195484e-01f, 1.72819182e-01f, 2.38581911e-01f, 1.49571627e-01f, 1.30412340e-01f, 1.67969123e-01f, 2.10289866e-01f, 1.65225074e-01f, -6.26732130e-03f,
  2.24816561e-01f, 1.43859804e-01f, 2.42193267e-01f, 1.21950723e-01f, 1.75171569e-01f, 9.64211449e-02f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  3.63814905e-02f, 5.27501218e-02f, 1.92097798e-01f, -4.71977405e-02f, 7.38229305e-02f, -1.14568837e-01f, 3.97775546e-02f, 8.35862383e-03f, 7.36331716e-02f, -1.36644226e-02f,
  4.10887226e-02f, -5.75590059e-02f, 9.83593389e-02f, -1.72046013e-02f, -4.77038696e-02f, -1.66468397e-02f, 6.51277602e-02f, 6.36349469e-02f, -2.10938193e-02f, 4.12645936e-02f,
  1.19666435e-01f, 6.26774505e-02f, -1.36919376e-02f, -1.61056325e-03f, 5.99583797e-03f, 5.11382297e-02f, 4.06980664e-02f, 8.65590796e-02f, -2.56778132e-02f, 5.43712964e-03f,
  1.29749864e-01f, 1.05253652e-01f, 9.26020443e-02f, 8.78922790e-02f, 5.99231310e-02f, 5.88162020e-02f, 2.06466783e-02f, 1.09190270e-01f, 5.31795099e-02f, -2.26957630e-02f,
  6.40463904e-02f, 6.05101585e-02f, -5.89335524e-02f, -3.02126855e-02f, 1.30388126e-01f, 1.10377155e-01f, 1.50953457e-02f, -7.32103139e-02f, 1.01624817e-01f, 5.45870215e-02f,
  -9.41335931e-02f, 3.93837428e-04f, -8.76679793e-02f, 1.58317331e-02f, 1.36685241e-02f, 1.88732103e-01f, -6.82741180e-02f, -2.59495806e-02f, -7.73188174e-02f, 1.67834625e-01f,
  -1.70947611e-01f, -1.20754629e-01f, 1.02727205e-01f, -1.25608325e-01f, 3.48361582e-02f, 7.00585172e-02f, 1.40486643e-01f, 7.33700991e-02f, -4.89059240e-02f, -2.14855019e-02f,
  -1.37871400e-01f, 9.60569233e-02f, 4.37539034e-02f, 9.87620372e-03f, 5.79951964e-02f, -6.40353374e-03f, -9.27500576e-02f, -1.37236550e-01f, -6.70099333e-02f, 8.55047777e-02f,
  -5.92151359e-02f, 1.31916143e-02f, -8.50820616e-02f, -9.92228985e-02f, 1.23598680e-01f, -4.34053480e-04f, 7.75717869e-02f, -7.23904520e-02f, 9.04100761e-02f, -8.44719559e-02f,
  -7.99826160e-02f, 1.74945921e-01f, 7.36631379e-02f, 2.86632888e-02f, 7.23043606e-02f, 1.03434198e-01f, -4.16633040e-02f, -6.61973506e-02f, -1.91095900e-02f, 7.57954568e-02f,
  -2.09993407e-01f, -1.06390994e-02f, 9.79351848e-02f, -1.02325223e-01f, -1.14793763e-01f, 2.23645591e-03f, 1.77989259e-01f, -2.75722370e-02f, -9.50460285e-02f, -1.69663504e-01f,
  -9.85504165e-02f, -2.24151369e-02f, 1.71116143e-01f, 6.84573948e-02f, 1.88718423e-01f, -1.36391684e-01f, 7.04538897e-02f, 1.93130095e-02f, 9.90277249e-03f, -1.03800155e-01f,
  -1.29964575e-01f, -1.02971688e-01f, -4.37257737e-02f, 1.10266328e-01f, -1.17230546e-02f, 2.42999922e-02f, 1.57686085e-01f, -1.21733390e-01f, -4.66509685e-02f, 1.10225528e-01f,
  1.08154401e-01f, -8.33288208e-02f, 1.26581779e-03f, -5.35176732e-02f, -2.85431705e-02f, 3.41192484e-02f, 3.21945623e-02f, -8.40716213e-02f, -4.55538668e-02f, -7.90468752e-02f,
  8.14590454e-02f, -7.38205835e-02f, 6.68570166e-03f, 8.50575864e-02f, -8.04163814e-02f, -7.70605877e-02f, -5.96760102e-02f, 1.34370197e-02f, 4.36196029e-02f, 6.51578605e-02f,
  9.40616727e-02f, 3.95452604e-02f, -4.00426723e-02f, -1.52689044e-03f, 5.32268966e-03f, 7.09991455e-02f, 2.23660786e-02f, -5.08277528e-02f, 4.29251157e-02f, -2.83603668e-02f,
  -3.57226767e-02f, -2.26222109e-02f, 1.00854272e-02f, -1.07373022e-01f, 1.57154739e-01f, 1.32533833e-01f, 3.27544585e-02f, 3.46546359e-02f, -2.25611292e-02f, 8.92969593e-02f,
  -1.26581922e-01f, 2.79938523e-02f, -5.33608757e-02f, -4.10755426e-02f, 1.11151941e-01f, -1.27155408e-02f, 2.31875107e-03f, 7.11877644e-02f, -8.89144763e-02f, -1.00443192e-01f,
  9.03897732e-02f, 1.85258016e-01f, 7.40058795e-02f, 1.84298620e-01f, -1.30286247e-01f, 1.49142012e-01f, -8.71622041e-02f, 3.33791375e-02f, -1.22031435e-01f, -1.06694944e-01f,
  4.65674475e-02f, 9.98306349e-02f, 4.58327904e-02f, 1.88143849e-01f, 6.27322942e-02f, -1.92472503e-01f, -1.45147100e-01f, -1.48500815e-01f, -1.66439667e-01f, -9.51454490e-02f,
  3.20003480e-02f, 1.00897223e-01f, 1.05307326e-01f, 1.41953096e-01f, 1.64426535e-01f, 1.41186744e-01f, -1.33790612e-01f, -2.53167581e-02f, -3.29063013e-02f, -9.58087295e-02f,
  -1.62106771e-02f, -1.10463947e-01f, 7.09374174e-02f, 2.69266851e-02f, 4.74746572e-03f, 8.23293328e-02f, 5.70630282e-02f, -1.11776136e-01f, 9.62917507e-02f, -3.57593745e-02f,
  5.04873656e-02f, -1.59571037e-01f, 2.02297978e-02f, 1.09920599e-01f, 4.48845886e-02f, 6.95339218e-02f, 7.04331771e-02f, -6.67737797e-02f, -3.20579112e-02f, -1.14973314e-01f,
  -2.30479017e-01f, -5.71430288e-02f, 3.73958759e-02f, -2.33478174e-01f, 3.23744789e-02f, -9.60971713e-02f, 9.72004160e-02f, -1.83616936e-01f, -1.90151811e-01f, -7.10661709e-02f,
  -3.76194194e-02f, -9.75348614e-03f, 2.13213321e-02f, -2.03433167e-02f, 9.83641576e-03f, 2.01170631e-02f, 5.36739267e-02f, -1.52879879e-01f, 7.75335878e-02f, 1.62635837e-02f,
  -6.14420623e-02f, -6.78487420e-02f, 2.01759208e-02f, 1.11047149e-01f, 2.56341010e-01f, -1.13972209e-01f, -4.58425842e-02f, 7.12222680e-02f, 3.26695517e-02f, -1.25263944e-01f,
  -4.90441322e-02f, -5.79990633e-02f, -4.12567481e-02f, 4.87018637e-02f, -1.11862784e-02f, -6.34576231e-02f, 5.38719334e-02f, -6.18822016e-02f, 7.62284780e-03f, 1.27370125e-02f,
  -2.49725934e-02f, 1.03977628e-01f, -1.35200113e-01f, -1.02017950e-02f, -8.03029686e-02f, -7.57817999e-02f, -4.15834598e-02f, 3.37319858e-02f, -7.98164681e-02f, 4.23137564e-03f,
  -1.64756253e-02f, -1.54393166e-02f, 4.01294678e-02f, -1.94362476e-02f, -6.79369569e-02f, 5.60512878e-02f, 1.59586929e-02f, -5.18748797e-02f, 8.99805687e-04f, -1.26219451e-01f,
  -2.62229647e-02f, 1.02297686e-01f, 1.25663644e-02f, 4.12659757e-02f, -8.38757828e-02f, 6.60855621e-02f, -1.24116484e-02f, 2.90709417e-02f, -2.68680938e-02f, -1.05166040e-01f,
  -4.48652357e-02f, -7.35190734e-02f, 1.71000827e-02f, 7.35498816e-02f, -8.42156261e-02f, -2.78365915e-03f, -7.40203485e-02f, 3.23566906e-02f, -7.64911845e-02f, 8.41859356e-02f,
  1.04204781e-01f, 1.06869051e-02f, -3.95055413e-02f, 5.65240122e-02f, -1.63303390e-02f, -9.13521554e-03f, -2.03656614e-01f, 8.93573929e-03f, 6.07268959e-02f, 5.78908958e-02f,
  -5.92656694e-02f, -1.90139506e-02f, 4.06623594e-02f, -6.64940253e-02f, 1.78070311e-02f, -6.15210459e-02f, -1.04929984e-01f, -8.70600790e-02f, 6.15506433e-02f, 1.63753062e-01f,
  -1.07214004e-01f, -9.88691002e-02f, -6.94635510e-02f, 7.21090958e-02f, -3.46051925e-03f, -8.55344813e-03f, -1.58919066e-01f, -9.89920348e-02f, 9.50286388e-02f, 1.80050768e-02f,
  5.45640402e-02f, 1.91760495e-01f, -3.87280360e-02f, -1.65347755e-02f, 1.17028821e-02f, -1.21293634e-01f, 1.20917894e-01f, -1.85841903e-01f, 6.69746846e-02f, -7.16400445e-02f,
  -7.98246488e-02f, 1.07793741e-01f, 1.34369075e-01f, 1.65977746e-01f, 2.36230567e-02f, 1.45424470e-01f, -4.39404920e-02f, -1.83871597e-01f, 1.08388104e-01f, 2.38959454e-02f,
  -5.28934188e-02f, -8.57738256e-02f, 6.71231188e-03f, -1.40552595e-01f, -2.10933425e-02f, 6.31895959e-02f, -1.67820603e-01f, -1.23605840e-01f, -4.39635329e-02f, -1.74472183e-01f,
  7.41468295e-02f, -8.91657844e-02f, 4.74599116e-02f, -5.28237559e-02f, 4.01806422e-02f, 1.06892794e-01f, 8.46374184e-02f, -5.87895326e-02f, -1.06941007e-01f, 1.85411111e-01f,
  4.35712114e-02f, 6.18780628e-02f, 9.41777751e-02f, -5.79981655e-02f, 3.79312076e-02f, -7.13743363e-03f, -1.76904034e-02f, -1.01279676e-01f, 5.79482643e-03f, -6.62158355e-02f,
  -8.88949111e-02f, -3.31661031e-02f, 3.48403342e-02f, 2.90327892e-02f, 4.24066633e-02f, -2.05102302e-02f, -1.61327142e-02f, 4.95351814e-02f, 5.69871478e-02f, -1.16180032e-02f,
  -7.18606263e-02f, 6.15911372e-02f, -7.22073391e-02f, -6.94159865e-02f, -6.97762296e-02f, 1.03987738e-01f, -1.61601588e-01f, 6.16275705e-02f, -1.27374195e-02f, 5.19129410e-02f,
  3.36334445e-02f, -5.54071739e-02f, -7.83932284e-02f, -1.20039396e-02f, 5.62572107e-02f, -8.10737684e-02f, -1.42864078e-01f, -1.86040755e-02f, 1.43806683e-03f, 1.63248539e-01f,
  -1.85721330e-02f, 6.27214136e-03f, -2.09723189e-02f, 7.39322305e-02f, -1.18173972e-01f, -6.21471107e-02f, 5.79013117e-02f, -1.33567564e-02f, 8.39866400e-02f, -5.86462324e-04f,
  -8.37592185e-02f, -3.33166309e-02f, 4.00407389e-02f, 5.65506406e-02f, -1.18750660e-02f, -1.81478560e-01f, -1.88034445e-01f, -6.10767156e-02f, 3.62793878e-02f, 1.44208400e-02f,
  -1.04310349e-01f, -1.98646020e-02f, -6.69051111e-02f, -1.76600963e-01f, 1.06753640e-01f, -2.19519511e-01f, 1.74120665e-01f, -1.22520812e-01f, -4.87321615e-02f, 1.86517134e-01f,
  8.80043805e-02f, -3.80816460e-02f, 1.00865684e-01f, -1.42624766e-01f, 1.51139433e-02f, 1.31050408e-01f, 1.20712966e-01f, 1.97457373e-01f, -1.60949752e-02f, -9.91929919e-02f,
  -2.14150548e-02f, -5.51097132e-02f, 1.34165987e-01f, 3.92601453e-02f, -1.43874153e-01f, -8.09355676e-02f, -9.40288827e-02f, -1.94820598e-01f, 1.00917391e-01f, -1.11945398e-01f,
  -1.59767836e-01f, -1.95924699e-01f, -2.13726088e-02f, 4.09910195e-02f, -6.34676963e-02f, 5.88389300e-02f, 4.21459675e-02f, 1.11577891e-01f, 1.97295561e-01f, 1.37342051e-01f,
  2.73624044e-02f, 9.89579335e-02f, -4.43495624e-02f, 1.60347208e-01f, -6.17064647e-02f, 1.05793200e-01f, 2.89150029e-02f, -1.22957528e-01f, -1.72869772e-01f, -1.19346298e-01f,
  1.03962868e-01f, 4.06367332e-02f, -9.00636539e-02f, 1.04068518e-01f, -1.53758392e-01f, -5.75884245e-02f, 2.07802579e-01f, -7.52883330e-02f, 2.90276140e-01f, -1.22164644e-01f,
  9.02863070e-02f, 1.23653241e-01f, 7.80663732e-03f, 7.02664927e-02f, 1.57303423e-01f, 1.26241893e-01f, 8.15305263e-02f, 3.98047715e-02f, 8.90023482e-04f, 8.23989436e-02f,
  1.58832222e-01f, -2.70769615e-02f, 4.11506137e-03f, 1.83424298e-02f, -7.97555372e-02f, -5.92298731e-02f, -1.34002000e-01f, 1.40483916e-01f, -4.49098721e-02f, -5.78901730e-02f,
  -1.40918670e-02f, 3.77907641e-02f, 2.79649440e-02f, 4.15594131e-02f, -9.39849615e-02f, 2.11732257e-02f, 2.03288682e-02f, -4.62936908e-02f, -2.24794745e-02f, 3.10443956e-02f,
  -9.15761814e-02f, -1.23264112e-01f, -5.64106666e-02f, 4.63473499e-02f, 7.14895576e-02f, -1.85210332e-02f, 7.33133480e-02f, -5.29192155e-04f, 1.12239541e-02f, -7.92986229e-02f,
  -8.28886628e-02f, -4.34244201e-02f, -1.28572196e-01f, -5.68361878e-02f, -1.21410958e-01f, 1.05398018e-02f, 2.68042106e-02f, -1.02547094e-01f, 4.97317463e-02f, -1.11304656e-01f,
  -1.34291947e-01f, 6.96179341e-04f, 9.98232365e-02f, -6.15108162e-02f, 8.34194291e-03f, 8.63272846e-02f, 1.80246995e-03f, 2.01317854e-02f, 8.01129732e-03f, -5.87685481e-02f,
  -7.71494284e-02f, 5.34737017e-03f, 5.09293303e-02f, 1.80620506e-01f, 1.78361952e-01f, 4.44405712e-02f, 5.80257438e-02f, -5.35366423e-02f, -9.19319466e-02f, -4.81736585e-02f,
  1.68318450e-01f, 6.28471300e-02f, -4.27409336e-02f, 4.30312864e-02f, -8.26260820e-02f, 1.29088417e-01f, 6.28277659e-02f, -1.12014845e-01f, -1.80922896e-01f, -2.13808138e-02f,
  -1.03791393e-01f, -5.88948315e-04f, -9.30629671e-02f, -5.71526363e-02f, -1.09400533e-01f, -1.01474315e-01f, -8.14755913e-03f, 3.40654850e-02f, 6.66106641e-02f, 1.80124700e-01f,
  -1.72823206e-01f, 1.21106459e-02f, -1.16812356e-01f, 1.64450034e-02f, 6.23661168e-02f, 1.40959829e-01f, -1.74515367e-01f, 1.54606849e-01f, 9.99265537e-02f, 2.35181749e-01f,
  -1.13464400e-01f, 2.62488090e-02f, 1.00662172e-01f, -2.86183134e-02f, -6.30378798e-02f, -1.60823077e-01f, -1.62014827e-01f, 7.96232279e-03f, 1.62658453e-01f, 1.65321736e-03f,
  1.08027987e-01f, -7.78959412e-03f, 4.23730090e-02f, -1.66422829e-01f, -2.27955997e-01f, 6.83938637e-02f, 5.25747985e-02f, 1.43532977e-01f, -9.37125757e-02f, -1.13557965e-01f,
  9.68915522e-02f, 1.58828929e-01f, 5.88873252e-02f, 1.40621543e-01f, -1.32857159e-01f, -1.35274353e-02f, -1.00848958e-01f, 7.66454935e-02f, -5.28901294e-02f, -1.60011262e-01f,
  -3.46902125e-02f, 9.23615322e-02f, -8.32157210e-03f, -1.05417613e-02f, -1.60601035e-01f, -7.48978853e-02f, 1.73940197e-01f, -1.08422317e-01f, -1.87383100e-01f, 1.30440816e-01f,
  -3.21976319e-02f, 1.37001470e-01f, 3.64165753e-02f, -1.59595418e-03f, 1.34607442e-02f, -1.02962060e-02f, -4.15993445e-02f, 7.92281106e-02f, 3.08941794e-03f, 7.35644773e-02f,
  6.96936473e-02f, -9.76901129e-02f, 6.10418133e-02f, 8.81869346e-02f, 5.18671982e-02f, 1.06950022e-01f, 3.40351984e-02f, -7.77853429e-02f, -5.31406887e-02f, 2.11415929e-03f,
  4.85624745e-02f, 3.73268910e-02f, -4.22720946e-02f, 6.75048381e-02f, 4.81212772e-02f, 2.08810001e-04f, 6.98148608e-02f, -1.11794844e-03f, 4.42931391e-02f, 6.62038773e-02f,
  6.06300160e-02f, 3.31914462e-02f, 2.66049057e-02f, 2.97259185e-02f, 3.59522901e-03f, 5.61142266e-02f, 6.50758296e-02f, -1.34723872e-01f, -3.43496315e-02f, 4.19640280e-02f,
  -1.60969943e-02f, 5.61114028e-02f, 1.82341069e-01f, -2.84930300e-02f, 6.78523257e-02f, -2.71715485e-02f, -9.32818651e-03f, -7.27074221e-02f, -8.05409849e-02f, -8.05336088e-02f,
  6.11824170e-02f, 2.27145124e-02f, 3.87660041e-02f, 1.04562588e-01f, -6.80064131e-03f, -3.10724205e-03f, -1.09120004e-01f, -1.75556898e-01f, -8.00200030e-02f, -2.14655057e-01f,
  -1.71473771e-02f, 1.04101911e-01f, -6.17058314e-02f, -9.14619341e-02f, -1.62699461e-01f, 2.25924458e-02f, 3.51335481e-02f, -1.19663313e-01f, 8.06215033e-02f, 1.60521995e-02f,
  1.82304919e-01f, -5.28604649e-02f, 6.05709255e-02f, 3.50708701e-02f, -1.96893029e-02f, -9.94405970e-02f, 5.32528497e-02f, 4.86840606e-02f, 1.58422098e-01f, 1.51073903e-01f,
  4.65514995e-02f, -1.41910568e-01f, -1.42733797e-01f, -5.72167262e-02f, 1.81816682e-01f, 8.41585472e-02f, -1.31862283e-01f, 1.72233194e-01f, -5.03212810e-02f, -3.29995416e-02f,
  -1.15363285e-01f, -9.26001966e-02f, -1.96932331e-02f, 3.09197349e-03f, -7.68916979e-02f, -1.05551302e-01f, 3.90106179e-02f, 2.85593444e-03f, 1.23240791e-01f, -5.46747856e-02f,
  1.03526630e-01f, -8.12479854e-02f, -9.35349241e-02f, -4.51381020e-02f, 8.34437162e-02f, 2.82874629e-02f, -1.46661907e-01f, 1.21554956e-02f, 3.78137045e-02f, 1.37409523e-01f,
  7.22100446e-03f, -4.75749150e-02f, -1.01171834e-02f, 1.94389507e-01f, 1.01959094e-01f, 1.43278569e-01f, 3.49891484e-02f, -6.65243119e-02f, 1.23507611e-01f, 1.52791396e-01f,
  8.86135772e-02f, -1.21527418e-01f, -1.13621145e-01f, -2.31983870e-01f, 2.74513997e-02f, 8.66991729e-02f, 1.56907469e-01f, 8.76643509e-02f, -1.27073703e-02f, -4.91785146e-02f,
  3.59149724e-02f, 5.84977902e-02f, -1.35825261e-01f, 3.41458246e-02f, 1.25994571e-02f, 1.97945852e-02f, -4.94703501e-02f, 1.08882748e-01f, -1.74493007e-02f, 1.46477874e-02f,
  4.77180071e-02f, 5.76842390e-02f, 7.72533715e-02f, 8.74460936e-02f, 1.51323276e-02f, 2.27862690e-02f, 7.61363506e-02f, 6.82770535e-02f, 8.00750032e-03f, -9.59808007e-03f,
  2.37954054e-02f, 2.84666549e-02f, 1.64669193e-02f, 7.47076347e-02f, 4.63994816e-02f, -2.88914237e-02f, -1.84331592e-02f, 3.18357497e-02f, 4.89418842e-02f, 6.62450641e-02f,
  -2.11817976e-02f, 6.26850575e-02f, -4.82764840e-03f, 1.32323587e-02f, 1.13930590e-01f, 1.87991038e-02f, -2.10803710e-02f, 8.29833671e-02f, -8.56727958e-02f, -3.67975160e-02f,
  1.02074906e-01f, 1.03705816e-01f, 4.71080914e-02f, 3.40325497e-02f, 1.13120452e-01f, -6.82622492e-02f, -4.20775898e-02f, -5.88645190e-02f, -3.53186205e-02f, -1.66619703e-01f,
  1.02451548e-01f, 6.94915056e-02f, 6.56663477e-02f, 6.51209727e-02f, -1.57574177e-01f, -2.42178957e-03f, 8.88444707e-02f, -1.96012691e-01f, -8.14616606e-02f, -5.90120107e-02f,
  7.92423412e-02f, -2.78873718e-03f, -7.02723339e-02f, 2.24151481e-02f, -1.30863950e-01f, -7.99263790e-02f, -8.20471048e-02f, -1.49539769e-01f, -7.25569203e-02f, -2.75914352e-02f,
  7.70373046e-02f, 9.89607796e-02f, -2.94580720e-02f, 4.59067933e-02f, 1.97253436e-01f, 7.77209848e-02f, 7.67468067e-04f, 1.15544103e-01f, -7.89818242e-02f, -5.96272722e-02f,
  -1.46872833e-01f, -1.20204212e-02f, 1.46520913e-01f, 7.22945258e-02f, -3.26503776e-02f, 5.34843802e-02f, -8.63220766e-02f, -5.31270467e-02f, 1.99709237e-01f, -1.34438440e-01f,
  4.04696800e-02f, -8.83488432e-02f, 7.63418153e-03f, 1.50910467e-01f, 4.91574444e-02f, 1.03886090e-01f, 6.05668835e-02f, -1.11090012e-01f, 1.77639760e-02f, -1.01993799e-01f,
  -2.61421837e-02f, -1.09653724e-02f, 1.85210496e-01f, -5.98824807e-02f, -9.25006792e-02f, 3.85249257e-02f, -1.58514790e-02f, -1.54523691e-02f, -3.28022763e-02f, 7.99113065e-02f,
  -1.06833041e-01f, 5.41264676e-02f, 1.08190611e-01f, -5.63072897e-02f, 1.46630988e-01f, -1.17802821e-01f, 2.07408499e-02f, 3.86910923e-02f, 1.87125638e-01f, 1.62133649e-01f,
  -8.91913623e-02f, -1.84755847e-02f, 1.42248631e-01f, 1.99215934e-01f, 1.19631737e-01f, -2.77343728e-02f, 3.69267426e-02f, -2.71818396e-02f, -2.13036425e-02f, 7.27242976e-02f,
  1.20603584e-01f, -5.80929592e-02f, -1.65906139e-02f, 5.96884312e-03f, 3.47205848e-02f, 1.69559233e-02f, -7.11987838e-02f, -5.86909354e-02f, 3.85980867e-02f, 6.15262706e-03f,
  9.54282507e-02f, -3.55341770e-02f, -5.46576120e-02f, -3.66982445e-02f, 9.19414535e-02f, -6.35303836e-03f, 1.24943770e-01f, -1.24445893e-01f, 1.38119087e-01f, 7.22358823e-02f,
  -1.03241593e-01f, 6.23472072e-02f, -9.46891829e-02f, -1.03541575e-02f, 4.45685573e-02f, 1.01358317e-01f, 7.60321841e-02f, 1.42133251e-01f, 2.73371693e-02f, -1.01493701e-01f,
  2.50292774e-02f, 6.54257685e-02f, -5.99411391e-02f, 3.24726179e-02f, 2.65905783e-02f, -5.31083252e-03f, -8.19091648e-02f, 6.69845492e-02f, 8.57472867e-02f, 2.71866638e-02f,
  -4.00844999e-02f, -8.03357884e-02f, 4.10718657e-03f, 1.08233787e-01f, 4.13708985e-02f, -6.07301154e-05f, -1.16562828e-01f, 6.23321347e-02f, 9.52662900e-02f, 3.68513316e-02f,
  2.98490226e-02f, -1.71188582e-02f, 2.83856653e-02f, 3.80169079e-02f, 5.34127578e-02f, -1.15979962e-01f, -1.32470593e-01f, 2.47021332e-01f, 1.04215490e-02f, -8.98216665e-02f,
  -5.10089397e-02f, 4.63079028e-02f, -4.47298044e-05f, -1.30381778e-01f, -3.66886482e-02f, 1.80100381e-01f, 3.70318666e-02f, -6.50771856e-02f, 6.50557727e-02f, -6.44805059e-02f,
  1.36939228e-01f, -4.72943904e-03f, 1.58344749e-02f, 5.10688163e-02f, -2.11733788e-01f, 4.08038646e-02f, 1.23391204e-01f, -9.61695611e-02f, 1.54636368e-01f, 3.80585194e-02f,
  5.04864119e-02f, 1.47380218e-01f, -8.70916620e-02f, 1.18104517e-01f, 1.49907455e-01f, -7.78799132e-02f, 8.44389126e-02f, -1.17960580e-01f, -3.23943533e-02f, -3.26839741e-03f,
  -2.04216037e-02f, -2.99374666e-02f, 9.24296677e-02f, 8.72466043e-02f, -7.21709877e-02f, -1.73950389e-01f, -3.30775219e-04f, -1.26811564e-01f, -5.20316102e-02f, 1.98487669e-01f,
  2.26375267e-01f, 2.01081172e-01f, 1.15127042e-02f, 3.64273749e-02f, 6.75684512e-02f, -1.35937825e-01f, 4.36801054e-02f, 6.43693656e-02f, -1.16951942e-01f, 6.93975314e-02f,
  -2.36663416e-01f, 6.47782162e-02f, -3.49812768e-02f, -1.94205903e-02f, -9.49372724e-02f, -1.37293115e-01f, -1.09161949e-02f, 1.46614864e-01f, 2.23110686e-03f, -7.03912452e-02f,
  -9.18792263e-02f, -7.40959197e-02f, 6.33940399e-02f, -5.10556512e-02f, 5.14114276e-02f, 5.85148521e-02f, -1.65052071e-01f, -3.74623761e-02f, -4.65481691e-02f, -9.94272754e-02f,
  4.86640632e-02f, -6.47692382e-02f, -4.46707606e-02f, -6.85108006e-02f, -5.21170422e-02f, -6.69898987e-02f, -3.43007781e-02f, 7.35694217e-03f, -1.82071496e-02f, -1.22537628e-01f,
  -6.07125312e-02f, -4.53990698e-02f, 9.69997421e-03f, -7.76641443e-02f, 2.07785740e-02f, 6.52943626e-02f, 9.44846794e-02f, -5.99122867e-02f, 1.20042868e-01f, 5.80969639e-02f,
  -3.81258666e-03f, -5.55854999e-02f, -1.61684416e-02f, 5.03609218e-02f, 2.70032119e-02f, 1.36251664e-02f, 2.94206571e-03f, 2.31814459e-02f, 1.42867975e-02f, -5.62202232e-03f,
  -1.53460456e-02f, 3.96474004e-02f, -1.17699407e-01f, -1.60085466e-02f, 1.27358967e-02f, 3.76249626e-02f, -1.14318967e-01f, -1.74220242e-02f, 4.53227907e-02f, -5.45803718e-02f,
  2.20802482e-02f, 1.23339102e-01f, 1.91868115e-02f, -3.38454521e-03f, 6.04923058e-04f, -2.90708034e-03f, 2.07662210e-02f, -3.19972634e-02f, 1.57397106e-01f, -4.29918803e-02f,
  2.24027745e-02f, 2.45151684e-01f, 2.20021784e-01f, 7.02173859e-02f, 1.00440577e-01f, 1.12527706e-01f, -1.14936851e-01f, 5.47450744e-02f, 9.61108878e-02f, 2.70691998e-02f,
  5.83224697e-03f, -1.45559371e-01f, 1.14351317e-01f, -1.67883188e-01f, -1.05802387e-01f, -1.69851005e-01f, 9.08119753e-02f, 5.50776236e-02f, -1.60771191e-01f, 1.64418425e-02f,
  -1.12650424e-01f, 8.62856507e-02f, -1.36616260e-01f, -1.16646454e-01f, 7.55612403e-02f, -7.55698839e-03f, 1.99559242e-01f, 8.76659751e-02f, -1.43544286e-01f, 7.58565590e-02f,
  -3.13827097e-02f, -3.29775475e-02f, -6.23481497e-02f, 1.81581885e-01f, 1.02244720e-01f, -1.79580078e-01f, -2.18351573e-01f, -5.05233966e-02f, -1.76835909e-01f, -5.89369163e-02f,
  8.00038353e-02f, 5.32338582e-02f, 1.03166379e-01f, 1.27236664e-01f, 8.98792297e-02f, -1.54032364e-01f, -2.35074237e-02f, 1.26351938e-01f, 6.83539128e-03f, -8.43750488e-04f,
  -4.88518253e-02f, 3.11738160e-03f, 2.54295021e-01f, 3.19159068e-02f, 6.49857968e-02f, 2.63933651e-02f, -3.59285921e-02f, -2.54580289e-01f, -1.42870203e-01f, -4.68633100e-02f,
  5.89860715e-02f, -2.11117938e-01f, -1.12658031e-01f, 2.78586205e-02f, 1.70270279e-02f, 3.35386358e-02f, -4.97716628e-02f, 1.34241864e-01f, -5.48008792e-02f, -4.47534248e-02f,
  -2.15415042e-02f, 6.30686581e-02f, -6.36265278e-02f, -3.02411113e-02f, 1.19310766e-01f, -9.61613506e-02f, -6.51689544e-02f, -7.23076165e-02f, -4.50627767e-02f, 5.69454208e-02f,
  -4.42657247e-02f, -8.58169165e-04f, -1.80999003e-02f, 4.09773588e-02f, -2.09273659e-02f, 3.60246338e-02f, 5.73288314e-02f, 3.39593403e-02f, 1.11512035e-01f, 1.31107956e-01f,
  -9.01308004e-03f, 1.66667923e-02f, 7.98343346e-02f, -2.15542484e-02f, -8.98006633e-02f, 4.99768369e-02f, -4.55326401e-02f, 1.04993582e-01f, 5.89840822e-02f, 1.28128558e-01f,
  -4.25125845e-02f, -7.38769844e-02f, 8.79647285e-02f, 5.66229261e-02f, -3.26537602e-02f, 1.04222097e-01f, 4.24227007e-02f, 1.15833573e-01f, -2.95612831e-02f, 5.24143092e-02f,
  -4.55167592e-02f, 1.63030974e-03f, -2.95367856e-02f, 6.43047616e-02f, -5.79006374e-02f, 8.48878641e-03f, 1.24535538e-01f, 4.82377596e-02f, -5.27288802e-02f, 4.40218672e-02f,
  6.21799044e-02f, 8.87104869e-02f, 7.18571022e-02f, -3.08682770e-02f, -1.25273272e-01f, -1.50111243e-01f, -9.30992588e-02f, 1.22467250e-01f, -1.79810822e-01f, -1.60718530e-01f,
  -3.52224223e-02f, 1.31617591e-01f, -1.14883229e-01f, -1.53098300e-01f, 8.04806128e-02f, 4.18901443e-03f, 6.87479675e-02f, -1.26029700e-01f, 6.33611903e-02f, 1.08527265e-01f,
  -1.49820223e-01f, -1.23202994e-01f, 2.63726106e-03f, 6.71390444e-02f, -1.40073299e-01f, 6.11331128e-02f, 2.63072867e-02f, 5.86709194e-02f, 8.30612779e-02f, -9.94546935e-02f,
  4.00030427e-02f, 4.68625724e-02f, -1.90246299e-01f, 1.19639181e-01f, -2.39134338e-02f, 4.00761031e-02f, 1.33102641e-01f, -2.76565086e-02f, -6.85084462e-02f, 1.06477812e-01f,
  9.43442434e-02f, -6.28290772e-02f, -2.60835839e-03f, 3.92566845e-02f, 1.51125818e-01f, -5.04600666e-02f, 7.36251026e-02f, 1.94256142e-01f, 1.15669340e-01f, -4.70842719e-02f,
  -1.16091646e-01f, 1.56777725e-01f, -2.02141538e-01f, -2.88311765e-02f, -6.04421692e-03f, -1.61038548e-01f, -2.26165846e-01f, 5.38142510e-02f, 1.84848520e-03f, -9.34436470e-02f,
  -1.18398234e-01f, 4.94047217e-02f, -2.36060023e-02f, 2.75767408e-02f, 2.56637726e-02f, 1.36374161e-01f, 2.17134446e-01f, -5.35116866e-02f, -2.61127092e-02f, 5.97890802e-02f,
  1.72927622e-02f, -4.07877192e-02f, 8.08374733e-02f, 8.51762220e-02f, 1.30694034e-02f, 2.44358610e-02f, 2.08510891e-01f, 5.25547564e-02f, -5.56194503e-03f, -1.02293149e-01f,
  -1.34060159e-01f, 2.06704214e-02f, 3.65611315e-02f, -2.09751297e-02f, -3.51934545e-02f, 4.27896082e-02f, -4.36571352e-02f, 6.50563743e-03f, 2.44587194e-02f, 5.57492189e-02f,
  -2.71753147e-02f, 1.48677239e-02f, 1.37574300e-01f, -9.70943049e-02f, -8.41115266e-02f, 4.50933026e-03f, -3.61901671e-02f, 8.53450969e-03f, -1.53226238e-02f, 1.09111123e-01f,
  -7.53038237e-03f, 4.39786613e-02f, 1.19293451e-01f, -4.23115231e-02f, -4.87343073e-02f, -2.64749806e-02f, 9.20432508e-02f, 1.05892934e-01f, 3.47186089e-03f, 5.46022058e-02f,
  -2.06235070e-02f, -3.00346836e-02f, 9.79437586e-03f, 9.33978558e-02f, 1.27099389e-02f, -1.24731824e-01f, 6.43436015e-02f, 1.09278336e-01f, 1.15850091e-01f, -7.69058848e-03f,
  -9.44674909e-02f, -6.05218671e-02f, -5.38692586e-02f, 1.77356713e-02f, -6.43975958e-02f, -1.88740413e-03f, -7.53448636e-04f, -3.82899083e-02f, 5.48545318e-03f, 2.95941383e-02f,
  4.34759222e-02f, 3.54182236e-02f, -3.52599807e-02f, 4.57647257e-03f, -5.10605760e-02f, 1.79818109e-01f, -1.21336550e-01f, -5.92023209e-02f, -1.32184058e-01f, 2.22118348e-01f,
  9.91311949e-03f, 2.10178178e-02f, 1.55625045e-02f, -5.42939417e-02f, 1.36215016e-01f, -1.51562437e-01f, -1.35969236e-01f, -1.10674626e-03f, -1.84853822e-01f, 8.49852487e-02f,
  -2.25906938e-01f, 1.35458857e-01f, -1.15771718e-01f, -2.20718235e-01f, 8.53509456e-02f, 1.42662406e-01f, 3.99072804e-02f, -2.33527329e-02f, -1.80834755e-02f, 1.04667984e-01f,
  -4.54721190e-02f, 7.93491080e-02f, -1.27354652e-01f, -3.31108202e-03f, -1.53639326e-02f, 3.28876413e-02f, 1.99137568e-01f, 2.15828508e-01f, -1.06301345e-01f, -1.12113796e-01f,
  -7.97231719e-02f, 3.88814136e-02f, 5.74696586e-02f, -1.68492556e-01f, 2.36849394e-02f, 1.45096987e-01f, -5.78235015e-02f, -1.81739762e-01f, -5.77403940e-02f, -3.43895219e-02f,
  -7.25734904e-02f, -1.26265153e-01f, -1.99197724e-01f, 5.24455793e-02f, -4.11563329e-02f, 5.95161207e-02f, -2.23055594e-02f, -1.18853934e-01f, -1.20566279e-01f, 2.29018405e-02f,
  3.60476449e-02f, -9.83261541e-02f, -7.32014924e-02f, 1.44727916e-01f, -1.94900110e-01f, 1.26755849e-01f, -7.71347210e-02f, -6.52785599e-03f, -1.51489601e-01f, -1.33648977e-01f,
  -7.87883550e-02f, -8.67693648e-02f, -1.37224346e-01f, -2.05776319e-01f, 2.28623189e-02f, 6.99011609e-02f, -8.59390199e-02f, -1.67062208e-01f, -2.37032864e-02f, 9.31246299e-03f,
  4.20713462e-02f, 3.65033075e-02f, -9.55987349e-02f, -1.69827100e-02f, 2.03733612e-02f, -9.52728167e-02f, 4.85472940e-02f, -3.35711353e-02f, 2.76592970e-02f, -2.36575082e-02f,
  -8.57751593e-02f, 5.21485582e-02f, -4.40966077e-02f, 8.43360871e-02f, 6.15463294e-02f, -1.13249868e-01f, -4.59543094e-02f, -1.56719889e-02f, -3.65154110e-02f, 9.85577777e-02f,
  -5.84288612e-02f, -1.03245825e-01f, -3.55817862e-02f, -7.34592741e-03f, 6.07126579e-02f, -6.96688667e-02f, 7.79775754e-02f, -5.12114502e-02f, 2.11367514e-02f, -3.06359977e-02f,
  -1.14395641e-01f, -2.32848991e-02f, 3.30955498e-02f, -1.59821939e-02f, 6.76093549e-02f, -3.37204076e-02f, -2.81934608e-02f, 7.75793334e-03f, -1.75426539e-03f, -6.52561411e-02f,
  1.41443953e-01f, 6.37337416e-02f, 3.22098136e-02f, 5.11539578e-02f, 1.84898004e-02f, 1.51440250e-02f, -8.84207636e-02f, -8.44693705e-02f, 1.41825587e-01f, -2.16958359e-01f,
  -2.22049817e-03f, 5.26212491e-02f, 1.04059894e-02f, -1.28656313e-01f, -6.60196394e-02f, 1.82777425e-04f, -6.61793649e-02f, -2.40630642e-01f, 9.07714367e-02f, -5.38263954e-02f,
  2.33930070e-03f, -4.55759801e-02f, -2.46693399e-02f, 1.04071476e-01f, -1.68586820e-02f, -2.36466876e-03f, 6.86006173e-02f, -2.26158604e-01f, -1.55589897e-02f, -2.01881211e-02f,
  -2.10107211e-02f, -2.57958025e-02f, 3.09168035e-03f, -5.67362085e-02f, 2.43571535e-01f, 3.15076113e-02f, 7.82265663e-02f, -2.56119370e-02f, 1.13475285e-02f, -1.66479871e-01f,
  -9.29554477e-02f, 6.62607374e-03f, 1.62650511e-01f, -6.95642009e-02f, -3.39286365e-02f, -6.68194592e-02f, -1.59180865e-01f, 1.48894981e-01f, 3.71014215e-02f, -2.34760833e-03f,
  1.92712098e-02f, 1.65100284e-02f, 9.99540538e-02f, 8.71076137e-02f, -1.07585654e-01f, 3.28287520e-02f, 1.06306538e-01f, 2.94644777e-02f, 1.24150835e-01f, -1.16290167e-01f,
  -1.07300974e-01f, -1.54984118e-02f, 1.22233550e-03f, -7.82978088e-02f, -1.02606826e-01f, 5.70514500e-02f, -6.82088733e-02f, 1.11994922e-01f, 8.21493343e-02f, 5.99430464e-02f,
  6.56727999e-02f, 9.52220857e-02f, 8.93911719e-02f, 5.10778725e-02f, -3.72653790e-02f, -3.70511934e-02f, 4.33515683e-02f, 3.97113077e-02f, 1.56549007e-01f, 1.80075362e-01f,
  -1.04029313e-01f, -7.28885680e-02f, -2.15113014e-02f, 1.50077119e-01f, 7.78204948e-02f, 9.79937017e-02f, 5.00647537e-02f, -6.63930271e-03f, 1.05572119e-01f, 1.45664560e-02f,
  -2.04250589e-03f, -8.23900774e-02f, -3.71235497e-02f, -5.63171646e-03f, -2.63569113e-02f, -7.41387857e-03f, -4.65544313e-02f, 5.05303629e-02f, -5.34601584e-02f, -5.63343242e-02f,
  -4.40089330e-02f, -5.94436191e-02f, 2.66396385e-02f, 8.44641030e-02f, -2.19448935e-02f, 1.11881740e-01f, 6.72751069e-02f, -1.13541052e-01f, -6.15865439e-02f, -3.59186679e-02f,
  -3.12600583e-02f, -1.14062063e-01f, -1.11383341e-01f, 4.76705022e-02f, -5.05320206e-02f, -1.21652305e-01f, 6.35974109e-02f, 9.98293087e-02f, 3.47919166e-02f, -1.25911529e-03f,
  -1.11127250e-01f, 1.29802441e-02f, -1.24486871e-01f, 1.26870930e-01f, 1.58212423e-01f, -2.38161162e-02f, 1.89815219e-02f, -3.75464000e-02f, 1.13248490e-01f, -4.82262336e-02f,
  1.81220509e-02f, -2.36213468e-02f, -2.50973105e-02f, -8.29801112e-02f, 6.21750690e-02f, 3.94887775e-02f, -1.08316708e-02f, -9.02369991e-02f, -1.41683668e-01f, -1.84966251e-02f,
  -1.93553969e-01f, -5.21800146e-02f, 6.98533133e-02f, 1.65618751e-02f, -2.30481476e-01f, -5.34705035e-02f, 1.70510381e-01f, -6.65011331e-02f, -5.28349206e-02f, -8.86924788e-02f,
  1.00422557e-02f, 9.01840404e-02f, 1.30248621e-01f, 1.87948838e-01f, -9.75684971e-02f, -3.58562842e-02f, 1.23216566e-02f, 2.40159538e-02f, -1.03564724e-01f, -6.84886277e-02f,
  5.15418276e-02f, -1.49143025e-01f, 5.10999337e-02f, -1.62528783e-01f, 1.30505174e-01f, -1.19933315e-01f, 9.90479514e-02f, 1.95870772e-01f, 8.59678164e-02f, -9.77720916e-02f,
  1.16247855e-01f, -1.00029804e-01f, -1.84231371e-01f, -1.46288201e-01f, 4.49189311e-03f, 2.26077586e-02f, -2.55549639e-01f, 2.40341321e-01f, 4.97543477e-02f, 1.41143560e-01f,
  1.05428711e-01f, -1.13059461e-01f, -1.34781972e-01f, -1.66345060e-01f, -7.63991699e-02f, -4.55702581e-02f, -8.61452371e-02f, 7.82826170e-02f, -1.25259027e-01f, 2.48544291e-03f,
  -7.48614548e-03f, 8.15953091e-02f, 5.23749813e-02f, 5.91334961e-02f, -4.47649285e-02f, -1.81453854e-01f, 2.69891005e-02f, 9.93452221e-02f, 1.32758990e-01f, 6.81943372e-02f,
  -9.52258185e-02f, 4.32783552e-02f, -1.81335047e-01f, 1.12539366e-01f, 3.10859643e-02f, -1.35063529e-01f, -4.80675744e-03f, 1.33042768e-01f, 1.53617412e-01f, -1.69885665e-01f,
  -1.15913071e-01f, 2.40292237e-03f, 1.31012619e-01f, -5.66329733e-02f, 6.50980771e-02f, -3.19179222e-02f, 3.26621011e-02f, -1.04183853e-02f, 5.46509251e-02f, 3.21440026e-02f,
  3.44387777e-02f, 7.48201609e-02f, 1.02853976e-01f, 1.70091167e-01f, 6.28363283e-04f, -1.07952610e-01f, 7.45961517e-02f, 9.90110636e-02f, 4.99684103e-02f, 1.15362026e-01f,
  2.02748980e-02f, 9.82987061e-02f, -4.45263498e-02f, 1.27885476e-01f, -1.99672226e-02f, -4.26387647e-03f, 7.66149238e-02f, 4.01823781e-02f, -4.19341866e-03f, -1.40005331e-02f,
  -5.91901597e-03f, 1.05311193e-01f, -3.03859524e-02f, 1.05432011e-01f, -3.48382480e-02f, 1.37242019e-01f, 1.15794681e-01f, 2.36786772e-02f, 1.32131591e-01f, 3.43873799e-02f,
  5.88382334e-02f, -9.49092209e-02f, 1.23446837e-01f, 6.93371296e-02f, -3.32972482e-02f, 1.30526796e-02f, 1.83652624e-01f, 4.11984697e-02f, 5.15485592e-02f, -2.79673655e-02f,
  -5.75544909e-02f, 5.86312264e-02f, 1.33885108e-02f, 4.66028824e-02f, -1.33373104e-02f, 9.32829157e-02f, -6.96386248e-02f, 5.67181967e-02f, -2.23971177e-02f, -6.01955205e-02f,
  1.29812673e-01f, -1.77232891e-01f, -6.80863634e-02f, -1.36920124e-01f, -4.91219060e-03f, 1.69641837e-01f, 5.67422397e-02f, -1.76791742e-01f, -7.24717602e-02f, 1.26397476e-01f,
  3.49763259e-02f, -1.10403700e-02f, -8.25808719e-02f, 1.52038842e-01f, -4.52794544e-02f, 1.80071354e-01f, 6.28877580e-02f, -1.61958009e-01f, 3.34250778e-02f, -8.41609165e-02f,
  -3.60474885e-02f, -1.09195508e-01f, 3.41575891e-02f, 2.00958312e-01f, 2.52884887e-02f, -9.46958065e-02f, -9.38464925e-02f, -8.88731033e-02f, 7.18306303e-02f, 4.81929146e-02f,
  -1.59607921e-02f, -4.59850878e-02f, 1.00694649e-01f, -8.90080780e-02f, -9.13390517e-02f, 1.04626022e-01f, 8.25536065e-03f, 5.67971468e-02f, -3.29878293e-02f, -5.46328910e-02f,
  -1.09398648e-01f, 3.59294303e-02f, -3.03413589e-02f, -1.76086873e-01f, -1.02570288e-01f, 1.75859600e-01f, 1.50879100e-01f, 2.16535911e-01f, 2.23550022e-01f, 2.78371270e-03f,
  2.66891003e-01f, -2.13900525e-02f, -1.34102955e-01f, 3.75182438e-03f, -4.71581258e-02f, -1.91635154e-02f, 2.05965489e-01f, 1.91208005e-01f, 5.47081116e-04f, 5.44065684e-02f,
  6.33230060e-02f, 4.05864865e-02f, 1.06542081e-01f, -8.73043090e-02f, -9.62436050e-02f, -1.49275064e-01f, 7.74938017e-02f, -4.92411433e-03f, -7.33449161e-02f, 1.71551362e-01f,
  2.60421429e-02f, 7.76340859e-03f, 2.05928609e-02f, -4.90604788e-02f, 1.09995427e-02f, 1.05299659e-01f, 5.76018542e-02f, 7.87750855e-02f, 9.39656645e-02f, -3.14707570e-02f,
  -8.26158561e-03f, 1.38353199e-01f, -8.02939013e-02f, -4.16800044e-02f, -2.96939965e-02f, -9.61239263e-02f, 2.64792088e-02f, -3.99922989e-02f, -1.80469006e-02f, 4.35407721e-02f,
  -1.05818331e-01f, 2.51233280e-02f, 4.89577465e-02f, -1.61444265e-02f, 6.34482950e-02f, 4.76693036e-03f, 1.68239661e-02f, -5.12495860e-02f, 3.06320451e-02f, 2.68915351e-02f,
  3.74944471e-02f, 7.51633421e-02f, 8.02271292e-02f, -4.49171104e-02f, 6.13122843e-02f, 2.67092418e-02f, 8.07549059e-02f, -1.62792265e-01f, -2.31680311e-02f, 1.12358751e-02f,
  1.61201432e-01f, 8.17016736e-02f, -8.72755945e-02f, 5.12937568e-02f, 1.31882668e-01f, -1.02621101e-01f, -1.00656211e-01f, 3.44947465e-02f, 7.64638335e-02f, 2.04370022e-02f,
  -7.79364333e-02f, -8.03047419e-02f, 1.56864777e-01f, -3.13620344e-02f, -3.34206894e-02f, 1.93760365e-01f, -1.87386498e-01f, 8.67388994e-02f, 8.80725123e-03f, -4.89225686e-02f,
  9.10513625e-02f, 6.87702326e-03f, -1.75824929e-02f, 3.02802268e-02f, -1.57508850e-01f, 1.56656951e-01f, 9.21327844e-02f, -1.19979307e-01f, -1.79496631e-01f, -9.99444053e-02f,
  -1.64602965e-01f, 1.32092074e-01f, -9.01775211e-02f, 2.19927076e-02f, -1.55522391e-01f, -2.03739122e-01f, -1.09372484e-02f, 6.77516386e-02f, 1.08358540e-01f, -5.34640737e-02f,
  -1.42701790e-01f, -8.03453177e-02f, 3.81232798e-02f, -1.06968105e-01f, -5.95233142e-02f, -8.93135890e-02f, -9.14037302e-02f, 7.90324155e-03f, 7.70621970e-02f, 4.86490224e-03f,
  -2.21682623e-01f, -1.29396752e-01f, 1.50733134e-02f, 1.41822398e-01f, 5.75444363e-02f, -4.87316437e-02f, 3.39460596e-02f, 3.14090289e-02f, -9.31409448e-02f, -1.05082013e-01f,
  -4.73286919e-02f, -2.35320717e-01f, 1.37880147e-01f, -7.99542665e-02f, -1.19225405e-01f, 2.23862097e-01f, 9.31897834e-02f, -8.76365453e-02f, 6.54681446e-03f, -8.81466568e-02f,
  8.75046030e-02f, -1.69419181e-02f, -9.91788954e-02f, -6.19990239e-03f, -7.03392476e-02f, 1.74687102e-01f, -2.01449469e-01f, 6.50607124e-02f, -4.19094861e-02f, 1.75490454e-01f,
  5.13292588e-02f, -1.26842484e-01f, -1.16686963e-01f, -1.49406448e-01f, -2.29240861e-03f, -8.48422498e-02f, 4.70376723e-02f, 1.51385412e-01f, -7.40319863e-02f, 6.93787932e-02f,
  -1.12580627e-01f, -6.55559748e-02f, 8.72112215e-02f, -8.44973624e-02f, 1.05550148e-01f, 1.77634861e-02f, 9.90132987e-03f, 4.10070010e-02f, 4.23992844e-03f, 1.55873562e-03f,
  5.20194657e-02f, -6.44726604e-02f, 8.31673816e-02f, 2.37904377e-02f, -8.47722962e-02f, -1.00077152e-01f, -3.34259332e-03f, 5.31667238e-03f, -3.91252041e-02f, -3.16127576e-02f,
  -5.35398610e-02f, 3.58204171e-02f, -1.21353053e-01f, 8.69684592e-02f, -2.19888147e-02f, -5.19476086e-02f, 4.98645902e-02f, 5.51372208e-02f, 3.48599628e-02f, -2.24093795e-02f,
  2.84753852e-02f, 1.73072293e-02f, -4.36947495e-02f, 4.34187576e-02f, -3.09633669e-02f, 7.30124339e-02f, -6.29422665e-02f, -5.40272333e-02f, -2.65594595e-03f, -2.99361651e-03f,
  9.77176651e-02f, 3.26221175e-02f, -1.21368375e-02f, -8.60297754e-02f, 5.22036925e-02f, -5.99722320e-04f, -1.12216488e-01f, -2.57397816e-02f, 2.86727957e-02f, -5.34448121e-03f,
  7.40323737e-02f, 2.19676588e-02f, -1.62846804e-01f, -9.64118391e-02f, -4.18625847e-02f, -1.55908391e-02f, 6.37712330e-02f, -1.72529742e-01f, -1.89781174e-01f, 1.46760836e-01f,
  8.69376585e-02f, -5.76590821e-02f, 2.27186717e-02f, -1.44460127e-01f, 4.23806384e-02f, 7.27904886e-02f, 1.04536582e-02f, 1.72470093e-01f, -8.81128199e-03f, 1.40144959e-01f,
  6.60103336e-02f, 1.26302883e-01f, 4.69415411e-02f, -3.88506092e-02f, -7.73702282e-03f, -6.28957748e-02f, -1.02926210e-01f, -1.72411472e-01f, 6.98895156e-02f, 5.14891334e-02f,
  -4.91717905e-02f, 5.80951162e-02f, -3.43670286e-02f, -5.24269640e-02f, 3.03128548e-03f, -1.70456901e-01f, -1.63747221e-02f, -1.71203509e-01f, 9.33266524e-03f, -1.01555593e-01f,
  -1.66931421e-01f, 1.69090509e-01f, 8.69109184e-02f, 1.86942652e-01f, 2.71405745e-02f, -4.98446785e-02f, -8.56540650e-02f, -7.83953890e-02f, -7.72825927e-02f, 1.41922370e-01f,
  -6.86155185e-02f, 2.45520562e-01f, 9.82698277e-02f, -3.43933254e-02f, -2.31062710e-01f, 5.06413868e-03f, 1.31607503e-01f, -4.10035662e-02f, -6.08737469e-02f, -1.40680134e-01f,
  -1.35431839e-02f, -8.38792995e-02f, 1.95361167e-01f, 1.08100303e-01f, 1.55664282e-02f, -8.36071819e-02f, -3.61140706e-02f, 1.47435829e-01f, 1.22874789e-01f, 4.08449732e-02f,
  -1.01729915e-01f, -2.55155154e-02f, 1.29087821e-01f, 5.07197827e-02f, -3.53650376e-02f, -7.48632848e-02f, 1.45211341e-02f, -7.14652911e-02f, 2.98203379e-02f, 1.34236021e-02f,
  -6.90044463e-02f, -2.80309170e-02f, 2.02699230e-04f, 1.14286162e-01f, -9.91424080e-03f, -3.90594117e-02f, 2.77808290e-02f, 1.40394140e-02f, 1.70100387e-02f, 3.22031192e-02f,
  7.54945278e-02f, -6.91961572e-02f, -3.63202691e-02f, 2.05587633e-02f, 5.58433272e-02f, -7.27669597e-02f, 5.08960448e-02f, -7.74348751e-02f, 8.23548883e-02f, -2.93306634e-02f,
  -2.59159878e-03f, -5.77269420e-02f, 8.26214999e-02f, 8.06625001e-03f, -9.23028812e-02f, -6.94313506e-03f, -1.20006695e-01f, -3.66250500e-02f, -2.32365560e-02f, -1.07404158e-01f,
  -7.88410902e-02f, 1.01123519e-01f, -9.47917700e-02f, -7.24693015e-02f, -1.30136877e-01f, -6.83337823e-02f, 6.90799281e-02f, -1.95523705e-02f, 2.25601364e-02f, 6.89288825e-02f,
  -2.82609165e-02f, 6.42556250e-02f, -1.81598924e-02f, -7.23283663e-02f, 5.52213304e-02f, 6.82015568e-02f, -9.01650079e-03f, 3.36142145e-02f, -7.29525536e-02f, 1.70168757e-01f,
  4.42312360e-02f, -1.67648599e-01f, 1.01474494e-01f, -3.95807810e-02f, 1.68296397e-01f, 6.22549802e-02f, 1.45873306e-02f, 1.29399583e-01f, 1.02735057e-01f, 5.80364745e-03f,
  -2.66387947e-02f, -3.02685089e-02f, 4.05833721e-02f, -1.94672108e-01f, -1.20779369e-02f, 2.45747343e-01f, 3.76929119e-02f, 1.70970932e-01f, 4.71207909e-02f, 1.52622331e-02f,
  -1.67690322e-01f, -1.36594117e-01f, 4.43665460e-02f, 8.13114643e-02f, -2.84440108e-02f, -2.98427604e-02f, -1.46857155e-02f, 2.09689476e-02f, 1.75402001e-01f, 2.67557446e-02f,
  1.11094415e-01f, 1.16728790e-01f, -1.42869517e-01f, -8.76407698e-02f, 7.61974826e-02f, -6.11248054e-02f, -1.25934668e-02f, 8.49861950e-02f, -1.01368196e-01f, 1.28856942e-01f,
  -5.10784499e-02f, 1.72364607e-01f, -9.60007601e-05f, -1.26256824e-01f, -1.29648671e-01f, -1.75937623e-01f, 7.33888000e-02f, 1.57149225e-01f, -8.02129880e-02f, 9.04353410e-02f,
  3.90232019e-02f, -1.67719841e-01f, -8.62514786e-03f, 1.22498818e-01f, -1.72044411e-02f, 7.69797862e-02f, -6.68895766e-02f, -3.38912643e-02f, 1.39141724e-01f, 1.25792667e-01f,
  -3.23463306e-02f, -9.17809233e-02f, -9.32147875e-02f, 5.86550832e-02f, -1.21925259e-02f, -1.13619111e-01f, -1.07604407e-01f, 7.59409182e-03f, -1.39785111e-02f, 7.78258592e-02f,
  7.38949254e-02f, -1.35317460e-01f, 1.58486336e-01f, -6.49595633e-02f, -2.60476828e-01f, -1.30432263e-01f, -8.39203969e-03f, -2.72159595e-02f, 1.36751473e-01f, -4.79490012e-02f,
  -7.64618516e-02f, -5.73839620e-02f, -6.42619953e-02f, 2.81514470e-02f, -4.51201946e-02f, 6.79803565e-02f, -1.84576809e-02f, 4.36042435e-02f, -3.89784239e-02f, 6.92999139e-02f,
  -2.10515987e-02f, -4.57580248e-03f, 4.83707860e-02f, 5.10249063e-02f, -8.99590105e-02f, 2.76891552e-02f, 1.37494253e-02f, -4.71116491e-02f, -2.86646299e-02f, 9.41910073e-02f,
  -1.01672569e-02f, -8.19768757e-02f, -4.17345800e-02f, 3.91295142e-02f, 4.54724161e-03f, 2.40274332e-02f, -3.73822550e-04f, -1.56457145e-02f, -3.38320620e-02f, 1.39284745e-01f,
  -4.85811643e-02f, -5.28410561e-02f, -6.85707256e-02f, 2.60490496e-02f, 7.20134899e-02f, 7.71760792e-02f, 2.18997449e-02f, 5.44279590e-02f, -4.94820662e-02f, -9.28058699e-02f,
  5.69177605e-02f, 7.18647018e-02f, 9.38167982e-03f, -5.26995957e-02f, 4.42617312e-02f, -2.58270074e-02f, 3.07164751e-02f, -8.79542083e-02f, -4.87209037e-02f, -9.09177661e-02f,
  -1.00537755e-01f, 8.92076641e-02f, -3.82501893e-02f, -1.43240556e-01f, -1.38340995e-01f, 5.72364666e-02f, -1.12034297e-02f, -1.26704738e-01f, 1.05559565e-02f, 4.42531034e-02f,
  1.42614350e-01f, -1.66227613e-02f, 4.91480306e-02f, 7.40421563e-02f, -1.17945820e-01f, -1.36233181e-01f, -1.25678882e-01f, 2.00604364e-01f, -1.72775522e-01f, 5.78152165e-02f,
  -4.07803468e-02f, -8.02097283e-03f, -7.03115985e-02f, -1.67793274e-01f, 1.16777234e-01f, -1.34182692e-01f, -2.03386128e-01f, 1.94581784e-02f, -1.28708720e-01f, -5.17723151e-02f,
  -1.98472701e-02f, -3.54393311e-02f, 9.06812772e-02f, 1.39547521e-02f, -1.34455323e-01f, -8.65828991e-02f, -1.00924991e-01f, 1.75731048e-01f, 1.66825756e-01f, -3.94338854e-02f,
  1.04824483e-01f, 1.74654216e-01f, 7.76818991e-02f, -1.77198499e-01f, -8.62721950e-02f, 2.86666937e-02f, -5.03109545e-02f, 8.29682350e-02f, -4.57263328e-02f, -3.99775840e-02f,
  -1.74243763e-01f, 3.29478420e-02f, 9.82224345e-02f, -1.21583574e-01f, -6.99242428e-02f, 6.31519333e-02f, -2.77258232e-02f, -6.95064142e-02f, 5.24220578e-02f, 8.40457007e-02f,
  1.33628964e-01f, 4.23174240e-02f, -1.37632877e-01f, 1.19443171e-01f, 1.61139034e-02f, 9.92489308e-02f, 9.10122842e-02f, -5.29188514e-02f, -6.71212599e-02f, -1.01395398e-02f,
  2.24285468e-01f, 3.12098414e-02f, -1.31535411e-01f, 5.57319596e-02f, 3.07805240e-02f, 5.61566055e-02f, -4.36507612e-02f, 6.99783117e-02f, 1.51762133e-02f, 5.27742542e-02f,
  -8.66370499e-02f, 3.96139622e-02f, 5.97250089e-02f, -5.39741702e-02f, -1.19665697e-01f, 4.15584259e-02f, 4.09898423e-02f, -1.10273220e-01f, -2.70797350e-02f, 4.05215099e-02f,
  -7.39838034e-02f, -1.20644234e-02f, 9.56464186e-03f, -5.72124496e-02f, -3.31796370e-02f, -7.99791887e-02f, 1.29164830e-01f, -1.85109377e-02f, -2.82500274e-02f, 5.14069460e-02f,
  6.62218332e-02f, -1.04702294e-01f, -1.07425995e-01f, -2.97781527e-02f, 4.91198264e-02f, -1.06598750e-01f, 1.04165841e-02f, -1.53412949e-02f, 2.94272322e-02f, -9.74310711e-02f,
  -8.38289708e-02f, -5.78719713e-02f, 1.04550540e-03f, 2.31840163e-02f, 6.87323064e-02f, -3.16164531e-02f, 2.80009843e-02f, -5.51613346e-02f, -4.33833040e-02f, -7.50348046e-02f,
  6.80376589e-02f, -7.85269290e-02f, -5.64246476e-02f, 1.13029614e-01f, 6.33930340e-02f, 1.92346990e-01f, 1.71048209e-01f, 3.35377716e-02f, 7.38843307e-02f, 1.19144060e-01f,
  -9.27964300e-02f, -2.79415306e-02f, -2.06497200e-02f, 2.75240004e-01f, -1.79998010e-01f, 7.12170154e-02f, -1.27863169e-01f, 1.02725059e-01f, -3.46823148e-02f, -1.84104010e-01f,
  -7.20669553e-02f, 1.02075394e-02f, -4.34712432e-02f, 6.56485483e-02f, -4.61421907e-02f, -3.23348977e-02f, -1.36338413e-01f, -1.68629155e-01f, 1.03009164e-01f, 1.14600316e-01f,
  6.38408884e-02f, -2.84716394e-02f, -1.51029736e-01f, 1.23658210e-01f, -1.79769009e-01f, -3.58924782e-03f, -4.71630786e-03f, 1.20677739e-01f, -1.31637067e-01f, 5.56678325e-02f,
  2.24368319e-01f, 1.46425426e-01f, 6.14812151e-02f, -1.59288451e-01f, 1.22841924e-01f, 8.58727917e-02f, -1.63442437e-02f, -4.59370241e-02f, -1.43295318e-01f, -3.73733528e-02f,
  7.86361545e-02f, -1.10645734e-01f, -3.58060934e-02f, -2.57926267e-02f, -1.05796307e-01f, -5.92113240e-04f, -8.53632987e-02f, 3.53692584e-02f, 3.25457752e-02f, 1.54348940e-01f,
  -1.84831079e-02f, -2.30730891e-01f, 9.58813876e-02f, -2.58613713e-02f, -2.14796476e-02f, -4.47104275e-02f, -1.10503040e-01f, 1.34906853e-02f, -2.30068922e-01f, 1.53174639e-01f,
  6.04927633e-03f, -9.84839275e-02f, -2.54104566e-02f, -1.52390435e-01f, -1.89766556e-01f, -1.17735408e-01f, -1.50131255e-01f, 5.51662259e-02f, -1.16701110e-03f, -1.25344113e-01f,
  -2.65585959e-01f, -1.19822524e-01f, 6.43273667e-02f, 4.86050121e-04f, -1.21515684e-01f, -2.90789437e-02f, 7.50066563e-02f, -4.71129902e-02f, 1.22630969e-01f, -2.23820750e-02f,
  8.20547342e-02f, 6.29076511e-02f, -1.56187052e-02f, 2.42829565e-02f, -3.08082462e-03f, -4.13213111e-02f, -1.48593970e-02f, -1.23012580e-01f, -4.76413742e-02f, 5.72975688e-02f,
  5.57648949e-02f, -5.65229505e-02f, -7.23870024e-02f, 4.50218618e-02f, -7.11132511e-02f, 1.55366967e-02f, -1.21766003e-02f, -7.78192431e-02f, -5.14491610e-02f, -5.19126356e-02f,
  2.11853324e-03f, 3.67988683e-02f, 2.65354924e-02f, 2.80449949e-02f, 7.67407417e-02f, -4.17329483e-02f, 6.87810220e-03f, -5.60227558e-02f, 2.68948227e-02f, -5.28656086e-03f,
  -4.80965935e-02f, -5.32271788e-02f, -9.31055397e-02f, 3.00924690e-03f, -2.43690913e-04f, -2.87269913e-02f, -6.46416545e-02f, -1.55417435e-02f, 4.11883742e-02f, 8.98249298e-02f,
  -6.86473846e-02f, -3.75846326e-02f, 7.27737918e-02f, -1.60079196e-01f, -6.28094599e-02f, 1.49607122e-01f, 4.67644297e-02f, -7.29590431e-02f, 1.57556921e-01f, 1.65171623e-01f,
  1.34340629e-01f, -4.50467952e-02f, 2.19174460e-01f, 2.78474726e-02f, -5.13269976e-02f, 1.81020540e-03f, -6.28098398e-02f, 1.50604546e-01f, -4.34090123e-02f, -2.22993419e-02f,
  7.90180564e-02f, 4.93291356e-02f, 5.75363562e-02f, 6.55205548e-02f, 2.04874173e-01f, 1.37784542e-03f, -7.03172833e-02f, 9.21741202e-02f, -6.90767094e-02f, -2.69507077e-02f,
  3.43406089e-02f, -9.74348933e-02f, 2.02789366e-01f, -1.05828255e-01f, 8.52215886e-02f, -1.18960589e-01f, -1.03625149e-01f, -7.66708627e-02f, 5.60674146e-02f, -1.07763946e-01f,
  -6.57028565e-03f, 6.51466176e-02f, 3.21624689e-02f, 8.29541907e-02f, -1.57263607e-01f, 2.10287601e-01f, 4.14310284e-02f, -1.37929931e-01f, -1.38926744e-01f, 3.01031005e-02f,
  -1.81315932e-02f, -1.82900921e-01f, 1.61718801e-01f, 1.30741298e-01f, 8.64745900e-02f, 1.63150802e-01f, 1.41262352e-01f, -1.80937767e-01f, 9.64363739e-02f, 2.59161387e-02f,
  -2.56212670e-02f, -2.09392644e-02f, -7.67105073e-02f, -3.36067714e-02f, -1.07185375e-02f, 1.61510557e-02f, -2.06802934e-01f, -4.39217389e-02f, 3.12384423e-02f, 1.08897932e-01f,
  1.50159821e-01f, -5.48446625e-02f, -1.00975230e-01f, -4.90713082e-02f, 1.25204340e-01f, 6.54819459e-02f, -1.26691341e-01f, 1.32203549e-01f, 5.70470169e-02f, 4.97480482e-02f,
  -3.82123850e-02f, -5.72401248e-02f, 1.80940554e-02f, -1.37266472e-01f, 1.49502277e-01f, -1.50185362e-01f, -1.65944040e-01f, -1.49817914e-01f, -2.66809668e-02f, 2.54617650e-02f,
  -8.80838931e-02f, 5.44065498e-02f, -5.96602000e-02f, 4.87657525e-02f, -1.54921189e-02f, -1.59677025e-02f, 1.14178611e-02f, 1.13362834e-01f, -1.62340421e-02f, 8.98304023e-03f,
  2.77288631e-02f, -9.91616920e-02f, 2.16605458e-02f, -7.24823698e-02f, -7.53179714e-02f, 5.37095480e-02f, -8.46446380e-02f, 8.30334499e-02f, -9.11159590e-02f, 4.12032120e-02f,
  9.59686041e-02f, -3.72321010e-02f, -8.02822411e-02f, -2.14632917e-02f, 2.62136944e-02f, 1.96016375e-02f, -1.12126634e-01f, 3.36359143e-02f, 4.82200868e-02f, -7.59016722e-02f,
  -5.46105988e-02f, 2.68205032e-02f, -1.18927382e-01f, -7.14252098e-03f, -8.09819158e-03f, -2.71583293e-02f, -9.37702414e-03f, -9.79972109e-02f, 1.41558126e-01f, -5.05679846e-02f,
  -1.61561027e-01f, 1.88655213e-01f, -8.12485889e-02f, -1.19148329e-01f, -1.07426681e-02f, 1.51882991e-01f, -1.30507827e-03f, -1.02368027e-01f, -1.05446100e-01f, 1.02892697e-01f,
  -1.97110698e-01f, 2.31465269e-02f, 1.23023123e-01f, -1.55125692e-01f, 9.13183168e-02f, -1.48846924e-01f, 9.62522402e-02f, 1.20693132e-01f, 1.49193024e-02f, 4.76103835e-02f,
  -1.68772817e-01f, 1.52277276e-01f, -1.27095670e-01f, -2.36584283e-02f, 8.76270905e-02f, -1.53750509e-01f, -1.96715042e-01f, -9.18327197e-02f, 3.40939723e-02f, 7.25925341e-02f,
  -2.30903234e-02f, -5.80154965e-03f, 1.28095239e-01f, 3.23491879e-02f, 6.76347390e-02f, -1.26689579e-02f, -5.24983890e-02f, 6.33721724e-02f, 1.07118934e-01f, -1.35893330e-01f,
  -1.47863626e-02f, 4.49933000e-02f, 5.08880103e-03f, -2.43834052e-02f, 9.12451148e-02f, -1.89920124e-02f, 1.42147288e-01f, 4.17362116e-02f, -1.61057889e-01f, 2.33216658e-02f,
  -1.35261998e-01f, -1.12964407e-01f, 1.09730102e-01f, -8.48229155e-02f, -2.35286608e-01f, 1.85337543e-01f, 9.88370180e-02f, -4.33269702e-02f, -1.31341428e-01f, 1.04779126e-02f,
  8.05248332e-04f, -5.20957708e-02f, 5.81522174e-02f, -5.03349937e-02f, 1.22157216e-01f, -2.58850656e-03f, 4.45066690e-02f, 7.91578442e-02f, 2.25671604e-02f, -6.18813746e-02f,
  8.69755745e-02f, 7.72689059e-02f, -2.31728945e-02f, 2.63884902e-01f, 1.52428597e-02f, -1.11292198e-01f, 5.60708269e-02f, -1.72797143e-01f, -7.65044317e-02f, -1.13171302e-01f,
  5.52269742e-02f, 4.91717421e-02f, -1.09286988e-02f, 1.40985346e-03f, -8.29821080e-02f, -1.07408300e-01f, -5.25772274e-02f, -3.97109352e-02f, -2.35883016e-02f, -1.05175346e-01f,
  -1.48594426e-02f, 1.49962176e-02f, -6.65614083e-02f, -4.68378328e-03f, -7.91777298e-02f, 3.02892793e-02f, -1.14473470e-01f, 4.55268845e-02f, -3.06940470e-02f, 5.14096841e-02f,
  -1.25108063e-01f, 3.77482921e-02f, -3.21029536e-02f, -1.31854162e-01f, -2.09543365e-03f, -2.14925855e-02f, -1.72928162e-03f, 1.66606437e-02f, 9.27811954e-03f, 7.70580620e-02f,
  -6.66032806e-02f, -7.34687075e-02f, -1.00806300e-02f, -1.10110052e-01f, -5.79937734e-02f, 3.03013017e-03f, 1.14518680e-01f, 4.82112467e-02f, -1.08526953e-01f, -1.18707657e-01f,
  8.22998881e-02f, -1.16650708e-01f, -5.02798930e-02f, 2.15895870e-03f, 1.06344298e-02f, -1.77927352e-02f, 4.67661582e-02f, 2.72085592e-02f, -3.73532251e-03f, -1.32199556e-01f,
  -7.75010511e-02f, -6.71576411e-02f, -1.40035182e-01f, 6.02154508e-02f, -5.49980672e-03f, -8.45396593e-02f, -2.00179428e-01f, -1.31606400e-01f, -1.71038620e-02f, -1.66987151e-01f,
  1.23636901e-01f, -1.54311240e-01f, -3.20553258e-02f, 5.54013737e-02f, 1.19221710e-01f, 4.40398380e-02f, -1.73261881e-01f, -7.10964799e-02f, -5.35078123e-02f, 1.37356266e-01f,
  1.05754882e-01f, 1.40695944e-01f, 7.32857808e-02f, -1.22104995e-01f, -2.45364159e-02f, -1.16931967e-01f, 9.57899839e-02f, -6.86195567e-02f, 2.41841059e-02f, -1.08152479e-01f,
  -1.55087218e-01f, -1.35344669e-01f, 1.32353783e-01f, -8.04479420e-02f, -6.46343827e-02f, -9.79610756e-02f, -1.40727207e-01f, -8.93793926e-02f, 1.33377733e-02f, 1.56110242e-01f,
  -8.89706612e-03f, 1.72451720e-01f, 1.57475427e-01f, 8.69059041e-02f, -1.67915344e-01f, -2.11354392e-03f, 5.15134521e-02f, -3.65843177e-02f, -4.54649962e-02f, 1.61669552e-01f,
  8.14963281e-02f, -1.33434404e-03f, 6.88797981e-02f, -9.56438631e-02f, 1.40032142e-01f, 5.55337481e-02f, -1.10931970e-01f, -1.46391511e-01f, -8.39357376e-02f, -8.06874558e-02f,
  2.24599570e-01f, 1.01977168e-02f, 2.52108853e-02f, -6.55414462e-02f, -5.77842407e-02f, 1.42803594e-01f, 1.55743629e-01f, -2.61617780e-01f, 7.89350644e-02f, 1.57356307e-01f,
  1.55086190e-01f, 1.04557700e-01f, -1.63857713e-02f, 1.20121673e-01f, 8.93804803e-02f, -1.48653910e-01f, -9.84445363e-02f, -8.28509852e-02f, -5.60752451e-02f, -3.75345312e-02f,
  -4.62059211e-03f, 7.52103701e-02f, -7.08762854e-02f, 8.70377123e-02f, -6.24243431e-02f, -1.64220128e-02f, 7.25061521e-02f, -3.33060212e-02f, 5.26081212e-03f, -5.75636514e-02f,
  5.54463004e-05f, -9.38155800e-02f, 1.01300493e-01f, 7.90507123e-02f, -2.32939213e-03f, 2.35273708e-02f, -3.33176218e-02f, 2.21138331e-03f, -7.07548335e-02f, -3.38988900e-02f,
  4.04726639e-02f, 8.69731884e-04f, 1.38704060e-02f, 7.29469731e-02f, 1.17932551e-01f, -1.13782369e-01f, 4.27289903e-02f, 5.74569702e-02f, 4.00251336e-02f, -4.42566834e-02f,
  -7.93408230e-02f, -8.74815434e-02f, -1.33941229e-03f, 9.17911530e-02f, 9.43239704e-02f, -3.28534432e-02f, -3.66811641e-02f, -2.72561554e-02f, 1.10500092e-02f, -9.01200771e-02f,
  2.31161080e-02f, 6.35219887e-02f, 1.16929021e-02f, 1.22660408e-02f, 1.25188194e-03f, 8.09987485e-02f, 9.91972759e-02f, -6.58706501e-02f, -2.73656063e-02f, -2.38402802e-02f,
  -1.60895303e-01f, -6.85077384e-02f, 6.90903922e-04f, -2.17016377e-02f, -5.01064025e-03f, -7.07931444e-02f, 8.44772533e-02f, -1.71299502e-01f, -7.31103718e-02f, 2.92179305e-02f,
  5.32405451e-02f, -4.94969264e-02f, 7.32280463e-02f, 2.05368891e-01f, -3.96322086e-02f, 6.54900819e-02f, 8.12544003e-02f, 8.61252770e-02f, -1.44303024e-01f, -1.31319150e-01f,
  1.60258621e-01f, -7.73223042e-02f, 1.79188952e-01f, -2.06763558e-02f, -1.07589982e-01f, -1.52091920e-01f, 1.10240288e-01f, 6.68691099e-02f, -2.82518677e-02f, -1.37603715e-01f,
  5.55347577e-02f, -1.76654458e-01f, -9.59182158e-02f, -2.44815201e-02f, -1.46017909e-01f, -5.47824576e-02f, -1.03700608e-01f, 1.59469381e-01f, 1.08659729e-01f, 1.96681291e-01f,
  1.77009106e-01f, 2.12741252e-02f, -1.72120631e-01f, -1.59788013e-01f, -7.82426521e-02f, -6.56969994e-02f, 2.64778733e-02f, 7.94481635e-02f, -1.67141929e-01f, 1.06099598e-01f,
  1.04735509e-01f, 2.86902338e-02f, 1.21844999e-01f, 1.71073079e-01f, -3.33985761e-02f, -1.06966704e-01f, 1.10699162e-01f, 1.10801920e-01f, 8.11432227e-02f, 1.14745468e-01f,
  -6.61734790e-02f, 2.45028697e-02f, -1.04085997e-01f, 4.13166396e-02f, 1.31400928e-01f, -1.53538615e-01f, -1.35617945e-02f, 4.97748293e-02f, 1.67025506e-01f, -1.39806807e-01f,
  -1.65328290e-02f, 9.06262919e-02f, -9.63340253e-02f, -3.04630361e-02f, -8.18503127e-02f, -2.37777131e-03f, -4.85360734e-02f, 1.56653319e-02f, -2.25113947e-02f, 1.54509947e-01f,
  -1.04675321e-02f, -3.28446999e-02f, -6.43974841e-02f, 8.09538215e-02f, -2.05387026e-02f, 2.22796202e-02f, -2.63751559e-02f, -5.90266474e-02f, -5.21494746e-02f, -8.67673978e-02f,
  -1.84434950e-02f, -2.14755572e-02f, 2.49876850e-03f, -4.01528589e-02f, -5.78709505e-02f, -4.80655469e-02f, -8.24860483e-02f, -1.33247348e-02f, 4.49944288e-02f, -5.29807433e-02f,
  7.93080181e-02f, -9.30069759e-02f, 1.38450533e-01f, 5.33827282e-02f, -7.36462325e-02f, -4.79057468e-02f, 1.01386078e-01f, -1.03960872e-01f, -5.40795811e-02f, -1.41262203e-01f,
  -6.61721453e-02f, -1.07730068e-01f, 2.39174571e-02f, 8.52192119e-02f, -1.97815541e-02f, -6.94450811e-02f, 1.15207836e-01f, -5.31990305e-02f, -1.14177570e-01f, 2.23372187e-02f,
  -3.68622616e-02f, -9.07997042e-03f, -7.13211000e-02f, 3.66132930e-02f, 5.54295816e-02f, 4.63217683e-02f, 2.34788172e-02f, 1.58059448e-02f, -1.16268449e-01f, -2.03257710e-01f,
  1.66441247e-01f, 1.22500714e-02f, 1.14580736e-01f, -1.42921746e-01f, 3.22587639e-02f, 1.32869691e-01f, -1.43702969e-01f, 6.16313443e-02f, -6.37757629e-02f, 8.68913680e-02f,
  -7.09081255e-03f, -4.36916761e-02f, 9.93779600e-02f, 1.46252170e-01f, 1.86866000e-01f, -1.43043563e-01f, -3.27177867e-02f, -8.08705240e-02f, -1.54864090e-02f, 5.87813072e-02f,
  3.67483660e-03f, -5.40155917e-02f, 1.11001879e-01f, 6.09253719e-02f, -8.49589240e-03f, -1.55277187e-02f, -3.39592546e-02f, -1.08044572e-01f, -7.71505237e-02f, -3.44249769e-03f,
  -7.35189244e-02f, -4.81624156e-02f, -5.05184680e-02f, 1.17400259e-01f, -9.70440283e-02f, -8.35606977e-02f, 8.53780005e-03f, 3.39342020e-02f, -1.02444440e-01f, -1.94661632e-01f,
  -1.64337113e-01f, -3.64072509e-02f, 1.13536991e-01f, -1.38366923e-01f, 1.56944484e-01f, 3.47486064e-02f, -2.73916405e-02f, 1.15338273e-01f, 1.59593135e-01f, -3.55336964e-02f,
  -7.81493858e-02f, 7.76368380e-02f, 8.78247544e-02f, -2.05687881e-02f, 4.41986136e-03f, -1.13118969e-01f, -1.60324693e-01f, 7.92351738e-02f, -2.52257317e-01f, 8.85015801e-02f,
  -2.58417074e-02f, -4.29828092e-02f, 1.58991069e-01f, -1.74740376e-03f, -9.17799175e-02f, -5.14496863e-02f, -1.26239480e-02f, -8.41964930e-02f, -1.28287002e-01f, 5.94087765e-02f,
  -2.83842644e-04f, 1.81209799e-02f, -4.45335880e-02f, 4.89844233e-02f, -9.49491113e-02f, -2.81616151e-02f, 5.06902449e-02f, 9.45084691e-02f, 5.75388744e-02f, 7.88814854e-03f,
  4.55950201e-02f, -4.06715684e-02f, 6.08181171e-02f, 7.34320134e-02f, -2.29881741e-02f, 2.23619342e-02f, 5.97182438e-02f, -3.26141319e-03f, 3.21149603e-02f, 4.82141152e-02f,
  9.91350114e-02f, 4.34580259e-02f, 1.12764217e-01f, -1.15456916e-01f, -1.03795892e-02f, 4.88046586e-04f, 1.07056946e-01f, -3.85187380e-02f, -7.99966305e-02f, -6.76647872e-02f,
  8.48945752e-02f, 4.39733826e-03f, -8.16549435e-02f, -5.79089969e-02f, 1.36630863e-01f, -3.05758696e-03f, -5.95632754e-02f, -7.29191378e-02f, -5.99430390e-02f, -1.06770910e-01f,
  -9.43162851e-03f, 7.84690678e-02f, 4.96847071e-02f, 1.05922043e-01f, 1.98178040e-03f, -7.01946020e-02f, 2.29643770e-02f, 7.76329488e-02f, 4.67258459e-03f, 4.36813571e-02f,
  5.58177195e-02f, -4.74256836e-02f, -4.86355508e-03f, 1.26945391e-01f, 3.36729623e-02f, -6.12990931e-02f, -3.61607112e-02f, -7.72590116e-02f, 1.14883341e-01f, -3.13550122e-02f,
  1.48114450e-02f, 1.74338341e-01f, 4.91516180e-02f, 1.26038432e-01f, -8.45270380e-02f, 4.07149643e-02f, -2.90775928e-03f, -5.06631620e-02f, -7.44641945e-02f, 2.24574860e-02f,
  2.05577631e-02f, 1.96277678e-01f, 6.65784627e-03f, -8.56938735e-02f, -6.02490455e-02f, -2.26517156e-01f, -5.62885962e-02f, 4.26898189e-02f, -6.27521798e-02f, -1.72355279e-01f,
  1.28928581e-02f, -2.50034332e-02f, 1.72179669e-01f, 9.48363245e-02f, 7.48085827e-02f, -5.63281728e-03f, -1.53836548e-01f, 4.83889654e-02f, 7.87861869e-02f, 5.86252846e-02f,
  1.37259915e-01f, 5.86266220e-02f, -6.44469932e-02f, 1.53439268e-01f, -1.72224432e-01f, 2.36559901e-02f, -1.72873199e-01f, -1.31219044e-01f, -1.17092974e-01f, -2.11399421e-02f,
  6.54378086e-02f, -1.05071232e-01f, 6.09579198e-02f, 4.81569320e-02f, 1.10904295e-02f, 9.47984308e-02f, 1.61088184e-02f, 1.62755668e-01f, 2.02997010e-02f, -1.16564073e-01f,
  1.10416248e-01f, -1.09124310e-01f, 5.71624786e-02f, 5.04180491e-02f, -3.43837626e-02f, -2.89338250e-02f, -2.20538527e-01f, 4.47858945e-02f, -1.79613996e-02f, -4.19849008e-02f,
  -9.28344429e-02f, 6.70228712e-03f, -1.92636773e-01f, -2.15370417e-01f, 3.14309448e-02f, 3.75363830e-04f, -1.08621910e-01f, -2.14679062e-01f, -1.22070581e-01f, 9.76378024e-02f,
  -7.60483071e-02f, 1.26394048e-01f, 9.20571610e-02f, 4.91952486e-02f, -1.02488801e-01f, -7.01671243e-02f, -7.58931190e-02f, 4.44752537e-02f, -3.23244669e-02f, -1.21009715e-01f,
  1.30898599e-02f, 6.90802559e-02f, 9.88910794e-02f, -5.52865444e-03f, 6.76510949e-03f, 2.60863565e-02f, -2.62278803e-02f, -4.08449471e-02f, -2.19932571e-02f, 2.27624010e-02f,
  1.69387028e-01f, 2.16940846e-02f, 1.04169220e-01f, 1.77310628e-03f, 8.67536739e-02f, 1.43139035e-01f, 7.69763663e-02f, 8.06577131e-02f, -4.10709381e-02f, -4.18137535e-02f,
  1.39742225e-01f, 1.10464599e-02f, -1.05503209e-01f, 6.86605051e-02f, 1.56936020e-01f, 4.10128869e-02f, 3.31794098e-02f, 1.69222161e-01f, -3.44670266e-02f, 1.90432258e-02f,
  -4.45838384e-02f, 1.01168558e-01f, -1.16627567e-01f, 4.61476222e-02f, -3.07699051e-02f, -5.86055443e-02f, 8.36669058e-02f, 1.63829662e-02f, 1.12473883e-01f, 1.80059031e-01f,
  -6.07291274e-02f, -2.68949158e-02f, 4.28480282e-03f, -1.05167516e-01f, 7.52522200e-02f, 2.27187440e-01f, -1.37987837e-01f, -2.08111610e-02f, -7.47103542e-02f, 8.54338035e-02f,
  -1.69968069e-01f, 2.57688891e-02f, 1.29435137e-01f, 2.42815167e-02f, 1.12796977e-01f, -1.37186304e-01f, -7.17453808e-02f, 3.56867425e-02f, -7.30132610e-02f, -1.32241413e-01f,
  -2.17341036e-01f, -9.14928038e-03f, -7.06180409e-02f, 2.67583057e-02f, 1.07186567e-02f, 1.01983748e-01f, 7.10770488e-02f, 1.45884648e-01f, 3.09262387e-02f, 1.52553409e-01f,
  -2.20115185e-01f, 1.48441613e-01f, -9.58767310e-02f, 8.71645808e-02f, 1.88259870e-01f, 3.49208452e-02f, 1.10057503e-01f, 2.46462990e-02f, 5.83978668e-02f, -1.30211607e-01f,
  -1.69962167e-03f, -9.41477865e-02f, 1.86989784e-01f, -1.27833053e-01f, -6.74861968e-02f, 5.53523488e-02f, 1.67603791e-01f, -1.43459633e-01f, -8.01553950e-02f, 7.44923726e-02f,
  -2.38035768e-01f, -1.39198676e-01f, -2.04487696e-01f, -1.16764158e-01f, -6.48382455e-02f, 1.44390523e-01f, -6.46962449e-02f, -1.93890370e-02f, -9.84091014e-02f, 6.90741390e-02f,
  -6.33412674e-02f, 9.24592912e-02f, -2.54458580e-02f, 2.23362565e-01f, 1.20454140e-01f, 3.48654799e-02f, -1.68255325e-02f, -4.83502634e-02f, -3.48249935e-02f, 6.76228330e-02f,
  1.57817081e-01f, 4.81027365e-02f, -7.64476433e-02f, -1.45102963e-01f, 8.85481983e-02f, 4.88072224e-02f, 4.66619944e-03f, -1.18119553e-01f, 6.20143600e-02f, -5.43053495e-03f,
  1.29151717e-01f, 6.02950640e-02f, 8.37062225e-02f, -1.57443270e-01f, 5.80455288e-02f, 8.51928443e-03f, 2.96478774e-02f, -1.79590687e-01f, -6.73575029e-02f, 7.91537538e-02f,
  -8.95961095e-03f, -6.27222806e-02f, 7.29301274e-02f, -4.37883399e-02f, -6.92657530e-02f, -3.19076795e-03f, 5.11108488e-02f, 3.93084176e-02f, -5.98320588e-02f, 1.56403735e-01f,
  4.40732986e-02f, 1.33449920e-02f, 1.06921412e-01f, 1.15427613e-01f, -1.04156330e-01f, 1.38022220e-02f, -3.32901180e-02f, -3.10049653e-02f, 1.14193067e-01f, 5.06690107e-02f,
  -4.33367752e-02f, 2.05933042e-02f, 7.86209945e-03f, 1.60280257e-01f, -8.07382837e-02f, 1.55903280e-01f, -6.06859848e-02f, 4.62448671e-02f, 8.73052180e-02f, -1.04308622e-02f,
  -1.60399094e-01f, 5.96972145e-02f, 1.83444470e-02f, 1.04696773e-01f, 2.30773799e-02f, -6.55546412e-02f, 5.79855330e-02f, -3.99132520e-02f, -7.16821551e-02f, -1.75401852e-01f,
  -1.46432996e-01f, -5.47600687e-02f, -3.50445649e-03f, 1.50817364e-01f, -7.99428374e-02f, 1.49267927e-01f, -5.99874258e-02f, 1.44979388e-01f, 1.21252134e-01f, -1.37334034e-01f,
  4.02081907e-02f, -1.53350364e-02f, 1.76719859e-01f, 1.23415329e-01f, 1.71401203e-01f, -2.02637054e-02f, -5.00197485e-02f, -1.02824435e-01f, -1.22391410e-01f, 3.80772837e-02f,
  1.73047483e-02f, 5.70554547e-02f, 3.87983210e-02f, 9.19013992e-02f, -1.35274976e-01f, -8.17553028e-02f, 8.09149817e-02f, -2.29311690e-01f, -6.45014867e-02f, 7.32173249e-02f,
  1.48650452e-01f, -9.26553085e-02f, -7.76704103e-02f, -1.12357602e-01f, 4.00333703e-02f, -1.54057667e-01f, -3.81988250e-02f, 1.72801525e-03f, -6.69925213e-02f, -3.17292809e-02f,
  8.23854282e-03f, -5.11282310e-02f, 5.09285964e-02f, 1.30286083e-01f, 1.15207419e-01f, -4.29908298e-02f, -1.86272785e-02f, 1.22036822e-01f, -8.35204497e-02f, 1.29090166e-02f,
  4.39834334e-02f, -8.01623464e-02f, -1.51225448e-01f, -1.46961987e-01f, -6.53120726e-02f, 5.04712202e-02f, -4.55639921e-02f, 4.68761772e-02f, -5.83733106e-03f, -6.23915717e-03f,
  1.56412259e-01f, -3.54396328e-02f, 1.05145775e-01f, -1.62649378e-01f, -7.97130391e-02f, 8.31056833e-02f, -1.01549029e-02f, 5.32961935e-02f, 2.08739549e-01f, 9.28360447e-02f,
  9.51205567e-02f, 9.06034897e-04f, 2.10054275e-02f, -7.24515170e-02f, 1.26887396e-01f, -1.29695758e-01f, 1.69371054e-01f, 2.81899404e-02f, -6.01101406e-02f, -7.22018853e-02f,
  1.38791382e-01f, 1.45113766e-02f, -2.56475214e-05f, -6.18291125e-02f, 1.02911137e-01f, -6.23586997e-02f, -2.68452633e-02f, -6.77479208e-02f, -8.98282081e-02f, 1.43781140e-01f,
  -2.36976370e-02f, -8.46880004e-02f, 4.22514323e-03f, -8.28210041e-02f, 8.59642923e-02f, -4.27891836e-02f, -1.09112754e-01f, -7.55166784e-02f, 6.67442232e-02f, 6.72294125e-02f,
  -1.04580941e-02f, -8.87056962e-02f, -1.13347061e-01f, -5.17653860e-02f, 6.64122775e-02f, 5.80327809e-02f, -1.39332935e-01f, 3.63850780e-02f, 1.44816563e-01f, -1.35903820e-01f,
  -1.22093588e-01f, 1.23847239e-01f, -1.14450827e-01f, -5.78518957e-02f, 3.90481041e-03f, 2.01469753e-02f, 2.96107940e-02f, -9.11277160e-02f, 1.28959775e-01f, -3.28844264e-02f,
  -1.07849471e-01f, -4.69452888e-02f, -2.00711675e-02f, -1.75505951e-02f, -1.44506926e-02f, -7.25426972e-02f, -7.54362419e-02f, -6.56246245e-02f, -3.09864413e-02f, 9.36826319e-02f,
  1.09350748e-01f, -2.08406046e-01f, 2.19941661e-01f, 2.76130270e-02f, 1.16607986e-01f, -1.43825158e-01f, 1.87505588e-01f, 1.13912925e-01f, -3.60470526e-02f, -1.05155170e-01f,
  -1.23527952e-01f, 1.91822231e-01f, 4.66914624e-02f, -7.31877089e-02f, 1.03259750e-01f, 2.98882648e-02f, 1.54168934e-01f, -6.42500296e-02f, 1.82489082e-01f, -8.30771551e-02f,
  -1.31930441e-01f, -4.96683121e-02f, -1.59207955e-01f, -7.09588528e-02f, 4.99269292e-02f, -2.67111324e-02f, 1.97462603e-01f, 9.36418958e-03f, 2.01907396e-01f, 1.08185979e-02f,
  -1.03975393e-01f, 3.34233306e-02f, -5.84199689e-02f, -6.76453561e-02f, 6.42360300e-02f, 3.25343721e-02f, -6.21987833e-03f, -1.21856585e-01f, -1.33561328e-01f, 1.01427831e-01f,
  -6.46222457e-02f, -1.62018001e-01f, -1.01692840e-01f, 8.69392678e-02f, 7.72861391e-02f, -7.01152682e-02f, 2.00171664e-01f, 1.46397054e-01f, 9.03339162e-02f, 1.57461956e-01f,
  4.54166681e-02f, -6.40997291e-02f, 8.97159893e-03f, 8.45291018e-02f, -1.54396577e-03f, 3.47559191e-02f, -3.48610505e-02f, -5.82758076e-02f, 8.26398283e-02f, -1.72321677e-01f,
  -1.23080999e-01f, -6.85292631e-02f, -1.93842209e-03f, 4.29114625e-02f, 5.25531359e-02f, 3.29483822e-02f, -8.88758898e-02f, -7.36317560e-02f, 1.48292854e-01f, -5.88888824e-02f,
  -2.25474864e-01f, -1.37662470e-01f, 4.96805944e-02f, 3.11581809e-02f, 9.73377973e-02f, 3.86693589e-02f, -6.77486975e-03f, 5.82289845e-02f, 7.56038260e-03f, 7.74533115e-03f,
  9.30679664e-02f, 8.69069025e-02f, 5.47953434e-02f, 4.62550297e-02f, 4.09927070e-02f, -6.55245632e-02f, 6.88573569e-02f, 1.11906841e-01f, 5.02882600e-02f, -7.49419406e-02f,
  1.30755715e-02f, -6.39931485e-02f, 8.09783414e-02f, 2.14740206e-02f, -7.00454637e-02f, -7.76448566e-03f, -3.95345390e-02f, -1.90421764e-03f, 6.73428997e-02f, -7.12472126e-02f,
  6.06764155e-03f, -5.21790497e-02f, 2.48511489e-02f, 2.61331834e-02f, -2.99329385e-02f, 1.96287930e-02f, 3.87658626e-02f, -3.19423117e-02f, -1.08304225e-01f, -1.74595173e-02f,
  -9.70732495e-02f, -4.02864367e-02f, 6.79222867e-02f, -3.14619355e-02f, 2.66983826e-02f, -4.32809331e-02f, 8.32154751e-02f, 1.75649095e-02f, 7.58791417e-02f, -4.71308641e-02f,
  4.85750474e-02f, -8.17926507e-03f, -2.00638324e-02f, -8.82035717e-02f, -3.17030177e-02f, -1.29469037e-01f, -1.10534847e-01f, -3.98491547e-02f, 4.22574468e-02f, -1.41541705e-01f,
  9.93349105e-02f, -2.81205457e-02f, 4.62053604e-02f, -1.31198689e-01f, 1.30611777e-01f, -5.09927571e-02f, -1.02453365e-03f, -1.06871188e-01f, -1.47734120e-01f, 9.87291336e-02f,
  1.50971845e-01f, -1.38866268e-02f, 4.78240252e-02f, 7.36902282e-02f, 1.38166055e-01f, 9.65169221e-02f, 1.05209745e-01f, -6.08909167e-02f, -1.46067575e-01f, -4.94698994e-02f,
  7.28172297e-03f, -1.39381215e-01f, 1.69477493e-01f, 1.95410568e-02f, 1.74738929e-01f, -4.75230925e-02f, -6.25436977e-02f, -1.34088188e-01f, 1.67282578e-02f, -1.40535936e-01f,
  2.14051437e-02f, -1.31975055e-01f, -3.81315500e-02f, 6.68297186e-02f, -8.81896988e-02f, 6.18605763e-02f, -1.33045077e-01f, 1.97741166e-01f, 1.78726930e-02f, -9.32035446e-02f,
  -1.34283230e-01f, 9.01099816e-02f, -2.54532322e-02f, 2.95229983e-02f, 1.40701517e-01f, 3.96593437e-02f, 9.60147008e-02f, 1.20198488e-01f, 1.25684321e-01f, -1.20088287e-01f,
  1.31945819e-01f, -5.07159680e-02f, 5.12151085e-02f, -2.97585223e-02f, -1.38549075e-01f, -4.41545248e-02f, 6.44298196e-02f, -3.26312743e-02f, -5.65535426e-02f, -1.38725117e-02f,
  4.96037118e-02f, 8.68556350e-02f, 1.64045468e-01f, 9.74617675e-02f, -1.44185483e-01f, -9.99731198e-02f, 1.60934925e-01f, 4.97698272e-03f, -1.96862683e-01f, 8.15679431e-02f,
  2.36834828e-02f, 8.99952352e-02f, -1.22896172e-01f, 1.80351198e-01f, 1.86703324e-01f, -6.13844283e-02f, 4.02736440e-02f, -1.25859737e-01f, -8.37383494e-02f, 5.69890812e-02f,
  1.20428242e-01f, 5.01260981e-02f, -2.03657686e-03f, 8.81728530e-03f, 5.07348329e-02f, -1.56617314e-02f, -4.55757491e-02f, 7.80853629e-02f, 8.05767700e-02f, -1.24213677e-02f,
  -5.40970936e-02f, 2.14944035e-02f, 1.30053535e-01f, 1.10872891e-02f, 2.84240004e-02f, 1.51474285e-03f, -2.67928820e-02f, 6.58050478e-02f, 1.58613712e-01f, 4.24390174e-02f,
  -1.55848106e-02f, 2.02797987e-02f, 6.98141530e-02f, 1.09033622e-02f, 2.79129576e-02f, 7.46375462e-03f, 9.83492658e-02f, 3.84537838e-02f, -2.97788926e-03f, 3.39458510e-02f,
  5.49256355e-02f, 6.60049915e-02f, -3.23544666e-02f, 1.42528322e-02f, -3.09128761e-02f, 6.92343563e-02f, 8.12388286e-02f, 3.15602077e-03f, -7.39758834e-02f, -1.34857197e-03f,
  1.32415429e-01f, -2.63003502e-02f, -9.52374339e-02f, -5.66537902e-02f, -7.04429001e-02f, 5.03728874e-02f, 1.64611805e-02f, 1.19834311e-01f, -9.12780464e-02f, -1.94892958e-01f,
  -1.98789075e-01f, 1.09696358e-01f, -1.19948961e-01f, 3.26319709e-02f, 1.93428565e-02f, 2.96123382e-02f, 6.06474169e-02f, -7.35683367e-02f, -3.16522196e-02f, -8.11713859e-02f,
  -7.43699670e-02f, -1.33087024e-01f, -5.62641621e-02f, 2.27157418e-02f, -5.49268201e-02f, -1.51653327e-02f, 5.75891770e-02f, 3.62676452e-03f, 1.48851082e-01f, 6.07595369e-02f,
  7.31088147e-02f, 1.87459856e-01f, -1.36366352e-01f, 1.25888094e-01f, 3.44177783e-02f, 5.48731461e-02f, 3.58430818e-02f, 5.90491332e-02f, 1.18854657e-01f, 2.08609894e-01f,
  1.48888147e-02f, -1.26733467e-01f, -2.32484546e-02f, -1.24681376e-01f, 1.64590940e-01f, -2.01895699e-01f, -4.25967202e-02f, 1.79509163e-01f, 6.70516044e-02f, -1.61238939e-01f,
  -1.25342324e-01f, 6.73847571e-02f, -2.16697037e-01f, -1.43143952e-01f, -1.24527015e-01f, -1.01192407e-01f, -1.83910713e-01f, -5.79557121e-02f, -5.10733686e-02f, -9.17798579e-02f,
  -8.00956264e-02f, 5.56001142e-02f, -1.21556677e-01f, -9.02123600e-02f, -1.15327999e-01f, 1.57477692e-01f, 2.93810815e-01f, -8.81694083e-04f, -3.16721275e-02f, 4.49421518e-02f,
  -8.32593367e-02f, 7.80268684e-02f, 5.38506880e-02f, -1.52750149e-01f, -1.36424109e-01f, -1.02008753e-01f, 5.02269529e-02f, 6.31759763e-02f, 1.24893114e-01f, -5.25269657e-02f,
  -1.43705279e-01f, -7.99060985e-02f, 4.13096733e-02f, -1.39198825e-02f, -5.53142913e-02f, -3.29696797e-02f, -8.16399828e-02f, 4.68729623e-02f, -1.68114319e-01f, -1.30429298e-01f,
  7.03287050e-02f, 7.12937489e-02f, 2.13374887e-02f, -1.58218652e-01f, -1.00146100e-01f, 6.37396723e-02f, -1.60756800e-02f, 4.93923053e-02f, 2.66424008e-02f, 5.17690256e-02f,
  7.19064400e-02f, 6.54090056e-03f, 5.65701872e-02f, 2.15334576e-02f, 4.80162445e-03f, 8.00451934e-02f, 6.06768318e-02f, 1.63052399e-02f, 1.90055538e-02f, -1.22658238e-01f,
  -1.47440955e-02f, 6.99549541e-02f, -1.05003946e-01f, 8.39477703e-02f, 2.57368553e-02f, 7.43583962e-02f, 2.91654132e-02f, 9.85015631e-02f, -3.85023952e-02f, -8.60316008e-02f,
  8.45706239e-02f, 3.02862655e-02f, -9.73818451e-02f, -5.96577628e-03f, -3.88173647e-02f, -6.63595349e-02f, -3.27304602e-02f, 6.45855069e-02f, 1.00569777e-01f, -3.14045437e-02f,
  -3.15051116e-02f, -1.24295160e-01f, 1.27596157e-02f, -3.39284725e-02f, -1.96588159e-01f, -8.25219974e-02f, -1.09391518e-01f, -1.32123893e-02f, -9.81991366e-02f, 8.20432007e-02f,
  1.95255820e-02f, -1.88490033e-01f, -1.37238115e-01f, 1.76649675e-01f, 2.05089122e-01f, -4.28608358e-02f, 6.32856134e-03f, 4.71587703e-02f, -1.15202285e-01f, -2.03537926e-01f,
  1.64985210e-02f, -1.74231201e-01f, -7.30440393e-02f, 3.81545648e-02f, 1.09850273e-01f, -4.79276218e-02f, 7.58465156e-02f, -2.52365414e-02f, -1.03916787e-01f, -1.24785893e-01f,
  -1.51564568e-01f, -6.37610024e-03f, -2.51643080e-03f, 8.30549449e-02f, 2.35894322e-02f, -5.62614165e-02f, -1.56793490e-01f, -5.96468188e-02f, -8.66651163e-03f, 5.72201125e-02f,
  -9.30199549e-02f, 1.41397148e-01f, 2.07539544e-01f, -5.86717762e-02f, 9.50083435e-02f, 2.77313348e-02f, 1.52623672e-02f, -7.17139468e-02f, -1.50367051e-01f, 7.94265710e-04f,
  1.74564794e-02f, -6.87230304e-02f, -1.10834755e-01f, 3.65150012e-02f, -6.02472760e-02f, -6.46686740e-03f, -4.78472747e-02f, -1.94861256e-02f, 2.54552215e-02f, 5.42924404e-02f,
  1.04831524e-01f, 2.72581577e-02f, -8.47531259e-02f, 1.44922778e-01f, 9.21994448e-02f, -4.74736392e-02f, -1.79380894e-01f, 1.23813875e-01f, 1.84161872e-01f, 2.05349438e-02f,
  4.73412350e-02f, 1.89497904e-03f, 1.31953865e-01f, -4.47319001e-02f, 8.42181817e-02f, 1.63229272e-01f, 5.33836782e-02f, -8.71376768e-02f, 6.29770104e-03f, 4.21985351e-02f,
  -3.00195701e-02f, -2.53900071e-03f, 4.72192094e-02f, -1.15908548e-01f, -9.06474069e-02f, -7.34330118e-02f, -9.91247315e-03f, -4.36923057e-02f, -4.10979092e-02f, -3.04811429e-02f,
  4.93497401e-02f, 6.94110692e-02f, 6.08142279e-02f, 3.53639387e-02f, -1.15959831e-02f, -4.09567170e-02f, -9.10003763e-03f, -1.23388492e-01f, -5.27258441e-02f, -7.71876052e-02f,
  -5.09180054e-02f, -7.76983276e-02f, 6.33557215e-02f, -1.15908007e-03f, -2.53796261e-02f, 2.45414674e-02f, -8.46881866e-02f, -2.90382560e-02f, 2.39956230e-02f, 3.32876332e-02f,
  -6.71598539e-02f, -8.01292881e-02f, -4.15216051e-02f, 1.47621095e-01f, 4.01366055e-02f, 6.20396920e-02f, -1.12441286e-01f, -9.22103822e-02f, -2.80559380e-02f, 7.72666931e-02f,
  -1.11014038e-01f, 1.22340126e-02f, -4.00514193e-02f, -4.61897056e-04f, 5.93748465e-02f, 8.75561386e-02f, 1.44133255e-01f, -4.57947850e-02f, -3.44764329e-02f, 9.00682732e-02f,
  1.41026363e-01f, -1.76252410e-01f, 1.77778915e-01f, -3.73173356e-02f, -1.40452355e-01f, 6.36461154e-02f, -5.38958833e-02f, 1.15898259e-01f, -1.03129990e-01f, -9.61831212e-02f,
  6.97450666e-03f, 3.17567475e-02f, 1.26101002e-01f, 3.70910764e-02f, 8.61301944e-02f, 1.65958051e-02f, 6.25781119e-02f, -1.92012534e-01f, 3.13949771e-02f, -5.25953509e-02f,
  7.23891705e-02f, 1.09583333e-01f, 6.65613934e-02f, -3.77214924e-02f, -2.02094596e-02f, 1.28000468e-01f, 9.35730152e-03f, 7.89696649e-02f, -3.40161920e-02f, 1.15647681e-01f,
  1.56672850e-01f, 1.47336751e-01f, 9.82481018e-02f, -2.41883807e-02f, -6.66266084e-02f, 2.12510936e-02f, 6.92552924e-02f, 2.22938098e-02f, 2.26206891e-02f, -1.53930545e-01f,
  1.18565150e-01f, -5.90743534e-02f, -7.88534898e-03f, 1.23150080e-01f, 1.66807517e-01f, -2.41748877e-02f, -4.80823144e-02f, 2.30720297e-01f, -7.42334649e-02f, -9.98997241e-02f,
  -2.57829856e-02f, -1.68188959e-01f, -1.71760261e-01f, 1.12195969e-01f, -1.10919520e-01f, 8.48546922e-02f, -7.72488043e-02f, -3.41644883e-02f, 1.16195507e-01f, 1.45113036e-01f,
  -5.77555448e-02f, -6.96321949e-02f, 1.68112606e-01f, -9.15924460e-02f, 5.08554354e-02f, -1.41848817e-01f, -1.31141976e-01f, 9.00442004e-02f, 6.13598563e-02f, 1.39413223e-01f,
  -3.50792035e-02f, 4.49189879e-02f, 8.21384341e-02f, -1.24195352e-01f, 3.72506939e-02f, 2.14325525e-02f, -1.28280474e-02f, 7.40392134e-02f, 8.87439027e-02f, 4.07250747e-02f,
  -1.47221843e-02f, -8.77906531e-02f, 6.67941943e-03f, -8.64290521e-02f, -1.37562394e-01f, -1.29861444e-01f, 5.60954921e-02f, 5.24792820e-02f, 1.52886601e-03f, -5.63081317e-02f,
  6.14332706e-02f, 6.41101226e-02f, 6.24064952e-02f, 3.64750028e-02f, 3.25482674e-02f, 3.98162380e-02f, 9.72963795e-02f, 4.87787984e-02f, 4.05569887e-03f, 4.14497294e-02f,
  6.21986613e-02f, 2.08820567e-01f, -2.46082190e-02f, 1.15123577e-01f, 1.37323156e-01f, 7.49675557e-02f, 3.11466102e-02f, 1.05547039e-02f, -1.98304877e-02f, -4.05467860e-02f,
  1.13122715e-02f, 6.59213588e-02f, 2.84397919e-02f, -5.91523573e-02f, -3.64050828e-02f, -2.39000265e-02f, -5.48424833e-02f, -9.31100398e-02f, -6.46064579e-02f, 1.23352833e-01f,
  -8.93719569e-02f, -4.62606400e-02f, -7.36109391e-02f, 1.18489368e-02f, -1.17021762e-02f, -3.82406004e-02f, -6.46833470e-03f, -1.95237353e-01f, -6.33032024e-02f, 7.92890438e-04f,
  -3.83257866e-02f, -2.42308546e-02f, -7.94082284e-02f, -1.30290255e-01f, -1.43097127e-02f, -6.66439012e-02f, -7.56364241e-02f, 2.04689801e-02f, -1.12856999e-01f, 1.26453698e-01f,
  1.17262289e-01f, -4.32784148e-02f, -4.54212427e-02f, -2.04318047e-01f, 8.67658630e-02f, -1.27528295e-01f, -8.70552585e-02f, -2.65991297e-02f, -7.73846358e-02f, 5.80819063e-02f,
  1.29896151e-02f, -5.76283932e-02f, -1.98847651e-02f, 1.09543659e-01f, 1.88589301e-02f, -1.14620328e-02f, -1.73544943e-01f, 7.38474494e-03f, 1.12490386e-01f, 9.98809189e-02f,
  -2.72963177e-02f, 6.98415935e-02f, -4.84810323e-02f, 1.45398155e-01f, 5.83128780e-02f, -6.16360605e-02f, -5.33699393e-02f, -2.15656742e-01f, 1.91208154e-01f, -1.46856338e-01f,
  -1.84347257e-01f, 2.87308320e-02f, 2.23619923e-01f, 5.10136299e-02f, -1.33406490e-01f, -7.32466951e-02f, -7.23005608e-02f, -1.10018320e-01f, -1.26306102e-01f, -1.65584106e-02f,
  -2.31678545e-01f, 9.18661952e-02f, -9.35300440e-02f, -1.52552441e-01f, 1.17709480e-01f, 6.33877292e-02f, -7.06010833e-02f, -2.20249835e-02f, -4.26767431e-02f, 5.75510226e-02f,
  1.42888740e-01f, 3.27062830e-02f, 1.41541716e-02f, -2.41514426e-02f, -4.39103059e-02f, 4.93574031e-02f, 1.87779292e-01f, -1.15544908e-01f, -1.31980449e-01f, -4.38331850e-02f,
  2.48801545e-03f, -6.17394745e-02f, 1.36360213e-01f, 5.54088727e-02f, 1.34534482e-02f, 1.14823747e-02f, 1.20990705e-02f, -4.41184044e-02f, -7.03075975e-02f, -1.08320214e-01f,
  7.22211897e-02f, -5.72637320e-02f, 1.32478535e-01f, 8.82483795e-02f, -9.90663306e-04f, -1.11775085e-01f, -7.40372688e-02f, 1.26872463e-02f, 9.25142318e-02f, 3.99071388e-02f,
  -8.43961462e-02f, -4.86962609e-02f, 1.19897760e-02f, -4.93369736e-02f, -4.50205244e-02f, 1.03913814e-01f, -1.12558298e-01f, 8.67178440e-02f, 2.41674413e-03f, 9.56742615e-02f,
  2.17197649e-02f, 2.66227275e-02f, -6.31105602e-02f, 8.35965723e-02f, 1.87101588e-02f, -9.81419683e-02f, 2.12278217e-03f, 3.61866131e-02f, 9.60254744e-02f, 3.71470451e-02f,
  5.92129864e-02f, 1.04947500e-01f, -6.89779818e-02f, 6.92119300e-02f, -6.53437451e-02f, 5.98956551e-03f, 5.53603098e-02f, -4.26629521e-02f, -1.97476451e-03f, 5.06564267e-02f,
  2.10481845e-02f, -8.13957602e-02f, 3.27802971e-02f, -1.60047915e-02f, -7.77679905e-02f, -5.23790419e-02f, 3.61313149e-02f, 1.33873314e-01f, 3.52283753e-02f, 1.73326418e-01f,
  -1.41226292e-01f, 1.49713773e-02f, -2.67515313e-02f, -1.19853718e-02f, -1.74959287e-01f, 2.34821942e-02f, 3.85470949e-02f, 8.93897712e-02f, 7.17005432e-02f, 1.24544233e-01f,
  -8.92001465e-02f, -7.21235201e-02f, -6.04721606e-02f, -9.46874321e-02f, -1.58163533e-01f, 6.95204809e-02f, 9.57548097e-02f, 1.88807502e-01f, -4.68358770e-02f, 1.14821561e-01f,
  7.13261887e-02f, 1.53057277e-01f, -1.49015948e-01f, 3.21774222e-02f, -1.00408994e-01f, -5.15785962e-02f, 5.61502427e-02f, 1.65280215e-02f, 3.73661630e-02f, 1.85788795e-01f,
  7.50377625e-02f, 8.32962990e-02f, -1.21566087e-01f, -1.73295185e-01f, 1.43033728e-01f, 2.07241229e-03f, 8.42261985e-02f, -1.17141142e-01f, -1.33644138e-02f, 7.93469399e-02f,
  1.96683649e-02f, 1.33522764e-01f, -3.57195660e-02f, 7.47864246e-02f, -4.64303121e-02f, -1.73468262e-01f, -8.86272788e-02f, -3.70606184e-02f, -4.61674966e-02f, -1.41184852e-01f,
  9.50678065e-02f, -1.49754331e-01f, 8.29481427e-03f, 4.79061976e-02f, -9.15978029e-02f, -1.00985423e-01f, 4.86101583e-02f, -2.86282618e-02f, 1.61158353e-01f, -1.50464371e-01f,
  9.67878625e-02f, 2.99627893e-02f, -6.43190965e-02f, -4.72203409e-03f, 1.11448042e-01f, -1.19844295e-01f, -9.68425870e-02f, -2.22309232e-02f, 1.92156434e-03f, 3.86011750e-02f,
  1.06607422e-01f, 6.02353225e-03f, -8.09784681e-02f, -1.09302603e-01f, -8.32903683e-02f, -3.83503512e-02f, -1.15369424e-01f, 1.11231729e-01f, -6.80045178e-03f, -6.41769469e-02f,
  4.25034799e-02f, 1.00007214e-01f, 3.82759161e-02f, -3.32604386e-02f, 1.45460172e-02f, -1.97581062e-03f, -8.67705233e-03f, 9.60696787e-02f, -8.83606076e-02f, -9.18310285e-02f,
  -6.96282759e-02f, -3.52466740e-02f, 3.51798907e-02f, -5.31962551e-02f, 1.09289639e-01f, -4.67343144e-02f, -2.62490306e-02f, -8.12467262e-02f, 1.11882061e-01f, -4.76623215e-02f,
  4.42515872e-02f, -4.67757769e-02f, -1.05844080e-01f, -1.23141557e-01f, 5.39142638e-04f, 2.25812886e-02f, 1.19308084e-01f, -2.25272790e-01f, 1.13540736e-03f, -6.41190484e-02f,
  -9.19630677e-02f, 8.93353112e-03f, 6.38407692e-02f, -9.35300291e-02f, 1.36941060e-01f, -8.68764892e-02f, -2.13262206e-03f, -1.57627329e-01f, -7.43266344e-02f, 8.02568905e-03f,
  -1.67032257e-01f, -2.55206823e-02f, 7.15442300e-02f, 8.83532465e-02f, 2.11964011e-01f, 1.83818683e-01f, -1.06705464e-01f, -8.56056660e-02f, 1.01214968e-01f, 1.46812931e-01f,
  4.60267812e-02f, -1.34559646e-01f, 5.55852577e-02f, -4.03700098e-02f, -7.52953365e-02f, 5.93013056e-02f, -5.33239581e-02f, -3.45287584e-02f, -5.47989570e-02f, -4.35210671e-03f,
  -1.44687682e-01f, 8.54404718e-02f, -1.73510741e-02f, -2.12704353e-02f, 2.01571658e-02f, -7.48607218e-02f, 1.64287448e-01f, 7.17048571e-02f, 1.78604171e-01f, 1.69746488e-01f,
  -8.04933384e-02f, 5.55449910e-02f, 6.65553734e-02f, -1.18095741e-01f, -9.73252654e-02f, 8.72859731e-02f, -1.83063466e-02f, 1.42965659e-01f, 7.79825449e-02f, -1.99389625e-02f,
  -9.72668678e-02f, -6.06063567e-03f, 1.28003657e-01f, 4.62773107e-02f, -1.39606059e-01f, 8.41560736e-02f, 2.78476439e-03f, -1.24668472e-01f, -2.14729935e-01f, -3.95599976e-02f,
  9.48077366e-02f, -2.12302729e-01f, 1.10308468e-01f, 3.89388725e-02f, -2.90430784e-01f, 1.40596777e-01f, 2.65237838e-01f, 8.07848498e-02f, -1.38852522e-02f, 6.74540624e-02f,
  2.29873788e-02f, -3.75090539e-02f, 1.21563494e-01f, 1.04098693e-01f, -1.39984801e-01f, 4.22616564e-02f, -1.50587648e-01f, 3.08931991e-02f, -4.87902164e-02f, -1.66718930e-01f,
  8.80724937e-02f, -1.42957136e-01f, 7.87152052e-02f, 1.30054757e-01f, -3.63833411e-03f, 6.91566290e-03f, 1.85462758e-02f, 1.40900269e-01f, -1.83049738e-01f, -1.06716029e-01f,
  1.15530184e-02f, 6.01091906e-02f, -3.41334492e-02f, 2.74498947e-02f, 1.59864470e-01f, -1.37116060e-01f, -7.82651752e-02f, 4.08980846e-02f, 5.90970740e-02f, 1.50191680e-01f,
  3.78419757e-02f, -5.96450679e-02f, -2.57979594e-02f, 2.74587832e-02f, 8.89752358e-02f, 2.03650165e-02f, -1.08709820e-01f, -4.91082594e-02f, 2.70653348e-02f, -2.01087222e-02f,
  -3.07959188e-02f, -1.28320247e-01f, 1.11126639e-02f, -9.45602059e-02f, -9.29478481e-02f, -1.02674834e-01f, -8.72447416e-02f, -3.20811719e-02f, -7.75974691e-02f, 3.68753797e-03f,
  1.38759492e-02f, -5.66005660e-03f, 8.64773393e-02f, -9.56917182e-02f, 1.14977136e-01f, 6.25014976e-02f, -4.56030369e-02f, 1.06929168e-01f, 1.16598811e-02f, 3.20521370e-02f,
  -2.65110121e-03f, 2.40825731e-02f, -2.55412236e-02f, 2.65723690e-02f, -4.15692143e-02f, -1.47244379e-01f, -1.04536638e-02f, 1.11709334e-01f, -5.56024574e-02f, 1.29825562e-01f,
  -1.16127998e-01f, 1.58282503e-01f, 1.12764284e-01f, -5.01541756e-02f, 9.11247581e-02f, 7.11928979e-02f, 5.08166552e-02f, 1.35789156e-01f, -1.26711316e-02f, -1.57877617e-02f,
  -1.61163568e-01f, 9.09895003e-02f, 8.90670121e-02f, -1.41232908e-01f, -1.77088857e-01f, 1.13847561e-01f, -1.83713213e-02f, 2.34253984e-02f, -1.03700891e-01f, 6.83065727e-02f,
  3.43212485e-02f, 8.33440199e-03f, 2.06514195e-01f, 1.11223437e-01f, -7.25553231e-03f, -8.13011155e-02f, -1.39316335e-01f, 6.91934526e-02f, 3.13046388e-02f, 1.51554033e-01f,
  1.27338648e-01f, -4.01345044e-02f, -1.61903817e-02f, -4.72462140e-02f, 1.25204042e-01f, 1.84630632e-01f, -8.08252022e-02f, -3.10314912e-02f, 2.37033322e-01f, -5.44723012e-02f,
  8.84690359e-02f, -9.01926123e-03f, -6.99825734e-02f, 7.96376467e-02f, 1.32614613e-01f, -1.77749544e-01f, -8.68118107e-02f, 4.25503477e-02f, -8.47518295e-02f, 3.74123920e-03f,
  5.57315489e-03f, 2.02333242e-01f, 1.54798076e-01f, -3.56408693e-02f, 1.31529570e-01f, -1.07200928e-02f, 1.92805409e-01f, 9.61449370e-02f, -6.98997676e-02f, -1.65561929e-01f,
  -1.23893477e-01f, -5.09180911e-02f, -2.22612116e-02f, -9.96610299e-02f, -3.89322974e-02f, 1.96333183e-03f, 1.23591147e-01f, 8.40673875e-03f, -4.07948792e-02f, -1.58799365e-01f,
  -1.35919556e-01f, -1.49141848e-01f, 6.94725811e-02f, 7.76214749e-02f, -1.30626842e-01f, -6.72789142e-02f, 1.12171248e-01f, -1.03637420e-01f, -5.05059101e-02f, 7.32860202e-03f,
  -7.16587678e-02f, -9.70505849e-02f, -4.74018976e-02f, -4.66618389e-02f, 4.95539932e-03f, 6.52114227e-02f, 4.95739654e-03f, 5.96385561e-02f, 1.11394972e-01f, -4.17131633e-02f,
  5.95420897e-02f, 5.81266917e-03f, 1.03615791e-01f, 4.03963067e-02f, -2.93584131e-02f, -5.37095368e-02f, -5.26971556e-02f, -6.56911805e-02f, 5.66905588e-02f, 1.05042458e-01f,
  -3.89027484e-02f, 2.98261307e-02f, -1.18251987e-01f, 3.60694416e-02f, 8.01112652e-02f, -3.96357216e-02f, 9.34489444e-03f, 3.54067348e-02f, 6.55745715e-02f, -1.73482462e-03f,
  3.41178067e-02f, 1.66080538e-02f, -4.49487306e-02f, -1.09314814e-01f, 2.59723496e-02f, -4.19349968e-03f, 6.73752725e-02f, 8.36430863e-03f, -3.50034460e-02f, 8.82602558e-02f,
  -5.86331710e-02f, -6.40310943e-02f, 8.11918750e-02f, 5.92987686e-02f, 5.13629839e-02f, 6.20262371e-03f, -3.70281190e-02f, 8.23557898e-02f, -2.49327719e-02f, 8.66909996e-02f,
  8.92071724e-02f, 2.20071778e-01f, 9.23998356e-02f, 1.55893579e-01f, -1.03490882e-01f, -7.26676732e-02f, 8.47322121e-02f, -4.47968580e-02f, -1.43039897e-01f, 4.55907099e-02f,
  -2.05282178e-02f, -1.23967405e-03f, -9.10403207e-02f, 7.66618550e-02f, -1.73696578e-01f, -2.01008290e-01f, -1.09710403e-01f, -2.70243138e-02f, -9.56834480e-02f, -4.61084284e-02f,
  6.22432865e-02f, 6.58225417e-02f, 6.50265962e-02f, 6.82847053e-02f, 7.07723573e-02f, 1.60134137e-01f, -1.34935111e-01f, 2.25222617e-01f, -6.03811108e-02f, -1.40206516e-01f,
  -7.24417940e-02f, 3.31843272e-02f, -2.76375259e-03f, 1.69275105e-01f, -1.37162451e-02f, 4.83249389e-02f, 2.99768709e-02f, -1.45050734e-01f, 1.34437293e-01f, -7.54313692e-02f,
  6.17977083e-02f, -6.34769648e-02f, -3.96506451e-02f, 1.04299873e-01f, 7.12528974e-02f, 1.76468804e-01f, -6.31576702e-02f, -7.46047571e-02f, 3.03915553e-02f, -8.46553743e-02f,
  -1.07580945e-01f, 1.11894540e-01f, 1.94112435e-01f, -1.07596785e-01f, 9.23841521e-02f, -6.90538287e-02f, -5.77249005e-02f, -7.96269476e-02f, -2.10645765e-01f, -1.29181460e-01f,
  -1.22043863e-01f, 2.35756300e-02f, 1.37514686e-02f, 4.22190167e-02f, 2.15476960e-01f, 9.25815105e-02f, 7.91209657e-03f, -5.54356650e-02f, -4.63514403e-02f, -1.13989182e-01f,
  -8.05912614e-02f, 2.79205646e-02f, -5.31410985e-02f, 2.56953649e-02f, 1.06195025e-01f, 8.48528892e-02f, 4.22869856e-03f, 1.35900587e-01f, 9.82327312e-02f, -6.61346391e-02f,
  5.35891056e-02f, -1.88880384e-01f, -7.31909135e-03f, -2.21967585e-02f, -3.44441570e-02f, 5.12350202e-02f, -2.31693853e-02f, 1.19449403e-02f, 1.02433981e-02f, 6.63235262e-02f,
  1.02045067e-01f, 1.56287272e-02f, -6.90804124e-02f, -2.18996089e-02f, -4.04198952e-02f, 5.46390787e-02f, 9.14730132e-02f, -3.00463233e-02f, 1.76483039e-02f, 1.87038537e-02f,
  5.75376675e-02f, 1.05843283e-01f, 8.68222639e-02f, 1.88917950e-01f, 3.57553959e-02f, 8.17962214e-02f, 1.21319644e-01f, 1.12920865e-01f, 9.31174085e-02f, 6.20176829e-02f,
  1.48664555e-02f, 1.99683383e-01f, 6.32529482e-02f, 3.79495583e-02f, 2.13990044e-02f, -1.06474429e-01f, -4.26603183e-02f, 3.67871299e-02f, -6.72486126e-02f, 7.34647503e-03f,
  -1.51736811e-02f, -8.46665259e-03f, -5.37834177e-03f, 7.67739266e-02f, 7.99798444e-02f, 6.67250454e-02f, -7.48005956e-02f, -9.23413411e-02f, -5.08954674e-02f, -2.24546045e-02f,
  3.03760190e-02f, 1.21391319e-01f, -1.54418945e-01f, -9.79466960e-02f, -1.38141870e-01f, 5.33902310e-02f, -1.81971520e-01f, 1.70011386e-01f, 4.54932749e-02f, 1.69306584e-02f,
  1.16441414e-01f, -6.34085760e-02f, 1.11834705e-01f, 9.20302700e-03f, 1.07326999e-01f, -6.07555583e-02f, -4.63469848e-02f, -1.46516815e-01f, 6.74285367e-02f, 9.58340615e-02f,
  5.64596429e-02f, -1.12411059e-01f, -1.28093109e-01f, -6.62858784e-02f, -4.77091111e-02f, 1.26805827e-01f, -1.77343115e-01f, 1.15799546e-01f, -5.52736446e-02f, -2.84497365e-02f,
  8.11436400e-02f, 5.94437756e-02f, 1.18437083e-02f, 9.15791914e-02f, 1.70921862e-01f, -1.79036781e-01f, -1.59225315e-01f, 1.05439313e-02f, 2.37403139e-01f, -1.58010975e-01f,
  -2.64530759e-02f, -6.89538196e-02f, 1.41246349e-01f, 4.13567238e-02f, -9.89562422e-02f, 2.03721225e-01f, -5.14865816e-02f, 2.49488503e-02f, 5.38415201e-02f, -8.22596401e-02f,
  -1.81475386e-01f, 4.13739756e-02f, -8.50072280e-02f, -1.29538774e-01f, -5.40977232e-02f, 1.44954547e-01f, -9.92254093e-02f, -8.40820521e-02f, -7.11378381e-02f, 7.96110034e-02f,
  2.32639551e-01f, 2.83706281e-03f, 9.63715762e-02f, 1.24817282e-01f, -4.03157845e-02f, 7.25870878e-02f, -2.68752333e-02f, -8.35827515e-02f, -8.72942358e-02f, -1.53571576e-01f,
  -2.55794954e-02f, -3.84271666e-02f, 1.48351833e-01f, 3.11806109e-02f, 7.74976686e-02f, 5.58346231e-03f, 3.23621519e-02f, -9.15457234e-02f, 1.35162398e-02f, -1.51372403e-01f,
  4.54140790e-02f, -7.64950663e-02f, -7.76584595e-02f, -1.29633829e-01f, -1.73620824e-02f, 2.22977065e-02f, -9.55052525e-02f, 5.04427850e-02f, 7.11432621e-02f, 6.40628040e-02f,
  -1.86749119e-02f, -1.01207323e-01f, -1.88995227e-02f, 1.31647727e-02f, 7.83047602e-02f, 1.06616020e-01f, -5.07723466e-02f, -3.06836981e-03f, 4.83907685e-02f, 1.57264784e-01f,
  1.16234440e-02f, 1.95934530e-02f, 7.29376599e-02f, 4.91640754e-02f, -1.72726773e-02f, -6.48314357e-02f, -7.17909858e-02f, -6.95399195e-02f, 1.18220504e-02f, 1.54267401e-01f,
  -9.65247378e-02f, 1.16192326e-02f, -1.22912742e-01f, -1.00212090e-01f, -9.73219611e-03f, -2.40691714e-02f, -1.65107653e-01f, 1.53517514e-01f, -6.97380230e-02f, -2.95373257e-02f,
  -5.29843383e-02f, 9.86651108e-02f, 9.89141241e-02f, -2.92461514e-02f, -7.23357424e-02f, -1.71360895e-01f, -6.26785979e-02f, -1.54389262e-01f, 1.28704190e-01f, -9.98243615e-02f,
  -1.25947416e-01f, 6.93002120e-02f, 6.96606711e-02f, -2.45970041e-02f, -6.99541345e-03f, -3.74602154e-04f, -5.51947998e-03f, 1.25071436e-01f, 5.27674593e-02f, 1.07930377e-01f,
  3.52928713e-02f, 2.49570049e-02f, 1.22059062e-01f, -1.83129847e-01f, -3.80177842e-03f, -7.54197612e-02f, 7.49761611e-02f, 9.48252007e-02f, 2.84024893e-04f, 3.64013575e-02f,
  -6.18818887e-02f, 1.23275913e-01f, 4.11912650e-02f, -9.13827568e-02f, -8.16033222e-03f, 8.99771526e-02f, 2.59970557e-02f, 3.13413739e-02f, -3.99681507e-03f, -1.18132286e-01f,
  -5.97474799e-02f, 6.12345673e-02f, 3.33761014e-02f, 1.14505962e-01f, 8.10284615e-02f, -7.54668638e-02f, 3.99832763e-02f, 2.37598922e-02f, -5.16578741e-02f, 1.20592229e-02f,
  1.85435742e-01f, -3.53770629e-02f, -2.71576494e-02f, 1.73331708e-01f, -6.25479743e-02f, -1.18719906e-01f, 7.47084096e-02f, -5.86747006e-02f, -2.11724669e-01f, -7.80695453e-02f,
  -1.18664227e-01f, 4.00563926e-02f, 1.71694070e-01f, 1.12527914e-01f, 1.05242983e-01f, 1.66162640e-01f, -1.13194823e-01f, -1.43946081e-01f, 1.58952862e-01f, -1.67817511e-02f,
  -2.96577089e-03f, -7.55373761e-02f, -1.60243094e-01f, 1.66232169e-01f, 8.87735859e-02f, 7.01449439e-02f, -8.66040960e-02f, -1.37585580e-01f, 2.52650324e-02f, -8.96362364e-02f,
  7.25341141e-02f, 7.30886236e-02f, 1.47010456e-03f, -5.09069376e-02f, 4.26019840e-02f, 8.93645808e-02f, -6.62402883e-02f, 1.63548335e-01f, 9.01719183e-02f, 5.78185264e-03f,
  -2.85636839e-02f, 1.44699410e-01f, -9.09503698e-02f, -8.83928761e-02f, 3.46461385e-02f, -5.63568957e-02f, -5.66504560e-02f, -7.99326524e-02f, 7.34719038e-02f, 1.46940529e-01f,
  1.22698927e-02f, 1.70990173e-02f, -5.48208579e-02f, 7.34968707e-02f, 2.35273577e-02f, 6.36898577e-02f, -1.13700181e-01f, -1.77550167e-01f, -9.89112332e-02f, 4.98490036e-02f,
  -3.19246389e-02f, -1.79777425e-02f, 5.74591197e-02f, -1.51291452e-02f, -5.89578263e-02f, 8.27199668e-02f, 5.44256456e-02f, -1.39966771e-01f, 4.86952476e-02f, -9.35284495e-02f,
  7.89469704e-02f, 7.34795555e-02f, -1.23077728e-01f, 5.65188099e-03f, 1.90720305e-01f, -1.67141765e-01f, -4.33509573e-02f, -7.06299208e-03f, 2.99475472e-02f, -1.53352842e-01f,
  -4.56679389e-02f, -7.62465922e-03f, 4.85448390e-02f, -1.96264386e-02f, 7.41659030e-02f, 1.28925145e-01f, -7.74011984e-02f, -7.72103891e-02f, 1.00269251e-01f, 5.85755073e-02f,
  5.49949035e-02f, -1.55093625e-01f, 7.88398162e-02f, -1.45610958e-01f, 1.05623320e-01f, -1.66697651e-02f, -8.06935653e-02f, -2.47411747e-02f, -1.01243012e-01f, 3.51784378e-02f,
  -1.20455638e-01f, 1.49658039e-01f, 1.41807590e-02f, 1.26072645e-01f, -5.18561825e-02f, 7.15356469e-02f, 1.62214801e-01f, -1.17666185e-01f, 9.49851051e-02f, -5.24895154e-02f,
  -1.22145131e-01f, -1.05124228e-01f, -4.76380885e-02f, -7.53971040e-02f, -1.11793496e-01f, -1.10211939e-01f, 8.55754912e-02f, 8.80032033e-03f, -1.79070532e-02f, -1.03288852e-01f,
  -1.79176852e-01f, 4.24711965e-03f, -6.93196356e-02f, 2.12307185e-01f, -5.85902072e-02f, -3.17821093e-03f, 1.54411048e-01f, 3.11720669e-02f, -1.31656677e-01f, -6.79204464e-02f,
  6.91987500e-02f, -2.06106737e-01f, 6.10000566e-02f, 1.58869818e-01f, 1.07121542e-01f, 2.03349233e-01f, 1.28911614e-01f, -4.95304689e-02f, 1.10227078e-01f, 6.04889691e-02f,
  -1.50347883e-02f, 3.05690989e-02f, 8.59218538e-02f, 4.48018871e-02f, 9.92316008e-02f, -2.29024589e-02f, -1.53142828e-02f, 1.08047025e-02f, -9.03700888e-02f, 1.37298003e-01f,
  1.42970502e-01f, -1.93105608e-01f, 5.64199500e-02f, 1.15369342e-01f, 4.46628369e-02f, 5.42792231e-02f, 5.09526879e-02f, 1.18843049e-01f, -1.03142992e-01f, 8.72636810e-02f,
  -7.97356516e-02f, -6.14824966e-02f, 9.47467163e-02f, 5.34478426e-02f, 7.23334476e-02f, 1.14839459e-02f, 2.80178897e-02f, -3.89520042e-02f, 1.72308367e-03f, 1.77308768e-02f,
  -2.41186675e-02f, 6.42235354e-02f, 6.32265657e-02f, 9.23687816e-02f, 1.38514536e-02f, 1.03999339e-01f, -1.81767512e-02f, 5.13784215e-02f, 4.53603417e-02f, -2.99272593e-02f,
  -3.08087599e-02f, 1.86728612e-02f, 6.07786179e-02f, -8.40319619e-02f, -1.79926604e-02f, 1.70091167e-02f, -3.63435945e-04f, 9.13415551e-02f, -4.73677367e-02f, -3.89210396e-02f,
  9.89594162e-02f, 3.97433788e-02f, -2.13754736e-02f, -6.44032061e-02f, 4.55182716e-02f, -2.61528399e-02f, 2.31800228e-02f, 1.09589800e-01f, 8.65510851e-02f, -4.51362841e-02f,
  1.02611426e-02f, 1.06541142e-02f, -3.60879898e-02f, -5.41611016e-02f, 5.36413267e-02f, -6.47232533e-02f, -4.44390215e-02f, -5.04906923e-02f, 8.83875415e-02f, 2.80037057e-02f,
  1.05003314e-02f, -3.52707542e-02f, -6.44065514e-02f, -6.26875982e-02f, -1.08818792e-01f, 1.11697763e-01f, 1.33676812e-01f, -4.07886505e-02f, -9.39528570e-02f, -9.76430550e-02f,
  3.09567265e-02f, -4.01686952e-02f, 1.35253295e-01f, -8.93846154e-02f, -8.38372558e-02f, 4.98365238e-02f, 1.48411185e-01f, 1.62171185e-01f, 3.81396413e-02f, 4.01503332e-02f,
  -1.74978673e-02f, 1.03777125e-01f, -8.18547606e-02f, -9.20706168e-02f, 9.98819321e-02f, -1.08422562e-01f, -1.89094283e-02f, -1.15074031e-01f, 1.45789068e-02f, 1.59760579e-01f,
  1.22745097e-01f, 1.23648673e-01f, -7.47529119e-02f, -6.60244748e-02f, 1.51013538e-01f, -7.62855411e-02f, -4.40635085e-02f, -6.59844875e-02f, 1.14322171e-01f, -2.08374914e-02f,
  -9.14134160e-02f, 5.47777824e-02f, 8.86871363e-04f, 2.75277290e-02f, 1.19258367e-01f, -4.69612554e-02f, -1.47386998e-01f, -1.31974146e-01f, -8.76449868e-02f, -8.79792124e-02f,
  -6.80495054e-02f, 1.04382627e-01f, 9.72734615e-02f, 1.88404950e-03f, 1.95126180e-02f, 1.33043468e-01f, 1.92761961e-02f, 2.02223569e-01f, -1.19473226e-01f, -2.14045450e-01f,
  4.57935259e-02f, 1.14492802e-02f, 8.55312347e-02f, 1.06317416e-01f, -1.20613687e-01f, 3.01091224e-02f, -4.50899899e-02f, 1.01461031e-01f, 1.03015766e-01f, -3.97040248e-02f,
  -1.62168536e-02f, 1.92782283e-01f, 1.12673141e-01f, -1.29066899e-01f, -1.07437216e-01f, 1.24933727e-01f, 8.91590714e-02f, -7.70483911e-02f, -5.70681952e-02f, -5.21454178e-02f,
  -4.85575646e-02f, -1.19455427e-01f, 2.70677507e-02f, 2.96746083e-02f, 7.59681836e-02f, 3.40886787e-02f, -1.38829350e-01f, -1.76628470e-01f, 2.14895755e-02f, -9.43360701e-02f,
  -5.48097752e-02f, -5.32386824e-02f, 4.54456508e-02f, 3.15969884e-02f, 1.01001682e-02f, -1.35884926e-01f, -6.99664801e-02f, -9.81070846e-03f, -6.10201294e-03f, -6.05057031e-02f,
  4.58611473e-02f, 4.32290137e-03f, -5.24205528e-03f, -3.91660491e-03f, -9.28231701e-02f, -3.59117575e-02f, -9.41770300e-02f, -7.49871135e-02f, -2.26071272e-02f, -2.37057526e-02f,
  -8.34408998e-02f, -5.59593141e-02f, -3.85926291e-02f, -7.85347372e-02f, -1.16778471e-01f, 2.38594878e-02f, -3.90343368e-02f, -1.30021259e-01f, 4.71308380e-02f, -9.05701146e-02f,
  -1.20892204e-01f, 1.83376446e-02f, -8.35119262e-02f, -1.31757408e-01f, 1.50087394e-03f, 1.80370203e-04f, 1.67336855e-02f, -4.23002243e-02f, 5.16882986e-02f, -2.24715169e-03f,
  5.97509146e-02f, 1.00300582e-02f, 3.62186693e-02f, -1.27529129e-01f, 7.80343683e-03f, 1.18927397e-01f, 5.79259880e-02f, 1.00869738e-01f, 7.08330572e-02f, -4.28344458e-02f,
  -4.36020084e-02f, 1.08071581e-01f, 2.97459718e-02f, -1.66000992e-01f, -1.79144193e-03f, 6.94919028e-04f, -2.73695514e-02f, -6.56242818e-02f, 1.23692602e-01f, -2.19114304e-01f,
  -1.49181962e-01f, 1.07732661e-01f, 8.43890682e-02f, -2.83129960e-02f, -1.33005846e-02f, 2.07598135e-01f, -1.01589687e-01f, -8.90279561e-02f, -1.20922640e-01f, -9.66298655e-02f,
  1.08608179e-01f, 1.97733104e-01f, -5.53805530e-02f, 1.86584502e-01f, -1.11741930e-01f, 9.04267877e-02f, -5.06304353e-02f, 1.27126053e-01f, 1.39946625e-01f, -7.13825226e-02f,
  -1.21897105e-02f, -1.31136507e-01f, -2.10561566e-02f, 5.68316951e-02f, 1.73213810e-01f, 1.52236477e-01f, 2.39085555e-02f, 1.77696660e-01f, 1.23858176e-01f, -8.78161266e-02f,
  -1.17912255e-01f, -4.85411808e-02f, -4.33920808e-02f, -2.17655115e-02f, -1.18417881e-01f, -3.03739589e-02f, 8.89400318e-02f, 1.43699139e-01f, 1.31121874e-01f, 5.44956252e-02f,
  -2.07539231e-01f, -1.38640299e-01f, 2.96296198e-02f, 3.02886367e-02f, 2.30725948e-02f, -2.54256744e-03f, -1.23250611e-01f, -4.20562401e-02f, 1.16388015e-01f, 5.69503903e-02f,
  -5.30670471e-02f, -7.61844218e-02f, 4.06534337e-02f, -1.01791658e-01f, -4.06489670e-02f, 4.90190014e-02f, 8.37064534e-02f, 1.15347793e-02f, -5.24443537e-02f, -4.09032516e-02f,
  -7.80482143e-02f, 7.51195028e-02f, 1.36652933e-02f, 1.03429906e-01f, 5.12887575e-02f, -2.58262381e-02f, 4.21460122e-02f, 4.59421761e-02f, 8.00141245e-02f, -2.91738864e-02f,
  -3.23276892e-02f, -6.86569745e-03f, 2.71138009e-02f, -8.82549137e-02f, 6.51710331e-02f, -5.53451255e-02f, 2.46032863e-03f, 5.05950637e-02f, 1.43819675e-01f, -2.31657960e-02f,
  1.35062665e-01f, 8.12696740e-02f, 2.45489459e-02f, -6.90261796e-02f, -6.97704917e-03f, 4.46289890e-02f, -6.80480599e-02f, -4.58162129e-02f, 6.49445355e-02f, -5.21409623e-02f,
  6.76103234e-02f, 8.70929449e-04f, 1.16473719e-01f, 4.30297442e-02f, 1.49041452e-02f, -2.57743057e-02f, 6.78367391e-02f, 6.18680827e-02f, -7.58400187e-02f, -1.44611867e-02f,
  -4.93017882e-02f, -1.44763617e-02f, 8.49426910e-03f, -5.72102203e-04f, -1.16135843e-01f, -4.85054180e-02f, -3.84706073e-02f, -2.32701171e-02f, 2.11495057e-01f, 4.72278967e-02f,
  2.12452158e-01f, 2.32074913e-02f, 2.96887010e-02f, 2.05637127e-01f, 1.84952095e-01f, -1.26724228e-01f, -1.84292346e-02f, 3.68461870e-02f, 1.06542155e-01f, -9.77637321e-02f,
  -1.99956045e-01f, 4.97419350e-02f, -1.41808763e-01f, -1.21752076e-01f, 4.78079729e-02f, 1.10922545e-01f, 1.11509133e-02f, -4.58709486e-02f, 1.55290917e-01f, 1.69914141e-02f,
  3.18310224e-02f, 1.08774051e-01f, 1.20698586e-01f, 1.57960638e-01f, 3.86767425e-02f, 1.45376235e-01f, 1.79413751e-01f, -4.15074266e-02f, 5.61457537e-02f, 8.32719132e-02f,
  -4.91667446e-03f, 1.31078660e-02f, 9.44934860e-02f, 6.81265304e-03f, -1.44995181e-02f, 1.44798517e-01f, 1.13006763e-01f, -1.57999262e-01f, -2.31062546e-01f, 9.33857113e-02f,
  -8.79935846e-02f, -1.41487181e-01f, -6.82347966e-03f, 8.86981934e-02f, 8.55798870e-02f, -1.06510483e-01f, 6.39794543e-02f, -1.01041622e-01f, -5.07297665e-02f, 8.11498985e-02f,
  1.66097507e-01f, -1.05697446e-01f, -6.10609213e-03f, 6.84809387e-02f, -2.94112898e-02f, -1.32313728e-01f, 1.29470587e-01f, 6.57349452e-02f, -9.28486809e-02f, -3.62129956e-02f,
  -2.23789215e-01f, -9.19836760e-02f, 8.93697217e-02f, -1.89581543e-01f, 4.74288128e-03f, 4.46391366e-02f, -2.40754914e-02f, 5.69514371e-02f, 2.11736169e-02f, 1.10372044e-01f,
  1.07024182e-02f, 7.17885001e-03f, 4.94228117e-02f, -6.12097122e-02f, -1.13111800e-02f, -7.53711984e-02f, 3.59217860e-02f, -1.18413297e-02f, 8.45660344e-02f, 1.04179040e-01f,
  -1.08260289e-01f, -9.89649165e-03f, -2.11668946e-02f, -6.02723844e-02f, -8.65596384e-02f, 2.29913881e-03f, 5.81614766e-03f, 1.69954207e-02f, -1.22408094e-02f, -8.63870829e-02f,
  1.29577503e-01f, 9.52269882e-02f, 2.96591651e-02f, 1.25670090e-01f, -2.71985936e-03f, 9.62516386e-03f, 4.92378250e-02f, 9.53681618e-02f, 4.65393811e-02f, 4.10646992e-03f,
  -5.42108156e-02f, -1.12129441e-02f, -1.09866366e-01f, -4.74666506e-02f, 1.64261818e-01f, 7.44358217e-03f, 1.69085357e-02f, 5.83500005e-02f, 7.84579292e-02f, -1.36253610e-01f,
  2.70776846e-03f, 1.34064555e-01f, 1.42729640e-01f, 3.87149267e-02f, -1.30133005e-02f, 1.05149299e-01f, -1.03490436e-02f, -4.15303931e-02f, -2.99331527e-02f, 1.24674022e-01f,
  1.02135397e-01f, -2.53191460e-02f, 4.62680720e-02f, 2.79877838e-02f, 2.18751132e-02f, 8.16497281e-02f, 1.46937743e-02f, -4.08948436e-02f, 5.52536994e-02f, 1.65782273e-01f,
  -7.93266743e-02f, -5.45987859e-02f, -1.31887466e-01f, 1.34616897e-01f, -2.24677455e-02f, -4.98858616e-02f, 8.11143443e-02f, -1.05282910e-01f, 1.27028868e-01f, -1.55538186e-01f,
  5.42177446e-02f, 1.20146155e-01f, -9.87170935e-02f, 1.09717071e-01f, -1.91891328e-01f, 1.04650944e-01f, -2.11015493e-01f, -2.76993588e-02f, 1.56165898e-01f, 1.34126291e-01f,
  -6.75847605e-02f, -1.28800288e-01f, -1.03230305e-01f, -6.95382431e-02f, -4.60590683e-02f, 8.08330402e-02f, -1.23193905e-01f, -4.40856814e-02f, -4.51672338e-02f, -1.19160324e-01f,
  1.78042874e-01f, -8.35478082e-02f, -3.98146175e-03f, -1.60074487e-01f, 2.26465203e-02f, 2.03292012e-01f, -2.99365856e-02f, 1.08027062e-03f, 1.66073039e-01f, 1.52307943e-01f,
  7.66648399e-03f, -1.23886779e-01f, -6.97341263e-02f, -6.64108759e-03f, -1.82578564e-01f, 5.55861928e-02f, 9.44310427e-03f, -5.05233407e-02f, -1.26459077e-01f, 1.18356414e-01f,
  1.66949153e-01f, 5.43478727e-02f, -1.42741159e-01f, -1.43708318e-01f, 1.72046199e-01f, 1.24952175e-01f, 6.27123713e-02f, 5.03663756e-02f, -1.12807065e-01f, 7.85431117e-02f,
  2.85806973e-02f, 9.82065499e-03f, -8.14274326e-02f, -1.08241230e-01f, -8.23638737e-02f, 2.40896747e-01f, -1.23351924e-02f, 1.24320038e-01f, 1.80932224e-01f, -2.65897289e-02f,
  -1.73956141e-01f, -1.32667184e-01f, -1.09766997e-01f, 6.39039427e-02f, -3.93421352e-02f, 3.23405825e-02f, -8.74360651e-02f, 6.92900419e-02f, 6.93056127e-03f, 9.43188891e-02f,
  4.79560252e-03f, -6.67979866e-02f, 1.20271794e-01f, -2.53706556e-02f, -6.13890626e-02f, -8.36115405e-02f, -6.67243376e-02f, 1.00389376e-01f, 1.16135180e-01f, -5.69679216e-02f,
  -5.43760769e-02f, -5.24245612e-02f, -1.06647201e-01f, 4.19745483e-02f, -2.92433538e-02f, -1.27180181e-02f, -1.13423448e-02f, 9.91181955e-02f, -3.22226714e-03f, -3.31865773e-02f,
  9.72377807e-02f, 3.35313380e-02f, -3.18723693e-02f, 4.57920097e-02f, -1.06862068e-01f, 5.62391058e-02f, 2.45181425e-03f, 1.20387919e-01f, 1.04092345e-01f, 3.48005593e-02f,
  1.96675882e-02f, -2.89650634e-02f, 1.57088950e-01f, -2.30202749e-02f, -4.11909446e-02f, -5.29088490e-02f, -5.90143055e-02f, 1.26614526e-01f, 7.81941190e-02f, 5.70652783e-02f,
  2.32070014e-02f, -9.38924700e-02f, 1.11594193e-01f, -1.00089215e-01f, 8.37105140e-03f, -1.10460632e-02f, 2.98101529e-02f, 2.93440074e-02f, -1.11262081e-02f, -2.84358836e-03f,
  1.04924656e-01f, 4.41321358e-02f, -2.25790720e-02f, -1.04313314e-01f, -1.22141436e-01f, 1.42553926e-01f, 1.54304624e-01f, 1.17522851e-01f, -7.60488138e-02f, -8.25652108e-02f,
  5.34349903e-02f, -2.37580702e-01f, -1.62560698e-02f, 2.11617872e-02f, 5.88476136e-02f, 1.28132582e-01f, -9.63179916e-02f, 1.03307500e-01f, 7.23566860e-02f, -6.23287596e-02f,
  1.04403988e-01f, -1.90291572e-02f, -2.10119992e-01f, -5.03480323e-02f, -1.51938096e-01f, -7.21097663e-02f, -3.23810279e-02f, -2.60318238e-02f, -3.42700854e-02f, -6.41265586e-02f,
  -3.11539304e-02f, 1.33888021e-01f, -4.15085554e-02f, -3.14649567e-02f, 9.97431278e-02f, -1.03406943e-01f, 6.37031794e-02f, 1.99570715e-01f, 1.42274192e-02f, 3.72666679e-02f,
  6.59763888e-02f, 1.07576460e-01f, 2.72433758e-02f, -5.09602726e-02f, 4.75222580e-02f, 6.55002426e-03f, -1.96845740e-01f, -1.97061688e-01f, -1.11168973e-01f, 1.12625323e-02f,
  1.20282672e-01f, 1.26845673e-01f, -1.01570813e-02f, 8.97326842e-02f, -2.19858829e-02f, -3.56644578e-02f, 1.59381866e-01f, -1.02217287e-01f, -6.70396117e-03f, 1.00736931e-01f,
  1.46026909e-01f, 1.49708778e-01f, 1.40658900e-01f, 6.30177632e-02f, 3.50863114e-02f, 1.84377015e-01f, 1.31059378e-01f, 2.27718189e-01f, 5.92796281e-02f, 4.86649424e-02f,
  4.83083911e-02f, 4.60938625e-02f, -1.96834072e-03f, -1.05514467e-01f, 1.43327057e-01f, -7.21636638e-02f, -1.14524374e-02f, 5.15521243e-02f, 7.26194456e-02f, 9.01681632e-02f,
  2.64048502e-02f, 1.30721531e-03f, -1.10016398e-01f, -1.40527307e-04f, 4.49932106e-02f, -9.39355716e-02f, -1.03153206e-01f, 3.28916013e-02f, -7.55407587e-02f, 4.34282199e-02f,
  -6.84157535e-02f, -4.25903313e-02f, -2.29617972e-02f, -5.11257872e-02f, 2.66908612e-02f, -1.14400052e-01f, -2.40269434e-02f, -2.46031545e-02f, -1.55370414e-01f, -4.13837358e-02f,
  1.68567169e-02f, -2.28528343e-02f, -6.17295690e-02f, -5.16794696e-02f, -1.06392719e-01f, 3.71955633e-02f, -1.36991233e-01f, -8.90474692e-02f, 6.92013055e-02f, -1.00177592e-02f,
  -3.05543952e-02f, 2.67041922e-02f, 2.56421268e-02f, 6.57293200e-02f, 6.18381388e-02f, -1.27697930e-01f, -1.24384925e-01f, 8.67442265e-02f, 9.36645344e-02f, 8.21951479e-02f,
  -1.72342718e-01f, 1.91966727e-01f, -4.23933193e-02f, -8.33102688e-02f, 1.00130573e-01f, -7.50064030e-02f, 1.25769749e-01f, 7.59497881e-02f, -1.04567274e-01f, 5.25543168e-02f,
  -1.79739669e-02f, -1.72500070e-02f, 1.54268101e-01f, -1.17166571e-01f, -4.59349044e-02f, 8.96157511e-03f, 1.80163935e-01f, 1.21405810e-01f, 1.35765046e-01f, 6.14821911e-02f,
  1.87402278e-01f, -1.74097605e-02f, 8.23771507e-02f, 1.01291001e-01f, -1.27079427e-01f, -1.34822115e-01f, -1.39286714e-02f, -1.45601287e-01f, 4.22951393e-02f, 1.00632673e-02f,
  1.48552075e-01f, 1.31117344e-01f, 1.23229690e-01f, -6.32109344e-02f, 1.90835267e-01f, 1.32384166e-01f, -7.81678036e-03f, -3.35462461e-03f, -1.84913829e-03f, 1.00504108e-01f,
  -1.22646227e-01f, 3.11192460e-02f, 4.90132868e-02f, 1.87730968e-01f, 9.58881825e-02f, -2.20703244e-01f, -6.87014088e-02f, 1.11095406e-01f, -3.66747454e-02f, 1.75438911e-01f,
  -1.02134615e-01f, 2.16126531e-01f, 1.51186258e-01f, -1.07214987e-01f, -7.83681497e-02f, 7.40458891e-02f, 1.41418934e-01f, -7.05261678e-02f, -2.21104510e-02f, -1.02245152e-01f,
  -9.66153666e-02f, -5.71596585e-02f, 1.17424272e-01f, 2.37366315e-02f, 1.47541508e-01f, -9.64677259e-02f, 7.38293305e-02f, -2.25099307e-02f, 1.34735033e-02f, -4.22999710e-02f,
  -8.91864970e-02f, -4.35578190e-02f, 3.38228866e-02f, -1.74606163e-02f, 3.83956768e-02f, -1.54698446e-01f, -7.58878887e-03f, -1.68782771e-02f, -4.26822109e-03f, 1.48057505e-01f,
  3.94123867e-02f, 1.02923922e-01f, 4.97896634e-02f, 1.13975583e-02f, -5.60163409e-02f, 6.87463582e-02f, 2.10274719e-02f, 1.67315364e-01f, -5.25040645e-03f, 1.08996099e-02f,
  -8.54963958e-02f, 1.03333350e-02f, -5.91848232e-02f, 1.02063991e-01f, 8.55229273e-02f, -1.14690952e-01f, -4.92936652e-03f, 2.36471351e-02f, -4.09753248e-02f, -1.09279761e-02f,
  -1.84155833e-02f, 4.17973567e-03f, 4.97416258e-02f, -1.07329823e-01f, 5.25675416e-02f, -1.86626855e-02f, 5.09068258e-02f, -2.26839446e-02f, -7.10949153e-02f, -7.26640150e-02f,
  1.14502735e-01f, -1.98352244e-02f, 8.73765424e-02f, -3.61565361e-03f, 1.33952081e-01f, -1.24681227e-01f, -7.72566423e-02f, 2.87749898e-02f, 2.11737603e-02f, 3.43530579e-03f,
  1.67611524e-01f, -2.47433074e-02f, 7.44006876e-03f, -3.80090214e-02f, -6.91378415e-02f, 2.20219940e-02f, 2.26548146e-02f, 5.94673567e-02f, 9.12413225e-02f, -1.69605061e-01f,
  8.05491135e-02f, 1.53870642e-01f, -1.29253089e-01f, 1.62155349e-02f, -1.07871711e-01f, -1.16988316e-01f, -1.01414822e-01f, -2.11151898e-01f, -1.61024943e-01f, 9.34163928e-02f,
  -2.90983692e-02f, -9.27105322e-02f, -1.73727006e-01f, 1.20746776e-01f, 9.00895447e-02f, -8.87065753e-02f, 5.48339486e-02f, -4.03871387e-02f, 1.88170001e-01f, -1.53310850e-01f,
  7.91082904e-02f, -3.97884436e-02f, -7.44309202e-02f, -1.23190105e-01f, 1.09740771e-01f, -1.61905168e-03f, -2.33712196e-02f, 1.92299336e-01f, -5.81953414e-02f, -7.45880157e-02f,
  -6.50859699e-02f, -1.18770432e-02f, 2.06019476e-01f, 1.09165601e-01f, -1.45022660e-01f, 1.70438379e-01f, -1.22694634e-01f, -6.05115779e-02f, -1.06789246e-01f, -1.51438657e-02f,
  1.10491686e-01f, -1.31944492e-01f, -8.17326605e-02f, -2.13395804e-03f, -1.46905959e-01f, 7.88704529e-02f, -3.43336142e-04f, -9.66436863e-02f, 5.80065846e-02f, 5.78912087e-02f,
  -7.94374794e-02f, -5.49819879e-02f, 1.37116939e-01f, -2.85472795e-02f, -7.54790530e-02f, 8.17223266e-03f, -4.39428026e-03f, 8.26125741e-02f, -1.65545233e-02f, -9.47231874e-02f,
  -8.66327509e-02f, 2.11120188e-01f, 1.04303636e-01f, 7.13513792e-02f, 2.60284059e-02f, 5.05650453e-02f, 7.11963419e-03f, -1.85214616e-02f, -8.83790851e-02f, -1.07484825e-01f,
  -2.20834855e-02f, -2.32251912e-01f, -9.97848809e-02f, 8.55578557e-02f, 5.42674363e-02f, 9.01577175e-02f, 9.32329297e-02f, -5.73374778e-02f, 5.93050458e-02f, -1.72289424e-02f,
  1.49343371e-01f, -4.12536822e-02f, 4.39337157e-02f, -6.17913976e-02f, -3.99754383e-02f, -6.89947829e-02f, -5.59808202e-02f, -1.12504149e-02f, -4.27386118e-03f, 7.13761225e-02f,
  3.19316499e-02f, 4.91194502e-02f, 7.21992925e-03f, 1.95317268e-02f, -1.32874446e-02f, -4.76848893e-02f, -2.75627654e-02f, -7.89040923e-02f, 5.17830066e-02f, 4.14390266e-02f,
  4.46602814e-02f, 6.82353154e-02f, -6.04512952e-02f, -2.08066460e-02f, -3.82500999e-02f, 5.79843856e-02f, 1.25840217e-01f, 6.61199689e-02f, -2.57119648e-02f, 8.23355187e-03f,
  -3.03934887e-02f, 8.52127373e-03f, 4.15282603e-03f, 1.10209465e-01f, 1.05242647e-01f, -4.70510572e-02f, 7.36729652e-02f, 1.55348301e-01f, -1.95766240e-01f, 1.72084402e-02f,
  5.34122400e-02f, 7.29623064e-02f, 3.61441150e-02f, 6.99293092e-02f, 1.22710280e-01f, 6.72434568e-02f, -1.97059698e-02f, 1.54146984e-01f, 4.04719114e-02f, -1.18070818e-01f,
  2.11931825e-01f, 7.89119601e-02f, 6.42202199e-02f, 5.39310388e-02f, 6.13263212e-02f, 2.24855945e-01f, -5.30967601e-02f, 1.38641104e-01f, 6.11965172e-02f, -1.05922885e-01f,
  -1.03331013e-02f, -2.10796133e-01f, -2.95781549e-02f, 1.67713419e-01f, -1.35492086e-02f, 1.56804025e-01f, -7.12991953e-02f, 1.06767774e-01f, -3.35277840e-02f, -5.00710905e-02f,
  7.26928115e-02f, 2.55964175e-02f, -2.36174524e-01f, -5.70849627e-02f, -1.55634917e-02f, 7.33703226e-02f, 1.55294929e-02f, 2.42642742e-02f, 1.08527541e-01f, 9.22642350e-02f,
  -1.44537359e-01f, -3.47882160e-03f, 1.48073882e-01f, 5.31250201e-02f, 8.43894929e-02f, -9.15328488e-02f, -2.05450971e-02f, -5.64981531e-03f, -1.74409952e-02f, -8.59006569e-02f,
  9.40038711e-02f, 3.83057967e-02f, 6.60840571e-02f, -1.16815947e-01f, -1.00583054e-01f, 4.49374653e-02f, -1.40645564e-01f, 3.91948335e-02f, 1.14946648e-01f, -1.86996665e-02f,
  -1.04921192e-01f, 1.91938370e-01f, 1.12267368e-01f, -5.41673005e-02f, -1.14600472e-01f, -1.66805357e-01f, 2.33413093e-02f, 7.55166858e-02f, 3.08827087e-02f, -1.80056408e-01f,
  -1.24759376e-01f, -8.88476893e-02f, 1.08394794e-01f, -1.79711491e-01f, -1.29653752e-01f, -1.17020026e-01f, -1.54358506e-01f, 5.81343053e-03f, -3.75147760e-02f, 6.51267692e-02f,
  1.07242845e-01f, -2.01102957e-01f, -3.34296860e-02f, -2.01260485e-02f, 9.32359323e-03f, -4.01870012e-02f, -4.55608331e-02f, 2.55369022e-02f, -1.36012631e-02f, 6.58924431e-02f,
  -5.32623827e-02f, 2.15978120e-02f, 4.49832156e-02f, -6.10050224e-02f, 4.64036614e-02f, -8.83379430e-02f, 2.15236843e-02f, -2.14516129e-02f, -2.59435680e-02f, 2.44073533e-02f,
  1.03003569e-02f, 6.09345585e-02f, -2.77748406e-02f, 6.41436800e-02f, 4.18635271e-02f, 8.19286034e-02f, 7.09318072e-02f, -8.88495073e-02f, 4.10504565e-02f, -3.93891148e-02f,
  8.42910334e-02f, -1.48619488e-02f, -4.59197834e-02f, -8.10774192e-02f, 1.95076112e-02f, -1.30205140e-01f, -1.21364266e-01f, 1.93608049e-02f, 3.04861162e-02f, -1.23356201e-01f,
  1.28412664e-01f, 1.14470333e-01f, -1.05887122e-01f, 7.50177205e-02f, 1.31604197e-02f, -4.92791906e-02f, -1.02529116e-01f, -2.44414620e-02f, -1.08034313e-02f, 3.57710607e-02f,
  5.55246398e-02f, 1.31905228e-02f, -8.68880972e-02f, 3.99500830e-03f, 8.60600322e-02f, -2.11425081e-01f, 1.57523885e-01f, 1.87867403e-01f, 8.47275648e-03f, 9.36712176e-02f,
  -1.53895095e-01f, 4.34601866e-02f, 5.01346737e-02f, -9.36272666e-02f, 9.13728997e-02f, -1.17566705e-01f, -5.03338613e-02f, 9.72489268e-02f, -1.89656785e-04f, -4.94992658e-02f,
  -9.48116034e-02f, -1.00497656e-01f, -1.06176451e-01f, -1.63951695e-01f, -1.91741765e-01f, -2.04775091e-02f, -1.11795299e-01f, -7.07805604e-02f, 1.09103188e-01f, 1.82204559e-01f,
  1.76506370e-01f, 1.61891162e-01f, -1.49653569e-01f, -1.11952849e-01f, -6.70885518e-02f, -2.12699305e-02f, -9.05028582e-02f, -5.09796776e-02f, -3.29357088e-02f, -7.53876567e-02f,
  1.58221737e-01f, 4.43627983e-02f, -8.21228549e-02f, -9.38658789e-03f, 9.32955965e-02f, 6.62436783e-02f, 9.68896523e-02f, -1.21809384e-02f, 1.30016282e-01f, 1.88417941e-01f,
  -1.39672354e-01f, -3.62203754e-02f, 7.44279698e-02f, -1.56048357e-01f, -5.88956587e-02f, -7.56115913e-02f, -1.69104904e-01f, 1.81412976e-02f, 4.00232524e-02f, -3.52959558e-02f,
  1.41703915e-02f, 5.97864874e-02f, -8.76632621e-05f, -7.39243999e-02f, 4.07405160e-02f, -3.33313867e-02f, -5.72309783e-03f, 9.62695032e-02f, -1.41405329e-01f, 3.38810943e-02f,
  -1.55214161e-01f, 2.75411252e-02f, 4.08211350e-02f, -1.58455133e-01f, 9.70228240e-02f, 2.01161444e-01f, -8.90628248e-02f, -4.76847626e-02f, 1.16856381e-01f, 6.85810819e-02f,
  -3.69408429e-02f, -1.66348934e-01f, 1.37328329e-02f, -1.92781296e-02f, -1.07115842e-01f, -5.34151830e-02f, -1.87726334e-01f, 1.63561314e-01f, -1.06842173e-02f, 1.07658274e-01f,
  -5.71611617e-03f, 8.74118581e-02f, -1.35770254e-02f, -1.09022290e-01f, -5.57513721e-02f, 1.14220856e-02f, -5.62712811e-02f, -4.84652445e-02f, 1.80445984e-02f, 3.00869085e-02f,
  -1.01322711e-01f, -3.33112739e-02f, -2.71460358e-02f, -2.11074995e-03f, -9.77962017e-02f, -8.46868753e-02f, -5.44725824e-03f, -6.78316504e-02f, 1.99407581e-02f, -1.17808789e-01f,
  4.42242026e-02f, 4.31911461e-02f, 1.42197264e-02f, -2.84905918e-02f, -4.47518975e-02f, -1.03359446e-01f, -1.00484572e-01f, -1.51415154e-01f, 4.32933960e-03f, -1.78193852e-01f,
  -1.00382708e-01f, -4.11610343e-02f, -1.09818615e-01f, -4.33939919e-02f, 1.07895108e-02f, 2.54870951e-02f, 1.66546963e-02f, -1.24953225e-01f, -4.93668718e-03f, -4.47407477e-02f,
  -8.62671882e-02f, 2.95649320e-02f, 1.65079739e-02f, -4.15685661e-02f, 1.34442553e-01f, 6.57647476e-02f, 2.14242488e-02f, 1.83212981e-02f, -6.20220713e-02f, 4.64091375e-02f,
  1.07611768e-01f, -1.70328483e-01f, -1.48613956e-02f, -8.11943486e-02f, 2.39077117e-03f, 2.33307201e-02f, -1.84204042e-01f, 6.38816692e-03f, -6.76620081e-02f, -1.49806842e-01f,
  -4.93811257e-02f, -1.06134564e-02f, 1.66059181e-01f, 3.07221897e-02f, 8.64897668e-02f, 7.71948248e-02f, -2.71826126e-02f, -4.30422649e-03f, 1.28677353e-01f, 7.60209337e-02f,
  -8.14334601e-02f, 4.53441888e-02f, 3.37649435e-02f, -2.28869379e-01f, -1.54339358e-01f, -6.89738914e-02f, 7.50349835e-02f, 1.29879400e-01f, 3.58563699e-02f, 1.01397805e-01f,
  -1.67919904e-01f, 5.36020808e-02f, 1.30506888e-01f, 2.72569433e-02f, -1.24407135e-01f, -5.80011718e-02f, -3.51122022e-02f, -8.02629292e-02f, -3.42055298e-02f, 1.08110666e-01f,
  1.39741987e-01f, -1.72891870e-01f, 1.44660100e-01f, 4.84547690e-02f, -1.34766206e-01f, 2.39104852e-02f, 2.11289033e-01f, -1.59788042e-01f, 9.61412936e-02f, -4.48523685e-02f,
  1.39023393e-01f, 6.91843256e-02f, -1.22150080e-02f, -1.06186435e-01f, -8.51976722e-02f, 6.95385337e-02f, -3.79526578e-02f, 7.09094256e-02f, 5.09239994e-02f, -1.95220802e-02f,
  7.46464282e-02f, 8.83465633e-02f, -1.39853060e-02f, -9.02581215e-02f, -3.94366868e-02f, 1.41947307e-02f, 5.24141714e-02f, 1.51782691e-01f, -1.62417993e-01f, 1.74903452e-01f,
  -9.94880274e-02f, 6.18127696e-02f, 9.71230045e-02f, -9.23618115e-03f, -9.18428078e-02f, -2.13481244e-02f, 2.93678325e-02f, -6.85233548e-02f, 1.72304604e-02f, 5.71245188e-03f,
  -6.06881045e-02f, -5.42193726e-02f, -2.78737321e-02f, -7.74507895e-02f, 1.43464860e-02f, 2.77022198e-02f, 9.57758725e-02f, 8.41192976e-02f, 7.69575462e-02f, -6.45432100e-02f,
  5.32271788e-02f, 1.70553867e-02f, 3.49001549e-02f, 4.57963496e-02f, 3.57174017e-02f, 5.51385395e-02f, 1.38348058e-01f, 2.33183801e-02f, -8.73292610e-02f, 1.14542358e-01f,
  -4.05999646e-02f, -9.08346027e-02f, -4.70162258e-02f, -3.16265784e-02f, 1.13161653e-01f, -9.18305814e-02f, 3.50041948e-02f, -8.27068463e-03f, 7.83802345e-02f, 3.35911997e-02f,
  -8.87179151e-02f, -3.47462595e-02f, 7.44900927e-02f, 9.05284509e-02f, -3.40896621e-02f, -6.70906669e-03f, 8.57343227e-02f, -6.49123862e-02f, -8.79692882e-02f, 3.20800915e-02f,
  4.69652489e-02f, -1.80857852e-02f, -1.57626197e-01f, 1.83682833e-02f, 1.43779263e-01f, 1.08377479e-01f, -5.34204468e-02f, -4.33541052e-02f, -2.03717127e-02f, -4.69676331e-02f,
  -1.83865920e-01f, 2.88293939e-02f, -5.00376523e-03f, -1.84680894e-01f, 1.53559977e-02f, 1.49824265e-02f, 6.66803569e-02f, -8.50336328e-02f, -4.63412069e-02f, -2.83268671e-02f,
  -1.90161705e-01f, 1.79817647e-01f, -5.58133014e-02f, -1.48534551e-01f, -7.26277977e-02f, 1.83870062e-01f, -1.08070597e-02f, -4.33666222e-02f, -2.49585770e-02f, 1.48158640e-01f,
  -2.20159646e-02f, 1.63454086e-01f, -1.92512736e-01f, -3.62243201e-03f, 3.93190496e-02f, -7.71913826e-02f, 1.85319066e-01f, 1.37406424e-01f, 9.71035659e-02f, -5.74260987e-02f,
  9.91277993e-02f, 6.53206632e-02f, -2.65028570e-02f, -8.88446271e-02f, -1.38492361e-01f, 4.44739945e-02f, 4.46729660e-02f, -1.38000011e-01f, 2.96991542e-02f, 2.07241159e-03f,
  -8.14448446e-02f, 4.83062342e-02f, 3.23791131e-02f, 2.25579794e-02f, -5.06346524e-02f, -1.23501360e-01f, 8.12283754e-02f, -1.07077427e-01f, -1.34418219e-01f, -6.70575202e-02f,
  -1.40095577e-02f, -1.49715751e-01f, 4.99279946e-02f, 1.09151758e-01f, -6.84897527e-02f, 1.49802389e-02f, 5.56015633e-02f, -1.53755501e-01f, 2.61662770e-02f, -9.38236639e-02f,
  -1.04920506e-01f, -1.64436385e-01f, -1.71827853e-01f, 6.64433539e-02f, -5.54815643e-02f, -1.46381482e-02f, -9.68414620e-02f, -1.41117379e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  1.58692196e-01f, 1.30755708e-01f, 2.57216692e-01f, 2.23849997e-01f, 6.30563423e-02f, -4.52260561e-02f, 5.21434285e-03f, 2.59424057e-02f, 8.83826166e-02f, 1.05742641e-01f,
  1.07682571e-02f, 1.12888761e-01f, 2.53214270e-01f, 1.49263799e-01f, 7.65258074e-02f, 2.58063406e-01f, 8.54032859e-02f, 2.11500451e-01f, 8.85185823e-02f, 7.84493387e-02f,
  2.05926567e-01f, 1.42629549e-01f, 2.87923038e-01f, 6.14033826e-02f, 1.43212378e-01f, 1.21809155e-01f, 7.36991093e-02f, 1.24924421e-01f, -3.43531417e-03f, 1.63291201e-01f,
  1.59365594e-01f, 1.18325010e-01f, 1.37621298e-01f, 1.23518705e-01f, 3.11676383e-01f, -2.04696544e-02f, 1.61999583e-01f, 1.17113680e-01f, 1.38440907e-01f, 1.64668873e-01f,
  -7.81203434e-03f, 1.98689684e-01f, 1.21425338e-01f, 1.90089092e-01f, 1.96966678e-01f, 1.42571196e-01f, 4.03837711e-02f, 1.89754795e-02f, 2.09520787e-01f, 7.24036545e-02f,
  6.26343489e-02f, 1.07509000e-02f, 1.42604839e-02f, -6.66056480e-03f, 1.24499798e-01f, 3.47307295e-01f, -1.35273337e-01f, -2.33887970e-01f, -2.22618774e-01f, 2.29769647e-01f,
  -2.62224585e-01f, 1.53037935e-01f, 9.46035758e-02f, -1.79817900e-01f, 9.34567675e-02f, -1.76550940e-01f, -6.77058622e-02f, -1.62848040e-01f, -3.11376005e-01f, 8.88173655e-02f,
  -2.97870666e-01f, 1.74199462e-01f, -9.52540636e-02f, -1.73309490e-01f, 2.16608629e-01f, 7.50369281e-02f, 7.57806674e-02f, 1.58314928e-01f, -2.42499158e-01f, 1.93559259e-01f,
  -1.08264260e-01f, 9.95117947e-02f, 3.28577794e-02f, 2.90736626e-03f, 7.28695989e-02f, 6.56064525e-02f, 1.52603686e-01f, 2.40961671e-01f, 1.24017097e-01f, -3.19548994e-01f,
  8.21411982e-02f, 6.90933503e-03f, 1.82110861e-01f, -2.23282665e-01f, -7.17191100e-02f, 2.23998755e-01f, 1.87762678e-01f, -1.71604812e-01f, -1.26797050e-01f, -1.06509537e-01f,
  -2.81800836e-01f, -2.80779243e-01f, -1.84942633e-01f, -5.05377278e-02f, 9.15037021e-02f, 1.58728078e-01f, -1.29649937e-01f, -2.21485756e-02f, -2.06333235e-01f, -2.11829603e-01f,
  2.63844319e-02f, 1.05601542e-01f, -1.47585452e-01f, 3.60902935e-01f, -1.01009354e-01f, 1.13647647e-01f, -2.68686488e-02f, -1.97625652e-01f, -2.17899948e-01f, -2.01599687e-01f,
  1.78083479e-02f, -2.60649365e-04f, -1.71523690e-01f, -2.37439543e-01f, 1.60196703e-02f, -5.62098622e-02f, 2.28778571e-01f, -2.14887977e-01f, 7.37529900e-03f, 2.72212714e-01f,
  1.04120195e-01f, 5.63494787e-02f, 1.04181573e-01f, 8.57563242e-02f, 9.01574045e-02f, 2.23905414e-01f, 1.20838605e-01f, 4.19173986e-02f, 1.04691632e-01f, 9.94147286e-02f,
  1.31498292e-01f, 1.85379043e-01f, 3.42878215e-02f, 2.40766317e-01f, 4.83645387e-02f, 8.36385414e-02f, 1.55732259e-01f, 8.34337324e-02f, -1.99765805e-03f, -4.35556099e-02f,
  9.58493724e-02f, 6.75831512e-02f, 1.86015993e-01f, 1.57252535e-01f, 1.78961128e-01f, 1.67530909e-01f, 3.59417722e-02f, 9.19741839e-02f, 1.19145475e-01f, 1.39868125e-01f,
  1.90974653e-01f, 6.21009320e-02f, 4.26442921e-02f, 2.55989015e-01f, 1.26857487e-02f, 6.13642111e-02f, 1.55204251e-01f, 9.23737064e-02f, 2.55290985e-01f, 6.43624067e-02f,
  -1.03785899e-02f, 2.53209949e-01f, 1.77544326e-01f, 2.04188034e-01f, -2.00527757e-02f, 1.78694591e-01f, 2.91754514e-01f, 5.02008349e-02f, 1.11616917e-01f, 2.71931626e-02f,
  -2.83650070e-01f, -2.22543463e-01f, 4.31153513e-02f, -9.95608345e-02f, 4.78549004e-02f, -3.30384970e-01f, -2.56867021e-01f, 2.08181709e-01f, -1.70688719e-01f, 2.31995583e-01f,
  2.49349745e-03f, -6.81025684e-02f, 2.34398283e-02f, 3.02558448e-02f, 2.59304404e-01f, 5.66662773e-02f, 2.31213167e-01f, 4.55604680e-02f, 1.81803435e-01f, -1.96804442e-02f,
  -3.19542587e-02f, -6.75129890e-02f, -3.30187976e-01f, -1.56644449e-01f, -1.51620105e-01f, -2.10448250e-01f, 3.10851872e-01f, 2.90883332e-01f, -2.78239280e-01f, 2.03096315e-01f,
  7.04236329e-03f, 6.91390336e-02f, 1.16961725e-01f, -2.09603198e-02f, -4.71377671e-02f, 1.38989002e-01f, 3.05264115e-01f, 2.88351383e-02f, -2.16068491e-01f, -1.74886733e-01f,
  1.64195225e-01f, -8.11478496e-02f, -1.91683292e-01f, -1.09644733e-01f, 1.54885396e-01f, -3.58406939e-02f, -1.56915888e-01f, 3.75064552e-01f, -1.71215355e-01f, 1.88871846e-01f,
  2.89015353e-01f, -3.04283410e-01f, -3.39997292e-01f, 1.76267371e-01f, -1.26581147e-01f, -1.85323551e-01f, 1.22750223e-01f, 1.27348214e-01f, -8.78227428e-02f, -4.34695035e-02f,
  1.45572275e-01f, 2.30775476e-01f, 3.53742540e-01f, 1.28919363e-01f, 1.49207205e-01f, -1.17530502e-01f, -3.01508955e-03f, 3.29479605e-01f, -2.41058916e-01f, -3.17103237e-01f,
  -1.30889162e-01f, -7.41794705e-02f, 4.13045362e-02f, -1.19800074e-02f, 1.20281093e-01f, 1.27649605e-01f, 1.29812732e-01f, 1.18405782e-01f, 6.75034374e-02f, 1.69785202e-01f,
  2.04064269e-02f, 7.57190585e-02f, -1.30215064e-02f, -1.07339146e-02f, 1.36870116e-01f, 6.87423423e-02f, 5.53972870e-02f, -6.59753606e-02f, 7.96169117e-02f, 1.65515840e-01f,
  1.50933571e-03f, 1.70207947e-01f, -1.35096591e-02f, 6.93516359e-02f, 1.66529402e-01f, 3.79496887e-02f, -2.01593377e-02f, -4.44420875e-04f, 1.08093277e-01f, 6.68354332e-02f,
  -1.00845061e-02f, -9.06009413e-03f, 2.55896956e-01f, 7.86051601e-02f, 1.37795225e-01f, 2.02971444e-01f, 4.46315333e-02f, 4.40231673e-02f, 1.51229873e-01f, -7.89328367e-02f,
  1.96464807e-01f, 8.42275936e-03f, 1.94221333e-01f, 3.94042879e-02f, 7.77414963e-02f, 2.74755299e-01f, -5.07947169e-02f, 3.25098522e-02f, 1.78090185e-01f, 1.32883102e-01f,
  6.10265434e-02f, 1.23075828e-01f, 8.65630880e-02f, 3.34112495e-02f, 5.99437393e-02f, 6.57588989e-02f, 1.26997650e-01f, -1.79021388e-01f, -2.22599968e-01f, 2.10616842e-01f,
  1.32568002e-01f, 2.16977358e-01f, -5.90725169e-02f, 5.06998925e-03f, -2.54831344e-01f, -3.16477001e-01f, -1.93252176e-01f, 1.05743691e-01f, 2.43577912e-01f, -3.01266909e-01f,
  -2.05824688e-01f, 3.30780834e-01f, 6.05241321e-02f, -3.05519789e-01f, -1.41077200e-02f, 2.95292935e-03f, -1.46039575e-01f, 2.68518001e-01f, 1.36943176e-01f, 1.14049323e-01f,
  5.91036072e-03f, 1.09492712e-01f, 2.14516193e-01f, 8.11196119e-02f, 8.23534727e-02f, 2.93847024e-01f, -1.88919101e-02f, -1.11394957e-01f, -2.77170628e-01f, -2.77795672e-01f,
  1.99206874e-01f, -4.63508666e-02f, -4.75165769e-02f, 6.49238229e-02f, 1.36370629e-01f, -1.62499666e-01f, 1.10095948e-01f, -2.29001075e-01f, 1.79471429e-02f, -8.35856423e-02f,
  4.25457396e-02f, 1.25888586e-01f, -5.95780015e-02f, 8.44158456e-02f, 7.93188363e-02f, -1.59015089e-01f, -1.41123356e-02f, -6.72962740e-02f, 1.04644626e-01f, -1.62575059e-02f,
  1.05524443e-01f, -1.93600953e-01f, 6.31282255e-02f, 2.29575243e-02f, -2.09672540e-01f, -1.66794181e-01f, -1.90686896e-01f, -3.06927353e-01f, 2.51816422e-01f, 1.50770128e-01f,
  1.68352455e-01f, -1.04109235e-02f, 1.31658748e-01f, -1.36640862e-01f, 3.78644392e-02f, -5.70665449e-02f, 2.34954536e-01f, 2.83561479e-02f, -1.98107272e-01f, 1.83093742e-01f,
  -9.30983946e-02f, 2.96319991e-01f, 2.28185073e-01f, -1.37680978e-01f, 1.58670247e-01f, 1.00913160e-01f, 1.25248954e-01f, 1.07887164e-01f, 5.60344756e-02f, 9.53485817e-02f,
  2.68941015e-01f, 2.13008776e-01f, 1.20373942e-01f, 2.04888403e-01f, 6.85544685e-02f, 1.69303104e-01f, 8.91668350e-02f, -6.37675077e-02f, 1.28123716e-01f, 8.90388212e-04f,
  1.78829417e-01f, 5.42355515e-02f, -2.88852323e-02f, 9.97117311e-02f, 1.00374281e-01f, 1.35846287e-01f, 7.80597627e-02f, 1.79577872e-01f, 1.06918640e-01f, 8.97186026e-02f,
  1.74986884e-01f, 7.40158558e-02f, 1.84153035e-01f, -3.67437908e-03f, 1.05223775e-01f, 1.20505027e-01f, 2.00553387e-01f, 1.04186319e-01f, -6.55433210e-03f, 8.06428865e-02f,
  4.75925431e-02f, 2.53908802e-03f, 5.11661209e-02f, 9.90898237e-02f, 1.10091999e-01f, 1.50325432e-01f, 6.15782291e-02f, -6.35740682e-02f, 2.01099329e-02f, 3.20299901e-02f,
  9.99519154e-02f, 1.39679193e-01f, -6.18960783e-02f, 9.47268009e-02f, 1.36276931e-01f, -1.76243857e-01f, 2.38456037e-02f, 2.01753438e-01f, -8.62023160e-02f, -2.11273860e-02f,
  4.41615246e-02f, 1.37363523e-01f, 7.69584775e-02f, 7.18314871e-02f, 2.15816498e-01f, -4.67193387e-02f, -2.06814021e-01f, 2.14210242e-01f, 2.19181757e-02f, 1.33523092e-01f,
  -1.68105498e-01f, -3.86302322e-02f, 7.02328607e-02f, 1.29235595e-01f, 3.25381756e-02f, -1.61466569e-01f, 1.79895326e-01f, -4.88949828e-02f, -1.32016659e-01f, 5.61964363e-02f,
  2.29818299e-01f, 1.20185949e-01f, -1.19401850e-01f, -2.11945847e-01f, 1.69864640e-01f, -1.46487713e-01f, -7.14984015e-02f, -9.26719159e-02f, -2.48098284e-01f, 1.67094365e-01f,
  2.15353191e-01f, -1.35238722e-01f, -2.87296444e-01f, 9.63064358e-02f, 6.73730001e-02f, 1.38909295e-01f, -1.05917402e-01f, -5.73107041e-02f, -4.45603728e-02f, -4.18206453e-02f,
  -2.41192624e-01f, 1.04695290e-01f, 2.03689169e-02f, -2.04900667e-01f, 2.34224916e-01f, 6.23660050e-02f, -2.73202598e-01f, 2.47080117e-01f, 1.71612278e-01f, -2.74523169e-01f,
  1.89642102e-01f, -1.81460947e-01f, 3.43928516e-01f, 3.35197389e-01f, -1.72154382e-01f, -1.27768114e-01f, -1.37148529e-01f, -1.33770853e-02f, -3.01478095e-02f, -9.09331627e-03f,
  -1.10590652e-01f, 2.32872397e-01f, 2.92484581e-01f, 2.09533662e-01f, -1.31858334e-01f, -2.16873422e-01f, 2.33859479e-01f, 2.16373848e-03f, -4.36802693e-02f, 1.58669308e-01f,
  -1.61860973e-01f, 2.92509258e-01f, 4.84086201e-02f, 5.75602353e-02f, 1.06313907e-01f, 1.38002068e-01f, 3.72015908e-02f, 7.88362101e-02f, 1.07300073e-01f, 1.63846090e-01f,
  1.59662515e-01f, 1.85296431e-01f, 3.38075086e-02f, -8.75816047e-02f, 2.08809569e-01f, 2.82889418e-03f, 5.17333783e-02f, 8.71022567e-02f, 5.23117706e-02f, 3.48062105e-02f,
  1.77246779e-01f, 1.03109814e-01f, 5.43550886e-02f, 2.78552324e-02f, 1.53075144e-01f, 2.63310485e-02f, 3.86450104e-02f, 1.29155472e-01f, 1.27521127e-01f, 1.59542803e-02f,
  5.48240654e-02f, 1.65708452e-01f, 2.28070095e-01f, 3.57199050e-02f, 3.22132967e-02f, 5.84786907e-02f, 1.44265249e-01f, -1.95180997e-02f, 1.81900471e-01f, 4.46335487e-02f,
  1.13609746e-01f, 2.06141800e-01f, 4.93304133e-02f, 2.85261236e-02f, 4.74921428e-02f, 1.66998014e-01f, 9.71542150e-02f, -1.33702308e-02f, 5.05714454e-02f, 8.40122923e-02f,
  -1.65438801e-02f, 1.38061438e-02f, -1.69227980e-02f, 1.83591649e-01f, 1.30767882e-01f, 1.13439962e-01f, 2.48576999e-01f, 2.27036625e-01f, -3.73334922e-02f, 1.77652031e-01f,
  -6.70014322e-02f, -1.07895203e-01f, -2.57768780e-01f, 8.68606940e-02f, 2.02355444e-01f, -2.48688638e-01f, -1.30441979e-01f, 1.38926685e-01f, -1.85307354e-01f, -3.07898194e-01f,
  -1.04105458e-01f, 1.09577872e-01f, -2.44770229e-01f, 1.42352000e-01f, 1.45207167e-01f, 8.85227099e-02f, -6.21846244e-02f, 2.61100143e-01f, 1.50456384e-01f, 2.23996922e-01f,
  1.85822081e-02f, 2.82449156e-01f, 2.88641565e-02f, -4.71920744e-02f, -2.04109117e-01f, -1.22557327e-01f, 8.35147947e-02f, 2.80312210e-01f, 2.17867061e-01f, -2.04668194e-02f,
  5.77873513e-02f, -2.03351215e-01f, 3.24527979e-01f, -8.48863944e-02f, -1.63495392e-01f, -6.31289110e-02f, 1.37965724e-01f, -4.52205054e-02f, -2.65528522e-02f, 1.65348157e-01f,
  1.89592633e-02f, -1.26283942e-02f, -6.69674873e-02f, -1.32653996e-01f, 2.22394004e-01f, 6.03390187e-02f, 3.78461421e-01f, -2.15778112e-01f, 1.04175031e-01f, -9.67746004e-02f,
  -1.54866219e-01f, -1.57453805e-01f, -1.85115620e-01f, -2.31782600e-01f, 7.30334148e-02f, -4.89513017e-02f, 1.03829138e-01f, -4.38102819e-02f, 2.21154004e-01f, -1.34226382e-01f,
  1.97354883e-01f, -9.21877548e-02f, 8.26804340e-02f, -7.64489397e-02f, -1.61823794e-01f, 2.68240929e-01f, 4.15057875e-02f, 1.56138048e-01f, 2.51307815e-01f, -6.62883222e-02f,
  -5.93929589e-02f, -1.00717498e-02f, 6.37851283e-02f, -4.09971513e-02f, 4.05632704e-03f, -7.29366988e-02f, 1.04393914e-01f, 1.37127057e-01f, -6.06295466e-02f, -1.52205333e-01f,
  1.14862092e-01f, 1.38867702e-02f, 6.04844503e-02f, -8.33395720e-02f, 4.20977697e-02f, 2.50198934e-02f, -7.27117956e-02f, 1.52600840e-01f, -2.07471997e-02f, 4.95402217e-02f,
  -6.10041758e-03f, 1.78790346e-01f, -2.97831371e-02f, 9.56723392e-02f, 7.70907030e-02f, 5.53827435e-02f, -1.23487778e-01f, -1.26226082e-01f, 1.34917479e-02f, -9.30929333e-02f,
  6.27485961e-02f, 2.08419897e-02f, 3.26101184e-02f, 1.49669096e-01f, 5.51500916e-02f, 1.30725414e-01f, 9.57353879e-03f, 5.11277877e-02f, 1.13235591e-02f, 9.34572294e-02f,
  1.71531990e-01f, 1.23007014e-01f, -2.08652079e-01f, 3.50309424e-02f, 9.49884728e-02f, 1.64441932e-02f, 6.40965402e-02f, 8.65356177e-02f, 1.96821243e-02f, 4.09484878e-02f,
  1.00768685e-01f, 2.78123319e-01f, 1.12923674e-01f, 4.33473475e-03f, 2.82071620e-01f, 1.01516940e-01f, -9.39932913e-02f, 1.02100350e-01f, 2.62989491e-01f, 2.09254995e-01f,
  -1.15252085e-01f, -2.96563469e-02f, -9.81652960e-02f, 2.96527565e-01f, 2.42306054e-01f, -1.79518729e-01f, -2.15151891e-01f, -1.16825186e-01f, -2.30335221e-02f, -2.45658219e-01f,
  -2.91745782e-01f, -2.94145755e-02f, -2.41873488e-01f, 2.32208073e-01f, 7.84442127e-02f, 1.27412498e-01f, -3.08754474e-01f, 1.10424936e-01f, -1.21725038e-01f, -1.21923409e-01f,
  -2.86941737e-01f, -1.58362314e-02f, -8.47946629e-02f, 1.59183994e-01f, -1.58279553e-01f, 4.27268259e-02f, 1.36437982e-01f, -8.55189487e-02f, 1.39744803e-01f, -4.20984998e-03f,
  2.78457850e-01f, 2.66794078e-02f, 5.78694902e-02f, -2.65487224e-01f, 1.60043966e-02f, 2.82237172e-01f, 2.74456710e-01f, 1.97003156e-01f, -6.82306513e-02f, 2.78385222e-01f,
  -3.58116589e-02f, -1.62244633e-01f, 1.95235148e-01f, 1.60843983e-01f, -1.30495802e-01f, 6.03288412e-02f, 1.67596340e-01f, 2.12357454e-02f, 1.69498652e-01f, 1.81346852e-02f,
  7.61660710e-02f, 1.81722596e-01f, 1.10286772e-01f, -4.38790858e-01f, 3.25871296e-02f, -1.17630586e-01f, 2.78536677e-01f, 2.23596301e-02f, 1.06670242e-02f, 8.89476240e-02f,
  9.13171992e-02f, 9.52469781e-02f, -1.08489871e-01f, 4.05824959e-01f, 2.85879225e-01f, -1.16445022e-02f, -2.57768780e-02f, 8.82911086e-02f, 1.55999750e-01f, 1.30285218e-01f,
  -7.31818154e-02f, 1.43856406e-01f, -3.40772346e-02f, 2.52250820e-01f, 4.62768376e-02f, 1.74998119e-01f, 8.16778541e-02f, 3.15423787e-01f, 1.49450034e-01f, -3.26626636e-02f,
  -3.12330248e-03f, 1.03099100e-01f, 5.15314080e-02f, 1.32075831e-01f, 1.42707735e-01f, 2.58714836e-02f, 6.71343803e-02f, 8.65491852e-02f, 8.81896242e-02f, 1.59047961e-01f,
  9.26351696e-02f, 1.00054629e-01f, 2.17854045e-02f, 3.40994298e-02f, 1.31025687e-01f, -1.33065116e-02f, 1.94787651e-01f, 1.96064681e-01f, 2.53196936e-02f, 1.93746723e-02f,
  1.22403249e-01f, 9.54449642e-03f, 5.92428893e-02f, 2.15122988e-03f, 2.68288225e-01f, -3.86554636e-02f, 3.47426608e-02f, 1.87473893e-01f, -6.26906455e-02f, -1.64820962e-02f,
  2.11483389e-01f, 1.97862964e-02f, 5.26697971e-02f, -1.79311782e-02f, -1.97445806e-02f, 1.47962615e-01f, -1.50700510e-01f, 4.69169468e-02f, 1.90842211e-01f, -8.47183764e-02f,
  1.40298083e-01f, 2.37257168e-01f, 6.12351038e-02f, 7.21388310e-02f, -6.41451124e-03f, 2.97250301e-02f, 4.11933335e-03f, -3.85669708e-01f, -1.76743880e-01f, -5.08059468e-03f,
  1.09832704e-01f, -1.44533038e-01f, -2.63803780e-01f, 1.76613659e-01f, -1.67218342e-01f, -2.20294997e-01f, -1.17382584e-02f, 1.18639827e-01f, 1.10873036e-01f, -1.02820680e-01f,
  2.67747253e-01f, 1.95084274e-01f, -3.40441689e-02f, -3.32762450e-02f, 2.06715286e-01f, 3.42367679e-01f, -1.38316274e-01f, 2.06048384e-01f, 8.94214064e-02f, -2.57343560e-01f,
  -3.32973123e-01f, -1.43359542e-01f, 3.33117545e-01f, 3.34263325e-01f, -1.94743514e-01f, 7.60485902e-02f, -1.33661553e-01f, -2.09075306e-02f, 1.86956882e-01f, 2.49213655e-03f,
  -1.11690745e-01f, 1.42888114e-01f, 9.47239473e-02f, -1.33169785e-01f, -1.63584605e-01f, 2.37892449e-01f, 2.30138823e-01f, -3.01484138e-01f, 2.23773986e-01f, 1.79899223e-02f,
  9.39792022e-02f, 2.04664275e-01f, 4.83441174e-01f, -1.88334897e-01f, 1.31994069e-01f, 8.76163542e-02f, -8.45428631e-02f, 1.44538833e-02f, -1.57146975e-01f, -1.30049750e-01f,
  4.32339981e-02f, 8.38008076e-02f, 1.78619683e-01f, -5.90966567e-02f, 2.38164261e-01f, 7.93767422e-02f, 2.82221824e-01f, 2.47847643e-02f, 7.78650567e-02f, 2.64572240e-02f,
  -1.80166978e-02f, 1.29469186e-01f, 4.58707325e-02f, 3.05439800e-01f, 2.59987622e-01f, 2.29844287e-01f, 4.57280461e-04f, 1.37951195e-01f, 6.48703799e-02f, 6.14047088e-02f,
  6.27506105e-03f, 1.13734476e-01f, 1.84205592e-01f, 1.09481446e-01f, -3.20509113e-02f, -6.91062361e-02f, 4.24074903e-02f, 6.26098514e-02f, 8.83462280e-02f, -1.62027273e-02f,
  1.27518997e-01f, 3.61879990e-02f, 4.02678177e-02f, 5.21466695e-02f, 1.23893969e-01f, 1.26003712e-01f, 1.72835037e-01f, 2.30971545e-01f, 1.41204953e-01f, 2.04159513e-01f,
  1.16639957e-01f, 1.81263179e-01f, 1.59265235e-01f, 6.29231427e-03f, 1.83424503e-01f, 1.85674150e-02f, -3.21873091e-02f, 1.34053931e-01f, 4.49976400e-02f, 1.71025693e-01f,
  -2.46657450e-02f, 1.15831062e-01f, 4.26851213e-02f, 1.02049269e-01f, 3.26726884e-02f, 2.67057363e-02f, 2.38663658e-01f, 1.30108878e-01f, -1.14865460e-01f, 1.02771716e-02f,
  1.16205230e-01f, 1.90463096e-01f, 1.67303115e-01f, 1.07495688e-01f, 5.82337379e-02f, -4.40414771e-02f, 1.05157748e-01f, -1.93666428e-01f, -1.03402540e-01f, -1.04435682e-01f,
  -5.37828170e-02f, -1.46216005e-01f, -7.15448335e-02f, -4.28945757e-03f, 2.99439907e-01f, 1.54248849e-01f, 2.72698730e-01f, -9.15677398e-02f, -2.32938692e-01f, 3.91503274e-01f,
  2.20737875e-01f, -8.47376138e-02f, -1.01792002e-02f, 1.38750210e-01f, 8.68424699e-02f, -2.27878615e-01f, -5.80945984e-02f, -1.95239693e-01f, -3.49548087e-02f, 6.04443401e-02f,
  -6.85059652e-02f, 1.51955441e-01f, -8.02919567e-02f, -9.60591659e-02f, -6.73198253e-02f, -3.79362166e-01f, -1.24925092e-01f, 1.16932794e-01f, 2.79158831e-01f, 1.14523478e-01f,
  -3.17697704e-01f, -2.15533540e-01f, 7.07753003e-02f, 5.62843084e-02f, -2.63308734e-01f, 1.10453099e-01f, -5.97237274e-02f, -1.34417087e-01f, 8.90154317e-02f, -1.97491124e-02f,
  -2.84278244e-01f, 7.70122483e-02f, 2.09343553e-01f, 2.49913894e-02f, -5.19384556e-02f, 8.74448717e-02f, 1.60988182e-01f, -1.62499025e-01f, -2.29004934e-01f, 1.64630488e-01f,
  -3.27831119e-01f, 1.19104050e-01f, -2.94143707e-01f, -1.23177752e-01f, 3.21305811e-01f, 4.80661452e-01f, 1.67673185e-01f, 2.77374834e-01f, -9.31538194e-02f, -2.04990640e-01f,
  1.78613186e-01f, 1.39756903e-01f, -6.86431602e-02f, -2.27000844e-02f, -3.90325598e-02f, 4.23260272e-01f, 2.91433632e-01f, 1.08678676e-01f, -8.74306634e-03f, 1.74459979e-01f,
  1.01379283e-01f, -8.92828777e-02f, -4.73722406e-02f, 3.25338095e-01f, -5.74222207e-02f, 1.06565274e-01f, 1.68540537e-01f, 9.67359617e-02f, 7.01228231e-02f, 4.98185260e-03f,
  1.00663818e-01f, 3.37010697e-02f, -6.57919347e-02f, -2.39943769e-02f, 2.01206859e-02f, 1.56317338e-01f, 6.17081784e-02f, 1.21112920e-01f, 1.97789334e-02f, 1.52364336e-02f,
  1.59491763e-01f, 6.46990091e-02f, -4.90928479e-02f, -1.02893835e-04f, 1.54760678e-03f, 1.34204580e-02f, 6.50418699e-02f, 3.06916386e-02f, 1.59658954e-01f, -3.00408658e-02f,
  1.66429818e-01f, 2.06834346e-01f, 1.72916636e-01f, 2.13526487e-02f, 9.62079465e-02f, 1.06998142e-02f, 1.53068220e-02f, 1.28707737e-01f, 6.96590990e-02f, 1.69541597e-01f,
  8.45096335e-02f, 1.02827556e-01f, -4.52676462e-03f, 6.80496618e-02f, -9.19971429e-03f, 1.17243342e-01f, 1.51659533e-01f, 9.91769210e-02f, 8.48186538e-02f, 9.63840783e-02f,
  4.43574376e-02f, 4.63247895e-02f, 2.08433360e-01f, 1.26212940e-01f, 8.56272951e-02f, -2.61274576e-01f, -1.56327337e-01f, -8.48965570e-02f, -3.01665187e-01f, -8.57461616e-02f,
  9.87307057e-02f, -9.23169628e-02f, -1.29197940e-01f, -7.43140802e-02f, 1.29349679e-01f, -2.37416729e-01f, -3.72419618e-02f, 9.13274754e-03f, 9.49830487e-02f, 1.62157997e-01f,
  2.21903488e-01f, 2.52649903e-01f, 1.63960345e-02f, -3.83951440e-02f, 2.10940987e-01f, -1.09601557e-01f, -4.99326885e-02f, -1.54329836e-01f, 1.49754271e-01f, -2.56074637e-01f,
  1.27558708e-01f, -2.51745582e-01f, 1.24966629e-01f, -1.49809733e-01f, 2.73512322e-02f, 2.69302875e-02f, -7.51874596e-02f, -1.22784346e-01f, 2.30722100e-01f, -3.78415793e-01f,
  -2.60298789e-01f, -2.92024553e-01f, -5.54641634e-02f, 9.31021050e-02f, -2.58527368e-01f, 1.35968864e-01f, 2.20652983e-01f, 1.64727971e-01f, 7.52470717e-02f, -1.09733073e-02f,
  -2.69600391e-01f, -1.42506316e-01f, -1.51073307e-01f, 9.28663742e-03f, -2.04924587e-03f, 2.04947144e-01f, -3.64151709e-02f, -3.10077164e-02f, -7.13339949e-04f, 1.85393259e-01f,
  -7.82349184e-02f, 2.84382135e-01f, -1.76133990e-01f, -1.03403768e-02f, 2.07779080e-01f, 1.43906265e-01f, 2.01906309e-01f, 2.29021981e-01f, 8.45149998e-03f, 5.91789894e-02f,
  -2.56152600e-01f, 3.59331936e-01f, 2.25784481e-01f, -5.56482412e-02f, 2.52383202e-01f, 1.99181825e-01f, 2.68582791e-01f, -1.40078515e-01f, 1.31745800e-01f, 2.25314051e-01f,
  6.10039383e-02f, -1.64529786e-01f, 2.22052068e-01f, 6.90767169e-02f, 2.14608721e-02f, 1.29486963e-01f, 1.33716717e-01f, 1.13220595e-01f, 2.33072042e-01f, 8.94117057e-02f,
  3.95771563e-02f, 1.00252338e-01f, 1.79428786e-01f, 9.62755531e-02f, -4.52822708e-02f, -7.77530205e-03f, 1.80959210e-01f, 4.52910289e-02f, 4.71030697e-02f, 2.73468941e-02f,
  7.30634630e-02f, 4.03068289e-02f, 1.45203909e-02f, 1.01931527e-01f, 1.26573846e-01f, 4.57998067e-02f, 1.03013873e-01f, 3.84802558e-03f, -6.01046532e-02f, 8.75464827e-02f,
  1.10199705e-01f, -1.63541257e-03f, -9.38017517e-02f, 1.73074394e-01f, 1.39508620e-01f, -1.44057581e-02f, -1.61030501e-01f, 6.59421235e-02f, 1.08329013e-01f, -3.12691666e-02f,
  3.34438868e-02f, -6.12839945e-02f, 3.17915156e-02f, 5.20888828e-02f, 2.90334914e-02f, 8.92214179e-02f, 3.32893208e-02f, 1.90406162e-02f, 1.07308961e-01f, 9.74655002e-02f,
  -3.11155524e-02f, -7.54282922e-02f, 1.37782961e-01f, -2.31592909e-01f, -1.16572402e-01f, -1.64313882e-03f, -9.88193005e-02f, -1.71672821e-01f, 2.19062090e-01f, 1.29742175e-01f,
  2.42454395e-01f, 1.11826561e-01f, 2.93513924e-01f, 2.34033056e-02f, -2.80296862e-01f, 1.32981032e-01f, 6.51298538e-02f, 3.21648642e-02f, 1.16122834e-01f, 3.27285007e-02f,
  2.87328064e-01f, -6.12598360e-02f, 1.92487255e-01f, -2.73323417e-01f, 2.00085133e-01f, -3.28315282e-03f, -2.00894386e-01f, -1.49791632e-02f, -3.82626243e-02f, -1.89177338e-02f,
  -5.78600168e-02f, -2.09535539e-01f, 1.94319949e-01f, -1.19263701e-01f, 2.30560482e-01f, 5.16676763e-03f, -3.57322544e-01f, 2.22462285e-02f, -9.58138257e-02f, -1.23101383e-01f,
  -1.95064187e-01f, 2.82142252e-01f, -7.47206956e-02f, -1.01154767e-01f, -2.05523342e-01f, 1.53791532e-01f, -1.79586902e-01f, -1.45435795e-01f, -8.81898403e-02f, 1.51945129e-01f,
  8.27645287e-02f, -2.33632117e-03f, 2.54485935e-01f, 3.95732746e-02f, 7.75713399e-02f, 9.61779132e-02f, -4.31369022e-02f, -4.62011173e-02f, -7.58574381e-02f, -5.65789156e-02f,
  3.62946451e-01f, 2.72233605e-01f, -1.50923982e-01f, 9.39936936e-02f, -1.67087942e-01f, -2.76203752e-01f, 1.07305408e-01f, 4.65247668e-02f, -7.91670680e-02f, 1.54949874e-01f,
  -8.69118720e-02f, 2.93449759e-01f, -7.15109035e-02f, -1.98073402e-01f, 1.40430391e-01f, 7.68651292e-02f, -2.99502350e-02f, -2.18303546e-01f, -9.22661573e-02f, 3.37039977e-01f,
  3.22437733e-02f, 2.15802088e-01f, 2.64686584e-01f, 1.74012348e-01f, -8.43456388e-02f, 2.96243355e-02f, 7.30498880e-02f, 7.89753124e-02f, 1.93405628e-01f, 1.97114404e-02f,
  1.42079175e-01f, 1.36908174e-01f, 9.34831947e-02f, 2.33452301e-02f, 1.48881227e-01f, 1.68525755e-01f, 1.03747271e-01f, 1.47870213e-01f, 1.78827811e-03f, 2.87863314e-02f,
  4.85754162e-02f, 2.29430854e-01f, 2.66738255e-02f, 1.22806698e-01f, 8.30544606e-02f, 2.55852968e-01f, 2.05264553e-01f, 2.14483678e-01f, 9.95529443e-03f, 1.60038874e-01f,
  1.45745873e-01f, 1.22237332e-01f, 1.02826782e-01f, 1.32637890e-02f, 2.07917958e-01f, 1.38978213e-01f, 2.61190861e-01f, 9.13275257e-02f, 1.03107922e-01f, 1.01582468e-01f,
  3.96614112e-02f, 1.16323270e-01f, 8.16097856e-02f, 8.68888125e-02f, 8.21044296e-02f, 1.96607023e-01f, 8.19812417e-02f, 1.37981310e-01f, 9.55674201e-02f, 1.57938853e-01f,
  8.62043798e-02f, -1.23628832e-01f, -4.27422710e-02f, -4.49890224e-03f, 2.57995576e-01f, 3.11158597e-01f, -3.98108810e-01f, 1.05784554e-02f, -2.49621719e-01f, -8.01655129e-02f,
  -2.57037342e-01f, -9.95760188e-02f, 1.99836805e-01f, 6.42630784e-03f, -8.68922248e-02f, 1.14366546e-01f, -1.93082154e-01f, -1.47725239e-01f, -9.46372598e-02f, -4.03378159e-01f,
  -2.93772072e-01f, 9.94540155e-02f, -1.11077763e-02f, 2.54142314e-01f, -6.34166226e-02f, 3.46729875e-01f, 1.92404553e-01f, 1.33324265e-01f, 1.09375954e-01f, 1.95278704e-01f,
  -2.46167615e-01f, -2.65942980e-02f, -2.67610043e-01f, -1.30531371e-01f, 3.04433465e-01f, 1.34262547e-01f, 1.37628317e-01f, 1.24509469e-01f, -5.07906340e-02f, -2.08326116e-01f,
  2.30608970e-01f, -1.02836363e-01f, 2.87632853e-01f, -1.88226253e-01f, 7.43197128e-02f, 3.17414373e-01f, 1.56931311e-01f, 1.30266873e-02f, 2.62494534e-02f, 2.08521381e-01f,
  -1.22598946e-01f, -2.71829814e-01f, 1.15422793e-01f, -1.36497408e-01f, -1.49363115e-01f, -2.96171337e-01f, -6.46038773e-03f, -1.73108235e-01f, -2.07955137e-01f, 8.27306882e-02f,
  -2.75081873e-01f, -2.70333707e-01f, 9.88533869e-02f, 9.59741399e-02f, 4.17423040e-01f, -1.87986076e-01f, 2.97022372e-01f, -1.00886554e-01f, 6.24900423e-02f, 1.34424105e-01f,
  2.81452000e-01f, -1.66818351e-01f, -1.71219602e-01f, 1.60806194e-01f, 2.48323247e-01f, 3.47385287e-01f, 2.42677376e-01f, -8.32808167e-02f, 1.78568110e-01f, 2.61642724e-01f,
  1.33995384e-01f, 2.01062292e-01f, 7.23928586e-02f, -9.10023507e-03f, 2.38293171e-01f, 9.16930735e-02f, 9.27917659e-03f, -8.07065815e-02f, 1.55719921e-01f, 1.99564174e-01f,
  1.68595269e-01f, 1.84174284e-01f, 2.53566653e-01f, 2.17913508e-01f, 1.95195392e-01f, 7.18214959e-02f, 1.61399722e-01f, 1.62011221e-01f, 1.63583696e-01f, 1.30407572e-01f,
  2.09533051e-01f, 1.62971675e-01f, 2.83918381e-01f, 3.90984327e-01f, 2.85260797e-01f, 8.79354179e-02f, 1.30141780e-01f, 1.61235750e-01f, 5.48727177e-02f, 1.80533871e-01f,
  1.32143691e-01f, 1.54311299e-01f, 2.63048634e-02f, 2.42996648e-01f, 2.11588144e-01f, 4.62282151e-02f, -3.67616899e-02f, 1.47162855e-01f, 2.00320214e-01f, 7.87459761e-02f,
  -5.52742966e-02f, 2.23863497e-01f, 1.05503239e-01f, 2.37364963e-01f, 2.29084492e-01f, 1.97663456e-01f, 1.13171153e-01f, 8.18990842e-02f, 2.41684511e-01f, -1.82530656e-01f,
  -1.02825522e-01f, -6.70564175e-02f, 1.04830235e-01f, -1.56811923e-01f, -1.85461760e-01f, -5.95534742e-02f, -3.71619277e-02f, 2.18319103e-01f, -1.96669139e-02f, 2.37199292e-01f,
  -1.30261436e-01f, 2.04087898e-01f, 8.17947611e-02f, 1.87393166e-02f, 3.02308612e-02f, -1.19601049e-01f, 1.72805786e-01f, -3.20683002e-01f, -3.04057840e-02f, -2.85332233e-01f,
  -4.04912755e-02f, -1.04297541e-01f, -2.82963902e-01f, 1.96909136e-03f, -6.21663630e-02f, -8.37178901e-03f, 1.06618583e-01f, -1.28337637e-01f, -1.77545339e-01f, 1.66814685e-01f,
  2.04102606e-01f, 1.43648624e-01f, -1.74036846e-01f, 3.33446115e-02f, 1.53950915e-01f, 1.36673108e-01f, -1.29033439e-02f, 1.66989520e-01f, 5.34164011e-02f, -2.70215958e-01f,
  1.97244868e-01f, -1.05494954e-01f, -3.05217803e-01f, 5.42842038e-02f, 1.96193978e-01f, 4.77902479e-02f, 1.11348033e-01f, 8.52598995e-02f, -3.87939587e-02f, -2.97896862e-01f,
  -1.66869551e-01f, -1.29593760e-01f, -2.13963494e-01f, 8.49548802e-02f, -3.23419482e-01f, -7.94426948e-02f, 2.25684553e-01f, 4.18579966e-01f, -2.96168197e-02f, 1.89559355e-01f,
  -7.15510249e-02f, 1.39678970e-01f, 2.86444813e-01f, 1.45519719e-01f, 9.24345199e-03f, -2.03500167e-01f, -1.88900560e-01f, 4.52947915e-01f, 2.08556250e-01f, -2.23513901e-01f,
  -1.15629606e-01f, -2.24674284e-01f, 6.93814829e-02f, -1.53796256e-01f, 2.06358492e-01f, 2.86533833e-01f, 1.69351161e-01f, -7.54086003e-02f, -1.87220186e-01f, 7.58594871e-02f,
  1.56019023e-02f, 2.49753624e-01f, 2.06314623e-01f, 8.53259712e-02f, 1.34673133e-01f, 1.53550029e-01f, -3.17425793e-03f, -6.61200806e-02f, 1.02170408e-01f, 2.62790732e-02f,
  9.34973806e-02f, -2.69586425e-02f, 2.80923378e-02f, 1.27138391e-01f, 5.48293740e-02f, 4.32071984e-02f, 1.09074317e-01f, 5.77265583e-02f, 1.06614828e-01f, 3.44256088e-02f,
  -7.25776404e-02f, -1.80121232e-03f, 1.27035215e-01f, -6.32292554e-02f, 1.39569983e-01f, 1.13139339e-01f, 5.60643747e-02f, -5.79270087e-02f, 4.64265831e-02f, -9.57594160e-03f,
  -1.21468818e-02f, -1.05942331e-01f, 1.45438924e-01f, -8.33405256e-02f, 1.41664855e-02f, 8.47907737e-02f, 1.28822803e-01f, 2.60885730e-02f, 2.65449017e-01f, 2.18140800e-02f,
  6.26311302e-02f, -9.29891318e-02f, 1.46489851e-02f, 2.40240097e-02f, -1.89233944e-01f, 8.08463525e-03f, 1.81304321e-01f, 1.91030145e-01f, 2.34052420e-01f, 2.02597231e-01f,
  -8.40451717e-02f, -2.18336940e-01f, 5.24696074e-02f, 1.64898813e-01f, 1.98081106e-01f, -2.83286899e-01f, 9.98076722e-02f, 1.29787639e-01f, -2.18539357e-01f, 1.30562976e-01f,
  -2.32356533e-01f, -8.63356292e-02f, -3.06485653e-01f, -1.82734758e-01f, -3.88419069e-02f, 2.09410310e-01f, 1.30074427e-01f, -5.61917052e-02f, -9.97184366e-02f, -5.18838726e-02f,
  6.16058670e-02f, -9.89820659e-02f, 2.33906761e-01f, 2.16488987e-01f, -2.64014751e-01f, 1.50840506e-01f, 7.16449469e-02f, -3.03493977e-01f, -1.61919162e-01f, 9.92970914e-02f,
  -1.23411067e-01f, 2.08607778e-01f, -1.36572629e-01f, 2.06899360e-01f, -1.98020533e-01f, 1.01003006e-01f, 1.47042304e-01f, 3.26820984e-02f, -2.71872967e-01f, 8.37769266e-03f,
  -6.65865615e-02f, -1.80502966e-01f, -1.71600923e-01f, 1.82730094e-01f, 2.28535712e-01f, -2.99394816e-01f, 3.10934395e-01f, -6.32808581e-02f, -2.23065734e-01f, 3.11698884e-01f,
  4.69473094e-01f, 1.36267424e-01f, 1.31492808e-01f, 9.53041092e-02f, 2.62999266e-01f, 2.75313586e-01f, 2.28692725e-01f, -2.83565912e-02f, -1.07539058e-01f, -4.21692468e-02f,
  -3.05750668e-01f, 1.66625217e-01f, 3.79323065e-02f, 1.72127914e-02f, 2.25390092e-01f, 5.77081041e-03f, -7.49610597e-03f, 4.05611768e-02f, -5.66975388e-04f, 1.28214061e-01f,
  1.14001855e-01f, 2.10257977e-01f, -2.01740205e-01f, 2.17998669e-01f, 1.10889755e-01f, 1.63047329e-01f, 2.77900785e-01f, 8.41582119e-02f, 2.09227130e-01f, 1.02502368e-01f,
  -2.93012951e-02f, -6.21543191e-02f, 3.38886231e-02f, 5.04031405e-02f, 1.35061378e-02f, 2.39727527e-01f, 1.17909923e-01f, 1.74625903e-01f, -2.62624137e-02f, 5.80110550e-02f,
  1.85065836e-01f, 2.21360818e-01f, 2.40802881e-03f, 1.86900407e-01f, 1.81949884e-01f, 9.96440724e-02f, 2.08593115e-01f, 1.24241412e-01f, -1.10920705e-02f, 1.61491707e-01f,
  6.81956038e-02f, 2.56634206e-01f, 1.37948036e-01f, 1.07579447e-01f, 1.54002145e-01f, 1.70849428e-01f, 7.08264783e-02f, 3.61102372e-02f, 1.30203262e-01f, 9.53978151e-02f,
  8.20444822e-02f, 2.47417882e-01f, 2.28597000e-01f, 3.25901248e-02f, -3.94517556e-02f, 7.70203769e-02f, 1.01934284e-01f, 1.21091336e-01f, 1.00722916e-01f, 1.01327211e-01f,
  3.95528972e-02f, -6.21549748e-02f, 1.31086648e-01f, 1.50212646e-01f, 4.34114188e-02f, -1.22766592e-01f, -1.33852601e-01f, 5.86229153e-02f, -2.11760566e-01f, 3.19133580e-01f,
  -1.90728381e-01f, -7.20406100e-02f, -3.31635267e-01f, -3.76806557e-02f, -1.37897149e-01f, -2.06309929e-01f, 1.65535778e-01f, -2.45272011e-01f, 1.36610687e-01f, 4.58394177e-02f,
  1.57642573e-01f, 1.12239674e-01f, -1.78336740e-01f, -1.11798719e-01f, -2.58028001e-01f, 2.84623116e-01f, -2.10024193e-01f, -6.02014409e-03f, 2.28422731e-01f, -1.35654569e-01f,
  1.97781250e-01f, 4.83352616e-02f, -4.36295494e-02f, -1.47859221e-02f, -3.44241448e-02f, -2.32206434e-02f, -1.37143865e-01f, -1.54532984e-01f, 1.84004247e-01f, -1.04683824e-01f,
  -8.54384229e-02f, 6.74172863e-02f, -6.38341755e-02f, -1.84544593e-01f, -1.50322765e-01f, 2.54518121e-01f, 1.58312127e-01f, -1.37742041e-02f, 2.04968899e-01f, 2.72311956e-01f,
  2.30072718e-02f, -2.59803921e-01f, -1.69855118e-01f, -2.30606467e-01f, -2.45452613e-01f, -9.78697091e-02f, -6.12235107e-02f, -2.06154473e-02f, 2.03082319e-02f, 2.46130005e-01f,
  1.53505564e-01f, 2.31404796e-01f, -3.33310723e-01f, -1.77117154e-01f, 1.93577588e-01f, 1.06990889e-01f, 1.95415363e-01f, 3.59007508e-01f, 8.61801431e-02f, 1.43456414e-01f,
  -1.67122349e-01f, 1.51977733e-01f, -4.15807553e-02f, -1.84260026e-01f, 3.59806597e-01f, 2.08330452e-01f, 6.26081303e-02f, -2.58334130e-01f, 2.14777455e-01f, 2.21481159e-01f,
  1.89115584e-01f, -1.98757485e-01f, 1.71615809e-01f, 5.81114739e-02f, 9.05554816e-02f, 7.12254643e-02f, -6.63736761e-02f, 1.13454536e-01f, 5.66604584e-02f, 1.07598022e-01f,
  4.79268841e-02f, 1.60664171e-01f, 1.46512493e-01f, 9.55609903e-02f, -8.72388333e-02f, 1.22117989e-01f, 1.15801968e-01f, 1.91199761e-02f, -3.36605757e-02f, 5.48668243e-02f,
  1.95906997e-01f, 6.38856143e-02f, -5.46181276e-02f, 4.66868132e-02f, 1.47373490e-02f, 9.00511816e-02f, 7.93097466e-02f, 1.45109758e-01f, -5.45923710e-02f, 2.03088429e-02f,
  8.64621475e-02f, 1.42480224e-01f, -7.58715048e-02f, 7.59657025e-02f, -1.22903436e-02f, 1.96039062e-02f, 6.67598993e-02f, 2.12228343e-01f, 1.05756544e-01f, -1.52675956e-01f,
  1.86286196e-02f, 1.01404421e-01f, 5.34172952e-02f, 7.20254332e-02f, 2.19699964e-01f, 1.20929703e-01f, 3.74841504e-02f, 8.32332447e-02f, -3.51523161e-02f, 9.45606679e-02f,
  -7.18044937e-02f, -2.66081709e-02f, 1.89107299e-01f, 1.71727315e-01f, -4.91860509e-02f, -1.32906660e-01f, 2.05330327e-01f, -2.14356020e-01f, 2.11191863e-01f, -1.53713450e-01f,
  1.00986354e-01f, -4.96395417e-02f, -1.05707690e-01f, 9.70473588e-02f, -5.47702946e-02f, -1.19810998e-01f, -2.61479288e-01f, -6.29133433e-02f, -7.12757856e-02f, -6.28408715e-02f,
  2.40766793e-01f, -3.22781201e-03f, 1.18856907e-01f, -1.33095637e-01f, -4.97013107e-02f, 1.45157069e-01f, -2.42189109e-01f, -2.64421403e-01f, -2.49384925e-01f, -6.20726794e-02f,
  2.87817359e-01f, 2.69702464e-01f, 4.25277576e-02f, 2.67566647e-02f, 1.12636343e-01f, 2.46085376e-01f, 1.66488141e-02f, 1.85222253e-01f, -2.33087108e-01f, 1.05283000e-01f,
  6.56847358e-02f, 2.40053967e-01f, 4.04105037e-02f, -2.12698668e-01f, -8.07086453e-02f, -1.26781398e-02f, -1.52907997e-01f, -9.96650532e-02f, 2.30076164e-01f, 2.21367627e-01f,
  1.88683361e-01f, 1.96632162e-01f, 2.09622115e-01f, 6.34231418e-03f, 3.93994659e-01f, 1.73668414e-02f, -6.83433712e-02f, 3.38758022e-01f, -1.35746732e-01f, 3.88846993e-02f,
  2.19205230e-01f, 2.88517267e-01f, 3.00956279e-01f, 1.02218695e-01f, 5.60614280e-02f, -1.04971886e-01f, 1.46105200e-01f, 1.10069446e-01f, 2.59150058e-01f, -2.09310919e-01f,
  -1.11956364e-02f, 2.32487381e-01f, 1.34112477e-01f, -2.47206558e-02f, -9.83662531e-02f, 1.61627606e-01f, 2.19375819e-01f, -9.05507877e-02f, -2.09580176e-03f, 2.57935911e-01f,
  1.20657437e-01f, 5.06530106e-02f, 1.09255210e-01f, 1.33513436e-01f, 8.83520097e-02f, -1.33985588e-02f, 2.25506648e-01f, 5.17890528e-02f, 2.23850548e-01f, 8.36462229e-02f,
  5.65283149e-02f, 2.10277036e-01f, 2.28599697e-01f, 1.97760701e-01f, 1.50448143e-01f, 7.16675445e-02f, 1.00545995e-01f, 2.47578248e-01f, 1.37482524e-01f, 1.81674570e-01f,
  1.64744124e-01f, 1.86547920e-01f, 3.46519463e-02f, 6.44819513e-02f, 1.56096995e-01f, 5.58240749e-02f, 3.50208692e-02f, 2.37842605e-01f, 4.87579629e-02f, 1.16263155e-03f,
  2.11304501e-01f, 1.76813439e-01f, 1.15314305e-01f, 1.33048683e-01f, 3.33753675e-02f, 3.79326418e-02f, 1.04524083e-01f, 2.47783974e-01f, 2.49821976e-01f, 1.59604549e-01f,
  3.17127965e-02f, 1.76225364e-01f, 1.49799198e-01f, -3.07633802e-02f, 2.23089322e-01f, 1.58921480e-01f, 1.32272840e-01f, 1.85635746e-01f, 1.42685235e-01f, 1.03433266e-01f,
  -3.28521170e-02f, -2.05105469e-01f, -9.95440185e-02f, 2.58179177e-02f, -9.07140672e-02f, 9.58580002e-02f, 1.36409178e-01f, -4.44711000e-02f, -1.26046523e-01f, -2.06466317e-02f,
  8.60312283e-02f, -1.76926002e-01f, 1.86176181e-01f, -1.38231695e-01f, 2.10103337e-02f, 2.71827281e-01f, 1.67217419e-01f, 2.44060643e-02f, 5.36939278e-02f, 1.86991975e-01f,
  4.97296825e-02f, 8.52074027e-02f, 2.41583690e-01f, -1.78935662e-01f, -4.53816876e-02f, -1.02432050e-01f, -9.23353434e-02f, -8.52360278e-02f, 1.87058762e-01f, -2.20572293e-01f,
  2.05470562e-01f, 6.18568882e-02f, -9.30086374e-02f, -2.99236834e-01f, 1.44430771e-01f, -1.33506820e-01f, -4.25004512e-02f, -2.77612329e-01f, 1.73595026e-01f, -1.76878572e-01f,
  -1.56505719e-01f, 2.49976546e-01f, -1.22125065e-02f, 2.16971666e-01f, 2.31910169e-01f, -1.39627054e-01f, -1.84507892e-01f, -5.37005700e-02f, -1.59996599e-01f, -4.33511846e-02f,
  -8.77299085e-02f, 2.14516371e-01f, 1.18878096e-01f, 9.70600843e-02f, 1.50374606e-01f, -2.49440834e-01f, 3.21881473e-01f, 3.25982496e-02f, -2.41758991e-02f, -2.55857795e-01f,
  -2.52652228e-01f, -1.07189789e-01f, 3.29948902e-01f, 1.89960644e-01f, 1.43272395e-03f, -2.16851071e-01f, -2.67211199e-02f, 2.88149267e-01f, 2.44217336e-01f, -3.06695141e-02f,
  -1.06211036e-01f, -9.29218233e-02f, 2.70249337e-01f, -9.46485773e-02f, -1.89256191e-01f, 2.95924813e-01f, 2.00552896e-01f, -6.87124357e-02f, 3.75108868e-02f, 1.03084296e-01f,
  3.67750414e-02f, 1.71412244e-01f, 1.04250498e-02f, 2.17268601e-01f, -3.19610052e-02f, 5.01372628e-02f, 5.00994511e-02f, 1.43701404e-01f, -3.54504101e-02f, 4.37641963e-02f,
  4.61847000e-02f, 4.67793047e-02f, -2.36305911e-02f, 7.07662255e-02f, 1.13086872e-01f, 3.13387997e-02f, 1.69086412e-01f, 2.97715273e-02f, 1.11437805e-01f, -4.33343202e-02f,
  3.62516455e-02f, 1.06777526e-01f, 8.78381059e-02f, -3.71073820e-02f, 1.29372682e-02f, 5.87507375e-02f, 3.66962962e-02f, 1.60208538e-01f, -4.05711643e-02f, -3.46688814e-02f,
  6.95387200e-02f, 4.48848456e-02f, 1.39273763e-01f, -5.21510802e-02f, 7.42790475e-02f, -1.45591825e-01f, -4.90472466e-02f, 1.07220367e-01f, -1.30719496e-02f, 4.73585054e-02f,
  2.60129035e-01f, 4.11457457e-02f, 8.79597366e-02f, 5.51329330e-02f, 8.91208500e-02f, -1.94399599e-02f, -2.47301571e-02f, 1.11526579e-01f, 2.22989410e-01f, 2.69328505e-01f,
  2.36334816e-01f, -4.62572947e-02f, -1.61126897e-01f, -1.73426330e-01f, 1.44119605e-01f, -1.57315910e-01f, 1.57852784e-01f, -1.68204308e-01f, -1.29219715e-03f, 1.87544450e-01f,
  -1.01325691e-01f, -6.49458542e-02f, -2.20175847e-01f, -2.41664067e-01f, -2.30340540e-01f, 9.60884690e-02f, -1.28381118e-01f, 3.13925445e-01f, 1.58465594e-01f, 8.58961120e-02f,
  -2.61203676e-01f, -1.34965494e-01f, 1.82875708e-01f, -7.75458887e-02f, 5.33283539e-02f, 2.54632402e-02f, -6.25637546e-02f, 2.39317015e-01f, 2.99493968e-02f, -1.94743007e-01f,
  -5.19161224e-02f, 1.75702661e-01f, -2.69506611e-02f, 2.56857872e-02f, -1.50945425e-01f, 2.90679455e-01f, -1.43385470e-01f, 8.40500370e-02f, 4.62355129e-02f, 1.21800952e-01f,
  -1.98380634e-01f, 6.28691167e-02f, -1.57224476e-01f, -1.14347957e-01f, -4.56394702e-02f, -1.57078475e-01f, 1.29632711e-01f, -1.88870251e-01f, 7.65259042e-02f, 1.46967947e-01f,
  -7.70277018e-03f, 9.97090340e-02f, 2.46624231e-01f, 3.60445410e-01f, 6.13199621e-02f, 1.81691587e-01f, -6.85498714e-02f, 7.07235485e-02f, 3.44207525e-01f, 1.41005963e-01f,
  -1.85640171e-01f, 1.14182793e-01f, -3.27358931e-01f, 3.12598258e-01f, 2.56631281e-02f, -2.37682477e-01f, -4.44100946e-02f, 5.02822213e-02f, 1.52392954e-01f, 2.43660867e-01f,
  -1.58497050e-01f, 8.44871253e-02f, 2.53405362e-01f, -7.92730376e-02f, -1.96859255e-01f, 3.04219555e-02f, 1.55134484e-01f, 2.22289234e-01f, 4.63836603e-02f, 9.09184664e-02f,
  2.06446126e-01f, 2.49361224e-03f, -7.96299353e-02f, 1.03217371e-01f, 1.15239874e-01f, 6.52673515e-03f, 1.69172883e-02f, 9.86028835e-02f, 4.59108427e-02f, 2.69872606e-01f,
  6.83566630e-02f, 9.41423252e-02f, -8.51403624e-02f, 2.84987837e-02f, 1.90916061e-01f, 1.90220922e-02f, 6.68167472e-02f, -6.63666381e-03f, -7.90924355e-02f, 8.64463672e-02f,
  3.49990278e-02f, 1.63147286e-01f, 5.25381640e-02f, 3.58102992e-02f, -2.27252729e-02f, 4.54745144e-02f, 2.10808753e-03f, 1.13836095e-01f, 3.03353034e-02f, -3.32551226e-02f,
  5.42070828e-02f, 1.89165607e-01f, 4.91451509e-02f, -4.05351743e-02f, 8.39736015e-02f, 3.94442305e-02f, 7.12739453e-02f, 7.64033571e-02f, 1.11482807e-01f, 1.11430667e-01f,
  5.81618734e-02f, 1.51216745e-01f, -4.00333218e-02f, 2.19691753e-01f, 4.82920147e-02f, -6.64145220e-04f, 9.33157504e-02f, 2.69306183e-01f, -1.09201074e-01f, -1.73204750e-01f,
  2.51535863e-01f, 2.80878693e-02f, -1.05356738e-01f, -2.42294475e-01f, -2.16407850e-01f, 1.13013424e-02f, -1.78493917e-01f, 2.53737062e-01f, 1.85933948e-01f, -3.57208341e-01f,
  -1.25408694e-01f, 1.33369029e-01f, 1.79139048e-01f, -1.13070436e-01f, 1.29572958e-01f, -2.73017641e-02f, 6.92026243e-02f, -5.14616035e-02f, 2.59728171e-02f, 5.45339398e-02f,
  -4.97066118e-02f, -2.70827293e-01f, -2.77788997e-01f, -6.11835532e-02f, 2.24031433e-01f, 3.05575281e-01f, -1.88926116e-01f, 2.02339247e-01f, 1.27933109e-02f, 1.62592545e-01f,
  1.92338526e-01f, 1.59419820e-01f, -2.29252711e-01f, 1.12951510e-01f, 2.76790202e-01f, -1.41242445e-01f, -2.55522300e-02f, -2.94633508e-01f, 1.45079046e-02f, -8.38518143e-02f,
  -8.91382322e-02f, -1.37478665e-01f, 2.08834991e-01f, 1.29821792e-01f, -1.29103392e-01f, 2.43598893e-01f, -1.17402911e-01f, -9.23329219e-02f, 3.08747053e-01f, -1.85956180e-01f,
  -2.01275080e-01f, 2.52959639e-01f, -5.00926077e-02f, -9.32330191e-02f, -2.18351170e-01f, -5.56218624e-02f, 7.29995221e-02f, 8.42216536e-02f, 2.14310259e-01f, 8.95776600e-02f,
  1.56583801e-01f, 1.48794711e-01f, 3.25659841e-01f, -1.24971338e-01f, -1.71600506e-02f, 9.60868746e-02f, 5.38619235e-02f, -2.07293928e-01f, -2.45245248e-01f, 2.20383778e-01f,
  3.23483460e-02f, -4.83673923e-02f, 1.85775012e-01f, -9.33763310e-02f, 1.96047872e-01f, 4.91026193e-02f, -3.58844846e-02f, 1.11700624e-01f, 1.75445639e-02f, 1.10444076e-01f,
  9.71120000e-02f, 8.59770924e-02f, 5.90530783e-02f, -2.34565921e-02f, 1.95072934e-01f, 1.02338061e-01f, -5.79674589e-03f, 8.90056416e-02f, 1.71448335e-01f, 1.12754285e-01f,
  1.49898743e-02f, -8.53570700e-02f, 2.30100200e-01f, -3.72606218e-02f, -2.28337944e-02f, 3.44914570e-02f, 3.00174579e-02f, 1.31173864e-01f, 9.17828754e-02f, 2.06450656e-01f,
  6.97460175e-02f, -3.77191976e-02f, 2.00746223e-01f, 5.55114634e-02f, 2.68792007e-02f, 1.33536130e-01f, 2.05706999e-01f, 1.47585245e-02f, 5.59945107e-02f, 1.53430030e-01f,
  8.18058401e-02f, -4.22051596e-03f, 2.44689696e-02f, 5.73902316e-02f, 5.08571789e-02f, 2.40655765e-02f, 1.43472165e-01f, 1.29086837e-01f, -2.88536604e-02f, 1.87386706e-01f,
  9.14556980e-02f, 1.21656224e-01f, -2.96029467e-02f, 2.08444917e-03f, 1.57429412e-01f, -2.97429919e-01f, -4.29664701e-02f, 7.74574792e-03f, 1.46629632e-01f, -2.76117265e-01f,
  6.14892356e-02f, 8.89781639e-02f, 1.26479581e-01f, -3.83230329e-01f, 1.86848626e-01f, 1.25022620e-01f, -1.06515087e-01f, 7.73199424e-02f, -1.27450660e-01f, 2.27401569e-01f,
  3.77498046e-02f, -1.32282212e-01f, 3.24088037e-01f, -1.71800330e-01f, 2.80675471e-01f, -2.91622967e-01f, 2.34354228e-01f, 1.76555589e-01f, -2.46610746e-01f, -1.45360768e-01f,
  5.20852245e-02f, 1.28462359e-01f, 2.33851686e-01f, -9.40292627e-02f, 1.32184193e-01f, -1.80711269e-01f, 1.58442825e-01f, 5.68216341e-03f, -1.63091049e-02f, -8.71392861e-02f,
  -3.12352329e-01f, -1.43740565e-01f, -1.15150824e-01f, 3.53153676e-01f, -1.82461366e-02f, -3.06818724e-01f, -2.46460408e-01f, 2.34350368e-01f, -1.83724374e-01f, -1.91048965e-01f,
  6.87088966e-02f, 2.90558934e-01f, 3.25370848e-01f, 1.63937509e-02f, 3.16752911e-01f, -9.96138379e-02f, 5.06272577e-02f, 9.80838388e-02f, 1.56169742e-01f, 1.12860827e-02f,
  -4.61489230e-01f, 1.80246204e-01f, 2.02755600e-01f, 3.41226012e-01f, 1.43473670e-01f, 1.53645664e-01f, -5.14759272e-02f, -1.68259785e-01f, 1.99291229e-01f, 7.71666765e-02f,
  1.05545200e-01f, -1.59016326e-01f, -1.63444690e-02f, 4.72682953e-01f, 3.39106858e-01f, 2.05609262e-01f, 8.22147653e-02f, 6.68895617e-03f, 1.35801500e-02f, 8.70786374e-04f,
  4.99055743e-01f, 3.46360147e-01f, 2.62603574e-02f, 8.44147056e-02f, 5.52793173e-03f, 2.07338959e-01f, 7.96015263e-02f, 2.15831921e-01f, 1.62405998e-01f, 1.88923910e-01f,
  -2.74897041e-03f, 8.76865163e-02f, 1.17989592e-01f, 1.74366310e-01f, 2.08546907e-01f, -6.34301975e-02f, 1.71564639e-01f, 1.77047595e-01f, 1.46522254e-01f, 1.63155422e-01f,
  3.93541083e-02f, 4.47454415e-02f, 1.41652599e-01f, 1.42574847e-01f, 1.22828759e-01f, 7.68099204e-02f, 1.52556643e-01f, 1.48949191e-01f, 3.83400870e-03f, -7.40652308e-02f,
  -3.31119634e-02f, 1.55323848e-01f, 2.09094942e-01f, -2.76608095e-02f, -2.80579552e-02f, 9.81724337e-02f, 2.18441933e-01f, -8.83878395e-02f, 6.13631718e-02f, 6.71385229e-02f,
  6.23898245e-02f, 5.28127477e-02f, 8.05644244e-02f, 2.02684924e-01f, -7.57416934e-02f, 1.65357843e-01f, 6.27129748e-02f, 2.39581447e-02f, 2.39605725e-01f, 4.18498106e-02f,
  8.68436396e-02f, 1.97624862e-01f, 1.89036485e-02f, 3.45954895e-01f, 3.11974972e-01f, -8.22846293e-02f, 2.89752662e-01f, 2.53245950e-01f, -4.73033078e-02f, 2.59545356e-01f,
  9.76864845e-02f, 2.00888932e-01f, -1.61473230e-01f, 9.38128829e-02f, -3.89492214e-02f, 2.02520922e-01f, 6.04947582e-02f, -4.18220699e-01f, -1.71368077e-01f, 1.28109425e-01f,
  -1.31744221e-01f, 1.89490914e-01f, -1.79259717e-01f, -1.04280068e-02f, -4.02216703e-01f, 1.53492764e-02f, 1.45069852e-01f, 3.37245971e-01f, -2.16365810e-02f, 1.42893091e-01f,
  -2.53120124e-01f, 6.05143383e-02f, -1.30441681e-01f, 1.16382495e-01f, 3.06017268e-02f, 1.91934690e-01f, -3.22664529e-01f, 1.31077662e-01f, 2.96908230e-01f, 1.94480106e-01f,
  -2.33026128e-02f, -7.95981213e-02f, 2.89334506e-01f, 1.53281773e-02f, -2.71451682e-01f, -1.06709242e-01f, -1.14144593e-01f, 2.60983072e-02f, 1.11355886e-01f, -1.21009871e-01f,
  1.70291230e-01f, 3.94047536e-02f, -1.42162323e-01f, -2.33493056e-02f, -9.99109074e-02f, 8.01320970e-02f, 1.37193620e-01f, 2.72551984e-01f, -7.38618448e-02f, 5.09725139e-02f,
  7.96914399e-02f, -1.45777658e-01f, 2.14911163e-01f, 2.59353697e-01f, -2.81182498e-01f, 1.25958070e-01f, -3.62300456e-01f, 1.00732677e-01f, 1.01734139e-01f, -3.68393481e-01f,
  -2.12122291e-01f, -4.46096510e-02f, -5.80040999e-02f, 3.08845073e-01f, -1.23149499e-01f, 2.24673033e-01f, 2.90105164e-01f, -1.72591478e-01f, -3.63568485e-01f, -1.26825094e-01f,
  -1.37276649e-02f, -9.36700776e-02f, 1.41952476e-02f, 2.12368920e-01f, 8.92358720e-02f, 2.28020653e-01f, -8.96058306e-02f, -1.41186090e-02f, -5.64054772e-02f, 2.83705831e-01f,
  2.84604300e-02f, 4.82901074e-02f, 6.13455400e-02f, 1.73920378e-01f, -7.62996227e-02f, 1.02245450e-01f, 8.81116465e-02f, 1.90152377e-01f, 1.14940874e-01f, 1.76092118e-01f,
  1.01189055e-01f, -5.54919504e-02f, 4.77143051e-03f, 1.37037262e-01f, 6.17241450e-02f, -6.43628612e-02f, 1.83420137e-01f, 1.05048239e-01f, 1.66267663e-01f, 2.09871963e-01f,
  1.80131108e-01f, 1.27071604e-01f, -1.11072659e-01f, 5.02856597e-02f, 2.18051136e-01f, -9.46628675e-02f, 1.53304681e-01f, 3.38525698e-02f, 6.86129481e-02f, 1.87201351e-01f,
  5.96959181e-02f, 9.07221287e-02f, 3.65697563e-01f, 8.06733593e-02f, 1.46964580e-01f, 3.10957860e-02f, -1.28495169e-03f, -8.31719860e-02f, -6.80524558e-02f, 8.70384946e-02f,
  2.21536994e-01f, 2.10163936e-01f, 1.00709625e-01f, -7.61455148e-02f, -2.76766151e-01f, 3.19354311e-02f, 1.77597225e-01f, -2.03200728e-01f, -1.39031395e-01f, -2.36293465e-01f,
  1.00047983e-01f, -1.57447919e-01f, 8.44176412e-02f, -1.11075103e-01f, -1.22840039e-01f, -2.19466597e-01f, -1.39302939e-01f, 1.12748362e-01f, -2.59387732e-01f, 2.60340840e-01f,
  2.31075641e-02f, 3.55546594e-01f, -2.27098301e-01f, -9.95069668e-02f, 2.54604012e-01f, -2.28118107e-01f, 2.37196952e-01f, -1.89685747e-01f, -9.28274393e-02f, 2.22060725e-01f,
  -5.73088229e-02f, -1.56474248e-01f, -2.62928993e-01f, 5.11233024e-02f, 1.97157532e-01f, -8.61071721e-02f, -1.98547408e-01f, 9.94056091e-02f, -4.84219454e-02f, 1.73454769e-02f,
  -1.14306197e-01f, 3.61983269e-01f, -3.90071981e-03f, 7.71926492e-02f, 2.86690354e-01f, 1.23630896e-01f, -1.52057737e-01f, -1.49281964e-01f, -3.09682805e-02f, -2.45611668e-01f,
  -1.23871028e-01f, 1.82889715e-01f, 1.26520231e-01f, 8.18020850e-02f, 3.06960106e-01f, 3.25832039e-01f, 4.32496816e-01f, 2.03133568e-01f, -2.69941241e-01f, -1.39258597e-02f,
  3.17469776e-01f, 1.47286206e-01f, 2.72996336e-01f, 3.33942562e-01f, -1.29289865e-01f, 3.08968663e-01f, 1.96877439e-02f, 2.75845081e-01f, 3.31517756e-01f, -1.78390071e-01f,
  1.07212797e-01f, 3.04300904e-01f, 1.95182815e-01f, 2.17347026e-01f, 2.94181705e-01f, 3.88793379e-01f, -1.61576301e-01f, -8.24569017e-02f, 3.46253105e-02f, -4.06016968e-02f,
  7.53444061e-03f, 7.18068937e-03f, -6.16257079e-02f, 1.84997380e-01f, 5.36085963e-02f, 2.32148632e-01f, 8.10971335e-02f, 2.16798887e-01f, 2.38642499e-01f, 3.55136767e-02f,
  -4.57041375e-02f, 1.22764193e-01f, 5.37844412e-02f, 5.07882908e-02f, 1.75298616e-01f, 4.63319942e-02f, 2.23621521e-02f, 1.05444212e-02f, -6.37380034e-02f, 1.54768944e-01f,
  -1.51604757e-01f, 5.77444583e-02f, 2.68101580e-02f, -2.76069692e-03f, 8.32176283e-02f, 3.23060714e-02f, 1.81622669e-01f, 1.12659130e-02f, 7.28364801e-04f, 9.37720835e-02f,
  -5.19131124e-02f, 1.91021472e-01f, -9.82546210e-02f, 1.46064296e-01f, 1.87222604e-02f, -2.46509798e-02f, -1.99469905e-02f, 1.01763755e-01f, 1.27811700e-01f, 7.89726079e-02f,
  1.58713996e-01f, 3.94294672e-02f, 1.60986379e-01f, 1.14658721e-01f, 9.08043310e-02f, 1.28944993e-01f, 6.85112625e-02f, 1.85094271e-02f, 1.82530284e-01f, -8.39583576e-02f,
  -1.80820763e-01f, -1.93410337e-01f, -7.05166832e-02f, -2.26325080e-01f, 1.47033811e-01f, -3.70526686e-02f, 6.04281276e-02f, -2.07027555e-01f, 1.79831743e-01f, -4.16806579e-01f,
  7.11762486e-03f, 7.39668161e-02f, -1.78182378e-01f, 1.46301195e-01f, 5.00413328e-02f, 4.79635298e-02f, 1.77031487e-01f, -1.13934964e-01f, 2.99231678e-01f, 2.60640085e-02f,
  2.47191712e-02f, 2.49820650e-01f, -1.65189087e-01f, -5.44370040e-02f, -3.97566333e-02f, -2.35313594e-01f, 3.13411236e-01f, -9.49848536e-03f, -1.14817962e-01f, -4.47625592e-02f,
  -2.79002905e-01f, -1.64409950e-01f, 2.39006937e-01f, -2.08035856e-01f, -1.03258945e-01f, -2.35085353e-01f, -4.24464792e-02f, 2.62759686e-01f, -1.62821785e-01f, 1.28889561e-01f,
  7.87428096e-02f, 2.44844496e-01f, 1.76093891e-01f, -3.13928612e-02f, -1.13278300e-01f, 1.74690500e-01f, -3.23853679e-02f, 1.51165813e-01f, 6.28649965e-02f, 1.69658691e-01f,
  1.83510646e-01f, 3.18036862e-02f, 6.17985278e-02f, -1.85882717e-01f, 2.61177093e-01f, 1.05828062e-01f, -6.01943843e-02f, 1.58666313e-01f, -4.63774689e-02f, -6.35030493e-02f,
  3.38859797e-01f, -1.29698083e-01f, 3.37160110e-01f, -1.96620941e-01f, 1.17250927e-01f, 2.26038858e-01f, 3.35857809e-01f, 1.48684695e-01f, 1.82468846e-01f, 1.96890831e-01f,
  3.22887152e-01f, 2.34162673e-01f, 1.69733942e-01f, 3.39745671e-01f, -8.02170932e-02f, 2.12966353e-01f, 1.63933292e-01f, 2.23491509e-02f, 5.65170906e-02f, 2.11093903e-01f,
  2.04479806e-02f, 1.32687613e-01f, 1.41047120e-01f, 1.45796284e-01f, 1.81382790e-01f, -2.17583664e-02f, 1.86837539e-01f, 1.38325572e-01f, 9.91672799e-02f, -2.50916053e-02f,
  1.57121465e-01f, 5.36220968e-02f, 1.75477281e-01f, -1.51316719e-02f, 1.63570374e-01f, 1.26979396e-01f, 1.99725077e-01f, 1.36884958e-01f, 1.00794137e-01f, 1.30132347e-01f,
  1.98247373e-01f, 1.77370414e-01f, 1.31005198e-02f, 2.91808974e-02f, 1.32951260e-01f, 5.06214797e-03f, 2.26543173e-02f, -2.43230220e-02f, 5.50008789e-02f, 1.36870399e-01f,
  1.32383972e-01f, -3.79036851e-02f, 1.19409755e-01f, 1.05110608e-01f, 5.25327341e-04f, 8.57965499e-02f, 7.12743029e-02f, 2.20207095e-01f, -6.62950724e-02f, 2.38631383e-01f,
  1.08908191e-01f, 2.57041883e-02f, 1.74172059e-01f, 6.53796270e-02f, 1.14490561e-01f, 1.58954710e-01f, 1.13165446e-01f, 3.20240915e-01f, 2.79141575e-01f, -8.88888091e-02f,
  1.42520949e-01f, 8.77149925e-02f, -9.72443819e-02f, 2.24014252e-01f, 1.96884632e-01f, 2.59615064e-01f, -1.08307805e-02f, 1.53465778e-01f, -1.22102246e-01f, 1.22804031e-01f,
  3.72523442e-02f, -1.93149686e-01f, -1.96718112e-01f, 2.05415547e-01f, -1.33010875e-02f, 1.23429023e-01f, 1.47785656e-02f, -8.36208984e-02f, -3.00210476e-01f, -1.08125761e-01f,
  -2.84138955e-02f, 2.47434258e-01f, 3.07965074e-02f, 1.64198652e-01f, -1.00765921e-01f, 1.61755651e-01f, -6.82981014e-02f, -2.67396588e-02f, -4.06038798e-02f, 2.80021667e-01f,
  -2.40373209e-01f, 7.00238645e-02f, 2.65031546e-01f, 1.55567080e-01f, -1.22939266e-01f, 1.97436675e-01f, 2.24964708e-01f, -1.00415595e-01f, -2.16853723e-01f, -1.19938634e-01f,
  -1.49196506e-01f, 1.20004062e-02f, 1.37633011e-01f, -2.14100242e-01f, 2.21481577e-01f, 1.16949165e-02f, 1.18134215e-01f, -5.26415966e-02f, -1.31115124e-01f, -1.01250082e-01f,
  4.32923995e-02f, 2.15604231e-01f, -3.97738665e-02f, 3.95458601e-02f, 2.08785832e-01f, 1.97007820e-01f, 2.93040097e-01f, 1.90679088e-01f, -3.44352484e-01f, 1.86793402e-01f,
  -6.42409176e-02f, 2.10611776e-01f, 4.13113609e-02f, -2.76112288e-01f, -2.03849062e-01f, 2.10114986e-01f, -3.62660512e-02f, 6.02747872e-02f, -8.17082599e-02f, -6.78739026e-02f,
  3.61220539e-01f, -1.42234921e-01f, -3.63253146e-01f, 1.47909090e-01f, 4.90508750e-02f, 1.29746750e-01f, -1.23963784e-02f, 1.50339782e-01f, 6.73499778e-02f, 1.78485990e-01f,
  1.30882755e-01f, 2.02907428e-01f, 7.68973380e-02f, 2.19352413e-02f, 5.30070961e-02f, 1.48471594e-01f, 1.06098771e-01f, -6.49188161e-02f, 9.59723666e-02f, 6.74215928e-02f,
  7.30497688e-02f, 4.90128510e-02f, -4.64489078e-03f, 1.10427827e-01f, 8.54796842e-02f, 2.86871754e-02f, 1.62947878e-01f, 1.78579569e-01f, 1.04572803e-01f, 1.39605746e-01f,
  1.24653548e-01f, 7.60434419e-02f, 1.03229769e-01f, 8.50085318e-02f, 5.98300621e-02f, -9.18928534e-03f, 1.00928739e-01f, 1.93374142e-01f, 1.24975584e-01f, -9.49256420e-02f,
  7.36418590e-02f, -3.08196731e-02f, 1.60961196e-01f, -8.75083450e-03f, 1.73083961e-01f, 1.41242906e-01f, 3.19745801e-02f, 1.22377470e-01f, 5.54166548e-02f, 1.47732675e-01f,
  1.10296644e-01f, 1.48961961e-01f, 1.01707011e-01f, 4.29235958e-02f, 2.09332928e-01f, 3.21843773e-01f, 1.54945657e-01f, 5.94529090e-03f, -5.42786494e-02f, 1.59599960e-01f,
  -1.07792996e-01f, 7.11483462e-03f, 4.35529798e-02f, 4.21231657e-01f, -2.14267567e-01f, 2.40572736e-01f, -1.78772345e-01f, 2.26376712e-01f, 5.78111447e-02f, -2.86658376e-01f,
  -1.16603665e-01f, -1.10143032e-02f, -1.16847359e-01f, 2.45465919e-01f, -1.33876801e-01f, 9.25743282e-02f, -3.49523634e-01f, -1.89943701e-01f, -2.80367192e-02f, 3.19811463e-01f,
  -6.54501170e-02f, -3.91827263e-02f, -1.85155421e-01f, 1.50042996e-01f, -2.42723152e-01f, 1.54529482e-01f, -1.66683063e-01f, 1.93054721e-01f, -2.44072095e-01f, 5.96711412e-02f,
  3.35954249e-01f, 2.70817697e-01f, 8.03420469e-02f, -1.89981222e-01f, 1.66561361e-02f, 2.76596304e-02f, 8.86080861e-02f, -1.69848442e-01f, -2.84839094e-01f, 3.12938653e-02f,
  -2.58570611e-02f, -2.11063430e-01f, -1.72074482e-01f, 3.33080105e-02f, -3.87879349e-02f, 3.79366726e-02f, -1.52883902e-01f, 7.82717690e-02f, -7.42481574e-02f, 2.47605175e-01f,
  5.27334698e-02f, -1.71276748e-01f, 1.71880975e-01f, -1.17480576e-01f, 5.29050119e-02f, 8.92215893e-02f, -2.86660969e-01f, 3.31632882e-01f, -3.17045063e-01f, 2.20191404e-01f,
  9.42181237e-03f, -1.46283820e-01f, -6.48768097e-02f, -4.20584381e-02f, -4.27149206e-01f, -3.85428756e-01f, -2.12875053e-01f, 3.91819589e-02f, 2.29651868e-01f, 1.14692235e-02f,
  -3.29185039e-01f, -2.26932839e-02f, 7.95533806e-02f, -5.94990961e-02f, 1.03755020e-01f, 3.03344298e-02f, 1.64675415e-01f, 7.84395188e-02f, 4.10108380e-02f, 3.50735933e-02f,
  -6.31597489e-02f, 1.03448316e-01f, 1.52596533e-01f, 1.01185709e-01f, 2.13272154e-01f, 1.38359398e-01f, -9.65860933e-02f, 1.50916740e-01f, 1.73757747e-01f, 9.15858224e-02f,
  1.46411896e-01f, 8.77139270e-02f, 6.04148544e-02f, 8.78060386e-02f, 9.23215132e-03f, 4.23139222e-02f, 1.43843010e-01f, -3.18900868e-02f, 8.87659788e-02f, 1.94571614e-01f,
  1.40770540e-01f, 1.43890396e-01f, 2.72740354e-03f, 1.28544599e-01f, 7.79312551e-02f, 2.14204878e-01f, -2.41122744e-03f, 1.01196289e-01f, 2.65701525e-02f, 1.50776342e-01f,
  2.37016961e-01f, 6.11426458e-02f, 2.01583415e-01f, 7.46260658e-02f, 1.93613783e-01f, -4.00121398e-02f, 1.55537069e-01f, 2.05945045e-01f, 1.47404686e-01f, 3.57445031e-02f,
  2.15042040e-01f, 1.38931796e-01f, 1.73269495e-01f, -1.23385794e-01f, -3.09981555e-01f, -2.31204927e-01f, -2.98930287e-01f, -1.66527554e-01f, 3.03417891e-01f, -1.94234505e-01f,
  -7.78475255e-02f, -2.34143157e-02f, 2.96997517e-01f, -3.06837857e-01f, -3.89528275e-03f, -1.35683209e-01f, 4.04556729e-02f, 1.05797641e-01f, 2.42211416e-01f, 2.89248765e-01f,
  -6.90630898e-02f, 1.36033475e-01f, 7.32097700e-02f, 1.73623100e-01f, -1.64708942e-01f, -1.50814638e-01f, 1.63140446e-01f, -2.30954155e-01f, -1.78058967e-01f, -3.76837850e-01f,
  2.85833746e-01f, -2.99123824e-01f, 5.83143644e-02f, 1.94779783e-01f, -1.01178609e-01f, -3.05276215e-01f, 1.37244895e-01f, -4.37810034e-01f, -1.56774923e-01f, -2.55441874e-01f,
  2.54526466e-01f, 7.80865923e-02f, -3.32990050e-01f, 1.70798123e-01f, 7.37932101e-02f, 3.27512413e-01f, 2.10645765e-01f, -1.24056861e-01f, -2.40762368e-01f, -1.30173951e-01f,
  -2.03947201e-01f, 9.85030457e-02f, -1.54210895e-01f, 3.36320966e-01f, 2.50778645e-01f, 1.62632063e-01f, -1.79004937e-01f, 2.17547983e-01f, 2.31399715e-01f, 2.55079836e-01f,
  -2.58442849e-01f, -2.24098027e-01f, 2.17904270e-01f, 2.28857443e-01f, 2.81842768e-01f, 1.49782613e-01f, -1.64890826e-01f, 1.39418244e-01f, -1.98325654e-03f, 4.16021943e-01f,
  3.47506404e-01f, -4.70025353e-02f, 1.75336763e-01f, 3.67892772e-01f, 3.36601675e-01f, 2.98763722e-01f, 8.49616677e-02f, 3.18353415e-01f, -2.88730767e-02f, -1.04247317e-01f,
  2.26358742e-01f, -8.91216546e-02f, -5.25476225e-02f, -1.05297901e-02f, 1.09336145e-01f, 5.55582978e-02f, 1.37820110e-01f, -8.10249820e-02f, 7.43319765e-02f, 1.17378570e-01f,
  1.01358533e-01f, 6.46669939e-02f, 3.78480889e-02f, 1.88651413e-01f, 1.67358443e-02f, -9.86867622e-02f, 7.96576068e-02f, 1.19123742e-01f, 1.76327173e-02f, 1.35200769e-01f,
  -2.72368640e-03f, 1.70274347e-01f, 1.04659393e-01f, 1.41871095e-01f, -1.78537387e-02f, -6.82429969e-02f, -1.41379684e-01f, 6.43442348e-02f, 1.32513374e-01f, 1.11773364e-01f,
  -9.25788889e-04f, 1.13963917e-01f, 1.51294827e-01f, 7.79011175e-02f, -1.92522869e-01f, -1.93827134e-02f, -4.52609509e-02f, 7.30263442e-02f, 1.05757490e-01f, 5.43770716e-02f,
  8.76301154e-02f, 1.28177062e-01f, 1.44558191e-01f, -1.12968102e-01f, 1.69939429e-01f, -9.40299965e-03f, -2.08526403e-02f, 6.99928701e-02f, -3.35573144e-02f, -1.07345253e-01f,
  9.96516347e-02f, -1.79504961e-01f, -8.51728246e-02f, 7.91367441e-02f, -2.44141281e-01f, -2.76971221e-01f, 1.85670257e-01f, 5.13189994e-02f, 1.04521602e-01f, -1.48829833e-01f,
  2.59297371e-01f, -1.93907514e-01f, -1.93014368e-02f, -2.59773154e-03f, 8.44169930e-02f, 1.34211406e-01f, 1.36597276e-01f, 3.40168551e-03f, -4.61123437e-02f, 1.22832730e-01f,
  1.67612344e-01f, -9.95234996e-02f, 2.43433505e-01f, -6.04364797e-02f, 6.16852045e-02f, -3.38981926e-01f, -5.50182648e-02f, -9.98000242e-03f, -1.95608988e-01f, -3.12638193e-01f,
  2.27741197e-01f, -2.57786036e-01f, 9.70959440e-02f, -1.42835483e-01f, -1.28553689e-01f, -1.78968593e-01f, -1.37602568e-01f, -3.15502822e-01f, -1.73714861e-01f, 9.59796086e-02f,
  -2.33143732e-01f, 1.85517460e-01f, -1.83530375e-01f, 1.95911825e-01f, 2.21729517e-01f, -1.74706746e-02f, -3.32086742e-01f, -4.13304474e-03f, -4.47129272e-02f, -1.69209480e-01f,
  7.83341005e-02f, 2.32505292e-01f, 1.40998245e-03f, 3.07605445e-01f, 2.09676996e-01f, -1.64413769e-02f, 1.70598641e-01f, 3.11177254e-01f, 2.28844464e-01f, 1.56347945e-01f,
  1.61029119e-02f, 2.85323951e-02f, 1.30560070e-01f, -1.73193201e-01f, -5.75097539e-02f, -2.53295042e-02f, -3.08464140e-01f, 2.97622174e-01f, 1.96061209e-01f, -2.94473432e-02f,
  1.04274139e-01f, 2.05854014e-01f, 2.95470655e-01f, -3.67796943e-02f, -1.33579120e-01f, -6.83816969e-02f, 1.19393192e-01f, 1.92215234e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.97053894e-01f, 1.04743458e-01f, -2.76295412e-02f, 4.62491326e-02f, 1.37628004e-01f, 1.36333987e-01f, 9.92105082e-02f, 2.17515737e-01f, 1.60536230e-01f, 1.98947359e-02f,
  1.61558315e-01f, 9.61065963e-02f, 1.69678349e-02f, 4.92960513e-02f, 9.58169997e-02f, 1.11284479e-01f, 1.22137181e-01f, 8.07431191e-02f, 1.25370085e-01f, 5.29343747e-02f,
  1.37506023e-01f, 6.21147379e-02f, 2.78228745e-02f, 1.08999304e-01f, 8.09426457e-02f, 1.11180611e-01f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  1.42991900e-01f, -2.23177206e-03f, 7.24468827e-02f, 9.51988250e-02f, -2.03298330e-02f, -8.43435302e-02f, 6.99976757e-02f, -7.12658912e-02f, 1.34829525e-02f, 8.78671408e-02f,
  -4.31577228e-02f, 8.81112292e-02f, 9.12084281e-02f, -3.56518812e-02f, -1.04425155e-01f, 6.70738667e-02f, -1.48341417e-01f, 9.39096734e-02f, -8.00835490e-02f, -1.60961822e-01f,
  -1.48931861e-01f, 8.85296687e-02f, -1.14204995e-01f, 5.76173924e-02f, -4.27533351e-02f, 6.01689965e-02f, 8.40671435e-02f, 1.88332181e-02f, -1.02654353e-01f, -5.73612712e-02f,
  -3.64644527e-02f, -2.80337292e-03f, -3.47460061e-02f, 5.49618751e-02f, -1.26777496e-03f, -6.92910999e-02f, -2.10158108e-03f, -4.37358655e-02f, -2.05857575e-01f, -1.67533904e-01f,
  8.16537142e-02f, 5.77489771e-02f, -2.81739905e-02f, 9.92967859e-02f, -5.43863028e-02f, 4.36586887e-02f, -1.44274205e-01f, -1.51967958e-01f, 8.45062807e-02f, 6.18786179e-03f,
  -1.19534560e-01f, -6.32271990e-02f, 1.81003600e-01f, 1.89459417e-02f, 6.64562210e-02f, -1.92439109e-01f, 4.94500436e-02f, 1.04487225e-01f, 1.93117023e-01f, -1.59021944e-01f,
  -2.93923199e-01f, -1.55592933e-01f, 1.03446998e-01f, 1.97703809e-01f, 1.89936394e-03f, 1.41257852e-01f, -2.62556169e-02f, -1.38152063e-01f, -2.83229530e-01f, -1.49626106e-01f,
  -7.37387035e-03f, -1.26519039e-01f, 2.40164712e-01f, 1.42443195e-01f, 2.67080158e-01f, -1.48684427e-01f, -2.83142149e-01f, -3.19942504e-01f, 1.43730074e-01f, 7.25283250e-02f,
  -2.17342302e-01f, 2.35207930e-01f, -9.76287294e-03f, -1.73453107e-01f, -5.01945242e-03f, 2.86528111e-01f, 3.05557609e-01f, 1.94005862e-01f, -9.49511454e-02f, -1.06072843e-01f,
  -7.96041936e-02f, 8.04062039e-02f, -1.54391021e-01f, 1.21192351e-01f, -2.73663521e-01f, -5.87217184e-03f, -7.59843290e-02f, 2.05762863e-01f, -1.10529579e-01f, 1.29287794e-01f,
  2.53577024e-01f, -2.16888025e-01f, -2.65820444e-01f, -4.31160033e-01f, -4.04639356e-02f, 1.87193900e-01f, 3.13786715e-02f, -7.24592060e-02f, 2.61291683e-01f, -4.42900509e-01f,
  1.22066788e-01f, -5.26467673e-02f, -1.27375782e-01f, -3.52363825e-01f, 2.16162398e-01f, -6.29574433e-02f, -2.32328579e-01f, 1.62091538e-01f, -7.82877430e-02f, -3.45719159e-01f,
  4.74869572e-02f, -4.04282957e-01f, 9.06999707e-02f, 1.63399175e-01f, -3.19280177e-01f, -3.83703172e-01f, 2.94408128e-02f, 2.06941858e-01f, -9.23698694e-02f, -6.95675313e-02f,
  -2.15222389e-02f, -9.39988568e-02f, -6.30164333e-03f, -1.59768373e-01f, 7.96842724e-02f, -5.56932837e-02f, -3.72196361e-02f, -2.14771718e-01f, 7.11860210e-02f, 3.43158767e-02f,
  -8.38102922e-02f, 3.04211024e-03f, -1.63368970e-01f, -8.32828060e-02f, -5.03290794e-04f, -3.92042734e-02f, 6.35682046e-02f, 6.38491586e-02f, -8.91150385e-02f, -5.68856187e-02f,
  6.78551048e-02f, -6.02757232e-03f, 4.43780646e-02f, -8.68735015e-02f, -3.50525528e-02f, 4.04369086e-02f, 1.03184365e-01f, -3.48214023e-02f, -5.88500465e-04f, -9.36086848e-02f,
  7.76380897e-02f, 1.23446509e-02f, 5.39673716e-02f, 3.03656422e-02f, 1.31706893e-01f, 8.60684961e-02f, 2.16801122e-01f, -4.62635159e-02f, -3.82435657e-02f, 1.83674589e-01f,
  -8.75217468e-02f, -4.08010557e-02f, 6.21934868e-02f, -1.90246567e-01f, -1.14451043e-01f, -2.75851376e-02f, -7.15567768e-02f, 5.17213680e-02f, -1.32648728e-03f, -1.92586735e-01f,
  -1.13274179e-01f, -1.50946686e-02f, -2.21064180e-01f, 3.15519422e-01f, 8.18688869e-02f, 1.00075804e-01f, 1.80455282e-01f, 2.59695530e-01f, -2.21158028e-01f, -1.44814894e-01f,
  1.24296948e-01f, -2.15303198e-01f, 1.74021780e-01f, 2.61573076e-01f, -7.13477060e-02f, -1.82441786e-01f, -1.97009280e-01f, -5.29783852e-02f, 3.41843247e-01f, 1.81545138e-01f,
  -2.67677873e-01f, -2.66910121e-02f, 3.05225402e-01f, 2.34746113e-01f, -3.64356518e-01f, -2.38946855e-01f, 3.44083518e-01f, 2.76163638e-01f, -1.98445037e-01f, -1.51572868e-01f,
  -3.04950714e-01f, 1.47657171e-01f, -1.82501804e-02f, 1.99615166e-01f, -2.74363488e-01f, 1.55313596e-01f, -2.32528821e-01f, -8.81376415e-02f, 1.92886665e-01f, -2.59916633e-01f,
  6.07932806e-02f, 1.73338592e-01f, -3.08753401e-01f, 6.52632713e-02f, -1.22570463e-01f, -3.97681221e-02f, -2.22620055e-01f, -4.43534702e-02f, 1.46688521e-01f, -1.43869534e-01f,
  -1.50638491e-01f, -2.99182177e-01f, -1.11122735e-01f, 2.10289478e-01f, -1.11867264e-01f, -9.07370225e-02f, 7.22580850e-02f, 1.48594931e-01f, -2.08492771e-01f, 2.32561290e-01f,
  -3.00780058e-01f, 7.58737624e-02f, 2.83160567e-01f, -4.06152427e-01f, 1.24243490e-01f, -2.87878424e-01f, 1.67728111e-01f, -2.03301311e-01f, 2.27286056e-01f, -5.88143282e-02f,
  -7.53578022e-02f, -1.45575136e-01f, 1.80504732e-02f, -3.39599103e-02f, -2.26041049e-01f, 1.88049883e-01f, 2.71962341e-02f, -3.11927237e-02f, 4.06382568e-02f, 9.65506658e-02f,
  -6.91410527e-02f, -1.87792733e-01f, 1.27548184e-02f, 2.30564624e-02f, 8.64388943e-02f, 6.38986081e-02f, -7.40636289e-02f, -1.42547548e-01f, -1.10288277e-01f, 8.69690850e-02f,
  1.04839459e-01f, 2.75711734e-02f, 7.09467381e-02f, -3.83764245e-02f, -8.99989009e-02f, -3.44702005e-02f, -7.44948015e-02f, -9.22546387e-02f, 1.45656744e-03f, 2.03651842e-02f,
  -9.50099826e-02f, 4.00926098e-02f, 5.78914359e-02f, 1.25281811e-01f, -3.29334312e-03f, -5.45491204e-02f, -3.84814814e-02f, -1.01360772e-02f, -1.38919845e-01f, -7.29148015e-02f,
  3.38889956e-02f, -1.22500509e-01f, 3.45429629e-02f, -8.92101228e-02f, -1.47014186e-01f, 3.68303806e-02f, -2.11667940e-01f, -5.83982766e-02f, -5.51412208e-03f, -1.46769375e-01f,
  -1.73362687e-01f, 1.04697630e-01f, 1.44970985e-02f, -1.19355969e-01f, 7.99399894e-03f, 3.52075621e-02f, -1.92069307e-01f, -1.61298558e-01f, -1.16416581e-01f, 2.58890867e-01f,
  2.22046569e-01f, 1.64774299e-01f, 4.72812587e-03f, -5.30470349e-02f, -3.52389246e-01f, 7.23434091e-02f, 2.02987209e-01f, -5.51844835e-02f, 1.23497799e-01f, -7.10900500e-02f,
  -2.24311382e-01f, -3.12779725e-01f, -5.66422604e-02f, -3.36686857e-02f, 1.10404052e-01f, -1.64570361e-01f, -3.15189779e-01f, -2.18227565e-01f, 3.81764732e-02f, -2.28594214e-01f,
  -1.55602455e-01f, -2.56843120e-01f, 1.94281772e-01f, -2.13780366e-02f, -1.98248133e-01f, -5.97301833e-02f, 3.02804738e-01f, 1.28105894e-01f, 2.76581556e-01f, 1.30538195e-01f,
  2.33672068e-01f, -2.21561059e-01f, -6.42188564e-02f, -4.35688123e-02f, 5.19334152e-02f, 1.15396507e-01f, -6.08286485e-02f, -1.00390345e-01f, 2.69365132e-01f, -1.21643372e-01f,
  -1.61750466e-01f, -4.45318148e-02f, 1.24895591e-02f, 2.11787283e-01f, -2.24372625e-01f, -2.44055659e-01f, 1.74955800e-01f, -1.07128337e-01f, -3.71595740e-01f, 1.65062398e-01f,
  -2.65560508e-01f, 8.92986432e-02f, -2.63515890e-01f, -4.48550321e-02f, -3.29984650e-02f, 1.89739868e-01f, -9.54977125e-02f, 1.69594735e-01f, 9.48971435e-02f, 2.03258082e-01f,
  -2.85853874e-02f, -3.14868927e-01f, 2.46346563e-01f, -4.38534468e-01f, -6.89663589e-02f, 1.85036305e-02f, 1.90911531e-01f, -1.98403329e-01f, -2.82906204e-01f, 1.97212234e-01f,
  1.06741138e-01f, -2.11637706e-01f, -4.22973156e-01f, -1.40810803e-01f, -2.71423101e-01f, -3.97317745e-02f, -9.42084491e-02f, -1.41700655e-02f, -1.31543428e-01f, -2.08317377e-02f,
  -1.65967464e-01f, 6.33260384e-02f, -3.42936926e-02f, -2.00945623e-02f, 2.61098370e-02f, -1.04398787e-01f, -2.13829756e-01f, -2.34249726e-01f, 1.10345699e-01f, -4.33819257e-02f,
  1.20318152e-01f, -7.95434117e-02f, -8.49081352e-02f, -2.60015037e-02f, 6.16250113e-02f, -8.78112987e-02f, -1.44937634e-01f, 5.94300479e-02f, 5.99657781e-02f, 9.48510692e-02f,
  -7.85959587e-02f, 9.02732387e-02f, -3.57937515e-02f, 1.21746145e-01f, 7.33120367e-02f, 3.00204419e-02f, -7.05669448e-02f, 7.55160872e-05f, -1.13883600e-01f, 7.48144463e-02f,
  -4.01654616e-02f, 8.84050597e-03f, 5.11137098e-02f, -1.12743661e-01f, -1.13311939e-01f, -9.24540907e-02f, -1.77456319e-01f, -1.34086937e-01f, 9.53742862e-02f, -1.33518904e-01f,
  -9.71603692e-02f, -5.93822524e-02f, 3.75468247e-02f, -1.83306769e-01f, 8.95775706e-02f, 1.11308649e-01f, -2.68577635e-01f, -1.90261453e-01f, 1.73057944e-01f, 2.72882711e-02f,
  -3.34606230e-01f, -2.59361297e-01f, -6.23415783e-02f, -1.32934436e-01f, 4.95377854e-02f, -9.66304988e-02f, -2.43905172e-01f, -4.45776694e-02f, 2.94294804e-02f, 6.76726177e-02f,
  1.41594987e-02f, 1.77585229e-01f, 1.74267039e-01f, -1.58767283e-01f, 1.68206930e-01f, 3.26428086e-01f, 2.81621695e-01f, 1.91785321e-01f, -1.79885313e-01f, 1.43324316e-01f,
  -2.98364639e-01f, 1.07888952e-01f, 2.12189645e-01f, 4.43821028e-02f, -1.82169750e-01f, 2.07936484e-02f, -2.24024907e-01f, -2.49844790e-01f, -1.73579693e-01f, -7.51569942e-02f,
  1.53956816e-01f, -2.23236144e-01f, 1.01567954e-02f, -2.49298438e-01f, 2.53676206e-01f, 1.15367338e-01f, -5.84192649e-02f, -2.01020956e-01f, 1.97211355e-01f, -1.65850833e-01f,
  2.12843642e-01f, -2.63349950e-01f, 2.57159650e-01f, -1.86266363e-01f, -1.49412453e-01f, -9.28531215e-02f, -9.76627767e-02f, -1.31333068e-01f, -2.50758231e-01f, 2.73842011e-02f,
  -3.34419191e-01f, -1.05368115e-01f, -4.00531113e-01f, -6.20016120e-02f, 1.48757637e-01f, 1.35425164e-03f, -3.04959387e-01f, -2.84482837e-01f, -2.93231875e-01f, 1.99137360e-01f,
  -3.97974700e-01f, 2.68599361e-01f, -1.81021333e-01f, -1.88519463e-01f, -4.59726602e-01f, -2.21779823e-01f, 8.00251439e-02f, 9.22588855e-02f, -3.43790919e-01f, -2.39072382e-01f,
  2.33083159e-01f, 3.27216536e-01f, -9.63032022e-02f, 1.56654313e-01f, 2.65655071e-02f, -5.25722243e-02f, -1.48832217e-01f, 1.01202995e-01f, 1.13490298e-01f, 7.28762820e-02f,
  -2.00611472e-01f, -1.06307849e-01f, 1.41403275e-02f, -8.33428353e-02f, 6.75857887e-02f, -3.11782826e-02f, -7.36750141e-02f, 5.52872382e-02f, -1.01580292e-01f, -7.83559754e-02f,
  1.23212496e-02f, 1.57095537e-01f, 5.84593192e-02f, -3.13392505e-02f, 7.25094602e-02f, 4.70062047e-02f, 5.54842278e-02f, 4.21532393e-02f, 6.72308356e-02f, -4.71080653e-02f,
  1.06058754e-01f, -7.16086775e-02f, -7.63727650e-02f, 3.29435915e-02f, 2.00801238e-01f, 1.15872808e-01f, 1.28143236e-01f, -2.65987087e-02f, 2.59733647e-01f, -6.42889962e-02f,
  9.99702960e-02f, 6.28038198e-02f, -2.69999057e-02f, -1.06645651e-01f, 8.28031544e-03f, 7.17630386e-02f, -1.49831504e-01f, -2.50921887e-03f, -1.60473324e-02f, 8.67191050e-03f,
  1.15115859e-01f, 1.47715896e-01f, 1.81902908e-02f, -3.86218503e-02f, 2.49835238e-01f, -1.15553118e-01f, 1.67226702e-01f, -2.03662694e-01f, 1.68844983e-01f, 2.39206061e-01f,
  -2.08669275e-01f, -1.35767594e-01f, 2.56753236e-01f, 1.62859023e-01f, 1.95588917e-01f, 3.28198254e-01f, 1.19942747e-01f, 1.48340032e-01f, 2.43582442e-01f, -2.29002044e-01f,
  2.82041311e-01f, -7.08698556e-02f, -2.57487930e-02f, -1.14464529e-01f, 2.53246933e-01f, 2.53430039e-01f, -6.69129938e-02f, -3.08091313e-01f, 2.38694891e-01f, 2.66569108e-01f,
  -2.24597916e-01f, 9.20373648e-02f, 3.43019605e-01f, 2.10309356e-01f, -1.11073367e-01f, 1.69182330e-01f, 1.28129810e-01f, -1.71766236e-01f, -3.39729607e-01f, 5.52068911e-02f,
  9.11606923e-02f, -5.93129881e-02f, 1.75688878e-01f, 4.24361117e-02f, -1.81822777e-02f, -2.33390823e-01f, 2.13929221e-01f, 1.53997406e-01f, -2.59017199e-01f, 1.92618147e-01f,
  -2.69537985e-01f, 2.75312662e-01f, -1.91218182e-01f, 1.78970411e-01f, 9.85017642e-02f, -2.65465695e-02f, 1.85396984e-01f, 4.37730849e-02f, -9.10916999e-02f, -2.10157812e-01f,
  -7.48439953e-02f, 8.07671323e-02f, 2.27782533e-01f, -2.54000157e-01f, 2.22798929e-01f, 7.23271668e-02f, -2.50739932e-01f, 2.77922362e-01f, -3.78117979e-01f, 9.35233161e-02f,
  -2.42434457e-01f, -1.66807875e-01f, -2.90135574e-02f, -3.76364708e-01f, 5.90358377e-02f, 6.12269193e-02f, -3.18576187e-01f, -3.94282453e-02f, 1.14921570e-01f, -6.66763857e-02f,
  1.43740654e-01f, 1.03490837e-01f, 2.13693734e-02f, -1.06033593e-01f, 1.34322435e-01f, -5.41977808e-02f, -2.64473986e-02f, -5.85415810e-02f, 1.04521513e-01f, 2.04407200e-01f,
  3.22033241e-02f, 1.19418114e-01f, -3.94083969e-02f, -1.20526686e-01f, -1.41241491e-01f, 5.41574471e-02f, 1.78234100e-01f, 3.82589810e-02f, -1.00627691e-02f, 1.01782255e-01f,
  -6.30579144e-02f, 1.25892639e-01f, 7.30072036e-02f, 1.25554278e-01f, 7.40001276e-02f, 1.23460248e-01f, -1.85450204e-02f, -6.79600239e-02f, 1.51019931e-01f, 1.15770563e-01f,
  3.43144573e-02f, -2.08955221e-02f, 1.22485377e-01f, 1.43471554e-01f, -8.60012174e-02f, -8.37765560e-02f, 1.51911490e-02f, 1.48088291e-01f, -1.72440454e-01f, 3.29237245e-03f,
  1.58825800e-01f, -6.21529259e-02f, -8.99276584e-02f, 7.17533454e-02f, 1.23679668e-01f, 1.80859473e-02f, 3.82569619e-02f, 1.69492394e-01f, -6.63490221e-02f, 9.93784964e-02f,
  9.22545567e-02f, 5.60704283e-02f, 1.85599491e-01f, -2.09367603e-01f, -1.47339895e-01f, 8.53036195e-02f, -5.74597530e-02f, 7.34959245e-02f, 3.33125852e-02f, -2.05532610e-01f,
  -1.57366976e-01f, 2.54211217e-01f, -5.48060164e-02f, -2.54542053e-01f, -1.49602061e-02f, 1.81291521e-01f, -1.08539306e-01f, 1.19829781e-01f, -3.85211818e-02f, 2.94578224e-01f,
  4.53458019e-02f, -2.45640337e-01f, -1.96719065e-01f, 4.95497137e-02f, 2.55111996e-02f, 1.15764119e-01f, 1.82431012e-01f, -2.15667292e-01f, -1.49355888e-01f, -7.40286112e-02f,
  1.41946360e-01f, -2.71832913e-01f, -2.68783331e-01f, -2.46403575e-01f, 1.92805275e-01f, 3.27294469e-01f, 1.81886166e-01f, 1.36310130e-01f, -1.11152247e-01f, -2.06930742e-01f,
  1.96859777e-01f, 1.52352806e-02f, -1.36471763e-01f, 1.60585448e-01f, 2.98012555e-01f, -1.66333392e-01f, -1.36235237e-01f, 1.60368949e-01f, 1.54489905e-01f, 1.58847213e-01f,
  2.88601905e-01f, 2.15205252e-01f, 1.81824684e-01f, -2.22526759e-01f, 1.09619416e-01f, 9.00295153e-02f, 1.78089887e-01f, -1.66441649e-01f, 8.89536589e-02f, -3.20777535e-01f,
  -2.54056543e-01f, -2.65249759e-01f, 6.27021194e-02f, -9.06818211e-02f, 1.41378865e-01f, 6.60615191e-02f, -1.49037346e-01f, -2.64433343e-02f, 1.56834960e-01f, -2.07114473e-01f,
  -2.97064632e-01f, 2.55373627e-01f, 1.54167742e-01f, -2.03737691e-01f, 2.13651285e-01f, 1.80782944e-01f, -2.80276000e-01f, -2.19194904e-01f, 6.09956160e-02f, -1.02021299e-01f,
  5.52301109e-03f, 4.98913080e-02f, -4.77645174e-02f, 1.37985662e-01f, 8.16905051e-02f, 4.45053056e-02f, 7.76353851e-02f, -3.82869095e-02f, 2.98471842e-02f, 8.50757435e-02f,
  -1.05431996e-01f, 9.43076164e-02f, 1.63734093e-01f, 1.86625216e-02f, 6.77989721e-02f, 9.50542465e-02f, 2.73978189e-02f, 2.29337544e-04f, 1.37718409e-01f, -1.41135722e-01f,
  5.60256327e-03f, -1.23130530e-01f, 1.71910495e-01f, -8.73704925e-02f, 2.77612911e-04f, -1.87500015e-01f, -1.65853202e-01f, -5.00897840e-02f, -3.40329995e-03f, 6.19247183e-02f,
  -1.45968929e-01f, -6.44772649e-02f, 9.47348401e-02f, 5.95294647e-02f, -4.33440581e-02f, -5.12478426e-02f, 5.64693846e-02f, -2.11073784e-03f, -2.30628159e-03f, 1.39339924e-01f,
  2.06743255e-02f, 5.22706397e-02f, -1.45246238e-02f, -1.14676945e-01f, 1.30661458e-01f, -4.90279831e-02f, 2.10579727e-02f, -3.80249284e-02f, 1.45726547e-01f, 1.12078145e-01f,
  2.77151495e-01f, 1.52674839e-01f, -3.16559374e-01f, 2.21573040e-01f, -1.60419673e-01f, 9.65346843e-02f, -1.41277555e-02f, 3.17838401e-01f, 1.07494302e-01f, 1.35020718e-01f,
  -2.93571115e-01f, -1.92758307e-01f, -2.68185109e-01f, 1.98902518e-01f, -1.55406356e-01f, -1.04555748e-01f, 7.19278827e-02f, 3.30272645e-01f, -1.88409165e-01f, -5.02178036e-02f,
  -1.87709093e-01f, -2.16877535e-01f, -1.52813956e-01f, -1.06891938e-01f, 3.41371708e-02f, 2.04108357e-01f, -6.86980337e-02f, -2.36978590e-01f, 1.45809218e-01f, 2.23639444e-01f,
  1.81554690e-01f, 1.93689793e-01f, 2.54235357e-01f, -1.64533526e-01f, -1.85153872e-01f, 1.78334154e-02f, 1.02798410e-01f, 1.99143037e-01f, -2.17526466e-01f, -2.53126055e-01f,
  2.10393935e-01f, -5.08602057e-03f, 2.77964890e-01f, 1.79607615e-01f, -1.07674748e-01f, -3.05933535e-01f, 2.95611709e-01f, 1.90781832e-01f, -1.14933759e-01f, 1.85291301e-02f,
  1.56007782e-01f, -4.01529856e-02f, -2.23514840e-01f, 5.97137325e-02f, -2.64257267e-02f, 3.54461253e-01f, -3.13306719e-01f, 2.69617498e-01f, -2.13094771e-01f, 3.61826569e-02f,
  1.08589269e-01f, 1.79257825e-01f, -1.20316990e-01f, -3.79271321e-02f, -2.02615619e-01f, -2.03065947e-01f, -2.80869186e-01f, -1.21673867e-01f, -2.82284677e-01f, 2.69874871e-01f,
  -4.63544607e-01f, -3.91921341e-01f, 1.58358619e-01f, 2.70082206e-01f, -2.51743406e-01f, -2.18985006e-01f, -1.15689315e-01f, -4.01793979e-02f, 6.33729715e-03f, -1.72336608e-01f,
  -7.11263195e-02f, -6.66239783e-02f, 1.21957570e-01f, -6.00011647e-02f, 3.67759317e-02f, -6.65734336e-03f, -1.12962037e-01f, 3.37544195e-02f, -6.95483461e-02f, -1.31919369e-01f,
  1.85696874e-02f, -8.24385881e-02f, -8.94878898e-03f, 2.68598944e-02f, 6.91999495e-02f, 3.80548611e-02f, -4.45199870e-02f, -1.90825982e-03f, 5.04910722e-02f, -1.83870103e-02f,
  2.52514035e-02f, 7.58970305e-02f, 3.45558859e-02f, 6.41649961e-02f, -9.66432020e-02f, 8.03498700e-02f, -1.00945793e-01f, 7.92263821e-02f, -8.20520222e-02f, 1.18052334e-01f,
  -6.19795285e-02f, -6.13814853e-02f, 5.42984232e-02f, 8.44393000e-02f, 3.41842473e-02f, -2.19906513e-02f, -3.83719020e-02f, -1.02027640e-01f, 5.53080738e-02f, -6.33034483e-02f,
  -8.44728723e-02f, 3.78581993e-02f, -9.56167355e-02f, -1.06959052e-01f, 9.75321699e-03f, 9.46568400e-02f, -8.45476538e-02f, -6.57649934e-02f, -1.25449955e-01f, 1.45496756e-01f,
  1.28309458e-01f, -7.39895925e-02f, -1.29209101e-01f, -2.83633806e-02f, -2.39032522e-01f, -9.26461667e-02f, 8.12813714e-02f, -1.12693459e-01f, -1.85948655e-01f, -2.51403213e-01f,
  -4.78224680e-02f, -2.18953550e-01f, 1.37150556e-01f, -7.10827336e-02f, 7.80816451e-02f, -1.11904508e-02f, 6.50919527e-02f, 1.34523720e-01f, 1.66764513e-01f, -2.38394335e-01f,
  6.63679931e-03f, -4.91731055e-02f, -1.64031118e-01f, -1.02577060e-01f, -4.83307280e-02f, 1.01091042e-01f, -1.60369143e-01f, -1.94618702e-01f, -8.98612887e-02f, -1.30379140e-01f,
  8.03790335e-03f, -9.59982257e-03f, 1.90595210e-01f, 5.29250652e-02f, -2.97494382e-02f, -1.60064369e-01f, 5.48464060e-02f, 7.14454055e-03f, -1.72114223e-02f, 3.13950814e-02f,
  1.55840889e-01f, 8.94135386e-02f, 1.25420019e-01f, -2.31896475e-01f, 1.86642736e-01f, -2.13417262e-01f, -3.74424234e-02f, 1.45116493e-01f, -3.28304321e-01f, 9.50518474e-02f,
  1.52634695e-01f, -2.03838214e-01f, 2.01233909e-01f, 2.61156112e-01f, 1.04053812e-02f, -2.13091865e-01f, -2.08036333e-01f, -2.89004087e-01f, 1.28499031e-01f, -2.65049279e-01f,
  -1.01506367e-01f, -3.19305718e-01f, 1.95000127e-01f, -2.73409840e-02f, 1.26347132e-02f, 2.35750556e-01f, -1.22739695e-01f, 2.52906755e-02f, 1.10866264e-01f, 2.80452222e-01f,
  -1.82365045e-01f, -4.56333868e-02f, 1.46603376e-01f, -2.82117933e-01f, -1.39199812e-02f, 4.39170562e-02f, 1.51526453e-02f, 6.20618612e-02f, 7.04904133e-03f, 3.49565893e-02f,
  -1.38655812e-01f, -7.15102777e-02f, 6.77945912e-02f, -3.97206917e-02f, -5.15414262e-03f, -6.55749440e-02f, 1.54991634e-02f, 1.07657045e-01f, 9.85424221e-03f, -3.26821022e-02f,
  -6.77786395e-02f, -6.15546247e-03f, -3.29297632e-02f, 8.25607125e-03f, 8.93239304e-02f, 4.27756505e-03f, 6.84235469e-02f, 6.87330775e-03f, -5.90067403e-03f, 3.04214898e-02f,
  5.32431193e-02f, 5.31547740e-02f, -9.70628411e-02f, -6.86185211e-02f, 2.19918322e-02f, -3.68052460e-02f, -5.14595397e-02f, -6.13544546e-02f, -1.03107197e-02f, -1.19315460e-01f,
  -6.14191331e-02f, 5.74826039e-02f, -7.92857036e-02f, -7.14264438e-02f, 3.42395157e-02f, 5.30374274e-02f, -5.37610054e-02f, -9.54032615e-02f, -6.86616870e-03f, -1.05634727e-01f,
  -1.31501704e-01f, -4.17018011e-02f, -1.28008559e-01f, 4.77447771e-02f, -1.74620524e-01f, -1.03060275e-01f, -1.31783292e-01f, -1.74911708e-01f, -2.36908980e-02f, 1.47499785e-01f,
  1.70556139e-02f, 4.60810363e-02f, 4.73442227e-02f, 2.08979294e-01f, 1.89714544e-02f, -1.38509050e-01f, 1.81908533e-01f, 3.01765520e-02f, -2.18959674e-01f, -2.16999337e-01f,
  -1.77987278e-01f, 1.73082098e-01f, -4.62376662e-02f, -8.33816752e-02f, -1.86342433e-01f, -1.14777004e-02f, 5.65613583e-02f, 1.71078369e-01f, -2.84556039e-02f, -1.64708316e-01f,
  7.03397170e-02f, 1.86256811e-01f, -1.93664625e-01f, -1.82359979e-01f, -2.17072442e-01f, 1.95173681e-01f, 1.89530045e-01f, 4.28133607e-02f, -1.78971305e-01f, 1.72228202e-01f,
  -2.85059437e-02f, -1.28769979e-01f, -2.30003253e-01f, 1.77772582e-01f, 1.15345158e-01f, 7.76889995e-02f, 2.07885742e-01f, 1.55975208e-01f, 1.57678068e-01f, 4.44876552e-02f,
  -8.38760734e-02f, -2.27686659e-01f, 6.76507875e-02f, 1.92919850e-01f, -1.29931957e-01f, -5.90435974e-03f, -2.94322073e-02f, -4.17013943e-01f, -2.07618296e-01f, -3.50031495e-01f,
  -2.62534797e-01f, 5.35452776e-02f, -1.61979467e-01f, 1.15876883e-01f, 1.74701557e-01f, -1.14266515e-01f, -2.44211152e-01f, 1.01220263e-02f, 5.76844327e-02f, 1.93738595e-01f,
  6.94653913e-02f, -3.77433985e-01f, 2.17646301e-01f, -1.41071767e-01f, 1.46988511e-01f, 2.35635206e-01f, 2.35877857e-01f, -5.50585054e-02f, 1.45115137e-01f, -2.17055649e-01f,
  1.24906234e-01f, 4.11439426e-02f, -5.91139309e-02f, -7.03565031e-02f, -1.49299890e-01f, 1.34045482e-01f, -9.13962349e-03f, -1.53596818e-01f, -1.14816785e-01f, -9.24684927e-02f,
  -2.23947521e-02f, 6.45588636e-02f, 1.34218544e-01f, 6.60976022e-02f, 6.28332123e-02f, -4.26505320e-02f, -2.90521849e-02f, 6.81660743e-03f, -1.84160873e-01f, 9.05291289e-02f,
  1.80572905e-02f, 7.15377107e-02f, 5.51549271e-02f, 1.13051943e-01f, -1.69521198e-01f, -9.34789777e-02f, -5.85233159e-02f, -9.06118006e-02f, 4.77908403e-02f, 1.29638284e-01f,
  9.83927473e-02f, -8.76951888e-02f, 2.93525215e-02f, 1.84381045e-02f, -8.99590999e-02f, -1.00189760e-01f, -5.99047467e-02f, 1.01209871e-01f, -1.17241122e-01f, -1.78690121e-01f,
  8.45090821e-02f, -9.10637528e-02f, 4.50175889e-02f, 1.46280155e-01f, 6.20796569e-02f, 4.08715755e-02f, 9.11762118e-02f, 1.36909649e-01f, 5.50823361e-02f, 3.52621824e-02f,
  3.64267454e-02f, 6.89118961e-03f, 1.15423210e-01f, 1.35432379e-02f, -3.71012394e-03f, 1.61443084e-01f, 3.06409508e-01f, -2.31209144e-01f, 1.83543682e-01f, -2.05298215e-02f,
  2.42503852e-01f, 3.88773195e-02f, 3.47932912e-02f, -1.46547511e-01f, 5.86507283e-03f, -2.49990180e-01f, 9.98477861e-02f, -3.02678436e-01f, -8.24773461e-02f, 5.74009046e-02f,
  -1.91699207e-01f, -2.52083778e-01f, -1.46540612e-01f, 6.76007792e-02f, -1.21588908e-01f, -1.39210805e-01f, -1.10042311e-01f, -1.59895748e-01f, 1.70113370e-01f, 1.91508710e-01f,
  -3.04519888e-02f, -1.14059575e-01f, 1.01443544e-01f, -2.63321251e-01f, 2.40656257e-01f, 1.29213378e-01f, 7.44816884e-02f, -1.38592497e-01f, 3.63057882e-01f, 8.34542289e-02f,
  -4.63483706e-02f, 2.26483122e-01f, -2.15054542e-01f, -5.94345145e-02f, -2.08104670e-01f, 1.86007485e-01f, -1.79369330e-01f, 2.11959966e-02f, -2.06089560e-02f, 2.71319687e-01f,
  3.79728191e-02f, -1.27246201e-01f, -1.36940420e-01f, 9.43048149e-02f, 2.15231553e-01f, 1.03630133e-01f, 2.98127681e-01f, -2.29970813e-01f, 2.11176679e-01f, -9.82405394e-02f,
  1.33539513e-01f, -2.44572908e-01f, -2.23821267e-01f, -2.06997305e-01f, 1.99162006e-01f, 1.05293378e-01f, -3.00550967e-01f, 1.35244206e-01f, 3.94707806e-02f, 8.90999846e-03f,
  -2.58852452e-01f, 3.02010238e-01f, 1.85445145e-01f, -2.09747851e-01f, -3.56765956e-01f, -3.30242306e-01f, -1.95578113e-01f, -2.88515300e-01f, -4.30189282e-01f, -2.17466265e-01f,
  1.96144924e-01f, 2.18919702e-02f, -3.66220586e-02f, 1.04819246e-01f, -4.95554879e-02f, 1.81001469e-01f, 8.87630656e-02f, 9.81266648e-02f, 1.12515546e-01f, 1.06727630e-01f,
  -8.16890001e-02f, 4.19510603e-02f, 7.94685781e-02f, 1.29064053e-01f, -4.66846414e-02f, 1.28513679e-01f, 9.16752126e-03f, 3.28946253e-03f, -5.96402586e-02f, 2.47914083e-02f,
  -7.10549951e-02f, 4.38256301e-02f, 1.41808420e-01f, 7.14298803e-03f, -5.37589677e-02f, 5.96795529e-02f, 4.21380624e-02f, -7.70041272e-02f, -1.67451560e-01f, 9.03868303e-02f,
  1.14119016e-01f, 1.14316195e-01f, 1.70367047e-01f, -1.38531327e-01f, -4.51843999e-02f, 5.63116521e-02f, -6.60047308e-02f, 9.28110257e-02f, 8.53522494e-02f, -2.59335432e-02f,
  1.37552004e-02f, 9.12069306e-02f, 3.46981362e-02f, 1.45929649e-01f, 1.43681332e-01f, 9.14506391e-02f, 2.04919763e-02f, 1.32490352e-01f, -3.00015472e-02f, -9.66864452e-02f,
  -3.76023687e-02f, 6.96262866e-02f, -1.27504826e-01f, -2.10432991e-01f, -1.04516163e-01f, -2.10448340e-01f, -3.30494754e-02f, -2.96964109e-01f, -1.81355596e-01f, 2.23689973e-01f,
  -2.59692490e-01f, -1.35472715e-01f, -4.67834733e-02f, 2.58758366e-01f, 9.12017897e-02f, -2.07908928e-01f, 2.76487261e-01f, 2.05518574e-01f, -1.66646987e-01f, -8.31418782e-02f,
  2.30542570e-01f, -2.23915383e-01f, -2.58332729e-01f, 1.21452615e-01f, 1.77418724e-01f, 2.06397593e-01f, -1.31926700e-01f, 2.39885852e-01f, 2.49016404e-01f, 1.84335575e-01f,
  -2.24609062e-01f, -1.71238072e-02f, -7.38935964e-03f, -1.29155934e-01f, -1.44176722e-01f, -1.06239170e-01f, -1.36732876e-01f, -1.16463095e-01f, 1.31101320e-02f, 2.85683423e-01f,
  -2.39680737e-01f, 1.08726986e-01f, -2.46773154e-01f, 1.61954030e-01f, -1.59758896e-01f, 1.07122622e-01f, 1.77228138e-01f, -1.58019021e-01f, 5.29618785e-02f, -2.15478092e-01f,
  -1.28046662e-01f, 1.04605546e-02f, -2.90071219e-01f, 2.08612710e-01f, -2.17096969e-01f, 7.90414587e-02f, -2.45256364e-01f, -3.07302982e-01f, -2.69062430e-01f, 1.62865788e-01f,
  1.26868546e-01f, 2.04146951e-01f, -2.83144563e-01f, 2.00383529e-01f, -2.36517549e-01f, -3.22461128e-01f, -7.53337843e-03f, 7.45348930e-02f, -1.60558552e-01f, -1.37195978e-02f,
  2.52036065e-01f, -2.54835747e-02f, -4.20795172e-01f, 7.83848614e-02f, 4.47131470e-02f, 3.97528149e-02f, 1.06396191e-01f, 2.16106977e-02f, -2.13891361e-03f, -7.23002627e-02f,
  -6.74631000e-02f, -1.36499614e-01f, 5.93035445e-02f, -8.14925656e-02f, 1.38143301e-01f, -1.95666477e-02f, -9.78137031e-02f, -8.61753523e-02f, -7.82175437e-02f, -4.01622429e-02f,
  -2.09841356e-02f, -1.67684197e-01f, 3.92243750e-02f, 8.07186589e-02f, 3.91092822e-02f, 1.94741692e-02f, 1.39795421e-02f, -1.20844655e-01f, 1.57391727e-02f, -5.71276061e-02f,
  3.77714261e-02f, 1.43594798e-02f, -7.67190009e-02f, -2.83811074e-02f, 5.12278713e-02f, -2.66452227e-02f, 9.02809724e-02f, 3.29637318e-03f, 1.90830622e-02f, 2.02902816e-02f,
  -4.76365462e-02f, -6.06018081e-02f, 1.05712535e-02f, 7.55505785e-02f, 8.28848481e-02f, -1.25961125e-01f, 3.85762006e-02f, 9.82239470e-02f, 8.57837871e-03f, 1.62329916e-02f,
  -6.82444721e-02f, 3.34486626e-02f, 1.03867725e-01f, 8.25877041e-02f, 6.19620532e-02f, -8.91197100e-02f, -1.05260350e-02f, -1.56870812e-01f, -3.27720419e-02f, 7.30865076e-02f,
  -2.63837636e-01f, -2.14060470e-01f, -2.38867417e-01f, -3.69618786e-03f, 3.82857472e-02f, -2.71127641e-01f, 1.52585655e-01f, -1.45909652e-01f, 1.32528946e-01f, 5.86415678e-02f,
  -2.14993551e-01f, 2.22945154e-01f, 1.68536440e-01f, 2.21603233e-02f, 2.39928663e-01f, 2.13717908e-01f, 1.19384840e-01f, 3.19165021e-01f, -2.19316825e-01f, 2.38539353e-01f,
  -1.29808292e-01f, 6.43653870e-02f, 4.46043350e-02f, 2.31484815e-01f, 1.23327971e-01f, -2.00494826e-01f, -1.05484031e-01f, -1.80908322e-01f, 2.07397446e-01f, 9.39573869e-02f,
  2.00845785e-02f, 8.70215371e-02f, -2.50289291e-01f, -6.94268420e-02f, -1.02898851e-02f, -1.52829826e-01f, 1.36536255e-01f, -9.66854244e-02f, -1.10116780e-01f, 2.27139145e-01f,
  -1.61456242e-01f, -1.92045525e-01f, 1.23323806e-01f, -2.29338527e-01f, 3.84888165e-02f, 2.13450849e-01f, 1.98609874e-01f, -2.10644037e-01f, -6.12074584e-02f, 4.68957946e-02f,
  2.07122624e-01f, 2.91767716e-01f, -2.30810165e-01f, -3.41666132e-01f, -3.42334032e-01f, -2.30947778e-01f, -4.07071412e-01f, -5.71423434e-02f, 7.43312910e-02f, -2.62276769e-01f,
  -2.29054078e-01f, 8.07939991e-02f, -1.58933714e-01f, 9.83972847e-02f, 5.96357621e-02f, -1.51758075e-01f, 2.26115137e-01f, 2.65846282e-01f, -3.08775961e-01f, 6.40127435e-02f,
  1.77752927e-01f, -2.90704608e-01f, 4.33402285e-02f, 2.73752183e-01f, 1.02541946e-01f, -3.26470196e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.38251777e-02f, 4.17801850e-02f, 6.84822500e-02f, 4.57982607e-02f, 6.58928007e-02f, -4.00223862e-03f, 7.20217302e-02f, -4.78253402e-02f, -5.99968694e-02f, 7.05925450e-02f,
  6.40719905e-02f, 6.84857294e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    