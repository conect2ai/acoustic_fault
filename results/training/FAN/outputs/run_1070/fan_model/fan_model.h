/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.97315270e-01f, -1.58092137e-02f, -5.09771671e-05f, 2.07237676e-02f, -7.14662150e-02f, 4.42228913e-02f, -1.71343125e-02f, -5.18092839e-03f, 3.55960429e-02f, 5.36513813e-02f,
  4.26163245e-03f, -8.46831799e-02f, -6.62768558e-02f, 1.68186147e-02f, 6.80453936e-03f, 8.16390216e-02f, -1.09726883e-01f, -1.51147153e-02f, -3.76017671e-03f, -4.31091040e-02f,
  -8.40629339e-02f, -3.70218381e-02f, -3.32496576e-02f, -7.85652697e-02f, -2.28296176e-01f, -1.25665497e-02f, -1.01724066e-01f, -6.86270371e-03f, -3.89618725e-02f, -2.17599705e-01f,
  9.81146097e-03f, 8.44256282e-02f, 1.15342200e-01f, -2.41645449e-03f, 1.45272417e-02f, -2.35067774e-02f, 7.36790076e-02f, -7.43226260e-02f, 1.98012963e-02f, -5.65443449e-02f,
  -9.68525335e-02f, 4.94967811e-02f, -9.39483941e-02f, -9.21435058e-02f, -6.13226928e-02f, 2.12233770e-03f, -7.05556050e-02f, -7.11096004e-02f, -6.13188110e-02f, -5.35994442e-03f,
  -1.64574146e-01f, 1.25571378e-02f, 1.08154945e-01f, -1.77834332e-02f, -2.85581853e-02f, 1.26645714e-01f, -3.01753357e-02f, 1.20982649e-02f, 1.25453100e-01f, -3.42545696e-02f,
  -1.90992616e-02f, 2.68846168e-03f, -5.57273999e-02f, -8.74260999e-03f, -3.21747065e-02f, -1.74173266e-02f, -1.11698069e-01f, -9.78534296e-02f, 2.16545910e-02f, -4.69910651e-02f,
  2.54051685e-02f, 4.49828943e-03f, -4.51096930e-02f, 3.73727679e-02f, -6.57830164e-02f, 3.99321504e-02f, 3.95793021e-02f, 1.29601164e-02f, -9.92892459e-02f, 1.81996617e-02f,
  6.70935512e-02f, -7.93577638e-03f, -8.53370503e-02f, -8.15291777e-02f, -6.64400263e-03f, -9.87328663e-02f, 5.09807430e-02f, -7.77254114e-03f, 4.17850502e-02f, -5.26993237e-02f,
  4.16731834e-02f, 1.52376220e-01f, -1.53553747e-02f, -3.48795727e-02f, -3.15055884e-02f, 2.09387485e-02f, -4.35347520e-02f, 7.78047880e-03f, -4.46386598e-02f, -3.89953367e-02f,
  3.48707251e-02f, 2.31277496e-02f, 4.28203773e-03f, -1.08806781e-01f, -6.09573349e-02f, -6.61084205e-02f, -5.12301736e-02f, 1.97920632e-02f, 2.74822898e-02f, -1.70499444e-01f,
  -7.21303234e-03f, 5.15269414e-02f, 1.57011226e-01f, -1.71858240e-02f, 7.76100829e-02f, 1.47247508e-01f, -3.39535922e-02f, 3.64062488e-02f, 1.52083993e-01f, 1.46947548e-01f,
  -1.36724204e-01f, 8.64643604e-02f, 1.91634595e-01f, -7.27317035e-02f, 6.10626899e-02f, 1.03964604e-01f, 9.56661478e-02f, -1.18508767e-02f, 6.25377595e-02f, 6.42132685e-02f,
  7.50687486e-03f, -8.62329379e-02f, -2.68525053e-02f, 1.20151624e-01f, 1.50002539e-01f, 3.13569725e-01f, 2.67580479e-01f, 2.06388235e-01f, 1.54237062e-01f, 7.84017071e-02f,
  7.89672509e-03f, 9.54545289e-02f, 7.89989531e-02f, 1.44523367e-01f, 1.45557269e-01f, 7.92773068e-02f, 9.57832411e-02f, 4.97025214e-02f, 1.72319382e-01f, 3.37021589e-01f,
  2.11826801e-01f, -8.90936255e-02f, 7.44536379e-03f, -2.01338101e-02f, 1.12955878e-02f, -7.81359267e-04f, 4.19256799e-02f, 3.87411453e-02f, -4.85055335e-02f, 1.28286397e-02f,
  -4.45464700e-02f, 7.90014192e-02f, 6.16658255e-02f, 1.38647094e-01f, 4.91774864e-02f, -2.66798097e-03f, -3.59253888e-03f, 1.46620438e-01f, 6.62917411e-03f, 9.75725651e-02f,
  2.15680674e-02f, 2.40585953e-02f, 9.68805701e-03f, -4.28193286e-02f, 4.36164550e-02f, -4.22746316e-02f, 2.27957014e-02f, 6.37401566e-02f, -3.41922715e-02f, 1.22393541e-01f,
  -7.38419443e-02f, 4.20334153e-02f, -3.24844159e-02f, -4.11668345e-02f, -1.35537069e-02f, -2.11528651e-02f, 6.24133945e-02f, 7.56915137e-02f, 1.90726686e-02f, 6.20593466e-02f,
  1.07053570e-01f, -1.04299383e-02f, 3.65072526e-02f, 6.67231008e-02f, 6.19035698e-02f, 8.73345062e-02f, -2.98423804e-02f, 4.93074693e-02f, 2.58082151e-02f, -2.01118607e-02f,
  4.22919579e-02f, 5.29875904e-02f, 1.03781596e-02f, 1.29753470e-01f, -6.27108791e-04f, 2.00871844e-03f, -1.80053525e-02f, 2.99092233e-02f, -2.86402069e-02f, -3.82445641e-02f,
  -1.44532770e-02f, -1.00562468e-01f, 6.84050769e-02f, 1.31228790e-01f, 3.32488790e-02f, 1.21690705e-01f, -4.45150863e-03f, 4.76461351e-02f, -6.73787808e-03f, 3.06424149e-03f,
  5.89259118e-02f, -1.86248273e-02f, 5.63189946e-03f, 1.50283650e-01f, 4.69322950e-02f, 1.09870568e-01f, -2.51879282e-02f, 4.12996635e-02f, 1.58207044e-01f, 8.86676088e-02f,
  1.20475397e-01f, 1.01537369e-01f, 4.55100201e-02f, 1.70119449e-01f, 1.42272651e-01f, 1.05880629e-02f, 9.68512520e-02f, 1.57557875e-01f, 1.08084805e-01f, 7.08978251e-02f,
  -1.00169279e-01f, 1.45046979e-01f, -8.99767429e-02f, -8.81516188e-03f, 1.29409134e-01f, 3.55798692e-01f, 4.15004432e-01f, 3.01208019e-01f, 8.88286084e-02f, 1.13254935e-01f,
  3.23609002e-02f, -1.26734585e-01f, -1.22877799e-01f, 4.79986630e-02f, 1.37661725e-01f, 1.36233225e-01f, 1.18791990e-01f, -4.28494625e-02f, 2.96831857e-02f, 2.19368756e-01f,
  2.32198924e-01f, -6.01709224e-02f, -7.34198317e-02f, 3.96799855e-02f, 5.46628516e-03f, -1.31049950e-03f, 5.59166819e-03f, 1.20731182e-01f, 6.29985332e-02f, 8.34798217e-02f,
  -1.27095252e-01f, 7.12654069e-02f, 9.19955671e-02f, -4.54145819e-02f, 2.37773322e-02f, 3.36400010e-02f, 2.40612812e-02f, -8.42379332e-02f, -1.37875825e-02f, 8.13667253e-02f,
  -2.63072327e-02f, 1.05119599e-02f, -1.18665770e-02f, 1.53989056e-02f, 6.12690486e-03f, 1.11251876e-01f, 1.19444400e-01f, 5.75060323e-02f, 2.03074235e-02f, 1.24630623e-01f,
  6.93043247e-02f, 1.20334953e-01f, 1.16064353e-02f, 1.92370370e-01f, 1.23049200e-01f, 4.45613591e-03f, 5.20643629e-02f, 5.56356013e-02f, 4.14186679e-02f, 1.50681689e-01f,
  -3.62657174e-03f, -9.67085958e-02f, -8.17377344e-02f, 6.13010488e-03f, -4.99036014e-02f, -6.81904405e-02f, -6.88096136e-02f, -3.43825258e-02f, -9.84724313e-02f, -1.18267231e-01f,
  -3.61012407e-02f, -5.06081097e-02f, -4.36070114e-02f, -1.44193256e-02f, -9.08896625e-02f, -8.47601816e-02f, -5.88870235e-02f, -2.74496991e-02f, -8.63042176e-02f, -2.45125629e-02f,
  -4.16595973e-02f, -4.03735936e-02f, -7.28392527e-02f, -5.14206626e-02f, -4.63712551e-02f, -2.92618461e-02f, -6.85893148e-02f, -1.50883198e-01f, -1.46448016e-01f, -5.10102846e-02f,
  -7.57895634e-02f, -7.10744550e-03f, -7.00683296e-02f, 7.29306117e-02f, 7.39549380e-03f, 2.78849136e-02f, 5.63460216e-03f, 6.86354041e-02f, 2.23049466e-02f, 5.86877391e-03f,
  7.28959367e-02f, 8.82859230e-02f, 3.37626114e-02f, 9.97629836e-02f, 1.11492857e-01f, 7.90780857e-02f, 2.65195724e-02f, 2.61048954e-02f, 1.14388555e-01f, 3.74973193e-02f,
  1.39881641e-01f, 1.07866943e-01f, -3.30946557e-02f, 8.43822137e-02f, 1.27676129e-01f, -4.97096684e-04f, 1.03981808e-01f, 1.34501591e-01f, 4.33894657e-02f, 8.22921246e-02f,
  1.72991888e-03f, -5.36366226e-03f, -2.93343365e-01f, 3.87016162e-02f, -1.30158678e-01f, -2.03933865e-01f, -3.57208341e-01f, -8.06844458e-02f, 1.42762870e-01f, -1.16304807e-01f,
  2.65094321e-02f, 1.87263161e-01f, 1.58004984e-01f, 1.74029887e-01f, -6.63262755e-02f, -2.35866189e-01f, -1.50546312e-01f, -1.23844795e-01f, -4.28712554e-02f, 1.02348745e-01f,
  6.44683614e-02f, 3.07217725e-02f, 4.17618938e-02f, 8.77994746e-02f, 1.06831163e-01f, 5.45185246e-02f, 3.19764949e-02f, 3.83999981e-02f, -8.48273113e-02f, 2.24577282e-02f,
  -1.24902144e-01f, -9.71736461e-02f, -1.44070446e-01f, 4.35990393e-02f, -9.33603123e-02f, -3.59031819e-02f, -8.63191262e-02f, 2.01796554e-02f, -7.47114560e-03f, -1.19393528e-01f,
  -5.41819893e-02f, 1.09223202e-02f, 8.71868506e-02f, -7.70253362e-03f, -3.01460214e-02f, -3.42342556e-02f, 1.32282376e-02f, 8.20416510e-02f, 2.40339059e-02f, 1.27460435e-03f,
  -4.44038585e-02f, -1.36324186e-02f, -1.86404794e-01f, -6.09577112e-02f, 4.87896288e-03f, -1.18692532e-01f, -8.51498097e-02f, -1.57912225e-02f, -9.09801573e-02f, -4.26988192e-02f,
  3.92275713e-02f, 1.20159350e-01f, 1.64570630e-01f, 1.51976466e-01f, 1.15835480e-01f, 1.33284524e-01f, 9.91409644e-02f, 2.70678084e-02f, 9.49206203e-02f, 1.44421622e-01f,
  1.57727778e-01f, 9.42721739e-02f, 1.14343345e-01f, 9.47678611e-02f, 1.09128743e-01f, 1.43596247e-01f, 1.35908350e-01f, 1.62488401e-01f, 1.28834993e-01f, 1.56352356e-01f,
  1.45974949e-01f, 3.60558815e-02f, 1.27511144e-01f, 1.07580900e-01f, 1.73649237e-01f, 1.18592121e-01f, 1.00606598e-01f, 5.85739277e-02f, 5.16534001e-02f, 1.15975313e-01f,
  1.54809207e-01f, -2.20494404e-01f, -8.15746114e-02f, -2.59261467e-02f, -9.88269132e-03f, 2.72916295e-02f, -4.58833762e-02f, 2.68964544e-02f, -3.91793735e-02f, -3.91925080e-03f,
  -4.93629314e-02f, -7.39391893e-02f, -7.70040676e-02f, -2.95344070e-02f, 2.94560082e-02f, 1.20600744e-03f, -1.19364802e-02f, -6.24520816e-02f, 2.83266585e-02f, 8.64496529e-02f,
  -1.73557792e-02f, -1.99965518e-02f, -1.69740856e-01f, -5.49577102e-02f, -1.00026168e-01f, -1.44651592e-01f, -6.69782758e-02f, -5.04072309e-02f, -1.55405492e-01f, -2.19787166e-01f,
  5.24853263e-03f, 1.61450654e-01f, 3.28980058e-01f, 8.50536302e-02f, 9.78345349e-02f, 5.85890897e-02f, 9.92825925e-02f, -7.33513385e-02f, -1.21574633e-01f, 6.04578070e-02f,
  7.48450980e-02f, -1.65314853e-01f, -1.51327148e-01f, -1.47004783e-01f, -2.13314131e-01f, 5.62849753e-02f, 5.89644797e-02f, -1.07520908e-01f, -2.30802611e-01f, -1.13647640e-01f,
  -1.42212035e-02f, -6.59564584e-02f, -1.73197594e-02f, -5.24774976e-02f, 9.23430622e-02f, -9.85844508e-02f, 2.51862407e-01f, 1.92958787e-01f, 1.34373486e-01f, 2.49159515e-01f,
  2.71561235e-01f, 2.11107120e-01f, -1.21452659e-01f, -1.00580573e-01f, 1.83690488e-01f, -2.00720550e-03f, 2.73967162e-02f, 1.01723082e-01f, 2.93290266e-03f, 9.02834311e-02f,
  4.33023311e-02f, 8.61752592e-03f, -2.42846608e-02f, 1.00555494e-02f, 5.32823987e-02f, 8.60343277e-02f, 1.32878765e-01f, 7.77374655e-02f, 7.93739595e-03f, 1.10246412e-01f,
  7.40756914e-02f, 1.66788176e-01f, 1.34011790e-01f, 7.04023764e-02f, -1.37017062e-02f, -1.37848437e-01f, 1.02682918e-01f, -5.37161808e-03f, 4.08424102e-02f, 1.60932183e-01f,
  -1.06888585e-01f, -1.93106551e-02f, -9.31436568e-03f, -3.70622724e-02f, 3.18273269e-02f, -2.10194048e-02f, -3.06883641e-02f, 4.18530926e-02f, -7.77132660e-02f, 3.90618108e-02f,
  -6.15988597e-02f, -2.45062243e-02f, -2.26258598e-02f, 9.09217517e-04f, -2.15000566e-02f, 8.73379596e-03f, 1.70715414e-02f, -4.79374230e-02f, -3.61638260e-03f, 6.93237856e-02f,
  4.20151912e-02f, -1.06566036e-02f, 5.23396917e-02f, -2.21786294e-02f, 1.06133716e-02f, -1.15457531e-02f, -1.88620517e-03f, -8.98127481e-02f, -4.34402078e-02f, 4.00001667e-02f,
  -9.08263922e-02f, -6.06528530e-03f, 1.81362424e-02f, -3.50577086e-02f, 1.00626841e-01f, 2.30932720e-02f, 1.07261784e-01f, 2.45340057e-02f, 6.71274140e-02f, 4.53235582e-02f,
  2.71957126e-02f, -6.46073371e-02f, 9.58932415e-02f, 8.02236050e-03f, 4.46893536e-02f, 7.57560832e-03f, -2.45847218e-02f, -1.01828389e-03f, 1.84605252e-02f, 8.28661695e-02f,
  -2.13347822e-02f, -7.11601600e-02f, -1.37452617e-01f, -5.42834289e-02f, -4.02489379e-02f, -1.41896889e-01f, 5.40372282e-02f, -2.41615903e-02f, -2.37579010e-02f, 3.00653707e-02f,
  2.66425222e-01f, 5.64793684e-03f, 2.69950867e-01f, -2.21787840e-02f, -2.18518218e-03f, -3.21104005e-02f, -8.89182761e-02f, -1.21651672e-01f, -3.60032842e-02f, 8.40332061e-02f,
  -6.45803809e-02f, -1.54310733e-01f, 3.84687074e-02f, -8.93711001e-02f, -3.76793183e-02f, -3.75434160e-02f, -1.91071257e-02f, 1.50891110e-01f, 1.09113902e-01f, -4.65137698e-02f,
  -2.07580805e-01f, -8.88847932e-02f, -6.10595522e-03f, -4.40225452e-02f, -2.82406975e-02f, 5.72726391e-02f, 1.19087741e-01f, 1.60510987e-01f, 1.40606835e-01f, -2.71307509e-02f,
  2.27657288e-01f, 1.33630827e-01f, -5.60334511e-03f, -8.39918032e-02f, 7.38994032e-02f, 4.48441356e-02f, 8.61783624e-02f, 7.36960024e-02f, 1.21079676e-01f, 1.94644742e-03f,
  1.07248962e-01f, 6.25954568e-02f, -1.16976518e-02f, -4.10859361e-02f, 6.77705780e-02f, -2.55573541e-02f, 7.48802423e-02f, 1.16653539e-01f, 1.10716298e-02f, -5.01670018e-02f,
  1.09424628e-02f, 3.78207341e-02f, 1.92490041e-01f, 7.71857724e-02f, -1.21179298e-02f, 1.46068543e-01f, 1.49982259e-01f, 2.35488862e-02f, 1.74342498e-01f, 1.65256321e-01f,
  4.91169421e-03f, 4.42746133e-02f, -1.12710148e-01f, 6.46449178e-02f, -8.29786435e-02f, -4.64965105e-02f, 1.00083975e-03f, -5.65115176e-02f, -6.75890595e-02f, -1.45705547e-02f,
  -3.88630852e-02f, 9.17547941e-03f, 1.67802369e-04f, -6.23433143e-02f, -7.12136403e-02f, -6.06042631e-02f, -5.66987693e-02f, -2.85951830e-02f, 4.38714586e-02f, -3.67589928e-02f,
  -4.67829257e-02f, 2.00439505e-02f, -7.29824649e-03f, -8.85034651e-02f, -5.10774693e-03f, -1.26770046e-03f, -6.75697327e-02f, -5.50021641e-02f, -1.13192406e-02f, -5.70457242e-02f,
  -1.20213360e-01f, 5.56794405e-02f, 5.16477302e-02f, -6.01203255e-02f, 1.05786324e-01f, -2.69180257e-02f, 4.10752445e-02f, -6.89597859e-04f, -1.74569115e-02f, 9.93794948e-02f,
  8.30551386e-02f, 2.08408050e-02f, 4.65813279e-02f, 1.71646243e-03f, 4.53538634e-02f, 4.53568548e-02f, -3.70127745e-02f, -7.16315722e-03f, -5.82143739e-02f, 8.88627023e-02f,
  -8.38936567e-02f, 9.21062008e-02f, 1.39898635e-04f, 1.32890597e-01f, 1.00987159e-01f, 1.16134211e-01f, 1.46559209e-01f, 1.49465591e-01f, 1.26594871e-01f, 1.70230251e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.08188704e-01f, -4.40905213e-01f, 3.17616522e-01f, -6.58066869e-02f, 1.92642838e-01f, 2.90768862e-01f, 2.60745287e-01f, 8.11664015e-02f, -8.42213351e-03f, 1.68138310e-01f,
  -2.37035722e-01f, -2.20601335e-01f, -1.32779226e-01f, -2.07560569e-01f, -1.59409732e-01f, 1.99234217e-01f, 1.44651666e-01f, 6.36624321e-02f, 1.61018729e-01f, 8.64983350e-02f,
  -2.13020109e-02f, 5.41321151e-02f, -5.86730316e-02f, -9.70989466e-02f, -6.32717833e-02f, 1.86461303e-02f, 1.37784466e-01f, -1.21782206e-01f, -1.15910307e-01f, 5.95441088e-02f,
  3.51254404e-01f, -3.31598997e-01f, -3.56991950e-04f, -3.52967918e-01f, 6.99238665e-03f, -5.52053517e-03f, 1.42781353e-02f, -4.59809862e-02f, -1.67401150e-01f, 2.10193023e-02f,
  -1.62324049e-02f, -1.82504460e-01f, -2.64232606e-01f, 2.96944734e-02f, -2.43511121e-03f, 7.76320472e-02f, -1.95492551e-01f, -1.57711610e-01f, -1.43093675e-01f, -8.37815255e-02f,
  -2.59300143e-01f, -5.24358116e-02f, 1.31592676e-01f, 1.52996778e-02f, -8.56465311e-04f, -5.01734316e-02f, 1.20033987e-01f, -8.10945034e-02f, -2.10276935e-02f, 1.11384474e-01f,
  1.68434158e-02f, 1.81307927e-01f, -1.37788998e-02f, 3.87661047e-02f, -1.59045495e-02f, -9.76093486e-03f, 4.55338173e-02f, 4.40402701e-02f, 1.52807370e-01f, 1.44726768e-01f,
  -3.42000760e-02f, 1.11148305e-01f, 1.87134042e-01f, 7.07861129e-03f, -2.66195592e-02f, 6.79722503e-02f, -5.73948538e-03f, -4.98608276e-02f, -8.77388865e-02f, 5.41329347e-02f,
  -1.72803749e-03f, 1.99143067e-02f, 3.80629338e-02f, -6.55065328e-02f, -5.29881306e-02f, 2.18634680e-02f, 5.07708043e-02f, -9.72252265e-02f, -1.08910412e-01f, -1.21094532e-01f,
  2.73703873e-01f, -2.97817051e-01f, 6.81470260e-02f, -1.08494461e-01f, -8.09489575e-06f, -1.50146887e-01f, -8.48286077e-02f, -6.40050918e-02f, 5.50709181e-02f, 3.19158807e-02f,
  -1.78071409e-01f, -1.32373527e-01f, -9.08911079e-02f, -7.36920387e-02f, 1.78785637e-01f, 1.95677001e-02f, -1.49934441e-01f, 3.29122171e-02f, -2.66689193e-02f, 6.26438335e-02f,
  -3.66547257e-02f, 1.95833743e-02f, 2.58049369e-01f, 1.49697006e-01f, 1.47620048e-02f, 1.56558469e-01f, 2.30633140e-01f, 2.79500723e-01f, 1.74758002e-01f, 2.33312920e-01f,
  -2.76407860e-02f, -2.74817228e-01f, 2.09631950e-01f, 1.15703754e-01f, 1.15758374e-01f, -1.59044474e-01f, -2.86297858e-01f, -1.34706423e-01f, -5.08165509e-02f, -5.17573208e-03f,
  -6.22529946e-02f, 1.99050814e-01f, 2.28940308e-01f, 2.23189682e-01f, 1.45427495e-01f, 1.69049188e-01f, 3.01217169e-01f, 4.03534144e-01f, 1.60270929e-01f, 2.52776649e-02f,
  2.23780423e-02f, 1.57829404e-01f, 2.05646411e-01f, 2.57320523e-01f, 9.36547890e-02f, 1.60342962e-01f, 1.41814947e-01f, 6.23216033e-02f, 5.13354056e-02f, 3.32284540e-01f,
  2.48863548e-01f, -9.71559212e-02f, 1.23428799e-01f, 6.33993000e-02f, 3.44766788e-02f, -1.42043214e-02f, 1.30870985e-02f, -1.00328200e-01f, -1.41505420e-01f, -2.50287652e-02f,
  -1.56737156e-02f, 9.57014691e-03f, -6.37977123e-02f, -1.74176935e-02f, -3.62780616e-02f, -1.18959531e-01f, -1.05086058e-01f, -8.04605633e-02f, -2.81702392e-02f, -1.22364154e-02f,
  -7.77870491e-02f, -8.41560289e-02f, -9.57775563e-02f, -8.13370496e-02f, 1.35921338e-03f, -4.89651076e-02f, -1.83010191e-01f, 2.35175411e-03f, -4.04298753e-02f, -1.29607692e-01f,
  2.15906397e-01f, -1.24539647e-05f, 2.93033030e-02f, -2.47355178e-02f, -1.68121755e-01f, -1.28289968e-01f, 8.15904886e-02f, 6.17325380e-02f, 1.49170803e-02f, -1.20858647e-01f,
  -6.97096512e-02f, 2.38746945e-02f, 3.04270536e-02f, 8.02434683e-02f, 7.95438886e-02f, 1.69043783e-02f, -7.33421892e-02f, -8.01291168e-02f, -7.46085122e-02f, -1.54577479e-01f,
  5.14942445e-02f, 3.72851305e-02f, -4.25740667e-02f, -6.07365258e-02f, -7.58882463e-02f, 2.97838897e-02f, 3.45509648e-02f, 3.81798409e-02f, -2.11300068e-02f, 6.93561584e-02f,
  -8.22507441e-02f, 2.20705494e-01f, 2.64738709e-01f, 3.53248715e-02f, 4.00893204e-02f, -9.16812867e-02f, 1.50874898e-01f, 7.78883602e-03f, 5.57852164e-02f, 4.44253534e-02f,
  -5.65333255e-02f, 5.34812845e-02f, -8.63764510e-02f, -1.30387515e-01f, 2.46681981e-02f, -2.18390748e-02f, -4.05399799e-02f, -2.71918718e-02f, 9.67357680e-02f, 5.40862530e-02f,
  -9.09150764e-02f, 8.83282721e-02f, 1.67559549e-01f, 1.32780552e-01f, 1.19478412e-01f, 1.48714617e-01f, 2.13363692e-02f, -7.66770989e-02f, -9.90040321e-03f, 2.06185561e-02f,
  -2.46915087e-01f, 2.80109167e-01f, -1.46890208e-02f, -2.65233159e-01f, -2.73049921e-01f, -6.32258728e-02f, 4.09358293e-01f, -7.76481479e-02f, -2.76740134e-01f, 2.57691771e-01f,
  9.92147401e-02f, -2.04434544e-01f, -8.13475400e-02f, -9.47926193e-02f, 1.11037746e-01f, 3.57946545e-01f, 1.64649673e-02f, -1.34745210e-01f, -3.42436641e-01f, -2.55392879e-01f,
  -1.02272719e-01f, -3.06223314e-02f, -1.34315193e-01f, -2.30730340e-01f, -1.93953052e-01f, -2.26866364e-01f, -6.57727718e-02f, -4.95004170e-02f, -1.16880305e-01f, -1.34951025e-01f,
  2.37401247e-01f, -4.09953110e-02f, -9.87670049e-02f, -8.61219540e-02f, -1.74864277e-01f, -7.60492980e-02f, -8.19600448e-02f, -1.37166798e-01f, -9.30145606e-02f, -2.85138283e-02f,
  -1.47798032e-01f, -8.09994489e-02f, 5.79954498e-02f, 3.27242091e-02f, 2.87124552e-02f, -2.45698597e-02f, -2.69175600e-03f, -1.93493441e-01f, -1.06359564e-01f, -1.08074956e-01f,
  -1.27436668e-01f, -9.95210111e-02f, 2.18118671e-02f, -1.25559375e-01f, -5.11457622e-02f, -1.96839243e-01f, -9.64248832e-03f, -1.98866799e-01f, -1.67424738e-01f, 1.22472115e-01f,
  -1.13242202e-01f, 6.05557561e-02f, 1.52653102e-02f, 4.38876823e-02f, 1.43864557e-01f, -3.43181789e-02f, 5.09037413e-02f, 4.49796952e-02f, -1.37526658e-03f, -1.58828660e-03f,
  6.37371615e-02f, 1.56309038e-01f, 6.14783242e-02f, 1.89161107e-01f, 8.65264013e-02f, 3.98835763e-02f, 4.01102677e-02f, 9.63148400e-02f, 7.40229338e-02f, -7.81315863e-02f,
  -1.31431565e-01f, -8.39999411e-03f, -9.36750323e-02f, 1.46823004e-01f, -4.58491705e-02f, 2.22249441e-02f, 1.03299312e-01f, -5.16823567e-02f, -1.12658152e-02f, -8.56191758e-03f,
  2.23128036e-01f, 5.85062951e-02f, 1.59796521e-01f, -6.22618198e-02f, 1.81631278e-02f, -1.27183750e-01f, 8.96366388e-02f, 1.47193167e-02f, 6.99596107e-03f, 1.44855469e-01f,
  -5.47541901e-02f, 1.32507071e-01f, 5.63348271e-02f, -1.34622389e-02f, -5.62639385e-02f, 2.13289019e-02f, 6.87674433e-02f, -4.39647175e-02f, 5.07780947e-02f, -2.26416290e-02f,
  1.99535824e-02f, 6.75291270e-02f, 1.25266671e-01f, 1.66803956e-01f, -2.76894532e-02f, -9.10964310e-02f, 1.23874947e-01f, 1.18952960e-01f, -1.89367887e-02f, 3.69364172e-01f,
  6.74436331e-01f, 9.32316557e-02f, 2.50534952e-01f, 1.75369889e-01f, 2.70844251e-01f, 1.62720904e-01f, 1.72616988e-01f, 5.19242473e-02f, 4.90351059e-02f, 7.02958405e-02f,
  8.32903683e-02f, 1.00494750e-01f, 1.82535592e-02f, -1.53261302e-02f, 1.99509636e-02f, -2.65884642e-02f, 5.18880598e-02f, 9.41418484e-02f, 2.33163431e-01f, 1.40934736e-01f,
  9.19197202e-02f, 1.61421269e-01f, 7.88660944e-02f, -5.89197129e-02f, -6.51791617e-02f, 1.89703889e-02f, 3.73416580e-02f, 6.63359538e-02f, -6.30915314e-02f, -6.25345036e-02f,
  -1.77318111e-01f, 8.11734721e-02f, 1.38525993e-01f, 2.57420616e-04f, -8.21173266e-02f, -2.37511732e-02f, -8.77525471e-03f, -1.17559545e-01f, -1.04488127e-01f, -1.00200646e-01f,
  -5.22337779e-02f, -1.04548797e-01f, -5.15976101e-02f, -1.62202835e-01f, 3.19653340e-02f, 2.98378877e-02f, -4.32773940e-02f, -6.53361753e-02f, 2.39321534e-02f, 1.46952765e-02f,
  -7.46797323e-02f, 1.24951504e-01f, 3.32445465e-02f, -6.93787634e-02f, -5.38636521e-02f, 4.85750427e-03f, 4.80441051e-03f, -2.63353065e-02f, 1.27347186e-01f, -2.49789301e-02f,
  8.12605396e-02f, 7.13661462e-02f, 1.97335824e-01f, 4.53488939e-02f, 9.26502869e-02f, -2.95776986e-02f, -5.97617701e-02f, -3.52099463e-02f, 7.99982809e-03f, 6.55645281e-02f,
  -2.96707470e-02f, 1.18604131e-01f, -7.40369111e-02f, 3.53705660e-02f, 1.58240542e-01f, 1.14453197e-01f, -9.00921300e-02f, -1.21231079e-01f, 4.38646488e-02f, -2.88454629e-02f,
  2.97806654e-02f, -6.06266968e-02f, -1.24909058e-01f, -1.79058254e-01f, 1.43438764e-02f, 1.20807728e-02f, 1.66875914e-01f, -1.40119549e-02f, -9.52064805e-03f, 4.75328527e-02f,
  -3.06667358e-01f, 1.17585324e-01f, -6.54242709e-02f, -1.09489210e-01f, -1.01585828e-01f, -5.13612516e-02f, 8.19699168e-02f, -1.54723808e-01f, -1.25506654e-01f, -6.75582066e-02f,
  -9.37132463e-02f, -2.48161033e-02f, -4.12947573e-02f, -1.11309238e-01f, -4.47512493e-02f, -7.64502361e-02f, -1.28385991e-01f, 1.79568641e-02f, -3.20579633e-02f, -1.18936531e-01f,
  -1.17987245e-01f, 9.44448262e-02f, 1.23567916e-01f, 8.10399577e-02f, -7.39351809e-02f, 1.25549987e-01f, -2.26145629e-02f, -5.71143143e-02f, 5.40566891e-02f, 1.60506561e-01f,
  -2.03062743e-01f, -3.85767460e-01f, -1.57449841e-01f, -3.56160522e-01f, -2.37465099e-01f, -8.53288826e-03f, -3.12662959e-01f, -5.73810935e-02f, -5.62295690e-02f, -2.89747953e-01f,
  -1.82977393e-02f, 9.98244211e-02f, -2.60144426e-03f, 1.33499026e-01f, 1.67347088e-01f, -3.52998406e-01f, -2.27421820e-01f, 4.53100987e-02f, 2.97830015e-01f, 2.43487909e-01f,
  -2.50790510e-02f, 3.22038345e-02f, 1.66382015e-01f, 8.87774862e-03f, -2.74663329e-01f, 2.70924624e-02f, -2.06785664e-01f, -1.31928355e-01f, 6.15492184e-03f, -4.15558159e-01f,
  -1.48204148e-01f, -1.84189290e-01f, 1.36389315e-01f, 1.63204148e-01f, -1.41299674e-02f, 5.32050058e-02f, -2.40271538e-02f, -4.82401159e-03f, 4.58618924e-02f, -6.98840320e-02f,
  2.29378697e-02f, 1.37010738e-01f, -3.21650691e-02f, 6.56392798e-02f, 5.47806211e-02f, 1.10639818e-01f, 1.01710372e-02f, 7.37466663e-02f, -6.48678616e-02f, -5.66188134e-02f,
  -2.18690291e-01f, -1.26553744e-01f, -3.56641933e-02f, 4.17256430e-02f, 1.42995372e-01f, 3.96327376e-02f, 8.65992159e-02f, 3.21771950e-02f, 4.39353436e-02f, -2.66389996e-01f,
  -1.54616712e-02f, 8.17978010e-02f, 2.51248237e-02f, -9.51794684e-02f, -2.96525620e-02f, -4.96522821e-02f, -2.99788397e-02f, -5.54754138e-02f, 1.35095045e-03f, 1.65946204e-02f,
  2.26570424e-02f, -2.26471014e-02f, -3.98642123e-02f, -4.78131808e-02f, -7.53639713e-02f, -7.31611550e-02f, -4.27780785e-02f, 3.80249806e-02f, -2.90601198e-02f, 6.23859577e-02f,
  6.20345818e-03f, 1.52200251e-03f, -1.06511228e-01f, 1.49345668e-02f, -4.13553417e-02f, -3.96011584e-02f, 1.82075277e-02f, 1.53035894e-01f, 7.06648901e-02f, -2.74375640e-02f,
  -1.62861571e-02f, 1.01513267e-01f, -2.35610127e-01f, 3.59020047e-02f, -9.93655697e-02f, 6.03942238e-02f, -8.80988538e-02f, 6.92106485e-02f, 1.19845588e-02f, -1.45127937e-01f,
  1.07827552e-01f, -6.31429255e-02f, -9.06343237e-02f, 3.17394584e-02f, 1.42389357e-01f, -2.39114426e-02f, -7.30030686e-02f, -3.94019336e-02f, 9.23520774e-02f, -7.55182654e-02f,
  -4.73717079e-02f, -1.01483904e-01f, -3.79895605e-02f, -6.76526576e-02f, 1.88670354e-03f, 5.27652167e-02f, -6.81966636e-03f, -8.79589766e-02f, 7.11206794e-02f, -2.98120499e-01f,
  -3.16110879e-01f, 1.94101885e-01f, 1.11338748e-02f, 2.42596731e-01f, 3.41340810e-01f, 3.89420003e-01f, 3.54425102e-01f, 1.25126168e-01f, 3.14105339e-02f, 1.31627798e-01f,
  1.70222253e-01f, 7.64151365e-02f, 2.80227400e-02f, 1.00134179e-01f, 1.69054180e-01f, 2.36723304e-01f, 1.24936111e-01f, -7.94548094e-02f, 6.22560866e-02f, 1.11340359e-01f,
  1.26916543e-01f, 1.12111546e-01f, -3.03568467e-02f, -9.26077366e-02f, 3.67095135e-02f, -3.50187942e-02f, 2.02204868e-01f, 2.01202050e-01f, 6.05786778e-02f, -7.21991137e-02f,
  -5.70677966e-02f, 6.68754727e-02f, -1.32265911e-01f, -8.11794475e-02f, -7.25698248e-02f, -1.69053644e-01f, -6.64434582e-02f, -1.52897730e-01f, -7.27638900e-02f, -9.39837098e-03f,
  1.34997936e-02f, 4.62287012e-03f, 1.35018423e-01f, 5.74341007e-02f, 6.92315632e-03f, -1.00438282e-01f, 1.90693755e-02f, 1.28531992e-01f, 1.12165481e-01f, 5.05214147e-02f,
  3.03704347e-02f, 1.81140438e-01f, 1.24990590e-01f, 1.03624472e-02f, 4.59593087e-02f, -1.63265839e-02f, 3.90732028e-02f, -8.67233053e-02f, -8.30374286e-02f, -7.41664395e-02f,
  -9.63155297e-04f, 6.37318268e-02f, 1.47650123e-01f, 1.90732345e-01f, 3.82051733e-03f, 6.26904890e-02f, 1.65254099e-03f, 1.35026217e-01f, 8.42552409e-02f, -1.42789539e-03f,
  -2.32488941e-03f, 1.83120266e-01f, 1.42377451e-01f, -1.04480516e-02f, -1.78100299e-02f, 1.90428719e-01f, 1.09624289e-01f, -1.13509800e-02f, 8.45357329e-02f, 5.96344471e-02f,
  4.74771000e-02f, -1.54032689e-02f, -1.42843142e-01f, -8.99412553e-04f, 6.27034307e-02f, -6.24190941e-02f, -4.39854302e-02f, -8.54695868e-03f, -5.87526225e-02f, -5.65562062e-02f,
  3.80805433e-01f, 3.55347663e-01f, 3.22377086e-02f, 5.36606461e-02f, -4.26207408e-02f, -2.51009762e-01f, 7.68102705e-02f, -2.74122022e-02f, 4.56359088e-02f, -9.42394584e-02f,
  -3.00259832e-02f, -1.08403973e-01f, 4.85856272e-02f, 4.66816425e-02f, -1.64785340e-01f, -1.61709115e-01f, 7.41188554e-03f, 1.42525593e-02f, 9.35013369e-02f, -1.75405499e-02f,
  -7.03310296e-02f, 9.59999263e-02f, 1.77926958e-01f, 8.23234953e-03f, -2.31493190e-02f, 7.32990727e-02f, -6.52643591e-02f, -9.22901556e-02f, 2.27808896e-02f, -2.07303822e-01f,
  4.15131480e-01f, -3.13406646e-01f, -5.26063859e-01f, -3.91786359e-02f, -2.56482601e-01f, -2.79689610e-01f, -3.75762969e-01f, 1.88136548e-02f, -2.17957832e-02f, -3.45818192e-01f,
  -1.67867362e-01f, 1.44698486e-01f, -1.42384037e-01f, -2.89945565e-02f, -1.28836498e-01f, -4.81589317e-01f, -4.41577464e-01f, -2.50330329e-01f, 4.51654717e-02f, 1.62131563e-01f,
  5.76481298e-02f, -4.96582640e-03f, 8.03518966e-02f, 1.00880124e-01f, -2.13162258e-01f, -8.90877619e-02f, -3.55398864e-01f, -2.18935251e-01f, -2.81899303e-01f, -4.48205441e-01f,
  -4.00097102e-01f, -1.84250940e-02f, 4.66171764e-02f, 1.46751001e-01f, -7.10034892e-02f, 1.51003107e-01f, 5.97752333e-02f, 3.61663178e-02f, 1.71601459e-01f, -5.91076463e-02f,
  5.41517697e-02f, 8.01308900e-02f, 1.10779606e-01f, -2.08475143e-02f, 5.19273952e-02f, 3.99241596e-03f, 1.07134394e-01f, 1.79109760e-02f, -1.17471993e-01f, -5.53897955e-02f,
  1.68402158e-02f, -1.02492139e-01f, 5.28992377e-02f, -4.53327633e-02f, 5.53713972e-03f, 4.09354368e-04f, -1.58711091e-01f, -8.48444924e-02f, -1.16595365e-01f, -1.72518969e-01f,
  -2.95082033e-02f, -2.75796540e-02f, 1.03011005e-01f, 6.48494065e-02f, 1.76581338e-01f, -4.91395853e-02f, 8.89433827e-03f, 1.25546038e-01f, 9.81841311e-02f, -3.33644450e-03f,
  -7.68350139e-02f, 1.93342082e-02f, 4.26544696e-02f, 1.51763139e-02f, -3.84901911e-02f, 5.46054170e-02f, 7.78472656e-03f, 3.94037515e-02f, 8.41701105e-02f, 1.01678576e-02f,
  1.52664343e-02f, 2.92300861e-02f, -5.80775738e-02f, 3.18757147e-02f, -5.91323003e-02f, -1.05015382e-01f, -3.11704669e-02f, 4.26466092e-02f, 8.99627358e-02f, -1.43269086e-02f,
  -6.28292561e-02f, -2.04752877e-01f, 1.34876249e-02f, 8.31094682e-02f, -1.27025209e-02f, -9.26420689e-02f, -3.31331193e-02f, 1.60701722e-01f, 1.57948434e-01f, 8.85349661e-02f,
  -2.87210755e-02f, 8.50549787e-02f, -1.35466546e-01f, -5.68593219e-02f, 5.12834005e-02f, 1.18374445e-01f, 2.23797448e-02f, 8.63448605e-02f, 2.93629896e-02f, 4.19349261e-02f,
  -3.02327182e-02f, 6.30130619e-02f, 1.15271509e-01f, -1.10926311e-02f, 2.28156685e-03f, 2.00063027e-02f, -1.04625039e-01f, -7.80292228e-02f, -8.26421753e-02f, -1.06528044e-01f,
  -3.72171670e-01f, -3.01804263e-02f, 6.22797646e-02f, 1.42020267e-03f, 5.19500002e-02f, -1.06906191e-01f, -3.93944591e-01f, -2.85655200e-01f, 4.25953977e-02f, -5.65508828e-02f,
  2.41956804e-02f, 1.22422293e-01f, -2.45399657e-03f, -2.54479468e-01f, -3.90526086e-01f, -4.00512666e-01f, -1.61098942e-01f, -4.01143998e-01f, -4.31353390e-01f, -3.59328687e-01f,
  -2.54414260e-01f, -3.46969843e-01f, -3.55238259e-01f, -1.12594962e-01f, 1.16306387e-01f, -8.08404982e-02f, -5.81851341e-02f, -6.30362285e-03f, -1.07619174e-01f, -3.80379446e-02f,
  -4.84638326e-02f, -7.03389496e-02f, -5.18814437e-02f, -7.06001837e-03f, 2.45711461e-01f, 9.26526338e-02f, 3.19445282e-02f, 4.74127494e-02f, 2.31717620e-02f, -3.72837596e-02f,
  8.35454240e-02f, 1.66212674e-02f, 4.48320433e-02f, 2.58234292e-02f, -1.81343347e-01f, -2.30976596e-01f, -1.54638007e-01f, -1.74961001e-01f, -1.92912202e-02f, 1.27615601e-01f,
  3.31603140e-02f, -1.05913892e-01f, -9.79234874e-02f, -4.64667268e-02f, 1.19508232e-03f, 9.33650061e-02f, 7.72889629e-02f, 1.34775802e-01f, -1.27818761e-03f, -1.79533467e-01f,
  -8.77262950e-02f, 4.03800560e-03f, -3.90207469e-02f, -5.75584807e-02f, 3.47381830e-02f, 9.00875628e-02f, 2.46428866e-02f, -4.05941680e-02f, -6.60065608e-03f, -1.14340976e-01f,
  1.18419062e-02f, 2.85074953e-02f, -9.58803967e-02f, -1.67871922e-01f, 6.71020150e-03f, 2.29427591e-02f, -5.93580864e-02f, -1.45564497e-01f, -1.20771661e-01f, -4.02821004e-02f,
  -9.42623764e-02f, 1.29456976e-02f, -8.05183202e-02f, -1.78407133e-01f, -1.43214509e-01f, -1.43854484e-01f, -2.49626394e-02f, 2.66136639e-02f, -3.17982733e-02f, -3.08944285e-03f,
  -3.12106699e-01f, -1.41417189e-03f, -3.86765762e-03f, -1.77398950e-01f, 9.34600532e-02f, 7.36448020e-02f, 1.89702690e-01f, -8.09895322e-02f, 1.95320416e-03f, -1.04196623e-01f,
  -6.42669052e-02f, 4.40867506e-02f, 5.22741377e-02f, 1.30166739e-01f, -7.73352608e-02f, 2.65070405e-02f, -5.29921241e-02f, -1.24790981e-01f, -9.98437926e-02f, 7.92142078e-02f,
  1.43973213e-02f, -2.81423599e-01f, -2.84372598e-01f, -8.18099231e-02f, 1.53192913e-03f, -7.86017850e-02f, -7.84121454e-02f, -2.30227620e-03f, -1.37085244e-01f, -3.52180034e-01f,
  2.27327123e-01f, -4.26191390e-02f, -5.01593888e-01f, 2.24511195e-02f, -4.28865999e-01f, -4.10719335e-01f, -3.57139796e-01f, 1.91308245e-01f, 1.12092145e-01f, -1.66689977e-01f,
  -7.19467029e-02f, -1.32425670e-02f, -9.71872211e-02f, -1.39319122e-01f, -9.07192305e-02f, -3.85883421e-01f, -3.71237516e-01f, -3.32827419e-01f, -1.30132064e-01f, -1.22732371e-02f,
  -5.70116192e-02f, -4.62218672e-02f, -9.87184346e-02f, -8.93918127e-02f, -2.33861990e-02f, -7.89541099e-03f, -3.14196497e-01f, -1.30734965e-01f, -2.02402294e-01f, -3.24775040e-01f,
  -2.33302131e-01f, -8.03944767e-02f, -6.15608245e-02f, 1.16942843e-04f, 1.02265164e-01f, 1.25578478e-01f, 5.58902025e-02f, 4.29427773e-02f, 8.74074772e-02f, -6.89160526e-02f,
  -1.31624565e-01f, -1.80603992e-02f, 8.34234357e-02f, -8.34836736e-02f, -2.52760090e-02f, -2.64626965e-02f, -1.18587524e-01f, -1.43889442e-01f, -1.93687990e-01f, -2.10951418e-01f,
  -1.82821557e-01f, -3.73364687e-01f, -1.45775273e-01f, -7.51732513e-02f, -8.41160640e-02f, -1.78868383e-01f, -9.61425081e-02f, -2.94742100e-02f, -1.27767891e-01f, 5.20758182e-02f,
  1.50723355e-02f, 1.21690251e-01f, -1.68847162e-02f, 1.34009719e-01f, 4.94951792e-02f, -9.59861372e-03f, 1.46278134e-02f, 5.37524037e-02f, -7.13368971e-03f, 5.11885919e-02f,
  -2.59100497e-02f, -2.65823063e-02f, -1.38645917e-02f, -7.82074928e-02f, -6.56391010e-02f, -7.18064308e-02f, 1.20831206e-01f, -1.68048944e-02f, -9.66282114e-02f, -1.57661155e-01f,
  -4.93131988e-02f, 3.62370685e-02f, -4.77730855e-02f, 4.73488942e-02f, -3.13564613e-02f, -6.70563504e-02f, -6.51916191e-02f, 4.67360578e-02f, -4.29143012e-02f, 3.11629195e-03f,
  2.35507861e-01f, -2.14699134e-01f, 5.08543812e-02f, 1.91831201e-01f, -1.05943829e-02f, 3.24909836e-02f, 2.21724678e-02f, 4.11585942e-02f, -2.45409664e-02f, 2.77728476e-02f,
  1.71760153e-02f, 6.86615184e-02f, -9.09212977e-03f, -5.80644347e-02f, 1.06328055e-02f, -1.05560556e-01f, 6.47048578e-02f, -1.40300214e-01f, -7.76519030e-02f, 6.35584593e-02f,
  1.19380452e-01f, 4.49691527e-03f, 1.53816774e-01f, 7.94094354e-02f, 7.97815025e-02f, 5.39584905e-02f, 4.41802107e-02f, 1.51149854e-01f, 2.96489559e-02f, 2.56979108e-01f,
  -6.22275233e-01f, 3.72442394e-01f, -5.74260056e-02f, -3.85938674e-01f, -7.55882189e-02f, 1.78458706e-01f, 5.02627075e-01f, 2.29117826e-01f, -1.12645932e-01f, 3.81998122e-01f,
  9.97053608e-02f, -2.91729987e-01f, -4.07898188e-01f, -2.52097934e-01f, -1.59890857e-02f, 3.41505438e-01f, 1.10449679e-01f, -3.87083113e-01f, -3.82543445e-01f, -2.14957565e-01f,
  -2.03620195e-01f, -3.53492349e-01f, -4.11460757e-01f, -3.87775958e-01f, -2.36560643e-01f, -3.25221777e-01f, -6.34949058e-02f, -2.16084987e-01f, -3.12161166e-02f, -1.88293025e-01f,
  -1.19388446e-01f, -2.60176808e-01f, -2.18381450e-01f, -4.80815284e-02f, -5.68974093e-02f, -3.55455428e-02f, -3.58461738e-02f, -8.86785612e-02f, 5.14399111e-02f, 4.00432535e-02f,
  -1.07858136e-01f, -3.49245705e-02f, -1.93768427e-01f, -1.83400452e-01f, -6.53476939e-02f, -9.38913077e-02f, 6.86712861e-02f, -1.89461321e-01f, -3.79052944e-02f, 1.83909908e-01f,
  2.64725000e-01f, -5.46955131e-02f, -8.31036046e-02f, 1.25081852e-01f, -2.08428185e-02f, -6.82613030e-02f, 4.38909483e-04f, -1.12018183e-01f, -6.97777495e-02f, 3.63703892e-02f,
  1.81592867e-01f, -3.35647119e-03f, 1.95641965e-02f, -7.99995065e-02f, 6.82337806e-02f, 1.98019091e-02f, -4.09525596e-02f, 6.35619909e-02f, -3.23214084e-02f, -8.16346630e-02f,
  -5.52249141e-04f, 1.01475716e-01f, 3.65924835e-03f, -2.16662940e-02f, 2.96319928e-02f, -3.03230379e-02f, 6.86659738e-02f, 3.27394940e-02f, 1.26169305e-02f, 4.17526513e-02f,
  -1.21290527e-01f, 5.16787693e-02f, 9.80595220e-03f, -9.57964584e-02f, 1.68912902e-01f, -4.48805876e-02f, -7.79740512e-03f, 4.47964557e-02f, 7.41910608e-03f, 4.60735410e-02f,
  -3.93532693e-01f, -3.33072096e-02f, -5.14108650e-02f, -1.33439571e-01f, -4.35717478e-02f, 1.70430407e-01f, 6.78347498e-02f, 1.86633710e-02f, -1.18415520e-01f, 1.95529982e-01f,
  8.70253071e-02f, 5.41226491e-02f, -6.07687607e-02f, 4.41593379e-02f, -2.90054698e-02f, -6.04564659e-02f, 2.59960026e-01f, -1.11381024e-01f, 9.97495502e-02f, 2.46009886e-01f,
  2.81941473e-01f, 2.03979909e-01f, 6.54500648e-02f, 7.20471442e-02f, -7.17627108e-02f, -1.09409951e-01f, -1.18161410e-01f, -9.41736798e-05f, 4.70725074e-02f, 1.33044645e-01f,
  -2.86113828e-01f, -1.17521109e-02f, 1.44982517e-01f, -4.09638941e-01f, -1.64489076e-01f, -8.76834467e-02f, -2.32322469e-01f, -2.78292179e-01f, -5.66317961e-02f, -9.75769758e-02f,
  1.78290740e-01f, 3.54685336e-02f, 1.57967955e-01f, -1.46543294e-01f, -3.38890284e-01f, -2.53962427e-01f, -2.72102833e-01f, -1.81041852e-01f, -3.95083010e-01f, -3.91444862e-01f,
  -3.08149755e-01f, -2.87922621e-01f, -3.37264240e-01f, -2.17764139e-01f, -1.92597196e-01f, 1.87180762e-03f, 4.41001728e-02f, -7.91778415e-02f, 2.38268655e-02f, 1.18303798e-01f,
  2.35659212e-01f, 1.10209368e-01f, -2.24517658e-02f, -1.47894293e-01f, -9.06188414e-02f, -6.47803303e-03f, -1.84146538e-01f, 3.08269192e-03f, 5.49371950e-02f, 1.92271732e-02f,
  -1.23319970e-02f, -1.43135786e-01f, -7.23308418e-03f, -1.51521619e-02f, -3.34780484e-01f, -1.86711460e-01f, -1.26611769e-01f, -2.90860832e-01f, -2.71990299e-01f, -1.40047491e-01f,
  -2.19105020e-01f, -2.22974822e-01f, -1.24013953e-01f, -1.25489712e-01f, -1.34756491e-01f, -1.27894953e-01f, 4.92278114e-02f, -8.08288604e-02f, -9.33139026e-02f, -1.44988179e-01f,
  -8.21974594e-03f, 2.76967376e-01f, 1.77048266e-01f, -4.50976603e-02f, 1.40170511e-02f, 1.70950457e-01f, 7.23980814e-02f, -9.21198949e-02f, -1.92670934e-02f, 8.39139670e-02f,
  1.10315777e-01f, 1.06505774e-01f, -2.51243208e-02f, -5.19921295e-02f, 7.91692287e-02f, -5.46230413e-02f, 1.09197207e-01f, 2.55392622e-02f, 1.00604676e-01f, 5.54263107e-02f,
  6.53678179e-02f, 4.39798906e-02f, 8.12834501e-02f, 1.45214647e-01f, 2.48695031e-01f, 1.25903189e-01f, 1.83090314e-01f, 2.55610436e-01f, 5.04968390e-02f, 1.99452370e-01f,
  8.10391158e-02f, 2.74543613e-01f, 1.58449411e-02f, -1.93722814e-01f, -1.11609086e-01f, 1.03909656e-01f, -1.10214375e-01f, -5.81020787e-02f, 2.15488717e-01f, -2.13297278e-01f,
  -9.40882787e-02f, -1.60393909e-01f, 7.41694421e-02f, -2.93920599e-02f, -1.11294217e-01f, -1.65457249e-01f, -1.38014674e-01f, -3.93964574e-02f, -1.19592465e-01f, -1.87726662e-01f,
  -1.65662125e-01f, -1.97444290e-01f, -4.40931991e-02f, -1.10107422e-01f, -1.89777672e-01f, -1.88457578e-01f, -1.95778231e-03f, -9.04181153e-02f, -6.14948049e-02f, -2.55381376e-01f,
  4.59836930e-01f, 2.81493038e-01f, 6.85803071e-02f, 1.67760178e-01f, -1.90147415e-01f, -2.35134423e-01f, -3.38388205e-01f, -1.59346923e-01f, 4.76190783e-02f, 1.36034116e-01f,
  -6.87715262e-02f, -1.54105917e-01f, -1.37495279e-01f, -1.27866358e-01f, 2.21281918e-03f, 7.94573203e-02f, 6.32773861e-02f, 8.05333778e-02f, -5.94351478e-02f, -5.84159270e-02f,
  -7.79568031e-02f, 6.62079360e-03f, 1.56463489e-01f, 7.02115297e-02f, 1.29750118e-01f, -1.13366708e-01f, 1.21708475e-01f, 1.90521404e-01f, 7.30334893e-02f, 1.66428864e-01f,
  2.12063000e-01f, 1.29871055e-01f, -2.59774119e-01f, -3.51309739e-02f, 1.07517995e-01f, 1.89225331e-01f, 4.96264212e-02f, 1.22008294e-01f, -5.81011251e-02f, 7.29300454e-02f,
  8.28471780e-02f, 1.22746550e-01f, -5.22072576e-02f, -1.81004405e-03f, 2.56426986e-02f, -7.08101392e-02f, 1.80265494e-02f, 3.64798233e-02f, -6.54545203e-02f, 4.18501534e-02f,
  -4.34237681e-02f, 2.38069687e-02f, -8.03071633e-02f, -2.81872898e-01f, -1.95565354e-02f, 1.53920082e-02f, -8.27815458e-02f, -1.44608337e-02f, -8.72390494e-02f, 1.02426529e-01f,
  8.93370956e-02f, -1.18949171e-02f, 3.97978537e-02f, 2.02142745e-01f, 1.47920728e-01f, 1.04652800e-01f, 3.66594307e-02f, 2.55267080e-02f, 8.93543102e-03f, 9.59236994e-02f,
  1.02191843e-01f, 1.39100999e-01f, 1.37210712e-01f, 9.03088823e-02f, 5.85284047e-02f, 1.70597583e-01f, 1.83530301e-01f, 1.67407934e-02f, -3.88004817e-02f, 3.36586311e-02f,
  -6.72414750e-02f, -1.12092467e-02f, 6.87217638e-02f, 4.08985987e-02f, 4.53752317e-02f, 1.72383159e-01f, 1.32388517e-01f, 1.00096144e-01f, 2.03534570e-02f, 1.77991956e-01f,
  -1.33238822e-01f, -3.86315793e-01f, -3.97320576e-02f, 4.89680842e-02f, -5.58118895e-02f, 1.06632568e-01f, 1.43402502e-01f, 2.90305912e-02f, 7.47662932e-02f, 1.21731125e-01f,
  4.76728640e-02f, 1.37176007e-01f, -4.15840596e-02f, -5.39900362e-02f, -4.67699319e-02f, 3.30867362e-03f, 1.32056028e-01f, -6.18592836e-02f, -7.05366954e-02f, 8.49574134e-02f,
  -3.58010940e-02f, -2.56312728e-01f, -3.65618497e-01f, -2.05641046e-01f, -7.22317696e-02f, -2.31062874e-01f, -1.10489719e-01f, -1.33074090e-01f, -2.67528653e-01f, -2.49525923e-02f,
  -2.84896910e-01f, -6.77140877e-02f, -4.28045511e-01f, -4.26278979e-01f, -5.26591241e-01f, -3.97240281e-01f, -1.26175269e-01f, -2.23735318e-01f, -2.51351744e-01f, -9.24400613e-02f,
  4.06824872e-02f, 2.09806979e-01f, 4.41005826e-02f, 8.85342583e-02f, 2.40242735e-01f, -1.67908728e-01f, -2.74199963e-01f, -7.21828043e-02f, 4.90596369e-02f, 6.00722805e-02f,
  7.57916495e-02f, -2.03307927e-01f, -1.57993168e-01f, -1.80140287e-01f, -1.73271224e-01f, -2.04069331e-01f, -2.61272341e-01f, -2.75222152e-01f, -2.71318704e-01f, -3.43074948e-01f,
  3.04898202e-01f, -3.36093754e-01f, 6.35823235e-02f, -9.30624604e-02f, -8.65539685e-02f, -2.30907835e-02f, 9.86658186e-02f, -1.15163080e-01f, -1.00853600e-01f, -4.36461717e-02f,
  -1.88382775e-01f, -9.95443016e-02f, -3.87466811e-02f, 6.60341009e-02f, -1.17981778e-02f, 3.44534442e-02f, -1.23737372e-01f, -6.88885972e-02f, -1.09703444e-01f, -1.91759563e-03f,
  -1.48881264e-02f, -1.13838822e-01f, 7.70077333e-02f, 2.42758747e-02f, -3.13831791e-02f, 2.53379531e-02f, -1.72484480e-02f, -5.39184920e-02f, -2.59543415e-02f, -1.15373265e-02f,
  1.03488239e-02f, -3.94900180e-02f, -8.55227336e-02f, 7.95721561e-02f, -3.57269794e-02f, -5.45965135e-03f, 2.60818899e-02f, 3.25413346e-02f, 3.01856510e-02f, 1.07202731e-01f,
  -3.90363950e-03f, -3.44533147e-03f, 1.03773251e-02f, 4.42847908e-02f, 1.67858116e-02f, -4.21028882e-02f, 6.33084178e-02f, 3.03973593e-02f, -4.05024812e-02f, -1.07355744e-01f,
  -3.12584825e-02f, -3.30683142e-02f, -4.00727578e-02f, 1.35568567e-02f, -1.68444484e-01f, -8.91449749e-02f, -1.18261985e-02f, -5.90687357e-02f, 4.21779510e-03f, -7.12563470e-02f,
  2.72517800e-01f, -1.00027077e-01f, 6.48477077e-02f, -2.88598356e-03f, -7.66145065e-02f, -9.04197544e-02f, -8.73834069e-05f, -7.19909444e-02f, -1.26803994e-01f, -2.40005516e-02f,
  -8.30249339e-02f, 4.51688506e-02f, 1.02435395e-01f, 5.12406826e-02f, -3.71934474e-02f, 9.58640222e-03f, 7.66000748e-02f, 1.06739059e-01f, -6.49430752e-02f, -7.69868344e-02f,
  -5.31146191e-02f, 1.72086209e-01f, 2.62970030e-01f, 1.44561753e-01f, 4.19225581e-02f, 2.31735855e-02f, 3.88194397e-02f, 8.75782445e-02f, 1.67733312e-01f, 1.70762256e-01f,
  4.23488557e-01f, 2.50014439e-02f, 3.00478516e-03f, -1.51535496e-01f, -1.92707852e-01f, -9.70468745e-02f, -2.09035963e-01f, 1.76851619e-02f, 3.20963226e-02f, 5.44138290e-02f,
  1.45400867e-01f, 6.55723829e-03f, 1.12251809e-03f, -5.23383822e-03f, -1.58817344e-03f, -9.57412273e-02f, -1.77206427e-01f, 6.26910329e-02f, 8.59390106e-03f, 1.83010455e-02f,
  -1.46408051e-01f, -2.89259069e-02f, 1.27078190e-01f, 9.46403071e-02f, -2.03091204e-01f, -3.35312001e-02f, 3.86965014e-02f, -7.71138370e-02f, -2.99588498e-02f, -1.68585584e-01f,
  -1.81752041e-01f, 1.67419881e-01f, 6.67796582e-02f, 1.16616592e-01f, 5.86374030e-02f, 1.56309932e-01f, 1.05823547e-01f, -8.50033667e-03f, -8.28971714e-02f, -8.69021118e-02f,
  4.41616774e-02f, 1.29614219e-01f, 7.50669092e-02f, 6.11450560e-02f, 1.58988945e-02f, 1.28168225e-01f, -1.73700030e-03f, 5.76141514e-02f, -6.13063201e-02f, 2.46983208e-02f,
  1.03192508e-01f, -8.80209580e-02f, -5.55542223e-02f, 1.74011402e-02f, 1.39672846e-01f, 1.00885667e-01f, 1.22147977e-01f, -4.43208590e-02f, 8.03162530e-02f, 2.55467575e-02f,
  1.48599237e-01f, -9.30673331e-02f, 3.11239082e-02f, 7.05928430e-02f, 1.95541844e-01f, 1.62605848e-02f, -1.40046149e-01f, -1.04286924e-01f, 1.39384776e-01f, 1.89747289e-01f,
  -3.49968262e-02f, -1.34606170e-03f, 3.40958196e-03f, -7.36114681e-02f, 3.36922565e-03f, 4.63545471e-02f, -1.63318768e-01f, -8.09399039e-02f, 7.20834034e-03f, -8.18719342e-03f,
  -3.92274037e-02f, -5.61234504e-02f, -6.49298131e-02f, 1.49827264e-02f, -8.15589502e-02f, -4.47036587e-02f, 5.60412481e-02f, -1.69217065e-02f, 3.55009027e-02f, -3.62776779e-02f,
  -3.02994102e-01f, 3.38747770e-01f, -6.58128560e-02f, -2.51299492e-03f, 3.10838968e-02f, 1.10805832e-01f, 3.10874339e-02f, -3.18326429e-02f, -1.30826473e-01f, -7.80556127e-02f,
  -2.33796914e-03f, 3.02073099e-02f, -4.66386676e-02f, -3.81821953e-02f, 6.51384667e-02f, -2.67555118e-02f, 1.44326419e-01f, -1.50175780e-01f, -1.25775963e-01f, -3.02731320e-02f,
  -1.02469578e-01f, -3.82638499e-02f, -5.57571948e-02f, -3.83322351e-02f, 1.02751791e-01f, -1.07643949e-02f, -5.12026399e-02f, -1.30573392e-01f, 6.49244711e-02f, 2.24455316e-02f,
  -7.57936165e-02f, -4.81567353e-01f, -1.11581355e-01f, -2.61735409e-01f, -1.93136901e-01f, -2.17678696e-01f, -5.20348907e-01f, -2.06958547e-01f, -5.09779826e-02f, -4.24286157e-01f,
  -1.17457904e-01f, 6.22399189e-02f, 1.40587091e-01f, 1.63744047e-01f, 1.35222495e-01f, -3.25726748e-01f, -2.81139046e-01f, 2.23899052e-01f, 2.53338486e-01f, -3.47783454e-02f,
  -2.82825857e-01f, -1.10915728e-01f, 2.75853693e-01f, 2.16054365e-01f, -3.59664679e-01f, -5.95581904e-02f, -5.35614155e-02f, -1.82040200e-01f, -6.90866187e-02f, -3.83757055e-01f,
  -3.29301566e-01f, -7.14041069e-02f, 1.07695892e-01f, 1.17745422e-01f, -5.39628901e-02f, 3.46821174e-03f, -3.76058966e-02f, 5.47578931e-02f, -4.24479321e-02f, -2.61678547e-02f,
  -1.03976734e-01f, 3.72646786e-02f, 3.92415635e-02f, 1.25927245e-02f, -8.88676494e-02f, -6.14776388e-02f, 4.81743924e-02f, 2.28726283e-01f, 7.60715827e-02f, -1.24256775e-01f,
  -1.88693941e-01f, -8.11655223e-02f, 1.38899401e-01f, 3.86672840e-02f, 8.26559290e-02f, 2.51098555e-02f, -8.63464177e-02f, -1.31421173e-02f, 2.33881906e-01f, -2.46071085e-01f,
  -7.63763636e-02f, 9.15279165e-02f, -8.85925144e-02f, -2.47731693e-02f, -6.53041750e-02f, 2.85275020e-02f, -1.22876316e-02f, 7.94697329e-02f, 5.23999035e-02f, -3.82966325e-02f,
  -4.86738607e-02f, -2.90455390e-02f, 5.02607785e-02f, 9.75969154e-03f, -2.09073792e-03f, 8.23309273e-02f, -7.96785578e-03f, -8.07917193e-02f, -3.85010354e-02f, 4.07428741e-02f,
  5.98863512e-02f, -4.42154147e-02f, 1.26448035e-01f, 1.26460809e-02f, 1.43219507e-03f, -6.41072020e-02f, -9.53258798e-02f, -3.29744704e-02f, -9.68582481e-02f, 2.00761855e-02f,
  4.42446023e-02f, 3.05595130e-01f, -2.99518615e-01f, 5.22006340e-02f, -1.06468491e-01f, 1.62916947e-02f, -5.18400520e-02f, 1.43708795e-01f, 6.59360215e-02f, 1.76448431e-02f,
  3.13192643e-02f, 5.21831885e-02f, 2.04988960e-02f, -9.36805084e-03f, -6.28527924e-02f, 3.67890224e-02f, -3.16604823e-02f, -4.55638357e-02f, 3.87532972e-02f, -1.12765893e-01f,
  -9.10285115e-02f, -9.25437827e-03f, -4.52203229e-02f, 4.75072451e-02f, -9.56880003e-02f, 1.16096489e-01f, -3.69112492e-02f, -1.05185479e-01f, 1.44862430e-02f, -2.11491391e-01f,
  -2.23982781e-01f, -2.25230604e-01f, 1.32934600e-01f, -1.63973689e-01f, 1.24087799e-02f, 8.90444145e-02f, -9.29870605e-02f, 5.35462908e-02f, -1.20340616e-01f, -1.50123179e-01f,
  3.60230505e-02f, 6.65572472e-03f, -8.76926333e-02f, 1.05967730e-01f, 1.90203056e-01f, -1.98542595e-01f, -2.94638097e-01f, 4.89881486e-02f, 3.04984182e-01f, 1.55015305e-01f,
  -1.83418438e-01f, -1.96536496e-01f, -7.13179037e-02f, -9.79252234e-02f, -3.14548433e-01f, -2.05416203e-01f, -3.18032414e-01f, -1.73332140e-01f, -1.60732105e-01f, -4.75318164e-01f,
  3.08382493e-02f, 3.53532210e-02f, 2.48774663e-01f, 2.45030262e-02f, -1.07070588e-01f, 7.61914700e-02f, -7.46123195e-02f, -1.04657672e-01f, -1.40985534e-01f, 3.72757614e-02f,
  -2.00872734e-01f, 4.48795110e-02f, -4.30685580e-02f, -6.28430676e-03f, -2.18116771e-03f, 5.90537861e-03f, -3.12775075e-02f, 5.85579127e-02f, -5.57326525e-03f, -3.47130410e-02f,
  -2.50292063e-01f, -2.69555658e-01f, -6.77150711e-02f, -2.18247175e-02f, 4.47805896e-02f, 3.70105985e-03f, 2.34606881e-02f, -1.66078117e-02f, -9.94883329e-02f, -4.10737693e-01f,
  -1.28222525e-01f, 6.14973530e-02f, -3.45530100e-02f, 2.30369400e-02f, -1.09766908e-01f, -1.17367364e-01f, -6.40950678e-03f, -1.11905031e-01f, 1.99241620e-02f, -1.40675128e-01f,
  6.67444021e-02f, 9.81775820e-02f, 6.03763461e-02f, -1.69294447e-01f, -1.08930372e-01f, -1.41407534e-01f, -4.38290350e-02f, -7.06906244e-02f, -4.46277224e-02f, -1.03160731e-01f,
  -8.95713177e-03f, 3.01115029e-03f, -9.62035060e-02f, 3.99204390e-03f, -3.12322695e-02f, 7.41970539e-02f, -2.65802816e-02f, 7.19922334e-02f, -1.38579383e-01f, -9.58050713e-02f,
  -1.01572007e-01f, 3.16998661e-01f, -1.43185928e-01f, -1.18765598e-02f, 7.55946618e-03f, 6.86084628e-02f, 1.37419896e-02f, 2.14477405e-01f, 5.18411025e-02f, 1.40202522e-01f,
  6.80048838e-02f, 4.77163494e-02f, -1.78564161e-01f, 5.96376583e-02f, 5.92322722e-02f, 9.32932273e-03f, -1.40137702e-01f, -9.94748846e-02f, -3.31870392e-02f, -9.32132974e-02f,
  -1.67489320e-01f, -9.21740606e-02f, -1.54503018e-01f, -1.78698704e-01f, -1.99528649e-01f, -5.43289594e-02f, -2.86077596e-02f, -1.97543561e-01f, -8.61232504e-02f, -4.12142128e-01f,
  5.78915119e-01f, -5.09895086e-02f, 3.80184986e-02f, 1.92956984e-01f, 3.48864384e-02f, -2.04096101e-02f, -9.68743563e-02f, -4.95365374e-02f, 1.36992157e-01f, 6.06365725e-02f,
  1.75317541e-01f, 1.70503363e-01f, 1.83248863e-01f, 1.02127820e-01f, 1.31619841e-01f, -8.06112960e-02f, -7.04261586e-02f, 2.74692085e-02f, 8.91149323e-03f, 1.05107829e-01f,
  1.82576943e-02f, -4.86626253e-02f, 1.12193212e-01f, -1.46445641e-02f, -1.51653672e-02f, 8.54842812e-02f, -8.21967795e-02f, 4.09190282e-02f, -1.03650890e-01f, -8.05746987e-02f,
  1.58788458e-01f, 1.12910427e-01f, -6.85745850e-02f, 5.07553713e-03f, 2.80104186e-02f, -1.19068958e-01f, -6.08632341e-02f, -6.78839833e-02f, -1.30486235e-01f, -6.28903732e-02f,
  3.25540849e-03f, 3.00642755e-02f, -1.12453103e-01f, -1.25173375e-01f, -4.31806929e-02f, -4.98957746e-02f, -4.69183959e-02f, -1.59892999e-02f, -3.23913805e-02f, -2.14711688e-02f,
  -2.95896083e-02f, -1.00641616e-01f, -8.90557170e-02f, -1.42843068e-01f, 4.74513024e-02f, 9.41700786e-02f, -5.77049516e-02f, 5.30885458e-02f, 3.79128270e-02f, 1.82955023e-02f,
  6.52679205e-02f, 6.02914393e-02f, 9.49925371e-03f, 3.67995761e-02f, 1.10781439e-01f, -2.31081620e-02f, -5.38616814e-02f, 9.49341059e-03f, 1.13469921e-02f, -8.75645578e-02f,
  8.33985284e-02f, 1.17369607e-01f, -4.42630760e-02f, -2.17934512e-03f, 6.21488132e-02f, -3.52608552e-03f, -8.08652639e-02f, 1.26963267e-02f, 7.80083239e-02f, -2.68393904e-02f,
  -2.05349401e-02f, -5.53687010e-03f, 1.46567021e-02f, -4.77177538e-02f, 5.45250215e-02f, 3.35973129e-02f, -3.94175500e-02f, -1.17385117e-02f, 6.23310804e-02f, 3.88530605e-02f,
  -1.11526027e-01f, 3.46211269e-02f, 1.23693250e-01f, -4.60295416e-02f, -8.66683796e-02f, -1.41013637e-02f, -4.84854728e-02f, 7.75801251e-03f, -1.10137179e-01f, -8.87199417e-02f,
  -1.53799087e-01f, -6.40702769e-02f, -1.05285510e-01f, -1.62529334e-01f, 7.57497689e-03f, -1.27891153e-01f, -3.14623155e-02f, -5.43353707e-02f, -1.09250061e-01f, -1.22144163e-01f,
  -9.75345746e-02f, -6.07364327e-02f, -6.26369640e-02f, -7.15373456e-02f, -9.38705876e-02f, -6.78142607e-02f, -1.43802792e-01f, -1.61508322e-01f, -2.02638600e-02f, -9.53423530e-02f,
  -2.88294584e-01f, 2.72561878e-01f, -1.12797290e-01f, -1.46905631e-01f, 2.09117860e-01f, 1.86930567e-01f, 2.36670688e-01f, 9.15535763e-02f, -5.62474541e-02f, 9.51985717e-02f,
  4.47066814e-01f, -1.03505060e-01f, -1.07060656e-01f, -3.17713767e-01f, -3.92345667e-01f, -2.14219764e-01f, -3.40260595e-01f, -4.57593828e-01f, -3.01920980e-01f, 1.77497372e-01f,
  4.53201719e-02f, -1.58876464e-01f, -4.23358440e-01f, -2.88937300e-01f, -1.12670615e-01f, -2.72843987e-01f, -2.61994094e-01f, -9.92421508e-02f, 7.25296736e-02f, -1.55469611e-01f,
  -4.32943702e-02f, 1.25915021e-01f, 3.88687104e-02f, -2.76102182e-02f, 1.15932330e-01f, -2.14437217e-01f, 3.50582786e-02f, -1.20389290e-01f, 1.59293890e-01f, -5.45732537e-03f,
  2.01605186e-01f, 2.17685953e-01f, 2.50255466e-01f, 8.18708837e-02f, 3.23535092e-02f, -1.07918009e-01f, -6.61699697e-02f, -1.57412738e-01f, -2.15903461e-01f, 1.56428441e-01f,
  1.57867059e-01f, 1.13528855e-01f, -1.59760956e-02f, -8.46540183e-02f, -7.23482743e-02f, -2.27589369e-01f, -2.92643197e-02f, -1.74203828e-01f, -1.84319958e-01f, -3.62313509e-01f,
  6.45444617e-02f, 1.60565395e-02f, 7.83961359e-03f, 1.43692121e-01f, 1.86672565e-02f, -2.60890462e-04f, 2.03330573e-02f, -9.50253382e-03f, -5.23686558e-02f, -1.56524956e-01f,
  7.66957700e-02f, 3.52876959e-03f, 1.20753888e-02f, 5.85606843e-02f, -9.83452871e-02f, -7.06236362e-02f, -3.93891111e-02f, -1.28243223e-01f, -2.17390239e-01f, -1.29174769e-01f,
  3.52457166e-02f, 7.48787671e-02f, 4.90886234e-02f, -6.19690493e-02f, -2.19377503e-02f, -1.29381940e-01f, -1.53483450e-02f, 1.37211680e-02f, 4.03656773e-02f, -2.53381431e-02f,
  -4.83832777e-01f, -1.69575125e-01f, -1.12530157e-01f, -1.33839056e-01f, -2.95140855e-02f, -1.87850773e-01f, 8.04037824e-02f, -1.29870042e-01f, 1.84661299e-01f, -6.58124834e-02f,
  2.38042563e-01f, -7.87155032e-02f, 1.30275548e-01f, -9.22382064e-03f, -1.31134555e-01f, -1.96844060e-03f, -1.33042917e-01f, -2.34301239e-01f, -1.20430849e-01f, 1.37728810e-01f,
  -2.94870079e-01f, -3.17978442e-01f, -2.56805003e-01f, -3.23592246e-01f, -7.35684186e-02f, -2.88621247e-01f, -3.34644884e-01f, -3.29354823e-01f, -3.34461182e-01f, -5.43068945e-01f,
  -6.32837176e-01f, -8.83992612e-02f, -1.78260371e-01f, -2.22160488e-01f, -5.20517826e-02f, 1.35985501e-02f, 1.27326265e-01f, 7.59452358e-02f, 4.13099788e-02f, 6.56192079e-02f,
  2.48823408e-02f, 9.43919122e-02f, 6.48967475e-02f, 1.69767126e-01f, 9.34109166e-02f, -2.39268057e-02f, -5.29660992e-02f, -6.97456822e-02f, -3.22152153e-02f, 1.19585954e-01f,
  1.80490520e-02f, -9.91954431e-02f, -9.72991660e-02f, -1.07887805e-01f, 3.96305285e-02f, 1.20149646e-02f, -6.06521517e-02f, -6.75768256e-02f, 1.48382649e-01f, -8.72545019e-02f,
  2.63955235e-01f, -9.24312770e-02f, 6.42029122e-02f, 9.46380496e-02f, -1.74934454e-02f, -6.68579265e-02f, -6.51658028e-02f, -1.05582550e-02f, 7.05515817e-02f, 1.12279385e-01f,
  -4.85232612e-03f, -1.15278773e-01f, -4.17932048e-02f, -1.51334172e-02f, -7.07527995e-02f, 4.05452400e-02f, 3.79216000e-02f, 9.77739468e-02f, 3.55618000e-02f, 5.88389300e-02f,
  9.07030851e-02f, 1.21662496e-02f, 1.18212655e-01f, 1.77218318e-01f, 6.15005083e-02f, 1.78824961e-02f, 2.30957456e-02f, 1.71516035e-02f, 3.11974231e-02f, 6.52226061e-02f,
  2.55763054e-01f, 7.56397471e-02f, 6.73161671e-02f, 2.52041426e-02f, 8.91678706e-02f, 4.12987694e-02f, -1.10218398e-01f, 2.66938154e-02f, 1.13837451e-01f, -3.75705510e-02f,
  -8.88040941e-03f, -5.66791650e-03f, -3.91831854e-03f, -1.16887167e-01f, -5.74041717e-02f, -6.45859390e-02f, -1.76383182e-01f, -4.37498689e-02f, 1.03380211e-01f, 4.15345766e-02f,
  -2.35477611e-02f, 5.36331423e-02f, -1.03753351e-01f, -1.56869758e-02f, -2.64090765e-02f, 5.12550399e-02f, -8.02239478e-02f, 3.36852223e-02f, -5.14414348e-02f, -1.29940793e-01f,
  3.62015724e-01f, 8.96164179e-02f, 7.27251694e-02f, -9.90889221e-02f, -1.92109674e-01f, -2.22486392e-01f, -1.76917419e-01f, -1.72159985e-01f, -1.31103277e-01f, -6.59313574e-02f,
  3.69232614e-04f, -1.54674888e-01f, 3.48200537e-02f, 4.19369154e-02f, -1.03267416e-01f, -5.34147434e-02f, 3.11876703e-02f, 1.20407389e-02f, 9.22043025e-02f, 3.83699946e-02f,
  -9.36655968e-04f, 1.03254668e-01f, 1.97512284e-01f, 7.44691640e-02f, 4.31789234e-02f, 1.14132710e-01f, 8.68093073e-02f, -2.51506474e-02f, 8.80288482e-02f, -1.62613001e-02f,
  -5.43205142e-01f, 1.64614171e-02f, 2.71872580e-01f, -1.16684049e-01f, 2.49633044e-01f, 5.02252519e-01f, 5.76886773e-01f, 2.24822551e-01f, -1.72985896e-01f, 1.60689149e-02f,
  -3.30370925e-02f, -3.17078024e-01f, -2.19342858e-01f, -1.62904873e-01f, 4.75396775e-02f, 3.61482710e-01f, 3.78409803e-01f, 1.36468753e-01f, -8.51996467e-02f, 1.19916260e-01f,
  2.67373044e-02f, -2.32359365e-01f, -2.47977912e-01f, -1.53588921e-01f, -1.09064229e-01f, -1.59404770e-01f, -4.11353521e-02f, -1.08437426e-01f, 1.65233195e-01f, 3.00699174e-02f,
  -2.03316271e-01f, -1.02622300e-01f, -1.26333525e-02f, -2.61789203e-01f, -1.19638130e-01f, -1.66202784e-01f, 1.10376775e-01f, -1.34083405e-01f, -1.10048741e-01f, 1.91371044e-04f,
  -7.64946640e-02f, -1.23944104e-01f, -2.89534330e-01f, -1.07805982e-01f, -1.22131504e-01f, -2.14694496e-02f, -1.36311175e-02f, -5.88724054e-02f, -1.70270249e-01f, -8.44895467e-02f,
  1.14819840e-01f, -2.08936725e-02f, -9.95049924e-02f, 4.15896699e-02f, 6.92860782e-03f, -2.39775047e-01f, 7.17535838e-02f, -7.05296397e-02f, 3.28945182e-02f, -1.71599582e-01f,
  7.89094530e-03f, 7.51353684e-04f, 4.70647700e-02f, 3.11321337e-02f, 2.27585230e-02f, 2.00917758e-02f, 2.38733832e-02f, -3.82903218e-02f, 6.42532110e-02f, -1.38005288e-02f,
  -1.18350431e-01f, -5.07116020e-02f, -5.56353368e-02f, 5.27948141e-04f, -1.07647732e-01f, 5.54962046e-02f, 1.57371670e-01f, 2.63047386e-02f, 6.39979616e-02f, -2.18469673e-03f,
  -1.56422883e-01f, 1.16203018e-01f, -4.27526645e-02f, -6.28757179e-02f, 9.74510536e-02f, 1.15891911e-01f, -5.22094145e-02f, 2.27974379e-03f, -8.48475546e-02f, 1.44508556e-01f,
  -4.54446852e-01f, 2.66344547e-01f, -2.33866930e-01f, -1.69109888e-02f, -1.68824680e-02f, 7.42811561e-02f, -6.57004043e-02f, -1.98129145e-03f, -3.23294522e-03f, -5.00943586e-02f,
  1.06384479e-01f, -3.59461419e-02f, -2.72654235e-01f, 7.86455348e-02f, -3.48639339e-02f, 8.34853277e-02f, 1.50465369e-01f, 7.42799044e-02f, -7.66988844e-02f, -4.23885956e-02f,
  -3.33880074e-02f, 9.45316255e-02f, -1.13477059e-01f, 1.13347247e-01f, -7.51760751e-02f, -5.50344698e-02f, 6.62192628e-02f, 5.74252792e-02f, 8.20273608e-02f, 8.32645744e-02f,
  5.74305415e-01f, 4.97169673e-01f, 8.89694914e-02f, 1.73988491e-01f, 2.25759879e-01f, 4.50509302e-02f, 9.81251672e-02f, -4.43961136e-02f, -4.88296663e-03f, 2.57207006e-01f,
  4.14004445e-01f, 7.42330030e-02f, 2.93642120e-03f, -1.28888011e-01f, -1.79329202e-01f, -1.31433234e-01f, -1.37166858e-01f, -1.28420755e-01f, -1.68271512e-01f, 7.41968900e-02f,
  1.29351184e-01f, 9.58885700e-02f, 1.12822138e-01f, 6.57105073e-02f, 1.82062596e-01f, -2.34611630e-02f, 8.69052261e-02f, 2.39403114e-01f, 1.73571736e-01f, 1.12804629e-01f,
  2.50489533e-01f, 3.36414576e-01f, -3.22242945e-01f, -5.31312218e-03f, 8.66060033e-02f, -1.17162108e-01f, 2.03881282e-02f, -1.52789265e-01f, -1.40340537e-01f, -1.58430576e-01f,
  1.14705622e-01f, 1.27529517e-01f, 6.24972694e-02f, 4.12176512e-02f, -1.52060231e-02f, -3.58526707e-02f, -7.79761896e-02f, -1.37715951e-01f, -1.10675707e-01f, -2.45432183e-02f,
  8.99554119e-02f, 2.42347226e-01f, 6.70900866e-02f, -1.61288872e-01f, -1.96499541e-01f, -1.08721234e-01f, 9.30677075e-03f, 4.04739864e-02f, -5.01626879e-02f, -1.20466486e-01f,
  -2.22470671e-01f, 5.67785911e-02f, 7.45508745e-02f, -9.72561091e-02f, -1.67739823e-01f, -3.96916717e-02f, -9.19447914e-02f, 4.57963645e-02f, -2.18730513e-02f, -1.51895836e-01f,
  -1.37640432e-01f, -1.73481703e-01f, -6.88624531e-02f, -5.71756326e-02f, -7.92337060e-02f, 2.08186684e-03f, -5.79118729e-02f, 6.71068728e-02f, -5.47085330e-02f, 3.78482230e-02f,
  1.45512596e-02f, -1.04099691e-01f, -3.41562554e-02f, -8.82678553e-02f, -1.45362243e-02f, -1.79161638e-01f, -1.55535832e-01f, -2.08065659e-03f, 5.93811348e-02f, 1.03187278e-01f,
  -1.27321109e-01f, -5.97531684e-02f, -2.11871024e-02f, -2.37965416e-02f, 4.44630310e-02f, 1.80241093e-01f, 1.33160084e-01f, 2.99591068e-02f, 4.77446914e-02f, 7.92488828e-03f,
  1.21315211e-01f, 3.95472683e-02f, 1.38846219e-01f, -8.67794305e-02f, -1.18926875e-01f, 1.33750392e-02f, 1.59983430e-02f, 2.73932796e-02f, -1.20841198e-01f, 4.16786736e-03f,
  2.92281527e-02f, -2.62702499e-02f, -1.23681791e-01f, -2.68195540e-01f, -1.07415043e-01f, -1.67241260e-01f, -1.46586627e-01f, -1.10297151e-01f, -1.66184083e-01f, -1.86637834e-01f,
  4.93892223e-01f, -8.10126513e-02f, 2.53633082e-01f, -6.47301525e-02f, -1.77974194e-01f, -1.04877315e-01f, -4.00954224e-02f, -6.17831163e-02f, -8.28006938e-02f, -2.76162708e-03f,
  4.35982272e-03f, -1.13237780e-02f, 4.18887287e-03f, 1.87999234e-01f, 2.30965182e-01f, 1.34072214e-01f, 1.23898633e-01f, 3.34789276e-01f, 1.90862045e-01f, 1.73248053e-02f,
  3.48936506e-02f, -1.32487286e-02f, 1.90562621e-01f, 2.12335736e-01f, -2.47562118e-02f, 9.66895968e-02f, 9.80743989e-02f, 3.20775323e-02f, -1.82578620e-02f, 3.91534604e-02f,
  6.32600039e-02f, 1.58745840e-01f, 7.94012547e-02f, -2.59008985e-02f, 5.15274070e-02f, 6.76360503e-02f, -3.72485518e-02f, 5.82844988e-02f, 2.72534732e-02f, -9.18901525e-03f,
  5.19357696e-02f, 7.56877363e-02f, 7.08815977e-02f, -9.42120925e-02f, -2.15547923e-02f, -4.75514047e-02f, 1.24351643e-01f, 2.09545404e-01f, 5.71398735e-02f, 9.83472168e-02f,
  1.59448646e-02f, -1.36805505e-01f, -6.58276975e-02f, 5.56582473e-02f, 1.49466142e-01f, -5.04982881e-02f, 9.39506516e-02f, 9.46683809e-02f, 7.73019642e-02f, 8.10524970e-02f,
  -2.83550452e-02f, 2.87132077e-02f, 6.47084862e-02f, 1.44112958e-02f, 1.18110292e-01f, 4.26018089e-02f, -4.90149157e-03f, 2.20218357e-02f, 1.30738914e-01f, 6.34639710e-02f,
  6.11919723e-03f, -1.25636216e-02f, 4.89725433e-02f, 8.73967707e-02f, -5.65159647e-03f, 5.06756715e-02f, 5.01875533e-03f, -9.78540257e-02f, -8.09562057e-02f, -1.08450495e-01f,
  4.93656099e-03f, 4.81542498e-02f, 5.07284738e-02f, 1.63539559e-01f, 8.17160867e-03f, 7.09348544e-02f, -1.50479442e-02f, -1.00201935e-01f, -1.11678764e-01f, -7.18573406e-02f,
  -5.03364980e-01f, 1.80671960e-01f, -8.96767378e-02f, 5.05524427e-02f, 5.67597896e-02f, -8.81150588e-02f, -8.04799329e-03f, -8.94146934e-02f, -1.48163110e-01f, -1.42024651e-01f,
  -1.84456065e-01f, 1.15977846e-01f, 3.73325422e-02f, -5.12053370e-02f, -7.54399672e-02f, -6.41467124e-02f, -3.32267536e-03f, -7.50975087e-02f, 7.19123110e-02f, -1.51041344e-01f,
  -4.69869487e-02f, -1.27492487e-01f, -2.39856899e-01f, -1.41243532e-01f, -6.37650490e-02f, -3.39470357e-02f, -1.16505459e-01f, -1.69700757e-01f, -1.09114893e-01f, -1.25555277e-01f,
  -4.41244602e-01f, -2.39875630e-01f, -5.01887739e-01f, 1.36762887e-01f, 2.08365053e-01f, -3.49800698e-02f, -3.57655406e-01f, -1.27230823e-01f, 2.66600430e-01f, 3.85094471e-02f,
  1.75081819e-01f, 2.84288585e-01f, 5.05809002e-02f, -5.74040636e-02f, -2.42700741e-01f, -1.59878224e-01f, -7.30595216e-02f, -3.04755807e-01f, -1.98950693e-01f, 2.01093122e-01f,
  3.15885186e-01f, 1.24552853e-01f, -9.79385898e-02f, -7.57644624e-02f, 2.39088073e-01f, 1.73213959e-01f, 3.35155986e-02f, 5.73041700e-02f, 5.36181033e-02f, 1.30104974e-01f,
  -8.44114870e-02f, -2.72809863e-01f, 7.19239041e-02f, 1.72487304e-01f, 5.06519079e-02f, -3.71445686e-01f, -7.13312924e-02f, -2.43425220e-01f, 1.48962110e-01f, -7.80108422e-02f,
  1.62150770e-01f, -6.73737153e-02f, 2.49309167e-01f, 7.22322091e-02f, 7.87438005e-02f, -9.84706283e-02f, -2.19240680e-01f, -3.77625763e-01f, -3.19959402e-01f, -2.82289416e-01f,
  3.17729563e-01f, 4.64943908e-02f, -3.32253575e-01f, -2.42193028e-01f, -2.48875976e-01f, -9.76026133e-02f, -2.55048454e-01f, -1.22032747e-01f, -3.65021914e-01f, -2.54279584e-01f,
  4.65733223e-02f, 6.44852519e-02f, -8.25976729e-02f, -1.05250366e-01f, 5.33050969e-02f, 1.25126243e-01f, 1.21915452e-01f, 1.40147328e-01f, 8.45586732e-02f, -4.09503877e-02f,
  7.76238218e-02f, -6.63157925e-02f, -9.10344440e-03f, 7.21416920e-02f, 6.77641928e-02f, -4.28432738e-03f, -3.61155951e-04f, -6.36971593e-02f, -1.34199291e-01f, -1.02306753e-01f,
  -9.33525898e-03f, 3.56905186e-03f, 1.26225308e-01f, -2.49947719e-02f, -1.72702342e-01f, -1.12153575e-01f, -6.75363168e-02f, 1.64708365e-02f, -4.14569490e-02f, -9.69781950e-02f,
  2.84964681e-01f, -1.72769010e-01f, -7.74130039e-03f, 5.56096211e-02f, -2.34942441e-03f, 8.00781921e-02f, 2.46366616e-02f, -1.77299827e-01f, -2.18974296e-02f, -9.94428843e-02f,
  -9.67048630e-02f, -1.37882889e-03f, 1.22688957e-01f, -5.26924692e-02f, -1.54810876e-01f, 1.35073597e-02f, 2.40541212e-02f, -4.99369204e-02f, -1.14914797e-01f, 8.98306668e-02f,
  -6.59194067e-02f, -2.68404186e-01f, -2.74841338e-01f, -2.73528725e-01f, 5.71273603e-02f, -1.50241688e-01f, -1.54242262e-01f, -2.15834919e-02f, -2.91126043e-01f, -2.96328545e-01f,
  -1.95037395e-01f, 8.98596272e-02f, 1.55854836e-01f, -1.38029680e-01f, -1.64726794e-01f, -4.55368549e-01f, -3.95843953e-01f, -3.56765300e-01f, -1.77077219e-01f, -8.29735622e-02f,
  7.36690387e-02f, -1.01953790e-01f, 1.31772473e-01f, -1.29877120e-01f, -1.85510769e-01f, -1.36586174e-01f, -6.52873814e-02f, -5.17497733e-02f, -3.36912394e-01f, -4.14731055e-01f,
  -2.56065309e-01f, -2.14794293e-01f, -1.50278717e-01f, -1.06263869e-01f, 7.99520910e-02f, 5.81793077e-02f, 1.18283525e-01f, -5.50682172e-02f, 3.28732394e-02f, 9.06836540e-02f,
  2.29119241e-01f, -1.01582363e-01f, -7.59425536e-02f, -5.50336018e-02f, 1.47078643e-02f, -7.81612545e-02f, 1.61046032e-02f, -2.11250074e-02f, 1.24276907e-03f, -8.59568715e-02f,
  9.42455977e-03f, -7.14141056e-02f, -2.04132441e-02f, -9.22433194e-03f, -6.50993735e-02f, -1.72825605e-01f, -9.20646545e-03f, -1.83505222e-01f, -7.02606738e-02f, -8.97553982e-05f,
  -4.92711999e-02f, -1.81331545e-01f, -6.40074834e-02f, -1.84170842e-01f, -1.18132621e-01f, -6.89430982e-02f, 2.02422962e-02f, -1.73656732e-01f, -1.28045738e-01f, 3.86158563e-02f,
  -1.31762668e-01f, -7.10588247e-02f, -2.15415135e-01f, -1.91053987e-01f, -2.52155453e-01f, -1.49778500e-01f, -1.25566646e-01f, -8.88399184e-02f, -2.05394462e-01f, -1.61847979e-01f,
  -1.80654615e-01f, -1.45092353e-01f, -1.75049648e-01f, 3.95094370e-03f, -4.50342409e-02f, -2.01664418e-02f, -2.27849036e-01f, -1.39448598e-01f, -2.05465734e-01f, -1.25875503e-01f,
  -6.00707009e-02f, -8.42304602e-02f, -2.44209245e-02f, -1.22653805e-02f, -9.28859636e-02f, -9.51260328e-02f, -2.96990350e-02f, -1.53307199e-01f, 2.89010187e-03f, -3.59295383e-02f,
  1.99202029e-03f, 4.11547348e-02f, 1.92880541e-01f, -1.23940036e-03f, 1.62502632e-01f, 1.80085480e-01f, 1.45096213e-01f, 1.14881530e-01f, 6.20510578e-02f, -1.62803195e-02f,
  -1.16477497e-01f, -6.48812801e-02f, 9.29399654e-02f, -5.74398134e-03f, -1.51381433e-01f, 2.58142632e-02f, 5.84990755e-02f, 9.47988182e-02f, -2.48861071e-02f, 2.08466463e-02f,
  9.12609324e-02f, -2.92047728e-02f, -7.58937970e-02f, 4.38503316e-03f, -1.34745538e-02f, 2.35558301e-02f, 8.88751149e-02f, 1.54672423e-02f, 6.60174340e-02f, 4.30433750e-02f,
  -1.60660688e-02f, -3.34081016e-02f, -1.24749891e-01f, 2.58080605e-02f, -1.27561435e-01f, -1.74168423e-01f, -1.17245927e-01f, 3.18435058e-02f, 1.78521708e-01f, 1.75917670e-01f,
  2.48624384e-01f, 1.94500700e-01f, 9.12013873e-02f, -6.10130019e-02f, -1.59177274e-01f, -7.86940232e-02f, -9.14848372e-02f, -2.99560189e-01f, -1.38633683e-01f, -5.90754040e-02f,
  -1.48061767e-01f, -2.47788459e-01f, -2.20921844e-01f, -1.05367638e-01f, -1.25940458e-03f, -3.58002223e-02f, -1.11244880e-01f, -7.92624429e-02f, -7.87604898e-02f, -9.95256454e-02f,
  -1.60233140e-01f, -1.96863875e-01f, -7.14348182e-02f, -4.05318439e-02f, -2.66227406e-02f, 1.46224396e-02f, -1.40845373e-01f, 1.80070493e-02f, 1.45447865e-01f, 1.30559593e-01f,
  -8.49802867e-02f, -6.80061728e-02f, -1.64389148e-01f, 5.39413914e-02f, 5.16275428e-02f, -2.24464154e-03f, 1.66534752e-01f, 1.48910791e-01f, 4.68736589e-02f, 8.11015144e-02f,
  7.89765045e-02f, -3.04269567e-02f, 3.37577723e-02f, 6.13278486e-02f, 9.48479250e-02f, 8.34099948e-02f, 1.43823192e-01f, 1.22552983e-01f, 1.62469655e-01f, 2.44044885e-01f,
  3.57324034e-02f, 3.76594700e-02f, 1.24745525e-01f, 2.25143135e-01f, 1.17982730e-01f, 1.22356780e-01f, 4.38894471e-03f, 3.14826742e-02f, 4.29351628e-02f, 1.12577388e-02f,
  7.89978653e-02f, 8.70531425e-02f, -4.25053984e-02f, -2.87963524e-02f, -9.74647552e-02f, -8.71484354e-02f, -1.20288931e-01f, 3.90099436e-02f, 3.48958746e-02f, 3.54908928e-02f,
  7.32199242e-03f, -1.08698726e-01f, -4.56522852e-02f, -1.40207201e-01f, 9.08329850e-04f, 1.68092608e-01f, -3.11931260e-02f, 6.80188686e-02f, -3.89534049e-02f, -1.77740138e-02f,
  6.38131946e-02f, -1.79152220e-01f, -9.37750936e-02f, -1.22752048e-01f, -8.75899866e-02f, 3.90517898e-02f, 3.11934426e-02f, -1.11241892e-01f, -8.74310657e-02f, -1.39411911e-03f,
  -1.37751480e-03f, -5.97023182e-02f, -8.82327631e-02f, 5.28702214e-02f, 4.89490293e-02f, 1.16064876e-01f, 1.96154952e-01f, 4.66081910e-02f, 5.88135310e-02f, 1.00277521e-01f,
  -3.67531069e-02f, 1.24387048e-01f, 1.29979789e-01f, 5.38103059e-02f, 6.11828752e-02f, -3.50049734e-02f, 2.71058269e-02f, 1.29415980e-03f, -4.83427523e-03f, 2.17313051e-01f,
  5.84619761e-01f, -4.09781486e-01f, 2.00685054e-01f, 3.39916945e-02f, -7.68408030e-02f, 3.00108232e-02f, -9.14513916e-02f, -1.03103653e-01f, 6.39532208e-02f, -1.07245103e-01f,
  -4.05523241e-01f, -2.95591712e-01f, -2.41748720e-01f, -1.97952449e-01f, -4.37952392e-02f, 2.30298609e-01f, 2.62546837e-01f, 2.42309660e-01f, 3.36557567e-01f, 1.25154138e-01f,
  -1.59373224e-01f, 1.04021803e-01f, 5.99921122e-02f, 1.24828361e-01f, -1.76807791e-01f, -1.04541726e-01f, -1.09164849e-01f, -1.27231972e-02f, -1.76695004e-01f, -1.04043841e-01f,
  8.80272537e-02f, -1.55902743e-01f, 3.55113670e-02f, -1.61245167e-01f, -1.86824985e-02f, 4.48437743e-02f, -8.88901576e-03f, 2.04556878e-03f, 6.45518824e-02f, 9.88901407e-02f,
  -7.53007084e-02f, -1.35541931e-01f, -3.79213085e-03f, -1.35866374e-01f, 5.03745787e-02f, -2.64200941e-02f, -7.38651827e-02f, -6.53052479e-02f, -1.36463732e-01f, -1.21856399e-01f,
  -2.71099031e-01f, -1.29489480e-02f, -5.38299643e-02f, 4.51064594e-02f, -3.64621393e-02f, -4.96581756e-02f, 4.98188380e-03f, -2.84976978e-02f, -7.21524805e-02f, 1.12224482e-01f,
  9.24806595e-02f, -8.06647819e-03f, -2.08932161e-01f, -8.20760056e-02f, 1.04357652e-01f, -1.89505816e-02f, 8.62119049e-02f, 5.02158366e-02f, 5.72809801e-02f, 5.41001260e-02f,
  -1.51275888e-01f, 8.14497191e-03f, -6.08932367e-03f, -7.93420598e-02f, -9.32180658e-02f, -1.01068728e-01f, 6.42380640e-02f, -5.51364087e-02f, -2.05338046e-01f, -1.83058113e-01f,
  -8.34945440e-02f, -1.67712029e-02f, -4.66297008e-02f, -1.71136096e-01f, -1.96183458e-01f, -3.63206416e-02f, -3.12140863e-02f, -1.01199210e-01f, 2.35270429e-02f, 6.43080249e-02f,
  -8.51612389e-02f, -2.52814800e-01f, 1.65399581e-01f, 1.18781634e-01f, -2.17424054e-02f, -8.47988054e-02f, -4.83760349e-02f, -6.01667576e-02f, -8.27035233e-02f, 4.77190390e-02f,
  -3.50578763e-02f, 1.35295302e-01f, 4.96337749e-02f, -2.17818022e-02f, 2.15199262e-01f, 1.39903473e-02f, -7.82517493e-02f, 1.11180857e-01f, 1.04145743e-02f, -1.27340779e-01f,
  -6.95742145e-02f, 1.65537581e-01f, 2.28952199e-01f, 7.15458095e-02f, 1.79595366e-01f, 2.08173305e-01f, 1.06412984e-01f, 1.21395685e-01f, 2.22338259e-01f, 2.42313713e-01f,
  3.93282264e-01f, -4.43531275e-01f, 3.64323378e-01f, 2.65162885e-01f, 2.55081683e-01f, 3.38606358e-01f, 6.19096169e-03f, 1.90518890e-02f, 9.34299454e-02f, -4.09067087e-02f,
  -9.79074538e-02f, -1.06635951e-02f, -7.09751919e-02f, 2.96994466e-02f, -7.64663890e-02f, -8.70486721e-02f, 1.08179331e-01f, 3.14653844e-01f, 3.79569322e-01f, 9.85937566e-02f,
  -1.61795437e-01f, -4.71905507e-02f, 1.88990515e-02f, 8.12433660e-02f, -1.94859400e-01f, -2.06254935e-03f, -1.37217313e-01f, -6.70265630e-02f, -9.39912722e-02f, -1.97538644e-01f,
  -2.46703491e-01f, -1.56915307e-01f, 5.66294678e-02f, -2.15338081e-01f, -6.40734956e-02f, -7.63660148e-02f, -2.39268932e-02f, -9.92259085e-02f, -1.94242895e-01f, -1.29467025e-01f,
  -6.13768212e-02f, -5.80834374e-02f, 4.77351174e-02f, -4.69845943e-02f, -3.43021080e-02f, -8.86622723e-03f, -5.53486906e-02f, -5.98586127e-02f, -6.36995956e-02f, -3.74869369e-02f,
  -1.82666302e-01f, 9.69030801e-03f, 1.62475765e-01f, 9.77955610e-02f, 9.65636075e-02f, 8.71011540e-02f, -3.67295071e-02f, 6.10465463e-03f, 1.29766092e-01f, -4.06880770e-03f,
  7.30306550e-04f, 3.86476815e-02f, 1.31408125e-01f, 8.33436251e-02f, 2.62734778e-02f, 1.53210148e-01f, 3.45470347e-02f, 1.34044047e-02f, 9.48570892e-02f, 7.44752735e-02f,
  5.37587814e-02f, 4.29132506e-02f, 5.02530783e-02f, 6.99579194e-02f, 2.07117070e-02f, 6.94365874e-02f, 4.45438884e-02f, -8.73807222e-02f, 8.29693023e-03f, -2.94071715e-03f,
  1.08466826e-01f, -7.59705231e-02f, -3.73388827e-02f, 2.67251562e-02f, -1.12742884e-03f, -1.17315594e-02f, -1.28588900e-02f, -4.82343212e-02f, -2.31630970e-02f, -3.98544580e-05f,
  -2.07758710e-01f, 2.24037558e-01f, 9.75815430e-02f, -8.19570124e-02f, -4.70850766e-02f, -2.80364994e-02f, 3.59171890e-02f, -1.28187810e-03f, -1.72631368e-02f, 1.53028518e-02f,
  4.36373521e-03f, 2.64989976e-02f, -3.13179903e-02f, 2.67816596e-02f, 1.05611287e-01f, 1.31142184e-01f, -1.72166526e-01f, 8.60622823e-02f, -1.93053111e-02f, -1.27354220e-01f,
  -5.36722131e-02f, 1.75056994e-01f, 2.59096533e-01f, 1.67048469e-01f, 1.77603196e-02f, 1.76817328e-01f, 9.02979746e-02f, 8.97081122e-02f, 1.66837990e-01f, 1.12280652e-01f,
  -1.25350486e-02f, -3.85414064e-02f, 9.74268988e-02f, 1.51292592e-01f, 1.47546887e-01f, 1.33074060e-01f, 7.10787997e-02f, 9.40606594e-02f, 2.25813806e-01f, 1.08883768e-01f,
  4.73059490e-02f, 5.97195365e-02f, 2.04573646e-01f, 9.87805724e-02f, 1.31163657e-01f, 1.99825808e-01f, 2.76033819e-01f, 2.33907461e-01f, 2.13225886e-01f, 4.86822315e-02f,
  1.38213143e-01f, 1.25540450e-01f, 1.68738477e-02f, 5.14250919e-02f, 9.70176160e-02f, 7.27474540e-02f, 1.03019565e-01f, 1.24937117e-01f, 9.06921253e-02f, 1.21984765e-01f,
  4.37359437e-02f, -1.54901341e-01f, 1.43717695e-02f, -1.63816214e-01f, -7.56674930e-02f, -1.93187386e-01f, 1.97067391e-02f, -9.40790251e-02f, -1.25827298e-01f, 7.53250346e-02f,
  1.35721574e-02f, -1.35139838e-01f, 3.77822556e-02f, -1.26162589e-01f, -1.93893537e-02f, -3.23697962e-02f, -1.09639250e-01f, 2.34132726e-03f, 7.16915429e-02f, -3.80027220e-02f,
  -3.19167748e-02f, -1.38611406e-01f, 9.46237445e-02f, 4.99366783e-02f, 7.83124045e-02f, 3.31902923e-03f, 5.46644675e-03f, -5.86177073e-02f, -8.59130397e-02f, 1.74791887e-02f,
  -2.52892915e-02f, 1.26102626e-01f, 2.88737621e-02f, -1.55232340e-01f, -7.12821856e-02f, 6.33658990e-02f, 7.44126588e-02f, 4.19715829e-02f, 1.35260625e-02f, -1.34674534e-01f,
  4.38671038e-02f, 1.81555986e-01f, 1.71461374e-01f, 9.14572030e-02f, -4.03319709e-02f, -8.02080035e-02f, 2.27860399e-02f, 1.05433255e-01f, 4.65666950e-02f, 5.33399619e-02f,
  9.98570621e-02f, 1.50943398e-01f, -1.45651206e-01f, 8.80915523e-02f, 1.50522869e-02f, -2.94028316e-02f, -2.69294418e-02f, 3.10413763e-02f, 1.40485242e-02f, -6.33512856e-03f,
  1.55739889e-01f, 1.13184430e-01f, 8.10806006e-02f, 1.40533760e-01f, -1.24680184e-01f, -1.19765863e-01f, 7.30898157e-02f, 2.44920645e-02f, -8.09517205e-02f, 1.40890539e-01f,
  6.33687824e-02f, 3.53480503e-02f, 1.09829549e-02f, -9.27619934e-02f, -2.57754587e-02f, -1.61452755e-01f, -8.88637751e-02f, 8.87459815e-02f, 2.96848826e-02f, 7.46210963e-02f,
  -2.72495393e-02f, -8.08003396e-02f, 1.20291561e-01f, 1.11536339e-01f, 1.10194854e-01f, -4.77518514e-03f, -3.72302011e-02f, 3.69039364e-02f, -2.70355083e-02f, -5.63508905e-02f,
  1.27116323e-01f, 2.00099558e-01f, -1.65508538e-02f, 1.81982279e-01f, 2.71558762e-01f, 2.41362125e-01f, 3.03143919e-01f, 2.50880480e-01f, 2.25235105e-01f, 2.11805254e-01f,
  1.95722580e-01f, 2.15056956e-01f, 1.10933058e-01f, 7.00106099e-02f, 1.77706823e-01f, 2.24065989e-01f, 2.36306578e-01f, 9.00015533e-02f, 1.10390715e-01f, 1.39380559e-01f,
  1.73862070e-01f, 6.48019761e-02f, 4.94566858e-02f, 1.10182405e-01f, -2.39137486e-02f, 1.72056958e-01f, 1.07480176e-01f, -2.63482817e-02f, 5.92582710e-02f, 6.40950873e-02f,
  -2.21611977e-01f, -9.93770808e-02f, 4.50319089e-02f, -9.58119035e-02f, -4.86456081e-02f, -7.57969543e-02f, -1.20304421e-01f, -4.66034748e-03f, 4.91836295e-02f, 1.74619246e-03f,
  -2.31373347e-02f, -5.40074259e-02f, -1.23524316e-01f, -1.43808186e-01f, -1.28383264e-01f, -9.01049897e-02f, -3.92509475e-02f, -2.38425448e-03f, 1.63365215e-01f, -6.59397766e-02f,
  4.93603572e-02f, 1.55494716e-02f, -3.05677447e-02f, 7.59781152e-02f, 4.46979553e-02f, 2.04715971e-03f, -7.89812431e-02f, 2.19890382e-02f, -6.71837032e-02f, -3.43878008e-02f,
  2.12741703e-01f, 1.96146995e-01f, -3.97220179e-02f, 4.62516164e-03f, -1.06166251e-01f, 9.04745422e-03f, -3.48546281e-02f, -2.34008487e-02f, 1.18737169e-01f, -3.01866662e-02f,
  2.33433247e-02f, -4.68387119e-02f, -1.43407017e-01f, 2.74893865e-02f, -2.98610758e-02f, 3.03820316e-02f, -1.30682871e-01f, -1.88681588e-01f, -1.07633978e-01f, -6.80353716e-02f,
  -6.18598685e-02f, 5.28861508e-02f, -8.45761523e-02f, -1.78356469e-01f, -9.10110325e-02f, -2.33654603e-02f, -7.01373070e-02f, 8.25845543e-03f, -3.04634254e-02f, 6.06576167e-02f,
  1.14161380e-01f, -1.56716794e-01f, -4.78877779e-03f, 6.54571578e-02f, -9.65403467e-02f, -4.27964367e-02f, -7.06509799e-02f, -1.14652000e-01f, -1.88403815e-01f, -1.57795176e-01f,
  -1.01522207e-01f, -2.75443587e-02f, 1.34557742e-03f, 2.38307249e-02f, -3.91761884e-02f, -1.09334022e-01f, 1.44723859e-02f, 1.03575110e-01f, 7.75458068e-02f, 2.13651787e-02f,
  -1.14511652e-03f, 9.46868807e-02f, 2.78723966e-02f, 1.08935439e-03f, 6.97926357e-02f, 1.44191191e-01f, 3.26817743e-02f, 3.00885104e-02f, 3.24416459e-02f, 4.25003991e-02f,
  -5.63283384e-01f, 1.19955681e-01f, 6.54293597e-02f, -2.86993295e-01f, 9.00123715e-02f, 2.62105584e-01f, 3.35022032e-01f, 9.56438705e-02f, -8.55050385e-02f, 1.57062575e-01f,
  1.42697655e-02f, -1.06801316e-01f, 7.71666178e-03f, 1.61984116e-01f, 1.52559534e-01f, 1.84025958e-01f, 3.25230032e-01f, 1.03227854e-01f, -6.21765144e-02f, -4.33792621e-02f,
  1.59168258e-01f, -1.12630695e-01f, -3.38114411e-01f, -6.89917430e-02f, 1.18244782e-01f, 9.61231068e-02f, 3.65325324e-02f, -6.20660894e-02f, 1.32350102e-01f, 1.84433088e-01f,
  -2.22858503e-01f, -3.48877013e-01f, -1.38027836e-02f, -1.43798336e-01f, 5.68596721e-02f, -9.17635784e-02f, -6.32887483e-02f, -1.62904114e-02f, 1.06298238e-01f, -6.93151802e-02f,
  -8.78399089e-02f, -1.88665371e-02f, 1.66094393e-01f, -1.48228854e-01f, -9.56556052e-02f, -1.23625584e-01f, -1.40568754e-02f, -1.85647592e-01f, -1.58943489e-01f, -5.48786484e-02f,
  3.25479865e-01f, -4.90346849e-02f, -2.34417766e-01f, 8.54642391e-02f, 8.76294822e-03f, -1.70577019e-01f, -8.07847902e-02f, -1.68191969e-01f, -1.51935518e-01f, -2.99338013e-01f,
  -9.33881104e-02f, 3.90393287e-02f, 4.91520986e-02f, 1.00575067e-01f, -4.41766679e-02f, -1.31643899e-02f, 1.50777012e-01f, 1.95445523e-01f, 4.01738249e-02f, 3.02234758e-02f,
  1.43074423e-01f, -1.03546306e-01f, 4.69386242e-02f, -1.26508307e-02f, -6.68570399e-02f, -5.06528541e-02f, 4.32412773e-02f, -1.15702692e-02f, -1.03446124e-02f, -3.90853398e-02f,
  -8.47985744e-02f, -1.14971377e-01f, -7.83321187e-02f, 4.45585921e-02f, 1.35897517e-01f, 1.02080584e-01f, -7.84248859e-02f, -1.66980233e-02f, -8.18230957e-02f, 5.07927835e-02f,
  -1.36602119e-01f, 7.37843290e-02f, -1.66906521e-01f, 5.05066067e-02f, 1.02647118e-01f, 3.90187539e-02f, 3.42086405e-02f, -9.68519822e-02f, -9.17591304e-02f, -2.04297781e-01f,
  -3.77813564e-03f, -4.27432321e-02f, -3.93818431e-02f, 5.91907166e-02f, -1.27883151e-01f, -1.81585878e-01f, -2.36675590e-02f, 3.73780243e-02f, 4.49308828e-02f, -3.88063006e-02f,
  6.20303340e-02f, -1.55524865e-01f, -3.14150393e-01f, 5.26703708e-02f, 2.00987123e-02f, -1.15337774e-01f, -1.76955283e-01f, -1.03378005e-01f, -6.30195886e-02f, -2.96387821e-01f,
  5.51348031e-01f, 2.86867350e-01f, 2.73490131e-01f, 1.66653290e-01f, 1.77337602e-01f, 1.16134390e-01f, 8.08967054e-02f, 2.02726871e-01f, 3.18231434e-02f, 8.11758190e-02f,
  2.18129635e-01f, 1.92541227e-01f, 1.28120020e-01f, 9.30248499e-02f, 1.40807196e-01f, 4.18152474e-02f, 5.12687005e-02f, 1.95925295e-01f, 1.80849254e-01f, 1.98265284e-01f,
  1.74495414e-01f, 1.80001661e-01f, 8.82953629e-02f, 1.96254909e-01f, 9.13079157e-02f, 1.21680342e-01f, 2.01918706e-01f, 1.30484089e-01f, 1.95941955e-01f, 7.25826025e-02f,
  -1.49386957e-01f, 1.94400758e-01f, -1.05181940e-01f, 9.03921574e-02f, -5.34314737e-02f, 2.33505201e-02f, -2.04803701e-02f, -6.64495528e-02f, -8.52167383e-02f, -5.35103492e-02f,
  -6.94324598e-02f, 3.69143821e-02f, 9.49525759e-02f, 3.88548933e-02f, -8.20770040e-02f, 2.44164579e-02f, -2.13256758e-02f, -4.14672531e-02f, -7.73287341e-02f, -9.47541371e-02f,
  -3.24612521e-02f, -8.13600048e-02f, -1.22994632e-01f, 1.88328661e-02f, 2.24117339e-02f, 2.04609521e-03f, 9.44146421e-03f, -7.40001574e-02f, -4.55768928e-02f, -1.61764827e-02f,
  1.81939751e-01f, 4.84680943e-02f, 1.02142707e-01f, 1.96219340e-01f, 2.66428828e-01f, 3.88664827e-02f, 5.19643351e-02f, -5.70688546e-02f, 1.07079268e-01f, -5.64271659e-02f,
  -6.32244945e-02f, -2.20245700e-02f, -6.17084205e-02f, 4.84645776e-02f, 1.09894104e-01f, 1.76694393e-02f, -4.07304540e-02f, 1.12382539e-01f, 6.88696504e-02f, 8.28689858e-02f,
  6.91086128e-02f, -8.33953768e-02f, 7.03378348e-03f, 4.16448563e-02f, -3.64757441e-02f, 5.27430847e-02f, 1.60741825e-02f, 2.74230214e-03f, 1.67095453e-01f, 1.09267026e-01f,
  -3.71602565e-01f, 7.18859285e-02f, 5.37202246e-02f, -1.25938237e-01f, 3.76026295e-02f, -8.73805657e-02f, -4.58929017e-02f, -1.04582876e-01f, -2.52605956e-02f, -1.04942955e-01f,
  -1.20608456e-01f, -3.26641127e-02f, -1.14395522e-01f, 4.39166054e-02f, 1.05219465e-02f, -7.38260299e-02f, -1.35781497e-01f, -4.86038849e-02f, -7.96554312e-02f, -1.81015581e-01f,
  -4.70231287e-02f, -1.27963290e-01f, -2.44450867e-01f, -6.09802641e-02f, 9.01702500e-04f, -4.65357155e-02f, -3.03612892e-02f, -1.38551638e-01f, -2.98993289e-02f, -1.04526587e-01f,
  1.73153609e-01f, -1.68486521e-01f, -3.02213669e-01f, 2.37376504e-02f, -1.47557676e-01f, -2.94870045e-02f, 4.95026121e-03f, -1.12329893e-01f, 6.37903460e-04f, 7.38121942e-02f,
  1.60613395e-02f, -2.56102718e-02f, 9.49055627e-02f, 3.66681926e-02f, 3.24258395e-02f, -8.74975845e-02f, -1.32500425e-01f, -1.40641525e-01f, -8.34215581e-02f, -1.09786622e-01f,
  7.52274767e-02f, 8.77668634e-02f, 6.82945251e-02f, -7.14521930e-02f, -1.63960680e-01f, 5.76045141e-02f, -2.23810613e-01f, -1.03484519e-01f, -7.41354302e-02f, -2.33856335e-01f,
  2.02639222e-01f, -2.18386739e-01f, 1.46020427e-02f, 2.26300731e-02f, -1.93641782e-01f, 7.73674771e-02f, 7.42714554e-02f, -1.25046656e-01f, 2.84330416e-02f, 6.95340186e-02f,
  2.93399971e-02f, -9.43842679e-02f, -3.86140421e-02f, 4.41663601e-02f, -1.44325132e-02f, -2.74681821e-02f, -2.58046418e-01f, -1.76109329e-01f, -1.99319750e-01f, -1.74303085e-01f,
  -1.52703404e-01f, -2.05675110e-01f, -1.41112387e-01f, -1.24474429e-01f, -2.71323502e-01f, -5.18602505e-02f, -1.23758636e-01f, -3.05872202e-01f, -1.64418519e-01f, -3.21828425e-02f,
  -2.19703335e-02f, 5.35331294e-02f, -2.11710054e-02f, 5.91253815e-03f, 9.77159292e-02f, 3.03334687e-02f, -5.30597381e-02f, -5.94598353e-02f, 3.39058675e-02f, 8.67555514e-02f,
  -1.71325237e-01f, -2.65601240e-02f, -9.36483964e-02f, 2.60569365e-03f, -6.22882787e-03f, -7.83962831e-02f, 4.24669459e-02f, -1.03646014e-02f, -1.61207989e-02f, 1.09957352e-01f,
  9.15376619e-02f, -5.32180332e-02f, -2.20820634e-03f, -3.95877892e-03f, -1.08518086e-01f, -7.37645775e-02f, -5.84562346e-02f, 4.32120450e-02f, 3.97249572e-02f, -7.17113027e-03f,
  2.94686824e-01f, -1.25139073e-01f, 1.54272377e-01f, -1.63429286e-02f, -5.72701469e-02f, -7.73517340e-02f, 6.42948076e-02f, -6.46228716e-02f, 4.49962281e-02f, 2.04783201e-01f,
  -6.20013215e-02f, 5.76913208e-02f, 4.86036278e-02f, 8.15378949e-02f, 7.55142868e-02f, 1.31019754e-02f, 6.49335459e-02f, -6.20006397e-02f, -1.98191516e-02f, 5.88685125e-02f,
  6.18141443e-02f, 5.18957935e-02f, 2.05702856e-01f, 1.45328827e-02f, 1.04239648e-02f, 1.76737472e-01f, 4.10739481e-02f, 1.01029843e-01f, 1.64548203e-01f, 2.27004051e-01f,
  -7.14410543e-02f, -2.48171631e-02f, 2.22944915e-01f, 1.73462197e-01f, 2.91364528e-02f, -2.94350564e-01f, -3.88183922e-01f, -2.56670892e-01f, 4.11770456e-02f, 6.35073520e-03f,
  2.60924199e-03f, 9.10045654e-02f, -3.47071625e-02f, -2.77397949e-02f, -6.84214905e-02f, -3.69014293e-02f, -7.09208846e-03f, 3.10897343e-02f, -2.80733239e-02f, -8.68248343e-02f,
  -2.67906487e-02f, -4.37646396e-02f, 8.00584555e-02f, 3.12681273e-02f, 1.55181259e-01f, 9.48697180e-02f, 1.04564883e-01f, 1.26588941e-01f, 3.40419970e-02f, 3.07977319e-01f,
  5.08898854e-01f, 1.97867095e-01f, 2.08441950e-02f, 5.45752831e-02f, 1.64084762e-01f, 2.62296330e-02f, -2.23767925e-02f, 1.32028952e-01f, 5.34089468e-03f, -6.05502054e-02f,
  1.42621920e-01f, 5.46512939e-02f, 1.81198791e-02f, 4.85504977e-02f, 6.11579865e-02f, 1.56147867e-01f, 9.16949064e-02f, -4.40757014e-02f, -1.39076591e-01f, 7.74621069e-02f,
  1.23876855e-01f, 6.63254559e-02f, -1.96889304e-02f, -1.62768587e-01f, -2.26361468e-01f, 5.72794527e-02f, 3.60068791e-02f, 4.41993140e-02f, -1.69131719e-02f, -1.21579237e-01f,
  -1.42143056e-01f, -1.07539356e-01f, 1.00647360e-01f, 1.96190868e-02f, -1.21512413e-01f, -3.20956111e-02f, -4.35352139e-02f, -1.27182171e-01f, -1.79099560e-01f, -1.42439827e-01f,
  -8.46233144e-02f, -4.88176495e-02f, 3.73186963e-03f, 2.72275265e-02f, 2.15897754e-01f, 8.78399536e-02f, 5.14801815e-02f, 6.91158772e-02f, 1.48980796e-01f, 8.64531174e-02f,
  4.49988209e-02f, 3.95529298e-03f, 2.01276332e-01f, 1.79636665e-02f, 1.28153428e-01f, 1.63012117e-01f, 4.53720652e-02f, 4.83265333e-02f, -7.01424927e-02f, -8.35177582e-03f,
  9.29194689e-02f, -9.88000780e-02f, 2.63816565e-02f, 5.87128699e-02f, -2.05340851e-02f, 8.52403194e-02f, 1.51648805e-01f, 1.74945027e-01f, 1.22625396e-01f, 6.22289218e-02f,
  1.50369197e-01f, 9.76184681e-02f, 2.38392204e-02f, -1.77555606e-02f, -6.22864515e-02f, 1.16366215e-01f, 7.28316978e-02f, -1.35074398e-02f, 8.56385380e-03f, 4.49281372e-02f,
  -7.83863366e-02f, -8.68959352e-02f, -1.16841592e-01f, -1.21237881e-01f, -5.94022982e-02f, -9.92818326e-02f, -2.48655733e-02f, 1.17114503e-02f, 3.66190784e-02f, -1.00515664e-01f,
  7.18737900e-01f, 4.44034100e-01f, 2.06019238e-01f, 5.52758165e-02f, -1.04973175e-01f, 1.26461565e-01f, 3.19861293e-01f, 1.90062627e-01f, 7.97514431e-03f, 1.70047089e-01f,
  1.72495693e-01f, 2.34101936e-02f, -1.12073356e-02f, 7.34169558e-02f, 1.83206663e-01f, 5.70092984e-02f, -3.46360132e-02f, -3.28894593e-02f, -3.91474925e-02f, 1.46572478e-02f,
  -1.25269815e-01f, -8.37752819e-02f, 1.28915191e-01f, -5.30981235e-02f, -2.79309750e-02f, -1.32463917e-01f, -2.34948527e-02f, -5.74712493e-02f, 2.51421575e-02f, -8.36533904e-02f,
  -1.18068188e-01f, 3.62098008e-01f, -1.22593835e-01f, 4.79156114e-02f, 5.03667332e-02f, 3.12927961e-02f, 2.40791757e-02f, 6.88685756e-03f, 2.42682472e-02f, -8.51329118e-02f,
  -1.45954378e-02f, -3.70821990e-02f, 1.41687626e-02f, 1.01752035e-01f, -1.94561493e-03f, 2.41247611e-03f, 8.17803219e-02f, 2.05447122e-01f, 1.15895204e-01f, 5.00517152e-02f,
  1.11450486e-01f, 1.13368770e-02f, 1.29331723e-01f, 9.35570374e-02f, 1.52750775e-01f, -4.12325971e-02f, 8.99252966e-02f, 1.91332009e-02f, 1.17887393e-01f, 8.86319354e-02f,
  -3.01050022e-02f, 1.70431957e-02f, 9.87344459e-02f, -7.79084489e-02f, -8.75067860e-02f, -1.91635750e-02f, -1.61670148e-01f, -8.27616304e-02f, -5.13495058e-02f, -1.12767011e-01f,
  1.85540330e-03f, -9.66962278e-02f, 7.88199082e-02f, -1.57825872e-01f, -4.81565148e-02f, 5.73511571e-02f, 2.67440919e-02f, 3.06006111e-02f, -1.20346069e-01f, 5.54526486e-02f,
  6.80942386e-02f, -5.26493751e-02f, -1.27787530e-01f, -1.37940034e-01f, 2.25513484e-02f, -2.48428318e-03f, -1.31760418e-01f, 2.72364840e-02f, 3.80424634e-02f, -5.85602447e-02f,
  -9.32619125e-02f, 3.40798870e-02f, -3.30009721e-02f, 3.38901160e-03f, 1.05924690e-02f, -3.21476012e-02f, -2.01984849e-02f, -4.98358831e-02f, -1.00419253e-01f, -1.14648275e-01f,
  -9.30748805e-02f, -4.22446057e-02f, 3.57462689e-02f, 1.58326998e-02f, -6.53518513e-02f, -1.96202561e-01f, -1.24065215e-02f, 2.20176261e-02f, -6.43342827e-03f, -1.04578450e-01f,
  -5.10357283e-02f, -5.06658033e-02f, -7.63841420e-02f, -6.31234199e-02f, -4.76489142e-02f, -1.82394281e-01f, -1.21938184e-01f, -4.70542200e-02f, -1.13508284e-01f, -1.03508890e-01f,
  2.22159371e-01f, 7.93605857e-03f, -7.47513995e-02f, 1.00738361e-01f, -1.58257946e-01f, -2.70281285e-01f, -3.76820654e-01f, -3.31136316e-01f, 9.41364244e-02f, 3.73003893e-02f,
  6.08089007e-02f, 2.45411262e-01f, 7.52008408e-02f, 1.38938770e-01f, 6.48731366e-02f, 9.96161178e-02f, 6.72413930e-02f, 8.34658518e-02f, -1.24097494e-02f, 1.61970496e-01f,
  1.72158152e-01f, 9.88723487e-02f, 1.50468618e-01f, 9.28069502e-02f, 1.51058212e-01f, 9.94378924e-02f, -2.35759337e-02f, 1.14289083e-01f, 1.59485981e-01f, 4.72328424e-01f,
  2.83066481e-01f, -2.05043070e-02f, -6.44157529e-02f, 9.81992036e-02f, 6.67380765e-02f, 7.33633712e-02f, -2.74154972e-02f, -3.29526998e-02f, -8.86645168e-02f, 2.67091040e-02f,
  9.26340073e-02f, 5.21142632e-02f, 6.64178655e-02f, -8.53182375e-02f, -2.95361294e-03f, -7.34290630e-02f, -5.08400872e-02f, 2.96406709e-02f, -3.63259651e-02f, 1.14050545e-02f,
  4.93827350e-02f, 8.00412241e-03f, -1.27982408e-01f, -1.32249728e-01f, -9.46004912e-02f, 5.30730039e-02f, -6.75940439e-02f, 8.57505873e-02f, -1.12858243e-01f, -6.58404902e-02f,
  3.35256271e-02f, 1.39685154e-01f, 8.88826475e-02f, 7.22075440e-03f, 1.95028316e-02f, 3.69668007e-02f, 8.78988206e-02f, -5.77048622e-02f, 5.53639382e-02f, 2.70528141e-02f,
  -3.39656286e-02f, 5.96131373e-04f, -2.26745941e-02f, 9.08454359e-02f, 3.94060500e-02f, 3.75459297e-03f, 1.08701587e-01f, 1.41512947e-02f, -1.54914921e-02f, -1.41979102e-02f,
  1.07754134e-01f, -7.87599608e-02f, 4.68689688e-02f, 8.59496742e-02f, 9.50215980e-02f, 2.32329760e-02f, 1.43766508e-01f, -2.53571477e-02f, -2.80265100e-02f, 2.01258603e-02f,
  -1.68773517e-01f, -2.76387125e-01f, 1.80707887e-01f, -1.91586763e-02f, 5.80386855e-02f, -2.19645631e-02f, 2.36428380e-02f, -1.66565273e-02f, 4.08751331e-02f, -5.64666055e-02f,
  -4.27031470e-03f, -8.77107866e-03f, -4.69805896e-02f, -4.94641624e-02f, -9.78471637e-02f, -1.38073429e-01f, 6.53921291e-02f, 1.03793025e-01f, 4.45272913e-03f, -8.04166570e-02f,
  -1.10626295e-01f, -1.72560140e-01f, -1.08773559e-01f, -1.36219397e-01f, -9.61817354e-02f, 2.08186824e-02f, -6.98562935e-02f, -6.59208819e-02f, -1.99136660e-01f, -9.50493440e-02f,
  -3.86994451e-01f, 1.25556542e-02f, -1.93832405e-02f, -6.03911541e-02f, -6.25015721e-02f, -4.14336175e-01f, -4.24016982e-01f, -3.66246045e-01f, -4.37507108e-02f, 1.37880743e-01f,
  2.36881658e-01f, 7.24641830e-02f, 2.25679904e-01f, -5.03644766e-03f, -3.12739402e-01f, -1.11504935e-01f, -1.26216874e-01f, -2.10172057e-01f, -4.26302254e-01f, -3.99138778e-01f,
  -2.13203073e-01f, -2.52580404e-01f, -3.03770274e-01f, -1.46403164e-01f, 2.15964571e-01f, 3.32327113e-02f, 1.85176194e-01f, -9.40651521e-02f, 3.00576165e-02f, 2.34201238e-01f,
  3.04724902e-01f, -3.22483331e-01f, -1.65410414e-01f, -1.81522053e-02f, 6.14871942e-02f, 2.34406590e-02f, -6.84967823e-03f, 2.85501909e-02f, -8.45421925e-02f, 3.63305099e-02f,
  6.33338541e-02f, -4.02388796e-02f, 9.02754441e-02f, -8.74929130e-03f, 2.48399153e-02f, -2.74506817e-03f, -9.42868832e-03f, -2.34908998e-01f, 8.60666111e-03f, 4.76382896e-02f,
  1.81135789e-01f, -1.14440508e-01f, -1.23556517e-01f, -3.34312469e-02f, -5.10296859e-02f, 2.50159726e-02f, 2.56193914e-02f, -1.82923704e-01f, -8.26127753e-02f, 1.19538508e-01f,
  -4.03371155e-02f, 6.71890154e-02f, 1.13855585e-01f, 3.27066816e-02f, 5.66516668e-02f, 1.18782870e-01f, 1.57358050e-02f, 1.28660515e-01f, 4.37172018e-02f, 2.87769157e-02f,
  -4.41491865e-02f, 3.66984755e-02f, -4.20172922e-02f, 3.84178422e-02f, -2.69110352e-02f, -5.66723719e-02f, -1.46910055e-02f, 6.86950684e-02f, 9.14803892e-03f, 7.34841079e-02f,
  3.18170339e-02f, 1.12863192e-02f, 1.05925091e-02f, -5.55360094e-02f, 4.05457988e-02f, 1.97390597e-02f, -2.78610755e-02f, -2.59709526e-02f, -3.07740504e-03f, 4.41281237e-02f,
  2.08902508e-01f, -2.90221602e-01f, 4.76406217e-02f, -1.48271829e-01f, -5.48157506e-02f, 1.26854122e-01f, 1.41025320e-01f, -4.22070175e-02f, 1.43176094e-01f, -3.54382093e-03f,
  -3.50122750e-02f, 9.24078189e-03f, 1.38688296e-01f, 1.98572222e-02f, 2.28362754e-02f, 5.13897948e-02f, -3.69331427e-02f, 3.85372080e-02f, 7.92897865e-02f, 7.11511001e-02f,
  5.21442369e-02f, -8.16992968e-02f, 1.00962788e-01f, 6.48363829e-02f, -3.30908597e-02f, -6.99822158e-02f, 9.84046608e-02f, 8.83008689e-02f, -3.82424816e-02f, 8.66658688e-02f,
  -5.59729561e-02f, -7.13803172e-02f, 5.07540116e-03f, 2.29630604e-01f, -9.92617104e-03f, -3.48932177e-01f, -4.18624341e-01f, -3.84003311e-01f, 3.84410508e-02f, -9.16852877e-02f,
  6.87898397e-02f, 1.34509921e-01f, 6.19762875e-02f, 7.73561150e-02f, -1.34151727e-01f, -9.20270458e-02f, 2.33921349e-01f, 3.11839610e-01f, 1.64895467e-02f, 3.39413323e-02f,
  2.42572933e-01f, 2.47059479e-01f, 2.00710803e-01f, 2.35726789e-01f, 1.81022763e-01f, 1.41595885e-01f, 1.09410666e-01f, 1.70234263e-01f, 1.84322461e-01f, 4.08171266e-01f,
  -1.40488788e-01f, -2.52222180e-01f, -5.28576113e-02f, 1.33033708e-01f, 2.86337342e-02f, -5.96661940e-02f, -2.43860204e-03f, 1.20019965e-01f, 1.28621683e-01f, 2.93553490e-02f,
  7.57561550e-02f, 7.01142289e-03f, 6.78414926e-02f, 8.42684135e-02f, -4.87865508e-02f, -1.17813826e-01f, 8.12535454e-03f, -1.03783160e-02f, -4.27983589e-02f, -1.90842152e-01f,
  2.62962192e-01f, 8.33782405e-02f, -1.82568938e-01f, -2.03768224e-01f, -2.33767182e-01f, 4.94862981e-02f, -2.93266267e-01f, -3.30666825e-03f, -3.58647615e-01f, -1.35389894e-01f,
  3.45532037e-02f, -6.46779612e-02f, -8.18150789e-02f, 4.04006802e-02f, 4.53254208e-03f, 5.80776371e-02f, 5.34959063e-02f, -5.58232926e-02f, 1.55050959e-02f, -8.15396085e-02f,
  -6.18149936e-02f, -7.09716156e-02f, -3.71948555e-02f, -1.61525026e-01f, 7.82333910e-02f, 3.19872499e-02f, 2.22740658e-02f, -8.10393766e-02f, 3.21821943e-02f, -9.13230330e-02f,
  7.02124611e-02f, -1.19993752e-02f, 3.38154323e-02f, -4.74791266e-02f, -2.96982285e-02f, -2.02903468e-02f, -2.69058496e-02f, -4.32341881e-02f, -7.80010819e-02f, -9.08505991e-02f,
  -1.92144260e-01f, 6.45527244e-02f, -1.05641052e-01f, 5.15252305e-03f, -8.44822824e-02f, 3.86008285e-02f, -2.38980949e-02f, 3.79000567e-02f, -6.60028085e-02f, -1.66104332e-01f,
  -2.13739350e-01f, -2.58452892e-01f, -5.08909374e-02f, -3.14709805e-02f, 3.08548491e-02f, -1.33452117e-01f, 1.42573826e-02f, -1.25424443e-02f, -1.08908832e-01f, -1.06484860e-01f,
  1.19341560e-01f, -1.68014452e-01f, -3.13424110e-01f, -3.33313942e-01f, -2.11114615e-01f, -1.64830208e-01f, -1.67377949e-01f, -2.46394128e-01f, -3.70249957e-01f, -3.97346050e-01f,
  4.46371436e-01f, 3.69946808e-01f, 2.86076844e-01f, 2.01239977e-02f, -3.67894292e-01f, -2.24999219e-01f, -7.06993192e-02f, -1.03297062e-01f, 3.66117023e-02f, 7.53654391e-02f,
  -9.64542180e-02f, -2.53410459e-01f, -2.84121428e-02f, -9.64381248e-02f, -1.39995795e-02f, 1.67919159e-01f, 1.39230803e-01f, 1.61757112e-01f, -1.10592067e-01f, -2.05214635e-01f,
  -1.64406881e-01f, 1.08125977e-01f, 1.75699443e-01f, 2.14799434e-01f, 8.81262794e-02f, -1.46511555e-01f, 7.39082396e-02f, 9.17812958e-02f, 1.32232562e-01f, 3.33976328e-01f,
  2.04337299e-01f, 3.52123439e-01f, -3.15615475e-01f, -1.71501055e-01f, -1.08352780e-01f, 1.27863422e-01f, -6.26924494e-03f, 6.03643479e-03f, -5.32366447e-02f, 1.97630879e-02f,
  -1.15442462e-01f, -8.98427293e-02f, -3.37535962e-02f, -6.51952252e-02f, 3.11026685e-02f, -6.45191744e-02f, 7.72925764e-02f, 1.55206814e-01f, 4.07847427e-02f, 9.80264917e-02f,
  -1.59374446e-01f, -1.35715291e-01f, 1.52534153e-02f, -1.61404669e-01f, 1.80202484e-01f, -1.22343674e-01f, 6.38854876e-02f, 5.52763231e-02f, 3.34930699e-03f, 2.52461702e-01f,
  -1.65518939e-01f, -1.06989052e-02f, 4.72481363e-02f, -1.36338696e-01f, -9.07994360e-02f, -1.77392393e-01f, -3.81204858e-02f, -5.60470372e-02f, -9.48641449e-02f, 9.65883397e-03f,
  -1.45216882e-01f, -1.04821280e-01f, -1.36926293e-01f, -3.33610810e-02f, -5.33998013e-02f, -3.34453583e-02f, -9.36385170e-02f, -5.75842932e-02f, -4.82547358e-02f, -4.89530042e-02f,
  -1.20034941e-01f, 4.14694734e-02f, 5.92085607e-02f, 5.05109280e-02f, -3.96854132e-02f, -4.56848219e-02f, -7.85170048e-02f, -7.96228871e-02f, -1.85457654e-02f, -9.20666382e-03f,
  -2.64388740e-01f, -4.66109514e-01f, -7.60610476e-02f, 1.84418738e-01f, 1.48050403e-02f, 7.84111470e-02f, -3.54952589e-02f, -4.49439831e-04f, -1.31088480e-01f, -6.55140262e-03f,
  1.80067960e-02f, 5.53691201e-02f, 9.69462469e-02f, 1.41912848e-02f, -1.99552700e-01f, -6.88667819e-02f, -1.40844226e-01f, 3.22277956e-02f, -4.83514294e-02f, -5.95608819e-03f,
  -8.87943283e-02f, -2.34410778e-01f, -1.64808050e-01f, -6.31758869e-02f, -1.11037575e-01f, -3.48892242e-01f, -2.26030692e-01f, -1.04972728e-01f, -1.89701900e-01f, -1.59982175e-01f,
  5.56486547e-01f, -6.84096515e-02f, -8.44773799e-02f, -8.98443046e-04f, -1.03486471e-01f, -1.45871341e-01f, -1.51097357e-01f, 3.57133970e-02f, -3.91007476e-02f, -1.13067664e-01f,
  -1.93874493e-01f, -5.23061343e-02f, -5.12446389e-02f, -3.31576914e-02f, 9.10279304e-02f, -2.18369454e-01f, -1.75354689e-01f, 9.46187824e-02f, 2.42862388e-01f, 1.39452502e-01f,
  -5.27001694e-02f, 5.24003170e-02f, 1.74570486e-01f, 5.84250093e-02f, -2.90678609e-02f, -3.47653814e-02f, -1.02999248e-01f, -1.99189261e-01f, -1.00077137e-01f, -1.79436222e-01f,
  -2.53841072e-01f, -8.47813487e-02f, 1.45798370e-01f, 3.48274335e-02f, 1.61520138e-01f, 1.74780488e-01f, 1.00282744e-01f, 2.12481633e-01f, 8.09042230e-02f, 1.83836371e-02f,
  -1.12009114e-02f, -9.98260267e-03f, 3.15242372e-02f, 2.26524528e-02f, 1.24885431e-02f, 7.39174187e-02f, 9.81410965e-02f, 1.23884708e-01f, -3.49543095e-02f, -3.17465328e-02f,
  -5.83028272e-02f, -8.97548124e-02f, 6.01248667e-02f, 5.20710833e-02f, -8.64437409e-03f, -4.79378598e-03f, 2.85888147e-02f, -1.61320232e-02f, 9.92355719e-02f, 2.89847758e-02f,
  3.05031762e-02f, 1.04392335e-01f, -2.15909518e-02f, -1.17133977e-02f, -2.70115547e-02f, 1.30367726e-01f, -8.05384964e-02f, 2.04343293e-02f, 2.13292297e-02f, -4.03317101e-02f,
  1.74140336e-03f, -2.15832174e-01f, -1.18357994e-01f, 5.60356714e-02f, -3.43612209e-02f, -1.22345882e-02f, 3.23837586e-02f, -1.12881236e-01f, 4.15313849e-03f, -1.15824878e-01f,
  -8.48496407e-02f, -5.48993871e-02f, 3.36695276e-02f, -3.57143162e-03f, -8.48595053e-02f, 5.87810650e-02f, -6.26341552e-02f, 1.72603559e-02f, 3.17616202e-02f, -5.38593754e-02f,
  -1.47033721e-01f, -1.54793188e-01f, -2.92950273e-02f, -1.43664673e-01f, -1.12457804e-01f, -1.78131275e-02f, -1.10368647e-01f, -5.01936935e-02f, 4.25257012e-02f, -5.05706742e-02f,
  2.52713729e-02f, 6.02013804e-03f, -8.61591026e-02f, 9.76737775e-03f, 1.51783422e-01f, 4.05693147e-03f, 4.96240556e-02f, -1.20641626e-01f, -4.66891304e-02f, -5.98992668e-02f,
  -5.17703108e-02f, 1.90958306e-02f, 8.17064866e-02f, -1.73428338e-02f, 7.19874213e-03f, -5.47839561e-03f, 3.75249237e-02f, 3.07555757e-02f, -6.37944639e-02f, 1.19855024e-01f,
  -5.37082195e-01f, -3.63256633e-01f, -2.26295486e-01f, -5.30225813e-01f, -3.84259999e-01f, 4.55323905e-02f, -6.93507642e-02f, -1.24198429e-01f, -2.11915478e-01f, -3.21694434e-01f,
  -3.58206294e-02f, -1.11660035e-02f, -3.28132920e-02f, 4.27237488e-02f, -7.07185641e-02f, -1.96478307e-01f, -3.46150428e-01f, -2.15300471e-01f, -4.22800146e-02f, 1.39048502e-01f,
  -1.86746567e-01f, -3.28084111e-01f, -2.01368794e-01f, -2.34699860e-01f, -1.57808110e-01f, -1.49655536e-01f, -9.73938629e-02f, -2.09721640e-01f, -4.09621149e-02f, -3.52527291e-01f,
  2.84972578e-01f, 6.74352050e-02f, 3.58892158e-02f, -1.54588250e-02f, -1.09464293e-02f, 8.11585337e-02f, -1.47474688e-02f, -3.45599204e-02f, -1.45577844e-02f, 3.83894369e-02f,
  -3.42195369e-02f, -4.38321456e-02f, -1.39279217e-01f, 1.04334084e-02f, 3.78825585e-04f, -4.95803030e-03f, 8.37623924e-02f, -1.18385710e-01f, 1.12020336e-01f, 1.94085449e-01f,
  1.51362106e-01f, 1.60159729e-02f, 1.43919706e-01f, 2.62438715e-01f, 2.62688607e-01f, 1.01228699e-01f, 2.38616616e-01f, 2.95078903e-01f, 2.48203829e-01f, -4.06547040e-02f,
  1.01632856e-01f, 1.50661264e-02f, 9.57487598e-02f, 8.27882253e-03f, 9.78689492e-02f, -5.92707060e-02f, -2.87590120e-02f, -6.75074309e-02f, 2.97759734e-02f, -2.87756454e-02f,
  -1.23633303e-01f, 9.21596214e-02f, 4.52006608e-02f, -9.27307606e-02f, 3.30702998e-02f, -9.43653807e-02f, -7.74665996e-02f, 2.49017193e-03f, 1.08168542e-01f, -1.11361463e-02f,
  5.57571985e-02f, 7.59211332e-02f, -7.53969699e-02f, 1.23843454e-01f, 9.06585827e-02f, 4.27373312e-02f, 8.97545069e-02f, 1.95835099e-01f, -8.77627209e-02f, -1.41573578e-01f,
  1.73908025e-01f, 2.21885249e-01f, -1.73913434e-01f, -3.06261163e-02f, -8.62630531e-02f, 3.45692858e-02f, 1.20216794e-01f, 2.94390097e-02f, -9.45230722e-02f, 1.37370124e-01f,
  1.56323597e-01f, 2.77012065e-02f, 6.63601374e-03f, 1.24434792e-02f, -4.06934172e-02f, 1.02574147e-01f, 7.06831887e-02f, -7.73631409e-02f, 1.16674542e-01f, 7.54214004e-02f,
  -2.98591126e-02f, -7.67631158e-02f, -2.96794064e-02f, 1.10168330e-01f, 8.95801466e-04f, -5.31475581e-02f, 6.17705919e-02f, 8.22752416e-02f, 1.01905189e-01f, -1.00031406e-01f,
  3.83208096e-01f, -2.00954542e-01f, -5.45110404e-01f, 4.38689709e-01f, -1.83862168e-02f, -2.53750443e-01f, -2.62501299e-01f, 1.00102119e-01f, 3.49796772e-01f, 2.58905962e-02f,
  -1.95807323e-01f, -1.56474754e-01f, -1.65620968e-01f, -3.67524028e-01f, -4.97576982e-01f, -2.45055676e-01f, -2.40911052e-01f, -5.00170767e-01f, -3.26190203e-01f, -1.35882571e-01f,
  7.57540464e-02f, 2.35585064e-01f, 8.26358572e-02f, -5.24464883e-02f, 3.36727232e-01f, 1.91748530e-01f, -3.43055651e-02f, 9.68728587e-02f, -2.77906775e-01f, 1.24588609e-02f,
  -2.60552913e-01f, -2.98885331e-02f, -8.47776234e-02f, -2.26428881e-02f, 2.82286219e-02f, -3.60993184e-02f, -8.73252004e-02f, -2.77884621e-02f, -6.13280088e-02f, -7.56518096e-02f,
  -1.38492525e-01f, -4.55663353e-02f, -1.72496930e-01f, -2.44807303e-02f, 5.34929521e-02f, -8.16549361e-02f, 8.08321219e-03f, -2.40203410e-01f, -1.40096933e-01f, -1.00816891e-01f,
  -1.13928668e-01f, -1.80714443e-01f, -2.90492177e-01f, -1.34379297e-01f, -1.10418305e-01f, -4.25617732e-02f, -7.10003674e-02f, -5.34019023e-02f, -1.80271536e-01f, 1.69003755e-01f,
  5.83379865e-02f, -1.28747178e-02f, 8.18831846e-02f, 3.63931209e-02f, 1.31325677e-01f, 9.79634672e-02f, -8.76643229e-03f, -9.05773565e-02f, 1.99263524e-02f, -4.35561780e-03f,
  5.37275672e-02f, -1.27061054e-01f, 4.57356945e-02f, 3.45857628e-02f, -8.62837359e-02f, -8.06552768e-02f, -7.82640651e-02f, 2.24453118e-02f, -6.96516188e-04f, 8.94663632e-02f,
  -7.18915164e-02f, 7.43944719e-02f, 1.07834190e-01f, -5.60854115e-02f, -1.35689825e-01f, 4.36752709e-03f, -3.44931334e-02f, -1.61328353e-02f, -2.90763713e-02f, -2.16387697e-02f,
  3.02841604e-01f, -3.32775146e-01f, 1.73329636e-01f, -2.05715522e-01f, 3.65478732e-02f, -3.58064449e-03f, 5.22592478e-02f, -9.14034918e-02f, 3.98581326e-02f, -3.06052528e-02f,
  -1.54813141e-01f, -6.38614818e-02f, -1.10140890e-01f, 6.34609610e-02f, -8.46547931e-02f, -4.52226251e-02f, 5.97120523e-02f, -1.26923546e-01f, -9.74168405e-02f, 1.24822035e-01f,
  4.99616787e-02f, 3.42984162e-02f, 3.77162099e-02f, 3.59620452e-02f, 1.74973920e-01f, 1.20314881e-01f, -7.40497336e-02f, 2.26686429e-03f, -1.18154995e-01f, 3.06698084e-01f,
  -3.88454884e-01f, -4.04201001e-01f, -1.23151354e-01f, -4.04152036e-01f, -3.54939282e-01f, -1.54256463e-01f, -5.36650121e-01f, -3.16605538e-01f, -2.77994901e-01f, -5.20832419e-01f,
  -2.79149830e-01f, -9.48458016e-02f, -5.17906137e-02f, 5.66945672e-02f, 4.23281565e-02f, -4.87728000e-01f, -1.57704160e-01f, 1.19334482e-01f, 2.74301708e-01f, -2.22002178e-01f,
  -3.64844650e-01f, -2.23447546e-01f, 4.08064462e-02f, 9.09366608e-02f, -2.17989311e-01f, 8.35865512e-02f, 2.10288800e-02f, -9.41761509e-02f, 3.20926383e-02f, -2.56316423e-01f,
  -3.28709304e-01f, -1.03412278e-01f, 7.41273388e-02f, 6.61678687e-02f, -1.61264271e-01f, -6.44490570e-02f, -1.11379521e-02f, 1.25345578e-02f, -5.60104772e-02f, -2.40704849e-01f,
  -7.55805224e-02f, -6.16614483e-02f, -4.75173816e-03f, -8.44561234e-02f, -2.44829640e-01f, -1.48055360e-01f, 1.07885502e-01f, 1.35998912e-02f, 8.69676024e-02f, -1.82879493e-01f,
  -2.02611778e-02f, -2.77452059e-02f, 2.10496243e-02f, 1.78757519e-01f, -2.83147991e-02f, 6.85862899e-02f, 3.34182731e-03f, 1.56527579e-01f, 3.38230163e-01f, -1.31050169e-01f,
  -8.53944644e-02f, -3.43390070e-02f, 7.05574900e-02f, 2.38688309e-02f, -1.11754676e-02f, 5.69474585e-02f, 4.15550079e-03f, -1.34397238e-01f, 9.65450108e-02f, -1.65046249e-02f,
  -9.62265208e-02f, 4.12858874e-02f, -2.88303494e-02f, 4.82868627e-02f, 2.33487729e-02f, 4.56720777e-02f, -6.94944859e-02f, 7.96898082e-02f, 9.33233723e-02f, 3.71452905e-02f,
  4.73320931e-02f, 4.91458885e-02f, -7.58947572e-03f, 7.53774121e-02f, 1.31311595e-01f, 3.13506015e-02f, -8.82069170e-02f, 1.00891382e-01f, -4.65312600e-02f, -6.69614077e-02f,
  -1.92945063e-01f, 4.32607949e-01f, -3.44810635e-01f, 3.99922021e-02f, -6.14052899e-02f, 1.30718485e-01f, -4.93784696e-02f, -6.25999048e-02f, 3.22713628e-02f, -1.31912380e-01f,
  1.27884522e-01f, -2.11157531e-01f, -8.85658488e-02f, 3.32173854e-02f, -9.84102190e-02f, 1.75103974e-02f, -1.51572544e-02f, 3.34682898e-03f, 6.71083406e-02f, 4.39042225e-03f,
  -3.60287055e-02f, -1.16578519e-01f, -1.94669977e-01f, 1.30576696e-02f, 1.21505447e-02f, -2.15483569e-02f, -2.69650798e-02f, 6.68636933e-02f, 2.02149883e-01f, -3.15261275e-01f,
  -5.42438865e-01f, -3.49154532e-01f, 5.04881382e-01f, -3.09983164e-01f, -2.89443940e-01f, -2.97524720e-01f, -3.54647845e-01f, -3.14262778e-01f, -3.21175724e-01f, -9.54268202e-02f,
  4.76522185e-02f, 3.08920413e-01f, 3.27757657e-01f, 2.25600019e-01f, 7.47532994e-02f, 1.07166305e-01f, 8.05217549e-02f, 3.15227270e-01f, 2.83981144e-01f, -1.78773507e-01f,
  -6.25876710e-02f, -1.65738538e-01f, -5.11117242e-02f, -1.11098073e-01f, -3.69518660e-02f, 1.16706826e-01f, 1.65229619e-01f, -8.58175159e-02f, 4.46852185e-02f, 1.65966284e-02f,
  4.06014264e-01f, -2.95816749e-01f, 1.98791862e-01f, -7.93703720e-02f, 8.23930204e-02f, -2.71267090e-02f, -4.15156521e-02f, -4.87350579e-03f, -1.74059030e-02f, 2.70897690e-02f,
  -9.14980173e-02f, -1.39088267e-02f, -4.16875333e-02f, 1.14483647e-02f, -1.71925589e-01f, -2.80733779e-02f, 8.27301666e-02f, 9.02728960e-02f, 9.61159170e-02f, -2.66666617e-03f,
  -1.03396177e-02f, -2.05911025e-02f, 4.97982614e-02f, -2.76975408e-02f, -3.68874632e-02f, 1.31289974e-01f, -4.18293960e-02f, -1.27073944e-01f, -6.55782521e-02f, -1.36012197e-01f,
  7.14805946e-02f, 1.51727572e-01f, -3.58917820e-03f, 1.07349336e-01f, 1.00798011e-01f, 1.12546064e-01f, 6.42005280e-02f, -1.71459001e-02f, -3.11179217e-02f, 8.05319101e-03f,
  8.13813433e-02f, 1.83359254e-02f, -5.42964824e-02f, -7.48189092e-02f, -8.31805766e-02f, -4.87168208e-02f, 3.97113115e-02f, -3.51283117e-03f, 4.26852368e-02f, -9.18113366e-02f,
  -3.88692953e-02f, -1.74441170e-02f, 4.14237306e-02f, -7.48740137e-02f, -4.28629555e-02f, -1.58989448e-02f, -1.00092813e-01f, 5.76936416e-02f, 1.49664385e-02f, -5.87900765e-02f,
  3.04444265e-02f, -4.03687954e-02f, 8.73737559e-02f, -3.19022052e-02f, -7.68794268e-02f, -1.14940777e-01f, -6.19797073e-02f, -7.67698288e-02f, -8.81153643e-02f, -2.34319698e-02f,
  -1.26323104e-01f, -1.11933634e-01f, 2.28954963e-02f, 6.83571547e-02f, 4.41786572e-02f, -3.45098972e-02f, -3.85645889e-02f, 4.66002058e-03f, -1.04606301e-01f, 9.73286256e-02f,
  -9.07282904e-03f, -4.49003167e-02f, 1.24604568e-01f, 1.09424919e-01f, -4.81840037e-02f, 5.64884059e-02f, 2.24002287e-01f, 1.19241841e-01f, -6.42966628e-02f, -1.04922391e-01f,
  7.04682618e-02f, 3.22244793e-01f, -3.41229111e-01f, 8.58858824e-02f, 1.47169814e-01f, 1.09539062e-01f, 4.34942305e-01f, 2.53468454e-01f, 1.27147943e-01f, 1.25416204e-01f,
  -1.67770699e-01f, -2.63544798e-01f, -1.81626782e-01f, -1.22888431e-01f, -1.27758399e-01f, 2.06303790e-01f, 3.50394100e-01f, -1.85544729e-01f, -1.41267359e-01f, 1.15740545e-01f,
  2.53739744e-01f, 3.36926788e-01f, 2.65936032e-02f, 1.60465106e-01f, 5.83443232e-02f, 9.10980254e-03f, 8.27613398e-02f, -1.20815067e-02f, -2.11517215e-02f, 2.32198313e-02f,
  -5.13384759e-01f, -7.23332986e-02f, -2.24099606e-02f, 8.93825144e-02f, -1.23472549e-01f, 5.46040945e-02f, 1.43383211e-02f, 1.39996737e-01f, 9.91746336e-02f, -1.78591888e-02f,
  -2.08492145e-01f, -1.67690903e-01f, -2.02713653e-01f, -2.22012490e-01f, -4.71639037e-02f, -4.50782590e-02f, 1.52811900e-01f, -2.85367109e-02f, -2.51482308e-01f, -2.12911561e-01f,
  7.27972910e-02f, -2.42639184e-02f, -2.37260848e-01f, -3.54610272e-02f, -2.33050436e-01f, -1.88320369e-01f, -1.89624816e-01f, -2.15636745e-01f, -2.94819623e-01f, 6.10618517e-02f,
  3.00543364e-02f, -1.07058911e-02f, -8.52390081e-02f, 6.55956864e-02f, 6.02475880e-03f, -6.72385916e-02f, -1.34321079e-01f, -4.94795740e-02f, -1.27303883e-01f, 8.62443224e-02f,
  -1.38135165e-01f, -8.22749734e-02f, -1.91091016e-01f, -1.02359287e-01f, -4.74730730e-02f, -2.71200538e-02f, -7.19397813e-02f, 5.35292216e-02f, -1.46750789e-02f, -2.67106760e-02f,
  2.41098516e-02f, -1.19932190e-01f, -8.90665501e-03f, -4.91848812e-02f, 1.83458388e-01f, -6.68384135e-02f, 5.55268563e-02f, 6.46017417e-02f, 9.72432569e-02f, 1.17602751e-01f,
  1.91035554e-01f, 4.72068638e-02f, -1.65255874e-01f, 1.46588773e-01f, -6.73878193e-02f, -2.22083747e-01f, -1.74288034e-01f, -6.63956478e-02f, -1.29846722e-01f, -1.33186057e-01f,
  -2.38785952e-01f, -2.12565169e-01f, -2.92989910e-01f, -1.34779662e-01f, -8.61310884e-02f, -5.48094977e-03f, 1.21747486e-01f, -2.68677063e-02f, 6.67154649e-03f, -1.13365218e-01f,
  1.89405635e-01f, 1.87346444e-01f, 9.27162264e-03f, 1.53519347e-01f, -2.34271772e-03f, -4.58137132e-02f, 5.05414093e-03f, 1.02452450e-01f, 1.41650504e-02f, 4.77995723e-01f,
  3.47633362e-01f, 4.53564793e-01f, 1.19871691e-01f, 1.95443466e-01f, 2.28524670e-01f, 1.57762393e-01f, 2.12868914e-01f, 1.69266462e-01f, 5.80230728e-02f, 5.61076142e-02f,
  2.48807266e-01f, -1.93517148e-01f, -1.13064416e-01f, -2.54762739e-01f, -3.39611739e-01f, -1.81243196e-01f, -2.61423856e-01f, -4.09896970e-01f, -4.59334165e-01f, -2.62549341e-01f,
  -3.30159664e-01f, 2.69381274e-02f, -4.98906001e-02f, -1.32116958e-01f, 1.70737699e-01f, -4.05847691e-02f, 2.97967196e-01f, 3.18792969e-01f, -1.58527971e-03f, -1.57923818e-01f,
  -4.94651310e-02f, 4.89361167e-01f, -3.52411777e-01f, -9.66898799e-02f, 2.28080958e-01f, -1.82402745e-01f, -8.36721063e-02f, -3.60410251e-02f, 3.30099352e-02f, -6.54018447e-02f,
  1.20308101e-02f, -3.02819163e-02f, -2.22587842e-03f, -1.95919812e-01f, -4.81510386e-02f, -1.82197750e-01f, -1.99599899e-02f, -1.52175426e-01f, -1.65338650e-01f, -9.46787894e-02f,
  -1.92395017e-01f, 1.83083013e-01f, 3.08063447e-01f, -9.66798421e-03f, 9.69549492e-02f, -1.62045419e-01f, 2.53260881e-01f, 1.10220246e-01f, 1.46586552e-01f, 1.18710555e-01f,
  -2.82538347e-02f, 9.95411649e-02f, 1.16899304e-01f, 1.67919874e-01f, -1.34015292e-01f, -2.67571323e-02f, 1.96358990e-02f, -6.53685033e-02f, 3.86381596e-02f, 1.27073854e-01f,
  4.11862507e-02f, 6.61580265e-02f, 1.24183342e-01f, 9.59052444e-02f, 1.99347325e-02f, 1.52836129e-01f, -1.71404965e-02f, 1.85685176e-02f, -1.70317143e-02f, 2.47634165e-02f,
  -1.32783175e-01f, -1.16036711e-02f, 1.47106573e-01f, -8.66803303e-02f, -3.76163684e-02f, -1.50958952e-02f, -4.18581031e-02f, -6.91199601e-02f, 1.37999821e-02f, 1.18690751e-01f,
  -9.32827368e-02f, 9.62208062e-02f, -1.57892138e-01f, -5.18499762e-02f, 1.11986138e-01f, 7.43447095e-02f, -2.84918555e-04f, -2.24060621e-02f, 2.00371921e-01f, -2.40070764e-02f,
  6.59682155e-02f, -6.34898990e-02f, 9.06197801e-02f, -2.27731109e-01f, -2.02945337e-01f, -7.69369453e-02f, -1.26584828e-01f, -8.97803605e-02f, -1.66941553e-01f, 2.85092946e-02f,
  -3.54286693e-02f, -8.24555680e-02f, -8.66990015e-02f, -5.56858890e-02f, 6.39688522e-02f, -1.84450358e-01f, -1.38320446e-01f, -1.24545895e-01f, -1.66397408e-01f, -1.78814813e-01f,
  4.04098660e-01f, 4.07031104e-02f, -5.33362269e-01f, 7.38602132e-02f, -3.81497353e-01f, -2.47049421e-01f, -1.72829539e-01f, 1.24282159e-01f, 1.67046055e-01f, -1.65306404e-01f,
  -7.38141090e-02f, -1.52489588e-01f, -2.09137902e-01f, -2.02462062e-01f, -2.12356895e-01f, -3.90562385e-01f, -4.66741085e-01f, -4.03675050e-01f, -3.65352154e-01f, -1.11260466e-01f,
  -1.78869888e-01f, -1.35978773e-01f, -6.74076080e-02f, -1.20928623e-01f, -6.62782267e-02f, -1.24954395e-01f, -2.90948540e-01f, -1.54400349e-01f, -1.21476017e-01f, -2.59401560e-01f,
  -4.87594128e-01f, 9.69854966e-02f, -1.93709821e-01f, 1.62381139e-02f, -1.15953170e-01f, 5.95409423e-02f, -3.26161017e-03f, 4.97642644e-02f, 7.27182329e-02f, -1.43216938e-01f,
  1.77813899e-02f, -5.33563434e-04f, -6.74552768e-02f, -1.20146379e-01f, -3.13576381e-03f, -5.66553995e-02f, 6.44088835e-02f, -7.05116242e-02f, -1.72811806e-01f, -1.84002686e-02f,
  -3.19302417e-02f, -9.41297784e-02f, -2.67455000e-02f, 6.70678243e-02f, 3.07894778e-02f, -1.09197125e-01f, 4.57653366e-02f, 1.09518893e-01f, -5.94808944e-02f, 2.99887937e-02f,
  -1.89511981e-02f, 6.26892895e-02f, 2.88415840e-03f, 1.25390321e-01f, 4.25877199e-02f, -5.76415695e-02f, 4.04122584e-02f, 4.26234938e-02f, -1.91579424e-02f, 1.66967488e-03f,
  -5.00549898e-02f, -5.19276448e-02f, -9.24185440e-02f, 7.61759505e-02f, -1.08398050e-01f, -2.16053985e-02f, -1.15199800e-04f, 6.71733469e-02f, -4.59730104e-02f, -1.71323176e-02f,
  -4.76278253e-02f, 9.74530354e-03f, 4.32768930e-03f, 1.01013988e-01f, -4.65369783e-02f, -2.06149705e-02f, 2.19930802e-02f, 7.35515654e-02f, -1.63007826e-02f, -1.05364591e-01f,
  -1.34736635e-02f, -1.24784566e-01f, -9.70970094e-02f, 1.14328057e-01f, -1.47351950e-01f, -1.02433547e-01f, 3.36274430e-02f, -5.40862866e-02f, -8.96285847e-02f, -6.15176149e-02f,
  -8.88869632e-03f, -4.18202467e-02f, -6.93128034e-02f, 5.11351041e-02f, -8.31575394e-02f, -7.65730441e-02f, 3.24360877e-02f, -1.19453676e-01f, 1.28115360e-02f, -3.18397884e-03f,
  5.10823913e-02f, -7.50159472e-03f, 5.68294376e-02f, -1.69893187e-02f, 5.74668571e-02f, -6.45625521e-04f, -2.88344752e-02f, -4.88703847e-02f, 4.42002676e-02f, 1.49037272e-01f,
  -2.41687838e-02f, 2.13791192e-01f, 1.75057739e-01f, 5.03602950e-03f, -3.50360245e-01f, -3.30883622e-01f, -2.25510448e-01f, -1.53628305e-01f, -6.53043166e-02f, 1.62559852e-01f,
  -1.88411221e-01f, -3.07945669e-01f, -1.50558770e-01f, -1.07848145e-01f, -6.04097918e-02f, 1.65195987e-01f, 2.27145612e-01f, 8.14764127e-02f, -4.55348045e-01f, -4.41130459e-01f,
  -2.19241798e-01f, -1.41018182e-01f, -7.96441063e-02f, -3.00462190e-02f, 2.09437743e-01f, 5.75704500e-03f, 2.69875377e-01f, 1.13095440e-01f, 1.08778983e-01f, 4.09343898e-01f,
  6.71437830e-02f, 2.60108352e-01f, -1.72611415e-01f, -1.72518402e-01f, -2.13863879e-01f, -1.09593414e-01f, -5.03209941e-02f, 7.15346336e-02f, 1.63342841e-02f, 1.55351996e-01f,
  -1.85228691e-01f, -1.17294729e-01f, -1.52556732e-01f, -7.84680545e-02f, -2.88183868e-01f, -1.64085060e-01f, 1.06604174e-01f, 5.06667458e-02f, 6.22335337e-02f, -2.80594602e-02f,
  -2.53834903e-01f, -2.57089168e-01f, -4.89490367e-02f, 2.87048426e-02f, 1.97307810e-01f, -1.72276795e-01f, -1.45632297e-01f, -8.15120526e-03f, 1.58309173e-02f, 2.56191343e-01f,
  1.26197651e-01f, 8.80478621e-02f, -4.74976860e-02f, 6.57535940e-02f, -1.30113319e-01f, -3.67639586e-02f, 1.10982552e-01f, -4.19674776e-02f, -6.99881688e-02f, 3.56170088e-02f,
  1.06702574e-01f, 6.31633550e-02f, 4.23430093e-02f, 1.55592769e-01f, -3.54148302e-04f, -1.13097414e-01f, -6.98712766e-02f, 5.68890870e-02f, 1.74577907e-01f, 3.29091698e-02f,
  -5.06894849e-02f, -8.51282384e-03f, -4.95987274e-02f, -6.70251101e-02f, 1.08974561e-01f, 7.63275623e-02f, -1.18471552e-02f, -1.04921749e-02f, 4.04724814e-02f, 5.24772657e-03f,
  -1.21257752e-01f, -1.84966847e-02f, 7.20257834e-02f, 1.46641523e-01f, -1.26228914e-01f, -8.85949209e-02f, 1.24376863e-01f, 1.38438158e-02f, 6.25517368e-02f, -8.73718932e-02f,
  -1.81732714e-01f, -2.32321303e-02f, 1.07028157e-01f, -1.89670629e-03f, -2.88313895e-01f, -1.23108633e-01f, -4.12207767e-02f, -1.09113313e-01f, -5.84459715e-02f, -1.56748429e-01f,
  3.01793162e-02f, -3.33543330e-01f, -2.69045502e-01f, -5.46394698e-02f, -1.32239401e-01f, -3.20516557e-01f, -1.81075767e-01f, -1.29347101e-01f, -1.08796231e-01f, -1.34378951e-02f,
  6.50089562e-01f, -2.19633803e-01f, 4.94063310e-02f, 7.83426780e-03f, -2.90003326e-02f, 5.19120879e-02f, -4.91551124e-02f, -3.19130495e-02f, -2.84262840e-02f, 8.96709263e-02f,
  6.29890338e-02f, 2.46252507e-01f, 1.00425862e-01f, 5.16134538e-02f, 1.09688349e-01f, -1.19210675e-01f, -1.77037805e-01f, 1.33507565e-01f, 2.79375434e-01f, 8.99645686e-02f,
  -6.13758974e-02f, -3.03253215e-02f, 3.46184783e-02f, 4.27143350e-02f, 7.54687050e-03f, 1.08021758e-01f, -9.66178998e-02f, -2.86017582e-02f, -2.48755813e-02f, -7.63559565e-02f,
  -5.36841564e-02f, 1.44394174e-01f, 1.07762218e-01f, 3.75258587e-02f, -3.22417691e-02f, 9.28074028e-03f, 6.12725616e-02f, 6.60515251e-03f, -1.45376936e-01f, -8.48417655e-02f,
  1.38896601e-02f, 1.05875291e-01f, 1.84479393e-02f, -3.05050425e-02f, 2.67427620e-02f, 5.71183525e-02f, 8.38513598e-02f, -4.01299773e-03f, 6.58649281e-02f, -5.22813350e-02f,
  -3.07476409e-02f, -4.26246747e-02f, -7.69291371e-02f, 5.65337576e-02f, 4.55708429e-02f, 8.09114203e-02f, -3.27771418e-02f, -2.66661886e-02f, 3.36159281e-02f, 4.28884588e-02f,
  4.41066995e-02f, 1.43364131e-01f, 5.25601692e-02f, -4.67763282e-03f, 4.43354324e-02f, 5.14024943e-02f, -2.16338187e-02f, -4.47368510e-02f, 1.46386221e-01f, 1.06253207e-01f,
  -7.40842149e-02f, -1.09833162e-02f, 5.40764779e-02f, -1.22617348e-03f, 9.37627181e-02f, -2.58617960e-02f, 2.25900002e-02f, 5.17711788e-02f, 5.27759045e-02f, -5.26666362e-03f,
  3.13701294e-02f, -5.44677675e-03f, 9.94968042e-02f, -7.53394961e-02f, -9.24998894e-02f, 8.71586651e-02f, 5.04811630e-02f, -1.85548502e-03f, -2.10122373e-02f, 4.27431762e-02f,
  -2.13883072e-01f, 1.56085059e-01f, 9.62622091e-03f, 6.03769161e-02f, -1.09867446e-01f, -3.28916833e-02f, 4.29083779e-02f, -1.66965351e-01f, -2.71151721e-01f, -1.66871950e-01f,
  -1.03268228e-01f, 6.22319058e-02f, 2.82115489e-02f, -2.29249727e-02f, 7.15975463e-02f, -7.19228238e-02f, -7.06154853e-02f, 4.94751297e-02f, 1.69950612e-02f, -5.59216365e-02f,
  -1.25932857e-01f, 1.26652300e-01f, 1.15186088e-01f, 5.85222710e-03f, 7.77479112e-02f, 8.64301398e-02f, 6.39566630e-02f, 5.31306863e-02f, 1.47077411e-01f, 7.51709798e-03f,
  7.58588612e-01f, -1.69998124e-01f, -3.68222922e-01f, 1.61796108e-01f, -1.89993382e-01f, -1.16084993e-01f, -1.61348283e-01f, 1.05077989e-01f, 1.78710163e-01f, 5.53151742e-02f,
  1.58800334e-01f, 3.83731246e-01f, 3.81150603e-01f, 2.17642307e-01f, 2.14571938e-01f, -1.79024994e-01f, -3.64081681e-01f, 8.64608437e-02f, 2.50217378e-01f, 3.62782516e-02f,
  -5.33698201e-02f, -2.88732890e-02f, 2.10293442e-01f, -7.30087012e-02f, -2.82043964e-01f, 2.02379357e-02f, -3.73144478e-01f, -3.18293482e-01f, -2.07171932e-01f, -4.70243663e-01f,
  1.29609361e-01f, -7.94468820e-02f, -5.60675226e-02f, 9.85614117e-03f, -1.12585656e-01f, -4.02841344e-02f, 7.48258755e-02f, -1.81018487e-01f, -2.07879096e-02f, -1.06113665e-01f,
  -1.45242527e-01f, -4.33678888e-02f, -5.68963438e-02f, -1.12008661e-01f, -2.57888466e-01f, -4.94156443e-02f, -1.00829065e-01f, -1.05608113e-01f, -2.49247923e-02f, 1.71298888e-02f,
  -2.27720458e-02f, -1.05802171e-01f, -1.35025114e-01f, -7.19214976e-02f, -2.12423488e-01f, -4.11670506e-02f, -1.68247998e-01f, -2.05506057e-01f, -1.61343321e-01f, -1.74809456e-01f,
  1.62988007e-02f, -3.97076942e-02f, -1.14360683e-01f, 4.84003732e-03f, 1.34491220e-01f, 4.94039804e-02f, 8.96189269e-03f, -2.44873632e-02f, 8.36701971e-03f, -1.44337818e-01f,
  -8.52807015e-02f, 1.55639425e-02f, 3.42996679e-02f, -7.83067867e-02f, 6.57803938e-02f, -2.59864498e-02f, -5.81363104e-02f, 1.76499374e-02f, -6.75872667e-03f, 5.26077785e-02f,
  1.28095165e-01f, -8.56158659e-02f, 8.20704848e-02f, 1.14570754e-02f, 2.68306863e-03f, 5.75832911e-02f, 8.77691582e-02f, 1.01056118e-02f, 5.07684834e-02f, 4.50430438e-03f,
  2.71333814e-01f, 1.92580491e-01f, 6.64574429e-02f, 7.69913495e-02f, -1.36504382e-01f, 2.40203682e-02f, 1.78454984e-02f, 5.92964403e-02f, 1.56771481e-01f, 1.36137173e-01f,
  -4.34826501e-02f, 9.89338085e-02f, -5.95875755e-02f, -1.22082256e-01f, 1.14489812e-02f, 1.12045437e-01f, 7.37423897e-02f, 1.16570845e-01f, 1.47786299e-02f, -4.45188321e-02f,
  2.13251822e-02f, 5.36859445e-02f, 1.93916261e-01f, 1.05339691e-01f, -4.47644554e-02f, 2.83023059e-01f, -1.70728881e-02f, 6.36620671e-02f, 2.55325407e-01f, 1.42003015e-01f,
  -4.99969274e-01f, -4.12279367e-01f, -1.55034423e-01f, -2.10113302e-01f, 9.57581326e-02f, -1.53043985e-01f, -4.75469917e-01f, -3.70161712e-01f, -1.47198856e-01f, -1.30409658e-01f,
  9.89068225e-02f, 2.84417152e-01f, 1.08743526e-01f, 1.23756275e-01f, -2.65587747e-01f, -3.27074409e-01f, -2.60348562e-02f, -5.02919480e-02f, 1.58965260e-01f, 2.08627120e-01f,
  1.80207551e-01f, 4.09912206e-02f, 9.46487710e-02f, 3.39613296e-02f, -8.57057329e-03f, 1.20744035e-01f, -5.81832007e-02f, 7.81959761e-03f, 3.76583114e-02f, 7.43144974e-02f,
  4.05091234e-02f, -3.83848399e-01f, 9.74569693e-02f, 1.25162765e-01f, 1.80389464e-01f, -7.47966766e-02f, -6.05805591e-02f, -1.99930146e-02f, 1.30486012e-01f, -1.52934060e-01f,
  1.87765360e-01f, -1.20992223e-02f, 1.43757537e-01f, 3.81068662e-02f, -1.13964982e-01f, -1.32387221e-01f, -6.63140342e-02f, -1.95683435e-01f, -1.32746145e-01f, -7.97221959e-02f,
  1.92409381e-01f, 2.60846429e-02f, -1.20899029e-01f, -1.35954261e-01f, -2.39959061e-01f, 1.49042547e-01f, 3.36010903e-02f, 1.17194597e-02f, -1.81118250e-01f, -3.44533980e-01f,
  4.49778512e-02f, 9.54005420e-02f, 1.33580873e-02f, -2.62929332e-02f, 1.81596018e-02f, -5.39273350e-03f, -2.48143133e-02f, 1.14955138e-02f, 4.83867377e-02f, -1.16744824e-03f,
  -4.30278294e-02f, -2.80304495e-02f, -2.40466185e-02f, -6.80460855e-02f, 4.91942801e-02f, -8.77156779e-02f, -5.72987013e-02f, -1.65119171e-02f, -1.88719276e-02f, 4.96816635e-02f,
  -7.02045299e-03f, -1.73088796e-02f, 8.18965659e-02f, -6.96224421e-02f, 1.81401931e-02f, 6.14256896e-02f, 3.41529772e-02f, 5.05800825e-03f, 2.46583037e-02f, 1.04790106e-02f,
  -2.68061519e-01f, 2.68154383e-01f, -2.43335128e-01f, -3.86954620e-02f, -7.75999501e-02f, 6.45016581e-02f, 1.71320233e-02f, 1.06113777e-01f, -8.46746564e-03f, -1.66294694e-01f,
  -7.42867216e-02f, -1.24181710e-01f, -1.52015269e-01f, 5.14215371e-03f, -3.90484221e-02f, -4.10966724e-02f, -5.81732802e-02f, -3.50695313e-03f, -8.96409974e-02f, 1.30211487e-02f,
  -1.84251085e-01f, -2.92971939e-01f, -3.56077880e-01f, -3.50902319e-01f, -1.72566950e-01f, -1.47926584e-01f, -2.29157656e-02f, -1.92225158e-01f, -1.60925984e-01f, -3.98174703e-01f,
  4.85250622e-01f, 1.05327338e-01f, 2.17499696e-02f, 1.12902477e-01f, 1.35422349e-01f, 1.93639740e-01f, 4.30226117e-01f, 2.20185846e-01f, -6.25775307e-02f, 1.34408817e-01f,
  -7.57960510e-03f, -1.59595385e-01f, -2.47654065e-01f, -2.47814640e-01f, -4.81120870e-02f, 2.06598453e-02f, 2.59164255e-02f, 4.18975344e-03f, -2.65056733e-02f, 8.35327879e-02f,
  -6.28693998e-02f, 1.36127800e-01f, 1.30298421e-01f, 2.75378861e-02f, -8.88950601e-02f, -1.30401999e-01f, 7.86012784e-02f, 3.77063639e-03f, -1.72348246e-01f, -2.82953471e-01f,
  -2.29989186e-01f, 1.08777575e-01f, -1.25404149e-01f, -1.70891672e-01f, -3.27607989e-02f, 3.23330760e-02f, -2.05861796e-02f, 1.71451092e-01f, 6.37262687e-02f, 1.10281564e-01f,
  1.26266629e-02f, 1.62617609e-01f, 1.31316096e-01f, 1.27944544e-01f, 1.04432151e-01f, 9.54283848e-02f, 9.04964954e-02f, 6.34146295e-03f, 1.55757414e-02f, -1.21827185e-01f,
  -9.93639678e-02f, 9.30384770e-02f, 1.13688678e-01f, 7.47595578e-02f, -1.00583158e-01f, -2.22156662e-03f, -9.77577791e-02f, -3.81642617e-02f, -1.03323430e-01f, -6.24790264e-04f,
  -4.02311496e-02f, 1.44423202e-01f, 7.84730911e-02f, 5.52442968e-02f, 1.35222673e-01f, 7.18111396e-02f, 9.15356353e-02f, 1.10851200e-02f, 8.30330551e-02f, 1.26110569e-01f,
  -3.59235890e-02f, 1.74042881e-02f, 2.24133983e-01f, 1.88419402e-01f, 2.23547057e-03f, 1.37962148e-01f, 2.01669056e-02f, 1.82030842e-01f, 2.25162819e-01f, 1.82584047e-01f,
  1.00999117e-01f, 9.74898264e-02f, 7.13855550e-02f, 1.17603309e-01f, 1.97667815e-02f, 6.18119091e-02f, 1.02612630e-01f, -2.97035296e-02f, 1.38754264e-01f, 2.55494006e-02f,
  9.53920186e-02f, 1.35181457e-01f, -1.33911178e-01f, -2.17646509e-01f, -3.52029055e-02f, 4.68705334e-02f, -1.44489169e-01f, 2.29257364e-02f, 5.20363124e-03f, -1.50144240e-02f,
  -9.37321503e-03f, 9.75985527e-02f, 1.18827373e-01f, 6.83395937e-02f, 2.06026435e-01f, 9.05428752e-02f, 3.55933420e-02f, -7.91970566e-02f, -1.63747653e-01f, -9.62976590e-02f,
  -2.94587407e-02f, 1.61066785e-01f, 1.14153989e-01f, 4.63392660e-02f, -7.42505118e-02f, -6.46402594e-03f, -4.21176702e-02f, -1.77120604e-02f, -6.67337701e-03f, 2.43309915e-01f,
  5.42615466e-02f, 4.00284439e-01f, 5.30384108e-02f, -9.88205820e-02f, 1.07527666e-01f, 2.68577076e-02f, 2.64173657e-01f, 1.53770491e-01f, -5.89872384e-03f, -1.13704596e-02f,
  -1.52663663e-01f, -1.47189856e-01f, -2.84981038e-02f, -2.34841201e-02f, 1.23507887e-01f, 1.03709340e-01f, 1.76395372e-01f, 5.43370135e-02f, -7.59893879e-02f, 5.37318327e-02f,
  1.57720577e-02f, -1.68899503e-02f, -1.05946943e-01f, -1.96230039e-02f, 9.55432877e-02f, 6.75283081e-04f, 9.83965471e-02f, 1.58683524e-01f, -1.86821595e-02f, 2.34183848e-01f,
  -8.56008530e-02f, 1.23709328e-01f, -3.03730875e-01f, -1.43189445e-01f, -3.05171385e-02f, 4.40815091e-03f, 3.84382321e-03f, -9.09014195e-02f, -7.10227946e-03f, 2.34035291e-02f,
  9.31624994e-02f, 7.74364099e-02f, 4.13617529e-02f, 1.58738926e-01f, 1.38448551e-01f, 6.73183650e-02f, 1.43027782e-01f, 1.09976888e-01f, -2.52654450e-03f, 4.50133793e-02f,
  6.12961501e-02f, -2.16531679e-02f, 4.43081418e-03f, 1.09822359e-02f, 1.04551673e-01f, -2.07732543e-01f, 2.54480522e-02f, -4.32519213e-04f, -5.42381704e-02f, -2.04370730e-02f,
  -1.83185786e-01f, -4.16176580e-02f, 1.18885010e-01f, 4.77889366e-02f, 1.23829678e-01f, -3.09629226e-03f, 1.05723754e-01f, 9.45409909e-02f, 3.21510583e-02f, 1.15592338e-01f,
  -9.13087055e-02f, -8.33192654e-03f, 1.00755088e-01f, 4.94549870e-02f, -1.72171727e-01f, 9.16163903e-04f, 4.88904715e-02f, -1.34991936e-03f, -2.20160652e-02f, -1.20273337e-01f,
  -2.57135965e-02f, 4.76008430e-02f, -9.61084738e-02f, 1.84310880e-02f, -1.61159009e-01f, 6.70858175e-02f, -1.08714495e-03f, -1.35105267e-01f, -2.79910341e-02f, -1.59342997e-02f,
  -1.53132364e-01f, -2.86343172e-02f, -1.94716543e-01f, 6.76337555e-02f, 4.31295112e-02f, 3.08233779e-02f, -8.24710578e-02f, -1.54937640e-01f, 5.66328131e-02f, -1.16632923e-01f,
  -8.03210214e-03f, 4.01602723e-02f, 1.83378309e-02f, 1.86458696e-02f, -3.65689546e-02f, -1.78002194e-01f, -3.16556655e-02f, -2.41902601e-02f, -7.67177716e-02f, -2.44799592e-02f,
  -2.34984905e-02f, -2.81397253e-01f, -2.29340225e-01f, -1.26932949e-01f, -2.96623260e-01f, -4.45892662e-01f, -1.60256341e-01f, -1.36169240e-01f, -2.41876110e-01f, -2.14443624e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  3.38603288e-01f, 1.82289883e-01f, 3.28117132e-01f, 5.55168152e-01f, 9.05272216e-02f, 2.22024083e-01f, 7.06071258e-02f, 2.95664549e-01f, 3.09112608e-01f, 3.98649871e-01f,
  2.97872305e-01f, 2.07860172e-01f, 1.80595621e-01f, 1.44978344e-01f, 3.25600863e-01f, 2.05776572e-01f, 3.22502226e-01f, 3.37773114e-01f, 6.45236596e-02f, 5.10167181e-01f,
  3.00201029e-01f, 3.23548824e-01f, 2.99129933e-01f, 2.36044779e-01f, -9.19893086e-02f, 3.60173494e-01f, 4.09626365e-01f, 1.27300605e-01f, 3.43712449e-01f, 2.12666526e-01f,
  4.31825489e-01f, 2.82051355e-01f, -1.02303036e-01f, 2.57390458e-02f, 8.06279704e-02f, 3.59627157e-01f, 3.54800522e-01f, 1.56421289e-01f, -1.12068087e-01f, 1.42531827e-01f,
  2.95237452e-01f, 3.50914508e-01f, 5.39699078e-01f, 4.20312971e-01f, 2.46746510e-01f, 3.80319029e-01f, 4.96393621e-01f, 1.22842498e-01f, 4.80219901e-01f, 4.13560331e-01f,
  4.90358859e-01f, 2.49147952e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -9.12105897e-04f, -5.91839328e-02f, 3.68142948e-02f, -3.40441279e-02f, 2.14821130e-01f, 5.98183088e-02f, 6.14265166e-02f, -7.59620816e-02f, -3.82237881e-02f, -2.10364844e-04f,
  1.08086523e-02f, -4.30269837e-02f, 1.89276397e-01f, 9.31284353e-02f, -5.97462878e-02f, 7.45848417e-02f, -1.60465300e-01f, -1.43479317e-01f, -4.61806543e-02f, 4.70145047e-02f,
  -9.15399343e-02f, -3.25206555e-02f, 5.31428121e-02f, 2.05416024e-01f, -2.37562507e-01f, -2.97933556e-02f, 7.13347867e-02f, -8.97380859e-02f, -1.75540030e-01f, -2.82482445e-01f,
  -1.19264737e-01f, 6.86082616e-02f, -2.19979450e-01f, -3.51797007e-02f, -2.23479662e-02f, -2.12930925e-02f, -1.19525127e-01f, 2.14458853e-01f, 5.04740551e-02f, 6.12649135e-03f,
  -9.07117352e-02f, -2.27375254e-01f, -6.00470528e-02f, -9.31158289e-03f, 1.14872500e-01f, -9.15354043e-02f, 9.21235010e-02f, 6.81039989e-02f, 1.80901855e-01f, 1.05101086e-01f,
  1.12596080e-01f, -2.33220100e-01f, 3.02263707e-01f, 7.32329562e-02f, -2.23876998e-01f, 2.92477518e-01f, -2.37458900e-01f, -1.13254920e-01f, 2.37679303e-01f, 1.13893338e-01f,
  -2.16741011e-01f, 2.40073614e-02f, 7.07007647e-02f, -4.98140529e-02f, 1.10253781e-01f, -6.81520905e-03f, -1.63498968e-02f, 2.44061649e-01f, -1.02843545e-01f, -6.05267212e-02f,
  -1.67942449e-01f, 7.14514926e-02f, -4.77025099e-02f, 1.07877605e-01f, -2.14124724e-01f, -1.26654617e-02f, -1.05144806e-01f, -1.94477476e-02f, -2.08798170e-01f, -1.25786826e-01f,
  9.79534388e-02f, -8.09293762e-02f, -6.29098564e-02f, -6.94934726e-02f, -1.85663179e-01f, 2.78525412e-01f, -2.95312330e-02f, -5.85407354e-02f, -6.79903403e-02f, -5.23495041e-02f,
  1.78126201e-01f, 2.29195744e-01f, 5.66306105e-03f, 1.10403694e-01f, -5.55073842e-02f, 2.95819014e-01f, -2.86394179e-01f, 1.33633584e-01f, -7.77562335e-02f, -1.56460911e-01f,
  -8.83131996e-02f, 1.41486585e-01f, 8.59699771e-03f, -3.38298492e-02f, -5.14687970e-02f, 2.22393706e-01f, 8.55942257e-03f, -1.14709198e-01f, -1.11598738e-01f, -5.82836419e-02f,
  -6.54767752e-02f, -1.19391434e-01f, -1.26328850e-02f, 1.21288761e-01f, -5.78275770e-02f, 1.12342082e-01f, -2.71605760e-01f, 1.98785976e-01f, 1.53491572e-01f, 6.97923303e-02f,
  -1.79254264e-01f, -4.70738448e-02f, 1.99686438e-01f, -1.05105780e-01f, -1.62656248e-01f, 6.60189912e-02f, -3.40843573e-02f, 2.02469572e-01f, -2.00061891e-02f, -9.45359841e-03f,
  4.48688008e-02f, -5.82254604e-02f, 1.72672674e-01f, 1.13522157e-01f, 8.58020559e-02f, 1.16363661e-02f, -1.96251974e-01f, -6.11179508e-02f, 5.99011034e-02f, -4.58369218e-03f,
  7.27780536e-02f, -8.55851546e-02f, 3.47358733e-02f, 5.88278547e-02f, -1.11994632e-01f, -1.50186568e-01f, 1.12199513e-02f, -1.88962922e-01f, 1.20124608e-01f, 2.12531462e-01f,
  3.45002897e-02f, -4.76297364e-02f, -1.94110088e-02f, 9.95522439e-02f, -4.03895676e-02f, -1.18332960e-01f, -9.14630294e-03f, -1.02484018e-01f, -9.75292176e-02f, -1.92237690e-01f,
  7.34018981e-02f, 1.56146675e-01f, -2.66037703e-01f, 1.54569955e-03f, -8.92226771e-02f, 1.74112231e-01f, -9.87837762e-02f, -1.62640721e-01f, 1.28873056e-02f, -1.97945476e-01f,
  1.04223609e-01f, -9.21583697e-02f, -6.37646988e-02f, 1.41719684e-01f, 3.52056883e-02f, -2.83011957e-03f, -9.27715972e-02f, 1.12789795e-01f, 1.14373498e-01f, -3.50129098e-01f,
  1.47351280e-01f, -8.52432922e-02f, -2.64885962e-01f, 2.31338888e-01f, 2.82620251e-01f, 2.17193291e-01f, 2.24228770e-01f, -1.16993196e-01f, -7.18074739e-02f, -2.69930989e-01f,
  2.17371956e-01f, 1.76035851e-01f, -9.38247144e-02f, 1.21961916e-02f, 1.42135471e-01f, 3.61549780e-02f, 9.23346058e-02f, 9.20619443e-02f, 7.96605349e-02f, -2.69414373e-02f,
  8.52063373e-02f, -5.31864576e-02f, -1.74112990e-01f, -2.15976071e-02f, 1.41938388e-01f, -8.12968388e-02f, 5.68019189e-02f, -8.68351310e-02f, 5.20958677e-02f, -1.78210381e-02f,
  -2.11632065e-02f, -3.26022990e-02f, 9.83477756e-02f, 1.85612664e-01f, -5.71244881e-02f, -1.81457147e-01f, 2.41259113e-01f, 7.10621998e-02f, -3.10421735e-02f, 1.35530217e-03f,
  8.63703415e-02f, -9.15434025e-03f, -4.86276820e-02f, 3.01983118e-01f, -1.62706241e-01f, -6.35565445e-02f, 5.76548651e-02f, -1.10719174e-01f, 7.16306493e-02f, -3.05498093e-02f,
  -5.25862072e-03f, 4.17863466e-02f, -1.04586385e-01f, 2.04489201e-01f, -3.21803614e-02f, 1.13303624e-01f, -5.91263659e-02f, -1.38511404e-01f, -3.70722860e-02f, -4.11362387e-03f,
  -1.46160901e-01f, -2.33376741e-01f, 9.08221863e-03f, 9.81606841e-02f, 8.81248862e-02f, 5.09437323e-02f, -3.96418534e-02f, 5.13397679e-02f, -1.73962310e-01f, 1.02099963e-01f,
  -1.27782002e-01f, -9.40016061e-02f, 6.57323003e-02f, -1.50398284e-01f, -1.22198844e-02f, -6.81871399e-02f, -6.80699572e-02f, -5.72003517e-03f, 2.18630712e-02f, -2.04730462e-02f,
  -2.09230542e-01f, 6.99385330e-02f, 2.09421426e-01f, -3.21689807e-02f, 4.71239090e-02f, -1.35531157e-01f, -6.96907192e-02f, 4.25538868e-02f, 3.63628231e-02f, -3.23533043e-02f,
  -1.38976455e-01f, 9.39409211e-02f, 4.76788059e-02f, 1.75419286e-01f, 3.14540304e-02f, 3.80174965e-02f, -1.13409154e-01f, 3.57357152e-02f, 1.18312925e-01f, 1.76348705e-02f,
  1.29490003e-01f, -4.80427928e-02f, 2.69609522e-02f, -1.95226762e-02f, 3.26808058e-02f, -5.61110675e-02f, -2.03571059e-02f, 2.77117564e-04f, 1.05556317e-01f, 4.68414240e-02f,
  -1.35629192e-01f, 1.95747763e-01f, -1.42063797e-01f, 2.36869697e-02f, 2.45266959e-01f, 5.04824072e-02f, 2.66325772e-02f, -5.86232841e-02f, -9.80195552e-02f, -4.53715436e-02f,
  -2.46556830e-02f, 1.23648597e-02f, 9.95755196e-02f, -2.10849062e-01f, -8.60286579e-02f, -1.16131835e-01f, -1.84810776e-02f, 1.14507705e-01f, -3.40686560e-01f, -3.52327973e-02f,
  -1.86738029e-01f, -4.27111268e-01f, -1.77308455e-01f, 1.03687435e-01f, -1.69774219e-01f, 1.43614635e-01f, 2.85574645e-01f, -9.63905603e-02f, -9.91863087e-02f, -8.65867548e-03f,
  -1.08613834e-01f, 7.38391280e-02f, 7.55661279e-02f, -1.70141041e-01f, 4.97734360e-02f, 2.18076836e-02f, -7.53475726e-03f, -1.73062786e-01f, 5.85821420e-02f, -2.79473305e-01f,
  2.73243874e-01f, 1.98277161e-01f, 3.36125374e-01f, -2.94260774e-02f, 9.27905217e-02f, 5.63680753e-02f, -2.43971735e-01f, -9.03562456e-02f, -1.79714486e-01f, 1.53674588e-01f,
  -4.93078828e-02f, 1.32044777e-01f, 8.12679753e-02f, 2.91030910e-02f, -1.31814048e-01f, -3.56343016e-03f, -9.17693079e-02f, -1.16968580e-01f, 3.34733985e-02f, 8.55609030e-02f,
  1.31559744e-01f, 1.60033181e-01f, 1.09039478e-01f, -1.27997875e-01f, 4.49947603e-02f, 2.90592968e-01f, 1.47675630e-02f, 5.45597747e-02f, -1.50942475e-01f, -2.21146926e-01f,
  7.00553805e-02f, -1.13229468e-01f, 2.15710346e-02f, 3.44904400e-02f, -5.27418181e-02f, -2.68334728e-02f, -1.67435348e-01f, 1.79324344e-01f, -2.31761947e-01f, 1.79493707e-02f,
  -9.99759790e-03f, 4.47425339e-03f, -6.45202845e-02f, -4.17069197e-02f, 1.36374012e-01f, 4.28457186e-02f, 3.14283788e-01f, -1.00749843e-02f, -5.07305749e-02f, 8.14911947e-02f,
  -1.29011005e-01f, 2.17913259e-02f, 3.40303741e-02f, -7.32004493e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.24619491e-01f, 1.45544752e-01f, 1.59739137e-01f, 2.15687901e-01f, 1.18933007e-01f, 3.72646421e-01f, 7.00085983e-02f, -9.48512703e-02f, -2.15385690e-01f, 2.21085951e-01f,
  2.21411705e-01f, 9.82210711e-02f, -1.31956741e-01f, 1.07686505e-01f, 9.39783752e-02f, 2.36372918e-01f, -1.31182283e-01f, 7.31099099e-02f, 1.72238722e-01f, 1.33983776e-01f,
  -5.16795442e-02f, -9.43601578e-02f, 9.11506265e-02f, 3.76833111e-01f, -1.92898259e-01f, 2.53673553e-01f, 1.96581319e-01f, -1.67081244e-02f, 1.25549644e-01f, -1.43744826e-01f,
  -1.42998159e-01f, -3.13336551e-01f, 2.72622257e-01f, 1.89270392e-01f, -1.82494283e-01f, 3.43061835e-01f, -8.47334936e-02f, 1.72529649e-02f, 1.76137194e-01f, -1.92936718e-01f,
  1.11520309e-02f, -2.79344678e-01f, 2.90030271e-01f, -1.68399081e-01f, -1.02177700e-02f, 1.07043758e-01f, -2.89106350e-02f, 3.81629094e-02f, 3.51126909e-01f, 2.20093384e-01f,
  7.93113187e-02f, -1.07541293e-01f, 1.32599715e-02f, 2.85661966e-01f, 2.43158825e-02f, -1.20523788e-01f, 4.23034996e-01f, 1.49955153e-01f, 3.21818233e-01f, 1.44888043e-01f,
  4.31506038e-01f, 6.33915961e-02f, 1.89551130e-01f, 1.83090642e-02f, 1.94760785e-01f, 1.82732031e-01f, 1.29485294e-01f, 2.83691704e-01f, 3.59614909e-01f, 1.90260693e-01f,
  1.92058533e-02f, 1.81266293e-01f, -4.27926518e-02f, -1.95782751e-01f, 8.74586850e-02f, 3.02711334e-02f, 5.28267264e-01f, 6.81409687e-02f, 3.40500265e-01f, 8.28213617e-02f,
  1.43834442e-01f, -2.18955919e-01f, -3.63611519e-01f, 1.27508447e-01f, -2.07537830e-01f, 2.52364159e-01f, 2.81301618e-01f, -7.57154822e-02f, 1.17779620e-01f, -1.33041888e-01f,
  -2.74776164e-02f, 3.21031432e-03f, -2.00571015e-01f, -2.30436977e-02f, 1.95564508e-01f, 6.16424680e-01f, -3.84441108e-01f, 1.91408738e-01f, 1.53687559e-02f, 2.14524075e-01f,
  -9.15786996e-02f, 3.77629757e-01f, 1.71278298e-01f, -1.38624767e-02f, 5.81427701e-02f, 4.98710632e-01f, -1.38732167e-02f, -3.18231694e-02f, -1.64127350e-01f, -3.35749090e-01f,
  -2.42835104e-01f, 2.28748396e-01f, 3.21890801e-01f, -2.87343204e-01f, -2.86511127e-02f, 1.12253152e-01f, -1.57976314e-01f, 7.38750622e-02f, 4.86516804e-01f, 2.66950160e-01f,
  -1.43588692e-01f, -3.21695179e-01f, 3.58631730e-01f, -1.37440175e-01f, -1.88728794e-01f, 2.81150341e-01f, -2.51960307e-02f, -4.22075540e-02f, 2.41453230e-01f, 1.40565529e-01f,
  -3.59767932e-03f, -1.89648882e-01f, 5.70479184e-02f, -4.55045402e-02f, 2.03724176e-01f, 1.23906381e-01f, 2.61256188e-01f, -2.99322575e-01f, 2.52737254e-01f, 2.80772865e-01f,
  1.48028255e-01f, -2.23947167e-01f, 1.61121920e-01f, 1.22860245e-01f, -2.89201528e-01f, 1.78770423e-01f, -2.01747701e-01f, -2.37665638e-01f, -4.79283154e-01f, 1.65547371e-01f,
  -9.63887349e-02f, -9.45488084e-03f, -1.29819915e-01f, -6.72682151e-02f, -1.47533521e-01f, 5.65477572e-02f, 1.25345752e-01f, 2.21905097e-01f, -1.96074203e-01f, 2.80392110e-01f,
  2.31120452e-01f, 1.78600937e-01f, -2.46493682e-01f, -1.03179805e-01f, 3.78725529e-02f, 5.16788512e-02f, 2.83779860e-01f, 1.94365606e-02f, 4.25225077e-03f, -7.84108192e-02f,
  7.79674053e-02f, -3.77754532e-02f, -4.68374491e-02f, 1.02671467e-01f, -2.54672766e-01f, -2.84062743e-01f, -2.20325693e-01f, 6.13861904e-02f, -1.29480600e-01f, 1.09880231e-01f,
  -1.09246254e-01f, -4.44480367e-02f, -1.70076415e-01f, -7.62896985e-02f, 2.75345653e-01f, -1.00882053e-01f, -1.33102201e-02f, 1.83913305e-01f, -1.35538317e-02f, -1.30472124e-01f,
  2.96364874e-01f, 1.27392992e-01f, 1.58380210e-01f, 8.16177204e-02f, 8.53340402e-02f, 1.73899502e-01f, 2.57544786e-01f, 6.31067529e-02f, -1.17970340e-01f, 2.52643406e-01f,
  7.23261386e-02f, 4.48137661e-03f, -2.21797414e-02f, 1.88670143e-01f, 3.78678650e-01f, -1.77582890e-01f, -9.08904597e-02f, 9.81083363e-02f, 1.38526842e-01f, -1.79043248e-01f,
  -1.59357116e-01f, -3.78148526e-01f, -3.25483471e-01f, -3.19160044e-01f, -1.71259150e-01f, 1.49514496e-01f, -1.15066871e-01f, -1.73063666e-01f, 2.90090442e-01f, -5.73873445e-02f,
  4.60434258e-02f, -7.81229138e-02f, -1.66326448e-01f, 3.02997798e-01f, -2.00791970e-01f, 1.95232034e-01f, -2.51718581e-01f, 4.63185981e-02f, -3.71042311e-01f, 3.77502531e-01f,
  2.84838080e-01f, 1.99383702e-02f, 2.23380812e-02f, 1.96582586e-01f, 1.34371266e-01f, -2.02735767e-01f, -2.78214663e-01f, -9.58381742e-02f, -5.35137095e-02f, -3.22343528e-01f,
  1.61005065e-01f, 4.02088344e-01f, 2.24937014e-02f, -1.79044574e-01f, -1.12286441e-01f, 3.01997632e-01f, 2.62559280e-02f, 1.40438110e-01f, -3.41712334e-03f, -3.23917121e-01f,
  4.40785378e-01f, -1.45379975e-01f, -3.80066097e-01f, -1.84457839e-01f, 8.34921449e-02f, 2.98547477e-01f, 2.61186481e-01f, 2.93760717e-01f, 2.44308114e-01f, 1.43708616e-01f,
  2.54423499e-01f, 4.27349694e-02f, -1.52087817e-02f, -2.05516070e-02f, 1.36527896e-01f, -2.90785246e-02f, 7.19998358e-03f, -8.35083798e-02f, 3.44465792e-01f, -1.61999196e-01f,
  1.94730639e-01f, -1.12810113e-01f, -3.10130239e-01f, 8.24975520e-02f, 2.34049349e-03f, -1.50679097e-01f, 2.98850030e-01f, 1.89274460e-01f, -1.00819312e-01f, -1.40027687e-01f,
  3.72740515e-02f, 2.23288406e-03f, -2.04026014e-01f, -4.03319657e-01f, -2.05144525e-01f, -3.87676582e-02f, 1.29848227e-01f, 2.21082926e-01f, -4.19404730e-02f, -8.90410021e-02f,
  4.31404293e-01f, 1.52904794e-01f, -9.62702930e-02f, 1.49279386e-01f, -1.00526877e-01f, -2.58467104e-02f, 1.18239217e-01f, 3.27442348e-01f, 1.89358592e-02f, 1.53767705e-01f,
  -2.42137969e-01f, -1.25322148e-01f, -2.10614607e-01f, 2.25431412e-01f, -3.43683572e-03f, -3.32993418e-01f, 1.05320081e-01f, -8.68605897e-02f, 5.49866378e-01f, -2.85561532e-01f,
  -1.51442572e-01f, 6.55849159e-01f, 4.91999239e-02f, 4.49964739e-02f, 1.83329940e-01f, -3.06433551e-02f, -7.89105222e-02f, -2.46448845e-01f, 2.34456912e-01f, 6.33508414e-02f,
  1.41801208e-01f, 2.00307965e-01f, 1.04937822e-01f, -1.82562787e-02f, 3.74062993e-02f, -3.42808887e-02f, -1.69797674e-01f, -5.33718765e-02f, 8.28819200e-02f, -1.78368419e-01f,
  -2.04535484e-01f, 1.87455386e-01f, -3.10931623e-01f, -3.76858637e-02f, -8.83861780e-02f, -1.30182222e-01f, 1.51801392e-01f, 2.20087200e-01f, 4.55589704e-02f, 2.01121658e-01f,
  -2.21076850e-02f, 7.43059292e-02f, 1.18970133e-01f, -7.46083409e-02f, -1.87386889e-02f, 1.78817317e-01f, 2.88118750e-01f, 2.39616171e-01f, -7.11201653e-02f, 3.45034242e-01f,
  1.91240415e-01f, 5.02952456e-01f, 7.67453760e-02f, 1.48968965e-01f, 6.03524558e-02f, -4.21554387e-01f, -7.43581653e-02f, -3.62609446e-01f, 2.17794165e-01f, 1.38799638e-01f,
  -1.32656410e-01f, 3.71668428e-01f, 2.86725275e-02f, -2.49900103e-01f, -5.11568272e-03f, 2.88746983e-01f, -2.72835076e-01f, -4.25921082e-01f, -1.29571617e-01f, 1.19905815e-01f,
  1.54839205e-02f, 4.31433380e-01f, -2.63032913e-01f, 2.34233737e-01f, 8.38861316e-02f, -1.01801224e-01f, 2.55131245e-01f, 1.56860590e-01f, -1.17278576e-01f, -5.55019118e-02f,
  -1.20920904e-01f, 2.44536296e-01f, 7.48235732e-02f, 1.65027171e-01f, -1.19253315e-01f, -5.89535646e-02f, 1.03164725e-01f, 9.84873399e-02f, 2.83587784e-01f, 9.25143659e-02f,
  8.80224854e-02f, 8.42696801e-03f, -3.41185108e-02f, -1.32309407e-01f, -1.37091368e-01f, 5.02694808e-02f, 2.70518959e-01f, 1.56281278e-01f, -2.47959699e-02f, -1.02386244e-01f,
  -1.38867125e-01f, 1.32821485e-01f, -9.30356458e-02f, -1.21840723e-01f, -1.06477708e-01f, -1.65836103e-02f, -2.39256620e-01f, 1.09553248e-01f, -3.21095049e-01f, -1.06479220e-01f,
  -6.08068705e-02f, -3.67234468e-01f, -1.21986270e-01f, -2.48510931e-02f, 1.97014883e-02f, 3.34444731e-01f, -1.58754498e-01f, -8.04974809e-02f, 3.00702769e-02f, 1.39454365e-01f,
  2.84201466e-02f, 1.97099715e-01f, 1.22458473e-01f, 1.56075254e-01f, 3.39535903e-03f, 1.60705999e-01f, 1.70604754e-02f, 1.17228314e-01f, 1.45432234e-01f, -3.13819982e-02f,
  3.10429558e-02f, 7.38436729e-02f, 2.25466594e-01f, -1.17830247e-01f, 1.05576403e-01f, -2.46491626e-01f, 2.89101839e-01f, -1.88146666e-01f, -4.10238244e-02f, 1.16179675e-01f,
  -2.12184623e-01f, -1.59220964e-01f, 1.61822662e-01f, -3.86727341e-02f, -2.47702464e-01f, -5.15542254e-02f, 4.35063895e-03f, 6.44422993e-02f, 1.00538701e-01f, 2.40248650e-01f,
  1.22982614e-01f, 2.33566180e-01f, -1.39576169e-02f, 1.64302066e-01f, 2.77574420e-01f, -1.92830905e-01f, 1.07707545e-01f, -2.71444172e-01f, -2.35738367e-01f, 1.29114226e-01f,
  -2.37466805e-02f, -1.22555926e-01f, 1.84841573e-01f, 3.65902185e-01f, 2.35970721e-01f, -6.54690787e-02f, 2.04378754e-01f, -7.29547963e-02f, 1.71660095e-01f, 2.01304570e-01f,
  1.61525950e-01f, -2.63988405e-01f, 1.68028861e-01f, -3.20770591e-02f, 8.03387314e-02f, 1.79412633e-01f, 3.70917581e-02f, 1.35112137e-01f, -1.30972221e-01f, 2.19334185e-01f,
  3.66035223e-01f, -7.64398603e-03f, -2.88751811e-01f, 1.41099123e-02f, -1.51555791e-01f, -1.62832171e-01f, 1.77708656e-01f, 4.92419116e-02f, 1.14873476e-01f, 2.98025124e-02f,
  1.71336725e-01f, 1.17885590e-01f, -2.67356306e-01f, 9.69031230e-02f, -3.25864814e-02f, -1.22683503e-01f, -3.33591938e-01f, 2.94492599e-02f, -1.42955869e-01f, 1.85798574e-02f,
  -5.38529515e-01f, 3.00169259e-01f, -8.38848054e-02f, -1.00415327e-01f, 4.03890163e-02f, 6.69140518e-02f, -2.20338956e-01f, 1.53918862e-01f, 4.61654425e-01f, -1.34529188e-01f,
  2.51942605e-01f, -6.76920116e-02f, 2.38038212e-01f, 3.26019496e-01f, 1.43948331e-01f, 2.99215227e-01f, 2.52277344e-01f, 3.29033315e-01f, 1.17143750e-01f, 3.75369862e-02f,
  -2.81948924e-01f, 1.48593217e-01f, 7.56834894e-02f, -9.83008295e-02f, 1.79618925e-01f, 1.12377472e-01f, 3.26489776e-01f, 1.27513573e-01f, -9.12610367e-02f, -2.53940403e-01f,
  -1.97737929e-04f, 6.33299127e-02f, 1.35900127e-02f, -3.58622037e-02f, 2.10220650e-01f, 2.40150601e-01f, 2.87374519e-02f, -3.21624391e-02f, 5.13854958e-02f, 4.44119386e-02f,
  3.49770248e-01f, -2.66484022e-01f, -1.84638873e-02f, -3.38414699e-01f, 3.24396461e-01f, 1.94508508e-01f, -3.79719287e-02f, 2.26946786e-01f, -1.08898759e-01f, 4.82280962e-02f,
  -6.86878338e-02f, 1.41705438e-01f, -1.51592389e-01f, -1.46029936e-02f, 1.98615938e-01f, 2.62454182e-01f, 2.22395316e-01f, -7.11138025e-02f, 2.37870276e-01f, 2.19186902e-01f,
  3.92194062e-01f, 6.17365055e-02f, 4.22641914e-03f, -2.00147584e-01f, -1.66995913e-01f, -5.47054224e-02f, 4.21460539e-01f, -1.06479488e-01f, -3.64354402e-01f, 5.80438562e-02f,
  7.95246214e-02f, 1.28643259e-01f, 2.72716939e-01f, 1.89084664e-01f, 1.06339920e-02f, -7.89956450e-02f, 6.85389042e-02f, 1.55353367e-01f, 2.48147085e-01f, 2.28167176e-01f,
  2.70130247e-01f, 2.25236028e-01f, -2.03301877e-01f, 7.55396634e-02f, -5.21326251e-02f, 6.62957951e-02f, 1.27490938e-01f, 1.15033507e-01f, 1.09685272e-01f, 2.45118320e-01f,
  3.54198158e-01f, 5.51054813e-03f, 1.99869663e-01f, -2.02641860e-01f, -2.08041385e-01f, -3.45058516e-02f, -2.78583229e-01f, 2.66140699e-01f, 1.45090044e-01f, 3.17709804e-01f,
  1.31915987e-01f, 7.78890476e-02f, -4.13947031e-02f, 1.24593288e-01f, 1.98501218e-02f, 1.40512297e-02f, -1.14752598e-01f, 3.12436700e-01f, 2.10739166e-01f, 2.91155487e-01f,
  -8.12051445e-02f, 6.59576803e-02f, -2.44572327e-01f, 3.73565145e-02f, -1.06003527e-02f, 3.26497406e-02f, -6.97895437e-02f, 1.83208421e-01f, 4.00978029e-02f, -3.65537778e-02f,
  2.92786937e-02f, -1.83057442e-01f, 2.40712002e-01f, -6.81158975e-02f, 3.23639810e-01f, 1.88928783e-01f, 4.11143526e-02f, 1.21760249e-01f, -4.83118743e-01f, 1.08646199e-01f,
  2.81132162e-01f, -1.51813850e-01f, -1.89407691e-01f, -1.55179963e-01f, 9.20473486e-02f, -6.75493032e-02f, -3.99290800e-01f, 1.88774675e-01f, -2.76697725e-02f, 9.64416116e-02f,
  7.60922655e-02f, 1.61111653e-01f, 2.54750580e-01f, -5.60174473e-02f, -4.46743555e-02f, 1.47262990e-01f, 1.57778367e-01f, 1.52983349e-02f, -1.07367307e-01f, 1.14843056e-01f,
  -1.58749893e-01f, 6.90277964e-02f, 6.31184876e-02f, 7.71564692e-02f, -2.90953010e-01f, 2.66008288e-01f, 9.47613642e-02f, 9.40480456e-02f, 3.14059258e-01f, 9.40232724e-02f,
  2.66565263e-01f, -1.34045064e-01f, 1.49751529e-02f, -1.17018402e-01f, -1.42360874e-03f, 1.96898058e-01f, 3.63131762e-01f, 9.20344740e-02f, 1.29559994e-01f, -2.96961516e-01f,
  -6.61998242e-02f, -1.54013246e-01f, -1.83847323e-01f, 5.61043657e-02f, 1.25218138e-01f, 2.25529447e-01f, 1.21187098e-01f, 5.08892655e-01f, 4.17586803e-01f, 1.84097309e-02f,
  2.97725257e-02f, -2.89513290e-01f, 1.84179068e-01f, 1.17492989e-01f, -5.90530559e-02f, -7.03133866e-02f, -9.66435391e-03f, 1.23436406e-01f, 1.80253521e-01f, -5.77340461e-02f,
  -9.19361599e-03f, -1.52651474e-01f, 4.98307377e-01f, 3.96542966e-01f, -1.87805876e-01f, -3.21232155e-03f, -2.30884552e-01f, 2.18817368e-01f, 1.33738875e-01f, 2.05483422e-01f,
  5.02619088e-01f, 3.96004021e-02f, 2.11140260e-01f, -2.35528424e-01f, 2.26472884e-01f, 2.47346804e-01f, 1.04463704e-01f, -1.19024344e-01f, 1.22668400e-01f, 1.82871416e-01f,
  -3.08319956e-01f, 2.58183070e-02f, -8.10670853e-02f, 2.05198199e-01f, -4.06420194e-02f, 1.85514525e-01f, -2.38472894e-01f, -8.35192949e-02f, -4.56515253e-01f, -5.39519154e-02f,
  2.19461828e-01f, -1.51655097e-02f, 1.98065951e-01f, 2.53129214e-01f, 3.67083773e-02f, 2.83922572e-02f, -5.18957973e-02f, 2.22917393e-01f, -1.20974615e-01f, 1.53666213e-01f,
  3.41574997e-02f, 2.33552262e-01f, -1.67180051e-03f, 2.79330671e-01f, 9.04510468e-02f, -2.62481838e-01f, 1.64870247e-02f, 4.64717448e-02f, 2.20765918e-01f, -1.46519765e-01f,
  6.02998585e-02f, -3.00022922e-02f, -1.40233308e-01f, 9.72836465e-03f, -1.51051342e-01f, -1.79935753e-01f, 3.56209204e-02f, -1.15431182e-01f, 3.09598237e-01f, 6.60350397e-02f,
  1.38009429e-01f, -1.57914579e-01f, 4.99101073e-01f, 3.27776708e-02f, 1.29448608e-01f, 1.38793379e-01f, 2.93816656e-01f, 2.11187750e-01f, 1.10754885e-01f, -2.33868390e-01f,
  9.60207582e-02f, 1.60037242e-02f, 3.39861475e-02f, 5.76621145e-02f, -2.95216590e-01f, 3.44663203e-01f, -4.41015474e-02f, 3.19511443e-02f, 1.45274187e-02f, 7.90181234e-02f,
  9.38985031e-03f, -2.37453103e-01f, -1.10312119e-01f, -5.13123423e-02f, 5.68689741e-02f, -1.23917706e-01f, -2.31045455e-01f, -5.49936816e-02f, -4.40885603e-01f, 2.94277351e-02f,
  4.75650566e-04f, 6.15064688e-02f, -2.30177715e-01f, 2.43372753e-01f, 2.23061129e-01f, 4.93132416e-03f, 3.68177503e-01f, -2.05330756e-02f, 2.17030481e-01f, -3.59851331e-01f,
  8.05570483e-02f, -2.12091312e-01f, 2.24368259e-01f, -1.92804679e-01f, 1.05690680e-01f, 4.24927771e-02f, 2.43007734e-01f, 1.09279096e-01f, -1.94616958e-01f, -4.47307438e-01f,
  5.53776026e-02f, 1.55253336e-02f, 2.71303087e-01f, 2.68187784e-02f, -2.79631823e-01f, 4.38778661e-02f, 2.12734208e-01f, -4.91295233e-02f, 1.44591808e-01f, -2.10783273e-01f,
  1.27724230e-01f, 1.95597887e-01f, -2.60798544e-01f, -1.62653804e-01f, 1.51252985e-01f, -3.13790031e-02f, 2.65152454e-01f, -1.20439783e-01f, 5.16024791e-02f, 8.80282447e-02f,
  2.58967608e-01f, 1.22887902e-01f, 1.09154806e-02f, -2.72916138e-01f, 6.33251891e-02f, 7.41186291e-02f, -3.08990896e-01f, 1.06130183e-01f, 4.92458254e-01f, 8.63417313e-02f,
  1.00778509e-02f, -2.51741350e-01f, 2.15130642e-01f, 1.34135991e-01f, 8.49528685e-02f, 2.64179230e-01f, -2.55131386e-02f, -1.63926510e-03f, 2.40876973e-01f, -1.25859320e-01f,
  3.34756941e-01f, -3.33357137e-03f, 8.56627971e-02f, 3.05395201e-02f, -3.87176499e-02f, -3.97865802e-01f, 2.00396523e-01f, 4.60318066e-02f, -1.98177770e-01f, 1.13113716e-01f,
  1.30695790e-01f, 1.19782418e-01f, 9.05521587e-02f, 5.21538556e-01f, 1.33317009e-01f, -7.09626079e-02f, -4.97034565e-02f, 1.58098161e-01f, -6.98031038e-02f, 4.98160087e-02f,
  -7.58972764e-02f, 2.90020704e-01f, 2.18731761e-01f, 4.19116110e-01f, 3.17229986e-01f, -1.30717114e-01f, 7.90102035e-02f, -4.39805686e-02f, -2.04601139e-03f, 7.57012591e-02f,
  4.50320803e-02f, -1.91430435e-01f, 7.89425075e-02f, 2.61508450e-02f, 2.16343120e-01f, -5.20574264e-02f, -2.44888633e-01f, 1.86673611e-01f, -4.76975381e-01f, -5.29701300e-02f,
  -3.48675579e-01f, -3.44132050e-03f, -8.19737166e-02f, 1.21621758e-01f, 9.79251266e-02f, 4.36303392e-02f, -4.96653557e-01f, 4.05862272e-01f, 4.13960934e-01f, 2.28913039e-01f,
  7.91590139e-02f, -1.88656732e-01f, 1.02724314e-01f, -7.85377175e-02f, 3.73265952e-01f, 9.70634967e-02f, 1.43325832e-02f, 2.90135797e-02f, 1.33081332e-01f, -6.17750734e-02f,
  1.84510216e-01f, 9.69042908e-03f, -1.11915439e-01f, 1.00666992e-01f, 5.70504628e-02f, -1.23843022e-01f, -6.09473437e-02f, 8.94081444e-02f, 4.83957022e-01f, 2.00542867e-01f,
  2.71475520e-02f, 1.16881602e-01f, -3.62279356e-01f, -2.05985699e-02f, -5.07892631e-02f, 1.14498429e-01f, -1.17475122e-01f, -2.66948134e-01f, 2.90594324e-02f, -1.28320262e-01f,
  2.62393653e-01f, -1.56583935e-01f, -4.64473426e-01f, -4.61904198e-01f, -1.28354654e-01f, 2.79174715e-01f, -1.02152303e-01f, 2.01897427e-01f, 1.31899035e-02f, -2.10923806e-01f,
  4.34417069e-01f, 1.41016409e-01f, -5.41612059e-02f, 1.47308037e-01f, 2.69456595e-01f, 1.78548153e-02f, 1.30102053e-01f, 1.92002192e-01f, 4.51552197e-02f, 2.39263952e-01f,
  -6.64695911e-03f, -3.34755778e-01f, 2.96157897e-01f, 4.26689893e-01f, 3.29777956e-01f, -2.49716669e-01f, -2.45528787e-01f, 5.95397353e-02f, 2.19369441e-01f, -5.13814747e-01f,
  4.68025208e-01f, 4.00389880e-02f, -1.20329790e-01f, -1.60886481e-01f, -3.34029824e-01f, 1.19359501e-01f, 2.07718145e-02f, 2.99738228e-01f, -5.29724658e-02f, 1.44989155e-02f,
  1.75806776e-01f, -1.32988142e-02f, 1.72327086e-02f, 1.94220006e-01f, 7.13980049e-02f, 1.29336342e-01f, -6.06052130e-02f, 1.31509751e-01f, -4.00196612e-02f, 1.32578194e-01f,
  2.92664111e-01f, 4.51523513e-02f, -7.79243335e-02f, -9.71248653e-03f, 1.13748722e-01f, -2.20847083e-03f, -2.92358547e-01f, 1.04756087e-01f, -9.69784930e-02f, 2.31060445e-01f,
  -8.70182216e-02f, 2.16363091e-02f, 1.43380746e-01f, 3.92297417e-01f, 2.78434604e-02f, -1.12826131e-01f, -5.40597402e-02f, -1.42974183e-01f, -3.07509303e-02f, 2.10668311e-01f,
  -9.93406400e-02f, -2.36383289e-01f, 3.17141205e-01f, -4.19730740e-03f, 1.20629221e-01f, 2.90550321e-01f, -1.15254387e-01f, -2.32791409e-01f, -1.97874472e-01f, 1.07198007e-01f,
  2.39138931e-01f, -1.86595786e-02f, -9.97384191e-02f, -1.38828546e-01f, 7.98567981e-02f, 1.88298002e-01f, 9.56764147e-02f, 2.57556766e-01f, -3.25915180e-02f, 4.54223961e-01f,
  -5.40361293e-02f, -1.04759894e-01f, 1.99844569e-01f, -9.84052792e-02f, -5.10140089e-03f, -4.86887135e-02f, 4.78921264e-01f, 2.20856816e-02f, 4.56013262e-01f, 1.60815511e-02f,
  -3.98111492e-01f, -1.33012623e-01f, -7.41029903e-02f, 7.12035075e-02f, 1.33723795e-01f, 2.83361733e-01f, 2.63110518e-01f, 1.19868204e-01f, 1.79872513e-01f, 7.64600635e-02f,
  1.49402302e-03f, 5.58591932e-02f, -8.46507773e-02f, -1.19361535e-01f, 2.73824483e-01f, 5.16629443e-02f, -1.54134542e-01f, -3.62511069e-01f, 2.18155861e-01f, -1.34031307e-02f,
  -5.29532433e-01f, 2.10362170e-02f, 1.33039415e-01f, -1.53712809e-01f, 2.09292263e-01f, 8.07362124e-02f, 4.20757346e-02f, 3.86566490e-01f, -1.25666161e-03f, 1.02857031e-01f,
  -2.25469694e-01f, -4.78272110e-01f, -5.68904504e-02f, 1.77563682e-01f, 8.94380882e-02f, -2.49924064e-02f, 2.99386591e-01f, -2.43670139e-02f, 9.87458695e-03f, 1.84281841e-01f,
  -7.67286122e-02f, 7.15564936e-02f, -3.38560224e-01f, -1.69610940e-02f, -6.08679391e-02f, -7.11928529e-04f, 1.55401260e-01f, -1.93933081e-02f, -1.70982808e-01f, 2.44025458e-02f,
  -6.17444329e-02f, 1.43524706e-01f, -1.45702399e-02f, 3.21358383e-01f, -6.68163672e-02f, -1.75443292e-01f, 4.88670886e-01f, -2.93685734e-01f, -3.81158918e-01f, 1.82507753e-01f,
  3.62202436e-01f, 4.33199912e-01f, 4.05577093e-01f, -6.83597997e-02f, -1.27321497e-01f, -2.87337452e-01f, 3.70079666e-01f, 1.98048949e-01f, 1.06961720e-01f, 9.80027467e-02f,
  8.32910538e-02f, -7.01657496e-03f, 2.84054816e-01f, 2.13057041e-01f, 2.01530352e-01f, 7.19532669e-02f, -2.91472763e-01f, -1.12761997e-01f, -1.02534018e-01f, 2.68938303e-01f,
  2.11538702e-01f, -1.01788916e-01f, 7.99403861e-02f, 1.48555964e-01f, -8.08400065e-02f, -1.99002817e-01f, -1.04085356e-01f, 2.16170941e-02f, 1.07289337e-01f, -2.60511070e-01f,
  1.57872647e-01f, -1.95366845e-01f, 2.17128366e-01f, 7.67312711e-03f, 2.57271588e-01f, 1.67617016e-02f, 5.82856461e-02f, -3.17940384e-01f, -5.79585135e-02f, -2.56226748e-01f,
  -1.29680395e-01f, 1.97671115e-01f, 6.24269433e-02f, 2.54106522e-01f, 6.44337106e-03f, 4.02303457e-01f, 2.28312477e-01f, -3.57017033e-02f, 9.04261041e-03f, -9.50338468e-02f,
  2.02810969e-02f, 5.57720177e-02f, -1.97093666e-01f, -3.51689845e-01f, -2.60264665e-01f, 2.34957114e-01f, -8.10622517e-03f, 1.55878693e-01f, -7.85549656e-02f, 1.59856170e-01f,
  9.64664146e-02f, 1.71613812e-01f, 6.16798341e-01f, -7.62806134e-03f, -1.08323125e-02f, -1.03283763e-01f, 1.45925298e-01f, -1.04434662e-01f, 1.53583616e-01f, 5.64748719e-02f,
  9.62919295e-02f, -1.37502432e-01f, 2.68295676e-01f, -8.59233439e-02f, 1.74620882e-01f, 2.43854016e-01f, 3.52028571e-02f, 7.57124051e-02f, 1.50211066e-01f, -1.44501224e-01f,
  -1.03090815e-01f, 1.58286184e-01f, -7.35996813e-02f, 1.90758463e-02f, 1.69096485e-01f, -1.32840008e-01f, 2.95327514e-01f, -1.95405707e-01f, 8.36588442e-02f, 3.77442427e-02f,
  2.55885512e-01f, 3.44621837e-01f, 2.38746688e-01f, 4.95171875e-01f, 3.26649964e-01f, -1.14703983e-01f, 3.51819366e-01f, 5.80128841e-02f, 5.27264178e-02f, 3.17635030e-01f,
  -2.25913227e-01f, 1.91328824e-01f, 1.54237717e-01f, -4.12488505e-02f, -2.36564457e-01f, -3.37804496e-01f, 1.95277855e-01f, 1.53823912e-01f, 2.08802223e-01f, -1.51347622e-01f,
  -1.27086341e-01f, -7.47959465e-02f, -2.35998183e-01f, -4.13664468e-02f, -1.57511473e-01f, 2.08619550e-01f, -1.80525690e-01f, 4.35347036e-02f, -1.67608768e-01f, 4.30614233e-01f,
  -5.35420299e-01f, 1.44401878e-01f, 2.17250139e-02f, 3.48713279e-01f, 2.01479241e-01f, 2.81863868e-01f, 2.32678786e-01f, -1.41295269e-01f, 1.60282776e-01f, 2.75087506e-01f,
  -3.49158421e-02f, 1.57232191e-02f, 3.15055341e-01f, -4.25808914e-02f, 3.06677422e-03f, -1.14220239e-01f, 1.33248970e-01f, 8.74159858e-02f, 2.11883470e-01f, 1.31162792e-01f,
  8.98146769e-04f, 9.97314751e-02f, 1.11479849e-01f, -1.96658939e-01f, 1.59686655e-01f, 5.80751747e-02f, -3.24091434e-01f, -1.75758988e-01f, -8.67203102e-02f, -2.50697523e-01f,
  1.25029564e-01f, 1.59165442e-01f, 1.46737918e-01f, -5.18232472e-02f, 1.03414625e-01f, -2.03313679e-03f, 2.17165723e-01f, 4.19937640e-01f, -3.32361348e-02f, -1.55953959e-01f,
  2.47939944e-01f, 1.18009008e-01f, 1.70053631e-01f, 2.44478062e-01f, 1.11239843e-01f, 4.51655872e-02f, 1.97273850e-01f, 1.89891577e-01f, -1.39447764e-01f, -1.45253995e-02f,
  1.35197282e-01f, -1.64209560e-01f, 5.23274504e-02f, -1.64740875e-01f, -2.01558366e-01f, -4.04236689e-02f, 1.14399545e-01f, 4.46930788e-02f, 1.15804739e-01f, 1.11498967e-01f,
  -4.32119220e-01f, 1.43216908e-01f, -1.46512136e-01f, -1.40261546e-01f, 3.20681557e-02f, -4.03645396e-01f, 9.51602310e-02f, 2.12666646e-01f, 7.61750489e-02f, 2.15361580e-01f,
  -5.01057804e-01f, 3.73585969e-01f, -2.49413121e-02f, 2.14044929e-01f, 8.79779607e-02f, 1.44474087e-02f, 1.49211615e-01f, 8.56133625e-02f, 3.30297828e-01f, -1.33078732e-02f,
  1.84500590e-01f, 2.07061306e-01f, 4.32562232e-02f, 1.76051587e-01f, 7.64099285e-02f, 9.73045453e-02f, -9.99348331e-03f, 1.86245292e-02f, 7.04689249e-02f, -9.03825015e-02f,
  3.66722316e-01f, -6.91360235e-02f, -2.39767015e-01f, 3.14903632e-02f, 2.64833182e-01f, 5.28159365e-02f, -1.14865243e-01f, 1.70509502e-01f, -1.64274648e-01f, 1.33846551e-01f,
  -8.33797231e-02f, 3.81390750e-01f, 1.17138334e-01f, -8.30208883e-03f, -1.06803574e-01f, -1.22214422e-01f, 1.42001389e-02f, 2.19675496e-01f, 4.06972878e-02f, 3.07899415e-01f,
  2.06314310e-01f, 5.05091906e-01f, 1.33571371e-01f, 7.07394555e-02f, -1.19119436e-02f, 1.01090685e-01f, -2.04954594e-01f, -1.31777391e-01f, -3.09332222e-01f, -1.65774241e-01f,
  6.05565459e-02f, 3.75500232e-01f, 8.01736414e-02f, -3.17552567e-01f, -2.03735948e-01f, 2.83090118e-03f, -1.27010167e-01f, -3.59743051e-02f, 7.85929523e-03f, 5.64107224e-02f,
  -1.97558120e-01f, 2.13273153e-01f, -4.93009210e-01f, 1.75639749e-01f, -5.88338785e-02f, -1.81504309e-01f, 2.03205436e-01f, -9.57984403e-02f, 7.93741718e-02f, -2.86066066e-02f,
  -4.50703621e-01f, 1.84331521e-01f, 1.19044572e-01f, 1.77548468e-01f, 1.30394846e-01f, 1.97918087e-01f, 6.55585080e-02f, 1.13643661e-01f, 1.04084820e-01f, -3.11397724e-02f,
  -1.25004739e-01f, -4.10210453e-02f, 3.23871404e-01f, -8.81300569e-02f, 3.35379273e-01f, -5.21313511e-02f, -2.62755662e-01f, 2.80721802e-02f, 1.47435099e-01f, -6.45237789e-02f,
  -1.51402548e-01f, 1.17398530e-01f, -7.91831762e-02f, 2.62240142e-01f, -2.35441238e-01f, 3.61964822e-01f, 2.22014442e-01f, 3.11615229e-01f, -1.98780864e-01f, 2.53419839e-02f,
  9.75943878e-02f, 2.03095123e-01f, -5.58948815e-02f, 3.35428298e-01f, 7.46866614e-02f, 3.15803617e-01f, 1.87256888e-01f, 1.00628749e-01f, 1.37065530e-01f, 1.97478041e-01f,
  -1.20442584e-01f, -2.50998735e-01f, -2.61724621e-01f, -5.28180972e-02f, 2.49782354e-02f, 3.00776422e-01f, 2.15197336e-02f, -4.66468632e-01f, 1.40721321e-01f, 1.31652042e-01f,
  -5.13671339e-02f, 4.40187119e-02f, 2.00039983e-01f, 2.42502198e-01f, -1.75775185e-01f, -5.10968603e-02f, -3.90265942e-01f, 8.13647360e-02f, -5.40483370e-02f, 7.19566718e-02f,
  3.36417764e-01f, -5.17631918e-02f, 5.41349530e-01f, -1.62750036e-01f, -3.93027991e-01f, 1.92423105e-01f, 1.14506893e-02f, 2.47164831e-01f, 1.42235039e-02f, 1.70408577e-01f,
  1.82014674e-01f, -1.31166829e-02f, 3.02526262e-02f, 3.61781716e-01f, -9.07381549e-02f, 1.41791046e-01f, -1.98192537e-01f, 1.77507967e-01f, -1.38556480e-01f, 1.93818003e-01f,
  -1.57791778e-01f, 9.37520191e-02f, -2.20669180e-01f, 1.65063575e-01f, 2.51509666e-01f, -7.31546804e-02f, 1.87164992e-01f, -1.15704171e-01f, 5.08470125e-02f, -4.77251410e-01f,
  1.07988223e-01f, 2.78994113e-01f, 1.57686055e-01f, 1.64718628e-01f, 3.17277521e-01f, 2.97382027e-01f, 2.86686629e-01f, -2.35943764e-01f, -2.29822069e-01f, -1.87222704e-01f,
  1.80745572e-01f, 2.52622962e-01f, -5.35309911e-01f, 2.16798767e-01f, -9.48144421e-02f, 1.16160214e-01f, 5.06905466e-02f, 5.02172448e-02f, 4.06442117e-03f, -1.98739007e-01f,
  1.58948630e-01f, -4.15866226e-02f, -6.44423366e-02f, -6.72232434e-02f, 2.04565972e-01f, -2.63112694e-01f, 1.91433147e-01f, 3.18865865e-01f, 4.70649041e-02f, 4.49376479e-02f,
  -2.12046012e-01f, 4.91665632e-01f, 1.72936067e-01f, -2.68814147e-01f, -2.96150297e-01f, 1.89449683e-01f, 9.30085629e-02f, 2.42923230e-01f, 5.50814986e-01f, 7.71345710e-03f,
  -6.38043433e-02f, 9.62211564e-02f, 7.97537714e-02f, 2.08185345e-01f, -9.14864317e-02f, 6.41160607e-02f, 6.03319891e-02f, 5.51822186e-02f, -1.56537816e-02f, -4.70655374e-02f,
  -8.95702690e-02f, 1.86859593e-02f, 2.74698347e-01f, 4.90461895e-03f, 1.90541148e-01f, 1.08820405e-02f, 1.20589055e-01f, -1.03004523e-01f, -1.49202913e-01f, -1.23459078e-01f,
  -2.99173892e-01f, 1.94453120e-01f, -2.21021712e-01f, 2.18582883e-01f, 2.46036440e-01f, 1.90298915e-01f, -1.74889006e-02f, 4.17200960e-02f, 9.79820192e-02f, 1.49921887e-02f,
  -9.45119932e-02f, 1.18677951e-01f, 3.11965737e-02f, 2.66899288e-01f, 1.37851492e-01f, 9.28724278e-03f, 2.06266671e-01f, 3.96969169e-01f, -1.80306919e-02f, -1.63849354e-01f,
  1.31030172e-01f, -1.04306906e-01f, -8.73021111e-02f, 3.07311833e-01f, 4.71634679e-02f, -2.52739161e-01f, 1.38748094e-01f, -2.89197177e-01f, 2.15044841e-01f, 4.09869194e-01f,
  3.26112866e-01f, -1.17200665e-01f, -1.33807525e-01f, 3.94816846e-02f, -2.81466633e-01f, 1.06784537e-01f, 5.32943368e-01f, -8.04418772e-02f, 5.28514683e-02f, -1.75826609e-01f,
  3.06468844e-01f, 6.50043180e-03f, -3.34609240e-01f, 1.63277104e-01f, 2.78317165e-02f, 3.07930950e-02f, 3.07709537e-02f, -3.33875567e-02f, 9.10390317e-02f, -1.06977865e-01f,
  1.65237218e-01f, 3.16944271e-02f, 3.77897844e-02f, 1.78032637e-01f, 1.89551279e-01f, -2.34539490e-02f, 8.69948789e-02f, -1.34826317e-01f, -1.85307115e-01f, 2.42784202e-01f,
  2.74994448e-02f, 7.62099922e-02f, -2.60589749e-01f, 1.59151405e-01f, -3.26514989e-01f, -3.84797722e-01f, -2.47529164e-01f, -9.83768515e-03f, -1.74606413e-01f, 2.10805401e-01f,
  -6.61691204e-02f, 4.88458313e-02f, -3.85956466e-01f, -2.39815786e-01f, -8.46978948e-02f, 2.58482527e-03f, 1.67265516e-02f, 1.87363178e-01f, 6.95493817e-02f, 1.48580402e-01f,
  -2.55298525e-01f, 4.45812708e-03f, 3.64548415e-02f, 1.41827732e-01f, 1.28587894e-02f, 1.99391901e-01f, 2.50724226e-01f, 1.96059406e-01f, 2.20432058e-01f, -1.43984914e-01f,
  -1.18132256e-01f, 2.24503919e-01f, 8.75762627e-02f, -3.36220890e-01f, 9.52157155e-02f, 3.58412653e-01f, -5.88217936e-02f, -3.34446967e-01f, -1.15924612e-01f, -2.89550036e-01f,
  -1.59171805e-01f, 3.36837023e-01f, 6.60649166e-02f, -1.85923174e-01f, 3.42560410e-01f, -2.85412036e-02f, 5.59081249e-02f, -4.71577823e-01f, -1.48166731e-01f, 3.44506145e-01f,
  2.26236135e-01f, 2.08917618e-01f, 2.09045466e-02f, 2.10766569e-01f, 3.17960888e-01f, 6.23738617e-02f, -7.31682405e-03f, 4.11087722e-02f, -2.44021099e-02f, -1.71406791e-01f,
  3.30115974e-01f, 6.12390786e-02f, 2.02173755e-01f, -7.25663602e-02f, 2.09374726e-01f, 3.17523628e-02f, -3.67947787e-01f, 1.78287178e-01f, -2.32334390e-01f, -4.62471209e-02f,
  9.53144804e-02f, 1.91357002e-01f, 1.92884982e-01f, 2.40313441e-01f, 1.28857419e-01f, -1.97942764e-01f, -8.86216834e-02f, -2.09584326e-01f, -5.00401929e-02f, 1.40060142e-01f,
  -8.66891891e-02f, 2.12848693e-01f, 8.70056823e-02f, -9.74025801e-02f, 1.56551450e-01f, 3.15392256e-01f, -5.90009429e-02f, -5.51281571e-02f, -1.48309454e-01f, -8.42575505e-02f,
  -7.14837834e-02f, -2.61102710e-02f, -7.70525858e-02f, 1.32047504e-01f, 5.26186712e-02f, -7.55068138e-02f, -8.72829184e-02f, 4.88730788e-01f, -1.14394292e-01f, 3.19397263e-02f,
  -2.10253745e-01f, 4.78687622e-02f, 2.52663374e-01f, -1.36930436e-01f, 2.54545689e-01f, 3.03121030e-01f, 2.72203296e-01f, -5.72241731e-02f, 1.95849046e-01f, -1.11899711e-01f,
  -7.40817785e-02f, -1.11985147e-01f, 3.19582790e-01f, 1.47588374e-02f, 1.94903582e-01f, 2.46116966e-01f, 1.74750865e-01f, 2.19823718e-01f, 2.62153983e-01f, -4.46462724e-03f,
  -1.65894166e-01f, -2.89708679e-03f, 1.84138104e-01f, 2.19578475e-01f, -1.32716402e-01f, -6.43817261e-02f, 9.88944918e-02f, -1.84620127e-01f, -4.86268140e-02f, -1.92957476e-01f,
  1.14480287e-01f, 2.66226809e-02f, -1.96349069e-01f, 2.22013026e-01f, 3.41414884e-02f, 5.32943726e-01f, 2.70968109e-01f, -2.17120662e-01f, 1.88141093e-02f, -8.10316112e-03f,
  1.43388003e-01f, 3.16207767e-01f, -2.18317360e-01f, 1.64996162e-01f, 4.78511155e-02f, 3.99894953e-01f, -5.07092357e-01f, 3.13849896e-01f, 1.52614102e-01f, 1.41320959e-01f,
  2.60138005e-01f, -3.03887516e-01f, -2.53013205e-02f, 1.42725483e-01f, -6.04993999e-02f, 4.79042709e-01f, 9.63376015e-02f, -2.79828757e-01f, -2.04339921e-01f, -1.92358568e-01f,
  -3.43697459e-01f, 3.48067492e-01f, 9.32386070e-02f, 7.09320009e-02f, -8.22488144e-02f, 2.88245648e-01f, -2.60664582e-01f, 2.89000273e-01f, 4.03976768e-01f, 1.11287355e-01f,
  2.08666921e-01f, -1.08366869e-01f, 3.20292264e-01f, -2.93086469e-01f, -3.64852309e-01f, 2.18285263e-01f, -2.90197618e-02f, -4.48050050e-05f, 4.29826528e-02f, -1.13068163e-01f,
  -6.96070865e-03f, 7.08405301e-02f, 8.69321153e-02f, 2.31557135e-02f, -1.02840029e-01f, 2.20938735e-02f, 1.25555634e-01f, 1.17874285e-02f, 5.09628728e-02f, -1.13506950e-01f,
  -3.69686544e-01f, 2.93252096e-02f, -6.30029663e-02f, 1.22822881e-01f, -2.84393188e-02f, 6.15417212e-02f, 1.44010149e-02f, -1.35708153e-01f, -2.61499938e-02f, 1.92992061e-01f,
  -1.03374317e-01f, -6.83060437e-02f, -9.43460315e-03f, 7.29878992e-02f, -1.53123289e-02f, 1.07352115e-01f, 1.08511016e-01f, -1.84214383e-01f, 1.60294548e-01f, 1.78761870e-01f,
  7.33279809e-02f, 2.61601042e-02f, -1.69996992e-01f, -7.35054538e-02f, 1.12090856e-01f, -9.41995457e-02f, 9.49350744e-02f, 4.44292799e-02f, 2.42194980e-01f, 1.84229717e-01f,
  2.35299811e-01f, -1.12520412e-01f, -9.88428593e-02f, 2.10991189e-01f, 4.99541163e-02f, -1.98990390e-01f, -9.60754529e-02f, 1.68524534e-01f, 1.12748265e-01f, 4.48327027e-02f,
  -6.53252900e-02f, 2.25895882e-01f, -2.09212169e-01f, 2.78276615e-02f, 2.36624197e-04f, 1.02400392e-01f, 2.56019086e-01f, -2.11777762e-02f, 1.41785353e-01f, -2.62050152e-01f,
  -8.49803314e-02f, 2.02319622e-01f, 1.01423599e-01f, 2.00611595e-02f, 5.41563444e-02f, 1.78465694e-01f, 1.15451448e-01f, 3.37734893e-02f, -1.15463436e-02f, -1.25631228e-01f,
  1.54665500e-01f, 3.03374361e-02f, -3.31958562e-01f, -4.69653159e-01f, -1.59255087e-01f, -2.52630748e-03f, 1.58263147e-01f, 4.57138419e-02f, -1.09389372e-01f, 1.63577557e-01f,
  2.94394821e-01f, -1.77796274e-01f, 1.34223968e-01f, 2.54217267e-01f, -1.56089291e-01f, 1.14602536e-01f, 1.13965049e-01f, -4.11989912e-02f, -1.21602617e-01f, -1.65139228e-01f,
  -4.46330309e-02f, 1.91259265e-01f, 7.46652186e-02f, 1.51669785e-01f, 1.23976497e-02f, -1.22741558e-01f, 4.20028776e-01f, 4.56603244e-02f, 2.04647542e-03f, -3.52637060e-02f,
  -3.17009896e-01f, 1.38145685e-01f, 1.70924678e-01f, 3.19862932e-01f, 6.16604872e-02f, 1.71275303e-01f, -2.30407745e-01f, -1.67954117e-01f, -5.00235036e-02f, 1.03747100e-02f,
  2.00377584e-01f, -3.16990763e-01f, 8.68264362e-02f, -9.64552537e-03f, 4.05518502e-01f, -1.40542671e-01f, -6.46361053e-01f, 5.59235215e-01f, -1.26028404e-01f, 3.01009446e-01f,
  -1.35133937e-01f, -1.96915507e-01f, 1.13054894e-01f, 1.27089530e-01f, 8.18095356e-02f, -6.80195093e-02f, 2.03632206e-01f, 8.82694945e-02f, 6.38137162e-02f, -4.97923903e-02f,
  8.05612579e-02f, -6.04272308e-03f, -1.58960193e-01f, -1.51512742e-01f, 7.50342906e-02f, 1.62519023e-01f, 2.61603862e-01f, -1.19625680e-01f, -2.39161819e-01f, -9.51043367e-02f,
  -2.55656272e-01f, -2.05787700e-02f, 8.21407661e-02f, -8.21358860e-02f, 9.02150795e-02f, 3.61812472e-01f, -3.88310738e-02f, 2.14715123e-01f, 2.68258601e-01f, 1.73622012e-01f,
  -1.30608663e-01f, 3.78882140e-02f, 6.07751384e-02f, 6.92422241e-02f, -5.11511788e-02f, 4.08309758e-01f, -3.68608236e-02f, -3.38040888e-01f, 5.68292588e-02f, -1.19581684e-01f,
  4.68979806e-01f, 7.03310072e-02f, 8.22779536e-02f, -3.31794620e-01f, 8.54305550e-02f, -5.18928207e-02f, -3.60071003e-01f, 7.43207661e-03f, 1.51954787e-02f, -3.00950557e-01f,
  3.08993250e-01f, 1.88186821e-02f, 1.38052553e-01f, 3.72273356e-01f, 2.66937196e-01f, -1.78543478e-01f, -1.81552559e-01f, 2.15077579e-01f, 2.79371709e-01f, -3.31609696e-02f,
  -8.06424692e-02f, -2.78938174e-01f, 4.69484895e-01f, 1.44611761e-01f, -3.93492617e-02f, 7.57957622e-02f, -5.16510725e-01f, 3.44722092e-01f, -8.77469555e-02f, 2.30122320e-02f,
  7.78495893e-02f, 1.64269239e-01f, 1.95721313e-01f, 1.99770004e-01f, 1.64976269e-01f, 2.96339998e-03f, 2.01570302e-01f, -2.79909790e-01f, 2.52386540e-01f, 2.03965139e-02f,
  -3.06862742e-01f, -2.18263254e-01f, -1.44000858e-01f, -1.29161656e-01f, 2.30661124e-01f, 2.48946786e-01f, 1.01905264e-01f, 3.10397465e-02f, 3.59177560e-01f, -1.19423769e-01f,
  2.04442084e-01f, 2.57771879e-01f, 8.58101808e-03f, -2.90003389e-01f, 2.14236259e-01f, 2.94261239e-02f, 3.44274193e-02f, 4.23528627e-02f, 5.83726019e-02f, -3.15197036e-02f,
  -1.37390524e-01f, 2.67795831e-01f, 1.97205812e-01f, -4.74086292e-02f, -1.12178937e-01f, -1.18357077e-01f, -7.08943307e-02f, -1.95070878e-01f, 1.76632032e-01f, -2.32992787e-02f,
  1.23511709e-01f, 2.41935495e-02f, 2.72889316e-01f, 1.33369148e-01f, -2.96049058e-01f, 4.91568036e-02f, -6.30900934e-02f, -1.72464922e-01f, -1.09494194e-01f, -4.68594640e-01f,
  -8.16949159e-02f, 4.64165099e-02f, -1.18272431e-01f, 1.94150925e-01f, -4.41111773e-01f, 2.56211042e-01f, -3.12690914e-01f, 2.69968003e-01f, -5.30120824e-03f, 4.73611243e-02f,
  3.89491469e-01f, 4.02713642e-02f, 1.19738713e-01f, -7.34117767e-03f, 6.93483278e-02f, -8.82846117e-02f, 4.46832478e-02f, 1.96899906e-01f, 7.19723180e-02f, 7.10860118e-02f,
  -1.27864435e-01f, 1.39112249e-01f, 2.79020537e-02f, 9.14590955e-02f, 2.64619619e-01f, -5.86715750e-02f, 1.12654760e-01f, -4.22951616e-02f, 1.09865703e-01f, -2.26501867e-01f,
  -2.11047754e-01f, -2.50007451e-01f, -1.87372342e-01f, 7.94800147e-02f, 9.51638222e-02f, 2.08275482e-01f, 2.56202489e-01f, 2.84233719e-01f, 4.02576774e-02f, -1.19525149e-01f,
  -1.55160114e-01f, 1.13085032e-01f, 1.16039708e-01f, 3.91625986e-02f, -1.08782098e-01f, -1.26787543e-01f, 7.20870271e-02f, 1.65870026e-01f, -1.08497672e-01f, 2.16138899e-01f,
  -1.27118705e-02f, -1.14688940e-01f, -2.85412937e-01f, -4.34040278e-02f, 1.25059098e-01f, 5.21471314e-02f, 1.54505804e-01f, -1.88054070e-01f, 1.27655685e-01f, -1.60972327e-01f,
  1.80310652e-01f, 4.55558032e-01f, -9.93766412e-02f, 3.50791484e-01f, -2.73377776e-01f, 2.92302936e-01f, -3.17208618e-02f, -3.74087803e-02f, 4.05348182e-01f, -1.22902291e-02f,
  5.17994985e-02f, -1.92218907e-02f, 3.69598776e-01f, -1.19241573e-01f, -1.75833821e-01f, -1.11297004e-01f, -1.27380461e-01f, 1.06577970e-01f, 1.58118643e-02f, -9.94532090e-03f,
  2.79336460e-02f, 3.15858200e-02f, 1.85413167e-01f, -2.68932357e-02f, -2.49680817e-01f, -5.62224761e-02f, 2.54028618e-01f, 9.96527821e-03f, -2.16652855e-01f, -2.09674284e-01f,
  -2.83560395e-01f, 1.22712478e-01f, -1.36572793e-01f, -1.40887409e-01f, 2.34466031e-01f, 3.60299572e-02f, 1.80543158e-02f, 4.56437580e-02f, -1.15541697e-01f, 3.58084023e-01f,
  2.88746841e-02f, -3.44273308e-03f, -5.81602752e-02f, -2.50261337e-01f, 1.56047374e-01f, 5.06100841e-02f, -1.69637367e-01f, 1.97569937e-01f, 1.18062168e-01f, 4.96146590e-01f,
  -2.95497775e-02f, -5.08673638e-02f, 1.09784484e-01f, -7.84921497e-02f, -1.28719375e-01f, 1.06106009e-02f, 2.50081415e-03f, -2.67131981e-02f, 1.44163176e-01f, 2.96127796e-01f,
  6.48744404e-02f, -1.59022555e-01f, -1.71430320e-01f, -6.45869086e-03f, 1.52201638e-01f, -2.12820366e-01f, 1.67050138e-01f, -1.60115927e-01f, -3.24240297e-01f, 1.52940944e-01f,
  -2.99714953e-01f, 3.34566325e-01f, 8.27815980e-02f, 2.34259576e-01f, -3.00057083e-01f, -1.93423122e-01f, 6.43976927e-02f, 3.32029723e-02f, -4.10993904e-01f, 4.30617422e-01f,
  -2.03319103e-01f, 1.06000878e-01f, 5.00949919e-02f, 1.39850765e-01f, 6.07337616e-02f, 2.00540572e-01f, 8.00686851e-02f, 2.62865394e-01f, -4.07977216e-02f, 6.53639734e-02f,
  -4.01953645e-02f, 1.14113510e-01f, -8.62705559e-02f, 1.74761340e-01f, 1.36374384e-01f, -1.05488911e-01f, -1.55114057e-02f, -5.79860322e-02f, 2.19191119e-01f, -2.55660731e-02f,
  1.16470426e-01f, 1.41797468e-01f, 2.34657228e-02f, 2.41986245e-01f, 2.81630486e-01f, -1.71338588e-01f, 2.21672878e-01f, 8.76167193e-02f, 2.54291803e-01f, 2.45094329e-01f,
  9.42117274e-02f, -5.16739637e-02f, 8.18583369e-02f, -2.29572803e-01f, -1.48560554e-01f, -3.35048251e-02f, -1.95982587e-02f, 6.87847510e-02f, 1.31897166e-01f, 4.48554680e-02f,
  1.02557642e-02f, -3.98608632e-02f, -1.41353458e-02f, 2.47216299e-01f, 3.70435119e-02f, 1.07444093e-01f, 4.39216271e-02f, -5.40370494e-02f, 3.18440795e-02f, 3.18521917e-01f,
  9.79232416e-02f, 1.35067359e-01f, 2.89781056e-02f, 3.38304549e-01f, -1.25950933e-01f, 1.64427623e-01f, 4.57182884e-01f, -2.29838654e-01f, -1.31282043e-02f, -3.36166061e-02f,
  4.32147235e-02f, 7.51224533e-02f, 3.87625635e-01f, 1.20581858e-01f, -2.05582660e-02f, -1.40247047e-01f, 3.64653796e-01f, 7.13903755e-02f, 1.52797610e-01f, 3.14071894e-01f,
  3.56715679e-01f, 3.37018937e-01f, 3.04161832e-02f, -9.10374969e-02f, -1.76785737e-01f, -1.54260527e-02f, 3.39963399e-02f, -3.32222208e-02f, 3.90502155e-01f, 5.19809574e-02f,
  3.45784098e-01f, 2.21859291e-01f, 8.62245820e-03f, -4.43375260e-01f, -1.15777729e-02f, -3.70796978e-01f, 2.52209991e-01f, 5.14225699e-02f, 2.80542858e-02f, 2.21179768e-01f,
  2.70917267e-01f, 1.35522503e-02f, -1.97938755e-01f, -3.99569303e-01f, 1.74805909e-01f, -3.22842836e-01f, -7.18416739e-03f, -2.42728069e-01f, -2.99817771e-02f, -9.60584581e-02f,
  -4.76016514e-02f, 1.74772307e-01f, -9.31831747e-02f, 2.22200125e-01f, -6.64162040e-02f, 6.24645427e-02f, 2.51896441e-01f, -2.17578903e-01f, 1.52570814e-01f, 1.10320754e-01f,
  2.04006918e-02f, 5.17351180e-02f, 2.46910021e-01f, 1.22513980e-01f, 4.54906262e-02f, 2.12756932e-01f, 1.13518879e-01f, -1.31481484e-01f, 4.20839697e-01f, -3.17326903e-01f,
  1.41620964e-01f, 3.59688282e-01f, -2.59576678e-01f, 3.93402809e-03f, 1.71892494e-01f, -1.79521829e-01f, 2.88506448e-01f, -2.90048867e-01f, 5.46509996e-02f, 1.88505109e-02f,
  2.06223130e-01f, 2.39663944e-01f, 8.38775188e-02f, 3.57693918e-02f, -2.48249649e-04f, 2.19058275e-01f, -8.74617472e-02f, 2.41457015e-01f, 5.21341860e-02f, -2.08378419e-01f,
  1.22677259e-01f, 4.01528388e-01f, 2.51678407e-01f, -3.89186554e-02f, 1.50653601e-01f, 8.92305002e-02f, -3.43816072e-01f, 3.37520652e-02f, -3.13794672e-01f, -1.19815260e-01f,
  -2.69042253e-01f, -2.19978631e-01f, -1.26411393e-01f, 2.85455018e-01f, -1.11456867e-02f, -8.71946439e-02f, -3.82196188e-01f, -8.80749375e-02f, 3.64502706e-02f, 2.60558248e-01f,
  -2.69828647e-01f, 1.71357214e-01f, 2.80289799e-01f, 2.01532006e-01f, -4.14522588e-01f, -2.57851701e-04f, -2.43161380e-01f, 3.40452284e-01f, 1.39169067e-01f, 6.20836578e-03f,
  -1.98374331e-01f, -2.18851253e-01f, 1.37021407e-01f, -1.48642614e-01f, 5.97294867e-02f, 1.07601635e-01f, 5.26755601e-02f, -2.26706758e-01f, 1.23265356e-01f, 4.61127907e-01f,
  -8.07376280e-02f, -9.46697369e-02f, -1.78098362e-02f, -4.52698737e-01f, 8.66876543e-02f, 6.52618781e-02f, 1.71990246e-01f, -1.95249081e-01f, 1.06236495e-01f, -3.31594311e-02f,
  -2.05783457e-01f, -1.93884462e-01f, 1.96410313e-01f, 3.02766800e-01f, 6.15210608e-02f, 2.78271228e-01f, -2.18622927e-02f, 2.48730779e-01f, 1.22830875e-01f, 2.50441432e-01f,
  -2.57839682e-03f, -5.13111241e-02f, 5.54117709e-02f, 1.98107511e-01f, 1.15407810e-01f, -9.65279862e-02f, -1.26423419e-01f, -2.88458735e-01f, 2.76222616e-01f, 4.11044657e-02f,
  -4.42468494e-01f, -8.14749822e-02f, 4.40409519e-02f, 9.18176472e-02f, 4.61872742e-02f, 3.05887848e-01f, 3.77959609e-02f, 4.15619880e-01f, -1.49457380e-01f, -2.68677548e-02f,
  -1.80429801e-01f, -2.65153319e-01f, 4.22488227e-02f, 1.73552915e-01f, -9.92178842e-02f, 1.27658516e-01f, 1.53038755e-01f, -1.51978642e-01f, 1.72287319e-02f, 2.31084213e-01f,
  1.98334008e-01f, -6.73772395e-02f, -4.47479457e-01f, -1.22753046e-01f, 6.38340116e-02f, 1.20040320e-01f, 1.87879622e-01f, 1.25870109e-01f, -2.18947865e-02f, -1.69049323e-01f,
  -5.23684248e-02f, 3.63711298e-01f, 2.15749964e-01f, 2.27968022e-01f, -7.16731846e-02f, -1.17204346e-01f, 2.83698976e-01f, -4.35371744e-03f, -1.98369548e-01f, 5.18182814e-01f,
  4.27957177e-01f, 7.98567161e-02f, 4.38168406e-01f, -1.59598276e-01f, -8.57244059e-02f, -4.01813574e-02f, 2.58769810e-01f, 1.50335386e-01f, -4.91152741e-02f, 1.78639606e-01f,
  -2.80405413e-02f, -1.26308128e-01f, 8.38453844e-02f, -1.79232731e-02f, -1.51962623e-01f, 4.53984551e-03f, 2.33666122e-01f, -9.79143288e-03f, -2.19326049e-01f, -8.55547339e-02f,
  -8.92952457e-02f, 1.19406469e-01f, -1.37670681e-01f, 1.11770943e-01f, -1.40387207e-01f, 3.88134032e-01f, 1.35716889e-02f, -1.59413859e-01f, -3.00846249e-01f, 2.60271400e-01f,
  -1.37932628e-01f, -1.26588494e-01f, -1.76566124e-01f, -1.36586994e-01f, -3.25189829e-01f, -1.34784997e-01f, -5.64455017e-02f, 3.76254201e-01f, 1.13797940e-01f, 1.78221434e-01f,
  -2.32616463e-03f, 2.27841780e-01f, 7.40478635e-02f, -4.24286202e-02f, 9.18177217e-02f, -1.79368973e-01f, 1.76607996e-01f, 2.21337497e-01f, 2.29490981e-01f, 1.49120480e-01f,
  1.40545398e-01f, -1.18178494e-01f, -2.27624867e-02f, 7.04496130e-02f, 9.34489816e-02f, -1.15348272e-01f, -1.27412811e-01f, -1.43982440e-01f, -2.47316509e-01f, -1.87588379e-01f,
  -1.69023890e-02f, -3.55061918e-01f, 1.55961275e-01f, 4.17133495e-02f, 3.19102686e-03f, -2.87343413e-01f, -2.82161105e-02f, 7.78419450e-02f, 5.64509742e-02f, -2.79086739e-01f,
  -3.17617022e-02f, 1.25661939e-01f, 8.78052264e-02f, 1.80862337e-01f, 6.61442578e-02f, 8.58139694e-02f, -1.68461222e-02f, 9.31969136e-02f, 2.34915063e-01f, 1.89025655e-01f,
  -4.55983467e-02f, -1.29802212e-01f, -2.74022788e-01f, 1.31861806e-01f, 2.96843827e-01f, 1.01801157e-01f, 1.84459269e-01f, 1.26823813e-01f, 3.29523325e-01f, 4.77805808e-02f,
  5.26405498e-02f, 1.68098751e-02f, 1.36174023e-01f, -4.71968204e-01f, 3.07295173e-01f, -3.61716062e-01f, 6.92790374e-02f, 1.37665942e-01f, 3.16507131e-01f, 2.07760155e-01f,
  9.77824107e-02f, -5.50494730e-01f, 1.06207043e-01f, -1.08530469e-01f, -1.15782596e-01f, 2.40508631e-01f, -2.91654080e-01f, 1.22815810e-01f, -1.01130925e-01f, 2.20234528e-01f,
  1.49726793e-01f, 1.17343076e-01f, -1.94420069e-01f, -9.42324102e-02f, 1.50328740e-01f, 2.29186803e-01f, -1.82008110e-02f, -1.71547234e-02f, 8.43271986e-03f, 2.18527213e-01f,
  -3.22464854e-03f, -8.95850509e-02f, 3.70082967e-02f, 1.46458343e-01f, -3.03004444e-01f, 3.85618269e-01f, 4.23058659e-01f, -3.67884368e-01f, -5.06661534e-01f, -1.91441476e-01f,
  -2.73991555e-01f, 2.58771747e-01f, 4.98037308e-01f, 9.68269110e-02f, 1.81033947e-02f, -2.41697103e-01f, 1.29245043e-01f, -1.32375844e-02f, -1.37563655e-03f, 1.90552939e-02f,
  -8.69155079e-02f, 9.85950530e-02f, -8.23626667e-02f, -2.21543998e-01f, -9.09811854e-02f, 1.49520904e-01f, -1.73429564e-01f, -2.20193148e-01f, -1.53993234e-01f, -1.50959706e-02f,
  -1.23907767e-01f, 2.98489153e-01f, 1.15598343e-01f, -9.00170952e-02f, 2.95713127e-01f, 1.35656863e-01f, 3.63721818e-01f, -8.45167935e-02f, 1.50301799e-01f, 5.60565926e-02f,
  1.58990279e-01f, 6.40508905e-02f, -4.56296373e-03f, -8.13627616e-02f, 1.83751985e-01f, 8.69740248e-02f, 5.03626578e-02f, -5.97559869e-01f, 1.39971823e-01f, -6.09171912e-02f,
  3.71622711e-01f, -7.34489113e-02f, 2.56795883e-01f, 2.56204605e-01f, -7.21510649e-02f, 3.92233506e-02f, 1.77781269e-01f, -3.12639326e-01f, 3.00978482e-01f, 1.71083719e-01f,
  3.01944334e-02f, 4.00850736e-02f, 2.76203919e-02f, 1.38015181e-01f, 4.55582216e-02f, -4.40008529e-02f, 1.80410907e-01f, 1.09927163e-01f, 4.83299941e-01f, 2.39057392e-02f,
  -3.85082483e-01f, 9.05321687e-02f, 2.33783737e-01f, 3.48962218e-01f, -2.49842972e-01f, -6.49765879e-02f, 4.40973461e-01f, 2.16033205e-01f, 1.30340621e-01f, -3.07202131e-01f,
  1.41728416e-01f, 6.32191747e-02f, -3.42886783e-02f, 1.50900176e-02f, 9.23597720e-03f, -5.60947636e-04f, -2.36710414e-01f, 4.31621484e-02f, -1.68510914e-01f, 1.07598901e-01f,
  -7.91195929e-02f, -4.68853116e-02f, -1.36963710e-01f, 2.56363094e-01f, -4.30262625e-01f, -8.36526901e-02f, 3.54195982e-01f, 1.73626438e-01f, 4.77852412e-02f, 2.43921071e-01f,
  9.50045064e-02f, -2.23725066e-02f, 2.39046946e-01f, 2.55023211e-01f, -3.72894078e-01f, -1.98520303e-01f, 1.03286713e-01f, 1.87126517e-01f, 8.18977952e-02f, 3.34566981e-01f,
  -9.55506414e-02f, -5.60174063e-02f, -4.44496758e-02f, -1.58368219e-02f, 4.43728507e-01f, 2.12358549e-01f, -1.24695949e-01f, -4.91158217e-01f, -8.95171165e-02f, 2.19515577e-01f,
  1.07560717e-01f, 1.40183628e-01f, -1.41138047e-01f, -3.58162016e-01f, 2.27505416e-01f, -2.73712248e-01f, 2.33990490e-01f, 1.27609134e-01f, 4.41346914e-01f, -1.42182499e-01f,
  -1.39038369e-01f, 1.49479471e-02f, 2.12314710e-01f, 2.74195433e-01f, 3.43263239e-01f, -1.71007454e-01f, 1.00620322e-01f, 7.00979903e-02f, 5.64325303e-02f, 8.02710503e-02f,
  -4.69689757e-01f, 4.25162643e-01f, -1.69171751e-01f, 7.38420635e-02f, 2.35004611e-02f, 1.79597422e-01f, 5.46257123e-02f, 7.52783045e-02f, 1.42249048e-01f, 2.00673491e-01f,
  -1.13870136e-01f, -1.91359490e-01f, -1.29327103e-01f, 3.21372628e-01f, 2.45255022e-03f, -1.43115044e-01f, -1.08632287e-02f, -1.21430025e-01f, -1.14869729e-01f, 4.80373427e-02f,
  -2.72977054e-01f, 6.30530268e-02f, -6.22712169e-03f, 2.22434610e-01f, 4.92120832e-02f, 8.48307312e-02f, 3.85225075e-03f, 5.60210012e-02f, -2.68805842e-03f, 1.08254366e-02f,
  -1.44247696e-01f, -4.65016030e-02f, 1.73244774e-01f, 2.70492196e-01f, -6.93623349e-02f, -2.64441550e-01f, 1.94766447e-01f, -2.08866999e-01f, 3.36437643e-01f, 3.11049938e-01f,
  5.22969402e-02f, -1.31984726e-01f, -2.61198789e-01f, -1.30038157e-01f, -1.87755719e-01f, -2.43665557e-02f, 6.75804392e-02f, -4.40483280e-02f, 2.68234462e-01f, -2.85653025e-01f,
  2.05328599e-01f, 3.84712189e-01f, 2.80840755e-01f, -2.11925730e-01f, -1.86962292e-01f, -8.34424421e-02f, 7.16563582e-01f, -7.13815019e-02f, -2.37135872e-01f, 3.27841163e-01f,
  2.85118937e-01f, 2.34519541e-01f, 5.85190803e-02f, -1.02335617e-01f, -1.59816712e-01f, 1.69262871e-01f, 1.24991886e-01f, -1.06441356e-01f, 1.38758034e-01f, 3.12128395e-01f,
  -2.31395708e-03f, 1.37539536e-01f, 3.27027947e-01f, 2.66388476e-01f, -1.20185256e-01f, -2.29032338e-03f, -3.24571282e-01f, 1.21965617e-01f, 1.75446019e-01f, -2.47054826e-02f,
  -2.76348680e-01f, -6.80062547e-03f, -2.23064303e-01f, 1.13359265e-01f, -1.52456790e-01f, -1.23729661e-01f, -1.40876785e-01f, 6.58616945e-02f, -3.93329322e-01f, -4.27429348e-01f,
  -4.34249118e-02f, 3.06077182e-01f, -3.42297524e-01f, 2.21390575e-01f, -8.98662284e-02f, 3.69860721e-03f, 3.16827953e-01f, 1.32468060e-01f, -1.34066567e-01f, -6.98551089e-02f,
  6.67603761e-02f, 1.45606875e-01f, 1.44373745e-01f, 2.60812670e-01f, -1.58530965e-01f, -1.40517503e-01f, -1.62368178e-01f, -4.48786989e-02f, -1.33735528e-02f, 2.18847990e-01f,
  2.55481482e-01f, 5.39950021e-02f, 1.84386611e-01f, 1.65020805e-02f, 2.88905591e-01f, 3.99997160e-02f, 4.90808457e-01f, 1.19308859e-01f, -6.04133047e-02f, -4.79302518e-02f,
  -9.08969939e-02f, 4.50409465e-02f, 8.68037045e-02f, 2.36848891e-02f, -2.37303838e-01f, -2.50861228e-01f, 1.45553350e-01f, -2.59549897e-02f, 5.54596726e-03f, 3.58484000e-01f,
  -9.40665826e-02f, 1.05630212e-01f, 1.91843599e-01f, -1.93739682e-02f, 1.60207808e-01f, -9.30042279e-06f, 2.02025548e-01f, 1.79973207e-02f, -5.33597320e-02f, -1.53821092e-02f,
  1.16727324e-02f, -9.50255245e-02f, -7.65703022e-02f, -7.13273324e-03f, 2.36567542e-01f, 1.72438726e-01f, 2.03743860e-01f, -2.44500220e-01f, -7.29976445e-02f, 1.42812848e-01f,
  -2.30432689e-01f, 9.37977508e-02f, 6.42687306e-02f, -2.95436871e-03f, 1.31333202e-01f, -7.23911100e-04f, 2.55643666e-01f, -1.15420386e-01f, -6.69155568e-02f, -4.41050082e-02f,
  -1.75215572e-01f, -1.83032379e-02f, 1.35520577e-01f, 5.62541820e-02f, -1.47172198e-01f, 1.59735028e-02f, 1.41035929e-01f, 1.40379995e-01f, -1.38735831e-01f, -1.33319467e-01f,
  -4.40656208e-02f, 8.08574632e-02f, 1.33334681e-01f, 3.06069911e-01f, -7.42715895e-02f, 2.30010286e-01f, -6.30554035e-02f, -1.10877216e-01f, 2.47993283e-02f, 3.21309268e-01f,
  2.41315905e-02f, -1.50713727e-01f, -1.91669837e-01f, 2.11082604e-02f, 2.12062951e-02f, -1.94549501e-01f, 4.18304980e-01f, 3.04946825e-02f, 7.91793223e-03f, -2.13544905e-01f,
  7.19516650e-02f, -1.38124615e-01f, -6.61254898e-02f, -1.13091968e-01f, -1.27729788e-01f, 5.12040332e-02f, -3.87679748e-02f, 1.22305125e-01f, 1.46027967e-01f, 5.23445830e-02f,
  2.71295905e-01f, -2.23047093e-01f, 1.05481863e-01f, 1.95338622e-01f, 3.52277607e-01f, -1.36748657e-01f, -2.10524082e-01f, 3.25023234e-02f, 4.63813096e-01f, -5.45913540e-02f,
  -2.42350399e-02f, -3.35065499e-02f, 1.99974533e-02f, 1.15704931e-01f, 1.48956001e-01f, -1.25506386e-01f, 2.13137329e-01f, 3.75055254e-01f, -1.94134489e-01f, -3.43583584e-01f,
  1.47801116e-01f, -1.00365564e-01f, 1.34957908e-02f, -1.68612152e-01f, -2.16937676e-01f, 2.62308031e-01f, 5.48628680e-02f, 5.44914663e-01f, -2.76171751e-02f, 1.14416685e-02f,
  4.51246589e-01f, -4.62977365e-02f, -9.75504220e-02f, 1.91180378e-01f, 1.60650477e-01f, 1.04589775e-01f, -4.49545197e-02f, 4.16571707e-01f, -6.41906708e-02f, 1.79264426e-01f,
  -6.97323233e-02f, -2.04046905e-01f, -1.11071341e-01f, -1.94433197e-01f, 5.84120303e-02f, -2.49624178e-01f, -6.42229170e-02f, 3.07410327e-03f, 3.83758485e-01f, -8.08711052e-02f,
  -4.92502749e-01f, 3.39774072e-01f, -3.72328550e-01f, 2.07029939e-01f, -1.18419059e-01f, -1.38113320e-01f, -2.55532205e-01f, 6.03987835e-02f, 2.36509413e-01f, 1.74843833e-01f,
  -1.76580455e-02f, -1.33863930e-02f, 1.36554569e-01f, -1.73613429e-01f, -1.21670865e-01f, -1.48000374e-01f, 7.97704514e-03f, -1.73740193e-01f, -1.27380386e-01f, -1.70000196e-01f,
  -2.92844206e-01f, 1.35522977e-01f, -1.98765114e-01f, -6.31938651e-02f, -2.01439291e-01f, 2.11477101e-01f, 1.42159835e-01f, 6.97826296e-02f, 3.59234601e-01f, -3.90174761e-02f,
  1.59251779e-01f, -2.69409239e-01f, 1.37741581e-01f, -1.73569113e-01f, 4.51416634e-02f, -1.19344750e-02f, 2.67931014e-01f, 2.25251362e-01f, 1.99555054e-01f, 7.97299296e-02f,
  4.96310890e-02f, -2.31725857e-01f, 1.12174757e-01f, 1.41058534e-01f, 2.10812002e-01f, -2.11229220e-01f, -1.00834601e-01f, -5.26586436e-02f, 2.10902169e-01f, 2.98451409e-02f,
  -2.50836294e-02f, -9.63049755e-02f, 2.68889666e-01f, -8.36405829e-02f, -1.88008875e-01f, 3.57384719e-02f, -2.15811193e-01f, -2.05499977e-01f, 1.16660014e-01f, -1.11856714e-01f,
  8.06264877e-02f, -9.65118222e-03f, 6.52626306e-02f, 2.23690629e-01f, -1.54512018e-01f, -3.57140511e-01f, 1.88762337e-01f, 2.91580647e-01f, -3.17874491e-01f, 2.47667417e-01f,
  3.53314549e-01f, 1.25802219e-01f, -4.27665673e-02f, -1.41618215e-02f, 8.53700563e-02f, 2.17364337e-02f, 5.80718108e-02f, -7.70651400e-02f, -2.04879493e-01f, -9.82176736e-02f,
  -8.73558596e-02f, -4.33098897e-02f, 2.77725309e-01f, -1.04055405e-02f, 2.54625797e-01f, 4.32366356e-02f, -1.26584396e-01f, -1.19544804e-01f, -2.31509909e-01f, 2.52960399e-02f,
  -5.20375557e-03f, -6.53099269e-02f, 1.14621952e-01f, 3.63100231e-01f, 1.96733236e-01f, 2.50613749e-01f, 2.40011469e-01f, 2.02996396e-02f, -4.96089123e-02f, -1.09312333e-01f,
  -2.03272387e-01f, 9.20191407e-02f, -1.36629771e-02f, 5.14815032e-01f, 5.09543754e-02f, -1.15422748e-01f, 4.25938457e-01f, -2.34165430e-01f, 4.50654477e-01f, 1.93224192e-01f,
  1.38810694e-01f, -2.79538065e-01f, -2.05025375e-01f, -7.36836717e-02f, -8.27551410e-02f, 9.33566019e-02f, 1.71226054e-01f, -2.91025341e-01f, 6.17197081e-02f, 5.17359190e-02f,
  -2.79316824e-04f, 9.74998772e-02f, 7.74754882e-02f, 8.03982243e-02f, -2.90117770e-01f, 2.53426999e-01f, 4.05535430e-01f, -3.54718380e-02f, -2.04432711e-01f, -5.09237945e-02f,
  6.37302816e-01f, 1.32256657e-01f, 1.00593731e-01f, -4.72655185e-02f, -3.77063006e-01f, 1.87611803e-01f, 1.14685677e-01f, 1.31850928e-01f, -8.93634465e-03f, -6.46011233e-02f,
  1.04348861e-01f, -1.49910286e-01f, 1.21598713e-01f, -2.85480231e-01f, -4.86919284e-02f, -8.01839456e-02f, 1.22511052e-01f, -3.25170249e-01f, -2.01674387e-01f, -1.52956219e-02f,
  2.30449244e-01f, 3.67716746e-03f, -1.68670356e-01f, -1.43624708e-01f, -1.14876285e-01f, 2.05157563e-01f, -1.81969151e-01f, -3.13350976e-01f, -2.95512766e-01f, -1.98040809e-02f,
  -1.96023539e-01f, -3.30938429e-01f, -1.84358597e-01f, -1.46315202e-01f, -1.72949016e-01f, -1.09663941e-01f, 1.54073369e-02f, 1.14956357e-01f, -2.81676222e-02f, 4.09145653e-01f,
  -4.71331999e-02f, -9.20384079e-02f, 1.75122902e-01f, -7.69547746e-02f, -9.25216898e-02f, 2.51078278e-01f, 2.70808935e-01f, 1.05162635e-01f, 1.34059444e-01f, 3.43545198e-01f,
  -3.81963514e-02f, -1.30724898e-02f, -1.27616927e-01f, 1.53359966e-02f, -2.38187730e-01f, -2.39866488e-02f, -1.11172274e-02f, -2.14882866e-01f, -9.56239626e-02f, -1.27690762e-01f,
  1.03482999e-01f, -4.73641679e-02f, -9.78505984e-02f, 1.96518511e-01f, -2.62654908e-02f, -2.97899216e-01f, -5.18232472e-02f, -1.38329044e-01f, -1.19666457e-01f, -2.59107828e-01f,
  1.52025208e-01f, 1.62182376e-01f, 3.13543111e-01f, 2.95698106e-01f, 5.33608906e-02f, -3.26900557e-02f, 1.25086740e-01f, 1.15877926e-01f, 2.02759713e-01f, 1.26235619e-01f,
  1.18710540e-01f, -1.17420197e-01f, 2.19380528e-01f, 2.51208872e-01f, 3.11754227e-01f, -1.74863353e-01f, 1.01809181e-01f, 1.56870022e-01f, -3.57398331e-01f, 6.29871385e-03f,
  -3.12567472e-01f, -4.01471078e-01f, -1.81642815e-01f, 9.51957330e-03f, -1.27404690e-01f, 1.06340148e-01f, -1.18403658e-01f, 8.25575069e-02f, -3.50377932e-02f, -6.06029257e-02f,
  8.05163682e-02f, 1.18045397e-01f, -1.60208255e-01f, 2.05952555e-01f, 2.17089638e-01f, 1.23521686e-01f, -4.51871872e-01f, -2.20118389e-01f, -3.48091796e-02f, 1.49543792e-01f,
  2.15654135e-01f, 1.42155424e-01f, 3.48747745e-02f, -1.44369692e-01f, 9.60320160e-02f, -4.69958074e-02f, -3.63890231e-02f, 6.33541346e-02f, -5.97091168e-02f, -3.87506843e-01f,
  -2.17976913e-01f, 3.78428549e-01f, 9.97376628e-03f, -5.29533066e-02f, -1.40712142e-01f, -2.43596844e-02f, -2.39178270e-01f, 4.03683223e-02f, 4.07894313e-01f, -6.79096626e-03f,
  1.87070981e-01f, 1.94265246e-01f, 1.25962319e-02f, -2.86914200e-01f, 2.72270858e-01f, 3.42234284e-01f, 7.90266469e-02f, 1.88621327e-01f, 2.78342038e-01f, 4.91169952e-02f,
  1.20492622e-01f, 3.75375338e-02f, 4.14571539e-02f, 1.48454756e-01f, 2.80858189e-01f, -1.71917528e-01f, -2.18789175e-01f, 9.89574119e-02f, 3.03554833e-01f, 9.72090364e-02f,
  2.52671212e-01f, -1.29496446e-02f, 4.29570191e-02f, 1.92313954e-01f, -2.19427928e-01f, -1.04634285e-01f, 1.19425759e-01f, 3.41523290e-01f, 1.15202731e-02f, -3.12007338e-01f,
  2.25276694e-01f, -2.35815614e-01f, -2.26923600e-02f, -7.80577306e-03f, 1.03258183e-02f, 4.44401428e-02f, 1.21444128e-01f, 7.55888283e-01f, -1.22691773e-01f, -1.09473683e-01f,
  -5.40930294e-02f, 3.93512249e-02f, -3.27093117e-02f, 2.53961384e-01f, 8.22863728e-02f, 1.97413743e-01f, -3.34370434e-02f, 3.23899329e-01f, -3.58853559e-03f, 2.17670456e-01f,
  -2.92649806e-01f, -1.18725657e-01f, -2.12620288e-01f, 8.58663097e-02f, -1.26671121e-01f, -2.86441714e-01f, -6.32825792e-02f, 2.75985096e-02f, -3.05095524e-01f, 1.28260879e-02f,
  3.65364194e-01f, 2.00546548e-01f, -2.07606912e-01f, -5.73994331e-02f, 2.53030714e-02f, 9.02676955e-02f, 9.06739235e-02f, 5.83778657e-02f, 1.56225474e-03f, -2.39896588e-02f,
  -7.42359534e-02f, 2.22634271e-01f, 1.53548896e-01f, -1.99882209e-01f, 1.97920591e-01f, 2.37071831e-02f, 3.22055161e-01f, -2.76630139e-03f, 5.27943000e-02f, -2.18214720e-01f,
  -2.83068325e-02f, 1.70934588e-01f, 4.71488118e-01f, 8.13589916e-02f, -2.06369296e-01f, 2.28484958e-01f, -1.68486685e-01f, -1.14032596e-01f, -2.01186433e-01f, -2.87248373e-01f,
  -3.68778020e-01f, -1.80133164e-01f, -2.40131691e-01f, -1.65953651e-01f, -2.46778935e-01f, -7.96082690e-02f, -1.54346347e-01f, -3.03620368e-01f, -2.53050644e-02f, -1.62745908e-01f,
  -1.99313149e-01f, 4.08797801e-01f, -3.02305698e-01f, -1.00410925e-02f, -1.53263733e-01f, 9.96429399e-02f, -1.62154157e-02f, 3.58816832e-01f, 3.45160455e-01f, -5.20196976e-04f,
  -1.63734868e-01f, -4.32641692e-02f, -1.14753895e-01f, 1.25085026e-01f, 3.91439386e-02f, -2.22952560e-01f, -2.30782956e-01f, -2.26552472e-01f, 7.77135119e-02f, -3.77558857e-01f,
  4.28366363e-02f, -1.61365956e-01f, 6.79867268e-02f, 1.88624915e-02f, -7.80757815e-02f, 1.97302371e-01f, -4.91947502e-01f, -2.62251467e-01f, -7.92513341e-02f, 1.84189267e-02f,
  -1.71886563e-01f, 2.56397035e-02f, 2.66794264e-01f, -1.45363256e-01f, 1.52291022e-02f, 5.05723543e-02f, 1.42296880e-01f, -8.79084766e-02f, -3.39495279e-02f, -2.26254873e-02f,
  1.86423153e-01f, 3.84792238e-02f, 1.90115049e-01f, -1.11828946e-01f, -1.68944255e-01f, -1.97758013e-03f, -2.40974694e-01f, 4.59093340e-02f, -1.15508161e-01f, 1.62430510e-01f,
  3.43028635e-01f, 3.78211215e-02f, 1.31796971e-01f, 1.01420075e-01f, 1.62393242e-01f, -7.99959376e-02f, 4.00879905e-02f, -1.75972000e-01f, 3.18300389e-02f, 1.35058150e-01f,
  3.68055105e-01f, 4.11651433e-01f, 8.74264985e-02f, 1.45191327e-01f, 9.14622173e-02f, 1.74422383e-01f, -5.88609390e-02f, 1.97224677e-01f, -7.01491758e-02f, -1.26010150e-01f,
  -6.54286221e-02f, 1.25990873e-02f, 8.91939402e-02f, 6.86975718e-02f, 7.76618137e-04f, 6.92689791e-02f, 1.05215363e-01f, 2.63263993e-02f, 2.42438968e-02f, -4.23132814e-02f,
  -9.71357450e-02f, -3.39815259e-01f, -1.86146155e-01f, -2.92649101e-02f, 2.19035614e-03f, 4.62299883e-01f, -1.27213523e-01f, 3.65196615e-01f, -2.83728335e-02f, -3.60892773e-01f,
  2.22466122e-02f, 1.53396845e-01f, 4.96245362e-02f, 1.66069478e-01f, 2.80002236e-01f, 1.83633029e-01f, -1.08163841e-01f, 9.65469889e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  3.11722338e-01f, 1.97568953e-01f, 2.44615778e-01f, 2.24864110e-01f, 1.97362646e-01f, 8.50695968e-02f, 1.10968560e-01f, 2.15435281e-01f, 2.22231731e-01f, 1.41625613e-01f,
  2.41002455e-01f, -2.51568537e-02f, 1.41132921e-01f, 1.08281322e-01f, 8.80979076e-02f, -1.27445534e-02f, 2.00678483e-01f, 1.43751815e-01f, 1.21467136e-01f, 3.18416327e-01f,
  1.23075075e-01f, 2.15250671e-01f, 1.45278096e-01f, 2.07462743e-01f, 3.26356828e-01f, 2.91865349e-01f, 9.44663286e-02f, 2.34477103e-01f, 3.30026358e-01f, 1.61579788e-01f,
  1.06276549e-01f, 1.56310737e-01f, 7.29571134e-02f, 1.27256438e-01f, 1.11609034e-01f, 6.89118132e-02f, 2.91412145e-01f, 2.38395080e-01f, 1.97768211e-01f, 1.71074033e-01f,
  1.95854921e-02f, 2.99793810e-01f, 1.94104880e-01f, 2.21112609e-01f, 9.78087559e-02f, 7.45385885e-02f, 1.33211195e-01f, 2.56975323e-01f, 5.14768139e-02f, 2.04439059e-01f,
  -4.05824371e-02f, 1.06084518e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.43574879e-01f, -8.46798122e-02f, -3.12752217e-01f, 1.97160244e-02f, -2.02199854e-02f, -9.54212248e-02f, 1.73078313e-01f, 1.39217794e-01f, -7.14209899e-02f, -7.28098676e-02f,
  -8.58438164e-02f, -1.86332509e-01f, -2.95690238e-01f, -5.06045878e-01f, -1.80895194e-01f, 1.27583876e-01f, -2.03256443e-01f, 2.41916344e-01f, -2.15176530e-02f, -4.12712209e-02f,
  -3.18150938e-01f, -2.56708831e-01f, 4.97264555e-03f, 2.44718060e-01f, 3.45067471e-01f, 5.10719307e-02f, -1.22011416e-01f, -4.11110967e-01f, -3.05308402e-01f, -1.40210003e-01f,
  1.61452562e-01f, 2.35446215e-01f, -2.52748847e-01f, -2.76001900e-01f, -1.71910778e-01f, -3.57064515e-01f, -4.11174357e-01f, -4.50057745e-01f, 2.19764989e-02f, -6.65265992e-02f,
  1.67963818e-01f, 1.89477161e-01f, 5.58596551e-02f, -6.82758912e-02f, 4.52996008e-02f, 9.43606421e-02f, -1.54335365e-01f, -6.06869571e-02f, -4.40441519e-01f, -4.04349625e-01f,
  -1.03873638e-02f, 2.82239527e-01f, 6.99503049e-02f, 1.72117434e-03f, -3.12157154e-01f, -2.42205307e-01f, 2.38110915e-01f, 2.75598913e-01f, 1.74936876e-01f, -1.12802088e-02f,
  -1.74825206e-01f, -3.17196369e-01f, 1.40807126e-02f, 2.41942763e-01f, 6.41392767e-02f, -1.14069581e-01f, 2.33317971e-01f, 4.55180667e-02f, -9.89508480e-02f, 1.67795032e-01f,
  -4.11268860e-01f, 5.36798425e-02f, 3.91866565e-02f, -1.07203089e-01f, 3.39113057e-01f, -2.19892010e-01f, 1.79469243e-01f, -5.21015346e-01f, 6.97243065e-02f, -1.13159902e-01f,
  -4.91053224e-01f, -1.17929690e-01f, -1.23287678e-01f, 4.67524052e-01f, 7.57099641e-03f, -3.53698492e-01f, 3.13744992e-01f, -1.61449507e-01f, 3.18099618e-01f, -1.61916278e-02f,
  -7.43476450e-02f, -2.91283339e-01f, -3.15863281e-01f, 5.17218634e-02f, 1.52200431e-01f, 1.15990387e-02f, -2.11828962e-01f, -3.30225259e-01f, 2.56234825e-01f, -3.01845551e-01f,
  5.46842217e-02f, -3.92316222e-01f, -2.40387529e-01f, 1.02343522e-01f, -1.12075545e-01f, -3.94795358e-01f, 2.94476062e-01f, -2.72152871e-01f, -1.77460074e-01f, 2.08738729e-01f,
  -1.13932766e-01f, -4.34003137e-02f, -3.47396374e-01f, 1.45158395e-01f, 2.69657254e-01f, 1.45472631e-01f, -3.79677325e-01f, -4.91688967e-01f, 1.18478492e-01f, -1.03550874e-01f,
  -3.30884218e-01f, 2.98968464e-01f, -4.54717964e-01f, 5.79237081e-02f, 2.10516211e-02f, -7.62862936e-02f, -1.90351710e-01f, 1.88159838e-01f, 1.82672143e-01f, -1.95374802e-01f,
  2.16667742e-01f, -3.87180485e-02f, 8.61106813e-02f, 9.41740274e-02f, 1.52466550e-01f, 3.43905330e-01f, -2.93201566e-01f, -3.05782676e-01f, -1.52524158e-01f, -4.21552718e-01f,
  2.53922552e-01f, 3.60120922e-01f, -2.06634909e-01f, 1.61752537e-01f, -2.63209671e-01f, 2.08728626e-01f, -1.61178689e-02f, -1.22857928e-01f, 1.68372750e-01f, 2.19053328e-01f,
  1.50250778e-01f, 2.28695199e-01f, -1.11681342e-01f, -3.65026444e-01f, -2.44376481e-01f, -3.76085907e-01f, -4.04474020e-01f, 2.49334633e-01f, -4.16170835e-01f, -7.48636425e-02f,
  1.13382980e-01f, 1.21229082e-01f, 1.49591655e-01f, 1.51171744e-01f, -3.86215985e-01f, -2.74670005e-01f, 1.28037557e-01f, -3.35337147e-02f, -4.41787183e-01f, 1.63529694e-01f,
  -2.68348008e-01f, -2.51182795e-01f, 3.66576612e-01f, 1.03785269e-01f, -2.90575504e-01f, -3.18071485e-01f, -2.31304035e-01f, -2.95437247e-01f, 1.95003122e-01f, -1.72943935e-01f,
  2.53346205e-01f, -1.15749806e-01f, 2.71149457e-01f, -1.12990774e-01f, -2.98002869e-01f, -1.92468415e-03f, -4.29813594e-01f, -3.19272280e-01f, -9.34223011e-02f, -1.22031845e-01f,
  8.14210624e-02f, 1.20979793e-01f, -9.39714238e-02f, -3.31414521e-01f, -2.12525427e-01f, -2.29920372e-01f, 1.24024160e-01f, -9.39238742e-02f, 6.84356019e-02f, 2.59372115e-01f,
  -1.30181074e-01f, 8.30220133e-02f, 7.67085254e-02f, -3.40892933e-02f, -3.39501977e-01f, 2.84105629e-01f, -1.30537212e-01f, -1.96326867e-01f, -1.93547189e-01f, 1.41668662e-01f,
  -4.27995920e-01f, 2.65258789e-01f, -1.94689170e-01f, 3.96827012e-01f, -4.57499504e-01f, -1.10448092e-01f, -4.74556416e-01f, 2.21015811e-01f, -3.18866193e-01f, -1.63228184e-01f,
  -3.00395012e-01f, -2.11929098e-01f, 7.56014884e-02f, 2.11475223e-01f, 4.07146782e-01f, 2.06874147e-01f, -2.94337124e-01f, 1.34250790e-01f, -1.74015120e-01f, -9.66308266e-02f,
  2.09923804e-01f, -3.77026945e-02f, -4.08390090e-02f, 8.45235363e-02f, 2.01327592e-01f, 7.22390339e-02f, 3.77062827e-01f, 9.21064764e-02f, -1.67887717e-01f, -1.74242020e-01f,
  -5.16928695e-02f, -4.58720177e-01f, -2.97864079e-01f, -2.78683752e-01f, -5.70866093e-02f, -1.77978218e-01f, -1.24088824e-01f, -1.16462015e-01f, 8.54351968e-02f, -2.33200416e-01f,
  2.91996133e-02f, -2.33564511e-01f, -1.58052624e-03f, 2.60679871e-01f, -4.96477373e-02f, 7.73620903e-02f, -3.20553660e-01f, 5.61911225e-01f, 1.21098317e-01f, 5.10070503e-01f,
  -1.81228131e-01f, -1.83807626e-01f, -2.76024669e-01f, 9.28856879e-02f, 4.87026013e-02f, 4.10757035e-01f, -2.13501289e-01f, 4.38451052e-01f, 1.12212025e-01f, -7.27673201e-03f,
  3.55051905e-02f, -1.07794337e-01f, -2.97694132e-02f, -1.55041311e-02f, -3.38656642e-02f, -2.71168172e-01f, -2.32469857e-01f, -3.70289713e-01f, 2.86149681e-02f, -1.63037274e-02f,
  -1.09922111e-01f, 6.85057938e-02f, -1.82834297e-01f, 3.60032409e-01f, 8.63147527e-02f, 1.62933961e-01f, 1.37146324e-01f, -4.55853827e-02f, -1.31985009e-01f, 8.90375450e-02f,
  -2.52229869e-01f, 2.04751417e-01f, 8.29742998e-02f, 1.00959234e-01f, 1.95122495e-01f, 5.66373207e-02f, -3.12834352e-01f, 2.63888478e-01f, -2.87696898e-01f, 2.30372429e-01f,
  -2.99055874e-01f, 1.00307383e-01f, -3.60674530e-01f, -3.68637800e-01f, 1.99484602e-01f, 1.64096519e-01f, -1.21393077e-01f, 1.01498358e-01f, 7.39825740e-02f, 2.12014854e-01f,
  -3.86466026e-01f, -6.22313321e-02f, -3.95918041e-01f, -8.35120231e-02f, 2.11659610e-01f, -2.33583581e-02f, -3.74535955e-02f, -3.83216292e-01f, 3.12569961e-02f, -6.71740249e-02f,
  2.13076249e-01f, -5.81847094e-02f, 1.77237336e-02f, -6.75633177e-02f, 3.99634004e-01f, 2.56389081e-01f, 9.58227143e-02f, -2.45308340e-01f, 3.41506064e-01f, 1.86944902e-01f,
  -2.74953485e-01f, -1.02977753e-02f, 9.13613960e-02f, -5.70213981e-02f, -2.22290039e-01f, -2.77189642e-01f, 4.27041709e-01f, -5.76532781e-01f, 3.54683660e-02f, -7.29105473e-02f,
  -2.25519557e-02f, -4.43006188e-01f, 1.42383143e-01f, -1.44229472e-01f, -1.61552966e-01f, 2.75747448e-01f, -1.90177009e-01f, -1.18656546e-01f, 3.29285264e-01f, 1.29251825e-02f,
  9.83736739e-02f, 3.07396561e-01f, -5.24519324e-01f, -4.71999854e-01f, -2.38702849e-01f, -4.78679150e-01f, 1.25240490e-01f, 1.63970590e-01f, -1.17480807e-01f, 9.04607028e-02f,
  5.14532506e-01f, -8.59965384e-02f, 2.31591299e-01f, -2.43990064e-01f, -2.51731038e-01f, -7.90762380e-02f, 2.82838792e-01f, -3.81078869e-01f, 3.16736877e-01f, -1.35957927e-01f,
  -2.37056434e-01f, 3.28056425e-01f, -2.49877751e-01f, 2.87539959e-01f, -8.25112164e-02f, -9.93269309e-02f, 1.41527697e-01f, -2.06410244e-01f, -2.13254362e-01f, -1.65139034e-01f,
  -3.35382409e-02f, -7.69831538e-02f, -2.06804737e-01f, -2.69879848e-01f, 5.18896170e-02f, 1.17932416e-01f, -2.54083484e-01f, 3.44326086e-02f, 2.68651936e-02f, -2.93540563e-02f,
  3.21204245e-01f, 2.35063791e-01f, 3.02713394e-01f, -6.73026741e-02f, 5.68263233e-03f, -2.10300118e-01f, 1.67483345e-01f, -4.42892343e-01f, -1.39603943e-01f, 4.09068435e-01f,
  -2.37904444e-01f, -4.26064312e-01f, 9.36605409e-02f, -4.58541274e-01f, 2.33631209e-01f, 2.55945832e-01f, -1.50655642e-01f, 3.61444838e-02f, -3.54971230e-01f, -4.53497946e-01f,
  -4.72780615e-01f, 2.41383761e-01f, 2.49821126e-01f, -1.73654735e-01f, -2.08124802e-01f, -1.65805161e-01f, -3.49277481e-02f, 1.54551983e-01f, 2.66066551e-01f, -7.97179937e-02f,
  1.94009140e-01f, -9.51077044e-02f, -3.16619843e-01f, -2.73899222e-03f, -4.88177150e-01f, -2.40316123e-01f, -3.43039393e-01f, 2.41935492e-01f, -2.18696177e-01f, -4.43344265e-01f,
  2.37282827e-01f, 3.69627774e-01f, 9.53428298e-02f, -1.05491512e-01f, -8.83079097e-02f, -2.65842944e-01f, -1.86843097e-01f, -1.97656497e-01f, 1.53650299e-01f, -1.43523470e-01f,
  -3.72876853e-01f, -4.24418926e-01f, -1.21525504e-01f, -4.86899704e-01f, 1.02301307e-01f, -3.01903099e-01f, -1.82773888e-01f, -2.29956493e-01f, 1.35227934e-01f, -9.72210392e-02f,
  -2.97520515e-02f, -2.14197505e-02f, -1.74284652e-02f, -1.90520182e-01f, -1.70327395e-01f, -1.10371098e-01f, -5.19063845e-02f, -2.62999088e-01f, -5.39300255e-02f, -2.77508408e-01f,
  -3.62782568e-01f, 9.27241743e-02f, -2.50725746e-01f, 1.85074866e-01f, 2.63282955e-01f, 3.24699208e-02f, 1.78969830e-01f, -4.03614670e-01f, -4.24673080e-01f, -2.76370198e-01f,
  -1.16963074e-01f, -2.37053305e-01f, -1.13439374e-01f, -6.30848557e-02f, 2.02585623e-01f, 3.52962799e-02f, 3.21555734e-02f, -2.55298465e-01f, -3.04717660e-01f, -6.74397498e-02f,
  1.17968984e-01f, 2.47746736e-01f, -2.09241167e-01f, -6.90731779e-03f, 1.56184852e-01f, -1.22872770e-01f, 2.96317157e-03f, 1.05920210e-01f, 3.06608647e-01f, -1.00878783e-01f,
  -7.02942163e-02f, -3.31332177e-01f, 3.45923245e-01f, -3.63842696e-01f, -5.59589207e-01f, -1.74495980e-01f, 1.06541432e-01f, 1.89857408e-01f, -4.23867628e-03f, -1.29390746e-01f,
  1.01110697e-01f, 1.21154844e-04f, 6.56070784e-02f, 1.79843932e-01f, 2.96765029e-01f, -3.32650989e-02f, -5.39847128e-02f, 2.60944426e-01f, -4.16251719e-01f, 1.50531858e-01f,
  -5.54200560e-02f, 1.52184647e-02f, -1.85907900e-01f, 1.88207582e-01f, -2.26657689e-02f, 1.37153417e-01f, 6.29406497e-02f, -8.86615440e-02f, 4.13507164e-01f, -1.02698095e-01f,
  2.57391721e-01f, 1.53567150e-01f, 2.08173916e-01f, 3.31046849e-01f, -2.01151088e-01f, 3.18207711e-01f, 2.07848266e-01f, 4.31611866e-01f, 1.97042227e-01f, -1.73574150e-01f,
  2.31359124e-01f, -6.96653919e-03f, -1.88059434e-01f, 1.72984060e-02f, 2.76785374e-01f, -1.88053966e-01f, 4.23207358e-02f, 4.61523160e-02f, 2.18496278e-01f, -2.40887925e-01f,
  -6.72755390e-02f, 2.67034799e-01f, -4.24696475e-01f, -3.41410488e-01f, -1.70645431e-01f, -1.25374898e-01f, -4.33290675e-02f, -1.31627157e-01f, -5.68869747e-02f, 1.05116636e-01f,
  -2.51513332e-01f, -2.76077718e-01f, -1.79236606e-01f, -1.75415009e-01f, -7.94844329e-02f, -2.72130966e-01f, -3.03716306e-02f, -2.28078604e-01f, 6.74378797e-02f, 2.93077886e-01f,
  -2.78316319e-01f, 2.50412859e-02f, 1.59692928e-01f, -2.26406828e-01f, -9.37081948e-02f, -1.64925814e-01f, -8.97827893e-02f, -1.35433614e-01f, 3.08312595e-01f, -1.46834329e-01f,
  -1.65629253e-01f, 3.02908123e-01f, 2.34870285e-01f, 1.90980911e-01f, 4.50879335e-01f, -2.71706551e-01f, 1.38277307e-01f, 9.60353240e-02f, 3.11013728e-01f, -1.57954648e-01f,
  1.32795557e-01f, -1.14741400e-01f, 8.71997252e-02f, -4.11372930e-01f, -5.14913388e-02f, -3.59592795e-01f, 3.00545543e-02f, 2.33003378e-01f, 1.10526904e-01f, -2.64813155e-01f,
  -1.62872806e-01f, -4.92084950e-01f, -2.34644309e-01f, -5.46198666e-01f, 5.39667644e-02f, -2.83431679e-01f, 2.65737146e-01f, 1.72816679e-01f, 2.60962769e-02f, 6.42686114e-02f,
  1.07493885e-01f, -2.80148834e-01f, 4.80249792e-01f, 5.67125939e-02f, 2.09675282e-02f, -3.70665133e-01f, -3.46593350e-01f, -5.00535011e-01f, 7.94054419e-02f, 1.13366455e-01f,
  5.12062386e-02f, 3.02803159e-01f, -2.46161759e-01f, 1.35306552e-01f, -5.46885252e-01f, -3.42037767e-01f, 5.92973456e-02f, 2.91209489e-01f, -2.70341456e-01f, -1.08899875e-02f,
  7.67222270e-02f, -1.29110277e-01f, -7.52525404e-02f, -1.31937889e-02f, 9.51751694e-02f, -1.39395148e-01f, -8.20644051e-02f, 1.11416295e-01f, 2.78489351e-01f, 4.58535880e-01f,
  2.13739812e-01f, -3.11622340e-02f, -2.30928019e-01f, -8.67147744e-02f, 2.92136788e-01f, -2.94698000e-01f, -4.87652302e-01f, -4.28006828e-01f, 1.61521986e-01f, -4.41812575e-01f,
  -1.26866892e-01f, -3.89849730e-02f, 6.20539971e-02f, -1.24866687e-01f, -1.08611502e-03f, -2.48826016e-02f, -2.82341003e-01f, -2.12691247e-01f, -2.62520075e-01f, -1.19339889e-02f,
  -1.27848417e-01f, 1.43126324e-01f, -5.30377805e-01f, 3.22972506e-01f, -2.91032046e-01f, -2.28218228e-01f, 1.92544177e-01f, -2.58965671e-01f, -3.72624904e-01f, 5.58443777e-02f,
  2.70483732e-01f, 2.09898785e-01f, -4.28592354e-01f, -3.32254380e-01f, -5.14069432e-03f, -3.21357518e-01f, 3.59530330e-01f, -6.19007014e-02f, -6.69841617e-02f, 2.55970389e-01f,
  1.88197374e-01f, -1.28342077e-01f, -8.46942142e-03f, -3.12892854e-01f, -2.71574438e-01f, 1.47796109e-01f, -2.21693277e-01f, 3.15876991e-01f, 6.82667419e-02f, -4.15780246e-01f,
  -1.25387311e-01f, -2.34431446e-01f, -2.33539656e-01f, 1.89956471e-01f, -2.43471250e-01f, 2.15975001e-01f, 1.52384460e-01f, -1.14890963e-01f, -3.96752864e-01f, -2.23042697e-01f,
  2.72325814e-01f, -3.30190510e-01f, -2.17350677e-01f, -3.14536005e-01f, -1.26027182e-01f, 3.18698674e-01f, -7.12868497e-02f, -3.17907065e-01f, -2.94169426e-01f, -3.33542913e-01f,
  -3.61806154e-01f, 2.39438951e-01f, -3.24318379e-01f, -3.40736508e-01f, -4.81783450e-02f, 5.93223535e-02f, -2.57595360e-01f, 4.53444980e-02f, 9.48479995e-02f, 6.26188219e-02f,
  -3.37125689e-01f, -2.09184885e-01f, 2.04223767e-01f, -1.37007460e-01f, 1.75556794e-01f, 3.11296314e-01f, 1.28254980e-01f, -2.83410698e-01f, 3.65843475e-01f, 3.60505749e-03f,
  4.17339429e-02f, 2.91541487e-01f, -4.54124212e-01f, 2.88878232e-01f, -2.87533730e-01f, -1.26520053e-01f, -4.16018069e-01f, -1.65028840e-01f, -3.00080746e-01f, 4.93140906e-01f,
  -3.42566013e-01f, 1.02046445e-01f, 3.82081300e-01f, -2.14773059e-01f, -2.88055092e-01f, -2.12278012e-02f, 3.31558824e-01f, 1.14377879e-01f, -1.25963256e-01f, -1.09110959e-01f,
  -1.22211641e-02f, 3.10154945e-01f, -1.95125759e-01f, -8.60281587e-02f, -1.50743142e-01f, -6.17907615e-03f, -1.05735838e-01f, -2.98073053e-01f, -2.77542412e-01f, -3.14962566e-01f,
  -3.29686254e-01f, 2.71379679e-01f, 5.73114939e-02f, -1.26466611e-02f, -1.80865124e-01f, -1.76166967e-01f, -3.40138227e-01f, -3.99614051e-02f, -9.49970409e-02f, -1.99647412e-01f,
  -5.05318008e-02f, 1.14420496e-01f, 3.18214625e-01f, 7.88950641e-03f, 3.88140351e-01f, -5.43420464e-02f, -1.54433027e-01f, 3.16290930e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -4.93368730e-02f, -3.59790698e-02f, 3.82968150e-02f, -9.71717238e-02f, -5.86349219e-02f, 1.77496463e-01f, -1.06528513e-01f, 1.13281459e-02f, 1.77770443e-02f, 1.17967233e-01f,
  -5.96256442e-02f, -5.05833179e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    