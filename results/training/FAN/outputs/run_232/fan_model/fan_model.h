/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.82104677e-02f, -1.81780234e-01f, -2.02953696e-01f, -5.06942272e-01f, 2.52653152e-01f, -3.48319151e-02f, -4.02381092e-01f, 8.62222165e-03f, -1.51108965e-01f, -5.05859451e-03f,
  -2.33954892e-01f, -2.43775770e-02f, -1.22606918e-01f, -2.62694597e-01f, -2.79589832e-01f, -2.54004627e-01f, -1.92118108e-01f, -7.48697892e-02f, -2.56191976e-02f, -2.01692786e-02f,
  -1.10517055e-01f, -2.43726879e-01f, -2.55360395e-01f, 2.75638532e-02f, -2.69446075e-02f, 1.08096458e-01f, -5.54179447e-03f, 6.11966522e-03f, 4.02757004e-02f, -1.00611433e-01f,
  -9.60092172e-02f, 5.77758811e-02f, -7.36633409e-03f, 5.33791929e-02f, -7.19777495e-03f, 1.03671653e-02f, 4.35062945e-02f, -7.62512982e-02f, -1.65583640e-02f, 1.40502956e-02f,
  5.67333438e-02f, 1.86232720e-02f, -1.29636656e-02f, -5.89835383e-02f, 7.79174939e-02f, 7.40081742e-02f, 2.96218134e-02f, -1.94908411e-03f, -7.77109712e-02f, -4.93795006e-03f,
  1.37964040e-02f, -3.04218344e-02f, -2.49540769e-02f, 2.76617967e-02f, 2.16932055e-02f, 1.97487269e-02f, -6.55107424e-02f, 4.69799228e-02f, 5.58591448e-03f, -2.05675922e-02f,
  8.75017494e-02f, 1.29355735e-03f, 2.49612834e-02f, -4.04010266e-02f, -4.61497493e-02f, -4.19064164e-02f, 1.11050643e-02f, 4.93777543e-03f, 5.84725430e-03f, 8.07163585e-03f,
  -7.77152088e-03f, -1.80770457e-02f, -2.52089985e-02f, 2.64505483e-02f, -6.03917427e-03f, -2.62187403e-02f, -6.74312189e-02f, 6.94738030e-02f, -5.48082544e-03f, 1.32797463e-02f,
  -3.10838135e-04f, 1.82145778e-02f, -8.92605726e-03f, -1.67627241e-02f, -4.36108448e-02f, 9.34259407e-03f, -1.74038317e-02f, -7.74690509e-03f, 4.76965010e-02f, 2.46830727e-03f,
  -5.70705123e-02f, -6.29653409e-02f, -9.13665742e-02f, -3.92160192e-02f, 1.31314769e-02f, 3.37004922e-02f, -1.94450822e-02f, 9.11740214e-02f, -8.66624434e-03f, -1.36828432e-02f,
  1.00995816e-01f, 3.92964818e-02f, 4.26352136e-02f, -1.68616008e-02f, -5.48714362e-02f, -4.88120131e-02f, -4.58286144e-02f, 4.48734611e-02f, 6.20518439e-02f, 4.95754136e-03f,
  1.57809313e-02f, 2.19597481e-02f, -7.94087816e-03f, 2.44288296e-02f, 7.19747134e-03f, 3.36784031e-03f, 7.77876005e-02f, -4.27710190e-02f, 3.99147496e-02f, 5.64536871e-03f,
  -5.25687873e-01f, 3.10637116e-01f, -1.74686145e-02f, 2.67398804e-01f, -1.87344700e-01f, -1.21111892e-01f, -1.32839516e-01f, 1.52037516e-01f, -1.41750142e-01f, 1.59765601e-01f,
  6.35697320e-02f, -7.49380663e-02f, -2.35437844e-02f, 1.74572825e-01f, -1.95730194e-01f, 7.22927367e-03f, 1.37770414e-01f, 1.48857990e-02f, -7.49967992e-02f, 9.82833356e-02f,
  2.38051303e-02f, 4.72457781e-02f, 2.96158437e-02f, 4.49734740e-02f, 7.46683031e-02f, 9.84321237e-02f, 1.63762886e-02f, 3.06355348e-03f, 1.55518472e-01f, 7.21049309e-03f,
  -9.85186547e-02f, 7.77518600e-02f, 4.09902744e-02f, -5.28474562e-02f, 7.31695630e-03f, 3.87971546e-03f, 1.53163578e-02f, 8.31661746e-03f, 3.50385113e-03f, -2.06252802e-02f,
  -2.77063698e-02f, 4.96993121e-03f, 1.06706740e-02f, -4.32418138e-02f, -1.45891521e-04f, 5.87449893e-02f, -1.81480963e-02f, -5.87191014e-03f, 9.17270489e-04f, -7.71789765e-03f,
  2.77972668e-02f, 2.84308363e-02f, 1.85657367e-02f, -3.57343480e-02f, -1.07185384e-02f, 1.17286751e-02f, -8.78198445e-03f, -4.74855863e-02f, -2.25200783e-02f, -1.39167812e-03f,
  -7.17231110e-02f, 1.05087152e-02f, 1.53267300e-02f, 8.28102883e-03f, 1.00991437e-02f, 3.81950499e-03f, -1.13841621e-02f, 2.11301446e-02f, -8.73567909e-03f, 1.22113237e-02f,
  2.48741219e-03f, 1.22444285e-02f, 1.27670374e-02f, 2.32232921e-02f, 4.98225959e-03f, 3.84937637e-02f, -1.45456241e-02f, -1.11994147e-02f, 1.00560309e-02f, 4.44195140e-03f,
  2.30178162e-02f, -3.88116390e-02f, -1.50080118e-03f, -2.94278609e-03f, 4.59597073e-03f, -2.40915585e-02f, 1.02121048e-02f, 2.05105003e-02f, -1.02638463e-02f, 7.88167212e-03f,
  1.18925750e-01f, 1.09386884e-01f, -9.37915873e-03f, 5.21611571e-02f, -1.92556493e-02f, 8.09192099e-03f, -5.43863885e-02f, 2.01847358e-03f, 2.27885135e-02f, 1.24353487e-02f,
  -1.78469159e-03f, 2.64047645e-02f, -9.76616982e-04f, 2.58382370e-05f, -9.73553397e-03f, -1.86809581e-02f, 1.62714329e-02f, 4.45401333e-02f, 1.19303223e-02f, 4.92231548e-02f,
  1.16392812e-02f, -1.54804625e-02f, -4.85797087e-03f, 1.82662960e-02f, 2.62054312e-03f, 4.39832658e-02f, -3.01324874e-02f, 1.53657543e-02f, 3.51746567e-02f, -2.45144162e-02f,
  2.98546970e-01f, 1.95412725e-01f, 2.75899976e-01f, 9.10352990e-02f, 6.49766698e-02f, 2.35059962e-01f, 9.81743857e-02f, 8.11255872e-02f, 3.01218480e-01f, -9.62405205e-02f,
  -2.02881113e-01f, 8.72377530e-02f, -4.05476801e-02f, -6.03615455e-02f, -2.59728334e-03f, 3.20900753e-02f, 1.59059477e-03f, -1.08001232e-01f, 1.22264110e-01f, -2.10219878e-03f,
  -1.28180347e-02f, -7.90551081e-02f, 3.10613327e-02f, -7.46051371e-02f, -1.86550971e-02f, 1.89800356e-02f, -1.95057988e-01f, 3.44375819e-02f, -1.42440572e-01f, 6.19633757e-02f,
  -1.17811725e-01f, 1.09941445e-01f, 9.31002945e-03f, 4.47426625e-02f, -5.72728105e-02f, -9.82140377e-03f, -2.86677089e-02f, 2.17510704e-02f, -9.84878186e-03f, 7.41822794e-02f,
  -3.11122159e-03f, -9.90323443e-03f, 3.51565592e-02f, 1.34220114e-02f, 1.36026498e-02f, -7.80865492e-04f, 3.25188339e-02f, 5.88153675e-02f, 4.99364659e-02f, 2.66222488e-02f,
  2.34208591e-02f, 3.26956529e-03f, -3.04129031e-02f, 3.21899424e-03f, -1.87918078e-02f, 9.94460937e-03f, 3.25134620e-02f, -6.44076765e-02f, 2.13472005e-02f, 1.38065591e-02f,
  -1.00759864e-01f, -2.16967184e-02f, -2.00932454e-02f, 1.94957736e-03f, -2.68256012e-02f, -2.92860949e-03f, -7.41013838e-03f, -3.41910310e-02f, 1.61421541e-02f, -4.83253412e-02f,
  -3.85188535e-02f, 3.36497230e-03f, -3.43388692e-03f, 4.59731445e-02f, -2.30175164e-02f, -8.87550693e-03f, -1.77624691e-02f, 2.46974453e-03f, 2.06247461e-03f, -1.60222147e-02f,
  3.43608148e-02f, -1.61259007e-02f, -3.62535901e-02f, -4.85111885e-02f, 1.30952690e-02f, -3.23528312e-02f, -1.55922761e-02f, 1.44020477e-02f, 6.07710285e-03f, -4.89484295e-02f,
  4.63665649e-03f, -4.38779518e-02f, 1.77368578e-02f, -6.49322523e-03f, -4.38362733e-03f, -7.29725212e-02f, -1.29731642e-02f, -5.51918522e-03f, 4.95426990e-02f, -1.96026750e-02f,
  7.51786819e-03f, 1.38518037e-02f, -3.85313742e-02f, 1.64138444e-03f, 4.43362910e-03f, -2.16841083e-02f, -6.44300878e-03f, -2.34057214e-02f, -5.02285063e-02f, -4.78343405e-02f,
  -5.55081069e-02f, -1.98800843e-02f, 4.04175967e-02f, 3.39642353e-02f, -6.20528404e-03f, -7.11854324e-02f, 1.29289301e-02f, 8.09712429e-03f, -3.43767703e-02f, -9.24257003e-03f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.18629256e-01f, 3.05295318e-01f, 4.47640801e-03f, 1.31871089e-01f, -7.09592625e-02f, -4.43600416e-01f, -1.56369224e-01f, -8.74666572e-02f, 4.14167531e-02f, 6.72666589e-03f,
  -2.21029371e-01f, 4.87365067e-01f, -1.55209556e-01f, 5.36418147e-02f, -5.49943984e-01f, -1.59085140e-01f, -2.43801758e-01f, 4.35339697e-02f, -4.85686362e-02f, -2.32941024e-02f,
  -1.08145639e-01f, -1.43558815e-01f, -1.04634494e-01f, -1.96165591e-02f, 2.66628545e-02f, 1.16888352e-01f, -1.51059464e-01f, 1.22798476e-02f, 3.41385342e-02f, -4.25349064e-02f,
  2.26428267e-02f, 1.61100090e-01f, 1.85323194e-01f, -3.76894027e-02f, -1.43848062e-01f, -1.46661615e-02f, 1.70233995e-02f, -2.94429064e-02f, 2.03766841e-02f, -3.52179557e-02f,
  6.97516352e-02f, -1.08798005e-01f, 3.09236255e-02f, 1.96757279e-02f, 4.55804467e-02f, 3.52169946e-02f, 6.37837872e-02f, -2.91586225e-03f, 8.25012177e-02f, 8.98004323e-02f,
  9.37410071e-02f, 2.45455140e-03f, -6.80161789e-02f, 2.38574320e-03f, -1.27501702e-02f, 5.96423596e-02f, 2.77236123e-02f, 3.05072013e-02f, -3.69713292e-03f, -9.58095025e-03f,
  8.34517702e-02f, -5.97257912e-02f, 4.58129607e-02f, 9.30612907e-02f, 5.44808358e-02f, -6.06757635e-03f, 4.67230007e-02f, 4.73027024e-03f, 9.53128655e-03f, 2.66986666e-03f,
  -2.25381870e-02f, 4.15525399e-02f, 4.42852564e-02f, -1.05659682e-02f, 3.10904738e-02f, 4.22813036e-02f, -1.99096855e-02f, 2.12182384e-02f, 1.26117263e-02f, -3.79043855e-02f,
  -1.08588720e-03f, -3.75591032e-02f, 3.92575227e-02f, 3.02769840e-02f, -5.10551296e-02f, -2.48748669e-03f, 2.91487519e-02f, 6.91753626e-02f, 3.43208984e-02f, -4.52134525e-04f,
  -3.42246443e-01f, -3.46913755e-01f, -4.55831327e-02f, 5.77711910e-02f, 8.01425278e-02f, -4.54202248e-03f, -5.68741048e-03f, 1.18485177e-02f, -1.20822988e-01f, -2.00020131e-02f,
  3.44404392e-02f, -1.12872850e-03f, -5.69578782e-02f, -2.46951021e-02f, -4.22687046e-02f, -6.70510456e-02f, -2.27025803e-02f, 8.11719615e-03f, -3.19137145e-03f, -7.80610070e-02f,
  5.06829955e-02f, 1.39876110e-02f, 5.25906980e-02f, -4.95147984e-03f, 8.16602260e-03f, -5.27874380e-02f, 1.67266782e-02f, 7.62419626e-02f, -3.51238325e-02f, -2.28974335e-02f,
  3.31020325e-01f, -5.04285634e-01f, -4.49657813e-03f, 1.54503301e-01f, 2.23186135e-01f, 1.24060027e-01f, 1.27359509e-01f, -5.45978062e-02f, -7.77218863e-03f, -1.34377718e-01f,
  -3.66679393e-02f, -3.29753086e-02f, -1.20594539e-01f, 5.11817075e-02f, 2.00217113e-01f, -2.05862582e-01f, 6.76527917e-02f, 4.95456019e-03f, -1.42139658e-01f, -7.79507607e-02f,
  6.47597685e-02f, 7.79320896e-02f, 2.80582868e-02f, -8.38356167e-02f, 6.23077154e-02f, -3.16047892e-02f, 9.46556479e-02f, -5.64337708e-02f, -2.46354081e-02f, 1.19619220e-01f,
  9.78843048e-02f, -1.72616243e-02f, 3.73091498e-05f, 4.86386335e-03f, -3.57412174e-02f, 8.83402396e-03f, -1.82006322e-02f, 9.06535760e-02f, 1.21203382e-02f, -6.39427453e-02f,
  -4.34066206e-02f, 2.71505956e-02f, 8.75504985e-02f, 1.79284588e-02f, -2.94490829e-02f, 3.77724506e-02f, -3.06047108e-02f, -4.01199237e-02f, -1.97467878e-02f, -4.27533910e-02f,
  -5.77561446e-02f, -6.71819746e-02f, -2.37523019e-02f, -4.64591794e-02f, -1.06910408e-01f, -7.06301164e-03f, 7.08333449e-03f, -5.80574684e-02f, -1.43369511e-02f, 5.62359113e-04f,
  -9.08122063e-02f, 2.45354623e-02f, 3.27154249e-02f, 5.22463098e-02f, 1.65534299e-02f, -2.99712811e-02f, 1.33613730e-02f, -3.21056023e-02f, -2.71532014e-02f, -1.80871505e-02f,
  -6.01647645e-02f, 6.40405267e-02f, -4.43032086e-02f, 5.09692840e-02f, 5.79793705e-03f, -6.13490911e-03f, 5.44291735e-02f, -2.11564954e-02f, -4.55944277e-02f, 1.13186694e-03f,
  3.02939042e-02f, -1.39359564e-01f, 1.62187088e-02f, -2.55687218e-02f, 2.62588356e-02f, 5.29688634e-02f, -4.79783937e-02f, -3.79314497e-02f, -3.96798179e-02f, 3.03898053e-03f,
  -1.73643157e-01f, -2.75904149e-01f, 2.37198379e-02f, 3.42258997e-02f, 5.91831887e-03f, -4.49103080e-02f, -3.26030068e-02f, -5.79513423e-02f, -4.58294377e-02f, 4.10747435e-03f,
  -5.48268780e-02f, -2.60606818e-02f, -2.34934725e-02f, 2.03279108e-02f, 5.01270033e-02f, -4.82090004e-02f, -1.15396250e-02f, 2.44755447e-02f, -2.74490640e-02f, -5.96639290e-02f,
  4.85650357e-03f, -1.77915692e-02f, 1.56275388e-02f, 2.33791210e-02f, -1.27136018e-02f, -7.77312294e-02f, -1.78561453e-02f, 7.90080503e-02f, -1.06057823e-02f, -5.00071980e-02f,
  3.60369116e-01f, 1.63132727e-01f, -1.10233843e-01f, 1.22530730e-02f, -5.27921729e-02f, 1.70664322e-02f, 1.35136098e-01f, -7.93305635e-02f, 1.19421296e-01f, 7.90470168e-02f,
  2.79896051e-01f, 1.28531814e-01f, 9.80666131e-02f, 1.69404507e-01f, 8.82419944e-02f, 1.62709311e-01f, 1.17345504e-01f, 2.04361975e-01f, 3.53133343e-02f, 9.87400115e-02f,
  6.24303194e-03f, 8.58068690e-02f, -8.63576457e-02f, -1.42374545e-01f, 2.06031222e-02f, -1.49112880e-01f, -8.80831480e-02f, -1.28399268e-01f, 4.58961986e-02f, -9.89617929e-02f,
  2.11053751e-02f, 5.00030294e-02f, 4.51044850e-02f, -4.13663052e-02f, 7.31008053e-02f, -2.15664264e-02f, 4.52999733e-02f, -4.90685105e-02f, -3.51102464e-02f, -7.48479217e-02f,
  9.73470658e-02f, -9.82779115e-02f, -2.81736930e-03f, -6.64827526e-02f, -5.29408529e-02f, 1.50334723e-02f, -1.74968187e-02f, -1.36648482e-02f, 1.40445093e-02f, 1.51722843e-03f,
  9.80164930e-02f, 3.08531132e-02f, 7.36540705e-02f, -2.96108369e-02f, -3.02620493e-02f, 2.23915949e-02f, -3.44043784e-02f, 6.58062771e-02f, 1.76982339e-02f, 3.79356206e-03f,
  -2.71124411e-02f, 6.98872060e-02f, -1.67969931e-02f, -2.58383602e-02f, 2.73839943e-02f, -3.11898859e-03f, -8.66722502e-03f, 6.74702153e-02f, -1.56239243e-02f, 7.58259892e-02f,
  6.20707087e-02f, -3.01046167e-02f, 6.05802350e-02f, -4.85578291e-02f, 1.09474929e-02f, 6.36760816e-02f, 7.89596438e-02f, -3.98183204e-02f, 1.35391941e-02f, 4.40897532e-02f,
  -3.53493467e-02f, 2.97662523e-03f, -3.56696732e-02f, -2.05030814e-02f, 4.65108640e-02f, -1.78309362e-02f, -8.03156663e-03f, 4.73697297e-03f, -2.00799890e-02f, 6.65549515e-03f,
  1.27654925e-01f, 8.19792077e-02f, -1.69882644e-02f, 5.61411232e-02f, -4.15910129e-03f, 5.04861958e-02f, -2.34981105e-02f, -2.34392788e-02f, 3.59280482e-02f, 1.12670865e-02f,
  -6.20235130e-02f, -7.61207798e-03f, 9.95820854e-03f, -2.60647070e-02f, 4.67830785e-02f, 2.08160616e-02f, 2.15370916e-02f, 3.30226938e-03f, 4.98685613e-02f, 4.85490225e-02f,
  -6.91502243e-02f, 8.50819610e-03f, -1.85444336e-02f, -5.34445122e-02f, 9.36564431e-02f, 7.39594502e-03f, -1.81482174e-02f, -4.88288477e-02f, -1.78471748e-02f, 4.58615925e-03f,
  -8.87470245e-02f, -1.81399006e-02f, -1.55615419e-01f, 8.09373036e-02f, -2.25729316e-01f, -1.29765600e-01f, 1.51245221e-02f, -5.16928434e-02f, 1.26762837e-01f, 2.84972638e-01f,
  5.55801578e-03f, -6.94673955e-02f, 1.89493611e-01f, 7.99470916e-02f, -6.96932226e-02f, 2.24663630e-01f, 3.77262793e-02f, 1.06030099e-01f, 1.42146917e-02f, -5.94809838e-02f,
  -2.27821176e-03f, -1.91746037e-02f, 2.97618303e-02f, -8.65826681e-02f, -1.95296541e-01f, -8.25346797e-05f, 4.38637137e-02f, -2.30219781e-01f, -5.67004308e-02f, -1.32338881e-01f,
  6.25048876e-02f, 4.77311164e-02f, 3.45367976e-02f, 1.67470798e-02f, -9.11200494e-02f, 4.62159514e-02f, 6.00473620e-02f, -3.32038924e-02f, -2.54551731e-02f, 5.56916036e-02f,
  4.14859876e-02f, -2.17533167e-02f, -4.01448272e-02f, -1.71575195e-03f, -4.37539108e-02f, -5.45490719e-02f, -4.83633578e-02f, 4.08675633e-02f, -1.78386271e-02f, -2.49148179e-02f,
  -3.08186840e-02f, 2.42798980e-02f, -3.13088931e-02f, 5.15729263e-02f, -1.00511156e-01f, -3.97995003e-02f, -1.53092286e-02f, -8.85655433e-02f, -6.23993725e-02f, -8.17563981e-02f,
  3.96502912e-02f, 9.23769474e-02f, 3.18281800e-02f, -5.97624779e-02f, -7.49097541e-02f, -4.29985300e-02f, -4.01294269e-02f, 1.28463292e-02f, -3.91257480e-02f, -3.01938262e-02f,
  1.73855890e-02f, 7.29261711e-03f, -1.93959083e-02f, 7.22792223e-02f, 4.92167212e-02f, 3.45179364e-02f, 8.18410423e-03f, 1.75386183e-02f, -9.64814350e-02f, 4.95996587e-02f,
  2.88506504e-02f, -2.87159514e-02f, 6.71524778e-02f, 5.85280508e-02f, -5.64427674e-03f, -7.44835800e-03f, -3.93283330e-02f, 6.96120113e-02f, -3.94204333e-02f, 5.23041338e-02f,
  1.39671210e-02f, 1.43868178e-02f, -1.98153649e-02f, -7.82744735e-02f, 8.36922899e-02f, -1.32297613e-02f, -4.58412850e-03f, -9.31976922e-03f, 9.04966798e-03f, -5.75819090e-02f,
  -2.61114947e-02f, 6.95769442e-03f, 2.19059289e-02f, 2.31911577e-02f, 3.26927267e-02f, 1.00568011e-02f, -4.53749038e-02f, -1.22715738e-02f, -5.84102981e-03f, -3.58949904e-03f,
  -3.09045017e-02f, -2.79621407e-03f, 1.10300213e-01f, -3.09731122e-02f, 8.82513374e-02f, 4.27338444e-02f, 9.00107436e-03f, -8.44894797e-02f, -1.89958345e-02f, -5.44815464e-03f,
  -6.56346455e-02f, -2.68988341e-01f, -6.28854930e-02f, 1.82942823e-02f, 4.00963537e-02f, -2.30436847e-01f, -5.06199718e-01f, -3.83830667e-02f, -1.55956402e-01f, -2.23578051e-01f,
  -1.68404207e-01f, 1.52042106e-01f, -1.88007161e-01f, -6.51925728e-02f, 1.72282100e-01f, -1.70620292e-01f, 3.66764702e-02f, 3.42914811e-03f, 5.08933328e-02f, -6.54239254e-03f,
  1.09784521e-01f, 9.52641591e-02f, 1.76614657e-01f, 5.96521087e-02f, 7.57694477e-03f, 3.18823382e-02f, 2.61459649e-01f, 7.88459089e-03f, 9.12847221e-02f, 1.02546126e-01f,
  -3.62100452e-02f, 1.10442843e-02f, 2.40950249e-02f, 2.54133306e-02f, -5.70050962e-02f, 1.29282568e-02f, 4.81383875e-02f, 2.28062402e-02f, 8.27875063e-02f, 5.80174178e-02f,
  4.24059257e-02f, -1.60019509e-02f, -2.20518354e-02f, 1.05091957e-02f, -5.04937358e-02f, 1.19113596e-02f, 1.74908191e-02f, -1.57648721e-03f, -3.18773575e-02f, -1.21330936e-02f,
  -2.51684859e-02f, 1.46408072e-02f, 3.92379090e-02f, -2.89198048e-02f, -6.06825352e-02f, -2.07849815e-02f, -2.64000688e-02f, -1.44997500e-02f, 7.77907968e-02f, 3.16106305e-02f,
  -7.04352036e-02f, -1.08455606e-02f, -1.37528911e-01f, 3.71031351e-02f, 3.64043973e-02f, -3.42092104e-02f, -2.60079256e-03f, 4.50685434e-02f, 9.25476663e-03f, -4.00684774e-02f,
  -3.53410654e-02f, 4.79493216e-02f, 3.73024978e-02f, 6.10628119e-03f, -6.65205671e-03f, -1.54454063e-03f, 4.60761003e-02f, 4.12531011e-02f, -4.37749662e-02f, -4.79817763e-02f,
  -4.67887707e-02f, 3.79031077e-02f, -1.13230065e-01f, -5.92262633e-02f, -3.37727293e-02f, -5.59758954e-02f, 4.18107659e-02f, -1.38452500e-02f, 1.71114244e-02f, -4.33372594e-02f,
  -1.33625744e-02f, 9.77951363e-02f, -6.11414872e-02f, 1.20886713e-02f, -1.32476715e-02f, -1.59115940e-02f, -4.63921390e-02f, 2.80264765e-02f, 1.81631818e-02f, 4.38899286e-02f,
  4.66766506e-02f, 7.21597066e-03f, -8.48060846e-03f, -5.15920892e-02f, 6.94105104e-02f, -3.27268802e-02f, 1.15221948e-03f, -2.12440682e-05f, 4.59243841e-02f, 9.49324518e-02f,
  -5.24046645e-02f, -5.51411475e-04f, 5.47721470e-03f, -4.46342677e-02f, 4.00985740e-02f, -7.32456446e-02f, -1.98681783e-02f, -1.85342189e-02f, -6.33128285e-02f, 9.68544744e-03f,
  9.72734317e-02f, -2.64998138e-01f, -2.64488071e-01f, -2.18683839e-01f, 6.95164576e-02f, -3.73641968e-01f, -2.25270942e-01f, 1.30987738e-03f, 1.26690671e-01f, 7.11316764e-02f,
  -1.51514262e-02f, 4.38777581e-02f, 1.25053003e-01f, -1.86334878e-01f, -1.03245251e-01f, 3.56189720e-02f, -3.40390533e-01f, -2.15701997e-01f, 7.66423717e-03f, -2.11752608e-01f,
  -1.93512291e-02f, -5.51377311e-02f, -1.43659890e-01f, -7.76236132e-02f, -2.01646507e-01f, 2.28114184e-02f, 4.30795476e-02f, -2.85388785e-03f, -1.14952922e-01f, 6.28632233e-02f,
  8.51720199e-02f, 2.67756343e-01f, 5.13578206e-02f, 6.31508976e-02f, -7.15958104e-02f, -7.93454126e-02f, -3.57077383e-02f, 8.64517987e-02f, 1.25320882e-01f, 1.54889980e-02f,
  -2.80263890e-02f, -1.02337860e-02f, -4.04962599e-02f, 3.20526026e-02f, -3.08992621e-02f, 2.02278644e-02f, -6.88873380e-02f, -8.92305896e-02f, 3.42595577e-02f, -1.03308082e-01f,
  -2.68854829e-03f, -5.04560024e-02f, -1.09093957e-01f, 3.81247029e-02f, -3.88678238e-02f, 4.85237539e-02f, 1.65826841e-05f, -3.20405401e-02f, 3.07892822e-02f, -1.70048214e-02f,
  -1.56054437e-01f, 3.26394439e-02f, -8.13964978e-02f, 8.32662880e-02f, -2.87105404e-02f, 9.13106799e-02f, -8.51389989e-02f, 2.53524873e-02f, 2.82309260e-02f, -2.01253383e-03f,
  -4.66237999e-02f, 5.69549464e-02f, -6.56516105e-03f, -6.50048107e-02f, -3.84191982e-02f, -1.40594803e-02f, 4.21483703e-02f, 1.83888525e-02f, -6.16903193e-02f, -4.18405458e-02f,
  5.81420735e-02f, -2.73818076e-02f, -6.33312091e-02f, -1.47774499e-02f, 5.54256421e-03f, 1.42361252e-02f, 5.03722299e-03f, -2.76374221e-02f, -3.68872820e-03f, -2.66147032e-02f,
  -2.16598094e-01f, -1.16360202e-01f, 1.31008727e-02f, 2.23008711e-02f, -4.03888933e-02f, -2.67260335e-02f, 3.74147184e-02f, -6.13469370e-02f, -9.02834833e-02f, -9.86058731e-03f,
  -9.41988751e-02f, 4.53495942e-02f, -2.46085301e-02f, -1.73405148e-02f, -1.43752191e-02f, -1.89312771e-02f, 8.26807767e-02f, 4.78325412e-02f, -9.80583280e-02f, -8.23792666e-02f,
  -1.47495298e-02f, 1.65165327e-02f, 5.51178865e-02f, -3.76715884e-02f, -3.07775475e-02f, -6.33883029e-02f, -2.27814484e-02f, 1.87277663e-02f, -7.33511150e-02f, -5.75354397e-02f,
  -2.44070664e-02f, 1.14664271e-01f, -2.57314034e-02f, -9.10909555e-04f, -1.07606009e-01f, 1.20653331e-01f, -5.57644069e-02f, 4.48964499e-02f, 1.71876606e-02f, 1.15729645e-01f,
  -1.49571374e-02f, 7.79524865e-03f, -4.39018570e-02f, 3.87834907e-02f, 6.72272369e-02f, 1.51806936e-01f, 7.90407807e-02f, 2.05697883e-02f, -8.14895332e-02f, -4.17558178e-02f,
  -1.49446473e-01f, -2.30454430e-01f, -7.81250093e-03f, -1.90436780e-01f, -6.84020743e-02f, 2.57869437e-03f, -9.80144516e-02f, -1.10695519e-01f, -7.86660686e-02f, -1.12489626e-01f,
  -2.38794405e-02f, -5.84190385e-03f, 4.44643386e-02f, -1.02487609e-01f, -6.48029745e-02f, 1.93480775e-02f, -4.44447659e-02f, -8.77430886e-02f, -5.73819466e-02f, -5.06312214e-02f,
  -2.28121947e-03f, 4.93136086e-02f, 1.14262337e-02f, -1.56851765e-02f, -1.57130379e-02f, 3.19357216e-02f, 9.20908675e-02f, -8.37915763e-02f, -3.04231104e-02f, 4.53445949e-02f,
  3.01832035e-02f, 3.38721238e-02f, -5.01257367e-02f, -4.26865183e-02f, -3.47924745e-03f, 3.60740051e-02f, 1.84857715e-02f, 5.09398431e-02f, -3.63837951e-03f, -2.18455791e-02f,
  8.03294405e-03f, -6.94563463e-02f, -3.89055982e-02f, 5.75718023e-02f, 2.28853635e-02f, -3.13027315e-02f, -5.99663658e-03f, -2.74624396e-02f, 6.41495362e-02f, 2.77427156e-02f,
  -1.07532613e-01f, 3.39840390e-02f, 6.04186505e-02f, 1.37681849e-02f, 3.37194614e-02f, 2.30328343e-03f, -7.53255095e-03f, 7.31722862e-02f, 4.11536098e-02f, 5.40544763e-02f,
  6.66093081e-03f, -6.44599572e-02f, -2.40303203e-02f, -2.11635828e-02f, -5.34683503e-02f, 6.67600259e-02f, -2.06805021e-02f, -6.39714524e-02f, 1.05674356e-01f, 1.40327066e-02f,
  8.68460387e-02f, -1.08058646e-01f, -6.51505813e-02f, 7.62482062e-02f, 7.30686486e-02f, 5.83934523e-02f, -5.82144409e-03f, -3.04234661e-02f, 1.14611154e-02f, -5.60059920e-02f,
  3.11530121e-02f, 2.47417912e-02f, -4.36390191e-02f, -3.04271327e-03f, -1.72821488e-02f, 4.00406867e-02f, 5.95975854e-02f, 2.82169748e-02f, 2.69420655e-03f, -4.53800298e-02f,
  -1.36191621e-01f, -4.39607240e-02f, -6.93404004e-02f, 1.57921016e-02f, 2.82002520e-02f, -2.62485072e-02f, 5.55919074e-02f, 2.01141592e-02f, -1.07674282e-02f, 5.91276959e-02f,
  -6.52662888e-02f, -2.06581205e-02f, -1.21186346e-01f, -3.02858979e-01f, 4.94819023e-02f, -8.36234614e-02f, -1.66420281e-01f, -9.72816199e-02f, 2.47348491e-02f, -1.87690929e-01f,
  -2.48556480e-01f, -8.54690894e-02f, 8.79563391e-02f, -2.50620455e-01f, 8.97836462e-02f, 1.70234442e-01f, -2.60750502e-01f, -1.56890050e-01f, 2.29556769e-01f, -1.61585942e-01f,
  -4.21702415e-02f, -2.61215806e-01f, -3.60136405e-02f, 3.26437056e-02f, -1.88115045e-01f, -1.01694554e-01f, 2.49062628e-02f, 4.28342707e-02f, -1.93811715e-01f, 8.13824609e-02f,
  -6.04351461e-02f, -4.47053760e-02f, -1.43423721e-01f, 1.36124855e-02f, -1.69942871e-01f, 3.50445956e-02f, -9.22826305e-02f, -2.96047516e-02f, -6.65015131e-02f, -2.80546863e-02f,
  -2.82462090e-02f, 2.86954455e-02f, 3.95670049e-02f, 1.21138178e-01f, -5.68289310e-02f, -8.66899863e-02f, -7.92100728e-02f, 7.53199011e-02f, 9.13139433e-03f, 4.43939567e-02f,
  -5.50226197e-02f, -1.45247560e-02f, -5.35312183e-02f, -1.31424544e-02f, 3.29614505e-02f, -4.04271744e-02f, 1.64324120e-02f, 5.23465723e-02f, -9.39359423e-03f, 4.19949815e-02f,
  -3.29102948e-02f, -3.03628612e-02f, 5.04277870e-02f, -2.37639230e-02f, 4.07340974e-02f, 2.79222112e-02f, 3.60790850e-03f, 6.38919398e-02f, -2.04297546e-02f, -4.68958961e-03f,
  -3.38123403e-02f, -4.90227714e-02f, 2.38979626e-02f, 4.33583697e-03f, -6.79364353e-02f, 3.77227776e-02f, 7.19290301e-02f, -3.63064595e-02f, 1.37270316e-02f, -3.18017192e-02f,
  -9.10482407e-02f, -3.69747914e-02f, -1.94639955e-02f, -5.26332073e-02f, 6.04979731e-02f, 5.18996157e-02f, -6.95708320e-02f, -1.96816698e-02f, -4.01508063e-03f, -8.12351704e-02f,
  2.96553187e-02f, -1.53173104e-01f, 2.23412793e-02f, 6.74127275e-03f, 5.56775331e-02f, -4.04376723e-02f, 1.18036673e-03f, 9.77753848e-03f, 2.80363653e-02f, 4.45767492e-02f,
  -2.85382643e-02f, -9.01688784e-02f, -1.68435629e-02f, 1.52296452e-02f, 3.46762538e-02f, 1.78106055e-02f, -1.34046152e-02f, -1.19981736e-01f, 4.53341287e-03f, 7.23660886e-02f,
  -2.62508318e-02f, 5.17629758e-02f, 9.16228537e-03f, -2.71950569e-02f, 2.56421752e-02f, -5.68345226e-02f, 4.70071770e-02f, 4.32030670e-02f, -1.49465986e-02f, 1.36820851e-02f,
  8.68197918e-01f, -2.23524824e-01f, 1.40661716e-01f, 3.84146750e-01f, 2.62777478e-01f, -3.51501852e-01f, 2.03342006e-01f, 8.15700665e-02f, 1.33624449e-01f, -1.19342402e-01f,
  1.53131127e-01f, -1.28039271e-01f, 5.81471855e-03f, 2.61439532e-02f, 2.00588763e-01f, 1.05222100e-02f, 8.35534483e-02f, -2.80134361e-02f, -4.34898175e-02f, 3.77339609e-02f,
  1.26360938e-01f, 1.16622552e-01f, 1.85228273e-01f, 8.13661963e-02f, 1.08514637e-01f, 6.82877153e-02f, 1.19079754e-01f, 2.62110047e-02f, -2.06980724e-02f, -2.77803391e-02f,
  -2.14551035e-02f, 8.96955132e-02f, 4.93904054e-02f, -7.64502585e-02f, 1.35069499e-02f, 3.85695100e-02f, -7.49622658e-02f, 5.38999438e-02f, 4.21845056e-02f, -1.41247055e-02f,
  -8.18862915e-02f, -2.39153281e-02f, -4.93200049e-02f, 4.11707759e-02f, -1.62082445e-02f, 5.91492048e-03f, -7.48041039e-03f, -1.06182471e-02f, -3.11210994e-02f, -1.79624166e-02f,
  3.56671214e-02f, 7.11938292e-02f, -1.42954234e-02f, -5.28602377e-02f, 1.00039922e-01f, -1.23064946e-02f, -2.78059356e-02f, -1.40614267e-02f, -2.79546045e-02f, -2.82570403e-02f,
  9.75242630e-02f, -6.58317804e-02f, -3.43359374e-02f, -2.99579650e-02f, 2.57029831e-02f, 2.86432598e-02f, -2.71250103e-02f, 4.64919358e-02f, 2.68218629e-02f, 3.36509682e-02f,
  3.02473325e-02f, 5.20511903e-02f, -9.56976553e-04f, -1.32285627e-02f, 3.37923616e-02f, -6.41239882e-02f, -4.01815437e-02f, -2.05741860e-02f, 5.47141992e-02f, -1.58794988e-02f,
  5.35795791e-03f, 4.42790836e-02f, 4.05580029e-02f, 5.47869764e-02f, -3.14891338e-02f, 2.09197402e-02f, 1.67939290e-02f, -7.76987430e-03f, 1.26184952e-02f, 3.35207917e-02f,
  -3.12736183e-01f, -1.45712331e-01f, 4.32048067e-02f, 9.29269660e-03f, -5.93821928e-02f, 1.65068023e-02f, 3.63915972e-02f, -5.60545921e-03f, -9.49711800e-02f, 4.16785069e-02f,
  2.24601869e-02f, 7.19074234e-02f, -2.59127319e-02f, 9.44493152e-03f, 1.07248370e-02f, -9.93181486e-03f, -9.23200790e-03f, -6.61344221e-03f, 1.80787034e-02f, 3.63492519e-02f,
  -6.21527527e-03f, -1.20603461e-02f, 3.12558860e-02f, 1.39879913e-03f, -3.08672320e-02f, 8.36433694e-02f, -4.89734299e-03f, 1.92776415e-02f, 2.53828038e-02f, 9.27037792e-04f,
  1.99130066e-02f, 9.77993309e-02f, -1.21779986e-01f, 1.14026971e-01f, -1.85556840e-02f, 1.20328907e-02f, -1.78446159e-01f, 1.54696122e-01f, -1.47793189e-01f, 1.25251338e-01f,
  -1.75734553e-02f, 3.74502875e-02f, -1.41284704e-01f, 1.82096317e-01f, -7.17047974e-03f, -1.12500258e-01f, -1.41860954e-02f, -6.24886751e-02f, -1.01883128e-01f, 9.61402878e-02f,
  -5.47770448e-02f, 2.43855819e-01f, -5.99674275e-03f, 1.44648612e-01f, 2.12076172e-01f, 1.17381118e-01f, 2.14617312e-01f, -3.36312316e-02f, 2.15417117e-01f, 1.28739953e-01f,
  9.76986811e-02f, 3.13347839e-02f, -5.91819584e-02f, 5.37509806e-02f, 1.65978167e-02f, 1.70916214e-03f, -3.14993225e-02f, -3.89465913e-02f, -4.59782630e-02f, -3.44529636e-02f,
  7.70929307e-02f, 2.96106562e-03f, 8.60173702e-02f, -4.80103418e-02f, -5.31565100e-02f, -8.80389288e-03f, 2.16079652e-02f, 4.38672192e-02f, -1.37132276e-02f, -4.96195890e-02f,
  -7.10242391e-02f, 3.94437322e-03f, -4.28309813e-02f, 6.29959181e-02f, -1.36733549e-02f, -1.17495731e-02f, 4.64048982e-02f, -7.09850714e-02f, 7.02832714e-02f, -5.88450804e-02f,
  6.34950846e-02f, 3.07079591e-02f, 1.00337118e-01f, 5.34144118e-02f, 4.74163555e-02f, 8.47391505e-03f, 5.84888943e-02f, -2.94291880e-02f, 4.88221310e-02f, 6.70398548e-02f,
  -4.13550846e-02f, 1.96534619e-02f, 3.93024422e-02f, 3.79348435e-02f, 5.63142784e-02f, -1.37322219e-02f, 4.76714112e-02f, 3.43354046e-02f, -1.50909433e-02f, -6.44028112e-02f,
  -1.52751990e-02f, 2.03986093e-02f, 3.35233398e-02f, -5.52710369e-02f, 2.86823772e-02f, -5.17930314e-02f, 5.83818853e-02f, -6.94553088e-03f, 3.76249067e-02f, 3.84553731e-03f,
  5.39569557e-02f, 1.71060577e-01f, 3.81734897e-03f, -4.45479080e-02f, -5.63882403e-02f, 1.54324360e-02f, 4.13303748e-02f, 1.11131564e-01f, 5.29389307e-02f, -1.79368723e-02f,
  9.17106774e-03f, 2.19604466e-02f, 8.03681910e-02f, 6.47855252e-02f, 2.80155353e-02f, -6.36993349e-02f, 1.17353894e-01f, -2.37166788e-02f, 5.37717082e-02f, 3.92243490e-02f,
  8.53056833e-02f, 2.98251677e-02f, -4.00314070e-02f, 6.43692538e-02f, 2.04394367e-02f, -2.96847802e-02f, -2.01378129e-02f, -6.25339011e-03f, 5.32931648e-03f, -3.26231644e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  -3.56317759e-01f, 3.24055068e-02f, 9.62867737e-02f, 7.76174888e-02f, -3.85544002e-02f, -1.55925572e-01f, -4.07811534e-03f, 1.94532290e-01f, 9.05287936e-02f, -3.46669221e-05f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.67596871e-01f, -2.10166171e-01f, 8.20095614e-02f, -1.87286362e-01f, 2.50879884e-01f, -4.22858477e-01f, 1.62620693e-01f, -5.94379231e-02f, -1.52711153e-01f, 3.63236547e-01f,
  3.90830278e-01f, 5.99775650e-02f, 1.74915314e-01f, 3.12348306e-01f, -1.45513758e-01f, 6.97171465e-02f, -1.45244375e-01f, 1.88204780e-01f, -1.38713866e-01f, 2.22599551e-01f,
  -3.09362896e-02f, 1.68839132e-03f, 5.91597795e-01f, -9.32278112e-02f, -1.61066562e-01f, 3.99523787e-02f, -2.44076729e-01f, 1.22123323e-01f, 2.02276871e-01f, 1.18797109e-01f,
  -6.65401399e-01f, -1.32656142e-01f, -1.43016145e-01f, 2.12853014e-01f, -7.90614933e-02f, -4.03742939e-01f, -4.66023356e-01f, 5.31088300e-02f, -7.79398233e-02f, 1.69553950e-01f,
  3.95326346e-01f, 2.70511955e-01f, -1.71588525e-01f, -3.13032448e-01f, 2.88358271e-01f, -2.66936183e-01f, 5.64697921e-01f, 3.37880522e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.59564638e-01f, 2.79983968e-01f, 1.55337065e-01f, -2.12654322e-01f, -3.25151861e-01f, 4.04893398e-01f, 3.23633552e-01f, -9.69417393e-02f, 1.09560989e-01f, -2.33304843e-01f,
  -3.51518631e-01f, 2.98183680e-01f, -1.47234157e-01f, 2.10891917e-01f, 6.60716072e-02f, -1.03365205e-01f, 2.26466190e-02f, 1.18755311e-01f, -1.83748957e-02f, -1.67683318e-01f,
  1.23738073e-01f, 6.66403472e-02f, 3.33784670e-01f, -1.65510461e-01f, 1.15296148e-01f, 4.24623370e-01f, -2.62748986e-01f, 6.92621022e-02f, 1.57326180e-02f, -2.66387224e-01f,
  -2.81722426e-01f, -4.59258370e-02f, -8.04098397e-02f, 2.38388404e-01f, -2.89006710e-01f, -4.46590632e-02f, -1.71646774e-01f, 3.84090036e-01f, 1.28181353e-01f, -2.19474569e-01f,
  5.28051592e-02f, 1.34759203e-01f, -1.77065492e-01f, 4.52574827e-02f, 1.08699091e-01f, 1.37795433e-01f, 2.62447566e-01f, -4.46384065e-02f, 2.49646455e-01f, 4.81254309e-01f,
  -3.31523307e-02f, -1.36848778e-01f, 2.51630902e-01f, 5.54189563e-01f, 6.12010062e-01f, -3.10309045e-02f, 1.55442610e-01f, 1.07889056e-01f, -4.95165288e-01f, 8.43286961e-02f,
  -1.39872059e-01f, -1.54985592e-01f, -2.40831748e-01f, -6.21265173e-03f, 4.25339222e-01f, 2.85627365e-01f, 2.88436394e-02f, -2.16453485e-02f, -3.46406579e-01f, 3.77760202e-01f,
  -5.95372319e-01f, 6.24419808e-01f, 3.63247514e-01f, -1.48237929e-01f, 2.05149382e-01f, 1.73104904e-03f, 6.22214973e-02f, 3.21245164e-01f, 1.62670225e-01f, 8.09348095e-03f,
  -1.41429722e-01f, -2.35161304e-01f, 2.06752583e-01f, 5.17204702e-01f, -2.44061574e-01f, -4.19366568e-01f, 2.71308962e-02f, -1.06583320e-01f, -1.38635794e-02f, 2.84196377e-01f,
  3.77651453e-02f, 5.40037870e-01f, -1.45129502e-01f, 4.13691998e-01f, -1.08461142e-01f, 8.29921737e-02f, 2.27509290e-01f, 7.56760612e-02f, -4.70745489e-02f, 1.24951713e-01f,
  -4.20849234e-01f, 2.56597936e-01f, -2.98310339e-01f, -1.43334314e-01f, -3.58626246e-02f, 1.19122947e-02f, 1.40474901e-01f, 2.71776170e-01f, 2.38779098e-01f, 2.70502985e-01f,
  1.83230832e-01f, -3.28171521e-01f, 1.92265391e-01f, -2.29315594e-01f, 2.74115562e-01f, -2.28609130e-01f, 2.44945824e-01f, 7.21143484e-02f, -1.32008463e-01f, 3.40085089e-01f,
  -2.96253294e-01f, -8.28997567e-02f, 2.95031071e-01f, -2.16902882e-01f, 8.40580389e-02f, -2.11207777e-01f, 1.72894388e-01f, 3.09766054e-01f, 3.66765112e-01f, 2.62389421e-01f,
  -9.40608829e-02f, -4.06420380e-02f, 3.64588946e-02f, 4.13849503e-01f, 1.93258747e-01f, -1.12556212e-01f, -2.05848664e-01f, 2.31423751e-01f, 1.95808992e-01f, 3.52955073e-01f,
  1.66510269e-01f, 1.39516488e-01f, -2.68581152e-01f, -3.72030944e-01f, -2.84855068e-01f, -5.78737855e-02f, 6.33288361e-03f, 3.33538651e-01f, -1.29563883e-01f, -4.75106761e-02f,
  1.59056529e-01f, -2.85618126e-01f, 1.18165880e-01f, -1.27897248e-01f, 1.37990177e-01f, 5.26991129e-01f, -9.06219631e-02f, 4.38922912e-01f, 1.57945111e-01f, 2.37299398e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  3.66879046e-01f, 1.90763414e-01f, 3.30291279e-02f, 4.78042811e-01f, -2.01104525e-02f, -1.40518844e-01f, 1.83785573e-01f, -1.31544456e-01f, 1.69376299e-01f, 1.04268759e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.29864439e-01f, -6.00130530e-03f, 1.38036340e-01f, 4.89197880e-01f, 3.86212826e-01f, -1.01914734e-01f, -2.47692868e-01f, 3.21605653e-01f, -3.52309704e-01f, 1.14665627e-01f,
  -5.94504416e-01f, 2.45573401e-01f, -4.85807747e-01f, 1.91414617e-02f, -1.51981652e-01f, 2.99673140e-01f, -4.74891663e-02f, 4.16500956e-01f, 9.71154869e-02f, 4.42409851e-02f,
  4.13114369e-01f, -3.10666203e-01f, -1.82676062e-01f, -1.81996286e-01f, -3.09270155e-02f, 6.13716431e-02f, -5.69914758e-01f, 2.92088360e-01f, -1.36923313e-01f, -1.95556179e-01f,
  2.01053232e-01f, 3.64069313e-01f, -8.75611510e-03f, 1.67910352e-01f, 3.02398980e-01f, 7.09417939e-01f, 5.63365459e-01f, -4.55452919e-01f, -8.37185681e-02f, -6.62563145e-02f,
  -5.66155836e-02f, -2.34659493e-01f, -5.92369616e-01f, 3.78068179e-01f, -3.35499316e-01f, 3.08196485e-01f, 8.43353719e-02f, 8.24770033e-02f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  7.11483002e-01f, 2.78114200e-01f, 6.75917506e-01f, 6.50408089e-01f, -7.71712899e-01f, 8.68575871e-01f, -2.41823912e-01f, 1.79051414e-01f, -2.72379279e-01f, -3.98274928e-01f,
  3.86021256e-01f, -6.64185062e-02f, -1.77298114e-01f, 5.66634178e-01f, -4.36275274e-01f, 1.95461392e-01f, 3.40339869e-01f, 2.70194799e-01f, 1.73664570e-01f, -9.59342048e-02f,
  4.00876701e-01f, -5.41457057e-01f, -4.31225821e-02f, -3.40926617e-01f, -1.79458573e-01f, 6.88238218e-02f, -1.25873730e-01f, 2.55986542e-01f, -5.52971102e-02f, 1.03072681e-01f,
  -1.21028975e-01f, 2.25209922e-01f, 8.86205435e-01f, 7.83537209e-01f, 2.70886332e-01f, 5.82340322e-02f, 6.41808510e-01f, -3.49733055e-01f, 7.74985671e-01f, 2.71113932e-01f,
  9.15930420e-02f, 1.10920644e+00f, 7.61872306e-02f, -3.79926004e-02f, -2.39150561e-02f, -1.80506602e-01f, 4.71505672e-01f, 2.65512526e-01f, 1.03853464e-01f, -2.30198398e-01f,
  -2.43890416e-02f, -9.16357264e-02f, 2.14493573e-01f, -2.13589631e-02f, -1.35380462e-01f, 1.30767927e-01f, -8.58814493e-02f, 1.72621757e-02f, -2.12007731e-01f, 5.62283769e-03f,
  -1.80987731e-01f, 1.40481687e-03f, -1.76700503e-01f, -1.99001089e-01f, -1.38429418e-01f, 3.27088177e-01f, 6.03518069e-01f, 1.11906372e-01f, 2.70435959e-01f, -7.86248446e-01f,
  9.05601680e-02f, -3.32909971e-01f, 6.73503382e-03f, -3.68862003e-01f, 2.09905624e-01f, 8.15993369e-01f, 4.47468042e-01f, 1.66283026e-01f, 3.98553133e-01f, 4.56829369e-01f,
  1.78538989e-02f, -1.13431692e-01f, -4.14991714e-02f, 2.42668003e-01f, 2.41970301e-01f, -2.18088418e-01f, 1.38581861e-02f, -7.68707618e-02f, 6.91706762e-02f, 2.72020530e-02f,
  1.89640507e-01f, -1.82298437e-01f, -5.64151295e-02f, 1.68891728e-01f, -2.04682410e-01f, -9.33841169e-02f, 1.26928329e-01f, -2.78470546e-01f, 1.42302969e-02f, 5.76090328e-02f,
  1.18383177e-01f, 2.56151855e-01f, -2.24437162e-01f, 1.89099032e-02f, -3.24067399e-02f, -5.53992093e-02f, 4.18411195e-02f, 1.47284016e-01f, -2.51921028e-01f, 2.43647918e-01f,
  -8.92120674e-02f, -2.26820752e-01f, 4.53865342e-02f, 3.65741193e-01f, 3.03040445e-01f, 6.20888285e-02f, 2.41714284e-01f, 3.48452985e-01f, -1.31200537e-01f, 3.74125123e-01f,
  -6.24099933e-03f, -2.64937989e-02f, -1.57346383e-01f, -1.89720929e-01f, 2.35267863e-01f, 9.58425328e-02f, 3.69267464e-01f, -2.50799954e-01f, -2.43333787e-01f, 2.02470317e-01f,
  -2.94683110e-02f, 2.97149956e-01f, 1.73181608e-01f, 8.55322853e-02f, -7.13705495e-02f, 1.14069201e-01f, 9.46288705e-02f, -1.05048204e-02f, -1.79283172e-01f, -7.96476286e-03f,
  2.63775259e-01f, -9.82066244e-02f, 5.34377806e-02f, 1.61629081e-01f, 1.36512339e-01f, -1.69805437e-01f, 2.05585122e-01f, 3.15369070e-02f, -1.08804002e-01f, -1.83359995e-01f,
  -2.17493415e-01f, -5.63222989e-02f, -1.33296236e-01f, -2.22806543e-01f, -1.44600287e-01f, -2.15805635e-01f, -1.57166198e-01f, -1.80587843e-01f, 1.55609563e-01f, -1.63847044e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  7.73180425e-01f, 3.78874868e-01f, 7.28657603e-01f, -1.13581479e-01f, 2.04941675e-01f, -1.23060808e-01f, -1.06415257e-01f, 6.57449737e-02f, 8.07448104e-03f, -1.71055257e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  2.59188712e-01f, -2.00868621e-01f, 5.69861829e-01f, 5.36545634e-01f, 3.56927752e-01f, 6.04984403e-01f, -5.64785182e-01f, 1.67401910e-01f, 2.32595280e-01f, -2.35787034e-01f,
  1.64034754e-01f, -2.60349773e-02f, -1.51752725e-01f, -2.67476309e-02f, 1.48519024e-01f, 2.29599383e-02f, 1.55297920e-01f, -8.16374421e-02f, 5.16632378e-01f, 8.14397395e-01f,
  4.56758827e-01f, 9.40108359e-01f, -5.40362358e-01f, 1.67787764e-02f, 2.48886302e-01f, 6.72380552e-02f, 1.74150407e-01f, 2.28476956e-01f, 2.01899007e-01f, 2.68465579e-01f,
  -1.12910487e-01f, 9.90625471e-02f, 2.23648027e-01f, 3.24729562e-01f, -1.96633607e-01f, 1.65952727e-01f, 1.86081201e-01f, 7.85784610e-03f, -5.57019949e-01f, 2.94347823e-01f,
  4.43699241e-01f, 1.47255316e-01f, 1.35324195e-01f, -1.45211115e-01f, -3.50165546e-01f, -1.54591039e-01f, -1.03501745e-01f, 2.31259063e-01f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -7.76294395e-02f, 6.91317068e-03f, -2.49500856e-01f, 3.37004885e-02f, 1.30311191e-01f, 7.87913650e-02f, -2.40623966e-01f, 4.30942625e-02f, -1.60675347e-01f, -6.77097067e-02f,
  1.46685326e-02f, -6.92265630e-02f, -3.04873679e-02f, -8.84065479e-02f, -4.92035821e-02f, 1.60471335e-01f, 1.14648831e+00f, 5.70018530e-01f, 1.43010795e+00f, 8.03869441e-02f,
  -1.29113629e-01f, -5.67232072e-01f, 1.01595914e+00f, -4.74160790e-01f, 4.87655938e-01f, -1.59289390e-02f, -5.23423970e-01f, -2.21660212e-01f, 1.79694816e-01f, 6.71030343e-01f,
  2.84990072e-01f, -8.81328881e-02f, 2.34340310e-01f, -1.58692691e-02f, 1.09464355e-01f, 2.86747724e-01f, 2.22707063e-01f, 6.22970045e-01f, 2.77716786e-01f, 3.87371853e-02f,
  1.01904072e-01f, -2.37348139e-01f, 2.89575756e-01f, -1.15276486e-01f, 2.36801475e-01f, -2.38917489e-02f, -1.98845323e-02f, 1.35638282e-01f, -7.82909617e-03f, 5.01229167e-01f,
  4.43559468e-01f, 3.45611364e-01f, 2.69554049e-01f, -2.97355801e-01f, -4.56074566e-01f, 1.28141850e-01f, 1.46215141e+00f, -2.02184767e-01f, -6.90617263e-01f, -1.58076044e-02f,
  1.20180310e-03f, -2.21816245e-02f, -3.28400105e-01f, 3.05532943e-02f, -3.80085737e-01f, 4.18225117e-02f, -3.57395768e-01f, 7.90268302e-01f, 1.13423035e-01f, 7.65460134e-01f,
  1.95625558e-01f, 5.20673096e-01f, 5.04045308e-01f, -2.85992189e-03f, 6.72982782e-02f, -2.39522904e-02f, 9.95701551e-02f, 3.81808393e-02f, -5.56742400e-02f, -6.45745099e-02f,
  -2.04428658e-01f, -1.94429874e-01f, -1.81116294e-02f, 3.36052835e-01f, 1.10236555e-01f, 3.00967097e-01f, -3.54811132e-01f, -1.40626714e-01f, 4.56494242e-01f, -7.82849714e-02f,
  -2.56910205e-01f, -5.57595193e-02f, 1.25596702e-01f, -1.84741676e-01f, -3.42375450e-02f, 1.32478416e-01f, -2.16253594e-01f, 2.54761457e-01f, -5.73001266e-01f, -1.08042657e+00f,
  -4.43404108e-01f, -7.38525629e-01f, 5.81633747e-02f, -2.00005785e-01f, 7.80863881e-01f, -1.31727830e-01f, -2.71282229e-03f, 1.95746928e-01f, -1.96282119e-02f, 2.12596714e-01f,
  -2.81458706e-01f, -1.62429512e-01f, -1.05395114e+00f, -3.74492705e-01f, -1.03731322e+00f, -4.90949154e-01f, -2.52804428e-01f, -2.84055382e-01f, 6.33491337e-01f, 1.78154558e-01f,
  4.56145257e-01f, -2.43941963e-01f, 4.22501564e-01f, 4.63957377e-02f, -7.90661946e-02f, -8.40095058e-02f, 2.85175741e-01f, -5.41123673e-02f, 4.36864287e-01f, 7.98423737e-02f,
  2.43403643e-01f, 8.52594674e-02f, 4.75112438e-01f, 3.30900431e-01f, -4.14058149e-01f, 5.60320854e-01f, 9.00091827e-01f, 7.59608597e-02f, 1.25400615e+00f, 1.85493767e-01f,
  5.94545156e-02f, 1.45498261e-01f, -6.82954341e-02f, 5.59549686e-03f, 6.69106305e-01f, 3.58511418e-01f, 8.15200508e-01f, -2.22903803e-01f, -4.16724896e-03f, -4.13755357e-01f,
  1.18153095e+00f, 3.29693466e-01f, -1.59331352e-01f, 1.77323818e-02f, -5.47840074e-02f, -1.97360680e-01f, -6.09801784e-02f, -2.64627576e-01f, -4.82810587e-02f, -1.15325838e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  3.83014008e-02f, 2.21532002e-01f, 5.58433263e-03f, 8.01745579e-02f, 4.53606457e-01f, -5.22430651e-02f, 1.32366031e-01f, 2.60262847e-01f, 3.04776639e-01f, 2.33263299e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  1.05625892e+00f, 8.33550155e-01f, 5.01250863e-01f, 3.09030503e-01f, 6.50718927e-01f, -1.46930143e-02f, -1.35214478e-01f, 1.11631048e+00f, 2.19450742e-01f, 6.64884001e-02f,
  1.69901967e-01f, 1.18670635e-01f, -5.56386828e-01f, -4.92223203e-01f, -3.53570640e-01f, -1.78684831e-01f, 2.65027247e-02f, -3.50762725e-01f, 9.09394443e-01f, -8.40123236e-01f,
  -9.75989997e-01f, -5.97185850e-01f, -1.37182415e-01f, 5.85124373e-01f, -3.32715690e-01f, -1.75466374e-01f, -4.64539766e-01f, 1.88957229e-01f, 3.78839940e-01f, -1.94871038e-01f,
  -1.74417615e-01f, 5.20412207e-01f, -9.06792045e-01f, -6.67279899e-01f, -1.19889486e+00f, 1.11427970e-01f, -2.43542388e-01f, 9.64881927e-02f, -2.20149934e-01f, 1.90703720e-01f,
  -1.05535954e-01f, -4.80051249e-01f, -3.91830355e-01f, -1.67041123e-01f, 9.32346731e-02f, 3.51704925e-01f, -5.74497342e-01f, 6.72077060e-01f, -2.63387084e-01f, -2.43532211e-01f,
  -4.37312394e-01f, 2.69488007e-01f, 3.77146974e-02f, 1.36380613e-01f, -1.40600577e-01f, -1.26580536e+00f, -7.37628527e-03f, 4.63681936e-01f, 7.63415575e-01f, 4.75571424e-01f,
  -7.04822764e-02f, -1.71885207e-01f, 5.54207504e-01f, -7.53232837e-01f, 8.55241239e-01f, 7.73555934e-01f, -2.78230645e-02f, 8.51800561e-01f, 9.97177720e-01f, 7.03536689e-01f,
  7.36217387e-03f, -1.29864901e-01f, -3.96790914e-02f, 2.47624829e-01f, -3.31435055e-01f, -3.64108324e-01f, 4.65059340e-01f, -2.06151783e-01f, 8.28528166e-01f, -1.05521329e-01f,
  7.19049454e-01f, 7.66552925e-01f, 2.04832509e-01f, -5.02642274e-01f, -5.95594108e-01f, 2.24083200e-01f, 5.86516745e-02f, 1.50185257e-01f, -4.65503395e-01f, 6.71063602e-01f,
  -3.19999039e-01f, 1.46528170e-01f, 7.65761495e-01f, -8.66169930e-02f, -2.28245541e-01f, -2.31827185e-01f, 3.01961541e-01f, 3.86464953e-01f, 6.30183995e-01f, -1.15932643e+00f,
  -1.11270976e+00f, -7.49568939e-01f, -1.34290352e-01f, -1.12711728e+00f, 5.46907298e-02f, -1.04008712e-01f, 5.19363225e-01f, 2.78238267e-01f, 2.03795359e-01f, 1.11845493e+00f,
  -2.24361926e-01f, -6.85193002e-01f, -1.24602303e-01f, -6.06596351e-01f, -6.92415014e-02f, 2.84924984e-01f, 2.50991821e-01f, 1.66129425e-01f, -1.67308003e-01f, -1.00512815e+00f,
  3.84791762e-01f, -9.08932865e-01f, 1.73021197e-01f, -1.49555683e-01f, 7.45231211e-02f, 3.42761666e-01f, 8.68045390e-01f, -5.65979004e-01f, 1.97788954e-01f, 2.81126022e-01f,
  -5.41538000e-01f, -6.04138911e-01f, -6.84337497e-01f, -6.86819077e-01f, 1.37554839e-01f, 8.00459981e-01f, 2.54623532e-01f, -6.06154442e-01f, -1.95475936e-01f, 1.67734101e-02f,
  -8.79197836e-01f, -8.33723247e-01f, -7.80037940e-01f, 8.79981339e-01f, -6.34618998e-01f, -7.03890145e-01f, 2.39513695e-01f, -6.04367435e-01f, -7.25267291e-01f, -7.84481645e-01f,
  1.48194050e-02f, -3.23816031e-01f, -1.08427666e-01f, -3.67995292e-01f, 2.33595334e-02f, -5.87919764e-02f, 9.69819129e-01f, 8.45437765e-01f, -6.76989555e-01f, -5.12436107e-02f,
  2.39995301e-01f, -4.52564180e-01f, -2.97876596e-02f, 1.24582064e+00f, 1.20653808e+00f, 9.13435698e-01f, 1.58084199e-01f, -3.71859163e-01f, 5.48188210e-01f, 3.22556309e-02f,
  7.57069945e-01f, -2.16507480e-01f, -5.18210530e-01f, -2.18942747e-01f, 4.86793965e-01f, 1.58115685e-01f, -5.44138134e-01f, -3.56067419e-01f, -4.26816940e-01f, 4.62486953e-01f,
  4.46822584e-01f, 4.57779914e-02f, 1.22471623e-01f, 2.31221449e-02f, -1.30915269e-02f, 1.08411515e+00f, -5.69214411e-02f, 3.74492615e-01f, -7.90311620e-02f, -4.82750833e-01f,
  1.50603177e-02f, -4.19175267e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.73076779e-01f, 8.23648497e-02f, 2.47119173e-01f, -1.57986864e-01f, 1.61415301e-02f, -1.00118816e-01f, 4.10965890e-01f, -2.95143336e-01f, -1.37902424e-01f, 2.30221957e-01f,
  1.87124889e-02f, -1.85775161e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    