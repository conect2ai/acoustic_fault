/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.55173230e-01f, 4.22117949e-01f, -6.48281584e-03f, 1.49195239e-01f, -2.20819768e-02f, 1.94139317e-01f, 9.35704559e-02f, 1.34817079e-01f, 1.29943341e-01f, 1.60002708e-01f,
  7.09399069e-03f, 2.67290510e-02f, -4.74772193e-02f, 1.79687694e-01f, -2.69672781e-01f, -2.77406573e-02f, 1.26276135e-01f, 3.64890955e-02f, -1.35315672e-01f, 2.02528164e-02f,
  -5.17757609e-02f, 1.73225507e-01f, -3.96715887e-02f, 1.45211488e-01f, 4.00854200e-02f, 4.35355082e-02f, -5.26856184e-02f, -1.07544012e-01f, 1.00945137e-01f, -2.63148844e-02f,
  -4.00555320e-02f, 9.83822644e-02f, -4.87391949e-02f, 7.13650063e-02f, -8.30337219e-03f, 2.35971925e-03f, 5.28623490e-03f, -4.58820015e-02f, -1.11207440e-01f, -2.88548414e-02f,
  -3.73082631e-03f, 4.91128974e-02f, 7.43474364e-02f, -4.36850935e-02f, 2.39903647e-02f, -4.47833091e-02f, -2.56790183e-02f, -2.82912832e-02f, 4.00907844e-02f, 2.56838221e-02f,
  -3.27011868e-02f, 6.06779754e-03f, 3.32780853e-02f, 1.18935794e-01f, -1.06776599e-02f, 6.63209707e-02f, 8.96823220e-03f, -7.75877982e-02f, -8.55704490e-03f, 1.14010036e-01f,
  -6.85686767e-02f, 2.13696621e-02f, 1.57030821e-02f, -4.03260700e-02f, 4.13919166e-02f, 9.14997756e-02f, 3.06590125e-02f, -2.82921293e-03f, -8.64438899e-03f, 7.86663443e-02f,
  7.95299280e-03f, -1.90231856e-02f, -2.00558268e-02f, 1.30054772e-01f, 1.05009293e-02f, 8.75891149e-02f, -4.56584878e-02f, -5.43393269e-02f, 8.99609586e-04f, -2.87992433e-02f,
  2.57723965e-03f, 9.79527365e-04f, 2.61018910e-02f, -3.84517014e-03f, 4.10132781e-02f, -8.69684443e-02f, -8.56696803e-04f, 7.26703182e-02f, -4.77179438e-02f, -5.44576831e-02f,
  1.52755529e-01f, 1.11068599e-01f, 3.57223079e-02f, 4.43016505e-03f, 3.60125974e-02f, -3.07741873e-02f, -2.24931277e-02f, 9.33992192e-02f, 8.84997472e-02f, -5.02306707e-02f,
  3.48270871e-02f, -6.68998659e-02f, 3.85236815e-02f, -4.10381146e-02f, 3.85487787e-02f, 1.21717267e-01f, -5.22231981e-02f, 2.98340991e-02f, -5.20742207e-04f, 2.81063672e-02f,
  6.46389350e-02f, 1.79221167e-03f, -2.05127057e-02f, 3.23397517e-02f, 4.63947356e-02f, 3.39855924e-02f, -4.85690832e-02f, 1.17912963e-01f, -1.10627189e-02f, -1.28841745e-02f,
  -3.57686132e-01f, 2.77630031e-01f, -1.01168811e-01f, 2.97482014e-02f, -7.12950677e-02f, 2.16168851e-01f, 1.84848502e-01f, 2.66847126e-02f, 2.47558523e-02f, 2.26063877e-01f,
  8.09694082e-02f, 2.41889921e-03f, 1.68622881e-01f, 2.08972320e-01f, -5.93752228e-02f, 2.00505883e-01f, 6.75707608e-02f, 1.03931062e-01f, 1.86811504e-03f, 4.81527932e-02f,
  -1.64103638e-02f, 1.92786977e-01f, -4.33245040e-02f, 4.53821085e-02f, -1.66919231e-02f, -1.67538255e-01f, -1.07803375e-01f, -8.32349584e-02f, -1.00249134e-01f, -7.54940556e-04f,
  -3.56255583e-02f, 2.32307781e-02f, -6.28106669e-02f, 4.83997688e-02f, 8.10054690e-03f, 5.10134026e-02f, -3.15714628e-02f, -2.71105226e-02f, -2.08455231e-02f, 2.53881905e-02f,
  4.31749597e-02f, -1.28417639e-02f, 7.37076998e-02f, -2.02666433e-03f, 7.40950927e-03f, 1.23383021e-02f, -3.69510017e-02f, -4.12613489e-02f, -1.37000736e-02f, 3.96967866e-02f,
  5.45329787e-03f, -1.58118270e-02f, -3.14025618e-02f, 6.81552738e-02f, -2.89605558e-02f, -6.35542814e-03f, 5.19986525e-02f, -6.38873577e-02f, -1.94355417e-02f, -5.11679538e-02f,
  5.45156561e-02f, -3.58547680e-02f, 4.01070453e-02f, 9.15281940e-03f, 5.34811877e-02f, -2.40819936e-04f, -3.81188025e-03f, -2.83101238e-02f, -3.59822102e-02f, -1.22039439e-02f,
  -2.32989118e-02f, 4.97219265e-02f, 4.68643270e-02f, -1.02791898e-02f, -4.57098000e-02f, -6.23021694e-03f, -2.24960390e-02f, -3.57587747e-02f, -4.51035351e-02f, -9.09207687e-02f,
  5.51298782e-02f, 7.62236159e-05f, 6.31415620e-02f, -2.48531979e-02f, -5.26514947e-02f, 1.26147422e-03f, 8.15518424e-02f, -3.50321531e-02f, -2.31367759e-02f, -2.95149460e-02f,
  1.57015666e-01f, 2.02767849e-01f, 5.23920283e-02f, 2.98226736e-02f, 4.71711792e-02f, 1.69711560e-02f, -2.43556052e-02f, 2.70264056e-02f, 7.36451596e-02f, 8.47150758e-03f,
  -8.34858939e-02f, -9.06793587e-03f, -5.67790978e-02f, -2.45316178e-02f, -1.06915019e-01f, 1.08434707e-01f, -4.35830094e-03f, -2.06405092e-02f, -7.99356773e-03f, -8.96095950e-03f,
  1.34830372e-02f, 3.74748819e-02f, -8.82879496e-02f, 1.16706891e-02f, -3.65103148e-02f, -1.86577868e-02f, -2.10201219e-02f, -5.88246584e-02f, 1.86989419e-02f, -1.16860643e-02f,
  2.84278691e-01f, -6.21821433e-02f, 2.58335806e-02f, 1.10102028e-01f, -5.96556552e-02f, 7.97917917e-02f, 2.63883527e-02f, 1.38662934e-01f, 1.59364864e-01f, -1.50689721e-01f,
  -6.42780289e-02f, -1.03609435e-01f, -2.93497387e-02f, 2.55608633e-02f, 3.60659510e-01f, 5.62804602e-02f, 1.37397960e-01f, -3.33205499e-02f, 5.33683933e-02f, -5.33334911e-02f,
  5.31079322e-02f, 1.23212576e-01f, -3.97954732e-02f, -4.83374745e-02f, -6.41219988e-02f, -6.45591170e-02f, 1.70826614e-01f, -1.10092551e-01f, -1.46542236e-01f, 8.28987285e-02f,
  4.31113206e-02f, 3.10009997e-02f, -9.08142775e-02f, -1.86585840e-02f, -4.27017454e-03f, -5.90756387e-02f, 2.12562550e-02f, 4.48366627e-02f, 3.97646464e-02f, -4.76070382e-02f,
  -5.51835373e-02f, -8.31216201e-02f, 3.64151690e-03f, -7.69857094e-02f, -9.55205469e-04f, -1.39075801e-01f, 3.47964242e-02f, -7.73378238e-02f, 1.84124336e-02f, 1.25322351e-02f,
  -9.60539356e-02f, -1.15504470e-02f, -3.68170850e-02f, 5.59766218e-02f, 5.46200387e-02f, 4.58170427e-03f, -8.07446614e-02f, -4.15706672e-02f, 1.34521360e-02f, -1.80059846e-03f,
  1.10027559e-01f, 2.07609218e-02f, 2.83883531e-02f, -5.85752241e-02f, 2.67124046e-02f, -2.59427819e-03f, -7.50124604e-02f, -6.77644834e-02f, 2.38703452e-02f, -8.05259570e-02f,
  -2.64022984e-02f, 3.69760022e-02f, 2.08110567e-02f, -7.99154267e-02f, 7.39455670e-02f, 5.46806455e-02f, 7.13825375e-02f, 1.68676469e-02f, 4.75561284e-02f, 5.77492602e-02f,
  -2.57703499e-03f, -9.88116860e-03f, -5.99968508e-02f, 3.62809002e-02f, 2.27203239e-02f, 3.30586918e-02f, -4.77066301e-02f, -1.72345527e-02f, 7.42509589e-02f, 6.79860562e-02f,
  1.21360291e-02f, 2.89654911e-01f, 1.60472747e-02f, -6.48443326e-02f, 5.60083687e-02f, 7.57585838e-03f, 1.87419765e-02f, -3.19102295e-02f, 1.50148841e-02f, 5.66550083e-02f,
  -8.08735266e-02f, -7.77437491e-03f, -1.14849769e-02f, 6.05801158e-02f, -2.40056682e-02f, 6.10995404e-02f, 7.44225234e-02f, 1.07597493e-01f, 3.12925726e-02f, 2.57642530e-02f,
  -1.93694164e-03f, -1.06665038e-01f, 4.78342064e-02f, 1.34892222e-02f, 7.96117336e-02f, -5.72706945e-02f, 8.35454166e-02f, 1.78181808e-02f, -1.99920963e-02f, -6.09127581e-02f,
  3.65832597e-01f, 3.31952074e-03f, -1.30359769e-01f, 5.69203310e-02f, -1.34936199e-02f, -1.36231139e-01f, -1.67698026e-01f, -5.34125492e-02f, 1.88200042e-01f, 1.02320742e-02f,
  -1.11226082e-01f, 2.04199016e-01f, 2.78625265e-03f, -1.74632311e-01f, -2.71873415e-01f, -9.75639969e-02f, -1.36096269e-01f, 8.75365862e-04f, 1.09766759e-01f, -6.41680211e-02f,
  -1.49614178e-02f, -7.05738142e-02f, -1.73101753e-01f, 1.91750173e-02f, -2.54589189e-02f, 6.58028945e-03f, -2.14910343e-01f, -4.66919839e-02f, -1.52673692e-01f, -1.08636975e-01f,
  -4.04401422e-02f, 1.16401732e-01f, -1.17694419e-02f, -1.53271174e-02f, -8.52182582e-02f, -2.09155884e-02f, -1.14856377e-01f, -7.63447136e-02f, 9.45523567e-03f, -7.62576014e-02f,
  1.44961700e-01f, -4.44332957e-02f, 1.87721364e-02f, -2.49038283e-02f, 5.97707741e-02f, -3.66152897e-02f, 1.03501573e-01f, -1.81153566e-02f, -3.22951637e-02f, -8.63954946e-02f,
  5.21299010e-03f, -2.84545161e-02f, -2.01851390e-02f, 2.41555646e-02f, 2.59139724e-02f, 3.07860207e-02f, -6.06125705e-02f, -7.70348310e-02f, -5.98273873e-02f, 7.45735541e-02f,
  1.17594957e-01f, -6.20169006e-03f, -4.16478701e-02f, 1.82097107e-02f, -6.40264824e-02f, -9.26224235e-03f, -4.94202599e-02f, -2.61501707e-02f, -6.30996004e-02f, -3.95727418e-02f,
  1.86369307e-02f, -3.00093126e-02f, -4.89645191e-02f, -2.13670637e-02f, 4.24278751e-02f, 3.27055156e-02f, -6.07126020e-02f, -3.41367498e-02f, 1.35900006e-02f, -1.72730051e-02f,
  4.02782559e-02f, -1.61802135e-02f, 7.69594684e-02f, 2.13235598e-02f, -8.23888779e-02f, 2.01393664e-02f, -8.49281177e-02f, -4.59566759e-03f, -2.33630445e-02f, -4.33487333e-02f,
  -4.90209050e-02f, 6.73906878e-02f, -5.33276200e-02f, -2.31627915e-02f, 7.28521217e-03f, 3.08829509e-02f, 3.07970811e-02f, 7.89211914e-02f, -3.42005417e-02f, -5.39106503e-02f,
  -2.10793167e-02f, 4.68128882e-02f, -4.37384583e-02f, 2.14172876e-03f, 3.54650207e-02f, -7.23156333e-02f, -1.69718023e-02f, 8.86159576e-03f, 1.05714845e-03f, 3.60387415e-02f,
  -2.13081501e-02f, 2.12415960e-02f, 4.89759445e-02f, -2.60071941e-02f, 6.01914264e-02f, -7.08781034e-02f, 8.13476965e-02f, 9.50524770e-03f, -3.40579897e-02f, 1.10871093e-02f,
  -3.04606315e-02f, 7.93854818e-02f, -3.80813889e-02f, 2.89010435e-01f, 1.13598451e-01f, -3.82176712e-02f, -1.97149470e-01f, 1.24441117e-01f, 1.65131003e-01f, -6.30266666e-02f,
  -1.70603782e-01f, 8.56531188e-02f, -2.85638690e-01f, -8.14217404e-02f, -1.92655578e-01f, -2.36940950e-01f, -1.87595055e-01f, -1.08715691e-01f, 1.06145650e-01f, 8.20559785e-02f,
  5.02814800e-02f, -3.94583978e-02f, -1.79450065e-01f, 2.21724615e-01f, -4.22243029e-02f, 1.48026004e-01f, -8.16832483e-02f, 1.38816506e-01f, 6.78858832e-02f, -3.88031267e-02f,
  -2.61918288e-02f, 4.36653979e-02f, 5.26786745e-02f, -5.26280403e-02f, -8.02914649e-02f, -3.31461914e-02f, -4.52875048e-02f, 5.42277172e-02f, 2.50380486e-02f, 6.69535846e-02f,
  -7.15297163e-02f, 4.52314131e-02f, -2.62537953e-02f, 2.72115879e-02f, 8.65753219e-02f, 2.52430863e-03f, 1.07034914e-01f, -1.41988378e-02f, 8.28813016e-02f, -1.92970764e-02f,
  -2.10575014e-02f, 6.02364494e-03f, 4.17161956e-02f, -1.04209609e-01f, -9.25896131e-03f, 3.72295268e-02f, 4.07149196e-02f, -8.03156123e-02f, 3.38583440e-03f, 1.24996580e-01f,
  -6.02256395e-02f, 1.13491111e-01f, -6.93088546e-02f, -4.10943702e-02f, -7.21541345e-02f, -5.41653447e-02f, -1.95143688e-02f, -4.93636280e-02f, -1.99603178e-02f, -9.38657820e-02f,
  -2.40099952e-02f, 1.08391017e-01f, 6.26223162e-02f, 8.58088657e-02f, 1.49890482e-02f, -7.87353441e-02f, -1.02577299e-01f, 7.20991045e-02f, 7.15972437e-03f, 5.25483526e-02f,
  1.14845457e-02f, 2.65389252e-02f, -3.86492126e-02f, -3.57736126e-02f, -5.69328777e-02f, -3.22433636e-02f, 1.60103366e-02f, -3.31916846e-02f, -9.50383916e-02f, -1.02043055e-01f,
  -1.50224641e-01f, 1.20334469e-01f, 2.55785100e-02f, -1.91072207e-02f, -1.07911997e-01f, -3.17215398e-02f, 4.09278162e-02f, 1.24536850e-03f, -5.30542992e-02f, -1.16661996e-01f,
  2.46217046e-02f, 2.65552085e-02f, -4.30783145e-02f, 6.63956478e-02f, -5.13480753e-02f, -6.21362776e-02f, -6.64401129e-02f, -3.14354128e-03f, 2.75193695e-02f, 6.40916750e-02f,
  -2.29156408e-02f, -2.98120137e-02f, 3.40528861e-02f, 5.09578250e-02f, 9.08906087e-02f, 3.58194113e-02f, -1.90411434e-02f, 8.12103003e-02f, 1.99045055e-02f, -6.34213388e-02f,
  -1.09410673e-01f, 1.95207253e-01f, 1.18032381e-01f, -1.44637689e-01f, -4.98236865e-02f, -1.63576886e-01f, -2.09787205e-01f, -7.82152079e-03f, -4.75650579e-02f, 9.24621522e-02f,
  -1.29841313e-01f, -2.09927913e-02f, 3.47465165e-02f, -2.32090190e-01f, -3.39366980e-02f, 1.51646748e-01f, -8.53602290e-02f, -1.06554903e-01f, 1.16191007e-01f, -7.79665336e-02f,
  -1.19557828e-02f, -1.61557600e-01f, -9.20610800e-02f, 1.70226730e-02f, -3.46662812e-02f, 6.82625175e-02f, 7.95218945e-02f, 9.06285569e-02f, -1.83757991e-01f, -7.05521256e-02f,
  -1.14354320e-01f, 2.14429442e-02f, -4.58257124e-02f, 4.23429348e-02f, -5.37912594e-03f, -8.26321766e-02f, -8.29380844e-03f, -2.26476938e-02f, -1.07686212e-02f, 4.52575721e-02f,
  3.18104960e-02f, 1.07140455e-03f, 1.43613368e-02f, 3.87112983e-03f, 1.48658277e-02f, -6.07721647e-03f, 9.61028878e-03f, 3.00387666e-02f, 6.78361757e-05f, -7.02098012e-02f,
  4.21368927e-02f, -5.19179478e-02f, -4.28061076e-02f, 4.92596328e-02f, -4.26632538e-02f, -4.64331731e-02f, -3.23454179e-02f, -1.64626352e-02f, 1.18835568e-01f, -4.23527993e-02f,
  5.76086491e-02f, -2.95722317e-02f, 1.88455600e-02f, 5.31605929e-02f, 5.18204086e-03f, -3.32804844e-02f, -6.10703323e-03f, 2.47402340e-02f, -3.24361734e-02f, 6.13266788e-02f,
  -7.34506026e-02f, -4.25436459e-02f, 4.81474511e-02f, 2.16888580e-02f, 7.84607418e-03f, -6.13539927e-02f, 4.47733290e-02f, -2.76159327e-02f, -7.81586096e-02f, -6.14150576e-02f,
  8.93206894e-02f, 1.43393846e-02f, -2.11608466e-02f, -1.21684205e-02f, -8.01517442e-03f, -1.18252397e-01f, 5.66930547e-02f, -4.22492959e-02f, -1.17575587e-03f, -8.55166018e-02f,
  4.80192415e-02f, 1.53877616e-01f, -4.15554009e-02f, -7.16494918e-02f, 4.02522087e-02f, 4.96745249e-03f, -3.40946727e-02f, 2.42017265e-02f, 1.24476170e-02f, -6.08410500e-02f,
  2.08864622e-02f, -9.41882879e-02f, 3.64807695e-02f, -1.14634605e-02f, -8.46686438e-02f, 2.42233574e-02f, 1.28455400e-01f, -2.02951650e-03f, -4.20860685e-02f, 1.25288712e-02f,
  -3.60551178e-02f, 6.52459785e-02f, 6.60647973e-02f, 1.14510888e-02f, -2.28555668e-02f, 4.18669432e-02f, -1.28687574e-02f, 4.39695753e-02f, -2.99560837e-02f, 2.38490459e-02f,
  2.28239313e-01f, -2.64255311e-02f, -2.38624796e-01f, 2.41153664e-03f, 2.75151372e-01f, -8.21496267e-03f, -4.20156009e-02f, 1.78914994e-01f, -1.59789503e-01f, 3.10549494e-02f,
  1.43542171e-01f, -1.36948854e-01f, -6.16618618e-02f, -3.79687659e-02f, 2.46070419e-02f, -1.88078895e-01f, 1.18913248e-01f, 1.44757172e-02f, -7.02629313e-02f, 1.57806098e-01f,
  -5.24157658e-02f, 9.92246717e-02f, 5.53647503e-02f, 1.72456667e-01f, 8.14099982e-02f, -1.50508108e-02f, 1.13639072e-01f, -1.04351260e-01f, 1.59928411e-01f, 2.71581188e-02f,
  1.12503119e-01f, 1.40167866e-02f, -1.88212208e-02f, -9.99030545e-02f, 9.66158211e-02f, 5.28171584e-02f, -4.07227613e-02f, -1.30296171e-01f, 1.15779545e-02f, -3.74387987e-02f,
  -1.95838157e-02f, -5.17556304e-03f, 3.12745431e-03f, -1.09389849e-01f, -3.87402028e-02f, 4.99003977e-02f, -8.43636170e-02f, 4.70619909e-02f, -9.03050788e-03f, -8.05262104e-02f,
  -2.07877252e-02f, -7.77924713e-03f, -2.74927728e-02f, 5.00606664e-04f, 1.95169542e-02f, -6.73857518e-03f, -3.81337516e-02f, 7.73015842e-02f, -1.59686300e-04f, 7.90435374e-02f,
  -7.48055428e-02f, -1.32932642e-03f, 2.06044372e-02f, 3.49233556e-03f, 3.59653793e-02f, 1.02787785e-01f, -6.54188693e-02f, -2.97789574e-02f, -1.62275061e-02f, -1.11376280e-02f,
  7.11364001e-02f, 3.81908985e-03f, -1.18531868e-01f, 7.29433224e-02f, 2.76110098e-02f, -8.79153386e-02f, 7.95796979e-03f, -4.52739447e-02f, 5.34931682e-02f, -2.19994374e-02f,
  -2.14068852e-02f, 5.42575158e-02f, 6.45905733e-02f, -3.86461690e-02f, -2.42721774e-02f, -7.28047639e-03f, -6.92809522e-02f, -5.96816689e-02f, -2.13052519e-02f, 1.90460160e-02f,
  1.52285635e-01f, 1.11340536e-02f, 3.86267640e-02f, -2.06402829e-03f, 5.03937043e-02f, 8.71342607e-03f, -1.17306992e-01f, -1.28306746e-02f, 4.96600382e-02f, 7.86763616e-03f,
  8.40936154e-02f, -2.80021448e-02f, -1.25521496e-02f, 7.36622289e-02f, -4.36507873e-02f, 1.53595814e-02f, -4.26166654e-02f, 4.89400290e-02f, 8.38000402e-02f, 3.35842222e-02f,
  1.20065980e-01f, 1.62400100e-02f, -2.64870562e-02f, 8.19637403e-02f, 5.86580066e-03f, 2.07987241e-02f, -5.11132441e-02f, 3.91838560e-03f, -8.75641778e-02f, -5.67396320e-02f,
  1.19981080e-01f, -6.98752925e-02f, -1.57957822e-01f, 3.97890098e-02f, 1.26732364e-01f, 1.58450842e-01f, 8.53935182e-02f, -1.65124759e-02f, -4.39813025e-02f, 1.80805430e-01f,
  1.84784960e-02f, -9.82318372e-02f, -2.84709930e-02f, 1.55301511e-01f, -1.78182367e-02f, -1.93015903e-01f, 1.83178291e-01f, -2.20576804e-02f, -5.05023003e-02f, 4.57445458e-02f,
  2.99261324e-02f, 1.98391244e-01f, -1.11872787e-02f, 9.77567881e-02f, 3.11333518e-02f, -9.24032256e-02f, 8.62811357e-02f, -7.54921958e-02f, -3.40674669e-02f, -3.64159681e-02f,
  6.64109141e-02f, -6.22719117e-02f, -5.78403799e-03f, -4.35133874e-02f, 5.93948513e-02f, 6.66285530e-02f, -9.88801345e-02f, -6.24188073e-02f, 1.09889945e-02f, -7.61180371e-02f,
  1.08077573e-02f, -7.22103519e-03f, -8.84717554e-02f, -6.52942285e-02f, 1.01267390e-01f, -7.07549900e-02f, 1.59939937e-02f, 1.10072501e-01f, -5.15478710e-03f, 5.92965856e-02f,
  -2.05409341e-02f, -3.93682234e-02f, -8.81330110e-03f, -7.71533102e-02f, -5.36073092e-03f, -7.47647602e-03f, 4.57173064e-02f, -6.85780644e-02f, -9.35312957e-02f, 5.82997352e-02f,
  8.27638283e-02f, 8.76870677e-02f, 7.31575936e-02f, -3.55156809e-02f, 6.89638173e-03f, 1.98317561e-02f, -3.75101902e-02f, 2.90971082e-02f, 6.05023419e-03f, 1.93997528e-02f,
  4.16890569e-02f, -3.53496452e-03f, 3.12367151e-03f, 9.65449214e-02f, 1.16509229e-01f, 2.92604621e-02f, -4.97946702e-02f, 1.33292226e-03f, -1.53635349e-02f, 4.37868796e-02f,
  -2.88182441e-02f, 4.71195579e-02f, -2.36145966e-03f, 3.83171737e-02f, -1.67292468e-02f, -2.44918764e-02f, -5.22541581e-03f, -1.24059856e-01f, 3.37568521e-02f, -1.41937630e-02f,
  -6.24712072e-02f, -1.44773666e-02f, -6.48303255e-02f, 3.59202139e-02f, -5.43173850e-02f, 6.35618344e-02f, 1.33307800e-02f, 2.59792469e-02f, -1.21151432e-01f, -3.09915617e-02f,
  1.65130854e-01f, 3.95467579e-02f, -1.26036465e-01f, -1.03961083e-03f, -1.11751020e-01f, -4.57448252e-02f, 2.36840895e-03f, 1.33174444e-02f, 2.63202544e-02f, -3.19555029e-02f,
  5.51109575e-02f, -2.17025373e-02f, -5.18956594e-02f, 8.18178132e-02f, 1.09742530e-01f, -2.14162413e-02f, 2.89620720e-02f, -5.20312749e-02f, -7.52402470e-02f, 5.33448532e-02f,
  7.27678388e-02f, -2.20853105e-01f, -1.19955562e-01f, -2.33893171e-02f, 5.33182956e-02f, 3.43037456e-01f, 2.13585287e-01f, -8.75341296e-02f, -2.17923507e-01f, -4.62359004e-02f,
  1.52823955e-01f, -2.40215868e-01f, -6.27620146e-02f, 1.30382618e-02f, 1.14488445e-01f, 6.08019494e-02f, 8.79293233e-02f, -5.41282669e-02f, -6.17904030e-03f, -9.74761397e-02f,
  -7.50375986e-02f, 1.57317623e-01f, -1.29508570e-01f, -4.59611490e-02f, -2.36097188e-03f, -1.57955259e-01f, 8.61898065e-03f, -1.94361378e-02f, 1.84651222e-02f, 5.55234514e-02f,
  1.36777446e-01f, -1.22145146e-01f, -3.77514004e-03f, 2.21694317e-02f, 1.67132001e-02f, 4.40377444e-02f, 6.39744028e-02f, 3.30226980e-02f, -3.35895419e-02f, 8.77833925e-03f,
  4.36843047e-03f, -1.17106751e-01f, -1.13730354e-03f, 4.88820858e-03f, 3.37792002e-02f, -8.88402835e-02f, -5.03396913e-02f, 7.26271346e-02f, -7.68061206e-02f, -2.60611586e-02f,
  -1.01340488e-02f, 3.79870161e-02f, 1.78170968e-02f, 6.51532924e-03f, -1.16013624e-02f, 3.70142683e-02f, -4.29556146e-02f, -6.98210374e-02f, 8.54495615e-02f, -6.83224574e-02f,
  5.71609139e-02f, -2.22596768e-02f, 2.71627773e-02f, -1.55209620e-02f, 4.46311943e-02f, -5.56482077e-02f, 9.48581770e-02f, 2.11583450e-02f, -6.51217848e-02f, 4.42281691e-03f,
  4.52659763e-02f, -3.13178413e-02f, 1.91082451e-02f, 2.15188228e-02f, 4.14206088e-02f, 5.07780612e-02f, 2.99039166e-02f, 5.97600490e-02f, -2.49420535e-02f, 6.14857711e-02f,
  7.13391602e-03f, -3.39952148e-02f, -2.96945684e-02f, 1.00785874e-01f, 3.04586124e-02f, -4.79161926e-02f, 3.33834477e-02f, -3.95139754e-02f, -1.91758554e-02f, 8.77805799e-02f,
  3.95038910e-02f, -1.81347892e-01f, -9.64732990e-02f, 9.83266458e-02f, -5.10334000e-02f, 3.63895372e-02f, -4.26454516e-03f, 3.49387117e-02f, -8.86764601e-02f, -3.12546343e-02f,
  -2.52864305e-02f, 6.29438013e-02f, -3.36022153e-02f, 6.91154003e-02f, 1.68135539e-02f, -5.36490604e-02f, -6.73794793e-03f, -7.33476207e-02f, 4.58182730e-02f, 2.70992089e-02f,
  2.45143026e-02f, -4.81214002e-03f, 5.70261246e-03f, 1.59677565e-02f, 1.04188442e-01f, 4.62393602e-03f, -6.63784158e-04f, 1.81657970e-02f, 3.08293290e-02f, -3.52213606e-02f,
  4.94391238e-03f, 2.98408456e-02f, 2.92927206e-01f, -4.89662737e-02f, -9.76938605e-02f, -3.54113467e-02f, 1.70279201e-03f, -8.80830362e-02f, -3.57815810e-03f, -2.38718346e-01f,
  -1.88642386e-02f, 1.38583705e-01f, 2.30206717e-02f, -2.53294379e-01f, 1.80565163e-01f, 3.27131748e-02f, -1.20130032e-01f, -1.78231224e-02f, 4.12426284e-03f, -6.72444329e-02f,
  8.24378207e-02f, -2.85802722e-01f, 2.57291704e-01f, -2.21204683e-01f, -2.81794369e-03f, 8.31497461e-02f, 2.56166738e-02f, 9.25536081e-02f, -3.81378010e-02f, -2.00263802e-02f,
  1.06588220e-02f, 5.54209128e-02f, 3.10914721e-02f, 2.98431572e-02f, -1.24949766e-02f, 3.23703773e-02f, 2.38378812e-02f, 9.74342169e-04f, 5.82127012e-02f, -1.16093718e-02f,
  1.24455214e-01f, 7.36774579e-02f, -3.81669402e-02f, -9.29050744e-02f, -3.60476859e-02f, -2.39091739e-02f, -1.44639714e-02f, 8.37324262e-02f, 2.43523046e-02f, 5.58326440e-03f,
  1.08021446e-01f, 4.11166362e-02f, 3.20124030e-02f, 2.10783836e-02f, 1.21835455e-01f, 9.91904549e-03f, 5.02908640e-02f, 4.19555716e-02f, 1.22986166e-02f, -1.73380300e-02f,
  -3.10340095e-02f, -4.23217155e-02f, 3.09030935e-02f, -4.52566184e-02f, -5.28935855e-03f, 7.23380595e-02f, -4.53642234e-02f, -3.89381275e-02f, -2.89696809e-02f, -1.45699000e-02f,
  3.99158150e-02f, -1.29188793e-02f, -2.49549728e-02f, 1.92849105e-03f, -5.72000928e-02f, 2.47516837e-02f, 1.77020524e-02f, -4.10966529e-03f, -5.79718426e-02f, 2.19457820e-02f,
  1.04490183e-01f, -3.73823978e-02f, 5.24480678e-02f, 4.39257137e-02f, -5.78221232e-02f, -1.19850470e-03f, -1.04049042e-01f, -1.33085819e-02f, 2.48559495e-03f, 3.89836095e-02f,
  -4.88762325e-03f, -9.06333104e-02f, 3.39153595e-02f, -7.02980459e-02f, 3.93242426e-02f, -2.95826606e-02f, 2.86258906e-02f, -9.05032456e-03f, 4.19647098e-02f, -3.08498163e-02f,
  -5.78182712e-02f, -8.19228664e-02f, -1.25415325e-02f, 8.30264762e-03f, -8.59268196e-03f, 4.66874763e-02f, 2.58803256e-02f, 2.41926666e-02f, -9.53323245e-02f, -6.11380525e-02f,
  4.81850691e-02f, -2.40656622e-02f, -6.19463623e-02f, -4.27326262e-02f, -9.59375501e-02f, 7.54521191e-02f, 3.42077352e-02f, -1.35701206e-02f, -2.75157648e-03f, 1.50532229e-02f,
  4.10093218e-01f, -7.49131665e-02f, -3.86298932e-02f, -1.18299853e-02f, 3.55293266e-02f, 1.18823081e-01f, 1.85473055e-01f, -4.32953648e-02f, -5.67091852e-02f, -1.13032587e-01f,
  -5.84541773e-03f, -1.26859203e-01f, -1.05183020e-01f, -1.40397185e-02f, 2.27876306e-01f, -1.10384494e-01f, 1.00370571e-01f, 2.55074278e-02f, -1.81436334e-02f, -5.42084035e-03f,
  -3.83110084e-02f, 2.79165134e-02f, 2.06298977e-02f, 5.62612489e-02f, 4.84830663e-02f, -5.23475781e-02f, -4.90593240e-02f, -5.89318611e-02f, -1.14848288e-02f, 6.28253222e-02f,
  1.13067105e-01f, -3.95634919e-02f, -5.98879270e-02f, -2.79990416e-02f, -3.87400016e-02f, 1.02115117e-01f, -4.86684591e-02f, 6.35882691e-02f, -2.40333434e-02f, -2.53245085e-02f,
  2.48377491e-02f, 4.44547459e-03f, -7.20888451e-02f, -4.38466482e-02f, 9.41374004e-02f, 4.12787236e-02f, -4.71449867e-02f, -5.87519072e-03f, -3.75445783e-02f, 6.58659264e-02f,
  1.92889590e-02f, -1.77711584e-02f, 2.94244457e-02f, -4.38312031e-02f, 3.71594988e-02f, -9.02782846e-03f, -5.69262728e-02f, -2.07452942e-02f, -6.22926839e-02f, 6.48368374e-02f,
  -2.92610526e-02f, -2.03772429e-02f, 2.58023459e-02f, 3.32616270e-02f, -3.67468596e-02f, -6.83071092e-02f, 6.74286708e-02f, -5.61888851e-02f, 5.84119521e-02f, -4.26578820e-02f,
  -2.47554667e-02f, 5.91704680e-04f, 2.83618346e-02f, -2.94340122e-02f, 2.10041227e-03f, -1.24895282e-03f, -2.66660973e-02f, 1.22290459e-02f, -1.74970776e-02f, 1.93578135e-02f,
  -3.69634628e-02f, 1.07686490e-01f, -1.97533481e-02f, -4.79118973e-02f, -7.98454601e-03f, 3.40764076e-02f, 7.25212619e-02f, 2.34800819e-02f, 1.15165235e-02f, -6.07057009e-03f,
  -1.66797727e-01f, -1.40939996e-01f, -5.05273119e-02f, 1.96711700e-02f, 8.97027273e-03f, 1.91644840e-02f, 4.19279449e-02f, 6.39373995e-03f, -1.39018102e-02f, -2.65121534e-02f,
  -5.44163771e-02f, 1.23493299e-02f, 3.37314419e-02f, 8.87886807e-03f, 1.04786791e-02f, -8.56422037e-02f, -6.21086266e-03f, -8.15448165e-02f, 1.28235389e-03f, -1.89886335e-03f,
  4.68371995e-02f, -1.66439507e-02f, -1.32459300e-02f, -5.51670901e-02f, -2.53377613e-02f, -6.13732934e-02f, 2.72971336e-02f, -3.82600352e-02f, 2.69468352e-02f, -1.44344606e-02f,
  3.21671575e-01f, -6.79696053e-02f, -9.57871974e-02f, 8.97215083e-02f, -4.45390716e-02f, 1.01418756e-02f, 2.69785970e-01f, -1.05485462e-01f, 1.71767473e-01f, 7.57920668e-02f,
  6.92727715e-02f, 1.31406248e-01f, 1.66875392e-01f, -1.25364140e-01f, 1.70425624e-01f, 1.84605584e-01f, 1.62991956e-02f, -9.67879873e-03f, -7.74445012e-02f, -1.69157106e-02f,
  7.33516291e-02f, -1.75791830e-01f, 4.03645448e-02f, -2.19635010e-01f, -1.20665506e-02f, -4.58989143e-02f, -1.15504898e-02f, 4.60795909e-02f, -6.79038763e-02f, -7.99077228e-02f,
  -6.83134720e-02f, -5.97313158e-02f, -5.00328429e-02f, -2.66754720e-02f, 2.60288622e-02f, -6.49892464e-02f, 7.29937777e-02f, 2.56516039e-02f, -9.30474978e-03f, 4.39202227e-02f,
  2.12185141e-02f, -3.72459367e-02f, -1.15049519e-02f, -3.19300964e-03f, -6.66328892e-02f, -8.77439380e-02f, 1.14533827e-02f, 3.97164971e-02f, 1.24180242e-02f, -1.25343241e-02f,
  4.73004282e-02f, -1.99720003e-02f, 6.71073347e-02f, -5.80391288e-02f, 8.21994394e-02f, -7.26896804e-03f, -1.32237179e-02f, 1.62833910e-02f, -1.31310932e-02f, -5.66873178e-02f,
  9.69235133e-03f, 5.39419726e-02f, 2.39122510e-02f, -9.94148999e-02f, 1.47048114e-02f, -5.51904812e-02f, -2.95953769e-02f, 4.30380506e-03f, 1.44725507e-02f, 8.10835510e-04f,
  2.83879135e-02f, 3.25035378e-02f, 6.80712238e-02f, 7.94307664e-02f, -3.53385881e-02f, -1.03106931e-01f, 4.66818642e-03f, -5.37244901e-02f, 5.18105477e-02f, -4.16540839e-02f,
  2.83241030e-02f, -2.21691076e-02f, -5.42315729e-02f, 4.50128391e-02f, 4.81747910e-02f, 1.04622617e-02f, -7.34804049e-02f, -6.95201103e-03f, -1.93471964e-02f, 2.03173626e-02f,
  4.71589528e-02f, -2.83446815e-02f, -3.17090489e-02f, -4.60231639e-02f, -5.14435628e-03f, -4.47318843e-03f, 8.78025778e-03f, -5.09942509e-02f, 4.29591769e-03f, -1.06609315e-02f,
  7.01058581e-02f, 3.32937874e-02f, -2.42429283e-02f, -5.51318638e-02f, 1.17112882e-02f, 1.16742151e-02f, 2.26494297e-02f, -6.09486597e-04f, 7.22272024e-02f, -1.93540864e-02f,
  -9.53797475e-02f, 5.86092025e-02f, 1.75839588e-02f, -6.63435534e-02f, -4.48954888e-02f, 9.55924578e-03f, -3.98655795e-02f, 3.23061310e-02f, 4.59919907e-02f, 2.93523800e-02f,
  -3.23559970e-01f, 2.92562157e-01f, -3.17951441e-01f, 6.74108118e-02f, -7.45455399e-02f, 1.31674141e-01f, 9.17773470e-02f, 2.99445577e-02f, 1.03602871e-01f, 3.23632091e-01f,
  1.70520067e-01f, -4.14019125e-03f, 1.23491853e-01f, 3.46088320e-01f, -1.56992123e-01f, 1.67663842e-01f, 6.61426187e-02f, 7.45912939e-02f, -2.63914447e-02f, 7.45413974e-02f,
  -7.42084235e-02f, 2.20456585e-01f, -1.79597244e-01f, 2.17755679e-02f, 1.91307510e-04f, -1.26954690e-01f, 7.22243562e-02f, -1.60927966e-01f, 5.79221770e-02f, -2.09838375e-02f,
  -2.25209594e-02f, 1.53920976e-02f, -7.69779682e-02f, -3.76689918e-02f, -3.48993056e-02f, -8.44567865e-02f, -5.93151897e-02f, -5.63870035e-02f, -1.21778041e-01f, -3.10836136e-02f,
  -5.49835674e-02f, -3.42114568e-02f, -4.04510126e-02f, -1.91627408e-03f, -6.01275600e-02f, -4.26036231e-02f, -2.45784200e-03f, -2.82138027e-02f, 1.77917518e-02f, -8.15894231e-02f,
  -5.08512417e-03f, -5.63485958e-02f, 5.81279732e-02f, 4.49236892e-02f, -8.62868652e-02f, 4.57865223e-02f, -1.26295723e-02f, -1.02306306e-01f, 4.04475592e-02f, 2.02416703e-02f,
  -3.15096416e-02f, -7.26732761e-02f, -9.73482733e-04f, -3.24371550e-03f, 5.56947291e-02f, -5.28858304e-02f, 1.05208978e-01f, -4.18706164e-02f, -3.21696326e-02f, 2.34925840e-02f,
  -1.45125035e-02f, -3.13742943e-02f, 7.20653981e-02f, -5.85760036e-03f, -2.64199656e-02f, 5.85261658e-02f, -1.05114914e-01f, 6.89415215e-03f, -4.69327047e-02f, 1.62739796e-03f,
  7.49348709e-03f, 3.27836699e-03f, -3.54783349e-02f, 3.43830744e-03f, 2.21973844e-02f, -5.50530441e-02f, 2.53173131e-02f, 8.00685212e-03f, 8.04459769e-03f, -1.74322817e-02f,
  1.26311108e-01f, 1.33380905e-01f, 2.07777247e-02f, 1.18485112e-02f, 2.48980448e-02f, 4.15274762e-02f, 9.54872184e-03f, -9.53713730e-02f, 3.21182683e-02f, 1.03570533e-03f,
  -6.78608641e-02f, -1.16753848e-02f, 4.13482124e-03f, -2.04180945e-02f, 7.23281875e-02f, -2.80318893e-02f, 6.29889145e-02f, -3.78344697e-03f, 6.87707365e-02f, 6.93941070e-03f,
  -2.64838357e-02f, 5.02007566e-02f, -2.19278485e-02f, -7.03783110e-02f, 4.24756594e-02f, -2.73989066e-02f, 3.86774354e-02f, -3.52556184e-02f, 9.42193251e-03f, 9.94216353e-02f,
  1.42534897e-01f, 1.71971962e-01f, 3.18810076e-01f, 9.41552892e-02f, -1.08079026e-02f, 1.12665810e-01f, 4.42791618e-02f, 1.06000677e-01f, 6.26083165e-02f, -1.02240957e-01f,
  -1.48062676e-01f, 1.86857030e-01f, -1.29928246e-01f, 2.27053732e-01f, 2.21148878e-01f, 1.68995082e-03f, 1.68325782e-01f, 4.27463874e-02f, 5.84208220e-02f, 1.15710907e-01f,
  4.32652794e-02f, -6.71902671e-02f, 2.50718862e-01f, -4.71542776e-02f, 1.12627387e-01f, 3.33681051e-03f, -3.40793431e-01f, -7.69276172e-02f, 1.04699992e-01f, 4.10565436e-02f,
  1.15585059e-01f, -1.44880200e-02f, 8.39204714e-02f, -2.82780975e-02f, 9.79536865e-03f, 1.71871539e-02f, -2.18813885e-02f, -1.36273808e-03f, -1.74504425e-02f, 8.23274255e-02f,
  -3.62009928e-02f, -5.98853305e-02f, 3.82746309e-02f, -3.36360186e-02f, -7.62286931e-02f, 5.31155095e-02f, 7.55602345e-02f, 6.32726699e-02f, 1.06883682e-01f, 8.37117285e-02f,
  6.63320422e-02f, 5.43832779e-02f, -2.28228457e-02f, -1.40637467e-02f, 3.65241580e-02f, 2.10466720e-02f, -2.92696543e-02f, 4.60851304e-02f, 5.39820734e-03f, 1.04598045e-01f,
  -1.22662941e-02f, -3.36257629e-02f, 5.49492985e-03f, -2.33289506e-02f, -3.11881527e-02f, 1.03405956e-02f, -7.28999153e-02f, -3.22508253e-02f, -5.92243113e-02f, -3.40416022e-02f,
  3.59191485e-02f, -5.05721522e-03f, -2.58928770e-03f, 6.07451014e-02f, -1.31580024e-03f, -1.46249533e-02f, 1.77081563e-02f, -3.98951769e-02f, 1.39227301e-01f, -1.17722600e-04f,
  -1.96157750e-02f, 6.29528193e-03f, 6.41718656e-02f, -1.13329396e-01f, -1.20179672e-02f, 1.86429769e-02f, -4.19473182e-03f, 4.15881304e-03f, 5.01105969e-04f, -2.49656700e-02f,
  -4.31800559e-02f, -6.45262897e-02f, -3.82080376e-02f, 1.25367986e-02f, -5.53372167e-02f, -1.33413952e-02f, -9.34794173e-03f, 2.22345963e-02f, -2.00878009e-02f, -1.77760273e-02f,
  -1.59822102e-03f, -8.33178461e-02f, -2.27902941e-02f, 8.79023522e-02f, 1.88008528e-02f, -5.17005548e-02f, -4.01541814e-02f, -7.16841295e-02f, -2.25632749e-02f, -6.65158033e-02f,
  -6.72056153e-03f, -4.23701964e-02f, -4.79064472e-02f, 2.75425874e-02f, -4.65646535e-02f, -5.84983490e-02f, 2.73169875e-02f, 3.15268375e-02f, -7.94037059e-02f, -8.18796903e-02f,
  -4.64205295e-02f, -9.55550447e-02f, 1.91302776e-01f, 1.23934545e-01f, 2.15201126e-03f, 7.45940655e-02f, 1.19256072e-01f, 7.77346045e-02f, 3.41982424e-01f, 3.32461931e-02f,
  -3.76315787e-02f, 9.99775305e-02f, 4.60002292e-03f, -7.42588863e-02f, 1.40246987e-01f, 1.41263857e-01f, -5.51642962e-02f, -9.34654251e-02f, -1.38811981e-02f, -1.70103222e-01f,
  -1.41438120e-03f, -1.70975313e-01f, -1.03941679e-01f, -1.18203752e-01f, -1.71220481e-01f, -5.11761121e-02f, -1.86671793e-01f, 7.11978301e-02f, -7.71508291e-02f, 4.87090312e-02f,
  -1.25502041e-02f, -2.83355918e-02f, -1.21720716e-01f, 4.80790883e-02f, -7.85945654e-02f, -5.15683852e-02f, -5.43831475e-02f, 7.62552693e-02f, 1.88408326e-02f, -3.32569424e-03f,
  8.18634406e-03f, 7.66059831e-02f, 1.64181273e-02f, 4.14819084e-02f, 6.80208579e-02f, 5.40888719e-02f, -2.96734106e-02f, -8.99466425e-02f, -6.96270773e-03f, -2.40302291e-02f,
  1.24351919e-01f, -2.30920464e-02f, 1.22206360e-02f, -6.47743642e-02f, -4.38523963e-02f, 7.35897152e-03f, 4.35299277e-02f, 4.89959680e-03f, -7.88805634e-02f, -1.03831757e-02f,
  -7.08907247e-02f, 1.21843658e-01f, -2.70616580e-02f, -4.24279645e-02f, -2.70752814e-02f, -7.94348270e-02f, 2.34314669e-02f, -1.24027263e-02f, -6.15595607e-03f, -2.38907989e-02f,
  -6.74880296e-02f, 2.54848115e-02f, 1.64954399e-03f, 6.13391288e-02f, 6.69617131e-02f, 1.09908991e-01f, -5.31938113e-02f, -8.63924921e-02f, 8.05087611e-02f, 1.63233168e-02f,
  2.13848595e-02f, 3.71292941e-02f, -5.59336245e-02f, -7.05745369e-02f, -2.91803037e-03f, 3.81436534e-02f, -4.77244295e-02f, -3.30501460e-02f, -4.71942220e-03f, 4.17571515e-02f,
  -1.69696242e-01f, -1.48508721e-03f, -1.75531004e-02f, 2.72000208e-03f, 6.75405608e-03f, -1.41811827e-02f, 2.15716418e-02f, -5.28406128e-02f, 4.25200816e-03f, -2.83971634e-02f,
  -3.98126133e-02f, -6.21897839e-02f, 1.26387058e-02f, 3.44231538e-02f, 5.63909523e-02f, 6.22597374e-02f, 1.95450261e-02f, 1.65235680e-02f, -2.76848953e-02f, -9.13779214e-02f,
  -8.33386406e-02f, 8.16271082e-03f, 2.30389480e-02f, 5.22337295e-03f, -6.54541329e-02f, -1.21079415e-01f, -4.32970002e-02f, -2.75726859e-02f, -2.64133234e-02f, 2.00534575e-02f,
  2.89736409e-02f, 5.67083023e-02f, 2.44051203e-01f, -1.76394060e-01f, -6.26093224e-02f, 7.27395490e-02f, 1.90914854e-01f, -1.50189325e-01f, 8.56830925e-02f, -2.03210697e-01f,
  -1.12449810e-01f, 6.36418238e-02f, 1.17727213e-01f, -2.62255758e-01f, -1.58577740e-01f, 1.75125562e-02f, -2.54342109e-01f, -5.86235747e-02f, 4.50451151e-02f, -1.84142277e-01f,
  -4.60961051e-02f, -2.93124050e-01f, -6.45145029e-02f, -2.03669488e-01f, -1.57793075e-01f, -5.49608432e-02f, -2.66454786e-01f, 1.27778754e-01f, -2.08923787e-01f, -3.70242856e-02f,
  -2.13879868e-02f, 2.23936979e-03f, -1.30658839e-02f, 4.36167158e-02f, -6.28399663e-03f, 3.76940370e-02f, 2.62330864e-02f, -1.09976167e-02f, 4.01960015e-02f, -7.74518994e-04f,
  4.63240631e-02f, 6.47014612e-03f, -3.94083299e-02f, -3.25983018e-02f, 2.26777997e-02f, 9.34945140e-03f, -8.50580167e-03f, -3.02298721e-02f, 1.65313929e-02f, 8.07082802e-02f,
  6.70044720e-02f, 4.82551642e-02f, -7.64214247e-03f, -5.27712628e-02f, 4.85718483e-03f, -8.99335556e-03f, -1.96337583e-03f, 1.91156268e-02f, 4.10086438e-02f, -8.17258935e-03f,
  -4.55798917e-02f, -1.39792264e-02f, 1.69442482e-02f, -4.25407030e-02f, -1.11513166e-02f, -3.89509350e-02f, -2.68439688e-02f, -5.97862527e-03f, -6.08536648e-03f, 2.20282301e-02f,
  -2.53163800e-02f, -1.65603906e-02f, 1.46331387e-02f, 1.59563851e-02f, -1.60553101e-02f, 1.36673525e-02f, 4.83428538e-02f, -1.58855710e-02f, 5.48954215e-03f, -3.08372639e-02f,
  -2.31627598e-02f, -6.82799071e-02f, -1.61439534e-02f, 1.27350222e-02f, 2.61457767e-02f, -6.17269566e-03f, 6.33552857e-03f, 2.43926551e-02f, -2.76370645e-02f, -2.65909005e-02f,
  -1.12137467e-01f, -5.37047759e-02f, 5.89753315e-02f, 1.18289655e-02f, 1.51482532e-02f, -6.62240237e-02f, -2.70270705e-02f, 1.85066916e-03f, -3.92251927e-03f, 2.53496855e-03f,
  -5.55373169e-02f, -1.27036739e-02f, -1.01335756e-01f, 4.75465432e-02f, -6.12335140e-03f, 1.26080913e-02f, -1.00173458e-01f, 4.94512841e-02f, -1.75414011e-02f, -9.16914791e-02f,
  -3.13075893e-02f, 2.58101728e-02f, 7.64191896e-03f, -3.49526154e-03f, -1.05246723e-01f, -5.82661480e-02f, 3.32389362e-02f, 1.44854769e-01f, -1.20356768e-01f, -1.45281469e-02f,
  2.33557269e-01f, -1.67503003e-02f, 8.22657943e-02f, -8.82658437e-02f, 1.19390540e-01f, -1.73627675e-01f, -3.22328508e-01f, 5.37331253e-02f, -7.00927079e-02f, -2.86398351e-01f,
  -1.08457796e-01f, -9.05468240e-02f, -1.33076668e-01f, -2.01164499e-01f, 6.59552440e-02f, -2.08647028e-01f, -4.17542346e-02f, -1.11168399e-01f, 2.97812149e-02f, 3.21482345e-02f,
  9.37826708e-02f, -5.13826869e-02f, -4.19490561e-02f, 8.17770287e-02f, -1.35307079e-02f, 1.52227491e-01f, 9.31428745e-02f, -6.63988590e-02f, 2.27161627e-02f, 1.97253600e-02f,
  6.07488565e-02f, -6.24481067e-02f, -4.84882370e-02f, -5.01353033e-02f, -7.43600959e-03f, 5.76285645e-02f, -1.08969975e-02f, -5.76905683e-02f, -2.11094902e-03f, -5.15163839e-02f,
  -8.83423025e-04f, 3.75052020e-02f, -3.61372344e-02f, -1.44969784e-02f, 4.06477079e-02f, 8.54827315e-02f, 4.50180247e-02f, -9.68466047e-03f, 3.18530314e-02f, 9.44679081e-02f,
  -5.15127964e-02f, 7.01329783e-02f, -5.51999398e-02f, 4.45031421e-03f, 4.88768779e-02f, -1.44660324e-02f, -4.52790223e-02f, -3.36817615e-02f, 5.93384579e-02f, 1.67553294e-02f,
  -2.64590420e-02f, -7.25658163e-02f, 1.53487204e-02f, -7.93989673e-02f, 7.96975940e-02f, 8.35919753e-02f, -2.55404282e-02f, -6.70813322e-02f, 8.76193419e-02f, -6.85193837e-02f,
  6.24924572e-03f, -3.83955240e-02f, -2.81831389e-03f, -3.35717276e-02f, -3.70385759e-02f, -3.23732086e-02f, -2.20895912e-02f, -6.38518259e-02f, 2.22380757e-02f, -1.83768980e-02f,
  -3.91367339e-02f, -2.11464912e-02f, -6.35099038e-02f, -4.12680693e-02f, -5.24061844e-02f, -2.63788681e-02f, -2.82300077e-02f, -2.72806454e-02f, -3.24506685e-03f, 6.70043901e-02f,
  -7.85061046e-02f, -7.57263154e-02f, -7.13584200e-02f, 2.62283087e-02f, 6.91040307e-02f, 9.49560553e-02f, 2.78274417e-02f, 4.55722548e-02f, 2.53516287e-02f, -4.13394496e-02f,
  7.68319122e-04f, -7.30538741e-03f, 3.06416824e-02f, -2.30376441e-02f, -3.45276073e-02f, -3.59895416e-02f, -6.67933822e-02f, -3.93285975e-02f, -4.16656956e-02f, -4.94693266e-03f,
  -1.21136643e-02f, 1.57647580e-02f, -3.71979512e-02f, 7.42117167e-02f, 2.06312258e-02f, 1.28007331e-03f, 2.80685592e-02f, 4.50714538e-03f, 9.83734876e-02f, 5.88291278e-03f,
  -5.17024636e-01f, 1.45926878e-01f, 1.09601937e-01f, -6.80347607e-02f, -2.75122710e-02f, 2.90939230e-02f, -1.64314732e-02f, -7.06438394e-03f, 1.04586489e-01f, 1.44692823e-01f,
  5.02846343e-03f, 9.46725439e-03f, 2.70162970e-02f, 1.14747450e-01f, -1.75683677e-01f, 1.15679838e-01f, -9.05677974e-02f, 5.69548719e-02f, 9.10498053e-02f, -4.96954434e-02f,
  9.23183840e-03f, 1.28402216e-02f, 7.98324049e-02f, 8.07847530e-02f, -5.07343784e-02f, 1.93141066e-04f, -1.61841989e-01f, 5.36194742e-02f, -1.09518273e-02f, -8.69699474e-03f,
  -1.07126109e-01f, 3.24108154e-02f, 1.16333663e-02f, 4.20003533e-02f, -3.49825695e-02f, -2.83800513e-02f, -3.10084838e-02f, -8.23634584e-03f, 5.54283441e-04f, -4.29200456e-02f,
  -4.04952839e-02f, -2.19622366e-02f, 4.65442473e-03f, 6.41904771e-02f, -7.50938291e-03f, 7.34806508e-02f, 3.49567048e-02f, 8.25207606e-02f, 4.96768765e-02f, -3.27727618e-03f,
  5.57549894e-02f, 3.20292190e-02f, 4.98532131e-02f, 1.30381331e-01f, 4.14711013e-02f, 2.97259670e-02f, 2.01484617e-02f, -7.12621212e-03f, -1.35540245e-02f, 4.68082540e-02f,
  3.82422134e-02f, -2.01357529e-02f, 2.84413025e-02f, -4.34927754e-02f, 1.73038337e-02f, 2.37218086e-02f, 2.05842070e-02f, -4.38292846e-02f, -4.93850708e-02f, -4.66522016e-02f,
  -5.22973686e-02f, 9.19322390e-03f, 4.18883562e-02f, -3.89298871e-02f, -1.15630776e-02f, 8.27512983e-03f, 2.34657153e-03f, 1.25176385e-02f, -1.07921205e-01f, 3.87086235e-02f,
  1.36822229e-03f, -5.76326065e-02f, 6.70869742e-03f, -6.40419945e-02f, -1.76566299e-02f, -8.78073499e-02f, 7.30526075e-02f, 2.38426100e-03f, 3.63754630e-02f, -1.69328284e-02f,
  -6.71751499e-02f, 6.14698678e-02f, -8.82913265e-03f, -1.76275559e-02f, 5.00284880e-02f, 1.19363062e-01f, 1.01786844e-01f, 3.44027244e-02f, 7.38940435e-03f, 2.13872921e-02f,
  1.98071580e-02f, 2.75346916e-02f, 3.82239115e-03f, -2.29862519e-02f, 1.04448674e-02f, -4.96273302e-02f, -1.02838181e-01f, -3.61168012e-02f, -3.04741431e-02f, -4.31460626e-02f,
  2.30282973e-02f, -6.28307685e-02f, 7.00479820e-02f, -8.40789378e-02f, -2.15060487e-02f, -1.18315434e-02f, -8.16969424e-02f, -1.14093046e-03f, 4.55235243e-02f, -1.48530435e-02f,
  -7.19405636e-02f, 1.08698942e-01f, 1.08044639e-01f, 4.37993467e-01f, -1.43993199e-01f, 6.52664751e-02f, 1.71220526e-01f, 2.16594972e-02f, 1.50637433e-01f, -7.77762905e-02f,
  1.69361651e-01f, 6.67220075e-03f, -1.57003049e-02f, 3.98066461e-01f, 4.74148363e-01f, 1.37841761e-01f, 3.85898769e-01f, 1.61442310e-01f, 4.14564013e-02f, 8.76650587e-02f,
  2.05683768e-01f, 2.24199787e-01f, 2.57703692e-01f, -5.67105152e-02f, 1.77925676e-02f, -7.14703053e-02f, -1.13044903e-02f, -1.33325890e-01f, 1.39111727e-01f, -5.03963931e-03f,
  1.02343388e-01f, 1.37136504e-02f, -6.93982840e-02f, -6.89224824e-02f, 1.51338056e-02f, -7.33455718e-02f, -9.90072563e-02f, -3.91666144e-02f, 3.82479429e-02f, 3.92444283e-02f,
  -4.25264752e-03f, -1.73324216e-02f, 5.26395589e-02f, -1.19917095e-02f, -1.56154931e-02f, 1.79370251e-02f, 2.32655648e-02f, 3.08131408e-02f, -8.37109424e-03f, 1.03180241e-02f,
  5.22954799e-02f, 6.87888591e-03f, 7.53343804e-03f, 1.27370458e-03f, 4.56142426e-02f, 3.54293138e-02f, 6.47449568e-02f, 4.51453822e-03f, -3.85029204e-02f, 3.83134857e-02f,
  -8.45945850e-02f, -4.23886590e-02f, -5.57830036e-02f, 2.59122234e-02f, 6.67188168e-02f, -9.81163606e-03f, 1.53036937e-02f, 1.79477949e-02f, -2.93433852e-02f, 1.77313033e-02f,
  -3.19343619e-02f, -3.69730517e-02f, 4.67123184e-03f, -4.79529984e-02f, 1.97150894e-02f, -4.28708009e-02f, -4.33542803e-02f, 1.45280108e-04f, 6.58047292e-03f, -2.44775470e-02f,
  3.74236703e-02f, -2.04230715e-02f, -4.20545153e-02f, -4.43059243e-02f, 3.12485993e-02f, -1.14604700e-02f, 9.31594986e-03f, -4.15588468e-02f, -3.02421451e-02f, -4.28816350e-03f,
  3.09756268e-02f, 1.02538541e-01f, 6.94094598e-02f, 4.89851125e-02f, 2.21294500e-02f, -4.97127287e-02f, 1.05993159e-01f, 1.41980415e-02f, -2.45341193e-02f, -3.64107965e-03f,
  -1.28539011e-01f, 2.68073212e-02f, -1.19786255e-01f, -3.34646255e-02f, 5.12189977e-02f, 3.23851593e-02f, -4.72359080e-03f, -1.11645810e-01f, 5.79458699e-02f, 1.94633491e-02f,
  -7.05221146e-02f, -9.34110135e-02f, -1.33557161e-02f, -6.67971894e-02f, -9.54725593e-03f, -6.37221560e-02f, 7.29972869e-03f, 7.37198070e-03f, -1.66362319e-02f, -3.34101766e-02f,
  -3.40103060e-01f, 1.01670958e-02f, 9.17581394e-02f, -1.12748399e-01f, -5.33576272e-02f, -2.58761853e-01f, -8.31142217e-02f, 7.25062788e-02f, -1.89536616e-01f, 4.55193296e-02f,
  2.09379867e-02f, -4.56945188e-02f, 1.44464225e-01f, -9.63691249e-02f, -1.61096931e-01f, -1.00179806e-01f, -1.35633603e-01f, -1.03147246e-01f, -4.27529998e-02f, 7.64545612e-03f,
  -3.68902124e-02f, -7.20448121e-02f, 1.42600283e-01f, 6.68893084e-02f, -2.75512226e-02f, 1.60200093e-02f, 1.24382727e-01f, 4.90452647e-02f, -1.98071096e-02f, -5.04786521e-02f,
  -1.24286331e-01f, 1.99976694e-02f, 1.77844707e-02f, -7.08352327e-02f, 2.84779519e-02f, -4.61449698e-02f, 4.47496921e-02f, -7.08393380e-02f, -2.29272200e-03f, 6.38308981e-03f,
  -2.42604502e-02f, 8.97678081e-03f, -6.41121417e-02f, 4.53565978e-02f, -5.26761264e-02f, 3.94037701e-02f, -2.58002430e-02f, 3.80096808e-02f, 4.21866700e-02f, -7.80540183e-02f,
  3.68495733e-02f, 6.07173815e-02f, -1.20908744e-03f, 1.78261176e-02f, -3.57024223e-02f, 1.34551628e-02f, -1.18986331e-02f, -4.52331677e-02f, -1.07470363e-01f, -2.23610736e-02f,
  -8.66803974e-02f, -2.71931570e-02f, -9.30137839e-03f, 1.26044564e-02f, 1.40973330e-02f, 5.89761138e-02f, 7.16582239e-02f, 5.04163243e-02f, -3.35851423e-02f, 7.55976513e-03f,
  -4.03007343e-02f, 1.98129490e-02f, 3.94207574e-02f, -8.35302696e-02f, 3.37473005e-02f, 5.52268438e-02f, -1.11146048e-02f, 6.74860105e-02f, -9.43886042e-02f, 4.43647392e-02f,
  5.85710146e-02f, 2.42780568e-03f, 5.77639528e-02f, 5.15323319e-02f, 6.81890622e-02f, 2.96541993e-02f, 2.56967172e-03f, 8.09985492e-03f, 1.04052082e-01f, 5.70193306e-02f,
  2.72609410e-03f, 1.04651496e-01f, 8.93279817e-03f, -5.59299311e-04f, 6.62489757e-02f, 5.79425395e-02f, 4.95588593e-02f, -7.44185969e-02f, -7.45558704e-04f, -3.51750813e-02f,
  1.76372342e-02f, 8.10553413e-03f, -3.31170228e-03f, -6.08382141e-03f, -1.66527573e-02f, -6.55470341e-02f, 8.76314491e-02f, 4.56531905e-02f, 4.13995935e-03f, 5.20887896e-02f,
  2.70753838e-02f, -8.66718218e-02f, -1.25786159e-02f, -8.94152373e-02f, -2.81908065e-02f, -3.35440077e-02f, -6.44790307e-02f, -4.88799848e-02f, 1.09796748e-02f, -1.39887528e-02f,
  -2.63470083e-01f, -1.18036605e-01f, 8.25535655e-02f, -2.30454937e-01f, -8.46591741e-02f, 3.09608638e-01f, 1.97625101e-01f, -1.29977748e-01f, -1.12484768e-01f, -1.09064497e-01f,
  -3.21083725e-03f, -2.54224986e-02f, 1.05164357e-01f, -5.02576716e-02f, 6.87527135e-02f, 2.88133323e-01f, 6.70805946e-02f, 6.89011142e-02f, 5.01848012e-02f, -1.82235047e-01f,
  8.72203857e-02f, -1.57413080e-01f, 1.55968636e-01f, -1.96554273e-01f, -7.85508230e-02f, 2.27304138e-02f, -1.59060046e-01f, -6.00478724e-02f, -1.41961426e-01f, -1.81736313e-02f,
  1.36177987e-03f, -1.49264410e-01f, 3.53125483e-02f, 1.21610314e-02f, -2.21494604e-02f, 5.51931933e-02f, 2.22410318e-02f, 8.93264413e-02f, -1.05123026e-02f, -4.39579897e-02f,
  -5.05268434e-03f, -2.37802546e-02f, -1.19197629e-02f, 3.59017104e-02f, -7.32284738e-03f, 4.38621044e-02f, 3.65954335e-03f, 8.33833292e-02f, -5.46696922e-03f, 1.15965074e-02f,
  4.78862263e-02f, 7.08536133e-02f, 5.10910749e-02f, 1.84146669e-02f, 4.79136854e-02f, 1.89052485e-02f, 1.27421230e-01f, 1.05988868e-02f, -5.57106510e-02f, -6.45232797e-02f,
  1.90464016e-02f, 5.53221582e-03f, -7.53641501e-03f, -6.44631460e-02f, -9.12025571e-02f, -4.05166186e-02f, -1.67228619e-03f, 7.52158388e-02f, -4.51157149e-03f, -2.62597203e-02f,
  -7.72172511e-02f, -3.27603556e-02f, -3.62840556e-02f, 1.53283309e-02f, 2.07225289e-02f, -7.88507909e-02f, 4.98195104e-02f, -3.80339064e-02f, -7.12105725e-03f, -7.35453516e-03f,
  -3.49051021e-02f, -4.45844084e-02f, -2.32964265e-03f, 6.44031540e-02f, -3.44828553e-02f, 4.70299609e-02f, 1.79563835e-02f, 1.12747978e-02f, 2.24987343e-02f, 7.72072151e-02f,
  -9.06563178e-02f, -3.31499666e-01f, 1.91135593e-02f, -7.26450309e-02f, -5.88230602e-03f, 1.07949274e-02f, -4.57383282e-02f, -4.53095697e-02f, 2.00746208e-03f, -8.44121873e-02f,
  2.01188978e-02f, 7.22662061e-02f, -3.30169015e-02f, 6.09818380e-03f, -1.40913976e-02f, -6.43662512e-02f, 3.45126316e-02f, -1.49824042e-02f, -3.40443589e-02f, -3.52829471e-02f,
  -1.41255960e-01f, -9.60048512e-02f, 6.24780022e-02f, -7.16844499e-02f, -2.73938496e-02f, 1.05081145e-02f, -1.27493888e-01f, 5.21378033e-02f, -1.69074945e-02f, 6.07313700e-02f,
  4.11754102e-01f, -1.67901199e-02f, 1.38830766e-01f, 2.68634455e-03f, -8.85575116e-02f, 1.38839319e-01f, 2.00942069e-01f, 1.06448807e-01f, 1.43381625e-01f, -8.23492836e-03f,
  1.66782085e-02f, 1.43680349e-01f, -2.89125135e-03f, -3.87800485e-02f, 4.13321219e-02f, -1.24732301e-01f, 5.00553055e-03f, 1.50899574e-01f, -4.02417146e-02f, 7.80437961e-02f,
  1.94198936e-02f, -1.39326155e-01f, -7.50285164e-02f, -1.31713778e-01f, 1.59934476e-01f, -4.51716036e-02f, -1.02833025e-01f, -7.38311857e-02f, 2.54646726e-02f, -1.19788875e-03f,
  7.73552433e-02f, 1.17682502e-01f, 1.06741555e-01f, 8.44970047e-02f, 1.23476133e-01f, 9.94339809e-02f, -6.69883855e-04f, -3.72840390e-02f, 1.78696029e-03f, 3.46271060e-02f,
  1.15363644e-02f, 5.38945086e-02f, 2.70079840e-02f, 1.07282691e-03f, 1.19217291e-01f, 4.44051176e-02f, -7.55823404e-02f, 6.53085634e-02f, 4.16557007e-02f, -4.66686636e-02f,
  -1.37819154e-02f, 1.03615671e-02f, 3.51183452e-02f, 3.57647277e-02f, 5.55658247e-03f, -2.10351907e-02f, 5.12280278e-02f, 3.28967497e-02f, 7.01545328e-02f, 2.90690716e-02f,
  -1.41508253e-02f, -1.44814211e-03f, -6.17457740e-02f, 1.57943740e-03f, -5.88314123e-02f, 4.20582108e-02f, -7.31498897e-02f, 2.96643768e-02f, 3.81047721e-03f, -7.70819560e-02f,
  -1.40972331e-03f, 1.72646338e-04f, 1.30708441e-02f, -6.27468899e-03f, -4.56197448e-02f, 4.51091826e-02f, -3.71961221e-02f, 1.65008176e-02f, 4.57177125e-02f, -1.32242246e-02f,
  2.26389933e-02f, 4.08887267e-02f, 3.55805047e-02f, -2.37552226e-02f, 8.65362287e-02f, -1.09674431e-01f, 1.31887076e-02f, -1.01899013e-01f, -2.12246235e-02f, -7.01591969e-02f,
  -2.68023536e-02f, 1.96462534e-02f, -9.01605189e-02f, 7.70671619e-03f, -4.80712615e-02f, 8.31567310e-03f, -6.56797737e-02f, 7.57566914e-02f, 9.23902094e-02f, 1.04217017e-02f,
  9.12803486e-02f, -4.67254370e-02f, 4.68744449e-02f, 6.57101115e-03f, -9.37547013e-02f, -8.05205852e-03f, 3.88888568e-02f, 2.34691687e-02f, 4.16426361e-03f, -1.56738758e-02f,
  -1.17518390e-02f, 2.60733794e-02f, -2.50327270e-02f, -3.94439287e-02f, 8.50326382e-03f, 8.23535249e-02f, 3.00230235e-02f, 2.19881758e-02f, -6.28094673e-02f, -7.59859569e-04f,
  -1.81653678e-01f, 5.36844358e-02f, -4.78621051e-02f, -2.22222418e-01f, 1.81189433e-01f, 4.52333279e-02f, -1.81376800e-01f, 5.74524067e-02f, -6.79190606e-02f, -2.37650499e-02f,
  -1.13737233e-01f, -3.62339094e-02f, -1.40553802e-01f, -2.18769833e-01f, -2.91920483e-01f, -2.38945156e-01f, -1.66232571e-01f, -7.03025386e-02f, 1.77961644e-02f, -1.33923385e-02f,
  -1.42256897e-02f, -1.97200462e-01f, -1.28048897e-01f, 2.23685652e-01f, 1.77357905e-02f, 1.52791202e-01f, -1.18296154e-01f, 1.55839324e-01f, 7.31680244e-02f, 3.83830480e-02f,
  8.47667456e-02f, -2.24422514e-02f, 1.71334520e-01f, 3.97628136e-02f, 3.04078311e-02f, -3.62120457e-02f, 3.75941060e-02f, -4.58395742e-02f, 6.04357496e-02f, 4.97099385e-02f,
  -1.66664068e-02f, -1.02692680e-03f, 3.42212915e-02f, 1.69117190e-02f, -3.31072346e-03f, -2.42919270e-02f, 3.47090065e-02f, 8.74224901e-02f, 4.50560264e-02f, -7.20359981e-02f,
  -5.49325161e-02f, 3.74304466e-02f, -2.92794146e-02f, -1.62287115e-03f, 2.66125742e-02f, -3.00228558e-02f, 1.11417817e-02f, -1.14284800e-02f, -3.75624411e-02f, -1.11338444e-01f,
  -2.36839131e-02f, 2.51316689e-02f, 2.79161111e-02f, 3.95216085e-02f, 6.08069412e-02f, -3.78928031e-03f, -4.84276190e-02f, 8.10272992e-02f, 3.27823311e-02f, 9.31907073e-03f,
  -2.60181371e-02f, 4.61470112e-02f, 5.26500046e-02f, -4.36466597e-02f, -4.76358160e-02f, -4.46784645e-02f, 3.25609893e-02f, 2.30090115e-02f, -1.22590316e-02f, 8.93729832e-03f,
  -7.79871345e-02f, -1.50220729e-02f, 2.39543095e-02f, -3.83998007e-02f, -4.34186570e-02f, -2.09589535e-03f, 8.51225704e-02f, -2.89938860e-02f, 5.96347563e-02f, -2.20890101e-02f,
  -1.04844220e-01f, -2.45378524e-01f, 1.61633939e-02f, 4.07984592e-02f, 1.81645248e-03f, 2.70053484e-02f, -4.54496406e-02f, 4.86435182e-02f, -7.98697397e-02f, -8.45450535e-03f,
  5.40963858e-02f, 7.06754476e-02f, -7.53268308e-04f, 6.77072257e-02f, 1.02643399e-02f, -6.15663677e-02f, -1.09219857e-01f, -5.37032820e-02f, 1.86552033e-02f, 2.88159661e-02f,
  2.74239127e-02f, -2.63889600e-02f, -5.13042361e-02f, -3.25157642e-02f, 1.76434196e-03f, -5.89158386e-02f, -1.80349704e-02f, 4.24691178e-02f, 2.14866027e-02f, 2.24189158e-03f,
  1.10022180e-01f, -6.39899895e-02f, -1.40329553e-02f, -1.93308264e-01f, 3.60830985e-02f, 1.64193481e-01f, 6.18002415e-02f, -1.24173738e-01f, 1.87405765e-01f, -1.75546452e-01f,
  -1.37084546e-02f, 1.19913772e-01f, 1.91777185e-01f, 1.17471009e-01f, 4.18970883e-01f, 2.51770109e-01f, 2.03764781e-01f, 1.78242438e-02f, 7.83748105e-02f, -1.70233473e-02f,
  9.63153914e-02f, -6.86092675e-02f, 7.42675588e-02f, -1.35208458e-01f, -2.44209975e-01f, -2.51833260e-01f, -2.64047235e-01f, -4.88472208e-02f, -1.26309037e-01f, 1.37775227e-01f,
  9.03459862e-02f, 2.49101594e-03f, 1.01528326e-02f, -5.27929142e-02f, -8.89763609e-03f, -9.45210680e-02f, -7.93126002e-02f, -8.82396176e-02f, 6.88353106e-02f, -2.58956291e-02f,
  -1.16433064e-02f, 4.03685085e-02f, -3.78474891e-02f, -1.28887007e-02f, -6.84988126e-02f, 2.54348628e-02f, 7.28521198e-02f, 1.66998506e-02f, 5.44249043e-02f, 1.00452587e-01f,
  3.04484926e-02f, -3.98487337e-02f, -1.22298352e-01f, -3.10230386e-02f, 4.03650105e-02f, -3.16355824e-02f, -7.07585504e-03f, 2.40729526e-02f, -2.74262875e-02f, 1.69119276e-02f,
  -5.89088835e-02f, -5.07306820e-03f, -8.02176632e-03f, -7.00308606e-02f, 1.07623532e-01f, -3.58539075e-02f, 4.27563973e-02f, -4.30006199e-02f, -4.32516012e-04f, 1.82786747e-03f,
  3.79173793e-02f, -5.49570881e-02f, 4.31288444e-02f, -3.67299914e-02f, 5.57900928e-02f, -6.52603656e-02f, -1.36049301e-03f, 3.22020948e-02f, -1.81007944e-02f, 5.27558029e-02f,
  2.53022294e-02f, 1.24386474e-01f, -5.11937998e-02f, -1.11360870e-01f, 3.57074030e-02f, 1.79057419e-02f, 4.10544537e-02f, 2.27735694e-02f, 4.78263721e-02f, 2.96552274e-02f,
  6.62897527e-02f, -2.31266394e-02f, -5.62217385e-02f, 3.36844102e-02f, -1.62374955e-02f, 2.94877421e-02f, 1.06610984e-01f, 4.02676016e-02f, 8.51483084e-03f, -4.39302586e-02f,
  1.18909655e-02f, -2.85774376e-02f, -1.53101217e-02f, 2.42502056e-02f, -4.27530594e-02f, 2.07603443e-02f, -5.72503218e-03f, 2.01408099e-02f, -8.86284038e-02f, -3.37632513e-03f,
  -1.55133024e-01f, 8.50707386e-03f, -1.79064944e-02f, 3.24283317e-02f, 1.66171733e-02f, -3.59254028e-03f, 2.87187248e-02f, 2.61933543e-02f, 2.43583508e-02f, 2.26191934e-02f,
  3.07270586e-01f, -7.87404552e-02f, -1.04848161e-01f, -5.41918054e-02f, 3.20275798e-02f, -1.16512597e-01f, -7.15258345e-02f, -1.30964071e-01f, -2.86450773e-01f, -1.70039073e-01f,
  -2.92663369e-02f, 1.35962039e-01f, -1.20508268e-01f, 6.12735115e-02f, 1.48713633e-01f, -3.49696763e-02f, 1.64522063e-02f, 7.48552456e-02f, -9.95010510e-03f, 1.97911128e-01f,
  1.30118847e-01f, 7.10254014e-02f, 9.84190032e-02f, -5.88673074e-03f, 1.48065612e-01f, 2.41458267e-02f, 2.35641137e-01f, -1.08013444e-01f, 1.47524372e-01f, -2.01492291e-02f,
  6.96623251e-02f, -3.59574780e-02f, 1.23658977e-01f, -4.42746542e-02f, 4.43209633e-02f, 1.66762564e-02f, -4.35402170e-02f, 5.60571961e-02f, -2.45657656e-02f, 6.40364690e-03f,
  3.05025596e-02f, 5.05853482e-02f, 3.69255319e-02f, -3.16183977e-02f, -1.17987707e-01f, -7.33185336e-02f, 4.14235070e-02f, -2.55754255e-02f, -4.62397598e-02f, 1.67598464e-02f,
  -6.79506361e-02f, -5.75951152e-02f, 2.04012846e-03f, -8.35464671e-02f, 2.43770406e-02f, -2.63610259e-02f, 1.30297709e-03f, 5.64228818e-02f, 2.54647676e-02f, -2.53693927e-02f,
  -1.76555831e-02f, -3.06817032e-02f, -3.16207409e-02f, -6.51038662e-02f, -9.16249081e-02f, -2.27883663e-02f, 2.65568197e-02f, 4.66389097e-02f, -2.99947821e-02f, 3.94668691e-02f,
  -4.84672301e-02f, 9.12236236e-03f, -3.68901007e-02f, -3.05466019e-02f, 9.66085866e-02f, -2.22144797e-02f, 6.41828850e-02f, 1.83297805e-02f, -1.28173664e-01f, 7.67251328e-02f,
  -5.52670136e-02f, -8.68747756e-03f, -1.15795508e-02f, -3.37802544e-02f, 3.36092934e-02f, -4.07669283e-02f, -4.53284048e-02f, -4.59445715e-02f, 2.53203604e-02f, 3.66192721e-02f,
  7.65803605e-02f, 5.52384704e-02f, 4.37808335e-02f, 2.23391186e-02f, -8.24726000e-03f, 3.87816168e-02f, 6.20721467e-02f, 8.45380053e-02f, -4.21263613e-02f, 5.90825395e-04f,
  2.99462728e-04f, -4.90074866e-02f, 1.12265497e-01f, -5.06893285e-02f, 2.02594791e-02f, -3.62927951e-02f, -3.16187888e-02f, -4.20095064e-02f, 2.19300343e-03f, 2.96280459e-02f,
  1.14748172e-01f, 3.67559195e-02f, 4.72770892e-02f, 1.37124779e-02f, -8.35309997e-02f, 1.13285892e-01f, -1.79023426e-02f, -4.60972190e-02f, 4.19937819e-03f, 1.51412236e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.60394964e-02f, -2.01774940e-01f, -2.70833641e-01f, -1.11928038e-01f, -2.93042250e-02f, -1.19415209e-01f, -2.32099861e-01f, 1.04679033e-01f, -8.45079422e-02f, -5.64298406e-02f,
  1.42694935e-01f, -5.28829992e-02f, -1.36914238e-01f, -7.04072863e-02f, 2.02016175e-01f, -2.03613549e-01f, 1.07908636e-01f, -2.34459881e-02f, -1.19319759e-01f, 8.41336250e-02f,
  9.57726538e-02f, 1.79054797e-01f, 1.76654030e-02f, 1.93046600e-01f, 8.36250708e-02f, 1.86084569e-01f, 2.94381678e-01f, 1.25594512e-01f, 3.03020447e-01f, 6.80818185e-02f,
  -5.18562831e-02f, -7.69037940e-03f, -1.14902504e-01f, 2.97904294e-02f, 2.51128897e-02f, 1.45247877e-01f, -2.03750171e-02f, -1.82404090e-03f, 5.92338368e-02f, -3.59362215e-02f,
  1.94904283e-02f, 4.19086143e-02f, -7.35113695e-02f, 4.77743894e-02f, -3.75862373e-03f, 3.79203440e-04f, -9.88825858e-02f, 1.15432553e-02f, -1.51246458e-01f, 5.97908869e-02f,
  9.87166353e-03f, 2.51588188e-02f, -4.84459214e-02f, -3.38788778e-02f, -6.65969476e-02f, -5.94798587e-02f, 9.31394380e-03f, 8.06903001e-03f, -4.74666357e-02f, -1.94409695e-02f,
  8.03398564e-02f, 1.87820029e-02f, 1.67220831e-02f, -7.33912960e-02f, -8.82820785e-03f, -7.36930668e-02f, -4.51648496e-02f, -4.51375209e-02f, -2.98195668e-02f, 7.81897306e-02f,
  -2.84827165e-02f, 3.30339260e-02f, 7.17077479e-02f, 4.31315973e-02f, 5.80325648e-02f, 3.12954262e-02f, 7.58609921e-02f, -1.40906880e-02f, 1.10985460e-02f, -1.06817469e-01f,
  -1.61998775e-02f, -3.24444771e-02f, 4.01200391e-02f, 1.33482749e-02f, -8.48881230e-02f, -4.47016954e-03f, 6.36030585e-02f, -1.08422367e-02f, -8.49870294e-02f, -2.25582458e-02f,
  7.83131346e-02f, 2.04842970e-01f, 3.16759497e-02f, -5.67392446e-02f, -8.16276446e-02f, 2.40775738e-02f, 8.60016886e-03f, 4.29932872e-04f, 1.39702931e-01f, -2.63450500e-02f,
  1.24743849e-01f, -1.73177794e-02f, 1.02133431e-01f, -2.15091999e-03f, -6.15008287e-02f, 1.05250716e-01f, 7.46156797e-02f, 6.43708855e-02f, 4.36306559e-02f, 5.36956526e-02f,
  6.59830794e-02f, -2.34927386e-02f, -4.99367807e-03f, -1.43110827e-01f, -5.72904944e-02f, 1.06556490e-01f, 7.89252669e-02f, 9.78914127e-02f, 2.44826023e-02f, -7.32916519e-02f,
  -3.36994946e-01f, 1.02727659e-01f, -2.38570765e-01f, -3.94585401e-01f, -1.61831435e-02f, -1.48909658e-01f, -2.46926829e-01f, -1.85877327e-02f, -1.38030484e-01f, -2.06709057e-01f,
  -1.77463695e-01f, -7.74134398e-02f, 7.37174973e-02f, -1.52368769e-01f, 8.53374749e-02f, 2.49227881e-01f, -2.72819847e-01f, -1.67169258e-01f, 8.50815251e-02f, -1.81934714e-01f,
  -3.88383754e-02f, -7.84713551e-02f, 1.83905996e-02f, 2.58049066e-03f, -1.37695014e-01f, -1.37949556e-01f, -3.43146957e-02f, -3.12797092e-02f, -1.66074380e-01f, 3.38457376e-02f,
  -1.92583859e-01f, -3.10040593e-01f, -2.08018437e-01f, -2.12623224e-01f, -1.05549119e-01f, 2.83521228e-03f, -1.43676013e-01f, 3.97564238e-03f, -7.19712451e-02f, 1.74902529e-02f,
  -5.53846732e-02f, 1.64248236e-02f, -1.51033521e-01f, -2.58703344e-02f, -5.21255843e-02f, -3.95635888e-02f, 1.36599675e-01f, 1.49324443e-02f, 5.95988706e-02f, -7.23369699e-03f,
  -6.56874403e-02f, -5.63633107e-02f, -6.35666698e-02f, -6.45358756e-04f, 1.53614312e-01f, 1.18470164e-02f, 1.82292033e-02f, 5.23380423e-03f, -8.16609710e-02f, 3.40510234e-02f,
  1.81695435e-03f, -7.71273151e-02f, 4.08605151e-02f, -6.12657666e-02f, 1.25211384e-02f, -1.41259842e-02f, -7.37910569e-02f, 4.60472442e-02f, 1.29898237e-02f, -1.77709330e-02f,
  3.06518525e-02f, -2.54945103e-02f, -4.48727608e-02f, 4.39867899e-02f, -2.81597786e-02f, -8.73034373e-02f, -5.06713912e-02f, -4.83305193e-02f, -7.67074933e-04f, -4.52971496e-02f,
  3.06577776e-02f, -1.19318161e-02f, 1.91342626e-02f, -3.54639068e-02f, -7.61043578e-02f, -1.27047347e-02f, -1.28811166e-01f, 5.52817807e-02f, -7.77633339e-02f, -1.13579752e-02f,
  -3.18412364e-01f, -3.71156245e-01f, -8.62655044e-02f, -1.69823021e-01f, -2.63971481e-02f, -3.90641578e-02f, 1.62262749e-02f, -4.76372018e-02f, -7.85536617e-02f, -1.07128985e-01f,
  -1.66963898e-02f, -5.14227115e-02f, -2.15935688e-02f, -2.61038542e-02f, 9.83731635e-03f, -2.10684333e-02f, -4.98490632e-02f, -4.59836461e-02f, -1.35942042e-01f, -6.69414401e-02f,
  9.89826303e-03f, -6.83173863e-03f, 1.01967573e-01f, -6.54262863e-03f, 2.13198531e-02f, -1.06319338e-01f, 4.66480898e-03f, -3.84214241e-03f, 3.32371704e-02f, -1.20892227e-02f,
  -3.76918137e-01f, 1.31300583e-01f, -2.29964331e-02f, -2.66383648e-01f, 1.23170614e-01f, -1.82253942e-01f, -2.21479222e-01f, 2.50010520e-01f, 1.32560566e-01f, -6.87361509e-02f,
  -1.68597680e-02f, -5.69200888e-02f, 6.03660196e-02f, -1.73689932e-01f, -1.61338300e-01f, -1.14560790e-01f, -2.11373284e-01f, -1.23455122e-01f, 1.49389073e-01f, -6.33228570e-02f,
  -4.57281247e-02f, -7.29496852e-02f, -2.00840876e-01f, 8.82566944e-02f, -2.77951397e-02f, 6.44422770e-02f, -1.62620559e-01f, 1.29963323e-01f, -2.34638721e-01f, 1.02078550e-01f,
  -1.49580866e-01f, -9.08852890e-02f, -7.63050467e-02f, 4.13362309e-02f, -6.23232834e-02f, -3.24349366e-02f, -6.27322048e-02f, 5.31265419e-03f, 3.27767543e-02f, 2.54764203e-02f,
  -1.54453246e-02f, 2.78709643e-02f, 7.72660747e-02f, 2.28527151e-02f, 6.83762953e-02f, 8.63552988e-02f, -2.49561910e-02f, 4.62904871e-02f, -4.41893637e-02f, 9.03971419e-02f,
  1.02170192e-01f, -4.53450009e-02f, -6.40800446e-02f, -1.55452594e-01f, -2.60784216e-02f, 3.27026099e-02f, -6.24345541e-02f, 3.38379033e-02f, -9.26592052e-02f, -4.16859053e-02f,
  4.87364791e-02f, -3.06529328e-02f, -2.33366508e-02f, 4.23821844e-02f, 6.43261895e-03f, 1.25409409e-01f, 1.63683519e-02f, 4.34047310e-03f, 5.03988862e-02f, -9.68813803e-03f,
  -6.53790385e-02f, -4.48860340e-02f, 7.60669410e-02f, -1.87115725e-02f, -5.81084974e-02f, -1.82573441e-02f, -2.47622896e-02f, 7.01890960e-02f, 8.48375633e-02f, 2.98530087e-02f,
  1.31363515e-02f, -3.84100638e-02f, 9.41819511e-03f, 1.80047955e-02f, 1.22204684e-01f, 2.08828263e-02f, 5.88946417e-02f, -2.44164839e-03f, 5.92320785e-02f, -6.01908714e-02f,
  -2.99001515e-01f, -3.03697884e-01f, 5.17925881e-02f, 5.88380955e-02f, -2.05325540e-02f, -6.63253590e-02f, -7.55224228e-02f, 2.88784467e-02f, -3.74281779e-02f, 4.57335711e-02f,
  -6.02072552e-02f, -5.08103892e-03f, -1.72959015e-01f, 8.75406787e-02f, 2.99875308e-02f, -5.58037423e-02f, -4.83165421e-02f, -9.88754928e-02f, -7.57631734e-02f, 1.22436337e-01f,
  -5.35726584e-02f, 3.67925763e-02f, -5.33635095e-02f, -5.99512570e-02f, -1.19731069e-01f, -2.02511381e-02f, -1.12517007e-01f, 5.51037192e-02f, -5.27875610e-02f, -1.51641071e-01f,
  -2.27075517e-02f, -4.17308062e-02f, 1.53241932e-01f, 2.87667930e-01f, -1.57764137e-01f, -4.07008231e-01f, -3.79902631e-01f, 5.50724231e-02f, -5.41581810e-02f, -1.42417997e-01f,
  1.70730855e-02f, 5.33345230e-02f, 4.15544435e-02f, 1.46255910e-01f, 2.43952274e-01f, 6.64984882e-02f, 1.05258308e-01f, -9.18374062e-02f, 1.65018946e-01f, 7.63601661e-02f,
  2.32622609e-01f, 6.80198967e-02f, 2.09582895e-01f, 1.09339990e-01f, 2.55329814e-02f, 1.67886689e-01f, 2.78188616e-01f, 9.21585858e-02f, 1.45259649e-01f, -1.12752892e-01f,
  -5.08432090e-02f, 6.97320923e-02f, -3.66868861e-02f, -7.69638345e-02f, 5.77962212e-02f, -3.21501307e-02f, -8.74384642e-02f, 2.57327314e-03f, 1.64032541e-03f, 1.16652809e-01f,
  -3.23214866e-02f, -1.93723943e-02f, -1.45776570e-02f, 4.30807509e-02f, -1.60404537e-02f, 4.38912585e-02f, -5.98472171e-03f, -4.87108529e-03f, 4.45831418e-02f, -3.64316404e-02f,
  -5.73807582e-02f, -7.46619748e-03f, 1.06559001e-01f, -4.20838334e-02f, 2.60766670e-02f, -1.11778289e-01f, -5.44985244e-03f, 8.48781765e-02f, -6.63973996e-03f, 6.14371449e-02f,
  -6.16624840e-02f, 3.47661301e-02f, -6.53717369e-02f, 2.65976526e-02f, 3.85597758e-02f, 2.32829936e-02f, 2.07010955e-02f, -2.05204114e-02f, 2.09375732e-02f, -4.10076715e-02f,
  4.80153225e-02f, 4.05921601e-02f, -5.57189099e-02f, -4.77469154e-03f, -2.90954113e-02f, -6.21801428e-02f, -2.11093184e-02f, -9.25410911e-03f, 7.52661228e-02f, 3.70559224e-04f,
  -2.17728689e-02f, 2.07704548e-02f, -4.55132015e-02f, -2.12190095e-02f, -3.98924761e-02f, 1.54589433e-02f, 8.88032839e-02f, 2.05529723e-02f, -1.12224440e-03f, -4.27357778e-02f,
  4.48254570e-02f, 2.49824747e-01f, -1.16399238e-02f, -1.31674394e-01f, -4.37937304e-02f, 8.21566302e-03f, 1.95032377e-02f, -8.15915912e-02f, 5.14494888e-02f, -6.58403784e-02f,
  -1.22791994e-02f, 4.21272852e-02f, -1.06674023e-02f, -9.97675769e-03f, 6.88031092e-02f, -1.97908003e-02f, 9.08784196e-02f, 1.17615171e-01f, 8.51782113e-02f, 1.92713022e-01f,
  9.25299674e-02f, 1.83483437e-02f, 5.22132553e-02f, 1.25024887e-02f, -5.15179783e-02f, -3.78249697e-02f, 3.00986581e-02f, -7.80363753e-02f, 7.73785487e-02f, 5.07485829e-02f,
  8.80938992e-02f, -3.56900990e-01f, 1.20771289e-01f, -1.10090263e-02f, 1.50730163e-01f, 1.38930574e-01f, 1.11908570e-01f, -1.44297898e-01f, -2.11012572e-01f, -1.76041067e-01f,
  1.33104520e-02f, -8.43117200e-03f, 5.51266931e-02f, 4.41872366e-02f, 3.06540251e-01f, 2.17416417e-02f, 6.54963776e-02f, 9.75701436e-02f, -6.00722842e-02f, -8.77176896e-02f,
  -2.24873498e-02f, 4.61322553e-02f, 2.97266636e-02f, 2.06718855e-02f, 1.65996984e-01f, -6.17459901e-02f, 6.34330139e-02f, 2.22625941e-01f, -5.03406860e-04f, 2.04489663e-01f,
  -1.84425600e-02f, -8.71583000e-02f, -4.59315479e-02f, -3.96004990e-02f, -1.46134198e-01f, -7.57392868e-02f, 2.18200721e-02f, 7.87729844e-02f, 4.73106978e-03f, -1.11076131e-03f,
  -9.36014205e-03f, -5.08762933e-02f, 7.51140639e-02f, 7.22411573e-02f, -1.36058345e-01f, -5.34615517e-02f, 5.19443341e-02f, -4.73056221e-03f, 3.30424234e-02f, -3.94165367e-02f,
  1.57663580e-02f, 6.58384264e-02f, -1.76833309e-02f, 4.81535532e-02f, 4.02723029e-02f, 1.85095333e-02f, 2.70538740e-02f, 6.01025485e-02f, -4.75713871e-02f, -6.51031658e-02f,
  -3.80701199e-02f, 8.22184235e-02f, -1.36264056e-01f, 7.31365904e-02f, 4.28105853e-02f, 1.10307420e-02f, -9.79793593e-02f, 9.73936915e-02f, 4.41342629e-02f, 5.40975444e-02f,
  3.17962505e-02f, 6.44723922e-02f, 1.77296270e-02f, -7.29318103e-03f, -4.90237698e-02f, -3.97225730e-02f, 4.23811637e-02f, -5.85596599e-02f, 3.76250483e-02f, 2.07231659e-02f,
  3.82300913e-02f, 1.29272966e-02f, 1.19435722e-02f, 6.17583431e-02f, -6.80246949e-02f, 3.86249721e-02f, -1.23427603e-02f, 1.11477368e-01f, -3.20447283e-03f, 2.41142400e-02f,
  -2.90268719e-01f, -3.24637026e-01f, 3.24232429e-02f, -6.72876239e-02f, 2.08604801e-02f, -2.51440220e-02f, 9.85176070e-04f, -7.40001304e-03f, -2.67055798e-02f, 1.56900368e-03f,
  -7.87528828e-02f, 6.56154677e-02f, -9.20035467e-02f, 6.16304204e-02f, 4.60739657e-02f, 2.96864510e-02f, -8.14008787e-02f, 2.43169460e-02f, -1.18001923e-02f, 2.03708746e-02f,
  -6.13424331e-02f, -4.06223163e-02f, 1.36421785e-01f, 4.17318679e-02f, 1.82833429e-02f, -9.07454826e-03f, -6.36486188e-02f, -6.06036410e-02f, 5.79339564e-02f, 7.55666345e-02f,
  -4.93149608e-01f, 5.75662777e-02f, 3.44702661e-01f, -1.24945670e-01f, -1.23086087e-01f, 2.73095101e-01f, 2.54497647e-01f, 1.19715622e-02f, -1.49453834e-01f, 9.43128020e-02f,
  8.81247744e-02f, 9.08123329e-03f, 1.18396915e-01f, 9.49117243e-02f, 3.73777449e-02f, 5.20232841e-02f, 3.62906940e-02f, 5.89321405e-02f, -6.38571307e-02f, -1.41527355e-01f,
  -9.67268869e-02f, -1.24121420e-01f, 1.25439689e-01f, -1.31802894e-02f, 1.08506680e-01f, -1.12072162e-01f, -1.26433924e-01f, 7.23087862e-02f, 9.73833501e-02f, 3.40724438e-02f,
  -1.73007935e-01f, -2.14827403e-01f, -9.87533927e-02f, 9.12632141e-03f, 5.55635057e-02f, 7.59941861e-02f, 6.43674210e-02f, 4.12781984e-02f, -8.68532881e-02f, -2.60786470e-02f,
  -5.74874468e-02f, -4.06573154e-02f, -4.28350978e-02f, -2.69095264e-02f, -7.17951879e-02f, 1.08538964e-03f, 7.48128295e-02f, 1.03431661e-02f, 1.64789509e-03f, 1.67615443e-01f,
  1.21629991e-01f, -3.54467542e-03f, 3.67271081e-02f, 5.96373007e-02f, 3.06221843e-02f, -3.72943468e-02f, -9.11586266e-03f, 1.34361594e-03f, 3.25952135e-02f, 3.02174445e-02f,
  7.97580108e-02f, 9.96637251e-03f, 9.15952921e-02f, -6.63064942e-02f, 2.22857986e-02f, 3.97246853e-02f, 1.52790416e-02f, -9.88861471e-02f, 3.15571912e-02f, -8.87547880e-02f,
  -1.13311179e-01f, -5.01540229e-02f, -3.73245403e-02f, 2.57206168e-02f, -3.24144028e-02f, 8.28304607e-03f, 8.01542774e-03f, -3.17506306e-02f, 3.01940157e-03f, 5.47021069e-02f,
  -1.25439670e-02f, 3.70694883e-02f, 2.47205552e-02f, -3.59012224e-02f, 3.77245471e-02f, 5.55161312e-02f, -4.03908193e-02f, 6.85339496e-02f, -4.92452867e-02f, -4.09169355e-03f,
  -3.68226916e-01f, -3.19396883e-01f, -3.12001742e-02f, -3.85243669e-02f, -3.05718277e-02f, 8.06690753e-03f, -9.01503339e-02f, -3.52503434e-02f, -9.70822349e-02f, -7.01895133e-02f,
  2.82417331e-02f, -2.42489018e-02f, 5.77677861e-02f, 4.01640944e-02f, 4.99997884e-02f, -5.97351603e-02f, -2.24618819e-02f, -3.20677310e-02f, -1.36022028e-02f, -2.24628896e-02f,
  1.75952520e-02f, -7.41561456e-03f, 8.01080689e-02f, 6.82127755e-03f, -3.02929953e-02f, 2.71956287e-02f, -1.28277779e-01f, 1.90427396e-02f, -3.18916664e-02f, 3.89611423e-02f,
  4.15089071e-01f, 4.87323990e-03f, 1.95784330e-01f, 1.94536731e-01f, -2.29187004e-04f, -1.04226559e-01f, 6.13490939e-02f, 7.93254655e-03f, 3.18805903e-01f, -5.59500791e-02f,
  -8.08185712e-02f, 2.06387132e-01f, -2.11076677e-01f, 2.18149453e-01f, -3.90171707e-01f, -2.33301654e-01f, -2.86948159e-02f, 1.05256431e-01f, 2.29327381e-02f, 1.89180911e-01f,
  6.04145788e-02f, -1.81024060e-01f, -1.38938278e-01f, -8.17466378e-02f, 2.01672867e-01f, 1.56486735e-01f, -2.01792493e-01f, -1.65293142e-01f, -2.59093568e-03f, -2.00109974e-01f,
  -2.44041290e-02f, 5.07636368e-02f, 4.85974289e-02f, 2.85879131e-02f, 3.97345312e-02f, 2.31912406e-03f, -2.99739446e-02f, -9.68832076e-02f, -1.30382385e-02f, 1.27036674e-02f,
  4.87243794e-02f, -7.37578496e-02f, 3.26730148e-03f, 6.12271903e-03f, 6.84007257e-02f, 9.16264430e-02f, 8.50973949e-02f, 1.78803116e-01f, 9.70320106e-02f, 7.26877749e-02f,
  1.76182747e-01f, 1.15032412e-01f, 1.19557075e-01f, 7.06718192e-02f, 7.24551007e-02f, -1.49371009e-02f, 8.26410484e-03f, 6.54445663e-02f, 6.31195605e-02f, 1.30984066e-02f,
  -5.71740381e-02f, -3.28223146e-02f, -3.97243649e-02f, 3.97408977e-02f, 1.01036370e-01f, 1.17233038e-01f, 1.55267101e-02f, -4.83879037e-02f, 7.12616965e-02f, 2.21733563e-02f,
  5.19957319e-02f, 5.02659045e-02f, 2.77263636e-04f, 3.49023640e-02f, 4.04372774e-02f, 4.81705703e-02f, 4.73640747e-02f, 8.07941146e-03f, 4.70183380e-02f, 1.04395365e-02f,
  -5.47409803e-02f, -3.80558111e-02f, -9.03443061e-03f, -2.17444659e-03f, -5.47837242e-02f, 1.43314607e-03f, 1.80735420e-02f, 1.48416251e-01f, -2.57510655e-02f, 5.28447039e-04f,
  -1.00161627e-01f, -1.49082959e-01f, 5.51820397e-02f, 2.05001999e-02f, 3.03458842e-03f, 4.80965525e-03f, 2.06245631e-02f, -1.87753495e-02f, -4.20017056e-02f, -6.46682084e-02f,
  1.12677375e-02f, 5.94488010e-02f, 5.19870557e-02f, -6.41891509e-02f, -5.13016060e-03f, -1.23722203e-01f, 5.94796464e-02f, 9.26462468e-03f, -4.63427082e-02f, -1.51069583e-02f,
  7.79234469e-02f, -1.01704821e-01f, -2.46839654e-02f, -8.86390975e-04f, 5.40660620e-02f, -3.76343802e-02f, -4.34221514e-02f, -2.17990894e-02f, 6.23035356e-02f, -3.54374200e-02f,
  6.48404136e-02f, -4.07442331e-01f, -1.76413134e-01f, 4.88784276e-02f, 2.71844566e-01f, 5.82537204e-02f, 7.19421264e-03f, 2.54185721e-02f, -9.65579003e-02f, -2.55396605e-01f,
  1.38448458e-02f, -3.70699465e-02f, -2.91755527e-01f, 1.42077431e-01f, 2.04603404e-01f, -1.37462229e-01f, 1.37437060e-01f, 1.84743740e-02f, -4.48413044e-02f, -1.82878658e-01f,
  2.61474010e-02f, 2.23105490e-01f, 7.87487626e-03f, 1.02017991e-01f, 9.27936379e-03f, -1.00877598e-01f, 1.74472295e-02f, -1.38822988e-01f, 2.10292071e-01f, 5.57462685e-02f,
  4.14595231e-02f, -5.37336655e-02f, -6.92098439e-02f, 2.37392671e-02f, -1.68747846e-02f, -7.09477663e-02f, 9.69760865e-02f, 9.18144435e-02f, 8.14155042e-02f, -6.63641393e-02f,
  2.66884044e-02f, 6.40120059e-02f, 4.34080511e-02f, 7.47221336e-02f, 6.43876493e-02f, 1.35035768e-01f, -1.03801559e-03f, -4.52713817e-02f, 2.35891249e-02f, -1.47973135e-01f,
  -3.81036475e-02f, -1.56785585e-02f, 6.68311417e-02f, -2.78585926e-02f, -9.85142142e-02f, -3.12507935e-02f, 2.60089692e-02f, 1.48212109e-02f, -9.32088345e-02f, -7.70803094e-02f,
  4.74063121e-02f, 1.06447563e-02f, 6.64863288e-02f, 1.09449066e-01f, 3.33463475e-02f, 6.82036430e-02f, 8.00710469e-02f, -7.30130123e-03f, -6.28501326e-02f, 2.09098347e-02f,
  -6.01484850e-02f, 2.14401148e-02f, -2.05327244e-03f, -1.30632576e-02f, 2.48149550e-03f, 1.54597778e-02f, 8.12700912e-02f, -3.19145173e-02f, -1.31892726e-01f, -2.72717997e-02f,
  5.88869452e-02f, -1.43308584e-02f, 3.52373384e-02f, -2.80125532e-02f, 3.83048654e-02f, -3.86671610e-02f, 4.21803668e-02f, -8.15277025e-02f, 1.79889947e-02f, 2.96528507e-02f,
  -1.03575766e-01f, -1.99362963e-01f, -6.13579117e-02f, 1.44169450e-01f, -4.34013978e-02f, -6.00007595e-03f, -7.55176991e-02f, 5.40978685e-02f, -8.46425742e-02f, -5.95575571e-02f,
  1.04070380e-01f, 1.26149565e-01f, -8.19578543e-02f, 3.79384607e-02f, 8.89572576e-02f, -8.11955333e-02f, -9.50600393e-03f, 5.90156093e-02f, 5.10704592e-02f, -2.55659185e-02f,
  -3.46428007e-02f, 5.63940369e-02f, -3.02345995e-02f, 4.80363332e-03f, 5.55233657e-02f, -1.52045852e-02f, 8.14744830e-03f, -1.87625866e-02f, -4.10030223e-02f, -2.04840321e-02f,
  1.48925055e-02f, -1.33114532e-01f, -1.54810414e-01f, -1.98269308e-01f, -7.87831098e-02f, -1.50831521e-01f, -9.77374986e-02f, -1.85422733e-01f, 1.49276137e-01f, -1.25125900e-01f,
  -2.08656594e-01f, 1.63320810e-01f, 1.10597238e-01f, -2.00019136e-01f, 2.57575542e-01f, 2.70039141e-01f, -2.77669013e-01f, -7.32509792e-02f, -1.20529709e-02f, -1.86740413e-01f,
  -3.53696719e-02f, -1.27946734e-01f, -7.96877667e-02f, -1.88605592e-01f, -2.59719759e-01f, -2.50972420e-01f, -2.22747377e-03f, -1.58570260e-01f, -2.96006590e-01f, -3.37317698e-02f,
  -7.15522468e-02f, 2.75433753e-02f, -1.85096134e-02f, 1.24652602e-01f, 1.62741505e-02f, -2.04596063e-03f, -8.81571323e-02f, -3.16367019e-03f, -2.47579664e-02f, -2.50112236e-04f,
  7.14844316e-02f, 3.83142270e-02f, 4.81869131e-02f, 7.61869997e-02f, 1.31781744e-02f, -8.86305645e-02f, -5.20363376e-02f, -8.15760568e-02f, -1.01024024e-01f, -5.62681481e-02f,
  -8.61078314e-03f, -6.75520971e-02f, -1.87595487e-02f, 3.77209075e-02f, 1.51547911e-02f, -2.90131755e-02f, 6.75944537e-02f, 6.02763854e-02f, 1.49165168e-02f, 1.91375334e-02f,
  1.28377648e-03f, 6.25991598e-02f, 7.15084150e-02f, -3.05802934e-02f, 2.87040677e-02f, -2.80398317e-02f, -1.88107893e-04f, 1.41106427e-01f, -1.03887707e-01f, 2.68244911e-02f,
  3.34682725e-02f, 6.80575073e-02f, 4.42112871e-02f, -1.06617853e-01f, -1.16553586e-02f, -5.50097302e-02f, 9.75524038e-02f, 2.92245280e-02f, -1.48884535e-01f, -4.76533882e-02f,
  3.02244141e-03f, -3.63568397e-04f, -3.05657238e-02f, -1.26952142e-01f, 1.40285701e-04f, -2.18431223e-02f, 4.39780243e-02f, -6.65541217e-02f, -4.44993749e-02f, 1.07712233e-02f,
  -1.52869653e-02f, 1.81142882e-01f, 5.13782911e-02f, 8.36954266e-02f, -6.20523468e-02f, 4.52358983e-02f, 1.35433972e-02f, -8.41227174e-03f, 6.32691756e-02f, 3.93784530e-02f,
  -4.40482609e-02f, 8.22492316e-02f, 3.06886099e-02f, 3.08869556e-02f, -7.92784542e-02f, -1.00587480e-01f, -8.19004104e-02f, 1.15629332e-02f, 5.45168854e-02f, -1.17441133e-01f,
  -1.90506913e-02f, 4.33184812e-03f, 8.73982161e-02f, -4.28910507e-03f, -4.44284864e-02f, 2.48615928e-02f, 3.90504822e-02f, -3.37324701e-02f, -7.46066198e-02f, 6.68871254e-02f,
  3.20863456e-01f, -6.28128722e-02f, -3.32895592e-02f, 1.72592714e-01f, 1.89632237e-01f, 1.44029155e-01f, 1.54507950e-01f, 1.48001730e-01f, 3.60512555e-01f, -1.46017745e-01f,
  -6.30014390e-03f, -1.34349793e-01f, -1.76468790e-01f, 1.25351936e-01f, -1.78178679e-03f, 1.09727897e-01f, 2.79480338e-01f, 1.56971872e-01f, 1.97177038e-01f, 4.67704795e-02f,
  1.06287062e-01f, -1.84772629e-03f, -2.20923617e-01f, -2.22014170e-02f, 1.24591067e-01f, -3.04571986e-02f, -2.18629465e-01f, -7.68366642e-03f, -1.07473679e-01f, 8.76790956e-02f,
  1.16163597e-01f, 9.95126218e-02f, -1.14338741e-01f, -6.30862564e-02f, 7.95420706e-02f, -4.54818681e-02f, 9.24637634e-03f, -9.90206674e-02f, -8.71947315e-03f, 6.66526556e-02f,
  -1.19641677e-01f, -2.31920648e-02f, 9.42919627e-02f, 5.14196679e-02f, -1.09139428e-01f, 3.29567008e-02f, 6.02726229e-02f, 8.91429856e-02f, 4.08208854e-02f, -2.41081808e-02f,
  -1.02643989e-01f, 5.81424534e-02f, 1.53446734e-01f, 6.82079792e-02f, -1.73517670e-02f, 8.82439092e-02f, 7.03960955e-02f, -5.75912781e-02f, -6.51128963e-02f, 7.90658221e-02f,
  4.83344570e-02f, 3.17448750e-02f, -1.71235744e-02f, 2.53607845e-03f, 4.03029919e-02f, 1.96941737e-02f, 3.40531692e-02f, 1.33703435e-02f, 1.00011058e-01f, -2.28823442e-02f,
  -2.54723970e-02f, 1.17623538e-01f, 1.15501136e-01f, -3.68926078e-02f, 7.93517753e-03f, 8.44500680e-03f, -3.65582928e-02f, 1.08090132e-01f, 3.73582505e-02f, 2.93782428e-02f,
  2.28005480e-02f, -6.23287112e-02f, -9.61728469e-02f, -1.00862220e-01f, -7.37972511e-03f, -1.38540957e-02f, 2.90634707e-02f, 1.47935972e-01f, -5.96255474e-02f, -5.64415492e-02f,
  1.88719470e-03f, 6.89189658e-02f, 3.16077983e-03f, -1.15619591e-02f, -3.01268045e-02f, 2.93765850e-02f, 7.34427646e-02f, 8.59238729e-02f, -2.40438562e-02f, -2.46724230e-03f,
  3.17105688e-02f, 2.09413990e-02f, 4.21733670e-02f, 2.35681217e-02f, -6.01736940e-02f, -1.20423838e-01f, 2.31053680e-02f, 5.16154766e-02f, -1.04780413e-01f, -1.27447829e-01f,
  -4.03257869e-02f, 3.84340296e-03f, 6.12154268e-02f, -4.51743156e-02f, -7.92620033e-02f, 3.09112892e-02f, -2.84096394e-02f, 4.49656807e-02f, -3.35709825e-02f, 4.89777662e-02f,
  2.13811368e-01f, -1.50876522e-01f, 1.08538374e-01f, 3.29731524e-01f, 1.82265624e-01f, 2.33728066e-02f, 2.69814461e-01f, 1.16020039e-01f, 3.00226957e-01f, -1.97421521e-01f,
  -4.29514199e-02f, -1.30597830e-01f, -1.02909785e-02f, -1.66242719e-01f, 1.00012444e-01f, -1.10210359e-01f, 8.87935981e-03f, -1.18593805e-01f, 7.86183998e-02f, 3.86033431e-02f,
  1.25227153e-01f, 6.21006377e-02f, 1.22149438e-01f, -2.24369973e-01f, -3.90129238e-02f, -9.09732133e-02f, -8.71198922e-02f, 4.94494252e-02f, -1.08390369e-01f, -3.69878262e-02f,
  9.33902413e-02f, -6.18909225e-02f, -6.17648624e-02f, 4.49788384e-03f, 3.74087617e-02f, 2.70073698e-03f, 3.98196243e-02f, 1.95279100e-03f, 8.28475803e-02f, 2.18507014e-02f,
  -5.90746887e-02f, 2.75604706e-02f, 4.06725742e-02f, 9.65407789e-02f, 3.88173684e-02f, 8.10166635e-03f, 3.47162187e-02f, -9.59590729e-03f, 2.36661192e-02f, -3.46070528e-02f,
  -4.90817726e-02f, -4.04808158e-03f, -3.11182588e-02f, -7.53072873e-02f, -1.02373973e-01f, -8.88858922e-04f, -1.98289398e-02f, -1.14563473e-01f, -5.53353541e-02f, 1.05395960e-02f,
  -8.25446546e-02f, 7.98450969e-03f, -5.35987725e-04f, 5.40692806e-02f, 5.06041534e-02f, 9.89407301e-03f, 5.68142906e-02f, 2.15547327e-02f, 2.63100043e-02f, 5.92399761e-02f,
  1.94729455e-02f, -4.29476202e-02f, 2.44278628e-02f, 1.22662112e-01f, -4.89309654e-02f, -2.68940497e-02f, -3.10194679e-02f, -7.36618787e-03f, -7.27649257e-02f, -5.04291244e-02f,
  2.46498659e-02f, -1.21739125e-02f, -3.87310353e-03f, 4.54444215e-02f, 1.06760878e-02f, 5.73367737e-02f, 4.68690181e-04f, -5.99303916e-02f, 2.73241196e-02f, -1.34492922e-03f,
  -8.93080682e-02f, -9.58216414e-02f, 6.56831786e-02f, -1.26819730e-01f, -5.08413315e-02f, -1.70122966e-01f, 7.09415898e-02f, -5.06580658e-02f, -6.83749616e-02f, 4.77475710e-02f,
  -2.45606229e-02f, 3.16737257e-02f, -1.05014764e-01f, 3.07100429e-03f, -1.16376588e-02f, -6.27559796e-02f, -9.05017927e-02f, -1.33148044e-01f, -4.74097766e-03f, 5.05343545e-03f,
  -6.96869753e-03f, -5.98611608e-02f, -6.69326186e-02f, -5.55785820e-02f, -5.80394268e-02f, -2.90522818e-02f, -5.66427335e-02f, 1.83389951e-02f, 1.32499067e-02f, -5.99661358e-02f,
  2.86383599e-01f, -1.31368279e-01f, -5.94354384e-02f, 1.49281010e-01f, 1.83671534e-01f, -6.77877292e-02f, 1.69530953e-03f, 2.79535145e-01f, 5.08946121e-01f, -1.92406669e-01f,
  -1.56589586e-03f, -1.53447449e-01f, -6.52053356e-02f, -7.79537782e-02f, -1.14508092e-01f, -1.04027823e-01f, 1.42864138e-01f, -1.63013503e-01f, 1.77571699e-01f, -7.08250096e-03f,
  1.60322025e-01f, 1.17012253e-02f, 1.63124166e-02f, -5.63782826e-02f, 4.69267517e-02f, 8.82098004e-02f, -1.58809364e-01f, -1.47710472e-01f, -1.83232054e-01f, -1.73424914e-01f,
  5.31370156e-02f, 5.70526905e-02f, -1.55732810e-01f, 2.22382154e-02f, 7.89883062e-02f, 5.77092320e-02f, -1.19834647e-01f, -1.29759640e-01f, -4.15275246e-02f, -2.45570540e-02f,
  -1.44348353e-01f, -3.31801316e-03f, -1.57393441e-02f, -1.65248942e-02f, 1.27042845e-01f, 3.67941819e-02f, 6.16667308e-02f, 1.12435505e-01f, 9.35115572e-03f, -6.81046173e-02f,
  2.83575505e-02f, -4.70393412e-02f, -2.76883338e-02f, -8.59467126e-03f, -5.05844913e-02f, -1.76519025e-02f, -2.34766640e-02f, -1.77278996e-01f, -5.81571646e-02f, -1.07034799e-02f,
  -3.87490401e-03f, -3.99145670e-02f, -2.19294168e-02f, -3.53292711e-02f, 5.18154576e-02f, 1.23318307e-01f, 2.11388990e-02f, 3.95042896e-02f, 6.01057559e-02f, 5.77756315e-02f,
  1.37067186e-02f, -5.89480214e-02f, 1.65217277e-02f, 3.98088433e-02f, -7.32300729e-02f, 1.18981972e-01f, 1.44072985e-02f, -2.43963972e-02f, -4.84456420e-02f, 1.14989966e-01f,
  -1.66938435e-02f, 2.22718120e-02f, -7.94080868e-02f, 4.57337731e-03f, -4.73048501e-02f, -7.78471911e-03f, 1.73593983e-02f, 3.10878213e-02f, 8.52638036e-02f, 5.64488992e-02f,
  -8.54073092e-03f, -1.22411422e-01f, -1.20963000e-01f, -5.86060733e-02f, 1.34880636e-02f, -3.87968570e-02f, 1.44697661e-02f, -8.19825307e-02f, 2.50096563e-02f, 1.05282731e-01f,
  -6.85801953e-02f, -5.09894677e-02f, -6.15002448e-03f, 8.25447887e-02f, -5.57187907e-02f, 8.57903436e-02f, -7.05248639e-02f, 1.28802052e-02f, 3.18486802e-02f, 4.20163721e-02f,
  1.96044575e-02f, 1.10879421e-01f, 3.30564938e-02f, 6.00264687e-03f, 6.26206398e-02f, -1.24131545e-01f, -5.81223192e-03f, -3.35459709e-02f, 7.89658725e-03f, 8.42104703e-02f,
  -6.53004125e-02f, 8.76258612e-02f, -1.48979072e-02f, 1.29038513e-01f, -1.36930883e-01f, -3.40813130e-01f, -1.68736368e-01f, 6.54374734e-02f, -1.88567847e-01f, -4.88821464e-03f,
  7.52633661e-02f, -1.85223132e-01f, 1.22116052e-01f, 1.90698504e-01f, 7.59655833e-02f, 9.53191370e-02f, 1.10247016e-01f, -5.65557741e-02f, 7.26886839e-02f, 1.75258175e-01f,
  6.82290792e-02f, 1.08509563e-01f, 2.24705264e-01f, 1.16508521e-01f, 3.13985720e-02f, 1.04513206e-03f, 1.37713939e-01f, 6.35210797e-02f, 8.98479596e-02f, -1.21737182e-01f,
  -4.08141576e-02f, 3.75110619e-02f, 3.46533358e-02f, -7.72722438e-02f, 6.16533719e-02f, -4.43845540e-02f, -8.15033391e-02f, -4.28144857e-02f, 3.57307903e-02f, -6.53794557e-02f,
  -1.11931048e-01f, -1.39250671e-02f, -4.24235091e-02f, 3.35489698e-02f, 1.06158005e-02f, -1.46634653e-02f, -8.01476464e-02f, -1.59860045e-01f, 1.70197524e-02f, -4.68220096e-03f,
  -2.75362805e-02f, -4.27721739e-02f, -2.71596014e-02f, -5.17638354e-03f, 1.34382145e-02f, 1.20523488e-02f, -1.51826357e-02f, -7.17299283e-02f, -4.46553007e-02f, -6.81530163e-02f,
  -5.58798686e-02f, -1.11157328e-01f, -5.41124791e-02f, -7.50317574e-02f, -1.11331560e-01f, 4.75821905e-02f, -5.10177277e-02f, 4.34014797e-02f, 2.37096362e-02f, 3.69893350e-02f,
  -2.58173165e-03f, -5.13461046e-02f, -3.91362561e-03f, -1.25403795e-02f, -2.24066209e-02f, -3.03441826e-02f, -2.59462111e-02f, 1.15806551e-03f, 4.20709997e-02f, 1.66411623e-02f,
  -4.16270681e-02f, 9.94716287e-02f, -5.50651662e-02f, -4.10498939e-02f, 4.49080486e-03f, 7.06784725e-02f, 5.07217534e-02f, 1.05070718e-01f, -3.31965671e-03f, -5.44497035e-02f,
  9.13285688e-02f, 1.67880908e-01f, -5.44304773e-02f, -4.76789176e-02f, -2.48941164e-02f, 1.50481821e-03f, 1.31488210e-02f, 6.91632926e-02f, 8.46430019e-04f, 5.88153712e-02f,
  7.82469362e-02f, -2.79323477e-02f, 4.92057875e-02f, 5.74139133e-02f, -1.05017439e-01f, -2.52224728e-02f, 1.51856756e-02f, -6.93262666e-02f, -6.66076690e-02f, -1.06837295e-01f,
  -1.50642851e-02f, 5.68149053e-03f, 4.59490716e-02f, -1.46521240e-01f, 1.12106395e-03f, -7.35389590e-02f, -1.47378191e-01f, 6.85761273e-02f, 2.63722613e-02f, -7.98085034e-02f,
  3.95011097e-01f, -3.53459150e-01f, -8.10438395e-02f, 1.65503934e-01f, 2.41362676e-01f, 6.95846230e-02f, 9.97493714e-02f, 7.72792324e-02f, 3.85273769e-02f, -1.47147775e-01f,
  1.58355355e-01f, -8.57738629e-02f, -1.62520573e-01f, 1.73673987e-01f, 1.63591966e-01f, -1.14343122e-01f, 6.35517314e-02f, 5.43974340e-02f, -6.46140873e-02f, -1.62249207e-02f,
  1.57635033e-01f, 1.85822949e-01f, 8.03411976e-02f, 2.56582238e-02f, 3.11514512e-02f, 1.05643074e-03f, -3.83051224e-02f, -6.60247281e-02f, -7.93716405e-03f, 1.24816880e-01f,
  -9.36941057e-02f, 1.31002553e-02f, 7.38890246e-02f, -5.84753342e-02f, 1.90456249e-02f, -8.08478370e-02f, -6.96247369e-02f, -1.49383917e-02f, 5.75244389e-02f, -5.42118773e-02f,
  -1.53511539e-01f, 7.71245509e-02f, 1.20386675e-01f, 8.14799685e-03f, -2.44910624e-02f, 8.82416070e-02f, 1.11966453e-01f, -4.47555892e-02f, -5.29124923e-02f, -8.78148433e-03f,
  1.95154995e-02f, -3.52420472e-02f, 2.68923249e-02f, 4.07803804e-02f, 3.82257439e-02f, 8.25130418e-02f, -1.09371476e-01f, -2.63455492e-02f, 4.63770479e-02f, 5.20339720e-02f,
  7.67186508e-02f, -4.20365520e-02f, -1.58065566e-04f, 2.95605808e-02f, -2.00651940e-02f, 7.98682421e-02f, -2.02266835e-02f, 3.45259793e-02f, -6.04978353e-02f, -7.59564489e-02f,
  6.37643337e-02f, 5.20347245e-02f, -6.70043170e-04f, -1.26837296e-02f, 4.01292788e-03f, -1.80018973e-02f, -8.18255693e-02f, 9.83218625e-02f, -1.55951325e-02f, -2.17907578e-02f,
  1.35707213e-02f, -2.81969607e-02f, -1.11638069e-01f, 3.85325924e-02f, 2.72555519e-02f, -3.08341533e-02f, -1.73404370e-03f, -1.18692201e-02f, -4.33036918e-03f, 1.65357012e-02f,
  -2.33113930e-01f, -3.05977762e-01f, 2.35245451e-02f, 6.24516122e-02f, -7.23515227e-02f, -4.71032131e-03f, -9.38040763e-02f, 1.77831762e-02f, -1.30703552e-02f, 1.82199501e-03f,
  -4.15263027e-02f, -4.10738960e-02f, 1.21268211e-02f, -1.63041651e-02f, -3.00431605e-02f, 2.46319566e-02f, -4.41846326e-02f, -1.86113063e-02f, 1.78648569e-02f, -8.41802582e-02f,
  -5.04277572e-02f, -1.16835393e-01f, 8.56963694e-02f, -1.25891240e-02f, -2.95420573e-03f, -6.67978749e-02f, -9.00127590e-02f, 7.48392045e-02f, 3.56637202e-02f, -5.81442285e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  8.01121444e-02f, 1.46072343e-01f, 3.33290249e-02f, -6.18717559e-02f, 1.51568815e-01f, 1.59538001e-01f, 7.39986748e-02f, 3.62078883e-02f, 1.54911324e-01f, 3.74249034e-02f,
  1.00309841e-01f, 4.26578298e-02f, 1.11851059e-01f, 1.70490481e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -6.91079646e-02f, 4.65223081e-02f, 2.47410350e-02f, 3.94932963e-02f, -1.32693410e-01f, 1.49577394e-01f, 8.76371413e-02f, 2.05555826e-01f, 1.47529021e-01f, -4.14170325e-02f,
  1.42878473e-01f, 6.79777935e-02f, -4.53777285e-03f, -2.57117897e-02f, -1.59804374e-01f, 4.29000072e-02f, 1.74181517e-02f, 1.19585432e-01f, -9.49675813e-02f, 1.02029247e-02f,
  -4.65974137e-02f, 1.44800609e-02f, -1.68693349e-01f, 5.17510343e-03f, 2.46372391e-02f, 1.68062121e-01f, 3.53376389e-01f, 5.44987433e-02f, -1.84144005e-01f, -6.58415109e-02f,
  1.01468548e-01f, 1.39041059e-02f, -2.23772712e-02f, -1.59066264e-02f, 1.65065732e-02f, -2.49419987e-01f, 4.81604710e-02f, 3.27145219e-01f, -3.37185025e-01f, 1.62755679e-02f,
  -8.18468258e-02f, -2.09846810e-01f, -4.47698496e-02f, -7.80933648e-02f, 5.29486462e-02f, 4.11423482e-02f, -1.52497903e-01f, -6.99494872e-03f, -6.23969035e-03f, -1.27844036e-01f,
  7.53061771e-02f, 1.96523145e-01f, 8.59445930e-02f, 2.12806538e-01f, -2.46620774e-01f, -8.20048600e-02f, -1.48038894e-01f, -2.88256168e-01f, 1.38524607e-01f, -1.27946045e-02f,
  -9.92022455e-02f, -7.08881617e-02f, 2.10929617e-01f, -1.80774882e-01f, 8.71726722e-02f, -1.25268817e-01f, -1.88726768e-01f, 4.48360369e-02f, -1.94929317e-01f, 2.12842733e-01f,
  -9.41611826e-02f, 1.39347211e-01f, 1.39969409e-01f, 1.37842655e-01f, -2.47353204e-02f, 5.10662943e-02f, 4.18558307e-02f, 1.82606295e-01f, -6.79025948e-02f, 2.22753454e-02f,
  -8.33911896e-02f, 6.72195405e-02f, 1.42694518e-01f, 2.96284109e-02f, 4.96304296e-02f, 2.68827472e-02f, 4.91254665e-02f, 1.81154042e-01f, -7.59787858e-02f, 3.07892740e-01f,
  3.27663541e-01f, 8.87331180e-03f, 2.50128899e-02f, -2.27678418e-02f, 3.81681584e-02f, -6.09378293e-02f, -1.17618572e-02f, 1.44183673e-02f, -2.09584028e-01f, -5.46142198e-02f,
  -2.34027132e-02f, 3.26867789e-01f, 2.89144460e-02f, 1.58894718e-01f, 1.36626258e-01f, -8.26461241e-02f, 9.68605578e-02f, 8.90197083e-02f, -5.33603951e-02f, -9.67501625e-02f,
  1.15269512e-01f, -1.30232885e-01f, 4.07129303e-02f, -1.64203957e-01f, -1.23314559e-01f, 3.23321149e-02f, 1.34490594e-01f, -2.49805838e-01f, -4.51819450e-02f, 1.60010859e-01f,
  -1.62794694e-01f, -1.27069131e-01f, 7.87196234e-02f, 1.02919629e-02f, -2.08542228e-01f, -2.57428437e-01f, 9.19053778e-02f, -2.01299503e-01f, -4.20772471e-02f, 1.47515386e-01f,
  6.59543043e-03f, 3.03937979e-02f, 1.41346440e-01f, 3.42675596e-02f, -6.07195757e-02f, 3.34896669e-02f, 7.36725703e-02f, 1.32408470e-01f, 4.92159911e-02f, -1.02585226e-01f,
  2.60117739e-01f, -3.61511521e-02f, -8.86418447e-02f, 9.30897146e-02f, 2.12446362e-01f, -5.50314784e-02f, 1.05046108e-01f, 5.87389208e-02f, 1.52865589e-01f, -1.27298543e-02f,
  2.62677968e-02f, -7.31382519e-02f, -6.60814531e-03f, -1.98669538e-01f, 1.54695641e-02f, 4.61644568e-02f, 1.91130131e-01f, 1.53349042e-01f, 1.66923404e-01f, 6.44579604e-02f,
  -1.07622527e-01f, 4.59682606e-02f, 1.26459673e-01f, 2.67434299e-01f, -4.41115350e-02f, -1.49157509e-01f, 4.29555364e-02f, 1.40136153e-01f, 6.79121688e-02f, 6.77053407e-02f,
  -1.87437221e-01f, -3.04276079e-01f, -7.90922716e-02f, -3.61973457e-02f, 6.46803007e-02f, 1.86418235e-01f, 2.35322878e-01f, -7.09776208e-02f, 4.03713398e-02f, 2.29989871e-01f,
  2.42247313e-01f, -2.57397085e-01f, 5.24751395e-02f, -9.69398320e-02f, 2.13440098e-02f, 5.21022230e-02f, 1.36552244e-01f, 6.48097247e-02f, 9.28633735e-02f, 8.66830498e-02f,
  -2.66351938e-01f, 1.06867850e-01f, 1.83707085e-02f, -1.40649185e-01f, 1.80157106e-02f, 2.21507698e-01f, -1.29411697e-01f, 1.55414626e-01f, -1.38108730e-01f, -5.49088828e-02f,
  9.02472436e-02f, -2.61940947e-03f, -1.22256935e-01f, -6.23856224e-02f, -3.24862450e-01f, 7.20097795e-02f, -1.09857582e-01f, 1.13523267e-01f, -1.02132984e-01f, 6.47177594e-03f,
  1.44628659e-01f, 3.80140804e-02f, -1.05732724e-01f, 3.22192721e-02f, -3.85954939e-02f, 1.10407509e-01f, -2.34736390e-02f, 2.93268830e-01f, 2.10090742e-01f, 1.35439962e-01f,
  -2.30319966e-02f, -2.43417352e-01f, 9.70951095e-03f, 1.18115187e-01f, 1.67590424e-01f, -2.02517156e-02f, 4.76084203e-02f, 9.55559537e-02f, 1.21477321e-01f, 2.21824646e-01f,
  4.88219075e-02f, 3.06502003e-02f, -1.09315604e-01f, -2.38023415e-01f, -1.56290665e-01f, 3.27312708e-01f, -1.47951078e-02f, -2.20871255e-01f, 1.19398698e-01f, -3.31408978e-01f,
  4.13007848e-02f, 3.94623056e-02f, 1.43724039e-01f, -1.87024251e-01f, -3.55036944e-01f, 2.00525269e-01f, -3.65618579e-02f, 3.72881591e-02f, -4.72304821e-02f, -2.30228022e-01f,
  1.56595092e-02f, 2.52712488e-01f, 1.48824796e-01f, -2.24613473e-02f, 4.70038988e-02f, -1.90065093e-02f, -9.23953354e-02f, 5.44233099e-02f, -2.20642500e-02f, -1.07512541e-01f,
  -7.59866536e-02f, -3.34028825e-02f, -1.10981777e-01f, -1.55350164e-01f, 1.33484840e-01f, -6.67992011e-02f, -5.70644774e-02f, -3.94670889e-02f, -6.35603666e-02f, 8.82438347e-02f,
  4.93937023e-02f, 4.82123792e-02f, 2.06015632e-02f, -1.61792845e-01f, 1.72196031e-01f, 4.44372883e-03f, -2.70175021e-02f, -5.45326695e-02f, 3.97803672e-02f, 3.15636350e-03f,
  3.26166749e-02f, -2.81445503e-01f, -1.82689711e-01f, 9.06812400e-02f, -4.35222313e-02f, 7.30978623e-02f, -1.31920725e-01f, 1.18218884e-01f, 1.41962126e-01f, 1.54769659e-01f,
  1.12770393e-01f, 1.62360221e-01f, -6.37058392e-02f, -1.53367147e-01f, 1.52632892e-01f, 1.03214988e-02f, -3.48583646e-02f, 8.42998773e-02f, -8.24534297e-02f, 9.34552103e-02f,
  -1.27324477e-01f, 1.63034588e-01f, -5.49530126e-02f, -2.21178960e-02f, 5.27727306e-02f, 1.13467142e-01f, -1.00240946e-01f, 3.79946940e-02f, 1.87792853e-02f, -1.39173999e-01f,
  1.45433366e-01f, 6.46774694e-02f, -2.84530781e-02f, 1.58817768e-01f, -1.08256325e-01f, -1.38646632e-01f, 1.85876682e-01f, 1.32410675e-01f, 1.25681525e-02f, 2.73114115e-01f,
  -7.82173350e-02f, 1.66732185e-02f, -9.41371396e-02f, -1.54113043e-02f, -1.32132366e-01f, -3.94948199e-03f, 1.04740746e-01f, 1.26449659e-01f, -2.05689613e-02f, 1.43305093e-01f,
  -2.33748741e-02f, -4.14639562e-02f, 2.94912737e-02f, 2.78217383e-02f, 3.35160680e-02f, 6.90057129e-02f, -8.32372159e-02f, -6.09735884e-02f, -1.97281539e-02f, -1.33542195e-01f,
  -2.64942199e-01f, -1.62862867e-01f, -1.04398064e-01f, 1.35863632e-01f, -1.43624797e-01f, 4.80659194e-02f, 2.00110480e-01f, 1.28991112e-01f, -2.85914570e-01f, 3.70718427e-02f,
  1.65362939e-01f, -2.44804546e-02f, -1.45293444e-01f, -8.60807598e-02f, -4.58269157e-02f, -2.16291040e-01f, -1.49929717e-01f, 2.00276226e-01f, 5.87366931e-02f, 5.68224788e-02f,
  -1.20948907e-02f, 4.75130603e-03f, 2.36951679e-01f, 2.49159545e-01f, 2.03644350e-01f, 1.13574557e-01f, -1.89602330e-01f, -2.54658043e-01f, 1.17513217e-01f, -1.81242332e-01f,
  -9.81873870e-02f, 2.52462089e-01f, 2.13080138e-01f, 2.30804265e-01f, -6.63542077e-02f, 1.10451378e-01f, -1.90522522e-01f, -4.07189131e-02f, -1.30572498e-01f, -9.49841738e-02f,
  -9.58933532e-02f, -1.80728823e-01f, 1.96641102e-01f, -8.81428346e-02f, 2.29072809e-01f, 8.26122463e-02f, -2.46863235e-02f, 6.80315197e-02f, -1.09485099e-02f, 1.28707975e-01f,
  1.22893192e-01f, 8.17263946e-02f, 2.21558847e-02f, 9.72842500e-02f, 1.30261272e-01f, 2.04463422e-01f, 1.13249488e-01f, 1.08598834e-02f, 4.20808308e-02f, 1.00641765e-01f,
  -3.65854688e-02f, -9.05800089e-02f, -5.27327880e-02f, -6.96279705e-02f, -1.08469464e-01f, -1.79931358e-01f, 1.30835520e-02f, 8.49372223e-02f, -7.60134533e-02f, 2.82121658e-01f,
  2.11979136e-01f, -1.61563575e-01f, -1.95209950e-01f, 2.63456821e-01f, -1.67999536e-01f, -6.70704022e-02f, -6.37550876e-02f, -5.54564595e-02f, -1.40219945e-02f, -1.59696326e-01f,
  -1.28336191e-01f, 1.33540004e-01f, 8.10707361e-02f, 2.78286450e-03f, -6.79397285e-02f, -2.72369403e-02f, 2.75859863e-01f, -1.51409265e-02f, 1.80049211e-01f, -3.72607969e-02f,
  -1.87892959e-01f, 1.60985380e-01f, -1.41758069e-01f, -2.94875950e-01f, -3.84190120e-02f, 1.03089005e-01f, 1.99113816e-01f, -4.99016829e-02f, -9.86016989e-02f, 1.96766227e-01f,
  3.93968560e-02f, -1.64298594e-01f, -1.72113493e-01f, 2.99998443e-03f, -2.37501949e-01f, -1.76856965e-01f, 7.03507140e-02f, -1.94781199e-01f, -2.49808043e-01f, -1.15509525e-01f,
  1.47423089e-01f, 4.02873196e-02f, -8.52968022e-02f, -1.96206748e-01f, -1.24079166e-02f, 1.17751770e-02f, 6.44493997e-02f, -6.33769259e-02f, -4.72019948e-02f, -1.20416388e-01f,
  -1.90646872e-01f, 4.16389145e-02f, -7.64062554e-02f, -1.37683213e-01f, -1.65614426e-01f, 1.18846736e-04f, 1.35628000e-01f, 2.23660585e-03f, -1.14858113e-01f, 2.93723699e-02f,
  5.81725575e-02f, -9.30803921e-03f, -7.52259570e-04f, -8.12601373e-02f, -1.56383052e-01f, -5.30496761e-02f, -2.87979901e-01f, -1.41564995e-01f, -3.56294438e-02f, -9.90361199e-02f,
  -3.84572968e-02f, 1.86688855e-01f, 2.20112920e-01f, 4.73378487e-02f, 6.17731586e-02f, -1.83285549e-01f, -1.67805374e-01f, -7.87123758e-03f, -1.88156053e-01f, 8.48365203e-02f,
  -8.39152038e-02f, 3.84284579e-03f, 1.07486725e-01f, 2.33631670e-01f, -2.35753879e-01f, -1.89276546e-01f, 2.75455266e-01f, 3.19895335e-02f, 3.78452912e-02f, 5.90514950e-02f,
  -1.38705298e-02f, 6.36619776e-02f, 7.35604465e-02f, 1.48159310e-01f, -3.82216364e-01f, 2.21311778e-01f, 1.27609506e-01f, -2.99213737e-01f, -2.44871508e-02f, -1.24164969e-01f,
  -6.39458001e-02f, 2.46444624e-02f, -3.21406573e-02f, 1.45480871e-01f, 3.36615145e-02f, -1.22026622e-01f, -4.11459524e-03f, 4.92387339e-02f, 6.65391982e-02f, -5.36272153e-02f,
  4.27124314e-02f, -8.71808082e-03f, 8.68010800e-03f, -7.92978257e-02f, 2.85299242e-01f, -1.08914338e-01f, 1.18215188e-01f, 1.65221289e-01f, 2.59201705e-01f, 1.73097819e-01f,
  -1.39330387e-01f, -2.01768428e-02f, 4.19732295e-02f, -6.48666993e-02f, 5.33972159e-02f, 1.90663468e-02f, 1.72879249e-01f, 5.23589216e-02f, -5.50846271e-02f, -5.92054091e-02f,
  2.13989973e-01f, 1.40104502e-01f, 7.52675012e-02f, -6.76772147e-02f, -1.60499841e-01f, -1.58124402e-01f, 5.41325025e-02f, -1.42247438e-01f, -4.62679937e-03f, 2.80525964e-02f,
  9.45670232e-02f, -8.76914710e-02f, 1.82378277e-01f, 1.40462220e-01f, 7.86134973e-02f, -2.51236737e-01f, 1.17822602e-01f, -3.76504734e-02f, -1.56086013e-01f, 1.93982303e-01f,
  -1.15675271e-01f, -3.94086130e-02f, -1.03426643e-01f, 5.52034331e-03f, 2.56184727e-01f, -5.51723167e-02f, -2.46393010e-01f, -1.21621434e-02f, 1.17961563e-01f, -2.32481182e-01f,
  1.93911657e-01f, 2.49529295e-02f, -2.66266674e-01f, 4.36237082e-02f, -1.59186140e-01f, -2.90760577e-01f, -8.27714130e-02f, -3.09476852e-02f, 1.06296577e-01f, -2.82592587e-02f,
  6.16889335e-02f, -1.19073749e-01f, 4.46054302e-02f, 7.26180822e-02f, -1.07214257e-01f, -3.26744542e-02f, -1.19142141e-02f, -8.81081522e-02f, -1.44893870e-01f, -1.78600833e-01f,
  -7.26995766e-02f, -1.37771055e-01f, 9.96445119e-02f, 1.38142496e-01f, -3.10606867e-01f, 6.81047365e-02f, -3.26417610e-02f, 8.88046399e-02f, 1.09610491e-01f, -8.56765881e-02f,
  -4.68244366e-02f, 2.65193731e-03f, -7.98930302e-02f, -8.54917541e-02f, 4.97283414e-02f, -1.54646337e-01f, 1.03680521e-01f, 2.73969263e-01f, 6.34976178e-02f, 6.93085021e-05f,
  -3.12264323e-01f, -6.70673475e-02f, -8.90492871e-02f, 1.28074899e-01f, -2.88033813e-01f, -2.16262564e-01f, -2.74384797e-01f, 1.26975954e-01f, -1.53887253e-02f, -1.08409107e-01f,
  -5.23064984e-03f, -1.12906493e-01f, -2.14023262e-01f, 1.18033759e-01f, -4.73664813e-02f, 7.38620311e-02f, 3.01924169e-01f, 1.02078661e-01f, 6.69029206e-02f, -4.08945940e-02f,
  -5.77259511e-02f, -5.86670227e-02f, -2.84033686e-01f, 1.11054361e-01f, -4.82495949e-02f, -8.53533819e-02f, -3.02979827e-01f, -1.13368049e-01f, 1.36107251e-01f, 1.60724238e-01f,
  1.47539601e-01f, -7.39795193e-02f, -1.64661139e-01f, 2.41921823e-02f, 3.41218710e-02f, 1.46547765e-01f, 1.79241076e-01f, -3.72516625e-02f, -3.36837284e-02f, 2.04632469e-02f,
  -2.14362234e-01f, -5.31627908e-02f, 1.52246475e-01f, 8.77802819e-03f, 1.23262152e-01f, 1.06722653e-01f, -4.18004543e-02f, -1.48527369e-01f, 1.01529635e-01f, -8.33003446e-02f,
  -1.42059475e-02f, -2.30370983e-01f, -2.05879375e-01f, -8.28685760e-02f, -9.00214314e-02f, 6.54205829e-02f, 9.12154466e-02f, -1.04857482e-01f, 1.31883577e-01f, 2.37696484e-01f,
  -9.89790633e-02f, -2.73069710e-01f, -3.99380736e-03f, -2.07608581e-01f, -8.32752436e-02f, 2.09048335e-02f, -1.98580310e-01f, 1.99399590e-01f, 1.33726463e-01f, 1.71530828e-01f,
  9.89630818e-02f, -1.34575903e-01f, 2.09709406e-01f, -7.83222541e-02f, 5.87240234e-02f, -3.88672166e-02f, -5.99100702e-02f, 9.68143169e-04f, 9.46444497e-02f, -1.14581861e-01f,
  -2.75431633e-01f, 2.09454503e-02f, 1.11093596e-01f, -2.16405019e-01f, -5.80225997e-02f, -6.17352203e-02f, 3.75311561e-02f, -1.12653948e-01f, -6.83330223e-02f, 9.80029926e-02f,
  1.57653131e-02f, 1.06511638e-02f, -2.93007810e-02f, -7.09738284e-02f, -1.94451764e-01f, -1.78058207e-01f, 4.12991084e-02f, -3.45414616e-02f, 6.58309311e-02f, 1.17651232e-01f,
  -4.72236425e-03f, -6.35367483e-02f, 7.95423463e-02f, -9.83324498e-02f, 4.02225815e-02f, -2.78021432e-02f, -6.65623024e-02f, 2.29737423e-02f, -1.21638164e-01f, -9.90441218e-02f,
  -1.81747809e-01f, -3.58842760e-02f, -7.52180144e-02f, 2.90530100e-02f, -9.71758664e-02f, 5.36576193e-03f, 1.13574684e-01f, 1.80349380e-01f, -9.49292704e-02f, -9.99254081e-03f,
  2.67421126e-01f, 2.99894422e-01f, -1.11517876e-01f, -1.44773304e-01f, 1.41906723e-01f, -6.12059049e-02f, -5.00486009e-02f, -1.04102187e-01f, -1.49745243e-02f, -1.85899213e-01f,
  -8.20655450e-02f, 2.18521997e-01f, 9.79690179e-02f, 2.37668395e-01f, -1.25381559e-01f, -2.03162536e-01f, 9.89158005e-02f, 1.88144580e-01f, 9.51864421e-02f, -6.63310662e-02f,
  -8.31038877e-02f, -2.24290445e-01f, 2.58689374e-01f, -7.68671632e-02f, -1.59689523e-02f, 3.13181847e-01f, 1.13464795e-01f, 1.90754890e-01f, -2.51226068e-01f, -1.26176272e-02f,
  -2.30850071e-01f, -2.89599150e-01f, 2.41326869e-01f, -1.54713094e-01f, -7.26567507e-02f, -5.49278371e-02f, 1.62784874e-01f, -2.53558666e-01f, -2.81824041e-02f, 4.78504300e-02f,
  3.08697205e-02f, 2.23852862e-02f, -1.05791904e-01f, 2.94574499e-02f, 4.44117598e-02f, 1.66582726e-02f, -6.38693050e-02f, 3.80639620e-02f, 1.12262636e-01f, 1.06572449e-01f,
  -2.05734074e-01f, 3.95400897e-02f, 1.29424080e-01f, -1.53449714e-01f, -8.21089521e-02f, -9.50169712e-02f, -9.51932594e-02f, 5.21770716e-02f, -1.89901143e-01f, 2.67432369e-02f,
  7.39367232e-02f, 3.82855837e-03f, -4.13660482e-02f, -1.02692097e-01f, 2.81674247e-02f, -3.72960158e-02f, -3.10171843e-01f, -1.34443760e-01f, -8.19750875e-02f, -1.66353002e-01f,
  -6.12126812e-02f, 5.72938770e-02f, 8.97629485e-02f, -1.94616646e-01f, -2.19407752e-01f, 3.55585068e-02f, -1.10147648e-01f, -2.26723682e-02f, -7.91177005e-02f, -1.41639579e-02f,
  2.42906258e-01f, 1.77629408e-03f, 2.30537564e-01f, 9.41375047e-02f, -2.46261418e-01f, 7.63468351e-03f, -2.20069494e-02f, 1.12442769e-01f, 7.49039501e-02f, 3.85122746e-01f,
  7.27057382e-02f, 3.08625311e-01f, 3.56721282e-01f, 1.67692930e-01f, -3.48541290e-01f, 3.29276472e-01f, -5.99497631e-02f, -2.70005018e-01f, -4.69584689e-02f, -2.59656161e-01f,
  1.71442389e-01f, 4.01514992e-02f, -2.15204582e-01f, 5.04947156e-02f, 1.11985557e-01f, 2.63855996e-04f, -9.22089592e-02f, -1.01961933e-01f, 7.36893266e-02f, -1.54264733e-01f,
  4.29731198e-02f, 2.08253437e-03f, 8.24418217e-02f, -1.11780725e-01f, 1.15936331e-01f, -1.06000364e-01f, 4.21887711e-02f, -9.83327627e-02f, 3.32431830e-02f, -3.48806120e-02f,
  2.13213503e-01f, 4.22509573e-02f, 2.32121851e-02f, 3.81514579e-02f, -1.72266103e-02f, -1.49073124e-01f, -8.04998577e-02f, -1.86845705e-01f, -2.20722139e-01f, 1.18968384e-02f,
  5.51021844e-02f, -6.30700216e-02f, 3.39206345e-02f, -2.07984615e-02f, -1.68502733e-01f, -1.24093359e-02f, 1.89109936e-01f, 1.53662413e-01f, -1.18040152e-01f, -8.04779828e-02f,
  1.75925219e-04f, 6.27663136e-02f, 2.14663416e-01f, 1.13406286e-01f, -1.14468060e-01f, -1.03920490e-01f, -8.82507339e-02f, 9.64302346e-02f, 7.19626322e-02f, -5.42323515e-02f,
  2.28209436e-01f, 2.85809457e-01f, -1.70783878e-05f, 1.11427225e-01f, -9.26323831e-02f, -8.04392174e-02f, 1.52405754e-01f, -5.04486486e-02f, -2.08533868e-01f, 2.18988925e-01f,
  1.50389388e-01f, -1.09895743e-01f, -4.72643636e-02f, -1.62475362e-01f, -1.65552929e-01f, 7.84644708e-02f, -1.21596744e-02f, 1.18959293e-01f, 7.13777095e-02f, -5.48542179e-02f,
  1.34666666e-01f, -1.35892794e-01f, -2.02856977e-02f, -1.70614854e-01f, -5.16407415e-02f, -1.28137127e-01f, -1.82831526e-01f, -1.34007707e-01f, 4.87819128e-02f, -1.00090258e-01f,
  -1.06311962e-01f, -1.54529661e-01f, 5.48725873e-02f, 2.23905575e-02f, -1.75584033e-01f, -1.70062155e-01f, -1.30474254e-01f, 3.16473329e-03f, -1.28813460e-01f, -2.32877582e-01f,
  -1.30220488e-01f, -1.01641081e-01f, -1.52366176e-01f, 3.16854209e-01f, -3.97704095e-02f, 1.65591761e-01f, -4.46378030e-02f, 2.24771142e-01f, -1.53816100e-02f, 8.17948952e-02f,
  -1.18382588e-01f, 4.39301506e-02f, -4.26816382e-02f, -9.16478857e-02f, 1.07250534e-01f, -1.03022382e-01f, -9.29979756e-02f, 1.37831494e-01f, -1.47412434e-01f, 1.91710621e-01f,
  -1.50032621e-02f, -2.85919607e-01f, -1.31282985e-01f, 5.43041192e-02f, -6.58227503e-02f, 1.87003478e-01f, 1.94611549e-02f, -2.38816142e-01f, -2.01912105e-01f, 1.76437944e-01f,
  5.48895122e-03f, -2.25561678e-01f, -1.41486272e-01f, 1.50921896e-01f, -2.38692760e-01f, -4.19192724e-02f, 1.16417192e-01f, 1.98441967e-01f, 5.75256236e-02f, 1.38365149e-01f,
  3.79790589e-02f, -1.84254255e-02f, 5.85817844e-02f, 7.97676519e-02f, 7.03899339e-02f, 1.38600662e-01f, -1.30442083e-01f, 1.30106524e-01f, -5.16874641e-02f, -1.10425107e-01f,
  7.92311653e-02f, 1.02415584e-01f, -3.83378230e-02f, 1.37218624e-01f, -8.53457600e-02f, 5.03198951e-02f, 3.01252212e-02f, 8.27951729e-02f, -1.34207793e-02f, 3.57945934e-02f,
  1.98690370e-01f, 1.07342135e-02f, 5.02874590e-02f, -7.68793225e-02f, 1.61074877e-01f, 1.45262524e-01f, -6.41311184e-02f, 1.43326493e-03f, -3.43362875e-02f, -4.30278806e-03f,
  -1.38996243e-02f, 2.28045955e-02f, 9.54579860e-02f, -4.06489708e-02f, 1.37783632e-01f, 1.01777896e-01f, 1.31934568e-01f, -1.38461232e-01f, 1.53671205e-01f, -3.01694479e-02f,
  -2.89897062e-03f, 1.31855473e-01f, -3.10398549e-01f, 2.02546790e-01f, -1.29734069e-01f, -2.98087358e-01f, 2.26423874e-01f, -1.99916795e-01f, -5.53537123e-02f, 1.04580425e-01f,
  2.11451024e-01f, -3.41817558e-01f, -3.37693095e-01f, 2.09483534e-01f, -5.75607680e-02f, -2.30981521e-02f, 2.12753490e-01f, -4.89995517e-02f, -1.31949738e-01f, 2.91773081e-01f,
  1.47947311e-01f, 7.82489255e-02f, 7.98418187e-03f, 1.31404832e-01f, 1.89592510e-01f, 2.43817985e-01f, -1.37307510e-01f, -6.87613487e-02f, 4.71177176e-02f, -1.59922391e-01f,
  -4.90947627e-02f, 3.36854905e-02f, -1.20476924e-01f, -7.02389851e-02f, -8.19196459e-03f, -1.09867699e-01f, 1.70616150e-01f, -1.32307142e-01f, 1.98040068e-01f, -2.14691833e-01f,
  1.20809935e-01f, 1.43270269e-01f, -3.55443805e-01f, -8.08053762e-02f, -3.01019922e-02f, -1.17370375e-01f, 1.30179683e-02f, -1.61592439e-01f, -3.85924280e-02f, -1.73917264e-01f,
  -2.97094256e-01f, 9.56676959e-04f, 6.21905737e-02f, 2.82598495e-01f, 3.82123403e-02f, -7.95116927e-03f, -1.86625347e-01f, -2.06153512e-01f, 6.82900846e-02f, -1.22476026e-01f,
  -2.76915133e-01f, -1.33287996e-01f, 1.19166560e-01f, -2.06644550e-01f, -1.32428017e-03f, 2.92279214e-01f, 1.43325910e-01f, -4.76522781e-02f, 2.80243605e-01f, -1.58148974e-01f,
  -2.10390300e-01f, 3.24061006e-01f, -2.70562261e-01f, 2.10888237e-01f, -1.35270897e-02f, -7.46367574e-02f, 1.94751825e-02f, 1.50600195e-01f, -1.59666389e-02f, 4.16456759e-02f,
  2.04759791e-01f, 2.61828929e-01f, -5.16512729e-02f, -2.07298651e-01f, -2.37787008e-01f, 1.31669668e-02f, 8.41256753e-02f, 3.81331146e-02f, 2.52897758e-02f, 1.21795395e-02f,
  -2.41844617e-02f, -5.26460521e-02f, -1.67534500e-01f, -5.19407354e-02f, 5.36526814e-02f, 1.47136256e-01f, 1.64203942e-02f, 7.86305740e-02f, -1.07341692e-01f, 4.19240035e-02f,
  -2.12810263e-02f, 1.54264495e-01f, 4.65855896e-02f, 1.65728107e-01f, -8.11477304e-02f, -5.84129952e-02f, 2.05829129e-01f, -7.87405595e-02f, 1.37024056e-02f, -1.47014886e-01f,
  -2.66437046e-02f, 7.31176436e-02f, -5.74867092e-02f, 2.07235381e-01f, 3.14846545e-01f, -1.43670961e-01f, -2.09247991e-02f, -2.35907942e-01f, -6.86856881e-02f, -1.24365725e-01f,
  -7.37159103e-02f, 1.53272569e-01f, 3.43155190e-02f, -1.43625662e-01f, -7.05594197e-02f, 2.49275580e-01f, -4.99965101e-02f, 5.97628057e-02f, 1.69342145e-01f, -2.14602858e-01f,
  1.09718889e-01f, 1.15743689e-01f, -1.41704753e-01f, 2.26977617e-01f, -1.58866078e-01f, -9.94918048e-02f, 2.39983693e-01f, -1.79718554e-01f, -1.62334353e-01f, 2.99631119e-01f,
  1.09222278e-01f, -1.25380695e-01f, 8.31069518e-03f, 2.70249963e-01f, -6.13944083e-02f, -1.63634285e-01f, 1.08004488e-01f, -8.20285380e-02f, -3.39199938e-02f, -3.12038034e-01f,
  -1.96108684e-01f, -7.21636415e-02f, 1.56612754e-01f, -2.46246848e-02f, 8.41275007e-02f, 1.85862511e-01f, -3.72873694e-02f, -1.19039558e-01f, -3.70915839e-03f, 6.10221038e-03f,
  3.94869037e-02f, -2.62558684e-02f, -1.16916507e-01f, 8.99689347e-02f, 3.87797207e-02f, 4.39183302e-02f, 9.84630212e-02f, 2.12662127e-02f, -1.47127345e-01f, 2.79003754e-03f,
  -3.44249308e-01f, -2.94806007e-02f, -7.32283220e-02f, 4.99899276e-02f, -8.56690109e-02f, -4.70717363e-02f, 2.74244174e-02f, 2.69060940e-01f, 9.61410403e-02f, -1.27340648e-02f,
  -1.28264308e-01f, -1.57512557e-02f, -9.02094692e-02f, 1.80976525e-01f, 8.95313472e-02f, 6.18792735e-02f, -2.91602314e-01f, -1.21964581e-01f, -1.34697586e-01f, 2.99676776e-01f,
  -1.29143134e-01f, -9.53551531e-02f, -8.75217617e-02f, -9.10260826e-02f, 7.04357401e-02f, 2.52023697e-01f, 1.58051118e-01f, -1.75311878e-01f, -6.22298345e-02f, -7.06470013e-02f,
  -2.32045114e-01f, -1.37724727e-01f, 1.25959888e-01f, -5.91699295e-02f, -1.08385375e-02f, -2.84394808e-02f, -7.78516605e-02f, -2.01382324e-01f, -2.13523552e-01f, 1.97923228e-01f,
  -2.94061843e-04f, -3.91098894e-02f, -2.72201836e-01f, -5.83469346e-02f, 1.88945860e-01f, 1.74371913e-01f, 1.18392177e-01f, 7.51666799e-02f, -9.06085223e-03f, -1.21103309e-01f,
  3.42112631e-02f, 6.17829943e-03f, -1.51663022e-02f, 1.69751383e-02f, 1.69382486e-02f, 6.73102140e-02f, -1.09731786e-01f, 8.36824030e-02f, 1.80591643e-01f, -1.69577271e-01f,
  4.37336043e-03f, 1.58732086e-01f, 1.09063670e-01f, -4.78901863e-02f, -6.53896481e-02f, -1.26659758e-02f, -2.02641655e-02f, -7.58731142e-02f, -4.58441488e-02f, -4.02406305e-02f,
  1.23185836e-01f, 2.66826805e-02f, -1.80464294e-02f, -2.93388277e-01f, -3.61013226e-02f, 2.32564777e-01f, -9.85518619e-02f, -1.14668431e-02f, 1.45744914e-02f, -1.18519828e-01f,
  -1.04911454e-01f, 1.44940475e-02f, -1.99973568e-01f, 1.02825522e-01f, -4.72438820e-02f, -6.39679655e-02f, 1.91151932e-01f, 1.68816261e-02f, 1.61535010e-01f, -3.31820458e-01f,
  1.61326334e-01f, -2.75424663e-02f, 4.47375216e-02f, 2.69098312e-01f, -6.37645572e-02f, -1.07755549e-01f, -3.19322273e-02f, -6.57188594e-02f, 1.42225370e-01f, -2.03018486e-01f,
  -1.73066050e-01f, 1.32744491e-01f, 2.60865957e-01f, -5.97050115e-02f, -1.78149164e-01f, -1.91226587e-01f, -1.40221015e-01f, -1.85206264e-01f, -3.88121116e-03f, -2.80354977e-01f,
  -3.08880191e-02f, 4.30029184e-02f, 6.21054173e-02f, 1.24672472e-01f, 4.00156081e-02f, 1.97635576e-01f, 2.47849710e-02f, 8.28068331e-02f, 1.05735809e-01f, 5.15061617e-02f,
  1.36538729e-01f, 3.94700728e-02f, 3.13723087e-02f, 1.75319284e-01f, -4.49493388e-03f, 1.79932952e-01f, 1.09833807e-01f, -9.83859897e-02f, 2.76723683e-01f, 7.21154809e-02f,
  6.86647836e-03f, -1.25677809e-01f, 1.92521773e-02f, 1.03105925e-01f, -6.02144636e-02f, -5.29316925e-02f, -1.14919702e-02f, -9.20578018e-02f, 6.66898713e-02f, -1.77827906e-02f,
  8.20100121e-03f, -9.31876972e-02f, -1.54307663e-01f, 1.23863950e-01f, 2.24258125e-01f, 1.27432451e-01f, -1.27070921e-03f, -6.19037412e-02f, 2.45530233e-01f, 9.90312621e-02f,
  1.50397718e-01f, 5.39173819e-02f, 8.42758268e-02f, -4.95741405e-02f, -1.54772416e-01f, 9.83719677e-02f, 8.63204524e-02f, 3.45711969e-02f, 2.50197798e-01f, -4.86480147e-02f,
  -9.10172015e-02f, 2.59444397e-02f, 3.29882689e-02f, -1.69795558e-01f, 9.36345086e-02f, 3.94966751e-02f, 2.56809264e-01f, -1.44628853e-01f, -9.19360742e-02f, 8.50682985e-03f,
  3.12896848e-01f, 1.00207172e-01f, -7.55402818e-02f, 1.93627477e-02f, 5.23158023e-03f, 1.50796577e-01f, -1.39896587e-01f, -1.95044558e-02f, 8.75338316e-02f, 1.51443183e-01f,
  9.51469392e-02f, -9.47367400e-03f, -1.17069155e-01f, -1.11764539e-02f, 5.77796483e-03f, 7.55368322e-02f, 9.52526182e-02f, 2.04197709e-02f, 1.19724363e-01f, -1.38592273e-01f,
  6.45437166e-02f, 4.36747335e-02f, -6.78635575e-03f, 9.88772213e-02f, -1.58584967e-01f, -8.89190659e-02f, -9.76780206e-02f, -1.72501355e-02f, 9.46075544e-02f, 1.45161361e-01f,
  -1.25607505e-01f, -2.05198094e-01f, -1.92753710e-02f, 4.53076363e-02f, 5.09754568e-02f, -5.48620075e-02f, -2.13395476e-01f, -1.54879257e-01f, 1.99246168e-01f, -1.50686592e-01f,
  4.94523942e-02f, -2.59904325e-01f, 1.65882096e-01f, -1.10295102e-01f, -3.11636142e-02f, 4.18561548e-02f, 1.29769966e-01f, -1.13214716e-01f, 1.00900508e-01f, 2.32527778e-01f,
  -1.14197537e-01f, 1.57485664e-01f, -1.52553186e-01f, 2.77930461e-02f, -3.20908688e-02f, 2.56572291e-02f, 2.99690329e-02f, 1.90824047e-01f, -9.11169797e-02f, 2.90102363e-01f,
  2.41706856e-02f, -2.27392077e-01f, -1.15467630e-01f, -2.55347341e-01f, -1.06277630e-01f, -1.92483649e-01f, -1.49579104e-02f, -1.88464910e-01f, -2.26896718e-01f, 1.32734284e-01f,
  -5.83897009e-02f, 2.85580214e-02f, -7.10960627e-02f, 4.00250070e-02f, 1.85765103e-01f, -4.07779776e-02f, 3.40685388e-03f, 5.17667495e-02f, -7.11462423e-02f, -4.45791967e-02f,
  2.76218746e-02f, 1.06636927e-01f, 1.67490721e-01f, -1.60669349e-02f, -8.29358678e-03f, 5.33543564e-02f, -1.39240727e-01f, -1.01336852e-01f, -1.70082644e-01f, -4.31804769e-02f,
  -5.10884933e-02f, 2.49124363e-01f, -1.23594969e-03f, -1.04590982e-01f, 1.79905459e-01f, -7.73649067e-02f, 1.19983390e-01f, 1.42924160e-01f, -2.20114980e-02f, -1.69144765e-01f,
  -1.48672417e-01f, -2.66455323e-01f, 2.12455109e-01f, -3.06949675e-01f, -1.28635570e-01f, -1.21914141e-01f, -8.27645063e-02f, 9.61491093e-02f, -2.39213426e-02f, -1.31990850e-01f,
  2.30182032e-03f, 4.04236317e-02f, 1.89308286e-01f, 8.63348916e-02f, -2.35877573e-01f, -1.28757551e-01f, 3.92959751e-02f, -1.58972561e-01f, -7.38567114e-02f, 3.09879094e-01f,
  2.08151937e-01f, 1.90516219e-01f, -6.53946102e-02f, 1.38863832e-01f, -7.57176206e-02f, -1.67373076e-01f, 2.12502152e-01f, -1.77666545e-01f, 7.63007812e-03f, 6.23037219e-02f,
  1.78131506e-01f, -2.44447753e-01f, 5.00857756e-02f, 1.22243613e-01f, 5.76828159e-02f, 4.79931459e-02f, -6.34084642e-02f, 1.30217701e-01f, 3.96372415e-02f, -1.20975852e-01f,
  1.12328768e-01f, -1.28003825e-02f, 4.68950979e-02f, -8.79349113e-02f, 5.88670038e-02f, -7.17643797e-02f, 5.40456809e-02f, 4.25944775e-02f, 1.78657159e-01f, -1.11601688e-01f,
  2.72998422e-01f, 4.99946922e-02f, -5.14257178e-02f, -8.52854103e-02f, -1.89364552e-02f, 1.65322646e-02f, 1.45019293e-01f, -1.34061635e-01f, -3.04306000e-01f, -1.33796170e-01f,
  -6.57839254e-02f, 8.79228953e-03f, -8.22520033e-02f, -1.00706011e-01f, -3.39278579e-02f, -5.09063713e-02f, 3.05048615e-01f, 1.50948286e-01f, -3.06344545e-03f, -2.53551543e-01f,
  3.15880448e-01f, 2.91566066e-02f, 1.61015436e-01f, 3.38708423e-02f, -8.66024047e-02f, -3.10958356e-01f, 1.17756547e-02f, 2.59835958e-01f, 7.93999508e-02f, 2.69206077e-01f,
  1.46928936e-01f, -1.57229137e-02f, -2.35014707e-01f, -3.29121947e-02f, 1.71955507e-02f, -4.63942513e-02f, 9.55914706e-02f, 2.17890486e-01f, 1.47525877e-01f, 9.90322530e-02f,
  -6.58485889e-02f, -4.47729714e-02f, 2.61391014e-01f, 4.49692272e-02f, -1.18564330e-01f, 7.65469894e-02f, 1.18880667e-01f, -1.50943518e-01f, 1.10977829e-01f, 1.32725373e-01f,
  6.97998181e-02f, -8.62590075e-02f, -1.18076382e-02f, -1.19553141e-01f, 1.49621755e-01f, 1.99104045e-02f, 5.11542261e-02f, -3.85662727e-02f, -1.58749506e-01f, 1.32929072e-01f,
  -1.24614306e-01f, -9.31418464e-02f, -1.80157200e-01f, -1.47013381e-01f, -6.92314059e-02f, -6.51426241e-02f, 6.12714440e-02f, -5.61558008e-02f, 3.26104229e-03f, -5.38747720e-02f,
  8.01108107e-02f, -7.13159814e-02f, -3.20453607e-02f, 9.21289325e-02f, -1.45535588e-01f, 2.09645703e-02f, -5.91992363e-02f, 5.22273257e-02f, 9.96835455e-02f, 1.66434690e-01f,
  -7.17415139e-02f, 1.81381151e-01f, 1.04863562e-01f, 1.04375683e-01f, -1.22631945e-01f, -5.62731698e-02f, -1.04506090e-01f, -9.50704440e-02f, -8.71183276e-02f, 1.75688505e-01f,
  -7.30625466e-02f, 6.48863520e-03f, 6.66166842e-02f, 4.69572581e-02f, -2.06417784e-01f, -1.43111944e-01f, 4.90779355e-02f, -2.53484964e-01f, -2.37159923e-01f, -3.83091867e-02f,
  -1.28929457e-02f, -2.10373234e-02f, 7.38338679e-02f, 1.47986203e-01f, -2.22191051e-01f, 1.27376886e-02f, 9.71236303e-02f, 1.79117575e-01f, 6.72088712e-02f, 2.04156101e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.22922400e-01f, 2.60874063e-01f, -3.09646223e-02f, 7.93500319e-02f, 2.19593287e-01f, 5.04403077e-02f, 1.34658426e-01f, 1.94537446e-01f, 9.91269797e-02f, 1.82233736e-01f,
  2.13803321e-01f, 3.86430509e-02f, 3.17059755e-01f, -1.05112437e-02f, 1.95333645e-01f, 7.82336965e-02f, 3.29149574e-01f, 2.34142974e-01f, -2.57397920e-01f, -3.32877040e-02f,
  1.41124666e-01f, 2.97422111e-02f, -3.26194018e-02f, 6.79786056e-02f, -1.85997784e-02f, -3.30954529e-02f, 1.50772547e-02f, -2.13581845e-01f, 1.86726060e-02f, 2.78250098e-01f,
  1.85774311e-01f, -7.85191804e-02f, -6.82610571e-02f, -1.78135589e-01f, 8.62330571e-02f, -2.25000843e-01f, -2.12608814e-01f, 5.27817151e-03f, -1.45155117e-01f, -1.01048023e-01f,
  5.37954308e-02f, 8.91435370e-02f, 7.84254819e-02f, -2.29977146e-01f, 2.64172584e-01f, -1.60835579e-01f, -5.32645471e-02f, 2.96004742e-01f, -2.27743864e-01f, -1.19948881e-02f,
  1.54328808e-01f, 2.17535883e-01f, 3.27747941e-01f, 2.13365659e-01f, -1.70804173e-01f, 5.50490916e-02f, 1.90776959e-01f, -1.87232107e-01f, 3.20368648e-01f, -1.38497129e-01f,
  -2.54405439e-01f, -5.80022372e-02f, 1.24739610e-01f, -3.44235688e-01f, -2.02040493e-01f, 4.52648513e-02f, 2.55598873e-01f, 1.05131283e-01f, 1.40245467e-01f, 4.83845472e-02f,
  1.66085269e-02f, 5.10391891e-02f, -6.12124391e-02f, 8.33820254e-02f, 5.26286773e-02f, -3.74050029e-02f, 5.43200038e-02f, 2.78260857e-01f, 3.98689974e-03f, -1.99982703e-01f,
  3.25134732e-02f, 5.67454435e-02f, 1.32352963e-01f, 2.72651494e-01f, -1.61799863e-01f, 2.10281000e-01f, 2.19122976e-01f, 1.87474549e-01f, -1.41863778e-01f, -5.73198795e-02f,
  7.27062300e-02f, 1.07031427e-01f, -4.60507631e-01f, -1.72952667e-01f, 7.13241920e-02f, -1.34303808e-01f, -6.39285818e-02f, 5.63633516e-02f, 2.60384887e-01f, -7.73043260e-02f,
  2.73473132e-02f, -1.83786482e-01f, 1.07076295e-01f, 2.32858676e-02f, -1.68959238e-02f, -5.68634570e-02f, 1.46571383e-01f, 1.50945559e-01f, 1.88964397e-01f, 2.62450695e-01f,
  -1.57434151e-01f, -9.81999710e-02f, 3.10437351e-01f, 2.48474240e-01f, 1.18051358e-01f, 2.55599469e-01f, -6.82783499e-02f, 4.86697495e-01f, 3.29124302e-01f, 3.38443637e-01f,
  -3.53268176e-01f, 3.32618654e-01f, 1.63590282e-01f, -1.93371907e-01f, 2.68798526e-02f, -1.96901664e-01f, 2.27297321e-01f, -1.14965566e-01f, 8.36031660e-02f, -6.66672084e-03f,
  8.36454332e-02f, 2.01320037e-01f, 7.99462870e-02f, 7.61062205e-02f, 2.32455507e-02f, 1.59490108e-01f, 2.78946906e-01f, 2.42054295e-02f, -2.77239531e-02f, 1.28487453e-01f,
  -1.11875795e-01f, 3.42310935e-01f, -3.00774816e-02f, 6.90100938e-02f, 1.20966628e-01f, 1.04997166e-01f, 3.54847640e-01f, 1.20289594e-01f, 6.78397119e-02f, 2.37288013e-01f,
  2.57736802e-01f, 1.88791201e-01f, 2.23746672e-02f, 2.27758177e-02f, 1.28095254e-01f, 2.10296169e-01f, -1.29383951e-01f, -3.37487221e-01f, -2.15600356e-01f, -5.97372614e-02f,
  1.12560228e-01f, 2.63243288e-01f, -4.02936041e-02f, 2.81726182e-01f, 3.95291239e-01f, 2.97922432e-01f, -5.32662086e-02f, 6.50725141e-02f, 5.47014363e-02f, -2.88336426e-01f,
  -4.71779965e-02f, 3.88016105e-01f, -2.71238416e-01f, 4.70590927e-02f, 2.50544757e-01f, -4.62678492e-01f, 3.23430479e-01f, -1.57272026e-01f, -2.84654815e-02f, -5.20834662e-02f,
  -7.24253133e-02f, -2.01604068e-01f, 1.00600973e-01f, 5.75840287e-02f, -1.80486873e-01f, 1.83102712e-01f, 1.94223195e-01f, 3.45470428e-01f, 1.55538335e-01f, 7.61541352e-02f,
  1.35036618e-01f, 1.97390914e-01f, 2.50950724e-01f, -3.91492993e-02f, 1.31920934e-01f, 1.18286021e-01f, 1.22069553e-01f, -1.22977957e-01f, -2.56127082e-02f, 8.78932849e-02f,
  -7.63843628e-03f, -2.04361584e-02f, -3.27714086e-02f, 8.64725932e-02f, 1.23183094e-01f, -3.78601428e-04f, 8.55410099e-02f, -1.91513702e-01f, 4.08751816e-02f, 1.44448653e-01f,
  -1.93998113e-01f, -7.32490346e-02f, 1.48869142e-01f, 1.90808743e-01f, 3.58481072e-02f, -1.23679914e-01f, 6.64778578e-04f, 5.96511140e-02f, -1.97787970e-01f, 1.67950377e-01f,
  -9.24347788e-02f, 1.07163019e-01f, -2.56865531e-01f, 2.94901729e-01f, 2.35615656e-01f, 1.78765923e-01f, -2.30054393e-01f, 1.65846974e-01f, -1.42187968e-01f, -3.16519663e-02f,
  2.24641543e-02f, -2.26958305e-01f, -1.94616437e-01f, 2.63512075e-01f, -3.01433560e-02f, 6.88558370e-02f, -1.82269782e-01f, -2.15921283e-01f, 1.88056054e-03f, 7.54447728e-02f,
  -2.48104185e-01f, 6.42517582e-02f, 3.44361812e-01f, -4.04827058e-01f, 1.15674259e-02f, 1.26591757e-01f, 1.95445701e-01f, -4.00484681e-01f, -1.18326560e-01f, 4.31918055e-01f,
  -1.75689384e-02f, 1.92866519e-01f, -2.52276529e-02f, 3.84759873e-01f, 5.45554347e-02f, 3.26420546e-01f, 7.91744962e-02f, 2.43820548e-01f, 1.76291689e-01f, -4.28246520e-03f,
  3.50453675e-01f, 1.03006899e-01f, 2.11660013e-01f, 4.14990969e-02f, 3.67392957e-01f, 3.08323085e-01f, 2.07693279e-01f, 1.70783073e-01f, 4.98386145e-01f, -6.63422123e-02f,
  1.41593531e-01f, 1.23749793e-01f, 2.43929699e-01f, 2.55779952e-01f, -5.92066720e-02f, 1.52576551e-01f, 3.84353012e-01f, 2.08766371e-01f, 2.28261203e-01f, 2.44554295e-03f,
  5.12999594e-02f, -1.99258715e-01f, -2.51347989e-01f, 5.40448278e-02f, 2.84305364e-01f, 1.86178818e-01f, 5.25973067e-02f, -1.07087083e-01f, -6.20556511e-02f, -8.80661756e-02f,
  -4.34843898e-02f, 1.82130292e-01f, 4.84675057e-02f, -8.81082751e-03f, -1.71458304e-01f, 9.36239809e-02f, 5.40932966e-03f, 2.56707072e-01f, -1.83294341e-01f, -1.20288879e-01f,
  -8.07136819e-02f, 1.30652366e-02f, 1.13739572e-01f, 2.16612250e-01f, 1.37297571e-01f, 1.24404930e-01f, 1.33201241e-01f, 1.80020437e-01f, 3.25861156e-01f, -2.17050146e-02f,
  1.72189415e-01f, -1.08969763e-01f, 2.35795230e-01f, 2.30607852e-01f, 2.04679444e-01f, 3.26771528e-01f, 2.21795738e-01f, 2.45105326e-01f, -1.69161767e-01f, 1.99236885e-01f,
  -2.95873344e-01f, -6.82610571e-02f, 2.83100549e-03f, -3.73966873e-01f, 2.10985273e-01f, -1.37886018e-01f, 1.45991743e-01f, -8.13747719e-02f, -1.24645429e-02f, 6.04794025e-02f,
  1.24545321e-01f, -1.34171516e-01f, 1.46860280e-03f, -4.41723704e-01f, 8.97848010e-02f, 9.79133993e-02f, 6.86229989e-02f, 1.91796273e-01f, -4.15650278e-01f, 9.98709500e-02f,
  2.63224542e-01f, 7.65380710e-02f, 8.15140456e-02f, -8.59381109e-02f, -6.19048765e-03f, -3.11539322e-01f, -9.53117833e-02f, 7.73829520e-02f, 4.66093093e-01f, -8.22648555e-02f,
  1.81410164e-01f, -5.76159768e-02f, -2.97785282e-01f, -3.82383227e-01f, 3.19294259e-02f, -3.32533419e-01f, 3.38698477e-02f, -1.23712257e-01f, -4.94032562e-01f, -2.47833459e-03f,
  -5.20766973e-02f, 1.72959372e-01f, -2.63704658e-01f, -2.72237748e-01f, 2.17506051e-01f, -6.71913400e-02f, -1.92972869e-01f, 5.35441115e-02f, 1.13131255e-02f, 9.82951000e-02f,
  -9.58295248e-04f, 4.38915938e-01f, 4.24883425e-01f, 7.72483945e-02f, -1.45157248e-01f, -3.42203885e-01f, -3.42726350e-01f, -1.24240249e-01f, 4.23143446e-01f, -1.05246156e-01f,
  -2.87564039e-01f, 8.86776373e-02f, -1.41660184e-01f, -3.14935356e-01f, 2.97530919e-01f, 2.69706398e-01f, 4.46459688e-02f, 2.00544119e-01f, 3.99512760e-02f, 2.59128958e-01f,
  2.42156804e-01f, 2.45794997e-01f, 1.69594511e-01f, 1.85959890e-01f, 6.76791742e-02f, 2.56501943e-01f, 2.15112180e-01f, 3.52475457e-02f, 1.52559325e-01f, 2.31084749e-01f,
  9.05422196e-02f, 1.70239970e-01f, -5.05162776e-02f, 9.78640914e-02f, 1.69765860e-01f, 1.30810723e-01f, -1.06134400e-01f, 8.02985672e-03f, 1.63562164e-01f, 3.18679869e-01f,
  2.34563872e-01f, -3.25061530e-01f, 4.74044979e-02f, 2.26167977e-01f, 4.54695225e-02f, -9.15510356e-02f, -4.68021072e-03f, -8.72888714e-02f, -2.73336302e-02f, -2.86915243e-01f,
  -2.86157489e-01f, 1.74370725e-02f, -1.90651074e-01f, 7.39497459e-03f, 1.41917944e-01f, -9.66565087e-02f, 2.23960191e-01f, -2.66828567e-01f, 2.68854111e-01f, -1.89874731e-02f,
  -1.76352978e-01f, 2.33044729e-01f, -2.58464664e-01f, -2.56970078e-01f, -8.41208827e-03f, 4.05727746e-03f, 2.49412566e-01f, -9.86237228e-02f, -1.59412742e-01f, 1.00667804e-01f,
  1.58713669e-01f, -3.23624276e-02f, 4.62704934e-02f, 4.20386307e-02f, -9.41188559e-02f, -2.85304282e-02f, 1.62038401e-01f, -1.27947092e-01f, -1.39165983e-01f, 1.63888171e-01f,
  4.39259224e-02f, -1.66656952e-02f, -5.84623329e-02f, 2.32318148e-01f, 2.10253179e-01f, 2.36247301e-01f, 6.88192770e-02f, 9.43222642e-02f, 4.67733033e-02f, 7.99824148e-02f,
  1.06745817e-01f, 1.82862669e-01f, -1.65531151e-02f, 1.70895904e-01f, 1.58645660e-01f, 1.02729782e-01f, 3.11460137e-01f, 2.63045222e-01f, -4.92877513e-02f, -5.17748296e-02f,
  8.44751578e-03f, 1.53077275e-01f, -6.31869584e-02f, 4.37188148e-02f, 1.31300956e-01f, -1.04640156e-01f, -1.51720196e-01f, -9.98682454e-02f, 1.36976376e-01f, -2.43620276e-01f,
  -1.49609193e-01f, 1.45532161e-01f, 2.94651479e-01f, -3.10375839e-02f, -5.45172878e-02f, -1.48575783e-01f, 1.41825840e-01f, 1.84028581e-01f, 1.47586569e-01f, -3.99690792e-02f,
  2.45065764e-01f, -8.53229687e-02f, -5.78990113e-03f, 3.11644971e-01f, -1.80612609e-01f, 2.98334248e-02f, 3.77463669e-01f, -1.22551322e-01f, -1.59840643e-01f, 3.31648380e-01f,
  1.42430335e-01f, -6.52259737e-02f, 1.54104024e-01f, 3.84611517e-01f, -1.67260200e-01f, -1.18719079e-01f, 1.07405789e-01f, -7.05408677e-02f, -8.73419717e-02f, -1.75954193e-01f,
  -1.02348916e-01f, -2.76069343e-01f, 5.15842363e-02f, -2.80769598e-02f, 2.12690204e-01f, 1.80572391e-01f, -1.27223860e-02f, 1.18031085e-01f, 1.43710360e-01f, 2.38858670e-01f,
  1.09394185e-01f, 1.60984382e-01f, 1.86565667e-01f, 9.00751799e-02f, -1.28494158e-01f, 1.46718219e-01f, 1.57826364e-01f, 6.03158139e-02f, -3.17232870e-02f, 1.80406034e-01f,
  1.19768128e-01f, 2.49047354e-01f, 8.55626836e-02f, 2.89821714e-01f, 7.82968625e-02f, -1.93736516e-02f, 3.03826481e-01f, 1.53326010e-02f, -1.50072291e-01f, -2.21160337e-01f,
  -1.86685190e-01f, -1.87541664e-01f, -1.67430505e-01f, 6.96983710e-02f, 1.73132911e-01f, 2.28122786e-01f, -1.35420579e-02f, 6.99400669e-03f, 9.93471593e-02f, -2.54388917e-02f,
  -1.14266887e-01f, -1.04040027e-01f, -5.77023402e-02f, -1.28510907e-01f, 3.98141854e-02f, 5.26252352e-02f, -4.87954691e-02f, 5.68353683e-02f, 4.65771146e-02f, 7.25776404e-02f,
  -1.31863326e-01f, 5.16723953e-02f, 2.77010709e-01f, -4.61540446e-02f, -2.60292619e-01f, -2.85827927e-02f, 1.37205794e-01f, 2.33609825e-01f, 2.36845151e-01f, 3.43014561e-02f,
  -1.67164728e-01f, 9.62610245e-02f, 1.46166891e-01f, 9.38200206e-02f, -5.03412560e-02f, 2.57941335e-01f, -1.07140131e-01f, 1.24251068e-01f, 1.17094912e-01f, 1.18940175e-01f,
  1.05440989e-03f, 7.16796592e-02f, 1.03711747e-01f, 2.23615244e-02f, 7.03245122e-03f, -1.20528907e-01f, 1.40144661e-01f, 1.59536198e-01f, 9.05151069e-02f, 2.28192434e-01f,
  1.71453152e-02f, -1.16574906e-01f, 1.98991984e-01f, 2.13976264e-01f, -1.00478306e-01f, 2.12661669e-01f, -8.70726779e-02f, 2.76843816e-01f, 1.84017807e-01f, -3.15830112e-02f,
  1.54702500e-01f, -3.19733292e-01f, -3.24663997e-01f, 1.32815212e-01f, -5.52061200e-02f, -1.44421414e-01f, -1.32195488e-01f, 1.57788366e-01f, 1.99990720e-01f, 2.58529931e-01f,
  1.42407030e-01f, 1.85992450e-01f, -1.40766174e-01f, -2.38229305e-01f, -1.40225917e-01f, -2.74151742e-01f, -1.04198374e-01f, 8.47203359e-02f, -2.36121178e-01f, 3.99236940e-02f,
  5.13857305e-02f, 2.98596900e-02f, -3.18909474e-02f, -5.89978835e-03f, -1.46558210e-01f, 2.45239258e-01f, 4.07190859e-01f, 1.87323783e-02f, -1.12850584e-01f, 3.59078586e-01f,
  3.01431060e-01f, 6.04058392e-02f, -3.58767360e-02f, 3.39711249e-01f, 4.82110828e-02f, -3.32944207e-02f, 2.71260768e-01f, 9.60611701e-02f, 1.47278592e-01f, 3.52202654e-01f,
  2.89412677e-01f, -3.93630052e-03f, 1.43803153e-02f, 2.78443545e-01f, 2.91054379e-02f, 1.63045079e-01f, 5.69991209e-02f, 7.93893635e-02f, 1.67862713e-01f, 2.30430201e-01f,
  1.22700118e-01f, 2.29528978e-01f, -3.24057112e-03f, 2.40006328e-01f, 4.91317250e-02f, 3.27297032e-01f, -4.58268374e-02f, 4.13867552e-03f, 1.21588245e-01f, 1.11424237e-01f,
  1.25263408e-01f, 7.88674280e-02f, 6.43402934e-02f, 1.42911911e-01f, 1.65653065e-01f, 3.30800921e-01f, 3.05221170e-01f, -6.51356280e-02f, 4.98917438e-02f, -2.66705677e-02f,
  3.31576429e-02f, -1.19681485e-01f, 1.19181521e-01f, -1.11108929e-01f, -1.47592872e-01f, -1.77372038e-01f, -6.66317120e-02f, 2.90370196e-01f, -1.62365511e-01f, 2.21266523e-01f,
  -2.45385915e-02f, -2.17548132e-01f, 2.37844020e-01f, 1.80400461e-02f, -1.19360968e-01f, 8.24931636e-02f, 5.68878390e-02f, 3.94274406e-02f, -7.65477493e-02f, -3.23010802e-01f,
  -1.07709743e-01f, 8.08313787e-02f, 1.11773089e-01f, -1.75535947e-01f, -1.73310801e-01f, -1.82490014e-02f, 8.78244564e-02f, -1.05926163e-01f, 1.70818511e-02f, 3.65972489e-01f,
  1.65981427e-01f, 2.75583863e-01f, 7.04789832e-02f, 2.20310949e-02f, -8.12487900e-02f, -3.81884305e-03f, 2.56188214e-01f, 1.31590649e-01f, -6.38596192e-02f, -8.58169235e-03f,
  1.47017494e-01f, 1.27746329e-01f, -5.47864428e-03f, 9.32459161e-02f, 2.18047440e-01f, -1.62821766e-02f, 1.16112620e-01f, 2.04236448e-01f, -1.01554357e-02f, 4.23690490e-03f,
  1.07438438e-01f, -1.69843175e-02f, 5.26448786e-02f, 2.02375382e-01f, 2.79308017e-02f, 6.82205427e-03f, 2.39676937e-01f, 1.80978581e-01f, -6.91526011e-02f, -7.51466975e-02f,
  5.46130165e-02f, -1.59087285e-01f, -3.53850096e-01f, -1.91860214e-01f, 9.56227481e-02f, -2.58707136e-01f, -2.69229978e-01f, 9.56945121e-02f, 3.33942413e-01f, -1.03363227e-02f,
  -4.06901427e-02f, -3.28786999e-01f, 1.12158932e-01f, 8.71083140e-02f, 9.21475962e-02f, -3.29707153e-02f, 2.34519586e-01f, -1.91410258e-01f, 2.47724414e-01f, 3.67746353e-01f,
  -2.91136593e-01f, -2.43530814e-02f, 3.42018753e-01f, 3.32828145e-03f, -9.15982425e-02f, 3.27081561e-01f, 1.99123949e-01f, 2.77709723e-01f, 2.88024276e-01f, 2.42408365e-01f,
  -1.98018447e-01f, -5.03823534e-02f, 9.74489450e-02f, -3.98937792e-01f, -5.72310649e-02f, -2.67840445e-01f, 8.15137774e-02f, -1.04132354e-01f, 1.50211066e-01f, 1.46344170e-01f,
  -4.14458849e-02f, 1.79834619e-01f, 5.15522920e-02f, 1.48846388e-01f, 7.23210126e-02f, 3.17752510e-02f, 2.28318587e-01f, 2.02798232e-01f, -5.75647168e-02f, 6.48880750e-02f,
  2.65292525e-01f, 1.85733691e-01f, 8.34767148e-02f, 2.78037846e-01f, 7.45123848e-02f, 1.47788212e-01f, 3.38484257e-01f, 1.77959606e-01f, 5.45400381e-02f, -6.96518412e-03f,
  1.15173556e-01f, 6.08369485e-02f, 8.56949687e-02f, 1.26654431e-01f, -8.90273787e-03f, 1.21227980e-01f, 3.27086776e-01f, 8.47579762e-02f, -6.21496215e-02f, -1.50114909e-01f,
  -2.18268439e-01f, -2.55530924e-01f, 3.09614331e-01f, 7.74243101e-02f, 2.48109385e-01f, -4.19753417e-02f, 4.49110806e-01f, 1.89525932e-01f, 3.70059818e-01f, -2.27304175e-02f,
  -4.73531559e-02f, 1.52145475e-01f, -3.12095344e-01f, 1.80014029e-01f, 3.12496334e-01f, -2.48546705e-01f, 2.63424695e-01f, -1.33474153e-02f, -3.15572351e-01f, -2.78367162e-01f,
  -1.21113710e-01f, -1.14317879e-01f, -6.10148720e-02f, -8.02859440e-02f, 3.44130546e-01f, -1.44193798e-01f, 1.26848683e-01f, 1.71076477e-01f, 3.68122309e-01f, 3.53771210e-01f,
  -3.05350572e-01f, -8.23030248e-03f, -7.45759085e-02f, -9.71633047e-02f, 2.31840253e-01f, 1.85214862e-01f, 6.95137233e-02f, 9.15575773e-03f, -1.46280333e-01f, 1.62769839e-01f,
  1.58534944e-01f, 2.52008326e-02f, 1.89677000e-01f, 2.31931180e-01f, -2.37954661e-01f, 7.87150189e-02f, -3.65986712e-02f, 6.06381856e-02f, -9.16770622e-02f, 2.53833294e-01f,
  -1.78687081e-01f, 1.47471189e-01f, 1.40539825e-01f, 2.01556370e-01f, 1.36576295e-01f, 5.62256239e-02f, 4.05067950e-02f, 9.70524698e-02f, 2.46919706e-01f, 6.32755607e-02f,
  -7.97164142e-02f, -2.43326053e-01f, -4.15305682e-02f, 3.16783756e-01f, 2.61081487e-01f, 3.08242083e-01f, -2.57865310e-01f, -6.48713112e-02f, 1.46758094e-01f, 2.95095742e-01f,
  -2.28930935e-01f, -1.65683761e-01f, -1.69799432e-01f, -1.14843041e-01f, 2.46741883e-02f, -5.66841057e-03f, 1.26034468e-01f, -2.23183006e-01f, -5.95942177e-02f, -1.94629118e-01f,
  -1.87080815e-01f, 1.13693334e-01f, 4.11752522e-01f, 1.87594429e-01f, 3.77863385e-02f, 5.75290397e-02f, -3.13115977e-02f, 1.04037888e-01f, -1.45982876e-01f, 2.77930945e-02f,
  2.02179834e-01f, 1.44599229e-01f, -2.79497504e-01f, -4.89929179e-03f, 2.21352711e-01f, -3.76251750e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.13820583e-01f, -6.54424587e-03f, 1.46851838e-01f, 8.91504064e-02f, 3.09764355e-01f, 8.81913155e-02f, 1.10243149e-01f, 6.64689299e-03f, 5.33020049e-02f, 2.34764203e-01f,
  2.14919716e-01f, 1.95242733e-01f, -6.78240284e-02f, 2.41742715e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -6.14885474e-03f, -4.03869934e-02f, 1.11728251e-01f, 4.86434996e-02f, 4.30892259e-02f, 1.06203690e-01f, -1.09894760e-01f, 2.69588660e-02f, 7.52222762e-02f, 4.21436280e-02f,
  -3.01216580e-02f, -2.38932967e-02f, 2.61505824e-02f, 7.37200007e-02f, 5.99979386e-02f, -8.19134414e-02f, 1.56333819e-01f, 1.15254812e-01f, 1.15372360e-01f, -1.19249314e-01f,
  -6.20300658e-02f, 1.74396843e-01f, 6.58685267e-02f, -1.27758617e-02f, -6.56411797e-02f, -8.87686461e-02f, -3.22796628e-02f, 2.26111040e-01f, -1.48776397e-01f, 1.25012398e-01f,
  8.01533014e-02f, 1.96440354e-01f, -8.90015215e-02f, 8.38299766e-02f, -1.95560932e-01f, 1.09784454e-01f, -2.22057700e-01f, 1.45691752e-01f, 4.86440696e-02f, -1.50791198e-01f,
  -2.62925923e-02f, 2.29467779e-01f, 9.59240943e-02f, -1.62881941e-01f, 2.10564852e-01f, 1.11128420e-01f, 1.38907254e-01f, 6.98874891e-02f, 1.36871517e-01f, -2.90738940e-01f,
  1.54079050e-01f, -2.38550212e-02f, 1.11383770e-03f, -1.24722816e-01f, -2.62384806e-02f, -2.71733522e-01f, 1.95508674e-01f, 1.12114005e-01f, -1.61806017e-01f, -1.13950176e-02f,
  -1.06242612e-01f, 1.26867160e-01f, 6.51858896e-02f, -1.55296892e-01f, -5.03053293e-02f, -7.75076672e-02f, 8.18903148e-02f, -6.11521788e-02f, 1.28457114e-01f, -4.57681082e-02f,
  5.45660816e-02f, 5.63464649e-02f, -7.89068565e-02f, 9.76857729e-03f, 3.55248675e-02f, -7.21877441e-02f, 1.48196165e-02f, -4.34554592e-02f, 1.76014546e-02f, 7.36666694e-02f,
  -8.59089717e-02f, 9.23153386e-02f, 5.43557219e-02f, -7.27570802e-02f, 1.80969507e-01f, -9.81172323e-02f, 1.73601583e-01f, 1.61144346e-01f, -1.32488431e-02f, 1.45769328e-01f,
  1.47649616e-01f, -7.85003975e-02f, 1.50894016e-01f, -4.32267290e-04f, -1.65754840e-01f, 1.43802539e-01f, -7.30539262e-02f, -1.25947133e-01f, 1.05040921e-02f, -6.84283227e-02f,
  -1.49821818e-01f, -3.51432443e-01f, -2.69910395e-01f, -2.33679339e-01f, 5.51682897e-02f, -1.72515213e-01f, -3.77140299e-04f, -2.67601199e-02f, 7.12454990e-02f, -4.60586995e-02f,
  -9.45591405e-02f, -5.11371940e-02f, -1.75955370e-01f, 1.89381823e-01f, 3.91315967e-02f, -2.14410782e-01f, 3.31724882e-02f, 6.78318515e-02f, -1.12338662e-02f, 1.91952288e-01f,
  1.51538208e-01f, -9.35265794e-02f, 3.63565944e-02f, -1.96618110e-01f, 2.04451591e-01f, -2.08926454e-01f, 6.64585456e-02f, 1.34021759e-01f, -4.49387059e-02f, -2.05407497e-02f,
  8.36824849e-02f, 4.09505703e-03f, 1.59726501e-01f, -1.30494898e-02f, -1.91960074e-02f, -6.37275204e-02f, -1.26133800e-01f, 1.01896338e-01f, 1.93587750e-01f, -1.39112100e-01f,
  2.80735847e-02f, 8.50384906e-02f, -1.47063896e-01f, 2.84881532e-01f, -1.70985982e-02f, 3.61909159e-02f, -2.08678767e-02f, -1.19465746e-01f, 3.28219496e-02f, 2.91944575e-02f,
  7.56919757e-02f, 3.84924561e-02f, 1.27157629e-01f, -1.55866265e-01f, -1.79586425e-01f, -1.58969954e-01f, -7.55653717e-03f, -7.37976953e-02f, -1.04985319e-01f, 2.70835787e-01f,
  2.18763277e-01f, -8.37959498e-02f, 2.01455280e-02f, -5.86592704e-02f, -2.88446695e-01f, 1.75586730e-01f, -6.60974830e-02f, 4.26789261e-02f, 9.91351753e-02f, 2.69655496e-01f,
  -1.23104878e-01f, -7.39327967e-02f, 2.80075490e-01f, -8.54928717e-02f, 2.94548810e-01f, 1.17954843e-01f, 1.45794541e-01f, 5.12778712e-03f, 1.41843967e-02f, 1.76108092e-01f,
  -3.81523408e-02f, 1.16641290e-01f, -1.38405055e-01f, -3.10607880e-01f, 9.69095454e-02f, 3.73110808e-02f, 1.95067182e-01f, 7.91558027e-02f, -1.62949950e-01f, 2.24318489e-01f,
  -1.26575172e-01f, -1.48291618e-01f, -1.00443155e-01f, 7.72769079e-02f, -3.59134115e-02f, 8.76890868e-02f, -1.26216054e-01f, 9.08960849e-02f, 1.25464471e-02f, -1.11081250e-01f,
  2.90439166e-02f, 5.03745489e-02f, 7.25073889e-02f, -2.08054688e-02f, 4.75293584e-02f, -1.74686328e-01f, -5.58468029e-02f, -3.48153599e-02f, -1.77123398e-02f, 1.06331132e-01f,
  -1.25017921e-02f, 2.58528683e-02f, -4.16818671e-02f, 1.10670038e-01f, -1.42624427e-03f, 1.42852947e-01f, -3.50756533e-02f, 1.55548468e-01f, -2.31579661e-01f, 1.20838881e-01f,
  -3.21493894e-01f, 3.83789949e-02f, 1.26480414e-02f, 6.76359609e-02f, 2.69387513e-01f, 2.13721007e-01f, 3.22315522e-04f, -1.08101599e-01f, -4.81622331e-02f, 2.93705016e-01f,
  -1.03588579e-02f, 1.80727020e-02f, -1.23607218e-01f, 2.23643184e-01f, 5.04293130e-04f, 1.45250753e-01f, 1.66886762e-01f, -1.05340339e-01f, 4.43352647e-02f, 1.01686142e-01f,
  1.09787621e-01f, -7.63579011e-02f, 9.49258655e-02f, 1.12222917e-01f, -1.31262079e-01f, 4.95675504e-02f, 3.89009677e-02f, 2.68108040e-01f, 9.31749195e-02f, 1.65762842e-01f,
  -3.37809809e-02f, 1.23017587e-01f, -4.26962189e-02f, 2.11652115e-01f, -2.06265554e-01f, -6.49700835e-02f, -1.26164764e-01f, -4.12467052e-04f, -3.34351920e-02f, 2.24970710e-02f,
  2.74017695e-02f, -9.53841805e-02f, -8.46846625e-02f, 3.32732983e-02f, -2.92516388e-02f, -1.14085428e-01f, -4.54710163e-02f, -3.95188257e-02f, -2.83991285e-02f, 1.60265446e-01f,
  -7.81666338e-02f, -1.68752357e-01f, 1.73643142e-01f, 1.34672686e-01f, 7.14147314e-02f, 4.98856716e-02f, -1.59275010e-01f, 1.96485072e-02f, -1.40988141e-01f, -2.69197803e-02f,
  -1.88728407e-01f, -1.01905800e-01f, -2.86673214e-02f, 2.21012935e-01f, -1.98545113e-01f, 1.33687839e-01f, 1.87630937e-01f, -2.48901069e-01f, -9.07629877e-02f, 2.04546362e-01f,
  -8.02352726e-02f, 1.30895257e-01f, 8.16110894e-02f, -1.47746652e-01f, 7.34617561e-02f, -1.11322768e-01f, -2.46229634e-01f, -5.74461967e-02f, 4.65184636e-02f, -2.11116403e-01f,
  -3.74243855e-02f, 7.23481402e-02f, 2.83487160e-02f, 7.67815113e-02f, 2.20870689e-01f, -4.97134440e-02f, 5.12905084e-02f, -1.51453763e-01f, -4.48186360e-02f, 1.76915415e-02f,
  1.88150689e-01f, 5.19496463e-02f, 1.06077932e-01f, -2.15626713e-02f, -2.13546589e-01f, -4.30799499e-02f, 1.35239616e-01f, -8.44442472e-02f, 1.07614160e-01f, -1.65030673e-01f,
  1.35949954e-01f, 1.01452358e-01f, 2.40407996e-02f, -1.79167107e-01f, -9.17983986e-03f, 3.07333749e-03f, -5.05805686e-02f, 7.47362822e-02f, 9.21340436e-02f, 1.28213957e-01f,
  6.32506311e-02f, 1.44629404e-01f, 4.14362922e-02f, -8.85796845e-02f, 7.70986527e-02f, 3.60738449e-02f, -1.42572820e-01f, 1.18603952e-01f, -1.44821405e-01f, 9.24948826e-02f,
  -2.91074011e-02f, 4.64260578e-02f, 1.52283862e-01f, 1.40418718e-02f, 1.96983561e-01f, -4.20887992e-02f, 2.54270267e-02f, -1.32865235e-01f, 2.95068681e-01f, -6.10973798e-02f,
  7.63193518e-02f, -1.37378156e-01f, 1.27818942e-01f, -5.28211296e-02f, 3.34088206e-02f, -1.58544496e-01f, 2.18037888e-01f, 1.36778474e-01f, -1.22128129e-01f, 1.09194770e-01f,
  2.24716514e-01f, -3.03413033e-01f, 4.00861800e-02f, -8.58231038e-02f, -1.82135954e-01f, -1.59670357e-02f, -9.74095613e-02f, -5.13431802e-02f, -1.72197372e-01f, 1.55948296e-01f,
  -1.45464420e-01f, 1.42481163e-01f, 1.85293689e-01f, -1.47333801e-01f, -1.31315082e-01f, -3.04483119e-02f, -1.11670233e-01f, 9.61814895e-02f, 3.20446715e-02f, 1.01366863e-01f,
  -1.62948016e-02f, 6.67671934e-02f, -7.85111785e-02f, 2.14177873e-02f, -3.27306539e-02f, -1.33311436e-01f, 8.18912610e-02f, -1.59216654e-02f, -1.38924196e-01f, -8.61554965e-02f,
  -7.72428885e-02f, -8.57732743e-02f, 1.31901875e-02f, -9.52889621e-02f, -7.48461932e-02f, 3.40884440e-02f, 6.64982349e-02f, 2.64982712e-02f, 1.39903009e-01f, -1.61953673e-01f,
  3.23683582e-02f, 9.61938277e-02f, 4.15841080e-02f, -9.89447832e-02f, 2.44661048e-02f, 3.09880264e-02f, -6.36367053e-02f, -5.10587059e-02f, -5.00152111e-02f, 9.11831930e-02f,
  1.30594581e-01f, 7.23566711e-02f, 1.67329237e-01f, -1.33356228e-01f, 1.27356455e-01f, -1.78502247e-01f, -9.23834890e-02f, 5.17449565e-02f, 4.02710438e-02f, 4.54517119e-02f,
  1.61488235e-01f, -2.56009340e-01f, 2.69048754e-02f, -1.61544606e-02f, 8.96971375e-02f, -1.66199774e-01f, 1.27932385e-01f, 7.73079544e-02f, -8.88402164e-02f, 5.29684871e-02f,
  -2.60889322e-01f, -6.08921163e-02f, -2.21411631e-01f, 5.57646155e-02f, -4.21444550e-02f, -2.90361166e-01f, 1.63442045e-01f, -9.06343982e-02f, -5.29795587e-02f, 2.42430374e-01f,
  8.39261636e-02f, -1.71376154e-01f, -1.00950629e-01f, -1.78055093e-01f, 6.94891289e-02f, -9.33793113e-02f, 2.03422889e-01f, -5.29510118e-02f, -1.08099990e-01f, 1.06101878e-01f,
  -7.02830553e-02f, -3.77294347e-02f, -3.35913710e-02f, 8.79349560e-02f, -1.06107302e-01f, -7.62953004e-03f, -3.47361118e-02f, 7.88097829e-02f, -6.32133335e-02f, 3.50262076e-02f,
  -1.15697190e-01f, 1.27540171e-01f, -7.80267864e-02f, -9.69985723e-02f, 3.17287631e-02f, -1.05848849e-01f, 1.45044267e-01f, -4.74523753e-02f, 5.50966896e-02f, 5.72502054e-02f,
  7.39125088e-02f, 1.27906531e-01f, 8.00056309e-02f, 5.44700399e-02f, -9.36678946e-02f, 9.01489779e-02f, -1.02756426e-01f, -2.13393942e-01f, 1.30096704e-01f, 6.85988292e-02f,
  -2.27746874e-01f, 1.23061970e-01f, 2.31143087e-01f, -8.91491398e-02f, 4.16579209e-02f, -4.26924089e-03f, 8.74006897e-02f, -1.82716444e-01f, -1.86823636e-01f, 2.86324322e-01f,
  -1.80692852e-01f, -1.60072464e-02f, 1.57906860e-01f, -6.61973804e-02f, 1.04209282e-01f, 1.84715956e-01f, -3.49020846e-02f, -2.39871070e-01f, 1.62714496e-01f, -9.74569768e-02f,
  -2.72327751e-01f, -1.96876645e-01f, 1.98573560e-01f, 4.93941344e-02f, 1.51915520e-01f, 7.70403743e-02f, -2.14741573e-01f, 1.11724637e-01f, -1.14354357e-01f, -1.73910409e-02f,
  2.35860739e-02f, -1.24872446e-01f, 7.07232533e-03f, 1.21175237e-01f, 1.22623714e-02f, -1.53448626e-01f, -1.40162734e-02f, 1.19119190e-01f, 1.76437065e-01f, -1.11020878e-01f,
  -1.53134808e-01f, 7.29577914e-02f, -4.26015034e-02f, 1.79230064e-01f, 1.10772982e-01f, 3.54212197e-03f, 9.94102210e-02f, -8.38234201e-02f, 3.63102066e-04f, 1.14906952e-01f,
  -8.36561993e-02f, -2.31346302e-02f, 1.42056763e-01f, -8.94846544e-02f, -1.73827171e-01f, 1.54584527e-01f, -1.32397458e-01f, 1.20574713e-01f, 1.41120598e-01f, -1.94420204e-01f,
  1.41965255e-01f, -1.69879630e-01f, -3.14561725e-02f, -6.78709522e-02f, -5.45153879e-02f, 9.75151137e-02f, 1.89454943e-01f, 6.98386356e-02f, 2.13270515e-01f, -7.57270455e-02f,
  1.36264637e-02f, 7.69865175e-04f, 7.71308467e-02f, 1.61970511e-01f, -6.56744465e-03f, 1.20143458e-01f, -7.09962845e-02f, -8.02796409e-02f, 5.62861003e-02f, -6.53505027e-02f,
  -2.40722805e-01f, -1.84965611e-01f, 2.46047184e-01f, 2.81127021e-02f, -1.47875071e-01f, 1.03512354e-01f, -3.74906696e-02f, 1.84520826e-01f, -6.14765063e-02f, -2.20641404e-01f,
  -8.86536390e-03f, 7.69537538e-02f, -6.54167384e-02f, -1.26541406e-01f, -1.23757176e-01f, 9.56600681e-02f, -1.55000955e-01f, -7.15787262e-02f, -8.77782181e-02f, -4.91695255e-02f,
  -1.56242743e-01f, -1.76127061e-01f, 7.06040487e-03f, 2.84643024e-02f, 1.44166261e-01f, 9.75039322e-03f, 1.41974449e-01f, 1.11990891e-01f, -1.44466981e-01f, -4.66820523e-02f,
  -1.87943764e-02f, -1.06719576e-01f, 3.79479378e-02f, -1.84252530e-01f, 1.80790201e-02f, 1.23522719e-02f, 6.56283423e-02f, 4.02827514e-03f, -2.28379771e-01f, 4.30426076e-02f,
  7.66930804e-02f, -2.89070010e-01f, -8.45495164e-02f, -5.21419942e-02f, 9.94325802e-02f, 2.59368926e-01f, 3.58679473e-01f, 1.51188925e-01f, -9.74976793e-02f, 3.38311978e-02f,
  1.04181487e-02f, 1.98728547e-01f, 8.67118239e-02f, 1.67935148e-01f, -1.60625279e-01f, 2.46787906e-01f, -6.32438511e-02f, 2.82707930e-01f, -1.97471306e-01f, 1.49027824e-01f,
  -4.34410013e-02f, 4.24627028e-02f, -9.95390266e-02f, 7.95187801e-02f, -1.26632571e-01f, 7.39572942e-02f, -7.19446093e-02f, -3.02692521e-02f, 3.24878469e-02f, 3.29224050e-01f,
  -9.47551653e-02f, -9.99325588e-02f, 5.35130315e-02f, -1.85240358e-01f, -9.72241834e-02f, 2.74876077e-02f, 1.59127370e-01f, 1.51158469e-02f, 4.78346720e-02f, -2.26767883e-01f,
  -1.04015641e-01f, -2.89953258e-02f, -8.33651423e-02f, -1.18821748e-02f, -1.08530931e-01f, 8.57453123e-02f, 7.57583454e-02f, -6.58417121e-02f, -1.10663837e-02f, -1.08343445e-01f,
  1.85523531e-04f, -7.37719312e-02f, 5.25795370e-02f, -1.25360921e-01f, 2.30131783e-02f, -1.21141179e-02f, 5.19783758e-02f, -7.49117509e-02f, 1.69777349e-02f, 5.34230983e-03f,
  3.55001260e-03f, -1.14663973e-01f, 1.00317873e-01f, -1.95264056e-01f, 1.07443675e-01f, -2.47912332e-01f, -1.86871156e-01f, -7.17488006e-02f, 1.10709779e-01f, 9.05354768e-02f,
  -1.55120343e-02f, -1.95701838e-01f, 1.40385274e-02f, -8.36703330e-02f, -6.01663440e-02f, -1.32199869e-01f, -2.89079454e-02f, -2.12013777e-02f, 1.14362836e-01f, 9.61586684e-02f,
  2.05484867e-01f, 1.12423763e-01f, -1.12262025e-01f, -1.46147445e-01f, -1.83634311e-01f, 9.23338011e-02f, -9.17517096e-02f, -1.23277269e-01f, 1.48340970e-01f, 1.81480974e-01f,
  -1.45197168e-01f, 4.20409180e-02f, 1.47853345e-01f, 5.93855493e-02f, -5.15649132e-02f, 1.23494871e-01f, -8.71572196e-02f, -2.51161337e-01f, 1.45581841e-01f, 2.03353569e-01f,
  -6.19205125e-02f, 3.72181833e-02f, -9.93527323e-02f, -5.59068210e-02f, -1.48046687e-01f, -1.12545662e-01f, 6.21505231e-02f, 2.01134700e-02f, 6.36141747e-02f, 3.31605300e-02f,
  2.71407492e-03f, 1.22350119e-02f, -2.13698335e-02f, 1.02120638e-01f, -4.25145030e-02f, -4.11251858e-02f, -1.18218504e-01f, 1.76216327e-02f, 6.03142381e-02f, -8.30044597e-02f,
  6.97700083e-02f, -6.88350350e-02f, -8.04562941e-02f, -2.19115317e-02f, -9.24594700e-02f, -1.37864500e-01f, -1.14303738e-01f, -7.42485151e-02f, 1.03320859e-01f, -1.14800096e-01f,
  -1.44478858e-01f, -2.37671003e-01f, 2.26982668e-01f, 1.59588516e-01f, 8.51547718e-02f, -2.33846307e-01f, -1.78484485e-01f, -1.02858834e-01f, -1.31140156e-02f, 9.05211568e-02f,
  7.12278411e-02f, -1.46800786e-01f, -1.04060672e-01f, 2.21842453e-01f, 1.99786827e-01f, 1.63431033e-01f, -1.01850167e-01f, 2.51432091e-01f, -1.66908905e-01f, 1.09856306e-02f,
  -2.08704755e-01f, -7.76949152e-02f, -2.02393055e-01f, 2.15153232e-01f, 1.06145158e-01f, -1.34532586e-01f, 5.91707565e-02f, 1.12687275e-01f, 1.59877967e-02f, 1.53798074e-01f,
  -1.60271540e-01f, -2.07515091e-01f, -7.39724711e-02f, 1.08262390e-01f, -9.13727209e-02f, -1.45243064e-01f, -1.12362951e-01f, 4.51220162e-02f, 1.46832345e-02f, -1.67775769e-02f,
  2.03413498e-02f, 1.15052775e-01f, -1.25464916e-01f, -6.03018142e-02f, 2.06914432e-02f, -1.24001138e-01f, -1.37957990e-01f, -1.88284945e-02f, 6.15643710e-02f, 5.37384674e-02f,
  -4.42620665e-02f, -5.52691482e-02f, 4.66753133e-02f, -7.63296708e-02f, 2.51401924e-02f, -1.23180665e-01f, -1.36440858e-01f, 8.14694986e-02f, 4.79441173e-02f, -3.84826516e-03f,
  -7.18384515e-03f, -1.66287303e-01f, 7.33403042e-02f, -5.24527691e-02f, -4.07014005e-02f, -2.21095942e-02f, -6.46853819e-02f, -1.56328067e-01f, 5.37323728e-02f, 1.50077924e-01f,
  -2.28980884e-01f, 2.11263433e-01f, 2.07357869e-01f, 1.00677367e-02f, -3.89831215e-02f, 7.91025534e-02f, -2.38035098e-01f, -2.22212318e-02f, 9.77640599e-02f, 2.14307949e-01f,
  -1.87619314e-01f, 6.50765821e-02f, 2.51621753e-01f, -1.24622449e-01f, 2.70351946e-01f, -3.88717488e-03f, -3.58632579e-02f, -3.10781524e-02f, 1.68396875e-01f, -1.38028324e-01f,
  -1.50909781e-01f, 5.04898792e-03f, -1.23841297e-02f, -7.34631717e-03f, 1.83958128e-01f, -1.76350489e-01f, 6.20790459e-02f, 9.49216038e-02f, -9.01604071e-02f, -1.12220213e-01f,
  -7.22540617e-02f, -3.97598334e-02f, -7.64469504e-02f, -7.93651044e-02f, -7.21609592e-02f, -1.20637296e-02f, 3.78458388e-02f, -1.24118865e-01f, -3.35671343e-02f, 4.46418002e-02f,
  -3.37510817e-02f, -6.24010414e-02f, -8.33501294e-02f, -1.11594297e-01f, -1.03551537e-01f, -1.82152823e-01f, 1.06842637e-01f, 1.51225343e-01f, 3.48205902e-02f, -1.33678511e-01f,
  -5.18561937e-02f, 2.40599941e-02f, -4.79769111e-02f, 2.35821418e-02f, 5.64817749e-02f, 1.30392075e-01f, 2.04712749e-02f, -9.31655690e-02f, -8.89556296e-03f, 5.56348115e-02f,
  -3.97967398e-02f, 1.16792008e-01f, -4.46737465e-03f, -2.30122730e-01f, 2.33629197e-01f, -1.39337286e-01f, 8.86406191e-03f, -4.38947938e-02f, 1.30041897e-01f, 1.39265016e-01f,
  6.58698231e-02f, 6.89930618e-02f, 7.47737959e-02f, -2.26866275e-01f, 4.99717593e-02f, -6.74577728e-02f, -2.34867632e-01f, 5.75385951e-02f, -2.62498140e-01f, -9.41671729e-02f,
  -2.97365356e-02f, 8.74315649e-02f, -2.08093986e-01f, 1.63238168e-01f, 1.05264336e-01f, -1.11205708e-02f, 4.22227308e-02f, 3.49275954e-02f, -1.92127526e-01f, 1.35454893e-01f,
  7.49806240e-02f, 3.83821838e-02f, 4.72481400e-02f, 9.66157913e-02f, 9.65466425e-02f, -1.32585108e-01f, 8.12461078e-02f, -1.56580672e-01f, 1.87935438e-02f, 9.52910539e-03f,
  3.70375775e-02f, 6.86221644e-02f, 1.02656186e-01f, -1.33835539e-01f, 8.27196538e-02f, -4.15043831e-02f, 7.35573769e-02f, -1.85203746e-01f, 2.52226293e-02f, -9.17722508e-02f,
  -9.34175849e-02f, 1.71469245e-02f, -1.05292477e-01f, 1.43480673e-01f, 5.03752604e-02f, 3.62752303e-02f, 2.82192486e-03f, -9.50836316e-02f, 6.39879405e-02f, -1.67447358e-01f,
  -1.46113858e-01f, -1.64410204e-01f, -1.09690309e-01f, 1.62200674e-01f, -2.24177182e-01f, 1.44478664e-01f, -1.91067263e-01f, -2.69033253e-01f, 1.62999853e-02f, 1.61154941e-01f,
  -1.15206845e-01f, -2.10483428e-02f, 5.48250191e-02f, -1.45279855e-01f, 1.63826957e-01f, -5.76827768e-03f, 9.08953547e-02f, -5.56782894e-02f, 1.28324583e-01f, -1.49159715e-01f,
  -1.76457390e-01f, 1.28398135e-01f, 1.37935504e-01f, 6.14685677e-02f, 1.88827932e-01f, -1.96931630e-01f, -1.65635005e-01f, 4.62412722e-02f, 3.89359668e-02f, -9.88756865e-02f,
  2.49613360e-01f, 2.69346796e-02f, -1.33786246e-01f, 1.45214451e-02f, -1.34214923e-01f, 5.84524758e-02f, 2.38770526e-02f, 7.08504170e-02f, 2.82373488e-01f, -1.96219206e-01f,
  -8.36049020e-02f, -9.82142612e-02f, -8.11321363e-02f, 1.12968281e-01f, -4.94634025e-02f, -1.01424597e-01f, -1.22904591e-01f, -5.80613092e-02f, -5.37009612e-02f, -7.92858973e-02f,
  1.19315898e-02f, 7.55213052e-02f, -1.20871544e-01f, -8.75677019e-02f, -1.19395807e-01f, -1.22735277e-01f, 1.03956290e-01f, -4.18908671e-02f, 3.82757699e-03f, -8.84982720e-02f,
  -1.82554632e-01f, 1.16570272e-01f, -1.81399450e-01f, -8.15892294e-02f, -1.67447507e-01f, -1.61072761e-01f, 1.60193462e-02f, -2.67598443e-02f, -1.57098785e-01f, 8.81980807e-02f,
  2.08045557e-01f, -8.96110609e-02f, 1.82838947e-01f, -6.42529363e-03f, -1.95980743e-01f, 3.55361849e-02f, 2.44544908e-01f, 2.05129698e-01f, 1.75980002e-01f, 6.29944503e-02f,
  -1.23057604e-01f, -1.22320756e-01f, 1.65257320e-01f, -2.07889527e-01f, -1.92011639e-01f, 7.89827183e-02f, 7.19761550e-02f, 2.21052557e-01f, 7.68584311e-02f, -2.52598543e-02f,
  -8.24078768e-02f, 2.41049707e-01f, -3.62926386e-02f, 3.82842496e-02f, 1.89079300e-01f, -1.37412369e-01f, -7.74505064e-02f, 1.51011348e-01f, -1.59550682e-01f, -5.38960025e-02f,
  5.82918897e-02f, 9.52912774e-03f, 1.11546732e-01f, -2.00220555e-01f, -2.58005738e-01f, -8.17926899e-02f, -1.18880972e-01f, 6.16147108e-02f, -7.00908303e-02f, -1.68972269e-01f,
  -7.61864781e-02f, 1.02734931e-01f, 1.00667037e-01f, -1.28762228e-02f, 4.73911688e-02f, -7.49513879e-02f, -1.18547894e-01f, -1.22417711e-01f, -4.80947345e-02f, 1.49540196e-03f,
  -1.99388191e-02f, -1.90012485e-01f, -1.38110220e-01f, -4.19346057e-02f, 4.82868105e-02f, 5.45645654e-02f, -1.48596957e-01f, -7.17350394e-02f, -1.73454240e-01f, -5.65903261e-02f,
  -1.11206062e-01f, 1.54839173e-01f, -2.42172435e-01f, 2.52842307e-01f, -1.42731853e-02f, -1.35666087e-01f, 9.08983797e-02f, -9.69230011e-02f, -1.10396303e-01f, -3.22809094e-03f,
  -7.87973255e-02f, 1.32949829e-01f, 2.28987634e-01f, 7.16988072e-02f, -2.84084231e-01f, -5.90191688e-03f, 1.00515649e-01f, 3.26507054e-02f, 1.22262416e-02f, 3.42603400e-03f,
  -2.42968962e-01f, 3.39743234e-02f, 1.38584018e-01f, 1.69892147e-01f, -2.27390483e-01f, 3.20495740e-02f, 1.05478972e-01f, -5.47032170e-02f, 1.16618358e-01f, 2.97243029e-01f,
  -1.85467303e-01f, -7.31154084e-02f, 5.30580804e-02f, 1.46241905e-02f, 4.38342281e-02f, -7.23507702e-02f, -3.63345519e-02f, -1.00662015e-01f, -5.95356375e-02f, -2.24445984e-02f,
  -1.06108570e-02f, -1.06008433e-01f, -1.12483710e-01f, 3.52931730e-02f, -8.58898610e-02f, 1.10750265e-01f, 1.61388144e-01f, -1.53522715e-01f, -1.38536289e-01f, -2.14456543e-02f,
  1.31039783e-01f, 2.85693053e-02f, 1.10213064e-01f, -1.67719901e-01f, -3.52920592e-02f, 4.81493510e-02f, -7.94449374e-02f, 2.13517621e-02f, 2.57100929e-02f, 7.56010227e-03f,
  -2.63683293e-02f, -9.90874991e-02f, 3.13063599e-02f, -9.94538888e-02f, 8.60624984e-02f, 1.40509561e-01f, 6.97299168e-02f, 1.02992602e-01f, 6.84320852e-02f, -2.01217711e-01f,
  -2.10938100e-02f, -9.70634446e-02f, -1.48550943e-01f, 3.42832245e-02f, 4.18620892e-02f, -2.22041458e-01f, 2.71128327e-01f, -4.65776250e-02f, 9.89146251e-03f, -3.06548119e-01f,
  2.18153477e-01f, -1.73069015e-01f, -1.84721753e-01f, -3.50452354e-03f, -1.96649328e-01f, -1.26245186e-01f, 1.66804474e-02f, 1.32102566e-02f, -1.15664683e-01f, -5.04499003e-02f,
  1.68836862e-01f, -4.37703282e-02f, 1.22453898e-01f, 1.61461264e-01f, -2.70985395e-01f, -7.44141564e-02f, -1.15561761e-01f, 8.30676523e-04f, -6.97922111e-02f, 3.59683372e-02f,
  2.32176796e-01f, 1.21576609e-02f, 8.30036588e-04f, 2.86023226e-02f, -1.89329907e-01f, -1.49087831e-02f, -1.00622894e-02f, -6.99916333e-02f, -4.10500728e-02f, 9.79470164e-02f,
  2.07600981e-01f, 3.66965123e-02f, 6.04018047e-02f, 5.34274019e-02f, -6.27408326e-02f, -2.95710992e-02f, 6.16932474e-02f, 1.47472829e-01f, -6.26880750e-02f, -1.49346665e-01f,
  -1.35796703e-02f, -1.23178894e-02f, -1.47540674e-01f, 7.40347756e-03f, 1.57364964e-01f, -6.10491410e-02f, -3.07374950e-02f, 2.32704788e-01f, -2.97743315e-03f, -8.48101526e-02f,
  1.72935113e-01f, -5.07871620e-02f, 1.08671211e-01f, -1.65226638e-01f, 2.85478950e-01f, -5.33874556e-02f, -2.37967238e-01f, 1.17233098e-02f, 8.36659297e-02f, -1.23000711e-01f,
  5.52213788e-02f, -1.17485225e-01f, -1.29274502e-01f, -3.81435335e-01f, 1.37454540e-01f, -1.03008255e-01f, -2.86292344e-01f, 1.34623140e-01f, 9.09195244e-02f, 4.17433158e-02f,
  2.39578635e-02f, -1.51647702e-01f, -1.40462965e-01f, -8.04824941e-03f, 3.77248377e-02f, -1.95555404e-01f, -7.85797089e-02f, 6.18201606e-02f, -1.85164213e-01f, 1.66163251e-01f,
  6.59657121e-02f, -1.72202047e-02f, 2.64536999e-02f, 1.90199330e-01f, 1.48414105e-01f, 1.09544054e-01f, 2.62603201e-02f, -7.10102171e-02f, 1.40053198e-01f, 6.84916303e-02f,
  -1.46100856e-02f, 1.20494656e-01f, -3.42087075e-02f, -1.07824832e-01f, 3.84085439e-02f, 6.66634664e-02f, 5.78896254e-02f, -1.28185108e-01f, 4.74935658e-02f, -6.38114363e-02f,
  -4.23326306e-02f, 7.62713626e-02f, 9.74710062e-02f, 7.24370703e-02f, -5.06708063e-02f, 6.07274957e-02f, 9.88215953e-02f, -4.56548743e-02f, -9.03171152e-02f, 8.55010897e-02f,
  -1.50645282e-02f, -5.04377075e-02f, -1.59215227e-01f, 1.82863995e-02f, -3.29159260e-01f, -9.34426486e-02f, -3.62319872e-02f, 1.43029660e-01f, -6.94895461e-02f, 1.72169149e-01f,
  9.70165581e-02f, -2.88622919e-03f, -2.35445611e-02f, 9.25369859e-02f, 1.17184721e-01f, 7.33824596e-02f, -3.07225045e-02f, 2.27484316e-01f, -1.07008055e-01f, 1.29258677e-01f,
  2.75262684e-01f, -1.01274922e-01f, 7.34118372e-02f, 1.45645007e-01f, -3.96812409e-02f, -1.40726432e-01f, 2.08939686e-01f, 2.79122796e-02f, -1.38936520e-01f, 1.60507634e-01f,
  2.37922281e-01f, 2.54436359e-02f, 2.31889505e-02f, -8.38963985e-02f, -3.43495160e-02f, -4.72801663e-02f, -1.48482010e-01f, -5.37932664e-02f, -1.98934928e-01f, 4.77371439e-02f,
  1.40775859e-01f, -1.59291327e-02f, -1.45023093e-01f, -1.04715265e-01f, -1.11307465e-01f, 9.31260437e-02f, 1.60606708e-02f, 6.59662858e-02f, 6.43324107e-02f, -1.32115304e-01f,
  -8.53824541e-02f, -4.75320173e-03f, 1.15892753e-01f, -1.71975624e-02f, 6.91995695e-02f, 7.73562938e-02f, 1.11709021e-01f, 2.23524608e-02f, 5.76827712e-02f, 9.23683047e-02f,
  -6.53202012e-02f, 6.28027469e-02f, -8.50689113e-02f, 5.50319850e-02f, -1.05025791e-01f, 1.19940378e-02f, -6.26261234e-02f, 1.15900300e-01f, -3.70454602e-02f, 7.92224929e-02f,
  -7.40321204e-02f, -1.79302573e-01f, 1.93457395e-01f, 7.39662796e-02f, 1.99868545e-01f, -1.73125178e-01f, 1.40153736e-01f, 2.47636035e-01f, 1.43761009e-01f, 1.53542861e-01f,
  5.75383566e-02f, -7.34248757e-02f, -4.93912362e-02f, -5.50702922e-02f, -2.02243894e-01f, -4.58775163e-02f, 7.19301179e-02f, 1.08881973e-01f, -2.18009762e-02f, -9.61392149e-02f,
  1.14503637e-01f, 2.81348169e-01f, 1.49397505e-02f, 6.00254610e-02f, 1.64743185e-01f, -1.61723435e-01f, -2.59302795e-01f, 1.18760712e-01f, -2.71626282e-02f, 1.68675661e-01f,
  -2.38678426e-01f, -4.04753629e-03f, -2.04726920e-01f, -1.10144615e-01f, 1.43016232e-02f, -3.22748423e-02f, -4.48068231e-02f, -9.78938211e-03f, 1.27656311e-01f, 1.54775515e-01f,
  1.00733437e-01f, 1.44918203e-01f, 2.15510517e-01f, 7.64988139e-02f, -5.44860102e-02f, 8.81490484e-02f, -5.31945936e-02f, -1.88043881e-02f, 8.10936317e-02f, 1.23314429e-02f,
  6.54541329e-02f, -3.13255116e-02f, -2.45565549e-02f, 8.97187442e-02f, -6.69347169e-03f, 1.71351075e-01f, 1.13594919e-01f, 1.05269104e-01f, 1.28343895e-01f, 2.60863543e-01f,
  1.05195373e-01f, -9.41750826e-04f, 2.66960293e-01f, -1.30200058e-01f, 1.56415850e-01f, 2.65096396e-01f, -1.58936277e-01f, 4.75890487e-02f, 1.09728009e-01f, -9.85877663e-02f,
  1.62626207e-01f, 1.60463274e-01f, -2.21256495e-01f, -9.55718160e-02f, -8.91065225e-02f, 5.91580011e-03f, 7.83983245e-02f, 1.33858040e-01f, 6.33561388e-02f, 8.05304721e-02f,
  -2.61740219e-02f, 1.19259849e-01f, -1.86627544e-02f, 2.02707108e-02f, -1.39096435e-02f, 2.01151952e-01f, -6.25104308e-02f, 7.11754721e-04f, -1.28957331e-01f, -2.92321891e-01f,
  6.29674941e-02f, 8.33082665e-03f, -6.79798275e-02f, -8.77883062e-02f, 2.18521401e-01f, 8.64759833e-02f, -3.57722789e-02f, 1.84019469e-02f, -7.51081854e-02f, 9.17481035e-02f,
  6.73785359e-02f, 8.80216509e-02f, -5.62035330e-02f, -6.65780231e-02f, 1.86520204e-01f, -4.54606079e-02f, 9.19658318e-02f, 5.02051674e-02f, -6.90342635e-02f, -9.72114056e-02f,
  5.49718067e-02f, 1.34850144e-01f, -1.02564692e-01f, 6.72333688e-02f, 2.21054386e-02f, -7.64387250e-02f, -1.06588781e-01f, 3.57475877e-02f, 4.10206579e-02f, -9.79300365e-02f,
  -1.02891982e-01f, -6.76129907e-02f, 8.19313005e-02f, -1.31155327e-02f, -2.64757156e-01f, -1.72582746e-01f, 6.62224144e-02f, 5.38302176e-02f, -1.25901878e-01f, -2.44937167e-02f,
  -1.03238061e-01f, 2.16907278e-01f, 5.61094694e-02f, 2.64612958e-02f, -6.48732632e-02f, -2.29824126e-01f, 4.31687981e-02f, 1.66475236e-01f, 2.18199015e-01f, 2.78659493e-01f,
  -2.52238303e-01f, -5.78127131e-02f, 7.14134332e-03f, -1.33208096e-01f, 2.36887380e-01f, -6.69630915e-02f, -3.25224660e-02f, 1.87262148e-01f, 8.36005360e-02f, -1.23206794e-01f,
  -1.36087030e-01f, 1.12790987e-01f, 1.90209851e-01f, 1.94855053e-02f, -1.00439757e-01f, -2.71763593e-01f, 1.51657015e-01f, -1.24837225e-02f, -5.53661883e-02f, -1.66159794e-01f,
  8.59401226e-02f, 6.09767511e-02f, -1.76977828e-01f, -1.29988462e-01f, 1.48950979e-01f, 1.79790691e-01f, -2.58071069e-02f, 5.06898686e-02f, -2.99414080e-02f, -1.31035849e-01f,
  -1.20953575e-01f, -3.30273248e-02f, 8.71549919e-02f, -2.49798894e-01f, -4.33641225e-02f, 1.20094113e-01f, 2.07225792e-02f, 1.25883043e-01f, -4.88853604e-02f, -9.93651748e-02f,
  3.14023420e-02f, -1.50594816e-01f, 7.31054097e-02f, -3.41379568e-02f, 6.14561178e-02f, 1.54107258e-01f, -1.77007660e-01f, -2.30963260e-01f, -1.33262634e-01f, 1.33887470e-01f,
  -2.37541154e-01f, -5.82449920e-02f, -6.11700863e-02f, -1.46590948e-01f, -2.87985772e-01f, 1.40995726e-01f, -7.76837766e-02f, -5.54975681e-02f, -2.42173746e-01f, -2.45422408e-01f,
  1.15919197e-02f, 3.33939977e-02f, -1.17503241e-01f, 3.24211746e-01f, -2.49081358e-01f, 5.15009724e-02f, 2.41102815e-01f, -3.18331048e-02f, 4.22403263e-03f, -1.28677532e-01f,
  1.15573376e-01f, 1.43434137e-01f, 5.27115725e-02f, -1.33299604e-01f, -1.26763776e-01f, 1.01795077e-01f, 1.32299989e-01f, 2.00521439e-01f, -1.98665038e-02f, -1.43496066e-01f,
  -2.86009945e-02f, 1.35528902e-02f, 8.42849240e-02f, -1.38076797e-01f, 5.55156264e-03f, -2.03703493e-01f, -4.06829193e-02f, -4.91871238e-02f, 1.50958851e-01f, -1.16329432e-01f,
  1.26480669e-01f, 1.99424192e-01f, 6.39118552e-02f, 9.40947980e-02f, 5.17298393e-02f, -1.61848590e-01f, -1.11268491e-01f, 7.51695409e-02f, 1.32679611e-01f, 1.64040774e-01f,
  1.15272284e-01f, 1.05458703e-02f, 2.99945902e-02f, -1.80748031e-02f, -7.25648478e-02f, -1.23943746e-01f, 9.59712192e-02f, 1.18105188e-02f, -7.80644491e-02f, 1.54074043e-01f,
  -5.67932986e-02f, 2.27494732e-01f, 3.79242264e-02f, 1.81587160e-01f, 1.44136265e-01f, -1.48166254e-01f, -4.19403911e-02f, 4.60869335e-02f, -2.92149276e-01f, 2.96381950e-01f,
  9.23268646e-02f, -3.94345671e-02f, 8.39441940e-02f, -2.96962202e-01f, 1.07258044e-01f, -2.14750562e-02f, 5.72556891e-02f, -6.96933419e-02f, 5.99271543e-02f, 1.71722844e-01f,
  -6.95764646e-02f, -1.74381495e-01f, -1.27859876e-01f, -9.87786651e-02f, -1.87850341e-01f, -1.16020530e-01f, 2.10628688e-01f, -2.13185735e-02f, 3.08615202e-03f, -1.13930658e-01f,
  1.09502196e-01f, 9.34720039e-02f, 1.84692472e-01f, -9.27133784e-02f, -1.97078437e-01f, -1.79918543e-01f, 9.99619290e-02f, -1.44930467e-01f, -4.28779833e-02f, 9.64172110e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  2.39546284e-01f, 8.81039500e-02f, 2.30542168e-01f, 1.42264232e-01f, 5.61413541e-02f, 1.19908797e-02f, 2.14743614e-01f, 4.48959321e-02f, 5.57688661e-02f, -1.65161178e-01f,
  1.75277635e-01f, -1.15243364e-02f, 1.87220559e-01f, 1.12088121e-01f, 2.07011372e-01f, 1.50283471e-01f, -2.39718277e-02f, 2.55745709e-01f, 1.03934281e-01f, 1.45903111e-01f,
  3.89568210e-02f, 8.88685435e-02f, 3.65220398e-01f, -1.27117962e-01f, 3.18260103e-01f, -8.76113847e-02f, 2.20835000e-01f, 1.32812932e-01f, 3.50285433e-02f, -2.18023267e-03f,
  -4.78997797e-01f, 5.73448241e-02f, -2.82827523e-02f, 5.77202067e-03f, -2.43379399e-01f, -2.90743440e-01f, -3.50517124e-01f, -3.38922828e-01f, -7.42250755e-02f, -1.50856644e-01f,
  2.86478251e-01f, -2.10037336e-01f, 3.15258955e-03f, -2.51497865e-01f, 1.77624434e-01f, 1.95173740e-01f, 1.60961095e-02f, -2.59548515e-01f, 4.77330834e-02f, 7.29393214e-03f,
  1.34871379e-01f, -1.03471249e-01f, 1.95075840e-01f, -2.26098523e-01f, 5.21340668e-02f, -3.42237115e-01f, 2.54675571e-04f, 2.85377592e-01f, 3.13940883e-01f, 7.48395696e-02f,
  1.84252977e-01f, 1.05675444e-01f, 4.64767158e-01f, 5.49487136e-02f, 4.11639176e-02f, 1.36722744e-01f, 3.13950390e-01f, -4.11255173e-02f, 1.97579175e-01f, 2.13239595e-01f,
  2.34800413e-01f, -1.26196280e-01f, -7.19245896e-02f, 9.66561288e-02f, 1.31324813e-01f, 5.73659651e-02f, 2.60229200e-01f, 2.75430620e-01f, 3.92128341e-02f, 1.08856276e-01f,
  -2.05513425e-02f, 2.45378181e-01f, 6.87321872e-02f, -5.63902631e-02f, 1.67294055e-01f, 2.16889158e-02f, 7.95542076e-02f, 2.87788808e-01f, -1.48967383e-02f, -4.36705612e-02f,
  1.92970350e-01f, 2.95583665e-01f, 1.69212475e-01f, -2.51578659e-01f, -3.40630025e-01f, 1.31199896e-01f, -4.84125584e-01f, 5.76468594e-02f, 4.00540903e-02f, 1.38904914e-01f,
  -2.64639884e-01f, -4.52592432e-01f, -3.21062565e-01f, -1.41002551e-01f, 1.97498262e-01f, 1.73567384e-02f, -4.37526368e-02f, 3.43957782e-01f, 2.88913310e-01f, 1.40619576e-02f,
  -3.07496816e-01f, -4.69372898e-01f, -1.46805063e-01f, 1.27206087e-01f, 8.04705024e-02f, -3.35150391e-01f, 1.87505201e-01f, 3.13394189e-01f, 2.56588548e-01f, 9.74529162e-02f,
  2.29396671e-01f, -9.24495310e-02f, 4.56151329e-02f, -1.15873270e-01f, 2.73837715e-01f, -3.71749192e-01f, 2.54172534e-01f, 1.59568340e-01f, 1.63856402e-01f, 1.11583918e-01f,
  3.85859311e-02f, 1.85017303e-01f, -2.64029615e-02f, 1.62862167e-01f, -1.14890784e-01f, 8.39045420e-02f, -1.63890168e-01f, 2.19026804e-01f, 1.56349108e-01f, 8.22941586e-02f,
  1.34197518e-01f, 1.23706430e-01f, -4.33859900e-02f, 5.29646613e-02f, 3.39406908e-01f, 1.68269604e-01f, -7.10206553e-02f, -4.60783653e-02f, 1.08569032e-02f, 1.90041870e-01f,
  -1.14536531e-01f, -1.17843270e-01f, -1.97892308e-01f, 1.58374950e-01f, -2.56463408e-01f, 4.66648221e-01f, -5.53306520e-01f, 7.19454736e-02f, -5.56049831e-02f, 1.78780228e-01f,
  1.30681813e-01f, 4.08541799e-01f, 1.92898229e-01f, 2.47462858e-02f, -1.16337880e-01f, 3.09230179e-01f, 2.06718639e-01f, -3.21955770e-01f, -3.94936800e-01f, -4.03412804e-02f,
  1.40044102e-02f, -4.22960639e-01f, 4.54127282e-01f, 1.86489582e-01f, 4.70576465e-01f, 2.56231219e-01f, 2.56340235e-01f, -3.17615122e-01f, 4.11149502e-01f, 6.57468215e-02f,
  -2.77798504e-01f, -3.28758597e-01f, 4.62747186e-01f, 6.12202883e-01f, 2.86686987e-01f, 3.98923308e-01f, -4.65623774e-02f, 1.57631949e-01f, -9.53366086e-02f, 4.62778211e-01f,
  -2.10684180e-01f, -4.54444177e-02f, 3.14462767e-03f, 1.22431986e-01f, -1.14104468e-02f, 3.19923251e-03f, 1.45882130e-01f, 2.39869311e-01f, 2.33352497e-01f, 3.07341486e-01f,
  4.35053408e-02f, 3.14620912e-01f, -9.31279138e-02f, 3.03267390e-02f, 3.36343236e-02f, 9.95161012e-02f, 9.16402712e-02f, 1.09730624e-01f, 6.46488070e-02f, -6.39595240e-02f,
  3.42007242e-02f, 6.21092655e-02f, 3.28242719e-01f, 1.93759337e-01f, -1.55145183e-01f, 2.39293262e-01f, -2.92885154e-02f, 3.68052274e-02f, -3.28974754e-01f, -2.25647718e-01f,
  4.63953465e-02f, -9.88754854e-02f, 5.04553784e-03f, -1.97746366e-01f, 3.37349623e-01f, -2.17030019e-01f, 4.42991734e-01f, -4.22103375e-01f, 1.93953693e-01f, 5.18231213e-01f,
  2.37378687e-01f, 1.21396020e-01f, 4.28571701e-02f, 1.74567178e-01f, -2.19828963e-01f, 3.02551657e-01f, -3.53170425e-01f, -3.33265103e-02f, -2.08923757e-01f, -1.27828285e-01f,
  -2.08272874e-01f, 3.13783400e-02f, 3.38734865e-01f, 4.86098289e-01f, 2.09262624e-01f, 5.78786492e-01f, 2.61395007e-01f, 8.09003174e-01f, 1.18961101e-02f, 3.88269536e-02f,
  2.08592340e-01f, 4.13115859e-01f, -2.10634455e-01f, 4.47857261e-01f, -3.98824990e-01f, 5.27105212e-01f, 1.95617020e-01f, -1.53874746e-02f, 7.88759962e-02f, 2.26548925e-01f,
  2.42221296e-01f, 2.75396705e-02f, 1.01704441e-01f, 8.57386887e-02f, 1.40787110e-01f, 1.12075336e-01f, 7.65677467e-02f, 5.20131625e-02f, 8.41454491e-02f, -2.65816003e-02f,
  -7.58343711e-02f, 2.47358799e-01f, 1.39510095e-01f, 2.33681984e-02f, -8.12445069e-04f, 8.49864855e-02f, -2.94128686e-01f, 2.50258207e-01f, 2.93907702e-01f, -2.45870426e-01f,
  1.21184535e-01f, 4.52921813e-04f, 2.09864542e-01f, 4.94489744e-02f, 4.54221852e-02f, 2.05796987e-01f, 1.04158163e-01f, 1.67869538e-01f, 2.51952052e-01f, 4.11639176e-02f,
  -5.06739676e-01f, -1.87407658e-01f, 1.39510080e-01f, 1.81737974e-01f, 1.17162436e-01f, -2.24871621e-01f, 3.07084620e-02f, -3.35071445e-01f, 3.48368496e-01f, -4.73564833e-01f,
  -2.15098038e-01f, 3.81103516e-01f, 2.86625415e-01f, 2.90446371e-01f, 4.08798546e-01f, -1.06061153e-01f, -9.98934880e-02f, 5.91405213e-01f, 3.20513934e-01f, -2.18195170e-01f,
  1.11139312e-01f, -5.12591183e-01f, 6.10160902e-02f, 3.46368641e-01f, 2.85614669e-01f, 1.02455013e-01f, 9.41523463e-02f, 3.53767753e-01f, 3.65274757e-01f, -1.83639862e-02f,
  5.69345169e-02f, 1.80012420e-01f, 2.36220658e-01f, -9.90992412e-02f, 1.39596999e-01f, 1.75962642e-01f, 1.11996599e-01f, 1.10057689e-01f, -8.66574049e-02f, -4.06791107e-04f,
  9.30602998e-02f, 2.08580717e-02f, 3.41222197e-01f, -5.95118068e-02f, 1.60939302e-02f, -7.28358701e-02f, -7.37778693e-02f, 3.04164827e-01f, -3.51392403e-02f, 2.59582535e-03f,
  9.72268432e-02f, -2.96101030e-02f, 1.51021898e-01f, -5.97698838e-02f, -1.13012576e-02f, -1.34371683e-01f, 5.28160371e-02f, 1.64247006e-01f, 3.95967901e-01f, 2.99839199e-01f,
  -3.76982927e-01f, -6.21591806e-01f, 2.25819722e-01f, -2.34127507e-01f, -8.72164443e-02f, -1.33071870e-01f, 7.38340914e-02f, -7.36003742e-02f, 2.71430910e-01f, -7.37817734e-02f,
  4.08608258e-01f, -5.35897553e-01f, 1.25710696e-01f, -6.31338730e-02f, -5.27000427e-01f, 2.98624158e-01f, -5.13395429e-01f, -2.88006425e-01f, -4.66769971e-02f, 2.75746614e-01f,
  -2.57825166e-01f, 7.10142478e-02f, 6.23050630e-01f, 3.07051122e-01f, 3.21646363e-01f, 7.48091042e-01f, -3.71238589e-01f, -3.63604836e-02f, 1.66253284e-01f, 1.92544639e-01f,
  5.46737481e-03f, -1.22928899e-02f, 4.60682929e-01f, 8.73549134e-02f, 7.48593314e-03f, 1.31104454e-01f, -8.33746865e-02f, 1.06373295e-01f, 3.36276442e-02f, -9.71230567e-02f,
  1.69717088e-01f, 2.01145083e-01f, 1.35962060e-02f, 2.76867189e-02f, 8.30085278e-02f, -2.25986809e-01f, 6.89985827e-02f, 1.30490288e-01f, 2.19978243e-01f, -1.53589606e-01f,
  1.95680588e-01f, 2.26550642e-03f, -6.74509257e-02f, 8.25643018e-02f, 3.90653238e-02f, -7.47802779e-02f, 3.80224511e-02f, -3.92343057e-03f, 2.16575190e-02f, -2.93669432e-01f,
  -1.23280913e-01f, 1.30635455e-01f, 2.99014337e-02f, 3.44586134e-01f, -2.51500428e-01f, -2.24445283e-01f, -2.45456174e-01f, -1.54935643e-01f, -4.18150658e-03f, -1.44689232e-01f,
  -1.15487657e-01f, -1.37341335e-01f, -8.61109123e-02f, -4.33919532e-03f, 1.44227728e-01f, -1.77567720e-01f, -3.31994027e-01f, 8.95955563e-02f, -1.12669416e-01f, 5.59857208e-03f,
  -4.07720745e-01f, -2.60697037e-01f, 2.89766863e-03f, 4.52172756e-01f, -3.61255258e-01f, -2.79203176e-01f, 8.30552354e-02f, 3.96343708e-01f, 2.64706343e-01f, -1.81438714e-01f,
  -1.01256408e-01f, -3.99825186e-01f, 2.10599691e-01f, 1.69767514e-01f, 1.00591689e-01f, -4.35431749e-01f, -7.16022998e-02f, 7.46184811e-02f, 1.23196609e-01f, 3.42711248e-02f,
  2.55005002e-01f, 1.90432653e-01f, 7.12748393e-02f, 1.14262834e-01f, 4.22974583e-03f, 2.76467148e-02f, 2.31669635e-01f, 1.13150276e-01f, 3.04972291e-01f, 2.05100954e-01f,
  1.37738422e-01f, 1.62045330e-01f, -2.17393458e-01f, 1.69219926e-01f, 2.30515242e-01f, 8.37446079e-02f, 4.42018509e-01f, 1.70789629e-01f, 3.15641552e-01f, 3.37117016e-01f,
  -1.48929870e-02f, 3.65702182e-01f, -3.93150933e-02f, 5.13132393e-01f, 2.13498712e-01f, 2.64136285e-01f, -3.47009420e-01f, -3.93619984e-01f, 4.73261811e-02f, 4.10651475e-01f,
  -3.31249118e-01f, 4.60328341e-01f, 5.16032167e-02f, 7.77730718e-02f, 5.79479244e-03f, -5.86960502e-02f, -1.22705035e-01f, -2.14697674e-01f, -3.93445462e-01f, 2.40411647e-02f,
  1.76334307e-01f, 2.38760319e-02f, 4.44505811e-01f, 1.57945648e-01f, 3.29776183e-02f, 2.24445328e-01f, -6.39571398e-02f, -2.29932696e-01f, 5.24024308e-01f, -1.18380249e-01f,
  -2.61806417e-02f, -2.37250298e-01f, 4.84263867e-01f, 9.76957977e-01f, 3.84637117e-01f, 1.36860251e-01f, 7.20222816e-02f, -2.50655532e-01f, 3.55309784e-01f, 9.10875946e-02f,
  1.83938920e-01f, 1.39831051e-01f, -3.11068863e-01f, -1.44207880e-01f, -6.85240105e-02f, 3.81532371e-01f, -1.47353962e-01f, -2.07557783e-01f, 2.10383892e-01f, -1.34993652e-02f,
  1.84915975e-01f, -2.66078293e-01f, 8.11680406e-02f, -4.33505297e-01f, -1.22694433e-01f, 6.71043023e-02f, -2.12998595e-02f, -1.26206517e-01f, -7.85024688e-02f, -3.86601001e-01f,
  2.64612615e-01f, 1.40841335e-01f, -8.85517076e-02f, 2.10923374e-01f, 1.37481987e-01f, 2.47079536e-01f, 4.40751463e-02f, -1.75520837e-01f, -5.44165671e-01f, 1.01689756e-01f,
  6.59348741e-02f, -1.01981694e-02f, -2.24410728e-01f, -5.78246117e-02f, -2.50115871e-01f, 1.30601853e-01f, -2.15087444e-01f, 2.11932193e-02f, -7.85126910e-02f, -4.07120198e-01f,
  1.95051413e-02f, 1.14405401e-01f, 2.20392972e-01f, 5.47806084e-01f, -3.36283416e-01f, 9.11373720e-02f, 2.49450784e-02f, 9.36050043e-02f, -8.37347284e-02f, 1.30698249e-01f,
  2.53999561e-01f, 2.44562909e-01f, 1.27732456e-01f, -8.86184052e-02f, 2.39462070e-02f, 4.07429487e-01f, 3.93220663e-01f, -2.36373022e-01f, 1.27314523e-01f, -2.19561636e-01f,
  1.07727565e-01f, 1.70646951e-01f, 8.08014497e-02f, -1.64529532e-01f, 4.06811148e-01f, -1.60804868e-01f, -1.32229611e-01f, -1.33528829e-01f, 2.04180449e-01f, -5.43513931e-02f,
  -7.86752477e-02f, 1.76093921e-01f, -1.56862989e-01f, 1.19092740e-01f, 1.76999137e-01f, 1.40153825e-01f, 2.32987329e-01f, 2.77503729e-01f, 6.91170022e-02f, 1.87020361e-01f,
  -1.17330439e-01f, -1.70120806e-01f, -1.31428361e-01f, -5.31234965e-02f, 2.20794722e-01f, 2.04385772e-01f, -7.05572776e-03f, 2.60851175e-01f, -7.61804357e-02f, 2.96906531e-01f,
  1.34710729e-01f, 4.24501389e-01f, 4.87449855e-01f, -3.13238725e-02f, 1.27995595e-01f, -2.21167997e-01f, 7.13743985e-01f, 1.86141983e-01f, -2.70990014e-01f, 6.49774373e-02f,
  -2.70906478e-01f, 4.50088173e-01f, 2.57234752e-01f, 3.72363001e-01f, -3.39361429e-01f, -2.50983506e-01f, -2.87476689e-01f, -1.29230440e-01f, 5.05423427e-01f, 2.43818060e-01f,
  -2.46282481e-02f, 1.43849820e-01f, 3.19289304e-02f, 2.53758699e-01f, -2.12425828e-01f, -1.14171416e-01f, 2.37131953e-01f, 3.13369006e-01f, 3.31751585e-01f, -2.70058393e-01f,
  4.38799225e-02f, -2.73916960e-01f, 2.92442888e-01f, 2.03339562e-01f, -1.14513442e-01f, -2.77808487e-01f, 4.54728276e-01f, 2.80707091e-01f, 1.55766442e-01f, 1.18396178e-01f,
  1.99344233e-01f, 2.08925635e-01f, 1.13887042e-01f, 1.22557908e-01f, 5.00830933e-02f, -2.30729997e-01f, 1.52601004e-01f, 2.50929594e-02f, 2.07980096e-01f, -2.01300725e-01f,
  2.96216458e-01f, -2.72568524e-01f, 1.10370435e-01f, 2.38894999e-01f, 1.44328013e-01f, -4.30813506e-02f, 2.78877437e-01f, 2.24404573e-01f, 1.08177043e-01f, 1.73303992e-01f,
  -6.37979448e-01f, 5.53754866e-02f, 2.61647522e-01f, -4.80544060e-01f, 1.61395356e-01f, -3.11891407e-01f, -1.01475872e-01f, 5.79476714e-01f, -4.17914867e-01f, 1.79560795e-01f,
  -2.46441394e-01f, -2.02376321e-02f, -3.50974441e-01f, 2.90995985e-01f, -6.33150518e-01f, -7.89171550e-03f, -1.48620635e-01f, -6.55587554e-01f, 3.66334356e-02f, -1.36248976e-01f,
  1.52471200e-01f, -1.99904636e-01f, -1.28851682e-01f, -8.52362871e-01f, 2.05848873e-01f, 2.77874887e-01f, 1.61903277e-01f, 1.35235205e-01f, 5.30676901e-01f, -1.95086479e-01f,
  2.21792489e-01f, -1.37217000e-01f, 3.08200289e-02f, -1.01892017e-01f, 3.31310034e-01f, -7.08481789e-01f, 1.85187548e-01f, 2.24137321e-01f, 1.77665353e-01f, 2.83892322e-02f,
  2.34536767e-01f, 1.69769406e-01f, 6.68379903e-01f, -1.87917396e-01f, 5.01384586e-02f, 2.52638310e-01f, 1.47880018e-01f, -2.87007894e-02f, 1.65744349e-01f, 9.87265036e-02f,
  2.42342860e-01f, 2.26821989e-01f, 1.20962359e-01f, 1.15176283e-01f, -9.47505161e-02f, 1.86184626e-02f, 5.70315570e-02f, 5.71009479e-02f, 3.38576287e-01f, -1.22368425e-01f,
  4.48559113e-02f, 3.63964662e-02f, 1.29791917e-02f, 1.60321891e-01f, 5.74842244e-02f, -3.48232165e-02f, 5.03032058e-02f, -7.58345947e-02f, 1.95184678e-01f, 2.78635044e-02f,
  -2.34951690e-01f, -5.24260178e-02f, 2.08845839e-01f, -4.45277803e-02f, -3.86799723e-02f, -8.82535353e-02f, -1.97702557e-01f, -2.02000677e-03f, 4.61344898e-01f, -3.43033969e-01f,
  -1.45862341e-01f, 1.35410473e-01f, -8.78900737e-02f, 1.36674747e-01f, 2.37000063e-01f, 2.34506857e-02f, -3.76500010e-01f, 3.76856148e-01f, -1.45030200e-01f, -1.39036641e-01f,
  -1.52357459e-01f, -2.82577485e-01f, -2.60131627e-01f, 1.11487523e-01f, 1.15834288e-01f, 2.37768516e-01f, 1.37161631e-02f, 6.07456982e-01f, 2.60386825e-01f, 2.37449482e-01f,
  -6.09225519e-02f, -3.62719238e-01f, 4.64096814e-02f, 3.33567679e-01f, -1.77329108e-01f, -2.69869357e-01f, -7.59128928e-02f, 2.14411348e-01f, -2.13927682e-02f, 7.33805075e-02f,
  1.38363972e-01f, 1.49908900e-01f, -3.53313871e-02f, 6.21168641e-03f, 3.81362401e-02f, 9.76035893e-02f, -1.25175282e-01f, -1.35702059e-01f, 1.64999545e-01f, -2.39010036e-01f,
  1.62341386e-01f, 2.22753450e-01f, 2.20575020e-01f, 2.10862428e-01f, 1.56067014e-01f, 1.64304212e-01f, 6.12308383e-02f, -2.66752969e-02f, 8.22435617e-02f, -7.91590363e-02f,
  4.33735400e-02f, 5.97338974e-02f, 1.62225232e-01f, -2.53436387e-01f, -5.01556471e-02f, 3.07328343e-01f, -1.44858673e-01f, 5.83601184e-02f, -5.33842266e-01f, -1.53560368e-02f,
  -8.60910416e-02f, 1.20013170e-01f, 4.91594076e-02f, -6.52971268e-02f, -3.43111038e-01f, -2.79623449e-01f, 2.23191101e-02f, -8.04626420e-02f, 3.23728740e-01f, -6.14624061e-02f,
  -2.94780016e-01f, -1.48542091e-01f, 1.80167228e-01f, 1.84185892e-01f, -1.91651493e-01f, -4.12385613e-01f, 2.95075953e-01f, 2.93106645e-01f, -9.70893204e-02f, -1.69098005e-01f,
  2.03033090e-01f, 5.69927275e-01f, 3.66433769e-01f, -1.13334797e-01f, 9.98056605e-02f, -1.80637881e-01f, 3.30394626e-01f, 2.16042578e-01f, 5.49624227e-02f, -2.38694295e-01f,
  1.21436082e-01f, 5.57654090e-02f, 3.95041555e-02f, 1.37976289e-01f, -8.26787204e-02f, 9.14564505e-02f, 2.15876281e-01f, 2.57276595e-02f, 6.40251189e-02f, 1.55712336e-01f,
  2.32353419e-01f, 1.05893500e-01f, 7.68576339e-02f, 9.52775776e-02f, -1.34887621e-01f, 1.30645007e-01f, 2.06056684e-01f, 2.17193678e-01f, -9.50181037e-02f, -2.43863970e-01f,
  1.36151552e-01f, 2.44026631e-01f, 1.85100451e-01f, 4.70966659e-02f, 2.94732183e-01f, 1.71130911e-01f, 2.71498948e-01f, 4.74334389e-01f, 1.28005194e-02f, -4.43359494e-01f,
  3.49001765e-01f, -1.43416554e-01f, 1.26055151e-01f, 3.85167837e-01f, -1.09004028e-01f, -3.11954528e-01f, 2.86027670e-01f, -3.60370010e-01f, 2.06638962e-01f, 2.88962513e-01f,
  -5.01845241e-01f, 1.11233957e-01f, 1.16408326e-01f, -5.22908680e-02f, -2.72538185e-01f, 3.52562547e-01f, 4.11511995e-02f, -1.23228848e-01f, 5.40527105e-02f, -1.34835327e-02f,
  -2.26239458e-01f, 2.62343884e-01f, 3.10380626e-02f, 8.52520615e-02f, 2.06506580e-01f, 2.50373930e-01f, -9.32482481e-02f, -3.06684524e-01f, 1.52811006e-01f, -1.16525322e-01f,
  3.87754709e-01f, 3.22164804e-01f, 2.45117813e-01f, 7.75505602e-02f, -1.89724699e-01f, 4.80557621e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  5.18235750e-02f, 3.66748311e-02f, 2.29234129e-01f, 1.01933047e-01f, 4.08135504e-02f, 4.73658554e-02f, -9.35244747e-03f, 9.54874381e-02f, 1.40397325e-01f, 2.12399796e-01f,
  2.47248486e-01f, 1.28929704e-01f, 1.08519979e-01f, 1.35742515e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  1.51367903e-01f, 1.57679319e-01f, 1.53387040e-01f, 2.83307135e-01f, -2.75032282e-01f, -1.95968419e-01f, 5.68450317e-02f, -4.12354730e-02f, 3.05555165e-02f, 2.31451109e-01f,
  -2.48297770e-03f, -6.68905228e-02f, 1.59882382e-02f, 4.06313911e-02f, -1.01166591e-01f, 2.63661027e-01f, 7.16204196e-02f, 4.28496040e-02f, -1.26111582e-01f, 4.18825919e-04f,
  1.70169666e-01f, -3.14199835e-01f, -2.60680646e-01f, -2.63472468e-01f, 2.29436308e-01f, -3.36788028e-01f, 3.34872693e-01f, 3.48022908e-01f, 1.74622640e-01f, -2.90910780e-01f,
  2.15217188e-01f, -2.41559014e-01f, -4.12750453e-01f, -1.77633092e-01f, -3.07278857e-02f, -8.56569186e-02f, -2.47097120e-01f, -2.13731095e-01f, 1.58651635e-01f, -4.35713232e-01f,
  -7.84379542e-02f, -1.05131350e-01f, -2.49417305e-01f, 1.57855064e-01f, -3.94516408e-01f, -3.12991738e-01f, 7.77609646e-02f, -2.92633593e-01f, 5.59159033e-02f, -1.75174475e-01f,
  -5.89079484e-02f, -2.20832035e-01f, -2.00525880e-01f, 5.00470959e-02f, 2.36930683e-01f, -1.90391794e-01f, -2.30026141e-01f, -4.02134918e-02f, -4.76669014e-01f, 2.54761159e-01f,
  -9.18616772e-01f, -3.24114770e-01f, -5.15792489e-01f, 3.92215133e-01f, -1.60097241e-01f, -1.58279166e-02f, 1.85685918e-01f, 6.68185204e-02f, -1.13232806e-01f, -2.07916543e-01f,
  2.40918487e-01f, -1.70583144e-01f, -2.45834794e-02f, 1.21188328e-01f, 1.26415327e-01f, 1.29171818e-01f, 1.31480366e-01f, 2.24084795e-01f, 9.01787132e-02f, -2.85767138e-01f,
  -9.14390571e-03f, 2.18694493e-01f, 2.61230201e-01f, 9.06897485e-02f, 4.50416543e-02f, 2.14803010e-01f, 1.12248719e-01f, -1.90109864e-01f, 1.85958311e-01f, -1.02612972e-01f,
  1.55197293e-01f, -2.81437010e-01f, -4.16086912e-01f, -1.17599674e-01f, 1.55432835e-01f, -3.15020941e-02f, 1.24399224e-02f, 3.11589003e-01f, -9.27132890e-02f, 3.76880139e-01f,
  3.92770648e-01f, -2.76778877e-01f, 1.86223805e-01f, -3.37860823e-01f, -1.08715124e-01f, -1.28137097e-01f, 2.72502631e-01f, -1.84073359e-01f, -2.12664634e-01f, 1.07834935e-01f,
  2.46815979e-01f, -8.82499963e-02f, -2.00425759e-01f, 2.67428845e-01f, 9.04125571e-02f, 2.55562633e-01f, -1.66038677e-01f, 1.47114828e-01f, -1.80751890e-01f, 2.55421013e-01f,
  1.70993119e-01f, -4.20041740e-01f, -8.37063611e-01f, -2.36311585e-01f, -4.69115853e-01f, 2.22591862e-01f, 1.07827201e-01f, 1.52361661e-01f, 1.37804486e-02f, 2.41056737e-02f,
  -1.74706891e-01f, 4.69854437e-02f, 7.40500465e-02f, 1.32873058e-01f, -3.29254031e-01f, -6.31212443e-02f, 1.16068125e-01f, -4.33677621e-02f, -1.22843698e-01f, 3.67835872e-02f,
  1.09574005e-01f, -1.68023303e-01f, 2.26876646e-01f, 1.57717228e-01f, 1.01844072e-02f, 1.43436506e-01f, -1.57753572e-01f, -9.72187296e-02f, -1.64905414e-01f, 1.13825295e-02f,
  -1.17973559e-01f, 1.29512325e-01f, -2.21916869e-01f, -1.85008660e-01f, -3.89147341e-01f, 2.64823675e-01f, 3.49772364e-01f, -2.19760045e-01f, 5.72980829e-02f, 3.97106670e-02f,
  -2.98926771e-01f, 6.21201992e-02f, 2.82366395e-01f, 8.77318308e-02f, 1.98897362e-01f, -1.21283077e-01f, 1.68542936e-01f, 3.55503298e-02f, 3.51814143e-02f, 4.09934342e-01f,
  -1.97689850e-02f, -1.94386035e-01f, 3.98201764e-01f, 8.57791118e-03f, -4.13467556e-01f, 8.72840956e-02f, 4.27046865e-01f, -3.69886130e-01f, -2.93420166e-01f, -1.91571843e-02f,
  -2.54487306e-01f, 2.67793685e-01f, -2.76615947e-01f, 1.00134045e-01f, 2.35220969e-01f, -6.01309419e-01f, 3.78236234e-01f, -4.35118109e-01f, -6.50334954e-01f, 1.11384355e-01f,
  2.28916869e-01f, -1.51803181e-01f, -1.37531295e-01f, -4.57387082e-02f, 7.63262883e-02f, -1.66912690e-01f, -1.41913801e-01f, -1.38082206e-01f, 2.03673020e-01f, -1.01650737e-01f,
  2.25357581e-02f, 2.41464004e-01f, -2.70025611e-01f, 8.77781026e-03f, -7.95306712e-02f, -2.87820041e-01f, 2.37318594e-02f, 2.77297288e-01f, 1.66199710e-02f, -1.21645659e-01f,
  -9.19865817e-02f, -2.43861452e-01f, -1.06208809e-01f, -1.78043876e-04f, 6.80776983e-02f, 1.77532643e-01f, -2.59265095e-01f, 2.27461755e-01f, 3.01437765e-01f, -2.56751031e-01f,
  9.38972458e-02f, 3.34659725e-01f, -1.52354509e-01f, 1.89517900e-01f, -1.03468880e-01f, 1.99677423e-01f, -7.90440571e-03f, -1.02676880e-02f, -9.87552628e-02f, 2.38545403e-01f,
  -9.22980309e-02f, -3.18834811e-01f, -1.89701155e-01f, -1.87417835e-01f, -2.13126883e-01f, -2.33312950e-01f, 2.65711159e-01f, -1.06709942e-01f, 1.57638595e-01f, -3.43277276e-01f,
  1.68427050e-01f, -3.89242731e-02f, -4.10455436e-01f, 1.38472825e-01f, 2.25446209e-01f, -1.20735228e-01f, -4.66950864e-01f, -3.56824517e-01f, -1.27667233e-01f, 2.38927290e-01f,
  -8.41336250e-01f, 4.55952555e-01f, -5.58253825e-01f, -2.35804677e-01f, -4.58872974e-01f, -1.93160787e-01f, -2.51318127e-01f, 9.06359702e-02f, -7.93596506e-02f, -2.97549903e-01f,
  1.52568117e-01f, 2.50445813e-01f, -1.83137387e-01f, 1.98633820e-01f, 1.80564467e-02f, 3.66216972e-02f, -9.70095694e-02f, -1.47277072e-01f, 2.47080311e-01f, 1.92581743e-01f,
  2.69503534e-01f, -1.00495756e-01f, 1.06663123e-01f, 2.44106561e-01f, 1.88206270e-01f, 1.35911703e-01f, 1.74748808e-01f, -1.37135670e-01f, -1.27728149e-01f, -5.16553745e-02f,
  9.29862037e-02f, 1.26275301e-01f, -3.73649687e-01f, 3.79919372e-02f, 2.58303016e-01f, 1.83059320e-01f, -7.74372444e-02f, -4.17122133e-02f, 3.32009405e-01f, -2.92617500e-01f,
  -8.80393237e-02f, -9.94430035e-02f, 2.41048664e-01f, -3.10484290e-01f, -5.29074520e-02f, 2.41806090e-01f, 1.20177671e-01f, -1.78552344e-01f, -3.03934962e-01f, 3.61684263e-01f,
  1.31184459e-01f, 2.99640238e-01f, 3.24540436e-01f, -2.26323158e-01f, -1.91871628e-01f, -5.74485175e-02f, -2.59342752e-02f, -3.59802753e-01f, 3.13798696e-01f, -1.68878958e-01f,
  3.01300079e-01f, -4.60139364e-01f, -1.81407496e-01f, 6.70301616e-02f, -6.33937061e-01f, 1.19246393e-01f, 1.71009392e-01f, -1.26976341e-01f, -3.10176194e-01f, -1.68979958e-01f,
  7.18741566e-02f, -7.87890628e-02f, -9.01705474e-02f, 8.89506042e-02f, 2.51595229e-01f, 1.56726360e-01f, 9.14346427e-02f, 2.05592826e-01f, 8.53455812e-03f, 6.28406182e-02f,
  1.55659169e-01f, -7.21602291e-02f, -1.32870182e-01f, 2.12188408e-01f, 1.65973201e-01f, 1.67507976e-01f, -4.69652265e-02f, 1.06508620e-01f, 3.65199745e-02f, 3.60983163e-02f,
  -7.29836815e-04f, -4.32071798e-02f, 1.71779901e-01f, 1.08859710e-01f, -1.87077507e-01f, 9.15355701e-03f, 2.00313658e-01f, -4.13935095e-01f, -3.46075803e-01f, 3.31095904e-02f,
  2.62974918e-01f, 3.39171708e-01f, -3.35566103e-01f, -2.05599323e-01f, -1.36981830e-01f, -2.28433535e-01f, -1.49554640e-01f, -2.21452579e-01f, 1.84785053e-01f, 3.46578956e-01f,
  -5.44681549e-02f, -6.94419146e-02f, 4.11333174e-01f, 1.61693811e-01f, -1.70926601e-01f, -2.15052232e-01f, 1.81898370e-01f, -3.37908149e-01f, -2.66669750e-01f, 3.26779693e-01f,
  1.25335336e-01f, 2.70153075e-01f, -4.57182199e-01f, -4.62229520e-01f, 7.15021044e-02f, 1.39230758e-01f, -2.50161767e-01f, 1.09956555e-01f, 1.59440324e-01f, 2.57356972e-01f,
  -1.76603645e-02f, -2.51260132e-01f, -7.92264491e-02f, -1.96527660e-01f, 4.40346561e-02f, 2.48295531e-01f, -5.17662093e-02f, -1.30835846e-01f, -2.31381997e-01f, 1.16936557e-01f,
  2.49599904e-01f, 1.18828937e-01f, -2.52769083e-01f, 3.84306237e-02f, -1.67949572e-01f, 1.30352065e-01f, 1.71063647e-01f, -1.38126001e-01f, -1.08342385e-02f, 1.18183173e-01f,
  3.04628909e-02f, -2.00501949e-01f, 1.88313752e-01f, 7.55714625e-02f, 2.50459909e-01f, -2.07204353e-02f, -9.61072072e-02f, 7.91050717e-02f, 4.74527888e-02f, -1.28650993e-01f,
  1.61937565e-01f, -4.26467270e-01f, -2.69494683e-01f, 4.00076747e-01f, -1.89276470e-05f, 1.63258255e-01f, -2.17255950e-01f, -2.10253954e-01f, 1.29202500e-01f, 2.45339721e-01f,
  1.44437596e-01f, -4.25662659e-02f, 2.05343395e-01f, 1.89202458e-01f, -8.04985687e-03f, 3.36912930e-01f, 1.45184726e-01f, 8.49777907e-02f, -2.20301434e-01f, -4.19206955e-02f,
  -2.45413542e-01f, 3.93871456e-01f, 3.58779371e-01f, -2.64959335e-01f, -1.53169117e-03f, 2.57105753e-02f, -3.00209254e-01f, -4.32710171e-01f, -1.09580969e-02f, 8.52701142e-02f,
  3.31141412e-01f, -4.16092724e-01f, 4.11194891e-01f, -5.60170293e-01f, 2.22038895e-01f, 1.00294501e-02f, 2.25346193e-01f, -1.13622710e-01f, 2.05754504e-01f, 1.32777765e-01f,
  -6.91848472e-02f, -1.38466150e-01f, 7.47546786e-03f, 1.44207031e-01f, 9.79604051e-02f, -1.79922163e-01f, -1.25944093e-01f, -2.28150010e-01f, 6.21351264e-02f, -2.55673788e-02f,
  5.84323145e-02f, 1.22506566e-01f, 1.13172480e-03f, 1.36116788e-01f, 9.80192870e-02f, 1.91841573e-01f, 7.74672851e-02f, -1.38121411e-01f, -2.16740221e-01f, 3.78131797e-03f,
  1.58757254e-01f, 2.60943342e-02f, -1.45795926e-01f, -2.42204949e-01f, -8.73698220e-02f, -2.27082461e-01f, 4.94838580e-02f, 2.78382331e-01f, -7.37712756e-02f, -1.46369040e-01f,
  2.00592518e-01f, 2.74618089e-01f, 8.28533098e-02f, -1.52695641e-01f, -1.34505093e-01f, -2.01367840e-01f, 1.13659605e-01f, 2.38123149e-01f, 1.89505547e-01f, 5.56453392e-02f,
  1.17472045e-01f, 1.89293712e-01f, 2.78663695e-01f, 1.89599082e-01f, -2.83278465e-01f, -6.90304786e-02f, 1.53159462e-02f, 2.23948479e-01f, -3.07361901e-01f, -3.41059566e-01f,
  2.78795689e-01f, 3.55220169e-01f, -5.86065315e-02f, 1.94593698e-01f, -2.49301061e-01f, 8.38030875e-02f, -4.69118327e-01f, -5.03747821e-01f, -4.99169856e-01f, 3.82931135e-03f,
  -1.73597485e-01f, -2.79040217e-01f, 1.26597181e-01f, 9.24745128e-02f, 1.52736204e-02f, 2.01717783e-02f, -1.74204737e-01f, 2.43759021e-01f, -1.13918282e-01f, 1.79411039e-01f,
  -2.34756798e-01f, 1.05119787e-01f, 6.66717514e-02f, 7.18331635e-02f, 1.32848984e-02f, 1.15620770e-01f, -5.05339429e-02f, -1.10310558e-02f, -2.78387100e-01f, -1.14505447e-01f,
  9.92188379e-02f, 3.13044451e-02f, -1.73336223e-01f, -1.60612881e-01f, -7.74665317e-03f, -9.48622227e-02f, 8.68071914e-02f, -2.69388199e-01f, -3.77860397e-01f, 2.58788764e-01f,
  2.97925502e-01f, -2.60763586e-01f, 3.79189759e-01f, -6.61984608e-02f, 3.53084177e-01f, 2.64131993e-01f, 3.55025172e-01f, 1.08132213e-01f, 3.28907430e-01f, 3.99035543e-01f,
  -1.86890662e-01f, -2.76721120e-01f, -1.73946425e-01f, -2.21914068e-01f, -3.16280931e-01f, -2.53265887e-01f, 4.27665085e-01f, 2.93549597e-01f, 2.83742189e-01f, 3.44191760e-01f,
  -3.11151296e-01f, 1.34838834e-01f, -3.86619002e-01f, -3.96025002e-01f, -1.75542772e-01f, 3.56279522e-01f, -1.42714724e-01f, -4.02643263e-01f, -4.28065985e-01f, -2.83999115e-01f,
  2.90472150e-01f, -6.43508956e-02f, -5.67558944e-01f, 3.47056866e-01f, -4.51340377e-01f, 3.14049244e-01f, -4.12878813e-03f, -1.27561212e-01f, 1.25034139e-01f, 2.00793482e-02f,
  1.24072894e-01f, -2.66352057e-01f, -2.20478978e-02f, -4.25128862e-02f, -1.27736166e-01f, -2.89475828e-01f, -1.63903043e-01f, -5.69261797e-02f, -6.94841668e-02f, -2.10506707e-01f,
  -2.01669931e-01f, 2.41371542e-02f, 1.56716749e-01f, -1.69281438e-01f, -1.04167983e-01f, -2.11719181e-02f, -2.13965446e-01f, 1.61135435e-01f, 3.50248329e-02f, -1.36925772e-01f,
  -2.78878987e-01f, 1.16327815e-01f, -3.81638885e-01f, 2.92017102e-01f, 3.08850735e-01f, -8.36599618e-02f, 1.48200348e-01f, -1.54340312e-01f, -2.61080921e-01f, -6.14812039e-02f,
  -1.58327430e-01f, 2.81664908e-01f, -1.55830428e-01f, 2.11118236e-02f, -7.10453689e-02f, 1.04454093e-01f, 7.70829767e-02f, 2.15498134e-01f, 2.94675261e-01f, 2.36879766e-01f,
  -1.60856783e-01f, 2.07570598e-01f, -2.43607819e-01f, -3.36528957e-01f, -2.76409447e-01f, -2.28291959e-01f, 2.01486513e-01f, -4.05520767e-01f, 5.26580960e-02f, 1.59826204e-02f,
  3.27489555e-01f, 2.85723895e-01f, -1.65996239e-01f, -5.69973469e-01f, -2.15883121e-01f, -3.76774877e-01f, 8.43381584e-02f, -6.90233558e-02f, 7.14934319e-02f, -2.55360126e-01f,
  2.16064677e-01f, -1.52419209e-01f, -1.07895680e-01f, -1.11938976e-01f, 1.19146146e-01f, 4.54642996e-02f, -1.05787618e-02f, -2.18097474e-02f, 1.25287265e-01f, -8.45882669e-02f,
  8.42093825e-02f, 1.00535154e-01f, -1.29806548e-01f, -1.59115359e-01f, 4.36206870e-02f, -4.43310499e-01f, -7.19643608e-02f, -2.45600402e-01f, -1.51874319e-01f, -1.82042122e-01f,
  1.75940171e-01f, -6.32019863e-02f, -5.52566303e-03f, -1.08498838e-02f, -2.47738108e-01f, 1.08661443e-01f, 2.54538655e-01f, 2.10732967e-01f, 3.99749726e-02f, -2.49725804e-01f,
  -3.79513472e-01f, -1.69196546e-01f, 1.71487063e-01f, 2.07702994e-01f, -8.08390826e-02f, -3.33199382e-01f, -1.60527959e-01f, 1.55204952e-01f, -2.06421137e-01f, -2.83813506e-01f,
  2.44539097e-01f, 3.12721357e-02f, -8.03711191e-02f, -1.57199323e-01f, -5.39917648e-02f, -2.77495105e-03f, 4.95750494e-02f, 3.18744242e-01f, 2.91531444e-01f, 1.23022892e-01f,
  1.37690291e-01f, 1.99208468e-01f, 4.91829254e-02f, 1.54550085e-02f, -4.20126259e-01f, -5.94780326e-01f, -4.45387438e-02f, 7.47355968e-02f, 8.02607611e-02f, -3.81813377e-01f,
  -2.97217697e-01f, 1.63540319e-01f, 2.98223823e-01f, 2.25146815e-01f, -2.83647865e-01f, 3.44681293e-02f, -8.74293596e-02f, 1.86659455e-01f, 4.79733944e-02f, -2.01273918e-01f,
  2.31544062e-01f, 1.82112847e-02f, 1.75390825e-01f, -2.80514136e-02f, 1.29247561e-01f, -1.82863757e-01f, 5.26850820e-02f, -1.12111375e-01f, 4.93845902e-02f, 2.05069184e-01f,
  -1.19634576e-01f, 3.51376808e-03f, 1.39176011e-01f, 1.32460445e-01f, -7.22412542e-02f, 2.34786600e-01f, 7.62667134e-03f, -1.19346194e-02f, 2.38690779e-01f, 1.24787718e-01f,
  1.35007188e-01f, 3.83735478e-01f, 1.45371467e-01f, 1.85957387e-01f, -2.64010698e-01f, -1.94664329e-01f, 2.82991797e-01f, -1.39042616e-01f, -1.46376669e-01f, -2.07858458e-01f,
  -1.77918479e-01f, 4.29647535e-01f, -2.69535482e-01f, 3.31949174e-01f, -1.80486739e-01f, -4.15551700e-02f, -3.76416445e-01f, -3.74181926e-01f, 3.43864828e-01f, -2.89688081e-01f,
  -2.12028742e-01f, 1.87132314e-01f, 4.63560760e-01f, 2.34258175e-01f, 1.93401515e-01f, 1.44780740e-01f, 1.00362457e-01f, -5.78093350e-01f, 4.46320325e-02f, -3.47485036e-01f,
  -1.99158967e-01f, -3.32120694e-02f, 1.87345356e-01f, -3.52564633e-01f, 3.69912326e-01f, -3.43740582e-01f, 1.65310740e-01f, -4.07240301e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  4.61846925e-02f, -7.98099488e-02f, -4.58789952e-02f, -2.16234494e-02f, 4.67385948e-02f, 2.06252839e-02f, -1.44205764e-01f, -1.17544837e-01f, -3.56063619e-02f, 1.07250638e-01f,
  -1.53525956e-02f, -5.45116961e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    