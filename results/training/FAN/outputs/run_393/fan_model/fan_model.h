/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.20642996e-01f, 6.65908083e-02f, -3.90713036e-01f, -1.14544988e-01f, 5.94930425e-02f, 6.81658685e-01f, -3.39773633e-02f, 1.57022700e-01f, -1.04764871e-01f, 2.34478369e-01f,
  7.23450482e-02f, 8.66778120e-02f, -1.19279914e-01f, 2.28746593e-01f, -2.62792557e-02f, -1.06176600e-01f, 2.84625031e-03f, 1.64854497e-01f, -7.47926757e-02f, -5.99608049e-02f,
  -1.49603665e-01f, 1.85964018e-01f, -2.19143614e-01f, 1.27934515e-01f, 3.83071974e-02f, -1.55262435e-02f, -3.39977480e-02f, -3.88707370e-02f, 1.35405064e-01f, 8.45507681e-02f,
  -1.94970399e-01f, -1.60410613e-01f, -4.81595546e-02f, -2.64088400e-02f, 7.24409744e-02f, -2.13003904e-03f, 4.14983593e-02f, -6.23153057e-03f, -2.48195473e-02f, 7.07792714e-02f,
  4.50702794e-02f, 7.23687466e-03f, 5.13047390e-02f, -7.03187138e-02f, 4.35082540e-02f, 7.66849145e-03f, -4.05262373e-02f, -7.74308220e-02f, 1.03507917e-02f, -4.49645370e-02f,
  -1.02104926e-02f, -1.14939846e-02f, -8.95850956e-02f, -5.42458370e-02f, -3.25159580e-02f, 1.10730501e-02f, -7.43193328e-02f, 2.21093800e-02f, 9.77627635e-02f, 1.07052187e-02f,
  6.48870226e-03f, -4.05405052e-02f, -2.39247140e-02f, 2.45505758e-02f, -4.75675166e-02f, 5.46927331e-03f, 1.58589683e-03f, 3.61424014e-02f, -5.30834831e-02f, 6.63767308e-02f,
  -2.86641400e-02f, -2.07058676e-02f, -7.41381617e-03f, 2.29578335e-02f, -4.72885258e-02f, 9.95334424e-03f, 5.33043826e-03f, 5.65569177e-02f, -1.30437256e-03f, 5.03333844e-02f,
  1.36915278e-02f, -1.94364078e-02f, 7.15414137e-02f, -1.19821876e-02f, 5.02611548e-02f, -7.73933753e-02f, 2.84438897e-02f, -4.35058773e-03f, -4.11973409e-02f, 1.58809535e-02f,
  3.68245244e-01f, 2.80439854e-01f, 3.31225954e-02f, -2.05124505e-02f, 2.15527788e-02f, 3.76526006e-02f, -2.59486046e-02f, 6.06848747e-02f, 4.61585373e-02f, -8.03903397e-03f,
  5.34376036e-03f, 1.17908241e-02f, -2.60453741e-03f, 1.99622605e-02f, -5.37927225e-02f, 5.87409455e-03f, 6.27669692e-03f, 1.09694377e-01f, 3.55896279e-02f, 5.75641207e-02f,
  9.59437340e-03f, -3.30825336e-02f, -1.58879552e-02f, 8.75328183e-02f, 6.35307143e-03f, 2.17462834e-02f, 9.86158028e-02f, -4.52840440e-02f, -1.10191070e-02f, -9.30364709e-03f,
  3.40793669e-01f, 4.65069979e-01f, -5.72984554e-02f, 2.13001221e-01f, 2.56344210e-02f, -3.71896654e-01f, 2.58873701e-01f, -2.81339716e-02f, 5.33523619e-01f, 2.10234717e-01f,
  3.20657901e-02f, -3.44413184e-02f, 1.19622163e-01f, 2.06868313e-02f, -4.66718465e-01f, 2.66604781e-01f, -4.81174923e-02f, 4.14991304e-02f, 2.01376557e-01f, -1.62661865e-01f,
  -1.38892920e-03f, -6.16548210e-02f, -1.34045377e-01f, -1.75966680e-01f, -8.76954645e-02f, -1.10421821e-01f, -2.23862544e-01f, -9.17339399e-02f, -1.96505502e-01f, -6.28058985e-02f,
  1.07069820e-01f, 2.82011718e-01f, 2.56685447e-02f, -1.61247905e-02f, -4.08447161e-02f, -6.87565804e-02f, -1.51739374e-01f, -5.32345437e-02f, 4.51497883e-02f, 4.70100269e-02f,
  2.19495259e-02f, 3.62168043e-03f, 6.21920973e-02f, 2.03023106e-02f, 1.02524675e-01f, 8.29990804e-02f, -1.38066029e-02f, 2.33288985e-02f, 3.85576710e-02f, 3.30839567e-02f,
  -2.67670043e-02f, 2.53295656e-02f, -3.25445235e-02f, 2.74495985e-02f, -1.57093704e-02f, 6.50179535e-02f, -5.19018769e-02f, -5.97241186e-02f, 9.11587849e-02f, -2.07775347e-02f,
  1.88175049e-02f, -6.01235852e-02f, -3.41115519e-02f, 1.86376259e-01f, -4.40383814e-02f, -2.86310483e-02f, 7.48237073e-02f, -3.32212402e-03f, -2.01106872e-02f, 8.87300372e-02f,
  2.48261000e-04f, 5.93026802e-02f, 1.12483606e-01f, -4.23288392e-03f, -1.26636052e-03f, 5.00983335e-02f, 8.80810432e-03f, -5.89198098e-02f, 7.28867501e-02f, -7.13183433e-02f,
  7.18199238e-02f, -3.19403186e-02f, -6.47685304e-02f, -4.97409441e-02f, 6.72699064e-02f, -3.01884338e-02f, 3.19371782e-02f, 6.89719245e-02f, -3.87853459e-02f, -6.32546470e-02f,
  -2.02069595e-01f, -2.03061312e-01f, 3.85205224e-02f, 6.77479729e-02f, 3.39370333e-02f, 1.94652211e-02f, 1.32698014e-01f, -8.45278054e-03f, -1.12267427e-01f, -4.26456928e-02f,
  -9.76616740e-02f, -6.89884871e-02f, -1.71919949e-02f, -4.36076485e-02f, -7.81890452e-02f, -2.73439288e-02f, 2.77055707e-02f, -1.82600711e-02f, -6.57801256e-02f, -3.58838029e-02f,
  -5.44719957e-02f, -1.84348933e-02f, 3.75209786e-02f, -3.86903957e-02f, -8.58922824e-02f, -4.61683907e-02f, -7.19044656e-02f, 7.62918638e-03f, -9.21727344e-02f, 6.23219758e-02f,
  -6.83678925e-01f, -1.64985117e-02f, -3.93765867e-02f, -3.73191655e-01f, -3.24930757e-01f, 1.86771467e-01f, -1.27721429e-01f, -6.94254786e-02f, -1.04868770e-01f, 4.41089086e-02f,
  -1.25148995e-02f, -1.54182687e-01f, 3.29275578e-01f, -9.58546028e-02f, -1.20640537e-02f, 4.38219696e-01f, -3.10424209e-01f, -3.02580297e-02f, 6.57764152e-02f, -1.29301757e-01f,
  -2.31295690e-01f, -1.30252331e-01f, -8.03075731e-02f, 8.30287933e-02f, -2.76118070e-01f, -7.38407969e-02f, -2.67449945e-01f, 1.13116644e-01f, -1.30810276e-01f, 8.37796032e-02f,
  1.39750078e-01f, 1.07067831e-01f, -9.77913514e-02f, 5.20378910e-02f, -1.25380710e-01f, -9.41254869e-02f, -1.68783609e-02f, 7.83109069e-02f, -1.50304884e-02f, 3.85172144e-02f,
  -1.25748059e-02f, -4.19892482e-02f, 2.75446102e-03f, 6.18668459e-02f, -1.11487329e-01f, 7.40909250e-03f, -2.10599154e-02f, -6.74772961e-03f, -1.59949958e-02f, -4.28004302e-02f,
  6.76641166e-02f, 3.17299031e-02f, -1.44795939e-01f, 2.87240334e-02f, -7.87721351e-02f, -9.98393074e-03f, 6.33933321e-02f, -2.99922694e-02f, -5.94054535e-02f, -6.33684397e-02f,
  -5.55886179e-02f, -1.85285807e-02f, 5.79766333e-02f, 3.08582801e-02f, 4.33420055e-02f, -3.62264216e-02f, -1.93124712e-02f, -4.19617891e-02f, 4.05427851e-02f, -4.88494858e-02f,
  3.05082127e-02f, 5.62110404e-03f, -8.40323791e-03f, 2.01389436e-02f, -5.98420873e-02f, 1.30254440e-02f, -5.17446399e-02f, 9.35723633e-02f, -4.78318222e-02f, 1.41422320e-02f,
  4.02814522e-02f, -2.03312207e-02f, 9.43158418e-02f, -2.69726906e-02f, 4.28817756e-02f, -2.36627162e-02f, -5.17940596e-02f, -3.98225822e-02f, -8.00085440e-03f, -2.80866362e-02f,
  -4.19051126e-02f, -1.09248608e-01f, 5.04309610e-02f, 3.05957943e-02f, 7.11166933e-02f, -1.91428117e-03f, 1.15575269e-02f, -2.47269031e-02f, 2.60174740e-02f, 1.80004742e-02f,
  -1.00941010e-01f, 2.87804715e-02f, -6.99899942e-02f, -2.45753750e-02f, 1.23134419e-01f, -3.46659347e-02f, -1.86568461e-02f, -4.77201976e-02f, -1.22265197e-01f, -1.40630938e-02f,
  -8.06453675e-02f, 1.60631388e-02f, 2.90172268e-02f, -8.21368992e-02f, -2.21143123e-02f, -3.42124924e-02f, -9.72336382e-02f, 2.29939334e-02f, 1.06260935e-02f, 1.78164477e-03f,
  -2.84889787e-01f, 1.18563332e-01f, 1.13355733e-01f, -2.19395295e-01f, -4.30055469e-01f, 1.46927029e-01f, 4.60574329e-01f, -2.65601307e-01f, -4.64033484e-02f, 4.02719051e-01f,
  -1.76027611e-01f, 3.53322238e-01f, 2.48677377e-02f, -5.31723537e-02f, -2.40639076e-01f, -1.00867808e-01f, -1.53360307e-01f, -5.60402349e-02f, -1.35728652e-02f, -2.11463794e-01f,
  -2.58912325e-01f, -4.00053710e-01f, -1.99598730e-01f, -3.13839227e-01f, -1.60703436e-01f, -2.55399197e-02f, -1.44759983e-01f, 9.55262110e-02f, 2.05353498e-02f, 1.66359618e-02f,
  -4.99782562e-02f, -1.34991765e-01f, 1.39449865e-01f, 8.62055272e-02f, -5.94406947e-02f, 6.82442412e-02f, 1.65495813e-01f, 1.26771554e-01f, -2.46905703e-02f, 2.08809655e-02f,
  8.42395425e-02f, -1.02788366e-01f, -2.69056354e-02f, 6.00717962e-02f, 2.24125497e-02f, 4.70093787e-02f, -3.42092030e-02f, -3.41436490e-02f, -3.52697596e-02f, 1.80268493e-02f,
  -3.29867527e-02f, 2.12654881e-02f, -1.22499159e-02f, 5.70367984e-02f, -3.33750583e-02f, -1.46178342e-02f, 4.26000878e-02f, 6.94684908e-02f, 1.14494087e-02f, 3.83917056e-02f,
  7.09000677e-02f, 9.66556817e-02f, 2.87139770e-02f, -4.79254834e-02f, 1.99413430e-02f, -5.94844017e-03f, -1.91139467e-02f, -2.26920447e-03f, 2.38975547e-02f, 1.74584258e-02f,
  -3.40256803e-02f, 4.20027301e-02f, -3.70072499e-02f, 3.70476134e-02f, 5.42860031e-02f, 5.26675470e-02f, -2.22683214e-02f, -1.93528291e-02f, -5.33720851e-02f, 1.80684011e-02f,
  6.87852036e-03f, -3.10447384e-02f, 2.39857696e-02f, 3.12906727e-02f, 2.87031569e-03f, 5.45158237e-02f, -1.26471920e-02f, 3.16594238e-03f, 3.90204042e-02f, -4.13107425e-02f,
  -5.88595727e-03f, -1.54555291e-02f, -4.19617258e-02f, -5.58670945e-02f, 6.17299117e-02f, 5.38637908e-03f, -6.40992001e-02f, -1.43754840e-01f, 2.61192024e-02f, -6.16512299e-02f,
  -9.57949494e-04f, 6.83769807e-02f, 2.96047013e-02f, -7.25769848e-02f, -6.03414625e-02f, -2.91240830e-02f, 1.00920096e-01f, 4.88558523e-02f, -6.55755401e-04f, -3.12328152e-02f,
  1.82369072e-02f, -5.37517890e-02f, 7.39733726e-02f, -5.20409681e-02f, -2.48960387e-02f, -5.22390800e-03f, -3.07345502e-02f, 1.96279418e-02f, -8.34112167e-02f, 4.60918471e-02f,
  -6.38380408e-01f, -6.30808294e-01f, -8.13947842e-02f, -5.04340053e-01f, -2.79753543e-02f, -5.19792855e-01f, -1.13583013e-01f, -2.45877892e-01f, -1.73806161e-01f, -1.83215335e-01f,
  2.05799211e-02f, -1.32983238e-01f, 1.01269549e-02f, -3.91052991e-01f, 5.14372960e-02f, -1.07527427e-01f, -3.61579984e-01f, -2.12104425e-01f, -3.20009850e-02f, -2.60615557e-01f,
  -8.12388211e-02f, -3.11876625e-01f, 8.08274522e-02f, -6.03928007e-02f, -9.99364182e-02f, -1.19940676e-01f, 7.68741444e-02f, 1.36725143e-01f, -9.57666617e-03f, -5.50057099e-04f,
  9.44972858e-02f, -3.43591385e-02f, -4.84450720e-02f, -3.58414873e-02f, -5.65112308e-02f, 9.19328723e-03f, -1.48292119e-02f, 1.60771042e-01f, 7.32036680e-02f, -3.59016955e-02f,
  1.61713585e-02f, 2.04565339e-02f, -3.76350693e-02f, -2.75218803e-02f, -7.50011653e-02f, -7.38566159e-04f, -5.98587561e-03f, -1.01525430e-02f, -6.58707647e-03f, 6.14918303e-03f,
  -2.61676162e-02f, -2.32860427e-02f, -6.66769519e-02f, 4.90317878e-04f, -1.49006648e-02f, -1.59398187e-02f, -7.94722363e-02f, 4.44568768e-02f, -4.54435833e-02f, -9.99188274e-02f,
  -5.12232371e-02f, -3.76635082e-02f, -3.45121250e-02f, 2.47367211e-02f, -9.82999206e-02f, 6.21908233e-02f, -7.78006390e-02f, 7.44324625e-02f, -1.41336285e-02f, -1.98140666e-02f,
  -2.69902982e-02f, -1.52635118e-02f, -1.41724097e-02f, 2.19855784e-03f, -9.83934477e-03f, -4.96648904e-03f, 7.89689720e-02f, -1.19258743e-02f, -1.08309952e-03f, -1.81911327e-02f,
  2.76630148e-02f, -5.32978913e-03f, -9.90477391e-03f, 2.66704001e-02f, 3.87361227e-03f, 2.85896473e-02f, -7.27168769e-02f, -3.11834197e-02f, 1.79344183e-03f, 6.04967996e-02f,
  -1.84082180e-01f, -2.07321197e-01f, 5.43467924e-02f, 3.22331302e-02f, 3.63350660e-02f, -1.39336446e-02f, 1.07459980e-03f, -1.19286098e-01f, -7.30384663e-02f, -3.66364606e-03f,
  -3.58081646e-02f, -4.24587838e-02f, -3.11636534e-02f, 2.75390614e-02f, 6.84211329e-02f, -9.40436497e-02f, -2.21666065e-03f, 1.84109304e-02f, -8.44245870e-03f, -2.10653897e-02f,
  1.92906931e-02f, 1.48882763e-02f, 4.55390587e-02f, -3.55825573e-02f, -4.60262559e-02f, 1.72789097e-02f, -1.59203000e-02f, -2.46090395e-03f, 6.07071109e-02f, 5.91393188e-02f,
  2.07640901e-01f, 2.12144196e-01f, 2.23444670e-01f, 2.11038589e-01f, -9.15498883e-02f, -3.07861835e-01f, -3.55470538e-01f, 1.02372393e-01f, 4.09331083e-01f, -1.84974432e-01f,
  -1.88481390e-01f, 3.05422068e-01f, -5.55324741e-02f, -3.29389274e-01f, 4.42463811e-03f, -1.68995619e-01f, -1.66226879e-01f, -2.17115153e-02f, 1.56087711e-01f, 1.39118046e-01f,
  1.56778581e-02f, -1.18259557e-01f, -1.38155967e-01f, 6.87190890e-02f, -8.06876495e-02f, 1.58520639e-01f, -3.99778448e-02f, -4.77623492e-02f, -5.79405650e-02f, -7.91000649e-02f,
  -2.06010208e-01f, 3.75995003e-02f, 4.38289307e-02f, 2.30684131e-02f, -7.76596414e-03f, -6.12963103e-02f, -1.25928521e-01f, -5.98758757e-02f, -2.52772328e-02f, 2.00539511e-02f,
  4.89460640e-02f, -2.74365675e-02f, 5.94120361e-02f, 8.38346314e-03f, -1.03656255e-01f, 2.13847496e-02f, 1.05042465e-01f, -2.58071031e-02f, 3.00894845e-02f, -5.25677279e-02f,
  4.99775633e-02f, -2.75849272e-02f, -6.42081127e-02f, -3.92069481e-02f, 5.02537936e-02f, 1.89058948e-02f, 1.13696260e-02f, -2.42871419e-02f, 4.66105379e-02f, 7.56619722e-02f,
  5.45645989e-02f, 7.63857691e-03f, -5.66518568e-02f, -1.11429594e-01f, -2.84875394e-03f, 3.04598026e-02f, -2.76413802e-02f, 6.33618562e-03f, 3.45024280e-02f, -8.04819074e-03f,
  -3.54947858e-02f, -4.27652672e-02f, -2.58571887e-03f, -2.49048322e-02f, 5.05611077e-02f, 2.29251143e-02f, 2.11930065e-03f, -4.91618030e-02f, -7.98770227e-03f, 2.97163036e-02f,
  6.92714518e-03f, -3.17709409e-02f, 6.06530048e-02f, -5.12249172e-02f, -2.58875843e-02f, 5.50095108e-04f, -6.17068224e-02f, -2.00966913e-02f, 3.43159437e-02f, -1.04357302e-02f,
  1.03654422e-01f, 2.61949033e-01f, -1.27090383e-02f, 6.59376103e-03f, 3.17622870e-02f, -2.84321848e-02f, 1.39707383e-02f, 8.20054859e-02f, 1.25270590e-01f, -1.12310825e-02f,
  -6.91313669e-02f, 3.78422148e-04f, -1.88349411e-02f, -8.70652348e-02f, 1.18351929e-01f, -2.25300267e-02f, -6.08726740e-02f, 5.06639592e-02f, 4.00280096e-02f, 7.57731572e-02f,
  3.11910007e-02f, 1.54859060e-02f, 9.17544439e-02f, 8.87173635e-04f, -6.08371831e-02f, -2.25930698e-02f, 6.88863695e-02f, 3.48785706e-03f, -1.85576119e-02f, 4.99236993e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.62732387e+00f, 9.34237421e-01f, 3.87153447e-01f, -1.29310167e+00f, -4.99202721e-02f, -5.30111670e-01f, -1.29358661e+00f, 8.82183164e-02f, -3.50973159e-01f, 1.86803386e-01f,
  -5.74090838e-01f, 3.22514832e-01f, -4.08137888e-02f, -4.52111810e-01f, -1.21517098e+00f, -1.26321003e-01f, -1.01819217e+00f, -3.96134764e-01f, -1.06061911e-02f, -2.98459440e-01f,
  -5.88665843e-01f, -7.66164064e-01f, -4.41503078e-02f, 4.13947016e-01f, 8.36263970e-02f, 1.90048620e-01f, -3.76898229e-01f, 2.30400324e-01f, -2.13371038e-01f, -8.14720690e-02f,
  -2.41158754e-02f, -1.94067284e-02f, 3.85287344e-01f, 5.08305468e-02f, -1.11384451e-01f, -9.04956833e-02f, -1.28393203e-01f, -6.79450631e-02f, 9.14092138e-02f, 2.02112079e-01f,
  1.25709504e-01f, 2.35352010e-01f, -1.47811562e-01f, 1.81352809e-01f, 3.98274846e-02f, 2.07492888e-01f, 2.24715531e-01f, 2.57909209e-01f, 3.26103598e-01f, 3.15204799e-01f,
  1.48612767e-01f, 2.04303831e-01f, 5.10995500e-02f, -9.94126797e-02f, 5.53705543e-02f, 4.13851142e-02f, -1.03956506e-01f, 1.92057446e-01f, 2.23129839e-01f, -2.88041383e-01f,
  1.50670130e-02f, -1.40711665e-01f, -1.05704039e-01f, 1.27904654e-01f, -2.51892626e-01f, 8.36243331e-02f, -1.69856578e-01f, -1.86632663e-01f, -4.40837592e-02f, -1.26660481e-01f,
  -2.68433183e-01f, -2.96368003e-02f, -2.83523262e-01f, 4.50508967e-02f, -1.83454484e-01f, -1.34316340e-01f, -1.70871258e-01f, 1.85943134e-02f, -8.72355774e-02f, -1.77744642e-01f,
  -5.28553277e-02f, -1.20066464e-01f, -4.75900657e-02f, -7.66285360e-02f, -1.81739554e-01f, 8.30690470e-03f, 8.10559392e-02f, 2.82049417e-01f, -9.26012080e-03f, -1.69314817e-01f,
  -5.83926082e-01f, -1.23073030e+00f, -3.11840236e-01f, -1.04077123e-01f, -5.01293465e-02f, 4.05898243e-02f, -1.34194449e-01f, 1.03645911e-02f, -1.58179685e-01f, -2.67023742e-01f,
  6.14126585e-02f, -2.94269741e-01f, -1.77729547e-01f, -6.67838007e-02f, -2.80430347e-01f, -2.56012380e-01f, -2.53812134e-01f, -1.46700770e-01f, -2.96607375e-01f, -6.62315711e-02f,
  4.87878025e-02f, -1.08293951e-01f, -8.37092772e-02f, 3.69540788e-02f, -8.31934959e-02f, -1.65477350e-01f, -6.75028786e-02f, -6.75306469e-02f, -7.79607445e-02f, 1.00173742e-01f,
  8.77545536e-01f, -4.18936014e-01f, 1.06842506e+00f, 2.96727598e-01f, 7.29605734e-01f, 5.31070828e-01f, 8.58933151e-01f, 5.00771739e-02f, 9.81394291e-01f, -1.01816380e+00f,
  -6.45324111e-01f, -2.88803466e-02f, 7.68595397e-01f, -6.44973278e-01f, 1.21895337e+00f, 3.72432619e-01f, -2.84130394e-01f, -3.09610188e-01f, 3.51842016e-01f, 5.13914227e-02f,
  1.47766713e-03f, -6.63960993e-01f, 2.46984363e-01f, -9.08188105e-01f, -1.11506239e-01f, -4.88242656e-01f, -7.68754780e-01f, 3.11112285e-01f, -1.25824928e+00f, -1.70728877e-01f,
  7.15183094e-03f, -8.21057484e-02f, -2.52997488e-01f, -1.00063801e-01f, 9.80158448e-02f, 3.38042824e-04f, 5.37633821e-02f, 4.01502755e-03f, 2.44317055e-01f, 1.59144282e-01f,
  -1.74164434e-03f, 2.05509886e-02f, -1.16348617e-01f, 4.80852537e-02f, 2.19621398e-02f, -1.56493545e-01f, 1.47333562e-01f, -9.82721895e-02f, 8.72875080e-02f, 2.31274962e-01f,
  3.00235242e-01f, 6.66897073e-02f, 1.96656361e-01f, -1.94966450e-01f, -9.03229415e-02f, -1.96800664e-01f, 1.45324811e-01f, 2.37911925e-01f, 1.40633821e-01f, -1.68606397e-02f,
  -1.92695275e-01f, 1.01535097e-01f, -3.06293610e-02f, -2.14572743e-01f, -1.98266804e-02f, -2.08833441e-01f, 3.57171595e-02f, -5.94290048e-02f, 1.94189653e-01f, 1.47548452e-01f,
  -3.01961359e-02f, -2.69716214e-02f, 4.33787815e-02f, 1.78071797e-01f, -1.52450427e-01f, -2.89985120e-01f, 1.26409873e-01f, -1.51292101e-01f, -7.38993511e-02f, -8.10059085e-02f,
  2.75499616e-02f, 8.49956945e-02f, -3.42350379e-02f, 7.84505531e-02f, -1.01658456e-01f, 2.58704603e-01f, -2.45272413e-01f, 2.69530594e-01f, 1.46431765e-02f, -7.46166706e-03f,
  3.62402163e-02f, -7.43912876e-01f, -2.80828238e-01f, -1.67508081e-01f, -1.44321740e-01f, -5.22588968e-01f, 8.86939466e-02f, -1.85155887e-02f, -4.80918512e-02f, -3.92139405e-02f,
  -2.13302135e-01f, -1.10060453e-01f, -3.46649326e-02f, -1.17136929e-02f, -7.05989450e-02f, 1.22069620e-01f, -2.24521399e-01f, -3.50634396e-01f, -1.30475014e-01f, -2.18870759e-01f,
  -2.26978604e-02f, -5.53035885e-02f, 8.31065178e-02f, -2.38806084e-01f, -1.76856071e-01f, -1.36974722e-01f, 8.02624449e-02f, -6.74271211e-03f, 1.86398309e-02f, 3.49916182e-02f,
  -1.54726589e+00f, 8.59391153e-01f, -5.21782875e-01f, 2.37267494e-01f, 1.05460338e-01f, -1.32180142e+00f, -3.01277488e-02f, 4.42145050e-01f, -4.56274539e-01f, 7.31402576e-01f,
  1.73828259e-01f, -6.93032503e-01f, 1.05365849e+00f, 6.29641116e-02f, -9.01669860e-01f, 8.68074372e-02f, 1.71683654e-02f, -3.08638483e-01f, -1.84077010e-01f, 4.19233263e-01f,
  -3.07323277e-01f, 3.13484132e-01f, -2.12665666e-02f, 5.63361824e-01f, -8.90473649e-02f, 1.74480021e-01f, 1.10783601e+00f, 3.47325593e-01f, 1.93596222e-02f, -4.65841591e-01f,
  -3.55903327e-01f, -8.36672820e-03f, 4.72207554e-02f, -1.30988136e-01f, -5.59698716e-02f, -1.37433708e-02f, 1.14809601e-02f, -2.37964347e-01f, -1.53168723e-01f, 8.83734599e-03f,
  5.78937270e-02f, -2.01364458e-01f, -1.82626933e-01f, 8.00851658e-02f, -3.52567017e-01f, -7.37563819e-02f, -1.06674522e-01f, -6.43507689e-02f, -4.76657338e-02f, -1.65653214e-01f,
  -1.18910909e-01f, -4.85062674e-02f, 1.37605935e-01f, -6.81768581e-02f, 2.03365982e-02f, -7.08865374e-02f, -3.17755826e-02f, 6.78570941e-02f, -3.86537635e-03f, -1.59591928e-01f,
  -1.66390449e-01f, 1.80155914e-02f, 1.95286259e-01f, -5.06528579e-02f, -1.45444185e-01f, 4.08296213e-02f, 1.56471357e-02f, -3.38311791e-02f, -8.63141939e-02f, 1.75980970e-01f,
  1.35042109e-02f, -7.33517557e-02f, 4.14719023e-02f, 4.27583419e-02f, -7.25891441e-02f, -4.50957231e-02f, -5.42450137e-03f, 1.19090550e-01f, -1.49543449e-01f, -1.57006592e-01f,
  1.98545903e-01f, 5.59982238e-03f, 1.17110409e-01f, 1.12688160e-02f, -9.08196438e-03f, -2.36275978e-02f, 1.03071138e-01f, 6.33436665e-02f, 1.77962601e-01f, -5.34474216e-02f,
  3.30528170e-01f, 7.43322074e-01f, -1.67606771e-01f, -1.90493524e-01f, -2.31157197e-03f, -2.07309768e-01f, -8.64295065e-02f, -1.33296058e-01f, 1.10397890e-01f, -5.92005551e-02f,
  7.80257359e-02f, 5.44082522e-02f, 6.78834692e-02f, -9.27058980e-02f, 1.12806939e-01f, 3.96254808e-02f, 2.07822710e-01f, -3.74652036e-02f, 2.29872048e-01f, 2.01266091e-02f,
  2.66073555e-01f, 1.41850347e-02f, -1.67534083e-01f, 1.01756332e-02f, 2.56282091e-02f, 1.04170293e-01f, 6.13306127e-02f, -2.40125577e-03f, -4.46879342e-02f, 9.39532742e-03f,
  1.80998340e-01f, 3.94328833e-01f, -5.50651848e-01f, -2.86345869e-01f, -7.13941276e-01f, -8.75012204e-03f, -3.70167196e-01f, -5.17744005e-01f, -2.59978265e-01f, 5.49084783e-01f,
  3.84598896e-02f, -1.63091570e-01f, 1.08837903e+00f, -1.07901998e-01f, 6.31536365e-01f, 1.42334282e+00f, 4.77702945e-01f, 1.48207426e-01f, 1.16402535e-02f, -9.97582227e-02f,
  2.05168679e-01f, -2.45260466e-02f, 5.20056188e-01f, -2.63659060e-01f, -3.28251958e-01f, -8.84176970e-01f, 3.47686052e-01f, -2.75459021e-01f, -2.47445002e-01f, -1.14127986e-01f,
  5.29337078e-02f, -1.33526772e-01f, -4.31238949e-01f, -1.47136644e-01f, 7.18314154e-03f, -3.74330431e-02f, -2.47906387e-01f, -1.25625134e-01f, -3.72678667e-01f, 4.61967662e-02f,
  7.47919902e-02f, -5.35453819e-02f, -1.04590349e-01f, 6.20729104e-02f, -3.92871648e-01f, -3.95283461e-01f, -1.86762065e-01f, -9.11781415e-02f, -1.07699350e-01f, -9.06472746e-03f,
  -1.27661139e-01f, -1.47833318e-01f, -1.92656785e-01f, 9.14229453e-02f, -1.92554265e-01f, -2.76630893e-02f, 2.29369074e-01f, 6.07969500e-02f, -2.16103628e-01f, 2.23811623e-02f,
  7.60048404e-02f, -2.17572954e-02f, 1.56413496e-01f, 1.56592019e-02f, -1.10227205e-01f, 3.68205197e-02f, 3.47012724e-03f, 9.46551561e-02f, -8.74703079e-02f, 1.54427901e-01f,
  -9.46232975e-02f, -1.86312646e-01f, -5.50547475e-03f, -2.19226759e-02f, 1.70984343e-01f, -1.98073201e-02f, 1.33310452e-01f, -2.03402676e-02f, -1.44756928e-01f, -9.79460254e-02f,
  1.59526274e-01f, -2.31191330e-02f, -7.18561187e-02f, -5.31562371e-04f, -1.25328526e-01f, 3.09998468e-02f, 2.75614019e-02f, 1.62200883e-01f, -4.58310731e-02f, 1.36898637e-01f,
  1.31071910e-01f, 2.52254367e-01f, -4.60246317e-02f, -3.11252236e-01f, -2.34714057e-02f, -5.66181615e-02f, 2.97821105e-01f, 5.78930974e-02f, 2.24551335e-01f, 2.08350256e-01f,
  6.26947284e-02f, -2.90195853e-01f, -4.59146453e-03f, -1.77626133e-01f, 1.25716031e-01f, 2.96552956e-01f, 1.74053028e-01f, -6.15958609e-02f, 8.31381902e-02f, -3.47622968e-02f,
  3.34416449e-01f, 8.96329582e-02f, 1.61603555e-01f, -8.03175122e-02f, -1.54478324e-03f, 1.46017134e-01f, -3.25105071e-01f, -1.33327886e-01f, 9.69253480e-02f, -2.70098783e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.60771024e+00f, 1.13626194e+00f, 7.21285045e-01f, 1.82957125e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  2.16822736e-02f, 5.04061818e-01f, -1.04650557e+00f, 3.64333034e-01f, 5.07791221e-01f, -2.35753798e+00f, 1.11811411e+00f, 1.34737778e+00f, 1.75528431e+00f, 2.03096128e+00f,
  -7.85211802e-01f, -1.50417757e+00f, -8.90640914e-01f, -1.57341135e+00f, 4.38938022e-01f, 7.63836801e-01f, -2.28548336e+00f, 1.03943169e+00f, 1.27769470e+00f, 1.02021806e-01f,
  -2.29041409e+00f, 2.87945449e-01f, 1.33079633e-01f, -1.04345596e+00f, -2.00819945e+00f, -1.92092633e+00f, -1.06481111e+00f, -2.31563115e+00f, -2.10290670e+00f, -1.29857457e+00f,
  -4.31414872e-01f, 7.85902798e-01f, 2.18320704e+00f, -2.13782120e+00f, -7.93113470e-01f, -1.71051669e+00f, 2.40888858e+00f, 1.16017187e+00f, 1.98043776e+00f, -1.38886392e+00f,
  -1.40956604e+00f, -1.70116723e+00f, -6.49666369e-01f, -1.82074690e+00f, -1.32760465e+00f, -1.27858126e+00f, -1.27378809e+00f, -8.89561236e-01f, -1.51691988e-01f, -4.75308627e-01f,
  -1.38458896e+00f, -6.63161516e-01f, -9.14612710e-01f, -2.60013938e-01f, -6.23892307e-01f, 2.59199452e+00f, 1.84298623e+00f, -5.94430149e-01f, 1.59470403e+00f, 9.17671323e-01f,
  7.36012936e-01f, -1.74607873e+00f, 8.10887337e-01f, -1.18542099e+00f, 1.04358733e+00f, 3.20193827e-01f, -1.00491488e+00f, 2.23300919e-01f, 1.08593678e+00f, 9.38910842e-01f,
  -9.97438133e-02f, -7.82554924e-01f, 2.46164489e+00f, -1.06243193e+00f, 1.37110341e+00f, -8.00071895e-01f, 7.08880961e-01f, 5.84535189e-02f, -1.06149054e+00f, -6.41689226e-02f,
  1.17942059e+00f, -4.15053777e-02f, 6.16002679e-01f, 1.01559258e+00f, -1.41323256e+00f, 1.49817502e+00f, 2.59147406e+00f, 1.25102830e+00f, 1.02746999e+00f, 2.01726317e+00f,
  -1.91752732e+00f, 2.39067197e+00f, -1.79891813e+00f, 3.97896022e-01f, -1.29506135e+00f, 3.65124285e-01f, 4.26101804e-01f, 2.87145257e-01f, -1.47674131e+00f, -2.05281377e-01f,
  7.61836886e-01f, 3.96199226e-01f, -2.11640692e+00f, 2.26518846e+00f, -1.31796908e+00f, -1.91113281e+00f, -1.26627076e+00f, 5.79919219e-01f, -1.87695324e+00f, 9.85640645e-01f,
  -1.06950760e+00f, -1.16289818e+00f, -2.15208673e+00f, -8.73059809e-01f, -5.07740140e-01f, 1.36325821e-01f, -2.13105059e+00f, -7.24158108e-01f, -1.38842726e+00f, 1.00329518e+00f,
  2.80813932e-01f, -1.48869336e-01f, 3.81404281e-01f, 1.84266353e+00f, 5.60170591e-01f, -2.56876737e-01f, -1.50347888e+00f, 8.71072888e-01f, 3.12182277e-01f, -2.60371208e-01f,
  -1.24610674e+00f, -1.52881169e+00f, 2.84189224e-01f, -1.25821364e+00f, -1.94776237e+00f, -6.84352517e-01f, -1.35491776e+00f, -5.58907151e-01f, -8.32960486e-01f, 2.29583526e+00f,
  -1.16236436e+00f, -1.30683351e+00f, 1.16329455e+00f, 2.09975153e-01f, -5.35759255e-02f, 7.12315977e-01f, 1.51872075e+00f, 5.59343696e-01f, 5.27779579e-01f, -8.96839499e-01f,
  -1.26482105e+00f, -2.17507148e+00f, 6.35399699e-01f, 1.41805542e+00f, 2.68885899e+00f, -1.34331477e+00f, -1.92635655e+00f, 9.83186305e-01f, -1.52045882e+00f, -2.12972045e-01f,
  -1.20450780e-01f, 2.49028891e-01f, 1.41178942e+00f, 1.63255918e+00f, 1.33988947e-01f, 4.26963240e-01f, 1.50803745e+00f, -2.45221853e+00f, -1.07805061e+00f, 1.64569342e+00f,
  1.74327695e+00f, 2.19573170e-01f, 1.05125137e-01f, -1.29637063e+00f, 8.91936123e-01f, -1.25018346e+00f, 7.22072005e-01f, 1.81173041e-01f, 8.36328089e-01f, -4.27915096e-01f,
  2.64265597e-01f, -1.39419138e+00f, -1.58900893e+00f, 9.37863171e-01f, -2.11204243e+00f, 1.66368163e+00f, -2.31445289e+00f, 1.15004742e+00f, 1.15044069e+00f, -7.37569511e-01f,
  -1.30837250e+00f, -2.22291207e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -8.16195667e-01f, 5.29763222e-01f, 1.53685427e+00f, -6.48012757e-01f, -1.36343211e-01f, 7.00056851e-01f, -4.16118465e-02f, -7.72416532e-01f, -7.03723207e-02f, -2.55002975e-01f,
  -1.73060134e-01f, 3.26204628e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    