/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.33042198e-02f, 2.03530937e-02f, -5.91983795e-02f, 2.04252198e-01f, -1.00935981e-01f, 1.62529588e-01f, 1.96900025e-01f, -1.47823960e-01f, -5.34599088e-02f, 9.34486836e-02f,
  7.98902139e-02f, -3.64948362e-02f, -1.53427664e-02f, 1.09011754e-01f, 2.06059575e-01f, 4.26365323e-02f, 1.25332445e-01f, 1.50839508e-01f, -8.20145663e-03f, -4.98805046e-02f,
  -1.26274135e-02f, 7.93249905e-02f, -7.54016340e-02f, -5.40136956e-02f, -5.91300577e-02f, -5.56714125e-02f, -3.77269927e-03f, -6.84034973e-02f, -7.57052051e-03f, 2.38358248e-02f,
  -4.00092173e-03f, 1.18580889e-02f, -1.57924052e-02f, -2.23367941e-02f, -1.36179803e-02f, 2.80513354e-02f, -2.34343112e-02f, -4.88332286e-02f, 4.01637033e-02f, 1.51848989e-02f,
  6.79169223e-02f, -4.62509133e-03f, 1.69734028e-03f, -7.48085827e-02f, -1.09057818e-02f, 1.09594613e-02f, -1.44156758e-02f, -3.50441318e-03f, -4.01489735e-02f, 1.19087836e-02f,
  3.88788059e-02f, -6.45694137e-03f, -2.18989868e-02f, -5.50920144e-03f, -8.39320421e-02f, -3.71121466e-02f, -4.99576377e-03f, 7.29485080e-02f, 2.03637592e-02f, -3.79806897e-03f,
  2.74076518e-02f, 2.92588305e-02f, 2.28454378e-02f, -5.40169142e-02f, -4.83673923e-02f, -3.70517955e-03f, 3.45592350e-02f, -3.31226364e-02f, -2.60842741e-02f, 4.21113195e-03f,
  -3.00613488e-03f, -3.55821848e-02f, 2.18846798e-02f, 5.53574897e-02f, 3.12019847e-02f, 6.09799346e-04f, -1.63557613e-03f, 4.42242511e-02f, -6.37267381e-02f, -3.29693705e-02f,
  2.10075863e-02f, -5.28866500e-02f, 4.09918949e-02f, -3.98432314e-02f, -2.04491280e-02f, -6.30991906e-02f, 5.01691028e-02f, -1.73245072e-02f, -7.24265873e-02f, 6.04395568e-02f,
  1.57047976e-02f, 2.65968069e-02f, 5.46630844e-02f, -2.87452154e-02f, 5.81814907e-02f, 2.07863990e-02f, 6.88890442e-02f, 5.93241826e-02f, 1.78273302e-02f, -9.96674784e-03f,
  -6.88145123e-03f, 7.57334381e-02f, 3.21399979e-02f, -3.19591202e-02f, 7.30836093e-02f, -6.39591366e-02f, -1.74760967e-02f, 3.28910910e-02f, 7.25349262e-02f, -9.19341370e-02f,
  -7.57766217e-02f, -9.51472018e-03f, 6.97758645e-02f, 5.18753082e-02f, 5.91014512e-02f, 9.11671482e-03f, -8.61856621e-03f, -5.77834807e-02f, -5.10711037e-02f, 5.73023409e-03f,
  -3.35793853e-01f, 1.53893471e-01f, 1.57856077e-01f, -1.80470392e-01f, -1.36343837e-01f, -6.80283383e-02f, -7.97037780e-02f, -6.36432916e-02f, -1.43244520e-01f, -7.73757473e-02f,
  -7.09838569e-02f, 1.19752340e-01f, 1.31036893e-01f, -2.07679451e-01f, -2.14211538e-01f, 3.60995494e-02f, -2.91458815e-01f, -6.36107773e-02f, 8.36530104e-02f, -7.00988695e-02f,
  -4.75997105e-03f, -1.46371812e-01f, 1.53440192e-01f, -2.31359005e-02f, -1.11013591e-01f, 6.87974989e-02f, -1.04098678e-01f, 1.33535907e-01f, 3.33717689e-02f, -1.55408783e-02f,
  3.24691422e-02f, 6.40088832e-03f, -3.19507928e-03f, 1.21466011e-01f, -2.19753999e-02f, -4.03597988e-02f, 2.28079520e-02f, 3.16210650e-02f, 1.42094651e-02f, 5.98837854e-03f,
  2.48651300e-02f, -2.25724839e-02f, 2.55572163e-02f, 1.11931330e-02f, 3.34710814e-02f, 8.21645558e-02f, 4.83431146e-02f, 2.98865326e-02f, 1.69962738e-02f, 5.14837541e-02f,
  9.78794098e-02f, 7.88493678e-02f, -4.35624644e-02f, 1.41025456e-02f, 2.55871341e-02f, -4.85724583e-02f, 6.65271431e-02f, 3.62874195e-02f, 7.86432531e-03f, -3.42985764e-02f,
  -3.13658081e-02f, 2.36528106e-02f, -3.29112820e-02f, 1.28731309e-02f, 9.68864281e-03f, -3.37641612e-02f, -4.36018337e-04f, -4.04716097e-02f, 8.43086094e-03f, 4.65182886e-02f,
  4.70394734e-04f, 4.50964435e-04f, -2.39224592e-03f, -5.32796383e-02f, -9.31338873e-03f, -1.09659927e-02f, -9.29530803e-03f, 3.61802876e-02f, -1.57543004e-03f, 2.09763758e-02f,
  3.98340111e-04f, 6.06692210e-03f, 2.27841139e-02f, 3.71712679e-03f, -2.52249371e-02f, 1.34567255e-02f, -2.61395350e-02f, 6.12845682e-02f, -2.72481404e-02f, 8.25958047e-03f,
  -3.28944735e-02f, -1.27797797e-01f, -7.69158453e-02f, -5.44140525e-02f, -3.24913077e-02f, 2.58812681e-02f, 2.16009654e-03f, -1.12007679e-02f, -1.69425849e-02f, 3.42937782e-02f,
  2.64788456e-02f, 3.03844009e-02f, -5.58425561e-02f, 2.82411873e-02f, 1.63306408e-02f, -5.65005615e-02f, -1.04486130e-01f, -3.21534611e-02f, -2.82402849e-03f, -1.70071740e-02f,
  2.85911206e-02f, -3.96291241e-02f, 2.76678577e-02f, 6.00142172e-03f, -6.20922260e-03f, 2.02922542e-02f, -3.64864357e-02f, 6.36834577e-02f, 7.43246498e-03f, 7.14264959e-02f,
  -3.18789393e-01f, -8.14821757e-03f, -1.54907806e-02f, -2.65048087e-01f, 3.96648087e-02f, -1.62409827e-01f, -2.19395757e-01f, 1.77100506e-02f, -8.50196481e-02f, 5.39106354e-02f,
  -1.30340979e-01f, -7.35132992e-02f, 1.45872263e-02f, -2.26092160e-01f, -2.32572868e-01f, 1.47946589e-02f, -2.79783934e-01f, -1.15127005e-01f, 7.23457336e-02f, -5.72112054e-02f,
  5.39975949e-02f, -1.46483779e-01f, -7.63797760e-02f, 1.84152320e-01f, -1.14137262e-01f, 1.52520910e-01f, 1.69079155e-01f, 1.39816403e-01f, -6.78020641e-02f, 8.68212897e-03f,
  -9.95392278e-02f, 6.11332022e-02f, 3.92498495e-03f, -1.62753034e-02f, -1.32081788e-02f, -2.60255020e-02f, -6.18399493e-02f, 7.46615008e-02f, 4.90907878e-02f, 8.77445936e-02f,
  7.61748804e-03f, -9.85510834e-03f, -8.56297184e-03f, -3.32037099e-02f, -3.86583433e-02f, -3.77440751e-02f, 3.81934717e-02f, 1.45394364e-02f, -2.27472726e-02f, 7.05172271e-02f,
  -6.30813977e-03f, -1.96115244e-02f, 2.91217510e-02f, 1.46952914e-02f, 5.22595681e-02f, -6.00217283e-02f, -3.81835289e-02f, 6.98888376e-02f, 4.71315980e-02f, 6.74422085e-02f,
  5.07152872e-03f, 3.11669800e-02f, 6.41862601e-02f, 3.00058238e-02f, 3.65176313e-02f, 7.43907616e-02f, -3.40680056e-03f, 7.41783828e-02f, -4.15596850e-02f, 4.23549637e-02f,
  -8.90848935e-02f, -2.63075531e-02f, 1.50447842e-02f, -3.46579663e-02f, 1.51681537e-02f, -3.89712341e-02f, -3.74187641e-02f, 3.40828963e-04f, -8.94702505e-03f, 5.40412180e-02f,
  -9.42572206e-03f, -7.96613470e-03f, 4.33679298e-02f, 7.89125357e-03f, -1.94486678e-02f, -2.97734905e-02f, -2.86983233e-02f, 4.81397994e-02f, -1.64397042e-02f, -2.84934118e-02f,
  2.16071624e-02f, -2.93199476e-02f, 2.50934213e-02f, -2.92959865e-02f, 4.10245545e-03f, -4.45130542e-02f, -5.19872978e-02f, -1.02081466e-02f, 3.03287953e-02f, -5.07571436e-02f,
  -6.77921847e-02f, 1.96803715e-02f, 5.16435839e-02f, -4.43900898e-02f, 6.44971579e-02f, 7.08718505e-03f, -5.98836876e-02f, -6.09960556e-02f, -1.65793095e-02f, 7.31109083e-02f,
  -1.98111087e-02f, 8.15246850e-02f, 4.84578647e-02f, -2.14588530e-02f, 2.63737119e-03f, -3.76049872e-03f, 1.14494711e-02f, 2.58986335e-02f, 2.18927450e-02f, -1.21075166e-02f,
  1.54786795e-01f, 1.75449580e-01f, -3.75166461e-02f, 3.04123074e-01f, -6.25837967e-02f, -1.55435294e-01f, -1.91680744e-01f, 1.89742804e-01f, 1.24833196e-01f, 4.25490700e-02f,
  -6.57829398e-04f, 8.78431946e-02f, -1.75458044e-01f, 2.08146214e-01f, -2.21825898e-01f, -1.80978045e-01f, 6.77572712e-02f, 6.90132752e-02f, 9.01971851e-03f, 1.30752042e-01f,
  5.50986119e-02f, 1.20383769e-01f, -4.00705636e-02f, 7.02566877e-02f, 1.27107337e-01f, 5.45936823e-02f, 3.59562598e-03f, -1.41021118e-01f, 1.52889818e-01f, 1.50644658e-02f,
  -8.81928056e-02f, -1.26996478e-02f, -1.96319260e-02f, -1.09870452e-02f, 6.96351305e-02f, 5.07001653e-02f, -4.40565199e-02f, -4.06447761e-02f, -4.16250853e-03f, 1.24746386e-03f,
  -5.55103160e-02f, -7.67865125e-03f, 7.64194727e-02f, -1.46882730e-02f, 2.18786523e-02f, 7.19096363e-02f, -1.01521555e-02f, 2.68564876e-02f, 3.43910903e-02f, -4.30711955e-02f,
  1.19850188e-02f, 5.31871803e-02f, 6.51478320e-02f, -9.15586203e-03f, 5.25996322e-03f, -5.63131422e-02f, 5.39151067e-03f, -5.54840267e-02f, 2.43766662e-02f, 4.35427716e-03f,
  6.06857464e-02f, -1.25871180e-02f, 1.09013123e-02f, 1.11963563e-02f, -4.72148657e-02f, 6.00333288e-02f, -2.42680497e-02f, -3.70380990e-02f, -2.27906182e-02f, 4.15535495e-02f,
  -2.09449511e-02f, 4.13357094e-02f, 3.57838124e-02f, 4.33554314e-02f, 2.70359870e-03f, 4.42561544e-02f, -2.98222899e-03f, -5.31710908e-02f, 5.01567982e-02f, 2.89483368e-02f,
  -6.81979954e-03f, -1.15491392e-03f, 2.21730154e-02f, 3.37443128e-02f, -2.98792087e-02f, -4.26922478e-02f, 9.11990553e-02f, 2.34783255e-02f, -5.74702248e-02f, -4.35711630e-02f,
  7.16190711e-02f, 1.27217412e-01f, -3.11932731e-02f, 4.39107791e-02f, -8.83067772e-03f, 3.17582674e-02f, -1.69101283e-02f, 5.78713929e-03f, 2.40085181e-02f, 7.31449574e-02f,
  6.73974305e-02f, -2.52546109e-02f, 1.63464695e-02f, -3.69898118e-02f, -1.45205287e-02f, 1.24409078e-02f, 3.86683382e-02f, -1.05204554e-02f, 4.95154262e-02f, 6.93968534e-02f,
  3.48636098e-02f, -6.62341490e-02f, -4.03952710e-02f, -1.92409474e-02f, -5.18928922e-04f, 3.03045381e-02f, 2.00500488e-02f, 4.05910745e-04f, 7.98115134e-03f, 4.86674756e-02f,
  -6.04640022e-02f, 2.56103482e-02f, 1.50734201e-01f, -5.34087867e-02f, -5.03707044e-02f, 3.62293757e-02f, -4.65202145e-02f, 8.59061349e-03f, 2.36646563e-01f, -1.27067193e-01f,
  -1.28529280e-01f, 8.84424150e-02f, -4.47092727e-02f, -1.58833027e-01f, 8.34614187e-02f, -3.10117137e-02f, -1.93161041e-01f, -1.30953237e-01f, 4.31172289e-02f, -1.34959698e-01f,
  4.28995974e-02f, -1.57185569e-01f, -8.50834474e-02f, -5.07349819e-02f, -1.05810791e-01f, 7.09588826e-02f, 4.53386595e-03f, -1.53387676e-03f, -1.49901628e-01f, 4.95347232e-02f,
  -3.63742188e-02f, 9.19741020e-02f, 2.53893808e-02f, 9.05246474e-03f, 3.27021405e-02f, -8.86583552e-02f, 3.02283559e-02f, 8.08569640e-02f, 3.39995697e-02f, 7.32768849e-02f,
  2.63451785e-02f, 1.08883157e-03f, -2.98130861e-03f, 6.66782409e-02f, 2.59143896e-02f, 5.57984821e-02f, -2.62731463e-02f, -3.15454714e-02f, 1.98311564e-02f, 5.55963852e-02f,
  1.66212134e-02f, 1.24666756e-02f, 1.24057382e-03f, 1.08131953e-02f, 2.07505617e-02f, -4.79226448e-02f, -4.00832184e-02f, -1.50146838e-02f, -2.21724715e-02f, 1.33873662e-02f,
  1.56844296e-02f, -5.45741320e-02f, 8.35353881e-03f, -3.55218686e-02f, 2.02505533e-02f, 5.04958350e-03f, 2.43193898e-02f, -6.26211539e-02f, 6.41435087e-02f, -6.96490929e-02f,
  -4.34837602e-02f, 1.35033522e-02f, 2.98168994e-02f, -5.67643270e-02f, -7.12045729e-02f, -1.72811877e-02f, -5.15619516e-02f, -1.36502469e-02f, 3.15423012e-02f, 5.35754040e-02f,
  -7.64748380e-02f, 3.67996357e-02f, -4.92869951e-02f, -9.31107532e-03f, 4.61098365e-02f, 4.56730090e-02f, -4.18909676e-02f, 2.63543688e-02f, 6.00758828e-02f, -3.67142186e-02f,
  1.26615621e-03f, -4.36161309e-02f, 6.77594915e-02f, 1.17363311e-01f, -4.89145983e-03f, -1.99850034e-02f, -2.24069990e-02f, -6.09661229e-02f, 3.79656516e-02f, -6.36355486e-03f,
  1.18546560e-02f, -3.77369337e-02f, 5.01088565e-04f, -8.28621909e-02f, 6.08730875e-02f, -2.63755843e-02f, -5.40280752e-02f, -1.11575695e-02f, -4.99139354e-02f, -2.97915787e-02f,
  -1.94843449e-02f, 3.00477687e-02f, -4.98162303e-03f, -8.29493999e-03f, -8.11670721e-02f, -5.82517050e-02f, -3.61405388e-02f, 4.10109982e-02f, -5.13208695e-02f, 5.38246427e-03f,
  -2.88798600e-01f, 2.81862170e-01f, -2.63597399e-01f, -6.50609583e-02f, -1.40415430e-01f, -8.56307000e-02f, -5.78937829e-02f, -1.82631682e-03f, 1.50441423e-01f, 1.28631175e-01f,
  -2.84192301e-02f, 4.26443070e-02f, 7.60055631e-02f, 7.11425170e-02f, -7.74904564e-02f, 2.28366554e-01f, -1.55203957e-02f, 5.39134145e-02f, 6.10516127e-03f, -9.78419185e-02f,
  -1.27346031e-02f, 4.55614962e-02f, -5.05570211e-02f, -6.53390437e-02f, -1.22839279e-01f, -2.97100432e-02f, -3.91021818e-02f, -9.84892324e-02f, -3.56157906e-02f, 6.23409338e-02f,
  -5.25613725e-02f, -8.56512785e-02f, -1.24369830e-01f, -7.85010010e-02f, -1.61162019e-01f, -3.63062732e-02f, -1.12026185e-01f, -6.04763553e-02f, -6.15076460e-02f, -5.94381951e-02f,
  1.88668277e-02f, -3.70745175e-02f, -4.76230048e-02f, 8.59702751e-02f, -1.35529004e-02f, 9.70238913e-03f, 6.61344752e-02f, -7.36693144e-02f, 2.11279225e-02f, -5.94503945e-03f,
  -1.70387997e-04f, -1.97664853e-02f, -2.65616030e-02f, 4.43883166e-02f, 5.77379204e-03f, 2.94611161e-03f, -2.23501809e-02f, -4.90210354e-02f, -2.02713851e-02f, -2.83358116e-02f,
  -3.95337790e-02f, -1.50497323e-02f, 1.69106759e-02f, -3.67872156e-02f, -6.41659694e-03f, -2.70940084e-02f, -4.86805625e-02f, 1.91624947e-02f, 1.08764628e-02f, 2.38234419e-02f,
  -2.87993364e-02f, 5.34807928e-02f, -5.14482260e-02f, 5.55540361e-02f, -1.83171500e-02f, 1.60001144e-02f, -5.79738431e-02f, 4.92006503e-02f, 2.49320194e-02f, 4.28788997e-02f,
  5.69029003e-02f, 9.40582436e-03f, -3.26411240e-02f, 2.92347632e-02f, -2.91035371e-03f, 7.20890909e-02f, 1.87228597e-03f, 4.09433357e-02f, -6.43400028e-02f, -1.27288662e-02f,
  7.40268361e-03f, -5.75323123e-03f, -4.58178520e-02f, -8.29499513e-02f, -1.24544343e-02f, -6.23549446e-02f, -6.25279034e-03f, 1.03260070e-01f, 1.36704311e-01f, 1.83306392e-02f,
  -1.74774528e-02f, -4.88784201e-02f, -9.38038453e-02f, -2.77225301e-02f, 4.43077087e-02f, 2.56649349e-02f, 2.12776475e-02f, 3.05037871e-02f, -8.80953297e-03f, -1.63325351e-02f,
  -8.18471014e-02f, -7.78356642e-02f, 1.11993318e-02f, -3.97643484e-02f, -1.73443295e-02f, -1.54108545e-02f, -2.83784550e-02f, 7.07126502e-03f, 8.33158940e-02f, -4.24995758e-02f,
  -3.01115692e-01f, 2.07092956e-01f, 1.09471761e-01f, -2.26225615e-01f, 9.44390744e-02f, 1.60115920e-02f, -6.66499883e-02f, 3.38619091e-02f, 2.31632236e-02f, 1.59146979e-01f,
  -8.62915516e-02f, -5.85053191e-02f, -3.45040336e-02f, -2.94162296e-02f, -4.89154071e-01f, -2.20220014e-01f, -1.22051924e-01f, -6.70734122e-02f, -9.04228017e-02f, 2.62850262e-02f,
  -1.14035569e-01f, -1.78589553e-01f, -9.05119926e-02f, 6.34764358e-02f, 5.18629774e-02f, 1.07720904e-01f, -8.04884657e-02f, -5.58832486e-04f, 4.22092192e-02f, -8.61106813e-02f,
  -4.09460850e-02f, 1.07611984e-01f, 1.28643319e-01f, 4.13091294e-02f, -3.57473902e-02f, 2.55924300e-03f, -5.57796918e-02f, -3.91317271e-02f, -1.88010801e-02f, -6.42036945e-02f,
  -1.75270475e-02f, 2.17615124e-02f, -4.83870804e-02f, -1.47912381e-02f, 5.01556210e-02f, 8.41850191e-02f, 4.36255485e-02f, 5.02391905e-02f, -3.93854827e-03f, 4.81975228e-02f,
  6.93089589e-02f, -4.80941273e-02f, 3.95949418e-03f, -1.35081345e-02f, -9.66361444e-03f, 5.60189709e-02f, 2.44251452e-02f, 6.67756125e-02f, -2.32633390e-02f, 1.29121318e-02f,
  -6.42752200e-02f, -6.95710704e-02f, -3.35572846e-02f, -2.96581592e-02f, -5.07165119e-02f, 3.81576270e-02f, -7.27891177e-02f, -9.53662582e-03f, 1.54091949e-02f, -5.20505384e-02f,
  2.27941182e-02f, -2.30358131e-02f, -2.08703317e-02f, -1.43909324e-02f, -8.37104209e-03f, 5.88582605e-02f, -1.38202934e-02f, 6.48030266e-02f, 9.50153451e-03f, -1.48897804e-02f,
  3.63684772e-03f, -1.42429089e-02f, 1.94440782e-02f, 1.09468689e-02f, 1.00896256e-02f, -4.30014962e-03f, -4.34821881e-02f, 7.42530152e-02f, 1.29089132e-02f, -6.06277958e-02f,
  -1.42855467e-02f, -1.36919454e-01f, 2.72855349e-02f, 4.34304774e-03f, 2.30677370e-02f, 1.66969858e-02f, -2.12937258e-02f, 2.22384948e-02f, 1.83625314e-02f, 4.40032268e-03f,
  7.89217874e-02f, 3.37314121e-02f, -2.10422203e-02f, -7.34115168e-02f, -8.52124617e-02f, -5.89458384e-02f, 1.41631300e-03f, 8.78765155e-03f, -2.11264044e-02f, -5.79492152e-02f,
  -3.66261462e-03f, 7.89040327e-02f, -5.56018613e-02f, -8.49456340e-03f, 1.15113612e-02f, -2.20991038e-02f, -4.34400663e-02f, -1.50548546e-02f, -4.91145300e-03f, -1.64944455e-02f,
  -5.34415878e-02f, -6.96666166e-02f, -3.31871003e-01f, -1.56203769e-02f, 2.42712796e-02f, 1.41964868e-01f, -8.05696025e-02f, 1.10897841e-02f, -1.85896814e-01f, 1.97818056e-01f,
  7.71375895e-02f, -7.26050213e-02f, -1.04663506e-01f, 1.09340601e-01f, -6.18078820e-02f, -8.55224878e-02f, 1.15043603e-01f, 4.63611409e-02f, -6.01311997e-02f, -1.97910573e-02f,
  -8.88284817e-02f, 2.27184713e-01f, -8.43908414e-02f, 5.46434242e-03f, 7.39197358e-02f, -1.09414533e-01f, 1.49450302e-01f, -1.13237381e-01f, 1.89034939e-01f, 8.70779231e-02f,
  -3.02633699e-02f, 2.70700697e-02f, 1.62050109e-02f, -8.62904117e-02f, -3.89094613e-02f, 1.19199425e-01f, 1.61410496e-02f, 2.26553101e-02f, -6.30216748e-02f, -6.97791651e-02f,
  2.76533142e-02f, -3.69233005e-02f, 5.62885813e-02f, 2.85646301e-02f, -3.63672823e-02f, -5.91702834e-02f, -3.50366831e-02f, -1.24666486e-02f, -9.49444845e-02f, -3.26368324e-02f,
  -1.84705146e-02f, 6.33432865e-02f, -3.23041566e-02f, -5.30391745e-02f, -4.73756492e-02f, 1.01511693e-02f, -4.02813740e-02f, 2.54860576e-02f, -1.85374580e-02f, -5.05330414e-02f,
  2.52076201e-02f, -4.99295536e-04f, -1.34886634e-02f, -6.30061980e-03f, -3.53907458e-02f, 3.96695323e-02f, -3.02745961e-02f, 4.84140171e-03f, -4.17580307e-02f, 1.90272443e-02f,
  1.38928853e-02f, 1.40718147e-02f, 4.08648960e-02f, -3.50072943e-02f, -1.12375859e-02f, 1.29418438e-02f, 3.64226848e-02f, -7.34594883e-03f, -1.32740447e-02f, -4.83580902e-02f,
  5.23628965e-02f, -4.24324758e-02f, -5.98086603e-02f, 6.05614297e-02f, 5.61966635e-02f, 4.56409231e-02f, -1.73090640e-02f, -2.90385745e-02f, 1.25443889e-02f, 2.62788888e-02f,
  7.84826502e-02f, 3.33867185e-02f, -1.75989959e-02f, -3.25487815e-02f, 6.93266392e-02f, 2.34912802e-02f, 3.92732956e-02f, 1.04261525e-02f, -4.39944267e-02f, 2.81047616e-02f,
  7.03702960e-03f, 1.13253556e-02f, 3.02029331e-03f, 4.60463203e-02f, 2.35519111e-02f, 7.26070032e-02f, -1.78380236e-02f, -2.66818162e-02f, 8.09544101e-02f, 5.37922010e-02f,
  2.63630822e-02f, 3.76338116e-03f, -6.50999770e-02f, -3.57556045e-02f, -1.27680805e-02f, 7.24104196e-02f, 3.36669688e-03f, -8.26454386e-02f, -8.03703070e-03f, -1.58510879e-02f,
  9.79398265e-02f, -1.12936333e-01f, 1.80442825e-01f, 2.01353393e-02f, 6.74470812e-02f, 9.99982655e-02f, 1.17111720e-01f, -1.07493676e-01f, 8.44427794e-02f, -2.39041433e-01f,
  -3.83898839e-02f, 7.17296079e-02f, 1.16053753e-01f, -1.82037562e-01f, 2.52464384e-01f, -6.61236513e-03f, -8.47874209e-02f, -8.37645903e-02f, 1.16676643e-01f, -4.10187356e-02f,
  7.85747841e-02f, -1.80287927e-01f, 5.98501302e-02f, -1.07194357e-01f, 7.13937879e-02f, -5.71223646e-02f, -7.40074590e-02f, 1.58815593e-01f, -1.23530313e-01f, 7.02179372e-02f,
  -6.30537188e-03f, -1.26341432e-01f, -2.13096514e-02f, -3.26608457e-02f, 2.24861298e-02f, 7.92292319e-03f, -6.18630350e-02f, 1.75474994e-02f, 1.06939718e-01f, 4.81582955e-02f,
  -4.32849787e-02f, 7.54648075e-02f, -4.82561579e-03f, 4.37512212e-02f, -7.83723593e-02f, -5.67466579e-02f, 3.23082320e-02f, -8.88866186e-03f, -8.62870272e-03f, 8.25028270e-02f,
  1.12973765e-01f, 3.18526067e-02f, 9.43624601e-03f, -6.31672591e-02f, 4.52394933e-02f, -5.91471617e-04f, -2.32316852e-02f, -4.00398206e-03f, -3.27496976e-02f, -4.78204340e-02f,
  -8.09919648e-03f, 2.72040013e-02f, 3.21372747e-02f, 7.64121069e-03f, -1.30614229e-02f, -1.58733930e-02f, -1.29264751e-02f, -4.60010059e-02f, -2.50898320e-02f, -4.05005664e-02f,
  -4.57641520e-02f, -3.17596085e-02f, -7.64616951e-02f, 1.08235739e-02f, -1.10676687e-03f, -8.17002431e-02f, 2.25881990e-02f, -6.45526350e-02f, 5.70072792e-02f, -4.74527404e-02f,
  1.27525907e-03f, -2.40228344e-02f, 2.51555517e-02f, 3.12573500e-02f, -5.09115309e-02f, 3.72933485e-02f, -2.72786319e-02f, -6.22123154e-03f, -1.61632057e-02f, 6.86385855e-02f,
  -3.99538968e-03f, -1.48827851e-01f, 4.58900221e-02f, -3.40388231e-02f, -2.55157482e-02f, -1.17495526e-02f, 1.47796879e-02f, -6.71987981e-02f, -5.50937355e-02f, 2.58376356e-02f,
  -5.02418466e-02f, -9.89370346e-02f, -4.63520326e-02f, -5.11465259e-02f, 5.37445880e-02f, -3.91612016e-03f, 4.99502905e-02f, 6.55750036e-02f, -4.46549430e-02f, 1.23818731e-02f,
  -4.56831530e-02f, -6.14374429e-02f, -4.20909226e-02f, -5.74227236e-02f, 1.71634220e-02f, -4.23818789e-02f, 3.83245759e-02f, 3.15005034e-02f, 1.63835511e-02f, 1.08485110e-02f,
  1.34315163e-01f, 1.41982868e-01f, 2.78987619e-03f, 9.05232430e-02f, -1.91469993e-02f, 7.22131059e-02f, 7.69439489e-02f, -2.17142124e-02f, -1.94006145e-01f, -6.57362677e-03f,
  5.17328121e-02f, 1.42645732e-01f, -6.24037832e-02f, 8.32012519e-02f, 1.29518479e-01f, 7.12047843e-03f, 1.14214987e-01f, 6.55718073e-02f, -4.50347476e-02f, 1.14412263e-01f,
  4.65422720e-02f, 1.38694480e-01f, 6.74076602e-02f, 7.97221661e-02f, 1.17842890e-01f, 9.04937312e-02f, 1.17734671e-01f, 4.01865132e-02f, 2.25926906e-01f, 4.66119312e-02f,
  1.24786101e-01f, -7.94890895e-02f, 9.52964276e-02f, 3.14500090e-03f, 3.82248275e-02f, -5.33124730e-02f, -4.03793752e-02f, 4.75447960e-02f, 1.93910189e-02f, 4.30118628e-02f,
  1.29937092e-02f, -1.23062646e-02f, -2.66179536e-02f, 2.44770595e-03f, -4.17218991e-02f, -2.98896688e-03f, 1.97226927e-02f, 2.89587323e-02f, -7.43821189e-02f, -5.80670573e-02f,
  -9.90546793e-02f, -1.96759887e-02f, -4.64278609e-02f, -3.34859155e-02f, 2.72955280e-02f, -4.89293560e-02f, 4.79765572e-02f, 1.41250575e-02f, -2.33567785e-02f, -5.15517294e-02f,
  -8.58209357e-02f, -8.82442866e-04f, 5.54969534e-02f, -1.14290183e-02f, 2.53175590e-02f, -1.31928446e-02f, 4.04786691e-02f, -8.09996948e-03f, -1.53441459e-03f, -2.22576801e-02f,
  4.54943478e-02f, -4.82378677e-02f, -2.92402506e-02f, -5.29926978e-02f, 5.75015992e-02f, -1.16372153e-01f, -2.15287954e-02f, 3.09283622e-02f, -7.96708241e-02f, -3.35162356e-02f,
  -4.82039675e-02f, 2.65694708e-02f, -2.48305313e-02f, -1.90838911e-02f, -4.23933864e-02f, -2.96392143e-02f, -4.09141891e-02f, 2.40821410e-02f, -3.59106846e-02f, 3.94860022e-02f,
  1.74910679e-01f, 1.75504535e-01f, 5.22177899e-03f, 6.57662824e-02f, 5.56727201e-02f, 8.94646198e-02f, 6.67604953e-02f, 6.44736663e-02f, 1.14752881e-01f, -2.74383258e-02f,
  2.26857048e-03f, -1.77215470e-03f, 4.26289141e-02f, -2.16851253e-02f, -6.89212680e-02f, 6.99082091e-02f, 2.87747215e-02f, 1.03725486e-01f, 1.10919192e-01f, 2.86397431e-02f,
  8.11013207e-02f, 7.53573701e-02f, 1.08692087e-02f, 2.14200374e-02f, -1.62791256e-02f, 7.27478042e-02f, -2.20537689e-02f, 4.26759049e-02f, -2.68042218e-02f, 4.19589616e-02f,
  -1.05863251e-01f, 6.13896810e-02f, -2.41708398e-01f, -1.99636832e-01f, -7.30755180e-02f, 9.06286612e-02f, 1.21136419e-01f, 8.11013952e-03f, -8.30866098e-02f, 2.43947491e-01f,
  1.19322680e-01f, -1.06678806e-01f, 1.91953897e-01f, 5.31569181e-04f, 5.23156971e-02f, 8.73423815e-02f, 5.39550371e-02f, 9.27436724e-02f, -1.19865835e-01f, 7.28556588e-02f,
  -1.33831441e-01f, 9.08421353e-02f, -1.34581730e-01f, 5.87956905e-02f, -5.00781573e-02f, -1.93700477e-01f, 6.69002756e-02f, -1.19065866e-01f, 2.81566735e-02f, 1.89546570e-02f,
  1.11363597e-01f, 2.12676805e-02f, -6.17340542e-02f, 1.87339354e-02f, 6.51226491e-02f, -3.52979600e-02f, -7.11166337e-02f, -1.06351189e-02f, -3.90228629e-02f, -5.75131625e-02f,
  7.69905671e-02f, 4.74011935e-02f, 1.34224147e-02f, -9.34883282e-02f, -3.96678410e-02f, -1.25518426e-01f, -2.01388747e-02f, -1.29605783e-02f, 9.29399580e-03f, 4.40923050e-02f,
  -7.93562606e-02f, -6.60285056e-02f, -3.61356959e-02f, -1.36554260e-02f, -1.14389732e-01f, 2.11595241e-02f, -6.34935349e-02f, 1.36591832e-03f, 3.98420691e-02f, -9.27032158e-02f,
  -4.19377871e-02f, -6.29156604e-02f, 1.81978848e-02f, 7.41077587e-02f, -4.31387080e-03f, -4.40979265e-02f, 2.14554090e-02f, 5.12481853e-03f, -7.89354648e-03f, 4.43064980e-03f,
  -1.34620816e-03f, -2.89766882e-02f, -9.28907935e-03f, 7.47356843e-03f, 2.38225982e-02f, 8.04075748e-02f, 1.22696962e-02f, 4.29323502e-02f, -6.73627555e-02f, -3.50877382e-02f,
  -3.93904857e-02f, 2.83320248e-02f, 4.34462726e-02f, -6.72997162e-02f, -1.37198567e-02f, 2.38892902e-02f, -1.48035018e-02f, -3.34302187e-02f, -1.33234104e-02f, -3.74041721e-02f,
  2.52915591e-01f, 7.16716424e-02f, -7.44715706e-03f, 4.63639572e-02f, 5.18049188e-02f, 5.51462248e-02f, -1.51458541e-02f, -3.99643235e-04f, 4.75532189e-02f, 1.34323416e-02f,
  -2.76301205e-02f, -4.43669260e-02f, -1.11442497e-02f, 3.43641490e-02f, 4.04146593e-03f, 7.74363279e-02f, 5.02582937e-02f, 3.02165505e-02f, 5.26023842e-03f, -8.11807066e-02f,
  1.79834682e-02f, 1.27146328e-02f, -3.40437032e-02f, -2.98275165e-02f, 3.87722962e-02f, -2.42799092e-02f, 3.67912278e-02f, -3.06498613e-02f, -4.60178740e-02f, 2.47046668e-02f,
  2.44090736e-01f, 2.64407188e-01f, 4.62602109e-01f, 2.24276111e-01f, -1.26267359e-01f, -3.22570838e-02f, 2.05190822e-01f, 7.00138062e-02f, 9.39596221e-02f, -1.37874633e-01f,
  -1.30042553e-01f, 2.91500390e-01f, 1.95477083e-01f, 5.38945012e-02f, 1.55582219e-01f, 1.12169661e-01f, 9.18409228e-03f, -2.97068153e-02f, 8.75033885e-02f, 1.02190815e-01f,
  1.31972125e-02f, -1.05531432e-01f, 1.19034439e-01f, -2.02241689e-01f, 3.04550864e-02f, 7.17415214e-02f, -1.51697416e-02f, 5.59357107e-02f, -8.26534927e-02f, -4.32446972e-02f,
  -1.18325226e-01f, -1.94967501e-02f, 6.17947094e-02f, 6.03621779e-03f, 2.48719822e-03f, -2.64829136e-02f, 8.51180255e-02f, 5.47696650e-02f, -3.72609310e-02f, -5.71513828e-03f,
  4.81212921e-02f, -3.97606827e-02f, -5.82787655e-02f, 1.30857620e-02f, 3.58777936e-04f, -2.44662389e-02f, 9.70555237e-04f, -8.21435750e-02f, 1.76900271e-02f, 6.39740452e-02f,
  4.95831966e-02f, -5.72609045e-02f, -4.69581410e-02f, 3.67778167e-02f, 3.49704511e-02f, -1.80255454e-02f, -3.70837562e-02f, 3.71690579e-02f, -1.97849479e-02f, -3.43031511e-02f,
  -8.91406462e-02f, 3.23776118e-02f, -2.81574167e-02f, 1.97086204e-02f, 5.59046865e-02f, -5.63662425e-02f, -1.21376179e-02f, -3.61002721e-02f, 7.18570426e-02f, 3.74321197e-03f,
  1.39792282e-02f, 4.59881499e-02f, -3.00001204e-02f, 1.11660929e-02f, 4.99968708e-04f, -2.65139677e-02f, 6.36917278e-02f, -9.78774112e-03f, 1.03531722e-02f, 3.20959208e-03f,
  -1.26127491e-03f, 2.91588083e-02f, -1.78669486e-02f, -3.37333344e-02f, 1.71831939e-02f, 5.32985516e-02f, -3.30332145e-02f, 1.14129065e-02f, -4.16554185e-03f, -5.07239671e-03f,
  -3.55069749e-02f, 2.10825935e-01f, 1.51210520e-02f, 4.57943864e-02f, 7.68172964e-02f, -2.01120060e-02f, 1.37381693e-02f, -6.77869562e-03f, 4.77734208e-02f, 3.94150019e-02f,
  3.18944231e-02f, 4.07786295e-02f, 5.24117909e-02f, -1.11346208e-02f, -4.98852320e-03f, -3.86680327e-02f, 3.61688458e-03f, 4.64545526e-02f, 7.73118511e-02f, -4.05671485e-02f,
  4.96128798e-02f, -4.80796061e-02f, 8.78389776e-02f, -7.78176337e-02f, -7.81644285e-02f, -1.16428202e-02f, -2.27005426e-02f, 4.77602445e-02f, -2.05940083e-02f, -2.24087927e-02f,
  -4.71452206e-01f, 1.88404918e-01f, -1.11161560e-01f, -9.34157893e-02f, -1.76550765e-02f, -1.11622196e-02f, 3.67507823e-02f, 7.27202967e-02f, -1.83464319e-01f, 2.07917422e-01f,
  3.79472338e-02f, -5.68107888e-02f, 4.20482829e-02f, 6.02997020e-02f, -2.87989229e-01f, 1.04200803e-02f, -1.22095510e-01f, -6.67097745e-04f, -1.40586244e-02f, -6.32948522e-03f,
  -1.06775716e-01f, 5.39416634e-02f, -7.09672421e-02f, 1.40804023e-01f, 8.71718116e-03f, -7.33064860e-02f, -1.83239095e-02f, 3.27262022e-02f, 3.95105258e-02f, -6.88132718e-02f,
  8.08115527e-02f, 4.25527766e-02f, -3.40567864e-02f, 3.51067223e-02f, -7.51340762e-02f, -1.25198569e-02f, -1.45017784e-02f, -6.75213290e-03f, 3.92906228e-03f, 4.22980674e-02f,
  -5.45456670e-02f, -1.46596264e-02f, -4.80011180e-02f, -2.03207340e-02f, -5.36126792e-02f, 7.56763946e-03f, 5.60913049e-02f, -4.57531288e-02f, 1.08053744e-01f, -2.35143732e-02f,
  5.70705123e-02f, 3.32316458e-02f, 1.70764904e-02f, -4.73344997e-02f, 7.47597683e-03f, -6.13222159e-02f, -4.15303651e-03f, 2.54153330e-02f, -2.66707279e-02f, -1.31142875e-02f,
  1.65200315e-03f, -2.08110530e-02f, 8.78468563e-04f, -3.84841561e-02f, 5.28696552e-02f, -5.18911406e-02f, 2.68674046e-02f, 6.89108996e-03f, -7.87343308e-02f, -5.26452437e-03f,
  -6.35866225e-02f, 2.91388924e-03f, -3.18283550e-02f, 5.74997850e-02f, -7.19950243e-04f, -2.73122378e-02f, 2.29463596e-02f, 4.92830947e-03f, -5.99218942e-02f, -4.75506950e-03f,
  -1.64969414e-02f, -8.04349594e-03f, 3.84376869e-02f, -2.98908483e-02f, 3.07704192e-02f, -2.81438958e-02f, 5.24036624e-02f, -5.47491685e-02f, -5.75488657e-02f, -4.17591184e-02f,
  -1.73184946e-02f, -4.84444238e-02f, 5.20697981e-02f, 5.72701991e-02f, 4.81131263e-02f, 5.48272543e-02f, -1.83006674e-02f, -3.89026739e-02f, -3.30267958e-02f, -4.64697555e-02f,
  6.90387413e-02f, -2.48214062e-02f, 5.05376235e-02f, 1.09655336e-02f, 5.00387624e-02f, 1.38612930e-02f, 2.94941012e-02f, 1.97938178e-02f, -4.87145074e-02f, 4.72633056e-02f,
  3.21046711e-04f, 7.89283216e-02f, -1.57330986e-02f, 1.03276432e-01f, -1.35292690e-02f, 3.27722952e-02f, 4.02989686e-02f, -4.37647989e-03f, 7.47026736e-03f, 2.45378632e-02f,
  3.63615960e-01f, 2.11901680e-01f, 3.03694457e-02f, 1.30989239e-01f, -1.26524299e-01f, -2.86908686e-01f, -1.17656589e-01f, 3.13728526e-02f, 8.91470537e-02f, -2.52402555e-02f,
  -1.50990382e-01f, 2.20398813e-01f, 6.12984225e-02f, -2.15214372e-01f, -2.06751540e-01f, -1.08642139e-01f, -7.30853826e-02f, -1.53063536e-02f, 9.29940864e-02f, 1.41350135e-01f,
  -1.75045896e-02f, -2.13225856e-01f, -9.13052410e-02f, -5.54506034e-02f, -5.75487092e-02f, 1.78426728e-01f, 3.61072808e-03f, 4.05327789e-02f, -1.06758885e-01f, -7.72443935e-02f,
  8.21859390e-02f, 1.68686375e-01f, -8.34273268e-03f, 6.29108250e-02f, -4.47378717e-02f, 4.42261584e-02f, 3.44183221e-02f, -8.78818408e-02f, -1.54392999e-02f, -2.18872004e-03f,
  3.92910652e-02f, -6.09003976e-02f, -1.56846382e-02f, -3.18033807e-02f, 5.52731790e-02f, 3.95433977e-02f, -8.42018202e-02f, 3.72484438e-02f, -7.69002084e-03f, -4.66704965e-02f,
  -2.87193209e-02f, 2.76396293e-02f, 3.65814678e-02f, -1.20278895e-02f, 5.17733768e-02f, -2.33461428e-02f, -1.84440631e-02f, 1.81944259e-02f, 3.09600349e-04f, -2.87999545e-04f,
  -4.63063689e-03f, -5.31117152e-03f, 5.11761159e-02f, -3.72694880e-02f, -7.06724543e-03f, -4.12219316e-02f, -2.19210777e-02f, -5.40599301e-02f, 3.55943991e-03f, -1.57890636e-02f,
  -2.24718302e-02f, 1.93752907e-02f, 2.87473164e-02f, -1.54988421e-02f, 4.02550735e-02f, 4.46808599e-02f, 1.14628486e-02f, 4.11094306e-03f, 3.29441833e-03f, -7.46900961e-02f,
  4.27403487e-03f, 4.14478965e-03f, -2.95789186e-02f, -2.18628962e-02f, -2.01815497e-02f, -2.99104992e-02f, 5.15876487e-02f, 2.25828402e-02f, -2.06660368e-02f, -1.75540689e-02f,
  1.63808331e-01f, 3.25724453e-01f, 6.35628495e-03f, -4.68597673e-02f, 2.90828999e-02f, -1.31305039e-03f, 1.04518734e-01f, -1.03015676e-02f, 3.23790237e-02f, 1.05122551e-02f,
  -1.02353338e-02f, -8.71985685e-03f, 3.76233160e-02f, 2.16416921e-02f, 1.47993304e-02f, -6.41820207e-02f, 6.43393025e-02f, -2.63110213e-02f, -5.17522320e-02f, 2.76808869e-02f,
  3.38312946e-02f, 6.69365972e-02f, -7.99665600e-02f, -1.34742651e-02f, -1.06891971e-02f, 3.09840832e-02f, 2.21861098e-02f, 1.37154814e-02f, 3.22127566e-02f, -8.51486402e-04f,
  -4.82393801e-01f, -8.39176923e-02f, -2.51830161e-01f, -2.16227636e-01f, -1.95674598e-02f, -7.80236125e-02f, -1.18783757e-01f, -4.18497659e-02f, -3.46809596e-01f, 2.09133863e-01f,
  1.99036628e-01f, -1.72390506e-01f, 9.95088145e-02f, 8.10074285e-02f, 9.19226371e-03f, -5.75250620e-03f, -2.42679473e-02f, 1.09241670e-03f, -1.33599684e-01f, -1.91085432e-02f,
  -1.40488997e-01f, 1.62327901e-01f, 6.61656260e-02f, 2.14690953e-01f, -2.73003615e-02f, -5.00331260e-02f, 3.33228528e-01f, 6.34651184e-02f, 2.25570783e-01f, 1.46439243e-02f,
  -7.02446327e-02f, -1.03841454e-01f, -5.68571948e-02f, -5.96999265e-02f, 1.51584707e-02f, 6.75416142e-02f, 3.66264097e-02f, 1.87487788e-02f, -5.61389700e-02f, -6.29269481e-02f,
  -3.22256424e-02f, 4.81136478e-02f, -1.32063320e-02f, -6.98163360e-02f, -1.37427468e-02f, -3.90578955e-02f, -9.76061374e-02f, -7.77303502e-02f, -4.42641675e-02f, -9.36541557e-02f,
  -6.35671169e-02f, -5.31520694e-03f, -3.11878808e-02f, 7.89173543e-02f, -4.18474199e-03f, -1.94781777e-02f, 3.23123559e-02f, 1.43170916e-02f, -6.21821173e-02f, -4.89223488e-02f,
  -3.25295739e-02f, -4.16624919e-02f, -1.03503028e-02f, -1.31593216e-02f, -2.70396285e-02f, 1.18672661e-02f, -3.00783012e-02f, 6.48444146e-02f, -1.56600755e-02f, 3.59031186e-02f,
  -2.86628902e-02f, 1.39365634e-02f, -3.88821326e-02f, -4.66006324e-02f, 5.23445792e-02f, -4.05557342e-02f, 1.70652650e-03f, 4.89277318e-02f, -1.44080017e-02f, 3.44764529e-04f,
  2.02248991e-02f, 1.32720452e-02f, -2.05993839e-02f, 1.71121228e-02f, -8.53127986e-03f, -2.00527348e-02f, 3.24762873e-02f, -3.99918705e-02f, -5.88687323e-02f, -4.08447869e-02f,
  7.31031299e-02f, 1.25533581e-01f, 2.68715508e-02f, -2.78893299e-02f, 4.61047068e-02f, 1.33838709e-02f, -3.63381766e-02f, 8.52046907e-03f, -6.32540695e-03f, 7.86432624e-02f,
  -2.15391974e-05f, -2.22043023e-02f, 8.99355952e-03f, 4.24009636e-02f, -2.36786064e-02f, -1.99170318e-02f, 4.50105369e-02f, 4.33612019e-02f, 7.80321434e-02f, 6.59492686e-02f,
  4.77242051e-03f, -1.23739932e-02f, -2.89757131e-03f, 1.27576170e-02f, 5.95270991e-02f, 4.47772145e-02f, -5.45321703e-02f, -1.18295159e-02f, 8.70423317e-02f, 3.29746678e-02f,
  2.72185504e-02f, -1.90535709e-01f, -8.11098441e-02f, -3.18821296e-02f, 2.10968778e-01f, 2.57893682e-01f, 2.24097937e-01f, 1.57006159e-02f, 2.49941573e-02f, -1.24661475e-01f,
  1.44065857e-01f, -1.26582220e-01f, -4.45803963e-02f, 2.97070444e-02f, 2.72093266e-01f, -4.55331951e-02f, 1.19128160e-01f, -5.79890003e-03f, -9.43958163e-02f, 2.39047259e-02f,
  7.10332692e-02f, 1.62147701e-01f, 1.11561818e-02f, -7.06423819e-02f, 6.65235668e-02f, -1.39342919e-01f, 3.32899578e-03f, -1.28661662e-01f, 4.24736142e-02f, 7.19487444e-02f,
  8.56686160e-02f, -8.51108879e-02f, 9.01765153e-02f, -2.96136551e-03f, -5.34376130e-02f, -3.72696333e-02f, -1.55234328e-02f, 6.06962619e-03f, 6.68301284e-02f, 4.80657397e-03f,
  -2.19744258e-02f, 6.72356933e-02f, 7.03968927e-02f, 1.21783605e-02f, 1.81151051e-02f, -3.14936191e-02f, 9.27833617e-02f, 8.28136969e-03f, 3.62454616e-02f, 1.54501321e-02f,
  -7.01645538e-02f, 2.14863159e-02f, 5.39536290e-02f, -6.33143410e-02f, 3.70031223e-02f, -1.53043009e-02f, -5.87348491e-02f, 2.60308925e-02f, 7.80399740e-02f, -4.60063629e-02f,
  -2.10474487e-02f, -9.06828493e-02f, 8.87074694e-03f, 2.14456823e-02f, -9.00141615e-03f, 5.56066483e-02f, -3.66363153e-02f, -2.50715557e-02f, -4.34181020e-02f, -3.42919677e-02f,
  -4.16774228e-02f, 6.60996661e-02f, -3.69123705e-02f, -5.41326143e-02f, 8.34428356e-04f, 5.04371375e-02f, -5.23644015e-02f, 5.34218960e-02f, -3.29368226e-02f, 6.60215737e-04f,
  -6.05428219e-02f, 5.08570671e-02f, 1.83094218e-02f, -2.86291540e-02f, -3.38243172e-02f, 3.08310762e-02f, 1.23124933e-02f, 4.53970861e-03f, 3.51051763e-02f, -2.29525138e-02f,
  -2.01304238e-02f, -1.43280089e-01f, -9.52383131e-03f, 8.18364918e-02f, -8.50283131e-02f, -8.58150497e-02f, 4.43434641e-02f, -4.52045836e-02f, -8.49030390e-02f, 3.42448279e-02f,
  1.22507047e-02f, -8.75255764e-02f, -5.28406575e-02f, 4.15934995e-02f, 2.76174638e-02f, 6.09073648e-03f, -4.70937304e-02f, -3.54828462e-02f, 7.90765136e-03f, -5.04359975e-03f,
  2.49763969e-02f, -8.27038381e-03f, 7.08259316e-03f, 8.29346031e-02f, -4.07923013e-02f, -7.53340796e-02f, 6.55511692e-02f, 1.70353800e-02f, 7.10992888e-02f, -3.19072939e-02f,
  7.21344501e-02f, 4.54235315e-01f, 9.76343080e-02f, 2.97696978e-01f, -2.73958966e-02f, 4.89286035e-02f, -1.60973296e-02f, 2.68031776e-01f, 2.50192493e-01f, 2.42074430e-01f,
  -6.38779998e-02f, 2.20919907e-01f, -1.81371495e-02f, 1.77282408e-01f, 2.76692249e-02f, 1.49531513e-01f, 2.70306021e-01f, 1.01800591e-01f, -1.72050260e-02f, 8.05167779e-02f,
  8.45154077e-02f, 1.17116712e-01f, 2.86577065e-02f, 9.80769657e-03f, 9.58993137e-02f, 1.12059437e-01f, 2.72744708e-02f, -1.48519173e-01f, -1.10816834e-02f, -8.39338303e-02f,
  -1.08266018e-01f, 1.16953969e-01f, 3.16607654e-02f, 2.60503069e-02f, 1.32764261e-02f, 7.48161739e-03f, -5.01593053e-02f, -1.15955256e-01f, -6.69906959e-02f, 3.66686247e-02f,
  -2.75999289e-02f, 5.07864617e-02f, -2.00831573e-02f, -2.23053303e-02f, 6.17008917e-02f, -3.26737240e-02f, 3.15881819e-02f, -5.83270565e-02f, 2.01016515e-02f, 6.41609952e-02f,
  -3.66375339e-03f, -2.09779069e-02f, -1.50844119e-02f, 1.51787093e-02f, 1.92676596e-02f, 3.21531016e-03f, 1.99937597e-02f, -5.63348792e-02f, 1.40999500e-02f, 6.35449812e-02f,
  6.87902644e-02f, 1.03296032e-02f, 6.50366396e-02f, -5.66544086e-02f, 5.01133129e-02f, -1.05999917e-01f, -2.98591461e-02f, -3.97834592e-02f, 1.52986767e-02f, 1.83133595e-03f,
  4.89806682e-02f, 2.38791704e-02f, 2.46724356e-02f, 3.09023857e-02f, -4.31236550e-02f, 5.38251316e-03f, 7.86360353e-03f, 1.76583957e-02f, 3.76202017e-02f, -4.87494282e-02f,
  -6.50613289e-03f, -2.76024826e-02f, 1.97049826e-02f, -2.45431531e-02f, 2.76055150e-02f, -1.29393758e-02f, 1.68336499e-02f, 1.19301639e-02f, -3.49092484e-02f, -2.66836490e-02f,
  1.92999020e-01f, 2.55722761e-01f, 3.60057130e-02f, 2.63632573e-02f, 1.15449578e-02f, -4.52819727e-02f, 1.91973820e-02f, 1.00092866e-01f, 5.41352406e-02f, -4.08114381e-02f,
  -1.77319460e-02f, -2.54009701e-02f, 5.08872755e-02f, 2.30657719e-02f, 3.03223077e-02f, -1.99995637e-02f, 5.44958189e-02f, -2.34239344e-02f, -2.83651613e-02f, 4.57006656e-02f,
  4.99722511e-02f, 1.99064575e-02f, -1.16591221e-02f, 3.59906256e-02f, 1.29713686e-02f, -4.37462479e-02f, 7.68246129e-02f, 2.52169743e-03f, 3.05241514e-02f, 6.06549159e-02f,
  -1.28247499e-01f, 1.88494056e-01f, 1.73810065e-01f, 1.60437971e-01f, -1.67837869e-02f, -1.31151676e-01f, -8.27305317e-02f, 1.18849598e-01f, 3.32526118e-01f, -3.18756253e-02f,
  -1.46548942e-01f, 3.61197293e-02f, -7.93841295e-03f, 2.46432088e-02f, -9.49470997e-02f, 1.06972091e-01f, 7.80778518e-03f, -5.79313524e-02f, 1.58590853e-01f, 7.42778033e-02f,
  6.76748678e-02f, -7.52935708e-02f, -8.91714171e-03f, 1.32640690e-01f, -4.59650233e-02f, 8.82234052e-02f, -1.73511595e-01f, 3.49366441e-02f, -5.74470758e-02f, -9.98558700e-02f,
  3.74247087e-03f, 9.22195017e-02f, 1.03164352e-01f, 7.56598338e-02f, -6.48228377e-02f, -6.24784268e-02f, -7.44543523e-02f, -1.02415912e-01f, 4.54524010e-02f, 1.55202942e-02f,
  -1.45155238e-02f, 3.92725952e-02f, -4.76382673e-02f, 9.87640116e-03f, 1.69537757e-02f, 2.01114416e-02f, -5.89312054e-03f, -1.29283508e-02f, 1.46742612e-02f, -3.71589325e-03f,
  1.03071872e-02f, 2.31056772e-02f, -6.33857101e-02f, 2.44528763e-02f, 1.79921999e-03f, -3.75661836e-03f, -1.02100009e-02f, -3.74426432e-02f, -1.08331749e-02f, -5.45815937e-02f,
  2.98197439e-04f, 7.49089122e-02f, 4.38467152e-02f, 2.93531492e-02f, 2.67636422e-02f, 1.40782893e-02f, -3.25896847e-03f, -7.10038142e-03f, 5.15728816e-02f, -2.26255581e-02f,
  3.33024724e-03f, 4.39206883e-02f, 6.48245737e-02f, 4.24279794e-02f, -2.99207903e-02f, 3.86497378e-02f, -2.32010446e-02f, -4.81175166e-03f, -2.45868601e-02f, 3.11124651e-03f,
  3.32183056e-02f, 8.45016073e-03f, 3.45975012e-02f, -2.22283266e-02f, -3.00854631e-02f, 3.68500166e-02f, 2.36038724e-03f, 4.08098698e-02f, -3.41277979e-02f, -5.20189069e-02f,
  -1.15948103e-01f, 4.48379777e-02f, 7.46573210e-02f, 2.55733505e-02f, 6.86813444e-02f, -6.44392222e-02f, 3.57454605e-02f, 7.74054527e-02f, -4.14058864e-02f, 2.34369002e-02f,
  -1.11980975e-01f, -2.91416738e-02f, 4.44498360e-02f, 3.41700427e-02f, -1.75424553e-02f, 5.67055643e-02f, 6.23053797e-02f, -3.20454105e-03f, -6.66549196e-04f, -2.94665601e-02f,
  -2.10289471e-02f, 1.04621509e-02f, 5.30451573e-02f, 4.65150476e-02f, -1.86956930e-03f, -5.45443296e-02f, 5.16306935e-03f, -7.53895874e-05f, -6.41276836e-02f, 5.35513647e-02f,
  5.58225393e-01f, -8.67613852e-02f, -9.62519646e-02f, 9.61464643e-02f, 1.45167753e-01f, -5.07039949e-02f, -4.13361890e-03f, 7.04932958e-02f, 3.49706039e-02f, -1.37007669e-01f,
  -3.61894518e-02f, 1.14709154e-01f, -2.46951580e-01f, -9.86123979e-02f, 1.96422622e-01f, -1.95003346e-01f, -3.57240327e-02f, 3.99366952e-03f, -6.73214495e-02f, 2.82105431e-02f,
  4.11632583e-02f, -3.45908105e-02f, -6.12011701e-02f, -9.55500156e-02f, 7.49174878e-02f, -7.60875689e-03f, 8.08794275e-02f, -1.05334677e-01f, 1.01764826e-02f, -3.16671282e-02f,
  1.28376961e-01f, -1.90910641e-02f, -4.57090139e-03f, -1.62491519e-02f, 1.15372293e-01f, 1.95883904e-02f, 1.39765926e-02f, -1.17876746e-01f, -4.95375833e-04f, -5.64088449e-02f,
  1.56991556e-02f, 3.03408783e-02f, 6.39225468e-02f, -6.48350567e-02f, 9.02216360e-02f, -8.30071513e-03f, 2.34291758e-02f, 4.63885861e-03f, -9.18872356e-02f, -1.10879764e-02f,
  -1.87095031e-02f, 2.17582397e-02f, 1.51758026e-02f, -3.63221280e-02f, 9.17848200e-03f, 1.26956776e-02f, -1.64645705e-02f, -1.51893799e-03f, 4.28771228e-02f, 8.96901563e-02f,
  -4.02171165e-03f, 2.61702035e-02f, -6.94282427e-02f, 3.46654244e-02f, -5.56923747e-02f, 7.40038278e-03f, -2.98881670e-03f, 6.10261299e-02f, 9.96444396e-06f, 3.95460799e-02f,
  1.10104335e-02f, 6.66345954e-02f, -1.49265798e-02f, 3.52003612e-02f, 1.98811553e-02f, 2.44175252e-02f, -2.56545283e-02f, 1.71588995e-02f, -3.81182675e-04f, 6.45546839e-02f,
  7.14399200e-03f, 4.83165756e-02f, 9.69340652e-03f, -1.81817394e-02f, 1.60129592e-02f, 4.80910856e-03f, 5.73354634e-03f, -3.10333204e-02f, -4.25721481e-02f, 2.67029684e-02f,
  1.70211360e-01f, 1.42395601e-01f, -9.72502306e-02f, 6.09657392e-02f, -8.45567361e-02f, 1.43305417e-02f, -5.22971004e-02f, 4.83313836e-02f, -4.80689928e-02f, 7.46908635e-02f,
  6.65273191e-03f, 5.00796922e-02f, 7.68573806e-02f, 2.69041639e-02f, -5.61563075e-02f, 4.79656234e-02f, -3.05369520e-03f, 6.80165133e-03f, 1.05054535e-01f, -2.58731600e-02f,
  2.21148655e-02f, 8.82183760e-03f, 3.13986987e-02f, 2.27516647e-02f, -3.41625535e-03f, 2.45001428e-02f, 7.39240572e-02f, -5.28985634e-02f, 4.24140692e-02f, -4.12412174e-02f,
  1.38831407e-01f, -1.82320833e-01f, 4.78520431e-02f, -4.14854228e-01f, -5.25158737e-03f, 1.46395341e-01f, -1.70773603e-02f, -8.78457353e-02f, -2.44881541e-01f, -9.57384408e-02f,
  -7.82984048e-02f, 1.16974168e-01f, -1.69781912e-02f, -1.90430999e-01f, 1.87705919e-01f, -2.60531949e-03f, -1.33268952e-01f, -4.72343527e-03f, -9.50496346e-02f, -1.11309439e-01f,
  -8.76137763e-02f, -1.27489313e-01f, -3.61559764e-02f, -6.29381612e-02f, 3.55098508e-02f, -5.76442033e-02f, -1.17366388e-01f, 6.68456703e-02f, -1.23739436e-01f, 1.41305849e-01f,
  6.00208007e-02f, -3.26118656e-02f, -3.21744196e-02f, -6.35789521e-03f, -1.82788651e-02f, 1.08161464e-01f, 2.03572772e-02f, 5.67353927e-02f, -1.15026934e-02f, -4.70863692e-02f,
  4.60187308e-02f, 1.48120914e-02f, -2.53883842e-02f, 2.94727683e-02f, -1.35757271e-02f, -2.85242405e-02f, 1.43733313e-02f, 2.91081052e-02f, 1.40967304e-02f, 1.03563376e-01f,
  3.74621265e-02f, 3.55977193e-02f, -9.74419713e-02f, -5.01128286e-02f, -3.06354333e-02f, -6.82499930e-02f, -9.36586875e-03f, 2.26105954e-02f, -7.54654221e-03f, -8.99363011e-02f,
  9.23395380e-02f, -1.96993928e-02f, 2.13054195e-02f, 3.16730961e-02f, -6.61139190e-02f, 9.29473341e-03f, -5.68429641e-02f, 2.56640818e-02f, -2.27148961e-02f, -3.85834239e-02f,
  -3.98689732e-02f, -3.20767872e-02f, -4.27476540e-02f, -3.85411258e-04f, -7.04776272e-02f, 7.15070346e-05f, 6.77419454e-02f, 9.70744411e-04f, -3.48975486e-03f, 2.70679053e-02f,
  -4.42693084e-02f, -3.15862745e-02f, 5.84932091e-03f, 2.53745611e-03f, 3.12031936e-02f, 5.42679094e-02f, -2.27394253e-02f, -1.20523628e-02f, -8.58691987e-03f, 2.55575348e-02f,
  -7.20931962e-02f, -1.71988949e-01f, 4.29839827e-02f, 3.98463495e-02f, 2.13259868e-02f, -2.33442709e-02f, 8.34676903e-03f, 3.53409462e-02f, -3.49123334e-03f, 1.22455612e-03f,
  7.02988580e-02f, 8.87286011e-03f, 7.43391290e-02f, 1.15410620e-02f, -2.95480480e-03f, 1.71993822e-02f, -2.39381418e-02f, -4.07763906e-02f, -3.28428298e-02f, 4.69413660e-02f,
  1.35417059e-02f, -3.12025077e-03f, 4.70214635e-02f, -1.82494335e-02f, -4.81927507e-02f, 3.18191983e-02f, 1.76462270e-02f, -6.55712606e-03f, 8.09543058e-02f, -4.87623643e-03f,
  -4.05903459e-02f, -9.15551037e-02f, -9.28192735e-02f, 1.69480801e-01f, 1.49739936e-01f, 1.11742795e-01f, 1.72045738e-01f, 1.91863835e-01f, 3.09109271e-01f, -6.02959767e-02f,
  8.67074504e-02f, -6.10775836e-02f, -1.34289637e-01f, 1.70137078e-01f, 1.32727206e-01f, 1.06627673e-01f, 1.44411862e-01f, -8.16273596e-03f, 6.43661916e-02f, 8.62923861e-02f,
  1.57224774e-01f, 2.43599042e-01f, 6.86036348e-02f, -5.14336005e-02f, -2.41132770e-02f, -6.08833358e-02f, -4.93298694e-02f, -1.24498717e-01f, -5.46695590e-02f, -1.15984604e-01f,
  -9.89352465e-02f, 4.30431329e-02f, -5.68360947e-02f, -9.73581597e-02f, -4.20882516e-02f, -4.22748551e-02f, -1.25065356e-01f, -9.89082605e-02f, 1.28826033e-02f, 3.93714942e-02f,
  -4.52728570e-03f, -5.96055239e-02f, 1.23707168e-01f, 1.15853129e-02f, 4.18358333e-02f, 3.25984173e-02f, -1.33448886e-02f, -2.54799426e-02f, 3.23926806e-02f, 8.11299309e-02f,
  3.46392579e-02f, 2.17324942e-02f, -1.84785444e-02f, 3.68305892e-02f, 3.53418514e-02f, 9.01191160e-02f, 8.35791305e-02f, -3.66312824e-02f, -6.02263175e-02f, 5.48741780e-02f,
  2.64330693e-02f, -3.51350270e-02f, 2.80055795e-02f, 3.70497219e-02f, 5.13779512e-03f, 2.88925935e-02f, 3.78659815e-02f, 1.86892692e-02f, -3.69116850e-02f, 4.90874834e-02f,
  -7.73625635e-03f, 6.75759166e-02f, 1.03995542e-03f, -6.51744753e-03f, 4.99493442e-03f, 3.51001620e-02f, -4.15235534e-02f, 6.05319487e-03f, 5.69795929e-02f, 2.48260833e-02f,
  3.54363620e-02f, -2.04370189e-02f, 2.59929523e-02f, -3.58766913e-02f, 1.76528341e-03f, 3.82186919e-02f, -1.91045627e-02f, -1.66448988e-02f, -3.98150422e-02f, -8.21134970e-02f,
  -1.59710884e-01f, -1.17720485e-01f, 3.42925312e-03f, -4.68256883e-02f, -9.08140913e-02f, 2.37854943e-02f, -5.59867397e-02f, 4.96372916e-02f, -6.35902360e-02f, 4.40224707e-02f,
  -7.07538277e-02f, 5.95687469e-03f, -7.18004704e-02f, 7.16379564e-03f, 9.31056216e-03f, 9.28771272e-02f, 2.67858319e-02f, 4.63814801e-03f, -1.52492682e-02f, -5.67232259e-02f,
  -4.23383154e-02f, -5.13509288e-02f, 1.00896247e-02f, 1.26636671e-02f, 1.91133860e-02f, -3.81651409e-02f, -5.44146597e-02f, -5.97122759e-02f, 1.73923206e-02f, 4.41077538e-02f,
  2.19178155e-01f, 2.03955606e-01f, 3.14083844e-01f, 1.45770475e-01f, -1.64948061e-01f, 5.19141331e-02f, 2.22412586e-01f, 2.92197019e-02f, 2.46685371e-01f, 3.65749858e-02f,
  -1.12831630e-01f, 2.40132838e-01f, 1.70940198e-02f, 4.87319678e-02f, 4.26774323e-02f, 4.20363583e-02f, -1.37289122e-01f, 1.44418294e-03f, 3.64955179e-02f, -7.40751848e-02f,
  -2.63471864e-02f, -2.54976958e-01f, 5.57296015e-02f, -1.86349750e-01f, 3.19882594e-02f, 2.06388123e-02f, -2.08012596e-01f, -6.96622729e-02f, -1.38355032e-01f, -5.83121888e-02f,
  3.40096243e-02f, 3.76964845e-02f, -2.30376087e-02f, 7.04741627e-02f, -2.50098612e-02f, -5.33901192e-02f, -1.30467676e-02f, 5.33328950e-02f, 6.73087430e-04f, -2.37271767e-02f,
  9.99924354e-03f, 2.80238260e-02f, 3.41896154e-02f, 2.45195930e-03f, 3.43011692e-02f, 5.45731224e-02f, -1.98167227e-02f, 4.68345210e-02f, 8.67322367e-03f, -2.71186996e-02f,
  9.18543786e-02f, 4.59778961e-03f, -9.50161833e-03f, -1.24308690e-02f, -1.36075579e-02f, 2.14536190e-02f, 5.36309332e-02f, 5.83563335e-02f, -7.19786249e-03f, -2.25535850e-03f,
  -4.95080277e-03f, -6.28251433e-02f, 2.97992192e-02f, -1.63326208e-02f, -4.36599692e-03f, -2.31362469e-02f, 9.23041807e-05f, -1.88501533e-02f, -7.85729103e-03f, -4.08884138e-02f,
  6.21357746e-02f, -2.08277274e-02f, 1.70416827e-03f, -5.26813753e-02f, 1.87754468e-03f, -2.82439608e-02f, -2.85800714e-02f, 1.16046425e-02f, 4.40906733e-02f, -7.03039467e-02f,
  -1.23749077e-02f, 4.61656507e-03f, -4.62525673e-02f, -1.13402158e-02f, 3.13658379e-02f, 2.67172419e-02f, -4.63135988e-02f, 5.67873716e-02f, -1.74075942e-02f, -2.42142063e-02f,
  1.53485872e-02f, -8.24236497e-02f, 4.22841534e-02f, -2.62267850e-02f, -1.73737276e-02f, -6.54013157e-02f, 9.27485246e-03f, -3.05730980e-02f, 1.95628125e-02f, 1.82610843e-02f,
  -3.75530757e-02f, -3.35570797e-02f, -6.28264025e-02f, -3.06771919e-02f, 6.06771652e-03f, -6.63316995e-02f, -4.28544022e-02f, -2.91378424e-02f, -4.11292957e-03f, 5.49782440e-03f,
  -1.09105378e-01f, -1.90814435e-02f, -8.79725255e-03f, -1.80658913e-04f, 7.50579685e-03f, 3.92731316e-02f, -1.48494672e-02f, 7.87838325e-02f, -8.19115043e-02f, 1.28402710e-02f,
  2.86101520e-01f, 1.74334154e-01f, 7.64859244e-02f, 1.02286637e-01f, 5.78388870e-02f, -1.26861706e-01f, -1.79846421e-01f, 8.86728466e-02f, -1.92265779e-01f, 4.28539813e-02f,
  8.88697729e-02f, 6.46735076e-03f, -8.37935954e-02f, -2.60078702e-02f, -3.01295131e-01f, -2.77834117e-01f, -8.92355442e-02f, -5.83630092e-02f, -4.34972793e-02f, 1.62873939e-01f,
  -4.63824831e-02f, 4.77398746e-02f, 2.83151790e-02f, 1.10741019e-01f, 2.06882358e-01f, 1.32306829e-01f, 4.47607003e-02f, -1.12147760e-02f, 1.93621069e-01f, -1.43438457e-02f,
  1.36560813e-01f, 7.77150691e-02f, 3.58486287e-02f, -4.50995304e-02f, 2.72619538e-03f, 5.12675643e-02f, 1.04707130e-03f, -9.36122686e-02f, 2.03071069e-02f, -1.95576586e-02f,
  5.96744008e-03f, 6.30407706e-02f, -2.06517037e-02f, -9.39401388e-02f, -1.47437295e-02f, -3.49834859e-02f, -2.51712482e-02f, 1.77868840e-03f, 6.40995726e-02f, -2.11005006e-02f,
  6.86376691e-02f, 3.12648080e-02f, -3.67265753e-02f, 4.33597248e-03f, -2.26927623e-02f, -6.89625368e-02f, -4.49281521e-02f, 5.31465486e-02f, 6.94075227e-02f, -4.75183055e-02f,
  -4.16153967e-02f, -3.69532183e-02f, 1.42906758e-03f, 1.01712070e-01f, 7.55765885e-02f, 7.86791295e-02f, -2.55539734e-02f, 2.92649623e-02f, -4.43015853e-03f, 5.93978390e-02f,
  4.19088043e-02f, 5.39741628e-02f, 2.45908126e-02f, 1.36767374e-03f, -1.85966045e-02f, -1.28800124e-02f, -5.84063344e-02f, 1.10669704e-02f, -8.18085019e-03f, 7.64374882e-02f,
  -5.90171712e-03f, -4.21604514e-02f, 9.45467316e-03f, 2.46749949e-02f, -8.09141397e-02f, -2.99191438e-02f, -2.61617322e-02f, -3.52521008e-03f, -2.53215767e-02f, -2.54887193e-02f,
  8.53909587e-04f, 1.54388770e-01f, -6.21308237e-02f, -4.59425151e-02f, 4.16240990e-02f, -5.50498292e-02f, -7.66926780e-02f, -2.63078455e-02f, -1.78002771e-02f, -8.52650777e-02f,
  6.30582571e-02f, 4.61589396e-02f, 5.76416515e-02f, -3.07977144e-02f, 2.39094645e-02f, -4.41659354e-02f, -1.99323073e-02f, 4.99861576e-02f, 1.72086433e-02f, 7.63901994e-02f,
  5.15443981e-02f, -6.68361783e-02f, 9.73434094e-03f, 4.55321223e-02f, 3.86828929e-02f, -1.66304447e-02f, -5.16871810e-02f, 2.50866674e-02f, 4.15253639e-03f, -1.74360275e-02f,
  5.50344050e-01f, -2.33822465e-01f, 2.49914601e-02f, 2.94658691e-01f, 2.61124045e-01f, -5.68847097e-02f, 1.79767702e-02f, 4.76035215e-02f, 6.72418028e-02f, -2.20824257e-01f,
  -1.63349342e-02f, 2.90358588e-02f, -1.90897688e-01f, -7.13183032e-03f, 1.78506106e-01f, -2.75319517e-01f, -3.62969190e-02f, 3.53397131e-02f, -5.30109704e-02f, 1.59174114e-01f,
  1.80160910e-01f, 1.04783820e-02f, -6.71777874e-02f, -8.07944834e-02f, 9.71603319e-02f, 7.72618428e-02f, 1.14838183e-01f, -9.28760991e-02f, 9.09878463e-02f, 1.00163240e-02f,
  -4.25447971e-02f, -9.76994634e-02f, 5.05886413e-02f, -4.43793386e-02f, 4.50200476e-02f, 3.37968171e-02f, 1.30782807e-02f, 1.16362143e-02f, 5.42979874e-02f, 1.43873310e-02f,
  -9.85890161e-03f, 2.97574606e-02f, -9.29749105e-03f, -2.80468501e-02f, 2.08372809e-02f, 5.75716533e-02f, 4.01542112e-02f, 3.57261859e-02f, -1.96926538e-02f, 4.35725000e-04f,
  -1.82932466e-02f, 2.13680547e-02f, 6.36537969e-02f, -1.41507220e-02f, 8.04066509e-02f, -4.08760011e-02f, -1.86383147e-02f, 3.47038470e-02f, -1.39975650e-02f, 4.72406931e-02f,
  -8.38899799e-03f, -2.06633639e-02f, -8.06602882e-04f, -9.89979953e-02f, 4.69242111e-02f, 5.19961305e-03f, -2.95130182e-02f, -5.19581931e-03f, -3.59334201e-02f, 3.79534252e-02f,
  2.27696765e-02f, 3.89304534e-02f, -3.96471322e-02f, -1.32280951e-02f, 3.58235799e-02f, 3.41364518e-02f, -6.92043500e-03f, 2.33089197e-02f, 3.06626055e-02f, 4.90018576e-02f,
  -5.09942025e-02f, 5.71313873e-02f, -1.78744309e-02f, 3.95070054e-02f, -7.23461360e-02f, 4.93174605e-02f, -4.31519793e-03f, -1.25085600e-02f, 1.33692762e-02f, 8.12200946e-04f,
  -4.47651483e-02f, -5.95542565e-02f, -4.20768633e-02f, -2.51911972e-02f, -9.17365178e-02f, 4.86166626e-02f, -7.38920197e-02f, -3.86928837e-03f, -1.06165614e-02f, 1.64607242e-02f,
  8.02666172e-02f, -2.35559661e-02f, 1.35349063e-02f, 5.17337285e-02f, -6.46693306e-03f, -2.31309533e-02f, 3.16356234e-02f, -5.95326535e-03f, 2.01347694e-02f, 6.22144826e-02f,
  1.02436123e-02f, 5.78659549e-02f, -2.72160172e-02f, 5.85199296e-02f, 3.08443531e-02f, 4.80525121e-02f, 5.70028909e-02f, 1.94165204e-02f, 2.92663812e-03f, -3.67762633e-02f,
  -1.84907719e-01f, 1.02116399e-01f, -4.08351906e-02f, 1.41674846e-01f, -1.23955294e-01f, -3.41018558e-01f, -8.72525573e-02f, -8.36370792e-03f, 2.28663301e-03f, 1.67591199e-01f,
  6.32498860e-02f, 5.64138852e-02f, 2.57030074e-02f, 6.87794983e-02f, -2.54282266e-01f, -6.32794574e-02f, -1.24333449e-01f, -8.13502148e-02f, -9.96314585e-02f, 2.09969133e-02f,
  -2.96441000e-02f, 1.01010375e-01f, -5.16036712e-02f, 1.01252943e-02f, -9.34147835e-02f, 1.38693750e-01f, 2.09123455e-02f, -1.39570516e-02f, 1.12644859e-01f, -5.34274951e-02f,
  -5.68772517e-02f, 2.33112928e-02f, 9.47920233e-02f, -4.50702421e-02f, -5.73506430e-02f, 3.68745513e-02f, -7.65739335e-03f, -9.34004039e-02f, -6.26067519e-02f, 1.43535491e-02f,
  3.45879681e-02f, -3.70143130e-02f, 3.62015516e-02f, 4.51169014e-02f, -4.54289094e-02f, -4.02453206e-02f, 3.55320307e-03f, 7.02456862e-04f, 6.00276962e-02f, 1.44774076e-02f,
  2.43791658e-02f, -4.12159041e-02f, 3.34075689e-02f, -2.40684114e-02f, -5.46258427e-02f, -3.90746864e-03f, -1.12557389e-01f, 1.55780045e-02f, 2.40737461e-02f, 1.24294432e-02f,
  -1.59591567e-02f, -3.61790359e-02f, 1.55895464e-02f, -2.08852757e-02f, -2.30918042e-02f, 1.53362034e-02f, 6.88530132e-02f, -2.99413409e-02f, -4.98736612e-02f, 1.55447293e-02f,
  1.54259568e-02f, -2.64155236e-03f, 3.83835845e-02f, -3.56315263e-02f, -3.54886837e-02f, 6.53176606e-02f, -1.56703163e-02f, 1.28735621e-02f, 2.87715433e-04f, -6.04259558e-02f,
  -8.43897433e-05f, -4.10313644e-02f, 2.68049259e-02f, -3.57381031e-02f, -2.27463242e-05f, 3.94482762e-02f, 2.70219035e-02f, -2.41934061e-02f, -4.89948541e-02f, -2.61515509e-02f,
  -9.90406871e-02f, 1.14753954e-01f, 1.07036814e-01f, 9.37629715e-02f, -9.47432779e-03f, -7.90391266e-02f, -2.45154928e-02f, 6.65644463e-03f, -2.35853959e-02f, -4.66220453e-02f,
  5.01667298e-02f, -1.47761516e-02f, -3.48684303e-02f, -1.07625313e-01f, 3.22584547e-02f, -2.47162767e-02f, 2.90434640e-02f, 2.42950357e-02f, 1.24235712e-02f, 4.16756831e-02f,
  2.57925633e-02f, -5.22069708e-02f, 3.19471769e-02f, 5.22816479e-02f, 7.88261220e-02f, 2.19483711e-02f, 5.57069145e-02f, -4.05059308e-02f, -3.32675315e-02f, 1.75221581e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.25096241e-01f, 5.01386560e-02f, -8.91787484e-02f, -5.42868339e-02f, -1.90772519e-01f, 7.41173923e-02f, 4.04492132e-02f, -1.82608292e-02f, -3.31049296e-03f, 9.48099047e-02f,
  3.16791646e-02f, 8.34633857e-02f, 1.13853909e-01f, 8.44187960e-02f, 3.70886363e-02f, 1.19161762e-01f, 5.81278875e-02f, -7.07035791e-03f, 3.58011611e-02f, 1.11397453e-01f,
  -8.81659091e-02f, 1.39226034e-01f, 3.34299654e-02f, 9.52074712e-04f, 9.85623375e-02f, -4.95374240e-02f, -1.12498514e-01f, 1.87411718e-02f, 5.66652417e-02f, -8.76773670e-02f,
  9.48439240e-02f, -9.53840732e-04f, -5.54249622e-02f, 4.09681350e-02f, 4.13263477e-02f, -7.25979060e-02f, 1.37721552e-02f, 8.57965201e-02f, 2.63997950e-02f, -7.51245767e-02f,
  -4.80828471e-02f, -3.13553996e-02f, 6.97340593e-02f, 4.29713391e-02f, -5.09418249e-02f, 1.61981452e-02f, -6.64800778e-02f, 4.11192812e-02f, 3.50887142e-02f, -4.33334000e-02f,
  3.52289863e-02f, 5.39592728e-02f, 5.75058162e-02f, -2.35918872e-02f, 2.24721748e-02f, 7.40291104e-02f, 3.99262421e-02f, 5.12388311e-02f, 1.01650478e-02f, 6.52382672e-02f,
  8.26628506e-02f, 4.45273928e-02f, 9.82884243e-02f, -3.66679616e-02f, 2.17519458e-02f, 3.73699181e-02f, 1.56788919e-02f, -7.16934577e-02f, 7.00969622e-02f, 7.10982382e-02f,
  4.97910306e-02f, -2.61967555e-02f, 3.99163961e-02f, 8.82831365e-02f, 8.38664100e-02f, 3.06706149e-02f, 8.54304805e-02f, -8.95787477e-02f, 3.91710065e-02f, -4.07610983e-02f,
  -2.58082692e-02f, 7.34013245e-02f, 1.38222361e-02f, -9.35667232e-02f, -8.41045082e-02f, 6.46966416e-03f, 2.25561559e-02f, 4.46573123e-02f, 3.22979912e-02f, 4.28123958e-02f,
  -3.66707146e-02f, 1.35094225e-01f, 7.93782324e-02f, 8.77956003e-02f, 7.12187439e-02f, 4.78098243e-02f, 1.48551529e-02f, -3.62993628e-02f, -4.21682447e-02f, 4.13622968e-02f,
  6.67821392e-02f, 6.24693111e-02f, 4.67435420e-02f, -1.05003908e-01f, -2.47569457e-02f, 4.43470702e-02f, -2.58446522e-02f, -9.22305603e-03f, -4.66058552e-02f, -2.25106645e-02f,
  -1.06833883e-01f, 6.14474714e-02f, -9.58433188e-03f, 4.68622893e-02f, -3.22814193e-03f, -1.02123804e-02f, 1.46398554e-02f, 6.99794432e-03f, 1.41698797e-03f, -1.95149723e-02f,
  -7.54929706e-02f, -3.02440654e-02f, -2.58848608e-01f, -1.99663371e-01f, -1.00582585e-01f, -4.01181728e-01f, -3.16016912e-01f, -9.99442935e-02f, 9.17947814e-02f, 4.32935767e-02f,
  -9.57188755e-02f, 1.43714935e-01f, 1.09166123e-01f, -2.61751503e-01f, 7.32544297e-03f, 8.84705931e-02f, -3.61686468e-01f, -1.72789350e-01f, 1.18817776e-01f, -2.60724455e-01f,
  -2.74451599e-02f, -1.08943120e-01f, -2.23934621e-01f, -3.63467447e-02f, -2.60552406e-01f, 4.28710468e-02f, 8.17961060e-03f, -3.62504683e-02f, -2.22843274e-01f, -2.75502875e-02f,
  -8.25018436e-02f, 9.87995490e-02f, -2.23415736e-02f, -9.78493318e-03f, -1.24973387e-01f, -7.22215772e-02f, -2.33159792e-02f, 2.39210911e-02f, 5.73337823e-02f, -3.71681340e-02f,
  4.01544683e-02f, 6.92444816e-02f, -4.98913676e-02f, 1.19953185e-01f, -4.81722225e-03f, -1.23971356e-02f, 2.60625314e-03f, 1.09137632e-02f, 3.74404527e-02f, -5.74244522e-02f,
  -7.26250783e-02f, -8.78195018e-02f, -1.31765708e-01f, 3.04967631e-02f, -8.46387893e-02f, 1.81422625e-02f, -5.93068674e-02f, 3.37588191e-02f, -8.79014060e-02f, 8.02255329e-03f,
  -1.00083007e-02f, 5.34002446e-02f, -1.40627725e-02f, 2.00938471e-02f, -1.77078582e-02f, -2.00644787e-02f, -2.68279985e-02f, 4.20106985e-02f, -2.31488813e-02f, 7.78613426e-03f,
  3.12461760e-02f, -1.37232160e-02f, -2.45442102e-03f, -6.14255704e-02f, -7.14873150e-02f, 4.16506231e-02f, -4.77046818e-02f, 5.57039641e-02f, -1.35064155e-01f, 2.53437785e-03f,
  -2.13683947e-04f, 5.48483664e-03f, 5.59079833e-03f, -6.18643407e-03f, 4.14679460e-02f, 6.71267882e-02f, -1.96553580e-02f, 7.93064088e-02f, 9.87486076e-03f, -7.44393617e-02f,
  -2.28965674e-02f, -9.33089703e-02f, -8.73090886e-03f, 3.06441933e-02f, 2.20738444e-02f, -1.18655674e-01f, -7.43971616e-02f, -8.42063874e-02f, -4.05642502e-02f, -8.09544846e-02f,
  -1.09620973e-01f, 1.08176507e-02f, -2.70687276e-03f, -5.59117980e-02f, -1.00374985e-02f, -4.94495398e-05f, 2.40943573e-05f, -1.56790074e-02f, -3.44811082e-02f, -5.75042292e-02f,
  4.22525145e-02f, 7.81044830e-03f, 5.96998930e-02f, -4.47665667e-03f, 2.49296427e-02f, -8.53396133e-02f, -1.29093335e-03f, 6.97021261e-02f, 1.02685308e-02f, -1.69558544e-02f,
  1.68740880e-02f, -6.65602908e-02f, -1.17610700e-01f, -8.82642493e-02f, 1.78174246e-02f, -3.86741012e-02f, 1.65694281e-02f, 7.02039376e-02f, -1.21066064e-01f, -4.46365122e-03f,
  1.42867956e-02f, 5.33076795e-03f, -4.32114266e-02f, -4.46340516e-02f, 7.77014643e-02f, 4.58519980e-02f, 5.49651161e-02f, -5.90465218e-02f, 2.80216541e-02f, -3.56707647e-02f,
  7.74585977e-02f, 1.39874533e-01f, -2.90960334e-02f, 7.38411248e-02f, 4.74305600e-02f, -4.96415002e-03f, -2.54405327e-02f, 2.07211040e-02f, -2.43142396e-02f, -4.62152883e-02f,
  2.74110194e-02f, 5.96975647e-02f, -3.63136902e-02f, 7.44003206e-02f, 1.61012840e-02f, -2.40370538e-02f, 4.83892746e-02f, -6.84759244e-02f, -4.53531370e-02f, -7.21514449e-02f,
  1.16791315e-02f, -6.30721152e-02f, -5.69219552e-02f, 2.48465338e-03f, 8.23238865e-02f, 6.15619235e-02f, -4.69003431e-02f, -2.68832389e-02f, -3.13707106e-02f, 2.71875784e-02f,
  5.16050905e-02f, 2.35363990e-02f, 3.06306351e-02f, -4.84828241e-02f, 3.32226939e-02f, -1.87386125e-02f, 1.51731577e-02f, 7.87171200e-02f, -2.24326812e-02f, 5.98535351e-02f,
  -4.49390523e-02f, -6.55582994e-02f, -9.97315813e-03f, -2.24990528e-02f, -3.26840207e-02f, -2.25920733e-02f, -3.05115171e-02f, 6.10524490e-02f, -4.78777685e-04f, 7.68216252e-02f,
  4.12148517e-03f, -6.70581385e-02f, -2.40840297e-02f, 1.19900582e-02f, -1.77394897e-02f, -7.21236616e-02f, -1.41431615e-02f, 2.92512756e-02f, 5.54471426e-02f, 5.16770920e-03f,
  4.67524193e-02f, 3.13304216e-02f, 2.30946299e-02f, 1.81739703e-02f, -2.76596434e-02f, 8.72104501e-05f, -2.65246462e-02f, -5.02755977e-02f, -4.62908968e-02f, -6.67346343e-02f,
  -8.97556730e-03f, 1.28796499e-03f, -1.28205149e-02f, 2.44767847e-03f, -4.48708683e-02f, 6.70383424e-02f, -6.25382066e-02f, 2.72031687e-02f, 2.86228657e-02f, 4.66440469e-02f,
  5.03660217e-02f, -1.92651358e-02f, -6.88549429e-02f, -6.97850958e-02f, -7.24340901e-02f, 5.90459779e-02f, -5.06266430e-02f, -4.49034050e-02f, -4.37899157e-02f, 9.87154320e-02f,
  -2.87217889e-02f, -1.84611678e-02f, -1.53469592e-02f, -9.15718973e-02f, -7.06939623e-02f, -1.58275589e-02f, -6.42140722e-03f, 2.25649402e-02f, 3.01266443e-02f, 6.42992482e-02f,
  -5.04931509e-02f, -1.34200249e-02f, 7.18777701e-02f, 8.12868960e-03f, -1.71348035e-01f, -2.46225744e-01f, -9.54005048e-02f, 9.20687467e-02f, -4.21921313e-02f, 1.79908145e-02f,
  -6.39018491e-02f, -3.64024155e-02f, 4.11608219e-02f, 8.71453360e-02f, -2.76624952e-02f, -8.42436776e-03f, -6.77642506e-03f, 8.62323493e-03f, 2.29287762e-02f, 3.12503539e-02f,
  2.08835810e-01f, -2.45155450e-02f, 9.41494629e-02f, 1.56446099e-01f, -3.30562284e-03f, 1.98865831e-01f, 2.26195350e-01f, 1.16661415e-02f, 9.75339189e-02f, -8.13916698e-03f,
  -8.09053630e-02f, 9.86832529e-02f, 5.40168993e-02f, -9.27489251e-02f, 7.57565647e-02f, -7.25362450e-02f, 7.23084733e-02f, 2.73510795e-02f, -4.56625633e-02f, 9.30827036e-02f,
  -7.34764487e-02f, -2.77271681e-02f, 6.05878346e-02f, 2.05569831e-03f, 3.18876319e-02f, -4.06442583e-02f, 7.68977553e-02f, 2.26204898e-02f, -4.58545759e-02f, 8.18132609e-02f,
  -5.91504388e-02f, 2.39095464e-02f, -5.90074668e-03f, 1.92979574e-02f, -1.83167364e-02f, 5.34471869e-02f, 1.63488258e-02f, -1.60432272e-02f, 4.33537625e-02f, 5.16307503e-02f,
  -3.07115726e-03f, -5.73644154e-02f, 3.65150236e-02f, -6.07409002e-03f, -2.72893868e-02f, -2.30759364e-02f, -6.74977675e-02f, 6.16570190e-02f, -1.57377776e-02f, -4.36334722e-02f,
  -2.71566249e-02f, 6.67092800e-02f, -6.00565448e-02f, 7.71933794e-02f, -6.29450157e-02f, 4.91828807e-02f, -4.15378138e-02f, 6.11971021e-02f, -5.82286678e-02f, 8.95393491e-02f,
  -3.18944491e-02f, 8.88425019e-03f, -2.22096890e-02f, -6.13038056e-02f, -8.27242360e-02f, 4.45281565e-02f, 4.31742407e-02f, 3.89987081e-02f, -2.16176864e-02f, 1.23272575e-02f,
  -3.34665067e-02f, 9.29203480e-02f, 5.26956171e-02f, -4.65858169e-02f, -1.35752792e-02f, -7.41609409e-02f, 3.39283282e-03f, 5.53831980e-02f, 8.79939497e-02f, -1.57804005e-02f,
  -5.49466796e-02f, 7.50799999e-02f, -8.06619599e-02f, 6.14755936e-02f, 2.16232017e-02f, -1.93122979e-02f, -3.40156443e-02f, 3.08237150e-02f, 1.31872706e-02f, -2.20953003e-02f,
  7.92485252e-02f, -9.47990343e-02f, -7.11330250e-02f, -2.46806312e-02f, 4.90906509e-03f, 4.04020920e-02f, 1.02727963e-02f, -8.19996186e-03f, -5.89814559e-02f, 8.96293111e-03f,
  -8.87341574e-02f, 3.23251426e-01f, -9.34573188e-02f, 3.86519842e-02f, -4.89640012e-02f, 2.73143500e-01f, 2.89012462e-01f, -4.72875535e-02f, 1.98195636e-01f, 2.70523161e-01f,
  1.19544461e-01f, 9.69592184e-02f, 5.26380353e-02f, 2.23800093e-01f, 4.90199998e-02f, 1.37833461e-01f, 2.92487293e-01f, 2.29993567e-01f, -7.47948810e-02f, 5.33020273e-02f,
  1.03815608e-02f, 3.51206847e-02f, -1.24951124e-01f, -1.64301485e-01f, -5.48821203e-02f, -1.37584135e-01f, -1.17294975e-02f, -1.02670118e-01f, -7.04190731e-02f, 9.52855274e-02f,
  -1.87607240e-02f, 4.64026891e-02f, -9.03534819e-05f, -8.13875273e-02f, 1.56825744e-02f, -8.06862861e-02f, 3.39684971e-02f, -6.82327375e-02f, -5.61266989e-02f, 9.57707595e-03f,
  1.08815908e-01f, 6.12383895e-03f, 5.22751287e-02f, -4.84945532e-03f, -3.96871455e-02f, -6.83469232e-03f, -2.83979699e-02f, -4.90739616e-03f, 2.07166877e-02f, -1.30845636e-01f,
  1.22396799e-03f, 3.24224122e-02f, 4.71914001e-02f, 5.96997961e-02f, -5.80809377e-02f, -2.19639521e-02f, 5.34899160e-02f, -5.72198676e-03f, -3.14214230e-02f, 8.55967402e-02f,
  6.25327881e-03f, 2.09600963e-02f, 2.32638512e-02f, -4.47039306e-02f, 4.65798452e-02f, -1.30792633e-02f, 5.33335656e-02f, -3.62876728e-02f, 4.35756845e-03f, 2.29905434e-02f,
  -1.63436104e-02f, -8.60351250e-02f, 1.93076227e-02f, 2.40923557e-03f, 1.65001526e-02f, 7.73765370e-02f, 2.39853431e-02f, 2.45919311e-03f, 4.52041961e-02f, 1.43131334e-02f,
  -1.95200145e-02f, 9.20591280e-02f, 5.22619300e-03f, 2.67547835e-02f, 1.67061854e-02f, 1.74436253e-02f, 1.46940257e-02f, -3.33431438e-02f, -1.04101757e-02f, -9.94039103e-02f,
  1.27799138e-01f, 2.39367545e-01f, 4.72387858e-03f, 3.10147777e-02f, -4.27814610e-02f, 2.34240480e-02f, 6.98236227e-02f, -4.41235676e-02f, 1.08608596e-01f, 4.33789827e-02f,
  -3.71778831e-02f, -4.09842767e-02f, -1.09990211e-02f, 4.13692882e-03f, -2.20442489e-02f, 3.12898047e-02f, 5.24345273e-03f, -1.56110916e-02f, 9.41697881e-03f, -1.61714479e-02f,
  -2.11728904e-02f, 1.02024684e-02f, -7.18685910e-02f, -6.97738081e-02f, 5.23024611e-02f, 2.93019298e-03f, 6.56009763e-02f, -8.77803285e-03f, -8.77565145e-02f, 5.03848754e-02f,
  -2.13096589e-01f, 2.31291816e-01f, 3.61278690e-02f, 6.52835378e-03f, -3.91050316e-02f, 7.43665844e-02f, 6.77246004e-02f, -1.17223999e-02f, -1.51618477e-02f, -3.07209161e-03f,
  -1.26368091e-01f, 3.55359390e-02f, 1.30163521e-01f, -1.31371077e-02f, 7.94577375e-02f, 2.60234177e-01f, -2.71297805e-02f, 2.86919363e-02f, 7.79314432e-04f, -4.69371537e-03f,
  -2.29620896e-02f, -2.86953282e-02f, 7.40884468e-02f, -3.58943455e-02f, -1.20828666e-01f, -1.20927997e-01f, -1.07978150e-01f, 8.08966532e-02f, 1.46998065e-02f, -1.15516363e-02f,
  -6.98183253e-02f, -9.79304910e-02f, -1.56376392e-01f, -1.13468438e-01f, -4.58678044e-02f, -1.47406263e-02f, -8.22261348e-02f, -4.92598265e-02f, -5.49953096e-02f, -5.44244349e-02f,
  -1.06352746e-01f, -1.81095190e-02f, 6.32632971e-02f, 4.61813360e-02f, -9.50842351e-02f, -3.82416998e-03f, -2.47240644e-02f, 5.95553629e-02f, 6.54051378e-02f, -9.91687085e-03f,
  -4.82976483e-03f, -5.60901761e-02f, 3.60537395e-02f, 5.55340666e-03f, -3.50094847e-02f, 5.02927527e-02f, -1.94204357e-02f, 6.19374588e-02f, -8.94163828e-03f, 7.53931925e-02f,
  -5.70763648e-02f, 8.84903222e-02f, 1.36038708e-02f, 1.93884000e-02f, 4.09977101e-02f, 2.70755813e-02f, -6.82182014e-02f, -6.51750192e-02f, -7.30146617e-02f, 6.57951310e-02f,
  -2.60041119e-03f, 4.27397341e-02f, -1.03133716e-01f, 1.02657331e-02f, 7.06327856e-02f, -2.51865182e-02f, 4.82612066e-02f, -8.37650448e-02f, -1.11351034e-03f, 1.98581498e-02f,
  2.74336468e-02f, -1.80234760e-02f, -5.71254864e-02f, -4.37815785e-02f, -4.59573008e-02f, -1.82797736e-03f, -4.89349440e-02f, -8.60217288e-02f, 9.26396847e-02f, 8.07783753e-03f,
  1.84882861e-02f, -9.64450389e-02f, -8.20528343e-02f, -1.00806698e-01f, -4.96643186e-02f, 4.48242202e-02f, 3.22759850e-04f, -5.64090461e-02f, -4.47283732e-03f, -5.83889149e-02f,
  -1.89138154e-05f, 4.28603739e-02f, -3.84289324e-02f, 7.97570646e-02f, 5.62710986e-02f, 3.25593539e-02f, -6.75595030e-02f, -5.46493120e-02f, 2.51298267e-02f, 3.41346301e-02f,
  -2.42251400e-02f, 1.74088050e-02f, -6.41319603e-02f, -1.11738227e-01f, -4.50386144e-02f, 5.82141094e-02f, -8.34295079e-02f, -3.67522128e-02f, 4.06476483e-02f, 1.06174558e-01f,
  1.05014695e-02f, -9.72273573e-02f, -5.68412952e-02f, 6.75875098e-02f, 2.77843833e-01f, -1.16254158e-01f, 2.89707780e-02f, 2.59721041e-01f, 2.10960805e-01f, -5.79965524e-02f,
  -2.15149336e-02f, -2.52988487e-01f, 3.51423696e-02f, -2.78088212e-01f, -4.04423743e-01f, -2.79765546e-01f, -2.59485245e-01f, -1.77770078e-01f, 1.61014497e-02f, -1.18865585e-02f,
  -7.92706609e-02f, 2.37795208e-02f, -1.98288903e-01f, 1.06370151e-01f, 1.88945130e-01f, 1.61650866e-01f, 1.00813307e-01f, 1.98276624e-01f, -1.08112767e-01f, -8.92494321e-02f,
  6.30827546e-02f, 1.01594873e-01f, 8.54784027e-02f, 1.35649377e-02f, 1.14072479e-01f, 3.18540297e-02f, -6.00255616e-02f, -2.86864638e-02f, 6.79695606e-02f, -7.34357685e-02f,
  -8.49866346e-02f, -3.03060263e-02f, -5.23059033e-02f, 6.83033019e-02f, 1.12152368e-01f, 7.41455406e-02f, -7.49930888e-02f, 4.79877405e-02f, 1.15142763e-02f, -1.15768492e-01f,
  3.32947485e-02f, -9.58712772e-02f, -7.04964846e-02f, -9.65470597e-02f, -5.98845854e-02f, -7.72814080e-03f, -6.34286040e-03f, -7.96254277e-02f, 9.23532620e-03f, 1.66808919e-03f,
  1.74285341e-02f, 1.03908149e-03f, -1.35501325e-02f, 8.69148672e-02f, -1.15334811e-02f, 6.37366995e-02f, -4.10312340e-02f, -1.36135090e-02f, 3.63514908e-02f, -4.45142947e-03f,
  7.80108199e-02f, -5.73101826e-02f, 3.64149585e-02f, 6.63981959e-02f, 1.02515460e-03f, -3.96876112e-02f, 2.87056211e-02f, -5.62469400e-02f, 7.65628964e-02f, 3.10355071e-02f,
  -5.03467815e-03f, 1.63344219e-02f, -2.34947521e-02f, 8.42667930e-03f, -8.28906819e-02f, 4.74675708e-02f, -4.95382510e-02f, 5.36764525e-02f, 1.56882815e-02f, 1.55805256e-02f,
  -1.04349688e-01f, -2.99245864e-02f, 2.61707418e-03f, 4.62788679e-02f, -4.34404574e-02f, 6.31492212e-02f, -5.46777733e-02f, 1.33423060e-02f, -6.55248240e-02f, 6.07238635e-02f,
  2.72257347e-02f, 1.03517987e-01f, 2.57795826e-02f, 2.62317993e-02f, 2.18263716e-02f, -2.86832731e-02f, -9.44157830e-04f, 2.61948593e-02f, -4.92089381e-03f, -5.56804705e-03f,
  4.51041497e-02f, 2.22112238e-02f, -5.93527332e-02f, 5.06835654e-02f, 1.98110635e-03f, -2.14844272e-02f, 9.03294329e-03f, -3.49027589e-02f, -1.13343365e-01f, -6.42470121e-02f,
  1.98514909e-01f, -2.11760685e-01f, -5.40647991e-02f, -1.67133715e-02f, 2.03891397e-01f, -3.29235680e-02f, 1.29664212e-01f, -5.16486056e-02f, 8.64411891e-02f, -1.78001538e-01f,
  -7.33784065e-02f, -6.76918402e-02f, 6.84193820e-02f, -2.03867763e-01f, 1.77228644e-01f, 1.00512784e-02f, -1.14714466e-02f, 7.15883262e-03f, -2.50492971e-02f, 1.19385226e-02f,
  4.58321497e-02f, -1.30205661e-01f, -8.30344930e-02f, -1.54495552e-01f, -1.16406068e-01f, -3.39739956e-02f, 2.03493629e-02f, 6.59658536e-02f, -1.27353579e-01f, -8.92347768e-02f,
  -7.84110352e-02f, 6.71481192e-02f, -1.38989016e-02f, -1.78340189e-02f, -9.61340889e-02f, 4.47969139e-02f, -8.09818283e-02f, 5.10280021e-02f, 4.48609442e-02f, -3.27295577e-03f,
  -3.21062170e-02f, -4.91319224e-02f, -3.54705602e-02f, -5.10943346e-02f, -2.61135288e-02f, -5.97811230e-02f, -6.95317537e-02f, -7.55533576e-02f, 6.11266755e-02f, 6.29852898e-03f,
  4.35784385e-02f, -9.66454297e-02f, 2.87806857e-02f, -2.90451711e-03f, 1.84775162e-02f, -3.24351713e-02f, 5.73240668e-02f, 1.71258952e-02f, 7.15183690e-02f, 4.82918434e-02f,
  -7.62522034e-03f, 9.46143791e-02f, 3.15173604e-02f, 2.77765915e-02f, -1.27092712e-02f, 9.36068818e-02f, -4.80325185e-02f, -6.67439308e-04f, -3.88285369e-02f, 7.03963712e-02f,
  4.27217335e-02f, 1.47545699e-03f, 2.12640762e-02f, 8.07560384e-02f, 4.54155020e-02f, -1.38442628e-02f, 7.34139383e-02f, -1.33369751e-02f, 2.95383390e-02f, -1.03027811e-02f,
  -4.43319567e-02f, -5.47558405e-02f, -4.02067788e-02f, 6.69890363e-03f, -1.19094783e-02f, 4.66108322e-03f, 2.53857728e-02f, 3.34057212e-02f, -1.24812536e-02f, -5.16949445e-02f,
  5.21621630e-02f, -1.67339787e-01f, 2.89744362e-02f, -5.29373735e-02f, -6.52727392e-03f, -7.40935430e-02f, 6.40374469e-03f, -2.28341445e-02f, 3.51909995e-02f, -1.08073205e-01f,
  7.69070536e-02f, 3.98910828e-02f, -6.56369627e-02f, -5.44625223e-02f, 4.42077732e-03f, -8.32352191e-02f, -9.17166099e-02f, 3.84175628e-02f, -3.33441794e-02f, -6.72731623e-02f,
  -8.14396665e-02f, 5.93710802e-02f, 7.27775246e-02f, 4.76043709e-02f, -6.70069382e-02f, 7.50532225e-02f, -3.14761549e-02f, 2.20654011e-02f, -7.31841922e-02f, -8.13169479e-02f,
  -3.57784107e-02f, 1.91042393e-01f, 4.37734574e-02f, -4.14118990e-02f, -4.74835970e-02f, -1.05566248e-01f, 4.98761050e-02f, -6.77803382e-02f, -1.39773078e-02f, 1.64338350e-01f,
  -4.35875878e-02f, 1.17966376e-01f, -6.61661997e-02f, -1.04806855e-01f, -3.17314744e-01f, -1.98151827e-01f, 1.54514164e-02f, 9.06640291e-02f, -9.86062214e-02f, -2.19993349e-02f,
  -1.27177373e-01f, -1.91300422e-01f, -9.22612771e-02f, -1.26418427e-01f, 9.47778076e-02f, 1.20961584e-01f, -3.10590137e-02f, 5.30870743e-02f, 7.67491758e-02f, -9.60762054e-02f,
  1.47453416e-02f, -5.70238754e-02f, 1.64940730e-02f, 1.18779493e-02f, 5.49411476e-02f, 7.82671645e-02f, 1.22190714e-01f, 2.81959530e-02f, -3.13322037e-03f, 4.64708619e-02f,
  1.66591182e-02f, 1.56222703e-02f, 2.11395766e-03f, -1.25648677e-01f, 1.59089025e-02f, 8.83469637e-03f, 8.43743309e-02f, 3.39579508e-02f, 1.13909133e-01f, 7.82278366e-03f,
  -2.27053510e-03f, 1.35736889e-03f, 1.08507492e-01f, 9.82148051e-02f, -2.18727514e-02f, 5.71947731e-02f, 4.33306582e-02f, 6.70940056e-02f, 5.31940050e-02f, -8.19463283e-02f,
  1.24058863e-02f, 3.91682051e-02f, 3.28546688e-02f, 5.22609092e-02f, 1.24715846e-02f, 5.65314628e-02f, 5.54788392e-03f, 4.87077124e-02f, -3.05665005e-02f, 2.89022680e-02f,
  -6.13514297e-02f, -6.94080582e-03f, -1.57252736e-02f, -3.77596729e-02f, -1.33368671e-02f, -2.36943569e-02f, 4.75713760e-02f, 2.21683104e-02f, 2.79505625e-02f, -4.10689488e-02f,
  -4.79519926e-02f, -2.09465753e-02f, -1.41961151e-03f, -7.51517862e-02f, -3.78414840e-02f, 1.08038839e-02f, -5.01411920e-03f, -3.94311249e-02f, 3.91083956e-02f, -5.43272309e-02f,
  -1.64111843e-03f, -2.10389644e-02f, 1.04666334e-02f, 3.95259708e-02f, -4.19091135e-02f, -3.42700258e-02f, 6.26257211e-02f, -6.66221306e-02f, 5.70159592e-02f, 3.86433192e-02f,
  1.07978545e-01f, -4.08234447e-02f, -1.18311227e-03f, 5.13615832e-02f, 3.22562680e-02f, 2.68733874e-02f, 7.68416077e-02f, 6.64567947e-03f, 6.85436800e-02f, -5.41488752e-02f,
  7.99450930e-03f, 2.61714254e-02f, 2.89996155e-02f, -5.32827899e-02f, 2.66092867e-02f, 7.34801590e-02f, 3.98423038e-02f, 9.61363316e-02f, 2.83411499e-02f, -6.52645901e-03f,
  4.44915742e-02f, -1.41851172e-01f, 9.40463599e-03f, 1.78203639e-02f, -1.83991541e-03f, 1.85862258e-01f, 2.56688565e-01f, -2.97733247e-02f, -1.01418486e-02f, -5.36122918e-03f,
  -5.05745523e-02f, -3.04364730e-02f, 7.16320202e-02f, 5.80675155e-03f, 8.45853984e-02f, 2.07522716e-02f, -6.57619983e-02f, 4.75353673e-02f, -1.58738978e-02f, 8.97296295e-02f,
  -5.71513027e-02f, 3.67903337e-02f, 6.02248823e-03f, -1.16204441e-01f, -1.26502402e-02f, -5.92260547e-02f, -5.29193506e-02f, -1.38046769e-02f, -5.69268912e-02f, 5.98989567e-03f,
  5.47459759e-02f, 7.99053013e-02f, 4.01060358e-02f, -4.03259173e-02f, 4.34139837e-03f, -8.44738781e-02f, -7.60126561e-02f, 6.51922524e-02f, -4.20122072e-02f, 4.13321294e-02f,
  3.19672860e-02f, -2.58190520e-02f, 1.53832398e-02f, -7.55307227e-02f, 4.52068150e-02f, -7.95533732e-02f, -1.01360582e-01f, 4.75734212e-02f, 3.20034027e-02f, -4.43962812e-02f,
  -1.06219500e-02f, 2.71278583e-02f, 5.76899610e-02f, -9.51124802e-02f, 1.26973940e-02f, 2.71216128e-03f, -4.36006412e-02f, 7.66857490e-02f, -1.76582648e-03f, -2.73295306e-02f,
  9.47237015e-03f, -2.48869285e-02f, -1.07186716e-02f, -2.26237290e-02f, -5.18848896e-02f, -1.98118631e-02f, -5.68076000e-02f, -1.46584511e-02f, -2.01880392e-02f, 4.79280464e-02f,
  6.73753396e-02f, 6.78144768e-02f, -7.75045296e-03f, -3.86568420e-02f, 2.90197581e-02f, 2.80799866e-02f, 3.28364633e-02f, -4.51732092e-02f, -3.32345366e-02f, 6.88525885e-02f,
  -2.53017992e-03f, 4.51399013e-02f, -3.34335342e-02f, -2.97361817e-02f, -3.70069779e-02f, -1.11729708e-02f, 7.52241304e-03f, 6.05000034e-02f, 6.81361854e-02f, -3.89230177e-02f,
  -5.32423705e-02f, -4.15978208e-02f, 2.87436899e-02f, -6.73101936e-03f, -3.42535228e-02f, -4.14283946e-02f, 5.55347465e-02f, -1.78078003e-02f, 7.18025565e-02f, 2.48689801e-02f,
  -7.13338852e-02f, -3.52974609e-02f, -2.58596544e-03f, 5.36842868e-02f, 5.29106259e-02f, -1.94292404e-02f, 4.13611345e-02f, 3.29724066e-02f, 1.21804625e-02f, -6.33477122e-02f,
  8.80406424e-02f, 1.92736108e-02f, 8.17262661e-03f, 7.21122250e-02f, -8.52040723e-02f, -5.11374511e-02f, 9.43414867e-03f, 1.95444357e-02f, -5.34682423e-02f, 8.38220492e-02f,
  1.10415190e-01f, 1.37782380e-01f, 6.76796734e-02f, 4.58480194e-02f, -1.03802972e-01f, -3.41826767e-01f, -1.81202307e-01f, 1.09118685e-01f, -8.66521746e-02f, -5.59746549e-02f,
  -7.84655809e-02f, 1.42360553e-01f, -3.50515507e-02f, -4.54737693e-02f, -1.28322542e-01f, 3.01238447e-02f, 1.52047118e-02f, 8.44112784e-03f, 1.51564525e-02f, 1.03328541e-01f,
  7.09678605e-02f, -4.51515391e-02f, 1.06786661e-01f, 6.81842566e-02f, 7.87835941e-02f, 1.42856419e-01f, 1.77172780e-01f, 4.09240127e-02f, 8.66900459e-02f, -8.15898553e-02f,
  8.68953858e-03f, 1.57324821e-01f, 2.74402685e-02f, 3.10072815e-03f, -5.53746894e-02f, -5.95867075e-02f, -7.40434751e-02f, 2.40367744e-03f, -1.01886701e-03f, -8.93027056e-03f,
  3.03010568e-02f, 5.35514951e-02f, -5.46577089e-02f, 2.47571748e-02f, -6.63147122e-02f, -6.79330751e-02f, 7.09063038e-02f, 3.15382914e-03f, 2.33859494e-02f, 4.49400730e-02f,
  9.74077508e-02f, 1.56459119e-02f, -6.70821294e-02f, -4.68844362e-02f, -2.26138979e-02f, 3.44477105e-03f, 4.76569496e-03f, -9.09702759e-03f, 4.58475687e-02f, 3.81901972e-02f,
  1.22852102e-01f, 1.17683439e-02f, -8.90988111e-03f, -8.46822094e-03f, -3.84358875e-02f, 6.08321978e-03f, 1.21539449e-02f, 6.90971464e-02f, 8.46944153e-02f, -5.73161766e-02f,
  1.26226284e-02f, 6.84480667e-02f, -7.15148523e-02f, -7.01164156e-02f, -5.11840023e-02f, -5.59169892e-03f, 6.82609761e-03f, 7.19401985e-02f, 4.77168709e-02f, 1.99153218e-02f,
  -2.43183300e-02f, -6.33673891e-02f, 3.19483839e-02f, -6.40788972e-02f, -5.60623370e-02f, 3.45348082e-02f, 2.90339831e-02f, 2.46285740e-03f, 5.54714687e-02f, 4.40284610e-02f,
  3.09657231e-02f, 1.23615898e-01f, 4.54113781e-02f, -1.19640380e-02f, -1.09090634e-01f, -1.00409262e-01f, -2.49208249e-02f, 7.25644380e-02f, 2.99563054e-02f, 6.04474917e-02f,
  3.77477258e-02f, -1.10793479e-01f, -9.79330204e-03f, 5.26440516e-02f, -8.82468279e-03f, 3.62003818e-02f, 8.59979019e-02f, 2.20269319e-02f, -2.57273689e-02f, 2.41953358e-02f,
  -2.62703225e-02f, -3.22797708e-02f, -2.83445735e-02f, 2.07650978e-02f, 5.46720363e-02f, -2.92432401e-03f, -2.94991713e-02f, -3.32157910e-02f, 1.04425460e-01f, -1.33114746e-02f,
  -4.89646681e-02f, -4.50677842e-01f, -1.01146884e-01f, 8.12656134e-02f, 9.25748572e-02f, -5.34734735e-03f, -1.77699670e-01f, -2.45014615e-02f, -1.25132665e-01f, -3.09561729e-01f,
  -6.77571073e-02f, -2.51069684e-02f, -2.68411726e-01f, 3.85417193e-02f, 2.07227588e-01f, -1.72081172e-01f, -2.11883299e-02f, -9.05265436e-02f, 5.00482693e-02f, -2.11833362e-02f,
  1.67812586e-01f, 1.06374972e-01f, 2.68984437e-01f, 2.03165218e-01f, 6.34776056e-02f, 1.92324579e-01f, 2.21324667e-01f, 4.93129231e-02f, 2.55482972e-01f, 1.12932913e-01f,
  -5.96841574e-02f, -5.63920923e-02f, -9.15588904e-03f, 9.02257208e-03f, -2.53265332e-02f, -6.85785804e-03f, 7.06976131e-02f, 1.23315483e-01f, 9.71835405e-02f, -4.66138050e-02f,
  -5.53882197e-02f, 8.64118114e-02f, 7.99146481e-03f, 1.77944321e-02f, -5.29400334e-02f, 1.09253876e-01f, 7.55758286e-02f, -5.29308543e-02f, -4.25458215e-02f, -6.84806481e-02f,
  -5.19071743e-02f, -5.31908497e-02f, -6.39283434e-02f, 9.21571627e-03f, -1.16981259e-02f, 1.51229360e-05f, 9.96389426e-03f, 3.34125012e-02f, -7.19360933e-02f, 1.19867763e-02f,
  -5.40411286e-02f, 2.07525468e-03f, -8.11824724e-02f, -1.18658913e-03f, -1.98684353e-02f, -2.20708139e-02f, -7.52363652e-02f, -3.82619724e-02f, 4.75502983e-02f, -4.99183349e-02f,
  6.99752048e-02f, -1.58468056e-02f, 4.21336591e-02f, 4.78935130e-02f, 5.03118150e-03f, -3.36258933e-02f, 1.29407868e-01f, -4.31328900e-02f, 5.28256632e-02f, 1.33123267e-02f,
  -5.32468222e-02f, 7.78493984e-03f, -3.02876462e-04f, 3.07569448e-02f, -6.42240746e-04f, -3.49331903e-03f, -4.00542878e-02f, -5.75573742e-02f, -3.90190855e-02f, 5.22777624e-02f,
  -6.06050640e-02f, -8.96092653e-02f, -4.05440852e-02f, 8.03577080e-02f, 5.13055711e-04f, -8.45243037e-02f, 5.64633869e-02f, -3.13851722e-02f, 1.36467740e-02f, -6.49710968e-02f,
  1.01791151e-01f, 6.89759254e-02f, -1.01725027e-01f, 7.99005181e-02f, 1.43433779e-01f, -9.31096748e-02f, 1.31008693e-03f, 1.31859835e-02f, 8.43652114e-02f, 2.82076020e-02f,
  3.31868976e-02f, -4.88967868e-03f, 7.58434907e-02f, -2.26212181e-02f, 3.04955356e-02f, -4.48056757e-02f, -1.23791583e-02f, 6.70634583e-03f, -2.91523784e-02f, 4.51741181e-02f,
  -1.77295685e-01f, -1.56935960e-01f, 5.06776720e-02f, -1.78239807e-01f, 2.33056676e-02f, -2.00740889e-01f, -1.54282838e-01f, -2.19187468e-01f, -8.28199312e-02f, -1.33438632e-01f,
  1.99281313e-02f, 9.05793533e-02f, 1.98492169e-01f, -2.06769049e-01f, 1.65204778e-01f, 1.34974495e-01f, -2.61579245e-01f, -7.80595094e-02f, -6.55410951e-03f, -1.70617506e-01f,
  -8.00149292e-02f, -7.40069374e-02f, 3.21846418e-02f, -9.88366529e-02f, -1.25348583e-01f, -1.00443937e-01f, -1.92313902e-02f, 6.97920844e-02f, -1.16891876e-01f, 1.03318982e-01f,
  -1.16058066e-01f, -1.35822833e-01f, 2.91676689e-02f, -4.15054224e-02f, -5.08890022e-03f, 2.84532439e-02f, -3.14409994e-02f, 3.48550230e-02f, 4.69504334e-02f, -8.78438503e-02f,
  3.03898230e-02f, -3.70016620e-02f, -4.18607034e-02f, -1.20985126e-02f, -2.57261153e-02f, 2.85138339e-02f, -3.61509882e-02f, -6.31594881e-02f, 6.17642030e-02f, -5.44905737e-02f,
  -6.05013445e-02f, 9.65740066e-03f, -6.57057315e-02f, -6.43320829e-02f, 5.83779067e-02f, -1.66528393e-02f, 7.08014816e-02f, 7.31789321e-02f, -8.26378446e-03f, -2.45533045e-02f,
  6.15061484e-02f, -5.73896877e-02f, 3.16500268e-03f, 3.11372560e-02f, -5.72467409e-02f, 4.05397154e-02f, 7.04686642e-02f, -9.76424571e-03f, 4.83621284e-02f, 4.21917737e-02f,
  -9.74430367e-02f, 1.82096306e-02f, 5.59961982e-02f, 3.71798165e-02f, -9.01147276e-02f, -1.41845248e-03f, 2.02363841e-02f, -6.75398186e-02f, -6.48726448e-02f, -8.33414868e-02f,
  -4.29626405e-02f, -3.92174086e-04f, 3.19959223e-02f, 3.86051014e-02f, -2.32368745e-02f, 7.59886056e-02f, -2.18914654e-02f, -7.50891585e-03f, 6.14484698e-02f, -2.23655459e-02f,
  -1.91584289e-01f, -1.43788651e-01f, -2.36464348e-02f, 6.31049350e-02f, -4.25407179e-02f, -8.29710811e-03f, 6.05353303e-02f, -7.17911720e-02f, -1.03287376e-01f, 6.84412494e-02f,
  -1.31600335e-01f, -3.82310562e-02f, -5.74055687e-02f, 9.88416299e-02f, -7.50323609e-02f, -6.81248978e-02f, 2.38151420e-02f, 8.53657164e-03f, -6.77898154e-02f, -7.98359439e-02f,
  1.19599504e-02f, 8.30246210e-02f, 2.59835962e-02f, 3.25284973e-02f, -2.52302531e-02f, -5.21535687e-02f, -2.40562670e-02f, -2.97722984e-02f, -5.97517118e-02f, -4.13235649e-02f,
  1.04458831e-01f, 9.33243893e-03f, -1.60051689e-01f, -9.64180455e-02f, -2.68081725e-01f, -1.58619657e-01f, -1.78290814e-01f, -4.33585569e-02f, 1.09678350e-01f, 2.02618062e-01f,
  1.03743095e-02f, 1.41395673e-01f, 1.07959703e-01f, -9.82130766e-02f, -4.49183546e-02f, 2.16870785e-01f, -1.50678053e-01f, -3.92921008e-02f, -3.23197804e-02f, -3.75867821e-02f,
  -6.13851100e-02f, 4.64800671e-02f, -6.85127079e-02f, -1.14064880e-01f, -1.91199929e-01f, -8.25309083e-02f, 7.35312141e-03f, -8.74573886e-02f, -2.12065712e-01f, -1.36549473e-01f,
  -1.23979971e-01f, 1.37700304e-01f, -2.26684380e-02f, 6.93218336e-02f, -5.38168103e-02f, -6.05060048e-02f, -1.07440844e-01f, 3.70517261e-02f, -1.09270848e-01f, 6.99395388e-02f,
  1.15378806e-02f, 1.33540526e-01f, -2.52749007e-02f, 2.88772564e-02f, -1.22173671e-02f, 4.81613502e-02f, -4.89034653e-02f, -6.57495065e-03f, -5.58041148e-02f, -2.31486335e-02f,
  -6.71683550e-02f, -8.21853429e-02f, -3.43386121e-02f, 6.06029406e-02f, 2.04227641e-02f, -9.50286388e-02f, 8.56402516e-02f, -1.34228133e-02f, 4.50232774e-02f, -1.51749719e-02f,
  2.50471681e-02f, -4.60807309e-02f, -7.30766580e-02f, 3.08515914e-02f, 4.59903367e-02f, -1.29839976e-03f, 5.33121005e-02f, 2.04649419e-02f, 7.37410039e-02f, -8.21516588e-02f,
  7.96941966e-02f, 5.75168729e-02f, 1.22896470e-02f, -5.54880500e-03f, -2.27077752e-02f, 6.28852565e-03f, 7.87091181e-02f, 7.38447998e-03f, 3.85884829e-02f, 2.36067884e-02f,
  1.69359073e-02f, -3.92721333e-02f, -3.09671164e-02f, 1.41997961e-03f, -3.33878286e-02f, 6.75847381e-02f, 5.99636547e-02f, 4.19264436e-02f, 1.17303059e-02f, 8.82513635e-03f,
  -1.14185378e-01f, 1.16450951e-01f, 1.43040251e-02f, 1.23571835e-01f, -1.71285644e-02f, -6.97711390e-03f, -1.74580049e-02f, 1.08530195e-02f, -1.12935401e-01f, 5.19291237e-02f,
  -2.91913617e-02f, -1.44026228e-04f, -1.49188179e-03f, -9.66266692e-02f, 8.73824656e-02f, -4.52215970e-02f, -7.50731751e-02f, 1.29507557e-01f, -5.76509535e-02f, 2.71911211e-02f,
  -3.20427194e-02f, 5.46269715e-02f, 2.66579352e-02f, -1.28814466e-02f, 3.18750516e-02f, -7.16741607e-02f, -5.23241684e-02f, -3.91979702e-02f, -6.53212890e-02f, 2.48572472e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  7.47895613e-02f, 1.26825529e-03f, -8.24539959e-02f, 1.31638527e-01f, 1.68646783e-01f, 1.76701531e-01f, 2.85012096e-01f, 2.13717476e-01f, 1.24507554e-01f, 1.80086249e-03f,
  1.72119051e-01f, 2.47775033e-01f, 1.36814997e-01f, 5.20318821e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.57392712e-02f, 1.30782267e-02f, 1.25022218e-01f, -2.42722891e-02f, -9.82581899e-02f, -1.58785000e-01f, -6.20669406e-03f, 8.50433558e-02f, -1.23755708e-01f, 8.75399075e-03f,
  -1.20902427e-01f, 9.73901898e-02f, 4.91438396e-02f, 6.04536198e-02f, 2.01405615e-01f, 1.54137481e-02f, -4.17655855e-02f, -7.90679231e-02f, -6.33089468e-02f, -1.35739297e-01f,
  5.56047447e-02f, 1.32069051e-01f, 9.87101346e-02f, -2.73765828e-02f, -1.24886282e-01f, -3.48346084e-02f, 1.35044917e-01f, -5.30821048e-02f, -1.63513228e-01f, 9.27009061e-02f,
  1.75697163e-01f, -2.22220346e-01f, -6.91696107e-02f, 1.55873507e-01f, -3.72749493e-02f, 1.25028297e-01f, 1.93297535e-01f, -3.79549265e-02f, -1.43423647e-01f, -1.25043809e-01f,
  7.09189773e-02f, 2.40606237e-02f, 9.63097662e-02f, -1.27343893e-01f, 1.91215858e-01f, 7.37650320e-02f, 1.77548364e-01f, -1.77478492e-01f, -1.86175615e-01f, -1.80828080e-01f,
  9.25532579e-02f, 1.22722574e-01f, 9.40620229e-02f, -1.07659496e-01f, -2.21125372e-02f, 1.92421943e-01f, -1.24800041e-01f, 6.62011877e-02f, -9.49439108e-02f, 1.53513744e-01f,
  -5.61651401e-02f, -2.86532313e-01f, 2.28005499e-01f, 1.47409171e-01f, -3.04336920e-02f, 2.48697847e-02f, 1.69604093e-01f, -7.97751993e-02f, -1.38162360e-01f, -1.71353608e-01f,
  8.56413841e-02f, -8.05153102e-02f, 4.68295999e-02f, -1.10753857e-01f, 9.36903432e-02f, 7.78010860e-02f, 9.95968580e-02f, -6.13859929e-02f, -2.35133227e-02f, 1.64828703e-01f,
  4.19602208e-02f, -3.56456228e-02f, 2.73790490e-02f, -3.30295302e-02f, -6.21305034e-02f, 4.97989282e-02f, -9.19845626e-02f, -2.37449482e-02f, 9.25628617e-02f, 9.65560004e-02f,
  1.09752581e-01f, 1.07777707e-01f, -1.70841459e-02f, 8.29574764e-02f, 2.09527656e-01f, -7.20760599e-02f, -3.93267497e-02f, 9.62759256e-02f, 6.49704486e-02f, -1.51276365e-01f,
  7.51535147e-02f, -9.61637422e-02f, -1.08599268e-01f, -2.03060016e-01f, -9.28412527e-02f, 2.01735795e-01f, 2.05613911e-01f, 5.79988770e-03f, -2.52985302e-02f, 1.82221517e-01f,
  1.42301083e-01f, -1.36825025e-01f, -2.38409400e-01f, -5.65493256e-02f, 7.31195062e-02f, 5.93704581e-02f, 1.30700707e-01f, 1.33943498e-01f, 1.22312225e-01f, 1.66388899e-01f,
  -1.40175089e-01f, -1.30912736e-01f, -1.93862095e-01f, -1.35832429e-01f, 1.11346491e-01f, 3.48541290e-02f, 3.21834721e-02f, 6.50120080e-02f, -5.49238175e-02f, -6.58667833e-02f,
  6.90302178e-02f, -2.90159937e-02f, -3.34350057e-02f, 5.99885844e-02f, -3.21566919e-03f, 6.14924133e-02f, -1.21612530e-02f, 1.78592391e-02f, -7.06458166e-02f, 2.54116207e-02f,
  -8.58725235e-02f, -1.11851260e-01f, -1.60564139e-01f, -1.02103755e-01f, 3.38294841e-02f, 1.00447491e-01f, 1.18575402e-01f, -8.83201361e-02f, -1.71642333e-01f, 2.53764959e-03f,
  1.04444869e-01f, 8.23655128e-02f, 6.02936707e-02f, -1.52907982e-01f, -3.20806921e-01f, -9.14348736e-02f, 2.25401700e-01f, -5.90574071e-02f, -1.88278168e-01f, -1.09348513e-01f,
  -4.15656120e-02f, 8.79438370e-02f, 9.83832255e-02f, -1.28906399e-01f, 3.78369614e-02f, -1.49599805e-01f, 5.29155582e-02f, -2.27475967e-02f, 1.35246336e-01f, 9.57064554e-02f,
  -1.88966803e-02f, 2.79156178e-01f, -6.67826682e-02f, 8.49929899e-02f, -8.42941850e-02f, 2.50922412e-01f, 3.78469229e-01f, -1.19453613e-02f, -1.04402177e-01f, -1.25070289e-01f,
  1.12160400e-01f, -1.97713939e-03f, -1.41666368e-01f, -2.33969510e-01f, 2.01984853e-01f, 1.43800214e-01f, -1.40127733e-01f, -7.79479593e-02f, 1.55385584e-01f, 6.69924170e-02f,
  2.26407172e-03f, -2.37931877e-01f, 1.28608495e-01f, 7.13659152e-02f, 1.52770607e-02f, -5.67884035e-02f, -6.60353005e-02f, -4.28709686e-02f, -1.01886369e-01f, 9.74587053e-02f,
  -1.50562271e-01f, -1.17703937e-01f, 1.70151263e-01f, -3.78947221e-02f, -9.96984765e-02f, 1.01761952e-01f, 1.20099373e-01f, 1.05584130e-01f, -1.23593416e-02f, 6.69867098e-02f,
  -2.98944414e-02f, -1.16884053e-01f, 1.56531766e-01f, 1.19597331e-01f, 1.22887462e-01f, -1.56314015e-01f, 1.00705242e-02f, -1.40852734e-01f, 1.22196466e-01f, 3.02146494e-01f,
  -2.20823616e-01f, 7.93415308e-02f, 4.11299011e-03f, -1.50873706e-01f, -1.66751891e-01f, 1.75499171e-01f, -2.20582336e-01f, -4.88308817e-02f, 4.72071245e-02f, 3.84566225e-02f,
  -1.44014433e-01f, 2.52204686e-01f, 5.05498461e-02f, -2.87855148e-01f, 1.09374695e-01f, -1.85046732e-01f, -1.08611621e-01f, -1.17736302e-01f, -7.52296001e-02f, -1.66751400e-01f,
  -1.05537578e-01f, 2.92820483e-03f, -1.61127105e-01f, 7.01510310e-02f, -1.67378671e-02f, 2.15739861e-01f, -1.87260196e-01f, 8.34397133e-03f, 1.40438810e-01f, -5.13970144e-02f,
  -1.77861646e-01f, -8.23013708e-02f, 5.83036654e-02f, 2.13968992e-01f, 1.61640793e-01f, 6.84566423e-03f, 1.29704833e-01f, -2.88815312e-02f, 6.62851408e-02f, -2.80360967e-01f,
  -1.99918915e-02f, -9.83822048e-02f, -1.62982121e-02f, 1.10488366e-02f, 2.52510584e-03f, -1.92743808e-01f, 1.44688904e-01f, -1.27091721e-01f, 2.73746997e-03f, 3.33138369e-02f,
  1.10928789e-01f, -1.00136638e-01f, -1.61884710e-01f, -1.65982172e-02f, 1.37063384e-01f, -2.40337491e-01f, -4.28851284e-02f, -1.29004210e-01f, -2.64944658e-02f, 1.35091841e-01f,
  6.53877258e-02f, -1.18257657e-01f, 1.54664487e-01f, 3.62536199e-02f, -4.29523066e-02f, 6.03021085e-02f, -7.26028681e-02f, -2.41555586e-01f, -6.47579646e-03f, 2.73941271e-02f,
  1.72512636e-01f, -2.77449433e-02f, 9.49927270e-02f, -2.70899743e-01f, 8.32858980e-02f, -2.04617530e-02f, 2.53339782e-02f, -3.10664922e-02f, -7.25559667e-02f, 2.23221764e-01f,
  1.71540424e-01f, -4.13928181e-02f, -4.44453172e-02f, 4.52704914e-02f, 1.96379974e-01f, -2.37726625e-02f, -5.78713194e-02f, -1.02795393e-03f, -2.71061230e-02f, 9.56251100e-02f,
  -2.36260191e-01f, -1.03452422e-01f, -2.03825563e-01f, 1.25444785e-01f, 6.40160069e-02f, -6.58514798e-02f, 1.00945629e-01f, 3.09174001e-01f, 1.40221119e-01f, 4.46097888e-02f,
  -8.82440358e-02f, -1.03817470e-02f, 1.54354930e-01f, -3.69028598e-02f, 4.18911986e-02f, 4.39571626e-02f, 2.88404953e-02f, 1.18581191e-01f, -8.82254913e-02f, 3.41872051e-02f,
  1.60220843e-02f, -3.94594707e-02f, 7.09737930e-03f, 3.20554525e-02f, 8.40580016e-02f, -2.59433556e-02f, 6.51436821e-02f, -1.02329113e-01f, -8.77411515e-02f, -4.86820377e-02f,
  1.35450721e-01f, -1.26870107e-02f, 4.68220264e-02f, -7.00968802e-02f, -1.56955242e-01f, -1.60864934e-01f, 1.07069828e-01f, 6.84189498e-02f, -1.82327002e-01f, 1.43735092e-02f,
  -1.61977589e-01f, 7.02854916e-02f, -2.26908341e-01f, 2.12400451e-01f, -2.26035863e-01f, -4.06792685e-02f, 1.05120577e-01f, 1.75215095e-01f, -2.05778360e-01f, -2.20150426e-02f,
  1.39550865e-01f, -2.66345799e-01f, 1.17439300e-01f, -2.22280115e-01f, 1.86609656e-01f, 2.46243086e-02f, 1.72692724e-02f, -6.71267956e-02f, -2.20525786e-01f, 3.39217633e-02f,
  -1.51885688e-01f, -1.41373590e-01f, 9.31036174e-02f, -1.14403024e-01f, -2.39652082e-01f, 1.55446410e-01f, 1.79185029e-02f, -2.99368473e-03f, 1.09930672e-01f, 3.72685678e-03f,
  -6.32839203e-02f, 9.36787277e-02f, 8.27177465e-02f, -2.38149121e-01f, -5.74409664e-02f, -8.74636546e-02f, 1.25963315e-01f, -1.27064824e-01f, 3.17034423e-02f, 1.09832130e-01f,
  -9.61577147e-02f, 4.38990705e-02f, 3.72593477e-02f, -1.07845508e-01f, 1.00248508e-01f, -2.71636080e-02f, 1.40067652e-01f, -8.63368362e-02f, 1.92982584e-01f, -4.33047898e-02f,
  -1.38582379e-01f, 4.42706831e-02f, 2.16555208e-01f, -1.25615403e-01f, 6.29515275e-02f, -7.93104842e-02f, 7.26494044e-02f, 2.01570660e-01f, -2.94285677e-02f, 6.39829133e-03f,
  7.82431439e-02f, 7.93004856e-02f, -2.38486622e-02f, -4.11397628e-02f, -1.68807477e-01f, -2.12975010e-01f, 1.08940527e-01f, 1.00792140e-01f, 1.93655089e-01f, -2.64696013e-02f,
  5.38796224e-02f, -1.85919210e-01f, 1.00671962e-01f, 8.07451904e-02f, 1.94441542e-01f, -4.88297045e-02f, -1.49736121e-01f, 1.83056906e-01f, 3.79680283e-02f, -1.04510456e-01f,
  -2.45218799e-01f, 2.08143264e-01f, 1.08274765e-01f, 3.15732472e-02f, -9.60656349e-03f, -2.07639784e-01f, 9.80306864e-02f, 1.78971186e-01f, -1.00377843e-01f, -6.66890293e-02f,
  -4.11122777e-02f, -5.99011481e-02f, -1.46216482e-01f, -6.72196299e-02f, 9.48978961e-02f, 2.86389470e-01f, 4.55112532e-02f, -1.74049944e-01f, -8.35070945e-03f, 7.89188072e-02f,
  -1.78312394e-03f, -6.50940686e-02f, -1.03879973e-01f, 1.29345462e-01f, 7.14645013e-02f, 9.19378176e-02f, -8.05019960e-02f, -1.24278590e-01f, -1.22614115e-01f, -2.08848212e-02f,
  -1.45864049e-02f, 2.00210698e-02f, -9.91369560e-02f, -7.89614543e-02f, -1.02293994e-02f, 7.91356936e-02f, -2.03703344e-02f, -1.07099734e-01f, 3.27625163e-02f, 1.17372992e-02f,
  6.86527267e-02f, -2.30226871e-02f, -1.59736812e-01f, 6.36241361e-02f, 1.48770520e-02f, -1.38220385e-01f, -5.54005392e-02f, 2.04651281e-02f, 5.73073921e-04f, -3.28564681e-02f,
  -1.69392049e-01f, 2.10747227e-01f, -1.26923382e-01f, -2.32379839e-01f, 2.66498864e-01f, -1.48786664e-01f, 1.96035117e-01f, -4.22515780e-01f, 1.57667007e-02f, 2.09015235e-01f,
  2.90232390e-01f, -7.52178803e-02f, -1.00885428e-01f, 4.89908308e-02f, 3.74075234e-01f, 3.06689311e-02f, 3.51681672e-02f, -2.15096809e-02f, 7.96010643e-02f, -1.19541019e-01f,
  -4.72180657e-02f, -3.60282138e-02f, 1.17495902e-01f, 7.96354711e-02f, 2.25110576e-02f, -4.30573970e-02f, -2.69798320e-02f, 5.47981821e-03f, 1.28321365e-01f, -1.26871362e-01f,
  -1.59819558e-01f, 1.49006099e-01f, 7.26197585e-02f, -1.24887720e-01f, 4.85151187e-02f, 1.20097689e-01f, -5.71648255e-02f, 4.80152108e-02f, 3.81681956e-02f, -2.26999763e-02f,
  1.80127956e-02f, 8.17403942e-03f, 1.37042373e-01f, 4.22450304e-02f, 3.67816798e-02f, 1.48371056e-01f, 2.92151365e-02f, 3.85661796e-02f, 9.34914649e-02f, -1.24867283e-01f,
  1.20445177e-01f, 3.77427302e-02f, -1.26561031e-01f, 8.23714398e-03f, 6.42951652e-02f, -9.61913466e-02f, -3.31504159e-02f, -1.95718527e-01f, -1.25094745e-02f, 1.44521147e-01f,
  -2.39037529e-01f, 8.25048089e-02f, -1.82677671e-01f, 1.40429750e-01f, 8.65572877e-03f, 1.45888716e-01f, -7.92578012e-02f, -1.87032118e-01f, -1.72085613e-01f, 7.97519088e-02f,
  -2.00030997e-01f, -1.59569457e-01f, 2.00529724e-01f, -1.80470482e-01f, -7.00243264e-02f, 1.55898303e-01f, 2.00118929e-01f, 7.41357589e-03f, -3.95515449e-02f, 1.00968361e-01f,
  9.94156748e-02f, -2.10012093e-01f, -5.86512275e-02f, -2.21099898e-01f, 4.21363898e-02f, -1.39124155e-01f, -2.00193867e-01f, -1.27676781e-02f, 2.23853961e-01f, 1.04070604e-01f,
  -1.67942464e-01f, -1.74798220e-02f, -4.83854897e-02f, 1.00854300e-01f, -8.15841481e-02f, -2.14511365e-01f, 5.20675443e-02f, 1.12831406e-01f, -8.09878781e-02f, 9.73188803e-02f,
  8.12001005e-02f, 1.04041763e-01f, -1.05198950e-03f, 7.72679374e-02f, 2.02945042e-02f, -2.45559383e-02f, 1.01019226e-01f, 1.42837897e-01f, -1.47718072e-01f, 6.57670051e-02f,
  -1.22004710e-01f, 7.51315504e-02f, 4.24953140e-02f, 1.37205169e-01f, -3.91678214e-02f, 1.67995423e-01f, -1.27993673e-01f, 1.06378257e-01f, 7.33915269e-02f, 3.58098722e-03f,
  -3.36744003e-02f, -8.45741406e-02f, -6.18504547e-02f, 8.20117071e-02f, 1.00555852e-01f, 8.70735347e-02f, -1.32706702e-01f, 2.16766626e-01f, -1.52747035e-01f, 9.74876154e-03f,
  -1.31006435e-01f, -9.53284428e-02f, 2.30423212e-02f, 7.68397301e-02f, 2.96196729e-01f, -2.03986064e-01f, -2.17204615e-01f, 5.71708493e-02f, 1.23084135e-01f, 2.03525499e-01f,
  -3.67684290e-02f, 2.06522481e-03f, 1.96251512e-01f, 2.64098793e-01f, 2.00920999e-01f, 7.95003101e-02f, 1.00048646e-01f, 8.82737935e-02f, -3.79589275e-02f, 5.08250706e-02f,
  1.35660218e-02f, 2.96355896e-02f, 3.11886311e-01f, 1.51738495e-01f, 1.24576241e-01f, -5.86412624e-02f, 4.10522446e-02f, -2.39030063e-01f, 5.47271641e-03f, 1.02436833e-01f,
  -2.91070268e-02f, -2.86058914e-02f, -4.08392102e-02f, 1.13589890e-01f, 5.03152274e-02f, -9.28370375e-03f, -2.74410453e-02f, 9.20621455e-02f, -9.84111875e-02f, 1.91221982e-01f,
  -6.37542978e-02f, -8.03187490e-02f, 4.82372753e-02f, -7.93008655e-02f, 1.13662995e-01f, 3.66014093e-02f, -2.18026750e-02f, 9.19870734e-02f, 8.96413550e-02f, 5.39507531e-02f,
  1.73114315e-01f, -1.98434223e-03f, 1.27506331e-01f, 3.56241055e-02f, -1.55478902e-03f, -2.26528477e-03f, 1.28501922e-01f, 3.34418602e-02f, -1.08515460e-03f, -1.51197528e-02f,
  7.97507688e-02f, 1.09844461e-01f, 1.35287017e-01f, -9.61862728e-02f, -1.07628450e-01f, 1.05343439e-01f, -1.36771306e-01f, 6.11736476e-02f, -1.30200982e-01f, 2.96166182e-01f,
  -7.78939053e-02f, -2.85161078e-01f, -1.15225159e-01f, 6.31185547e-02f, 1.60758927e-01f, -1.93836734e-01f, -1.20764701e-02f, 4.19512428e-02f, 2.08650604e-02f, 9.21655074e-02f,
  1.33778071e-02f, 9.05240774e-02f, 5.11119934e-03f, 2.30733771e-02f, -1.11466452e-01f, 1.18656926e-01f, -9.66345593e-02f, -1.05647827e-02f, 5.92434369e-02f, -9.50813890e-02f,
  1.02292761e-01f, 7.84477070e-02f, 2.46370926e-01f, -1.13356272e-02f, 7.06600025e-02f, -5.40548898e-02f, 5.75646609e-02f, 6.26220480e-02f, 2.48490088e-02f, -1.57850957e-03f,
  3.40528078e-02f, 5.76307625e-03f, 9.34175551e-02f, -7.58498758e-02f, 1.81574766e-02f, 8.29930678e-02f, -5.31182513e-02f, 1.07025400e-01f, -2.49428693e-02f, -6.81160018e-02f,
  -1.40298381e-01f, -4.54101264e-02f, 2.15577111e-02f, 7.66736940e-02f, -1.19855545e-01f, 6.30827099e-02f, -5.72006255e-02f, -1.34055629e-01f, -2.46037729e-02f, 7.55371153e-02f,
  -2.17941254e-01f, -1.74556375e-01f, 2.13528007e-01f, -1.93278208e-01f, 5.03927320e-02f, -2.46629313e-01f, 1.06623441e-01f, -9.77800786e-02f, 6.27873167e-02f, 1.95877776e-01f,
  1.37295246e-01f, -1.34958744e-01f, 1.95958558e-02f, -3.57865617e-02f, -7.30333701e-02f, 2.77874589e-01f, 5.78771010e-02f, 1.75365373e-01f, -3.47950488e-01f, 2.26605922e-01f,
  -1.34715214e-02f, 1.30546823e-01f, 1.59723267e-01f, 8.43506679e-02f, -1.48234833e-02f, -1.98715121e-01f, 3.66356000e-02f, 1.15843244e-01f, 1.73622236e-01f, -1.22155994e-01f,
  1.12333231e-01f, -9.88378823e-02f, 1.88897587e-02f, -1.61151737e-02f, 2.04537436e-01f, 4.58456539e-02f, -4.32265438e-02f, 7.49302879e-02f, 1.67076707e-01f, 1.63556039e-01f,
  1.19959883e-01f, 1.00879565e-01f, 3.29015224e-04f, 1.08794961e-02f, 1.48470655e-01f, 8.84274170e-02f, 1.09048404e-01f, -2.04641875e-02f, -2.61113569e-02f, -2.68797167e-02f,
  -3.67287844e-02f, 9.90474038e-03f, -6.51436523e-02f, 7.06344694e-02f, 1.33879855e-01f, 3.77961323e-02f, -6.73396885e-02f, -1.05566896e-01f, 1.03471782e-02f, -1.62863042e-02f,
  -4.92754905e-03f, -8.72658789e-02f, 1.50933728e-01f, 8.10157880e-02f, -2.26880014e-01f, -2.50964314e-01f, 2.39790026e-02f, 1.39239743e-01f, -2.42444742e-02f, -2.96727628e-01f,
  -1.93359572e-02f, 4.23791856e-02f, 1.81189016e-01f, -2.03780338e-01f, 1.29588008e-01f, -3.23179483e-01f, -1.20652534e-01f, -2.47313455e-01f, 2.25291595e-01f, -7.20725209e-02f,
  4.10606191e-02f, 8.54717642e-02f, -7.01305084e-03f, 1.98506549e-01f, 2.06949621e-01f, -1.65916294e-01f, 1.13449641e-01f, -1.37131378e-01f, 6.21952452e-02f, -1.29052788e-01f,
  -7.47872517e-02f, 1.26464041e-02f, 2.57300399e-02f, 3.03051136e-02f, -9.66214389e-02f, 5.79833277e-02f, -1.19082838e-01f, 1.19830430e-01f, -3.75783630e-02f, 1.85367197e-01f,
  -8.64038318e-02f, 9.01703164e-02f, 1.29530311e-01f, 3.69981416e-02f, 6.01305626e-03f, -1.92440897e-02f, -4.72499356e-02f, -1.29326180e-01f, 1.49682820e-01f, 1.67660102e-01f,
  8.96652788e-02f, 1.36384860e-01f, -1.60816386e-02f, -3.08934581e-02f, 1.88792944e-02f, -2.57621761e-02f, -7.94340894e-02f, 6.87402999e-03f, 9.95782688e-02f, -4.06136997e-02f,
  -9.98195261e-02f, 1.81355625e-01f, 8.10974315e-02f, 1.10780448e-01f, 9.59810615e-02f, -1.41375676e-01f, 2.74861194e-02f, -1.38596017e-02f, 1.65367186e-01f, -7.13230297e-02f,
  -1.87881008e-01f, 7.81174153e-02f, 7.33692646e-02f, 9.80612487e-02f, -1.41203716e-01f, 2.13837132e-01f, -1.85614705e-01f, -2.25887060e-01f, -1.07234698e-02f, -2.22684406e-02f,
  -2.76866108e-01f, -8.08639005e-02f, 1.06415428e-01f, -1.15362003e-01f, 1.35983318e-01f, -9.99442264e-02f, 7.52971023e-02f, 9.94242430e-02f, 1.70387655e-01f, -2.02231258e-01f,
  -6.84206858e-02f, -1.45678028e-01f, 4.57256958e-02f, 3.91620910e-03f, -1.21419609e-01f, -3.88954543e-02f, 5.59247769e-02f, 1.06718473e-01f, -1.08991124e-01f, -4.52640317e-02f,
  -9.57378522e-02f, 4.01822701e-02f, -1.49160266e-01f, 2.38796044e-02f, -3.48230638e-02f, -2.58989614e-02f, 7.58138448e-02f, 1.14931747e-01f, -6.23059869e-02f, 1.30332948e-03f,
  4.61325496e-02f, 2.75440589e-02f, 1.97911635e-01f, 1.10571772e-01f, -2.06641983e-02f, 1.16882496e-01f, 3.54184061e-02f, -8.29626545e-02f, 2.27217004e-02f, 1.56351209e-01f,
  -2.50080764e-01f, -7.58789778e-02f, -1.02517880e-01f, -5.79107441e-02f, 1.58836856e-01f, 1.14207841e-01f, -3.29750553e-02f, -9.05954763e-02f, -4.02550064e-02f, -5.85215613e-02f,
  -1.07859328e-01f, 1.43043593e-01f, -2.55821466e-01f, -1.61893249e-01f, -4.40033078e-02f, 5.00351228e-02f, -2.89365947e-01f, -1.23896405e-01f, -3.62645723e-02f, 1.52426869e-01f,
  5.05189784e-03f, -1.76379085e-01f, 1.94963589e-01f, -2.09147111e-01f, 8.79939348e-02f, -2.81819612e-01f, -2.86293570e-02f, 7.51156881e-02f, 5.39000903e-05f, 1.73457086e-01f,
  -6.96926704e-03f, 4.45551351e-02f, 1.48582771e-01f, 5.04030287e-02f, 2.77925879e-01f, -3.63727915e-03f, 9.58068818e-02f, -3.25073421e-01f, -1.14621602e-01f, -1.25294864e-01f,
  1.01982154e-01f, -7.45932832e-02f, 2.49169450e-02f, 6.30837679e-02f, 1.02420121e-01f, 1.04778662e-01f, -1.73123553e-01f, -1.68638546e-02f, -1.82501629e-01f, -5.94189242e-02f,
  -1.10671990e-01f, -1.23776607e-01f, 4.44014072e-02f, 8.51770267e-02f, 8.83581340e-02f, 7.19408393e-02f, -5.04381619e-02f, 1.76035054e-02f, -1.65302053e-01f, 3.27348895e-02f,
  -8.40438008e-02f, -3.68914753e-02f, -1.12342715e-01f, 1.43605517e-02f, -1.64284289e-01f, -1.32884327e-02f, -5.07505201e-02f, 6.04015812e-02f, 1.27071708e-01f, 1.51240095e-01f,
  -2.40118086e-01f, -1.96632389e-02f, -5.74379740e-03f, -8.35985243e-02f, -1.13863096e-01f, 8.97920877e-02f, -2.80599415e-01f, -4.41675410e-02f, -2.08570212e-01f, -6.64078966e-02f,
  -2.58269250e-01f, -1.51357934e-01f, 1.43963054e-01f, 4.14812826e-02f, 1.00795053e-01f, 3.52937095e-02f, -2.06023917e-01f, -1.84117660e-01f, -1.86970338e-01f, 5.52210882e-02f,
  1.85040802e-01f, -8.38224217e-02f, -1.62516996e-01f, 1.52187571e-01f, 3.05680037e-02f, 2.13315353e-01f, -6.20956235e-02f, -5.17634787e-02f, 2.85968721e-01f, -4.24455032e-02f,
  -1.26679949e-02f, -1.38560340e-01f, 3.90413068e-02f, 2.55121943e-02f, -4.41513136e-02f, -1.05857946e-01f, 2.03052595e-01f, 1.50602356e-01f, -1.34540237e-02f, 1.03979044e-01f,
  -2.24174052e-01f, 1.95266739e-01f, -1.57202244e-01f, -2.22236380e-01f, -4.94265296e-02f, -1.21769205e-01f, 1.12226292e-01f, -1.88123867e-01f, 6.44300729e-02f, 1.31614748e-02f,
  3.80182341e-02f, 2.16600150e-02f, 2.37309709e-02f, 1.85841359e-02f, -1.10805899e-01f, -3.88399772e-02f, 1.43455446e-01f, 2.08646394e-02f, 1.75189301e-01f, 6.67824894e-02f,
  -2.23187059e-01f, -1.41526788e-01f, 2.55131841e-01f, -1.89901277e-01f, 8.74026194e-02f, -2.31030397e-02f, -1.45047560e-01f, 2.92900145e-01f, 4.65690158e-02f, -3.86033719e-03f,
  5.48603795e-02f, -6.08230084e-02f, 6.75609559e-02f, 4.89256345e-02f, -2.81103961e-02f, -2.55898803e-01f, -2.69364510e-02f, 1.55124038e-01f, 2.16914564e-01f, 6.10597692e-02f,
  2.88361847e-01f, -7.38755390e-02f, 2.17067331e-01f, -1.43723860e-01f, -1.24254502e-01f, 2.15490296e-01f, -2.33508572e-02f, 1.50602460e-01f, 2.24998534e-01f, -1.21009551e-01f,
  1.61960259e-01f, 1.07243486e-01f, 1.55189440e-01f, -9.79849845e-02f, 7.95628354e-02f, 1.64824739e-01f, 4.92167249e-02f, 5.63148558e-02f, 1.22584127e-01f, 1.26547679e-01f,
  -3.22258294e-01f, 1.24726623e-01f, -4.40544002e-02f, 2.92627569e-02f, 2.12537438e-01f, -1.07303523e-01f, -9.30267852e-03f, 4.54150513e-02f, 6.77528232e-02f, -2.21760385e-02f,
  -6.07660264e-02f, -1.26891639e-02f, 5.00329994e-02f, -1.04166217e-01f, -1.87911525e-01f, 6.84896193e-04f, -1.20365016e-01f, 6.08629640e-03f, -5.21313921e-02f, 9.24469084e-02f,
  -5.59194200e-02f, 6.22512884e-02f, -8.88995919e-03f, -1.13866463e-01f, 1.03967644e-01f, -8.60146210e-02f, -8.75723884e-02f, 4.04122546e-02f, -2.22035442e-02f, -8.09071120e-03f,
  2.48424634e-02f, -2.49919653e-01f, 4.95781703e-03f, -1.49160504e-01f, -7.52700679e-03f, 5.95654473e-02f, -1.96226686e-01f, 8.15686136e-02f, 9.74365510e-03f, 5.24762236e-02f,
  1.18865192e-01f, 9.64863971e-02f, -2.39511117e-01f, 5.18840784e-03f, -2.84143597e-01f, 1.36091188e-01f, -2.16832399e-01f, 2.58869659e-02f, 1.62039742e-01f, -2.52721220e-01f,
  -2.34619249e-02f, -1.10613024e-02f, -3.33239809e-02f, 4.85183746e-02f, -1.54170483e-01f, 3.12726828e-03f, -1.69912741e-01f, -8.60252604e-02f, -1.44043729e-01f, 1.36681154e-01f,
  -4.36984897e-02f, -1.50145859e-01f, -4.62384112e-02f, 6.17528073e-02f, 2.51438767e-01f, 1.42012373e-01f, -6.94051012e-02f, 1.38096556e-01f, -3.41971754e-03f, -1.24095427e-02f,
  2.02597380e-01f, 1.89013109e-02f, -9.10312310e-02f, -1.10119410e-01f, -7.09922835e-02f, -7.77530447e-02f, -4.08999622e-03f, -8.66977032e-03f, -1.48591116e-01f, 7.00910687e-02f,
  2.12349314e-02f, -1.34225488e-01f, 4.63945270e-02f, -1.61725283e-01f, -1.69714704e-01f, -5.22396713e-02f, -8.09526667e-02f, 3.69376689e-02f, -1.76288784e-01f, -1.51120638e-02f,
  1.64698929e-01f, -1.41445756e-01f, 1.42179146e-01f, -7.51777813e-02f, -1.04264215e-01f, 1.28512859e-01f, -5.58986850e-02f, -1.12405583e-01f, 6.81240708e-02f, 1.90718293e-01f,
  2.31815919e-01f, 2.94281226e-02f, -2.02648118e-02f, 1.29895657e-01f, 9.41212997e-02f, -1.33861676e-01f, 7.97398761e-02f, 1.42342255e-01f, 1.17844313e-01f, 2.04781145e-01f,
  1.88197240e-01f, 2.11993933e-01f, -7.83982649e-02f, 1.82988420e-01f, 2.83712707e-02f, 6.30209967e-02f, -1.87501758e-01f, -1.12457968e-01f, -9.75987762e-02f, 3.09221119e-01f,
  -4.83983383e-02f, 2.25792408e-01f, 2.71512605e-02f, -9.21937227e-02f, 6.44392893e-02f, 4.49423045e-02f, 5.00933174e-03f, -1.03151880e-01f, -5.79914153e-02f, -2.32257381e-01f,
  -4.03007120e-03f, -9.96061414e-02f, 8.82987902e-02f, -1.41808376e-01f, -1.55201271e-01f, -6.15501776e-02f, 1.45832583e-01f, 1.12936459e-01f, 1.70980878e-02f, -1.22957587e-01f,
  4.64695953e-02f, 1.38610611e-02f, -1.11439498e-02f, -8.63430873e-02f, -1.26613647e-01f, -5.22780493e-02f, -6.28917590e-02f, -1.77165106e-01f, 1.96482703e-01f, 7.21184909e-02f,
  -1.78270712e-02f, 6.73784167e-02f, -1.51931077e-01f, -9.68860462e-02f, 1.29747525e-01f, -1.56074241e-02f, 1.23732723e-01f, -1.19237512e-01f, -4.35612015e-02f, 2.53545493e-01f,
  4.56935689e-02f, -2.72362661e-02f, 9.15097892e-02f, 4.79437858e-02f, -2.42104813e-01f, 9.69270766e-02f, -7.00263381e-02f, 5.77154383e-02f, -5.59538603e-02f, 1.15754493e-01f,
  1.20662667e-01f, 2.01983303e-02f, 2.56635725e-01f, -1.53742000e-01f, 6.44803047e-02f, -1.53248325e-01f, -2.39697210e-02f, -1.15500102e-02f, -2.44054541e-01f, 2.04706892e-01f,
  3.64883453e-01f, -2.51945943e-01f, 8.49880651e-03f, 5.22034056e-02f, 1.52053252e-01f, -1.99568495e-01f, 1.43815661e-02f, 6.48228377e-02f, -9.38823968e-02f, -1.46072090e-01f,
  5.23234308e-02f, -2.98553202e-02f, -2.95907915e-01f, 8.69933665e-02f, 1.71341702e-01f, 9.97925028e-02f, -7.14071244e-02f, -1.06970929e-01f, 1.63995504e-01f, 9.55072269e-02f,
  -7.53533095e-02f, 1.28456121e-02f, -1.64677516e-01f, 1.11500561e-01f, 2.37695202e-02f, 1.47558585e-01f, -5.41369095e-02f, 5.44405170e-02f, 4.72765826e-02f, 1.33136526e-01f,
  -3.39272022e-02f, 5.72253764e-02f, 2.05462165e-02f, 8.76264647e-02f, -2.73647010e-01f, 7.49631450e-02f, -8.45440105e-02f, -9.20282304e-02f, 1.33713320e-01f, -5.78253791e-02f,
  -1.11390486e-01f, 5.19641191e-02f, 2.92936191e-02f, -7.93583021e-02f, -1.16530307e-01f, -1.69128589e-02f, 1.18243098e-01f, 4.60707322e-02f, 1.64346844e-01f, -7.88946226e-02f,
  -8.84441733e-02f, 2.03424111e-01f, 6.06361441e-02f, 7.18041435e-02f, -4.00883481e-02f, -1.84218794e-01f, 1.23878224e-02f, 7.82909468e-02f, 2.86008835e-01f, 1.55596957e-01f,
  -1.67491466e-01f, -1.29566371e-01f, 1.19332939e-01f, 4.47274409e-02f, 2.75499350e-03f, -1.38455287e-01f, 2.36336980e-02f, 1.98587105e-01f, 3.56942713e-02f, 2.41003290e-01f,
  -1.67753339e-01f, 6.37030900e-02f, 1.21283727e-02f, 1.31323949e-01f, -1.96820170e-01f, -6.39259368e-02f, 2.79952228e-01f, 7.13085458e-02f, 2.06033185e-01f, -3.34757045e-02f,
  1.08006030e-01f, -1.74964190e-01f, -1.52011439e-01f, -2.65154056e-02f, -8.57720226e-02f, -1.67219210e-02f, -2.74636056e-02f, -9.92828608e-02f, -8.98213983e-02f, -1.03789546e-01f,
  1.19193502e-01f, -1.72549069e-01f, 3.09120137e-02f, -9.81887802e-02f, -6.92225546e-02f, -2.78577451e-02f, 2.19464768e-02f, -8.29159617e-02f, 1.41436115e-01f, -1.32512391e-01f,
  8.45236853e-02f, -1.03851661e-01f, 1.72420606e-01f, 7.11872429e-02f, -1.01589575e-01f, 9.84129459e-02f, -2.63002614e-04f, -1.88010780e-03f, 6.70711920e-02f, 5.44240959e-02f,
  -9.89491567e-02f, -1.98858939e-02f, -1.39022186e-01f, 1.15377479e-03f, -5.55571243e-02f, -2.68077940e-01f, -1.13018252e-01f, 1.25125930e-01f, 6.21500276e-02f, -5.15570752e-02f,
  -8.55781585e-02f, -2.85785377e-01f, -8.93601999e-02f, -1.08805686e-01f, 1.58622071e-01f, -2.86986738e-01f, -2.06640154e-01f, 2.38704219e-01f, 2.67320603e-01f, 1.06920622e-01f,
  -6.23189993e-02f, -1.22674659e-01f, 2.59970784e-01f, -1.29953176e-01f, -7.74462819e-02f, 4.40202691e-02f, 1.62943095e-01f, -4.00818698e-02f, -2.04545572e-01f, 1.10056605e-02f,
  -1.01925254e-01f, 1.59868747e-01f, -1.88804731e-01f, 1.28697857e-01f, -1.80393964e-01f, 3.22484374e-01f, 2.40727022e-01f, -9.37087089e-02f, 4.80366163e-02f, 1.32566215e-02f,
  1.41920835e-01f, 2.13600114e-01f, -8.41109082e-02f, -1.08057760e-01f, -9.07484218e-02f, -3.75471544e-03f, 3.74951437e-02f, 1.11600667e-01f, 1.69488788e-02f, -8.34106281e-02f,
  4.56868783e-02f, -2.01727003e-01f, -8.55685547e-02f, 9.33350548e-02f, 1.32081971e-01f, 3.42948474e-02f, -1.89631820e-01f, 1.97079591e-02f, 7.92658180e-02f, -1.83736105e-02f,
  1.03523396e-01f, 2.49048620e-02f, 1.13514088e-01f, -2.28683427e-02f, 1.11794323e-01f, 1.02657981e-01f, -9.42705199e-02f, -1.91286772e-01f, 7.74803534e-02f, 2.71323949e-01f,
  1.60180390e-01f, 1.88213568e-02f, -4.41190861e-02f, 8.81952122e-02f, -2.47254103e-01f, 2.17992395e-01f, -3.30901265e-01f, 2.58302569e-01f, 3.94849367e-02f, -7.54133090e-02f,
  -1.74909428e-01f, -1.87246814e-01f, 9.65503976e-02f, -7.89728090e-02f, -3.61170955e-02f, -5.17436396e-03f, 2.46011885e-03f, -6.08055443e-02f, 4.09867708e-03f, -1.63323984e-01f,
  8.54929909e-02f, 7.68895745e-02f, 3.85349207e-02f, -4.46668491e-02f, 1.67230800e-01f, -1.26309380e-01f, 1.35955811e-01f, 8.65241960e-02f, -3.75918932e-02f, 9.87329483e-02f,
  -3.58592086e-02f, -1.82717860e-01f, 4.43291627e-02f, 4.90630697e-03f, -2.02436317e-02f, 8.90799090e-02f, 2.48616897e-02f, -6.02690615e-02f, -4.52203378e-02f, 2.52294987e-02f,
  2.35334709e-02f, 4.63792421e-02f, 1.37539729e-01f, -5.27773565e-03f, -1.70625485e-02f, -3.36919390e-02f, -7.94139653e-02f, 7.90564492e-02f, 4.11390364e-02f, -1.03942506e-01f,
  5.12949191e-03f, 8.49566758e-02f, -1.04460523e-01f, -1.60389572e-01f, 4.88078631e-02f, -1.81459505e-02f, -1.00002609e-01f, -7.03862160e-02f, 3.42903376e-01f, 2.10919335e-01f,
  -2.05792665e-01f, 3.90725583e-02f, 4.55377847e-02f, 3.65197152e-01f, 4.94262427e-02f, 5.78183383e-02f, -2.00341091e-01f, -1.34780928e-01f, -1.58941031e-01f, 1.47821441e-01f,
  8.02682489e-02f, -1.14820816e-01f, -6.99248910e-02f, -2.06232682e-01f, -8.25285271e-04f, -1.16608672e-01f, 2.62859553e-01f, -1.66034952e-01f, 7.29639456e-02f, 2.45443135e-02f,
  -2.42274880e-01f, -6.14881590e-02f, -1.83858693e-01f, 6.78801686e-02f, 5.27719222e-02f, -8.15075263e-02f, -2.42139116e-01f, -5.64391613e-02f, 1.05187744e-01f, -5.57243116e-02f,
  1.62029043e-01f, 1.15101028e-03f, -7.94233680e-02f, -3.56021710e-02f, 1.48676306e-01f, -8.87225121e-02f, -6.86876401e-02f, 2.40693484e-02f, 7.42445737e-02f, -6.22322150e-02f,
  -7.92940035e-02f, -7.23840967e-02f, -1.29163149e-03f, -9.04875472e-02f, 6.88343719e-02f, -4.20600995e-02f, 4.84547531e-03f, 6.63239211e-02f, -2.98943333e-02f, -7.76669532e-02f,
  1.90517455e-01f, 8.44493136e-02f, -4.13633920e-02f, -7.73628131e-02f, -6.25623390e-02f, 3.47500779e-02f, -4.78703789e-02f, -1.70291718e-02f, -2.19181590e-02f, 1.64771855e-01f,
  3.79863679e-02f, 1.24068320e-01f, 1.86214939e-01f, 3.99632528e-02f, -2.08116740e-01f, -7.31190145e-02f, 1.55995667e-01f, 5.25627434e-02f, 1.04520343e-01f, 5.53483404e-02f,
  6.48805499e-02f, 2.25707948e-01f, -8.66803080e-02f, 1.05972067e-02f, -1.45326093e-01f, 3.60390395e-02f, -7.43182600e-02f, 5.84766380e-02f, -1.19153075e-01f, -2.83277392e-01f,
  9.81475562e-02f, -5.56225255e-02f, 3.46024185e-02f, -1.28982201e-01f, -3.64470720e-01f, -5.33903129e-02f, 6.15297183e-02f, 2.46167213e-01f, 8.39392543e-02f, -5.43186851e-02f,
  1.05763055e-01f, 1.74225464e-01f, -9.74237323e-02f, -6.19031526e-02f, 8.38767365e-02f, 1.38385385e-01f, -1.02242246e-01f, -2.51604676e-01f, 2.18713775e-01f, 2.85470560e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  4.97262403e-02f, 2.04041645e-01f, 9.70243290e-02f, 9.20360982e-02f, 8.22766274e-02f, -1.20162979e-01f, 1.12792533e-02f, 2.15120375e-01f, 5.06118797e-02f, 1.66519284e-01f,
  2.56647971e-02f, 1.34726897e-01f, 2.91124880e-02f, 9.17229056e-02f, 6.95053264e-02f, 1.99281365e-01f, -9.08759236e-03f, 3.98211926e-02f, -4.32055956e-03f, 2.61497423e-02f,
  1.72286779e-01f, 4.12799045e-02f, 8.83721635e-02f, -1.18189216e-01f, -1.39143392e-02f, 4.58624810e-02f, -3.82789411e-02f, -1.01576760e-01f, -6.83712810e-02f, -4.91263680e-02f,
  3.30914371e-02f, 1.30329177e-01f, 8.53251144e-02f, -1.29337609e-01f, -1.14549689e-01f, 1.03899218e-01f, 3.19769718e-02f, 2.29236007e-01f, -1.91272795e-01f, 2.14221045e-01f,
  1.10058188e-01f, -5.07285520e-02f, -6.66786283e-02f, -2.70763159e-01f, -1.64017424e-01f, 1.34750605e-01f, -1.02707192e-01f, -2.66919732e-01f, -2.42569879e-01f, 1.51906535e-01f,
  -1.10178925e-02f, -1.63129300e-01f, -6.08625710e-02f, -1.81115232e-02f, 7.11456612e-02f, 1.17933147e-01f, 4.43872698e-02f, -4.39761691e-02f, -2.54734177e-02f, -7.70899877e-02f,
  -1.23310372e-01f, 1.32062100e-02f, 1.37545645e-01f, 1.25760704e-01f, 4.71100919e-02f, 6.64304346e-02f, 1.10384732e-01f, 1.07166126e-01f, -5.12632206e-02f, -7.68284574e-02f,
  1.96191967e-01f, 1.70792311e-01f, 1.07422315e-01f, -4.41579334e-02f, -1.06228441e-02f, 8.38778839e-02f, 1.27971217e-01f, -1.02586232e-01f, 3.14663760e-02f, 1.91656217e-01f,
  6.02008663e-02f, -1.45157222e-02f, -2.97968509e-03f, -8.39465857e-02f, 1.15901187e-01f, 1.04278818e-01f, -4.73437421e-02f, -8.99938643e-02f, 1.11512907e-01f, 1.54738322e-01f,
  -5.40142246e-02f, 3.68401445e-02f, -8.23347792e-02f, -6.85756728e-02f, 2.05900118e-01f, 4.11700942e-02f, 1.49041623e-01f, -2.35405173e-02f, 2.76193395e-03f, 5.11950366e-02f,
  9.26765241e-03f, 7.62876794e-02f, -1.48991928e-01f, 2.33897399e-02f, 7.65146613e-02f, 1.07616402e-01f, -3.73574235e-02f, -2.53269047e-01f, 3.97536270e-02f, 7.51781985e-02f,
  9.80274230e-02f, -1.24609821e-01f, -2.38121510e-01f, 1.06885388e-01f, 9.52887163e-02f, 1.25940386e-02f, -1.94342770e-02f, 4.74692136e-02f, 1.49449244e-01f, 1.11297436e-01f,
  -1.93143636e-01f, -8.03285465e-03f, 1.91093944e-02f, -1.04915336e-01f, -3.15720662e-02f, 4.77226004e-02f, -8.61096084e-02f, 1.44138351e-01f, 5.45092933e-02f, 4.81598675e-02f,
  -1.59554500e-02f, 9.90686566e-03f, 1.05073452e-01f, 1.72895923e-01f, 1.67836770e-01f, 2.08257437e-01f, 4.25666608e-02f, 6.82295114e-02f, 5.87940253e-02f, -8.39249864e-02f,
  1.28443688e-01f, 2.08880138e-02f, -6.83121160e-02f, 1.81511074e-01f, 1.84559282e-02f, 3.32109779e-02f, 2.48065852e-02f, -3.16188000e-02f, 1.95906416e-01f, 4.81092222e-02f,
  -4.75406274e-02f, 1.88239291e-01f, -4.87575382e-02f, -8.60964358e-02f, -9.86667052e-02f, -1.29810154e-01f, 2.62904078e-01f, 1.06631979e-01f, -1.25130579e-01f, 3.98913585e-03f,
  -1.08666189e-01f, 2.97036245e-02f, 9.06749964e-02f, -1.84614450e-01f, 2.90579379e-01f, -1.54949024e-01f, 3.34328026e-01f, -1.36229783e-01f, -1.05642371e-01f, 3.47347766e-01f,
  2.29005858e-01f, 8.70804861e-02f, -1.58838242e-01f, -1.38386130e-01f, 2.04954177e-01f, 1.20495178e-01f, 1.49746448e-01f, 1.36942342e-01f, 5.31305894e-02f, -3.29752229e-02f,
  -1.38464794e-01f, 2.01571524e-01f, 1.11773796e-01f, 1.20747179e-01f, 6.59100013e-03f, -1.55674160e-01f, 7.81859308e-02f, -3.37172933e-02f, 1.04799382e-01f, -1.01070575e-01f,
  1.71073657e-02f, 1.46887287e-01f, -8.62435997e-02f, -5.83541952e-02f, 3.92380394e-02f, -1.01597600e-01f, 9.24745500e-02f, 5.58205023e-02f, 1.66327432e-02f, -7.08153993e-02f,
  -9.45975706e-02f, 4.62523103e-02f, 1.14519320e-01f, -1.43897282e-02f, -1.16828065e-02f, 1.32551551e-01f, -1.30074486e-01f, -5.74160777e-02f, 1.37077406e-01f, -9.71470475e-02f,
  9.12015960e-02f, -5.12274504e-02f, -9.83360782e-02f, 5.71790077e-02f, -1.04394205e-01f, 5.46662509e-02f, 1.27870396e-01f, 3.71079259e-02f, -4.37394008e-02f, -2.74827555e-02f,
  -9.34257582e-02f, -7.89015442e-02f, -4.33287099e-02f, 3.00811194e-02f, -9.12235305e-02f, -2.96178628e-02f, 4.32201698e-02f, -3.38132419e-02f, 1.03112198e-02f, 3.84738222e-02f,
  -9.49269384e-02f, -1.02031276e-01f, 4.05052640e-02f, -8.87724385e-02f, 7.67358840e-02f, 9.70392674e-02f, 7.01717436e-02f, 2.32719220e-02f, 1.02103144e-01f, -1.38166379e-02f,
  1.40940458e-01f, -6.26897514e-02f, -6.99104667e-02f, -8.40107203e-02f, -1.10161871e-01f, -2.55488940e-02f, -9.60563123e-02f, 8.99821594e-02f, 1.35123283e-01f, 1.26828894e-01f,
  -1.02272756e-01f, 5.13234958e-02f, -7.00784400e-02f, -1.20082553e-02f, -9.73499031e-04f, 7.44507164e-02f, 7.25690573e-02f, 9.77476835e-02f, -5.64743504e-02f, -7.87340999e-02f,
  1.18968062e-01f, 5.09483553e-03f, -7.89999068e-02f, 1.06804602e-01f, -6.64465502e-03f, -2.62141936e-02f, 2.47322038e-01f, -8.98907036e-02f, 2.00493664e-01f, -7.38523155e-02f,
  1.52279705e-01f, 1.67509824e-01f, -6.42863065e-02f, 3.58501039e-02f, 2.59971857e-01f, 7.35310698e-03f, 5.33393063e-02f, 4.55885455e-02f, 1.64645031e-01f, 1.72209945e-02f,
  6.24980778e-02f, 9.19817761e-02f, 4.05121259e-02f, 6.60316497e-02f, -1.28673529e-02f, -1.53529316e-01f, -1.47814348e-01f, -2.86202729e-01f, 6.49345964e-02f, 1.10140026e-01f,
  2.51986861e-01f, -1.31842256e-01f, 6.28114212e-03f, -1.39249995e-01f, 7.22914636e-02f, 8.78409073e-02f, 9.30243507e-02f, -1.07432723e-01f, -1.56954825e-01f, -2.38067415e-02f,
  -4.67206500e-02f, -1.62383586e-01f, -1.10425808e-01f, -1.21256337e-01f, 1.74396157e-01f, 1.05647305e-02f, -8.02850425e-02f, -1.43475384e-01f, -1.83283221e-02f, -4.35031066e-03f,
  -1.55110061e-01f, 1.06113546e-01f, -1.01385102e-01f, 7.44204670e-02f, 8.93519521e-02f, -8.82590711e-02f, -1.84414815e-02f, 3.04247826e-01f, 1.76512748e-01f, 7.85831064e-02f,
  3.73977423e-02f, 1.95598423e-01f, 1.80420578e-01f, 1.07103206e-01f, 1.70801669e-01f, 3.93773168e-02f, 6.07292615e-02f, 8.52785185e-02f, 9.58345085e-02f, 1.83672920e-01f,
  1.21577397e-01f, 2.20282286e-01f, 8.25061873e-02f, 2.45609164e-01f, 5.51059172e-02f, 2.39606604e-01f, 6.15510419e-02f, 1.61997929e-01f, -7.36245438e-02f, -3.97825986e-03f,
  3.99454348e-02f, -3.48166525e-02f, 7.57829845e-02f, 1.47809878e-01f, -3.65160145e-02f, -3.85193378e-02f, 4.13780175e-02f, 2.64397240e-03f, -1.43679017e-02f, 1.29782200e-01f,
  8.32825154e-03f, 1.48488179e-01f, -2.30784640e-01f, 1.37790516e-02f, -2.09333509e-01f, -5.07261343e-02f, 2.63871878e-01f, 4.79531139e-02f, 1.80978309e-02f, -2.93568403e-01f,
  -1.36185795e-01f, 2.14200974e-01f, 3.02415431e-01f, -1.88702658e-01f, -7.63156712e-02f, 1.72793031e-01f, 2.34065235e-01f, -2.00803742e-01f, -1.15021028e-01f, -1.21697664e-01f,
  -1.55543052e-02f, -1.53650627e-01f, -1.06892049e-01f, -7.65324906e-02f, -4.10484709e-02f, 1.87477961e-01f, -1.74519662e-02f, -1.42841665e-02f, 5.24803214e-02f, 2.38683093e-02f,
  -4.92792539e-02f, -1.21595062e-01f, -1.41319126e-01f, 1.47795886e-01f, 1.81370825e-01f, 1.11325927e-01f, 1.36144280e-01f, 1.68588176e-01f, 1.74972177e-01f, 2.63145845e-02f,
  7.85268024e-02f, 2.47830562e-02f, -9.09304526e-03f, 1.42024070e-01f, 4.16937098e-02f, -4.02953802e-03f, 1.03391938e-01f, 1.33361146e-02f, 2.32042070e-03f, 1.59211010e-01f,
  1.55446768e-01f, 1.99269101e-01f, 1.68661103e-01f, 1.38207391e-01f, 7.25778490e-02f, -8.46587941e-02f, -7.62233734e-02f, -1.30222753e-01f, 1.55126482e-01f, -1.30903674e-02f,
  5.91026992e-02f, 2.67671254e-02f, 1.53095141e-01f, 1.86430030e-02f, -2.56589383e-01f, 1.96927428e-01f, 1.19319580e-01f, -1.82532072e-02f, -1.01326786e-01f, -1.94800079e-01f,
  -4.94192764e-02f, 4.92096804e-02f, -5.83804445e-03f, 3.95336524e-02f, 1.49407893e-01f, -4.51175962e-03f, -1.07940130e-01f, 2.14850590e-01f, -1.48679048e-01f, -2.49135196e-02f,
  -1.64959162e-01f, 1.24008290e-01f, 1.88098431e-01f, 2.11533625e-02f, -1.58770457e-01f, -1.20435946e-01f, -1.04453109e-01f, 8.43889415e-02f, -2.36153230e-01f, -7.72453994e-02f,
  2.44568482e-01f, 1.55906096e-01f, 1.91302910e-01f, -1.45798981e-01f, -2.40350943e-02f, 3.12336385e-01f, -8.83494765e-02f, -7.23282471e-02f, 9.41089317e-02f, 3.27929109e-02f,
  8.40071142e-02f, 1.49329618e-01f, -6.54494986e-02f, 1.48872167e-01f, 1.38336658e-01f, 1.72211066e-01f, 1.84665591e-01f, -1.00556813e-01f, 1.79657917e-02f, -6.81967065e-02f,
  1.74550619e-02f, 1.31809795e-02f, 8.92382041e-02f, 1.53814510e-01f, 6.09688498e-02f, 7.31339529e-02f, 1.01501234e-01f, 1.49629563e-01f, 3.52349877e-02f, -7.94123411e-02f,
  8.73492733e-02f, 7.18108863e-02f, 1.44309223e-01f, -2.82648522e-02f, -1.15945809e-01f, -8.05176795e-02f, 1.70047395e-02f, 1.81786314e-01f, 1.28638878e-01f, 7.44856000e-02f,
  -1.37394937e-02f, 1.18579865e-01f, -3.39662023e-02f, -1.44868299e-01f, 1.59152612e-01f, 8.87430161e-02f, 3.84761505e-02f, -2.79015183e-01f, -5.05973352e-03f, 1.38581246e-01f,
  1.32427081e-01f, 8.97618607e-02f, 1.08323365e-01f, -2.50390824e-03f, 1.33799061e-01f, -1.73224106e-01f, -1.20088108e-01f, -1.91779822e-01f, 7.91750848e-02f, -1.21325422e-02f,
  -7.62453899e-02f, -1.27163798e-01f, 7.66346464e-03f, 1.20073140e-01f, 5.44705614e-02f, 9.23183709e-02f, 4.57287729e-02f, 5.97352255e-03f, -5.92768304e-02f, -1.40955776e-01f,
  -1.88541055e-01f, -2.37125140e-02f, 1.00726321e-01f, 1.35171071e-01f, 5.07810153e-02f, 5.06810024e-02f, 1.35105491e-01f, 1.18387816e-02f, 3.88595670e-01f, 2.15735704e-01f,
  1.95958503e-02f, -9.53615457e-03f, 8.86352211e-02f, 3.66066433e-02f, 1.39021322e-01f, 2.47225285e-01f, 4.80197407e-02f, 3.58788334e-02f, 8.70484635e-02f, 3.43187340e-02f,
  1.60850391e-01f, 1.10925302e-01f, 8.27839747e-02f, 1.36938527e-01f, 1.17536001e-01f, 2.12201849e-01f, 1.49029447e-02f, 1.43987358e-01f, -1.58803031e-01f, -1.69107750e-01f,
  -2.50516355e-01f, 1.15778439e-01f, 1.40022412e-01f, -3.01841676e-01f, -1.45905167e-02f, 2.11152911e-01f, -8.63547474e-02f, 2.59364814e-01f, 1.03194088e-01f, -7.08928779e-02f,
  -1.01152877e-03f, -2.97921300e-01f, 1.85655266e-01f, 1.59088209e-01f, -1.53616890e-02f, 1.75054163e-01f, 2.32427493e-01f, -2.88916472e-03f, 1.78585634e-01f, -3.06806535e-01f,
  -1.25638574e-01f, -2.78072327e-01f, 7.91719481e-02f, 1.04917511e-01f, -5.94737194e-02f, -1.23695873e-01f, 2.82924294e-01f, -4.99242954e-02f, -8.79487023e-02f, 2.86634266e-01f,
  -2.03866273e-01f, 2.07417294e-01f, -1.02313392e-01f, -8.73778686e-02f, -1.96660478e-02f, 1.28970310e-01f, 1.21710867e-01f, -5.33647612e-02f, 3.19960080e-02f, -3.80058028e-02f,
  -1.01506233e-01f, 8.16926584e-02f, 5.38651161e-02f, 8.59609619e-02f, -8.77866298e-02f, 3.29743996e-02f, 7.94958398e-02f, -7.15549961e-02f, 5.83971627e-02f, -5.66932969e-02f,
  -8.64959359e-02f, 7.33118225e-03f, 8.29587281e-02f, 9.23481807e-02f, -3.33233476e-02f, 1.09844217e-02f, 1.37173876e-01f, 2.81837992e-02f, -1.00124277e-01f, 5.33769913e-02f,
  -2.83568818e-02f, 2.47737598e-02f, -1.03518004e-02f, 5.27468622e-02f, -7.12364987e-02f, 6.22325763e-02f, -6.40572384e-02f, 4.59300950e-02f, 1.81028508e-02f, 1.15644030e-01f,
  2.24078894e-02f, 7.71815330e-02f, 2.91466527e-02f, -3.46914567e-02f, 8.80192071e-02f, -6.77453876e-02f, -1.24279149e-01f, 5.74714877e-02f, 4.58105840e-02f, -1.10194772e-01f,
  -8.79418552e-02f, -1.53184369e-01f, -2.46830378e-02f, -6.34047985e-02f, -8.31361413e-02f, 4.56336513e-02f, -6.87507838e-02f, 1.20382592e-01f, -9.14286226e-02f, -7.39729553e-02f,
  1.38832137e-01f, 1.35608211e-01f, -1.13263726e-01f, -1.88658759e-02f, 4.08382080e-02f, -8.59236047e-02f, 2.78191771e-02f, 1.25372782e-01f, 4.31414060e-02f, 8.99038985e-02f,
  1.53160647e-01f, 1.74703673e-01f, 4.20325398e-02f, -4.92774248e-02f, 1.21177830e-01f, 9.47824940e-02f, 1.55783847e-01f, -4.01628725e-02f, 3.11103836e-03f, 1.18560687e-01f,
  2.77678706e-02f, -3.21992785e-02f, 5.83352111e-02f, -2.78578475e-02f, 4.20526341e-02f, -8.09348226e-02f, -3.64693329e-02f, 2.16563970e-01f, 1.14302253e-02f, 8.18029046e-02f,
  1.21146962e-01f, 1.00366492e-02f, -5.18783890e-02f, -8.08955878e-02f, 7.23147914e-02f, 6.25463054e-02f, -1.84795544e-01f, 6.74493238e-02f, 1.45948559e-01f, 6.88887239e-02f,
  -1.22692540e-01f, -2.17896044e-01f, -7.67825618e-02f, 2.00992413e-02f, -3.76689546e-02f, -1.08356230e-01f, 1.18792877e-01f, -1.36308968e-01f, 1.01905271e-01f, -1.15626212e-02f,
  -3.31274085e-02f, -4.23894189e-02f, 9.20046642e-02f, 9.18271393e-03f, 1.00969844e-01f, 6.04134873e-02f, 1.17299356e-01f, 1.20484672e-01f, 2.86508709e-01f, -1.09175490e-02f,
  1.42685156e-02f, 1.00108862e-01f, -5.79179749e-02f, 1.85106426e-01f, -1.45732999e-01f, -1.08645961e-01f, 3.41126956e-02f, -3.22399400e-02f, -3.19863223e-02f, 1.85261783e-03f,
  1.41694546e-01f, 2.67836124e-01f, 1.12431504e-01f, -5.34919463e-02f, 6.38413653e-02f, 8.58692005e-02f, -6.79821372e-02f, 1.43250883e-01f, -5.74474409e-03f, 2.72404365e-02f,
  -1.29668601e-02f, -1.03430912e-01f, 1.14086665e-01f, -5.19210435e-02f, -5.84272482e-02f, 1.08356670e-01f, 1.61530584e-01f, -2.73197163e-02f, 2.13864297e-01f, -7.75740147e-02f,
  -1.02837207e-02f, 2.13257354e-02f, 1.58118829e-01f, 5.72485887e-02f, -4.97055389e-02f, 1.26065478e-01f, 8.54654163e-02f, 1.73689261e-01f, 2.07913801e-01f, -5.33423573e-02f,
  -1.62303343e-01f, -9.77769420e-02f, 1.80393428e-01f, -2.09582120e-01f, -2.83124279e-02f, -1.38634250e-01f, 1.72197789e-01f, -1.79071903e-01f, 2.70833403e-01f, 3.18564802e-01f,
  -2.97429055e-01f, 1.29077166e-01f, -2.21738681e-01f, 3.97633821e-01f, 2.54986677e-02f, 9.37741175e-02f, -2.76819542e-02f, 3.80795673e-02f, -1.39742434e-01f, 1.20025836e-01f,
  -3.11756074e-01f, 5.59022911e-02f, 1.13715298e-01f, -1.09820127e-01f, 1.92736074e-01f, 6.74480945e-02f, 7.65990615e-02f, 1.03556029e-02f, 2.45957106e-01f, 9.72339958e-02f,
  1.30726825e-02f, -1.13988683e-01f, -8.30641314e-02f, -1.05837733e-01f, 1.27290830e-01f, 1.27093438e-02f, -1.51773453e-01f, 7.66095426e-03f, 2.34781094e-02f, -4.72200811e-02f,
  -9.59795043e-02f, 1.37409821e-01f, 8.21281523e-02f, 1.03410356e-01f, -8.96496773e-02f, 1.28013805e-01f, 9.81698111e-02f, -6.29351139e-02f, 1.25628725e-01f, 4.83039394e-02f,
  1.09335400e-01f, 7.50917643e-02f, 2.10717633e-01f, 1.38420746e-01f, 4.84555513e-02f, 1.64654404e-01f, 8.47130641e-02f, 8.66215974e-02f, 2.19407445e-03f, 6.39708042e-02f,
  3.70609760e-02f, 1.03278227e-01f, 7.20375590e-03f, -2.76106358e-01f, 3.78990442e-01f, 4.18712318e-01f, 1.26527529e-02f, 3.01727265e-01f, 2.92150915e-01f, 9.74553525e-02f,
  -5.55516183e-02f, 1.25295902e-02f, -3.35328788e-01f, -9.42442641e-02f, -2.67206460e-01f, 1.02799207e-01f, 1.40550196e-01f, 1.68726370e-01f, -2.67639399e-01f, -2.99015611e-01f,
  9.11371112e-02f, 2.72946395e-02f, 1.84636384e-01f, -1.98310778e-01f, -1.43184349e-01f, -1.48208812e-01f, -3.10716540e-01f, 2.16648117e-01f, -7.94672742e-02f, 6.34259760e-01f,
  -8.09791982e-02f, 1.06857687e-01f, -2.42518589e-01f, -1.20457932e-02f, 2.89155394e-01f, 1.67475730e-01f, 4.60563600e-02f, -1.55039251e-01f, 1.73071340e-01f, 2.70747095e-02f,
  3.56395334e-01f, 3.54981154e-01f, 1.44497663e-01f, -1.04345940e-02f, 4.07237485e-02f, 1.23749323e-01f, 2.01265931e-01f, 2.48794146e-02f, 5.33977598e-02f, -2.16149092e-02f,
  -6.48626834e-02f, 1.70150340e-01f, 1.32186010e-01f, 6.81445468e-03f, -2.65613422e-02f, 5.05148955e-02f, 1.67886764e-01f, -2.53145527e-02f, 1.50077865e-01f, 1.24905743e-01f,
  2.93511571e-03f, 1.69248849e-01f, -2.12018117e-02f, -4.39555272e-02f, 1.60393845e-02f, 4.66389954e-03f, 1.71664506e-01f, -9.12151933e-02f, 1.81840107e-01f, 1.05880380e-01f,
  -4.79880162e-02f, 8.40126202e-02f, -1.56869501e-01f, -1.52199119e-02f, -1.90561697e-01f, 1.63494319e-01f, -1.46329388e-01f, -1.36948243e-01f, 8.83149654e-02f, 6.09067641e-02f,
  3.47255985e-03f, -2.03455519e-02f, -8.47987756e-02f, -1.18465193e-01f, 9.28862095e-02f, -2.21836474e-03f, 2.04614148e-01f, 2.31081340e-02f, 1.22870311e-01f, 4.56906110e-02f,
  5.40143959e-02f, -1.21444650e-01f, -9.27896053e-02f, -1.03605375e-01f, -8.28669444e-02f, 7.53816143e-02f, 3.14700156e-02f, 7.87314251e-02f, -7.75828585e-02f, 1.47728011e-01f,
  -8.50111395e-02f, -4.32137437e-02f, 1.41436327e-03f, 5.22687547e-02f, -4.73201424e-02f, -1.63998783e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.43350169e-01f, 3.14712301e-02f, 2.03090280e-01f, -9.53745991e-02f, 2.10921556e-01f, 1.70570940e-01f, 1.49490898e-02f, 1.19557343e-01f, 1.82510614e-01f, -1.43982396e-02f,
  1.43897403e-02f, 2.34112397e-01f, -2.81339372e-03f, 2.78570876e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  1.53735667e-01f, -5.63317202e-02f, -2.50502706e-01f, 1.31115675e-01f, -4.57937807e-01f, 2.36005858e-01f, -1.76552668e-01f, 1.44362867e-01f, -1.55467018e-01f, 2.53818125e-01f,
  -4.09767516e-02f, 8.75390172e-02f, 2.12154567e-01f, -6.94879815e-02f, 1.21544376e-01f, 2.12094024e-01f, -5.91729470e-02f, 1.50714353e-01f, -6.45233840e-02f, -1.43610790e-01f,
  3.64434645e-02f, -6.16711527e-02f, -2.58087426e-01f, 6.73926100e-02f, -1.68342307e-01f, 7.70102888e-02f, 1.26326308e-01f, -3.32904518e-01f, -1.02949757e-02f, -1.72753707e-01f,
  -1.42605856e-01f, -3.85030627e-01f, -2.38998860e-01f, -5.15064001e-01f, -2.84436464e-01f, 9.27174538e-02f, 5.70851937e-02f, 1.67555407e-01f, 2.65757978e-01f, -3.11369300e-01f,
  -1.52940303e-01f, -4.29520965e-01f, 7.65020549e-02f, -1.38324201e-01f, -4.21258241e-01f, -2.31517255e-01f, -3.86209279e-01f, 3.60324681e-01f, -2.63198733e-01f, 2.66689718e-01f,
  5.72455227e-01f, 4.70412403e-01f, -1.86069638e-01f, 5.08439988e-02f, -1.94680676e-01f, 1.17419697e-02f, -1.10993907e-01f, -1.77754059e-01f, -9.11900476e-02f, 1.28720716e-01f,
  -1.05592504e-01f, 2.09235042e-01f, -3.91836792e-01f, -2.73422867e-01f, 2.10945159e-01f, 1.78064153e-01f, 3.87326568e-01f, -7.23172575e-02f, -3.02612539e-02f, -2.43522182e-01f,
  2.53166914e-01f, 8.09060261e-02f, 1.23095624e-01f, 1.28809899e-01f, 5.61336614e-02f, -2.18191788e-01f, 2.35755876e-01f, 7.79895633e-02f, 9.66066495e-02f, 1.93068981e-01f,
  1.29823267e-01f, 1.17567599e-01f, 2.99776703e-01f, -6.05740771e-03f, 6.18581511e-02f, 2.51915872e-01f, 2.13075474e-01f, -2.68525481e-01f, 2.40095347e-01f, -4.67098393e-02f,
  -1.41687483e-01f, 2.63539493e-01f, -5.21221817e-01f, -1.54463619e-01f, -3.72024953e-01f, 2.58202374e-01f, -3.73870611e-01f, -1.29884779e-01f, -1.54226154e-01f, 2.00090427e-02f,
  3.24238867e-01f, 1.77622095e-01f, -3.11218351e-01f, -1.59998417e-01f, 3.92458737e-01f, 2.28296608e-01f, -6.21633716e-02f, -1.26655504e-01f, -4.33303304e-02f, -3.16848844e-01f,
  6.48714602e-02f, 2.56731570e-01f, -2.27011383e-01f, 2.12089717e-01f, -1.05171874e-01f, -3.69226336e-02f, -1.62312061e-01f, -8.13736543e-02f, -9.66141969e-02f, -4.04099315e-01f,
  -2.61772007e-01f, -9.54647437e-02f, 1.58346385e-01f, -1.56205401e-01f, -1.83558896e-01f, 7.65214682e-01f, -3.16856474e-01f, -2.17668906e-01f, -2.93371171e-01f, 3.11704352e-02f,
  -3.22230719e-02f, 1.73012197e-01f, 2.47906856e-02f, 1.19137429e-01f, -2.38381147e-01f, -1.92888558e-01f, 3.18115810e-03f, 2.05793008e-01f, -4.47188541e-02f, 4.23025228e-02f,
  -2.91420847e-01f, 1.94829226e-01f, 1.73023105e-01f, -3.07831168e-01f, -9.17325262e-03f, -2.59172302e-02f, -2.63971519e-02f, -5.68314716e-02f, 3.60685377e-03f, -2.78677583e-01f,
  -9.89819840e-02f, -9.51798856e-02f, -2.01133937e-01f, -3.53111058e-01f, -1.19493499e-01f, 2.99760371e-01f, -5.09059206e-02f, 2.88206816e-01f, -1.46995425e-01f, 2.14536116e-01f,
  -3.33598495e-01f, 3.67969841e-01f, -4.74427819e-01f, 1.04789242e-01f, 1.19120024e-01f, 2.69544423e-01f, 2.27464805e-03f, 1.16939686e-01f, 4.84223485e-01f, -4.00162756e-01f,
  7.79242590e-02f, -1.81904703e-01f, -2.69648910e-01f, -2.49705270e-01f, 4.15502995e-01f, 2.04492703e-01f, -2.05856845e-01f, -2.98307955e-01f, 2.99364980e-02f, -7.16781151e-03f,
  -2.40615591e-01f, 2.27793381e-02f, 3.86795938e-01f, -3.84170204e-01f, 4.28723097e-01f, -1.57756656e-01f, -3.49353254e-01f, -1.27461851e-01f, 2.68857598e-01f, 2.29557708e-01f,
  -2.72656083e-01f, -6.94615394e-02f, 3.37015867e-01f, -2.05330644e-03f, -1.12376936e-01f, -2.35131711e-01f, -2.31338769e-01f, 6.69247359e-02f, -7.91706294e-02f, 1.29266515e-01f,
  9.12897438e-02f, -2.75905907e-01f, -2.07038954e-01f, 7.81930685e-02f, -2.11145326e-01f, 1.14338044e-02f, -3.55435789e-01f, -1.65173993e-01f, -1.47043094e-01f, -2.27794617e-01f,
  1.89662442e-01f, -4.49662022e-02f, -5.84625825e-02f, -2.14703172e-01f, -1.09356735e-02f, -1.44181669e-01f, -4.58283499e-02f, 6.84576258e-02f, -2.21340135e-01f, -3.42679113e-01f,
  3.23955715e-01f, -3.76915693e-01f, 1.92882255e-01f, -4.08375978e-01f, -1.70786902e-01f, -8.73411968e-02f, 8.37240517e-02f, 1.06330819e-01f, -1.52643889e-01f, -4.67661500e-01f,
  -2.86674667e-02f, -2.38197491e-01f, -2.41313472e-01f, -3.75898510e-01f, 3.73224050e-01f, 1.76450878e-01f, -4.67248350e-01f, 3.30459028e-01f, -2.50513047e-01f, 1.12575829e-01f,
  3.00033301e-01f, 9.23082158e-02f, 1.45603597e-01f, -9.37688351e-02f, -1.39600083e-01f, 2.40170583e-02f, -2.94934362e-01f, -6.63024411e-02f, -1.96625367e-01f, -1.40184611e-01f,
  -4.51252371e-01f, -6.27861246e-02f, -1.51315093e-01f, -8.82011652e-02f, 7.13627398e-01f, -5.38020879e-02f, 1.19220860e-01f, -1.03309803e-01f, -8.33614767e-02f, -1.97052002e-01f,
  3.90257798e-02f, -2.32642889e-01f, 1.11215718e-01f, 1.12974375e-01f, 5.93653768e-02f, 1.87894017e-01f, 1.18765496e-01f, -5.69205545e-02f, 4.58945602e-01f, -2.91630894e-01f,
  1.87406421e-01f, 1.80165723e-01f, 2.40079775e-01f, 1.19928211e-01f, -9.47528630e-02f, 2.89930135e-01f, 2.83993036e-01f, 1.67944402e-01f, -8.34383443e-02f, 2.64984295e-02f,
  9.66972858e-02f, 3.50602180e-01f, 3.25115800e-01f, -1.84038013e-01f, 4.92672443e-01f, -8.69866908e-02f, 4.85988289e-01f, 6.91565424e-02f, -8.30117539e-02f, 4.30417001e-01f,
  -1.20369889e-01f, 3.49444412e-02f, -5.22680938e-01f, 3.74636687e-02f, 2.74586946e-01f, -5.21787047e-01f, -2.88593352e-01f, -1.40435100e-01f, 9.13485736e-02f, -2.06124231e-01f,
  2.85976529e-02f, -2.51129717e-01f, 6.08187318e-02f, 2.30029404e-01f, 5.39580047e-01f, 2.95842707e-01f, 1.26128897e-01f, 1.14527829e-01f, -1.82958826e-01f, 9.25886631e-03f,
  -5.10339178e-02f, 3.84827882e-01f, -5.18703870e-02f, 2.28018150e-01f, -1.73686706e-02f, 5.74757755e-02f, -1.45610318e-01f, -7.98870847e-02f, 1.44400015e-01f, 2.67352283e-01f,
  -1.00851633e-01f, -2.06244931e-01f, -1.54469550e-01f, -1.52743161e-01f, -7.80043900e-02f, -1.45081729e-02f, -7.16263875e-02f, 5.25487540e-03f, -1.32133633e-01f, 9.64208916e-02f,
  -3.38281244e-02f, -5.07767946e-02f, -1.23420522e-01f, 3.47035602e-02f, 2.66229976e-02f, 1.82403877e-01f, -4.68156785e-02f, -2.85355866e-01f, 1.16644703e-01f, 1.41656384e-01f,
  -8.92189071e-02f, 2.56874263e-01f, -5.90911647e-03f, -1.14826471e-01f, 7.61396512e-02f, 2.42899910e-01f, 2.45596483e-01f, -2.73395300e-01f, -3.20000947e-01f, -2.40150303e-01f,
  -1.87100664e-01f, -2.09713981e-01f, 4.53685731e-01f, -3.02670240e-01f, 3.81253883e-02f, -3.22358012e-01f, 1.21731035e-01f, 1.82994008e-01f, 7.41168410e-02f, 4.34477627e-01f,
  -1.49549007e-01f, 3.14677387e-01f, -1.82295084e-01f, -1.22653708e-01f, 1.61591709e-01f, -1.68310553e-01f, -3.55767936e-01f, -3.35438758e-01f, -1.12688400e-01f, 1.10696867e-01f,
  7.18488842e-02f, 1.73199221e-01f, 3.50724250e-01f, -1.63765520e-01f, 2.94288690e-03f, 4.68554556e-01f, -3.49417895e-01f, 4.11581546e-01f, 5.62412679e-01f, 3.29816118e-02f,
  -9.94150713e-02f, -1.52229801e-01f, -4.91535008e-01f, -1.54669568e-01f, 2.42979959e-01f, 6.78746626e-02f, -2.40610182e-01f, 1.01987816e-01f, 1.16281509e-01f, 2.35187203e-01f,
  1.14757717e-01f, -9.01646819e-03f, -1.80378273e-01f, -2.96170026e-01f, 6.47026524e-02f, 6.37924820e-02f, -3.88087898e-01f, -9.03735161e-02f, -3.35109383e-01f, -1.08229324e-01f,
  1.89707316e-02f, 2.06842184e-01f, -3.58518779e-01f, 7.76148140e-02f, 1.91805050e-01f, 1.37516946e-01f, 1.21995457e-01f, 3.81799079e-02f, -2.07791626e-01f, -5.66023812e-02f,
  1.12655684e-02f, 5.12969196e-01f, 3.78878647e-03f, -2.61959463e-01f, -3.72378789e-02f, -2.42796287e-01f, 3.07869852e-01f, 4.15670335e-01f, 3.21335912e-01f, -4.06601220e-01f,
  2.72893786e-01f, 2.03433409e-01f, 1.28401980e-01f, 4.13713813e-01f, 6.30898476e-01f, -2.37809360e-01f, 1.49634659e-01f, -2.22416624e-01f, -1.67815506e-01f, 1.61461115e-01f,
  4.53499109e-01f, -1.83953717e-01f, -1.18003890e-01f, -3.79409581e-01f, -1.52798846e-01f, -2.55964726e-01f, 6.69196919e-02f, 1.41125873e-01f, -2.68700540e-01f, 1.57706648e-01f,
  2.16912448e-01f, 1.75410479e-01f, 3.23230267e-01f, -1.31234139e-01f, 1.99991375e-01f, -3.09488595e-01f, -1.90725744e-01f, 8.05813894e-02f, -6.10550083e-02f, -2.06921756e-01f,
  -7.55676180e-02f, -1.34963125e-01f, -7.59208128e-02f, -1.40130609e-01f, 5.40458933e-02f, -1.56921819e-01f, -1.01041727e-01f, 2.34335400e-02f, -2.03301072e-01f, -1.41794667e-01f,
  2.58063879e-02f, 3.38420621e-03f, -2.52376169e-01f, -2.13145703e-01f, -1.99396431e-01f, 3.33152451e-02f, -1.93546250e-01f, -1.40307620e-01f, 3.12724337e-02f, 3.09722517e-02f,
  -1.70298159e-01f, -1.17677696e-01f, -1.92717075e-01f, 3.21461439e-01f, 2.29902685e-01f, -1.46867573e-01f, 2.31230617e-01f, 4.18755084e-01f, -2.33275354e-01f, -1.67902306e-01f,
  -6.71933293e-02f, -2.46918499e-01f, 1.22220486e-01f, 1.78479832e-02f, -2.02241391e-01f, -2.93376707e-02f, 3.62651609e-02f, -2.49990061e-01f, -1.69494450e-01f, 3.27915192e-01f,
  9.15540755e-02f, -1.00240655e-01f, 2.91263878e-01f, -7.46454298e-02f, 3.61924022e-01f, -2.94228345e-01f, 1.60634816e-01f, 1.64822698e-01f, -3.73915166e-01f, 1.97629016e-02f,
  -3.69980149e-02f, 5.89419454e-02f, -3.04477904e-02f, -2.08549142e-01f, -1.77497968e-01f, -7.43660480e-02f, 1.94813117e-01f, 1.98837042e-01f, 1.28337815e-01f, 1.42445294e-02f,
  8.47988486e-01f, -7.69267678e-02f, -1.77158535e-01f, 2.68885549e-02f, -5.43421842e-02f, -1.88982710e-02f, -1.20710684e-02f, -3.66955549e-02f, -3.56150448e-01f, 2.08570004e-01f,
  -6.61335960e-02f, -7.01412698e-03f, -3.02402209e-03f, -4.34980452e-01f, -1.38465492e-02f, -6.89417198e-02f, 1.62114590e-01f, 1.38015673e-01f, -1.23806760e-01f, -2.74243742e-01f,
  1.63972139e-01f, -3.67054977e-02f, 9.38811675e-02f, 9.42205042e-02f, 5.39158359e-02f, -3.56091678e-01f, -1.35575533e-01f, -3.15900385e-01f, 7.10146129e-02f, 3.46719086e-01f,
  1.86373249e-01f, 5.22535145e-01f, -2.56259173e-01f, 2.99423188e-01f, 1.31353647e-01f, -3.36358666e-01f, 1.31374598e-01f, -1.18688278e-01f, 2.90240675e-01f, 6.61553144e-02f,
  -4.06978965e-01f, 5.35104014e-02f, -1.85315713e-01f, 2.15233296e-01f, -3.62150520e-01f, 4.43793029e-01f, -2.51416296e-01f, 2.31430501e-01f, -2.07145736e-01f, -2.83810198e-01f,
  -4.95490372e-01f, -3.82416546e-01f, -1.35768175e-01f, -5.59926182e-02f, 5.13929069e-01f, -1.16775103e-01f, 2.36180067e-01f, -2.04007834e-01f, 4.82894331e-02f, -2.02225342e-01f,
  -4.29386497e-01f, 1.04117468e-01f, 3.46121639e-01f, 1.55005351e-01f, -2.15707123e-01f, -6.90929517e-02f, -1.00243323e-01f, 2.04243157e-02f, 2.89473891e-01f, 1.09818898e-01f,
  4.18799073e-02f, 4.19197977e-02f, 1.51089013e-01f, 1.26320004e-01f, -7.52972886e-02f, 3.03381383e-01f, 1.07917733e-01f, 7.13078231e-02f, -1.25054777e-01f, -2.62576193e-02f,
  -1.87369715e-02f, 1.69110656e-01f, -1.26322266e-02f, 1.88049495e-01f, -2.75176436e-01f, -4.50020134e-01f, -5.73809743e-02f, -3.62883478e-01f, -3.26978602e-02f, 2.16326252e-01f,
  2.42002860e-01f, 4.65718985e-01f, -1.71250716e-01f, 2.27326732e-02f, 3.68577749e-01f, 3.19983214e-01f, 3.38059574e-01f, 2.67813563e-01f, 1.68472826e-02f, 1.52980804e-01f,
  -2.22319573e-01f, 1.64080679e-01f, -4.06771421e-01f, 2.57378310e-01f, 3.58619958e-01f, 3.93196791e-01f, 2.98968583e-01f, 3.52637917e-01f, 1.23873219e-01f, -3.35325189e-02f,
  6.92338169e-01f, -2.03895792e-01f, 5.17739356e-01f, -8.35614204e-02f, 2.04430930e-02f, 1.44967347e-01f, 5.73358452e-03f, -1.39362544e-01f, -1.36567235e-01f, 6.73465282e-02f,
  4.03546333e-01f, -7.04938695e-02f, -1.96342841e-01f, -3.14333737e-02f, 5.02675593e-01f, 7.57084340e-02f, 1.20630786e-01f, -3.03301871e-01f, -3.89683992e-01f, 1.93105474e-01f,
  -3.78268659e-01f, -2.30178103e-01f, 2.81692266e-01f, 1.31591409e-01f, 1.78923652e-01f, 1.44876748e-01f, 1.89772725e-01f, -3.87948185e-01f, -7.54458681e-02f, -1.15215428e-01f,
  -1.66564792e-01f, 2.88259268e-01f, 5.39272279e-02f, 6.68422133e-02f, 1.75054282e-01f, 2.96116620e-01f, 7.56031796e-02f, 2.30629563e-01f, 2.39427939e-01f, 4.19669524e-02f,
  -1.75050661e-01f, 1.46966562e-01f, -2.08247110e-01f, 1.93881132e-02f, 2.33387068e-01f, -4.51529443e-01f, -4.26935852e-01f, 2.77006030e-02f, 6.61787093e-02f, -1.91740334e-01f,
  -4.43981215e-02f, 1.85863122e-01f, -3.72676969e-01f, 1.62887737e-01f, 1.46339819e-01f, 2.64692247e-01f, -1.08601972e-01f, -6.70888305e-01f, -4.52668697e-01f, -1.47911280e-01f,
  1.20007642e-01f, -4.02253360e-01f, 4.00273986e-02f, 2.49935761e-01f, -6.24940768e-02f, 3.75426143e-01f, -4.34632212e-01f, 2.67570823e-01f, 2.92740971e-01f, -1.70738161e-01f,
  5.31858280e-02f, -1.55588657e-01f, -1.67269528e-01f, 6.22683205e-02f, 7.65876845e-02f, -2.78397888e-01f, 4.36363101e-01f, -1.25523582e-01f, -1.75310686e-01f, -7.32669458e-02f,
  -7.65601695e-02f, 2.23023251e-01f, 1.89352766e-01f, 4.14475314e-02f, 4.23471779e-02f, 2.41034687e-01f, 1.23502925e-01f, 8.95244405e-02f, 1.00826725e-01f, 8.76882672e-02f,
  1.82538837e-01f, 1.11373343e-01f, 7.27728978e-02f, -5.11069238e-01f, 4.35277335e-02f, 1.50979832e-01f, 1.99439079e-01f, 2.27681160e-01f, 1.17572501e-01f, -4.39768136e-02f,
  3.81982774e-02f, 1.72477285e-03f, 3.38821739e-01f, -1.45935975e-02f, -8.68744031e-02f, -1.44551083e-01f, 1.80708885e-01f, 3.59340578e-01f, 3.67517062e-02f, -2.68372208e-01f,
  -7.66668767e-02f, 9.93338078e-02f, -5.08665442e-01f, -3.99903208e-02f, -5.27757071e-02f, -1.19216204e-01f, 3.83536607e-01f, -1.08888440e-01f, 2.35905468e-01f, 4.43247296e-02f,
  -6.86387345e-02f, -1.36875823e-01f, 6.40869699e-03f, 2.15939656e-01f, -5.29770136e-01f, 3.00482243e-01f, -4.21244651e-01f, 8.30309317e-02f, 3.16019267e-01f, 4.43015665e-01f,
  -3.29915434e-01f, 3.69301476e-02f, 3.97573113e-01f, -1.05954841e-01f, -3.27274084e-01f, -1.51817858e-01f, 5.01306176e-01f, -6.17179237e-02f, -1.53579980e-01f, 2.40340218e-01f,
  1.55430242e-01f, 1.39258638e-01f, -3.50640327e-01f, 1.08489707e-01f, 9.14349779e-02f, -3.22535932e-01f, -1.46153465e-01f, 1.22223690e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -5.84156923e-02f, 1.63122505e-01f, 2.21131922e-04f, -7.03965724e-02f, 1.07242711e-01f, -6.06762432e-02f, 9.39352214e-02f, -1.52381852e-01f, 1.47534013e-01f, -3.94504778e-02f,
  -4.74081635e-02f, 6.34197369e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    