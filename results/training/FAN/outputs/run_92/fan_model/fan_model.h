/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.61582213e-02f, -8.58511180e-02f, -1.31837457e-01f, 1.83986814e-03f, 1.23207182e-01f, 4.28016812e-01f, 4.18592185e-01f, -1.19361794e-02f, -4.34093736e-02f, 1.04306296e-01f,
  2.18876138e-01f, -1.49844453e-01f, -7.34610260e-02f, 1.85422555e-01f, 1.08499035e-01f, -3.01980507e-02f, 3.08778226e-01f, 1.45261884e-01f, -1.43353781e-02f, -4.57588671e-04f,
  -8.37697834e-02f, 1.08221196e-01f, 2.75663938e-02f, -8.85946527e-02f, 7.99605250e-02f, -1.52078807e-01f, -2.34278589e-02f, -4.94093224e-02f, 1.54184038e-02f, 5.72710708e-02f,
  1.44178376e-01f, -8.56163129e-02f, -8.09971243e-02f, -5.68299890e-02f, 6.18640222e-02f, -1.87479183e-02f, -2.41509965e-03f, -3.46369413e-03f, -4.66130748e-02f, 4.62162689e-06f,
  5.55996895e-02f, -1.00046791e-01f, 5.85970394e-02f, 7.82876313e-02f, -2.25838125e-02f, -5.45295514e-02f, -9.84681398e-02f, 2.19541742e-03f, -4.67501506e-02f, 5.95028400e-02f,
  -3.07230782e-02f, 1.19601935e-03f, -7.94615299e-02f, -8.38772580e-03f, -1.88235063e-02f, -6.65177479e-02f, 2.98026502e-02f, -6.65872544e-03f, 7.81844184e-02f, 3.01907095e-03f,
  6.67328238e-02f, -1.06802858e-01f, 2.55843606e-02f, -2.77356394e-02f, -1.38928359e-02f, 9.13386047e-03f, -3.93742211e-02f, -7.42168799e-02f, -1.31766163e-02f, 4.37338790e-03f,
  4.22481373e-02f, 9.59893540e-02f, -2.35938821e-02f, 1.29986964e-02f, 3.84592004e-02f, -6.53304206e-03f, 9.10693184e-02f, 2.02953313e-02f, 4.95751165e-02f, 3.89583372e-02f,
  -5.92278838e-02f, 7.44592175e-02f, -7.79562443e-02f, 1.18630461e-01f, 1.50728703e-01f, -3.85889523e-02f, -7.16250986e-02f, -3.97448801e-02f, -5.51469997e-02f, 9.97649878e-02f,
  4.17050645e-02f, -1.22858517e-01f, -2.84067076e-02f, -2.29417775e-02f, -9.61723085e-03f, 2.14977395e-02f, 2.40140855e-02f, 5.04554547e-02f, -2.76658442e-02f, -1.54590309e-02f,
  4.08022180e-02f, 2.15334147e-02f, 1.44350361e-02f, -5.04517816e-02f, 1.21700885e-02f, 5.00272587e-02f, -7.68877100e-03f, 8.22497718e-03f, 8.80512372e-02f, 2.50952095e-02f,
  -6.01005293e-02f, -2.85144430e-02f, 6.71608225e-02f, 4.11188826e-02f, 4.40996923e-02f, 9.34096635e-04f, 2.11137962e-02f, 4.69651036e-02f, 1.74426343e-02f, 9.47174504e-02f,
  2.66270433e-03f, 1.52256161e-01f, -1.45848662e-01f, -2.29100540e-01f, -3.47919881e-01f, -1.42568141e-01f, -9.57183912e-02f, -1.35180965e-01f, -2.29517072e-01f, 1.16797380e-01f,
  1.13670170e-01f, 2.06135944e-01f, 1.43907741e-01f, 1.26203634e-02f, 1.32910103e-01f, 1.52434543e-01f, 1.73136905e-01f, 1.49809629e-01f, -3.95533815e-02f, 9.87665132e-02f,
  -1.00397028e-01f, -1.49066430e-02f, 1.43279126e-02f, -6.16698265e-02f, -1.07144944e-01f, -1.83935314e-01f, -8.04568976e-02f, -1.77789535e-02f, -3.61466557e-02f, -1.07176239e-02f,
  1.01980701e-01f, -1.86912681e-03f, 1.33287013e-01f, -4.17829910e-03f, -6.41146377e-02f, -6.19857274e-02f, 6.77103102e-02f, 1.29044130e-01f, -4.68492731e-02f, -9.33359489e-02f,
  4.51401472e-02f, -1.36087894e-01f, -3.59657668e-02f, -4.83853742e-02f, 3.33328061e-02f, -1.14825470e-02f, 1.96167342e-02f, -2.98550930e-02f, 3.81902307e-02f, 2.77687442e-02f,
  -6.05542623e-02f, 6.73834607e-02f, -1.46642476e-02f, -1.64539050e-02f, -2.20638029e-02f, 2.51177493e-02f, 1.16663929e-02f, 2.87482738e-02f, -1.71126090e-02f, -3.39097995e-03f,
  9.15004238e-02f, -7.24681020e-02f, -8.31639096e-02f, -2.90490314e-02f, 1.14566274e-02f, -1.22022621e-01f, -3.32219303e-02f, 5.59416716e-04f, -2.56744679e-02f, -1.51732769e-02f,
  4.01352253e-03f, 1.64284483e-02f, 8.81094411e-02f, -3.39259468e-02f, -4.07185405e-02f, -2.38362001e-03f, 1.01127792e-02f, 1.62072815e-02f, 4.80373539e-02f, -1.61149465e-02f,
  2.48562749e-02f, 1.59048289e-02f, 5.93465418e-02f, -6.09177127e-02f, 9.67990234e-02f, -9.09894258e-02f, -4.57264390e-03f, 4.00065295e-02f, -3.48437205e-02f, 5.49481390e-03f,
  9.73405093e-02f, -3.47126760e-02f, -2.73551960e-02f, 6.10220507e-02f, 8.05766694e-03f, 7.20613450e-02f, -1.15688264e-01f, -6.31505176e-02f, 9.32013690e-02f, 3.96371260e-02f,
  3.99478003e-02f, -6.65353686e-02f, -2.79628243e-02f, -5.41111045e-02f, 1.18385971e-01f, 3.13645229e-02f, 7.92410225e-02f, -2.96105817e-02f, 7.06533901e-05f, 1.19799025e-01f,
  3.96434590e-02f, -3.48520726e-02f, -2.22821590e-02f, -1.14942022e-01f, -1.20860925e-02f, -6.23704009e-02f, 2.49511059e-02f, -5.27723925e-03f, 1.59820337e-02f, -2.11336706e-02f,
  -1.14214137e-01f, -3.32432874e-02f, 2.48396564e-02f, -2.20796019e-01f, 2.02091828e-01f, -1.07304581e-01f, -2.88270384e-01f, 6.70922315e-03f, -9.16964933e-02f, -5.59546659e-03f,
  -1.52779132e-01f, 8.31910968e-02f, -4.93068546e-02f, -2.44652897e-01f, -3.89761657e-01f, -2.63592213e-01f, -3.28568399e-01f, -5.26805185e-02f, -3.49530540e-02f, 4.12323745e-03f,
  -7.89866522e-02f, -1.58737659e-01f, -1.69773355e-01f, 6.37826324e-02f, 3.52176167e-02f, 1.59898490e-01f, 4.05553682e-03f, 1.97742924e-01f, -3.44317220e-02f, -6.45972416e-02f,
  -2.15992898e-01f, -1.92097183e-02f, -2.97303661e-03f, 2.65554674e-02f, 1.33086164e-02f, 8.83640535e-03f, -6.18505338e-03f, 2.09213383e-02f, 6.12966903e-02f, -9.84571055e-02f,
  3.25495601e-02f, -2.47396864e-02f, -1.36751756e-02f, 2.81979470e-03f, 3.31200585e-02f, 1.14566699e-01f, -5.56231067e-02f, 1.43890662e-04f, 6.00022227e-02f, -3.47627103e-02f,
  5.85816652e-02f, 2.60515455e-02f, 1.43513549e-02f, 3.00249439e-02f, 3.49741196e-03f, 2.11669486e-02f, 1.42928753e-02f, 7.14019910e-02f, -9.18738730e-03f, -6.67216210e-03f,
  -2.81889364e-02f, -3.62313837e-02f, -4.40360093e-03f, -3.11478716e-03f, 4.80222255e-02f, 2.13732887e-02f, 3.18414755e-02f, -4.71070316e-03f, 1.05985310e-02f, 7.90785402e-02f,
  -1.42168498e-03f, 2.53217034e-02f, -3.80592570e-02f, -2.30086502e-02f, -9.79083125e-03f, 3.03391609e-02f, 1.17349915e-01f, 6.96256384e-02f, 2.22633909e-02f, -1.72390428e-04f,
  -4.74247187e-02f, 8.99451412e-03f, 8.45647138e-03f, -2.95984335e-02f, -1.31392866e-01f, 5.28300405e-02f, -3.72981885e-03f, -1.01814996e-02f, -3.49457115e-02f, -3.51163968e-02f,
  -2.82133017e-02f, -3.41069289e-02f, -4.74709533e-02f, -3.30296978e-02f, -1.30513338e-02f, 2.07924694e-02f, -8.17374215e-02f, 1.87088978e-02f, -1.42917335e-02f, -1.48457745e-02f,
  1.08121730e-01f, 2.87391916e-02f, -6.21446967e-02f, 5.84083563e-03f, 1.69859007e-02f, -2.30903253e-02f, -2.43607350e-02f, 5.81395552e-02f, 2.58476269e-02f, 7.69289210e-02f,
  1.43396899e-01f, 4.89517488e-02f, 3.61367241e-02f, 5.44960834e-02f, 3.08710393e-02f, 5.77174202e-02f, 3.45489234e-02f, 2.30644681e-02f, 2.10926645e-02f, -1.80846788e-02f,
  2.47464448e-01f, 9.21086669e-02f, 2.69150227e-01f, 2.98346043e-01f, 4.97783609e-02f, 3.32074687e-02f, -9.31624919e-02f, 1.25056833e-01f, 1.37143329e-01f, 6.17679283e-02f,
  -2.62754671e-02f, 2.68718451e-01f, -2.54495200e-02f, 1.27208263e-01f, -1.80810824e-01f, -2.20422402e-01f, 3.22774760e-02f, 1.19993813e-01f, 8.02158043e-02f, 2.22585186e-01f,
  7.86131807e-03f, -1.35273665e-01f, -6.24153093e-02f, 1.96441244e-02f, 7.88516030e-02f, 1.31382376e-01f, 7.00897956e-03f, -1.68328416e-02f, -1.31217493e-02f, -1.23375095e-01f,
  -3.56938764e-02f, -6.53562024e-02f, -3.66577804e-02f, 1.49032213e-02f, -2.25172602e-02f, 7.78492540e-02f, -3.26367915e-02f, -5.08158952e-02f, -4.15262021e-02f, -5.57462424e-02f,
  -2.95951823e-03f, 3.60184871e-02f, 1.83158498e-02f, 8.80559813e-03f, -3.51352766e-02f, -6.61345348e-02f, 1.97730027e-02f, 1.61513928e-02f, 5.71097173e-02f, 1.97052695e-02f,
  -3.23283561e-02f, -4.53262888e-02f, 5.12683801e-02f, -1.02810875e-01f, -1.01707643e-02f, -1.84106100e-02f, -3.57465856e-02f, -4.36237156e-02f, -5.53144440e-02f, -3.50657068e-02f,
  -8.69319513e-02f, -5.80733037e-03f, 3.12451553e-02f, 8.38580057e-02f, -1.73153691e-02f, -3.59517895e-02f, -4.82664257e-02f, -2.12284420e-02f, 9.87698976e-03f, -2.62099877e-02f,
  -6.43271357e-02f, 1.68515667e-01f, 8.60384665e-04f, 7.29281902e-02f, 4.11547534e-02f, -5.74483201e-02f, -4.27941829e-02f, 1.26640081e-01f, 7.89378509e-02f, 8.75068605e-02f,
  -5.99423423e-02f, -5.26967570e-02f, 3.97342108e-02f, 2.35067122e-02f, -6.59311339e-02f, 6.31839931e-02f, -5.94889075e-02f, -1.05169810e-01f, -4.07917462e-02f, 1.32340521e-01f,
  1.92586647e-03f, 1.28277346e-01f, 3.96106346e-03f, -1.19999871e-01f, 4.01549451e-02f, -6.25157962e-03f, 1.67548150e-01f, -4.80410876e-03f, -4.05135304e-02f, 1.41835688e-02f,
  1.48695167e-02f, -1.69608567e-03f, -2.11564377e-02f, 4.69902121e-02f, -4.14082371e-02f, 6.47583157e-02f, -9.00528133e-02f, 4.18100460e-03f, -6.99105784e-02f, -6.51737452e-02f,
  -6.45962209e-02f, -4.43124175e-02f, 2.31959838e-02f, -1.69088151e-02f, -5.66699915e-02f, -2.95906980e-02f, -2.96481587e-02f, 8.62771496e-02f, -5.28441593e-02f, 8.91803131e-02f,
  -2.13287354e-01f, 2.34688446e-01f, -2.55915076e-01f, 7.72662535e-02f, -2.37787869e-02f, -8.57429579e-03f, 5.35685793e-02f, 3.92079465e-02f, -6.60112277e-02f, 2.71207571e-01f,
  1.24981783e-01f, -1.75593570e-01f, -5.46987765e-02f, 3.18721205e-01f, -3.34834576e-01f, -6.57455623e-02f, 1.03561237e-01f, -3.40831131e-02f, -1.42805979e-01f, 1.11669093e-01f,
  -9.41343680e-02f, 8.50690454e-02f, -9.97447222e-02f, -6.19880669e-02f, 1.40500128e-01f, -7.35034943e-02f, -3.71395163e-02f, -2.19898634e-02f, 1.00002602e-01f, -8.53359774e-02f,
  3.79508212e-02f, 1.58689022e-01f, 7.82283247e-02f, -6.65150285e-02f, 6.43571094e-02f, -7.12188035e-02f, -1.39351800e-01f, -1.21519431e-01f, -1.24221724e-02f, -8.38055015e-02f,
  3.54363769e-02f, -2.72559673e-02f, -3.33367772e-02f, -3.40708382e-02f, 4.64323871e-02f, 1.90163348e-02f, 1.26023144e-01f, -3.68357939e-03f, -9.27458704e-02f, 3.77494693e-02f,
  -1.37914149e-02f, 3.12368535e-02f, 2.06026305e-02f, -9.17013809e-02f, -9.16997343e-02f, 3.81020419e-02f, -1.09534478e-02f, 1.46820517e-02f, -8.50171223e-03f, -2.83731823e-03f,
  -1.14804186e-01f, -1.67087317e-01f, -2.44288612e-02f, -1.38510037e-02f, 5.61491400e-03f, -1.97346695e-02f, 1.73439253e-02f, -2.32986603e-02f, -7.55009577e-02f, -3.82124074e-02f,
  -2.04577837e-02f, -1.15246102e-02f, 1.38943279e-02f, 3.12400740e-02f, -1.70063172e-02f, 2.29734299e-03f, 9.56943855e-02f, 5.64387292e-02f, -6.42045662e-02f, -6.82699457e-02f,
  -6.55692443e-03f, 7.55312815e-02f, 3.86218424e-04f, -3.70358229e-02f, -6.15158230e-02f, -1.17764939e-02f, 4.83732112e-02f, 8.92808437e-02f, 3.56680416e-02f, -8.76611918e-02f,
  2.41866902e-01f, 4.67520729e-02f, 1.16704041e-02f, 5.89523464e-02f, -4.18116450e-02f, 1.40198186e-01f, -3.27134095e-02f, 3.96698229e-02f, 1.47616491e-02f, 1.11330226e-01f,
  5.94902933e-02f, -4.66069654e-02f, -9.81851015e-03f, 3.18250246e-02f, -3.47186327e-02f, -3.35884392e-02f, 1.54237160e-02f, 4.92331199e-02f, 2.87841558e-02f, 1.44920209e-02f,
  5.05099073e-02f, 6.23104675e-03f, -5.37910834e-02f, -9.89625752e-02f, 2.88652088e-02f, -1.11718170e-01f, -1.09914811e-02f, 4.19035442e-02f, 3.76931876e-02f, -2.28788070e-02f,
  2.24225789e-01f, -3.69279683e-01f, 6.37588724e-02f, -3.17338966e-02f, -1.61532894e-01f, -1.22090727e-01f, -1.14376964e-02f, -3.64411995e-02f, -3.91144380e-02f, -1.77289099e-01f,
  -1.52318412e-02f, -5.65787107e-02f, 1.71263337e-01f, -1.23065211e-01f, 1.77976847e-01f, 1.97196439e-01f, -1.43922985e-01f, -7.28338510e-02f, 9.51944813e-02f, -7.83086196e-02f,
  1.43230438e-01f, -8.81418884e-02f, 1.45204768e-01f, -1.33049423e-02f, 6.15961403e-02f, 1.75394490e-01f, -1.58268064e-01f, 1.15508243e-01f, -5.76047897e-02f, 4.77620699e-02f,
  7.59471133e-02f, 3.02613452e-02f, -9.92324501e-02f, 1.10878140e-01f, -4.64171804e-02f, -5.76957650e-02f, -8.18814039e-02f, 1.43337086e-01f, -9.70685948e-03f, 5.25968149e-02f,
  1.49106428e-01f, 6.14650697e-02f, 8.95522088e-02f, -2.78805736e-02f, -1.48932384e-02f, 7.68186375e-02f, 3.03240921e-02f, 1.15384897e-02f, -2.12511718e-02f, 2.62105800e-02f,
  -2.51233988e-02f, 3.80697171e-03f, -7.50591010e-02f, 2.51436997e-02f, 1.13127217e-01f, -4.51662485e-03f, -3.36357318e-02f, 4.50046360e-02f, 4.75716544e-03f, -4.36091460e-02f,
  2.36068992e-03f, 3.73258372e-03f, 4.18337714e-03f, 8.00469592e-02f, -8.58552009e-02f, 2.33225226e-02f, 2.49702367e-03f, 1.54504851e-02f, -2.42537875e-02f, -8.06067605e-03f,
  -3.50375585e-02f, 2.00763773e-02f, -8.10917690e-02f, -5.04377931e-02f, -7.13554397e-03f, -6.46062847e-03f, -3.41083407e-02f, 1.30002916e-01f, 1.99410673e-02f, 4.33726721e-02f,
  4.27695997e-02f, -6.05730973e-02f, 3.96424718e-02f, 6.37099613e-03f, -5.98221049e-02f, 7.85507038e-02f, 4.73618880e-02f, -4.96147480e-03f, -3.66513394e-02f, -7.46320337e-02f,
  -2.18544900e-01f, -2.12702140e-01f, 4.76655774e-02f, 1.88096557e-02f, -2.52428390e-02f, 4.59717959e-03f, 1.04901418e-02f, 6.66481405e-02f, -2.33414080e-02f, -5.50787114e-02f,
  2.15508696e-02f, 1.13920281e-02f, -1.46592543e-01f, -3.50794606e-02f, -6.94707483e-02f, -8.61411914e-02f, -2.68353298e-02f, 4.29750904e-02f, -1.00657649e-01f, -1.60323624e-02f,
  -1.94970574e-02f, 1.51686948e-02f, 8.61114785e-02f, 4.83249361e-03f, -4.53360565e-03f, 1.04543716e-02f, -8.14418271e-02f, 5.55792190e-02f, 2.68565733e-02f, -7.28620142e-02f,
  -4.63101625e-01f, -2.34058172e-01f, 2.55433246e-02f, -1.64098471e-01f, -3.79802361e-02f, 1.49828373e-02f, 1.19303279e-01f, -1.25428349e-01f, -1.45426825e-01f, 3.01268995e-02f,
  -6.91461936e-02f, -8.45858976e-02f, 6.99628592e-02f, -7.98961613e-03f, -7.63100535e-02f, -2.51855273e-02f, -1.52163446e-01f, -1.50207356e-01f, -5.88679872e-02f, -5.01917638e-02f,
  -8.67117941e-02f, 6.83460832e-02f, 7.95429274e-02f, 4.59100411e-04f, -6.34506196e-02f, 2.00834218e-02f, 1.18966028e-01f, 4.05833423e-02f, 6.26618192e-02f, -3.06056309e-02f,
  -1.10585570e-01f, -1.83986261e-01f, 1.22673303e-01f, -2.58546267e-02f, 3.50833945e-02f, -2.89469268e-02f, -4.46047299e-02f, 9.51204747e-02f, 8.05267692e-02f, 2.04182807e-02f,
  1.22419465e-02f, -2.27916874e-02f, 3.43259913e-03f, 2.81094816e-02f, -1.03960939e-01f, 9.09885168e-02f, 6.02325201e-02f, -1.99252497e-02f, -1.00180004e-02f, 6.13091104e-02f,
  -9.18543339e-02f, -3.11090872e-02f, 4.96653803e-02f, -3.28309461e-02f, -3.00173778e-02f, -3.80862653e-02f, 8.63484368e-02f, 6.28501847e-02f, 1.18732248e-02f, 1.83066092e-02f,
  -3.00854258e-03f, -4.89769429e-02f, -3.92658114e-02f, 1.74432527e-02f, -7.08857775e-02f, 2.78322250e-02f, 7.01136589e-02f, 4.55238670e-02f, 2.88969185e-02f, -3.06495596e-02f,
  3.27283866e-03f, -2.04703230e-02f, -2.96089798e-03f, 6.90381229e-02f, -9.74537339e-03f, -2.06211507e-02f, -2.81338431e-02f, 4.87286337e-02f, 8.50094035e-02f, 5.31828180e-02f,
  -2.61524669e-03f, 2.98936684e-02f, -1.63150746e-02f, 4.39921990e-02f, 4.90746498e-02f, 1.65193714e-02f, 1.82807017e-02f, 4.55899052e-02f, 1.95941217e-02f, -9.42817926e-02f,
  -1.66680813e-01f, -1.83490768e-01f, 6.22588471e-02f, -6.47750199e-02f, 5.84543273e-02f, -2.21344512e-02f, -4.26942967e-02f, 7.85126090e-02f, 7.87429512e-03f, 6.05618916e-02f,
  -4.45601381e-02f, -8.96592066e-02f, -4.24113311e-02f, -1.88346505e-02f, -3.78474444e-02f, 1.62474036e-01f, 1.07838819e-02f, -2.35587987e-03f, 9.46205482e-02f, 3.66048962e-02f,
  2.92839613e-02f, -1.35382917e-02f, -4.15507285e-03f, -9.70975161e-02f, -5.37247770e-03f, -5.07404543e-02f, -1.37844309e-02f, -9.27812885e-03f, -6.08821213e-02f, 9.80197266e-02f,
  5.44944882e-01f, -1.82892561e-01f, 2.05435306e-01f, -9.50457528e-02f, -3.54414918e-02f, -2.76871845e-02f, 4.33657989e-02f, -9.67529789e-02f, 1.87640041e-01f, -1.85555965e-01f,
  -1.54477790e-01f, 2.44844094e-01f, -3.52016091e-02f, -1.34610891e-01f, 1.45301312e-01f, -6.19644746e-02f, 4.94501926e-02f, -1.19194351e-01f, -1.34323100e-02f, -7.29767233e-02f,
  -5.36470627e-03f, -1.57683909e-01f, 7.20541626e-02f, -2.34302640e-01f, -4.39572372e-02f, -9.33089480e-03f, -7.31983706e-02f, -1.09648779e-01f, -9.41661224e-02f, -2.05863197e-03f,
  2.80217268e-02f, -3.19982953e-02f, 5.98454848e-02f, 9.25373808e-02f, -5.81380650e-02f, 2.18848605e-02f, 8.31104293e-02f, 2.60737147e-02f, -5.26602082e-02f, 1.44636063e-02f,
  -5.34507893e-02f, 4.56609987e-02f, 8.21838602e-02f, 1.71873346e-02f, 3.33098434e-02f, -7.66787271e-04f, -4.26112004e-02f, -3.24719250e-02f, 5.15640043e-02f, 3.79405878e-02f,
  9.28490236e-02f, -7.70608112e-02f, 2.14882661e-02f, -5.98849542e-02f, -8.16390757e-03f, 3.81057709e-02f, 8.73736665e-02f, -5.70244761e-03f, -8.70697498e-02f, 7.12860674e-02f,
  -5.98602556e-02f, 1.64359361e-02f, 3.46755870e-02f, 5.09874336e-02f, 1.57904113e-03f, -2.55481657e-02f, 8.56588110e-02f, 7.51829566e-03f, 1.24363273e-01f, 1.79411098e-02f,
  1.15934843e-02f, 4.67986688e-02f, 1.17733270e-01f, 5.91465347e-02f, -1.67990118e-04f, 5.33069409e-02f, 5.18151224e-02f, 8.56303647e-02f, 8.53176340e-02f, 1.03952773e-01f,
  -2.79891025e-02f, -1.27428556e-02f, 2.43698936e-02f, -2.14176420e-02f, -8.43153819e-02f, -1.76419001e-02f, 2.81283329e-03f, 1.25445635e-03f, -3.49713974e-02f, -8.74616578e-03f,
  -1.75857544e-01f, -9.67950746e-02f, -1.51220085e-02f, 7.29948003e-03f, 7.02170702e-03f, 4.02289592e-02f, 3.33382860e-02f, -4.17081974e-02f, -9.71342772e-02f, -2.60170083e-02f,
  1.22087533e-02f, -1.92256439e-02f, -9.18427110e-02f, -2.53219716e-02f, 1.72700156e-02f, 8.43566936e-03f, -2.78877597e-02f, 1.54445926e-02f, 2.38859262e-02f, -6.43058717e-02f,
  6.36430755e-02f, 2.15612594e-02f, 8.88198391e-02f, 2.86649577e-02f, -7.23116025e-02f, 8.68619382e-02f, 6.75854692e-03f, 3.60536352e-02f, -1.95854325e-02f, 1.18086729e-02f,
  -2.66005427e-01f, 5.85594121e-03f, 1.89696234e-02f, -3.83126400e-02f, 2.18991246e-02f, -1.75672784e-01f, -1.28796250e-01f, 6.42342642e-02f, -7.08957091e-02f, 1.57099124e-02f,
  -5.39431833e-02f, 2.06332549e-01f, -1.56995971e-02f, -3.47375721e-02f, -1.96547225e-01f, 2.32586209e-02f, -8.55064839e-02f, 2.93004382e-02f, 1.25094891e-01f, -1.73475835e-02f,
  3.19020189e-02f, -2.29388271e-02f, 8.72184783e-02f, 1.08678408e-01f, 5.81830554e-02f, 1.53467596e-01f, 6.05034195e-02f, 1.93125904e-01f, 1.45014888e-02f, 1.90498516e-01f,
  -8.28526467e-02f, -6.52856613e-03f, 1.51808104e-02f, 8.96233972e-03f, 2.48581618e-02f, 3.02772364e-03f, 2.24270932e-02f, 4.69110021e-03f, 2.49472167e-02f, 3.94866196e-03f,
  1.50368735e-02f, -1.03357667e-02f, -2.63282028e-03f, 7.01169744e-02f, -1.36944801e-02f, 1.02145830e-03f, -2.13133562e-02f, -1.73415765e-02f, 6.50358712e-03f, -2.45520584e-02f,
  -6.59587383e-02f, 8.52031410e-02f, -5.01022711e-02f, -5.83778471e-02f, -4.44697291e-02f, 1.61143709e-02f, -1.07555509e-01f, 3.04311179e-02f, -2.79508140e-02f, 5.22907637e-03f,
  -3.45101543e-02f, 8.36630818e-03f, -1.09460041e-01f, 2.49876920e-02f, -6.38955459e-02f, -8.54803622e-02f, -7.96213746e-02f, 1.10365842e-02f, 3.34598459e-02f, -6.37559816e-02f,
  1.59750953e-02f, -1.31032187e-02f, -8.00033100e-03f, -9.85104144e-02f, -8.79591331e-03f, -2.05304176e-02f, 4.25724313e-02f, 2.04304308e-02f, 3.83781549e-03f, 6.41229656e-03f,
  2.01727092e-01f, -2.00711396e-02f, 2.60917954e-02f, -1.42060043e-02f, 4.68654558e-02f, 6.01887591e-02f, 1.49996020e-02f, 8.11720267e-02f, -1.37729952e-02f, -1.34844249e-02f,
  -4.05883305e-02f, 1.64215043e-02f, -4.52805161e-02f, -1.95394177e-02f, 5.99507391e-02f, -9.97291729e-02f, -4.57846150e-02f, -3.84530388e-02f, 2.90375222e-02f, 3.36246602e-02f,
  2.37887390e-02f, 3.10632084e-02f, -3.06524839e-02f, -1.08916625e-01f, 1.03592612e-01f, 3.72106992e-02f, -4.68812697e-02f, -4.29388285e-02f, -3.61031145e-02f, 8.49046484e-02f,
  2.81773154e-02f, 4.75336425e-03f, -6.11790046e-02f, -1.02472000e-01f, -9.16323587e-02f, 4.64172959e-02f, 1.05767220e-01f, 6.65869936e-02f, -2.81179529e-02f, -4.96218763e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.12560034e-01f, 1.25283375e-01f, 2.59941697e-01f, 3.17790180e-01f, -2.48825282e-01f, -2.24391922e-01f, -2.16374919e-01f, 6.01136126e-02f, -1.70621559e-01f, -8.05489868e-02f,
  -5.07697240e-02f, 1.01059884e-01f, -1.91574916e-01f, 2.89164007e-01f, 2.80062169e-01f, -8.67930204e-02f, 2.19591036e-01f, 8.69382843e-02f, 2.99456809e-02f, 2.02192947e-01f,
  1.45453528e-01f, 1.86048131e-02f, 1.64334714e-01f, 1.80943742e-01f, 1.44178659e-01f, 2.27121159e-01f, 2.56274194e-01f, 8.73007923e-02f, 4.40742999e-01f, 9.30746272e-02f,
  2.87043545e-02f, -4.41892445e-02f, 1.10891871e-01f, -2.44664717e-02f, -7.15507194e-02f, 2.11332478e-02f, 5.61620072e-02f, 1.03570834e-01f, -9.54700008e-05f, 4.74462919e-02f,
  -7.47292489e-02f, 1.24083444e-01f, -2.04807147e-02f, 4.50173542e-02f, 6.90183789e-02f, 8.11863095e-02f, -5.34059666e-02f, 6.11063559e-03f, 2.32137758e-02f, 2.98969094e-02f,
  7.68151954e-02f, -8.09907354e-03f, -1.89992916e-02f, 7.97449518e-03f, 3.91191617e-03f, 8.73793140e-02f, 6.32043183e-03f, 5.66764809e-02f, 4.04306613e-02f, 1.02341935e-01f,
  8.92835930e-02f, -1.76385328e-01f, -3.20007317e-02f, -3.73659283e-02f, 5.80386035e-02f, 5.04693575e-02f, -9.62262750e-02f, -7.65744373e-02f, 1.77056622e-02f, -8.22293281e-04f,
  4.71187569e-02f, 4.91377600e-02f, -1.53340667e-01f, -2.82940976e-02f, 4.70103733e-02f, -1.29339725e-01f, -9.58448425e-02f, 2.10935604e-02f, -4.02984122e-04f, 8.36831778e-02f,
  1.25240842e-02f, -2.06994750e-02f, 5.57788201e-02f, -1.07833810e-01f, -3.86491301e-03f, -1.45933460e-02f, -6.18877374e-02f, 7.37911239e-02f, 8.14232416e-03f, 6.15842640e-02f,
  1.90224382e-03f, 9.78709832e-02f, 7.13024363e-02f, 7.21644759e-02f, 1.24041094e-02f, 1.51739627e-01f, 1.82299167e-02f, 1.02048106e-02f, 8.38660523e-02f, 1.13884620e-01f,
  6.42913058e-02f, -6.01862520e-02f, 8.39009043e-03f, 1.86167769e-02f, 4.92269546e-02f, 6.47703633e-02f, -7.86394030e-02f, 4.74015549e-02f, 1.03493556e-01f, 1.31494910e-01f,
  -4.80800644e-02f, -1.57988667e-01f, -8.46601278e-02f, -2.43287589e-02f, -1.26217641e-02f, -1.15934886e-01f, 4.19201702e-02f, 2.04132292e-02f, 2.26986874e-02f, 3.89905944e-02f,
  -2.03404963e-01f, 2.91969210e-01f, -1.49935231e-01f, -2.10662156e-01f, 3.79977137e-05f, -1.65210158e-01f, -2.24613830e-01f, -2.66697425e-02f, -1.23722330e-01f, -1.48444235e-01f,
  -1.78747773e-01f, 2.06548035e-01f, -3.76557931e-02f, -1.88748240e-01f, -2.72562802e-01f, -8.29773694e-02f, -2.86896557e-01f, -7.91698247e-02f, 7.02687204e-02f, -3.32609517e-03f,
  4.55154963e-02f, -1.47818133e-01f, -1.94850825e-02f, 1.73559695e-01f, -7.34162480e-02f, -7.51524465e-04f, -2.45842069e-01f, 5.74834980e-02f, -5.79129579e-03f, 5.55713177e-02f,
  -1.85857281e-01f, -1.77811190e-01f, -1.53021097e-01f, -6.52874559e-02f, -1.99022144e-01f, -4.26554354e-03f, -8.60658586e-02f, 3.28974947e-02f, -6.75173178e-02f, 6.46981760e-04f,
  4.54677194e-02f, 6.40915066e-04f, -4.53488976e-02f, 5.06275408e-02f, -9.82029736e-03f, -3.16577870e-03f, -3.55575641e-04f, 4.46435325e-02f, -1.01855388e-02f, 1.80073112e-01f,
  3.06571685e-02f, 1.64964665e-02f, -1.47233874e-01f, -8.58464763e-02f, -7.67348111e-02f, -3.60220596e-02f, -5.32771647e-02f, -7.56336330e-03f, 5.47117554e-03f, -1.07528813e-01f,
  4.01076339e-02f, -1.76085951e-03f, -1.78782940e-02f, -3.17115746e-02f, 1.75378621e-02f, -1.87286418e-02f, -4.86590788e-02f, -4.42829030e-03f, -3.27304937e-02f, -9.06719044e-02f,
  6.06632233e-02f, 5.64409085e-02f, 1.83390826e-02f, -3.77711244e-02f, 9.61109623e-02f, -1.87349245e-02f, -7.42806587e-03f, 4.83908467e-02f, 7.59502053e-02f, 2.77030431e-02f,
  -1.20560549e-01f, -8.32839683e-02f, 6.19293712e-02f, -1.47380410e-02f, -5.98574802e-03f, -4.86992337e-02f, -1.75774544e-02f, -2.24894080e-02f, -8.65910649e-02f, 4.02651075e-03f,
  -3.58220220e-01f, -4.09886599e-01f, -2.05918681e-02f, -5.96279912e-02f, -4.32678312e-02f, -6.50732825e-03f, -5.41450530e-02f, 3.79686877e-02f, 2.38932092e-02f, -6.81869164e-02f,
  2.52022706e-02f, 8.80320743e-03f, -9.62329581e-02f, -1.01416454e-01f, 2.95966957e-02f, -9.37732235e-02f, -1.19842462e-01f, -9.30838585e-02f, -1.33367628e-01f, 4.94247861e-03f,
  2.93307044e-02f, -1.69908982e-02f, -6.51065353e-03f, -8.10525659e-03f, -1.08231932e-01f, -3.14170904e-02f, 3.55775841e-02f, 3.07581518e-02f, -1.23001300e-01f, -4.93025482e-02f,
  1.69174895e-01f, 5.54605164e-02f, 3.03600013e-01f, -7.98720587e-03f, 1.56054944e-01f, 1.58889502e-01f, 2.18754709e-01f, 1.42904930e-02f, 1.72750667e-01f, -2.95202196e-01f,
  -1.32592186e-01f, 5.66796027e-02f, -7.83239026e-03f, -1.79342881e-01f, 3.06977276e-02f, 4.01799567e-02f, 4.12165448e-02f, 5.40191904e-02f, 2.02998087e-01f, -2.71599945e-02f,
  -2.77340487e-02f, -2.20586568e-01f, 1.62933901e-01f, -9.89067107e-02f, 5.74087650e-02f, 9.41871107e-03f, -1.60156012e-01f, 1.22030608e-01f, -2.74541140e-01f, -3.24166827e-02f,
  1.21365793e-01f, 2.23853774e-02f, 9.48289111e-02f, -8.71888995e-02f, 1.20372467e-01f, 3.27771381e-02f, -8.51157010e-02f, -5.50896786e-02f, 9.23530087e-02f, -7.51081184e-02f,
  -1.12026460e-01f, -1.23563930e-01f, -4.00486626e-02f, -9.75578949e-02f, 8.03324580e-02f, -4.97496836e-02f, 8.68653283e-02f, 6.59224465e-02f, 7.98814669e-02f, 8.88539106e-02f,
  8.32332969e-02f, 1.75906830e-02f, 1.60111547e-01f, -9.15893912e-02f, 3.26720439e-02f, 8.38707089e-02f, -1.01753278e-03f, 1.22630913e-02f, -2.53222026e-02f, -1.38309607e-02f,
  -1.76986977e-02f, -6.46940693e-02f, 8.33170023e-03f, 8.93058907e-03f, 1.73511207e-02f, 1.21613964e-02f, -3.97344865e-02f, -4.90076281e-02f, 4.21355516e-02f, -8.93336833e-02f,
  -6.41844571e-02f, -3.80916297e-02f, 3.74538042e-02f, 6.77977428e-02f, -1.57218084e-01f, -7.66332671e-02f, 1.43368766e-02f, -1.11962125e-01f, 9.84273925e-02f, 1.11385877e-03f,
  -9.48760062e-02f, 6.00332245e-02f, 4.21797819e-02f, -5.16402796e-02f, 7.13834018e-02f, 5.90760559e-02f, -1.78101644e-01f, -5.32858185e-02f, -5.70817031e-02f, 4.73206937e-02f,
  5.13864458e-02f, -1.63459256e-01f, 7.69586563e-02f, -5.69561124e-02f, 4.90031764e-02f, -3.52004170e-02f, -2.12357286e-02f, -7.08328187e-02f, 1.34166241e-01f, -1.67296484e-01f,
  -1.06419995e-01f, 3.00199557e-02f, -6.57446682e-02f, -8.17756057e-02f, 1.51405156e-01f, -6.46569058e-02f, 2.90244389e-02f, -1.69533736e-03f, -8.52659941e-02f, -1.51441814e-02f,
  -4.55915183e-02f, -3.47322449e-02f, 5.29175028e-02f, -3.55953798e-02f, -1.13072596e-01f, -7.73834437e-03f, -3.15969288e-02f, 6.11541420e-02f, -8.74175429e-02f, -2.96316072e-02f,
  3.23922187e-01f, 1.50846541e-01f, 3.33216250e-01f, 2.14930192e-01f, -1.48141012e-01f, -1.08994478e-02f, 2.11297184e-01f, -2.61327997e-02f, 2.69552082e-01f, 1.20254345e-02f,
  -1.90620527e-01f, 2.33180493e-01f, -1.21516600e-01f, 1.39187455e-01f, -9.76154730e-02f, -3.91622558e-02f, 6.65185526e-02f, -7.26126805e-02f, 2.69371495e-02f, 6.47383928e-02f,
  4.33307812e-02f, -2.99012035e-01f, -2.60416195e-02f, -2.93824971e-01f, -3.20770815e-02f, 1.82423249e-01f, -2.71106362e-01f, -8.11209083e-02f, 1.73198935e-02f, -2.60934606e-02f,
  1.68520436e-02f, -1.39149297e-02f, 1.27432831e-02f, 1.09487809e-01f, 1.12574687e-03f, -2.69970410e-02f, 1.03612535e-01f, 9.80356336e-02f, 1.20427506e-02f, 1.13470286e-01f,
  9.03617963e-02f, 5.32383882e-02f, 2.83556189e-02f, 5.00464179e-02f, 1.03670627e-01f, 1.32879794e-01f, 5.66356704e-02f, -2.28592232e-02f, 1.30058467e-01f, 2.35702917e-02f,
  8.08193907e-02f, -9.44844820e-03f, 1.05766818e-01f, 1.10664591e-01f, 3.72984633e-02f, 5.13932593e-02f, 4.61420566e-02f, 1.61634833e-02f, -9.34248716e-02f, 9.39842910e-02f,
  -1.17781840e-01f, -6.52682153e-04f, 1.13576548e-02f, -2.78063081e-02f, 4.24193554e-02f, 1.39956921e-02f, -4.71940339e-02f, -4.57201526e-02f, 8.48627985e-02f, 1.26005961e-02f,
  5.85494004e-02f, 6.46320209e-02f, -2.59252470e-02f, 6.53477609e-02f, -5.83734699e-02f, 2.42790785e-02f, 3.82106900e-02f, 1.15870610e-01f, 6.32640347e-03f, 5.58822863e-02f,
  -1.38583958e-01f, -2.76891645e-02f, 1.60442404e-02f, -1.24589186e-02f, -4.25550006e-02f, -6.07652478e-02f, 2.84280144e-02f, 2.97479834e-02f, -8.43003858e-03f, -2.94358842e-02f,
  -1.25383571e-01f, -1.15797579e-01f, -9.29380208e-03f, 1.81803659e-01f, -6.76732510e-02f, 9.81230196e-03f, 1.41508493e-03f, 1.20636739e-01f, -1.93877146e-02f, 5.88473380e-02f,
  1.41087919e-02f, -3.53333689e-02f, -2.01519728e-02f, 9.88980010e-02f, 3.21862698e-02f, -4.48839217e-02f, 2.80112624e-02f, 3.60264187e-03f, -1.02387361e-01f, -1.70512155e-01f,
  -7.27532478e-03f, -5.79124205e-02f, 9.08392817e-02f, 1.39730163e-02f, 6.52688220e-02f, 1.19752511e-01f, -2.52940152e-02f, 8.19140449e-02f, -8.63427147e-02f, -1.63845289e-02f,
  1.06929444e-01f, -2.92040348e-01f, 1.58796862e-01f, -3.11198970e-03f, 1.50615528e-01f, -3.02655958e-02f, 7.16049671e-02f, -1.96080729e-01f, -1.23723328e-01f, -2.96614438e-01f,
  -8.85618478e-02f, 2.48440266e-01f, 1.01527870e-01f, -1.85831890e-01f, 4.83071119e-01f, 1.84828326e-01f, -1.81499705e-01f, -3.39742303e-02f, 6.73273858e-03f, -6.14604764e-02f,
  6.38313740e-02f, -2.57266194e-01f, 9.06053782e-02f, -3.35001975e-01f, -8.29604864e-02f, -1.50372356e-01f, 1.37289897e-01f, 1.87848166e-01f, -8.46274644e-02f, 1.26649141e-01f,
  -2.40630716e-01f, -2.17732623e-01f, -1.73111156e-01f, -1.37005776e-01f, -9.08690784e-03f, 7.38327131e-02f, -1.82202272e-02f, 2.07809925e-01f, 2.56897770e-02f, -2.12793741e-02f,
  9.54932943e-02f, -7.38368183e-02f, -1.59398794e-01f, -1.08007364e-01f, -4.33434770e-02f, -1.07329421e-01f, -3.78521904e-02f, -1.13955803e-01f, 5.26550636e-02f, 6.08722270e-02f,
  -5.31587824e-02f, -1.73649788e-02f, 3.66503485e-02f, -4.14695853e-04f, -5.71417734e-02f, -6.12865649e-02f, 8.24404061e-02f, 2.16848448e-01f, -6.01304248e-02f, -3.78970020e-02f,
  -1.91014502e-02f, -6.33615404e-02f, -4.12901351e-03f, -5.37609980e-02f, -3.56539562e-02f, -1.49253190e-01f, 2.13650949e-02f, 7.70001113e-02f, 4.49698232e-03f, -7.89312795e-02f,
  -3.32277864e-02f, 7.30740204e-02f, 3.02310530e-02f, 2.03905273e-02f, -7.76880234e-02f, -3.56507935e-02f, 7.86273107e-02f, 7.72404000e-02f, -1.11430466e-01f, 5.95120601e-02f,
  -1.73813533e-02f, 7.33287707e-02f, -7.07994848e-02f, -3.92643102e-02f, -6.37441427e-02f, -1.29423179e-02f, -1.28112897e-01f, -3.59936953e-02f, 7.58675113e-02f, 2.69910935e-02f,
  -2.60013312e-01f, -1.45011514e-01f, -1.01767965e-01f, -1.66499168e-01f, -3.82320546e-02f, -1.85816586e-02f, 4.05161604e-02f, -1.15483422e-02f, 4.38327901e-02f, 4.57059778e-02f,
  -7.41705149e-02f, -7.24735484e-02f, 3.30037139e-02f, -2.91174538e-02f, -3.98041904e-02f, -5.13308682e-02f, 4.88418527e-02f, 1.01819567e-01f, 4.13930416e-03f, -6.23862632e-02f,
  -4.59245928e-02f, -5.09629659e-02f, 6.22197166e-02f, -1.86680779e-01f, -9.96178091e-02f, -1.34431235e-02f, -7.13430159e-03f, -1.68403387e-02f, 2.28073336e-02f, 1.73723120e-02f,
  3.83946836e-01f, 2.26504296e-01f, 2.42196456e-01f, 2.75525451e-01f, -3.00914317e-01f, -2.08750218e-01f, -2.97364205e-01f, -7.22143753e-03f, -8.11445042e-02f, -1.83307126e-01f,
  -1.20246522e-02f, 1.12484299e-01f, -4.61032167e-02f, 2.17127576e-01f, 2.47078419e-01f, -9.40686688e-02f, 1.93614960e-01f, -4.05389927e-02f, -3.03279776e-02f, 1.77337408e-01f,
  5.72240874e-02f, 6.19233549e-02f, 2.47015506e-01f, 1.38526067e-01f, 2.35527754e-02f, 1.56048089e-01f, 2.26482660e-01f, 5.33268787e-02f, 2.04075813e-01f, -2.84170825e-02f,
  -9.52973962e-02f, -3.02820243e-02f, 5.10880314e-02f, -9.25958529e-02f, 6.57798052e-02f, -1.39892966e-01f, -1.27953559e-01f, 1.07012026e-01f, -3.79917473e-02f, 4.97861318e-02f,
  -9.04288422e-03f, 3.40714790e-02f, 6.37410134e-02f, 8.59305188e-02f, 5.30173853e-02f, 1.19589575e-01f, 5.02397567e-02f, 4.34791856e-03f, -2.48042159e-02f, 7.86698684e-02f,
  1.22163050e-01f, 5.52129606e-03f, -4.48043160e-02f, -9.12737325e-02f, 1.08887345e-01f, 9.51228365e-02f, -1.59713462e-01f, 6.63875863e-02f, -4.15244093e-03f, 1.66732464e-02f,
  4.45435904e-02f, -5.12238480e-02f, -4.26371954e-02f, -5.34864701e-02f, -2.93358378e-02f, 2.70050280e-02f, -1.98211297e-01f, -2.74276026e-02f, -2.21989043e-02f, -1.27823308e-01f,
  -4.82011661e-02f, 1.30068315e-02f, -3.96626517e-02f, -4.44954485e-02f, 1.68374472e-03f, -6.54303804e-02f, -5.66518791e-02f, -3.75985578e-02f, -8.02122056e-04f, 1.62879489e-02f,
  -7.72376359e-03f, 2.14899257e-02f, 8.72606486e-02f, -1.90826990e-02f, -3.60543765e-02f, -5.64435981e-02f, 1.72530264e-02f, 9.01374221e-02f, -2.50893310e-02f, 7.03081712e-02f,
  1.13011701e-02f, 2.37375483e-01f, 4.11295928e-02f, -4.99773510e-02f, -7.48339202e-03f, 2.37981249e-02f, -8.46960861e-03f, -3.16659617e-03f, 1.33397713e-01f, 1.03525653e-01f,
  -3.39905955e-02f, -8.76514465e-02f, -1.31017253e-01f, 9.26134363e-02f, 2.80983769e-03f, 1.82237029e-02f, 1.10985734e-01f, -1.57117307e-01f, 4.03650254e-02f, 2.15848207e-01f,
  -1.64319705e-02f, -7.86050558e-02f, -4.65476476e-02f, -1.06354423e-01f, -8.27019382e-03f, -7.66500160e-02f, -3.91613245e-02f, 2.21484713e-02f, -9.02954303e-03f, 7.80197009e-02f,
  -2.93346107e-01f, -9.71754566e-02f, -2.19505012e-01f, -1.81619033e-01f, 3.77616622e-02f, -4.04351830e-01f, -1.85207248e-01f, 2.23667803e-03f, 1.77465931e-01f, 1.43348470e-01f,
  -4.80965711e-02f, -2.66811755e-02f, 1.18916996e-01f, -1.61997542e-01f, -2.18523398e-01f, 5.74373081e-02f, -3.46949458e-01f, -2.99791574e-01f, 6.14197366e-02f, -2.38090232e-01f,
  -7.69521967e-02f, -1.11068927e-01f, -2.42191777e-01f, 3.11873090e-02f, -3.07256848e-01f, -7.25722313e-02f, 9.90882516e-02f, -2.71960367e-02f, -1.88321009e-01f, -8.73257034e-03f,
  -3.56783308e-02f, 2.14768648e-01f, 1.54334661e-02f, -1.30296543e-01f, -1.05702676e-01f, -1.07721426e-01f, -1.07963093e-01f, 5.54277822e-02f, -4.28492166e-02f, -7.56774144e-03f,
  -5.18368185e-02f, 5.17594405e-02f, -3.17716151e-02f, 3.52742337e-02f, -2.52285730e-02f, 6.88739941e-02f, -5.20490482e-02f, -3.16134878e-02f, 1.18058054e-02f, -8.61734301e-02f,
  3.48346233e-02f, -6.42256159e-03f, -7.97974765e-02f, 1.18155926e-01f, -5.89933842e-02f, 1.13493353e-01f, -2.21979618e-02f, -1.88331194e-02f, -7.44648129e-02f, -1.71886780e-03f,
  -3.44526619e-02f, -2.63380329e-03f, -3.24213579e-02f, -5.66124134e-02f, 3.56190614e-02f, 2.78701708e-02f, -1.73163768e-02f, 4.05694172e-02f, -1.19086895e-02f, 5.94251119e-02f,
  4.60923053e-02f, -4.25184779e-02f, 2.58789100e-02f, -3.21992114e-02f, -4.31562252e-02f, 3.48359682e-02f, -6.25254959e-02f, -3.38131301e-02f, -1.27937451e-01f, -1.00326426e-01f,
  1.85282350e-01f, 1.71992611e-02f, 7.43132317e-03f, 6.79680100e-03f, 4.21137922e-02f, 5.40075339e-02f, -3.18934806e-02f, -6.64379597e-02f, 1.20359771e-02f, -9.41855088e-02f,
  1.06751332e-02f, -9.13148522e-02f, 9.66536701e-02f, 1.00961827e-01f, 8.32935143e-03f, -1.10735565e-01f, -9.81337670e-03f, -3.70704662e-03f, -4.58761817e-03f, -5.15913963e-02f,
  -1.44301012e-01f, -2.79643126e-02f, -6.84120432e-02f, -1.22329900e-02f, -1.62196327e-02f, 1.35070113e-02f, 3.89268622e-02f, 1.30371228e-01f, -3.30355093e-02f, -6.04420062e-03f,
  -2.20637862e-02f, 1.33559182e-01f, 8.14448595e-02f, 6.53578043e-02f, 7.17506856e-02f, 2.37365756e-02f, 5.87997353e-03f, 5.18675148e-02f, -2.01478153e-02f, 2.90584378e-02f,
  3.35326970e-01f, 4.59009130e-03f, -1.08902985e-02f, 2.24697545e-01f, 1.68548673e-01f, 1.56803876e-01f, 2.11581483e-01f, 2.62296289e-01f, 5.36762238e-01f, -6.53526485e-02f,
  2.10090708e-02f, 4.98163737e-02f, -1.47185341e-01f, 9.75386053e-02f, 1.38401806e-01f, 4.02362309e-02f, 2.17632711e-01f, 1.44004941e-01f, 2.28028879e-01f, 1.11494131e-01f,
  2.37468079e-01f, 5.85794449e-02f, -2.08592966e-01f, -2.22454146e-01f, -2.90216766e-02f, -7.15867803e-02f, -3.02352160e-01f, -1.24286920e-01f, -2.57112771e-01f, -4.28302884e-02f,
  -4.61397432e-02f, 1.50489420e-01f, -4.47892025e-02f, -8.82290769e-03f, -2.38175178e-03f, -3.21860798e-02f, -1.01432055e-01f, -8.68952200e-02f, -7.89333694e-03f, -2.35944279e-02f,
  6.69731274e-02f, -3.78564745e-02f, 1.00269847e-01f, -3.04280408e-02f, -1.23313684e-02f, 1.34422025e-02f, 8.25294014e-03f, 1.23483883e-02f, 8.63827765e-03f, -2.41063256e-02f,
  1.48314647e-02f, -3.43610831e-02f, -2.84418147e-02f, -9.89172831e-02f, 1.14760327e-03f, -7.54927145e-03f, 7.19228759e-02f, -8.12876225e-02f, 6.09274171e-02f, 3.32880542e-02f,
  -5.93098402e-02f, -1.73890274e-02f, -2.74898373e-02f, 1.43226599e-02f, 2.97353212e-02f, 4.10682783e-02f, 7.74852280e-03f, 4.57413569e-02f, 6.55917078e-02f, 1.10655269e-02f,
  1.75363477e-02f, 1.05298206e-01f, 6.42659739e-02f, 4.52928543e-02f, 2.35110018e-02f, 9.94566306e-02f, -5.32582030e-03f, -4.09397073e-02f, 4.32371609e-02f, -4.05471027e-03f,
  3.15072872e-02f, 2.77227387e-02f, -1.46886736e-01f, -9.19749141e-02f, -7.76619911e-02f, 5.16155548e-02f, 1.77549291e-02f, -8.76826867e-02f, 1.08139180e-02f, 1.15925916e-01f,
  3.94802280e-02f, 1.66434184e-01f, -6.01446405e-02f, -1.72675587e-02f, 1.60054415e-02f, -7.16159679e-03f, 1.34904593e-01f, 3.81305404e-02f, 5.08557446e-03f, 4.72635999e-02f,
  2.04217315e-04f, 7.36113787e-02f, -4.48945239e-02f, 5.59144057e-02f, -5.15691787e-02f, -4.97240350e-02f, 7.60621671e-03f, -7.41369352e-02f, -9.74204689e-02f, 4.47262488e-02f,
  -1.18918546e-01f, 2.71070562e-02f, 6.39017671e-02f, -1.50182908e-02f, 9.19625461e-02f, -4.44712378e-02f, -4.94181961e-02f, -1.02196762e-03f, -5.67107350e-02f, -7.88823292e-02f,
  -5.10142982e-01f, 9.16613564e-02f, -3.82345431e-02f, -1.28392622e-01f, -2.44209602e-01f, -3.10669690e-01f, 3.05234920e-02f, -1.74748436e-01f, 1.27034053e-01f, 2.04194814e-01f,
  1.78007215e-01f, -1.68141603e-04f, 3.13225478e-01f, 1.77889407e-01f, -7.64584094e-02f, 1.65048599e-01f, -1.09364204e-02f, 5.48632815e-02f, -1.13111176e-01f, -1.31131023e-01f,
  -4.78012189e-02f, -6.09512329e-02f, 6.06035739e-02f, -1.15971304e-01f, -9.86795947e-02f, -9.75633562e-02f, 6.05858043e-02f, -6.17103800e-02f, -1.87181458e-02f, -1.68560836e-02f,
  -1.85315326e-01f, -1.55486673e-01f, -1.19038984e-01f, 9.57159400e-02f, -6.41016662e-02f, -1.24450006e-01f, 1.21897571e-02f, -9.27163847e-03f, -5.64296953e-02f, -8.74671489e-02f,
  -8.01604614e-02f, 2.75809970e-03f, -1.02033459e-01f, -2.75180954e-02f, -5.25665581e-02f, -5.26783578e-02f, -7.82021731e-02f, 5.15349358e-02f, -4.28869538e-02f, 1.86045412e-02f,
  6.02886453e-02f, -4.72311527e-02f, 3.21750827e-02f, 1.96300913e-02f, -4.53702360e-02f, -6.84565231e-02f, 2.77286116e-02f, 1.05824880e-01f, -1.86588675e-01f, -8.43130797e-02f,
  -2.64029931e-02f, 6.83458569e-03f, 4.14673053e-02f, 1.14826597e-02f, -1.69563964e-02f, 4.27387729e-02f, 5.08045629e-02f, 2.82110483e-03f, 6.55687749e-02f, -9.13795382e-02f,
  7.30316911e-04f, -6.93445802e-02f, -9.56903398e-02f, 2.79016718e-02f, -7.75557244e-03f, 9.03030708e-02f, 7.95050040e-02f, 2.95020845e-02f, 1.46267906e-01f, 8.16564709e-02f,
  -4.97756675e-02f, 2.70917658e-02f, 5.96783124e-03f, 2.39150394e-02f, -4.46744403e-03f, -3.59248254e-03f, -2.80483514e-02f, 6.05123453e-02f, -1.11411717e-02f, -3.64925899e-02f,
  -4.54827517e-01f, -3.07322890e-01f, -1.22765355e-01f, -7.61634782e-02f, -5.43945096e-02f, -6.44764528e-02f, -1.32337501e-02f, -1.93267331e-01f, -9.54146683e-02f, -8.59169438e-02f,
  4.12841933e-03f, -8.72456096e-03f, -8.56012106e-02f, 1.92873999e-02f, -2.07244456e-02f, 8.64672065e-02f, 1.57593917e-02f, -3.25770602e-02f, -5.17536551e-02f, -8.67717117e-02f,
  -1.65013671e-02f, -8.74534175e-02f, 6.67936951e-02f, -1.02380738e-01f, -9.57036167e-02f, 2.17123851e-02f, -1.01786897e-01f, 4.90822047e-02f, -6.93929568e-02f, -3.21480185e-02f,
  7.05021098e-02f, -2.78747797e-01f, 2.50962436e-01f, -2.25992780e-02f, 3.22656155e-01f, 1.62581816e-01f, 1.39287621e-01f, 1.56151175e-01f, 5.27715012e-02f, -2.18024492e-01f,
  -1.39643118e-01f, -2.04251766e-01f, -8.83467272e-02f, -1.55296400e-01f, 8.55771229e-02f, -1.66839391e-01f, -1.97866745e-02f, -1.58248812e-01f, 8.75030905e-02f, 1.16313780e-02f,
  3.66181582e-02f, 1.62503719e-02f, 2.25430265e-01f, 5.07080331e-02f, -4.17539431e-03f, -6.44982010e-02f, -8.07024017e-02f, 1.97947994e-01f, 6.44036084e-02f, 1.22995347e-01f,
  6.32670149e-02f, -1.71638831e-01f, -2.97157988e-02f, -4.39388305e-02f, 2.82393340e-02f, -3.16790715e-02f, -8.16700831e-02f, -1.89356301e-02f, -2.80607026e-02f, 2.42784042e-02f,
  -4.82419617e-02f, -1.06005045e-02f, -2.57818326e-02f, -5.05209994e-03f, 9.62700322e-03f, 1.26931444e-01f, 6.07128628e-02f, -1.30802225e-02f, 1.26287907e-01f, 4.90844361e-02f,
  1.04622848e-01f, -2.44767796e-02f, -3.33790779e-02f, -1.58576071e-01f, 7.30740698e-03f, -8.27973634e-02f, -8.22226182e-02f, 4.70564701e-02f, 1.64570548e-02f, 8.44395980e-02f,
  2.32265014e-02f, -1.34164765e-01f, 2.00390778e-02f, -5.99019136e-03f, 6.46026060e-02f, -8.06863457e-02f, 4.16906141e-02f, -3.45555060e-02f, -3.18007246e-02f, 5.82864247e-02f,
  1.68183018e-02f, 3.93762477e-02f, 4.37126160e-02f, 9.61904973e-03f, -1.70644015e-01f, -8.18176493e-02f, -1.11580297e-01f, -6.76235184e-02f, -2.20564064e-02f, -1.38299791e-02f,
  -4.10080813e-02f, -8.61776154e-03f, -1.66176483e-02f, -7.17271045e-02f, -3.56124341e-02f, -5.67205437e-02f, -4.72110733e-02f, 2.23857928e-02f, -1.16470149e-02f, 8.93380046e-02f,
  -3.72368574e-01f, -2.77137786e-01f, -8.48093256e-02f, -6.04011491e-02f, -1.08263195e-01f, -3.95318232e-02f, -5.65955602e-02f, -2.46571638e-02f, -3.12765911e-02f, 2.34618802e-02f,
  -1.60061479e-01f, 7.57317524e-03f, -8.18103775e-02f, -1.92788523e-02f, -2.60175373e-02f, 1.00482572e-02f, -6.83035403e-02f, -5.04447110e-02f, 5.90352807e-03f, -1.33560756e-02f,
  -5.78136630e-02f, -1.95191205e-01f, 1.09660909e-01f, -7.58737102e-02f, -5.60967438e-02f, -1.58430543e-02f, -1.12729326e-01f, 3.24892737e-02f, 1.42564978e-02f, 2.58558262e-02f,
  2.19782278e-01f, -3.75760138e-01f, -2.14213207e-02f, 2.45934784e-01f, 2.71236479e-01f, 9.52940509e-02f, 1.20748937e-01f, -2.49465570e-01f, -1.66970268e-01f, -1.98877886e-01f,
  7.55995139e-02f, -8.20552707e-02f, -2.10855573e-01f, 9.21038985e-02f, 3.63357604e-01f, -1.76163793e-01f, 2.24958226e-01f, 1.68819010e-01f, -1.05563715e-01f, -2.90423576e-02f,
  4.23573330e-02f, 2.92872995e-01f, -8.24002028e-02f, -4.92137857e-02f, 1.61678821e-01f, -6.54642805e-02f, 6.19843416e-02f, -1.46529481e-01f, 1.19587563e-01f, 9.14991796e-02f,
  1.35263503e-01f, -5.82143217e-02f, 4.30670790e-02f, 3.05001508e-03f, -3.08686979e-02f, 5.42799346e-02f, 2.00128127e-02f, 1.73801228e-01f, 2.64626034e-02f, -7.10700005e-02f,
  6.03151247e-02f, 8.87631550e-02f, 1.14355542e-01f, 4.91616502e-02f, -2.82991920e-02f, 6.32419586e-02f, -2.56016329e-02f, -9.15962160e-02f, -1.09353043e-01f, -3.93656045e-02f,
  -7.12096319e-02f, -2.54506152e-03f, 1.88138392e-02f, -9.69852321e-03f, 6.28534995e-04f, 6.01121373e-02f, -2.35785693e-02f, -3.41739096e-02f, 6.96181729e-02f, -9.29014310e-02f,
  -1.92417949e-02f, -8.86203796e-02f, 2.47093569e-02f, 2.53500119e-02f, 6.26829965e-03f, 8.35505351e-02f, -1.34877130e-01f, -4.54585217e-02f, -9.46699232e-02f, -3.55614610e-02f,
  6.78000450e-02f, -5.09904921e-02f, 3.21350805e-02f, 5.98510802e-02f, 9.45434868e-02f, -7.03087375e-02f, 6.54189140e-02f, 6.54715523e-02f, 8.09340738e-03f, 7.07308054e-02f,
  2.05816831e-02f, 5.31332232e-02f, -1.47132983e-03f, 9.10723954e-02f, 4.36276980e-02f, -3.78213972e-02f, 3.42142163e-03f, -2.23344713e-02f, -3.12747061e-02f, 2.44060531e-02f,
  -1.64896905e-01f, -2.31513694e-01f, -7.34705999e-02f, 9.89829898e-02f, -3.89761105e-02f, -2.94592194e-02f, 2.82221530e-02f, 4.38102074e-02f, -4.61527035e-02f, 7.49861449e-03f,
  1.13238581e-01f, 1.58516258e-01f, -1.37748778e-01f, -3.57527006e-03f, -8.64316337e-03f, -3.95727158e-02f, 1.92615874e-02f, -9.29659754e-02f, -1.14841178e-01f, 3.60909142e-02f,
  1.03693465e-02f, 7.97831193e-02f, 3.32981348e-02f, -1.25056775e-02f, 4.25577955e-03f, -5.24414144e-02f, 5.35275787e-02f, -1.02066778e-01f, 1.02335632e-01f, 3.13265473e-02f,
  -2.56302003e-02f, -1.12475798e-01f, -1.90558482e-03f, 2.67720222e-01f, 3.06100808e-02f, -9.70021933e-02f, -2.19993085e-01f, 2.27416039e-01f, -1.85153574e-01f, -2.84656826e-02f,
  1.96145684e-01f, -1.55487761e-01f, -1.95159376e-01f, 5.14236130e-02f, 1.84992373e-01f, -2.10130692e-01f, 1.52548939e-01f, -6.15967177e-02f, -7.17103481e-02f, 1.11751102e-01f,
  1.45308390e-01f, 3.06835353e-01f, 1.87803537e-01f, 4.83938843e-01f, 4.20932509e-02f, 2.27883607e-01f, 4.53009665e-01f, 8.66307765e-02f, 3.43101442e-01f, 1.15725979e-01f,
  -1.21329203e-01f, -4.31657508e-02f, -2.29664985e-02f, -1.31313473e-01f, 6.88653290e-02f, 1.31599039e-01f, -3.11636832e-02f, -6.90721273e-02f, -8.92267749e-02f, -5.30452803e-02f,
  -4.26146202e-02f, -7.11843651e-03f, 1.02785394e-01f, 4.12715785e-02f, 2.46885139e-02f, -1.66311138e-03f, -9.71792042e-02f, -8.26267451e-02f, -2.09369704e-01f, 2.65853275e-02f,
  -4.32288684e-02f, 4.64923270e-02f, -1.79745685e-02f, -7.11439252e-02f, 1.22785121e-02f, 7.09517598e-02f, 3.53189372e-02f, 5.60021326e-02f, 9.19949356e-03f, 2.72833183e-02f,
  3.50746959e-02f, -4.03871685e-02f, -1.15840882e-01f, -3.91316824e-02f, -3.46668586e-02f, -2.73744464e-02f, -1.17739044e-01f, 2.04607584e-02f, -2.52316240e-02f, 2.66498867e-02f,
  2.63330918e-02f, 4.49527241e-02f, 2.34571248e-02f, -3.02062687e-02f, -3.01944446e-02f, -3.70729752e-02f, 3.80906574e-02f, 5.40249981e-02f, -9.65208863e-04f, -1.25674829e-01f,
  -6.74377233e-02f, 6.67806044e-02f, 2.09204927e-02f, -5.28700538e-02f, 7.29643777e-02f, 1.36209860e-01f, 3.98469195e-02f, 2.43383665e-02f, 1.48346098e-02f, 8.74816030e-02f,
  5.30729070e-02f, 2.38247320e-01f, -4.70323004e-02f, -8.05104598e-02f, -1.51822669e-02f, 5.66928200e-02f, -8.48511830e-02f, 1.81884617e-02f, 3.67267691e-02f, 2.69135963e-02f,
  3.51166837e-02f, -4.93691005e-02f, 8.12092423e-02f, 5.72313890e-02f, 6.76861331e-02f, 7.53662735e-02f, -6.37184456e-03f, 2.37617418e-02f, 1.71335172e-02f, 1.77997455e-01f,
  6.12271205e-02f, -5.01864552e-02f, -7.46679083e-02f, -1.00733414e-01f, 1.05488300e-01f, -2.64983848e-02f, 1.50606707e-01f, 2.28980891e-02f, -2.09422875e-02f, -6.06519617e-02f,
  3.31901282e-01f, -2.37592333e-03f, 6.08950853e-02f, 6.19399659e-02f, 1.15221828e-01f, 4.98282872e-02f, -1.90741923e-02f, -4.77029644e-02f, 8.14741999e-02f, -3.20281312e-02f,
  7.16710743e-03f, -4.94988523e-02f, -1.91770345e-01f, -1.22749554e-02f, -2.72503775e-02f, -1.58272311e-01f, 1.45064920e-01f, 3.64774838e-03f, 4.80622128e-02f, 4.14705649e-02f,
  6.62789270e-02f, 5.23893647e-02f, -1.21682212e-01f, 5.60826510e-02f, 8.47879350e-02f, 1.82028487e-01f, 9.80380923e-02f, 6.51620179e-02f, -1.23530835e-01f, 1.60159878e-02f,
  -3.91224623e-02f, -1.22008942e-01f, -3.53417322e-02f, -5.51505759e-02f, 1.35465980e-01f, 4.20248769e-02f, 9.38985422e-02f, -1.26848370e-01f, -6.19093329e-02f, -8.22416469e-02f,
  -4.82149422e-02f, -5.68927126e-03f, 6.75651878e-02f, -3.26106437e-02f, -1.08316718e-02f, -9.98672321e-02f, -1.21518247e-01f, 7.46395737e-02f, -1.48959562e-01f, -1.66125268e-01f,
  -1.16948038e-01f, -7.34803751e-02f, 1.41183808e-01f, 5.06232269e-02f, 7.25967139e-02f, 8.46566483e-02f, 3.94601449e-02f, -3.70488130e-02f, -4.02013734e-02f, 3.72401029e-02f,
  -9.54653951e-04f, -1.33498684e-01f, 1.96572561e-02f, -8.29084292e-02f, 2.97830459e-02f, 3.65397222e-02f, 4.56794240e-02f, 1.63703308e-01f, 1.26777336e-01f, -7.84948021e-02f,
  1.33820653e-01f, 1.30470648e-01f, -2.68921349e-02f, 4.55962587e-03f, 1.00429259e-01f, -1.91679373e-02f, 1.32049918e-01f, 8.96583274e-02f, 7.86628649e-02f, 3.65526490e-02f,
  6.33663312e-02f, 4.72484455e-02f, -7.98573866e-02f, 3.26835923e-02f, 6.97403103e-02f, 9.10268947e-02f, -7.83147216e-02f, -1.54650360e-02f, -1.30101759e-02f, 5.64301759e-02f,
  5.97467180e-03f, 6.21964596e-02f, -5.13639040e-02f, -6.86391816e-02f, 2.14427020e-02f, 1.11981295e-01f, 1.35638565e-01f, -6.68939650e-02f, 3.87586541e-02f, 1.62390824e-02f,
  9.00931582e-02f, 9.10455510e-02f, 7.84139261e-02f, -3.64331417e-02f, -2.94918399e-02f, -7.43685588e-02f, -2.40247939e-02f, 6.77378755e-03f, -7.37247709e-03f, -3.62794995e-02f,
  -1.04532562e-01f, 1.43450364e-01f, 7.65946954e-02f, 5.98104820e-02f, 3.17241997e-02f, -5.33660688e-02f, 6.51237294e-02f, -2.17824038e-02f, 7.86263868e-03f, -8.03684890e-02f,
  2.74054766e-01f, -4.88196522e-01f, -1.57747477e-01f, 1.96960777e-01f, 2.79832512e-01f, 5.23619028e-03f, 5.50696254e-02f, 9.98834893e-02f, 2.24781245e-01f, -2.70653218e-01f,
  -5.81162311e-02f, -1.26365393e-01f, -3.90891552e-01f, -2.02382058e-02f, 2.55819380e-01f, -3.03739309e-01f, 2.59417649e-02f, -1.78020433e-01f, -9.55540165e-02f, -1.64867770e-02f,
  1.48620829e-01f, 2.00008065e-01f, 1.09281607e-01f, 1.21865392e-01f, 6.73557892e-02f, 1.09017625e-01f, 1.57063484e-01f, -1.28700748e-01f, 1.58087730e-01f, 9.62408632e-02f,
  1.03685774e-01f, -6.73857406e-02f, 1.02451541e-01f, -3.15623507e-02f, -2.78088171e-02f, -1.49931520e-01f, -2.47458592e-02f, -3.94054614e-02f, 7.96611831e-02f, 1.68062076e-02f,
  -2.27090865e-02f, 6.29110336e-02f, -6.63220230e-03f, 6.44664839e-02f, 4.08086441e-02f, 9.07677487e-02f, 7.19949305e-02f, 2.50879489e-02f, 5.54297268e-02f, -1.79880470e-01f,
  -1.05485193e-01f, -6.27184585e-02f, -5.82266487e-02f, -3.51604521e-02f, -3.07136215e-03f, 3.45995389e-02f, -2.05905773e-02f, -1.32787108e-01f, 3.17951441e-02f, 9.57762599e-02f,
  9.73143354e-02f, -6.84907986e-03f, -8.17131475e-02f, -2.37777620e-03f, 4.11465839e-02f, 4.58000191e-02f, 7.51269460e-02f, -6.19105026e-02f, -6.88748732e-02f, -3.60333137e-02f,
  7.22482055e-02f, 2.51848958e-02f, -5.91854639e-02f, 3.77245583e-02f, 5.82913309e-02f, -1.45477224e-02f, -4.57382873e-02f, -5.49357347e-02f, -1.62058286e-02f, 7.52302781e-02f,
  4.34411541e-02f, 6.18409663e-02f, -9.27613378e-02f, 5.45475408e-02f, -5.03627993e-02f, -2.58392394e-02f, -3.05466186e-02f, -4.89384867e-02f, 9.80800763e-02f, -2.82656662e-02f,
  -1.41334847e-01f, -2.21789300e-01f, 9.39470064e-03f, 4.26573157e-02f, -4.75900061e-03f, -1.67607024e-01f, -1.01731881e-01f, 3.88664082e-02f, -2.52845269e-02f, -2.54239868e-02f,
  -2.91261580e-02f, -2.20670342e-03f, -1.09100586e-03f, 7.28391707e-02f, 5.91940358e-02f, -8.13875571e-02f, 1.02244904e-02f, -3.36292982e-02f, 1.61409691e-01f, -7.31496187e-03f,
  -4.41371500e-02f, -8.87611136e-02f, -7.08941668e-02f, 1.07398219e-01f, -9.18311626e-03f, -3.61227803e-02f, -1.58512238e-02f, -3.02842427e-02f, -8.12424049e-02f, 4.00048383e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.72727153e-02f, 2.52769619e-01f, 2.59181350e-01f, 1.54401273e-01f, -4.45278082e-03f, 9.63277146e-02f, 8.64554569e-02f, 1.81680202e-01f, 1.00089617e-01f, 1.05979815e-01f,
  4.67426442e-02f, 2.41505280e-01f, 1.89548403e-01f, -7.03013837e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -2.35664900e-02f, 3.47576618e-01f, -1.88481390e-01f, 2.20677301e-01f, -2.93591451e-02f, 1.03429839e-01f, -1.92609400e-01f, -1.13307610e-01f, 1.35636285e-01f, -2.27589384e-01f,
  -1.72852486e-01f, -6.83347927e-03f, 2.47242406e-01f, 2.62909174e-01f, -1.97364748e-01f, -1.24337830e-01f, -2.21197709e-01f, 1.36130735e-01f, 1.88309085e-02f, 8.39184225e-02f,
  1.97099335e-02f, 2.62592167e-01f, -3.32104594e-01f, 1.00898400e-01f, -1.27589265e-02f, 1.04540717e-02f, -1.19776078e-01f, -1.64933071e-01f, -7.88810551e-02f, 8.30467194e-02f,
  -9.58230868e-02f, -4.00487959e-01f, 9.23805162e-02f, -1.59075558e-01f, 1.71098206e-03f, -1.74780503e-01f, 2.28559092e-01f, -2.58033201e-02f, -4.11263928e-02f, 4.17969972e-02f,
  8.72751549e-02f, 5.01584485e-02f, -1.26148149e-01f, 1.46412373e-01f, 2.64697134e-01f, 1.18662991e-01f, -1.72962695e-01f, -2.84264237e-01f, 1.10072553e-01f, -1.52604014e-01f,
  -8.39742646e-02f, -9.19711888e-02f, 7.85689950e-02f, 2.26512298e-01f, -2.78676689e-01f, -4.30665277e-02f, -3.62594813e-01f, 3.00441563e-01f, -2.48928905e-01f, -6.15185918e-03f,
  -3.74457799e-02f, -2.13824734e-01f, 2.42254704e-01f, -5.94120212e-02f, 1.32891193e-01f, -1.60302788e-01f, 8.36260095e-02f, 2.90004537e-02f, -8.84257853e-02f, 1.80636704e-01f,
  2.41453052e-02f, 9.38030854e-02f, -5.43280505e-02f, 2.97481325e-02f, -1.43105194e-01f, -4.11963165e-02f, 2.20949814e-01f, -7.61820078e-02f, 7.89454132e-02f, -6.69797361e-02f,
  1.95884764e-01f, -7.61535950e-04f, -9.06807631e-02f, -2.22365171e-01f, 1.12757981e-01f, -4.05798629e-02f, 2.00235426e-01f, 1.51629016e-01f, -1.59556374e-01f, 1.95602141e-02f,
  -8.58661011e-02f, 1.64506242e-01f, 2.74848908e-01f, 9.94996950e-02f, 1.43632829e-01f, 4.50522453e-01f, -2.78132707e-01f, 9.12606833e-04f, -4.76340592e-01f, 3.56258675e-02f,
  -2.79313121e-02f, 7.10135617e-04f, -2.15604022e-01f, 6.96594652e-04f, -1.38774186e-01f, 4.55989763e-02f, -1.00302689e-01f, -1.46490350e-01f, 6.46363199e-02f, 4.35879648e-01f,
  -3.74437273e-01f, 1.19749703e-01f, -4.60817039e-01f, 7.82081038e-02f, 1.53953701e-01f, -4.91908900e-02f, -4.58968043e-01f, -2.86260039e-01f, -4.73309845e-01f, 1.50671415e-02f,
  3.63695323e-02f, -2.41714805e-01f, 6.59908131e-02f, -2.01625407e-01f, 2.92409748e-01f, 3.55550319e-01f, -1.96763813e-01f, 1.81264341e-01f, -1.32505130e-02f, 2.45587751e-01f,
  2.70976555e-02f, 6.00624606e-02f, 9.87496898e-02f, 1.69008717e-01f, -1.96866691e-02f, 9.26322266e-02f, 2.84804367e-02f, 7.76547417e-02f, -8.50816816e-02f, 4.55120355e-02f,
  9.57097113e-02f, -6.24431372e-02f, -1.01310782e-01f, -8.12449157e-02f, -1.51371375e-01f, 1.29471734e-01f, 6.74608573e-02f, -2.31795362e-03f, -4.92508188e-02f, 1.28120095e-01f,
  -1.41088068e-01f, -4.55373488e-02f, -1.84744835e-01f, 1.20536454e-01f, -2.68343419e-01f, 9.25500691e-02f, -2.33287930e-01f, 9.62584540e-02f, 3.39952596e-02f, -2.43511409e-01f,
  -1.54338315e-01f, 3.06553483e-01f, -1.03659093e-01f, -1.46977693e-01f, -5.97564876e-02f, -5.88740706e-02f, 8.44125748e-02f, -2.62207333e-02f, -9.79512185e-02f, -2.70233423e-01f,
  -1.18192017e-01f, 3.05438548e-01f, 5.75143136e-02f, -8.61775130e-02f, 1.38370007e-01f, -1.30866870e-01f, -3.21177654e-02f, 1.42772555e-01f, 1.99004427e-01f, 3.23678941e-01f,
  2.62554158e-02f, -4.45479639e-02f, -3.67334224e-02f, 2.09502697e-01f, 2.48923749e-01f, -1.64626434e-01f, -1.33892298e-01f, -6.86631724e-03f, -2.63760716e-01f, 4.79128957e-02f,
  -8.36598352e-02f, -2.50661969e-01f, -9.44343060e-02f, 1.33035645e-01f, -1.67716950e-01f, 1.27996236e-01f, -3.69907655e-02f, -6.15420341e-02f, -3.85976806e-02f, 2.25614551e-02f,
  -8.39152709e-02f, 2.16019645e-01f, 3.41206752e-02f, 8.14161748e-02f, -2.28896618e-01f, 1.31596521e-01f, 8.57078135e-02f, 3.93447131e-01f, -2.29679152e-01f, 1.34019330e-01f,
  -2.30416551e-01f, -1.70484781e-02f, -5.44110574e-02f, -2.40519017e-01f, 3.60196918e-01f, -2.54782319e-01f, 1.96143135e-01f, -3.14281672e-01f, 2.20502526e-01f, -7.87449107e-02f,
  -2.19451357e-02f, -9.56512764e-02f, -2.06379041e-01f, -1.47805482e-01f, -2.01962009e-01f, 3.54811661e-02f, -1.82904154e-01f, 9.42202359e-02f, -1.89251438e-01f, -7.20788091e-02f,
  8.94673914e-02f, -1.07894346e-01f, -1.10590287e-01f, -1.18182831e-01f, 1.13882713e-01f, 5.06593660e-02f, -5.92456609e-02f, 1.09752864e-01f, 1.37071431e-01f, -6.01810105e-02f,
  1.05803303e-01f, 3.96738648e-02f, -2.47840863e-02f, 8.11171532e-02f, 2.44241096e-02f, -1.11988693e-01f, 5.67900296e-03f, -6.34970814e-02f, 2.78871208e-01f, -1.09155431e-01f,
  1.91480830e-01f, -2.26816311e-01f, -1.02424994e-01f, -1.14199929e-01f, -8.43718946e-02f, -3.19283634e-01f, 1.54573873e-01f, -3.07748377e-01f, 1.83217883e-01f, 1.59719616e-01f,
  -9.38938931e-02f, -8.22930038e-02f, 1.17138419e-02f, 1.35249570e-01f, 1.21329568e-01f, 2.07410634e-01f, 9.22407433e-02f, -2.47752234e-01f, -1.12341523e-01f, -6.07750602e-02f,
  6.98986351e-02f, 1.06934503e-01f, 2.74644401e-02f, -2.16280147e-01f, -2.59896725e-01f, -7.15587139e-02f, -7.08786026e-02f, -1.36605009e-01f, 2.20559780e-02f, -2.07450137e-01f,
  2.41206437e-01f, 2.63151884e-01f, 2.23513469e-01f, 2.28152573e-01f, 2.59847343e-01f, 1.98156871e-02f, -6.60031568e-03f, 1.64498299e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  5.03182948e-01f, -9.43396315e-02f, 4.64550167e-01f, 1.90873191e-01f, 1.71352044e-01f, 3.00450712e-01f, 2.76038587e-01f, 2.71935463e-01f, 3.74045789e-01f, 2.74219483e-01f,
  -4.17167433e-02f, -1.21533625e-01f, -9.34509039e-02f, -1.43007100e-01f, 6.93420991e-02f, 2.50568628e-01f, 7.93336928e-02f, -3.76958959e-02f, -3.86281796e-02f, 1.72782354e-02f,
  3.14196974e-01f, 3.67787033e-01f, 1.16624922e-01f, -1.81196377e-01f, -1.56101003e-01f, 2.72290289e-01f, 1.69921309e-01f, 3.80273134e-01f, 1.08932421e-01f, 2.33280519e-03f,
  7.28787482e-02f, 2.23320946e-01f, 6.90082982e-02f, 5.57920992e-01f, -2.35841051e-01f, 2.03970015e-01f, 6.52877539e-02f, 3.38217348e-01f, 3.28408837e-01f, 8.10460597e-02f,
  1.74253762e-01f, -1.94769174e-01f, -2.08617300e-01f, 6.43124878e-02f, 8.61726850e-02f, 2.36347094e-01f, -1.89347371e-01f, 2.18150198e-01f, -3.51532668e-01f, 2.76526004e-01f,
  4.34372053e-02f, 2.87450284e-01f, 1.51197035e-02f, 8.17771181e-02f, -3.11714448e-02f, 3.53404842e-02f, 2.21424535e-01f, -2.28543371e-01f, 4.02818203e-01f, 3.34075429e-02f,
  -7.01507032e-02f, 2.41316482e-01f, -6.99608624e-02f, -2.08124474e-01f, 9.89866704e-02f, 2.81087589e-02f, 2.45238215e-01f, 1.69453561e-01f, 7.96139240e-02f, -1.32963927e-02f,
  6.55423254e-02f, 1.44844487e-01f, 1.44836932e-01f, -5.27061671e-02f, 6.63654059e-02f, -3.69547457e-01f, 4.49855700e-02f, 7.73268342e-02f, -3.28594923e-01f, -3.20121467e-01f,
  2.57692430e-02f, -1.12803325e-01f, 3.15865636e-01f, -2.28606224e-01f, -1.41199857e-01f, -8.49273577e-02f, -9.31806043e-02f, 5.09603381e-01f, -7.08206445e-02f, 4.13439423e-01f,
  -1.30950138e-01f, 7.50813484e-02f, 1.97570756e-01f, 3.58830303e-01f, 1.82868764e-01f, 3.13780099e-01f, -1.29505992e-01f, 5.76225743e-02f, 3.28067839e-02f, -4.42283675e-02f,
  -1.45095378e-01f, -3.85429263e-02f, 4.63551357e-02f, 1.30314097e-01f, -7.71985948e-02f, -3.00372720e-01f, -5.76344803e-02f, 2.90253401e-01f, -2.03335926e-01f, -1.80972129e-01f,
  3.72716099e-01f, 1.05036870e-01f, 2.36180238e-02f, 9.87940729e-02f, 1.82354613e-03f, 2.99282491e-01f, 6.64922968e-02f, -1.84108138e-01f, 2.95329452e-01f, -3.37141976e-02f,
  5.74546874e-01f, -7.29556084e-02f, 1.28978044e-01f, 1.35820627e-01f, -7.77474418e-02f, -1.51555777e-01f, -1.53644651e-01f, -1.12156168e-01f, 2.86583692e-01f, -4.60135452e-02f,
  5.19703090e-01f, 2.17845529e-01f, 1.86377466e-01f, 2.17995644e-01f, 2.73813665e-01f, 1.45716473e-01f, 1.27262652e-01f, 1.83415756e-01f, 1.19627021e-01f, -2.79709667e-01f,
  -1.65337607e-01f, -3.52472477e-02f, 1.95194274e-01f, 1.63976818e-01f, 1.76364735e-01f, -2.11766046e-02f, -6.39967993e-02f, 2.29266919e-02f, 2.43812874e-01f, 1.22164853e-01f,
  2.03924879e-01f, 7.94160515e-02f, -1.32640600e-01f, 1.87179521e-01f, 3.46912950e-01f, 3.52332175e-01f, 3.10165375e-01f, 9.02894011e-04f, 4.81384387e-03f, 3.31353158e-01f,
  1.20016046e-01f, 3.25285316e-01f, 9.89011154e-02f, -3.55748944e-02f, 2.74297029e-01f, 7.27017298e-02f, 4.92643490e-02f, 2.03753427e-01f, 5.26310690e-02f, -2.30312616e-01f,
  1.74524605e-01f, -1.09641194e-01f, 2.68485218e-01f, -2.05681965e-01f, -1.51551515e-01f, -3.39024633e-01f, 1.58264041e-01f, 2.00003907e-01f, 2.06828669e-01f, 1.68830365e-01f,
  1.87850043e-01f, 3.31562430e-01f, 1.06503144e-01f, 3.99514377e-01f, -6.47432357e-03f, 3.26777905e-01f, -6.83627874e-02f, -2.63277233e-01f, -4.48476076e-01f, 9.00444295e-03f,
  -2.51315389e-04f, -1.61143884e-01f, 5.56420684e-02f, 1.23555958e-01f, -6.76028728e-02f, 2.75525957e-01f, -6.42214864e-02f, 6.91362172e-02f, 8.78211334e-02f, 1.02257460e-01f,
  1.40338868e-01f, 1.27571613e-01f, 1.74675539e-01f, -9.69149696e-04f, -2.20850289e-01f, 2.82795005e-03f, 1.64133146e-01f, 3.10605645e-01f, -9.15194675e-02f, 1.13796264e-01f,
  -7.99272284e-02f, 2.50002652e-01f, 7.24467933e-02f, 5.84357698e-03f, 3.17475587e-01f, -2.27923051e-01f, 3.22955281e-01f, -2.13856012e-01f, 3.70773196e-01f, -6.63527474e-03f,
  -3.87775674e-02f, -6.47979323e-03f, -1.41347691e-01f, -1.77830800e-01f, -1.70076728e-01f, 2.80793577e-01f, -1.74915213e-02f, 1.73593730e-01f, 2.26644680e-01f, -3.39009473e-03f,
  -8.98896828e-02f, 2.90896446e-01f, 1.43220469e-01f, 9.72589925e-02f, 2.54784226e-01f, -3.14008117e-01f, -2.06085518e-01f, 3.18359703e-01f, -5.04729629e-01f, -1.06213555e-01f,
  -3.07310998e-01f, -3.12450767e-01f, 3.48935425e-01f, -2.90700078e-01f, -4.11670476e-01f, -2.46314138e-01f, -1.44676477e-01f, 2.71381438e-01f, -4.68310155e-02f, 2.66619772e-01f,
  1.13858975e-01f, -2.22702339e-01f, 3.65163565e-01f, 4.02950883e-01f, 5.95190302e-02f, 9.66898203e-02f, 2.95166552e-01f, 5.25147617e-01f, 1.96335644e-01f, 3.02608401e-01f,
  5.89513257e-02f, 4.09674942e-01f, 1.69450149e-01f, 2.03995049e-01f, 3.28974187e-01f, -6.20746054e-03f, -2.29327142e-01f, 1.89299867e-01f, -2.76740730e-01f, 7.10221299e-04f,
  9.01436880e-02f, 4.90616202e-01f, -2.62064487e-01f, 2.32112095e-01f, 2.86794275e-01f, 3.70090842e-01f, 5.67935556e-02f, -2.93284003e-02f, -5.66129088e-02f, -9.12749916e-02f,
  -5.28706517e-03f, -3.82378399e-01f, 6.57849163e-02f, 3.31200898e-01f, 6.73407987e-02f, 3.07111681e-01f, 8.79985187e-03f, 2.32207075e-01f, 1.13445543e-01f, 6.29066154e-02f,
  2.69872814e-01f, 1.48419574e-01f, 3.37731332e-01f, 3.05927426e-01f, 7.39648715e-02f, 1.54186785e-01f, 2.77534038e-01f, -8.47691670e-02f, 7.28054419e-02f, -4.07373011e-02f,
  3.33708599e-02f, -2.12319687e-01f, -9.80962068e-02f, -1.89536154e-01f, 2.31561244e-01f, -6.23254552e-02f, 2.19263673e-01f, 1.40231818e-01f, 2.20146716e-01f, 2.47113958e-01f,
  -7.78546408e-02f, 4.09226626e-01f, -1.93165734e-01f, 3.95400673e-01f, -1.31053865e-01f, 3.49105299e-01f, 1.61283910e-01f, 1.80133551e-01f, 1.89709499e-01f, 2.10407138e-01f,
  2.19459936e-01f, 2.91122049e-01f, -6.85952976e-02f, 2.16778219e-01f, 1.49752691e-01f, 1.27492890e-01f, 1.51444912e-01f, 3.36730838e-01f, 2.04606637e-01f, -5.75871915e-02f,
  -8.14114884e-02f, 2.03087274e-02f, 2.27822606e-02f, 1.82567462e-01f, -2.97909707e-01f, 1.26081156e-02f, -1.55079037e-01f, -1.08310273e-02f, 3.16575497e-01f, -1.06516406e-02f,
  -1.35006070e-01f, -2.90551037e-02f, -1.81114703e-01f, 1.96720243e-01f, -8.92910585e-02f, 1.00075528e-01f, -1.35977298e-01f, -1.70944840e-01f, 5.11525907e-02f, 4.50885236e-01f,
  2.16316491e-01f, 9.47396681e-02f, 1.20538272e-01f, -1.36914879e-01f, 1.62596166e-01f, 2.00253934e-01f, -1.28977910e-01f, 2.63171792e-02f, 3.01258624e-01f, 7.70297348e-02f,
  1.97303042e-01f, 2.12006763e-01f, 1.84875399e-01f, -2.18445122e-01f, -2.57288575e-01f, -1.35684043e-01f, 1.65919825e-01f, 1.57821834e-01f, 1.95532843e-01f, -4.98669632e-02f,
  1.17195379e-02f, 7.51748830e-02f, -1.69337296e-03f, -9.62627903e-02f, 2.25704819e-01f, -8.59526247e-02f, -1.48179635e-01f, -1.21175662e-01f, 3.12748671e-01f, -2.22750157e-02f,
  4.07397389e-01f, 2.22711135e-02f, -8.78843665e-02f, 2.00843543e-01f, 2.93674588e-01f, 3.32080305e-01f, 9.55431983e-02f, 1.16666131e-01f, 3.71557117e-01f, 3.48487109e-01f,
  1.52424544e-01f, 2.21546024e-01f, 3.10919732e-01f, 1.69568472e-02f, -1.59308314e-01f, 2.86373973e-01f, 1.00736268e-01f, 7.33201206e-02f, -2.11922273e-01f, 7.70019293e-02f,
  -2.17211604e-01f, 9.67450738e-02f, 7.03698173e-02f, 4.39715087e-01f, 2.12179005e-01f, 2.98533261e-01f, -1.84469327e-01f, -2.43845746e-01f, 3.17765683e-01f, 4.97742631e-02f,
  5.81370965e-02f, -4.08437476e-02f, -2.32764035e-01f, 3.02186776e-02f, 1.09358467e-01f, -3.37286890e-01f, 6.51810085e-03f, 1.77872464e-01f, 3.76605928e-01f, -8.77174959e-02f,
  3.03591073e-01f, 5.52037321e-02f, 2.84925491e-01f, 5.78182973e-02f, 2.50667155e-01f, -2.29684025e-01f, 1.26839682e-01f, 1.96539193e-01f, 4.42530140e-02f, -3.37679923e-01f,
  3.58032286e-01f, 3.00507173e-02f, 2.25969553e-01f, 1.99700370e-01f, 3.06561738e-01f, 4.09329355e-01f, 2.07090288e-01f, 2.13236332e-01f, 3.17597300e-01f, 1.91416517e-01f,
  2.72522569e-01f, 9.12461728e-02f, -2.09702365e-03f, 6.40262067e-02f, -2.26496413e-01f, -5.92118762e-02f, -8.60825479e-02f, -2.72418082e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  5.09113185e-02f, 3.11105698e-01f, 2.32529581e-01f, 2.24251002e-01f, 8.71665403e-02f, 3.41467336e-02f, 2.07727119e-01f, 3.60968590e-01f, 2.02488378e-01f, 2.74997890e-01f,
  3.17181349e-01f, 1.68194011e-01f, 4.31233913e-01f, 3.47741157e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  2.12543994e-01f, 1.28658727e-01f, 3.46799701e-01f, -8.06340128e-02f, 8.95426273e-02f, 2.35658109e-01f, 1.15781896e-01f, 4.00712937e-01f, 1.37346342e-01f, 2.18806848e-01f,
  6.97231442e-02f, -5.31040058e-02f, -1.04860790e-01f, 3.60341519e-02f, 4.31889854e-02f, 1.98342562e-01f, -3.26356851e-03f, 2.85793412e-02f, 1.14196902e-02f, 3.08017433e-01f,
  -8.06202665e-02f, -1.44955158e-01f, -2.18819767e-01f, 2.88279783e-02f, 1.22433938e-01f, 8.99659470e-02f, -1.68637544e-01f, 1.75731734e-03f, -6.46820366e-02f, -1.22432224e-01f,
  3.28176081e-01f, -2.79465653e-02f, -1.98940039e-02f, 9.28997174e-02f, 2.28038877e-01f, -5.98564036e-02f, -6.82892324e-03f, 5.26679307e-02f, 4.25159521e-02f, 2.27708206e-01f,
  -1.04715608e-01f, 1.73558757e-01f, 3.22548226e-02f, -6.11471497e-02f, -2.64836270e-02f, 1.84372291e-01f, 1.93995416e-01f, 2.88773626e-01f, 1.05087627e-02f, -2.53007114e-01f,
  1.56426549e-01f, 2.86381096e-01f, -3.57165426e-01f, -2.44288787e-01f, -1.61085472e-01f, 5.48545644e-02f, 1.06125318e-01f, -1.26120433e-01f, 1.49143130e-01f, -9.29578617e-02f,
  8.52202717e-03f, -1.51251316e-01f, 1.23212308e-01f, -6.77830055e-02f, 1.57934293e-01f, -5.30971996e-02f, 1.43696025e-01f, 1.87788442e-01f, 2.64753737e-02f, 1.56067908e-01f,
  -1.61648378e-01f, 1.54737711e-01f, -1.02761142e-01f, -6.90814927e-02f, 1.98658600e-01f, -5.54340743e-02f, 8.56829658e-02f, 6.03748187e-02f, 8.29255879e-02f, -2.01130912e-01f,
  -2.80931573e-02f, -7.62999728e-02f, 5.01140067e-03f, -9.68364999e-02f, 1.98918372e-01f, -1.84581667e-01f, 1.11588918e-01f, 7.46989101e-02f, -8.36893395e-02f, 2.73390144e-01f,
  1.92497633e-02f, 1.97489858e-01f, 2.65150487e-01f, -1.20994732e-01f, 1.21248523e-02f, -2.56854892e-01f, -1.83465347e-01f, 5.18706888e-02f, 9.90218744e-02f, -2.11810712e-02f,
  -5.70785766e-03f, -1.60376027e-01f, -1.34050012e-01f, -6.15184344e-02f, -6.78568110e-02f, 1.77630514e-01f, 1.14734575e-01f, -1.53034013e-02f, 1.55723125e-01f, 6.46468699e-02f,
  1.51416302e-01f, -8.90206918e-02f, 1.11942038e-01f, -2.66895235e-01f, -1.56329811e-01f, 1.62021399e-01f, -4.99472581e-02f, -7.86238685e-02f, -1.01159073e-01f, 2.01642439e-01f,
  -1.11555949e-01f, -8.08741078e-02f, -1.63546756e-01f, 2.10077345e-01f, 6.96093291e-02f, -8.04426596e-02f, 1.49118900e-01f, -1.41416239e-02f, -6.29977211e-02f, 7.57624134e-02f,
  -9.14688571e-04f, -1.82575047e-01f, 4.68774848e-02f, 1.13537088e-01f, 8.08250904e-02f, 1.83444738e-01f, -6.56397715e-02f, 9.02386010e-03f, 7.13800117e-02f, 2.14512810e-01f,
  -1.29949540e-01f, 1.06543981e-01f, 1.13203160e-01f, -1.65610969e-01f, -2.35653684e-01f, -1.57214448e-01f, 1.34213055e-02f, -1.01773396e-01f, 1.56963214e-01f, -2.99435198e-01f,
  2.92029262e-01f, -9.26266685e-02f, -2.34983400e-01f, -1.36429161e-01f, 2.18396917e-01f, 3.23971331e-01f, 8.16625282e-02f, 4.19053175e-02f, -1.86320171e-01f, 7.32266903e-02f,
  -9.99262854e-02f, -5.82138784e-02f, -2.15226442e-01f, 1.16918366e-02f, 7.99420252e-02f, 7.74564818e-02f, -2.61345301e-02f, -6.28088787e-02f, 1.04728974e-01f, -1.80214494e-02f,
  -2.31032059e-01f, -5.79527160e-03f, 1.56651586e-01f, 8.12854022e-02f, 5.04938550e-02f, 1.15384683e-01f, 9.11997072e-03f, 1.34134710e-01f, 8.84517133e-02f, 9.53465328e-02f,
  -9.80948508e-02f, 5.89393489e-02f, -8.06250051e-02f, -1.78720564e-01f, 1.93176463e-01f, -1.20632134e-01f, 4.98264968e-01f, -1.04918048e-01f, 9.24644545e-02f, 7.23654777e-02f,
  8.92334059e-02f, -2.41862997e-01f, -1.11157164e-01f, 7.77224526e-02f, 3.71998399e-02f, -6.30797967e-02f, -9.60066542e-02f, 1.60704106e-02f, 2.25135133e-01f, 1.10498518e-01f,
  4.48641274e-03f, 4.33922224e-02f, -2.92932451e-01f, -1.58589765e-01f, -1.27017483e-01f, 1.68033093e-02f, 6.90901354e-02f, 3.19485635e-01f, 8.29065666e-02f, 6.29245676e-03f,
  5.13767079e-02f, 2.07008988e-01f, -1.52651519e-01f, 1.22169144e-01f, -6.78487122e-02f, -7.33494833e-02f, 2.75861859e-01f, -2.67759144e-01f, 9.72953439e-02f, -2.80005485e-01f,
  -1.79529294e-01f, 1.43212318e-01f, 1.28521556e-02f, 1.96341008e-01f, 1.52035177e-01f, 2.67836656e-02f, 1.06291026e-01f, -1.35974780e-01f, 1.77174266e-02f, 1.44052386e-01f,
  -1.48475096e-01f, 4.03760150e-02f, -9.93071310e-03f, -1.43464968e-01f, 2.36750945e-01f, -1.63161725e-01f, -1.90429688e-01f, -2.37077512e-02f, 1.09469153e-01f, 4.50890958e-02f,
  -9.55319554e-02f, 5.47580980e-02f, 5.56410477e-02f, -8.38746950e-02f, -1.03849731e-01f, 1.13759279e-01f, 1.03876390e-01f, -9.47635770e-02f, -2.73079854e-02f, -3.04820955e-01f,
  -1.17194831e-01f, 4.07943018e-02f, -1.54466644e-01f, -2.50556003e-02f, 1.78561553e-01f, 4.16625254e-02f, -1.03831619e-01f, 6.63582310e-02f, -1.64369047e-01f, 2.35305205e-02f,
  -9.98950005e-02f, 1.77875068e-02f, -2.14378357e-01f, 1.58132100e-03f, -3.17425211e-03f, -1.51592210e-01f, -8.99527520e-02f, 9.39531345e-03f, 2.84718007e-01f, -2.37902045e-01f,
  -1.96976140e-01f, 1.10633127e-01f, 1.01223495e-02f, 1.72959685e-01f, 8.87078047e-02f, -2.71418914e-02f, 2.40468204e-01f, -2.51121223e-01f, 2.34594479e-01f, -1.60147727e-01f,
  7.41412118e-03f, 4.12548035e-02f, -3.12611431e-01f, 8.40788558e-02f, 9.59882140e-02f, 1.58700541e-01f, -3.01286668e-01f, -1.69248879e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.72069848e-01f, -1.26635343e-01f, -1.14830919e-01f, 1.85427256e-02f, 1.02505431e-01f, -2.26049781e-01f, -9.69560742e-02f, -1.24010071e-01f, 4.61265296e-02f, 3.15720975e-01f,
  -2.35435426e-01f, -9.35081393e-02f, 3.11344981e-01f, 4.38858457e-02f, 3.76664132e-01f, 1.92734361e-01f, 2.72921443e-01f, -2.72391856e-01f, -5.74791841e-02f, 5.08692384e-01f,
  1.15833312e-01f, 3.06791574e-01f, -1.40258595e-01f, 1.95498273e-01f, 9.58622247e-02f, 7.13694766e-02f, 2.30223119e-01f, -2.04695109e-02f, 3.10041279e-01f, -7.49024823e-02f,
  2.10453406e-01f, 4.53458540e-02f, 2.29049072e-01f, 4.93733734e-02f, -3.45823392e-02f, -2.19656885e-01f, 2.51927525e-01f, 1.64431229e-01f, -3.94065291e-01f, -2.51352135e-02f,
  3.23399194e-02f, -5.06709255e-02f, 4.11951661e-01f, 3.90038490e-02f, -4.76173699e-01f, 2.59635597e-01f, 6.98855147e-02f, -1.77284300e-01f, -2.32900590e-01f, -1.33062452e-01f,
  4.09752369e-01f, 4.76453602e-02f, 1.45414293e-01f, -3.10776681e-01f, 5.67933172e-02f, 3.72141212e-01f, -2.98733890e-01f, -1.57749802e-01f, 3.15458626e-01f, 2.39419267e-01f,
  2.26312682e-01f, -2.68065512e-01f, 4.68461663e-01f, 9.50208232e-02f, 8.08703899e-02f, -9.02219191e-02f, 2.76229382e-01f, 1.33162037e-01f, 8.78048614e-02f, 1.94592923e-01f,
  8.97036046e-02f, 3.08304233e-03f, -1.46037946e-02f, 2.15999335e-01f, -1.05506390e-01f, -4.03254963e-02f, -2.33290523e-01f, 1.48491114e-01f, 5.81516147e-01f, 1.51446819e-01f,
  5.67024127e-02f, -2.75643170e-01f, -1.10049136e-01f, 3.91775936e-01f, -1.51396692e-01f, 3.79274845e-01f, -8.75472501e-02f, 4.33016449e-01f, 3.19741458e-01f, -2.36453012e-01f,
  3.93214583e-01f, 2.09886342e-01f, 3.47917825e-02f, -2.11383820e-01f, 3.77787828e-01f, 4.78839219e-01f, 1.92825153e-01f, 2.67766565e-01f, -2.21373007e-01f, -1.52975172e-02f,
  2.00931802e-01f, 1.41394153e-01f, 7.99187273e-02f, -3.65555324e-02f, 1.02758825e-01f, -2.17060760e-01f, 4.40931283e-02f, 5.87986968e-02f, -1.97608337e-01f, 5.07140607e-02f,
  -3.36352706e-01f, -9.74755809e-02f, -1.31294653e-01f, 3.04285228e-01f, 5.10784388e-01f, -9.93472412e-02f, 2.93531120e-01f, -1.12560473e-01f, 4.52652216e-01f, -1.22049496e-01f,
  -8.45071971e-02f, 1.53635606e-01f, 2.81483412e-01f, 2.71222144e-01f, 2.00556472e-01f, 1.40190721e-01f, -7.59634608e-03f, -1.02622733e-02f, 1.28105670e-01f, 9.73634645e-02f,
  2.00717703e-01f, 4.08635378e-01f, 7.65569657e-02f, 1.26922131e-01f, 1.78365886e-01f, 9.47134420e-02f, 1.24674156e-01f, 3.12003434e-01f, -4.18243796e-01f, 8.20254534e-02f,
  4.20970589e-01f, 8.68888348e-02f, 1.10173017e-01f, 7.28837401e-02f, -1.12732679e-01f, -6.67075366e-02f, -1.84390262e-01f, 4.81048733e-01f, 4.42755729e-01f, -1.48782432e-01f,
  -1.11771636e-01f, 7.03513972e-04f, 4.57525253e-03f, 5.83753169e-01f, 4.83188629e-01f, 1.31193891e-01f, 4.69824016e-01f, 1.48158045e-02f, 3.16863023e-02f, -2.28975907e-01f,
  -1.15969237e-02f, -4.51725610e-02f, 1.58674121e-01f, -5.22463918e-02f, 2.95600276e-02f, -1.07108600e-01f, 2.84245163e-01f, 4.39137046e-04f, 2.31718019e-01f, -2.07240701e-01f,
  -4.73106056e-01f, -1.06883049e-01f, -1.40430406e-01f, -1.07167795e-01f, 1.78818017e-01f, 2.15966225e-01f, 1.79212496e-01f, 2.13080689e-01f, 8.56639221e-02f, 2.66634405e-01f,
  -3.33584577e-01f, 5.71303308e-01f, 2.41101056e-01f, -6.39224201e-02f, 3.13998014e-01f, -2.80226201e-01f, 2.12467954e-01f, -8.91719982e-02f, -4.02538896e-01f, 2.65545577e-01f,
  1.00279480e-01f, 2.91517615e-01f, 2.97609031e-01f, 3.15083534e-01f, 4.24726963e-01f, 2.88232118e-01f, 9.29139480e-02f, 3.05376351e-01f, 1.46686450e-01f, 3.25892568e-01f,
  3.13108683e-01f, 2.41120681e-01f, 4.35384899e-01f, 1.42049715e-01f, 4.72622402e-02f, 2.10069194e-01f, -2.56931156e-01f, -2.99833328e-01f, -2.28670135e-01f, 1.62238017e-01f,
  1.34871989e-01f, -1.84186399e-02f, 4.92490530e-01f, -2.81948149e-01f, 3.48911211e-02f, 3.14072520e-01f, -3.85068357e-02f, 5.65143228e-01f, -2.80398354e-02f, 2.80365884e-01f,
  2.07992494e-01f, -1.21546283e-01f, 3.61909002e-01f, -2.06765950e-01f, 3.43613476e-02f, 1.18530512e-01f, 3.51731092e-01f, -4.32593152e-02f, 6.45592958e-02f, 1.40472487e-01f,
  6.06912225e-02f, 2.13542253e-01f, -9.36982930e-02f, 3.11998159e-01f, 1.39875442e-01f, -1.02975130e-01f, -5.02202094e-01f, 1.77106231e-01f, 5.11457741e-01f, -8.41233507e-03f,
  2.58455034e-02f, -4.32525188e-01f, 1.07232079e-01f, 3.61988187e-01f, -6.94364607e-02f, 2.25040615e-01f, -1.94050923e-01f, 3.36107105e-01f, 1.17107809e-01f, -7.93868154e-02f,
  2.43374690e-01f, 7.60392696e-02f, 1.59089878e-01f, -3.47273052e-01f, 4.29416746e-01f, 4.96461540e-01f, -3.20519470e-02f, -1.03743393e-02f, -2.33883098e-01f, 1.24798872e-01f,
  1.29038721e-01f, 3.66022997e-02f, -8.19688216e-02f, 1.03168609e-02f, -7.58115053e-02f, -2.66307384e-01f, -2.69919962e-01f, 1.26545101e-01f, 4.34166968e-01f, -2.25623965e-01f,
  -2.97874123e-01f, 2.38957033e-02f, 2.78896559e-02f, 2.24427104e-01f, 3.36895764e-01f, 7.80463442e-02f, 2.36487776e-01f, -1.57320395e-01f, 3.62188816e-01f, -3.12567711e-01f,
  2.80622542e-01f, 2.06663549e-01f, 2.95650959e-01f, 5.14306352e-02f, -5.00908010e-02f, 4.33904320e-01f, -1.50985643e-01f, -1.62814096e-01f, 1.71405956e-01f, 1.34923437e-03f,
  -3.99185389e-01f, -1.53274879e-01f, 1.46567732e-01f, -1.01579567e-02f, -1.43234238e-01f, -2.60195524e-01f, 1.94673941e-01f, -3.91718566e-01f, 9.98229459e-02f, -5.49667627e-02f,
  -3.25522959e-01f, 2.81981193e-02f, -1.95151746e-01f, -1.02393031e-01f, -1.69942603e-01f, 2.96439588e-01f, 4.06314224e-01f, -1.95359528e-01f, -2.78392546e-02f, 1.26598706e-03f,
  3.26027811e-01f, -5.17345406e-02f, -3.10091656e-02f, -2.68634975e-01f, 2.64491230e-01f, 4.33390677e-01f, -5.66171631e-02f, 1.67344227e-01f, 1.55308306e-01f, 9.75476578e-02f,
  1.06547832e-01f, 2.21196443e-01f, 1.01963624e-01f, 3.88693847e-02f, 2.69749966e-02f, 8.01561251e-02f, 1.59057587e-01f, 2.75646806e-01f, 9.43567157e-02f, 1.53904129e-02f,
  8.06422904e-03f, 7.22319484e-02f, -4.38314706e-01f, 3.01779151e-01f, -2.85042636e-02f, -7.95469061e-02f, -1.78285256e-01f, -8.03135708e-02f, 4.16260570e-01f, 1.21392041e-01f,
  2.27835968e-01f, -5.92483729e-02f, 4.02089566e-01f, 3.42951089e-01f, 5.16999774e-02f, 1.69793516e-01f, 3.14047068e-01f, 2.96750784e-01f, 3.63212913e-01f, 1.61826581e-01f,
  2.10856482e-01f, 2.15187103e-01f, 1.95199531e-02f, 2.44567633e-01f, 2.45237306e-01f, 2.09066853e-01f, 1.02817073e-01f, 1.55095860e-01f, 1.52074933e-01f, 1.91589430e-01f,
  2.09949091e-01f, 3.53548139e-01f, -2.22295076e-02f, -1.40250996e-01f, 4.28433776e-01f, 1.06742442e-01f, -1.64538547e-01f, 2.75631875e-01f, 3.95904342e-03f, 6.71285465e-02f,
  -1.58748589e-02f, 4.45652604e-01f, -2.42237523e-01f, -3.60055715e-02f, -1.67429611e-01f, -3.57835144e-01f, 2.64042765e-01f, 1.68718994e-01f, 2.92493105e-01f, -3.94498408e-01f,
  2.46563375e-01f, -1.53973073e-01f, 4.08415258e-01f, -4.38771456e-01f, 1.91494107e-01f, 4.30772789e-02f, -1.86922476e-01f, -1.94905456e-02f, 2.49498606e-01f, -2.00840198e-02f,
  -6.92657381e-02f, -1.80788010e-01f, 3.70865315e-02f, -3.79398555e-01f, -3.57570857e-01f, -4.19705175e-03f, 8.03553835e-02f, -2.19107181e-01f, -1.81530774e-01f, 3.42651516e-01f,
  2.45629385e-01f, 3.19130242e-01f, 2.70918936e-01f, 1.67921588e-01f, -1.48870915e-01f, 2.96186328e-01f, 4.26494092e-01f, -1.15100324e-01f, 3.70686114e-01f, -9.49606821e-02f,
  3.06187242e-01f, -2.46849563e-02f, -1.73481345e-01f, 2.94483304e-01f, 1.53484881e-01f, 2.13382766e-01f, 5.12792692e-02f, 4.23273087e-01f, 2.70974338e-01f, 1.62275091e-01f,
  2.49680340e-01f, 2.41018504e-01f, 4.45573896e-01f, 1.68688715e-01f, 2.74188250e-01f, 2.39337876e-01f, -8.91637281e-02f, -5.61602004e-02f, 4.81640249e-01f, 9.95136332e-03f,
  -2.74157852e-01f, 2.87515372e-01f, 2.28144936e-02f, 2.35017449e-01f, 3.68254445e-02f, 2.30012253e-01f, -1.52973369e-01f, -1.25398636e-01f, 1.50557220e-01f, -4.05998498e-01f,
  1.89966962e-01f, 2.99262881e-01f, 5.19622229e-02f, -2.16229036e-01f, 1.50260031e-01f, 2.39312932e-01f, 1.20514005e-01f, -2.97444165e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -4.00327295e-02f, 9.91921797e-02f, 2.71060675e-01f, 8.74750391e-02f, 7.57052898e-02f, 6.33330420e-02f, 2.59273142e-01f, 4.67959382e-02f, 1.34571388e-01f, 1.08561195e-01f,
  1.67237744e-01f, 1.96609288e-01f, 2.28108048e-01f, 2.67955244e-01f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  5.76407695e-03f, -6.15234710e-02f, -4.56762575e-02f, 1.49959296e-01f, -4.27213423e-02f, 7.64181316e-02f, -1.25837289e-02f, 2.18786716e-01f, -1.76796764e-01f, 5.64975180e-02f,
  -1.23736069e-01f, -2.06067845e-01f, 7.07390755e-02f, -1.45498663e-01f, -9.13913324e-02f, 7.02094063e-02f, -7.46468380e-02f, 3.31900865e-01f, 1.03700198e-01f, -1.49263233e-01f,
  7.63079897e-02f, -8.06277692e-02f, -1.51131555e-01f, 9.87888724e-02f, 4.29416411e-02f, -1.89572886e-01f, 1.46051021e-02f, 2.81075183e-02f, -2.67760064e-02f, 2.93437272e-01f,
  5.03094718e-02f, 2.10640013e-01f, 1.87709257e-02f, -2.55306400e-02f, 4.65879329e-02f, -2.41389908e-02f, -4.07621562e-02f, 9.50923562e-02f, 3.63730825e-02f, -9.54022110e-02f,
  8.41056276e-03f, -1.75368160e-01f, -2.13689655e-01f, 4.14513797e-02f, -9.37816501e-02f, -4.37461259e-03f, 8.05361792e-02f, -3.90156433e-02f, 8.11988711e-02f, -2.07566202e-01f,
  -1.47544518e-01f, 2.46803444e-02f, 1.76254064e-01f, 7.34156519e-02f, 6.01676013e-03f, -1.38693392e-01f, -1.23744924e-02f, 1.15287334e-01f, 6.40236586e-02f, 1.64134398e-01f,
  1.16779856e-01f, -2.64261365e-01f, 1.08123161e-01f, -2.58955151e-01f, 1.49293104e-02f, -3.14426124e-02f, -5.22657149e-02f, -1.17078638e-02f, 8.57458487e-02f, 1.07071988e-01f,
  -1.08984224e-02f, 1.21309765e-01f, -9.54071656e-02f, 6.23919666e-02f, -1.86112583e-01f, 2.88000982e-02f, -9.71890986e-02f, 1.62438631e-01f, -1.29759476e-01f, -7.67336711e-02f,
  6.46775588e-02f, 4.98553887e-02f, -1.10845841e-01f, 2.14012295e-01f, 1.26111507e-02f, 1.03726804e-01f, -8.66131335e-02f, -9.41536352e-02f, 1.43007472e-01f, 4.77247536e-02f,
  1.65961742e-01f, 1.73649326e-01f, 2.47115120e-01f, -1.12435386e-01f, 4.48386557e-03f, -3.48014720e-02f, 1.11389257e-01f, 5.49704432e-02f, -1.20110080e-01f, 6.44867569e-02f,
  -4.72368486e-02f, 1.27454668e-01f, -1.12653315e-01f, 1.40088201e-01f, 1.83569357e-01f, 2.36822098e-01f, -2.42101312e-01f, 1.67044625e-01f, -8.58797505e-02f, -6.15296653e-03f,
  -2.28460301e-02f, -2.00087428e-01f, 1.23455636e-01f, -1.28189236e-01f, 8.86539295e-02f, 2.14183912e-01f, 2.39179611e-01f, -1.64498948e-02f, 4.39507924e-02f, -1.22979559e-01f,
  2.25492060e-01f, 2.11633399e-01f, -2.53071748e-02f, 6.35306090e-02f, -1.46351159e-01f, -1.64082482e-01f, 9.31272954e-02f, -1.27764910e-01f, 7.71785481e-03f, 1.42544135e-01f,
  -5.27564855e-03f, -1.40498832e-01f, -1.74220085e-01f, 3.47929299e-02f, 3.63375768e-02f, 1.17874399e-01f, 1.56977922e-01f, 1.42022729e-01f, 1.30472675e-01f, -2.34322593e-01f,
  1.26825929e-01f, 1.42837405e-01f, -1.82484183e-02f, 2.20100597e-01f, 8.81884769e-02f, -1.62554935e-01f, -7.89729971e-03f, -3.74135538e-03f, 5.28988838e-02f, -2.56663840e-02f,
  -8.27122778e-02f, 1.31624877e-01f, -1.94580123e-01f, 3.71625304e-01f, -9.64109302e-02f, 6.12781867e-02f, 9.23602358e-02f, -2.28780210e-01f, 1.99262947e-02f, -2.95069441e-03f,
  4.93834168e-02f, -1.85310710e-02f, -1.32419571e-01f, 1.39006242e-01f, 8.25415924e-02f, 2.83616725e-02f, 1.70271978e-01f, 2.26299446e-02f, 1.95230111e-01f, 1.52308688e-01f,
  -1.40043467e-01f, 2.29422763e-01f, -5.13155572e-03f, 3.78655456e-02f, 5.76033406e-02f, 5.08053117e-02f, 1.55547606e-02f, 9.34504438e-03f, -1.49730250e-01f, -1.28751785e-01f,
  1.83549188e-02f, -1.14137761e-01f, 1.51003301e-01f, 8.58512223e-02f, 2.11641639e-01f, -2.03320280e-01f, -1.63282435e-02f, -1.44918263e-01f, -1.00253820e-01f, 7.64845386e-02f,
  3.57455052e-02f, 1.96729064e-01f, 1.06458806e-01f, 1.89858735e-01f, 7.09536672e-02f, -5.83132505e-02f, -1.94022998e-01f, 6.82679638e-02f, 3.73985507e-02f, 4.07359190e-02f,
  1.44585356e-01f, 2.19637796e-01f, -1.44560322e-01f, -2.54101396e-01f, 2.13829577e-02f, 1.67605653e-01f, -1.70822576e-01f, 6.91760480e-02f, -8.86112675e-02f, -1.01568401e-01f,
  1.02041431e-01f, -5.37129641e-02f, 1.82382539e-01f, 5.35275526e-02f, -1.34048596e-01f, 1.90465942e-01f, -1.58917985e-03f, 5.73570468e-02f, -2.43662819e-01f, -1.53311387e-01f,
  2.98131645e-01f, -2.06007913e-01f, -1.99787878e-02f, -2.46421415e-02f, 3.33730243e-02f, -3.02185360e-02f, -1.15875319e-01f, -1.58622069e-03f, -1.38179973e-01f, 2.65242942e-02f,
  1.09480448e-01f, 2.35449951e-02f, -2.15235502e-02f, 1.13107070e-01f, 7.77256712e-02f, -5.98160923e-02f, 3.03821471e-02f, -2.30098721e-02f, -5.04829586e-02f, 2.22004592e-01f,
  4.94720079e-02f, -4.14439291e-03f, 5.52957542e-02f, 4.56609987e-02f, 1.26891091e-01f, -1.15107626e-01f, -6.72697425e-02f, 1.22151554e-01f, -1.03738151e-01f, -4.48374413e-02f,
  1.15279563e-01f, -6.70549497e-02f, -2.19999745e-01f, 3.13089877e-01f, 4.72519025e-02f, 1.83627203e-01f, -3.89605835e-02f, -4.89846841e-02f, 9.23884436e-02f, 9.02232826e-02f,
  1.91097572e-01f, -4.13475744e-02f, 7.82357827e-02f, -1.05400100e-01f, -5.31053692e-02f, -9.99455750e-02f, -9.29604620e-02f, 1.70587331e-01f, -1.89717963e-01f, -1.92593876e-02f,
  -8.83989129e-03f, -1.08406633e-01f, 4.62504253e-02f, 1.84873059e-01f, 7.82003161e-03f, -1.86353177e-02f, -2.64852136e-01f, 1.42251268e-01f, 2.34962944e-02f, -5.56212962e-02f,
  1.00724392e-01f, -1.76904187e-01f, 1.23230077e-01f, 3.04257516e-02f, 2.35715602e-02f, -1.43775716e-01f, 2.26399839e-01f, -9.09313709e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  2.38946721e-01f, 3.70187879e-01f, -1.77439943e-01f, 1.31640211e-01f, 1.44198656e-01f, 1.29847959e-01f, -1.34452343e-01f, 1.90973461e-01f, 2.97720999e-01f, 6.60998762e-01f,
  -2.63058931e-01f, 1.54984325e-01f, -6.30181357e-02f, 5.41120827e-01f, -4.29151386e-01f, -2.34167710e-01f, -1.48842618e-01f, 2.75922902e-02f, -4.26044941e-01f, -1.04478478e-01f,
  3.66984040e-01f, 3.16364840e-02f, 2.35878617e-01f, 2.45550409e-01f, 4.31550473e-01f, 4.20020193e-01f, -3.73124570e-01f, -2.32030660e-01f, 2.54077107e-01f, -1.59138456e-01f,
  -2.85740256e-01f, 3.78004014e-02f, 4.40556444e-02f, -2.67412752e-01f, -4.55576368e-02f, -6.57851249e-02f, -2.64472961e-02f, 8.66225213e-02f, -3.19312721e-01f, -2.80169070e-01f,
  -1.34266704e-01f, -3.51134151e-01f, -1.91416770e-01f, -8.39208215e-02f, -5.65791354e-02f, -6.03006706e-02f, -2.53350288e-02f, -2.04005510e-01f, -1.47950128e-02f, 7.79545531e-02f,
  1.70270905e-01f, 2.59599835e-01f, -3.07932347e-01f, 2.67158955e-01f, 4.84305799e-01f, -3.29568952e-01f, 1.24717705e-01f, -3.36198717e-01f, 3.75687510e-01f, 1.78949192e-01f,
  1.66025236e-01f, -3.27302843e-01f, 6.64956309e-03f, -4.00416136e-01f, -3.05700094e-01f, -1.54873699e-01f, 9.40878168e-02f, -1.76150903e-01f, 1.07818447e-01f, -3.11166793e-01f,
  8.68198201e-02f, -1.54603601e-01f, -7.24259466e-02f, 4.79685739e-02f, 4.19358462e-01f, -5.72503060e-02f, 3.46973062e-01f, 4.57500815e-02f, -1.61132566e-03f, -1.03788055e-03f,
  -1.08956017e-01f, -4.16367382e-01f, 4.12172496e-01f, 3.61148268e-01f, 1.63008332e-01f, 6.60330243e-03f, 7.80706882e-01f, -2.10681289e-01f, 3.41403067e-01f, 2.89883286e-01f,
  -8.84264559e-02f, -1.62524313e-01f, 2.42525175e-01f, 5.39456248e-01f, -2.24294230e-01f, 2.53300279e-01f, 8.13186634e-03f, 2.49941170e-01f, 1.09538492e-02f, -9.79660228e-02f,
  -8.43713954e-02f, -1.25999842e-02f, 8.76522213e-02f, -3.33665051e-02f, 1.53850064e-01f, 2.07854837e-01f, -6.53459167e-04f, 2.29576379e-02f, 2.92489946e-01f, 8.00022259e-02f,
  -3.15284669e-01f, -1.91430286e-01f, 4.97228950e-02f, 5.79127017e-03f, 2.03980416e-01f, 3.29999506e-01f, 3.59157622e-01f, -1.02635093e-01f, 2.24722013e-01f, -2.36805186e-01f,
  5.29827625e-02f, 4.19818550e-01f, -2.22217262e-01f, -1.45852193e-01f, 1.33453056e-01f, -5.37789524e-01f, -2.43132263e-01f, -5.69282115e-01f, -8.70369226e-02f, -3.44284698e-02f,
  1.53791919e-01f, 1.61115099e-02f, -7.99597129e-02f, -6.62907511e-02f, -6.10104278e-02f, 2.25125641e-01f, 6.38249218e-02f, 2.58211922e-02f, 9.94826704e-02f, 6.24085516e-02f,
  -3.23042832e-02f, 3.47314216e-02f, -2.09461346e-01f, -1.24391608e-01f, 2.07135752e-01f, -1.44407731e-02f, -2.30649963e-01f, 6.60697341e-01f, -8.83374587e-02f, 3.54996800e-01f,
  -4.07077044e-01f, -2.14944735e-01f, 5.43662300e-03f, 1.98862985e-01f, -3.59003916e-02f, 5.90628088e-01f, 2.12602884e-01f, -3.43536027e-02f, 2.21649915e-01f, -3.61456186e-01f,
  -7.64507130e-02f, 9.83097479e-02f, -2.61518024e-02f, 1.66951999e-01f, -3.43679376e-02f, -6.29337877e-02f, 2.58221524e-03f, 5.82044423e-02f, 9.82298926e-02f, 3.13464433e-01f,
  7.30073377e-02f, 1.93123251e-01f, 2.95069695e-01f, 1.03236184e-01f, -3.64334702e-01f, -1.50339156e-01f, -1.16353855e-01f, -7.02326521e-02f, 1.52769238e-01f, 2.38861009e-01f,
  1.67452410e-01f, -2.30997637e-01f, 2.85997421e-01f, -2.60975182e-01f, 3.75710517e-01f, 3.80135953e-01f, -4.56935257e-01f, -2.58753002e-01f, 3.38888019e-01f, 1.34513617e-01f,
  -3.26310962e-01f, -1.38830677e-01f, -6.30254224e-02f, -1.48282424e-01f, 1.73508361e-01f, 1.25733420e-01f, 3.06474090e-01f, -1.87351122e-01f, 2.18029052e-01f, 2.84203440e-01f,
  2.46055517e-02f, 2.33445857e-02f, 2.34372199e-01f, 4.92254674e-01f, -6.87846839e-02f, 1.75479904e-01f, 2.19170079e-02f, -3.42494845e-02f, 2.81479359e-01f, -4.73786294e-01f,
  -1.85746104e-01f, 6.46261930e-01f, 2.58923322e-01f, 2.27275625e-01f, -4.48375791e-01f, -2.61201233e-01f, 2.51594365e-01f, 1.65648654e-01f, -3.25994492e-01f, 3.79423529e-01f,
  3.53788763e-01f, 1.71198383e-01f, -6.21510856e-02f, -1.22379586e-01f, -4.15836880e-03f, 1.24777578e-01f, -1.27033815e-01f, 2.77035952e-01f, 5.66872954e-02f, 2.29397342e-01f,
  7.99113326e-03f, 1.11020289e-01f, -3.41841392e-02f, 3.37926038e-02f, -3.17417771e-01f, 1.66064829e-01f, -1.97689980e-01f, 2.11577252e-01f, -1.70704976e-01f, -2.55306512e-01f,
  -2.84343362e-01f, 5.44818997e-01f, -6.91951141e-02f, -1.78247556e-01f, -5.50506949e-01f, 4.47629690e-01f, 3.85630190e-01f, -3.41079950e-01f, 5.49388885e-01f, -3.16838354e-01f,
  4.38217372e-01f, 1.57858729e-01f, 1.84870541e-01f, 2.78788894e-01f, 1.26981109e-01f, 4.30864066e-01f, 7.09867291e-03f, 1.63309321e-01f, 2.37643376e-01f, -1.53823778e-01f,
  -3.50084603e-02f, -6.95099309e-02f, 2.94400066e-01f, 1.06459334e-01f, 6.49804398e-02f, -4.43975404e-02f, 1.77906618e-01f, -1.85045004e-01f, -1.37569696e-01f, -2.88785487e-01f,
  4.14588153e-01f, 5.20967662e-01f, -2.99271569e-02f, 1.13641933e-01f, 2.55616158e-01f, -4.55921203e-01f, 2.28843898e-01f, -9.11354646e-02f, 1.47990212e-01f, 4.35243309e-01f,
  -2.93507099e-01f, -3.32528427e-02f, 4.20331210e-01f, -7.77738392e-02f, 2.06828132e-01f, 2.79861808e-01f, 5.41730344e-01f, 2.54918158e-01f, -7.63237998e-02f, 6.62200302e-02f,
  2.14906469e-01f, 3.06812990e-02f, 1.75535604e-01f, -7.41086915e-05f, 2.11452216e-01f, 1.05871931e-01f, 2.21687537e-02f, 2.30774924e-01f, 4.21620905e-01f, 1.40995771e-01f,
  1.32300004e-01f, -1.47671118e-01f, 2.64945805e-01f, 2.11293951e-01f, -7.13340566e-02f, -3.00899416e-01f, 4.07885909e-01f, -1.78427681e-01f, 4.91323769e-01f, -2.34383062e-01f,
  4.71627325e-01f, 1.36424944e-01f, 1.62415132e-02f, 4.17873204e-01f, -1.32273108e-01f, -2.32344195e-01f, -9.35204774e-02f, 6.08499467e-01f, 2.61853546e-01f, 3.57043982e-01f,
  2.06016116e-02f, -2.16707494e-02f, -1.26279920e-01f, -1.26867602e-02f, -2.69551098e-01f, -2.04697791e-02f, -1.70861393e-01f, 9.57738236e-03f, -1.81801006e-01f, -7.48477727e-02f,
  -4.28712368e-03f, -2.47408167e-01f, 1.31278321e-01f, -2.44347870e-01f, -8.58621020e-03f, 6.57230616e-02f, -2.77367998e-02f, 5.91685018e-03f, 3.31493109e-01f, -2.64504045e-01f,
  2.79370278e-01f, -4.37301904e-01f, -1.27719432e-01f, 2.83723027e-01f, -3.70676011e-01f, 3.03947598e-01f, -1.98491991e-01f, -2.05204770e-01f, -1.98151723e-01f, 7.48116449e-02f,
  2.17130408e-01f, -2.38889620e-01f, 4.96106371e-02f, 3.67010273e-02f, 4.78630066e-02f, 4.71103452e-02f, 1.01880871e-01f, 7.46178627e-02f, 4.51952778e-02f, 2.06914797e-01f,
  4.90884148e-02f, 1.69173241e-01f, -1.79801732e-01f, -8.53707194e-02f, -3.12409759e-01f, 2.97178686e-01f, 2.92896118e-04f, -1.39789679e-03f, -3.22237834e-02f, 4.30374801e-01f,
  -4.02375042e-01f, 3.88204157e-02f, -3.88005257e-01f, 4.09638822e-01f, 1.03118449e-01f, 1.92515496e-02f, 2.14614481e-01f, -2.54456788e-01f, 3.54141533e-01f, 3.60374272e-01f,
  2.32160926e-01f, 3.84420417e-02f, 3.45560044e-01f, 3.86436909e-01f, -1.68064103e-01f, -1.46538153e-01f, 5.97648136e-02f, -2.11449251e-01f, 2.63340056e-01f, -1.87677965e-01f,
  2.56614774e-01f, -2.86913365e-01f, 6.82846829e-02f, -2.25145847e-01f, 1.60162002e-01f, -1.54689193e-01f, -1.23764813e-01f, 2.07252175e-01f, 4.21195507e-01f, 3.47344190e-01f,
  -1.69529185e-01f, -6.45967126e-02f, -1.73033923e-01f, -1.47070780e-01f, -9.16089788e-02f, 2.97181875e-01f, 4.74153429e-01f, 1.71914864e-02f, -4.78316844e-02f, -3.37610431e-02f,
  2.38080889e-01f, 2.90327668e-02f, 2.14679614e-01f, -7.35551491e-02f, 9.82347280e-02f, 3.06997865e-01f, 2.16792047e-01f, 1.21186793e-01f, 2.10655034e-01f, -1.48792326e-01f,
  -1.20429315e-01f, 5.59797585e-02f, -3.22127074e-01f, -3.26251313e-02f, -1.62558183e-01f, -2.40010425e-01f, -1.93313569e-01f, -3.65766823e-01f, -2.24206328e-01f, 1.00228973e-02f,
  3.02616745e-01f, 1.99681595e-01f, 3.13479334e-01f, -1.95383191e-01f, 1.65511608e-01f, 9.68321860e-02f, 2.79174536e-01f, 3.66639256e-01f, -9.55764726e-02f, 6.35052919e-01f,
  -2.03973442e-01f, 1.69265360e-01f, 1.19690932e-01f, 6.38709545e-01f, 2.75265127e-01f, -1.80894047e-01f, 5.96843302e-01f, -4.09413278e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  3.43294799e-01f, 4.74575050e-02f, -1.10339157e-01f, 2.62042042e-02f, 7.87198246e-02f, 9.58013311e-02f, 3.12598087e-02f, 3.35062474e-01f, 1.30290091e-01f, 9.01479721e-02f,
  5.20500168e-02f, 1.79182902e-01f, -6.67335093e-02f, 1.55617237e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -2.75953203e-01f, -8.72099027e-02f, 1.91223264e-01f, -5.83101623e-03f, -3.16304892e-01f, -7.58699775e-02f, -1.80251263e-02f, -1.11621566e-01f, -4.87472452e-02f, 1.30350500e-01f,
  -2.46038869e-01f, -1.85770616e-01f, -3.15578789e-01f, -2.49673873e-01f, 4.37747426e-02f, -3.81145358e-01f, 2.36674234e-01f, 2.86006838e-01f, -4.48722154e-01f, -3.11639905e-01f,
  -1.08251691e-01f, -8.87107775e-02f, -3.42456073e-01f, -3.41783464e-01f, -3.54604274e-01f, 2.61125267e-01f, 4.59572643e-01f, 2.42049977e-01f, -1.93301916e-01f, 1.42504364e-01f,
  1.22123629e-01f, -3.44811976e-01f, 2.36055791e-01f, 4.38604951e-01f, 2.82289505e-01f, 3.69566739e-01f, -2.02578217e-01f, -2.62649775e-01f, 2.16238230e-01f, 2.66253173e-01f,
  -1.94562167e-01f, 2.66351491e-01f, -2.66305804e-01f, 2.43356809e-01f, 3.15856487e-01f, 1.49070755e-01f, 7.40937144e-02f, -1.19220205e-01f, -1.42944604e-01f, 1.53619200e-01f,
  4.77072924e-01f, 1.00101396e-01f, 4.50899713e-02f, -4.16200638e-01f, -4.74358916e-01f, -1.91133022e-02f, -4.17644590e-01f, 4.91246641e-01f, -5.63170969e-01f, -2.03372926e-01f,
  9.15932655e-03f, 2.25747481e-01f, -1.51079206e-03f, -4.77749705e-01f, -1.10484902e-02f, -2.68473178e-01f, -1.08521335e-01f, 5.48577420e-02f, -2.49294162e-01f, 1.06230736e-01f,
  -7.77818039e-02f, -2.11826012e-01f, 2.48413786e-01f, -2.37182140e-01f, 2.05612347e-01f, 5.29610664e-02f, -1.51018366e-01f, -6.95015639e-02f, 1.24951884e-01f, -2.92046577e-01f,
  -2.49328420e-01f, -8.07853639e-02f, -5.00468075e-01f, 4.79332805e-01f, 2.18815207e-01f, -1.72351390e-01f, -2.01987997e-01f, -4.17044997e-01f, -3.12829226e-01f, 2.06443429e-01f,
  -1.19089358e-01f, -4.88416880e-01f, 1.13026358e-01f, -1.07935080e-02f, 3.39346766e-01f, 5.08321524e-02f, -1.65851519e-01f, -2.28498548e-01f, -3.00037749e-02f, 4.59372252e-02f,
  1.17244497e-02f, -2.94850450e-02f, 3.87926400e-02f, 7.37504959e-02f, -1.36126444e-01f, -3.05663437e-01f, -3.60181332e-01f, 2.22743973e-01f, 4.75548133e-02f, 2.32205749e-01f,
  2.15250582e-01f, 1.41926974e-01f, -1.65996477e-02f, -9.25668925e-02f, -2.48374015e-01f, 1.81649122e-02f, 2.48601452e-01f, -7.60077611e-02f, -1.79849491e-01f, 8.35107788e-02f,
  -4.97191608e-01f, -4.79783982e-01f, 1.31345257e-01f, 3.59775484e-01f, 4.79708880e-01f, -3.20821047e-01f, -3.61487478e-01f, -1.07537553e-01f, 1.94166481e-01f, 2.90769637e-01f,
  2.78277606e-01f, 2.05563262e-01f, 4.78439406e-02f, 1.60835162e-02f, 7.23739341e-02f, 1.14308387e-01f, 2.61437029e-01f, 1.23374343e-01f, 2.14620262e-01f, -6.24430627e-02f,
  -5.06081544e-02f, 2.50958562e-01f, 5.48821241e-02f, 9.00890604e-02f, 4.09880310e-01f, 1.14779845e-01f, 7.29787424e-02f, -4.05271977e-01f, 1.39993861e-01f, -1.88435912e-01f,
  6.49261400e-02f, -2.63621062e-01f, 2.15612680e-01f, -4.97155070e-01f, -2.60400157e-02f, 1.42389223e-01f, -2.53820777e-01f, 4.52509783e-02f, 2.60558724e-01f, 3.43342334e-01f,
  2.12994725e-01f, 3.76218818e-02f, -2.40031287e-01f, -2.43075415e-01f, 3.75960588e-01f, 4.01505321e-01f, 7.58066922e-02f, -1.39250681e-01f, -3.06213647e-01f, -2.86324799e-01f,
  2.14606121e-01f, 5.40673081e-03f, -3.71064991e-02f, -1.02755189e-01f, 1.67234480e-01f, 3.00220191e-01f, -2.00898573e-01f, 1.72114611e-01f, 3.13330412e-01f, -1.03992924e-01f,
  -1.78363740e-01f, 5.72085530e-02f, 2.93106407e-01f, 2.61276901e-01f, 3.24498147e-01f, 1.31473005e-01f, -3.49663526e-01f, -6.40627742e-01f, 5.12358434e-02f, 1.61176845e-01f,
  -2.47768804e-01f, -1.65218934e-01f, 7.12127835e-02f, 2.26440262e-02f, -5.64993173e-02f, 1.79559246e-01f, -1.17776163e-01f, -2.40554005e-01f, 1.48434699e-01f, -5.62348701e-02f,
  8.76579657e-02f, 5.95876426e-02f, -4.84856069e-02f, -3.48768458e-02f, 1.79253295e-01f, -2.28336856e-01f, -2.19640225e-01f, -3.86989951e-01f, -7.13456348e-02f, -1.10114433e-01f,
  -4.39447403e-01f, 3.76439571e-01f, -5.10974467e-01f, -5.49661279e-01f, 4.22473520e-01f, -4.94884044e-01f, 3.05735797e-01f, 1.53829843e-01f, -7.07531750e-01f, -2.90538132e-01f,
  -6.84161708e-02f, 9.20527130e-02f, -3.23613852e-01f, 2.21816361e-01f, -8.27578083e-02f, -4.68410365e-02f, 1.86926834e-02f, -1.06674200e-02f, 2.44462211e-02f, 2.82991767e-01f,
  -2.08313927e-01f, -9.93760154e-02f, 2.92443722e-01f, 1.50159195e-01f, 2.83371270e-01f, -3.63919884e-01f, 1.76346481e-01f, 2.01068342e-01f, 1.69243872e-01f, 1.44535512e-01f,
  3.11822534e-01f, -2.01958075e-01f, 7.45809004e-02f, -1.84250399e-02f, -7.38117814e-01f, -1.29739180e-01f, -2.71285146e-01f, -2.57020295e-01f, -1.00258529e-01f, -2.21114039e-01f,
  1.91216379e-01f, 1.18288755e-01f, 3.76939625e-01f, -4.71005857e-01f, -3.03271800e-01f, 4.89460588e-01f, -1.05254635e-01f, -1.12698950e-01f, 4.19540629e-02f, -9.99759659e-02f,
  3.51292640e-02f, 2.79429313e-02f, -1.14678897e-01f, -1.99311525e-01f, 5.84911034e-02f, -2.44384229e-01f, -9.26694646e-02f, -2.61302684e-02f, -2.11927325e-01f, -1.41040698e-01f,
  1.89361751e-01f, 1.28357336e-01f, -1.63390964e-01f, -2.62952386e-03f, 1.74562767e-01f, 2.91336894e-01f, 2.65799731e-01f, 5.20877600e-01f, -4.06200171e-01f, 2.60111660e-01f,
  -4.38453883e-01f, -1.89700529e-01f, -3.48778009e-01f, -1.20155431e-01f, -1.12104863e-01f, -3.71958375e-01f, 7.68195018e-02f, 4.00158903e-03f, -3.08641046e-01f, -2.04783931e-01f,
  -1.19011410e-01f, -2.66553700e-01f, 3.09761256e-01f, 9.96939242e-02f, 6.48302734e-02f, 1.19196907e-01f, -2.31181785e-01f, 1.12290837e-01f, 2.59508163e-01f, 1.07227996e-01f,
  -1.20599918e-01f, 3.78177136e-01f, -3.98261845e-01f, 3.61053735e-01f, 2.31787175e-01f, 1.34549901e-01f, -4.11070555e-01f, -7.52228796e-02f, -7.16983438e-01f, -6.15931721e-03f,
  7.94134140e-02f, -1.61940351e-01f, -2.85863042e-01f, 1.14346981e-01f, 1.92808777e-01f, -5.23117840e-01f, -8.19708630e-02f, 2.04391494e-01f, 2.53238410e-01f, 2.92082429e-01f,
  2.36631215e-01f, 5.26038222e-02f, -2.41223305e-01f, -8.57903212e-02f, -1.81285784e-01f, -2.29524091e-01f, 1.43990204e-01f, 4.77366149e-02f, 2.23295450e-01f, 1.36996821e-01f,
  -2.96514511e-01f, -2.90934205e-01f, 7.62749091e-02f, -1.98264107e-01f, -2.82396246e-02f, -3.56298894e-01f, 2.85716325e-01f, -3.24382991e-01f, -1.30897403e-01f, -3.04522336e-01f,
  4.58778054e-01f, -1.89557761e-01f, -3.15404594e-01f, 2.22301543e-01f, 3.53977114e-01f, -2.28068739e-01f, -1.35407031e-01f, 3.51200908e-01f, -3.16838145e-01f, -5.22971869e-01f,
  9.59401429e-02f, -6.93674862e-01f, 6.33487552e-02f, -1.11044504e-01f, -1.26986340e-01f, -1.12105265e-01f, -5.17169945e-03f, -1.78721592e-01f, -9.54200141e-03f, 9.22967270e-02f,
  2.22362936e-01f, -1.33481026e-01f, 3.91796231e-02f, 2.43335888e-01f, -1.58104710e-02f, 1.80460498e-01f, -2.91240424e-01f, -5.37892431e-02f, -2.00158536e-01f, -2.78488368e-01f,
  2.46818960e-01f, -4.43212360e-01f, 2.03200966e-01f, 4.79088008e-01f, 2.54680574e-01f, 1.92229986e-01f, 3.07362944e-01f, -7.19163001e-01f, -3.87391329e-01f, -6.64591268e-02f,
  8.65197256e-02f, -5.82027495e-01f, -5.76640368e-01f, -2.14647830e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  9.65013653e-02f, 2.80849099e-01f, -4.66889665e-02f, 4.26204987e-02f, 1.39323741e-01f, -1.22534491e-01f, -8.96610618e-02f, 1.80496454e-01f, -1.30300999e-01f, 1.81064885e-02f,
  2.13284697e-02f, -1.12054236e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    