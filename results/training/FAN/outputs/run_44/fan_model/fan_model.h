/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.30124331e-01f, -3.26621771e-01f, -3.81808169e-02f, 3.67761590e-02f, 2.21404620e-02f, 9.92812030e-03f, -8.04844126e-03f, -4.81974185e-02f, 1.23429475e-02f, -2.24693447e-01f,
  -1.38450386e-02f, 9.01018158e-02f, -6.88276440e-02f, 1.08382493e-01f, 6.08319163e-01f, 8.47051740e-02f, 2.28255272e-01f, 5.40073030e-03f, 1.50011122e-01f, -1.93316806e-02f,
  7.36186206e-02f, 2.25416109e-01f, 2.13183686e-01f, 8.85917470e-02f, -7.37233311e-02f, -8.59120414e-02f, 5.68044819e-02f, 2.70437449e-02f, -5.04406318e-02f, 1.65066004e-01f,
  1.12300925e-02f, -8.35489556e-02f, -7.40677267e-02f, -1.91025622e-02f, 1.02296984e-02f, -1.01729907e-01f, -7.18999207e-02f, 1.25723295e-02f, 5.54612763e-02f, 3.40882279e-02f,
  1.65975757e-03f, 4.73071821e-02f, 5.05205654e-02f, 2.73280479e-02f, -9.81175825e-02f, 1.23668863e-02f, 8.73292703e-03f, -1.77669153e-02f, 3.52339596e-02f, 1.54239535e-02f,
  3.10874246e-02f, 2.06120033e-02f, -6.71843858e-03f, -4.84557636e-03f, 1.73055343e-02f, -3.30215544e-02f, -5.86716048e-02f, 1.56606138e-02f, -2.90140305e-02f, -9.29473259e-04f,
  1.73469111e-02f, 1.57346651e-02f, -1.23206610e-02f, 7.89356139e-03f, -3.23474556e-02f, 6.39725700e-02f, 1.65392105e-02f, -3.38361748e-02f, 4.00163308e-02f, -3.11764944e-02f,
  1.46132810e-02f, -2.52034818e-03f, 1.26478476e-02f, 2.01066490e-02f, -6.16076402e-02f, 1.09220417e-02f, 4.94590141e-02f, -3.30572529e-03f, -1.85261108e-02f, -6.93510694e-04f,
  3.57134119e-02f, 3.57156582e-02f, 1.76817458e-02f, -2.32264046e-02f, 5.04639558e-02f, -1.11680245e-02f, 9.07501113e-03f, -8.91460665e-03f, 1.77501943e-02f, 5.19274585e-02f,
  -9.75163281e-02f, -1.28478687e-02f, -1.40676936e-02f, 5.52208461e-02f, -6.38145721e-03f, 2.05748365e-03f, 1.04408294e-01f, 2.04432290e-02f, 5.53608090e-02f, 2.02750955e-02f,
  -1.33493639e-04f, -1.10000353e-02f, -4.59703393e-02f, 1.54590067e-02f, 5.53096049e-02f, -6.23250194e-03f, 2.99832039e-02f, -1.68647710e-02f, -5.56853600e-03f, -2.73354165e-02f,
  -9.76249278e-02f, -3.45132314e-02f, 5.31866029e-02f, -1.93366334e-02f, -2.02192031e-02f, -1.33044915e-02f, 4.64079566e-02f, -4.63134870e-02f, 6.08995967e-02f, -1.28363268e-02f,
  3.83566618e-01f, -2.37355614e-03f, 9.43186358e-02f, -4.85660471e-02f, 1.99587107e-01f, -1.61680877e-01f, -3.62788528e-01f, 1.05282649e-01f, -1.50116280e-01f, -3.16626281e-01f,
  -2.06253052e-01f, -9.65413973e-02f, -1.83051646e-01f, -3.14621806e-01f, 1.45475660e-02f, -2.68090934e-01f, -1.77526265e-01f, -1.43708393e-01f, 9.70300734e-02f, 7.20143020e-02f,
  6.36446550e-02f, -2.60630865e-02f, -7.43648484e-02f, 2.09328488e-01f, 5.08373743e-03f, 2.81157017e-01f, 2.15693582e-02f, 3.28393094e-02f, 5.80392368e-02f, -4.56227846e-02f,
  1.06847309e-01f, -2.24985159e-03f, 8.62045884e-02f, -2.87010875e-02f, 3.77776176e-02f, 1.95406415e-02f, 6.56237965e-03f, -2.50620930e-03f, 8.64764303e-03f, 2.09554397e-02f,
  1.31030828e-02f, 9.09959003e-02f, 4.30702791e-02f, -5.37260436e-02f, 1.26521423e-01f, 6.48976341e-02f, 5.66581637e-03f, -1.06674032e-02f, 3.34833376e-02f, 3.19104968e-03f,
  -6.60082474e-02f, -7.19793960e-02f, -9.93191525e-02f, -6.53761998e-02f, 2.58834660e-02f, -1.27267651e-02f, 2.17495859e-02f, 4.74842871e-03f, 4.11069281e-02f, 1.64864771e-02f,
  4.33068350e-02f, -4.86451648e-02f, -5.16283065e-02f, -6.51074527e-03f, 2.40866654e-02f, -6.48436509e-03f, 8.61584302e-03f, -1.63920317e-02f, -3.21523077e-03f, 1.36833871e-02f,
  1.18303094e-02f, 3.63955013e-02f, -4.80682217e-02f, -8.35967362e-02f, -2.15365961e-02f, -3.01445089e-02f, 1.89744532e-02f, -1.80654526e-02f, -7.03109950e-02f, 6.49599545e-03f,
  -1.07913010e-01f, 2.52321400e-02f, -7.30341375e-02f, -2.41294838e-02f, 1.57726277e-02f, -8.33327919e-02f, -9.08158869e-02f, 2.45301053e-03f, -3.09780426e-02f, 7.55779911e-03f,
  1.18808813e-01f, 1.54106677e-01f, -3.56486998e-02f, -2.81367749e-02f, 3.27264480e-02f, -2.02661008e-02f, -3.91684063e-02f, -5.50512737e-03f, 4.67141941e-02f, 8.31570998e-02f,
  -4.32634652e-02f, -5.04193362e-03f, 2.33987700e-02f, 8.34427681e-03f, -1.82255022e-02f, -3.96026634e-02f, 7.25071738e-03f, -2.28420505e-03f, -3.79262976e-02f, 7.80541822e-02f,
  2.55830344e-02f, 7.74868578e-02f, 2.15955153e-02f, 2.52629574e-02f, -3.15518305e-02f, 2.00094730e-02f, 1.68557912e-02f, -2.94505209e-02f, 7.27318302e-02f, -5.69266565e-02f,
  -2.85230994e-01f, -1.82195082e-01f, -3.62533450e-01f, 2.28428423e-01f, 1.02077000e-01f, 2.85992563e-01f, 2.03298062e-01f, 6.77341148e-02f, 9.99193192e-02f, 1.49650395e-01f,
  1.96056947e-01f, -1.60371527e-01f, 4.28798124e-02f, 4.57583874e-01f, 1.58150256e-01f, 2.21459076e-01f, 2.68246323e-01f, 1.22851536e-01f, 3.70785631e-02f, -7.92319626e-02f,
  1.10893250e-01f, 2.42854983e-01f, 1.91116214e-01f, 7.21378028e-02f, 2.29049958e-02f, -1.17631986e-04f, -4.56851069e-03f, -1.99182525e-01f, 6.55519068e-02f, 1.34745091e-01f,
  1.84210371e-02f, -1.09602354e-01f, -2.48401985e-02f, -2.41047684e-02f, 3.41474116e-02f, 4.36945185e-02f, -4.89252396e-02f, -5.70054054e-02f, 1.78049561e-02f, 2.48937644e-02f,
  -1.12707905e-01f, 1.75938767e-05f, 2.00628601e-02f, -1.81564558e-02f, -2.98653170e-03f, 3.05909477e-02f, -7.33290846e-03f, -7.54118804e-03f, 7.29662701e-02f, -2.68772431e-02f,
  9.86778643e-03f, 2.60349712e-03f, -7.23042041e-02f, 6.76099285e-02f, -3.14576030e-02f, 2.43502781e-02f, 4.49044593e-02f, -7.15949684e-02f, 7.52356350e-02f, 1.74333341e-02f,
  6.71621691e-03f, -5.72588556e-02f, -1.60324003e-03f, 7.62898549e-02f, 3.95273138e-03f, 2.41802745e-02f, 3.34233837e-03f, 7.61667863e-02f, -1.06429271e-01f, 2.40671262e-02f,
  8.68615787e-03f, -9.37850475e-02f, 1.22465901e-02f, -1.83257170e-03f, -5.66343628e-02f, 1.43082226e-02f, -7.70439431e-02f, -3.38443182e-02f, 1.62222646e-02f, 7.70428479e-02f,
  -6.11910271e-03f, -3.21491361e-02f, -6.78354129e-02f, -1.55816106e-02f, 1.51607543e-02f, 2.65692603e-02f, -6.79246150e-03f, 9.10244184e-04f, -1.06216557e-02f, -4.39695790e-02f,
  -1.92115948e-01f, -3.51783574e-01f, 6.40573129e-02f, 4.67414632e-02f, -6.94933832e-02f, 6.58154534e-03f, -2.70470884e-02f, 3.18263881e-02f, -5.73495030e-02f, 3.50104608e-02f,
  -1.18988834e-03f, 7.43064703e-03f, 1.30211823e-02f, 4.15646844e-02f, -2.64831446e-02f, 3.16070975e-03f, -3.54957990e-02f, -5.49982162e-03f, -1.28358966e-02f, -2.24633180e-02f,
  -6.51492253e-02f, -4.37770002e-02f, 1.65764317e-02f, 5.95159782e-03f, -8.13779980e-03f, -2.86146030e-02f, -4.00787964e-02f, 1.60891109e-03f, 3.01089790e-03f, 8.24201759e-03f,
  2.46174932e-02f, 3.15228045e-01f, 1.77247841e-02f, 1.34972870e-01f, 4.32143882e-02f, -4.82317954e-01f, -4.24231946e-01f, 1.32314354e-01f, -2.48042252e-02f, -1.97794903e-02f,
  -6.62446171e-02f, 2.02945024e-01f, -9.54716131e-02f, 8.58122781e-02f, -3.92799318e-01f, -2.92264909e-01f, -2.33460236e-02f, 5.97512200e-02f, 6.49965107e-02f, 4.65005189e-02f,
  -5.35396226e-02f, -3.28676850e-02f, -1.64152920e-01f, 5.17921299e-02f, 1.10695392e-01f, 1.31413057e-01f, 1.52977720e-01f, 4.54759039e-02f, 1.33762509e-01f, -3.77058201e-02f,
  -1.74151629e-01f, 1.05580337e-01f, 7.60124698e-02f, -6.21108711e-02f, -1.42203286e-01f, -1.97445378e-02f, -1.45352688e-02f, 4.64772806e-02f, 7.75367469e-02f, 4.68051396e-02f,
  3.06324493e-02f, 2.80231610e-02f, 2.04598475e-02f, -6.00134097e-02f, -8.32022075e-03f, 7.44809210e-02f, 1.52952835e-01f, 5.60189877e-03f, -1.00177461e-02f, 4.96914722e-02f,
  -3.25929448e-02f, -1.09090969e-01f, 4.45312783e-02f, -4.31964211e-02f, 2.45477781e-02f, 2.59909816e-02f, -1.53327119e-02f, 2.75325831e-02f, 4.99721384e-03f, 1.65963806e-02f,
  3.67901213e-02f, -3.33129428e-02f, -1.31395813e-02f, 8.51574764e-02f, -8.56079347e-03f, 1.27808405e-02f, -6.71024341e-03f, -8.56858492e-03f, 6.73497915e-02f, 1.19013311e-02f,
  -3.98441479e-02f, 3.97249982e-02f, 5.78036457e-02f, -9.66752097e-02f, 1.34236179e-03f, 1.43085457e-02f, -3.65774371e-02f, 5.05186692e-02f, -8.62782374e-02f, 5.10498509e-02f,
  8.71428661e-03f, -5.94186336e-02f, -1.14968894e-02f, -3.25581767e-02f, -1.14006549e-01f, -2.92482711e-02f, 3.15203033e-02f, -2.90861111e-02f, 5.36554046e-02f, -4.18579653e-02f,
  -4.01690528e-02f, 1.04134589e-01f, 3.09460498e-02f, -2.46132910e-02f, 2.69953888e-02f, -2.32940167e-02f, -1.57263409e-02f, -9.54643264e-03f, -6.28359839e-02f, -6.08793348e-02f,
  -6.10919781e-02f, -6.49659038e-02f, -4.48414348e-02f, -5.63786179e-03f, -2.72873957e-02f, 1.52337933e-02f, -5.64762540e-02f, -2.92815622e-02f, 2.86745299e-02f, 6.76236600e-02f,
  6.06489107e-02f, 4.44406830e-02f, 8.51576123e-03f, -2.95461100e-02f, 1.64420586e-02f, -5.41687608e-02f, 2.91656679e-03f, -5.52072376e-02f, 3.44040357e-02f, -3.77778634e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.90531158e-01f, -5.24561033e-02f, 1.00458957e-01f, 3.45565498e-01f, 2.90615022e-01f, 3.46801400e-01f, 3.22147965e-01f, 3.01451027e-01f, 7.52115190e-01f, -1.21222511e-02f,
  -9.33516491e-03f, -1.39981762e-01f, -7.41772056e-02f, -1.09894827e-01f, 6.25747442e-02f, -3.25236358e-02f, 1.62431434e-01f, -5.57966903e-03f, 1.84103116e-01f, 3.91048789e-02f,
  1.41937092e-01f, -9.16764066e-02f, -4.15345818e-01f, -2.03741565e-01f, -1.01376630e-01f, -2.23561302e-02f, -3.54692519e-01f, -1.33749187e-01f, -2.87356019e-01f, -7.17059448e-02f,
  5.67124672e-02f, 1.62621632e-01f, -1.13182485e-01f, -3.21466468e-05f, 9.72092599e-02f, -4.60151806e-02f, -1.09642610e-01f, -7.69207329e-02f, -7.32663600e-03f, -7.48746563e-03f,
  1.44888670e-03f, -7.32063726e-02f, 3.64041962e-02f, 2.57596970e-02f, 1.31699547e-01f, -2.68004425e-02f, -4.45149504e-02f, 5.85202537e-02f, -6.66909665e-02f, -5.59697561e-02f,
  -2.31556166e-02f, -1.56043563e-02f, 3.48847248e-02f, -3.83492187e-02f, 5.08229528e-03f, 5.99712245e-02f, 1.13828361e-01f, 2.19311230e-02f, 1.60556827e-02f, 1.88611940e-01f,
  -4.04528007e-02f, 1.39336899e-01f, -2.43104044e-02f, -2.15892345e-02f, 5.16452417e-02f, -1.80381518e-02f, -2.67057549e-02f, -5.67549840e-02f, 1.47867184e-02f, -5.04439659e-02f,
  -1.21469283e-02f, 6.98008090e-02f, 2.48640552e-02f, -3.39770652e-02f, 5.49982302e-02f, 6.40783757e-02f, 4.75590117e-03f, -8.44200701e-02f, 1.05574913e-01f, 1.94449071e-02f,
  -4.88062687e-02f, -3.66138257e-02f, -9.25672799e-02f, 1.58159230e-02f, -3.46887186e-02f, 1.77560952e-02f, -6.31185174e-02f, -3.31406891e-02f, -2.18676291e-02f, -9.17268693e-02f,
  2.07709000e-01f, 1.64052933e-01f, -4.49892646e-03f, 1.10714864e-02f, -3.89731452e-02f, -6.90804422e-02f, 4.99994680e-02f, 4.45684418e-02f, 5.67863286e-02f, 4.61959206e-02f,
  -1.15732802e-02f, 7.78429359e-02f, 1.22680087e-02f, -5.23790084e-02f, -2.03347001e-02f, 4.10996340e-02f, -4.40178290e-02f, 5.28603084e-02f, 6.30223528e-02f, -7.00197667e-02f,
  -1.49048209e-01f, 1.01523045e-02f, -3.74525748e-02f, 6.68907985e-02f, 3.06656826e-02f, -1.29461423e-01f, 9.13748369e-02f, -2.74157692e-02f, -4.67021801e-02f, -1.22157119e-01f,
  5.19393146e-01f, 1.97828606e-01f, -4.05583233e-01f, 3.34767601e-03f, 1.11017987e-01f, 4.59693134e-01f, 1.79432347e-01f, 4.36572731e-02f, -6.05984703e-02f, 1.80367351e-01f,
  1.99371904e-01f, -1.11160129e-01f, 2.68025361e-02f, 3.95456642e-01f, 8.91304985e-02f, -2.31637731e-02f, 3.73074353e-01f, 1.33052468e-01f, -7.72856548e-02f, 1.55386001e-01f,
  -8.72296542e-02f, 4.96699572e-01f, -2.53076285e-01f, 5.31586893e-02f, 2.68044561e-01f, -3.25145841e-01f, 3.25010009e-02f, -2.15253279e-01f, 6.08866587e-02f, 1.76301897e-01f,
  7.45138898e-02f, 2.94292625e-02f, -6.44576475e-02f, -7.67032728e-02f, 5.57292141e-02f, -8.00766610e-03f, -4.84684743e-02f, -1.22094586e-01f, -2.10249081e-01f, 3.87714244e-02f,
  -9.47391428e-03f, 1.13314521e-02f, 1.90039556e-02f, -8.26981813e-02f, 7.78357238e-02f, -4.96070161e-02f, -3.83660197e-03f, -3.16965505e-02f, -1.13388047e-01f, 2.64850762e-02f,
  -5.78975789e-02f, 2.90911049e-02f, 1.37256235e-02f, -4.41070460e-02f, -9.32663083e-02f, 3.42744850e-02f, -7.85411596e-02f, -5.34778498e-02f, 1.34561658e-02f, 5.16939387e-02f,
  1.06842920e-01f, 2.24308521e-02f, 4.69211722e-03f, 4.77807224e-02f, 2.03455463e-02f, -2.53410954e-02f, 1.58945005e-02f, -3.79126370e-02f, -6.52760118e-02f, 5.40354997e-02f,
  -8.59751105e-02f, 4.85089831e-02f, 3.54557671e-02f, -9.44932476e-02f, 2.07446367e-02f, 3.39008011e-02f, -5.61417639e-03f, -2.78931074e-02f, -2.87606847e-02f, -2.06167977e-02f,
  -2.39177141e-02f, 7.99066797e-02f, -8.17468986e-02f, 4.07865010e-02f, -2.91183367e-02f, -7.27156624e-02f, 1.25628099e-01f, -8.29147641e-03f, -3.84080522e-02f, -9.68259666e-03f,
  7.03317150e-02f, 2.45196015e-01f, -5.88919558e-02f, -2.77424138e-02f, -3.60041112e-03f, 1.18448459e-01f, 9.23187137e-02f, 7.12752789e-02f, 5.14504984e-02f, 6.57882867e-03f,
  -2.02780776e-02f, -9.05707553e-02f, 3.11343595e-02f, 1.46951992e-02f, -8.68957564e-02f, 9.70710292e-02f, 5.18418942e-03f, -1.61570460e-02f, 1.23694219e-01f, -6.98652538e-03f,
  5.11387289e-02f, -4.79568215e-03f, -6.57150336e-03f, 3.10523864e-02f, 8.17859396e-02f, -6.07490242e-02f, 5.34732044e-02f, -9.46815908e-02f, 3.65024880e-02f, -6.89552501e-02f,
  -7.25021780e-01f, 5.32770455e-01f, 4.24230695e-01f, -3.95430982e-01f, 3.11301917e-01f, 4.79888260e-01f, -1.28178686e-01f, 2.78199166e-01f, 2.21457839e-01f, -1.56283319e-01f,
  -2.44943842e-01f, 1.21745199e-01f, -4.02719481e-03f, -1.55170858e-01f, -8.09196383e-02f, 1.57564148e-01f, 1.13785177e-01f, -3.78443412e-02f, 2.91084319e-01f, 6.66728336e-03f,
  -1.18075567e-03f, -4.22943123e-02f, -3.99849750e-02f, 2.82278717e-01f, -1.82713009e-02f, -3.57635729e-02f, -3.74182880e-01f, 2.27983564e-01f, -1.60493255e-01f, 1.79899961e-01f,
  -9.26454365e-02f, -5.34293987e-02f, -4.56407815e-02f, 1.15572855e-01f, -2.88577788e-02f, 5.22941723e-02f, 1.78018864e-02f, 6.12036400e-02f, 1.09254625e-02f, -3.60652478e-03f,
  -1.87538899e-02f, 5.96816801e-02f, 5.62387742e-02f, 3.95945180e-03f, 1.97323084e-01f, 2.31634043e-02f, -5.26527641e-03f, 6.81813760e-03f, 1.07634567e-01f, 1.45681426e-01f,
  -6.07777536e-02f, 5.45730181e-02f, 5.57729900e-02f, -1.56710614e-02f, -3.02801691e-02f, -9.35235713e-03f, -1.02836967e-01f, -5.01514710e-02f, 1.01426862e-01f, 1.93706509e-02f,
  1.29916295e-01f, 1.03404999e-01f, -4.67499495e-02f, -2.29228977e-02f, -6.47324696e-02f, 5.48157096e-02f, 1.39942924e-02f, -9.44782863e-04f, -3.82835642e-02f, -8.64319056e-02f,
  -1.39454782e-01f, 2.15776078e-02f, 1.70872599e-01f, -4.19501960e-03f, -1.34964645e-01f, -5.66270724e-02f, -9.36463661e-03f, -8.92778859e-03f, -7.82018825e-02f, -4.22496982e-02f,
  9.52487066e-03f, 1.03517309e-01f, -7.34736845e-02f, -6.91897795e-02f, 5.13968617e-02f, -2.23592222e-02f, 2.10474674e-02f, -3.97393145e-02f, -6.62711114e-02f, 1.93694234e-03f,
  8.86178836e-02f, 4.71296534e-02f, -6.54816553e-02f, -5.13582975e-02f, -9.30163823e-03f, -1.76378693e-02f, 1.65717140e-01f, 1.34927751e-02f, -1.81579404e-02f, -5.48173534e-03f,
  -7.19147474e-02f, -9.04600546e-02f, 6.07536137e-02f, 7.24243447e-02f, 1.52988574e-02f, -1.20809097e-02f, -4.86917943e-02f, -2.91786548e-02f, -7.33721862e-03f, 7.61366682e-03f,
  -5.22764847e-02f, -5.23820557e-02f, -7.35547841e-02f, -5.79591617e-02f, 5.94328232e-02f, -1.03162296e-01f, 4.26409468e-02f, 3.67528349e-02f, 3.13134119e-02f, 2.63767540e-02f,
  -1.29473343e-01f, -2.71781892e-01f, -4.89507884e-01f, -4.07407075e-01f, 2.76350249e-02f, -3.22814256e-01f, -3.80143851e-01f, 2.50215791e-02f, 6.24825209e-02f, 2.15674758e-01f,
  2.27514561e-02f, -1.22533150e-01f, 1.12347960e-01f, -3.57671738e-01f, -1.81023911e-01f, -6.36677891e-02f, -4.44137633e-01f, -2.85120934e-01f, -9.36245695e-02f, -2.50392824e-01f,
  -2.30697647e-01f, -1.10666059e-01f, -5.13996780e-01f, 9.76181775e-02f, -3.57956439e-01f, 3.45787071e-02f, 1.18041709e-01f, 2.57656835e-02f, -1.51616007e-01f, -3.42563801e-02f,
  -1.66107297e-01f, 1.91581115e-01f, -4.96609658e-02f, -2.01084297e-02f, -1.25840142e-01f, 7.24497158e-03f, -3.20343859e-02f, 8.20952207e-02f, -9.72706079e-02f, 2.35481430e-02f,
  5.22570498e-02f, 1.25642046e-01f, 4.37968411e-02f, 4.97875139e-02f, -1.76017582e-02f, 7.66106173e-02f, -1.23678610e-01f, -1.26541197e-01f, 3.58887017e-02f, -1.52723655e-01f,
  -2.54675567e-01f, -6.53836206e-02f, -8.99322405e-02f, -1.30696576e-02f, -9.03047621e-02f, -6.71425089e-02f, -9.99030098e-02f, 1.51487635e-02f, -9.55121368e-02f, -3.31065170e-02f,
  9.05465782e-02f, 6.76885946e-03f, -2.88019963e-02f, -3.28159779e-02f, -2.82963179e-02f, 5.46074938e-03f, -4.04745415e-02f, 6.50549307e-02f, 8.34614709e-02f, -6.68922067e-02f,
  -8.74724984e-03f, -1.57158766e-02f, 5.99555150e-02f, -4.51580472e-02f, -8.57446790e-02f, -1.55107770e-02f, 4.54152897e-02f, 3.21245417e-02f, -1.19660400e-01f, -1.10396177e-01f,
  5.17341271e-02f, -9.29912403e-02f, 4.09496874e-02f, -5.64644113e-02f, -1.51759349e-02f, 6.08832836e-02f, 9.27630067e-03f, 8.71096700e-02f, -8.53506774e-02f, -2.20954120e-02f,
  -2.67248824e-02f, 1.31362528e-01f, 7.63348341e-02f, 1.27648413e-01f, 5.75809032e-02f, -6.01786375e-03f, -2.55963802e-02f, -8.52635950e-02f, 3.17646824e-02f, -1.89059377e-02f,
  1.17652090e-02f, 5.31172752e-03f, -7.91526884e-02f, -2.82400735e-02f, -6.92282096e-02f, -3.74241807e-02f, -1.18766734e-02f, 5.65424077e-02f, -3.63246165e-02f, -4.74612713e-02f,
  5.20312265e-02f, 8.60114470e-02f, 1.29843682e-01f, -1.36336051e-02f, 6.96005207e-03f, 4.77824733e-03f, -2.11660303e-02f, 2.23160125e-02f, -3.54263745e-02f, -3.14462185e-02f,
  -4.17312413e-01f, -1.04952887e-01f, -2.14100897e-01f, -4.41926688e-01f, 2.00846836e-01f, -4.94183265e-02f, -3.02406788e-01f, -2.02342212e-01f, -9.33864936e-02f, -2.26145938e-01f,
  -1.36153027e-01f, 3.77890691e-02f, 1.51370808e-01f, -4.25743997e-01f, 2.00826600e-01f, 1.87771395e-01f, -3.96467388e-01f, -5.95031567e-02f, 7.30557963e-02f, -2.65056103e-01f,
  -4.47735861e-02f, -2.78855205e-01f, -7.82135576e-02f, -9.46606770e-02f, -2.08154157e-01f, -7.87089765e-02f, -7.63957798e-02f, 4.07180637e-02f, -1.69997394e-01f, 8.60120803e-02f,
  -5.76121323e-02f, -1.95216313e-01f, -1.73923105e-01f, -6.91182390e-02f, -1.17633529e-01f, -1.76603440e-02f, -7.36804456e-02f, 5.06169945e-02f, -1.92056764e-02f, -2.07079779e-02f,
  1.06409788e-02f, 4.42840792e-02f, -9.19337273e-02f, 1.11000098e-01f, 6.25337148e-03f, -6.26806989e-02f, 3.18284631e-02f, 3.61615755e-02f, -7.01863021e-02f, 7.13963211e-02f,
  3.18334959e-02f, -2.90308781e-02f, -8.47447589e-02f, 2.50418466e-02f, 1.97346117e-02f, -4.70255315e-02f, 6.87956139e-02f, 9.05406848e-02f, -3.63779478e-02f, -3.40714566e-02f,
  -9.53106508e-02f, 8.47236719e-03f, -3.53802461e-03f, 2.96480525e-02f, -9.42984447e-02f, -1.29814842e-04f, -5.33390678e-02f, -7.29535446e-02f, -5.21483235e-02f, -7.10615963e-02f,
  -4.07196209e-02f, 2.75486447e-02f, -6.12693690e-02f, -5.65449260e-02f, -4.77785803e-02f, -3.03781349e-02f, 4.00357544e-02f, -3.68024558e-02f, -3.93175054e-03f, 8.41828529e-03f,
  -2.02140026e-02f, 7.10292011e-02f, 2.42643263e-02f, -3.14919651e-02f, -2.48011574e-02f, -9.84761631e-04f, -1.71178691e-02f, -1.08256564e-01f, 3.61010768e-02f, -3.24743353e-02f,
  -4.84964158e-03f, -2.89706498e-01f, -1.87144205e-02f, -1.12547375e-01f, 1.04760388e-02f, 2.11218148e-02f, -7.16909394e-02f, -2.74523348e-02f, 5.56781292e-02f, -1.27509693e-02f,
  -8.32596570e-02f, -5.67753837e-02f, -2.44526956e-02f, -4.86526340e-02f, 2.21992657e-03f, 1.84072889e-02f, -1.55361108e-02f, 6.62841052e-02f, -6.93226531e-02f, 6.25108555e-02f,
  -1.07833883e-02f, 1.87366884e-02f, -5.69842814e-05f, -3.97571735e-02f, -1.62477400e-02f, 1.80093888e-02f, 5.23247384e-02f, -4.80948314e-02f, 1.30560786e-01f, 1.54412696e-02f,
  -2.36237645e-02f, -4.41032559e-01f, -4.01799798e-01f, -1.30665749e-01f, 4.77753669e-01f, 2.25045890e-01f, -7.04567507e-02f, 1.69834867e-01f, -1.58397511e-01f, 6.86411262e-02f,
  -5.77601455e-02f, -2.66459376e-01f, -4.13458139e-01f, -3.39507222e-01f, -2.18718424e-01f, -4.15485620e-01f, 2.44552325e-02f, -1.04489282e-01f, -1.52843028e-01f, -2.80755223e-03f,
  2.20144372e-02f, 8.43002796e-02f, -2.88795769e-01f, 2.88093179e-01f, 4.36734483e-02f, 1.29333183e-01f, 2.67133951e-01f, 4.45767045e-02f, 1.81914449e-01f, 7.19325319e-02f,
  -1.45543693e-02f, -2.68133163e-01f, -3.67706344e-02f, -1.08267479e-01f, 5.72170541e-02f, 1.04965910e-01f, 1.14447050e-01f, 1.26032513e-02f, -3.90144624e-02f, -6.12498410e-02f,
  -3.54261883e-02f, 5.26443869e-02f, -2.91012297e-03f, 8.30847993e-02f, 3.13904025e-02f, -6.58492977e-03f, 4.72297950e-04f, -2.64752712e-02f, -7.40828142e-02f, -1.65180340e-01f,
  -1.75051227e-01f, 1.18245920e-02f, 2.61071324e-02f, -1.29250772e-02f, -5.03873173e-03f, -1.46411359e-02f, 1.18722254e-02f, -3.67541541e-03f, 5.92049398e-02f, 4.25926922e-03f,
  4.99198213e-02f, 5.60666136e-02f, -1.32698506e-01f, -4.41295952e-02f, -7.90754184e-02f, 2.66192798e-02f, -3.48517969e-02f, 1.06232408e-02f, -5.78103326e-02f, -6.27683522e-03f,
  8.50737393e-02f, -3.19682620e-02f, 5.14080562e-02f, 6.20454885e-02f, 1.27741415e-02f, 4.98492345e-02f, 1.37136402e-02f, -6.77468721e-04f, 1.26942096e-03f, -9.22944322e-02f,
  -1.76571980e-02f, 1.86868813e-02f, 4.19225730e-02f, 6.08929768e-02f, -1.40781207e-02f, 4.84847166e-02f, 3.51500846e-02f, -4.44699898e-02f, 3.96955125e-02f, 1.07649537e-02f,
  6.26535714e-02f, 4.09908360e-03f, -1.36267603e-03f, 7.59629160e-02f, -9.86922309e-02f, 4.62440886e-02f, -1.30293608e-01f, 2.24024989e-02f, 9.34183300e-02f, 2.02780906e-02f,
  1.67916268e-01f, 7.07715601e-02f, 1.01645388e-01f, -3.26590613e-02f, 3.95643190e-02f, 3.41539718e-02f, 2.46140417e-02f, 1.26209125e-01f, 1.28121734e-01f, 4.15896140e-02f,
  9.32509825e-02f, 3.43258083e-02f, -6.96190223e-02f, 3.66335958e-02f, 1.13219589e-01f, 4.67374586e-02f, -1.06988680e-02f, -3.93871889e-02f, 3.36480443e-04f, 4.14423384e-02f,
  6.99616075e-01f, -5.34484684e-01f, 8.10228586e-02f, 9.87598971e-02f, 3.38712126e-01f, -8.00239816e-02f, 6.21705532e-01f, -1.19571343e-01f, 7.15076551e-02f, -4.75203246e-01f,
  1.41790465e-01f, 9.72130336e-03f, 1.06357746e-01f, -1.67070612e-01f, 6.33724272e-01f, 1.05977774e-01f, -7.61579871e-02f, -4.35722433e-02f, -3.26830857e-02f, 7.39041809e-03f,
  8.04947093e-02f, -1.20945111e-01f, 5.65424152e-02f, -3.48489136e-01f, -2.01982558e-02f, -1.55744389e-01f, 3.28847133e-02f, 1.37812704e-01f, -3.33156079e-01f, 7.73738921e-02f,
  1.04117215e-01f, -3.14818360e-02f, -4.27123010e-02f, 2.30907090e-03f, -8.12400803e-02f, 2.82425787e-02f, 4.94485779e-04f, 1.95740715e-01f, 9.96034071e-02f, -3.14897634e-02f,
  3.96825224e-02f, -4.40689139e-02f, -8.91579408e-03f, 2.01700907e-02f, -2.10228050e-03f, -5.53760529e-02f, -1.12334043e-02f, -1.01641588e-01f, 6.64935866e-03f, 6.32037520e-02f,
  1.70415007e-02f, -6.82264857e-04f, -1.33510297e-02f, -7.09904432e-02f, -2.85348743e-02f, -1.28809279e-02f, -2.44517997e-02f, 6.11788258e-02f, -1.21601470e-01f, -7.93176666e-02f,
  2.38227360e-02f, 2.96834037e-02f, -1.84282903e-02f, -1.41926873e-02f, -2.98822559e-02f, 2.63413554e-03f, 2.62294710e-02f, -1.18976645e-02f, 5.73167428e-02f, -4.55310643e-02f,
  -7.82421678e-02f, 6.91339523e-02f, 3.32539193e-02f, 1.29899299e-02f, -2.49968898e-02f, -4.21157517e-02f, 8.25804323e-02f, -1.04958683e-01f, -2.65276115e-02f, -4.42612953e-02f,
  3.73863126e-03f, 1.58505831e-02f, -1.22943468e-01f, 2.91604046e-02f, 2.75521148e-02f, 1.08311074e-02f, -2.84975823e-02f, -5.14775403e-02f, -6.12550788e-02f, 7.97349438e-02f,
  -1.23356216e-01f, -3.42645735e-01f, -2.34540459e-02f, -2.45650075e-02f, 5.48425838e-02f, -6.18274659e-02f, 1.06963538e-01f, -8.82544070e-02f, -1.43846810e-01f, 1.92190204e-02f,
  -7.34304190e-02f, 5.80932759e-02f, 2.67066807e-02f, 2.82079391e-02f, 3.61650623e-02f, -7.69193545e-02f, -6.40738532e-02f, -5.04382653e-03f, 1.10165272e-02f, -1.64626315e-01f,
  -1.03900656e-01f, 3.01362551e-03f, 4.52981554e-02f, -2.34108828e-02f, -2.66189650e-02f, 5.26999170e-03f, -1.72458068e-02f, 6.29156269e-03f, 6.25560135e-02f, 1.51144527e-02f,
  -5.52730411e-02f, -1.29352119e-02f, -5.29692583e-02f, 8.42662007e-02f, -6.73139021e-02f, -4.61531401e-01f, -4.86610174e-01f, -5.44215553e-02f, -3.26138198e-01f, -9.71346423e-02f,
  -4.46613617e-02f, -1.69746384e-01f, 1.33120626e-01f, -1.82518065e-01f, 1.05842523e-01f, 5.74778393e-02f, 6.59976825e-02f, -5.58342338e-02f, 1.32118523e-01f, 2.07146540e-01f,
  2.45270148e-01f, 1.02111869e-01f, 1.01951189e-01f, 1.94360316e-01f, 7.33334348e-02f, 2.72608429e-01f, 5.97777128e-01f, 1.34838328e-01f, 1.68718278e-01f, 7.72446347e-03f,
  -1.27230749e-01f, 9.08204019e-02f, -3.99156213e-02f, -2.50597801e-02f, 1.50653958e-01f, 2.44821645e-02f, -8.55729915e-03f, 8.96328986e-02f, -7.50585645e-02f, 7.43908063e-02f,
  9.59683582e-02f, 3.41360904e-02f, -3.73025723e-02f, -1.04459502e-01f, 1.24432974e-01f, -5.06426916e-02f, 2.55024303e-02f, -6.17444776e-02f, -5.81046864e-02f, 3.61615530e-04f,
  -1.20610245e-01f, 5.19144982e-02f, 5.18760942e-02f, -2.86808033e-02f, 1.34525932e-02f, -3.47063020e-02f, -2.56947912e-02f, 4.32395674e-02f, 9.80039611e-02f, 4.55209464e-02f,
  1.32540688e-01f, 4.81454208e-02f, 7.63708279e-02f, 8.44721403e-03f, 1.17607443e-02f, -3.49769747e-04f, 4.48969342e-02f, 4.45423983e-02f, -7.18398616e-02f, 1.01868093e-01f,
  -7.26804510e-02f, -3.81824262e-02f, 5.77810630e-02f, 4.62002717e-02f, 6.69699237e-02f, -1.28270471e-02f, -4.84777689e-02f, 5.05515225e-02f, -1.15975782e-01f, 1.61404274e-02f,
  -1.90653671e-02f, 6.26146346e-02f, -1.29141465e-01f, -1.98956113e-02f, -6.57903552e-02f, 5.98842185e-03f, 8.78571942e-02f, -2.97176298e-02f, -1.47047536e-02f, 1.21006593e-01f,
  1.02281347e-01f, 5.78688204e-01f, -1.59602657e-01f, -8.45737234e-02f, 6.61343038e-02f, 9.84544456e-02f, 9.98256449e-03f, -3.05133108e-02f, 9.95794684e-02f, 8.83758739e-02f,
  5.38657978e-02f, -9.47455391e-02f, 2.27365866e-01f, -7.39375651e-02f, 4.00224812e-02f, 9.67067182e-02f, 8.24159905e-02f, -3.40461209e-02f, 9.59488228e-02f, 9.51954797e-02f,
  1.57563582e-01f, 9.57783163e-02f, 1.19891591e-01f, -2.04978794e-01f, 5.37855012e-05f, -7.89407268e-03f, -5.41354790e-02f, 1.24877589e-02f, 1.54641584e-01f, -8.74393359e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.01517193e-01f, 2.56044269e-01f, 3.89425337e-01f, 2.35481218e-01f, 1.89486817e-01f, 3.03017553e-02f, 2.46455073e-01f, 2.78942347e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.32660437e-01f, 1.44355536e-01f, 5.50002635e-01f, 4.03784141e-02f, 1.75603405e-01f, -2.04581648e-01f, -1.43683925e-01f, -4.58263934e-01f, 3.51720989e-01f, -3.74248445e-01f,
  -9.16685089e-02f, 8.72135088e-02f, 2.04505667e-01f, -3.89073044e-01f, 3.12271893e-01f, 2.47181822e-02f, -4.62491542e-01f, 7.11244464e-01f, 2.10350871e-01f, -3.01092356e-01f,
  1.04738146e-01f, -1.02983989e-01f, 5.13669709e-03f, 3.37305129e-01f, -2.60713995e-01f, -3.02211463e-01f, 1.14079319e-01f, 3.50398868e-01f, 2.10239798e-01f, 7.86252506e-03f,
  2.14188278e-01f, 1.02350414e-01f, -1.58227354e-01f, -4.04575318e-01f, -2.51777351e-01f, 5.08226395e-01f, 1.53907150e-01f, 3.20208043e-01f, 1.13829575e-01f, -3.38988334e-01f,
  -1.26560748e-01f, -1.59337297e-01f, -5.50686657e-01f, -6.82705492e-02f, 1.64590836e-01f, 5.18271089e-01f, 6.38769031e-01f, -4.72127795e-02f, 8.41046572e-02f, -3.40292633e-01f,
  8.64762589e-02f, -2.02372327e-01f, 4.13020879e-01f, 2.81936750e-02f, 3.35116461e-02f, 5.85400984e-02f, -6.95734918e-02f, 3.01609039e-02f, -1.31449118e-01f, 2.67444432e-01f,
  2.10917115e-01f, -4.69635308e-01f, -3.61532390e-01f, 5.60143813e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.52304024e-01f, 7.90953159e-01f, 6.51450276e-01f, 3.72184575e-01f, 5.63176513e-01f, 4.81500141e-02f, 2.12885514e-01f, 1.15132779e-01f, 6.67552352e-01f, 3.44996512e-01f,
  -5.24617434e-02f, -3.11832398e-01f, -2.69418329e-01f, 3.38253081e-01f, 7.74405599e-01f, 2.87539244e-01f, 6.95053563e-02f, 3.08671266e-01f, 8.11409280e-02f, 2.43682057e-01f,
  6.09747052e-01f, -2.01241195e-01f, -2.63418704e-01f, 2.58566082e-01f, 1.00166522e-01f, 8.03179264e-01f, 2.41479613e-02f, 7.03879297e-01f, 3.63038182e-01f, 1.73361003e-01f,
  -1.97878376e-01f, 5.75099409e-01f, 4.98774737e-01f, 1.15083113e-01f, 2.21922100e-01f, 5.81328750e-01f, 5.03401637e-01f, -2.39640489e-01f, 2.31044486e-01f, -1.89005479e-01f,
  7.87302077e-01f, 3.42485547e-01f, -2.02993557e-01f, 8.57271403e-02f, -6.02926493e-01f, -1.52054466e-02f, -9.38829407e-02f, -1.66785851e-01f, 5.21570086e-01f, 8.49224925e-02f,
  4.22494531e-01f, 5.62139273e-01f, 2.86242455e-01f, -1.73209071e-01f, 2.05724895e-01f, -5.54544985e-01f, 5.58592498e-01f, 4.17071462e-01f, 3.71821672e-01f, 1.08735241e-01f,
  -2.50782967e-01f, -3.75725061e-01f, 1.60974875e-01f, -2.91035660e-02f, 2.45670691e-01f, 1.46389261e-01f, -3.01721752e-01f, 2.04119533e-01f, 3.30000907e-01f, -2.19700068e-01f,
  3.44700813e-01f, -2.21534088e-01f, 3.37255895e-01f, 7.68743336e-01f, -1.57407328e-01f, -2.23143503e-01f, -4.02451128e-01f, 1.05885252e-01f, -5.72244637e-02f, 3.49855989e-01f,
  2.99525738e-01f, -2.97630280e-01f, 4.70279455e-02f, -3.29960734e-01f, 6.03085279e-01f, -2.78932005e-01f, -1.68159232e-01f, 1.86679602e-01f, -6.06590152e-01f, -6.26777634e-02f,
  -5.92869461e-01f, 3.03998888e-01f, 5.87393999e-01f, -3.28414291e-01f, 8.52513075e-01f, 7.46846378e-01f, -9.95039418e-02f, 4.06132281e-01f, 2.24085629e-01f, 2.82977611e-01f,
  -7.52340674e-01f, 5.71569264e-01f, -5.01500666e-01f, 6.73670352e-01f, -8.37666318e-02f, 3.82898673e-02f, -1.38101727e-01f, 4.42597568e-01f, -1.95897311e-01f, 4.99093831e-01f,
  -5.57497025e-01f, 5.76460660e-01f, 1.67173505e-01f, 8.98808420e-01f, 5.43556452e-01f, 2.27989838e-01f, -1.07525364e-01f, -3.49060327e-01f, -9.84411761e-02f, -1.64150149e-01f,
  2.97965169e-01f, -1.48237184e-01f, 7.19570220e-01f, 7.64032483e-01f, 6.02662742e-01f, -3.63936365e-01f, -3.59835416e-01f, 1.51106894e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  6.49906933e-01f, 4.36143756e-01f, -4.45894860e-02f, 6.49806559e-02f, 1.00106545e-01f, 2.97494173e-01f, 4.42117363e-01f, 2.70157844e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -3.65368009e-01f, 1.98679239e-01f, -3.12080383e-01f, -1.18858375e-01f, 1.04480259e-01f, 2.45420337e-01f, 6.07452869e-01f, -2.74100274e-01f, 1.28068596e-01f, 1.11113511e-01f,
  -4.03972536e-01f, -2.51698971e-01f, -1.96682245e-01f, 2.55644411e-01f, 2.00086400e-01f, -6.05956092e-02f, 8.98176059e-02f, 2.41428807e-01f, 6.45009056e-02f, 5.37431501e-02f,
  -3.88298720e-01f, -4.02672559e-01f, 5.28964937e-01f, -2.84279346e-01f, -9.97001082e-02f, 1.87926188e-01f, 1.69463322e-01f, -1.29790260e-02f, 3.07692617e-01f, -2.35753149e-01f,
  -2.88607955e-01f, -2.92963207e-01f, 2.89821982e-01f, 2.90533900e-02f, 2.34517500e-01f, 2.59646654e-01f, -1.84197992e-01f, -5.90769172e-01f, 6.21425435e-02f, 3.35027874e-01f,
  -2.68171132e-02f, 1.37093989e-02f, 4.79251891e-01f, 3.21766436e-01f, 2.15066016e-01f, -2.36619473e-01f, -1.83671579e-01f, -3.09512556e-01f, 8.39704722e-02f, -1.74363881e-01f,
  -1.31384194e-01f, -1.00254796e-01f, -4.33287084e-01f, 2.16534808e-02f, 3.40644538e-01f, -2.42693335e-01f, 5.79979410e-03f, -4.35714498e-02f, 1.24490470e-01f, -1.83038786e-01f,
  1.61741853e-01f, -3.37254554e-01f, 2.45857805e-01f, -3.18638146e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -3.89017642e-01f, 5.00129998e-01f, -2.31910758e-02f, -9.83322114e-02f, 5.83548546e-01f, -3.15794677e-01f, 7.01693475e-01f, -4.96782750e-01f, 8.54198933e-01f, 2.58373618e-01f,
  5.03454804e-01f, 5.25537729e-01f, 2.12699473e-01f, 7.91577816e-01f, -3.19952935e-01f, 1.82959035e-01f, 2.12547347e-01f, -4.74019736e-01f, 1.36449546e-01f, -1.99562162e-01f,
  -7.97995627e-02f, 2.74366252e-02f, 2.24151701e-01f, 1.25640050e-01f, -2.16401786e-01f, 5.20118773e-01f, -3.86859298e-01f, -2.92699277e-01f, -5.00076592e-01f, -4.67259251e-02f,
  8.68545532e-01f, 8.82000804e-01f, -2.11847782e-01f, -1.26138777e-01f, 4.11452085e-01f, -3.58001180e-02f, 7.08749473e-01f, -1.34223461e-01f, -3.21196675e-01f, 4.04502034e-01f,
  -2.01021153e-02f, 4.66758162e-01f, 3.92890483e-01f, 5.20748019e-01f, 2.89999187e-01f, 5.77997684e-01f, -3.22049320e-01f, 7.66344368e-01f, 8.47034335e-01f, 7.24610165e-02f,
  6.12381637e-01f, 3.80165040e-01f, -8.10795605e-01f, -4.31682289e-01f, 6.38427854e-01f, -1.91658616e-01f, 1.64599895e-01f, 9.93480802e-01f, 4.56626564e-01f, 3.13741148e-01f,
  8.65711689e-01f, 7.15884686e-01f, 7.53047168e-01f, -2.03779951e-01f, 6.66148126e-01f, -8.57451111e-02f, 4.53742832e-01f, 5.58844566e-01f, -2.43188702e-02f, 4.81843472e-01f,
  -6.05837703e-01f, -2.30341613e-01f, -5.21627888e-02f, -3.41144383e-01f, -1.21876813e-01f, 3.21102709e-01f, -1.08882643e-01f, -5.05205691e-01f, 3.06290090e-01f, 7.26329148e-01f,
  6.37888730e-01f, -9.56474617e-02f, 2.31804848e-01f, 1.66515559e-01f, 1.34806603e-01f, 4.59524632e-01f, -1.24495220e+00f, 6.16424680e-01f, -6.93018362e-03f, 7.34003007e-01f,
  1.02450505e-01f, -4.38774452e-02f, 2.32807919e-01f, 5.55058420e-01f, 2.95305550e-01f, 7.26720691e-01f, -1.05525024e-01f, 8.02145422e-01f, 1.19174354e-01f, -2.84738511e-01f,
  5.61045766e-01f, -1.17639422e-01f, -3.37524742e-01f, -4.62757885e-01f, 7.02580333e-01f, -1.81414589e-01f, 6.76794231e-01f, 5.70098221e-01f, 2.48299669e-02f, -9.20564890e-01f,
  6.16211146e-02f, 3.85917425e-01f, 8.66798237e-02f, 9.08367276e-01f, -2.25731656e-01f, -2.24326346e-02f, -6.76409066e-01f, 4.66109574e-01f, 5.44897676e-01f, -9.48720336e-01f,
  7.35324621e-01f, 9.02690440e-02f, -2.07548335e-01f, -2.44359195e-01f, 1.36394560e-01f, 7.99443573e-02f, 8.05178404e-01f, -4.68280949e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  3.83412242e-01f, -1.96167268e-02f, 1.86336488e-01f, 5.43607712e-01f, 7.52921522e-01f, 3.63627821e-01f, -3.46700512e-02f, 5.88982821e-01f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -6.35331035e-01f, 1.49090931e-01f, 2.32000705e-02f, -3.61686498e-01f, 3.46230507e-01f, -3.26211005e-01f, -3.03771704e-01f, -3.18772584e-01f, -2.76157111e-01f, 2.07348272e-01f,
  2.11572155e-01f, 1.51487803e-02f, -3.53130549e-01f, 7.15069771e-02f, -8.25108439e-02f, -4.24440503e-02f, -3.14380452e-02f, -7.92690665e-02f, -2.45389134e-01f, -2.80266672e-01f,
  -1.59161046e-01f, -6.68982267e-02f, 1.86303169e-01f, -1.59604967e-01f, 2.72962064e-01f, -1.10875532e-01f, 2.69944314e-02f, 1.31654561e-01f, -2.82554746e-01f, -2.19439529e-03f,
  3.33679736e-01f, -3.92710686e-01f, 3.97519231e-01f, -2.79619068e-01f, 1.55465186e-01f, 1.43262804e-01f, -4.47165407e-02f, 4.43317235e-01f, 1.57183573e-01f, 5.80742598e-01f,
  -1.19362827e-02f, -2.34825686e-01f, 7.01914653e-02f, 1.22237727e-02f, -4.19587374e-01f, 1.83945835e-01f, 2.32962355e-01f, -4.57281694e-02f, -4.35016692e-01f, 6.11705892e-02f,
  7.37857968e-02f, -3.83832097e-01f, 3.14909488e-01f, -2.64880717e-01f, 1.69223741e-01f, -6.19562604e-02f, 2.66953707e-01f, 6.49012625e-02f, 1.77019194e-01f, -2.46457353e-01f,
  -3.22056890e-01f, 2.04545259e-01f, -6.50638044e-02f, -2.50436991e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -3.00713256e-03f, 2.32013956e-01f, 7.02089146e-02f, -7.23457158e-01f, -3.90855104e-01f, -2.76215523e-01f, 5.83651699e-02f, -3.18826437e-01f, 5.84240794e-01f, -2.08016232e-01f,
  1.07081664e+00f, -2.10069746e-01f, -1.42159536e-02f, -3.44879776e-02f, 8.20889890e-01f, -4.76778597e-01f, -7.80346870e-01f, -2.90373653e-01f, -1.81122050e-01f, -1.39801517e-01f,
  6.54302895e-01f, 5.24536893e-02f, -4.62656356e-02f, 3.98117214e-01f, 7.16832459e-01f, 5.29976904e-01f, 8.33541214e-01f, 5.35536587e-01f, -8.02834332e-01f, 4.31354672e-01f,
  -4.82800528e-02f, 6.94036186e-02f, 5.13042688e-01f, -3.51344883e-01f, 1.42256677e-01f, 1.87695399e-01f, -7.64223576e-01f, -2.06540108e-01f, -4.71496344e-01f, -5.37752628e-01f,
  -5.41218221e-01f, 8.22336614e-01f, 5.32243669e-01f, 8.88088346e-01f, 8.71668875e-01f, 1.12741745e+00f, -2.56326795e-01f, -2.15347648e-01f, 5.86271286e-01f, 5.74020028e-01f,
  2.26762742e-01f, -1.93843752e-01f, -5.32586396e-01f, -1.22656740e-01f, 4.73449320e-01f, -3.99128914e-01f, 2.68099934e-01f, -2.81319082e-01f, 1.58869460e-01f, -3.77266765e-01f,
  7.14650393e-01f, 7.01489374e-02f, 9.26083565e-01f, 3.01770002e-01f, 5.02514541e-01f, 1.58596814e-01f, 1.11083996e+00f, 5.22401094e-01f, 9.60229576e-01f, -4.48639423e-01f,
  -7.74185240e-01f, 2.15790600e-01f, 2.20055670e-01f, 3.00316755e-02f, -5.92549264e-01f, 5.24828911e-01f, -1.52416945e-01f, 6.10795170e-02f, 6.24960005e-01f, 1.30083823e+00f,
  2.61473536e-01f, 1.30596459e-01f, -8.62729251e-01f, 6.92979813e-01f, -8.82502615e-01f, 9.99717295e-01f, 9.54509139e-01f, 3.49777460e-01f, 2.95072526e-01f, -5.35972834e-01f,
  2.85450190e-01f, 6.79343402e-01f, -7.44216442e-02f, -3.13120157e-01f, 3.78655821e-01f, -7.97138810e-01f, -1.91771224e-01f, 6.05959713e-01f, 4.73066159e-02f, 6.45710826e-01f,
  -6.85778633e-03f, 3.16483647e-01f, 4.19518977e-01f, -5.82293272e-01f, 8.61027181e-01f, -7.75828600e-01f, 3.32844734e-01f, 6.01095915e-01f, -5.81429541e-01f, -6.16380908e-02f,
  7.25673884e-03f, 8.11832622e-02f, -4.04739417e-02f, -6.56501651e-02f, -1.23105966e-01f, 3.67384613e-01f, 6.48172617e-01f, 6.24417901e-01f, -2.40892507e-02f, 6.87227488e-01f,
  3.69500965e-01f, 3.12859952e-01f, -4.41368073e-01f, 7.14037120e-01f, -1.41587019e-01f, -7.11306810e-01f, -4.52641658e-02f, 4.99502927e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  9.58071277e-02f, -2.22071052e-01f, 6.58633471e-01f, 1.77162424e-01f, 1.33733168e-01f, 5.47917113e-02f, 4.19359654e-01f, 2.72031695e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  8.96701291e-02f, 3.46035302e-01f, 6.07786536e-01f, -6.39503300e-02f, -5.94104111e-01f, 1.06186426e+00f, 4.30160820e-01f, -7.25569606e-01f, -2.33501822e-01f, -1.10224992e-01f,
  8.05682242e-02f, -1.14539415e-01f, -1.62709785e+00f, 6.19997025e-01f, 4.41853881e-01f, -2.62646005e-02f, -2.38317579e-01f, -4.36098933e-01f, -7.66216099e-01f, 1.45142660e-01f,
  -8.67437273e-02f, -8.43462110e-01f, 3.52766365e-01f, 1.02161735e-01f, 7.47896507e-02f, 2.71105736e-01f, -1.85685217e-01f, -3.59894484e-01f, -1.26852110e-01f, 1.22779131e-01f,
  1.41188502e-01f, 5.72954044e-02f, -3.66554946e-01f, 5.20196021e-01f, -1.51511624e-01f, 1.83274701e-01f, -3.66670340e-01f, -1.78510472e-01f, 5.83786428e-01f, -6.20776534e-01f,
  -8.23596358e-01f, -9.70264599e-02f, -8.95114243e-01f, -3.99237067e-01f, 6.84950650e-01f, -3.43142837e-01f, 1.71461761e-01f, 5.56643546e-01f, 1.57084659e-01f, -4.51457977e-01f,
  -1.33887663e-01f, 2.13837609e-01f, 6.14791989e-01f, -3.38391274e-01f, -2.17204809e-01f, 5.00205278e-01f, -6.74749792e-01f, -2.92159200e-01f, 7.77856767e-01f, -4.61901665e-01f,
  -7.41741061e-01f, -2.08767891e-01f, -4.90502477e-01f, -4.81554419e-01f, 1.35391295e-01f, 3.64056289e-01f, 2.78767854e-01f, 5.13566315e-01f, -2.89994299e-01f, 5.22234321e-01f,
  -3.58512312e-01f, 2.57223874e-01f, 6.77837014e-01f, -2.63157129e-01f, 2.37125039e-01f, 5.08672953e-01f, -5.93074799e-01f, -1.06482017e+00f, -2.33545780e-01f, -1.35589570e-01f,
  -4.50393967e-02f, -1.48554981e-01f, 1.16432883e-01f, -3.52587104e-01f, -1.09295085e-01f, -4.10747290e-01f, 4.53882903e-01f, 6.58155084e-01f, 5.46404660e-01f, 1.71591952e-01f,
  -4.92829502e-01f, 6.13853931e-01f, -8.03763092e-01f, -7.72179812e-02f, 3.78045648e-01f, -1.02609968e+00f, -2.74227142e-01f, 2.17445735e-02f, -6.03945374e-01f, 2.80386537e-01f,
  8.79852772e-01f, -1.55567199e-01f, 2.96635032e-01f, -3.81506677e-03f, 1.50489211e-01f, -2.43724272e-01f, -1.10428977e+00f, 5.64622283e-01f, 5.55044331e-04f, 3.54348451e-01f,
  2.71219164e-01f, 1.14124537e-01f, -2.93185771e-01f, -1.23495236e-01f, 1.55138075e-01f, -1.12041749e-01f, 2.86680609e-01f, -1.67588577e-01f, 4.39729333e-01f, 2.37616763e-01f,
  1.30391449e-01f, 7.26845920e-01f, 2.46892739e-02f, -5.86509705e-01f, -7.28004336e-01f, -3.35853040e-01f, -5.99417448e-01f, -3.39842349e-01f, 5.01609184e-02f, 6.77792490e-01f,
  6.23127460e-01f, 5.46258628e-01f, 8.28251362e-01f, -4.72540170e-01f, -1.23977788e-01f, 2.81503648e-02f, -5.97225189e-01f, 1.00321494e-01f, 8.94668326e-02f, -5.73068380e-01f,
  2.95324266e-01f, -7.88257420e-01f, 2.27942973e-01f, -3.54652524e-01f, 2.69059718e-01f, -2.01844722e-01f, 4.85797912e-01f, 2.30012745e-01f, -5.35726011e-01f, 7.69691706e-01f,
  -7.03580081e-01f, 1.02404118e+00f, 4.09311019e-02f, 3.63150209e-01f, -9.76589143e-01f, -1.72477379e-01f, -4.94893827e-03f, -9.12204266e-01f, 6.10609710e-01f, 9.94347632e-02f,
  2.46007189e-01f, -2.83414096e-01f, -5.32260180e-01f, -3.56014788e-01f, 5.86275220e-01f, 2.49946374e-04f, -2.84294754e-01f, 8.31845254e-02f, 2.46905431e-01f, 4.86154296e-02f,
  -3.88752185e-02f, -4.66921210e-01f, 5.01108050e-01f, -1.56152919e-01f, -1.25722086e+00f, 6.38775706e-01f, 3.34039666e-02f, -4.76880133e-01f, 2.47438237e-01f, -5.09525597e-01f,
  -7.44422317e-01f, -2.60644495e-01f, -6.19236290e-01f, -3.51466715e-01f, -5.98219514e-01f, -1.38949907e+00f, 3.33425730e-01f, 4.38653409e-01f, 6.28589332e-01f, -4.69211191e-01f,
  -3.08525771e-01f, -1.66942149e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.68896988e-01f, -5.15110552e-01f, 1.42990962e-01f, -1.94439217e-01f, -7.14018242e-03f, -3.02149981e-01f, -1.95375741e-01f, -1.45632014e-01f, -2.07271829e-01f, -6.92177415e-02f,
  -2.69527912e-01f, 3.31184596e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    