/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.70426923e-01f, -2.12862045e-01f, -2.11096510e-01f, -3.53362799e-01f, -1.36832550e-01f, -2.32456978e-02f, -4.42093983e-02f, 4.72331196e-02f, -6.99095726e-02f, -1.75395593e-01f,
  -5.39285168e-02f, 7.68901333e-02f, 1.59540191e-01f, 1.67889580e-01f, 3.69835287e-01f, -8.78776144e-03f, 4.17020097e-02f, 2.07203016e-01f, 4.15600300e-01f, 1.81255683e-01f,
  1.49880573e-01f, -2.26472318e-01f, -6.60100579e-02f, 1.13272123e-01f, -2.55386472e-01f, 7.78571591e-02f, -1.75354660e-01f, -1.94876730e-01f, -4.09347937e-02f, -1.69966891e-01f,
  -1.34458274e-01f, -3.81896615e-01f, 1.79699287e-01f, 5.49675971e-02f, -3.16551514e-02f, 4.68431115e-02f, 5.76626398e-02f, -9.19817239e-02f, 1.91589240e-02f, -4.71185520e-02f,
  -9.71517488e-02f, -4.31440026e-03f, 3.61831076e-02f, -1.02406843e-02f, -1.15714662e-01f, -4.10585850e-02f, -1.25261724e-01f, 6.10347092e-02f, 4.21418436e-02f, -4.35683280e-02f,
  -6.80240318e-02f, -1.17214255e-01f, -2.12122217e-01f, 6.75704181e-02f, 1.08396061e-01f, 1.60127923e-01f, -7.07639828e-02f, 6.26254976e-02f, 1.07243182e-02f, -2.29635119e-01f,
  3.02307457e-02f, -1.43382763e-02f, -1.27632720e-02f, -2.50810198e-02f, 4.16201614e-02f, -1.16520934e-02f, 2.27424223e-02f, 1.06722061e-02f, 6.52666837e-02f, -3.22396085e-02f,
  4.45125476e-02f, 1.44940941e-02f, 3.63020860e-02f, -1.51720103e-02f, 1.80087853e-02f, -1.02447376e-01f, 4.66638617e-03f, -2.47137062e-02f, 1.31600751e-02f, -9.93266143e-03f,
  -2.68886909e-02f, 6.91380352e-02f, -5.42530045e-02f, 2.76098642e-02f, 8.56834576e-02f, -5.20297792e-03f, 1.81523524e-02f, 5.88566922e-02f, 6.84144953e-03f, -1.07259788e-01f,
  -2.03501042e-02f, 1.98032051e-01f, -1.41377181e-01f, 2.08864398e-02f, -4.27309573e-02f, -3.14560793e-02f, -5.23572266e-02f, 3.22135463e-02f, -3.12662534e-02f, -4.31703217e-02f,
  1.08675912e-01f, 5.12455218e-02f, -5.66912889e-02f, 3.83245945e-02f, 4.31757346e-02f, -4.36212085e-02f, -4.74664941e-02f, -2.93335635e-02f, 1.04062883e-02f, -1.39267340e-01f,
  2.07790975e-02f, -3.25118601e-02f, 1.47834886e-02f, -4.23535667e-02f, 5.41712828e-02f, 1.33443743e-01f, -7.77769927e-03f, -5.22951670e-02f, 1.04426622e-01f, -7.73246884e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.88675976e-01f, 3.81648801e-02f, 2.35710397e-01f, -2.04454720e-01f, -2.32495904e-01f, -7.76862726e-02f, 9.20254588e-02f, -1.91628903e-01f, -1.88314989e-01f, -3.28490399e-02f,
  8.86355788e-02f, -2.02616895e-04f, 3.58525217e-02f, 7.65048712e-02f, 3.96580249e-02f, 1.70271426e-01f, -3.52518894e-02f, -1.09635971e-01f, -1.13238633e-01f, -2.81092405e-01f,
  -1.78113639e-01f, -1.85751438e-01f, -3.07986498e-01f, -1.66570649e-01f, -5.99727444e-02f, 1.04299318e-02f, 6.28243834e-02f, -1.06922381e-01f, -1.61785647e-01f, 6.24294281e-02f,
  6.34916782e-01f, -1.49184793e-01f, 1.09131811e-02f, -2.08075628e-01f, 6.58157170e-02f, -8.73109847e-02f, 6.11559637e-02f, -5.07110246e-02f, -7.53704784e-03f, 3.94739322e-02f,
  -3.94582823e-02f, -1.18279524e-01f, -4.77333600e-03f, -5.84995784e-02f, 1.00656068e-02f, -7.55358040e-02f, -1.27668694e-01f, -1.39762700e-01f, -1.03781991e-01f, 6.78946078e-02f,
  -1.55291423e-01f, -1.38494864e-01f, 5.57656437e-02f, -1.93037074e-02f, -1.11831099e-01f, -1.61563396e-01f, 1.47154346e-01f, -1.38160080e-01f, -1.43303275e-01f, -6.18404038e-02f,
  -1.16095329e-02f, 7.46901929e-02f, 2.73314212e-02f, -5.03551885e-02f, -2.85349898e-02f, 5.99093921e-02f, 9.05848294e-03f, 2.03470923e-02f, -1.39997452e-02f, -9.64477938e-03f,
  1.05494121e-02f, 6.22841418e-02f, 2.29159798e-02f, 1.78649463e-02f, 5.21085300e-02f, -4.76729311e-02f, -9.35548842e-02f, 3.53337936e-02f, -4.64015603e-02f, -1.01868130e-01f,
  -8.51764455e-02f, -1.08173667e-02f, 6.10499680e-02f, -3.60596739e-02f, -1.33668920e-02f, 7.04935705e-03f, -3.61811817e-02f, -1.97916944e-02f, -4.90599908e-02f, -8.03880543e-02f,
  3.16757441e-01f, -1.73226640e-01f, 1.91731736e-01f, -5.70007898e-02f, 9.78963599e-02f, -6.56989887e-02f, 8.47842544e-02f, -8.90562013e-02f, 4.29105163e-02f, -3.41057479e-02f,
  -5.73542081e-02f, -5.85819595e-02f, 5.43123484e-02f, 2.11524013e-02f, -7.49012157e-02f, -5.09432554e-02f, -1.47523329e-01f, 1.16848543e-01f, -4.69368137e-02f, 2.12852992e-02f,
  -7.67988935e-02f, -3.98537181e-02f, 1.48672506e-01f, 1.66493505e-01f, 7.80476034e-02f, 9.73864719e-02f, 2.65568703e-01f, 1.33247778e-01f, 1.13474101e-01f, 2.32356071e-01f,
  -1.21556312e-01f, 4.26597744e-01f, -4.68222201e-02f, -5.40663861e-03f, 2.86581725e-01f, 1.75774649e-01f, 1.26349658e-01f, -1.76670134e-01f, -2.21351042e-01f, 2.14198291e-01f,
  2.30786860e-01f, -1.88811086e-02f, -1.06589757e-01f, -6.11894503e-02f, -2.13901654e-01f, 4.17552665e-02f, -4.80464054e-03f, -2.89903373e-01f, -4.99622047e-01f, -1.30410805e-01f,
  -3.27169001e-02f, -6.67109564e-02f, -3.25835824e-01f, -9.62533876e-02f, 1.77088574e-01f, -7.11277798e-02f, 1.37643754e-01f, 2.36177146e-01f, 2.57560104e-01f, 2.98476338e-01f,
  9.78194326e-02f, 3.27826768e-01f, -2.80787528e-01f, 1.00971244e-01f, 1.54324904e-01f, -1.29572794e-01f, 2.49456782e-02f, -1.59619935e-02f, 6.91729691e-03f, -4.99386564e-02f,
  2.02140361e-01f, 3.67046408e-02f, 1.18329681e-01f, -1.75842345e-02f, -1.19235210e-01f, -1.47143364e-01f, -1.46642432e-01f, -1.71229526e-01f, -2.01220319e-01f, -6.59347922e-02f,
  1.95289060e-01f, 2.55419791e-01f, 4.08449350e-03f, 5.49154915e-02f, -1.99527480e-04f, -2.44681053e-02f, 3.16272043e-02f, 9.15887579e-02f, 2.49207783e-02f, 9.59657878e-02f,
  -4.21422832e-02f, 5.32911792e-02f, 9.11854506e-02f, 8.22528172e-03f, 6.02975637e-02f, 1.97164267e-02f, 9.04631540e-02f, 5.80736063e-03f, -3.33507657e-02f, -2.32537854e-02f,
  -4.12843302e-02f, 3.27052735e-02f, -6.19874671e-02f, -3.95996794e-02f, 1.55270826e-02f, 8.69636461e-02f, -5.20463809e-02f, 2.08251290e-02f, -6.95424601e-02f, 1.81523412e-02f,
  -5.60059734e-02f, 3.09288297e-02f, -5.14442660e-02f, -2.08620839e-02f, 1.18982084e-01f, -3.03542055e-02f, 6.34196326e-02f, -2.05633361e-02f, 4.57700193e-02f, 1.59084991e-01f,
  -3.79117489e-01f, -2.43453886e-02f, -7.74015337e-02f, -3.71458717e-02f, 4.47699465e-02f, -1.97369549e-02f, 6.03574850e-02f, 9.44022276e-03f, 5.67761622e-02f, -1.11138532e-02f,
  6.36805687e-03f, -3.50934565e-02f, 6.83947355e-02f, -4.42573950e-02f, -1.31620958e-01f, -2.44163238e-02f, 8.24561063e-03f, -5.75986840e-02f, -9.24800411e-02f, -2.84988619e-02f,
  -5.30684292e-02f, -1.86999023e-01f, -2.87958562e-01f, -1.75415665e-01f, 2.46532005e-03f, -7.30338022e-02f, -2.27736905e-02f, -3.84484790e-02f, -2.05450013e-01f, -2.90941477e-01f,
  4.21574056e-01f, 5.31802237e-01f, 3.05285662e-01f, 5.48637807e-02f, -8.55342224e-02f, 1.78556308e-01f, 3.88344675e-01f, 1.85699806e-01f, -7.59718493e-02f, -6.16086945e-02f,
  4.87015136e-02f, -2.32599080e-01f, -1.41442388e-01f, -1.34752378e-01f, 9.94811952e-02f, 9.49886814e-02f, -4.19162512e-02f, 9.98450220e-02f, -1.00103334e-01f, -6.70140386e-02f,
  -6.29122034e-02f, 1.27948215e-02f, 1.29134715e-01f, -5.08260094e-02f, -9.87835899e-02f, -2.58849591e-01f, 9.87693369e-02f, 1.22568481e-01f, -4.71156612e-02f, -8.39245096e-02f,
  -4.72598113e-02f, 5.65731764e-01f, -2.59588957e-01f, -2.22573400e-01f, -1.74707863e-02f, -2.98671629e-02f, 8.78919102e-03f, 1.20085885e-03f, -1.59490686e-02f, -5.95516451e-02f,
  -6.97293431e-02f, 1.42535726e-02f, 3.55318114e-02f, 1.09853465e-02f, 7.96238035e-02f, 3.11972648e-02f, -1.69141204e-04f, 1.67761430e-01f, 2.11332943e-02f, 5.07524610e-02f,
  -2.17787605e-02f, 1.12901758e-02f, 2.45071620e-01f, 3.17348912e-02f, 5.01978882e-02f, -1.27800986e-01f, 1.57587543e-01f, 4.78596389e-02f, -3.39675918e-02f, -3.16130929e-02f,
  -1.11636557e-01f, -3.22040506e-02f, -1.73010733e-02f, 1.00947730e-01f, -6.97348863e-02f, -3.35003920e-02f, 3.16309854e-02f, 8.22188053e-03f, -1.86400134e-02f, -1.32660177e-02f,
  4.11636159e-02f, -1.64162852e-02f, 5.05632758e-02f, 1.35564860e-02f, -1.32867470e-01f, 5.62647879e-02f, 6.53073117e-02f, -5.38099697e-03f, 1.83476415e-02f, 1.04693240e-02f,
  -5.28006405e-02f, 3.25476639e-02f, 3.78381312e-02f, 3.42996679e-02f, 1.76900160e-02f, -1.14744576e-02f, 7.24662023e-05f, -1.52555555e-02f, -3.89620475e-02f, -4.52828445e-02f,
  -3.45703185e-01f, 1.46182880e-01f, -1.83004171e-01f, -7.16870949e-02f, 5.63075505e-02f, -1.85126737e-02f, -4.68813293e-02f, -2.68065929e-02f, 3.65782417e-02f, 2.91898865e-02f,
  5.48582599e-02f, -2.31018779e-03f, 1.22483194e-01f, 3.28566134e-03f, -3.43135484e-02f, -7.64160976e-02f, -5.55160716e-02f, 7.05507910e-03f, -4.40266021e-02f, -1.83824170e-02f,
  -5.81976287e-02f, -1.40023232e-01f, -1.59887880e-01f, -1.32794335e-01f, -5.91500327e-02f, -2.51241207e-01f, -1.60317734e-01f, -8.72651637e-02f, -7.64557570e-02f, -2.62936115e-01f,
  -3.53639126e-02f, 1.51052043e-01f, 6.20235540e-02f, 1.90792009e-01f, 3.44283849e-01f, 3.73315215e-01f, 3.73459607e-01f, 2.61213303e-01f, 9.31801572e-02f, 1.57364637e-01f,
  2.33741626e-01f, 2.74174184e-01f, 2.66971707e-01f, 1.34415329e-01f, 1.82603762e-01f, 2.05720738e-01f, 9.26822126e-02f, -3.37253064e-02f, 9.50775445e-02f, 9.08863693e-02f,
  1.39484555e-01f, 4.23020162e-02f, -1.13138057e-01f, -3.36230546e-02f, 5.50042428e-02f, 1.37488484e-01f, -1.00540249e-02f, 1.05796754e-01f, -3.29734720e-02f, 3.34120169e-02f,
  -7.47251213e-02f, 1.48895651e-01f, 9.46513563e-02f, 7.47573227e-02f, 2.83034630e-02f, -1.91190019e-01f, 2.22489936e-03f, -1.84749082e-01f, -4.46460135e-02f, -1.54245794e-01f,
  -1.18252777e-01f, -1.78316534e-01f, 1.03845149e-01f, -9.05305892e-02f, -1.03798978e-01f, -7.05117285e-02f, -1.35260224e-01f, 3.36700119e-02f, -2.14582458e-02f, 3.07506211e-02f,
  -2.66826134e-02f, -2.68313754e-02f, -8.45317766e-02f, 1.55479293e-02f, 1.67791799e-01f, 4.02487740e-02f, -6.93333987e-03f, -8.09740722e-02f, -2.04471350e-02f, -1.97502285e-01f,
  3.68010513e-02f, 1.78373642e-02f, 7.20840842e-02f, -8.94730017e-02f, 7.33392909e-02f, 1.94398928e-02f, 2.13679429e-02f, 5.82163818e-02f, 1.01632245e-01f, -3.50883640e-02f,
  2.10993942e-02f, 8.62414425e-04f, 6.34771809e-02f, 6.24433309e-02f, 4.11354825e-02f, -2.21503414e-02f, -3.57407592e-02f, 3.02277487e-02f, -4.57747653e-02f, -6.15915097e-02f,
  6.71245232e-02f, 8.05525947e-03f, -1.08948797e-01f, -4.73018847e-02f, -4.10799310e-02f, 5.57541735e-02f, -1.03205852e-01f, -5.17080575e-02f, 4.48723771e-02f, -6.51437417e-02f,
  -1.92069933e-02f, 2.67505735e-01f, 3.96692269e-02f, 4.09053080e-02f, 2.50883643e-02f, -1.59560785e-01f, 5.78830764e-02f, -4.83537801e-02f, -1.31692931e-01f, -1.26771674e-01f,
  -1.65936314e-02f, -5.47719710e-02f, 3.43574807e-02f, -8.80512893e-02f, -7.11409748e-02f, -1.30550548e-01f, 1.03039332e-02f, 8.04102346e-02f, 5.82354851e-02f, -6.57999516e-02f,
  2.97280140e-02f, -1.96266716e-04f, -5.94602413e-02f, -2.50624251e-02f, 1.55025110e-01f, 1.16239786e-01f, -3.99923250e-02f, -1.77908033e-01f, -5.94162494e-02f, -1.91846266e-01f,
  7.57807672e-01f, -1.65932495e-02f, 3.42219710e-01f, 6.01275116e-02f, -3.21122229e-01f, -2.39930004e-01f, -4.18875992e-01f, -1.03127740e-01f, -8.32246095e-02f, -2.87800981e-03f,
  -3.88505012e-02f, 3.11036780e-02f, 1.69905141e-01f, 1.58253491e-01f, 1.68512762e-01f, -4.73324955e-02f, 6.60389587e-02f, 3.28429371e-01f, 3.33791792e-01f, 9.94964093e-02f,
  -1.72889784e-01f, 1.84187353e-01f, 3.13123792e-01f, 6.16491437e-02f, -9.60003957e-03f, -3.80072594e-02f, -5.54919913e-02f, -9.58794728e-03f, 2.89960466e-02f, 2.86285162e-01f,
  2.20868051e-01f, 1.99708700e-01f, 1.37996785e-02f, 2.29925197e-02f, 1.42562807e-01f, 6.57292753e-02f, -7.35333934e-02f, 3.74847837e-02f, 8.00446980e-03f, -7.43184388e-02f,
  -6.18679449e-02f, 5.15195392e-02f, -7.44208694e-02f, -5.94587103e-02f, -5.55818118e-02f, 2.48643011e-02f, 1.94869228e-02f, 1.19943604e-01f, 1.15559354e-01f, -2.66514122e-02f,
  -1.02199636e-01f, -1.30866379e-01f, -1.62013665e-01f, -1.03130370e-01f, 7.41386367e-03f, 7.77654815e-04f, -6.81048706e-02f, -4.52248529e-02f, 1.08787818e-02f, 8.18886980e-02f,
  7.08943754e-02f, 8.51436034e-02f, -9.15194955e-03f, -7.51023972e-03f, 6.28778487e-02f, -7.23642707e-02f, -8.78974516e-03f, -7.88901746e-02f, -3.80811468e-02f, -5.55288838e-03f,
  -2.00351220e-04f, -1.97773967e-02f, -5.64957038e-02f, -5.35022579e-02f, 9.61782187e-02f, -5.23533039e-02f, -7.27883354e-02f, 8.92684236e-02f, -1.78269502e-02f, -2.65552104e-03f,
  2.82027796e-02f, 1.12038590e-02f, -3.36883292e-02f, 4.04660217e-02f, 4.72035781e-02f, 3.31998132e-02f, -6.10375814e-02f, -1.22716419e-01f, 4.26199064e-02f, 3.94343585e-02f,
  -2.41432831e-01f, 9.75267738e-02f, 2.12259606e-01f, 1.12770386e-01f, 1.03471903e-02f, 1.45377234e-01f, 9.16331261e-02f, -5.02403155e-02f, 2.37513538e-02f, -4.41530980e-02f,
  -5.36606461e-02f, 8.40960369e-02f, 1.06405199e-01f, 3.66611630e-02f, -1.04525916e-01f, -4.54046987e-02f, -3.83738950e-02f, 4.01876587e-03f, 2.40089837e-02f, 4.88901697e-03f,
  1.34988399e-02f, -2.23204598e-01f, -9.56073031e-02f, -1.20669037e-01f, -1.49930239e-01f, -9.22485664e-02f, -1.12347163e-01f, -1.42782301e-01f, -1.44675195e-01f, -1.94637671e-01f,
  2.00516298e-01f, -4.58185300e-02f, 1.59402788e-01f, 1.86378747e-01f, -1.79817051e-01f, -4.88524675e-01f, -7.01965213e-01f, -4.73336250e-01f, -7.77014196e-02f, 2.57844746e-04f,
  -1.44545242e-01f, -2.27324180e-02f, -9.98933055e-03f, -5.27013466e-02f, -2.13206008e-01f, 1.83411092e-02f, 1.72091320e-01f, 3.15403253e-01f, -5.83754443e-02f, -1.85601041e-01f,
  3.12591977e-02f, 2.08520845e-01f, 2.29689091e-01f, 7.62106106e-02f, 7.45060518e-02f, -3.24631669e-02f, 1.87319994e-01f, 1.44569948e-01f, 4.04499322e-02f, 5.46644092e-01f,
  2.59437948e-01f, -2.38467548e-02f, -6.73194602e-02f, 6.32066280e-02f, 1.48785323e-01f, 6.70692623e-02f, -7.60557801e-02f, 1.94831416e-01f, -9.99024045e-03f, 2.28476468e-02f,
  1.09707005e-01f, -4.23826501e-02f, 4.75965068e-02f, 1.91932432e-02f, -1.44442141e-01f, -5.77544011e-02f, 7.46683031e-02f, 6.32803738e-02f, 1.18068576e-01f, 3.14792916e-02f,
  -4.92997002e-03f, 4.36886959e-02f, -9.20160487e-02f, -1.61926940e-01f, -8.73999372e-02f, 1.53303102e-01f, -1.19760849e-01f, -1.62358452e-02f, -1.67760894e-01f, 1.23743460e-01f,
  -8.72153416e-02f, 3.62838097e-02f, -7.32738003e-02f, 4.37655561e-02f, -7.96504468e-02f, 3.92053872e-02f, 7.20087066e-02f, -5.41870855e-02f, 1.59091149e-02f, 1.53400125e-02f,
  1.82746593e-02f, -2.53358856e-02f, 1.36433942e-02f, 5.41574806e-02f, 3.89675573e-02f, 3.86769548e-02f, 1.12286890e-02f, -2.77551170e-02f, -2.36665667e-03f, 3.08301728e-02f,
  1.45463441e-02f, -1.25994291e-02f, 1.54342964e-01f, -2.23569218e-02f, 3.07447203e-02f, 6.76686764e-02f, 7.44829029e-02f, -2.73307376e-02f, -4.24553342e-02f, 4.56072092e-02f,
  -1.00625128e-01f, -1.29189357e-01f, 1.23356007e-01f, 2.40563508e-02f, 1.77480727e-02f, -6.35534152e-02f, 4.97834533e-02f, -2.61295736e-02f, 3.19855660e-02f, -1.37001593e-02f,
  -1.55441970e-01f, -9.48361456e-02f, -1.31448284e-02f, -7.04803243e-02f, -4.10114601e-02f, -1.99718043e-01f, -1.65663883e-02f, -6.00296259e-02f, -6.82458356e-02f, -5.75711317e-02f,
  -2.14490254e-04f, -3.05368781e-01f, -2.79548615e-01f, -2.88079768e-01f, -1.49470940e-01f, -1.67878464e-01f, -1.61019102e-01f, -1.47146314e-01f, -2.84447014e-01f, -2.45958045e-01f,
  -1.24885842e-01f, 4.81470898e-02f, -3.36697623e-02f, 1.36210740e-01f, -7.17763277e-03f, -9.68745910e-03f, -3.55856819e-03f, -2.70154942e-02f, -8.37319647e-04f, 4.00983207e-02f,
  -8.06036219e-02f, -6.04201518e-02f, 4.82280180e-02f, -4.63428423e-02f, 6.50940835e-02f, 6.74767047e-02f, 1.04832128e-01f, 1.74509749e-01f, 1.22559242e-01f, 1.43100545e-01f,
  1.93387941e-01f, 6.46181777e-02f, -6.99076504e-02f, -2.66020950e-02f, 2.75971264e-01f, 1.77077413e-01f, 3.01598441e-02f, 7.09264353e-02f, 1.39748767e-01f, 3.72233510e-01f,
  6.51643649e-02f, -9.60479528e-02f, -6.68860078e-02f, -1.29355602e-02f, 4.89815930e-03f, 1.58740301e-02f, -1.02692405e-02f, -7.34300613e-02f, -1.25729069e-01f, 8.71551782e-02f,
  4.09724601e-02f, -5.75393401e-02f, -3.99748571e-02f, -4.97272909e-02f, -1.18444219e-01f, 4.51815166e-02f, 1.69890579e-02f, 3.52315158e-02f, -1.82230100e-02f, -3.75573374e-02f,
  1.49919063e-01f, 8.64869654e-02f, -9.20656845e-02f, -6.75843135e-02f, 4.35468666e-02f, -6.73873350e-02f, -8.89398977e-02f, -3.28197107e-02f, -1.45961851e-01f, 9.34603214e-02f,
  3.40857990e-02f, -1.51128143e-01f, 6.58895299e-02f, 1.86643116e-02f, 5.15734926e-02f, -1.34032285e-02f, 7.35645927e-03f, 7.40709454e-02f, -1.41506828e-02f, 3.80492993e-02f,
  -7.46136720e-05f, -1.66013073e-02f, 2.88106082e-03f, 6.13949299e-02f, -2.18266551e-03f, -3.27304006e-02f, 2.14900970e-02f, -3.37515734e-02f, -7.89834410e-02f, -6.29274547e-02f,
  -1.93477713e-03f, 1.54760266e-02f, 4.68496010e-02f, -4.54716869e-02f, -5.24496287e-02f, 7.19426349e-02f, -3.42247239e-03f, -4.46525589e-03f, 6.89057782e-02f, 3.39701436e-02f,
  -1.26369715e-01f, -1.92992628e-01f, -2.33041234e-02f, -4.79633510e-02f, -3.97161953e-02f, -6.54864982e-02f, 4.39209491e-02f, 8.16068985e-03f, -8.46229941e-02f, -7.17621446e-02f,
  6.15717061e-02f, 3.35576981e-02f, -8.71582329e-03f, 2.94968784e-02f, 4.99062389e-02f, -7.38041028e-02f, 7.63719948e-03f, -7.20901787e-02f, -9.65742692e-02f, -1.39560506e-01f,
  3.54459770e-02f, -1.22785755e-01f, -1.53306037e-01f, -1.26793593e-01f, -1.16802333e-02f, 2.63342652e-02f, -4.36384901e-02f, -7.47170895e-02f, -6.07463121e-02f, -1.60583436e-01f,
  -1.82548221e-02f, -3.31454091e-02f, -8.04823577e-01f, -7.04904785e-03f, -4.15133089e-01f, -4.05936033e-01f, -2.30392188e-01f, 2.41631031e-01f, 1.55210599e-01f, -6.14268668e-02f,
  3.23213004e-02f, 1.25292940e-02f, 2.40044557e-02f, -8.73596035e-03f, -7.36660957e-02f, -3.65354419e-01f, -3.99782777e-01f, -4.12661314e-01f, -3.15944791e-01f, -1.59543246e-01f,
  -9.99903604e-02f, -6.75356239e-02f, 1.53563609e-02f, 3.74385901e-02f, -1.86689012e-02f, 4.14224118e-02f, -7.70073384e-02f, -2.50324368e-01f, -1.18397430e-01f, -3.10115606e-01f,
  -4.66617167e-01f, -1.47364393e-01f, -1.37785465e-01f, 6.73317164e-02f, -7.32905492e-02f, -1.10118994e-02f, 2.77886563e-03f, -7.30102584e-02f, 5.69817005e-03f, 5.19079901e-02f,
  -1.18863776e-01f, -1.13735415e-01f, -1.31811291e-01f, -1.35193439e-02f, -6.33588433e-02f, -7.62523487e-02f, 7.22866179e-03f, -2.33820945e-01f, -9.08666998e-02f, -1.10094868e-01f,
  -1.57143980e-01f, -3.73771518e-01f, -1.25289708e-01f, 9.38021243e-02f, -1.09203711e-01f, -2.29099810e-01f, -1.65667534e-02f, 8.09015241e-03f, -1.12891786e-01f, 2.44508103e-01f,
  1.03207640e-01f, 2.45332438e-02f, -6.11028858e-02f, 8.50912035e-02f, 1.10973433e-01f, 1.96374469e-02f, 2.20967010e-02f, 1.71624254e-02f, 2.65208017e-02f, 4.28218730e-02f,
  8.07970390e-02f, -5.36696762e-02f, -3.07161757e-03f, 5.96046150e-02f, -4.48244587e-02f, -5.05853221e-02f, -2.83390563e-02f, 7.00792745e-02f, -2.45715808e-02f, -3.42943030e-03f,
  -3.56912240e-02f, -4.54150885e-02f, 6.67375512e-03f, 1.29651666e-01f, -1.13480322e-01f, -3.96935083e-02f, 1.53055592e-02f, 5.36374748e-02f, 4.31147702e-02f, -1.02342889e-01f,
  5.16201794e-01f, -2.24230245e-01f, 8.66634846e-02f, 9.15144086e-02f, -7.35016763e-02f, 9.16185044e-03f, -1.66133996e-02f, 9.53199565e-02f, -2.39121541e-03f, -7.46497586e-02f,
  -6.75155297e-02f, -2.00820193e-02f, 1.63209960e-02f, 3.49943489e-02f, -4.05759998e-02f, -9.66035873e-02f, 8.90577510e-02f, -6.97345585e-02f, -7.66172260e-02f, -2.66231988e-02f,
  1.17668241e-01f, 6.42082766e-02f, 1.68759171e-02f, 1.49473082e-02f, 2.38350569e-03f, -1.14428602e-01f, -5.64783439e-03f, -5.23565114e-02f, 2.09897812e-02f, 4.10127282e-01f,
  -3.90657455e-01f, -9.68436152e-02f, -1.10747695e-01f, -1.58162624e-01f, 1.51885659e-01f, -8.95159170e-02f, -2.66244709e-01f, -2.42303208e-01f, -5.92443421e-02f, 3.10538914e-02f,
  2.34318927e-01f, 1.27135366e-01f, -4.43188474e-02f, -1.39526471e-01f, -3.95277888e-01f, -3.41860741e-01f, -2.83141077e-01f, -2.97989756e-01f, -3.31073970e-01f, -7.96886384e-02f,
  1.45816758e-01f, -2.00134832e-02f, -1.82534888e-01f, -1.53316796e-01f, 5.17095663e-02f, 7.05456063e-02f, -6.24042340e-02f, -8.45451355e-02f, 1.27264857e-01f, -1.66962352e-02f,
  1.33090481e-01f, -9.48395655e-02f, 6.55517802e-02f, 7.04496577e-02f, 2.25253224e-01f, -8.66470858e-02f, -2.96984203e-02f, -3.75319310e-02f, 1.25158191e-01f, -6.32620081e-02f,
  9.94195938e-02f, 2.79783737e-02f, 4.50047515e-02f, 2.77690925e-02f, -7.32451677e-02f, -8.10820311e-02f, -1.35603696e-01f, -2.34738231e-01f, -9.14193690e-02f, -5.95926382e-02f,
  9.26230624e-02f, 5.45831732e-02f, -1.78391188e-01f, -6.74703941e-02f, -1.37337208e-01f, 9.08303633e-03f, 5.03412895e-02f, -9.82866734e-02f, -1.75759941e-01f, -3.77532572e-01f,
  5.96351139e-02f, 6.26585856e-02f, 2.24336255e-02f, 9.85252019e-03f, -4.15956303e-02f, 6.07333370e-02f, -1.49060292e-02f, 1.45216575e-02f, -3.71290185e-02f, -4.52447273e-02f,
  -1.63262952e-02f, 4.93189842e-02f, -6.24208013e-03f, -6.34684637e-02f, 5.86989510e-04f, -6.16821786e-03f, 1.83852017e-02f, -1.06471002e-01f, -4.67435755e-02f, 1.91584732e-02f,
  -8.52254257e-02f, 2.48253495e-02f, 8.56074020e-02f, -7.23516494e-02f, -2.87923329e-02f, -2.71122959e-02f, -3.31312120e-02f, 4.43310058e-03f, -4.22370508e-02f, -1.69375632e-02f,
  -2.22794145e-01f, 2.25453451e-01f, -4.68451269e-02f, -1.33041427e-01f, 7.35468417e-03f, 9.91931185e-02f, 1.22755274e-01f, 7.45050190e-03f, 4.10271548e-02f, -1.47057012e-01f,
  1.82620678e-02f, -6.63426667e-02f, -7.71808922e-02f, -8.65691062e-03f, -3.49900983e-02f, -4.37607281e-02f, -3.51851024e-02f, -5.11368141e-02f, -8.36470202e-02f, 9.66614783e-02f,
  -1.05892330e-01f, -1.87860698e-01f, -3.09178174e-01f, -1.73105329e-01f, -1.33485690e-01f, -2.09465981e-01f, -2.79474199e-01f, -2.94285208e-01f, -3.82775724e-01f, -5.40286958e-01f,
  -1.67612359e-01f, -6.39604151e-01f, -1.04608633e-01f, -2.01123431e-01f, -3.16585451e-01f, -1.63800955e-01f, -5.32257855e-01f, -3.34021486e-02f, -7.75827542e-02f, -3.99197161e-01f,
  -1.63827643e-01f, 8.94763768e-02f, 6.21837974e-02f, 1.80136189e-01f, 1.12770841e-01f, -4.22875047e-01f, -2.70351589e-01f, 2.03148872e-02f, 3.06534231e-01f, 6.94226474e-02f,
  -2.31919177e-02f, -1.10128209e-01f, 1.94065258e-01f, 3.09164133e-02f, -1.49360955e-01f, 3.53857838e-02f, -2.41614759e-01f, -1.70909837e-01f, -1.84439078e-01f, -4.11836416e-01f,
  -2.68738740e-03f, 8.33620038e-03f, 1.48994789e-01f, 6.53690100e-02f, -9.92834419e-02f, 5.42194508e-02f, -8.15442502e-02f, 5.14051206e-02f, 4.04364206e-02f, -3.42894234e-02f,
  3.79126556e-02f, 1.05120853e-01f, 1.15678370e-01f, -2.02746876e-02f, -3.00380029e-02f, -1.95907243e-02f, 6.59174100e-02f, 7.54379630e-02f, 8.88585597e-02f, 2.48475371e-05f,
  -8.08983594e-02f, -4.95378338e-02f, 7.39516839e-02f, 8.56054723e-02f, 1.32394239e-01f, 1.05818331e-01f, -7.04908371e-02f, 7.34697282e-02f, 9.97591913e-02f, -3.30332607e-01f,
  -9.32939649e-02f, -7.45838881e-03f, 7.86039680e-02f, -1.03599858e-02f, -1.10645462e-02f, 2.79684644e-02f, -1.01182871e-02f, -4.75271270e-02f, 7.64675206e-03f, -6.66199699e-02f,
  5.22676557e-02f, 2.56973924e-03f, -5.11740744e-02f, 9.42537189e-03f, 4.49448032e-03f, 5.94264492e-02f, -5.37863746e-02f, -5.60531542e-02f, -2.98556332e-02f, 2.60372134e-03f,
  3.18393186e-02f, 1.28132263e-02f, -6.59255747e-05f, 4.10110727e-02f, 1.83387622e-02f, -6.31439015e-02f, 9.13033076e-03f, 1.26674920e-01f, 2.76879147e-02f, 7.14821443e-02f,
  -3.09391487e-02f, 3.61356050e-01f, -1.29336014e-01f, 7.45545328e-02f, 3.27907652e-02f, -5.17815799e-02f, -2.81570312e-02f, 2.54473817e-02f, 1.12813003e-01f, -6.34102076e-02f,
  9.46995169e-02f, -4.56738360e-02f, -3.71125154e-02f, 3.24465404e-03f, 9.42161866e-03f, 2.86701750e-02f, -1.49371266e-01f, -2.35222448e-02f, 9.43020657e-02f, -9.05000791e-03f,
  -2.49268059e-02f, -1.35198653e-01f, -3.92991006e-02f, -1.42202079e-01f, -5.31978607e-02f, 7.41497725e-02f, -6.31667674e-02f, -2.14628875e-02f, 5.25113046e-02f, -4.54646051e-01f,
  -4.55455720e-01f, 1.48531735e-01f, 1.03657722e-01f, -2.87220031e-01f, -1.77216455e-01f, 4.77628671e-02f, 1.55074582e-01f, -7.86984339e-02f, -2.16748774e-01f, -1.40550022e-03f,
  3.81989777e-02f, -7.42418319e-02f, 7.26922322e-03f, 8.55214000e-02f, 8.34370255e-02f, 4.79219817e-02f, 4.94215731e-03f, -5.46338921e-03f, 2.33171834e-03f, -1.17502697e-01f,
  4.11379673e-02f, -1.97624102e-01f, -3.04743946e-01f, -1.52351499e-01f, -6.25181897e-03f, -8.49212408e-02f, -1.23920321e-01f, -1.71771735e-01f, 3.99901085e-02f, -9.95772928e-02f,
  4.73139077e-01f, -1.59853905e-01f, 6.24189386e-03f, -1.05927490e-01f, 3.36775668e-02f, -6.73677539e-03f, 1.50222294e-02f, -6.83019981e-02f, -8.18134472e-02f, -3.19972783e-02f,
  -8.20748657e-02f, -3.24908495e-02f, -8.50709006e-02f, -1.80427474e-03f, 2.36566383e-02f, 1.39874499e-02f, -8.76986161e-02f, -1.22627370e-01f, 9.38482508e-02f, 1.01248160e-01f,
  7.87259713e-02f, -1.09136634e-01f, -4.60278168e-02f, 7.90233612e-02f, -3.82004157e-02f, -2.00470015e-02f, -3.32984254e-02f, 2.74147578e-02f, 5.34616271e-03f, 3.71320434e-02f,
  8.24741647e-02f, -2.20676344e-02f, -5.49832620e-02f, 3.74208428e-02f, 1.45742241e-02f, -2.75621023e-02f, 4.01991345e-02f, 7.45340362e-02f, -1.16610089e-02f, 3.62800583e-02f,
  4.33607437e-02f, -2.14986335e-02f, 9.22792032e-03f, 2.27341969e-02f, -1.05792983e-02f, -4.55779694e-02f, -9.81015712e-03f, 7.74704153e-03f, 5.35186045e-02f, 9.09738336e-03f,
  -2.17790697e-02f, -6.72476813e-02f, 4.20112796e-02f, 5.62092871e-04f, -1.54230362e-02f, 6.93689957e-02f, 3.35130394e-02f, -5.85109042e-03f, -3.31159793e-02f, -1.94810927e-02f,
  1.29161686e-01f, -5.99599443e-02f, 3.33602950e-02f, -3.58173475e-02f, -1.31648079e-01f, -1.91942193e-02f, -3.70181836e-02f, -4.87191370e-03f, -5.26197292e-02f, 3.88007537e-02f,
  2.44650654e-02f, -2.03155018e-02f, 4.65548001e-02f, -1.85126136e-03f, -6.61547780e-02f, -4.85220850e-02f, 1.64977070e-02f, -6.24486133e-02f, -4.28086519e-02f, 5.73180243e-02f,
  4.00513262e-02f, -1.40614538e-02f, 1.74726099e-01f, 6.15333170e-02f, 1.62252877e-02f, -2.42698994e-02f, 1.23324886e-01f, 1.25794569e-02f, 1.71684548e-02f, 1.88930944e-01f,
  -6.64948106e-01f, 1.80127814e-01f, -1.83073610e-01f, -2.07889274e-01f, 2.66296148e-01f, 2.78596431e-01f, 4.22957540e-01f, 1.46209881e-01f, -1.30530566e-01f, 1.77473221e-02f,
  -8.70738626e-02f, -1.79170012e-01f, -6.06223308e-02f, 4.68526818e-02f, 5.81036806e-02f, 3.50774229e-01f, 2.98963875e-01f, -7.55529944e-03f, -1.17406979e-01f, -1.44942934e-02f,
  1.76566437e-01f, -1.82403713e-01f, -2.49316230e-01f, -1.76854655e-01f, -7.48295039e-02f, -3.29756700e-02f, -1.13423832e-01f, -1.01411656e-01f, 1.59901544e-01f, -1.00553327e-03f,
  -3.48590016e-01f, -4.19308126e-01f, 4.65622880e-02f, 1.67326890e-02f, -3.93486358e-02f, -4.63554636e-02f, -2.06881594e-02f, -1.84568197e-01f, -4.94674742e-02f, -5.57764657e-02f,
  -6.98433444e-02f, -9.05177668e-02f, -6.50800094e-02f, 3.53514850e-02f, -1.30803749e-01f, -1.03036411e-01f, 5.12175746e-02f, -1.30263388e-01f, 4.71989922e-02f, 1.35390060e-02f,
  2.28633806e-01f, 8.36038142e-02f, -9.02796909e-02f, 3.66392881e-02f, -1.01709284e-01f, -1.22554161e-01f, -6.75456226e-02f, 3.36391898e-03f, -1.34337008e-01f, -1.15672037e-01f,
  9.40593407e-02f, -4.96568680e-02f, -3.21835815e-03f, 1.45598734e-02f, -3.93632613e-02f, -5.41014262e-02f, 1.61774084e-02f, 6.96933568e-02f, 1.85348541e-02f, -1.99538972e-02f,
  -3.29494220e-03f, 1.65521149e-02f, -4.16487232e-02f, -3.34438868e-02f, -5.29225208e-02f, 3.66852917e-02f, 1.25469565e-01f, 1.12964306e-02f, 7.38339350e-02f, -1.10226301e-02f,
  -5.62283285e-02f, -3.65666449e-02f, -4.95030805e-02f, 5.16910013e-03f, 5.22515252e-02f, 7.35599101e-02f, 2.84668375e-02f, 2.42374316e-02f, -7.94626325e-02f, -2.25062203e-03f,
  -3.62462491e-01f, 1.88109457e-01f, -1.98402032e-02f, -3.47374566e-02f, 6.42260537e-02f, -8.88757408e-02f, -5.46281636e-02f, 5.27901798e-02f, -1.11670814e-01f, -7.09423423e-02f,
  -4.96507958e-02f, -1.35501027e-01f, 3.90814897e-03f, 5.81672080e-02f, 5.33265546e-02f, -6.98092580e-02f, 1.24180280e-01f, 5.14476374e-02f, 4.75833677e-02f, -2.06934437e-02f,
  1.35728270e-01f, 6.49241954e-02f, -1.39587924e-01f, -1.97793748e-02f, 8.28163624e-02f, -2.30809767e-02f, -4.98449383e-03f, -7.45214596e-02f, 7.55994469e-02f, 2.57901214e-02f,
  7.65212595e-01f, -5.56347430e-01f, 1.55232072e-01f, 3.04988235e-01f, 5.72564453e-03f, 1.45667136e-01f, -1.73021972e-01f, -1.03655875e-01f, 1.28969684e-01f, -1.43171236e-01f,
  -3.14700454e-01f, -1.70796111e-01f, -9.91006568e-02f, -4.00966741e-02f, 9.43631753e-02f, 6.50821719e-03f, 1.09110437e-01f, 3.93119693e-01f, 3.76877457e-01f, -2.88314521e-02f,
  -1.55800700e-01f, 3.65901403e-02f, 1.13687918e-01f, 8.83634165e-02f, -1.90117821e-01f, -9.71916318e-02f, -1.30641237e-01f, -1.62315816e-01f, -3.60989779e-01f, -2.86075264e-01f,
  -1.48956448e-01f, -1.94428429e-01f, 1.39010489e-01f, -3.12107634e-02f, -1.40069723e-01f, -1.10777169e-02f, 4.89835255e-02f, 5.99946938e-02f, 3.22268978e-02f, -1.29298046e-02f,
  1.16412146e-02f, -5.74254505e-02f, 2.41066236e-02f, -1.21521465e-01f, 1.98656209e-02f, -4.82774153e-02f, -4.64996658e-02f, -2.67420616e-02f, -7.08029745e-03f, -2.39268705e-01f,
  -2.44582385e-01f, -1.49046943e-01f, 8.56237710e-02f, -1.65743544e-03f, -1.48137689e-01f, 1.37061313e-01f, -2.32933715e-01f, -8.34862739e-02f, 4.15694080e-02f, -1.14573881e-01f,
  4.83507337e-03f, -1.26503231e-02f, -9.80517175e-03f, -7.91560486e-03f, -4.92170407e-03f, 3.87817845e-02f, 6.95455670e-02f, -2.64044153e-03f, 1.00750171e-01f, 3.80416736e-02f,
  2.16491781e-02f, 4.30613905e-02f, -7.47791352e-03f, 2.82139946e-02f, 1.76684968e-02f, -6.27790671e-03f, 1.04071632e-01f, -1.54710442e-01f, -9.94738541e-04f, 1.00782096e-01f,
  -1.88896637e-02f, 4.34476100e-02f, -2.96166586e-03f, -6.89741895e-02f, -1.17826544e-01f, -2.56706066e-02f, 4.83873338e-02f, -1.58064738e-01f, -4.16084938e-02f, 5.02277762e-02f,
  1.60511266e-02f, 1.53381094e-01f, 2.92589758e-02f, -1.16214361e-02f, 6.95145577e-02f, -1.20617911e-01f, -3.21188159e-02f, 1.78226437e-02f, -3.81889641e-02f, 2.50379350e-02f,
  -1.28582999e-01f, -1.87253859e-02f, -1.37035653e-01f, -6.88896924e-02f, 1.47429377e-01f, 3.13251391e-02f, -1.05571374e-01f, 1.40678152e-01f, -8.24034438e-02f, -1.17553055e-01f,
  -1.60762206e-01f, 2.49292076e-01f, 3.32629710e-01f, 2.40104109e-01f, -5.20846136e-02f, 3.15635175e-01f, 5.10338098e-02f, 6.03833832e-02f, 3.10502887e-01f, 2.44565293e-01f,
  -3.14919382e-01f, -5.00264652e-02f, -1.80809394e-01f, -1.74118206e-01f, 7.78231993e-02f, 5.83389737e-02f, 6.22422695e-02f, -6.34648511e-03f, -1.48221731e-01f, 3.83946523e-02f,
  4.04181182e-02f, 7.74626061e-02f, -5.11993207e-02f, 1.22409813e-01f, -3.96215245e-02f, -3.85216437e-03f, 5.54733537e-02f, 8.61200392e-02f, 8.73049349e-02f, 1.38494000e-01f,
  4.77491245e-02f, -8.30470547e-02f, -8.34857970e-02f, -6.39962181e-02f, -1.90711934e-02f, 7.20311003e-03f, -3.18316780e-02f, -2.32345294e-02f, 1.06246538e-01f, -1.50494128e-02f,
  1.70585923e-02f, -2.40127835e-03f, 2.93141380e-02f, 1.38000742e-01f, 6.09764904e-02f, -1.19549558e-01f, 3.68009172e-02f, -9.00262892e-02f, -7.28488117e-02f, 4.43612300e-02f,
  3.25426161e-02f, 6.90452307e-02f, -1.14370678e-02f, -3.79004702e-02f, 3.72262374e-02f, -1.26218544e-02f, 6.19888445e-03f, 8.89886916e-03f, -1.35810837e-01f, -6.22692192e-03f,
  1.50715336e-01f, 2.41189022e-02f, -6.20144792e-02f, 9.92703065e-03f, -1.38800487e-01f, -9.80430283e-03f, -3.76757868e-02f, -8.83204713e-02f, -1.07293829e-01f, -9.36510786e-02f,
  3.07255033e-02f, -4.14073057e-02f, -4.86255549e-02f, 5.85062318e-02f, 7.32048526e-02f, 5.33024855e-02f, 4.03424725e-02f, 3.79710831e-02f, 5.78451529e-02f, -9.42143574e-02f,
  1.53521728e-02f, 4.06509191e-02f, -1.69948880e-02f, -1.12434536e-01f, 2.30083689e-02f, 9.29058879e-04f, -8.62307101e-03f, 4.94630672e-02f, -2.62145307e-02f, -3.17681581e-02f,
  5.28315343e-02f, -2.53934003e-02f, -1.67093668e-02f, 5.60405217e-02f, -1.66827755e-04f, -2.36844644e-02f, 1.68276038e-02f, -2.55198702e-02f, -1.16184577e-01f, -6.19547628e-02f,
  -1.87999666e-01f, 2.55487561e-01f, -1.00386471e-01f, -2.59629209e-02f, -7.29540139e-02f, -6.40147924e-02f, -3.75496112e-02f, 4.99892235e-02f, 8.44246671e-02f, -7.28290295e-03f,
  -1.69814881e-02f, -1.72995101e-03f, -1.14289291e-01f, 7.20002577e-02f, -6.24861605e-02f, -5.42296097e-02f, -2.15919521e-02f, 4.41260962e-03f, -5.28014228e-02f, -5.00692874e-02f,
  -1.34129673e-02f, -1.20584138e-01f, -2.34849490e-02f, -1.24654271e-01f, -1.43441811e-01f, -2.14645434e-02f, -8.10759366e-02f, -1.43494889e-01f, -7.60238022e-02f, -1.23223618e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.75181225e-02f, 4.80019510e-01f, 1.63507134e-01f, 1.77203178e-01f, 4.15122867e-01f, 4.18354630e-01f, 6.27418384e-02f, 6.97174311e-01f, 3.15909714e-01f, 3.27292025e-01f,
  5.60052358e-02f, 3.37104827e-01f, 6.69253647e-01f, 8.06822777e-02f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.54720902e-01f, -3.58359605e-01f, 4.58891302e-01f, 3.48342389e-01f, -1.50355875e-01f, 1.06449306e-01f, 2.62589604e-01f, 2.75737584e-01f, 6.22956967e-03f, -3.95256132e-01f,
  1.75185259e-02f, -5.99793315e-01f, 1.49674267e-02f, 3.30392942e-02f, -1.53338000e-01f, 2.66934514e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.76929200e-01f, -6.26912937e-02f, 1.69121735e-02f, -1.70468837e-01f, 4.36752103e-02f, -1.49786785e-01f, -1.27224952e-01f, -2.31086224e-01f, -2.43531004e-01f, -2.08982021e-01f,
  -3.98150869e-02f, 1.19583942e-01f, 1.39960730e-02f, -1.66259542e-01f, 2.11619243e-01f, -9.23284292e-02f, 1.10288702e-01f, -5.37058949e-01f, 5.66716969e-01f, 5.84319592e-01f,
  6.84425116e-01f, 5.90067327e-01f, 3.23262215e-01f, 3.86226848e-02f, 2.17157364e-01f, 2.19522178e-01f, -3.18648100e-01f, -1.03510238e-01f, 1.96854308e-01f, -3.21304739e-01f,
  -7.19536394e-02f, -2.09473059e-01f, 3.51154692e-02f, 4.74670440e-01f, 9.00167823e-01f, 1.68046188e-02f, 3.45142901e-01f, -1.90468982e-01f, 4.25301582e-01f, 1.23023205e-01f,
  2.13778943e-01f, -3.19067575e-02f, -4.96860415e-01f, 5.55703044e-01f, 5.71403980e-01f, 4.47082296e-02f, 9.77313668e-02f, -2.90730633e-02f, 3.37327927e-01f, -4.79686186e-02f,
  9.71334353e-02f, 5.47448754e-01f, -5.01775801e-01f, 1.28910929e-01f, -2.40452796e-01f, 4.55345869e-01f, 5.33044159e-01f, -3.40168983e-01f, 4.65456039e-01f, -3.12553756e-02f,
  3.35911155e-01f, 7.23686635e-01f, -5.17446920e-02f, 1.81817174e-01f, 6.90732989e-03f, 2.60542125e-01f, 1.50711462e-01f, 3.58685911e-01f, -5.91594994e-01f, -1.07321575e-01f,
  6.22539461e-01f, 6.61632001e-01f, 3.26936156e-01f, -3.44102085e-01f, 6.53574705e-01f, 7.86493048e-02f, 2.47407585e-01f, 4.61171865e-02f, -1.08607359e-01f, 3.17402452e-01f,
  1.41488180e-01f, 7.32505143e-01f, -4.26621288e-01f, 2.20989481e-01f, 2.35031173e-01f, 5.57407498e-01f, 2.47431770e-01f, -3.02854776e-01f, -1.01958573e-01f, 4.24786747e-01f,
  3.39522392e-01f, 5.10312438e-01f, -1.96792081e-01f, 6.23711526e-01f, 1.92376956e-01f, 4.21057880e-01f, 5.93540311e-01f, -3.93892556e-01f, 5.68460941e-01f, 1.50723889e-01f,
  -3.56287777e-01f, 1.61805853e-01f, -2.79790998e-01f, 7.04723084e-03f, 1.39773488e-01f, 1.32652593e+00f, 4.10597801e-01f, -5.78129232e-01f, 5.47349691e-01f, 2.77929485e-01f,
  -3.00820053e-01f, -1.88545689e-01f, 6.27700239e-02f, 1.44159570e-01f, 2.96521872e-01f, 7.27526367e-01f, 6.00425243e-01f, 2.51074940e-01f, -4.66792017e-01f, -5.11879623e-01f,
  1.80105761e-01f, -2.69909918e-01f, 2.80171752e-01f, -1.67030007e-01f, 2.15429693e-01f, 9.09653664e-01f, 3.58246863e-02f, 2.23796546e-01f, 1.24478616e-01f, -1.12142630e-01f,
  1.50830327e-02f, 7.50235394e-02f, 1.26485527e-01f, 1.02102965e-01f, -3.88410330e-01f, 9.63840485e-02f, -5.63178472e-02f, -2.12057173e-01f, -2.28231072e-01f, -4.43857670e-01f,
  5.01676016e-02f, 5.00613391e-01f, 5.65626800e-01f, 1.73734501e-01f, 1.85235754e-01f, -7.68585980e-01f, 1.46664172e-01f, 7.96615541e-01f, 5.59099555e-01f, -5.09344220e-01f,
  7.05226421e-01f, 1.21557903e+00f, 1.54435784e-01f, -1.65284038e-01f, 3.30569327e-01f, 3.80225740e-02f, -3.37253541e-01f, -3.48529488e-01f, 1.36396408e-01f, -3.09734702e-01f,
  3.54512632e-01f, 4.28160936e-01f, 8.11161287e-03f, -2.59707451e-01f, -4.04417872e-01f, 5.75335979e-01f, -7.31961429e-02f, 9.74413678e-02f, 3.28981042e-01f, -1.95561200e-01f,
  -1.03352159e-01f, 3.58592808e-01f, -2.27406576e-01f, 3.10951293e-01f, 1.38157535e+00f, -2.21407376e-02f, -9.38140154e-02f, -1.92863762e-01f, -4.43716377e-01f, 8.26728940e-02f,
  1.55821741e-01f, 9.85612050e-02f, -5.01262806e-02f, -7.99731538e-02f, -4.32288677e-01f, 9.44011211e-01f, 9.45823193e-01f, 9.58640993e-01f, -2.44008660e-01f, -2.15874970e-01f,
  -3.56663507e-03f, 2.81655014e-01f, 6.74245775e-01f, 7.50060007e-02f, 6.59355074e-02f, -6.00239396e-01f, -4.40517329e-02f, -1.46508040e-02f, 7.94496715e-01f, 5.08024275e-01f,
  2.33520586e-02f, 4.64999467e-01f, -4.94981378e-01f, -2.02437639e-01f, -1.26462858e-02f, -8.03810209e-02f, 9.60301340e-01f, -5.04257120e-02f, -1.54668033e-01f, -2.03018542e-02f,
  1.10996597e-01f, 2.44987383e-01f, -1.52347133e-01f, 2.44322956e-01f, -2.26631582e-01f, -2.55639881e-01f, -1.10400155e-01f, 3.07586133e-01f, 4.39104527e-01f, 3.48742962e-01f,
  8.72163549e-02f, 1.57791637e-02f, -3.44183743e-01f, 1.67771101e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.66839206e-01f, 3.01050633e-01f, -1.48843169e-01f, 1.93708524e-01f, 2.40897909e-01f, 8.36147219e-02f, 6.47161603e-01f, 2.59318262e-01f, 7.78531134e-02f, 4.29821074e-01f,
  3.91907930e-01f, 4.68095988e-01f, 5.16839206e-01f, -2.02666268e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -5.53480983e-01f, 4.18438643e-01f, -1.68112308e-01f, -9.20297578e-02f, -7.88443983e-02f, -3.55397552e-01f, -2.85657436e-01f, 2.68502146e-01f, -1.33940550e-02f, -4.27156895e-01f,
  -2.27945521e-01f, -5.43471158e-01f, -2.09489763e-01f, 1.11328876e+00f, -3.82195473e-01f, 3.46844792e-01f, -4.27811921e-01f, 9.10927653e-02f, 1.70358658e-01f, 1.37288108e-01f,
  3.88925672e-01f, -6.48189604e-01f, -2.31541932e-01f, 5.89205503e-01f, -3.83294612e-01f, -2.09870160e-01f, -5.17119408e-01f, -7.76582658e-01f, 7.55750120e-01f, 2.75277466e-01f,
  6.74079776e-01f, -1.74773350e-01f, 9.02803361e-01f, -4.82074291e-01f, -1.13678537e-01f, -9.64898884e-01f, 1.92511752e-01f, 1.86102480e-01f, 6.47855580e-01f, 2.06583247e-01f,
  -6.88894629e-01f, -4.34810847e-01f, -2.41676837e-01f, 4.83543038e-01f, 2.95336753e-01f, 2.45052099e-01f, 3.76559675e-01f, -2.07546234e-01f, 3.49459440e-01f, -6.22998536e-01f,
  -6.96081445e-02f, -4.27904993e-01f, 2.47003123e-01f, 4.18254435e-01f, 1.96293771e-01f, 3.61196578e-01f, 2.36675054e-01f, 8.41333747e-01f, 1.32089019e-01f, -5.71973383e-01f,
  -5.27343750e-01f, 6.55492842e-02f, -5.06620109e-01f, 4.09666419e-01f, -6.20014630e-02f, -6.90005839e-01f, -1.22220926e-01f, 2.37025723e-01f, -2.50005960e-01f, -1.32851839e-01f,
  -8.79465044e-02f, -4.57069606e-01f, 6.68822408e-01f, -1.42405823e-01f, 7.84097910e-02f, 6.76954389e-01f, -2.47426003e-01f, 4.40775484e-01f, -6.51592910e-01f, 5.27727842e-01f,
  8.32612533e-03f, -7.20994711e-01f, -2.74674207e-01f, 1.53984949e-01f, -7.05753207e-01f, -1.88487336e-01f, -5.17495215e-01f, 2.12400332e-01f, 1.07328641e+00f, -2.39188164e-01f,
  2.41245702e-02f, -3.29954773e-01f, -1.11879840e-01f, 6.24578819e-02f, 7.88304806e-01f, -3.38336259e-01f, -1.00800738e-01f, 5.82586408e-01f, -6.56353012e-02f, 2.86655188e-01f,
  5.06433487e-01f, -1.73353076e-01f, 1.55425116e-01f, -6.00306630e-01f, -7.14420021e-01f, -4.27009672e-01f, 1.81014493e-01f, 9.86014366e-01f, -5.85897803e-01f, -9.26136017e-01f,
  4.42736149e-01f, 2.76660658e-02f, -2.73662120e-01f, 5.20317912e-01f, -2.42778938e-02f, -5.15548438e-02f, 3.28379720e-02f, 5.79862237e-01f, -3.79335438e-03f, 6.38700843e-01f,
  -3.71031404e-01f, 7.73325920e-01f, 3.32273424e-01f, -4.46644485e-01f, 3.06432754e-01f, -5.16870379e-01f, -6.12256885e-01f, 1.15576655e-01f, 4.37593549e-01f, -5.11481643e-01f,
  3.53166550e-01f, -3.36688429e-01f, -1.44332990e-01f, 9.63637009e-02f, -4.55681801e-01f, -5.14732718e-01f, -3.28134000e-01f, 2.37161964e-01f, 7.19514906e-01f, -4.89151180e-02f,
  1.07878006e+00f, -6.35119975e-01f, 4.79294121e-01f, -8.61939713e-02f, -3.31919342e-01f, 5.34297168e-01f, 1.32708460e-01f, -5.61012886e-02f, -5.98274291e-01f, 8.52073610e-01f,
  8.91285002e-01f, -1.83607236e-01f, -5.49050272e-02f, -3.85100037e-01f, -1.40991867e-01f, 5.57923794e-01f, -2.55268931e-01f, 2.64880173e-02f, -1.54789671e-01f, -2.30613589e-01f,
  3.83653700e-01f, 6.87794909e-02f, -2.30363473e-01f, 5.45158803e-01f, 9.40855563e-01f, 4.20980006e-02f, -1.32272109e-01f, -6.49871647e-01f, 7.81244993e-01f, -1.11451641e-01f,
  -1.82594702e-01f, -6.18578374e-01f, -3.40515971e-01f, -4.61663723e-01f, 1.87946349e-01f, -9.72281024e-02f, -1.16083482e-02f, 5.90364635e-01f, -1.53062567e-01f, 7.92598188e-01f,
  -1.89821869e-01f, -2.18126222e-01f, -5.49777567e-01f, 2.17883617e-01f, -6.62326932e-01f, 5.54440379e-01f, 3.00341230e-02f, 6.23417199e-01f, -6.44017637e-01f, 3.50847542e-01f,
  -6.00138128e-01f, -2.04969510e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.73637863e-02f, 6.52123289e-03f, 1.13444015e-01f, -1.24112979e-01f, 9.40404907e-02f, 4.78106827e-01f, -9.91486013e-02f, -3.69092077e-01f, 9.44695845e-02f, -2.22513914e-01f,
  -7.19554573e-02f, 1.09416336e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    