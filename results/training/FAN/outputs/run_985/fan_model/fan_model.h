/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.00533295e-01f, -2.18480960e-01f, -1.58741087e-01f, -2.61116415e-01f, 2.56330460e-01f, 2.27531016e-01f, 1.71070516e-01f, 1.31912872e-01f, -2.80851778e-02f, 3.16453762e-02f,
  2.26528533e-02f, -1.16258655e-02f, -1.19712301e-01f, 2.28490848e-02f, -4.79288921e-02f, -1.68548450e-02f, -8.55399743e-02f, -2.80574232e-01f, 1.56228691e-01f, 4.07931685e-01f,
  3.13424349e-01f, -1.00765117e-02f, -2.16255814e-01f, -4.27004993e-02f, 1.29853994e-01f, 1.01565361e-01f, -1.55670136e-01f, -1.20704316e-01f, 8.15681666e-02f, 4.13187034e-03f,
  -2.24899903e-01f, -1.48991764e-01f, 1.45398170e-01f, 1.40918240e-01f, 5.08012287e-02f, -1.16044246e-02f, 1.21312723e-01f, 4.37843315e-02f, 1.13564981e-02f, 6.53352365e-02f,
  -8.72914493e-03f, 1.11588985e-01f, -2.20072363e-02f, 1.19674183e-01f, 6.09370582e-02f, 6.50024489e-02f, 1.20494023e-01f, -1.77762646e-03f, -1.20054334e-02f, 1.52708262e-01f,
  1.78959399e-01f, -3.16857472e-02f, 1.37088110e-03f, 8.69433954e-02f, 3.73769552e-02f, -9.46480259e-02f, 9.33941975e-02f, 1.01521574e-01f, -1.98722966e-02f, 1.08419947e-01f,
  5.30571900e-02f, -8.04840252e-02f, -8.26990232e-02f, 1.63668431e-02f, -6.24053963e-02f, -6.31173998e-02f, -1.13985173e-01f, 8.47372133e-03f, -6.52297307e-03f, -1.98550206e-02f,
  -5.92957847e-02f, -4.11868468e-02f, -9.71035659e-02f, -3.53983529e-02f, -3.52186747e-02f, -9.90636051e-02f, -1.33646891e-01f, -2.56598257e-02f, -3.87014002e-02f, -4.69238982e-02f,
  -4.63869683e-02f, -1.13878652e-01f, -3.96412238e-02f, 2.01217029e-02f, -2.88933814e-02f, -5.84505461e-02f, -6.53543696e-02f, 4.78081442e-02f, -9.11986008e-02f, -3.28174345e-02f,
  4.01410274e-03f, 3.85330655e-02f, -5.03491163e-02f, 3.13491821e-02f, 1.19208405e-03f, 1.05025265e-02f, -3.72164622e-02f, -1.01787597e-02f, -4.84116785e-02f, -1.69911273e-02f,
  3.39185148e-02f, -7.90868476e-02f, -3.58678699e-02f, -7.13412315e-02f, 4.97558899e-02f, 1.51236672e-02f, 1.43097369e-02f, 6.71649203e-02f, 2.63438858e-02f, -6.22769957e-03f,
  -2.30244212e-02f, 8.16707779e-03f, -9.39939022e-02f, 1.91730708e-02f, -8.05132743e-03f, -2.07300298e-02f, 5.23264073e-02f, 5.66346236e-02f, -5.19409068e-02f, 1.44659653e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.39071584e-01f, 1.86274853e-02f, -5.06219208e-01f, -3.90471965e-01f, -2.37861544e-01f, -1.97672173e-01f, -1.56064117e-02f, 3.60356927e-01f, 1.94411427e-01f, -1.59231335e-01f,
  -1.20117091e-01f, -2.64700234e-01f, -3.81107628e-01f, -5.09966947e-02f, -2.73362100e-01f, -3.27940255e-01f, -7.18895376e-01f, -6.93035126e-01f, -2.45208979e-01f, 4.06267136e-01f,
  1.13786355e-01f, -5.15209496e-01f, -5.21395564e-01f, -2.19795674e-01f, -2.23604083e-01f, -3.35549980e-01f, -6.89523816e-01f, -5.05657494e-01f, -3.13107789e-01f, -6.63366020e-01f,
  -5.53020597e-01f, 1.53893650e-01f, 7.54975826e-02f, 5.48921041e-02f, -2.11518884e-01f, 5.47560416e-02f, 5.02409227e-02f, -1.07538275e-01f, 1.74611830e-03f, -1.04460590e-01f,
  -1.62900075e-01f, 3.44388574e-01f, -2.52184778e-01f, -1.18951812e-01f, -1.47826925e-01f, -6.95778430e-02f, -1.13264240e-01f, -6.78325817e-02f, -1.56463385e-02f, 1.59330711e-01f,
  4.89787981e-02f, -3.81855816e-01f, -3.65123004e-01f, 1.42592907e-01f, 1.11581080e-01f, -1.12237437e-02f, 2.31681943e-01f, 2.07072869e-01f, -1.25237912e-01f, 7.10738078e-02f,
  2.39528194e-01f, -1.23817148e-02f, 1.10822998e-01f, 1.96037367e-01f, -1.45546108e-01f, 1.91418342e-02f, -1.42132565e-01f, 1.88424364e-01f, 5.95444860e-03f, -7.31412023e-02f,
  1.60748020e-01f, -1.49705866e-02f, 1.38367144e-02f, -7.86070824e-02f, -1.51696399e-01f, -5.27548641e-02f, 7.17033595e-02f, 3.22877392e-02f, -6.58043660e-03f, 3.53466980e-02f,
  1.85685322e-01f, -7.14757517e-02f, -4.66962792e-02f, 8.51619169e-02f, -1.78104993e-02f, -1.67570531e-01f, 3.40608321e-02f, 1.17732301e-01f, 9.13246647e-02f, -2.20701862e-02f,
  -9.21765044e-02f, 3.24992952e-03f, -1.24430530e-01f, 2.25364178e-01f, -2.13359445e-01f, 2.04085082e-01f, -1.24164954e-01f, 8.39372054e-02f, -2.25777090e-01f, 1.97578501e-02f,
  2.02288315e-01f, -4.11319435e-02f, -8.65737721e-02f, 1.66665465e-01f, 1.30659267e-01f, 1.68173701e-01f, -3.64034139e-02f, -1.48820415e-01f, 6.44310489e-02f, 2.36326069e-01f,
  1.93423286e-01f, 1.66199386e-01f, -1.55843660e-01f, 3.72222178e-02f, 5.25916442e-02f, -1.81166127e-01f, 1.29294088e-02f, 1.92088529e-01f, -7.74745345e-02f, 1.71480536e-01f,
  -1.08080912e+00f, 1.65557861e-02f, -8.96733254e-02f, -3.48461032e-01f, 1.11657828e-01f, -1.79268762e-01f, -2.51073062e-01f, -4.51425999e-01f, -3.45536202e-01f, 4.10243236e-02f,
  2.69284397e-01f, 3.50749552e-01f, 1.80168241e-01f, 1.30339399e-01f, -2.36479685e-01f, -4.44956385e-02f, -2.28276193e-01f, -7.47271180e-02f, -7.11437613e-02f, 1.53799757e-01f,
  3.70947570e-01f, 1.97495371e-01f, -1.52772576e-01f, -1.86735205e-02f, 1.98245168e-01f, 2.33297169e-01f, 1.23021156e-01f, 1.55152604e-01f, 3.05269420e-01f, 3.76975596e-01f,
  6.73322260e-01f, -3.72353762e-01f, -1.81346655e-01f, -1.18136905e-01f, 3.27662714e-02f, -1.21818319e-01f, -9.38024372e-02f, -1.82566226e-01f, -9.59979668e-02f, -3.34158093e-02f,
  -2.83962991e-02f, 4.35710214e-02f, -1.24875002e-01f, 5.46121225e-02f, -2.01938320e-02f, -1.54530825e-02f, -1.92365453e-01f, -1.88692704e-01f, -8.13699514e-03f, 1.14650443e-01f,
  1.89855784e-01f, 1.52390331e-01f, 1.37845933e-01f, -6.09037094e-02f, -1.87017128e-01f, 7.25276247e-02f, 1.31637260e-01f, -5.13993874e-02f, -5.58034517e-02f, 1.78487704e-03f,
  1.52841238e-02f, -1.17570676e-01f, -6.51107654e-02f, 7.88358524e-02f, -8.77434313e-02f, -2.39530019e-02f, 5.32743894e-03f, -3.57609242e-02f, -4.90885228e-02f, -6.58527091e-02f,
  1.23769537e-01f, 1.03229783e-01f, 6.27553388e-02f, -2.89141871e-02f, 6.35126010e-02f, -5.59269041e-02f, -1.32960901e-01f, -2.54935194e-02f, 4.12782840e-02f, -1.23885170e-01f,
  -9.45055945e-05f, -7.41853490e-02f, -4.83528450e-02f, 3.23058628e-02f, 6.54479936e-02f, -1.08838819e-01f, 1.00458963e-02f, 2.65868194e-03f, -1.29610635e-02f, 3.12959068e-02f,
  4.84443337e-01f, 5.63912885e-03f, 2.18426697e-02f, -3.36834155e-02f, -1.14161447e-01f, -1.00206681e-01f, -1.30117480e-02f, -4.21960391e-02f, 2.33405195e-02f, -3.79808843e-02f,
  -3.59073468e-02f, -1.37893856e-01f, 4.65219393e-02f, 7.74031579e-02f, -4.29085754e-02f, -1.01146642e-02f, -9.40972865e-02f, 9.04980078e-02f, 8.96973163e-02f, -3.47090848e-02f,
  -1.61851317e-01f, -5.34076504e-02f, 7.16619045e-02f, 4.74406630e-02f, -3.19624618e-02f, 3.33701447e-02f, 3.27652782e-01f, 1.10186324e-01f, 1.40232267e-02f, 1.21837705e-02f,
  5.03617346e-01f, -6.30839348e-01f, -5.92680097e-01f, 1.63329430e-02f, -1.46502689e-01f, 1.80375993e-01f, -1.57804251e-01f, 3.01092118e-01f, 2.38793001e-01f, -3.76688898e-01f,
  -3.67683321e-01f, 2.40943264e-02f, -1.34867162e-01f, -1.12235680e-01f, 3.76667500e-01f, -4.54402655e-01f, -1.75803274e-01f, 2.03508049e-01f, 6.45293951e-01f, 3.83832425e-01f,
  1.31433740e-01f, 1.54449120e-01f, 3.47806931e-01f, 2.85041064e-01f, -2.84322947e-01f, 1.46926800e-02f, -3.68050069e-01f, -1.75866172e-01f, -1.87401846e-01f, -8.08200836e-01f,
  -5.22061288e-01f, -1.29512042e-01f, 1.22428596e-01f, 1.68446481e-01f, -1.75243080e-01f, 2.80421656e-02f, -1.25174765e-02f, -6.20651320e-02f, -5.04065938e-02f, -5.33634648e-02f,
  -5.49791642e-02f, 6.37880191e-02f, -4.99694273e-02f, 1.21314399e-01f, -4.15598713e-02f, 6.32561669e-02f, -8.86508729e-03f, -1.18691392e-01f, -1.82569399e-01f, -1.30841523e-01f,
  -2.37812072e-01f, -1.05505675e-01f, -8.38599056e-02f, -7.86960274e-02f, 2.51469109e-03f, 8.02676454e-02f, -3.07626098e-01f, -4.50828411e-02f, 5.81292845e-02f, -4.45313781e-01f,
  -1.29966602e-01f, -1.58061478e-02f, 1.16104066e-01f, -1.02583222e-01f, 5.04534133e-02f, -5.88202812e-02f, -1.40553325e-01f, 6.09475300e-02f, 6.60271719e-02f, 4.55109868e-03f,
  -1.35824516e-01f, -3.83010283e-02f, -6.81924000e-02f, -1.58802018e-01f, -5.22096753e-02f, 4.73091565e-02f, 5.65202488e-03f, -4.17093234e-03f, 1.18283361e-01f, 1.00451723e-01f,
  7.83909783e-02f, 7.55450800e-02f, -5.66643439e-02f, 3.03316340e-02f, -9.46528912e-02f, -2.22323611e-02f, 2.19424739e-02f, -3.40606309e-02f, -5.88934310e-02f, -3.37864608e-02f,
  -3.99250872e-02f, 1.18581891e-01f, -2.04163998e-01f, 1.21913731e-01f, 1.74067318e-01f, 2.29640417e-02f, -1.93961382e-01f, -1.79460254e-02f, 4.93949875e-02f, -7.53498152e-02f,
  1.58089831e-01f, -4.57114875e-02f, -3.24115843e-01f, -5.41848689e-02f, 1.39326081e-02f, 1.05873898e-01f, 4.80768364e-03f, 2.16851197e-02f, 7.42220357e-02f, 9.92195010e-02f,
  -3.72941867e-02f, 2.18002290e-01f, 2.15710491e-01f, 2.76130475e-02f, 9.10150707e-02f, 1.42043084e-01f, 5.40033430e-02f, -2.94276164e-03f, 1.14924818e-01f, -6.39019907e-02f,
  8.84277701e-01f, -4.30437356e-01f, -5.84633708e-01f, 6.26511157e-01f, -4.65594590e-01f, -3.04168820e-01f, -8.01776528e-01f, 5.87606467e-02f, 4.87202466e-01f, -4.43089336e-01f,
  -1.28094018e-01f, 4.46459055e-01f, 4.46662486e-01f, 1.72356740e-01f, 1.70846373e-01f, -5.24297655e-01f, -3.92425716e-01f, 8.96811252e-04f, 5.90697117e-02f, -2.87845314e-01f,
  -2.02867948e-03f, 1.61641702e-01f, 6.01195157e-01f, 3.56799662e-01f, -3.63943785e-01f, -5.42471521e-02f, -2.81969070e-01f, -1.00771137e-01f, -3.03886950e-01f, -6.21500432e-01f,
  -4.64917123e-01f, -2.50569731e-01f, -2.26582915e-01f, 1.38537884e-01f, -1.39352083e-01f, -6.49957135e-02f, -2.14037687e-01f, -8.66377205e-02f, -5.36729284e-02f, 4.37349789e-02f,
  -9.26725790e-02f, -5.32246456e-02f, 1.01557016e-01f, -6.29952624e-02f, 3.02970707e-02f, -6.07293891e-03f, 8.66821855e-02f, 4.92245145e-02f, 5.26926853e-02f, -6.16998188e-02f,
  -6.09339448e-03f, -2.08425760e-01f, -2.24242494e-01f, -2.88569599e-01f, -1.80725679e-01f, -2.12350473e-01f, -3.57287079e-01f, -3.37617218e-01f, -2.13493809e-01f, -2.36366242e-01f,
  -5.73340291e-03f, 4.59551737e-02f, -1.24666117e-01f, 7.47539774e-02f, 7.45456591e-02f, -1.92456506e-02f, 2.65607852e-02f, -1.58771891e-02f, 3.14348601e-02f, 5.90351261e-02f,
  -2.25184206e-02f, -8.78702700e-02f, 5.15398532e-02f, -2.08829623e-02f, -4.17419113e-02f, -6.69202656e-02f, -5.88669255e-02f, -6.03877902e-02f, -4.29834984e-02f, -3.51995160e-03f,
  -2.87337750e-02f, -8.71225744e-02f, 2.83713564e-02f, -1.25182301e-01f, 4.46039177e-02f, -8.23367760e-02f, 2.70239171e-03f, -6.66029304e-02f, 2.27943644e-01f, 4.77928706e-02f,
  5.67321599e-01f, 7.40778893e-02f, -5.28340265e-02f, -1.48548201e-01f, 2.94765048e-02f, 5.54217622e-02f, -6.95748776e-02f, -1.49615770e-02f, 1.38784975e-01f, -4.59515005e-02f,
  -1.67507708e-01f, 1.75888464e-02f, 1.81667302e-02f, -6.86619580e-02f, -1.49144948e-01f, 1.89193711e-02f, -4.21205983e-02f, 7.33948871e-02f, -7.68232048e-02f, -6.57870341e-03f,
  1.61655009e-01f, 1.20859541e-01f, 1.60938591e-01f, -2.48909425e-02f, 1.75652161e-01f, 1.74854305e-02f, -1.23087116e-01f, -1.49048626e-01f, 8.41581672e-02f, 7.31211156e-02f,
  1.21039510e+00f, 6.60932124e-01f, -1.83205098e-01f, -3.11402585e-02f, -9.43360031e-02f, -1.82039246e-01f, 3.68745655e-01f, 1.38996199e-01f, -1.03823215e-01f, 2.90588081e-01f,
  -1.31614609e-02f, -3.30244690e-01f, -2.06568077e-01f, -2.82381535e-01f, -2.57956982e-01f, 1.12097859e-01f, 4.92531136e-02f, -2.66446531e-01f, -6.66251719e-01f, -4.49969500e-01f,
  -2.84425616e-01f, 2.05022037e-01f, 4.64843698e-02f, 3.30484100e-02f, 3.17026436e-01f, 4.40449873e-03f, 3.20344150e-01f, 2.70580053e-01f, 1.50768444e-01f, 2.20680967e-01f,
  -8.05789158e-02f, 5.46659648e-01f, -6.00041509e-01f, 5.29513210e-02f, 3.48757356e-02f, 5.18569797e-02f, -1.40449896e-01f, -5.99603634e-04f, -1.06685415e-01f, -3.05962395e-02f,
  1.76898837e-02f, -1.27592787e-01f, 2.59253923e-02f, -1.62742555e-01f, -4.37231623e-02f, -1.13527790e-01f, 1.66175619e-01f, -8.17855150e-02f, -5.60641736e-02f, 2.30746027e-02f,
  -1.33793801e-01f, -5.92935719e-02f, 1.75333589e-01f, -1.62903279e-01f, -5.96244074e-02f, -1.81677029e-01f, 3.76551114e-02f, 7.36203566e-02f, 5.80052584e-02f, 2.15603083e-01f,
  -2.27527037e-01f, 5.29729351e-02f, -5.20293005e-02f, 1.86082330e-02f, 1.46174878e-01f, -1.44949570e-01f, -1.07375659e-01f, -9.57122296e-02f, -7.64586776e-02f, -5.06566614e-02f,
  -2.75686175e-01f, -8.29432905e-02f, -1.68059289e-01f, 2.69223657e-02f, 8.16107616e-02f, -7.28743002e-02f, -1.25118326e-02f, -1.30499881e-02f, -5.67157287e-03f, 9.64400545e-02f,
  1.92556120e-02f, -6.72607357e-03f, 1.07099637e-01f, 3.78737263e-02f, -1.17776655e-01f, -3.52575071e-02f, -2.09929705e-01f, -6.54491484e-02f, 8.02260786e-02f, 8.72979984e-02f,
  -7.52251372e-02f, -4.29433674e-01f, 8.67803767e-02f, 1.67779282e-01f, 1.75176099e-01f, 1.36257440e-01f, 1.45110652e-01f, -9.08513144e-02f, 9.28757265e-02f, -5.76037876e-02f,
  4.78992090e-02f, -9.17517245e-02f, 7.66885579e-02f, 2.03905702e-02f, -1.08978331e-01f, -8.67709816e-02f, 9.08984467e-02f, -4.46753353e-02f, -1.70941517e-01f, 1.14792600e-01f,
  -1.05097421e-01f, -7.69671574e-02f, -1.31763235e-01f, -7.65832514e-02f, -9.61795915e-03f, -2.98644185e-01f, -3.75361815e-02f, -1.75659820e-01f, -8.40763599e-02f, 5.84329218e-02f,
  -6.42185748e-01f, 2.79741198e-01f, 1.76971853e-01f, -2.17911035e-01f, 4.54367369e-01f, 5.39132059e-01f, 8.92746329e-01f, 3.29903722e-01f, -8.95518903e-03f, 1.44694716e-01f,
  -2.56297827e-01f, -7.65878201e-01f, -4.63269562e-01f, -2.12966308e-01f, 8.29352662e-02f, 6.67723536e-01f, 5.52523434e-01f, -1.83067307e-01f, -1.65747613e-01f, 5.80130965e-02f,
  9.79578570e-02f, -8.00171345e-02f, -5.05915403e-01f, -1.77216977e-01f, 7.67670339e-03f, -1.98159739e-01f, 1.38527408e-01f, -8.55179355e-02f, 1.95103083e-02f, -3.24586630e-01f,
  -5.67834377e-01f, -8.16515237e-02f, 1.99326687e-02f, -3.72786105e-01f, -6.39237836e-02f, -3.06863755e-01f, -8.92212018e-02f, -1.76045775e-01f, -5.48207797e-02f, -7.13071898e-02f,
  -2.40167007e-01f, -1.15163401e-01f, -1.33850083e-01f, -1.02249339e-01f, -4.36355323e-02f, -2.87429076e-02f, 1.15269743e-01f, -1.09603591e-01f, -1.04081467e-01f, -6.20741285e-02f,
  1.65693853e-02f, 2.61503123e-02f, 6.57467842e-02f, 2.89046764e-01f, 6.42029149e-03f, -3.93121243e-02f, -2.18035262e-02f, -1.31167844e-01f, -1.09535322e-01f, -1.36998475e-01f,
  -4.93821241e-02f, 5.20865396e-02f, -7.28693828e-02f, -1.03371171e-02f, 3.50733362e-02f, 1.16588749e-01f, -9.54052359e-02f, -1.06587112e-02f, 1.07951663e-01f, 9.55902189e-02f,
  1.78142581e-02f, 1.92816239e-02f, -7.82693475e-02f, -1.91108901e-02f, -8.74021426e-02f, 5.48440963e-03f, 5.58180101e-02f, 2.11598049e-03f, -8.35930184e-02f, 5.41061163e-03f,
  -5.48889637e-02f, 8.87148678e-02f, 8.91597569e-02f, -1.98498771e-01f, 1.13513909e-01f, -8.38863701e-02f, -7.06179142e-02f, -5.74367940e-02f, 2.36330088e-03f, -4.14662808e-02f,
  -2.01010406e-01f, 1.58089966e-01f, -1.28102213e-01f, -9.75934714e-02f, 8.04485977e-02f, -3.29036191e-02f, -1.55800700e-01f, -1.02171868e-01f, 5.95606193e-02f, -1.57364588e-02f,
  -6.52431175e-02f, -1.43023819e-01f, -1.40000582e-01f, -2.43726261e-02f, -1.66713353e-02f, 2.61093806e-02f, 6.62862659e-02f, -7.78756589e-02f, -5.45185432e-02f, -1.08632617e-01f,
  2.15505302e-01f, 3.07993531e-01f, 4.14579622e-02f, 4.98723425e-02f, -9.89003927e-02f, 9.26931649e-02f, -4.12801281e-02f, 1.04366586e-01f, 1.63986459e-01f, 3.09458643e-01f,
  -9.19327378e-01f, -2.01330587e-01f, -6.47251979e-02f, -8.65672305e-02f, 6.03190204e-03f, -2.78260887e-01f, -3.12564254e-01f, -2.58228928e-01f, 6.61240816e-02f, -1.94408536e-01f,
  -3.97016227e-01f, 2.12844666e-02f, 2.65774131e-01f, 1.72626778e-01f, 1.70072615e-01f, 3.22925508e-01f, 5.81616104e-01f, 3.23059410e-01f, -1.16749972e-01f, -9.40035656e-02f,
  2.62737274e-01f, 1.00890137e-01f, -1.09439775e-01f, 1.46702752e-01f, 1.66960329e-01f, 9.14092287e-02f, 1.70328274e-01f, 5.42064980e-02f, 7.71287680e-02f, 5.88166773e-01f,
  -4.92492616e-01f, -3.08639497e-01f, 1.16677262e-01f, -9.68761556e-03f, -1.21212834e-02f, -2.35386714e-02f, 1.34409200e-02f, -4.71094660e-02f, -1.00447923e-01f, 4.99455724e-03f,
  -4.69806083e-02f, -1.31715924e-01f, 3.72972280e-01f, 6.09821863e-02f, -2.49580760e-02f, -1.22689307e-01f, 1.36303917e-01f, 1.47749512e-02f, 1.68050248e-02f, -3.00598949e-01f,
  2.85734534e-01f, -1.48793191e-01f, -4.12656754e-01f, -9.43927169e-02f, -1.49912179e-01f, -1.68487549e-01f, -3.66482705e-01f, -6.26478195e-02f, -2.31072694e-01f, -1.77299708e-01f,
  1.46406785e-01f, 5.60898557e-02f, 1.46110460e-01f, 4.42774184e-02f, 1.28974663e-02f, 1.39522642e-01f, 2.84266442e-01f, 5.02176769e-02f, 9.77617949e-02f, -7.17973560e-02f,
  4.72594202e-02f, -1.63652763e-01f, 5.89198107e-03f, 5.47376983e-02f, -5.85895404e-02f, -7.71991462e-02f, 7.03357439e-03f, -1.96079630e-02f, 8.97302851e-02f, -1.55755682e-02f,
  1.85723215e-01f, -5.66815166e-03f, 3.47594731e-02f, 3.11374217e-02f, -3.37897688e-02f, -1.23840019e-01f, -9.19526145e-02f, -2.10818678e-01f, -1.72648907e-01f, -2.00106621e-01f,
  -2.77267307e-01f, 2.74304032e-01f, -1.24125786e-01f, 1.28376558e-01f, 4.26384620e-02f, -6.63553327e-02f, 4.49619479e-02f, -9.15794000e-02f, -2.10277736e-01f, -3.81489635e-01f,
  -5.26049435e-01f, -1.02046609e-01f, -7.50360489e-02f, 3.57575007e-02f, -2.47287393e-01f, -1.46974578e-01f, 5.87103181e-02f, 1.26672789e-01f, 5.05150817e-02f, -2.39003479e-01f,
  5.44127040e-02f, -1.02570198e-01f, -2.43902028e-01f, -9.93457884e-02f, -1.34260237e-01f, -1.77694365e-01f, -2.26535827e-01f, -3.09810966e-01f, -3.27956498e-01f, -4.44695562e-01f,
  5.46030819e-01f, 1.36884078e-01f, 3.25387120e-01f, 2.61426717e-01f, 3.84591520e-01f, 5.14521301e-01f, 5.44581831e-01f, 3.19475174e-01f, 9.60452780e-02f, 1.11468621e-01f,
  -1.53146282e-01f, -2.70329267e-01f, -1.68309465e-01f, -1.85406715e-01f, 9.77194160e-02f, 2.78209209e-01f, 3.79906334e-02f, 3.53403799e-02f, 1.03387460e-01f, 1.37696430e-01f,
  -1.57807440e-01f, 1.85228750e-01f, 8.85626227e-02f, -3.20759341e-02f, -7.49230981e-02f, -2.14251369e-01f, 8.97052363e-02f, 1.95592508e-01f, -1.32011138e-02f, -1.61738992e-01f,
  -1.01103842e-01f, 3.12450647e-01f, -2.68532783e-01f, -2.14638159e-01f, -3.27981450e-02f, -2.00155988e-01f, 3.31019284e-03f, -1.19124360e-01f, -6.79267049e-02f, -7.16668293e-02f,
  -3.84804495e-02f, -3.52932028e-02f, 4.51121330e-02f, -5.14098145e-02f, 2.05659181e-01f, 1.17155544e-01f, -3.24789211e-02f, 9.93514359e-02f, 8.48200172e-02f, -7.57125691e-02f,
  -1.31841674e-01f, 2.36416221e-01f, 2.70850837e-01f, 1.28536716e-01f, 1.14630170e-01f, 6.04452472e-03f, 3.67594771e-02f, 5.96053340e-03f, 1.52150244e-01f, 6.47571236e-02f,
  1.18322223e-01f, 1.97430611e-01f, 2.96642389e-02f, 1.82393212e-02f, 8.10121894e-02f, -8.61671939e-03f, 7.35118659e-03f, 6.76082745e-02f, 1.31714404e-01f, 1.64629370e-01f,
  -2.39408063e-03f, -7.73589835e-02f, 8.92486125e-02f, -6.45795325e-03f, -4.26381268e-02f, 8.46199766e-02f, 6.20579580e-03f, -1.06121458e-01f, -8.82589296e-02f, -3.97487432e-02f,
  1.02840550e-01f, 3.38009857e-02f, -3.42114903e-02f, 1.21645547e-01f, 9.97346193e-02f, 8.27620752e-05f, -2.28779223e-02f, -2.29459275e-02f, 5.01351804e-02f, -5.02309622e-03f,
  -2.76935160e-01f, 1.28665417e-01f, -2.73560524e-01f, -7.44743496e-02f, -6.91052377e-02f, -1.75722405e-01f, 4.26593162e-02f, -1.33277312e-01f, -1.21463731e-01f, -6.30965233e-02f,
  -1.01620957e-01f, -2.68316343e-02f, 1.01481639e-01f, 6.83775917e-02f, 1.18775204e-01f, -2.11361889e-02f, -1.08360849e-01f, 4.95987236e-02f, -1.24430411e-01f, -1.14917889e-01f,
  -1.63525805e-01f, 2.08056979e-02f, 1.33866578e-01f, 4.68623731e-03f, -1.14968732e-01f, 4.78662103e-02f, -7.66373500e-02f, -2.89068017e-02f, 5.40454239e-02f, -1.20755658e-01f,
  6.86611682e-02f, -4.58240137e-02f, 4.00117785e-01f, 3.90815645e-01f, -4.55545075e-02f, -4.36940312e-01f, -5.26931703e-01f, -3.29541385e-01f, -4.41907719e-02f, -1.59537330e-01f,
  -3.83425444e-01f, -2.01629195e-02f, -1.49669014e-02f, -9.44771152e-03f, 2.98083145e-02f, -9.24133230e-03f, 5.47512650e-01f, 5.58925271e-01f, 5.02834544e-02f, -1.62793100e-01f,
  1.92659125e-01f, 2.53705174e-01f, 2.31761277e-01f, 1.14446536e-01f, 1.96008295e-01f, 2.11458653e-02f, 5.13801537e-02f, 5.01822941e-02f, -4.02039550e-02f, 7.30994880e-01f,
  -6.87673390e-02f, -7.83359855e-02f, -8.05426389e-02f, -1.46251082e-01f, -2.40825024e-02f, 2.25712538e-01f, -1.42804861e-01f, 1.26149267e-01f, -1.20495439e-01f, -3.31129022e-02f,
  4.34365310e-02f, -1.02800526e-01f, 4.14206088e-02f, 7.19257593e-02f, -1.13040460e-02f, -1.92725241e-01f, 1.94606811e-01f, 2.48557732e-01f, 4.54949923e-02f, -5.39628789e-02f,
  2.58212417e-01f, -1.48434028e-01f, -2.15269521e-01f, -2.17828780e-01f, -8.89978483e-02f, 1.82343185e-01f, -1.37709960e-01f, 1.04379982e-01f, -1.34235680e-01f, 1.09814003e-01f,
  -1.71256587e-01f, 7.22390460e-03f, 1.35903684e-02f, 9.19186771e-02f, 5.41145690e-02f, -4.88503538e-02f, 8.87747854e-02f, -9.03182756e-03f, 1.49482340e-01f, 9.63948667e-02f,
  2.36220956e-02f, -8.17545652e-02f, 8.82469025e-03f, 1.74701177e-02f, 5.43825850e-02f, 3.70415449e-02f, 7.12147951e-02f, 1.21237382e-01f, -6.01739697e-02f, -6.71713501e-02f,
  5.57345487e-02f, 1.82133187e-02f, 1.03125922e-01f, 1.45237118e-01f, -5.99887557e-02f, 1.34421661e-01f, 1.14748344e-01f, -8.21375027e-02f, 8.45575556e-02f, 3.78833152e-02f,
  -2.54437566e-01f, -3.36510003e-01f, -5.43423556e-02f, 1.08590387e-01f, 8.26801360e-02f, -1.50419921e-02f, 1.56972468e-01f, 2.30858810e-02f, 9.95173529e-02f, 4.70263548e-02f,
  2.59939022e-03f, -5.67887388e-02f, -8.48904625e-02f, -1.73457935e-02f, -1.03466623e-01f, 2.44858600e-02f, -3.41929309e-02f, -5.76240569e-02f, -8.74098092e-02f, 1.40528426e-01f,
  1.70975536e-01f, -4.83546376e-01f, -5.47169745e-01f, -2.55709082e-01f, -2.67853409e-01f, -3.78782511e-01f, -3.50635409e-01f, -7.18250498e-02f, -5.69799423e-01f, -2.05069020e-01f,
  6.08622551e-01f, -5.56509197e-01f, 3.16599607e-02f, 3.60902637e-01f, 3.31471622e-01f, 4.76594567e-01f, 2.00203389e-01f, 2.75443345e-02f, 1.83202505e-01f, 4.85711023e-02f,
  -1.09211788e-01f, 1.09178260e-01f, 7.22329393e-02f, -1.58940852e-01f, -4.82702963e-02f, -2.77735796e-02f, 3.84156704e-02f, 1.36199847e-01f, 2.10827142e-01f, 1.44295484e-01f,
  -2.22921260e-02f, -9.23810303e-02f, -1.11641765e-01f, -6.37183711e-02f, -3.16750318e-01f, 6.31875992e-02f, -1.56597584e-01f, -1.99990600e-01f, -1.69585004e-01f, -3.51762921e-01f,
  -2.56573796e-01f, -3.43807966e-01f, 1.49582431e-01f, -9.21747298e-04f, -1.04883499e-01f, -5.90980686e-02f, 8.16657245e-02f, -1.83242142e-01f, -2.21149161e-01f, -4.04382944e-02f,
  -1.24610566e-01f, -8.47279802e-02f, -5.70085272e-02f, -1.68197423e-01f, -2.26884428e-02f, -1.47657216e-01f, -1.62388355e-01f, -1.05795361e-01f, -1.33474628e-02f, -1.04391523e-01f,
  -1.22328527e-01f, -3.98852341e-02f, -3.60289812e-02f, 9.08555984e-02f, 1.23964392e-01f, 2.95781679e-02f, -1.99648008e-01f, -1.25961646e-01f, -3.01001389e-02f, 8.38783160e-02f,
  7.35598756e-03f, 9.97134373e-02f, 1.42147854e-01f, 8.96822289e-02f, 1.87557429e-01f, 8.64773169e-02f, -2.59633362e-02f, 4.65428010e-02f, 5.58735393e-02f, 7.69928470e-02f,
  -2.74327472e-02f, 1.56063274e-01f, -1.16189439e-02f, 5.02174646e-02f, 5.00446036e-02f, 1.70441512e-02f, -8.10073838e-02f, -8.53937492e-02f, -7.77148530e-02f, 3.42973322e-02f,
  1.70999438e-01f, -5.43096475e-02f, -1.94999143e-01f, -1.31090984e-01f, -1.53720051e-01f, -1.88709274e-02f, -6.02916554e-02f, -1.14235338e-02f, -2.01366073e-03f, 3.90376002e-02f,
  4.31001708e-02f, 1.87890112e-01f, 1.40971139e-01f, 1.58848502e-02f, -1.48529917e-01f, -4.60741157e-03f, 1.60737514e-01f, -1.51865229e-01f, -1.62193596e-01f, -1.03076056e-01f,
  -1.17995381e-01f, -4.19133492e-02f, -5.12691885e-02f, 2.91411225e-02f, 1.23239771e-01f, 5.79777509e-02f, -1.16928145e-01f, 8.29856023e-02f, -4.26082797e-02f, -5.59835471e-02f,
  -2.27328055e-02f, 3.13581616e-01f, 2.66280413e-01f, 2.96721756e-01f, 1.59973845e-01f, 3.29064071e-01f, 4.75658402e-02f, 1.52073264e-01f, 2.79815763e-01f, 3.79591912e-01f,
  2.99135655e-01f, -5.49010694e-01f, -6.95342779e-01f, -2.54032284e-01f, -3.55863720e-01f, -1.17401548e-01f, -5.39008565e-02f, -1.96284167e-02f, 1.30999750e-02f, -1.79659963e-01f,
  -3.68333310e-01f, -2.14854646e-02f, -1.31715298e-01f, -2.43579149e-01f, 1.33994505e-01f, -3.45012210e-02f, -1.25587627e-01f, 4.77688797e-02f, 2.35995367e-01f, -1.25474157e-02f,
  1.63139775e-01f, 2.60533810e-01f, 2.11874992e-01f, 9.74812955e-02f, -1.69581458e-01f, 1.00556552e-01f, -3.51998061e-01f, -3.00687492e-01f, -2.27399439e-01f, -5.28814018e-01f,
  3.07917632e-02f, -8.30186605e-01f, -4.93321717e-02f, -4.85453345e-02f, -1.25492305e-01f, -1.43639103e-03f, -4.83466350e-02f, -1.70000672e-01f, -6.51163012e-02f, 1.22294649e-01f,
  -1.54806048e-01f, -9.75417793e-02f, -1.56515822e-01f, -5.60462847e-02f, 1.13143310e-01f, -5.59280254e-02f, -1.05415933e-01f, -3.18226606e-01f, -5.13357341e-01f, -1.62089840e-01f,
  -3.63535613e-01f, -4.35409904e-01f, -2.09997043e-01f, -2.93114543e-01f, -4.40454692e-01f, -8.91876146e-02f, -2.07608327e-01f, -3.61430347e-01f, -4.16816950e-01f, 1.28594443e-01f,
  2.05229983e-01f, 8.10605753e-03f, -1.83006264e-02f, 1.10246770e-01f, 1.08663402e-02f, 1.45442467e-02f, -1.36174820e-03f, 1.08651325e-01f, 2.00797319e-02f, 2.08133131e-01f,
  -1.61526695e-01f, 5.80608435e-02f, -1.77131742e-01f, -1.76116526e-02f, 4.85753641e-02f, -1.86333850e-01f, 1.30941141e-02f, 1.07671209e-01f, 4.98902909e-02f, 1.43888712e-01f,
  -3.94914225e-02f, -1.54430047e-01f, 5.27943000e-02f, 7.41588846e-02f, -2.93651372e-01f, -7.59041458e-02f, -3.02570015e-02f, 7.36012906e-02f, 1.12560857e-02f, -1.18895739e-01f,
  6.26627147e-01f, -3.53870124e-01f, 3.58857572e-01f, -9.02625620e-02f, -6.44264221e-02f, -8.69142488e-02f, -1.41934827e-01f, 1.18487529e-01f, -6.93897754e-02f, 5.64903133e-02f,
  -2.73214608e-01f, 1.22967198e-01f, -3.12098842e-02f, 4.98602577e-02f, 1.49438784e-01f, -2.18798593e-02f, 9.24614221e-02f, 1.08624488e-01f, -1.20558552e-01f, 1.47187948e-01f,
  4.81874980e-02f, 3.27094495e-01f, 5.11163712e-01f, 3.62769216e-01f, 1.16349660e-01f, 3.31194431e-01f, 5.39706528e-01f, 2.88011521e-01f, 3.94931614e-01f, 1.01424968e+00f,
  -4.67272729e-01f, -6.83138371e-02f, -3.36806744e-01f, 2.07539156e-01f, 5.98364711e-01f, -8.63510370e-02f, -5.68277478e-01f, -4.22529668e-01f, 1.60735041e-01f, 1.03657305e-01f,
  4.41102833e-01f, 4.84634191e-01f, 2.19930053e-01f, 3.59785818e-02f, -6.97198629e-01f, -2.09080189e-01f, -5.67449816e-02f, -3.85684460e-01f, -4.99119103e-01f, -5.72838709e-02f,
  2.44879842e-01f, -1.25242621e-02f, -3.87424678e-01f, -2.13043541e-01f, 2.37829328e-01f, 5.50772287e-02f, 2.03829468e-03f, 7.31567144e-02f, 9.90128964e-02f, 2.72549361e-01f,
  1.74515367e-01f, 1.39866412e-01f, 7.05283061e-02f, 3.31418216e-01f, 1.37269840e-01f, 6.28174320e-02f, 5.15085878e-03f, -3.09621114e-02f, 7.35394880e-02f, -1.93011165e-01f,
  4.27819461e-01f, 2.61117697e-01f, 1.92622423e-01f, -1.47636924e-02f, 1.05598666e-01f, -1.63363338e-01f, -2.36239642e-01f, -5.26765704e-01f, -6.44113541e-01f, -2.25564852e-01f,
  2.99858242e-01f, 2.36325011e-01f, -3.20729643e-01f, -2.78345495e-01f, -2.81408221e-01f, -9.91078988e-02f, -5.23376942e-01f, -2.91721255e-01f, -5.72835624e-01f, -4.36664283e-01f,
  -6.74586818e-02f, 9.00718421e-02f, 7.77819976e-02f, -5.59213236e-02f, 3.64465006e-02f, 1.70902893e-01f, 3.01761422e-02f, 5.38554117e-02f, -1.14567764e-02f, -8.82444829e-02f,
  -3.95312272e-02f, -2.93903649e-02f, -4.41126823e-02f, -8.13628137e-02f, 1.52547419e-01f, 9.26594585e-02f, -2.65255030e-02f, -8.35159123e-02f, 2.81644426e-02f, 6.80393204e-02f,
  1.58894181e-01f, 1.04300112e-01f, 2.65975714e-01f, -1.22262582e-01f, 4.81180623e-02f, -6.11944720e-02f, 1.23490587e-01f, 1.85748145e-01f, -8.43141675e-02f, 2.52759345e-02f,
  -3.02300960e-01f, 9.42677334e-02f, 1.67346865e-01f, -6.69071302e-02f, 6.24497347e-02f, 8.06090608e-02f, -9.84238237e-02f, 1.62980554e-03f, 1.15506478e-01f, -3.79010618e-01f,
  -1.13373317e-01f, -1.22347578e-01f, -1.37792423e-01f, -2.19786644e-01f, -2.21746013e-01f, -6.49080202e-02f, 7.20555633e-02f, -3.43952812e-02f, -2.50403792e-01f, 6.90971455e-03f,
  -2.15425223e-01f, -3.12559247e-01f, -3.23947579e-01f, -3.84135544e-01f, 2.42274612e-01f, 1.15269618e-02f, -3.08390945e-01f, -2.04749972e-01f, -3.24605048e-01f, -7.19727516e-01f,
  7.91438162e-01f, 3.03098410e-01f, 5.58614790e-01f, 3.39631677e-01f, 1.12279411e-03f, 3.27287465e-01f, 5.70964515e-01f, 3.61415118e-01f, 1.82743818e-02f, 2.12863311e-01f,
  6.62450269e-02f, -1.74986228e-01f, -3.46250869e-02f, -3.46985785e-03f, 2.36758068e-01f, 2.13054180e-01f, -5.56811206e-02f, 2.58870006e-01f, 2.36342162e-01f, 1.25471354e-01f,
  -1.43247947e-01f, 8.92335251e-02f, 6.14115335e-02f, 1.15719184e-01f, -3.31890816e-03f, 2.08512391e-03f, 8.11349899e-02f, 5.89123704e-02f, 1.97364122e-01f, 1.08227320e-02f,
  3.91019344e-01f, 4.53947604e-01f, -8.88825133e-02f, -1.95286185e-01f, 2.08438467e-02f, -1.15517706e-01f, -1.59989461e-01f, -1.66395113e-01f, -2.18318343e-01f, -1.44868076e-01f,
  -7.13372752e-02f, -7.29487371e-03f, 4.40907776e-02f, -5.41419163e-02f, 9.52857733e-03f, 4.26878147e-02f, 7.51036182e-02f, 1.42367691e-01f, 1.62585974e-01f, 9.18584540e-02f,
  -3.01647130e-02f, -5.51835969e-02f, 1.13891857e-02f, 5.81666641e-02f, 2.48552471e-01f, -9.63178203e-02f, -4.14789207e-02f, 6.62725093e-03f, 4.27023694e-03f, -4.23985645e-02f,
  -9.32565257e-02f, -1.39917567e-01f, 1.10411450e-01f, 2.89289933e-02f, 1.91894934e-01f, 1.00086510e-01f, 1.52700305e-01f, 1.21159397e-01f, 1.45852074e-01f, -7.23398775e-02f,
  -2.87461746e-02f, 1.77776143e-01f, 1.93869367e-01f, 6.44522086e-02f, 1.33581851e-02f, 1.65998176e-01f, -3.78360376e-02f, 5.61595447e-02f, 3.67639586e-02f, -4.07040827e-02f,
  -4.77489047e-02f, 1.39059246e-01f, 3.85495797e-02f, 2.42164686e-01f, 9.80137587e-02f, -4.67120856e-03f, 1.38498053e-01f, 5.22255823e-02f, -6.90503493e-02f, -1.30154714e-01f,
  -1.71041295e-01f, 6.33373410e-02f, 3.11286319e-02f, -6.20989092e-02f, -5.97962551e-03f, -2.13262439e-01f, 2.38116495e-02f, -1.77006096e-01f, -3.46176088e-01f, -6.20218962e-02f,
  2.44533531e-02f, -9.15752202e-02f, 6.96870610e-02f, -7.54860938e-02f, -1.26564786e-01f, -1.67279661e-01f, -6.49149492e-02f, -1.41043365e-01f, -6.41592368e-02f, -1.22559696e-01f,
  -1.60636023e-01f, -1.97649851e-01f, -2.17139155e-01f, -1.06461525e-01f, -9.24042165e-02f, -2.75498927e-01f, -2.51724839e-01f, -2.49567255e-01f, -6.12119697e-02f, -2.32651621e-01f,
  7.07383871e-01f, -4.56410110e-01f, 1.85835421e-01f, -1.77231148e-01f, -5.26410878e-01f, -4.45516884e-01f, -6.35466039e-01f, -2.27615610e-01f, 1.50481360e-02f, -2.46447012e-01f,
  -1.37481153e-01f, 3.09776932e-01f, 4.40613180e-01f, 3.95888299e-01f, 4.32470024e-01f, -9.03964490e-02f, 1.83059629e-02f, 5.49174249e-01f, 5.41074216e-01f, -1.86981961e-01f,
  -1.68002561e-01f, 2.94473898e-02f, 4.19835389e-01f, 2.39980415e-01f, -2.70325124e-01f, 6.20014034e-02f, 1.89595334e-02f, -2.03421608e-01f, -9.73947868e-02f, -7.92648569e-02f,
  1.25201076e-01f, 7.58912414e-04f, 2.52645731e-01f, 1.38466135e-01f, -2.17658952e-02f, 1.07445776e-01f, -2.94782128e-02f, 8.24523941e-02f, -5.30183017e-02f, -1.36243746e-01f,
  1.27887931e-02f, -2.35488135e-02f, 7.31094405e-02f, -8.62035155e-02f, -1.81123897e-01f, -2.07460602e-03f, 1.05444863e-01f, 7.33747110e-02f, 1.30360141e-01f, -1.08717211e-01f,
  -1.93323523e-01f, -1.25783384e-01f, -4.57592830e-02f, 7.59351579e-03f, 2.38190770e-01f, 1.50720969e-01f, -6.96148956e-03f, -2.87746117e-02f, 8.68665352e-02f, -1.01148024e-01f,
  -8.90522897e-02f, 2.21347790e-02f, -8.17140192e-03f, -3.49416882e-02f, 3.31925340e-02f, -1.34352863e-01f, -6.39532655e-02f, -9.68378410e-02f, 1.31767929e-01f, -3.38329338e-02f,
  -1.22648552e-01f, 5.96034899e-02f, -1.00878410e-01f, -2.07612999e-02f, 1.87245652e-01f, -6.97152019e-02f, -7.53661692e-02f, 2.81637423e-02f, 8.45078900e-02f, -2.21681260e-02f,
  1.67089522e-01f, 7.26828212e-03f, 9.61503852e-03f, -4.34085391e-02f, -4.60831895e-02f, -2.80640759e-02f, -1.71519406e-02f, 1.11459978e-01f, -5.11674322e-02f, -5.61917312e-02f,
  -3.36783260e-01f, 4.71296072e-01f, 7.22598061e-02f, 5.95152825e-02f, -1.16754258e-02f, -2.53562927e-02f, 2.41757780e-02f, -6.45815730e-02f, -6.01509698e-02f, -1.21404454e-01f,
  -9.62035507e-02f, 4.83835936e-02f, -1.99532881e-02f, 8.86547416e-02f, 9.43959653e-02f, 3.03016957e-02f, -5.25105558e-03f, -2.60618161e-02f, -6.88885376e-02f, -2.42623851e-01f,
  -1.38424128e-01f, 1.62466860e-03f, -6.11869954e-02f, 5.98792844e-02f, -3.86606669e-03f, 1.61933690e-01f, -7.12132752e-02f, -8.62537920e-02f, 1.09104045e-01f, -2.38476723e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  4.32866871e-01f, 5.29108524e-01f, 3.71715218e-01f, 4.39126521e-01f, 1.13930130e+00f, 1.04886389e+00f, 5.28318524e-01f, 4.69701111e-01f, 6.43086970e-01f, 6.44859910e-01f,
  9.39279795e-01f, 1.72304526e-01f, 6.61262751e-01f, 3.10356885e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.77504066e-02f, -3.12097222e-01f, -3.87331337e-01f, -1.54277816e-01f, -4.43271339e-01f, -3.23356129e-02f, -1.71287672e-03f, 1.70904338e-01f, 1.88214734e-01f, -2.74874359e-01f,
  4.58689928e-01f, -1.74021855e-01f, 1.68040559e-01f, 9.39300284e-03f, 2.74023451e-02f, 2.63066351e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.22505106e-01f, 1.18573360e-01f, 1.26979083e-01f, -6.02227092e-01f, 9.77613628e-01f, 5.92894435e-01f, -7.17409402e-02f, -3.68180901e-01f, 4.22561973e-01f, -8.69941935e-02f,
  4.80607241e-01f, 2.44276568e-01f, 4.82836038e-01f, -5.92610598e-01f, 3.13731790e-01f, 8.31659675e-01f, 5.01330674e-01f, -2.54659414e-01f, -1.66188940e-01f, 6.27761543e-01f,
  2.46217456e-02f, 9.97744203e-01f, 2.42003575e-01f, -7.09588826e-01f, -5.11036068e-02f, 3.28869955e-03f, 3.42144817e-01f, 3.43964726e-01f, 6.76431358e-01f, 3.43542308e-01f,
  2.80813485e-01f, 1.08370274e-01f, 2.17269287e-02f, -1.72048673e-01f, -3.86650972e-02f, -2.52393991e-01f, -6.87459528e-01f, -5.49789488e-01f, 1.14579415e+00f, 1.17788076e-01f,
  2.15967763e-02f, 2.51052111e-01f, 1.08157821e-01f, -5.43855250e-01f, -4.88505125e-01f, -5.78962624e-01f, 8.01215053e-01f, -3.30477744e-01f, 4.45579916e-01f, -3.56402904e-01f,
  -3.50806773e-01f, -6.10950351e-01f, 4.93344218e-01f, -3.21169794e-01f, 6.70992792e-01f, 7.26236999e-01f, -4.50805813e-01f, 4.89142001e-01f, -2.66341865e-01f, 9.57010314e-02f,
  1.83575362e-01f, -4.50829975e-02f, 1.74918115e-01f, -1.84042677e-01f, -2.05319345e-01f, -2.39623785e-02f, -6.61099628e-02f, -3.61186787e-02f, -6.99362066e-03f, 6.50163770e-01f,
  5.17084673e-02f, -4.82712835e-02f, 2.67669767e-01f, -2.52011687e-01f, 1.16758361e-01f, 1.59678504e-01f, -2.86540370e-02f, -9.46448207e-01f, -2.01987401e-02f, -7.07405746e-01f,
  -3.33434165e-01f, 1.19889751e-01f, -8.17529023e-01f, 3.05564106e-01f, -3.41063410e-01f, -9.46108937e-01f, -1.01967268e-01f, -8.34626146e-03f, 3.11353117e-01f, 8.34740791e-03f,
  9.22316462e-02f, 5.99389732e-01f, -9.31356788e-01f, 3.62564564e-01f, -1.80422187e-01f, 4.54090461e-02f, 7.19413683e-02f, 2.70166118e-02f, -3.16843018e-02f, -8.77157375e-02f,
  1.20810289e-02f, -3.22459757e-01f, 1.12464420e-01f, 8.74883354e-01f, -8.51745009e-02f, 6.56151593e-01f, 1.39075629e-02f, 8.21668029e-01f, 7.57708430e-01f, -3.87920141e-01f,
  5.20485342e-01f, -2.25890502e-01f, 4.74262476e-01f, 1.94494538e-02f, 4.48822081e-01f, 9.75560769e-02f, 1.11975625e-01f, 1.38798892e+00f, 2.12052077e-01f, -1.62771598e-01f,
  3.04298341e-01f, -5.08360922e-01f, 2.42712453e-01f, 1.01110578e-01f, 6.08157694e-01f, 4.45491850e-01f, -1.43894315e-01f, -3.40809643e-01f, 3.14619154e-01f, -1.58215567e-01f,
  -1.95801556e-01f, 6.97040498e-01f, 3.60724598e-01f, -5.10165513e-01f, 3.53478687e-03f, 9.27020013e-01f, 9.63171124e-01f, -2.75364891e-02f, 1.19826913e+00f, 4.26732838e-01f,
  6.31219864e-01f, 2.23185986e-01f, -5.68265654e-02f, -1.35248646e-01f, 3.54808778e-01f, 4.36162949e-01f, 7.68041015e-01f, 3.46074194e-01f, 1.49326250e-01f, -9.13312584e-02f,
  3.34066331e-01f, 1.09797966e+00f, 4.81470495e-01f, -5.82891256e-02f, -3.18477869e-01f, 2.10765693e-02f, 3.07353646e-01f, 8.48774970e-01f, -6.49315417e-02f, -1.00591934e+00f,
  3.91023606e-03f, 3.97042096e-01f, 4.39541310e-01f, 8.49525392e-01f, 3.18097383e-01f, -3.57006967e-01f, -3.40640098e-01f, 9.64776576e-01f, 2.91745305e-01f, 8.49006549e-02f,
  7.47205764e-02f, -1.36675045e-01f, 4.84361976e-01f, 3.85374427e-01f, -7.25937039e-02f, -2.49836713e-01f, 1.06043510e-01f, 4.76282425e-02f, -1.13087207e-01f, 3.16044152e-01f,
  -5.54072976e-01f, -4.48785663e-01f, 9.65805531e-01f, -2.54163533e-01f, -5.71870327e-01f, -2.05291957e-01f, 5.19935071e-01f, -3.14861864e-01f, 3.78011644e-01f, 5.76238692e-01f,
  1.68960243e-01f, 7.35825226e-02f, 1.36184141e-01f, -1.84193090e-01f, 2.15289861e-01f, 8.82804841e-02f, -9.98979151e-01f, -8.86831507e-02f, 9.53298092e-01f, 3.96568120e-01f,
  7.43151188e-01f, 3.75451297e-01f, 6.51783764e-01f, -2.20635131e-01f, -3.45856875e-01f, 5.25081575e-01f, 7.83532932e-02f, 4.94566225e-02f, 2.20619321e-01f, -4.91795510e-01f,
  2.69986749e-01f, -5.20831227e-01f, 4.27128017e-01f, 8.82250011e-01f, 2.84003079e-01f, -2.63125211e-01f, -5.00179589e-01f, 3.90838325e-01f, -2.73623079e-01f, 5.01899362e-01f,
  1.59642622e-01f, -2.86186308e-01f, 5.13456643e-01f, 4.70317960e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.96261728e-01f, -1.09772570e-01f, 6.98269606e-02f, 6.80833101e-01f, 5.43157339e-01f, 4.88685310e-01f, 1.46041676e-01f, 5.92349529e-01f, 2.92424768e-01f, 8.07823911e-02f,
  -2.89763641e-02f, 4.91252571e-01f, 5.96699774e-01f, 1.93440840e-02f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -2.11667418e-02f, -5.69517575e-02f, 1.61807477e-01f, 1.47067308e-01f, -1.67303860e-01f, 1.80764586e-01f, -5.33161819e-01f, 2.08985984e-01f, 2.13032529e-01f, -1.14582524e-01f,
  -4.50226329e-02f, -3.55302662e-01f, 6.42972514e-02f, 3.17059845e-01f, -9.56582576e-02f, 2.55685866e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  5.08773029e-01f, -1.40583917e-01f, 1.28985509e-01f, -2.69269086e-02f, 3.51758420e-01f, 6.56049848e-01f, -3.93968105e-01f, -5.90167105e-01f, 4.24482226e-01f, -2.53508329e-01f,
  1.22979172e-02f, 4.17563498e-01f, 4.41798568e-01f, -1.14943814e-02f, -2.03013197e-01f, 3.45998645e-01f, -8.38221610e-02f, 1.19108789e-01f, -2.42489437e-03f, 2.62821149e-02f,
  -1.74494833e-01f, -2.33255506e-01f, -2.76034713e-01f, 7.81780779e-02f, 1.50791004e-01f, -1.50980487e-01f, -8.46119225e-02f, -2.74582654e-01f, -1.08448245e-01f, -4.63588648e-02f,
  -2.16575757e-01f, -1.37472078e-01f, 1.26070172e-01f, -1.85005701e+00f, -3.74946415e-01f, 4.76839453e-01f, 5.84691703e-01f, 2.63839066e-01f, 6.39277637e-01f, 3.35127056e-01f,
  4.89840060e-01f, -4.96274466e-03f, -1.49823567e-02f, 2.05901619e-02f, -3.90760690e-01f, 8.74193907e-02f, 6.34401202e-01f, 4.24936622e-01f, 2.97338337e-01f, -9.08105969e-01f,
  7.64255300e-02f, -7.51257688e-02f, 4.73745465e-02f, 6.84217289e-02f, 8.86182129e-01f, 2.37923324e-01f, -2.16619059e-01f, 7.68868744e-01f, -5.27089536e-01f, 5.89857817e-01f,
  -6.65938929e-02f, -6.07291996e-01f, 3.41732562e-01f, 2.57464319e-01f, 2.11395144e-01f, -1.74115360e-01f, 6.61706030e-01f, -3.16413134e-01f, 9.41826463e-01f, 5.17675519e-01f,
  -2.56401360e-01f, 6.75168097e-01f, 4.43495542e-01f, -4.25455630e-01f, 3.08488280e-01f, -4.14110720e-01f, -2.07472131e-01f, 1.74919851e-02f, 5.85926712e-01f, 2.99874336e-01f,
  6.72245622e-01f, -9.24320996e-01f, -6.21937990e-01f, -1.18920982e-01f, -1.36089884e-02f, 4.96818036e-01f, 2.07000032e-01f, -9.28699613e-01f, -5.18791005e-02f, 2.62795120e-01f,
  -5.45734260e-03f, 3.32462043e-01f, 1.64520010e-01f, 3.64861012e-01f, -8.25574920e-02f, 1.07923187e-01f, 8.85424018e-03f, 3.02088205e-02f, 5.57530224e-01f, 6.48903251e-01f,
  2.86591295e-02f, -3.22801203e-01f, 1.32777587e-01f, 1.19140439e-01f, 1.07010223e-01f, 3.21653485e-01f, -1.33394729e-03f, -2.49915585e-01f, 3.85197103e-01f, -1.94556937e-01f,
  -5.54173708e-01f, 2.86724985e-01f, 4.35348988e-01f, 2.68395275e-01f, 4.88209069e-01f, 3.07269633e-01f, 1.39715359e-01f, -1.14019535e-01f, 5.39675772e-01f, 1.94503546e-01f,
  -7.62120664e-01f, 4.19232547e-01f, -7.62787640e-01f, 5.78624368e-01f, 2.01860681e-01f, -2.82281727e-01f, -2.23323748e-01f, 7.10549414e-01f, -7.20822334e-01f, 6.82947159e-01f,
  1.02354968e+00f, 3.43873322e-01f, -1.84372202e-01f, -5.12947738e-01f, 8.93641114e-02f, 5.13763964e-01f, 8.96203667e-02f, 3.62227082e-01f, 4.78463471e-01f, -3.58397126e-01f,
  -4.19450611e-01f, 1.71623170e-01f, 4.73636895e-01f, 5.26035786e-01f, -2.17928246e-01f, -7.14644134e-01f, 7.33745933e-01f, 3.60496372e-01f, -5.52607596e-01f, 1.18889354e-01f,
  4.30154800e-01f, -3.96681577e-02f, 4.25540149e-01f, 4.67799157e-01f, 2.94006914e-01f, -2.38817498e-01f, -1.02311462e-01f, -7.07508862e-01f, -7.97080547e-02f, 2.88997710e-01f,
  8.03224325e-01f, 2.02544659e-01f, -1.75198898e-01f, 1.81860596e-01f, -7.84785986e-01f, 4.04453903e-01f, 7.04496950e-02f, -7.43796155e-02f, 4.36022669e-01f, 3.76692325e-01f,
  3.99404705e-01f, 9.33612525e-01f, 9.77947116e-01f, 9.90460813e-02f, -5.37083298e-02f, -1.78952679e-01f, -3.99152696e-01f, -2.47314461e-02f, 6.87290668e-01f, 4.47442010e-02f,
  -6.45368099e-01f, -4.70635355e-01f, -7.55081475e-02f, -3.24734837e-01f, -3.11156213e-01f, 5.83910011e-02f, 2.81970203e-01f, -4.83134508e-01f, 3.29031646e-02f, -6.62928045e-01f,
  -1.80517435e-01f, 1.08019389e-01f, -4.59460169e-01f, -6.38841977e-03f, -5.66530406e-01f, -1.49132147e-01f, -1.78296357e-01f, -7.27236032e-01f, 8.29622746e-02f, 3.48458409e-01f,
  -3.00221771e-01f, 4.49512191e-02f, 3.98524106e-01f, 8.07452083e-01f, 7.69319832e-01f, -4.16259676e-01f, 5.17855883e-01f, -2.45726198e-01f, -2.83817381e-01f, 1.75959453e-01f,
  3.59173626e-01f, 6.21571004e-01f, -7.30806813e-02f, -2.82177180e-01f, -3.43260774e-03f, -4.84136259e-03f, -7.37162888e-01f, 3.31058949e-01f, 2.81639457e-01f, -1.33506432e-01f,
  -1.94339350e-01f, 7.77573347e-01f, 4.90869939e-01f, -4.18578774e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  6.32570907e-02f, -2.84408033e-01f, 9.76973996e-02f, 6.49310589e-01f, 1.50276542e-01f, 3.46228749e-01f, -2.68929034e-01f, 1.82349369e-01f, 6.22077100e-02f, -1.03337243e-01f,
  5.41193008e-01f, -2.09085066e-02f, 4.07589376e-02f, 3.22560400e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  3.53465766e-01f, -1.53399929e-01f, 2.19755083e-01f, 3.21557410e-02f, -1.33609629e+00f, 2.40217462e-01f, 2.53461357e-02f, -1.82255909e-01f, 1.37740970e-01f, 5.58046877e-01f,
  -3.84894460e-02f, -1.33178920e-01f, -1.47556663e-02f, -5.43676987e-02f, -6.01973534e-02f, -1.67190075e-01f, -5.38957953e-01f, -6.62879050e-01f, 1.21903084e-01f, -7.03834668e-02f,
  3.46930295e-01f, -1.07183911e-01f, 3.06673814e-02f, -8.31128716e-01f, 4.26150650e-01f, 1.61911398e-01f, 1.78285748e-01f, 3.25872153e-01f, -7.36741781e-01f, 3.40283692e-01f,
  -3.28963250e-01f, -5.65076292e-01f, 1.13404077e-02f, 3.29502299e-02f, -6.82893455e-01f, -1.00205407e-01f, -7.69073725e-01f, -5.91527402e-01f, -1.55786444e-02f, -7.90195465e-01f,
  2.49496818e-01f, -6.11077011e-01f, 2.76712358e-01f, 4.97192800e-01f, -5.47376037e-01f, 7.97121942e-01f, -8.72939304e-02f, 3.12940538e-01f, -3.76769006e-01f, -2.03973472e-01f,
  3.29305887e-01f, 2.64357124e-02f, -3.90162200e-01f, 2.38105193e-01f, -6.12482667e-01f, 1.42762840e-01f, -1.00591207e+00f, -2.47968554e-01f, -9.77884531e-01f, -3.29163820e-01f,
  2.54374206e-01f, -6.72392130e-01f, 7.51521945e-01f, -1.00361800e+00f, -4.47180837e-01f, -5.85846722e-01f, -1.09249778e-01f, -1.09123610e-01f, 5.07477641e-01f, 4.56458151e-01f,
  -2.10389465e-01f, 5.54245055e-01f, -4.67827260e-01f, 1.00118391e-01f, -5.51351726e-01f, 1.14448167e-01f, -1.44092098e-01f, -8.75541985e-01f, 1.41959310e-01f, 1.80785939e-01f,
  7.13665426e-01f, 3.96493524e-01f, -1.03222117e-01f, -1.58551186e-01f, 1.72215760e-01f, 4.16141957e-01f, -3.87288898e-01f, 2.98515469e-01f, -5.63070402e-02f, 4.66713309e-02f,
  -5.72537370e-02f, 4.00379002e-01f, 1.86031222e-01f, -1.39241779e+00f, -1.13220274e+00f, -2.67165512e-01f, -4.87196594e-01f, 5.56630313e-01f, -2.39428997e-01f, -1.78617448e-01f,
  2.88719796e-02f, -4.32578862e-01f, 3.24330896e-01f, -5.37301302e-01f, -5.93985677e-01f, -2.18534380e-01f, 3.56975198e-01f, -2.65494674e-01f, -1.26803994e+00f, -2.41329983e-01f,
  -5.99869549e-01f, 4.60273832e-01f, 4.80775870e-02f, 1.58572376e-01f, -1.17758967e-01f, -1.28609374e-01f, 2.11787671e-01f, -9.44000296e-03f, 2.02714235e-01f, -6.62481129e-01f,
  5.58258314e-03f, -4.39028084e-01f, 1.43297361e-02f, -3.31878930e-01f, 8.77996534e-02f, -6.03932798e-01f, 6.78194761e-01f, -5.59578598e-01f, -1.17224187e-01f, 2.33406857e-01f,
  3.56133789e-01f, 1.03531256e-01f, -1.44777104e-01f, -1.00807691e+00f, 1.65681238e-03f, 4.38436382e-02f, -4.83613968e-01f, -3.83460373e-01f, -1.39103562e-01f, 5.15852809e-01f,
  5.20273209e-01f, -9.38270427e-03f, -6.72716379e-01f, -7.62108445e-01f, 6.49969339e-01f, 5.00741422e-01f, -9.85537052e-01f, 1.06160238e-01f, -7.53431320e-02f, -6.38806581e-01f,
  -2.84914643e-01f, -4.99066979e-01f, -6.38923466e-01f, -6.55646622e-01f, 3.23407412e-01f, -3.80289406e-01f, 6.67962134e-02f, -1.20018816e+00f, 7.66389072e-02f, 7.60495543e-01f,
  1.03193805e-01f, 4.77913231e-01f, 3.47865880e-01f, -2.00171247e-01f, -6.26903296e-01f, -1.22748435e+00f, -1.35393798e+00f, 2.15872869e-01f, 6.44600034e-01f, -7.78755188e-01f,
  -5.23622751e-01f, 1.49376187e-02f, 6.74708545e-01f, -1.03328812e+00f, -1.65921733e-01f, 1.12045920e-02f, -6.48370206e-01f, -3.82219627e-02f, 4.63218361e-01f, -1.87200848e-02f,
  3.76715839e-01f, -5.48353612e-01f, 2.52760947e-01f, 4.08115357e-01f, -3.99301618e-01f, -1.13103437e+00f, -4.75291908e-01f, -1.17621994e+00f, -2.98348218e-01f, -1.29304814e+00f,
  -6.80389047e-01f, -4.12408143e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  9.72379223e-02f, -7.56266236e-01f, -1.87864095e-01f, -2.91347444e-01f, 3.74737352e-01f, 7.39639997e-02f, -1.65394265e-02f, -1.16107613e-01f, -1.41586304e-01f, 3.48840654e-01f,
  -4.31691296e-02f, 2.36122496e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    