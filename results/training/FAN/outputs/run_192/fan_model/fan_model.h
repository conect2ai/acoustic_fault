/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.41822028e-01f, 1.23154908e-01f, -2.04837710e-01f, -2.40388632e-01f, 1.27566308e-01f, -1.87834457e-01f, -4.19067532e-01f, 1.12206832e-01f, 3.21256429e-01f, 4.72362936e-02f,
  8.16446915e-02f, -4.60336655e-02f, 8.47593397e-02f, -1.31481886e-01f, -2.96934366e-01f, 1.55134246e-01f, -1.66193202e-01f, -1.41800776e-01f, 2.78752655e-01f, -7.14540705e-02f,
  5.57905547e-02f, 6.80453181e-02f, -2.53912240e-01f, 2.03946397e-01f, -2.12572634e-01f, 4.59466353e-02f, -1.33762315e-01f, 8.23525339e-02f, -2.00872779e-01f, -7.50320684e-03f,
  -6.94072917e-02f, 2.08192959e-01f, -4.25198339e-02f, 2.88708843e-02f, -6.11979738e-02f, -1.06053963e-01f, -1.61809668e-01f, -7.94173405e-02f, 2.06343811e-02f, 1.25860628e-02f,
  -2.98770797e-02f, 4.96078096e-03f, 4.72628400e-02f, 6.32780567e-02f, -1.76180620e-02f, -4.43292223e-03f, -1.44679686e-02f, -3.13917473e-02f, -3.20562236e-02f, 2.18770765e-02f,
  2.43493402e-03f, -7.34743178e-02f, -6.97511062e-02f, -2.86019035e-03f, -5.26360199e-02f, 1.32285431e-02f, -8.34576711e-02f, -1.67387314e-02f, -1.92444697e-02f, 7.03194812e-02f,
  4.42474522e-02f, 8.20131153e-02f, -4.15673293e-02f, 4.44725640e-02f, -1.01383245e-02f, 2.37408001e-02f, -1.89557895e-02f, 4.70823422e-02f, 2.52113715e-02f, -1.88762192e-02f,
  -3.89665775e-02f, -1.95551980e-02f, 1.78580899e-02f, -5.24147898e-02f, -3.12444586e-02f, -2.55636014e-02f, -6.70723841e-02f, 3.47262733e-02f, -5.63832298e-02f, -1.09740708e-03f,
  1.43888565e-02f, -3.01852520e-03f, 9.91829764e-03f, -5.25778383e-02f, 4.91215698e-02f, -3.33181322e-02f, 8.16375464e-02f, 1.60883982e-02f, -1.35921780e-02f, -9.80518609e-02f,
  2.10830215e-02f, 1.73405349e-01f, 6.77725226e-02f, 2.71266513e-02f, 5.07131219e-02f, -1.24805886e-02f, 6.41311780e-02f, 1.24458671e-02f, 1.40048540e-03f, 2.34584976e-02f,
  -4.65595908e-02f, -3.51541117e-02f, -8.46587196e-02f, -3.40041667e-02f, -8.96559805e-02f, 8.90388712e-03f, -8.56414065e-02f, -1.61749423e-02f, -6.82685152e-02f, -3.21971416e-03f,
  -2.34542359e-02f, 8.38303752e-03f, -9.12339333e-03f, 1.29927974e-02f, -4.74156365e-02f, -8.87301564e-02f, 2.00430769e-03f, 1.37234498e-02f, -4.87749353e-02f, 2.10940233e-03f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.79451919e-01f, 3.01580806e-03f, -2.07207695e-01f, -1.92756027e-01f, -2.72743076e-01f, -3.42103839e-01f, -2.74575967e-02f, -3.02303553e-01f, -8.13919008e-02f, 3.13837379e-01f,
  1.67634636e-01f, -2.33709514e-01f, 4.16612923e-01f, 1.42970175e-01f, -2.00375289e-01f, 4.82306212e-01f, -2.68366523e-02f, 8.41426402e-02f, -1.33383758e-02f, -3.41549635e-01f,
  -7.74434209e-02f, -8.74840692e-02f, 7.74523243e-02f, -1.82546392e-01f, -1.73751637e-01f, -2.55897343e-01f, 4.47575413e-02f, -5.94251901e-02f, -1.54725807e-02f, 6.01039268e-02f,
  -2.77074099e-01f, -3.38708907e-01f, -1.52330205e-01f, -7.38093033e-02f, -1.50545269e-01f, -1.79971606e-02f, -1.76748261e-02f, 8.11512247e-02f, -8.30003694e-02f, -9.88218114e-02f,
  -5.70171326e-02f, -9.91242453e-02f, 4.56038909e-03f, 3.02662570e-02f, -1.23430833e-01f, -9.76134911e-02f, -6.65046126e-02f, 6.00204691e-02f, -6.81132600e-02f, -8.62725750e-02f,
  -2.30072141e-02f, 5.42190149e-02f, -3.17071788e-02f, 5.45828380e-02f, 5.94242709e-04f, -1.56560615e-02f, 2.77064666e-02f, 3.88436876e-02f, -9.11316499e-02f, -8.84949788e-02f,
  -4.97433124e-03f, -2.15885732e-02f, -8.76255275e-04f, -3.64771821e-02f, -6.66790605e-02f, 6.94502071e-02f, -2.93404702e-02f, 3.49487215e-02f, -2.76091360e-02f, 1.14584845e-02f,
  -4.86914478e-02f, -3.19017395e-02f, -1.63302831e-02f, 1.62208062e-02f, 4.54901764e-03f, 3.68853882e-02f, -1.70919280e-02f, -1.83434915e-02f, 9.52100456e-02f, -2.11201012e-02f,
  -3.92111577e-02f, -3.35799307e-02f, 1.18224934e-01f, 7.36890510e-02f, -4.87047657e-02f, 7.63311386e-02f, 5.69889881e-02f, 2.25106459e-02f, 2.67554447e-02f, -1.61417220e-02f,
  -3.65198642e-01f, -4.50205415e-01f, -1.19617887e-01f, -1.21746399e-01f, -3.76492459e-03f, -1.05617210e-01f, 2.37578377e-02f, -9.82974470e-02f, -2.98197418e-02f, -8.53305534e-02f,
  -3.90140675e-02f, 5.17344400e-02f, -5.92286140e-02f, 2.59577762e-02f, -8.70966986e-02f, -1.25205722e-02f, 5.59366457e-02f, -2.02874038e-02f, -1.65656731e-01f, -1.03020772e-01f,
  -1.30019132e-02f, 5.45058865e-03f, 1.09539982e-02f, -4.82973121e-02f, 1.94927044e-02f, -8.80374946e-03f, -1.04491010e-01f, -4.90161292e-02f, -6.16367497e-02f, 5.73516190e-02f,
  -3.29789817e-01f, 2.23348737e-02f, -3.96553278e-01f, -1.72724962e-01f, 1.57801777e-01f, 2.35276610e-01f, 8.62513930e-02f, 1.47101313e-01f, -3.23147357e-01f, 4.16041940e-01f,
  4.76520717e-01f, -9.90801454e-02f, -3.65290977e-02f, 2.78475106e-01f, 2.04011485e-01f, 2.83701085e-02f, 4.37504649e-01f, 2.40718320e-01f, -6.59746453e-02f, 3.17139000e-01f,
  4.30586226e-02f, 5.03063440e-01f, 5.50023243e-02f, 2.98565716e-01f, 1.90603256e-01f, -8.97798911e-02f, 2.85902768e-01f, -1.08142860e-01f, 3.14341009e-01f, 1.87141269e-01f,
  7.91661069e-02f, -7.94327632e-02f, -1.77373271e-02f, -2.06125870e-01f, 5.04661864e-03f, 3.36861201e-02f, -2.64604278e-02f, -1.17046908e-01f, 5.83487214e-04f, 3.14879306e-02f,
  -1.52937636e-01f, 1.77661255e-02f, -6.19322294e-03f, -1.96414106e-02f, -1.11321881e-02f, -2.99467631e-02f, -6.40600128e-03f, -5.72257526e-02f, -6.04171492e-02f, -4.13952246e-02f,
  -4.52028364e-02f, -1.29961418e-02f, 4.73212153e-02f, -1.89848132e-02f, -3.40755619e-02f, 3.30209583e-02f, -2.77353190e-02f, -2.67687514e-02f, -2.29954105e-02f, 4.01754342e-02f,
  7.17791840e-02f, -4.11571609e-03f, 9.44882855e-02f, -3.91040407e-02f, -1.62445698e-02f, 4.93323877e-02f, 4.59514186e-02f, 3.40015702e-02f, -8.38381872e-02f, 6.65893331e-02f,
  -5.79283796e-02f, -4.65528332e-02f, -1.65001266e-02f, 4.40801401e-03f, 1.16543695e-01f, -5.17745093e-02f, -5.19576706e-02f, 1.05341889e-01f, -5.29953688e-02f, -7.96720907e-02f,
  -4.06761505e-02f, 4.16386314e-02f, 3.33633237e-02f, -3.97327431e-02f, -2.04621460e-02f, 3.80548462e-02f, 7.96007290e-02f, -1.09790880e-02f, 1.81697011e-02f, -4.69630910e-03f,
  2.13051468e-01f, 2.20291138e-01f, -7.49895424e-02f, -9.52399522e-02f, 3.57745327e-02f, 7.70907328e-02f, -5.18869609e-02f, 2.89445128e-02f, -1.51719642e-03f, -6.61609992e-02f,
  7.01554352e-04f, 9.90513526e-03f, 4.20555249e-02f, -3.22289430e-02f, 2.51247101e-02f, 6.44345507e-02f, 1.36590479e-02f, 2.41112839e-02f, 6.11942671e-02f, 1.07762262e-01f,
  -1.59245785e-02f, 7.24911615e-02f, -2.19975151e-02f, -6.44004419e-02f, 1.18931178e-02f, 6.21859245e-02f, -5.41122688e-04f, 5.24628023e-03f, 2.95899939e-02f, 1.60710011e-02f,
  -5.29227912e-01f, 3.16812634e-01f, 6.76835895e-01f, -3.70939583e-01f, 6.47648498e-02f, 2.16848105e-01f, 1.77225292e-01f, -1.07711002e-01f, -2.40874544e-01f, -1.67789444e-01f,
  -1.03736900e-01f, 4.80969578e-01f, 3.34788144e-01f, -1.35279521e-02f, -2.46735200e-01f, -3.34548056e-02f, -3.48627061e-01f, -4.95260134e-02f, 9.28114057e-02f, -1.27885006e-02f,
  -2.48396963e-01f, -1.65948451e-01f, 1.54994458e-01f, 7.03792498e-02f, 1.02067046e-01f, -3.10281869e-02f, -3.77293646e-01f, 4.68979895e-01f, -8.10481831e-02f, 2.22968504e-01f,
  -3.70541215e-02f, -5.21432795e-02f, 1.23212844e-01f, 1.48999915e-01f, -1.17704324e-01f, -4.71411198e-02f, -7.34757446e-03f, 1.57625258e-01f, 1.77437384e-02f, -4.77510281e-02f,
  4.04336043e-02f, 9.08364952e-02f, -7.33791292e-02f, 7.55816326e-02f, 3.07432227e-02f, 3.24685462e-02f, 1.16209269e-01f, 5.18526584e-02f, 1.63293675e-01f, 1.56669140e-01f,
  1.25573322e-01f, 9.89803672e-02f, -2.60992441e-02f, -6.95512146e-02f, 1.70285664e-02f, -1.04491937e-03f, -2.21203715e-02f, 6.30946606e-02f, -3.95135172e-02f, -1.09874532e-01f,
  3.95576507e-02f, -3.04770004e-02f, 7.09073320e-02f, 7.32668862e-02f, 3.50381695e-02f, 3.39542106e-02f, 1.06706612e-01f, 2.82598920e-02f, -1.25619350e-02f, 3.15130241e-02f,
  -5.72304688e-02f, 2.22546253e-02f, -8.01875908e-03f, -1.82824628e-03f, -2.20309868e-02f, -2.69296784e-02f, 4.84712459e-02f, 1.04991430e-02f, -3.69615927e-02f, 3.41225322e-03f,
  -9.40120500e-03f, -9.67683792e-02f, 3.30998823e-02f, -6.19170666e-02f, -1.12814447e-02f, 8.34670477e-03f, 3.02175749e-02f, 6.42930642e-02f, -9.28000435e-02f, 2.20012143e-02f,
  -2.51369834e-01f, -3.33913714e-01f, 3.70636694e-02f, 6.73673302e-02f, 4.60634120e-02f, -2.04672199e-03f, 1.78865530e-02f, -3.62357348e-02f, -7.48080611e-02f, -4.11602333e-02f,
  -8.46936852e-02f, -6.01946674e-02f, 4.60557081e-02f, 2.90564373e-02f, 8.33538827e-03f, -1.09816350e-01f, -1.08042352e-01f, -3.14630494e-02f, -4.41255532e-02f, -3.53895500e-02f,
  8.78004804e-02f, -7.55846202e-02f, -2.26349924e-02f, -1.12843715e-01f, -1.23184219e-01f, -6.06911071e-02f, -4.97821122e-02f, -2.62280996e-03f, -1.84042081e-02f, 4.01013382e-02f,
  -1.65118158e-01f, 7.23239705e-02f, 6.31222129e-02f, 3.74552250e-01f, -1.20643184e-01f, -4.59932774e-01f, -3.41230303e-01f, 1.59334868e-01f, -1.12155154e-01f, -1.03976630e-01f,
  7.89159760e-02f, -7.09922686e-02f, -9.68021750e-02f, 4.94787060e-02f, 1.86023131e-01f, -9.14279148e-02f, 2.08866596e-01f, -1.18702635e-01f, 1.52308801e-02f, 3.48427683e-01f,
  3.83238435e-01f, 4.00532514e-01f, 4.17131513e-01f, 3.23236614e-01f, 5.69858588e-02f, 4.30051237e-01f, 5.61146259e-01f, 9.71388370e-02f, 4.07629013e-01f, -3.56932729e-03f,
  -1.28018826e-01f, 1.21708341e-01f, -4.45733778e-02f, -7.47161731e-02f, 5.93658201e-02f, -1.08313166e-01f, -3.29950303e-02f, -5.47950380e-02f, 2.48416010e-02f, 5.73353954e-02f,
  -4.79715019e-02f, 1.98317040e-02f, 1.91986188e-02f, 1.90884434e-02f, -4.86546755e-02f, 6.01910651e-02f, 3.12747573e-03f, -7.60245323e-02f, 2.69045066e-02f, 1.90245286e-02f,
  3.86631303e-02f, 3.19454595e-02f, 1.77861601e-02f, -7.62125244e-03f, 4.09010053e-03f, -6.07821979e-02f, -7.75175467e-02f, -2.09461711e-03f, -3.28991096e-03f, 5.94476461e-02f,
  1.51975438e-01f, -5.15147336e-02f, -1.58092380e-01f, -3.38987820e-02f, 1.31604029e-02f, -1.34661440e-02f, -2.80828285e-03f, 5.58680680e-04f, -1.48743801e-02f, -2.45618597e-02f,
  1.51007669e-02f, 4.29815575e-02f, -7.03399107e-02f, -4.55966070e-02f, -3.08202356e-02f, -7.61046186e-02f, 1.23207811e-02f, -9.92033514e-04f, 3.79300453e-02f, 4.77809273e-02f,
  -6.18412625e-03f, -2.46530510e-02f, 3.25616375e-02f, 1.68984495e-02f, -4.78616133e-02f, -1.25375250e-02f, 3.60849984e-02f, -6.92616180e-02f, 1.55012077e-02f, 6.06597289e-02f,
  1.77357510e-01f, 5.66271663e-01f, -1.50224278e-02f, -1.13199085e-01f, 7.14035332e-03f, -3.36997001e-03f, 1.92961339e-02f, 1.94122847e-02f, 6.66474178e-02f, 3.82258408e-02f,
  1.09966576e-01f, 1.08039333e-02f, -1.49668474e-02f, 4.40427624e-02f, 9.00979936e-02f, 6.68755174e-02f, 9.21511278e-02f, 6.93411008e-02f, 9.61607695e-02f, 1.74866751e-01f,
  1.07212029e-01f, -1.25789875e-02f, 8.25308710e-02f, 1.46486452e-02f, 3.74532156e-02f, 1.08314753e-01f, 1.79912057e-03f, 2.10613627e-02f, 5.58627807e-02f, 7.32919499e-02f,
  -3.18116635e-01f, 1.58008844e-01f, -2.37376750e-01f, -1.30438715e-01f, -5.17867208e-01f, -2.02144504e-01f, 3.33601497e-02f, -1.78952157e-01f, 2.66712129e-01f, 4.27492827e-01f,
  3.19706909e-02f, 5.45416437e-02f, 5.01359820e-01f, -1.97706111e-02f, -2.56786525e-01f, 3.72946024e-01f, -1.00608272e-02f, 1.46972358e-01f, 4.50394303e-02f, -1.90523222e-01f,
  -2.33170718e-01f, -5.31928763e-02f, -6.00052513e-02f, -1.77471250e-01f, -4.74504799e-01f, -1.69230714e-01f, -1.44272476e-01f, -3.05230916e-02f, -3.33732545e-01f, -1.66817367e-01f,
  -1.78928167e-01f, 1.97366506e-01f, -1.06176361e-01f, 1.32915646e-01f, -1.11798093e-01f, -1.23780087e-01f, -7.47172311e-02f, -6.15245551e-02f, 3.60139720e-02f, -3.59698534e-02f,
  -7.78774545e-02f, -3.13618295e-02f, 1.37145659e-02f, 1.05200678e-01f, -7.37147629e-02f, 1.09712500e-02f, -9.37799960e-02f, -6.00874163e-02f, 1.43290469e-02f, -5.21759540e-02f,
  4.30370420e-02f, -1.05607606e-01f, -3.52735519e-02f, 6.59394041e-02f, -2.70685963e-02f, -1.88911725e-02f, 1.62513126e-02f, -1.04344204e-01f, -2.51827035e-02f, -5.18301874e-02f,
  1.90681908e-02f, 3.75678614e-02f, 1.14721164e-01f, 4.29188684e-02f, -2.10080445e-02f, -3.51527035e-02f, 5.26049584e-02f, -1.62935629e-02f, -2.33192425e-02f, -3.99493799e-02f,
  -2.04628631e-02f, -1.85633563e-02f, -5.88999735e-03f, -4.05804906e-03f, -3.62618342e-02f, 6.45579472e-02f, 2.96433140e-02f, -3.39022465e-02f, -6.55192286e-02f, -7.42464960e-02f,
  9.12420154e-02f, 2.77668666e-02f, -6.70179129e-02f, -6.46579564e-02f, 9.40368138e-03f, -4.39873561e-02f, 3.07758581e-02f, 3.45444307e-02f, 6.59027100e-02f, -2.20768191e-02f,
  -1.55765593e-01f, 3.31281871e-02f, 9.24611539e-02f, 2.96853594e-02f, 1.54436694e-03f, -4.90066819e-02f, 6.14343723e-03f, -3.19240130e-02f, -1.07908949e-01f, 1.03764154e-01f,
  -9.89768468e-03f, 4.01406549e-02f, -5.67045808e-02f, 4.02318723e-02f, 1.22316152e-01f, -1.02615714e-01f, -3.34734730e-02f, -3.88559932e-03f, 2.53085364e-02f, 8.79907049e-03f,
  -3.90999690e-02f, 1.03775375e-01f, 5.79728596e-02f, 1.39377797e-02f, -3.42481695e-02f, 1.40164169e-02f, -4.99244556e-02f, -1.86689887e-02f, -8.33881125e-02f, 1.03919965e-03f,
  -4.02451545e-01f, 4.08478618e-01f, 4.84641880e-01f, -1.79104060e-01f, 4.25777107e-01f, 2.11229339e-01f, 5.25598833e-03f, 4.96673375e-01f, 4.39090520e-01f, -1.17841601e-01f,
  -5.82586713e-02f, -2.95195341e-01f, 2.32530594e-01f, -1.61993667e-01f, -2.41803378e-01f, 9.42933783e-02f, -1.66175216e-01f, -1.90139890e-01f, 2.46356413e-01f, -1.31185412e-01f,
  -3.83129269e-02f, -2.53266215e-01f, 8.41005296e-02f, 6.15921319e-02f, -4.38839421e-02f, -8.46285373e-03f, -3.86084586e-01f, 4.69752774e-02f, -2.13125467e-01f, -5.09509966e-02f,
  -1.65133148e-01f, -1.51479691e-01f, -6.55006021e-02f, -5.88606149e-02f, -1.34562217e-02f, -1.27254590e-01f, -1.58210561e-01f, -2.66817082e-02f, 4.65999842e-02f, 1.26192898e-01f,
  -1.05358578e-01f, 1.67373195e-02f, -2.58011874e-02f, 1.04333870e-02f, 5.89161702e-02f, 6.69071302e-02f, 8.90783519e-02f, 7.39746764e-02f, 3.08736023e-02f, 1.45273551e-01f,
  9.20375437e-02f, 3.45900655e-02f, -2.59346664e-02f, -2.52644885e-02f, -1.22301057e-02f, 1.19773678e-01f, 2.81086210e-02f, -4.62989658e-02f, -3.79360095e-02f, 8.64054263e-02f,
  1.32406112e-02f, -4.54798900e-02f, 2.56297877e-03f, -4.76022623e-02f, -1.66724343e-02f, 4.22977954e-02f, -6.84114099e-02f, -1.35701537e-01f, 5.18809073e-02f, -7.60411248e-02f,
  -2.43901163e-02f, -3.64359282e-02f, 3.52929980e-02f, 2.16248538e-02f, -1.91991478e-02f, -3.33698727e-02f, -1.01581477e-01f, 7.75184901e-03f, 4.54785349e-03f, -2.23969761e-02f,
  1.17752189e-02f, -2.20721262e-03f, 4.26724702e-02f, -1.02660088e-02f, 4.75684553e-02f, 1.54229235e-02f, 5.41959482e-04f, 6.43940568e-02f, 2.78348774e-02f, -1.06440827e-01f,
  -4.70396936e-01f, -3.90344173e-01f, 1.13457851e-02f, -7.82999769e-02f, -7.26273879e-02f, -4.28176764e-03f, -1.20104635e-02f, -1.27585875e-02f, -8.52749720e-02f, 2.11493187e-02f,
  -4.17439155e-02f, -5.62575459e-02f, -5.84687404e-02f, -2.13228371e-02f, -5.50875738e-02f, 2.41669081e-02f, -7.51433074e-02f, -1.38356730e-01f, -1.65397435e-01f, 3.24217253e-03f,
  -1.47853822e-01f, -2.86843218e-02f, -2.46798657e-02f, 3.79862264e-02f, 1.84450287e-03f, -1.24345966e-01f, -9.71883014e-02f, 2.25533284e-02f, -3.06881089e-02f, -2.71733478e-02f,
  -2.93134779e-01f, -4.28613007e-01f, -1.26686677e-01f, -7.74848834e-02f, 1.20547727e-01f, 1.93795174e-01f, 3.54641676e-02f, -1.79894716e-01f, -5.30591547e-01f, -4.33341801e-01f,
  -3.03610768e-02f, -1.53908372e-01f, -2.66154170e-01f, -2.86446270e-02f, 3.50516737e-01f, -6.36900663e-02f, -2.21685157e-03f, -4.30642404e-02f, 8.02323222e-03f, -7.06111863e-02f,
  1.02274697e-02f, 1.60804614e-01f, 2.04186380e-01f, 2.26420149e-01f, -1.15589112e-01f, -4.66051809e-02f, 1.50915191e-01f, 2.93403089e-01f, 3.22584271e-01f, 2.75146425e-01f,
  -9.99250114e-02f, -3.31780702e-01f, -9.14034620e-02f, -1.21040598e-01f, -7.61396438e-02f, -2.93162633e-02f, 4.27973270e-02f, 2.29504675e-01f, 1.64538492e-02f, -5.85589111e-02f,
  -3.58414724e-02f, 8.97035450e-02f, 3.46381515e-02f, 8.29116162e-03f, -9.58741382e-02f, 4.66087386e-02f, 1.01256678e-02f, -1.43035561e-01f, -2.78482903e-02f, 7.99890794e-03f,
  -5.50343245e-02f, -6.38320744e-02f, -4.55466248e-02f, 8.21453333e-02f, 3.17717809e-03f, 4.45502661e-02f, -3.36622191e-03f, -3.42203653e-03f, -5.32979183e-02f, 3.26749943e-02f,
  5.92694879e-02f, 6.20492399e-02f, -2.10092589e-03f, -5.13179712e-02f, -2.99039930e-02f, -3.71535905e-02f, -2.72362810e-02f, -4.36517708e-02f, 9.76648778e-02f, -5.99844381e-02f,
  -5.42743579e-02f, -1.01815000e-01f, -4.60403934e-02f, 3.10724694e-02f, -3.32581140e-02f, -5.99261038e-02f, 3.18269730e-02f, 4.25407067e-02f, -4.29291278e-03f, 9.40875337e-03f,
  -3.89804989e-02f, 4.69484404e-02f, -6.79323152e-02f, 7.16413781e-02f, 6.16208799e-02f, -3.36053148e-02f, 2.78368406e-02f, -3.59479450e-02f, -2.15147063e-02f, 1.11826733e-02f,
  -2.43843883e-01f, -2.83146173e-01f, 4.88008792e-03f, -4.20171358e-02f, 1.90473236e-02f, 3.46046798e-02f, 1.81423817e-02f, -8.74173176e-03f, -5.46633601e-02f, -6.30636290e-02f,
  -3.23512480e-02f, 4.89990897e-02f, -2.96760292e-04f, -1.13787304e-03f, 1.32747173e-01f, -5.19229956e-02f, -8.15608725e-02f, -6.15416281e-02f, -2.28152554e-02f, 5.65905459e-02f,
  -6.94323704e-02f, 3.21252830e-02f, 4.80993018e-02f, 3.07278465e-02f, 2.02728827e-02f, 6.28229603e-03f, -1.16802920e-02f, 6.30964860e-02f, 6.82050437e-02f, 5.03197387e-02f,
  -4.26872551e-01f, -1.41588494e-01f, -5.14367461e-01f, -2.74995714e-01f, 3.80965710e-01f, -3.38127375e-01f, -6.01901524e-02f, 8.49594995e-02f, -1.16820209e-01f, 2.57987291e-01f,
  1.69513807e-01f, -3.84734541e-01f, 2.45148931e-02f, -4.54101324e-01f, -7.07324862e-01f, -3.50237966e-01f, -4.56220001e-01f, -2.90755093e-01f, -1.96006700e-01f, 2.46907193e-02f,
  -2.04051673e-01f, 1.77414924e-01f, -3.56845379e-01f, 4.86797303e-01f, 1.13027059e-02f, 2.54981279e-01f, 2.88104624e-01f, 3.48532677e-01f, -1.46480098e-01f, -7.27229239e-03f,
  -2.06193104e-01f, -3.99297178e-02f, -2.49246825e-02f, -8.92058015e-02f, 1.74028669e-02f, 1.00755274e-01f, 3.21431551e-03f, -8.03729612e-03f, -1.93946622e-02f, -6.25619963e-02f,
  2.30090693e-02f, -1.82767063e-02f, -6.97818547e-02f, 3.51684578e-02f, 1.55651554e-01f, 1.80213470e-02f, -9.93041173e-02f, -4.84429933e-02f, 2.39305664e-02f, -1.24590330e-01f,
  -1.44285157e-01f, -1.16392173e-01f, -3.86665687e-02f, -9.94041786e-02f, -9.06985924e-02f, 7.16967648e-03f, -5.25560528e-02f, -5.62470071e-02f, -7.23515823e-02f, 1.52465459e-02f,
  6.37707934e-02f, 4.26778756e-02f, -4.40913402e-02f, 3.88793126e-02f, 2.49921437e-02f, 3.48504144e-03f, -7.23104971e-03f, 2.96757184e-02f, 1.02245463e-02f, 5.02817445e-02f,
  2.37994771e-02f, 1.56310573e-02f, 2.40131244e-02f, -2.14941204e-02f, -8.88877828e-03f, 2.57836692e-02f, -4.10500616e-02f, 1.46045396e-02f, -3.34103182e-02f, -8.16192925e-02f,
  7.23571777e-02f, -6.91915601e-02f, 2.70500891e-02f, -2.44106241e-02f, -6.17732331e-02f, -1.43262707e-02f, 8.83430541e-02f, -9.57798585e-02f, -1.72999117e-03f, 2.69866697e-02f,
  1.04354033e-02f, 8.59786123e-02f, 2.75638010e-02f, 3.22165936e-02f, -5.48250638e-02f, 1.63127296e-02f, -1.15987070e-01f, -8.80636424e-02f, 8.01222958e-03f, 3.68120074e-02f,
  8.64958763e-02f, 9.93963629e-02f, 6.02508802e-03f, -1.85400583e-02f, 2.80412962e-03f, 3.21024619e-02f, 4.76913862e-02f, 6.47172108e-02f, 7.47019500e-02f, -8.23720545e-02f,
  8.70844945e-02f, 6.75203130e-02f, 4.73129302e-02f, 1.04162380e-01f, 2.16163006e-02f, 4.96133864e-02f, 4.11423706e-02f, -1.02693876e-02f, 4.19786572e-02f, -7.49872550e-02f,
  2.03281194e-02f, 5.67265809e-01f, 4.44108658e-02f, 1.50011256e-01f, -2.29495704e-01f, 3.75782430e-01f, 6.69751823e-01f, -1.03189148e-01f, 2.08995774e-01f, 4.82666612e-01f,
  5.48301972e-02f, 3.89291704e-01f, 6.79243263e-03f, 3.34169477e-01f, -7.39477798e-02f, 1.83842152e-01f, 4.33192760e-01f, 4.44668978e-01f, 9.83568728e-02f, 2.83941012e-02f,
  -1.84664518e-01f, 1.60976112e-01f, -9.20793712e-02f, -1.26158193e-01f, 1.74774587e-01f, -4.38394658e-02f, -2.22197473e-01f, -1.58386588e-01f, 1.04604289e-01f, 4.20204997e-02f,
  1.23736531e-01f, 3.58497538e-02f, -3.22458968e-02f, 2.80159153e-02f, 5.43129444e-02f, -9.90099506e-04f, 5.27332202e-02f, -7.79235587e-02f, -4.80024107e-02f, -2.77901907e-03f,
  9.45612714e-02f, -4.43713320e-03f, 7.45341182e-02f, -8.43390450e-02f, 2.20389524e-03f, -2.11354177e-02f, -3.16705406e-02f, -4.06806879e-02f, 9.89796966e-02f, 2.18738467e-02f,
  4.46627215e-02f, 2.60793343e-02f, -7.92679861e-02f, 1.55403420e-01f, -7.66949356e-02f, 4.49706092e-02f, 1.42107517e-01f, -9.58302617e-03f, 5.16733155e-02f, 7.99926445e-02f,
  3.28222737e-02f, 6.95484281e-02f, 1.43851889e-02f, -7.74317682e-02f, 1.73807163e-02f, -1.46791618e-02f, -4.55378741e-02f, -9.60084982e-03f, 2.13140119e-02f, 1.53706446e-02f,
  -4.03332785e-02f, -4.38364781e-03f, -3.22928019e-02f, 7.03684287e-03f, -2.47055180e-02f, 5.25958203e-02f, -9.15819779e-02f, 7.00661391e-02f, 8.99513252e-03f, -5.90745211e-02f,
  2.21146252e-02f, 5.66969737e-02f, 6.20293953e-02f, 2.58538313e-02f, 9.01796669e-02f, -7.92271942e-02f, 4.98917103e-02f, -2.14857217e-02f, 5.67943091e-03f, -1.00838408e-01f,
  1.30716205e-01f, 2.66242176e-01f, 3.92830707e-02f, 5.10687791e-02f, 7.29504898e-02f, -6.08866885e-02f, 8.19660723e-02f, -3.59833576e-02f, 8.37895870e-02f, 8.06902274e-02f,
  -1.29222259e-01f, 5.08307144e-02f, 1.91380288e-02f, -4.28675860e-03f, 5.19670248e-02f, 4.35965881e-02f, 1.13482058e-01f, 2.52843164e-02f, 3.25914361e-02f, -6.63520917e-02f,
  -2.41197683e-02f, 5.00505082e-02f, 1.59211084e-02f, 2.44924687e-02f, 1.05424546e-01f, -3.33194397e-02f, -3.06038875e-02f, 2.99006444e-03f, 2.87567247e-02f, 5.21775670e-02f,
  7.81067014e-01f, 1.68600470e-01f, -3.73722076e-01f, -3.65364105e-02f, 7.43558034e-02f, 5.06780505e-01f, 3.76388222e-01f, 2.05511853e-01f, 3.30422103e-01f, 1.79081470e-01f,
  2.93723401e-02f, 3.38778943e-02f, -2.88475845e-02f, 1.31489322e-01f, 2.87902355e-01f, 1.45106658e-01f, 3.65928948e-01f, 9.97023508e-02f, 1.09989494e-01f, 1.40731037e-01f,
  9.31484327e-02f, 2.10321382e-01f, -4.24517065e-01f, 7.56279472e-03f, -4.61991690e-02f, -1.70138165e-01f, -1.84282809e-01f, -2.36789376e-01f, -8.13084245e-02f, 1.23261683e-01f,
  -1.04236454e-01f, -4.26042341e-02f, -1.85434744e-01f, -2.78986599e-02f, -7.41180331e-02f, -3.72259989e-02f, -6.04049005e-02f, 1.04347439e-02f, -1.43216759e-01f, 4.84460667e-02f,
  4.29477654e-02f, -4.18320745e-02f, 9.00608972e-02f, 6.10218756e-03f, 6.73903897e-02f, -3.40312757e-02f, -8.16521719e-02f, -7.63313547e-02f, -4.81513143e-02f, -5.43064671e-04f,
  -8.59427303e-02f, -8.79779160e-02f, -9.29312222e-03f, -4.65383567e-02f, 1.18908314e-02f, -1.88546337e-03f, -1.09902304e-02f, -8.71758536e-02f, 6.77626580e-02f, 1.15451999e-01f,
  1.71754614e-01f, 9.59166661e-02f, 7.08917230e-02f, -1.25448136e-02f, 3.01063191e-02f, -5.70238493e-02f, 1.14657544e-02f, -8.23508054e-02f, 2.77863117e-03f, 7.89695710e-04f,
  3.69100682e-02f, -4.55513969e-02f, 5.03978282e-02f, 8.32972527e-02f, 1.14631593e-01f, 3.59991901e-02f, -4.91014356e-03f, -1.56748109e-02f, 3.96680050e-02f, -5.39481901e-02f,
  -1.34455249e-01f, 2.34397650e-02f, -2.34300550e-02f, -3.20207551e-02f, -2.90234499e-02f, -3.20230909e-02f, 6.04147129e-02f, 5.59730642e-02f, -1.00530356e-01f, 3.38638686e-02f,
  3.27176340e-02f, 3.64403486e-01f, -3.12534794e-02f, 2.21070927e-02f, -8.02884549e-02f, 7.37991482e-02f, 2.62054112e-02f, 1.33620888e-01f, 1.13577619e-01f, 8.80542248e-02f,
  5.73326573e-02f, 2.88987085e-02f, 6.87390715e-02f, -2.10056175e-02f, -1.08060800e-01f, 1.70321882e-01f, -8.42317566e-03f, 6.54416829e-02f, 4.49989550e-02f, -7.13358670e-02f,
  -8.15743059e-02f, 1.13685951e-01f, 4.54668552e-02f, -5.36837168e-02f, -2.01265793e-02f, 5.16819730e-02f, 3.53358276e-02f, -7.17269704e-02f, -4.73583750e-02f, 4.03251387e-02f,
  4.40188975e-04f, 2.03748107e-01f, -9.07238647e-02f, -1.86436195e-02f, -6.60160482e-02f, -4.21405315e-01f, -3.65953118e-01f, -1.17159262e-01f, 1.06745943e-01f, 2.44896725e-01f,
  -3.10641348e-01f, 4.84451085e-01f, -1.07235432e-01f, -5.19719481e-01f, -8.41373086e-01f, -4.70117062e-01f, -4.77622300e-01f, 6.15356350e-03f, -1.77000288e-03f, 1.85824454e-01f,
  -1.88757807e-01f, -4.11906838e-01f, -4.02820140e-01f, -6.09251335e-02f, 7.60803223e-02f, 3.25959206e-01f, 9.47731510e-02f, -2.45807525e-02f, 1.40289247e-01f, -3.22728574e-01f,
  -1.43983111e-01f, -1.10657923e-02f, 8.04229155e-02f, -4.04232480e-02f, -3.77774164e-02f, 8.98714513e-02f, 9.08749625e-02f, -1.63062915e-01f, -3.48331727e-04f, 3.65816876e-02f,
  1.55065760e-01f, 2.90660467e-02f, -8.15661326e-02f, -5.41434735e-02f, 6.61439076e-02f, 7.82221183e-02f, 2.34083068e-02f, 1.06112838e-01f, 1.93370730e-02f, 4.39055786e-02f,
  7.72217438e-02f, 6.51432052e-02f, 1.33332610e-01f, 8.02269354e-02f, -6.64436817e-02f, -6.81076646e-02f, 2.37681884e-02f, 9.01891068e-02f, 1.48145720e-01f, -2.05287244e-02f,
  1.26389391e-03f, 4.22609188e-02f, -1.06988057e-01f, -5.70418462e-02f, -6.99296966e-02f, -1.01679694e-02f, -5.89598045e-02f, -4.13622931e-02f, 1.36591662e-02f, -3.44488695e-02f,
  -2.52165906e-02f, 2.33862828e-02f, -3.69597711e-02f, 4.99916598e-02f, 4.50262465e-02f, 2.86817551e-02f, -4.19352576e-02f, 4.29404415e-02f, -1.52471783e-02f, -3.30083147e-02f,
  -2.77883783e-02f, -5.29902354e-02f, 1.76150426e-02f, 2.40330398e-02f, -7.81654119e-02f, -5.64066172e-02f, 4.64154333e-02f, 2.80087572e-02f, 2.66542695e-02f, -2.45960727e-02f,
  3.79243270e-02f, 1.15476534e-01f, -1.40242614e-02f, 3.61180939e-02f, 4.32634912e-02f, -8.85213763e-02f, -9.09878761e-02f, -1.16179511e-02f, 8.24669376e-03f, -4.22861725e-02f,
  1.24418579e-01f, -1.87716875e-02f, 1.26444742e-01f, -2.93412386e-03f, -2.22019833e-02f, -1.19121052e-01f, 1.53114162e-02f, 1.05343089e-01f, 3.38855758e-02f, 1.15424626e-01f,
  9.14080963e-02f, 1.30047426e-01f, -8.38994887e-03f, 5.35254963e-02f, 8.88229087e-02f, 6.41779229e-02f, 6.28089160e-02f, 3.85207497e-03f, 2.87674610e-02f, 6.61415309e-02f,
  5.41151345e-01f, -4.85483617e-01f, 4.82407212e-01f, 6.98758125e-01f, 8.99247900e-02f, 6.30408674e-02f, 7.45927095e-01f, -1.22905985e-01f, 5.53957582e-01f, -6.35498941e-01f,
  -2.47634098e-01f, 6.31551594e-02f, 1.85236380e-01f, -1.88396990e-01f, 6.69033051e-01f, 1.20568573e-01f, 3.32172699e-02f, -1.91862341e-02f, 1.39128149e-01f, 1.09419554e-01f,
  2.78836846e-01f, -2.36608461e-01f, 1.26658306e-01f, -5.82732797e-01f, -4.19372655e-02f, -7.15658143e-02f, -2.10128680e-01f, 1.22731641e-01f, -4.52163547e-01f, -1.53880212e-02f,
  -1.55818254e-01f, 1.29863039e-01f, -1.01132311e-01f, -9.17694196e-02f, -7.78676122e-02f, -8.41252804e-02f, 3.86485867e-02f, 8.04267749e-02f, 1.23975515e-01f, -1.84155479e-02f,
  -2.17735656e-02f, -2.37708967e-02f, -8.39571953e-02f, 6.33163303e-02f, 1.27351629e-02f, -6.09525330e-02f, -3.67854647e-02f, -4.29221094e-02f, -4.97605698e-03f, 3.51630226e-02f,
  6.04976676e-02f, -7.08441958e-02f, 8.70204493e-02f, -1.38430014e-01f, 5.01814485e-02f, 1.81290247e-02f, -7.56589277e-03f, 5.34803886e-03f, -7.04243332e-02f, -1.74513534e-02f,
  -4.73842807e-02f, 5.01638278e-02f, -7.57824630e-03f, 1.19403482e-03f, 9.62795690e-03f, -1.66582726e-02f, -1.92182511e-02f, -2.27857940e-02f, -2.74442043e-02f, -5.55011332e-02f,
  1.05355436e-03f, -2.00173445e-02f, -1.07536288e-02f, 3.80097590e-02f, 3.45986448e-02f, 3.42223011e-02f, 7.82151986e-03f, -6.11081235e-02f, 2.48029083e-02f, -4.89511937e-02f,
  2.41423324e-02f, 6.21782877e-02f, -6.91064149e-02f, 5.31566911e-04f, 5.92733920e-02f, 1.17889851e-01f, -6.80795535e-02f, -4.77553019e-03f, 7.29937404e-02f, 2.51982156e-02f,
  -4.02296335e-02f, 5.55947199e-02f, -4.77379151e-02f, -1.17513664e-01f, 6.32396666e-04f, -1.16279319e-01f, -4.94194543e-03f, -6.29468486e-02f, 1.21957913e-01f, 2.11342908e-02f,
  -1.05192348e-01f, -1.22560989e-02f, -5.91600221e-03f, -4.04438898e-02f, 2.72078589e-02f, -5.88250495e-02f, 1.09074913e-01f, -6.08304404e-02f, 2.21190229e-02f, -1.19699091e-01f,
  -2.16648374e-02f, 7.57607669e-02f, 5.09429611e-02f, -1.53339151e-02f, -8.32897201e-02f, -3.68955499e-03f, 7.67633766e-02f, 8.15642904e-03f, -6.03884794e-02f, 1.03418231e-02f,
  4.77473825e-01f, -2.38642588e-01f, -1.73224181e-01f, -3.21783215e-01f, -1.90540984e-01f, -2.53371358e-01f, -2.24682853e-01f, -3.18567336e-01f, -2.97272146e-01f, -3.65881085e-01f,
  -8.82427245e-02f, -8.86309519e-02f, 3.08468342e-01f, -4.46350217e-01f, 4.73128676e-01f, 4.42171335e-01f, -2.57624000e-01f, -8.10177997e-02f, 3.06354202e-02f, -2.18165442e-01f,
  9.93509516e-02f, -2.17323586e-01f, 4.98951077e-02f, -2.20653653e-01f, -2.21453100e-01f, -1.20378532e-01f, 2.10803181e-01f, 6.05224483e-02f, -2.23793224e-01f, 4.09906469e-02f,
  -1.81291103e-02f, -1.12128876e-01f, -1.19306304e-01f, 7.58332759e-02f, 3.84374149e-02f, -1.83379464e-02f, -1.66212395e-02f, 4.00477834e-02f, -2.46262532e-02f, 3.51547971e-02f,
  5.01654446e-02f, 6.78558573e-02f, -1.18604489e-01f, 1.06915690e-01f, -1.12475958e-02f, -1.56154498e-01f, 6.42800331e-02f, -7.17745423e-02f, -4.46987748e-02f, 1.30320653e-01f,
  -5.53752221e-02f, 5.13938069e-02f, -7.38438591e-02f, 2.74386499e-02f, 4.09488194e-02f, -3.08846161e-02f, 5.91269322e-02f, 4.19801064e-02f, -2.40867808e-02f, -5.05030863e-02f,
  7.78380930e-02f, 1.15396827e-01f, -1.92567818e-02f, -1.89449347e-03f, -4.91819205e-03f, -5.53939529e-02f, 3.82759757e-02f, -1.38217080e-02f, -2.26155831e-03f, 3.03993654e-02f,
  -4.81281579e-02f, -4.63967808e-02f, -9.40086506e-03f, 2.69241761e-02f, 9.66668501e-03f, 4.76664193e-02f, 2.17421465e-02f, 2.45816018e-02f, -7.62815475e-02f, -4.35901508e-02f,
  1.04673412e-02f, 9.34838690e-03f, -4.43984903e-02f, 3.56255956e-02f, 1.59308722e-03f, -2.92880237e-02f, -2.98319105e-02f, -2.44937483e-02f, -8.23656563e-03f, 2.11481713e-02f,
  -2.22564906e-01f, -1.72996253e-01f, -1.72140002e-01f, -3.12728211e-02f, 2.36163475e-02f, 7.86955841e-03f, 6.50418475e-02f, -5.03776446e-02f, -6.86643599e-03f, -4.92783897e-02f,
  2.56346492e-03f, 2.60928948e-03f, -3.50112170e-02f, 7.39363677e-05f, -3.84864323e-02f, -1.66732922e-01f, 2.46782899e-02f, -3.54128145e-02f, -1.16468720e-01f, -1.93816554e-02f,
  -6.01626001e-02f, -3.13622728e-02f, 1.96306705e-02f, -6.71307668e-02f, -2.86563262e-02f, 9.61881317e-03f, 2.40414422e-02f, 7.41911680e-03f, 1.67733669e-01f, -7.66866505e-02f,
  5.37258923e-01f, -5.53241670e-01f, -1.60247207e-01f, 4.49445426e-01f, 2.86120743e-01f, 1.04234152e-01f, -5.80647290e-02f, 2.79214233e-01f, 2.33778745e-01f, -2.09126189e-01f,
  1.19017102e-01f, 2.75592655e-02f, -7.05650091e-01f, 4.00886357e-01f, -7.34380707e-02f, -5.36111772e-01f, 3.34239423e-01f, 8.70061740e-02f, 1.06982484e-01f, 2.05138549e-02f,
  2.15683401e-01f, 2.56435841e-01f, -8.50393847e-02f, 8.17068145e-02f, 2.69796520e-01f, 1.51308671e-01f, -1.34238496e-01f, -4.15369183e-01f, 2.11523771e-01f, 5.20106554e-02f,
  2.45155200e-01f, 3.24512720e-02f, 1.17211640e-01f, 2.67226491e-02f, -3.24462242e-02f, 8.35368708e-02f, -3.19019854e-02f, -5.79436310e-02f, 1.32377863e-01f, 2.00029593e-02f,
  -7.09797954e-03f, 1.28764540e-01f, 1.35127082e-01f, -1.12253703e-01f, 1.71098739e-01f, 6.98417500e-02f, 1.03658780e-01f, 8.24709982e-02f, 4.66421358e-02f, -1.11240363e-02f,
  1.17016975e-02f, 5.52280359e-02f, 1.33792967e-01f, -8.94270465e-02f, -4.65936288e-02f, 4.28649113e-02f, -2.06440650e-02f, -1.37190685e-01f, 6.73610345e-02f, 1.07279547e-01f,
  -2.29221564e-02f, -4.53910343e-02f, -5.46714514e-02f, 9.27226469e-02f, -2.98424698e-02f, 5.78703806e-02f, -3.37765962e-02f, -3.88968177e-02f, -6.89797550e-02f, -1.98882092e-02f,
  3.30676697e-02f, 7.09622800e-02f, 3.44812386e-02f, 1.05818156e-02f, 6.61281124e-03f, 9.39918011e-02f, -5.10155084e-03f, -5.94764994e-03f, 3.68751325e-02f, 7.43137524e-02f,
  -4.32718359e-02f, -1.77407302e-02f, -8.37926865e-02f, 4.20904644e-02f, -4.82010506e-02f, -1.09670617e-01f, -4.67024092e-03f, -3.34041268e-02f, -2.05692127e-02f, -2.20063445e-03f,
  -3.31908971e-01f, -5.66517949e-01f, 2.77692080e-03f, 7.89013952e-02f, -8.71783495e-02f, -3.83972414e-02f, -2.04063319e-02f, 7.49869570e-02f, -1.72811151e-01f, 5.99385658e-03f,
  2.06298847e-02f, 4.36237901e-02f, -1.40446499e-02f, 8.01988021e-02f, -5.98517023e-02f, -6.79542497e-02f, -8.41733962e-02f, 3.55878100e-03f, -4.93560955e-02f, -1.49746910e-02f,
  -2.62343250e-02f, -7.36905113e-02f, -3.39226387e-02f, 1.09449089e-01f, 5.53346500e-02f, -1.73712261e-02f, -3.88529599e-02f, -1.44039560e-02f, -7.94404671e-02f, -9.30112898e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.60161936e-01f, 3.71577829e-01f, 7.87093103e-01f, 1.03250794e-01f, 3.10716480e-01f, 4.90261853e-01f, 3.46287310e-01f, 2.15195507e-01f, 5.91708004e-01f, 5.46300828e-01f,
  6.63717628e-01f, 6.86184347e-01f, 2.61416942e-01f, 4.41820443e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  1.54276833e-01f, -1.75933555e-01f, 1.09565842e+00f, 4.37268466e-01f, -3.95091414e-01f, -1.42611176e-01f, 8.48862946e-01f, -1.06767602e-01f, -3.18903804e-01f, -3.42804462e-01f,
  6.97390556e-01f, -2.64640927e-01f, -4.43815172e-01f, -5.52125394e-01f, -2.86059588e-01f, -1.24677636e-01f, 4.41812389e-02f, -1.08253330e-01f, -4.63547587e-01f, 1.01644492e+00f,
  -4.76561368e-01f, -2.11028993e-01f, -4.38299865e-01f, -4.42341417e-01f, -3.81697834e-01f, -2.51858443e-01f, 4.94086027e-01f, 1.05916798e+00f, -4.70214576e-01f, -7.83720195e-01f,
  7.97149062e-01f, 1.92208692e-01f, -3.31835896e-01f, -2.10786924e-01f, -2.73624267e-02f, 1.72565594e-01f, -3.13101232e-01f, 2.53461808e-01f, -2.83078760e-01f, -4.26023662e-01f,
  8.11271846e-01f, -2.03287482e-01f, -2.57427514e-01f, -2.15568423e-01f, -3.91537786e-01f, -3.75315547e-01f, -6.23667352e-02f, 1.14290905e+00f, -9.85505641e-01f, 5.78427255e-01f,
  3.99569362e-01f, -3.48523885e-01f, 5.09331465e-01f, -2.22339824e-01f, 3.34855348e-01f, 2.82757103e-01f, -6.01034388e-02f, 9.66040254e-01f, -2.16256022e-01f, -3.15088421e-01f,
  3.05083990e-01f, -5.22515416e-01f, -3.23217779e-01f, -3.18228871e-01f, 5.66397369e-01f, 5.67353487e-01f, 1.84282511e-01f, 4.78884391e-02f, 9.76996064e-01f, -4.13215868e-02f,
  -8.37345645e-02f, 1.17601848e+00f, 4.90394652e-01f, -4.75998253e-01f, -3.82965773e-01f, -1.59269333e-01f, -5.87745547e-01f, -5.55788934e-01f, 1.44451872e-01f, -4.49721664e-01f,
  8.37252010e-03f, 2.82166451e-01f, -5.63756108e-01f, -3.51051956e-01f, -1.52507797e-01f, -3.52406353e-01f, 5.62003970e-01f, 4.91891019e-02f, -4.19668168e-01f, -2.77169734e-01f,
  9.99752045e-01f, 9.67687011e-01f, -1.49518937e-01f, 6.84184432e-01f, -3.78706664e-01f, -6.33632898e-01f, 4.27603483e-01f, -2.75394410e-01f, -3.25939596e-01f, -5.43448567e-01f,
  -5.97778916e-01f, -2.80675173e-01f, -2.64167756e-01f, 4.46428180e-01f, -4.50221390e-01f, 2.87074387e-01f, -3.96301061e-01f, 1.87579110e-01f, -4.93189454e-01f, 1.03792202e+00f,
  -4.17143524e-01f, 8.98363352e-01f, -4.86657172e-01f, 4.02523607e-01f, 5.58289587e-01f, -1.89937934e-01f, -5.16966820e-01f, -1.03681721e-01f, 4.77581739e-01f, 1.46893129e-01f,
  -2.34771296e-01f, -5.47607169e-02f, -4.84919995e-01f, -5.41481562e-02f, 3.56996685e-01f, -1.01109654e-01f, 9.36702490e-01f, -3.85554522e-01f, -1.42330769e-02f, -2.80186474e-01f,
  -3.95595014e-01f, 2.62351722e-01f, -2.94911295e-01f, 1.40391529e+00f, -2.49144629e-01f, -1.45401537e-01f, -1.85074478e-01f, -3.28126192e-01f, -3.15574318e-01f, -2.26956189e-01f,
  -1.84141904e-01f, 1.76098272e-01f, 5.90504557e-02f, -4.25361276e-01f, -5.97713232e-01f, -7.29253650e-01f, 6.53611636e-03f, -4.79463995e-01f, 5.70617616e-01f, -4.80728179e-01f,
  -4.58214991e-02f, -4.07353431e-01f, 4.39911515e-01f, -1.35610148e-01f, -1.24057382e-01f, -2.94689715e-01f, -5.20749390e-01f, 1.14252174e+00f, 4.95710909e-01f, -4.97612357e-01f,
  5.16218901e-01f, 4.27189648e-01f, -2.29306757e-01f, 2.86273837e-01f, -1.77916765e-01f, -9.89957433e-03f, -5.62251270e-01f, -6.92210972e-01f, 1.69132769e-01f, 1.19441247e+00f,
  -4.12568778e-01f, -2.47737646e-01f, 8.46768498e-01f, -4.49854016e-01f, -2.74810016e-01f, -2.41820276e-01f, 2.58104622e-01f, -3.86590481e-01f, -3.92460525e-01f, -4.42594886e-01f,
  6.51695073e-01f, -4.26977247e-01f, -2.89284110e-01f, 1.03083543e-01f, -4.76701885e-01f, -6.04628503e-01f, 3.12291622e-01f, -4.17515814e-01f, 1.11439121e+00f, -3.34129900e-01f,
  -4.43142027e-01f, 4.30099487e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.48218663e-02f, 2.06109181e-01f, 2.15409230e-02f, -1.53195292e-01f, 5.21060765e-01f, 1.21721961e-01f, -4.52573262e-02f, -2.17256472e-01f, -1.08552342e-02f, 1.70848832e-01f,
  -1.61015280e-02f, 5.74529171e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    