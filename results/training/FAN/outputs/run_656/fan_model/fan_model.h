/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.00344938e-01f, -3.75229046e-02f, -5.68975270e-01f, -3.53114873e-01f, -5.16786873e-01f, -2.90855825e-01f, -5.72972931e-02f, -8.14654455e-02f, -1.24053836e-01f, -1.22932360e-01f,
  1.23154861e-03f, -1.16405055e-01f, -4.17848304e-02f, -6.83120117e-02f, -1.06739327e-01f, -1.45961136e-01f, -2.99571246e-01f, -3.26640159e-01f, -2.92508453e-01f, -2.56262451e-01f,
  -9.62229520e-02f, -1.80170372e-01f, -2.52446771e-01f, -5.80188520e-02f, -7.76386186e-02f, -1.00764073e-01f, -2.49710515e-01f, -1.57336533e-01f, -1.05012469e-02f, -2.03525960e-01f,
  -1.12232529e-01f, -3.03340763e-01f, -5.15501201e-02f, -1.16137847e-01f, -1.68336585e-01f, -1.23470359e-01f, -1.59371287e-01f, -1.29757553e-01f, -5.03967889e-02f, -1.17797844e-01f,
  -1.75440446e-01f, -2.07520932e-01f, -1.47709996e-01f, -1.85018435e-01f, -1.99686781e-01f, -2.20497474e-01f, -2.49548908e-02f, -1.71550214e-01f, -1.24065697e-01f, -1.36626825e-01f,
  -8.21302235e-02f, -1.72041371e-01f, -1.83139965e-01f, 1.36800564e-03f, -9.15311053e-02f, -4.37164828e-02f, -1.17792018e-01f, -1.04843594e-01f, -1.21976689e-01f, 6.59658909e-02f,
  6.70553520e-02f, 6.55818284e-02f, -1.18503105e-02f, 1.97319631e-02f, 1.42242789e-01f, 3.53841633e-02f, 2.13393047e-02f, 1.48383692e-01f, -1.48961898e-02f, 6.55306280e-02f,
  -4.28914391e-02f, 6.47988468e-02f, 6.30958974e-02f, -7.34198913e-02f, -3.66364233e-02f, -2.84189917e-02f, 7.89373964e-02f, 6.41086698e-02f, 1.24672681e-01f, 2.79855859e-02f,
  -3.61307226e-02f, -6.07214458e-02f, -2.07455549e-02f, 5.43164052e-02f, -5.15414439e-02f, -5.40121011e-02f, -2.89600436e-02f, -1.34314401e-02f, 5.64605743e-02f, -3.44834477e-02f,
  -1.39544308e-01f, -3.06944579e-01f, 1.69408396e-02f, -9.58638079e-03f, -1.13492362e-01f, 4.31879051e-03f, -1.42661899e-01f, 3.14428583e-02f, -9.42006186e-02f, -1.03781685e-01f,
  -1.59502298e-01f, -1.23496227e-01f, -1.00353085e-01f, -7.59262815e-02f, -9.80923995e-02f, -1.47442400e-01f, -4.76344936e-02f, -9.93251801e-02f, -2.40858626e-02f, 2.64279470e-02f,
  -3.34353484e-02f, 4.21953723e-02f, 2.78516803e-02f, 9.26841572e-02f, 5.77567331e-02f, -4.12350558e-02f, -3.54005322e-02f, -1.00423642e-01f, 2.10550893e-02f, 2.62587845e-01f,
  -2.24334285e-01f, -2.15260148e-01f, -1.93245020e-02f, -3.78741398e-02f, 1.33415312e-02f, -3.34725752e-02f, -3.79506558e-01f, -1.82632357e-01f, -4.92514558e-02f, -8.24049264e-02f,
  1.81068584e-01f, 4.35799450e-01f, 3.21052253e-01f, 2.71928430e-01f, 9.52976644e-02f, -2.17581913e-01f, -1.28694445e-01f, 1.17066585e-01f, 1.81830317e-01f, 1.57907352e-01f,
  2.33238965e-01f, 3.21577154e-02f, 5.28357700e-02f, 5.36240861e-02f, -5.60428090e-02f, 2.62234837e-01f, -8.82323161e-02f, 2.09124368e-02f, 1.44690171e-01f, 1.94694251e-01f,
  3.43474418e-01f, -1.74881950e-01f, 1.58410519e-01f, 1.56737193e-01f, 2.01297089e-01f, 7.74029270e-02f, 1.01016998e-01f, 6.06694557e-02f, 8.93419906e-02f, 1.31491527e-01f,
  1.77546501e-01f, 8.14304426e-02f, 8.92918855e-02f, 1.69280246e-01f, 4.42491658e-02f, 9.74181518e-02f, 7.14728460e-02f, 7.22618476e-02f, 1.80245921e-01f, 9.15320441e-02f,
  1.44660577e-01f, 1.57583147e-01f, 5.59566021e-02f, 1.13745116e-01f, 8.13171044e-02f, 3.36498588e-01f, 5.93693890e-02f, 1.44527867e-01f, 8.74039978e-02f, 1.52299821e-01f,
  1.28258094e-01f, 1.20739095e-01f, -8.72189086e-03f, -5.28538227e-02f, -6.97122440e-02f, -4.76377830e-02f, 1.92568023e-02f, 6.16713166e-02f, 1.30927737e-03f, -3.59559916e-02f,
  -3.13271098e-02f, 9.35235806e-03f, -2.09267661e-02f, 6.13861391e-03f, 1.08102329e-01f, 2.68031750e-02f, 1.10527230e-02f, -1.89146902e-02f, -3.29356827e-02f, -1.81331877e-02f,
  1.06092747e-02f, -7.04104751e-02f, -5.98331317e-02f, -2.66231056e-02f, -1.62874367e-02f, 6.24385886e-02f, 5.32907024e-02f, 3.10400855e-02f, 7.46556818e-02f, 8.89639780e-02f,
  9.29519758e-02f, 1.63355231e-01f, 1.10221863e-01f, 1.20898865e-01f, 1.36933714e-01f, 1.49713591e-01f, 2.33594656e-01f, 1.89332604e-01f, 1.84357688e-01f, 1.80188298e-01f,
  1.76259711e-01f, 1.37068331e-01f, 9.85938832e-02f, 1.09771878e-01f, 1.80050090e-01f, 1.05840541e-01f, 1.05171636e-01f, 9.85412300e-02f, 1.62610054e-01f, 1.32427678e-01f,
  7.38871694e-02f, 4.25931774e-02f, 9.10352543e-02f, 9.03072059e-02f, 1.87522769e-01f, 2.85914719e-01f, 1.63176939e-01f, 1.22214593e-01f, 2.40588695e-01f, 4.62051556e-02f,
  -7.50154793e-01f, -2.33201608e-01f, 5.00752442e-02f, -4.10999497e-03f, 1.25501573e-01f, 1.10648401e-01f, -9.64835957e-02f, 5.41941822e-02f, 8.17988589e-02f, -1.22115918e-01f,
  5.88644780e-02f, 9.38372780e-03f, 1.27871400e-02f, 5.74440509e-02f, -1.05473399e-01f, -1.56104103e-01f, 4.59599122e-02f, -8.25014785e-02f, 1.14575297e-01f, 1.01251341e-01f,
  6.23232760e-02f, -3.62819023e-02f, -1.12967221e-02f, -1.19789913e-02f, -6.32019639e-02f, -1.34157583e-01f, 1.87215339e-02f, -1.69916391e-01f, 7.92246219e-03f, -3.74860406e-01f,
  -3.09706151e-01f, -3.91470999e-01f, -9.10169706e-02f, -1.29030839e-01f, -8.21738765e-02f, -1.97523206e-01f, -1.73282579e-01f, -2.21005410e-01f, -2.03178987e-01f, -1.59138680e-01f,
  -1.25098512e-01f, -3.90706509e-02f, -1.69480637e-01f, -1.92744359e-01f, -2.08876729e-01f, -1.30639419e-01f, -1.15880609e-01f, -2.00572073e-01f, -1.10776022e-01f, -1.70462281e-01f,
  -7.15137348e-02f, -1.39065264e-02f, -1.95349872e-01f, -1.06566191e-01f, -5.55386096e-02f, -1.03161000e-01f, -1.51639074e-01f, -2.82382429e-01f, -1.69450015e-01f, -3.50619704e-01f,
  -4.15126942e-02f, -3.55013870e-02f, 2.89888494e-02f, 1.73413716e-02f, 2.35156976e-02f, 3.60278003e-02f, -3.65647264e-02f, 2.38096584e-02f, 1.58931292e-03f, 4.00051586e-02f,
  2.87412275e-02f, 4.81314491e-03f, -5.31437658e-02f, 1.55932214e-02f, 2.63143051e-02f, -1.97763108e-02f, 6.83100708e-03f, 4.31056768e-02f, 1.43583603e-02f, -4.90121096e-02f,
  1.07194185e-01f, 4.03563157e-02f, 5.45186177e-02f, 8.37134570e-03f, -1.30557735e-02f, 1.05255162e-02f, -4.08163071e-02f, 9.34383497e-02f, 7.63971210e-02f, -1.17177435e-03f,
  -9.89507958e-02f, -5.25380336e-02f, -2.01829672e-01f, -1.11240692e-01f, -1.22993544e-01f, -4.79670390e-02f, -1.35571435e-01f, -1.52141213e-01f, -1.05873466e-01f, -1.00866601e-01f,
  -2.57002041e-02f, -1.08350180e-01f, -1.22990169e-01f, -8.01889375e-02f, -1.20990805e-01f, -8.17226842e-02f, -1.80692270e-01f, -1.57269359e-01f, -1.96121214e-03f, -7.26797283e-02f,
  -2.46265270e-02f, -6.43974766e-02f, -1.08367331e-01f, -4.41443585e-02f, -1.44235536e-01f, -4.41131666e-02f, -1.34873092e-01f, -1.54908746e-01f, -2.23341361e-01f, -3.03372562e-01f,
  -3.41101348e-01f, 4.34491158e-01f, -4.39878911e-01f, -2.53852853e-03f, -1.91630036e-01f, -3.13706517e-01f, -2.71018147e-01f, -1.25249624e-01f, 1.33076772e-01f, 1.39783695e-01f,
  2.33350500e-01f, 2.99152732e-01f, 2.30880588e-01f, 1.88373461e-01f, -1.49692580e-01f, -6.93439022e-02f, -1.77373141e-01f, -3.20780516e-01f, -3.83861512e-01f, -1.14228509e-01f,
  1.03085302e-01f, -8.06557462e-02f, -2.52743900e-01f, 2.85310093e-02f, 2.72216320e-01f, 1.06894232e-01f, 3.02918479e-02f, -3.74213569e-02f, 6.84825564e-03f, 1.97537854e-01f,
  -9.53829810e-02f, -2.39766330e-01f, -2.67099719e-02f, 1.17149211e-01f, 2.34762784e-02f, -6.89080730e-02f, -2.78131366e-02f, -4.98085581e-02f, 1.05311252e-01f, -3.59258056e-02f,
  1.05770297e-01f, 7.29339793e-02f, -1.70203205e-02f, 9.04416516e-02f, -4.62877899e-02f, -1.20602939e-02f, 2.63593011e-02f, -4.46197502e-02f, 1.53690595e-02f, 6.46080524e-02f,
  1.61537081e-01f, 1.21121621e-02f, -2.03971148e-01f, -5.86652644e-02f, -9.38786864e-02f, -3.25540379e-02f, 4.20812108e-02f, 5.92174418e-02f, -7.72892088e-02f, 1.01618335e-01f,
  9.60237980e-02f, -4.25779596e-02f, -4.83038239e-02f, -8.15837830e-02f, -5.20908721e-02f, -3.21724862e-02f, -5.19937202e-02f, 2.45599430e-02f, 7.58857583e-04f, 7.20614800e-03f,
  5.84355146e-02f, -3.31236161e-02f, -5.84955178e-02f, -5.48694469e-02f, 1.16275251e-02f, -5.47556393e-02f, -1.13197237e-01f, 5.54870516e-02f, -6.40703589e-02f, -8.28095973e-02f,
  8.45028367e-03f, 1.96144879e-02f, 6.82452843e-02f, 1.40139880e-02f, -5.92304505e-02f, -8.57271627e-02f, 4.88692038e-02f, -1.14364102e-02f, 1.96072292e-02f, 3.31877209e-02f,
  2.99234569e-01f, -1.85658455e-01f, 8.25952739e-02f, 9.33550969e-02f, -5.43128746e-03f, 1.58668414e-01f, 2.60917991e-02f, 2.67280098e-02f, -5.34211518e-04f, 3.97032723e-02f,
  1.21103674e-02f, -4.84275296e-02f, 2.70157140e-02f, 3.58416140e-02f, 8.88937805e-03f, -1.59352354e-03f, 1.38566598e-01f, 2.26101652e-02f, -1.57245900e-02f, 5.30162379e-02f,
  1.19173981e-01f, -6.45181313e-02f, -5.99191599e-02f, 1.00880347e-01f, 6.44437075e-02f, -1.39523745e-01f, -3.54589634e-02f, 5.56308962e-02f, -1.79873988e-01f, 1.33484006e-01f,
  4.71972197e-01f, 2.80052722e-01f, 3.48598689e-01f, 1.38265938e-01f, 1.24467881e-02f, 1.23875074e-01f, 2.60143012e-01f, -9.08259228e-02f, -1.07404180e-01f, 1.43018097e-01f,
  7.15375617e-02f, -1.56421483e-01f, -6.74351957e-03f, -1.54844478e-01f, -1.98231526e-02f, 2.06372142e-01f, 5.50291203e-02f, -5.11267520e-02f, -1.05927691e-01f, -4.79251221e-02f,
  -5.59282564e-02f, 5.66192949e-03f, -5.78006357e-02f, -1.88957393e-01f, 4.20771586e-03f, -3.82867344e-02f, 1.21145897e-01f, 1.35348648e-01f, 1.16031185e-01f, 3.25297356e-01f,
  3.55474085e-01f, 1.52443781e-01f, -1.84305593e-01f, -1.04379095e-01f, -5.84781766e-02f, -9.79662761e-02f, -8.28349814e-02f, -1.48305938e-01f, -1.60900116e-01f, -3.54021229e-02f,
  -2.45221183e-02f, -3.29855047e-02f, -1.03609398e-01f, -1.00742131e-01f, -5.89048490e-03f, -6.63231239e-02f, -7.61333704e-02f, -5.38462289e-02f, -2.71704933e-03f, -9.01317000e-02f,
  3.69148925e-02f, -1.65896099e-02f, 1.68413967e-02f, -1.74193606e-01f, -2.73114238e-02f, -8.45956579e-02f, -3.52006108e-02f, -6.14779107e-02f, -1.36000484e-01f, 2.44931970e-03f,
  1.67452041e-02f, 2.83086381e-04f, -1.57581475e-02f, 3.53857726e-02f, 1.31289195e-02f, 1.53889842e-02f, 3.65274660e-02f, 1.29000500e-01f, -4.73035909e-02f, -3.72949615e-02f,
  3.48816477e-02f, 8.83108899e-02f, 5.55762947e-02f, 5.59809878e-02f, 2.25958489e-02f, -1.01426922e-01f, 5.71239926e-02f, 1.86510123e-02f, -1.11726960e-02f, -1.08475622e-03f,
  3.12518217e-02f, -3.05263549e-02f, 4.11812775e-02f, -4.24885675e-02f, 1.44033721e-02f, 3.32641155e-02f, 2.05244180e-02f, -6.34174561e-03f, -4.04656045e-02f, -2.23335121e-02f,
  -4.71077263e-02f, -9.10512209e-02f, 1.11791730e-01f, -6.39613196e-02f, -8.13613236e-02f, -6.98989257e-02f, -1.15541741e-03f, -3.90785597e-02f, -4.90714200e-02f, 2.74671074e-02f,
  -6.99967146e-02f, 3.31770666e-02f, -4.16639261e-02f, -9.44322571e-02f, -7.83624053e-02f, -9.82520431e-02f, -9.84781906e-02f, -6.74366206e-02f, -9.44351871e-03f, 2.71064658e-02f,
  -1.11654669e-01f, 9.75882541e-03f, 9.98792052e-02f, -5.84105328e-02f, -8.73691291e-02f, -2.69059483e-02f, -3.16903889e-02f, -6.88679740e-02f, 6.04265928e-03f, -1.64219603e-01f,
  -2.62183249e-01f, 2.85085645e-02f, -5.31259216e-02f, -2.16873258e-01f, -7.42598772e-02f, 2.14561775e-01f, -3.54867317e-02f, 1.04067065e-01f, -8.18346627e-03f, -1.66653946e-01f,
  1.04484834e-01f, -4.99310866e-02f, 6.72778115e-02f, 1.94043219e-01f, 1.23285785e-01f, -2.30199605e-01f, -1.48280039e-01f, 3.24002393e-02f, 1.60361424e-01f, 6.48896769e-02f,
  -7.27301240e-02f, -1.26022562e-01f, 1.22776337e-01f, 8.20508003e-02f, -1.93515286e-01f, -1.53801158e-01f, -1.11569390e-01f, 1.88548014e-01f, 2.00655088e-01f, -3.22084844e-01f,
  -5.56169078e-02f, 1.21208392e-01f, -2.13233195e-02f, -1.31200716e-01f, 3.13610546e-02f, -9.33486670e-02f, -4.88518998e-02f, -4.21995632e-02f, -5.44693740e-03f, -1.88971893e-03f,
  2.25087395e-03f, 4.14536931e-02f, 9.67348367e-02f, -3.11103314e-02f, 1.83079913e-02f, -9.19128433e-02f, -2.69739330e-02f, -9.22893919e-03f, 4.31744456e-02f, -5.78518808e-02f,
  -4.49688965e-03f, 1.06720410e-01f, 1.04728557e-01f, 1.86823517e-01f, 1.38481036e-01f, 1.70495868e-01f, 6.56162724e-02f, 2.04279914e-01f, 2.31967375e-01f, -1.28260583e-01f,
  2.91155446e-02f, -8.61817673e-02f, 8.35910067e-02f, 2.10248772e-02f, 6.38148785e-02f, 1.98509973e-02f, -2.73796208e-02f, 5.71622923e-02f, 8.12072977e-02f, -1.01551220e-01f,
  1.06236055e-01f, -2.64270417e-02f, 8.74387287e-03f, -2.55290177e-02f, 4.10153307e-02f, 3.09465043e-02f, 2.58067846e-02f, 4.27472107e-02f, 6.41949102e-02f, 1.00586720e-01f,
  1.42850839e-02f, 3.70056033e-02f, -2.48384159e-02f, 1.11019067e-01f, 1.03127740e-01f, 1.33102030e-01f, -7.37916455e-02f, 6.76143020e-02f, -4.81764749e-02f, 1.92946903e-02f,
  -2.52077520e-01f, 1.68411195e-01f, -1.98517770e-01f, -8.52186456e-02f, -2.91829053e-02f, 1.06418626e-02f, 2.38199607e-02f, -3.43962461e-02f, -6.60238639e-02f, -3.87033299e-02f,
  4.68098633e-02f, -4.07659970e-02f, -3.18373106e-02f, -5.51877165e-05f, -9.31842551e-02f, -2.14780159e-02f, 5.40693328e-02f, -1.17131852e-01f, 1.05049442e-02f, -8.38838797e-03f,
  4.99412380e-02f, -1.57969415e-01f, -1.19391464e-01f, -1.44168571e-01f, -2.60230675e-02f, -7.54834041e-02f, -9.72696841e-02f, -4.34036776e-02f, -1.13717252e-02f, -4.23700333e-01f,
  6.63079441e-01f, 2.63006501e-02f, -2.13884771e-01f, 3.74583513e-01f, -1.24776386e-01f, -1.29963070e-01f, -3.26003075e-01f, -1.17743827e-01f, 7.00732768e-02f, -5.94596379e-02f,
  3.89065444e-02f, 1.31113097e-01f, -5.70755359e-03f, 7.82170333e-03f, -1.46877497e-01f, -3.11103344e-01f, -1.36432558e-01f, -1.69215649e-02f, 5.67661338e-02f, -3.67100984e-02f,
  1.42923242e-03f, 1.54416710e-01f, 2.31818199e-01f, 1.20865986e-01f, 1.62695140e-01f, 2.75075785e-03f, -1.03550136e-01f, 1.43214211e-01f, -1.88243408e-02f, 1.24562241e-01f,
  -5.70023842e-02f, -9.82876215e-03f, -2.62814760e-01f, -1.46133834e-02f, -5.79362214e-02f, -2.12379377e-02f, -4.31092903e-02f, -6.70026871e-04f, -3.61413360e-02f, 4.05489765e-02f,
  -1.10994667e-01f, -5.79345599e-02f, -4.78642397e-02f, -2.16641445e-02f, -1.13025382e-01f, -6.20776415e-02f, -8.36191177e-02f, 1.00129889e-02f, -8.61922204e-02f, -3.47235915e-03f,
  -8.71097669e-02f, -5.22101074e-02f, -5.65902255e-02f, -5.37355579e-02f, -9.99133214e-02f, -3.02277990e-02f, -9.29013733e-03f, 6.97070062e-02f, 5.83159029e-02f, 4.27985936e-02f,
  -5.93158863e-02f, -1.96693372e-02f, 1.08683081e-02f, 7.11079314e-02f, -9.67067759e-03f, -1.49408998e-02f, 6.34421036e-02f, 5.05105499e-03f, 6.06711917e-02f, 8.07887241e-02f,
  9.88436416e-02f, 1.16141774e-01f, 7.37174824e-02f, 1.65890038e-01f, 7.92101175e-02f, 6.23919889e-02f, 7.21502230e-02f, 1.12914592e-01f, 7.08135217e-02f, 4.38094176e-02f,
  4.14277837e-02f, 6.79178908e-02f, 7.28649497e-02f, 7.69560561e-02f, 1.03102453e-01f, 8.67342800e-02f, 7.48699754e-02f, 1.04028925e-01f, -1.40243033e-02f, 1.88375581e-02f,
  -3.86882499e-02f, -2.24170491e-01f, -6.24723323e-02f, -3.56756449e-02f, -2.04333104e-02f, -3.66935357e-02f, -2.37818640e-02f, 1.01589458e-02f, 8.72057863e-03f, -3.05566601e-02f,
  6.96993023e-02f, -5.75424992e-02f, -3.35537121e-02f, -1.32376194e-01f, -3.76889706e-02f, -2.18648147e-02f, -1.23590909e-01f, -8.31501782e-02f, -3.25043611e-02f, -5.44506088e-02f,
  -9.15996507e-02f, -9.36046466e-02f, -8.75967667e-02f, -1.20491877e-01f, -3.08119208e-02f, -5.56318574e-02f, -1.62296414e-01f, -1.06665432e-01f, -2.12858215e-01f, -9.41937938e-02f,
  -4.47494328e-01f, -9.04066041e-02f, 1.26120940e-01f, -2.03142196e-01f, 2.81102747e-01f, 1.86299264e-01f, 2.92316616e-01f, -1.02404617e-01f, -1.32789984e-01f, -2.39519235e-02f,
  -1.18796803e-01f, -1.77943230e-01f, -1.65990010e-01f, -2.35752210e-01f, -9.49018821e-02f, 2.48011857e-01f, 2.85314769e-01f, -1.41128942e-01f, -4.54918481e-02f, -3.97599116e-02f,
  1.50057152e-01f, -4.59089614e-02f, -3.68396342e-01f, -2.51598120e-01f, 7.68927764e-03f, -8.16627145e-02f, 7.49356225e-02f, -7.28079826e-02f, 1.84903610e-02f, -1.40710562e-01f,
  -2.02213153e-01f, -6.29155114e-02f, -2.77131088e-02f, -1.29639030e-01f, 7.20545202e-02f, -7.63974339e-02f, -6.61219582e-02f, -6.95420057e-02f, -2.12682113e-02f, -1.15086734e-01f,
  -5.51681817e-02f, -1.11761369e-01f, -1.24976654e-02f, -6.00475036e-02f, -1.20588064e-01f, -9.67052504e-02f, -6.18717670e-02f, -1.83397591e-01f, -1.07654586e-01f, -9.42900702e-02f,
  -1.44681139e-02f, -2.78858729e-02f, -2.25238856e-02f, 2.46676523e-03f, -1.62834808e-01f, -7.70727471e-02f, -1.24219961e-01f, -1.59486473e-01f, -1.79764748e-01f, -1.59142688e-01f,
  -1.31480858e-01f, -3.68783809e-02f, 3.07999048e-02f, -5.20735197e-02f, 6.58187121e-02f, -1.88894980e-02f, 5.27831465e-02f, -2.13436745e-02f, 6.45972565e-02f, 1.97463986e-02f,
  -1.38393510e-02f, 5.56923710e-02f, 1.82189234e-02f, 4.02986351e-03f, 3.49493958e-02f, -4.65437062e-02f, 5.10859229e-02f, 1.96136646e-02f, 4.27416079e-02f, -9.37702879e-03f,
  6.16402961e-02f, 3.19622904e-02f, 6.62366003e-02f, 2.08799075e-02f, -1.73753146e-02f, 4.10334729e-02f, 6.34006038e-02f, 2.45348122e-02f, 6.54353574e-02f, 5.87335788e-02f,
  -4.54285629e-02f, -6.68618158e-02f, -9.94383320e-02f, 1.80472657e-02f, 9.20041464e-03f, -5.66477440e-02f, -6.73407167e-02f, -6.94983080e-02f, -6.78970590e-02f, -7.77127221e-02f,
  -1.25103861e-01f, -6.18985966e-02f, 3.87004483e-03f, -1.97425252e-03f, -5.51929660e-02f, -5.50306737e-02f, -3.75515968e-02f, 3.70529443e-02f, -7.20467195e-02f, -1.76472031e-02f,
  1.66464783e-02f, 1.00503480e-02f, -6.89263269e-02f, -1.03188090e-01f, 1.58594754e-02f, 1.59363635e-03f, 9.20482352e-02f, 2.49425825e-02f, 2.37232633e-02f, 9.30285975e-02f,
  -4.65232655e-02f, 4.94379967e-01f, -4.56057442e-03f, -9.64281857e-02f, 1.60965800e-01f, 1.64556295e-01f, 5.37780583e-01f, 1.67561680e-01f, 3.18651199e-02f, 2.02984974e-01f,
  -9.62039270e-03f, -3.04580092e-01f, -2.36494452e-01f, -1.67056412e-01f, -1.70145825e-01f, 3.99202734e-01f, 2.50276625e-01f, -2.73180336e-01f, -3.56043547e-01f, -1.12787232e-01f,
  9.43005923e-03f, 1.12438994e-03f, -1.89360008e-01f, -1.83884397e-01f, 1.04971655e-01f, 5.22079542e-02f, 3.31284344e-01f, 1.16694480e-01f, 6.74989447e-02f, 9.76331905e-02f,
  3.22900771e-04f, 1.36851728e-01f, -6.54500052e-02f, -4.63628769e-03f, 1.15869477e-01f, 3.72858308e-02f, 6.44279569e-02f, -1.73900742e-02f, 1.40040033e-02f, 1.15328975e-01f,
  3.76867093e-02f, 1.90645736e-02f, -5.37927039e-02f, 7.18745217e-02f, 9.22822058e-02f, -2.07100250e-02f, 1.21784518e-02f, -2.88180411e-02f, -8.00628960e-02f, 1.57085344e-01f,
  1.19426355e-01f, 1.03831686e-01f, 1.21012419e-01f, 1.28215536e-01f, 3.51027027e-02f, -3.93621996e-02f, 1.30221099e-02f, -6.29503950e-02f, 4.50407751e-02f, 2.35994592e-01f,
  -2.24954300e-02f, 6.74672127e-02f, 3.59116755e-02f, 1.30455857e-02f, 3.90913896e-02f, 2.26387754e-02f, -9.28300619e-02f, 3.95851992e-02f, -7.46340677e-02f, 5.62626906e-02f,
  -8.32631811e-02f, -2.92248242e-02f, -2.98874956e-02f, -3.13102920e-03f, -5.21455109e-02f, 2.52435431e-02f, 1.89206079e-02f, -3.94978225e-02f, -1.39437720e-01f, 8.88714381e-03f,
  -1.32110342e-01f, -3.17018889e-02f, -6.51808456e-02f, -4.72615771e-02f, -1.72235090e-02f, -9.33922827e-02f, -2.80919019e-02f, -4.31292802e-02f, -1.00987041e-02f, 9.07201786e-03f,
  -5.10580912e-02f, -1.34137928e-01f, 6.28153831e-02f, 3.42252180e-02f, 7.21714422e-02f, -7.44506856e-03f, 2.51522521e-03f, 3.94636989e-02f, 1.03379034e-01f, -4.69908491e-03f,
  5.22729494e-02f, -2.68243384e-02f, 4.00631875e-02f, -6.88380748e-03f, 5.14924414e-02f, 1.77039746e-02f, 1.12550199e-01f, 1.51504911e-02f, 4.03280370e-02f, 1.01472951e-01f,
  8.35153386e-02f, 1.57535046e-01f, 4.32645530e-02f, 6.94809482e-02f, 1.25842810e-01f, 5.82324378e-02f, 1.00899592e-01f, 1.34852514e-01f, 2.38064919e-02f, 3.55804473e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -8.45614314e-01f, -3.02016944e-01f, 7.77217522e-02f, 1.60103142e-01f, 1.38392419e-01f, 9.96541828e-02f, 1.65238574e-01f, -9.26304385e-02f, 3.30866389e-02f, 8.72651264e-02f,
  -6.40758500e-02f, 5.65150194e-02f, 1.95782423e-01f, 9.13080871e-02f, 9.04272199e-02f, 1.89168662e-01f, 2.96037942e-01f, 1.16909094e-01f, 1.90843508e-01f, 2.26351768e-01f,
  1.73796624e-01f, 1.97281972e-01f, -1.64289013e-01f, 7.66855059e-03f, 1.55514345e-01f, 1.61778107e-01f, 1.17954008e-01f, 5.50379343e-02f, 1.07407413e-01f, 2.52750784e-01f,
  5.71112931e-01f, -1.68221384e-01f, 1.29756436e-01f, -7.86927938e-02f, -1.67441592e-01f, -3.17435354e-01f, -7.70665035e-02f, -1.10984832e-01f, -1.18169844e-01f, 1.69574004e-02f,
  -1.37092859e-01f, 1.20036025e-02f, -9.82669070e-02f, -7.97584206e-02f, -8.39605629e-02f, -1.52329296e-01f, -2.12433949e-01f, -4.96392958e-02f, 8.59087557e-02f, 1.08984746e-01f,
  2.82270294e-02f, -1.59795046e-01f, 9.34277028e-02f, -1.00709550e-01f, -4.13920507e-02f, 4.89795301e-03f, -5.34767061e-02f, -5.16880825e-02f, -1.17792457e-01f, -1.03922807e-01f,
  -2.17817444e-02f, 8.87199417e-02f, -2.50972267e-02f, 5.88189140e-02f, 1.01735257e-02f, 2.59127351e-03f, 3.72158103e-02f, -3.51255126e-02f, 4.17268537e-02f, -7.28761032e-02f,
  8.18533897e-02f, 2.04781994e-01f, 3.72427665e-02f, -6.74023107e-02f, 8.86809900e-02f, -5.51954983e-03f, -1.61424488e-01f, 2.39881389e-02f, -1.51919931e-01f, -1.26641154e-01f,
  -9.00014117e-02f, -4.55040298e-02f, -8.91312286e-02f, -5.39293215e-02f, 2.15982366e-02f, -3.35234962e-02f, -3.12480293e-02f, -6.22576475e-03f, -6.54237252e-03f, 1.34599591e-02f,
  5.94436586e-01f, -1.93371773e-01f, 2.11789340e-01f, 1.10365294e-01f, 2.47833338e-02f, -1.79320961e-01f, 1.23552203e-01f, 8.06677341e-02f, -2.90420130e-02f, 1.54322594e-01f,
  -3.13346907e-02f, 6.62012398e-03f, -2.04164665e-02f, -4.81708385e-02f, 3.00627369e-02f, -5.41798100e-02f, -1.10579140e-01f, 9.20030698e-02f, 2.50639506e-02f, -3.48167866e-02f,
  -1.76684305e-01f, 1.41681628e-02f, 2.10608885e-01f, 7.15619996e-02f, -3.64177525e-02f, 1.95433840e-01f, 4.99967411e-02f, 1.59171790e-01f, 6.77125752e-02f, 7.62752071e-02f,
  7.73856342e-01f, 2.13467568e-01f, 3.28828454e-01f, 8.62514302e-02f, -2.65977174e-01f, -5.35826348e-02f, -1.63283627e-02f, 2.15352848e-01f, 2.59838134e-01f, 1.82962567e-01f,
  1.02908097e-01f, 1.66958541e-01f, 1.00471720e-01f, 1.49042428e-01f, 2.56622404e-01f, -2.23733541e-02f, 9.96211842e-02f, 1.57858402e-01f, 1.46234363e-01f, 6.22074008e-02f,
  -4.41474691e-02f, -1.88907329e-02f, 9.09753889e-02f, 1.62262749e-02f, -7.08389431e-02f, 1.00518344e-02f, -2.48770732e-02f, -1.45261392e-01f, -4.80571166e-02f, 2.90710926e-01f,
  2.90081114e-01f, 2.45548859e-01f, 1.82588890e-01f, -1.10476904e-01f, -1.23373894e-02f, 9.12506133e-02f, 1.15805276e-01f, 7.35162571e-02f, -1.76280275e-01f, -1.24488853e-01f,
  -1.17998002e-02f, 6.77234307e-03f, 2.32561794e-03f, -8.99668261e-02f, -6.66158646e-02f, 8.95931348e-02f, 1.35824502e-01f, 9.63568240e-02f, 8.33072662e-02f, 1.40766039e-01f,
  -9.63900238e-03f, 1.03218175e-01f, -6.53721765e-02f, 7.31081516e-02f, 6.96892738e-02f, 2.61456594e-02f, 1.57016769e-01f, 6.00754172e-02f, 1.21328808e-01f, 2.57820189e-01f,
  3.66473757e-02f, 7.55176395e-02f, 8.36150050e-02f, 1.29903987e-01f, 2.27357950e-02f, -3.45671549e-02f, 2.16239248e-03f, -8.69882703e-02f, 4.87617329e-02f, -1.39431328e-01f,
  -1.96078986e-01f, 2.60530468e-02f, 1.63291633e-01f, 4.20385599e-02f, -3.40541685e-03f, 4.90315780e-02f, 5.72687685e-02f, 1.05744675e-02f, -5.83639592e-02f, 3.90298218e-02f,
  -7.48661309e-02f, -7.96757415e-02f, -9.33410674e-02f, 1.92165058e-02f, -6.64149225e-02f, 4.89704385e-02f, 4.39680368e-03f, 6.22605383e-02f, -1.75127033e-02f, -4.63536680e-02f,
  -1.62192229e-02f, 5.92002347e-02f, 6.35250956e-02f, 4.95962091e-02f, 7.68366382e-02f, -1.18267864e-01f, 1.38291761e-01f, -1.50276288e-01f, -1.22061767e-01f, 5.42261489e-02f,
  6.71209171e-02f, 3.74606252e-03f, 7.91145042e-02f, -7.39532709e-02f, -1.90710679e-01f, -9.98123065e-02f, 2.82157809e-02f, 1.97579563e-01f, 1.03443645e-01f, -2.04883870e-02f,
  1.82125121e-02f, 1.56804815e-01f, 6.79320991e-02f, 1.04280807e-01f, 4.48136441e-02f, -1.16673904e-02f, -9.87533480e-02f, -4.50932719e-02f, 4.32142243e-02f, -1.10959567e-01f,
  -2.96943277e-01f, -3.29565667e-02f, -3.30317318e-01f, 2.22538054e-01f, 2.05730021e-01f, -1.83018118e-01f, -1.27647385e-01f, -6.37089387e-02f, 1.20699257e-01f, 1.89593092e-01f,
  5.49977347e-02f, 2.42385164e-01f, 1.59190908e-01f, 9.98225659e-02f, -1.04878515e-01f, 9.80906114e-02f, 7.60246664e-02f, -3.73627222e-03f, -6.39511049e-02f, 1.48920193e-01f,
  3.55681181e-01f, 2.50484407e-01f, -1.11556677e-02f, 1.29865900e-01f, 3.69352788e-01f, 4.04138386e-01f, 1.13084748e-01f, 2.78823860e-02f, 2.29403868e-01f, 5.52292705e-01f,
  -2.21541636e-02f, -1.55276984e-01f, 8.21865052e-02f, 1.22998014e-01f, -1.19322464e-01f, -5.97976483e-02f, 7.69634619e-02f, -4.28882279e-02f, -7.22571909e-02f, -5.76721430e-02f,
  1.42851453e-02f, 2.68889181e-02f, -9.70747769e-02f, -7.47604147e-02f, -5.99170066e-02f, -2.54096128e-02f, -2.47921705e-01f, -2.89252196e-02f, -7.81971067e-02f, 9.82830152e-02f,
  1.72215283e-01f, 4.93877493e-02f, -1.16054922e-01f, -9.57290009e-02f, -5.33361845e-02f, 9.29266401e-03f, -1.50574669e-01f, -1.37815699e-01f, -2.47947559e-01f, -1.23051308e-01f,
  1.26969919e-01f, -5.56662306e-02f, 1.66542605e-02f, 1.67594850e-02f, 4.72398149e-03f, -4.28456888e-02f, -4.22293916e-02f, -5.38538992e-02f, 4.21176478e-02f, -1.16157167e-01f,
  7.57753570e-03f, 1.13613540e-02f, 3.42538534e-03f, 2.82058883e-02f, 2.35051528e-01f, 1.37037918e-01f, 8.55319053e-02f, -3.76412980e-02f, -1.07466295e-01f, -5.38225956e-02f,
  1.10170752e-01f, -1.29504755e-01f, -4.00738306e-02f, -1.10920370e-01f, 5.65209985e-02f, 6.82033002e-02f, 6.28006086e-03f, 1.02958292e-01f, -4.89603505e-02f, 1.55931845e-01f,
  -5.94087644e-03f, -2.29260445e-01f, 3.16817403e-01f, 9.70127657e-02f, 9.15212855e-02f, -3.22178453e-02f, 2.67822623e-01f, 1.06812917e-01f, 1.98452458e-01f, 1.07815128e-03f,
  -6.29200088e-03f, -7.99522325e-02f, -1.51086971e-01f, -6.08376078e-02f, -1.32969335e-01f, 3.34041975e-02f, 2.42494307e-02f, 1.38450280e-01f, -1.80257130e-02f, 1.58362940e-01f,
  -1.43819032e-02f, 2.66947765e-02f, 2.79342686e-03f, -1.61398482e-02f, 1.34244859e-01f, 1.39792353e-01f, 6.33341521e-02f, 7.11846277e-02f, 1.82410311e-02f, -1.32620364e-01f,
  4.01055545e-01f, 7.28898197e-02f, 1.76574558e-01f, 2.67556489e-01f, 2.85777509e-01f, 2.23243475e-01f, 3.22154760e-01f, 2.21863657e-01f, 6.45936802e-02f, 1.71813667e-01f,
  2.27502808e-01f, 8.98981392e-02f, 3.15530747e-01f, 2.54902214e-01f, 1.69977903e-01f, 3.36574800e-02f, 4.19131033e-02f, 2.08668143e-01f, 1.99506983e-01f, 3.91934365e-02f,
  1.53171331e-01f, 9.13958699e-02f, 1.22613870e-01f, 1.92566425e-01f, 2.29381457e-01f, 2.32241884e-01f, 1.02850668e-01f, 2.07595021e-01f, 2.35979810e-01f, 1.69156134e-01f,
  6.46217540e-02f, 2.68972218e-01f, 7.24375062e-03f, 8.67455602e-02f, 3.56679894e-02f, -1.68892682e-01f, -2.15243533e-01f, -8.75537023e-02f, -1.04880013e-01f, -7.32718781e-02f,
  -1.28505439e-01f, -1.02781383e-02f, 4.67793010e-02f, 2.58240420e-02f, -3.87837328e-02f, -1.61009312e-01f, -5.09116054e-03f, -8.00059214e-02f, 1.13057695e-01f, -5.92531748e-02f,
  -1.24407429e-02f, -1.13379516e-01f, -8.01295713e-02f, 5.26881516e-02f, 1.68867022e-01f, 4.26332243e-02f, 4.76210658e-03f, 1.28082052e-01f, 9.17483470e-04f, 8.73953700e-02f,
  1.24628041e-02f, 1.38426408e-01f, 1.48310646e-01f, 1.65494457e-02f, 1.79620638e-01f, -1.16740860e-01f, -3.25942747e-02f, -4.06508148e-03f, 1.66474611e-01f, -3.24883983e-02f,
  -1.71300024e-01f, 3.18464860e-02f, -4.45177853e-02f, -7.13378266e-02f, 1.47515848e-01f, -4.94419858e-02f, -7.68656433e-02f, -9.63032022e-02f, 4.69557494e-02f, -9.20109171e-03f,
  -5.99697866e-02f, -1.39120631e-02f, 2.38633398e-02f, -8.13508928e-02f, 1.43321864e-02f, -4.52718250e-02f, -1.42529095e-02f, 3.60158198e-02f, -7.33538717e-02f, -5.42412437e-02f,
  -3.87394518e-01f, 2.77053356e-01f, 1.37133226e-02f, 5.59267960e-02f, -1.60358474e-02f, 7.66537711e-02f, -2.32736561e-02f, -5.90546466e-02f, -5.85598536e-02f, -1.50599360e-01f,
  -1.87550057e-02f, -8.36822838e-02f, -9.51971561e-02f, -4.63370718e-02f, -1.47417411e-01f, -1.48107171e-01f, -6.59140795e-02f, -1.21612243e-01f, -7.15202093e-02f, -1.06762417e-01f,
  -3.39520387e-02f, -2.11144656e-01f, -2.27419704e-01f, -4.70254086e-02f, -3.91647033e-02f, -1.95176423e-01f, -3.05586867e-02f, -3.40326577e-02f, -4.46744859e-02f, -1.62409410e-01f,
  -1.81422710e-01f, -4.70059723e-01f, -6.18789438e-03f, 1.91412657e-01f, 3.64854157e-01f, 3.53834033e-01f, 3.82643282e-01f, 2.95788884e-01f, 1.98239625e-01f, 7.28288591e-02f,
  -2.11996421e-01f, -8.39942470e-02f, -2.67890804e-02f, -3.96975540e-02f, 1.68190580e-02f, 1.27181381e-01f, 2.06876457e-01f, 3.46790291e-02f, 2.63997495e-01f, 4.25214440e-01f,
  2.25381345e-01f, 2.26565525e-01f, 3.91983911e-02f, 1.46410137e-01f, -1.68973114e-02f, 2.00291991e-01f, 9.26461220e-02f, 9.03554726e-03f, -3.91122848e-02f, -2.07532987e-01f,
  -6.46453798e-01f, -3.29054475e-01f, 5.35356067e-02f, -1.12816006e-01f, -1.78238273e-01f, -3.55871208e-02f, -9.31750461e-02f, -8.79931375e-02f, -3.69654037e-02f, -1.90492086e-02f,
  -8.80987868e-02f, -1.51894867e-01f, -1.00304015e-01f, -6.55969307e-02f, -4.44101878e-02f, 1.15459174e-01f, -8.74756128e-02f, 2.27836836e-02f, 1.57105066e-02f, -1.45407915e-01f,
  -2.21208278e-02f, -4.52258363e-02f, -8.85916501e-03f, 1.51649415e-01f, 9.73453671e-02f, 7.42490515e-02f, -1.22543290e-01f, 4.13191393e-02f, 1.03430031e-02f, 2.73686536e-02f,
  3.21197838e-01f, 8.80497470e-02f, 1.34407813e-02f, 4.76311259e-02f, 2.15932146e-01f, -1.85594130e-02f, -5.94579391e-02f, -1.09396487e-01f, 9.95955989e-02f, 2.63595022e-02f,
  -1.27924025e-01f, 3.00523434e-02f, 3.39671820e-02f, -6.53188601e-02f, -3.57131362e-02f, 5.31408004e-03f, -2.25959271e-02f, -1.43131107e-01f, -2.61010546e-02f, -9.49834585e-02f,
  2.83564907e-03f, 1.80096757e-02f, -1.12872280e-01f, -1.06751055e-01f, -1.37060173e-02f, 3.08003165e-02f, -1.17353983e-02f, -2.14434844e-02f, 9.26204305e-03f, 6.62036017e-02f,
  -1.23227857e-01f, -2.21673891e-01f, -2.21247971e-01f, -1.61309868e-01f, -9.61036012e-02f, -1.31143108e-01f, -1.07944198e-01f, -1.87848121e-01f, -1.17352054e-01f, -2.11256426e-02f,
  -1.01177670e-01f, -1.12219810e-01f, -2.24130064e-01f, -1.21882871e-01f, 1.35501415e-01f, 9.65697765e-02f, -1.05604060e-01f, -2.03579981e-02f, -2.45622806e-02f, -1.59963161e-01f,
  3.53396311e-02f, 2.62958169e-01f, 2.10615113e-01f, 1.69633374e-01f, 3.45696285e-02f, 1.04861252e-01f, 1.84432670e-01f, 1.01870984e-01f, 2.05542088e-01f, 4.22597110e-01f,
  2.97701985e-01f, 2.05568671e-02f, 2.18442351e-01f, 2.99837142e-02f, -3.20323706e-01f, -2.10760400e-01f, -4.04823095e-01f, -1.55234233e-01f, -3.15864235e-02f, 2.74934173e-02f,
  1.16688073e-01f, 1.10988878e-01f, 1.97383046e-01f, 2.60250658e-01f, 4.50932048e-02f, 4.95740883e-02f, 1.32645890e-01f, 4.46406573e-01f, 2.68110156e-01f, 1.21052086e-01f,
  -1.10683376e-02f, 1.37984917e-01f, 3.04060012e-01f, 2.02014595e-01f, 1.65919527e-01f, 1.75737426e-01f, 9.78673995e-02f, 5.82318418e-02f, 1.10591225e-01f, 5.31507671e-01f,
  3.39103878e-01f, -1.81171708e-02f, 5.23467995e-02f, -6.83542565e-02f, 6.01975024e-02f, -8.52624401e-02f, -1.42705768e-01f, 1.40204012e-01f, -1.62214898e-02f, 6.02999851e-02f,
  -3.02712992e-02f, 4.69714180e-02f, -4.29713614e-02f, 8.04794207e-03f, -1.23957068e-01f, -5.06389551e-02f, -3.96684110e-02f, 2.32699692e-01f, 1.77327067e-01f, -8.43979269e-02f,
  1.89018901e-02f, -7.59811699e-02f, -1.52171597e-01f, -9.12462845e-02f, -3.82117853e-02f, 1.73301339e-01f, 5.58774322e-02f, 7.58010298e-02f, 7.23631307e-02f, 3.17262173e-01f,
  2.58059688e-02f, 8.58160034e-02f, 2.14874707e-02f, -6.84187515e-04f, 5.28763719e-02f, -2.65811267e-03f, 1.17423475e-01f, -4.69131283e-02f, 2.21938714e-02f, -6.98106363e-02f,
  5.31496853e-02f, 1.65066477e-02f, -9.00500715e-02f, 4.58572730e-02f, 2.23037824e-02f, -1.16194952e-02f, -1.01044729e-01f, 1.12092480e-01f, -1.05826147e-02f, -4.13348153e-03f,
  -1.77971311e-02f, 1.03393801e-01f, 1.72553007e-02f, 2.29507670e-01f, 1.86936662e-01f, 5.50210960e-02f, -3.00296140e-03f, -7.06873909e-02f, 3.78346741e-02f, 4.33367752e-02f,
  -3.44485551e-01f, -2.86092192e-01f, 2.28312224e-01f, -1.78387269e-01f, 2.26429664e-02f, -9.10759047e-02f, -1.61374822e-01f, 2.39245687e-02f, -1.54329864e-02f, 7.18632266e-02f,
  -2.17660710e-01f, -1.28062353e-01f, -3.01382467e-02f, -9.61297229e-02f, -1.28899977e-01f, -9.38237086e-02f, -1.04089916e-01f, 1.73420718e-04f, 4.47839312e-03f, -1.38770998e-01f,
  -1.96995080e-01f, -3.23466986e-01f, -3.02496225e-01f, -5.34840934e-02f, -2.16699541e-01f, -1.99237674e-01f, -1.89296454e-01f, -2.87317485e-01f, -4.57933545e-01f, -2.07927898e-01f,
  -1.63091421e-01f, -5.34195662e-01f, -5.06230712e-01f, -1.87397957e-01f, -2.51817137e-01f, 4.45243381e-02f, -2.54240841e-01f, 1.82226047e-01f, 1.19827531e-01f, -6.08203530e-01f,
  2.85053179e-02f, 2.91737616e-01f, -1.14308774e-01f, 1.97658673e-01f, 1.65678397e-01f, -6.05034709e-01f, -4.25808966e-01f, -3.70150059e-02f, 3.84324491e-01f, 4.13089573e-01f,
  5.51297069e-02f, -8.52765515e-02f, 2.36942813e-01f, 2.07601547e-01f, -3.59372169e-01f, 2.50140228e-03f, -5.34611881e-01f, -7.41174594e-02f, -1.62742496e-01f, -7.16092288e-01f,
  -4.33666229e-01f, -6.46728277e-02f, 1.47520706e-01f, 2.91138172e-01f, -3.10429454e-01f, 1.39632851e-01f, 1.22804552e-01f, -2.13028058e-01f, -4.59048487e-02f, -5.18531092e-02f,
  -2.72934847e-02f, 1.33944795e-01f, 1.21819302e-01f, 8.32939893e-02f, -4.25711237e-02f, 6.90881582e-03f, -1.07468680e-01f, -8.35688338e-02f, -1.57766834e-01f, -5.04584089e-02f,
  -3.86174470e-02f, -2.46089771e-02f, -8.24462809e-03f, 1.12816587e-01f, 2.36098394e-01f, -5.41142523e-02f, -2.32993774e-02f, 1.50718996e-02f, 3.05925533e-02f, -5.41700721e-01f,
  -5.16383685e-02f, -6.38663620e-02f, -9.97314043e-03f, 5.91385085e-03f, 7.48923002e-03f, -3.33423167e-02f, 4.28141616e-02f, 1.13178924e-01f, 9.93615910e-02f, -1.37510058e-02f,
  -5.79799712e-02f, 3.70959565e-02f, 5.65259904e-03f, -5.97370267e-02f, -1.01928134e-02f, -1.49513464e-02f, -8.24503452e-02f, -8.16795677e-02f, 1.32376729e-02f, -7.92095885e-02f,
  -4.24184166e-02f, 7.44308382e-02f, -1.10579669e-01f, 2.65781097e-02f, -1.23527972e-02f, 1.54257687e-02f, -1.95024665e-02f, 1.19826175e-01f, 8.93801544e-03f, 2.98904665e-02f,
  -3.65649424e-02f, 1.64479122e-01f, -2.36161023e-01f, 6.58648163e-02f, -1.24848954e-01f, -4.86720150e-04f, -1.18682101e-01f, -1.25096114e-02f, 2.01278795e-02f, 5.31901903e-02f,
  1.50767773e-01f, -4.68573794e-02f, -2.07419574e-01f, -1.43414000e-02f, 1.36391670e-02f, 1.35642514e-01f, -6.02519065e-02f, 3.77127044e-02f, 9.66086388e-02f, -4.90616597e-02f,
  -2.47063730e-02f, -5.99202653e-03f, 1.16393991e-01f, -2.22248524e-01f, 1.54375508e-01f, -1.76788066e-02f, -1.74920540e-02f, -8.13052580e-02f, 8.86854678e-02f, -4.16997463e-01f,
  1.05398190e+00f, 1.73977777e-01f, 2.93029428e-01f, 8.16303212e-03f, -3.13308448e-01f, 1.52907539e-02f, 2.21654430e-01f, 9.18732882e-02f, -6.65720031e-02f, 5.17519712e-02f,
  -1.51397690e-01f, -2.81643957e-01f, -8.67060795e-02f, -1.64954942e-02f, 2.15118960e-01f, 1.68962762e-01f, 2.02446505e-02f, 2.50127137e-01f, 1.81621760e-01f, -1.88804846e-02f,
  -1.47830725e-01f, 1.26313269e-01f, 3.03393185e-01f, 1.32863149e-01f, -1.25407744e-02f, -1.40292034e-01f, -1.29032463e-01f, -5.56017365e-03f, -7.22367987e-02f, 1.31662846e-01f,
  3.53229165e-01f, 9.60934535e-03f, -2.94151127e-01f, -1.51732624e-01f, -1.85664639e-01f, 3.79872061e-02f, 6.13926984e-02f, 7.20694289e-02f, -7.84987863e-03f, -9.22344252e-02f,
  -7.78013170e-02f, -6.71368986e-02f, -4.38729227e-02f, 7.04486817e-02f, 3.44851147e-03f, 2.24008765e-02f, -2.36085672e-02f, 9.81336161e-02f, 5.64979278e-02f, -1.33731794e-02f,
  -1.56128690e-01f, -4.41129580e-02f, -6.52441904e-02f, -5.12411706e-02f, 3.25992107e-02f, -5.51622845e-02f, -9.44396555e-02f, -5.56241944e-02f, 3.38317864e-02f, 2.03788467e-02f,
  -1.21509936e-02f, 9.45774168e-02f, -3.55812795e-02f, -2.57211793e-02f, -1.16012851e-02f, -7.28626847e-02f, 4.75809500e-02f, 1.31356232e-02f, 7.85664096e-03f, 1.27018139e-01f,
  1.20885894e-02f, -5.43961814e-03f, -6.71291351e-02f, 2.34941617e-02f, 7.56067038e-03f, -1.20224636e-02f, 1.78898573e-01f, -4.24055103e-03f, -1.10889606e-01f, -1.59369260e-01f,
  1.85015202e-02f, 1.22082181e-01f, -1.77605432e-02f, 5.41820331e-03f, -1.55751733e-02f, 1.02508646e-02f, -3.07977688e-03f, -8.12178105e-02f, 3.25111523e-02f, 7.89206401e-02f,
  -3.78900588e-01f, -4.52232927e-01f, 6.85392395e-02f, 5.14438786e-02f, 1.78683832e-01f, 4.01375517e-02f, -2.90293526e-02f, -1.19711775e-02f, -1.08522452e-01f, -3.62129547e-02f,
  3.55501892e-03f, 1.00033350e-01f, 6.55324236e-02f, 1.51068136e-01f, 9.64697003e-02f, 9.16600078e-02f, -4.12538089e-02f, 7.50072449e-02f, -3.87484878e-02f, -1.51883988e-02f,
  6.38808310e-02f, -1.65275428e-02f, 6.91016167e-02f, 5.14836684e-02f, 3.74674313e-02f, 7.10777491e-02f, 4.84587625e-02f, 1.16409630e-01f, 1.39275566e-01f, 1.15451172e-01f,
  -9.27386224e-01f, 2.35842913e-01f, 2.51033008e-01f, -7.09800184e-01f, 2.11421549e-01f, 2.05225244e-01f, 5.43495834e-01f, 6.20165132e-02f, -6.51523024e-02f, 1.36066630e-01f,
  1.97508320e-01f, -1.44768536e-01f, -3.88911627e-02f, 2.47110739e-01f, 3.81868519e-02f, 2.47718349e-01f, 1.44659653e-01f, -8.72972384e-02f, -8.54901522e-02f, 2.04435274e-01f,
  1.57162115e-01f, -3.75566036e-01f, -4.72667903e-01f, -7.86603615e-02f, -1.08877681e-01f, -1.40986249e-01f, -7.32435361e-02f, -5.85149601e-02f, 1.93856746e-01f, -2.43424296e-01f,
  -1.98996365e-01f, -9.36732441e-02f, 3.01804215e-01f, -1.33760527e-01f, -1.16210781e-01f, -1.34483129e-01f, -8.21451694e-02f, 7.91545399e-03f, 8.77264701e-03f, -7.29563460e-02f,
  -2.36240163e-01f, 4.95693050e-02f, -2.26138309e-01f, -3.07626612e-02f, -1.06221728e-01f, -7.48119829e-03f, 3.33614349e-02f, 1.31831393e-01f, -3.66927125e-02f, 3.23791802e-02f,
  1.01341784e-01f, 1.91532280e-02f, -8.87407437e-02f, 2.47722030e-01f, 7.50093013e-02f, 1.71651896e-02f, 1.81076191e-02f, -3.55320685e-02f, 2.49860093e-01f, -3.10544938e-01f,
  7.75173008e-02f, 7.09262043e-02f, 1.26437142e-01f, -5.35714515e-02f, -8.43825564e-02f, 3.58712524e-02f, -1.58697199e-02f, -5.02356142e-02f, 7.37302601e-02f, -2.60026045e-02f,
  1.10408291e-01f, -1.04264207e-02f, 1.10935688e-01f, -3.44976336e-02f, -6.18285686e-02f, -3.43200043e-02f, -3.03518847e-02f, -5.95606454e-02f, -6.78875670e-02f, -2.07080860e-02f,
  1.73711590e-02f, -8.90690535e-02f, -2.24777795e-02f, -3.96615677e-02f, 1.51555210e-01f, -1.06610201e-01f, 1.11025110e-01f, -3.27362940e-02f, -5.53849004e-02f, 1.55071840e-01f,
  -4.76388961e-01f, 4.44048882e-01f, -1.57929361e-01f, 8.80704448e-02f, 2.08335891e-02f, 9.14510936e-02f, -8.81661624e-02f, 3.32678482e-02f, -5.95812313e-02f, 8.66165534e-02f,
  5.28903231e-02f, 6.18087985e-02f, 5.44170141e-02f, 7.51526654e-03f, -3.42053063e-02f, 2.88352836e-02f, -2.73753274e-02f, -6.69461712e-02f, 8.66590142e-02f, -1.50067091e-01f,
  -9.36526507e-02f, -7.25660250e-02f, -2.43136853e-01f, -6.98725581e-02f, -4.61235791e-02f, -2.84520909e-02f, -2.18249395e-01f, -8.72113705e-02f, -1.58731882e-02f, -4.24851537e-01f,
  -4.05893922e-01f, 8.53121579e-02f, -3.30482721e-01f, -1.42922312e-01f, 2.72572070e-01f, -8.27929452e-02f, -7.31015857e-03f, -2.10500762e-01f, 3.02856695e-02f, 2.06957266e-01f,
  1.45211354e-01f, 1.53542519e-01f, 1.77305847e-01f, 1.97838396e-01f, -1.95938051e-01f, 1.49841323e-01f, 2.10090339e-01f, -1.03380904e-01f, -3.79964709e-01f, -7.43364468e-02f,
  2.59633899e-01f, 2.75526401e-02f, -3.07207018e-01f, -9.93498415e-02f, 1.76294461e-01f, 1.29645884e-01f, 1.67493857e-02f, 1.26675460e-02f, 1.63439661e-01f, 3.19374770e-01f,
  -4.56737243e-02f, -1.33015692e-01f, 3.81620601e-02f, -4.42573912e-02f, -7.66425207e-03f, 3.86616848e-02f, 4.24959548e-02f, -1.32256836e-01f, -9.38384086e-02f, -9.59280208e-02f,
  1.57547235e-01f, -2.04166565e-02f, 4.83637005e-02f, 6.59790486e-02f, -1.49722606e-01f, -2.60329098e-01f, -1.51710212e-01f, -1.30004987e-01f, -4.80167747e-01f, -3.73542100e-01f,
  2.34783143e-01f, 1.28468230e-01f, -2.46643484e-01f, -2.89521337e-01f, -2.82150209e-01f, -6.42721951e-02f, -3.53269756e-01f, -2.21670434e-01f, -3.41533870e-01f, -3.88051867e-02f,
  -1.12420529e-01f, -5.29383942e-02f, 7.37727061e-02f, 1.53561726e-01f, 1.53404158e-02f, 6.72683790e-02f, 4.92779240e-02f, 1.08991399e-01f, 2.03255206e-01f, 4.88553159e-02f,
  -1.00374045e-02f, -3.64887388e-03f, 9.62666571e-02f, -3.16414386e-02f, 1.12506084e-01f, -7.02183619e-02f, -4.80409190e-02f, -8.89181048e-02f, -1.29902828e-02f, 9.91449654e-02f,
  4.10102541e-03f, 4.58834656e-02f, 1.98548466e-01f, -1.86239228e-01f, 1.80820212e-01f, 3.37969847e-02f, 2.73445249e-02f, -3.73262726e-02f, -9.60553959e-02f, 5.64900786e-02f,
  -4.52119904e-03f, 1.51188165e-01f, 9.54594612e-02f, -4.40080427e-02f, -8.26523826e-02f, -4.32850085e-02f, 7.73487315e-02f, -2.14371476e-02f, -9.94078070e-02f, -3.77530158e-01f,
  -2.36599520e-01f, -8.90547633e-02f, -1.02214632e-03f, 7.01958034e-03f, -2.39275232e-01f, -4.63018939e-02f, 7.80375227e-02f, -3.72019922e-03f, -5.41488901e-02f, -2.37721592e-01f,
  -8.84189457e-02f, -7.90608078e-02f, -1.52901888e-01f, -2.09502831e-01f, 1.28015548e-01f, -5.03255427e-03f, -7.57535473e-02f, -3.85494679e-02f, -1.53095379e-01f, -1.10176340e-01f,
  -1.03826058e+00f, 1.85032219e-01f, 1.98195115e-01f, -4.38835055e-01f, -5.26118316e-02f, -1.42980471e-01f, -3.05644833e-02f, -1.24570075e-02f, -9.49494615e-02f, 3.22518319e-01f,
  9.30104107e-02f, -1.45909265e-01f, -7.40733296e-02f, -1.01027846e-01f, -4.57249105e-01f, -2.35196009e-01f, -3.09722006e-01f, -4.31922019e-01f, -5.55891812e-01f, -1.54514134e-01f,
  -2.02949241e-01f, -6.36561453e-01f, -7.13158846e-01f, -2.08282575e-01f, 2.67025918e-01f, -5.41890226e-02f, 1.76768109e-01f, -1.44569248e-01f, 6.29915819e-02f, 4.45867851e-02f,
  4.97537032e-02f, -1.30241483e-01f, -3.59707959e-02f, -5.38099520e-02f, 2.25140341e-02f, -1.00686513e-01f, -1.24866582e-01f, 6.44674823e-02f, -2.49146279e-02f, 2.08328441e-02f,
  -7.78311715e-02f, 3.64920422e-02f, -1.24417692e-01f, 5.58033511e-02f, -1.45441800e-01f, -4.29351777e-02f, 6.66744933e-02f, -2.56862491e-02f, 1.20066442e-02f, 3.36750031e-01f,
  9.76937115e-02f, -7.55856782e-02f, -1.16339410e-02f, 2.66417712e-01f, 8.26855674e-02f, -5.00412248e-02f, 2.31730342e-01f, 1.70692027e-01f, 9.41320583e-02f, 1.92626551e-01f,
  3.26475278e-02f, 9.51865762e-02f, 8.87499191e-03f, -1.69211011e-02f, 4.39529978e-02f, 7.13549778e-02f, 3.49308103e-02f, 5.57692796e-02f, -9.64630675e-03f, -3.03837359e-02f,
  5.66053391e-02f, -3.59565914e-02f, 1.36363774e-03f, -1.89279753e-03f, 5.50187230e-02f, -4.64096852e-02f, -7.78327286e-02f, 3.24905217e-02f, 9.63871852e-02f, -1.17143981e-01f,
  -7.62959570e-02f, 4.19299081e-02f, -5.54364622e-02f, 4.02869135e-02f, -2.83266585e-02f, -7.92812929e-02f, -6.78994879e-02f, 3.66747454e-02f, -1.81772932e-02f, 1.55520197e-02f,
  -1.59303017e-03f, -3.53524685e-01f, -6.25217780e-02f, 7.76739568e-02f, -2.88947336e-02f, 7.45883882e-02f, 1.00340853e-02f, 6.02050498e-02f, -1.03060871e-01f, 1.70728080e-02f,
  -3.45732272e-02f, -2.00230768e-03f, 5.25863245e-02f, 1.36670858e-01f, -9.81627405e-02f, 1.91078596e-02f, 6.56827316e-02f, -5.84233217e-02f, -8.41396581e-03f, 1.06047124e-01f,
  1.50356725e-01f, 6.41579106e-02f, -1.29734993e-01f, 1.17325224e-01f, -2.10620128e-02f, -1.93426341e-01f, 5.56570292e-02f, 6.79733977e-02f, -1.49571911e-01f, 1.44647628e-01f,
  -1.24152315e+00f, -1.25300949e-02f, 2.73078501e-01f, -4.28969711e-01f, 9.52064693e-02f, 2.02251345e-01f, 3.43976647e-01f, -5.95248230e-02f, -2.65301734e-01f, 9.75441709e-02f,
  -3.89747769e-02f, -2.47205809e-01f, -6.73669130e-02f, 8.83498862e-02f, -4.45540659e-02f, 3.53900462e-01f, 1.88129574e-01f, 1.83300488e-02f, -4.13771793e-02f, 1.97392508e-01f,
  1.48010731e-01f, -2.15855315e-01f, -4.72074389e-01f, -1.72997326e-01f, -4.59235273e-02f, -1.64323915e-02f, 1.07644208e-01f, -2.75641438e-02f, 2.07016960e-01f, 1.09895565e-01f,
  4.81917143e-01f, -2.84964532e-01f, -8.52193609e-02f, -9.36377347e-02f, 3.09573915e-02f, -6.32653683e-02f, 6.57203421e-02f, -9.48548540e-02f, 4.23879037e-03f, 1.24977335e-01f,
  -1.61967648e-03f, -4.35490422e-02f, -1.66451722e-01f, 8.32505897e-02f, 4.97236103e-02f, -2.96818092e-02f, -8.75188187e-02f, 2.05489565e-02f, 1.84923992e-01f, 1.78958178e-01f,
  1.13227747e-01f, 1.20875821e-01f, 5.94892912e-02f, 1.90512314e-01f, -3.78594287e-02f, -8.71107355e-03f, 1.12237655e-01f, 3.74440588e-02f, -1.81038454e-02f, -4.15562056e-02f,
  1.72506481e-01f, 6.27254415e-03f, 1.33947395e-02f, -7.69574270e-02f, -3.55805084e-02f, -3.87909561e-02f, -2.02456899e-02f, 2.24622898e-02f, 5.61533980e-02f, -8.37592185e-02f,
  4.11021598e-02f, 1.33718885e-02f, -5.05415723e-02f, 2.82370509e-03f, 6.90039396e-02f, -2.10925974e-02f, -6.20798692e-02f, 6.58212975e-02f, -1.42860720e-02f, -8.21836740e-02f,
  -7.32106790e-02f, 1.10853143e-01f, -1.08630545e-02f, 6.56853393e-02f, 1.01242550e-01f, 1.04111791e-01f, 7.20099360e-02f, 2.77370457e-02f, -1.04676643e-02f, -3.40602384e-03f,
  6.51978478e-02f, -1.52790934e-01f, -1.55008242e-01f, -6.47253469e-02f, -4.17530313e-02f, -1.05982944e-01f, -1.42549843e-01f, -4.13595065e-02f, 1.93039715e-01f, 8.64750221e-02f,
  3.09548881e-02f, 8.89567956e-02f, -8.94921347e-02f, -9.25497524e-03f, 1.89925749e-02f, -2.63281097e-03f, -1.29893780e-01f, -7.40984827e-02f, 6.72114938e-02f, 8.59518200e-02f,
  5.59157282e-02f, 1.49807960e-01f, 1.32104188e-01f, 1.45852685e-01f, 9.36944783e-03f, 4.33707088e-02f, 2.29736164e-01f, 1.49563551e-01f, 1.19101815e-01f, 2.02871785e-01f,
  -4.35452200e-02f, 3.65906149e-01f, -3.34446430e-01f, 1.57499269e-01f, 3.52316499e-01f, 1.40350526e-02f, 1.29391477e-01f, -9.19593871e-03f, -1.91615880e-01f, 9.52095911e-02f,
  -7.99486414e-02f, -1.66671816e-02f, -1.12678878e-01f, 1.19871441e-02f, -4.22410172e-04f, 9.38432440e-02f, 2.69594431e-01f, 1.04878843e-02f, -2.10359022e-01f, -1.45486405e-03f,
  2.48752967e-01f, 9.57526788e-02f, -2.83563524e-01f, -7.40339234e-02f, 2.36762196e-01f, -6.68918192e-02f, -1.12226801e-02f, 2.00991407e-01f, 2.61285961e-01f, 7.28154838e-01f,
  1.77287962e-02f, -2.65290011e-02f, -2.00274184e-01f, 1.57543436e-01f, 8.58211517e-02f, -1.68247476e-01f, -5.55404276e-02f, -1.16268001e-01f, -1.53453514e-01f, 6.39231354e-02f,
  1.93767563e-01f, 1.83115317e-03f, 2.64980853e-01f, 1.52151048e-01f, 3.16187143e-02f, -2.15305425e-02f, 2.87649855e-02f, -1.73053920e-01f, -2.03874812e-01f, -1.97604764e-02f,
  4.88178760e-01f, 2.10411802e-01f, -2.43269419e-03f, -4.06638137e-04f, 9.81320255e-03f, -2.34886780e-01f, -2.61691473e-02f, -4.65738401e-02f, -5.40217698e-01f, 2.10770443e-01f,
  -1.17040388e-01f, 2.05832943e-01f, 1.12145156e-01f, -4.69525438e-03f, 7.09395972e-04f, -9.36466455e-03f, 1.68260619e-01f, 6.92036748e-02f, 1.23612016e-01f, 5.05111739e-02f,
  -1.29916131e-01f, -1.25018850e-01f, -1.50017321e-01f, -1.92874536e-01f, -2.09034324e-01f, 6.94681285e-03f, 4.38812934e-02f, 6.62636431e-03f, -1.99112506e-03f, -1.62913010e-01f,
  -7.24715292e-02f, -1.51324188e-02f, -1.66522279e-01f, 3.93157527e-02f, -5.20422310e-02f, -1.78919226e-01f, 4.66412529e-02f, -7.63631836e-02f, -7.59460106e-02f, -1.33769698e-02f,
  -4.02211457e-01f, -2.14519486e-01f, -5.09231985e-02f, -1.14982471e-01f, 8.99853632e-02f, -8.56002346e-02f, -3.94584350e-02f, -6.51634783e-02f, -7.48280436e-02f, -1.59508824e-01f,
  -6.06419779e-02f, -2.12131739e-02f, -6.59569353e-02f, 1.28872357e-02f, -8.41117650e-02f, -9.08130854e-02f, 1.52368322e-01f, 7.73227513e-02f, -9.00192782e-02f, 1.19167358e-01f,
  2.95928329e-01f, -5.97919151e-02f, -1.25055462e-01f, -2.37860069e-01f, -2.44544428e-02f, -4.45256531e-01f, -1.51271775e-01f, -2.91529536e-01f, -3.91619742e-01f, -3.19487661e-01f,
  9.44872499e-01f, -1.39356390e-01f, -6.32414103e-01f, 1.14273489e-01f, -3.12600553e-01f, -4.44875248e-02f, -3.50545757e-02f, 1.94787279e-01f, 2.57930815e-01f, -4.71598804e-02f,
  1.39506847e-01f, 4.06587601e-01f, 5.34090698e-01f, 1.96898445e-01f, 2.91518897e-01f, 5.35700750e-03f, -2.10230857e-01f, -1.27315998e-01f, 1.03890769e-01f, -2.19663084e-02f,
  -9.93933454e-02f, 1.43281054e-02f, 1.63602188e-01f, 5.73878810e-02f, -3.56965244e-01f, 1.22067899e-01f, -2.46611610e-01f, -3.60892981e-01f, -3.16149026e-01f, -5.84270000e-01f,
  6.03223406e-02f, -2.65186489e-01f, 2.04603784e-02f, 7.49712512e-02f, -1.53331220e-01f, -1.35310935e-02f, -2.44754236e-02f, -1.62436366e-01f, -1.81590378e-01f, -1.57887056e-01f,
  -2.00737491e-01f, -9.76912156e-02f, -2.46536862e-02f, -7.77170137e-02f, -1.91049337e-01f, 5.92274824e-03f, -1.34955824e-03f, -3.94322909e-02f, -1.46633074e-01f, -8.59074891e-02f,
  -2.10430361e-02f, -1.13899179e-01f, -1.12697355e-01f, 1.12371258e-01f, 7.54854754e-02f, 1.52822619e-03f, -1.59042150e-01f, -3.01395923e-01f, -1.37494519e-01f, 4.23374362e-02f,
  4.63315193e-03f, 9.04898569e-02f, 1.45309374e-01f, 1.13148727e-01f, 2.26727009e-01f, 7.89348185e-02f, 1.54510811e-02f, 2.94222385e-02f, 1.20435983e-01f, 8.73236209e-02f,
  -1.16398474e-02f, 5.35114622e-03f, -3.15801464e-02f, -6.04281388e-02f, 5.68859950e-02f, -9.25314426e-02f, -6.73009381e-02f, 6.48941770e-02f, -9.70529541e-02f, -7.94087276e-02f,
  8.54597613e-02f, -6.06382824e-02f, -7.62036517e-02f, -1.03119403e-01f, -1.01964958e-01f, 7.85882995e-02f, 2.37981211e-02f, 7.49875009e-02f, 4.53465506e-02f, -1.09683767e-01f,
  5.78054130e-01f, -1.77356496e-03f, 2.43938208e-01f, 1.76732931e-02f, -1.61454052e-01f, -3.02507263e-02f, 1.55475184e-01f, -2.67053843e-02f, -1.72220886e-01f, 3.10275294e-02f,
  -5.95392510e-02f, 8.26273039e-02f, 6.65638447e-02f, 5.93573302e-02f, 1.10937111e-01f, -1.25389569e-03f, 5.17251529e-03f, 1.76783830e-01f, -5.16633466e-02f, -6.74469396e-02f,
  -2.15258193e-03f, 2.35325336e-01f, 3.62863690e-01f, 1.94325149e-01f, 4.89646606e-02f, 2.32580379e-01f, 1.37543142e-01f, 6.19759969e-02f, 2.36037269e-01f, 4.20355588e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.13985553e-01f, 4.58539613e-02f, 3.10983330e-01f, 1.99633926e-01f, 1.48493871e-01f, 3.62558752e-01f, 1.36667296e-01f, 3.28049213e-01f, 4.61747974e-01f, 3.72580051e-01f,
  2.19503909e-01f, 1.12683788e-01f, 6.69039711e-02f, 4.41464841e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -6.16731420e-02f, -4.90492992e-02f, 1.42683327e-01f, 1.49797365e-01f, 8.63995329e-02f, 2.20710002e-02f, -2.35892966e-01f, -1.20154560e-01f, 3.84723991e-02f, -1.63413212e-01f,
  1.91377893e-01f, -9.04311463e-02f, -1.70060918e-01f, 1.49717569e-01f, -9.18193087e-02f, -1.97982818e-01f, 1.59269273e-01f, -2.18084499e-01f, 1.22098960e-01f, 1.41322568e-01f,
  8.23773816e-02f, 1.25375375e-01f, 1.59315035e-01f, 1.14522912e-01f, -9.82867554e-02f, 6.65500611e-02f, -4.50798422e-02f, -1.54428976e-02f, -4.15059514e-02f, 3.42418462e-01f,
  1.57257207e-02f, -1.23568043e-01f, -2.99493819e-02f, 4.26492020e-02f, 1.05071776e-01f, -2.74999887e-02f, -2.72104107e-02f, -3.92241776e-02f, -1.11023872e-03f, -1.39080539e-01f,
  1.52776748e-01f, -5.01544252e-02f, -2.05696613e-01f, 4.63316537e-04f, 1.26433343e-01f, -1.19444234e-02f, -3.90145272e-01f, 5.90210296e-02f, 2.01165557e-01f, 1.81507975e-01f,
  1.34516358e-01f, 1.34118959e-01f, 2.18195498e-01f, 6.23001046e-02f, 2.21762866e-01f, -3.57446164e-01f, 1.06790334e-01f, -4.22101654e-02f, -7.85767809e-02f, 9.15086418e-02f,
  9.21169147e-02f, 1.26323730e-01f, 7.64248446e-02f, 2.70153023e-02f, 7.41564482e-02f, 9.70046222e-03f, 4.41123508e-02f, 5.31173721e-02f, -4.99069616e-02f, 7.07596587e-03f,
  -2.17999429e-01f, -5.69630452e-02f, -8.33731145e-03f, -5.14650941e-02f, 2.90461555e-02f, -8.89119133e-02f, 8.19546655e-02f, 1.48899034e-01f, -7.77833536e-02f, 2.77898069e-02f,
  -1.62964031e-01f, -1.95199966e-01f, 1.23012386e-01f, 1.80715322e-01f, 1.44642293e-01f, -6.41289055e-02f, -2.28730470e-01f, 1.07959233e-01f, 2.33515263e-01f, -5.35968281e-02f,
  -3.24510783e-01f, 2.87795156e-01f, -3.15118402e-01f, -3.87397110e-02f, 3.08563769e-01f, 9.17955339e-02f, 1.28758222e-01f, -2.09462154e-03f, 1.06672142e-02f, -1.68918505e-01f,
  -8.68494436e-03f, -1.12967715e-01f, -3.33093032e-02f, 8.45148321e-03f, -2.74753440e-02f, -1.95904449e-01f, -2.32651487e-01f, 7.36731887e-02f, 1.70167498e-02f, -8.63767788e-02f,
  1.55399581e-02f, -3.55685949e-02f, 2.85130348e-02f, 2.99083292e-01f, 1.60525039e-01f, 2.28555173e-01f, 5.89007698e-02f, -5.12639508e-02f, 3.19495127e-02f, 2.55462658e-02f,
  -9.99260321e-02f, 2.23234504e-01f, -2.42685452e-01f, 4.91286889e-02f, -3.23359996e-01f, -7.09456354e-02f, 1.32978037e-01f, -8.22534040e-03f, -1.29129574e-01f, -1.01254791e-01f,
  -7.58297518e-02f, -9.69968513e-02f, 1.41930744e-01f, 1.12037048e-01f, -5.45528866e-02f, -1.50201738e-01f, 1.04279883e-01f, -1.34131461e-01f, -9.59508717e-02f, -4.02750634e-03f,
  2.08558943e-02f, 9.59598944e-02f, 9.44238156e-02f, 5.93259707e-02f, 4.53362279e-02f, 3.47436070e-01f, -9.78140384e-02f, 1.29971772e-01f, -1.50804043e-01f, -8.38228315e-03f,
  4.62899990e-02f, 9.45277214e-02f, -4.52358931e-01f, 2.23130152e-01f, 1.21000980e-03f, 1.05102375e-01f, -2.31310472e-01f, 1.39795303e-01f, 1.73959628e-01f, 1.86053082e-01f,
  -7.07842559e-02f, -8.96289200e-02f, 5.16954176e-02f, -2.15710521e-01f, 1.84631556e-01f, 1.18132912e-01f, 1.61140785e-02f, 3.57999504e-02f, 7.23957047e-02f, 9.56642628e-02f,
  -9.39797889e-03f, 1.05933230e-02f, 1.48058027e-01f, 3.80479954e-02f, -3.79143357e-01f, 2.12749958e-01f, -1.75319850e-01f, -2.76870221e-01f, 1.31637827e-01f, 8.21267888e-02f,
  1.81344420e-01f, -1.62607461e-01f, -4.87878919e-02f, 1.50524735e-01f, 1.77415714e-01f, -2.68658370e-01f, -3.58150482e-01f, 1.38234836e-03f, 3.10993135e-01f, -1.78670809e-01f,
  -2.15409249e-01f, 2.89871514e-01f, 1.32949054e-02f, -2.10291315e-02f, -5.81657924e-02f, 3.71487401e-02f, -1.90406382e-01f, -3.19785002e-04f, -2.45249458e-02f, 2.86837444e-02f,
  -1.05643541e-01f, 2.50188917e-01f, -8.53112787e-02f, 3.18546966e-02f, 2.92349663e-02f, 1.91359922e-01f, 3.43420923e-01f, -2.32631862e-01f, -5.05442396e-02f, 1.16065934e-01f,
  -1.91762418e-01f, 1.37419030e-01f, 1.94528073e-01f, -3.06446087e-02f, -3.22217457e-02f, -1.83319852e-01f, 3.13431025e-01f, 2.48988029e-02f, 2.71248072e-01f, -1.00005075e-01f,
  1.93874650e-02f, 3.06522828e-02f, 6.87873214e-02f, 1.08189965e-02f, -8.15131664e-02f, -1.70445859e-01f, 1.59425244e-01f, 3.24679822e-01f, -2.98347414e-01f, 2.95863617e-02f,
  1.35776073e-01f, 5.41612394e-02f, -1.87376723e-01f, -6.81302026e-02f, 5.69921955e-02f, -3.21795344e-01f, -2.16085091e-01f, 2.96842992e-01f, 3.94088119e-01f, -1.43145800e-01f,
  -2.00498208e-01f, -2.49275997e-01f, -7.94089586e-02f, 4.41431999e-02f, -2.16446593e-01f, 3.41504037e-01f, -3.66549402e-01f, 2.63357311e-01f, 1.90850601e-01f, 7.03605413e-02f,
  -1.03948563e-01f, -5.20562232e-01f, -3.90355617e-01f, -4.48648304e-01f, -1.31061599e-01f, 6.33766130e-02f, 1.56892762e-01f, 8.61333236e-02f, 2.79233634e-01f, 8.51150006e-02f,
  7.95495734e-02f, 2.55332559e-01f, 2.21402302e-01f, 7.36219436e-02f, 1.39245555e-01f, -1.50434539e-01f, -5.03713498e-03f, -5.79887349e-03f, -1.72987834e-01f, -7.57140741e-02f,
  -1.02994598e-01f, 1.36651844e-02f, 1.50943091e-02f, -1.15859665e-01f, -8.93095210e-02f, 1.68903425e-01f, -1.42940387e-01f, 1.50821194e-01f, -7.36667216e-02f, 1.38544261e-01f,
  2.91779432e-02f, 2.09355786e-01f, -3.35526794e-01f, -2.05063447e-01f, -1.90188825e-01f, -1.15326591e-01f, 1.25046805e-01f, 1.21658809e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.26986104e-01f, 2.64030606e-01f, 2.58883595e-01f, -1.88488901e-01f, 1.32704958e-01f, 3.86702836e-01f, 2.34009847e-01f, 4.53553975e-01f, 4.34925526e-01f, -2.56544769e-01f,
  -5.36540300e-02f, -3.59176874e-01f, -1.32367909e-01f, 2.22053844e-02f, -2.82693714e-01f, 3.83204892e-02f, 2.61584580e-01f, 5.06013095e-01f, -2.00343236e-01f, -1.41741261e-01f,
  -1.48423344e-01f, 3.65585119e-01f, 1.77678481e-01f, 3.24686579e-02f, -1.44668296e-02f, 3.59058231e-01f, -1.91381667e-03f, 1.39000013e-01f, -2.23162159e-01f, -1.16530068e-01f,
  5.13389051e-01f, 4.60410535e-01f, 6.12130538e-02f, 2.83430636e-01f, 2.80205727e-01f, 3.14589262e-01f, 3.15566570e-01f, 2.02343434e-01f, 2.52739877e-01f, 2.60821313e-01f,
  3.24633747e-01f, 5.29060550e-02f, 2.02426434e-01f, 6.92308918e-02f, 1.72898531e-01f, 2.53048651e-02f, -3.15166622e-01f, -1.39984339e-01f, 1.65996179e-01f, -1.95397839e-01f,
  5.49929321e-01f, -1.59207836e-01f, 2.86921799e-01f, 2.72920579e-01f, 1.35358930e-01f, -4.44232747e-02f, -1.79535355e-02f, -2.38211021e-01f, 1.93196416e-01f, 5.00541866e-01f,
  2.20551893e-01f, 8.88833404e-02f, 9.36785787e-02f, 3.51414353e-01f, 1.21071979e-01f, 8.74522608e-03f, 6.99918419e-02f, 2.93047220e-01f, 3.85175385e-02f, 5.04850894e-02f,
  1.85626671e-01f, 8.51585809e-03f, 9.29338671e-03f, -2.25570589e-01f, -5.23971729e-02f, -8.78513381e-02f, -2.77144074e-01f, 1.04663719e-03f, 4.45325941e-01f, -2.53850490e-01f,
  6.67722821e-02f, 2.75034942e-02f, 2.78771967e-01f, -5.73315807e-02f, -4.54432331e-02f, 1.75946251e-01f, -1.27420574e-01f, 2.14416414e-01f, -4.90391999e-02f, -2.19448626e-01f,
  5.67414463e-01f, 1.42186761e-01f, -2.28764415e-01f, 1.83393002e-01f, 5.71478367e-01f, -1.58139214e-01f, 1.59016922e-01f, 1.74363822e-01f, -3.11579625e-03f, 4.38192822e-02f,
  1.17686607e-01f, 1.61129668e-01f, 2.97716618e-01f, 2.40781665e-01f, 4.83279563e-02f, 2.29232833e-02f, 2.77204841e-01f, 1.61526069e-01f, -8.36285800e-02f, -1.81004673e-01f,
  3.48161638e-01f, -2.04077810e-01f, -5.12243584e-02f, -3.91803414e-01f, -2.74198502e-01f, 1.86183408e-01f, -3.04232091e-01f, 1.36705145e-01f, 1.03905380e-01f, 2.27270082e-01f,
  5.88286698e-01f, -1.69541910e-01f, 3.30334485e-01f, -1.01280749e-01f, 1.50450751e-01f, 1.19338080e-01f, -6.38301075e-01f, -4.67884354e-02f, 2.73634847e-02f, 1.22405037e-01f,
  2.86310483e-02f, 1.48854062e-01f, -2.79144943e-01f, 7.27802690e-04f, 4.34264317e-02f, -4.90576997e-02f, 1.69930253e-02f, -9.97274444e-02f, -2.42214218e-01f, -1.10090196e-01f,
  2.02558294e-01f, 2.97342427e-02f, 1.50405005e-01f, -1.83176913e-03f, 8.41465518e-02f, -8.25718194e-02f, 2.60121614e-01f, 2.51369476e-01f, 1.64705411e-01f, 3.46329361e-01f,
  9.37993973e-02f, 2.31699035e-01f, 5.40629327e-01f, -3.06917489e-01f, 1.26370177e-01f, 1.73207238e-01f, -3.02926421e-01f, -2.01519802e-01f, 1.44276530e-01f, 3.90915126e-01f,
  3.94934684e-01f, 6.00422397e-02f, 8.78879279e-02f, -5.36192991e-02f, 1.17516533e-01f, 9.91811603e-02f, 1.65317044e-01f, 2.81247377e-01f, -2.08508626e-01f, -3.85573208e-01f,
  9.37091112e-02f, 5.39991319e-01f, 5.06823838e-01f, -1.86857909e-01f, 2.49760062e-01f, 3.11296672e-01f, -1.42299877e-02f, -4.71503913e-01f, 2.40436673e-01f, -1.82070091e-01f,
  2.36377522e-01f, -5.35788797e-02f, -5.17497919e-02f, 2.53824621e-01f, 4.83786821e-01f, -6.21466815e-01f, 1.46512389e-01f, 2.73326844e-01f, 7.47781694e-02f, -5.91877162e-01f,
  1.42580092e-01f, 1.31193444e-01f, 5.02208844e-02f, 2.03468040e-01f, -1.30625647e-02f, 5.29423952e-01f, 1.51495725e-01f, -1.44374728e-01f, 1.93568289e-01f, 1.87393278e-01f,
  7.99456388e-02f, 4.88847613e-01f, 1.12622224e-01f, -2.61916965e-01f, 6.53854311e-01f, -4.28648263e-01f, -2.87290812e-01f, -2.90164381e-01f, -5.42425551e-02f, -2.42750406e-01f,
  2.50435740e-01f, -4.18512940e-01f, -2.30277807e-01f, -1.14620365e-01f, -6.13725305e-01f, -6.96376503e-01f, 4.91137505e-01f, -1.02370530e-01f, -1.83119312e-01f, -1.61510095e-01f,
  1.35595590e-01f, 2.06038699e-01f, 1.16363056e-01f, 7.24989176e-01f, -1.24100856e-01f, 2.10107509e-02f, -8.86212811e-02f, 1.82475910e-01f, 1.86016694e-01f, 9.60212648e-02f,
  3.73823009e-02f, -5.62210307e-02f, -9.69665945e-02f, -2.86950488e-02f, 2.28016097e-02f, -1.88712012e-02f, 1.26589894e-01f, -1.38876274e-01f, 4.19379234e-01f, -2.23882169e-01f,
  5.96705899e-02f, 6.30082488e-02f, -3.35356265e-01f, -4.70076889e-01f, 3.80802840e-01f, 5.66130504e-02f, 7.30463415e-02f, 1.07594654e-01f, 2.16020957e-01f, -3.50925326e-01f,
  5.28514922e-01f, 3.42987120e-01f, 1.30876198e-01f, 3.85131150e-01f, 1.25615433e-01f, -2.40957052e-01f, 1.22417748e-01f, 1.24812685e-01f, 3.92682031e-02f, 1.77798137e-01f,
  2.45430768e-01f, 1.52817652e-01f, 4.91399206e-02f, 2.71604449e-01f, 2.77651012e-01f, -3.61490995e-02f, 1.30309230e-02f, -4.95020784e-02f, -3.29167426e-01f, -2.30672374e-01f,
  1.09050624e-01f, -4.10757244e-01f, 1.43540546e-01f, 1.32606953e-01f, 3.44844848e-01f, -4.56312485e-02f, 8.99281576e-02f, -2.06689417e-01f, 2.25327969e-01f, -6.52626604e-02f,
  -2.04490706e-01f, 3.62326652e-02f, 4.54602867e-01f, 2.96122402e-01f, 1.85425416e-01f, 4.54143256e-01f, 1.80616006e-01f, 1.26367196e-01f, 3.84520032e-02f, 2.25740910e-01f,
  2.69436777e-01f, 3.63994181e-01f, 3.17520231e-01f, 6.23594336e-02f, 2.95880824e-01f, 5.16457319e-01f, 4.18028146e-01f, 2.27409393e-01f, -6.67825639e-02f, 2.78841883e-01f,
  4.46721703e-01f, -9.86378454e-03f, 1.73369311e-02f, 3.18975151e-01f, -1.71623304e-01f, -1.85666494e-02f, -3.90953928e-01f, 1.32262819e-02f, -1.41195476e-01f, 5.09573966e-02f,
  -4.69857901e-02f, 1.50883704e-01f, -6.88691884e-02f, -7.06349671e-01f, 4.17205304e-01f, 6.50558114e-01f, 8.55920613e-01f, -3.92344072e-02f, -3.70273083e-01f, 3.47912729e-01f,
  -5.19365408e-02f, -2.35449020e-02f, 9.24151018e-02f, 2.00357884e-01f, 1.37746722e-01f, 5.19528240e-02f, 1.67821616e-01f, 2.02870205e-01f, 2.04507276e-01f, -2.45042413e-01f,
  -1.61766738e-01f, -1.81694999e-01f, 1.11199822e-02f, -5.21599948e-02f, 1.14628688e-01f, -1.37257069e-01f, 5.51745705e-02f, -3.10551189e-02f, 4.03115898e-02f, 2.41156816e-01f,
  1.51531756e-01f, -1.34140067e-02f, 6.12341352e-02f, 3.13791752e-01f, 5.08662581e-01f, 4.88155186e-01f, -2.12295100e-01f, -8.50273743e-02f, -3.34986866e-01f, -2.75181144e-01f,
  7.92567991e-03f, 2.34010696e-01f, 1.42638430e-01f, 2.81776227e-02f, 2.29984000e-01f, 3.34542632e-01f, 1.72467783e-01f, 2.32315928e-01f, -1.49344489e-01f, -6.21208623e-02f,
  4.69794095e-01f, -3.88845317e-02f, 1.27798274e-01f, -2.09489062e-01f, 2.03236029e-01f, 3.70975941e-01f, -1.87499046e-01f, 1.39038384e-01f, -4.55713958e-01f, -2.75924832e-01f,
  1.21817514e-01f, 2.98780520e-02f, 1.89859182e-01f, -3.60286951e-01f, -8.14231932e-01f, 4.64528084e-01f, -5.70706949e-02f, 3.61152261e-01f, -8.33773196e-01f, 1.70259550e-01f,
  -3.09362322e-01f, -4.67193335e-01f, 3.69560897e-01f, -2.73283839e-01f, 2.78121065e-02f, 7.78713226e-02f, 8.81355926e-02f, 3.09540778e-01f, -3.81613448e-02f, 1.74234986e-01f,
  1.38989359e-01f, 1.09284282e-01f, -1.06068971e-02f, -9.81130973e-02f, 1.72878012e-01f, -1.25570530e-02f, -2.59689718e-01f, -1.85122028e-01f, 1.97357282e-01f, 6.64350167e-02f,
  -2.66155720e-01f, -6.12485528e-01f, -1.05094165e-01f, 3.97262610e-02f, -6.88364431e-02f, 2.53265172e-01f, -9.04452894e-03f, 3.91452909e-01f, 6.69968963e-01f, 1.82443768e-01f,
  -1.72391728e-01f, -4.80924636e-01f, -2.81511873e-01f, -4.55150932e-01f, -1.07903324e-01f, 4.78717536e-01f, 1.49935767e-01f, 2.57084876e-01f, 3.62474233e-01f, 4.05696541e-01f,
  5.08450344e-02f, 2.91414797e-01f, 8.16475749e-02f, 2.30020925e-01f, 1.08029284e-01f, -1.78148463e-01f, 1.34245083e-01f, 2.10218206e-01f, 1.00494638e-01f, -2.42438346e-01f,
  3.30441654e-01f, 1.36472642e-01f, -9.45564881e-02f, -1.48675576e-01f, -1.09260939e-01f, 6.74984278e-03f, 2.39395767e-01f, 8.85614902e-02f, -5.06549358e-01f, 1.97255880e-01f,
  1.59437343e-01f, -4.80502918e-02f, 4.44339514e-01f, 3.58845860e-01f, -1.24153756e-01f, 1.90562159e-01f, 3.57814640e-01f, -5.49808681e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  5.69967270e-01f, 3.07781070e-01f, 3.89274389e-01f, 5.30357696e-02f, 3.32033709e-02f, 3.54391396e-01f, 2.45350212e-01f, 1.38217926e-01f, 6.93018958e-02f, 4.88964111e-01f,
  3.96341473e-01f, 7.48354867e-02f, 1.19312756e-01f, 4.68099147e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -6.15707375e-02f, -2.21186623e-01f, -4.70965952e-02f, 8.34238231e-02f, 4.03874874e-01f, 1.78128392e-01f, 2.40262702e-01f, -1.96729213e-01f, 3.26327860e-01f, 2.26098284e-01f,
  4.21751976e-01f, 1.41869918e-01f, 1.58607572e-01f, -1.10603701e-02f, 5.32538593e-01f, -6.59781247e-02f, -3.03741723e-01f, -4.42024227e-03f, 8.43984410e-02f, 2.36459896e-01f,
  -3.04913241e-02f, -3.69543880e-01f, 6.70341402e-02f, 1.40241966e-01f, 2.17661653e-02f, -8.39476213e-02f, 3.17958072e-02f, -1.62316203e-01f, -4.80488315e-02f, 1.35578573e-01f,
  -3.45393509e-01f, -1.02672979e-01f, 4.52510938e-02f, -1.30976245e-01f, -3.61438423e-01f, 2.84924865e-01f, -2.65527695e-01f, 2.84630716e-01f, -1.91177219e-01f, -3.24391834e-02f,
  -7.64248446e-02f, -3.08026105e-01f, -1.60438403e-01f, 3.54592651e-02f, 3.12054586e-02f, -2.10596904e-01f, 1.63248032e-01f, -2.03214079e-01f, -3.47687155e-02f, -2.79324144e-01f,
  -1.43316790e-01f, -8.86868536e-02f, -1.71981454e-01f, 8.96240249e-02f, 3.27032618e-02f, 3.06731492e-01f, -1.54682174e-01f, 3.77449006e-01f, -1.91101417e-01f, 2.15524152e-01f,
  2.53345996e-01f, 3.75745118e-01f, -9.75325555e-02f, -3.28289159e-02f, -1.97896346e-01f, -2.38065287e-01f, 3.34747493e-01f, -2.55206734e-01f, -1.08730875e-01f, 3.31882611e-02f,
  -5.82014918e-02f, -4.26191427e-02f, 2.46034384e-01f, -3.15446049e-01f, -4.56924886e-01f, -2.87813842e-01f, 2.13444699e-02f, 3.66616040e-01f, -2.91587830e-01f, -3.51705670e-01f,
  -2.17163414e-01f, 2.02655822e-01f, 2.18770429e-01f, -2.90646255e-01f, 1.73926041e-01f, 1.78933814e-02f, 5.39079383e-02f, 2.09819689e-01f, -3.15285712e-01f, -2.05027476e-01f,
  1.78829774e-01f, -2.19487250e-01f, -1.95232719e-01f, -3.01773787e-01f, 1.11671932e-01f, 2.77386636e-01f, -2.45157942e-01f, -1.17924921e-01f, -3.28105688e-02f, -3.24286431e-01f,
  -1.36997595e-01f, 9.90186632e-03f, -1.07280910e-01f, -1.32009550e-03f, 4.00460251e-02f, -6.10882267e-02f, -2.81045407e-01f, 3.48363936e-01f, 9.35604572e-02f, 2.73143411e-01f,
  -5.55547550e-02f, 1.74010590e-01f, 2.20578775e-01f, 3.19733024e-01f, 9.69146863e-02f, -1.72038525e-01f, 1.22933306e-01f, 6.19032159e-02f, -2.23549098e-01f, 3.32549155e-01f,
  -5.04315160e-02f, -5.31144440e-01f, -3.07021230e-01f, -2.27636889e-01f, 7.23469630e-02f, 1.91170976e-01f, 3.08274239e-01f, 1.64754584e-01f, -2.21085280e-01f, 1.69493884e-01f,
  2.70393699e-01f, 2.06181943e-01f, -2.43753940e-01f, -5.45265414e-02f, 2.23323137e-01f, 9.31060463e-02f, -6.06407709e-02f, 9.26077142e-02f, 3.39166135e-01f, -3.81489456e-01f,
  1.68649822e-01f, 2.66359389e-01f, -1.88925698e-01f, 3.33600968e-01f, -1.12295359e-01f, 1.63562104e-01f, 2.93776840e-01f, -2.24518344e-01f, -9.52556431e-02f, -1.44353718e-01f,
  5.01092114e-02f, -9.31879580e-02f, -5.79435453e-02f, -4.12410349e-01f, -3.43932509e-01f, 2.51405716e-01f, 8.41157138e-02f, -2.02922285e-01f, 1.69860765e-01f, -2.00837106e-01f,
  -1.82330221e-01f, 1.44926757e-01f, 4.86970812e-01f, -1.20278727e-02f, 1.61126584e-01f, -7.25433826e-02f, 1.12003967e-01f, 1.63944498e-01f, 1.45821184e-01f, -1.00495026e-01f,
  4.51678455e-01f, -4.32467043e-01f, -2.86813192e-02f, 3.78220350e-01f, 1.99128211e-01f, 9.33959261e-02f, -1.43729776e-01f, 1.44991919e-01f, 1.15682416e-01f, -1.38905481e-01f,
  5.90820909e-02f, -1.02777034e-01f, -2.53733337e-01f, 9.55607072e-02f, 2.99061865e-01f, -3.51309687e-01f, -1.70847952e-01f, 1.17374502e-01f, -9.07721445e-02f, -5.02677560e-01f,
  2.42505476e-01f, -7.54036233e-02f, 1.49241844e-02f, -6.19222447e-02f, -3.15514356e-01f, -5.15159965e-01f, -2.41983280e-01f, -1.20278679e-01f, -4.61105019e-01f, -6.23501465e-02f,
  -2.78716236e-01f, -1.91474214e-01f, 1.25805378e-01f, 3.56153488e-01f, -3.96591932e-01f, 5.01609892e-02f, 1.59387171e-01f, 3.74734476e-02f, -3.19473028e-01f, -3.27504396e-01f,
  -1.62914023e-01f, -3.99364531e-02f, 8.15547630e-02f, -1.53416276e-01f, 1.75548941e-01f, -6.89488053e-02f, 6.49767891e-02f, 5.25803328e-01f, 6.45408686e-03f, 9.40436125e-02f,
  1.53853456e-02f, 4.55895156e-01f, -4.91637856e-01f, -2.46462133e-02f, -1.35762706e-01f, 2.75359005e-02f, 8.88127759e-02f, -9.76855159e-02f, -6.19354844e-02f, 4.78837669e-01f,
  -2.62762159e-01f, 5.15120365e-02f, 1.05232492e-01f, 2.52738316e-02f, 2.76869237e-02f, 1.41498461e-01f, -1.74228027e-01f, 4.32478040e-02f, 2.55447656e-01f, -1.08007630e-02f,
  3.76029387e-02f, -9.08069611e-02f, -2.36454308e-02f, 8.78171846e-02f, -1.40873939e-01f, 2.87450671e-01f, 1.05025567e-01f, -6.85927123e-02f, 1.73724927e-02f, -1.88955784e-01f,
  -1.33993015e-01f, -1.17670894e-01f, 1.68575734e-01f, 1.20477848e-01f, 5.48501730e-01f, -2.72063583e-01f, 5.98469935e-03f, -1.72771886e-02f, -2.57820278e-01f, -1.25523945e-02f,
  3.20420921e-01f, 1.40849754e-01f, 2.15690359e-01f, 1.20557345e-01f, -1.01000533e-01f, 2.30043828e-02f, 4.83147055e-01f, -4.04850662e-01f, 1.10105418e-01f, -1.93423375e-01f,
  -4.52686325e-02f, -1.55363649e-01f, -5.19389570e-01f, 1.54988706e-01f, 3.15652490e-01f, 9.40406471e-02f, 1.94748715e-01f, -2.63900578e-01f, -1.25142857e-01f, -2.62730569e-02f,
  1.47526264e-01f, -2.49763466e-02f, 4.58527803e-02f, -4.63286648e-03f, -3.29074234e-01f, -1.45327404e-01f, -3.36260617e-01f, 1.44692674e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  4.29367334e-01f, 3.69714707e-01f, -2.79787630e-01f, 2.22490598e-02f, -3.98404211e-01f, 1.01679236e-01f, -4.13139015e-01f, 2.35790461e-01f, -1.73750252e-01f, -3.44859511e-01f,
  -2.94305295e-01f, -1.52281463e-01f, -1.56083286e-01f, 1.15530051e-01f, -2.43491143e-01f, 4.67473231e-02f, 2.27650884e-03f, -1.89443827e-01f, -3.59808415e-01f, 4.43515517e-02f,
  -3.63926440e-02f, 5.40129721e-01f, 1.49690181e-01f, 3.82828176e-01f, -3.82502973e-02f, 6.55473113e-01f, 6.62110448e-02f, 1.17189862e-01f, -3.64005536e-01f, 3.87696356e-01f,
  9.12351757e-02f, 2.15164095e-01f, -1.51738608e-02f, 3.55352134e-01f, 1.05733164e-01f, 8.32667500e-02f, 1.92081422e-01f, 2.10451260e-02f, 4.94596809e-01f, 3.39979023e-01f,
  1.58770382e-01f, 5.51148057e-01f, 6.09918475e-01f, 1.51443645e-01f, 5.99259794e-01f, 8.65796566e-01f, -5.13728619e-01f, -1.37860253e-01f, 6.19359838e-04f, 2.98325926e-01f,
  7.85924315e-01f, 2.81838208e-01f, 3.44807535e-01f, -4.41425323e-01f, 2.53571928e-01f, -2.90979713e-01f, -7.66029596e-01f, -1.31503284e-01f, 2.09863231e-01f, -9.09896493e-01f,
  2.98066229e-01f, -1.43687092e-02f, -1.25376299e-01f, 2.36741081e-01f, 4.38710712e-02f, 6.10341370e-01f, 4.07097310e-01f, 1.16073512e-01f, 4.56218570e-02f, -1.60177439e-01f,
  3.02802205e-01f, -6.69685937e-03f, -1.15510896e-01f, 5.43247461e-02f, -4.03504461e-01f, 3.94968092e-01f, -3.26150022e-02f, 3.67477864e-01f, -4.99474078e-01f, 5.57436168e-01f,
  7.36663759e-01f, 5.37250280e-01f, 1.51690274e-01f, -3.34616512e-01f, 4.48830158e-01f, 2.47217447e-01f, 6.91219280e-03f, 3.59584540e-02f, 4.18137431e-01f, 6.93452656e-02f,
  -7.73566544e-01f, 1.27757967e-01f, 1.27856776e-01f, 3.17332178e-01f, 4.30928946e-01f, 4.41613078e-01f, 1.53909907e-01f, -2.66914904e-01f, 1.33399501e-01f, -2.04023700e-02f,
  3.30026984e-01f, 3.71736616e-01f, 2.78506309e-01f, -1.36834696e-01f, 2.68509746e-01f, 6.74240291e-01f, 5.28163731e-01f, -6.54482245e-01f, -9.44843516e-02f, -4.14349794e-01f,
  2.70607978e-01f, -1.13043392e+00f, -7.96204567e-01f, -3.05545419e-01f, 3.66913766e-01f, 2.72789508e-01f, -1.48610428e-01f, -2.66456217e-01f, -3.84883970e-01f, -1.14732288e-01f,
  2.83780992e-01f, -1.39516965e-01f, 4.73437995e-01f, 3.44905257e-01f, -4.18305874e-01f, -3.94206822e-01f, -3.67795616e-01f, -6.85042813e-02f, 1.12679146e-01f, 9.15436968e-02f,
  2.20598146e-01f, 7.45927244e-02f, -7.41515458e-02f, 2.29999870e-01f, -1.00083180e-01f, -2.16186151e-01f, -4.57788974e-01f, 2.02187940e-01f, 1.66776344e-01f, 1.63110301e-01f,
  9.26941109e-04f, 3.55160326e-01f, -1.47289768e-01f, -3.19963358e-02f, 3.20533156e-01f, 1.73470125e-01f, 2.13267833e-01f, -1.74234379e-02f, -1.21715464e-01f, 1.82145417e-01f,
  8.35523158e-02f, -6.93760872e-01f, 4.42375392e-01f, -1.15956092e+00f, -1.09879330e-01f, -1.77103981e-01f, 3.84133130e-01f, 2.16760978e-01f, 9.28918839e-01f, -3.96036416e-01f,
  3.64330143e-01f, 5.31904876e-01f, -6.64114952e-01f, -2.00192600e-01f, -2.14405775e-01f, 2.96253651e-01f, 4.34441090e-01f, -3.21213335e-01f, -1.10851936e-01f, -1.34262159e-01f,
  1.36208013e-01f, -1.58998072e-01f, -2.63296068e-01f, -1.48995444e-01f, 1.82481930e-01f, 3.96057993e-01f, -2.41416842e-01f, -4.98620689e-01f, -2.92351574e-01f, 1.37064561e-01f,
  -3.63722891e-01f, 1.22474954e-01f, -5.61794341e-01f, -2.63719916e-01f, -1.29705921e-01f, 4.32242543e-01f, 3.00398082e-01f, 3.18456411e-01f, -7.09823012e-01f, -6.17080256e-02f,
  -7.75743246e-01f, 5.37122451e-02f, -1.97328895e-01f, 2.16686606e-01f, 3.49362940e-01f, -4.42395359e-01f, -4.14418429e-01f, 1.33487746e-01f, 1.63871601e-01f, -9.22543108e-02f,
  -3.06920297e-02f, 1.83740526e-01f, -2.15596437e-01f, -8.67081881e-02f, -8.48031819e-01f, -5.58341622e-01f, 6.83486521e-01f, 4.05853182e-01f, 2.47258335e-01f, -1.47642508e-01f,
  -3.84660922e-02f, 1.17694698e-01f, -1.07647724e-01f, 2.73961812e-01f, 2.03783423e-01f, 2.80401558e-01f, 1.06593110e-01f, -2.51628548e-01f, -3.69669020e-01f, 1.53520674e-01f,
  4.15922608e-03f, -3.91074866e-01f, 7.60008931e-01f, -3.01659524e-01f, -3.17102998e-01f, 5.62258661e-01f, 1.04828507e-01f, 2.10992903e-01f, 2.36761048e-01f, 1.30350381e-01f,
  3.97202879e-01f, 5.55010617e-01f, 6.59368336e-01f, -4.93549496e-01f, 7.01763690e-01f, -5.15799046e-01f, -3.24805886e-01f, -1.07835475e-02f, 7.15761185e-01f, 3.95739257e-01f,
  -5.38727224e-01f, -5.12307107e-01f, 2.39909500e-01f, -1.72381643e-02f, -6.54653668e-01f, 8.61609355e-02f, 1.61981359e-01f, 4.25587863e-01f, 8.73443112e-02f, -1.70420766e-01f,
  -8.16150367e-01f, 4.94153023e-01f, -1.99249193e-01f, -3.82214844e-01f, 6.87926412e-02f, -1.41070500e-01f, 1.21318743e-01f, 2.30315909e-01f, -5.62810957e-01f, -3.60653758e-01f,
  -3.61305743e-01f, -1.31638765e-01f, 2.93233156e-01f, -3.05217654e-01f, -5.86506836e-02f, -5.81706455e-03f, -1.68673083e-01f, -1.84977040e-01f, -4.02570635e-01f, 1.22270629e-01f,
  1.09699331e-01f, 1.12362720e-01f, -3.35195750e-01f, -4.86326128e-01f, -3.32254738e-01f, 4.05745566e-01f, 3.65039498e-01f, 2.45172232e-01f, -8.98726843e-03f, 3.54092598e-01f,
  -4.25336733e-02f, 5.93064129e-01f, 3.91677141e-01f, 2.91534126e-01f, -3.37100953e-01f, -7.72250712e-01f, -7.92196512e-01f, 5.43487012e-01f, -2.51803827e-02f, -3.66703749e-01f,
  5.32293737e-01f, 2.07528174e-01f, 1.40475377e-01f, -2.04118520e-01f, 2.67232299e-01f, 2.37079233e-01f, -1.26615828e-02f, -1.36312455e-01f, 1.89051837e-01f, 1.41602620e-01f,
  -2.66214252e-01f, -1.02687187e-01f, -3.45757157e-01f, 6.07764661e-01f, 2.03372136e-01f, 2.03264624e-01f, 4.54137653e-01f, 2.84575582e-01f, 2.71488219e-01f, 3.89989257e-01f,
  1.85757533e-01f, 3.71189952e-01f, 6.69857144e-01f, -1.94186807e-01f, 1.33115545e-01f, 5.33684731e-01f, 1.04985252e-01f, -6.72890604e-01f, 3.72391850e-01f, -3.23333770e-01f,
  3.15406471e-01f, 3.59742880e-01f, 7.70455718e-01f, 9.72563624e-01f, 6.79073513e-01f, 3.62154096e-02f, 6.38841748e-01f, 5.48705399e-01f, 9.29316640e-01f, -4.81252193e-01f,
  -2.16058955e-01f, -1.04950643e+00f, 2.21785661e-02f, -3.84318382e-01f, 2.68069189e-03f, -1.24904178e-02f, 1.72031388e-01f, 7.59691894e-01f, 2.67415583e-01f, 2.09958494e-01f,
  4.67895493e-02f, -3.60691436e-02f, -3.38097185e-01f, 3.43208909e-01f, -4.75557595e-01f, -2.37750620e-01f, -8.86415988e-02f, 3.17736953e-01f, -1.95237979e-01f, -3.64127047e-02f,
  -1.24393463e-01f, 3.43328357e-01f, 3.59752238e-01f, 2.54489541e-01f, -1.45478696e-02f, 3.19753587e-02f, 1.46276951e-01f, 4.90969345e-02f, 2.51034409e-01f, 2.43355945e-01f,
  1.35560393e-01f, 1.67600796e-01f, -3.92556459e-01f, 4.19661552e-01f, -1.25749623e-02f, -2.01790649e-02f, 3.70886810e-02f, 4.38995928e-01f, 5.43373704e-01f, 4.44872111e-01f,
  -4.24344502e-02f, 1.72169209e-01f, 3.85003716e-01f, -3.70623350e-01f, 2.61172563e-01f, 1.12226158e-01f, 7.79527277e-02f, 2.86878645e-01f, -4.82708454e-01f, -2.42662370e-01f,
  1.90647244e-01f, 8.42503846e-01f, 1.23220749e-01f, 6.66236639e-01f, 1.80141464e-01f, 5.92564605e-02f, 1.55575484e-01f, 1.51053488e-01f, 3.71802598e-01f, 3.56809676e-01f,
  3.21576893e-01f, 2.21872076e-01f, 2.12796211e-01f, 4.50565875e-01f, 7.92046487e-01f, -1.26205310e-01f, 2.92831630e-01f, -1.51439309e-01f, 4.51635867e-01f, -5.89093029e-01f,
  -3.66617858e-01f, 1.65505752e-01f, 2.44229347e-01f, 4.04163927e-01f, -6.92068487e-02f, -3.29448164e-01f, -2.99220234e-01f, -2.66409725e-01f, 6.87390447e-01f, -6.17578447e-01f,
  2.88623422e-01f, 1.24294478e-02f, 2.75492251e-01f, 8.65350723e-01f, 1.31243214e-01f, -2.61601001e-01f, 2.26370916e-01f, -1.63578928e-01f, 2.47432992e-01f, 2.21551150e-01f,
  -1.57860667e-01f, 4.14494216e-01f, -1.59469813e-01f, 1.37565389e-01f, 2.58397371e-01f, -6.01811945e-01f, -2.41085917e-01f, 1.01888910e-01f, -4.19116586e-01f, -7.42463589e-01f,
  5.93719900e-01f, 1.54288217e-01f, -1.39954969e-01f, 8.21822211e-02f, -4.55158297e-04f, 3.16835403e-01f, -1.99334815e-01f, 5.31819224e-01f, 3.56995255e-01f, 7.52127826e-01f,
  6.19766891e-01f, 1.76605806e-01f, -1.30367935e-01f, 6.33080900e-01f, 1.65170029e-01f, 1.81965500e-01f, 3.98324132e-01f, 1.52538987e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -2.72472017e-02f, 2.32890204e-01f, 2.49185443e-01f, 2.22924605e-01f, 2.66323864e-01f, 1.65595502e-01f, 8.13275427e-02f, 1.35867506e-01f, 2.58809999e-02f, 3.39167833e-01f,
  3.30017507e-01f, 1.86091661e-01f, 2.57140636e-01f, 1.06725752e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -5.56966782e-01f, -3.80772382e-01f, 1.27498940e-01f, 4.73456949e-01f, -1.33141726e-01f, -3.44444305e-01f, 4.22015697e-01f, -1.20349161e-01f, -2.11794183e-01f, -7.31155500e-02f,
  -1.78753771e-02f, -1.07910931e-01f, -4.34143424e-01f, -2.38994181e-01f, 2.41982490e-01f, 2.64357124e-02f, 4.78495926e-01f, -3.71261686e-01f, 4.65245396e-01f, -5.98797023e-01f,
  -9.59604904e-02f, -8.15886855e-01f, -4.46905404e-01f, -3.54775846e-01f, 4.74309951e-01f, 5.16965210e-01f, -2.54909080e-02f, 1.27963752e-01f, -5.97230136e-01f, -2.41243497e-01f,
  -4.81309414e-01f, 2.89040446e-01f, -9.15546417e-02f, 4.02363092e-01f, -3.58393669e-01f, 3.55000585e-01f, 3.34112912e-01f, 4.91219461e-02f, -1.73297271e-01f, -5.24415016e-01f,
  -2.79901177e-01f, -1.97589621e-01f, -1.70425311e-01f, 5.39427064e-02f, 5.01180768e-01f, 5.32390594e-01f, 1.66179970e-01f, -1.24075741e-01f, 4.63158973e-02f, -6.22850180e-01f,
  -2.27608144e-01f, -8.80998001e-02f, 1.36664137e-01f, -7.08270252e-01f, 4.57938641e-01f, -7.99917951e-02f, 6.80754244e-01f, 7.91288838e-02f, -3.55724096e-01f, 1.76503628e-01f,
  -4.22115147e-01f, -7.88238049e-02f, -7.43301362e-02f, 1.18550219e-01f, 3.17455918e-01f, 9.98390466e-02f, 6.09422624e-01f, -1.48566052e-01f, -4.95629869e-02f, 2.84918994e-01f,
  -4.45073217e-01f, 2.84048021e-01f, -3.14923167e-01f, -8.66539299e-01f, 6.19224191e-01f, 5.64648986e-01f, 2.33119935e-01f, -4.28294569e-01f, -5.41199446e-01f, -2.29184106e-01f,
  5.84711194e-01f, -6.37879670e-01f, -3.11128367e-02f, -8.29892814e-01f, 2.01752037e-01f, -5.66819370e-01f, -2.22834095e-01f, -4.16470766e-01f, 5.45712933e-02f, -7.29819119e-01f,
  -1.72421619e-01f, 9.95870605e-02f, 5.98310888e-01f, 1.92506060e-01f, -7.42633343e-01f, 3.32296044e-01f, -6.91268966e-03f, -1.11629330e-01f, 5.33210747e-02f, 4.41986434e-02f,
  -6.07153952e-01f, -5.89448333e-01f, -2.72939026e-01f, -4.73621130e-01f, 2.24583626e-01f, -4.56909359e-01f, 9.37497169e-02f, -5.12054823e-02f, 2.46984079e-01f, 2.73035258e-01f,
  -4.25064772e-01f, -3.91063839e-01f, -3.37709010e-01f, 6.76509514e-02f, 4.58401650e-01f, -7.04775333e-01f, -2.70543098e-01f, -2.20077261e-02f, -7.05236971e-01f, 4.84807223e-01f,
  -7.15995848e-01f, -7.69211054e-01f, 4.82751548e-01f, 3.65799032e-02f, -5.00832319e-01f, -3.50150585e-01f, -4.38355058e-01f, 5.59630841e-02f, 5.26815891e-01f, -4.82666075e-01f,
  -3.14592212e-01f, -7.48337209e-01f, 3.78251165e-01f, 4.97398257e-01f, 2.66531110e-01f, 1.19759649e-01f, 5.18528044e-01f, -1.19879074e-01f, 6.42344534e-01f, -2.95375705e-01f,
  -3.00562859e-01f, -5.27838826e-01f, 4.48533803e-01f, 7.38710761e-01f, -3.69914025e-01f, 3.52637023e-01f, -5.58684207e-02f, 1.19239027e-02f, -5.83247244e-01f, 1.45004340e-03f,
  4.16984744e-02f, 3.43809843e-01f, 2.15072483e-01f, 5.38823187e-01f, 2.52110511e-01f, -6.84010983e-02f, -2.47354396e-02f, -9.02336687e-02f, -3.22813928e-01f, 8.27584565e-02f,
  3.00430059e-01f, 3.60753208e-01f, -2.72308290e-01f, -1.36199370e-01f, -7.41902813e-02f, -2.94146448e-01f, 2.76905715e-01f, 4.45358336e-01f, 2.05915391e-01f, 2.88746476e-01f,
  3.95141661e-01f, -4.33034956e-01f, -4.71529037e-01f, 1.42092794e-01f, 2.12595090e-01f, -5.21530688e-01f, 4.39841568e-01f, 5.70225537e-01f, -3.73645931e-01f, -2.12091208e-01f,
  -3.23538780e-01f, -1.51976973e-01f, -1.81729104e-02f, -1.77017853e-01f, -5.17294705e-01f, 7.16553926e-01f, -4.86433715e-01f, 3.83075148e-01f, 2.44604200e-01f, -3.60116899e-01f,
  1.80362821e-01f, 1.91946402e-01f, 5.27323633e-02f, 1.15473859e-03f, -3.92935388e-02f, -4.76570338e-01f, 3.04895341e-01f, -2.07196340e-01f, 2.12707296e-01f, -3.88606608e-01f,
  -2.64075454e-02f, -1.75000042e-01f, 1.91771716e-01f, 1.24828052e-02f, -3.18883657e-01f, 4.95790005e-01f, -3.82032007e-01f, 2.29612943e-02f, 3.11131597e-01f, -3.51306617e-01f,
  -1.45316139e-01f, 1.91679388e-01f, 3.93851608e-01f, 6.02533743e-02f, 4.79227871e-01f, -2.99693178e-02f, -1.36526853e-01f, 1.13382610e-02f, -9.28272605e-02f, -8.35708201e-01f,
  -9.66561019e-01f, 3.49691987e-01f, 1.83654070e-01f, -5.83760202e-01f, -4.73913401e-02f, -6.91753626e-02f, -3.77069652e-01f, -1.26136556e-01f, 2.67853551e-02f, -3.80522430e-01f,
  2.23805364e-02f, -3.11681032e-01f, -3.07098180e-01f, 2.78254986e-01f, -3.30922306e-01f, 3.69737387e-01f, -5.04029334e-01f, -1.35592045e-03f, -4.21657681e-01f, 4.02397156e-01f,
  -1.46093100e-01f, 1.57655105e-01f, -4.20439616e-02f, 3.16451639e-01f, -9.89341661e-02f, -1.63413025e-02f, -3.29665422e-01f, -5.25599539e-01f, 2.20100209e-02f, -1.37546688e-01f,
  6.32384539e-01f, 1.34776682e-01f, -6.12492740e-01f, 1.22726656e-01f, -3.12340826e-01f, -2.72028536e-01f, -1.92700669e-01f, -1.91398427e-01f, 3.61652255e-01f, 4.57903504e-01f,
  1.59800857e-01f, 1.09457061e-01f, -3.36257428e-01f, 1.82494029e-01f, -2.59020627e-01f, 6.11163557e-01f, -4.29959625e-01f, 6.22297525e-01f, -3.31343710e-01f, 2.98167735e-01f,
  6.13929033e-01f, -1.34264156e-01f, 5.03170133e-01f, -5.34157567e-02f, -2.49090165e-01f, 3.53027254e-01f, -8.53591681e-01f, 5.22064269e-01f, 1.24443933e-01f, -3.93546402e-01f,
  -2.92926468e-02f, -6.34560049e-01f, -4.10361111e-01f, -1.91379547e-01f, 2.19718143e-01f, -6.77093506e-01f, 4.95041400e-01f, -6.27367079e-01f, -4.34776306e-01f, 5.80900311e-02f,
  7.12489486e-02f, -2.57894635e-01f, -3.06767464e-01f, -4.63945329e-01f, 6.79914773e-01f, 4.17519599e-01f, 5.84125876e-01f, 7.76725292e-01f, -3.54254134e-02f, -4.91151303e-01f,
  5.29057741e-01f, -4.14269626e-01f, -5.18315315e-01f, 4.96417545e-02f, -5.04945740e-02f, 4.38650608e-01f, -2.85558868e-02f, 1.41126802e-02f, 3.45082767e-02f, -1.26862064e-01f,
  -9.01867330e-01f, -3.77082616e-01f, -5.50013542e-01f, -4.53133255e-01f, -3.86765659e-01f, -4.41673577e-01f, 3.53798270e-01f, 5.25414884e-01f, 2.69014060e-01f, 3.55773903e-02f,
  -4.99629259e-01f, 6.77081104e-03f, -4.02995795e-01f, -1.17631137e-01f, -3.47599596e-01f, 3.59667331e-01f, 2.65464097e-01f, -1.35731563e-01f, -5.19392371e-01f, 2.01554969e-01f,
  -5.76012790e-01f, 1.60585582e-01f, 1.68935701e-01f, -5.35037994e-01f, 3.19678783e-01f, 7.35262260e-02f, -4.94865686e-01f, 3.42796832e-01f, -4.94136125e-01f, -9.17693317e-01f,
  -2.97111124e-01f, 8.02915812e-01f, -3.97316426e-01f, -2.03772597e-02f, -2.32038006e-01f, -8.65311325e-01f, 1.28262326e-01f, 1.03367433e-01f, -2.05102831e-01f, -4.52575296e-01f,
  5.68424940e-01f, 2.43151020e-02f, 4.30778265e-01f, -4.72886950e-01f, 2.89568782e-01f, 1.63832292e-01f, -5.94668202e-02f, 6.26261711e-01f, -4.21730101e-01f, 2.77354956e-01f,
  6.15195632e-01f, -9.43587184e-01f, -7.23689914e-01f, 6.77448988e-01f, 8.29089999e-01f, 4.35557902e-01f, 6.17359638e-01f, -4.21737313e-01f, -4.75645781e-01f, 2.46133506e-01f,
  -4.86888975e-01f, 2.59692252e-01f, 4.50642824e-01f, -8.63775790e-01f, 5.56141101e-02f, -4.13463652e-01f, -3.67541730e-01f, -4.58747894e-01f, -1.75830215e-01f, 1.93625525e-01f,
  4.81016308e-01f, 1.70416385e-02f, -3.09779227e-01f, -1.04410779e+00f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.00843716e-01f, -7.76020810e-02f, 1.22855134e-01f, -7.38999546e-02f, -1.48436770e-01f, 1.39123037e-01f, -1.29577413e-01f, -1.33621454e-01f, 1.20009027e-01f, 2.28106156e-01f,
  -5.38535230e-02f, 1.35053009e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    