/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.51164865e-01f, -1.95294976e-01f, 1.44101650e-01f, -3.13558787e-01f, 8.18998143e-02f, -1.75341517e-01f, -9.02757421e-02f, -2.40123365e-02f, 4.62920777e-02f, 3.08492053e-02f,
  4.44360375e-02f, -4.42298129e-03f, 1.60545409e-01f, -1.63030326e-01f, 6.34658113e-02f, 1.34142237e-02f, -8.27175565e-03f, -4.96717095e-02f, -1.12862699e-01f, -1.69994459e-02f,
  -1.03227487e-02f, -1.05626665e-01f, 1.79495923e-02f, -4.47012205e-03f, -1.59844428e-01f, -1.35493847e-02f, 8.33937228e-02f, -4.17387374e-02f, -9.47797205e-03f, -2.39738310e-03f,
  -4.46594693e-02f, 3.40982452e-02f, -9.10686888e-03f, 4.34651263e-02f, 6.33126944e-02f, 2.46098954e-02f, 8.62447638e-03f, 2.63934163e-03f, -5.48624946e-03f, -2.25661676e-02f,
  -7.24326074e-02f, 2.99061649e-02f, 1.43970419e-02f, 2.74301022e-02f, -1.06861526e-02f, 1.81475412e-02f, -9.90849175e-03f, -1.41454944e-02f, -1.95997451e-02f, 4.24330570e-02f,
  1.68440975e-02f, -3.63935009e-02f, -4.54966277e-02f, -4.66410220e-02f, 9.98267811e-03f, -6.05304353e-03f, -1.70560628e-02f, 1.21091893e-02f, 3.89996991e-02f, -9.13350005e-03f,
  3.08770742e-02f, -2.08693407e-02f, 2.53714211e-02f, 3.15819718e-02f, -1.60913095e-02f, 2.33853795e-03f, 4.30024453e-02f, 2.37579718e-02f, -4.46252637e-02f, 1.36148827e-02f,
  -4.57509905e-02f, 3.63530144e-02f, 1.26167694e-02f, -2.49513909e-02f, -5.40041775e-02f, 2.69396720e-03f, 2.13800929e-02f, -1.10179149e-02f, -2.27505546e-02f, -6.51904056e-03f,
  -1.17218925e-03f, -9.73885413e-03f, -1.43070947e-02f, 1.52783878e-02f, 2.31188703e-02f, -1.27953002e-02f, -4.49435525e-02f, 3.02064382e-02f, -4.62441929e-02f, 1.85129382e-02f,
  -1.10071860e-01f, 3.01162545e-02f, -2.75493339e-02f, 1.93429645e-02f, -6.53563961e-02f, -1.61754005e-02f, -1.36265447e-02f, -4.87464890e-02f, -1.97221488e-02f, 9.52330977e-03f,
  5.12020029e-02f, 4.30706926e-02f, -1.06720310e-02f, -3.30825001e-02f, -4.48358916e-02f, -2.29289709e-03f, -3.23378146e-02f, 9.45365801e-03f, -9.92712379e-03f, -4.94179176e-03f,
  1.57410395e-03f, 6.78057000e-02f, -4.45232131e-02f, 8.89872760e-03f, -7.50130741e-03f, -2.77886856e-02f, -4.52226624e-02f, -3.42493318e-02f, 4.17319052e-02f, 3.36544663e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.09733820e-01f, -8.97393897e-02f, -1.28574789e-01f, -1.55925781e-01f, -4.23678160e-02f, -3.09480280e-01f, -3.46256524e-01f, -1.48326069e-01f, 5.63257141e-03f, -1.77397087e-01f,
  -1.05290294e-01f, 5.60260974e-02f, 2.06363015e-02f, -1.93647310e-01f, 1.71847388e-01f, 1.37121856e-01f, -2.03859463e-01f, -8.82252753e-02f, 5.28029464e-02f, -1.00656681e-01f,
  9.81379077e-02f, -1.33865312e-01f, 9.55670234e-03f, -3.85433584e-02f, -2.07808360e-01f, 3.73716019e-02f, 8.73203129e-02f, -5.28020002e-02f, -6.15939833e-02f, -1.17545411e-01f,
  -2.46324074e-02f, 7.80506209e-02f, -4.27930057e-02f, 2.63104606e-02f, 1.18794277e-01f, 5.38076945e-02f, -4.56261775e-03f, 1.19871292e-02f, 2.19350625e-02f, -3.24292742e-02f,
  -3.27226631e-02f, 2.83586811e-02f, 5.27473725e-02f, 7.84731582e-02f, 1.45375440e-02f, -3.68361138e-02f, -1.02435902e-01f, -8.40184987e-02f, -6.86303899e-02f, 4.40725721e-02f,
  -1.14331305e-01f, -1.64195504e-02f, -1.15097709e-01f, 3.45526822e-02f, 5.67404814e-02f, -3.92316990e-02f, -6.04648218e-02f, 1.11059602e-02f, 2.05695834e-02f, 3.18013951e-02f,
  4.47311737e-02f, 9.03961435e-02f, -7.22917318e-02f, 6.03615828e-02f, 4.22915891e-02f, -1.44331781e-02f, -1.08416311e-01f, 4.39153053e-02f, 5.55217378e-02f, 5.28300107e-02f,
  8.34744424e-02f, -5.93225770e-02f, 5.35674244e-02f, -3.29563282e-02f, 6.52447790e-02f, -2.74210442e-02f, 4.93112467e-02f, 2.10247631e-03f, -9.00631770e-02f, 4.88293879e-02f,
  3.79820354e-02f, -5.22471219e-02f, -8.03267001e-04f, -2.14774124e-02f, 3.78107503e-02f, -5.39769195e-02f, 1.99399535e-02f, -1.17434107e-01f, -7.66187385e-02f, -6.09952845e-02f,
  -5.70534207e-02f, -4.87343371e-02f, 2.54207682e-02f, 4.97516133e-02f, 9.73818358e-03f, 3.41983400e-02f, -4.37705703e-02f, 2.59613786e-02f, -4.13107499e-03f, -2.41682138e-02f,
  3.68643366e-02f, -4.43312749e-02f, 5.50637692e-02f, -4.96013239e-02f, 3.27106304e-02f, -4.53595258e-02f, -9.10340995e-03f, 1.09400868e-03f, 5.56300534e-03f, 3.00210342e-02f,
  5.65972254e-02f, 2.23882273e-02f, 6.77596778e-02f, -2.91973576e-02f, -4.06624414e-02f, -7.01631755e-02f, 4.77589481e-02f, 1.79078300e-02f, 3.07752136e-02f, 9.63835884e-03f,
  -8.45371038e-02f, -3.40672910e-01f, -2.80792236e-01f, -1.97684377e-01f, -9.98466834e-02f, -5.66027403e-01f, -4.46683854e-01f, -4.51513194e-02f, 1.63057134e-01f, 4.09277231e-02f,
  -1.16170086e-02f, 1.93517402e-01f, 1.65769771e-01f, -3.26191455e-01f, -8.19966421e-02f, 6.60083592e-02f, -5.16282737e-01f, -1.91440195e-01f, 2.37474847e-03f, -2.67509073e-01f,
  -1.21434592e-01f, -2.96016634e-01f, -1.99971795e-01f, -1.46242544e-01f, -2.85917401e-01f, 6.81226999e-02f, -2.22002249e-02f, 2.87987404e-02f, -1.73602939e-01f, 7.19213709e-02f,
  -1.62032060e-02f, 2.09726855e-01f, 7.91576952e-02f, 2.16392148e-02f, -7.68618584e-02f, -1.17831834e-01f, -6.18284941e-02f, 5.88532016e-02f, 9.22029987e-02f, -5.83431078e-03f,
  5.92385717e-02f, -1.61607750e-02f, -8.07312876e-03f, -8.57820828e-03f, -4.93689589e-02f, 8.93667042e-02f, 1.01494761e-02f, -4.14258502e-02f, 3.13398279e-02f, -6.13034293e-02f,
  -1.86211560e-02f, -1.53965259e-03f, -1.37068570e-01f, 2.99641229e-02f, 7.38278255e-02f, 3.86960767e-02f, -6.72491267e-02f, 8.56681168e-03f, -7.04884678e-02f, 1.34825967e-02f,
  -6.21204562e-02f, 2.50953641e-02f, -3.46107148e-02f, -4.06407453e-02f, -6.70069456e-02f, 5.12692071e-02f, 2.92041004e-02f, 2.42399741e-02f, -3.59376408e-02f, -6.39731213e-02f,
  3.30756828e-02f, -3.20208631e-02f, -4.22443962e-03f, -1.32735431e-01f, -2.34089009e-02f, 3.27131748e-02f, -3.98280770e-02f, 4.26117750e-03f, -5.48117496e-02f, 3.10321432e-02f,
  2.52761580e-02f, 5.50239719e-02f, -7.92322829e-02f, -1.64786186e-02f, 1.90762952e-02f, 5.26019298e-02f, -1.75944753e-02f, 3.84577438e-02f, 1.52632762e-02f, -3.07752378e-03f,
  -2.27487460e-01f, -1.38501748e-01f, 7.11181387e-02f, -3.84339504e-02f, 4.50984575e-02f, -2.55199801e-02f, 2.14856789e-02f, -1.27143189e-02f, -1.03462920e-01f, -5.78829385e-02f,
  -1.21647485e-01f, 2.44712457e-02f, -7.56631866e-02f, 1.46940395e-01f, 3.94829661e-02f, -6.27593473e-02f, -4.37916741e-02f, 4.84138653e-02f, -8.93672109e-02f, -2.78019207e-03f,
  8.15785117e-03f, 2.45236121e-02f, 1.09643884e-01f, 1.85753051e-02f, -4.82331701e-02f, -5.76725230e-02f, -1.29138917e-01f, 1.76987797e-02f, 3.52245086e-04f, -6.20224699e-02f,
  -1.43631831e-01f, -1.22523554e-01f, -2.74114400e-01f, -1.99951883e-02f, 1.06322438e-01f, 2.17670411e-01f, -5.77474907e-02f, 4.74770106e-02f, -4.18318249e-02f, 6.48499429e-02f,
  6.58598617e-02f, 9.71609503e-02f, -2.93042272e-01f, 3.32459182e-01f, 2.76470959e-01f, 4.84648813e-03f, 2.08480835e-01f, 6.65620118e-02f, -7.55965784e-02f, -3.67071405e-02f,
  4.95620966e-02f, 2.70796895e-01f, 8.16461071e-02f, 4.86638360e-02f, 1.31526783e-01f, -1.23894699e-01f, 4.12314795e-02f, -1.44086555e-01f, 2.74451047e-01f, 1.71152934e-01f,
  2.81625409e-02f, -2.07023650e-01f, -1.02551579e-01f, -3.81139778e-02f, 1.27884550e-02f, -1.29539713e-01f, -1.90405070e-03f, -2.36154366e-02f, -3.32814045e-02f, 5.57869710e-02f,
  -3.18888612e-02f, -1.88206714e-02f, 1.26096651e-01f, -1.62981376e-01f, 9.95414611e-03f, 3.91153283e-02f, 8.87080655e-02f, 2.36610845e-02f, -8.95092264e-03f, 5.97164519e-02f,
  1.68471306e-03f, 6.31634220e-02f, 9.49681923e-02f, 5.12305610e-02f, 5.81838228e-02f, 7.13571161e-02f, -3.38954628e-02f, -3.77319306e-02f, 4.40974347e-02f, 5.39816394e-02f,
  -8.38485733e-02f, -6.53780475e-02f, -5.98484427e-02f, -2.36878172e-02f, -4.73845378e-02f, 6.77725822e-02f, -7.66030699e-02f, -3.46100167e-03f, -1.51471188e-02f, 5.49345687e-02f,
  2.77596861e-02f, -9.52540315e-04f, -8.94067436e-02f, 3.66079225e-03f, 3.97597142e-02f, 2.67724991e-02f, -5.10015991e-03f, 5.48802651e-02f, -5.57442233e-02f, 1.05202965e-01f,
  -5.68514727e-02f, 2.06938908e-02f, 4.71508242e-02f, -1.74421538e-02f, -1.79776475e-02f, 7.40965530e-02f, -5.09230271e-02f, -3.90975038e-03f, 3.81517084e-03f, 1.71481899e-03f,
  -4.59876955e-02f, -2.48504102e-01f, -3.62342759e-03f, 4.10470739e-02f, -3.01167704e-02f, 3.72871682e-02f, -5.07711694e-02f, 4.11046445e-02f, -7.25973817e-03f, -3.76939066e-02f,
  -4.03711833e-02f, -5.43358624e-02f, 6.76320354e-03f, 9.08474699e-02f, -1.44230938e-02f, 6.55868510e-03f, -8.08987860e-03f, 7.31427744e-02f, 1.56062782e-01f, 1.21319536e-02f,
  1.61592551e-02f, -4.84017581e-02f, -8.60671047e-03f, -4.66900133e-02f, 3.01002879e-02f, -2.18054820e-02f, -1.47287041e-01f, 8.31460580e-03f, 1.16413878e-02f, -2.97018215e-02f,
  3.87878753e-02f, 4.55139801e-02f, -1.82926264e-02f, -2.51123626e-02f, -1.60540193e-02f, -2.35450733e-02f, -8.47918987e-02f, 3.44360322e-02f, -4.62530516e-02f, -5.57599589e-02f,
  -7.90719241e-02f, -1.14163876e-01f, -1.27171621e-01f, 5.85131999e-03f, -1.58037692e-01f, -2.10844129e-01f, -5.40647991e-02f, -3.84101644e-02f, 1.24131022e-02f, 1.25832101e-02f,
  -6.49972409e-02f, 1.50932150e-03f, 3.86921167e-02f, 1.46437973e-01f, 1.26748711e-01f, 7.08459243e-02f, -6.25671120e-03f, 1.14938006e-01f, 9.39601064e-02f, 7.50582144e-02f,
  -7.42331962e-04f, 4.21971492e-02f, 8.42832178e-02f, -4.35506552e-02f, -2.27271412e-02f, 5.82270436e-02f, -9.46859047e-02f, -1.35504710e-03f, -4.67517376e-02f, 4.17730175e-02f,
  -5.84526882e-02f, -6.21874444e-02f, 6.30417094e-02f, -1.68674849e-02f, 9.72320586e-02f, -9.98327062e-02f, 3.28654535e-02f, 1.03935674e-01f, -2.52752360e-02f, 3.08693666e-02f,
  -3.70003805e-02f, -4.80539687e-02f, 8.52917433e-02f, 7.11554214e-02f, 5.92471026e-02f, -1.85866375e-02f, -6.30654469e-02f, -1.94735155e-02f, -6.14194572e-02f, 6.46620174e-04f,
  -2.85415854e-02f, -1.15482464e-01f, -5.06993849e-03f, -8.88836607e-02f, -5.79413623e-02f, 8.31127316e-02f, -8.03840086e-02f, -3.61741744e-02f, 9.36235189e-02f, -4.53864858e-02f,
  3.38302068e-02f, 3.39016244e-02f, -5.95204905e-02f, -7.36066923e-02f, 5.52637549e-03f, -1.04834177e-01f, -7.43948296e-02f, -5.61485291e-02f, 6.80154413e-02f, -5.68621717e-02f,
  -5.37366346e-02f, -2.46547256e-02f, -3.84766459e-02f, 7.64349550e-02f, -5.13432771e-02f, 6.31765574e-02f, -4.39915694e-02f, 5.56095727e-02f, -5.47942743e-02f, -8.05744976e-02f,
  1.21689647e-01f, 9.81005803e-02f, 1.19241677e-01f, -2.30509834e-03f, -3.42106596e-02f, -8.44698921e-02f, 1.69278793e-02f, -6.41886517e-02f, 9.94195864e-02f, -1.79276168e-02f,
  -1.83930211e-02f, -1.72512408e-03f, -2.37963237e-02f, 7.59920254e-02f, 7.69349709e-02f, -1.49100544e-02f, -6.72174916e-02f, 4.73746732e-02f, -1.32461137e-03f, 1.04977667e-01f,
  -1.78449806e-02f, 2.56216191e-02f, -8.20665434e-02f, -1.89678501e-02f, 4.44954969e-02f, 5.23877852e-02f, 8.51273835e-02f, 3.51581499e-02f, 4.97020632e-02f, 3.51174325e-02f,
  8.80044520e-01f, 1.89338684e-01f, 3.83864164e-01f, 6.05940163e-01f, 1.70518413e-01f, -2.44170398e-01f, -3.08260936e-02f, 1.29398927e-01f, 3.85738850e-01f, -1.45247653e-01f,
  -1.17812917e-01f, 1.80323198e-01f, -3.19969058e-01f, 9.93138626e-02f, -2.68550217e-01f, -1.75624773e-01f, 4.17319983e-02f, 1.24788107e-02f, 1.32175311e-01f, -6.66992441e-02f,
  1.26447186e-01f, -2.99216390e-01f, 1.16234116e-01f, -1.78128824e-01f, 2.75414884e-01f, 1.04512013e-01f, -1.68364286e-01f, -9.82964337e-02f, 1.24131657e-01f, -7.33306780e-02f,
  1.24834839e-03f, 1.81811824e-01f, 7.80138820e-02f, -4.35043648e-02f, -4.42636274e-02f, 9.05626118e-02f, -8.21868628e-02f, -4.95194755e-02f, 1.45857751e-01f, 2.78930776e-02f,
  -3.89960520e-02f, -1.78648382e-02f, 7.43758976e-02f, -6.50697723e-02f, 5.17083444e-02f, 1.11422032e-01f, 7.97521472e-02f, 1.02078013e-01f, 5.39618023e-02f, 9.97569039e-02f,
  1.30686939e-01f, 1.69822410e-01f, 5.07907607e-02f, -3.78099494e-02f, 3.33792455e-02f, 7.50243366e-02f, -2.47227158e-02f, 6.60286695e-02f, 9.60490331e-02f, -3.99445593e-02f,
  -5.96705228e-02f, -1.38557687e-01f, -3.42703499e-02f, -1.34131350e-02f, 3.99634847e-03f, 1.84578132e-02f, -1.91886090e-02f, 2.56430563e-02f, 3.43708321e-02f, 2.39608120e-02f,
  3.05963513e-02f, -3.10131982e-02f, 1.07790614e-02f, 3.45050097e-02f, 4.33261041e-03f, 3.90948504e-02f, -3.18127200e-02f, -1.10841694e-03f, 3.76251414e-02f, 1.79870687e-02f,
  -7.50792027e-03f, 3.23609747e-02f, -1.15071507e-02f, 3.02248392e-02f, 1.06341373e-02f, 3.97333428e-02f, -8.74538347e-03f, 7.70398378e-02f, -7.33130937e-03f, -6.29371181e-02f,
  -4.59919721e-01f, -5.02994478e-01f, -1.13454787e-02f, -2.09984872e-02f, 2.21541990e-03f, -4.80509549e-03f, 4.95647406e-03f, 7.47861192e-02f, -1.07917987e-01f, -3.13818976e-02f,
  1.93148684e-02f, 5.29115126e-02f, -6.39020577e-02f, 6.10970333e-02f, -5.67847341e-02f, -6.62009642e-02f, -5.98075241e-02f, -6.71221837e-02f, -5.00020608e-02f, -3.48415412e-02f,
  3.08588543e-03f, -1.44131795e-01f, 6.47317804e-03f, 7.05692098e-02f, 6.38177395e-02f, -5.57665266e-02f, -7.61363795e-03f, 5.06946295e-02f, -8.77946094e-02f, -2.13927813e-02f,
  4.55255955e-01f, -6.31933570e-01f, -2.47697935e-01f, 1.85537562e-01f, 4.43040848e-01f, 1.10342398e-01f, 1.50162414e-01f, 3.35017517e-02f, 8.28020647e-02f, -3.23441714e-01f,
  1.31113023e-01f, -1.92498997e-01f, -2.81504661e-01f, 5.08450903e-02f, 5.19939601e-01f, -2.86167920e-01f, 1.49694070e-01f, -8.66470765e-03f, 8.95189401e-03f, 2.05841977e-02f,
  1.34593591e-01f, 2.22734019e-01f, -1.50734624e-02f, -4.38686274e-02f, 8.01358894e-02f, -5.06140254e-02f, 2.64539924e-02f, -1.45212457e-01f, 2.66406331e-02f, 1.21812567e-01f,
  1.96120501e-01f, -1.04422439e-02f, 1.64238781e-01f, -8.15944299e-02f, -1.02289505e-01f, -7.61472881e-02f, -1.05770767e-01f, 7.74900839e-02f, 5.17891981e-02f, 8.67576804e-03f,
  -2.65373494e-02f, 5.97708039e-02f, 6.26921281e-02f, 2.80288863e-03f, 1.02730200e-01f, 8.04021675e-03f, 2.94326283e-02f, -7.40237981e-02f, -9.21957791e-02f, -3.08299493e-02f,
  -7.13103339e-02f, -7.78711215e-02f, -4.83095758e-02f, -7.07398131e-02f, -1.75203998e-02f, 4.36960459e-02f, -6.51698858e-02f, -8.45079869e-02f, -5.47361635e-02f, 6.36268109e-02f,
  -3.85454297e-03f, -3.23530659e-02f, 2.34409440e-02f, 5.83518520e-02f, 1.80095043e-02f, 2.31368430e-02f, 1.49221038e-02f, 4.56841849e-02f, 4.93004732e-02f, -5.47319390e-02f,
  7.34071061e-02f, -5.69701148e-03f, 2.15701256e-02f, 3.02063078e-02f, 3.99271064e-02f, 2.76111010e-02f, 1.96693484e-02f, -1.52841583e-03f, 3.97473127e-02f, -5.47689535e-02f,
  -2.11394392e-02f, -2.37097405e-02f, -2.24776212e-02f, -2.11656466e-02f, 5.05949147e-02f, 4.73782606e-02f, 1.79977976e-02f, -1.15929004e-02f, 5.84243909e-02f, -2.71974932e-02f,
  -3.31218660e-01f, -3.37788403e-01f, 3.07210945e-02f, 4.69551422e-02f, -7.71240219e-02f, -2.77233422e-02f, -3.40881832e-02f, 3.19461823e-02f, -4.04938534e-02f, -8.63155350e-03f,
  -2.01225486e-02f, -7.73522258e-02f, -2.09900457e-02f, 2.18509449e-04f, -6.76613152e-02f, 8.54813010e-02f, -3.76652591e-02f, 1.74340401e-02f, 7.81113952e-02f, -9.10734199e-03f,
  -1.02339029e-01f, -6.97166845e-02f, 5.40089533e-02f, 7.60638993e-03f, -3.52337547e-02f, -3.19130346e-02f, -5.04075252e-02f, 2.86931284e-02f, -1.49676837e-02f, -2.95013003e-02f,
  8.72913525e-02f, 1.23850644e-01f, 1.58394501e-01f, 3.36361170e-01f, -2.24510834e-01f, -6.97591424e-01f, -3.19816679e-01f, 3.54689136e-02f, -3.86727490e-02f, -7.91392773e-02f,
  -9.51584652e-02f, 1.33584589e-01f, -7.15686828e-02f, 1.76705211e-01f, 1.20525509e-01f, 4.68121655e-02f, 1.35242388e-01f, -1.02093004e-01f, 8.18073601e-02f, 1.17921978e-01f,
  1.65334404e-01f, 9.56950188e-02f, 3.97147566e-01f, 7.39987120e-02f, 6.15422986e-02f, 1.76732302e-01f, 4.33518589e-01f, -7.47349784e-02f, 7.12210089e-02f, 4.16449867e-02f,
  -2.08837703e-01f, 7.35333487e-02f, 1.28876388e-01f, -1.41164018e-02f, -3.52855287e-02f, -8.39467049e-02f, -6.69009238e-02f, -1.91505607e-02f, -3.82065438e-02f, -7.50429258e-02f,
  3.31058353e-02f, -1.22783475e-01f, 6.75608590e-02f, 4.37648073e-02f, -7.33561739e-02f, 9.16865021e-02f, 4.60342653e-02f, 4.34940122e-02f, -1.11861213e-03f, -9.82412100e-02f,
  1.17563255e-01f, 1.20028909e-02f, 1.88268162e-02f, -3.75794396e-02f, 1.02696642e-01f, 4.12823446e-02f, -5.29009365e-02f, 1.02518173e-02f, 5.63525036e-02f, 3.80097292e-02f,
  -2.88571212e-02f, -1.08024724e-01f, -6.19289558e-03f, -4.02016975e-02f, -1.46362362e-02f, -5.88756166e-02f, -8.84727389e-02f, 1.47667751e-02f, -7.34035075e-02f, -6.02724329e-02f,
  -1.58078801e-02f, -1.08259479e-02f, -1.10260509e-01f, -5.31716049e-02f, -4.37215418e-02f, -3.48101482e-02f, 2.63753161e-02f, -6.15081973e-02f, 3.89010794e-02f, 4.50222418e-02f,
  8.32033285e-04f, -6.39095083e-02f, 8.35914090e-02f, -4.53527868e-02f, -2.57501788e-02f, -1.30628364e-03f, 6.22655712e-02f, -1.50871277e-03f, -1.06596034e-02f, -1.33736047e-03f,
  9.42777097e-02f, 3.24729443e-01f, -1.30135304e-04f, -5.05885519e-02f, -6.95504062e-03f, -6.78290874e-02f, -9.65663344e-02f, 1.89592503e-02f, 8.45170319e-02f, 1.76065473e-03f,
  -6.08302504e-02f, 7.52213001e-02f, -5.83017692e-02f, 9.72619653e-03f, 5.27293049e-02f, 9.70990285e-02f, -4.86533195e-02f, 1.02972478e-01f, 1.36105642e-01f, 8.19182694e-02f,
  2.93630119e-02f, -1.01642743e-01f, -9.42106266e-03f, 1.09578259e-01f, -9.98734236e-02f, 7.26448279e-03f, 7.35142920e-03f, 2.18939176e-03f, 3.88618037e-02f, -4.80469875e-02f,
  -5.67091942e-01f, 2.83040673e-01f, 2.41586939e-01f, -9.51769017e-03f, 1.99272037e-01f, 1.83482736e-01f, 9.73861516e-02f, 6.38203695e-02f, -1.32348448e-01f, -1.36932656e-01f,
  -1.33000940e-01f, -1.30138397e-01f, -5.20912148e-02f, 1.82808824e-02f, -1.14367507e-01f, -3.69095244e-03f, 7.78243467e-02f, -6.94647506e-02f, -5.26787899e-03f, -1.44522898e-02f,
  4.57550399e-02f, -1.18110299e-01f, 1.47505417e-01f, 8.26949701e-02f, -3.27380784e-02f, -6.38899058e-02f, -9.02542099e-02f, 6.67297281e-03f, 1.08232789e-01f, 9.23425483e-04f,
  -1.20752417e-01f, -1.32681921e-01f, 5.14094941e-02f, 3.51598226e-02f, 6.30158782e-02f, 8.43519643e-02f, 5.31083792e-02f, 3.78413941e-03f, 4.64089774e-02f, -5.14825545e-02f,
  -7.89247379e-02f, 4.14512977e-02f, 7.23235160e-02f, 6.33851513e-02f, 1.94995366e-02f, 3.06691770e-02f, 6.02343194e-02f, 2.01345049e-02f, 3.05990074e-02f, 1.20042264e-01f,
  4.10423353e-02f, 6.31110966e-02f, -4.82788086e-02f, -5.62691018e-02f, 4.21621315e-02f, 2.19816435e-02f, -4.33726721e-02f, 6.53855056e-02f, 6.60224780e-02f, 4.54585329e-02f,
  -4.10566404e-02f, -1.10960260e-01f, 1.02143146e-01f, 5.25475554e-02f, 1.14202984e-01f, 7.07281707e-03f, 3.09890620e-02f, 1.00909382e-01f, -2.81916969e-02f, -2.33511385e-02f,
  -5.03910407e-02f, -3.16067487e-02f, -4.61029969e-02f, -1.08281188e-02f, -1.09580763e-01f, -4.41941433e-02f, 1.66575070e-02f, -6.24994654e-03f, 4.93846536e-02f, -2.55864635e-02f,
  -8.57150927e-03f, -1.54294949e-02f, 2.27028392e-02f, 1.37803135e-02f, 2.84368638e-02f, -3.56667228e-02f, 3.97294905e-04f, 8.21375921e-02f, -3.52722071e-02f, -2.28401851e-02f,
  -1.51509956e-01f, -5.42703718e-02f, 3.10297962e-02f, 4.27674390e-02f, 3.28462608e-02f, 1.49740838e-02f, -6.14623129e-02f, -5.38389049e-02f, 6.25546696e-03f, 4.18506823e-02f,
  5.46838641e-02f, 6.00520335e-03f, 3.98064079e-03f, -9.23822299e-02f, -9.79495645e-02f, -1.67256370e-02f, -1.01946682e-01f, -7.60181919e-02f, 3.59653048e-02f, 7.34764338e-03f,
  7.16029853e-02f, -9.72014479e-03f, -3.30620185e-02f, 7.71875829e-02f, 2.98904311e-02f, -8.11060295e-02f, -9.37747434e-02f, 3.82945687e-02f, 6.62405491e-02f, 1.16483621e-01f,
  2.09215432e-01f, 7.95628130e-02f, 5.54302149e-02f, 1.80625677e-01f, -4.22268063e-02f, -9.68626440e-02f, 7.11388737e-02f, 5.75206392e-02f, 3.54891092e-01f, 8.26325715e-02f,
  -1.23886444e-01f, 1.77901581e-01f, -2.63724513e-02f, 8.60608742e-02f, -5.17523400e-02f, -5.77429831e-02f, 7.26151839e-02f, 1.77128368e-05f, 4.63862605e-02f, 1.04656622e-01f,
  2.42153015e-02f, -6.70382455e-02f, -2.57858615e-02f, -1.20871738e-01f, -8.44817758e-02f, -1.39407292e-02f, -2.05097705e-01f, -2.11501494e-02f, -5.92052676e-02f, -2.41210274e-02f,
  -1.74556859e-02f, 1.13359958e-01f, 4.68793586e-02f, 8.96936357e-02f, 3.77023406e-02f, -1.08867474e-01f, -3.14110480e-02f, -5.59960753e-02f, 8.19363445e-03f, -2.42632590e-02f,
  5.57163358e-02f, -8.71381834e-02f, 1.17524616e-01f, -7.06072226e-02f, 1.75989866e-02f, -6.37859777e-02f, 1.42148271e-01f, 1.62217598e-02f, 8.81279036e-02f, -7.22824857e-02f,
  -1.17386594e-01f, 2.57614050e-02f, -5.03989793e-02f, 2.76507363e-02f, 4.56343293e-02f, 5.43993004e-02f, -6.80909157e-02f, -9.52323526e-02f, -4.49895412e-02f, 8.31230208e-02f,
  -4.04872885e-03f, 1.03405165e-03f, 1.64705906e-02f, 6.30941568e-03f, 1.02475487e-01f, -1.32590067e-02f, -5.72906435e-02f, 6.97950348e-02f, 7.50140026e-02f, -2.29922459e-02f,
  6.71711192e-02f, 7.44519085e-02f, -9.51738134e-02f, -1.18326582e-03f, 2.76162773e-02f, 7.73123801e-02f, 2.20959168e-02f, 7.59119317e-02f, 1.92249995e-02f, -1.50017310e-02f,
  -5.53564727e-02f, 1.02215214e-02f, 7.38030626e-03f, -3.02598514e-02f, -2.79121455e-02f, -8.08108225e-02f, -3.29695158e-02f, -2.36270297e-02f, -2.46559437e-02f, -6.61732778e-02f,
  2.36127213e-01f, 1.06313474e-01f, 6.20165430e-02f, 1.18081190e-01f, 6.84181741e-03f, 1.56686213e-02f, 6.95692003e-02f, -1.42803993e-02f, 5.76101616e-02f, -4.25819643e-02f,
  -4.68612723e-02f, -7.66577125e-02f, 8.47983137e-02f, 7.46173039e-03f, -1.51208425e-02f, 6.66351318e-02f, 2.53300145e-02f, -1.19467033e-02f, 1.62619576e-01f, -1.14389479e-01f,
  -6.78632110e-02f, -1.58070289e-02f, 5.61313331e-02f, -1.27648771e-01f, 2.34876331e-02f, -1.04630063e-03f, 7.10128918e-02f, -9.22566745e-03f, 1.05081528e-01f, 6.01954684e-02f,
  -2.12129969e-02f, -2.82196105e-01f, -4.80983138e-01f, -1.08238496e-02f, 2.35009357e-01f, 8.92574191e-02f, -2.00531572e-01f, -4.44684364e-02f, -2.08466411e-01f, 1.21485638e-02f,
  8.38102624e-02f, -2.33284444e-01f, -3.29966962e-01f, -1.03740348e-02f, -4.20447551e-02f, -4.20603603e-01f, 1.21129587e-01f, -5.28350584e-02f, -1.08801775e-01f, 8.60263631e-02f,
  -1.95166077e-02f, 2.49685913e-01f, -2.27612242e-01f, 2.32188463e-01f, 1.49823263e-01f, 2.20380411e-01f, 3.46862584e-01f, -7.24560246e-02f, 2.34492853e-01f, 5.14898375e-02f,
  3.61888483e-02f, -4.33538780e-02f, -7.29584545e-02f, -8.54258835e-02f, 2.95692142e-02f, 4.73979898e-02f, 4.61328775e-02f, -4.63395827e-02f, 1.24502685e-02f, -1.04029223e-01f,
  -1.84106752e-02f, -8.44131038e-02f, 1.29172467e-02f, 2.98661012e-02f, 1.00037962e-01f, 4.24902923e-02f, -1.55882975e-02f, 1.09284073e-02f, -6.40249103e-02f, -1.56953976e-01f,
  -1.44019306e-01f, 4.44716364e-02f, 2.19072048e-02f, -5.96991293e-02f, -1.04363644e-02f, -4.45874669e-02f, -3.83344805e-03f, -2.70081451e-03f, 2.30592005e-02f, 2.07214262e-02f,
  2.45003235e-02f, 4.15910818e-02f, 3.05818953e-03f, -2.50249356e-02f, 1.90162864e-02f, 6.15605973e-02f, -1.18845236e-02f, 5.21289259e-02f, -5.13269566e-02f, 3.38833518e-02f,
  -8.10200814e-03f, -4.82162274e-02f, -5.04466966e-02f, 3.23244967e-02f, 4.64771129e-02f, -6.77535534e-02f, 5.89401200e-02f, -1.27924560e-02f, -1.52449207e-02f, 5.91515489e-02f,
  -7.11389855e-02f, 6.99434951e-02f, -3.38479578e-02f, -5.37352487e-02f, -7.72615373e-02f, -4.94360365e-02f, -2.36564130e-03f, -1.53342895e-02f, -2.10369471e-02f, -2.52589900e-02f,
  1.23549439e-01f, 1.30391032e-01f, -7.92177208e-03f, 2.84337886e-02f, 1.07286163e-01f, 1.33236304e-01f, -1.54327359e-02f, 1.00767314e-02f, 8.22735801e-02f, 5.73809482e-02f,
  1.23264477e-01f, 4.71122861e-02f, 1.35217845e-01f, 4.64237295e-02f, 2.97576934e-02f, 4.74969484e-03f, 8.09817575e-03f, -1.48741147e-02f, 3.95015106e-02f, 4.22850661e-02f,
  1.04750931e-01f, 7.48085156e-02f, -1.51353879e-02f, 9.33122262e-02f, 6.27470315e-02f, 5.43662347e-02f, 1.81356043e-01f, 1.46899577e-02f, -6.40988490e-03f, -1.00361757e-01f,
  -7.00953677e-02f, 9.42649320e-02f, -1.32415533e-01f, 1.37253582e-01f, 1.18428364e-01f, 9.62704122e-02f, 1.74734429e-01f, 1.13654323e-01f, 2.98047334e-01f, 5.10125048e-02f,
  1.20271184e-01f, 7.40344748e-02f, -1.87305864e-02f, 1.70014128e-01f, 1.43008411e-01f, 1.64427936e-01f, 1.79641008e-01f, 9.40322503e-02f, -1.23881167e-02f, 5.67450598e-02f,
  -2.86027230e-03f, 1.49535343e-01f, -1.37983397e-01f, -1.11847386e-01f, -8.72061995e-04f, -1.79100990e-01f, -1.76108673e-01f, -1.36736467e-01f, -3.17184292e-02f, 5.38403243e-02f,
  -2.97917593e-02f, 1.11514442e-02f, -6.07844032e-02f, -3.63308378e-02f, -8.92980024e-02f, -2.13958640e-02f, -1.74189433e-02f, 3.70653868e-02f, 6.27392232e-02f, 6.67926818e-02f,
  -5.01697920e-02f, 3.94102186e-03f, 9.13901478e-02f, -5.49504794e-02f, 7.45868459e-02f, -5.64688556e-02f, 5.80226555e-02f, -5.85000962e-02f, 2.89530884e-02f, -6.01690076e-02f,
  -6.89786747e-02f, -7.19190538e-02f, 8.42124894e-02f, 4.25673127e-02f, 6.92145228e-02f, 8.53367671e-02f, -8.44131224e-03f, -4.38929237e-02f, 1.50920898e-02f, 4.58817445e-02f,
  -6.62154052e-03f, -1.66263562e-02f, 6.45261556e-02f, 3.59631926e-02f, -1.10593503e-02f, 6.16779588e-02f, -4.73745018e-02f, 2.46983580e-02f, 2.96629127e-02f, 3.41998972e-02f,
  -2.28313319e-02f, -8.73540342e-02f, 2.59347185e-02f, 1.37361791e-02f, 2.01056898e-02f, -1.69057883e-02f, 3.51753086e-02f, -4.62819152e-02f, 2.85372213e-02f, 1.80940870e-02f,
  3.59282531e-02f, -3.47479247e-02f, 4.41475287e-02f, -4.18507084e-02f, -1.60853527e-02f, -4.57059108e-02f, 1.41057943e-03f, -9.46433097e-03f, 1.00636771e-02f, -5.90611435e-02f,
  1.75680608e-01f, 1.87682524e-01f, 4.13294323e-02f, 3.32474299e-02f, 5.01179844e-02f, -2.36750674e-02f, 1.41743720e-02f, -7.86957238e-03f, 6.46955892e-02f, -2.79236361e-02f,
  2.98874825e-02f, -1.65357403e-02f, 3.66398841e-02f, -7.68301561e-02f, -6.14467598e-02f, 3.44021320e-02f, -2.53373524e-03f, 1.75802708e-02f, -2.78784353e-02f, -5.41889574e-03f,
  -8.76710340e-02f, 6.61012232e-02f, 4.92254198e-02f, 8.85490142e-03f, -3.74474674e-02f, -1.75160151e-02f, 4.43786662e-03f, -4.02795002e-02f, 1.39794592e-02f, 1.12088434e-02f,
  -2.56732911e-01f, -4.03815247e-02f, 2.61804387e-02f, -1.67353630e-01f, -8.71088356e-02f, -3.12019706e-01f, -2.25819811e-01f, -1.58780161e-02f, 7.36063719e-03f, -1.05012335e-01f,
  -1.48060516e-01f, 4.81264703e-02f, 1.34020627e-01f, -2.49060884e-01f, -8.10051188e-02f, -1.80511102e-01f, -2.65087187e-01f, -6.21170253e-02f, -7.74237812e-02f, -1.24153644e-01f,
  -5.51770814e-02f, -2.77430862e-01f, -1.75507545e-01f, -2.28408612e-02f, -7.61207342e-02f, 1.42497150e-02f, -9.39175263e-02f, 6.52588159e-02f, -8.36287960e-02f, 9.77965258e-03f,
  -1.39301479e-01f, 1.91529263e-02f, -1.01727620e-01f, 5.00231702e-03f, -1.82770833e-01f, 1.66266095e-02f, 2.61109148e-04f, 2.92041060e-02f, -3.64935063e-02f, 2.98906825e-02f,
  -3.37872878e-02f, 6.73337057e-02f, -5.52140316e-03f, 8.92898366e-02f, 5.93236461e-02f, 1.55462325e-02f, 1.42699862e-02f, 1.94899179e-02f, -4.36288826e-02f, 5.96653149e-02f,
  1.13925021e-02f, -8.14799219e-02f, 1.06964977e-02f, -1.36938570e-02f, -5.80627806e-02f, 1.08911199e-02f, 2.35316507e-03f, 5.60391136e-02f, -6.68758973e-02f, -4.21760753e-02f,
  -4.58808430e-02f, -1.78742278e-02f, -6.24015518e-02f, 9.72374901e-03f, 3.91173214e-02f, -3.35490890e-02f, 6.23506419e-02f, -3.70891429e-02f, -7.14531913e-03f, 7.74526447e-02f,
  -6.43369183e-02f, 6.43451326e-03f, 2.05527432e-02f, -2.51931567e-02f, -3.21581662e-02f, -1.03071546e-02f, 6.57150000e-02f, -8.78852699e-03f, -1.78055745e-02f, -2.42558308e-02f,
  1.83076356e-02f, -2.87570860e-02f, 4.04106416e-02f, -2.36060042e-02f, -8.74244701e-03f, 4.53011924e-03f, 3.31470817e-02f, -4.43663001e-02f, 2.50401665e-02f, -4.03636917e-02f,
  -2.51716822e-01f, -2.64802366e-01f, -1.44140527e-01f, -6.41198382e-02f, -3.19387647e-04f, -2.77263746e-02f, -4.35548350e-02f, -8.18440095e-02f, -9.32245404e-02f, -1.48314824e-02f,
  1.47148538e-02f, -3.71183921e-03f, -6.35409951e-02f, -1.04787827e-01f, 3.30186673e-02f, -4.83227372e-02f, 3.45087536e-02f, -5.00032045e-02f, -4.05304208e-02f, -4.17725146e-02f,
  -5.08899279e-02f, 6.30653501e-02f, 3.62381935e-02f, -5.12485020e-02f, 5.80702350e-02f, 5.57040684e-02f, 9.68177021e-02f, -4.59664427e-02f, -6.99345395e-02f, -1.58341862e-02f,
  -1.70809831e-02f, -3.89852524e-01f, 1.61109939e-01f, -8.52247775e-02f, 1.28996581e-01f, 2.03249946e-01f, 8.43936726e-02f, -4.07181904e-02f, -3.22524816e-01f, -2.26108596e-01f,
  6.65765582e-03f, -1.06143758e-01f, -3.04343328e-02f, -1.71702057e-01f, 1.78966299e-01f, -2.13374317e-01f, -1.14995919e-01f, -1.03383861e-01f, -3.68187241e-02f, -1.06082134e-01f,
  3.78175043e-02f, -6.62547871e-02f, 3.97187285e-02f, -8.49379525e-02f, 8.21026042e-02f, -8.91446993e-02f, 2.79118158e-02f, 1.82243735e-01f, 5.27173206e-02f, 1.81733876e-01f,
  1.97651964e-02f, -8.98415521e-02f, -2.81273071e-02f, 2.92002372e-02f, 7.53602087e-02f, -4.22146618e-02f, 1.57536313e-01f, 7.14372396e-02f, 3.00028119e-02f, -3.17733027e-02f,
  -1.56313665e-02f, 1.92090720e-02f, -7.05271587e-02f, 6.82581738e-02f, 1.35819390e-02f, -5.47453687e-02f, 2.76964530e-02f, -2.57586893e-02f, 4.99145240e-02f, -8.29744637e-02f,
  2.38031298e-02f, -3.89194265e-02f, 7.36222789e-02f, 1.39224142e-01f, 5.44378944e-02f, 7.18657076e-02f, 8.91306475e-02f, 6.81164861e-02f, -4.59320843e-02f, 9.98561755e-02f,
  -3.96806784e-02f, 9.57481787e-02f, -4.43774164e-02f, 1.11014619e-02f, 3.50087020e-03f, -1.74201895e-02f, -7.39482865e-02f, 2.70143943e-03f, 1.77825037e-02f, -8.54536332e-03f,
  -3.01640830e-04f, -4.11280878e-02f, -3.67074497e-02f, 5.61103150e-02f, 3.17119770e-02f, 2.12008410e-04f, -3.96508537e-02f, 8.79289508e-02f, -4.58906814e-02f, 4.36146259e-02f,
  3.26462761e-02f, -6.77029043e-02f, 2.57505402e-02f, 2.75154319e-02f, -8.41848776e-02f, 1.06685394e-02f, 9.67932343e-02f, -9.79954749e-02f, -3.68944630e-02f, 4.01119217e-02f,
  -1.90970734e-01f, -2.05428645e-01f, -4.06542905e-02f, 4.64776829e-02f, -5.76796643e-02f, -1.74234656e-03f, 5.22081275e-03f, -4.93718013e-02f, -8.09472352e-02f, -7.54936635e-02f,
  5.10130599e-02f, 8.57969299e-02f, -6.29588217e-02f, 7.44412690e-02f, 2.38269679e-02f, -1.19028963e-01f, -3.32838967e-02f, 4.28953655e-02f, 7.55513012e-02f, -5.38999252e-02f,
  1.09374570e-02f, 1.08009383e-01f, 1.13871083e-01f, 4.08916995e-02f, -5.64431921e-02f, -3.19825187e-02f, -7.15307379e-03f, 4.04942408e-02f, 7.81108961e-02f, -6.13450445e-02f,
  -4.99040298e-02f, 7.26993158e-02f, -3.93163443e-01f, 1.62455812e-02f, -2.05710113e-01f, -1.38178542e-01f, -2.51388154e-03f, 5.46353348e-02f, 1.66291315e-02f, 3.97600561e-01f,
  2.86207676e-01f, -8.48689452e-02f, 2.17835173e-01f, 4.41411167e-01f, -2.12223843e-01f, 2.49005884e-01f, 1.50009945e-01f, 1.27481043e-01f, -1.18944377e-01f, 2.75603477e-02f,
  -1.67124778e-01f, 4.08786684e-01f, -1.02823839e-01f, 4.06520776e-02f, -6.03928044e-02f, -1.40639424e-01f, 1.56831846e-01f, -2.24747628e-01f, 1.28791079e-01f, 1.76181570e-02f,
  3.27305764e-01f, 3.57431382e-01f, -5.83454743e-02f, -3.11033288e-03f, -2.19159033e-02f, -3.13882679e-02f, -1.14050925e-01f, -7.90643841e-02f, -5.04790284e-02f, -4.18143049e-02f,
  -4.11597192e-02f, -2.28877389e-03f, 8.87286812e-02f, 1.09678991e-02f, -2.85684187e-02f, -6.50123879e-02f, -6.22247532e-02f, 4.75504696e-02f, 2.43485142e-02f, 1.61483921e-02f,
  -2.37874947e-02f, 1.62556861e-02f, -6.57597110e-02f, -9.62958112e-02f, -4.10617776e-02f, 4.59242091e-02f, 4.14933078e-02f, -7.18518868e-02f, 6.59385622e-02f, -5.40299434e-03f,
  4.68075648e-02f, -5.73445037e-02f, 6.14817813e-02f, 5.52484915e-02f, -4.34243605e-02f, 4.03278396e-02f, 3.08387000e-02f, 3.24939704e-03f, -6.17544465e-02f, -3.14746834e-02f,
  4.50425260e-02f, -5.39575424e-03f, 2.05082707e-02f, -2.88614091e-02f, 1.73069909e-02f, 7.10608736e-02f, 9.93600581e-03f, -1.90197527e-02f, 1.95632596e-02f, -6.01643287e-02f,
  3.52993794e-02f, -4.65660878e-02f, 9.61810630e-03f, 8.56996253e-02f, 5.53800538e-02f, -1.04913123e-01f, 1.49347261e-02f, -5.18041896e-04f, -3.94815058e-02f, 8.28535017e-03f,
  -9.42823440e-02f, -4.19114791e-02f, 7.64525756e-02f, -2.01133406e-03f, -8.27073604e-02f, -1.63041484e-02f, 6.50042593e-02f, -3.82363126e-02f, 4.65488359e-02f, -2.33141240e-02f,
  3.15931104e-02f, 5.14379889e-03f, -4.99051176e-02f, -3.86938942e-03f, -9.20956954e-02f, 1.51120335e-01f, 6.72754720e-02f, -3.91503982e-02f, -9.19558480e-03f, -7.75013939e-02f,
  -5.15711270e-02f, -3.45831513e-02f, -5.73066212e-02f, 3.90962288e-02f, -3.84033844e-02f, 2.21044682e-02f, -2.48583872e-02f, -2.99816318e-02f, 1.07328501e-02f, 2.79809372e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -6.85102865e-02f, -1.70654878e-02f, 6.63161799e-02f, -9.39958077e-03f, 2.57306695e-01f, 2.57122099e-01f, -3.57180089e-01f, 5.84835783e-02f, 7.34582543e-02f, 3.35743427e-01f,
  7.05381259e-02f, 7.06878081e-02f, 3.69786173e-01f, 4.67406549e-02f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -6.78642154e-01f, -3.73967826e-01f, 1.41001016e-01f, 2.60151982e-01f, 3.11670125e-01f, 6.59394264e-02f, -2.28382155e-01f, -1.66868001e-01f, -3.58303040e-01f, 5.34841061e-01f,
  -8.17237720e-02f, 7.90745392e-02f, -2.74306536e-01f, 3.91542912e-01f, 1.64525494e-01f, 3.25504899e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  6.46904051e-01f, 6.14486694e-01f, -1.60203531e-01f, -3.02009314e-01f, -7.60708898e-02f, -4.64709252e-02f, 6.71678126e-01f, 4.11759138e-01f, 4.97099340e-01f, -2.40082160e-01f,
  2.58235902e-01f, -1.88678965e-01f, -1.46856889e-01f, 5.76075017e-02f, 3.47911566e-01f, -3.20831358e-01f, 7.13641584e-01f, 2.01692730e-01f, -1.17856182e-01f, -1.22367211e-01f,
  1.10948481e-01f, -1.31393075e-01f, 8.69697690e-01f, 1.55962974e-01f, -5.76960981e-01f, -5.25725409e-02f, 2.19367623e-01f, 2.26568375e-02f, 9.95457470e-02f, -1.62084594e-01f,
  3.73592496e-01f, -5.49687862e-01f, 3.19222063e-01f, -2.20253304e-01f, -5.28903008e-02f, -1.28109857e-01f, 2.27684319e-01f, -5.38780801e-02f, -3.84186059e-02f, 1.85686216e-01f,
  -3.10460895e-01f, 2.02439353e-01f, 1.00744531e-01f, 3.18251713e-03f, 2.71873891e-01f, -1.68865025e-01f, 1.51154697e-01f, 1.07359543e-01f, 2.50644167e-04f, -1.42867258e-02f,
  1.74955666e-01f, 2.96844065e-01f, 2.09833197e-02f, 3.23093794e-02f, 4.38903183e-01f, -2.65726238e-01f, 2.92650014e-01f, 2.38996461e-01f, -1.56128909e-02f, -2.09102541e-01f,
  -2.89690882e-01f, 2.80053467e-01f, 8.31047371e-02f, 7.29617402e-02f, 1.88863948e-01f, 6.48538649e-01f, 4.78280447e-02f, 1.06520973e-01f, -1.03098989e-01f, 2.42293030e-01f,
  6.77375376e-01f, 3.81545752e-01f, 8.73871371e-02f, -9.11241546e-02f, 8.69063139e-02f, 5.00071824e-01f, -1.35656476e-01f, 1.67572543e-01f, 2.87322015e-01f, -7.84143806e-02f,
  -1.99186265e-01f, 5.03240973e-02f, 3.83490487e-03f, 7.93448612e-02f, -1.76179424e-01f, 5.97225502e-03f, 1.23400696e-01f, -8.29564407e-02f, -2.24852681e-01f, 1.73094034e-01f,
  1.64264962e-01f, -2.25759387e-01f, 2.65118659e-01f, -1.92654103e-01f, 1.85805798e-01f, -2.65599608e-01f, 1.32768437e-01f, -1.73720464e-01f, 1.54377326e-01f, 5.49326301e-01f,
  -1.56868219e-01f, 2.70153344e-01f, 1.19686730e-01f, -2.54157245e-01f, 4.65623021e-01f, 2.13890940e-01f, 1.29681081e-01f, 2.94605434e-01f, -1.84422042e-02f, 4.59889680e-01f,
  2.11655557e-01f, 4.23916206e-02f, -1.78788126e-01f, -6.07373975e-02f, 5.35816014e-01f, 7.83666551e-01f, -8.07205290e-02f, -2.94858485e-01f, -1.56015038e-01f, -7.38215297e-02f,
  -1.01515293e-01f, -2.18821745e-02f, -1.47321135e-01f, 2.70346366e-02f, 3.87373157e-02f, 2.51782805e-01f, -1.63576528e-01f, 1.42910825e-02f, 4.71443415e-01f, 3.18005115e-01f,
  4.28384691e-02f, 4.72152792e-02f, 5.42032480e-01f, -1.28793895e-01f, -8.40147957e-03f, 9.45939422e-01f, -6.57348275e-01f, -5.86437657e-02f, -4.96717662e-01f, 7.68651426e-01f,
  -2.57780086e-02f, -2.27585044e-02f, 3.94049257e-01f, 3.72154653e-01f, 1.23156294e-01f, -1.61118567e-01f, 9.92503837e-02f, 3.17705661e-01f, 1.04570158e-01f, 3.89892459e-02f,
  -8.60579163e-02f, 2.54233241e-01f, -2.41759822e-01f, 5.53362250e-01f, -3.36140633e-01f, -5.87886013e-02f, -4.10640806e-01f, 4.57072526e-01f, 4.57809985e-01f, -2.98338562e-01f,
  2.14386627e-01f, -2.58981258e-01f, 7.62463957e-02f, 5.28517544e-01f, 1.75564200e-01f, -9.87988785e-02f, 3.08052860e-02f, 2.16698237e-02f, -2.53503978e-01f, -1.09269628e-02f,
  4.90792990e-02f, -2.41461337e-01f, 6.34298697e-02f, 2.37843528e-01f, -2.22799838e-01f, 6.26910686e-01f, 3.06046735e-02f, 3.04260314e-01f, 1.80125684e-01f, 2.39711944e-02f,
  2.73682028e-01f, 2.52007723e-01f, -3.57456282e-02f, 2.70120412e-01f, 3.35550122e-02f, 1.85705036e-01f, -1.36254951e-01f, 3.35005105e-01f, -2.98756778e-01f, 3.67511883e-02f,
  -7.91938379e-02f, -7.04780519e-02f, 8.39708373e-02f, 1.75842911e-01f, -1.19803555e-01f, 1.15105949e-01f, 1.53952464e-01f, 2.21344039e-01f, 2.78374106e-01f, 8.49039033e-02f,
  -6.83083385e-02f, 2.54087359e-01f, 7.39744753e-02f, 1.84753045e-01f, -1.37933463e-01f, 2.80727968e-02f, 2.83748865e-01f, -3.71742964e-01f, -1.87748238e-01f, -1.12748943e-01f,
  -1.10017397e-01f, 1.70263365e-01f, 1.33353472e-01f, -2.42345169e-01f, -1.10532090e-01f, -2.00735833e-02f, -1.61036417e-01f, 1.43559650e-01f, 1.61705405e-01f, -1.77661210e-01f,
  2.39348486e-01f, -2.05665246e-01f, -6.16789833e-02f, -1.41765460e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  6.04934692e-01f, 9.02725995e-01f, 2.35944092e-01f, -3.90058719e-02f, 2.62574196e-01f, -2.55710483e-01f, -9.91913024e-03f, -1.53184667e-01f, 5.52213907e-01f, 5.62191129e-01f,
  6.24861896e-01f, -8.49903002e-02f, -4.90998477e-02f, 7.70803690e-02f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.41127899e-01f, -9.76040289e-02f, 2.95602102e-02f, -1.09722264e-01f, -9.97286886e-02f, 3.19327921e-01f, 8.06221291e-02f, -8.51057619e-02f, 1.67676192e-02f, 1.66844413e-01f,
  -3.73644531e-01f, 3.48011315e-01f, -2.04065323e-01f, -1.38830900e-01f, 3.26643176e-02f, -1.06919566e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.36833787e-01f, -4.37011451e-01f, 1.25359684e-01f, 5.27318060e-01f, 2.05975980e-01f, -1.65487587e-01f, -9.38814804e-02f, -4.06881571e-02f, -1.26420483e-01f, -1.01067439e-01f,
  -2.57358164e-01f, -3.45073909e-01f, 3.98766212e-02f, -3.31889212e-01f, -2.49275848e-01f, -1.34518608e-01f, 2.93890703e-02f, -6.93822682e-01f, 6.66766822e-01f, 6.95456505e-01f,
  -1.58751160e-02f, 1.47001266e-01f, 3.25777493e-02f, 2.74428159e-01f, -7.87376240e-03f, -2.85097033e-01f, -3.94003808e-01f, 1.78733677e-01f, 2.10378408e-01f, -2.31480762e-01f,
  1.32162169e-01f, 1.17793322e-01f, -3.03652108e-01f, -2.37941846e-01f, 4.25306559e-01f, -1.99891716e-01f, 3.71476859e-02f, 1.07339874e-01f, 1.56715944e-01f, -1.33230358e-01f,
  7.15661654e-03f, 1.29163668e-01f, -1.74147144e-01f, 3.15600820e-02f, -2.50464767e-01f, -4.10295278e-02f, 2.21212313e-01f, -2.32884690e-01f, 1.27212375e-01f, 3.24235409e-01f,
  9.61448625e-02f, 5.03430247e-01f, -1.38123229e-01f, 5.29208779e-01f, 2.66239673e-01f, 2.06658095e-02f, 4.52533931e-01f, 6.97161019e-01f, -4.69600745e-02f, 5.60234487e-01f,
  2.06829220e-01f, 2.55807698e-01f, 2.38753214e-01f, -9.46794301e-02f, 1.19580865e-01f, -9.69852626e-01f, 7.20382094e-01f, 7.81514585e-01f, 7.49505311e-02f, 1.28807247e-01f,
  4.84343112e-01f, -5.11391126e-02f, 1.30729303e-01f, -3.94042730e-01f, 1.32227868e-01f, 1.41261844e-02f, -2.54798472e-01f, 1.52811021e-01f, 4.91562635e-02f, -1.22802835e-02f,
  1.12445697e-01f, 4.99617845e-01f, -3.88852388e-01f, -1.11603200e-01f, 7.40439305e-03f, -5.14724217e-02f, -3.33021395e-02f, 9.45557281e-02f, 1.83794260e-01f, 3.06959510e-01f,
  1.99714258e-01f, 1.26512900e-01f, 1.00206196e-01f, -2.62129366e-01f, 2.43119393e-02f, -1.23516032e-02f, 6.00509048e-01f, 1.04551065e+00f, -3.05111706e-01f, 1.09407967e-02f,
  1.16003841e-01f, 8.45762789e-02f, -2.64570415e-01f, -3.58301252e-01f, 2.06729323e-01f, 3.17620426e-01f, 6.45000577e-01f, 3.91915679e-01f, 6.97784603e-01f, 9.95506346e-02f,
  -2.45932028e-01f, -3.69529729e-03f, -1.16128340e-01f, -1.03233106e-01f, 1.26931025e-03f, -1.09794140e-01f, -2.26844341e-01f, 7.88030997e-02f, 4.26030718e-02f, 7.17565790e-02f,
  1.07432626e-01f, -6.40391856e-02f, 2.19102576e-01f, -3.82100493e-01f, 3.98115247e-01f, -2.07713634e-01f, -1.42872348e-01f, 8.29943046e-02f, 1.34413957e-03f, -3.60902905e-01f,
  3.33036482e-01f, 2.89118946e-01f, -1.57258227e-01f, 9.04952511e-02f, 2.77732551e-01f, -2.06375688e-01f, -2.97816038e-01f, -1.52107954e-01f, 4.76491302e-01f, -1.94406569e-01f,
  5.15842848e-02f, 1.47801325e-01f, 3.61177653e-01f, -1.96906686e-01f, 1.00253187e-01f, -9.43671107e-01f, 5.00435531e-01f, 2.58188456e-01f, 1.12540908e-01f, -1.33716330e-01f,
  5.24086297e-01f, 7.02916458e-02f, 4.41920124e-02f, -2.63376266e-01f, -9.04748142e-02f, -2.68883288e-01f, -3.09505709e-03f, 6.44527301e-02f, -1.27925247e-01f, -1.43293419e-03f,
  1.86261654e-01f, -2.68578142e-01f, 4.45518583e-01f, 4.96334523e-01f, -1.22312859e-01f, -1.50560990e-01f, 5.87972403e-01f, 7.33139515e-02f, -4.13464829e-02f, -9.16583762e-02f,
  8.12664866e-01f, 3.99248302e-01f, -4.02470022e-01f, 4.20054436e-01f, 3.22111636e-01f, 4.32140902e-02f, -1.39611781e-01f, -4.42764878e-01f, 3.13295931e-01f, -1.03493184e-01f,
  -9.62030366e-02f, 1.02999829e-01f, 2.95626938e-01f, -1.47714734e-01f, 4.88438278e-01f, 1.47548258e-01f, -1.57010198e-01f, -1.85031593e-01f, 3.17904472e-01f, 2.22820401e-01f,
  1.89192757e-01f, -3.02308053e-01f, 6.82150200e-02f, -3.80690306e-01f, -1.79277420e-01f, -7.20950142e-02f, 1.84089035e-01f, -1.87026247e-01f, 2.04386339e-01f, -3.10719758e-02f,
  -1.78050324e-01f, -1.61408186e-01f, 7.84009025e-02f, -1.16523854e-01f, 1.26053780e-01f, -1.80740386e-01f, -2.12999612e-01f, -1.53381586e-01f, 8.18629563e-01f, 6.63798004e-02f,
  4.42389958e-03f, 8.30735624e-01f, 4.95709479e-01f, -4.14576530e-01f, 3.01507682e-01f, -1.53834745e-01f, -4.33910042e-01f, -2.78142184e-01f, 1.09071136e+00f, 3.90352845e-01f,
  3.28097820e-01f, -9.45381150e-02f, 2.94326484e-01f, 1.65164173e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  3.19797605e-01f, 5.88019729e-01f, -2.19004884e-01f, 6.72913375e-05f, 4.79287893e-01f, 6.16353035e-01f, 7.45150924e-01f, 2.77645022e-01f, -1.20705165e-01f, 3.50873947e-01f,
  -6.37939796e-02f, 1.81257740e-01f, 5.48822470e-02f, 6.85594022e-01f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -2.45081425e-01f, -3.06601822e-02f, 2.24346325e-01f, 8.77565145e-02f, -5.10069020e-02f, -1.32135421e-01f, -1.90757126e-01f, -4.22436923e-01f, -7.28331581e-02f, 2.94868886e-01f,
  3.31427813e-01f, 1.14703082e-01f, 2.69081503e-01f, 2.71777719e-01f, 3.81028295e-01f, -2.84207948e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -2.30900943e-02f, -4.01006699e-01f, -1.33092076e-01f, -4.45869625e-01f, -3.28436643e-01f, -3.77997756e-01f, 2.16591403e-01f, 1.43127307e-01f, 1.82063788e-01f, -1.63929258e-02f,
  6.46222308e-02f, -2.65413485e-02f, 1.86733052e-01f, 2.56924275e-02f, 1.35796979e-01f, 7.11855054e-01f, -1.13267414e-01f, -9.07571465e-02f, -1.15237087e-01f, -1.11232057e-01f,
  1.68611726e-03f, 3.69044870e-01f, -1.62692428e-01f, -2.50756014e-02f, 2.09811464e-01f, 7.57464617e-02f, -2.30970532e-01f, -8.36195052e-02f, 6.80224225e-02f, -3.45649570e-02f,
  -1.65534183e-01f, -3.31582844e-01f, 2.02517733e-02f, 6.54632226e-02f, -1.03995636e-01f, -2.92377084e-01f, -1.48568168e-01f, 3.24740708e-01f, -2.54038572e-01f, 2.49086320e-01f,
  5.58190703e-01f, 1.96437553e-01f, -2.19570637e-01f, -2.41793260e-01f, -1.01175115e-01f, -3.56831662e-02f, -1.27504826e-01f, -2.57806808e-01f, -1.52725250e-01f, -5.38370669e-01f,
  -2.95737565e-01f, -1.80594072e-01f, -3.31609964e-01f, 1.49702579e-01f, 4.21835274e-01f, -6.31045625e-02f, -1.94921717e-01f, -3.99617702e-01f, 4.71945614e-01f, -4.25986499e-02f,
  9.24965739e-01f, -4.17062908e-01f, 2.48250529e-01f, 1.22506011e+00f, -2.73929328e-01f, 1.84285805e-01f, 2.79978365e-01f, -4.01529334e-02f, -1.65646031e-01f, 4.23211008e-01f,
  1.07253693e-01f, -1.10109739e-01f, 2.11630128e-02f, -6.79240515e-03f, 2.08842978e-01f, 2.71484315e-01f, -1.20572403e-01f, 9.45714712e-02f, -1.10819101e-01f, 2.26923183e-01f,
  1.19413204e-01f, 2.06338137e-01f, -1.87441349e-01f, -2.13770509e-01f, -2.25130737e-01f, 6.21701241e-01f, -7.44270459e-02f, 3.80340785e-01f, 5.73640645e-01f, -3.20916735e-02f,
  -3.08725625e-01f, -1.89555913e-01f, -3.28543298e-02f, 2.83568203e-01f, -1.12642154e-01f, -4.42367643e-01f, 1.20985174e+00f, -3.62606883e-01f, 2.29153425e-01f, 9.61304978e-02f,
  -4.91578102e-01f, -1.50619254e-01f, -1.70581579e-01f, 5.14750361e-01f, 7.83431113e-01f, -1.16799712e-01f, -4.79384452e-01f, -3.35785717e-01f, -3.85561138e-01f, -5.68801641e-01f,
  1.63680520e-02f, 8.96062791e-01f, -1.82709441e-01f, -3.22490573e-01f, -1.65587291e-01f, -2.88988411e-01f, 7.75200352e-02f, -4.92168933e-01f, -3.03069085e-01f, 1.40466899e-01f,
  7.23176897e-01f, 2.84591079e-01f, -1.22271441e-01f, -2.30192602e-01f, -3.68252397e-01f, -1.21438138e-01f, 5.88892922e-02f, 4.75361347e-01f, 1.75143238e-02f, 6.80617094e-02f,
  -2.52441794e-01f, -1.24098331e-01f, 3.11296806e-02f, 2.31536865e-01f, -2.08297893e-02f, 2.55768448e-01f, 5.70271075e-01f, 1.49807790e-02f, -6.09605387e-02f, 2.48881802e-01f,
  2.41810363e-02f, 3.62401783e-01f, 1.76909447e-01f, -2.23925620e-01f, -3.61631602e-01f, -3.51196975e-01f, 1.87162921e-01f, -3.43425632e-01f, 1.24432594e-01f, -4.14589047e-01f,
  1.52743459e-01f, 9.48663875e-02f, 1.61262578e-03f, 2.70217806e-01f, 1.90062970e-01f, 2.74873018e-01f, 2.95766175e-01f, -5.15864827e-02f, 2.06337068e-02f, 3.53990972e-01f,
  4.49754059e-01f, 3.83172967e-02f, -4.12007451e-01f, -6.89538494e-02f, -3.57468873e-02f, 3.75953048e-01f, -2.93883264e-01f, -7.57919848e-02f, 5.97172379e-01f, -3.65128666e-01f,
  -4.10305820e-02f, -5.53804457e-01f, 4.03317750e-01f, -4.28211093e-01f, -2.79976338e-01f, 4.49505240e-01f, 5.71137620e-03f, -1.88563034e-01f, -2.85860538e-01f, 3.13370943e-01f,
  3.16418968e-02f, 1.62528828e-01f, 8.18127155e-01f, -3.42077464e-01f, -6.42617762e-01f, 3.13350037e-02f, 4.99717295e-01f, 3.35811526e-01f, 7.46142387e-01f, 2.03377590e-01f,
  -1.41868487e-01f, -7.51419589e-02f, 8.84399891e-01f, 1.62731662e-01f, 4.91732270e-01f, 1.11372662e+00f, 7.22964704e-02f, -4.58505526e-02f, 1.16192400e+00f, -4.22516197e-01f,
  -5.34849226e-01f, -8.56072679e-02f, 2.31180504e-01f, 8.57057929e-01f, 8.23464394e-02f, 2.17090920e-01f, 1.44693181e-01f, 3.37505937e-01f, 7.06700385e-01f, 9.44358930e-02f,
  1.51061416e-01f, 1.66379035e-01f, -3.94336060e-02f, 6.83821067e-02f, 3.16715479e-01f, 2.50275552e-01f, 1.76093787e-01f, -3.36457454e-02f, -2.45255873e-01f, 2.98265308e-01f,
  2.36448526e-01f, -4.08711322e-02f, -1.59470618e-01f, -2.12577283e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  -1.03112340e-01f, -2.63693571e-01f, 2.34262824e-01f, -1.63239524e-01f, -1.62013099e-01f, 6.64209723e-02f, 9.92391765e-01f, 1.40206724e-01f, 2.72536010e-01f, -4.26777750e-02f,
  5.51191032e-01f, -1.95131645e-01f, 5.77262163e-01f, 5.51457465e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  3.32078546e-01f, -7.70054162e-01f, 1.60089508e-01f, -1.21102169e-01f, 2.54444122e-01f, -3.94843251e-01f, -1.32542178e-01f, -2.92452812e-01f, 9.43100631e-01f, 8.76730263e-01f,
  -9.47359577e-02f, -1.53017327e-01f, 1.77109644e-01f, -5.17754018e-01f, -9.19762313e-01f, -2.11921975e-01f, 6.12324536e-01f, 2.03497082e-01f, 2.94452935e-01f, -2.02556655e-01f,
  1.95538271e-02f, 5.36685288e-01f, 2.01532379e-01f, -2.12724522e-01f, 1.92958817e-01f, 4.45495814e-01f, 1.32406736e-02f, 5.39607406e-01f, 2.48659402e-01f, -5.36711156e-01f,
  -7.13078618e-01f, -3.19349468e-01f, -5.02728045e-01f, -2.85803705e-01f, 3.15172613e-01f, 2.93673366e-01f, 2.24639978e-02f, 8.42825890e-01f, 2.50379145e-01f, 1.69319525e-01f,
  -6.95692122e-01f, -3.31097916e-02f, 2.84506660e-02f, 3.00505638e-01f, -1.14442986e-02f, 5.07631123e-01f, -4.61102158e-01f, -7.70319998e-01f, 3.91720891e-01f, -9.47475851e-01f,
  -4.00573611e-01f, 1.20063191e-02f, 4.21166569e-01f, -7.67878592e-01f, -3.45708996e-01f, 5.47536731e-01f, 7.04427898e-01f, 2.63924360e-01f, 4.09060568e-01f, -1.22280166e-01f,
  5.35567343e-01f, -3.10071707e-01f, -7.00848281e-01f, 2.52555102e-01f, 4.76752877e-01f, -5.15877545e-01f, -3.03234816e-01f, -1.57395661e-01f, -2.87371837e-02f, 1.92440212e-01f,
  -2.06495032e-01f, -2.05415413e-02f, 7.56516635e-01f, -3.34556341e-01f, -2.34987840e-01f, -4.70183194e-01f, 8.03867817e-01f, -5.24123549e-01f, -2.26486996e-02f, 2.57873744e-01f,
  6.31139398e-01f, 4.63020205e-01f, 7.87847489e-03f, -1.97346006e-02f, -1.10992856e-01f, -2.49881729e-01f, 9.36493650e-02f, -3.13401312e-01f, 5.91121197e-01f, -2.31369436e-01f,
  -2.15199560e-01f, 3.62305343e-02f, -5.43565273e-01f, -3.83719683e-01f, 1.04119241e+00f, 1.18109837e-01f, -6.97917104e-01f, -3.78425926e-01f, -8.15264508e-02f, -8.88077095e-02f,
  -3.04409931e-03f, 3.41483325e-01f, -6.10597320e-02f, 1.09816931e-01f, -9.73364174e-01f, 2.81056762e-01f, 5.69235235e-02f, 4.55274254e-01f, -5.82424402e-01f, 5.80754757e-01f,
  4.01799083e-01f, -3.94209251e-02f, -6.88873410e-01f, -4.96787906e-01f, -2.83923328e-01f, 4.78706151e-01f, 6.59261107e-01f, -5.38217008e-01f, 2.54038513e-01f, 7.80928493e-01f,
  -1.02002978e-01f, -1.09489046e-01f, 5.62188566e-01f, -2.75320649e-01f, -8.09344370e-03f, -4.35058922e-01f, -3.42888176e-01f, 1.06869981e-01f, -9.35266837e-02f, 1.01294184e+00f,
  -5.09050906e-01f, -1.07845955e-01f, -4.58981097e-01f, -1.05621576e+00f, -6.07425980e-02f, -4.30129170e-02f, -7.95748472e-01f, -3.16257715e-01f, 1.71525851e-01f, 8.58111009e-02f,
  -3.69011819e-01f, 5.17955422e-01f, 1.01183426e+00f, 2.36907706e-01f, -2.79027432e-01f, 1.02908933e+00f, 1.96700245e-02f, 5.10672899e-03f, 6.57886267e-02f, 3.72988373e-01f,
  -7.45851025e-02f, -2.62410611e-01f, -2.08828688e-01f, -3.15367490e-01f, -3.29648137e-01f, 4.21794057e-02f, 7.07880929e-02f, 3.08511406e-01f, 4.11898404e-01f, -7.93520585e-02f,
  8.55884373e-01f, 6.58392251e-01f, 4.42695260e-01f, 2.79444996e-02f, -2.45410740e-01f, 5.04366159e-01f, 6.76646177e-03f, -2.41988838e-01f, 1.33541733e-01f, -2.59883761e-01f,
  1.78459808e-01f, 3.31622958e-02f, 1.72784969e-01f, 1.41834579e-02f, -1.82128027e-01f, 1.94135442e-01f, -8.35774362e-01f, 4.11140949e-01f, -5.51745117e-01f, 1.86235085e-01f,
  -2.06850976e-01f, -5.12784049e-02f, 4.47689891e-01f, -6.86729401e-02f, -6.58890069e-01f, -1.37322932e-01f, -2.33069941e-01f, -3.89406621e-01f, -4.84326601e-01f, 4.53952998e-01f,
  8.24756145e-01f, -3.13718878e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.88816309e-01f, 1.44976512e-01f, -5.83277404e-01f, 2.87436932e-01f, 4.23319250e-01f, 5.84748924e-01f, -6.28881991e-01f, -2.05755576e-01f, -4.22257781e-02f, 1.54360570e-02f,
  6.37866259e-01f, -3.75576973e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    