/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.94517328e-02f, 1.30894994e-02f, -3.35007682e-02f, -2.25378886e-01f, 3.75280939e-02f, -3.66562217e-01f, -4.63333815e-01f, -2.94297319e-02f, -1.84918031e-01f, -2.17203647e-01f,
  -2.00810596e-01f, -1.95399076e-01f, -1.73507333e-01f, -2.30810478e-01f, -1.93032876e-01f, -1.19751632e-01f, -1.84909388e-01f, -9.61693004e-02f, 6.09175712e-02f, 6.70131594e-02f,
  3.94540355e-02f, -5.28172255e-02f, -1.48439988e-01f, 1.57793194e-01f, -9.42770615e-02f, 1.90021381e-01f, 1.31671280e-01f, 4.84284088e-02f, -4.93388332e-04f, -4.55551185e-02f,
  -8.70572329e-02f, 1.39010213e-02f, -7.81855881e-02f, -2.34462619e-02f, -2.89364327e-02f, 1.81909986e-02f, 3.28757800e-02f, -6.79015517e-02f, -1.36871431e-02f, 1.02266455e-02f,
  1.48955928e-02f, 4.94279154e-02f, 2.29182392e-02f, -6.72914609e-02f, 6.49901256e-02f, -2.86527518e-02f, 2.76405551e-02f, -4.93167378e-02f, 3.64929587e-02f, -5.31572998e-02f,
  -6.50038347e-02f, 5.88773042e-02f, -5.48053207e-03f, -3.62352878e-02f, -5.90170696e-02f, 8.87325406e-03f, 2.82986797e-02f, -2.27029901e-02f, -1.07286610e-02f, -7.31853396e-02f,
  4.83742543e-02f, 5.31838760e-02f, -1.74779259e-02f, 3.16209160e-02f, -3.78953591e-02f, 6.93895072e-02f, -5.98293208e-02f, 4.64452058e-02f, 4.45497036e-02f, -1.37561513e-02f,
  -6.38821945e-02f, 1.68441702e-02f, 1.08147587e-03f, 4.61192429e-02f, -8.79613962e-03f, 3.02197244e-02f, 3.91143151e-02f, -6.28374284e-03f, -7.00527504e-02f, -2.51441542e-02f,
  -3.43073010e-02f, 7.07871765e-02f, -7.69557431e-02f, 2.73404345e-02f, 1.17753604e-02f, -9.12322402e-02f, 3.48876454e-02f, 5.17280400e-03f, 2.11698357e-02f, -3.68939154e-02f,
  -9.15364102e-02f, -9.19851940e-03f, -3.27790156e-02f, -8.09941813e-02f, 1.11011311e-03f, -2.22010165e-02f, -2.42922846e-02f, 1.98501572e-02f, 3.34117599e-02f, -2.11673025e-02f,
  4.59489375e-02f, 2.89695803e-02f, 8.31608772e-02f, 4.91241924e-02f, 3.73796672e-02f, -1.18473552e-01f, 1.40822781e-02f, -5.23321982e-03f, 9.27828066e-03f, 4.82014045e-02f,
  -1.17060617e-02f, 5.38119636e-02f, -1.86831672e-02f, -3.03748157e-02f, 4.18074280e-02f, -5.09352423e-02f, -2.76901806e-03f, 6.82999641e-02f, 3.73547785e-02f, -9.37672406e-02f,
  -3.39913994e-01f, -1.51828721e-01f, 9.22081992e-02f, 3.29337083e-02f, -2.27606624e-01f, -1.63221836e-01f, 1.38864219e-01f, -1.22740693e-01f, -2.05445588e-02f, -2.49922983e-02f,
  6.26716614e-02f, -1.95589319e-01f, 2.77462363e-01f, 1.00044184e-03f, -1.83723234e-02f, 3.09854060e-01f, -2.17391312e-01f, -2.28974391e-02f, 4.24825735e-02f, -2.57321715e-01f,
  -6.83489591e-02f, -9.53931063e-02f, 7.43931606e-02f, -1.74085140e-01f, -4.97572236e-02f, -4.93487157e-02f, -4.24730256e-02f, 1.46649867e-01f, -1.02345385e-01f, -5.21920100e-02f,
  -1.53743625e-01f, 2.21434385e-02f, 6.87695891e-02f, 1.04232557e-01f, -1.31801188e-01f, -3.75982262e-02f, -2.73714531e-02f, 1.27062604e-01f, 2.05083992e-02f, 2.39525326e-02f,
  3.86764621e-03f, -1.87302176e-02f, -1.53493388e-02f, 8.09486434e-02f, -3.37606966e-02f, -8.49268772e-03f, 2.64251959e-02f, 3.36746052e-02f, 2.17242930e-02f, 4.44842726e-02f,
  4.54302356e-02f, 3.48685123e-02f, -4.31558713e-02f, -3.00253183e-02f, 3.18139605e-02f, -5.13863303e-02f, -3.00980248e-02f, 2.87855826e-02f, -5.00829518e-02f, -1.14091910e-01f,
  4.55396473e-02f, -1.65351816e-02f, 3.73682305e-02f, 1.21709099e-02f, -2.21184958e-02f, -1.56295970e-02f, -4.05461490e-02f, -1.81671494e-04f, -8.59232098e-02f, -3.30231413e-02f,
  -5.68518117e-02f, 2.42354423e-02f, 2.81894710e-02f, 1.67297162e-02f, -4.85328957e-02f, -1.18536092e-02f, -6.46754866e-03f, 1.58799756e-02f, -8.70556384e-02f, 2.77308635e-02f,
  7.88841769e-02f, -4.80387583e-02f, 2.40866188e-03f, 1.79614574e-02f, 3.83404875e-03f, -5.99174062e-03f, 5.57454042e-02f, 3.27239744e-02f, 6.66053593e-02f, -1.92625634e-02f,
  -2.65986592e-01f, -2.00745925e-01f, -1.22437626e-02f, 4.68802266e-02f, -3.81869152e-02f, -6.42024260e-03f, -3.32150534e-02f, -1.15506006e-02f, -1.27470959e-02f, 2.21628621e-02f,
  8.26254021e-03f, -1.54310837e-02f, -1.32845968e-01f, -1.39763555e-03f, -4.81878370e-02f, -5.00745028e-02f, -4.76449495e-03f, -3.13855149e-02f, -6.29487932e-02f, -5.44141196e-02f,
  4.41199094e-02f, 1.04591362e-02f, -5.37905991e-02f, -9.27266702e-02f, -1.92450490e-02f, -1.61554143e-02f, -8.19732919e-02f, 2.00542118e-02f, 6.25056177e-02f, -6.02718676e-03f,
  5.06948642e-02f, 6.65275473e-03f, 1.33929104e-01f, 2.75107175e-01f, -1.75616056e-01f, -1.89716339e-01f, 1.01616219e-01f, -2.67854273e-01f, 1.62330300e-01f, 2.13663261e-02f,
  -3.61201502e-02f, 1.54305786e-01f, 8.14981833e-02f, 5.55418395e-02f, 1.91812087e-02f, 1.71228439e-01f, -1.02613047e-02f, 6.13997690e-02f, 1.23622017e-02f, 1.96141340e-02f,
  2.26949025e-02f, -1.09000996e-01f, 4.47499081e-02f, -2.40169585e-01f, -1.08978935e-01f, -6.41812608e-02f, -7.10351020e-02f, -4.29198258e-02f, -8.47457349e-02f, 9.95447114e-03f,
  -5.00539951e-02f, 1.35668695e-01f, -3.93171497e-02f, -2.29934938e-02f, 4.24551927e-02f, -4.02269699e-02f, 2.37649921e-02f, 7.50987753e-02f, -5.65892644e-03f, 5.27053922e-02f,
  1.37927476e-02f, -4.77288999e-02f, 3.65177318e-02f, 4.84109623e-03f, -8.15983340e-02f, 1.82231516e-02f, 4.98239808e-02f, -3.00961528e-02f, 1.05368651e-01f, -2.04305863e-03f,
  5.94054461e-02f, -1.84109318e-04f, -1.38800442e-02f, 4.35642973e-02f, 5.67992926e-02f, 2.29798462e-02f, 2.79792752e-02f, -1.70771591e-02f, 2.00568475e-02f, 2.91609783e-02f,
  -3.34216952e-02f, -4.00529914e-02f, 4.19163480e-02f, -8.75932053e-02f, -4.20317389e-02f, 3.77637558e-02f, -9.60613508e-03f, -2.38589626e-02f, 4.59737293e-02f, -2.83667794e-03f,
  -2.65641455e-02f, 5.39432019e-02f, -4.10296349e-03f, -5.27626649e-03f, 2.64549814e-02f, -4.85067023e-03f, 8.05710908e-03f, 3.38129215e-02f, -1.72395520e-02f, -1.81089230e-02f,
  2.07341611e-02f, 1.88878048e-02f, 5.94110321e-03f, 1.83284134e-02f, -8.43533352e-02f, 1.02077678e-01f, -3.88287939e-02f, -9.34230816e-03f, 3.40750106e-02f, -2.61342339e-02f,
  9.52842459e-03f, 9.31173861e-02f, -2.79133627e-03f, 3.75839733e-02f, 3.37669887e-02f, -4.61586453e-02f, 3.91185991e-02f, -8.01755339e-02f, 9.99441557e-03f, 2.75321236e-05f,
  -4.40587336e-03f, 1.55239124e-02f, -1.97859537e-02f, 6.14442956e-03f, 3.06163281e-02f, -1.04898429e-02f, 7.82023668e-02f, 3.37115154e-02f, -3.58379334e-02f, -2.24694703e-02f,
  -4.96184379e-02f, 6.08130954e-02f, -4.46448922e-02f, -5.81983775e-02f, 2.96774600e-02f, 4.72935922e-02f, -8.51146355e-02f, 2.05909126e-02f, -2.89995931e-02f, 4.76002134e-02f,
  -9.08025503e-02f, 1.15708433e-01f, -2.89043099e-01f, 9.13529396e-02f, 4.48305979e-02f, -5.27896434e-02f, -1.11247404e-02f, 1.13106854e-01f, -1.28170013e-01f, 2.60062754e-01f,
  3.82862873e-02f, -1.82804197e-01f, -4.67649177e-02f, 1.50219426e-01f, -8.94019678e-02f, -2.14364022e-01f, 1.52174369e-01f, -7.24909035e-03f, -8.08008015e-02f, 1.11028470e-01f,
  -4.95267175e-02f, 2.90052801e-01f, 6.57573044e-02f, 1.94571033e-01f, 9.95491222e-02f, -3.55003849e-02f, 2.39936098e-01f, -5.35603352e-02f, 1.26825735e-01f, 3.88878179e-05f,
  6.82275742e-02f, 9.19990391e-02f, 3.76318097e-02f, 8.36903416e-03f, 4.14534770e-02f, 1.42703466e-02f, -7.34508634e-02f, -1.09009370e-01f, 1.23411827e-02f, -1.27868876e-02f,
  -1.07347563e-01f, 1.40960822e-02f, -3.85451727e-02f, -4.87984866e-02f, 6.57911897e-02f, -1.47499219e-02f, 1.36607829e-02f, 5.86753041e-02f, -7.21716955e-02f, -5.65202162e-02f,
  -2.96115130e-02f, -1.07952066e-01f, -3.18377875e-02f, -6.32947218e-03f, -8.27939436e-02f, 2.46816110e-02f, -1.71423014e-02f, -5.80148511e-02f, -3.49717848e-02f, -3.30304401e-03f,
  -5.09284846e-02f, 7.65835792e-02f, 4.30948883e-02f, 9.97552462e-03f, 1.92849711e-02f, 3.69062647e-02f, 2.24956460e-02f, 1.76155847e-02f, 2.08817367e-02f, 4.89012934e-02f,
  6.68633208e-02f, 3.34190093e-02f, -9.80850682e-03f, -7.38563528e-03f, 9.23788697e-02f, 3.20762955e-02f, -5.95861450e-02f, -4.93769683e-02f, -2.72168964e-02f, 6.83144405e-02f,
  9.53917019e-03f, 2.20476789e-03f, 4.25313041e-02f, -1.12995626e-02f, -7.79264700e-03f, -4.81571490e-03f, -1.11913159e-02f, -4.42272946e-02f, 2.20026281e-02f, -6.74041212e-02f,
  1.88984081e-01f, 1.88735455e-01f, 2.57535614e-02f, 3.05777304e-02f, 3.95032912e-02f, 3.72123756e-02f, -8.39569345e-02f, -4.85692993e-02f, 2.09866185e-02f, -3.60851437e-02f,
  9.77865513e-03f, 8.20975676e-02f, -2.83141397e-02f, -2.07010414e-02f, 5.37000522e-02f, 1.83371305e-02f, 8.03094450e-03f, -2.35199407e-02f, 1.00621626e-01f, 5.61741479e-02f,
  1.15071103e-01f, -1.70286614e-02f, -3.48189361e-02f, 7.44527653e-02f, -3.21665127e-03f, -2.75002629e-03f, -3.48388851e-02f, -7.34205544e-02f, 4.47128378e-02f, -1.98146179e-02f,
  -8.41380730e-02f, 1.62532747e-01f, 4.76555293e-03f, -2.70153463e-01f, 4.61236686e-02f, 7.99435526e-02f, -1.64527565e-01f, -1.67563166e-02f, -6.12082109e-02f, -1.05265127e-02f,
  -1.51853904e-01f, 2.04689190e-01f, 3.96409631e-03f, -3.18636447e-01f, -2.87993610e-01f, -1.39348492e-01f, -2.28301972e-01f, -6.08761199e-02f, 2.38829814e-02f, -2.02326719e-02f,
  -1.59243718e-01f, -2.67004400e-01f, -1.16484463e-01f, 6.46049157e-03f, 9.18689072e-02f, 1.61801040e-01f, -2.29870796e-01f, 6.09757751e-02f, 3.78603451e-02f, -4.13707979e-02f,
  6.42439798e-02f, -3.99367623e-02f, 7.85351172e-02f, 2.89647421e-03f, -4.49392274e-02f, 3.93239632e-02f, 5.37112216e-03f, -3.30310576e-02f, -5.10332249e-02f, 5.75500503e-02f,
  4.14693542e-02f, 2.41991854e-03f, -5.97274117e-02f, 2.34150626e-02f, -2.31040772e-02f, 3.10980491e-02f, 1.39721781e-02f, 2.46921014e-02f, -8.98202881e-03f, -4.63552633e-03f,
  2.89333258e-02f, 3.65669318e-02f, -4.00669351e-02f, -9.14958119e-02f, 1.72965089e-03f, -6.51386902e-02f, -3.40136588e-02f, -1.59531704e-03f, 3.59568633e-02f, 1.58176792e-03f,
  -5.20569868e-02f, -5.01242280e-02f, -2.00341828e-02f, 2.98391115e-02f, -2.24937256e-02f, 1.10145984e-02f, 3.03076748e-02f, -8.21516663e-03f, 1.64102670e-02f, -2.86018960e-02f,
  -1.93300825e-02f, -1.90719292e-02f, -3.92318740e-02f, 6.47268351e-03f, -1.27620064e-02f, 7.55575486e-03f, -5.81995286e-02f, 4.37072217e-02f, -2.88855657e-02f, -1.60078518e-03f,
  -1.95778105e-02f, -5.22151031e-03f, 8.83298442e-02f, 2.22428683e-02f, 5.30603807e-03f, 6.60871528e-03f, -4.39268551e-05f, 2.41073873e-02f, 1.30478805e-02f, -4.83891033e-02f,
  -9.12661031e-02f, -2.16563076e-01f, -1.72142778e-02f, 3.02922893e-02f, 7.99435526e-02f, 1.57609805e-02f, -6.36090040e-02f, 3.21519822e-02f, -1.62637718e-02f, 2.77340319e-03f,
  -1.26784267e-02f, 2.47162394e-02f, 3.32921185e-02f, 2.97298972e-02f, -2.85171866e-02f, -3.28503326e-02f, -1.07205801e-01f, -1.64266806e-02f, -1.02186002e-01f, 1.28006842e-03f,
  1.49417091e-02f, 4.08965982e-02f, -4.73931152e-03f, 3.41459066e-02f, 1.31256804e-02f, -7.95452762e-03f, 5.63994721e-02f, 2.83202268e-02f, 2.29111891e-02f, -1.20576825e-02f,
  -4.45464514e-02f, -3.55168790e-01f, 6.86569884e-02f, 8.75046551e-02f, 1.02060497e-01f, -1.86185867e-01f, -1.65058617e-02f, -9.95035991e-02f, -8.68512541e-02f, -2.94243872e-01f,
  -5.03852889e-02f, 6.25668764e-02f, -7.68746883e-02f, -1.79165766e-01f, 1.06964119e-01f, -5.39441258e-02f, -9.61580575e-02f, -1.63480356e-01f, 6.29836991e-02f, -1.32418752e-01f,
  5.80427311e-02f, -9.16800499e-02f, 1.66414663e-01f, -4.92365137e-02f, 6.41702712e-02f, 3.82806845e-02f, 1.03740450e-02f, 1.11417778e-01f, -3.16313878e-02f, 1.11679211e-01f,
  -7.76693448e-02f, -1.08790755e-01f, 8.75722524e-03f, 3.18957716e-02f, -5.37068918e-02f, 6.07499368e-02f, 2.43423749e-02f, 3.50437090e-02f, 6.25801906e-02f, -3.26368995e-02f,
  -3.13525833e-02f, 1.21708931e-02f, 1.76193044e-02f, -1.05864322e-02f, -1.64545681e-02f, -2.94346586e-02f, 2.83122640e-02f, 1.93746369e-02f, 2.01109927e-02f, 1.15345381e-01f,
  5.33350334e-02f, 1.58300363e-02f, 4.45883498e-02f, 1.75002832e-02f, 1.12798080e-01f, -3.02551780e-02f, 5.88109307e-02f, 1.70465522e-02f, 5.02456818e-03f, -5.94660826e-03f,
  -9.74249467e-02f, 7.79569745e-02f, 1.05412684e-01f, 2.75632236e-02f, 1.25444345e-02f, 6.44301102e-02f, -1.39165688e-02f, 8.82788822e-02f, 4.49095070e-02f, -1.15917763e-02f,
  -2.97340821e-03f, 1.11785240e-01f, 2.69561037e-02f, -1.25630889e-02f, 6.93986863e-02f, -2.08932231e-03f, -8.63114372e-03f, 5.83583601e-02f, -2.93744281e-02f, 7.73306862e-02f,
  1.21157954e-03f, -3.82657200e-02f, -1.35260358e-01f, 2.82383617e-02f, -8.12987834e-02f, -4.21006436e-04f, 1.03454767e-02f, 1.25816641e-02f, -3.91897708e-02f, 9.53801647e-02f,
  -2.03813761e-01f, -3.72423619e-01f, 6.82620481e-02f, 2.26065386e-02f, -7.19761923e-02f, -2.23869067e-02f, 2.86546838e-03f, -2.58732345e-02f, -1.02144629e-01f, -2.15984918e-02f,
  7.45360833e-03f, 4.15266119e-02f, -4.59042490e-02f, -3.78817394e-02f, -3.12143695e-02f, -9.08092409e-03f, -1.04208244e-02f, -6.21049181e-02f, 1.44889215e-02f, -1.58465710e-02f,
  -7.72001315e-03f, -8.84202719e-02f, 4.79072295e-02f, 9.95281115e-02f, 5.68348691e-02f, 3.45633961e-02f, -5.52615412e-02f, -6.61279336e-02f, 7.21090510e-02f, -4.44602296e-02f,
  -1.57984242e-01f, 1.03922635e-01f, -1.93273053e-01f, -7.06160218e-02f, 1.47546977e-01f, -2.65353382e-01f, -1.45945936e-01f, 1.00595951e-01f, -1.82028428e-01f, 2.17881188e-01f,
  8.93051084e-03f, -1.27560779e-01f, 7.63185173e-02f, -1.54534191e-01f, -1.85744718e-01f, -8.76415297e-02f, -1.22307412e-01f, -7.38242418e-02f, -7.09569454e-02f, 1.65602818e-01f,
  -4.24119458e-02f, 8.08088481e-02f, -1.81176364e-01f, 3.74593474e-02f, 7.45388865e-02f, -2.65848264e-02f, 2.95005977e-01f, -9.88987274e-03f, 2.07053013e-02f, -4.76133414e-02f,
  -1.30867496e-01f, 2.12841425e-02f, -3.85636985e-02f, -6.12313561e-02f, 3.06313280e-02f, 2.61552669e-02f, -3.33422385e-02f, -1.30154910e-02f, -2.88585424e-02f, -2.84455740e-03f,
  2.58863010e-02f, -6.28819838e-02f, -4.19791490e-02f, 2.97428817e-02f, 5.21384878e-03f, -4.07255925e-02f, -5.38066924e-02f, -1.22078732e-01f, -4.30948921e-02f, -1.10015646e-02f,
  -5.97936474e-02f, 1.10988701e-02f, 4.99164388e-02f, -1.22090830e-02f, -2.50767823e-02f, -5.44522479e-02f, -5.01424298e-02f, -1.39538972e-02f, -3.79977822e-02f, -5.57046570e-02f,
  5.04942387e-02f, 9.58047155e-03f, 4.34899591e-02f, -4.95989472e-02f, -7.61380419e-02f, 4.01249388e-03f, -3.69218625e-02f, 4.67269570e-02f, -2.73522474e-02f, 1.67415012e-02f,
  1.15967374e-02f, -1.24501456e-02f, -1.71416346e-02f, 9.91266314e-03f, -4.25103679e-03f, -2.04952154e-02f, -2.18541473e-02f, 6.38682991e-02f, -4.91638295e-02f, -8.58331397e-02f,
  -1.42255034e-02f, 3.98495607e-02f, -3.55308764e-02f, 6.07348755e-02f, 1.18521915e-03f, 3.68903438e-03f, 7.99100008e-03f, -3.20964903e-02f, -3.20347473e-02f, 2.53150743e-02f,
  5.25619239e-02f, 1.84056357e-01f, 6.70172647e-03f, -4.26264713e-04f, -1.81370955e-02f, -4.74584363e-02f, -6.55416846e-02f, 5.21411970e-02f, -1.86068136e-02f, -2.98158415e-02f,
  3.79955173e-02f, 4.96668480e-02f, 2.31395997e-02f, -1.17311114e-02f, -3.12023889e-03f, -1.03818988e-02f, 8.44861045e-02f, 1.10914642e-02f, 7.43980333e-02f, -3.84507887e-02f,
  8.97542238e-02f, 2.84994915e-02f, -7.12707266e-02f, -2.74669454e-02f, -1.43723981e-02f, 3.44180241e-02f, -2.69082263e-02f, -1.78113242e-03f, 5.85854352e-02f, 3.42255160e-02f,
  -2.97300369e-01f, 1.07566990e-01f, -1.10938385e-01f, -4.57508443e-03f, -1.23976536e-01f, -2.30798274e-01f, -2.12907597e-01f, 9.37847327e-03f, 1.70313782e-04f, 2.62304097e-01f,
  7.21718371e-02f, -8.90288353e-02f, 1.73381820e-01f, -4.69998159e-02f, -4.25486594e-01f, 3.92246693e-02f, 3.16089839e-02f, 2.44127326e-02f, 5.96351624e-02f, 9.58291516e-02f,
  6.46394417e-02f, 7.58255720e-02f, -1.00617163e-01f, -2.23312853e-03f, -9.49423313e-02f, 1.94515213e-02f, 9.61012244e-02f, -1.80311933e-01f, -2.18478572e-02f, -8.80092010e-02f,
  -1.14102751e-01f, 1.29009917e-01f, -2.69831400e-02f, -5.72726578e-02f, -4.48239669e-02f, 6.09458657e-03f, 3.82472365e-03f, -8.16880390e-02f, -6.02636263e-02f, 2.20461003e-02f,
  1.75515246e-02f, -1.85870868e-03f, 6.51148409e-02f, -5.18899895e-02f, -2.42163949e-02f, -1.74965411e-02f, -4.73451056e-02f, 5.45079075e-02f, -1.42657822e-02f, -3.81593592e-02f,
  -8.70290585e-03f, -2.95880809e-02f, 5.05684391e-02f, -1.23230787e-02f, -3.85227017e-02f, -7.30084546e-04f, 9.61460844e-02f, -4.64408137e-02f, 1.53227225e-02f, -4.24545668e-02f,
  -7.70570186e-04f, -3.36824618e-02f, 3.80820818e-02f, -9.79425968e-04f, 3.68352570e-02f, -1.10288486e-02f, 3.58037725e-02f, 2.52235420e-02f, -5.93275130e-02f, 3.80498320e-02f,
  2.87121460e-02f, 2.70155463e-02f, 7.98806641e-03f, 5.23238108e-02f, 5.43130897e-02f, 1.11541077e-01f, 4.96660999e-04f, 5.06935874e-04f, 6.32906035e-02f, 2.33375514e-03f,
  -4.70539108e-02f, -4.55215313e-02f, -3.50161269e-02f, 9.06165913e-02f, 2.21526735e-02f, -1.93666462e-02f, -9.98097751e-03f, 3.42135094e-02f, 2.27262545e-02f, -3.86680588e-02f,
  6.35387599e-02f, 2.19633475e-01f, 6.52220249e-02f, 1.57209616e-02f, -5.27263060e-02f, 1.61477048e-02f, -9.40103531e-02f, -2.69197039e-02f, 5.62264472e-02f, 5.86646027e-04f,
  4.55572940e-02f, 1.63233504e-02f, 1.94763467e-02f, -5.38755320e-02f, -6.84710443e-02f, 5.30678779e-02f, 5.72695546e-02f, 5.14458194e-02f, 4.72687557e-02f, 6.14370219e-02f,
  6.12454116e-02f, 3.90686542e-02f, -8.17918330e-02f, 5.47726080e-02f, 4.49159853e-02f, 1.11222966e-02f, -1.18344056e-03f, 1.96416825e-02f, 3.11238859e-02f, 1.38522309e-05f,
  -3.18953931e-01f, 1.71830535e-01f, 2.41462022e-01f, -8.04634988e-02f, 2.68678889e-02f, -1.18392549e-01f, -1.62767887e-01f, -7.81736001e-02f, -2.24810019e-01f, 7.17805373e-03f,
  -2.09524721e-01f, 9.90279242e-02f, 1.50008157e-01f, -2.38393202e-01f, -2.45666698e-01f, -8.36425647e-02f, -2.31583476e-01f, 2.15551872e-02f, -8.57432559e-02f, 2.73984727e-02f,
  -6.21240065e-02f, -2.40278944e-01f, 1.19783998e-01f, -7.15091005e-02f, -4.38737571e-02f, 1.26410797e-01f, 9.33508798e-02f, 1.01158887e-01f, -4.40492481e-02f, 6.57943543e-03f,
  -2.21572742e-02f, 4.08527814e-02f, -3.23633142e-02f, 3.15598361e-02f, 7.00170845e-02f, 2.01971605e-02f, 1.44865736e-01f, 5.92143908e-02f, -1.23058669e-02f, -1.65120885e-02f,
  9.46493372e-02f, -1.34818656e-02f, -3.02202702e-02f, -3.61149423e-02f, -9.73060131e-02f, 3.88106368e-02f, 3.81433778e-02f, -1.29640307e-02f, -1.41716469e-02f, -2.27112751e-02f,
  8.71709138e-02f, 2.18039695e-02f, 1.57303326e-02f, 9.90895741e-03f, 1.17266826e-01f, -9.50846914e-03f, 8.28959718e-02f, 1.19211689e-01f, -3.94597389e-02f, -5.91868311e-02f,
  -3.31581682e-02f, -2.10063718e-02f, 4.16571870e-02f, -6.29930496e-02f, 4.02827887e-03f, -8.07929486e-02f, -1.12597816e-01f, -6.36874959e-02f, -4.49123420e-03f, -2.92373449e-02f,
  -1.06942169e-02f, -4.41958010e-03f, -2.16324218e-02f, 1.43552362e-03f, -2.75491420e-02f, -2.03487054e-02f, 6.35804832e-02f, 4.48150001e-02f, 3.42682414e-02f, -3.48305237e-03f,
  2.25694813e-02f, -2.34715901e-02f, 7.56060556e-02f, -2.60059908e-03f, -3.83081660e-02f, 8.44109990e-03f, -5.52580282e-02f, -6.46650568e-02f, 1.41179804e-02f, 3.74633744e-02f,
  -1.81560107e-02f, 1.08816989e-01f, 2.44958568e-02f, -4.03678641e-02f, 1.10491179e-01f, 7.35222846e-02f, -5.77390753e-02f, -3.89654823e-02f, 2.32149884e-02f, -1.60433073e-02f,
  1.13499418e-01f, 6.85710683e-02f, -1.55385612e-02f, -2.39267722e-02f, -4.93820049e-02f, -1.38272969e-02f, 6.59364536e-02f, 9.86623019e-03f, -3.60340849e-02f, -3.18469517e-02f,
  1.01011157e-01f, 5.97234219e-02f, -1.25209037e-02f, 4.03580330e-02f, -1.14184543e-02f, 5.38206175e-02f, -2.18847450e-02f, -5.37168495e-02f, -5.50500266e-02f, -9.38091706e-03f,
  5.82396448e-01f, 7.42107928e-02f, 1.52163357e-01f, 1.38460159e-01f, -2.51632556e-02f, -2.34710902e-01f, 2.84311976e-02f, -1.14169419e-01f, 1.90874591e-01f, -1.66173339e-01f,
  -9.85832214e-02f, 2.01472357e-01f, 6.76089227e-02f, -1.97035789e-01f, 3.10087621e-01f, 9.16068628e-02f, 1.86328813e-02f, -1.06008947e-02f, 7.99103975e-02f, 1.78571977e-02f,
  1.27084240e-01f, -1.86542362e-01f, -1.65461516e-03f, -2.19164282e-01f, -6.26342297e-02f, 7.35448115e-03f, -1.12321349e-02f, -2.70777065e-02f, -1.85215235e-01f, 1.48978056e-02f,
  -4.26014997e-02f, -1.74003355e-02f, 2.22135149e-02f, 2.34820992e-02f, -2.68501025e-02f, 1.57729387e-02f, -2.88556796e-02f, -2.61879526e-03f, -7.34434603e-03f, 3.42584886e-02f,
  5.20728007e-02f, 2.74971444e-02f, -2.92346682e-02f, 5.17641120e-02f, 2.24602222e-03f, -2.16709021e-02f, -1.92442033e-02f, -4.95275334e-02f, -4.78788055e-02f, 3.18467133e-02f,
  2.96643120e-03f, -1.16182845e-02f, -2.52459310e-02f, 5.47816604e-02f, -1.09759467e-02f, 1.91890690e-02f, 4.43568192e-02f, -1.29850330e-02f, 3.65461856e-02f, 9.28358175e-03f,
  3.85367535e-02f, 8.23796764e-02f, -7.22556747e-03f, -1.29638026e-02f, 2.49497462e-02f, -7.26964846e-02f, 3.58500821e-03f, -2.29464229e-02f, 8.26187655e-02f, 1.44862588e-02f,
  3.78398821e-02f, 4.97353114e-02f, -3.13336290e-02f, 5.85534461e-02f, 4.24285121e-02f, 8.44915025e-03f, 3.73868495e-02f, 1.16637433e-02f, 7.39829964e-04f, 2.88937874e-02f,
  -3.48604401e-03f, 5.53239025e-02f, -4.66625728e-02f, -2.29565892e-02f, -3.52308527e-02f, 3.87245528e-02f, -4.46403548e-02f, 1.38150919e-02f, -3.34241837e-02f, 5.86966500e-02f,
  -7.21117705e-02f, 8.51803869e-02f, -6.11273646e-02f, 3.16646788e-03f, -6.47297187e-04f, 1.11278407e-02f, 1.06770797e-02f, 2.36299057e-02f, 4.28300202e-02f, 6.91555208e-03f,
  6.30791124e-04f, -3.73886246e-03f, -3.27604706e-03f, -4.35724929e-02f, -2.47881021e-02f, -4.30927537e-02f, 7.07677528e-02f, 2.47909036e-02f, 3.38871814e-02f, -3.52510437e-02f,
  -3.25530022e-03f, -2.71903519e-02f, 2.35457476e-02f, -1.62434764e-02f, -4.51402292e-02f, -5.94237298e-02f, -2.11513489e-02f, 1.50391152e-02f, 3.69712114e-02f, -1.47238532e-02f,
  -3.36366743e-01f, -3.35666887e-03f, -2.32502714e-01f, -3.08486134e-01f, 1.21130683e-01f, 4.18479554e-03f, -2.11303547e-01f, -3.28515954e-02f, -2.60237426e-01f, 2.97120288e-02f,
  1.94229469e-01f, -2.18545601e-01f, 1.09264985e-01f, 4.25685495e-02f, -1.07802585e-01f, 8.12273845e-02f, -1.46943495e-01f, -1.59655184e-01f, 4.99752760e-02f, -8.58505145e-02f,
  -7.52128437e-02f, 2.39267215e-01f, 1.73915949e-04f, 1.78875178e-01f, -2.59195734e-02f, -1.32538721e-01f, 5.07139340e-02f, 7.36749321e-02f, -2.02918854e-02f, 4.10006121e-02f,
  4.45222668e-02f, 1.40833650e-02f, -1.25205845e-01f, -1.33987099e-01f, -9.31414068e-02f, -3.93735431e-02f, -7.94568434e-02f, 2.15197075e-02f, -1.46488659e-02f, -7.26374518e-03f,
  -1.02934148e-03f, 3.39480788e-02f, -4.05345373e-02f, -2.00839192e-02f, -7.73459747e-02f, -4.23496664e-02f, 3.23349088e-02f, -1.36009958e-02f, -1.91602635e-03f, 2.77055148e-02f,
  2.90110447e-02f, 7.06082489e-03f, -4.94165123e-02f, -1.05612077e-01f, -9.17445049e-02f, -1.88087840e-02f, -8.22708979e-02f, -2.87297368e-02f, -2.45454274e-02f, -3.77161354e-02f,
  5.54037355e-02f, -2.53969319e-02f, -1.60649735e-02f, 1.19310478e-02f, 4.21484523e-02f, 3.70801203e-02f, 2.86257658e-02f, -1.32542681e-02f, -1.16430074e-01f, -4.81632492e-03f,
  -4.98951040e-03f, -1.18650962e-03f, -1.14974976e-02f, -6.19216450e-02f, 1.27622811e-02f, -4.03224267e-02f, 1.97373126e-02f, -1.51144825e-02f, -5.31662256e-02f, -2.04034485e-02f,
  -5.24015957e-03f, 6.79610483e-03f, 5.51193301e-03f, -1.41175948e-02f, 4.26940098e-02f, 4.42195684e-02f, -3.69417705e-02f, -4.83384393e-02f, 1.18726872e-01f, -1.71663929e-02f,
  4.57780287e-02f, -1.25864819e-01f, -1.67696010e-02f, 3.58643420e-02f, 2.12296862e-02f, 2.67002713e-02f, 5.26075400e-02f, -3.14077325e-02f, -1.69913713e-02f, 3.19090784e-02f,
  -2.16991808e-02f, -8.84879977e-02f, -1.30217848e-02f, 2.07249522e-02f, -5.60159311e-02f, 1.06979441e-03f, -1.12794833e-02f, -4.80845459e-02f, -1.08499445e-01f, 3.27054486e-02f,
  -5.01927249e-02f, 2.36387607e-02f, -2.01080497e-02f, 1.76805798e-02f, -5.80813885e-02f, 1.64403338e-02f, -4.81019244e-02f, -4.30696197e-02f, 3.96861322e-03f, -2.66358163e-02f,
  3.59293640e-01f, -1.13939419e-01f, -1.91073403e-01f, 2.42766738e-01f, 2.11450666e-01f, -8.73145536e-02f, 1.04338862e-01f, 1.19867429e-01f, 1.42593578e-01f, -2.04459965e-01f,
  4.42444123e-02f, -1.91363513e-01f, -6.44597858e-02f, -3.91835682e-02f, 2.51937151e-01f, -1.02683589e-01f, 1.42766565e-01f, -6.21527433e-02f, 2.03771777e-02f, 1.24982014e-01f,
  -4.00166865e-03f, 1.42497122e-01f, -1.19207501e-01f, -9.17994455e-02f, 6.44055977e-02f, 7.46893231e-03f, 1.26136273e-01f, -1.05959162e-01f, -6.29532412e-02f, 1.43351987e-01f,
  5.22323772e-02f, -2.32792068e-02f, -5.78277037e-02f, -6.97308034e-02f, 9.00966898e-02f, -3.74443457e-02f, -2.65022013e-02f, 1.07723856e-02f, 2.16919626e-03f, 6.43791705e-02f,
  2.22600102e-02f, -4.17663679e-02f, 5.49182706e-02f, -9.53553841e-02f, 3.44434939e-02f, -2.71188784e-02f, -7.26275668e-02f, -3.29107828e-02f, -6.05197400e-02f, -1.06611505e-01f,
  -1.71899304e-01f, -3.19079123e-02f, -5.57378456e-02f, -5.25683574e-02f, 6.95558190e-02f, -3.88051718e-02f, -5.34292907e-02f, 2.65947077e-02f, 1.45980786e-03f, 4.72153574e-02f,
  -3.76324840e-02f, 3.38494368e-02f, 3.54859536e-03f, 2.41702590e-02f, -1.10044237e-02f, 1.91296097e-02f, 8.98643397e-03f, -1.12257721e-02f, -3.40103395e-02f, -4.32565138e-02f,
  7.07103983e-02f, 5.15250079e-02f, 3.15516279e-03f, -4.78749163e-02f, 3.48620582e-03f, 9.73520149e-03f, -7.28767216e-02f, 2.82882471e-02f, 2.37267837e-02f, 3.66632007e-02f,
  2.22540251e-03f, -2.31494959e-02f, 3.45272347e-02f, 2.58507635e-02f, 2.34052520e-02f, -4.42289049e-03f, -8.44346359e-02f, -1.04813263e-01f, 6.58431202e-02f, 4.26190235e-02f,
  6.60133436e-02f, 1.45935312e-01f, 3.43821272e-02f, -2.74872687e-02f, 4.07191105e-02f, -5.50995581e-02f, 1.43905694e-03f, -2.09820569e-02f, 8.42376649e-02f, 7.50085190e-02f,
  -7.48131275e-02f, 4.19881009e-03f, 3.90248559e-02f, -4.91096228e-02f, -1.06440708e-01f, 1.03495130e-02f, 5.73162623e-02f, 1.33010084e-02f, 1.12331674e-01f, -4.20114100e-02f,
  1.75307121e-03f, 7.37248659e-02f, -1.01502337e-01f, 4.22212481e-02f, -2.75407103e-03f, -3.25180292e-02f, 8.23061913e-02f, -8.96908790e-02f, 5.95620312e-02f, -6.13839962e-02f,
  -2.79182553e-01f, 2.50402719e-01f, 1.33554414e-01f, -2.66870141e-01f, -4.66504060e-02f, 2.48910204e-01f, 5.15372790e-02f, 2.34027393e-02f, -2.02203825e-01f, 2.26837337e-01f,
  -1.40874237e-01f, 3.46183665e-02f, -8.54945183e-02f, -9.04263258e-02f, -4.86647666e-01f, -1.10414669e-01f, -2.03264445e-01f, -1.20479790e-02f, -1.38315290e-01f, 2.59969127e-03f,
  -1.46116316e-01f, -1.64000005e-01f, -9.03841779e-02f, 4.43311185e-02f, 1.23197637e-01f, 1.02926075e-01f, -7.86461234e-02f, 1.66338697e-01f, 2.07534153e-02f, 6.57915100e-02f,
  3.08827367e-02f, -3.94364484e-02f, -1.66958911e-04f, 5.47355078e-02f, -5.71313407e-03f, 4.67066728e-02f, 7.75836501e-03f, -4.31882516e-02f, -7.45239407e-02f, -4.20213453e-02f,
  -1.69968710e-03f, -3.45195420e-02f, -2.10438482e-02f, -5.75680956e-02f, 2.28720671e-03f, -2.57888883e-02f, 2.70963125e-02f, 5.76237775e-02f, 2.67440192e-02f, 4.86542631e-05f,
  -1.99532527e-02f, -2.75448915e-02f, -1.27188377e-02f, 3.04922811e-04f, 9.16487444e-03f, 8.96650925e-03f, 2.62409579e-02f, 1.86856017e-02f, 3.49402539e-02f, -1.40492609e-02f,
  6.14944054e-03f, -1.88893862e-02f, 1.58410985e-02f, -3.92654492e-03f, 1.79589931e-02f, -1.25653958e-02f, -3.97582352e-02f, 1.15945265e-02f, -7.35174678e-03f, -3.19457799e-02f,
  -2.20244774e-03f, -3.78208384e-02f, -2.03606393e-02f, -3.61397639e-02f, -1.82807236e-03f, 1.49554750e-02f, -1.41572487e-02f, 3.09463628e-02f, -6.27815723e-02f, 3.28181237e-02f,
  -1.77195854e-02f, -3.32985297e-02f, 4.24228497e-02f, 3.49733531e-02f, 1.71894711e-02f, -2.62686070e-02f, -5.33877388e-02f, 4.44785692e-02f, -1.28779775e-02f, -1.03955055e-02f,
  -2.74305567e-02f, 5.12896106e-02f, 3.02478652e-02f, 2.57876273e-02f, 3.94176766e-02f, -8.96046869e-03f, -7.97447283e-03f, 3.37997116e-02f, 4.71245907e-02f, 2.52771471e-02f,
  4.50395746e-03f, 3.31865810e-02f, 9.08516422e-02f, -8.47330540e-02f, -4.00302783e-02f, 2.31998097e-02f, 7.78560713e-02f, 1.91642344e-02f, 3.23762372e-02f, -2.70280634e-05f,
  5.47669344e-02f, 4.24714983e-02f, -1.74992494e-02f, 6.54302984e-02f, -2.92038769e-02f, 6.93095922e-02f, -4.18566726e-03f, -1.57530978e-02f, 4.15643584e-03f, 2.36899443e-02f,
  9.07186046e-02f, -1.52095616e-01f, -1.43018395e-01f, -1.42572820e-01f, 5.82800806e-02f, -3.78491342e-01f, -3.36444706e-01f, 6.27567247e-02f, -1.46739110e-01f, -5.98472208e-02f,
  -4.23622923e-03f, -9.85928401e-02f, -5.39207598e-03f, -2.38071501e-01f, 2.16621393e-03f, -5.40501997e-02f, -2.45449513e-01f, -1.01855673e-01f, -8.18257313e-03f, 5.16942479e-02f,
  2.26310790e-02f, -8.25507287e-03f, -1.07831247e-01f, 9.48969945e-02f, -1.14787854e-01f, 6.20996393e-02f, 1.44562364e-01f, 1.75318003e-01f, -1.00102961e-01f, 2.46382337e-02f,
  1.27862114e-02f, 1.74991667e-01f, -9.06975195e-02f, -1.82152726e-02f, 3.74216102e-02f, -3.05701587e-02f, -6.37734234e-02f, 3.38304378e-02f, 2.45046429e-02f, -5.49399517e-02f,
  -1.09055758e-01f, 3.77165154e-02f, -2.71788538e-02f, -6.55464530e-02f, -7.69807175e-02f, -1.64714288e-02f, -3.85490917e-02f, -1.21720225e-01f, -6.17272295e-02f, -1.03397518e-02f,
  -1.42014429e-01f, -8.03684816e-02f, -1.00434095e-01f, -6.83530234e-04f, 6.23671822e-02f, -4.49397005e-02f, -3.18181664e-02f, -4.89891181e-03f, -1.37293003e-02f, 2.35566683e-03f,
  -2.68258573e-03f, -1.38299828e-02f, 1.01795944e-04f, -5.97867407e-02f, 7.63136335e-03f, 1.04339622e-01f, -9.79794785e-02f, 7.43948147e-02f, 1.39341839e-02f, 5.61508238e-02f,
  7.98183959e-03f, 1.69628188e-02f, 2.10725963e-02f, -7.83957690e-02f, 2.31976993e-02f, -1.71822160e-02f, 7.05622442e-05f, 1.76223572e-02f, -5.51426969e-02f, -2.28247959e-02f,
  2.69809715e-03f, -1.53179033e-04f, -5.80002032e-02f, -4.44856100e-03f, 2.46658288e-02f, 3.11516467e-02f, -5.81271155e-03f, -2.18299776e-02f, -2.36604717e-02f, 1.28393201e-02f,
  2.67200917e-02f, 2.20645979e-01f, 4.89919297e-02f, 1.61534338e-03f, 3.02594732e-02f, 1.10367201e-02f, -4.42633331e-02f, 8.40172842e-02f, 1.72579177e-02f, 9.97338723e-03f,
  5.87541461e-02f, -8.63213092e-03f, 6.31007627e-02f, -2.87193023e-02f, -1.49521418e-02f, 3.02971974e-02f, 1.35174934e-02f, 1.95181426e-02f, -5.19124493e-02f, 3.40587795e-02f,
  3.63302939e-02f, 2.23301072e-02f, 3.95880640e-02f, 1.82864591e-02f, 3.84182744e-02f, 2.23406386e-02f, -4.02626814e-03f, 1.02608707e-02f, 7.06054121e-02f, 2.75213663e-02f,
  6.43545270e-01f, 1.66881949e-01f, 1.59860596e-01f, 1.85921639e-01f, -3.45031694e-02f, 1.05026513e-01f, 1.72773048e-01f, 3.61947045e-02f, 4.06409413e-01f, -1.92783549e-02f,
  -1.09550543e-01f, 1.14592187e-01f, 1.39522916e-02f, -3.98552557e-03f, -1.96958818e-02f, 3.62397432e-02f, 3.45584787e-02f, 1.74919125e-02f, -5.53367900e-05f, -4.80991900e-02f,
  7.15269074e-02f, -2.35330313e-01f, -1.21531703e-01f, -2.06240967e-01f, 6.15016073e-02f, 3.15238759e-02f, -1.78972706e-01f, -1.39754057e-01f, -2.20522359e-01f, -1.24963336e-01f,
  9.21685831e-04f, 6.72976598e-02f, 2.67419964e-02f, 7.87653252e-02f, 2.61137448e-02f, 1.86403617e-02f, 1.51428049e-02f, -1.67311858e-02f, 4.95716929e-02f, -3.07692075e-03f,
  1.59712248e-02f, 6.04710281e-02f, -3.04411463e-02f, 2.53506121e-03f, 9.15138796e-02f, 4.87274937e-02f, 4.20392789e-02f, 4.55809422e-02f, 5.07650059e-03f, -3.56230186e-03f,
  -1.55938845e-02f, 2.96563897e-02f, 1.90143976e-02f, -1.59082357e-02f, -1.82870764e-03f, 8.84687752e-02f, 2.81379912e-02f, -4.50475328e-02f, -1.34087782e-02f, 5.05013019e-02f,
  7.39944428e-02f, -2.13537868e-02f, -1.16281603e-02f, 1.84760932e-02f, -2.24080831e-02f, -2.42439751e-02f, -5.04570752e-02f, -5.72658032e-02f, -5.88060636e-03f, 2.39785407e-02f,
  7.56644737e-03f, 1.39579875e-02f, -1.61204502e-04f, 1.04690336e-01f, -1.28573179e-02f, -1.66480783e-02f, -9.94555838e-03f, -6.74669296e-02f, 6.45781532e-02f, -5.39726056e-02f,
  4.52975137e-03f, -2.36195773e-02f, -2.86146738e-02f, -3.82885598e-02f, -3.70308873e-03f, 2.57818345e-02f, 1.17142312e-03f, 2.23583505e-02f, -4.85639162e-02f, -2.41210666e-02f,
  -2.11584233e-02f, -5.65371551e-02f, 3.29036601e-02f, 4.78431862e-03f, -3.76426019e-02f, -1.64084453e-02f, 6.41332343e-02f, -3.04738469e-02f, 2.61788182e-02f, -3.23380008e-02f,
  6.70120679e-03f, 1.38444928e-02f, -7.29232058e-02f, -4.64487523e-02f, -1.16024734e-02f, 1.88307706e-02f, -6.59476891e-02f, 3.00916191e-02f, -4.80883755e-03f, -3.23253237e-02f,
  6.56336220e-03f, -8.96699075e-03f, 9.62954294e-03f, 2.67286156e-03f, -3.60575281e-02f, -8.35523456e-02f, 5.16837556e-03f, 6.96863532e-02f, -8.33322778e-02f, 2.46340856e-02f,
  -1.02657534e-01f, -6.71301782e-02f, -2.56810904e-01f, -2.60934532e-01f, -1.02143884e-01f, 2.65765905e-01f, 2.90918022e-01f, -1.31755844e-01f, -1.03441380e-01f, 2.04969615e-01f,
  6.96266443e-02f, 8.35849158e-03f, 1.83405608e-01f, -6.13611341e-02f, 3.67209427e-02f, 1.68787941e-01f, -7.48860911e-02f, -9.57484990e-02f, -5.64245507e-02f, -1.10077098e-01f,
  -9.01327208e-02f, -3.63147259e-03f, -1.14339374e-01f, -2.33357936e-01f, -1.60583839e-01f, -1.15138814e-01f, -2.32872572e-02f, 3.20991687e-02f, -8.71940106e-02f, 3.69993858e-02f,
  9.62678790e-02f, 8.49023741e-03f, -1.56860743e-02f, -1.64943524e-02f, 2.35062279e-02f, 7.99719095e-02f, 4.51025814e-02f, 5.56148440e-02f, 3.13274153e-02f, 7.44645819e-02f,
  5.37194982e-02f, 3.83203290e-02f, 2.12114677e-02f, -1.54942088e-02f, 1.83599014e-02f, -8.41841027e-02f, -4.24492098e-02f, 6.14685100e-03f, -9.91322100e-02f, 8.69094208e-03f,
  -1.70394946e-02f, 1.13400100e-02f, -3.42281610e-02f, 8.99383798e-02f, -8.94467533e-03f, 8.27397406e-03f, 3.84641401e-02f, 5.00556193e-02f, 2.15617437e-02f, -1.30271181e-01f,
  6.49507418e-02f, -2.71273293e-02f, -1.40145319e-02f, -4.43872586e-02f, 2.80607902e-02f, -2.07407549e-02f, 3.07507180e-02f, 8.53345320e-02f, -1.30354073e-02f, 3.97368520e-02f,
  -1.20546492e-02f, -6.78849965e-02f, -5.56185879e-02f, -8.71002525e-02f, -1.07048284e-02f, 4.97868918e-02f, 1.09799607e-02f, -1.63530037e-02f, -3.18058319e-02f, -7.77145326e-02f,
  4.62127756e-03f, 2.24858802e-02f, -4.22557406e-02f, 1.44776218e-02f, 4.06756848e-02f, 1.16378360e-03f, -7.95812756e-02f, -1.26378611e-02f, -1.20658902e-02f, -4.06578928e-02f,
  5.21162413e-02f, -6.01917580e-02f, -2.42717681e-03f, -1.65390745e-02f, 1.61263011e-02f, -1.36262237e-03f, -5.39368950e-03f, -1.06548294e-01f, 1.74632464e-02f, -1.49634518e-02f,
  6.64025396e-02f, 2.51517743e-02f, -1.10105537e-02f, 1.05853993e-02f, 2.27213353e-02f, -1.45812947e-02f, 2.64852513e-02f, 1.51921902e-02f, -7.16033280e-02f, -3.86091694e-02f,
  -1.78374443e-02f, 6.27309456e-02f, 6.17491044e-02f, 2.19761450e-02f, 7.12060407e-02f, 6.43586442e-02f, 3.97505797e-03f, -5.76739246e-03f, 1.21050049e-02f, 2.45752372e-02f,
  1.00463383e-01f, -1.39983371e-01f, -2.84567140e-02f, 2.19618618e-01f, 1.31631568e-01f, -2.43472502e-01f, -4.20099087e-02f, 1.42057985e-01f, -4.21989784e-02f, -1.13131098e-01f,
  -6.12020073e-03f, -8.08375999e-02f, -2.24179134e-01f, 8.59786049e-02f, -1.67552799e-01f, -2.61047781e-01f, 8.94381925e-02f, 4.86453809e-02f, 3.11346166e-02f, 1.33652851e-01f,
  1.35261774e-01f, 6.72121421e-02f, 1.23195842e-01f, 1.10600874e-01f, 1.80663973e-01f, 1.50517493e-01f, 1.69706032e-01f, -9.43401083e-02f, 1.25164792e-01f, -7.65136480e-02f,
  -4.08467054e-02f, -1.81759670e-02f, 9.02415663e-02f, -3.98237817e-02f, -1.07963681e-02f, 3.06684915e-02f, 1.56051815e-02f, -1.92561448e-02f, 6.31676987e-02f, -8.50488315e-04f,
  -2.05718502e-02f, 6.91429749e-02f, 2.74724402e-02f, -1.87693853e-02f, 2.86006164e-02f, 6.09998107e-02f, 6.08936511e-02f, 2.48105284e-02f, 4.98960949e-02f, 1.19616352e-02f,
  4.77453833e-03f, 1.11057935e-03f, -8.03488493e-03f, 3.51635553e-02f, 2.83523872e-02f, -3.59581457e-03f, -1.66823473e-02f, 2.89961509e-02f, -4.04546186e-02f, 1.11921858e-02f,
  3.53681259e-02f, -7.80253932e-02f, -5.04645705e-02f, 4.14248668e-02f, -5.09731546e-02f, 3.06920074e-02f, -1.12734906e-01f, -4.23808880e-02f, -5.93060665e-02f, -2.03484707e-02f,
  3.75774354e-02f, 4.00999598e-02f, -2.87674274e-02f, 4.35215347e-02f, 3.79430340e-03f, 1.42301172e-02f, -4.75926287e-02f, 5.94813377e-03f, 7.09032714e-02f, 6.30024355e-03f,
  -3.36467810e-02f, 2.02855989e-02f, 4.79595363e-03f, 1.53409867e-02f, -5.58205545e-02f, 4.40432504e-02f, 2.29545534e-02f, -6.03354275e-02f, 1.35528864e-02f, 1.84665639e-02f,
  -2.05746219e-02f, -1.35752827e-01f, 4.88595804e-03f, -1.43350270e-02f, -2.86146067e-02f, 1.38532370e-02f, -9.46479663e-02f, -1.83998644e-02f, -3.91157120e-02f, 2.23264080e-02f,
  9.74335149e-02f, 6.72356784e-02f, -1.18127078e-01f, 9.74072292e-02f, 1.04378406e-02f, -2.58265622e-03f, 3.07968836e-02f, 5.02172019e-03f, 4.34278138e-02f, 8.37373920e-03f,
  6.59455806e-02f, -2.20757350e-02f, -3.91540155e-02f, 5.06480262e-02f, 1.08390741e-01f, -6.45854026e-02f, -2.08332110e-03f, -2.54632272e-02f, 4.27855998e-02f, -1.57032870e-02f,
  3.19690347e-01f, 1.61884353e-01f, 4.72023562e-02f, 1.73772946e-01f, 3.39933522e-02f, -1.29447192e-01f, -4.49578874e-02f, 7.69496188e-02f, 1.42823607e-01f, 4.60031517e-02f,
  -9.14827138e-02f, 2.28286460e-01f, -1.31985426e-01f, 2.75806733e-03f, -2.78834164e-01f, -2.44395033e-01f, 5.62213361e-02f, 1.21519104e-01f, 9.49646458e-02f, 1.05900243e-01f,
  -4.81871180e-02f, -2.08235383e-02f, -1.78821966e-01f, 4.23560180e-02f, 2.06807088e-02f, 1.19314708e-01f, 3.97093780e-02f, 6.38981489e-03f, 1.33242309e-01f, 6.54082149e-02f,
  -1.03976138e-01f, -2.52213012e-02f, 1.88721474e-02f, -1.92859769e-02f, -6.46547973e-02f, -4.20614611e-03f, 2.43391823e-02f, -4.04511318e-02f, -4.12271656e-02f, 2.65768636e-02f,
  -5.73573459e-04f, -2.16252338e-02f, 5.96195497e-02f, 9.16435290e-03f, 6.94620684e-02f, 5.92560619e-02f, 3.88974585e-02f, 1.26985868e-03f, 3.23277287e-04f, -1.87051632e-02f,
  -3.96196498e-03f, -1.15999728e-02f, 6.28801957e-02f, 2.01117825e-02f, -1.55270733e-02f, 7.05264732e-02f, 8.21777678e-04f, -2.37023495e-02f, 3.98694687e-02f, 1.05590761e-01f,
  4.84281369e-02f, 5.00710532e-02f, -3.60507667e-02f, 1.89708527e-02f, 5.81743382e-03f, 1.10047236e-04f, 3.98661592e-04f, 1.38432661e-03f, 6.04652204e-02f, -4.04109620e-03f,
  1.26653956e-02f, 8.50880221e-02f, -2.28709206e-02f, 5.23372591e-02f, 8.99111945e-03f, 7.17128208e-03f, -5.62002957e-02f, 3.13515663e-02f, 1.41578177e-02f, 3.23142065e-03f,
  -1.94282774e-02f, 2.83063427e-02f, 1.32016586e-02f, -3.60656641e-02f, -2.30641458e-02f, 1.15366299e-02f, 2.75146943e-02f, 3.62173989e-02f, -5.25192134e-02f, -4.44789743e-03f,
  5.50766066e-02f, 1.07500203e-01f, 2.00112397e-03f, 6.60096630e-02f, 3.04371454e-02f, 2.93623768e-02f, -3.01480368e-02f, 3.26634310e-02f, 9.63529479e-03f, 9.87952296e-03f,
  6.14217371e-02f, 2.25543585e-02f, -1.43630560e-02f, 5.49989380e-03f, 1.22045185e-02f, -1.88677758e-02f, -5.57574034e-02f, 7.17188697e-03f, 4.62738536e-02f, 5.40181696e-02f,
  6.39017532e-03f, -1.29405027e-02f, -1.08579937e-02f, -8.94666882e-04f, -2.95124743e-02f, -2.25274209e-02f, 4.87849042e-02f, -2.73651141e-03f, 1.58608891e-04f, 7.09786918e-03f,
  -3.76224488e-01f, -6.75142705e-02f, -5.08011915e-02f, -6.69704005e-02f, 1.49587303e-01f, 1.09962411e-01f, 1.61740128e-02f, 6.40259087e-02f, 2.28012979e-01f, 1.57723147e-02f,
  7.28148893e-02f, -1.43587366e-01f, 1.62774578e-01f, -2.81490944e-02f, -1.17457949e-01f, 2.08853856e-01f, -6.03646934e-02f, 1.30092371e-02f, 1.84270442e-01f, -2.00412318e-01f,
  -2.72326991e-02f, -7.58022070e-02f, -1.84377566e-01f, -9.29931626e-02f, -4.90555838e-02f, -1.43126309e-01f, -2.87735667e-02f, -9.75020789e-03f, -2.24384323e-01f, 2.47875564e-02f,
  -1.76405281e-01f, -1.56966135e-01f, -1.44466612e-04f, 5.42359613e-02f, -6.53793663e-02f, 1.56040546e-02f, 2.32647937e-02f, 8.01066160e-02f, 1.17340824e-03f, 2.11962294e-02f,
  1.21115623e-02f, -9.81490612e-02f, 5.39807305e-02f, 1.47117898e-01f, 8.03279411e-03f, 9.48484838e-02f, 1.04511648e-01f, -2.91745411e-03f, 7.59070786e-03f, -4.87968177e-02f,
  -1.04864322e-01f, -4.05826047e-02f, -1.69186443e-02f, 4.79121394e-02f, -2.59304065e-02f, -6.69414699e-02f, -2.01027077e-02f, -3.16156521e-02f, 3.58963087e-02f, -1.86301246e-02f,
  7.98459165e-03f, -1.19658774e-02f, 2.33465489e-02f, 7.14668026e-03f, -3.94573472e-02f, -3.02117281e-02f, 3.00908592e-02f, 1.30998297e-02f, 7.77837541e-03f, -1.09671205e-02f,
  6.59636334e-02f, -2.13581640e-02f, 3.72449355e-03f, 6.93713427e-02f, -7.41551816e-02f, -4.39136475e-02f, 1.25848372e-02f, 4.89446893e-02f, 3.20895277e-02f, 4.38926136e-03f,
  9.09188688e-02f, -1.51675064e-02f, -2.34428626e-02f, 2.94814762e-02f, -6.96464442e-03f, 3.88054992e-03f, 9.74885002e-02f, 3.98367010e-02f, 9.61387679e-02f, 2.83392780e-02f,
  -3.24248262e-02f, -1.63642928e-01f, -3.19621153e-02f, -6.87707812e-02f, 6.90761134e-02f, 1.25332922e-01f, 8.54033157e-02f, 4.61807884e-02f, -1.77914966e-02f, 5.77149503e-02f,
  -4.56622280e-02f, -1.85140129e-02f, -5.37676215e-02f, -2.06105541e-02f, 2.65515153e-03f, 4.38051932e-02f, -5.88368401e-02f, -7.13668168e-02f, -2.60289409e-03f, -4.50688452e-02f,
  -5.65929189e-02f, -8.31938013e-02f, -5.66519350e-02f, -3.23150773e-03f, 4.52926792e-02f, -1.12830967e-01f, -4.15900536e-02f, -1.27085000e-01f, 2.68439278e-02f, 2.04408038e-02f,
  4.41299751e-02f, 8.75627548e-02f, 1.25795543e-01f, 1.96659014e-01f, -5.44845685e-02f, -4.20510709e-01f, -2.74885029e-01f, 1.28546879e-01f, 2.86582336e-02f, -2.53580641e-02f,
  -1.07394777e-01f, -1.62249357e-02f, -5.64514361e-02f, -1.33162990e-01f, -2.47901171e-01f, -1.77963614e-01f, -9.54283476e-02f, -1.46171004e-01f, 8.65319893e-02f, 2.51589380e-02f,
  8.53265822e-03f, -1.32742524e-01f, 7.66928047e-02f, 4.28998061e-02f, 1.18420936e-01f, 1.85282916e-01f, 2.04743356e-01f, -5.35463449e-04f, 7.15223029e-02f, -1.10548779e-01f,
  -9.18174759e-02f, -5.75757446e-03f, 8.95239338e-02f, -1.41808335e-02f, 5.74679859e-02f, -3.63486446e-02f, -1.01406798e-01f, -7.29998276e-02f, 4.86319214e-02f, 1.78733766e-02f,
  -4.01591472e-02f, -5.96576817e-02f, 4.00911830e-02f, 6.64457083e-02f, -2.54776068e-02f, 6.05888478e-02f, 6.93847332e-03f, 3.54096293e-02f, 2.44928915e-02f, 1.41158551e-02f,
  6.17750026e-02f, 2.19463892e-02f, 1.66767929e-02f, -2.74467934e-02f, 5.91330156e-02f, -2.29861448e-03f, -5.03203413e-03f, 1.78933796e-02f, 2.61195917e-02f, 9.25657824e-02f,
  -7.65123814e-02f, -3.50394771e-02f, 4.10268195e-02f, 1.36109114e-01f, 6.21988289e-02f, 7.38837942e-02f, 2.16219574e-03f, -2.54276991e-02f, 1.03533855e-02f, -3.75356004e-02f,
  2.09212173e-02f, -2.60637514e-02f, -3.93624231e-02f, 3.74019854e-02f, -3.56232189e-02f, 6.46187291e-02f, -1.56181445e-02f, 1.99699495e-02f, 4.92896847e-02f, 7.38966540e-02f,
  1.12153832e-02f, -4.76268530e-02f, 6.94134235e-02f, 2.85989717e-02f, -1.54181765e-02f, 5.85600957e-02f, -1.72083396e-02f, 6.97761700e-02f, 6.34975135e-02f, -4.28660726e-03f,
  -1.51509508e-01f, -4.07946557e-02f, 5.53059019e-02f, -6.14208020e-02f, -5.68912691e-03f, 4.58474308e-02f, -6.30675722e-03f, -2.57569067e-02f, -1.29068950e-02f, -3.36645469e-02f,
  -3.19220275e-02f, 3.60831358e-02f, -1.57767404e-02f, -8.53253994e-03f, 3.00779175e-02f, 1.34179434e-02f, -3.47752906e-02f, 3.46956141e-02f, -7.34469341e-03f, -2.12259833e-02f,
  3.85074578e-02f, -8.21137130e-02f, 4.40082438e-02f, 4.76471074e-02f, -1.73915159e-02f, -3.26857381e-02f, 3.53205204e-02f, 1.12689119e-02f, 4.14231345e-02f, -2.80225296e-02f,
  1.48316324e-01f, -2.32556209e-01f, -1.20256312e-01f, 1.23786479e-01f, -1.47174001e-01f, 1.53197393e-01f, 1.43605843e-01f, -1.47940293e-01f, -2.03803126e-02f, -5.22706024e-02f,
  2.07127593e-02f, 1.26599278e-02f, 2.84738261e-02f, -1.12663759e-02f, 4.00202066e-01f, 1.44674510e-01f, 1.82479218e-01f, 7.40255937e-02f, 5.33267809e-03f, -1.78936720e-02f,
  -2.85528740e-03f, 1.07630312e-01f, 3.45074348e-02f, -1.13503471e-01f, -1.51917979e-01f, -1.92723051e-01f, 8.82931128e-02f, -7.33960345e-02f, -6.59436733e-02f, -3.57923564e-03f,
  -5.45158535e-02f, -8.05047378e-02f, -1.19019881e-01f, -3.67871262e-02f, -6.61517009e-02f, -1.29202036e-02f, -1.07172169e-02f, 4.02434655e-02f, 3.29333209e-02f, -1.10051024e-03f,
  -1.13439746e-02f, 5.20577095e-02f, 6.74372464e-02f, 5.01099462e-03f, -5.34569435e-02f, -6.45232275e-02f, -4.80804853e-02f, -4.41371389e-02f, -5.84583320e-02f, 2.37318152e-03f,
  -1.77656412e-02f, -8.26503336e-03f, 3.08234623e-04f, 1.47482045e-02f, -3.18767689e-02f, -3.52733061e-02f, 3.27203050e-02f, -1.53770316e-02f, -7.54661160e-03f, 2.37602219e-02f,
  5.16064279e-02f, 1.11462183e-01f, -8.59486312e-03f, 2.06572413e-02f, 4.12631631e-02f, -4.34168242e-02f, 5.12074269e-02f, 1.21875741e-02f, -1.77144539e-02f, -1.25492150e-02f,
  -2.82094050e-02f, -1.01841930e-02f, -3.53191840e-03f, -4.45974851e-03f, 4.93162777e-03f, -8.28978047e-03f, -1.04813045e-02f, -2.36763023e-02f, 3.16268504e-02f, 1.38282147e-03f,
  3.41607183e-02f, 1.62609890e-02f, -2.76094545e-02f, -3.95180751e-03f, 1.80290714e-02f, 1.10444743e-02f, -4.29181978e-02f, 1.77527138e-03f, 2.64809444e-03f, 2.03221496e-02f,
  -1.91443395e-02f, 7.73211271e-02f, -5.82682826e-02f, -1.08451257e-03f, 1.83778908e-02f, 8.83042254e-03f, 5.01499511e-02f, -5.80509715e-02f, 3.04546133e-02f, 4.31634896e-02f,
  -4.55642901e-02f, 4.08188486e-03f, 2.21398566e-02f, 1.49369603e-02f, 2.69524553e-05f, 8.85755420e-02f, 3.11138630e-02f, 3.78647782e-02f, -2.14671511e-02f, -1.09027820e-02f,
  8.44838936e-03f, 2.97775604e-02f, 4.69651259e-02f, 3.00899707e-03f, 3.03598270e-02f, 6.26807660e-02f, 3.19043361e-02f, -4.34159189e-02f, 4.69610393e-02f, 4.55429554e-02f,
  -5.19155562e-02f, -4.21573743e-02f, 1.13775805e-01f, 1.30812861e-02f, 1.77074283e-01f, 7.03149959e-02f, 1.35518461e-01f, 8.51833727e-03f, 3.23761493e-01f, -2.42978960e-01f,
  -2.05455869e-02f, -1.67675644e-01f, 2.28661969e-01f, -2.31481209e-01f, 3.84267643e-02f, 2.08679274e-01f, -9.70366374e-02f, -9.78509411e-02f, 1.58028707e-01f, -1.06027946e-01f,
  4.37181070e-03f, -2.41522074e-01f, -2.74364688e-02f, -1.18846923e-01f, -1.86139077e-01f, -1.08931856e-02f, -2.48541057e-01f, 1.91935033e-01f, -3.19329232e-01f, 8.50240327e-03f,
  4.62097526e-02f, 6.55735061e-02f, 1.41142458e-02f, -2.59730630e-02f, -3.11094150e-02f, 1.65689383e-02f, 7.42317364e-03f, 1.23074479e-01f, 1.25132009e-01f, 2.23929472e-02f,
  -3.97150964e-02f, -8.53613093e-02f, -1.07164554e-01f, -2.07769033e-02f, 5.28360605e-02f, -1.16119087e-02f, -6.41801022e-03f, -6.97431117e-02f, -2.99864300e-02f, -1.36303371e-02f,
  5.31674139e-02f, -7.88627099e-03f, -7.61607289e-02f, -2.23085787e-02f, -4.03562784e-02f, 4.05763499e-02f, 1.74401719e-02f, 1.52492672e-02f, 1.51941609e-02f, 2.67270077e-02f,
  1.09806135e-02f, 1.16545901e-01f, 1.52360369e-02f, -3.19826268e-02f, -3.99956740e-02f, -1.81862004e-02f, -5.23046367e-02f, -1.33198602e-02f, 7.55002722e-04f, -4.22697030e-02f,
  -7.34351724e-02f, -3.50553244e-02f, 2.33383365e-02f, -2.47049723e-02f, -2.03058049e-02f, -5.49687818e-02f, -2.51117870e-02f, -5.82055673e-02f, -2.82464530e-02f, 9.86823812e-03f,
  1.71822291e-02f, 4.21547592e-02f, -5.04780468e-03f, 7.96532556e-02f, 9.56059992e-02f, 2.98943575e-02f, -7.13533014e-02f, -8.54694843e-03f, 1.34430349e-01f, -8.11541860e-04f,
  -2.77640205e-02f, -6.97154701e-02f, -1.75569095e-02f, 3.07013001e-02f, 8.86225179e-02f, -1.27829492e-01f, 9.02845487e-02f, -7.65681341e-02f, 6.05589300e-02f, -5.16016074e-02f,
  -7.75122866e-02f, -2.67968234e-02f, -3.28509100e-02f, 2.25918647e-02f, 3.60619426e-02f, 7.24193826e-03f, -1.96497310e-02f, 4.46325764e-02f, -8.61577541e-02f, -2.20191181e-02f,
  -8.32851827e-02f, 1.17351823e-02f, -1.49025274e-02f, -4.66875024e-02f, -1.38972953e-01f, -2.59631686e-02f, -2.53352784e-02f, 5.84660992e-02f, -3.00390436e-03f, 5.04681980e-03f,
  -4.15300697e-01f, 4.10514027e-01f, -8.93007778e-03f, 2.87269592e-01f, -2.06222087e-01f, -8.84792358e-02f, -3.54449898e-02f, 7.93714300e-02f, 1.09172300e-01f, 2.75994360e-01f,
  3.48400231e-03f, 1.01542518e-01f, -3.43567431e-02f, 2.06788465e-01f, -3.86391819e-01f, 1.04345560e-01f, 3.34140472e-02f, 1.23397864e-01f, -7.10201683e-03f, 1.08064990e-03f,
  -1.21398374e-01f, -5.63318767e-02f, -3.27117294e-02f, 1.09884923e-03f, 2.08880864e-02f, 6.24922700e-02f, -4.79109325e-02f, -4.76198532e-02f, 8.10015574e-02f, 1.96312508e-03f,
  1.10861279e-01f, 1.09885722e-01f, -3.58202606e-02f, 2.66122483e-02f, -5.88377379e-02f, 1.24176461e-02f, -2.56148353e-02f, -2.13275012e-02f, -4.36092913e-02f, -6.14567427e-04f,
  -2.49906834e-02f, 2.98928022e-02f, 2.04735845e-02f, -6.53070956e-02f, -5.83523698e-02f, -4.44564894e-02f, -4.51783724e-02f, 1.21496245e-02f, 8.08383897e-02f, -1.82444789e-03f,
  -3.13382149e-02f, 2.72287372e-02f, 3.04461550e-03f, 6.10787943e-02f, -5.69009259e-02f, 1.61599629e-02f, 4.13819700e-02f, 2.52137869e-03f, 3.87906246e-02f, 7.89480843e-03f,
  -4.14522514e-02f, 2.91997138e-02f, 4.76182485e-03f, -1.39731923e-02f, 4.65778857e-02f, 4.93732095e-03f, -3.87412868e-02f, 2.88292728e-02f, -5.54598926e-04f, -2.41791271e-02f,
  -5.84101584e-03f, 3.54946554e-02f, 1.10884141e-02f, -5.84973656e-02f, -2.24659964e-02f, 9.15207528e-03f, -2.24683136e-02f, 6.51346743e-02f, 5.64651974e-02f, -5.08991256e-03f,
  6.04376383e-02f, -5.45538031e-02f, 8.17554146e-02f, 2.85241921e-02f, -1.09893912e-02f, -4.97469343e-02f, 4.50696945e-02f, 3.58042680e-02f, 2.83488035e-02f, -6.00897223e-02f,
  3.90239316e-03f, 7.73233548e-02f, 7.26885200e-02f, 5.74638369e-03f, 5.85919954e-02f, -2.21428815e-02f, -6.75022835e-03f, 5.27129741e-03f, 1.06864274e-01f, -8.98737907e-02f,
  -5.07277884e-02f, 1.22025097e-02f, 4.89555970e-02f, -3.14878896e-02f, -2.63543073e-02f, 4.53963503e-02f, 3.72366756e-02f, 4.65787724e-02f, -4.61725928e-02f, -2.35795099e-02f,
  4.80437046e-03f, -5.82705671e-03f, 6.42073900e-02f, -2.47099549e-02f, 2.33233646e-02f, 1.31712835e-02f, -3.74041609e-02f, 7.03012720e-02f, -3.86229381e-02f, 3.22042704e-02f,
  2.04138726e-01f, -2.25569576e-01f, 2.41191760e-01f, -1.66391626e-01f, -2.47985721e-02f, -2.92345077e-01f, -1.51640847e-01f, 4.93769459e-02f, 4.63765934e-02f, -2.12989464e-01f,
  -3.47250551e-02f, 1.19298935e-01f, 1.24125354e-01f, -3.09416771e-01f, 8.05518627e-02f, -7.92010501e-03f, -2.66444176e-01f, -1.53024420e-01f, 1.01510204e-01f, 8.41922984e-02f,
  8.52345079e-02f, -2.50553280e-01f, 5.46454415e-02f, 5.38937971e-02f, -3.03034876e-02f, 6.68560341e-02f, 4.51425686e-02f, 2.43239805e-01f, -1.19513936e-01f, -1.41608184e-02f,
  -2.49464661e-02f, 9.02412906e-02f, 4.73110713e-02f, 5.49439974e-02f, -3.00084017e-02f, -2.89506838e-03f, 4.39297706e-02f, 1.74972787e-02f, 4.81081493e-02f, 3.98328975e-02f,
  3.63277309e-02f, 3.57461199e-02f, -5.24167903e-02f, 5.31645641e-02f, 8.65471642e-03f, -3.80243510e-02f, 1.64636038e-02f, -3.56132910e-02f, 5.70429163e-03f, 4.30416651e-02f,
  1.12076299e-02f, -4.72318083e-02f, -4.52424474e-02f, -7.25533962e-02f, 4.17396277e-02f, -4.36007828e-02f, -3.26437429e-02f, 2.73258202e-02f, -6.37070462e-02f, 6.09710172e-04f,
  -2.06887275e-02f, 4.30459492e-02f, 2.39425320e-02f, 1.78253464e-02f, -5.89260869e-02f, 2.06962749e-02f, 6.17070310e-03f, 7.44752884e-02f, 5.72112687e-02f, 2.11759415e-02f,
  -6.00889232e-03f, -3.21562728e-03f, 6.56020194e-02f, 3.71254515e-03f, -6.53798282e-02f, -7.45484382e-02f, 1.21232666e-01f, -3.69392000e-02f, 6.43297359e-02f, -5.93288690e-02f,
  8.51771981e-02f, 4.36735805e-03f, 2.15907302e-03f, 4.10495792e-03f, -8.82845279e-03f, 5.98343611e-02f, -2.20919885e-02f, -1.81295220e-02f, -1.55517468e-02f, 8.02874193e-03f,
  -1.77475333e-01f, -3.38716758e-03f, 1.72611643e-02f, -3.64762284e-02f, -1.35381371e-02f, -2.69924067e-02f, -4.90399376e-02f, -9.92253423e-03f, 2.32601184e-02f, 1.34712812e-02f,
  5.71079813e-02f, 3.01181595e-03f, 2.25232653e-02f, 1.83532517e-02f, 1.40253184e-02f, -5.89079177e-03f, 2.65099388e-02f, 6.98364228e-02f, -3.29834111e-02f, 3.69120413e-03f,
  -2.32466888e-02f, -2.43778750e-02f, 7.48654976e-02f, -5.89375272e-02f, -9.88189876e-02f, 3.06366384e-02f, -9.29187536e-02f, 8.92940611e-02f, -1.69089977e-02f, 3.15894447e-02f,
  3.76632482e-01f, -4.79622453e-01f, 1.88241169e-01f, -1.44895524e-01f, 1.61463559e-01f, -7.60874748e-02f, -8.68012290e-03f, -1.69329137e-01f, -8.96010250e-02f, -2.08833113e-01f,
  -2.51924023e-02f, -6.64190215e-04f, -1.09466463e-01f, -1.63399264e-01f, 1.63149267e-01f, -2.31940880e-01f, -7.05580041e-02f, -2.48285066e-02f, -1.27114162e-01f, -9.42695290e-02f,
  -5.79790212e-02f, -2.04729781e-01f, 4.74233590e-02f, -1.42746910e-01f, 1.61422081e-02f, -2.15233769e-02f, 8.59126970e-02f, -6.99284747e-02f, 3.87687087e-02f, -9.37172771e-03f,
  8.58566910e-02f, -5.30220792e-02f, 1.17814831e-01f, 6.71842173e-02f, 1.46494489e-02f, 8.28794390e-02f, 2.53877994e-02f, 7.39744306e-02f, 6.18958846e-02f, 2.91889142e-02f,
  5.37974574e-02f, 1.25000002e-02f, -3.13505270e-02f, -2.96012056e-03f, -7.04364153e-03f, 7.31718615e-02f, 4.40225907e-04f, 3.32902484e-02f, -6.68775290e-02f, 3.47858891e-02f,
  -1.10722715e-02f, 5.31748123e-02f, 2.37325616e-02f, -8.12592208e-02f, 3.89245264e-02f, -1.49521912e-02f, -1.03590954e-02f, 5.01130708e-02f, -3.06000691e-02f, 4.89802621e-02f,
  -3.66467275e-02f, 2.74156928e-02f, -3.46475020e-02f, 6.35613361e-03f, -1.65686142e-02f, -3.27094048e-02f, 1.01498514e-02f, -2.26966920e-03f, -8.58437177e-03f, 1.54742703e-03f,
  4.23431620e-02f, -3.03510781e-02f, -8.06954689e-03f, -8.43379647e-03f, -1.42484615e-02f, 3.80860865e-02f, 5.95562831e-02f, -7.34673999e-03f, 3.65955150e-03f, 5.56587391e-02f,
  -1.90229435e-02f, -4.02964167e-02f, -3.05750500e-02f, 1.90030504e-02f, -1.94844827e-02f, 3.95866297e-02f, -2.02987138e-02f, -2.02395655e-02f, 3.84040512e-02f, 2.89293136e-02f,
  -2.30009824e-01f, -3.09385598e-01f, -4.70051281e-02f, -2.45435126e-02f, -1.24592865e-02f, 3.52057368e-02f, -2.19280981e-02f, -2.24493314e-02f, -8.39411095e-02f, -4.70355414e-02f,
  3.32479849e-02f, 2.69279052e-02f, 1.38161052e-02f, 1.01790787e-03f, 3.13134585e-03f, -6.11934476e-02f, -8.77320617e-02f, -2.11076494e-02f, 1.66046824e-02f, -4.11061384e-02f,
  2.95050088e-02f, -5.06074205e-02f, 6.43273443e-03f, -6.10931106e-02f, -1.14943124e-02f, 4.88658249e-02f, -2.41681561e-02f, -5.93870599e-03f, 3.08142346e-03f, -3.55059691e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.00225854e-01f, 2.25317441e-02f, -3.49585682e-01f, -1.38551712e-01f, 1.43460510e-02f, -3.41404229e-01f, -8.27047303e-02f, -6.42170385e-02f, 3.49799022e-02f, 3.14180344e-01f,
  7.23350346e-02f, -2.07601294e-01f, 1.41418353e-01f, -9.20547098e-02f, -4.42537159e-01f, 8.64133313e-02f, -2.56870836e-01f, -8.66745114e-02f, -2.20758747e-02f, -1.35762945e-01f,
  -1.45301417e-01f, -1.24415364e-02f, -2.01531425e-01f, 6.54052347e-02f, -1.53986678e-01f, -9.96692032e-02f, 1.79350838e-01f, 2.36724550e-03f, -1.68491185e-01f, -2.56581698e-02f,
  -6.96849078e-02f, -2.35666651e-02f, 2.77508963e-02f, -3.60390022e-02f, -1.73093334e-01f, -4.58352417e-02f, -3.38431075e-02f, -3.72018330e-02f, -7.67857134e-02f, -5.00316098e-02f,
  -4.78822216e-02f, -9.21095759e-02f, -8.66342634e-02f, 3.62289846e-02f, 3.26997675e-02f, 5.92329958e-03f, -2.03058682e-02f, -7.31554329e-02f, -5.47088645e-02f, -1.24229677e-01f,
  -7.49735758e-02f, -7.26682767e-02f, 5.70441559e-02f, 6.14740625e-02f, -4.17539328e-02f, 1.80043429e-02f, 2.18839608e-02f, -5.63485213e-02f, -1.48680776e-01f, -1.50881195e-02f,
  -1.59493764e-03f, -4.56341356e-02f, -4.09870632e-02f, -5.31128282e-03f, -2.66166348e-02f, 6.02387451e-02f, 3.04484461e-02f, 7.96644296e-03f, 8.92299134e-03f, 6.28429130e-02f,
  4.70378948e-03f, -3.27378660e-02f, 2.19928306e-02f, 1.40993744e-02f, -2.96872910e-02f, 7.64620071e-03f, -1.69398021e-02f, 1.02893943e-02f, -2.82291453e-02f, -1.75376050e-02f,
  6.87370449e-02f, 4.68336120e-02f, 2.09415201e-02f, 4.09818701e-02f, -2.77483538e-02f, 1.88418888e-02f, -7.14793662e-03f, -7.24442378e-02f, -1.71035193e-02f, 2.08703112e-02f,
  -6.09642603e-02f, -7.46530667e-02f, -1.64573011e-03f, 9.98062920e-03f, 2.78915893e-02f, -5.61878160e-02f, -5.06906363e-04f, -1.00360654e-01f, -7.09330365e-02f, -4.13105935e-02f,
  -9.10176784e-02f, 6.10964149e-02f, -9.85864475e-02f, 5.72238751e-02f, 1.01024918e-02f, -3.17527503e-02f, 8.13159198e-02f, 7.36763328e-03f, -7.50906020e-02f, 7.13946298e-03f,
  1.43544869e-02f, 6.60785800e-03f, 1.59015413e-02f, -1.02315303e-02f, 9.32147801e-02f, 5.40090762e-02f, -7.08582401e-02f, -1.59328356e-02f, -1.64568126e-02f, 4.28126603e-02f,
  -1.74583301e-01f, -3.06272477e-01f, -2.76842475e-01f, 3.49918194e-02f, -1.19007431e-01f, -2.59814970e-02f, 1.01568542e-01f, -2.50772595e-01f, -2.04496518e-01f, 3.13066542e-02f,
  1.96079075e-01f, 4.82535511e-02f, 7.78329000e-02f, 2.42379174e-01f, 3.00370067e-01f, 8.48520696e-02f, 1.42251179e-01f, 2.37213999e-01f, -1.96126476e-02f, -1.45836860e-01f,
  1.04875281e-01f, 1.57865584e-01f, 6.55441582e-02f, -6.36656508e-02f, -5.41815422e-02f, -9.35073942e-02f, 1.08754911e-01f, -1.10719845e-01f, 1.82815135e-01f, 1.31802171e-01f,
  7.29889199e-02f, -2.37535506e-01f, -3.87047231e-02f, 1.59243180e-03f, -8.20825845e-02f, 6.72333315e-02f, 9.38675478e-02f, 1.01894110e-01f, -1.55882426e-02f, 1.77709609e-02f,
  -6.79875910e-02f, -4.77345735e-02f, -8.37812722e-02f, 6.55733421e-02f, -2.03588009e-02f, -4.60965410e-02f, 5.47639541e-02f, 3.94875258e-02f, 3.81573997e-02f, 6.64106919e-04f,
  -1.25863552e-01f, 1.96567383e-02f, -2.88687535e-02f, 3.43290754e-02f, -7.49694975e-03f, -2.75171772e-02f, -2.68937610e-02f, -7.79392421e-02f, -7.63402879e-02f, -1.04493283e-01f,
  -1.89313907e-02f, -1.22494705e-01f, -1.04105100e-01f, 7.11717159e-02f, -1.06042251e-01f, 6.62886053e-02f, 1.45041822e-02f, 1.45029500e-01f, 5.05399927e-02f, -3.84450369e-02f,
  -1.86318718e-02f, -4.76257168e-02f, 2.98357382e-02f, 3.03908307e-02f, -1.43989688e-02f, -6.70928806e-02f, -1.42006529e-02f, 8.26584268e-03f, -7.98359960e-02f, 1.19823121e-01f,
  9.27481800e-02f, 1.28303247e-03f, 1.84303373e-02f, 5.60166053e-02f, -6.88495534e-03f, -5.65861771e-03f, 6.97454845e-04f, -2.74060667e-02f, -2.36431360e-02f, -2.11553033e-02f,
  -1.77474821e-03f, -3.55331540e-01f, 2.68371366e-02f, 4.84538488e-02f, 7.28412792e-02f, -3.92852537e-02f, -1.07601043e-02f, -1.58164613e-02f, -6.37516826e-02f, -9.72800255e-02f,
  5.49530126e-02f, 4.48950492e-02f, -6.99510947e-02f, -6.13467721e-03f, -1.81508791e-02f, -1.01561189e-01f, -2.59091202e-02f, 8.68858919e-02f, 1.25835817e-02f, 5.58737433e-03f,
  -5.59926778e-02f, -5.35542071e-02f, -1.13771185e-02f, -5.63258789e-02f, 1.74529012e-02f, 9.85782668e-02f, -3.67024615e-02f, -1.08769074e-01f, 1.50454298e-01f, 4.41936171e-03f,
  -4.06143606e-01f, -3.78750674e-02f, -1.09392717e-01f, -2.52310872e-01f, -2.36946613e-01f, -6.24555722e-02f, 7.79192075e-02f, -6.26642928e-02f, -4.00233176e-03f, 8.86672586e-02f,
  -7.52368793e-02f, 2.18857620e-02f, 3.39400440e-01f, -7.65342414e-02f, 8.14438760e-02f, 2.67577797e-01f, -1.70089900e-01f, 3.05095315e-02f, -1.18811794e-01f, -1.63032815e-01f,
  -1.04204699e-01f, -1.39719680e-01f, 1.73501130e-02f, -1.78480044e-01f, -2.34764978e-01f, -2.10468039e-01f, -4.81391698e-02f, -1.01622194e-01f, -2.42844820e-01f, -6.89552128e-02f,
  -3.15494031e-01f, -2.75951385e-01f, -1.32721171e-01f, -9.22369212e-02f, -8.96111801e-02f, -3.81587334e-02f, -3.12397201e-02f, 8.12621564e-02f, -2.34921221e-02f, -2.78354827e-02f,
  5.24667948e-02f, 9.41274315e-03f, -4.61872853e-02f, 4.79815044e-02f, -5.01098186e-02f, -6.92771450e-02f, -7.00856699e-03f, -1.36780828e-01f, -4.94443486e-03f, -2.07736506e-03f,
  -4.88808416e-02f, -1.01215377e-01f, -1.58327818e-01f, 6.94828629e-02f, -1.66133810e-02f, -1.30423144e-01f, 5.35640195e-02f, 6.50331527e-02f, -1.45260856e-01f, -8.86307061e-02f,
  4.95567843e-02f, 1.03987098e-01f, -5.67530505e-02f, 1.13686383e-01f, -1.09333722e-02f, -4.34044972e-02f, -4.79434542e-02f, 6.08639643e-02f, 1.63042266e-02f, 1.07589655e-03f,
  4.64389771e-02f, -6.60934597e-02f, -5.85043766e-02f, -4.20489945e-02f, 4.18538451e-02f, 5.29342983e-03f, 1.59274973e-02f, -8.51782635e-02f, -7.67877139e-03f, -6.13174327e-02f,
  -1.26366140e-02f, -3.18650305e-02f, 2.48882174e-02f, -1.58357397e-02f, -2.61419117e-02f, 6.77860230e-02f, -2.51509994e-02f, 5.01707615e-03f, -8.44411403e-02f, -2.87162364e-02f,
  -4.03787285e-01f, -3.15098941e-01f, -3.05745238e-03f, -5.86581007e-02f, 3.83710042e-02f, -5.66219799e-02f, -1.09572196e-02f, -4.14152592e-02f, -1.14673957e-01f, 1.70801468e-02f,
  -1.18639767e-01f, 8.44332874e-02f, -1.26214977e-02f, -1.19821134e-03f, 5.83231412e-02f, -6.52941614e-02f, 4.54373751e-03f, -5.16809337e-02f, -1.63515937e-02f, -9.62644741e-02f,
  3.83736938e-02f, 4.56587225e-02f, 6.71334341e-02f, 1.66121684e-03f, -1.09653873e-02f, -6.75186068e-02f, -4.21194993e-02f, 2.47537264e-05f, -1.07455648e-01f, 4.04005460e-02f,
  -1.41583815e-01f, -1.93175733e-01f, -9.60786119e-02f, -2.63580829e-01f, 5.03429137e-02f, -1.45609051e-01f, -2.05176532e-01f, 4.74751368e-02f, -1.87948626e-02f, 2.40505278e-01f,
  7.87251666e-02f, -7.83811212e-02f, 4.68838140e-02f, -3.20333719e-01f, -3.34522575e-01f, -1.54311106e-01f, -3.08462024e-01f, -1.47261024e-01f, -8.89020637e-02f, -1.89793736e-01f,
  -1.05653688e-01f, -1.87486753e-01f, -2.51121432e-01f, -6.89253658e-02f, -1.41156837e-01f, 9.65682268e-02f, 1.78240821e-01f, -2.58102473e-02f, -2.15337053e-02f, -1.05229944e-01f,
  -4.61349264e-02f, 1.39871448e-01f, 1.42860591e-01f, -5.36158402e-03f, 7.42429048e-02f, 2.05819681e-02f, 2.42794603e-02f, -7.45747611e-02f, 5.15203215e-02f, -8.06756392e-02f,
  -3.41308233e-03f, -3.98367643e-03f, -5.64695373e-02f, -5.81587367e-02f, 2.09053140e-02f, 3.40367816e-02f, -3.51055861e-02f, 4.52966131e-02f, -6.14009215e-04f, -7.98928440e-02f,
  -1.05074637e-01f, 1.53377540e-02f, -2.41099973e-03f, -2.90308911e-02f, 5.61583648e-03f, 1.91032607e-02f, 7.64974905e-03f, -5.24541549e-03f, -9.24277492e-03f, -3.86298704e-03f,
  7.98710715e-03f, 1.06412433e-01f, -1.39667159e-02f, -2.00149417e-03f, 7.98018737e-05f, 3.61599587e-02f, -2.69328076e-02f, -2.55756285e-02f, 3.59193347e-02f, 2.47481018e-02f,
  -3.18905618e-03f, -2.73256339e-02f, -7.32430667e-02f, 6.74534542e-03f, -5.52017540e-02f, -4.24046302e-03f, -6.42218441e-03f, -3.99316847e-02f, -1.01703532e-01f, -1.76205160e-03f,
  2.02001221e-02f, -7.85709321e-02f, -7.44042732e-03f, -3.74094620e-02f, 6.02890458e-03f, -4.24094871e-03f, 6.70102090e-02f, 1.69398787e-03f, -1.62754543e-02f, -7.85665214e-02f,
  1.00115482e-02f, 3.89938615e-02f, 4.50384468e-02f, -8.12349096e-02f, 6.68184832e-02f, 1.66635332e-03f, -3.76371779e-02f, -9.31652412e-02f, -5.20609505e-02f, -3.05746328e-02f,
  -4.56952868e-04f, -1.05243328e-03f, 5.88089377e-02f, -9.01744422e-03f, -2.37590307e-03f, 5.18160947e-02f, -2.01062132e-02f, 1.60486195e-02f, -6.93415524e-03f, 1.80419348e-02f,
  -6.84508495e-03f, 6.72392100e-02f, -3.97989945e-03f, -3.69658805e-02f, -2.51028761e-02f, 6.05002232e-02f, 5.14921695e-02f, 1.25344908e-02f, -9.92533658e-03f, 6.14355877e-02f,
  1.73691630e-01f, 1.65503755e-01f, -2.35946581e-01f, 8.56867805e-02f, -1.49812415e-01f, 1.66971639e-01f, 2.31655747e-01f, -3.85869630e-02f, -7.38761723e-02f, 2.83045232e-01f,
  1.24685891e-01f, 1.20056532e-02f, 1.24161996e-01f, 2.93411553e-01f, 1.81174710e-01f, 1.95723012e-01f, 3.70509505e-01f, 1.95486292e-01f, -5.96219338e-02f, 2.29715526e-01f,
  9.40877572e-03f, 3.62335950e-01f, 3.50116915e-03f, 5.59282564e-02f, 5.17329499e-02f, -1.89471111e-01f, 6.73011541e-02f, -2.41731271e-01f, 5.85844032e-02f, 4.56176735e-02f,
  4.24914993e-02f, 8.69292766e-02f, -1.08557239e-01f, -9.14801378e-03f, -3.78998742e-02f, 9.77928634e-04f, -3.75522189e-02f, -4.08940315e-02f, -1.42053351e-01f, 2.21480746e-02f,
  5.67958653e-02f, -3.68931480e-02f, 9.34344009e-02f, 3.02562900e-02f, -9.76240933e-02f, -5.52500524e-02f, -9.11197215e-02f, -1.98551252e-01f, -1.02666333e-01f, 3.71867232e-02f,
  -4.40477990e-02f, -1.65196862e-02f, -1.22090848e-02f, -1.93757601e-02f, -3.70382816e-02f, -4.36640490e-04f, 5.73732238e-03f, -8.20427239e-02f, 2.86843050e-02f, 6.33706897e-02f,
  3.10057662e-02f, 5.79945184e-02f, 6.75847381e-02f, 7.76978061e-02f, 2.80937590e-02f, -9.98831242e-02f, 5.49006537e-02f, -5.01947701e-02f, -9.97100472e-02f, 5.92270419e-02f,
  -6.20616786e-02f, -6.25037029e-02f, 3.93504314e-02f, -9.23069660e-03f, 7.11851716e-02f, 1.58435032e-02f, -2.39118049e-03f, -3.81904729e-02f, -1.14536889e-01f, -8.15935284e-02f,
  1.39816692e-02f, -6.93387315e-02f, -7.63330143e-03f, 1.99972037e-02f, 2.23936439e-02f, -7.75640551e-03f, 5.27621694e-02f, -2.20324844e-02f, -4.61012870e-02f, 4.36012037e-02f,
  1.43533111e-01f, 2.88115919e-01f, -2.31237989e-03f, 1.05501525e-02f, -1.13618933e-02f, 3.78735699e-02f, 1.76213998e-02f, 8.84180441e-02f, 4.38855328e-02f, 7.39406794e-02f,
  7.93728083e-02f, -5.48368990e-02f, 2.33541001e-02f, -3.12234811e-03f, 2.45867739e-03f, 9.43428352e-02f, 1.17270216e-01f, -5.54598644e-02f, -1.32981129e-02f, 4.18133065e-02f,
  4.40419503e-02f, 1.11193340e-02f, 2.57182885e-02f, -1.10351488e-01f, 4.54348996e-02f, -3.17495167e-02f, -7.07293078e-02f, -5.43404818e-02f, -2.50687301e-02f, 5.40312901e-02f,
  1.38912067e-01f, 2.58922517e-01f, -9.38297287e-02f, 8.08917806e-02f, -1.73034117e-01f, -2.84933716e-01f, -1.51622728e-01f, -1.02435023e-01f, 1.46598950e-01f, 1.51197314e-01f,
  -2.53904581e-01f, 5.29523015e-01f, -8.99174437e-02f, -4.13091779e-02f, -2.80069292e-01f, -1.04778007e-01f, -2.05869451e-01f, 2.72770356e-02f, 1.60475671e-01f, -3.01657338e-03f,
  -9.24232379e-02f, -1.90843835e-01f, -2.45584041e-01f, -8.76168832e-02f, -1.88265726e-01f, 3.18237059e-02f, -2.57580101e-01f, -9.17797387e-02f, -1.14525467e-01f, -2.03042477e-02f,
  -1.22622088e-01f, 2.04070330e-01f, 3.28761339e-02f, 2.53263470e-02f, -1.21723779e-01f, -1.50220562e-02f, -8.95423666e-02f, 5.09078577e-02f, 4.46282700e-02f, 4.88550663e-02f,
  8.49964470e-02f, -1.68916602e-02f, 5.48538379e-02f, -1.30470647e-02f, -2.93468032e-02f, 3.30789783e-03f, 5.95903806e-02f, -5.14940359e-02f, 1.02833860e-01f, 1.68764498e-02f,
  1.24683538e-02f, -5.08743944e-03f, -2.52117869e-02f, 2.60513239e-02f, 3.18214670e-02f, -1.36472536e-02f, -8.90561938e-02f, -3.23845856e-02f, 2.29507312e-02f, 6.93173856e-02f,
  6.03233762e-02f, 3.28242071e-02f, -3.06575354e-02f, -1.56157166e-02f, -5.71320318e-02f, -6.20703399e-02f, 6.74860552e-02f, -7.81949237e-03f, -4.54359762e-02f, -9.54293087e-02f,
  -4.28888611e-02f, 9.56303328e-02f, -4.53330539e-02f, -5.61967194e-02f, -2.38078623e-03f, 1.60985924e-02f, -4.06840444e-02f, -1.59124434e-02f, -4.37258817e-02f, -3.33774239e-02f,
  -8.33178870e-03f, -4.67759371e-02f, 1.03434853e-01f, -3.38678956e-02f, -9.98195484e-02f, 1.05175037e-04f, 7.89053086e-03f, -8.44668876e-03f, 6.09025918e-02f, -3.58415209e-02f,
  -7.33604236e-03f, 2.44806260e-02f, 8.65602642e-02f, 5.67729659e-02f, 3.23004909e-02f, -1.25192963e-02f, 8.44717142e-04f, 7.97024816e-02f, -3.73513927e-03f, 3.23200151e-02f,
  -2.58927047e-02f, 2.28786618e-02f, 3.15696634e-02f, -1.99643839e-02f, 3.17567997e-02f, -1.05570428e-01f, -1.68808158e-02f, 5.43357022e-02f, 4.44113538e-02f, -3.37045640e-02f,
  5.42217605e-02f, -2.09238902e-02f, 6.39926717e-02f, 7.45552313e-03f, -3.14826556e-02f, -1.29802171e-02f, 3.31367105e-02f, -2.78188521e-03f, 2.61401478e-02f, 2.20645946e-02f,
  5.09536088e-01f, -5.42689979e-01f, -3.19033824e-02f, 1.62033007e-01f, 4.59189326e-01f, 1.19020909e-01f, 2.68411398e-01f, 5.83271682e-02f, 8.73729438e-02f, -2.19597638e-01f,
  7.81503320e-02f, -2.32604980e-01f, -2.47842610e-01f, 1.45051433e-02f, 2.32841939e-01f, -1.90095797e-01f, 8.84608477e-02f, -1.16467904e-02f, -4.88746427e-02f, 4.74068569e-03f,
  1.49599701e-01f, 2.12680414e-01f, 4.86278459e-02f, -6.49735630e-02f, 1.48344040e-01f, -1.45712838e-01f, -5.32741398e-02f, -8.07812512e-02f, 9.69916023e-03f, 1.81936696e-01f,
  1.94347836e-02f, 5.63011840e-02f, 2.07614452e-02f, -3.31475101e-02f, -4.60902601e-02f, -3.70523147e-02f, -1.97805800e-02f, 9.51921791e-02f, 2.57133637e-02f, -1.77922659e-02f,
  -9.19969156e-02f, 6.07586140e-03f, 4.89770509e-02f, 2.43807081e-02f, -3.91789712e-02f, 5.99392168e-02f, 3.97940390e-02f, -5.16214743e-02f, -3.25042084e-02f, -2.95194481e-02f,
  1.90514904e-02f, -6.64951205e-02f, 8.41802359e-03f, -2.15924736e-02f, -3.07106860e-02f, 3.07255182e-02f, -2.35154573e-02f, -7.78043568e-02f, -5.09478385e-03f, 4.97672968e-02f,
  6.18275777e-02f, -7.84587786e-02f, 9.46705788e-03f, 4.50084507e-02f, 8.66207201e-03f, 7.67816529e-02f, -7.12121800e-02f, -3.49031202e-02f, -5.35748079e-02f, 3.74510256e-03f,
  2.78495084e-02f, -4.43052053e-02f, -6.37789667e-02f, -8.97852518e-03f, -1.85308792e-02f, 1.95649788e-02f, -2.43527605e-03f, 3.08126211e-02f, -3.20657305e-02f, -6.62600156e-03f,
  8.44761264e-03f, 8.83010100e-04f, 1.98998041e-02f, 4.16895300e-02f, 1.79318842e-02f, 4.46509942e-02f, -3.38948816e-02f, 1.36908155e-03f, 1.00792460e-02f, -1.13093583e-02f,
  -3.91514361e-01f, -3.25612187e-01f, -8.23386088e-02f, 5.42960465e-02f, -2.78328676e-02f, -7.30717704e-02f, -3.31854634e-02f, 2.51115616e-02f, -1.18154556e-01f, 8.18586573e-02f,
  -4.18113731e-02f, 3.42921354e-02f, -6.07337020e-02f, 8.16710815e-02f, -5.85974427e-03f, 3.53318378e-02f, -2.06778422e-02f, -3.97281274e-02f, -6.10989965e-02f, -9.56200212e-02f,
  -2.20560841e-03f, -1.27724474e-02f, 1.74857397e-02f, 7.22831786e-02f, -9.09036919e-02f, 2.22023781e-02f, -1.93356182e-02f, 2.86600161e-02f, -7.11855292e-02f, -2.43809316e-02f,
  8.77533704e-02f, -1.84082851e-01f, -4.02589329e-02f, -1.76212519e-01f, 2.80951355e-02f, -2.64820248e-01f, -2.16673523e-01f, -1.88319460e-01f, -8.06432813e-02f, -2.52349615e-01f,
  -2.00945079e-01f, 1.35606289e-01f, 1.70028821e-01f, -3.33442271e-01f, 3.50375801e-01f, 2.32203215e-01f, -2.24038318e-01f, -8.62740651e-02f, 1.65119991e-01f, -2.65061468e-01f,
  -3.17447484e-02f, -2.02223241e-01f, 6.51880205e-02f, -3.20628017e-01f, -2.49500513e-01f, -1.08643346e-01f, 1.52959391e-01f, -6.27503321e-02f, -3.08089286e-01f, 2.02934630e-03f,
  -5.89011386e-02f, -1.48893610e-01f, -5.55854142e-02f, -2.39663515e-02f, -7.76995197e-02f, -4.82898904e-03f, 5.40135019e-02f, 1.64797641e-02f, 9.82140843e-03f, -3.61653939e-02f,
  8.56974944e-02f, 1.93548035e-02f, -7.75532052e-02f, 4.34875861e-02f, -3.90737019e-02f, -4.54612374e-02f, -6.40897220e-03f, -4.54856902e-02f, -7.47149736e-02f, 9.64494869e-02f,
  6.20859824e-02f, 5.23691364e-02f, 4.02416326e-02f, -3.30244079e-02f, -8.23058560e-03f, -5.82714099e-04f, 3.91275100e-02f, 5.98633476e-02f, 4.81408136e-03f, -2.17565000e-02f,
  6.00844296e-03f, 3.76894996e-02f, 2.09360104e-03f, -6.36120662e-02f, -4.74548861e-02f, -2.67720968e-02f, -3.64385322e-02f, 3.64979431e-02f, 2.67144572e-02f, 1.55739430e-02f,
  -1.25516336e-02f, 4.62340526e-02f, -3.82212289e-02f, -5.71961813e-02f, -4.64807712e-02f, -4.61383797e-02f, 9.44581777e-02f, 8.35544914e-02f, 1.44237177e-02f, 2.83657573e-02f,
  -9.31419432e-03f, -3.96552049e-02f, 6.22832403e-02f, 1.02596506e-02f, -2.10021921e-02f, 1.16716094e-01f, -1.98107562e-03f, 1.76217072e-02f, -2.57885773e-02f, 5.84553294e-02f,
  -2.70760730e-02f, -1.52800113e-01f, -6.61602616e-02f, -6.70832396e-02f, 5.79945110e-02f, 4.37619947e-02f, 2.01426446e-02f, -6.24617226e-02f, -9.39489231e-02f, -1.51000157e-01f,
  -8.09563920e-02f, 6.37171557e-03f, 3.17282714e-02f, -4.69326861e-02f, 1.42383333e-02f, -2.25860123e-02f, -3.79318893e-02f, 2.32779533e-02f, -3.44056971e-02f, 7.67235011e-02f,
  4.22545150e-02f, 2.54040072e-03f, 9.34271440e-02f, -1.76510401e-02f, -7.85940737e-02f, 2.12138379e-03f, -1.61316874e-03f, -4.32392256e-03f, 3.20635289e-02f, 1.85413454e-02f,
  -1.28788978e-01f, -3.85393232e-01f, -2.89709091e-01f, -9.72096696e-02f, 2.45263234e-01f, 1.75042629e-01f, -1.56792328e-01f, -6.54781004e-03f, -1.72572881e-01f, 8.26579034e-02f,
  2.84761912e-03f, -2.21123725e-01f, -4.03735846e-01f, -3.21067363e-01f, -1.59684703e-01f, -3.52483898e-01f, 1.73431095e-02f, -4.43831421e-02f, -1.53218165e-01f, -5.89158311e-02f,
  -1.17072888e-01f, 5.80685819e-03f, -2.63219595e-01f, 2.70832032e-01f, 1.16940238e-01f, 7.71043226e-02f, 2.53852338e-01f, 4.71564755e-02f, 2.27407962e-01f, 1.01517677e-01f,
  8.05976801e-03f, -1.94761902e-01f, -1.46492749e-01f, -1.23992506e-02f, 4.40808050e-02f, 7.81597197e-02f, 1.15432210e-01f, 2.46152543e-02f, 4.87204269e-02f, -1.30061239e-01f,
  1.24667883e-01f, -1.62607096e-02f, -3.40436981e-03f, 2.78426632e-02f, -6.51818663e-02f, -3.48446257e-02f, -6.92902282e-02f, -1.80734284e-02f, -1.18832864e-01f, -1.76593900e-01f,
  -1.40365362e-01f, -2.94949040e-02f, -9.42692626e-04f, -3.17428000e-02f, 8.71816371e-03f, -7.16889724e-02f, 9.22125112e-03f, 3.34045440e-02f, 1.53913438e-01f, 1.11151068e-02f,
  3.09018008e-02f, 1.13907926e-01f, -1.23764230e-02f, -5.80974929e-02f, -6.16462603e-02f, -4.01466116e-02f, -1.58810169e-02f, -2.63742656e-02f, -4.56835888e-02f, -5.90304583e-02f,
  6.08048514e-02f, -7.84480497e-02f, 1.05512387e-03f, 1.03444174e-01f, 3.32703590e-02f, 4.77012359e-02f, 6.56966539e-03f, 2.46063061e-03f, 4.22561131e-02f, -7.83523172e-02f,
  5.73988855e-02f, 4.48834039e-02f, 7.94621408e-02f, 7.54513778e-03f, -3.30054052e-02f, 9.08919349e-02f, 2.22948268e-02f, 1.73122864e-02f, -2.33637774e-03f, 7.86721706e-02f,
  3.75303961e-02f, 6.31126910e-02f, -8.72563720e-02f, 4.51707374e-03f, -6.21106736e-02f, 6.81310669e-02f, 1.33727146e-02f, 4.09610420e-02f, 5.67733310e-02f, 1.96152423e-02f,
  8.73094648e-02f, 2.58176215e-02f, 2.02456191e-01f, -1.49042448e-02f, 3.93915176e-03f, 4.78181764e-02f, 6.10684678e-02f, 1.02637947e-01f, 1.02667257e-01f, 7.97449797e-02f,
  2.09980801e-01f, 1.01129621e-01f, 2.11689211e-02f, 6.87079653e-02f, 1.31863534e-01f, 3.02825663e-02f, 5.97190298e-02f, -1.12899179e-02f, -3.45294029e-02f, 6.69936091e-02f,
  4.24761325e-01f, -1.02130488e-01f, 1.06745131e-01f, 4.60990995e-01f, 3.08772802e-01f, 3.84950601e-02f, -7.56688137e-03f, 3.05851638e-01f, 6.24171615e-01f, -9.14322734e-02f,
  1.42883249e-02f, -8.50906521e-02f, -1.36122331e-01f, 1.26791358e-01f, -1.01254195e-01f, 1.81116890e-02f, 1.07133240e-01f, 7.42624328e-02f, 1.97254673e-01f, 7.39910677e-02f,
  1.89675570e-01f, -9.87642109e-02f, -2.80504793e-01f, -2.16302052e-01f, -4.12893333e-02f, -5.71449148e-03f, -3.23436141e-01f, -2.80254900e-01f, -2.76391000e-01f, -1.73102155e-01f,
  2.91905850e-02f, 1.93091109e-01f, -8.48149806e-02f, -1.00971423e-01f, 1.83896907e-02f, -7.50346333e-02f, -9.45336670e-02f, -2.30829522e-01f, 4.59012426e-02f, -3.76721621e-02f,
  1.98660837e-03f, -5.53861782e-02f, 7.02434033e-02f, -2.12903880e-02f, 3.36083956e-02f, 4.08616923e-02f, 1.12477213e-01f, 3.38394344e-02f, -2.15477925e-02f, -3.92343570e-03f,
  2.87924631e-04f, 3.73916216e-02f, 4.16008532e-02f, -5.15366867e-02f, 7.88613129e-03f, 2.64726598e-02f, -6.75297305e-02f, -7.44855106e-02f, -2.60565933e-02f, -1.14707407e-02f,
  1.71530135e-02f, -1.15872510e-02f, -1.19458742e-01f, -2.68546622e-02f, 4.10577096e-02f, 1.83039661e-02f, 2.35225800e-02f, -5.18987770e-04f, 8.66443664e-02f, 3.16077806e-02f,
  3.61681655e-02f, -1.15587171e-02f, 1.06647640e-01f, 3.90653033e-03f, 3.35644484e-02f, 6.17019646e-02f, -3.40943970e-02f, -1.52297481e-03f, -1.88353658e-03f, -2.41655100e-04f,
  5.00501469e-02f, -1.20513057e-02f, -1.08276673e-01f, -2.50294898e-02f, -1.53722921e-02f, -3.30603011e-02f, -2.13256935e-04f, 7.20816627e-02f, 4.29415256e-02f, -1.09125108e-01f,
  -1.90616213e-02f, -7.39314407e-02f, -3.20356265e-02f, -2.90486421e-02f, 4.24712449e-02f, 6.54615536e-02f, 3.72228734e-02f, 7.63317794e-02f, -5.20077087e-02f, -3.47852670e-02f,
  1.18333837e-02f, 4.15508002e-02f, -4.10154425e-02f, 1.24066100e-02f, -5.03695384e-02f, -6.35588989e-02f, 1.28335459e-02f, -1.60403419e-02f, -8.97765234e-02f, -6.06595054e-02f,
  5.35968272e-03f, 1.24693319e-01f, 1.98183917e-02f, -6.21475326e-03f, 6.50949180e-02f, -2.92976201e-02f, 7.22692534e-02f, -7.64156729e-02f, -7.87065551e-02f, 2.02006865e-02f,
  -1.54857188e-01f, 3.09592694e-01f, 2.06076160e-01f, 8.93280730e-02f, 3.64259700e-03f, -4.22908187e-01f, -1.96518570e-01f, 1.24037422e-01f, 2.09597930e-01f, 7.00023174e-02f,
  3.12990323e-02f, 1.95021003e-01f, 1.33296505e-01f, 7.20580071e-02f, -2.95276821e-01f, -9.29438248e-02f, -1.57848746e-01f, -5.95482253e-02f, -5.50390929e-02f, 9.95732471e-02f,
  -7.36465529e-02f, 3.37850973e-02f, -2.50265673e-02f, 1.54988855e-01f, 1.79899469e-01f, 1.46821052e-01f, -5.34351543e-02f, 8.44147429e-02f, 2.34571490e-02f, 4.68086936e-02f,
  -8.69678780e-02f, 2.06458315e-01f, 5.79550341e-02f, 5.01098074e-02f, -7.23971426e-02f, -3.37235332e-02f, -1.27070233e-01f, 6.54020719e-03f, 1.47229712e-02f, 7.50862015e-03f,
  -5.12426998e-03f, 4.53849025e-02f, 5.13441414e-02f, 1.69588551e-01f, 4.15668935e-02f, 1.55321836e-01f, -3.64968777e-02f, -3.44653092e-02f, 7.28243142e-02f, 3.55470590e-02f,
  1.27091229e-01f, -1.03987409e-02f, -4.09673825e-02f, -2.64925696e-03f, -1.70879532e-03f, 7.31424466e-02f, -1.04748882e-01f, 2.94417776e-02f, -3.26658636e-02f, -1.03521775e-02f,
  -7.02431947e-02f, -2.78964434e-02f, 7.07009658e-02f, 1.41177520e-01f, 8.79361574e-03f, 5.79033010e-02f, -2.96209250e-02f, -3.47936340e-02f, 8.92567635e-03f, -9.43813026e-02f,
  -4.53584194e-02f, -3.55060734e-02f, 3.31556797e-02f, -9.19969454e-02f, -3.75136025e-02f, 1.19118497e-01f, -5.37940189e-02f, 3.88126150e-02f, -8.42870101e-02f, -2.09311731e-02f,
  8.45841244e-02f, -7.26447403e-02f, -9.61513538e-03f, -1.41737610e-01f, 7.69901555e-03f, 8.63365680e-02f, 3.48108895e-02f, -1.02099567e-03f, -5.23086898e-02f, -6.95710033e-02f,
  -2.76879281e-01f, 1.24256268e-01f, -2.25632060e-02f, -4.84573692e-02f, -7.81481713e-02f, 3.51183601e-02f, -4.34766058e-03f, -8.02518707e-03f, -6.15061261e-03f, -3.69741991e-02f,
  2.17158459e-02f, 3.31473653e-04f, -6.51970059e-02f, -6.40326515e-02f, -8.54880661e-02f, -2.55288891e-02f, 3.87959406e-02f, -2.09099464e-02f, -7.02301040e-02f, 5.67291342e-02f,
  -3.99278617e-03f, 3.05574872e-02f, -9.02033672e-02f, -2.70344527e-03f, -4.42361683e-02f, -3.40512879e-02f, 1.63104367e-02f, -3.14793736e-02f, -7.21334293e-02f, -6.84436932e-02f,
  -4.66342062e-01f, 3.42316747e-01f, 2.26277620e-01f, -1.17762290e-01f, 3.91714156e-01f, 3.14887911e-01f, 5.60643710e-03f, 3.14299434e-01f, 1.77677184e-01f, -2.05954060e-01f,
  -2.08830774e-01f, -2.06231356e-01f, -7.00953009e-04f, -1.01853788e-01f, 5.76126240e-02f, 7.97583982e-02f, 1.64742712e-02f, -1.96554616e-01f, 3.19086522e-01f, 7.25519508e-02f,
  1.33294061e-01f, -2.95356326e-02f, 1.52625814e-01f, 2.63338327e-01f, 1.69269536e-02f, -4.89603356e-02f, -2.58738786e-01f, 1.62240326e-01f, -1.94475397e-01f, 1.07384987e-01f,
  -4.83691581e-02f, -2.07316026e-01f, -1.05861068e-01f, -1.06281020e-01f, -9.30627882e-02f, -4.84045595e-02f, -1.20166756e-01f, -3.84667031e-02f, -6.01719171e-02f, 6.58640987e-04f,
  -8.32031220e-02f, 1.55958319e-02f, -2.29702871e-02f, 1.20956730e-02f, 9.72056910e-02f, 9.02074797e-04f, 3.32556814e-02f, 2.15242878e-02f, 8.60803574e-02f, 5.65336309e-02f,
  1.07933573e-01f, 1.01727217e-01f, -1.80899948e-02f, -8.57398137e-02f, 7.07259849e-02f, -6.50338945e-04f, 2.62534693e-02f, -4.80187535e-02f, 4.22798283e-02f, 2.89750490e-02f,
  7.14372173e-02f, 7.03142257e-03f, -4.83239703e-02f, -3.43461074e-02f, 5.37273148e-03f, 6.76857587e-03f, -4.89730276e-02f, -3.58138531e-02f, 9.05256066e-03f, 1.75158009e-02f,
  -8.47106427e-02f, -1.12319529e-01f, 6.68201447e-02f, 7.98357185e-03f, 3.82513157e-03f, -1.05762810e-01f, -7.93710276e-02f, 2.27601435e-02f, 3.44603807e-02f, 4.12058830e-03f,
  -1.96533408e-02f, -2.23794039e-02f, 2.21983995e-02f, -2.56061759e-02f, 9.59385931e-02f, 1.17649101e-01f, -4.46967967e-02f, 5.93132190e-02f, -3.70501988e-02f, 1.63294170e-02f,
  -2.20033340e-02f, -1.09004505e-01f, -9.66119394e-02f, -1.17557026e-01f, -2.15852931e-02f, -6.26421124e-02f, 6.29238039e-02f, 2.99202520e-02f, 4.88823615e-02f, -4.03174646e-02f,
  -2.17671804e-02f, -1.29510492e-01f, 1.63150076e-02f, 5.19333296e-02f, 3.85564193e-03f, 8.23237300e-02f, -4.82086763e-02f, -6.14002906e-02f, -1.73473865e-01f, -6.32644445e-03f,
  -1.43926397e-01f, -4.50342707e-03f, -1.46457385e-02f, 4.70853783e-02f, -6.21654131e-02f, -7.65280947e-02f, 6.77508244e-04f, -3.12693380e-02f, 2.53224783e-02f, 1.00337647e-01f,
  1.36201112e-02f, -2.98213996e-02f, 3.36363882e-01f, 3.92953932e-01f, -3.05537060e-02f, -3.21029633e-01f, -2.11329848e-01f, 1.69889256e-02f, -2.28738710e-02f, -2.48513415e-01f,
  -3.56095806e-02f, 1.77448347e-01f, -1.73115268e-01f, 2.79578596e-01f, 3.06543469e-01f, -1.80914760e-01f, 1.98754579e-01f, 1.75958592e-03f, 6.79450259e-02f, 9.31521431e-02f,
  1.84817687e-01f, 1.00907430e-01f, 3.95815283e-01f, 2.22215399e-01f, 1.39609337e-01f, 3.19419622e-01f, 2.79900879e-01f, 1.48623183e-01f, 3.49025100e-01f, 7.92317539e-02f,
  -2.01925173e-01f, 5.37781268e-02f, 4.07665931e-02f, -1.90103259e-02f, 4.11327113e-04f, -1.00440331e-01f, -4.71745897e-03f, 1.10809758e-01f, 8.76961797e-02f, -4.36243415e-03f,
  -1.13247581e-01f, 2.36428175e-02f, 6.83765262e-02f, -8.56470200e-04f, -8.15913901e-02f, 7.65835121e-02f, 4.01430167e-02f, -6.53791502e-02f, 8.49165246e-02f, 1.64947528e-02f,
  7.31699681e-03f, 1.35219647e-02f, 2.60904208e-02f, -2.22328007e-02f, 5.93593903e-02f, -2.42324751e-02f, 6.16840534e-02f, 8.43270719e-02f, 9.82954260e-03f, 6.11200593e-02f,
  9.32733342e-02f, -1.81151815e-02f, -7.74223432e-02f, -3.84087749e-02f, 1.17408391e-02f, -8.88532028e-03f, 3.33467238e-02f, -2.09233817e-02f, 7.70374388e-02f, -4.81155850e-02f,
  -6.07446395e-02f, 2.80833226e-02f, -2.18997151e-02f, -1.02104850e-01f, -3.98568846e-02f, -1.36612579e-02f, 2.22846586e-02f, 1.91278546e-03f, -5.05643561e-02f, -1.83485225e-02f,
  7.60187507e-02f, 1.34449787e-02f, 9.61681176e-03f, -6.08072914e-02f, -2.83488240e-02f, -1.08156810e-02f, -1.35725727e-02f, -1.31773101e-02f, 1.49907190e-02f, 7.57407993e-02f,
  -1.76198557e-01f, 2.00991407e-01f, 8.03038199e-03f, -1.25837028e-01f, 4.08404134e-02f, -3.50181721e-02f, 1.12146318e-01f, -2.41663326e-02f, 1.01254985e-01f, -4.63183783e-02f,
  -8.60236213e-02f, -2.55103372e-02f, -9.69007090e-02f, 2.43557757e-03f, 5.37185371e-02f, -2.54668184e-02f, -5.94530022e-03f, 3.75647806e-02f, -1.83112994e-02f, 8.56432915e-02f,
  2.08555162e-02f, -7.23864585e-02f, 5.87643348e-02f, -2.50275340e-02f, -4.66987491e-02f, -1.34294424e-02f, -1.88251007e-02f, 7.75042176e-03f, 6.54185638e-02f, 1.06765479e-01f,
  3.50120515e-01f, 1.66865706e-01f, 7.22130686e-02f, 1.41041698e-02f, -1.59780160e-01f, -3.55279259e-02f, 1.48570295e-02f, -1.27884954e-01f, -1.15024917e-01f, 8.14162865e-02f,
  -3.35462838e-02f, 1.27819479e-01f, -5.25399111e-02f, -2.06725076e-02f, -1.14036746e-01f, -1.78360820e-01f, 2.75905547e-03f, 1.48999775e-02f, -5.46070673e-02f, 2.57887989e-01f,
  2.86152102e-02f, -4.84795272e-02f, -7.93788135e-02f, -5.23408614e-02f, 1.36179239e-01f, 1.30591124e-01f, 7.19787478e-02f, 2.33826619e-02f, 1.56796128e-01f, -8.75967965e-02f,
  1.82748633e-03f, -6.24586493e-02f, 5.35690077e-02f, 3.51997442e-03f, 3.91267724e-02f, 1.40601248e-01f, 4.55874912e-02f, -1.82576962e-02f, -3.85519452e-02f, -3.06035765e-03f,
  1.47822211e-02f, -9.94461868e-03f, -3.32633443e-02f, 1.02259703e-02f, 8.68948456e-03f, 2.56399903e-02f, 3.48641649e-02f, 1.11744518e-03f, -9.02068093e-02f, 1.18657961e-01f,
  5.94997853e-02f, 1.58293266e-02f, 2.46375818e-02f, 2.31806953e-02f, -9.05459002e-03f, 6.84496202e-03f, 8.38409737e-02f, 1.00489743e-01f, -2.43268032e-02f, -2.49529760e-02f,
  8.23299885e-02f, 1.00715095e-02f, -5.06804371e-03f, -7.11994246e-02f, 1.00919073e-02f, -2.54136100e-02f, -4.74142805e-02f, 7.68045755e-03f, 2.89865118e-02f, 4.89061400e-02f,
  -2.46692486e-02f, -3.59997340e-02f, -9.93994251e-02f, 4.90601249e-02f, 4.76774685e-02f, -2.06955839e-02f, 6.93688244e-02f, 3.73469070e-02f, 5.83670214e-02f, 2.86436127e-03f,
  -5.57415523e-02f, 3.97587642e-02f, 4.23195120e-03f, -1.83344074e-02f, -9.40559134e-02f, -5.26693240e-02f, 1.85810924e-02f, 2.17899363e-02f, 1.51533931e-02f, -6.52721524e-02f,
  2.08411403e-02f, 1.37940630e-01f, 2.11599562e-02f, -6.80168644e-02f, -2.08702851e-02f, 6.66040182e-02f, -4.60554212e-02f, 2.30229199e-02f, 4.68603708e-02f, -1.40469568e-02f,
  9.76204723e-02f, 1.76531300e-02f, 2.39735395e-02f, 3.24775022e-03f, -1.32561196e-02f, 5.54700494e-02f, 2.72611286e-02f, 5.18501252e-02f, -1.03599532e-02f, 3.56582478e-02f,
  8.35018232e-02f, 8.54633898e-02f, -2.02483200e-02f, 9.70054045e-03f, 5.99734075e-02f, 2.95660850e-02f, 6.82058111e-02f, 2.70501673e-02f, 7.73460139e-04f, 1.25232460e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.39190206e-01f, 2.57066816e-01f, 3.44513208e-01f, 2.51561940e-01f, 3.42322350e-01f, 3.70230883e-01f, 1.33418366e-01f, 6.91001862e-02f, 1.49063855e-01f, 5.63233383e-02f,
  2.42074102e-01f, 2.00439483e-01f, 1.21616840e-01f, 2.77453423e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  7.33525231e-02f, 3.21767665e-02f, -5.10327406e-02f, -2.96827853e-02f, -1.67184785e-01f, 5.71343955e-03f, -1.03806145e-01f, -2.25054715e-02f, 1.24780498e-02f, 4.08720188e-02f,
  -1.02093570e-01f, -2.62781624e-02f, -1.76651239e-01f, -1.47416699e-03f, -4.90271039e-02f, -9.44597200e-02f, -3.29875038e-04f, -2.66624689e-02f, -8.95959809e-02f, 4.50307243e-02f,
  -9.78304744e-02f, -1.44950114e-02f, 4.81270850e-02f, 1.11056283e-01f, 4.43496741e-03f, 2.13459909e-01f, 8.48669335e-02f, -9.55652744e-02f, -1.94998123e-02f, 8.69300887e-02f,
  5.11593223e-02f, 2.06357971e-01f, 1.10634029e-01f, 1.39749631e-01f, -9.95054990e-02f, 4.53937426e-02f, -1.08807713e-01f, 5.14489673e-02f, 2.03671068e-01f, -1.65164337e-01f,
  -1.49885982e-01f, 6.87341169e-02f, 1.44452639e-02f, 2.52765864e-02f, 1.89400122e-01f, -1.84834406e-01f, 4.73297834e-02f, 3.73196378e-02f, 8.41178223e-02f, -1.03881247e-01f,
  6.16472661e-02f, -1.81029350e-01f, -5.54559715e-02f, 1.21919863e-01f, -1.46900803e-01f, 6.03443086e-02f, -2.10346803e-01f, -1.59303874e-01f, -1.41904607e-01f, -1.09744564e-01f,
  2.04200685e-01f, 6.36757761e-02f, 7.59251416e-02f, -9.72710997e-02f, 1.11355610e-01f, 1.32307500e-01f, -1.39531307e-02f, -1.33920861e-02f, -3.35144401e-02f, 9.80579183e-02f,
  -4.78676260e-02f, 7.61583149e-02f, 1.58806369e-01f, 3.88791747e-02f, -9.34881493e-02f, 2.73023220e-03f, -1.36410855e-02f, 9.49820280e-02f, -1.33674771e-01f, -1.20924283e-02f,
  -1.98712666e-02f, 6.24794653e-03f, 8.14256351e-03f, 5.82324564e-02f, -3.84122245e-02f, 4.90320027e-02f, 9.49251726e-02f, 2.34910920e-01f, 7.16123031e-03f, -4.47930349e-03f,
  1.27596304e-01f, 5.70039004e-02f, -1.74022913e-01f, 1.06250867e-01f, 1.21079884e-01f, -1.02581978e-02f, 4.95840833e-02f, 1.58886120e-01f, 5.67960627e-02f, -1.39792740e-01f,
  -8.18893984e-02f, -4.83215339e-02f, 1.13774806e-01f, 7.80988708e-02f, -1.48109913e-01f, 7.72221684e-02f, -2.71884934e-03f, 1.61264706e-02f, 2.40165606e-01f, -1.34088591e-01f,
  2.43818387e-01f, -4.96235192e-02f, 1.41700462e-01f, 4.62536290e-02f, 7.17275664e-02f, -1.70451969e-01f, 1.77182518e-02f, 1.37342453e-01f, -1.41501904e-01f, 2.78243810e-01f,
  -5.30930348e-02f, 1.03260435e-01f, -1.66433334e-01f, 2.74773449e-01f, 2.44070873e-01f, 1.15396403e-01f, 5.80801703e-02f, -6.79297596e-02f, -1.08625822e-01f, 2.74376835e-05f,
  -3.05316187e-02f, -2.86916047e-02f, 4.70831953e-02f, 7.88742793e-04f, -1.46530885e-02f, -6.13759309e-02f, -1.04574502e-01f, -4.74926308e-02f, 1.91302791e-01f, 3.13075036e-02f,
  -3.04002464e-02f, -8.71728361e-02f, 5.57221696e-02f, 7.84779899e-03f, 1.90671161e-02f, 2.65100598e-02f, -3.95010374e-02f, -8.41527358e-02f, 4.86101583e-02f, -6.45481423e-03f,
  4.35270779e-02f, -1.81626454e-01f, 1.57651724e-03f, 1.32170469e-01f, -1.54257059e-01f, -8.94494057e-02f, 2.03372553e-01f, -2.02697247e-01f, -1.11587740e-01f, 1.79949731e-01f,
  7.55263269e-02f, -8.55107978e-02f, -4.48369198e-02f, 8.08785111e-02f, 2.36331940e-01f, -4.41138819e-02f, 1.20081522e-01f, -1.37453705e-01f, 7.30998814e-02f, 3.35750952e-02f,
  7.06510246e-02f, -3.38203795e-02f, -4.92051765e-02f, 1.53827861e-01f, -1.87981114e-01f, -1.67302620e-02f, -5.57597652e-02f, -1.12093203e-01f, 7.30141923e-02f, 1.68237567e-01f,
  -1.35512725e-01f, -7.95478672e-02f, 1.97251424e-01f, -1.83975995e-01f, 5.53763732e-02f, -1.63325340e-01f, 2.73922801e-01f, -9.01754797e-02f, -1.79471061e-01f, -1.76653013e-01f,
  1.26033500e-01f, 1.06876142e-01f, 1.01436609e-02f, 7.07799122e-02f, 6.55482188e-02f, 9.29991677e-02f, 1.37341425e-01f, 6.65188134e-02f, 1.01104766e-01f, 1.55736431e-01f,
  1.96235385e-04f, 6.71566799e-02f, -3.51314358e-02f, 1.25604756e-02f, 1.83548003e-01f, 1.09120078e-01f, -5.52182412e-03f, 5.96305504e-02f, 6.40065176e-03f, 1.56778187e-01f,
  -3.49383093e-02f, -1.33253010e-02f, 1.64621651e-01f, -2.61090919e-02f, 1.68409467e-01f, 9.07587186e-02f, 1.08464867e-01f, -2.09924668e-01f, -2.45996982e-01f, 3.17061432e-02f,
  2.61664595e-02f, -1.76506881e-02f, -2.49540105e-01f, -1.35135591e-01f, -1.40498534e-01f, -1.38988107e-01f, 2.50606984e-01f, -1.62562445e-01f, 1.56165749e-01f, -8.93185064e-02f,
  -1.55591458e-01f, 3.15947920e-01f, -1.31592117e-02f, -1.16759539e-01f, 1.07789993e-01f, -6.54776096e-02f, -2.08576228e-02f, 6.43796697e-02f, 3.89128700e-02f, -1.80370007e-02f,
  -1.32867187e-01f, -1.63933679e-01f, -2.29810566e-01f, -2.09571138e-01f, -6.99749291e-02f, -7.93504491e-02f, 1.24989778e-01f, 4.95835729e-02f, 3.63791957e-02f, -9.90288034e-02f,
  -1.05456613e-01f, 2.51579463e-01f, -8.75299796e-02f, 1.06600121e-01f, -6.72307163e-02f, 2.46441051e-01f, -1.11547917e-01f, -5.07996306e-02f, 7.32629001e-03f, 7.88512081e-02f,
  -1.28796604e-02f, -6.39976040e-02f, 1.22180648e-01f, 4.37093899e-02f, -2.26596948e-02f, -1.14688694e-01f, -1.14062652e-01f, -1.98857691e-02f, 9.06873792e-02f, -1.30687132e-01f,
  1.01171106e-01f, 8.08092486e-03f, 1.28231809e-01f, -7.70343170e-02f, -2.72215866e-02f, 4.45306599e-02f, -9.86026321e-03f, 6.65528104e-02f, -2.77518351e-02f, -2.10760668e-01f,
  -3.81621160e-02f, -6.95260689e-02f, 8.51917267e-02f, 6.26024231e-02f, 7.31147602e-02f, -1.00745305e-01f, -1.48807257e-01f, -6.34964257e-02f, 9.95616242e-02f, 2.91519538e-02f,
  -1.50562793e-01f, 1.58606783e-01f, -1.48413584e-01f, 7.88686983e-03f, -1.22541063e-01f, -5.10630123e-02f, 1.36739209e-01f, -1.55872181e-01f, -2.60744058e-02f, 2.28266373e-01f,
  -2.03681365e-01f, 4.74524386e-02f, -3.19316275e-02f, 2.37577066e-01f, -6.80710897e-02f, -2.13374034e-01f, 1.07069731e-01f, 5.43374717e-02f, 1.73244864e-01f, 4.79228161e-02f,
  1.40383527e-01f, 6.49269521e-02f, -2.36820951e-01f, 2.64378041e-02f, -1.73866838e-01f, -1.72944337e-01f, 1.68715026e-02f, 8.16381276e-02f, -2.07120374e-01f, -1.30103141e-01f,
  1.72859624e-01f, -4.91020232e-02f, -8.13527629e-02f, 7.91783705e-02f, -1.25460520e-01f, 3.85408662e-02f, -8.54398981e-02f, 4.78083007e-02f, -6.34379918e-04f, 3.75463851e-02f,
  -7.16097131e-02f, -1.24782808e-01f, -9.52314064e-02f, 2.00007670e-02f, -1.27668500e-01f, -6.27292842e-02f, -4.13244367e-02f, 9.78559908e-03f, -7.86514729e-02f, 5.64689189e-03f,
  -7.48865679e-02f, -2.34475248e-02f, -2.38828156e-02f, 2.16703534e-01f, 4.10017557e-02f, -8.82824212e-02f, 2.31557488e-02f, 3.01631950e-02f, -6.17861152e-02f, 1.17469646e-01f,
  5.29477000e-02f, -9.10280123e-02f, -4.73567247e-02f, 3.32404859e-03f, 6.77385032e-02f, -1.33641884e-01f, -9.61573720e-02f, 6.40286282e-02f, -3.74593772e-02f, 2.16515034e-01f,
  -1.43687934e-01f, 8.34946558e-02f, 6.40713796e-02f, -4.87121716e-02f, 2.31961578e-01f, -2.00843886e-01f, 1.45903543e-01f, 5.24224192e-02f, -9.49939154e-03f, 1.61050469e-01f,
  -9.41420496e-02f, -2.30102539e-01f, -1.59193829e-01f, -6.89297020e-02f, -1.86177865e-01f, 1.22984834e-01f, 6.03725910e-02f, -2.19122127e-01f, -2.02038422e-01f, 2.64424562e-01f,
  1.59916013e-01f, -8.56217593e-02f, -1.22582234e-01f, -7.04112276e-02f, -4.83845100e-02f, -6.96175694e-02f, -7.16009289e-02f, -1.15341291e-01f, -1.35696799e-01f, -6.83445111e-02f,
  -1.62627459e-01f, -4.26621065e-02f, -2.21461669e-01f, -9.33410004e-02f, 6.53130412e-02f, 1.46182459e-02f, -2.06715822e-01f, -9.73279178e-02f, -1.78510919e-01f, -1.26307845e-01f,
  -1.93615571e-01f, 6.76258728e-02f, -1.46583974e-01f, -1.17034435e-01f, 1.22521846e-02f, -1.63570598e-01f, 5.27326874e-02f, -1.45086288e-01f, 2.14119647e-02f, 2.92574883e-01f,
  -1.79176614e-01f, -9.93107036e-02f, 1.81402549e-01f, -1.07121810e-01f, 9.61191058e-02f, 1.89523295e-01f, -5.00047393e-03f, -1.21066019e-01f, -2.85336562e-03f, 5.14461547e-02f,
  2.76803434e-01f, -1.30948544e-01f, 2.13618487e-01f, -6.70909137e-02f, -1.63498774e-01f, 2.36991674e-01f, 1.20665453e-01f, -1.83354750e-01f, 2.21429035e-01f, -4.08468349e-03f,
  -2.02827126e-01f, -2.36200467e-01f, 5.01032025e-02f, 1.72231212e-01f, -5.54115586e-02f, 3.73328216e-02f, -2.45730117e-01f, -4.96355183e-02f, -1.20129930e-02f, -6.39752820e-02f,
  1.74222559e-01f, -3.58981714e-02f, 1.39724076e-01f, 1.17487796e-01f, -1.62164822e-01f, -2.70905077e-01f, 7.94731751e-02f, -4.12958935e-02f, 1.46066427e-01f, 7.42165446e-02f,
  -5.47656305e-02f, 1.16929173e-01f, 9.81428623e-02f, 7.53308013e-02f, -5.01814298e-02f, 3.32918167e-02f, 1.22014051e-02f, 9.00583863e-02f, -9.68859047e-02f, -7.52034783e-02f,
  -4.83725592e-03f, 5.69899045e-02f, -4.53352444e-02f, 6.11882135e-02f, 1.89265737e-03f, 8.94634649e-02f, -4.74872217e-02f, 6.35110289e-02f, 2.47115009e-02f, 8.62834603e-02f,
  7.17464909e-02f, 9.58291739e-02f, 4.65046009e-03f, -1.95491433e-01f, 8.81520510e-02f, -1.79904532e-02f, 8.09100550e-03f, 4.31832895e-02f, -3.60715650e-02f, -7.56217465e-02f,
  -4.01510596e-02f, -7.91649297e-02f, -3.05597298e-02f, -9.07251164e-02f, -5.73898815e-02f, 1.05275959e-01f, -1.46924973e-01f, 1.99863344e-01f, -1.17796427e-02f, -9.56969634e-02f,
  1.05154011e-02f, 1.29758969e-01f, -3.67466658e-02f, -1.09598912e-01f, 2.63721228e-01f, 8.68422166e-02f, -1.27019346e-01f, -1.15811214e-01f, 7.07040727e-03f, -1.45311788e-01f,
  -5.68481870e-02f, -3.12295882e-03f, -9.11859646e-02f, 3.58609222e-02f, 1.38067482e-02f, -2.28844583e-01f, -1.08999200e-01f, 2.30132371e-01f, 1.54076099e-01f, 1.93666935e-01f,
  -1.80692002e-01f, -1.14580691e-01f, 9.82848033e-02f, -4.52622306e-03f, -5.69878630e-02f, -7.08329529e-02f, -1.28153428e-01f, -1.66658405e-02f, -1.66592989e-02f, -7.04363137e-02f,
  1.06482960e-01f, 1.72931496e-02f, -7.38676861e-02f, 1.48629984e-02f, -1.37145385e-01f, 8.10031369e-02f, -3.14446986e-02f, -4.12779637e-02f, -9.34109017e-02f, -4.19948436e-02f,
  1.28472047e-02f, -1.58905070e-02f, -1.13142915e-01f, 7.40082376e-03f, 1.83609780e-02f, 2.07478926e-01f, 7.86145497e-03f, 9.50231478e-02f, 7.61985928e-02f, 3.08700688e-02f,
  -1.81110039e-01f, 3.88146117e-02f, 2.51500279e-01f, 9.23442282e-03f, -1.29252702e-01f, 7.25039244e-02f, 1.78264260e-01f, -1.26810461e-01f, 2.89578848e-02f, -1.04191959e-01f,
  1.19721256e-01f, 3.53825986e-02f, -1.76001102e-01f, 1.52974531e-01f, 9.07018036e-02f, -1.47859216e-01f, 2.20070511e-01f, 1.23617370e-02f, 8.81244838e-02f, -1.04103886e-01f,
  1.18497118e-01f, 2.89378524e-01f, 7.94010460e-02f, -4.16636840e-03f, -9.13176802e-04f, 1.94924623e-02f, -1.99605793e-01f, 2.25633875e-01f, 2.02246457e-01f, 1.82091415e-01f,
  -3.36623825e-02f, 8.96701664e-02f, 1.71305105e-01f, -7.47503862e-02f, 8.17554519e-02f, -7.01474100e-02f, -2.77394950e-02f, -4.63599013e-03f, -4.47621159e-02f, 7.21078217e-02f,
  -1.06200472e-01f, 4.22134735e-02f, 1.99989378e-02f, 3.49624045e-02f, 1.08962305e-01f, -3.03423014e-02f, -1.50142267e-01f, 3.41006406e-02f, 2.91157467e-03f, -6.59904480e-02f,
  8.04518238e-02f, 5.11838645e-02f, 8.42029005e-02f, -1.91580698e-01f, 1.16844133e-01f, 5.68151884e-02f, -3.54375094e-02f, 1.43199116e-01f, -1.17060468e-01f, -1.74368266e-02f,
  6.25477405e-03f, 7.41330627e-03f, 1.56827286e-01f, 8.10695216e-02f, -1.73989058e-01f, 2.13072941e-01f, -1.64002012e-02f, 8.00705887e-03f, 1.81936800e-01f, 2.04462245e-01f,
  -1.25787333e-01f, 7.73960911e-03f, -2.66766161e-01f, 2.02426031e-01f, -7.76896700e-02f, -1.02221228e-01f, 9.68227386e-02f, -6.75236359e-02f, -3.21528576e-02f, 1.29814550e-01f,
  3.14073749e-02f, -9.98213589e-02f, 3.81721929e-03f, 2.55387038e-01f, 5.32194190e-02f, -5.06031066e-02f, 1.92619294e-01f, -3.48938331e-02f, 1.96650922e-01f, 1.30334765e-01f,
  -9.56737176e-02f, 9.99249369e-02f, -2.63966560e-01f, 1.02668554e-01f, -1.00696810e-01f, -1.66797116e-01f, 1.00809209e-01f, 9.76379141e-02f, -1.93500727e-01f, -7.80930594e-02f,
  6.36291727e-02f, 1.23707606e-02f, 7.31710121e-02f, -2.28724312e-02f, 7.73799047e-02f, -1.29627285e-03f, -3.82397696e-02f, -4.22790181e-03f, -2.86205001e-02f, 1.12648606e-01f,
  8.83805230e-02f, -3.59358862e-02f, 1.58817098e-02f, 1.24158695e-01f, -6.46900237e-02f, 9.70332921e-02f, -1.44659996e-01f, 2.07132131e-01f, -5.06035872e-02f, -6.60667568e-02f,
  1.06505878e-01f, -9.04032513e-02f, 1.21109806e-01f, 1.16860859e-01f, 7.88967684e-03f, -1.58503398e-01f, -1.80364013e-01f, -6.15358576e-02f, 4.31818105e-02f, -5.81158623e-02f,
  1.78999286e-02f, -1.14770681e-01f, -2.55399495e-01f, -1.90376386e-01f, 1.64354235e-01f, -9.22321230e-02f, 1.66437179e-01f, -6.17845841e-02f, -2.86890529e-02f, 1.34869844e-01f,
  -2.43423153e-02f, 3.93603556e-02f, -3.34853336e-04f, -1.66119084e-01f, -5.77036776e-02f, 1.24936350e-01f, 7.16365278e-02f, -2.26367027e-01f, -8.29328671e-02f, 1.88128203e-01f,
  -2.02756599e-01f, -2.93906555e-02f, -1.13279648e-01f, -1.64478973e-01f, 4.71419059e-02f, -1.04722597e-01f, 2.77016282e-01f, -9.48851034e-02f, 1.35583475e-01f, 2.39847645e-01f,
  -1.86828181e-01f, -4.79080193e-02f, 1.06570669e-01f, 1.12758450e-01f, 1.49081871e-01f, 7.39303008e-02f, -7.89913535e-03f, -6.42644465e-02f, 2.85106525e-02f, 3.88105698e-02f,
  -1.43686563e-01f, -8.81566480e-02f, 5.02808839e-02f, 7.07457811e-02f, 6.12436384e-02f, -1.27553130e-02f, -2.94894613e-02f, 1.11209221e-01f, -7.45654628e-02f, 2.60415096e-02f,
  -1.05453871e-01f, 6.57200292e-02f, 5.36563061e-03f, -8.13356712e-02f, -1.35335373e-02f, -2.43643229e-03f, -2.43943315e-02f, 2.29482114e-01f, 3.68289761e-02f, -6.48356006e-02f,
  -4.91949022e-02f, 3.25237103e-02f, -1.20021075e-01f, 1.13539202e-02f, 1.69781148e-01f, -1.46552343e-02f, -1.70602486e-01f, -8.98464248e-02f, 2.06847548e-01f, -2.35537887e-01f,
  1.52756810e-01f, -6.49579540e-02f, 6.89050704e-02f, 1.12747476e-01f, -1.41933635e-01f, 1.24118648e-01f, 1.28028214e-01f, -2.15730712e-01f, 1.87365606e-01f, -1.16655584e-02f,
  1.45102918e-01f, -1.97922125e-01f, 1.66648924e-02f, 2.26802662e-01f, -1.40259311e-01f, -2.87058391e-02f, -1.36391759e-01f, -7.18984157e-02f, -1.21682554e-01f, -2.58796830e-02f,
  2.32861742e-01f, -2.98132766e-02f, 1.33401453e-01f, 2.37019911e-01f, -6.41470477e-02f, -1.17125720e-01f, 1.68613091e-01f, 4.99038175e-02f, 4.09679599e-02f, -2.78371107e-02f,
  5.33537343e-02f, -8.76417607e-02f, 5.20511530e-02f, 3.02936509e-02f, -7.96479546e-03f, -1.40858620e-01f, -1.89880617e-02f, -5.86830527e-02f, 1.28709912e-01f, 9.64151509e-03f,
  -1.11945875e-01f, 4.18429784e-02f, 1.29501536e-01f, 9.33650136e-02f, 2.55002473e-02f, 1.57940648e-02f, 9.66492295e-02f, 9.19898078e-02f, 5.89322969e-02f, 6.57562912e-02f,
  -5.08296005e-02f, -1.01598185e-02f, -5.44334017e-02f, 3.85458805e-02f, 1.54979736e-01f, -5.71736582e-02f, -8.22491795e-02f, 9.27997306e-02f, 1.61468461e-01f, -6.57806695e-02f,
  -4.03950103e-02f, 3.45834792e-02f, -1.78999230e-01f, 1.14028260e-01f, -1.21083811e-01f, 1.60554767e-01f, -2.36114822e-02f, -1.75546944e-01f, 1.56815678e-01f, -2.40062885e-02f,
  -1.35522857e-01f, 3.77354063e-02f, -1.44325420e-01f, 2.91108396e-02f, 2.30983719e-02f, -1.04272529e-01f, 3.76489721e-02f, 2.07370564e-01f, 3.62783521e-02f, 2.19763622e-01f,
  6.65358752e-02f, 2.47093849e-02f, -1.30455554e-01f, -2.17157036e-01f, 1.13429248e-01f, 1.21702939e-01f, 2.04130337e-01f, -1.87104732e-01f, -1.74419239e-01f, -4.26979624e-02f,
  -5.63554317e-02f, -4.03998494e-02f, -5.79399988e-02f, -8.63225386e-02f, 1.62857771e-02f, 3.89128402e-02f, 1.37630820e-01f, -7.52319619e-02f, 3.84017900e-02f, -1.54442918e-02f,
  -1.35111526e-01f, -5.67124896e-02f, 3.87978144e-02f, -8.54241773e-02f, 1.48654580e-01f, -1.19349144e-01f, -4.70918827e-02f, -3.83448713e-02f, -5.62287308e-02f, 4.64906283e-02f,
  -6.74378797e-02f, -1.16713149e-02f, 3.51721942e-02f, -1.67805254e-02f, -4.62843366e-02f, -1.88847914e-01f, 1.13017475e-02f, -1.52141675e-01f, -6.02516606e-02f, 2.08316389e-02f,
  2.22042337e-01f, -2.36496136e-01f, -8.93032029e-02f, -7.18177259e-02f, -1.53394816e-02f, -2.16643646e-01f, -5.15761673e-02f, 3.18966690e-03f, 1.64051354e-01f, -1.10680901e-01f,
  -1.42559677e-01f, 7.96253532e-02f, 1.06400713e-01f, -4.28237244e-02f, -2.00888533e-02f, 6.81874249e-03f, -1.78162307e-01f, 5.87097071e-02f, -6.90108985e-02f, -1.94346476e-02f,
  -1.49707854e-01f, -6.15640730e-02f, -4.74727303e-02f, 1.03325158e-01f, -4.24844176e-02f, -2.28662118e-01f, 1.81550264e-01f, -1.36493698e-01f, 1.74180567e-01f, -1.65891528e-01f,
  1.11734115e-01f, 1.35992512e-01f, -1.59583271e-01f, -1.57035097e-01f, -4.78444397e-02f, -6.21747449e-02f, 8.59007332e-03f, -7.00927898e-02f, -1.02094160e-02f, -1.32141292e-01f,
  1.11232467e-01f, -3.06775738e-02f, 5.27668931e-02f, -4.80934009e-02f, 6.48079440e-02f, -5.51375896e-02f, 6.44583479e-02f, -5.44098206e-02f, -7.85467327e-02f, 1.25513852e-01f,
  6.80254698e-02f, 5.55157773e-02f, -8.85640085e-02f, 1.02608934e-01f, 1.30074352e-01f, 5.29509224e-02f, 6.69741780e-02f, -5.65578714e-02f, -5.81416190e-02f, 3.35191973e-02f,
  -3.51652913e-02f, -1.46386679e-02f, 1.02411374e-01f, -5.72552048e-02f, -9.34427977e-02f, 9.69892070e-02f, 2.08140358e-01f, -1.21463850e-01f, -2.04954669e-01f, -7.35834837e-02f,
  6.75321892e-02f, 1.10892609e-01f, 3.35895456e-02f, -1.75712854e-02f, -1.51414759e-02f, 2.11766046e-02f, 1.22497305e-01f, 1.22756455e-02f, -1.82170123e-01f, -3.15226763e-02f,
  -1.17985219e-01f, 6.92376569e-02f, 1.44309655e-01f, -2.54069358e-01f, 1.15844540e-01f, 2.72464663e-01f, -1.59918442e-01f, 5.86097389e-02f, 3.90414633e-02f, 7.05778152e-02f,
  -2.06280500e-01f, -1.46207884e-01f, 2.65979171e-01f, 2.16216728e-01f, 4.17207442e-02f, -1.04981534e-01f, -1.53399855e-01f, 4.78005297e-02f, -4.24798504e-02f, -1.18147515e-01f,
  -3.20754535e-02f, -1.82648934e-03f, 5.62839322e-02f, -3.21165472e-02f, 1.16817348e-01f, -4.94876429e-02f, 5.78595512e-02f, -1.45133197e-01f, 1.08159341e-01f, -1.03945211e-01f,
  7.53669813e-02f, -4.84249182e-02f, 5.16635589e-02f, -2.20650584e-02f, 1.55045807e-01f, 5.03233224e-02f, 1.12559889e-02f, -4.68111550e-03f, 1.66088104e-01f, 1.34251341e-01f,
  6.14925511e-02f, 3.50021459e-02f, -1.74814790e-01f, -7.48621076e-02f, -7.61470422e-02f, -7.38403052e-02f, 2.60250002e-01f, 7.66175985e-02f, 5.03277630e-02f, -1.28171533e-01f,
  1.51072830e-01f, -5.14308624e-02f, 3.09905596e-02f, -6.03033677e-02f, -1.03184603e-01f, 8.40535313e-02f, -6.65493682e-02f, -5.76837175e-02f, -3.37514430e-02f, -5.87177910e-02f,
  2.35635474e-01f, -5.80591261e-02f, -1.98292285e-01f, 9.93431732e-02f, -1.65015459e-01f, 1.29333913e-01f, 1.00939177e-01f, -4.39638346e-02f, 7.19025061e-02f, 1.69261917e-01f,
  1.79784045e-01f, 2.86115050e-01f, 1.49961457e-01f, -3.89115810e-02f, -3.06408778e-02f, -1.27843469e-01f, 2.20871300e-01f, 1.44873589e-01f, 1.18897170e-01f, -1.21079423e-01f,
  -1.62530113e-02f, -1.11978747e-01f, -7.56371915e-02f, -1.52314410e-01f, -4.36235107e-02f, -4.04122919e-02f, -1.67015586e-02f, 1.15789429e-04f, -4.60640416e-02f, 3.99722084e-02f,
  4.26063836e-02f, 1.47965923e-01f, -6.48845956e-02f, 2.03484558e-02f, 3.28028165e-02f, -1.72572862e-03f, 1.11133814e-01f, -2.41802670e-02f, -1.32816255e-01f, 6.29480649e-03f,
  -3.38888317e-02f, -6.39586337e-03f, -5.99760190e-02f, -1.53829619e-01f, 9.72127020e-02f, -5.87468073e-02f, 6.50807172e-02f, 6.37200242e-03f, 4.41953689e-02f, -1.36211157e-01f,
  -2.43718892e-01f, 4.60226871e-02f, 1.15750179e-01f, 1.25937192e-02f, -1.85440347e-01f, 1.02165034e-02f, -7.91576430e-02f, -1.31363526e-01f, 2.45177776e-01f, -1.45183623e-01f,
  1.18534118e-01f, -8.37174580e-02f, -1.23627581e-01f, 2.81999677e-01f, -4.38170247e-02f, 4.64923754e-02f, 1.31269336e-01f, -1.47135943e-01f, 4.02652770e-02f, 5.43921366e-02f,
  -1.13368072e-01f, 1.62536968e-02f, -9.50299725e-02f, -2.21163351e-02f, -2.07237780e-01f, -1.85956180e-01f, -1.73904702e-01f, -2.09804714e-01f, 1.40387580e-01f, -2.82737818e-02f,
  4.33554612e-02f, -4.93897647e-02f, -9.75197032e-02f, 2.70745486e-01f, -1.72895312e-01f, -1.37587830e-01f, -7.07157701e-02f, 1.92005277e-01f, 8.55266675e-02f, -1.17555819e-02f,
  1.30354107e-04f, 5.53712100e-02f, 1.88989460e-01f, -1.59440208e-02f, 8.69573131e-02f, 8.23903829e-03f, 7.03167543e-03f, 3.37109193e-02f, 3.18227559e-02f, -4.39451784e-02f,
  8.46397653e-02f, 7.56103396e-02f, 6.69075176e-02f, 1.28043845e-01f, -5.95971420e-02f, 3.84149700e-02f, 4.64415960e-02f, 1.06293373e-01f, 6.98037148e-02f, 7.10038915e-02f,
  -5.95656708e-02f, 3.07657532e-02f, -5.89490347e-02f, -2.02066675e-01f, 8.65945742e-02f, 1.65560544e-02f, -3.19372006e-02f, -3.12441420e-02f, 3.59101081e-03f, -2.18808919e-01f,
  -1.76731586e-01f, -1.14516310e-01f, -5.88757731e-02f, 1.54912639e-02f, -1.43636707e-02f, 6.15330264e-02f, -1.96699992e-01f, 6.46394789e-02f, 1.29694164e-01f, -7.93414712e-02f,
  -8.25084448e-02f, 3.80833410e-02f, -1.50308922e-01f, 6.75171893e-03f, 1.27193153e-01f, -8.38695616e-02f, -9.63096619e-02f, 1.16000541e-01f, -1.46328434e-01f, 7.25269467e-02f,
  4.18221317e-02f, -9.49611664e-02f, -4.19326127e-02f, -1.80675462e-01f, 2.35906631e-01f, -3.65815200e-02f, 3.32129486e-02f, 9.46701542e-02f, -1.29185185e-01f, 1.14367381e-01f,
  -1.08425081e-01f, 1.88934226e-02f, -1.71563067e-02f, -5.87978847e-02f, 4.61145490e-03f, -2.10977695e-03f, -1.72384843e-01f, 2.56311968e-02f, -1.65707842e-02f, -7.43378606e-03f,
  -4.34525870e-02f, -5.40707670e-02f, 8.95950645e-02f, -6.28003106e-02f, -1.06842659e-01f, -1.03258424e-01f, 4.77557406e-02f, -4.32173163e-02f, 4.58555631e-02f, -7.68429190e-02f,
  -1.24833383e-01f, -2.30752584e-02f, -6.71438500e-02f, 1.83547463e-03f, -2.98620500e-02f, -1.56750411e-01f, 3.15299816e-02f, 1.64840341e-01f, 5.14852442e-02f, -6.84887469e-02f,
  1.04742847e-01f, -1.25312135e-01f, 8.78041834e-02f, 9.41219777e-02f, 1.40285701e-01f, 2.82307863e-02f, -1.85838670e-01f, 7.46809617e-02f, -1.38603691e-02f, 2.75507523e-03f,
  6.71387464e-02f, -2.20415100e-01f, -3.87388729e-02f, 1.27550915e-01f, -6.34937407e-03f, -4.36609164e-02f, 1.08927205e-01f, -3.98786888e-02f, -2.56891161e-01f, 1.97935581e-01f,
  -1.55768273e-02f, -2.65507773e-02f, 1.86030298e-01f, 2.14286685e-01f, 8.05535540e-03f, -6.21407330e-02f, 1.31336570e-01f, 1.30373277e-02f, -1.75726358e-02f, -1.50376633e-01f,
  4.27542739e-02f, -1.21936455e-01f, 1.92429706e-01f, -1.12403154e-01f, 2.17701524e-01f, -1.63220130e-02f, 6.66517466e-02f, 6.28852621e-02f, 4.40832451e-02f, 1.54992966e-02f,
  -1.54367596e-01f, 1.10591672e-01f, -3.81485187e-02f, 8.03383961e-02f, -5.08514792e-02f, 9.09627676e-02f, -4.07314487e-02f, -2.89873667e-02f, -6.79808781e-02f, -2.38616690e-02f,
  5.99319935e-02f, 4.28191796e-02f, 1.80004030e-01f, -3.06070801e-02f, -2.26138588e-02f, -1.62093081e-02f, -4.82499078e-02f, 7.02146515e-02f, 7.05244243e-02f, -3.62246484e-02f,
  7.95718655e-02f, 1.68362215e-01f, 1.56141240e-02f, -2.06454173e-01f, 9.70493555e-02f, 1.10985748e-01f, -7.75237158e-02f, 1.16039224e-01f, 1.14529863e-01f, 1.82230189e-01f,
  -2.48381004e-01f, 1.44703329e-01f, -1.89975187e-01f, 1.58243328e-01f, -7.00978190e-03f, -1.79892763e-01f, -4.81796972e-02f, 9.02135596e-02f, -2.00255513e-02f, 1.30841225e-01f,
  7.75766149e-02f, -2.18387946e-01f, -1.54872552e-01f, 1.45103335e-01f, 1.46289527e-01f, -1.43610746e-01f, 7.25377575e-02f, -8.93871933e-02f, -4.25074734e-02f, 1.37713075e-01f,
  1.66254193e-02f, 4.34590243e-02f, -1.22944728e-01f, -1.10637598e-01f, -6.92345351e-02f, -9.76506397e-02f, 1.79436952e-01f, 1.24056533e-01f, -1.58662274e-01f, 8.59435126e-02f,
  -5.94189316e-02f, -6.86998060e-03f, 3.18254158e-02f, 1.24442883e-01f, 1.32052392e-01f, -2.42938772e-02f, 1.99288577e-01f, 5.93044236e-02f, 6.95629418e-02f, 5.29794917e-02f,
  -7.83395767e-03f, 6.31282702e-02f, 2.67872125e-01f, 3.23658697e-02f, 6.68796971e-02f, 9.48890820e-02f, 1.76242832e-02f, -1.07108735e-01f, 1.17443591e-01f, -8.90056342e-02f,
  1.54484538e-02f, 5.59286028e-02f, 5.66387922e-02f, -2.13303398e-02f, 1.90638192e-02f, -1.98773071e-01f, -8.92892480e-02f, 1.14557922e-01f, -1.50782973e-01f, 1.72153935e-01f,
  -2.10591450e-01f, -1.31799072e-01f, -4.68794852e-02f, -2.33908296e-02f, 2.11390719e-01f, -1.02777168e-01f, -8.88428614e-02f, 1.20060712e-01f, -2.20744252e-01f, 1.88025504e-01f,
  1.54023483e-01f, -1.73114866e-01f, -3.80825181e-03f, 9.18050471e-04f, -1.84338495e-01f, 1.45712748e-01f, 3.39285820e-04f, 1.45753846e-01f, -1.18766159e-01f, -6.47385567e-02f,
  -2.00331986e-01f, -3.79613787e-02f, 1.38696939e-01f, -5.58133349e-02f, 8.58077854e-02f, 9.35121551e-02f, -1.82536185e-01f, 1.84249684e-01f, -9.56505761e-02f, -1.34605289e-01f,
  -1.78321242e-01f, 5.65017536e-02f, -9.15547907e-02f, 1.43250763e-01f, -4.26373631e-02f, 5.72569333e-02f, -1.01127680e-02f, 1.05248205e-02f, -4.49049287e-02f, 4.08271551e-02f,
  -1.11291641e-02f, 1.76093227e-03f, 5.04718814e-03f, 2.47593829e-03f, -4.07514684e-02f, 2.84602456e-02f, -1.88082159e-02f, 6.08268157e-02f, 6.77888393e-02f, 8.45790282e-02f,
  1.78288102e-01f, -1.65507216e-02f, 6.10263348e-02f, 7.34647810e-02f, -6.54059127e-02f, 7.81207904e-02f, -3.74964136e-03f, 2.76805088e-02f, 3.43907736e-02f, 1.58253357e-01f,
  6.44521788e-02f, -1.34246260e-01f, -5.53069962e-03f, 1.69781372e-01f, 1.27358418e-02f, 1.33994013e-01f, 7.60419890e-02f, 1.44331232e-01f, -1.97920412e-01f, 1.92953408e-01f,
  -1.95184767e-01f, 1.81019649e-01f, 3.05724982e-02f, -1.48612708e-01f, 5.51405735e-02f, -3.64273526e-02f, -2.05824524e-02f, 1.60897404e-01f, -1.37160281e-02f, -1.31861985e-01f,
  -5.52240107e-03f, 7.57961050e-02f, 1.02847569e-01f, -1.57683954e-01f, 1.58368573e-01f, -7.78127164e-02f, 4.23698984e-02f, 2.28887662e-01f, -6.95724180e-03f, 7.70659745e-02f,
  -1.56054437e-01f, -7.03637954e-03f, 1.61163602e-02f, -1.83426663e-01f, 1.83921695e-01f, 1.34589925e-01f, -2.31364802e-01f, -1.49346516e-02f, 7.75880814e-02f, 6.61430322e-03f,
  -8.70030075e-02f, 5.55424858e-03f, -1.87336117e-01f, 3.42689827e-02f, -8.25626701e-02f, 1.90182384e-02f, 1.41851772e-02f, -6.12147972e-02f, -1.23296216e-01f, -2.41696686e-02f,
  -2.29272351e-01f, -1.31473333e-01f, -1.55164808e-01f, -1.17106006e-01f, 3.61865270e-04f, -9.75566581e-02f, -4.62963283e-02f, 2.16729902e-02f, -8.89258683e-02f, 7.47865215e-02f,
  -7.01630339e-02f, 8.64024237e-02f, -6.33585220e-03f, 2.32286543e-01f, 8.07222575e-02f, 4.02911268e-02f, -4.22421284e-02f, 1.23712912e-01f, 1.44275650e-01f, 9.99339968e-02f,
  1.18176326e-01f, 1.21392176e-01f, 1.82932802e-02f, -7.17751868e-03f, -1.53162658e-01f, 4.63792793e-02f, 1.60984904e-01f, -4.79821973e-02f, -1.77553177e-01f, 1.36863992e-01f,
  8.48663226e-02f, -1.51912319e-02f, 2.17271417e-01f, -1.20628864e-01f, -5.54694422e-03f, 2.17491705e-02f, 1.41603082e-01f, 1.03615470e-01f, 1.56414717e-01f, -1.13673881e-01f,
  -5.49628995e-02f, 1.15322798e-01f, -2.45389223e-01f, 1.46131113e-01f, -1.55105174e-01f, -3.18022370e-02f, -1.14891797e-01f, 9.64397267e-02f, 1.46517068e-01f, -3.68586034e-02f,
  -2.50883307e-02f, -3.13524306e-02f, -1.53612837e-01f, 3.73990275e-03f, 2.27515493e-02f, 3.26669179e-02f, 3.65992896e-02f, -4.49303463e-02f, -4.46933135e-02f, 3.74614224e-02f,
  -8.42208117e-02f, -2.78618429e-02f, 8.69603306e-02f, 6.61258623e-02f, 3.92324105e-02f, -6.20377362e-02f, 4.62529212e-02f, -6.07861998e-03f, 1.22692689e-01f, 1.63247734e-02f,
  -1.09680839e-01f, -1.07152574e-02f, -1.23989135e-02f, 1.31275086e-02f, 1.47826433e-01f, -1.41596824e-01f, 9.51220654e-03f, 1.35203123e-01f, -1.83893979e-01f, -9.72521529e-02f,
  1.96874171e-01f, -1.43527627e-01f, -2.44792491e-01f, 1.45342082e-01f, 1.52484432e-01f, -2.10419614e-02f, -8.87061432e-02f, 1.33039430e-01f, 8.23536217e-02f, 8.36747792e-03f,
  1.85453352e-02f, -1.85801387e-01f, 6.67926744e-02f, -4.84642647e-02f, 4.51733219e-03f, 1.15299253e-02f, -1.35900438e-01f, 2.40574293e-02f, -2.16611937e-01f, 9.51217115e-02f,
  -5.10521233e-02f, -3.26400429e-01f, 6.76788315e-02f, 7.49044865e-02f, -6.51874021e-02f, 4.24001738e-02f, 2.33092934e-01f, -1.11801431e-01f, -1.80797964e-01f, -1.12494014e-01f,
  9.51404944e-02f, -1.31894827e-01f, -6.04847632e-02f, 4.42909412e-02f, 3.03006172e-02f, 6.30684718e-02f, -4.79288325e-02f, -6.33722767e-02f, -2.26559900e-02f, -4.75287810e-02f,
  1.85594503e-02f, -3.73165309e-02f, -3.52068283e-02f, -1.48292974e-01f, -1.59634687e-02f, -9.36236531e-02f, 7.98284933e-02f, 4.22263034e-02f, -9.91548970e-02f, -7.41265938e-02f,
  1.18855573e-01f, 5.12008592e-02f, 7.82305673e-02f, -6.82454631e-02f, 1.11324474e-01f, 6.83842674e-02f, -4.14196625e-02f, 6.46496266e-02f, -1.41748816e-01f, -1.56087890e-01f,
  -8.18770900e-02f, 1.46692649e-01f, 2.22945794e-01f, -3.72135974e-02f, 2.20292881e-02f, -1.67069044e-02f, 1.09931037e-01f, 8.55952799e-02f, 1.89785630e-01f, 1.28900215e-01f,
  -2.74083585e-01f, 1.53399408e-01f, -1.29032105e-01f, 1.04247577e-01f, 8.54798108e-02f, -2.68248409e-01f, 1.39425084e-01f, -2.51655933e-02f, -1.27570182e-01f, 1.59421876e-01f,
  -1.10932805e-01f, 6.63067633e-03f, -6.65708780e-02f, 3.57807092e-02f, 1.40080273e-01f, -3.24685164e-02f, 2.42235243e-01f, 2.04124123e-01f, 9.94197950e-02f, 1.29637450e-01f,
  -4.29987609e-02f, -1.39075384e-01f, -7.34429434e-02f, 1.54963076e-01f, 1.85946032e-01f, -2.79920906e-01f, -1.58041697e-02f, -4.86695021e-02f, -1.71036944e-01f, -1.33761823e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.66492814e-01f, 1.38967499e-01f, 5.51891141e-02f, 4.82718982e-02f, 1.79550454e-01f, 1.18305452e-01f, 2.05401585e-01f, 1.39892563e-01f, 1.98969066e-01f, 2.32415557e-01f,
  -3.03228870e-02f, -4.01106440e-02f, 1.55414954e-01f, 2.10080534e-01f, -1.29330484e-02f, 1.19434409e-01f, 8.17626789e-02f, 1.01858795e-01f, 1.14032596e-01f, 1.30001143e-01f,
  1.20214634e-01f, 9.40204635e-02f, 5.23308069e-02f, 3.28479052e-01f, 1.28520876e-01f, -2.94501960e-01f, 9.31649730e-02f, 7.42579624e-03f, -2.14965209e-01f, 2.48435378e-01f,
  9.16107669e-02f, -2.95425355e-01f, -2.82178313e-01f, 3.84883881e-02f, 1.71169743e-01f, -2.19690263e-01f, -1.48352385e-01f, 6.51770905e-02f, -3.00249219e-01f, 3.91180247e-01f,
  -5.21851033e-02f, 5.13886027e-02f, -1.05549097e-01f, 6.53320327e-02f, 5.11465371e-02f, -1.06162876e-01f, 3.26760799e-01f, -1.42036498e-01f, 5.73588200e-02f, 2.61394054e-01f,
  -2.89421320e-01f, -2.52671987e-01f, -3.60725186e-04f, 6.04468510e-02f, -2.23769024e-01f, 1.28910884e-01f, 2.99343109e-01f, 3.25806700e-02f, -2.61014581e-01f, 3.71883482e-01f,
  9.15398598e-02f, 3.97833079e-01f, -1.42728344e-01f, 1.61089227e-01f, -7.21184835e-02f, 1.43322080e-01f, 1.10369392e-01f, 2.04135329e-01f, 7.08847195e-02f, 1.02459162e-01f,
  -1.00831814e-01f, -9.06512607e-03f, -9.45827067e-02f, 1.08388163e-01f, 1.93417758e-01f, 1.52123719e-01f, 8.19830000e-02f, -5.14295436e-02f, 8.21808428e-02f, 9.04945433e-02f,
  1.70413315e-01f, 1.77311301e-01f, 6.44128919e-02f, 3.38397957e-02f, -2.17189547e-02f, 8.66287872e-02f, 1.83599710e-01f, -7.78129250e-02f, 1.15097359e-01f, 1.76064581e-01f,
  -2.24626333e-01f, -1.44905103e-02f, 3.42698753e-01f, -2.34983668e-01f, -2.92451054e-01f, 2.83228397e-01f, 2.57875025e-01f, -1.05691031e-01f, -2.12465957e-01f, 4.34736945e-02f,
  1.03472851e-01f, 9.91922915e-02f, 1.13102511e-01f, -2.06395313e-01f, 1.16023533e-01f, 5.56911202e-03f, 2.46936619e-01f, -1.93344671e-02f, -1.44040912e-01f, 2.60493010e-02f,
  -2.05666557e-01f, 2.80933231e-01f, -2.20027328e-01f, -3.55792552e-01f, 4.01375175e-01f, 2.95420170e-01f, 3.52471955e-02f, 1.44875661e-01f, 4.38184828e-01f, 5.79670928e-02f,
  -2.13022362e-02f, -2.86444545e-01f, 4.64850307e-01f, 1.56821664e-02f, 9.93800834e-02f, -2.16813818e-01f, 7.08643645e-02f, 1.66472897e-01f, -9.75656360e-02f, -2.59125810e-02f,
  1.41240582e-01f, -7.03946725e-02f, 1.90551244e-02f, -1.81396715e-02f, 6.48176149e-02f, 3.72526161e-02f, -6.50149360e-02f, -3.12554501e-02f, 3.10757875e-01f, 1.13596395e-01f,
  -4.01003473e-02f, -6.79336563e-02f, 1.95358649e-01f, -1.15578091e-02f, 4.24791947e-02f, 8.78424644e-02f, 1.48144551e-02f, -2.00775312e-03f, 1.62945971e-01f, 5.29007940e-03f,
  1.07714711e-02f, -2.47276723e-01f, -2.75196228e-03f, 8.71409029e-02f, -8.98843706e-02f, -1.21785887e-02f, 1.76607743e-01f, -1.97325230e-01f, 5.61639592e-02f, 1.12148233e-01f,
  1.21207133e-01f, -8.07539225e-02f, -7.73585513e-02f, 1.57330438e-01f, 2.07235947e-01f, -1.45513564e-01f, 1.26866236e-01f, -2.56788671e-01f, 1.18999869e-01f, 7.84000233e-02f,
  -9.92128402e-02f, -1.30754307e-01f, -7.39006475e-02f, 1.66722089e-01f, -3.49300653e-01f, -4.85156626e-02f, 7.37496242e-02f, 2.63955090e-02f, 6.53862879e-02f, 4.42587018e-01f,
  1.24095693e-01f, 7.54151046e-02f, 3.64117980e-01f, -1.88753188e-01f, 1.51863828e-01f, 2.80409724e-01f, 3.10784012e-01f, -2.43614540e-01f, -1.70297384e-01f, -2.53942102e-01f,
  3.98271024e-01f, 2.22260773e-01f, 1.86403558e-01f, 9.13793221e-02f, 3.26326191e-02f, -5.47281839e-02f, 1.19622469e-01f, 1.56661630e-01f, 1.61945283e-01f, 2.61782676e-01f,
  -2.25349993e-01f, 1.74160987e-01f, 2.55824685e-01f, 3.05143129e-02f, -1.63914397e-01f, 2.76874036e-01f, -2.62591001e-02f, 2.98090518e-01f, -1.60853490e-01f, 2.15119839e-01f,
  6.22464940e-02f, 2.31713727e-01f, 2.55297959e-01f, 5.04083894e-02f, 2.50213265e-01f, 4.59709428e-02f, 2.48385563e-01f, 3.04177284e-01f, -3.63948882e-01f, -5.91212928e-01f,
  1.54555425e-01f, 9.28302035e-02f, 2.78590024e-01f, 1.97932031e-03f, -3.44074637e-01f, -1.57027423e-01f, -3.37981105e-01f, 2.94632554e-01f, 1.29773617e-01f, 1.63290560e-01f,
  -5.47090881e-02f, -1.42317578e-01f, -8.36792663e-02f, 2.79636234e-01f, -1.43821493e-01f, -1.15769692e-01f, -4.42400686e-02f, -1.02098927e-01f, -2.60956734e-01f, -4.26313072e-01f,
  -1.61099419e-01f, 3.32379192e-01f, -1.63163587e-01f, 2.29139939e-01f, -3.13466400e-01f, 4.16426480e-01f, 3.42076421e-02f, -2.28538096e-01f, 4.59878057e-01f, -1.47275459e-02f,
  4.62689459e-01f, 3.60322386e-01f, -1.97965264e-01f, 3.81210566e-01f, -1.90479401e-02f, 1.90639570e-01f, 6.61972761e-02f, 2.50976346e-02f, 1.31572664e-01f, -5.26252910e-02f,
  6.79425672e-02f, -2.01073661e-02f, 1.36576399e-01f, 4.67225648e-02f, 7.00867474e-02f, 3.19304802e-02f, 1.58017039e-01f, 1.17556691e-01f, 2.50965822e-02f, 1.25646383e-01f,
  -4.36644740e-02f, -8.76203850e-02f, -6.20890409e-02f, 1.53023258e-01f, -4.05042507e-02f, -5.11056557e-02f, 1.78711757e-01f, -4.77911793e-02f, 1.18986830e-01f, 4.09710221e-02f,
  1.92059968e-02f, 4.80518527e-02f, -8.27131420e-02f, 8.92450064e-02f, -2.85098832e-02f, -2.54971653e-01f, 2.86152780e-01f, -2.65458506e-02f, -1.48567140e-01f, -2.52993286e-01f,
  3.51948738e-01f, -1.73842236e-01f, 3.46513182e-01f, -3.95021498e-01f, 1.61150038e-01f, 1.87229991e-01f, -1.81407034e-01f, 2.00738251e-01f, 7.95344710e-02f, -2.48199463e-01f,
  2.42666736e-01f, 1.15022123e-01f, -1.53289102e-02f, -2.90869802e-01f, 1.54337794e-01f, 3.37784678e-01f, 4.65000272e-02f, 1.55289501e-01f, 6.27181903e-02f, 5.05438596e-02f,
  1.79992214e-01f, 2.66311437e-01f, 4.53249007e-01f, 3.84142607e-01f, 1.52197525e-01f, 4.70514357e-01f, 9.33874771e-02f, -5.50447591e-02f, 4.52898294e-01f, 6.10455088e-02f,
  2.51193553e-01f, 2.44594038e-01f, 1.94368318e-01f, 3.79787296e-01f, -3.23254466e-02f, 2.46863648e-01f, 1.10835105e-01f, 2.65117675e-01f, 2.55932093e-01f, 3.36511195e-01f,
  -1.12334937e-01f, 2.92592440e-02f, 1.89532191e-01f, 1.15725599e-01f, -1.68500319e-02f, -8.32244102e-03f, 6.98869005e-02f, -3.99649143e-02f, 7.52290292e-03f, 1.07942030e-01f,
  -3.72565314e-02f, 1.61385626e-01f, 1.96621448e-01f, 3.96181017e-01f, 1.69481114e-01f, -2.30807275e-01f, 5.73191792e-02f, 1.73327655e-01f, -2.00089097e-01f, 2.11256489e-01f,
  -2.90424287e-01f, -1.67588130e-01f, 1.29758269e-01f, 2.15718955e-01f, -1.02716675e-02f, -2.89464474e-01f, -3.34632903e-01f, 3.20545167e-01f, -2.73752034e-01f, 9.89217237e-02f,
  -1.94664270e-01f, -1.36720613e-01f, 1.79065660e-01f, 9.89745930e-02f, 1.31796464e-01f, -3.14974099e-01f, 1.74101353e-01f, 4.79395211e-01f, -2.80747384e-01f, -4.45180833e-01f,
  3.80906239e-02f, -2.28623614e-01f, 2.35027716e-01f, 5.45202605e-02f, 9.57569331e-02f, 4.61853683e-01f, -5.03471553e-01f, -3.53700846e-01f, -2.97262609e-01f, 1.78312197e-01f,
  5.19467354e-01f, 4.67231154e-01f, 3.60866457e-01f, 1.21381216e-01f, 2.23029312e-02f, 7.81604797e-02f, 1.16996683e-01f, 5.51702529e-02f, 5.73050790e-03f, 1.49494007e-01f,
  9.17925462e-02f, 1.09336793e-01f, 4.88887504e-02f, 5.53439930e-02f, -4.78282236e-02f, 4.01579514e-02f, -9.90596488e-02f, 7.82265421e-03f, 1.41396880e-01f, 1.57925144e-01f,
  4.66615744e-02f, 1.46799907e-02f, 8.34918581e-03f, 1.84816629e-01f, 5.69019094e-02f, 1.63550958e-01f, 8.59368294e-02f, 1.52579118e-02f, 1.36770219e-01f, 1.97978213e-01f,
  2.44166955e-01f, -1.62656829e-01f, -7.55514577e-02f, 2.31980711e-01f, -1.45229679e-02f, 1.84567273e-01f, 2.29568556e-01f, 3.09577554e-01f, -3.94234717e-01f, 2.96605766e-01f,
  -3.45720053e-01f, 2.34773681e-01f, 1.18238397e-01f, -2.79647917e-01f, 3.92911695e-02f, -1.15981393e-01f, -1.23480797e-01f, 3.36982042e-01f, 6.03653491e-02f, -2.50560075e-01f,
  7.27320313e-02f, 1.19723089e-01f, 9.58648622e-02f, -2.72705287e-01f, 4.94611263e-01f, 7.64858723e-02f, 3.88862789e-01f, 5.23698986e-01f, -6.65246546e-02f, 2.83277005e-01f,
  -2.80644119e-01f, 1.42370582e-01f, 1.24433443e-01f, -1.06310830e-01f, 2.84772635e-01f, 4.27355528e-01f, -1.71908438e-01f, -1.95722550e-01f, 5.65674827e-02f, 7.82177970e-02f,
  1.17003486e-01f, 4.74695265e-02f, 3.03214472e-02f, -9.02763568e-03f, 2.07627520e-01f, -1.46421576e-02f, 3.69705468e-01f, -7.32244505e-03f, 9.55395494e-03f, 2.00086877e-01f,
  2.70718575e-01f, 1.45842791e-01f, 2.07455724e-01f, 4.54383492e-02f, 1.22912675e-01f, -1.20916680e-01f, 2.47835457e-01f, 3.48903239e-02f, -1.66052654e-02f, 8.24408308e-02f,
  -1.04320355e-01f, 1.36522233e-01f, -2.76560001e-02f, -2.53178447e-01f, 3.34489673e-01f, 4.21918213e-01f, -4.04149681e-01f, 1.33374542e-01f, 1.12393782e-01f, -2.40498573e-01f,
  -3.88009623e-02f, 2.39164129e-01f, 2.95444340e-01f, -2.16594949e-01f, -2.65303254e-01f, -3.12801707e-03f, -1.18457824e-01f, 9.77409109e-02f, 7.58562535e-02f, -1.90894157e-01f,
  -6.10976256e-02f, -2.09428519e-02f, -2.11429801e-02f, 1.40670761e-01f, 1.90491155e-01f, 1.75540388e-01f, 1.14556782e-01f, 1.44315854e-01f, 1.69124439e-01f, 2.62402803e-01f,
  6.56069577e-01f, 1.34778112e-01f, -1.27879465e-02f, 4.51266021e-01f, -1.10693410e-01f, 5.38306594e-01f, -2.19162866e-01f, -1.87033638e-01f, 2.30818942e-01f, -1.86805204e-02f,
  2.20827878e-01f, 4.21637148e-02f, 8.40732381e-02f, 9.33481157e-02f, 1.71424925e-01f, 9.25499573e-02f, 3.04902941e-01f, 4.83249798e-02f, 1.85272053e-01f, 9.55025852e-02f,
  1.32453382e-01f, 1.83529794e-01f, 1.27286855e-02f, -4.95281853e-02f, 2.75510758e-01f, 1.75822392e-01f, 7.45402575e-02f, 2.01383665e-01f, 1.04811452e-01f, 1.93931788e-01f,
  4.02868874e-02f, 1.52909458e-01f, 1.46616697e-01f, -1.40405400e-02f, 1.68661565e-01f, 1.95279256e-01f, 2.45101210e-02f, -2.45145828e-01f, 1.52196093e-02f, -4.80638724e-03f,
  -1.52881205e-01f, 7.28731081e-02f, -2.06462979e-01f, -1.89195678e-01f, -2.11670727e-01f, -4.84386906e-02f, 1.67571858e-01f, -4.66695242e-02f, 4.19060886e-03f, 7.28319772e-03f,
  -1.73050418e-01f, 2.37538427e-01f, 1.33295015e-01f, -2.38268182e-01f, -1.21449985e-01f, 2.03488216e-01f, -2.52607197e-01f, 4.94080782e-02f, 3.75992507e-01f, -1.11757107e-01f,
  1.54904639e-02f, -1.31092995e-01f, -2.97103450e-02f, -2.70414591e-01f, 1.89195156e-01f, 1.65905375e-02f, 7.79476091e-02f, 1.85570531e-02f, 1.52363107e-01f, 7.93606415e-02f,
  -1.48127913e-01f, 1.68766499e-01f, 7.62173757e-02f, 4.76215720e-01f, -2.11429268e-01f, 1.34234568e-02f, 2.10057437e-01f, 2.03730807e-01f, 1.18857011e-01f, 1.42195269e-01f,
  -1.72819138e-01f, 1.91688612e-01f, -5.47584780e-02f, 9.89135951e-02f, -1.92681197e-02f, 1.02278396e-01f, 9.42801833e-02f, 2.18582928e-01f, -1.64561912e-01f, 8.77943337e-02f,
  -7.94226595e-04f, 1.25136375e-01f, 7.93621019e-02f, -3.74445729e-02f, 1.14005513e-01f, 6.97708726e-02f, -4.79792692e-02f, 2.01588422e-01f, 1.52973995e-01f, 2.59949028e-01f,
  1.74476907e-01f, 2.52716959e-01f, -1.87456712e-01f, -8.01495463e-02f, -1.86045300e-02f, 2.64788121e-01f, 2.19449580e-01f, 1.50003359e-01f, 7.92240947e-02f, 2.17624158e-01f,
  -4.83314134e-02f, -2.52184629e-01f, -1.14089772e-01f, 3.31648350e-01f, 1.16878219e-01f, -7.20594376e-02f, -2.45700687e-01f, 2.78349459e-01f, 3.02932680e-01f, -3.67733985e-01f,
  3.58568460e-01f, -3.01590800e-01f, -2.09587649e-01f, 1.06565617e-01f, 5.82764624e-03f, 2.86552876e-01f, 1.07550904e-01f, 1.23875253e-01f, -1.87445611e-01f, 2.41291657e-01f,
  -1.13968104e-01f, 2.50974983e-01f, 2.38671936e-02f, -1.71942532e-01f, 4.15074110e-01f, 8.94291401e-02f, 2.01623723e-01f, -2.83656120e-01f, 3.63941640e-01f, 3.26859862e-01f,
  -3.58473882e-03f, 8.78662392e-02f, 8.71905088e-02f, 1.06916189e-01f, 6.48101345e-02f, 6.48624599e-02f, 1.23252645e-01f, 2.78084069e-01f, -4.08017039e-02f, 8.02273974e-02f,
  5.95093444e-02f, 4.51473035e-02f, 1.28629938e-01f, 5.10450564e-02f, -1.55833408e-01f, -7.53415376e-02f, -9.18675140e-02f, 1.40382364e-01f, -1.19571529e-01f, -4.86625545e-02f,
  1.28304988e-01f, -1.28877908e-01f, 2.54103720e-01f, 1.48782246e-02f, 1.63507417e-01f, -3.81032787e-02f, -3.77664626e-01f, 9.47168097e-02f, 8.10164288e-02f, -1.94609269e-01f,
  -1.91106752e-01f, -1.27930101e-02f, -1.17787600e-01f, -2.62518078e-01f, 3.30112875e-01f, -2.06048772e-01f, 3.11220974e-01f, -3.24626416e-01f, -9.97807458e-03f, 3.88890535e-01f,
  -2.68910617e-01f, 5.17435335e-02f, 2.18940407e-01f, -1.93431988e-01f, 1.64123058e-01f, 4.12698798e-02f, -9.50261876e-02f, -4.22811974e-03f, -1.04461543e-01f, -1.26223668e-01f,
  -1.22602910e-01f, -1.70716360e-01f, -1.16498791e-01f, -2.60694306e-02f, 3.82070333e-01f, 3.72140139e-01f, 1.02789119e-01f, 4.86848690e-02f, -1.24149099e-01f, 6.00568235e-01f,
  7.38452077e-02f, 3.99356186e-02f, 2.68235564e-01f, 1.98480055e-01f, -2.53606975e-01f, -8.78859963e-03f, 7.20158964e-02f, -7.67991936e-04f, 7.48356953e-02f, -1.45851076e-02f,
  1.04740314e-01f, 2.25148320e-01f, 9.23868548e-03f, -1.04469784e-01f, 2.19589442e-01f, 2.05494612e-01f, 1.06198117e-01f, -2.22167984e-01f, 1.44371554e-01f, 2.81481370e-02f,
  2.25636736e-01f, 1.68210402e-01f, 9.66291036e-03f, -1.86408348e-02f, 2.35996604e-01f, 6.56909421e-02f, 8.89108330e-02f, -2.42379650e-01f, 1.21090405e-01f, -3.86251882e-02f,
  -2.27283433e-01f, 1.00830570e-01f, 3.09885830e-01f, -2.45649084e-01f, -4.02869642e-01f, 2.75224090e-01f, 3.48665595e-01f, -2.07864955e-01f, -1.77444201e-02f, 1.05068929e-01f,
  1.58581376e-01f, -2.08033338e-01f, 3.32055949e-02f, 1.17235392e-01f, 2.84506857e-01f, -6.44326955e-02f, 4.03926428e-03f, 1.22072853e-01f, -9.68959555e-02f, 2.47247443e-01f,
  -2.91559547e-01f, 1.29655033e-01f, -8.35481882e-02f, -2.88579464e-01f, 3.62122267e-01f, 3.17837447e-02f, 1.38718978e-01f, 3.44595253e-01f, 4.21104640e-01f, 2.14460790e-01f,
  -6.15341328e-02f, 1.98943660e-01f, 2.39903912e-01f, 3.39381397e-01f, -1.07316539e-01f, -2.24925876e-01f, -3.65037769e-01f, 2.89118737e-01f, -2.34258603e-02f, -3.08620557e-02f,
  1.85297772e-01f, -1.01365887e-01f, 9.48241055e-02f, 8.78748074e-02f, 1.87527284e-01f, 6.10402524e-02f, 3.56831580e-01f, 5.19604161e-02f, 1.80458948e-01f, 1.24745220e-01f,
  2.04545453e-01f, 5.17199840e-03f, 1.92530870e-01f, -1.84959456e-01f, 3.36556211e-02f, 2.63352003e-02f, -5.74941449e-02f, 5.13554402e-02f, 1.73249245e-01f, -1.99068282e-02f,
  -4.35266793e-02f, -8.97183940e-02f, -9.07378346e-02f, -1.74038976e-01f, 3.83461237e-01f, 1.88488588e-01f, -7.38344248e-03f, -2.70401686e-01f, -6.97252080e-02f, 1.54011115e-01f,
  3.14382017e-01f, 1.83624581e-01f, 2.33408492e-02f, 1.35596856e-01f, -9.65459272e-03f, -3.06501001e-01f, 1.88035801e-01f, -1.85118139e-01f, 2.37957649e-02f, -1.12740606e-01f,
  -2.14408442e-01f, 2.83504009e-01f, 4.84799854e-02f, 6.01464547e-02f, 1.01954043e-01f, 1.42627999e-01f, 1.77979484e-01f, -3.32747400e-01f, 2.26258188e-01f, 1.29206270e-01f,
  6.02067232e-01f, 8.65167454e-02f, 3.42969745e-01f, -2.59367004e-02f, -2.05530927e-01f, 3.78192633e-01f, -3.46607924e-01f, -1.63591206e-01f, 2.34483421e-01f, 3.44033241e-01f,
  5.12331486e-01f, -3.51960063e-02f, 5.38648330e-02f, 9.40495580e-02f, 1.86925843e-01f, 6.72609583e-02f, 3.04466307e-01f, 7.72219375e-02f, 2.60075033e-01f, 3.63308117e-02f,
  1.58343911e-01f, 2.10872516e-01f, 2.35802561e-01f, 7.59734539e-03f, 2.49660909e-01f, 2.14037672e-01f, 3.08892757e-01f, 1.77687019e-01f, 9.73131657e-02f, 1.68937489e-01f,
  1.51740253e-01f, 1.80035830e-01f, 8.76654312e-02f, 4.33335565e-02f, 2.78390236e-02f, 7.25871027e-02f, -6.89208508e-02f, -4.41963434e-01f, 1.71686053e-01f, 3.00993361e-02f,
  -3.85140739e-02f, -1.94226727e-01f, -1.00080386e-01f, -3.79963934e-01f, -2.76769161e-01f, -1.46288797e-01f, -6.42834902e-02f, 9.91985649e-02f, 1.03183892e-02f, -8.42664912e-02f,
  -2.92360485e-01f, -1.14868777e-02f, 3.27928036e-01f, -2.28766352e-01f, -2.97023952e-01f, 1.42137542e-01f, -4.45104390e-01f, 2.42869690e-01f, 2.11725846e-01f, -3.55110317e-02f,
  -1.86365202e-01f, -9.22715142e-02f, -2.09703237e-01f, 3.52763057e-01f, 2.80830234e-01f, -2.22970352e-01f, 3.42819870e-01f, -3.07923257e-01f, 3.36171985e-01f, 7.83969462e-02f,
  -3.36270519e-02f, -1.70475364e-01f, -1.59503579e-01f, 3.01118463e-01f, 1.59579203e-01f, 3.63846123e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.39748797e-01f, 2.08987623e-01f, 1.69845492e-01f, 1.65296391e-01f, 1.55507013e-01f, 2.23196641e-01f, 1.41627818e-01f, 1.28151894e-01f, 1.59768105e-01f, 1.13466531e-01f,
  1.42733470e-01f, 1.02062806e-01f, 1.28696024e-01f, 2.01004192e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.85580969e-01f, 1.38926283e-01f, 1.52130961e-01f, 3.72265369e-01f, -4.66123700e-01f, -1.10559218e-01f, -3.44724059e-01f, 1.05325639e-01f, -2.72013903e-01f, 1.14758454e-01f,
  1.27010182e-01f, -3.09721798e-01f, 6.48005456e-02f, -3.94681608e-03f, -1.03417493e-03f, -4.62854028e-01f, 1.10817432e-01f, -1.98362377e-02f, 4.57298607e-02f, 1.34910196e-01f,
  1.92636922e-02f, 1.35639757e-01f, -1.41838938e-01f, 1.42697962e-02f, -9.96756107e-02f, -1.37319475e-01f, -4.46993172e-01f, 2.88614690e-01f, -8.31053033e-02f, 1.11541964e-01f,
  -3.47048454e-02f, 7.38448352e-02f, 6.48348033e-02f, -1.61365837e-01f, 4.67346549e-01f, -4.05189902e-01f, -1.27903432e-01f, 1.56025618e-01f, 4.48409855e-01f, -1.88928798e-01f,
  4.48147766e-02f, -3.25040042e-01f, 2.25536436e-01f, 4.45173979e-01f, 5.65299690e-02f, 1.97838873e-01f, 9.58020166e-02f, -2.72602051e-01f, 2.21370146e-01f, 4.39054251e-01f,
  -4.11308557e-01f, 2.02201948e-01f, 2.15386778e-01f, -7.45974660e-01f, -5.92728317e-01f, -7.22863339e-03f, 4.06074412e-02f, -4.91075404e-03f, -1.24961227e-01f, -3.48461717e-01f,
  -4.27390635e-01f, 3.00301850e-01f, 3.86655152e-01f, 2.53071278e-01f, -2.14704394e-01f, -2.46102005e-01f, -3.33794147e-01f, -3.36890310e-01f, 1.97670415e-01f, -3.30966651e-01f,
  4.35762018e-01f, -1.17182322e-02f, -2.49403164e-01f, -6.66791722e-02f, 3.28053087e-02f, 2.30041295e-01f, 2.41632968e-01f, -4.06903811e-02f, 1.51117131e-01f, 1.78147390e-01f,
  4.66380902e-02f, 1.51107937e-01f, 1.66368544e-01f, 2.10784540e-01f, 1.35664254e-01f, 2.65237302e-01f, -1.28686905e-01f, -3.00924212e-01f, 3.47490519e-01f, -6.05946109e-02f,
  -3.45748156e-01f, 2.78132498e-01f, 2.74075031e-01f, 3.98870647e-01f, -1.59941405e-01f, -1.19652681e-01f, -1.93194568e-01f, -4.02604401e-01f, -4.36723232e-01f, 2.98368037e-01f,
  -4.96850669e-01f, -1.64470926e-01f, 1.86253846e-01f, -1.18819140e-01f, -4.40192129e-03f, 3.46032202e-01f, 5.37248403e-02f, 2.31407881e-01f, 6.87536821e-02f, 2.81122118e-01f,
  -1.90161616e-02f, 1.43523216e-01f, 1.57781899e-01f, -1.91202357e-01f, -4.42430973e-01f, 3.20550531e-01f, 3.12829703e-01f, 1.77852765e-01f, -8.30694139e-02f, -6.28004313e-01f,
  -3.73486578e-01f, -6.95749223e-01f, 6.19852450e-03f, -4.47798520e-01f, 1.79483101e-01f, 4.69328254e-01f, -1.66177318e-01f, 1.48219958e-01f, -8.32798257e-02f, 1.57071248e-01f,
  -1.90958008e-01f, 2.27137789e-01f, -1.65033802e-01f, -8.52796733e-02f, -6.19887002e-03f, -3.22317705e-02f, 9.21707302e-02f, -1.68156251e-01f, -3.26744497e-01f, -2.88642824e-01f,
  1.32012842e-02f, 6.90351874e-02f, 4.39938158e-02f, -3.17545868e-02f, 4.11230624e-02f, 9.57421064e-02f, -6.42692149e-02f, -7.13371411e-02f, 4.96662222e-02f, -1.75146013e-01f,
  -9.07986984e-02f, 2.72923201e-01f, 9.30697024e-02f, -1.95298746e-01f, -3.73767108e-01f, 2.03969836e-01f, -1.07272100e-02f, -1.31175026e-01f, -2.19386160e-01f, 2.33843371e-01f,
  -2.37748250e-01f, 2.84992695e-01f, 7.67809749e-02f, -1.59362815e-02f, 2.51371354e-01f, 3.64002407e-01f, 2.80174464e-01f, 3.06072205e-01f, 1.81142777e-01f, -1.79773882e-01f,
  2.67877102e-01f, 3.36512655e-01f, -3.46679509e-01f, -3.05702537e-01f, -2.27494732e-01f, -2.10554466e-01f, 1.02518490e-02f, -1.68445930e-01f, -4.44655120e-01f, 1.15116768e-01f,
  2.60201663e-01f, 5.00723302e-01f, 3.61543775e-01f, -5.53441167e-01f, -3.84413570e-01f, -3.18383723e-01f, -4.91696417e-01f, 2.40800917e-01f, 9.97421611e-03f, -6.05342746e-01f,
  -5.47244608e-01f, 7.99900815e-02f, -2.83394694e-01f, -2.68640548e-01f, 1.55052871e-01f, -6.48627579e-02f, -4.66979928e-02f, 6.28757104e-02f, -3.23301286e-01f, 1.12641506e-01f,
  1.55087918e-01f, -1.21450529e-01f, -3.60071927e-01f, -1.77330345e-01f, 2.36120578e-02f, -8.66562352e-02f, -2.35787313e-02f, 1.06209226e-01f, -3.36975217e-01f, -6.17687911e-05f,
  -3.01028378e-02f, -3.29155236e-01f, 4.56604436e-02f, -2.05412284e-01f, -4.08126973e-02f, 1.03301227e-01f, -7.59991854e-02f, 2.54456192e-01f, 1.51045784e-01f, -3.82406592e-01f,
  -3.19187492e-01f, 3.54206562e-01f, -1.50359422e-02f, -1.45535514e-01f, 3.33970964e-01f, 2.12127641e-01f, 5.11644743e-02f, 4.84182779e-03f, -2.44594485e-01f, -1.13649443e-01f,
  2.84560248e-02f, -3.05879325e-01f, 1.28245696e-01f, 1.12329818e-01f, -3.88238907e-01f, 3.10188264e-01f, 1.29974168e-02f, -3.90259892e-01f, -2.47910172e-01f, 3.34478617e-01f,
  1.52922168e-01f, 1.70946077e-01f, -3.63470733e-01f, 2.20023736e-01f, -4.30899173e-01f, -5.26705861e-01f, -3.18140298e-01f, 3.49893451e-01f, 4.72512245e-01f, 1.22710699e-02f,
  2.09711641e-02f, -4.28842865e-02f, -3.15995008e-01f, -7.60159120e-02f, 1.98044375e-01f, -6.27199769e-01f, 4.19422776e-01f, 7.99096972e-02f, -1.98287204e-01f, 1.61467344e-01f,
  4.87544350e-02f, -2.38490105e-02f, -4.40094545e-02f, -9.66676772e-02f, 1.64054364e-01f, 5.65669835e-02f, 3.29243779e-01f, 9.06532183e-02f, -1.15683330e-02f, -3.86905558e-02f,
  1.57406077e-01f, 2.13470280e-01f, -1.83590576e-01f, 1.57611053e-02f, 7.33857276e-04f, 1.23229526e-01f, -1.74522176e-02f, -1.81612119e-01f, 2.18609035e-01f, 4.45993505e-02f,
  2.55030155e-01f, -1.96356606e-02f, 2.93579638e-01f, -1.66824281e-01f, 1.37467891e-01f, 1.24092877e-01f, 3.63142900e-02f, 9.92733613e-02f, 1.72005948e-02f, -2.69934893e-01f,
  2.73797303e-01f, -2.10372165e-01f, -2.86296457e-01f, 2.60811716e-01f, -4.51332241e-01f, 4.37262148e-01f, 2.12056890e-01f, -3.88025254e-01f, 3.41073096e-01f, -2.58291572e-01f,
  5.11596322e-01f, 1.75538719e-01f, 4.43346977e-01f, -2.85319567e-01f, -6.77213669e-02f, 1.12392977e-01f, 2.71808177e-01f, -5.42804360e-01f, -2.78295279e-01f, 3.88984174e-01f,
  -5.95577121e-01f, 2.74491102e-01f, 2.87157625e-01f, -9.37531963e-02f, 2.89914191e-01f, -3.38615239e-01f, -5.07052481e-01f, -5.64543724e-01f, 1.83020130e-01f, 2.06342921e-01f,
  -2.33181074e-01f, 2.68555164e-01f, 2.80431032e-01f, -3.98808986e-01f, 1.81665421e-01f, 2.71951348e-01f, -3.53055924e-01f, -2.19073132e-01f, 1.57098800e-01f, 2.44482487e-01f,
  -1.62748042e-02f, 1.80434644e-01f, -6.49474422e-03f, 2.31433660e-01f, 1.90319002e-01f, 2.11194202e-01f, 8.57306942e-02f, -2.37454437e-02f, -1.63714513e-01f, 1.99439917e-02f,
  -3.73938441e-01f, 3.21544521e-02f, -2.46800259e-01f, 3.18140566e-01f, -2.88413703e-01f, -1.99257538e-01f, 1.13344975e-01f, -1.11025929e-01f, -2.99808383e-01f, 3.21659923e-01f,
  -1.41940519e-01f, -2.64066104e-02f, 2.63177663e-01f, -4.69879329e-01f, -1.64312184e-01f, 3.67576599e-01f, -3.81834339e-03f, -5.49105048e-01f, 3.40443134e-01f, -3.59682322e-01f,
  -1.41265303e-01f, 3.51139516e-01f, 1.08833797e-01f, -3.84694189e-01f, -4.71741110e-01f, 3.30855511e-02f, -1.60513848e-01f, -1.68187931e-01f, 1.37204215e-01f, -3.83575827e-01f,
  -1.36120915e-02f, 1.69453733e-02f, -4.01059598e-01f, -7.09633887e-01f, -1.67409658e-01f, 4.78558034e-01f, -3.95932704e-01f, 2.44416371e-02f, 3.31572205e-01f, -4.38236624e-01f,
  3.21838528e-01f, 1.04768626e-01f, -8.27800184e-02f, 1.57025531e-01f, -3.47334109e-02f, -1.69516966e-01f, 1.20526135e-01f, -3.56817484e-01f, -2.06794024e-01f, 2.08601356e-01f,
  4.84268427e-01f, -1.92919046e-01f, -5.55610657e-02f, -3.18125308e-01f, -3.02240133e-01f, -2.87458688e-01f, 1.13384575e-01f, 3.55329551e-02f, -5.14875725e-02f, 1.10973999e-01f,
  -4.15319391e-02f, -1.55822888e-01f, -1.45709887e-01f, 5.33122234e-02f, 2.66455770e-01f, -7.92523175e-02f, 2.29198053e-01f, -2.39310637e-01f, -2.59979099e-01f, -1.22367091e-01f,
  3.24836224e-01f, -2.68821418e-01f, 1.09624602e-01f, -1.39467463e-01f, 5.59047461e-01f, -2.73965392e-02f, 3.67515206e-01f, 3.23650330e-01f, -2.33729526e-01f, -1.61303021e-02f,
  5.81863746e-02f, -9.28619429e-02f, 1.78306028e-01f, 3.88781607e-01f, 2.56262541e-01f, 2.22468421e-01f, 1.29055038e-01f, -2.75369406e-01f, -1.69170499e-01f, -3.64818275e-01f,
  -1.49708882e-01f, -1.94574475e-01f, -3.20827097e-01f, -2.09844127e-01f, 3.80213767e-01f, -4.68531460e-01f, -4.27743167e-01f, 3.39388937e-01f, 4.33936119e-01f, -3.39997232e-01f,
  -3.77327055e-01f, -3.98648411e-01f, 1.76461875e-01f, -1.07784264e-01f, 3.38420093e-01f, -2.23504822e-03f, -5.48016071e-01f, -1.57799900e-01f, 7.87011459e-02f, -8.56865868e-02f,
  -2.62627080e-02f, 4.75540906e-02f, 5.41433804e-02f, -2.10666612e-01f, 1.63656279e-01f, -2.55983561e-01f, -1.87600404e-01f, -6.44172877e-02f, -1.35403141e-01f, 3.00970413e-02f,
  -5.11965044e-02f, -2.17981592e-01f, -4.14197631e-02f, -1.48676977e-01f, -6.95196092e-02f, -2.28740964e-02f, 9.56486464e-02f, 1.11864552e-01f, 2.11894568e-02f, 7.86070675e-02f,
  9.87437367e-02f, 2.61633042e-02f, 2.09512748e-02f, -1.83234736e-01f, 8.07732344e-02f, -8.72406214e-02f, -1.52555510e-01f, 2.02696279e-01f, -6.48343042e-02f, -1.10895164e-01f,
  -2.65456408e-01f, 1.33349746e-01f, 1.65742159e-01f, -2.63526022e-01f, -1.12997733e-01f, -3.54883336e-02f, -1.74238041e-01f, 3.01083505e-01f, 1.34778410e-01f, -1.90509513e-01f,
  -2.72786528e-01f, -9.94855165e-02f, -2.09975347e-01f, 1.71704739e-01f, 3.74468341e-02f, 2.12408796e-01f, -1.81655601e-01f, 1.76493883e-01f, -3.08262259e-01f, -3.38907450e-01f,
  1.72319964e-01f, -2.96274126e-01f, 3.54682773e-01f, -5.68930387e-01f, 2.08210632e-01f, 4.28224951e-01f, -1.30580500e-01f, -2.51302123e-01f, 8.29043165e-02f, 3.11830074e-01f,
  4.08145756e-01f, -5.26035905e-01f, 1.09588690e-01f, 1.02137856e-01f, -1.07310839e-01f, -5.10004759e-02f, -1.80264160e-01f, 7.62248039e-02f, 1.52629003e-01f, -9.25902203e-02f,
  1.74809664e-01f, -1.34478882e-01f, 6.29187226e-02f, 1.63868479e-02f, -2.08506897e-01f, 1.86568260e-01f, -1.49656713e-01f, -1.53263256e-01f, 4.85418290e-02f, -1.62300751e-01f,
  -2.36829013e-01f, 1.14060998e-01f, 5.60170673e-02f, 7.27977753e-02f, 2.44811714e-01f, 6.55977577e-02f, -1.42251417e-01f, 2.98341602e-01f, 3.46458167e-01f, 2.74530590e-01f,
  4.57533710e-02f, -2.73257762e-01f, -1.46448150e-01f, 2.28068829e-01f, -2.70980418e-01f, 1.12924136e-01f, -2.96738893e-01f, 1.33539796e-01f, 3.15613210e-01f, -3.15657973e-01f,
  -2.51739681e-01f, -2.41897762e-01f, -2.92120814e-01f, 1.04470924e-01f, -3.93566132e-01f, 1.58231467e-01f, 4.01434191e-02f, -3.70178699e-01f, -3.05719554e-01f, 5.00231013e-02f,
  2.68323869e-01f, -2.58423120e-01f, -4.58096236e-01f, 7.84015059e-02f, 2.54858881e-01f, -3.90308648e-01f, 3.01045895e-01f, 1.64517909e-01f, -3.79576921e-01f, -2.42256448e-01f,
  -4.26602215e-01f, 1.58333778e-01f, 3.19355637e-01f, -9.24948677e-02f, 5.32696128e-01f, -3.27858478e-01f, -2.79901296e-01f, 2.16594234e-01f, 3.05582099e-02f, 2.57812142e-01f,
  9.47873741e-02f, 4.51600142e-02f, -3.18111390e-01f, 2.81324416e-01f, 4.61163418e-03f, 1.95548028e-01f, -8.19286257e-02f, -7.33250976e-02f, -2.84251720e-01f, 4.78700772e-02f,
  -3.74347836e-01f, -5.01575530e-01f, 5.45169748e-02f, -1.82167187e-01f, -5.30216172e-02f, -1.68798029e-01f, -1.60942804e-02f, 1.43280640e-01f, -1.82465672e-01f, -1.25409320e-01f,
  3.48772407e-01f, -1.56784981e-01f, 7.77014717e-02f, -4.54127751e-02f, 1.87172562e-01f, -2.69562334e-01f, -3.39336365e-01f, -2.18989432e-01f, -1.83012038e-01f, 2.57050991e-01f,
  -1.42295346e-01f, 3.56805742e-01f, 4.51157987e-01f, 3.59319240e-01f, -1.29381984e-01f, 1.26444846e-01f, 4.40788269e-02f, -3.08588654e-01f, 1.91328913e-01f, -2.99472660e-01f,
  -3.04627120e-01f, 3.09327185e-01f, -2.24132821e-01f, -1.37753531e-01f, -3.47598493e-01f, 5.49241640e-02f, 1.02445304e-01f, -3.25460821e-01f, 9.79398116e-02f, -4.38728780e-01f,
  6.85465485e-02f, -5.53529978e-01f, -6.14925683e-01f, 4.73640025e-01f, 2.23785862e-01f, -2.12481737e-01f, -4.75333393e-01f, -4.89781141e-01f, 1.35852024e-01f, 4.25484657e-01f,
  1.63262367e-01f, 1.05824627e-01f, -6.41775578e-02f, 1.80032074e-01f, 1.07501604e-01f, -1.60671458e-01f, 3.76330584e-01f, 1.41160488e-01f, 5.68249673e-02f, 2.74876237e-01f,
  3.20529550e-01f, 1.14176668e-01f, -1.05942316e-01f, 5.15486263e-02f, 1.60633698e-01f, 8.43042731e-02f, -1.87954269e-02f, 1.62324220e-01f, 1.48708429e-02f, -1.59313649e-01f,
  1.28607973e-01f, -3.06073666e-01f, 1.52904212e-01f, -9.46241319e-02f, -1.09666079e-01f, 1.74041167e-01f, 6.62574023e-02f, 3.90203893e-01f, -1.27049044e-01f, -3.65742683e-01f,
  -1.99263588e-01f, 2.05625268e-03f, -9.93535593e-02f, -1.92857221e-01f, 2.37182975e-01f, -2.05644280e-01f, 3.41497622e-02f, 2.13963777e-01f, -2.27526173e-01f, -1.38279364e-01f,
  -8.66066013e-03f, -3.37232172e-01f, -1.77362144e-01f, 1.84558444e-02f, 1.88757107e-01f, -2.04070538e-01f, 1.58446759e-01f, 1.12226762e-01f, 1.51336640e-01f, 3.12941402e-01f,
  -3.37667108e-01f, 4.25746143e-01f, 1.68379307e-01f, 4.22489315e-01f, -3.44188869e-01f, -1.91271365e-01f, 1.32846951e-01f, -6.49161100e-01f, -2.80339599e-01f, 4.42837596e-01f,
  -4.46567595e-01f, 2.53324538e-01f, -5.33285201e-01f, -4.97935057e-01f, 2.23751009e-01f, -3.20879440e-03f, -1.50858596e-01f, -2.00396344e-01f, 5.73469922e-02f, -7.37516806e-02f,
  -7.10384026e-02f, 6.74046129e-02f, -6.10314608e-02f, 9.35341418e-02f, 9.33151841e-02f, 1.31210223e-01f, -2.31781099e-02f, -2.17721596e-01f, -5.45962006e-02f, -1.60330534e-01f,
  1.27269641e-01f, 1.08315654e-01f, 4.27024029e-02f, -4.29181792e-02f, -3.15165892e-02f, 1.36543080e-01f, 1.06697060e-01f, 3.93333621e-02f, -1.90475807e-01f, 3.15369703e-02f,
  2.22134329e-02f, -2.00562373e-01f, 2.54836500e-01f, -3.06492865e-01f, 3.85991573e-01f, -1.92074955e-01f, 8.53422433e-02f, 2.59655118e-01f, 3.32832158e-01f, -8.55547413e-02f,
  2.89769381e-01f, -1.92545518e-01f, -2.10013837e-01f, -2.60687143e-01f, -2.81179428e-01f, 3.60785156e-01f, -1.53721556e-01f, 2.75580250e-02f, 3.06917429e-01f, 3.58541340e-01f,
  2.38841981e-01f, 2.61794090e-01f, -2.34403431e-01f, -3.02643895e-01f, 1.93756416e-01f, -1.32874742e-01f, -3.64013016e-01f, -2.09635913e-01f, -9.54831988e-02f, 5.80875635e-01f,
  -1.87884584e-01f, 2.67608672e-01f, -1.62170157e-01f, 5.34754932e-01f, 1.11279637e-01f, -3.12346011e-01f, -7.30881989e-01f, -5.93042016e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.34572159e-02f, -2.27059722e-02f, 4.28992510e-02f, 2.55558230e-02f, 7.93996602e-02f, -2.86618080e-02f, -1.47268400e-02f, 1.90326590e-02f, 5.69385998e-02f, 9.25093964e-02f,
  -8.70620981e-02f, 1.97366555e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    