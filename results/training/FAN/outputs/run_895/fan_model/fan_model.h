/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.82583648e-01f, 1.99811757e-01f, -1.63264468e-01f, -1.55683711e-01f, -1.78677998e-02f, 4.18512039e-02f, 1.23920470e-01f, 6.06176071e-02f, -4.26779687e-02f, -2.26172898e-02f,
  -2.57428605e-02f, 3.78682055e-02f, -1.51522592e-01f, -3.66811790e-02f, -2.08589748e-01f, -9.75111499e-02f, -1.81595489e-01f, -3.01343739e-01f, -2.75139138e-02f, 6.50501400e-02f,
  1.35672346e-01f, 4.41078693e-02f, -1.44740507e-01f, 2.01548655e-02f, 4.09682579e-02f, 1.24404974e-01f, -1.97105221e-02f, 8.59058648e-02f, 4.51217480e-02f, -2.70804688e-02f,
  1.47614077e-01f, 5.77540882e-03f, -2.13850383e-02f, -5.71481064e-02f, 3.82565483e-02f, -2.79947799e-02f, -1.59513880e-03f, 2.44338159e-03f, 2.48994306e-02f, -1.11069866e-02f,
  1.08008822e-02f, 6.75828010e-02f, -1.85663928e-03f, 8.55715275e-02f, 6.47160634e-02f, 6.82995245e-02f, -2.64359750e-02f, -4.65106331e-02f, -1.33930564e-01f, 6.84943423e-02f,
  1.30904913e-01f, 5.69900908e-02f, -3.40294763e-02f, -1.85705442e-02f, 2.72232648e-02f, -7.54099265e-02f, 1.18222922e-01f, 5.83770312e-02f, 7.07596913e-03f, 7.08717704e-02f,
  -2.25280188e-02f, -2.77200490e-02f, -3.94983254e-02f, 4.77071926e-02f, -1.11750476e-02f, -3.73312868e-02f, 6.32920116e-02f, -4.31224294e-02f, 4.96885413e-03f, 1.37530919e-02f,
  -2.96044014e-02f, -9.53182951e-02f, -4.06384245e-02f, 3.20290625e-02f, 3.74768861e-02f, 4.09292988e-02f, -6.27195637e-04f, 2.46937983e-02f, -7.89287835e-02f, -3.43804285e-02f,
  1.47951851e-02f, 1.03950892e-02f, -2.31105778e-02f, 9.54526365e-02f, -4.18714061e-02f, -2.59618163e-02f, -8.75558630e-02f, 3.62091139e-02f, 7.82077983e-02f, -3.04127466e-02f,
  1.72360837e-01f, -2.30498120e-01f, -1.16330318e-01f, -4.42204550e-02f, 4.32773903e-02f, -4.61992137e-02f, 2.40938067e-02f, 5.44462167e-02f, 5.49359545e-02f, 3.30197848e-02f,
  4.83643636e-02f, -7.44400993e-02f, 2.39737667e-02f, 4.37465943e-02f, 2.36484897e-03f, 2.21855752e-02f, 8.61215347e-04f, -6.82136491e-02f, -2.61611268e-02f, 1.71484314e-02f,
  -8.25699940e-02f, -8.35989118e-02f, -1.52200498e-02f, -1.52026974e-02f, 6.55022562e-02f, -1.26692966e-01f, 4.92096283e-02f, 1.03325218e-01f, -6.64358959e-02f, 1.16141103e-01f,
  -2.25716606e-01f, -8.96564424e-02f, -1.43516704e-01f, -8.96440540e-03f, 3.50977145e-02f, 7.13536516e-02f, 8.07419047e-03f, 3.34641300e-02f, -2.14430727e-02f, -1.22808285e-01f,
  4.54632603e-02f, 1.42061621e-01f, 1.12198725e-01f, 1.14909619e-01f, 8.38038232e-03f, -1.22833513e-02f, -1.08743690e-01f, -6.44821003e-02f, 1.60380483e-01f, 1.40335232e-01f,
  -1.07468700e-03f, -1.19112626e-01f, -1.13828257e-01f, 1.89369489e-02f, -2.54015382e-02f, 3.93040814e-02f, -1.17257655e-01f, 1.52279651e-02f, 1.39193565e-01f, -2.23376490e-02f,
  -4.26609442e-02f, -9.93655175e-02f, 6.48235753e-02f, 2.88769919e-02f, -6.92169124e-04f, 8.83092824e-03f, 2.98246015e-02f, -9.81337577e-03f, -9.91191017e-04f, 2.85233203e-02f,
  9.60133374e-02f, -7.03831017e-02f, -4.00901996e-02f, -8.66508931e-02f, -6.73918426e-02f, 1.99580640e-02f, -1.25567526e-01f, 4.24866006e-03f, -4.66436818e-02f, 1.16373496e-02f,
  -4.33303751e-02f, -9.55437347e-02f, -2.32738582e-03f, 1.68342926e-02f, 3.94796282e-02f, 8.25462490e-02f, -3.67192365e-02f, 5.01194336e-02f, -2.92836688e-02f, -4.23810482e-02f,
  7.69143030e-02f, 2.66954172e-02f, 7.03238472e-02f, -3.93180400e-02f, 1.56231839e-02f, 3.02456282e-02f, -3.34740803e-02f, 3.52553986e-02f, 5.25390618e-02f, -5.75506687e-02f,
  5.26905060e-02f, -5.49170822e-02f, -5.83043462e-03f, -1.82444043e-02f, 8.75938311e-02f, -7.19686821e-02f, -4.82236184e-02f, -2.74966774e-03f, 7.42241666e-02f, -4.06319909e-02f,
  -4.92690802e-02f, -1.33502865e-02f, -3.80372815e-02f, 6.20182976e-02f, -7.90234376e-03f, 2.49309577e-02f, 1.73563063e-02f, 3.14175971e-02f, -7.34212901e-03f, -7.38495737e-02f,
  -6.77108988e-02f, 1.42031804e-01f, -5.25152311e-02f, 5.02310023e-02f, 2.70935502e-02f, -4.85773198e-03f, -4.91041057e-02f, 6.77749738e-02f, -2.17634011e-02f, -4.75413837e-02f,
  -5.44516295e-02f, -9.25892964e-02f, 4.36730869e-02f, 4.77972114e-03f, -2.96698883e-02f, 2.29521766e-02f, -6.84166551e-02f, 4.92740422e-04f, 9.59823132e-02f, -4.12895605e-02f,
  -2.51447558e-02f, 2.01153774e-02f, -1.13149203e-01f, 6.40712380e-02f, 5.67963198e-02f, 5.62780462e-02f, 1.88783687e-02f, 4.84394515e-03f, -6.00609258e-02f, -7.70407096e-02f,
  2.85585411e-03f, 3.97333056e-02f, 2.39500906e-02f, -1.74489096e-02f, 9.45301950e-02f, 3.41692716e-02f, 2.37656068e-02f, -6.64957762e-02f, -9.08989981e-02f, 8.12592357e-02f,
  6.38934597e-02f, -1.89225432e-02f, 4.57000956e-02f, -2.36416161e-02f, -1.07837133e-02f, -1.53707722e-02f, -2.14265976e-02f, 8.59279856e-02f, 4.41280790e-02f, -5.82572632e-03f,
  -7.11528875e-04f, -8.13196227e-02f, 2.42490899e-02f, -1.15132809e-01f, 1.16225347e-01f, -1.89862251e-02f, 9.71867144e-02f, 1.75932162e-02f, 5.63709028e-02f, 1.47421613e-01f,
  2.20910296e-01f, 6.75733536e-02f, 6.70336708e-02f, -8.40943381e-02f, 3.85249928e-02f, 2.78289970e-02f, 3.53790238e-03f, -3.70326526e-02f, 4.52730469e-02f, -2.81172618e-02f,
  1.99777801e-02f, -8.63934122e-03f, -3.65190767e-02f, -8.77111927e-02f, 4.28901240e-02f, 4.21308205e-02f, 2.45790966e-02f, 1.52269676e-02f, -3.60477599e-04f, 2.04083472e-02f,
  2.11670958e-02f, 2.00971980e-02f, 3.75336409e-02f, -3.75427045e-02f, -3.37739438e-02f, 7.59345815e-02f, 7.95938298e-02f, -4.75753136e-02f, -1.26739768e-02f, 4.06283364e-02f,
  4.99049537e-02f, 2.00865548e-02f, 7.32976198e-02f, -4.28976491e-02f, 3.49667743e-02f, 6.21752217e-02f, -8.01259801e-02f, 6.02214001e-02f, 7.47743323e-02f, 2.85769477e-02f,
  -7.67907575e-02f, 6.80224597e-02f, -8.10764879e-02f, -3.49653959e-02f, 1.97083373e-02f, -5.73334545e-02f, -1.24597866e-02f, 5.94945624e-02f, 7.94565678e-02f, 5.42309694e-03f,
  6.97656348e-02f, -1.44831103e-03f, 5.08192778e-02f, -5.35968877e-02f, -3.45082581e-02f, 5.67643866e-02f, 8.34519882e-03f, -5.41259348e-02f, 9.55193304e-03f, 4.00236882e-02f,
  -1.33207634e-01f, 6.63801506e-02f, 8.76386613e-02f, 6.29938096e-02f, -2.60106195e-02f, -8.68408978e-02f, 6.81723356e-02f, -5.57089485e-02f, -1.58201866e-02f, -3.06765307e-02f,
  5.38379438e-02f, -8.33730549e-02f, 3.97470966e-02f, 1.04840964e-01f, -5.70923798e-02f, 5.12541048e-02f, 6.99226409e-02f, -5.26106320e-02f, -5.46193905e-02f, -2.64942087e-02f,
  -3.88156436e-02f, 5.93178943e-02f, 1.92170274e-02f, -3.66542824e-02f, 1.93311926e-02f, 1.02791088e-02f, -2.73677185e-02f, -7.45084211e-02f, 3.45781334e-02f, -9.34754238e-02f,
  -1.01641163e-01f, 1.84909642e-01f, -1.63698662e-02f, 2.41245590e-02f, 6.51479512e-02f, 6.46506250e-02f, 2.50677675e-01f, -8.05246606e-02f, -1.81912601e-01f, 4.82354797e-02f,
  -6.82201236e-02f, -2.30367988e-01f, -8.45313072e-02f, -1.66906193e-01f, 3.94759234e-03f, 6.39644191e-02f, 1.07387491e-01f, -3.05528962e-03f, -1.93846330e-01f, 9.77139082e-03f,
  4.53296714e-02f, -2.56454200e-02f, -1.51048169e-01f, -1.10044964e-01f, 2.12585419e-01f, -1.18081652e-01f, 3.87622118e-02f, 1.38973564e-01f, 1.41982317e-01f, 3.72328937e-01f,
  6.46570921e-02f, 8.72731134e-02f, -3.27397138e-02f, 5.55372657e-03f, 6.34278590e-03f, 4.64836955e-02f, 4.94707450e-02f, 2.57355012e-02f, -3.69294845e-02f, 1.01468293e-03f,
  -1.34530971e-02f, 3.85911353e-02f, 5.69315851e-02f, -7.93266296e-03f, 5.54895364e-02f, 3.25641409e-02f, -4.01259549e-02f, 3.17490287e-02f, -1.12222452e-02f, 1.15421288e-01f,
  1.03468977e-01f, 4.22143340e-02f, 1.40950948e-01f, 6.46109357e-02f, -1.67518351e-02f, 7.48565271e-02f, 8.18623230e-02f, 1.42806441e-01f, 1.61034301e-01f, 2.65199035e-01f,
  1.52948312e-02f, 3.01003316e-03f, 2.65633147e-02f, 6.02361113e-02f, 3.10175791e-02f, -2.14525685e-02f, 4.27757725e-02f, -1.19421352e-02f, 1.12223001e-02f, -3.76578048e-02f,
  -3.25026847e-02f, 1.37930932e-02f, -1.67627633e-02f, 1.45271719e-02f, 6.36588037e-02f, 1.49239982e-02f, 4.05472927e-02f, 2.19572242e-02f, -8.54367465e-02f, 7.33778924e-02f,
  -5.38032912e-02f, -1.56517196e-02f, 1.65848155e-02f, 6.30707964e-02f, -9.34496243e-03f, 1.83697380e-02f, 4.07853723e-02f, -5.74797355e-02f, 1.68969445e-02f, -2.30143010e-03f,
  -1.70720249e-01f, -6.94860145e-02f, -9.69519019e-02f, 9.37802531e-03f, -2.67397407e-02f, 1.29637271e-02f, -5.19077927e-02f, -1.03043495e-02f, -7.24374875e-02f, 9.38014407e-03f,
  -4.44085784e-02f, -3.42095899e-03f, -3.87716331e-02f, -2.90398356e-02f, 2.58492008e-02f, -8.45752358e-02f, -8.42605382e-02f, -5.42738708e-04f, 6.89984336e-02f, -5.99320605e-02f,
  -6.16145916e-02f, 2.36774441e-02f, -1.03329249e-01f, 9.87495333e-02f, 6.28597438e-02f, -5.31479493e-02f, -5.98388352e-03f, 3.93559821e-02f, -1.21727332e-01f, 4.93628811e-03f,
  -4.52831797e-02f, 5.84825985e-02f, 6.85729161e-02f, -1.51657641e-01f, -1.37538284e-01f, 6.88909367e-02f, 1.70726717e-01f, 4.32119742e-02f, 4.85693626e-02f, -2.12746346e-03f,
  -1.77886784e-01f, -3.67671251e-02f, 4.87343315e-03f, 1.19077027e-01f, 2.23867625e-01f, 1.81369558e-01f, 1.12291649e-01f, 2.45998204e-01f, 5.83541058e-02f, 2.96468427e-03f,
  2.05384810e-02f, 4.89831977e-02f, 3.07425838e-02f, 4.86702882e-02f, -2.75191087e-02f, -1.30203913e-03f, -8.93242806e-02f, 2.67077535e-02f, -1.06738843e-01f, 1.20664373e-01f,
  1.26707017e-01f, -2.06383884e-01f, 3.85782234e-02f, -6.43828660e-02f, -1.20713949e-01f, 6.29257038e-02f, 2.35808548e-02f, -5.63112274e-02f, -5.55205010e-02f, -1.81192011e-02f,
  3.27034574e-03f, -3.51010486e-02f, 2.29122303e-02f, -4.89125177e-02f, -1.12202927e-01f, 1.10375032e-01f, -1.47778085e-02f, 2.10487600e-02f, 1.25463173e-01f, 9.40511674e-02f,
  -2.52835569e-03f, -1.94122363e-02f, 5.37985712e-02f, -1.11133158e-02f, 4.66735661e-02f, -6.98137134e-02f, -1.54117681e-03f, 8.80840346e-02f, 1.42151546e-02f, 7.00670332e-02f,
  -6.35478050e-02f, -6.48503602e-02f, 3.55119468e-03f, -4.98885848e-02f, -3.39311361e-03f, 7.61429267e-03f, -5.10326214e-03f, 2.63038706e-02f, -4.10200283e-03f, 4.04989682e-02f,
  1.53473970e-02f, -2.33051348e-02f, -7.84551576e-02f, 4.14325371e-02f, -4.10776548e-02f, 1.48582412e-02f, 7.33454302e-02f, 2.20933016e-02f, 1.07580781e-01f, -7.50233652e-03f,
  5.06922975e-02f, -5.09198345e-02f, 4.58524413e-02f, -1.10660903e-02f, 4.48877178e-02f, 3.67458053e-02f, -4.99246046e-02f, 5.88793196e-02f, 5.16995341e-02f, 4.26213965e-02f,
  4.00977768e-03f, -2.32560076e-02f, 3.58869284e-02f, 1.44512564e-01f, 3.85087207e-02f, 2.49981992e-02f, -9.43319649e-02f, 3.19944471e-02f, 3.29818763e-02f, 7.40367323e-02f,
  9.61482748e-02f, 2.31676102e-02f, -5.70755154e-02f, -2.55083740e-02f, 4.39629517e-02f, -2.79648621e-02f, 8.25380459e-02f, 1.13350868e-01f, 1.11791976e-02f, 8.68311822e-02f,
  7.14677721e-02f, 1.21489562e-01f, 1.66656017e-01f, 1.87319741e-02f, 5.24400882e-02f, 3.13462280e-02f, 1.15023002e-01f, 3.52391750e-02f, 2.00764030e-01f, 1.10493287e-01f,
  -2.60953873e-01f, 1.48569699e-02f, -9.76811349e-02f, -7.62526691e-02f, 1.74672619e-01f, -2.43034922e-02f, -1.31039739e-01f, 5.34653710e-03f, 1.30058751e-01f, 1.11301756e-02f,
  1.94887325e-01f, 1.47758648e-01f, 3.46423388e-02f, 1.19077943e-01f, -1.93934485e-01f, -1.36766449e-01f, -9.80856046e-02f, -1.61499724e-01f, -1.24981113e-01f, 4.37234342e-02f,
  1.44453153e-01f, -5.68611026e-02f, -1.42314419e-01f, -6.49713203e-02f, 6.96752220e-02f, 4.37549241e-02f, 3.57111245e-02f, 9.51277018e-02f, 1.88875690e-01f, 1.05068153e-02f,
  1.37020409e-01f, -5.39761111e-02f, -3.46571533e-03f, 1.23722479e-01f, 7.93149024e-02f, -5.32636158e-02f, -5.98305017e-02f, 9.12060589e-03f, -5.47633544e-02f, -2.85242014e-02f,
  -2.02040337e-02f, 8.80691260e-02f, -6.85299635e-02f, 2.51916088e-02f, -9.24020633e-03f, -3.27465590e-04f, -7.04301745e-02f, -6.89028278e-02f, -1.48176014e-01f, 7.61397332e-02f,
  1.06602371e-01f, 1.52895018e-01f, 4.74231616e-02f, -2.88120545e-02f, -8.74872729e-02f, -1.80740710e-02f, 1.14227839e-01f, 9.01271701e-02f, 7.02796085e-03f, 5.97285666e-02f,
  -1.27111450e-02f, -3.52504663e-02f, 1.47125432e-02f, 3.34913954e-02f, -3.03936340e-02f, 4.52060299e-03f, -6.09943271e-02f, 3.36794630e-02f, -5.36493538e-03f, -1.47345001e-02f,
  -1.32595906e-02f, -4.16950770e-02f, 8.49831104e-02f, -9.81676057e-02f, -6.42206296e-02f, -5.69046959e-02f, 3.30434297e-03f, 7.64184864e-03f, 8.66688713e-02f, -3.28859165e-02f,
  2.13031005e-02f, -2.76150554e-02f, -1.30927525e-02f, -3.50143500e-02f, 6.71800002e-02f, 1.34064620e-02f, -7.91069213e-03f, 5.43939434e-02f, 1.87159218e-02f, 4.97579612e-02f,
  3.09459828e-02f, -3.12365815e-02f, 1.40247298e-02f, -3.27876359e-02f, -4.14435901e-02f, 7.77528584e-02f, -9.98508744e-03f, 6.52616890e-03f, 1.36389630e-02f, -5.18217757e-02f,
  6.44945875e-02f, 7.71643035e-03f, -1.29657807e-02f, -3.09497882e-02f, 2.31310204e-02f, -2.88666468e-02f, -4.65491638e-02f, 1.52169121e-02f, -3.85204367e-02f, 7.86398947e-02f,
  7.82346055e-02f, -6.34329170e-02f, -5.65788411e-02f, -1.66479181e-02f, -1.21268341e-02f, 9.21498239e-03f, -1.06794736e-03f, 2.02721935e-02f, -1.50481209e-01f, -2.15572685e-01f,
  3.29406589e-01f, 8.17325711e-02f, -3.29059154e-01f, 2.02075019e-01f, -6.55365214e-02f, -1.24614060e-01f, -3.35410625e-01f, -4.15898301e-03f, 2.19305769e-01f, 3.94636579e-02f,
  1.34330869e-01f, 2.28216335e-01f, 1.04452208e-01f, 1.32849932e-01f, -6.84916303e-02f, -3.10398430e-01f, -2.65460700e-01f, -1.57064229e-01f, -1.71918869e-01f, -3.66057344e-02f,
  4.50996347e-02f, 1.49612740e-01f, 2.47250140e-01f, 7.89716244e-02f, -5.79654463e-02f, -1.12458700e-02f, 1.97923928e-02f, 1.24546684e-01f, -8.77513662e-02f, -1.76038370e-01f,
  -1.95319116e-01f, 8.51886868e-02f, -1.66309133e-01f, 2.54442394e-01f, 8.25692993e-03f, 4.63779420e-02f, 2.53739096e-02f, 5.44823669e-02f, 1.54055301e-02f, 4.44097212e-03f,
  5.91503419e-02f, 9.38205495e-02f, -3.41200642e-03f, 3.49953920e-02f, -3.71354818e-02f, -1.52134625e-02f, 8.95201787e-02f, 1.72163844e-02f, -7.30580762e-02f, 1.74633483e-03f,
  -7.83384070e-02f, 1.49071023e-01f, -2.01507956e-02f, -1.18080840e-01f, -6.84960112e-02f, 5.73902912e-02f, -5.75771518e-02f, -1.85816605e-02f, 2.74837483e-02f, 1.03671871e-01f,
  3.20971683e-02f, 2.24216897e-02f, -6.45520389e-02f, 6.17201664e-02f, 3.82173248e-02f, 3.97901796e-02f, -4.23172563e-02f, -3.60059477e-02f, 2.56286711e-02f, 1.53605202e-02f,
  3.34364623e-02f, -1.54469190e-02f, 3.90338595e-03f, 6.09233156e-02f, -3.61550711e-02f, -6.91124648e-02f, 1.74311437e-02f, -3.28812376e-02f, 5.99685721e-02f, -1.78766940e-02f,
  -2.61604208e-02f, 3.61353830e-02f, 1.31446877e-02f, -5.72573505e-02f, -5.50184883e-02f, 2.63806954e-02f, -2.03273725e-02f, 3.33551900e-03f, 4.70110252e-02f, 8.28302279e-02f,
  9.09558609e-02f, -2.16592345e-02f, 1.35817379e-02f, 4.50284556e-02f, 5.23958392e-02f, 8.59015808e-02f, 3.97819877e-02f, -1.57166496e-02f, 2.77355611e-02f, 5.19323489e-03f,
  2.86956877e-02f, -3.52714472e-02f, 1.98303275e-02f, -1.08099714e-01f, 4.09940071e-03f, -6.72709048e-02f, 5.53617813e-02f, -4.45903167e-02f, 7.04559162e-02f, 4.54266759e-04f,
  -2.38249507e-02f, -6.92814663e-02f, -4.96201310e-03f, -7.62075409e-02f, 4.15710844e-02f, -2.68184878e-02f, -1.14540271e-01f, -3.61081921e-02f, -4.03300673e-02f, -8.94164443e-02f,
  -2.85854161e-01f, 1.76536575e-01f, -3.51504162e-02f, -2.21465319e-01f, 1.58615887e-01f, 2.47820809e-01f, 4.33186412e-01f, 6.66988865e-02f, -8.81469399e-02f, 9.89696831e-02f,
  9.12023634e-02f, -1.95204601e-01f, -1.41929254e-01f, -1.03990644e-01f, -1.40383746e-02f, 1.05701625e-01f, 8.85483250e-02f, -5.70530780e-02f, 2.16916613e-02f, 1.53717414e-01f,
  7.87318945e-02f, -1.06563665e-01f, -1.77142709e-01f, -8.69412124e-02f, 4.05757800e-02f, -1.10019669e-01f, -4.65312824e-02f, -2.19815709e-02f, 8.54251310e-02f, -1.70268372e-01f,
  -6.54976889e-02f, -2.49729753e-02f, -3.99828590e-02f, -5.40998839e-02f, 6.94966130e-03f, -1.13487998e-02f, -5.21945246e-02f, -8.72153342e-02f, -2.06406740e-03f, -8.52689240e-03f,
  5.64072356e-02f, -3.34633403e-02f, -6.27743602e-02f, 2.44233366e-02f, 3.30295712e-02f, -4.96281683e-02f, 1.85651686e-02f, -7.44839832e-02f, -3.16228867e-02f, 8.90353695e-03f,
  7.15164095e-02f, 1.43923625e-01f, 3.54492627e-02f, 9.39518437e-02f, 5.62105887e-02f, -9.13481116e-02f, 1.07033916e-01f, -1.08265523e-02f, 8.18755403e-02f, -8.28291774e-02f,
  -1.11029632e-02f, 2.76588928e-02f, -2.79382020e-02f, -2.49331575e-02f, 5.32307997e-02f, -3.49067859e-02f, -1.34522896e-02f, 2.47169901e-02f, 4.18356769e-02f, 7.40348175e-02f,
  2.30710115e-02f, 1.70269813e-02f, 2.39429413e-03f, -1.06854076e-02f, -3.18994857e-02f, 1.67991854e-02f, 2.90245023e-02f, 6.03571869e-02f, 3.03550437e-02f, 1.54502485e-02f,
  -4.80963103e-02f, 7.47773424e-02f, -4.89272550e-02f, -4.66594808e-02f, 4.50760983e-02f, -1.67460821e-04f, -2.13516690e-02f, -2.40946072e-03f, -7.75998011e-02f, 5.25152013e-02f,
  -8.74991354e-04f, 2.99521368e-02f, -5.72741814e-02f, 2.18154360e-02f, -5.93742542e-02f, 4.34766226e-02f, -1.93537436e-02f, -2.33818255e-02f, 1.43860271e-02f, 1.16848797e-02f,
  -5.57372458e-02f, 1.19817974e-02f, -3.76748964e-02f, -2.08395533e-02f, 1.06909201e-02f, 5.59786223e-02f, 8.07395577e-02f, -1.54786371e-02f, 7.01569095e-02f, 5.05270362e-02f,
  -2.92319637e-02f, 7.91393965e-02f, 7.36471415e-02f, -6.19921349e-02f, -1.35822237e-01f, 5.26292901e-03f, 9.06017050e-02f, -7.32408091e-02f, 9.60429758e-02f, 5.15476838e-02f,
  3.14722955e-01f, -3.45779419e-01f, 3.87867205e-02f, -4.79565151e-02f, -9.84365046e-02f, 1.24673136e-01f, -3.34603935e-02f, 9.52152908e-02f, -4.35970761e-02f, -1.14534192e-01f,
  -1.48486510e-01f, 2.86154896e-02f, -1.65852550e-02f, -2.10562740e-02f, 1.64537057e-01f, -1.14143141e-01f, -2.40724593e-01f, 9.54444110e-02f, 4.03591454e-01f, 2.54694343e-01f,
  -5.75937442e-02f, -4.92472909e-02f, 3.01355068e-02f, -1.74009951e-03f, -1.51581466e-01f, 1.16714060e-01f, -3.86269055e-02f, -3.13069597e-02f, -1.17224706e-02f, -2.50065506e-01f,
  8.36610794e-03f, 2.47895829e-02f, 1.24903016e-01f, 5.77683374e-02f, 2.94050612e-02f, 7.74063542e-02f, -1.50631610e-02f, -3.32274996e-02f, -3.12794223e-02f, -1.53473049e-01f,
  -4.95968908e-02f, -4.68719900e-02f, 2.07814854e-02f, 2.51146574e-02f, -2.91482527e-02f, -1.42542422e-02f, 1.81594137e-02f, 3.76671925e-02f, 8.66647214e-02f, -4.03275453e-02f,
  -7.13106021e-02f, -5.76944612e-02f, 5.40266298e-02f, -2.13732403e-02f, 2.14903969e-02f, 5.54255955e-02f, 6.17329776e-02f, -1.71926748e-02f, 1.15691714e-01f, 1.02057852e-01f,
  1.02274725e-02f, -7.10776299e-02f, -6.09188527e-03f, 3.22593339e-02f, 3.26823331e-02f, -2.42200755e-02f, -4.35931571e-02f, 8.48656287e-04f, -5.75526897e-03f, 3.04352697e-02f,
  -1.79059487e-02f, 1.83071960e-02f, 1.71913020e-02f, 5.22633903e-02f, -4.16946262e-02f, -3.22478376e-02f, -5.22838440e-03f, 2.87523381e-02f, -4.03597616e-02f, -8.34603887e-03f,
  -2.50205211e-02f, 6.84650196e-03f, 4.72960025e-02f, 6.75733387e-02f, -7.91131854e-02f, 5.75414263e-02f, 3.72389704e-02f, 1.52369142e-02f, 7.79371411e-02f, -5.88208102e-02f,
  4.58537936e-02f, 4.63130213e-02f, -5.32137528e-02f, 3.75603437e-02f, -4.89776507e-02f, -1.76802371e-02f, -6.60334155e-02f, -5.37589453e-02f, -3.99341509e-02f, -5.41406684e-03f,
  5.97714214e-04f, 2.53353193e-02f, 6.46643201e-03f, -2.29574740e-02f, 8.00692886e-02f, -4.34755627e-03f, 6.36789249e-03f, 1.41630664e-01f, 5.03038578e-02f, -5.23669608e-02f,
  1.36847170e-02f, 4.10209745e-02f, 1.50659367e-01f, -3.76757681e-02f, 9.65909883e-02f, 1.51106670e-01f, 1.20883226e-01f, 1.42956123e-01f, 1.76996455e-01f, 1.16359659e-01f,
  1.04422569e-01f, -3.39778543e-01f, 1.99786335e-01f, -1.11038517e-02f, -4.32689451e-02f, 1.48112401e-02f, -1.94724932e-01f, 5.42499572e-02f, 4.10223939e-02f, -1.67646110e-01f,
  -1.42105222e-01f, 1.40590265e-01f, 4.11323644e-02f, 1.42739832e-01f, 9.27043632e-02f, -1.29158765e-01f, -1.90678447e-01f, 2.71732152e-01f, 3.85147691e-01f, 1.82611778e-01f,
  -1.33442149e-01f, -8.35225433e-02f, 7.63051584e-02f, 3.23355645e-02f, -1.20688446e-01f, 4.72778343e-02f, -4.21130098e-03f, -7.72358105e-02f, -1.24737106e-01f, -2.80259877e-01f,
  5.14174588e-02f, 3.25248912e-02f, 1.54736564e-01f, -1.02053925e-01f, 7.50235922e-04f, 2.58019613e-03f, 8.21478758e-03f, -1.69541854e-02f, 4.40463349e-02f, 6.16280697e-02f,
  -3.60533819e-02f, -3.22910249e-02f, -8.29874948e-02f, -9.56087187e-03f, 3.10838362e-03f, 4.41643409e-02f, -1.41411489e-02f, -9.32184234e-03f, -9.39218234e-03f, 3.40034813e-02f,
  -4.58774865e-02f, -1.13497287e-01f, 9.45339911e-04f, -3.23874243e-02f, -1.83524527e-02f, 9.86536741e-02f, 3.65287848e-02f, 2.52236277e-02f, 1.03213854e-01f, -9.60363597e-02f,
  1.53151890e-02f, 9.14127007e-02f, 5.70284836e-02f, -6.84485584e-02f, 4.15453352e-02f, -3.67941521e-02f, -5.27839735e-02f, 3.17407586e-02f, 4.50254185e-03f, -1.75180268e-02f,
  7.73888640e-03f, 1.99855678e-02f, -3.23110707e-02f, -5.14802970e-02f, 1.95716619e-02f, 2.34527867e-02f, 3.01287305e-02f, -5.05642183e-02f, -9.39507317e-03f, -2.59875227e-03f,
  5.54250106e-02f, 1.64415520e-02f, -5.79085574e-02f, 6.75280169e-02f, 7.88659847e-04f, -6.27314998e-03f, -1.43478485e-02f, -7.68207684e-02f, -3.81256044e-02f, -5.60362600e-02f,
  2.28529107e-02f, 5.42304441e-02f, 2.35412903e-02f, 2.63007767e-02f, 3.20278294e-02f, 4.14475352e-02f, -4.65432229e-03f, 9.39833373e-02f, -3.30918916e-02f, -6.57878863e-03f,
  -1.49211418e-02f, 1.09361960e-02f, -8.30444023e-02f, 3.74675877e-02f, 2.47217086e-03f, 1.23297330e-02f, -1.25929400e-01f, -1.05343526e-02f, -1.60536021e-02f, 1.49125876e-02f,
  -6.80806786e-02f, 1.01939529e-01f, 1.81764349e-01f, 6.65860102e-02f, -5.19559830e-02f, 1.16771027e-01f, 7.11344033e-02f, 1.55413765e-02f, 5.82710542e-02f, 2.25657094e-02f,
  -2.08043262e-01f, -2.70297438e-01f, -3.86622660e-02f, 5.53622358e-02f, -9.22292545e-02f, -1.11172102e-01f, -2.69878685e-01f, 2.40169317e-02f, -1.41360553e-03f, -1.08101264e-01f,
  -7.22776577e-02f, 9.81506184e-02f, 2.33058289e-01f, 1.51381135e-01f, 1.17534861e-01f, -6.07899651e-02f, 3.68176252e-02f, 2.06975728e-01f, 2.47149602e-01f, 6.79135397e-02f,
  2.91024633e-02f, 8.76263306e-02f, -2.53050048e-02f, 1.51752964e-01f, -7.74919149e-03f, 1.57575056e-01f, 1.74102420e-03f, -6.09904416e-02f, -2.88420580e-02f, -6.20078295e-02f,
  1.47077978e-01f, -2.05661476e-01f, 5.12696207e-02f, -1.41421720e-01f, -3.11978664e-02f, 4.21369784e-02f, 5.96206598e-02f, -5.20767877e-03f, -6.56756163e-02f, 6.80660689e-03f,
  -8.23770389e-02f, 7.67876506e-02f, 9.55481157e-02f, 1.36681627e-02f, -5.45529164e-02f, -4.22805436e-02f, -9.92158651e-02f, 7.89401904e-02f, 2.22160891e-02f, -1.40743768e-02f,
  -2.86532063e-02f, -1.94972262e-01f, -1.99880954e-02f, 5.09697348e-02f, 7.49720633e-02f, 2.65102945e-02f, -9.27507430e-02f, 5.05170226e-02f, -8.81076753e-02f, -1.32483825e-01f,
  -4.16053049e-02f, 7.24060014e-02f, -5.75142913e-03f, -3.16472203e-02f, -7.08081052e-02f, 4.82680872e-02f, -4.47835326e-02f, -3.20844017e-02f, -6.26396434e-03f, -2.13254653e-02f,
  1.55894989e-02f, 8.62068776e-03f, -1.82425696e-02f, 2.35898700e-02f, 6.65282682e-02f, 1.57496836e-02f, 3.88929173e-02f, -3.22928242e-02f, 4.24614176e-02f, 3.82313877e-02f,
  -7.80895120e-03f, 4.91335019e-02f, -4.46779374e-03f, 1.58824380e-02f, -1.25699326e-01f, 7.30003510e-03f, -4.24159132e-02f, 3.44906673e-02f, -2.72691436e-02f, -2.19669342e-02f,
  1.37813479e-01f, -3.87179554e-02f, 4.16894220e-02f, 6.50045127e-02f, 4.31022719e-02f, 4.52883057e-02f, 2.78534871e-02f, -3.29678282e-02f, -1.13955466e-02f, 2.34029293e-02f,
  5.33816926e-02f, 3.95129733e-02f, -2.23044306e-02f, -2.49023959e-02f, 6.77118152e-02f, 7.07240030e-02f, -4.77356501e-02f, -8.96377861e-02f, 1.74767710e-02f, -1.50230490e-02f,
  1.05531830e-02f, -4.58838120e-02f, -6.35528788e-02f, -2.65344419e-02f, -1.83184426e-02f, -3.31436470e-02f, 6.10045306e-02f, -1.55735239e-02f, 2.07035579e-02f, -1.16347790e-01f,
  -4.37933616e-02f, -1.47375837e-01f, 5.48695796e-04f, -2.04010829e-02f, -1.77360907e-01f, -2.26058200e-01f, -2.07251653e-01f, -1.02879599e-01f, 1.71334704e-03f, -7.04904720e-02f,
  2.03727167e-02f, 3.19584832e-02f, -4.65052091e-02f, -8.34226534e-02f, -1.86103418e-01f, -1.05398677e-01f, -1.80446610e-01f, 2.26575248e-02f, 2.51959264e-02f, -2.35902332e-02f,
  -7.85349682e-02f, 1.81270409e-02f, -4.57182676e-02f, -1.77367311e-02f, 2.96011288e-03f, 9.90647525e-02f, 7.60442987e-02f, -3.41541320e-02f, -8.64410847e-02f, -6.65851980e-02f,
  -4.70465496e-02f, -7.36219287e-02f, -3.82176630e-04f, 9.99621395e-03f, -8.51557180e-02f, 1.06123276e-02f, -1.12600654e-01f, -3.91826853e-02f, 4.41358984e-03f, 6.74341097e-02f,
  5.41724786e-02f, -3.70181724e-02f, 4.32857908e-02f, 1.06970370e-01f, -1.26867639e-02f, 2.15175189e-02f, 1.00311689e-01f, 3.52768525e-02f, -4.40051360e-03f, 5.17768320e-03f,
  3.86650395e-03f, -2.66388040e-02f, 1.61960572e-02f, 6.93292990e-02f, -5.61706536e-02f, -7.16960207e-02f, 4.80893590e-02f, -1.61638651e-02f, 2.74591409e-02f, 1.02249302e-01f,
  2.16375403e-02f, 6.10738993e-02f, -1.54112773e-02f, 1.60414334e-02f, 5.49552143e-02f, -6.94115739e-03f, 8.99135023e-02f, -7.96457231e-02f, -4.56072651e-02f, 5.91242546e-03f,
  5.43173915e-03f, -1.69644058e-02f, 5.82010224e-02f, -6.03948766e-03f, -1.18488418e-02f, 3.63241732e-02f, -3.21941376e-02f, 3.55185219e-03f, 8.62558782e-02f, 9.85885505e-03f,
  -2.04898305e-02f, -5.31205488e-03f, 7.17335567e-02f, -6.06339574e-02f, -8.41172785e-02f, 8.12569857e-02f, -1.94900371e-02f, 1.79759897e-02f, 6.24138229e-02f, -6.74272552e-02f,
  2.06236299e-02f, -7.88978711e-02f, -9.68768075e-02f, 3.69160553e-03f, 1.59351006e-02f, -1.64461136e-02f, 4.29668985e-02f, -4.48517092e-02f, -3.97289917e-03f, -2.71690395e-02f,
  1.12508396e-02f, 1.96534693e-02f, -4.57814001e-02f, 6.82009682e-02f, -4.67992947e-02f, -1.69979390e-02f, -7.87191186e-03f, -7.00478405e-02f, 1.60177667e-02f, -7.27082090e-03f,
  -5.92805706e-02f, 3.89550179e-02f, -6.33526295e-02f, 2.77512502e-02f, -3.63556370e-02f, -2.63606627e-02f, 7.57518574e-04f, 6.91416673e-03f, -2.95030586e-02f, -3.96882333e-02f,
  2.08634019e-01f, -3.43577787e-02f, 7.48470798e-02f, -2.32919659e-02f, -9.26305354e-02f, 8.64957049e-02f, 2.98346192e-01f, 1.94559172e-01f, 7.99603164e-02f, 1.27449915e-01f,
  -5.43605424e-02f, -1.90833449e-01f, -7.88746253e-02f, -7.76492581e-02f, 1.09151483e-01f, 2.46412307e-01f, 1.91624060e-01f, 2.24550534e-03f, -1.30015629e-04f, 1.69088319e-02f,
  -9.62406322e-02f, -2.75925454e-02f, 4.01621796e-02f, 2.05183495e-02f, -1.22352928e-01f, -1.05559319e-01f, 1.44285876e-02f, -4.90654185e-02f, -1.35990009e-01f, 8.05311128e-02f,
  -1.77210301e-01f, 1.54375881e-01f, -1.69715583e-02f, -7.34960511e-02f, 2.56397855e-02f, 1.32351313e-02f, -4.23036376e-03f, 7.86072388e-02f, 1.36627005e-02f, 4.06795740e-02f,
  -1.20127290e-01f, 1.99654568e-02f, -8.19008723e-02f, 4.94491197e-02f, 2.21591163e-03f, 7.96687827e-02f, 2.10934151e-02f, -9.74396337e-03f, -7.23615987e-03f, -4.54447828e-02f,
  -9.69366208e-02f, -8.24688002e-03f, 8.79678950e-02f, -3.75808566e-03f, 1.19515732e-02f, -8.87227729e-02f, -7.22955330e-04f, 7.56272115e-03f, 6.26619309e-02f, -6.39149100e-02f,
  -2.16631033e-02f, 4.44273837e-02f, 2.82416642e-02f, -9.78617929e-03f, 4.24914546e-02f, -1.05316773e-01f, 6.26997976e-03f, -7.32184201e-02f, 2.05122866e-02f, 8.26807395e-02f,
  -5.14371842e-02f, 5.70831634e-02f, 7.04156980e-02f, 2.98772100e-02f, -5.71774170e-02f, 3.71352141e-03f, -1.63552500e-02f, -1.74382944e-02f, 3.15618608e-03f, -5.08150160e-02f,
  -9.52205993e-03f, -9.83629283e-03f, -7.72616640e-02f, 1.62861086e-02f, 5.46498001e-02f, -3.94901559e-02f, -8.93325135e-02f, 1.68786701e-02f, 2.60962802e-03f, 4.11441810e-02f,
  -3.49426642e-02f, 5.80217838e-02f, 1.69022232e-02f, 8.77484493e-03f, -5.24412468e-02f, -8.42010416e-03f, 3.64444219e-02f, -5.23008294e-02f, 3.30456756e-02f, -7.31009468e-02f,
  4.74551022e-02f, 3.16484682e-02f, -7.95219690e-02f, 1.50743378e-02f, -8.67121965e-02f, 4.92737219e-02f, -2.00998131e-03f, -4.83784452e-03f, 5.43497279e-02f, -5.61631843e-02f,
  8.31166580e-02f, -6.84752390e-02f, -2.36976612e-02f, 7.78675601e-02f, -8.93830433e-02f, 2.93402821e-02f, -1.53234750e-02f, -6.64804354e-02f, 3.72217372e-02f, 1.06813475e-01f,
  3.48753244e-01f, 2.57155269e-01f, 3.64059135e-02f, 6.03913814e-02f, 1.03372306e-01f, -5.80120541e-04f, 9.13291574e-02f, -5.53734004e-02f, -4.00115363e-02f, 1.78099766e-01f,
  9.05631036e-02f, -2.20245775e-02f, -1.70973524e-01f, -2.08936661e-01f, -1.39829576e-01f, 1.27410531e-01f, 1.33006379e-01f, -4.86902818e-02f, -1.81748331e-01f, -7.40408599e-02f,
  7.08283633e-02f, -2.56205071e-02f, -7.00789690e-02f, -1.21757284e-01f, 1.90450847e-02f, -1.20365940e-01f, 6.12648996e-03f, -1.35568902e-02f, -3.03494148e-02f, 4.89050820e-02f,
  2.29080506e-02f, 2.20800251e-01f, -7.24489316e-02f, -4.37194146e-02f, -3.60707641e-02f, 5.29998541e-02f, 7.81381726e-02f, 4.03334685e-02f, -2.70732362e-02f, -6.05996186e-03f,
  7.69651830e-02f, 3.30725312e-02f, -1.04502607e-02f, -2.23196251e-03f, 3.64456512e-02f, -1.23901619e-02f, -5.76905943e-02f, 8.42103362e-03f, 3.71554866e-02f, 3.99240591e-02f,
  1.41291311e-02f, 1.46244597e-02f, -1.91983581e-03f, -1.01920560e-01f, 1.05513316e-02f, -7.40357116e-02f, -4.83149886e-02f, -8.74260888e-02f, 2.85884105e-02f, 1.09945320e-01f,
  -6.77250233e-03f, -1.89855546e-02f, 3.54615971e-02f, 7.47043639e-02f, -4.96674143e-02f, 4.07951139e-02f, -1.99503023e-02f, 5.65007739e-02f, 5.69048859e-02f, -8.23103338e-02f,
  3.25455703e-02f, -2.65567247e-02f, -3.13813463e-02f, 5.98837733e-02f, -8.26654956e-02f, 3.50096077e-02f, -5.39519042e-02f, -1.30240498e-02f, -7.01845065e-03f, 1.99667690e-03f,
  -2.39777584e-02f, 1.65456738e-02f, 1.20467944e-02f, -3.62217873e-02f, -1.35604488e-02f, 2.41081994e-02f, 3.05440370e-02f, -2.47997027e-02f, 1.76436361e-03f, -3.79234105e-02f,
  8.46476629e-02f, -8.10441524e-02f, 7.47020170e-02f, 2.68376600e-02f, 3.14741358e-02f, 1.13631599e-02f, 5.04699675e-03f, -1.18220523e-02f, -5.46462787e-03f, -1.09720230e-02f,
  -2.85616275e-02f, -6.08784445e-02f, -4.44342159e-02f, 2.89353020e-02f, -4.53954637e-02f, 1.01624429e-01f, -2.53072847e-03f, -9.85642225e-02f, 3.68448682e-02f, -3.97712141e-02f,
  5.43207973e-02f, 5.07831126e-02f, -1.65126212e-02f, 7.78049901e-02f, -6.91907853e-02f, 5.76375760e-02f, 4.88619730e-02f, 5.23954965e-02f, -5.98278232e-02f, 1.54751450e-01f,
  1.32741882e-02f, 7.53402188e-02f, 1.06755577e-01f, -3.95840742e-02f, -4.95845359e-03f, 1.22378826e-01f, 2.77332693e-01f, -3.34293619e-02f, -1.39930040e-01f, -3.72484997e-02f,
  -5.85120358e-02f, -6.82751685e-02f, 6.35531470e-02f, -5.75918257e-02f, 8.47877115e-02f, 1.35269463e-01f, 7.83578213e-03f, 9.33715478e-02f, 2.32443660e-02f, 3.93209495e-02f,
  2.26740595e-02f, -4.24958020e-03f, 7.70586217e-03f, -9.63816866e-02f, -8.50858353e-03f, 1.11032287e-02f, -1.20594881e-01f, -8.29675794e-02f, 2.32651345e-02f, -8.24698508e-02f,
  9.33239833e-02f, 5.50795300e-03f, 8.59296247e-02f, 7.79303443e-03f, 5.36827222e-02f, -2.96918731e-02f, 9.73230302e-02f, -4.92480211e-02f, 9.97615159e-02f, 1.62793361e-02f,
  -6.74898699e-02f, -3.14956196e-02f, -2.82911249e-02f, -7.46757090e-02f, -2.64581554e-02f, -5.01414128e-02f, -6.39076456e-02f, -3.83721702e-02f, -5.93554117e-02f, -1.55934719e-02f,
  1.05617426e-01f, -3.78597118e-02f, 3.30201723e-03f, 1.06709167e-01f, -2.72092894e-02f, -4.37077805e-02f, 2.86311768e-02f, 1.01566000e-03f, -6.23450689e-02f, -1.99232325e-02f,
  8.27685893e-02f, -9.78517905e-02f, -2.58571263e-02f, 2.07202379e-02f, -4.50636931e-02f, 4.61233146e-02f, -6.91320002e-02f, -1.49495685e-02f, 8.18720087e-02f, -3.29945516e-03f,
  -2.87434738e-02f, -1.20542282e-02f, 5.40148802e-02f, 3.13779898e-03f, -3.82667258e-02f, -5.22774793e-02f, -3.22256833e-02f, 1.05728917e-02f, 1.68877412e-02f, -2.57744156e-02f,
  -8.81213099e-02f, 6.93942457e-02f, 1.61037948e-02f, -3.36894803e-02f, -7.25943642e-03f, 6.65846616e-02f, -2.11034846e-02f, -6.33132756e-02f, -1.24679534e-02f, -4.89489734e-02f,
  -9.50916037e-02f, 1.29456595e-01f, 8.07816982e-02f, 1.23201730e-02f, 2.39584427e-02f, -3.16074528e-02f, 4.96700592e-02f, 5.68307117e-02f, -4.98794466e-02f, 1.53838471e-02f,
  1.22410849e-01f, 7.06312060e-02f, 7.73554072e-02f, -3.64045873e-02f, 8.64085332e-02f, -2.12601922e-03f, 4.12951410e-02f, -4.77550887e-02f, 6.08254597e-02f, 8.77725706e-03f,
  -1.52493678e-02f, 1.11185759e-01f, 7.30109066e-02f, 1.01932824e-01f, 5.55907153e-02f, 9.64575708e-02f, 1.31057382e-01f, 1.38850482e-02f, 1.33574441e-01f, 9.74605531e-02f,
  5.90044200e-01f, -2.62569468e-02f, 9.09387395e-02f, 3.42736423e-01f, 3.99464875e-01f, 2.12072566e-01f, 1.51180461e-01f, 1.34133011e-01f, 1.83236495e-01f, 9.05141756e-02f,
  -6.03909418e-02f, 4.69126143e-02f, -9.39468481e-03f, -3.98728400e-02f, -8.57172385e-02f, -3.05514243e-02f, 1.60896242e-01f, 1.17171668e-01f, 2.70672441e-01f, 2.92085350e-01f,
  2.38571800e-02f, 2.71976709e-01f, 1.45790085e-01f, 1.37831360e-01f, 9.24997218e-03f, -3.03039551e-02f, 4.49816957e-02f, 6.32831305e-02f, 5.09658270e-03f, 1.59114435e-01f,
  -1.40430883e-01f, 2.46571153e-01f, -5.36118001e-02f, 8.34486559e-02f, 4.68720831e-02f, -9.14668888e-02f, 1.25210751e-02f, 2.79003885e-02f, 1.45695521e-03f, -7.06980601e-02f,
  1.21869277e-02f, -5.55292144e-02f, 8.08640271e-02f, -7.14447573e-02f, 3.79363224e-02f, 1.76717266e-02f, 6.88961521e-02f, 4.06512879e-02f, -8.05484653e-02f, -1.05462737e-01f,
  -7.26123378e-02f, 9.72214118e-02f, 4.22003493e-02f, -7.99948797e-02f, -1.00765660e-01f, 3.02616097e-02f, -1.35120554e-02f, 5.30658066e-02f, -3.14281620e-02f, 4.35764715e-02f,
  1.01642786e-02f, -9.10849497e-02f, -3.27532478e-02f, -4.65124752e-03f, -4.82297167e-02f, -1.62524860e-02f, 1.02531612e-02f, 1.62530709e-02f, -4.28172313e-02f, 5.74153028e-02f,
  -6.05244935e-02f, 7.52774552e-02f, -9.79298130e-02f, -4.16321978e-02f, -6.81886151e-02f, 1.21395528e-01f, 2.91165034e-03f, -6.29722774e-02f, -4.09946702e-02f, 1.46429669e-02f,
  7.83929974e-02f, -4.15158570e-02f, -1.45859784e-02f, -3.34270336e-02f, 1.37370937e-02f, 6.96900934e-02f, -1.39126973e-02f, 2.77778339e-02f, 5.39416894e-02f, 3.63744348e-02f,
  -1.27669387e-02f, 4.42626178e-02f, -3.35266590e-02f, -9.52140540e-02f, 4.34074774e-02f, -3.05349026e-02f, 4.09098621e-03f, -6.03776909e-02f, -2.00956613e-02f, -5.78954583e-03f,
  8.53450969e-02f, -2.74091167e-03f, -5.69505058e-02f, -1.18411127e-02f, 5.19773737e-02f, 6.20811880e-02f, -6.12621978e-02f, 2.43335264e-03f, -2.93330550e-02f, -1.13101758e-01f,
  -8.05858299e-02f, 6.61091357e-02f, 2.30276883e-02f, 1.58814322e-02f, -4.06393521e-02f, 4.55577783e-02f, -3.51569615e-02f, -1.89344236e-03f, -1.00340031e-01f, -1.10599831e-01f,
  -3.50631773e-01f, -6.29448593e-02f, 1.53496861e-01f, -2.52466589e-01f, -6.84382394e-02f, 1.13834843e-01f, -2.95951962e-02f, -6.07439391e-02f, -4.97073345e-02f, 3.59520391e-02f,
  1.50744379e-01f, 1.17579155e-01f, 5.71481697e-02f, 1.07489545e-02f, 4.42877486e-02f, 2.92379372e-02f, -1.83896720e-01f, -1.11198373e-01f, 8.72638971e-02f, 1.74054597e-02f,
  -4.15506363e-02f, -1.81036934e-01f, -1.80217952e-01f, -1.02410197e-01f, -4.34923060e-02f, 3.37917283e-02f, -9.49113537e-03f, -1.38057813e-01f, 7.43801519e-02f, -2.05684826e-01f,
  2.02435985e-01f, -8.44976828e-02f, 2.70974264e-02f, -3.88758145e-02f, -1.94425806e-02f, 4.77171578e-02f, 7.98356682e-02f, 3.78804877e-02f, 1.77615024e-02f, -1.63164977e-02f,
  4.31071408e-02f, 5.07361954e-03f, 7.58087337e-02f, 6.40793592e-02f, -1.14866987e-01f, -4.63647395e-02f, -8.82648602e-02f, -1.10188521e-01f, -8.38662386e-02f, 8.33795890e-02f,
  2.64797937e-02f, -8.87369458e-03f, -5.53732291e-02f, -3.93002704e-02f, 2.43911333e-02f, -3.17749828e-02f, -2.48917062e-02f, -3.74752609e-03f, 7.02890754e-02f, -1.42848656e-01f,
  1.22597842e-02f, 1.72161846e-03f, 4.84917723e-02f, -9.68665443e-03f, -5.98808564e-02f, 2.74027735e-02f, -9.00144316e-03f, 3.42874601e-02f, 5.50747151e-03f, -4.04657051e-02f,
  5.14625646e-02f, -1.45966914e-02f, -5.26513942e-02f, 5.69483871e-03f, -8.92333686e-02f, 3.26542780e-02f, -4.26035514e-03f, -1.65203325e-02f, -4.52261455e-02f, -2.07972098e-02f,
  2.72538494e-02f, -2.36438140e-02f, -1.00736059e-01f, 3.36021185e-02f, -4.25741859e-02f, -4.71522212e-02f, 5.44820949e-02f, 7.24438578e-02f, 2.04546545e-02f, 4.33956236e-02f,
  -7.41813481e-02f, 1.62894934e-01f, 2.14882921e-02f, -3.33734639e-02f, 3.36586451e-03f, 3.07941437e-02f, -1.52912159e-02f, 9.15821195e-02f, 8.91896710e-02f, 6.47007301e-02f,
  4.48892415e-02f, 6.05280027e-02f, -5.35423607e-02f, 5.76670952e-02f, -1.69025976e-02f, 7.80874025e-03f, -6.24671690e-02f, 2.20713355e-02f, 1.52867974e-03f, -8.25157166e-02f,
  4.25137160e-03f, -7.75152296e-02f, -7.76600614e-02f, 5.45972884e-02f, -7.44275078e-02f, -7.59498775e-02f, -2.78343614e-02f, 2.71256156e-02f, -6.29771873e-02f, -5.52971810e-02f,
  9.28245857e-02f, 1.04627304e-01f, -2.02313095e-01f, -1.98136389e-01f, 7.10918903e-02f, 1.90622672e-01f, 4.24068987e-01f, 2.54220098e-01f, 7.73450062e-02f, 7.40888249e-03f,
  -1.54798757e-02f, -2.82079335e-02f, -3.60630155e-02f, -7.81057775e-02f, 1.10870145e-01f, 9.33759846e-03f, -1.82946146e-01f, -1.97843000e-01f, 4.29066345e-02f, 1.79088786e-01f,
  1.00743935e-01f, -9.14292596e-03f, -1.27963331e-02f, 9.81810782e-03f, -1.61227882e-01f, -7.14362264e-02f, -7.20062256e-02f, -1.62849084e-01f, -5.80154397e-02f, -4.40553665e-01f,
  -2.74232090e-01f, 1.91116575e-02f, -5.58764227e-02f, -4.40412126e-02f, -9.91171449e-02f, 9.48453397e-02f, 6.72390684e-02f, -5.81677109e-02f, 1.17825484e-03f, -4.70358133e-02f,
  -1.32127464e-01f, -3.08336876e-02f, -1.76201314e-02f, -6.66105524e-02f, 6.72763437e-02f, 1.76446531e-02f, -8.02265927e-02f, -4.63623852e-02f, -4.17092033e-02f, 9.43077356e-02f,
  -3.18529233e-02f, -4.05127257e-02f, -2.43714396e-02f, 6.68209791e-02f, 7.32441470e-02f, -6.02560006e-02f, 4.01057536e-03f, 4.90469225e-02f, 7.54511775e-03f, -5.53117953e-02f,
  -7.95939285e-03f, -6.69659972e-02f, -1.14192395e-02f, -3.26306932e-02f, 9.22712090e-04f, -5.54863364e-04f, -1.91444624e-02f, -6.41218200e-02f, 3.61906271e-03f, 3.40123959e-02f,
  -9.30476934e-03f, 1.90914038e-03f, 2.36745644e-02f, 2.81605981e-02f, -2.04820409e-02f, -7.24640414e-02f, 4.83414009e-02f, 3.56455594e-02f, -1.89539716e-02f, 3.79391685e-02f,
  -4.44574729e-02f, -9.18233395e-02f, 1.70881897e-02f, 3.85089777e-03f, -9.64703262e-02f, -1.38206169e-01f, -1.58005394e-03f, 3.08733247e-02f, -3.87891047e-02f, 2.04507764e-02f,
  6.65350854e-02f, -6.51683658e-02f, -2.37743240e-02f, -2.99202884e-03f, -3.36133167e-02f, -1.82297714e-02f, -9.84917209e-02f, -2.27986816e-02f, -9.44133475e-02f, 9.13826227e-02f,
  8.20520967e-02f, 4.52154987e-02f, 2.07560752e-02f, -1.49076777e-02f, 9.74515378e-02f, -1.49168735e-02f, 1.04011819e-01f, -3.88249829e-02f, 5.96584082e-02f, 9.35775191e-02f,
  7.13670924e-02f, 2.23307371e-01f, 1.18146554e-01f, 1.86446995e-01f, 7.12943971e-02f, 6.41601533e-02f, 9.23466608e-02f, 3.68910134e-02f, 1.21729039e-01f, 2.85770595e-01f,
  2.79167354e-01f, 1.46618992e-01f, 3.94085236e-02f, 5.83249591e-02f, -2.46522263e-01f, -3.18959802e-01f, -4.07804221e-01f, -1.21446446e-01f, 9.26472023e-02f, -1.25075445e-01f,
  -1.80864990e-01f, 4.03957628e-02f, 2.86076404e-02f, 3.76364030e-02f, -6.24203645e-02f, -2.06793826e-02f, 7.77663738e-02f, 1.51034400e-01f, -7.49510527e-02f, -2.21917450e-01f,
  -7.69493580e-02f, 6.29723966e-02f, 1.54314831e-01f, 4.08639796e-02f, 1.78053584e-02f, -1.24624081e-01f, -1.42997950e-02f, -1.73575375e-02f, -1.29892066e-01f, 1.51960045e-01f,
  -1.18302703e-01f, 2.28459999e-01f, -1.59187336e-02f, -2.38680169e-02f, 1.92440022e-02f, 1.03115000e-01f, -1.01695508e-01f, 4.74625379e-02f, 6.57743812e-02f, 7.45267347e-02f,
  5.85117117e-02f, -2.44545797e-03f, -7.04751024e-03f, -5.71800396e-02f, -1.10941129e-02f, 7.94980228e-02f, 2.68537067e-02f, 1.13900848e-01f, 9.02571753e-02f, 2.24398896e-02f,
  9.92054958e-03f, -5.00082076e-02f, 1.38426237e-02f, 1.10876942e-02f, 2.05878131e-02f, -3.01729166e-03f, 3.45177390e-03f, 1.26715258e-01f, 6.07893839e-02f, -3.55859399e-02f,
  3.05501022e-03f, -1.27885053e-02f, -2.71915589e-02f, -8.33635554e-02f, -1.99277028e-02f, -8.65516514e-02f, -2.87708882e-02f, 5.84867923e-03f, 2.89157405e-02f, -1.92186385e-02f,
  3.65251396e-03f, 8.88979156e-03f, -3.23402286e-02f, 1.80368964e-02f, 2.18514726e-02f, 2.92373803e-02f, -2.84433365e-03f, -2.38651736e-03f, 9.74379107e-03f, 1.15359470e-01f,
  6.93289842e-03f, 3.35865398e-03f, -2.27237865e-02f, -5.80845959e-02f, 3.91174518e-02f, 1.36918190e-03f, 2.05564853e-02f, -2.07620524e-02f, -1.38826659e-02f, 8.05923417e-02f,
  1.94813572e-02f, 6.79832324e-02f, -4.04030718e-02f, -9.63831600e-03f, -2.44260766e-02f, 3.78219858e-02f, -3.52852866e-02f, 4.43465561e-02f, 1.15854211e-01f, -2.67878007e-02f,
  -1.25882894e-01f, 4.03244495e-02f, 4.98627089e-02f, 1.65678095e-02f, -4.95150313e-03f, -1.83629338e-02f, -8.09572544e-03f, -3.35187837e-02f, 4.82001342e-02f, -7.08163902e-03f,
  4.99551706e-02f, -4.85036522e-02f, -9.65541005e-02f, -9.03231427e-02f, 5.23152538e-02f, -7.48404860e-02f, -1.46685287e-01f, -1.06697410e-01f, -9.11954939e-02f, -2.02751458e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.29683316e-02f, 1.90945908e-01f, -5.84388413e-02f, 8.34530666e-02f, 2.37714827e-01f, 2.29873002e-01f, 2.51324952e-01f, 1.35291100e-01f, 7.02196509e-02f, 5.12269288e-02f,
  1.95810303e-01f, 9.60464627e-02f, -3.00705992e-03f, 9.04434547e-02f, -4.73434106e-03f, 9.62985456e-02f, -7.79442936e-02f, 5.23762638e-03f, -7.10739866e-02f, 1.46629125e-01f,
  3.98971476e-02f, 5.33161759e-02f, -5.29748537e-02f, -8.18551853e-02f, -3.60880159e-02f, 2.36963071e-02f, 5.18169850e-02f, 4.86497842e-02f, 2.31818836e-02f, -9.97736901e-02f,
  3.96597236e-02f, 6.24611527e-02f, -7.31259584e-02f, 9.66728181e-02f, 7.78313875e-02f, -5.04788607e-02f, -2.31996942e-02f, -7.53463730e-02f, 2.75219046e-02f, -7.42281787e-03f,
  7.45824650e-02f, -4.49960604e-02f, -3.41289155e-02f, -1.39212534e-02f, -6.22697510e-02f, 2.64350418e-02f, 1.55180460e-02f, -9.88500193e-02f, -7.62806907e-02f, -3.01844347e-02f,
  4.99846749e-02f, 9.28193405e-02f, 1.18820630e-01f, 3.45097594e-02f, -2.31916867e-02f, -4.56226878e-02f, 8.45908001e-02f, 2.22489722e-02f, 1.71590149e-02f, -1.61969155e-01f,
  -6.67110309e-02f, 5.61963022e-02f, 6.23608232e-02f, -9.17597413e-02f, 4.93711978e-02f, -2.83556618e-02f, -5.60104325e-02f, 4.69728671e-02f, -1.31646814e-02f, -5.58466092e-02f,
  -1.52533101e-02f, 3.16558592e-02f, -8.89058411e-02f, 2.46512834e-02f, 3.28115895e-02f, 7.21740276e-02f, -4.51158658e-02f, 1.47149237e-02f, -2.06790157e-02f, -1.92041639e-02f,
  3.12821642e-02f, 5.53616509e-02f, -6.89937398e-02f, -3.32215354e-02f, -1.93799436e-02f, 1.35473441e-02f, -6.58969954e-02f, 6.48417994e-02f, -8.05896893e-03f, 1.09913154e-02f,
  2.74271034e-02f, 2.12576598e-01f, -4.16941419e-02f, -3.28964442e-02f, -1.13293706e-02f, -2.86555421e-02f, -2.04195101e-02f, -2.66477764e-02f, 6.97765723e-02f, -2.19971780e-02f,
  9.15296376e-02f, -5.22478037e-02f, 1.20438695e-01f, -4.83171083e-02f, -8.76499414e-02f, 3.35374288e-02f, -6.07011206e-02f, -7.14381859e-02f, 1.31651131e-03f, -1.17615759e-01f,
  -9.71647948e-02f, -1.00263879e-01f, 2.31841765e-02f, -7.84684420e-02f, -4.05664071e-02f, 5.99769317e-02f, -9.09422562e-02f, 3.22679547e-03f, -4.74947728e-02f, -1.67172953e-01f,
  -3.34229544e-02f, 8.51326883e-02f, -6.93121478e-02f, 4.86600362e-02f, -4.36316915e-02f, 3.66969220e-02f, -1.50758179e-03f, 1.16449393e-01f, -8.49910453e-02f, -4.45918329e-02f,
  8.44033137e-02f, 4.81331348e-02f, -4.58563156e-02f, -6.73742667e-02f, -4.96110544e-02f, -6.38723653e-03f, -9.22476500e-02f, -5.96848428e-02f, -5.16505800e-02f, -3.84762846e-02f,
  -1.00722246e-01f, -8.89365003e-02f, 1.61557682e-02f, -2.86320671e-02f, -7.18055964e-02f, -6.34559914e-02f, -5.38037792e-02f, 3.77877541e-02f, -3.83698158e-02f, -6.60136044e-02f,
  -1.20586574e-01f, 1.12350486e-01f, 1.73831899e-02f, -7.72075057e-02f, 8.68817568e-02f, -8.21338445e-02f, -5.38199581e-02f, 5.33356108e-02f, 3.93691622e-02f, -5.52329794e-02f,
  4.92473654e-02f, 6.23501316e-02f, 4.50733975e-02f, 5.29239811e-02f, -5.94461747e-02f, 5.40478304e-02f, -1.89511515e-02f, -4.65365574e-02f, 2.76201144e-02f, 6.39591217e-02f,
  5.35953604e-02f, -5.36405183e-02f, 4.88512143e-02f, 6.80512637e-02f, 5.36865881e-03f, -3.84680368e-02f, -4.71717268e-02f, 4.26446237e-02f, 4.60991077e-02f, 8.80834386e-02f,
  -1.79679953e-02f, 8.99244547e-02f, -3.84549722e-02f, -9.15458947e-02f, 1.47158857e-02f, 6.37467802e-02f, -3.18585634e-02f, -2.03788932e-02f, 4.69348431e-02f, 8.24138671e-02f,
  -5.29872179e-02f, -6.15726747e-02f, -4.22643945e-02f, 9.38935429e-02f, -1.21199759e-02f, -2.40570493e-02f, 6.25950396e-02f, 3.19961901e-03f, 7.92268813e-02f, 1.69633813e-02f,
  -6.68770820e-02f, -5.83512299e-02f, -3.82658318e-02f, -7.35960007e-02f, -5.18584973e-04f, 5.33448420e-02f, 7.58370524e-03f, -5.24266176e-02f, 2.81360187e-02f, -2.19559520e-02f,
  -1.39027849e-01f, 1.40212942e-02f, -6.98111504e-02f, -6.10896945e-02f, 1.55571317e-02f, -8.15559551e-02f, 4.93030436e-02f, 6.80196509e-02f, -1.02792289e-02f, -3.83050554e-02f,
  6.28032722e-03f, -7.55324513e-02f, 7.44250230e-03f, -3.93919200e-02f, -8.14222768e-02f, 7.88890105e-03f, -5.11596724e-02f, -8.19946602e-02f, -9.43230167e-02f, -1.58678915e-03f,
  -8.50346312e-02f, 1.24047520e-02f, 5.11458218e-02f, 1.60139836e-02f, -3.85541469e-02f, -2.47422457e-02f, 4.68143634e-02f, -1.34427575e-02f, 4.47861403e-02f, 7.11353868e-02f,
  -6.87546283e-02f, 2.07638815e-01f, 3.40022109e-02f, 5.38270846e-02f, 2.86031440e-02f, -3.44517007e-02f, 9.22116544e-03f, 4.73210476e-02f, 1.49647882e-02f, -5.79278283e-02f,
  -1.39341265e-01f, -1.40598370e-02f, 4.64946553e-02f, 1.08253971e-01f, 1.46610409e-01f, 1.78088591e-01f, 5.35954535e-02f, 8.64227191e-02f, 1.61905847e-02f, 7.27640241e-02f,
  1.29034936e-01f, 1.67897937e-03f, -3.25531028e-02f, 3.80762182e-02f, 6.21695593e-02f, -1.87670793e-02f, -2.54908223e-02f, 3.28773148e-02f, 1.55865783e-02f, 2.67090410e-01f,
  1.98205467e-02f, 2.66464315e-02f, -1.06834084e-01f, 8.00039694e-02f, 2.37977803e-02f, 3.17202769e-02f, 7.58710504e-02f, 6.50509596e-02f, -6.54379502e-02f, 5.86262457e-02f,
  -4.14686464e-03f, 1.03101097e-02f, 1.36420593e-01f, 9.29998532e-02f, -4.90577146e-02f, -1.31290620e-02f, 7.67329633e-02f, 2.38695592e-02f, 1.02265306e-01f, -3.08397673e-02f,
  1.26709267e-02f, -2.61942390e-02f, -1.50009077e-02f, -9.65483710e-02f, 7.48660266e-02f, -7.01285899e-02f, 2.32351688e-03f, 2.74417009e-02f, -4.52995524e-02f, 5.95736429e-02f,
  -7.76458234e-02f, 8.04424435e-02f, -2.39905026e-02f, -4.99837520e-03f, -6.80330917e-02f, 5.98772578e-02f, -8.76892582e-02f, 2.28024386e-02f, -5.08204894e-03f, 8.52863640e-02f,
  -7.30186999e-02f, -2.14556381e-02f, -5.73820546e-02f, -4.43364494e-02f, -1.11958660e-01f, -2.91231573e-02f, 7.46492967e-02f, 1.30347107e-02f, -1.00761699e-02f, -4.58891392e-02f,
  4.67689894e-02f, 2.93540722e-03f, 3.34753618e-02f, 1.11747816e-01f, -6.99069072e-03f, -3.39305662e-02f, -1.83616616e-02f, -3.24968100e-02f, -3.30128111e-02f, 2.07515266e-02f,
  1.24606574e-02f, -2.05354229e-01f, -8.36502388e-02f, 8.09286982e-02f, -9.01254453e-03f, 4.20207568e-02f, -2.37798542e-02f, 2.30109897e-02f, 4.93659452e-02f, 6.01628572e-02f,
  -3.05085797e-02f, 8.14097300e-02f, 3.66696119e-02f, -1.13088787e-02f, 6.40668795e-02f, 3.23124751e-02f, -2.35482510e-02f, 5.80831803e-02f, -7.77578428e-02f, -5.55296429e-02f,
  -3.42300497e-02f, -5.53507693e-02f, -1.89313188e-01f, -1.16586529e-01f, -1.12634443e-01f, -1.14807375e-01f, -5.08588217e-02f, -6.81370273e-02f, -8.20093751e-02f, -1.09349318e-01f,
  -1.02906220e-01f, 2.19485443e-02f, -6.39505358e-03f, 8.02557170e-02f, 3.16879041e-02f, -2.71747336e-02f, 7.69177824e-02f, 7.91413337e-02f, 1.11399420e-01f, 7.16329664e-02f,
  -7.68308714e-02f, 3.81229818e-02f, 1.88350827e-02f, -2.27911510e-02f, 7.34721497e-02f, -3.32352519e-02f, 6.23567514e-02f, 1.15217872e-01f, 6.98858723e-02f, -3.55829410e-02f,
  7.86306709e-02f, -6.33752868e-02f, 7.84451887e-02f, 6.32681251e-02f, -4.82674688e-02f, 4.89129312e-02f, 1.38146495e-02f, 4.54238728e-02f, -1.19645242e-02f, 2.28396393e-02f,
  -5.88625632e-02f, 4.04210687e-02f, -2.13831328e-02f, -7.37134367e-02f, 9.98960715e-03f, -1.92421563e-02f, 8.73955861e-02f, -7.17192814e-02f, -1.69642698e-02f, 3.31881121e-02f,
  -6.91077709e-02f, 2.58830916e-02f, 1.66064631e-02f, -3.84085067e-02f, -7.09864050e-02f, -1.74725486e-03f, 5.28415889e-02f, 3.86875346e-02f, -3.89979519e-02f, -6.47892058e-02f,
  -3.07534914e-02f, 4.72460911e-02f, -9.21543837e-02f, 6.89522251e-02f, -4.97876527e-03f, -3.87985056e-04f, -1.75454002e-02f, 9.54742879e-02f, 6.56566769e-02f, -4.86488156e-02f,
  7.63237849e-02f, 4.43248972e-02f, -2.18549464e-03f, -5.38342632e-02f, -1.68793811e-03f, 4.43172157e-02f, -5.04295155e-02f, -1.00454710e-01f, 6.61655366e-02f, -2.20790599e-02f,
  -6.21037744e-02f, -8.54393244e-02f, 1.28400596e-02f, -1.14540584e-01f, 5.67373633e-02f, 8.10681954e-02f, -5.40689081e-02f, -9.39858928e-02f, 4.07465622e-02f, 1.32009052e-02f,
  -9.27632302e-02f, 7.25596324e-02f, -4.32095043e-02f, 8.44090506e-02f, -4.65996154e-02f, -8.72432068e-03f, 4.04599160e-02f, 6.71839789e-02f, -5.56232035e-02f, 4.02328849e-04f,
  -4.01233882e-02f, -6.40321970e-02f, 1.07779674e-01f, 5.97774098e-03f, 6.28795754e-03f, 5.27326837e-02f, -6.48424961e-03f, -8.08710232e-02f, 1.51336631e-02f, 5.08500868e-03f,
  4.27895188e-02f, -3.36244665e-02f, 6.05802611e-02f, 5.88989332e-02f, -4.07180227e-02f, -7.46770501e-02f, 1.84477046e-02f, -2.86874082e-03f, 9.90460217e-02f, -5.27291596e-02f,
  5.89009561e-02f, 2.92366464e-02f, -7.70912692e-02f, 3.73221450e-02f, 4.19678027e-03f, 2.11016573e-02f, 1.26977579e-03f, 2.35239766e-03f, -2.37241238e-02f, 1.62170902e-02f,
  -1.65221110e-01f, 1.28743583e-02f, -8.44705403e-02f, -1.31147400e-01f, -3.32208388e-02f, 2.01685317e-02f, -6.02003895e-02f, 8.34519416e-02f, -1.16786532e-01f, -1.06203161e-01f,
  -2.94461064e-02f, 8.11216161e-02f, -8.12100694e-02f, -4.51175235e-02f, 1.01284027e-01f, -4.92040366e-02f, -6.40366003e-02f, -2.94164661e-02f, 8.65885231e-04f, 1.50746733e-01f,
  7.75819644e-02f, 4.08247672e-02f, -6.32308573e-02f, -5.18391356e-02f, 5.39801419e-02f, 8.41801055e-03f, -1.45424515e-01f, -1.88105851e-02f, 2.36275308e-02f, -8.13010857e-02f,
  -4.32168506e-02f, -9.35138576e-03f, 7.05628097e-02f, 5.95427379e-02f, -9.56965163e-02f, -3.03565226e-02f, 6.22830763e-02f, 2.23225206e-02f, -7.64030367e-02f, 6.40373603e-02f,
  -9.29775462e-02f, 8.90793353e-02f, -6.96363375e-02f, 8.49545449e-02f, 3.44136469e-02f, 1.03912637e-01f, -4.55398783e-02f, 4.42171879e-02f, -4.49994020e-02f, -1.59957595e-02f,
  -8.53359979e-03f, -6.94532767e-02f, 3.02156769e-02f, -4.56178747e-02f, -4.82212044e-02f, 2.66863257e-02f, -4.26813774e-02f, -6.88378587e-02f, -2.22572032e-02f, -9.58042517e-02f,
  -6.24153875e-02f, 2.00205613e-02f, 4.42443565e-02f, -4.08438779e-02f, 5.39230630e-02f, -3.51772979e-02f, 7.04614073e-02f, 1.07877187e-01f, 3.03776152e-02f, -4.64358665e-02f,
  4.41228338e-02f, 1.99984275e-02f, 1.00554358e-02f, -1.04490586e-03f, -4.13421802e-02f, -6.29676729e-02f, -1.20019987e-02f, 1.49053046e-02f, -3.90412845e-02f, 1.17670130e-02f,
  -4.88703996e-02f, -1.05460370e-02f, -8.67882743e-02f, 5.95889948e-02f, -1.04127660e-01f, 6.43989956e-03f, -2.07425561e-02f, -4.82272133e-02f, -3.77955521e-03f, 4.95086191e-03f,
  8.71412233e-02f, -8.13402459e-02f, -9.60222632e-02f, 4.57627699e-02f, -7.39910826e-02f, -4.68227006e-02f, -5.29224202e-02f, -3.25434208e-02f, 2.80129520e-04f, -1.08090527e-02f,
  -1.13622136e-02f, -1.22336103e-02f, 3.25104482e-02f, -1.00152194e-02f, -4.42034006e-02f, 3.65389995e-02f, 2.31208373e-03f, 3.91750745e-02f, 5.90560809e-02f, -6.07903302e-02f,
  2.48631332e-02f, 1.56316645e-02f, 3.81621607e-02f, -5.37248775e-02f, -5.56809045e-02f, 3.55161615e-02f, 7.52866641e-02f, 3.93205807e-02f, 1.04199953e-01f, -1.93776395e-02f,
  1.54057413e-03f, -1.17532322e-02f, -8.53260532e-02f, 1.60433706e-02f, 5.95285743e-02f, 9.40152481e-02f, 4.85828780e-02f, -2.65918206e-02f, 7.25859962e-03f, -7.45135397e-02f,
  9.43777710e-02f, -6.56003356e-02f, -8.63853693e-02f, 4.87015583e-02f, 5.63575737e-02f, -3.14844796e-03f, -5.80578335e-02f, 2.34497711e-02f, -1.19836060e-02f, 2.73136757e-02f,
  5.10821193e-02f, -5.07212393e-02f, -1.12961628e-01f, -8.29559341e-02f, 1.94648933e-02f, -9.92792100e-02f, -1.25734046e-01f, -6.81407452e-02f, -1.07578933e-01f, -1.81203917e-01f,
  -8.38660076e-02f, 1.19941518e-01f, -6.56909421e-02f, -7.40828291e-02f, -8.18242654e-02f, -1.52032841e-02f, -6.34609014e-02f, -8.15341994e-02f, -8.41998216e-03f, 6.52874559e-02f,
  -4.08572480e-02f, 1.20701955e-03f, -8.56660083e-02f, -6.43626377e-02f, -8.90433439e-04f, -7.98900872e-02f, -4.52186391e-02f, -2.39156019e-02f, 8.41959864e-02f, 3.08032800e-02f,
  -2.05490598e-03f, 7.78306648e-02f, -1.21164732e-02f, -3.74022573e-02f, -2.54413690e-02f, -8.66401121e-02f, 3.12916450e-02f, -1.01816924e-02f, -5.01318201e-02f, -8.71188194e-02f,
  8.48746002e-02f, 7.49118552e-02f, 9.51600075e-03f, -6.83965087e-02f, 8.34261626e-03f, -3.88893001e-02f, -3.56539860e-02f, -6.42934442e-03f, 3.32852900e-02f, 8.42253305e-03f,
  -3.51527818e-02f, -2.06091739e-02f, -1.49620846e-02f, -3.68276276e-02f, 7.92693626e-03f, 9.18026492e-02f, 8.70448351e-02f, -6.84264749e-02f, 7.01124817e-02f, 7.73946494e-02f,
  4.07124385e-02f, 6.89838454e-02f, -6.22766800e-02f, 4.01694924e-02f, 5.69304153e-02f, -5.61887361e-02f, 1.13293827e-02f, -5.43790578e-04f, 5.28335236e-02f, -5.04582981e-03f,
  -1.18787840e-01f, -4.92089130e-02f, 7.70207122e-02f, -2.37501319e-02f, 5.96440136e-02f, 3.37892175e-02f, 8.33117291e-02f, 2.24614721e-02f, -3.03957872e-02f, -4.14053388e-02f,
  -4.47500572e-02f, -3.71775893e-03f, 5.90181677e-03f, -7.67255872e-02f, 2.19489634e-02f, 2.03120783e-02f, 3.60857882e-02f, -5.35020493e-02f, 3.77371870e-02f, -6.16222881e-02f,
  6.31569847e-02f, 6.93680793e-02f, -1.55793410e-02f, 5.81230922e-03f, 1.04123969e-02f, -7.37477392e-02f, -6.21184222e-02f, -4.60996963e-02f, -7.69809708e-02f, -6.48488328e-02f,
  1.74707904e-01f, -1.00561619e-01f, 2.13658996e-02f, 1.57304570e-01f, 6.72924668e-02f, 7.56513281e-03f, -5.21077663e-02f, 8.69533978e-03f, 1.41798602e-02f, 5.97099587e-02f,
  8.95746723e-02f, 1.30530894e-01f, 1.37116298e-01f, 1.32565480e-02f, -2.98314206e-02f, -6.46329625e-03f, -8.33009332e-02f, -3.44916470e-02f, 8.69159177e-02f, -3.61971743e-02f,
  5.58073148e-02f, 3.11842635e-02f, -9.21440497e-02f, 2.94143613e-02f, -9.52550098e-02f, -2.39233468e-02f, 3.85202430e-02f, -1.36253610e-01f, -6.81942329e-02f, -7.10736141e-02f,
  -1.29330516e-01f, 1.20264225e-01f, 1.24875918e-01f, 4.39428911e-02f, -1.35972183e-02f, -7.62020126e-02f, 7.01879635e-02f, -5.25594726e-02f, -1.17240269e-02f, -2.96707209e-02f,
  4.41654660e-02f, -2.03633253e-02f, -6.36767149e-02f, -7.05711246e-02f, 3.77564505e-02f, 7.79269934e-02f, -2.02035177e-02f, 2.19860841e-02f, 8.37995857e-02f, 3.92537899e-02f,
  3.78013141e-02f, 7.78274834e-02f, -1.65669937e-02f, -2.83281729e-02f, 1.31458715e-01f, 1.36544243e-01f, 6.02879152e-02f, 3.56345694e-03f, 9.43720117e-02f, -6.56500310e-02f,
  -6.68877065e-02f, 1.16868978e-02f, -7.05886856e-02f, 9.91137046e-03f, -4.41263393e-02f, 2.16436666e-02f, 8.53563100e-02f, 3.54107469e-02f, -7.25105554e-02f, -1.13706574e-01f,
  -4.41440344e-02f, 8.72484371e-02f, 7.55553916e-02f, -2.18894631e-02f, -1.25517156e-02f, -7.62391416e-03f, 1.47665404e-02f, -5.32526635e-02f, 4.01104940e-03f, -1.24855310e-01f,
  -3.25145796e-02f, -6.54855147e-02f, -8.39086473e-02f, 6.44755810e-02f, 4.90228347e-02f, 4.85231690e-02f, 6.94484115e-02f, 3.67968790e-02f, 4.39025126e-02f, -9.92252976e-02f,
  -1.53758854e-01f, 1.98593482e-01f, -4.11513373e-02f, 6.44222200e-02f, -8.56199861e-02f, 4.23458591e-02f, -5.30896783e-02f, -8.98554474e-02f, 1.03378203e-02f, -6.28817976e-02f,
  -8.78042877e-02f, 4.90413085e-02f, 5.73810749e-02f, -1.03679448e-01f, 4.29849923e-02f, 2.75424980e-02f, -7.68163428e-02f, 1.11746162e-01f, -8.76128748e-02f, -3.25880223e-03f,
  -1.12530172e-01f, 5.67560531e-02f, 1.81344062e-01f, 4.31260578e-02f, 7.15440288e-02f, 1.30478710e-01f, -9.71052200e-02f, -3.12818028e-02f, 2.40038079e-03f, 5.33727519e-02f,
  -3.28360856e-01f, -1.06012868e-03f, -1.77119430e-02f, -1.60895422e-01f, 1.31702676e-01f, 1.39932632e-01f, 1.42547071e-01f, -5.23504466e-02f, -8.58300626e-02f, 1.12838328e-01f,
  9.66868252e-02f, -2.40840055e-02f, 5.38459164e-04f, 7.62605749e-04f, -9.21315625e-02f, -7.86756799e-02f, -8.47473592e-02f, -2.47595385e-01f, -1.35057524e-01f, 6.83613941e-02f,
  3.61505300e-02f, -1.58807322e-01f, -2.37515539e-01f, -5.68357371e-02f, 1.35190319e-02f, -3.18834148e-02f, 1.34844482e-02f, -8.44796896e-02f, 1.97511330e-01f, 3.66781279e-02f,
  2.10694782e-03f, 8.29042271e-02f, 4.66716550e-02f, 2.33724732e-02f, 8.52661133e-02f, -9.96399447e-02f, 4.24429700e-02f, -2.84395907e-02f, 1.57089774e-02f, -2.38409024e-02f,
  1.47885326e-02f, 1.01552270e-01f, 4.71352711e-02f, -5.25418343e-03f, -7.19666928e-02f, -1.07043535e-01f, -5.93914315e-02f, -1.48061275e-01f, -1.26249731e-01f, -5.17574837e-03f,
  2.61261258e-02f, 1.71818584e-02f, -1.20861359e-01f, -1.24735832e-01f, -1.23595104e-01f, -2.01582946e-02f, -3.98639888e-02f, 1.47622880e-02f, -1.45131707e-01f, -1.81976110e-01f,
  4.60315384e-02f, 1.79470871e-02f, 1.74191743e-02f, -7.20538497e-02f, -3.13514611e-03f, 3.70702296e-02f, -1.95565931e-02f, 1.33320186e-02f, -3.32171144e-03f, -5.41635156e-02f,
  5.47510795e-02f, 1.00590065e-01f, -5.27135991e-02f, -5.60832694e-02f, -6.00500666e-02f, 1.28564546e-02f, 9.76896808e-02f, -9.65951607e-02f, -5.88508658e-02f, -5.03505059e-02f,
  -1.62680428e-02f, -4.62864079e-02f, 4.31219526e-02f, -2.42347103e-02f, 9.74755734e-03f, -5.68579361e-02f, -5.57865277e-02f, 1.92553978e-02f, -2.99657639e-02f, -4.64526005e-02f,
  -3.60145241e-01f, -1.88247096e-02f, 9.25200954e-02f, -5.65891154e-02f, 4.12608795e-02f, -3.08919363e-02f, -2.34930217e-02f, -3.50255519e-02f, 1.21906422e-01f, -4.58922945e-02f,
  1.79665498e-02f, -1.09044731e-01f, -7.81111643e-02f, -6.93344325e-02f, -7.10054208e-03f, -1.13252744e-01f, -1.08882366e-02f, -5.00057377e-02f, -3.80239747e-02f, -3.24597508e-02f,
  -1.36677381e-02f, -1.81587800e-01f, -2.02307254e-01f, -5.84595911e-02f, 1.91746582e-03f, -9.53004509e-02f, -1.10952660e-01f, -3.81105691e-02f, -1.43346205e-01f, -2.28553832e-01f,
  -2.07403198e-01f, -9.96753275e-02f, -5.56684751e-03f, 1.21370293e-01f, 1.24794699e-01f, 2.02426225e-01f, 1.74497470e-01f, 1.06107958e-01f, 4.80935583e-03f, 1.36925846e-01f,
  6.57448545e-02f, 2.01073423e-01f, 1.81513861e-01f, 8.64288509e-02f, 7.19351768e-02f, 1.74572423e-01f, 7.98221827e-02f, 1.51855741e-02f, 8.56082439e-02f, 1.80869605e-02f,
  1.12339936e-01f, -3.51247899e-02f, -1.30163878e-01f, 2.93035409e-03f, 6.97691068e-02f, 3.82360816e-02f, -1.94436908e-02f, -8.33389908e-02f, 6.50337562e-02f, 4.58228104e-02f,
  -5.82266040e-02f, 7.41815938e-06f, 8.77716169e-02f, 2.46423744e-02f, -6.80088252e-02f, -2.11363509e-02f, -8.05319846e-02f, -4.46190685e-02f, -8.54567289e-02f, -3.59102129e-03f,
  1.57833435e-02f, 1.41714858e-02f, 1.27579574e-03f, 2.33068280e-02f, -8.16950798e-02f, -7.13726059e-02f, -1.04313433e-01f, -6.17823489e-02f, 9.06086043e-02f, -7.16650486e-02f,
  -2.94527388e-03f, 5.71731478e-02f, -6.27371669e-02f, 6.73497841e-02f, 3.33512425e-02f, 9.86752212e-02f, 2.53938343e-02f, -8.53105113e-02f, -7.26677626e-02f, -1.49679378e-01f,
  -3.52368392e-02f, -2.97729466e-02f, 6.85189292e-02f, -7.24889487e-02f, -6.35660440e-02f, 5.40014030e-03f, 2.51081660e-02f, 8.31833556e-02f, 4.75092605e-02f, -3.49444002e-02f,
  -3.03485468e-02f, -3.79225425e-02f, 4.80562076e-02f, -8.30590352e-03f, -6.70435429e-02f, -2.03021504e-02f, 4.87221852e-02f, 2.97317114e-02f, 4.52693598e-03f, -1.21119227e-02f,
  6.25235513e-02f, -2.66501121e-02f, -5.36647514e-02f, -7.55077749e-02f, 8.71794969e-02f, -8.33751354e-03f, 6.97619468e-02f, -2.56558433e-02f, -4.36442047e-02f, 8.99295695e-03f,
  -4.76121117e-04f, 1.38545603e-01f, -4.25799517e-03f, -6.99873269e-02f, 8.20671842e-02f, -6.20550215e-02f, -5.67238070e-02f, -2.46515442e-02f, 4.66090217e-02f, 8.29289854e-03f,
  -6.84967488e-02f, -1.99304093e-02f, 1.36832912e-02f, -9.89402756e-02f, 1.63340494e-02f, 3.13870125e-02f, -2.36688666e-02f, -1.55549834e-03f, 8.62458274e-02f, -9.21631139e-03f,
  4.97601889e-02f, 5.57248108e-02f, -2.88684275e-02f, 1.24280415e-02f, 9.76922438e-02f, 1.10259555e-01f, -1.25067309e-01f, -2.51573585e-02f, 3.79590616e-02f, -2.54285764e-02f,
  -2.77604610e-02f, -5.41762263e-02f, -5.86012788e-02f, 1.60274003e-02f, -8.65988508e-02f, 2.88315285e-02f, -9.98525694e-02f, 3.24917845e-02f, -4.37276512e-02f, 2.50032246e-02f,
  -5.95242418e-02f, -1.02806807e-01f, -4.32220176e-02f, 1.53816611e-04f, 3.38549018e-02f, 5.01942262e-02f, -6.84695914e-02f, -1.47170376e-03f, 4.88731824e-02f, 3.50045227e-02f,
  -8.97377729e-02f, 1.05508417e-02f, -7.41720870e-02f, 2.61551887e-02f, -5.13459630e-02f, 4.27512117e-02f, -1.79235637e-02f, 6.19690418e-02f, 2.93167382e-02f, 5.74404858e-02f,
  -4.20856923e-02f, 5.55538163e-02f, -1.55637478e-02f, 1.05511151e-01f, 7.21384957e-02f, 1.10183954e-01f, 8.41293111e-02f, -5.42643219e-02f, -4.46771309e-02f, -4.71806452e-02f,
  4.79645692e-02f, 8.04593638e-02f, -7.01459721e-02f, 2.72601694e-02f, -1.50821656e-02f, -5.41710332e-02f, -7.79022425e-02f, 1.93431098e-02f, 7.95663148e-02f, 7.95783401e-02f,
  -4.95567685e-04f, -3.19835059e-02f, 2.48964801e-02f, -4.53427993e-02f, 2.85206717e-02f, 9.46153328e-02f, -8.95173009e-03f, 4.58130501e-02f, 5.97853884e-02f, -4.15248908e-02f,
  -1.13759995e-01f, -5.35198599e-02f, 3.33436653e-02f, -2.45469641e-02f, -9.17964652e-02f, -6.59497380e-02f, -8.73384923e-02f, -1.00708239e-01f, -1.13802649e-01f, 3.00028212e-02f,
  4.57787737e-02f, 4.13210876e-02f, 6.25735223e-02f, -9.18780267e-02f, 2.71122474e-02f, 4.52673435e-02f, -3.20018791e-02f, -1.27602927e-02f, -8.64400864e-02f, -7.85278454e-02f,
  4.85851131e-02f, -2.28651101e-03f, -8.64921212e-02f, 4.51247618e-02f, 4.62751240e-02f, -9.22139287e-02f, -7.72653669e-02f, -6.57085842e-03f, -3.09242196e-02f, 1.05113603e-01f,
  3.36709321e-02f, 9.73093212e-02f, 5.03335036e-02f, 3.74662131e-02f, 8.00449401e-02f, 1.11980751e-01f, -4.95896377e-02f, 4.99944054e-02f, 1.40948400e-01f, 1.07004255e-01f,
  1.25025004e-01f, 2.40621008e-02f, 5.74559979e-02f, -6.20266795e-02f, -2.44319648e-03f, 6.22326694e-02f, -2.71351058e-02f, 1.12863682e-01f, 7.25911781e-02f, -7.18096411e-03f,
  9.55462642e-03f, -2.35320237e-02f, 1.09015383e-01f, 5.13466932e-02f, -4.38484550e-03f, 4.02275585e-02f, -3.00059672e-02f, 7.01181144e-02f, -1.52801173e-02f, 5.00934236e-02f,
  -1.71074972e-01f, -5.27238892e-03f, -1.13870157e-02f, -8.30923170e-02f, 7.66338687e-03f, 1.43671110e-01f, 6.86861426e-02f, -4.56471406e-02f, 5.65558597e-02f, 6.94407821e-02f,
  -7.15814531e-03f, -4.29917723e-02f, 1.12561751e-02f, 8.83228797e-03f, 7.76128785e-04f, 2.42386125e-02f, 1.00137172e-02f, -8.80351439e-02f, 7.57874548e-02f, -5.13214022e-02f,
  5.66790104e-02f, -1.07422806e-01f, -1.29476070e-01f, -8.65823179e-02f, 6.04375862e-02f, 6.35719597e-02f, 1.69779677e-02f, 1.63943525e-02f, 3.07463761e-02f, 4.50580455e-02f,
  -5.52727617e-02f, 3.50880362e-02f, 5.18668145e-02f, 6.28387034e-02f, 2.78197192e-02f, -5.48408367e-02f, -3.04225814e-02f, -9.75579917e-02f, 1.18361292e-02f, -4.77828719e-02f,
  -2.88725384e-02f, 7.14960620e-02f, -9.34790745e-02f, 3.23076770e-02f, -1.64391287e-02f, -4.66497503e-02f, 6.59050420e-02f, -7.63412639e-02f, -5.12767062e-02f, -5.17679304e-02f,
  5.41493073e-02f, 3.20437960e-02f, 5.68562001e-02f, -2.84525398e-02f, 1.00003049e-01f, 1.62665416e-02f, 1.01878094e-02f, -6.43275529e-02f, -5.26357405e-02f, -9.09619685e-03f,
  3.65767293e-02f, -5.07292971e-02f, 5.94174974e-02f, 7.12635219e-02f, -2.01085974e-02f, -3.11384797e-02f, 1.78377647e-02f, -1.77008808e-02f, -5.78638092e-02f, -8.15613568e-02f,
  -1.05701245e-01f, 7.37924203e-02f, 4.95763607e-02f, -1.89077780e-02f, -6.69097528e-03f, 1.44468118e-02f, -4.93903048e-02f, -5.88693209e-02f, -6.00974495e-03f, 1.43131893e-02f,
  5.21211065e-02f, 6.52142614e-02f, 4.78965789e-02f, 1.18901283e-02f, 1.18678319e-03f, -2.10545640e-02f, 6.72153309e-02f, 8.15868601e-02f, 5.53127341e-02f, 8.39392189e-03f,
  -7.58187547e-02f, 5.24283480e-03f, -2.55403835e-02f, 1.16523635e-02f, 3.28259803e-02f, -2.17800904e-02f, 6.55096443e-03f, -1.76725462e-02f, -8.58547166e-02f, -2.65841130e-02f,
  -7.94834644e-02f, -1.78688187e-02f, 4.94807176e-02f, -5.92290126e-02f, 7.78148249e-02f, 7.23957419e-05f, -6.53086156e-02f, 5.28440159e-03f, 8.67656246e-03f, 3.52504142e-02f,
  3.74574363e-02f, -8.20001215e-03f, -2.48462223e-02f, 1.39084710e-02f, -3.56035158e-02f, 8.57130252e-03f, -4.72708466e-03f, -6.34921938e-02f, 9.04745758e-02f, 6.70211506e-04f,
  -5.96244307e-03f, -4.21734899e-02f, -1.82385787e-01f, -8.77790526e-02f, 1.67201236e-02f, -1.23985857e-01f, -1.23726711e-01f, 3.81078906e-02f, 3.06284502e-02f, -7.26083070e-02f,
  -1.53113350e-01f, 4.29131649e-02f, -2.50035506e-02f, -1.06166452e-01f, 1.61800478e-02f, -1.84371814e-01f, -1.87448859e-02f, -1.21141858e-01f, -1.08385295e-01f, -2.35078670e-02f,
  -7.54482113e-03f, -1.20151974e-01f, 3.23625281e-02f, -5.90785444e-02f, 1.10727281e-03f, -2.76302136e-02f, -8.41567963e-02f, 1.61157493e-02f, -1.43332509e-02f, -1.27042279e-01f,
  -1.30561322e-01f, 7.02799633e-02f, 8.58425051e-02f, 4.74103056e-02f, -2.53875386e-02f, 1.72121322e-03f, -7.29223713e-03f, 5.39745949e-02f, -5.81336906e-03f, -7.97627959e-03f,
  -4.33562994e-02f, -8.99044424e-03f, 2.34933775e-02f, 5.75482920e-02f, 1.02671534e-02f, -6.57214671e-02f, -4.90268357e-02f, 4.46885526e-02f, -4.11112756e-02f, 5.27415276e-02f,
  5.51363006e-02f, -2.26821657e-02f, 4.50158492e-02f, 2.59216372e-02f, 9.95646343e-02f, -5.91420941e-02f, 1.09792188e-01f, -2.67844666e-02f, 1.06025323e-01f, 5.18555418e-02f,
  -6.96182102e-02f, -1.04760414e-03f, -3.98517493e-03f, 1.00300401e-01f, 5.21172807e-02f, -1.55910542e-02f, -1.48364585e-02f, -1.17747355e-02f, -5.40198013e-02f, -5.81931770e-02f,
  -8.51367861e-02f, -1.22945094e-02f, 4.72282991e-02f, 5.29272342e-03f, -5.53871915e-02f, -8.64497572e-03f, 2.66232938e-02f, -1.05279023e-02f, -7.14466646e-02f, 6.80370480e-02f,
  3.93313468e-02f, -4.67381030e-02f, 3.84979509e-02f, -6.88687712e-03f, 8.84074159e-03f, -1.37501687e-03f, 4.84398343e-02f, 1.87422875e-02f, -7.85227418e-02f, -5.93743324e-02f,
  -1.62256330e-01f, 1.18957609e-01f, -3.34721655e-02f, 9.96638760e-02f, 5.91967721e-03f, 1.35951373e-03f, -6.29776716e-02f, -7.47898826e-03f, 7.20948353e-02f, 1.76277291e-02f,
  6.50761500e-02f, -1.73833352e-02f, -2.20732335e-02f, 8.75838846e-02f, -4.25185896e-02f, -1.76834762e-02f, 6.91403151e-02f, 6.10354319e-02f, -7.00239465e-02f, -6.61295280e-02f,
  5.18505983e-02f, -8.58836398e-02f, 8.76731649e-02f, -5.80131821e-03f, 3.70212793e-02f, -1.29163843e-02f, -3.61694619e-02f, 4.52337451e-02f, -4.74983174e-03f, 1.58253480e-02f,
  5.50369434e-02f, -3.83167267e-02f, 2.15948727e-02f, 8.04701820e-02f, -1.95088908e-02f, -4.34986204e-02f, 3.38473208e-02f, -6.85385391e-02f, -7.45158866e-02f, -3.12381033e-02f,
  -8.51925928e-03f, 6.27109110e-02f, 1.14156820e-01f, 1.29361302e-01f, 5.17896749e-03f, 3.21284533e-02f, 8.65066275e-02f, 1.17634432e-02f, 3.39852013e-02f, 1.19332790e-01f,
  -4.93358709e-02f, -8.86000227e-03f, 1.17263943e-01f, 4.09932695e-02f, -6.60832077e-02f, 1.87452585e-02f, 6.82537537e-03f, 6.61612898e-02f, -7.72384554e-02f, 6.97046816e-02f,
  4.18288559e-02f, 5.27583808e-02f, 7.24788606e-02f, 2.38782149e-02f, 5.69191873e-02f, -1.33839156e-03f, 3.27159949e-02f, -4.51389886e-02f, -4.45257640e-04f, 3.78748737e-02f,
  2.55260691e-02f, 1.90736074e-02f, -1.99205279e-02f, -1.23669701e-02f, -3.84797715e-02f, -9.68630314e-02f, 1.77104119e-02f, 1.97121296e-02f, 3.60325091e-02f, 2.30764020e-02f,
  6.18592389e-02f, -9.16140974e-02f, -1.07222639e-01f, -8.67191628e-02f, 4.07197587e-02f, -1.09050302e-02f, 2.50190906e-02f, -2.95647457e-02f, -7.51875760e-03f, -1.83891412e-02f,
  6.26024902e-02f, -4.17508297e-02f, -4.57614362e-02f, -4.48422991e-02f, -2.81214323e-02f, -2.82679833e-02f, -5.93861118e-02f, 7.79344216e-02f, 9.10389423e-02f, 4.16755723e-03f,
  2.25499342e-03f, -4.26054485e-02f, 4.95983027e-02f, -1.63768162e-03f, 6.39105141e-02f, -8.84971470e-02f, -5.51054254e-03f, 7.59308189e-02f, -2.71094237e-02f, 6.05450012e-02f,
  5.84585667e-02f, -3.73240118e-03f, 1.04505289e-02f, 5.27869165e-03f, 5.59036322e-02f, 9.14797932e-03f, 2.96413489e-02f, -6.65885136e-02f, -3.75283211e-02f, 4.56217192e-02f,
  2.02596914e-02f, -2.48049274e-02f, 9.50643197e-02f, 5.27713336e-02f, -6.40304387e-02f, 1.51566081e-02f, -4.34403345e-02f, -3.33556458e-02f, -1.02895640e-01f, -1.77597795e-02f,
  -1.11756168e-01f, 1.34446118e-02f, 1.41762309e-02f, 5.67826442e-02f, -2.75839455e-02f, 6.05201125e-02f, -6.77866861e-02f, -1.09529367e-03f, -6.56558126e-02f, -4.00679670e-02f,
  -3.40938829e-02f, -9.46305576e-04f, -1.09366896e-02f, 6.25984296e-02f, -9.42700952e-02f, 1.94129143e-02f, -5.34196384e-02f, 9.87865683e-03f, 9.34532508e-02f, 2.80606765e-02f,
  1.09343877e-04f, 5.73406518e-02f, -7.09791705e-02f, 7.96753243e-02f, 6.30949959e-02f, -5.68953268e-02f, -4.34738845e-02f, -2.63781194e-02f, 1.02292567e-01f, 1.28764972e-01f,
  7.92044029e-02f, 1.71666414e-01f, 9.14516971e-02f, 9.84317362e-02f, 1.08852694e-02f, -2.38115862e-02f, -4.15044911e-02f, 1.23316050e-01f, 9.39692855e-02f, 1.02174208e-01f,
  -1.48766239e-05f, 7.98081756e-02f, 4.53659706e-02f, -2.91867796e-02f, 8.06978047e-02f, -1.01877898e-02f, -4.87625673e-02f, -3.55140716e-02f, -2.52173226e-02f, 8.24682638e-02f,
  -6.13401569e-02f, -4.26873490e-02f, 7.98157454e-02f, 1.14437658e-03f, 6.59035221e-02f, -1.03727512e-01f, 7.55532756e-02f, -9.45425779e-02f, 7.93099552e-02f, 1.74020585e-02f,
  -5.29400818e-02f, 9.16116014e-02f, 1.60340182e-02f, 5.96916638e-02f, 8.95553827e-03f, -9.46044102e-02f, -4.51132357e-02f, 8.96133631e-02f, -1.75809511e-03f, 4.84110648e-03f,
  6.60612732e-02f, -8.84950459e-02f, -3.54590341e-02f, 6.33486658e-02f, 7.96019509e-02f, 7.95673206e-02f, -7.22773224e-02f, 5.70501164e-02f, -4.20968533e-02f, -5.59466928e-02f,
  -2.90801898e-02f, 7.80148655e-02f, 8.74760970e-02f, 6.91163214e-03f, 1.00081898e-01f, -7.30731757e-03f, 1.72869302e-02f, 6.43308461e-02f, 1.04540894e-02f, 2.80688088e-02f,
  3.85760143e-02f, -2.79001612e-02f, 3.36692482e-02f, 2.55494099e-02f, 1.73420999e-02f, -4.07069288e-02f, 5.94537482e-02f, 2.24913731e-02f, -5.06987832e-02f, -8.07319488e-03f,
  4.94397059e-02f, -1.37179755e-02f, 9.11253467e-02f, 2.68862341e-02f, -4.05037962e-02f, 9.47195813e-02f, -2.30303351e-02f, -7.95047581e-02f, 2.35578269e-02f, 5.16088754e-02f,
  1.46930274e-02f, 9.19764303e-03f, -3.27373035e-02f, 1.00575358e-01f, -5.15551567e-02f, -5.55505119e-02f, -6.07189275e-02f, 3.58886607e-02f, -1.05184987e-01f, -8.03774148e-02f,
  -7.67891929e-02f, 6.07329533e-02f, -1.28445001e-02f, -6.59953058e-02f, 4.98692691e-02f, -6.45626411e-02f, 5.96748143e-02f, 3.81799638e-02f, -6.67277500e-02f, 2.46979706e-02f,
  -6.23495132e-02f, -9.88631230e-03f, 9.73644406e-02f, -6.55823871e-02f, -6.64125606e-02f, 7.27603212e-02f, -3.43189016e-02f, -5.92586882e-02f, 3.36442217e-02f, 2.30251402e-02f,
  -3.00256848e-01f, -7.83890262e-02f, 2.34750602e-02f, 4.80039790e-03f, -7.87570328e-02f, 2.26039905e-02f, 2.35301927e-02f, 8.77590403e-02f, 7.63528123e-02f, -2.04140064e-03f,
  -5.26375882e-02f, 6.55648634e-02f, -3.47465612e-02f, -5.76981679e-02f, -7.77626736e-03f, 1.95613056e-01f, 1.89079553e-01f, 6.93436861e-02f, 7.72340223e-02f, 2.21899748e-02f,
  1.27748519e-01f, 5.75125925e-02f, -7.58665428e-02f, -5.96985184e-02f, -4.57419781e-03f, 8.07808042e-02f, 3.84939350e-02f, 2.24577319e-02f, -3.00931390e-02f, 1.51842862e-01f,
  -1.10727884e-01f, -1.46791428e-01f, 4.62050438e-02f, 5.20678647e-02f, -7.33518824e-02f, -6.14742488e-02f, -1.15301661e-01f, 5.19700572e-02f, -1.22889355e-02f, 6.31860569e-02f,
  2.23726369e-02f, 3.78670730e-02f, -2.94615868e-02f, 8.05118382e-02f, -3.44230048e-02f, -9.73582640e-02f, 4.86082658e-02f, 2.22806595e-02f, -4.50053886e-02f, 4.82993154e-03f,
  -2.43475065e-02f, -3.89915816e-02f, -9.87805724e-02f, 5.00902198e-02f, -4.42086197e-02f, -1.08784735e-01f, -1.30299151e-01f, -7.44645223e-02f, -2.17775330e-02f, -3.70465666e-02f,
  -3.60729881e-02f, -4.00612578e-02f, 1.31939743e-02f, 7.26591498e-02f, 4.34883237e-02f, 1.15636006e-01f, 8.97841528e-02f, -6.11452851e-03f, -1.71083247e-03f, -2.00214293e-02f,
  -2.44415924e-03f, -5.14236726e-02f, -4.83796038e-02f, 7.12044463e-02f, 2.70343199e-02f, 8.63548741e-02f, 5.28035313e-03f, 1.16676921e-02f, -1.08567430e-02f, -7.12458268e-02f,
  5.44584282e-02f, -6.78387806e-02f, -6.31995797e-02f, 3.75352390e-02f, -1.59181301e-02f, 4.14254442e-02f, 3.19083408e-02f, -7.33154593e-04f, -9.68152434e-02f, -9.29544047e-02f,
  -1.11600131e-01f, -1.39482126e-01f, -7.45939463e-03f, -7.15128481e-02f, -7.59051880e-03f, -1.07847720e-01f, -4.12742682e-02f, -1.06944621e-01f, -2.59829666e-02f, 1.08925952e-02f,
  -1.16594754e-01f, -4.79735956e-02f, -7.75386617e-02f, -7.36405200e-04f, -9.98650417e-02f, -4.38449010e-02f, 7.07713841e-03f, 3.48493755e-02f, -1.55223869e-02f, 3.85156786e-03f,
  2.09007990e-02f, -3.46939303e-02f, -1.16838776e-01f, 7.77282193e-02f, -8.35354701e-02f, -5.85014708e-02f, -2.93645374e-02f, -2.87680458e-02f, 1.10369436e-02f, -2.29420420e-03f,
  6.11295849e-02f, 7.13903606e-02f, 1.37823328e-01f, -5.10373674e-02f, 1.12390973e-01f, 5.84276393e-02f, 6.54468387e-02f, -5.36175817e-02f, 4.57862392e-02f, 9.22946334e-02f,
  9.49668214e-02f, 7.44663477e-02f, 6.73626661e-02f, -8.85534957e-02f, 9.93008986e-02f, 8.12469572e-02f, -9.70111340e-02f, 3.69019923e-03f, -6.14372529e-02f, -3.41393147e-03f,
  9.73675493e-03f, -5.59007116e-02f, 1.06161073e-01f, -2.16745678e-03f, -3.47339138e-02f, 6.72408268e-02f, 1.30001074e-02f, 3.28043960e-02f, 1.97441541e-02f, 4.20861095e-02f,
  3.39025296e-02f, 2.01201111e-01f, -1.28256902e-01f, 2.98903440e-03f, -5.99842779e-02f, -6.91230893e-02f, -8.16196278e-02f, -5.86767914e-03f, 1.69444233e-02f, -6.82214200e-02f,
  -4.45347577e-02f, 7.95646980e-02f, -4.72470298e-02f, 3.56144607e-02f, 2.28603892e-02f, 5.73950969e-02f, -9.08798501e-02f, -2.09670309e-02f, -2.69297138e-02f, 3.12770717e-02f,
  2.98723183e-03f, 2.83236951e-02f, 7.02094585e-02f, -9.93838608e-02f, -7.91463535e-03f, 7.77586624e-02f, -2.07979940e-02f, 8.68968964e-02f, -8.35276861e-03f, 3.12845781e-02f,
  4.88925129e-02f, -4.05467190e-02f, 8.15328658e-02f, 7.89058656e-02f, -3.95866074e-02f, -4.91968393e-02f, 1.13582285e-02f, -1.62117723e-02f, -2.57060882e-02f, -6.47487268e-02f,
  3.53198387e-02f, -1.04839820e-02f, 5.24133742e-02f, -9.49980877e-03f, -4.99948747e-02f, 6.65030777e-02f, -1.96872186e-02f, -3.20215113e-02f, -6.64615780e-02f, 6.11820482e-02f,
  2.55969521e-02f, -1.48657998e-02f, -3.74729410e-02f, -1.76966202e-03f, -1.70288770e-03f, 6.19231677e-03f, -6.86287135e-02f, -2.19266079e-02f, -5.86926006e-02f, 5.60639910e-02f,
  -8.62986222e-02f, 3.65614854e-02f, -2.64968034e-02f, -1.10673591e-01f, -8.30366984e-02f, 1.96287166e-02f, -3.41656245e-02f, -7.25656077e-02f, 9.41394791e-02f, 2.43080370e-02f,
  -4.11562733e-02f, 7.36763105e-02f, 8.65019485e-02f, 5.86023740e-02f, -5.43871075e-02f, 1.10070659e-02f, -2.98177432e-02f, 9.82978963e-04f, -1.18481427e-01f, 3.21093202e-02f,
  2.27682712e-03f, 6.63424805e-02f, -5.04590049e-02f, -5.74888214e-02f, -1.82224251e-02f, -1.00828491e-01f, 7.17180893e-02f, 2.85054161e-03f, -7.61879608e-02f, -8.64882916e-02f,
  6.33304268e-02f, -1.52159715e-03f, -1.45988364e-03f, -5.06316721e-02f, -1.18780091e-01f, 7.06332102e-02f, -3.79558839e-02f, 9.83414426e-02f, -6.22926168e-02f, -4.54818867e-02f,
  -5.79728037e-02f, 7.59571716e-02f, 6.82471171e-02f, -4.49068360e-02f, 5.64213917e-02f, -4.59152162e-02f, 5.02533764e-02f, -2.49188431e-02f, 2.54049036e-03f, 9.65212733e-02f,
  -1.02567039e-02f, 7.41168782e-02f, 9.33497101e-02f, 3.59904096e-02f, -9.91360247e-02f, -1.37116364e-03f, -1.29689917e-01f, 1.69156902e-02f, -1.33356839e-01f, -1.02239676e-01f,
  8.34363103e-02f, -1.48005038e-01f, 4.08689640e-02f, -3.43271419e-02f, -1.02400772e-01f, -4.73919697e-02f, 7.24530295e-02f, -5.38539402e-02f, -9.73621979e-02f, 7.96796232e-02f,
  -4.58391830e-02f, -4.12034430e-02f, -7.60403574e-02f, 3.17130871e-02f, -2.60217357e-02f, 3.38877481e-03f, -4.31942940e-02f, -7.37572461e-02f, 1.06682191e-02f, -3.46327946e-02f,
  -1.02883421e-01f, -1.27385641e-02f, -7.31640402e-03f, 4.00775708e-02f, -4.55125496e-02f, 2.54998114e-02f, -1.09134372e-02f, -1.21979080e-01f, -1.18667774e-01f, 6.77508712e-02f,
  8.31790492e-02f, -4.40128446e-02f, -1.70959570e-02f, -2.73770820e-02f, -2.31677983e-02f, 2.15088893e-02f, -1.11395217e-01f, -4.45654131e-02f, 2.07175501e-02f, 4.90961745e-02f,
  -2.42578145e-02f, -3.98358107e-02f, -5.61445504e-02f, 6.30753562e-02f, -1.21545503e-02f, -8.62856880e-02f, 3.81963886e-02f, 3.70904393e-02f, 1.12216305e-02f, 6.87719807e-02f,
  8.50993767e-02f, 4.76273149e-02f, 9.86954011e-03f, 7.17997998e-02f, 2.11943798e-02f, 5.81420958e-02f, 5.12151904e-02f, -2.56548432e-04f, -4.06138459e-03f, 2.56162938e-02f,
  1.38995603e-01f, -1.43225163e-01f, 1.52429655e-01f, -4.36252207e-02f, -2.30071191e-02f, 2.57456899e-02f, -7.63966292e-02f, -1.83215120e-03f, 2.47731246e-02f, 8.31046700e-02f,
  2.81737074e-02f, 9.23736393e-02f, 9.50012077e-03f, -6.02799207e-02f, 1.10203870e-01f, 6.60206843e-03f, 4.67212871e-02f, 1.83501933e-02f, -1.04250766e-01f, -9.83809703e-04f,
  -3.82899418e-02f, 1.77971739e-02f, -2.10985541e-02f, 9.12032276e-02f, -5.63003030e-03f, -6.54524714e-02f, 1.05932318e-01f, 7.82340914e-02f, 9.31000486e-02f, 2.04195946e-01f,
  2.52633661e-01f, -4.73499410e-02f, -9.35735106e-02f, 7.66223157e-03f, 3.74666266e-02f, 1.00702994e-01f, 3.98552306e-02f, 3.69028859e-02f, -2.95476299e-02f, -3.54498103e-02f,
  4.73445542e-02f, 9.79848430e-02f, 9.29803103e-02f, 2.90348288e-02f, 8.75639077e-03f, 1.86848883e-02f, -4.66550142e-02f, 6.68615997e-02f, 9.15525779e-02f, 5.84053583e-02f,
  -9.08504277e-02f, 5.76885939e-02f, -5.86538576e-02f, 6.10722341e-02f, -8.60027671e-02f, 3.43783433e-03f, -1.47717923e-01f, -1.43004090e-01f, -1.41166851e-01f, -1.93973437e-01f,
  9.75449011e-02f, -1.26475319e-01f, 3.83987129e-02f, -1.21991783e-02f, -6.30170926e-02f, 1.08459242e-01f, 1.20451981e-02f, -2.50228085e-02f, -1.08022140e-02f, -3.88874821e-02f,
  7.29902022e-05f, -8.67827088e-02f, 4.55149189e-02f, -8.34211335e-02f, 3.56955156e-02f, 2.78786570e-02f, -2.03096680e-02f, -3.31567526e-02f, -3.41250634e-05f, -1.25792131e-01f,
  -1.38202667e-01f, 2.70535760e-02f, -1.32249785e-03f, -1.86876766e-02f, 2.17557009e-02f, 9.35643986e-02f, -1.24767065e-01f, -5.88390678e-02f, 1.14202043e-02f, -1.13850273e-01f,
  -5.82858920e-03f, -3.84106785e-02f, -1.74644236e-02f, 9.81395617e-02f, 3.60509977e-02f, -6.25918107e-03f, 5.97470552e-02f, -5.83986007e-02f, 8.57168064e-02f, 4.66776714e-02f,
  -2.90413178e-03f, -6.42185286e-02f, -7.60043561e-02f, -8.26538261e-03f, 1.69339813e-02f, 2.04830207e-02f, 5.40320054e-02f, -4.84003425e-02f, 7.03801289e-02f, -2.67962143e-02f,
  3.93819660e-02f, 6.84084669e-02f, -5.02493307e-02f, -2.57300641e-02f, -1.15439538e-02f, -1.24148443e-01f, 7.78441504e-03f, 6.84406981e-02f, -6.34471551e-02f, 9.05037224e-02f,
  6.46412745e-02f, -2.81758551e-02f, 4.57208008e-02f, 6.60059005e-02f, 9.53234616e-04f, -3.00977044e-02f, -1.85701102e-02f, -4.45699468e-02f, -8.67074449e-03f, 2.66425218e-02f,
  3.06320395e-02f, 4.76671048e-02f, -1.60112400e-02f, 8.22873972e-03f, 7.36967325e-02f, -1.81103945e-02f, -5.18437177e-02f, 1.06498143e-02f, 1.58684049e-02f, -1.29440874e-01f,
  -5.34178875e-02f, 1.03637345e-01f, 1.40242830e-01f, 6.64976910e-02f, 5.11506312e-02f, 1.46101773e-01f, 9.99955833e-02f, 1.00719780e-01f, 1.31253108e-01f, 6.33504912e-02f,
  2.37681687e-01f, 1.50323017e-02f, 2.53416840e-02f, 2.39186231e-02f, 1.38334841e-01f, 8.26204419e-02f, 7.18867704e-02f, 9.04441848e-02f, 5.20250015e-02f, 6.10648878e-02f,
  1.74558178e-01f, 6.40560091e-02f, 3.55163775e-02f, 7.88973346e-02f, -1.30017642e-02f, -6.28957897e-02f, -2.61289962e-02f, 1.85917830e-03f, 9.41076651e-02f, 1.16089657e-01f,
  -2.27462761e-02f, -6.27005026e-02f, 3.13889012e-02f, -3.08291931e-02f, -7.67117217e-02f, 6.28852472e-02f, -2.15076585e-03f, -2.59521306e-02f, 9.09434482e-02f, 2.91419514e-02f,
  1.84782781e-02f, 1.41450644e-01f, -5.77903353e-02f, -7.91370571e-02f, -6.23316914e-02f, 4.47580852e-02f, 4.19804379e-02f, 3.21385451e-02f, 9.99822170e-02f, -5.87425530e-02f,
  1.10460490e-01f, 5.21650771e-03f, 8.41530859e-02f, 4.39313278e-02f, 6.70658275e-02f, -2.80059837e-02f, -8.36730525e-02f, 5.92479594e-02f, 3.43884167e-04f, 9.93742980e-03f,
  -3.23203355e-02f, 4.84938435e-02f, 6.14777543e-02f, -2.06654519e-02f, 9.17455852e-02f, -5.21644875e-02f, 1.12864543e-02f, -3.53155732e-02f, -7.50877857e-02f, 1.76567363e-03f,
  4.17634174e-02f, 8.63054469e-02f, -4.16114228e-03f, -3.56096402e-02f, 6.38415292e-02f, 6.52741566e-02f, -2.99681146e-02f, -2.95050479e-02f, 1.78858414e-02f, -2.90122088e-02f,
  2.83835549e-02f, 7.57790059e-02f, 2.14706864e-02f, 1.93269402e-02f, -6.31649345e-02f, 6.87443018e-02f, 8.07206556e-02f, 3.22214514e-02f, 9.52099562e-02f, 4.15827110e-02f,
  7.96574801e-02f, 8.48913416e-02f, 6.05081767e-02f, -2.92923041e-02f, -2.15345789e-02f, 9.32505429e-02f, 7.12758079e-02f, -4.74149920e-02f, -5.13040908e-02f, 4.84061353e-02f,
  -2.75903754e-02f, 3.76502960e-03f, -2.90391017e-02f, -2.47613359e-02f, 2.06194688e-02f, -6.37074485e-02f, 5.95092066e-02f, -8.13921839e-02f, 1.02007493e-01f, -2.31925258e-03f,
  1.26557434e-02f, 9.69494879e-02f, 3.49491127e-02f, 1.01266513e-02f, 8.00328627e-02f, -4.87383269e-03f, 7.08751157e-02f, 2.20437851e-02f, 4.62735891e-02f, -4.49814051e-02f,
  2.96883155e-02f, 1.29996631e-02f, 9.96055007e-02f, 9.18750912e-02f, -6.50576875e-02f, -2.67516263e-02f, 2.32931804e-02f, -2.31569912e-03f, 4.86539453e-02f, -3.99908908e-02f,
  -1.71767101e-01f, -7.76068587e-03f, -1.44273579e-01f, -1.71606421e-01f, -3.50315869e-02f, 5.76346442e-02f, -4.16551866e-02f, -3.87574434e-02f, -4.89066839e-02f, 1.17575033e-02f,
  6.70065060e-02f, 5.61684184e-03f, -7.74621218e-02f, -5.66285327e-02f, -9.65556651e-02f, -7.10082874e-02f, -1.50790334e-01f, -5.87324463e-02f, 1.22978603e-02f, -4.73288782e-02f,
  6.43054247e-02f, -1.45341486e-01f, -7.99507201e-02f, -7.85742179e-02f, -8.49401951e-03f, 3.78202237e-02f, 1.04795033e-02f, -3.00481021e-02f, -3.05701103e-02f, -1.74524058e-02f,
  -6.57033473e-02f, 8.87677670e-02f, 1.19134001e-01f, 5.56645878e-02f, -8.48696828e-02f, -2.61789393e-02f, 2.06906069e-03f, -7.87219778e-02f, 1.73066333e-02f, 2.81405393e-02f,
  -3.77155505e-02f, 8.33600163e-02f, 4.99246716e-02f, 1.27469376e-01f, 4.00105938e-02f, 3.42769772e-02f, 6.82226345e-02f, 4.07231413e-02f, -4.17797752e-02f, 1.01501383e-01f,
  -3.02072689e-02f, 7.38596991e-02f, -2.64276136e-02f, 1.38931498e-02f, 1.32415161e-01f, 1.05747111e-01f, 1.04400083e-01f, 3.28959897e-02f, 1.20601833e-01f, 2.39200182e-02f,
  -3.10670491e-02f, -3.20678465e-02f, 5.21019958e-02f, -3.96340229e-02f, -3.16282026e-02f, -2.22649844e-03f, -1.66900326e-02f, 4.36284617e-02f, -2.08405871e-02f, 4.25645113e-02f,
  3.69855091e-02f, 4.05597202e-02f, -3.36840749e-02f, 5.43549769e-02f, 8.55460912e-02f, 2.19335798e-02f, -5.21668866e-02f, 5.71213476e-03f, -1.95354354e-02f, -1.37835387e-02f,
  3.23223174e-02f, 7.66213313e-02f, -8.87907371e-02f, 9.67087373e-02f, 6.30430728e-02f, 5.21606626e-03f, -4.80638593e-02f, 7.50618130e-02f, -3.52872275e-02f, 6.68610781e-02f,
  -8.26868936e-02f, 6.44902438e-02f, 9.98711120e-03f, 7.89580867e-02f, -1.64945796e-02f, -4.70338352e-02f, -7.79387504e-02f, -5.21544851e-02f, -4.93916199e-02f, 7.34666958e-02f,
  1.04075670e-01f, -4.72381562e-02f, -1.10131474e-02f, 2.15554666e-02f, 1.95314921e-02f, 8.83086175e-02f, 8.75410512e-02f, 5.61960861e-02f, -2.34099403e-02f, 7.41299465e-02f,
  -6.59356490e-02f, 3.07974522e-03f, 6.69401512e-02f, 3.94127816e-02f, 5.80175482e-02f, -7.41907731e-02f, 3.11066229e-02f, 2.09576655e-02f, 9.55517814e-02f, -4.33880128e-02f,
  -1.72571555e-01f, 1.31244231e-02f, 1.35728261e-02f, 1.21112473e-01f, 1.49851203e-01f, 7.71065131e-02f, 1.10396557e-02f, 5.27273640e-02f, 7.86413401e-02f, 9.08311978e-02f,
  -6.79382309e-02f, 3.32045890e-02f, -2.16357838e-02f, -5.50009422e-02f, 5.22858053e-02f, 1.05910795e-02f, 6.01693727e-02f, -3.60829793e-02f, 5.44680841e-02f, -2.42129937e-02f,
  4.35887128e-02f, 1.06114931e-01f, -3.82391810e-02f, 2.46802699e-02f, 1.63567021e-01f, -3.81555296e-02f, 5.98590001e-02f, 4.83025350e-02f, 1.86343398e-03f, 1.58568919e-01f,
  -5.43304756e-02f, -6.48364127e-02f, -9.16650668e-02f, 4.39729281e-02f, -5.71673997e-02f, -8.36245865e-02f, 7.86140934e-03f, 8.18269048e-03f, -6.77838475e-02f, -4.92727533e-02f,
  -1.72269493e-02f, -2.73130778e-02f, -2.70662699e-02f, 8.74704793e-02f, 6.47283942e-02f, -8.59806687e-02f, -6.96974471e-02f, 5.69308118e-04f, -4.22620121e-03f, -4.23980691e-02f,
  1.16758727e-01f, 4.49515469e-02f, -3.07773855e-02f, -7.01679215e-02f, 9.47250798e-02f, -5.26731573e-02f, -1.61425509e-02f, 1.14182318e-02f, 4.45072120e-03f, -2.20069848e-02f,
  5.15488684e-02f, -7.60685429e-02f, 4.88821007e-02f, 5.22844419e-02f, 4.52387296e-02f, 1.47944260e-02f, -1.76173548e-04f, 2.32636184e-02f, 3.08509246e-02f, 7.22081633e-03f,
  9.16846991e-02f, -3.08156125e-02f, -1.32837733e-02f, -4.45056185e-02f, -1.65504999e-02f, 5.87557117e-03f, -5.48129305e-02f, 4.59959805e-02f, 1.60237942e-02f, 6.54665008e-02f,
  4.62683141e-02f, -4.55193296e-02f, 7.68275708e-02f, 6.95867017e-02f, 6.23083394e-03f, 5.24651594e-02f, -9.84925311e-03f, 6.08362108e-02f, -7.79742077e-02f, 3.59944813e-03f,
  -3.06597780e-02f, -1.19440481e-01f, -2.99778349e-05f, -1.96298007e-02f, -6.02302775e-02f, -7.02707916e-02f, -3.61622474e-03f, -2.45795194e-02f, 2.49585751e-02f, 1.64165013e-02f,
  6.53623715e-02f, 4.23028991e-02f, 7.57441148e-02f, 7.43861124e-02f, 7.70554841e-02f, 2.81887203e-02f, -3.18635218e-02f, 4.04874198e-02f, -1.23048380e-01f, -4.89187203e-02f,
  9.61603969e-03f, 3.70952487e-02f, -1.15634240e-01f, -3.98713816e-03f, -2.82694194e-02f, 7.68383518e-02f, 3.99065465e-02f, -3.98480259e-02f, 2.70528328e-02f, -6.97051659e-02f,
  -9.05105546e-02f, -3.59233245e-02f, -4.67687622e-02f, 2.58521065e-02f, -2.59790793e-02f, 3.68567258e-02f, -5.12318201e-02f, 6.56115860e-02f, -7.07607791e-02f, 2.78575905e-02f,
  -5.61163165e-02f, -8.62289127e-03f, 3.44316401e-02f, -8.53836536e-03f, -8.59648362e-03f, -9.70912203e-02f, -1.30336225e-01f, -3.61073166e-02f, -2.40906533e-02f, -4.18699197e-02f,
  -3.47638577e-02f, 1.20884962e-02f, -2.22216118e-02f, 1.37706418e-02f, -4.44333535e-03f, -6.50907531e-02f, 4.72856052e-02f, -8.76575857e-02f, 3.03269699e-02f, -5.26099093e-02f,
  -3.75212878e-02f, 4.69823070e-02f, 4.64812256e-02f, 6.77759945e-02f, 2.26258412e-02f, 2.15367377e-02f, 7.04997033e-02f, -1.02031380e-02f, -2.73907650e-02f, 4.49704118e-02f,
  -6.44884259e-02f, 6.59004301e-02f, -5.63427396e-02f, -5.07809147e-02f, 1.87049434e-02f, 5.93172293e-03f, -2.63872184e-02f, -5.92010133e-02f, 6.29743710e-02f, -2.88608242e-02f,
  4.57032733e-02f, -3.34404921e-03f, -5.05852289e-02f, -5.69786318e-02f, -4.69196662e-02f, -1.89885739e-02f, -1.53614068e-02f, -6.87155873e-02f, 1.19449109e-01f, 1.09207831e-01f,
  5.49665056e-02f, -8.77180994e-02f, -1.25940926e-02f, 8.51677656e-02f, 1.83460861e-02f, 2.63410527e-02f, -2.17975974e-02f, 3.51316109e-02f, 6.04730919e-02f, 5.18488847e-02f,
  5.86813726e-02f, 5.22956401e-02f, -7.19652623e-02f, -1.01570480e-01f, -1.01243518e-01f, 7.65945166e-02f, -5.98819330e-02f, -1.73291229e-02f, -4.75258827e-02f, 7.49371871e-02f,
  4.84769000e-03f, -3.65840271e-02f, 7.00395629e-02f, -3.93534964e-03f, 2.20185667e-02f, -1.95695106e-02f, -4.18757685e-02f, -1.64935496e-02f, 2.51411386e-02f, -8.01928043e-02f,
  -2.55457051e-02f, 1.81277636e-02f, -7.76809677e-02f, -4.73501869e-02f, -7.60223204e-03f, 6.34649843e-02f, 4.69327532e-02f, -4.50163111e-02f, 8.62758383e-02f, -5.64435795e-02f,
  6.61303895e-03f, -7.55943060e-02f, 7.10938871e-02f, -3.15321684e-02f, -9.38124657e-02f, -6.56737313e-02f, -2.73253191e-02f, 6.50773346e-02f, -2.22271048e-02f, -4.81883809e-02f,
  -6.81420490e-02f, -5.83220646e-02f, 6.61692396e-02f, -8.70027021e-02f, 3.38810161e-02f, 5.58651239e-02f, 9.94999427e-03f, -4.22183536e-02f, 1.08536102e-01f, -1.08410502e-02f,
  1.74505025e-01f, -1.06128357e-01f, -1.24492884e-01f, -5.43861836e-03f, -2.67496351e-02f, 7.01177958e-03f, 7.10031390e-03f, -4.45965156e-02f, -4.19608206e-02f, -3.95367183e-02f,
  2.69846688e-03f, -7.55731203e-03f, 7.44319558e-02f, -3.80643345e-02f, -4.10264079e-03f, 6.18133806e-02f, -8.82407743e-03f, 2.59351116e-02f, 6.59233779e-02f, -9.80502591e-02f,
  -4.30745222e-02f, -6.06604815e-02f, 7.10063130e-02f, 4.91165742e-02f, -1.41784400e-01f, -3.82242054e-02f, -1.47389203e-01f, 2.04250738e-02f, -7.53502315e-03f, -1.59542845e-03f,
  -2.06899405e-01f, -9.96612757e-02f, -2.85203420e-02f, 9.18709412e-02f, -1.08215064e-01f, 1.03032142e-02f, -1.49971843e-02f, 1.31135376e-03f, 5.90488501e-02f, 1.96395088e-02f,
  6.99257180e-02f, 1.02787264e-01f, -5.11562750e-02f, -3.62491165e-03f, -1.20331943e-02f, 6.97534299e-04f, -1.77294351e-02f, -6.61299974e-02f, -1.18457295e-01f, -1.66248586e-02f,
  -9.70745608e-02f, -8.20727944e-02f, 1.25563787e-02f, -4.94589796e-04f, -9.14686709e-04f, 4.88462336e-02f, -9.90670770e-02f, -5.94447441e-02f, -1.02190755e-01f, -1.01964891e-01f,
  3.66387367e-02f, -2.97427853e-03f, -1.31205758e-02f, 4.07757536e-02f, -6.33899122e-02f, 8.41834918e-02f, -1.27251109e-03f, 8.05171877e-02f, -2.19395328e-02f, 8.07222724e-03f,
  -7.32753575e-02f, -6.82558268e-02f, -5.64973429e-02f, 8.06348920e-02f, -3.10929213e-02f, 1.22660655e-03f, 2.21059974e-02f, 4.28563170e-03f, -6.16746172e-02f, 4.60198373e-02f,
  1.54604819e-02f, -1.73907038e-02f, 2.58009462e-03f, -7.11382478e-02f, -6.79459348e-02f, -2.30134204e-02f, -5.00902049e-02f, -4.99556493e-03f, -5.31468317e-02f, 9.47802141e-02f,
  -1.36540122e-02f, 5.12672067e-02f, 1.23170421e-01f, 6.06956929e-02f, 5.56899793e-02f, -5.60795106e-02f, 3.79151553e-02f, 3.97479441e-03f, -3.84027064e-02f, 2.37755068e-02f,
  -6.77934885e-02f, 1.11617455e-02f, -5.90783283e-02f, -1.59036915e-03f, 5.77392690e-02f, -2.55604777e-02f, 1.74635630e-02f, 6.64908215e-02f, -6.13866560e-02f, -3.88997048e-02f,
  -1.61249738e-03f, 1.86300278e-01f, 1.90060586e-01f, -9.70265549e-03f, 4.19111922e-02f, 1.80467829e-01f, -2.02496769e-03f, 5.67954592e-02f, 1.46399856e-01f, 1.40514761e-01f,
  1.18094139e-01f, -1.27659738e-01f, 1.36619195e-01f, -4.48694127e-03f, -7.75854215e-02f, 4.58521172e-02f, 9.13400725e-02f, 3.59880626e-02f, 7.54360259e-02f, -8.73522740e-03f,
  2.69204471e-02f, -1.01379819e-01f, -7.17518013e-03f, 6.78010136e-02f, -1.75001565e-02f, -5.14628701e-02f, -4.49563451e-02f, 4.66466062e-02f, 1.49194255e-01f, 1.05740484e-02f,
  -7.61680352e-03f, 1.57261938e-02f, 2.28822101e-02f, 5.82518056e-02f, 1.25904297e-02f, -1.49969729e-02f, 3.90317850e-02f, -9.64047536e-02f, -1.00067437e-01f, -7.82137830e-03f,
  5.50792404e-02f, -4.23180051e-02f, -4.39203642e-02f, -6.97264150e-02f, 1.04996599e-02f, -1.69641860e-02f, 2.38824226e-02f, 4.29996103e-02f, 6.16402477e-02f, 9.30584371e-02f,
  2.50596330e-02f, 6.62103295e-02f, 2.11589551e-03f, -3.29355970e-02f, 3.96633632e-02f, 2.32546534e-02f, -1.05760545e-01f, -1.38478279e-02f, -3.49337235e-02f, -1.45912906e-02f,
  -4.91958894e-02f, 3.88252214e-02f, 4.89884652e-02f, -5.19658811e-02f, -4.81228828e-02f, -5.68240806e-02f, -8.34394991e-02f, -8.08788091e-02f, -5.69125637e-03f, 8.58893096e-02f,
  -3.54363620e-02f, 1.81368515e-02f, 4.93497774e-02f, 7.55785732e-04f, 1.18870467e-01f, 2.94210529e-03f, -2.24745497e-02f, -2.55889576e-02f, 6.81933910e-02f, 1.41486879e-02f,
  9.51000452e-02f, -4.21015471e-02f, 2.51811687e-02f, 7.00551122e-02f, -6.06758147e-02f, -9.39010978e-02f, 1.46044139e-02f, 4.26135212e-02f, -3.67383361e-02f, 1.85987893e-02f,
  -5.63469268e-02f, -2.01939046e-02f, -8.17692205e-02f, -5.04869483e-02f, 3.21381576e-02f, 7.66400993e-02f, -5.53013980e-02f, 2.95097213e-02f, 5.27656041e-02f, 4.98498939e-02f,
  1.78689975e-02f, -9.14171413e-02f, 1.16870850e-02f, -4.90033301e-03f, 8.83409008e-02f, -9.81815383e-02f, -6.11115359e-02f, -6.23821840e-02f, 2.58638430e-02f, -6.57521095e-03f,
  -6.23458400e-02f, 3.42619941e-02f, 5.19981682e-02f, -9.59940106e-02f, 7.14134574e-02f, -1.84293594e-02f, -2.62971912e-02f, 7.76446089e-02f, 4.18469086e-02f, -4.69319075e-02f,
  1.67179424e-02f, 7.38654137e-02f, 1.19514562e-01f, 6.95161000e-02f, -1.14158622e-03f, 2.12258734e-02f, -5.06374352e-02f, 1.27959698e-01f, 6.26791641e-02f, 1.64190412e-01f,
  -6.15337491e-02f, -1.50294244e-01f, -1.59280688e-01f, -4.32920530e-02f, -9.28334817e-02f, -3.37845124e-02f, -1.02234460e-01f, 6.25785738e-02f, 1.68017671e-02f, -1.31088749e-01f,
  -1.27509043e-01f, -7.52052441e-02f, -7.32369721e-02f, -9.57807079e-02f, -2.38149259e-02f, -4.32356913e-03f, -6.21190146e-02f, 2.74942778e-02f, 8.05484429e-02f, -2.26931274e-02f,
  -3.01124845e-02f, -6.97255135e-02f, -8.10146406e-02f, 2.89627872e-02f, -1.23148739e-01f, -1.27836093e-01f, -1.64485157e-01f, -1.49636611e-01f, -9.39218476e-02f, -1.74261913e-01f,
  -1.86772078e-01f, -6.62943674e-03f, -3.95343900e-02f, -8.22241232e-02f, -7.54851401e-02f, -1.75904576e-02f, -1.11060530e-01f, 6.78660395e-03f, 5.95133677e-02f, -6.31094649e-02f,
  -3.58403549e-02f, 2.47959308e-02f, 3.20740864e-02f, 4.97756191e-02f, 4.02639322e-02f, 9.79363546e-02f, 1.38832703e-02f, 9.69686806e-02f, 8.39269534e-02f, -5.34451790e-02f,
  8.16647708e-02f, 8.35762694e-02f, 6.98054507e-02f, 6.76863194e-02f, -4.97894734e-02f, -6.84622675e-02f, -7.01310337e-02f, -8.39308724e-02f, -3.23607512e-02f, -8.13893080e-02f,
  -4.32962142e-02f, 5.52905388e-02f, 4.87088002e-02f, 1.93817373e-02f, -3.96796130e-03f, 8.26566890e-02f, 6.05585165e-02f, 2.83201020e-02f, 1.92838665e-02f, 2.84186937e-02f,
  -2.29974315e-02f, 3.84456515e-02f, -3.15050595e-02f, -2.99404766e-02f, -7.80114084e-02f, -3.04772425e-02f, 4.34994232e-04f, -4.90554199e-02f, -6.04683869e-02f, 4.22121026e-02f,
  -4.69826348e-02f, 9.37607437e-02f, 8.45066011e-02f, 2.65224762e-02f, 1.07762426e-01f, -3.78561281e-02f, 1.19975127e-01f, -1.01348292e-02f, 6.26716241e-02f, 7.67260641e-02f,
  -8.99944827e-02f, -3.22728902e-02f, -1.03505896e-02f, 1.55050168e-02f, -1.06290549e-01f, 1.34656290e-02f, -1.11217108e-02f, -2.37037949e-02f, -3.24860997e-02f, -2.86363880e-03f,
  3.67479213e-02f, -1.34385321e-02f, -1.25805005e-01f, 2.39568241e-02f, 3.86752635e-02f, -1.51992198e-02f, 3.39139178e-02f, -1.15798518e-01f, 1.01245143e-01f, 9.76417288e-02f,
  2.62416676e-02f, 6.93733841e-02f, -1.18071541e-01f, -4.03716490e-02f, -2.00759135e-02f, -8.98174196e-02f, -8.41439143e-02f, -8.08705688e-02f, -3.10640726e-02f, -1.19067900e-01f,
  -6.41164705e-02f, 1.28694132e-01f, 2.49838699e-02f, -8.37911218e-02f, 1.92481457e-04f, 1.86147951e-02f, 1.18961044e-01f, -6.30105054e-03f, 1.75442211e-02f, 1.14132024e-01f,
  1.16023663e-02f, 1.31703997e-02f, 7.64967576e-02f, -3.92222777e-02f, -7.32215941e-02f, 3.36458124e-02f, -4.50146310e-02f, -8.93423632e-02f, -3.60104591e-02f, -5.68716787e-02f,
  4.87476513e-02f, 4.47858498e-02f, 4.36717086e-02f, -8.97092894e-02f, 3.31346765e-02f, -1.02758959e-01f, 5.23177981e-02f, 7.50184730e-02f, 6.45680428e-02f, 7.58448690e-02f,
  -4.76903515e-03f, 1.48524269e-01f, 4.04386632e-02f, -6.83122352e-02f, 4.96719442e-02f, -1.03716534e-02f, 3.02643981e-02f, -7.94696733e-02f, -1.57997552e-02f, 7.59635726e-03f,
  4.17117067e-02f, -7.72696957e-02f, -5.79865351e-02f, 1.59609225e-02f, -1.71931237e-02f, 9.80583206e-02f, -4.76574078e-02f, -3.44963148e-02f, -6.43077716e-02f, -6.89862445e-02f,
  1.12054989e-01f, 7.65476972e-02f, 1.03525072e-01f, 9.81198251e-03f, -6.77019060e-02f, -4.97984281e-03f, -6.88871965e-02f, -8.80961269e-02f, -6.21492639e-02f, -3.54593806e-02f,
  -1.02995764e-02f, 4.94020507e-02f, -5.03380373e-02f, -1.31713683e-02f, -2.92593576e-02f, -3.57181504e-02f, -3.22787128e-02f, 1.25626594e-01f, -6.16405495e-02f, 4.28796858e-02f,
  4.54830297e-04f, -4.97132055e-02f, 3.42031270e-02f, -4.22454178e-02f, -6.01646788e-02f, -1.00549338e-02f, 3.39190513e-02f, -6.28859401e-02f, 8.03441647e-03f, 2.11543273e-02f,
  1.11559378e-02f, 3.12002283e-02f, 5.14709316e-02f, 4.29596119e-02f, 8.19287845e-04f, 2.45351158e-02f, 8.56087208e-02f, -5.70443012e-02f, -1.74696522e-03f, -5.82117005e-04f,
  -5.48611097e-02f, 1.11748405e-01f, -8.60933810e-02f, -8.05742666e-03f, 6.12353534e-02f, 3.55850696e-03f, -7.09078312e-02f, -8.45752954e-02f, 9.75195989e-02f, -3.04733589e-02f,
  2.70411596e-02f, -4.18915832e-03f, 7.08196238e-02f, 2.35213842e-02f, 1.91687867e-02f, 1.52489338e-02f, -1.81341264e-02f, -4.10294272e-02f, 6.86094835e-02f, 7.06440508e-02f,
  2.14878749e-02f, 7.11571425e-02f, -6.39646128e-02f, 4.84038442e-02f, 3.25671136e-02f, 5.77505119e-02f, 6.47427365e-02f, -5.08006774e-02f, -3.73602137e-02f, -1.21678188e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.42606580e-01f, 7.75331259e-02f, -1.60576664e-02f, 4.73147444e-02f, -7.10216956e-03f, -4.79862560e-03f, -2.60352995e-02f, 9.22853276e-02f, 1.24776758e-01f, 1.93383172e-02f,
  1.13737404e-01f, 2.85710674e-02f, -3.93414050e-02f, 1.03736138e-02f, 7.47808143e-02f, 5.43374904e-02f, 7.85921589e-02f, 1.62630886e-01f, -5.46225347e-03f, 5.04383631e-03f,
  4.06950042e-02f, -1.83986276e-02f, 1.26623377e-01f, 1.55301750e-01f, 3.68034318e-02f, 7.77031332e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.15533121e-01f, 9.74093154e-02f, 5.97420055e-03f, 1.63457811e-01f, 1.89728633e-01f, 1.56777769e-01f, 6.29887264e-03f, -1.03372872e-01f, 9.05551314e-02f, 2.62213610e-02f,
  1.98408440e-02f, 1.93152159e-01f, 5.33165373e-02f, -1.35787139e-02f, -4.00765799e-02f, -2.46780608e-02f, 2.84437779e-02f, 1.24194823e-01f, -1.81972355e-01f, 6.83627427e-02f,
  -1.14226408e-01f, 8.97720363e-03f, 2.11520210e-01f, 1.78928420e-01f, -5.69755100e-02f, -3.68509352e-01f, 1.39027044e-01f, 1.54153377e-01f, 2.28350192e-01f, 2.25877747e-01f,
  -1.11838933e-02f, 1.45449117e-01f, -5.36519252e-02f, 9.02247950e-02f, 1.30437687e-01f, 1.02336183e-01f, -4.05955352e-02f, 3.18094976e-02f, -1.51577264e-01f, -9.31642354e-02f,
  1.75875530e-01f, 6.75339028e-02f, -3.20433751e-02f, -1.69266313e-01f, -1.05499297e-01f, -1.39478698e-01f, -7.61072338e-02f, -1.19876288e-01f, -8.33215639e-02f, -1.41045809e-01f,
  1.37774989e-01f, 7.45966360e-02f, 1.93369482e-02f, 7.12813661e-02f, 1.79851547e-01f, 6.62546046e-03f, -1.36986047e-01f, -7.23250881e-02f, -1.71755049e-02f, -6.87297508e-02f,
  2.10299194e-02f, 1.64195940e-01f, -1.37978405e-01f, -1.50406897e-01f, 1.05777815e-01f, -3.04872524e-02f, 9.64411497e-02f, -3.07489242e-02f, 7.91180432e-02f, 4.84892800e-02f,
  1.80932283e-01f, -8.17828998e-02f, 4.02859934e-02f, -1.51246088e-02f, 1.55453369e-01f, 2.91144326e-02f, 6.44694045e-02f, 1.01100065e-01f, -3.83234285e-02f, 1.65856570e-01f,
  1.26506627e-01f, -2.27664709e-01f, 9.94712412e-02f, -2.36348614e-01f, -8.28654841e-02f, -7.70162940e-02f, 3.46173048e-02f, -3.22456285e-02f, -1.57391876e-01f, 1.45093024e-01f,
  -2.90772945e-01f, -1.99248016e-01f, -1.24355868e-01f, 3.14759538e-02f, 1.37576014e-01f, -1.24614662e-03f, 1.15318574e-01f, -1.32799685e-01f, 1.39349595e-01f, -2.15223029e-01f,
  -2.93831021e-01f, 2.67631143e-01f, -1.09865576e-01f, 4.26402390e-02f, 1.62791297e-01f, 9.03652310e-02f, -1.17143892e-01f, -1.11568436e-01f, -1.61059186e-01f, -1.04142331e-01f,
  6.89520314e-02f, 6.42517284e-02f, -8.01654831e-02f, 4.65411209e-02f, 6.87870234e-02f, -8.13535526e-02f, 8.96688923e-02f, -9.54682287e-03f, -4.80377078e-02f, -3.36172841e-02f,
  -5.62075786e-02f, -8.15793425e-02f, 4.55123335e-02f, 7.61310458e-02f, 1.41389281e-01f, -6.06385618e-02f, -9.38232169e-02f, -1.66538656e-02f, -1.23937614e-01f, -1.17090143e-01f,
  -4.96154763e-02f, -4.71056215e-02f, 1.47270607e-02f, -1.17061168e-01f, 1.54567920e-02f, 1.05732940e-01f, -7.31047168e-02f, 3.19688469e-02f, -1.88628927e-01f, -1.75260268e-02f,
  4.98039834e-02f, -9.63701308e-02f, -1.81603685e-01f, -8.36977959e-02f, -8.97226408e-02f, 9.58271511e-03f, -9.16683078e-02f, -4.49886359e-02f, 1.18439786e-01f, -7.78978914e-02f,
  -2.38771766e-01f, 5.82302511e-02f, 7.89763257e-02f, 1.48329273e-01f, -1.24320179e-01f, 1.16018057e-01f, 2.04445079e-01f, 1.31135151e-01f, 2.72293389e-02f, -1.18661195e-01f,
  -1.99882179e-01f, 1.21445976e-01f, -2.26149321e-01f, 9.04175565e-02f, 2.61638463e-01f, -1.27404988e-01f, 6.06352929e-03f, 4.91047502e-02f, -2.47863948e-01f, 7.44506642e-02f,
  1.33443981e-01f, 8.19291100e-02f, 4.80901897e-02f, -2.11852062e-02f, -2.71875579e-02f, -7.64412880e-02f, 3.59102897e-02f, 9.53053460e-02f, 9.71604735e-02f, 7.40907937e-02f,
  -7.80316144e-02f, -7.15648830e-02f, 1.00967355e-01f, 1.87304229e-01f, 8.00149702e-03f, 5.25909103e-02f, -5.49357869e-02f, -1.83212268e-03f, 9.03387144e-02f, 7.38636106e-02f,
  -9.59858298e-02f, -1.59352437e-01f, 1.96864426e-01f, 6.16813190e-02f, -3.81615274e-02f, -5.57314754e-02f, -8.46837536e-02f, 9.95913446e-02f, -1.14450883e-02f, 1.31139413e-01f,
  1.16047673e-01f, -3.64561044e-02f, -6.65805414e-02f, -3.05546559e-02f, -2.54577082e-02f, 1.19581863e-01f, 4.63477615e-03f, 4.02034493e-03f, 1.50807515e-01f, 1.10926069e-01f,
  -1.36551619e-01f, -7.20878020e-02f, -1.98653489e-01f, 5.35290167e-02f, 2.58751512e-01f, 1.73025519e-01f, -2.52883315e-01f, -9.23626125e-02f, -4.06251848e-02f, -8.14934373e-02f,
  -6.86212704e-02f, -2.74833351e-01f, 5.31621575e-02f, 7.23603647e-03f, 2.63092220e-01f, 6.09883592e-02f, 2.27900520e-01f, -1.55000374e-01f, 4.36743349e-02f, 6.26043230e-02f,
  -1.26058623e-01f, 1.06434591e-01f, 1.32591546e-01f, 9.02682021e-02f, -2.42006276e-02f, -1.24609560e-01f, 1.44721195e-02f, -2.38192230e-01f, -2.19503298e-01f, 1.31945042e-02f,
  -4.23330516e-02f, -1.22790419e-01f, -8.01127553e-02f, -8.26057866e-02f, 8.83638952e-03f, 2.06599515e-02f, 4.85271886e-02f, 6.88707223e-04f, 1.18361831e-01f, -1.72074378e-01f,
  8.21083263e-02f, -1.21626832e-01f, 1.76503271e-01f, 9.11841094e-02f, -1.17764011e-01f, 1.11979388e-01f, 6.44327924e-02f, 5.03918156e-02f, -3.27591822e-02f, -3.64376567e-02f,
  1.26747293e-02f, -1.18123971e-01f, -1.70937449e-01f, -1.01842806e-01f, -1.86975539e-01f, -2.03969046e-01f, 1.35439709e-01f, -1.46642476e-01f, -7.12651685e-02f, 7.50483051e-02f,
  -9.01745036e-02f, 1.13114096e-01f, 1.27474934e-01f, -6.20332025e-02f, -1.32404700e-01f, -1.60506219e-01f, -3.68151739e-02f, 1.46509865e-02f, 1.75784722e-01f, 1.69598222e-01f,
  -2.42333516e-01f, -2.58813202e-01f, -1.29334986e-01f, -4.14840654e-02f, -5.14826141e-02f, 1.24617577e-01f, -4.51099724e-02f, 2.08984777e-01f, -4.35390249e-02f, 1.69103369e-01f,
  2.17337608e-01f, -2.45964557e-01f, 3.92182358e-02f, 9.09066200e-02f, -1.73700362e-01f, -1.58579081e-01f, 1.25378609e-01f, -7.47879222e-02f, -4.46333289e-02f, -9.30684879e-02f,
  9.84437168e-02f, -1.46204337e-01f, 1.29398376e-01f, -5.17867580e-02f, -4.05666046e-02f, 3.27599831e-02f, 7.27336202e-03f, 4.69958149e-02f, -1.58277934e-03f, -1.70444727e-01f,
  -9.14228559e-02f, 2.42623910e-02f, 5.57111502e-02f, -1.13224000e-01f, -1.04702059e-02f, -1.60906643e-01f, 1.50649041e-01f, 2.04210840e-02f, -3.96030061e-02f, 3.07065789e-02f,
  3.52428183e-02f, 2.75212917e-02f, 1.65208817e-01f, -4.45086993e-02f, -5.16366586e-02f, 1.16017096e-01f, -1.01869859e-01f, -6.66884109e-02f, -1.34491742e-01f, -6.94362894e-02f,
  9.95763764e-02f, 1.03879161e-01f, -7.80736282e-02f, 1.07824523e-02f, -1.65455993e-02f, 2.58906707e-02f, 7.60185942e-02f, -8.06466639e-02f, -6.75294623e-02f, 1.80015862e-01f,
  -1.50668174e-01f, 5.41710220e-02f, 1.64061502e-01f, 1.42403528e-01f, 5.47942780e-02f, -2.13999689e-01f, -7.46833086e-02f, -1.87572137e-01f, -1.48818448e-01f, 1.58984717e-02f,
  1.04979813e-01f, -1.97318912e-01f, -4.43476662e-02f, -9.88904387e-02f, 2.51504499e-02f, 4.05427255e-03f, -4.07928675e-02f, -5.69212884e-02f, -1.63552731e-01f, -6.12541512e-02f,
  1.61496982e-01f, 3.02969804e-03f, 3.61191900e-03f, -9.68422219e-02f, -4.29901332e-02f, 1.10184185e-01f, -7.00391084e-02f, -1.30090490e-01f, 7.41475150e-02f, -6.34118542e-02f,
  7.08075985e-02f, -2.49725906e-03f, 1.69276610e-01f, -1.46054715e-01f, 9.08028102e-04f, -1.68328747e-01f, -1.68246254e-01f, -8.14574137e-02f, 1.58881977e-01f, 2.95379926e-02f,
  -1.32230163e-01f, 1.06400894e-02f, -1.37178645e-01f, -3.54385488e-02f, -5.69351986e-02f, 1.25876218e-01f, -1.00450814e-01f, 4.68080305e-02f, -7.27619454e-02f, -2.49104612e-02f,
  -1.58103123e-01f, 1.31826937e-01f, -7.28459358e-02f, -1.32767305e-01f, -4.20461781e-02f, -1.08679742e-01f, 5.94099090e-02f, 8.72478113e-02f, 1.58222932e-02f, 6.14583939e-02f,
  4.72473428e-02f, 1.50266290e-01f, -1.26124397e-01f, 7.54047744e-03f, 1.75431609e-01f, -3.13206166e-02f, -2.76064217e-01f, 1.67033494e-01f, -1.27758279e-01f, 1.50515642e-02f,
  -1.31599963e-01f, 3.15128833e-01f, 3.41433287e-01f, 2.02404827e-01f, 1.15945421e-01f, -1.19207896e-01f, -2.42156237e-01f, 1.28020585e-01f, -8.05651769e-02f, 1.90455034e-01f,
  8.71788710e-02f, -2.37845913e-01f, -8.84990171e-02f, -8.16131085e-02f, -2.91350782e-02f, -8.68120119e-02f, 1.31459907e-01f, -1.78338531e-02f, 5.37150763e-02f, 1.29161878e-02f,
  -8.22048411e-02f, 7.11069331e-02f, 3.28240693e-02f, 3.26027498e-02f, -1.74050387e-02f, 1.83902637e-04f, 5.04186414e-02f, -1.76412880e-01f, 8.61118510e-02f, 1.44560367e-01f,
  -9.92458537e-02f, 2.11743526e-02f, -6.01351336e-02f, 3.17932218e-02f, 5.11510745e-02f, -9.46528465e-03f, -6.34675100e-02f, -1.68396793e-02f, -1.09460585e-01f, 1.10182717e-01f,
  2.34553637e-03f, 1.39538683e-02f, 4.82313558e-02f, -9.63094737e-03f, -1.00151442e-01f, -6.48731589e-02f, 2.62018200e-03f, -4.67542931e-02f, 6.89860135e-02f, 5.87761663e-02f,
  -7.09015578e-02f, -1.61723733e-01f, -3.41627970e-02f, -6.63071722e-02f, -7.28369271e-03f, 8.11346248e-02f, 2.18491070e-02f, -1.10108010e-01f, 1.16056688e-01f, -1.82003558e-01f,
  -2.44599313e-01f, 1.04845256e-01f, -1.39666498e-02f, 2.27849297e-02f, -1.03722396e-03f, 1.60988376e-01f, 4.17960957e-02f, 9.91959311e-03f, 1.01245075e-01f, 3.71027216e-02f,
  -8.99558607e-03f, -5.38596548e-02f, 3.06143938e-03f, 6.00365959e-02f, 7.15539977e-02f, -7.85610825e-02f, 9.77059603e-02f, -2.00144518e-02f, -1.83241144e-01f, -2.27278750e-02f,
  1.75750591e-02f, -9.37831029e-02f, 2.00227834e-02f, -2.20668182e-01f, 8.87015760e-02f, 7.82713890e-02f, -8.73339623e-02f, 8.69742855e-02f, 4.18039896e-02f, -8.77106115e-02f,
  1.36724859e-02f, -6.04860596e-02f, 9.16898325e-02f, 1.03534609e-01f, 6.39798492e-02f, -1.12454921e-01f, 5.01964986e-02f, 1.23101600e-01f, 1.84985667e-01f, 1.39877424e-01f,
  1.44311726e-01f, -7.95166045e-02f, 6.50696680e-02f, 6.79632574e-02f, -4.39487100e-02f, -5.32089397e-02f, -5.13409041e-02f, -5.61576858e-02f, -1.77537978e-01f, 4.47231196e-02f,
  -8.48728605e-03f, -1.01011470e-01f, 1.06463715e-01f, -5.00370339e-02f, -1.07147321e-01f, 9.13672708e-03f, 6.99391887e-02f, -1.33268967e-01f, -1.33622554e-03f, 1.53661922e-01f,
  -2.32510944e-03f, -6.43453822e-02f, 1.11691587e-01f, 3.11498139e-02f, -1.26513690e-01f, 1.70165360e-01f, -1.41875237e-01f, -2.74484962e-01f, 1.84105963e-01f, 1.25513881e-01f,
  6.60533085e-02f, 1.77485973e-01f, -3.72800045e-02f, -8.39637220e-02f, -6.52023330e-02f, 4.71903151e-03f, -1.47869540e-02f, 8.81609693e-02f, -6.73911721e-02f, -1.99128330e-01f,
  7.27990596e-03f, -2.92967204e-02f, -7.94370323e-02f, 7.48865008e-02f, -3.57517065e-03f, 1.02109186e-01f, 1.78376436e-01f, -6.57290816e-02f, 1.82143360e-01f, -2.37717405e-02f,
  7.65606165e-02f, -6.72901571e-02f, 7.08899722e-02f, 6.17204420e-02f, 2.17512429e-01f, -4.15364541e-02f, 6.74405247e-02f, 3.34569253e-02f, -8.45037922e-02f, 8.86515155e-03f,
  1.03363439e-01f, 5.49157225e-02f, 1.40981197e-01f, 5.17072938e-02f, 3.45933326e-02f, 9.52523872e-02f, 1.78705982e-03f, 9.68413800e-02f, -3.09929233e-02f, 2.43315883e-02f,
  -1.33234471e-01f, -8.55708271e-02f, 3.50592239e-03f, 8.93762857e-02f, 9.43343043e-02f, -3.81666534e-02f, 2.38680001e-02f, -2.43476946e-02f, 6.29312024e-02f, -1.22341597e-02f,
  1.59456767e-02f, 3.64335217e-02f, -1.79787382e-01f, -1.50533900e-01f, -2.26013400e-02f, -4.61015925e-02f, -5.40822782e-02f, 1.60234079e-01f, 2.63265848e-01f, -1.41945094e-01f,
  5.62579818e-02f, -2.04651907e-01f, 1.80603474e-01f, -2.52410322e-01f, -2.30632633e-01f, 2.89259907e-02f, -7.10302889e-02f, 7.02465177e-02f, 7.15268552e-02f, 1.27083570e-01f,
  2.03515515e-01f, -9.90893841e-02f, -3.52273703e-01f, 1.54723004e-01f, 1.39822677e-01f, -7.31334984e-02f, 1.50625154e-01f, -7.61073455e-02f, -1.79014310e-01f, -8.87857005e-02f,
  -7.11152405e-02f, 2.36239716e-01f, 6.69291243e-02f, -2.19375566e-02f, -1.41755883e-02f, -3.12647969e-02f, 8.31252262e-02f, 1.73423870e-03f, -5.66155165e-02f, 4.32975888e-02f,
  -1.84907556e-01f, -9.48312283e-02f, 5.17877638e-02f, -5.80093861e-02f, 8.58743116e-02f, -1.87179272e-03f, -2.02930883e-01f, -6.79771751e-02f, -1.12981223e-01f, 9.45735052e-02f,
  -3.86457704e-02f, -1.00713976e-01f, 5.97077310e-02f, 3.10347322e-02f, 3.16375941e-02f, -1.34753615e-01f, 6.65225787e-04f, -1.27457678e-01f, -1.62376314e-01f, -1.46910146e-01f,
  -1.39696091e-01f, -6.06296817e-03f, -8.55314285e-02f, 3.27947401e-02f, 1.99297909e-02f, 8.82825926e-02f, -6.18174896e-02f, 4.57241163e-02f, 9.00466144e-02f, 5.79149611e-02f,
  1.87508583e-01f, 1.79187417e-01f, 2.85345595e-02f, -3.35440189e-02f, 3.26426953e-01f, 2.03269586e-01f, 7.98709970e-03f, -1.18027419e-01f, -1.46199707e-02f, -8.87139812e-02f,
  4.45345640e-02f, -1.60745338e-01f, 1.07029686e-02f, -8.22637230e-02f, -4.00408544e-02f, 4.80786115e-02f, 1.13654137e-01f, -1.50691897e-01f, 3.12956423e-01f, 3.91994230e-02f,
  -6.67478964e-02f, 2.90089194e-03f, -4.56985570e-02f, 1.29566759e-01f, 9.77630094e-02f, 3.10846806e-01f, 1.70927212e-01f, 1.56004503e-01f, 1.59111857e-01f, 1.13205492e-01f,
  -4.90796976e-02f, 1.47551537e-01f, -4.11401838e-02f, -1.08232647e-02f, -1.86749876e-01f, 1.63144507e-02f, 8.70987549e-02f, 1.62444144e-01f, 1.30493268e-01f, 9.97916386e-02f,
  -2.86696069e-02f, -8.01366493e-02f, 1.30084798e-01f, 1.61972210e-01f, -9.92034599e-02f, -8.72195214e-02f, 2.57155430e-02f, -4.46085120e-03f, -1.51655465e-01f, 1.75937207e-03f,
  -1.30865112e-01f, 1.40046999e-01f, -8.94313604e-02f, 4.34114560e-02f, -5.48933726e-03f, -1.65111974e-01f, -2.83751599e-02f, -1.48378402e-01f, -1.81864575e-01f, -8.42721760e-02f,
  1.28014371e-01f, 1.97345093e-01f, -1.77981824e-01f, -1.21993892e-01f, -7.46879131e-02f, -2.89196633e-02f, -2.52198368e-01f, -5.20907417e-02f, -1.56197533e-01f, 4.18089367e-02f,
  -1.26360402e-01f, 2.75001258e-01f, 2.13752270e-01f, 1.68584704e-01f, 3.67006846e-02f, 1.44126520e-01f, 1.92323863e-03f, -4.38267505e-03f, 4.70216349e-02f, 4.07152176e-02f,
  1.43558949e-01f, -9.18354467e-02f, -1.65084228e-01f, 5.91240749e-02f, 3.87904160e-02f, 1.05810627e-01f, 8.96052271e-02f, 1.01515107e-01f, 2.26519421e-01f, -2.36238495e-01f,
  -1.27302185e-01f, -9.57608670e-02f, -5.28340116e-02f, -1.20654665e-02f, -1.38305901e-02f, 3.75017598e-02f, 5.00067556e-03f, -2.53536962e-02f, 1.06900312e-01f, 2.18211323e-01f,
  -3.72393765e-02f, -1.04180574e-01f, 4.37369235e-02f, 4.56061475e-02f, 5.89106753e-02f, 4.83306758e-02f, 7.47139007e-03f, -1.32949889e-01f, 3.19050252e-02f, 7.03590065e-02f,
  3.86610515e-02f, 4.02393714e-02f, 8.53347778e-02f, 1.93005384e-04f, 5.40955998e-02f, -3.24120559e-02f, -1.42099112e-01f, -9.42947119e-02f, 1.02519803e-02f, -6.39990792e-02f,
  8.73490889e-03f, -4.54711989e-02f, 3.58168669e-02f, 3.83373303e-03f, 7.13267624e-02f, 7.08230166e-03f, -8.57182667e-02f, -8.59246328e-02f, 3.37086134e-02f, 1.04764931e-01f,
  1.82248637e-01f, 1.26866430e-01f, -1.33129105e-01f, -3.07563692e-01f, 1.82829574e-02f, -8.59418511e-02f, 3.35768834e-02f, -1.32988602e-01f, 7.92325288e-02f, 1.96724266e-01f,
  6.31883964e-02f, 1.38773816e-02f, 2.39078015e-01f, -1.43978059e-01f, 1.11306369e-01f, -1.08019531e-01f, 2.81867050e-02f, 3.85314673e-02f, 1.38438001e-01f, 6.41626716e-02f,
  1.21500887e-01f, -3.62181775e-02f, -2.33960412e-02f, 9.51138586e-02f, -4.37407289e-03f, 6.79164752e-02f, 7.77843148e-02f, -9.06208679e-02f, -9.65714157e-02f, -6.74439967e-02f,
  4.37244922e-02f, -1.32055938e-01f, 8.94471537e-03f, -1.26843061e-02f, -1.71904936e-01f, -9.56565961e-02f, 4.85925302e-02f, -8.03626999e-02f, -3.59994583e-02f, -9.35268402e-02f,
  1.63026676e-02f, 1.24800578e-01f, -1.71978921e-01f, 5.85605837e-02f, 1.06551461e-01f, -3.84879522e-02f, -1.87741727e-01f, -7.73837715e-02f, 8.83474573e-02f, 1.17508940e-01f,
  -1.34785905e-01f, 2.52336618e-02f, -1.26151532e-01f, -1.38568759e-01f, -9.94498879e-02f, -1.37563720e-01f, -4.38755192e-03f, 1.33565888e-01f, 6.56859279e-02f, -1.44935414e-01f,
  -5.75014949e-02f, -3.28907520e-02f, 1.95689738e-01f, -1.11879930e-01f, -5.24895713e-02f, -1.42855361e-01f, 2.05636322e-01f, -6.55739475e-03f, 2.27188319e-02f, 7.53380358e-02f,
  -2.36505810e-02f, 2.15149656e-01f, 3.32794860e-02f, -1.06652953e-01f, -1.67453080e-01f, -1.70687482e-01f, -1.41900077e-01f, 8.86259452e-02f, -1.22468814e-01f, 5.52139804e-02f,
  -2.27052774e-02f, 5.25495969e-02f, -4.62705866e-02f, -6.06920123e-02f, 1.70704082e-03f, -5.11181913e-02f, -3.53913642e-02f, 1.20361179e-01f, 1.85088351e-01f, 9.68519831e-04f,
  -7.53994882e-02f, 7.63020366e-02f, 5.98448217e-02f, 3.24044786e-02f, 8.70740712e-02f, -6.77261353e-02f, 4.93609123e-02f, -4.46028262e-02f, -2.77661886e-02f, 9.02373344e-02f,
  1.02635942e-01f, -8.51028487e-02f, 3.47782969e-02f, 5.53583689e-02f, 9.45585147e-02f, 3.64604443e-02f, -2.71662455e-02f, 3.50150652e-02f, -6.40508756e-02f, -9.57593322e-02f,
  -8.82530734e-02f, 7.42913708e-02f, -1.25582129e-01f, 3.95551063e-02f, -3.80904600e-02f, -1.20329820e-01f, -1.63503721e-01f, 9.09041241e-02f, -1.31403357e-01f, -1.03535093e-01f,
  6.84726834e-02f, -3.64313945e-02f, 5.10062575e-02f, 1.90326124e-01f, 1.79407746e-02f, -1.51321609e-02f, 4.86158654e-02f, 2.30265409e-02f, -5.41335111e-03f, -4.29993235e-02f,
  1.16481081e-01f, -9.56932828e-02f, 1.49814859e-01f, 2.12953478e-01f, 1.13295458e-01f, -1.40697602e-02f, -1.05853610e-01f, -3.03144958e-02f, -1.15791149e-01f, 2.48760924e-01f,
  -6.93269223e-02f, 1.86468542e-01f, 1.13982841e-01f, -3.27806532e-01f, 1.86547428e-01f, 4.75856513e-02f, -1.40494034e-01f, -1.27248645e-01f, 1.34988129e-01f, 5.28525673e-02f,
  1.74362004e-01f, 8.57932717e-02f, 1.02095038e-01f, 5.61078303e-02f, 6.34021088e-02f, 1.54548055e-02f, -3.81366573e-02f, -1.41099170e-01f, 1.05227800e-02f, -5.12289591e-02f,
  -1.12716313e-02f, 1.89386114e-01f, 9.65609998e-02f, 1.51046261e-01f, -1.27770573e-01f, 1.84322540e-02f, 1.67059377e-01f, 7.30161592e-02f, 2.91999318e-02f, 8.91260132e-02f,
  -2.16504127e-01f, -1.22475818e-01f, 3.54731083e-02f, -1.05179109e-01f, -2.03179345e-01f, 1.00348361e-01f, -2.62807645e-02f, 1.26402112e-04f, 7.33582824e-02f, -9.38134193e-02f,
  -7.46415481e-02f, 9.40925106e-02f, 6.44122064e-02f, -7.58122504e-02f, -7.93021992e-02f, 8.43428969e-02f, -1.28496259e-01f, 1.62175938e-01f, -1.60125688e-01f, 1.15300864e-01f,
  1.58195093e-01f, -4.76189442e-02f, 4.02674079e-02f, -7.12834895e-02f, 6.93619326e-02f, -7.01526031e-02f, 4.01652008e-02f, 1.88334927e-01f, 2.64021307e-01f, 2.03391030e-01f,
  1.42524168e-01f, -1.85147792e-01f, -3.23959053e-01f, 1.58907641e-02f, -3.13260853e-01f, 1.65010005e-01f, 9.25809443e-02f, 2.47033127e-02f, -1.40966773e-01f, -9.62617174e-02f,
  -3.72218490e-02f, -6.63900152e-02f, 1.38668731e-01f, -3.16232815e-02f, 2.33455151e-02f, -2.42670346e-02f, -1.00319996e-03f, 4.06108722e-02f, 9.83171761e-02f, 5.32508306e-02f,
  1.81702003e-02f, -1.05900235e-01f, -1.10526405e-01f, 3.81328687e-02f, 9.58984811e-03f, 6.29396290e-02f, -1.31664068e-01f, 1.37161851e-01f, -4.03753929e-02f, 6.28187060e-02f,
  -1.24016918e-01f, 2.36948766e-02f, 1.60784215e-01f, -6.50791749e-02f, 4.64265943e-02f, 1.11815266e-01f, 1.41540036e-01f, 1.12783924e-01f, -1.00157492e-01f, 7.68508315e-02f,
  7.57432170e-03f, -4.93668914e-02f, -9.92233977e-02f, 6.73618764e-02f, -2.27819234e-02f, 3.40586156e-02f, 4.56679985e-02f, 8.95758346e-02f, 3.59436236e-02f, 8.35983977e-02f,
  2.05803122e-02f, -1.73201889e-01f, 1.08395927e-01f, 1.70203552e-01f, -1.00306896e-02f, 5.97897954e-02f, 2.47036994e-01f, -3.34378448e-03f, 1.59673229e-01f, -1.76964596e-01f,
  2.68307775e-01f, -2.25146711e-01f, -2.33368367e-01f, -8.80156383e-02f, -6.59047961e-02f, -7.69838244e-02f, 4.51637916e-02f, -4.15757224e-02f, 1.78129852e-01f, 3.17878500e-02f,
  -1.78823039e-01f, -7.32709989e-02f, 1.08507842e-01f, 1.01714566e-01f, 1.44257873e-01f, 6.20974489e-02f, 4.72705886e-02f, 9.73859355e-02f, -1.86028063e-01f, 1.76578075e-01f,
  -4.52065188e-03f, 4.24963422e-02f, -7.90949725e-03f, -8.79271030e-02f, -6.17969148e-02f, -1.24610402e-01f, 3.85184512e-02f, 7.22979531e-02f, -1.24249063e-01f, -1.80937812e-01f,
  -7.76923820e-03f, 1.31406561e-01f, 1.49333149e-01f, -7.53665790e-02f, -1.61079556e-01f, -2.10635196e-02f, -1.22165836e-01f, 5.15252203e-02f, 5.56784272e-02f, 1.07541494e-01f,
  -1.16067544e-01f, -1.18873261e-01f, -1.71563447e-01f, -1.57702297e-01f, 5.36831878e-02f, -1.08096592e-01f, 6.64430410e-02f, 1.07053988e-01f, -2.88541820e-02f, -1.15871422e-01f,
  1.04894184e-01f, 7.91943222e-02f, -1.11811519e-01f, 1.26244113e-01f, 1.71420500e-01f, 3.97955850e-02f, -3.58435623e-02f, 1.06858492e-01f, 6.96506770e-03f, 5.12941554e-02f,
  -6.03476726e-02f, -2.22303137e-01f, 7.64105394e-02f, 3.07385057e-01f, -8.58956501e-02f, -1.56526864e-01f, -8.90507624e-02f, -5.55793904e-02f, 1.30607635e-01f, -1.68617353e-01f,
  -6.75303712e-02f, -1.78351849e-01f, -1.39488727e-01f, -2.74969749e-02f, -6.59552962e-02f, 9.35652182e-02f, -7.35412985e-02f, 1.44610628e-01f, -9.24512893e-02f, 3.74872796e-02f,
  6.87523037e-02f, -7.42944628e-02f, -5.17360494e-03f, 1.25343755e-01f, 1.02724209e-01f, 5.27916476e-02f, -7.10687488e-02f, 1.76050141e-01f, 3.37091051e-02f, 2.76035890e-02f,
  -1.78052992e-01f, -1.12640345e-02f, -8.43360126e-02f, -1.20692819e-01f, 1.44666255e-01f, -2.99928989e-02f, 3.51470546e-03f, -4.69547659e-02f, -6.55269250e-02f, 1.30007882e-02f,
  1.78369612e-01f, 9.60494503e-02f, -2.06617713e-01f, -1.32593401e-02f, -4.62715700e-02f, 4.09406684e-02f, 2.12320928e-02f, 9.22979340e-02f, -9.93998572e-02f, 6.30208030e-02f,
  4.51692715e-02f, -3.56597081e-02f, -1.09553486e-01f, -1.19280078e-01f, 4.66641672e-02f, -1.16710097e-01f, -7.51819164e-02f, -6.18952140e-02f, 9.02789980e-02f, -7.39677995e-02f,
  -9.58659425e-02f, -6.80331215e-02f, -7.43561797e-03f, -7.42978752e-02f, -2.30319470e-01f, -3.83147635e-02f, 1.13457970e-01f, 4.19909030e-01f, -3.94213498e-01f, 2.00443804e-01f,
  2.40921944e-01f, 1.82006553e-01f, 1.92267641e-01f, -1.23696245e-01f, -2.41102744e-02f, -1.13501981e-01f, -1.35026157e-01f, 5.57793081e-02f, 1.19047044e-02f, 1.93275556e-01f,
  -1.59163937e-01f, -2.68325303e-02f, -7.97228962e-02f, -4.07478325e-02f, -2.11738367e-02f, -4.54884246e-02f, 3.27194259e-02f, -1.66671246e-01f, -8.10164437e-02f, -3.39948535e-02f,
  -1.44612044e-01f, 7.10078806e-04f, 8.19365755e-02f, 2.01448023e-01f, 8.77992623e-03f, 3.18150707e-02f, -1.21907778e-02f, -8.09798464e-02f, 7.53474310e-02f, 6.45392016e-02f,
  -3.33959982e-02f, -6.38165176e-02f, -9.86447856e-02f, 9.20347497e-02f, 1.42567214e-02f, -2.79143769e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -3.60141955e-02f, 1.37162581e-01f, -8.36538076e-02f, 1.55028448e-01f, 5.07477932e-02f, 6.43158033e-02f, -6.67361077e-03f, 8.18632618e-02f, 8.07292610e-02f, 1.18352704e-01f,
  4.91116457e-02f, -9.11080558e-03f, 2.29240656e-02f, -8.65846351e-02f, 1.41653288e-02f, 8.56391415e-02f, 6.23523556e-02f, -3.59438881e-02f, 7.57045969e-02f, -2.09495798e-01f,
  8.41731131e-02f, -6.92660362e-02f, -1.86814949e-01f, 1.42376516e-02f, -1.18595418e-02f, 2.30072215e-02f, -1.00415960e-01f, 9.40505341e-02f, 4.35425825e-02f, 1.18370034e-01f,
  2.88599841e-02f, -1.21574448e-02f, -1.77276611e-01f, -1.05665721e-01f, -1.62874945e-02f, 8.50698128e-02f, -1.66787907e-01f, 5.96955679e-02f, 2.25288281e-03f, 9.93106440e-02f,
  -1.09783337e-01f, 6.35250211e-02f, 5.77768646e-02f, 3.45173152e-03f, -5.30042127e-02f, -1.80274665e-01f, -4.37843800e-02f, -4.25199084e-02f, -5.72828613e-02f, -3.41053195e-02f,
  -1.64521753e-03f, 6.12650998e-02f, 4.40186523e-02f, -5.51360622e-02f, 9.29776877e-02f, 8.52853805e-02f, -3.99339683e-02f, -1.13677010e-01f, -6.50415570e-02f, 7.00477511e-02f,
  8.93107355e-02f, 2.74597444e-02f, 8.17561448e-02f, -3.07683251e-03f, 8.84925723e-02f, 1.36473984e-01f, -9.15678069e-02f, -9.21961386e-03f, -1.32564399e-02f, -1.70579590e-02f,
  -9.55391824e-02f, 2.41715717e-03f, -4.37815711e-02f, -4.29242253e-02f, 1.12973303e-01f, 2.88640466e-02f, -3.01376805e-02f, -5.15967011e-02f, -6.78702071e-02f, 1.45751992e-02f,
  1.31520540e-01f, 8.23579207e-02f, -2.11339400e-04f, -1.08119875e-01f, 7.30270222e-02f, 4.23682481e-02f, -7.20678046e-02f, -2.37678625e-02f, -1.60516426e-02f, 2.95575466e-02f,
  -1.53726116e-01f, 1.09184727e-01f, 3.86391915e-02f, 1.19801857e-01f, 5.58950752e-02f, 4.77038957e-02f, 3.71204391e-02f, 1.07683361e-01f, -5.39551042e-02f, -5.14045916e-02f,
  -9.05571580e-02f, 1.09527774e-01f, -6.45170659e-02f, 1.06915727e-01f, -7.39748478e-02f, 1.08082376e-01f, -4.50714044e-02f, -8.05759337e-03f, 1.50999635e-01f, -1.01710327e-01f,
  -4.94337715e-02f, 1.35642916e-01f, 8.76616240e-02f, 1.20313317e-01f, -2.83452682e-02f, 2.48167887e-02f, -7.10203499e-02f, 5.39995730e-03f, 2.69396026e-02f, 6.38976619e-02f,
  -1.57824554e-03f, -8.88253599e-02f, -3.83552499e-02f, -9.37321968e-03f, 1.45579055e-02f, -7.29462579e-02f, -2.13944353e-02f, -1.09058239e-01f, 8.92344341e-02f, 1.47241056e-01f,
  1.20588571e-01f, -4.86837514e-02f, -1.65696666e-02f, 1.21259928e-01f, 1.47342935e-01f, -1.71089321e-02f, 1.32655159e-01f, 2.79981494e-02f, -8.01007971e-02f, 9.13780555e-02f,
  -5.99848777e-02f, 6.63352162e-02f, -2.37149335e-02f, 1.54451817e-01f, 1.44538701e-01f, 5.67080006e-02f, 2.02749297e-01f, -8.88482928e-02f, -4.02959064e-02f, 1.09614715e-01f,
  -1.39690340e-01f, -1.65712342e-01f, -7.06455857e-02f, 2.64530033e-01f, -2.85671875e-02f, 8.23396370e-02f, -4.15319279e-02f, -1.69945404e-01f, 3.07904556e-02f, 8.97417739e-02f,
  -8.11934918e-02f, -4.47675399e-02f, -3.69154885e-02f, -4.93652979e-03f, -3.63451254e-04f, 2.38719106e-01f, 1.80199698e-01f, 1.14725962e-01f, -9.84607171e-03f, -2.07364392e-02f,
  -1.11174146e-02f, -3.06157079e-02f, -2.13016775e-02f, 5.20626791e-02f, 4.91589233e-02f, 2.33609583e-02f, -2.06652395e-02f, 5.35786562e-02f, 1.20591097e-01f, 1.46658316e-01f,
  -1.52080134e-01f, 9.29845944e-02f, -1.40091315e-01f, 6.75643533e-02f, 3.95477489e-02f, 6.55874982e-02f, -1.28036626e-02f, 7.25705251e-02f, 6.20039478e-02f, -1.33844882e-01f,
  1.75118819e-02f, 6.35921657e-02f, 1.11110099e-01f, 7.39455149e-02f, 1.18102476e-01f, -1.87115241e-02f, 3.27894352e-02f, 1.48043871e-01f, 5.46683446e-02f, 2.29522407e-01f,
  2.33008802e-01f, -1.07081449e-02f, 4.64107543e-02f, 1.30601332e-01f, 4.58116643e-03f, 1.08751163e-01f, 9.83169451e-02f, -8.90745297e-02f, 1.54807391e-02f, 3.41789611e-02f,
  2.70698648e-02f, 2.51418203e-01f, 2.11778402e-01f, -1.57054484e-01f, -1.63225323e-01f, -1.25043228e-01f, 1.91084608e-01f, 1.61648262e-02f, 1.06237017e-01f, 8.65599141e-02f,
  1.38995340e-02f, 1.86586037e-01f, 1.74487397e-01f, -1.57037526e-01f, -1.33061633e-01f, 3.72501910e-02f, -1.65745020e-02f, 2.30047211e-01f, 2.13635728e-01f, -1.37503877e-01f,
  8.06148499e-02f, 1.36187002e-01f, -7.94278756e-02f, -3.47917923e-03f, 1.42262220e-01f, 2.18212664e-01f, -1.22098327e-01f, 3.10862154e-01f, -3.96566354e-02f, -9.37441140e-02f,
  -5.61316051e-02f, 5.33572286e-02f, 7.11554335e-03f, -4.77932505e-02f, 1.59593210e-01f, -7.65959024e-02f, 6.10333420e-02f, -3.95812429e-02f, -2.16296054e-02f, 1.30442306e-01f,
  1.43819628e-02f, -3.84275205e-02f, -1.12544550e-02f, 4.25558770e-03f, 2.77612984e-01f, -8.60484466e-02f, 1.96628407e-01f, 7.11122900e-02f, -2.84854267e-02f, 2.03908104e-02f,
  1.49766371e-01f, 1.12603858e-01f, 2.42979676e-01f, -6.39221922e-04f, 1.29020691e-01f, 2.42090464e-01f, 8.45005084e-03f, -6.03934117e-02f, -4.64152358e-03f, 1.86968952e-01f,
  8.06953236e-02f, 1.38681412e-01f, 2.18469962e-01f, 2.58425735e-02f, 1.59589335e-01f, -1.54289141e-01f, -2.49039829e-01f, -2.71275304e-02f, -5.43680452e-02f, -9.98632014e-02f,
  -1.16077952e-01f, 2.75385022e-01f, -1.63290069e-01f, 3.03288251e-02f, -1.32758051e-01f, -1.04566135e-01f, 8.15213323e-02f, 1.10976666e-01f, 1.94465756e-01f, 1.43803116e-02f,
  7.83572420e-02f, -1.29238591e-01f, -7.32094124e-02f, 2.68890709e-01f, 1.31069481e-01f, 7.94562325e-02f, 3.61004658e-02f, -1.06626511e-01f, -3.28434259e-02f, 9.28501934e-02f,
  -4.40248176e-02f, -1.20455191e-01f, -1.41801432e-01f, 1.99205838e-02f, 7.31093809e-02f, 1.57111168e-01f, -1.13082062e-02f, 5.43988161e-02f, -1.72783092e-01f, 4.40965816e-02f,
  1.04261987e-01f, 5.39885834e-02f, 7.38629028e-02f, 1.51325725e-02f, -1.45200631e-02f, -1.05981693e-01f, 1.55592874e-01f, 1.16884306e-01f, -2.75595300e-02f, -7.65176490e-02f,
  4.50255945e-02f, -1.02430075e-01f, -1.04161628e-01f, -1.29446576e-04f, -6.88477978e-02f, -3.47914472e-02f, -1.03709968e-02f, -6.69867545e-03f, 3.09872651e-03f, 2.66582370e-02f,
  -1.31447732e-01f, 5.48499972e-02f, 3.53337638e-03f, 2.41674799e-02f, 9.27529633e-02f, -5.57980947e-02f, -2.76918914e-02f, 5.97636290e-02f, -1.25336647e-01f, -1.03731982e-01f,
  -1.65031198e-03f, -1.11428961e-01f, -7.95755163e-02f, -6.06126562e-02f, -3.82996164e-02f, -1.19404592e-01f, -6.74127564e-02f, 1.13326162e-02f, 7.09595606e-02f, 9.54822153e-02f,
  6.72955662e-02f, -9.82385352e-02f, -9.65976864e-02f, 1.11789316e-01f, 1.09070942e-01f, -3.59275676e-02f, 3.62891518e-02f, 2.44507585e-02f, 2.39175465e-03f, -8.27662349e-02f,
  -4.40341681e-02f, 4.22680601e-02f, -1.26022019e-03f, 9.58110318e-02f, -1.18363284e-01f, 1.05524406e-01f, -1.98320150e-02f, 4.18006256e-02f, -2.29703151e-02f, -5.56508414e-02f,
  -3.46883461e-02f, -1.00255199e-01f, -7.56920874e-02f, 6.38328865e-02f, -3.05005647e-02f, 1.16379000e-01f, 6.62248880e-02f, -3.13612409e-02f, 5.01660816e-02f, -1.24794714e-01f,
  -3.81101444e-02f, -1.04189426e-01f, -7.67166391e-02f, 1.09239459e-01f, -1.84124969e-02f, -3.63821276e-02f, 1.32908285e-01f, -5.35988621e-02f, 3.26283500e-02f, -4.87217419e-02f,
  4.16863374e-02f, -2.33719237e-02f, -1.16715573e-01f, -3.79129057e-03f, -4.55737561e-02f, -7.70705938e-02f, 8.88548344e-02f, -3.00421864e-02f, 8.38743299e-02f, -1.32256672e-01f,
  3.83522809e-02f, 7.80526027e-02f, 4.35027033e-02f, -1.24213472e-03f, 3.69336456e-02f, -3.49604455e-03f, 8.07104409e-02f, -1.88109577e-02f, 8.70666131e-02f, -1.94172964e-01f,
  1.55740842e-01f, -1.32566959e-01f, -9.99475457e-03f, -9.09603164e-02f, -9.51586366e-02f, 7.00860918e-02f, -3.82139012e-02f, 6.07985109e-02f, 1.51970193e-01f, 4.54317294e-02f,
  -7.16334954e-02f, -1.21526599e-01f, 2.06108496e-01f, 1.11029498e-01f, 3.72625329e-02f, 4.26132940e-02f, 1.18098713e-01f, 4.43336740e-02f, 1.59422040e-01f, 3.28230470e-01f,
  2.30371207e-01f, -2.86767874e-02f, 1.03830904e-01f, -1.37426574e-02f, -9.38329175e-02f, 6.04769066e-02f, -2.39995886e-02f, 6.23356514e-02f, -1.49904564e-01f, 4.88402955e-02f,
  1.39333785e-01f, 1.55293465e-01f, 2.71651000e-02f, 2.75581442e-02f, 1.41059160e-02f, 3.59729528e-02f, 7.11963233e-03f, 3.87703925e-02f, 6.67377934e-02f, 3.95487510e-02f,
  1.18012115e-01f, -2.19617840e-02f, -2.64424216e-02f, 8.13612416e-02f, 4.46519516e-02f, 3.01228929e-02f, 6.02080673e-02f, -6.65081367e-02f, -5.57642952e-02f, 1.30227609e-02f,
  -8.67596827e-03f, -1.04883693e-01f, -5.40134758e-02f, 7.43459314e-02f, -1.09881252e-01f, -4.01629135e-02f, -5.66180162e-02f, 6.55184165e-02f, 1.08991958e-01f, 4.86867651e-02f,
  4.62902598e-02f, -1.22769333e-01f, 1.07846901e-01f, 1.22880571e-01f, 6.64772168e-02f, 1.15565322e-01f, -7.11449459e-02f, -1.20283417e-01f, 1.04190186e-01f, 1.11641631e-01f,
  -5.19814726e-04f, 7.50889396e-03f, 5.29120862e-02f, -1.23423897e-01f, -1.08092666e-01f, 1.11140944e-01f, -7.83553198e-02f, 4.12985869e-02f, 1.00954644e-01f, -1.07504010e-01f,
  -1.21187285e-01f, -2.79693212e-02f, 9.60738286e-02f, -8.27365518e-02f, -1.23607196e-01f, -1.98267959e-02f, 2.32002791e-02f, -1.06694274e-01f, 1.00503474e-01f, 1.08305633e-01f,
  -5.51881865e-02f, -3.83782163e-02f, -8.58203247e-02f, -3.01529374e-02f, -1.11888245e-01f, -3.26035134e-02f, 9.81954709e-02f, 2.66807266e-02f, 6.75725266e-02f, -2.79444959e-02f,
  -6.46167248e-03f, 1.10085003e-01f, 2.33850062e-01f, -3.29918526e-02f, 7.98278973e-02f, 1.91896498e-01f, 1.69722721e-01f, 8.05326551e-02f, -5.38444966e-02f, -5.81128523e-02f,
  4.87256646e-02f, -4.36137617e-02f, 1.82332993e-01f, 2.48413347e-02f, 1.89099669e-01f, 1.95470959e-01f, 8.06626081e-02f, 1.25427902e-01f, -1.22475298e-02f, 1.74028829e-01f,
  2.92601511e-02f, -1.25772223e-01f, -3.05935368e-02f, -5.86622469e-02f, -4.70226854e-02f, -5.76564595e-02f, -2.00205281e-01f, -2.19070926e-01f, 1.55832767e-01f, 6.72667027e-02f,
  -1.14481211e-01f, -7.75942504e-02f, -3.46607417e-02f, 1.41688436e-01f, 1.07288044e-02f, 7.61538073e-02f, 2.29268879e-01f, -1.80264845e-01f, 4.81594615e-02f, -5.62948845e-02f,
  -3.60167883e-02f, 1.03400752e-01f, -7.15626106e-02f, 3.78025584e-02f, -3.12717967e-02f, -3.60646211e-02f, 4.61539105e-02f, -6.13379404e-02f, 1.38738500e-02f, 4.64027748e-03f,
  3.85659598e-02f, 3.33729424e-02f, -1.18995436e-01f, -2.94568669e-02f, -1.59211457e-02f, 9.21500549e-02f, 1.79087058e-01f, 1.11399174e-01f, -1.12051331e-01f, 6.78486750e-02f,
  2.28702076e-04f, 1.41960420e-02f, 4.11694646e-02f, 1.27453908e-01f, -9.58791096e-03f, -5.10710403e-02f, 3.85926925e-02f, 5.20019457e-02f, -2.58584488e-02f, 2.98631415e-02f,
  1.29106253e-01f, 8.89896601e-02f, 5.27982861e-02f, 9.64879617e-02f, -9.91156250e-02f, -4.25952207e-03f, -1.30138332e-02f, 2.01257050e-01f, 2.87186094e-02f, 1.65782437e-01f,
  6.71389624e-02f, -2.67003234e-02f, -6.36905804e-02f, 1.04234539e-01f, 1.44025475e-01f, -7.61527792e-02f, 1.24577954e-01f, 5.60555905e-02f, -1.28471926e-01f, 4.37125750e-03f,
  -1.09129630e-01f, -1.41908020e-01f, 1.03251681e-01f, 1.75422475e-01f, 3.34835239e-02f, -3.17715146e-02f, -1.37038514e-01f, 8.84767026e-02f, -3.05587687e-02f, 1.66915998e-01f,
  -2.72764489e-02f, 1.69685975e-01f, 6.74491748e-02f, -1.46297812e-01f, -8.91103745e-02f, -6.99484497e-02f, -9.19245631e-02f, -7.16427490e-02f, 8.74755383e-02f, -1.06653839e-01f,
  4.16241176e-02f, 1.15716401e-02f, 2.01671440e-02f, -3.87404859e-02f, 7.51585886e-03f, 1.92664489e-02f, -7.75591061e-02f, -6.33998364e-02f, 1.59393549e-01f, -2.97490843e-02f,
  -5.07945940e-02f, 2.03712985e-01f, 5.43190166e-02f, 8.14438090e-02f, 4.33345698e-02f, 4.63428497e-02f, -5.10522537e-02f, 1.15889041e-02f, -2.58429237e-02f, -6.87161833e-02f,
  1.71536759e-01f, 6.64044023e-02f, 1.96510419e-01f, 1.26187772e-01f, 1.67696536e-01f, 1.13722995e-01f, -1.67304978e-01f, 5.22022210e-02f, 1.84727907e-01f, 1.05823819e-02f,
  -1.54913524e-02f, -5.25398506e-03f, 5.36938086e-02f, 8.56692567e-02f, 1.52140975e-01f, -5.88473491e-02f, -3.37949060e-02f, 1.18372858e-01f, 1.18110113e-01f, 2.00987551e-02f,
  -4.94305231e-02f, -1.59447894e-01f, 2.12929979e-01f, 2.21849993e-01f, -1.18080534e-01f, -3.18117470e-01f, 3.33513856e-01f, 2.40137726e-02f, -1.90643668e-01f, -2.14649141e-01f,
  1.92040950e-02f, 2.26200134e-01f, 1.37863591e-01f, 2.12824360e-01f, 2.62556493e-01f, -2.07243294e-01f, 1.50356576e-01f, -1.59435511e-01f, -2.80669201e-02f, -1.39549617e-02f,
  1.14906229e-01f, -4.86741737e-02f, 1.48628399e-01f, 1.50834590e-01f, -1.97157130e-01f, 1.30521536e-01f, 7.44411955e-03f, 9.77590978e-02f, 1.26761392e-01f, 6.72510266e-02f,
  5.19308001e-02f, -6.14522807e-02f, 1.27539769e-01f, -7.00841367e-04f, 1.11466795e-01f, 1.14059940e-01f, 1.27072617e-01f, -6.10368177e-02f, 1.01777270e-01f, 3.91489789e-02f,
  1.83227673e-01f, 1.77604258e-01f, -2.17438806e-02f, 1.36844754e-01f, -7.06924275e-02f, -7.98152611e-02f, -1.20900318e-01f, -4.97756861e-02f, 8.66191741e-03f, 1.59775950e-02f,
  5.36758043e-02f, 8.98088440e-02f, -1.47439446e-02f, 4.41322587e-02f, 8.05950090e-02f, -1.17363483e-01f, 2.50221901e-02f, -3.67829273e-03f, 1.12899087e-01f, -3.81490402e-03f,
  1.91235878e-02f, 5.68442754e-02f, -9.50806215e-02f, -1.28369585e-01f, -1.23743705e-01f, -5.90171553e-02f, 5.16773649e-02f, -1.35664448e-01f, 4.63529974e-02f, -6.65885806e-02f,
  8.21260884e-02f, -2.02898532e-02f, -9.88574848e-02f, -3.61721441e-02f, 7.82699063e-02f, 9.85839665e-02f, -8.97031277e-02f, 4.43324484e-02f, -9.06581283e-02f, -2.97809951e-02f,
  2.09098272e-02f, -1.16888449e-01f, 1.65349543e-01f, -9.40034837e-02f, -1.65550392e-02f, -5.00147305e-02f, 3.28262225e-02f, 3.26089188e-02f, 1.23845041e-01f, 8.85599628e-02f,
  1.32346928e-01f, -1.14033960e-01f, -1.14692725e-01f, 2.75742784e-02f, 5.86958788e-03f, -5.52082062e-03f, -1.26964360e-01f, 1.22290790e-01f, -1.06039487e-01f, -3.61871123e-02f,
  9.67351496e-02f, -6.73789084e-02f, -8.77192691e-02f, 1.04667448e-01f, 1.00551881e-01f, 5.00207804e-02f, -9.42685828e-02f, 1.16147429e-01f, 2.73799688e-01f, 4.87178862e-02f,
  1.22814849e-01f, 1.04704648e-01f, 8.27023536e-02f, 2.24711429e-02f, 5.45788109e-02f, 1.78840742e-01f, 1.01779222e-01f, 2.17002910e-03f, 3.12820852e-01f, 7.45585784e-02f,
  1.68139353e-01f, 1.83701292e-01f, 2.49564156e-01f, 2.36258149e-01f, -2.48970836e-02f, -1.12065911e-01f, 1.61433481e-02f, -2.45166793e-01f, -1.48643807e-01f, 2.51805391e-02f,
  2.75375675e-02f, 1.09867360e-02f, -8.85631591e-02f, -5.93425892e-02f, -2.18202516e-01f, -6.06965236e-02f, -1.46837473e-01f, 1.62049919e-01f, -4.80952561e-02f, 8.29600263e-03f,
  -7.54924044e-02f, 4.29845328e-04f, 1.48146823e-01f, -1.85620815e-01f, -3.12576592e-01f, 2.49207154e-01f, 2.00247578e-02f, -1.11606710e-01f, 1.69107839e-01f, 1.79533735e-01f,
  -1.05729714e-01f, -1.30578384e-01f, 2.80412100e-02f, 2.83427928e-02f, 6.52280748e-02f, 1.03585526e-01f, -1.74725335e-02f, -5.14314584e-02f, 5.39684221e-02f, -7.51204267e-02f,
  1.73289597e-01f, -9.75234509e-02f, 5.06748222e-02f, 1.16137229e-01f, -1.04769133e-01f, -1.14705555e-01f, 1.21447980e-01f, -9.75652412e-02f, 1.47060439e-01f, -6.92747831e-02f,
  -6.34693205e-02f, -2.14913255e-03f, 6.24784715e-02f, -8.77803862e-02f, 7.63092786e-02f, -4.34175432e-02f, -1.09907664e-01f, -6.94291666e-02f, 7.84991533e-02f, -6.14805259e-02f,
  -8.64830539e-02f, 2.96616666e-02f, 1.12422347e-01f, 2.50761565e-02f, 1.11022249e-01f, -5.49685247e-02f, -8.67893845e-02f, 7.16720149e-02f, 3.01889121e-03f, -2.77847331e-02f,
  -8.41693133e-02f, 1.76959857e-02f, 1.62565317e-02f, 1.07641280e-01f, -1.05811901e-01f, 3.28079648e-02f, 1.15553014e-01f, 1.77108217e-02f, -1.11486472e-01f, -9.09980908e-02f,
  6.36041835e-02f, -8.67364556e-03f, -1.27779797e-01f, 1.19700983e-01f, -1.01204831e-02f, 1.12431005e-01f, 9.05319899e-02f, 8.04984868e-02f, 8.80920663e-02f, -2.12600101e-02f,
  8.95001218e-02f, -1.09734774e-01f, -5.05035408e-02f, 2.42223237e-02f, 9.13400799e-02f, 1.03054874e-01f, -1.87193863e-02f, -6.25665113e-02f, -8.06927755e-02f, 7.60250613e-02f,
  -2.87220534e-02f, -7.92031139e-02f, -3.12375408e-02f, 1.13292664e-01f, 3.14746574e-02f, -6.91174567e-02f, -1.09194525e-01f, -3.77781317e-02f, 3.80875543e-03f, 1.01204522e-01f,
  3.27656954e-03f, 8.51333439e-02f, -1.10098213e-01f, 9.43807065e-02f, -5.40316291e-02f, 9.39726457e-03f, 8.28922465e-02f, 6.97710514e-02f, -8.00702069e-03f, -5.03035337e-02f,
  -2.36515217e-02f, 1.30470261e-01f, -4.99658249e-02f, -1.06791317e-01f, -6.29747212e-02f, -1.02972247e-01f, 9.18432325e-02f, -6.84310719e-02f, -8.66909921e-02f, -3.68229747e-02f,
  1.30929813e-01f, -3.23653594e-02f, -6.80134678e-03f, 3.74012142e-02f, 8.09595883e-02f, 5.23035089e-03f, -1.07422195e-01f, 4.69218101e-03f, -4.97103343e-03f, 4.03674580e-02f,
  -1.94864720e-02f, -4.99267466e-02f, -5.95293082e-02f, 7.22951815e-02f, -9.31959040e-03f, -2.36579304e-04f, 5.06866947e-02f, 5.31048849e-02f, -3.95828784e-02f, -8.40983018e-02f,
  -2.09769644e-02f, -2.36617904e-02f, 1.07304774e-01f, 7.79029578e-02f, -3.69544304e-03f, -2.74075903e-02f, -1.21181272e-01f, -1.13445790e-02f, 2.52096504e-02f, -1.80552546e-02f,
  -8.37166011e-02f, 1.04011089e-01f, -7.18679577e-02f, 4.62452732e-02f, -3.45570818e-02f, -4.18099426e-02f, 7.47301877e-02f, -5.12500443e-02f, 5.81204630e-02f, 9.46154296e-02f,
  -1.12313002e-01f, 5.21287955e-02f, 5.34374192e-02f, 2.36327611e-02f, 8.80595073e-02f, 5.37709985e-03f, 1.12040535e-01f, 1.04746863e-01f, -1.81263033e-02f, -1.13882190e-02f,
  -8.40327069e-02f, -1.08223565e-01f, 6.61898255e-02f, 1.13946661e-01f, -6.29466772e-02f, -4.97213006e-02f, -6.62281141e-02f, -7.20949098e-02f, -7.41922930e-02f, 1.07652582e-01f,
  1.21377073e-01f, 5.12604117e-02f, -1.13222547e-01f, -8.95957574e-02f, -9.45594758e-02f, -3.41224298e-02f, -6.64095432e-02f, -1.16371378e-01f, -1.21200159e-01f, -7.34454319e-02f,
  -7.02217370e-02f, -1.11906670e-01f, -2.27335822e-02f, 5.28263003e-02f, -1.18576646e-01f, -2.92619281e-02f, -8.27731341e-02f, 2.88156536e-03f, 1.07782096e-01f, -1.19698055e-01f,
  -5.49139902e-02f, 8.91118720e-02f, 5.23023866e-02f, -7.40655661e-02f, 5.42535894e-02f, -7.48876333e-02f, 8.92615393e-02f, 8.88561457e-02f, -1.05015047e-01f, -3.48508693e-02f,
  -3.49250622e-02f, -7.47406948e-03f, -1.21046919e-02f, -7.26492256e-02f, 9.97641236e-02f, -6.81654587e-02f, -8.48862808e-03f, -4.15424183e-02f, 7.31378794e-02f, -5.63720651e-02f,
  -4.12324592e-02f, 5.27771488e-02f, 2.23090854e-02f, 6.94677308e-02f, -6.64242804e-02f, -8.73164907e-02f, -8.66587460e-02f, 5.68706840e-02f, 8.32891837e-02f, 1.01925716e-01f,
  -7.14179799e-02f, 1.19314477e-01f, 5.36851287e-02f, 5.67724109e-02f, -1.14988312e-01f, 1.58523574e-01f, -1.61382332e-02f, -8.02857354e-02f, 1.05433082e-02f, 1.61528409e-01f,
  1.75537392e-01f, 1.58093482e-01f, -2.64794584e-02f, 8.28431994e-02f, -1.69224897e-03f, 2.07283273e-02f, 5.01343235e-02f, 4.26386259e-02f, 9.42567140e-02f, 3.33723053e-02f,
  1.05528906e-01f, 1.97438911e-01f, -8.99708420e-02f, -1.61224693e-01f, 1.88770771e-01f, 1.53667191e-02f, -1.59042627e-01f, 1.17708065e-01f, -1.11061446e-01f, -1.09675772e-01f,
  -7.58184418e-02f, 1.22841313e-01f, 2.65103638e-01f, 2.65990436e-01f, 1.02535844e-01f, -7.79485181e-02f, -2.79087335e-01f, -2.77639390e-03f, -1.73233390e-01f, 1.78429365e-01f,
  -1.26819432e-01f, 6.45078570e-02f, 3.21518630e-02f, -1.11400507e-01f, -1.55588146e-02f, 1.38191372e-01f, 7.11447671e-02f, -9.25673619e-02f, 2.16287106e-01f, -8.69013444e-02f,
  1.53109267e-01f, 1.00092143e-01f, -7.17857927e-02f, 3.20988633e-02f, 9.56156403e-02f, 1.48484223e-02f, -2.31604511e-03f, -1.35325762e-02f, -8.31908286e-02f, 5.67270629e-02f,
  1.64329082e-01f, 1.91988144e-03f, 8.42656121e-02f, -9.55578014e-02f, -5.43129779e-02f, 1.02557346e-01f, 1.37721390e-01f, -5.43873699e-04f, 9.92604196e-02f, 1.10467315e-01f,
  -5.73068000e-02f, -5.46683185e-02f, -3.59144025e-02f, 8.13221186e-02f, 1.80741668e-01f, 1.61234632e-01f, 9.70241874e-02f, 1.54168785e-01f, -4.74173613e-02f, -2.93041915e-02f,
  1.74893588e-01f, 3.74608599e-02f, 2.98321713e-02f, 1.31855741e-01f, 3.53946909e-02f, -8.28674957e-02f, 1.86792895e-01f, 3.45618837e-02f, 1.70754120e-01f, -1.87637936e-02f,
  -5.19252643e-02f, -2.24307194e-01f, 1.24487400e-01f, 2.04118252e-01f, 1.66019768e-01f, 7.89347943e-03f, -4.17548902e-02f, -1.62558407e-01f, 7.37771094e-02f, -1.76643535e-01f,
  -1.58246875e-01f, 3.81822027e-02f, 6.60084095e-03f, 1.39302341e-02f, 2.24383608e-01f, -1.09958775e-01f, 6.02717251e-02f, 9.48353633e-02f, -6.61641881e-02f, -9.60166976e-02f,
  -1.91324297e-03f, 2.26249829e-01f, 9.63017717e-02f, 3.29230219e-01f, -1.99805647e-02f, -2.47101504e-02f, -3.30414325e-02f, 2.35805929e-01f, 2.70749740e-02f, -4.15540002e-02f,
  5.34298085e-02f, 5.90915270e-02f, 2.70950682e-02f, -1.25947461e-01f, -8.84133577e-03f, 1.89071551e-01f, -5.58183603e-02f, 1.16309680e-01f, -5.23944460e-02f, -2.91301664e-02f,
  2.56501555e-01f, 8.89849588e-02f, -5.16592823e-02f, -2.89351586e-02f, -1.26111746e-01f, -7.55576715e-02f, 2.66060811e-02f, -1.29338518e-01f, -1.20723948e-01f, -7.59823322e-02f,
  -7.60164186e-02f, 3.29557545e-02f, -1.23106919e-01f, -1.41100781e-02f, -1.22131996e-01f, 7.90439174e-02f, -1.07775725e-01f, -3.57735716e-02f, 1.04173176e-01f, -6.21742420e-02f,
  -1.03331774e-01f, -2.20399126e-02f, -1.62564609e-02f, -1.20521188e-02f, -1.28648460e-01f, -5.22896722e-02f, -7.90592432e-02f, -1.09405197e-01f, 1.03080701e-02f, -2.69135237e-02f,
  -7.49604329e-02f, 2.13821884e-02f, -1.06438398e-01f, -4.51449715e-02f, 4.09771455e-03f, -5.51504157e-02f, 4.80602272e-02f, 7.91876912e-02f, -6.95820972e-02f, 1.13714077e-01f,
  -4.23573367e-02f, 6.48426563e-02f, 1.12079479e-01f, 1.06470458e-01f, -1.58431940e-02f, 2.13572886e-02f, 7.47181848e-02f, -3.73473279e-02f, 5.24326460e-04f, -5.27287573e-02f,
  -1.04651973e-01f, 5.95334060e-02f, -8.37624297e-02f, 4.64767218e-02f, 6.34624436e-02f, 8.74594375e-02f, 5.79577871e-02f, -2.71214191e-02f, 3.82358134e-02f, 3.68341543e-02f,
  6.38011890e-03f, -1.02428406e-01f, -7.56424740e-02f, 4.89459969e-02f, 3.24766003e-02f, -4.75929119e-02f, 7.21914396e-02f, 1.69512004e-01f, 5.48263453e-02f, 2.13620245e-01f,
  -6.50113672e-02f, 5.84289990e-03f, 1.18672393e-01f, 1.05424277e-01f, 9.30144042e-02f, 2.01531500e-01f, 2.31674969e-01f, 4.35784571e-02f, 2.95155309e-02f, 1.38257250e-01f,
  1.71437174e-01f, 2.24482879e-01f, 2.75504649e-01f, -2.12095872e-01f, 2.12910131e-01f, -5.37483394e-02f, 4.64874581e-02f, -1.05703011e-01f, -9.69021618e-02f, -9.06066746e-02f,
  2.16053993e-01f, 2.96253085e-01f, -1.73068479e-01f, -1.55331790e-01f, -5.02226762e-02f, 9.23539922e-02f, 2.32673675e-01f, -2.29501843e-01f, -1.73396319e-01f, -2.97117144e-01f,
  -1.50685459e-01f, -2.55205086e-03f, -1.86967582e-01f, 2.53922969e-01f, -1.77854896e-01f, -6.91950396e-02f, 1.52634189e-01f, 1.42820459e-02f, -1.90767478e-02f, -1.61565039e-02f,
  -7.84422737e-03f, 8.77697840e-02f, -8.25205296e-02f, 5.38568795e-02f, -2.01275502e-03f, 1.21848039e-01f, 6.45907521e-02f, 8.34576786e-02f, 1.10895649e-01f, -4.04911749e-02f,
  -7.00679198e-02f, -1.37404814e-01f, -8.29924196e-02f, 6.92572817e-02f, 6.48427606e-02f, 1.07970737e-01f, -4.32365201e-02f, -2.73245443e-02f, 1.02335453e-01f, -1.10689335e-01f,
  8.95468816e-02f, 8.50117877e-02f, -8.84548351e-02f, 9.18089151e-02f, 9.02798548e-02f, -1.13556288e-01f, -5.05592860e-02f, -1.02227211e-01f, -1.85972005e-01f, 2.46802205e-03f,
  5.83994165e-02f, -4.72771712e-02f, 8.57296139e-02f, -5.53513281e-02f, -9.67164263e-02f, 7.64759034e-02f, 6.88958541e-02f, 6.94717467e-02f, 3.43194641e-02f, -2.03395098e-01f,
  1.04952067e-01f, 6.15967512e-02f, -1.15551896e-01f, -9.92758498e-02f, 4.71003130e-02f, -1.04756646e-01f, -1.42520592e-01f, 2.03495696e-01f, 8.38298574e-02f, -4.17044535e-02f,
  -1.34774387e-01f, 6.12525046e-02f, -5.86755015e-03f, -6.33633435e-02f, 1.13578960e-01f, -2.99201664e-02f, 7.53474832e-02f, -3.40710245e-02f, -9.20884609e-02f, -3.63097042e-02f,
  2.57753953e-02f, -7.68525526e-02f, -1.09890535e-01f, 8.85278732e-02f, 1.96800798e-01f, -7.72775412e-02f, 9.48809683e-02f, 1.00391939e-01f, -3.09142191e-02f, 1.25964642e-01f,
  5.41176870e-02f, 1.01908229e-01f, -1.40143573e-01f, 4.56007831e-02f, -1.06139043e-02f, 1.69499531e-01f, 1.25974327e-01f, 1.13376215e-01f, -6.30385280e-02f, -9.78763867e-03f,
  4.44175489e-02f, 7.65051506e-03f, 7.12946355e-02f, -3.00318860e-02f, 1.53712407e-01f, 3.96642946e-02f, 8.48598406e-02f, 1.55328140e-01f, 1.32007495e-01f, 1.98209718e-01f,
  8.86724219e-02f, 1.53381750e-01f, -1.64981589e-01f, -1.13480836e-01f, 2.72438735e-01f, 1.12725347e-01f, 1.95526518e-03f, 2.19917625e-01f, 8.18928033e-02f, -1.14931082e-02f,
  5.87307699e-02f, 4.90075909e-02f, 3.19805704e-02f, -3.01775217e-01f, 4.80602011e-02f, -1.47473991e-01f, 5.85657656e-02f, 1.19499683e-01f, -1.36967614e-01f, -2.01227948e-01f,
  -1.60361230e-01f, 4.56088930e-02f, 1.74597964e-01f, 2.15686351e-01f, -1.45251095e-01f, 2.09178343e-01f, -1.74649328e-01f, 2.22588144e-02f, 2.19756439e-01f, -5.12143373e-02f,
  -1.45528868e-01f, 3.43039148e-02f, 1.39626205e-01f, 9.42667201e-02f, 1.96084663e-01f, 1.00239106e-01f, 7.18306825e-02f, -2.04724371e-02f, 1.86148971e-01f, -1.14157148e-01f,
  3.48928064e-01f, -9.76704061e-02f, 9.48103517e-02f, -6.72407895e-02f, 6.30456489e-03f, 2.01637000e-01f, 3.61959130e-01f, -2.19005113e-03f, 3.36115398e-02f, 3.89335826e-02f,
  -2.25778054e-02f, 2.92754062e-02f, 1.63504273e-01f, 7.35206231e-02f, 1.88844696e-01f, 1.28319025e-01f, 4.53862548e-02f, -8.58389735e-02f, 1.33504108e-01f, 3.63152139e-02f,
  1.51321083e-01f, 4.00396809e-03f, 9.48952958e-02f, 2.53124535e-01f, 7.55981207e-02f, 2.14237213e-01f, 2.53742754e-01f, 1.83437526e-01f, 7.36212581e-02f, 6.62251115e-02f,
  3.15857306e-02f, 8.45860317e-02f, 9.62522328e-02f, -1.10443896e-02f, 1.78778276e-01f, 3.33637804e-01f, 1.54956877e-01f, 6.43942282e-02f, -9.20705497e-02f, -2.35606238e-01f,
  -2.64681786e-01f, 2.27870941e-02f, -2.03170583e-01f, 1.40361771e-01f, 7.04070851e-02f, 3.33395392e-01f, 9.12918150e-02f, -2.04078645e-01f, -9.67014953e-02f, 1.43589795e-01f,
  1.53262451e-01f, 8.89961123e-02f, -1.59436628e-01f, -3.84924863e-03f, 4.96738702e-01f, -2.35989079e-01f, 2.51405150e-01f, 1.02616642e-02f, -1.98015168e-01f, -3.47808488e-02f,
  3.04120127e-02f, 5.76055981e-02f, 8.71675313e-02f, -1.36103556e-01f, -3.93890254e-02f, -2.34618858e-01f, -1.18473552e-01f, 1.39462709e-01f, 8.33031833e-02f, -4.14233729e-02f,
  -1.57323450e-01f, 1.54721320e-01f, 1.98571786e-01f, 2.63903320e-01f, 9.71065685e-02f, -1.26487529e-02f, -3.73467966e-03f, 1.60463423e-01f, 1.92064285e-01f, 2.08591565e-01f,
  2.59387672e-01f, 4.85269763e-02f, -8.61513466e-02f, -2.14291513e-02f, -1.21637523e-01f, 7.52132460e-02f, -8.84447098e-02f, -1.01203740e-01f, -9.40740928e-02f, 1.83876064e-02f,
  9.15260911e-02f, 1.17899869e-02f, -7.59298429e-02f, 2.57739592e-02f, 1.18391968e-01f, -9.11889784e-03f, -1.31493822e-01f, -2.91476343e-02f, 1.34512484e-02f, 1.07663579e-01f,
  -1.15933105e-01f, -5.38644716e-02f, 1.17714778e-02f, 1.80195831e-02f, -1.02395765e-01f, -1.28352493e-02f, 1.55354915e-02f, 8.61385558e-03f, 7.14584094e-05f, -8.41824189e-02f,
  2.89169010e-02f, -3.80021855e-02f, 8.45072195e-02f, 6.66535646e-02f, -1.74403321e-02f, -1.21045439e-02f, 4.61763479e-02f, 1.01672187e-01f, 7.02924803e-02f, -9.24931373e-03f,
  8.02677199e-02f, 4.54764664e-02f, 1.52759582e-01f, 9.78242457e-02f, -8.41223747e-02f, 6.54257834e-02f, 1.35840580e-01f, -8.94601420e-02f, 3.84944342e-02f, -9.74378586e-02f,
  -7.83301964e-02f, -6.36746958e-02f, 1.36694625e-01f, -1.60124302e-02f, 4.80266847e-02f, 1.05860896e-01f, -3.30963247e-02f, -5.00471927e-02f, -3.08215339e-02f, -1.80613920e-02f,
  1.48287371e-01f, 1.06136486e-01f, -4.15266715e-02f, -1.13805935e-01f, 9.22442600e-02f, 7.59627968e-02f, 1.92408919e-01f, -2.42540357e-03f, 1.11847781e-01f, 9.90920067e-02f,
  1.72522962e-01f, 1.40623190e-02f, 3.13426964e-02f, -9.81526524e-02f, 1.99320436e-01f, 2.04809830e-01f, -6.73728883e-02f, -2.59065665e-02f, 7.45846927e-02f, -5.30946702e-02f,
  9.56833214e-02f, 1.12178311e-01f, -4.69895378e-02f, -1.05810620e-01f, 2.39728734e-01f, 2.58016676e-01f, 6.09414056e-02f, -9.04222652e-02f, -3.68529372e-03f, -9.88304168e-02f,
  2.03803465e-01f, 4.86241505e-02f, 2.23941088e-01f, -1.00499690e-01f, -2.49752864e-01f, -2.02812254e-01f, -6.09939508e-02f, -5.75260371e-02f, 1.18449219e-01f, -8.53147954e-02f,
  -5.48542328e-02f, -6.75919876e-02f, 2.00189009e-01f, -1.92039981e-01f, 1.78053543e-01f, 2.04067249e-02f, -3.55227217e-02f, 3.33976597e-02f, 6.45297915e-02f, -4.93307523e-02f,
  1.76592898e-02f, 1.47154808e-01f, -9.37725324e-03f, -5.22798784e-02f, 1.39519408e-01f, 7.42598847e-02f, 3.15886028e-02f, 1.36221811e-01f, -7.50640705e-02f, 3.97059694e-03f,
  -4.84005176e-02f, -1.08572140e-01f, -1.12297170e-01f, 1.64838538e-01f, 2.28297943e-03f, -2.66333520e-02f, 4.25995141e-02f, -3.99288610e-02f, -5.48209250e-02f, -1.08466204e-03f,
  1.44219697e-01f, 9.11823809e-02f, -7.15081170e-02f, 2.59722620e-02f, -7.74887130e-02f, 4.40082978e-03f, 2.98786759e-02f, 1.01347663e-01f, -4.38496992e-02f, -1.41955838e-02f,
  6.47514760e-02f, -1.04186855e-01f, -8.09231773e-02f, -7.81803206e-02f, 3.66578624e-02f, -4.14258428e-02f, 1.64728984e-02f, -1.03420436e-01f, 1.79846019e-01f, 3.31199020e-02f,
  2.20546313e-02f, -3.52092423e-02f, 1.13570079e-01f, -9.10387114e-02f, 1.08318791e-01f, 4.34081033e-02f, 1.84290886e-01f, -7.42897484e-03f, -2.70848386e-02f, 7.79901966e-02f,
  -1.56494170e-01f, -2.04969235e-02f, 3.88958096e-03f, 8.46502334e-02f, 1.10493734e-01f, 6.60689548e-02f, -2.20098812e-02f, 7.39797531e-03f, 1.45818874e-01f, 1.14015467e-01f,
  -4.06327993e-02f, -4.12204750e-02f, 3.15116532e-02f, -6.04154393e-02f, 9.03185643e-03f, 2.48678908e-01f, 2.28897721e-01f, -7.73716122e-02f, 8.54618102e-02f, 4.61641215e-02f,
  -1.32770732e-01f, 7.63120130e-02f, 5.75065762e-02f, 9.25395861e-02f, -7.19219893e-02f, -9.49751213e-03f, -3.75171825e-02f, 1.45862594e-01f, 1.13981575e-01f, -4.00060304e-02f,
  -5.70988879e-02f, -5.95401414e-02f, 6.81635514e-02f, 1.11878499e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.19645730e-01f, -2.42047623e-04f, 1.07037343e-01f, 1.13990217e-01f, 3.96763980e-02f, -1.32478401e-01f, 1.24969430e-01f, -1.18985668e-01f, 1.76310018e-02f, 1.37845099e-01f,
  -2.67310697e-03f, 5.00890799e-02f, 4.04568315e-02f, 2.01694518e-02f, -4.78093512e-02f, -1.18418587e-02f, 1.17588386e-01f, 9.60838571e-02f, 1.91627853e-02f, 2.12486774e-01f,
  2.65720841e-02f, 7.28257820e-02f, 2.59235241e-02f, 7.80192912e-02f, 7.78380036e-02f, 1.53429061e-01f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.14635788e-01f, -1.14942394e-01f, 1.56593576e-01f, 8.19071084e-02f, 1.40917394e-02f, -1.34772897e-01f, 5.63534014e-02f, 2.06881273e-03f, 1.23841099e-01f, -1.12404533e-01f,
  2.18418613e-02f, -1.75451919e-01f, -2.62498632e-02f, -8.40712190e-02f, 1.24324881e-01f, 6.67517409e-02f, 1.00186631e-01f, -5.39206974e-02f, 5.42704947e-02f, 4.42758910e-02f,
  -2.17312053e-01f, 9.78498757e-02f, -1.62049472e-01f, -3.06653976e-01f, -1.14280462e-01f, 2.18442589e-01f, -8.57565645e-03f, 8.03446770e-02f, -1.23891227e-01f, 4.53970768e-02f,
  -8.72288719e-02f, -1.22353092e-01f, -2.98731383e-02f, 1.15196094e-01f, 2.26439103e-01f, -4.52026166e-02f, -9.26829502e-02f, 3.49716991e-02f, 1.22136116e-01f, -4.57938910e-02f,
  1.90221556e-02f, 1.83270603e-01f, -1.87648654e-01f, -3.33380252e-02f, 5.09355739e-02f, 1.11258596e-01f, -7.77964443e-02f, 9.55960304e-02f, -1.32496387e-01f, 5.14595918e-02f,
  -7.06095695e-02f, -4.37729806e-02f, 1.09895892e-01f, -9.01754051e-02f, 7.16476515e-02f, 4.83988449e-02f, 1.91244520e-02f, 2.93037146e-02f, -9.28737894e-02f, -1.16265483e-01f,
  9.93590727e-02f, -4.79330355e-03f, 1.90236434e-01f, 8.60029235e-02f, -7.65757784e-02f, -2.63974760e-02f, -1.55909106e-01f, 1.37078986e-01f, 1.64697409e-01f, 4.52689268e-02f,
  7.92085156e-02f, -9.62657034e-02f, -1.37195900e-01f, -5.79871573e-02f, -1.06657244e-01f, -3.51818763e-02f, -2.27281060e-02f, 1.77240670e-02f, 3.08561679e-02f, 1.48168147e-01f,
  -1.64620027e-01f, 4.55220556e-03f, -8.43727961e-02f, 1.71835959e-01f, 1.77654207e-01f, -1.05734602e-01f, 1.00311376e-01f, 1.48817748e-01f, 4.81299646e-02f, -6.48377687e-02f,
  1.68002322e-02f, 3.79721671e-02f, 1.87233403e-01f, -2.05248535e-01f, 1.35558590e-01f, 4.85726185e-02f, -9.90471151e-03f, -1.38926864e-01f, -2.48536706e-01f, -3.94650660e-02f,
  -8.34717602e-02f, 4.68955487e-02f, 8.57815892e-03f, 2.14994736e-02f, 8.40331241e-02f, -1.93054810e-01f, -7.11669773e-02f, 5.34062050e-02f, -4.70168144e-02f, 1.71729401e-02f,
  2.79117078e-02f, -4.29760143e-02f, 1.72155797e-01f, -7.26613551e-02f, 1.73549876e-01f, 7.97540918e-02f, 1.23247787e-01f, -1.15844727e-01f, -5.02051562e-02f, -4.34425399e-02f,
  6.35199994e-03f, -1.75437272e-01f, 9.09387320e-02f, 2.89484859e-01f, -3.13316137e-02f, -4.53280397e-02f, -1.16170473e-01f, -3.48026976e-02f, -1.37226582e-01f, 4.48638201e-02f,
  8.46702792e-03f, 9.95861441e-02f, -1.44271657e-01f, -1.51471626e-02f, 9.49587673e-02f, 1.05439723e-01f, -1.33651629e-01f, -6.25227913e-02f, 6.02063164e-02f, -8.18420276e-02f,
  1.77252386e-02f, 1.09199807e-01f, 7.51540251e-03f, -1.32341057e-01f, -1.90917868e-02f, -8.33251625e-02f, 3.71390991e-02f, -9.49193090e-02f, -2.01820463e-01f, 2.22312212e-01f,
  -2.50488311e-01f, -2.79314697e-01f, 5.78344651e-02f, 5.24661206e-02f, 1.54069826e-01f, 8.07642639e-02f, -1.48278505e-01f, 6.31397665e-02f, -7.55966129e-03f, -7.53484741e-02f,
  1.47885501e-01f, 6.19542301e-02f, 9.20644850e-02f, -1.41056657e-01f, 1.70731395e-02f, 6.56879619e-02f, 1.47353619e-01f, 6.02824874e-02f, 7.92988464e-02f, 2.23000467e-01f,
  -1.15048990e-01f, 8.57494399e-02f, 9.63501036e-02f, 6.57952875e-02f, -1.85823590e-01f, 1.07503645e-01f, -2.01153576e-01f, -1.01766862e-01f, -2.30798006e-01f, -9.32998136e-02f,
  -1.36591315e-01f, -1.01665013e-01f, 3.59871723e-02f, 2.57656783e-01f, -4.81557287e-02f, -7.19601884e-02f, -1.53962359e-01f, -1.18853049e-02f, 9.20478851e-02f, 4.28287834e-02f,
  2.20484599e-01f, 1.07219748e-01f, -1.08037062e-01f, -9.20834169e-02f, -1.30050033e-01f, -1.28534302e-01f, 1.12677358e-01f, 2.20998779e-01f, -1.27883360e-01f, 1.03589572e-01f,
  1.25432894e-01f, 2.19381049e-01f, -8.75774249e-02f, -1.06005199e-01f, 1.41732827e-01f, 7.01263174e-02f, 8.70948210e-02f, -2.95045562e-02f, 1.05954492e-02f, 4.46929671e-02f,
  -4.32185568e-02f, 1.36023283e-01f, 8.41795281e-02f, -2.99803674e-01f, 3.10924828e-01f, -1.12426132e-02f, 1.97029769e-01f, -7.09842965e-02f, 1.36355255e-02f, -9.78008583e-02f,
  2.04248667e-01f, -2.17543468e-01f, -9.82864993e-04f, 2.03054413e-01f, -1.61649585e-01f, -1.64903790e-01f, -8.57916698e-02f, 2.39708483e-01f, 9.85026266e-03f, -1.07043229e-01f,
  3.79803292e-02f, -2.43802145e-02f, -3.82506959e-02f, 4.93443571e-04f, 1.17483158e-02f, -8.53751823e-02f, 1.07684145e-02f, -7.34465942e-03f, 2.12883696e-01f, -9.72890109e-02f,
  8.59107599e-02f, -1.18704945e-01f, 1.96458027e-01f, -2.79717110e-02f, 8.03188384e-02f, 7.62380436e-02f, -5.50165772e-02f, -2.63704211e-01f, 3.52218822e-02f, -9.24513415e-02f,
  -9.61074606e-02f, -2.13498790e-02f, -1.03578106e-01f, -2.71830149e-02f, -7.48690357e-03f, -7.11069852e-02f, -3.73170682e-04f, 1.47715494e-01f, 1.89332664e-01f, 1.12679422e-01f,
  -1.56922899e-02f, 7.27512315e-03f, 7.79078156e-02f, 5.32554276e-02f, 2.01410819e-02f, 8.63607600e-03f, -3.16893347e-02f, 1.36522159e-01f, -3.24485488e-02f, -2.87307110e-02f,
  4.65699546e-02f, 4.87046950e-02f, 3.96228163e-03f, -2.36297935e-01f, 1.81569666e-01f, -1.78702354e-01f, 1.56766608e-01f, 1.60018846e-01f, -9.81991515e-02f, -1.99233770e-01f,
  4.46872786e-02f, 1.59281939e-01f, 1.10941298e-01f, -2.07472920e-01f, -8.94651115e-02f, 2.19216928e-01f, -7.58151934e-02f, -1.54963329e-01f, 1.09295901e-02f, -2.72820182e-02f,
  1.38266221e-01f, -6.30632415e-02f, 1.89078256e-01f, 1.25893563e-01f, 9.32556838e-02f, 5.83894663e-02f, 1.21589899e-01f, 6.49535730e-02f, -1.16868475e-02f, -3.53486128e-02f,
  -1.24233916e-01f, -7.87728280e-02f, -1.67048350e-01f, -2.18310561e-02f, -1.35336205e-01f, -7.80924708e-02f, -1.15709044e-01f, 8.57426748e-02f, 7.10964501e-02f, -4.58260626e-02f,
  -7.05057830e-02f, 7.34632686e-02f, -1.02687582e-01f, 3.29917729e-01f, -7.44686052e-02f, -3.19141299e-01f, 9.38980654e-02f, -5.02716517e-03f, 4.12282161e-02f, -1.16791159e-01f,
  -1.53538719e-01f, 1.58923790e-01f, 2.22591117e-01f, 6.44068122e-02f, -1.23972535e-01f, 1.38527956e-02f, 1.77983448e-01f, 1.39228284e-01f, 9.48147476e-02f, 6.19212501e-02f,
  -6.99555427e-02f, 2.23461866e-01f, 1.13520689e-01f, 7.10584596e-02f, 6.92554042e-02f, 1.14999413e-01f, 1.78966597e-02f, -1.45677522e-01f, 1.88306347e-01f, 1.80420596e-02f,
  1.72782838e-02f, 1.11479394e-01f, -1.49401948e-01f, -1.03358969e-01f, -8.08338076e-02f, 2.62101024e-01f, 8.47316533e-02f, 2.25215890e-02f, -2.74697185e-01f, -1.19818345e-01f,
  1.87924594e-01f, -2.15273276e-01f, 2.24233076e-01f, 9.18272212e-02f, 2.68315077e-01f, -2.21490562e-01f, 8.09672698e-02f, 1.77481696e-01f, -3.74428742e-03f, -4.90597785e-02f,
  -5.29126227e-02f, 2.52030194e-01f, -1.62194759e-01f, -4.27083345e-03f, -1.34355515e-01f, -1.22950852e-01f, -2.56841518e-02f, 6.47545159e-02f, -2.20839337e-01f, -2.06815731e-02f,
  -1.77727520e-01f, 3.67830694e-02f, 4.98806350e-02f, 4.30110879e-02f, 2.37839997e-01f, 1.68363690e-01f, 1.14278242e-01f, 5.90527914e-02f, 5.16943373e-02f, 8.01380351e-02f,
  1.96453288e-01f, 1.33320764e-01f, -8.36333781e-02f, 2.05158573e-02f, -6.26952574e-03f, 6.33875877e-02f, 1.57772243e-01f, -1.46598399e-01f, -1.59795120e-01f, 7.05037862e-02f,
  -7.16253743e-02f, 5.18162251e-02f, 1.24483041e-01f, -4.58362587e-02f, 2.13898495e-02f, 1.72727183e-01f, -5.16085140e-03f, 6.74363449e-02f, -7.42017583e-04f, 4.49717864e-02f,
  2.08401486e-01f, -1.19624071e-01f, 1.61524154e-02f, 1.27795607e-01f, -2.50461996e-01f, 1.43974617e-01f, -7.84425437e-02f, -1.33707196e-01f, -1.32242352e-01f, 1.31213918e-01f,
  1.84485614e-01f, 4.90400530e-02f, -3.23003381e-01f, 7.54974736e-03f, 2.03271285e-01f, 3.51052545e-03f, -2.44425014e-02f, 1.42672330e-01f, 2.29286253e-01f, -1.50179774e-01f,
  5.56546589e-03f, -4.26210240e-02f, -5.89591153e-02f, 1.15208946e-01f, -1.44460201e-01f, 1.69895515e-01f, 4.90863994e-02f, 9.24721286e-02f, -1.19321577e-01f, 8.36197138e-02f,
  -7.85805210e-02f, 6.26963675e-02f, 4.98222969e-02f, 6.47798702e-02f, -2.86116809e-01f, 5.92264831e-02f, 7.93864205e-02f, 1.20653316e-01f, 6.45531416e-02f, 1.09579906e-01f,
  1.52210500e-02f, 1.06382566e-02f, 1.18386552e-01f, -2.18441591e-01f, 1.45450935e-01f, -9.70133469e-02f, -8.20683762e-02f, 2.38152891e-02f, -8.59218612e-02f, 3.21764052e-02f,
  -1.78630486e-01f, -9.93176773e-02f, 8.13238844e-02f, 1.36880845e-01f, -1.56384945e-01f, -1.01086415e-01f, -5.58027485e-03f, -6.24242704e-03f, -3.50321606e-02f, -1.03786252e-01f,
  9.30335447e-02f, 4.70055677e-02f, -1.54770941e-01f, -2.73471903e-02f, 7.16511440e-03f, -9.74349901e-02f, 9.26821083e-02f, -5.59310522e-03f, 9.19953808e-02f, -2.58757472e-01f,
  9.99618173e-02f, 8.68225917e-02f, 4.61360579e-03f, -3.63976240e-01f, -1.98068738e-01f, -1.45257354e-01f, 2.95852989e-01f, -7.26336315e-02f, -1.96262762e-01f, 9.78885666e-02f,
  -6.59291148e-02f, -2.08484337e-01f, -1.29604727e-01f, 3.46038371e-01f, 5.10279201e-02f, -1.69421375e-01f, -4.66325060e-02f, -5.73457517e-02f, -6.44282252e-02f, 5.82929328e-02f,
  -6.64796755e-02f, 1.04271010e-01f, 1.01610363e-01f, 5.72601147e-02f, -1.01597130e-01f, -1.72720253e-01f, 1.43700868e-01f, 1.43205047e-01f, -5.43092191e-02f, 4.35751416e-02f,
  5.41803837e-02f, 2.96846870e-02f, -4.10333537e-02f, 3.04266661e-02f, -3.17773744e-02f, -7.08565442e-03f, -1.95274115e-01f, -2.46062092e-02f, -2.47716025e-01f, 1.03845946e-01f,
  1.40515015e-01f, 1.40012100e-01f, -1.08551927e-01f, -4.29481044e-02f, -1.72870263e-01f, 6.49353862e-02f, 1.32486328e-01f, 6.60371035e-02f, -1.28187463e-01f, -1.37341753e-01f,
  -1.01612896e-01f, -8.75566527e-02f, 4.11038063e-02f, -6.19101152e-02f, -8.50656554e-02f, 7.71832019e-02f, -7.41555095e-02f, 9.01798382e-02f, -1.81718767e-01f, 1.39979154e-01f,
  5.19967340e-02f, 1.14023037e-01f, -1.30290702e-01f, -2.44720299e-02f, 1.71570718e-01f, 1.15595534e-02f, 6.86754510e-02f, 7.97126964e-02f, 7.00424910e-02f, 1.46148205e-01f,
  1.67675298e-02f, -5.50985411e-02f, 1.69804707e-01f, 1.36265913e-02f, -3.91762741e-02f, -1.60198677e-02f, -8.15342516e-02f, 6.24192804e-02f, -1.66813463e-01f, 3.50213610e-02f,
  -3.44274864e-02f, 1.62279591e-01f, -1.09228618e-01f, 1.78433917e-02f, 2.36242618e-02f, 7.68209342e-03f, 1.83323130e-01f, -9.89431813e-02f, -1.59901567e-02f, 1.39491381e-02f,
  -2.05514673e-02f, 8.94135237e-02f, 1.37418807e-01f, 1.79154165e-02f, 3.13198045e-02f, -8.54147151e-02f, 2.46001825e-01f, -2.14313149e-01f, 8.23071525e-02f, -1.75200194e-01f,
  2.18702555e-01f, 2.62590021e-01f, 1.94767676e-02f, -1.22869872e-01f, -1.71672419e-01f, -1.06091008e-01f, 4.28226404e-02f, 1.00173438e-02f, 1.68359764e-02f, -3.43098342e-02f,
  2.51115467e-02f, -7.04805106e-02f, 1.89267144e-01f, 1.62972827e-02f, 6.48533478e-02f, 1.70304000e-01f, -1.72570944e-02f, 4.78467159e-02f, 3.27788517e-02f, -3.53928953e-02f,
  9.63735580e-02f, 4.23326939e-02f, 2.78732162e-02f, -7.57159889e-02f, -2.98119206e-02f, 7.68043622e-02f, 2.24620402e-01f, -1.36957318e-01f, 1.43936798e-01f, 2.86978304e-01f,
  -3.33115011e-02f, -2.50939667e-01f, 1.28560178e-02f, 1.42618686e-01f, 5.80389090e-02f, -2.19490841e-01f, 3.75132412e-02f, 2.47432724e-01f, -1.14124119e-01f, -1.38923839e-01f,
  -2.52959758e-01f, 1.48132920e-01f, -2.85091586e-02f, -2.31185019e-01f, -7.21134841e-02f, 1.73504818e-02f, -8.03864375e-02f, -9.07759145e-02f, 2.29445249e-02f, -4.45796468e-04f,
  -1.04382135e-01f, 1.05430447e-01f, 1.28155321e-01f, 2.35075951e-02f, 2.24628508e-01f, -3.80927250e-02f, 2.26395756e-01f, 7.41556585e-02f, 8.56913403e-02f, 4.90668491e-02f,
  -1.92289487e-01f, -1.07754678e-01f, -1.50693627e-02f, -6.73491508e-02f, -6.62963912e-02f, 1.97863296e-01f, -1.84821904e-01f, 3.15996818e-04f, 5.93492342e-03f, 7.12920800e-02f,
  -4.23919633e-02f, -7.62080774e-02f, 8.54367837e-02f, -6.53062249e-03f, 1.40135705e-01f, 1.44176548e-02f, -1.28283806e-04f, -9.70692337e-02f, 1.25292733e-01f, -1.35006011e-01f,
  6.11982420e-02f, 1.18318135e-02f, 1.18832357e-01f, -9.06074941e-02f, -9.35134068e-02f, 1.21486776e-01f, 1.84695840e-01f, -1.86442286e-02f, 2.05307364e-01f, 2.02716552e-02f,
  -1.65535063e-01f, 7.59946704e-02f, -2.35692114e-01f, -2.19608843e-01f, -4.40991707e-02f, 2.69101262e-01f, 1.49650365e-01f, -7.46583119e-02f, -2.27194220e-01f, -2.76048724e-02f,
  1.06201798e-01f, -1.16170876e-01f, 1.37285888e-01f, 8.85041505e-02f, 1.97809264e-01f, -1.61547184e-01f, 2.75508631e-02f, 3.27498049e-01f, 2.13416338e-01f, -2.46072561e-02f,
  3.99325276e-03f, 2.18927905e-01f, 3.13963182e-02f, 4.37194593e-02f, -1.97550520e-01f, -7.98838772e-03f, -1.73009768e-01f, 3.82535309e-02f, -1.93433329e-01f, -3.11302878e-02f,
  -7.35328346e-02f, 5.30143604e-02f, 5.42325526e-02f, -1.07287563e-01f, 2.11551741e-01f, 5.90435881e-03f, -2.86943670e-02f, 1.89701796e-01f, 1.24325395e-01f, -6.91260099e-02f,
  2.17800364e-01f, -1.92116275e-02f, -1.64695770e-01f, -1.62197679e-01f, -1.33015469e-01f, -1.11489043e-01f, 1.61692962e-01f, -4.58059981e-02f, -7.37228841e-02f, 9.71468389e-02f,
  9.22825113e-02f, 2.63113584e-02f, -1.05425037e-01f, -8.69855285e-02f, -8.71781707e-02f, 1.85679585e-01f, 1.16516063e-02f, -3.84582542e-02f, -6.26452034e-03f, 1.47361323e-01f,
  2.06646800e-01f, 1.36781204e-02f, 2.02609509e-01f, 2.13540763e-01f, -1.34633973e-01f, 6.46058470e-02f, 8.03086534e-02f, 1.07884794e-01f, 7.62760043e-02f, 1.75515339e-01f,
  7.29164258e-02f, 4.99882251e-02f, -2.66115636e-01f, -4.16583568e-01f, 1.04077972e-01f, 9.08471495e-02f, -5.19148745e-02f, -8.09303448e-02f, -9.92291048e-03f, -2.06668496e-01f,
  -8.54739472e-02f, 1.46655440e-01f, 9.41306502e-02f, -6.91017359e-02f, -1.73507124e-01f, -6.50273412e-02f, 1.24255933e-01f, -4.62612286e-02f, -2.33736336e-01f, 1.20874874e-01f,
  -4.04509641e-02f, -6.06007688e-02f, 1.18381687e-01f, -1.58859178e-01f, -1.89576503e-02f, 7.52704451e-03f, 9.80429798e-02f, 9.72260386e-02f, -6.15261262e-03f, -1.82581842e-01f,
  5.79751953e-02f, -2.27044430e-02f, -9.77743939e-02f, 8.71052742e-02f, 1.67192847e-01f, 8.72735605e-02f, -4.08861786e-02f, -1.35557473e-01f, -6.68395385e-02f, -6.57462329e-02f,
  -1.48014933e-01f, -5.23202084e-02f, 2.87807453e-02f, -1.26052141e-01f, -1.02960579e-01f, -7.08137006e-02f, -7.87994489e-02f, -2.23910838e-01f, -1.32429615e-01f, -8.93349200e-02f,
  6.50192276e-02f, 1.17278751e-02f, 6.01240396e-02f, -2.12479442e-01f, -1.33868352e-01f, 2.74814256e-02f, 2.38331910e-02f, -5.03672250e-02f, -2.15591013e-01f, 1.87925696e-01f,
  -1.67832956e-01f, -1.60306036e-01f, -1.56566083e-01f, 2.33032867e-01f, 1.53688222e-01f, 5.98509200e-02f, -2.09362119e-01f, 2.28212833e-01f, 1.45052105e-01f, -1.08849891e-01f,
  7.70130083e-02f, 1.97046250e-01f, 1.77882701e-01f, -2.46077701e-01f, 4.78531281e-03f, 2.56410390e-01f, 3.61902714e-02f, 1.13478698e-01f, 1.69933997e-02f, 2.47908458e-02f,
  -9.26996991e-02f, 3.08521930e-02f, 9.92887020e-02f, 1.35444719e-02f, -1.77162766e-01f, 1.20710716e-01f, -1.41424447e-01f, -5.56385741e-02f, -2.31631696e-01f, -5.54161035e-02f,
  -6.74560815e-02f, 3.29584591e-02f, 4.67146486e-02f, 5.26398346e-02f, 1.35848910e-01f, -2.61080395e-02f, -2.65331883e-02f, -8.76380131e-02f, 1.52774364e-01f, 5.30537106e-02f,
  -4.40567769e-02f, 4.10765270e-03f, -1.50666535e-01f, -8.02902356e-02f, -8.07878673e-02f, 2.03121603e-02f, -3.50805582e-03f, -7.76689053e-02f, -8.65990296e-02f, -9.40859690e-02f,
  -1.26201227e-01f, 1.43978834e-01f, -2.77115852e-02f, -3.54156382e-02f, -7.19233677e-02f, 5.08966558e-02f, -8.18881392e-02f, 1.14755139e-01f, 6.78060800e-02f, -5.50688580e-02f,
  1.88089564e-01f, 8.27915370e-02f, -5.88802854e-03f, 2.08701879e-01f, -7.67780989e-02f, -2.34362460e-03f, -7.51131251e-02f, 1.21621445e-01f, 5.93628362e-02f, -8.74738488e-03f,
  1.22183174e-01f, -4.18378301e-02f, 1.84866250e-01f, -9.19876322e-02f, 1.40116528e-01f, 4.62118201e-02f, 2.42299080e-01f, -8.32336321e-02f, -1.50355455e-02f, 1.32932633e-01f,
  1.19034126e-01f, 1.76336125e-01f, 1.54159203e-01f, -5.28001189e-02f, -1.35223687e-01f, 3.48937772e-02f, 3.29033583e-02f, 3.29304785e-02f, -1.41006395e-01f, -2.93571576e-02f,
  -2.89434254e-01f, -7.61379302e-02f, -9.69882160e-02f, 1.13957204e-01f, -4.90357690e-02f, -8.37184265e-02f, 3.57914180e-01f, -3.82922627e-02f, 4.62482907e-02f, 1.57393385e-02f,
  1.42637372e-01f, 8.94807130e-02f, -5.40445037e-02f, -1.10740870e-01f, -2.92873472e-01f, -1.26659080e-01f, -1.44898728e-01f, -3.72502469e-02f, -8.21235180e-02f, -1.45821944e-01f,
  -2.41765723e-01f, 2.31490672e-01f, 5.00701033e-02f, -1.93021949e-02f, 7.62287751e-02f, 9.24980119e-02f, -9.97222587e-03f, -1.69516949e-03f, -9.78811011e-02f, 7.35349357e-02f,
  5.83751276e-02f, -1.61739245e-01f, 1.32340476e-01f, -1.08285889e-01f, -2.13240907e-01f, 1.10863701e-01f, -3.27893049e-01f, 1.74146250e-01f, 1.70846041e-02f, -2.10164133e-02f,
  1.82221815e-01f, 3.58954333e-02f, -6.25708774e-02f, 1.96752295e-01f, -1.64043576e-01f, 1.14621006e-01f, -1.06098123e-01f, 1.35911494e-01f, 1.17438748e-01f, 6.08416870e-02f,
  2.39609390e-01f, 1.34707272e-01f, -1.32671043e-01f, -2.16854751e-01f, -8.93030316e-02f, 1.12572059e-01f, -2.22843736e-01f, 2.10731670e-01f, -3.49533677e-01f, -9.15753692e-02f,
  6.84839040e-02f, -7.01368377e-02f, -1.64738260e-02f, 8.42469931e-02f, 1.74448371e-01f, 3.23885642e-02f, 3.84636479e-03f, -1.26641737e-02f, -1.15375265e-01f, -8.49800110e-02f,
  2.77774613e-02f, 1.93658054e-01f, -1.17460422e-01f, -1.54598176e-01f, -8.59347954e-02f, -7.74019910e-03f, 1.72555987e-02f, -1.32410869e-01f, 9.69595835e-02f, -1.70331486e-02f,
  -8.86361003e-02f, 2.70397235e-02f, 8.65796730e-02f, -6.55362010e-02f, 7.31528131e-03f, -6.27807230e-02f, -1.64142083e-02f, -8.63330718e-03f, -1.61029994e-01f, -2.24465087e-01f,
  -1.39520001e-02f, 3.41193490e-02f, 8.27652663e-02f, -4.74946573e-02f, 5.13563901e-02f, -5.48395002e-03f, -1.80622190e-01f, 1.21878587e-01f, -1.22372426e-01f, 3.50406691e-02f,
  -2.54486073e-02f, 1.34759977e-01f, 5.31427301e-02f, 4.25318033e-02f, -6.43717423e-02f, 1.29511967e-01f, 1.88128427e-01f, 2.05509618e-01f, 7.42616132e-02f, -6.24864921e-02f,
  5.51117696e-02f, 7.73647875e-02f, 1.34414226e-01f, 1.17722072e-01f, -5.68209924e-02f, -1.50999025e-01f, -1.49714947e-01f, 1.26210436e-01f, 1.36112824e-01f, -2.08978262e-02f,
  -1.66237261e-02f, -1.07944831e-01f, -1.06399320e-01f, 1.17250383e-01f, 1.56015933e-01f, 8.43770653e-02f, 4.05385830e-02f, 9.81029402e-03f, 7.90257193e-03f, -2.22785827e-02f,
  -1.54446485e-02f, -1.16968341e-01f, 5.15123196e-02f, -1.17748693e-01f, 1.74606577e-01f, 1.65205970e-02f, 6.46285564e-02f, -1.98041752e-01f, 1.18142538e-01f, 1.73937067e-01f,
  1.47969192e-02f, 6.60580248e-02f, 2.43492015e-02f, -5.85403219e-02f, 1.15680605e-01f, 8.13137293e-02f, 1.22063123e-01f, -9.74108279e-02f, -5.23497909e-02f, -1.35201454e-01f,
  6.36484548e-02f, -1.37834102e-01f, -1.24704599e-01f, -5.45147210e-02f, -2.79138163e-02f, -9.85008478e-03f, 2.15223581e-02f, -6.84669614e-02f, 1.22393489e-01f, -2.76518036e-02f,
  -8.57681618e-04f, -1.04001909e-03f, -2.81888936e-02f, -8.43970552e-02f, 4.86483797e-02f, -7.98188820e-02f, 2.02012122e-01f, 9.08509046e-02f, -1.30715147e-01f, -6.72759116e-02f,
  7.36403689e-02f, -7.39136189e-02f, 1.11402482e-01f, 7.26226494e-02f, 1.34626523e-01f, 9.33529735e-02f, -1.62863597e-01f, 2.04961732e-01f, -1.18774280e-01f, -1.04440615e-01f,
  -1.15405373e-01f, -1.26912117e-01f, -5.31374477e-02f, 5.97257353e-02f, 8.24453011e-02f, -1.02502674e-01f, 7.31084421e-02f, 7.44781941e-02f, 8.96468386e-02f, -3.11164800e-02f,
  1.77254871e-01f, 9.44684967e-02f, 1.41395852e-01f, -3.60143259e-02f, 1.14330882e-02f, 5.61085530e-02f, 1.21470079e-01f, -4.96212430e-02f, -1.29688963e-01f, 7.04294667e-02f,
  1.01154484e-01f, -2.27159902e-01f, 1.98926628e-02f, 1.93367276e-04f, 1.81049295e-02f, -6.09127097e-02f, -1.14540331e-01f, 1.33765206e-01f, 8.90865549e-02f, 1.20472267e-01f,
  1.82516024e-01f, 8.46522674e-02f, -1.57875091e-01f, 8.73801019e-03f, -9.10940394e-03f, -8.56879950e-02f, -7.29605108e-02f, -6.11556992e-02f, 5.68280779e-02f, 7.95415416e-02f,
  -9.20153186e-02f, -6.80063739e-02f, -1.50916753e-02f, -5.62444292e-02f, 9.27165970e-02f, 5.59046715e-02f, 6.55933470e-02f, -2.50609607e-01f, 6.01460151e-02f, 2.02542409e-01f,
  -2.17911229e-01f, -1.89496040e-01f, -1.52229503e-01f, -7.49394821e-04f, 1.85962260e-01f, -7.14300498e-02f, -2.82180101e-01f, 1.13275938e-01f, 8.79523382e-02f, -8.96029472e-02f,
  1.14390282e-02f, 8.83150194e-03f, 2.06650980e-02f, -5.93435355e-02f, 6.48826733e-02f, 1.80514768e-01f, -8.19883421e-02f, -1.34745073e-02f, 8.69755894e-02f, 1.48638725e-01f,
  2.11147845e-01f, 5.11026606e-02f, -1.38827696e-01f, -3.73456962e-02f, -2.45890860e-02f, 4.37166616e-02f, -8.53472948e-02f, -8.02668482e-02f, -2.27279633e-01f, -1.30271733e-01f,
  -1.80474832e-03f, -3.55210109e-03f, -2.31485099e-01f, 2.22903728e-01f, -5.40876351e-02f, -3.73103693e-02f, -1.10164210e-01f, -1.68414325e-01f, 2.27407336e-01f, -1.25376880e-01f,
  2.14545801e-01f, -1.22945733e-01f, 1.64539307e-01f, 6.10368028e-02f, 1.84819967e-01f, -2.03140993e-02f, 6.77305833e-02f, -2.16936581e-02f, 1.34851366e-01f, -1.24108009e-01f,
  7.20449835e-02f, 1.23986145e-02f, -2.30313409e-02f, 8.63617659e-03f, -2.23889705e-02f, -1.73457796e-04f, 6.73050135e-02f, 1.47285625e-01f, -1.55759426e-02f, -1.42022884e-02f,
  1.77001446e-01f, -1.04423895e-01f, 1.81147859e-01f, 5.02417469e-03f, 3.35964747e-02f, -2.22636923e-01f, -3.22105177e-02f, -1.19293228e-01f, 5.21595925e-02f, -2.07283929e-01f,
  9.62032303e-02f, 1.91667341e-02f, -1.40355349e-01f, -5.38376719e-02f, -2.07410846e-02f, -8.04103166e-02f, 2.70648906e-03f, 9.25034508e-02f, 1.68452978e-01f, -3.28049175e-02f,
  1.16239905e-01f, -1.13690242e-01f, 4.56996076e-02f, -2.04449102e-01f, 3.04050624e-01f, 2.01953948e-02f, -1.83430493e-01f, -1.17031500e-01f, -4.89109233e-02f, -1.82495356e-01f,
  -1.70263410e-01f, 9.16850790e-02f, 2.13171989e-02f, 7.22717643e-02f, -1.23101816e-01f, -1.04570776e-01f, 2.63170898e-02f, 3.82141136e-02f, 7.47431442e-02f, 1.47149703e-02f,
  6.40203105e-03f, -7.34377801e-02f, 1.37181297e-01f, 2.91896667e-02f, -7.98935294e-02f, -1.71790812e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -1.00167379e-01f, -7.74558932e-02f, 9.34501365e-02f, -4.95024025e-02f, -9.69561115e-02f, -1.70513261e-02f, -6.97581992e-02f, 7.04448521e-02f, -2.13908479e-02f, 5.63154668e-02f,
  -3.37942061e-03f, -4.54161428e-02f, 1.10204607e-01f, 4.40781265e-02f, 1.08151838e-01f, 2.43603103e-02f, 1.48512959e-01f, 4.66780066e-02f, 1.34741127e-01f, -1.82671234e-01f,
  4.52738963e-02f, 1.16449490e-01f, -2.12289747e-02f, 3.45498621e-02f, -8.98471475e-02f, -1.32008731e-01f, 6.45850226e-02f, -4.84614819e-02f, -3.88909318e-02f, 1.90561071e-01f,
  -8.28061029e-02f, 6.77980557e-02f, 9.84408427e-03f, -3.55795845e-02f, -4.84411530e-02f, 1.01307156e-02f, 5.80457635e-02f, 6.44559041e-02f, -1.07577637e-01f, 3.02238129e-02f,
  -2.33744159e-02f, -4.09380794e-02f, 7.67780170e-02f, 1.09546721e-01f, 1.53602645e-01f, -3.99042852e-02f, -9.77523401e-02f, -1.20146319e-01f, -1.01554990e-01f, 6.72340766e-02f,
  -1.92692671e-02f, -1.03926755e-01f, -5.13415448e-02f, -9.18195993e-02f, 1.19690988e-02f, 6.67862296e-02f, 7.91054964e-02f, 1.08950660e-01f, -4.97483872e-02f, -1.04568645e-01f,
  3.33239622e-02f, 9.55060571e-02f, 9.30565000e-02f, 1.17564201e-01f, 1.83211982e-01f, 2.89289564e-01f, 1.49773717e-01f, 1.15837850e-01f, 8.82500261e-02f, 4.01043482e-02f,
  1.06814206e-01f, 2.03872710e-01f, 1.15063019e-01f, -2.65631318e-01f, 9.56535935e-02f, 1.92140803e-01f, 3.50418948e-02f, 1.45326443e-02f, 1.72715649e-01f, -1.28712013e-01f,
  -8.14688799e-04f, 1.55949160e-01f, -6.17986396e-02f, 1.07741006e-01f, -1.83270976e-01f, 1.58297375e-01f, 1.03533216e-01f, 1.70368135e-01f, -1.53067604e-01f, 2.94181466e-01f,
  2.28959844e-01f, 2.63220310e-01f, -7.45355785e-02f, 6.90244064e-02f, 2.58197069e-01f, 1.53686911e-01f, -1.74958974e-01f, 3.41642141e-01f, -7.40326270e-02f, -1.05174899e-01f,
  -3.20946872e-01f, -1.25529855e-01f, -5.20202219e-02f, 4.49742600e-02f, -9.66818854e-02f, 3.32857579e-01f, -1.52802736e-01f, 4.58628275e-02f, 8.44524130e-02f, -2.25217268e-02f,
  2.88814396e-01f, 3.61101180e-01f, 4.74023044e-01f, -5.08134887e-02f, -8.66731331e-02f, -1.23202384e-01f, 1.07437912e-02f, -1.74035598e-02f, 5.92163531e-03f, -4.62098382e-02f,
  -4.24042456e-02f, -3.81142527e-01f, 9.09983143e-02f, 4.19629961e-01f, 6.77374840e-01f, 2.48311125e-02f, 5.23172878e-02f, 1.33625358e-01f, 2.28658244e-01f, -9.49655399e-02f,
  -4.36744541e-02f, -7.31435977e-03f, -1.57778431e-02f, 2.01315820e-01f, 4.83780280e-02f, -9.01666470e-03f, 1.60764292e-01f, 8.19832459e-02f, -4.16773595e-02f, 4.75020055e-03f,
  2.08126903e-01f, 1.26016811e-01f, 8.47115740e-02f, 2.78687421e-02f, 1.00179181e-01f, 1.91365436e-01f, 9.56500620e-02f, -2.24417701e-01f, 1.68687090e-01f, -7.19598532e-02f,
  2.10642025e-01f, -2.22009033e-01f, -4.46968973e-02f, -3.14466000e-01f, -1.81829169e-01f, -2.14848042e-01f, 4.58532684e-02f, 5.62971719e-02f, -5.76016493e-02f, -1.41078994e-01f,
  -1.08082898e-01f, -1.36109352e-01f, -3.10197055e-01f, 4.80426662e-02f, 6.55852631e-02f, -1.35436267e-01f, -1.52785972e-01f, 5.95733635e-02f, 1.97812766e-01f, -9.30859968e-02f,
  2.85021633e-01f, -5.97113511e-03f, -2.84365527e-02f, 9.64243561e-02f, -2.74777338e-02f, -1.69150531e-01f, 9.54416394e-02f, 8.31287056e-02f, 5.42530529e-02f, 7.27013052e-02f,
  7.97649771e-02f, -1.11937694e-01f, -3.07620645e-01f, 1.12601802e-01f, 8.63840505e-02f, 1.70135811e-01f, -1.58726200e-01f, -1.95229486e-01f, 9.61521119e-02f, -6.37962343e-03f,
  2.75529385e-01f, 4.52900818e-03f, 6.33163601e-02f, -5.00129461e-02f, -1.90165527e-02f, -8.18936750e-02f, 5.40264957e-02f, -9.69060585e-02f, -6.33773208e-02f, -4.81839143e-02f,
  -2.29544137e-02f, 1.09709375e-01f, -2.84822751e-02f, -9.79953930e-02f, -6.71139956e-02f, 1.96995512e-02f, 1.11047074e-01f, -8.11129287e-02f, -7.39496350e-02f, -4.60266620e-02f,
  5.54183759e-02f, -4.72950824e-02f, 1.23639636e-01f, -4.59559150e-02f, -6.64651692e-02f, -7.43053406e-02f, -9.00249779e-02f, 3.54239643e-02f, 1.69132985e-02f, 1.52061969e-01f,
  1.73029006e-01f, 4.93216477e-02f, 6.48681074e-04f, 8.36096257e-02f, 5.72712198e-02f, 2.70861592e-02f, -9.47663710e-02f, -8.76775980e-02f, -7.68679678e-02f, 3.90377343e-02f,
  1.56561397e-02f, -1.07580341e-01f, -9.32247043e-02f, 6.35412112e-02f, -9.25930887e-02f, 4.68920097e-02f, 1.98618799e-01f, 1.03531461e-02f, -4.67571989e-02f, -5.29745314e-03f,
  -1.36149107e-02f, 1.41631812e-01f, 1.90137327e-02f, 7.82349333e-03f, -1.23043582e-01f, 1.71012543e-02f, 1.57779500e-01f, -1.07484400e-01f, 1.03005096e-01f, -8.59510899e-02f,
  -4.36547138e-02f, 2.64979690e-01f, -4.76667695e-02f, 1.62701324e-01f, 1.07592531e-02f, 1.57206476e-01f, -1.17126606e-01f, -5.38640581e-02f, -5.68145961e-02f, -1.28457835e-02f,
  2.63182018e-02f, -8.18907320e-02f, 4.54806387e-02f, -9.54772383e-02f, -1.17261611e-01f, -2.47793272e-02f, -1.18604630e-01f, 1.11796111e-01f, 8.46550837e-02f, 4.65238206e-02f,
  -1.01338036e-01f, -9.72778052e-02f, 5.32851964e-02f, -4.95358855e-02f, 9.44804624e-02f, 3.28442384e-03f, -7.56165609e-02f, -7.12572858e-02f, -1.68554503e-02f, -3.56375659e-03f,
  1.08060956e-01f, 1.07883103e-01f, -5.46992384e-02f, -9.95349735e-02f, -6.34827912e-02f, 8.43401775e-02f, 1.19925283e-01f, 1.06199294e-01f, -7.10544176e-03f, 2.68130563e-02f,
  -1.40714973e-01f, -7.41491560e-03f, -6.77480847e-02f, -2.95311753e-02f, 6.88703954e-02f, -2.52014548e-02f, -7.88120460e-03f, 4.08875309e-02f, 5.85755594e-02f, 4.27028425e-02f,
  -1.41986823e-02f, 3.69998403e-02f, -8.65901075e-03f, -8.14331546e-02f, 1.10401839e-01f, 1.13931850e-01f, 7.09148347e-02f, 3.91054899e-02f, -6.40018061e-02f, -9.13432315e-02f,
  -5.32581918e-02f, -1.00818932e-01f, 6.68688565e-02f, -8.12850799e-03f, -6.19888306e-03f, 1.53991655e-01f, 1.47820422e-02f, 1.08318411e-01f, -3.17496508e-02f, 1.10766301e-02f,
  1.08328581e-01f, -1.04549609e-01f, 2.62191687e-02f, -8.40483084e-02f, 2.70708203e-01f, 4.80542071e-02f, 1.80003308e-02f, 4.00443897e-02f, 8.93510878e-02f, -8.50458369e-02f,
  1.54993251e-01f, 2.69268841e-01f, 1.48018420e-01f, -2.84514017e-02f, 6.17960934e-03f, 1.01202711e-01f, 2.32466385e-01f, 1.36080086e-01f, 1.82769775e-01f, 2.77347594e-01f,
  1.13410152e-01f, -3.77556011e-02f, 1.93387389e-01f, 1.63816199e-01f, -2.34372333e-01f, 1.16197236e-01f, 1.10890992e-01f, -5.91455884e-02f, -4.76003289e-02f, -4.30878371e-01f,
  1.70899883e-01f, 1.57257751e-01f, -1.55214474e-01f, -5.96043244e-02f, -8.81923139e-02f, -1.89974517e-01f, -1.22896641e-01f, 1.30340472e-01f, 2.30710313e-01f, 9.97742191e-02f,
  1.59755722e-01f, -2.20759168e-01f, 3.25242162e-01f, -7.67922103e-02f, -2.07804635e-01f, -4.94327098e-02f, 3.03490341e-01f, -1.50169022e-02f, 1.58031240e-01f, 7.04827458e-02f,
  3.01766396e-01f, 5.61436377e-02f, -3.52708111e-03f, -9.81516540e-02f, 1.78912640e-01f, -1.00039601e-01f, 9.98676494e-02f, 7.31926262e-02f, 5.29641705e-03f, 2.26523414e-01f,
  4.00475502e-01f, 1.13102958e-01f, -1.95311591e-01f, -2.41834283e-01f, -2.48395409e-02f, -1.09320834e-01f, 8.87895375e-02f, -1.27348989e-01f, 9.79342163e-02f, 4.86720093e-02f,
  7.57710934e-02f, 5.60691021e-02f, -1.39565438e-01f, -4.04159799e-02f, 6.69492111e-02f, 7.08494186e-02f, -8.87100622e-02f, 4.26620208e-02f, 1.46166487e-02f, -4.52518314e-02f,
  -6.67490363e-02f, -1.29499868e-01f, 7.83545002e-02f, 9.75696370e-02f, -3.53854075e-02f, 2.82309782e-02f, 3.76625889e-04f, 7.79582709e-02f, -1.19875912e-02f, -1.17167383e-01f,
  -7.63973147e-02f, -6.23192713e-02f, 9.17426124e-02f, -9.11654234e-02f, 4.52277027e-02f, -2.25616395e-02f, 7.00528249e-02f, 1.31141186e-01f, 6.50271848e-02f, -3.95999253e-02f,
  -9.12446454e-02f, -3.96919856e-03f, -1.03580713e-01f, -2.50541116e-03f, -4.50597368e-02f, -2.02846471e-02f, -3.14584002e-02f, -4.08762954e-02f, 2.53905468e-02f, 8.67037624e-02f,
  -7.60478433e-03f, -7.35218674e-02f, -1.08604454e-01f, 2.82356124e-02f, -1.07748911e-01f, 9.43329593e-04f, -3.52191739e-02f, 1.14151150e-01f, 1.01693392e-01f, 1.60737541e-02f,
  5.81345297e-02f, -3.19146700e-02f, -2.33474579e-02f, -3.61564644e-02f, 3.56785581e-02f, 1.49289712e-01f, 5.68798818e-02f, -1.70495044e-02f, 7.07080066e-02f, -1.48053199e-01f,
  -1.06561137e-02f, 1.05048142e-01f, 7.97016248e-02f, -8.50488804e-03f, -4.90741096e-02f, 1.27555370e-01f, 4.52284366e-02f, -1.10907368e-01f, 1.66506872e-01f, 1.11936443e-01f,
  1.05319552e-01f, 1.16365090e-01f, 2.60209683e-02f, 2.25187950e-02f, 9.95102674e-02f, 1.07974604e-01f, -7.50087574e-02f, 2.11124763e-01f, -1.77648902e-01f, 1.20221183e-01f,
  -1.11992985e-01f, 2.36405917e-02f, 1.05948977e-01f, 1.68627039e-01f, 2.91103646e-02f, 2.04421237e-01f, -1.28049865e-01f, -3.55545222e-03f, 1.08876422e-01f, -1.09351510e-02f,
  -3.86731029e-02f, 2.02465519e-01f, 1.05108172e-01f, 6.35624528e-02f, -1.53277129e-01f, -1.13251515e-01f, -7.47815445e-02f, -1.21739544e-02f, -1.05850361e-01f, 9.03856307e-02f,
  -1.62717521e-01f, -2.70168688e-02f, -4.88383844e-02f, 9.35252979e-02f, 1.81828476e-02f, 1.70461103e-01f, -1.27592823e-02f, -9.55004394e-02f, -5.26838601e-02f, 5.67510650e-02f,
  -7.43124112e-02f, -8.98879915e-02f, 1.00839071e-01f, 1.95007436e-02f, 4.96410914e-02f, 2.10956428e-02f, -1.46449208e-01f, -5.15054166e-02f, 1.35433981e-02f, 3.32210809e-02f,
  -9.18357298e-02f, -4.02505994e-02f, 5.79677522e-02f, -4.33710515e-02f, -2.16552466e-02f, -1.27968103e-01f, 6.20044582e-02f, 9.06295925e-02f, 9.75672081e-02f, -3.87940332e-02f,
  -1.25958743e-02f, -3.43912952e-02f, -1.21887401e-01f, -5.35572432e-02f, -3.64618301e-02f, -4.84199747e-02f, 1.40467584e-01f, 8.35304633e-02f, 1.45523697e-01f, 5.08562177e-02f,
  4.45028720e-03f, 9.14553180e-02f, -1.37988552e-01f, 4.06751484e-02f, 1.77894458e-02f, -5.67864217e-02f, 8.38944223e-03f, -1.29442006e-01f, -5.14618568e-02f, -1.02736756e-01f,
  6.07708059e-02f, 9.11378115e-02f, -1.40911400e-01f, 8.30999315e-02f, 8.45165104e-02f, 1.31335100e-02f, 7.95284100e-03f, 4.94352989e-02f, 1.27306908e-01f, -1.41440287e-01f,
  -1.51178613e-02f, 5.62130823e-04f, 3.54399346e-02f, 2.17384204e-01f, -7.67878965e-02f, 7.04014897e-02f, 5.16589358e-02f, -1.28161699e-01f, 1.47681847e-01f, -4.53512184e-02f,
  1.13383904e-01f, 5.95211536e-02f, -1.13012092e-02f, -6.20746799e-02f, 6.36550933e-02f, -2.21021101e-02f, -4.10088263e-02f, 2.66896874e-01f, 7.71942958e-02f, 7.52728581e-02f,
  -1.49242982e-01f, -9.10035446e-02f, 4.47217859e-02f, -1.73226185e-02f, 2.38909706e-01f, -1.03728753e-02f, 2.09478110e-01f, 8.64614323e-02f, 1.62810795e-02f, 1.99873477e-01f,
  2.07670808e-01f, -1.69482678e-01f, -2.32083350e-02f, 3.03587578e-02f, 1.81475505e-01f, -1.16885088e-01f, 6.21190220e-02f, -1.57979816e-01f, 1.83772877e-01f, -2.62271892e-02f,
  1.16084784e-01f, 5.60187995e-02f, -8.96439478e-02f, 2.49596357e-01f, 7.80896619e-02f, -1.83928624e-01f, 1.09337062e-01f, -3.14077772e-02f, 5.52623235e-02f, -1.21535525e-01f,
  -1.65624246e-01f, -2.18845472e-01f, 1.91531982e-02f, -1.65873915e-01f, 1.85485482e-01f, 1.19734004e-01f, 1.47326640e-03f, -2.14562546e-02f, -1.30179659e-01f, 2.10769195e-02f,
  -1.88532043e-02f, -8.83523449e-02f, 2.46176615e-01f, -1.04529269e-01f, 4.79769781e-02f, 3.60828452e-02f, 2.29561597e-01f, -1.53678119e-01f, 1.51609644e-01f, 5.48786111e-02f,
  -3.11139245e-02f, -4.49143536e-03f, -8.69606659e-02f, 8.21212530e-02f, -1.64687142e-01f, 8.58038217e-02f, 9.67046916e-02f, 6.93498328e-02f, 1.22073077e-01f, -1.06326967e-01f,
  1.19322706e-02f, 1.56797677e-01f, -3.55114304e-02f, 2.11359747e-02f, 1.51065700e-02f, 1.11019500e-01f, 1.02675602e-01f, 2.24957466e-02f, 1.64494619e-01f, -5.32924384e-02f,
  -1.03166260e-01f, 6.43447367e-03f, 6.42998293e-02f, -1.07959643e-01f, -1.52021959e-01f, 6.84179142e-02f, 4.28082719e-02f, 1.39798343e-01f, 6.13294207e-02f, 2.91701406e-02f,
  -1.06050566e-01f, -1.51047140e-01f, 1.07879750e-01f, -6.31889254e-02f, -2.76963022e-02f, -6.22036308e-02f, 1.27443761e-01f, -5.11903204e-02f, -9.46201757e-02f, -1.36659294e-01f,
  -1.89761460e-01f, -5.12592727e-03f, -9.59238335e-02f, -1.35152519e-01f, 4.51733582e-02f, -4.78545669e-03f, -1.35261029e-01f, -5.06320186e-02f, -3.93833816e-02f, 4.20152135e-02f,
  -7.25574940e-02f, -7.00972304e-02f, 2.76852567e-02f, 1.17529996e-01f, 1.01275712e-01f, 7.73807839e-02f, 1.34823546e-01f, -1.55564547e-01f, -6.89793080e-02f, 6.02847636e-02f,
  8.79407004e-02f, 6.02798630e-03f, 4.90511954e-02f, 6.69784099e-02f, 1.86176926e-01f, 6.72009736e-02f, 2.51205098e-02f, -1.10388614e-01f, 1.99662641e-01f, -8.92773047e-02f,
  -6.19844310e-02f, -8.96369293e-02f, 1.24028683e-01f, -3.44891921e-02f, -8.65005776e-02f, 9.18376818e-02f, -9.70132351e-02f, 1.77067429e-01f, 1.23838417e-01f, -1.08811088e-01f,
  5.13605848e-02f, -8.62071589e-02f, 8.06923360e-02f, 1.42532378e-01f, 9.71610099e-02f, -5.95685989e-02f, 2.77784374e-02f, -5.39056137e-02f, -7.88782835e-02f, 6.74502999e-02f,
  3.34368013e-02f, 7.07855150e-02f, -8.51287767e-02f, -7.27281533e-03f, 7.02899471e-02f, -1.03045724e-01f, 1.31796990e-02f, -7.95053467e-02f, 2.41228957e-02f, -1.30969465e-01f,
  -4.03147601e-02f, 1.60722411e-03f, 1.26778046e-02f, 1.77127421e-02f, 6.43661767e-02f, 4.89630699e-02f, -3.40601206e-02f, 7.96200056e-03f, 4.48130406e-02f, 1.07977480e-01f,
  1.17442258e-01f, 8.37008804e-02f, -7.03833252e-02f, 3.59185115e-02f, 7.97479078e-02f, -8.50508809e-02f, 1.02220938e-01f, -5.71774058e-02f, -1.02276824e-01f, 9.89229083e-02f,
  -3.56820673e-02f, -2.51267590e-02f, -1.47741046e-02f, -1.23158172e-01f, 3.39669511e-02f, 1.93162635e-02f, 7.65405968e-02f, 1.64052323e-02f, -1.15079738e-01f, 9.17680189e-03f,
  1.81221310e-02f, -1.11360535e-01f, 9.79779437e-02f, -1.54980319e-02f, -6.68917820e-02f, -9.85605046e-02f, 1.68272816e-02f, -3.26729119e-02f, -2.08927486e-02f, -9.65744555e-02f,
  2.59541571e-02f, -8.63407701e-02f, -9.34056193e-02f, -5.34109883e-02f, 6.29110634e-02f, 6.97313026e-02f, 8.51167515e-02f, -1.08285278e-01f, 8.44977424e-02f, -1.14329504e-02f,
  -5.83422706e-02f, -4.51303720e-02f, 2.89449189e-02f, 3.78876589e-02f, 7.86830857e-02f, -6.10999055e-02f, 2.64968947e-02f, -1.11439802e-01f, 1.05309300e-01f, 3.25127766e-02f,
  -5.61290095e-03f, -5.18011041e-02f, -2.90283021e-02f, -9.06837657e-02f, 6.17736541e-02f, -1.03545614e-01f, -1.38189672e-02f, -1.75258949e-01f, -7.44727924e-02f, 1.56403363e-01f,
  -2.88355537e-02f, 1.06491350e-01f, -1.06384240e-01f, 1.26695051e-03f, -6.03389069e-02f, 9.27566066e-02f, -7.64931887e-02f, 1.65406466e-01f, 1.42077550e-01f, 1.03684096e-02f,
  7.90466368e-02f, 7.98656568e-02f, 1.32396832e-01f, -1.16494253e-01f, 4.65306826e-02f, 1.93590879e-01f, 5.90405893e-03f, 1.22026414e-01f, 1.67790860e-01f, 1.16591968e-01f,
  1.65618718e-01f, -3.30582820e-02f, -8.81613174e-04f, -8.58175755e-02f, -4.49001044e-02f, -3.61464061e-02f, -1.48862526e-01f, 6.58200160e-02f, 2.39869896e-02f, 1.19086176e-01f,
  7.63088837e-02f, -2.58393865e-02f, 5.54611273e-02f, 3.04559898e-02f, 5.33913411e-02f, 1.98782697e-01f, 2.00109392e-01f, -3.16490717e-02f, -5.22836410e-02f, -7.92399719e-02f,
  -1.66509926e-01f, 1.40990466e-01f, 5.11244386e-02f, 2.03704655e-01f, -1.92831811e-02f, -1.15478830e-02f, -2.02166229e-01f, 3.19015421e-02f, 1.15922756e-01f, 1.67785004e-01f,
  1.00482866e-01f, 8.45686644e-02f, 5.19266427e-02f, -2.74624042e-02f, -7.35319555e-02f, 3.32398899e-02f, 2.23429635e-01f, 5.58905378e-02f, 5.61148077e-02f, -2.26051316e-01f,
  -6.62547424e-02f, -2.46333987e-01f, -5.50598241e-02f, -1.12759382e-01f, -1.47022352e-01f, -3.21299545e-02f, 5.85844144e-02f, -1.10362746e-01f, -1.25199661e-01f, -6.37264550e-02f,
  -4.84984480e-02f, 3.91894430e-01f, -6.51126131e-02f, -3.39747332e-02f, 1.57511353e-01f, -1.18254364e-01f, 1.46400994e-02f, 2.48313770e-01f, 2.09158391e-01f, -1.82040557e-01f,
  -1.31222129e-01f, -5.62350452e-02f, 2.42168382e-01f, 2.75826544e-01f, 6.50433823e-02f, 9.46405157e-02f, 2.54496306e-01f, 8.53591934e-02f, -9.93734226e-02f, -1.26018584e-01f,
  -2.87851617e-02f, 4.42996472e-02f, -1.75199687e-01f, 6.78289011e-02f, -4.49111238e-02f, 3.91927175e-03f, -8.67580101e-02f, 3.69464785e-01f, 1.25534087e-01f, 2.22958654e-01f,
  7.43750408e-02f, -8.83137807e-02f, 1.11942798e-01f, 7.91410506e-02f, 2.44228542e-01f, 2.48820618e-01f, 5.70127107e-02f, -5.48568219e-02f, 4.41363603e-02f, -8.22319239e-02f,
  -5.26028164e-02f, 6.71386300e-03f, 2.91746985e-02f, 3.26752686e-03f, -6.44068001e-03f, -9.03614685e-02f, -5.33017665e-02f, -3.66759971e-02f, 1.40684983e-03f, -9.62701961e-02f,
  3.16409506e-02f, 2.69808043e-02f, 4.04273756e-02f, -1.05203286e-01f, -8.54540467e-02f, 6.25494570e-02f, -5.25468327e-02f, -1.21318929e-01f, -1.05370484e-01f, -3.80762271e-03f,
  -3.80946463e-03f, -7.82218874e-02f, -9.23088789e-02f, 4.92416695e-03f, 5.48049947e-03f, -6.49187937e-02f, 1.20847024e-01f, 7.11571127e-02f, 9.90869403e-02f, 1.29527375e-02f,
  -5.71464859e-02f, 1.95392650e-02f, 2.31426489e-02f, 9.70110446e-02f, -8.73263851e-02f, 7.50373602e-02f, 1.01818979e-01f, -2.99236923e-02f, 8.52412656e-02f, -6.36673570e-02f,
  1.64848678e-02f, -5.41682653e-02f, -6.68329075e-02f, 1.37129184e-02f, -1.19210564e-01f, 9.16689783e-02f, 8.87765512e-02f, -8.84911492e-02f, -1.70732848e-02f, 8.63599479e-02f,
  1.20042466e-01f, 2.18720897e-03f, -8.21153522e-02f, -8.89272913e-02f, -1.17748985e-02f, -4.15745936e-02f, -5.43548609e-04f, -1.06040925e-01f, 1.08277455e-01f, -6.42299652e-02f,
  -8.00298452e-02f, -6.19460130e-03f, -1.84669737e-02f, 8.00711010e-03f, -5.17163165e-02f, 7.03108758e-02f, 5.25838323e-02f, -4.08835821e-02f, -8.69029164e-02f, -6.64054006e-02f,
  -9.38646197e-02f, -3.99385132e-02f, -8.31725076e-02f, -4.29706834e-03f, -1.36971902e-02f, -6.17559813e-02f, 1.09238699e-02f, 1.79477073e-02f, 2.10165232e-02f, 5.64337745e-02f,
  -1.02570087e-01f, 1.15192257e-01f, 2.72248015e-02f, 4.29849140e-02f, -1.20856859e-01f, -2.03685127e-02f, -6.52159005e-02f, 1.47279641e-02f, -5.51964976e-02f, 5.26105752e-03f,
  -8.43202546e-02f, 1.19640119e-01f, 3.03072147e-02f, -1.08176872e-01f, -8.49333480e-02f, -3.27116922e-02f, -1.10706925e-01f, 2.25887205e-02f, 5.94221503e-02f, 1.20102249e-01f,
  7.65680820e-02f, -1.03615366e-01f, -4.77753021e-02f, 8.52496922e-02f, 6.99717328e-02f, 6.00665435e-02f, -9.89636481e-02f, -1.17093720e-01f, -7.06749782e-02f, -1.97979771e-02f,
  -9.29889455e-02f, -9.95184705e-02f, -7.22465366e-02f, -9.79259610e-02f, 9.16198641e-03f, -2.97573837e-03f, -3.33803557e-02f, -4.70225327e-02f, -1.11215621e-01f, 1.15212910e-01f,
  1.03572635e-02f, -6.96784928e-02f, 1.08916201e-01f, -1.53411720e-02f, 5.62479720e-02f, 1.40849501e-01f, -1.31394133e-01f, -8.69825035e-02f, -5.24255782e-02f, 2.15330020e-01f,
  -5.98154068e-02f, -1.41361067e-02f, -1.35745117e-02f, 1.81391731e-01f, -6.90445378e-02f, -2.58919429e-02f, 1.56303659e-01f, 6.92320839e-02f, -5.45698889e-02f, 2.57397536e-02f,
  -1.29924163e-01f, 2.37545073e-01f, -1.84172779e-01f, 9.98416021e-02f, -1.46362722e-01f, -3.53042111e-02f, -8.41388851e-02f, 3.18923518e-02f, -1.02398731e-01f, -7.18164667e-02f,
  -5.47622815e-02f, 1.30188778e-01f, 1.44475535e-01f, 1.36362225e-01f, -2.42315784e-01f, 2.13638067e-01f, -1.32048264e-01f, 2.03082964e-01f, 1.04073912e-01f, 2.90001184e-01f,
  -1.94935769e-01f, -3.20979625e-01f, -1.95777923e-01f, -1.06445245e-01f, -8.10059682e-02f, 1.25482291e-01f, -1.65902480e-01f, -1.18927315e-01f, 1.75523773e-01f, 3.86012755e-02f,
  1.42015964e-01f, 1.29074350e-01f, 3.61851782e-01f, -6.00527637e-02f, -5.74768856e-02f, -2.77731474e-03f, 2.77397167e-02f, -9.53891724e-02f, 5.56466579e-02f, 1.75188303e-01f,
  -8.14772863e-03f, -1.54241815e-01f, -1.20493449e-01f, 8.59244689e-02f, 9.20402184e-02f, -1.46250531e-01f, 1.93969145e-01f, 1.18381970e-01f, -5.64351715e-02f, 5.29662780e-02f,
  7.84568414e-02f, 1.15445303e-02f, -6.50062487e-02f, -3.32962573e-02f, -3.21878605e-02f, 1.08972356e-01f, -4.87889759e-02f, 8.31801221e-02f, -1.04853503e-01f, 4.16176580e-02f,
  -8.61836001e-02f, 5.93657233e-02f, -8.15438405e-02f, -6.49266914e-02f, 7.97492191e-02f, 2.83870548e-02f, 5.48856370e-02f, 9.75290984e-02f, -2.16379035e-02f, -8.23675394e-02f,
  -6.16027340e-02f, 1.08644605e-01f, 2.75541209e-02f, 7.58163109e-02f, -7.60166049e-02f, 2.29413882e-02f, -4.34494838e-02f, -6.73278496e-02f, 1.22581586e-01f, 9.14394483e-02f,
  -9.11605358e-02f, -8.51551071e-02f, 3.66117842e-02f, -4.47235517e-02f, 6.32753968e-03f, 7.34812543e-02f, -8.30414817e-02f, 8.34219754e-02f, 9.05661434e-02f, -7.51437992e-02f,
  1.17225787e-02f, -1.29074007e-02f, -6.27435595e-02f, -7.77151659e-02f, -9.33376625e-02f, -1.72245763e-02f, -5.54699972e-02f, 1.05655067e-01f, 7.58196861e-02f, -2.62449998e-02f,
  6.64994400e-03f, -1.90688428e-02f, -3.65964398e-02f, 2.08811685e-02f, -8.49667862e-02f, -1.02743842e-01f, -4.32324037e-02f, 8.62457454e-02f, -8.95522013e-02f, 5.81010431e-02f,
  9.16462392e-02f, 4.38821502e-03f, 8.08479041e-02f, 1.13988362e-01f, 2.74597675e-01f, 2.03947872e-01f, 5.68054207e-02f, -3.49051356e-02f, 1.82562172e-01f, 6.44195825e-02f,
  1.79165035e-01f, -4.80265319e-02f, 4.05279770e-02f, 1.89850584e-01f, 1.90741479e-01f, 8.74450281e-02f, 2.72346854e-01f, 1.90936074e-01f, 1.53674260e-01f, -4.41831350e-02f,
  2.60541201e-01f, -1.19447164e-01f, -1.86908487e-02f, 2.49464765e-01f, -1.97584435e-01f, -4.66134883e-02f, -1.79057062e-01f, 1.31745368e-01f, 2.10680649e-01f, -7.58649036e-02f,
  -3.25096726e-01f, -1.23511672e-01f, 1.67041019e-01f, -1.85283124e-01f, -3.08271847e-03f, -7.68783465e-02f, 1.71026230e-01f, -1.11257970e-01f, 1.42536789e-01f, 2.92550717e-02f,
  1.09315842e-01f, -6.32606372e-02f, 1.96325064e-01f, 3.15567821e-01f, 7.96685368e-02f, 4.06755470e-02f, -7.29689151e-02f, -2.06321720e-02f, 3.66985388e-02f, 3.67433839e-02f,
  -9.27274376e-02f, -1.15546644e-01f, -8.63766819e-02f, -1.16759248e-01f, -8.46411884e-02f, -1.12661242e-01f, 2.50512570e-01f, 2.25249290e-01f, 9.00313780e-02f, 2.84128264e-02f,
  5.47170341e-02f, -4.39216308e-02f, 4.27482814e-01f, -3.38259339e-02f, -5.55929542e-02f, -1.93128120e-02f, -5.64563237e-02f, 1.22828729e-01f, -1.04185179e-01f, 1.19458206e-01f,
  -6.31832406e-02f, -9.18115824e-02f, -3.23984213e-02f, 1.26684934e-01f, 5.46840467e-02f, 5.91679662e-02f, -3.62644717e-02f, -9.94016882e-03f, -9.24630761e-02f, -1.06174543e-01f,
  4.19960544e-02f, -5.33469915e-02f, 1.16339386e-01f, -1.21048875e-01f, -9.51347053e-02f, -1.63519811e-02f, 6.76147314e-03f, -4.30488959e-02f, 1.68472044e-02f, 6.28990531e-02f,
  -4.31949496e-02f, 1.07186161e-01f, 6.27577528e-02f, 1.01547003e-01f, -6.20401986e-02f, 5.83887137e-02f, -8.72115269e-02f, -4.56091464e-02f, 1.27905995e-01f, 8.70180205e-02f,
  1.39413968e-01f, 7.13295490e-02f, -3.94823737e-02f, 3.55757624e-02f, 1.15730397e-01f, 5.73013611e-02f, -3.15254740e-02f, -5.37533164e-02f, 2.03860495e-02f, 1.05718076e-01f,
  2.16045100e-02f, 4.43094894e-02f, 1.29838988e-01f, 8.65754038e-02f, -3.48146111e-02f, 1.95819791e-02f, 5.82396202e-02f, -7.47863427e-02f, -6.03981912e-02f, -3.68507691e-02f,
  1.24666020e-01f, 1.50453867e-02f, 9.47587043e-02f, 1.43239558e-01f, 4.75845858e-02f, 8.77219439e-02f, -1.00519091e-01f, 3.82805541e-02f, -1.10291205e-01f, -5.79361990e-02f,
  -2.73716170e-02f, -1.71272591e-01f, -5.05837463e-02f, 4.46942858e-02f, 1.22884654e-01f, -1.74550782e-03f, 1.14595838e-01f, 2.96756439e-02f, 8.57525170e-02f, 1.23153321e-01f,
  -9.11601335e-02f, 1.03395425e-01f, -7.11538792e-02f, 2.29728408e-02f, -8.43926445e-02f, -3.11475657e-02f, 1.72497451e-01f, 1.55009896e-01f, 8.02914128e-02f, 2.00504616e-01f,
  -5.83653860e-02f, 3.12185250e-02f, 5.53440377e-02f, -2.15817317e-02f, 1.66868806e-01f, 1.86721366e-02f, -2.22720839e-02f, 1.86938029e-02f, -8.89826268e-02f, -8.50677490e-02f,
  -8.70372206e-02f, -1.60614643e-02f, -1.32543147e-01f, -1.82014480e-01f, -4.30106483e-02f, -1.03442550e-01f, -8.68105218e-02f, -6.53512105e-02f, 5.59189282e-02f, -1.05710991e-01f,
  -2.98794955e-02f, 1.37037173e-01f, -3.99369560e-02f, 9.03879255e-02f, -1.37151405e-01f, -9.00460705e-02f, 6.92508146e-02f, -8.01692903e-02f, 1.80986390e-01f, -1.28616706e-01f,
  2.62685895e-01f, -6.15171380e-02f, -1.13280945e-01f, 1.00186385e-01f, 1.57144561e-01f, -1.57204241e-01f, 3.57334949e-02f, 1.86894938e-01f, -1.19698867e-01f, 1.30672649e-01f,
  -1.08213827e-01f, -6.49198294e-02f, 6.76423237e-02f, -1.15355939e-01f, 2.09619384e-02f, -6.12812787e-02f, 2.94096265e-02f, 8.35530460e-02f, 1.31115034e-01f, -1.33977801e-01f,
  -6.59290031e-02f, 1.36738867e-01f, -1.16807535e-01f, -9.35184304e-03f, 9.86134857e-02f, 3.41971144e-02f, 4.64988872e-02f, 1.40456110e-01f, 1.49244905e-01f, -1.15312397e-01f,
  -1.02066420e-01f, 3.87323312e-02f, -1.20521285e-01f, -1.26848400e-01f, -5.48646003e-02f, -9.33985710e-02f, -5.43619655e-02f, 1.05032980e-01f, -6.68966472e-02f, -3.25617380e-02f,
  1.85199603e-02f, -3.16515169e-03f, -8.87454227e-02f, 6.91582710e-02f, -6.28736839e-02f, 2.71932930e-02f, 5.82430512e-02f, 1.37109771e-01f, -9.21230167e-02f, 1.23855621e-01f,
  -8.09038281e-02f, 4.02706787e-02f, -6.66194633e-02f, -7.47908792e-03f, -5.36738150e-02f, -9.79681611e-02f, 6.31488934e-02f, -1.05519839e-01f, -4.67741080e-02f, -9.71619785e-02f,
  -6.10236451e-02f, -9.11973193e-02f, -2.92856041e-02f, 5.46288453e-02f, -4.32352768e-03f, 9.02497545e-02f, -1.09137408e-01f, -2.20761597e-02f, 3.82230505e-02f, -7.33447671e-02f,
  -1.03837118e-01f, -9.33837593e-02f, 1.10332720e-01f, 1.86469808e-01f, -5.02438769e-02f, 2.87796073e-02f, -6.19224459e-02f, 2.15000529e-02f, 1.68523580e-01f, 2.10057572e-01f,
  -8.01025406e-02f, -1.02288410e-01f, 4.87010777e-02f, -4.04526247e-03f, -1.21336102e-01f, 1.19537719e-01f, 3.52364480e-02f, 1.05688963e-02f, 1.22373700e-01f, 7.14249387e-02f,
  -1.24867167e-03f, -7.92334378e-02f, 1.87314991e-02f, 2.66290940e-02f, 8.85073617e-02f, 2.37573795e-02f, 4.35268544e-02f, -3.49503383e-02f, -3.35287452e-02f, -1.28799126e-01f,
  1.77961797e-01f, -1.41979918e-01f, -2.38250211e-01f, -3.43490280e-02f, 5.51565364e-02f, -5.84679320e-02f, 6.06412888e-02f, -1.39341518e-01f, -1.76686458e-02f, 1.52027562e-01f,
  -8.09443891e-02f, -2.22973991e-02f, -1.98109761e-01f, 7.39815906e-02f, 2.92501622e-03f, -8.96244571e-02f, -7.06066266e-02f, -1.03185602e-01f, 2.02449784e-01f, -1.08598836e-01f,
  2.74875104e-01f, 6.40695170e-02f, -6.78242072e-02f, -5.20365313e-02f, -3.76222767e-02f, -5.75207323e-02f, 1.41522318e-01f, 1.03263170e-01f, -2.70329714e-02f, -5.62231876e-02f,
  -2.07367800e-02f, -1.96067691e-02f, -3.97262760e-02f, 5.72189949e-02f, 5.48780560e-02f, -1.92873850e-01f, 3.24668437e-02f, -7.57623836e-02f, 3.30372751e-01f, 1.16954572e-01f,
  6.89476877e-02f, -9.50591937e-02f, 1.59824386e-01f, -6.05691178e-03f, 5.61376400e-02f, 2.38651678e-01f, 1.29057094e-01f, 2.13842824e-01f, 7.39425048e-02f, 1.80846795e-01f,
  -6.75851665e-03f, 1.05406605e-01f, 2.09426850e-01f, -6.33181632e-02f, 1.95790436e-02f, 2.69847900e-01f, -1.43795796e-02f, 1.79873809e-01f, 2.07254216e-02f, 6.13049716e-02f,
  1.95835039e-01f, -8.55223462e-02f, 3.09523433e-01f, -2.66904950e-01f, -1.20609343e-01f, 7.60052959e-03f, 1.83643654e-01f, -2.47611269e-01f, -8.11218247e-02f, 9.81988832e-02f,
  3.00835192e-01f, -8.80282521e-02f, -2.45543107e-01f, 9.31386724e-02f, 1.77027747e-01f, -2.45990559e-01f, -1.82658732e-01f, 1.83624387e-01f, 8.57144445e-02f, 6.29038811e-02f,
  1.02050975e-02f, 1.12400994e-01f, 1.29771069e-01f, 1.43782208e-02f, 9.48943570e-03f, 1.43556846e-02f, -4.23274338e-02f, -1.05255395e-01f, 1.86244603e-02f, 5.59330627e-04f,
  -2.12385237e-01f, -2.19878070e-02f, 4.35715586e-01f, -1.04033805e-01f, -1.51615385e-02f, -1.18745893e-01f, 2.18744879e-03f, -3.98347303e-02f, 1.01576835e-01f, 3.93264771e-01f,
  -4.65612300e-02f, 3.43847096e-01f, -3.72816741e-01f, -8.73192027e-02f, -8.88317823e-02f, 9.95480418e-02f, 1.64622083e-01f, -6.07595816e-02f, 1.30390659e-01f, 1.51051477e-01f,
  7.36242309e-02f, -7.51802872e-04f, 2.21936598e-01f, 1.43146977e-01f, 9.63289589e-02f, -1.52534517e-02f, 7.41791278e-02f, 1.09433219e-01f, 6.46712780e-02f, 5.71153872e-02f,
  5.96357696e-02f, 2.32740045e-01f, -3.56749967e-02f, -7.66279921e-02f, 1.95265502e-01f, -9.02018026e-02f, 2.84192026e-01f, -1.23289362e-01f, -1.64503172e-01f, 4.88913544e-02f,
  1.69876084e-01f, 2.94292234e-02f, -5.21091111e-02f, 4.95599350e-04f, 2.91033909e-02f, 1.58228338e-01f, -3.99822509e-03f, 2.01887228e-02f, 1.78400636e-01f, -2.07779273e-01f,
  -3.56550813e-02f, -2.49603353e-02f, 2.82716006e-02f, 3.45360562e-02f, 5.07561490e-02f, 1.42410696e-01f, 1.85311101e-02f, 1.89442247e-01f, 2.62937676e-02f, -1.20100461e-01f,
  -1.26401022e-01f, -3.59311700e-02f, -1.66348502e-01f, 1.42750535e-02f, -2.40074188e-01f, -1.09118737e-01f, 3.06283385e-01f, 7.46943429e-02f, 5.90402335e-02f, -6.00935295e-02f,
  2.17883155e-01f, 1.62007347e-01f, -3.11416630e-02f, 5.01185656e-01f, -3.90804373e-02f, 3.57218087e-01f, -3.45781595e-01f, -3.33473720e-02f, -2.51596398e-03f, 3.03248689e-02f,
  1.22270525e-01f, -1.28565699e-01f, 9.12571140e-03f, -1.31723925e-01f, 4.72708046e-02f, -8.23982060e-02f, -8.86853337e-02f, -2.34105736e-02f, -1.00314103e-01f, -1.74228504e-01f,
  -6.53095022e-02f, 5.88927642e-02f, -5.17657101e-02f, 1.25104457e-01f, 5.80829270e-02f, -1.08317554e-01f, -6.41899928e-02f, 1.68255437e-02f, 7.34664127e-02f, -1.26776665e-01f,
  1.13884591e-01f, 1.12099677e-01f, -6.05656765e-03f, 5.06322533e-02f, 8.56692865e-02f, 8.10635164e-02f, 1.32449090e-01f, -4.14295048e-02f, 1.19885996e-01f, 9.60310996e-02f,
  -6.68035224e-02f, 1.26280159e-01f, 1.09167725e-01f, -2.66138036e-02f, 1.16982423e-01f, 1.68328546e-02f, 8.12287256e-03f, 1.23946443e-01f, -3.60255651e-02f, 1.06579021e-01f,
  8.28640833e-02f, 8.95867944e-02f, -1.10727467e-01f, -1.02420002e-01f, -9.50866938e-02f, -1.03909764e-02f, -4.59180214e-03f, 4.73561548e-02f, 2.56507881e-02f, -3.38987224e-02f,
  1.14003330e-01f, 2.59764753e-02f, -5.12933582e-02f, 4.23799865e-02f, 1.16648994e-01f, 1.70037523e-01f, 2.20284406e-02f, 7.80780837e-02f, -8.90320018e-02f, 4.49953526e-02f,
  -2.80374326e-02f, 7.20433742e-02f, 4.17778827e-02f, 9.07754973e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  9.32928175e-02f, 3.61527652e-02f, 1.88078552e-01f, -1.13352984e-01f, -4.52992730e-02f, 3.28311995e-02f, 1.11261971e-01f, 7.80988708e-02f, -5.02100140e-02f, -1.72627736e-02f,
  1.43237993e-01f, -7.98972994e-02f, 9.18683186e-02f, 1.23633191e-01f, -7.16754124e-02f, -1.31922485e-02f, 1.15892678e-01f, -3.73021811e-02f, 1.56823713e-02f, 8.97481814e-02f,
  4.04364169e-02f, -7.36603737e-02f, -2.05476135e-02f, 1.62897781e-01f, 1.00753717e-01f, -9.33802575e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -1.84204176e-01f, -3.26465935e-01f, -2.38939911e-01f, -2.85986453e-01f, -3.29547167e-01f, 2.97651142e-02f, -1.97238907e-01f, -1.88332200e-01f, -3.21784705e-01f, -1.59822226e-01f,
  -2.36056700e-01f, 1.57926574e-01f, -6.07415885e-02f, 1.08753093e-01f, -3.44816335e-02f, 5.40386774e-02f, 3.23000401e-02f, -2.71780908e-01f, -7.99454190e-03f, 9.25641432e-02f,
  -8.91626626e-02f, -9.18459371e-02f, 1.13500301e-02f, 1.52553633e-01f, -2.67831564e-01f, 5.64305633e-02f, -8.04608390e-02f, -7.69121200e-02f, -9.19047967e-02f, 2.04474982e-02f,
  -8.57149884e-02f, 5.20593822e-01f, 1.25737801e-01f, 2.68148333e-01f, -1.19230106e-01f, -2.76727855e-01f, 8.09609890e-02f, -1.46300688e-01f, 1.31029248e-01f, 2.02744287e-02f,
  -1.60953760e-01f, -3.99928018e-02f, -8.11510012e-02f, -2.24802613e-01f, -8.18010420e-03f, -1.31616369e-01f, 6.80550039e-02f, -2.24633276e-01f, 2.18605429e-01f, -2.20728107e-02f,
  3.43044639e-01f, 3.86233896e-01f, -1.08814850e-01f, 8.28155503e-02f, -2.38907486e-01f, 1.01717070e-01f, 4.43274558e-01f, 3.98274772e-02f, 5.89839034e-02f, 8.52207318e-02f,
  -1.79183275e-01f, -4.60766256e-01f, 1.56882972e-01f, 1.63474217e-01f, 3.51965837e-02f, 2.06285000e-01f, 2.81862259e-01f, -2.51571268e-01f, -1.20250508e-01f, -2.73239791e-01f,
  3.01551656e-03f, -2.76434720e-01f, -8.82982537e-02f, 4.26195636e-02f, -3.24434005e-02f, 3.60698879e-01f, 1.81781396e-01f, 2.58706719e-01f, -1.46967739e-01f, -6.97816163e-02f,
  -7.71822184e-02f, -2.36865692e-02f, 7.32155442e-02f, 1.62977353e-01f, 5.44974469e-02f, 2.24092200e-01f, -4.41599399e-01f, -8.13572928e-02f, 5.32550886e-02f, -1.04975946e-01f,
  2.22689569e-01f, 3.27374101e-01f, -1.61550328e-01f, 8.56632888e-02f, 9.31962579e-03f, 4.00882989e-01f, 2.61570096e-01f, -5.45233786e-01f, 3.49134415e-01f, 1.78734392e-01f,
  3.47730927e-02f, 1.10011928e-01f, -2.68860329e-02f, 4.56945240e-01f, -3.15186769e-01f, 3.54764372e-01f, 7.70762190e-02f, 2.91084528e-01f, 1.09348729e-01f, -4.97083366e-02f,
  -3.78972024e-01f, 3.33445311e-01f, -2.68709511e-01f, -3.45277600e-02f, 2.35601261e-01f, -2.30404392e-01f, 1.03870891e-01f, 1.47227133e-02f, -2.97542870e-01f, 1.29011750e-01f,
  2.89542556e-01f, 5.52217662e-03f, -2.61307657e-01f, 1.64675802e-01f, 2.00571492e-02f, -1.76484853e-01f, -4.01124172e-02f, 1.21546574e-01f, 2.57806391e-01f, 2.41315618e-01f,
  1.56471118e-01f, 3.32692832e-01f, 2.06265360e-01f, -1.49560317e-01f, 3.01677078e-01f, 2.10136518e-01f, 1.50058344e-02f, 9.43857878e-02f, -5.23876399e-02f, 8.54926333e-02f,
  -1.70812920e-01f, 2.52728015e-01f, -7.40984008e-02f, 8.73717144e-02f, -1.25677109e-01f, 3.76302451e-01f, -2.22917125e-01f, 1.69237807e-01f, 3.56419496e-02f, -2.93426327e-02f,
  1.90930255e-02f, 8.66215080e-02f, 4.55901116e-01f, -2.61763036e-01f, -3.47509742e-01f, -1.61463097e-01f, 9.69685987e-02f, 3.19379747e-01f, 1.27816796e-01f, -2.08947718e-01f,
  2.12154210e-01f, -1.94304705e-01f, -1.28570125e-01f, -1.28858402e-01f, -8.53589475e-02f, 1.15940817e-01f, -2.29286522e-01f, -6.00646615e-01f, -2.84664631e-01f, -1.59648389e-01f,
  1.06855556e-02f, 4.03575182e-01f, -5.69747053e-02f, -4.85980511e-02f, -6.66475073e-02f, 6.85750395e-02f, -1.96195260e-01f, -9.82344374e-02f, -3.79618667e-02f, -2.11343944e-01f,
  -4.98597212e-02f, -2.34781951e-02f, -2.74214536e-01f, -6.56593665e-02f, 2.60118514e-01f, 1.47951692e-01f, 1.47119507e-01f, 3.41791995e-02f, -2.03854233e-01f, 4.15651977e-01f,
  4.20818985e-01f, 4.93348837e-02f, -1.16396010e-01f, -1.22367486e-01f, -2.13512615e-03f, 8.55372399e-02f, 3.64718318e-01f, 1.70626491e-01f, 1.68083429e-01f, 2.29017138e-01f,
  4.37065065e-02f, 2.44908839e-01f, 4.37677652e-01f, -2.81332731e-01f, 1.05732270e-01f, -2.00308651e-01f, -1.77649543e-01f, -1.06585771e-02f, 2.58127507e-02f, 9.28127244e-02f,
  1.23709209e-01f, 2.70225167e-01f, -2.46797621e-01f, 1.35980278e-01f, -1.27280295e-01f, 1.96120605e-01f, 3.94778341e-01f, 4.04022411e-02f, 1.08076468e-01f, -1.70576870e-01f,
  -6.68944865e-02f, 1.07097961e-01f, -1.53385535e-01f, -1.29309312e-01f, -2.21402302e-01f, 3.94073933e-01f, -7.36937672e-02f, 7.28494301e-02f, 1.61405757e-01f, -7.37793222e-02f,
  -1.57552899e-03f, 1.19016819e-01f, 2.14023027e-03f, -1.31752789e-01f, -1.19866692e-01f, -4.76674378e-01f, 1.99024542e-03f, 1.73058119e-02f, 3.01541388e-01f, 4.48938459e-02f,
  2.77252227e-01f, -6.63961023e-02f, -1.25448152e-01f, 3.26792717e-01f, -4.26949468e-03f, -1.53562054e-02f, 6.18627071e-01f, -7.67699629e-02f, -6.61806986e-02f, -1.63731128e-01f,
  -1.11205608e-01f, -3.97088937e-02f, -1.28246889e-01f, -1.49173394e-01f, -1.12822592e-01f, 4.19655479e-02f, 2.14854896e-01f, -2.55906224e-01f, 9.35188681e-02f, 1.42907098e-01f,
  -4.84615356e-01f, -3.04967225e-01f, 2.40033701e-01f, 2.12248161e-01f, -1.56607062e-01f, 2.43347719e-01f, 2.07602307e-01f, -9.99888871e-03f, 3.33236381e-02f, 1.50800720e-01f,
  3.36964607e-01f, -2.73881376e-01f, -7.19779059e-02f, -1.34930089e-01f, 3.29977646e-03f, 5.60495332e-02f, -3.70123059e-01f, 2.38831118e-01f, -2.87543654e-01f, 2.72100687e-01f,
  2.45730668e-01f, 2.30206653e-01f, 7.70527050e-02f, -3.10951203e-01f, -2.77535230e-01f, 4.09281731e-01f, -3.39743197e-01f, -2.09584504e-01f, -8.10145959e-02f, 1.18510731e-01f,
  -2.11714149e-01f, -1.54321998e-01f, 4.20798659e-01f, 2.54491955e-01f, 2.28601411e-01f, -5.56673229e-01f, 1.49709314e-01f, 4.82603759e-02f, 1.28682092e-01f, -5.67669630e-01f,
  8.75672922e-02f, -6.67972118e-02f, -1.08317450e-01f, -4.94782515e-02f, 1.00558043e-01f, 4.12129834e-02f, 1.01929687e-01f, 5.53159416e-01f, -6.11150004e-02f, -2.60650776e-02f,
  -2.16796562e-01f, -3.89101394e-02f, 2.12671489e-01f, -1.09817863e-01f, -1.46504804e-01f, 6.73491135e-02f, -5.15798777e-02f, 2.39730030e-01f, 3.03213924e-01f, -1.92329213e-01f,
  9.04983003e-03f, -1.49432318e-02f, 1.08229876e-01f, 1.90780297e-01f, 5.49223237e-02f, -3.40443738e-02f, 2.07480922e-01f, 7.64484517e-03f, 2.03030035e-01f, 2.31895491e-01f,
  3.05305302e-01f, 5.29561192e-02f, 1.99270006e-02f, -4.56047356e-01f, 1.72823101e-01f, 2.43969448e-02f, -3.94323654e-02f, -2.16877729e-01f, -7.49320462e-02f, 6.29438534e-02f,
  -3.49264033e-02f, 1.57450274e-01f, -1.80596486e-01f, 4.27015983e-02f, 1.53053969e-01f, 3.50420438e-02f, -3.88045073e-01f, -4.04094279e-01f, 2.63997078e-01f, 3.92985076e-01f,
  3.11044574e-01f, -2.99805760e-01f, -3.75017792e-01f, -2.60026544e-01f, -1.65294692e-01f, 1.22149754e-02f, 3.95283282e-01f, 3.03041637e-01f, 3.62013355e-02f, 1.99301958e-01f,
  3.96398425e-01f, 3.57083529e-02f, 2.69402564e-03f, 3.24987531e-01f, -4.86926623e-02f, -1.81085601e-01f, 9.68722478e-02f, 6.77283108e-02f, -8.59368145e-02f, -9.34849158e-02f,
  -2.32458159e-01f, -1.76801272e-02f, 6.73677176e-02f, -3.67699079e-02f, -2.45898008e-01f, -9.23308730e-02f, 3.83166760e-01f, -8.35603476e-02f, 1.59224644e-01f, -1.12456888e-01f,
  2.26175219e-01f, -2.25919038e-01f, -2.06532389e-01f, -5.58198690e-02f, -1.89191669e-01f, -8.31693858e-02f, -4.34534669e-01f, -3.79997671e-01f, -1.00985013e-01f, 4.18528244e-02f,
  8.49718601e-03f, 2.65190285e-02f, 1.62648648e-01f, -1.54818714e-01f, 1.92786425e-01f, 2.27964818e-01f, -1.89272210e-01f, 7.44558945e-02f, -5.99520281e-02f, -3.48605141e-02f,
  1.23912603e-01f, -3.41788858e-01f, 5.32686859e-02f, -3.48026633e-01f, 4.19381171e-01f, -2.50330001e-01f, 9.18165445e-02f, -4.93919492e-01f, -2.55074352e-01f, -1.28506541e-01f,
  3.06004494e-01f, 3.05541933e-01f, 9.33490172e-02f, -3.54807377e-01f, 7.21252039e-02f, 7.33579695e-02f, 6.41513467e-02f, -2.44773656e-01f, -1.08593315e-01f, -8.77417251e-03f,
  -1.77703932e-01f, -6.12801686e-02f, 6.70374408e-02f, -4.06464368e-01f, 2.33522281e-01f, -1.50824234e-01f, 1.45526186e-01f, 5.86068511e-01f, -4.95983325e-02f, 1.00000426e-01f,
  -1.73193321e-01f, -6.89288527e-02f, -1.12709709e-01f, 3.96862216e-02f, 1.24338139e-02f, -5.03376126e-01f, 1.30061314e-01f, 6.18020631e-02f, -3.34719904e-02f, 1.31200150e-01f,
  -4.25665379e-01f, -1.19372539e-01f, 3.26968580e-01f, -1.42683476e-01f, 5.91324344e-02f, 3.32079560e-01f, 1.41992375e-01f, -1.40930727e-01f, -1.32865325e-01f, -2.33954340e-01f,
  6.55257553e-02f, 3.00704241e-02f, -4.42493856e-01f, 1.16723873e-01f, -3.76284212e-01f, -1.27484500e-02f, -8.27748626e-02f, -1.92097694e-01f, -5.52284181e-01f, -1.44080967e-01f,
  -2.31988937e-01f, -1.90991908e-01f, 1.86184123e-01f, 8.59972164e-02f, 3.45203243e-02f, -3.34108233e-01f, -1.76191367e-02f, -1.26748398e-01f, 2.93521315e-01f, -1.08711123e-01f,
  1.86214104e-01f, -1.52768061e-01f, -3.39417756e-01f, -1.71765879e-01f, 1.93585232e-01f, 1.01696752e-01f, 7.59975389e-02f, -1.74625352e-01f, -1.73030585e-01f, -9.93983969e-02f,
  2.40247492e-02f, 3.11463982e-01f, 2.18925163e-01f, 6.92451671e-02f, -1.17183276e-01f, -4.17575061e-01f, 1.05097316e-01f, 2.37478733e-01f, -2.72827804e-01f, 1.81599244e-01f,
  2.08635698e-03f, -2.22823486e-01f, 1.16735231e-02f, -8.44867080e-02f, -7.96957836e-02f, -1.31789431e-01f, 5.47608808e-02f, 1.18320212e-01f, -4.03027907e-02f, 8.93151164e-02f,
  4.27286737e-02f, -4.40124422e-02f, 2.71919459e-01f, 4.58357818e-02f, -4.90267575e-01f, 4.66365591e-02f, 2.72548907e-02f, 1.11146241e-01f, -2.63449460e-01f, 4.27608043e-01f,
  2.08811566e-01f, 5.80694452e-02f, 1.69974603e-02f, -1.24704413e-01f, -7.48471394e-02f, 1.06044516e-01f, -1.99043095e-01f, 1.33364886e-01f, 1.84349060e-01f, -8.62921327e-02f,
  5.95985865e-03f, -4.58382368e-01f, 3.01128954e-01f, -6.81000650e-02f, -1.32875383e-01f, -3.34358364e-02f, -1.83195469e-03f, -2.26250142e-02f, -3.24471235e-01f, 1.08093910e-01f,
  -6.33356869e-02f, -1.71238258e-01f, 1.31839752e-01f, -3.78623515e-01f, 2.20561936e-01f, -1.55963525e-01f, 2.22839594e-01f, 1.19264595e-01f, -2.67354250e-01f, 3.60958844e-01f,
  2.80971646e-01f, -3.20870966e-01f, 4.00190204e-01f, -7.80589432e-02f, -1.44799218e-01f, 2.16690764e-01f, 1.19843230e-01f, 2.24285111e-01f, -4.40081090e-01f, -1.81371704e-01f,
  2.21089814e-02f, 6.79795146e-01f, -3.08497071e-01f, -7.01369625e-03f, 1.21929258e-01f, 3.89139563e-01f, -2.45597232e-02f, 6.80870749e-03f, -1.25430763e-01f, -4.35165286e-01f,
  -5.48364595e-02f, -7.87700266e-02f, -1.04157431e-02f, -2.39818946e-01f, 1.26681283e-01f, 1.03918470e-01f, 1.13810711e-01f, 8.45416784e-02f, -1.36982605e-01f, 8.07320923e-02f,
  -8.79851207e-02f, -1.31631970e-01f, 3.28297503e-02f, -3.86667043e-01f, -3.69911492e-01f, 8.73064399e-02f, 2.44027123e-01f, 1.31456763e-01f, 1.72615215e-01f, 7.63666183e-02f,
  3.74529451e-01f, 4.88793105e-01f, -2.56535470e-01f, 2.09964648e-01f, 1.10487804e-01f, 6.70477673e-02f, 4.21204150e-01f, -1.88711673e-01f, -1.56981423e-01f, -1.51236663e-02f,
  -5.33428863e-02f, -1.29001647e-01f, -6.01932546e-03f, 1.48116499e-01f, -6.70176968e-02f, -5.52138649e-02f, 4.59365435e-02f, -3.48720491e-01f, 1.88057587e-01f, 1.07284255e-01f,
  -3.70422542e-01f, -2.42825463e-01f, 2.63851404e-01f, -1.21181421e-01f, 1.11465856e-01f, -1.89038873e-01f, -3.64454061e-01f, -1.33918330e-01f, -1.34496957e-01f, -2.70290077e-01f,
  -1.03653640e-01f, -1.26616627e-01f, -1.26061365e-01f, 2.34833181e-01f, 1.61691368e-01f, -6.51392758e-01f, 4.20133114e-01f, 8.29960108e-02f, -1.50928078e-02f, -3.26392949e-01f,
  -3.06012463e-02f, 8.39400887e-02f, -1.87064260e-02f, 2.23049894e-01f, 1.37301888e-02f, -1.95428878e-02f, 1.10018887e-02f, 1.67653501e-01f, -2.29654592e-02f, -9.79976133e-02f,
  -1.73701808e-01f, -9.96235013e-02f, -3.67206782e-01f, 4.26425114e-02f, -2.13514436e-02f, -8.50361399e-03f, -2.56891698e-01f, 5.38051009e-01f, 4.16032374e-01f, 1.48608908e-01f,
  -3.51559043e-01f, 6.39970899e-02f, -8.02863166e-02f, 8.67417976e-02f, 2.40628690e-01f, -2.78209805e-01f, -2.97616512e-01f, -1.89944848e-01f, 2.18553051e-01f, -1.81704052e-02f,
  -2.19104826e-01f, -6.60838094e-03f, 1.54494569e-01f, 2.84619242e-01f, -1.42827421e-01f, 1.29397690e-01f, -5.27236015e-02f, 2.17647046e-01f, 1.53328449e-01f, 3.18485439e-01f,
  -3.80658686e-01f, 2.83916891e-01f, -4.38655615e-02f, -3.13785970e-02f, 1.29256370e-02f, 9.36504304e-02f, -2.25134090e-01f, 2.13022843e-01f, -3.89829069e-01f, 3.68890047e-01f,
  3.22259754e-01f, 3.17069441e-01f, 4.90583256e-02f, 5.54512918e-01f, 7.22855553e-02f, -3.08417469e-01f, 1.44672751e-01f, -3.60337913e-01f, -1.17325179e-01f, 5.82099438e-01f,
  -3.83133709e-01f, -8.77688304e-02f, -4.00117133e-03f, -5.62017672e-02f, -5.99457622e-02f, 5.39737165e-01f, -1.12003103e-01f, -3.77218425e-01f, -1.62142679e-01f, 2.85084136e-02f,
  -1.45601302e-01f, -3.11157823e-01f, 6.70149643e-03f, 5.32730594e-02f, 1.64224833e-01f, -8.25659558e-02f, 2.60907829e-01f, 4.09082398e-02f, 1.37920186e-01f, 7.26569220e-02f,
  -1.72339574e-01f, -4.04268086e-01f, -2.71328241e-01f, -1.55247614e-01f, 2.73771405e-01f, 2.76231498e-01f, 2.02633496e-02f, -9.74842608e-02f, -2.96733272e-03f, -5.08246832e-02f,
  7.38694668e-02f, 1.28713533e-01f, 1.95957646e-01f, 8.09168071e-02f, -1.92601353e-01f, -1.54138133e-01f, -5.71266524e-02f, -1.67963937e-01f, 4.15190533e-02f, 2.52983361e-01f,
  -1.28884643e-01f, 1.79982767e-01f, 4.45488691e-02f, -1.13430835e-01f, 1.26862988e-01f, -1.79194078e-01f, 2.57173002e-01f, -3.68470907e-01f, -4.28141952e-01f, -3.15388113e-01f,
  3.19088459e-01f, -3.16402540e-02f, 2.76124686e-01f, -4.41563874e-01f, -3.35810870e-01f, -5.57115488e-02f, -2.36866809e-02f, -1.53583050e-01f, -1.36437207e-01f, 3.16208988e-01f,
  -1.37696251e-01f, 2.02807352e-01f, 1.25257010e-02f, 8.50898623e-02f, 3.70039642e-01f, -1.36229083e-01f, -4.30243053e-02f, 6.86511844e-02f, -1.04553483e-01f, -1.49499923e-01f,
  -1.35733150e-02f, 3.16402495e-01f, 1.51523054e-01f, -9.84859094e-02f, -6.61401227e-02f, 2.20633447e-01f, -8.13675374e-02f, -6.64365068e-02f, 3.52322757e-01f, -6.41473243e-03f,
  -2.07002729e-01f, -1.59813166e-01f, -3.38507622e-01f, 7.78093040e-02f, 5.06108165e-01f, -1.67929873e-01f, -6.16688311e-01f, -1.02180347e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  6.09988905e-02f, 1.11239284e-01f, 7.15874881e-02f, 4.43270197e-03f, 2.52767727e-02f, 5.45628481e-02f, 1.30689755e-01f, 3.76482755e-02f, 6.43120855e-02f, -5.45327403e-02f,
  1.13798557e-02f, 3.22371349e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    