/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.87508363e-01f, 2.70131946e-01f, 4.69097614e-01f, 8.76096934e-02f, -1.97450638e-01f, 1.13184184e-01f, 1.53804079e-01f, 3.11433643e-01f, -4.84153777e-02f, 1.06981754e-01f,
  -5.18186912e-02f, -6.77866489e-02f, 1.18913678e-02f, 9.67011601e-02f, -4.28427830e-02f, 1.59146205e-01f, 2.00946704e-02f, 1.58799924e-02f, 3.13792005e-02f, 1.39347240e-01f,
  9.98777375e-02f, -9.69389640e-03f, 2.59042829e-01f, 1.16487324e-01f, 8.99593681e-02f, 7.50306770e-02f, -2.23064460e-02f, 1.55855402e-01f, -1.46067739e-01f, 3.77569236e-02f,
  9.27296579e-02f, 1.09669119e-01f, 5.24083935e-02f, 8.09384659e-02f, 1.77960061e-02f, -5.15923165e-02f, -3.67232747e-02f, -8.64407420e-02f, -1.56468060e-02f, -2.16533756e-03f,
  -5.69552556e-02f, -1.76196732e-02f, 9.96948332e-02f, 4.30962555e-02f, -8.28401223e-02f, -1.64729413e-02f, -3.69895948e-03f, -4.83976153e-04f, 4.90705632e-02f, -3.00561218e-03f,
  6.44998774e-02f, 2.40457859e-02f, -4.81316000e-02f, 2.36759521e-02f, -1.26987770e-01f, 3.54017951e-02f, 6.27871454e-02f, 2.15883162e-02f, -6.81892922e-03f, -5.94419241e-02f,
  -5.45359850e-02f, 7.56771490e-02f, 1.96466353e-02f, -4.62143943e-02f, 1.05709760e-02f, 3.86251844e-02f, 5.65417968e-02f, -1.26366124e-01f, 2.46347301e-02f, -8.97666216e-02f,
  -2.48560943e-02f, 5.30086411e-03f, -7.93743059e-02f, 7.25327805e-03f, -4.55083139e-02f, 2.95824725e-02f, 3.23661529e-02f, -3.75442323e-04f, -7.62504190e-02f, 4.72863205e-03f,
  2.62852181e-02f, 1.01161599e-01f, 3.93468700e-02f, 8.92292522e-03f, 5.09774126e-02f, 6.16507977e-03f, 1.81867424e-02f, -4.62484453e-03f, 1.12304024e-01f, -5.61585054e-02f,
  3.09002176e-02f, 1.62350610e-01f, 5.17534204e-02f, -2.84528751e-02f, -2.13214960e-02f, -9.13699269e-02f, 7.03566195e-03f, 4.00713012e-02f, -2.51633655e-02f, 6.90264478e-02f,
  -2.78801303e-02f, 2.30912659e-02f, -4.68163453e-02f, 5.68486042e-02f, -2.37435438e-02f, 4.54184972e-03f, 5.92162050e-02f, -1.77579727e-02f, -6.64935932e-02f, -3.13404836e-02f,
  5.89424372e-02f, -2.37319730e-02f, 3.85885760e-02f, 1.34498049e-02f, -6.09473325e-02f, 2.08883751e-02f, -3.48670594e-02f, 4.16378304e-02f, 1.19809611e-02f, 1.33188274e-02f,
  -2.64365733e-01f, 3.24777812e-01f, -2.96667516e-01f, 4.33241785e-01f, -1.35239601e-01f, 1.44891366e-01f, 2.62696780e-02f, 1.04812793e-01f, 1.61463067e-01f, 3.61503005e-01f,
  1.34388253e-01f, 5.26693240e-02f, -2.00714115e-02f, 2.28258684e-01f, -4.26648617e-01f, 5.53058721e-02f, 1.27689205e-02f, 2.09381625e-01f, -1.07476443e-01f, 6.82545304e-02f,
  -1.02100939e-01f, 2.66712189e-01f, -2.52998412e-01f, -4.41882983e-02f, -2.08992481e-01f, -4.89201397e-02f, 8.95202626e-04f, -1.63633019e-01f, -7.21721426e-02f, -2.87269149e-02f,
  -6.41135648e-02f, 7.78996199e-02f, -6.63965791e-02f, -2.01800764e-02f, 5.34776151e-02f, -6.23797774e-02f, -3.57808322e-02f, -5.83233982e-02f, -4.21995930e-02f, 5.03726564e-02f,
  1.26727037e-02f, 1.78879742e-02f, 5.62750585e-02f, -3.19707990e-02f, 3.53993382e-03f, -4.12345976e-02f, -6.83905631e-02f, -1.20993555e-01f, -2.35133953e-02f, 2.03438774e-02f,
  -9.77811796e-05f, -5.10195345e-02f, -2.51703020e-02f, 2.70869490e-02f, -4.57151188e-03f, 8.82142186e-02f, 7.29521513e-02f, -3.64950821e-02f, 5.51614054e-02f, 7.77027979e-02f,
  1.85733680e-02f, -3.57211083e-02f, 1.94508824e-02f, -2.39097867e-02f, -4.34033386e-03f, 1.82018019e-02f, -7.47343665e-03f, 1.29529638e-02f, -5.94060495e-02f, 1.11069016e-01f,
  4.08599116e-02f, 8.01618844e-02f, -4.67191301e-02f, -4.91610989e-02f, 5.21326065e-02f, 2.98187137e-02f, -7.45573565e-02f, 2.16005780e-02f, 6.68177381e-02f, 1.68458968e-02f,
  8.62940121e-03f, -1.38409752e-02f, 1.50261878e-03f, -3.46602798e-02f, 9.16349590e-02f, -5.48647046e-02f, 3.74807939e-02f, -1.68978553e-02f, -6.33555204e-02f, -7.53628239e-02f,
  1.75495222e-01f, 2.48978853e-01f, 2.96883266e-02f, 6.66743815e-02f, 5.23102656e-02f, -5.43657355e-02f, -8.64652731e-03f, 9.34465975e-02f, 9.08381790e-02f, -8.30554217e-02f,
  4.96612415e-02f, -2.74850316e-02f, 1.28637487e-02f, -4.99801897e-02f, -4.86217476e-02f, 5.49205020e-02f, 7.92270526e-02f, 1.20763473e-01f, -2.72049140e-02f, 6.65398911e-02f,
  7.61900388e-04f, -3.34991440e-02f, 3.07296636e-03f, 3.84463393e-03f, 6.49560466e-02f, -7.39426613e-02f, -4.36152071e-02f, 1.00352868e-01f, -9.79318768e-02f, 4.36158739e-02f,
  -1.16016760e-01f, -3.32085639e-01f, -3.32108349e-01f, -4.79417264e-01f, 3.35660130e-01f, -2.37581134e-01f, -2.44999111e-01f, -1.57542806e-02f, -2.27518663e-01f, -5.21487966e-02f,
  1.00749284e-01f, -1.68068618e-01f, -1.58045087e-02f, -2.21362323e-01f, -1.30130380e-01f, -1.83189064e-01f, -4.06552643e-01f, -8.28962624e-02f, -7.62898475e-02f, -5.03839515e-02f,
  -1.06112882e-01f, -1.25843942e-01f, -2.55949646e-01f, 1.19723067e-01f, 5.90398386e-02f, -1.06785297e-01f, 2.96538491e-02f, 7.85730109e-02f, 1.52486861e-01f, 5.92468269e-02f,
  1.11011371e-01f, -7.30319247e-02f, 2.51988117e-02f, -8.24438706e-02f, 8.09459388e-02f, 2.10938905e-03f, -1.93958506e-02f, -3.64251211e-02f, -1.57915410e-02f, -3.97629365e-02f,
  -9.44741219e-02f, -4.02804539e-02f, 1.44699151e-02f, -2.92842872e-02f, 5.11576347e-02f, 4.26900350e-02f, 5.64366467e-02f, 2.73002032e-02f, 3.32480110e-02f, 5.27628511e-02f,
  4.94659580e-02f, -4.24009338e-02f, -9.07289460e-02f, -5.53208850e-02f, -5.14904819e-02f, -3.55488658e-02f, -7.24781677e-02f, 5.06663024e-02f, 4.46266048e-02f, 5.27190007e-02f,
  -1.12939954e-01f, -1.96151510e-02f, 1.03316307e-02f, 3.08178216e-02f, 8.11244175e-02f, 1.27976000e-01f, -4.26107720e-02f, 1.36877015e-01f, 3.86048444e-02f, 4.32553068e-02f,
  5.79710975e-02f, -4.38812152e-02f, 6.20434508e-02f, 5.48518784e-02f, 2.21759267e-02f, -2.79136002e-03f, 7.31109753e-02f, -6.43462837e-02f, 1.80945564e-02f, 1.27838865e-01f,
  -1.56056806e-01f, 8.66526142e-02f, -3.45617672e-03f, 2.86598317e-03f, 3.71175632e-02f, -6.80980161e-02f, -1.45469770e-01f, -4.64951433e-02f, 1.67958764e-03f, -6.65378245e-03f,
  1.07888617e-01f, 1.60396919e-01f, 1.57261845e-02f, 7.58732036e-02f, 1.90208312e-02f, 3.06236260e-02f, -5.96599393e-02f, 7.60608725e-03f, -1.47855312e-01f, 8.11003968e-02f,
  1.79124214e-02f, 1.02809437e-01f, 5.38358316e-02f, -1.38946753e-02f, -6.49387315e-02f, -1.91886723e-03f, -7.87673295e-02f, -8.24331716e-02f, 4.31915484e-02f, -6.43898770e-02f,
  -2.80579366e-02f, 5.26150241e-02f, 1.30254431e-02f, 9.43029895e-02f, 4.61437628e-02f, 9.56215337e-02f, 4.55879271e-02f, -2.75818110e-02f, 7.45745525e-02f, -2.27014683e-02f,
  -5.02591729e-01f, -3.22903901e-01f, -2.89809316e-01f, -1.57754168e-01f, 4.30137441e-02f, -3.04570764e-01f, -3.76327634e-01f, 1.05330020e-01f, -3.36866170e-01f, 1.09116308e-01f,
  -4.40068766e-02f, -1.34218082e-01f, -2.17196524e-01f, 7.00778514e-02f, -1.09916568e-01f, -2.27343678e-01f, 1.22620091e-02f, -3.59127037e-02f, -8.42153504e-02f, 4.78874408e-02f,
  2.16800869e-02f, 5.86860701e-02f, -6.08908907e-02f, 2.08716825e-01f, -1.66751355e-01f, -3.64414789e-02f, 3.81172568e-01f, -1.02945067e-01f, 1.96949318e-01f, -9.19192377e-03f,
  -1.17239855e-01f, -6.94700703e-02f, -4.43400331e-02f, -4.36924994e-02f, 5.16988803e-04f, 5.54564260e-02f, 7.84424916e-02f, 2.86743063e-02f, -3.07496693e-02f, 2.62873191e-02f,
  2.91900039e-02f, 2.75881262e-03f, 4.38775867e-03f, 1.42695326e-02f, -8.96500945e-02f, -4.89893928e-02f, -6.16702288e-02f, -4.01209146e-02f, 1.81233063e-02f, -6.00262322e-02f,
  -5.11727668e-02f, 4.08957303e-02f, -8.00430849e-02f, 4.16332856e-02f, 1.29975379e-02f, -4.56265882e-02f, -2.85294596e-02f, -1.04787489e-02f, 5.42757399e-02f, -2.97341011e-02f,
  4.73904535e-02f, -2.64922548e-02f, 5.95932268e-03f, 3.07155196e-02f, -5.00406735e-02f, 6.36513159e-02f, -9.26591398e-04f, 8.52659270e-02f, -4.06662636e-02f, 6.94098547e-02f,
  -2.49409992e-02f, 4.63928767e-02f, 8.73935670e-02f, -4.93432656e-02f, 1.75682816e-03f, 1.36534348e-01f, -7.21533736e-03f, 2.31602378e-02f, -9.74747017e-02f, 1.45138241e-02f,
  6.38435408e-02f, 3.89243215e-02f, 2.19861250e-02f, 7.58969188e-02f, 3.16089466e-02f, -5.11696599e-02f, 6.20448999e-02f, 3.74139263e-03f, -2.05036602e-03f, -6.71079010e-02f,
  1.69372931e-01f, 1.06361479e-01f, -1.23247597e-03f, 3.44403945e-02f, -3.85765769e-02f, 1.78167727e-02f, -3.37886997e-02f, 1.06932186e-01f, -2.17826199e-02f, -4.97500487e-02f,
  6.78841025e-02f, -5.47399037e-02f, 4.76618074e-02f, 4.17821109e-02f, 4.99518178e-02f, 4.88863960e-02f, 6.39783889e-02f, 7.44409813e-03f, 1.08914617e-02f, 5.14851063e-02f,
  -5.77333383e-04f, -3.24358232e-02f, -6.87635019e-02f, -5.73223680e-02f, -3.14700752e-02f, 5.54973632e-02f, -1.63502786e-02f, -7.08912387e-02f, 4.46177348e-02f, 1.95945911e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.49694875e-01f, 5.93439877e-01f, 1.18659899e-01f, 3.74228209e-01f, -3.20673957e-02f, -8.79903197e-01f, -6.60544336e-01f, 2.99159884e-01f, -2.18226239e-01f, 6.56718388e-02f,
  -2.08760984e-02f, 3.55467379e-01f, -3.34240310e-02f, -1.61135897e-01f, -5.49720347e-01f, -4.10093784e-01f, -3.19999516e-01f, -1.97872892e-01f, 1.03986040e-01f, 2.34042019e-01f,
  -1.06400810e-01f, 6.00754432e-02f, 3.62273566e-02f, 2.93134093e-01f, -2.07998287e-02f, 5.24947345e-01f, 4.16691154e-01f, 1.93415523e-01f, 3.29480052e-01f, -1.07468024e-01f,
  -3.34391773e-01f, -3.06592006e-02f, 9.48923230e-02f, -1.88303385e-02f, -1.29651383e-01f, -6.11113869e-02f, -2.98156105e-02f, -1.55546442e-01f, 6.91340640e-02f, 2.05544923e-02f,
  3.10977809e-02f, -8.83010551e-02f, -8.29380974e-02f, 3.54331583e-02f, -1.35292038e-01f, 1.95541605e-02f, 5.31241000e-02f, -6.94110664e-03f, -3.37628685e-02f, 6.96469173e-02f,
  5.40954694e-02f, 1.05842128e-02f, 8.92486572e-02f, 2.22231951e-02f, 1.36003271e-01f, -4.27239388e-02f, -7.82607496e-02f, -1.74737386e-02f, -4.01958749e-02f, 8.71413574e-02f,
  1.12146595e-02f, 2.69801188e-02f, 5.46370447e-02f, 2.03044433e-02f, -5.27477823e-02f, -6.52407780e-02f, -3.47307581e-03f, -1.84832178e-02f, -4.71908450e-02f, 1.24743115e-02f,
  2.53893584e-02f, 4.80830260e-02f, -3.96117233e-02f, -5.07225730e-02f, 1.42830089e-01f, 1.78368576e-02f, 2.05521379e-03f, 6.53058589e-02f, -1.52332500e-01f, 1.33650587e-03f,
  -1.82381384e-02f, -2.58695465e-02f, 7.14879483e-02f, -9.72554833e-02f, -2.24269733e-01f, 1.50535852e-01f, 5.32668410e-03f, 1.47999171e-02f, 5.87523170e-02f, -1.04714043e-01f,
  4.05554771e-02f, 4.22793716e-01f, 6.90202275e-03f, -3.04019768e-02f, -2.59025283e-02f, -1.37435108e-01f, -1.27107725e-01f, 5.37046567e-02f, 7.35750049e-02f, -6.68462366e-03f,
  5.78021146e-02f, -3.74929979e-02f, 6.41675219e-02f, -1.29754469e-01f, 1.47927841e-02f, 4.09293994e-02f, 5.10087237e-02f, 8.59269947e-02f, 5.29133203e-03f, 9.39276740e-02f,
  1.91585481e-01f, -8.81338194e-02f, -4.98604365e-02f, -5.81210777e-02f, 1.37536870e-02f, 4.44368497e-02f, 7.58625939e-02f, 1.11846089e-01f, 1.10894181e-02f, -3.62969339e-02f,
  6.46364689e-01f, -5.27462304e-01f, 6.66744709e-02f, 4.89759535e-01f, 4.52776253e-01f, -1.32056430e-01f, -4.83516194e-02f, 2.31194347e-01f, 3.56400520e-01f, -2.96272904e-01f,
  -9.72369686e-02f, -1.16052948e-01f, -2.94106752e-01f, 2.58234024e-01f, 1.76096678e-01f, -2.94088244e-01f, 1.10880658e-01f, -2.56831967e-03f, 7.14215487e-02f, 3.51922563e-03f,
  5.64364120e-02f, 2.45185718e-01f, 2.47988142e-02f, 6.55374378e-02f, 2.19287593e-02f, 1.41595751e-01f, -8.53416771e-02f, -1.43984959e-01f, -1.21011540e-01f, 1.58141464e-01f,
  -1.47825077e-01f, -5.85234771e-03f, -1.18481480e-02f, -1.13654770e-01f, -4.60643433e-02f, -1.96743622e-01f, -6.59961775e-02f, -6.95666969e-02f, 9.69188437e-02f, -9.17676240e-02f,
  -2.07656816e-01f, 4.22843546e-02f, 1.41045943e-01f, 9.98372734e-02f, -3.21163200e-02f, 1.03629649e-01f, 1.40080094e-01f, -3.30862030e-03f, 7.84083903e-02f, 3.21784392e-02f,
  -5.99453263e-02f, 6.43825531e-02f, -1.55676842e-01f, 1.46069378e-01f, -9.64621603e-02f, 8.83844644e-02f, -2.42411345e-02f, -4.76933494e-02f, -2.88242903e-02f, 7.42946640e-02f,
  -1.17939368e-01f, 6.25323206e-02f, -8.31789002e-02f, 1.40706347e-02f, -3.93594382e-04f, 8.70881751e-02f, 5.10707498e-03f, -4.17380817e-02f, -1.36837855e-01f, -7.19362795e-02f,
  4.78620902e-02f, 6.76516742e-02f, 5.01917340e-02f, -8.47678035e-02f, 1.36059774e-02f, 6.77658916e-02f, -4.83262129e-02f, -6.90067513e-03f, -9.61486250e-02f, 1.48996398e-01f,
  -3.87641080e-02f, 6.32344857e-02f, -8.57946798e-02f, 1.28921881e-01f, 8.53904709e-02f, -3.00809015e-02f, -9.60376635e-02f, -1.54151455e-01f, -5.02320267e-02f, 2.29403172e-02f,
  -6.76104426e-01f, -6.45894706e-01f, -1.09229818e-01f, 1.23873062e-03f, -1.17896825e-01f, -9.97122824e-02f, -3.21987867e-02f, 1.13140665e-01f, -1.44032851e-01f, -4.51766253e-02f,
  -1.60046909e-02f, -9.54211131e-02f, -1.23809464e-01f, 4.51534912e-02f, 6.61504455e-03f, -1.43739954e-01f, 1.46533526e-03f, -3.48676667e-02f, -1.54170692e-01f, -7.51302540e-02f,
  5.67829981e-02f, -1.52563035e-01f, 1.19323760e-01f, 3.31241935e-02f, -7.13350996e-03f, 3.81617770e-02f, -8.59427750e-02f, 1.73780054e-01f, -7.34378546e-02f, -2.84920167e-02f,
  -1.42651892e+00f, 3.65500331e-01f, -3.66134018e-01f, -7.57814944e-02f, -2.18042910e-01f, -1.77905217e-01f, 1.21688515e-01f, -6.47916039e-03f, -1.39716998e-01f, 1.64906755e-01f,
  2.59611785e-01f, -2.08530024e-01f, 3.10065955e-01f, 2.35237569e-01f, -6.85644925e-01f, 2.35231966e-01f, -7.45252669e-02f, -2.76817195e-02f, 1.16451114e-01f, -2.76399940e-01f,
  -2.45768607e-01f, 2.43178204e-01f, -1.11840710e-01f, 2.48421490e-01f, -8.82484317e-02f, -1.14092141e-01f, -3.65786590e-02f, 9.59279165e-02f, 2.84479046e-03f, 3.47916484e-02f,
  -3.86370718e-01f, -2.47762412e-01f, -1.40677899e-01f, -1.91200152e-01f, -2.01745719e-01f, -1.32924616e-01f, -1.09484650e-01f, 6.31415918e-02f, -7.58326566e-03f, -4.65090275e-02f,
  -1.34326771e-01f, -1.67602282e-02f, 8.63041356e-03f, -8.78459308e-03f, -4.13822681e-02f, 3.41326557e-02f, -2.54482757e-02f, 8.06891918e-02f, 1.60955176e-01f, -5.82685396e-02f,
  8.07489455e-02f, -9.30600613e-02f, -8.70578438e-02f, 1.22268960e-01f, 2.03888379e-02f, -7.68853575e-02f, 4.92268205e-02f, -6.86417371e-02f, -1.42952576e-01f, -1.97099932e-02f,
  -3.68542410e-02f, 1.21732829e-02f, 6.53561279e-02f, -1.41288182e-02f, -4.93778177e-02f, -4.98743802e-02f, -2.84741186e-02f, 7.52574801e-02f, -1.27935335e-01f, -4.01099920e-02f,
  -9.72716808e-02f, -1.38600450e-02f, -8.47021583e-03f, -4.20796685e-02f, -9.88702476e-02f, -5.75992726e-02f, -5.23697697e-02f, -2.60879230e-02f, -4.00774777e-02f, -1.23694442e-01f,
  1.15027130e-01f, -1.88213661e-02f, 8.57881531e-02f, 5.36761619e-02f, 1.28177740e-03f, 8.57412629e-03f, 1.09608889e-01f, 2.97682080e-02f, 6.81339018e-03f, -4.66673598e-02f,
  -7.42879152e-01f, -7.73844779e-01f, 3.34364735e-02f, -1.59955442e-01f, -1.58202842e-01f, 2.44324785e-02f, 1.27782337e-02f, -1.32433757e-01f, -1.26879692e-01f, -6.48130253e-02f,
  -1.65147930e-02f, -1.41229518e-02f, -1.73473537e-01f, 3.53628956e-02f, 3.22381034e-02f, -5.54968342e-02f, -8.81108567e-02f, -1.00761950e-02f, -8.22203830e-02f, -3.89847569e-02f,
  3.07259932e-02f, 7.91970640e-02f, 7.13489717e-04f, 4.76819128e-02f, 5.37186600e-02f, 3.78812267e-03f, -9.26797371e-03f, 4.95805852e-02f, -7.17392042e-02f, -6.07759021e-02f,
  6.52091980e-01f, 2.56327063e-01f, 3.86863977e-01f, 3.33264828e-01f, -1.55150844e-02f, -3.48110586e-01f, 1.55724376e-01f, -3.32592689e-02f, 3.36550593e-01f, 1.24120772e-01f,
  -2.57168114e-01f, 4.64572370e-01f, -2.68148154e-01f, 2.85609096e-01f, -3.43626976e-01f, -3.61916304e-01f, -4.46338393e-02f, 1.54672250e-01f, -8.98930058e-02f, 1.71037525e-01f,
  1.68839887e-01f, -2.37879947e-01f, -9.75506306e-02f, -1.46916553e-01f, 3.19684833e-01f, 2.24009156e-01f, -3.79957527e-01f, -2.57014692e-01f, 2.08081916e-01f, -1.43207073e-01f,
  1.49161480e-02f, -9.02712066e-03f, 3.90309356e-02f, -2.78894044e-02f, -1.35025876e-02f, 4.57176082e-02f, -2.43489277e-02f, -2.62894426e-02f, -8.95771980e-02f, 7.38705099e-02f,
  8.70452672e-02f, -9.93559286e-02f, -1.28178718e-02f, 2.30966825e-02f, 3.87515351e-02f, 1.25552952e-01f, 1.25379795e-02f, 2.08203778e-01f, 1.53378710e-01f, 1.00688286e-01f,
  2.24616751e-01f, 4.21587750e-02f, -2.38096099e-02f, 1.60634809e-04f, 1.74471155e-01f, 5.26690902e-03f, -1.09381214e-01f, 1.56794507e-02f, 2.45334491e-01f, 7.97923654e-03f,
  -9.97342691e-02f, -2.13045105e-01f, -7.90148973e-02f, -5.00732847e-02f, 2.06904858e-02f, 5.12653254e-02f, 5.51418625e-02f, -7.31578842e-02f, -9.93220359e-02f, 1.80567838e-02f,
  -1.32754147e-01f, -8.56616721e-02f, 4.80962805e-02f, 1.38107836e-02f, 1.92295890e-02f, 8.18279460e-02f, -6.44472390e-02f, -2.22222116e-02f, 2.27278303e-02f, -4.69054803e-02f,
  -1.72406118e-02f, -4.28427011e-02f, -3.19665186e-02f, 1.36380447e-02f, 3.08037624e-02f, 2.75788959e-02f, 9.56217498e-02f, 1.54519185e-01f, 3.71705852e-02f, -8.44815522e-02f,
  -1.96997687e-01f, -3.97598505e-01f, 7.27811977e-02f, 6.31398186e-02f, 3.71128172e-02f, 1.08416202e-02f, -1.02475524e-01f, 1.11573972e-01f, -3.69413346e-02f, -7.97839165e-02f,
  7.04067424e-02f, 9.90239307e-02f, 8.97331070e-03f, 1.43500445e-02f, -1.12022944e-01f, -8.09491277e-02f, -2.59352271e-02f, -1.93792626e-01f, -1.01325572e-01f, -8.13193247e-02f,
  1.06614605e-01f, -3.36028151e-02f, -4.03448269e-02f, -2.66419966e-02f, -1.21008633e-02f, -7.49111846e-02f, 2.53555000e-01f, 8.14483091e-02f, -2.26912946e-02f, 3.94174550e-03f,
  1.18509904e-01f, -2.91953832e-01f, -3.21617007e-01f, 1.41991645e-01f, 2.65070349e-01f, -3.17378528e-02f, 1.85306028e-01f, 2.52316594e-01f, -7.40200728e-02f, -2.67061573e-02f,
  -7.86218513e-03f, -4.14959729e-01f, -3.77001077e-01f, -4.90286261e-01f, -5.05910099e-01f, -5.85918546e-01f, -5.03165163e-02f, -3.98755729e-01f, -1.48833528e-01f, 3.07792835e-02f,
  3.39089427e-03f, 4.03913781e-02f, -1.99103341e-01f, 1.32087126e-01f, 4.10791129e-01f, 3.58851224e-01f, 2.90489614e-01f, 1.26667216e-01f, 1.42617881e-01f, -6.72486471e-03f,
  -6.49863109e-02f, -2.13277608e-01f, -7.63880163e-02f, -2.90213395e-02f, -2.13741194e-02f, 1.27255350e-01f, 1.79873854e-01f, -1.26140907e-01f, -9.36453789e-02f, -1.00240588e-01f,
  -1.44893629e-03f, 1.70882177e-02f, -4.42537703e-02f, 5.73467165e-02f, 8.35683420e-02f, -4.69119474e-02f, -8.02872255e-02f, -2.08569374e-02f, 2.67491434e-02f, -1.90040410e-01f,
  -2.40389723e-03f, -5.94851561e-02f, 2.01831535e-01f, -3.22822444e-02f, -4.00781333e-02f, -5.43775111e-02f, 3.31609510e-02f, -7.58143216e-02f, 4.46075909e-02f, -1.35848537e-01f,
  3.19782495e-02f, 8.51219967e-02f, -2.96189077e-02f, -5.70590189e-03f, -7.32898936e-02f, 6.54509962e-02f, -5.21474332e-02f, 8.41126144e-02f, 6.10288307e-02f, -5.94539233e-02f,
  4.62049134e-02f, -4.25219126e-02f, -8.56971964e-02f, 1.31275505e-01f, -4.18336540e-02f, 1.13166841e-02f, 1.51351895e-02f, -4.60623130e-02f, 1.20686911e-01f, -1.23147972e-01f,
  -5.71649335e-02f, 3.45300473e-02f, 2.63580941e-02f, 3.91868427e-02f, -2.81715363e-01f, 3.37312743e-02f, 1.01882175e-01f, -1.42811574e-02f, -3.69186439e-02f, 4.05941233e-02f,
  3.50607857e-02f, -2.15729564e-01f, 3.30206975e-02f, 3.31122503e-02f, -1.18688338e-01f, -1.99215189e-02f, -1.34108722e-01f, -5.53137697e-02f, -4.79936525e-02f, 9.08913538e-02f,
  9.91372690e-02f, 2.01363444e-01f, 1.72997266e-01f, 1.24791302e-01f, 5.82622401e-02f, 1.26712350e-02f, 1.17778033e-03f, 2.04838276e-01f, 4.77433652e-02f, -3.24006155e-02f,
  6.92990869e-02f, 3.84166725e-02f, -3.63243520e-02f, 1.59452915e-01f, 1.47855327e-01f, -1.43602014e-01f, 3.71824801e-02f, -4.64438237e-02f, -1.03982054e-01f, -4.97705638e-02f,
  -2.50795215e-01f, -1.28667757e-01f, 2.90193468e-01f, -6.24569118e-01f, 1.29986554e-01f, -1.45924047e-01f, -6.47275820e-02f, -3.09400439e-01f, -1.32705018e-01f, -4.20884609e-01f,
  -2.62263566e-01f, 1.22667231e-01f, 2.98997164e-01f, -4.86089975e-01f, 4.62502480e-01f, 2.26306662e-01f, -6.06607914e-01f, -2.72259146e-01f, 2.89621465e-02f, -4.58144158e-01f,
  -1.21937044e-01f, -4.38451648e-01f, -2.41926257e-02f, -1.65017411e-01f, -2.50091136e-01f, -1.60708189e-01f, 2.61975341e-02f, 2.13276088e-01f, -2.01608211e-01f, 1.56181827e-01f,
  -1.23947943e-02f, -4.05451953e-01f, -2.12751683e-02f, 1.17224284e-01f, -1.46106154e-01f, -4.25280109e-02f, -8.87858123e-02f, 1.03137642e-01f, -1.47188948e-02f, -5.95527515e-02f,
  -3.00108269e-03f, 1.24870792e-01f, -1.31163508e-01f, 3.49225961e-02f, -1.15321696e-01f, -3.95273119e-02f, 2.58611571e-02f, 9.61616356e-03f, -4.10957299e-02f, 4.13128585e-02f,
  1.18126996e-01f, -5.20408377e-02f, -1.21029027e-01f, 7.85491765e-02f, 2.30538324e-01f, 4.67193909e-02f, 5.19606434e-02f, 6.82125017e-02f, -8.34013056e-03f, -1.57893270e-01f,
  -7.79127553e-02f, 3.60201709e-02f, 1.64931361e-02f, 7.45113045e-02f, -4.42428030e-02f, 8.48677605e-02f, -8.86322558e-02f, -2.93119177e-02f, -5.46090789e-02f, -2.27038488e-02f,
  -2.88176313e-02f, -1.93709917e-02f, -5.52778691e-02f, -9.34084207e-02f, -5.85308298e-02f, -1.82585523e-01f, 3.22299674e-02f, 4.02794331e-02f, 4.10416685e-02f, -5.59253879e-02f,
  -1.72378104e-02f, -4.07123080e-05f, 8.07311907e-02f, -6.96559623e-02f, -3.17209177e-02f, 7.82775804e-02f, -2.48195920e-02f, 6.76211715e-02f, 6.99278386e-03f, -2.14893799e-02f,
  -3.19202006e-01f, -6.49273753e-01f, -5.39312139e-02f, -5.09472862e-02f, -6.48639277e-02f, -7.85820037e-02f, -7.68248225e-03f, -5.36024794e-02f, 3.10036708e-02f, -1.44182742e-01f,
  -6.38326108e-02f, -8.47198963e-02f, -1.10475905e-02f, 1.73379481e-02f, 1.11310653e-01f, -2.90013980e-02f, -1.10375978e-01f, -1.22864485e-01f, -9.73497480e-02f, 2.98445746e-02f,
  1.39675559e-02f, 3.37679498e-02f, 9.53003392e-02f, -7.19027445e-02f, -1.13777608e-01f, -1.59977898e-02f, -5.52304387e-02f, 7.03895539e-02f, -6.65488541e-02f, -6.97939321e-02f,
  1.85249150e-01f, -1.76268667e-01f, -6.06589258e-01f, 6.34139776e-02f, 2.91631758e-01f, 1.37307972e-01f, -5.66262007e-02f, -5.25043122e-02f, -4.08669412e-01f, 2.50282884e-01f,
  3.54988992e-01f, -1.94951743e-01f, -3.51662248e-01f, 3.97367656e-01f, 1.37687922e-01f, -2.57984042e-01f, 4.66671526e-01f, 2.38322064e-01f, -2.31088176e-01f, 2.10288927e-01f,
  9.06668678e-02f, 6.61198139e-01f, 3.75574753e-02f, 4.99764830e-01f, 2.78421462e-01f, -1.21533841e-01f, 5.72994687e-02f, -1.26644328e-01f, 5.08814991e-01f, 5.63705489e-02f,
  4.46107611e-02f, -4.77411598e-02f, -9.04766321e-02f, 1.41917001e-02f, 5.97162056e-04f, 1.74896374e-01f, 7.57806674e-02f, -6.91779479e-02f, -1.50463849e-01f, -4.72325683e-02f,
  -8.61489326e-02f, 5.45729101e-02f, 1.90342106e-02f, 1.01816608e-02f, 6.81916773e-02f, 5.70669211e-02f, -6.41874596e-02f, -7.85074234e-02f, -1.26450628e-01f, 8.62553623e-03f,
  -7.13696927e-02f, 4.51584719e-02f, -3.10564414e-02f, -9.16690007e-02f, -9.57201272e-02f, -1.36767859e-02f, -1.06348395e-01f, -6.37519881e-02f, -2.57784524e-03f, 3.75268683e-02f,
  9.99408066e-02f, 1.41849920e-01f, -3.68181616e-02f, -2.37036999e-02f, 5.33170775e-02f, 3.61186080e-02f, 6.00462817e-02f, -4.63187173e-02f, -9.78501961e-02f, 4.01066951e-02f,
  -4.23140191e-02f, -8.81103054e-02f, -4.06639762e-02f, -2.37481247e-04f, 9.80061218e-02f, -3.87060381e-02f, 1.06808744e-01f, 4.65107709e-02f, 1.00030757e-01f, 3.57811600e-02f,
  3.98176769e-03f, -1.00117967e-01f, -2.80258548e-03f, -1.93963945e-01f, 2.20328823e-01f, 1.10161528e-01f, 1.48370758e-01f, 5.81661128e-02f, -5.82922657e-04f, -3.59797627e-02f,
  -6.79602474e-02f, 2.89384313e-02f, 1.17491921e-02f, 4.31886762e-02f, -7.07662925e-02f, 1.48854047e-01f, -4.12419997e-03f, -4.19439524e-02f, 7.46862739e-02f, -1.05576985e-01f,
  6.62244670e-03f, -2.18773950e-02f, -3.90008278e-03f, 5.19437939e-02f, -1.20798282e-01f, 4.39984314e-02f, 8.19966868e-02f, 4.34063934e-02f, -3.54871117e-02f, 3.21597978e-02f,
  9.32860747e-02f, 6.98249340e-02f, -2.77862349e-03f, -7.72710308e-04f, -5.17006293e-02f, -8.20844918e-02f, -3.39898691e-02f, 5.37820496e-02f, 1.09529242e-01f, -1.29161805e-01f,
  5.49028397e-01f, -2.79628336e-01f, -1.65725917e-01f, -1.28470898e-01f, 3.29451323e-01f, 6.54797912e-01f, 8.26705217e-01f, -4.10483358e-03f, -4.82733510e-02f, -1.70729816e-01f,
  1.39511362e-01f, 2.01411337e-01f, -3.62175778e-02f, 3.42103839e-01f, 8.05520535e-01f, -3.16607649e-03f, 9.92707238e-02f, 7.68710375e-02f, -9.45345014e-02f, 3.03927809e-01f,
  1.21854089e-01f, 4.07969683e-01f, -1.73542812e-01f, -1.05962515e-01f, 2.76975751e-01f, -2.93898374e-01f, -1.85811058e-01f, 7.09448308e-02f, -2.99645849e-02f, 2.40329549e-01f,
  1.02153897e-01f, -8.00964534e-02f, -4.95875031e-02f, -1.82216063e-01f, -5.14618419e-02f, -1.60197005e-01f, -3.46047059e-02f, 1.13703661e-01f, 4.64668162e-02f, 6.70942068e-02f,
  8.72450694e-02f, 3.31625901e-02f, 1.46494200e-02f, 8.61948356e-02f, 4.70563918e-02f, -5.00189140e-02f, -2.04326436e-02f, -7.38113895e-02f, -1.31512523e-01f, -8.15124512e-02f,
  3.73160131e-02f, -7.42044896e-02f, -4.23959121e-02f, -9.60242376e-02f, 3.95207852e-02f, -1.29942760e-01f, -2.54399814e-02f, 2.99817622e-02f, 1.01623185e-01f, 1.69739649e-02f,
  1.17577024e-01f, -5.59094129e-04f, 4.57655452e-02f, -4.13503358e-03f, 1.46687943e-02f, -9.41595435e-03f, 1.51868850e-01f, -9.34459362e-03f, -1.79432128e-02f, 6.16896190e-02f,
  -6.66418299e-02f, 1.91344339e-02f, -3.01701799e-02f, 5.00522703e-02f, 1.16638154e-01f, -4.57034856e-02f, -1.39862765e-02f, -2.12388821e-02f, -1.02957897e-01f, 4.09005508e-02f,
  -2.44459286e-02f, 1.95891604e-01f, 5.12770824e-02f, -2.65551180e-01f, 1.04864985e-01f, -7.81528372e-03f, 8.37446973e-02f, -3.92191522e-02f, 4.22632089e-03f, -5.10623073e-03f,
  2.77938172e-02f, -1.11045845e-01f, -3.15578729e-02f, -8.67544860e-03f, -1.23662986e-01f, -1.26257641e-02f, -7.43276179e-02f, 2.15683088e-01f, 8.10238346e-02f, 9.79945213e-02f,
  2.04617367e-03f, -5.94718419e-02f, -5.94430566e-02f, 1.16256237e-01f, 1.66795173e-04f, -5.53610325e-02f, -8.35940242e-02f, 3.91671211e-02f, -1.01384312e-01f, 4.09476757e-02f,
  -3.09234690e-02f, 1.16132475e-01f, -6.32673949e-02f, -6.64738417e-02f, -9.11124796e-02f, 2.30041947e-02f, 1.20457232e-01f, 3.11627779e-02f, 7.79674277e-02f, -3.47849913e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  5.19941628e-01f, 4.77130301e-02f, 7.98012540e-02f, -1.08975135e-01f, 1.90071747e-01f, 4.63868588e-01f, 3.44073147e-01f, 6.68411553e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.39568612e-01f, 4.35173452e-01f, -7.06640854e-02f, -4.71026033e-01f, 1.38542160e-01f, 3.39558989e-01f, -1.04371831e-01f, 2.52203673e-01f, 1.87038958e-01f, 4.27071780e-01f,
  -4.81053323e-01f, 8.51065591e-02f, 3.64001572e-01f, -3.43315423e-01f, 2.21085116e-01f, -8.50460157e-02f, 4.04191077e-01f, -2.55087405e-01f, 3.06258231e-01f, 1.19312182e-01f,
  1.11018993e-01f, 1.34286523e-01f, -3.62412035e-01f, -5.45524955e-01f, -3.35685283e-01f, 3.92447442e-01f, -8.90279040e-02f, -2.92248487e-01f, -9.31868106e-02f, -1.52204469e-01f,
  3.83828998e-01f, 4.41014946e-01f, -2.66534746e-01f, 5.65087534e-02f, -2.66035855e-01f, -2.46342987e-01f, -8.55323732e-01f, 1.85777798e-01f, 8.83133531e-01f, 2.51914740e-01f,
  -2.40262136e-01f, 3.94543588e-01f, -2.82172412e-01f, -3.73525172e-01f, 5.48587203e-01f, 1.21575601e-01f, 1.27320737e-01f, 2.34419480e-01f, 3.60226244e-01f, -2.19662964e-01f,
  -1.71595886e-01f, 3.07411224e-01f, 4.45262305e-02f, 5.23397624e-01f, -1.56224862e-01f, -2.65663177e-01f, -2.65405834e-01f, 9.06462669e-02f, 1.50229722e-01f, 5.43285549e-01f,
  -4.66570854e-02f, -1.85289368e-01f, -3.17561150e-01f, 6.00598194e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.38212901e-01f, 2.64306605e-01f, 3.17928463e-01f, 8.60368371e-01f, 8.76950085e-01f, 7.24826276e-01f, -4.04251516e-01f, 8.18934664e-02f, 5.48265517e-01f, -5.87249517e-01f,
  8.20294678e-01f, -6.89932778e-02f, -2.55344242e-01f, -4.09661382e-02f, 2.53368169e-01f, 9.09423381e-02f, 1.10542990e-01f, 6.08780570e-02f, 2.41465107e-01f, 8.46363902e-01f,
  1.17443919e-01f, -5.94990432e-01f, 8.12445998e-01f, 5.50603151e-01f, 2.38307685e-01f, -3.06264579e-01f, 4.80528742e-01f, -3.64393830e-01f, -4.14454371e-01f, 8.92656386e-01f,
  3.25621277e-01f, 2.61719078e-01f, 7.30561495e-01f, 4.75943446e-01f, 3.34154338e-01f, -1.55707642e-01f, -2.91443080e-01f, -4.72123384e-01f, -7.20782280e-01f, -8.02880466e-01f,
  5.76977849e-01f, 7.54702508e-01f, -5.85554004e-01f, 5.82277656e-01f, 5.15352488e-01f, -1.80211484e-01f, 1.63558364e-01f, 3.08579147e-01f, 5.10925949e-01f, 9.03957263e-02f,
  2.02562660e-01f, 1.32944463e-02f, -2.91052371e-01f, 3.41091156e-01f, -3.39732319e-01f, -1.31382811e+00f, -1.63523406e-01f, 2.69776523e-01f, -3.83171201e-01f, 1.00234652e+00f,
  3.84409398e-01f, -4.57969084e-02f, -6.73151731e-01f, 1.18382104e-01f, 5.73431492e-01f, 3.32812816e-01f, -3.07671875e-01f, 7.24552631e-01f, 1.72106817e-01f, 1.11604929e+00f,
  7.75601268e-02f, 5.50874650e-01f, 8.12022626e-01f, -6.34368896e-01f, 7.22576976e-01f, -1.70038477e-01f, 6.29981577e-01f, -2.12061033e-01f, 8.05024385e-01f, 2.28671402e-01f,
  1.65027395e-01f, 3.62097830e-01f, 8.79715569e-03f, 4.32606712e-02f, -6.56535685e-01f, 2.02304661e-01f, 8.69101524e-01f, 5.01285017e-01f, 3.92659694e-01f, 4.75732625e-01f,
  -1.55003384e-01f, -3.51458043e-01f, 8.85917783e-01f, -2.30512604e-01f, 5.58230817e-01f, 3.15031111e-01f, -6.00313187e-01f, 6.50503516e-01f, 3.91224921e-01f, -1.03570238e-01f,
  -4.07554120e-01f, -8.91705811e-01f, -2.34688461e-01f, 6.79573953e-01f, 1.08171773e+00f, 6.83912814e-01f, -1.50481924e-01f, 5.37501037e-01f, -5.08665526e-03f, 1.00947464e+00f,
  1.67622626e-01f, -3.80453840e-02f, 5.57783127e-01f, -4.48143303e-01f, 9.10223484e-01f, 6.84744060e-01f, 3.45761925e-01f, -4.88270074e-01f, -3.91518414e-01f, -9.32766914e-01f,
  -6.37540877e-01f, 3.64670813e-01f, -1.55725762e-01f, -3.09014529e-01f, -3.41861956e-02f, 6.46289289e-01f, 5.61001539e-01f, 1.21626723e+00f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  7.36543238e-01f, 6.83303893e-01f, 1.38424262e-01f, 1.01981342e-01f, 5.77149868e-01f, 3.50383133e-01f, 5.96033514e-01f, 7.68923461e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.85558364e-01f, -2.12703243e-01f, 1.41444337e-02f, -7.73038641e-02f, 2.02964116e-02f, 1.07216701e-01f, -3.05172354e-01f, 4.11604613e-01f, 3.45680445e-01f, -3.17345560e-01f,
  6.66141063e-02f, 6.05212487e-02f, 2.91536212e-01f, -3.10173094e-01f, 8.96754563e-02f, -3.07642519e-01f, -1.14479646e-01f, 1.00922463e-02f, -3.25040892e-02f, -3.06569878e-02f,
  4.82065916e-01f, 2.18131691e-01f, 6.05099738e-01f, -1.72142550e-01f, -4.94364314e-02f, -3.78008336e-01f, 1.54299676e-01f, -1.70774668e-01f, 6.95937872e-02f, 3.46696943e-01f,
  -2.97576487e-01f, 1.90823868e-01f, 1.60723001e-01f, 5.15585393e-02f, 1.64160013e-01f, 2.98482273e-02f, 1.83157980e-01f, -2.62184680e-01f, -6.40673697e-01f, 1.75592646e-01f,
  3.03771436e-01f, -3.09004158e-01f, -2.28080899e-01f, 4.08473015e-01f, 2.59145349e-01f, -2.11606860e-01f, 1.26317888e-01f, -1.22074105e-01f, -4.06748801e-02f, 2.39815205e-01f,
  -1.33792207e-01f, -2.66493767e-01f, -4.37487602e-01f, 4.24231201e-01f, -4.98333633e-01f, 1.96477234e-01f, 2.55502433e-01f, -1.60861716e-01f, 7.15292618e-02f, 1.25810489e-01f,
  -3.28507982e-02f, -4.50615436e-01f, 1.12014301e-02f, 9.02494490e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -9.76782739e-02f, 5.37442043e-02f, -2.61955172e-01f, -3.96274537e-01f, 9.29744244e-01f, -5.90781450e-01f, 3.35021287e-01f, -7.73427725e-01f, -3.77331138e-01f, 2.79099673e-01f,
  7.27509484e-02f, -1.35029566e+00f, 4.20904964e-01f, 8.67037833e-01f, 7.39365041e-01f, -3.64806622e-01f, 5.26529312e-01f, 5.93309551e-02f, 3.36294740e-01f, 4.69556302e-01f,
  -8.79407525e-01f, 8.09460402e-01f, -6.43933237e-01f, 8.14227819e-01f, 9.52517152e-01f, 7.59329975e-01f, -6.89047933e-01f, 2.68928753e-03f, 6.73674107e-01f, -5.39074559e-03f,
  -7.98055708e-01f, 8.77832592e-01f, -7.06418514e-01f, 4.80422407e-01f, -7.96564698e-01f, -1.83109298e-01f, 8.35625052e-01f, 3.19747716e-01f, -7.46284127e-01f, -1.46004945e-01f,
  6.04921840e-02f, -6.52935326e-01f, 1.08541083e+00f, 8.35798681e-01f, -2.07935032e-02f, 3.82440388e-01f, 6.16331518e-01f, -1.04524098e-01f, -7.88899884e-02f, -5.36642134e-01f,
  -1.63530916e-01f, 3.78236741e-01f, 9.30651546e-01f, 2.49091521e-01f, 1.07413650e+00f, 5.26084453e-02f, -7.65953422e-01f, 1.46610206e-02f, 4.33741927e-01f, 6.76474333e-01f,
  4.07807156e-02f, 8.14776659e-01f, 1.48976430e-01f, 3.27220589e-01f, 4.78350818e-01f, 4.34570163e-02f, 4.20759171e-01f, 4.11569655e-01f, 4.03177947e-01f, -1.15237904e+00f,
  2.88905263e-01f, -5.53995371e-01f, 8.09041917e-01f, 7.94824362e-01f, -5.48794627e-01f, -7.91444778e-01f, 1.10395205e+00f, 6.63186133e-01f, 5.67511976e-01f, -3.96230012e-01f,
  7.00089157e-01f, -3.57835174e-01f, 2.64687687e-01f, -7.27761686e-02f, 2.50362843e-01f, 6.12910748e-01f, -6.22648969e-02f, 6.15333915e-01f, 9.77889262e-03f, -2.66803205e-01f,
  9.82725561e-01f, 1.18783820e+00f, -2.87943214e-01f, 6.19859695e-02f, 5.10994159e-02f, 5.95687509e-01f, -2.12757587e-01f, 7.42907226e-01f, 9.24223512e-02f, 6.36406541e-01f,
  -9.93710041e-01f, -2.81583995e-01f, -3.26870054e-01f, -7.44888425e-01f, -2.09008545e-01f, 9.14158404e-01f, 1.26366178e-02f, -4.81987834e-01f, -7.46913314e-01f, -6.96916953e-02f,
  1.26602042e+00f, 7.82681108e-01f, 2.84644127e-01f, -8.83848429e-01f, 3.43112230e-01f, 1.07365280e-01f, 3.95807922e-02f, 1.00567102e+00f, 4.91458774e-01f, 2.35549152e-01f,
  -1.50275111e-01f, -1.66540071e-01f, 4.46499735e-01f, 5.62189072e-02f, -2.93018334e-02f, 4.46191937e-01f, -5.02984345e-01f, 9.80513096e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  -6.98441043e-02f, 4.03472722e-01f, 3.20757002e-01f, 2.64381528e-01f, 3.07629317e-01f, 1.88212544e-01f, 2.09586918e-01f, 6.70383275e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -6.52774930e-01f, 4.30110157e-01f, -6.11235142e-01f, -2.64536023e-01f, 6.09051466e-01f, -4.32600290e-01f, 3.66607755e-01f, 8.28492641e-01f, -1.38113499e+00f, 6.73210680e-01f,
  -1.07086241e+00f, -6.49952292e-01f, 2.55482465e-01f, -8.67483199e-01f, -1.25972581e+00f, -2.84018755e-01f, -1.10742591e-01f, -2.61452258e-01f, 2.34574094e-01f, 9.30820182e-02f,
  -5.75456738e-01f, 5.89762211e-01f, -4.89661187e-01f, -9.51898217e-01f, -3.63248169e-01f, 2.70632356e-01f, -1.04841363e+00f, 1.37955472e-01f, 7.63915256e-02f, 1.29748918e-02f,
  -6.89258456e-01f, 3.79619956e-01f, -1.81888759e-01f, -4.79592443e-01f, -3.42811197e-01f, -6.38926566e-01f, 1.94260165e-01f, 2.09478125e-01f, -4.96702671e-01f, -1.07388563e-01f,
  4.80034977e-01f, -6.18946671e-01f, 1.48297653e-01f, 2.44637191e-01f, -7.03344345e-01f, -3.17722410e-01f, -2.15726774e-02f, -1.27223553e-02f, -5.03295660e-01f, -2.56433904e-01f,
  -5.97756088e-01f, 1.43337280e-01f, 5.40169537e-01f, 1.93886578e-01f, 2.43626237e-02f, -7.17714369e-01f, -4.94232997e-02f, 4.03259834e-03f, -1.25048625e+00f, -9.62909579e-01f,
  6.39811158e-01f, -7.17301369e-01f, -3.26264232e-01f, -1.29048800e+00f, 4.19026524e-01f, -3.46794337e-01f, 4.97761250e-01f, 4.67597067e-01f, -5.92314720e-01f, -8.05100620e-01f,
  2.99756490e-02f, 3.39793831e-01f, -8.92280161e-01f, 4.70599860e-01f, -7.65557766e-01f, -9.06153440e-01f, -3.59699354e-02f, -5.37996590e-01f, 7.57846951e-01f, -7.28649676e-01f,
  4.32005793e-01f, 4.81230944e-01f, -1.58444300e-01f, -7.84228742e-02f, 8.37926447e-01f, -4.03663784e-01f, 7.83922732e-01f, 7.82474399e-01f, -6.24358118e-01f, 5.76739848e-01f,
  -1.51987970e-01f, -4.93019372e-01f, -9.97539103e-01f, 6.72440112e-01f, -9.32119071e-01f, 1.27994820e-01f, 1.44699231e-01f, 2.03089610e-01f, 2.04330161e-01f, 2.08255321e-01f,
  -4.92422253e-01f, 5.86821616e-01f, -1.60578027e-01f, -5.22590041e-01f, -6.19758785e-01f, -8.97418559e-01f, 2.35167906e-01f, 3.78796041e-01f, -1.01982999e+00f, 3.57565105e-01f,
  -6.41430199e-01f, 2.20914587e-01f, -1.03503160e-01f, -3.39313328e-01f, 1.42719924e-01f, -4.37729955e-02f, -5.67935526e-01f, -2.39661261e-01f, -5.35989463e-01f, -4.85045522e-01f,
  3.24167818e-01f, -9.71145988e-01f, -9.10406590e-01f, -2.08348364e-01f, -3.06576444e-03f, -5.38515985e-01f, 7.74567068e-01f, -8.43845844e-01f, -4.53791410e-01f, 5.45608699e-01f,
  -5.59342086e-01f, 8.78313601e-01f, 1.74127966e-01f, -3.12351257e-01f, 4.58853573e-01f, -3.82254064e-01f, 1.24113917e-01f, -7.83590853e-01f, 4.64794338e-01f, -1.02409923e+00f,
  2.75143474e-01f, -4.26777303e-01f, -8.96654651e-02f, -6.26649261e-01f, -5.46345115e-01f, 3.13494712e-01f, 1.12989716e-01f, 1.02961801e-01f, -3.25938255e-01f, -7.66795993e-01f,
  -6.48252368e-01f, 1.30271956e-01f, -6.26683056e-01f, -4.95799035e-02f, -6.51899099e-01f, -1.26844868e-01f, -1.36785579e+00f, 2.56094784e-01f, 5.65697074e-01f, 1.30061284e-01f,
  6.57317579e-01f, -3.99296820e-01f, 6.47248983e-01f, -1.01918864e+00f, 3.38064551e-01f, 8.53461862e-01f, 3.56950819e-01f, 3.79011631e-01f, 4.13909972e-01f, -7.01031744e-01f,
  -2.06644520e-01f, 1.44879639e-01f, 3.17194104e-01f, -7.45167196e-01f, -1.13971400e+00f, -1.06524181e+00f, -2.33469397e-01f, 9.38810110e-02f, -6.20289981e-01f, 1.22422248e-01f,
  6.50076985e-01f, -7.63121605e-01f, 1.40420645e-01f, 6.96938634e-01f, -7.15508103e-01f, -7.17207730e-01f, 5.74964345e-01f, 3.09917361e-01f, -2.63336658e-01f, 5.35069585e-01f,
  -5.15734494e-01f, -1.76820588e+00f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  7.98582751e-03f, -2.26424649e-01f, -6.66995347e-03f, -3.00768435e-01f, 2.82251363e-04f, 2.81371057e-01f, 2.56500363e-01f, -3.37377876e-01f, -1.93561330e-01f, -8.36616680e-02f,
  -1.30627766e-01f, 2.78666139e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    