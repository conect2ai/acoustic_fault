/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.93957239e-01f, 6.59361184e-01f, 6.06201649e-01f, -5.36014885e-03f, -2.16314122e-01f, 1.08612061e-01f, 1.79625615e-01f, -9.80445594e-02f, -9.61608347e-03f, -1.90697655e-01f,
  -3.07568163e-01f, 3.58351797e-01f, -4.33309413e-02f, -4.32080626e-02f, -6.74326122e-02f, 1.06489740e-01f, -4.20824528e-01f, 1.12143211e-01f, 1.03755176e-01f, 2.37484183e-02f,
  -1.08743623e-01f, -1.09581724e-01f, 8.65893885e-02f, -4.23823595e-02f, -5.91102056e-03f, 1.77441001e-01f, -4.54824895e-01f, 2.60226667e-01f, -2.61482745e-01f, 3.95564772e-02f,
  -4.76956777e-02f, 4.98667248e-02f, 1.39203832e-01f, 1.56337202e-01f, -6.18141657e-03f, -5.86874969e-02f, 8.66887122e-02f, 3.25981863e-02f, -2.30597588e-03f, 6.32999698e-03f,
  3.00364774e-02f, -7.70082930e-03f, 5.54106534e-02f, 5.18197864e-02f, 1.90852545e-02f, -5.30895852e-02f, 2.71463348e-03f, -6.20020963e-02f, 1.65068150e-01f, 1.71927959e-02f,
  8.05656761e-02f, -9.57680568e-02f, -1.86216101e-01f, -7.79647706e-03f, 9.93936807e-02f, 3.12410537e-02f, 5.15281819e-02f, 4.58476432e-02f, -9.24752373e-03f, 1.57187730e-02f,
  3.31708454e-02f, -2.90857386e-02f, 1.40931100e-01f, -7.24424198e-02f, 5.98438419e-02f, -6.35349303e-02f, -3.18645104e-03f, -4.29201983e-02f, 3.69589515e-02f, -7.48238117e-02f,
  -6.33774176e-02f, 1.93247646e-02f, -1.29120275e-01f, 2.27021221e-02f, -6.20036498e-02f, 6.92179601e-04f, 2.20031254e-02f, 4.90458980e-02f, -7.65080750e-02f, 4.93511595e-02f,
  -5.73105663e-02f, -2.63320021e-02f, 1.39153853e-01f, -6.08064793e-02f, -3.81301232e-02f, -6.46961108e-02f, -6.03748783e-02f, 6.50360212e-02f, -8.15845802e-02f, -5.96574880e-02f,
  2.92802081e-02f, 2.96334833e-01f, 6.80425838e-02f, -2.23500375e-02f, 2.46853270e-02f, 2.20665131e-02f, 1.50493141e-02f, -1.09033085e-01f, 4.52591032e-02f, 8.95356759e-02f,
  -2.53985729e-02f, 5.98278828e-02f, -6.88273087e-02f, -1.66691974e-01f, -2.87119169e-02f, -2.03047507e-02f, 7.24773183e-02f, -8.99590254e-02f, -1.15912892e-01f, -7.93721434e-03f,
  2.21410170e-02f, -2.64577866e-02f, 8.78137127e-02f, -1.08106006e-02f, -5.06855026e-02f, -5.36058173e-02f, 7.39066005e-02f, -1.60240859e-01f, 4.33887774e-03f, -1.05946772e-01f,
  3.22650909e-01f, -2.21554246e-02f, 2.15181321e-01f, 4.49020654e-01f, -1.77590564e-01f, -1.90804042e-02f, 8.73449087e-01f, -2.07650706e-01f, 3.12194258e-01f, -7.50639755e-03f,
  6.32098988e-02f, 7.12272450e-02f, 2.65023679e-01f, -3.28030437e-01f, 1.36609942e-01f, 2.16741070e-01f, -5.67777269e-02f, 4.97984141e-02f, 9.82411653e-02f, 3.38637382e-02f,
  1.39350891e-01f, -1.88264817e-01f, 2.08220139e-01f, -2.93952078e-01f, 4.50801440e-02f, 5.90211228e-02f, -1.00541167e-01f, 1.91863090e-01f, -3.30338985e-01f, -2.06345603e-01f,
  -2.46151742e-02f, 2.08920017e-01f, 2.02927440e-02f, 2.30718032e-02f, 5.66730089e-02f, -2.79066749e-02f, 5.45000881e-02f, 6.21378385e-02f, 2.28902083e-02f, 4.39975709e-02f,
  7.78530762e-02f, -5.58494925e-02f, 2.18259990e-02f, -6.30121455e-02f, -1.15400672e-01f, -7.14736730e-02f, 3.43225598e-02f, 5.10127423e-03f, 3.03324871e-02f, 6.23726025e-02f,
  6.25526160e-02f, -6.52173534e-02f, 8.47832020e-03f, 4.12517302e-02f, 7.94209838e-02f, 1.79745350e-02f, 6.38890788e-02f, -9.67690498e-02f, 7.80204218e-03f, -4.61340584e-02f,
  -3.62110846e-02f, 7.57492259e-02f, 4.68359590e-02f, -5.18751889e-02f, 6.82738200e-02f, -2.73491815e-02f, 1.36782639e-02f, -1.41833285e-02f, 5.52422181e-02f, -1.50699280e-02f,
  -3.46328504e-02f, -3.34811695e-02f, -5.85748665e-02f, -8.29973491e-04f, -1.50648709e-02f, 1.34359691e-02f, 7.45182633e-02f, -6.72000945e-02f, 1.66353568e-01f, -9.26079080e-02f,
  7.11119622e-02f, -1.90988202e-02f, 6.16349503e-02f, 5.54005317e-02f, 5.58655746e-02f, -2.34650876e-02f, -4.93548140e-02f, -1.56177124e-02f, 9.32135135e-02f, 3.70554929e-03f,
  -6.98238835e-02f, -9.47555155e-02f, 8.76029283e-02f, -1.52415149e-02f, 3.03051528e-02f, -1.48963213e-01f, 4.03718427e-02f, -1.32690087e-01f, -1.26668122e-02f, -1.04435578e-01f,
  -1.50780112e-01f, 3.32619138e-02f, 4.55447063e-02f, -3.84227447e-02f, 3.46310325e-02f, -2.43495815e-02f, 7.91343767e-03f, 4.68169199e-03f, -1.70825608e-02f, -1.02900818e-01f,
  -7.72377849e-03f, 1.11510925e-01f, 1.01114549e-01f, -9.81040578e-03f, -9.94170308e-02f, 2.60014012e-02f, -1.46903336e-01f, 1.27169505e-01f, -4.90161814e-02f, 1.08351465e-02f,
  -1.45826399e-01f, 2.33261302e-01f, 7.28608817e-02f, -1.92760199e-01f, 1.96530417e-01f, -6.99692369e-02f, -5.38265705e-01f, 1.12842865e-01f, 4.39484537e-01f, -3.47956926e-01f,
  -1.10752895e-01f, -1.22452257e-02f, -3.70674469e-02f, -2.51206458e-01f, -4.76825595e-01f, 1.98437959e-01f, -3.24984521e-01f, 7.82999843e-02f, 3.18951309e-01f, -2.39839047e-01f,
  2.26308048e-01f, -3.44436169e-01f, -2.34081820e-02f, 7.43463933e-02f, -1.61177404e-02f, -8.39341199e-04f, -3.64070088e-01f, 7.39248320e-02f, -3.72890502e-01f, -3.40092555e-02f,
  -1.32047832e-01f, 2.83473730e-01f, 1.15161151e-01f, -6.38064928e-03f, -2.47901250e-02f, -6.05367497e-02f, -7.88818300e-02f, -4.13287394e-02f, 5.15861176e-02f, 6.78103343e-02f,
  -1.30662501e-01f, -7.16906115e-02f, -3.22941467e-02f, 3.10207810e-02f, 1.92302719e-01f, 1.21888034e-01f, 1.08474195e-01f, 4.67417538e-02f, 1.14776805e-01f, 1.28412634e-01f,
  1.51396662e-01f, 1.40884355e-01f, 4.45313975e-02f, -5.10954969e-02f, -3.26968171e-02f, 4.84306179e-02f, -4.33422253e-02f, 5.80027979e-03f, -6.26183003e-02f, 4.83903326e-02f,
  8.93594176e-02f, -3.72763760e-02f, -4.51039709e-02f, -2.67547835e-02f, -7.47206509e-02f, 7.66635388e-02f, -2.48846114e-02f, -6.08255826e-02f, 2.87974672e-03f, -1.01841189e-01f,
  -1.66393846e-01f, 1.76628307e-02f, -3.65172103e-02f, 7.52360327e-03f, -1.07000268e-03f, -7.71911517e-02f, -1.76209345e-01f, -4.68099080e-02f, 8.55197606e-04f, -1.47239992e-03f,
  4.09956742e-03f, -2.98740212e-02f, -5.60028711e-03f, 2.91023869e-02f, 5.60145676e-02f, 5.23193926e-02f, 6.04770295e-02f, 8.50928277e-02f, 9.05978158e-02f, -8.52344036e-02f,
  -2.52305180e-01f, -1.65584922e-01f, 5.76077774e-02f, 2.55441107e-02f, -6.22986518e-02f, 7.05673918e-02f, -7.70797813e-03f, 1.47393167e-01f, -3.56821902e-02f, -5.93225248e-02f,
  9.65926796e-02f, -6.23736866e-02f, -1.61631659e-01f, 4.48930487e-02f, -1.15871437e-01f, 6.82087755e-03f, -1.59819528e-01f, -1.78797040e-02f, -1.32142529e-01f, 2.20154375e-02f,
  -7.79487267e-02f, -9.19711813e-02f, -7.14297593e-02f, -4.87507284e-02f, -4.53159213e-02f, -7.46753737e-02f, -1.66582912e-02f, 3.61161232e-02f, 1.53213097e-02f, -3.22987176e-02f,
  -5.21907449e-01f, -7.09923804e-02f, -5.39302491e-02f, -1.20168589e-01f, -2.74306148e-01f, -1.25680342e-01f, -3.87342393e-01f, -2.03110412e-01f, -1.00196272e-01f, -6.48376793e-02f,
  -2.46929437e-01f, 3.77791405e-01f, -2.57152230e-01f, -1.15084477e-01f, -3.67094547e-01f, -1.73994806e-02f, -2.72235155e-01f, 1.22114204e-01f, -9.27807614e-02f, -1.78236559e-01f,
  -8.27125907e-02f, -2.02700838e-01f, -1.19926147e-01f, -4.85457703e-02f, -1.45783231e-01f, 3.38773012e-01f, -2.44736999e-01f, 7.40936920e-02f, 2.42991984e-01f, 1.42780468e-01f,
  -2.08907083e-01f, -3.19661871e-02f, 1.54746190e-01f, -2.97464267e-03f, -7.14404061e-02f, -8.46514702e-02f, 7.55423009e-02f, 1.09050637e-02f, -3.78544331e-02f, 7.16571882e-02f,
  4.13916893e-02f, 7.18166158e-02f, 6.95803910e-02f, 4.81518656e-02f, 2.71600438e-03f, 5.98700978e-02f, 8.88553932e-02f, 6.35157526e-02f, -1.06778322e-02f, 2.77186837e-03f,
  6.40624613e-02f, 7.35127181e-03f, -6.17986880e-02f, 7.32169747e-02f, -8.06998163e-02f, 4.27912883e-02f, -6.08289754e-03f, 8.93733501e-02f, -1.07940836e-02f, 9.36954021e-02f,
  -1.19877793e-02f, 2.99708992e-02f, -8.96089971e-02f, 1.19212292e-01f, -3.88188101e-02f, -3.91786210e-02f, 1.10010609e-01f, 9.34163108e-03f, 8.20726529e-02f, -5.93480207e-02f,
  5.82065172e-02f, 5.70313493e-03f, 6.45001680e-02f, -1.05580226e-01f, 3.37647311e-02f, -5.41105419e-02f, 3.61433923e-02f, -6.75349310e-02f, -1.18562371e-01f, -1.00553887e-04f,
  -4.66431538e-03f, -1.40522823e-01f, 1.19465366e-02f, -6.52464712e-03f, -4.59684357e-02f, -6.31099120e-02f, -9.07060504e-02f, -5.70939817e-02f, 1.33667944e-03f, -1.96158770e-03f,
  -2.62296319e-01f, -2.33927235e-01f, -2.21682526e-02f, 6.11050390e-02f, 1.54875979e-01f, 4.07536738e-02f, 5.44746816e-02f, -4.42029871e-02f, 9.90290567e-02f, -1.93325341e-01f,
  -3.61252092e-02f, -1.19565502e-02f, 1.29082054e-02f, -6.70251949e-03f, -6.14221469e-02f, -1.43828139e-01f, -9.26513001e-02f, 2.10966598e-02f, -6.40140474e-02f, -4.33949120e-02f,
  -4.89495173e-02f, 1.44335344e-01f, 1.15714565e-01f, -6.21609613e-02f, -6.47865832e-02f, -9.94806923e-03f, -2.93477327e-02f, 1.32101953e-01f, 7.65501261e-02f, -2.05934346e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.28304553e+00f, 9.82428849e-01f, -7.29025677e-02f, 5.30583076e-02f, -9.20118988e-01f, 1.00265697e-01f, 9.13835242e-02f, 1.46912456e-01f, 3.78184229e-01f, 7.43478656e-01f,
  -7.79437274e-02f, 2.30066851e-01f, 5.43209255e-01f, 4.03345406e-01f, -8.27765763e-01f, 9.54810739e-01f, -2.03839168e-01f, 3.73071246e-02f, 3.36457998e-01f, -3.60809326e-01f,
  -4.80279833e-01f, -3.41117680e-01f, -1.74784049e-01f, 2.66473852e-02f, -7.81424046e-01f, -1.43481910e-01f, -7.42001593e-01f, 4.86739762e-02f, -5.44507563e-01f, -3.04549456e-01f,
  -6.10137343e-01f, 6.95736036e-02f, -3.89406979e-01f, 3.25734727e-02f, -4.45625693e-01f, -1.78664476e-01f, -2.67893374e-01f, 6.33260608e-02f, -3.20065394e-02f, 2.55919337e-01f,
  1.28883108e-01f, 2.69672181e-02f, 8.80659968e-02f, 6.28851354e-02f, -9.26754028e-02f, -2.58790213e-03f, -1.45685789e-03f, -1.84543565e-01f, 9.91297662e-02f, 2.30131745e-02f,
  1.06723838e-01f, 3.07554845e-02f, -5.48525006e-02f, 1.19197875e-01f, -1.01115048e-01f, 1.63378909e-01f, 2.68449754e-01f, -1.18877869e-02f, -1.78316832e-01f, 7.17906700e-03f,
  -1.04643032e-01f, 2.03003809e-01f, 1.06965855e-01f, -4.05280478e-02f, 1.43290758e-01f, -1.74171776e-01f, 1.36445329e-01f, -1.86933905e-01f, 8.82538408e-02f, -1.72897782e-02f,
  2.19367049e-03f, 2.02289168e-02f, 8.59336406e-02f, 1.13200583e-01f, -8.34569484e-02f, 8.26253295e-02f, -4.07346562e-02f, -5.38674109e-02f, 8.64442140e-02f, -1.93804830e-01f,
  3.23088802e-02f, -6.01679273e-02f, 5.82708567e-02f, -9.34018716e-02f, -9.28231340e-04f, 1.78846139e-02f, -1.27105024e-02f, 1.32682435e-02f, 7.01799318e-02f, -2.86439419e-01f,
  -6.00496292e-01f, -6.45850182e-01f, 1.05480395e-01f, -8.21650848e-02f, -5.41383252e-02f, -9.71492305e-02f, 1.20212294e-01f, -1.02660432e-01f, -9.39020067e-02f, -7.20837936e-02f,
  -8.34551305e-02f, -3.48688550e-02f, -2.00964481e-01f, -2.74646115e-02f, 1.25611678e-01f, 7.05124438e-03f, -4.20248769e-02f, 4.86538894e-02f, -2.82810181e-01f, -1.98146626e-01f,
  -2.09882140e-01f, 4.54762131e-02f, 3.85864936e-02f, 2.49725059e-02f, -1.60226166e-01f, -2.22997904e-01f, -1.89013436e-01f, 1.25069633e-01f, -2.98728555e-01f, 9.36326385e-02f,
  8.22327912e-01f, 3.72303039e-01f, 3.54887605e-01f, 9.22685936e-02f, 5.85505784e-01f, 1.59889162e-01f, 1.65959403e-01f, 2.55662709e-01f, 1.14420600e-01f, 4.34902847e-01f,
  -4.44692492e-01f, -1.28416149e-02f, -7.02768743e-01f, -4.21113968e-01f, -1.29121053e+00f, -9.90988374e-01f, -4.75729138e-01f, -1.95143849e-01f, -2.14189187e-01f, 2.29446635e-01f,
  -2.15483442e-01f, -6.04095042e-01f, -2.64340997e-01f, -4.58311923e-02f, 6.68452919e-01f, 6.41987145e-01f, -9.19197649e-02f, -1.18739028e-02f, 1.45768076e-01f, -3.89374852e-01f,
  -3.69837061e-02f, -2.12733168e-02f, 2.57099092e-01f, -1.25721708e-01f, 3.97579104e-01f, 2.32007176e-01f, 3.21380317e-01f, -4.31889266e-01f, -7.52081797e-02f, 4.07544943e-03f,
  2.44777575e-01f, -6.46849275e-02f, -1.31193727e-01f, -8.35111216e-02f, 3.01744878e-01f, 2.41182193e-01f, -3.80719528e-02f, 3.77758950e-01f, 2.47699648e-01f, 1.08351119e-01f,
  -3.77103803e-03f, 1.57271206e-01f, 3.71983081e-01f, -3.72005440e-02f, -8.21952224e-02f, 1.26324609e-01f, -4.11043540e-02f, 2.64758710e-02f, 2.07831815e-01f, 4.36358713e-02f,
  -4.12992612e-02f, 1.18216015e-01f, -9.90744606e-02f, 1.74383521e-01f, -2.09185496e-01f, 1.91004034e-02f, -1.44395217e-01f, 5.04348502e-02f, 6.37634546e-02f, 1.27919298e-02f,
  -4.40892242e-02f, 1.25324503e-01f, -7.75479525e-02f, 6.27319366e-02f, -1.17562138e-01f, 6.36337250e-02f, -6.36444539e-02f, -1.57157809e-01f, 1.89009085e-01f, -3.18678468e-02f,
  -1.71615764e-01f, -1.01512797e-01f, -1.48860896e-02f, 1.53742820e-01f, -2.13029414e-01f, -7.20802471e-02f, -1.63451225e-01f, 2.96326131e-02f, 1.22080646e-01f, -1.40555739e-01f,
  -2.33338371e-01f, -4.82553691e-01f, 8.78391322e-03f, -2.08537672e-02f, -2.64983118e-01f, -1.12378083e-01f, -3.66313197e-02f, 7.64584616e-02f, -1.62410080e-01f, -1.04221486e-01f,
  2.29844943e-01f, 2.23646253e-01f, 1.02353968e-01f, 8.44731461e-03f, -1.01868562e-01f, -5.93580864e-02f, -4.24243882e-02f, -9.04846862e-02f, 9.75529477e-02f, 6.67138696e-02f,
  2.31851041e-01f, 3.84646915e-02f, -1.06913513e-02f, 1.95856735e-01f, 5.67616969e-02f, 8.96421149e-02f, 2.73160905e-01f, -2.54110303e-02f, -5.35545610e-02f, 5.98351918e-02f,
  -6.95372462e-01f, -4.91969854e-01f, -1.29611278e+00f, -8.38907897e-01f, 5.17836630e-01f, -9.67159629e-01f, -7.09094524e-01f, -2.86196113e-01f, -2.24952310e-01f, 3.85301471e-01f,
  3.36686730e-01f, -2.48809516e-01f, 6.07315958e-01f, -1.37276673e+00f, -1.03287351e+00f, -3.85450304e-01f, -1.38869190e+00f, -6.70795619e-01f, -1.30343378e-01f, -1.30132288e-01f,
  -3.66209090e-01f, -1.84450485e-02f, -1.11807525e+00f, 6.66463792e-01f, -5.60380876e-01f, 1.30570918e-01f, 9.04207230e-01f, 6.19732618e-01f, -2.59348214e-01f, -2.98790038e-01f,
  -4.72005576e-01f, 1.34284362e-01f, -1.06028803e-01f, -1.60816193e-01f, -2.09060550e-01f, 2.17753381e-01f, 1.32655740e-01f, -1.51654063e-02f, 7.43209198e-02f, -1.29298195e-01f,
  1.09477490e-01f, 2.61231989e-01f, -2.15086982e-01f, 2.56063253e-01f, 2.94990659e-01f, -4.38491106e-02f, -2.38674432e-01f, -2.95958251e-01f, -4.46102805e-02f, -1.36033460e-01f,
  -4.25171703e-01f, -2.41896197e-01f, -5.31066060e-02f, -2.81397663e-02f, -1.12190194e-01f, -1.47836998e-01f, -1.56434819e-01f, 1.20500304e-01f, -2.23583300e-02f, -9.23971906e-02f,
  1.09716497e-01f, 3.11713278e-01f, 1.12934783e-01f, -6.69639260e-02f, 1.76390767e-01f, -1.26851887e-01f, 2.31204182e-02f, 5.40342368e-02f, 8.36175755e-02f, 8.13589618e-02f,
  5.70139326e-02f, -1.49969891e-01f, 1.18967094e-01f, 2.73823347e-02f, -2.72151232e-02f, -8.89980420e-02f, 2.45397817e-02f, 8.39318931e-02f, -1.85256585e-01f, -3.20664853e-01f,
  2.34437883e-02f, -1.67142093e-01f, 2.40546852e-01f, 1.81084737e-01f, -2.03596026e-01f, 9.27315578e-02f, 4.05101590e-02f, 9.61756557e-02f, -3.28141712e-02f, 7.63901472e-02f,
  -9.61222425e-02f, 1.68272838e-01f, -2.62107626e-02f, 1.04795426e-01f, -3.68964039e-02f, -2.50788275e-02f, -1.05800882e-01f, -3.22120607e-01f, 1.66980743e-01f, -1.74674727e-02f,
  2.94465452e-01f, 8.98098201e-02f, 1.09034441e-01f, -1.73195586e-01f, -1.93829834e-02f, 1.04899004e-01f, 2.17022449e-01f, 2.73884147e-01f, -1.72110081e-01f, -8.87010526e-03f,
  3.66934150e-01f, 1.48220465e-01f, 8.72169659e-02f, 1.52652934e-01f, 1.81668997e-02f, 9.38402265e-02f, 5.32879233e-02f, -6.94091851e-03f, 1.00611366e-01f, -7.96947777e-02f,
  -7.92007744e-02f, -1.14146543e+00f, 4.02024835e-01f, 4.96412724e-01f, 6.30722880e-01f, -5.63413322e-01f, -8.49785984e-01f, 3.26663166e-01f, 8.82022679e-02f, -1.09881592e+00f,
  1.76793873e-01f, -7.29810297e-01f, -7.93693066e-01f, 3.49522352e-01f, 3.08686763e-01f, -9.12497193e-02f, 4.54427689e-01f, -3.30360204e-01f, 2.89082170e-01f, 5.72222352e-01f,
  7.13050783e-01f, 5.12682498e-01f, 6.06452644e-01f, 7.28645980e-01f, 5.05488038e-01f, 2.41528690e-01f, -2.39929687e-02f, 1.59256354e-01f, 9.69837829e-02f, 1.90527722e-01f,
  -1.33869931e-01f, 3.21998030e-01f, -8.58500823e-02f, -1.40210405e-01f, 1.32623643e-01f, -2.81691551e-01f, -1.53066367e-01f, -6.27234159e-03f, 2.69291461e-01f, -1.60184111e-02f,
  -2.62768775e-01f, 2.62376457e-01f, 1.20644242e-01f, -2.35081092e-02f, 4.95265871e-02f, 2.21838817e-01f, 1.17566101e-01f, 9.78756174e-02f, 5.71644306e-02f, 6.77588060e-02f,
  1.10252939e-01f, 5.59370518e-02f, 3.68799120e-02f, -6.24475218e-02f, 1.85190171e-01f, 1.28815174e-01f, -3.09708528e-02f, -1.83626935e-01f, -1.40825272e-01f, 1.64191499e-02f,
  1.70126021e-01f, -1.28034979e-01f, 1.09552041e-01f, -1.59237295e-01f, 9.03102234e-02f, -1.51482662e-02f, -1.98760461e-02f, -9.50526968e-02f, -1.28595635e-01f, -2.05836874e-02f,
  1.10054031e-01f, 1.92584600e-02f, 8.50569308e-02f, 2.96627339e-02f, -9.06964242e-02f, -1.35029942e-01f, 6.11290522e-02f, -1.46502284e-02f, 9.77943093e-02f, 5.01790419e-02f,
  -3.12539518e-01f, 8.08201060e-02f, -5.95948398e-02f, -4.91669960e-02f, -4.73171361e-02f, -8.88959616e-02f, 2.78506372e-02f, -4.68652770e-02f, 8.48177150e-02f, -1.00525051e-01f,
  -1.62119722e+00f, -6.34268165e-01f, -4.65622395e-02f, -1.30901724e-01f, -2.03758121e-01f, -1.27134725e-01f, 1.44594967e-01f, 1.67361200e-01f, -2.63316512e-01f, -2.43033562e-02f,
  -1.19111113e-01f, -3.56688537e-02f, -1.80679053e-01f, 2.04283252e-01f, 1.56301633e-02f, -2.11005226e-01f, -1.86652884e-01f, -3.97387087e-01f, -1.79762602e-01f, -5.91624491e-02f,
  -2.42389500e-01f, -1.69410631e-01f, -6.26067966e-02f, 2.13193044e-01f, -8.85399580e-02f, -1.62233174e-01f, 8.28106105e-02f, -7.94710144e-02f, 1.25338182e-01f, -1.25836194e-01f,
  1.26724005e+00f, -4.76436287e-01f, -3.91346395e-01f, 3.69405776e-01f, 1.45837247e-01f, 9.48074698e-01f, 9.73757744e-01f, -1.42136782e-01f, 4.69824523e-01f, -3.70574981e-01f,
  -1.71317413e-01f, 4.62571830e-01f, -4.42452908e-01f, 5.98291159e-01f, 1.19562280e+00f, 1.29710615e-01f, 6.44673645e-01f, 5.03264070e-01f, 1.64702222e-01f, 2.54137367e-01f,
  3.37175339e-01f, 6.19114757e-01f, -5.70392907e-01f, -4.30903047e-01f, 1.44360796e-01f, -5.74177861e-01f, -7.49989688e-01f, -5.36640644e-01f, -2.83137739e-01f, 2.77030915e-01f,
  -5.76924495e-02f, 7.40758283e-03f, -1.51191682e-01f, 4.47321758e-02f, -9.48153436e-03f, -1.03305668e-01f, -2.14438420e-02f, -1.95188761e-01f, -4.85890079e-03f, 6.24834858e-02f,
  1.64238691e-01f, 1.65297851e-01f, 2.01695010e-01f, -3.25972438e-02f, 2.19806343e-01f, -2.88797002e-02f, -6.42603114e-02f, -2.19532967e-01f, -2.41298944e-01f, 6.60468712e-02f,
  -8.01734030e-02f, -1.33183509e-01f, 1.34614110e-01f, -1.96995474e-02f, -4.71262522e-02f, 1.58093318e-01f, 5.01188114e-02f, -9.13133621e-02f, 8.78178626e-02f, 3.00789535e-01f,
  1.13123618e-01f, 1.29009679e-01f, 1.26011059e-01f, -9.40712541e-02f, 1.88807920e-01f, -2.30751485e-01f, 8.63145590e-02f, -1.42177954e-01f, 4.62450497e-02f, -1.19581431e-01f,
  -1.69397681e-03f, 1.54131139e-02f, 1.25150695e-01f, 7.46505708e-02f, 1.60735399e-01f, 6.81449026e-02f, 1.33085158e-02f, -2.50367485e-02f, -4.22505103e-02f, -8.22348297e-02f,
  -1.45309195e-01f, 4.87943105e-02f, -5.05370684e-02f, -1.61468312e-01f, -1.20546803e-01f, -1.20625444e-01f, -9.43201631e-02f, -1.87198147e-02f, -1.43171459e-01f, -8.98308083e-02f,
  7.32453242e-02f, 1.56195447e-01f, -1.52880415e-01f, -6.00732937e-02f, -7.17123896e-02f, 4.20872942e-02f, 1.97680920e-01f, 3.08426499e-01f, 1.58414394e-02f, 2.03485012e-01f,
  2.34059561e-02f, -5.12147397e-02f, 6.85825795e-02f, -2.64801849e-02f, -1.66965589e-01f, 2.16285381e-02f, 8.78344849e-02f, 6.08557388e-02f, 4.39496636e-02f, -2.28656232e-01f,
  -1.50799707e-01f, 2.58609325e-01f, 8.45356658e-02f, 5.54757640e-02f, 2.83352137e-02f, -3.28982137e-02f, 1.99392200e-01f, -4.60522808e-02f, -6.56869262e-02f, -1.73667073e-01f,
  4.19548482e-01f, 1.00702333e+00f, 7.30707526e-01f, 6.66942656e-01f, -6.17705941e-01f, -9.53323185e-01f, -8.82920206e-01f, -7.32961744e-02f, 1.78665982e-03f, 8.98220837e-02f,
  -4.05235142e-01f, 9.47531402e-01f, 4.68889922e-02f, 1.15554459e-01f, -2.39280865e-01f, -3.27297121e-01f, 4.38641518e-01f, 2.88861811e-01f, 4.81416099e-03f, 8.50614667e-01f,
  5.00305831e-01f, -2.31545627e-01f, 2.29661658e-01f, -3.16849023e-01f, 1.99158788e-01f, 8.07830632e-01f, 6.33737922e-01f, -2.50681877e-01f, 8.42821240e-01f, -3.15984219e-01f,
  -2.85976142e-01f, 1.84544891e-01f, 1.46829829e-01f, -7.12051764e-02f, 1.49390727e-01f, -1.51341662e-01f, 5.79712242e-02f, -3.18564028e-01f, -2.37283587e-01f, 2.09370106e-01f,
  1.13904297e-01f, 3.35380733e-02f, 2.57594287e-02f, -1.16972536e-01f, -1.30342647e-01f, -6.07364587e-02f, 2.50695705e-01f, 6.93250299e-02f, -8.59767012e-03f, -4.02976610e-02f,
  3.10989439e-01f, -2.86512375e-02f, 1.74151868e-01f, 3.14565480e-01f, -4.24316041e-02f, -8.27882737e-02f, 1.23709962e-01f, 2.47925535e-01f, 1.30973876e-01f, 7.60651380e-02f,
  1.53884605e-01f, 6.82695806e-02f, -3.46591137e-02f, -1.59039279e-03f, 3.88770178e-03f, -1.34428635e-01f, -8.22439790e-03f, -4.39053588e-02f, -6.70477748e-02f, -6.43190369e-02f,
  -1.80062458e-01f, -1.49873793e-01f, -1.35547698e-01f, 9.93664563e-02f, 3.68058644e-02f, -2.46401533e-01f, -4.38951775e-02f, 4.14744727e-02f, 1.57745719e-01f, 6.34708256e-02f,
  -1.98367327e-01f, -1.52712911e-01f, 7.44659007e-02f, -2.58433893e-02f, -2.41140544e-01f, 1.11914031e-01f, 1.56791478e-01f, 1.37620226e-01f, 7.03811124e-02f, 2.62183766e-03f,
  4.05558676e-01f, 6.50893271e-01f, 2.92761941e-02f, -3.46805185e-01f, 1.41845956e-01f, -1.28019542e-01f, -1.46365598e-01f, 3.61954629e-01f, 3.60392153e-01f, -8.06479976e-02f,
  2.91338056e-01f, 6.53603375e-02f, 2.00067297e-01f, -5.08993082e-02f, -2.38992777e-02f, 4.62642640e-01f, 2.77112275e-01f, 1.70699671e-01f, 3.10281187e-01f, 4.15592372e-01f,
  9.88153741e-03f, -3.76539901e-02f, -7.28889033e-02f, -1.55751333e-01f, 4.69269753e-02f, 2.67249048e-01f, -2.09651887e-03f, 8.23732689e-02f, 1.05105497e-01f, 2.20818505e-01f,
  1.56852126e-01f, -6.80801272e-01f, 8.54915619e-01f, -7.66567528e-01f, 3.12585354e-01f, 1.94190234e-01f, 1.03801131e-01f, -4.25242901e-01f, -3.09294730e-01f, -9.41955745e-01f,
  -5.76825440e-01f, 1.68810546e-01f, 6.30775511e-01f, -7.77035058e-01f, 1.47244024e+00f, 2.45188013e-01f, -6.83955610e-01f, -3.56786162e-01f, -1.17257405e-02f, -6.60173655e-01f,
  -3.95513959e-02f, -1.22369802e+00f, 3.25222462e-01f, -7.84476876e-01f, -3.73547733e-01f, -2.50136375e-01f, -2.64613122e-01f, 3.74392658e-01f, -5.69575906e-01f, 2.15263650e-01f,
  -3.59234869e-01f, -6.66361392e-01f, -9.76920947e-02f, -1.07505145e-02f, -1.03806406e-01f, 7.32523203e-02f, 2.67596692e-01f, 2.91916490e-01f, 7.79039860e-02f, 1.57918021e-01f,
  3.51898745e-02f, 3.81156988e-02f, -3.18890601e-01f, 1.74855918e-01f, -7.83448219e-02f, -2.91270185e-02f, -3.54514085e-02f, 6.78200871e-02f, -1.01658545e-01f, 3.55813593e-01f,
  1.97262034e-01f, 1.78280115e-01f, -6.41802475e-02f, 7.98897743e-02f, 1.05642632e-01f, -1.52243271e-01f, 3.47073153e-02f, 4.43214059e-01f, -1.65398568e-02f, 3.10921203e-02f,
  -1.62527293e-01f, 7.97133818e-02f, 7.38176778e-02f, 2.86449143e-03f, 1.43554052e-02f, -8.26628655e-02f, -2.86700632e-02f, 4.06159908e-02f, -2.59436481e-02f, 4.45217043e-02f,
  -7.74502680e-02f, 7.84297436e-02f, -6.16437662e-03f, -2.50917636e-02f, -1.92392170e-01f, -1.67685956e-01f, 3.44768129e-02f, 2.24190466e-02f, -1.78231429e-02f, 5.41041121e-02f,
  -1.83757693e-01f, 4.71311109e-03f, -6.29233420e-02f, 8.42906758e-02f, -1.59349382e-01f, 2.06661314e-01f, -3.66128571e-02f, 6.72837496e-02f, -7.34897703e-02f, 1.87263429e-01f,
  -8.01673770e-01f, -1.24885082e+00f, -2.19880313e-01f, -2.32546106e-01f, -1.37367621e-01f, -1.91253498e-01f, -9.77567658e-02f, -7.65653104e-02f, -8.44115689e-02f, -9.39753503e-02f,
  -1.64018907e-02f, 2.93220803e-02f, -1.63999006e-01f, -8.91444087e-02f, -1.34046182e-01f, -3.29527669e-02f, -5.08402381e-03f, -1.52984560e-01f, -1.32827625e-01f, -2.13741064e-01f,
  5.79011813e-02f, -2.67579705e-02f, 3.05670112e-01f, -1.88524321e-01f, -2.67931789e-01f, 5.12397401e-02f, -1.16853006e-02f, 4.15483490e-02f, 1.10153563e-01f, -1.26895547e-01f,
  -2.47844115e-01f, -1.93131670e-01f, -4.99709010e-01f, -1.01891065e+00f, 1.48487583e-01f, 1.09046412e+00f, 9.00135577e-01f, -5.37641704e-01f, -1.15140224e+00f, 4.67428833e-01f,
  6.55275106e-01f, -5.57509720e-01f, 5.81004739e-01f, 7.06143260e-01f, 2.31619269e-01f, 7.14822769e-01f, 6.72125340e-01f, 5.10204077e-01f, -4.74836648e-01f, -4.36136220e-03f,
  -8.91579762e-02f, 1.07749891e+00f, 5.82875133e-01f, 2.48400748e-01f, 2.82085210e-01f, -5.37818491e-01f, -2.90268939e-02f, 5.71698956e-02f, 3.55150163e-01f, 1.44079655e-01f,
  2.13550821e-01f, -1.78224534e-01f, -1.47923946e-01f, -2.67566413e-01f, 2.37297416e-02f, 6.40252158e-02f, 4.86700144e-03f, 1.21059857e-01f, -3.34192574e-01f, -5.50480224e-02f,
  -5.16899070e-03f, -1.94833241e-02f, -5.54723991e-03f, -1.68782651e-01f, -1.80711776e-01f, -1.47661880e-01f, -1.26434073e-01f, -8.90129507e-02f, -9.05552357e-02f, 2.92089909e-01f,
  -5.48271611e-02f, -1.33681685e-01f, -1.17613107e-01f, -6.52310401e-02f, -1.92842647e-01f, -3.05201709e-02f, -7.69407749e-02f, -6.66235611e-02f, -7.89625570e-02f, -2.27172256e-01f,
  8.18316117e-02f, 2.45999023e-01f, 2.38291577e-01f, 1.99079290e-01f, -1.57485586e-02f, 3.48473862e-02f, 1.39310181e-01f, 7.33646974e-02f, -1.59734145e-01f, 5.45771830e-02f,
  -1.57021895e-01f, -1.00207970e-01f, -1.14479605e-02f, -1.76898703e-01f, 1.78846121e-01f, -7.70288184e-02f, 1.47860527e-01f, -6.12051338e-02f, -9.56825837e-02f, -1.61308814e-02f,
  -2.02307135e-01f, -2.56318033e-01f, 2.57471234e-01f, 1.27873331e-01f, 8.34897682e-02f, -1.24130510e-02f, -7.99840018e-02f, 4.16853279e-02f, -6.07563071e-02f, -1.37298638e-02f,
  3.99380885e-02f, -1.11275591e-01f, 2.27661356e-02f, -2.98258942e-02f, -1.61261857e-02f, 1.60487115e-01f, 8.35481212e-02f, -7.19601847e-03f, -1.39548346e-01f, 4.42295484e-02f,
  1.27350554e-01f, -1.22146770e-01f, -1.02597065e-01f, 6.22329041e-02f, -1.95640147e-01f, 2.72480547e-01f, 1.38239756e-01f, -2.51841307e-01f, -1.77785695e-01f, -1.09754600e-01f,
  -4.47376184e-02f, 1.05116959e-03f, -1.59659252e-01f, 9.42079872e-02f, -7.18837157e-02f, 8.30807313e-02f, -9.50678736e-02f, -1.73908710e-01f, 2.42694408e-01f, -2.95572937e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.05521476e+00f, 1.22045815e+00f, 7.47138083e-01f, 8.56267810e-01f, 1.52593434e+00f, 1.16527128e+00f, 1.20483220e+00f, 1.04087067e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -9.14619416e-02f, 1.97886899e-01f, 3.72893482e-01f, 6.70200109e-01f, -8.79761457e-01f, 6.27295017e-01f, -1.22106874e+00f, 2.72847246e-02f, 1.10973811e+00f, -4.23693687e-01f,
  -1.27912676e+00f, -1.21748734e+00f, -1.07432806e+00f, -3.37861985e-01f, -1.50066471e+00f, 1.00364923e+00f, -8.59675348e-01f, 4.83966142e-01f, -5.58692038e-01f, -1.08474803e+00f,
  -4.93238717e-01f, -1.41519499e+00f, -1.05892849e+00f, -1.19634604e+00f, -1.44834447e+00f, -2.75180221e-01f, -2.65500695e-01f, -1.16717505e+00f, 8.03625584e-01f, -3.21208447e-01f,
  -1.73497796e+00f, 9.16034937e-01f, -1.36112690e+00f, -8.99307907e-01f, -8.90972793e-01f, 6.68643534e-01f, -1.22918844e+00f, -2.15613556e+00f, -7.50253558e-01f, 1.62366199e+00f,
  -1.39704132e+00f, -2.38584802e-01f, -5.89914739e-01f, 1.23163450e+00f, 3.17735612e-01f, -8.57796311e-01f, -1.01239145e+00f, -6.11841798e-01f, -3.94582450e-01f, -1.51103973e-01f,
  -8.10848475e-01f, -7.56528854e-01f, 1.31869125e+00f, -2.15450525e-01f, 7.72168159e-01f, 3.47899556e-01f, 9.82287884e-01f, -4.28181797e-01f, 9.49250221e-01f, 2.74576068e-01f,
  -1.33624065e+00f, -1.15038919e+00f, -1.29114234e+00f, -8.44812453e-01f, 2.66130604e-02f, 1.58600914e+00f, -3.25541198e-01f, 1.22510540e+00f, 1.74356377e+00f, -6.79397762e-01f,
  1.77032864e+00f, 2.97282457e-01f, 4.95954275e-01f, -1.15685850e-01f, -1.07937336e+00f, 2.63385981e-01f, -2.10187101e+00f, -9.65400398e-01f, 7.33141601e-01f, 3.91023427e-01f,
  7.86256015e-01f, 6.55614853e-01f, 9.56263959e-01f, 9.35645223e-01f, 1.90145826e+00f, 1.73249567e+00f, 3.72545570e-01f, -1.28893495e+00f, 6.59783721e-01f, -9.83367860e-01f,
  -1.05136919e+00f, -1.83515406e+00f, 1.04143727e+00f, 2.25740001e-01f, -1.04261637e+00f, -1.08466458e+00f, 6.08677089e-01f, -8.47337246e-01f, 5.34399450e-01f, -3.07709306e-01f,
  -9.59131122e-01f, 1.75807214e+00f, 1.76137829e+00f, -9.75376725e-01f, -1.11926556e+00f, 6.31419837e-01f, -8.35838556e-01f, 6.38965607e-01f, 7.66999602e-01f, -1.34574759e+00f,
  -2.61961997e-01f, -1.75565338e+00f, 2.76147395e-01f, -5.30570187e-02f, -9.69276905e-01f, -7.17164278e-01f, -1.47375226e+00f, -2.65792817e-01f, 1.70608789e-01f, 5.51431179e-01f,
  -1.94737345e-01f, -1.92913640e+00f, 7.32371509e-01f, -1.00126779e+00f, -3.81042063e-01f, 3.61892939e-01f, 8.28527689e-01f, -1.68229771e+00f, 3.55056554e-01f, -3.30945939e-01f,
  -2.88314998e-01f, -9.36840996e-02f, 2.57360395e-02f, -4.85907644e-01f, -5.34796357e-01f, -8.34990561e-01f, -7.12179661e-01f, -1.31282723e+00f, -1.06785202e+00f, 4.00492340e-01f,
  -9.60313082e-01f, 1.34016883e+00f, -7.28031695e-01f, -8.20863128e-01f, 2.77802628e-02f, -9.17849958e-01f, 8.85563672e-01f, 1.90898776e-01f, 4.47503030e-01f, 7.86204040e-01f,
  -1.47845185e+00f, -9.53665674e-02f, -1.48937881e+00f, -1.57138300e+00f, -8.05245519e-01f, -5.06041110e-01f, -1.57764494e-01f, -9.50161934e-01f, 1.36498380e+00f, 2.00657636e-01f,
  2.40687490e-01f, -1.87381968e-01f, 1.01951838e+00f, 8.26207399e-01f, -1.15155387e+00f, -7.08023727e-01f, -8.59217346e-01f, 2.71267831e-01f, -1.24778700e+00f, 7.80299485e-01f,
  7.70114660e-01f, -1.01784956e+00f, -1.49201810e+00f, -1.50623322e-01f, -1.53889132e+00f, -1.80760503e-01f, -7.03179955e-01f, 2.22561017e-01f, 1.03546582e-01f, -7.57129312e-01f,
  6.99608743e-01f, -5.56722917e-02f, 7.92797267e-01f, 1.12429810e+00f, -2.64711887e-01f, 1.35702300e+00f, -1.64521921e+00f, -9.65634465e-01f, -8.21626782e-01f, 6.04974449e-01f,
  -3.52452695e-01f, -1.23034501e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.68193859e-01f, -5.52572727e-01f, 2.12402925e-01f, -2.16650352e-01f, 5.41216850e-01f, 2.55052060e-01f, 2.24683851e-01f, -3.94777991e-02f, 1.08830929e-01f, -1.04231261e-01f,
  -2.69554377e-01f, 4.12052833e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    