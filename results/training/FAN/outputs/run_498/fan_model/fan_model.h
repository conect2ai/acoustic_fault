/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.77216083e-01f, -3.66896749e-01f, 5.23249395e-02f, -3.60500336e-01f, 4.97575440e-02f, -6.04540706e-02f, -1.14219323e-01f, -2.04998598e-01f, -2.54414946e-01f, -2.50133216e-01f,
  -2.17301138e-02f, -1.11999288e-01f, -9.93383527e-02f, -1.87302172e-01f, 2.17966095e-01f, -6.88376427e-02f, -8.91093016e-02f, -9.69959721e-02f, 2.01541092e-02f, -1.85212761e-01f,
  2.59041879e-02f, -3.89538817e-02f, 7.83904567e-02f, 6.38606492e-03f, 8.66069365e-03f, -4.00381014e-02f, -5.76410890e-02f, 5.45125082e-02f, -5.73951043e-02f, 8.75603855e-02f,
  1.13562711e-01f, -8.60460326e-02f, -2.74546277e-02f, 2.84881014e-02f, 1.79380924e-02f, 8.91292542e-02f, 7.54244849e-02f, 8.46369117e-02f, -2.11054944e-02f, 4.69145514e-02f,
  2.69310866e-02f, 7.93973915e-03f, 2.52053700e-02f, 3.18092629e-02f, 1.33869918e-02f, -9.85182356e-04f, 2.82335281e-02f, -1.64582711e-02f, -3.53701189e-02f, 8.86706039e-02f,
  -8.76470562e-03f, 3.32356244e-02f, 2.07243375e-02f, 3.12182587e-02f, 2.81788725e-02f, -1.28091197e-04f, 1.83107667e-02f, 5.67751639e-02f, -7.60094449e-02f, -5.78680122e-03f,
  3.98535244e-02f, 1.11224726e-02f, 4.01093392e-03f, -1.18165035e-02f, -7.26805702e-02f, 7.69427493e-02f, -6.53579608e-02f, 3.83941308e-02f, -1.86376628e-02f, 5.87579496e-02f,
  -4.69818898e-02f, -7.76027516e-02f, -3.25467475e-02f, 1.23460852e-02f, -4.24856134e-02f, 2.78490316e-02f, 3.50940973e-02f, -2.71388367e-02f, 8.52697436e-03f, 4.37168144e-02f,
  -3.65331620e-02f, -1.16911102e-02f, -7.75887892e-02f, 5.08802086e-02f, -3.26593686e-03f, 3.74798253e-02f, -7.83064682e-03f, -5.98566532e-02f, 1.59730371e-02f, 1.48160066e-02f,
  -8.76159146e-02f, -2.85901934e-01f, -4.93660159e-02f, -4.05469500e-02f, -1.28572909e-02f, -2.58803517e-02f, 7.13056549e-02f, -4.98886174e-03f, -1.61040965e-02f, 1.77043281e-03f,
  5.94154187e-02f, -5.15591130e-02f, 3.07865459e-02f, 2.67299842e-02f, 8.71588662e-03f, -6.33285046e-02f, -7.14465529e-02f, 2.18110960e-02f, -2.55794413e-02f, -6.10537715e-02f,
  -3.94223519e-02f, -5.27457008e-03f, 6.86877444e-02f, -2.06386745e-02f, -1.68739296e-02f, -4.22776863e-02f, -4.11754660e-02f, 5.30697331e-02f, 7.72464126e-02f, -1.03194833e-01f,
  -2.14407697e-01f, 1.84055164e-01f, 1.46140918e-01f, -1.69780239e-01f, 5.69383390e-02f, -2.00933412e-01f, -1.15340851e-01f, 1.28543958e-01f, 1.25542268e-01f, 7.08314553e-02f,
  1.75257847e-02f, -1.17956258e-01f, 1.19036306e-02f, -1.18907735e-01f, -3.37557703e-01f, 9.35497135e-03f, -2.73819923e-01f, -1.93420127e-01f, 7.60515630e-02f, -7.70445764e-02f,
  1.85195766e-02f, -2.36521229e-01f, -1.95002556e-01f, -1.88304558e-02f, 1.05238423e-01f, 1.86174721e-01f, -1.94354370e-01f, 1.24758907e-01f, -5.01018725e-02f, -1.44095555e-01f,
  -2.31528829e-04f, 1.26888558e-01f, 6.60794899e-02f, 4.44068015e-02f, 4.60301555e-04f, -1.15822507e-02f, 3.33432853e-02f, -3.50321308e-02f, 5.53602427e-02f, -3.91252860e-02f,
  4.12648208e-02f, -5.42598367e-02f, -3.13144363e-02f, 2.19080523e-02f, 6.93520010e-02f, 2.01477744e-02f, 3.66181135e-02f, 4.75244485e-02f, 3.60230654e-02f, -4.94547971e-02f,
  -5.52784801e-02f, 2.90492121e-02f, -6.62648603e-02f, 1.31631624e-02f, -2.05358360e-02f, 4.79554273e-02f, 6.50484522e-04f, -6.00177385e-02f, -4.65177596e-02f, -5.95346466e-02f,
  -4.47237901e-02f, -3.61688528e-03f, -5.10714315e-02f, -1.79728661e-02f, -4.42069806e-02f, 1.15312999e-02f, 1.13425609e-02f, -1.07735731e-02f, 4.74359468e-02f, 1.28548052e-02f,
  6.79114684e-02f, 4.83353697e-02f, 4.88647148e-02f, 4.51291502e-02f, -4.14402075e-02f, -3.00406236e-02f, -4.62951288e-02f, -1.77853331e-02f, -2.16206480e-02f, 8.96742742e-04f,
  -2.23900415e-02f, -1.00859264e-02f, 2.37288028e-02f, -1.72155295e-02f, 5.72692417e-02f, 5.53275980e-02f, 5.08875474e-02f, 6.74382895e-02f, -2.33820733e-03f, -9.13993940e-02f,
  6.34645894e-02f, -8.48903283e-02f, 1.65202450e-02f, 6.39117584e-02f, -1.91206578e-02f, -3.12098190e-02f, -6.19163513e-02f, -1.74113899e-04f, 4.78638932e-02f, -2.61655282e-02f,
  8.60590581e-03f, -3.43006402e-02f, 2.15242729e-02f, 4.05540364e-03f, -5.97694255e-02f, 4.85236570e-02f, -7.51453191e-02f, -5.75290294e-03f, -9.14270580e-02f, 1.00490237e-02f,
  -3.67046371e-02f, -5.90911843e-02f, -6.04853630e-02f, -9.32637975e-02f, 9.44188610e-03f, -6.97752982e-02f, -5.16893016e-03f, 6.76280260e-02f, -2.04626080e-02f, 5.07238433e-02f,
  -1.62603214e-01f, -3.16852778e-01f, -3.12585890e-01f, 4.89163585e-02f, -2.85739638e-02f, -3.12876791e-01f, -3.27376753e-01f, 2.90092044e-02f, 1.61147676e-02f, 1.42047063e-01f,
  2.13873431e-01f, -2.21578568e-01f, 3.10766064e-02f, -2.47491300e-02f, -4.80064787e-02f, 1.48428418e-02f, -6.37108013e-02f, -7.95695856e-02f, -6.91883340e-02f, -1.02858990e-01f,
  3.93063128e-02f, 1.86742768e-01f, -1.06912337e-01f, -1.68471038e-03f, -1.42277852e-01f, -3.26454118e-02f, 2.86737323e-01f, 4.43912949e-03f, 5.22860475e-02f, -4.29652780e-02f,
  -6.25840873e-02f, 1.14261992e-02f, -4.83896881e-02f, 9.92800947e-03f, -1.53157720e-02f, 5.30973589e-03f, -4.12829593e-02f, -2.57158354e-02f, 6.95764199e-02f, 2.49849688e-02f,
  -1.00271910e-01f, 6.77343011e-02f, 4.59098183e-02f, 6.31401017e-02f, 8.28679837e-03f, -1.04939565e-02f, -7.90917873e-02f, 5.46052819e-03f, -1.08117945e-01f, 7.29902927e-03f,
  -2.42026001e-02f, 1.26110166e-02f, 5.53399250e-02f, 9.22119804e-03f, -4.64823954e-02f, -7.31220515e-03f, -4.46095364e-03f, 1.70494355e-02f, -5.05690016e-02f, -3.57389748e-02f,
  9.32951495e-02f, 2.09032744e-02f, -3.04635037e-02f, -3.30470912e-02f, -2.84220856e-02f, -3.11434586e-02f, 2.53436211e-02f, -3.45277376e-02f, 3.54046375e-02f, -1.36961341e-02f,
  -2.26981961e-03f, -6.89022094e-02f, 6.55820221e-02f, 4.56644930e-02f, 5.77187613e-02f, 7.14447945e-02f, -5.06220348e-02f, 2.29191929e-02f, -4.94602695e-02f, -1.07034408e-02f,
  2.79509909e-02f, -3.10983192e-02f, -1.64308473e-02f, 1.80701017e-02f, 3.23968418e-02f, -1.96866735e-04f, 1.50187109e-02f, -6.19391240e-02f, -4.77454066e-02f, 4.33556968e-03f,
  -7.08660204e-03f, 1.66790619e-01f, -4.33321707e-02f, -1.76944043e-02f, -3.10120732e-02f, -7.52550811e-02f, -3.03468015e-02f, 3.97108793e-02f, -6.64059445e-02f, -4.00139689e-02f,
  7.89849982e-02f, 5.16289249e-02f, 1.85526703e-02f, 3.79187390e-02f, -3.39413527e-03f, 2.33160313e-02f, -2.53968015e-02f, 3.84989530e-02f, 4.48742993e-02f, 3.76091264e-02f,
  6.15480356e-02f, -9.57688615e-02f, 4.57847305e-02f, -1.21378936e-02f, 7.89047033e-02f, -2.98406221e-02f, -1.40121520e-01f, 5.63658820e-03f, 6.33053780e-02f, 6.41892105e-02f,
  -3.96893203e-01f, 3.75121206e-01f, 2.63423715e-02f, -4.14138585e-02f, -2.49720603e-01f, 1.87381208e-01f, 4.92550768e-02f, 1.11383937e-01f, 1.25734121e-01f, 2.12027758e-01f,
  -7.84983113e-02f, 8.20464715e-02f, 6.28077090e-02f, 1.42550305e-01f, -1.64349467e-01f, 2.71225452e-01f, 1.07254751e-01f, 5.69399633e-02f, -1.48467924e-02f, -6.64094239e-02f,
  -1.41793806e-02f, 3.64134051e-02f, -9.20492504e-03f, 5.97399846e-02f, -1.53972387e-01f, -1.13004567e-02f, -4.37377393e-02f, -6.64668232e-02f, -4.44037607e-03f, -1.20225521e-02f,
  6.32634386e-02f, 5.20521514e-02f, -8.09805021e-02f, 4.60944958e-02f, -3.90107259e-02f, -9.22296420e-02f, -5.71633019e-02f, -3.54532599e-02f, -5.20235412e-02f, -2.68992763e-02f,
  4.21092957e-02f, -7.07304105e-03f, 8.24855939e-02f, -2.56933309e-02f, -1.63593907e-02f, 4.08861460e-03f, -9.45687480e-03f, -1.67641975e-02f, 6.49823099e-02f, 5.55670336e-02f,
  -1.11422054e-02f, -9.57478583e-03f, -8.51007849e-02f, 4.22570445e-02f, -3.90130579e-02f, 3.60681042e-02f, 4.54140827e-02f, -3.04923318e-02f, 4.05688062e-02f, -5.34838811e-03f,
  2.30737235e-02f, -8.33413005e-03f, 4.93565314e-02f, 2.84527168e-02f, 2.01563556e-02f, -7.43419528e-02f, 1.09439092e-02f, -7.73404585e-03f, 1.43158715e-03f, -6.54969551e-03f,
  -7.89886639e-02f, -5.29184788e-02f, 3.95464227e-02f, -2.99702631e-03f, -5.43060973e-02f, -4.34358679e-02f, -1.06321007e-01f, -1.58080347e-02f, -3.33091058e-02f, -5.00022992e-02f,
  1.44022079e-02f, 2.06267964e-02f, 7.95426406e-03f, 2.33254954e-02f, 1.63088720e-02f, -6.63025305e-02f, 5.90835474e-02f, 3.26392874e-02f, 1.90517679e-02f, -4.12201099e-02f,
  1.00893356e-01f, 3.11251611e-01f, 8.71670172e-02f, 2.32180171e-02f, 4.99649979e-02f, -3.40697542e-02f, 5.50823361e-02f, 7.05201626e-02f, 7.36940354e-02f, 3.75738670e-03f,
  1.77403875e-02f, -9.11636278e-03f, 2.35046428e-02f, -6.74319416e-02f, 4.62170839e-02f, 9.96996388e-02f, 1.79905947e-02f, 4.62590391e-03f, -2.99676508e-02f, -4.74977400e-03f,
  -1.70391500e-02f, -2.14152783e-02f, -2.44936962e-02f, -6.65468574e-02f, -3.76690105e-02f, -6.85459599e-02f, 1.13396514e-02f, 2.64999736e-02f, 2.01328248e-02f, 8.17389786e-02f,
  -9.74118337e-02f, -4.13145944e-02f, 1.88511670e-01f, 1.60997510e-01f, -2.31505871e-01f, -2.31476858e-01f, 1.65057868e-01f, -1.80226877e-01f, 1.87051333e-02f, 1.25590578e-01f,
  -3.33108678e-02f, 1.80415437e-01f, 1.28911719e-01f, -1.16574727e-01f, -1.32400766e-01f, 2.22921565e-01f, -1.84055373e-01f, 5.80600835e-02f, -5.03323600e-02f, -1.27723247e-01f,
  -7.21195862e-02f, -1.23292319e-01f, 1.12056226e-01f, -1.28425077e-01f, -7.63696507e-02f, 8.85973498e-03f, -6.08236575e-03f, 5.78126200e-02f, -1.01659521e-01f, -5.02432473e-02f,
  -1.17754593e-01f, 3.63272429e-02f, 3.96094918e-02f, -1.85377318e-02f, -5.41612059e-02f, 1.04667440e-01f, 7.97328651e-02f, 1.43932611e-01f, 7.43229836e-02f, -4.61626705e-03f,
  8.23955759e-02f, 1.23463916e-02f, -6.02687858e-02f, 1.64736770e-02f, 2.93775778e-02f, 8.89904276e-02f, 1.56575942e-03f, -1.30833359e-02f, 6.87628239e-02f, -4.80223633e-02f,
  4.89903167e-02f, 1.50211798e-02f, -5.15831355e-03f, -1.39706349e-02f, 7.46406838e-02f, -1.20310048e-02f, 3.63680683e-02f, 2.43179109e-02f, -3.60464267e-02f, -1.04367800e-01f,
  7.79935047e-02f, -4.05682065e-02f, 4.87565435e-02f, -5.76159097e-02f, -6.28426066e-03f, 5.38685452e-03f, 2.14159396e-03f, -3.20755946e-03f, 1.33666629e-03f, -6.01668879e-02f,
  -5.88788614e-02f, 4.65091951e-02f, 6.00641184e-02f, 4.74397577e-02f, -7.80145230e-04f, 1.08038476e-02f, 1.98630095e-02f, -3.06282304e-02f, -2.60630324e-02f, 2.01596580e-02f,
  7.17293769e-02f, -2.76946258e-02f, 1.70583855e-02f, -2.51074648e-03f, -3.38320713e-03f, 1.82972476e-02f, -1.34593341e-02f, 1.76554937e-02f, 1.50738331e-02f, -1.43726924e-02f,
  -2.67602265e-01f, -1.68174595e-01f, -2.01904215e-02f, -5.38591146e-02f, -5.51900379e-02f, -7.97049999e-02f, 4.04380336e-02f, -5.56947477e-02f, -3.41388187e-03f, 9.15841013e-03f,
  -2.48540714e-02f, 2.97299959e-02f, -3.15166973e-02f, -8.79107881e-03f, 2.16170140e-02f, -6.31765053e-02f, 2.95665395e-02f, -3.93305626e-03f, -6.75402805e-02f, -9.72778574e-02f,
  -2.06103362e-02f, -2.98401085e-03f, 2.18348857e-02f, -9.29405764e-02f, 5.89522384e-02f, -2.31356118e-02f, -9.35708880e-02f, 4.29277048e-02f, -1.30915530e-02f, -5.86730652e-02f,
  -2.64147222e-01f, 2.59309232e-01f, 8.61616209e-02f, -1.86295748e-01f, -8.26015398e-02f, -1.27687544e-01f, -1.25516593e-01f, 5.17007746e-02f, 2.63320029e-01f, 5.75328842e-02f,
  -1.99839354e-01f, -3.13697793e-02f, 1.96164653e-01f, -1.81192368e-01f, -1.83545694e-01f, 3.58851969e-01f, -1.15978077e-01f, -9.48239788e-02f, 2.25809157e-01f, -2.07325563e-01f,
  -1.10627770e-01f, -1.89959213e-01f, -8.66672918e-02f, -7.34312534e-02f, -4.25280854e-02f, -1.68788731e-02f, -2.07923651e-01f, 7.49488920e-02f, -1.83498040e-01f, 4.99154516e-02f,
  -2.89851688e-02f, 5.43907424e-03f, -2.64016930e-02f, 1.88320316e-02f, 1.36082666e-02f, 2.24930458e-02f, -5.28265722e-02f, 3.06764506e-02f, 1.88924186e-02f, 3.47373225e-02f,
  3.62243913e-02f, -6.27629533e-02f, 5.18020950e-02f, 5.93638793e-02f, -2.58056615e-02f, -7.51071274e-02f, 8.82754289e-03f, -5.88749126e-02f, -1.24248415e-01f, -2.46404372e-02f,
  -5.47577329e-02f, -9.16233403e-05f, -8.11038017e-02f, -9.86774545e-03f, -9.50334668e-02f, -9.09324642e-03f, -1.65619012e-02f, -3.02792899e-02f, 5.48758171e-02f, -2.63975132e-02f,
  -3.96869667e-02f, 2.83239149e-02f, -2.70407144e-02f, 1.26200065e-01f, -7.61295259e-02f, 1.40243024e-02f, -2.14970671e-02f, -1.41488034e-02f, 4.98490920e-03f, 5.82538545e-04f,
  2.25786678e-02f, -3.45372967e-02f, 1.08103208e-01f, -7.40301535e-02f, -1.45338699e-02f, -4.93321056e-03f, 3.28645073e-02f, 7.30890110e-02f, 3.03725101e-04f, -5.24241924e-02f,
  4.61621471e-02f, -1.18881445e-02f, -7.45335594e-02f, 6.12426596e-03f, 6.48261458e-02f, -2.51976531e-02f, -4.13296260e-02f, 1.18161254e-02f, 4.97845225e-02f, -2.82403901e-02f,
  -6.92351758e-02f, 1.05820149e-01f, 2.23629437e-02f, 5.27824536e-02f, 8.91492441e-02f, -9.37415510e-02f, 1.17190808e-01f, -8.25831480e-03f, 3.37726772e-02f, 2.58505587e-02f,
  -3.96585576e-02f, -1.10847680e-02f, -2.26664562e-02f, -7.93270767e-02f, 1.64299961e-02f, -5.12493216e-02f, 1.68062858e-02f, 3.12674083e-02f, 1.03992810e-02f, -1.08367920e-01f,
  -1.80893198e-01f, -3.79350856e-02f, 1.41126290e-02f, -1.23835597e-02f, 1.32238958e-03f, -7.03377053e-02f, -2.22797412e-02f, -8.55089352e-02f, 4.41693924e-02f, 5.88582829e-02f,
  2.42576197e-01f, 1.61596641e-01f, -6.97289081e-03f, 1.92311361e-01f, 6.92203194e-02f, -3.05394620e-01f, -1.84739381e-01f, 8.35012123e-02f, 1.04343869e-01f, -2.33943183e-02f,
  2.14053914e-02f, 1.17312223e-01f, -1.26255333e-01f, -1.49292678e-01f, -3.10644835e-01f, -2.73219496e-01f, -9.77197513e-02f, 5.99827692e-02f, -4.47949506e-02f, 1.44652307e-01f,
  -2.40327179e-04f, -5.15921265e-02f, -1.89043477e-01f, 7.68302828e-02f, 1.10090941e-01f, 1.63866833e-01f, 1.52398840e-01f, -9.06105116e-02f, 6.63942366e-04f, -4.64304090e-02f,
  -1.60124570e-01f, -3.81948613e-02f, 7.73725286e-02f, -2.03351565e-02f, 2.59400755e-02f, -5.25763184e-02f, -3.75791229e-02f, -1.16974451e-01f, -3.49635743e-02f, -2.26421980e-03f,
  -3.14134061e-02f, -4.76364885e-03f, 2.20019333e-02f, 5.92223890e-02f, -4.12732456e-03f, 4.64005396e-02f, 7.86132812e-02f, -2.83552781e-02f, 6.90733641e-02f, -2.83941114e-03f,
  2.33310610e-02f, -5.03173806e-02f, 6.84983134e-02f, -3.98350991e-02f, 4.51118201e-02f, -4.02140245e-02f, -9.86089855e-02f, -1.28970109e-02f, 1.46251004e-02f, 7.20925629e-02f,
  5.96295558e-02f, -1.09090679e-03f, 1.38493022e-02f, 3.18689905e-02f, 1.10673858e-02f, 3.36923376e-02f, 7.34864315e-03f, -6.00643568e-02f, 6.73635453e-02f, -6.10505603e-02f,
  4.62653814e-03f, 1.20393792e-02f, -7.26517430e-03f, -1.15487827e-02f, 5.04008401e-03f, 2.26004589e-02f, -1.04467301e-02f, -2.04942543e-02f, 4.26147617e-02f, -5.57724051e-02f,
  -1.69606972e-02f, 1.72761083e-02f, 2.25532316e-02f, -2.15282384e-02f, -9.68990028e-02f, 5.71770817e-02f, 7.81334862e-02f, 5.45187034e-02f, -1.92195941e-02f, -1.30472835e-02f,
  -4.15183231e-02f, 1.02585733e-01f, -3.87019068e-02f, 1.96646042e-02f, -1.35240741e-02f, 1.96535122e-02f, 2.54128538e-02f, 8.20040889e-03f, 2.05047149e-02f, -3.50111984e-02f,
  1.02167144e-01f, 1.29183531e-02f, 2.44677253e-02f, -1.53889470e-02f, 2.12987922e-02f, -7.98952952e-02f, -5.60141504e-02f, 1.30473273e-02f, 6.24712408e-02f, 9.19832960e-02f,
  2.39148065e-02f, 3.19219078e-03f, 1.25560947e-02f, 3.46376635e-02f, -7.66966539e-03f, -3.03717097e-03f, 9.36200842e-02f, -1.76102724e-02f, -1.67416297e-02f, -5.32907434e-02f,
  -2.85457850e-01f, -2.32169300e-01f, -6.39823154e-02f, -2.11261451e-01f, -1.12358183e-01f, 2.55187720e-01f, 3.39480639e-01f, -1.56556696e-01f, -1.76128194e-01f, 6.63603544e-02f,
  1.83157506e-03f, -6.16118871e-02f, 2.02748641e-01f, -2.19182074e-01f, 7.99115598e-02f, -1.45269055e-02f, -3.61543559e-02f, 8.78015980e-02f, -1.38874248e-01f, -8.59596729e-02f,
  -9.56727341e-02f, -4.91567627e-02f, -7.55362809e-02f, -4.54439633e-02f, -5.83282337e-02f, -1.07288636e-01f, 4.32193093e-02f, 5.12622818e-02f, 1.81365609e-02f, 9.24305543e-02f,
  3.39979352e-03f, -1.07725129e-01f, -9.83832404e-03f, 2.50023082e-02f, 4.68054824e-02f, 1.05503365e-01f, 1.20296426e-01f, 1.28243968e-01f, -2.35126074e-02f, -1.16158826e-02f,
  4.49860655e-02f, -2.36171894e-02f, -3.82501483e-02f, -2.27860622e-02f, -3.53267640e-02f, -6.78809211e-02f, -1.20104782e-01f, -4.46931124e-02f, -1.82477024e-03f, 6.76547782e-03f,
  -2.27457192e-02f, 1.69945173e-02f, 1.76635198e-02f, 2.63210591e-02f, -1.58075150e-03f, -5.80906272e-02f, 6.74772188e-02f, 6.89756721e-02f, 2.86074225e-02f, -5.19483797e-02f,
  5.71989045e-02f, -3.98413390e-02f, -4.98440675e-02f, -7.53010735e-02f, -2.37723887e-02f, 1.45164886e-02f, -2.51790346e-03f, 2.16383692e-02f, 6.05891831e-03f, -2.43277047e-02f,
  -3.42415161e-02f, -3.43263596e-02f, -4.64835130e-02f, -3.18479538e-02f, -5.04994858e-03f, -9.48425159e-02f, 2.66702939e-02f, -3.72172445e-02f, -4.62512858e-02f, -8.52076616e-03f,
  5.22559136e-02f, 4.56860662e-03f, 4.20173304e-03f, 1.08730942e-01f, -4.73791268e-03f, 3.78029328e-03f, 4.20093490e-03f, -5.14230765e-02f, 2.20006462e-02f, 1.10570997e-01f,
  1.76848888e-01f, 4.54996079e-02f, 4.87134904e-02f, -3.00381519e-02f, 4.06294577e-02f, -5.14404550e-02f, 3.97682795e-03f, -9.55109894e-02f, -3.35262204e-03f, 2.75717732e-02f,
  1.32697895e-02f, -1.07879257e-02f, -2.61255726e-02f, 4.48101293e-03f, 4.65131849e-02f, 6.48654774e-02f, 1.13104455e-01f, 2.86455974e-02f, 1.07926071e-01f, 6.05514413e-03f,
  5.83180860e-02f, 2.58713383e-02f, 2.33778208e-02f, 3.28786522e-02f, 3.03984117e-02f, 5.11574186e-02f, 4.12701722e-03f, -1.54189616e-02f, 2.36239433e-02f, 4.07150574e-03f,
  1.28125921e-01f, -3.98592889e-01f, -2.47825752e-03f, -8.27713087e-02f, 1.27866700e-01f, -1.21850252e-01f, -1.43297121e-01f, -2.40281504e-02f, -1.37425557e-01f, -2.81482458e-01f,
  7.00088451e-03f, -1.73314914e-01f, -4.84438706e-03f, -1.22368492e-01f, 2.98146129e-01f, 4.16875631e-02f, -3.04752938e-03f, -9.44132656e-02f, 1.61301166e-01f, 8.14209506e-02f,
  1.81668073e-01f, -1.80233028e-02f, 1.18133388e-01f, 1.60260260e-01f, 1.61441490e-02f, -4.21563461e-02f, 1.75085023e-01f, 1.42781451e-01f, -1.02477305e-01f, -8.97250548e-02f,
  -4.34884802e-02f, 6.42497391e-02f, 2.18809638e-02f, -2.37205066e-02f, -2.43891384e-02f, -5.94200641e-02f, 1.14156157e-02f, -1.23252477e-02f, 3.63345556e-02f, -6.49275184e-02f,
  -1.67612396e-02f, -5.82373627e-02f, -9.19804908e-03f, 6.03368171e-02f, 1.37477452e-02f, -7.66856521e-02f, 6.14948496e-02f, 1.43107260e-02f, -5.00931367e-02f, -2.31069382e-02f,
  5.33136651e-02f, -3.98636125e-02f, -1.86500810e-02f, -3.17496024e-02f, 1.00197338e-01f, -5.94028346e-02f, -8.17931909e-03f, -3.52512412e-02f, -4.24158387e-02f, -7.96574578e-02f,
  2.90515739e-02f, -1.09847775e-02f, 5.46612293e-02f, 4.07291651e-02f, -2.18060669e-02f, 3.48707996e-02f, -8.62380583e-03f, 1.09931570e-03f, 6.52161706e-03f, -5.63736856e-02f,
  2.09374428e-02f, -5.27745299e-02f, 4.16235216e-02f, -5.29706851e-03f, 2.15796586e-02f, -6.63794354e-02f, 6.17388338e-02f, -5.34514105e-03f, 6.40596896e-02f, 2.59081852e-02f,
  2.22486281e-03f, 5.53142317e-02f, -3.76325734e-02f, 5.97298630e-02f, -4.49986868e-02f, 6.02589129e-03f, 1.06663140e-03f, -5.74301928e-02f, 6.15857244e-02f, 2.22691875e-02f,
  -4.43561189e-02f, -8.04698169e-02f, 5.05959208e-04f, 1.21357813e-02f, 5.56557178e-02f, 7.44440258e-02f, 7.89762139e-02f, -7.30771944e-02f, -4.11086902e-02f, 1.20725892e-01f,
  -7.00283796e-02f, -7.29424530e-04f, -9.21021029e-03f, -3.87928002e-02f, -3.00892983e-02f, 1.51345748e-02f, 7.89000317e-02f, -5.03089353e-02f, 5.47025576e-02f, -2.24109957e-04f,
  1.28387678e-02f, -4.31226520e-03f, -1.78096350e-02f, 2.23124437e-02f, 1.28951203e-02f, -3.23594324e-02f, -3.74967791e-02f, -4.24803756e-02f, 4.08430099e-02f, -3.02865542e-02f,
  -4.31640953e-01f, -1.56116709e-01f, -1.82047114e-01f, -3.54335725e-01f, 1.06458910e-01f, -2.10412040e-01f, -3.05134416e-01f, 9.22512785e-02f, -2.92808145e-01f, -8.52070376e-02f,
  5.66434348e-03f, -7.47973993e-02f, -8.77923220e-02f, -1.68918014e-01f, -1.19738877e-01f, -1.04036435e-01f, -2.14364737e-01f, -1.53571935e-02f, -1.06278308e-01f, -1.35255516e-01f,
  -9.38604623e-02f, -1.04212556e-02f, -3.66939791e-02f, 2.27861285e-01f, -7.12112039e-02f, -6.06928812e-03f, 1.20088071e-01f, 7.31074736e-02f, 7.99341351e-02f, 1.58800274e-01f,
  3.60373147e-02f, -1.02157049e-01f, -1.84905604e-02f, 1.99264311e-03f, -3.63699123e-02f, 8.19452479e-02f, -7.28510022e-02f, 4.57402617e-02f, -5.13177961e-02f, 7.41224084e-03f,
  -1.34065542e-02f, 2.06813812e-02f, -3.57081206e-03f, 1.22158008e-03f, -2.89504100e-02f, 1.31855691e-02f, -2.61624493e-02f, -4.50750701e-02f, 3.35678384e-02f, -5.03245592e-02f,
  -6.13207221e-02f, 1.27696358e-02f, -6.33268803e-02f, -2.64846953e-03f, -1.53588811e-02f, -7.52892792e-02f, 3.98435863e-03f, -2.05669105e-02f, 2.95270216e-02f, 1.28361518e-02f,
  -2.14374866e-02f, 1.04334895e-02f, 1.22615043e-02f, 6.22787923e-02f, 3.20645384e-02f, 1.05664963e-02f, -8.42733774e-03f, 1.11773312e-01f, -6.29594103e-02f, -5.79573177e-02f,
  1.14017017e-02f, -5.89662120e-02f, 1.58568099e-02f, -2.07886044e-02f, 1.38418665e-02f, -1.25120338e-02f, 2.15092697e-03f, -3.46153788e-03f, -6.15737624e-02f, 1.25723742e-02f,
  -1.29482839e-02f, 5.01006693e-02f, 2.91787903e-03f, 6.84874356e-02f, 2.69843545e-02f, -4.97299135e-02f, 3.69085446e-02f, -1.30506754e-02f, -5.40689100e-03f, 2.15190034e-02f,
  -4.29826714e-02f, 6.21600717e-04f, -5.58177084e-02f, 5.83656803e-02f, -5.23087159e-02f, -4.99614924e-02f, 1.38241043e-02f, -3.95901687e-03f, 9.92810801e-02f, 9.80350422e-04f,
  -3.08483131e-02f, 1.09152170e-02f, 5.65647185e-02f, 3.55816074e-02f, 9.80400965e-02f, 4.24213102e-03f, -2.43101530e-02f, 7.81870857e-02f, -3.92475538e-02f, 2.37576459e-02f,
  1.86625887e-02f, -5.87237217e-02f, 1.03718145e-02f, 4.69334163e-02f, -1.77687849e-04f, -3.69579419e-02f, 2.25019902e-02f, 2.90282033e-02f, 4.38834913e-02f, -4.55156937e-02f,
  4.37351428e-02f, -3.61985117e-01f, 5.74899204e-02f, -2.20916048e-01f, 6.83789626e-02f, -1.64291024e-01f, 8.63820910e-02f, -2.07261860e-01f, -1.65498465e-01f, -2.68463492e-01f,
  -1.32742561e-02f, -1.38484342e-02f, -5.27807847e-02f, -3.49009812e-01f, 1.64637417e-01f, -1.61911651e-01f, -2.14617312e-01f, -1.00125417e-01f, -4.59705815e-02f, -9.35563147e-02f,
  4.09604833e-02f, -2.14138344e-01f, 3.10366247e-02f, -1.46959081e-01f, -5.05400524e-02f, -1.55611867e-02f, 1.11771636e-01f, 9.61363092e-02f, 1.42384749e-02f, 4.27552797e-02f,
  -7.12217987e-02f, -6.92040548e-02f, -5.97680397e-02f, 3.97516824e-02f, -3.84115279e-02f, 7.70635391e-03f, -1.00505287e-02f, 8.94820988e-02f, 5.00949845e-02f, 1.94984227e-02f,
  2.56438293e-02f, 2.51448322e-02f, -5.78946359e-02f, 2.23597959e-02f, -5.77142164e-02f, 2.76690535e-02f, 1.77461803e-02f, 7.32273236e-03f, -2.49169860e-02f, 1.12284794e-02f,
  -3.35838310e-02f, -1.67825427e-02f, -6.92825913e-02f, 1.01079037e-02f, 4.52300683e-02f, -1.44358096e-03f, -6.12810403e-02f, 9.37203988e-02f, -8.50093663e-02f, -2.17913687e-02f,
  -3.15970331e-02f, -5.98570108e-02f, 5.96598089e-02f, -1.40164327e-02f, -6.11044094e-03f, 9.42123495e-03f, 7.29882531e-03f, 1.30304927e-02f, 1.75974704e-02f, -5.19340187e-02f,
  8.25382322e-02f, -5.34276925e-02f, -3.18279155e-02f, 4.40802146e-03f, 2.50912774e-02f, -6.80749193e-02f, 2.16588452e-02f, -3.61935310e-02f, 5.78880915e-03f, 1.33961206e-02f,
  3.83251831e-02f, -4.91572246e-02f, -2.85849217e-02f, 2.13564802e-02f, -4.95775195e-04f, 1.86816789e-02f, -5.38744554e-02f, 2.32604127e-02f, -3.04599479e-03f, 7.11820647e-02f,
  -6.23218976e-02f, -2.38041773e-01f, 3.00538279e-02f, 2.25149840e-02f, 1.46297934e-02f, 5.82981668e-03f, 3.97950374e-02f, -5.12932502e-02f, -5.29616745e-03f, -9.00072753e-02f,
  2.72374786e-03f, 8.74123722e-03f, -5.03959716e-04f, -1.90937202e-02f, 4.33226535e-03f, -9.90418810e-03f, -6.57967059e-03f, 9.23602208e-02f, 1.99027639e-02f, -6.48958189e-03f,
  3.24496068e-02f, 2.29865536e-02f, 4.29223366e-02f, -3.71657088e-02f, -6.60194233e-02f, 4.80417237e-02f, 3.22133526e-02f, 2.18315441e-02f, 4.88598943e-02f, -6.39614239e-02f,
  2.95432270e-01f, -1.12687156e-01f, 7.59356655e-03f, 2.65127718e-01f, 1.41642531e-02f, 1.47320583e-01f, 1.31806836e-01f, -1.21489324e-01f, 1.26858652e-01f, -8.95247087e-02f,
  9.63175595e-02f, -4.20138985e-02f, -3.17824036e-01f, 2.48356640e-01f, 5.25868908e-02f, -2.51467615e-01f, 3.23628992e-01f, 2.17721432e-01f, -1.07343450e-01f, 1.05312392e-02f,
  -1.35090845e-02f, -1.46834888e-02f, -1.68804056e-03f, -9.04369205e-02f, 1.98930264e-01f, 1.03336252e-01f, -2.10072212e-02f, -2.34043188e-02f, 1.89210147e-01f, 8.02841261e-02f,
  3.34435292e-02f, -4.57371026e-02f, 5.98826930e-02f, -1.50340302e-02f, 5.71973883e-02f, 2.26710401e-02f, 1.02843381e-01f, 7.95833096e-02f, 7.77878687e-02f, -2.86044218e-02f,
  3.37332604e-04f, -4.37460318e-02f, -1.30336294e-02f, -7.67886043e-02f, 1.55652195e-01f, 6.17841631e-03f, -4.64478694e-02f, 2.11768858e-02f, 1.94764398e-02f, -7.71744689e-03f,
  3.76898888e-03f, -3.80464531e-02f, 5.27586192e-02f, 1.66279133e-02f, -2.07317318e-03f, 3.28750499e-02f, -1.08556394e-02f, 3.29887383e-02f, 2.05257796e-02f, 4.37147394e-02f,
  3.79697280e-03f, -1.22411855e-01f, 3.55732106e-02f, -7.75373504e-02f, -1.49340648e-03f, 9.77248326e-02f, 4.21133824e-03f, 6.25506788e-03f, 2.51689125e-02f, 3.98655906e-02f,
  3.94998677e-02f, 9.32038352e-02f, 7.13540018e-02f, 4.58630957e-02f, 2.91560758e-02f, 2.00304110e-02f, 6.30658716e-02f, -2.31593661e-02f, 7.77173936e-02f, -3.63145433e-02f,
  4.32074144e-02f, 8.54551699e-03f, -7.05269501e-02f, 4.17883657e-02f, 3.73626389e-02f, 4.50385213e-02f, -2.35350635e-02f, 6.41994029e-02f, 1.50553891e-02f, -2.69709080e-02f,
  -3.32231633e-02f, -1.77303597e-01f, -7.21188337e-02f, 2.67482884e-02f, -8.16873387e-02f, -8.01994000e-03f, -3.01992185e-02f, -2.74825525e-02f, 1.43502969e-02f, -6.73293918e-02f,
  -7.67146349e-02f, 5.63865900e-02f, 1.64429750e-02f, 1.49889048e-02f, 1.14588896e-02f, -3.59690003e-02f, -4.40212265e-02f, 7.61345774e-02f, 1.06080130e-01f, -4.07047011e-02f,
  -9.97131914e-02f, -4.76389788e-02f, -5.30707799e-02f, 7.28883920e-03f, 4.04828228e-02f, -4.40116934e-02f, -3.01486859e-03f, 2.44968552e-02f, -1.07225066e-03f, 5.28962584e-03f,
  -2.20548615e-01f, -6.22523651e-02f, -1.82603955e-01f, -1.97643772e-01f, 9.93167534e-02f, 8.32512975e-02f, 1.04761533e-02f, -1.53664589e-01f, -3.97193283e-01f, 2.08392859e-01f,
  -1.78361591e-02f, -4.85552736e-02f, 6.46532327e-02f, 9.03149396e-02f, -2.86572844e-01f, -8.44580233e-02f, -5.68176135e-02f, 2.09037643e-02f, -1.51917443e-01f, 1.07060850e-01f,
  -1.40514523e-01f, 1.75087407e-01f, 6.01192303e-02f, 5.74997962e-02f, 1.95174679e-01f, -6.39400706e-02f, 1.40215024e-01f, 8.44886228e-02f, 2.54742742e-01f, 2.92595662e-02f,
  -7.34839961e-02f, -8.85076970e-02f, 1.47718247e-02f, -4.72840481e-02f, 3.56377736e-02f, 8.91467556e-02f, 6.52136803e-02f, 5.97489960e-02f, -9.91177410e-02f, 2.07447484e-02f,
  1.16789348e-01f, -6.16255961e-02f, -4.08162102e-02f, -4.95264605e-02f, -5.97176095e-03f, -2.70367377e-02f, -3.73408687e-03f, -4.91362251e-02f, 2.58680177e-03f, -2.70208661e-02f,
  -2.73623448e-02f, -4.83951308e-02f, 2.23341193e-02f, -1.48833143e-02f, -2.86194254e-02f, 4.44843732e-02f, -8.85814205e-02f, 8.25463757e-02f, -4.09940779e-02f, -1.05639063e-01f,
  -2.75075566e-02f, 2.76851114e-02f, 1.25276502e-02f, 9.97608304e-02f, 5.47134830e-03f, -1.04177305e-02f, 1.58641431e-02f, 6.75113052e-02f, -6.90244976e-03f, 5.92717081e-02f,
  8.37565213e-03f, 5.16565815e-02f, -6.21228898e-03f, -7.95808733e-02f, 7.66329169e-02f, -1.48852449e-02f, 3.74108814e-02f, 8.25518295e-02f, -8.38151127e-02f, 8.72370526e-02f,
  -2.34737918e-02f, -3.39385569e-02f, -2.72582732e-02f, 5.72595298e-02f, -3.55079919e-02f, -1.70057975e-02f, -3.53208892e-02f, -2.03501768e-02f, 5.23447059e-02f, 4.02698033e-02f,
  -1.29725700e-02f, 1.81820691e-02f, -3.84700000e-02f, -3.60623412e-02f, -3.56522836e-02f, 9.20427442e-02f, -1.32138699e-01f, -3.07547878e-02f, -2.58171521e-02f, 1.06711509e-02f,
  3.57638001e-02f, 6.47959709e-02f, 4.57744561e-02f, 5.38298301e-03f, -1.29686862e-01f, -5.15284799e-02f, 1.79483742e-02f, -6.22659139e-02f, 3.61041650e-02f, -1.53249055e-02f,
  2.38220710e-02f, -1.95358205e-03f, -2.41914913e-02f, 6.44652843e-02f, -2.44062431e-02f, 5.60839213e-02f, 2.40068566e-02f, -6.13053814e-02f, 1.77038964e-02f, 2.86289863e-02f,
  2.86726635e-02f, 5.41882738e-02f, 1.75773829e-01f, 1.11070285e-02f, 3.78120020e-02f, -8.11378136e-02f, 4.02440540e-02f, 1.13290206e-01f, 2.30566576e-01f, -5.92687391e-02f,
  -3.69530246e-02f, 9.12622213e-02f, -1.85838826e-02f, -1.23478964e-01f, -3.78128141e-01f, -2.01055646e-01f, -1.47491321e-01f, 6.91926992e-03f, 6.59103468e-02f, 1.13888860e-01f,
  -1.33476425e-02f, -1.60712793e-01f, -1.46081164e-01f, 4.45654392e-02f, 1.18491448e-01f, 1.93692833e-01f, -9.29518864e-02f, 1.39484704e-01f, -1.17181517e-01f, -7.78000727e-02f,
  1.52893066e-02f, 1.75823647e-04f, 4.18843105e-02f, -2.52472479e-02f, 2.03504413e-02f, -1.44372685e-02f, -4.35755476e-02f, -3.35119404e-02f, 1.11145250e-01f, 2.56993324e-02f,
  1.16290245e-03f, -3.84207331e-02f, 4.57203165e-02f, -1.12282289e-02f, 1.14249744e-01f, -7.38770217e-02f, 4.19959538e-02f, 3.82047929e-02f, 4.30850200e-02f, -4.82597010e-04f,
  -1.07346643e-02f, 9.34323892e-02f, 6.94649071e-02f, -1.14587126e-02f, 7.92687684e-02f, 8.93089622e-02f, 7.90177286e-03f, 1.59012973e-02f, -8.66841618e-03f, 2.99175475e-02f,
  -1.03754982e-01f, 5.37722111e-02f, 2.88904645e-03f, 1.81968557e-03f, 6.61417283e-03f, -5.48654385e-02f, -4.67013480e-04f, -5.95948752e-03f, 3.41611505e-02f, -5.07717244e-02f,
  3.56764123e-02f, -1.53331691e-02f, 1.17947860e-02f, 7.23528191e-02f, 6.37410432e-02f, -6.77604079e-02f, -2.63721612e-03f, -8.89895391e-03f, 4.69139926e-02f, -5.21211140e-02f,
  -1.44198211e-02f, 4.30762582e-03f, 1.77557636e-02f, -6.60419539e-02f, -1.14580207e-02f, 4.36972408e-03f, 3.43987085e-02f, -2.09139474e-02f, 3.39738801e-02f, -2.74031311e-02f,
  -3.40121351e-02f, -7.59238657e-03f, 5.02761304e-02f, -6.25969470e-02f, -1.12613281e-02f, 2.01025028e-02f, -4.00104858e-02f, 2.05939133e-02f, -1.57596227e-02f, -5.82072772e-02f,
  4.97668311e-02f, -2.44505666e-02f, 1.67869423e-02f, 5.04017400e-04f, -2.57306993e-02f, -4.79664691e-02f, -3.24313939e-02f, 8.98400843e-02f, -2.86381766e-02f, -3.49403918e-02f,
  4.61539440e-03f, 1.65601876e-02f, 6.42405078e-02f, 9.82283987e-03f, -6.28527552e-02f, -2.01958120e-02f, -2.63604373e-02f, 9.86496657e-02f, -4.82815430e-02f, 8.65306892e-03f,
  5.72075974e-03f, -1.06090292e-01f, -2.81299651e-01f, -1.35026082e-01f, 1.53516382e-01f, 1.92883685e-01f, 1.05772026e-01f, 8.81986022e-02f, 4.14026789e-02f, 1.90962374e-01f,
  9.12589654e-02f, -2.64043778e-01f, -7.14500248e-02f, 2.43305475e-01f, -1.46924958e-01f, -9.41355750e-02f, 7.44509846e-02f, 6.34394884e-02f, -2.42583100e-02f, 3.70281003e-02f,
  -4.02498767e-02f, 2.71553218e-01f, -2.08926708e-01f, 1.71132430e-01f, -2.91289180e-03f, -1.84589714e-01f, -3.79312113e-02f, -5.38479276e-02f, 8.50548819e-02f, -7.57765546e-02f,
  6.90997615e-02f, 4.79923468e-03f, -4.14658301e-02f, -4.53904737e-03f, 5.68803847e-02f, 3.69313359e-02f, 4.01664339e-03f, -1.08652133e-02f, -2.20762249e-02f, 4.14158069e-02f,
  2.89797075e-02f, 2.18641479e-02f, 2.99968962e-02f, -3.58578563e-03f, 7.87951723e-02f, -3.34959887e-02f, 2.08478514e-02f, -1.31140342e-02f, -2.67401095e-02f, -8.67261365e-02f,
  -7.78737292e-02f, -1.40129440e-02f, -8.22744891e-03f, 5.28450171e-03f, -3.61801758e-02f, 2.50812825e-02f, -6.43793195e-02f, -4.05432768e-02f, -5.67415431e-02f, 1.93107314e-02f,
  1.11213215e-02f, 2.19439510e-02f, 3.19189541e-02f, 6.27708808e-02f, 2.35498510e-02f, 1.00206044e-02f, 1.10527389e-02f, 4.63199522e-03f, -5.94961531e-02f, -9.01870336e-03f,
  4.94804941e-02f, -6.39388859e-02f, 1.06334262e-01f, -3.92017961e-02f, 9.43910331e-03f, 4.99123754e-03f, -7.35519156e-02f, 1.32179540e-02f, -6.32461626e-03f, -9.03436448e-03f,
  1.33266011e-02f, 4.97837067e-02f, -1.47267971e-02f, -3.71592008e-02f, 7.01944083e-02f, -4.87644300e-02f, 7.94588029e-02f, -5.79334311e-02f, 8.87988892e-04f, -3.10755018e-02f,
  -4.98429835e-02f, -3.53308320e-02f, 2.24376973e-02f, 2.57058125e-02f, -6.61873519e-02f, 8.29642732e-03f, -9.24752839e-03f, -1.48653751e-02f, 1.03019807e-03f, 1.16044395e-01f,
  6.10361807e-02f, 3.25362831e-02f, -2.46591978e-02f, 3.48939151e-02f, -8.99388827e-03f, 7.83985294e-03f, 2.70459950e-02f, -1.00497156e-02f, -3.26829590e-02f, 2.01718546e-02f,
  9.93445665e-02f, 2.05990896e-02f, 2.92375945e-02f, 3.87005843e-02f, -9.36929323e-03f, 2.70571075e-02f, -1.62550819e-03f, -3.88106853e-02f, 2.14919578e-02f, -3.76006328e-02f,
  4.32808071e-01f, -1.15259022e-01f, 2.86224604e-01f, 1.55742809e-01f, 5.27491188e-03f, -1.50901884e-01f, 1.28808796e-01f, -7.60669708e-02f, 2.71026582e-01f, -1.39233828e-01f,
  -5.30405752e-02f, 7.42223039e-02f, 4.15808596e-02f, -5.49995229e-02f, 2.05179766e-01f, 8.19937363e-02f, -8.79901648e-02f, -7.88751915e-02f, 6.13247789e-02f, -3.84427756e-02f,
  9.72607434e-02f, -1.56114325e-01f, 1.51237726e-01f, -2.34497711e-01f, -2.85098649e-04f, -5.62590500e-03f, -3.98084372e-02f, 7.83745944e-02f, -1.59126267e-01f, -4.34007682e-02f,
  6.51229620e-02f, -7.40334252e-03f, 7.11988732e-02f, 5.12569249e-02f, -6.11845404e-02f, -3.36222164e-02f, -8.09773579e-02f, 5.46826608e-02f, -2.30214354e-02f, -3.48747298e-02f,
  4.93865125e-02f, 3.52672301e-02f, -5.02154380e-02f, 3.94480526e-02f, 5.48685789e-02f, 8.11162032e-03f, 3.29113677e-02f, 5.86656928e-02f, 4.95450124e-02f, 2.46933494e-02f,
  7.63429105e-02f, 4.60129566e-02f, 4.58315574e-02f, 4.53565530e-02f, 6.09823614e-02f, -3.67734469e-02f, 3.19657400e-02f, -3.91030125e-02f, -2.16457639e-02f, -7.29418872e-03f,
  -1.35378279e-02f, 1.46696260e-02f, 2.13121418e-02f, 1.79184340e-02f, -6.87242858e-03f, 1.55741088e-02f, -2.79601887e-02f, -1.51718808e-02f, 8.33972394e-02f, -3.98527235e-02f,
  3.08402181e-02f, 6.67391866e-02f, 2.06358414e-02f, 3.49883698e-02f, 8.51875113e-04f, 5.06883906e-03f, -7.23578315e-03f, -1.02411518e-02f, 4.30016667e-02f, -1.68136656e-02f,
  3.20717022e-02f, -3.94597044e-03f, -2.06727982e-02f, 3.73811387e-02f, 1.88851205e-03f, 2.06772313e-02f, 3.39362286e-02f, -1.62815638e-02f, 1.78081337e-02f, 9.53517668e-03f,
  -8.23478475e-02f, -9.24234614e-02f, 4.61389646e-02f, 1.40561184e-04f, -1.85067405e-03f, -3.17711718e-02f, 5.93185909e-02f, -5.73187880e-02f, 1.05381599e-02f, -7.01879710e-03f,
  -4.67389412e-02f, -3.51115167e-02f, -8.97343177e-03f, -5.80355898e-02f, -2.48153042e-02f, 1.63652766e-02f, -7.43218437e-02f, -5.09505048e-02f, -2.91570313e-02f, -3.19526866e-02f,
  -2.42427308e-02f, -3.11124083e-02f, -9.39264614e-03f, -2.94748209e-02f, -7.52572268e-02f, -3.25658103e-03f, -3.00483685e-02f, 4.98444624e-02f, -7.61531442e-02f, -4.08213176e-02f,
  -1.59234345e-01f, 3.12833972e-02f, -2.67683357e-01f, 1.89326450e-01f, 3.44434269e-02f, 3.65351766e-01f, 2.57089138e-01f, -2.97785979e-02f, 1.80168092e-01f, 2.27740467e-01f,
  2.65773386e-01f, -7.36184940e-02f, 3.59000713e-02f, 2.32013896e-01f, 2.14248970e-01f, 1.46151662e-01f, 2.13594899e-01f, 8.74130279e-02f, -8.94634426e-02f, -3.32777835e-02f,
  2.36338861e-02f, 2.25896806e-01f, -5.03465794e-02f, 4.60733520e-03f, 1.05279675e-02f, -1.43164128e-01f, -4.74698022e-02f, -1.34167790e-01f, 1.61748976e-01f, 1.32948374e-02f,
  -1.98393520e-02f, -2.06442446e-01f, -1.46612704e-01f, -2.36335248e-02f, 8.70627631e-03f, -7.04490915e-02f, -5.32296188e-02f, -5.18923067e-02f, -4.99464646e-02f, 2.26739924e-02f,
  -3.78498994e-02f, -4.67867367e-02f, 1.31466603e-02f, 1.83033608e-02f, 3.63773555e-02f, -1.97646376e-02f, -2.23683845e-02f, 1.18940733e-02f, -2.24690954e-03f, -8.97863880e-02f,
  -2.91451421e-02f, 9.84209999e-02f, 3.92812714e-02f, 3.37272398e-02f, 9.11974348e-03f, 1.06802717e-01f, -3.59317474e-02f, -8.69987980e-02f, 6.39919266e-02f, 8.25476944e-02f,
  -3.32174189e-02f, -1.85890570e-02f, -9.01006758e-02f, -4.10237573e-02f, -1.18725719e-02f, -4.61518690e-02f, 8.28837752e-02f, -9.13216248e-02f, 1.79380197e-02f, 4.70635928e-02f,
  9.86377671e-02f, 1.44370440e-02f, 3.24305147e-02f, 8.14577006e-03f, -1.00434050e-02f, 2.98265871e-02f, -2.27390248e-02f, -4.08250131e-02f, 3.59244049e-02f, 2.68103685e-02f,
  -3.37173901e-02f, 1.95634626e-02f, 3.14689539e-02f, -1.20561067e-02f, 8.05087835e-02f, -7.29756206e-02f, 2.25194935e-02f, 2.31151298e-05f, 5.64093469e-03f, -5.07194139e-02f,
  -1.20151816e-02f, -5.58960848e-02f, 8.28425400e-03f, 6.44000173e-02f, -6.26895800e-02f, 9.95561387e-03f, 2.60735340e-02f, -9.46338382e-03f, 4.29160036e-02f, -6.03060871e-02f,
  3.10153142e-02f, -3.57002765e-02f, -2.36284640e-03f, 1.97796635e-02f, 8.80529210e-02f, 3.44437477e-03f, 3.06949876e-02f, 7.13004917e-02f, 8.21224600e-02f, 1.51304742e-02f,
  -2.76506115e-02f, 4.36124541e-02f, -1.45511543e-02f, -4.52007260e-03f, -3.28209512e-02f, -3.26450765e-02f, -5.49917743e-02f, 6.24179021e-02f, 8.38024244e-02f, -4.21304218e-02f,
  -2.33731866e-01f, 3.96016836e-02f, -3.82782191e-01f, 2.35683825e-02f, 4.24405709e-02f, -2.11369023e-01f, -2.32883886e-01f, -1.32703129e-02f, -2.54712582e-01f, 1.74704507e-01f,
  4.23162691e-02f, -8.25425982e-02f, -1.88343897e-01f, 1.48155987e-01f, -2.30234355e-01f, -1.09466076e-01f, 1.06370360e-01f, 6.44737035e-02f, 2.68490054e-02f, -2.49156244e-02f,
  -1.42480791e-01f, 2.92284757e-01f, -1.64618865e-01f, 1.40801162e-01f, -1.21102676e-01f, -2.15062294e-02f, 2.50723600e-01f, 8.89959000e-03f, 1.84410438e-01f, 3.37016471e-02f,
  1.48443142e-02f, -5.45127504e-03f, -7.35573918e-02f, -5.85690476e-02f, -1.20295048e-01f, 4.35043350e-02f, 1.52590204e-04f, -2.78956462e-02f, 1.74047127e-02f, -4.43030074e-02f,
  -5.56773879e-02f, -8.53604451e-03f, 3.29396985e-02f, -4.78934776e-03f, -4.62838151e-02f, -1.12459743e-02f, 4.92342748e-02f, 5.00530973e-02f, 3.98859978e-02f, -3.11760865e-02f,
  -5.72154969e-02f, 1.86743736e-02f, 3.83817311e-03f, 2.75753997e-02f, -4.84276190e-02f, -7.11033940e-02f, -5.41819930e-02f, -5.67497872e-02f, 5.39585799e-02f, -9.87630337e-03f,
  3.82108837e-02f, -3.36249806e-02f, 2.86373813e-02f, 1.26158278e-02f, -3.21740471e-02f, 4.38186303e-02f, 2.21004826e-03f, 4.84781228e-02f, -9.39581729e-03f, 1.31792733e-02f,
  -5.18146940e-02f, 3.22536901e-02f, 7.26495609e-02f, 1.81499589e-02f, 3.21587808e-02f, 1.60357933e-02f, -4.47500087e-02f, 7.05072284e-03f, -2.33502090e-02f, 6.73884749e-02f,
  1.47491647e-02f, -4.94287163e-02f, 2.57758219e-02f, 8.38449076e-02f, 2.72826379e-04f, 1.16063431e-02f, 4.24068347e-02f, -2.02015284e-02f, 2.82657184e-02f, -6.50602132e-02f,
  -7.84348976e-03f, -2.31847521e-02f, -4.04638099e-03f, 9.02001187e-02f, 3.86777371e-02f, 6.11595660e-02f, 1.36029329e-02f, 6.23188308e-03f, -6.68126047e-02f, -4.10412811e-02f,
  1.89707372e-02f, 4.16256264e-02f, 5.33774728e-03f, 1.75737571e-02f, -4.01634537e-02f, -1.86716765e-02f, 9.42624826e-03f, -3.04039717e-02f, -1.58758517e-02f, 7.28054494e-02f,
  -1.33271245e-02f, 5.39137088e-02f, -1.64098050e-02f, 4.03823610e-03f, 6.34523556e-02f, 6.97811991e-02f, 4.69910689e-02f, -3.19509469e-02f, 4.10171337e-02f, 1.40092624e-02f,
  -2.93414235e-01f, -1.28962964e-01f, -4.52544540e-02f, -2.17205808e-01f, -1.08807683e-01f, 2.18901441e-01f, 2.37342879e-01f, -1.97960079e-01f, -3.40678275e-01f, 4.05932665e-02f,
  1.14264198e-01f, -2.38352403e-01f, 2.77954072e-01f, -1.23481125e-01f, 3.49963047e-02f, 2.17700884e-01f, -2.32741192e-01f, -9.60716829e-02f, -3.83427814e-02f, -1.45430312e-01f,
  -1.21808201e-01f, 4.90219472e-03f, 1.32100180e-01f, -9.74419490e-02f, -9.27595515e-03f, -1.28964007e-01f, 5.49029745e-02f, 1.75899908e-01f, -7.67769888e-02f, 8.09188709e-02f,
  4.46561202e-02f, -6.58015758e-02f, -7.41204713e-03f, -2.09404808e-03f, 1.66058522e-02f, 8.22807625e-02f, 4.80460562e-02f, 7.82025456e-02f, -2.31482238e-02f, 1.85320657e-02f,
  3.01036146e-02f, -7.67820701e-02f, -4.28621769e-02f, -7.50501230e-02f, -9.59646404e-02f, -9.36079025e-02f, 1.55091509e-02f, -6.21926365e-03f, -2.99612321e-02f, 4.73605655e-02f,
  5.93899935e-02f, -3.39112282e-02f, 9.66588443e-04f, -3.98021452e-02f, -7.05801928e-03f, -8.27606097e-02f, -2.64101140e-02f, 5.69043495e-02f, -1.57725159e-02f, -9.92382690e-02f,
  -5.73116802e-02f, 3.65524665e-02f, 1.93155333e-02f, 3.53769846e-02f, 1.94936525e-02f, 1.16288671e-02f, 6.42999783e-02f, 6.42942218e-03f, -4.44615558e-02f, 1.00138912e-03f,
  -6.56281039e-02f, -7.84817711e-02f, -6.13592006e-03f, -6.00927286e-02f, -3.44080515e-02f, -2.03969032e-02f, 3.84622850e-02f, -5.91122359e-03f, -5.11605814e-02f, 9.15203616e-03f,
  1.60560329e-02f, -6.81182742e-02f, 6.42245933e-02f, 9.12586004e-02f, 2.98244432e-02f, 1.20012052e-02f, -7.37918466e-02f, 2.38514077e-02f, 2.26338413e-02f, 3.10956798e-02f,
  -3.51878814e-02f, -1.48337081e-01f, 9.22103003e-02f, 4.66340035e-03f, 1.11892764e-02f, -2.76631378e-02f, -5.07225432e-02f, -8.94061476e-02f, -4.44987454e-02f, -3.99523340e-02f,
  -5.56467883e-02f, -4.77662943e-02f, -5.05226217e-02f, 6.14558794e-02f, 1.34952450e-02f, -1.77108590e-02f, 6.81316160e-05f, -4.45997827e-02f, -5.81575632e-02f, -6.51894435e-02f,
  -3.51314321e-02f, -2.59209778e-02f, 4.44956720e-02f, -9.68801603e-03f, -6.15373347e-03f, 8.10565054e-02f, -1.31372437e-01f, -5.07749133e-02f, 3.63346152e-02f, 1.20912772e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.67687881e-01f, -1.51696727e-01f, -8.18992853e-02f, 6.22317642e-02f, 6.24415353e-02f, 2.24590059e-02f, 6.17601983e-02f, -6.82651252e-02f, 4.97252196e-01f, -1.88099027e-01f,
  4.04121801e-02f, -2.05523938e-01f, 8.77145585e-03f, -1.79773465e-01f, 1.16669431e-01f, 1.10268481e-01f, 7.04667121e-02f, -1.29036829e-01f, 6.94099665e-02f, -5.05000353e-02f,
  1.51681378e-01f, -1.66229159e-01f, -2.59719193e-01f, -2.80930817e-01f, -1.25000045e-01f, -1.65801212e-01f, -1.83732256e-01f, -2.36165330e-01f, -3.22343707e-01f, -4.46496010e-02f,
  9.09735099e-05f, 1.27683237e-01f, 4.54636365e-02f, -6.93766549e-02f, 1.55062437e-01f, 6.13218918e-02f, -1.98842227e-01f, -1.80935755e-01f, 1.36445671e-01f, 1.08337477e-01f,
  4.31102216e-02f, -2.64209472e-02f, 4.36763233e-03f, -1.77109484e-02f, -2.15060450e-02f, -3.46683413e-02f, 8.40254351e-02f, 1.22184433e-01f, -9.69965085e-02f, -5.90326935e-02f,
  9.29555744e-02f, -4.51520458e-02f, 1.67154491e-01f, -7.23559931e-02f, -6.20868839e-02f, -5.07610217e-02f, -3.74656133e-02f, -7.99878612e-02f, -6.92510232e-02f, 1.26012027e-01f,
  -3.12239509e-02f, -3.18694450e-02f, 6.82074651e-02f, 8.33158344e-02f, -8.79680812e-02f, 9.10397843e-02f, 3.11416611e-02f, 3.83504182e-02f, 4.98560108e-02f, -4.68408763e-02f,
  -6.53212517e-02f, -3.89923938e-02f, 1.17037315e-02f, -1.32457754e-02f, 1.39386460e-01f, 4.54186462e-02f, -1.18508361e-01f, -2.81179138e-02f, 4.28008102e-03f, 1.19280957e-01f,
  1.11747213e-01f, -7.86918402e-02f, -4.82294038e-02f, -3.58602032e-03f, 4.15158160e-02f, 3.56173366e-02f, 6.67964295e-02f, 4.17949408e-02f, 1.80686712e-01f, -9.83756334e-02f,
  4.51309569e-02f, -2.49771085e-02f, 5.25354035e-02f, -1.01621687e-01f, -4.28458862e-02f, -2.56848615e-02f, -5.04849702e-02f, 9.69321579e-02f, 1.24705834e-02f, -5.13785444e-02f,
  -1.96195379e-01f, -9.00707096e-02f, -1.72756016e-02f, 1.69088040e-02f, -5.43683209e-02f, 1.53133413e-02f, -3.71873118e-02f, -2.72502992e-02f, -1.02267362e-01f, 6.03889450e-02f,
  -5.53946346e-02f, 1.20620001e-02f, 3.96904688e-05f, -3.67329493e-02f, -1.08727895e-01f, -3.21747139e-02f, -6.39475733e-02f, -1.51801286e-02f, -1.56064436e-01f, -4.13714163e-02f,
  -7.16131985e-01f, 1.78171024e-01f, 4.19090599e-01f, -4.36687171e-01f, 5.09439632e-02f, 3.99358749e-01f, 1.88071817e-01f, 1.18539192e-01f, -1.19587578e-01f, 1.77590828e-02f,
  6.97759539e-02f, -1.59075379e-01f, 3.29385042e-01f, 6.39915168e-02f, 1.70058414e-01f, 2.39158392e-01f, 1.25885889e-01f, 5.25906049e-02f, -1.96225159e-02f, -1.57738104e-01f,
  -1.04800671e-01f, -5.65910786e-02f, 1.71123415e-01f, -4.90191057e-02f, 3.31843272e-03f, -1.87255949e-01f, -1.90354973e-01f, 1.04811408e-01f, -7.46193603e-02f, 2.64137257e-02f,
  -6.56704903e-02f, -2.56005526e-01f, 1.12287495e-02f, 5.05710170e-02f, 2.38385759e-02f, -1.17355390e-02f, -5.16816508e-03f, 5.87799810e-02f, -6.76104501e-02f, 2.93803960e-02f,
  6.65005818e-02f, 9.29102078e-02f, -8.88309777e-02f, -1.25538651e-02f, -9.10656005e-02f, 8.14329982e-02f, 1.51283264e-01f, 4.39409576e-02f, 9.72283781e-02f, 1.34143889e-01f,
  5.54206297e-02f, 9.92259458e-02f, 7.63795003e-02f, 1.17655080e-02f, 3.05159930e-02f, -1.09357573e-02f, 9.05184671e-02f, 6.56455010e-02f, -1.08976476e-02f, -2.27541514e-02f,
  -1.11458488e-01f, -6.70036972e-02f, 8.82487670e-02f, -3.89532857e-02f, -1.33586787e-02f, -9.97121632e-02f, -4.59637977e-02f, -4.58971485e-02f, -1.15347998e-02f, -3.09877396e-02f,
  -6.12326413e-02f, -2.14184858e-02f, -8.27843845e-02f, 4.34774086e-02f, -2.21638661e-02f, -2.24208105e-02f, 8.76048505e-02f, -7.54085109e-02f, 5.47151826e-02f, -1.39015950e-02f,
  -1.03618212e-01f, -9.43972729e-03f, -2.16755643e-02f, -1.00348018e-01f, 4.14369144e-02f, 1.14447363e-01f, -3.39521430e-02f, 3.16594690e-02f, -5.62651195e-02f, 4.11801375e-02f,
  -3.39351967e-02f, -3.39257598e-01f, -9.25009921e-02f, -8.35450515e-02f, 3.87871265e-02f, 2.43150219e-02f, 5.01476461e-03f, 4.38010022e-02f, 2.36312131e-04f, -9.08423215e-02f,
  -9.28890631e-02f, 1.66744608e-02f, 7.30667077e-03f, -5.54796606e-02f, -9.49878469e-02f, -2.28778571e-02f, -3.52795199e-02f, 3.95143516e-02f, 3.48740667e-02f, -4.45582159e-03f,
  -1.71597376e-02f, -6.80121556e-02f, 1.93547085e-02f, -1.10281937e-01f, -1.06174931e-01f, -1.27854180e-02f, -1.03751615e-01f, 2.76190881e-02f, -1.21588574e-03f, 8.25939234e-03f,
  -1.74107730e-01f, 3.51563841e-01f, 1.10088237e-01f, -3.14609677e-01f, -4.81076501e-02f, -1.76002264e-01f, -1.38524204e-01f, 2.04039738e-01f, 1.01880454e-01f, 1.92156047e-01f,
  -2.68304106e-02f, 2.96157509e-01f, 1.37116402e-01f, -2.72274107e-01f, -4.41836566e-01f, -2.96250552e-01f, -4.12910759e-01f, -1.48815975e-01f, -1.65464535e-01f, -8.39882419e-02f,
  -1.98570445e-01f, -2.22837135e-01f, -1.63334653e-01f, 3.99263948e-02f, 6.21497743e-02f, 2.43632302e-01f, -7.59356171e-02f, 1.84194103e-01f, 5.86376293e-03f, 3.00615560e-02f,
  -3.72998044e-02f, 1.66252196e-01f, 2.36103907e-01f, 6.72889575e-02f, -9.30723082e-03f, 4.82757762e-02f, 8.11827555e-03f, -5.30858873e-04f, -6.93361089e-02f, -7.72871962e-03f,
  6.06751889e-02f, -7.55402213e-03f, 1.26132509e-02f, -4.56476025e-03f, 3.51221971e-02f, 4.28197123e-02f, -7.71329030e-02f, -3.90698053e-02f, 1.30674303e-01f, -2.52457075e-02f,
  -2.94316243e-02f, -1.37183629e-02f, -1.10765904e-01f, -8.16739723e-03f, -3.22441608e-02f, 6.78361431e-02f, -8.04259032e-02f, 5.03071472e-02f, -4.35931608e-02f, -4.95117605e-02f,
  -9.25612077e-02f, -2.05783233e-01f, 1.63299441e-02f, 9.60221365e-02f, -1.83925442e-02f, 8.07361528e-02f, -5.77864237e-02f, 7.22648948e-02f, -4.60794242e-03f, 1.54528196e-03f,
  5.20257354e-02f, 5.92717826e-02f, -4.66726394e-03f, -5.33240996e-02f, -1.30596876e-01f, -2.89556314e-03f, 8.86410847e-03f, 5.69141097e-02f, -1.33556888e-01f, 7.91659206e-02f,
  7.57867172e-02f, -8.68281052e-02f, 9.08079445e-02f, 1.42773837e-02f, 2.34936597e-03f, -1.37016848e-02f, -3.95886935e-02f, 1.52182039e-02f, 4.49009202e-02f, -9.07685831e-02f,
  1.17833782e-02f, -9.02701765e-02f, 6.45208210e-02f, 1.38146430e-01f, 4.41434681e-02f, -5.44819906e-02f, 2.29444318e-02f, 1.89594217e-02f, -7.44167045e-02f, -1.00829870e-01f,
  4.37713936e-02f, -3.98118645e-02f, -5.99822327e-02f, 1.16830254e-02f, -3.40019800e-02f, -2.11033900e-03f, 3.45203504e-02f, 4.16437611e-02f, -1.14745162e-02f, -2.73741279e-02f,
  8.93527642e-02f, -1.42049352e-02f, -1.33860916e-01f, -3.79710905e-02f, -4.83006090e-02f, 2.26618699e-03f, -1.75877325e-02f, 7.15135708e-02f, -6.77016303e-02f, -2.12278403e-02f,
  -2.49593809e-01f, -1.46356076e-01f, -3.10642004e-01f, -1.55313462e-01f, 2.98198815e-02f, -2.25833237e-01f, -2.56560385e-01f, -6.08793497e-02f, 1.02259010e-01f, 2.89380759e-01f,
  6.87762424e-02f, -7.36507177e-02f, 1.56715617e-01f, -3.50817412e-01f, -3.01323980e-01f, 3.43175903e-02f, -3.18207234e-01f, -1.09836780e-01f, 1.64296143e-02f, -1.06472582e-01f,
  -1.14268839e-01f, -1.69256970e-01f, -2.15459406e-01f, 3.05269975e-02f, -2.63020545e-01f, 8.66815373e-02f, 2.25296468e-01f, 4.54693325e-02f, -1.98336750e-01f, -1.25766769e-01f,
  -4.54979017e-02f, 1.13189816e-01f, -6.51863962e-02f, -7.47093093e-03f, 4.00070194e-03f, -6.57418137e-03f, -7.35289827e-02f, -2.79465597e-02f, 4.67639975e-02f, 3.92552800e-02f,
  7.39458650e-02f, 5.52519411e-02f, -3.71804386e-02f, -9.85676870e-02f, -2.48387493e-02f, 4.15696166e-02f, -5.91060854e-02f, -7.35410452e-02f, 7.64970630e-02f, -1.50152236e-01f,
  -1.43614337e-01f, 7.47870430e-02f, -3.70700173e-02f, 1.26026586e-01f, -4.96958569e-02f, -1.36049985e-05f, 3.71071920e-02f, -3.42939980e-02f, 4.52289432e-02f, 1.81523375e-02f,
  -8.88829380e-02f, 9.40290168e-02f, -4.60078008e-02f, -6.28086179e-02f, 2.03778764e-04f, 1.80760082e-02f, -3.43593992e-02f, 2.46267347e-03f, 7.09266290e-02f, 4.60382849e-02f,
  4.20032255e-02f, -1.07380701e-02f, -3.27640492e-03f, -8.17344785e-02f, -6.62450790e-02f, -3.52877975e-02f, -6.59950227e-02f, 6.84978440e-02f, -4.74562347e-02f, -5.75302690e-02f,
  1.27901062e-01f, -6.48238435e-02f, 7.99689516e-02f, 3.22754085e-02f, -2.50619967e-02f, -1.54717942e-03f, 7.02068210e-02f, -7.76911527e-02f, -4.09292616e-02f, 2.68733874e-03f,
  8.63874927e-02f, 1.27807006e-01f, 8.07046518e-02f, 2.35270690e-02f, 7.87613019e-02f, -5.80258220e-02f, -4.32399437e-02f, -9.41439345e-02f, -5.96036809e-03f, -4.70217504e-02f,
  -8.70463029e-02f, -5.57853393e-02f, 1.10614426e-01f, -5.22958338e-02f, 3.05101671e-03f, -1.62284989e-02f, 5.69321960e-02f, 1.32990241e-01f, 5.41595928e-02f, 2.24216785e-02f,
  2.79978886e-02f, 1.43522680e-01f, 3.70674883e-03f, 1.27496272e-01f, 5.23142442e-02f, 6.05417676e-02f, 4.19422146e-03f, -5.26302978e-02f, 1.06729299e-01f, 2.24939957e-02f,
  -3.55615914e-02f, 2.30586845e-02f, -6.86554387e-02f, -8.68739486e-02f, -3.44515055e-01f, 5.30986227e-02f, 2.07959842e-02f, -1.58659786e-01f, 2.28559285e-01f, 8.51217657e-02f,
  -2.06259921e-01f, 2.52344638e-01f, 1.39185444e-01f, -3.11986446e-01f, 2.64976621e-01f, 2.26550356e-01f, 9.37457085e-02f, 1.16825670e-01f, -3.31929438e-02f, 8.58568680e-03f,
  -2.98110694e-02f, -2.24082962e-01f, -2.28350937e-01f, -2.73292184e-01f, -4.68693793e-01f, -1.39877021e-01f, -2.55620211e-01f, -1.39339760e-01f, -3.24057102e-01f, -1.90868840e-01f,
  -2.50232518e-02f, -7.45598823e-02f, -8.64505991e-02f, 8.69721547e-02f, -1.14371076e-01f, 4.25391495e-02f, 2.56377067e-02f, 4.21159808e-03f, -4.72002476e-02f, 4.86950427e-02f,
  1.07372455e-01f, 2.58857347e-02f, 6.19899146e-02f, 3.27065140e-02f, -7.72772953e-02f, -1.15051366e-01f, -4.90192883e-02f, 7.12863542e-03f, 4.82797548e-02f, 1.54968724e-02f,
  -8.65562782e-02f, -1.09140083e-01f, -8.91876314e-03f, 1.05704427e-01f, 8.60910676e-03f, 6.44435808e-02f, 9.48749855e-02f, -1.14839552e-02f, 4.15724143e-02f, 2.29870379e-02f,
  -1.54200876e-02f, 2.40310896e-02f, 3.07034198e-02f, -3.55289504e-02f, -7.59155974e-02f, -1.36587992e-01f, 2.60217115e-03f, -8.86834338e-02f, 3.41794118e-02f, -8.56558681e-02f,
  5.33044152e-02f, -6.06935769e-02f, -3.10647041e-02f, 8.16112384e-02f, 9.48088337e-03f, 2.46812068e-02f, 1.21879391e-01f, -3.87300216e-02f, 7.69031942e-02f, 2.76633557e-02f,
  -7.68440664e-02f, 5.33953346e-02f, -5.18938676e-02f, -2.84365732e-02f, 6.33037277e-03f, 8.05049837e-02f, -7.11660553e-03f, -6.29124790e-02f, -1.06277779e-01f, 8.93997476e-02f,
  -3.36528644e-02f, 2.07831919e-01f, -2.33593001e-03f, 6.96220845e-02f, -2.31979601e-02f, -4.00407836e-02f, 3.72571987e-03f, 1.11793121e-02f, -1.07595825e-03f, 5.34112230e-02f,
  -1.95495542e-02f, 7.95526654e-02f, 1.41563594e-01f, -1.67912096e-02f, 3.37745175e-02f, -3.90378162e-02f, 9.92052406e-02f, 6.16649315e-02f, 3.45582962e-02f, -7.01134801e-02f,
  1.24875149e-02f, 5.21847494e-02f, 1.17869951e-01f, 1.62303597e-02f, 2.10873540e-02f, 2.94599384e-02f, 1.09912746e-01f, 1.11045688e-01f, -2.64765751e-02f, 1.02298222e-01f,
  -2.77312130e-01f, -1.08782411e-01f, -2.58561909e-01f, -2.08718643e-01f, -1.98412046e-01f, -1.87106580e-01f, -2.09293798e-01f, -2.05646649e-01f, -6.70048688e-03f, 1.77761048e-01f,
  -3.60487364e-02f, -8.85015503e-02f, 1.66157871e-01f, -1.53624982e-01f, -2.33527124e-01f, 2.20200360e-01f, -5.06353825e-02f, -7.64060020e-02f, 5.74901178e-02f, -2.39489555e-01f,
  -8.96245912e-02f, -5.18104881e-02f, -1.27536252e-01f, -1.24099553e-01f, -2.67478347e-01f, -6.60283715e-02f, 1.42151892e-01f, -1.54534891e-01f, -1.86261311e-01f, -8.94640461e-02f,
  -2.22385257e-01f, -2.01617077e-01f, -7.52902925e-02f, -7.81473070e-02f, -1.66304484e-01f, 9.31407977e-03f, -5.79696782e-02f, 2.09719483e-02f, -7.71688521e-02f, -7.31064826e-02f,
  1.94685662e-03f, -5.92256784e-02f, -3.17109264e-02f, 1.30929366e-01f, 2.47928803e-03f, -9.63360295e-02f, -1.84428111e-01f, -1.07569188e-01f, -1.56559005e-01f, -7.44601265e-02f,
  -9.28465575e-02f, -8.11365843e-02f, -8.91505480e-02f, 7.94731900e-02f, -4.22222279e-02f, -2.50968505e-02f, 5.86805381e-02f, 4.22130451e-02f, -6.83664754e-02f, -9.64810401e-02f,
  -1.68936758e-03f, 1.36774825e-02f, -5.59564903e-02f, -7.53331743e-03f, -1.09726470e-02f, 9.74811614e-04f, 4.64859940e-02f, 2.89764930e-03f, -2.43818164e-02f, 8.25855881e-03f,
  -2.52042152e-03f, -2.54471097e-02f, 8.12832359e-03f, 6.55009598e-02f, -3.99039825e-03f, 4.87489440e-02f, 2.56383941e-02f, -1.57541677e-01f, 1.49334997e-01f, -3.22433114e-02f,
  -4.43533584e-02f, -6.81929365e-02f, -2.11162083e-02f, -8.21834616e-03f, -5.62070534e-02f, 9.98411700e-02f, -1.14622653e-01f, -1.69098824e-02f, 2.58021727e-02f, -5.51837943e-02f,
  -1.52915284e-01f, -1.83247134e-01f, -3.51696014e-02f, -9.75047424e-02f, 1.61636293e-01f, 6.08134121e-02f, 7.06998110e-02f, -5.17923385e-02f, -3.50342095e-02f, 2.36416180e-02f,
  7.26226531e-03f, 4.96741943e-02f, -2.82286350e-02f, 7.38826320e-02f, 4.50002551e-02f, -2.43856180e-02f, -5.91113903e-02f, 1.29259750e-01f, -6.51402622e-02f, -4.35732352e-03f,
  -7.48373568e-02f, 6.30671531e-02f, 6.81639910e-02f, 5.53292572e-04f, 6.27621412e-02f, -6.73853606e-02f, -5.12759164e-02f, 5.58161102e-02f, -4.29169647e-02f, -1.89301465e-02f,
  6.20907210e-02f, -2.21166477e-01f, 3.81877944e-02f, 3.97645444e-01f, -1.57793224e-01f, -4.97749180e-01f, -4.91250575e-01f, 6.78140074e-02f, 8.46862942e-02f, -3.17828208e-01f,
  -9.10124555e-02f, 9.67063308e-02f, -2.72116244e-01f, 1.22492604e-01f, 3.23439807e-01f, -6.06076457e-02f, 2.25006327e-01f, -7.28899539e-02f, 7.89628476e-02f, 3.89564112e-02f,
  3.19533914e-01f, 2.15562835e-01f, 1.65424228e-01f, 5.69252335e-02f, -1.69221923e-01f, 1.33150429e-01f, 3.14731151e-01f, -1.54526934e-01f, 2.29121134e-01f, -3.78850996e-02f,
  -1.16354734e-01f, 3.99705246e-02f, 3.19639258e-02f, 4.41970266e-02f, 9.78676509e-03f, -1.10691659e-01f, 5.54508111e-03f, -6.64700270e-02f, 1.38395345e-02f, -7.10381344e-02f,
  5.35704102e-03f, 1.47670209e-01f, 5.36377318e-02f, -1.94974914e-02f, -9.87799615e-02f, 1.04239836e-01f, 3.43866870e-02f, 4.15595109e-03f, 5.89595065e-02f, -6.40394613e-02f,
  -5.91717586e-02f, 4.08771858e-02f, 5.62912039e-02f, 3.01496591e-02f, 6.90013468e-02f, 4.65149842e-02f, -9.34282877e-03f, -3.90276648e-02f, -1.22380722e-02f, 9.14655700e-02f,
  -2.35671476e-02f, -7.74794891e-02f, -1.07377835e-01f, -1.68086756e-02f, -3.03185526e-02f, 5.31035587e-02f, -3.18172276e-02f, -2.37249583e-03f, -1.12952339e-02f, -6.05747104e-02f,
  -2.01720539e-02f, 2.54784292e-03f, 5.45808487e-03f, -1.65852979e-01f, -6.79152226e-03f, 1.75287426e-02f, -5.01903356e-04f, -6.16253205e-02f, 2.89515927e-02f, 9.19254348e-02f,
  2.59836018e-02f, 1.38691105e-02f, 2.67358553e-02f, 1.42256059e-02f, -3.12863216e-02f, -4.55827154e-02f, 2.08608992e-02f, 1.05808843e-02f, 2.29204837e-02f, 1.55433509e-02f,
  2.42130905e-02f, 1.30641133e-01f, 2.17214376e-02f, 6.83912262e-02f, 4.02139984e-02f, -2.95554381e-02f, -1.67304941e-03f, 8.15807208e-02f, -1.70663802e-03f, 1.35231446e-02f,
  4.81462069e-02f, -7.40986839e-02f, -4.26870510e-02f, 5.04110828e-02f, 3.53238955e-02f, -1.02100544e-01f, 4.26798202e-02f, 1.51150636e-02f, 5.71888685e-02f, 2.06349447e-01f,
  1.19594354e-02f, -1.92416832e-01f, -3.00067253e-02f, -2.04169601e-02f, 1.82027631e-02f, -2.93167271e-02f, 2.43083690e-03f, 1.56566817e-02f, 1.04876667e-01f, 8.83745328e-02f,
  2.15457454e-01f, 1.69440538e-01f, 1.11405380e-01f, 1.34872466e-01f, -1.86737344e-01f, -3.31795782e-01f, -1.63506806e-01f, 6.87754974e-02f, -1.95722818e-01f, -8.52124318e-02f,
  1.28209651e-01f, -1.26186639e-01f, 2.15097114e-01f, 9.63812098e-02f, 1.43849552e-01f, 5.40373698e-02f, 9.28228498e-02f, -2.48077810e-02f, -1.49224671e-02f, 2.89896131e-01f,
  1.45792082e-01f, 1.87607989e-01f, 3.14682633e-01f, 1.53842673e-01f, 8.25456977e-02f, 1.79067001e-01f, 2.20591560e-01f, 1.49157912e-01f, 9.48344171e-02f, -1.78482443e-01f,
  -3.36653553e-02f, 1.12820096e-01f, -2.75838713e-04f, -1.07208103e-01f, 1.93005756e-01f, 1.22135729e-01f, 5.54139819e-03f, 1.88694634e-02f, -3.90697196e-02f, -2.74076667e-02f,
  -2.32840031e-02f, -1.03754804e-01f, -2.72236802e-02f, -7.66989440e-02f, -1.39989331e-01f, -4.52131815e-02f, -1.15341388e-01f, -5.82022071e-02f, -7.48151913e-02f, 3.59863862e-02f,
  1.88831612e-03f, -2.50849184e-02f, 3.44762057e-02f, -3.27305086e-02f, -2.50069704e-02f, -1.48689188e-02f, -7.61629269e-02f, -3.84973101e-02f, -2.50549186e-02f, -1.49140973e-02f,
  1.06676869e-01f, -2.63674371e-02f, -3.41848955e-02f, -1.28361331e-02f, -7.41794482e-02f, 6.55706897e-02f, -8.72645304e-02f, -4.87542264e-02f, 5.96180838e-03f, -3.49838063e-02f,
  2.18774918e-02f, 1.66425779e-02f, 6.45997450e-02f, -3.98922525e-02f, 1.61768198e-02f, 3.31275128e-02f, -8.09213519e-02f, 2.70102713e-02f, -2.17462163e-02f, -9.57894921e-02f,
  -2.88581625e-02f, -1.08842691e-02f, -4.45316806e-02f, 1.95507915e-03f, -5.55204190e-02f, 3.87121513e-02f, 6.36424050e-02f, 1.02186397e-01f, 3.74889113e-02f, -1.70362964e-02f,
  8.44206735e-02f, 2.36277148e-01f, 7.62551352e-02f, -1.51628807e-01f, -6.28962964e-02f, 4.86432686e-02f, 1.07312836e-01f, -4.14170846e-02f, 3.64024751e-02f, 1.49769783e-02f,
  6.97504580e-02f, -3.79562974e-02f, 1.00308023e-02f, 4.29766327e-02f, 1.91106908e-02f, -4.81746569e-02f, 2.21872535e-02f, -1.85676273e-02f, 5.14704622e-02f, 4.43613008e-02f,
  1.04782023e-01f, -3.93537581e-02f, 8.73749405e-02f, -8.14387649e-02f, -5.97491413e-02f, 4.86521162e-02f, 1.60614084e-02f, 2.37268750e-02f, 1.21223003e-01f, -2.85921805e-02f,
  -1.40263677e-01f, 6.80034086e-02f, -2.89023548e-01f, 2.14808032e-01f, -1.12786770e-01f, -9.56684574e-02f, 1.11162186e-01f, 1.33950636e-01f, -1.68830574e-01f, 1.66114256e-01f,
  3.76964837e-01f, -1.02380916e-01f, 2.53447592e-01f, 4.26426500e-01f, 4.61058766e-02f, 3.10993344e-01f, 2.55704969e-01f, 9.13592950e-02f, -1.42970150e-02f, 1.45758644e-01f,
  5.38592115e-02f, 2.72726774e-01f, 2.80421764e-01f, -5.81118185e-03f, 1.84973016e-01f, -3.89501415e-02f, 2.34545380e-01f, -9.27399173e-02f, 2.23517030e-01f, -1.07049525e-01f,
  1.23763055e-01f, 1.17574364e-01f, -4.25381139e-02f, -1.26839563e-01f, -2.66626794e-02f, 1.30920485e-02f, -1.19233675e-01f, -3.48434187e-02f, -1.92956813e-02f, 9.79912207e-02f,
  2.41613649e-02f, -3.78178246e-02f, -9.27107558e-02f, -3.13542485e-02f, -1.06784403e-02f, -9.28164348e-02f, 2.48339400e-02f, 5.78662641e-02f, -8.58689006e-03f, 7.22623989e-02f,
  7.02049304e-03f, -3.48217897e-02f, 2.64868457e-02f, 6.90981299e-02f, 1.55792218e-02f, -2.08156724e-02f, -3.23710367e-02f, -4.63136807e-02f, -3.65104526e-02f, -4.42543142e-02f,
  1.74398124e-02f, -2.96287667e-02f, 1.25681669e-01f, -9.60530117e-02f, 4.22058627e-03f, 2.74564791e-02f, 3.40636186e-02f, 5.59024140e-02f, -6.74729422e-02f, 8.25109035e-02f,
  1.37015535e-02f, 8.59389082e-02f, 6.50932342e-02f, 4.26730048e-03f, 8.46401326e-06f, -5.80754802e-02f, -2.05394644e-02f, -7.90092424e-02f, 8.11824724e-02f, 1.70154143e-02f,
  2.45666374e-02f, -5.89313544e-02f, 4.07311991e-02f, 1.18029490e-02f, -2.13847291e-02f, 6.38799891e-02f, 5.97217679e-02f, 3.99322174e-02f, -1.90842506e-02f, -5.17820455e-02f,
  9.52926055e-02f, 6.64253905e-02f, 1.54066980e-02f, -9.94848758e-02f, 1.23689240e-02f, 5.95244318e-02f, -2.67330594e-02f, -1.14396568e-02f, 2.78582089e-02f, -1.04830094e-01f,
  -5.77232540e-02f, -1.08603068e-01f, 3.60681079e-02f, -1.75646357e-02f, -9.26957801e-02f, 1.37739435e-01f, 3.89112085e-02f, -9.14622471e-02f, 9.98963192e-02f, 6.97655529e-02f,
  3.08378432e-02f, -9.18167084e-02f, -6.07356913e-02f, -2.22610757e-02f, -4.70271744e-02f, 6.46501333e-02f, 5.01611270e-02f, 2.45288275e-02f, 7.31951445e-02f, -4.18432951e-02f,
  -4.04246487e-02f, -5.77822328e-02f, 1.16952926e-01f, 3.09572130e-01f, 2.95863923e-04f, -2.91621596e-01f, -2.61478394e-01f, -2.35887736e-01f, 7.31765479e-02f, -3.14465106e-01f,
  -2.79305726e-01f, 3.11739385e-01f, -3.75974953e-01f, 3.58108342e-01f, 2.91487843e-01f, 2.40902626e-03f, 8.66967663e-02f, 8.18711519e-02f, 1.27714649e-01f, -9.69570801e-02f,
  1.57297686e-01f, 2.88913399e-02f, 3.27688903e-01f, 7.32557476e-02f, -5.56365470e-04f, 4.24421906e-01f, 4.31281656e-01f, 2.79265881e-01f, 3.87356013e-01f, 3.25408190e-01f,
  -1.24026082e-01f, -5.57633117e-02f, -1.01739340e-01f, 9.85478386e-02f, -5.33348694e-02f, -1.04638517e-01f, 1.17829986e-01f, 1.30202189e-01f, 1.67616792e-02f, 2.25718003e-02f,
  -7.30393305e-02f, 4.73734289e-02f, 1.39539137e-01f, -3.98625843e-02f, 3.39559317e-02f, 1.35487437e-01f, 1.30446777e-01f, -1.39390126e-01f, -3.12679373e-02f, -6.23710491e-02f,
  -1.76342148e-02f, 2.65401439e-03f, -9.79892239e-02f, 1.56281233e-01f, 1.01583809e-01f, -5.32000959e-02f, 7.83234090e-02f, 1.43663883e-01f, 6.33829385e-02f, -7.95918424e-03f,
  -1.11012191e-01f, 8.67000148e-02f, 8.62587243e-02f, 5.46431988e-02f, 1.71756633e-02f, 5.42126000e-02f, 2.19005942e-02f, 2.18687933e-02f, 1.87911227e-01f, 1.31718684e-02f,
  1.56275257e-02f, -4.93164314e-03f, 5.66350184e-02f, -7.95982927e-02f, -1.00177675e-02f, -1.28882289e-01f, 2.17692666e-02f, 6.55485615e-02f, -1.13559663e-02f, 3.33402269e-02f,
  6.66815937e-02f, 7.76620209e-02f, -5.90513460e-02f, -5.36032068e-03f, -6.46018907e-02f, -2.10607033e-02f, 3.19670304e-03f, -1.60922669e-02f, 1.60198156e-02f, -3.05316504e-02f,
  -1.01270087e-01f, 3.02737832e-01f, 6.54397719e-03f, -7.75034577e-02f, 3.08402535e-02f, -4.05225120e-02f, 9.20947418e-02f, 2.27907463e-03f, 8.79963487e-02f, -4.05071080e-02f,
  -8.89944732e-02f, -2.44591050e-02f, -6.95122546e-03f, -1.60985522e-03f, 9.55531839e-03f, -1.21256635e-01f, 4.04011309e-02f, 1.03061423e-01f, 8.04921687e-02f, -3.63885723e-02f,
  -6.74856603e-02f, -9.99684911e-03f, -9.23216622e-03f, 2.86242496e-02f, -7.51050785e-02f, 5.76789044e-02f, -5.64546026e-02f, 9.83711258e-02f, 1.13945410e-01f, -6.95059150e-02f,
  -2.99851801e-02f, -2.30454584e-03f, 2.80228168e-01f, -2.28871822e-01f, 3.46138299e-01f, 1.37489334e-01f, -2.53602266e-01f, 3.04620087e-01f, 1.18719235e-01f, -2.00334847e-01f,
  -1.31559789e-01f, -2.56956309e-01f, -2.16859356e-02f, -1.50880307e-01f, 1.63480118e-01f, 1.90087557e-01f, -3.51203270e-02f, -2.33844668e-01f, 1.75821483e-01f, -1.72984943e-01f,
  6.01177067e-02f, -1.69469133e-01f, 1.49359688e-01f, 1.62724644e-01f, -2.56192014e-02f, 3.19634899e-02f, -1.49330944e-01f, 6.45967647e-02f, 3.02593992e-03f, 1.44317970e-01f,
  -1.58827782e-01f, -2.12491959e-01f, -7.01074302e-02f, -4.61197412e-03f, 4.26779799e-02f, 3.94334039e-03f, -1.42543420e-01f, -6.02137521e-02f, -5.53920679e-02f, 4.94285114e-02f,
  -1.26729354e-01f, 2.87623499e-02f, 4.68040518e-02f, 4.74269241e-02f, -5.73139777e-03f, 2.66740452e-02f, 1.10913560e-01f, 7.28037506e-02f, -1.07142422e-02f, 1.82770222e-01f,
  2.11984053e-01f, 1.52492926e-01f, -4.14020419e-02f, -5.19600324e-02f, 2.40994506e-02f, 1.60678178e-02f, -2.30558347e-02f, 1.82714704e-02f, 9.82263759e-02f, 2.63409186e-02f,
  1.05017908e-01f, 1.09561749e-01f, 6.91920519e-04f, -3.60355526e-02f, 8.32043588e-03f, 2.35580467e-02f, -9.19620972e-03f, -3.75819132e-02f, 8.77651572e-03f, -4.50424058e-03f,
  -9.81209949e-02f, -2.37181038e-02f, 9.37433168e-03f, -6.79113418e-02f, -1.34562433e-01f, -1.52944599e-03f, -1.11637443e-01f, -4.42124233e-02f, 3.47948819e-02f, 1.11258971e-02f,
  -3.35921475e-04f, -8.82366821e-02f, 1.21984787e-01f, 1.92340259e-02f, -4.34071571e-02f, -9.46803950e-03f, -6.44450560e-02f, 3.93870510e-02f, 1.30910408e-02f, -1.11165913e-02f,
  -5.12149334e-01f, -3.02646160e-01f, -1.84577376e-01f, -1.25075221e-01f, -1.92915440e-01f, 2.57854108e-02f, -1.54328449e-02f, 3.24917361e-02f, -6.88861161e-02f, 2.06445716e-02f,
  4.79155853e-02f, -7.15883374e-02f, -6.13721907e-02f, 4.69153635e-02f, -4.85009849e-02f, 4.28566188e-02f, -1.38524443e-01f, -1.32463098e-01f, -1.89424381e-01f, -1.58893596e-02f,
  -8.85369852e-02f, -1.14957102e-01f, 5.29660285e-02f, 7.19029680e-02f, -8.29052937e-04f, -4.82215844e-02f, 4.56368886e-02f, 3.71392369e-02f, 6.47031367e-02f, 8.10408816e-02f,
  3.07612538e-01f, 4.19739373e-02f, -7.72360712e-02f, -4.80586430e-03f, -1.22688502e-01f, 1.16093941e-01f, -1.19250789e-01f, -4.59995642e-02f, -8.04642737e-02f, 4.03424203e-02f,
  1.16878986e-01f, 1.08436905e-01f, -3.03015023e-01f, 3.83986473e-01f, 3.09963316e-01f, -1.08142003e-01f, 2.92134434e-01f, 1.80026546e-01f, 4.06191610e-02f, 1.09374739e-01f,
  7.61514083e-02f, 3.01371366e-01f, -2.76251999e-03f, 3.25015634e-01f, 3.42865795e-01f, -1.10173039e-02f, -2.76198555e-02f, -1.59457490e-01f, 3.33150148e-01f, 1.54210299e-01f,
  8.49171653e-02f, 5.23702726e-02f, 8.52232575e-02f, 4.76254225e-02f, 9.67471686e-04f, -1.90950725e-02f, 3.49290259e-02f, 1.62645411e-02f, -3.99272256e-02f, -4.15793546e-02f,
  5.91340177e-02f, 1.25914410e-01f, 1.30741343e-01f, -6.06598109e-02f, 1.28157511e-01f, 7.00937137e-02f, -2.28881985e-02f, -2.01636180e-02f, -1.15835540e-01f, 7.25264251e-02f,
  -2.71349661e-02f, 9.34335217e-03f, -1.16226718e-01f, 1.30871916e-02f, -8.72033611e-02f, -2.06071176e-02f, -3.24791782e-02f, 1.60228256e-02f, 8.56176466e-02f, 1.14138417e-01f,
  4.62378636e-02f, -7.03256652e-02f, 4.80747186e-02f, 5.21875322e-02f, 4.08113785e-02f, 1.51986545e-02f, -2.59027742e-02f, -6.26599863e-02f, -2.55901250e-03f, -4.88237254e-02f,
  8.70940760e-02f, -2.24483069e-02f, -6.06833957e-03f, 4.72157188e-02f, 1.04519613e-01f, 3.21874097e-02f, -8.39107931e-02f, 5.29367663e-02f, -1.01131313e-01f, 3.51479137e-03f,
  2.72613168e-02f, 2.39920970e-02f, 4.74626273e-02f, -8.91303718e-02f, 8.11757229e-04f, -9.05478969e-02f, 1.26694337e-01f, 2.10366249e-02f, -1.84424549e-01f, -3.06614470e-02f,
  8.09186399e-02f, 1.11562602e-01f, -3.18004340e-02f, -3.14354636e-02f, -1.19558740e-02f, 1.52098924e-01f, 7.77396038e-02f, 9.95311961e-02f, 3.49095166e-02f, 6.69528693e-02f,
  2.79205199e-02f, -1.07792877e-01f, -8.70265886e-02f, 3.78965214e-02f, -4.29166406e-02f, 3.63125317e-02f, -4.13285792e-02f, 8.80706310e-03f, 2.14744695e-02f, 7.78007433e-02f,
  1.07665295e-02f, -7.54967928e-02f, 6.60966933e-02f, -5.21815345e-02f, -2.35021394e-03f, -4.69099432e-02f, 8.77660059e-04f, -9.46179405e-02f, -4.06247517e-03f, -5.36546670e-02f,
  3.78447697e-02f, -4.14078772e-01f, -1.66115493e-01f, -1.18110716e-01f, 5.46431392e-02f, 2.60831326e-01f, 2.36284301e-01f, -2.72553772e-01f, -2.21102819e-01f, -1.45074740e-01f,
  1.20373286e-01f, 3.08141351e-01f, -1.31537423e-01f, 2.18846679e-01f, 4.52433050e-01f, 9.61720794e-02f, 2.15551071e-02f, 9.62954238e-02f, -2.12912917e-01f, -1.37362182e-01f,
  -7.58132935e-02f, 1.71251938e-01f, 9.52278525e-02f, -7.39679262e-02f, 7.93523714e-02f, -6.78020567e-02f, 2.03799546e-01f, 1.21288031e-01f, 1.97900340e-01f, 2.99856037e-01f,
  -1.66345507e-01f, -2.94347763e-01f, -4.38484251e-02f, -2.49799574e-04f, -9.90325771e-03f, -3.63638848e-02f, 4.39592525e-02f, 1.49276361e-01f, 7.83385932e-02f, -7.40833208e-02f,
  4.58546355e-02f, 3.64601682e-03f, 2.01882441e-02f, 3.53584178e-02f, -6.51134327e-02f, -1.10549994e-01f, -5.64032495e-02f, -3.33695114e-03f, -1.47773698e-01f, -4.27928418e-02f,
  -1.14871457e-01f, -1.56403616e-01f, -1.03753075e-01f, -1.61652528e-02f, 4.04522680e-02f, -3.11967991e-02f, 1.40442662e-02f, -8.15042586e-04f, 4.36094254e-02f, -5.19782566e-02f,
  1.18786857e-01f, -2.62274481e-02f, -6.22935146e-02f, 2.18108520e-02f, -2.63967197e-02f, 4.71251644e-03f, 4.37164726e-03f, 9.03237909e-02f, 2.78117359e-02f, 1.12361191e-02f,
  -2.28018370e-02f, 2.01858394e-02f, -1.09196089e-01f, -2.78354194e-02f, -2.88835708e-02f, -3.76320966e-02f, -2.28159390e-02f, 4.89824340e-02f, -7.02175498e-02f, -4.34981361e-02f,
  3.47675756e-02f, -1.80225484e-02f, 1.18293114e-01f, -5.70227578e-02f, 7.66366860e-03f, 1.36235163e-01f, -7.56346881e-02f, -4.23449539e-02f, -2.46508177e-02f, 5.20516410e-02f,
  -3.07477236e-01f, -2.48766467e-01f, -1.27939591e-02f, -1.32371401e-02f, 4.81360629e-02f, -9.58998054e-02f, 6.06429502e-02f, -1.98673531e-02f, 5.45910262e-02f, -1.09067962e-01f,
  -4.80587743e-02f, 1.23817567e-03f, 1.31252557e-02f, 1.17194988e-01f, 1.83869377e-01f, -5.89025542e-02f, -1.13792261e-02f, 3.45520936e-02f, 2.92204916e-02f, -2.71954220e-02f,
  -1.99887622e-02f, -3.01550981e-02f, 1.78707436e-01f, -1.10229813e-01f, 1.22273445e-01f, -1.40657732e-02f, -6.96191341e-02f, 2.10188353e-03f, -8.20470378e-02f, 4.12559658e-02f,
  -2.04821602e-01f, 4.02302563e-01f, 2.56718665e-01f, 5.62872626e-02f, -2.30568293e-02f, -3.36676806e-01f, -1.14350580e-01f, 4.06051613e-02f, -3.28802988e-02f, 1.78840250e-01f,
  -2.19594851e-01f, 2.57539749e-01f, -8.02058727e-02f, 2.48660177e-01f, -3.68806869e-01f, -1.74916536e-01f, 3.09654046e-02f, -2.77190376e-02f, 6.01548664e-02f, 1.02407053e-01f,
  -1.24339163e-02f, -2.78141260e-01f, -1.65438261e-02f, 2.56058127e-02f, -1.56024536e-02f, 2.01743469e-01f, -8.87320191e-02f, 1.07894160e-01f, 1.13486916e-01f, 5.00291493e-03f,
  -3.01484056e-02f, 8.81776735e-02f, 7.83866420e-02f, 1.47288898e-02f, -1.48645818e-01f, 2.92405981e-04f, -1.11533031e-02f, -2.10800748e-02f, -1.33645711e-02f, 4.15857658e-02f,
  2.59825084e-02f, -4.24319915e-02f, -8.92900024e-03f, -1.53764337e-02f, 1.17771409e-01f, 4.47312854e-02f, 6.79273382e-02f, 9.05814692e-02f, 6.65091276e-02f, 1.89749058e-02f,
  1.07638307e-01f, 2.48273406e-02f, 6.10703640e-02f, 5.65288868e-03f, 6.72997758e-02f, 2.32490152e-02f, -3.27924900e-02f, 1.44219538e-02f, 4.32825163e-02f, 4.50957343e-02f,
  -1.65529060e-03f, -1.03493780e-01f, 4.76832464e-02f, -1.14313001e-02f, 3.00586037e-02f, 1.68292376e-03f, 2.73218658e-02f, -7.66568705e-02f, 9.70329866e-02f, -5.29897027e-03f,
  -3.09537463e-02f, 3.51391509e-02f, -5.94389578e-03f, 9.33807809e-03f, 1.35127688e-02f, 8.23618919e-02f, 2.12431811e-02f, -5.60565218e-02f, 4.81547154e-02f, -9.56538394e-02f,
  6.49208203e-03f, 2.36006416e-02f, -3.63998057e-04f, 9.68695991e-03f, -6.62979484e-02f, -1.33125093e-02f, 8.38128012e-03f, -1.76403131e-02f, -1.19948564e-02f, -4.94042784e-03f,
  3.03078406e-02f, 1.48162991e-01f, 1.30384704e-02f, -1.79445762e-02f, -4.05895375e-02f, 3.31212841e-02f, -1.64463196e-03f, 4.54233475e-02f, -3.09517365e-02f, 3.13084610e-02f,
  -6.50316477e-02f, 1.24556078e-02f, 2.06581149e-02f, -1.01726428e-02f, -2.12456845e-02f, -9.69028398e-02f, 2.79060025e-02f, -6.68689907e-02f, 8.65902677e-02f, 4.15665098e-02f,
  1.19109355e-01f, -1.30932063e-01f, 4.81233522e-02f, -1.49294110e-02f, 2.59130690e-02f, 3.29955705e-02f, 1.13818944e-02f, 1.27058446e-01f, -2.33978238e-02f, -2.15218421e-02f,
  -3.45751971e-01f, 1.36658559e-02f, -9.98708606e-02f, -1.75759137e-01f, 1.53573871e-01f, -4.19988692e-01f, -2.47324631e-01f, -7.47967660e-02f, 6.41213059e-02f, 2.06227396e-02f,
  -5.05341403e-03f, 1.68781817e-01f, 3.26419115e-01f, -1.04228757e-01f, -1.55213803e-01f, 1.87874928e-01f, -4.57027853e-01f, -2.54296303e-01f, 1.19287260e-01f, -1.29620731e-01f,
  -9.37471166e-02f, -2.97499597e-02f, -1.90871105e-01f, 1.55354500e-01f, -2.02364162e-01f, -6.65609539e-02f, -1.11771738e-02f, 1.98707670e-01f, -3.14483821e-01f, 1.53388172e-01f,
  -8.78076851e-02f, 1.61654457e-01f, -7.41077662e-02f, 6.61874637e-02f, -2.57556498e-01f, -9.72497016e-02f, -1.62841260e-01f, 7.47507811e-02f, 6.07371889e-02f, -1.59178488e-02f,
  -2.80853789e-02f, 1.88072771e-02f, -5.32212518e-02f, 1.56279817e-01f, 4.74385545e-02f, 8.89782980e-02f, 1.93087608e-02f, -9.02869180e-02f, 6.34869412e-02f, 5.37439734e-02f,
  6.22151904e-02f, -1.10743731e-01f, -2.94204652e-02f, -1.07574180e-01f, -3.86619382e-02f, 2.93959249e-02f, -1.06542863e-01f, 2.32516490e-02f, -4.17258739e-02f, -8.62371773e-02f,
  3.93124893e-02f, -8.41140896e-02f, 1.63095798e-02f, 5.76219009e-03f, 6.56390237e-03f, -1.22548537e-02f, 9.90708475e-04f, 5.94522245e-02f, 3.93189788e-02f, -2.48420220e-02f,
  -7.67453462e-02f, 7.94033781e-02f, 8.29879269e-02f, -9.87203419e-02f, -1.25083297e-01f, 3.64407003e-02f, 1.43824266e-02f, -1.51641220e-02f, -1.26240760e-01f, -7.13332817e-02f,
  6.42897710e-02f, 2.09878776e-02f, -4.44358028e-02f, 3.58048454e-03f, 6.82968795e-02f, 7.64716715e-02f, 1.45699736e-02f, -2.89757028e-02f, 5.39795086e-02f, -1.93680935e-02f,
  -3.96130681e-01f, -4.85719405e-02f, 1.09742261e-01f, 1.04824789e-01f, -6.70021772e-02f, 1.99820288e-02f, -7.52970055e-02f, -3.98001596e-02f, -8.33863616e-02f, 2.32085623e-02f,
  -9.59144011e-02f, -3.06344628e-02f, -1.73925832e-01f, -1.22655984e-02f, -9.07950327e-02f, -1.58445626e-01f, 2.03136373e-02f, -3.43784541e-02f, -1.11171037e-01f, -6.85989037e-02f,
  -8.80129592e-05f, 2.22149622e-02f, 2.09112149e-02f, -6.36718795e-02f, -4.70522158e-02f, -4.49216999e-02f, -4.03077938e-02f, -2.36998983e-02f, -6.62954003e-02f, -1.00176603e-01f,
  -6.36544108e-01f, 2.12815151e-01f, 3.79247665e-02f, -2.06996184e-02f, -1.77366048e-01f, -1.52645916e-01f, 1.79401532e-01f, -2.56919146e-01f, -4.57384400e-02f, 2.04566017e-01f,
  2.06361830e-01f, -1.84134960e-01f, 2.04529732e-01f, 2.13707849e-01f, -5.23523629e-01f, 1.95770308e-01f, 6.32293895e-02f, 1.68308154e-01f, -5.46553135e-02f, -6.20351359e-02f,
  -7.64956325e-02f, 5.82711361e-02f, 1.04883187e-01f, 8.78831670e-02f, -9.50771570e-03f, -5.76990210e-02f, 7.88224787e-02f, -7.04802722e-02f, 8.40693265e-02f, -1.02209337e-01f,
  -2.98197657e-01f, -5.72143421e-02f, -2.92658731e-02f, 4.63222042e-02f, -6.79074302e-02f, -2.02628449e-02f, -1.22950515e-02f, 2.08368711e-02f, -4.55875546e-02f, -1.25063032e-01f,
  -8.07932690e-02f, 2.39513423e-02f, -6.90582618e-02f, 1.71792489e-02f, -1.08074844e-01f, -5.57423234e-02f, -7.65274838e-02f, 8.11594725e-02f, 6.44514635e-02f, -1.45989684e-02f,
  1.21478304e-01f, 1.30304657e-02f, 6.75058886e-02f, 1.66564330e-01f, -5.27520664e-02f, 7.79318139e-02f, 1.36769176e-01f, -9.75956768e-03f, 4.64381389e-02f, -6.71988726e-02f,
  1.41808279e-02f, -3.49837877e-02f, 1.98670682e-02f, -2.04594061e-02f, 8.52312669e-02f, 7.36622810e-02f, -2.67315954e-02f, 3.27129178e-02f, 3.54542509e-02f, -2.39456166e-02f,
  -7.32480809e-02f, -3.49401608e-02f, -1.02480398e-02f, -1.96200684e-02f, 4.23003174e-02f, -1.73077025e-02f, 1.42890243e-02f, -1.90436691e-02f, -1.58484392e-02f, -2.92558852e-03f,
  -2.73344629e-02f, -8.26463178e-02f, 7.51212761e-02f, 4.13874574e-02f, -6.89245611e-02f, -1.37053147e-01f, 5.46825379e-02f, 4.37218919e-02f, -4.29462232e-02f, -1.12425439e-01f,
  -5.19048572e-01f, -3.66845280e-01f, 9.75519493e-02f, -9.97350514e-02f, -1.49032725e-02f, 1.14092196e-03f, 1.19856698e-02f, -8.08428973e-02f, -7.48491511e-02f, -1.15622431e-01f,
  1.17413774e-02f, -5.45783015e-03f, -7.52485404e-03f, -4.11326289e-02f, 5.40360846e-02f, 3.26114632e-02f, -6.81027770e-02f, -1.05903156e-01f, -1.27592683e-01f, -2.97353584e-02f,
  2.72710230e-02f, -3.78047973e-02f, 7.87545741e-03f, 7.62020946e-02f, 3.71560007e-02f, 1.22808956e-03f, -7.03916177e-02f, 4.86584753e-02f, -6.62833974e-02f, 5.31002954e-02f,
  9.00432914e-02f, -3.83292377e-01f, -2.52876520e-01f, -2.57119775e-01f, 4.05673794e-02f, -1.72826484e-01f, -2.21872002e-01f, -2.52323300e-01f, -2.33517826e-01f, -7.72123858e-02f,
  -6.85197860e-02f, -6.74932823e-02f, 1.26463071e-01f, -3.37153047e-01f, -6.03190437e-02f, -1.40996054e-01f, -1.93355635e-01f, -1.31123409e-01f, -1.03387162e-01f, -8.57373029e-02f,
  -6.39473870e-02f, -2.49653518e-01f, -2.13361651e-01f, -1.54393017e-01f, -1.67601183e-01f, -3.40379402e-02f, 2.40683332e-01f, 1.29943833e-01f, -1.83738116e-02f, -5.47034740e-02f,
  -4.28518541e-02f, -1.65692851e-01f, -1.10407807e-02f, -7.36419037e-02f, -2.15276871e-02f, 6.66315034e-02f, 1.21541232e-01f, 1.06370166e-01f, 1.86608713e-02f, -5.69913760e-02f,
  1.20542437e-01f, 3.70445102e-02f, -1.73932686e-01f, 7.79960528e-02f, -2.90833637e-02f, -1.17314182e-01f, -1.46876574e-02f, 8.54780376e-02f, -2.87283361e-02f, 3.03553101e-02f,
  -8.26532394e-02f, 6.74778447e-02f, -2.43566222e-02f, -6.01037443e-02f, -7.42339715e-02f, -3.80532667e-02f, 2.43875757e-02f, 9.57802832e-02f, 2.57361550e-02f, 6.76386431e-02f,
  -6.80566998e-03f, 8.69490728e-02f, -9.38659012e-02f, -7.28726164e-02f, -1.57359783e-02f, -1.16642537e-02f, 1.71923712e-02f, 2.23667324e-02f, -7.44540021e-02f, 2.94757932e-02f,
  -1.21308491e-02f, 1.99700221e-02f, 1.08094789e-01f, -8.15214217e-02f, 7.21642151e-02f, 1.17288576e-02f, 6.84967563e-02f, -5.58969229e-02f, -7.40439668e-02f, -6.60041496e-02f,
  8.83287638e-02f, 2.80066933e-02f, -1.45784924e-02f, 1.14442192e-01f, -1.11616589e-02f, -9.29194912e-02f, 3.14386562e-02f, 4.64006476e-02f, -1.13837346e-01f, 1.10419981e-01f,
  4.74414006e-02f, -9.74562392e-02f, -1.54598430e-01f, -1.11176915e-01f, -1.14345131e-02f, 1.37839213e-01f, -2.84438841e-02f, -1.00788407e-01f, 1.01523353e-02f, 1.01690199e-02f,
  8.60163346e-02f, 4.14361348e-05f, 1.46851838e-01f, -1.53566366e-02f, 2.23835073e-02f, -3.79309766e-02f, 1.01637736e-01f, 1.60513312e-01f, 4.37561385e-02f, 3.26327011e-02f,
  -2.45071221e-02f, -4.80633415e-02f, 5.58302291e-02f, -4.35912162e-02f, -8.69641677e-02f, 7.85702616e-02f, -3.01095415e-02f, 1.20306745e-01f, 5.05362824e-02f, 6.46529943e-02f,
  -2.57720143e-01f, 4.53728475e-02f, 1.86157703e-01f, 7.56018385e-02f, -4.19150367e-02f, -1.93847001e-01f, -1.94083065e-01f, 1.87777027e-01f, -2.33093083e-01f, -2.22466979e-02f,
  1.15350865e-01f, -1.40243858e-01f, 1.45115510e-01f, -2.76038945e-01f, -1.84405535e-01f, -1.88816890e-01f, -1.52899474e-01f, -1.22062273e-01f, -1.31562734e-02f, 2.55046368e-01f,
  7.11074769e-02f, -4.84414399e-02f, 1.66840434e-01f, 2.14137286e-01f, -1.49030378e-02f, 2.73505151e-01f, 3.66351843e-01f, 1.89148501e-01f, 1.15473993e-01f, -9.04939100e-02f,
  -1.10654503e-01f, 3.63305509e-02f, 8.53969716e-03f, -1.38582096e-01f, 1.61812261e-01f, 5.01696318e-02f, -4.65538800e-02f, -7.13187605e-02f, -7.35743269e-02f, -6.26976639e-02f,
  -8.97837356e-02f, 1.38548138e-02f, 7.41463006e-02f, -2.44590845e-02f, -1.00571334e-01f, -2.54053324e-02f, -6.23530820e-02f, -2.21973751e-02f, -1.88510753e-02f, -3.08596119e-02f,
  4.48769927e-02f, -7.02464879e-02f, -6.77452609e-02f, -7.72771658e-03f, 1.19971581e-01f, -5.22609577e-02f, 2.39542010e-03f, 1.84788212e-01f, -9.48669463e-02f, 1.02030091e-01f,
  6.32208884e-02f, -2.58953162e-02f, 7.48970825e-03f, -6.76283985e-02f, 4.69645113e-02f, 2.75147259e-02f, -1.27334133e-01f, -3.82084325e-02f, 5.43778799e-02f, -1.11217061e-02f,
  -2.23586056e-02f, 3.21018323e-02f, -1.62084386e-01f, 1.65108610e-02f, -3.15653346e-02f, -9.44650546e-02f, -3.08366809e-02f, -1.16284909e-02f, 1.45219371e-01f, -9.36057419e-03f,
  -1.28610015e-01f, 3.03321779e-02f, -3.05181593e-02f, -8.43855441e-02f, -1.21950120e-01f, 1.51134193e-01f, 4.76161586e-05f, 2.58864984e-02f, 7.33864531e-02f, -3.63757648e-02f,
  1.07816152e-01f, 3.23947489e-01f, 2.32472811e-02f, -1.47715226e-01f, 1.91792063e-02f, -8.30770731e-02f, -2.12733939e-01f, 3.47897895e-02f, 3.76042053e-02f, 1.09801926e-01f,
  1.13555439e-01f, 1.56107200e-02f, -2.76485905e-02f, -1.04938082e-01f, 5.49305454e-02f, 1.30011991e-01f, 6.26615807e-02f, -3.60488370e-02f, -3.66749018e-02f, 1.64440289e-01f,
  2.79733896e-01f, 5.08269258e-02f, -1.34469002e-01f, 2.46682726e-02f, 6.08906671e-02f, 5.04861884e-02f, 6.51820228e-02f, 9.92288720e-03f, -1.92516744e-02f, -4.98543233e-02f,
  -2.34256834e-01f, -7.99838826e-02f, -3.44209373e-01f, -2.02427179e-01f, 1.56522378e-01f, 1.62208065e-01f, 1.27042523e-02f, 2.23933123e-02f, -2.44354472e-01f, 2.67182022e-01f,
  4.27729562e-02f, -3.91414791e-01f, -1.46176979e-01f, -6.72627240e-02f, -3.07069302e-01f, -2.22063676e-01f, 5.43538183e-02f, -2.08514221e-02f, -2.81830817e-01f, -1.40530933e-02f,
  -1.81875825e-01f, 2.27531344e-01f, -2.91308820e-01f, 1.47801816e-01f, 1.81232944e-01f, 1.50748625e-01f, 3.63898128e-01f, -2.75148526e-02f, 2.39212528e-01f, -5.87201826e-02f,
  -7.04005361e-02f, -2.29380801e-01f, -9.89828929e-02f, -1.34394363e-01f, 9.06566624e-03f, 1.30085722e-01f, 1.74277142e-01f, -9.90756154e-02f, -6.24785759e-02f, -9.79309157e-02f,
  7.43515044e-02f, -1.45643204e-02f, -2.44066548e-02f, -7.61790574e-02f, 3.92887183e-02f, -1.49316108e-02f, -2.44908724e-02f, 1.06735742e-02f, -6.93204328e-02f, -9.33765098e-02f,
  -1.15684770e-01f, 1.29956782e-01f, 1.48521766e-01f, -1.63444448e-02f, -1.32804424e-01f, -1.26050366e-02f, 8.20092037e-02f, -2.60155573e-02f, 8.35282877e-02f, -4.67992574e-02f,
  3.51982675e-02f, 1.28567755e-01f, 3.68024148e-02f, -7.02548632e-03f, -1.23881839e-01f, 2.03602966e-02f, 4.82980125e-02f, -3.40366922e-02f, -4.56096977e-02f, -6.50443360e-02f,
  -1.06947273e-02f, 8.18523951e-03f, -2.41634529e-02f, 1.34542838e-01f, 3.30665186e-02f, 4.49471585e-02f, 6.22354858e-02f, -2.99143214e-02f, 3.49086374e-02f, -5.23109809e-02f,
  5.03044459e-04f, -6.50233775e-02f, 8.42431486e-02f, 8.64319876e-02f, -2.38412116e-02f, -9.35784057e-02f, 9.48527455e-02f, -9.24782157e-02f, 8.55276808e-02f, 1.17446966e-01f,
  1.45188928e-01f, 1.71669945e-01f, -6.41724467e-03f, 6.83935285e-02f, -7.75816813e-02f, 1.83763411e-02f, -8.02726597e-02f, 3.49113345e-02f, 3.69443670e-02f, 2.41734609e-02f,
  5.64326160e-02f, 2.47759055e-02f, 2.15869278e-01f, -5.83590055e-03f, 2.88509429e-02f, 4.39463332e-02f, 1.27131566e-01f, 3.09479400e-03f, 6.03508577e-02f, 3.75109725e-02f,
  1.53786168e-01f, 6.41128048e-02f, -8.87004510e-02f, -1.41240219e-02f, 1.23731017e-01f, 3.86610404e-02f, 1.01032890e-01f, 1.65566746e-02f, 4.08910168e-03f, 2.72353627e-02f,
  -6.82874739e-01f, 2.31753841e-01f, -1.01152785e-01f, -2.70120114e-01f, -8.80577564e-02f, -8.73825774e-02f, -8.25498775e-02f, -7.82182813e-02f, -9.95263234e-02f, 1.30893975e-01f,
  8.32998604e-02f, -1.32054523e-01f, 2.36068338e-01f, 1.16477691e-01f, -2.29336202e-01f, 1.83562681e-01f, -1.69373557e-01f, -1.62041798e-01f, 5.58552779e-02f, -2.07808092e-01f,
  -1.13485657e-01f, 8.86574984e-02f, 4.03640606e-02f, 2.34418705e-01f, -2.07025558e-01f, -5.75195290e-02f, -9.86008719e-02f, 1.30304992e-01f, 1.54857496e-02f, 1.04059167e-02f,
  -3.94435883e-01f, -2.97751576e-01f, -1.76531807e-01f, -1.07961491e-01f, -1.68665588e-01f, -6.38060421e-02f, -4.07804623e-02f, 4.76606078e-02f, -7.60963261e-02f, 2.04983214e-03f,
  -5.67647330e-02f, -8.87215883e-03f, 7.59079233e-02f, 2.80170981e-02f, -4.79940064e-02f, 2.14723940e-03f, 1.34423420e-01f, 6.79727048e-02f, 1.15289530e-02f, 1.13554923e-02f,
  5.77496290e-02f, 4.47533540e-02f, -7.47338831e-02f, 4.56320345e-02f, 7.15735331e-02f, -5.59101552e-02f, -6.74609691e-02f, -6.36686534e-02f, -5.92060760e-03f, -5.53375110e-02f,
  1.45312678e-02f, 6.23023771e-02f, 9.85849276e-03f, -3.84222791e-02f, -1.19203357e-02f, 7.32994378e-02f, 4.41713072e-02f, -7.12995902e-02f, 3.04828919e-02f, -2.22024042e-02f,
  -8.53381678e-02f, -6.70899898e-02f, -7.86956698e-02f, -3.28569598e-02f, 4.32138070e-02f, -6.60472959e-02f, 3.05133071e-02f, -8.66112784e-02f, 2.01089568e-02f, -7.94760734e-02f,
  7.58306403e-03f, 7.51821175e-02f, 3.24166901e-02f, -1.44410031e-02f, -2.49566752e-02f, 1.37416869e-02f, 4.60928120e-02f, 5.88542456e-03f, -1.08699258e-02f, -1.04540978e-02f,
  -5.39407015e-01f, -4.64955628e-01f, -6.03168681e-02f, -1.25989288e-01f, -2.95379292e-02f, -1.01242602e-01f, 2.71744397e-03f, -7.48179331e-02f, -8.97800475e-02f, -1.09633751e-01f,
  -8.09377283e-02f, -6.84508309e-02f, -1.30378008e-01f, 1.74942017e-02f, 3.99378799e-02f, 2.11495045e-03f, -1.27038315e-01f, -2.48562545e-02f, -8.12406912e-02f, -6.45325426e-03f,
  -2.19950583e-02f, -6.70334473e-02f, 9.29646790e-02f, 1.91486739e-02f, -4.98596206e-02f, -9.16568190e-02f, -4.68280502e-02f, 3.87521908e-02f, -8.00881758e-02f, 7.12409467e-02f,
  4.45366383e-01f, -3.12423855e-01f, 1.87597007e-01f, 3.11466873e-01f, 2.24647999e-01f, 4.43342812e-02f, 1.07162625e-01f, 1.16371378e-01f, 3.02769363e-01f, -2.50987679e-01f,
  -8.22312310e-02f, -5.06945141e-02f, -3.49419713e-01f, 2.46584073e-01f, -2.12901622e-01f, -2.00829893e-01f, 1.11206062e-01f, 1.43741816e-03f, 2.02922560e-02f, 4.76273485e-02f,
  9.71806794e-02f, 5.23007475e-02f, 1.05615417e-02f, 2.37082001e-02f, 2.98915207e-01f, 1.27472073e-01f, -2.76780743e-02f, -1.21672966e-01f, 1.36577219e-01f, 5.71485283e-03f,
  -3.47128101e-02f, 1.33702785e-01f, -3.30940895e-02f, -6.21435232e-02f, 1.71164125e-02f, 3.58204693e-02f, -1.46561280e-01f, 1.89857427e-02f, 2.48171836e-02f, -4.59657125e-02f,
  -7.94790164e-02f, 2.45115142e-02f, 1.93889230e-01f, -4.84442338e-02f, 9.09243748e-02f, 1.59353361e-01f, 1.21426024e-01f, -5.07504977e-02f, 7.50390589e-02f, -5.88036403e-02f,
  3.76673555e-03f, 2.14979227e-04f, 1.15524597e-01f, -4.08365354e-02f, -6.23845346e-02f, 1.12793468e-01f, 5.06653711e-02f, -9.09633785e-02f, 2.13330593e-02f, 8.04774389e-02f,
  -8.51576552e-02f, -5.37592210e-02f, -6.85197264e-02f, 1.12917580e-01f, 4.78064865e-02f, 4.62345332e-02f, -6.53853267e-02f, -2.19835117e-02f, -6.72864988e-02f, -2.84295995e-02f,
  5.51345050e-02f, 4.84505184e-02f, 4.69788425e-02f, 6.86468333e-02f, 2.13288143e-02f, 6.67574480e-02f, 2.85461098e-02f, 2.96683814e-02f, -7.54539818e-02f, 6.51453510e-02f,
  -3.25769819e-02f, -2.01727748e-02f, -2.19702218e-02f, 7.96489343e-02f, 2.58059278e-02f, -8.04013163e-02f, -3.57489027e-02f, 4.79158983e-02f, 8.24901313e-02f, -7.31673762e-02f,
  -2.62104481e-01f, -3.07043850e-01f, -7.63125420e-02f, 1.08650536e-03f, -2.26333980e-02f, -6.33059964e-02f, 6.62114397e-02f, 7.81555623e-02f, -1.37467742e-01f, 4.65876497e-02f,
  -7.72949234e-02f, 5.65217510e-02f, -1.87262008e-03f, 6.37526736e-02f, 1.05634294e-02f, -8.61661211e-02f, 1.17189782e-02f, -4.76719216e-02f, -9.47125256e-03f, -6.38504848e-02f,
  -1.27771003e-02f, -5.50759584e-02f, -4.72721942e-02f, 5.99772856e-02f, -1.55941844e-02f, -5.04940450e-02f, 1.29181325e-01f, 1.51788732e-02f, -2.21616160e-02f, -1.70009825e-02f,
  -2.66228974e-01f, -1.68933585e-01f, -6.29596040e-02f, 2.06397381e-02f, 2.42289469e-01f, -8.64922702e-02f, -1.99188381e-01f, 2.57916510e-01f, -8.52694958e-02f, -1.28412500e-01f,
  -1.18664622e-01f, -4.23375636e-01f, -1.40054122e-01f, -2.19326034e-01f, -1.58345997e-02f, -2.98204750e-01f, 1.76621839e-01f, -1.48131177e-01f, -1.19286031e-02f, 7.44863823e-02f,
  1.63826942e-01f, 2.74881214e-01f, 2.37040862e-01f, 3.36514264e-01f, 1.83830738e-01f, 3.33014786e-01f, 3.31816107e-01f, 2.97351062e-01f, 2.38892406e-01f, 9.55490917e-02f,
  -9.38155800e-02f, -1.15756109e-01f, 2.55170232e-03f, -3.36878933e-02f, 1.40306994e-01f, 8.36721733e-02f, 1.19547047e-01f, -5.65426014e-02f, 1.47744510e-02f, 3.58835422e-02f,
  -2.93590818e-02f, 1.40772805e-01f, -1.44466832e-01f, -5.21529987e-02f, 9.52649266e-02f, 8.16490278e-02f, -1.03806674e-01f, 3.69576700e-02f, 1.14416793e-01f, -2.32031211e-01f,
  -9.74896997e-02f, -1.48853436e-01f, -3.15653123e-02f, 2.79743131e-02f, -8.48913416e-02f, 3.26493308e-02f, -1.73831137e-03f, -5.86512461e-02f, 3.14245187e-02f, -5.49576506e-02f,
  1.86434835e-02f, -9.74398572e-03f, -3.02522443e-02f, -1.27110392e-01f, -5.37432730e-02f, -5.27265482e-02f, 8.89747515e-02f, -6.16870895e-02f, 7.89064690e-02f, -1.30738951e-02f,
  6.63768053e-02f, 2.60866154e-02f, -8.75655711e-02f, -5.16599603e-02f, -5.82500584e-02f, 4.29409146e-02f, 6.68042712e-03f, -9.64021459e-02f, 5.68611640e-03f, 1.27139781e-03f,
  -2.29574889e-02f, 4.73056808e-02f, 7.39322091e-03f, 6.75089657e-02f, 9.46089532e-03f, -3.26704197e-02f, 1.10955611e-02f, -1.21466972e-01f, -4.99276072e-02f, 1.77888083e-03f,
  -4.33517154e-03f, 1.23035215e-01f, 7.52561763e-02f, 1.28668798e-02f, -6.24354649e-03f, 3.28850076e-02f, 5.86466417e-02f, -1.23930834e-02f, 2.82543786e-02f, -1.07826255e-01f,
  1.66728750e-01f, 7.52353370e-02f, -3.82137275e-03f, 1.93046201e-02f, 6.57702237e-02f, -5.95249198e-02f, -4.76931110e-02f, 8.64549354e-02f, 2.37934560e-01f, 4.60749939e-02f,
  4.66524176e-02f, -1.13346376e-01f, 1.58816412e-01f, 5.42348176e-02f, 1.02575094e-01f, 3.23580578e-02f, -7.46622607e-02f, 1.09770000e-01f, -2.65042149e-02f, -3.30781192e-02f,
  2.38392323e-01f, -2.69426972e-01f, 1.07827678e-01f, 4.41298001e-02f, -3.94518711e-02f, -8.93056169e-02f, 1.12407200e-01f, -2.43439823e-01f, 3.32446545e-02f, -1.51725009e-01f,
  -4.48627537e-03f, 1.92789897e-01f, 2.44396180e-01f, -1.76528528e-01f, 4.43584889e-01f, 2.31326878e-01f, -5.42066321e-02f, 4.73907404e-02f, 2.06423905e-02f, -1.66638538e-01f,
  -6.10394739e-02f, -3.32926899e-01f, -6.49804771e-02f, -4.23127532e-01f, -1.19592287e-01f, -2.33852774e-01f, -3.67129035e-02f, 9.62251276e-02f, -2.71308333e-01f, 7.20449463e-02f,
  -1.58097029e-01f, -1.60309941e-01f, -1.11137874e-01f, -7.25580454e-02f, -1.22051455e-01f, -8.40771571e-02f, 1.23385638e-01f, 7.95387328e-02f, 5.75625971e-02f, -4.29416150e-02f,
  -1.83040816e-02f, 1.66656952e-02f, -1.04344562e-01f, 1.02596898e-02f, -1.17697999e-01f, -1.99113693e-02f, 5.96361868e-02f, -6.39185607e-02f, -2.54861340e-02f, 8.93434584e-02f,
  -2.77389982e-03f, 7.15813460e-03f, -3.68663371e-02f, 1.06709134e-02f, 2.14779545e-02f, -4.72590402e-02f, 8.19790736e-03f, 1.18715495e-01f, 5.44000082e-02f, 1.04178553e-02f,
  -7.25294575e-02f, 4.45616469e-02f, -1.00953214e-01f, -5.43582365e-02f, 2.97887810e-02f, -6.98966980e-02f, -6.66203424e-02f, -1.35014802e-02f, 2.57250015e-02f, 5.27062826e-03f,
  -1.43637694e-02f, 1.34361358e-02f, -1.18834153e-03f, -3.25796418e-02f, -7.56427050e-02f, 4.33314256e-02f, 2.66294610e-02f, -3.26882191e-02f, -1.02116413e-01f, -3.78710926e-02f,
  -9.77386371e-04f, 6.23558462e-02f, 1.15145696e-02f, 2.79417485e-02f, -3.44733447e-02f, 5.75288106e-03f, -3.69339134e-03f, 2.39454601e-02f, 5.18384576e-02f, 4.69754934e-02f,
  -2.04925463e-01f, -2.25137711e-01f, -6.18541799e-02f, -4.35731523e-02f, -5.50824478e-02f, -3.56538594e-02f, -5.65058812e-02f, -1.22118052e-02f, -1.39831901e-01f, 3.39847542e-02f,
  1.78105328e-02f, 2.16121096e-02f, -1.05500810e-01f, 5.04818819e-02f, -8.29734057e-02f, -1.16275221e-01f, -3.66037935e-02f, -7.36174732e-02f, -2.09430084e-02f, -3.73985656e-02f,
  4.26021181e-02f, 9.26380325e-03f, 2.51274761e-02f, -1.35582671e-01f, -9.60914046e-03f, 2.87119299e-02f, -6.46207854e-02f, 7.73328170e-03f, 8.00760463e-02f, 2.13727839e-02f,
  3.48512471e-01f, 3.51288915e-01f, 2.43347019e-01f, 2.97244877e-01f, -2.71589607e-01f, -1.87252149e-01f, -1.92447841e-01f, -1.21966638e-01f, 8.22246894e-02f, 2.04986200e-01f,
  -2.69861579e-01f, 4.66489702e-01f, -1.66381463e-01f, 7.59417191e-02f, -3.19656134e-01f, -1.27570003e-01f, 4.12344337e-02f, 2.94637501e-01f, -1.17061317e-01f, 8.65025967e-02f,
  4.10109572e-02f, -3.00148457e-01f, -8.78280401e-02f, -2.29412973e-01f, 1.29030451e-01f, 1.82325184e-01f, -2.77144819e-01f, -1.76488832e-01f, 2.20595673e-01f, -1.59762293e-01f,
  2.87333969e-02f, -3.61861102e-02f, 3.63390185e-02f, 6.90435767e-02f, 1.00543037e-01f, 7.87613019e-02f, 9.10029635e-02f, -9.62882638e-02f, -5.88302277e-02f, 8.31493959e-02f,
  1.28486007e-01f, -6.20092936e-02f, 4.17018728e-03f, -7.31837451e-02f, 4.12847959e-02f, 5.11457697e-02f, 1.66979909e-01f, 1.23724647e-01f, -2.02208329e-02f, 1.34068742e-01f,
  9.85666588e-02f, 1.62466154e-01f, -1.20588271e-02f, 6.14918768e-02f, 3.70612815e-02f, -8.21740031e-02f, 5.20387664e-02f, 5.31166941e-02f, 1.62445381e-01f, 6.18074276e-02f,
  -3.59333903e-02f, -1.35313105e-02f, -2.79998537e-02f, -2.92476267e-02f, -8.60834792e-02f, 2.90807690e-02f, -2.17892751e-02f, -9.67510194e-02f, 1.92480441e-02f, -1.59493387e-02f,
  3.27352807e-02f, 1.13250241e-02f, -3.10363080e-02f, 1.61153767e-02f, 7.07160830e-02f, 1.03085451e-01f, -2.25039646e-02f, 1.28695637e-01f, 3.74954492e-02f, 2.94894129e-02f,
  -4.76296544e-02f, -1.15892448e-01f, 6.79353401e-02f, 2.61873584e-02f, -1.10117719e-01f, -3.26967575e-02f, 1.40467621e-02f, 1.01646893e-01f, -4.70199808e-02f, -1.68773696e-01f,
  -4.78379205e-02f, -8.00517648e-02f, -3.74644902e-03f, -2.50343811e-02f, 7.78806135e-02f, -1.96062252e-02f, -2.17102822e-02f, 7.99362212e-02f, -4.51261774e-02f, -6.55936599e-02f,
  1.13376334e-01f, 2.54173446e-02f, -4.62593175e-02f, 4.32224795e-02f, -8.01432207e-02f, -6.60324097e-02f, 2.03892076e-03f, 4.68426012e-02f, -6.08647652e-02f, 2.55791750e-02f,
  1.06374845e-01f, 7.50105921e-03f, 6.75067529e-02f, -2.05842685e-02f, 3.93073894e-02f, 1.56199140e-02f, 8.12677890e-02f, 1.05289839e-01f, -4.50499840e-02f, -1.92562640e-02f,
  -3.90915692e-01f, 3.66152376e-01f, 1.11206390e-01f, 4.50172126e-01f, -3.85411561e-01f, -1.99744299e-01f, 3.08665395e-01f, 4.00002860e-02f, 1.06672637e-01f, 2.70377487e-01f,
  1.20075211e-01f, -8.87234583e-02f, 2.08082512e-01f, 3.40758771e-01f, 4.17744555e-02f, 3.47138464e-01f, 2.65722901e-01f, 1.41723022e-01f, 1.67229548e-02f, 7.74915963e-02f,
  4.06384803e-02f, 2.38445252e-01f, 1.87025994e-01f, -7.96996057e-02f, -7.90395513e-02f, 5.76501563e-02f, 2.62495995e-01f, -5.18945083e-02f, 6.87626749e-02f, -5.84831275e-02f,
  -2.39748117e-02f, 2.30601635e-02f, -4.86399643e-02f, -3.59347165e-02f, -2.11832654e-02f, -1.03646845e-01f, 3.81563120e-02f, -7.83236399e-02f, -2.07746495e-02f, 4.57179667e-05f,
  -3.14580947e-02f, -4.45778668e-02f, 4.71160263e-02f, -3.43973935e-02f, -1.47913158e-01f, -1.25856977e-02f, 2.23205350e-02f, -7.09215850e-02f, 1.06859179e-02f, -6.24943450e-02f,
  -5.24223503e-03f, 1.67633407e-02f, 5.61914891e-02f, 1.53752968e-01f, -3.20735201e-02f, 8.78929123e-02f, 7.65598118e-02f, -3.68603580e-02f, -6.34096116e-02f, 2.27906294e-02f,
  -8.40805247e-02f, 4.66908291e-02f, 1.12364460e-02f, 4.41372804e-02f, -3.24339308e-02f, 4.64253798e-02f, -5.78397177e-02f, 3.94575819e-02f, -2.55242568e-02f, 4.57790904e-02f,
  2.99619492e-02f, -9.30159166e-03f, -3.32396440e-02f, 4.66707759e-02f, -2.11489061e-03f, 8.35144967e-02f, -7.36906081e-02f, 2.27627065e-02f, -3.62418704e-02f, 5.37919104e-02f,
  1.41062021e-01f, -7.00738057e-02f, 8.76332372e-02f, -8.18441901e-03f, 7.11020306e-02f, -1.39878094e-02f, -6.67333603e-03f, -3.64675038e-02f, 1.42888859e-01f, -7.37286210e-02f,
  1.44683927e-01f, 3.28431934e-01f, 8.00339952e-02f, 6.10344764e-03f, 7.41949081e-02f, -1.03767209e-01f, 3.63169871e-02f, -4.10300195e-02f, 1.44453362e-01f, 1.22604631e-01f,
  -1.44566625e-01f, 1.81875564e-02f, 2.95189898e-02f, -1.65670924e-02f, 5.73497713e-02f, 9.23064277e-02f, 1.63326994e-01f, 9.00214911e-02f, 7.33338222e-02f, -2.35615559e-02f,
  7.79556260e-02f, 2.22599804e-02f, 6.45228522e-03f, -4.36536185e-02f, 5.00022210e-02f, 2.18693744e-02f, -1.28661349e-01f, -8.78473222e-02f, -1.66793555e-01f, 8.62518772e-02f,
  1.47001699e-01f, -1.55289983e-02f, -3.50008488e-01f, -9.01626498e-02f, -1.29786626e-01f, 1.86177954e-01f, 4.42467779e-02f, -2.19906196e-02f, -4.47518900e-02f, 2.80795485e-01f,
  1.74644560e-01f, -8.08075741e-02f, 6.27224669e-02f, 3.42871100e-01f, -3.80628034e-02f, 2.66601175e-01f, 3.01462412e-01f, 3.25207412e-01f, 6.73223808e-02f, -1.10134341e-01f,
  6.09861426e-02f, 2.89472520e-01f, -2.13294461e-01f, -1.78735554e-01f, -4.86902483e-02f, -3.51355374e-01f, -4.18764018e-02f, -3.19218576e-01f, -1.45535901e-01f, 3.62496190e-02f,
  4.64476421e-02f, 5.31683909e-03f, -7.31259435e-02f, 5.21554314e-02f, -1.39659578e-02f, 6.94547296e-02f, -7.82004967e-02f, -7.06495643e-02f, -3.38325761e-02f, -6.41725361e-02f,
  -2.14250926e-02f, -1.38767548e-02f, 9.96774212e-02f, -7.63313770e-02f, -6.50670305e-02f, 9.09241103e-03f, 7.38038868e-02f, -2.67012361e-02f, -1.47281557e-01f, -2.61274055e-02f,
  -1.41957611e-01f, -1.19062476e-02f, -1.73029881e-02f, -4.05854955e-02f, -3.53816487e-02f, -4.12527248e-02f, -6.19920436e-03f, -1.33827358e-01f, 1.56153142e-02f, -3.05659100e-02f,
  -3.14304568e-02f, 3.07414262e-03f, -1.70364138e-02f, 1.67837944e-02f, 7.43001625e-02f, 5.89763075e-02f, -4.67679538e-02f, 6.41631633e-02f, -3.08640786e-02f, 1.52364317e-02f,
  3.92071418e-02f, -1.03097688e-02f, 3.91343720e-02f, -4.79090177e-02f, 8.88311416e-02f, 5.81816621e-02f, 4.11090516e-02f, -2.21143048e-02f, 2.49964036e-02f, -1.56203695e-02f,
  3.86192165e-02f, 6.85206428e-02f, -1.17011312e-02f, 3.34502906e-02f, -1.35490242e-02f, -1.11580029e-01f, 7.78963137e-03f, 7.63486102e-02f, 5.82739478e-03f, 6.04403345e-03f,
  1.22002684e-01f, -4.21827473e-02f, 1.28831770e-02f, -5.15516400e-02f, -4.59755622e-02f, 5.52424155e-02f, 9.59560648e-02f, -1.81794390e-02f, -1.29103333e-01f, 3.55440080e-02f,
  8.61499012e-02f, 3.48453932e-02f, -6.23181649e-02f, -9.10566822e-02f, -7.76881054e-02f, 4.56619225e-02f, -2.65131854e-02f, 3.23781297e-02f, 2.65756175e-02f, -1.25170350e-01f,
  1.79244690e-02f, 4.62714806e-02f, -3.72215407e-03f, 8.46916959e-02f, 7.04189688e-02f, 5.08176461e-02f, -2.29569636e-02f, -1.49880335e-01f, 5.37518002e-02f, -6.02011234e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.68814141e-01f, 3.17044854e-01f, 3.46487731e-01f, 2.54455000e-01f, 2.42204905e-01f, 3.50114852e-01f, 9.59101617e-02f, -3.76348160e-02f, 2.43669953e-02f, 2.48545930e-01f,
  3.48021924e-01f, 2.43495882e-01f, 2.61595428e-01f, 3.35402071e-01f, 1.34900659e-01f, 1.55730024e-01f, 3.11666518e-01f, 2.17233330e-01f, 2.31295481e-01f, 2.73775697e-01f,
  2.64895499e-01f, 3.06687742e-01f, 2.78519869e-01f, 1.71438798e-01f, 2.39716560e-01f, 1.91215530e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  3.47636342e-02f, -6.34866059e-02f, -1.22574776e-01f, 9.28284600e-02f, 1.02614939e-01f, -4.22548354e-02f, 2.51717046e-02f, -1.02965228e-01f, 3.86258960e-02f, 3.01857498e-02f,
  -2.06677765e-02f, 5.73836826e-02f, 1.17853969e-01f, -2.80591156e-02f, -3.07366680e-02f, -1.03863388e-01f, 1.71672970e-01f, 2.04322990e-02f, -7.23204687e-02f, 1.15005739e-01f,
  1.95219755e-01f, 6.84544668e-02f, 9.39594656e-02f, 2.05670595e-01f, 6.74445853e-02f, -8.72410759e-02f, 9.66977049e-03f, 2.96170264e-01f, 3.26374710e-01f, 2.05544069e-01f,
  -3.09065670e-01f, 4.01763245e-02f, 6.67685494e-02f, -1.02157220e-01f, -1.59542505e-02f, -2.40196839e-01f, 5.87305203e-02f, 1.09631866e-01f, 2.28035524e-02f, 5.17272986e-02f,
  1.18293948e-01f, 2.69628167e-01f, -3.43445083e-03f, 1.03981920e-01f, 2.46485531e-01f, 5.72151542e-02f, -2.16919184e-02f, 1.62632316e-01f, 1.32194430e-01f, -1.69222370e-01f,
  -2.52282415e-02f, 1.12746984e-01f, 2.59162992e-01f, 1.09019503e-02f, -3.68971862e-02f, 3.66521776e-02f, -1.96238890e-01f, 1.94267794e-01f, -1.28870562e-01f, 1.33509850e-02f,
  -7.97552690e-02f, -1.73051313e-01f, -7.57098198e-02f, -2.73471981e-01f, 3.35304104e-02f, 2.28726149e-01f, 9.90415066e-02f, 3.10088899e-02f, 6.74000457e-02f, 2.51954973e-01f,
  6.92407489e-02f, 1.16601653e-01f, -6.32490441e-02f, 1.38859391e-01f, 5.46647944e-02f, 2.13700309e-01f, 1.71042025e-01f, 9.40155461e-02f, 8.76921415e-03f, -1.34524675e-02f,
  2.51233783e-02f, -1.83324069e-02f, -4.70106527e-02f, 2.28179507e-02f, -1.90913258e-03f, -2.92423636e-01f, 6.07365705e-02f, -1.30136847e-01f, 9.28575322e-02f, -1.76458865e-01f,
  1.33212909e-01f, -6.62884489e-02f, -2.87555277e-01f, 3.35995257e-02f, -7.08419606e-02f, -1.61598653e-01f, 3.52925248e-03f, -7.30933324e-02f, 2.28813529e-01f, 2.03069583e-01f,
  -1.01901293e-01f, 8.27987939e-02f, 7.46630505e-02f, 1.65934131e-01f, -9.96335223e-02f, -2.62815893e-01f, 1.76548325e-02f, -1.32524103e-01f, -3.08889538e-01f, 2.88490523e-02f,
  -1.45310983e-01f, -1.53284758e-01f, 1.09207906e-01f, 3.21434587e-02f, -1.29141986e-01f, 2.53376830e-02f, -1.40907794e-01f, -2.61687059e-02f, 1.03278947e-03f, -6.67198896e-02f,
  -2.31354423e-02f, -6.31793439e-02f, 7.80668929e-02f, -8.52326304e-03f, 1.40920654e-02f, 1.96060926e-01f, -7.54911005e-02f, 5.70621826e-02f, 3.94182838e-02f, 1.13126390e-01f,
  -6.21321574e-02f, -1.28571615e-01f, -2.23466661e-02f, -4.41037826e-02f, -1.02755867e-01f, -1.72279462e-01f, -1.28345057e-01f, -9.33855549e-02f, -3.38514969e-02f, -2.44974643e-02f,
  -1.26096264e-01f, -1.61547493e-02f, 4.20500711e-03f, -3.77371609e-02f, -1.98499829e-01f, -6.58480600e-02f, -1.06373660e-01f, -1.85481235e-01f, -1.36391833e-01f, 2.15232164e-01f,
  -1.38023058e-02f, -2.67744422e-01f, -1.07042342e-01f, 6.89973682e-02f, -1.37315601e-01f, -1.67830382e-03f, 7.85241649e-02f, -8.91543627e-02f, 2.50130147e-02f, 2.58759856e-01f,
  -2.30164960e-01f, 2.67741196e-02f, -1.04734823e-01f, 7.59934932e-02f, 1.63344130e-01f, 1.51400328e-01f, -1.79851860e-01f, -4.61467821e-03f, -6.14502281e-02f, -2.93987244e-03f,
  -1.20406620e-01f, -8.98458362e-02f, 7.46685490e-02f, 2.31593266e-01f, 2.30006069e-01f, -1.15747839e-01f, -9.65823159e-02f, 4.98188399e-02f, -5.03236838e-02f, 1.75092574e-02f,
  -3.26477140e-01f, 1.02913730e-01f, 2.58393269e-02f, 2.52555162e-01f, 2.97368199e-01f, -1.53653532e-01f, -2.26560041e-01f, 8.85449499e-02f, -8.81888494e-02f, -2.26034790e-01f,
  1.68389782e-01f, 1.10959291e-01f, -6.61124364e-02f, 6.07880913e-02f, 8.92782770e-03f, -6.28738925e-02f, 7.72554204e-02f, 7.22940043e-02f, 1.07490771e-01f, 1.07679769e-01f,
  -3.57250609e-02f, -1.78441033e-01f, -9.57516506e-02f, -9.14615393e-02f, 5.09271957e-02f, -7.77744204e-02f, -9.44755003e-02f, -2.50803977e-02f, 6.12668544e-02f, -1.11525655e-01f,
  1.19596370e-01f, 1.31836429e-01f, -1.22954860e-01f, 5.19737191e-02f, -3.26443583e-01f, -6.96673393e-02f, -1.54139355e-01f, -4.86246170e-03f, -3.87647264e-02f, 1.95144668e-01f,
  -3.08129434e-02f, 2.34027386e-01f, 1.85274646e-01f, -6.33157045e-02f, -6.61523417e-02f, -1.23738404e-02f, 2.48919547e-01f, 1.81741826e-02f, -7.38405883e-02f, -6.06369041e-02f,
  1.98862821e-01f, -1.92505255e-01f, -1.21549398e-01f, 4.26512538e-03f, 2.35826708e-02f, 4.28749174e-02f, -4.78971936e-02f, -1.26534089e-01f, -1.30226731e-01f, 1.53196175e-02f,
  5.61248846e-02f, -1.44241393e-01f, 1.38762936e-01f, -2.92656004e-01f, 1.26053706e-01f, -2.97349602e-01f, 8.28307196e-02f, -1.16118781e-01f, 1.12742528e-01f, -2.23967433e-01f,
  1.32256046e-01f, -4.26090173e-02f, 1.96729869e-01f, -1.01497352e-01f, -2.05702618e-01f, 7.87913054e-02f, 9.40993577e-02f, 5.56556471e-02f, 1.12648375e-01f, -1.71316177e-01f,
  1.21110372e-01f, 1.35002136e-02f, -2.97257975e-02f, -1.96215697e-02f, 1.09236296e-02f, 5.78603260e-02f, 8.89040977e-02f, 1.39062643e-01f, 9.20730606e-02f, 1.26998037e-01f,
  3.56612839e-02f, 5.56757189e-02f, 7.05478862e-02f, 1.59176737e-02f, -8.44154581e-02f, -2.45685130e-01f, -1.92878187e-01f, -8.65926892e-02f, 2.02128991e-01f, 9.36385170e-02f,
  1.75723568e-01f, -1.86021954e-01f, 9.52124447e-02f, 8.68234560e-02f, -2.76773006e-01f, -2.00145528e-01f, -7.69308135e-02f, -1.01990223e-01f, 2.91472282e-02f, 9.20476615e-02f,
  1.71960667e-01f, 1.22325905e-01f, -2.85880387e-01f, 1.39838412e-01f, 9.91179794e-02f, 1.39361992e-01f, -1.01414442e-01f, -5.07481806e-02f, -3.81624252e-02f, -1.13481805e-01f,
  -7.76425228e-02f, 1.68556795e-01f, -6.37648702e-02f, 1.46856844e-01f, -1.43292576e-01f, -2.59168278e-02f, -2.31149778e-01f, -1.80021107e-01f, -3.58790997e-03f, 3.95645536e-02f,
  -2.70837128e-01f, 2.44946685e-02f, -8.87325779e-02f, 1.54946195e-02f, -6.05086759e-02f, 5.19690476e-02f, 3.45810205e-02f, -2.38259405e-01f, 1.37285277e-01f, -1.07687209e-02f,
  -8.92314315e-02f, -2.81240186e-03f, 9.85982344e-02f, 5.69186732e-02f, -7.06961527e-02f, -8.38622376e-02f, 1.62159324e-01f, -4.84186299e-02f, 1.09974265e-01f, -7.56183937e-02f,
  1.14790596e-01f, 3.12611759e-02f, -5.05153984e-02f, -1.26749516e-01f, -1.04386285e-01f, -1.64091185e-01f, -2.03628078e-01f, -9.32787824e-03f, 1.51979759e-01f, 2.39223182e-01f,
  -9.94272605e-02f, 2.37357616e-01f, -1.19767785e-01f, -2.81511843e-01f, -2.96536356e-01f, 9.18766856e-02f, -4.69429754e-02f, 1.60655603e-01f, 9.81153324e-02f, 4.10912111e-02f,
  1.84399709e-01f, 1.52335033e-01f, -1.19950719e-01f, 2.99427390e-01f, 4.55186423e-03f, 1.44639596e-01f, 3.26373498e-03f, -1.91509634e-01f, 1.88390702e-01f, -2.15205833e-01f,
  -7.70592466e-02f, 8.17662012e-03f, -9.89129618e-02f, -1.43600672e-01f, 1.44479582e-02f, -1.88144460e-01f, 8.22046772e-02f, -1.43929020e-01f, 1.41645983e-01f, -4.01088372e-02f,
  -1.02535076e-01f, -2.51633823e-01f, -1.82660893e-01f, -2.89766937e-01f, 8.25118572e-02f, 1.44748062e-01f, 2.74846196e-01f, -1.57335684e-01f, 1.78462803e-01f, 2.03699201e-01f,
  2.68614031e-02f, -2.18013316e-01f, -3.20430249e-01f, 1.97457358e-01f, -7.63503881e-03f, -8.74517784e-02f, -1.13485061e-01f, 8.94170702e-02f, -1.60482258e-01f, -3.48897055e-02f,
  8.45531598e-02f, 3.81027609e-02f, -1.02664597e-01f, 5.78707922e-03f, -4.02328074e-02f, 7.65811875e-02f, 1.23002619e-01f, 2.64912285e-02f, -1.53510170e-02f, 1.07964188e-01f,
  -1.63351551e-01f, 4.02455665e-02f, 2.46952139e-02f, -1.46164313e-01f, 2.27402654e-02f, -3.16798594e-03f, 2.51791269e-01f, -1.54066905e-01f, 7.77519196e-02f, -9.79241952e-02f,
  -5.50405942e-02f, -1.15493350e-01f, -5.48583828e-03f, -2.68025458e-01f, -1.46105602e-01f, 7.53162056e-02f, -1.71487466e-01f, 2.27298006e-01f, -6.60338253e-02f, 5.31290099e-02f,
  1.59651488e-01f, 2.39785016e-02f, 6.20031245e-02f, 2.43617408e-02f, 1.39515594e-01f, -1.65207282e-01f, -1.19857177e-01f, -1.51359379e-01f, -9.07886624e-02f, 1.41274825e-01f,
  2.40158036e-01f, -1.73693597e-01f, -5.26304506e-02f, 6.88367337e-02f, 2.45034881e-02f, -3.47754471e-02f, 2.66435444e-01f, 2.14186773e-01f, -1.23515785e-01f, -1.86524495e-01f,
  -2.16213409e-02f, 2.70743012e-01f, -2.30808005e-01f, -1.40951306e-01f, -3.22278053e-01f, -1.82460994e-01f, 1.56560346e-01f, 8.11225697e-02f, 7.32287318e-02f, 1.15319230e-01f,
  1.18839093e-01f, 1.54974177e-01f, 8.50473419e-02f, 2.01912463e-01f, 4.04272787e-02f, 5.50969355e-02f, 3.37058865e-02f, 2.13779703e-01f, 9.26439017e-02f, 2.11568907e-01f,
  1.86720997e-01f, -3.95266265e-02f, -3.08660455e-02f, 5.43253087e-02f, -7.95766115e-02f, 1.47255898e-01f, -7.61702359e-02f, 1.18919179e-01f, 2.01524481e-01f, -7.64053240e-02f,
  -1.14374802e-01f, 2.09369227e-01f, 1.28671274e-01f, -8.93171206e-02f, -1.51935264e-01f, -8.66644979e-02f, -1.25781566e-01f, 4.56053726e-02f, -3.91596034e-02f, 2.73374379e-01f,
  1.29350126e-01f, 1.29394770e-01f, -2.11302444e-01f, -2.18522608e-01f, 4.21207994e-02f, 1.73887223e-01f, -9.46124792e-02f, 1.00830935e-01f, 3.08941692e-01f, -1.08946472e-01f,
  -3.12251061e-01f, -2.08228156e-02f, -2.74407774e-01f, -1.37329241e-02f, 6.60865232e-02f, -2.46486425e-01f, 9.36084762e-02f, 4.70708357e-03f, -1.53544396e-01f, 2.38305986e-01f,
  6.21715263e-02f, 3.98404986e-01f, -1.29867662e-02f, -1.52237996e-01f, -2.82538366e-02f, 1.32004350e-01f, 8.44069794e-02f, -1.70663565e-01f, -2.21555620e-01f, 7.69851357e-02f,
  9.85996276e-02f, 1.54444307e-01f, 4.29714955e-02f, -1.63114801e-01f, -4.79126610e-02f, -1.51949942e-01f, 3.46115306e-02f, 3.23318085e-03f, -1.11407146e-01f, -8.36936012e-02f,
  7.77931586e-02f, 3.35630029e-02f, 1.48556009e-01f, -1.62296951e-01f, -1.13931717e-02f, 4.71122786e-02f, 1.89732522e-01f, 1.37205198e-01f, 3.96982804e-02f, 7.57597834e-02f,
  3.23191620e-02f, -1.54453605e-01f, 2.11986557e-01f, 1.17923923e-01f, 1.61476344e-01f, 3.09793912e-02f, 2.62837321e-01f, 2.01857276e-03f, 8.61333124e-03f, 4.42662127e-02f,
  1.40828565e-01f, -3.44198085e-02f, -2.33016819e-01f, -4.90434933e-04f, 6.31020963e-02f, 3.51762660e-02f, -1.88872084e-01f, 1.32916301e-01f, 1.63680136e-01f, 3.56498510e-02f,
  -1.28966704e-01f, 4.26684804e-02f, 2.72265039e-02f, 1.88931286e-01f, 1.34924695e-01f, 2.22052544e-01f, 8.83249789e-02f, -1.07329778e-01f, -5.53494021e-02f, 1.97553113e-01f,
  -6.33602664e-02f, -7.68300965e-02f, 6.06801100e-02f, 2.30604690e-02f, 1.26775488e-01f, 1.07717283e-01f, -3.64196524e-02f, -4.50138301e-02f, 4.39121723e-02f, 2.72687733e-01f,
  -1.34255603e-01f, 1.09603778e-01f, -2.08696231e-01f, -1.93900436e-01f, 2.55541444e-01f, 8.82278234e-02f, -5.97925112e-02f, -8.90793949e-02f, 9.15486142e-02f, -1.94712169e-02f,
  6.87324023e-03f, -1.61403399e-02f, 1.13777384e-01f, 1.12131745e-01f, -3.20300646e-02f, 6.06546924e-02f, -1.08203441e-01f, 6.59058541e-02f, 1.34296745e-01f, -2.84633623e-03f,
  -1.02358097e-02f, -1.15477227e-01f, 2.69079339e-02f, -1.41730392e-02f, 6.42445162e-02f, -1.52718872e-02f, 2.82954257e-02f, 2.27185532e-01f, 3.59429941e-02f, -1.94415897e-01f,
  -3.72899580e-03f, 2.03161225e-01f, 7.09603354e-02f, 6.30585104e-02f, 2.22556084e-01f, -1.52991384e-01f, -1.05421811e-01f, 2.47758120e-01f, 4.96689081e-02f, 1.78249881e-01f,
  -2.17334241e-01f, -1.47749081e-01f, 1.23731479e-01f, 8.60125571e-02f, -3.47356983e-02f, 1.10279500e-01f, 1.71479374e-01f, -5.22508286e-02f, -3.20076138e-01f, 2.45790258e-02f,
  -2.40157112e-01f, 1.56793773e-01f, 1.97830856e-01f, -1.71793565e-01f, -8.68661106e-02f, -9.89663973e-02f, -1.15111500e-01f, 4.07337351e-03f, 1.52578846e-01f, 1.02098860e-01f,
  1.36641845e-01f, 1.64834261e-01f, 1.82948619e-01f, 7.21452460e-02f, -2.10346997e-01f, -9.58509371e-03f, -3.11039150e-01f, -1.38543136e-02f, 8.71003792e-02f, 5.64909428e-02f,
  2.94515416e-02f, 6.74216375e-02f, 1.20563991e-01f, 1.15641821e-02f, 1.32010996e-01f, 4.49569821e-02f, 1.42990366e-01f, -4.73226793e-03f, -1.04707126e-02f, 1.73353180e-02f,
  1.41437605e-01f, 3.83779407e-02f, -3.53187323e-02f, 7.56687447e-02f, 7.19101653e-02f, -8.29198807e-02f, -6.38420135e-02f, 1.13116957e-01f, -6.34484589e-02f, -2.13487491e-01f,
  1.55615166e-01f, 3.28440294e-02f, 5.36731668e-02f, 2.02430021e-02f, 1.35060653e-01f, 5.36225513e-02f, -2.43744954e-01f, 1.01934947e-01f, -1.10292330e-01f, -1.72616377e-01f,
  -3.73292379e-02f, 8.25954378e-02f, 3.05081904e-02f, 1.70608208e-01f, -1.33024797e-01f, -4.78962176e-02f, -1.57884769e-02f, 4.24032509e-02f, 1.59332007e-01f, 7.02300817e-02f,
  1.32243901e-01f, 2.54859090e-01f, -2.38427922e-01f, 3.93076353e-02f, -1.32337278e-02f, 1.52412966e-01f, 4.69328240e-02f, -2.03812256e-01f, -1.65487584e-02f, -1.81012884e-01f,
  -3.02444220e-01f, 7.62112141e-02f, 2.33654007e-01f, 2.04019621e-01f, -1.48618758e-01f, -1.22195657e-03f, -8.74114633e-02f, 2.38371253e-01f, 9.07718986e-02f, 8.04303661e-02f,
  -2.12683275e-01f, -7.99098462e-02f, 2.25184232e-01f, 9.61621553e-02f, 3.74426022e-02f, 3.70774232e-02f, -3.63800526e-02f, 5.41658513e-02f, -5.85517520e-03f, 9.63838249e-02f,
  7.84351602e-02f, 1.13616258e-01f, -8.28902647e-02f, 1.57160491e-01f, 1.16224967e-01f, 8.00295621e-02f, 1.50200725e-02f, -1.81169752e-02f, 4.66105752e-02f, 1.45310089e-01f,
  -8.66741166e-02f, 1.47224322e-01f, 1.64151922e-01f, -2.00104266e-01f, -5.19137233e-02f, -2.31762201e-01f, 2.05428749e-01f, 1.14861690e-01f, 2.47452736e-01f, -1.70410901e-01f,
  -7.33620673e-02f, -2.76919067e-01f, -2.11707398e-01f, -2.26178616e-01f, 9.05546248e-02f, -6.19682074e-02f, 9.76852849e-02f, 3.48861963e-02f, 1.20716974e-01f, 5.39360754e-02f,
  -2.11812213e-01f, 2.57503781e-02f, 1.05511069e-01f, 2.83068091e-01f, 5.72364405e-02f, -8.39287862e-02f, -2.77262870e-02f, -9.50590819e-02f, -1.00587972e-01f, 6.95642978e-02f,
  -9.28217173e-02f, -1.53683752e-01f, 1.15874477e-01f, 1.33009434e-01f, 6.09250665e-02f, 4.81983759e-02f, 9.83313695e-02f, 6.76243976e-02f, -1.31201610e-01f, -1.96568757e-01f,
  -1.68089807e-01f, 2.53342420e-01f, -2.61941012e-02f, -1.98456779e-01f, -1.89728811e-01f, 1.52709171e-01f, -5.98361716e-02f, 1.55278772e-01f, 2.88275760e-02f, 2.58699954e-01f,
  1.19393393e-01f, -1.14785343e-01f, 1.98097497e-01f, 2.47969568e-01f, -1.41420484e-01f, -6.38714582e-02f, -3.42984349e-02f, 2.31767613e-02f, 3.12427338e-03f, 1.40551493e-01f,
  -9.63610113e-02f, 1.00749962e-01f, 1.16488680e-01f, -7.99386799e-02f, 5.95692210e-02f, -8.15924630e-02f, -1.05046973e-01f, 1.40283466e-03f, -5.72829321e-02f, -8.47952291e-02f,
  -1.73972696e-02f, 2.19256371e-01f, -8.62322822e-02f, -1.13989107e-01f, 1.50157273e-01f, -9.95793417e-02f, -2.34298825e-01f, -5.47461994e-02f, 1.71820521e-01f, -1.83259379e-02f,
  1.15083836e-01f, -1.39247730e-01f, 1.83651447e-01f, 1.76839065e-02f, -1.59499422e-01f, 8.28955919e-02f, 9.22668651e-02f, 5.49227223e-02f, -1.36444971e-01f, -7.00874031e-02f,
  1.58038512e-01f, 1.11939451e-02f, -1.52880698e-01f, -2.33114907e-03f, 3.78867462e-02f, 7.72586092e-02f, -1.96813092e-01f, -2.55501002e-01f, 8.08440968e-02f, -4.44986857e-02f,
  -2.53510863e-01f, 1.27232015e-01f, -4.23763283e-02f, -7.40597025e-02f, 1.77729264e-01f, -9.15988311e-02f, 1.77309394e-03f, -1.30928785e-01f, 2.52428561e-01f, 2.57330030e-01f,
  1.92283183e-01f, 1.08783126e-01f, -1.97633743e-01f, 2.44304705e-02f, 4.70255353e-02f, -5.49901351e-02f, -2.15943232e-01f, -1.29145667e-01f, -2.41684616e-02f, -5.88038899e-02f,
  -1.01900004e-01f, -9.98999085e-03f, -1.79208949e-01f, 3.08077782e-02f, 2.97120046e-02f, -7.32609034e-02f, -1.02152355e-01f, -1.64382517e-01f, -2.65535831e-01f, -4.32308577e-02f,
  -2.04375293e-02f, 5.95821589e-02f, -1.47505164e-01f, 7.52525851e-02f, -7.06461146e-02f, -4.67726886e-02f, -2.20282406e-01f, -8.78580660e-02f, 1.91652204e-03f, -1.85097396e-01f,
  -3.53333130e-02f, 2.76733283e-03f, 8.69053975e-02f, 3.84764671e-02f, -2.16531977e-01f, 2.05844432e-01f, -3.49305896e-03f, 1.30415648e-01f, 2.03457903e-02f, 2.64938056e-01f,
  1.44618163e-02f, 1.08243249e-01f, -2.16911346e-01f, -2.18923241e-01f, -1.82764769e-01f, -4.55584712e-02f, -7.39718555e-03f, -1.11651700e-02f, 2.12427452e-01f, -9.85634625e-02f,
  -2.89741784e-01f, 9.17922258e-02f, 1.83636129e-01f, -9.92088243e-02f, -1.55965015e-01f, 1.89097568e-01f, 2.67648064e-02f, -1.67030878e-02f, 2.14826867e-01f, -5.09890877e-02f,
  -2.72451323e-02f, -5.39351776e-02f, -1.23334534e-01f, -1.04140431e-01f, 1.07971825e-01f, 2.19854817e-01f, -3.11184190e-02f, 3.95305865e-02f, -1.07978635e-01f, -1.71424970e-01f,
  1.29833579e-01f, 2.14470886e-02f, -1.57771543e-01f, -1.86304394e-02f, -1.40920058e-01f, 1.06511213e-01f, -1.65443406e-01f, 5.84203042e-02f, 1.31281074e-02f, 9.81360450e-02f,
  -1.07010476e-01f, 2.87906509e-02f, -1.14751525e-01f, -5.50475568e-02f, 3.65129225e-02f, 8.54139850e-02f, -1.22240663e-01f, -1.59483239e-01f, 9.99504328e-02f, 2.22625092e-01f,
  1.50407225e-01f, -1.34680837e-01f, 3.08460087e-01f, 3.71633992e-02f, -3.32289375e-02f, 1.23821422e-01f, 3.85601297e-02f, -2.58237161e-02f, -1.65869165e-02f, -1.41263485e-01f,
  1.52506173e-01f, 7.99168497e-02f, 3.94403413e-02f, 2.63367236e-01f, 5.11591882e-03f, -1.02080358e-02f, -1.33350089e-01f, 2.75356666e-04f, 2.15618268e-01f, 1.64072350e-01f,
  9.90135781e-03f, -1.26926094e-01f, 1.21702366e-02f, 2.02315986e-01f, -1.73042595e-01f, -2.16342151e-01f, 1.41002029e-01f, -2.06068814e-01f, -1.25619322e-01f, 9.72613320e-02f,
  -3.42207216e-02f, -4.70249429e-02f, -1.88068766e-02f, -4.25115228e-03f, -2.49668106e-01f, -2.56211489e-01f, 2.33517289e-01f, -2.30110392e-01f, 1.21664219e-01f, 2.19081882e-02f,
  1.38597051e-02f, -1.40383556e-01f, 3.19369286e-02f, -1.23612359e-02f, -6.34020641e-02f, -2.01305687e-01f, -8.46407027e-04f, -3.27438377e-02f, -9.18941479e-03f, -1.61976740e-02f,
  6.76716724e-03f, -3.13776061e-02f, 6.09100200e-02f, 2.03236267e-02f, -1.06203772e-01f, -7.65905827e-02f, -1.35050058e-01f, -2.62216479e-02f, 1.24733806e-01f, 1.88789889e-01f,
  -5.74946292e-02f, 7.25743398e-02f, -1.81500778e-01f, -1.52647674e-01f, -1.74742714e-01f, 6.23800047e-02f, -2.15189099e-01f, 2.00115398e-01f, 1.77146286e-01f, -5.89819103e-02f,
  -1.44542544e-03f, 9.24729332e-02f, 5.52476756e-02f, 2.45758817e-01f, -4.21308018e-02f, -6.86509237e-02f, 1.33989960e-01f, -2.61531740e-01f, 1.06520496e-01f, -1.47313207e-01f,
  3.67566720e-02f, -1.63934603e-01f, -2.93816864e-01f, -1.92356646e-01f, 1.64641991e-01f, 1.41105220e-01f, 1.93979274e-02f, -1.16215318e-01f, 2.06190437e-01f, 2.15427384e-01f,
  2.63131951e-04f, -1.60290644e-01f, 1.50638863e-01f, -1.65570840e-01f, -1.08979687e-01f, 1.97788581e-01f, 5.31943925e-02f, 4.58255336e-02f, 8.18523094e-02f, 1.29991084e-01f,
  -1.32743135e-01f, -1.86757848e-01f, -1.33237377e-01f, 1.42627373e-01f, -7.79766291e-02f, 2.29255892e-02f, 7.64601678e-02f, -8.24901760e-02f, -7.38525167e-02f, -2.28638761e-02f,
  1.49714760e-02f, 4.69865911e-02f, -1.27482533e-01f, 6.40158802e-02f, 4.96551171e-02f, 4.47124578e-02f, 1.03025071e-01f, 6.70033880e-03f, 1.11590698e-01f, 6.74305186e-02f,
  -7.53250346e-02f, -2.73279119e-02f, -1.01768754e-01f, 1.27712591e-02f, -2.66848922e-01f, -2.32445076e-02f, 1.60059571e-01f, -1.62158936e-01f, -1.29900649e-01f, -1.66291073e-01f,
  1.62453979e-01f, -2.64395699e-02f, -1.04063511e-01f, 4.68572862e-02f, -5.45551814e-02f, -5.53208515e-02f, -1.04547024e-01f, -2.42816545e-02f, 4.11686115e-02f, 2.64117926e-01f,
  -2.22101226e-01f, 1.44779563e-01f, -7.62895048e-02f, 2.24240601e-01f, -1.78033590e-01f, -2.78072000e-01f, 2.07040653e-01f, -1.29383042e-01f, 1.93501666e-01f, 1.17495932e-01f,
  6.52720928e-02f, 2.25616083e-01f, -1.14806093e-01f, -2.71058921e-02f, 1.98009863e-01f, -8.59087110e-02f, -1.09753557e-01f, -2.02545583e-01f, -1.12893403e-01f, 4.02801670e-02f,
  -1.20233670e-01f, -9.70458165e-02f, -2.28232667e-01f, -8.21243823e-02f, 1.71720330e-02f, -9.13272575e-02f, 1.80999771e-01f, -8.71430188e-02f, -1.30630508e-01f, -3.88617441e-02f,
  -1.06509209e-01f, 1.17597885e-01f, 7.37906545e-02f, -1.10326156e-01f, -5.12856841e-02f, 8.28496069e-02f, -8.89402777e-02f, 1.29966540e-02f, -8.95501673e-02f, 2.75658462e-02f,
  2.50361394e-02f, 8.20665527e-03f, 9.92868617e-02f, -1.50404405e-02f, 1.72902241e-01f, 7.56342709e-03f, 5.19636348e-02f, 1.30557269e-01f, 1.53277308e-01f, -2.27055579e-01f,
  -4.26241457e-02f, 1.80373922e-01f, 2.13102207e-01f, -1.37044221e-01f, -7.48572201e-02f, 9.36765820e-02f, -1.81785196e-01f, 2.23124459e-01f, -9.14731696e-02f, -1.58809960e-01f,
  2.50973050e-02f, -6.86347708e-02f, 2.68900633e-01f, 3.26076187e-02f, -1.88411981e-01f, -5.16091771e-02f, 1.20561965e-01f, 1.76191822e-01f, 1.65935576e-01f, 3.34640071e-02f,
  7.73332044e-02f, -5.57125434e-02f, -1.42590702e-01f, -2.18092978e-01f, -2.21124157e-01f, 1.51967868e-01f, 2.31620178e-01f, 6.24630488e-02f, 7.45981187e-02f, -4.80086468e-02f,
  2.96734244e-01f, -3.55125740e-02f, -1.73532143e-01f, -1.19099237e-01f, -2.51740843e-01f, 1.06981337e-01f, 2.84593135e-01f, -1.32884413e-01f, 2.21340477e-01f, 2.00993493e-02f,
  -1.38491094e-01f, -1.86729729e-01f, 8.33187252e-02f, 8.30147862e-02f, 9.38960090e-02f, -1.15445875e-01f, 9.60252732e-02f, 7.63554499e-02f, 9.96691361e-02f, 1.34717450e-01f,
  1.98623855e-02f, -1.15848176e-01f, -2.32925322e-02f, 8.39717537e-02f, -9.05928984e-02f, 9.58498493e-02f, 1.55775636e-01f, -7.00444058e-02f, 1.54478177e-01f, -2.89563239e-02f,
  1.35317286e-02f, 7.47647360e-02f, -1.44170541e-02f, -2.99835894e-02f, -2.89407372e-01f, 1.78082660e-02f, -8.04855376e-02f, -9.59543660e-02f, 1.69489101e-01f, 2.89357096e-01f,
  5.27774505e-02f, 2.03879640e-01f, 1.60517141e-01f, -8.73000696e-02f, 1.91783652e-01f, 1.94163665e-01f, 1.09716386e-01f, 1.74170062e-01f, -1.34120405e-01f, 8.27185884e-02f,
  1.87372267e-02f, 7.30703771e-02f, -7.67132640e-02f, -2.77077239e-02f, -3.57314087e-02f, -7.94458389e-02f, 1.81315094e-01f, -6.65876567e-02f, -1.45764574e-01f, 7.06203580e-02f,
  -2.90778801e-02f, -1.76657438e-01f, 3.68026309e-02f, -1.82424068e-01f, -2.70420641e-01f, -1.95376024e-01f, -8.10161158e-02f, 2.30344117e-01f, 2.68497884e-01f, -2.28151336e-01f,
  7.54851699e-02f, 2.20570222e-01f, 1.18977994e-01f, -1.48843840e-01f, -1.37395993e-01f, -1.88459709e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.89756596e-01f, 2.69591268e-02f, 1.45984054e-01f, 9.59304869e-02f, 1.64239824e-01f, 6.80988207e-02f, 1.73319191e-01f, 3.11347663e-01f, 2.22949609e-02f, 1.22475341e-01f,
  2.03901678e-01f, 1.10037282e-01f, 2.66164571e-01f, 1.74893424e-01f, 3.51184666e-01f, 2.24160597e-01f, 2.99541503e-01f, 1.42579049e-01f, 7.84899741e-02f, -1.44881696e-01f,
  3.94759059e-01f, -4.47976887e-01f, 2.96263486e-01f, 2.10471556e-01f, 2.63705492e-01f, -7.30438381e-02f, -2.34636068e-01f, -3.25690329e-01f, -1.38160139e-01f, -3.00393879e-01f,
  -8.61535594e-02f, -3.79005313e-01f, 3.35518658e-01f, -2.50265449e-01f, 1.22482933e-01f, 8.82025529e-03f, -3.59237462e-01f, -1.80628106e-01f, 1.10478230e-01f, 3.69767696e-01f,
  3.22598487e-01f, -7.15916529e-02f, 1.80020064e-01f, -1.49501354e-01f, -1.43597782e-01f, -9.49023589e-02f, -2.85207391e-01f, -1.07418243e-02f, 3.86104822e-01f, 7.28816167e-02f,
  -3.26587170e-01f, 3.21415395e-01f, 1.88826993e-01f, 3.75133485e-01f, -4.35958475e-01f, -1.89974025e-01f, -2.19672024e-01f, 3.69166583e-01f, 1.92942008e-01f, -6.86907470e-02f,
  -1.74097955e-01f, 4.37173098e-01f, 6.35264888e-02f, -1.04573563e-01f, -8.92603919e-02f, 1.62354335e-01f, 2.20495969e-01f, 4.46468256e-02f, -1.76956095e-02f, -2.62855321e-01f,
  1.52476713e-01f, 2.27868900e-01f, 1.53999642e-01f, -4.04810719e-02f, 5.18136322e-02f, -1.56633809e-01f, 3.04836836e-02f, 2.48687685e-01f, 1.57409962e-02f, 1.69353381e-01f,
  -1.42495409e-01f, 1.75069779e-01f, 1.43769935e-01f, -2.93400019e-01f, -2.39884868e-01f, 5.57266884e-02f, 2.94951171e-01f, -2.53706306e-01f, 2.42831148e-02f, -6.28288537e-02f,
  -2.43751405e-04f, -2.52593517e-01f, -2.53890097e-01f, -2.91679591e-01f, -7.09870085e-02f, -2.20109671e-01f, -1.74600214e-01f, 1.72490761e-01f, -4.11394425e-02f, 4.67016965e-01f,
  9.41664539e-03f, -4.10914749e-01f, 1.44343585e-01f, -5.21244742e-02f, -4.40088063e-01f, 1.95544869e-01f, 4.75969017e-01f, 2.28767917e-01f, 3.35279942e-01f, -1.08210310e-01f,
  -1.94435984e-01f, 4.25327867e-01f, -1.39466226e-01f, 2.67678767e-01f, 2.96889752e-01f, -2.67926306e-01f, 2.53900826e-01f, -5.42759240e-01f, 2.08621308e-01f, -1.68823853e-01f,
  1.21377744e-02f, -9.49298590e-02f, 4.49138731e-02f, 7.14423358e-02f, 1.01600677e-01f, -5.65421320e-02f, 9.32973474e-02f, 2.98049688e-01f, -3.32856225e-03f, 1.72476292e-01f,
  2.95759469e-01f, 2.05274578e-02f, 9.06717107e-02f, 3.08054209e-01f, -4.00572037e-03f, 1.64569601e-01f, 2.22223461e-01f, 2.77449489e-01f, 1.10826716e-01f, 2.71148652e-01f,
  2.13186115e-01f, 2.16005251e-01f, 2.48654708e-01f, 1.01530261e-01f, -4.90855239e-02f, 1.69576272e-01f, -1.21692512e-02f, 1.19318374e-01f, -3.17326963e-01f, -2.93183863e-01f,
  4.01128381e-01f, 7.71344453e-02f, 5.75021356e-02f, -4.35303897e-01f, 3.42780441e-01f, -9.89166051e-02f, -8.23418424e-02f, -3.18448395e-02f, -1.84559017e-01f, 2.98737109e-01f,
  -2.64758795e-01f, 9.44125056e-02f, -1.13071896e-01f, 1.72087386e-01f, -2.50467509e-02f, 4.02758867e-01f, 4.64054979e-02f, 5.39563954e-01f, -3.92271988e-02f, -1.41286671e-01f,
  -3.82740377e-03f, 5.62018901e-02f, -3.73614192e-01f, 1.31426277e-02f, 2.90021747e-01f, -8.76143482e-03f, 6.56132549e-02f, 1.95078567e-01f, 2.76504159e-01f, -5.00036329e-02f,
  1.84921324e-01f, 4.46951807e-01f, 7.23068640e-02f, -3.33747476e-01f, -1.33038806e-02f, 4.31862026e-01f, -3.08890730e-01f, -2.91903228e-01f, 6.14647605e-02f, -2.57438272e-01f,
  2.50296146e-01f, 1.35521308e-01f, 3.59140598e-04f, 1.30059317e-01f, 3.97342071e-02f, 1.84181705e-01f, 2.64010906e-01f, 2.46325899e-02f, 1.69869155e-01f, 1.92636978e-02f,
  2.00350106e-01f, -1.26942709e-01f, 1.60060018e-01f, 7.42975399e-02f, -7.02963471e-02f, 2.50017285e-01f, 2.37472326e-01f, 1.41056001e-01f, 1.63142055e-01f, 1.33923590e-01f,
  4.58623283e-02f, -4.30783391e-01f, 7.78589100e-02f, 3.13700512e-02f, 1.12064511e-01f, 1.84623018e-01f, 2.25198403e-01f, 3.41028541e-01f, -4.16085809e-01f, -4.25399914e-02f,
  -3.04045647e-01f, -3.07726175e-01f, 5.80981597e-02f, -3.01531076e-01f, 2.58341432e-01f, -8.80776644e-02f, 2.29327917e-01f, -4.15200964e-02f, -3.45939040e-01f, -3.46909523e-01f,
  3.64833325e-01f, -1.84898481e-01f, -1.11305974e-01f, 3.72176315e-03f, 7.71269500e-02f, -7.95038640e-02f, 4.17428613e-01f, 1.60077870e-01f, 6.54675290e-02f, 2.33588681e-01f,
  1.27374649e-01f, 2.20920574e-02f, -4.71212089e-01f, 1.80917829e-01f, -1.97646499e-01f, -1.70497864e-01f, -3.30871582e-01f, 9.81093496e-02f, -3.87385517e-01f, -2.47790143e-01f,
  2.69651681e-01f, 2.16780782e-01f, 1.20978737e-02f, 4.16269273e-01f, 2.88734913e-01f, -9.90100205e-02f, 1.75546855e-01f, 1.37145117e-01f, 2.84475207e-01f, -2.95172520e-02f,
  1.74387962e-01f, 1.22516841e-01f, 2.81734735e-01f, 2.88557261e-01f, 1.19539559e-01f, 1.66334182e-01f, 2.69788325e-01f, -2.52599884e-02f, -2.29788711e-03f, 3.03208768e-01f,
  3.52958262e-01f, 1.32150024e-01f, 2.67052382e-01f, 2.54914127e-02f, 1.88211784e-01f, 1.65287346e-01f, 6.56180456e-02f, -3.61792684e-01f, 2.23207369e-01f, 1.32284695e-02f,
  3.66997272e-01f, -3.55266690e-01f, 2.12874040e-01f, 2.51332790e-01f, -1.53408557e-01f, 8.60128328e-02f, -2.21711695e-01f, -5.02918184e-01f, 2.53540762e-02f, -2.20598578e-01f,
  2.37022698e-01f, 3.60902399e-01f, -4.03628916e-01f, -5.23359403e-02f, 3.96188408e-01f, 3.08891416e-01f, -2.49902815e-01f, 1.03856906e-01f, 5.24572849e-01f, 4.27924879e-02f,
  1.22753933e-01f, -1.96769670e-01f, -4.02217388e-01f, 5.13525486e-01f, 4.59168136e-01f, -8.82401019e-02f, 1.14284284e-01f, -2.85370857e-01f, -1.74929071e-02f, -2.98581451e-01f,
  1.56439133e-02f, -1.92436010e-01f, -3.96991283e-01f, 1.35370744e-02f, 2.27376804e-01f, 2.58230865e-01f, 3.10908496e-01f, -2.71044701e-01f, -5.28193712e-02f, 6.43295096e-03f,
  2.79168934e-01f, 1.47671133e-01f, 3.16658229e-01f, -1.10122718e-01f, -3.69231105e-02f, -3.25601641e-03f, 1.62423655e-01f, 1.22077510e-01f, 1.68847144e-01f, -1.09260060e-01f,
  1.45360962e-01f, -1.71931326e-01f, 4.07372080e-02f, 6.88277483e-02f, 2.03586847e-01f, -9.18357912e-03f, 1.00969911e-01f, 2.86541414e-02f, 2.13054851e-01f, -1.51146933e-01f,
  5.13262190e-02f, -3.07108574e-02f, -3.00249532e-02f, -3.02733839e-01f, -7.01259300e-02f, -8.58472064e-02f, -2.47034192e-01f, -9.86097474e-03f, -2.79695421e-01f, -2.17608660e-01f,
  3.79075855e-01f, -3.62772316e-01f, 1.73941091e-01f, 5.90208769e-01f, 9.55494195e-02f, 4.76572454e-01f, -8.35252330e-02f, -4.80552971e-01f, 3.16340685e-01f, -1.81835845e-01f,
  -3.11155915e-01f, -2.70514607e-01f, 9.50127766e-02f, -2.31230482e-01f, 1.40610859e-01f, -2.19248608e-01f, -1.35435149e-01f, -6.81339279e-02f, 1.98299900e-01f, 2.72313535e-01f,
  -6.10074922e-02f, -3.66172612e-01f, -1.90333530e-01f, -3.30186099e-01f, -2.97630608e-01f, -3.09033692e-01f, -6.62717409e-03f, -2.97353685e-01f, 4.78211433e-01f, 3.29859674e-01f,
  -7.55284429e-02f, -1.85566947e-01f, -1.22937009e-01f, 5.18744707e-01f, 3.06460917e-01f, 2.72929847e-01f, 1.12887993e-01f, 1.97367147e-01f, 1.46818995e-01f, 2.14702696e-01f,
  2.84578890e-01f, 1.77395359e-01f, 2.68225074e-01f, -1.58111304e-02f, 1.77423388e-01f, 3.17377687e-01f, 1.94775850e-01f, 2.42501408e-01f, 3.15842986e-01f, 5.77080064e-02f,
  3.42334569e-01f, 9.30487514e-02f, 1.72388420e-01f, 6.91695809e-02f, -1.11831650e-02f, -3.32371086e-01f, -2.58223265e-01f, 2.39752322e-01f, -6.70969486e-02f, 1.72385741e-02f,
  1.87210426e-01f, 7.39404112e-02f, -2.01552346e-01f, 2.82914162e-01f, 7.23363087e-02f, -1.72020644e-01f, 3.04483503e-01f, -1.84388667e-01f, 3.18037629e-01f, -5.01354970e-02f,
  -3.25973988e-01f, -8.59210491e-02f, 1.83163255e-01f, 1.16109222e-01f, 2.99115807e-01f, 1.16785541e-01f, 2.66717941e-01f, 6.84301229e-03f, -2.04213336e-01f, -2.64445990e-01f,
  -1.30633190e-01f, -1.08393943e-02f, 2.37423733e-01f, -2.74572641e-01f, 2.04472125e-01f, 9.04582515e-02f, 4.19537909e-02f, -6.90873489e-02f, 1.90850813e-02f, -5.52301332e-02f,
  -1.57925442e-01f, -2.43180141e-01f, 2.36121535e-01f, -1.35595828e-01f, 2.93276340e-01f, 1.14570215e-01f, -1.15178555e-01f, -1.28946558e-01f, -7.14177079e-03f, 1.63876653e-01f,
  -4.30873483e-02f, 3.87195796e-02f, -4.05415036e-02f, 7.92342126e-02f, 1.31316125e-01f, -1.82191329e-03f, 1.43476903e-01f, 2.14982480e-01f, -2.02613622e-01f, 2.70861000e-01f,
  1.82475090e-01f, 2.95857769e-02f, -1.95858870e-02f, 1.03524946e-01f, 7.25659654e-02f, -6.88664690e-02f, -9.43732560e-02f, 1.93027139e-01f, -4.11304653e-01f, 2.84419626e-01f,
  -2.30394170e-01f, -5.40486053e-02f, -3.66164565e-01f, -1.12931646e-01f, 4.14124787e-01f, 3.56426761e-02f, 1.20159023e-01f, 2.72830635e-01f, 2.41079137e-01f, 2.04950094e-01f,
  -3.42875302e-01f, -3.80217843e-03f, -4.94586341e-02f, -1.69080988e-01f, 1.00916728e-01f, 2.34315991e-01f, 9.59799513e-02f, -3.20756547e-02f, -8.80673528e-02f, 2.06847712e-01f,
  2.22002715e-01f, 1.31142005e-01f, -3.86005938e-02f, 1.76317208e-02f, 1.01876222e-01f, 2.01979935e-01f, -1.95432931e-01f, 8.56003463e-02f, 5.15841663e-01f, -1.56827420e-01f,
  -3.84226888e-02f, -1.12891361e-01f, 4.20812368e-01f, 2.31795430e-01f, 4.81512308e-01f, -1.13354512e-01f, -2.41385490e-01f, -2.42569000e-02f, 4.05636609e-01f, 3.96563932e-02f,
  1.87043652e-01f, 1.13322526e-01f, 1.13170199e-01f, 8.60910565e-02f, 1.34553649e-02f, 2.75279433e-01f, 6.74611330e-02f, -3.35072093e-02f, 4.78693061e-02f, 5.68946078e-02f,
  -7.01604635e-02f, 2.33254477e-01f, 1.91830695e-01f, 7.55760744e-02f, -1.37238093e-02f, 1.41306333e-02f, 7.52933025e-02f, 2.32175514e-01f, 2.41515890e-01f, 1.49711460e-01f,
  1.47920595e-02f, -7.98008218e-03f, 1.74067646e-01f, -1.55626431e-01f, -3.27299014e-02f, 1.75899088e-01f, 2.61635575e-02f, 3.51264387e-01f, -4.23384517e-01f, 2.18991265e-02f,
  5.39414994e-02f, -6.88444749e-02f, -1.39019610e-02f, -2.47046441e-01f, 2.34054431e-01f, -4.23137873e-01f, 2.25622416e-01f, -2.20522568e-01f, -5.33565842e-02f, -4.55427647e-01f,
  2.51243889e-01f, 7.54010305e-02f, 2.30013758e-01f, -1.34418979e-01f, 1.54665425e-01f, -3.66503522e-02f, 5.41036606e-01f, 2.59044558e-01f, 9.35546681e-03f, 4.57667470e-01f,
  5.56909919e-01f, 1.92524910e-01f, -2.44850367e-01f, 3.67042720e-01f, -4.48588058e-02f, 7.05760196e-02f, -1.57890812e-01f, 1.78417549e-01f, -2.31907800e-01f, 2.15651900e-01f,
  3.74275386e-01f, 2.95051515e-01f, -5.13328202e-02f, 5.09450793e-01f, -7.04222033e-03f, -2.00231805e-01f, 1.21753618e-01f, -4.34809178e-02f, 1.11553185e-01f, -5.56433648e-02f,
  1.66233316e-01f, 4.80577536e-02f, 1.55101985e-01f, 1.44224480e-01f, 2.34552905e-01f, -1.72109250e-02f, 3.76635939e-02f, -8.59416798e-02f, 9.99696031e-02f, 1.84638444e-02f,
  1.11164162e-02f, 1.82847694e-01f, 2.46022686e-01f, -1.81963644e-03f, 5.44121265e-02f, 1.36575699e-01f, -2.24875867e-01f, 1.55477136e-01f, -3.88276517e-01f, -9.59162042e-02f,
  -3.22073251e-01f, 1.24129213e-01f, -3.41909289e-01f, 2.81847417e-01f, 7.80369639e-02f, -9.40157846e-03f, 1.40824884e-01f, -1.93066657e-01f, -2.08108410e-01f, -4.58370000e-02f,
  1.66042209e-01f, -1.90909375e-02f, -1.15121245e-01f, -2.41175368e-01f, 4.89944033e-02f, -6.40090108e-02f, -2.01153621e-01f, -3.89916837e-01f, -2.15286076e-01f, -3.52735341e-01f,
  4.51190054e-01f, 1.84432432e-01f, 1.50560632e-01f, 4.12571937e-01f, 2.08025932e-01f, 2.08655193e-01f, 1.45141482e-01f, -1.55062869e-01f, -8.92405361e-02f, -1.56339064e-01f,
  -1.51161030e-01f, 2.72030890e-01f, -7.18541816e-02f, -2.06553727e-01f, 3.36903244e-01f, 2.58195013e-01f, 2.58499444e-01f, -3.25737268e-01f, 1.57969803e-01f, 5.42347692e-03f,
  -2.97022634e-03f, 1.66728035e-01f, 3.45149301e-02f, -1.54416680e-01f, 7.13564008e-02f, 2.81711102e-01f, 1.12239100e-01f, 9.64260027e-02f, 2.34220356e-01f, 9.67875123e-02f,
  -7.64373615e-02f, 3.64783555e-01f, 1.07296020e-01f, 1.32435694e-01f, 1.12857083e-02f, 1.16296373e-01f, -1.15507171e-01f, 2.10091412e-01f, 2.16123521e-01f, -1.29917234e-01f,
  -4.96661872e-01f, 1.18614323e-01f, 2.19804436e-01f, 1.39552414e-01f, -1.09235115e-01f, -2.49454394e-01f, 2.59693593e-01f, -2.31867343e-01f, -4.92938370e-01f, -2.73606747e-01f,
  2.67476916e-01f, 1.67865902e-02f, -3.95167440e-01f, 1.91656068e-01f, 1.13687575e-01f, 1.71032324e-01f, 4.09912914e-02f, 3.17404598e-01f, 3.58795285e-01f, 1.50557712e-01f,
  -4.39286441e-01f, 1.19385615e-01f, 4.33606386e-01f, 3.61843854e-01f, -2.21564636e-01f, -1.22856058e-01f, 4.76483971e-01f, -1.25945091e-01f, -3.72811407e-01f, 8.95622447e-02f,
  2.30355501e-01f, -3.43350828e-01f, 3.00826430e-02f, 1.68187395e-01f, 2.12161019e-01f, -4.55597013e-01f, 1.90587461e-01f, -4.00622236e-03f, -2.62333676e-02f, -5.23819625e-01f,
  5.29214799e-01f, -8.50363672e-02f, 4.14975494e-01f, 3.45498472e-01f, 1.75959691e-01f, -1.35849014e-01f, 1.10894859e-01f, 1.13365002e-01f, 2.53644705e-01f, 1.94197282e-01f,
  1.00095496e-01f, 2.33433008e-01f, 4.23873775e-02f, 1.66878194e-01f, 1.80115044e-01f, -3.32200639e-02f, 2.05936462e-01f, 7.93797001e-02f, 2.43370920e-01f, 1.82823941e-01f,
  2.17598215e-01f, 1.32423878e-01f, 6.97240373e-03f, 3.72260481e-01f, 4.79321778e-02f, -2.81830221e-01f, -3.18274349e-01f, 4.11721736e-01f, -3.65045387e-04f, -2.01031312e-01f,
  2.30820298e-01f, 2.16571391e-01f, 2.25353509e-01f, 3.01237255e-01f, 5.31373322e-02f, 1.45857841e-01f, 2.24784255e-01f, -2.66099066e-01f, 2.14314207e-01f, -2.44853705e-01f,
  -5.53633347e-02f, 3.11136127e-01f, -9.06622410e-02f, 3.46037865e-01f, 4.14888442e-01f, 3.83328344e-03f, -1.40185729e-01f, 1.45441487e-01f, -1.24676421e-01f, -9.83246565e-02f,
  -1.54966749e-02f, 7.27657154e-02f, 2.60990798e-01f, -6.48586527e-02f, 4.05425310e-01f, 6.16446324e-02f, 3.15721810e-01f, 5.06119072e-01f, 1.31209612e-01f, 6.37193471e-02f,
  1.02531716e-01f, 4.32242244e-01f, 2.87890524e-01f, -5.70603237e-02f, 1.56823248e-01f, -1.62379071e-01f, -2.24814087e-01f, -8.82457569e-02f, -2.63047349e-02f, 5.52140735e-02f,
  2.73205135e-02f, 1.23559274e-01f, 9.15786102e-02f, -5.77952340e-02f, 3.20069373e-01f, 1.68570593e-01f, 2.52715275e-02f, 8.73415917e-02f, 8.32801983e-02f, -8.61331597e-02f,
  1.45523325e-01f, 1.60369188e-01f, 9.79932621e-02f, 2.56263018e-01f, 1.50427409e-02f, 2.53176898e-01f, 3.23765576e-01f, -2.78865874e-01f, -2.36113399e-01f, -7.50201792e-02f,
  2.04201639e-01f, -3.59532624e-01f, 1.19578522e-02f, -1.31620513e-02f, -7.79965371e-02f, -3.10899347e-01f, -3.20105493e-01f, -3.88739645e-01f, 2.11819962e-01f, -2.02950388e-01f,
  -2.34258890e-01f, 3.56518507e-01f, -1.10505223e-01f, 3.99218291e-01f, -1.00080691e-01f, -4.49300677e-01f, 6.68530017e-02f, -1.54679557e-02f, -2.11058483e-01f, -7.05177337e-02f,
  2.88051784e-01f, -1.20961197e-01f, -1.41197398e-01f, -2.55572855e-01f, -2.26248309e-01f, 9.80911031e-02f, -1.81237444e-01f, 3.24092656e-01f, 1.19860090e-01f, 3.85855958e-02f,
  -1.99820280e-01f, -4.47192490e-01f, -8.34822804e-02f, -1.88182637e-01f, -6.47372454e-02f, -2.68251479e-01f, 1.46592990e-01f, 5.61186373e-02f, -1.04795240e-01f, 1.91294909e-01f,
  -3.62817422e-02f, 2.35811085e-01f, 8.34934488e-02f, 1.72691122e-01f, 3.24531406e-01f, 4.53636497e-02f, 1.29639432e-01f, 2.76133746e-01f, 2.72242904e-01f, 2.13307098e-01f,
  1.03998214e-01f, 3.13139141e-01f, 1.16581477e-01f, 4.22155678e-01f, 1.48620546e-01f, 1.99885339e-01f, 1.42563820e-01f, 2.10633390e-02f, 1.45896181e-01f, 8.18271190e-02f,
  2.56922934e-02f, -1.68721482e-01f, -3.15080523e-01f, -1.02876112e-01f, -7.78429583e-02f, -6.85930029e-02f, -3.31238210e-01f, -2.02193633e-01f, -8.58296677e-02f, 1.68772936e-01f,
  -2.66809523e-01f, 3.43532972e-02f, 1.96456000e-01f, -7.32547715e-02f, -2.65932769e-01f, 3.29373591e-02f, 1.64383262e-01f, 1.93920657e-01f, -5.69456220e-02f, 4.03327405e-01f,
  1.68015614e-01f, 4.35072184e-01f, -3.56355384e-02f, -2.07970679e-01f, -2.49357313e-01f, -1.86779425e-01f, 2.60043498e-02f, 4.13245022e-01f, 4.41617727e-01f, -7.06177428e-02f,
  3.06444377e-01f, 1.25837609e-01f, 2.48612277e-02f, -9.49956477e-02f, -3.03167105e-01f, 8.93780887e-02f, 9.67020392e-02f, 4.00612980e-01f, 2.30447635e-01f, 1.20543323e-01f,
  5.20356148e-02f, 3.08235556e-01f, 2.28795230e-01f, -2.92512238e-01f, 2.15539619e-01f, 1.10756636e-01f, -9.81565192e-02f, 2.98621863e-01f, -5.93566373e-02f, 7.16543794e-02f,
  1.12225777e-02f, 1.05146870e-01f, 9.31847095e-02f, 8.70788991e-02f, -9.32457298e-02f, 1.62421703e-01f, -4.23202291e-02f, -4.31234688e-02f, 7.09051862e-02f, 1.49581119e-01f,
  7.40801468e-02f, -3.57249491e-02f, -8.92120227e-02f, 9.43798944e-02f, 1.24173854e-02f, 3.19837213e-01f, 8.12706947e-02f, -2.78159976e-02f, -4.09045428e-01f, 2.87763178e-01f,
  6.59158640e-03f, 2.98309356e-01f, -3.45720708e-01f, 2.92659104e-01f, -6.94576651e-02f, 2.31670305e-01f, 1.73730016e-01f, -4.95671593e-02f, 5.32902125e-03f, -4.37868714e-01f,
  4.49964255e-01f, -3.58575195e-01f, -1.46451205e-01f, -1.38720581e-02f, 3.96878749e-01f, -5.08763492e-02f, 2.79317468e-01f, 1.83421552e-01f, 6.78498745e-02f, 2.67675787e-01f,
  8.77708122e-02f, 5.47348112e-02f, -2.42813438e-01f, 9.77701098e-02f, 2.00204641e-01f, -3.06082405e-02f, -8.09395686e-03f, 5.10231256e-02f, 6.45607188e-02f, 1.36366740e-01f,
  3.22910935e-01f, -3.14342797e-01f, -2.85734355e-01f, -5.31400405e-02f, 2.09839225e-01f, -3.90076131e-01f, 3.67641300e-01f, 5.46330512e-01f, -4.65916425e-01f, 3.04148532e-02f,
  3.56751323e-01f, 9.25444718e-03f, 2.12225184e-01f, 1.94481462e-01f, 2.57161885e-01f, 1.71763942e-01f, 3.00298601e-01f, 2.48571470e-01f, 9.22886804e-02f, 3.04549605e-01f,
  1.83236435e-01f, 2.49007508e-01f, 8.82551223e-02f, 2.01750144e-01f, 2.61754930e-01f, 9.60514396e-02f, 2.87321955e-01f, 7.09853992e-02f, 3.16364825e-01f, 3.79398674e-01f,
  -7.53255412e-02f, -1.26339048e-01f, -3.69703919e-01f, -3.18699688e-01f, -3.30334276e-01f, -2.53233671e-01f, 2.18856901e-01f, 3.55180353e-01f, 3.56470287e-01f, 2.15259939e-01f,
  1.29726544e-01f, 1.53801084e-01f, -5.92859723e-02f, 1.59336343e-01f, -2.20629454e-01f, 5.70044369e-02f, 1.19629838e-01f, 2.13488922e-01f, 1.41702235e-01f, 3.13525856e-01f,
  1.36760131e-01f, -1.46488041e-01f, -3.50606889e-01f, -1.82962894e-01f, -5.57533093e-02f, -1.48468718e-01f, -6.23449087e-02f, -4.89549115e-02f, 4.22412694e-01f, 2.17236385e-01f,
  3.40832531e-01f, -1.88848928e-01f, -4.59477603e-01f, -1.81481361e-01f, 1.03109114e-01f, 2.64309496e-01f, 4.78207797e-01f, -7.69784153e-02f, 2.68412322e-01f, 4.80903357e-01f,
  1.54308334e-01f, -2.97523141e-01f, -4.40705419e-01f, -7.57706463e-02f, 3.75134163e-02f, 1.32677674e-01f, 3.00995894e-02f, 1.23771653e-01f, 3.16178240e-02f, 6.77109417e-03f,
  -1.34950513e-02f, -1.31062437e-02f, 2.24112138e-01f, 7.40695223e-02f, 2.15681896e-01f, 3.00775975e-01f, 1.72132149e-01f, 2.17957154e-01f, 8.85132030e-02f, 3.45705450e-01f,
  1.54574484e-01f, 1.40588760e-01f, 1.35875404e-01f, -4.85368311e-01f, 6.81210682e-02f, -1.37197554e-01f, 4.39187109e-01f, 1.72676548e-01f, 4.26568389e-02f, 3.21905702e-01f,
  5.91731211e-03f, -5.31207681e-01f, -2.17315957e-01f, -4.51602727e-01f, 3.68247107e-02f, 8.50972086e-02f, 7.15028867e-02f, -2.54078627e-01f, 1.67728905e-02f, -1.40062375e-02f,
  1.95095614e-02f, -2.18246296e-01f, -1.43929005e-01f, -7.63566867e-02f, 1.10587567e-01f, -8.73839706e-02f, 2.06480131e-01f, 1.39962658e-01f, 1.40482895e-02f, 6.42023832e-02f,
  -6.03418201e-02f, 3.39988351e-01f, -3.44159275e-01f, 1.77061006e-01f, -7.80349001e-02f, 4.03036445e-01f, -2.92225301e-01f, 2.58282512e-01f, -2.08423629e-01f, 1.07799947e-01f,
  1.19616859e-01f, -2.10269481e-01f, 2.70375777e-02f, -1.73964784e-01f, -1.09362602e-02f, 4.05261815e-01f, 5.87057650e-01f, 1.23569429e-01f, 7.69233629e-02f, -2.60844350e-01f,
  9.11677331e-02f, 2.96849847e-01f, -3.45331319e-02f, -2.93393910e-01f, 1.83883652e-01f, 1.31328806e-01f, 1.54328331e-01f, -2.22365558e-03f, 2.88444072e-01f, -2.97507912e-01f,
  4.57882658e-02f, -8.04625675e-02f, 1.72302067e-01f, 1.35836422e-01f, 3.00527155e-01f, 2.60351561e-02f, 2.15358213e-02f, -2.69762099e-01f, 8.14849734e-02f, 3.70610386e-01f,
  -1.30063996e-01f, 6.41029552e-02f, -2.29735836e-01f, 6.15814209e-01f, -2.37900317e-01f, -2.22680420e-01f, 3.10570896e-01f, -6.41208440e-02f, 2.62595266e-01f, 3.85446727e-01f,
  2.20460653e-01f, 1.33648723e-01f, -3.02780807e-01f, -3.90627474e-01f, 4.59688842e-01f, -3.51629049e-01f, -4.13149267e-01f, -3.33287090e-01f, 4.43164498e-01f, 2.39295140e-01f,
  -1.88866034e-01f, 2.24609926e-01f, 4.71704930e-01f, 6.35957643e-02f, 3.85185070e-02f, 3.45209211e-01f, -3.69090229e-01f, 2.41261065e-01f, 3.50540191e-01f, 4.67813820e-01f,
  3.69033694e-01f, 5.28154848e-03f, 9.45741534e-02f, 3.36622834e-01f, 3.86137128e-01f, 1.08840682e-01f, 1.83422819e-01f, 9.12657753e-02f, -4.27573413e-01f, 3.78772587e-01f,
  8.28490183e-02f, -1.67997897e-01f, -3.00689936e-02f, -6.01167828e-02f, 2.46364504e-01f, -1.02947183e-01f, -3.60979915e-01f, -2.03935459e-01f, 2.72880226e-01f, 1.79741770e-01f,
  -7.42072985e-02f, 8.61259252e-02f, -7.03760097e-03f, -1.62017301e-01f, 3.25018108e-01f, 1.10537998e-01f, 4.16085832e-02f, 1.84954241e-01f, -3.43595982e-01f, 1.46870881e-01f,
  1.32294178e-01f, 1.58803329e-01f, -4.12917435e-01f, 1.17649414e-01f, -2.79003173e-01f, -4.88088757e-01f, -4.76530999e-01f, -3.03761184e-01f, -1.00823380e-01f, -1.82884485e-02f,
  2.06313148e-01f, -2.00025961e-01f, 2.90865064e-01f, 2.29376644e-01f, -4.65747148e-01f, 4.76756573e-01f, -3.90443712e-01f, 3.10249478e-01f, 3.42695326e-01f, -1.66121125e-01f,
  9.41096470e-02f, -1.94161713e-01f, -3.54967266e-01f, -3.98921639e-01f, -3.52035314e-01f, -6.11787677e-01f, -1.49313109e-02f, 9.81312916e-02f, 1.39360577e-01f, -1.11091577e-01f,
  1.67073980e-02f, 4.27133292e-01f, 3.22426081e-01f, -6.24419987e-01f, -1.50873095e-01f, -4.25215691e-01f, 8.67738500e-02f, -1.39483929e-01f, 2.14222297e-01f, -2.85591662e-01f,
  2.46556491e-01f, 1.10640764e-01f, -4.45187032e-01f, -2.75619149e-01f, -2.14155540e-01f, 3.49930793e-01f, 2.39868373e-01f, -6.35809749e-02f, -2.87315454e-02f, 5.62836789e-02f,
  -3.53858806e-03f, 7.04055652e-02f, 2.03103930e-01f, 2.01282531e-01f, 5.23850657e-02f, -4.36934084e-01f, 3.28450561e-01f, -2.37347364e-01f, -2.42844939e-01f, 1.13444112e-01f,
  1.03539526e-02f, -1.39975771e-01f, -6.80034384e-02f, 2.74961200e-02f, 3.51342484e-02f, 1.52170777e-01f, 9.48524401e-02f, -1.34429261e-01f, -3.87217492e-01f, 7.92853162e-02f,
  -2.85993606e-01f, -2.06426736e-02f, -5.62143743e-01f, 2.23495916e-01f, -1.27941310e-01f, 1.01170555e-01f, 3.37629855e-01f, -3.25853676e-01f, 4.19279188e-01f, 1.75597861e-01f,
  3.03092569e-01f, 9.01632831e-02f, -3.19383770e-01f, -2.76722461e-01f, 3.65652770e-01f, -4.37290341e-01f, -2.21879631e-01f, -1.61342204e-01f, -1.48048356e-01f, -5.10037065e-01f,
  1.29250407e-01f, -4.48885597e-02f, 1.03497975e-01f, -3.55244637e-01f, 1.78627163e-01f, -1.82473540e-01f, -2.75162131e-01f, -5.69410861e-01f, -2.50540197e-01f, -1.18361898e-01f,
  -3.36267650e-01f, -1.98701560e-01f, -3.23442340e-01f, -3.70719373e-01f, 4.30944920e-01f, 2.58002967e-01f, 5.21075986e-02f, -2.00851128e-01f, -5.51063955e-01f, 2.15895221e-01f,
  -1.11745343e-01f, -1.91466257e-01f, 3.30128185e-02f, 1.81942344e-01f, 1.27801104e-02f, -2.66230524e-01f, 1.30393490e-01f, 1.24707744e-01f, -1.57695841e-02f, 5.91132492e-02f,
  1.17177352e-01f, -2.35761166e-01f, 9.32791382e-02f, 1.02052525e-01f, 1.31284133e-01f, 2.71138042e-01f, 1.71267420e-01f, 7.42556900e-02f, -1.40636861e-02f, 4.16345239e-01f,
  -1.97477192e-01f, 1.32947385e-01f, -1.60862505e-01f, 2.94077694e-01f, 1.82419658e-01f, -3.79772455e-01f, 9.49207246e-02f, 3.34971786e-01f, 3.41317862e-01f, 3.17720830e-01f,
  -3.77634056e-02f, -1.60626963e-01f, -2.77538776e-01f, 1.18382219e-02f, 9.20499936e-02f, 2.50297189e-02f, 1.77301288e-01f, 5.26729263e-02f, -4.37139384e-02f, 2.02112600e-01f,
  2.40532577e-01f, 1.29787087e-01f, 1.60526067e-01f, 3.58657569e-01f, 4.27809000e-01f, -2.92538464e-01f, -2.23796457e-01f, 3.72831970e-01f, 2.77756423e-01f, 1.29867215e-02f,
  4.16707575e-01f, -1.33187294e-01f, 4.54903364e-01f, 6.19090572e-02f, 1.59678921e-01f, -1.80662543e-01f, -1.12468190e-01f, 4.01754439e-01f, 1.77328631e-01f, 1.51411286e-02f,
  2.99849182e-01f, -1.51980370e-01f, -2.69012637e-02f, 7.18587916e-03f, 1.95962787e-01f, 4.07908447e-02f, 6.94426522e-02f, 2.76434660e-01f, 1.44638807e-01f, 1.11800946e-01f,
  1.78628340e-01f, 1.92031369e-01f, 1.12736478e-01f, 3.00313443e-01f, 1.44978821e-01f, 2.67580241e-01f, 1.55437335e-01f, 2.04768986e-01f, 3.33056897e-01f, 2.85282344e-01f,
  1.96156669e-02f, 1.67649016e-01f, 1.71125844e-01f, -5.25161266e-01f, -1.15123115e-01f, 8.38223398e-02f, 3.91875416e-01f, -2.76445001e-01f, 2.62252182e-01f, -1.33083463e-01f,
  -4.77750078e-02f, -2.15684310e-01f, 2.16448963e-01f, -4.76772457e-01f, -3.75292748e-01f, 2.32146382e-01f, -3.82824719e-01f, 3.36243600e-01f, -2.71668911e-01f, 3.04131687e-01f,
  2.28953674e-01f, 1.77536577e-01f, 1.44571429e-02f, 4.86470819e-01f, 2.20625132e-01f, 3.84329915e-01f, 2.15343535e-02f, 3.68750393e-01f, 6.55761138e-02f, 3.24821979e-01f,
  4.97450590e-01f, 1.97334513e-02f, 2.00064883e-01f, 1.93332225e-01f, 3.34724062e-03f, 8.71541202e-02f, 4.34931070e-01f, 3.72498482e-01f, -3.76475453e-02f, 2.69375443e-01f,
  3.63303751e-01f, 3.93454283e-01f, -4.11712259e-01f, 1.77535772e-01f, -4.42343980e-01f, -3.15378010e-01f, 5.16938329e-01f, 3.69063735e-01f, 2.30482906e-01f, 1.20038074e-02f,
  -1.83033086e-02f, 1.54012060e-02f, 1.81793660e-01f, 1.65871620e-01f, -2.68606581e-02f, 1.01032387e-02f, 1.00360982e-01f, 3.49402279e-02f, 1.10047266e-01f, 4.82044928e-02f,
  4.50369194e-02f, -9.26613286e-02f, 1.31701648e-01f, -5.79503998e-02f, 9.36428979e-02f, 1.87654924e-02f, 3.78169343e-02f, -2.02129036e-01f, 3.28858942e-01f, 3.41996640e-01f,
  2.15836570e-01f, 3.47869843e-01f, 4.41310108e-02f, 2.25845978e-01f, 2.86606818e-01f, -4.52516377e-02f, 2.50998646e-01f, 4.82491329e-02f, -1.05613485e-01f, 3.24729323e-01f,
  1.05410933e-01f, 1.90566361e-01f, -1.77300155e-01f, -1.43076628e-01f, 4.06807005e-01f, 2.77880758e-01f, -5.89706264e-02f, 5.29642776e-02f, 2.87834466e-01f, 4.60441321e-01f,
  6.07887097e-02f, 4.75849897e-01f, -2.09437788e-01f, -3.97328846e-03f, 6.71995804e-02f, -2.74050355e-01f, -3.29612225e-01f, -1.60475641e-01f, -3.32212821e-02f, 1.76716685e-01f,
  3.64292443e-01f, 5.67421675e-01f, 1.08715050e-01f, 3.45352769e-01f, 3.67414594e-01f, 4.11234528e-01f, -1.48934215e-01f, 2.15325058e-01f, -2.16967344e-01f, -1.57059710e-02f,
  2.72127539e-01f, 2.03569800e-01f, 1.76994517e-01f, 3.29645693e-01f, 3.08160454e-01f, 1.20664805e-01f, 9.86251459e-02f, 2.58817613e-01f, 2.93808460e-01f, 2.70114839e-01f,
  3.45411658e-01f, 4.71339183e-04f, 1.84822589e-01f, 2.35016525e-01f, -1.40394634e-02f, 9.92787629e-02f, 3.07219237e-01f, 7.68086687e-02f, 6.77691996e-02f, 2.65974104e-01f,
  3.76706690e-01f, -2.09876612e-01f, -1.41066834e-01f, 4.49366271e-02f, -1.64215207e-01f, -3.41641873e-01f, -2.27685496e-01f, 3.33996207e-01f, 2.76230931e-01f, -2.15653092e-01f,
  -2.27504790e-01f, -2.20739041e-02f, 2.09628791e-01f, 1.34812057e-01f, 2.34134927e-01f, 3.46071064e-01f, -1.40549332e-01f, 3.18020791e-01f, -7.66890496e-02f, -2.15037867e-01f,
  1.71461239e-01f, -2.61797667e-01f, 2.79695615e-02f, -8.06328207e-02f, 2.69778788e-01f, -9.55661088e-02f, -3.52580309e-01f, -1.11270256e-01f, -9.91938338e-02f, -2.02601224e-01f,
  -1.30759925e-01f, 9.10398439e-02f, 2.36560535e-02f, -3.08536924e-02f, -4.19961452e-01f, -3.46371561e-01f, 2.02369094e-01f, 1.35964081e-01f, 5.30142128e-01f, -4.08643991e-01f,
  3.37813050e-01f, 2.18469188e-01f, 1.64062783e-01f, 2.61882514e-01f, -2.81099379e-01f, 2.22125128e-01f, 9.90173034e-03f, -3.74923125e-02f, 7.93477241e-03f, 2.74197936e-01f,
  1.71251163e-01f, -7.72804394e-02f, 1.80356562e-01f, 1.27809241e-01f, 1.23212352e-01f, 2.49594480e-01f, 3.01403821e-01f, -8.43056068e-02f, 1.39023051e-01f, 6.05899990e-02f,
  1.95622265e-01f, 1.37149036e-01f, 3.82153615e-02f, 1.70832291e-01f, 5.22832274e-02f, 2.40381703e-01f, 4.41356093e-01f, 1.57560945e-01f, 1.97619945e-01f, 2.58107483e-02f,
  3.91853273e-01f, 4.27835919e-02f, 1.45301893e-01f, 2.16555446e-01f, 4.60211247e-01f, 4.73135002e-02f, -4.84629422e-01f, 5.48366904e-02f, -2.24147104e-02f, 2.14197822e-02f,
  -2.73330897e-01f, -1.02256395e-01f, 2.51223475e-01f, 1.70452192e-01f, 5.60055673e-02f, 2.28877634e-01f, 4.63624060e-01f, 4.30243611e-01f, 1.78574789e-02f, 3.88071716e-01f,
  -2.12648585e-02f, -1.02118038e-01f, -4.70719226e-02f, 8.58613923e-02f, 3.65300357e-01f, -6.93487078e-02f, -2.48467863e-01f, 2.91319937e-01f, 2.93564826e-01f, 8.72323513e-02f,
  1.32333800e-01f, 1.36677682e-01f, 1.24060057e-01f, 4.60833848e-01f, -2.52957225e-01f, 3.37920576e-01f, -1.75215900e-01f, -1.02741413e-01f, -2.65267819e-01f, 3.26767676e-02f,
  3.30786675e-01f, 4.28842418e-02f, 2.01775834e-01f, 1.37673736e-01f, 1.50201410e-01f, -1.28333837e-01f, 1.72081143e-01f, 1.44412175e-01f, 1.62818745e-01f, -2.55502790e-01f,
  1.71395913e-01f, -2.77922273e-01f, -1.35784298e-01f, 8.81432462e-03f, 6.04442060e-02f, -8.04226771e-02f, 2.15586260e-01f, 6.55683652e-02f, 1.09297641e-01f, 2.04117373e-01f,
  3.02173644e-01f, 1.85322747e-01f, -3.97889018e-01f, 7.34337568e-02f, -2.37809449e-01f, 2.72894502e-01f, -3.36271286e-01f, 2.03766346e-01f, 1.81951970e-01f, 1.68673694e-01f,
  1.54864028e-01f, -1.04147524e-01f, 2.78464943e-01f, 2.61212796e-01f, -7.23670274e-02f, -2.28834778e-01f, 1.42266244e-01f, -3.37226510e-01f, 2.31517941e-01f, -5.37398994e-01f,
  3.43221724e-01f, 4.17152613e-01f, 4.39443365e-02f, 2.20488340e-01f, 2.34777138e-01f, -3.03763419e-01f, -1.75411493e-01f, 1.37467878e-02f, 1.39851764e-01f, -1.23980083e-01f,
  -4.28080447e-02f, 4.18317579e-02f, 9.38758627e-02f, 3.20687220e-02f, 1.49170846e-01f, 7.73175508e-02f, 3.35414708e-01f, -1.04829714e-01f, 3.35468322e-01f, 3.88067752e-01f,
  1.13373861e-01f, 2.74723500e-01f, -5.26310623e-01f, 6.37293085e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.05638722e-01f, 1.94682702e-01f, 2.95725971e-01f, 1.09969012e-01f, 5.07582128e-02f, 2.35392004e-01f, 1.21289939e-01f, 1.67976335e-01f, 7.24934936e-02f, 1.81724831e-01f,
  2.53014743e-01f, 1.68398708e-01f, 5.73341958e-02f, 1.18872672e-01f, -1.78773329e-02f, 1.47203252e-01f, 1.80889323e-01f, 1.09160133e-01f, 6.68517202e-02f, 5.66265434e-02f,
  2.92359591e-02f, 1.46094218e-01f, -1.91596095e-02f, 9.40857753e-02f, 2.46041596e-01f, 1.85087472e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  1.25293985e-01f, -2.16502603e-02f, 1.71338409e-01f, -1.42212749e-01f, -4.36883308e-02f, -2.62459349e-02f, -1.35795400e-01f, -2.36668423e-01f, -2.99096286e-01f, 7.68659562e-02f,
  -1.07751936e-01f, -2.07464900e-02f, -3.02286565e-01f, -1.24165431e-01f, 4.42631170e-02f, -1.73481151e-01f, 1.10926189e-01f, -5.93319116e-03f, -8.42767656e-02f, -3.08166564e-01f,
  -7.07573965e-02f, 2.69384712e-01f, -7.79863819e-02f, 1.62067577e-01f, -1.75935760e-01f, 1.45700097e-01f, -2.70059519e-02f, 6.47232756e-02f, 1.12973504e-01f, 3.53439748e-02f,
  1.50241315e-01f, 2.16774374e-01f, 3.73530179e-01f, 3.81539255e-01f, -1.80180013e-01f, 3.96459997e-02f, -3.01527023e-01f, -6.45826831e-02f, -1.20662205e-01f, -1.09294713e-01f,
  3.79656583e-01f, -2.56686509e-01f, -3.32727015e-01f, -6.95728898e-01f, -4.75425988e-01f, 1.17340036e-01f, -5.29474199e-01f, -4.19042200e-01f, 4.25077200e-01f, -7.26030916e-02f,
  -2.27167040e-01f, 2.11049944e-01f, -3.38557571e-01f, -5.98702729e-01f, 8.48081186e-02f, -2.71819711e-01f, -3.89466792e-01f, 1.38981670e-01f, -1.30005375e-01f, 3.36273313e-01f,
  3.40803206e-01f, -2.54029632e-01f, -1.50128573e-01f, -3.17690134e-01f, -1.54990703e-01f, 3.15330364e-02f, 6.10275865e-02f, 4.89497669e-02f, 6.74720779e-02f, 1.33273646e-01f,
  -1.47507221e-01f, 1.65597022e-01f, 4.44219150e-02f, 2.10170776e-01f, 2.31913954e-01f, 7.35490397e-02f, 1.19399384e-01f, -1.53302029e-01f, 1.05761983e-01f, 1.73242372e-02f,
  1.53447971e-01f, -9.50557217e-02f, 1.28850594e-01f, -2.53476232e-01f, 6.98301196e-02f, 3.39945376e-01f, -6.24504238e-02f, -4.69793454e-02f, 4.75614041e-01f, 3.60306174e-01f,
  1.09042540e-01f, -1.00772001e-01f, 2.63458461e-01f, 2.24218685e-02f, 2.28463829e-01f, -1.26668826e-01f, 3.73784572e-01f, -3.56105238e-01f, 3.02391052e-01f, 2.64591098e-01f,
  -2.43723795e-01f, -1.86482951e-01f, -5.03646195e-01f, 1.72623500e-01f, 1.42049655e-01f, -3.51930499e-01f, -4.69121605e-01f, 1.37867481e-01f, -3.84596676e-01f, 1.59807757e-01f,
  -4.48356390e-01f, -8.53681043e-02f, 1.82588696e-01f, -4.97065902e-01f, 2.59592354e-01f, 2.82330990e-01f, 5.18155955e-02f, 7.27272704e-02f, -1.06635235e-01f, -3.51199657e-02f,
  6.28856063e-01f, -2.93564320e-01f, -4.22607332e-01f, 2.19332680e-01f, -4.17926013e-01f, 3.01157653e-01f, -4.14205939e-01f, -3.88115019e-01f, 1.15613922e-01f, -7.93949738e-02f,
  1.74682140e-01f, 5.95129989e-02f, -3.02931014e-02f, -7.42727518e-02f, 8.08789358e-02f, -2.06926093e-02f, -4.95589301e-02f, 2.07295176e-02f, -9.97546967e-03f, 2.75418833e-02f,
  -5.06214686e-02f, 5.19954115e-02f, 3.92610393e-02f, -2.58870065e-01f, -1.27522647e-01f, 2.08993897e-01f, -1.75713092e-01f, -2.17996448e-01f, -3.84155661e-01f, 2.65284069e-02f,
  1.58668756e-01f, -3.10168535e-01f, 2.40012765e-01f, -2.63502181e-01f, -2.19301432e-01f, 8.10566917e-02f, -2.21832067e-01f, -2.33100250e-01f, -2.78882772e-01f, -2.42209956e-01f,
  2.28106141e-01f, 1.19323961e-01f, 2.25074589e-01f, 2.17712764e-02f, -7.29248300e-02f, 1.32425383e-01f, -4.31268454e-01f, 2.01335594e-01f, -3.33470672e-01f, -4.11952406e-01f,
  -5.85190058e-02f, 3.01820636e-01f, -2.79201925e-01f, -1.07237576e-02f, -1.76551361e-02f, 2.95432031e-01f, -3.82252365e-01f, -2.36828253e-02f, 1.80902764e-01f, -1.81642503e-01f,
  -4.00003493e-01f, 3.17022294e-01f, -2.75540471e-01f, 3.18213552e-01f, 4.08705533e-01f, -1.50726020e-01f, 3.91563535e-01f, -3.14866453e-01f, -3.06810051e-01f, 9.58370790e-03f,
  -2.32679889e-01f, 1.89478770e-01f, -2.74219602e-01f, -1.71731129e-01f, -2.92920023e-02f, -2.96003949e-02f, 5.40347062e-02f, -1.53358176e-01f, -2.75471881e-02f, -1.19598575e-01f,
  -2.77371109e-01f, -1.98169395e-01f, -1.75134182e-01f, 2.30890214e-01f, -2.50500172e-01f, -1.86039582e-01f, -1.78982597e-02f, 1.29693300e-01f, -2.53410846e-01f, 2.32429907e-01f,
  -1.36748061e-01f, -8.07021409e-02f, -4.19231385e-01f, -2.49307558e-01f, -2.50708729e-01f, -2.45735586e-01f, -3.41918290e-01f, 4.07733649e-01f, -2.90107019e-02f, -1.63554400e-01f,
  2.29068518e-01f, -1.26128152e-01f, 3.74700040e-01f, -2.83229470e-01f, -6.79404959e-02f, -2.71758795e-01f, 3.09417862e-02f, 3.43278348e-02f, 2.55433202e-01f, -2.69229293e-01f,
  9.38492343e-02f, -2.67775416e-01f, -7.34452158e-02f, -1.62331492e-01f, -4.46824998e-01f, -7.53734484e-02f, -2.58986815e-03f, -3.27741265e-01f, -1.67422354e-01f, -3.17048490e-01f,
  -5.44813514e-01f, 2.43942335e-01f, -1.86805367e-01f, -6.51737273e-01f, -3.01557213e-01f, -4.05478150e-01f, -1.68145135e-01f, 3.20943207e-01f, 1.09779112e-01f, 1.13105513e-01f,
  1.16114117e-01f, 2.85547137e-01f, 2.76974231e-01f, -5.64031959e-01f, 2.52292991e-01f, 9.04852301e-02f, -1.49964243e-01f, 2.46915426e-02f, 3.62414382e-02f, -2.24748310e-02f,
  5.85404746e-02f, 2.31447313e-02f, 2.77770102e-01f, -1.90480366e-01f, -2.16492210e-02f, 3.07964563e-01f, 5.01250885e-02f, -9.72844958e-02f, 2.72961378e-01f, -4.27387543e-02f,
  2.15565845e-01f, 4.76887561e-02f, 2.33500049e-01f, -5.21835908e-02f, 1.83951944e-01f, 2.68521369e-01f, 3.43592227e-01f, -1.49062708e-01f, -3.38299096e-01f, 4.96649370e-02f,
  -6.97782263e-02f, 2.35152796e-01f, 2.80152410e-01f, 2.67615110e-01f, 1.36340231e-01f, 2.48260260e-01f, 1.56582966e-01f, -3.61506939e-02f, -3.36971015e-01f, -4.93428744e-02f,
  1.22936140e-03f, -8.00566673e-02f, 1.26998782e-01f, 2.98944265e-02f, 3.05852026e-01f, -4.36749756e-01f, 2.50287503e-01f, -1.25979140e-01f, 2.94409752e-01f, -5.40719807e-01f,
  1.82136670e-02f, -2.77900249e-01f, 1.30849212e-01f, -2.57551312e-01f, -4.42236751e-01f, 1.98958129e-01f, -4.07848507e-01f, 1.49596095e-01f, -1.90762058e-01f, 2.85479695e-01f,
  -2.81929582e-01f, -8.34113061e-01f, -5.52101433e-03f, -3.52441370e-01f, 3.50231305e-02f, 1.91053092e-01f, -1.71466723e-01f, -4.54932123e-01f, 3.46497357e-01f, -3.77956688e-01f,
  8.84779319e-02f, -3.97252366e-02f, 4.63735275e-02f, 2.99153000e-01f, -1.72625884e-01f, 9.93379578e-02f, 2.34389380e-01f, 2.42272928e-01f, 4.31210846e-02f, 2.31597107e-02f,
  4.16209400e-02f, -2.00692907e-01f, -1.30968526e-01f, 1.23870067e-01f, 9.06242952e-02f, -1.91103756e-01f, 2.33799517e-02f, 1.29061192e-01f, 2.30990872e-01f, -3.05623651e-01f,
  1.79782599e-01f, -2.82536864e-01f, -1.98034167e-01f, 2.39278316e-01f, -3.72996062e-01f, 6.64919317e-02f, -5.88576123e-02f, 2.65154004e-01f, -4.25422877e-01f, -2.81216041e-03f,
  1.61180213e-01f, 2.38464639e-01f, -2.40407139e-01f, 2.11340532e-01f, -3.23393762e-01f, 1.68796733e-01f, 1.25906274e-01f, 9.17986687e-03f, 2.61552632e-01f, 4.11587745e-01f,
  -2.03951970e-02f, 2.27460280e-01f, 4.14962441e-01f, 1.32650003e-01f, 1.03788868e-01f, -1.44723371e-01f, -1.58693224e-01f, -2.69681662e-01f, 1.11676209e-01f, -4.29489106e-01f,
  4.04042512e-01f, -1.44376919e-01f, -5.43159962e-01f, -5.10084629e-01f, 2.17805654e-01f, -1.04627430e-01f, -5.44602513e-01f, -4.44416553e-01f, -1.55021235e-01f, 4.92407270e-02f,
  -3.45755726e-01f, 2.33751044e-01f, -2.23409116e-01f, -2.75487602e-01f, -3.11178733e-02f, -4.06421013e-02f, -2.08430812e-02f, -1.47498444e-01f, 4.29571606e-03f, -1.00243539e-01f,
  5.26201129e-02f, -7.03821406e-02f, -1.44986259e-02f, 6.88108876e-02f, 2.34526768e-02f, -3.41643170e-02f, -2.72757895e-02f, -3.34302969e-02f, 1.10736810e-01f, 1.36497632e-01f,
  -7.21263234e-03f, 2.63393056e-02f, -1.23536356e-01f, -1.55058533e-01f, 1.92527369e-01f, -1.70839027e-01f, 3.18397433e-01f, 1.30569145e-01f, 5.01165152e-01f, -2.38165751e-01f,
  6.32654354e-02f, -1.16515189e-01f, -2.76006237e-02f, 1.46168336e-01f, 4.68598455e-02f, 1.13696724e-01f, -1.13225028e-01f, -2.07965702e-01f, 2.44686514e-01f, -1.49200320e-01f,
  1.82540387e-01f, 2.69409776e-01f, 8.75480622e-02f, -2.04412013e-01f, -5.00288069e-01f, 3.01943481e-01f, 1.76341087e-01f, 4.65669423e-01f, 1.69530615e-01f, -3.79952610e-01f,
  7.02321529e-02f, 1.84170872e-01f, -1.18542269e-01f, -1.99508406e-02f, -9.04354379e-02f, 1.68442696e-01f, 9.71754715e-02f, 1.15318410e-02f, -5.09214461e-01f, -5.29165864e-01f,
  -1.25028059e-01f, 7.81459451e-01f, -2.74949312e-01f, -4.67472374e-01f, -1.92443967e-01f, 2.39691496e-01f, -2.69174337e-01f, 3.48770708e-01f, -2.20813811e-01f, -5.08305170e-02f,
  -1.37080267e-01f, -1.04942940e-01f, -1.70773447e-01f, 4.36985232e-02f, -9.38863605e-02f, 4.26375568e-02f, 4.13943492e-02f, 2.92173587e-02f, 1.37157783e-01f, 6.18407615e-02f,
  8.11469853e-02f, -1.56112939e-01f, 9.58639011e-02f, -8.34561884e-02f, -1.74023733e-01f, 9.89574045e-02f, -1.12380614e-04f, -9.38407108e-02f, -2.92192727e-01f, -3.17829736e-02f,
  2.61064142e-01f, -2.43803367e-01f, 1.56023845e-01f, -1.81501105e-01f, -1.88855991e-01f, 1.94577187e-01f, -9.10492763e-02f, -6.68399930e-02f, -5.23430258e-02f, 1.18716815e-02f,
  -8.73917900e-03f, 2.14251250e-01f, 5.76287657e-02f, -1.54809728e-01f, 9.05277655e-02f, -2.58484751e-01f, -4.27942753e-01f, 3.11974943e-01f, -3.15196067e-01f, -1.01766013e-01f,
  1.96907297e-01f, -2.37056226e-01f, -1.09858282e-01f, 2.86537439e-01f, 1.82568848e-01f, -1.59372136e-01f, 9.72954109e-02f, -3.87089662e-02f, -1.23321995e-01f, -3.90871823e-01f,
  4.39229220e-01f, -5.86290002e-01f, -3.25204134e-01f, -2.08221659e-01f, -1.83240995e-01f, -6.40082061e-02f, 3.41716468e-01f, -1.65705636e-01f, -4.17137928e-02f, -4.01351899e-01f,
  2.71078348e-01f, 2.95488000e-01f, 5.48013262e-02f, -3.07311844e-02f, -2.09368572e-01f, -1.33939773e-01f, 8.92288536e-02f, -4.86547500e-02f, 1.14888661e-01f, 8.08626115e-02f,
  -5.32363495e-03f, 1.33563355e-01f, 3.64805013e-02f, -2.22328696e-02f, 1.21403262e-01f, 7.69225881e-02f, -9.23103020e-02f, -6.59583043e-03f, 5.30440547e-02f, -8.52407962e-02f,
  7.04452172e-02f, -7.67823821e-03f, -2.40232676e-01f, 2.46123791e-01f, -1.92324921e-01f, 1.65818870e-01f, -1.21251665e-01f, 7.76748285e-02f, -2.68610150e-01f, 2.09910795e-02f,
  4.87501360e-02f, 9.58176106e-02f, -2.84580678e-01f, -1.46844625e-01f, -3.91753688e-02f, -1.39444098e-01f, 2.09156960e-01f, 2.84364432e-01f, -1.82475269e-01f, 7.70541131e-02f,
  -2.40702301e-01f, -1.42656760e-02f, -4.56426203e-01f, 3.87939990e-01f, -2.55707949e-01f, -5.61698675e-01f, -2.75188953e-01f, -1.43805370e-02f, 3.79358023e-01f, 3.72581631e-01f,
  -3.62129718e-01f, -3.43485028e-01f, -1.77575350e-01f, 3.08489650e-01f, -2.12210879e-01f, -2.56265223e-01f, 1.71965078e-01f, 3.49672586e-01f, -2.76341528e-01f, -4.55938317e-02f,
  -2.44942412e-01f, 2.16257244e-01f, -2.22477064e-01f, -2.30420977e-01f, -3.13495874e-01f, -2.14670062e-01f, 1.78798094e-01f, 5.70110651e-03f, -1.26232356e-01f, -6.90381303e-02f,
  1.13436412e-02f, 1.70041546e-02f, -5.62691502e-02f, 2.21497282e-01f, 1.39714152e-01f, -8.30970053e-03f, -1.26317404e-02f, 1.55672669e-01f, -3.38467151e-01f, 1.69853732e-01f,
  -9.38179716e-02f, -1.92382727e-02f, 3.16766724e-02f, -1.40434101e-01f, -5.61248995e-02f, 1.43251553e-01f, 1.36804923e-01f, -2.00870112e-01f, 2.85325050e-01f, 8.64910558e-02f,
  -9.78169814e-02f, -3.33504498e-01f, 6.21649576e-03f, -3.36967379e-01f, -2.93030649e-01f, -3.90904218e-01f, 8.73329565e-02f, 2.37885043e-01f, -1.63785592e-01f, 4.14694875e-01f,
  -2.74053901e-01f, 3.72481406e-01f, 1.65229097e-01f, 3.46202701e-01f, -2.40398228e-01f, -2.59433836e-01f, 2.36218065e-01f, -4.61117327e-01f, 1.49064541e-01f, -4.17275488e-01f,
  3.48588496e-01f, 3.66345406e-01f, -3.62327456e-01f, 7.17959106e-02f, 2.20484406e-01f, 3.65330011e-01f, -4.36258584e-01f, 2.31651336e-01f, 1.14948884e-01f, 1.43579915e-01f,
  -3.32231075e-01f, -2.06237376e-01f, -2.51693875e-01f, -2.89340764e-01f, 1.95164517e-01f, -4.87574399e-01f, -4.05207098e-01f, -6.71139881e-02f, -5.36332011e-01f, -2.39926919e-01f,
  8.74822289e-02f, -5.04960082e-02f, 6.01284057e-02f, 1.39917314e-01f, -1.00286668e-02f, 1.35040924e-01f, 1.51885062e-01f, 1.09011255e-01f, -1.12055421e-01f, -2.60820031e-01f,
  2.22715903e-02f, -1.22388326e-01f, 8.21060166e-02f, -1.49982260e-03f, 8.86074901e-02f, 9.52021778e-02f, -1.72920197e-01f, -2.25659192e-01f, -2.64643244e-02f, 1.56235546e-01f,
  -2.24845499e-01f, 2.94422776e-01f, -2.35182971e-01f, -2.98131227e-01f, 3.36344570e-01f, -3.09690982e-01f, 1.29793420e-01f, 2.61365205e-01f, 2.00650916e-01f, 2.60036498e-01f,
  -4.31000054e-01f, -1.09973945e-01f, -2.27290228e-01f, -1.65216148e-01f, 9.05382037e-02f, -2.47267723e-01f, -3.38182509e-01f, 3.82215649e-01f, -4.54122007e-01f, -1.54922172e-01f,
  -4.09564525e-01f, -2.99180001e-01f, -4.47459489e-01f, -4.49866503e-01f, 4.48052846e-02f, 3.19677681e-01f, -2.93873638e-01f, -3.17596972e-01f, -2.15626225e-01f, -3.97509299e-02f,
  -1.48586780e-01f, -1.16521835e-01f, -3.90650332e-01f, 3.39991421e-01f, -6.36024028e-02f, 2.08076864e-01f, -2.91902155e-01f, 9.16309729e-02f, -3.89374524e-01f, 7.17206299e-02f,
  2.87156463e-01f, 4.96231794e-01f, 1.65360510e-01f, 2.95919716e-01f, 2.03669980e-01f, 8.47086757e-02f, -1.55564338e-01f, 6.23703264e-02f, 1.75913458e-03f, -1.67233422e-01f,
  1.12862080e-01f, -2.56068319e-01f, 1.10527113e-01f, 1.40177667e-01f, 8.19385648e-02f, -1.90863162e-01f, 6.48328736e-02f, -1.02384873e-01f, -1.14213951e-01f, 2.44258717e-02f,
  -3.95826548e-02f, 1.61069825e-01f, 6.31257296e-02f, -9.56000164e-02f, 1.88386574e-01f, -1.86468542e-01f, -2.56860197e-01f, -3.82404745e-01f, -8.04314986e-02f, -1.44985467e-01f,
  1.03218272e-01f, -1.73040181e-01f, -4.51215208e-02f, 4.53165658e-02f, 2.80594409e-01f, 1.98971733e-01f, -1.02367878e-01f, -1.45515919e-01f, -1.95044830e-01f, -2.54966855e-01f,
  2.29462400e-01f, -3.26953381e-01f, 3.82508606e-01f, -5.49848378e-01f, -3.33884686e-01f, 2.12310225e-01f, -4.08691883e-01f, -3.76494288e-01f, 1.72757611e-01f, -1.40912190e-01f,
  3.69245917e-01f, -3.75812769e-01f, -4.70388383e-01f, 6.23414814e-02f, 1.65473167e-02f, -4.13942724e-01f, 3.69139135e-01f, -2.40003690e-01f, 3.88944089e-01f, 2.73069859e-01f,
  -1.84872910e-01f, -2.33858421e-01f, -4.06864882e-01f, -3.86689931e-01f, -1.50094822e-01f, 1.56890944e-01f, -1.74539149e-01f, 1.29586801e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -7.93305337e-02f, 1.15063064e-01f, -4.31540087e-02f, 6.82489425e-02f, 5.61578311e-02f, 3.29400860e-02f, -1.31075248e-01f, 8.66327211e-02f, -1.10011734e-01f, -1.06188983e-01f,
  1.08536169e-01f, -5.09429649e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    