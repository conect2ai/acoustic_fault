/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.32949078e-01f, -4.05416489e-02f, -1.78016834e-02f, 2.86976784e-01f, 1.07197404e-01f, 2.66293108e-01f, 4.60580550e-02f, 2.07979634e-01f, 1.96050927e-01f, 1.79267153e-01f,
  1.29051968e-01f, -1.36295155e-01f, -2.87378877e-02f, 2.34270602e-01f, 2.96159804e-01f, 1.17193699e-01f, 2.23320231e-01f, 3.11632478e-03f, 1.73078775e-02f, 1.54163083e-02f,
  1.28377691e-01f, 2.02201411e-01f, -9.50194243e-03f, 1.95786074e-01f, -7.54945725e-02f, -8.56505409e-02f, 1.73970126e-02f, -1.55258179e-02f, 3.55854742e-02f, -6.61607012e-02f,
  -1.44244693e-02f, 4.83633541e-02f, -2.29451270e-03f, 4.53679971e-02f, 9.96184424e-02f, -1.02005759e-02f, -4.99994457e-02f, -6.64381534e-02f, 6.96547180e-02f, -4.09142934e-02f,
  -1.81119132e-03f, -3.99046801e-02f, -1.37215864e-03f, 9.93544608e-02f, 2.93177217e-02f, 4.99114627e-03f, 7.56892562e-02f, -2.06001252e-02f, -1.86858904e-02f, -1.09011754e-01f,
  -4.12885919e-02f, -8.18819031e-02f, 8.92173499e-03f, -3.10017765e-02f, 4.04283777e-03f, 9.28685889e-02f, 6.64570648e-03f, -1.37501895e-01f, 1.69399213e-02f, 3.13677341e-02f,
  -2.89201573e-03f, -6.03691377e-02f, 5.42473532e-02f, 2.02975672e-04f, 4.91515025e-02f, 2.38660797e-02f, 8.90877321e-02f, -7.41995052e-02f, 1.17213232e-02f, 2.06549801e-02f,
  2.51573860e-03f, 8.49042833e-03f, 2.41554296e-03f, 8.34295601e-02f, -2.37291958e-02f, -5.79025447e-02f, -1.60310075e-01f, -3.14046815e-02f, 2.80439295e-03f, 6.38069212e-02f,
  -3.81780230e-02f, -1.50615571e-03f, 1.88253857e-02f, -4.14430574e-02f, 1.86909959e-02f, -2.36234348e-02f, 3.15965042e-02f, -2.53243372e-02f, 4.79925536e-02f, 1.87342260e-02f,
  1.45179525e-01f, 1.41880453e-01f, 4.57733981e-02f, -1.72670819e-02f, 4.00468521e-02f, 1.57792084e-02f, 2.22089980e-02f, 3.80739477e-03f, -1.09126698e-02f, -3.51577848e-02f,
  -3.73956608e-03f, 1.21457025e-01f, -5.19881435e-02f, -5.38233779e-02f, 2.92111356e-02f, 1.88613869e-02f, 1.03560125e-03f, 4.56870906e-02f, 1.92343295e-02f, 8.26504752e-02f,
  -3.29691195e-03f, 1.04183620e-02f, 2.92557059e-03f, 7.46407956e-02f, 6.87219054e-02f, -7.89403990e-02f, 1.06457643e-01f, 3.24232541e-02f, -3.79414149e-02f, 1.46280125e-01f,
  -1.95699409e-02f, -1.02790691e-01f, 1.96710192e-02f, 4.31328900e-02f, 7.08680600e-02f, -2.37167165e-01f, -7.84677118e-02f, -1.64197721e-02f, -1.68789178e-01f, 9.10771638e-02f,
  -2.36420911e-02f, 1.16711175e-02f, 3.10891861e-04f, 1.64430529e-01f, 1.68196633e-01f, -1.84440181e-01f, 1.15748428e-01f, -6.29105642e-02f, 6.49923533e-02f, 4.34785485e-02f,
  1.63753945e-02f, 2.30928585e-01f, 9.90202501e-02f, 7.14017153e-02f, 2.68822219e-02f, -1.68225123e-03f, 4.58128661e-01f, -2.58245207e-02f, 2.82714158e-01f, 1.22023955e-01f,
  -4.28447276e-02f, -1.62896484e-01f, 7.90279731e-02f, 6.80092163e-03f, 2.99103297e-02f, -2.87914034e-02f, 4.48012911e-02f, 8.89325142e-02f, -1.01377010e-01f, 3.56228789e-03f,
  -5.46839125e-02f, 2.75740493e-02f, -7.36416280e-02f, 4.57202233e-02f, -1.11928128e-03f, -2.41606031e-02f, 4.54303995e-02f, -1.68066844e-02f, 1.74665749e-02f, -7.20671937e-02f,
  -1.29408032e-01f, -3.38577218e-02f, -6.58234060e-02f, 1.06537402e-01f, 4.19656858e-02f, 6.00590669e-02f, -4.31862548e-02f, -1.54301496e-02f, -1.16751939e-02f, 3.90969440e-02f,
  6.36069551e-02f, -4.68075499e-02f, 5.18850237e-03f, -8.42887089e-02f, -1.69896558e-02f, 1.21249311e-01f, -9.29581560e-03f, 1.00065365e-01f, 9.03312787e-02f, 1.62324694e-03f,
  -5.47536556e-03f, -9.21058003e-03f, 2.44007260e-02f, -1.56105950e-01f, -4.10434976e-02f, -5.89371733e-02f, 3.55013013e-02f, -3.87358554e-02f, 2.65846439e-02f, -4.43822630e-02f,
  1.41055375e-01f, 1.49206862e-01f, -1.67598128e-01f, -7.68810837e-03f, -6.52609020e-02f, 1.07744606e-02f, 6.96554482e-02f, 9.97699648e-02f, -3.54257226e-02f, -2.13936027e-02f,
  7.28736222e-02f, 2.88055062e-01f, -3.83425020e-02f, -7.85218328e-02f, -5.27287759e-02f, -3.37523930e-02f, 2.72360276e-02f, -8.95207748e-03f, 8.48665982e-02f, -4.38918360e-02f,
  6.78166673e-02f, -1.50321350e-01f, 1.87478606e-02f, 1.59134250e-02f, -3.18972357e-02f, -4.51886095e-02f, -2.14520637e-02f, 1.48352562e-02f, 1.01918280e-01f, 7.20561743e-02f,
  -5.75194173e-02f, -1.24866955e-01f, -2.38301754e-02f, -1.02257088e-01f, -7.55742192e-02f, -2.99530290e-02f, -3.75463329e-02f, -7.24358857e-02f, 7.51367435e-02f, 3.22838023e-05f,
  2.77018040e-01f, 2.03611210e-01f, 1.63249101e-03f, 1.42370120e-01f, -1.99169949e-01f, 1.92356199e-01f, 6.02966174e-02f, -1.01092346e-02f, 8.45576674e-02f, 1.37820020e-01f,
  1.38116088e-02f, 9.50654075e-02f, 2.81855255e-01f, -3.80365849e-02f, 3.15403074e-01f, 2.45429173e-01f, 6.54617995e-02f, 2.48618454e-01f, -2.60104109e-02f, 1.17240950e-01f,
  5.09866737e-02f, -9.10856724e-02f, -5.49446940e-02f, -2.26328164e-01f, -1.31079018e-01f, -7.95340315e-02f, 1.27179816e-01f, -9.01545659e-02f, -1.35599691e-02f, -8.58852267e-02f,
  -5.67219481e-02f, -4.00271118e-02f, -1.46979421e-01f, 7.73842586e-03f, -7.72216767e-02f, -8.51034187e-03f, 1.03025120e-02f, -9.47618783e-02f, -6.84534758e-02f, -1.15120756e-02f,
  4.79637645e-02f, -5.79606891e-02f, -5.30533539e-03f, -3.54903787e-02f, -5.97420298e-02f, 1.33806467e-02f, -1.54781848e-01f, -1.15950204e-01f, -5.73458709e-02f, -6.29578577e-03f,
  -4.44822833e-02f, -3.36529762e-02f, 5.58608472e-02f, 1.53799310e-01f, -2.01851707e-02f, -3.13874558e-02f, -6.23243414e-02f, 1.67725179e-02f, -2.56987382e-03f, -1.87793598e-02f,
  2.92961281e-02f, 2.00279038e-02f, 2.61203554e-02f, -3.13294157e-02f, 5.10692112e-02f, -4.82456759e-02f, -1.01232016e-02f, -5.58001697e-02f, -8.62935185e-02f, 3.28552537e-02f,
  1.71508119e-02f, -2.15651952e-02f, -6.18962720e-02f, -8.15822035e-02f, -3.50912921e-02f, 1.36396417e-03f, 7.75059536e-02f, -7.08616003e-02f, 8.63399208e-02f, -3.97679061e-02f,
  -1.45760933e-02f, 7.32285678e-02f, 8.47926065e-02f, 6.18109144e-02f, 9.55281928e-02f, -2.24369694e-03f, -9.35973078e-02f, -8.07457194e-02f, -3.89053896e-02f, 5.51779345e-02f,
  4.02353168e-01f, 4.33153331e-01f, -8.20392277e-04f, -3.49251814e-02f, 5.98638020e-02f, -9.41198990e-02f, 4.42860201e-02f, -2.17946339e-02f, 6.68034554e-02f, 5.84769659e-02f,
  -5.09768017e-02f, -1.89508870e-02f, 5.81596307e-02f, 1.13592841e-01f, 6.38977140e-02f, 4.82873768e-02f, 1.15579940e-01f, 2.69076135e-02f, 7.04364032e-02f, -7.37884492e-02f,
  -1.18628275e-02f, -3.89317572e-02f, -6.59882650e-02f, -2.28605457e-02f, -4.60511111e-02f, -1.14419749e-02f, 1.62116840e-01f, -7.35621974e-02f, 1.14444755e-02f, -4.11135294e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.67760456e-01f, 1.05424240e-01f, 4.65655476e-01f, 9.40795004e-01f, 9.91918296e-02f, -4.51632708e-01f, -2.46778250e-01f, 4.06019539e-01f, 5.02224267e-01f, -3.00204962e-01f,
  -4.85027097e-02f, -7.54339695e-02f, -5.01586378e-01f, 4.43770140e-01f, -2.47408137e-01f, -5.18174827e-01f, 4.80976790e-01f, 3.12244948e-02f, 2.40490109e-01f, 2.72051573e-01f,
  4.53775018e-01f, -1.38573378e-01f, 9.64813381e-02f, -2.54615098e-02f, 5.20615876e-01f, 4.97465611e-01f, 2.15337113e-01f, -3.10892493e-01f, 3.41736883e-01f, -2.97820836e-01f,
  -1.13643244e-01f, 8.75770822e-02f, 2.55492479e-01f, 2.78077438e-03f, 4.50545438e-02f, 2.64022741e-02f, -9.29471478e-02f, -2.05722526e-01f, -8.65851436e-03f, -1.38697714e-01f,
  -7.29701146e-02f, -1.15772046e-01f, 1.04014106e-01f, -2.34284475e-01f, -2.46857163e-02f, 1.12689219e-01f, 1.42301982e-02f, 2.00941563e-01f, 3.02668605e-02f, -6.80530816e-02f,
  2.19432309e-01f, 3.34684961e-02f, 1.47214279e-01f, -1.93509106e-02f, 8.71368721e-02f, 1.43594667e-01f, -3.98784317e-02f, -5.16826250e-02f, 1.29496120e-03f, 9.96125638e-02f,
  3.76790464e-02f, 5.30685969e-02f, -6.36130050e-02f, -1.15408033e-01f, -7.30878711e-02f, 1.02832288e-01f, -9.70276520e-02f, -1.55165851e-01f, -1.83384232e-02f, -5.75904250e-02f,
  1.96948111e-01f, 7.13740364e-02f, 1.59481883e-01f, -2.74382881e-03f, 1.09066768e-02f, 2.41119601e-02f, 2.68469471e-02f, -8.39318931e-02f, 1.74954459e-01f, 6.10021055e-02f,
  -2.27389019e-02f, 8.75008553e-02f, 4.98761982e-02f, 2.12476365e-02f, -7.04983249e-02f, -8.24111253e-02f, 1.68162942e-01f, -1.70264766e-02f, -4.32749577e-02f, 3.76321748e-02f,
  1.60113454e-01f, 1.43031895e-01f, -3.72959301e-02f, -8.07653591e-02f, -2.13753954e-01f, -7.71373138e-02f, -1.87714156e-02f, 2.17651203e-01f, 6.34747744e-02f, -3.48860659e-02f,
  -1.72195192e-02f, -3.41218002e-02f, -1.63994282e-01f, 3.60545442e-02f, -7.25976899e-02f, 7.86681846e-02f, -8.24553818e-02f, 8.27639103e-02f, 7.26154596e-02f, 2.33872402e-02f,
  -6.24502823e-02f, -2.35629261e-01f, 1.50029771e-02f, 1.28997445e-01f, 5.44418916e-02f, -3.16499881e-02f, 7.35933930e-02f, -5.84366918e-02f, 3.24650295e-02f, -3.25787067e-02f,
  1.94309801e-02f, -5.19518077e-01f, -4.29648548e-01f, -3.52460206e-01f, -8.25188383e-02f, -4.42828804e-01f, -5.17571390e-01f, -4.18953866e-01f, -1.87924862e-01f, 8.81393179e-02f,
  -1.69664308e-01f, -1.96572393e-01f, -6.68529794e-02f, -7.13216186e-01f, 5.68867177e-02f, 1.61321595e-01f, -3.72840613e-01f, -1.94108337e-01f, 1.00946628e-01f, -3.36883694e-01f,
  3.19014094e-03f, -1.70044377e-01f, -3.01444501e-01f, -1.00246154e-01f, -2.95641810e-01f, -7.41519481e-02f, 4.60838526e-01f, -1.47436768e-01f, -2.11104125e-01f, -1.90596208e-01f,
  -3.23885769e-01f, -1.26967639e-01f, -8.08051601e-02f, -4.94514517e-02f, 1.41704651e-02f, 1.87570564e-02f, -4.18065004e-02f, -2.85156593e-02f, -8.86009559e-02f, -5.15419394e-02f,
  6.73526302e-02f, 5.79806194e-02f, -1.74513593e-01f, 8.20346102e-02f, -5.42709278e-03f, -5.86559772e-02f, -2.91080531e-02f, -2.57257640e-01f, -1.40011653e-01f, -6.39654547e-02f,
  -1.91888869e-01f, -6.39296174e-02f, 4.96772714e-02f, 6.96056262e-02f, 8.23102368e-04f, -3.40601020e-02f, 1.77085698e-02f, -3.13851796e-02f, -8.76274798e-03f, 1.63122326e-01f,
  3.23142745e-02f, 1.33599624e-01f, -1.21186122e-01f, -2.39436347e-02f, -8.21218863e-02f, 2.89421640e-02f, 1.67859290e-02f, 8.73880982e-02f, -1.32675609e-02f, 7.02099428e-02f,
  1.02257282e-01f, 7.64618963e-02f, 1.04760099e-02f, 9.26094130e-02f, -4.04700451e-02f, 1.08308874e-01f, -5.14446534e-02f, -2.03490793e-03f, -1.32838741e-01f, -3.61921191e-02f,
  9.16000009e-02f, 2.07276810e-02f, -6.58073202e-02f, -2.35776082e-02f, -1.14991240e-01f, 1.34274513e-01f, 1.61623046e-01f, -7.01937452e-03f, -9.05601382e-02f, 1.02624260e-01f,
  -5.42763174e-02f, 1.14117511e-01f, -6.94809034e-02f, -4.15804870e-02f, 2.28534043e-02f, 2.29687802e-02f, -8.30087066e-02f, -1.56727955e-01f, 7.79105574e-02f, 1.97423965e-01f,
  7.33385608e-02f, 9.85307124e-05f, -1.04892448e-01f, -7.94010386e-02f, -4.74942215e-02f, 1.63512617e-01f, 1.10649236e-01f, -5.99428639e-02f, 1.09168746e-01f, 5.43834940e-02f,
  3.51655111e-02f, -6.85945004e-02f, 2.57165045e-01f, -8.52557197e-02f, 1.14511706e-01f, -1.72424614e-02f, -1.18952043e-01f, -1.49348512e-01f, 8.87306482e-02f, 1.46312237e-01f,
  -4.77352411e-01f, -2.22710259e-02f, -5.46444058e-01f, -2.91809410e-01f, 3.17230701e-01f, -1.87395319e-01f, -2.21101031e-01f, -2.75597274e-02f, -1.04285747e-01f, 4.59765226e-01f,
  1.79870620e-01f, -3.78207058e-01f, -5.12320958e-02f, -3.75177920e-01f, -7.23859668e-01f, -2.58577853e-01f, -2.37138122e-01f, -2.54497081e-01f, -5.85596859e-02f, 4.99368608e-02f,
  -3.29649329e-01f, 3.23466212e-02f, -4.96055692e-01f, 4.13381279e-01f, 5.51250465e-02f, 1.67899087e-01f, 2.54949689e-01f, 2.84516662e-01f, 2.49162242e-02f, -7.62552917e-02f,
  -1.44808248e-01f, 5.10511883e-02f, -7.56724849e-02f, -6.66878745e-02f, -1.14023462e-01f, 8.41925200e-03f, -7.60506019e-02f, -1.17535591e-02f, -2.90898867e-02f, -2.38126740e-01f,
  -5.20350151e-02f, -2.48669032e-02f, -5.53405136e-02f, 5.18059619e-02f, 1.08881034e-01f, -4.14245911e-02f, -1.09849244e-01f, -1.35204956e-01f, -1.02533393e-01f, -8.60797167e-02f,
  -1.96871385e-01f, -7.14375973e-02f, -5.46375513e-02f, -4.12988439e-02f, -4.90017645e-02f, 9.55319032e-02f, -9.04242992e-02f, 7.12926686e-02f, -4.25468646e-02f, -4.05455008e-03f,
  5.10679670e-02f, 1.43886298e-01f, 4.30694874e-03f, 2.81469170e-02f, 4.17128690e-02f, 6.36798516e-02f, -1.35943800e-01f, -1.06879519e-02f, 8.95471945e-02f, 7.15969130e-02f,
  -4.61575128e-02f, -1.26000509e-01f, 6.06700480e-02f, 2.20557558e-03f, 6.88441396e-02f, 4.84882593e-02f, -8.76612514e-02f, -6.42528757e-02f, -6.96880817e-02f, -1.38594076e-01f,
  9.26339254e-02f, 3.46728414e-02f, 1.16874829e-01f, 2.52013002e-02f, 8.71021487e-03f, -6.54181372e-03f, -3.81754898e-02f, 3.82129326e-02f, -5.14576957e-02f, -6.72817405e-04f,
  3.07225883e-02f, 2.79805154e-01f, -4.43822378e-03f, 2.22389605e-02f, 8.37513730e-02f, -4.34937701e-03f, -9.13484022e-02f, -9.58606824e-02f, -4.39709686e-02f, 1.28416568e-01f,
  2.99201962e-02f, -2.81958990e-02f, 7.71993846e-02f, 1.73754394e-02f, -3.19452174e-02f, 1.82246894e-01f, 1.50440887e-01f, 1.15942121e-01f, 5.12114950e-02f, -8.70718881e-02f,
  2.76099965e-02f, 1.39942408e-01f, 1.58098247e-02f, 1.07134040e-02f, -7.53866974e-03f, 1.79750070e-01f, 6.61979318e-02f, -2.84699984e-02f, 4.96051721e-02f, 6.66150078e-02f,
  5.17071486e-01f, -9.50743735e-01f, -1.42375469e-01f, 4.38637644e-01f, 4.88321394e-01f, 1.27683625e-01f, 4.98191744e-01f, -1.66384667e-01f, -1.22560903e-01f, -4.64807421e-01f,
  1.63060054e-01f, -1.32707763e-04f, -1.41532838e-01f, -1.56709954e-01f, 5.17736197e-01f, -2.14077398e-01f, 3.53763811e-02f, -4.93233539e-02f, 1.21530101e-01f, 5.22057191e-02f,
  2.17956856e-01f, 1.49410695e-01f, 2.11471189e-02f, -1.03811316e-01f, 1.09486207e-01f, -4.76583578e-02f, -3.40572558e-03f, 1.31976120e-02f, 6.99403416e-03f, 1.29940510e-01f,
  6.68402687e-02f, -8.63169357e-02f, -1.60688497e-02f, -1.67160213e-01f, -1.74536765e-01f, -6.83458000e-02f, 2.30297190e-03f, 2.03415796e-01f, 1.20507777e-01f, -2.61077732e-02f,
  -5.50610609e-02f, -5.44218998e-03f, -5.30745946e-02f, 3.51364054e-02f, -2.88544782e-02f, -5.49541973e-02f, 6.37105154e-03f, -1.21140338e-01f, -2.46137455e-02f, 5.78363538e-02f,
  -1.13285743e-01f, -1.01077735e-01f, -2.51551494e-02f, 1.51360789e-02f, -3.63792852e-02f, 3.07956692e-02f, -2.59251706e-02f, 5.95226325e-02f, -7.00077191e-02f, 3.19790505e-02f,
  -6.89162165e-02f, -8.16883612e-03f, -2.96444446e-03f, 3.35573554e-02f, -7.51909167e-02f, 5.55258244e-02f, -4.01470140e-02f, -2.34656110e-02f, -1.81010105e-02f, -1.10233210e-01f,
  5.29819354e-02f, 6.07444160e-02f, 1.15812821e-02f, 1.12601416e-02f, 6.34809881e-02f, -2.65879445e-02f, 1.11562826e-01f, -2.35742722e-02f, 1.12451300e-01f, -1.11927710e-01f,
  5.55736981e-02f, 7.98733309e-02f, 5.02599664e-02f, -6.50520325e-02f, 2.42407192e-02f, 1.94205165e-01f, -1.00679033e-01f, -3.46932234e-03f, 1.26522750e-01f, 3.69648598e-02f,
  -1.02034494e-01f, -5.33681035e-01f, 1.55269885e-02f, 1.08837031e-01f, -3.78543437e-02f, -1.29180908e-01f, -1.23351207e-02f, -1.70082584e-01f, 5.75889014e-02f, 3.92181613e-02f,
  -1.79845970e-02f, 1.34405538e-01f, -1.05648311e-02f, 6.60291836e-02f, 7.34325796e-02f, 1.45953717e-02f, -8.21747035e-02f, 1.21493647e-02f, -2.09000017e-02f, -1.39764458e-01f,
  -7.86668286e-02f, 7.42066791e-03f, 5.48840091e-02f, -6.80062249e-02f, -1.59752637e-01f, 8.74897391e-02f, -4.76151844e-03f, -1.25469835e-02f, -3.98172066e-03f, -2.63596443e-03f,
  1.47233680e-01f, 5.22560515e-02f, -3.27732235e-01f, 1.52994573e-01f, 3.31355929e-01f, 4.54500645e-01f, -6.87205885e-03f, -2.13431753e-03f, -2.15315729e-01f, 1.47691399e-01f,
  2.67233193e-01f, -2.53304809e-01f, -2.88828641e-01f, 6.73186243e-01f, 1.89832807e-01f, -2.15152815e-01f, 4.24351960e-01f, 2.29506060e-01f, -2.25644961e-01f, -2.12265670e-01f,
  -7.02134743e-02f, 6.32087469e-01f, -2.24649981e-01f, 2.12046683e-01f, 1.61219299e-01f, -3.29766452e-01f, 1.84395730e-01f, -2.03760773e-01f, 4.60940838e-01f, 3.22207958e-01f,
  1.83257401e-01f, 8.63258243e-02f, -5.79979941e-02f, -2.97649466e-02f, -4.71182959e-03f, 1.39898717e-01f, -1.55565590e-01f, -9.06177517e-03f, -5.69086596e-02f, -1.01954900e-01f,
  2.91576572e-02f, -5.37551790e-02f, 5.52089252e-02f, 4.51468118e-02f, 1.50802910e-01f, 5.00592478e-02f, 6.53446745e-03f, -2.87823379e-02f, -1.22159332e-01f, -1.88736059e-02f,
  -2.14152366e-01f, 8.00032227e-04f, -1.64926872e-02f, -7.24397674e-02f, 8.81510135e-03f, 4.62264530e-02f, -1.14479072e-01f, -2.33750492e-01f, -4.92316335e-02f, 2.01007351e-02f,
  9.47559029e-02f, 1.43628996e-02f, -7.43891522e-02f, 6.15325756e-02f, 1.04868926e-01f, 1.65037915e-01f, 1.25183642e-01f, -1.63714141e-02f, -1.61824659e-01f, 6.58373684e-02f,
  -4.24632579e-02f, -2.73757707e-02f, -3.47598158e-02f, 3.53944115e-03f, 1.19678691e-01f, -2.20748261e-02f, 3.59198377e-02f, -1.09594017e-01f, -1.50246486e-01f, 1.81123048e-01f,
  6.52428418e-02f, -2.58394331e-02f, -5.67291565e-02f, 6.19710572e-02f, 4.24292199e-02f, -1.00735776e-01f, 1.69068187e-01f, -4.25987169e-02f, 5.99445717e-04f, 8.68866220e-02f,
  -1.99293159e-02f, -1.80234127e-02f, -2.30636790e-01f, -1.15752323e-02f, -5.56032546e-03f, 1.25724703e-01f, -1.00487165e-01f, 1.24991558e-01f, -1.42660648e-01f, 5.16495854e-02f,
  -6.01172820e-02f, -5.20812981e-02f, 1.05396807e-01f, 5.63235991e-02f, 9.70356464e-02f, 4.24799025e-02f, 1.50261493e-02f, 4.39906307e-02f, 7.02553093e-02f, -5.03991544e-02f,
  -4.87441793e-02f, -3.62314992e-02f, -4.69782986e-02f, -1.04403257e-01f, 9.26248282e-02f, 1.79764759e-02f, -6.23453036e-02f, -7.11662993e-02f, 9.31248739e-02f, -4.42937128e-02f,
  -7.59084344e-01f, -2.65052259e-01f, 2.92543948e-01f, -2.66815156e-01f, -2.53150146e-02f, -8.46457407e-02f, 5.80742359e-01f, -2.40031421e-01f, -3.32186610e-01f, 1.03704989e-01f,
  2.65446275e-01f, -3.12361449e-01f, 3.75168115e-01f, 1.52942359e-01f, 1.53123885e-01f, 4.15826201e-01f, 2.09116861e-01f, 7.85041004e-02f, -5.71251437e-02f, -1.71785757e-01f,
  -1.13044837e-02f, -1.02327401e-02f, 2.87385166e-01f, -4.11365151e-01f, 1.14390366e-01f, -1.75189048e-01f, 2.64784575e-01f, -1.07608084e-02f, -1.49723396e-01f, -3.31953280e-02f,
  -1.08525762e-03f, -1.23554766e-01f, 2.83122659e-02f, -5.09641208e-02f, -2.12805402e-02f, 9.94930640e-02f, -6.56261742e-02f, 4.72818539e-02f, 2.87791472e-02f, -2.25442667e-02f,
  7.45744184e-02f, -1.22222126e-01f, -1.66068003e-01f, -8.39622542e-02f, -1.23292230e-01f, -1.06884819e-03f, 2.53572147e-02f, 1.94646418e-02f, -7.23593161e-02f, 1.04777418e-01f,
  1.57916293e-01f, 1.19056024e-01f, 2.53961623e-01f, 2.96383444e-02f, 1.29884809e-01f, -8.08071867e-02f, 2.31278151e-01f, 2.53786176e-01f, -3.27984132e-02f, -5.95469400e-02f,
  1.12525210e-01f, -8.41017887e-02f, -5.49789332e-02f, -1.35467038e-01f, 7.30738975e-03f, 3.16018276e-02f, -1.16728477e-01f, 2.38541421e-02f, -6.61114678e-02f, 3.00074834e-02f,
  3.85160334e-02f, -2.38570310e-02f, 8.99110828e-03f, 1.07264251e-01f, -6.76584840e-02f, 3.67901213e-02f, -1.45180579e-02f, 8.92894790e-02f, 5.58467098e-02f, -5.99773414e-02f,
  -2.02876497e-02f, 2.38445662e-02f, -9.84906685e-03f, 1.53237253e-01f, -7.80767575e-02f, 7.65047818e-02f, -7.58298039e-02f, 5.89691699e-02f, 7.57344291e-02f, 1.67122349e-01f,
  -7.07879663e-01f, -5.75229824e-01f, -1.42580837e-01f, -8.99049044e-02f, -1.15029272e-02f, -1.16308451e-01f, -1.28438413e-01f, -1.15345586e-02f, -1.07330680e-01f, -4.65274341e-02f,
  2.71062348e-02f, 5.95968999e-02f, -1.33733898e-01f, 2.70793084e-02f, -7.66817182e-02f, 6.06220253e-02f, -1.10786535e-01f, -1.34962916e-01f, -3.63297164e-02f, -1.77606031e-01f,
  -9.50481668e-02f, -1.41070738e-01f, -3.66158634e-02f, -6.62717819e-02f, 2.18656734e-02f, 6.59882352e-02f, -2.79723018e-01f, -2.69105192e-02f, 4.42443080e-02f, 3.40652652e-02f,
  -1.35993588e+00f, 3.99508804e-01f, 9.62253436e-02f, -1.69746146e-01f, 6.03282228e-02f, 2.67711729e-01f, 1.39942979e-02f, 9.00093615e-02f, 2.61088908e-01f, 2.51544774e-01f,
  9.56555605e-02f, -6.48792237e-02f, 2.96461195e-01f, 6.82666823e-02f, -1.38885472e-02f, 2.99713820e-01f, 7.06015453e-02f, 1.64046809e-01f, 1.46398202e-01f, -3.38190459e-02f,
  -2.99707875e-02f, 2.62556195e-01f, -6.90672919e-02f, 1.91280901e-01f, -1.75200135e-01f, -1.86812058e-01f, -1.88399345e-01f, 6.86288327e-02f, -1.16170280e-01f, 8.42509717e-02f,
  -5.03068864e-01f, -1.56737730e-01f, -1.77997217e-01f, 1.14231920e-02f, -3.50809060e-02f, -1.03105135e-01f, -7.86189511e-02f, -5.51467389e-03f, -2.78163292e-02f, 7.39248097e-02f,
  2.48895329e-03f, -1.44804064e-02f, 8.30135196e-02f, 9.10731927e-02f, 4.24794666e-02f, 3.33197936e-02f, 2.27833702e-03f, 4.69693216e-03f, -6.87673083e-03f, 2.21625846e-02f,
  7.33578205e-02f, -1.03635810e-01f, -1.22963533e-01f, 2.51776930e-02f, 1.74861345e-02f, 3.57934125e-02f, 7.16847554e-03f, -3.83722819e-02f, -1.09594017e-01f, 1.04963310e-01f,
  7.20456019e-02f, 4.94168811e-02f, -6.39414936e-02f, -3.65717374e-02f, 8.50793645e-02f, -7.76901767e-02f, -3.69520709e-02f, -7.47824088e-02f, -8.43662843e-02f, -1.01297170e-01f,
  -7.33967647e-02f, -6.72432780e-02f, -6.60029724e-02f, -6.31234497e-02f, -2.98529379e-02f, -2.34388392e-02f, -9.14609432e-02f, 2.41753887e-02f, -3.52663435e-02f, -1.11908577e-01f,
  9.69811454e-02f, -9.44275968e-03f, -5.82481362e-02f, 1.95460636e-02f, -4.83364351e-02f, 3.09550017e-02f, 7.92003516e-03f, 1.88695937e-02f, -3.51115391e-02f, -6.30068630e-02f,
  1.69458091e-02f, -2.20373739e-02f, 5.97117282e-02f, -2.27145702e-02f, 1.15249269e-02f, 2.13491693e-02f, -1.59659848e-01f, -3.02533642e-03f, 1.74506605e-01f, -1.20962575e-01f,
  -7.56591782e-02f, -1.48226798e-01f, -6.37749881e-02f, -1.94568429e-02f, -1.19457266e-03f, 8.86310339e-02f, -3.13046463e-02f, 2.47165263e-02f, 1.16692185e-02f, 8.62158388e-02f,
  -5.58783375e-02f, 1.32295657e-02f, 1.86392795e-02f, -4.30734642e-02f, -6.01046234e-02f, -1.64429158e-01f, -1.14546165e-01f, 5.94448522e-02f, -6.59383554e-03f, 7.06769302e-02f,
  1.61569417e-01f, -8.48517641e-02f, -3.08447778e-01f, -1.73386991e-01f, 3.35798621e-01f, 1.63345397e-01f, -3.41365278e-01f, 1.09574504e-01f, -3.12553972e-01f, 1.36760890e-01f,
  8.26472789e-02f, -6.49165511e-02f, -2.81741500e-01f, -7.19142612e-03f, 2.99488842e-01f, -3.72683972e-01f, 3.83173704e-01f, 1.01627484e-01f, -2.65882522e-01f, 3.60814303e-01f,
  8.68318826e-02f, 4.98827696e-01f, -5.65807186e-02f, 2.67784953e-01f, 2.06079930e-01f, 1.42048240e-01f, 4.26820576e-01f, -3.49857137e-02f, 4.77684408e-01f, 1.67981684e-01f,
  -1.77512825e-01f, -6.97578639e-02f, -1.46594554e-01f, -1.79339722e-01f, 1.65101543e-01f, 9.23179090e-02f, -1.04345746e-01f, 5.37779443e-02f, 2.04392057e-02f, 6.99615851e-02f,
  -1.83581971e-02f, 1.63077950e-01f, 1.48939798e-02f, 4.49040905e-02f, 1.71179157e-02f, -3.40984203e-02f, 2.42117774e-02f, -1.13796955e-02f, -1.57254472e-01f, 3.22707952e-03f,
  -9.29872692e-02f, 8.07853267e-02f, 2.39765197e-02f, -2.17418689e-02f, -2.47350093e-02f, 2.34058127e-02f, 9.01780732e-04f, 1.25713319e-01f, -1.00400016e-01f, 7.40583390e-02f,
  1.27663150e-01f, 7.51845464e-02f, -1.77571811e-02f, -3.56638059e-02f, 1.01694159e-01f, -1.83513388e-01f, -1.10476129e-01f, 3.30838971e-02f, -1.73941553e-01f, 5.53490706e-02f,
  -4.29161042e-02f, -3.69021967e-02f, 4.60763928e-03f, 1.44655223e-03f, 7.06775114e-02f, -7.79429078e-02f, 2.87534446e-02f, 1.25614822e-01f, -4.50001247e-02f, -1.01101883e-01f,
  -9.67182666e-02f, 8.02174062e-02f, 1.14864903e-02f, -7.14949518e-02f, -7.33819902e-02f, 4.25361469e-02f, 1.81231350e-02f, 1.35070561e-02f, -1.22425154e-01f, -1.03847519e-01f,
  1.90985963e-01f, 4.26061869e-01f, 1.04016848e-02f, -3.59441638e-02f, -1.36256993e-01f, 1.15612373e-01f, -6.02731258e-02f, 5.36875054e-02f, 1.57535791e-01f, 7.21547827e-02f,
  1.96103171e-01f, -7.44123906e-02f, 4.55646217e-03f, 1.38610797e-02f, -4.38821986e-02f, 1.05138190e-01f, 1.21012209e-02f, 4.02008742e-02f, 3.65812778e-02f, 1.95845842e-01f,
  1.37441561e-01f, 1.07555136e-01f, 1.35083750e-01f, -9.59274247e-02f, 1.18195899e-01f, 2.03509144e-02f, 6.15974516e-03f, 8.05773288e-02f, -5.14663644e-02f, 3.19178700e-02f,
  8.16769600e-02f, 1.98986784e-01f, -5.78489840e-01f, -2.85624731e-02f, -2.98375130e-01f, 5.34241378e-01f, 6.17188275e-01f, -2.18931735e-01f, -2.05437735e-01f, 5.01888573e-01f,
  2.64516562e-01f, -4.47138809e-02f, 3.56973380e-01f, 5.48210263e-01f, -2.27153316e-01f, 4.04602289e-01f, 3.22871506e-01f, 1.14220403e-01f, -6.08383268e-02f, 1.17786847e-01f,
  -1.32142723e-01f, 5.59229136e-01f, -7.40494728e-02f, -3.96908857e-02f, 3.54322009e-02f, -2.96076804e-01f, -1.01156771e-01f, -3.72284889e-01f, -6.16270341e-02f, -1.34881958e-01f,
  2.19817221e-01f, 1.43840089e-02f, -4.50855345e-02f, -3.78554761e-02f, -3.49292047e-02f, -9.60188657e-02f, 7.38479570e-02f, -7.66706541e-02f, -9.38624069e-02f, -2.57528923e-03f,
  9.26999003e-02f, -1.45468324e-01f, 3.27010006e-02f, -2.06028059e-01f, -1.34650290e-01f, -1.86481357e-01f, -1.51992753e-01f, 6.21101167e-03f, -4.88901064e-02f, 1.85378233e-03f,
  -9.94182453e-02f, -1.60039458e-02f, -2.88143773e-02f, 5.57451770e-02f, -1.64914533e-01f, 6.87610209e-02f, 1.49155378e-01f, -4.72281361e-03f, 5.40932082e-02f, 4.90386151e-02f,
  -1.19496451e-03f, -9.27588418e-02f, 2.00522408e-01f, -1.06181344e-02f, -1.04294203e-01f, 2.83037368e-02f, -2.42482331e-02f, -1.59481186e-02f, -4.66179326e-02f, -1.99130066e-02f,
  -4.78419326e-02f, -3.41771683e-03f, 8.54710266e-02f, -8.00075904e-02f, 1.31703764e-01f, 1.15526102e-01f, 4.65527177e-03f, 4.43121791e-02f, -3.69335487e-02f, 1.51640549e-02f,
  -3.72273251e-02f, 1.07228477e-03f, -3.40879261e-02f, 1.14220768e-01f, 3.51646543e-02f, -1.00710027e-01f, 9.24901888e-02f, 7.73339942e-02f, 1.82780791e-02f, 3.02055459e-02f,
  4.44709100e-02f, 2.37383083e-01f, 7.10723475e-02f, 6.44616038e-02f, -1.04470633e-01f, 1.46038473e-01f, 1.09653451e-01f, -6.21078163e-02f, -4.64775711e-02f, 1.54254049e-01f,
  9.46452245e-02f, -6.00804836e-02f, -1.23563401e-01f, -1.21701984e-02f, -1.72484890e-01f, 3.03429157e-01f, 1.31419346e-01f, 3.07570789e-02f, -3.81300077e-02f, -1.40464067e-01f,
  9.69480202e-02f, -2.00756546e-03f, -1.92784984e-02f, 1.10712396e-02f, -6.20090179e-02f, 4.43176180e-02f, -1.22281648e-01f, 1.03320635e-03f, -2.25262605e-02f, 2.88552162e-03f,
  -6.03944719e-01f, 6.05498374e-01f, 1.08972818e-01f, 2.56923348e-01f, 3.49198490e-01f, 2.66266316e-01f, -1.63336352e-01f, 1.78924099e-01f, 2.91745424e-01f, -1.27308011e-01f,
  -1.21189766e-01f, 6.78081140e-02f, -1.57161161e-01f, -1.07422480e-02f, -9.59658921e-02f, 2.45492399e-01f, -8.57196283e-03f, 1.03789240e-01f, 2.16516495e-01f, 1.90912466e-02f,
  3.00417021e-02f, -8.54386687e-02f, -1.08170442e-01f, 1.26487333e-02f, -1.70717672e-01f, -9.15737599e-02f, -3.87805700e-01f, 1.04236051e-01f, -1.79499149e-01f, 1.48777038e-01f,
  -2.31310517e-01f, 3.34267467e-01f, -3.26617926e-01f, -9.72884744e-02f, -2.52281636e-01f, -6.45883977e-02f, -1.21732034e-01f, 3.20276320e-02f, -6.96999207e-02f, 1.05024762e-01f,
  -8.15901831e-02f, 2.88131963e-02f, -6.69191852e-02f, 3.03786676e-02f, 1.32950515e-01f, -2.60863323e-02f, 2.32004654e-02f, -7.84250945e-02f, -5.71530089e-02f, 2.78167315e-02f,
  -1.80094957e-01f, 9.42970365e-02f, 2.56921519e-02f, 7.04232254e-04f, 1.23218186e-02f, 1.23255216e-01f, 5.35347722e-02f, 7.60906637e-02f, -4.49555255e-02f, -1.61674619e-02f,
  1.28059834e-01f, 1.20374210e-01f, -1.76124889e-02f, -9.71308574e-02f, -3.04759312e-02f, 1.05733775e-01f, -5.62978797e-02f, -1.33404493e-01f, -3.88592295e-02f, -1.82265967e-01f,
  -7.35434815e-02f, -1.65383443e-02f, 5.37397340e-02f, -2.67521534e-02f, -4.05660048e-02f, -6.09125383e-02f, -8.48248787e-03f, -6.86256588e-02f, -4.67699207e-02f, -1.98041409e-01f,
  6.02829345e-02f, 3.05473022e-02f, -5.55081964e-02f, -1.19732402e-01f, -4.01381627e-02f, -4.80351001e-02f, 3.27489637e-02f, 1.60251811e-01f, -5.94227649e-02f, 1.60963815e-02f,
  3.50325823e-01f, 3.67966413e-01f, -2.06859577e-02f, -1.32352129e-01f, -2.73299534e-02f, 1.11003719e-01f, -7.92084727e-03f, -8.76017064e-02f, 2.10553318e-01f, -1.44700697e-02f,
  -1.18203431e-01f, -6.91845864e-02f, 1.31811231e-01f, 7.08766580e-02f, 6.86811702e-03f, 3.28893661e-02f, -3.45149823e-02f, 7.24879578e-02f, -1.12203360e-01f, -1.70773625e-01f,
  -2.51051039e-01f, -1.99736468e-02f, 3.97497490e-02f, -1.65083498e-01f, -1.46469995e-01f, -1.94870809e-03f, -2.26313397e-02f, -6.15305267e-02f, 1.39362076e-02f, 9.18157771e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  7.73465335e-01f, 2.01353237e-01f, 2.22547606e-01f, 2.35866502e-01f, 1.46068245e-01f, 5.28331995e-02f, 3.56767714e-01f, 3.10535014e-01f, 1.04244195e-01f, 3.64566505e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.70557857e-01f, 3.75689596e-01f, 3.69723499e-01f, -4.45573509e-01f, -4.54635143e-01f, -3.07959884e-01f, -6.60654251e-03f, 3.97323370e-01f, 4.61646229e-01f, 2.63896007e-02f,
  -3.48776579e-01f, -1.63799658e-01f, -1.37040466e-01f, -4.48782742e-02f, -1.80596858e-01f, 1.28502329e-03f, 3.52026969e-01f, -1.08797297e-01f, -5.78198254e-01f, 6.10911012e-01f,
  -1.83930229e-02f, -3.55226904e-01f, 3.27754349e-01f, -2.60199495e-02f, -1.28340006e-01f, -3.20400774e-01f, -4.19386297e-01f, 1.69006601e-01f, 3.11576337e-01f, -5.33269227e-01f,
  3.44261266e-02f, 2.59538621e-01f, 2.49003112e-01f, -4.10135478e-01f, -7.06242025e-02f, -2.16700554e-01f, -2.54284013e-02f, -3.05536747e-01f, 1.96120828e-01f, 2.24279314e-01f,
  2.46664688e-01f, -4.68339622e-01f, -4.94838595e-01f, -2.27362886e-01f, 1.01424053e-01f, -7.19569921e-02f, -2.79631048e-01f, 3.82061690e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.84244794e-01f, 8.21150899e-01f, 2.99514800e-01f, 1.66148335e-01f, 1.53354898e-01f, -3.43759745e-01f, -2.56237596e-01f, 1.40847027e-01f, 6.13875747e-01f, 8.97555351e-01f,
  6.06082916e-01f, 9.01913047e-01f, 2.73107737e-01f, -1.41812190e-01f, 4.71996248e-01f, -2.68568665e-01f, 5.25139689e-01f, 2.61428207e-01f, -1.13617465e-01f, 2.70655394e-01f,
  -3.50754440e-01f, -1.02333389e-01f, 8.57231557e-01f, 1.05308590e-03f, -3.36199164e-01f, -1.97597027e-01f, -1.50066495e-01f, -4.28639531e-01f, 5.02549350e-01f, 1.75414369e-01f,
  4.31031257e-01f, 5.72791994e-01f, 3.00464600e-01f, -1.97660103e-01f, 4.78931218e-01f, 8.10705900e-01f, 3.23144227e-01f, -4.97924462e-02f, 5.33172131e-01f, -1.45610094e-01f,
  4.62035775e-01f, 9.18540239e-01f, 6.04454398e-01f, -2.28073999e-01f, -5.34796894e-01f, 4.00156468e-01f, -4.47897166e-02f, -3.32166344e-01f, 3.49270962e-02f, 2.97111034e-01f,
  9.17450041e-02f, 7.70603359e-01f, -6.09868988e-02f, 6.03184879e-01f, 3.44762027e-01f, -1.05007283e-01f, -8.31256270e-01f, 2.17514182e-03f, 4.36306179e-01f, -3.14194351e-01f,
  6.77379489e-01f, 2.68814206e-01f, 7.28905201e-01f, 6.87067270e-01f, 5.27082920e-01f, -1.14064381e-01f, 4.99523312e-01f, -1.10460013e-01f, 9.85095799e-02f, 5.48642799e-02f,
  9.77752268e-01f, -1.85012326e-01f, 2.37240225e-01f, 5.53101659e-01f, 5.43804765e-01f, 4.87866923e-02f, -7.47162223e-01f, 8.65247071e-01f, -2.70142674e-01f, -7.27800429e-02f,
  6.91760480e-01f, 1.11224902e+00f, 3.75966668e-01f, -2.77082860e-01f, -8.59217227e-01f, -1.18395901e+00f, 3.42945457e-01f, -7.94781446e-02f, 9.41665649e-01f, -4.74753119e-02f,
  4.54275638e-01f, 7.17345893e-01f, 6.58030033e-01f, -1.28782392e-01f, 2.18626201e-01f, 4.92477626e-01f, 3.91473472e-01f, -3.47335543e-03f, 9.99514759e-02f, 1.11837184e+00f,
  -2.36111637e-02f, 4.66714859e-01f, 1.90621451e-01f, -1.28964052e-01f, -6.92736685e-01f, 8.11334193e-01f, 3.51559192e-01f, 6.37397766e-01f, 6.33908153e-01f, 2.83000946e-01f,
  9.08693373e-01f, 3.45241725e-01f, 5.89200556e-01f, 6.07225239e-01f, 3.72369409e-01f, -2.58880854e-01f, -5.98689675e-01f, -2.32427925e-01f, 1.63291708e-01f, -1.67462006e-01f,
  -5.45441031e-01f, 9.21792984e-01f, -4.93746281e-01f, 6.47108495e-01f, -6.95446134e-02f, -1.80519789e-01f, -5.07977009e-01f, 1.91376492e-01f, -7.70854875e-02f, -4.73741926e-02f,
  4.56586689e-01f, -3.13875228e-01f, 3.89391065e-01f, 1.01455963e+00f, 5.20535290e-01f, 1.00993407e+00f, 1.69235900e-01f, -6.23104274e-01f, 7.58844092e-02f, -6.03474140e-01f,
  1.12910450e-01f, 8.51584315e-01f, 2.31032684e-01f, 4.16414827e-01f, 3.38758498e-01f, 1.43080670e-02f, 1.52656928e-01f, 2.31233448e-01f, -6.28122389e-01f, -1.23899944e-01f,
  9.36321139e-01f, -3.43257666e-01f, -5.41164935e-01f, -2.06003368e-01f, -2.31449321e-01f, -6.25002980e-02f, 3.11177433e-01f, -1.14105932e-01f, -4.35088009e-01f, 6.74132645e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  -1.63720697e-02f, 5.81009269e-01f, 2.01098263e-01f, 4.41343457e-01f, 3.69686216e-01f, 5.28483510e-01f, 2.05279142e-01f, 2.23805308e-01f, 3.29645365e-01f, 5.15784800e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.35797486e-01f, -4.07928854e-01f, -2.48600155e-01f, -4.29652989e-01f, -2.60464132e-01f, 4.87138741e-02f, -1.28531754e-01f, -1.16570562e-01f, -3.31441164e-01f, 3.29789579e-01f,
  3.83322015e-02f, -3.76183242e-01f, 2.65983701e-01f, 1.03631012e-01f, 3.91274303e-01f, -1.98615998e-01f, 5.61767258e-02f, -4.73148189e-02f, 1.09072044e-01f, 1.19948737e-01f,
  6.55463815e-01f, -3.41526121e-01f, -1.41982749e-01f, 2.83707380e-01f, -2.26330966e-01f, -2.68396642e-02f, -3.23879927e-01f, 2.86214858e-01f, 3.83285643e-03f, -2.26655930e-01f,
  2.17971757e-01f, -7.26200715e-02f, -3.08124036e-01f, 1.26595721e-01f, 1.39702737e-01f, 4.24769491e-01f, -3.73918384e-01f, 1.94148391e-01f, 1.85448080e-01f, 5.32080494e-02f,
  3.41463298e-01f, -2.56165773e-01f, 6.79599941e-02f, 1.73033088e-01f, -3.19907129e-01f, 2.84460455e-01f, -3.40545863e-01f, -4.38700058e-02f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -4.30138618e-01f, -2.11625081e-02f, 5.61718881e-01f, 8.02686751e-01f, -6.30595744e-01f, 9.41883683e-01f, -2.05066547e-01f, 1.52805701e-01f, -5.74855581e-02f, -3.63022566e-01f,
  4.06055540e-01f, 4.30911720e-01f, -1.05433416e+00f, -2.79961079e-01f, 5.08943141e-01f, 2.65515655e-01f, 7.37971306e-01f, 6.77693859e-02f, 7.32795417e-01f, 5.72773665e-02f,
  1.06603608e-01f, -7.03186452e-01f, 3.24576050e-01f, 2.39449516e-01f, -6.12106562e-01f, 2.07685649e-01f, -1.80700645e-01f, -2.77900994e-01f, 3.57451022e-01f, 9.49508071e-01f,
  9.89573419e-01f, 8.42284635e-02f, 3.11480075e-01f, 2.93047547e-01f, 8.55830431e-01f, 9.66200471e-01f, -4.46810126e-01f, 6.71637714e-01f, -7.62138128e-01f, 7.84804165e-01f,
  -1.13957115e-01f, 2.85167366e-01f, 5.08269668e-01f, 4.57879335e-01f, -3.81307989e-01f, -5.07028811e-02f, 9.51311052e-01f, 1.31256676e+00f, -1.01275384e+00f, -2.93095052e-01f,
  -7.09511518e-01f, 2.17309490e-01f, -1.65092587e-01f, 7.55968034e-01f, 6.42663181e-01f, 1.82490930e-01f, -1.11510679e-01f, 1.35868445e-01f, -3.60631019e-01f, 6.14409864e-01f,
  1.50399968e-01f, -1.28551996e+00f, 8.38455498e-01f, -5.24893820e-01f, -2.72791147e-01f, -7.43894637e-01f, -2.98244119e-01f, -2.98336357e-01f, -7.43106246e-01f, -4.18472379e-01f,
  -3.58722918e-02f, 3.33438158e-01f, 1.15838361e+00f, 4.44634944e-01f, 1.04073501e+00f, -2.71803677e-01f, 4.28518534e-01f, -1.57482892e-01f, 2.30682462e-01f, 1.00508086e-01f,
  -4.78236645e-01f, -3.44092935e-01f, -1.10400192e-01f, -9.02940392e-01f, -9.44836438e-02f, -6.45376563e-01f, -1.29274756e-01f, 3.45557600e-01f, 1.67463854e-01f, 9.61402535e-01f,
  -1.39698341e-01f, -3.97130072e-01f, 9.28930819e-01f, -9.28111613e-01f, 4.67237890e-01f, -4.41708535e-01f, 6.42968416e-01f, 8.42934310e-01f, 2.66985983e-01f, 5.73120177e-01f,
  8.84338558e-01f, -1.58982068e-01f, 2.69243479e-01f, 5.11506021e-01f, -3.88323784e-01f, 4.02767211e-01f, -7.39720404e-01f, 7.88035929e-01f, 3.49259436e-01f, 5.29453516e-01f,
  -6.13889217e-01f, 6.29337907e-01f, 3.82244170e-01f, 8.40546429e-01f, 3.54187906e-01f, 2.30055347e-01f, 7.60234952e-01f, -2.91020185e-01f, 4.59818900e-01f, 5.95893741e-01f,
  -6.63164377e-01f, 5.68795323e-01f, -5.46360314e-01f, 7.22544670e-01f, 4.20018733e-01f, 1.58498839e-01f, -2.55649567e-01f, 6.79148138e-02f, 4.19519275e-01f, 4.18792486e-01f,
  9.98643875e-01f, -5.49763322e-01f, 8.48120689e-01f, 2.51154155e-01f, -5.97990513e-01f, 7.27850974e-01f, 5.91805100e-01f, 3.49947602e-01f, 6.26826644e-01f, -2.03153804e-01f,
  3.59097183e-01f, 2.09277809e-01f, 2.97818445e-02f, 1.25737369e+00f, -4.86777164e-02f, -4.66487795e-01f, -2.77729034e-01f, 1.08728878e-01f, -9.64586079e-01f, -7.42438614e-01f,
  1.03321826e+00f, -2.72561759e-01f, 9.13157225e-01f, -1.70779780e-01f, 6.38611972e-01f, 8.03011656e-01f, 3.68584335e-01f, 6.54009104e-01f, -5.34757912e-01f, -7.82102823e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  6.23401105e-01f, 5.62943995e-01f, 4.14447427e-01f, 1.91333085e-01f, -1.42084837e-01f, -5.86179979e-02f, 3.97165269e-01f, 5.07441580e-01f, 3.35107565e-01f, 1.72054246e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  4.06666338e-01f, -6.16650470e-02f, -5.46895433e-04f, -1.61257818e-01f, 1.92875460e-01f, -5.90347767e-01f, -7.29275346e-01f, 1.12138681e-01f, -1.37296379e+00f, 6.58667982e-02f,
  -4.78327304e-01f, 2.37134069e-01f, 4.20764089e-01f, 4.07807320e-01f, -6.38299108e-01f, -3.78889143e-02f, -4.81998384e-01f, 5.12120187e-01f, -3.60764116e-01f, 4.41846520e-01f,
  -5.26047885e-01f, -5.71481943e-01f, -6.46016359e-01f, 3.63057032e-02f, -1.38363898e-01f, 1.18198290e-01f, 3.22308958e-01f, 6.02285385e-01f, -4.73726988e-01f, -1.55374944e-01f,
  -4.04052526e-01f, -7.36099631e-02f, 3.01481843e-01f, -4.42526430e-01f, 2.37105981e-01f, 1.89186946e-01f, 3.80736560e-01f, 1.37975976e-01f, -3.92529577e-01f, -1.05620849e+00f,
  -4.53406036e-01f, -8.50161433e-01f, 5.97636104e-01f, 3.10462445e-01f, -9.50264394e-01f, -1.14833808e+00f, 7.66780004e-02f, 3.06581527e-01f, -2.12074861e-01f, -2.28335857e-01f,
  -1.01487547e-01f, 2.69320756e-01f, 3.99927676e-01f, 5.01631379e-01f, 2.54953414e-01f, -8.62761319e-01f, 2.29537815e-01f, 5.53835452e-01f, -1.11696076e+00f, -4.73589271e-01f,
  2.88910598e-01f, 2.32591942e-01f, -8.69979739e-01f, -3.04086655e-01f, -6.43749535e-01f, -3.40786832e-03f, 4.91360009e-01f, -7.38756061e-01f, 9.88341153e-01f, -3.00039411e-01f,
  -9.01717901e-01f, 3.39483023e-01f, 7.38341585e-02f, -3.02043438e-01f, -1.10388684e+00f, -8.15519154e-01f, 6.61168456e-01f, 4.46819156e-01f, 1.63484961e-01f, -1.40763268e-01f,
  5.36307633e-01f, 1.18595608e-01f, -3.75623703e-01f, 7.65032411e-01f, 6.29482031e-01f, -4.22966689e-01f, -9.00197864e-01f, 4.50507909e-01f, -1.37363072e-03f, -7.57196784e-01f,
  -1.83931410e-01f, 4.14327621e-01f, 1.99684307e-01f, 1.53407112e-01f, 3.89235228e-01f, -8.23409379e-01f, -4.46312606e-01f, 3.11940815e-02f, 1.48444846e-01f, -2.28579581e-01f,
  -5.84677875e-01f, 3.92778963e-01f, -9.02312338e-01f, -1.61367416e-01f, 1.11171638e-03f, -1.13250625e+00f, 1.71303138e-01f, -4.57023740e-01f, 1.70664757e-01f, -1.52330920e-01f,
  4.26268697e-01f, 1.51726976e-01f, 3.46348137e-01f, 1.59759015e-01f, 2.25234956e-01f, 7.86643982e-01f, 3.73574525e-01f, -4.70133364e-01f, 4.99581099e-01f, 6.56431019e-01f,
  3.03672463e-01f, 7.07821906e-01f, -5.85274279e-01f, -1.37503296e-01f, -5.95435739e-01f, -7.38525271e-01f, -4.90815610e-01f, -1.05267191e+00f, 3.51029903e-01f, -1.46016464e-01f,
  -8.33327100e-02f, 1.40403867e-01f, -4.38168228e-01f, -5.48626006e-01f, -4.14458066e-01f, 2.88935542e-01f, 4.55511898e-01f, -5.10022163e-01f, 2.73091644e-01f, 5.16561083e-02f,
  -1.02965951e+00f, -1.07121933e+00f, 5.30958056e-01f, -8.16781938e-01f, 3.23186278e-01f, -4.70159531e-01f, -2.96534300e-01f, -5.37784457e-01f, -7.20108449e-01f, 4.44737166e-01f,
  -4.50907290e-01f, 5.88853538e-01f, -1.05987549e+00f, -8.70821476e-01f, -6.01864532e-02f, -4.80699867e-01f, -4.85069863e-02f, -9.18156430e-02f, -7.36458778e-01f, 6.63289487e-01f,
  1.65942833e-01f, 7.39611834e-02f, 3.09610646e-02f, -2.85691857e-01f, 3.14323306e-02f, 4.42171276e-01f, 4.99550849e-01f, -1.96850970e-01f, 2.42019787e-01f, 9.53430682e-02f,
  2.52786130e-01f, -5.02405107e-01f, -8.46758902e-01f, -6.52211070e-01f, -5.90983868e-01f, 3.33804607e-01f, -2.19698012e-01f, 7.36303866e-01f, 4.91239697e-01f, -3.98887485e-01f,
  3.58044147e-01f, 7.99559951e-01f, 5.74724615e-01f, 7.37005472e-02f, 7.60705888e-01f, -1.30114686e+00f, -3.68091911e-01f, -7.79756725e-01f, 8.41711387e-02f, -3.35935988e-02f,
  -6.62749857e-02f, -4.71329182e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.67886573e-01f, -1.49815217e-01f, -7.41115026e-03f, 1.85930878e-01f, 2.37268969e-01f, -6.41551241e-02f, 1.24598481e-01f, -4.54184674e-02f, 8.91881064e-02f, 1.22073129e-01f,
  -1.66990608e-01f, 1.08698336e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    