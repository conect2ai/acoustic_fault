/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.97945926e-02f, 5.81170976e-01f, 2.06041411e-02f, 1.57739967e-02f, 1.10502735e-01f, -8.83436948e-02f, 2.50587702e-01f, 6.39713928e-02f, -1.83725342e-01f, 2.59927064e-01f,
  2.46192366e-01f, -4.81329635e-02f, -9.24343318e-02f, -7.33929724e-02f, -7.27094933e-02f, 1.73004508e-01f, 9.36845466e-02f, -2.30179518e-01f, -4.57355589e-01f, -7.52445236e-02f,
  8.93037096e-02f, -1.48746381e-02f, -1.22992761e-01f, -1.13385081e-01f, 1.35163292e-01f, -1.50253132e-01f, 8.67482945e-02f, 8.58992189e-02f, 3.99104282e-02f, 3.28126132e-01f,
  -3.94934155e-02f, 3.28804672e-01f, -1.47607863e-01f, 2.61074398e-02f, 6.59432858e-02f, -1.06295757e-01f, -8.57426077e-02f, 1.51484720e-02f, -7.10246786e-02f, -3.58555205e-02f,
  9.57024693e-02f, 8.61213803e-02f, 1.49634629e-01f, -8.45120326e-02f, -1.96161512e-02f, -4.16058078e-02f, 5.82298003e-02f, 2.36226413e-02f, -1.98384494e-01f, -1.01790585e-01f,
  1.25770569e-01f, 6.07018024e-02f, 8.66699126e-03f, -1.44103484e-03f, -8.73843506e-02f, -4.56921756e-02f, 1.20605156e-01f, -2.45796125e-02f, -1.82036757e-01f, 1.27209798e-01f,
  -2.31825020e-02f, 9.02953371e-02f, -2.24237144e-02f, 3.38145532e-02f, -1.22815780e-02f, 4.69301604e-02f, 3.03126592e-02f, 7.23309517e-02f, 1.17664328e-02f, 8.45133048e-03f,
  -3.63608338e-02f, -8.63178223e-02f, 3.80122438e-02f, -1.56678795e-03f, -2.57725026e-02f, 7.12747946e-02f, -2.46619415e-02f, 8.54349136e-02f, -4.88984212e-02f, -5.24370605e-03f,
  -7.55358487e-03f, -4.74608541e-02f, 4.71922709e-03f, -2.53143795e-02f, -1.72095131e-02f, -3.50261405e-02f, -4.43507396e-02f, 6.16878718e-02f, -7.66082332e-02f, 3.98035720e-02f,
  -1.60097688e-01f, -1.46298021e-01f, 3.07873487e-02f, 4.06009667e-02f, -7.28059039e-02f, -5.64877354e-02f, 1.60233472e-02f, -2.96002459e-02f, 3.99030857e-02f, 3.39194722e-02f,
  -1.60177089e-02f, -2.67686527e-02f, 9.65640973e-03f, 6.60550455e-03f, -1.29313357e-02f, -1.51031800e-02f, 2.60991901e-02f, -7.28848437e-03f, -1.20201455e-02f, -4.40133512e-02f,
  -4.33854647e-02f, -8.99150968e-02f, -7.51501322e-02f, 4.37216740e-03f, -1.14609189e-01f, -1.95566192e-01f, -9.94635299e-02f, -9.96291935e-02f, -1.69944838e-01f, -5.83454221e-02f,
  2.43096173e-01f, -1.82973426e-02f, 7.58072436e-02f, -6.92942888e-02f, 2.62466092e-02f, 1.66659176e-01f, 3.09584588e-01f, 9.72367898e-02f, -1.14646025e-01f, 2.61419229e-02f,
  -8.37217793e-02f, -1.69266701e-01f, -1.50319755e-01f, -1.20966345e-01f, 1.38001382e-01f, 8.48178286e-03f, 1.00757843e-02f, 4.09641378e-02f, 2.82488130e-02f, 6.64810985e-02f,
  -5.78515381e-02f, -1.41103178e-01f, 6.41189143e-02f, 8.76625776e-02f, -1.29179850e-01f, -1.37893721e-01f, -6.97255805e-02f, -8.82588625e-02f, 9.18834805e-02f, -1.40450373e-01f,
  -1.82352185e-01f, -8.84454406e-04f, 4.19418141e-02f, 5.71249239e-02f, -3.79121266e-02f, -7.51601085e-02f, -5.37711345e-02f, -6.20495416e-02f, 5.36029562e-02f, -6.34582564e-02f,
  -1.12709649e-01f, -8.68794620e-02f, -6.95147663e-02f, -1.92260649e-02f, 5.68771362e-02f, 2.79465187e-02f, 5.44512179e-03f, -4.69963141e-02f, 1.00203929e-02f, -2.34420691e-02f,
  -1.28950803e-02f, 6.40595481e-02f, 9.01602283e-02f, 4.91670817e-02f, 1.91414095e-02f, 1.07218914e-01f, -4.29256409e-02f, -2.62711495e-02f, 1.51675776e-01f, -1.14201427e-01f,
  -7.18088006e-04f, -6.95801526e-02f, 1.22145012e-01f, 7.23865926e-02f, -2.44640224e-02f, 2.33203899e-02f, -2.56812591e-02f, -9.49216168e-03f, -1.59060843e-02f, -3.86475958e-02f,
  -2.72713378e-02f, 2.62317918e-02f, -5.31524308e-02f, 3.68735753e-02f, -8.23283270e-02f, 4.92972927e-03f, 4.76078950e-02f, 1.67511613e-03f, -6.35556802e-02f, 3.55144665e-02f,
  -7.51515552e-02f, 3.55216451e-02f, 1.35765867e-02f, -9.27721523e-03f, 9.86240804e-02f, -4.13761809e-02f, -3.61127444e-02f, -5.30762188e-02f, -9.90010351e-02f, 4.87186909e-02f,
  -1.89475492e-01f, 1.28305569e-01f, -1.33255273e-01f, -5.33152036e-02f, -3.33120897e-02f, -1.54741388e-02f, -5.94387166e-02f, 1.02641794e-03f, -1.05591994e-02f, 3.98639999e-02f,
  1.09609470e-01f, -4.19464111e-02f, -7.95027018e-02f, -1.30388960e-02f, -3.59666757e-02f, 1.86343286e-02f, 4.15425673e-02f, 3.44940461e-02f, -1.47575792e-02f, -3.61307785e-02f,
  -3.82794999e-02f, 1.46481231e-01f, 8.72333124e-02f, 4.68162224e-02f, -1.90669280e-02f, -5.61560541e-02f, -7.75695518e-02f, -4.59322073e-02f, 1.44407123e-01f, 1.93302874e-02f,
  -3.78076702e-01f, -3.36081944e-02f, -1.22311130e-01f, 1.18689634e-01f, 8.35559815e-02f, -1.99182272e-01f, -1.88068837e-01f, -9.29323137e-02f, 1.11689530e-02f, -4.65235412e-02f,
  -7.72258416e-02f, 1.39823958e-01f, -6.41815662e-02f, 8.30811039e-02f, -1.63580641e-01f, 4.68145236e-02f, 6.85291216e-02f, -1.17174521e-01f, -2.03262836e-01f, -3.14977206e-02f,
  1.01402335e-01f, 9.87481475e-02f, -8.32758173e-02f, -4.41085314e-03f, 1.76552534e-01f, 7.64567703e-02f, 7.93027431e-02f, 5.83463199e-02f, -4.70376089e-02f, 3.36510092e-01f,
  1.18333928e-01f, -1.23014815e-01f, -2.88412441e-03f, -6.37208074e-02f, 9.61580575e-02f, 5.77136362e-03f, -3.02914940e-02f, 3.08400635e-02f, -3.67517211e-02f, -3.73226851e-02f,
  6.64988160e-02f, -2.98404358e-02f, -1.10670030e-02f, 1.96755193e-02f, 5.44507839e-02f, 3.72419395e-02f, -1.94514710e-02f, -1.10430852e-01f, -8.02492127e-02f, 5.26487567e-02f,
  1.18075490e-01f, 5.71162216e-02f, -5.64697832e-02f, 3.59464064e-02f, -1.31170899e-01f, -7.69769549e-02f, 2.14222595e-02f, -7.62344152e-02f, -9.10279676e-02f, 7.02091530e-02f,
  -6.74205050e-02f, -6.28350973e-02f, 5.17654531e-02f, 1.14434110e-02f, 7.67376786e-03f, -5.31132147e-02f, 8.70504826e-02f, -3.04888822e-02f, 5.99177973e-03f, -6.32008119e-03f,
  -4.93671261e-02f, -4.66746930e-03f, 3.62962000e-02f, -3.71105336e-02f, 2.63539627e-02f, 4.38080123e-03f, 1.96547946e-03f, -2.98151691e-02f, -4.02910039e-02f, 1.06992535e-02f,
  -1.08997189e-02f, 5.23412786e-03f, 3.97142768e-02f, 2.37855352e-02f, 3.84477079e-02f, -2.83315778e-02f, 3.66110876e-02f, -2.73166578e-02f, -5.42876963e-03f, -9.41331126e-03f,
  1.58723608e-01f, -1.76772013e-01f, 1.24182165e-01f, -7.72746513e-04f, 2.12923791e-02f, -1.88108627e-02f, 2.38701254e-02f, 2.59962268e-02f, -1.91851817e-02f, 7.26426393e-02f,
  -3.52101251e-02f, -3.22615281e-02f, -5.33121312e-03f, 4.84982841e-02f, -4.68509495e-02f, -2.84438152e-02f, 4.36918139e-02f, -1.64664760e-02f, 4.24419902e-02f, -2.24488936e-02f,
  -2.66582966e-02f, 2.29334868e-02f, 3.04288957e-02f, -3.31324451e-02f, 6.17317297e-02f, -6.45276457e-02f, 6.62678927e-02f, 3.66118923e-02f, -1.84030719e-02f, -8.85182545e-02f,
  5.26343472e-02f, 3.00945491e-01f, -3.96775872e-01f, 3.82658362e-01f, 1.53055757e-01f, -1.62220448e-01f, -1.18164569e-01f, 5.17764278e-02f, 1.61528930e-01f, 8.29422697e-02f,
  1.43863812e-01f, 8.93540904e-02f, -3.38531937e-03f, 2.66706366e-02f, -1.87783748e-01f, -2.44717881e-01f, -4.59976971e-01f, -4.73760754e-01f, -1.95124850e-01f, 5.36965504e-02f,
  1.56171739e-01f, -3.73572521e-02f, -6.52422681e-02f, -4.63162512e-02f, 1.99227497e-01f, -1.41324978e-02f, -1.48965158e-02f, 1.05838194e-01f, -6.57133535e-02f, -7.76229501e-02f,
  -7.10180029e-02f, 1.92270540e-02f, -9.50675979e-02f, 1.39738256e-02f, 8.73660727e-04f, -1.12033866e-01f, -9.79230106e-02f, -6.51633739e-02f, 1.00734709e-02f, -4.71146330e-02f,
  6.42057210e-02f, -6.30870089e-02f, -3.10660452e-02f, 9.19103399e-02f, -1.76864408e-03f, 2.60617789e-02f, -2.65404135e-02f, -1.12326108e-01f, -5.75017706e-02f, -1.88855249e-02f,
  1.94808841e-01f, 6.10371716e-02f, -9.38023254e-03f, 9.82614905e-02f, -1.42060418e-03f, -6.64733499e-02f, 1.06148928e-01f, -6.08148472e-03f, -8.14119801e-02f, 1.09572463e-01f,
  6.90652058e-02f, -1.92863643e-02f, 4.91041839e-02f, 6.57344759e-02f, 1.11368829e-02f, 7.66421258e-02f, -2.70586219e-02f, 7.67580792e-02f, -3.82462307e-03f, 6.92609921e-02f,
  5.30243143e-02f, -5.00360914e-02f, -3.27550694e-02f, 2.51617469e-02f, -4.98582274e-02f, -5.33435494e-02f, 1.34910960e-02f, 2.07201112e-02f, 8.88723508e-03f, -7.98502006e-03f,
  -1.18897045e-02f, 2.09479127e-02f, 6.86185658e-02f, 2.07655737e-03f, -6.57774974e-03f, -1.86409652e-02f, 4.45148535e-02f, -3.15308087e-02f, 6.21873848e-02f, -7.67155960e-02f,
  3.56103539e-01f, -2.08929971e-01f, 2.04573888e-02f, -1.40036926e-01f, 4.87882011e-02f, -1.52957439e-02f, 5.57315163e-02f, -4.19827476e-02f, -5.08090761e-03f, 1.98449418e-02f,
  7.39597008e-02f, -3.73780616e-02f, 6.35389388e-02f, 2.57422626e-02f, -2.76859216e-02f, 3.14767752e-03f, 1.14149138e-01f, 5.32674342e-02f, -2.11860798e-02f, 9.80173275e-02f,
  5.79043850e-02f, 1.09658375e-01f, 1.34615213e-01f, 3.33426408e-02f, 4.76472303e-02f, -6.24533519e-02f, -2.43005380e-02f, 3.13534699e-02f, -1.28539532e-01f, 1.31189197e-01f,
  4.89791989e-01f, -9.91526917e-02f, 8.53781998e-02f, 2.55382806e-01f, 3.14836264e-01f, 3.89828905e-02f, -4.45100218e-02f, -1.90895095e-01f, 8.06876644e-02f, -1.62245080e-01f,
  -8.08341950e-02f, 1.27326548e-01f, -3.60717289e-02f, -6.53077066e-02f, 3.48781757e-02f, -4.89370190e-02f, 9.00343433e-02f, 2.08510309e-01f, 2.38345832e-01f, 1.58169940e-01f,
  1.19437017e-01f, 3.85404974e-01f, 2.81475782e-01f, 5.45328185e-02f, 7.56045729e-02f, 1.32355899e-01f, -1.75113119e-02f, 1.15732946e-01f, -9.34382807e-03f, 1.85449079e-01f,
  -2.91670151e-02f, 1.50814742e-01f, 8.03811383e-03f, 1.50510848e-01f, -2.43827868e-02f, -6.28055111e-02f, -4.02262956e-02f, 8.25790092e-02f, -5.03391325e-02f, -2.63819657e-03f,
  1.81551632e-02f, 1.76457558e-02f, 8.55835974e-02f, 5.48557267e-02f, 6.73521906e-02f, 6.32661805e-02f, 4.63966420e-03f, -2.71690101e-03f, -8.24388415e-02f, -1.39613494e-01f,
  -5.25569096e-02f, 1.53537899e-01f, 1.40929878e-01f, -5.64815588e-02f, -1.54577032e-01f, 1.37377605e-01f, -1.38489559e-01f, -2.57190522e-02f, -7.28206560e-02f, -9.28355679e-02f,
  -4.73140664e-02f, -6.41277358e-02f, 1.95637695e-03f, 1.16730947e-02f, 1.76758319e-02f, -1.63441170e-02f, 3.53138186e-02f, 5.05577363e-02f, -1.54269580e-02f, -7.94808194e-02f,
  -5.92217259e-02f, 8.18950217e-03f, -6.78711534e-02f, -8.09522271e-02f, 1.67850126e-02f, 8.06397349e-02f, 2.41354555e-02f, 3.52366874e-03f, -3.89237367e-02f, 9.64379590e-03f,
  6.76341876e-02f, -4.64297421e-02f, 1.05971038e-01f, -6.23813123e-02f, 1.87487043e-02f, 1.18219787e-02f, 1.55685041e-02f, 1.48159666e-02f, -3.55715901e-02f, 7.01573268e-02f,
  -9.75875929e-03f, 1.04234189e-01f, -7.28363544e-02f, 3.75875421e-02f, 2.61645168e-02f, -5.69240376e-02f, 2.98188031e-02f, -3.87959220e-02f, 1.10769451e-01f, 8.36813543e-03f,
  3.97403501e-02f, 1.72992777e-02f, -2.28987709e-02f, -3.61273959e-02f, 2.66944850e-03f, 3.72408587e-03f, -6.15255907e-02f, 9.10776854e-02f, -1.37079023e-02f, -1.25731193e-02f,
  -9.66061875e-02f, -4.21776362e-02f, 9.46842320e-03f, -1.17335491e-01f, 8.84588808e-03f, 1.97802603e-01f, 1.52700096e-02f, -4.65044230e-02f, -3.98912653e-02f, -2.94848651e-01f,
  2.23531481e-02f, 2.16177836e-01f, 1.02298848e-01f, 4.13433649e-02f, 9.47074667e-02f, -1.33125395e-01f, -1.22869760e-01f, -1.08707868e-01f, -5.33341281e-02f, 1.55102044e-01f,
  1.52511880e-01f, -1.32468969e-01f, -1.08723626e-01f, -1.19178005e-01f, -2.34171674e-01f, -5.30776083e-02f, 1.22257277e-01f, -4.78761159e-02f, -2.49378398e-01f, -1.21407583e-01f,
  -4.83435988e-02f, 3.42602693e-02f, -1.69435143e-01f, -7.82497227e-02f, 1.15165979e-01f, -3.10383756e-02f, 1.21367387e-01f, 7.80255869e-02f, 1.32663414e-01f, 2.86343157e-01f,
  6.89142719e-02f, 1.41743049e-01f, -3.21403556e-02f, -1.37383314e-02f, 1.41010936e-02f, -2.33058464e-02f, -3.90399918e-02f, 1.31577002e-02f, 2.21292600e-02f, -7.02487454e-02f,
  9.63642150e-02f, -7.54140019e-02f, -3.50241689e-03f, 6.09791130e-02f, -1.39574613e-02f, -5.22971377e-02f, -5.45734027e-03f, -2.20923242e-03f, -7.95102268e-02f, 4.64499518e-02f,
  -2.05409676e-02f, 1.53505400e-01f, 6.22852072e-02f, 5.02545051e-02f, 2.52763405e-02f, -4.94168401e-02f, 4.35715206e-02f, 2.49568652e-02f, 5.97653128e-02f, 6.52757213e-02f,
  5.23499921e-02f, 2.59175394e-02f, -1.21384498e-03f, 9.31720436e-02f, -4.00156975e-02f, 5.60676642e-02f, 5.25062568e-02f, 1.02758349e-03f, 3.45701352e-02f, -1.18363164e-02f,
  3.60527704e-03f, 3.07301190e-02f, -4.44272486e-03f, 8.73071030e-02f, 5.36316931e-02f, 4.35401835e-02f, 2.55812388e-02f, -6.79851100e-02f, 1.78781431e-02f, 5.19413240e-02f,
  -7.79204012e-04f, -5.73398620e-02f, 4.49616835e-03f, -5.52663170e-02f, 3.91966328e-02f, 1.96624193e-02f, -2.30137557e-02f, 9.27152764e-03f, 8.36622193e-02f, 5.41292578e-02f,
  -1.76925793e-01f, -5.93863893e-04f, -2.75632851e-02f, -4.61483076e-02f, -1.44730462e-02f, 4.23525833e-02f, 3.03283501e-02f, 5.84816001e-02f, 5.83264269e-02f, -3.75647582e-02f,
  -1.18698157e-01f, 6.83964193e-02f, 4.06699330e-02f, -4.11007963e-02f, -6.85658231e-02f, 4.21351055e-03f, 8.04746151e-02f, -5.94638987e-03f, -7.50639588e-02f, -2.59803887e-02f,
  6.76300842e-03f, -9.59744602e-02f, -8.40177909e-02f, -5.06038144e-02f, 9.80268270e-02f, -2.93026585e-02f, -8.16622525e-02f, -1.86339356e-02f, -1.81745455e-01f, -1.33069292e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.99987009e-01f, -6.65354580e-02f, -2.53343061e-02f, -8.84669498e-02f, -5.03983013e-02f, -1.64825603e-01f, -2.11010039e-01f, -6.31692410e-02f, -6.46970123e-02f, -1.34451926e-01f,
  2.19383333e-02f, -2.92338140e-04f, 9.50822011e-02f, 1.18756391e-01f, 8.99048746e-02f, -1.26611546e-01f, -1.37534231e-01f, -3.57980542e-02f, 1.42458007e-02f, -3.77652571e-02f,
  -6.97746351e-02f, 1.70606822e-02f, -5.19603901e-02f, 7.09581450e-02f, 3.83431353e-02f, 1.16240717e-02f, -8.76817554e-02f, 8.56621470e-03f, -1.04706377e-01f, -7.58390203e-02f,
  1.50275007e-01f, -8.95958245e-02f, -2.86517031e-02f, -2.42105648e-02f, -4.04175594e-02f, -3.21081877e-02f, -8.03802721e-03f, 1.92227657e-03f, -5.52616641e-02f, 5.42090423e-02f,
  -7.87178427e-02f, -1.88758802e-02f, 7.30952322e-02f, -9.19770449e-02f, -2.96070408e-02f, 6.69502467e-02f, 1.57367848e-02f, 5.52292280e-02f, -7.81338140e-02f, -3.08476053e-02f,
  4.49950024e-02f, -6.40614331e-03f, 5.91235906e-02f, -4.39891405e-02f, 9.14159324e-03f, 1.20489694e-01f, 3.45025398e-02f, 9.11729187e-02f, -6.69220313e-02f, -6.79093674e-02f,
  4.29371074e-02f, -3.96475904e-02f, 4.87765484e-02f, 3.23423631e-02f, 6.97543323e-02f, 1.62044447e-02f, 4.36225720e-02f, 7.36350715e-02f, 6.87725767e-02f, 2.02681553e-02f,
  2.66947635e-02f, -4.72287089e-02f, 5.97971976e-02f, -3.63269672e-02f, 3.07427701e-02f, -3.22792330e-03f, 1.42919542e-02f, 2.97756284e-03f, 4.61210310e-02f, -1.15835160e-01f,
  -9.07042250e-02f, -6.10327981e-02f, 2.86077615e-02f, 5.66754006e-02f, -1.63813516e-01f, -3.13301175e-03f, -2.71191206e-02f, -2.30604317e-02f, 5.96668087e-02f, -4.45867777e-02f,
  1.11437872e-01f, 6.61000535e-02f, -3.69393080e-02f, 3.58262993e-02f, -4.72014509e-02f, -6.80388808e-02f, 8.71799067e-02f, 4.94374707e-03f, 1.27353668e-02f, 8.67803618e-02f,
  6.41021505e-02f, -2.69895811e-02f, -1.84320509e-02f, -8.03818852e-02f, 5.29744029e-02f, -6.47144625e-03f, -1.32236080e-02f, -6.40155300e-02f, 6.04338534e-02f, -1.20886490e-02f,
  -6.10923879e-02f, 4.11393456e-02f, 2.97742877e-02f, -6.32521580e-04f, 2.00393833e-02f, -1.98232140e-02f, 1.10891126e-01f, 5.85169122e-02f, 5.97990938e-02f, 1.48336459e-02f,
  2.87095487e-01f, -2.09424868e-01f, -1.75485328e-01f, 1.90113652e-02f, -1.95997432e-01f, -1.01270571e-01f, -9.05055776e-02f, -9.20019969e-02f, -3.51656526e-02f, -2.98995827e-03f,
  -7.52943233e-02f, 6.83308318e-02f, 1.74701259e-01f, 1.19110517e-01f, 9.55368355e-02f, -9.20170918e-02f, -7.13908523e-02f, 1.76857656e-03f, 1.43597230e-01f, -1.04638793e-01f,
  -1.48250073e-01f, 2.70709693e-02f, 8.33380446e-02f, -1.14730857e-02f, -8.38338360e-02f, 5.71304522e-02f, -2.96162423e-02f, -7.45199174e-02f, -9.33130383e-02f, -1.56004444e-01f,
  -1.53123215e-01f, 2.60703191e-02f, 6.45913407e-02f, 4.79580499e-02f, -3.18081230e-02f, 6.48060963e-02f, 4.10763919e-03f, 1.94097385e-02f, 6.25088587e-02f, -5.60874604e-02f,
  2.76867189e-02f, -2.00261995e-02f, 4.86622415e-02f, -3.50697897e-02f, -1.00093439e-01f, -3.04268021e-02f, 6.54995665e-02f, -3.81281152e-02f, 1.60338301e-02f, -7.12508485e-02f,
  -6.05903417e-02f, 2.14165589e-03f, 2.44621886e-03f, -2.20545065e-02f, 1.00143356e-02f, -3.85874733e-02f, -4.59529161e-02f, -1.49169281e-01f, 7.52554741e-03f, -1.70550674e-01f,
  -2.12077070e-02f, 7.43114501e-02f, 2.07079388e-02f, -2.89413612e-04f, 2.80442331e-02f, 8.58863145e-02f, -4.45350213e-03f, 4.49873536e-04f, 5.30081242e-02f, 5.58835082e-02f,
  -4.92337234e-02f, -4.38577794e-02f, -2.93549616e-02f, 9.68269259e-02f, -4.84918766e-02f, -6.09460436e-02f, -3.85610163e-02f, -1.86802056e-02f, -5.26180156e-02f, 1.18188120e-01f,
  8.57698843e-02f, 1.04724038e-02f, -2.46102512e-02f, 1.79840717e-02f, -3.62532735e-02f, 2.25634016e-02f, -1.61652584e-02f, 1.06170408e-01f, -2.80384906e-04f, 2.64842398e-02f,
  3.17308791e-02f, 7.60691101e-03f, 6.41356930e-02f, 3.00728381e-02f, -1.95248742e-02f, 2.62355860e-02f, 8.02034959e-02f, 4.62435894e-02f, 6.66920319e-02f, -9.29173455e-02f,
  -1.26449848e-02f, 1.05946153e-01f, -4.98752110e-02f, -9.20164883e-02f, -2.26174686e-02f, -8.28235149e-02f, 6.64458703e-03f, 7.25398287e-02f, 1.07543133e-01f, -7.86571428e-02f,
  4.07827422e-02f, 1.12724386e-01f, 8.52658898e-02f, -3.64973135e-02f, -1.48170758e-02f, 7.30870217e-02f, -1.09356120e-01f, 1.77789181e-02f, 4.58744122e-03f, -4.20533642e-02f,
  1.46768689e-02f, -3.33354622e-02f, -3.66839200e-01f, 4.29837294e-02f, -1.25253722e-01f, -5.26226535e-02f, -7.03750476e-02f, 5.34580201e-02f, 9.56100300e-02f, -1.50432259e-01f,
  -6.59467950e-02f, 1.26596913e-01f, -2.93817837e-02f, -5.61359562e-02f, -1.38637781e-01f, -1.49005711e-01f, -2.50373453e-01f, -1.45811424e-01f, 7.65786767e-02f, 1.44668773e-01f,
  9.87728909e-02f, 9.08509828e-03f, 4.39740252e-03f, 9.79724899e-03f, 5.55034205e-02f, 2.09903240e-01f, -8.97006616e-02f, 1.55197173e-01f, 1.03665203e-01f, -4.24168929e-02f,
  -3.36582884e-02f, -4.28492613e-02f, -4.21113800e-03f, 7.65473098e-02f, -8.70560557e-02f, -4.69236672e-02f, -6.73986450e-02f, 3.84480245e-02f, -5.58824353e-02f, -6.89439774e-02f,
  -8.22456926e-03f, -7.57179931e-02f, 3.01724300e-02f, 3.18119228e-02f, 1.36027979e-02f, -4.18837443e-02f, -4.11198810e-02f, -1.00727648e-01f, -8.53423104e-02f, -1.01701424e-01f,
  -1.06211603e-01f, 1.25308529e-01f, 3.58116738e-02f, 8.89966339e-02f, 4.63548079e-02f, -4.02445719e-02f, 3.52332443e-02f, 5.39230742e-02f, -3.20288166e-02f, 9.05299410e-02f,
  1.15299165e-01f, 6.94857687e-02f, -3.62641625e-02f, -2.16175076e-02f, 3.29748243e-02f, -4.36414517e-02f, -6.98503628e-02f, 4.43918966e-02f, 1.51339853e-02f, 5.60224988e-03f,
  -8.97597969e-02f, 2.67413184e-02f, -1.08848484e-02f, -5.56332357e-02f, 5.49488328e-02f, 8.39177817e-02f, 1.02219358e-01f, 5.84900118e-02f, -1.98645168e-03f, 4.41999920e-02f,
  6.43271655e-02f, -5.43352030e-02f, -5.56751117e-02f, 1.39984697e-01f, 4.46913615e-02f, -1.20724430e-02f, 6.17221519e-02f, -1.23080323e-02f, -3.36019136e-02f, 1.49187846e-02f,
  -3.47593166e-02f, 3.27942632e-02f, 5.14193438e-02f, 3.46148908e-02f, -1.23009846e-01f, -2.96294503e-02f, 6.76486865e-02f, -6.40790015e-02f, 9.37860087e-02f, 8.56660586e-03f,
  2.11890470e-02f, -6.84995670e-03f, -8.77037495e-02f, -1.76374204e-02f, 5.39534204e-02f, -8.17343220e-02f, -1.32255897e-01f, 5.49911410e-02f, 4.21844572e-02f, -7.26120621e-02f,
  -7.41419867e-02f, -2.57685836e-02f, -5.33635579e-02f, -4.48472053e-02f, 5.74764833e-02f, 3.91098000e-02f, -2.07484439e-02f, 1.08147562e-01f, -3.42534333e-02f, -1.60185128e-01f,
  -4.95259255e-01f, -2.10436448e-01f, 6.83061779e-02f, -6.54088259e-02f, 2.69265678e-02f, 5.97920455e-02f, 9.75874960e-02f, 1.49637843e-02f, -5.32340333e-02f, -5.18274643e-02f,
  -6.86703529e-03f, -9.64822471e-02f, 8.35738028e-04f, -4.72302772e-02f, -6.10592663e-02f, 6.77275434e-02f, 4.98256683e-02f, -1.19624145e-01f, -1.01221360e-01f, 8.74906257e-02f,
  -5.63388551e-03f, -1.42988041e-01f, -1.44621596e-01f, -1.70443758e-01f, 3.31790149e-02f, -9.97709557e-02f, -4.77672294e-02f, -6.59566075e-02f, 1.86295416e-02f, -5.71071245e-02f,
  -6.78415671e-02f, -1.98859386e-02f, 1.72985047e-01f, -3.53590734e-02f, -5.15530519e-02f, 1.60881691e-02f, 1.04585886e-02f, 1.43171577e-02f, 4.53004837e-02f, -7.30512142e-02f,
  4.80529945e-03f, 4.97050658e-02f, -4.27752845e-02f, -8.69676322e-02f, 3.09189130e-02f, -5.47618270e-02f, -8.11077189e-03f, -4.22886051e-02f, -3.24236900e-02f, 1.01380274e-01f,
  3.56762931e-02f, 2.17712275e-03f, -7.83527619e-04f, 7.71234855e-02f, 1.13505974e-01f, -3.14631425e-02f, 3.86478449e-03f, -2.55654361e-02f, -1.09683588e-01f, -1.82301313e-01f,
  -4.97996919e-02f, -3.20708975e-02f, 1.24862276e-01f, -9.95450616e-02f, 5.63125219e-03f, -7.54177198e-02f, 3.37290093e-02f, 4.97646593e-02f, 3.90995331e-02f, 1.13976309e-02f,
  6.51673004e-02f, -1.06133938e-01f, 2.50695553e-02f, -8.58602971e-02f, -1.13279879e-01f, -4.54789475e-02f, -1.02613114e-01f, -3.89155000e-02f, -5.73614240e-02f, -5.41159883e-03f,
  -6.84092864e-02f, 1.10728825e-02f, 4.32524607e-02f, 4.86686155e-02f, 9.60936323e-02f, 7.46617243e-02f, -4.12249863e-02f, 4.04130444e-02f, 6.93889633e-02f, -4.89130244e-02f,
  -1.39214873e-01f, 6.10568821e-02f, 4.73986194e-03f, -9.55021828e-02f, 4.74151857e-02f, -1.47046307e-02f, -2.81001050e-02f, -6.95760921e-02f, -6.41933270e-03f, 2.74571031e-03f,
  -4.67455573e-02f, -2.80457363e-02f, -1.79993417e-02f, 5.59373982e-02f, -2.48033497e-02f, -7.66511112e-02f, 3.50660011e-02f, -9.77777094e-02f, -4.04719263e-02f, 8.23309794e-02f,
  -1.11995287e-01f, -2.10628778e-01f, -2.17345536e-01f, 4.36100503e-03f, 2.09728982e-02f, -3.16441618e-02f, -1.41877681e-01f, -8.13530162e-02f, -7.71247894e-02f, -2.48980790e-01f,
  2.37387449e-01f, -1.13597572e-01f, 2.89822131e-01f, 1.71454370e-01f, 1.16939351e-01f, 6.28851652e-02f, -3.37376446e-02f, 1.71968099e-02f, 1.12735271e-01f, 7.95474946e-02f,
  -1.18032150e-01f, -1.38007745e-01f, -2.94918269e-02f, 1.77810807e-02f, 1.81894400e-03f, 1.05112828e-01f, 8.87226760e-02f, 5.90090193e-02f, 1.31478533e-01f, 1.33838043e-01f,
  -1.43878208e-02f, 8.81596804e-02f, 1.56205907e-01f, 1.61805809e-01f, 5.76705262e-02f, 9.79416519e-02f, 1.13513261e-01f, 5.03101945e-02f, 2.48404704e-02f, 1.79139853e-01f,
  -7.49001354e-02f, -6.97782710e-02f, 2.76414379e-02f, -1.60177797e-01f, -1.25335068e-01f, 6.25418127e-02f, 8.11653372e-05f, 3.45770419e-02f, -7.22060874e-02f, 7.88804609e-03f,
  6.88948575e-03f, -7.22999647e-02f, -9.35757607e-02f, -7.92299956e-02f, 1.00947142e-01f, 7.02072755e-02f, 5.60735054e-02f, -2.04138495e-02f, -3.36452685e-02f, -9.59245637e-02f,
  -7.71234706e-02f, 2.27984414e-02f, -4.85809557e-02f, 1.69792566e-02f, -3.33654918e-02f, -8.43041576e-03f, -2.55693384e-02f, 1.91147532e-02f, 6.59451857e-02f, -4.25223447e-02f,
  2.78048795e-02f, -4.81697284e-02f, -2.97095459e-02f, 5.30523695e-02f, 6.95071667e-02f, 5.14811389e-02f, 1.99936349e-02f, -1.72023885e-02f, 5.84331108e-03f, 1.00385480e-01f,
  6.92463592e-02f, 5.80493994e-02f, -3.41266990e-02f, 7.92298093e-02f, 4.13618376e-03f, -5.87475039e-02f, 6.02734424e-02f, 4.42580096e-02f, -6.00316599e-02f, -7.41945626e-03f,
  -3.97691540e-02f, -1.51634784e-02f, 3.07729207e-02f, 1.13944434e-01f, 2.64226720e-02f, 1.39633939e-02f, 5.45992926e-02f, 1.75631866e-02f, -6.52338052e-03f, -2.21463442e-02f,
  8.24130699e-03f, -1.07150212e-01f, 8.63408074e-02f, -1.85367446e-02f, -7.18847364e-02f, 9.61752515e-03f, -4.00329530e-02f, -4.51169275e-02f, -6.73161298e-02f, 1.30288392e-01f,
  -4.62273806e-02f, -2.78850794e-02f, 3.79446261e-02f, 4.35244432e-03f, 1.01856194e-01f, -4.93041202e-02f, -1.04013830e-01f, 2.52240151e-03f, 3.73051269e-03f, -9.43760127e-02f,
  2.71209609e-02f, 9.38643590e-02f, 4.54492262e-03f, 9.98475254e-02f, -1.06563412e-01f, -1.89202267e-03f, 1.33703230e-02f, -1.00753255e-01f, -8.75631289e-04f, 5.03220148e-02f,
  1.03432044e-01f, -1.72214851e-01f, -1.22125670e-01f, -1.05302006e-01f, -1.48506209e-01f, -3.01198065e-02f, -1.58100761e-02f, -7.63281016e-03f, -5.70546910e-02f, -1.60563871e-01f,
  -4.71542999e-02f, 1.12045892e-01f, 2.50450931e-02f, -6.28225058e-02f, 5.26363626e-02f, -3.53440270e-02f, -6.18787296e-02f, 1.57682568e-01f, 1.80014163e-01f, -1.06125072e-01f,
  -4.34001870e-02f, -6.88071772e-02f, -9.86452252e-02f, -8.18712935e-02f, -2.51079679e-01f, -1.63271166e-02f, -5.46167642e-02f, -7.67047927e-02f, -1.67273700e-01f, -1.45124897e-01f,
  8.37892070e-02f, -1.06751278e-01f, 2.09106244e-02f, 5.40465154e-02f, -1.47228688e-01f, 4.39797454e-02f, -2.38245074e-02f, 2.71077566e-02f, 8.56158510e-02f, -6.51472956e-02f,
  -3.23685352e-03f, 7.85480365e-02f, 1.71047181e-01f, -9.85940099e-02f, 2.68084649e-02f, 3.94463986e-02f, -1.29263148e-01f, -6.25141012e-03f, -1.37668937e-01f, -1.31182661e-02f,
  -1.40058734e-02f, 6.47809282e-02f, -4.49891724e-02f, -7.68810213e-02f, -2.44691893e-02f, 1.19835772e-01f, -1.37626022e-01f, 1.50168792e-03f, -1.12139151e-01f, -1.42442212e-01f,
  5.94334751e-02f, 3.07316538e-02f, -7.67315999e-02f, -2.42538005e-02f, 3.26329703e-03f, -3.65312933e-03f, 1.28853410e-01f, 9.84144397e-04f, -4.44661686e-03f, -2.86729671e-02f,
  -5.94949201e-02f, -3.84774245e-02f, -1.97809143e-03f, -4.74296398e-02f, -4.73358482e-03f, 3.80584784e-02f, 8.07826146e-02f, 8.34550038e-02f, -1.88183710e-02f, 5.37514500e-02f,
  -2.82457508e-02f, 2.90529542e-02f, -3.51429284e-02f, 9.54904594e-03f, -9.45061445e-02f, 4.36920449e-02f, 2.22545769e-02f, -7.27119073e-02f, 1.71359610e-02f, -7.19841644e-02f,
  1.37921395e-02f, 1.64471585e-02f, 1.23604283e-01f, -8.11523292e-03f, 8.84520486e-02f, -1.91400833e-02f, -1.27679482e-02f, 2.48637423e-02f, -3.88641916e-02f, -4.58969781e-03f,
  -1.78016946e-02f, 4.15165611e-02f, 1.30986497e-01f, -5.63209094e-02f, 2.83950157e-02f, -8.35242588e-03f, 3.83141674e-02f, 8.21706504e-02f, 2.09569968e-02f, -1.09985396e-01f,
  -1.45519912e-01f, 9.21595693e-02f, 2.19111443e-01f, 4.97039035e-02f, 6.11612387e-02f, 2.14843869e-01f, 1.14769004e-01f, 1.23339873e-02f, 1.26034394e-01f, 8.43187198e-02f,
  -1.08276799e-01f, -2.26916671e-01f, 4.19654697e-02f, -2.70155787e-01f, 3.28498520e-03f, 4.57681678e-02f, 9.33871716e-02f, -5.01237661e-02f, -1.12590082e-01f, 3.40902247e-02f,
  1.39690563e-02f, 8.08861554e-02f, 4.70254049e-02f, -5.41043701e-03f, 9.88830402e-02f, -5.67852855e-02f, 8.69382918e-02f, 8.22872519e-02f, 1.50738358e-01f, -3.10003385e-02f,
  -6.28931224e-02f, -1.46757569e-02f, -3.35574485e-02f, -1.11733139e-01f, 8.42210744e-03f, 2.29478106e-02f, -1.49273083e-01f, -3.86085995e-02f, 1.38478801e-02f, -6.13968670e-02f,
  3.84490699e-01f, -1.48136035e-01f, -1.73819661e-02f, -8.80920961e-02f, -9.41550136e-02f, 5.33161648e-02f, 1.53382957e-01f, -6.56611100e-02f, -8.64202976e-02f, 4.37268615e-02f,
  6.51481934e-03f, -1.05190076e-01f, 4.11077915e-03f, 4.98552546e-02f, -9.79493325e-06f, 8.34384654e-03f, -8.53627846e-02f, -6.27217293e-02f, -1.47256896e-01f, -3.39251645e-02f,
  -1.04981817e-01f, -9.45610702e-02f, 4.55470830e-02f, 7.77974306e-03f, -1.07105151e-01f, 6.80897459e-02f, 4.68168594e-02f, -3.14022340e-02f, -1.38808310e-01f, -3.51944268e-02f,
  -2.13726275e-02f, 1.21502690e-01f, -2.27168538e-02f, 6.09619869e-03f, -2.81740800e-02f, 4.08576941e-03f, 8.63611400e-02f, 2.84094224e-03f, -1.43238092e-02f, 4.06349339e-02f,
  2.77235564e-02f, 3.33451815e-02f, -6.26814784e-04f, -2.29731593e-02f, -3.30310836e-02f, -6.09469675e-02f, 1.48600554e-02f, 4.98542050e-03f, -2.61816736e-02f, 1.61950625e-02f,
  -6.44360036e-02f, 2.22664736e-02f, -4.04292233e-02f, -4.51428210e-03f, -6.61379620e-02f, -7.15477616e-02f, 1.92839783e-02f, 3.49353477e-02f, 2.58851368e-02f, 1.56029612e-02f,
  1.95844799e-01f, -1.07703723e-01f, 1.20584816e-01f, -1.03284582e-01f, -3.33195436e-03f, -7.87353292e-02f, -1.89015679e-02f, -5.56131750e-02f, 4.23194543e-02f, 1.72363576e-02f,
  -9.66475345e-03f, 3.51064280e-02f, 2.96520814e-03f, 5.57210073e-02f, 7.30383322e-02f, -5.71365887e-03f, -8.05712342e-02f, -3.64026092e-02f, -8.86786580e-02f, -4.34575416e-02f,
  -4.22819927e-02f, 1.01388231e-01f, 2.58056819e-01f, 1.74213693e-01f, 3.11185513e-02f, 1.45145550e-01f, 1.10739253e-01f, 1.74374022e-02f, 7.76183009e-02f, 5.44670485e-02f,
  5.97795984e-03f, -4.67543527e-02f, -3.95878583e-01f, -6.04189895e-02f, -2.28476599e-01f, -5.20399678e-03f, 6.34184759e-03f, 1.18504979e-01f, 9.14763957e-02f, -2.47311324e-01f,
  -9.84418392e-02f, -8.65963027e-02f, -2.94419620e-02f, -8.99212062e-02f, -2.51311567e-02f, -2.74443626e-01f, -2.07568914e-01f, -1.91439256e-01f, -8.16821009e-02f, 4.79536913e-02f,
  -1.19524486e-01f, -4.95036468e-02f, 8.09977502e-02f, 1.16180308e-01f, -1.53111801e-01f, -1.15269534e-01f, -2.63063997e-01f, -1.93862021e-01f, -2.03912333e-01f, -3.54186773e-01f,
  -5.47284722e-01f, 2.19689280e-01f, 3.09032686e-02f, 1.88746804e-03f, -1.02088422e-01f, 4.82126884e-02f, 2.90461704e-02f, 6.76811300e-03f, 1.63575392e-02f, -6.17610291e-02f,
  -3.78656462e-02f, 9.35170725e-02f, 2.99412124e-02f, -5.18938489e-02f, 1.17650032e-02f, 1.77961644e-02f, -2.35007126e-02f, 7.27382228e-02f, -6.91950917e-02f, -8.83077011e-02f,
  -1.17176317e-01f, -8.73968080e-02f, -1.47008136e-01f, 4.30409983e-02f, -3.86059694e-02f, -8.99333581e-02f, -8.86841863e-02f, -1.18727393e-01f, -6.06524348e-02f, -3.21692042e-02f,
  -3.36189047e-02f, -4.11170833e-02f, 5.77997640e-02f, 6.27834275e-02f, -4.97833453e-02f, -7.29464635e-04f, 4.65490520e-02f, 2.62570176e-02f, 5.30012436e-02f, -4.22370844e-02f,
  -5.05098775e-02f, -1.62512623e-02f, 6.63230643e-02f, -3.74350771e-02f, 3.54732620e-03f, -5.39261326e-02f, 2.08831131e-02f, -6.87980577e-02f, -5.67308851e-02f, -1.62187014e-02f,
  -1.10773016e-02f, -6.86244294e-02f, -3.97881679e-02f, 9.24342871e-03f, -8.18149894e-02f, -5.61627224e-02f, 1.36427088e-02f, 1.02536932e-01f, 1.49025291e-01f, 1.06567748e-01f,
  -4.24651466e-02f, 1.05343923e-01f, -5.17469831e-02f, 5.53946830e-02f, -1.03582805e-02f, -4.61673830e-03f, -1.10884570e-01f, 8.91369730e-02f, 3.54704410e-02f, 4.22510989e-02f,
  -6.88515976e-02f, 1.01963244e-01f, -7.75697082e-02f, 9.65193287e-02f, -1.91095844e-02f, 1.06393836e-01f, 5.19805141e-02f, -3.83084193e-02f, -5.56710064e-02f, 6.78866263e-03f,
  5.82337417e-02f, -7.66508505e-02f, 3.92021015e-02f, 4.97190654e-02f, 1.87007580e-02f, 7.92345218e-03f, -4.51295599e-02f, -2.72928998e-02f, -5.06467232e-03f, -2.50655990e-02f,
  3.86848420e-01f, -5.91070764e-02f, -4.93743978e-02f, 1.59703627e-01f, 1.35742486e-01f, 1.81541190e-01f, 1.46379009e-01f, 1.00808136e-01f, 1.77956924e-01f, 1.06433496e-01f,
  2.42689356e-01f, 2.42752492e-01f, 1.40448108e-01f, -1.69826560e-02f, 8.55404213e-02f, -1.01269752e-01f, -1.06969200e-01f, 3.31224166e-02f, 9.06444527e-03f, 1.56092346e-01f,
  5.62794171e-02f, -3.16534303e-02f, -2.45397817e-02f, -5.25916144e-02f, -1.00741282e-01f, 9.31442901e-02f, 1.65613424e-02f, -1.04431964e-01f, -2.28122100e-02f, -1.67580456e-01f,
  -5.31363972e-02f, 1.58418387e-01f, 9.00544506e-03f, 3.11509725e-02f, -6.19333191e-03f, -4.83636856e-02f, 3.59932333e-02f, -7.19972774e-02f, 1.06190346e-01f, -8.84973723e-03f,
  -4.48653698e-02f, -5.65210916e-03f, 3.75377163e-02f, 1.79518554e-02f, 7.11310953e-02f, 6.80939481e-02f, -1.26038626e-01f, -5.48265092e-02f, -1.21424755e-03f, -3.02213524e-02f,
  -5.93098812e-02f, 7.57518709e-02f, 1.67946756e-01f, 9.94433090e-02f, -2.17751134e-03f, 3.32981907e-02f, 2.58199815e-02f, -3.97838727e-02f, 8.34124833e-02f, -8.82802531e-03f,
  -6.37193695e-02f, -6.46842783e-03f, 6.31607175e-02f, 2.64253709e-02f, -1.56273860e-02f, -1.15702273e-02f, -5.66848069e-02f, -5.30467667e-02f, -1.86290126e-02f, -6.60532713e-02f,
  4.17690873e-02f, 6.90628961e-02f, 3.79239693e-02f, 1.14669837e-01f, 3.01628206e-02f, -5.73397428e-02f, 7.63935298e-02f, -4.63252328e-02f, 3.73779386e-02f, -2.32664421e-02f,
  -1.15763098e-02f, 1.35344118e-02f, -1.44122047e-02f, -8.73100981e-02f, 1.24139480e-01f, 4.25251834e-02f, -3.32604488e-03f, -5.71824936e-03f, 6.14356846e-02f, 5.44729978e-02f,
  -4.55232412e-02f, 2.49569073e-01f, -3.91900502e-02f, -6.86518028e-02f, -1.02130063e-01f, -1.13609828e-01f, 5.61225936e-02f, -7.26013780e-02f, -6.65952861e-02f, -1.74561851e-02f,
  -1.20631531e-02f, -2.38939058e-02f, -8.10355544e-02f, -2.98920535e-02f, 1.17437663e-02f, 6.44092336e-02f, -4.99572083e-02f, 1.31851179e-03f, -5.26716895e-02f, -7.75695220e-02f,
  -1.40545681e-01f, 1.22374184e-01f, 1.22820593e-01f, 8.63215476e-02f, -8.99742246e-02f, 1.36478707e-01f, 3.28483693e-02f, -1.63713228e-02f, 7.52452165e-02f, 1.55886607e-02f,
  1.17561899e-01f, 4.63997126e-02f, -2.66712487e-01f, 8.21932554e-02f, -3.26436423e-02f, -1.21571496e-01f, -1.01224497e-01f, 1.45269811e-01f, 1.25916496e-01f, 5.27726747e-02f,
  9.28444266e-02f, 1.55993372e-01f, -4.21578856e-03f, -1.46922627e-02f, -4.13301885e-02f, -4.90745194e-02f, -1.77625641e-01f, -1.21656030e-01f, -8.79484713e-02f, 6.17041625e-02f,
  -7.42028356e-02f, -3.45467515e-02f, 3.03010345e-02f, 2.27056388e-02f, -4.57683019e-02f, -7.23255351e-02f, -3.83384190e-02f, -1.19643688e-01f, -3.77089791e-02f, -1.33237347e-01f,
  -1.54459715e-01f, 6.10198267e-02f, 1.64777972e-02f, 2.35300660e-02f, -5.74336164e-02f, 1.55831743e-02f, 1.79242008e-04f, -1.85956191e-02f, 7.56954253e-02f, 1.96570028e-02f,
  3.43504325e-02f, 6.73612859e-03f, 2.88152136e-02f, -1.28240008e-02f, 6.14720136e-02f, 6.25073761e-02f, 1.22042663e-01f, 1.59420654e-01f, 1.71127226e-02f, 9.36643779e-02f,
  1.04748107e-01f, -7.46361073e-03f, -2.34442367e-03f, 1.32988105e-02f, -2.22898694e-03f, -6.52848394e-04f, 1.01707198e-01f, 1.11747794e-02f, 1.32306725e-01f, 4.79955226e-02f,
  -1.61864713e-01f, -6.32120296e-02f, -6.71303645e-02f, 3.21740843e-02f, -3.37189669e-03f, 1.00704264e-02f, -2.02372391e-02f, -9.69101563e-02f, -1.16491362e-01f, 2.28381082e-02f,
  1.14430487e-01f, -1.01342984e-01f, -6.30451739e-02f, -2.17197780e-02f, -1.40625313e-01f, -6.20555580e-02f, -1.12648085e-01f, -8.47649481e-03f, -3.73105034e-02f, -1.24643762e-02f,
  2.68852193e-04f, -2.89971735e-02f, -2.33868472e-02f, -7.20329955e-02f, -2.67695785e-02f, 8.64107087e-02f, -9.12485793e-02f, 9.66409296e-02f, 3.63369584e-02f, 8.72917473e-02f,
  7.64881149e-02f, -4.29285727e-02f, -7.95042813e-02f, 8.11486691e-03f, -1.97484493e-02f, 1.58982701e-03f, -2.24003592e-03f, 6.40890002e-02f, -2.13506259e-02f, 1.03158891e-01f,
  1.22581958e-03f, -2.26408448e-02f, 5.06296009e-02f, -2.84820385e-02f, 2.17762534e-02f, -1.12931523e-02f, 7.15057775e-02f, -1.83772799e-02f, 4.61621881e-02f, -2.34307609e-02f,
  -2.58698780e-02f, 9.75726247e-02f, 1.61750019e-02f, 7.08022118e-02f, -1.86908357e-02f, 6.86662330e-04f, -9.71762277e-03f, 1.13125900e-02f, -2.35787276e-02f, 9.24539641e-02f,
  1.19083546e-01f, 9.66359153e-02f, -2.64604807e-01f, 2.13303715e-01f, 1.99182779e-01f, 1.14747331e-01f, 6.36812299e-02f, 1.21756598e-01f, 1.45771489e-01f, 5.64410947e-02f,
  1.96352109e-01f, 2.46603474e-01f, 2.09610574e-02f, 9.46369469e-02f, 4.98788878e-02f, -3.37413400e-02f, 5.14052622e-02f, -1.62915856e-01f, -1.31305128e-01f, -1.70466658e-02f,
  2.22439289e-01f, 7.93373361e-02f, -8.66242591e-03f, -1.60315800e-02f, 3.00146472e-02f, 3.36710736e-02f, -1.05249017e-01f, 2.78072227e-02f, 3.24620306e-02f, 5.35229631e-02f,
  5.91218332e-03f, -6.41994104e-02f, -1.91051979e-02f, 1.43373713e-01f, -6.30659983e-02f, -2.00012103e-02f, 6.22289069e-02f, -1.17534965e-01f, 4.07554135e-02f, 3.18257213e-02f,
  6.30986467e-02f, 6.26398623e-02f, -5.55657744e-02f, -1.04037449e-01f, -9.16284099e-02f, -1.00361966e-01f, -1.30137041e-01f, -1.90176174e-01f, -1.30795956e-01f, -1.23317979e-01f,
  6.61160946e-02f, 2.67999750e-02f, -1.28025562e-01f, -3.80016267e-02f, -1.32139087e-01f, -3.91577706e-02f, -1.44855320e-01f, -1.15093179e-01f, -1.69276059e-01f, -1.63061827e-01f,
  2.08343547e-02f, -2.20694356e-02f, -4.98760566e-02f, -3.34698781e-02f, 5.83007410e-02f, 5.33420816e-02f, 1.78084690e-02f, -2.28505637e-02f, 4.36985828e-02f, -7.91193768e-02f,
  6.32514656e-02f, 9.08009708e-03f, -1.82122141e-02f, 3.32466094e-03f, 7.47391507e-02f, -2.63856929e-02f, 5.40499128e-02f, -2.55438499e-02f, -7.59941787e-02f, -4.07736637e-02f,
  -4.12941165e-02f, -9.00132880e-02f, -4.09198366e-02f, -1.06735332e-02f, 2.79674865e-02f, -5.04512265e-02f, 2.96697882e-03f, -3.83294672e-02f, 4.01236638e-02f, -2.88283434e-02f,
  1.98120609e-01f, 1.04926087e-01f, 4.31889407e-02f, -7.18968688e-03f, -4.23638597e-02f, 3.02553233e-02f, 1.23823687e-01f, 4.60237227e-02f, -4.49656583e-02f, -5.19358441e-02f,
  -5.55783175e-02f, -4.94727641e-02f, 1.38358802e-01f, -1.08065203e-01f, 8.11745301e-02f, 3.02672572e-02f, -3.07468232e-03f, -8.51350799e-02f, 4.94768471e-02f, -7.34291673e-02f,
  2.33749654e-02f, -6.30665570e-02f, -2.99867094e-02f, -1.03929564e-01f, 2.67970171e-02f, 1.86196938e-01f, -3.25225033e-02f, -6.56351596e-02f, -1.24313321e-03f, -1.23695232e-01f,
  -3.32667530e-01f, -1.67130172e-01f, -1.81807950e-01f, -1.57705307e-01f, -4.87130769e-02f, 9.94859338e-02f, 1.59188907e-03f, 1.02339387e-02f, -1.26063168e-01f, -6.94150999e-02f,
  -1.52690947e-01f, -2.55900957e-02f, -8.50558877e-02f, -3.63156274e-02f, 6.41912175e-03f, -1.33029167e-02f, -5.75174801e-02f, -5.36127090e-02f, 5.03905937e-02f, 5.80586307e-02f,
  -7.03542456e-02f, 2.08994448e-02f, -1.14327833e-01f, 5.06822579e-02f, -7.28147104e-02f, 2.46294569e-02f, -6.28021210e-02f, 6.69638515e-02f, 5.41513339e-02f, -6.97759688e-02f,
  -1.33997962e-01f, 2.54849363e-02f, 1.27398163e-01f, 8.46183971e-02f, -2.64100004e-02f, -5.28159775e-02f, -7.38523379e-02f, -6.85869679e-02f, 6.75804988e-02f, -1.41360551e-01f,
  -4.22265083e-02f, 4.93804887e-02f, -5.31547368e-02f, -4.86712195e-02f, -1.07907683e-01f, 6.79029990e-03f, -3.64855155e-02f, 4.10192907e-02f, -6.50748797e-03f, 7.27067739e-02f,
  -1.25917876e-02f, -5.05693033e-02f, 6.93430156e-02f, 9.71257836e-02f, 1.36188284e-01f, -6.19169064e-02f, 1.17961071e-01f, 9.80971903e-02f, 1.11404993e-01f, -3.16305757e-02f,
  6.61006644e-02f, -5.17144091e-02f, 4.65937704e-02f, -9.91963744e-02f, -8.19186792e-02f, -1.54961376e-02f, 7.03686103e-02f, 2.68069468e-03f, 7.43522942e-02f, 1.46752158e-02f,
  -5.67425378e-02f, 3.72062549e-02f, 2.12482028e-02f, -3.61939594e-02f, -3.73767465e-02f, 2.64540575e-02f, -4.92291115e-02f, -2.15982646e-03f, 7.80035555e-02f, 6.90707713e-02f,
  -7.56577477e-02f, 1.31540507e-01f, 2.15523597e-02f, 7.89023712e-02f, 7.25051109e-03f, -3.21159475e-02f, -3.69399786e-02f, 6.80653378e-02f, -6.07010955e-03f, -1.13367811e-01f,
  -1.89063236e-01f, 2.11304903e-01f, -1.29056871e-01f, -6.38935119e-02f, -5.08558489e-02f, -2.16487218e-02f, -4.38813716e-02f, -6.24954561e-03f, 4.51126918e-02f, 3.75880189e-02f,
  -5.69113791e-02f, 3.79297547e-02f, -3.90273891e-03f, -1.73588414e-02f, -2.04801802e-02f, -6.74476698e-02f, 1.17111420e-02f, 2.59464532e-02f, 1.36302426e-01f, -1.65636297e-02f,
  2.18006056e-02f, -1.07138850e-01f, -1.39798999e-01f, -3.64896879e-02f, -3.90577540e-02f, -7.21553201e-03f, 2.75902338e-02f, 5.53965122e-02f, -5.77876940e-02f, -1.63189560e-01f,
  -3.92353497e-02f, -2.71078944e-02f, 3.89943153e-01f, -1.20697897e-02f, 2.18267202e-01f, 2.76158452e-01f, 3.00975978e-01f, 3.63756642e-02f, -1.00461379e-01f, 8.45671743e-02f,
  1.25476137e-01f, -2.67924219e-01f, -2.58962512e-01f, -1.90929294e-01f, -1.65813547e-02f, 1.87686216e-02f, 8.01616833e-02f, -5.48157133e-02f, 8.90930220e-02f, -2.17213258e-02f,
  -7.82803521e-02f, 1.00063115e-01f, 4.20316458e-02f, -3.29227350e-03f, -7.10928962e-02f, -1.92851856e-01f, 4.09402624e-02f, 1.29356593e-01f, -3.08743678e-02f, 2.09468836e-03f,
  1.12002432e-01f, 2.02946320e-01f, -1.00523867e-01f, -1.77261636e-01f, 6.71559349e-02f, -8.63987505e-02f, 8.25730413e-02f, -8.99811015e-02f, -9.33329016e-02f, -3.41331922e-02f,
  1.13404967e-01f, -6.66455850e-02f, 1.36559919e-01f, 9.04478147e-05f, 1.70082092e-01f, 7.61578158e-02f, -4.93815541e-02f, -1.94978621e-02f, -8.39492232e-02f, -6.70429617e-02f,
  -1.01515546e-01f, 8.09118599e-02f, 1.81838661e-01f, 1.54315643e-02f, 7.66244084e-02f, -9.99754071e-02f, 5.69767393e-02f, 3.13733071e-02f, 8.49941522e-02f, -6.74347728e-02f,
  8.82003747e-04f, -6.77931414e-04f, 5.36525808e-02f, -1.46260083e-01f, 3.63958031e-02f, -8.11000690e-02f, 8.80694669e-03f, -4.62058596e-02f, -2.95254905e-02f, 6.11092597e-02f,
  -4.31234278e-02f, 1.51396785e-02f, 3.78516279e-02f, -1.00996301e-01f, -1.05814800e-01f, 2.11914442e-02f, 9.70197991e-02f, -4.10810560e-02f, -1.13075465e-01f, 4.13099118e-02f,
  -7.23980144e-02f, 1.00550830e-01f, -1.60421114e-02f, -9.69932787e-03f, -9.43870023e-02f, 6.77765161e-02f, -1.36552472e-02f, -1.04921293e-02f, 6.25339523e-02f, 7.43600947e-04f,
  2.04782467e-02f, 7.59836957e-02f, -7.53033757e-02f, -1.03537198e-02f, 3.30684371e-02f, -7.06411153e-02f, 1.35320257e-02f, 3.42542417e-02f, 2.75127012e-02f, 5.75736314e-02f,
  4.85617071e-02f, 2.16907710e-02f, 6.28834292e-02f, -9.54138068e-06f, 3.71525288e-02f, 9.93965194e-02f, 8.93160626e-02f, 5.72030656e-02f, -1.67624988e-02f, 2.33191773e-02f,
  -5.32223396e-02f, -3.83797400e-02f, 6.46935776e-02f, -2.99458066e-03f, 4.42797616e-02f, -7.39335567e-02f, 1.13211619e-02f, 1.99375916e-02f, 4.76912595e-02f, -1.06867842e-01f,
  -2.79650301e-01f, -3.45093131e-01f, -1.39557540e-01f, -1.08424783e-01f, -4.54113958e-03f, 3.35267894e-02f, -1.85342401e-01f, 5.39856255e-02f, 6.90013766e-02f, -1.22117110e-01f,
  4.05357368e-02f, 3.02385278e-02f, -6.40571788e-02f, -5.77259660e-02f, 1.82714686e-02f, -1.85945392e-01f, -5.44102937e-02f, -2.25205030e-02f, 1.42283201e-01f, 2.24043399e-01f,
  1.26591161e-01f, -1.94165688e-02f, -9.11439955e-03f, 7.27153197e-02f, -3.81543636e-02f, -3.72315347e-02f, 2.57939622e-02f, -3.06024938e-03f, 2.00178511e-02f, -1.52975144e-02f,
  -6.45084232e-02f, -4.54004779e-02f, 1.10940553e-01f, -8.56753532e-03f, 5.61035983e-02f, -3.46584222e-03f, 4.74433564e-02f, 8.00447017e-02f, 4.07852419e-02f, -8.80282521e-02f,
  3.28080654e-02f, 4.79551218e-02f, 2.58054361e-02f, -2.51101907e-02f, 1.73917115e-02f, -1.05939560e-01f, 1.47451721e-02f, -7.71009624e-02f, -1.34709955e-03f, 2.46926043e-02f,
  -6.28271000e-03f, -3.89099568e-02f, -6.70542121e-02f, -2.83691082e-02f, -6.95050955e-02f, 4.49543856e-02f, -7.16128945e-02f, -2.13831887e-02f, -1.20166406e-01f, -1.31614313e-01f,
  -2.25982442e-02f, 7.01224208e-02f, -1.32132173e-02f, 4.60004341e-03f, -8.19005892e-02f, -1.02485614e-02f, 1.39620798e-02f, -2.36713371e-04f, -7.76916966e-02f, -4.96443026e-02f,
  2.56678537e-02f, 5.77168837e-02f, -1.74379591e-02f, 2.38418542e-02f, 5.10342047e-02f, 2.00812276e-02f, 1.01603884e-02f, -1.58061627e-02f, 8.45378190e-02f, -8.42915569e-03f,
  -4.97893058e-02f, -2.82495022e-02f, -1.35263652e-02f, -5.88013828e-02f, -8.20699111e-02f, 5.57771772e-02f, -5.68861999e-02f, -6.38269112e-02f, -6.56976476e-02f, 3.68268155e-02f,
  -1.31119847e-01f, 9.37486663e-02f, -4.70675938e-02f, -1.76901910e-02f, -5.82266375e-02f, -3.71070988e-02f, -1.23582944e-01f, 3.30482051e-02f, -4.58762795e-02f, 1.32616386e-02f,
  -2.02004593e-02f, -5.45000508e-02f, -8.66844058e-02f, -1.98999103e-02f, 1.27976937e-02f, -9.11784172e-02f, -1.63737237e-01f, -1.52113829e-02f, 4.12174016e-02f, 5.94316348e-02f,
  -1.80378973e-01f, -9.70448330e-02f, -1.55088261e-01f, -2.11416617e-01f, -5.31158783e-02f, -1.94073349e-01f, -1.67906180e-01f, -1.21625766e-01f, -1.60258070e-01f, -2.87269324e-01f,
  -3.59662086e-01f, -1.63582936e-01f, 8.03227350e-03f, 2.35196739e-01f, 2.99813658e-01f, 3.67019087e-01f, 3.50911736e-01f, 1.61977157e-01f, 1.53256416e-01f, 4.71578725e-02f,
  -1.06937833e-01f, 4.42740768e-02f, 8.71505886e-02f, 4.15864289e-02f, 1.33113682e-01f, 3.00044239e-01f, 2.94046909e-01f, 8.91039222e-02f, -4.08184119e-02f, 8.34451243e-03f,
  1.34622186e-01f, -3.63547914e-02f, -1.18269593e-01f, -7.87502434e-03f, 1.78412110e-01f, 1.21709414e-01f, -1.40909450e-02f, 6.76022796e-03f, -1.21724702e-01f, 6.03322722e-02f,
  -2.47471333e-01f, -2.40323037e-01f, 2.06454307e-01f, -9.94579941e-02f, -4.61012200e-02f, -1.34544447e-01f, -6.64246902e-02f, -1.78825438e-01f, -9.54803973e-02f, 3.54686603e-02f,
  -3.88706923e-02f, -8.03057104e-02f, 8.91465396e-02f, -1.11348473e-01f, 6.51521003e-03f, -5.28038442e-02f, -1.73909783e-01f, 3.12837213e-02f, 1.18391933e-02f, 6.25116527e-02f,
  6.74093068e-02f, -7.49672055e-02f, -9.24604237e-02f, 6.08781241e-02f, 2.93090753e-02f, -3.29556614e-02f, -8.42167959e-02f, 1.83174890e-02f, 2.97066011e-02f, -1.33329090e-02f,
  6.20169332e-03f, -1.24416929e-02f, 5.93011733e-03f, -7.30926692e-02f, -2.69250087e-02f, 5.76529279e-02f, 4.90172878e-02f, 5.49227595e-02f, 6.77303001e-02f, -6.56052530e-02f,
  -1.53879514e-02f, 3.94548476e-02f, 3.89290154e-02f, 2.50612907e-02f, -3.44686210e-02f, 1.67932417e-02f, -3.49537916e-02f, -4.99646030e-02f, -1.24059796e-01f, -1.03892367e-02f,
  -1.00813573e-02f, 4.69067544e-02f, -3.71092297e-02f, -1.56489981e-03f, 4.41382127e-03f, 3.69259566e-02f, -3.43526937e-02f, -3.49054076e-02f, -1.76133197e-02f, -2.80121788e-02f,
  -7.35472888e-03f, -1.64459646e-02f, 1.38141766e-01f, 2.79924832e-02f, 2.16199588e-02f, -8.16445947e-02f, -2.94360742e-02f, 1.53453937e-02f, 3.46476547e-02f, -1.96789093e-02f,
  -1.10811414e-02f, -5.50276563e-02f, -6.31580949e-02f, -8.51006880e-02f, -4.43703830e-02f, -1.93231944e-02f, -6.42714964e-04f, 7.75773674e-02f, -5.39735891e-03f, -1.07145337e-02f,
  6.47755861e-02f, 2.95413509e-02f, 4.74762432e-02f, 1.79411665e-01f, 1.43272758e-01f, 2.03021262e-02f, -8.47793594e-02f, -2.73940228e-02f, 1.89105105e-02f, -1.51576120e-02f,
  -4.77930903e-01f, 7.38273039e-02f, 4.62430827e-02f, -1.24077156e-01f, 2.60298461e-01f, 2.97783852e-01f, 4.10186678e-01f, 2.00243816e-01f, -7.14854524e-02f, 1.28446361e-02f,
  6.35585338e-02f, -1.08069010e-01f, 2.37257276e-02f, -3.70714068e-02f, 1.29790857e-01f, 1.52778193e-01f, 9.62461680e-02f, -1.78171113e-01f, -6.52353317e-02f, 9.10549238e-03f,
  1.44499941e-02f, -2.01209888e-01f, -2.66999751e-01f, -9.41896290e-02f, -7.62261152e-02f, -1.50538255e-02f, 9.12390649e-03f, 4.10274491e-02f, 1.52392045e-01f, -1.91601533e-02f,
  2.87602693e-02f, -1.99812874e-02f, -5.68986423e-02f, -3.17634530e-02f, 9.08694714e-02f, -1.92368403e-02f, 1.03292344e-02f, -1.32932991e-01f, 2.98537500e-02f, 5.25575057e-02f,
  -1.64172519e-02f, -9.34373811e-02f, -4.95936386e-02f, -8.52963477e-02f, 4.08656808e-04f, 4.44509611e-02f, -7.69695640e-02f, -1.21827736e-01f, -2.73258658e-04f, 5.11539616e-02f,
  2.02452883e-01f, 1.37191385e-01f, 1.12756215e-01f, 8.38729087e-03f, 3.67075059e-04f, -2.37662643e-02f, 6.23095082e-03f, 7.79155046e-02f, 3.87300067e-02f, -1.90364033e-01f,
  6.72525838e-02f, 4.51497473e-02f, -3.35994773e-02f, 3.85530777e-02f, -5.98623678e-02f, 7.55898133e-02f, -3.05558387e-02f, 5.63102290e-02f, 4.44999896e-02f, -8.87637585e-02f,
  5.68245165e-02f, 4.29497622e-02f, -8.89254175e-03f, -4.66648750e-02f, -9.56400298e-03f, 7.90100768e-02f, 5.81012554e-02f, 7.74634928e-02f, 9.71756596e-03f, 1.99127514e-02f,
  -2.56155785e-02f, 6.36003762e-02f, -5.48206121e-02f, 2.63013318e-02f, 9.79923531e-02f, -4.61491756e-02f, 4.50086175e-03f, -4.05328022e-03f, 4.58217748e-02f, 3.18386890e-02f,
  -2.23515630e-01f, 1.40316486e-01f, -1.09798148e-01f, -7.90923387e-02f, -7.91738927e-02f, 3.00798714e-02f, 2.95107067e-02f, -2.01580077e-02f, -4.13339436e-02f, -1.65000111e-02f,
  6.15017414e-02f, -1.95107292e-02f, -1.06405346e-02f, 2.52021104e-03f, -8.42863321e-02f, -3.73765975e-02f, 1.60736479e-02f, -9.55243856e-02f, -1.62179694e-02f, -4.54574078e-03f,
  1.25676692e-01f, 1.95365101e-02f, -4.56765406e-02f, -6.33976981e-02f, 4.12550196e-02f, 1.40796397e-02f, -2.42802687e-02f, -9.57782418e-02f, -1.28796026e-01f, -2.35060573e-01f,
  -2.64473021e-01f, -8.25936943e-02f, 8.01956654e-02f, 3.86541858e-02f, 2.84421463e-02f, 8.85508582e-02f, -1.35161668e-01f, -1.74473628e-01f, 2.07697786e-02f, -1.18082188e-01f,
  8.81283954e-02f, 1.24676544e-02f, -5.43071404e-02f, -1.44628331e-01f, -3.38314921e-01f, -1.57060117e-01f, -9.50959697e-02f, -2.84170777e-01f, -1.96755141e-01f, 1.77802611e-03f,
  -2.50553060e-03f, -1.73630361e-02f, -1.89736679e-01f, -1.63050577e-01f, 1.11751683e-01f, -2.94942334e-02f, 1.29832402e-02f, -5.01771085e-03f, 1.30350828e-01f, 9.63345394e-02f,
  2.64523149e-01f, 9.00483131e-02f, 7.78029561e-02f, -2.28460203e-03f, 4.85691912e-02f, -1.76932439e-02f, 4.80961576e-02f, 3.79419439e-02f, -2.83246413e-02f, 8.00521448e-02f,
  4.44243848e-03f, 9.76001173e-02f, 7.07495958e-02f, 2.77520083e-02f, -3.50310951e-02f, -3.50446627e-02f, -1.82066336e-01f, -1.90082252e-01f, -6.61202241e-03f, -1.90106388e-02f,
  -1.08727375e-02f, 3.37017663e-02f, -1.22917734e-01f, -1.78203620e-02f, -1.75443627e-02f, 7.43545964e-02f, -7.35838339e-02f, 1.11338953e-02f, 5.57694547e-02f, -1.43369257e-01f,
  -1.18606249e-02f, 4.49972739e-03f, 9.52152349e-03f, -5.70566319e-02f, -7.22440034e-02f, 1.79194435e-02f, 7.51075894e-02f, -7.91296884e-02f, -1.35559710e-02f, -9.06218514e-02f,
  -2.80858204e-02f, 1.11451767e-01f, 2.30324920e-02f, -3.49038206e-02f, 1.10954389e-01f, -2.60268617e-02f, 5.51644973e-02f, -6.96824342e-02f, -3.44224907e-02f, -2.36911103e-02f,
  -4.53824177e-02f, 5.60044870e-02f, -3.94849759e-03f, 5.23059350e-03f, -6.86673597e-02f, 1.21253356e-02f, 7.94171095e-02f, -9.03606564e-02f, -3.42005044e-02f, 1.05375620e-02f,
  -1.29826620e-01f, 4.92579043e-02f, 4.10211198e-02f, -3.40735652e-02f, 4.35699448e-02f, 2.41222307e-02f, 3.57788056e-02f, 1.56555660e-02f, 1.26817644e-01f, -1.46720605e-02f,
  -3.64379399e-02f, 8.73378292e-03f, 5.56831881e-02f, -9.99629647e-02f, -3.43687013e-02f, -2.37119496e-02f, -1.88254297e-01f, -1.35095179e-01f, -9.43434089e-02f, -2.34391149e-02f,
  -1.94217741e-01f, -1.08305328e-01f, -1.04592249e-01f, -1.30434811e-01f, -3.74101251e-02f, -4.04870510e-02f, 1.20867919e-02f, 4.08666255e-03f, -2.68034860e-02f, -2.96452612e-01f,
  -3.09006989e-01f, -1.96863469e-02f, -3.51889543e-02f, -3.70873474e-02f, 1.11395001e-01f, 1.48528023e-02f, 1.45040959e-01f, 9.70341042e-02f, -5.38233444e-02f, 2.60526594e-02f,
  -9.55678988e-03f, -1.08318858e-01f, 4.82693221e-03f, -1.15760148e-01f, -6.97505549e-02f, 6.78300038e-02f, -6.35419264e-02f, -4.69210781e-02f, -1.18185073e-01f, -4.43526311e-03f,
  1.77468564e-02f, 1.50999948e-02f, -5.60295768e-02f, -1.63941719e-02f, -3.71070467e-02f, -1.51552156e-01f, 2.83592697e-02f, -4.49721552e-02f, -8.17721058e-03f, -1.09548643e-01f,
  1.33511266e-02f, 7.28827268e-02f, -7.13792816e-02f, -3.01987175e-02f, -4.01129164e-02f, 3.93489935e-03f, 2.87041515e-02f, 7.78740458e-03f, 8.67300257e-02f, 7.42251575e-02f,
  8.76175314e-02f, -4.77489308e-02f, 5.27841598e-02f, 5.73899075e-02f, -7.22484570e-03f, 1.02562211e-01f, 2.41470356e-02f, 8.96993354e-02f, -5.79721062e-04f, 3.69827752e-03f,
  1.55423936e-02f, 2.01138817e-02f, 1.10652946e-01f, 9.04231742e-02f, -1.93462009e-03f, 1.15571201e-01f, 5.98983541e-02f, 1.54089257e-02f, 5.34969047e-02f, -5.90231419e-02f,
  -9.27458853e-02f, -7.27024227e-02f, 3.87473665e-02f, -7.49990158e-03f, -5.44199720e-02f, -5.88780083e-02f, -4.36838791e-02f, -1.04950229e-02f, -7.51693696e-02f, -7.62018338e-02f,
  -6.09118007e-02f, -2.25247145e-02f, -2.58891955e-02f, -4.46353893e-04f, -3.94602157e-02f, -4.70257252e-02f, -1.18060422e-03f, 2.16933154e-02f, 6.67822286e-02f, -1.87550914e-02f,
  1.11171164e-01f, 2.46761572e-02f, -3.44819017e-02f, 6.82658628e-02f, 1.36662740e-02f, -2.08586510e-02f, 1.25549436e-01f, 8.84480104e-02f, 4.98930812e-02f, 7.53555894e-02f,
  -1.19367242e-01f, -3.22218984e-02f, -1.18499570e-01f, 1.31220743e-02f, -5.89163005e-02f, 6.04996718e-02f, 4.34141420e-02f, 1.11426033e-01f, 2.49399082e-03f, 8.69090930e-02f,
  1.02015205e-01f, -2.49847919e-02f, 2.43669935e-02f, -1.08982604e-02f, 9.98736639e-03f, -3.74917649e-02f, 3.93455513e-02f, 6.52257353e-02f, 1.08837359e-01f, 1.52324021e-01f,
  4.71543409e-02f, -7.51993805e-02f, -2.36770734e-02f, -2.03253292e-02f, -3.42291743e-02f, -4.79815565e-02f, 2.55026128e-02f, -4.91557792e-02f, 4.16607484e-02f, -1.43995747e-01f,
  -4.05235291e-02f, -7.46997669e-02f, -1.51140332e-01f, 1.16813347e-01f, 1.04757482e-02f, -1.01067938e-01f, -1.36205461e-02f, -3.70082408e-02f, 1.41752809e-02f, 1.29483104e-01f,
  -6.27869740e-02f, 6.72499090e-02f, 5.56474812e-02f, -5.25614619e-03f, -4.76773791e-02f, 4.85292487e-02f, 1.24804236e-01f, 8.11457857e-02f, -9.40150172e-02f, -5.76263629e-02f,
  1.82587028e-01f, 5.84976748e-02f, 6.28929287e-02f, 7.31502175e-02f, 2.09650829e-01f, 1.46170691e-01f, -1.59901064e-02f, 2.47006603e-02f, 1.20394506e-01f, 2.24945739e-01f,
  -1.70164913e-01f, -1.08192459e-01f, -1.21110855e-02f, 8.93560573e-02f, -4.59325723e-02f, -4.53653261e-02f, -2.57256217e-02f, -5.03494665e-02f, -5.92477098e-02f, -3.73832397e-02f,
  -6.67484403e-02f, 2.73416955e-02f, -2.90260892e-02f, -9.58514214e-03f, 2.53111422e-02f, -6.18698820e-02f, -4.15093265e-03f, 1.29526705e-02f, -2.99660042e-02f, -1.34391859e-01f,
  5.04949577e-02f, -6.05366230e-02f, -8.73141587e-02f, -1.50826082e-01f, -1.41201466e-01f, -8.15469399e-03f, -2.58487854e-02f, -1.16845407e-01f, -1.81003939e-02f, 6.32241815e-02f,
  -3.68150370e-03f, 2.41549741e-02f, -4.54996713e-02f, 3.52895036e-02f, -3.51983681e-02f, 6.29961304e-03f, 6.29018852e-03f, 6.74165487e-02f, -2.66780369e-02f, 1.34839518e-02f,
  -3.42843309e-02f, -6.34462982e-02f, -6.26336932e-02f, -3.99622172e-02f, 1.38473627e-03f, -6.37532175e-02f, 6.53233528e-02f, 3.19057107e-02f, -1.61333922e-02f, -7.40331074e-04f,
  4.06707078e-02f, -4.72954325e-02f, 3.61914113e-02f, 8.38059559e-02f, 5.53921014e-02f, 2.32192632e-02f, 3.50968941e-04f, 3.72277759e-02f, -3.83069254e-02f, -2.94429772e-02f,
  -1.59755826e-01f, -1.61479592e-01f, -5.73849455e-02f, -2.22232882e-02f, 8.09493810e-02f, -6.82310313e-02f, 5.38609512e-02f, -6.11913614e-02f, 1.76061615e-02f, -7.05556050e-02f,
  6.38745725e-02f, -1.04678474e-01f, -9.41700488e-02f, 3.12935449e-02f, -3.85327451e-02f, 3.58421355e-02f, -8.24353620e-02f, 5.54071665e-02f, -2.95401160e-02f, 1.10583734e-02f,
  -1.93100590e-02f, -5.08311503e-02f, -1.23370506e-01f, -9.93116945e-02f, -8.82275701e-02f, 3.10754683e-02f, -4.37603556e-02f, -7.16051981e-02f, -1.05958164e-01f, -9.48783159e-02f,
  8.18413943e-02f, -1.97181422e-02f, -4.13116738e-02f, 2.91463230e-02f, -5.54578863e-02f, 3.28793339e-02f, 7.68191065e-04f, -1.23312362e-02f, -2.63834689e-02f, -1.03771808e-02f,
  -9.15356949e-02f, 1.28437886e-02f, 5.97870834e-02f, -8.40652455e-03f, -4.25963439e-02f, -5.07010780e-02f, 2.57032607e-02f, 7.75642246e-02f, -2.14469824e-02f, -8.45656916e-02f,
  -1.01467632e-01f, -2.24400815e-02f, 3.30344811e-02f, 1.04548633e-01f, -2.70917714e-02f, -9.17894708e-04f, -8.73277038e-02f, -1.02882385e-01f, 6.12139478e-02f, -2.35170946e-02f,
  4.46757153e-02f, 6.19509406e-02f, 4.69194688e-02f, 5.66827133e-03f, 7.02705532e-02f, -4.86925058e-02f, -2.95821559e-02f, 4.44809049e-02f, 9.14120022e-03f, 4.24942235e-03f,
  -8.85251611e-02f, 5.78389540e-02f, -9.79086384e-02f, 1.82147734e-02f, 6.18351512e-02f, -8.44568610e-02f, 9.04832855e-02f, 5.84201552e-02f, 4.37232740e-02f, -3.96077670e-02f,
  -5.98864183e-02f, 1.19032385e-02f, 7.89453313e-02f, 6.74814284e-02f, 8.41856599e-02f, -5.28104641e-02f, 2.06158627e-02f, -7.00530782e-02f, -8.60249549e-02f, -5.81888594e-02f,
  -4.07812744e-02f, 1.94700975e-02f, -3.92088406e-02f, -5.09012677e-02f, 4.03201208e-02f, 7.62709528e-02f, -1.39489500e-02f, -3.14850733e-02f, 2.17264164e-02f, -5.52692600e-02f,
  -8.87334626e-03f, -4.95525524e-02f, -1.59885790e-02f, 7.16554001e-02f, 6.01614080e-02f, 5.86952046e-02f, 3.24476808e-02f, -3.15115303e-02f, -5.19691147e-02f, -6.74119890e-02f,
  3.41048129e-02f, -4.58238609e-02f, -2.73868199e-02f, -2.30852817e-03f, 1.15903862e-01f, -1.02505432e-02f, 7.92197958e-02f, 5.57693467e-02f, 8.79896358e-02f, -5.12087010e-02f,
  6.64751306e-02f, 6.11878633e-02f, 4.31951359e-02f, -2.62000579e-02f, 4.88475002e-02f, -5.64140789e-02f, -5.54161482e-02f, 8.40256363e-02f, -1.80061683e-02f, -1.80058535e-02f,
  -9.26915407e-02f, 2.01247297e-02f, -3.63665670e-02f, -3.88949104e-02f, 8.71691629e-02f, 7.11734518e-02f, 1.40560251e-02f, -8.56090263e-02f, -7.44979158e-02f, -5.76771684e-02f,
  -9.02521610e-02f, 4.50855196e-02f, -5.01445793e-02f, 1.38908606e-02f, -5.66335395e-02f, 5.21881226e-03f, 3.68549153e-02f, 1.73535924e-02f, 2.00697072e-02f, 3.79957668e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  1.11468308e-01f, 1.39564306e-01f, 2.43369445e-01f, 1.14214763e-01f, 1.51282579e-01f, 1.48621008e-01f, 1.29851148e-01f, 3.12731564e-01f, 2.43297979e-01f, 1.37939125e-01f,
  2.49906808e-01f, 1.74522534e-01f, 1.75207600e-01f, 3.80614772e-02f, 9.17271450e-02f, 3.15252423e-01f, 7.14579597e-02f, 3.68442573e-02f, 1.55271515e-01f, -7.13234320e-02f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.56070784e-01f, -1.00053906e-01f, -7.35179111e-02f, -2.23942742e-01f, 1.32014789e-03f, 9.14208218e-02f, -3.42538983e-01f, 1.14832789e-01f, -2.72360355e-01f, 1.14337184e-01f,
  -3.35504204e-01f, -4.38466668e-01f, -1.10321477e-01f, 1.60476387e-01f, 1.59262314e-01f, -1.25816777e-01f, -2.90018022e-02f, -2.60190126e-02f, -1.15503334e-01f, 2.37300515e-01f,
  8.95017236e-02f, 9.84972045e-02f, 2.64917910e-01f, 5.76836802e-02f, -2.75315762e-01f, -3.68939638e-02f, -8.72817338e-02f, 7.02103674e-02f, -3.44132364e-01f, -9.99304354e-02f,
  -1.62100762e-01f, 1.31412163e-01f, 1.64227724e-01f, 4.34715115e-03f, 4.58368473e-03f, -3.36440742e-01f, 2.19242871e-02f, 5.17423525e-02f, -1.77807406e-01f, -1.34700745e-01f,
  1.55736387e-01f, 2.41992414e-01f, -2.65929490e-01f, 2.65419986e-02f, -1.23676565e-02f, -2.08196729e-01f, -1.95350740e-02f, 1.86423123e-01f, 1.05129227e-01f, -1.10457703e-01f,
  4.70805876e-02f, -9.97936130e-02f, -2.41934419e-01f, -1.08855471e-01f, 3.37948874e-02f, 2.26989463e-01f, -7.86917284e-03f, 1.92407116e-01f, -1.29668206e-01f, -6.58225864e-02f,
  4.06536683e-02f, -1.16625875e-02f, 1.79829493e-01f, 2.37954017e-02f, -3.26884389e-01f, -9.18086916e-02f, -1.06971726e-01f, 1.84513733e-01f, 9.81049016e-02f, -8.35007429e-02f,
  -1.85147405e-01f, 1.10812314e-01f, 1.97012663e-01f, -2.01709196e-01f, 1.60296872e-01f, -8.41638912e-03f, 1.09179512e-01f, -1.15169719e-01f, -1.50637954e-01f, 1.68171108e-01f,
  -1.45261079e-01f, 2.23919302e-01f, 2.94904649e-01f, -3.78947109e-01f, -5.70115149e-02f, -1.68503940e-01f, -2.60056168e-01f, 7.91303515e-02f, 4.17332470e-01f, -2.02499540e-03f,
  3.03058505e-01f, 3.23094279e-01f, 1.57719299e-01f, 1.21818133e-01f, 4.94466759e-02f, -1.90399185e-01f, -2.37305671e-01f, 4.86417152e-02f, -1.52489930e-01f, 3.26339900e-01f,
  2.20549449e-01f, 2.43982777e-01f, -1.84570089e-01f, 3.42491359e-01f, -1.65092677e-01f, -4.32407886e-01f, 8.60606954e-02f, -2.35149816e-01f, -2.85359565e-03f, 2.66698569e-01f,
  -8.42615291e-02f, -7.51930550e-02f, -8.11301395e-02f, 8.69699270e-02f, 3.63447331e-02f, 1.17107928e-02f, 1.10065997e-01f, -2.20829155e-02f, 1.05634436e-01f, 1.69725522e-01f,
  2.92729110e-01f, 1.28032384e-03f, 3.18983287e-01f, 7.87488818e-02f, -1.85470670e-01f, 1.39405549e-01f, 6.78025633e-02f, 1.97346210e-01f, -5.14723063e-02f, -1.48790568e-01f,
  2.07583625e-02f, 6.75901026e-02f, 7.79684111e-02f, 7.39703700e-02f, 2.38323845e-02f, 4.78136688e-01f, -2.76089579e-01f, 1.28713846e-01f, -9.91262347e-02f, -2.27725387e-01f,
  -1.57104075e-01f, 4.25299257e-02f, -4.85213883e-02f, -2.45284781e-01f, 9.44872200e-02f, 4.58507836e-02f, 2.37057973e-02f, 3.34903151e-02f, 4.16692287e-01f, 1.35974571e-01f,
  4.33484726e-02f, -8.79248604e-03f, 5.53124696e-02f, -6.49766177e-02f, -2.04014882e-01f, -1.11522665e-02f, -2.18783617e-01f, -6.94299489e-02f, -2.88657218e-01f, 7.03967288e-02f,
  -4.06427383e-02f, 6.39729351e-02f, 7.88843334e-02f, 6.28726259e-02f, -1.30653039e-01f, -9.56892595e-03f, 2.69776493e-01f, -9.67971385e-02f, -3.00635640e-02f, -1.89653486e-01f,
  3.36877674e-01f, 4.36271215e-03f, -1.27406865e-01f, -7.25308955e-02f, -1.64499998e-01f, 2.64411181e-01f, 9.19352397e-02f, -8.65028575e-02f, -2.18946543e-02f, -3.24438542e-01f,
  -1.53941199e-01f, -2.32649207e-01f, -8.24956819e-02f, -7.75519311e-02f, 2.51619279e-01f, -3.28453444e-02f, 2.50021160e-01f, 2.75984108e-01f, 1.26595542e-01f, -4.38144468e-02f,
  -8.81775096e-02f, 4.43069339e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.17351323e-01f, 9.33752488e-03f, -4.89897020e-02f, -1.09077364e-01f, 1.57482818e-01f, 1.10228576e-01f, -2.41635423e-02f, -4.89247926e-02f, 2.19904140e-01f, 2.82509208e-01f,
  -4.99003427e-03f, -2.72662133e-01f, -8.71066451e-02f, -3.10395937e-02f, 1.97127253e-01f, 8.22613984e-02f, 1.48665696e-01f, 8.49590078e-02f, -1.21329855e-02f, 1.77953899e-01f,
  -1.84822548e-02f, -8.26745555e-02f, 2.13804916e-01f, -3.40767056e-02f, -7.61531666e-03f, 2.07821205e-01f, 3.82622927e-01f, -8.99449214e-02f, -1.38257191e-01f, 5.11799082e-02f,
  1.01055324e-01f, 8.60778764e-02f, 1.07410289e-01f, 2.13227376e-01f, 1.09207459e-01f, 2.25304097e-01f, 8.70206803e-02f, 1.61869377e-01f, 3.40066612e-01f, -2.00821385e-01f,
  2.27700993e-01f, 1.49766132e-01f, 3.56389076e-01f, 2.00065803e-02f, -1.41819686e-01f, 1.63913012e-01f, 1.64044335e-01f, -6.22032918e-02f, 2.68013209e-01f, -5.62357679e-02f,
  -2.12630451e-01f, -8.26833770e-02f, -6.06251806e-02f, 2.81381041e-01f, 3.33320826e-01f, -3.41963433e-02f, -9.39205438e-02f, -1.02235936e-02f, 1.79232210e-01f, -2.09507674e-01f,
  -5.62600605e-02f, -1.96070790e-01f, 3.20816427e-01f, -1.43331930e-01f, -1.09044947e-02f, -1.93448532e-02f, 5.60298674e-02f, 7.45249465e-02f, -7.92221054e-02f, -7.79287592e-02f,
  -2.03761443e-01f, -1.67005077e-01f, 1.25654101e-01f, -1.65307865e-01f, -2.53254026e-01f, -2.34005943e-01f, 2.45947406e-01f, -1.45963848e-01f, -3.58622670e-02f, -5.70064373e-02f,
  7.34505504e-02f, 1.53745979e-01f, 4.30420429e-01f, -1.93323389e-01f, -1.27010718e-01f, 9.74702016e-02f, -1.87631190e-01f, 5.12055382e-02f, 1.82144135e-01f, -1.92357212e-01f,
  1.29531831e-01f, -1.97954215e-02f, 7.16905743e-02f, 2.19397217e-01f, 1.41097978e-01f, 8.53377208e-02f, -1.96870193e-02f, 1.02379292e-01f, 1.56285599e-01f, 7.22887143e-02f,
  1.90303735e-02f, 2.69321442e-01f, -1.15907736e-01f, 3.02714705e-01f, -2.15988338e-01f, -2.49582797e-01f, 2.13631600e-01f, -6.13233745e-02f, -1.07891098e-01f, -1.60303682e-01f,
  -5.91161735e-02f, 2.36328006e-01f, -9.37063023e-02f, -1.19490184e-01f, 4.17382084e-02f, 1.19959027e-01f, -1.33134663e-01f, -4.76185465e-03f, 5.52225113e-02f, 2.25827947e-01f,
  -6.67482466e-02f, 3.54235545e-02f, -7.82659203e-02f, 3.23518366e-01f, 2.80471947e-02f, 8.95655453e-02f, 6.38146624e-02f, -1.23602383e-01f, 2.03711122e-01f, 4.11992997e-01f,
  5.17621934e-01f, 2.15669826e-01f, 3.85573834e-01f, 4.89620328e-01f, -7.25458801e-01f, -1.35825783e-01f, -1.75772771e-01f, -4.29412395e-01f, -1.50287479e-01f, -5.31737924e-01f,
  3.03015590e-01f, 3.16161275e-01f, 1.96267664e-01f, -2.54923373e-01f, 3.99581671e-01f, 5.11205137e-01f, 5.62408686e-01f, 2.78436482e-01f, 6.78130090e-02f, -2.80409038e-01f,
  -1.94737375e-01f, 1.00193441e-01f, -1.73128054e-01f, -1.30905136e-01f, 1.95832357e-01f, -1.53005853e-01f, -3.18171412e-01f, -4.05163348e-01f, 5.69486842e-02f, 1.03978112e-01f,
  1.03165172e-02f, 8.25498253e-02f, 2.60369256e-02f, -1.74850821e-01f, -1.96522832e-01f, -1.06850095e-01f, -9.70287398e-02f, 6.73392415e-02f, -9.55001730e-03f, 9.78960991e-02f,
  9.04433951e-02f, -1.16340607e-01f, 3.17280516e-02f, 5.75500191e-04f, -1.63748085e-01f, -3.30901868e-03f, 1.38004795e-01f, 8.50819349e-02f, -4.64502256e-03f, -1.04597449e-01f,
  8.40653703e-02f, -1.40393808e-01f, 4.64790761e-02f, -1.44131020e-01f, 3.51591632e-02f, 1.38477251e-01f, 1.46162044e-02f, 4.17558756e-03f, 2.02340484e-02f, 9.31528509e-02f,
  -8.06096289e-03f, 3.21970060e-02f, 1.89569950e-01f, 3.66266370e-01f, 3.39494854e-01f, 1.83801740e-01f, 1.82703823e-01f, 1.92023665e-01f, 1.37013704e-01f, 3.32848340e-01f,
  -3.18067700e-01f, -6.85255766e-01f, 4.83007640e-01f, 1.12219900e-01f, 6.99191689e-02f, 3.62674296e-02f, -1.16016477e-01f, 2.96983838e-01f, 3.48463118e-01f, -1.00330323e-01f,
  -1.24027506e-01f, -1.55284464e-01f, -2.02860013e-02f, -1.80812597e-01f, -3.68472606e-01f, 2.38756537e-01f, 3.38584930e-01f, 2.34676257e-01f, -2.46319532e-01f, 1.49746373e-01f,
  -1.67311251e-01f, 3.08356546e-02f, 1.12358138e-01f, 6.08633533e-02f, -1.45028785e-01f, 1.04048669e-01f, 5.36065325e-02f, 1.55312404e-01f, 3.31147224e-01f, 2.19641253e-01f,
  -3.94259065e-01f, 4.86804277e-01f, -4.91174161e-01f, -1.14718981e-01f, 2.88421780e-01f, -1.18650787e-01f, -3.39810438e-02f, 3.04226249e-01f, -7.07884179e-03f, -5.11719054e-03f,
  1.76846720e-02f, 3.52694988e-01f, -1.25213876e-01f, 3.49685460e-01f, 4.24600542e-01f, 3.28853577e-02f, 6.23641051e-02f, 1.24668464e-01f, 1.39819384e-01f, -3.36006768e-02f,
  1.11046188e-01f, 1.56662211e-01f, -9.29945111e-02f, 4.98209968e-02f, 6.75965054e-03f, -3.64220589e-02f, 4.12806571e-01f, 3.37877840e-01f, 2.58929044e-01f, -1.72124088e-01f,
  1.54273272e-01f, 2.50775099e-01f, 1.27341047e-01f, 2.13429675e-01f, 6.41501918e-02f, 3.05190563e-01f, -1.92549929e-01f, 1.83188796e-01f, 1.05370678e-01f, -2.04355210e-01f,
  -5.41509427e-02f, 3.82706821e-02f, -4.56735156e-02f, -1.11916609e-01f, -2.76890457e-01f, 2.67757565e-01f, -7.41225556e-02f, 1.57354753e-02f, 1.53837574e-03f, 1.52197942e-01f,
  -2.20658600e-01f, 3.42592448e-01f, -1.19249128e-01f, -4.34595235e-02f, 2.17203379e-01f, 2.01842651e-01f, -1.32500559e-01f, 6.10270165e-02f, -2.30233029e-01f, 5.62266111e-02f,
  -1.73317909e-01f, 1.50072455e-01f, -9.51947197e-02f, 9.65995938e-02f, 8.23135599e-02f, -1.88482955e-01f, -3.86994854e-02f, 8.39244947e-03f, 2.78576374e-01f, 4.28234152e-02f,
  -8.79577771e-02f, -3.39744948e-02f, 4.11777012e-02f, 1.39155552e-01f, 1.59263220e-02f, -2.44268492e-01f, 8.83965939e-02f, -1.15619577e-01f, 2.41605714e-01f, -1.68120172e-02f,
  3.31867278e-01f, 3.36310640e-02f, -2.81772371e-02f, -1.61145002e-01f, 5.84421337e-01f, 2.74494052e-01f, -3.46094631e-02f, 2.77501019e-03f, 1.50872782e-01f, -9.29571502e-03f,
  -1.45244569e-01f, 1.46400869e-01f, -1.02334127e-01f, 1.12151332e-01f, -6.42291009e-02f, 1.62396654e-02f, 6.61031082e-02f, 2.16705054e-02f, 1.24362610e-01f, 1.40328154e-01f,
  1.97334498e-01f, -1.26196861e-01f, -1.81650400e-01f, -1.42101482e-01f, -1.44576067e-02f, 2.51194108e-02f, -1.05162747e-01f, -2.37720795e-02f, -1.46104872e-01f, 4.44105826e-02f,
  -1.01511247e-01f, -2.90175527e-02f, -1.10666230e-01f, 1.12326004e-01f, 5.34816347e-02f, -1.58998281e-01f, 2.16001555e-01f, 1.96656510e-01f, -1.59106195e-01f, -1.38057306e-01f,
  4.66039404e-02f, 1.59539357e-02f, 2.77861446e-01f, 4.99802679e-01f, 2.15641782e-01f, -9.14111454e-03f, 2.73411591e-02f, 2.01415837e-01f, -3.96429926e-01f, -2.71752238e-01f,
  5.73339574e-02f, 5.13032019e-01f, -6.19664490e-01f, -3.59410882e-01f, 1.92140818e-01f, 5.87143041e-02f, 5.91749251e-01f, 2.38788784e-01f, -1.92200646e-01f, -9.75705907e-02f,
  -7.10293278e-02f, 7.03566253e-01f, 4.32098657e-01f, 3.52430016e-01f, 1.98026747e-01f, 4.02244538e-01f, -2.74214625e-01f, 5.49905717e-01f, -8.83494467e-02f, 1.14723556e-01f,
  3.18525344e-01f, 5.39858229e-02f, 1.92310750e-01f, -1.43085673e-01f, -1.75302699e-01f, -9.82030183e-02f, -1.12328149e-01f, -6.11491650e-02f, -8.56623203e-02f, -2.09758058e-02f,
  -3.83719467e-02f, -5.80715165e-02f, 2.72267424e-02f, -1.14660650e-01f, 2.49757096e-02f, 1.79364324e-01f, -4.30301912e-02f, -9.54266340e-02f, 1.52338848e-01f, 8.75118300e-02f,
  -1.51680574e-01f, 6.89062178e-02f, -1.30016044e-01f, -1.27792537e-01f, 6.36290433e-03f, -6.98071495e-02f, -1.31835893e-01f, 1.02964811e-01f, -9.17395204e-02f, -1.50763512e-01f,
  -1.46409214e-01f, 1.86272885e-03f, 3.62879038e-02f, 1.01508528e-01f, 5.71635924e-02f, 8.21567699e-02f, -1.72707230e-01f, -2.35789781e-03f, 1.60934061e-01f, -2.44450066e-02f,
  2.10348740e-01f, 5.49597032e-02f, -8.79305229e-02f, 1.82216570e-01f, 3.34246308e-02f, -1.78265259e-01f, 1.68900341e-02f, 3.82247306e-02f, 5.49624162e-03f, 1.04065910e-01f,
  -7.26068318e-02f, 3.07575643e-01f, 1.43287495e-01f, 1.99929684e-01f, -1.57978594e-01f, -4.26840559e-02f, -2.51720697e-01f, -2.23340411e-02f, 6.53884336e-02f, 2.08935618e-01f,
  8.17616843e-03f, 2.11290762e-01f, 3.00185800e-01f, 2.88771480e-01f, -1.16664372e-01f, 9.36751738e-02f, 1.39787167e-01f, 1.83287635e-02f, 3.26690711e-02f, 6.89795092e-02f,
  1.88397020e-01f, 4.04779464e-01f, 7.55386008e-03f, -7.24676773e-02f, 4.29788351e-01f, 5.17305955e-02f, 2.49390393e-01f, 2.00811341e-01f, -1.09484784e-01f, 2.51913309e-01f,
  -8.95122513e-02f, -2.70327270e-01f, 2.23769054e-01f, 3.33766490e-01f, -4.42975275e-02f, -1.84242323e-01f, -2.08372176e-02f, 6.98779449e-02f, 9.75112244e-03f, -1.31325454e-01f,
  3.26516807e-01f, 2.28104115e-01f, 1.42160758e-01f, 2.69364595e-01f, 1.05057701e-01f, 5.16035020e-01f, 4.85721439e-01f, 2.11915508e-01f, 1.25286460e-01f, -5.40568158e-02f,
  -1.35664955e-01f, -3.83204920e-03f, 1.04331963e-01f, 5.47252819e-02f, -9.33796689e-02f, 2.03461379e-01f, 2.48456240e-01f, 1.86216414e-01f, -2.59531081e-01f, 6.02118932e-02f,
  -1.68540049e-02f, 2.14834183e-01f, 3.35536897e-02f, -1.53549150e-01f, -1.56236112e-01f, 2.85418600e-01f, 5.33927828e-02f, -3.27914767e-02f, -1.23841405e-01f, 2.41574258e-01f,
  2.95545340e-01f, -2.13695079e-01f, 1.43921608e-03f, 1.56691447e-01f, 3.54166180e-01f, 6.40657246e-02f, -1.89598948e-01f, 3.53144914e-01f, 2.56741583e-01f, 5.23272855e-03f,
  -3.27432364e-01f, 1.60933971e-01f, 1.40451714e-01f, 1.57017249e-03f, -2.41818037e-02f, 4.89604734e-02f, 1.88787684e-01f, 1.09231837e-01f, -2.20591933e-01f, 1.97174400e-01f,
  -3.74978930e-02f, 2.22654358e-01f, -1.60843551e-01f, -7.37313256e-02f, 1.98209491e-02f, 6.81668445e-02f, -3.25589180e-02f, 8.39293897e-02f, 2.46356517e-01f, 1.49097428e-01f,
  -1.33327981e-02f, 1.96077883e-01f, 2.68260062e-01f, 1.08764887e-01f, 1.52017042e-01f, -2.42679343e-01f, -7.62580931e-02f, -1.24673441e-01f, 1.62059873e-01f, -7.01920614e-02f,
  8.42417218e-03f, -2.40595788e-01f, 1.17533207e-01f, -5.66461235e-02f, 3.45984614e-03f, 9.83412713e-02f, 1.23456717e-01f, 2.01319262e-01f, -1.69692472e-01f, 7.48999417e-03f,
  2.66461253e-01f, -9.48101729e-02f, -9.20757055e-02f, 1.62029609e-01f, 1.66701481e-01f, 3.33022065e-02f, -3.43847685e-02f, 1.13566332e-02f, -7.57991895e-02f, -1.63931057e-01f,
  7.30092004e-02f, -1.73823312e-01f, -1.29247621e-01f, -5.96454740e-02f, 1.03110895e-01f, 4.10994340e-04f, 6.72627687e-02f, -5.26708364e-02f, -2.26387084e-02f, -7.94233195e-03f,
  6.06251247e-02f, -1.28428638e-01f, -9.30104107e-02f, -7.28110597e-02f, 7.91527703e-02f, -1.30172685e-01f, -8.18697438e-02f, -6.78077200e-03f, -1.19437808e-02f, 2.35331431e-02f,
  -1.22541703e-01f, 1.45527795e-01f, -9.95399207e-02f, 1.15102105e-01f, -1.24368228e-01f, -1.38130829e-01f, -1.26886353e-01f, 1.01502649e-01f, -8.11748058e-02f, -1.35532558e-01f,
  -5.37034012e-02f, 2.21791819e-01f, 1.32894740e-01f, 1.21185884e-01f, -8.99911523e-02f, -1.61544625e-02f, -3.97588834e-02f, -3.19905430e-02f, 1.38854787e-01f, 3.67647149e-02f,
  1.88282028e-01f, 9.32068005e-02f, 1.28886491e-01f, 2.83623308e-01f, -5.76448515e-02f, 2.13875510e-02f, -1.04805827e-01f, -2.52973195e-02f, 2.06273105e-02f, 1.81546420e-01f,
  4.76733223e-02f, 8.47843513e-02f, -2.00369284e-02f, 2.12509051e-01f, 4.06490117e-01f, -2.07874671e-01f, 1.59937114e-01f, 1.32623501e-02f, 2.23965973e-01f, 9.15415436e-02f,
  -1.05153322e-01f, 5.32562658e-03f, 7.57359415e-02f, 1.63849935e-01f, -8.92811939e-02f, -1.60541251e-01f, 3.59385721e-02f, 2.17281893e-01f, 4.67501115e-03f, -7.00787827e-02f,
  3.23645830e-01f, 1.82475969e-01f, -9.23352018e-02f, 2.30174791e-03f, 2.20031932e-01f, 3.65027785e-01f, 2.34431893e-01f, 1.06227204e-01f, 2.32752174e-01f, 5.21817356e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  1.94806736e-02f, 1.66844621e-01f, -7.57080168e-02f, 2.32985139e-01f, 4.50117648e-01f, -1.48807392e-01f, 4.37790573e-01f, 2.19097912e-01f, 2.34227464e-01f, 2.22589165e-01f,
  9.39552300e-03f, 2.60312706e-01f, -1.76379204e-01f, -2.93432772e-02f, 1.12084709e-01f, 2.62757033e-01f, 1.36606678e-01f, 5.83902746e-02f, -2.72329133e-02f, 2.08214119e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.08946025e-01f, -8.04495141e-02f, -3.61809060e-02f, 1.81705937e-01f, 1.51098818e-01f, -2.53868908e-01f, 1.17712311e-01f, 4.23690528e-02f, -4.58107263e-01f, 4.61152121e-02f,
  1.20859630e-01f, 1.27146006e-01f, 1.56577438e-01f, 8.82467777e-02f, 1.00041637e-02f, 1.12629943e-01f, -6.02014959e-01f, 1.51660010e-01f, 3.47640249e-03f, -4.77586426e-02f,
  2.89685279e-01f, -7.44804889e-02f, 1.51874274e-01f, 3.19709927e-01f, 3.95420156e-02f, -1.67678237e-01f, 2.02990994e-01f, 2.04737663e-01f, -5.00617884e-02f, 1.39535308e-01f,
  -8.37596804e-02f, -9.89225656e-02f, 2.58216579e-02f, 2.86222041e-01f, -6.51303753e-02f, -6.78262301e-03f, 7.42132589e-02f, 2.11394072e-01f, -3.84370200e-02f, -1.19338028e-01f,
  -2.90215701e-01f, 8.49417001e-02f, 1.49894103e-01f, 1.32403240e-01f, -2.10444890e-02f, 3.26507360e-01f, -2.16903672e-01f, -2.04200909e-01f, -1.11703537e-01f, 7.29437033e-03f,
  -4.34606783e-02f, 1.85332090e-01f, 1.04073539e-01f, -2.22236458e-02f, 3.42650563e-02f, -2.56058842e-01f, -3.72135602e-02f, -5.15613481e-02f, -3.76642160e-02f, -5.91583066e-02f,
  1.51509345e-01f, 2.12699473e-02f, -1.53608650e-01f, 1.71138406e-01f, -1.33821204e-01f, -6.62726462e-02f, -2.65017509e-01f, -6.02089502e-02f, 1.08529374e-01f, 5.63798174e-02f,
  3.40006411e-01f, 2.50452518e-01f, 1.22803971e-01f, 2.09214821e-01f, -1.94286183e-01f, -2.46066570e-01f, 1.44110933e-01f, -1.20634116e-01f, 4.77671102e-02f, -4.58354242e-02f,
  2.96353281e-01f, -1.33804586e-02f, -1.47238418e-01f, 1.21322878e-01f, -1.01003893e-01f, -2.83162624e-01f, -1.40894115e-01f, 3.38582665e-01f, 4.35902402e-02f, 1.15078963e-01f,
  -1.17864080e-01f, -1.52484223e-01f, 1.02499817e-02f, -1.38957232e-01f, 3.89257371e-02f, -2.71893293e-01f, -6.18817247e-02f, 1.08867094e-01f, -3.62502858e-02f, 2.16095909e-01f,
  1.08086060e-04f, 2.49179050e-01f, -2.97771692e-01f, 1.40758500e-01f, 9.40550268e-02f, -2.27599200e-02f, -2.40902901e-01f, -1.20230868e-01f, 1.54089332e-01f, 8.21368396e-02f,
  9.84637365e-02f, -1.25915617e-01f, 8.01087394e-02f, -1.34958494e-02f, 2.06439123e-01f, -2.35530540e-01f, -9.94396508e-02f, 1.55963048e-01f, -8.90432447e-02f, -3.57622653e-01f,
  -1.13202751e-01f, -1.26082338e-02f, -4.87404317e-02f, -1.70709103e-01f, 1.61822781e-01f, 1.24208868e-01f, -9.87961069e-02f, 1.73560888e-01f, 7.94794504e-03f, 2.65087962e-01f,
  6.24880008e-03f, 3.33811194e-01f, 1.80309966e-01f, 1.50320664e-01f, 4.20901626e-01f, 1.74564775e-02f, -2.09902823e-01f, -1.56577393e-01f, 7.81863462e-03f, -2.61605620e-01f,
  1.44770909e-02f, 6.56963792e-03f, 6.23883754e-02f, -1.16431057e-01f, -3.52117419e-02f, 1.43993974e-01f, -3.51067662e-01f, -2.06982717e-01f, 2.72260636e-01f, -1.03673615e-01f,
  -5.31465448e-02f, 5.05702674e-01f, -2.48859338e-02f, -1.53327763e-01f, 1.08809054e-01f, -1.35630682e-01f, -1.71289891e-02f, 1.34765938e-01f, 1.98604912e-02f, -9.54377949e-02f,
  -1.22303464e-01f, 1.66747645e-01f, -6.03824630e-02f, -1.39975145e-01f, 9.06610563e-02f, -1.69605047e-01f, -2.05943882e-01f, -2.59050816e-01f, 2.37909228e-01f, 2.70350903e-01f,
  -4.74868491e-02f, 2.62611628e-01f, 8.38255957e-02f, -1.21193625e-01f, 7.11461827e-02f, -9.23876390e-02f, 3.43101591e-01f, -1.22253999e-01f, 2.43442178e-01f, 2.86802560e-01f,
  -1.94737136e-01f, 1.08529769e-01f, 1.86512083e-01f, -2.65414178e-01f, -1.85081661e-01f, 2.58821428e-01f, -2.10921928e-01f, -1.28092930e-01f, -5.18997647e-02f, -5.00933677e-02f,
  1.85071021e-01f, -6.59664348e-02f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.39954597e-01f, -1.38947129e-01f, 1.39450490e-01f, -1.82175055e-01f, 2.32514948e-01f, -1.94912538e-01f, 2.93582320e-01f, -3.99931699e-01f, -3.81845772e-01f, 3.07030141e-01f,
  3.97705495e-01f, -5.85729107e-02f, -1.14393920e-01f, 1.72141150e-01f, -3.66388828e-01f, 7.66728520e-02f, 2.31446639e-01f, 8.16871878e-03f, 3.30641167e-03f, 3.16809833e-01f,
  8.41556676e-03f, 2.77584076e-01f, -1.51524302e-02f, 2.16639817e-01f, -4.61521782e-02f, -3.02108377e-01f, -2.47921959e-01f, 2.06898034e-01f, 2.91354477e-01f, 1.08307600e-01f,
  -1.42984137e-01f, -7.08305836e-02f, 4.50657792e-02f, 4.13736880e-01f, 2.14239314e-01f, 4.34765041e-01f, 4.06617045e-01f, 4.14801687e-01f, 3.35339576e-01f, 1.77428350e-01f,
  -3.74948204e-01f, -1.95485368e-01f, 6.62932843e-02f, -3.53155434e-01f, 9.35378224e-02f, 2.56788820e-01f, -1.04000531e-01f, -4.32090200e-02f, 3.03387254e-01f, -2.56504752e-02f,
  -3.82521778e-01f, -3.36178899e-01f, 1.37855157e-01f, -1.69840157e-01f, -1.04406796e-01f, 6.18141890e-01f, 1.15836561e-01f, -2.27783903e-01f, 1.55471027e-01f, -2.92490069e-02f,
  1.58180594e-01f, 6.51307553e-02f, 4.92345355e-02f, 1.14048027e-01f, 3.95314731e-02f, 1.40247047e-01f, 7.27630481e-02f, 1.96272060e-01f, -4.85357121e-02f, 2.24996895e-01f,
  2.14196876e-01f, 2.07822129e-01f, -1.37199357e-01f, -2.14080676e-01f, 4.70265038e-02f, -2.02136934e-01f, 8.15375969e-02f, -1.96178690e-01f, -1.25780672e-01f, 1.69780813e-02f,
  -1.25341518e-02f, -1.75187662e-01f, -2.27538541e-01f, -1.52189657e-01f, 3.20312977e-01f, 2.63342299e-02f, -1.57532856e-01f, 4.00249124e-01f, -1.12525202e-01f, -1.00081511e-01f,
  3.41259450e-01f, 6.09693266e-02f, -1.65922828e-02f, 9.22433287e-03f, -6.28977716e-02f, 2.93496460e-01f, 2.30346456e-01f, 3.31259444e-02f, 1.09029695e-01f, 6.37065247e-02f,
  1.66559041e-01f, 1.30833611e-01f, -2.74225503e-01f, 9.26723555e-02f, 4.34437692e-01f, 1.60035014e-01f, 4.41271439e-02f, 1.67020291e-01f, -8.61183368e-03f, -1.42832726e-01f,
  4.35147643e-01f, -9.71054882e-02f, 6.29361451e-01f, -2.24491060e-02f, 3.46605144e-02f, -2.16808602e-01f, -3.82059306e-01f, -1.17725566e-01f, -1.63050853e-02f, -1.40229806e-01f,
  -4.70986292e-02f, -1.17296174e-01f, 1.38697386e-01f, -2.40369543e-01f, 1.47906020e-01f, -1.53920352e-01f, 5.01958169e-02f, -1.81694493e-01f, 1.49964139e-01f, -1.56146456e-02f,
  -2.38069788e-01f, -1.47917092e-01f, 3.96066234e-02f, -1.46686152e-01f, 3.45821562e-03f, 9.93055403e-02f, -1.35355040e-01f, -3.84251773e-02f, 1.15857802e-01f, 1.26136923e-02f,
  1.12510160e-01f, -8.45255330e-02f, -8.03216547e-02f, -1.34638682e-01f, 1.81741908e-01f, -5.69102764e-02f, -2.99619019e-01f, -6.59956858e-02f, 6.70265928e-02f, 2.16818899e-01f,
  -2.67873723e-02f, 4.65876758e-01f, 1.69586480e-01f, -1.29376873e-01f, 1.04215257e-01f, 1.42959386e-01f, 1.63606733e-01f, 8.87473822e-02f, 5.11230230e-02f, -3.38538270e-03f,
  1.06934853e-01f, 1.69364437e-01f, -5.94080659e-03f, 1.88498557e-01f, 1.17754385e-01f, -9.18981209e-02f, -1.13750614e-01f, -6.95773959e-02f, 1.73318818e-01f, 2.23647412e-02f,
  1.34725973e-01f, 2.63279855e-01f, 1.87100247e-01f, -5.82475066e-02f, -1.16968244e-01f, 2.00381026e-01f, -8.87220353e-02f, 1.38783306e-01f, 2.07691029e-01f, 1.39938697e-01f,
  -1.55305952e-01f, 2.99238980e-01f, 1.17012724e-01f, -2.15154454e-01f, 1.58808872e-01f, 1.94693089e-01f, -2.37347232e-03f, 2.10343540e-01f, -9.60191339e-03f, 1.60954669e-02f,
  1.63282678e-01f, -2.49493122e-02f, 3.60890962e-02f, 1.82801083e-01f, -7.99636468e-02f, 1.36072934e-01f, -8.48925710e-02f, 2.84052212e-02f, 2.30964333e-01f, -8.32544919e-03f,
  -2.19149679e-01f, -6.21857792e-02f, 1.51726544e-01f, -4.86807376e-02f, 1.08986087e-01f, 6.99363202e-02f, -7.05898851e-02f, -1.30897118e-02f, 9.36080068e-02f, 9.11434889e-02f,
  -1.02431469e-01f, -7.76002631e-02f, -1.47962980e-02f, 1.41812474e-01f, 7.13774040e-02f, 9.52914804e-02f, 1.07523941e-01f, -1.53902441e-01f, -1.78653553e-01f, -5.41200079e-02f,
  -1.25331283e-02f, -9.33073983e-02f, 5.67793064e-02f, -1.35305390e-01f, 1.63966894e-01f, 1.64949913e-02f, 2.95966994e-02f, -2.21968845e-01f, 2.98434019e-01f, 1.43304557e-01f,
  3.83121192e-01f, -2.10402116e-01f, 6.11246340e-02f, 1.83901876e-01f, 2.91073829e-01f, -3.47187877e-01f, 1.38873309e-01f, 3.31487246e-02f, 1.01345532e-01f, 6.31218255e-02f,
  1.21876121e+00f, -3.05722491e-03f, -6.05926774e-02f, 5.75486243e-01f, -1.97637945e-01f, -3.55932079e-02f, -5.07119969e-02f, 2.43829474e-01f, -6.15138421e-03f, -1.00546665e-01f,
  -5.83595097e-01f, -2.09387586e-01f, 3.82999092e-01f, 2.92023504e-03f, -1.66122615e-01f, -2.82711893e-01f, -8.17273837e-03f, 2.16302916e-01f, 5.78811057e-02f, 5.31915203e-02f,
  -9.73518658e-03f, -2.13767007e-01f, 3.43240082e-01f, 2.13496521e-01f, -2.13619903e-01f, -8.39918777e-02f, -7.69781545e-02f, -9.19985771e-02f, 3.00015986e-01f, 1.67023987e-01f,
  -1.84881851e-01f, 5.83102228e-03f, 1.90116554e-01f, -1.14635743e-01f, -2.16696858e-01f, 1.51180819e-01f, 1.56162217e-01f, 1.90817922e-01f, 9.26554352e-02f, 6.74335837e-01f,
  1.47725403e-01f, 4.24588770e-02f, 2.31314972e-01f, -2.45221630e-01f, 1.08474724e-01f, -1.92091838e-01f, -1.81008950e-01f, 2.67688543e-01f, 1.47339180e-01f, 7.59824216e-02f,
  -5.01509085e-02f, 1.53968528e-01f, 2.13823140e-01f, 1.31183356e-01f, -1.46703392e-01f, -8.83456394e-02f, -1.96644157e-01f, -1.49886712e-01f, -8.85523856e-02f, -7.62334093e-02f,
  1.40212357e-01f, 2.51490533e-01f, -3.03181782e-02f, 1.40136024e-02f, 2.10723802e-02f, 5.88497221e-02f, -8.88189003e-02f, -2.06596136e-01f, 4.33679521e-02f, -3.29912379e-02f,
  1.03751160e-01f, 4.64767031e-02f, -3.22118774e-02f, 3.57045978e-02f, 3.96104828e-02f, 8.35190341e-03f, -5.57813281e-03f, 7.82416612e-02f, -1.74075365e-01f, -3.11636422e-02f,
  1.50718182e-01f, 2.85377085e-01f, 2.20338255e-01f, 2.22854480e-01f, 3.22977245e-01f, 3.43074173e-01f, -2.17748344e-01f, 8.46365094e-03f, -6.29642308e-02f, 6.08831346e-02f,
  -3.78354698e-01f, 1.27950266e-01f, -6.27646744e-02f, -2.27546021e-02f, 1.47265688e-01f, -5.20052330e-04f, 4.13695693e-01f, 1.29809767e-01f, 2.97764897e-01f, -4.38520610e-01f,
  7.02185035e-02f, 2.40600873e-02f, -3.60803790e-02f, 8.17605406e-02f, -2.05341596e-02f, -1.57242313e-01f, -2.80869156e-01f, -2.14380071e-01f, -2.65748680e-01f, 1.58759840e-02f,
  -2.02540040e-01f, -5.54128811e-02f, 2.71662772e-01f, 3.82111937e-01f, 2.77726024e-01f, 4.36902732e-01f, 3.17725390e-01f, 2.03908250e-01f, -2.55145878e-01f, -1.04181319e-01f,
  -8.54912251e-02f, 1.27658382e-01f, -1.90574259e-01f, 2.67279595e-01f, -1.21774524e-01f, 2.34220937e-01f, -1.38965383e-01f, 2.98361450e-01f, 2.17294008e-01f, 2.68773828e-02f,
  7.76136279e-01f, -1.54435158e-01f, -2.43603382e-02f, -2.08291650e-01f, 2.99763097e-03f, -3.54301661e-01f, -2.07187831e-02f, 2.21894026e-01f, 1.30044788e-01f, -6.74526617e-02f,
  -1.76667958e-01f, -5.99758653e-03f, 1.44106105e-01f, 9.25571993e-02f, 4.04997975e-01f, 1.97498709e-01f, 3.92787546e-01f, -3.21383812e-02f, 3.87695730e-01f, 3.16504359e-01f,
  7.58802053e-03f, -1.80136546e-01f, 4.86032069e-01f, 5.77554405e-01f, 3.32414806e-01f, 3.34373206e-01f, -2.90904939e-01f, -4.85680670e-01f, -1.51371792e-01f, 3.70761454e-01f,
  3.87699068e-01f, 6.51406869e-02f, 6.85360551e-01f, 5.88576317e-01f, -1.90176398e-01f, -1.57160029e-01f, -1.38807043e-01f, -2.08604366e-01f, 1.43998206e-01f, 9.79463756e-03f,
  1.37872070e-01f, 5.69238007e-01f, -1.23511128e-01f, -1.90769494e-01f, 2.46466264e-01f, -7.83202350e-02f, 1.55215576e-01f, 2.67151564e-01f, 2.39488650e-02f, 3.23078215e-01f,
  2.15261176e-01f, 1.36538357e-01f, -2.20798448e-01f, 5.49207404e-02f, -4.20896709e-01f, -1.73582599e-01f, -1.31362259e-01f, 2.02752605e-01f, -1.60383686e-01f, 2.42951795e-01f,
  -2.90184736e-01f, 9.05600339e-02f, 3.15495044e-01f, 1.01040371e-01f, 4.89653975e-01f, -4.25560810e-02f, 3.21350515e-01f, -2.50101864e-01f, -5.13655767e-02f, -2.70026267e-01f,
  -9.57005918e-02f, -1.47446483e-01f, -2.10606158e-01f, 2.13328144e-03f, 1.69653445e-02f, 6.81990907e-02f, -1.89610183e-01f, 1.86974779e-01f, -2.66864039e-02f, -5.96221462e-02f,
  -7.60770440e-02f, -1.34189472e-01f, 1.63169801e-01f, -5.26833124e-02f, -1.55287966e-01f, 1.27239361e-01f, -1.24065407e-01f, -4.94437404e-02f, -1.17814362e-01f, -2.49306969e-02f,
  -1.35790750e-01f, 5.43329492e-02f, 2.09564455e-02f, 2.11187489e-02f, -6.00009784e-02f, -1.66181490e-01f, -2.39110552e-02f, 6.64291978e-02f, -3.14226337e-02f, 1.34089431e-02f,
  2.80020181e-02f, 1.27091855e-01f, -1.06832363e-01f, -1.75851762e-01f, -1.38597190e-01f, 1.96985766e-01f, -1.55290291e-01f, -3.36025767e-02f, -1.42264605e-01f, 1.58762157e-01f,
  1.26592526e-02f, -1.56275645e-01f, -9.63519588e-02f, -1.39318287e-01f, 1.97706237e-01f, -2.16010481e-01f, 1.86472416e-01f, -3.31955403e-02f, 6.87644929e-02f, 8.09783116e-03f,
  -2.05258161e-01f, 1.25057638e-01f, 2.23296389e-01f, 1.09851226e-01f, 3.78753506e-02f, -8.58692266e-03f, 3.05731356e-01f, 7.88476989e-02f, -1.04583457e-01f, -1.10599540e-01f,
  -1.66192085e-01f, 1.91784263e-01f, 1.36762634e-01f, 3.48785102e-01f, -1.24184992e-02f, 1.19320273e-01f, -8.38612691e-02f, -2.20591038e-01f, -6.74787089e-02f, 7.65603129e-03f,
  -1.08535290e-01f, 9.11072418e-02f, 9.58623141e-02f, 3.68288308e-01f, 4.01125014e-01f, 1.89376727e-01f, 2.32864683e-03f, 3.32525671e-01f, -5.42796671e-01f, -1.93977669e-01f,
  1.82644293e-01f, -3.09732825e-01f, -3.01049322e-01f, 2.97429115e-01f, -1.33988053e-01f, 1.34891570e-01f, -1.78554416e-01f, -9.57416743e-02f, -4.50480133e-01f, 1.00845940e-01f,
  -1.26185998e-01f, -1.54429808e-01f, 2.06476644e-01f, 3.41110379e-01f, 3.26236449e-02f, 1.21662505e-01f, 1.88986287e-02f, -1.56193465e-01f, 6.72077239e-01f, 3.53453636e-01f,
  2.53644353e-03f, 1.82511672e-01f, -2.95706820e-02f, 4.39672887e-01f, -1.64770205e-02f, -7.32618421e-02f, -1.27685010e-01f, 1.87704504e-01f, 1.38764322e-01f, 2.24567309e-01f,
  1.00923136e-01f, 1.65676638e-01f, -7.74226487e-02f, 1.77174613e-01f, 4.84732799e-02f, 6.29784837e-02f, 1.39430299e-01f, -1.36002079e-01f, 6.84400201e-02f, 1.34897724e-01f,
  4.34080064e-02f, -2.96219885e-02f, -1.53479176e-02f, -8.38149339e-02f, 2.29023769e-01f, 1.01731993e-01f, -1.40183911e-01f, -7.25841103e-03f, 1.02607077e-02f, 6.61009457e-03f,
  -1.04796223e-01f, -4.87785600e-02f, 2.07858294e-01f, -3.74014042e-02f, 6.83314502e-02f, -1.64616898e-01f, 1.10921249e-01f, 1.49786681e-01f, -4.06462140e-02f, -4.14855666e-02f,
  -5.50613850e-02f, 1.02350162e-02f, -1.52408555e-01f, -2.65215337e-01f, 1.35770917e-01f, 2.32967108e-01f, 9.53843296e-02f, 2.04957321e-01f, 1.62057310e-01f, 9.36754644e-02f,
  -1.82882845e-01f, 3.18557084e-01f, -2.89255083e-02f, -8.48206580e-02f, -3.94157507e-02f, 7.99769163e-02f, -4.92132865e-02f, 4.53105628e-01f, 1.97257519e-01f, -1.36846513e-01f,
  -6.43339902e-02f, 1.77662879e-01f, 3.48191708e-01f, -4.52704765e-02f, 4.26997878e-02f, 1.30856186e-01f, 5.30545339e-02f, 4.58258718e-01f, 1.97935075e-01f, -2.50335294e-03f,
  1.59304291e-02f, 1.48144498e-01f, 1.85296685e-01f, 2.80941546e-01f, 2.49408290e-01f, 2.55014181e-01f, -6.92137331e-02f, 1.17898732e-01f, -2.46684700e-01f, -1.11262038e-01f,
  -1.49255261e-01f, -3.33051324e-01f, -5.73863685e-02f, 1.84292525e-01f, 1.46366348e-02f, -1.31148368e-01f, 1.05258539e-01f, 4.75680232e-02f, 5.05411208e-01f, -2.88515776e-01f,
  1.72481295e-02f, 8.07511985e-01f, 2.81672794e-02f, 1.90055743e-01f, 8.50020850e-04f, 2.61771739e-01f, -1.27764255e-01f, -1.80879042e-01f, -8.36818665e-03f, 1.39434114e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  1.90757528e-01f, 3.18303108e-01f, 2.25681495e-02f, 2.21091881e-01f, 2.08682958e-02f, -1.34103531e-02f, 2.12140560e-01f, 1.97237417e-01f, 1.70346975e-01f, 2.98965842e-01f,
  -1.96270403e-02f, 1.36850491e-01f, 2.36801237e-01f, 1.69688419e-01f, -9.20675769e-02f, 2.10009664e-01f, 4.01806295e-01f, -3.60491574e-02f, 2.12397739e-01f, 2.50957757e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -4.16278213e-01f, -5.03192723e-01f, -5.86705565e-01f, -3.55598658e-01f, 2.09995180e-01f, -1.83088705e-01f, -1.68762773e-01f, -5.17716780e-02f, -6.11405894e-02f, 1.53460473e-01f,
  2.94030383e-02f, -2.25340724e-01f, 7.90492967e-02f, 1.73066184e-01f, 2.84476995e-01f, -6.62935525e-02f, 2.45087698e-01f, -4.94208671e-02f, 2.39701867e-02f, 9.28650349e-02f,
  4.49300170e-01f, 6.25708560e-03f, -1.87207401e-01f, -3.52917224e-01f, -3.14111292e-01f, -2.82526135e-01f, 3.30637433e-02f, 3.27225178e-01f, -3.46514106e-01f, 2.20583417e-02f,
  -2.03544796e-01f, 5.37661195e-01f, 2.09735334e-01f, -1.54556520e-02f, -2.42357463e-01f, -4.03615773e-01f, 1.69496641e-01f, -1.61259234e-01f, -4.14976150e-01f, 2.10386924e-02f,
  -3.07224542e-01f, -3.93945687e-02f, 4.06502895e-02f, 2.42531046e-01f, 7.79867649e-01f, -5.18823862e-02f, -3.30832928e-01f, -1.51774153e-01f, 8.32629651e-02f, 1.93138029e-02f,
  -5.68749234e-02f, 8.43646884e-01f, 1.90527085e-02f, -2.22653672e-01f, -1.34077221e-01f, -5.21748483e-01f, 1.38375849e-01f, -1.04847409e-01f, 8.58035535e-02f, 2.48328090e-01f,
  -2.49765918e-01f, -1.94300786e-01f, 5.00220694e-02f, -2.38666996e-01f, 1.39114916e-01f, 1.75625309e-01f, 3.30306083e-01f, -2.17148140e-02f, 3.45511526e-01f, 1.06230140e-01f,
  -2.41956636e-01f, -1.82701424e-02f, 6.08177245e-01f, -3.15423327e-04f, -1.06100783e-01f, 3.35141271e-01f, -2.44879216e-01f, -2.09965020e-01f, -2.37881392e-01f, -4.61241677e-02f,
  -2.54023194e-01f, -5.49839586e-02f, -1.70965001e-01f, 3.17147672e-01f, 5.48012694e-03f, -1.92074850e-01f, 4.44900930e-01f, 4.87007022e-01f, 3.84079784e-01f, 5.01016080e-01f,
  1.56700134e-01f, -1.45591721e-01f, -4.89795506e-01f, 6.09217286e-02f, -4.34436411e-01f, 6.02549553e-01f, -2.24368647e-01f, -5.29838074e-03f, 2.88983881e-01f, -6.33594617e-02f,
  -5.26105821e-01f, -1.10294307e-02f, 2.44853839e-01f, -2.94224143e-01f, -3.84198427e-02f, -5.19434094e-01f, 5.78908086e-01f, -4.95604098e-01f, -3.01266104e-01f, 9.39405411e-02f,
  2.73151875e-01f, -1.28192201e-01f, -5.07849269e-02f, -1.51168287e-01f, 7.18803480e-02f, -3.04677218e-01f, -1.49579927e-01f, -1.27860725e-01f, -1.93939373e-01f, 1.03238359e-01f,
  5.62684655e-01f, 5.10302484e-02f, -9.15068090e-02f, -2.99738765e-01f, 1.82114556e-01f, 5.55245653e-02f, 3.53369415e-01f, 4.78619218e-01f, -1.78943738e-01f, 1.72123089e-01f,
  2.64477134e-01f, 4.16373499e-02f, -7.39284039e-01f, -3.12742114e-01f, 4.96075690e-01f, -6.33382499e-02f, 5.41723430e-01f, -4.35851485e-01f, -1.15510054e-01f, -3.25261682e-01f,
  -5.70623912e-02f, 3.24642122e-01f, 3.74959022e-01f, -1.63495198e-01f, 3.91753942e-01f, -1.38747945e-01f, -7.21985102e-02f, -5.38203359e-01f, 1.24406680e-01f, 1.82365969e-01f,
  4.07331251e-02f, -6.39101863e-01f, -6.59458399e-01f, -2.92704463e-01f, 2.30036423e-01f, -1.86029047e-01f, 4.75660801e-01f, -4.67384420e-02f, -2.64035016e-01f, 4.32509214e-01f,
  4.29737657e-01f, 5.74749671e-02f, -1.91329360e-01f, 1.82237737e-02f, -2.64157057e-01f, 4.78912622e-01f, 3.38939726e-01f, 3.71502578e-01f, 5.49786508e-01f, -2.18632743e-01f,
  3.94923650e-02f, -4.44615930e-01f, 3.63751620e-01f, 6.32476866e-01f, 1.54044390e-01f, -4.68233883e-01f, 1.52040452e-01f, -1.90357506e-01f, 3.52754593e-01f, 4.25015897e-01f,
  2.97486752e-01f, 1.41941190e-01f, -1.62955612e-01f, -3.33680570e-01f, -4.25714523e-01f, 2.54517734e-01f, -1.20045140e-01f, -1.42982334e-01f, -6.70595288e-01f, 2.62712389e-01f,
  -1.15971796e-01f, -5.97685110e-03f, 4.40170586e-01f, 1.19388467e-02f, 2.51080573e-01f, -6.87628239e-02f, 5.43073773e-01f, 2.40443975e-01f, -6.48065433e-02f, 3.21714550e-01f,
  -6.20453298e-01f, 3.40213209e-01f, -2.89136916e-01f, 2.52261013e-01f, -6.03504851e-02f, -1.97036728e-01f, -3.51983875e-01f, 1.64439991e-01f, -1.28238708e-01f, 1.05659671e-01f,
  -2.90277693e-03f, -2.86668152e-01f, -4.69751984e-01f, 2.17864498e-01f, 4.91937667e-01f, 7.14685440e-01f, 4.86027896e-02f, 7.23201275e-01f, 1.45407706e-01f, -4.67103499e-04f,
  8.05226192e-02f, 1.21164538e-01f, -4.78960387e-02f, -3.87607574e-01f, 2.63720512e-01f, 7.10610151e-02f, -2.70710979e-02f, -6.52030483e-02f, 1.34908304e-01f, -1.89712018e-01f,
  -1.93652540e-01f, 1.06855251e-01f, -3.83032233e-01f, 2.69547552e-01f, -5.61430454e-01f, 2.72140115e-01f, -3.00705642e-01f, -5.71942449e-01f, -8.13046396e-02f, -4.02674712e-02f,
  1.08671531e-01f, 2.97885895e-01f, -1.90999866e-01f, -5.71877301e-01f, 3.07778209e-01f, 3.17695700e-02f, -3.66312385e-01f, -9.07789264e-03f, -5.83336771e-01f, -2.57563740e-01f,
  -3.91990542e-02f, 2.57593066e-01f, 4.32142764e-01f, 9.02033038e-03f, 6.85145915e-01f, -2.84060746e-01f, -6.77087247e-01f, -1.89801231e-01f, -2.02088282e-01f, -3.59342694e-02f,
  -2.71646321e-01f, -5.90027750e-01f, -1.83785990e-01f, 1.49522081e-01f, 2.57562160e-01f, 1.56300724e-01f, -6.78236961e-01f, 9.62555408e-02f, 1.51724920e-01f, -6.76967561e-01f,
  -3.06346476e-01f, 5.15037298e-01f, -4.83127981e-02f, 1.77968457e-01f, -1.10456690e-01f, 7.13848412e-01f, -3.72681051e-01f, -1.13215514e-01f, -2.53402293e-01f, -4.85183373e-02f,
  7.12932706e-01f, -1.47280274e-02f, -9.07850936e-02f, -1.31726757e-01f, -2.83924222e-01f, 1.38906032e-01f, 8.83281529e-02f, -4.76892114e-01f, 1.65159300e-01f, 1.10746257e-01f,
  2.90394425e-01f, 3.42954338e-01f, 2.88266629e-01f, 3.31252038e-01f, 2.52331585e-01f, 1.89255729e-01f, -2.98372626e-01f, 2.79747695e-01f, 7.52042472e-01f, -5.88739991e-01f,
  -1.27573416e-01f, 4.25131202e-01f, 1.10443234e-01f, -2.57553998e-03f, -3.08632135e-01f, -3.17372203e-01f, -1.86739028e-01f, -5.59238911e-01f, 7.74643496e-02f, 2.15720177e-01f,
  -8.12406242e-02f, 1.77477702e-01f, -6.41253591e-01f, 3.63164008e-01f, -3.40569355e-02f, -7.70442858e-02f, 7.63751149e-01f, 6.76031858e-02f, 1.27419429e-02f, -1.83337957e-01f,
  -3.07733566e-01f, -3.04519951e-01f, -3.29220653e-01f, 2.11799413e-01f, -1.31248191e-01f, 1.94219336e-01f, -4.61460829e-01f, -1.67313248e-01f, 4.08550292e-01f, 2.77875006e-01f,
  4.59842116e-01f, 4.32958454e-02f, -5.87255836e-01f, 3.92890483e-01f, -5.94580360e-03f, 7.54252255e-01f, 7.20327161e-03f, -9.05490294e-02f, -1.23200845e-03f, 4.77323622e-01f,
  -7.04129413e-02f, 5.87170087e-02f, 5.15591562e-01f, -2.70536155e-01f, -5.95396608e-02f, -2.02278614e-01f, 1.05522349e-01f, 3.19953293e-01f, -2.95729637e-01f, 1.52521685e-01f,
  -2.96203375e-01f, -2.94141769e-02f, 3.35624129e-01f, 2.50462890e-01f, -1.27181649e-01f, 2.38781661e-01f, -3.54568847e-02f, 6.30230177e-03f, 2.10372105e-01f, 2.17913032e-01f,
  -2.54803360e-01f, -9.17476777e-04f, -2.00539321e-01f, 3.51775467e-01f, 1.20046109e-01f, -5.60307980e-01f, -2.46462375e-01f, -1.91486225e-01f, -1.71474144e-01f, 3.98429424e-01f,
  -1.57749444e-01f, -5.48880994e-01f, -5.56912363e-01f, -1.36466101e-01f, -2.71878660e-01f, 8.50916058e-02f, 9.28155959e-01f, -4.53940704e-02f, 8.94955695e-02f, -2.13722244e-01f,
  4.02653128e-01f, 1.01150885e-01f, 2.26231571e-02f, -3.31714042e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.67497504e-01f, -1.70376852e-01f, 2.52232011e-02f, -5.19301184e-02f, 1.51228249e-01f, 4.38213274e-02f, 2.98975378e-01f, 7.57176876e-02f, -1.33347183e-01f, 3.50054383e-01f,
  -2.12097585e-01f, 9.96845961e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    