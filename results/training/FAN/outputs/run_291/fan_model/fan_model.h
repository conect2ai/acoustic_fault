/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.37493858e-02f, -4.43258286e-02f, 1.57354459e-01f, 1.29925078e-02f, -1.06150806e-01f, 1.82435215e-01f, 2.25872219e-01f, -4.12812941e-02f, -2.53684551e-01f, 1.12393005e-02f,
  -6.28176751e-03f, 2.74261534e-02f, 1.52142316e-01f, 9.11732465e-02f, 3.44466150e-01f, 4.80825230e-02f, 1.65637076e-01f, 9.87145752e-02f, -5.15827388e-02f, 1.77003399e-01f,
  5.01469597e-02f, 8.12322572e-02f, 1.54348999e-01f, -7.08585829e-02f, 8.07576701e-02f, -9.94188488e-02f, 1.16213754e-01f, 2.71824654e-02f, 7.23758265e-02f, 3.44039463e-02f,
  -4.15115990e-02f, -1.76407337e-01f, -3.85713801e-02f, -5.20430319e-02f, 1.64279304e-02f, 3.59409302e-03f, 5.58197610e-02f, 1.16149113e-01f, -2.52916478e-02f, -2.97527667e-02f,
  2.33996417e-02f, -5.40798344e-02f, -5.40524609e-02f, 7.20171398e-03f, -8.31928626e-02f, -9.91156548e-02f, 1.50989722e-02f, -1.37209222e-02f, -4.87731956e-03f, 1.79375503e-02f,
  -5.28733898e-03f, -5.02402112e-02f, -3.56773771e-02f, 2.57093441e-02f, 2.41759550e-02f, 2.42489912e-02f, 1.04954153e-01f, 1.73617508e-02f, 2.64036050e-03f, -4.27222066e-02f,
  6.63767010e-02f, 7.79867098e-02f, 3.23959393e-03f, -7.37192435e-03f, 2.07069069e-02f, -6.31376728e-02f, 4.73693572e-02f, -4.07301374e-02f, -9.34445206e-03f, -1.09178945e-02f,
  -1.72597058e-02f, -8.90020579e-02f, -6.98579401e-02f, -9.78177413e-04f, 6.14557713e-02f, -5.78576289e-02f, 5.46289422e-02f, -3.98918465e-02f, 1.92866232e-02f, -4.26447801e-02f,
  -4.67353202e-02f, 6.45478442e-02f, 9.74686537e-03f, -1.34413429e-02f, -2.89738849e-02f, -8.06918927e-03f, -6.00510687e-02f, -5.72425164e-02f, -5.07081896e-02f, 7.29021803e-02f,
  1.62561893e-01f, 2.91867524e-01f, -2.22658161e-02f, -7.88700301e-03f, -1.10885445e-02f, -3.23676206e-02f, -2.64260229e-02f, -3.33447009e-02f, 1.14543468e-01f, 3.51849571e-02f,
  3.81116867e-02f, 2.69029420e-02f, 5.05936444e-02f, -2.87451223e-02f, -5.79584809e-03f, 9.47672874e-02f, 6.50348291e-02f, 2.00863816e-02f, 1.78092085e-02f, -1.13358535e-03f,
  5.51950969e-02f, 2.27577183e-02f, -5.07229660e-03f, 3.16717252e-02f, -1.08873891e-02f, -5.04116863e-02f, 4.29873839e-02f, 4.27906625e-02f, 5.35418168e-02f, 3.17977183e-02f,
  1.42677659e-02f, -7.32985064e-02f, 1.98862299e-01f, 2.48025328e-01f, -1.54535040e-01f, -1.86878040e-01f, -2.36867696e-01f, -5.15843891e-02f, -8.98363739e-02f, -1.69350430e-01f,
  -1.99068651e-01f, 2.77843893e-01f, -2.80869365e-01f, 7.95773789e-02f, 1.81119964e-01f, -4.74100746e-02f, 7.90362358e-02f, 1.17947431e-02f, -1.38108050e-02f, 3.02680079e-02f,
  1.21525645e-01f, -7.41976425e-02f, 2.38199413e-01f, -9.73898917e-02f, -1.11986520e-02f, 1.45184621e-01f, 1.05732597e-01f, -5.89758232e-02f, 1.87235802e-01f, 8.80829468e-02f,
  -2.37817666e-03f, 3.24049108e-02f, 1.07226841e-01f, 4.26251218e-02f, 7.32440948e-02f, -5.40639460e-02f, -4.65482939e-03f, -5.15807979e-02f, 5.46104647e-02f, 3.03596538e-02f,
  2.13120114e-02f, 4.75618243e-02f, -3.50630172e-02f, -6.97635189e-02f, 3.80074693e-04f, 3.34854089e-02f, 5.80079257e-02f, 5.15633672e-02f, -2.27814373e-02f, 4.79196571e-03f,
  -2.58998070e-02f, 4.01317254e-02f, 2.56051719e-02f, 4.48620468e-02f, 5.61501496e-02f, 3.41616161e-02f, -1.78039726e-02f, 9.92961824e-02f, 1.08597182e-01f, 4.95331436e-02f,
  -4.66746576e-02f, -7.06239790e-02f, -5.96689247e-02f, -2.28407495e-02f, -6.13030978e-02f, 2.51273420e-02f, 1.12156728e-02f, 1.26973330e-03f, 2.29173210e-02f, -3.32925133e-02f,
  1.66190844e-02f, -3.90019715e-02f, -2.93560326e-02f, 3.29854228e-02f, -2.28143297e-02f, -2.70525366e-02f, 2.74524800e-02f, -1.96797550e-02f, 1.20968763e-02f, 2.24653110e-02f,
  -3.98493782e-02f, -2.87178904e-02f, -2.07285043e-02f, -3.63599770e-02f, -2.74271285e-03f, 2.17364468e-02f, -4.36591133e-02f, -2.35697702e-02f, 1.94810107e-02f, -5.79138473e-02f,
  4.24962342e-02f, -1.07864849e-02f, -8.78653452e-02f, 1.58188008e-02f, 1.45525194e-03f, -3.60382237e-02f, 2.01226566e-02f, 2.66525522e-02f, -5.34977466e-02f, -9.75156948e-02f,
  9.57152527e-03f, -1.84596274e-02f, 9.59773883e-02f, 4.46787216e-02f, 1.83633920e-02f, -1.43846255e-02f, 1.01191793e-02f, 5.08437231e-02f, 4.73783650e-02f, 1.97686162e-02f,
  6.69372678e-02f, -1.26735652e-02f, 3.29919122e-02f, -3.71332951e-02f, 1.59269590e-02f, -3.60982977e-02f, 4.03537601e-02f, 2.88007944e-03f, -3.69563140e-03f, 5.64264096e-02f,
  -5.88657111e-02f, 3.91201586e-01f, 2.94573486e-01f, -6.49672300e-02f, -1.74897000e-01f, 1.58156529e-01f, 5.29940203e-02f, 5.58428876e-02f, 5.49007282e-02f, 1.57266170e-01f,
  1.59095321e-02f, 2.06400510e-02f, 3.19353491e-01f, -1.06320880e-01f, -3.22268575e-01f, 1.84788540e-01f, -8.15471541e-03f, 3.72084379e-02f, 1.25071025e-02f, 4.47181240e-02f,
  -2.66367625e-02f, -2.29913920e-01f, 4.77400376e-03f, -1.55460350e-02f, -1.11810640e-01f, -3.95182259e-02f, -3.51424932e-01f, 1.23920694e-01f, -1.38537437e-01f, -1.36256367e-01f,
  -1.35306001e-01f, 3.52436397e-03f, 9.36251730e-02f, -1.11298473e-03f, -1.23653775e-02f, -3.72208618e-02f, 1.15360832e-02f, 2.48193461e-02f, 1.81983635e-02f, 1.22417780e-02f,
  8.50380883e-02f, -2.60085929e-02f, -5.04996181e-02f, 1.89117342e-02f, 1.70590710e-02f, 1.60065088e-02f, 1.85550787e-02f, 7.12861493e-02f, 1.70113780e-02f, -1.72781777e-02f,
  1.48923442e-01f, 5.05403653e-02f, 5.64921051e-02f, -4.62017842e-02f, -3.43766920e-02f, 5.87804690e-02f, -4.96869162e-02f, -2.60740109e-02f, -2.03531049e-02f, -4.96844947e-02f,
  7.89424852e-02f, -3.78178852e-03f, 4.01838087e-02f, -1.25152525e-02f, -8.45865055e-04f, -3.99816670e-02f, 1.61717925e-02f, -1.47165386e-02f, 5.85922152e-02f, -1.26509098e-02f,
  -3.50555927e-02f, -3.25949080e-02f, 1.20041408e-02f, 3.46430182e-03f, 1.32411150e-02f, -5.35092689e-02f, 5.59880547e-02f, -3.85674424e-02f, 4.03738655e-02f, 1.13718808e-02f,
  5.15721440e-02f, -2.11332887e-02f, 2.22677793e-02f, -4.51903902e-02f, 7.18864724e-02f, 4.49220464e-02f, 7.57635012e-03f, 7.89004862e-02f, -2.26778779e-02f, -2.81701088e-02f,
  -1.08537972e-01f, -1.49313301e-01f, -1.27615053e-02f, -2.23762393e-02f, -1.77075528e-02f, 4.34232764e-02f, -4.71533015e-02f, 1.39393588e-03f, 2.64075026e-03f, 2.13427525e-02f,
  -4.81492840e-02f, -2.42267624e-02f, -3.38794030e-02f, -2.58328840e-02f, -1.32046202e-02f, -3.05029843e-03f, -5.76869920e-02f, -3.16910893e-02f, -4.88507599e-02f, -2.17199959e-02f,
  -1.13849365e-03f, -7.09688989e-03f, -1.95415504e-02f, -1.23812826e-02f, 1.27320550e-03f, -1.52767147e-03f, -3.88771109e-02f, 7.19817653e-02f, 1.51662538e-02f, 6.42362684e-02f,
  8.30617547e-02f, -1.37024596e-02f, 6.86352551e-02f, 1.32999703e-01f, -1.48142248e-01f, 7.51926452e-02f, 1.92055956e-01f, -9.02502686e-02f, 3.67394120e-01f, 5.81579953e-02f,
  -1.69966400e-01f, 1.56964824e-01f, -1.08967684e-01f, -9.36089233e-02f, -1.39966533e-01f, -3.20197679e-02f, -3.19289882e-03f, -2.77172148e-05f, 3.23522510e-03f, -1.26569688e-01f,
  -3.51113081e-02f, -2.19823599e-01f, -1.48250774e-01f, -1.75218359e-01f, -8.49041939e-02f, -1.34855341e-02f, -2.83780903e-01f, -4.66481363e-03f, -1.95226058e-01f, -3.20495777e-02f,
  -4.99664098e-02f, -4.10117321e-02f, 3.28685082e-02f, 6.65888190e-02f, -9.79989693e-02f, 8.96764547e-03f, -2.80490294e-02f, -8.96239132e-02f, 4.95986566e-02f, -2.46258434e-02f,
  -1.11889737e-02f, -4.98354658e-02f, 6.67392612e-02f, 3.65215391e-02f, 1.09225348e-01f, 6.84001222e-02f, -2.48198211e-02f, -6.26533292e-03f, 4.17702310e-02f, -5.78598008e-02f,
  -3.03716827e-02f, 2.59818267e-02f, 1.17437486e-02f, 1.23684732e-02f, 1.50545416e-02f, 4.60543809e-03f, 9.56918895e-02f, 5.27556688e-02f, 2.73324717e-02f, 5.89596555e-02f,
  -4.20603640e-02f, 1.02692442e-02f, 9.49272793e-03f, -4.04317603e-02f, -4.87407623e-03f, -5.85936941e-02f, 2.77072936e-02f, -3.38729024e-02f, 7.53208846e-02f, 1.02468330e-04f,
  -5.10167470e-03f, 1.35001279e-02f, 6.35647774e-02f, -2.92090196e-02f, 1.22115482e-02f, -1.26991402e-02f, 3.75863500e-02f, 1.01415487e-02f, 3.29539296e-03f, 3.35993320e-02f,
  1.60950385e-02f, -6.28134385e-02f, 3.94036584e-02f, -7.43182972e-02f, -1.72908772e-02f, -3.10217123e-02f, 1.73945501e-02f, 5.29273935e-02f, -4.01548184e-02f, -6.59082755e-02f,
  -1.22165218e-01f, -7.39610717e-02f, 9.67434272e-02f, -3.07235774e-03f, 6.02848195e-02f, -1.05741970e-01f, 6.77005053e-02f, 3.22295241e-02f, 1.03673181e-02f, -3.57084386e-02f,
  -1.91713590e-02f, 1.00547083e-01f, -5.84245734e-02f, 8.13997723e-03f, 2.02772282e-02f, -7.34925866e-02f, -6.24490380e-02f, 6.85273185e-02f, -5.52573204e-02f, -2.78256554e-02f,
  -4.07723039e-02f, -4.45824154e-02f, 8.96938890e-02f, 1.21591426e-02f, 5.89668658e-03f, 7.55413389e-03f, -1.13565419e-02f, 3.48014645e-02f, -9.78909954e-02f, 5.58414720e-02f,
  1.29518524e-01f, -4.30867188e-02f, 6.21070340e-02f, 7.22123543e-03f, 2.73524433e-01f, 2.24210694e-01f, 5.19672502e-03f, 1.47092745e-01f, 2.58951318e-02f, 6.15709573e-02f,
  -6.04580482e-03f, -6.41993061e-02f, -9.79841873e-02f, -4.44582961e-02f, -1.19795628e-01f, -1.47829905e-01f, 7.86710829e-02f, -3.19801830e-02f, 4.99226227e-02f, 9.32146832e-02f,
  4.66821678e-02f, -2.73646954e-02f, -1.04041465e-01f, 1.05295032e-01f, 2.09260464e-01f, 9.82167795e-02f, -1.02776520e-01f, -1.25276744e-02f, -7.66587555e-02f, -1.68639511e-01f,
  5.36476225e-02f, 1.62338004e-01f, 1.05608553e-01f, 1.65748466e-02f, 8.61295909e-02f, 6.07802197e-02f, 8.27305019e-02f, -1.05802216e-01f, 1.92762669e-02f, 6.82104528e-02f,
  1.11329304e-02f, 2.34533437e-02f, -3.44953872e-02f, -7.33499229e-03f, 1.28733739e-01f, -3.64629850e-02f, 3.30285951e-02f, 3.01180016e-02f, 6.67460933e-02f, 5.33768535e-02f,
  -1.41615421e-02f, -3.84484865e-02f, -3.01960856e-02f, -6.83511123e-02f, 2.51352252e-03f, -1.64510868e-02f, 3.27644534e-02f, -1.56976357e-02f, 8.98900554e-02f, 8.51893649e-02f,
  -3.69460434e-02f, -7.94788748e-02f, 5.13958819e-02f, -4.61819209e-02f, -3.43776792e-02f, 1.67661645e-02f, -7.57188573e-02f, -1.80693325e-02f, -1.09774852e-02f, 9.71146300e-02f,
  -1.22403922e-02f, 1.43650854e-02f, 3.69956531e-02f, -3.42391916e-02f, -6.57264367e-02f, 1.64737031e-02f, -3.36996056e-02f, 5.12284972e-02f, 5.78100746e-03f, -2.72909272e-03f,
  -1.91491507e-02f, -2.05046497e-02f, 3.54738906e-02f, 6.10432401e-03f, 1.38777087e-03f, 2.93314178e-03f, 6.04433455e-02f, 9.40430835e-02f, 4.91422899e-02f, -5.43382987e-02f,
  1.78403437e-01f, 3.11668552e-02f, 3.46309878e-02f, 7.31691271e-02f, 1.16118509e-02f, 7.21073151e-02f, -2.97672059e-02f, 8.60290527e-02f, -3.94028462e-02f, -2.01963391e-02f,
  7.68772736e-02f, 1.66670419e-02f, -2.24298816e-02f, -5.58448844e-02f, -2.15747077e-02f, -1.17466915e-02f, 5.22676222e-02f, 3.81516889e-02f, 1.00184895e-01f, -5.02241254e-02f,
  -2.57574883e-03f, 4.00645249e-02f, 3.43229733e-02f, 8.29323009e-02f, 1.40208509e-02f, -5.22494949e-02f, -1.64698008e-02f, -9.56396237e-02f, 2.73323208e-02f, 1.54487258e-02f,
  -3.77533823e-01f, 3.12592834e-01f, -2.79260296e-02f, -1.10959798e-01f, -4.20927890e-02f, -2.94110328e-01f, -1.91379830e-01f, -1.27536342e-01f, 2.86713224e-02f, 2.45586500e-01f,
  -7.90445507e-02f, 1.19532451e-01f, 8.36858600e-02f, -1.05105609e-01f, -5.44678330e-01f, -4.82139625e-02f, -2.62965173e-01f, -5.17179593e-02f, -6.20964393e-02f, 1.15380678e-02f,
  -9.63333622e-02f, -8.02695751e-03f, -1.05926178e-01f, 8.98018032e-02f, 3.50255822e-03f, 8.23635757e-02f, 4.31332290e-02f, 1.17778830e-01f, -3.28683731e-04f, -4.50269580e-02f,
  -1.27507865e-01f, 1.71601713e-01f, 1.53408619e-02f, 5.92606030e-02f, -9.42257643e-02f, 3.06225847e-02f, -5.40755205e-02f, 1.37490164e-02f, 3.08548138e-02f, -3.68182138e-02f,
  -1.84754748e-02f, -6.82185367e-02f, 2.05585100e-02f, 3.57527807e-02f, 1.42416460e-02f, 1.63850430e-02f, -2.63125380e-03f, 6.97741238e-03f, -2.01484654e-02f, -5.25604524e-02f,
  -1.04141571e-02f, -6.73990920e-02f, -6.53012544e-02f, 1.81609392e-02f, -2.00577118e-02f, 3.44538726e-02f, -3.27448500e-03f, 9.94537957e-03f, -1.16723767e-02f, -2.57451721e-02f,
  -2.22669151e-02f, -1.13557577e-02f, 1.49190342e-02f, -1.28650488e-02f, -3.85504663e-02f, -1.70090492e-03f, -1.95745435e-02f, 1.02372514e-02f, -4.12962865e-03f, -4.55838814e-02f,
  -5.01191691e-02f, -1.86615866e-02f, -4.93694320e-02f, -3.17747630e-02f, -4.38784435e-02f, 3.11201147e-04f, -1.42867939e-04f, 1.01697696e-02f, 1.89565718e-02f, -6.31318539e-02f,
  1.91779751e-02f, -1.14370827e-02f, 4.69341390e-02f, 5.19073084e-02f, 3.52333821e-02f, 1.36515992e-02f, 1.60423145e-02f, -1.34794572e-02f, 7.83955120e-03f, -6.47558868e-02f,
  2.80395746e-02f, 7.19652846e-02f, 4.51281741e-02f, 5.83049096e-02f, 5.84463701e-02f, -5.74447885e-02f, 3.40656303e-02f, -2.25465205e-02f, -4.24474031e-02f, 1.61416419e-02f,
  -1.14198280e-02f, 2.35306509e-02f, 1.69003848e-02f, -1.51738385e-02f, -2.39952896e-02f, -2.12421566e-02f, 3.04418392e-02f, -3.57614234e-02f, -1.27603244e-02f, 1.60072111e-02f,
  2.46635173e-02f, 7.82424025e-03f, -3.00425421e-02f, 2.66064741e-02f, -4.98776929e-03f, -1.48506183e-02f, -3.20052803e-02f, 6.20260648e-03f, 4.74569621e-03f, 5.27219027e-02f,
  -3.23667347e-01f, -2.08171681e-01f, 1.23630784e-01f, -1.55788615e-01f, 3.31130549e-02f, 1.34605348e-01f, 2.25046381e-01f, -1.62873343e-01f, -2.33113989e-01f, -2.53706947e-02f,
  1.08656116e-01f, -1.21943451e-01f, 2.68200725e-01f, 1.27596498e-01f, 1.79532871e-01f, 1.48062155e-01f, -2.47254446e-02f, -2.23946925e-02f, -5.59238791e-02f, -1.80875242e-01f,
  -1.29714429e-01f, -5.81660075e-03f, 1.93526521e-01f, 9.57224891e-03f, -4.20041606e-02f, -2.04893321e-01f, -8.42978433e-02f, 1.99906722e-01f, 2.92196963e-02f, 1.08627193e-01f,
  -5.50006330e-02f, -1.93391860e-01f, 4.98642661e-02f, -1.36578493e-02f, -6.69626668e-02f, -4.38354574e-02f, -1.12203695e-03f, 1.41025767e-01f, 7.47263953e-02f, -6.63494039e-03f,
  1.44249788e-02f, 5.88486716e-03f, -4.04501446e-02f, 3.08145843e-02f, -2.93565225e-02f, -2.79144477e-02f, 4.91295010e-02f, -2.09628921e-02f, 1.21100862e-02f, 2.15511750e-02f,
  3.41909602e-02f, -1.31222736e-02f, -2.14287601e-02f, 1.89212279e-03f, -5.89813478e-02f, -1.98898334e-02f, -3.91985942e-03f, 4.63273786e-02f, -5.60725704e-02f, -7.92982131e-02f,
  -4.54282649e-02f, 2.08822750e-02f, 6.28968049e-03f, 6.73495160e-05f, 4.95982170e-03f, 6.17258027e-02f, 6.34154631e-03f, 6.45411387e-02f, 1.02911890e-03f, -2.87828110e-02f,
  5.81225147e-03f, -3.22769955e-02f, 1.91375036e-02f, -1.27883572e-02f, -4.20652591e-02f, 1.15194889e-02f, 6.41776323e-02f, -7.11805373e-02f, 3.55428569e-02f, 9.89673380e-03f,
  -8.12320039e-03f, 7.83122052e-03f, 2.34940201e-02f, -7.07838237e-02f, 1.99590065e-02f, 3.78767774e-02f, -1.46276224e-03f, -1.27472579e-02f, 3.50838006e-02f, -4.60216403e-03f,
  -2.78889328e-01f, -2.45197594e-01f, -4.81267693e-03f, -3.68111813e-03f, 6.70206770e-02f, 1.58959329e-02f, -1.40620572e-02f, -1.46386223e-02f, -6.39807060e-02f, 2.92287916e-02f,
  -5.66640943e-02f, -2.19535846e-02f, -2.59154923e-02f, -2.24933904e-02f, -1.96715444e-02f, 1.23955088e-03f, -1.21701472e-02f, -1.04256850e-02f, -8.95132404e-03f, -5.24511412e-02f,
  -5.94838597e-02f, -1.67255029e-02f, 2.68705618e-02f, -2.95006074e-02f, 1.43139344e-02f, 2.08973736e-02f, -4.53559607e-02f, -2.03197189e-02f, 1.44831676e-04f, 4.95975092e-02f,
  -3.78824234e-01f, 1.80663377e-01f, -1.71144709e-01f, 1.27870977e-01f, -9.70138907e-02f, 4.46117260e-02f, 9.58130732e-02f, 1.65658608e-01f, 8.97764117e-02f, 2.41741046e-01f,
  1.89194798e-01f, -1.52362525e-01f, 9.04521272e-02f, 3.36518556e-01f, 6.75299689e-02f, 2.73317397e-01f, 2.94580579e-01f, 1.09488979e-01f, -6.27858341e-02f, 5.19334711e-02f,
  2.85862107e-02f, 2.44398668e-01f, 1.56205639e-01f, 1.74923018e-01f, -1.00238714e-02f, -6.81140423e-02f, 5.20429052e-02f, -1.21831171e-01f, 1.20783262e-01f, 2.99917106e-02f,
  5.59883453e-02f, 7.75278807e-02f, -8.02432224e-02f, -1.14692800e-01f, 5.57135269e-02f, -2.98966840e-02f, -8.73844475e-02f, -8.88821855e-02f, -5.21959737e-02f, 2.09318977e-02f,
  -9.82721597e-02f, -8.79126973e-03f, 2.64754258e-02f, -1.64433699e-02f, -2.32824101e-03f, -4.35947552e-02f, -5.63709904e-03f, 8.84528924e-03f, 7.00388029e-02f, -6.99901506e-02f,
  1.65655762e-02f, 2.05197651e-02f, -4.47371602e-02f, 2.76757795e-02f, 1.52240330e-02f, -5.32929273e-03f, -4.01114672e-02f, -1.43157532e-02f, -1.43171567e-02f, -9.57106240e-03f,
  -2.92068217e-02f, 4.68615768e-03f, -2.17179395e-02f, -3.38166300e-03f, -2.82879490e-02f, 2.57558711e-02f, 3.01086735e-02f, 3.76357464e-03f, -4.75601070e-02f, 5.62084541e-02f,
  -7.13234209e-03f, 2.62557119e-02f, -3.57783101e-02f, 1.45255486e-02f, 3.59968245e-02f, 6.42082468e-03f, -8.74904618e-02f, 3.30907851e-02f, 2.74064466e-02f, -2.89439713e-03f,
  2.76618805e-02f, -2.74168216e-02f, 4.27275524e-02f, -3.29709128e-02f, 1.10533312e-02f, 2.94601899e-02f, 5.14004044e-02f, -4.68569770e-02f, 2.48697326e-02f, 2.07001604e-02f,
  1.39940992e-01f, 2.01668933e-01f, 2.65396964e-02f, 2.28956919e-02f, -2.25552805e-02f, -3.94045860e-02f, 7.02485964e-02f, 3.81067209e-02f, 7.88842048e-03f, 1.38368113e-02f,
  2.49970146e-03f, -3.89988790e-03f, -5.96406981e-02f, 6.24063378e-03f, 1.46345273e-02f, 9.34616849e-02f, 4.64090221e-02f, -1.55224302e-03f, 4.71252576e-03f, 6.46663904e-02f,
  1.26617067e-02f, -9.71611182e-04f, -2.10620016e-02f, -3.16729285e-02f, -5.16853854e-03f, -1.33052943e-02f, 3.30975354e-02f, -4.54586372e-02f, 1.41945749e-03f, 7.38371015e-02f,
  4.56838995e-01f, -2.14760944e-01f, 2.76620895e-01f, 1.34888500e-01f, 8.23613405e-02f, 2.99935490e-01f, 2.34486103e-01f, 9.15039680e-04f, 3.81306186e-02f, -3.41755062e-01f,
  -1.00596681e-01f, 3.82521786e-02f, -2.44558305e-01f, 5.61733134e-02f, 2.21428946e-01f, -1.55243427e-01f, 9.87209082e-02f, 4.03264770e-03f, -2.06499696e-02f, 2.84636356e-02f,
  5.74349128e-02f, -6.98697045e-02f, 1.42592549e-01f, -1.25016555e-01f, 1.90200448e-01f, 8.84617120e-02f, -1.81724697e-01f, 4.91948724e-02f, 3.10235433e-02f, 8.09242800e-02f,
  1.07339270e-01f, -4.76195253e-02f, 5.27540930e-02f, 5.25554270e-02f, 8.74587744e-02f, 4.67495695e-02f, 2.49330644e-02f, 7.56605938e-02f, 8.45890269e-02f, -1.50997220e-02f,
  -2.67555434e-02f, 2.71875188e-02f, -5.64379469e-02f, -1.23702902e-02f, 3.63320820e-02f, -7.56492699e-03f, 2.34724302e-02f, 4.23394442e-02f, -1.03876851e-02f, 8.63485187e-02f,
  2.84006577e-02f, 3.01572978e-02f, 4.57311198e-02f, -2.78019216e-02f, 6.94679916e-02f, 2.09994800e-02f, 1.26221003e-02f, 2.17071418e-02f, -5.21466583e-02f, -4.80080908e-03f,
  -4.74498570e-02f, -5.20626195e-02f, -2.51137512e-03f, 3.77949215e-02f, 3.26845655e-03f, 2.55422741e-02f, -3.82399336e-02f, -4.04952355e-02f, 6.32191747e-02f, -3.66184004e-02f,
  5.73924333e-02f, 5.00823278e-03f, -1.70849301e-02f, -4.52176388e-03f, -6.39319513e-03f, 2.59547774e-03f, 5.59151499e-03f, -3.24153006e-02f, 3.99818085e-02f, 5.85513562e-02f,
  -7.90827908e-03f, -2.57753804e-02f, -1.72083471e-02f, -1.26127573e-02f, 6.93379622e-03f, -2.99629867e-02f, -8.57061446e-02f, 2.11191885e-02f, -3.62737440e-02f, 6.44881055e-02f,
  -8.61757845e-02f, -3.80965173e-01f, -3.29345688e-02f, -4.34907898e-02f, -7.43397772e-02f, -7.13049853e-03f, 2.49755234e-02f, -8.10506009e-03f, -4.39674631e-02f, 2.07116790e-02f,
  1.35949636e-02f, 2.05892846e-02f, 4.31237146e-02f, 2.69922614e-02f, -2.09967210e-03f, -1.77828725e-02f, -6.02558106e-02f, -4.41802330e-02f, 1.68602709e-02f, -7.79870301e-02f,
  -3.07926144e-02f, -3.15630771e-02f, 4.19372693e-03f, 1.82896741e-02f, -6.63226694e-02f, 1.11959735e-02f, 3.48321646e-02f, -1.00640114e-02f, -2.39972752e-02f, -3.41077670e-02f,
  -4.69660372e-01f, -2.89469734e-02f, -1.83201507e-01f, -3.73103678e-01f, 1.05949976e-01f, -2.10509926e-01f, -1.01013698e-01f, 1.39747523e-02f, -3.37868661e-01f, 1.15409978e-01f,
  1.48818612e-01f, -2.44185641e-01f, 1.54217511e-01f, -1.27926186e-01f, -1.87116280e-01f, 1.01896591e-01f, -3.27645361e-01f, -1.10298097e-01f, -6.24844283e-02f, -1.74606934e-01f,
  -1.20780803e-01f, 5.88686857e-03f, -3.10829803e-02f, 1.62946865e-01f, -1.69994943e-02f, -6.97684288e-02f, 1.79968178e-01f, 1.53335139e-01f, 5.99546032e-03f, 1.25588655e-01f,
  -1.49104362e-02f, -7.92405829e-02f, -4.23025824e-02f, -2.77486742e-02f, -5.03930748e-02f, 2.36478355e-02f, -9.98257101e-03f, 4.43604887e-02f, -4.72936705e-02f, -5.20233251e-02f,
  -1.26769440e-03f, -8.73719715e-03f, -6.75843582e-02f, 4.41046730e-02f, -1.95300411e-02f, 3.75085734e-02f, 3.08730509e-02f, -2.63098944e-02f, -7.12775206e-03f, 3.39298323e-02f,
  -7.92661607e-02f, -4.56883051e-02f, -5.04598618e-02f, 3.47504467e-02f, 9.73478891e-03f, -6.19178489e-02f, -4.16678227e-02f, 7.71288434e-03f, -3.44777703e-02f, -5.09428717e-02f,
  -2.10881475e-02f, -7.94863328e-02f, 7.31285736e-02f, -6.15821593e-03f, -3.01261246e-02f, 4.24045101e-02f, -1.33267241e-02f, 4.30096053e-02f, -1.72289237e-02f, 1.55358603e-02f,
  -4.27097939e-02f, -1.84543766e-02f, 4.57104929e-02f, -4.74124178e-02f, -1.27092088e-02f, -4.82439846e-02f, 9.83812287e-03f, 3.67656015e-02f, -8.49694163e-02f, 5.23962975e-02f,
  -1.61645822e-02f, -1.06450403e-02f, 5.83058260e-02f, 2.86175609e-02f, 6.04387373e-03f, 3.02734841e-02f, -2.43678596e-03f, 6.85994420e-03f, -1.08451331e-02f, -1.63485184e-02f,
  8.12087394e-03f, -1.10513613e-01f, 2.23590881e-02f, 1.98230352e-02f, 1.34178698e-02f, 6.95421845e-02f, 1.01679331e-02f, -3.39661725e-02f, -1.18465647e-02f, -3.19966599e-02f,
  -2.58827675e-02f, -4.18769307e-02f, -3.43124121e-02f, -7.62122637e-03f, -3.80226485e-02f, 7.46772904e-03f, -5.68360947e-02f, -1.03982724e-02f, -2.69222222e-02f, -1.90107897e-02f,
  6.24672212e-02f, -4.10134485e-03f, -6.50034007e-03f, -2.05902345e-02f, -6.16737530e-02f, 3.69386338e-02f, -2.20233928e-02f, 2.12201895e-03f, 5.42499218e-03f, -3.17218415e-02f,
  4.41686958e-02f, 2.58900579e-02f, 1.78493440e-01f, 2.18460560e-01f, -1.44089147e-01f, 2.44422071e-02f, 1.79170147e-01f, -6.02152050e-02f, -2.11413339e-01f, 8.67458284e-02f,
  -3.17865126e-02f, 2.32382521e-01f, -9.08911899e-02f, 1.44742996e-01f, 1.29089147e-01f, -5.13618067e-02f, 1.43000305e-01f, 1.03457704e-01f, -1.84897974e-01f, 2.31261048e-02f,
  3.88685992e-04f, 4.15988863e-02f, 1.03271216e-01f, -8.63359272e-02f, 6.80596977e-02f, 8.32343772e-02f, 9.93851796e-02f, -4.14778572e-03f, 2.56513000e-01f, 7.70281926e-02f,
  5.35745583e-02f, -8.93134996e-02f, 8.34938958e-02f, -2.15164050e-02f, 7.18521420e-03f, 6.43894598e-02f, 1.26183078e-01f, 1.77843950e-03f, -6.55081272e-02f, 4.08038199e-02f,
  8.81296992e-02f, -2.74829529e-02f, 2.66249515e-02f, -1.01734854e-01f, -2.95990165e-02f, -3.84777077e-02f, 2.87312157e-02f, 3.86507176e-02f, 6.85159937e-02f, 1.31492969e-02f,
  3.96337956e-02f, 9.44110975e-02f, 3.32291983e-02f, 4.59135883e-03f, 8.72685853e-03f, -7.30032772e-02f, 7.38749132e-02f, 7.48104602e-02f, 7.62150437e-02f, -3.75061184e-02f,
  -6.26248047e-02f, 4.54184450e-02f, 3.62856202e-02f, -5.45324460e-02f, -2.17132606e-02f, 2.98429504e-02f, -5.85347135e-03f, -2.58004889e-02f, 4.87358384e-02f, -1.33114997e-02f,
  -2.69226846e-04f, 2.78251860e-02f, -4.30297367e-02f, -3.67600471e-02f, 8.34051296e-02f, 6.11896664e-02f, 6.14383183e-02f, 7.22225308e-02f, -6.32453151e-03f, 2.24556755e-02f,
  -3.25939730e-02f, 1.93800833e-02f, 6.40380234e-02f, -3.73228043e-02f, -7.66228288e-02f, 3.00917421e-02f, 5.34051098e-02f, 5.63420691e-02f, -1.46324756e-02f, -9.30046011e-03f,
  3.75368968e-02f, -5.74838221e-02f, -7.32459426e-02f, 1.22442527e-03f, 5.43762222e-02f, 5.58426566e-02f, 1.79248173e-02f, -4.22048941e-02f, 4.26934659e-02f, -8.69237706e-02f,
  1.71633866e-02f, 3.52112390e-02f, 4.28348929e-02f, 4.35494334e-02f, 3.11077982e-02f, 4.09344099e-02f, -2.62312982e-02f, -2.91486960e-02f, 1.98099725e-02f, 7.12952539e-02f,
  4.77614440e-02f, 7.92238768e-03f, 3.39693166e-02f, 6.14365824e-02f, -5.98542728e-02f, 8.71857163e-03f, 3.73298749e-02f, -8.83197878e-03f, 2.55686622e-02f, 1.93174146e-02f,
  -1.40213007e-02f, 9.78614017e-03f, 2.95732319e-01f, 1.12782381e-01f, 1.10312536e-01f, -1.82129100e-01f, -3.24135274e-01f, 1.90327883e-01f, 3.99256498e-02f, -1.99203670e-01f,
  -2.16117099e-01f, 7.27597699e-02f, -1.33283451e-01f, -1.90135658e-01f, -7.89196715e-02f, -1.67545542e-01f, -1.52914584e-01f, -1.37717530e-01f, 7.86128193e-02f, 9.75675359e-02f,
  9.46796089e-02f, -1.32515460e-01f, 3.27822044e-02f, 2.04056308e-01f, 3.06716524e-02f, 1.87653482e-01f, -5.65342195e-02f, 9.77508277e-02f, 7.16249198e-02f, 3.14011462e-02f,
  -7.00385422e-02f, -2.12385971e-02f, 3.91698070e-02f, 2.44022850e-02f, -2.07713824e-02f, -2.19014157e-02f, 4.13976237e-03f, -2.03189068e-02f, -6.78476645e-03f, -9.24611930e-03f,
  3.03858630e-02f, 7.88306147e-02f, 7.69560486e-02f, -6.43824339e-02f, -3.34320182e-04f, 9.51663256e-02f, 1.08606510e-01f, -3.45183397e-03f, 9.17522088e-02f, 5.26320413e-02f,
  7.44310692e-02f, 5.01880310e-02f, 4.62665372e-02f, -3.15392949e-02f, 1.17355041e-01f, 6.30627275e-02f, -3.60347591e-02f, 3.63753214e-02f, 2.38159895e-02f, 7.83413872e-02f,
  -7.24525452e-02f, 1.71211939e-02f, -2.70757154e-02f, 8.21172073e-03f, 1.98666882e-02f, 8.96254834e-03f, 8.52671824e-03f, -2.52419226e-02f, 3.73826139e-02f, -1.60883199e-02f,
  -1.59606095e-02f, -3.39564122e-02f, 6.91623688e-02f, -1.83260608e-02f, -1.04346089e-02f, -6.72985762e-02f, 4.75842021e-02f, 5.41421324e-02f, 2.08174363e-02f, -1.63269192e-02f,
  -3.37472260e-02f, -3.34412828e-02f, -6.24068305e-02f, 3.14140134e-02f, -3.17666084e-02f, 1.92119163e-02f, 5.08355573e-02f, 8.84859562e-02f, 4.12089489e-02f, -3.52446176e-03f,
  -2.15582892e-01f, -6.06933609e-02f, 3.84948291e-02f, 3.47319804e-02f, -2.44418029e-02f, -7.99076706e-02f, 1.13113327e-02f, 5.15663214e-02f, -4.38859351e-02f, 4.37613390e-02f,
  -3.09715257e-03f, 3.65358219e-02f, -3.87338661e-02f, 4.11187410e-02f, -5.99285448e-03f, -5.05211800e-02f, -7.05973879e-02f, -3.45592313e-02f, -4.40899879e-02f, 1.97899342e-03f,
  -5.38216457e-02f, 1.22938007e-02f, 4.90694530e-02f, 2.88308207e-02f, -5.99507280e-02f, -5.36517948e-02f, 6.77259266e-02f, -1.41755154e-03f, 3.09227500e-02f, -3.52995954e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.86117345e-02f, 3.44300270e-01f, 3.03168535e-01f, 5.91064133e-02f, -1.46574333e-01f, -2.01120880e-02f, -2.05663249e-01f, 3.25446576e-02f, -4.97890599e-02f, 5.96584454e-02f,
  -3.13746125e-01f, 2.49888673e-01f, -1.44720867e-01f, 2.91537531e-02f, -6.00881539e-02f, -6.60926998e-02f, 3.16122472e-02f, 1.48769002e-02f, 9.13417898e-03f, -6.30251691e-02f,
  -7.06137419e-02f, -3.54787856e-01f, 8.28268453e-02f, -6.98297769e-02f, -4.61777598e-02f, 8.83318558e-02f, -2.44852379e-01f, -2.10662991e-01f, 1.02476545e-01f, -7.34453127e-02f,
  -3.36136557e-02f, 4.15678695e-03f, 9.94063634e-03f, 1.69317186e-01f, -3.38066393e-03f, -2.44644471e-02f, 6.02261797e-02f, -9.79024693e-02f, -1.52609060e-02f, 3.51244919e-02f,
  7.09849373e-02f, -2.28873789e-02f, 1.79411971e-03f, -1.06878117e-01f, -6.43166378e-02f, 4.41238508e-02f, 1.30331457e-01f, -4.94819367e-03f, 5.13384528e-02f, 1.18512489e-01f,
  1.57018319e-01f, 1.31438226e-01f, -8.58065486e-03f, -2.28621494e-02f, -5.70914708e-03f, 5.74876890e-02f, 2.42636185e-02f, 4.27300781e-02f, 1.06925055e-01f, 1.06951497e-01f,
  -5.76993562e-02f, -5.72312959e-02f, 1.46469632e-02f, -6.26726300e-02f, -5.63501529e-02f, -4.08974104e-02f, -3.62637565e-02f, 2.04212440e-04f, -3.90657857e-02f, -8.35497528e-02f,
  1.55600002e-02f, 4.85759117e-02f, 4.94868308e-02f, -5.39035611e-02f, -2.21224222e-02f, 2.19637789e-02f, -1.43031450e-02f, 2.14157123e-02f, 4.91099134e-02f, 7.81027749e-02f,
  -8.83005336e-02f, 6.08246727e-03f, 9.35764797e-03f, 4.57023270e-02f, -5.83750419e-02f, -2.97679305e-02f, -1.44760194e-03f, 6.40166849e-02f, -2.45720185e-02f, -2.44664550e-02f,
  -1.04259998e-01f, -1.64560348e-01f, -1.99157260e-02f, -3.96534018e-02f, -6.16475148e-03f, 9.35379788e-03f, -2.93598380e-02f, 1.06856726e-01f, 9.85704735e-03f, -3.48617472e-02f,
  6.73814937e-02f, 5.83105683e-02f, -3.61010768e-02f, -5.09102903e-02f, 2.91938633e-02f, -2.64174119e-02f, -3.11374012e-02f, 3.85085531e-02f, 1.99793074e-02f, 7.76842535e-02f,
  1.18844528e-02f, -6.91563357e-03f, -5.09363487e-02f, -2.44865809e-02f, -5.73529229e-02f, -2.05034465e-02f, 5.74600026e-02f, 1.02077730e-01f, -3.85438949e-02f, -5.57064787e-02f,
  5.66061065e-02f, 1.78585321e-01f, 1.59959823e-01f, 1.65447265e-01f, -1.35728970e-01f, -3.02059799e-01f, -1.78991675e-01f, 1.23658866e-01f, 5.68997413e-02f, -5.61341122e-02f,
  1.55827301e-02f, 8.33062753e-02f, 7.15474132e-03f, 3.88563201e-02f, -1.86868161e-02f, -6.95878789e-02f, 1.23671927e-02f, -6.40271455e-02f, 2.24238802e-02f, 1.02782220e-01f,
  1.45562604e-01f, 6.85402006e-02f, 2.12946013e-01f, 1.35037210e-02f, 2.22136583e-02f, 2.20428079e-01f, 2.63913304e-01f, 7.45601803e-02f, 1.55150406e-02f, -3.43510769e-02f,
  -4.48258035e-02f, 1.05576493e-01f, 1.39063783e-02f, 1.52427042e-02f, 5.43324873e-02f, -8.84050280e-02f, -4.55044843e-02f, -9.84515026e-02f, 5.82973845e-03f, 8.78100544e-02f,
  1.06029939e-02f, 5.48738427e-02f, 1.70733184e-02f, -3.35523896e-02f, 2.28504650e-02f, 6.28892183e-02f, -5.01702353e-02f, 3.46561037e-02f, 9.38700661e-02f, 5.07482700e-02f,
  -9.94901359e-03f, 3.46049070e-02f, -1.09877046e-02f, 1.11338338e-02f, -3.24283317e-02f, -7.19455257e-02f, -1.14079062e-02f, 2.01530801e-03f, 5.59530631e-02f, -1.24795614e-02f,
  -4.74943407e-03f, -9.61719751e-02f, 4.77727689e-02f, 3.07664778e-02f, 2.85501778e-02f, -5.10711409e-02f, -7.79188126e-02f, 4.10309201e-03f, -7.29451049e-03f, 4.37925793e-02f,
  1.98540054e-02f, 4.19849679e-02f, 3.88666987e-02f, -7.38301650e-02f, 1.18550593e-02f, -1.94963478e-02f, -3.69697027e-02f, -7.29544610e-02f, 2.79547758e-02f, 4.41658683e-02f,
  -1.61437672e-02f, -8.28796476e-02f, 6.89384788e-02f, -4.00129110e-02f, 2.14002244e-02f, 7.48019814e-02f, 8.17722008e-02f, -4.72400300e-02f, 3.93653661e-03f, 7.06770346e-02f,
  8.93846154e-02f, 2.82112479e-01f, 7.53350183e-02f, -9.29948166e-02f, -4.85818312e-02f, -6.62615448e-02f, -7.49895647e-02f, 6.72896812e-03f, 4.29644510e-02f, 5.52917346e-02f,
  6.21070415e-02f, 1.60526112e-02f, -5.17958775e-02f, -4.41065915e-02f, 2.30899211e-02f, 4.54113223e-02f, 1.12672396e-01f, -2.58082920e-03f, 1.08222663e-01f, 8.39440748e-02f,
  3.22205648e-02f, -3.16608623e-02f, 7.57647753e-02f, 5.19992691e-03f, 4.31805812e-02f, 7.69519508e-02f, 5.87142678e-03f, 4.48736735e-02f, -2.79787555e-02f, 9.86900553e-02f,
  -2.18474433e-01f, 3.33208591e-01f, 1.58573762e-01f, -3.59033160e-02f, -2.84081381e-02f, 6.83775917e-02f, 1.18508436e-01f, 1.36675164e-01f, -2.48898566e-02f, 1.75388843e-01f,
  4.18365635e-02f, -2.59395186e-02f, 4.67007272e-02f, -1.14302542e-02f, -2.46387243e-01f, 8.20176154e-02f, -5.97980022e-02f, 3.76339108e-02f, 7.88778365e-02f, -1.29255012e-01f,
  -1.46443397e-01f, -1.03888601e-01f, 1.01032713e-02f, 3.27339731e-02f, -6.25851974e-02f, 2.48369705e-02f, -3.34910005e-02f, 8.31311718e-02f, -9.91388038e-02f, 7.32004941e-02f,
  -1.28352940e-01f, -2.27445245e-01f, -1.51026502e-01f, -5.44280671e-02f, -2.85464581e-02f, -1.18648946e-01f, -2.98681017e-02f, -4.83468063e-02f, -1.01403994e-02f, -4.67210524e-02f,
  -5.30002750e-02f, -1.81612540e-02f, 1.01684853e-02f, -3.61094177e-02f, 7.65532628e-02f, 1.60172023e-02f, 1.16392203e-01f, 5.78178093e-02f, 5.91039993e-02f, 6.97369576e-02f,
  1.66856814e-02f, 7.36826286e-02f, -3.12088747e-02f, -5.08444160e-02f, -6.21475913e-02f, 3.27210734e-03f, -3.53466757e-02f, -9.18628201e-02f, -1.01228811e-01f, 2.05687098e-02f,
  7.80259743e-02f, -8.67549852e-02f, 2.58164592e-02f, 1.26195792e-02f, -3.01971622e-02f, 3.79635319e-02f, 1.22021232e-02f, -6.40992820e-02f, 2.64949016e-02f, 6.19095191e-02f,
  -8.18235800e-02f, -8.49759951e-02f, 4.03089896e-02f, -6.29902110e-02f, -4.42722207e-03f, 7.40787461e-02f, 3.38496156e-02f, -1.55073553e-02f, 6.51962608e-02f, 2.47854404e-02f,
  2.03425083e-02f, -7.22817183e-02f, 7.74390772e-02f, -3.20261456e-02f, 3.74084301e-02f, 3.56859192e-02f, 8.04035366e-03f, 4.22323449e-03f, 3.71759422e-02f, 6.93606399e-03f,
  -1.08067654e-01f, -2.11005822e-01f, -1.28712192e-01f, -5.76450601e-02f, 8.76071677e-03f, -2.16911249e-02f, -1.10085011e-01f, -1.09310664e-01f, -2.02816483e-02f, -5.32955304e-02f,
  1.15686096e-02f, -5.01379929e-02f, -8.35779980e-02f, -7.66527951e-02f, 1.31722689e-02f, -4.47560698e-02f, -8.52901042e-02f, -7.92214572e-02f, -1.12004094e-01f, -6.79805651e-02f,
  1.68311652e-02f, -2.32144836e-02f, 4.21250286e-03f, 1.29405754e-02f, -5.15134819e-02f, 9.65299457e-03f, -8.27655941e-02f, 4.78666425e-02f, -1.50594870e-02f, 5.85956909e-02f,
  6.94531202e-02f, -3.82284969e-02f, 5.72739244e-02f, 3.23486507e-01f, -5.94894998e-02f, -1.88915282e-01f, -2.00709268e-01f, 1.64531879e-02f, -7.41715729e-02f, -8.35102871e-02f,
  8.19810256e-02f, 5.93913496e-02f, -2.60530591e-01f, 2.94470459e-01f, 2.73813546e-01f, -7.39853457e-02f, 2.43758798e-01f, 7.54740834e-02f, -2.20172405e-02f, 1.87482666e-02f,
  2.22582757e-01f, 3.35914493e-01f, 1.16222374e-01f, 2.32555702e-01f, 1.86807625e-02f, 2.01206118e-01f, 3.00548166e-01f, 4.14984077e-02f, 2.21272483e-01f, 1.37921393e-01f,
  -6.13954477e-03f, 1.17274784e-01f, 4.15906571e-02f, -5.46816774e-02f, -9.21741948e-02f, -1.13994451e-02f, 2.88168043e-02f, 3.01342295e-03f, 4.56423908e-02f, 2.63438374e-03f,
  -9.84748080e-02f, 2.58064847e-02f, 4.87641618e-02f, -1.87370516e-02f, -3.10505889e-02f, 4.14113365e-02f, 2.90355533e-02f, -1.96711514e-02f, 2.46560872e-02f, -1.14457995e-01f,
  -7.48377517e-02f, -4.89298068e-02f, 5.81440367e-02f, 4.37626056e-03f, 7.56209940e-02f, 5.27755506e-02f, 6.73914030e-02f, -5.25968596e-02f, -3.97669934e-02f, 1.26057416e-01f,
  -2.14116811e-03f, -5.93032241e-02f, -9.63304713e-02f, 6.22058846e-03f, -5.34636341e-02f, -2.01847199e-02f, -2.28012577e-02f, 3.97616103e-02f, -5.78524405e-03f, 1.01195322e-02f,
  3.83497588e-02f, -2.89417971e-02f, 6.21542409e-02f, -8.65484122e-03f, 2.34583649e-03f, 4.74106241e-03f, 7.81783275e-03f, 3.86147648e-02f, -4.28027026e-02f, 4.61401902e-02f,
  1.79752372e-02f, 9.47521254e-02f, -5.36430292e-02f, 1.30574626e-03f, -3.06501128e-02f, -2.36080233e-02f, 2.72339713e-02f, -3.70348990e-02f, -6.67686909e-02f, 3.76444717e-04f,
  2.48712432e-02f, 1.90220594e-01f, -2.22604573e-02f, 4.36989293e-02f, 1.16023906e-02f, -6.87264511e-03f, -6.31482294e-03f, 8.81753489e-02f, 1.20023541e-01f, -4.36881632e-02f,
  2.79007573e-02f, -8.95116385e-03f, -4.36860025e-02f, 5.18772043e-02f, 2.91901547e-02f, -2.68802643e-02f, 5.64050823e-02f, -3.12165208e-02f, -1.41146583e-02f, 1.99092701e-02f,
  -4.66302410e-03f, -5.29543161e-02f, 6.76314607e-02f, -3.30454037e-02f, 5.39461598e-02f, 6.04070388e-02f, -3.08663398e-02f, -7.72286877e-02f, 1.24231964e-01f, -3.74152176e-02f,
  2.17610627e-01f, -1.52159274e-01f, -4.33454961e-01f, -1.70919254e-01f, 2.63804436e-01f, 2.81765252e-01f, -6.25017937e-03f, 1.39889065e-02f, -2.99434602e-01f, 1.86448723e-01f,
  2.15366453e-01f, -2.44456649e-01f, -8.97381753e-02f, -4.14916947e-02f, -2.09679574e-01f, -2.40378037e-01f, 6.17072731e-02f, 2.87729874e-02f, -1.62918851e-01f, 2.60793474e-02f,
  -4.19846587e-02f, 2.50910133e-01f, -2.25688472e-01f, 1.41441643e-01f, 1.32608280e-01f, 8.62903520e-02f, 2.79434025e-01f, -5.04543409e-02f, 1.62920266e-01f, 5.97771071e-02f,
  8.81875381e-02f, -8.52113590e-02f, -7.81359002e-02f, -1.35806948e-01f, 1.32506907e-01f, 8.19552019e-02f, 2.55756117e-02f, -6.48692101e-02f, -1.10812515e-01f, -3.15694213e-02f,
  2.28316411e-02f, -4.45605768e-03f, -8.11637715e-02f, -9.68656465e-02f, 1.06118575e-01f, -4.15055007e-02f, -6.51823878e-02f, 1.66006088e-02f, -5.66939227e-02f, -3.82093973e-02f,
  -8.40637311e-02f, 1.19859120e-02f, 9.92710982e-03f, -9.14958715e-02f, -1.06507070e-01f, 3.19756716e-02f, -1.60092730e-02f, 8.59703962e-03f, 1.16219878e-01f, -1.00039385e-01f,
  3.24544869e-02f, 8.33354965e-02f, 1.99600104e-02f, -7.68781751e-02f, -2.90440582e-03f, 1.84324905e-02f, -8.02217517e-03f, 4.64929976e-02f, -7.41817653e-02f, 2.76126154e-02f,
  1.07364608e-02f, -7.17893988e-02f, -3.46362665e-02f, -2.30094120e-02f, 4.21425290e-02f, -5.77797554e-02f, 2.22046115e-02f, -1.14179484e-03f, -8.87961388e-02f, -1.95685085e-02f,
  -3.41443047e-02f, 6.85605183e-02f, -5.04897200e-02f, 3.60704660e-02f, 4.67670569e-03f, -2.14396957e-02f, -4.67389189e-02f, -1.38395596e-02f, -1.00508347e-01f, 7.12023601e-02f,
  9.85237956e-02f, 8.43414143e-02f, -5.68167008e-02f, 3.84129845e-02f, 2.30713952e-02f, 1.05743445e-01f, -5.79686612e-02f, -3.01110465e-02f, 1.02560734e-02f, -2.95251422e-02f,
  1.48821115e-01f, 5.10549583e-02f, 9.91004035e-02f, -5.29000461e-02f, -4.55486141e-02f, 9.32269618e-02f, 5.90776727e-02f, -4.47835103e-02f, 9.27267075e-02f, -1.52123971e-02f,
  4.86631207e-02f, 2.98552904e-02f, 1.24771697e-02f, 3.52153853e-02f, 4.87107038e-02f, 8.60792845e-02f, 9.86882299e-02f, -2.63142791e-02f, -3.97236180e-03f, -2.90380474e-02f,
  3.03537011e-01f, -1.92707777e-01f, -2.07667455e-01f, 2.82789040e-02f, 1.99910745e-01f, 1.05046220e-01f, 9.60831717e-02f, 6.38003051e-02f, 1.17810562e-01f, 3.25302668e-02f,
  7.78592303e-02f, -1.40304253e-01f, 2.45970152e-02f, 7.11815059e-02f, 1.17622195e-02f, 5.93650378e-02f, 1.06071725e-01f, 5.51265068e-02f, 4.91555175e-03f, 5.47375605e-02f,
  1.12264371e-02f, 1.62752822e-01f, -1.78510230e-02f, -1.12930149e-01f, 7.74684921e-02f, -9.34799016e-02f, -1.18735455e-01f, -1.38622314e-01f, -2.37335879e-02f, -5.96181564e-02f,
  1.22729793e-01f, 1.21377796e-01f, 5.75224962e-03f, -6.66801212e-03f, -7.06544816e-02f, 5.37617467e-02f, -6.06172867e-02f, -6.17393851e-02f, 7.35436901e-02f, -8.48350301e-03f,
  4.50452082e-02f, -9.28781554e-02f, 3.38275023e-02f, 6.82629719e-02f, -3.74941006e-02f, 3.99872698e-02f, -1.60354259e-03f, 7.64621422e-02f, -6.88525736e-02f, 5.52817322e-02f,
  6.35310933e-02f, 9.04311799e-03f, -9.74420644e-03f, -1.14381433e-01f, -4.46851701e-02f, 6.75898418e-02f, -5.98567016e-02f, -1.25807170e-02f, -9.64772031e-02f, 1.44415712e-02f,
  -3.28769684e-02f, 2.34594606e-02f, 8.62979740e-02f, 9.94435176e-02f, 2.25030091e-02f, 1.12056956e-02f, -2.75390539e-02f, -7.96008930e-02f, -6.20643981e-02f, -6.57178834e-02f,
  -2.42923610e-02f, 3.08871195e-02f, 5.09093469e-03f, -8.44098441e-03f, -4.63322327e-02f, -7.70577788e-02f, -7.38323107e-02f, 4.89458106e-02f, 6.17459863e-02f, -3.42593379e-02f,
  -5.59170777e-03f, -3.34268622e-02f, 1.98389664e-02f, 2.44396552e-02f, 7.57978298e-03f, 4.03114520e-02f, 9.47813615e-02f, -2.21876577e-02f, -2.12922948e-03f, 4.05286141e-02f,
  -9.01572779e-02f, 3.06518059e-02f, -7.91292787e-02f, -1.71251111e-02f, -1.36218071e-01f, 1.38301332e-03f, -7.25004375e-02f, -8.12856201e-03f, 1.68902222e-02f, 6.16841651e-02f,
  -4.34423909e-02f, 5.88093512e-02f, -4.94476932e-04f, -2.59670615e-03f, -1.54117003e-01f, 1.11587733e-01f, -9.71313491e-02f, -9.60862488e-02f, -1.24945894e-01f, -6.85002431e-02f,
  -8.52695107e-02f, 5.62503561e-02f, -5.88631853e-02f, -4.17809598e-02f, -4.19057384e-02f, -4.10324745e-02f, -9.76707452e-05f, -8.84337351e-02f, 6.50160462e-02f, -7.21337274e-02f,
  1.32043779e-01f, 1.00659758e-01f, 4.89023253e-02f, 4.18234430e-02f, -5.99053390e-02f, -2.61868030e-01f, -1.63878471e-01f, -2.56050415e-02f, 6.79012313e-02f, 1.45671908e-02f,
  -7.42635950e-02f, 1.46104515e-01f, -9.27555487e-02f, -1.67781606e-01f, -3.40860575e-01f, -1.59503475e-01f, -1.18857913e-01f, 8.57820828e-03f, 1.91861782e-02f, 4.38098274e-02f,
  -1.28631994e-01f, -1.31502762e-01f, -1.20105490e-01f, -2.93075219e-02f, -8.30526054e-02f, 9.26513150e-02f, -7.69303665e-02f, 6.48284033e-02f, 3.09178978e-02f, -7.17830509e-02f,
  -1.19653884e-02f, 6.79294989e-02f, 8.73911604e-02f, 2.14893743e-02f, -6.58539161e-02f, 3.76399308e-02f, -2.97215991e-02f, -9.46430862e-02f, 5.05483858e-02f, 4.09759916e-02f,
  5.17132692e-02f, 6.78893998e-02f, -6.44799694e-02f, 2.39902399e-02f, 8.79530087e-02f, -3.54764909e-02f, -4.45453487e-02f, 5.95190711e-02f, -5.48088513e-02f, 2.60060187e-02f,
  6.10033460e-02f, -4.88700643e-02f, 6.66798353e-02f, 4.46273610e-02f, -4.02354822e-02f, 3.97994779e-02f, 5.47203748e-03f, -2.40375418e-02f, 3.58573981e-02f, -7.74902850e-02f,
  5.88355735e-02f, 6.15763403e-02f, 5.01629338e-02f, 5.38171753e-02f, -7.71791115e-02f, 1.91989485e-02f, 6.82661682e-02f, 9.80328303e-03f, 5.40594310e-02f, -6.59141317e-02f,
  -5.43740764e-02f, -3.96834053e-02f, -7.44224489e-02f, -4.96582985e-02f, 7.04169050e-02f, -3.85772027e-02f, 5.47023676e-02f, -4.20023911e-02f, 1.57072917e-02f, -8.12573507e-02f,
  4.96590175e-02f, -1.09846234e-01f, 3.94576974e-02f, -6.51781783e-02f, 2.81024333e-02f, 3.63857262e-02f, 7.62193874e-02f, 3.84161957e-02f, 5.46742976e-02f, -9.91517678e-02f,
  -9.85105336e-02f, -5.42134494e-02f, 2.18094364e-02f, 4.40479815e-02f, -4.00938764e-02f, -7.83852562e-02f, 3.14733051e-02f, 5.37441783e-02f, -2.13389937e-02f, -9.05454531e-02f,
  1.44854663e-02f, 4.66161817e-02f, 6.80133775e-02f, 7.33388588e-02f, -7.65400678e-02f, 2.60243844e-02f, 6.87327906e-02f, -6.85269609e-02f, -9.62002352e-02f, 2.01489720e-02f,
  1.59543511e-02f, 1.17304802e-01f, -4.09484915e-02f, -4.77453731e-02f, -1.45950049e-04f, -4.01688665e-02f, 2.87869275e-02f, 4.99514341e-02f, -1.02906879e-02f, -2.06190404e-02f,
  2.96669789e-02f, 9.80486497e-02f, 2.02551764e-03f, 7.60275945e-02f, 9.77619067e-02f, -1.14108361e-01f, -5.31094782e-02f, -6.51768222e-02f, 7.43561089e-02f, 5.71132638e-02f,
  8.09103921e-02f, -3.60234119e-02f, -1.02837712e-01f, 8.24538991e-02f, -6.92552328e-02f, -1.18587382e-01f, 5.67088351e-02f, -7.34936148e-02f, -3.01483348e-02f, 7.24828895e-03f,
  1.98044069e-02f, 8.18057433e-02f, -1.74834561e-02f, 7.24419951e-02f, -6.53893352e-02f, -8.51129442e-02f, 9.33913291e-02f, 4.99451458e-02f, -6.17365260e-03f, 4.36309166e-02f,
  -1.62239261e-02f, 6.12105839e-02f, 1.63714832e-03f, 7.69023830e-03f, -7.13467747e-02f, 7.89420679e-02f, 2.47568097e-02f, 3.17810080e-03f, -9.04190093e-02f, 4.09107795e-03f,
  -6.08718432e-02f, -2.28273645e-02f, -4.66270857e-02f, -2.75292508e-02f, -6.44807667e-02f, -3.27272229e-02f, 6.63189143e-02f, 1.50057161e-02f, -3.18097286e-02f, 3.81400324e-02f,
  -7.61242062e-02f, 8.86872262e-02f, -1.56001234e-03f, -1.16478596e-02f, 4.86057587e-02f, 2.70825922e-02f, -7.69653544e-02f, 2.35643331e-02f, -8.21844265e-02f, -6.24088161e-02f,
  5.35909310e-02f, 1.63984876e-02f, -6.15926087e-02f, 3.42925042e-02f, 2.76033189e-02f, 8.97491053e-02f, 7.52743259e-02f, -5.20661846e-02f, -5.77488355e-02f, -5.51696494e-03f,
  -8.44080225e-02f, 3.40409502e-02f, 2.46280786e-02f, 5.31272516e-02f, -8.20223708e-03f, -3.87192816e-02f, -3.60863619e-02f, -2.36135013e-02f, -4.33185659e-02f, -3.28244716e-02f,
  7.93582126e-02f, -4.04560640e-02f, -7.46177286e-02f, 3.50617655e-02f, 1.82253830e-02f, -3.07687838e-02f, 9.92214754e-02f, -1.92473661e-02f, 9.23359990e-02f, 1.53082621e-03f,
  3.29114050e-02f, -1.33041451e-02f, -7.02147111e-02f, -3.14961188e-03f, -7.75050595e-02f, 2.84237955e-02f, -3.63667831e-02f, -7.39329867e-03f, 1.33220460e-02f, -7.08740354e-02f,
  2.05518566e-02f, 7.88770914e-02f, -6.63752332e-02f, 5.86956590e-02f, -3.91152129e-02f, 8.00039321e-02f, 3.40037011e-02f, -2.27995440e-02f, -5.04657626e-02f, -7.69364461e-02f,
  -5.47037367e-03f, -5.57265654e-02f, -6.52573183e-02f, 1.88019425e-02f, 8.28886330e-02f, 7.45733008e-02f, 1.25588933e-02f, -7.62577057e-02f, -3.80934104e-02f, -2.32733171e-02f,
  3.74355257e-01f, -5.06488860e-01f, 1.04601949e-01f, 5.53837538e-01f, 2.27486402e-01f, -2.39743758e-02f, 2.40439966e-01f, 9.89135131e-02f, 1.16826266e-01f, -2.74573445e-01f,
  8.34582970e-02f, -1.00501955e-01f, -6.49745315e-02f, 7.44665712e-02f, 1.16475753e-01f, -1.24346301e-01f, 3.04919910e-02f, -4.93702553e-02f, 1.40649319e-01f, 8.51278603e-02f,
  2.60023922e-01f, 6.64164796e-02f, 6.22010194e-02f, -8.82137194e-02f, 1.20028518e-01f, 1.07085302e-01f, 5.59568927e-02f, -1.28784239e-01f, -9.03629586e-02f, -5.60660847e-02f,
  -5.09763062e-02f, 1.34103656e-01f, 1.03458822e-01f, -7.66567215e-02f, -3.05563137e-02f, -1.61951631e-02f, -6.93433061e-02f, -7.48650730e-03f, 4.47878242e-02f, -4.56496812e-02f,
  -3.70380320e-02f, -1.86233092e-02f, 5.81871569e-02f, 3.95847894e-02f, 2.28186417e-02f, 2.64937077e-02f, 9.30536166e-02f, 5.19579500e-02f, 3.93070914e-02f, 1.99091826e-02f,
  8.21212009e-02f, -3.42533849e-02f, 5.13435639e-02f, -3.76033857e-02f, 1.16483599e-01f, 1.91004798e-02f, -2.04605889e-02f, -1.34701096e-02f, -1.09027177e-01f, -1.53360981e-03f,
  5.81546053e-02f, 1.54187568e-02f, 4.93075475e-02f, -2.62217335e-02f, -2.03218088e-02f, 9.24743861e-02f, -3.03832814e-02f, 2.63682790e-02f, 2.44245790e-02f, -6.80950209e-02f,
  3.81369181e-02f, 2.80375220e-03f, -3.51712145e-02f, -2.24030018e-02f, 1.05436631e-01f, 1.19514298e-02f, 2.36361530e-02f, -9.19273496e-02f, 1.11030437e-01f, 3.45025472e-02f,
  -3.81369293e-02f, 8.51849280e-03f, -2.22859327e-02f, 2.07305029e-02f, -3.11068688e-02f, -4.71786000e-02f, 4.63563837e-02f, -7.89343342e-02f, 5.14160022e-02f, -1.52747044e-02f,
  -2.98880279e-01f, -2.82131135e-01f, -3.47459465e-02f, -2.92080361e-02f, -3.61552499e-02f, -1.23412952e-01f, -1.14786059e-01f, 4.17272486e-02f, -5.04773594e-02f, -4.71289381e-02f,
  -4.40340303e-02f, -6.96090283e-03f, -7.14832693e-02f, -8.52044746e-02f, -2.13317759e-02f, -6.54750764e-02f, -3.91253978e-02f, -8.22996497e-02f, -6.08773250e-03f, -5.61494567e-02f,
  2.57732999e-02f, -4.15065214e-02f, -2.68522650e-02f, 2.60126777e-02f, -6.17091954e-02f, 2.97572743e-02f, 1.43338805e-02f, -1.92086734e-02f, -5.93338758e-02f, -1.70951635e-02f,
  8.56363401e-02f, -1.35236641e-03f, -3.23828697e-01f, -9.13256109e-02f, -9.38924626e-02f, 2.44456738e-01f, 1.69340879e-01f, 1.05104242e-02f, -2.48094439e-03f, 2.41827831e-01f,
  1.25815481e-01f, 2.69490462e-02f, 4.51915450e-02f, 1.73439041e-01f, 1.06360309e-01f, 6.08909689e-02f, 2.87994534e-01f, 1.99163139e-01f, -2.86155920e-02f, 3.40900682e-02f,
  -7.53839463e-02f, 1.89679667e-01f, -1.22557901e-01f, 5.32776266e-02f, 3.94910350e-02f, -1.85817868e-01f, -7.03118220e-02f, -8.68108124e-02f, 1.27136692e-01f, 5.26394360e-02f,
  -4.86869514e-02f, -1.13694884e-01f, -6.69972748e-02f, -5.91724478e-02f, 2.50654165e-02f, -3.26104350e-02f, -5.59476018e-02f, -2.81762052e-02f, -1.70472004e-02f, 1.55186793e-02f,
  -1.16718502e-03f, -1.16294384e-01f, 5.17241284e-02f, 1.85657199e-02f, 2.52983198e-02f, -8.11238885e-02f, 4.53644879e-02f, -1.15838401e-01f, -3.09467092e-02f, -6.34559318e-02f,
  -5.92554994e-02f, 4.68724333e-02f, -7.68567100e-02f, -4.96424735e-02f, 3.04104462e-02f, -7.82245919e-02f, 7.71048442e-02f, -5.57481982e-02f, 4.65201307e-03f, 4.79524732e-02f,
  2.69062389e-02f, 7.22521991e-02f, 3.66188996e-02f, -3.85303423e-02f, 5.05845696e-02f, -4.27957922e-02f, 3.92755121e-02f, -3.93865816e-02f, -5.95366955e-02f, 7.82400742e-02f,
  -3.35024558e-02f, -3.61211039e-02f, 3.70844305e-02f, 8.48812312e-02f, 5.24053499e-02f, -1.02988712e-03f, -3.23155639e-03f, -1.26886843e-02f, 1.27321212e-02f, -6.95127696e-02f,
  -8.30086246e-02f, 6.10317178e-02f, 7.00998977e-02f, 2.31171530e-02f, 4.77130711e-02f, -2.52671689e-02f, 1.24313049e-01f, 2.19707172e-02f, 1.29276114e-02f, -5.91515936e-02f,
  1.14310391e-01f, 1.52684420e-01f, 1.29490299e-02f, -3.56148044e-03f, -8.68901610e-02f, 7.12820515e-02f, 1.07799478e-01f, -6.70268852e-03f, 5.91863394e-02f, -7.53977150e-03f,
  6.02631755e-02f, -4.48756777e-02f, 6.84662312e-02f, -7.60005862e-02f, -5.90410829e-02f, 6.19375147e-02f, 4.18076403e-02f, 4.13454417e-03f, 6.71863854e-02f, -3.43064666e-02f,
  -7.71522745e-02f, 1.47939716e-02f, -1.26988522e-03f, -1.04803033e-02f, -3.65491142e-03f, 6.52034655e-02f, -7.60724768e-02f, -2.80175935e-02f, 8.52354243e-02f, -7.24397600e-04f,
  2.02503372e-02f, 1.68013692e-01f, -1.00727811e-01f, -7.74384290e-02f, 1.41380436e-03f, 1.02407429e-02f, -2.23129585e-01f, -4.97138053e-02f, -9.42303985e-02f, -5.70162944e-02f,
  -3.47703211e-02f, 7.78147429e-02f, -1.24520004e-01f, 2.23227486e-01f, 1.33603066e-01f, 1.34397736e-02f, 1.71318308e-01f, 1.23422138e-01f, 5.74146397e-03f, 1.24909192e-01f,
  9.84304324e-02f, 1.47542313e-01f, 1.29843548e-01f, 2.54111707e-01f, 2.04743311e-01f, -4.11008261e-02f, 7.60547444e-02f, -8.36623833e-02f, 1.29679441e-01f, 5.92678860e-02f,
  1.08545460e-01f, 1.86990965e-02f, -4.89899423e-03f, -4.95018363e-02f, -2.62089781e-02f, -5.51063307e-02f, -2.91875936e-02f, 7.60688484e-02f, -9.10718665e-02f, -7.41828000e-03f,
  -9.82092321e-02f, 3.13392803e-02f, 1.24924034e-01f, 5.86410090e-02f, 2.93402448e-02f, 3.71681750e-02f, 6.76903278e-02f, -8.85140523e-03f, -6.93718940e-02f, 4.61574569e-02f,
  -6.17871024e-02f, -1.28103746e-02f, -8.12305212e-02f, -2.28898916e-02f, -7.59135783e-02f, -4.13318984e-02f, 3.80067937e-02f, 3.59552838e-02f, -1.77779123e-02f, 4.09505293e-02f,
  3.68511677e-02f, 7.35858604e-02f, -4.93001007e-02f, 6.63727745e-02f, 2.17452813e-02f, -1.31291356e-02f, 5.64562008e-02f, -3.65672186e-02f, -1.95802078e-02f, -7.05160424e-02f,
  3.08272373e-02f, 5.41051440e-02f, -6.47824928e-02f, -7.63814226e-02f, -8.03745836e-02f, 2.29164381e-02f, -4.59210388e-02f, -6.78461492e-02f, -1.11689754e-02f, 5.98467365e-02f,
  -3.82824354e-02f, -8.74125063e-02f, 3.59664299e-02f, 8.48343875e-03f, 4.11870191e-03f, -1.16636388e-01f, 2.56242193e-02f, -1.75978541e-02f, -6.75066188e-02f, 6.51058033e-02f,
  8.31639692e-02f, -2.90824845e-02f, -2.79741678e-02f, 4.86257039e-02f, 2.17963272e-04f, -4.54229489e-02f, 6.55786879e-03f, -4.00898308e-02f, -4.16242406e-02f, -6.96767820e-03f,
  -5.34734949e-02f, 1.17664933e-02f, -3.72900143e-02f, 2.85284761e-02f, 6.74957037e-02f, -1.00504860e-01f, -2.03376133e-02f, -4.44758534e-02f, -1.20775051e-01f, 1.13885850e-01f,
  2.97195204e-02f, -4.78752255e-02f, -5.43658957e-02f, 2.18545888e-02f, -8.37081112e-03f, -1.34231732e-03f, -6.84700385e-02f, -9.63376928e-03f, -4.31413529e-03f, 6.69052750e-02f,
  2.25927174e-01f, -5.28870448e-02f, -6.95481375e-02f, 2.82356471e-01f, 2.82363862e-01f, 7.48706609e-02f, 1.95503116e-01f, 1.76659063e-01f, 3.69351089e-01f, -9.67179611e-02f,
  2.11328827e-02f, -8.46640766e-02f, -2.43387312e-01f, 1.22979246e-01f, -1.92543883e-02f, -1.40587062e-01f, 1.01562783e-01f, 1.01650171e-01f, 1.28341973e-01f, 6.98601231e-02f,
  1.46515757e-01f, 6.12342320e-02f, -2.21410185e-01f, -1.74394384e-01f, 1.35482997e-01f, -4.36710194e-02f, -1.62237048e-01f, -1.17702857e-01f, -1.35239497e-01f, -6.65868521e-02f,
  -2.00503394e-02f, 1.54396845e-02f, -1.18542986e-03f, -6.08406663e-02f, 9.04176757e-02f, 6.36472274e-03f, -6.80440292e-02f, -1.33376837e-01f, 7.46170133e-02f, 2.63318699e-03f,
  2.98928693e-02f, -6.49529323e-02f, 7.94026628e-02f, -8.46412331e-02f, 1.18938357e-01f, 6.53678458e-03f, 5.66423200e-02f, 4.17469777e-02f, 7.82003626e-03f, -4.67720665e-02f,
  -8.00047070e-03f, -3.25390249e-02f, 1.62119314e-01f, 4.17332277e-02f, -6.27453253e-02f, -7.03012943e-02f, 3.57912295e-02f, -1.08092919e-01f, 2.33914275e-02f, 7.20045343e-03f,
  2.83988640e-02f, 7.75458887e-02f, -2.03668922e-02f, 1.54454382e-02f, -3.75066064e-02f, 3.63113806e-02f, -3.50332446e-02f, 8.24899506e-03f, -1.59105100e-02f, 2.35223453e-02f,
  7.90430419e-03f, 5.26146889e-02f, -1.29558900e-02f, 1.82211436e-02f, 5.12726232e-02f, 1.22168258e-01f, -1.21260379e-02f, -4.40384224e-02f, 4.77437079e-02f, 7.94968009e-02f,
  -4.28546034e-02f, 2.37543434e-02f, -8.82636085e-02f, -5.22473566e-02f, -5.24140671e-02f, 2.58958768e-02f, -7.85569847e-02f, -4.27436084e-02f, 8.02204665e-03f, -9.35890654e-04f,
  1.19480371e-01f, 1.52073190e-01f, -1.04569525e-01f, 5.27655631e-02f, -8.36695284e-02f, 6.85718134e-02f, 7.76213929e-02f, 7.18686655e-02f, 3.49890295e-04f, -4.05769749e-03f,
  -2.91695371e-02f, 5.89019582e-02f, -2.87364740e-02f, -7.52604008e-02f, -4.54289764e-02f, 6.55791759e-02f, 2.71825735e-02f, 7.76495039e-02f, 2.37018196e-03f, -5.97431287e-02f,
  6.06576577e-02f, 5.47066517e-02f, 1.11357020e-02f, 1.54375657e-01f, -2.99831107e-02f, 5.40589392e-02f, -4.26235283e-03f, 1.38792098e-02f, -4.29683067e-02f, -2.30142698e-02f,
  -4.44704205e-01f, 1.99332416e-01f, 2.27980584e-01f, -2.87413657e-01f, 4.62422660e-03f, 3.49442452e-01f, -7.72873983e-02f, 1.72370970e-01f, 1.17310490e-02f, -7.43750669e-03f,
  -7.80911297e-02f, -1.53824270e-01f, 1.65319368e-01f, 1.65159982e-02f, 1.45522535e-01f, 2.09740996e-01f, 9.74550750e-03f, 2.80527305e-02f, 1.17975108e-01f, -8.69936571e-02f,
  -1.14457324e-01f, -1.20808668e-01f, 1.01041369e-01f, -3.54245640e-02f, -1.71987921e-01f, -9.22686905e-02f, -2.08668932e-01f, 1.46955959e-02f, 1.18253510e-02f, 1.37811452e-01f,
  -3.03979684e-02f, -1.69790030e-01f, 1.03661947e-01f, 8.20749179e-02f, 6.46286234e-02f, -1.23024322e-02f, -5.95622994e-02f, 2.57255174e-02f, -8.41065273e-02f, -4.10370491e-02f,
  -9.87568572e-02f, -4.90422137e-02f, -3.34286466e-02f, 5.83648272e-02f, 5.41242622e-02f, 7.71375820e-02f, 7.66592324e-02f, 1.33657195e-02f, 2.25351080e-02f, 9.47707817e-02f,
  7.84388036e-02f, 1.02652952e-01f, 3.82842273e-02f, -1.30711207e-02f, 5.57157621e-02f, -4.63447049e-02f, 1.45282578e-02f, 3.91209200e-02f, -2.84310076e-02f, -2.08919290e-02f,
  7.49816075e-02f, 7.85213113e-02f, 6.99191466e-02f, 3.14212143e-02f, -5.22969961e-02f, 6.10995553e-02f, -2.62733009e-02f, 4.24497463e-02f, -2.90184617e-02f, 2.83773858e-02f,
  -1.25160329e-02f, 1.80061087e-02f, -6.89983889e-02f, 7.59504959e-02f, -4.36819345e-02f, -2.31868727e-03f, 9.52850562e-03f, -1.59300212e-02f, 2.84335250e-03f, -4.30364273e-02f,
  2.33182944e-02f, 1.48752155e-02f, 1.67550109e-02f, 2.53900830e-02f, 1.09790988e-01f, -1.69302225e-02f, 5.65743670e-02f, 8.51492584e-02f, -4.57555754e-03f, -5.83403707e-02f,
  3.17327939e-02f, -1.12800054e-01f, -1.28354710e-02f, -1.75994001e-02f, -2.51873955e-02f, 5.61472401e-03f, 3.62501666e-02f, 6.81391507e-02f, 7.90401995e-02f, -2.90486831e-02f,
  -5.29674888e-02f, -3.44868563e-03f, -5.15044555e-02f, -3.81386653e-02f, -7.22900406e-02f, -2.32151896e-03f, -3.43839787e-02f, -3.52625810e-02f, -6.81075603e-02f, -1.83846038e-02f,
  -1.19846286e-02f, -4.87143770e-02f, -2.84627825e-02f, 1.99953374e-02f, -1.62611902e-02f, -5.93162999e-02f, -8.86118487e-02f, 2.88727530e-03f, 2.53472086e-02f, -2.08844282e-02f,
  3.07438932e-02f, -1.43323252e-02f, -9.81660858e-02f, 1.94414705e-01f, -1.21454440e-01f, 1.95410088e-01f, 1.30405933e-01f, -7.57153854e-02f, 2.75460541e-01f, -4.09553908e-02f,
  -2.26754099e-02f, 2.39549384e-01f, -2.15017527e-01f, 1.38524100e-01f, 1.98835358e-01f, 1.70674212e-02f, 2.53751069e-01f, 2.23423645e-01f, 6.57093450e-02f, 9.54560935e-03f,
  -8.36946517e-02f, 8.54289159e-02f, -2.30137423e-01f, 5.25748543e-02f, -8.06041434e-02f, -8.50076526e-02f, -1.07284971e-01f, -1.93645388e-01f, 3.21033262e-02f, 2.59707328e-02f,
  -1.80238262e-02f, 2.37299856e-02f, 4.31213006e-02f, 4.79032509e-02f, -4.88869250e-02f, 7.37411529e-03f, 1.53832547e-02f, 6.57653958e-02f, -1.72392819e-02f, -1.43082812e-02f,
  7.39619434e-02f, -9.81363747e-03f, 1.04217000e-01f, -3.48407105e-02f, -4.80067581e-02f, 9.47513357e-02f, -6.42401427e-02f, -9.64903012e-02f, 6.38487190e-02f, -1.09066390e-01f,
  -2.13651061e-02f, -5.99484425e-03f, -3.67612857e-03f, 6.52436614e-02f, 9.21259820e-02f, 2.41620485e-02f, -4.62478900e-04f, 5.19008972e-02f, 5.28068170e-02f, 1.35687329e-02f,
  -1.63322669e-02f, -3.87669727e-02f, -4.84449305e-02f, -2.14778017e-02f, -4.95608989e-03f, -9.53301042e-02f, -1.16405729e-02f, -6.58981800e-02f, -1.07816299e-02f, 1.69974826e-02f,
  -5.01866378e-02f, 1.92065984e-02f, 4.93890755e-02f, -6.93249032e-02f, -8.98235105e-03f, 2.15000622e-02f, 1.74342990e-02f, 4.18549255e-02f, 5.62169813e-02f, -4.88033742e-02f,
  3.66402641e-02f, 1.19912080e-01f, 3.40813845e-02f, -2.20582373e-02f, 1.06069289e-01f, -7.18747750e-02f, 5.22066317e-02f, -3.92046422e-02f, 3.56441177e-02f, -7.56698623e-02f,
  5.64732961e-02f, 2.15911984e-01f, 5.06179556e-02f, 2.98535079e-02f, -5.52649312e-02f, -6.45881817e-02f, -5.67513052e-03f, 5.52889071e-02f, 8.65043551e-02f, 3.89549136e-02f,
  -1.21255971e-01f, -6.71759620e-02f, -6.17681742e-02f, 5.47176674e-02f, 3.84078734e-02f, -2.86404695e-02f, -4.26535457e-02f, 3.52774896e-02f, -4.85599414e-03f, -4.77728397e-02f,
  -1.25619974e-02f, -4.92322408e-02f, -3.37334275e-02f, -1.95585433e-02f, -1.35199241e-02f, -5.38745001e-02f, 1.11525491e-01f, 5.52057438e-02f, 5.89144379e-02f, 8.48529935e-02f,
  9.45240557e-02f, -3.36954802e-01f, 1.29054025e-01f, 3.79002206e-02f, 4.02052216e-02f, 1.36562943e-01f, 3.77166063e-01f, -2.57105649e-01f, -1.87361568e-01f, -2.77407348e-01f,
  8.53465348e-02f, 8.52834508e-02f, 1.37898713e-01f, -1.96033120e-02f, 3.58487934e-01f, 4.00502570e-02f, -4.14450616e-02f, 1.61344171e-01f, -7.26338625e-02f, -2.29056776e-02f,
  -2.43360903e-02f, -3.95052247e-02f, 1.98981203e-02f, -2.56202340e-01f, -4.20163311e-02f, -2.14510813e-01f, 3.56107987e-02f, 1.55564040e-01f, -1.87682107e-01f, 5.26410714e-02f,
  -3.03902570e-02f, -8.46175328e-02f, 7.08018392e-02f, -1.28512442e-01f, -7.55031183e-02f, 1.07082054e-02f, 1.08435474e-01f, 1.97222725e-01f, 1.22492630e-02f, -1.16202042e-01f,
  5.92966340e-02f, -5.92870312e-03f, -7.79279917e-02f, 3.28359641e-02f, -4.83736098e-02f, -8.09156150e-02f, 8.28649569e-03f, -1.82282720e-02f, 1.63218770e-02f, -6.50828630e-02f,
  2.78970506e-02f, -2.32974943e-02f, -6.60679415e-02f, -2.29539704e-02f, 4.84719425e-02f, -4.51009162e-02f, -3.06297168e-02f, 1.21881254e-01f, -5.84641844e-02f, 2.65131686e-02f,
  -1.83012728e-02f, 2.57567242e-02f, -1.18558370e-02f, 1.20966053e-02f, 4.16105427e-02f, -7.24702477e-02f, -1.20464256e-02f, 4.61574569e-02f, -4.49806489e-02f, 9.67749506e-02f,
  -5.12107462e-02f, -5.06946491e-03f, 1.60508254e-03f, 2.44461205e-02f, -5.14282845e-02f, 5.58497831e-02f, 1.16243504e-01f, -2.66645122e-02f, 3.64804664e-03f, -6.04429320e-02f,
  -1.20126456e-02f, 1.15189292e-02f, 4.50278912e-03f, 2.21939795e-02f, -3.58824730e-02f, 4.66476455e-02f, 2.87441490e-03f, -7.04509914e-02f, -2.22915621e-03f, 6.58660159e-02f,
  -3.89310569e-02f, -5.25448360e-02f, -1.08679160e-02f, 5.63647179e-03f, 2.34870613e-02f, -1.67768914e-02f, -2.98253540e-02f, -7.37530440e-02f, 5.54931909e-02f, -4.16867249e-02f,
  -4.03503291e-02f, 4.65351716e-02f, -4.74985391e-02f, 7.07124243e-04f, 1.50896823e-02f, -9.85489935e-02f, 7.41864517e-02f, -7.79425129e-02f, -2.14024652e-02f, -5.19835129e-02f,
  -1.29305935e-02f, -4.59997021e-02f, 1.08839698e-01f, -4.48909178e-02f, -4.49244753e-02f, 5.46808243e-02f, -6.43070564e-02f, -2.35242210e-02f, -3.47714610e-02f, -9.30417422e-03f,
  -2.07292661e-02f, -2.57061440e-02f, 2.50613410e-02f, -3.87398601e-02f, 9.86186638e-02f, -6.20598234e-02f, 8.40914324e-02f, 1.65737972e-01f, 1.41002476e-01f, 8.31941664e-02f,
  -6.63376525e-02f, -1.61891490e-01f, 1.29270293e-02f, -4.59627621e-02f, -1.61776230e-01f, -2.03552376e-02f, -5.86911067e-02f, -1.30905986e-01f, -3.54108177e-02f, -5.12826107e-02f,
  7.32416436e-02f, 2.17834841e-02f, 6.01494908e-02f, 8.03106055e-02f, -4.71529551e-03f, -6.31292525e-04f, -1.00128293e-01f, 9.70725156e-03f, -7.68190715e-03f, -2.64754687e-02f,
  -4.18452919e-02f, 5.21702096e-02f, 3.12417350e-03f, 7.04314113e-02f, 2.19513252e-02f, -9.68101844e-02f, -4.67542000e-02f, -8.18562731e-02f, 5.63849322e-02f, 9.07124132e-02f,
  3.25718932e-02f, 6.88559562e-02f, 3.25759277e-02f, -5.46433926e-02f, 1.48899272e-01f, 8.08966681e-02f, -8.02806169e-02f, -5.50640598e-02f, 4.72280495e-02f, -2.63601989e-02f,
  5.30109601e-03f, -6.51718304e-02f, 7.26129562e-02f, 4.35160100e-02f, 7.81613141e-02f, 1.30624417e-03f, -7.21575087e-03f, -1.28453761e-01f, 6.95456984e-03f, 8.19475949e-02f,
  7.99430534e-03f, -1.36903496e-02f, -1.76488329e-02f, -5.19186035e-02f, 6.61699548e-02f, 8.60429481e-02f, -1.19065372e-02f, -8.47267509e-02f, -2.14873310e-02f, 7.27064908e-02f,
  -6.15503192e-02f, 1.03835575e-02f, 8.92574862e-02f, -8.32042247e-02f, -6.05176613e-02f, 7.76570439e-02f, -6.09743707e-02f, -7.95008168e-02f, -6.46829978e-02f, 4.79542203e-02f,
  9.95423552e-03f, 6.99829543e-03f, 6.02699555e-02f, 3.41782123e-02f, -2.28954796e-02f, -8.59061927e-02f, -6.22084811e-02f, -8.32398459e-02f, 5.74564859e-02f, -5.24250325e-03f,
  1.09720575e-02f, -1.36848420e-01f, 4.65208665e-04f, -8.64008069e-03f, 3.75542007e-02f, -8.50445405e-02f, -2.33443752e-02f, 2.11873986e-02f, -3.12640071e-02f, 7.57781416e-02f,
  4.35616300e-02f, 1.05456784e-01f, -3.94924022e-02f, 5.99345891e-03f, 1.00684830e-03f, 2.74518393e-02f, -7.19497651e-02f, 1.27744218e-02f, 3.44781950e-02f, 4.79787914e-03f,
  6.63954020e-02f, 9.12885275e-03f, 2.30250787e-02f, 2.72647627e-02f, -6.03432022e-02f, -3.85429827e-03f, 4.82895337e-02f, 3.64648812e-02f, -1.20768927e-01f, -3.77652422e-02f,
  -9.65383202e-02f, 3.27106416e-01f, 1.52129769e-01f, 1.83962623e-03f, -5.75492047e-02f, -3.12725097e-01f, -1.96747720e-01f, 1.29112825e-01f, 2.27648154e-01f, 9.54645351e-02f,
  -2.66148187e-02f, 1.58230022e-01f, 2.02144280e-01f, -2.66801547e-02f, -4.19030309e-01f, -1.25804886e-01f, -2.54199773e-01f, -2.21485898e-01f, 4.67212610e-02f, 1.08160535e-02f,
  -5.91024645e-02f, 7.39261135e-02f, 2.56991629e-02f, 2.41107985e-01f, 5.61170653e-02f, 2.15560824e-01f, -1.10212490e-01f, 2.68602699e-01f, -2.29699221e-02f, 3.94975245e-02f,
  -2.00670864e-02f, 1.47648871e-01f, 2.23576985e-02f, 7.78803006e-02f, -5.47528043e-02f, -1.23900585e-01f, 2.78831739e-03f, -6.21041171e-02f, -5.49131781e-02f, -1.52921015e-02f,
  -3.59027274e-02f, 2.19911337e-02f, -1.08661447e-02f, -7.43251806e-03f, 1.17840491e-01f, 3.32381465e-02f, 6.48238510e-02f, -8.13120753e-02f, 5.45989349e-02f, -6.64014816e-02f,
  8.34258944e-02f, 5.14038131e-02f, -5.97325340e-03f, -4.38925214e-02f, 2.55016126e-02f, -1.54520841e-02f, -9.13378745e-02f, -1.84144508e-02f, -3.70703684e-03f, -2.40039434e-02f,
  9.08351839e-02f, 2.20093038e-02f, 4.03017886e-02f, 9.20050126e-03f, 4.20565829e-02f, 5.65197272e-03f, 6.44474253e-02f, 5.10392450e-02f, 6.49719611e-02f, 3.46845426e-02f,
  2.68864874e-02f, 9.29783732e-02f, 3.10445260e-02f, 1.57077238e-03f, -5.47875576e-02f, 5.86322434e-02f, -6.47173543e-03f, 3.77023779e-02f, -1.99824162e-02f, 3.16998772e-02f,
  8.07815790e-03f, -1.47473328e-02f, 7.97214732e-02f, -5.68830632e-02f, -5.88420480e-02f, -5.33101037e-02f, 3.92144471e-02f, -3.05601619e-02f, 6.60384968e-02f, -9.98260826e-03f,
  -2.18087867e-01f, 3.98804396e-02f, 9.58850980e-02f, -7.52619409e-04f, -7.64657557e-02f, -1.73711739e-02f, -1.34978751e-02f, 6.66107163e-02f, 5.43793514e-02f, 3.70422676e-02f,
  3.85462516e-03f, -7.86395445e-02f, -1.38065994e-01f, 6.85369298e-02f, -7.47318864e-02f, -1.04055174e-01f, -5.02639590e-03f, -3.60273831e-02f, -9.16501414e-03f, -2.96933018e-02f,
  3.92506346e-02f, -4.44054529e-02f, -6.97375461e-02f, -2.23421259e-03f, -9.07792598e-02f, -8.75675157e-02f, 7.06257001e-02f, -2.19714660e-02f, -8.46238807e-02f, -8.74195322e-02f,
  -2.44513974e-01f, 1.94078609e-01f, -1.96925893e-01f, 4.72564399e-02f, -1.60886914e-01f, 1.17131732e-01f, 2.11634025e-01f, -1.16104804e-01f, -1.21991858e-01f, 3.37981224e-01f,
  3.91511172e-01f, -1.84487581e-01f, 1.69419616e-01f, 5.06246209e-01f, -1.20052509e-01f, 2.26217687e-01f, 4.01455760e-01f, 3.78714174e-01f, -1.45108148e-01f, -6.51060566e-02f,
  -9.42147300e-02f, 2.53480673e-01f, 1.06147692e-01f, -4.99391556e-02f, 1.19389191e-01f, -2.43250266e-01f, 3.15854698e-02f, -2.36663207e-01f, 1.88384682e-01f, 4.74008583e-02f,
  2.08779678e-01f, -5.12248166e-02f, 3.30028906e-02f, -6.67364337e-03f, 3.76938246e-02f, 5.23655256e-03f, 3.97076234e-02f, -6.93438649e-02f, -1.28860444e-01f, 5.89892268e-03f,
  -3.76418717e-02f, -5.59710190e-02f, -1.01795048e-01f, -6.71438873e-02f, -6.77194893e-02f, -1.15658313e-01f, -6.93645477e-02f, 5.91821186e-02f, -1.04764059e-01f, -8.61388445e-02f,
  -6.09769579e-03f, 4.69685979e-02f, 7.53423348e-02f, 6.88892528e-02f, -5.31299859e-02f, -1.84840094e-02f, 4.65485593e-03f, -3.19818072e-02f, 3.20335738e-02f, -6.75674751e-02f,
  -5.25346445e-03f, 4.32945453e-02f, 3.02396845e-02f, 4.96741235e-02f, 4.70488816e-02f, 3.38030122e-02f, -3.98696214e-03f, 4.55697402e-02f, -5.37423193e-02f, -5.31345140e-04f,
  -1.32132461e-02f, -4.25285921e-02f, 2.24488601e-02f, 9.39359816e-05f, 6.87438250e-02f, -2.30926163e-02f, 2.85363384e-02f, 4.98000979e-02f, 3.36132571e-02f, -5.50435530e-03f,
  2.09400244e-02f, -1.70152653e-02f, 1.58945192e-02f, 4.46500406e-02f, 5.00907637e-02f, -3.77877988e-02f, 2.60575581e-02f, 1.54167879e-02f, 1.70133673e-02f, -6.82170913e-02f,
  3.05557624e-02f, -1.29656509e-01f, 2.04535760e-02f, 1.13842040e-02f, -5.47159053e-02f, -7.03865476e-03f, -3.09885573e-03f, -2.95517733e-03f, -3.19584608e-02f, -4.05162945e-02f,
  -3.32243741e-02f, -3.84402312e-02f, -6.49171835e-03f, 4.67797890e-02f, 2.75489725e-02f, 4.52936478e-02f, 1.28295645e-02f, -5.23964651e-02f, -3.67897153e-02f, 7.98842497e-03f,
  -1.11893462e-02f, -3.83396037e-02f, -3.21464166e-02f, 5.91377728e-03f, -1.41832978e-02f, 6.08059205e-03f, -2.19027419e-02f, -6.67978674e-02f, -2.50373092e-02f, -3.68158333e-02f,
  -1.58621088e-01f, 4.44718711e-02f, -2.26853415e-02f, -2.24416196e-01f, 7.15508079e-03f, -6.61141202e-02f, -5.17002754e-02f, 9.36087314e-03f, -7.07123354e-02f, 1.61409512e-01f,
  1.07064351e-01f, -6.26410469e-02f, -4.45017517e-02f, -2.78257847e-01f, -1.32629171e-01f, -1.45473063e-01f, -1.69617444e-01f, -1.75864901e-02f, -7.88498670e-02f, -6.22931821e-03f,
  -6.98024929e-02f, -1.88530803e-01f, 4.61113006e-02f, 7.27063939e-02f, -4.84527508e-03f, 1.30465627e-01f, 9.22720805e-02f, 1.41940877e-01f, 9.29913446e-02f, -9.65193883e-02f,
  -5.60897477e-02f, 8.32431614e-02f, -1.68449618e-02f, 3.29239061e-03f, 8.57797414e-02f, 8.32028687e-02f, 1.41419619e-01f, 2.73978598e-02f, -6.78005740e-02f, 4.13993858e-02f,
  -6.21813014e-02f, 5.88558465e-02f, -3.17901708e-02f, -2.76619811e-02f, -4.72897198e-03f, -6.99407682e-02f, 6.75397739e-02f, -2.86994111e-02f, -6.60293847e-02f, 6.55016163e-03f,
  2.52195597e-02f, -1.95190702e-02f, -4.76562753e-02f, -1.39787504e-02f, 3.01000793e-02f, 4.35826331e-02f, 2.53769681e-02f, 1.05260901e-01f, 6.18917234e-02f, 6.74728826e-02f,
  9.36072841e-02f, -1.36337811e-02f, -1.05369180e-01f, 5.28248623e-02f, -9.57284570e-02f, -4.97710072e-02f, 4.48393188e-02f, 2.95259971e-02f, -7.53273116e-03f, 8.21955409e-03f,
  -2.52735391e-02f, 1.44134238e-02f, 2.17937231e-02f, -2.14191098e-02f, 6.19845930e-03f, -5.93582243e-02f, 9.64493230e-02f, 4.85217869e-02f, 4.73344959e-02f, -7.35305026e-02f,
  6.43967539e-02f, 2.34009828e-02f, -5.05649559e-02f, 2.81963199e-02f, -9.28511024e-02f, 5.31870387e-02f, 2.70635020e-02f, -6.52287975e-02f, -2.54874341e-02f, -5.49161248e-02f,
  9.98687223e-02f, 2.54603922e-01f, -2.24399343e-02f, -7.56269833e-03f, 7.77238682e-02f, 8.27513635e-02f, -8.44088048e-02f, 3.45278205e-03f, 6.14005700e-02f, -6.44770861e-02f,
  7.70498142e-02f, -3.43238190e-02f, -9.39234626e-03f, -6.95076138e-02f, 8.20302889e-02f, -3.64560075e-02f, 6.39068112e-02f, -4.52278415e-03f, 1.23259954e-01f, 1.30977944e-01f,
  -1.00145889e-02f, 6.82894215e-02f, -2.77254656e-02f, 1.73890889e-02f, 4.82122675e-02f, 7.90483728e-02f, 7.86781982e-02f, -1.00294771e-02f, -6.59529418e-02f, -1.31105362e-02f,
  2.55523533e-01f, -8.77037048e-02f, -2.16112986e-01f, 1.43201098e-01f, 2.82092214e-01f, 2.42413864e-01f, -2.68132575e-02f, 1.07198596e-01f, 7.22386166e-02f, -3.80076319e-02f,
  1.30537182e-01f, -3.57874781e-02f, -2.53650665e-01f, 2.13515952e-01f, 2.64772117e-01f, -1.92901716e-01f, 3.08103532e-01f, 9.77340415e-02f, 6.93432894e-03f, 3.84039395e-02f,
  1.61677241e-01f, 3.06239218e-01f, -7.53499418e-02f, 4.03225869e-02f, 8.66258666e-02f, -2.65533365e-02f, 5.68561628e-02f, -2.13413119e-01f, 1.89752996e-01f, 1.39949486e-01f,
  3.59914266e-02f, 2.81792022e-02f, -3.59965488e-02f, -2.76981723e-02f, 6.00444572e-03f, -5.13286181e-02f, -2.11149417e-02f, -1.08408334e-03f, -9.13603827e-02f, -7.17619732e-02f,
  -9.75818038e-02f, 5.73059060e-02f, 7.08646998e-02f, 1.09481355e-02f, 4.96894307e-02f, 6.61444888e-02f, 4.72943783e-02f, -9.41900834e-02f, -8.12544450e-02f, -3.03718634e-02f,
  -3.50102112e-02f, -2.55135316e-02f, -1.19789233e-02f, 4.79207896e-02f, -3.45603302e-02f, 5.85415624e-02f, -7.53468424e-02f, -1.72666516e-02f, 4.77471203e-02f, 1.22732371e-01f,
  5.46319075e-02f, -8.27399343e-02f, 5.48177846e-02f, -6.42103702e-02f, 6.07844396e-03f, -5.81995621e-02f, 3.08850575e-02f, 7.16638146e-03f, 2.60979235e-02f, 4.63477299e-02f,
  4.33746427e-02f, 2.07483321e-02f, 1.15088485e-01f, -2.87445784e-02f, 2.50860304e-02f, 1.30346352e-02f, 5.23961894e-02f, -2.98327282e-02f, 3.27756181e-02f, 2.98740268e-02f,
  -4.46775579e-04f, 4.45898622e-02f, 3.34100500e-02f, -8.13173726e-02f, 3.70678902e-02f, -4.93649440e-03f, 3.28746578e-03f, -6.27947003e-02f, -8.76540616e-02f, 1.28373988e-02f,
  7.56977275e-02f, 2.26251613e-02f, -4.33273651e-02f, -2.68521663e-02f, -4.95848060e-03f, 1.60684764e-01f, -1.04733305e-02f, 1.06241539e-01f, 6.12220690e-02f, 8.76491815e-02f,
  -5.43629304e-02f, -4.60417829e-02f, 4.68942933e-02f, 1.99763980e-02f, 4.26490158e-02f, 7.06396997e-02f, -2.92348526e-02f, 4.86824326e-02f, 1.20149618e-02f, 6.92176670e-02f,
  1.12192277e-02f, -4.32113558e-02f, -2.77384482e-02f, 6.24570921e-02f, 3.37767489e-02f, -3.88276093e-02f, 1.16867937e-01f, -6.36519641e-02f, -4.61293831e-02f, 1.53513800e-03f,
  1.91712186e-01f, -1.69707477e-01f, -1.05067700e-01f, -6.74647689e-02f, 6.57569990e-02f, 2.01154679e-01f, 2.01260056e-02f, -6.78115189e-02f, -1.55003399e-01f, 2.83736363e-02f,
  5.41608594e-02f, -4.34080604e-03f, -1.86200663e-01f, 1.90598756e-01f, 1.12782024e-01f, -8.80963281e-02f, 1.84571564e-01f, 8.66820365e-02f, -1.07290171e-01f, 2.99827326e-02f,
  -3.81844044e-02f, 1.29715413e-01f, -1.06369779e-01f, 1.07559010e-01f, 1.27780199e-01f, -4.52934299e-03f, 7.02156797e-02f, -5.84664866e-02f, 8.59067887e-02f, 1.55156562e-02f,
  7.10889027e-02f, -4.38922122e-02f, -6.36459664e-02f, 2.08604056e-03f, -5.57602718e-02f, -8.54501687e-03f, -6.73318002e-03f, 6.76858649e-02f, -1.01250961e-01f, 3.21611874e-02f,
  4.28153947e-02f, 1.58459023e-02f, 4.73417193e-02f, 5.17849289e-02f, 5.27556315e-02f, 1.80127509e-02f, 8.82796571e-03f, 5.92370071e-02f, 3.22775468e-02f, 1.44211072e-02f,
  -1.45284638e-01f, 6.94503859e-02f, -2.30076090e-02f, -3.01235151e-02f, -1.27472840e-02f, 5.39087038e-03f, -8.68060887e-02f, -1.07479900e-01f, 4.44981493e-02f, 2.83681974e-02f,
  -2.02048905e-02f, 8.27059988e-03f, -3.07583176e-02f, 4.81356457e-02f, -3.24892551e-02f, 5.98520748e-02f, -3.11034899e-02f, -5.97676612e-04f, -8.72598812e-02f, -1.90175921e-02f,
  -3.32855992e-02f, -5.69139160e-02f, 2.24472620e-02f, 4.86277752e-02f, -4.90061864e-02f, 6.71947226e-02f, 2.55301874e-03f, 7.35402182e-02f, -8.78687650e-02f, 3.97598855e-02f,
  6.42010570e-02f, -7.02533312e-03f, -4.35595252e-02f, 3.02132331e-02f, -6.33083060e-02f, 3.01839807e-03f, 1.60201024e-02f, 7.44935572e-02f, -5.81464618e-02f, 8.88878182e-02f,
  -1.59427375e-02f, -7.60292709e-02f, -7.96100944e-02f, 7.72083998e-02f, 4.27487493e-02f, -1.62173230e-02f, -1.36730019e-02f, 2.46199667e-02f, 5.60334101e-02f, 2.34063230e-02f,
  4.90777418e-02f, -3.58942039e-02f, 1.35554839e-02f, 4.55512330e-02f, 8.30883980e-02f, -6.95047304e-02f, -3.77103165e-02f, -9.77280810e-02f, -1.96361095e-02f, 2.68261842e-02f,
  -1.16416045e-01f, -3.34220678e-02f, 4.87313755e-02f, -9.57450420e-02f, 9.54779703e-03f, 5.40084578e-02f, -4.88594808e-02f, 4.99747917e-02f, 7.11122677e-02f, 8.25584680e-03f,
  7.57088959e-02f, 7.24343285e-02f, 2.18399346e-01f, 2.34037042e-01f, -1.86238274e-01f, -2.09967121e-01f, 3.67265902e-02f, -1.05092518e-01f, 1.34624928e-01f, 7.57213496e-03f,
  -3.54698747e-02f, 3.30931425e-01f, -3.49801704e-02f, 1.00822739e-01f, -9.70581844e-02f, -1.31563500e-01f, 9.20660142e-03f, 1.05341502e-01f, 7.36358315e-02f, -2.88115651e-03f,
  2.97708362e-02f, -4.36300375e-02f, 9.70945358e-02f, -1.80530995e-01f, 6.49242774e-02f, 1.35755718e-01f, -7.21197948e-02f, 3.10162567e-02f, -3.18994150e-02f, -5.32094985e-02f,
  1.22505352e-02f, 2.67831739e-02f, 1.05091549e-01f, 1.61917787e-02f, 2.18603183e-02f, 1.97837525e-03f, 1.06602021e-01f, -4.81600799e-02f, 4.24420871e-02f, 3.92490141e-02f,
  2.60373969e-02f, -8.18385854e-02f, 2.14046128e-02f, 3.52156833e-02f, -4.26919991e-03f, 8.51329491e-02f, 3.92533056e-02f, 1.69660076e-02f, 1.03374302e-01f, 3.83547768e-02f,
  1.47347018e-01f, 1.07341699e-01f, 6.27844036e-02f, 1.03409206e-02f, 3.25175785e-02f, 4.30907644e-02f, -2.42988691e-02f, -2.39144713e-02f, -2.91240532e-02f, 5.12131304e-02f,
  -1.37942228e-02f, 3.20983231e-02f, 5.39420545e-02f, -5.32191098e-02f, 1.51797943e-02f, 6.00232892e-02f, 5.85523143e-04f, -5.20680100e-02f, -7.12161884e-02f, -1.24516981e-02f,
  -9.34670568e-02f, 9.92424935e-02f, 6.07343093e-02f, -7.96353146e-02f, 2.99889799e-02f, 3.87155674e-02f, 3.91229093e-02f, -5.96682988e-02f, 7.70935640e-02f, -4.30689268e-02f,
  -2.02241330e-03f, -7.42225423e-02f, 8.75397846e-02f, 6.59998432e-02f, -4.20836285e-02f, -1.42063480e-02f, -2.24072346e-03f, -5.95815741e-02f, -5.14492020e-02f, -3.48256365e-03f,
  -1.50418073e-01f, -1.02454193e-01f, -7.11003691e-02f, 5.94565719e-02f, 3.53463441e-02f, -2.21416820e-02f, 1.90176163e-02f, 6.64168000e-02f, -3.78751718e-02f, -7.71908909e-02f,
  3.25968675e-02f, -7.44320303e-02f, -6.36424944e-02f, 2.33817585e-02f, -1.27062080e-02f, -5.10647744e-02f, 2.51821466e-02f, 2.34436654e-02f, 1.57571770e-02f, 8.54321048e-02f,
  -1.00857206e-02f, -6.00915924e-02f, 4.73347977e-02f, -1.54710114e-02f, 7.50065595e-02f, -5.10146543e-02f, -3.34328599e-02f, -2.59144455e-02f, -1.08137503e-02f, -5.12638018e-02f,
  -1.30198926e-01f, 5.73747605e-03f, 1.02890164e-01f, -5.55317802e-03f, -2.95936447e-02f, -5.65231666e-02f, -2.46207014e-01f, 2.84175985e-02f, -2.51255333e-01f, -9.90858749e-02f,
  -8.41250196e-02f, -1.40944734e-01f, 9.52539616e-04f, 1.01419659e-02f, 9.08483118e-02f, 9.66499150e-02f, 9.03526172e-02f, -3.78158428e-02f, 7.24951550e-02f, 1.42563343e-01f,
  2.35723495e-01f, 2.32447326e-01f, 3.00509334e-01f, 3.09685796e-01f, 1.50336027e-01f, 1.43122628e-01f, 7.81075954e-02f, 9.24550965e-02f, 6.52035102e-02f, 9.56694856e-02f,
  -7.24948421e-02f, -4.39456105e-02f, 3.91094573e-02f, -5.49477786e-02f, 1.37388110e-01f, -6.89098537e-02f, -4.87425476e-02f, -5.51071353e-02f, 1.58924423e-02f, -3.07975300e-02f,
  -6.62329374e-03f, 3.41305882e-02f, 3.44685540e-02f, 2.64754100e-03f, 2.00996571e-03f, -2.24849284e-02f, 4.32564411e-03f, -2.81561203e-02f, 4.81407717e-03f, -1.51802767e-02f,
  -2.91026160e-02f, -4.00925055e-02f, 5.87144494e-02f, -1.50864357e-02f, 4.62166369e-02f, -1.13936305e-01f, 1.02814138e-02f, 1.80381350e-02f, 3.72732691e-02f, 2.05840766e-02f,
  4.46046926e-02f, -1.59701016e-02f, 5.79933077e-02f, -9.51020122e-02f, 6.63195476e-02f, -5.39854122e-03f, -3.94831076e-02f, 6.48192614e-02f, -3.62342633e-02f, 5.97364716e-02f,
  8.80796369e-03f, -2.07259040e-02f, -5.18306792e-02f, -1.65056158e-02f, 1.89645551e-02f, -1.93232130e-02f, 2.34920587e-02f, 8.38398635e-02f, -2.88761780e-02f, 7.94693977e-02f,
  3.77300791e-02f, -1.13031240e-02f, -1.00246752e-02f, -6.57207146e-02f, -5.88226272e-03f, -7.41264522e-02f, 7.14270249e-02f, -4.88054901e-02f, 9.15312096e-02f, 1.43301208e-02f,
  1.48815557e-01f, 1.51195914e-01f, 6.93609938e-02f, 5.83814420e-02f, 1.23349413e-01f, 1.14999097e-02f, 4.12593111e-02f, 7.48110861e-02f, 3.83437350e-02f, 7.74086267e-02f,
  6.90042675e-02f, 4.60433774e-03f, -3.02329268e-02f, 4.21969295e-02f, -1.01814987e-02f, 6.11948222e-02f, -2.81040594e-02f, -6.65973648e-02f, -1.11948904e-02f, 5.76424524e-02f,
  3.38922292e-02f, 2.60414518e-02f, -6.95965067e-02f, 7.29751121e-03f, -2.73840204e-02f, -1.12139492e-03f, -5.59973903e-02f, -9.92219150e-03f, -5.30515052e-03f, 1.73588395e-02f,
  1.74686909e-01f, -1.42651066e-01f, -9.59124193e-02f, -9.18356329e-03f, -2.48126611e-02f, -6.60896897e-02f, -1.35381132e-01f, -1.10171996e-01f, 9.12156776e-02f, -3.00700754e-01f,
  -1.25881866e-01f, -1.03816718e-01f, 1.15140257e-02f, -2.26580620e-01f, 1.47990569e-01f, 9.00510028e-02f, -9.17019472e-02f, -1.94301799e-01f, -1.19289998e-02f, -1.98829547e-01f,
  -8.52207188e-03f, -1.23153038e-01f, -3.01226322e-02f, -2.80213743e-01f, -2.08426327e-01f, -8.65096506e-03f, -6.97852969e-02f, -5.83194755e-02f, -9.81085226e-02f, -1.15524262e-01f,
  2.93486081e-02f, 7.45579973e-02f, 2.98967212e-02f, -5.16064949e-02f, -6.57039359e-02f, -4.10452075e-02f, -1.79426298e-02f, -1.09851146e-02f, 6.35943487e-02f, 6.86014518e-02f,
  -6.77329749e-02f, -9.30938944e-02f, -1.12568997e-02f, -1.97072271e-02f, 1.04665579e-02f, -4.16181013e-02f, 9.02887657e-02f, 2.78120637e-02f, -7.88348764e-02f, -5.56311645e-02f,
  -5.63071743e-02f, 2.62815822e-02f, 5.00381328e-02f, -8.58712792e-02f, 3.74652296e-02f, -5.99401742e-02f, -2.39622016e-02f, -7.73958042e-02f, 6.38974383e-02f, -4.27189432e-02f,
  -1.33491784e-01f, -5.85814267e-02f, 5.47221079e-02f, -5.64917736e-02f, 4.46824245e-02f, -4.12444696e-02f, 6.33879602e-02f, 2.80317254e-02f, -4.25392501e-02f, -6.37201816e-02f,
  7.26014674e-02f, -6.93723559e-02f, -5.21996617e-02f, -6.13338277e-02f, -6.43980084e-03f, 4.60716002e-02f, 3.77346426e-02f, -3.38575765e-02f, -6.87771523e-03f, 3.66782472e-02f,
  -2.79042311e-03f, 5.55544458e-02f, -9.28955302e-02f, 2.73025651e-02f, -5.99904917e-02f, 3.84809971e-02f, 3.85236852e-02f, -3.09351403e-02f, 9.78345647e-02f, 3.29602249e-02f,
  -4.04151343e-02f, -8.41800645e-02f, -5.92114292e-02f, 1.49833374e-02f, -6.13491349e-02f, -1.79426782e-02f, -1.97085086e-02f, -3.95708047e-02f, 2.01414730e-02f, 4.43425961e-02f,
  -4.76168096e-02f, 1.27236415e-02f, -6.27866834e-02f, -3.50849852e-02f, -5.58168292e-02f, -5.29076271e-02f, -6.21901602e-02f, -1.56902580e-03f, -6.75676763e-02f, -8.86464678e-03f,
  -9.71057862e-02f, 4.29724380e-02f, -3.78517695e-02f, -4.76703718e-02f, 4.77781743e-02f, 3.80451120e-02f, -2.32402068e-02f, -5.13862167e-03f, -3.43095548e-02f, 3.63635272e-02f,
  2.40602732e-01f, 6.43194243e-02f, -1.02827586e-01f, 3.44481990e-02f, -4.89870757e-02f, 4.35064845e-02f, 7.06497347e-03f, -5.28765433e-02f, -1.20159328e-01f, 6.30245954e-02f,
  -2.77647097e-02f, 1.39115721e-01f, 5.63954525e-02f, 1.41043022e-01f, 1.74247488e-01f, 2.31352467e-02f, 9.58484039e-02f, -4.93021011e-02f, 4.94370644e-04f, 1.84476823e-01f,
  1.01355493e-01f, 1.52647465e-01f, 1.36356121e-02f, 6.36246353e-02f, -3.21856998e-02f, -8.96382853e-02f, 1.06192872e-01f, -5.87332509e-02f, -9.04349796e-03f, -4.62428182e-02f,
  9.35552671e-05f, 1.22907944e-01f, 5.84685691e-02f, 3.54047194e-02f, 4.22824882e-02f, -4.83159758e-02f, 2.47975420e-02f, -6.48988485e-02f, -1.38143159e-03f, 5.46421204e-03f,
  -2.20426992e-02f, -2.60096304e-02f, 7.93571249e-02f, 6.72639981e-02f, -1.42445527e-02f, -3.95954512e-02f, -9.11339298e-02f, 9.88709368e-03f, -1.41024403e-02f, -1.40843391e-02f,
  -2.09194701e-03f, 1.28777390e-02f, -1.26399091e-02f, 3.03700380e-02f, -3.87126803e-02f, -5.32298759e-02f, 2.39500180e-02f, 8.70945826e-02f, -4.09433879e-02f, 9.92785245e-02f,
  8.18678141e-02f, 1.02699827e-03f, -1.89173259e-02f, -7.09980726e-02f, 4.81526181e-02f, 2.07934603e-02f, -8.61668885e-02f, -5.01891859e-02f, 1.66633807e-03f, 5.29074334e-02f,
  -3.39315343e-03f, -4.36902642e-02f, 5.60336374e-02f, -3.35152671e-02f, 1.83736552e-02f, -4.53093871e-02f, 1.58232320e-02f, -7.94767067e-02f, -1.06541842e-01f, -9.94330421e-02f,
  -6.78287596e-02f, -2.10389141e-02f, -3.66065614e-02f, 5.52051477e-02f, 9.33460984e-03f, 1.25014521e-02f, -2.78493464e-02f, 8.98009017e-02f, 6.37623444e-02f, -5.28749404e-03f,
  -2.04060171e-02f, 2.67438650e-01f, -7.31738955e-02f, 5.28231123e-03f, 8.46727267e-02f, 4.83094482e-03f, 6.28115833e-02f, 9.06950459e-02f, -3.60934325e-02f, 1.19385667e-01f,
  -2.06328053e-02f, 2.85946038e-02f, -1.49196144e-02f, 1.40660144e-02f, -2.89769471e-02f, 1.14032507e-01f, -1.31708542e-02f, 7.56251514e-02f, -2.46419269e-03f, -5.93269393e-02f,
  3.63692790e-02f, 3.64070572e-02f, 3.11074909e-02f, 1.05994279e-02f, 7.42982998e-02f, -8.12183619e-02f, -6.13464303e-02f, -4.87448834e-03f, 1.52932759e-02f, -7.75719732e-02f,
  -5.76907061e-02f, 1.01866806e-02f, 3.54387432e-01f, 4.61967662e-02f, 2.15769574e-01f, 3.33297580e-01f, 3.43996435e-01f, 1.40521243e-01f, 1.94095924e-01f, -3.26596260e-01f,
  -1.43865168e-01f, -3.70042101e-02f, 5.15893921e-02f, 1.25932060e-02f, 2.81961322e-01f, 6.71972260e-02f, 8.63061249e-02f, -3.54562700e-02f, 2.61000305e-01f, -8.73159394e-02f,
  3.07377353e-02f, -1.83891326e-01f, -5.37600033e-02f, -1.74878553e-01f, -1.03789315e-01f, -1.54590175e-01f, -1.33079931e-01f, 2.44503051e-01f, -1.98425069e-01f, 7.34405145e-02f,
  5.65664880e-02f, -6.80597872e-02f, -7.55831450e-02f, 4.20483761e-02f, 2.68482836e-03f, -4.67501394e-02f, 6.77284002e-02f, -1.18724601e-02f, 1.74974464e-02f, 2.98274048e-02f,
  -3.62888053e-02f, -1.21237533e-02f, -7.66703114e-02f, 6.91485479e-02f, 3.68966870e-02f, -4.76115569e-02f, -7.10435659e-02f, 2.73890477e-02f, -4.12802435e-02f, -1.01378672e-02f,
  -2.45979447e-02f, 6.45387322e-02f, -4.15660292e-02f, -2.18536356e-03f, -2.59507797e-03f, 1.02780769e-02f, 5.57032041e-02f, 6.02073632e-02f, 4.14455235e-02f, 4.58961166e-02f,
  2.66814195e-02f, 4.47490327e-02f, 1.23737277e-02f, -5.60447127e-02f, 3.50190997e-02f, -2.65157372e-02f, 1.50758130e-02f, -8.50891024e-02f, -3.71998511e-02f, 1.98051687e-02f,
  9.32555553e-03f, 2.37849243e-02f, 3.32499519e-02f, 4.20575626e-02f, -4.05690866e-03f, -6.51943088e-02f, -3.80500443e-02f, -9.60706640e-03f, -8.68712142e-02f, -3.26684639e-02f,
  -4.42629606e-02f, -1.74203026e-03f, -7.41235688e-02f, 1.89130697e-02f, 1.03165463e-01f, 7.49128759e-02f, -5.13863601e-02f, 7.13375909e-03f, 5.14128292e-03f, 1.17736096e-02f,
  8.11773986e-02f, 6.31952435e-02f, 4.71906066e-02f, 8.29023682e-03f, 1.19895150e-03f, -9.59554315e-02f, 7.06294328e-02f, 2.06416789e-02f, 6.29560426e-02f, -6.59756437e-02f,
  -5.12506664e-02f, -1.07464179e-01f, -5.42564876e-02f, 1.00875343e-03f, 3.52384523e-02f, -9.83267576e-02f, 2.79012080e-02f, -2.84656812e-03f, 6.36931062e-02f, -6.44029155e-02f,
  -1.30590007e-01f, -4.57493812e-02f, -5.23480847e-02f, -1.49708003e-01f, -3.81766520e-02f, -6.46827696e-03f, -3.51670831e-02f, -1.09293293e-02f, -3.64964977e-02f, -5.37879672e-03f,
  7.31575787e-02f, -1.21903077e-01f, -1.65986136e-01f, -1.62537247e-01f, -1.30988389e-01f, -3.22837085e-01f, -2.35498801e-01f, -2.53278226e-01f, -3.41294594e-02f, -1.90980181e-01f,
  -1.13708600e-01f, -4.84073395e-03f, 2.07939446e-01f, -3.60454440e-01f, 1.46951333e-01f, 2.23617852e-01f, -3.20227325e-01f, -1.32715940e-01f, 3.29773361e-03f, -2.69668341e-01f,
  -1.12082630e-01f, -1.94704965e-01f, -9.93377268e-02f, -2.44471997e-01f, -1.83483839e-01f, -1.69498399e-01f, 3.45494859e-02f, -3.02076358e-02f, -1.88402638e-01f, -1.06692100e-02f,
  -5.93769848e-02f, 1.79167818e-02f, 2.51564160e-02f, -3.00263595e-02f, -8.64550173e-02f, -7.64859915e-02f, -9.43377614e-03f, 2.86487658e-02f, 4.03503664e-02f, 5.34503907e-02f,
  1.54446289e-02f, 8.91199410e-02f, -9.58972871e-02f, 5.84265888e-02f, -6.61900863e-02f, -8.71165246e-02f, -3.09788231e-02f, -3.33480835e-02f, -6.17641304e-03f, 6.93525150e-02f,
  1.51255801e-02f, 4.77758944e-02f, -5.73877580e-02f, -5.07519860e-03f, -7.89807644e-03f, 1.28049608e-02f, -1.27553167e-02f, 8.02559033e-02f, -1.17769372e-02f, 1.05941342e-02f,
  -6.32093176e-02f, 3.09832506e-02f, 1.80008281e-02f, -3.18702161e-02f, 1.34964837e-02f, -6.36371449e-02f, -7.82781988e-02f, -5.56313992e-02f, 4.45239693e-02f, 5.46422740e-03f,
  -7.86420330e-02f, -3.02825053e-03f, 1.69982277e-02f, -9.65701267e-02f, -1.69962482e-03f, 5.80740906e-03f, 5.55836335e-02f, 5.93255311e-02f, 5.16625354e-03f, -3.89013183e-03f,
  -4.25612703e-02f, 3.01485769e-02f, -2.62963236e-03f, -3.83632667e-02f, 5.02539948e-02f, 7.59144425e-02f, -4.96284552e-02f, -1.21063320e-02f, -5.25312573e-02f, -5.35513349e-02f,
  -1.03322364e-01f, -1.89462945e-01f, -6.40075430e-02f, 7.03926459e-02f, -3.93267628e-03f, -6.38461858e-02f, -4.16583791e-02f, -6.59106970e-02f, -2.47648149e-03f, 3.06985760e-03f,
  -3.32089663e-02f, -1.36180921e-02f, 3.61368619e-02f, 7.06946626e-02f, -5.53681003e-03f, -1.17059484e-01f, -7.69267455e-02f, 6.85909465e-02f, 2.24438366e-02f, -3.49155888e-02f,
  -6.81796893e-02f, -3.10692098e-02f, 6.33241311e-02f, -3.08967736e-02f, 3.13234772e-03f, 2.77472660e-04f, 7.99965486e-02f, 7.03999698e-02f, 6.32875487e-02f, -2.13921387e-02f,
  1.05949841e-01f, 2.15996131e-01f, 5.03156371e-02f, 1.04126735e-02f, 4.21182141e-02f, -1.28199935e-01f, -2.63287611e-02f, 4.45320494e-02f, -8.79170895e-02f, 6.71568811e-02f,
  1.81065984e-02f, 2.10986987e-01f, -1.05583526e-01f, -5.51715158e-02f, -4.47194695e-01f, -3.10902894e-01f, -1.76024616e-01f, 3.54688568e-03f, -1.42145887e-01f, 9.70167816e-02f,
  -9.06880125e-02f, -1.50889546e-01f, -1.19270988e-01f, 2.65987273e-02f, 1.73997506e-01f, 1.38210431e-01f, 5.68742007e-02f, 9.70521122e-02f, 1.14731066e-01f, -6.28546849e-02f,
  -4.12833616e-02f, -1.59076955e-02f, 3.06712687e-02f, -1.24664688e-02f, -7.09628537e-02f, 1.25349164e-01f, 1.09125204e-01f, -1.06923707e-01f, -8.72901455e-02f, -3.14857215e-02f,
  1.06963478e-01f, -6.05158322e-02f, -1.40208770e-02f, 3.42925563e-02f, -3.18914466e-02f, 1.30030200e-01f, 2.04640534e-02f, 4.73936349e-02f, -3.63419838e-02f, 1.23384185e-02f,
  7.81987533e-02f, 1.33396596e-01f, 9.81996730e-02f, 4.24492434e-02f, 4.28715348e-02f, -3.75930741e-02f, -3.25561948e-02f, 9.14954767e-02f, 1.68771893e-02f, 3.30109037e-02f,
  1.18582938e-02f, 3.52969230e-03f, -8.27844292e-02f, -1.79825593e-02f, 3.52715068e-02f, 5.78580052e-02f, -2.13816278e-02f, 5.38026989e-02f, -8.61412473e-03f, -3.04906797e-02f,
  2.66407747e-02f, -1.79093219e-02f, -6.49216771e-02f, 6.55084997e-02f, -1.59898377e-03f, 2.21147146e-02f, 1.02935880e-02f, -5.39712273e-02f, 5.02624810e-02f, 4.13512625e-02f,
  -7.05320612e-02f, -6.45366907e-02f, -4.20578085e-02f, -3.60858217e-02f, -3.51055488e-02f, -2.61389967e-02f, 3.94682726e-03f, -3.59203368e-02f, 4.86349724e-02f, 2.83144563e-02f,
  4.07216884e-03f, 8.21284726e-02f, 1.20353967e-01f, 3.26303951e-02f, -8.02118257e-02f, -1.91261712e-02f, -5.99786304e-02f, 5.00654206e-02f, 6.47346526e-02f, 2.24647913e-02f,
  9.28905159e-02f, 1.80149116e-02f, 2.61406396e-02f, 4.56746109e-03f, -7.25047961e-02f, -2.03054082e-02f, -4.79099825e-02f, 8.15142319e-02f, -1.68803521e-02f, 3.08755524e-02f,
  2.49475855e-02f, -2.50130612e-02f, -1.18580433e-02f, -4.80908863e-02f, 3.60780656e-02f, 3.12142447e-02f, 8.06513280e-02f, 1.32373497e-02f, 8.49340484e-02f, 3.06930672e-02f,
  -1.84011117e-01f, 7.67331943e-02f, -7.10278824e-02f, -2.78146397e-02f, 1.34318292e-01f, 7.01478347e-02f, 9.91249755e-02f, 7.20890565e-03f, 1.11840889e-02f, 2.42039770e-01f,
  8.99560228e-02f, -1.06157146e-01f, 3.26319365e-03f, -1.09951630e-01f, -7.84070864e-02f, -7.21406490e-02f, 1.30538568e-01f, 6.94395155e-02f, -1.30679989e-02f, 2.25429267e-01f,
  1.36316475e-02f, 5.10883480e-02f, -1.26882628e-01f, 1.28489375e-01f, -4.05340046e-02f, 8.49968195e-02f, 2.40334690e-01f, -3.41342278e-02f, 2.34612804e-02f, -7.74919838e-02f,
  -9.17911828e-02f, -9.37171653e-02f, -1.18170582e-01f, -8.54606554e-02f, 2.34110076e-02f, 1.84820853e-02f, 5.83831817e-02f, -1.06449351e-01f, 1.57808943e-03f, -1.81155354e-02f,
  7.15441853e-02f, -1.22595713e-01f, -8.98141563e-02f, -9.21930373e-02f, -7.37972558e-02f, 5.57103707e-03f, 3.86210419e-02f, -8.06976333e-02f, -9.20246765e-02f, -3.78791913e-02f,
  -7.90729299e-02f, 1.13304563e-01f, 1.31934240e-01f, -2.40244232e-02f, -8.08763281e-02f, -5.29619073e-03f, 4.21402752e-02f, -2.48883404e-02f, 1.53472712e-02f, 8.75160247e-02f,
  6.46746829e-02f, 9.17261243e-02f, 7.51382187e-02f, -9.06215832e-02f, -5.81344627e-02f, 7.43850097e-02f, -1.78583246e-02f, 1.78030785e-02f, 3.92549187e-02f, -4.84741246e-03f,
  6.82994649e-02f, 6.16950076e-03f, 2.40307003e-02f, 1.81288067e-02f, -2.57306006e-02f, 7.38724694e-02f, 6.02844022e-02f, 5.44470958e-02f, 8.45152885e-02f, -5.65709583e-02f,
  3.70663032e-02f, -5.18554114e-02f, 4.27998304e-02f, 2.00963253e-03f, 3.43299434e-02f, -4.79276516e-02f, 4.14773785e-02f, -7.05699110e-03f, -2.57483078e-03f, 3.08466218e-02f,
  2.56307453e-01f, 3.45943511e-01f, 4.86789597e-03f, -8.44146162e-02f, 6.75417483e-02f, 8.86781961e-02f, 1.29136795e-04f, 3.31145488e-02f, 1.13958143e-01f, 1.12110980e-01f,
  1.33397549e-01f, 6.32444173e-02f, 1.17645226e-01f, -3.17824483e-02f, 5.20551950e-02f, 3.95911932e-02f, 8.89277533e-02f, 7.42501840e-02f, 1.10617958e-01f, 1.03242733e-01f,
  7.15243518e-02f, 9.19865966e-02f, 9.67513013e-04f, 1.90168116e-02f, 7.86594599e-02f, 4.41442765e-02f, 3.14491056e-02f, 8.41982476e-03f, 1.91873293e-02f, 1.56328063e-02f,
  -5.46842590e-02f, -2.48649448e-01f, -3.24961008e-03f, -4.94955778e-02f, -1.53996482e-01f, -1.13784127e-01f, -2.67697107e-02f, -2.33964786e-01f, -1.01148985e-01f, -1.02694385e-01f,
  -1.34119298e-02f, 1.13112859e-01f, 2.46724546e-01f, -1.79223061e-01f, 3.16240758e-01f, 2.28702515e-01f, -8.56372342e-02f, 1.06675170e-01f, -3.24794613e-02f, -1.92951113e-01f,
  6.09730780e-02f, -1.62122145e-01f, 9.33601335e-02f, -1.63990974e-01f, -2.03760326e-01f, -5.48160560e-02f, 4.62686829e-02f, -4.00772505e-02f, -1.59613892e-01f, 8.86207726e-03f,
  -1.85661376e-01f, -1.43197060e-01f, -5.79973534e-02f, -1.38131334e-02f, -8.45675245e-02f, 5.36103286e-02f, -1.55742718e-02f, 5.10038361e-02f, 1.37907229e-02f, -1.06730215e-01f,
  8.26166943e-02f, -3.55964191e-02f, -7.29553849e-02f, 1.61070246e-02f, -2.84263045e-02f, -9.77939293e-02f, -6.81917295e-02f, 5.32868207e-02f, -6.33872822e-02f, -6.69988543e-02f,
  -5.75946495e-02f, -1.20328004e-02f, -1.94226857e-02f, 4.13484462e-02f, 9.02364030e-02f, -6.58274665e-02f, 9.36399847e-02f, 1.12330206e-01f, -7.21921623e-02f, -4.77568284e-02f,
  -8.63143802e-03f, 3.39412354e-02f, -5.49321920e-02f, -8.96844119e-02f, -4.12956700e-02f, 8.56449082e-03f, -5.67588806e-02f, 9.40250605e-02f, 3.48626226e-02f, -6.82114391e-03f,
  3.31420079e-02f, 2.68492252e-02f, -3.32505740e-02f, -1.95719004e-02f, 1.06663778e-02f, -5.49462065e-02f, -1.04797157e-02f, -6.98034391e-02f, -7.53423348e-02f, -1.14230104e-02f,
  6.64145574e-02f, -1.52755519e-02f, -5.38416766e-02f, 9.30801854e-02f, -6.51239902e-02f, 3.50404531e-02f, 1.62528716e-02f, 5.54890372e-02f, 2.55790018e-02f, 7.24548101e-02f,
  -2.05865771e-01f, -1.23155311e-01f, -8.14170316e-02f, -3.82621326e-02f, 6.97773248e-02f, 1.57073548e-03f, 7.98030943e-03f, 3.80833037e-02f, -4.62533943e-02f, -2.74070743e-02f,
  3.63647155e-02f, 7.43467733e-02f, 3.31222545e-03f, 2.56201718e-02f, 6.51732832e-02f, 1.60513204e-02f, 7.72691891e-02f, -4.37307497e-03f, 6.55257255e-02f, -2.44962722e-02f,
  -6.60499707e-02f, 2.14407477e-03f, 3.31590399e-02f, 7.38422796e-02f, 1.34559134e-02f, -9.18868650e-03f, 4.73216213e-02f, -3.27744260e-02f, 4.00864333e-02f, -8.11197609e-03f,
  -1.46548495e-01f, 7.25067854e-02f, 1.07259369e-02f, 7.69829229e-02f, -3.62908421e-03f, -7.54797310e-02f, -1.18478730e-01f, 7.88061395e-02f, -6.99684843e-02f, -4.40286566e-03f,
  8.37049559e-02f, -9.67769101e-02f, -3.39532904e-02f, 2.83585358e-02f, -1.90018886e-03f, 3.50433141e-02f, -4.45045531e-02f, -3.27397473e-02f, 3.94240580e-02f, 8.03390741e-02f,
  3.39406319e-02f, 7.65620396e-02f, 1.69087499e-01f, 1.32385284e-01f, 5.81117384e-02f, -3.14175361e-03f, 9.01691541e-02f, -3.40322182e-02f, 2.86321659e-02f, -9.36874300e-02f,
  6.42851517e-02f, 1.23849452e-01f, -8.98309648e-02f, -4.97172214e-02f, -1.94807760e-02f, -7.03121349e-02f, 6.00294471e-02f, 2.61235088e-02f, 7.54169375e-02f, 1.72517598e-02f,
  -1.05322875e-01f, -6.96410388e-02f, 5.63814640e-02f, 3.14567797e-02f, -3.22346240e-02f, 3.86120304e-02f, -6.36764765e-02f, 5.25969602e-02f, 6.63748682e-02f, -1.67233441e-02f,
  6.81637526e-02f, -7.25488290e-02f, -6.88342154e-02f, -2.02748850e-02f, -2.92955153e-02f, -5.30886799e-02f, 4.24854644e-03f, 9.85757913e-03f, -8.99493769e-02f, -4.64512175e-03f,
  5.80439568e-02f, 2.04846612e-03f, -8.25699568e-02f, -6.15582988e-02f, -9.61277038e-02f, 5.09622358e-02f, 1.76316276e-02f, -4.89515625e-02f, 6.51953369e-02f, -7.63238221e-02f,
  -9.47911572e-03f, 6.52986988e-02f, -4.13564108e-02f, -5.19164689e-02f, 6.29568193e-03f, 3.05765979e-02f, 7.02438429e-02f, -8.45979825e-02f, 4.59132306e-02f, 5.28265908e-02f,
  3.10874004e-02f, -6.45018294e-02f, -6.69621676e-02f, 3.42990123e-02f, -5.88841178e-02f, 3.27029750e-02f, 2.64608208e-02f, 6.00138791e-02f, 4.57459204e-02f, -6.28882945e-02f,
  1.01272263e-01f, 1.15399584e-01f, -7.30143115e-02f, -3.21127586e-02f, -1.78967249e-02f, -7.73747861e-02f, -4.12918068e-02f, 2.61468962e-02f, 6.10308647e-02f, -5.47812805e-02f,
  -3.02246660e-02f, 6.44069761e-02f, 3.76405716e-02f, -8.04831684e-02f, 8.66015181e-02f, -7.38569349e-02f, 9.78524312e-02f, 1.02708414e-02f, -2.99357204e-03f, 8.54388345e-03f,
  -5.40385470e-02f, 6.14846498e-02f, 2.96557602e-02f, 1.20050516e-02f, 4.57517393e-02f, -6.40337244e-02f, -2.16169674e-02f, 6.57224879e-02f, 4.05972451e-02f, 3.53024751e-02f,
  -7.94862583e-03f, -2.82422397e-02f, 5.60375452e-02f, 1.29335642e-01f, -8.52388218e-02f, 5.46191558e-02f, 2.23684892e-01f, -4.07938287e-02f, 3.55107367e-01f, -8.94166008e-02f,
  -1.98053300e-01f, -1.00312613e-01f, 1.07181430e-01f, -4.73648794e-02f, 1.56765684e-01f, 2.65746921e-01f, 1.83157325e-01f, 4.70600687e-02f, 1.17220953e-01f, -1.06218137e-01f,
  1.06078938e-01f, -2.48129070e-01f, -1.00680724e-01f, -2.88622528e-01f, -2.07018465e-01f, -1.52808964e-01f, -2.85740703e-01f, -1.14930436e-01f, -2.48222232e-01f, -8.37940425e-02f,
  1.48261979e-01f, -4.53110673e-02f, -1.42793447e-01f, 3.21884118e-02f, -1.28229512e-02f, -4.76966724e-02f, -5.77580323e-03f, 3.78956390e-03f, -3.50146554e-02f, 6.28990307e-02f,
  -5.38504459e-02f, -5.86280115e-02f, -4.14881948e-03f, 4.75953035e-02f, -4.08922881e-02f, 1.87981836e-02f, 1.17074186e-02f, -6.07093163e-02f, -7.31008872e-02f, 4.40770090e-02f,
  5.53331785e-02f, 5.67848096e-03f, 9.25906468e-03f, 5.05035706e-02f, 5.81117235e-02f, 7.57575687e-03f, 9.40198675e-02f, -7.13978782e-02f, -2.30143722e-02f, 4.29160520e-02f,
  -1.26647070e-01f, 6.92673847e-02f, 6.11560140e-03f, -5.17124459e-02f, 1.81397572e-02f, -5.75687829e-03f, 1.97064299e-02f, 6.97800890e-02f, 4.66500111e-02f, -1.71276387e-02f,
  -4.65189517e-02f, -9.02601257e-02f, -1.23818042e-02f, 4.23605517e-02f, -2.23062150e-02f, 5.81337959e-02f, -8.15738812e-02f, 7.04721212e-02f, 6.40441701e-02f, 9.00746603e-03f,
  -5.72828092e-02f, 4.76145446e-02f, -5.07856011e-02f, -3.47229466e-02f, -6.28833622e-02f, -1.45689100e-02f, -2.56240871e-02f, 1.67997163e-02f, 1.52826356e-02f, 3.02565075e-03f,
  1.60160542e-01f, 9.93505046e-02f, 9.21890959e-02f, 7.71049932e-02f, 3.83582525e-02f, 1.17429886e-02f, 8.03969044e-04f, 3.49301286e-02f, 9.25670415e-02f, 7.73979872e-02f,
  1.48168067e-02f, 8.57040361e-02f, -4.24216874e-02f, -6.79685697e-02f, -6.59108236e-02f, 5.06426543e-02f, 2.20286287e-02f, -4.14488241e-02f, -5.48627377e-02f, -1.09200336e-01f,
  -1.07806781e-02f, 8.77202451e-02f, 7.12926164e-02f, 1.85062513e-02f, -5.55504523e-02f, -2.36661751e-02f, 2.75844280e-02f, -1.74398199e-02f, -2.74472255e-02f, 3.94712463e-02f,
  -1.57500446e-01f, -3.73165607e-01f, 9.19711217e-03f, 3.67553090e-04f, 1.60236001e-01f, 6.76264390e-02f, 2.14999497e-01f, -1.49960265e-01f, -3.89955580e-01f, -2.00387180e-01f,
  1.16343834e-01f, -1.17892414e-01f, -7.11219832e-02f, -1.96997344e-01f, 1.76404536e-01f, -1.27063513e-01f, -1.85355708e-01f, 4.55662087e-02f, -7.41604418e-02f, -3.36929522e-02f,
  -7.20306113e-02f, 1.22447543e-01f, 8.08914080e-02f, 1.96600761e-02f, 6.37776405e-02f, -5.36276475e-02f, 1.41080335e-01f, 1.79550201e-01f, 1.32468402e-01f, 1.76673502e-01f,
  -5.83212823e-02f, -1.33501709e-01f, -1.64713450e-02f, 3.32904980e-02f, 5.30261360e-02f, 4.43396345e-02f, 1.63300373e-02f, 1.20640203e-01f, 9.60684940e-02f, 5.63636571e-02f,
  4.37417030e-02f, 4.35174778e-02f, -5.48552945e-02f, 1.93432197e-02f, -5.18198572e-02f, -7.83939883e-02f, -1.06623150e-01f, -2.39312332e-02f, 5.72198257e-03f, -2.66540200e-02f,
  -2.01332886e-02f, -4.92501520e-02f, 1.77494455e-02f, -3.39293666e-02f, -8.72957055e-03f, -4.99084108e-02f, 9.19853151e-02f, 5.73842786e-02f, -5.03056012e-02f, 1.00142229e-02f,
  4.22229394e-02f, 7.38156736e-02f, -8.86711553e-02f, -9.74640548e-02f, -5.24331331e-02f, -1.56548228e-02f, -2.63106879e-02f, -6.44418374e-02f, -1.05472682e-02f, 3.90978567e-02f,
  -6.94249794e-02f, 2.94898283e-02f, 4.05106805e-02f, -4.40416411e-02f, -6.08289726e-02f, -3.37853953e-02f, -1.56275276e-02f, 1.20945452e-02f, 5.96839190e-02f, -5.52332178e-02f,
  4.48877923e-02f, -4.30786051e-02f, -4.06399928e-02f, 1.48344021e-02f, -1.43037774e-02f, 3.58348154e-02f, 3.65016498e-02f, -5.23397438e-02f, 2.75246687e-02f, 4.29937467e-02f,
  -7.88766146e-02f, -7.95734823e-02f, -6.53933808e-02f, -1.60628371e-02f, -8.23932961e-02f, -2.14277487e-02f, -4.55982126e-02f, -3.25670056e-02f, -7.83227682e-02f, -2.58238316e-02f,
  -2.20947023e-02f, 9.97969434e-02f, 1.14070461e-03f, 1.46518182e-02f, 2.67906114e-02f, 2.70780697e-02f, 7.14512765e-02f, 1.86616182e-02f, -7.04014078e-02f, -2.05894541e-02f,
  6.89594671e-02f, -2.57593561e-02f, 6.99930415e-02f, -1.79414228e-02f, -3.66597883e-02f, -4.43583466e-02f, 1.81465428e-02f, 3.94836888e-02f, 9.90963206e-02f, -1.06266746e-02f,
  -1.37368992e-01f, -3.10449868e-01f, -1.72316447e-01f, -8.37602746e-03f, 1.23150557e-01f, 1.50446638e-01f, -1.11603558e-01f, -6.80194050e-02f, -1.35963082e-01f, -7.15360492e-02f,
  -1.21456161e-01f, -1.66488305e-01f, -3.70264828e-01f, -2.09515495e-03f, -1.25111461e-01f, -3.85302424e-01f, 7.42993727e-02f, -1.05643049e-01f, -1.91452801e-01f, 1.33016449e-03f,
  -1.91908295e-03f, 7.15271160e-02f, -3.59108374e-02f, 2.50517756e-01f, 1.01216681e-01f, 2.10491687e-01f, 2.14792699e-01f, 7.02434555e-02f, 2.65522867e-01f, 4.23493981e-02f,
  4.60006110e-02f, -2.17857286e-01f, -1.16055459e-02f, 7.25940168e-02f, -4.49154340e-02f, 7.30012134e-02f, 1.46352008e-01f, 6.79725334e-02f, 6.89035356e-02f, -6.05012551e-02f,
  -1.11160260e-02f, -2.41319910e-02f, 9.78373587e-02f, 3.24743465e-02f, 6.25413805e-02f, -1.68546569e-02f, -3.44036408e-02f, -8.58767016e-04f, -3.31084393e-02f, -7.71145895e-02f,
  -1.03422822e-02f, 3.37844566e-02f, 1.53027764e-02f, 7.88387507e-02f, 4.26755548e-02f, 8.02621692e-02f, 1.61255356e-02f, -7.15826731e-03f, 3.16129928e-03f, -4.54730988e-02f,
  4.30052467e-02f, 5.81373349e-02f, 3.35282758e-02f, -1.35672456e-02f, -6.61126012e-03f, 4.37297933e-02f, 1.72359142e-02f, 3.11852582e-02f, 2.85166549e-03f, -4.18337947e-03f,
  1.33559220e-02f, 7.38869756e-02f, -1.96353011e-02f, 9.70954224e-02f, -2.66822241e-02f, -7.48098344e-02f, 3.84051427e-02f, -2.64526121e-02f, -3.38606373e-03f, -2.76891105e-02f,
  1.43628279e-02f, 3.93769378e-03f, 4.60449979e-02f, 8.52421522e-02f, 1.39685682e-04f, 4.96878438e-02f, 1.53419347e-02f, 1.44819403e-02f, -7.67459860e-03f, 2.34031659e-02f,
  -7.33807264e-03f, -6.57616695e-03f, -4.34000455e-02f, 1.52682504e-02f, 5.79633713e-02f, -1.39581719e-02f, -6.87087793e-03f, -3.62489633e-02f, -6.11796305e-02f, 9.31887701e-03f,
  1.19079895e-01f, 1.25193059e-01f, 5.06394245e-02f, -1.86901947e-03f, 5.48190176e-02f, -8.64810571e-02f, 3.41632217e-02f, 9.31360349e-02f, 1.18301712e-01f, -3.12872343e-02f,
  2.10262910e-02f, 1.08444296e-01f, -2.67801043e-02f, 1.01381063e-01f, 2.98536979e-02f, 4.62775603e-02f, 5.23587465e-02f, -4.69495682e-03f, -3.45164463e-02f, -3.66045013e-02f,
  2.38203958e-01f, 7.41726458e-02f, -5.51542714e-02f, -9.61942226e-02f, -2.37876549e-02f, 1.31923825e-01f, -5.59392525e-03f, -2.96703633e-02f, -2.74883825e-02f, -5.00082783e-02f,
  -6.18271530e-02f, 5.92424953e-03f, 2.14566402e-02f, -3.15862931e-02f, 6.97539821e-02f, 9.03759748e-02f, -6.46986663e-02f, 7.77512714e-02f, -6.54232875e-02f, 2.30336357e-02f,
  -5.90353459e-02f, 1.28895357e-01f, -1.98887810e-02f, -2.19390541e-02f, 2.79070213e-02f, -2.26793680e-02f, -1.11275807e-01f, 9.35682096e-03f, 1.41367968e-03f, 7.46361539e-02f,
  1.09484002e-01f, 5.87178729e-02f, 8.39286968e-02f, 4.29177843e-02f, 3.67356837e-02f, 3.66375372e-02f, -7.44413063e-02f, 1.68980267e-02f, 4.99097854e-02f, -3.90856434e-03f,
  -6.83201551e-02f, -2.67926976e-02f, 6.31195903e-02f, -2.77848709e-02f, 6.43732995e-02f, -9.11891907e-02f, -3.21976654e-02f, -1.16729140e-01f, -7.50017464e-02f, 1.03206657e-01f,
  -1.96606684e-02f, 2.55545974e-02f, 7.15302154e-02f, -7.57595822e-02f, -6.08458221e-02f, -5.51877404e-03f, -7.50181898e-02f, 6.75650984e-02f, -9.99804884e-02f, -6.97568655e-02f,
  1.21038727e-01f, -7.18474314e-02f, -6.25728071e-03f, -6.21242374e-02f, -4.14244309e-02f, -7.59412572e-02f, -4.69403900e-02f, 7.73539618e-02f, 6.31951988e-02f, 8.43997765e-03f,
  -6.90130144e-02f, -5.74009754e-02f, -4.69730236e-02f, 3.96104716e-02f, -4.06974927e-02f, 9.32660773e-02f, 6.79998174e-02f, -6.75604790e-02f, -1.20676398e-01f, -8.14443827e-02f,
  6.05513565e-02f, -4.63101603e-02f, -4.87121157e-02f, -7.88220391e-03f, 7.48982280e-02f, -1.08409412e-02f, 3.63566019e-02f, 3.36696766e-02f, -3.82314660e-02f, 4.90988605e-02f,
  -1.02269389e-02f, 5.94235659e-02f, -6.19121119e-02f, -6.54174611e-02f, 1.91501155e-02f, 8.30108393e-03f, 4.37338836e-02f, -2.58697737e-02f, -1.93439033e-02f, 5.21017530e-04f,
  -9.80784297e-02f, 2.41761021e-02f, -7.08315000e-02f, 7.69966394e-02f, -4.79204347e-03f, 3.52045484e-02f, -6.83380440e-02f, -3.15292925e-02f, -1.60771515e-02f, 7.41521493e-02f,
  6.58017620e-02f, 7.77806714e-02f, -3.10372915e-02f, -8.84367898e-02f, -6.83702976e-02f, -4.07559797e-02f, 9.47216600e-02f, -2.92463582e-02f, 3.14351022e-02f, -8.27878527e-03f,
  -2.87721425e-01f, -1.90215692e-01f, -2.05810189e-01f, -1.77607052e-02f, -1.66378483e-01f, -5.86594641e-02f, 8.58755857e-02f, -2.82087356e-01f, -4.46755365e-02f, 1.08657405e-01f,
  5.21252342e-02f, -1.04708867e-02f, 1.10468030e-01f, 2.05670893e-01f, -4.93145827e-03f, 1.52583674e-01f, 1.96890414e-01f, 2.08142519e-01f, -4.92338762e-02f, -1.43835008e-01f,
  -5.81553616e-02f, -2.54255161e-02f, 1.40179053e-01f, -1.91365674e-01f, -1.24973103e-01f, 1.32137910e-02f, 1.69263280e-03f, -9.80849117e-02f, 1.04196891e-01f, -1.18385322e-01f,
  9.16420072e-02f, 5.37913665e-03f, -6.33353665e-02f, -4.00920883e-02f, -6.26833551e-03f, 6.47618622e-02f, 1.10872433e-01f, -4.60775904e-02f, 5.53406216e-02f, 2.93671768e-02f,
  -7.65260160e-02f, 4.56181392e-02f, 1.48351109e-02f, 5.28703742e-02f, -8.57923701e-02f, -9.16296709e-03f, -1.79611938e-03f, -5.99864237e-02f, -2.61612851e-02f, -7.28926882e-02f,
  -2.30890363e-02f, -2.71761250e-02f, -1.91155786e-03f, 3.61878313e-02f, 4.61255684e-02f, 3.10845468e-02f, 1.05140798e-01f, -7.37927034e-02f, 3.77554148e-02f, -4.48879525e-02f,
  -7.52697513e-02f, -4.59869988e-02f, -9.18360893e-03f, 7.49620497e-02f, -3.23928632e-02f, 6.66163687e-04f, -7.02218115e-02f, -2.67966185e-02f, -3.09816562e-02f, 3.09711974e-02f,
  2.05497537e-03f, 2.55497452e-02f, -3.66983041e-02f, 6.29255325e-02f, -8.86071995e-02f, 1.12550799e-02f, -1.62016973e-02f, -5.56185767e-02f, -2.86351647e-02f, -5.07441303e-03f,
  1.02530703e-01f, -6.48636520e-02f, 3.63590755e-02f, 1.01694852e-01f, 4.84468304e-02f, -1.32011659e-02f, -6.86756670e-02f, 1.24450785e-03f, 1.24789225e-02f, 6.22730963e-02f,
  9.00814086e-02f, -1.68084711e-01f, -3.08976192e-02f, -9.15953144e-03f, 1.19205983e-02f, -1.16692536e-01f, 2.64233146e-02f, -7.39431828e-02f, -1.91596467e-02f, -3.81803066e-02f,
  -5.58281802e-02f, -8.97174608e-03f, -8.29431564e-02f, -4.70989309e-02f, 5.17555512e-02f, 1.15790823e-02f, 6.91732168e-02f, 1.02382079e-01f, -3.42526957e-02f, -3.70017253e-02f,
  -2.87478659e-02f, 6.24545440e-02f, 3.63847874e-02f, -7.89589714e-03f, 7.12453574e-02f, 4.28543203e-02f, -9.68020335e-02f, -6.45914301e-02f, -7.93619975e-02f, 1.17058139e-02f,
  -1.04457531e-02f, -3.76578033e-01f, -2.29667604e-01f, 1.09220468e-01f, 2.53044069e-01f, 2.21158206e-01f, 1.84830613e-02f, 4.75778952e-02f, -4.88087833e-02f, -2.03250363e-01f,
  1.12057582e-01f, 9.64018516e-03f, -1.87052473e-01f, 1.79370105e-01f, 1.82618126e-01f, -1.18731029e-01f, 1.64643690e-01f, 9.12294090e-02f, -3.33675630e-02f, 1.42466286e-02f,
  5.77418916e-02f, 2.64675468e-01f, -8.23698267e-02f, 1.66783527e-01f, 1.60800457e-01f, -1.45424055e-02f, 9.81290713e-02f, -1.15573525e-01f, 2.32600763e-01f, 1.88352779e-01f,
  1.24888476e-02f, -9.01259780e-02f, -5.55494912e-02f, -2.56315693e-02f, 3.41152633e-03f, -8.72666314e-02f, -5.08435490e-03f, -2.47467626e-02f, 5.16360514e-02f, 5.82075529e-02f,
  1.89989861e-02f, 4.40291502e-02f, 4.01856489e-02f, 6.90268213e-03f, 7.64115751e-02f, 1.17111672e-02f, -4.18906696e-02f, -7.89518803e-02f, -7.66305551e-02f, -4.76216991e-03f,
  -1.43457865e-02f, 3.63438763e-02f, 2.06810441e-02f, -2.15653200e-02f, 4.93226461e-02f, -2.98233908e-02f, -2.68245060e-02f, -1.01928599e-01f, 6.91048428e-02f, 2.38199979e-02f,
  2.12642574e-03f, 1.10492939e-02f, 5.09910807e-02f, 8.12054947e-02f, -4.28641811e-02f, 5.08779474e-02f, 4.67693210e-02f, 1.17992442e-02f, -5.38262539e-02f, 3.48013900e-02f,
  -3.45526412e-02f, -3.46586928e-02f, -3.76049727e-02f, -3.23030092e-02f, -5.76129891e-02f, 6.24300763e-02f, 6.49385229e-02f, 7.89071321e-02f, 1.54357069e-04f, -2.85198409e-02f,
  -4.63916175e-02f, -2.77545005e-02f, 5.54642193e-02f, 6.95974799e-03f, 5.48084490e-02f, -2.53639016e-02f, -7.84401074e-02f, 1.51731605e-02f, 4.17931974e-02f, 2.12145541e-02f,
  -7.17291981e-02f, -2.04458788e-01f, 3.93732414e-02f, 2.00497787e-02f, -8.67570564e-02f, 6.55212104e-02f, -3.60242240e-02f, 8.87291804e-02f, -3.31849568e-02f, -4.71538492e-02f,
  2.50198394e-02f, -8.12171213e-03f, 1.68971233e-02f, -6.32768646e-02f, -4.87618111e-02f, -4.02693935e-02f, -4.73998934e-02f, -2.15214752e-02f, 7.70212933e-02f, 1.84524152e-02f,
  -2.54914723e-02f, -3.25105190e-02f, 7.18255937e-02f, 6.65228441e-02f, -1.31752621e-03f, -5.63271483e-03f, 3.59740295e-02f, -3.15771699e-02f, -4.66164723e-02f, 1.09163346e-02f,
  -1.38816282e-01f, 6.90679774e-02f, 5.36085805e-03f, -6.93919957e-02f, 6.16884977e-02f, 4.09986079e-02f, -1.90472323e-02f, -6.67398646e-02f, -1.93841934e-01f, -2.09683031e-01f,
  -1.48167744e-01f, -3.89224291e-02f, 1.15872286e-01f, -9.18769389e-02f, 2.11354479e-01f, 2.25669533e-01f, -1.13453582e-01f, -1.37685373e-01f, 1.08376481e-01f, -9.85775813e-02f,
  6.72295243e-02f, -1.28450230e-01f, 2.26447612e-01f, 7.47702569e-02f, -1.10955574e-01f, -1.48054242e-01f, 1.39862876e-02f, 2.89754085e-02f, -1.91697851e-02f, -1.18377106e-02f,
  -1.77886099e-01f, -2.45645583e-01f, -1.94159016e-01f, -1.54244050e-01f, -1.37758359e-01f, -4.87684505e-03f, -6.05967753e-02f, 3.28544788e-02f, 9.53648146e-03f, 2.63584070e-02f,
  -1.10190734e-01f, 1.41912540e-02f, -4.62551117e-02f, -2.57991236e-02f, -8.95935744e-02f, -1.41466188e-03f, 1.06850669e-01f, 1.27650797e-02f, -4.67724800e-02f, 8.83957818e-02f,
  8.96971077e-02f, -1.21894330e-02f, -3.39743495e-02f, 1.73522439e-02f, 1.21357054e-01f, 2.10177116e-02f, 7.83416256e-03f, -6.65481612e-02f, -6.19864017e-02f, -4.08773832e-02f,
  -6.07575700e-02f, -9.60480720e-02f, 1.78161059e-02f, 2.25743167e-02f, 2.19779890e-02f, -5.58645055e-02f, -1.48530025e-02f, -6.98311925e-02f, 1.33938128e-02f, 3.17249261e-02f,
  -2.32600700e-03f, 2.30057165e-02f, -1.20706027e-02f, 6.93252170e-03f, 6.17825463e-02f, -2.40396671e-02f, 7.87557065e-02f, -3.15351263e-02f, 1.94265437e-03f, -1.00550177e-02f,
  5.03360443e-02f, 2.14808551e-03f, -4.98837940e-02f, 2.60098279e-02f, 6.21844595e-03f, 3.84238213e-02f, -1.14444539e-01f, -9.33456328e-03f, -2.14627981e-02f, 4.32463810e-02f,
  -2.07609758e-01f, -1.47998899e-01f, -9.89022627e-02f, -2.28651911e-02f, -6.92740083e-02f, -1.56098902e-02f, 5.73780164e-02f, 8.46505836e-02f, -1.05124466e-01f, -6.41689524e-02f,
  -3.11616417e-02f, -6.88935444e-03f, -2.94161681e-02f, -2.46595349e-02f, 1.59187447e-02f, -7.60107562e-02f, -4.10637185e-02f, -6.77318871e-02f, -7.71799311e-02f, -6.98445439e-02f,
  -6.82492033e-02f, -1.16852142e-01f, 2.89883278e-02f, -1.50473351e-02f, -8.71243998e-02f, -8.99040997e-02f, 6.90512359e-03f, 5.71248727e-03f, 6.71519190e-02f, -2.46954691e-02f,
  1.71341032e-01f, 1.40132278e-01f, 4.44789454e-02f, 6.86846673e-04f, -1.25285193e-01f, -1.88400194e-01f, -5.92662022e-02f, 1.42758409e-03f, -6.40067980e-02f, 1.48596063e-01f,
  -2.50098351e-02f, 1.17849573e-01f, -1.12795450e-01f, 2.24408776e-01f, -1.05115503e-01f, 4.91472818e-02f, 7.88073018e-02f, 1.27582803e-01f, -2.34828647e-02f, 5.19311614e-03f,
  -3.18979588e-03f, 9.42795798e-02f, -7.74438540e-03f, 2.44056769e-02f, 1.69116229e-01f, 8.86503235e-02f, 1.97643396e-02f, -1.74060792e-01f, 1.54516771e-01f, -6.88369274e-02f,
  1.53563218e-02f, 6.00390360e-02f, -3.20688859e-02f, 1.14773978e-02f, 3.44041623e-02f, 6.12929165e-02f, -3.38689573e-02f, 4.72502597e-02f, -1.22774672e-02f, -8.18401948e-02f,
  1.03991538e-01f, 4.83797006e-02f, -2.29063677e-03f, -1.15224153e-01f, 8.45725760e-02f, 6.82519525e-02f, 8.28438327e-02f, 8.04182664e-02f, -5.54578565e-02f, 6.95375875e-02f,
  1.34887844e-02f, -2.20650546e-02f, 5.58508746e-03f, 1.68175511e-02f, 6.57793134e-02f, -7.92523921e-02f, 8.75641257e-02f, 1.99357071e-03f, -1.89820826e-02f, 8.91298056e-03f,
  8.94511938e-02f, -3.00857890e-02f, 7.58432224e-02f, -4.72909622e-02f, 4.53580953e-02f, -7.33418902e-03f, 5.18756881e-02f, 3.41801904e-02f, 4.93877679e-02f, 4.49777469e-02f,
  -7.89319500e-02f, 4.91365306e-02f, -3.71257439e-02f, 6.89565539e-02f, 9.54988971e-03f, -5.34070954e-02f, -3.23968902e-02f, -1.35723501e-04f, 5.17140292e-02f, -4.80176769e-02f,
  4.93709408e-02f, 5.00631034e-02f, -5.34965694e-02f, 3.55705209e-02f, 4.61800136e-02f, 5.53625152e-02f, 2.42701918e-02f, 2.64645834e-02f, 6.32793605e-02f, -6.62641749e-02f,
  4.95769270e-02f, 4.12415154e-02f, 2.33132932e-02f, -7.88164139e-02f, -7.61277825e-02f, 3.05657294e-02f, 1.31677405e-03f, 2.75218729e-02f, -6.12409487e-02f, -6.44879639e-02f,
  -6.22207858e-02f, -5.12544857e-03f, -6.61573466e-03f, 3.30210552e-02f, -4.64835800e-02f, 3.10963206e-02f, -1.72496047e-02f, -3.18276249e-02f, 5.49404062e-02f, 2.71181557e-02f,
  -1.89748537e-02f, 8.04652944e-02f, 6.39253035e-02f, -8.06942675e-03f, -1.14255659e-02f, 4.09821793e-02f, 1.38376309e-02f, 2.93626748e-02f, 3.03387530e-02f, 6.03491366e-02f,
  -1.77855060e-01f, 1.60746783e-01f, -3.04534376e-01f, -9.69429687e-02f, -3.32412988e-01f, 5.33469021e-02f, 1.57181591e-01f, 4.80197221e-02f, 2.90929824e-01f, 3.39137197e-01f,
  -5.25824726e-02f, 9.50810686e-02f, 2.08169967e-01f, 2.08324902e-02f, 4.29047979e-02f, 3.55110228e-01f, 1.18267424e-01f, 1.35590062e-01f, 1.61432400e-01f, 6.53665466e-03f,
  -1.30204007e-01f, 1.10341543e-02f, -2.55835921e-01f, -2.66044233e-02f, -1.79124892e-01f, -8.85564983e-02f, -1.90163285e-01f, -1.86592385e-01f, -6.28136322e-02f, -2.84762215e-02f,
  -7.91938696e-03f, -1.27022471e-02f, -1.11742146e-01f, 6.26184791e-02f, -9.94440690e-02f, -7.10768774e-02f, -5.43746389e-02f, -5.35316207e-02f, -1.28379539e-02f, 3.63473445e-02f,
  9.96358767e-02f, 6.67745396e-02f, -1.82843041e-02f, 2.94029079e-02f, 1.45396432e-02f, -1.19962551e-01f, -6.38317689e-02f, -7.90839419e-02f, 6.33047223e-02f, -7.20666721e-02f,
  -5.07026277e-02f, -8.52601528e-02f, -1.48626968e-01f, 3.00785564e-02f, -6.82653561e-02f, -3.11403628e-02f, 1.08925616e-02f, -1.10511608e-01f, -6.48884773e-02f, 1.67469010e-02f,
  9.74101853e-03f, 2.77647171e-02f, 1.01878479e-01f, 1.43555983e-03f, -5.22633344e-02f, -2.93828454e-02f, -1.24926986e-02f, -8.41870997e-03f, 2.78653167e-02f, -7.89285004e-02f,
  2.38903565e-03f, -1.09494537e-01f, 1.95616819e-02f, -5.67274401e-03f, 1.37961889e-02f, 5.51930591e-02f, -1.43497568e-02f, -3.08498666e-02f, -1.52143165e-02f, 8.33455008e-03f,
  -2.96166558e-02f, -1.29683735e-02f, -7.45940730e-02f, -7.06360564e-02f, -2.38314904e-02f, 9.15659312e-03f, -4.32411879e-02f, -4.40216437e-02f, -4.41776589e-02f, -2.49516796e-02f,
  5.78566007e-02f, 2.39489675e-01f, -3.63162383e-02f, 6.84114695e-02f, 1.00751564e-01f, -8.44129324e-02f, 1.24664670e-02f, 1.11689530e-02f, 5.26398532e-02f, 2.31232643e-02f,
  2.00125054e-02f, 4.45078723e-02f, 5.86142763e-02f, -8.10491294e-02f, 6.03613444e-02f, -4.19968814e-02f, 1.04274310e-01f, 5.05459085e-02f, -3.91532630e-02f, -6.90272003e-02f,
  -1.04953587e-01f, 3.29583623e-02f, 6.24699108e-02f, 6.12228401e-02f, 8.04726500e-03f, 7.40844663e-03f, 9.74215046e-02f, -4.58002426e-02f, -2.64403913e-02f, 3.94360088e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  2.01872855e-01f, 5.68376854e-02f, 1.07960977e-01f, 1.02131963e-01f, 3.27393234e-01f, 8.25799555e-02f, 1.10881194e-01f, -1.63632371e-02f, 2.05850005e-01f, 2.01582044e-01f,
  1.03177458e-01f, 1.75518647e-01f, 1.82715714e-01f, 9.90079120e-02f, 8.78860652e-02f, 4.47982969e-03f, 1.49997696e-01f, 5.37777767e-02f, 1.99988812e-01f, 2.23494947e-01f,
  9.60412025e-02f, 1.84156194e-01f, 5.53910062e-02f, 9.00749788e-02f, -2.87463608e-05f, 3.13847750e-01f, 1.44961521e-01f, 2.18635082e-01f, 2.53114253e-01f, 2.16384888e-01f,
  6.55622082e-03f, 2.95809388e-01f, 2.65137285e-01f, 7.18459561e-02f, 8.37819744e-03f, 1.49938628e-01f, 4.49443609e-02f, 1.22767784e-01f, 1.93071067e-01f, 2.86699504e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  1.34923533e-01f, -7.34129846e-02f, 1.64429862e-02f, 1.02615856e-01f, -2.58669071e-02f, 1.48022790e-02f, -2.92127073e-01f, -5.51177144e-01f, -8.44848603e-02f, 1.01490602e-01f,
  9.23673362e-02f, -4.30884510e-01f, 1.15472518e-01f, -1.15351364e-01f, 1.82642907e-01f, 1.08801790e-01f, -3.06322157e-01f, 1.16372779e-01f, 4.05958980e-01f, 4.84025300e-01f,
  -3.81507725e-01f, 3.51366758e-01f, 1.71159253e-01f, -4.39570725e-01f, -4.68682051e-02f, -1.36812553e-01f, 2.46908441e-01f, -1.57608390e-01f, -8.48466903e-02f, 4.25686762e-02f,
  -1.74712017e-01f, -1.10898609e-03f, -1.00356825e-02f, 2.48033956e-01f, 5.54562770e-02f, -2.09332943e-01f, 1.50357470e-01f, -8.34111050e-02f, 2.58707590e-02f, 2.39181658e-03f,
  -2.37237021e-01f, 1.01527250e+00f, -1.18986204e-01f, -2.61093646e-01f, 1.38366660e-02f, 3.18329223e-02f, -1.76077724e-01f, -1.58591315e-01f, -3.93043533e-02f, -3.16133142e-01f,
  -2.16031969e-01f, -1.54761165e-01f, 1.36480927e-01f, 1.63265720e-01f, 3.40040959e-02f, 9.74317417e-02f, -1.60441160e-01f, -1.06849067e-01f, -2.04376608e-01f, 5.99071205e-01f,
  -1.55368894e-01f, 4.80015054e-02f, 1.21844649e-01f, 3.24154556e-01f, -6.03717119e-02f, 1.34767503e-01f, 1.89144075e-01f, -1.83264032e-01f, 4.86735515e-02f, -5.39425798e-02f,
  -3.78071070e-02f, -2.97618508e-01f, 2.00918674e-01f, 2.30267033e-01f, 7.92872310e-02f, -2.97123641e-01f, 1.48280859e-01f, -2.70976514e-01f, -5.26380718e-01f, -3.51333171e-01f,
  2.54514009e-01f, -5.11168480e-01f, -2.08293006e-01f, 4.13786411e-01f, -2.54002307e-02f, -1.26909241e-01f, 9.70745683e-02f, -5.41969657e-01f, -1.28324121e-01f, -1.99141815e-01f,
  -1.39426306e-01f, -1.42947733e-02f, 5.36102116e-01f, 3.93519700e-01f, -2.55008359e-02f, 6.18126467e-02f, -1.98890015e-01f, 5.54946303e-01f, 1.96180925e-01f, 1.96529210e-01f,
  -7.58571252e-02f, 1.49426296e-01f, 2.73338985e-02f, -1.65391773e-01f, -1.77880630e-01f, 4.00472105e-01f, -2.26192474e-01f, 6.13362849e-01f, 2.91947216e-01f, -2.53869385e-01f,
  7.78280955e-04f, -4.40439247e-02f, 3.28741729e-01f, -2.07096860e-01f, -7.21660703e-02f, -5.97957559e-02f, 1.67169735e-01f, -3.34619820e-01f, -1.52115762e-01f, -2.58119076e-01f,
  -1.57316566e-01f, -2.38370538e-01f, 2.91160554e-01f, -2.40534723e-01f, 2.25968808e-01f, -2.22194031e-01f, 1.76091477e-01f, 5.66407815e-02f, -3.98337841e-02f, -2.53048211e-01f,
  -5.64934433e-01f, -5.24323434e-02f, 5.70353270e-02f, -1.78314924e-01f, 4.63313051e-02f, 1.07083935e-02f, -2.07346916e-01f, -3.19042392e-02f, -1.04740761e-01f, -2.23814882e-02f,
  4.04509623e-03f, 4.00748879e-01f, -2.03736737e-01f, -1.35023013e-01f, -1.69570655e-01f, -1.61116451e-01f, 2.05562249e-01f, 4.35320176e-02f, 3.77303898e-01f, 9.65069700e-03f,
  1.91883162e-01f, 1.29903615e-01f, 4.81870845e-02f, -2.06008211e-01f, -5.17195426e-02f, 5.22164702e-01f, 1.44454643e-01f, -1.76762238e-01f, -1.01443246e-01f, 5.49935140e-02f,
  2.32036591e-01f, -2.71568373e-02f, 2.43992075e-01f, -4.90615107e-02f, -8.11034665e-02f, 2.26371378e-01f, -1.22009153e-02f, -3.38109434e-02f, -1.68143541e-01f, -1.79569408e-01f,
  -1.58020407e-01f, 4.67577457e-01f, 3.13354611e-01f, -1.35831296e-01f, 9.49237123e-02f, -1.29702374e-01f, -1.10557102e-01f, -1.14783868e-01f, -2.06258953e-01f, -2.95216721e-02f,
  -2.89637715e-01f, -1.02679744e-01f, 7.25946808e-03f, -2.67534554e-01f, 3.68209362e-01f, 6.25622511e-01f, -9.58557427e-02f, 1.71795815e-01f, 6.28505945e-01f, -5.59136793e-02f,
  -1.83536336e-02f, -1.23992711e-01f, -2.24211246e-01f, -1.97094604e-01f, 3.11322231e-03f, 1.99937955e-01f, 1.60869390e-01f, -7.61637330e-01f, 2.66281396e-01f, 1.09504484e-01f,
  -3.23264897e-01f, -3.53404433e-01f, -1.30904587e-02f, 1.22115262e-01f, -5.55792987e-01f, -4.45402890e-01f, 4.24155474e-01f, 9.65237767e-02f, -1.54672340e-01f, 4.36681241e-01f,
  2.16494739e-01f, -1.03107274e-01f, -4.75478768e-01f, 4.75581914e-01f, -4.98453766e-01f, 1.31955609e-01f, -2.34913588e-01f, 6.43330440e-02f, 3.96258175e-01f, -9.88323316e-02f,
  -7.62106255e-02f, 2.02246085e-02f, 2.73748904e-01f, 1.35688931e-01f, -7.97376633e-02f, -1.46150813e-01f, 8.01377185e-03f, -2.02127323e-01f, -6.70266300e-02f, -1.30515173e-01f,
  -1.00933239e-01f, 1.92248046e-01f, 7.38876283e-01f, -1.71529576e-01f, 1.86464489e-01f, -7.24912211e-02f, -2.32175350e-01f, -2.35764543e-03f, -3.74559825e-03f, -1.12573355e-01f,
  -1.74224004e-01f, -2.08659500e-01f, 1.41322076e-01f, 1.62960902e-01f, -1.06338985e-01f, -1.76202118e-01f, 4.83020842e-02f, -3.61995161e-01f, 1.73080130e-03f, -2.58241475e-01f,
  6.09023161e-02f, -1.24086969e-01f, -1.40414447e-01f, -4.25466113e-02f, -4.57750037e-02f, 1.88849390e-01f, 1.11374713e-01f, 2.05845013e-01f, -4.27743569e-02f, 5.25002442e-02f,
  -4.84847054e-02f, 5.90192914e-01f, -7.32593313e-02f, 2.44921222e-01f, 5.81903338e-01f, 4.35915977e-01f, 3.36934596e-01f, 1.95792437e-01f, 8.01234692e-02f, -1.53039634e-01f,
  5.31995654e-01f, -4.14699651e-02f, 2.34629083e-02f, -3.61183062e-02f, 6.42509460e-01f, 4.27386127e-02f, 2.31774271e-01f, 4.72824574e-01f, -2.20761925e-01f, 2.49946564e-01f,
  2.91979909e-01f, -1.32856056e-01f, 4.77031350e-01f, -2.66561657e-01f, -1.20369904e-01f, -5.05457334e-02f, -2.29036167e-01f, -1.50709033e-01f, -3.14815879e-01f, -2.23001450e-01f,
  2.25917995e-01f, -3.73210549e-01f, 7.46561944e-01f, -3.78042042e-01f, -1.54436693e-01f, 5.77144511e-02f, -6.66346326e-02f, -1.49009854e-01f, 8.93651396e-02f, -2.30234131e-01f,
  -1.35596156e-01f, -2.06846133e-01f, 3.90501440e-01f, 8.59843269e-02f, -3.98280323e-02f, 3.71659279e-01f, -5.34976535e-02f, -1.40036523e-01f, -9.87017974e-02f, -9.41731334e-02f,
  3.27715613e-02f, 8.58430415e-02f, 7.29338452e-02f, -6.40446171e-02f, 1.04021706e-01f, -2.20863253e-01f, -5.58989719e-02f, 5.57376325e-01f, -2.41899207e-01f, -1.01598769e-01f,
  6.93009943e-02f, 1.57165360e-02f, 7.62669519e-02f, -1.06899552e-02f, 2.52699375e-01f, 3.98900837e-01f, 1.17314398e-01f, 2.88909942e-01f, 3.67536098e-01f, -1.56921610e-01f,
  1.03691384e-01f, 1.14757784e-01f, 2.62430072e-01f, -3.00252121e-02f, 6.89679161e-02f, 5.11795402e-01f, -4.70829429e-03f, -1.92655772e-01f, -2.85298258e-01f, 4.07304615e-01f,
  3.43480743e-02f, -7.46315897e-01f, -4.47103725e-04f, -3.55704337e-01f, 3.95320244e-02f, -9.05637890e-02f, -2.46685427e-02f, -3.19914743e-02f, -3.60395491e-01f, -9.56038162e-02f,
  -1.60002738e-01f, -5.26594743e-02f, -4.25916284e-01f, 2.16360271e-01f, -1.81326091e-01f, 2.72542119e-01f, 1.02172725e-01f, 4.97234553e-01f, -3.51344235e-03f, -2.21566893e-02f,
  -2.10808262e-01f, -2.92470545e-01f, -1.44094601e-02f, 5.53415269e-02f, -8.82615373e-02f, -7.66304880e-02f, -1.50445610e-01f, -2.12996736e-01f, 1.52159974e-01f, 5.29036701e-01f,
  -2.37049550e-01f, -1.66955575e-01f, 2.40475386e-01f, -1.08372472e-01f, -5.78591675e-02f, 5.85557520e-01f, -2.63350368e-01f, -8.31848159e-02f, 5.26896641e-02f, 1.46059468e-02f,
  -3.31956476e-01f, -2.89149076e-01f, -1.24553461e-02f, 6.99149668e-01f, 1.41482368e-01f, 2.39584278e-02f, 3.66314888e-01f, -3.79730761e-02f, 1.73061192e-02f, -1.42260775e-01f,
  3.02565306e-01f, 2.11778820e-01f, -4.55898553e-01f, -2.23460853e-01f, 1.59819618e-01f, -2.80740932e-02f, -3.15857351e-01f, -4.98240814e-02f, -2.74908423e-01f, 3.30113292e-01f,
  3.49110425e-01f, -4.20699090e-01f, -1.71835154e-01f, -2.10329726e-01f, 4.95212704e-01f, -3.98929179e-01f, -2.33723223e-01f, 1.46950394e-01f, -2.27179453e-01f, -2.74853930e-02f,
  -7.24225864e-03f, -1.89395696e-01f, -1.93425897e-03f, 4.12232429e-01f, 4.26099151e-02f, 1.25627052e-02f, 8.93121898e-01f, -2.82580703e-01f, -2.23592013e-01f, 5.76811135e-01f,
  -2.75346607e-01f, 2.36803927e-02f, 3.92705500e-02f, 2.49714062e-01f, 1.70712154e-02f, -1.71671063e-01f, -2.35477313e-01f, 1.98065087e-01f, -1.50654446e-02f, 7.50777498e-02f,
  -1.67677313e-01f, 2.44505778e-01f, -1.45347267e-01f, 2.40816683e-01f, -2.29959786e-01f, -1.84134036e-01f, -1.40215889e-01f, -2.20868275e-01f, -7.84325413e-03f, 2.96410054e-01f,
  -1.17724426e-01f, 5.67212142e-02f, -9.08096880e-02f, -1.34816021e-01f, 1.26909554e-01f, -1.86809506e-02f, -1.78540915e-01f, -2.67507344e-01f, -2.31437534e-01f, -3.02066624e-01f,
  -2.32405663e-01f, -1.50951058e-01f, -2.28034139e-01f, 1.06746376e-01f, -1.46739289e-01f, -6.50956035e-02f, -2.49506816e-01f, -1.18973583e-01f, -1.24667838e-01f, 1.07238675e-02f,
  -2.38369301e-01f, 3.04855138e-01f, -2.83458650e-01f, 2.51764208e-02f, -1.97000667e-01f, 1.60167679e-01f, -1.77839130e-01f, -2.83228457e-01f, -3.68360132e-01f, 2.31339976e-01f,
  -8.46562609e-02f, 7.40942918e-03f, 1.87153608e-01f, 9.14921016e-02f, -6.60993904e-02f, -1.35894092e-02f, -2.38050863e-01f, 1.42852021e-02f, 1.71765625e-01f, -3.73469554e-02f,
  -2.04959005e-01f, -1.57183960e-01f, 9.93307307e-02f, -1.21922798e-01f, 6.93371668e-02f, 4.99063171e-02f, 3.87616637e-05f, -5.17180115e-02f, -8.90578851e-02f, -2.05767289e-01f,
  4.25154716e-02f, -1.20107345e-01f, -2.00300917e-01f, 4.81723659e-02f, -2.62070484e-02f, 5.20599425e-01f, 5.50503768e-02f, -1.97847053e-01f, 7.92242885e-01f, -1.89734221e-01f,
  -1.67055681e-01f, 5.31530619e-01f, -8.25993195e-02f, 2.02559322e-01f, -2.20656976e-01f, -1.81086197e-01f, 3.32629569e-02f, 1.27851248e-01f, 2.59381328e-02f, 3.27191085e-01f,
  8.63478482e-02f, 2.15501666e-01f, -1.66208670e-01f, -3.81354123e-01f, -1.16758170e-02f, -3.72450858e-01f, 7.36462995e-02f, 1.25936329e-01f, -1.26716480e-01f, -1.85198873e-01f,
  1.18852891e-01f, -8.43282714e-02f, -9.39953402e-02f, -1.51061222e-01f, 3.23388934e-01f, 3.95049065e-01f, -2.64292508e-01f, -3.41836393e-01f, -1.24804534e-01f, -1.21678591e-01f,
  -2.01162457e-01f, 3.11092198e-01f, -2.59829223e-01f, -7.57403746e-02f, 2.30649561e-01f, 1.77442119e-01f, -1.88206341e-02f, 6.34848654e-01f, -1.51552916e-01f, 6.20093286e-01f,
  -2.85286158e-01f, -1.83995515e-01f, -5.26613779e-02f, 5.55451401e-02f, 1.77635983e-01f, -1.94676712e-01f, 2.21298158e-01f, -1.09301237e-02f, -1.10348292e-01f, -8.30522552e-02f,
  -1.74480304e-01f, -1.37004614e-01f, 2.82745093e-01f, -1.20737121e-01f, 1.42953977e-01f, 1.04477219e-01f, -1.80025324e-01f, 1.15190566e-01f, 4.77850407e-01f, -6.84047118e-02f,
  2.51949102e-01f, -1.80978239e-01f, -1.90341786e-01f, 9.91976187e-02f, 2.27071494e-01f, -2.32141018e-02f, 2.83505946e-01f, -2.31513619e-01f, -3.35467793e-02f, -7.61456788e-02f,
  -5.54588325e-02f, -1.82767138e-01f, -1.55812845e-01f, 5.01578338e-02f, 2.01429814e-01f, -2.56511956e-01f, -6.25755861e-02f, 1.54223412e-01f, 2.42993772e-01f, 2.09342584e-01f,
  1.24217287e-01f, -1.09213464e-01f, -3.03355128e-01f, -4.84457687e-02f, -3.21951389e-01f, 3.47381562e-01f, 4.80376147e-02f, 1.33505598e-01f, 5.19655704e-01f, 8.16109926e-02f,
  -3.07658147e-02f, 2.74866205e-02f, -2.06222430e-01f, -4.19642627e-01f, 5.95105469e-01f, -2.97805309e-01f, 5.18860459e-01f, -1.49281994e-01f, 2.83122003e-01f, -3.05799276e-01f,
  -2.62120903e-01f, -9.24674496e-02f, -3.00825983e-02f, -1.99327111e-01f, -1.40886098e-01f, -2.43121255e-02f, -1.59074217e-01f, -1.54203743e-01f, 2.86675215e-01f, -1.29257113e-01f,
  -2.65078217e-01f, -3.25268805e-01f, -8.51495788e-02f, -2.26233885e-01f, 8.85852754e-01f, -2.51884401e-01f, -1.40514612e-01f, -1.26429453e-01f, -1.23069324e-01f, -2.67761469e-01f,
  8.00843909e-03f, 6.35660887e-02f, -2.23778218e-01f, 1.53965086e-01f, -2.50754319e-02f, 3.77035230e-01f, 2.56815434e-01f, -1.03495739e-01f, -1.88365176e-01f, 4.17468995e-01f,
  -1.97157159e-01f, 1.08215444e-01f, 5.00153065e-01f, -1.22338325e-01f, 1.02129467e-01f, 9.72606912e-02f, 4.58631441e-02f, 1.32580310e-01f, -2.12919056e-01f, -3.31975907e-01f,
  1.08173423e-01f, 1.55476853e-01f, 3.35847199e-01f, 1.75401896e-01f, -2.49629095e-02f, 9.00418758e-02f, 6.05639033e-02f, 2.14757640e-02f, 2.72221118e-01f, 1.09546766e-01f,
  1.20069586e-01f, 9.47173387e-02f, -6.03438392e-02f, -2.51561195e-01f, -1.56481832e-01f, -1.69111177e-01f, 2.51255691e-01f, 4.36620027e-01f, -3.17661196e-01f, -2.14268416e-01f,
  -4.41191673e-01f, 4.60664600e-01f, -2.43663676e-02f, 3.65700759e-02f, -2.77068645e-01f, 4.10224348e-02f, -1.24350145e-01f, -2.83045292e-01f, 7.31812775e-01f, -6.73153326e-02f,
  8.57865140e-02f, -1.78865041e-03f, -7.34411478e-02f, -1.64710090e-03f, -2.45295137e-01f, 1.40261009e-01f, -2.34282479e-01f, -2.26711139e-01f, -1.43135667e-01f, 6.85571786e-03f,
  -1.72473833e-01f, -2.71536082e-01f, 4.97081190e-01f, -9.23557132e-02f, 1.97892003e-02f, -3.27034861e-01f, 7.40919169e-03f, -1.57164499e-01f, -2.02579960e-01f, -2.68726915e-01f,
  -2.61386395e-01f, 3.87095571e-01f, 5.40664077e-01f, -7.72857890e-02f, -1.88789628e-02f, -2.79837400e-01f, 3.22335839e-01f, 4.94871497e-01f, -1.74230978e-01f, 3.83369089e-03f,
  -1.12799801e-01f, -2.52068073e-01f, -8.70055184e-02f, -2.39912316e-01f, -1.55974673e-02f, 1.86095655e-01f, -9.15985852e-02f, -6.05677553e-02f, 7.92171881e-02f, 1.67080671e-01f,
  2.67755687e-02f, -3.94154638e-02f, 2.57301241e-01f, 1.44965500e-01f, -7.42830560e-02f, -1.30833797e-02f, -2.30785981e-01f, 3.79010767e-01f, 4.61609721e-01f, 2.99277633e-01f,
  1.67303845e-01f, 4.77578640e-01f, -3.38976830e-01f, -4.51855898e-01f, 4.34928924e-01f, -5.09210348e-01f, 3.22328031e-01f, 2.91855901e-01f, 6.91620231e-01f, 1.05280951e-01f,
  1.47925928e-01f, -2.23054588e-01f, -1.74856752e-01f, -9.24256071e-02f, 3.74030560e-01f, -1.82501823e-02f, 1.07109457e-01f, -1.70845255e-01f, 1.24404095e-01f, 8.16374645e-02f,
  -1.26650140e-01f, 5.10898605e-02f, -1.81754440e-01f, -5.21864742e-02f, 2.53067404e-01f, -2.55599581e-02f, 4.08261605e-02f, -1.85329184e-01f, -1.21715637e-02f, 4.84666675e-01f,
  -2.46535063e-01f, -1.10597178e-01f, -4.09199297e-02f, -2.00259075e-01f, -1.78983673e-01f, 5.23097038e-01f, -2.18572214e-01f, -1.55612722e-01f, -1.27832726e-01f, -1.83728859e-01f,
  -2.71440148e-01f, 1.70915516e-03f, -1.77292489e-02f, -8.71417448e-02f, -2.02593148e-01f, -2.19221741e-01f, 2.80257732e-01f, -2.76082009e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.79800481e-01f, -1.17159761e-01f, -2.13366091e-01f, 1.32174164e-01f, 2.11968735e-01f, 2.09041573e-02f, -3.99335623e-02f, -4.20931280e-02f, -1.30748395e-02f, -4.61807922e-02f,
  1.98807362e-02f, 6.16137013e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    