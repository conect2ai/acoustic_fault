/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.49287054e-01f, -4.54578921e-02f, 2.86626339e-01f, 1.21437691e-01f, 1.57203734e-01f, -2.46223465e-01f, -1.96591079e-01f, 1.56780392e-01f, 6.41023653e-05f, -1.04268767e-01f,
  -6.95260391e-02f, 4.36994657e-02f, 4.07984145e-02f, -5.20066582e-02f, 1.32021368e-01f, -1.57113984e-01f, 1.13295401e-02f, -8.39688033e-02f, 9.58433226e-02f, 8.30332711e-02f,
  2.44718418e-01f, -4.38546762e-02f, 1.95371494e-01f, 2.44644703e-04f, 1.46663502e-01f, 1.79673895e-01f, 5.45462593e-02f, 3.32027450e-02f, 2.46221591e-02f, -8.10820330e-03f,
  -1.19243078e-01f, 1.22249611e-01f, 3.17361243e-02f, 3.03132441e-02f, -6.07415661e-02f, 4.79347259e-02f, -3.46528105e-02f, -9.47446749e-02f, 1.07486323e-01f, -4.80773225e-02f,
  -8.32880735e-02f, 2.73081381e-02f, 3.78373414e-02f, -8.11198875e-02f, -5.21184318e-03f, -3.50489728e-02f, 1.34429270e-02f, 5.32902740e-02f, 7.65578123e-03f, 9.43047181e-02f,
  8.27764161e-03f, 4.59873974e-02f, 9.25714746e-02f, -7.56135583e-02f, 1.88158602e-02f, 4.59129410e-03f, -2.54116282e-02f, -1.45616790e-03f, 4.83951792e-02f, 3.57606821e-02f,
  -2.89777089e-02f, 4.68522161e-02f, -2.26276723e-04f, 2.74596512e-02f, -6.57338649e-02f, 1.49850221e-02f, -5.83757013e-02f, -7.35804066e-03f, -2.89782975e-02f, -3.59857013e-03f,
  -8.73709917e-02f, -8.60089064e-03f, 4.10887748e-02f, -3.68698463e-02f, -6.58151403e-04f, -8.33355077e-03f, 4.54861782e-02f, 1.34570934e-02f, 6.11058064e-02f, 9.06401053e-02f,
  -7.58154914e-02f, -5.41937724e-02f, -1.42332613e-02f, -5.67644387e-02f, -6.42437488e-02f, 8.37561712e-02f, 2.21500508e-02f, -3.54067087e-02f, -8.70132595e-02f, 8.47747996e-02f,
  -1.90028802e-01f, -4.89068404e-02f, 1.68729797e-02f, -7.87134543e-02f, -2.33595259e-02f, 3.34421918e-03f, 5.67391701e-02f, 1.96586866e-02f, -9.01175216e-02f, 5.94058633e-02f,
  2.09685639e-02f, -5.64649031e-02f, -1.47564465e-03f, -1.16029441e-01f, -1.78993002e-01f, 3.50231454e-02f, 2.10831650e-02f, -8.68273228e-02f, -2.40235706e-04f, -2.08902266e-03f,
  8.65445957e-02f, -7.21128061e-02f, 2.03336868e-02f, 4.76618148e-02f, -2.83479672e-02f, -4.07658406e-02f, 3.72016765e-02f, -4.96463552e-02f, 4.65697190e-03f, -6.00067452e-02f,
  2.80187111e-02f, -4.12639491e-02f, 2.46002093e-01f, -1.65366158e-01f, -5.62891625e-02f, 1.94910139e-01f, 3.16130295e-02f, -1.43997371e-01f, 1.03638925e-01f, -2.24713489e-01f,
  -1.67895526e-01f, 1.65632993e-01f, 1.23152174e-01f, -1.49979010e-01f, 1.36751726e-01f, 1.39708251e-01f, -1.26794890e-01f, 5.04510775e-02f, 1.44225538e-01f, -1.15325503e-01f,
  -6.15024241e-04f, -2.57864684e-01f, 4.29912582e-02f, -1.18921056e-01f, -1.86798900e-01f, -3.15201543e-02f, -2.24719420e-01f, 4.44740057e-02f, -1.29783511e-01f, -2.10233103e-03f,
  6.52923286e-02f, -8.51279125e-02f, 6.00271411e-02f, -2.14555357e-02f, -3.57206399e-03f, -5.36340550e-02f, 7.68574029e-02f, 6.02540225e-02f, -1.69541538e-02f, -5.49804866e-02f,
  9.44914818e-02f, -2.38905065e-02f, 2.97236536e-02f, -2.70585790e-02f, -1.51551869e-02f, 2.72864774e-02f, 2.20087077e-02f, -7.89337009e-02f, 6.74697990e-03f, 1.18785702e-01f,
  1.57230329e-02f, -1.15133869e-02f, -1.98510922e-02f, -3.60221192e-02f, 1.13708824e-01f, -7.84578994e-02f, 6.21933192e-02f, 9.12859365e-02f, 1.88215356e-02f, 5.54714538e-02f,
  -6.84666261e-02f, -1.04047880e-02f, 1.00658480e-02f, -7.14260489e-02f, 2.51303017e-02f, -6.62717968e-02f, 2.06655730e-02f, 1.12062348e-02f, 5.41638806e-02f, 2.29999740e-02f,
  1.44412201e-02f, 5.23253530e-02f, -6.03762344e-02f, 2.07968354e-02f, -4.28703427e-02f, -3.61543261e-02f, 4.18016873e-02f, -1.00590549e-02f, 8.47032666e-02f, 1.40630603e-02f,
  -4.05036248e-02f, 8.92769620e-02f, -9.78101119e-02f, -9.44385957e-03f, 3.30868103e-02f, 1.02974117e-01f, -8.64343569e-02f, 3.66129801e-02f, 8.78800359e-03f, -4.12512198e-02f,
  -1.26549020e-01f, -7.74413794e-02f, 9.16290519e-05f, 1.66380908e-02f, -3.30464691e-02f, -2.56813467e-02f, 1.54866790e-02f, 5.77724911e-02f, 8.76256227e-02f, -9.46367085e-02f,
  7.74371531e-03f, -1.41554549e-01f, 3.64108309e-02f, -1.64161331e-03f, 3.03581897e-02f, -5.16227726e-03f, -1.09235220e-01f, -1.59889087e-02f, -6.47314191e-02f, -3.15410122e-02f,
  -3.31692025e-02f, -2.61953138e-02f, 2.15698481e-02f, -5.15972376e-02f, 7.52270862e-04f, -6.93787064e-04f, -2.32217144e-02f, 5.70641048e-02f, 9.80919972e-02f, -1.96079165e-02f,
  -2.50276983e-01f, 8.76870155e-02f, -1.82570577e-01f, -1.16418064e-01f, 1.34843856e-01f, -2.10799143e-01f, -1.23260133e-01f, 4.23746407e-02f, -4.42761071e-02f, 2.69068599e-01f,
  4.61837389e-02f, -8.54754895e-02f, 7.17216209e-02f, 1.13279246e-01f, -7.77742937e-02f, -2.48607963e-01f, -1.20056175e-01f, -2.53955051e-02f, 1.06296502e-03f, 8.54662210e-02f,
  -1.55788273e-01f, 1.40586928e-01f, -1.53698593e-01f, 1.49314612e-01f, 4.81926762e-02f, -2.46469956e-02f, 1.57652572e-01f, 8.66525173e-02f, 1.48555368e-01f, -6.24989392e-03f,
  2.92732436e-02f, -4.26291786e-02f, -6.48878561e-03f, -3.66016035e-03f, 1.97788957e-03f, 4.15348783e-02f, 2.85605844e-02f, -2.43762005e-02f, 2.16963631e-03f, -5.90500422e-03f,
  2.13178191e-02f, 1.07518174e-01f, 2.81385873e-02f, -1.99029967e-02f, 2.53381114e-02f, 2.09298693e-02f, -7.31169730e-02f, -4.04030383e-02f, -4.66831140e-02f, -6.44223094e-02f,
  -3.38266417e-02f, -6.69237077e-02f, -7.71014094e-02f, -4.41046767e-02f, -1.60928387e-02f, 6.71459809e-02f, -6.92452341e-02f, -2.96278726e-02f, -4.15912494e-02f, 3.98604497e-02f,
  -1.04873978e-01f, 6.82083145e-02f, 4.71259234e-04f, 9.31659639e-02f, 1.29308281e-02f, -1.63115468e-02f, 2.29238160e-02f, -4.10924591e-02f, -2.58858576e-02f, 5.29222563e-02f,
  1.40917962e-02f, -8.01682174e-02f, 5.62466122e-03f, 1.02128610e-02f, 6.65754604e-04f, 1.27704544e-02f, -9.11780074e-02f, 1.04189962e-01f, -8.91944692e-02f, -6.30022436e-02f,
  1.09162673e-01f, 2.05261316e-02f, 3.42520736e-02f, 1.41696138e-02f, 7.00160414e-02f, -4.80050854e-02f, -1.23870503e-02f, -8.48479718e-02f, -2.25732066e-02f, 1.82991344e-02f,
  -3.49473320e-02f, 6.13822117e-02f, -3.63454372e-02f, 6.10221401e-02f, 3.66350561e-02f, 1.02048432e-02f, -3.38026555e-03f, -4.99533527e-02f, 5.17633837e-03f, -8.41744803e-03f,
  9.61195827e-02f, 3.81303747e-04f, 1.99265648e-02f, -7.22111464e-02f, -4.23298515e-02f, 4.60109822e-02f, -5.27212135e-02f, 3.79928127e-02f, -2.62935627e-02f, 8.09087008e-02f,
  9.21474844e-02f, 1.13069095e-01f, -1.09407417e-02f, 2.64594518e-03f, -1.70268472e-02f, 1.13507383e-01f, -6.36169761e-02f, -8.34054723e-02f, -8.64892267e-03f, 4.76031676e-02f,
  2.37876520e-01f, -2.51089662e-01f, 1.90442130e-01f, 3.33116725e-02f, -1.09636553e-01f, -1.91103682e-01f, -1.56848859e-02f, -6.85716793e-02f, -1.20743513e-01f, -2.51853436e-01f,
  -7.20013231e-02f, -1.09490745e-01f, -1.02449030e-01f, -7.91346133e-02f, 2.50291705e-01f, -2.31927931e-02f, 4.76102047e-02f, -5.78660071e-02f, -4.32799570e-02f, 8.16252306e-02f,
  1.76709607e-01f, -2.15805452e-02f, 2.53410518e-01f, -1.88852362e-02f, 1.17303513e-01f, 2.18387231e-01f, -3.45640853e-02f, 9.51145813e-02f, -2.26628920e-03f, -3.11440974e-03f,
  7.04546049e-02f, 1.74473882e-01f, -2.86851991e-02f, 1.07843921e-01f, 2.00851541e-02f, 1.82582028e-02f, 3.65184993e-02f, 6.81059882e-02f, 1.61885598e-03f, 5.96499220e-02f,
  4.17054072e-02f, 4.89604194e-04f, -3.54256965e-02f, -7.46339411e-02f, -7.83386752e-02f, -3.44392955e-02f, -1.65030006e-02f, -1.18574863e-02f, -3.19336355e-02f, 1.13986447e-01f,
  1.59068611e-02f, 6.46289587e-02f, 1.90679077e-02f, -2.04193257e-02f, 4.68598772e-03f, 4.32825089e-02f, -4.36424464e-02f, 3.85068581e-02f, -1.09914117e-01f, -6.67925254e-02f,
  -6.24358095e-03f, 2.75280997e-02f, 5.58365136e-02f, 2.42094640e-02f, -2.30157822e-02f, 7.53061399e-02f, -4.55620363e-02f, 6.13530651e-02f, -1.35984542e-02f, -7.92177841e-02f,
  5.84876873e-02f, -4.72991318e-02f, -2.76133176e-02f, 2.43112389e-02f, 1.16284005e-02f, 3.29709761e-02f, -2.09552445e-03f, 4.02702689e-02f, -4.17989194e-02f, -8.27508718e-02f,
  -1.58472639e-02f, 1.49236098e-02f, -5.94743975e-02f, -4.10719700e-02f, -6.40844926e-03f, 2.51165926e-02f, -3.54751423e-02f, -5.76858856e-02f, 2.14628875e-02f, 3.09056435e-02f,
  -1.23481885e-01f, -1.39407245e-02f, -4.69257459e-02f, -6.45054802e-02f, 8.92337528e-04f, 4.02180143e-02f, 3.72818834e-03f, -7.78030083e-02f, -2.70541478e-02f, 2.07734648e-02f,
  -4.45273109e-02f, -1.53509974e-02f, -1.96047872e-02f, 7.56033584e-02f, 1.02829179e-02f, -1.00042842e-01f, 4.09561992e-02f, 1.59953870e-02f, 1.98381804e-02f, 6.58793002e-02f,
  -9.28922836e-03f, -1.33361742e-02f, -5.14427945e-02f, 3.41190933e-03f, -1.03137195e-02f, -5.17110080e-02f, -4.82269302e-02f, -2.49410607e-02f, -2.16253269e-02f, -1.15627937e-01f,
  5.02702415e-01f, -2.28471488e-01f, -8.95442143e-02f, 1.03611939e-01f, 1.24817595e-01f, -2.04049852e-02f, 3.26029882e-02f, -8.67548678e-03f, -1.58246338e-01f, -2.09115982e-01f,
  -1.58235319e-02f, -4.14380245e-02f, -1.10337049e-01f, -1.91672500e-02f, 1.68375045e-01f, -7.26850927e-02f, 3.21675315e-02f, -5.10633402e-02f, 5.55611551e-02f, 1.93710104e-01f,
  7.03113526e-02f, 1.37110263e-01f, 3.21434401e-02f, 1.09901279e-01f, 1.99296325e-01f, -4.75847302e-03f, 1.53706551e-01f, 6.20462671e-02f, 1.05248116e-01f, 4.74219583e-02f,
  2.47119535e-02f, -3.13994996e-02f, 6.60189912e-02f, -6.68625161e-02f, 7.18448535e-02f, -1.67388935e-02f, -3.07160262e-02f, 6.47989810e-02f, 2.73453332e-02f, 1.71355344e-02f,
  -4.07639146e-02f, 5.36030717e-03f, -6.05452769e-02f, 4.08011489e-02f, -6.38694242e-02f, 4.78033870e-02f, -6.13804944e-02f, -1.82870384e-02f, -1.02744699e-01f, 4.85357717e-02f,
  -5.43167628e-02f, 1.23589728e-02f, -8.35792720e-03f, -4.50483933e-02f, 8.44552834e-03f, -1.43827125e-02f, 7.77099980e-03f, 4.02096063e-02f, -7.44460225e-02f, 3.67521495e-02f,
  1.07008733e-01f, -6.86642826e-02f, -1.50512755e-02f, -5.14578000e-02f, -1.73789188e-02f, 1.34070200e-04f, 1.69793554e-02f, -5.12551814e-02f, -3.32593210e-02f, 1.06120128e-02f,
  4.35416214e-02f, 9.91912410e-02f, 1.08503662e-02f, -3.58783193e-02f, 8.55814517e-02f, 4.64942073e-03f, 4.18635495e-02f, 4.91699241e-02f, 1.84096564e-02f, 3.25180963e-02f,
  -8.33037198e-02f, -5.30943507e-03f, 5.95457330e-02f, 1.29076689e-02f, 4.32439446e-02f, 5.77012226e-02f, -4.25538197e-02f, -2.33623665e-02f, -7.60300644e-03f, 6.32428750e-02f,
  -7.42944563e-03f, -7.83902630e-02f, -3.65885757e-02f, -3.75550217e-03f, -8.06413665e-02f, 9.85178575e-02f, 4.26698942e-03f, -3.50569300e-02f, -1.95279848e-02f, -2.90608406e-02f,
  -3.18507664e-02f, -1.64277703e-02f, -1.94362551e-02f, -9.55566019e-03f, 2.09032260e-02f, 1.98953995e-03f, -5.62345274e-02f, -4.14432324e-02f, 4.85323071e-02f, -3.39669473e-02f,
  -4.27973084e-03f, -3.42518911e-02f, 2.34622546e-02f, -3.82754728e-02f, -1.99811496e-02f, 3.76312770e-02f, 3.27980556e-02f, 3.35784964e-02f, -8.63049105e-02f, -6.62581399e-02f,
  7.72321820e-02f, 1.77011788e-01f, 1.34238064e-01f, 2.26236820e-01f, -1.50144383e-01f, -2.65959561e-01f, -1.89639851e-01f, 1.81147620e-01f, -2.45824493e-02f, 1.35065123e-01f,
  -2.31545083e-02f, -5.82977794e-02f, 1.58841878e-01f, 1.13624178e-01f, -2.42278695e-01f, -5.84052987e-02f, 5.93921728e-02f, -5.46478778e-02f, -6.39898404e-02f, 1.08775705e-01f,
  8.12028572e-02f, 3.37453298e-02f, 1.61809206e-01f, 3.01772039e-02f, -3.38824131e-02f, 7.21256137e-02f, 8.02513137e-02f, -3.00821327e-02f, -4.19666208e-02f, -4.64247093e-02f,
  -2.95334253e-02f, 1.71248481e-01f, -4.51910123e-02f, 3.71134430e-02f, -9.91366580e-02f, -1.14341706e-01f, -3.16730589e-02f, -9.29530859e-02f, 9.18033645e-02f, 2.05987208e-02f,
  -1.16960950e-01f, 5.52740023e-02f, -8.03536475e-02f, -8.59191418e-02f, -6.91185147e-02f, -6.72187470e-03f, 1.15675190e-02f, 5.11485934e-02f, 4.64157946e-02f, -2.11337376e-02f,
  1.24421986e-02f, -7.12294579e-02f, 1.27896786e-01f, -3.17336544e-02f, -2.94523197e-04f, 1.50053669e-02f, 5.09087965e-02f, -8.54627788e-02f, -2.81186625e-02f, -2.56043989e-02f,
  -5.58368377e-02f, -2.59598810e-03f, 4.52925041e-02f, 5.21525182e-02f, -4.28696163e-02f, 1.21791437e-02f, 9.11869332e-02f, 8.28082114e-02f, 1.66810695e-02f, 2.27123760e-02f,
  -5.52775599e-02f, 2.10950896e-02f, 9.74207148e-02f, 3.33029144e-02f, -3.55376713e-02f, 1.11382701e-01f, -1.77934561e-02f, 3.26292813e-02f, -4.47281897e-02f, 5.60659468e-02f,
  1.42915443e-01f, -3.69730704e-02f, 7.42205828e-02f, -1.89477194e-03f, 2.18471652e-03f, 3.40810865e-02f, -1.26892747e-02f, 3.88428122e-02f, -9.94496495e-02f, -2.88633071e-02f,
  1.22708261e-01f, 2.24657580e-01f, -4.11682911e-02f, 9.84012112e-02f, -5.43351471e-02f, 4.55286400e-03f, -4.66287471e-02f, 3.31415460e-02f, 1.06347159e-01f, 3.36292014e-03f,
  -4.93662581e-02f, 9.33288336e-02f, 4.50096615e-02f, -2.85977055e-03f, -5.43708466e-02f, -8.87743458e-02f, -3.67973037e-02f, -6.47653593e-04f, -1.54657895e-02f, -9.88774933e-03f,
  1.52527139e-01f, -7.14845024e-03f, -4.64007333e-02f, 8.17394909e-03f, -5.99877816e-03f, -1.17301635e-01f, -3.49141397e-02f, 8.66809934e-02f, 1.56125694e-03f, -6.14047237e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.79827774e-01f, 2.40553007e-01f, 4.78662774e-02f, 1.87351018e-01f, 8.61510932e-02f, -1.50555596e-01f, -9.69881341e-02f, 1.87217444e-02f, 1.59599379e-01f, -6.66403323e-02f,
  -2.82958262e-02f, 1.08037837e-01f, -9.42199528e-02f, 2.24266857e-01f, 1.28155723e-01f, -1.30157858e-01f, 3.20577681e-01f, 7.31324255e-02f, -1.43593759e-03f, 2.30399579e-01f,
  9.79250968e-02f, 2.19844356e-01f, 3.90625857e-02f, -4.55465354e-02f, 5.75029030e-02f, -1.06983580e-01f, -9.55321640e-03f, -2.34264269e-01f, -1.82034373e-02f, -3.21967974e-02f,
  -8.07231143e-02f, 7.15678781e-02f, 4.58674021e-02f, -9.98363718e-02f, 7.68282637e-03f, 4.93499860e-02f, -1.48479044e-01f, -4.05355589e-03f, 3.72608914e-03f, 2.74311192e-02f,
  7.84824118e-02f, -5.08447029e-02f, 3.30544710e-02f, -7.14146197e-02f, 7.83201158e-02f, 6.20581731e-02f, -3.66124250e-02f, 3.00761200e-02f, 1.09711308e-02f, 1.29741386e-01f,
  1.42406955e-01f, 3.52135599e-02f, 1.47257959e-02f, 1.01410575e-01f, 6.34441897e-02f, 1.17222227e-01f, -9.93531644e-02f, 4.54638675e-02f, -9.91357714e-02f, 1.08082794e-01f,
  5.89131117e-02f, 7.25455880e-02f, -1.83526538e-02f, -1.08921856e-01f, 5.10863736e-02f, 4.91039455e-02f, -3.86676453e-02f, -4.17233370e-02f, 7.74108991e-02f, 8.86798427e-02f,
  -1.60045866e-02f, 2.23499220e-02f, -5.31298406e-02f, 1.71677470e-02f, 9.74109024e-02f, -3.14887576e-02f, -7.12289140e-02f, 1.69396158e-02f, 4.08068076e-02f, 3.03277504e-02f,
  -1.11100726e-01f, 5.21965027e-02f, 2.28932146e-02f, -1.03262886e-01f, -6.92718988e-03f, -7.74825737e-03f, 2.43508797e-02f, 2.20114961e-02f, -7.30985031e-02f, -3.05425376e-02f,
  1.39843956e-01f, 2.11649075e-01f, -5.99160679e-02f, 6.70446604e-02f, 9.85432640e-02f, -5.09731919e-02f, 4.05477732e-02f, -6.80067996e-03f, 2.42839530e-02f, 2.34715249e-02f,
  8.85756388e-02f, -1.21280096e-01f, 5.96480109e-02f, 5.39371893e-02f, -5.46150841e-02f, -1.00359805e-02f, 2.33946890e-02f, -1.07745975e-02f, 3.88926007e-02f, 1.27465904e-01f,
  9.69420467e-03f, -3.25915851e-02f, 9.53038782e-03f, 2.23403778e-02f, 9.69187617e-02f, 7.20048649e-03f, -4.24608443e-04f, 4.02008556e-03f, 1.10041564e-02f, -8.99789557e-02f,
  -3.22980940e-01f, 1.82188869e-01f, -3.29317570e-01f, -1.68168008e-01f, 2.96653882e-02f, -2.67677873e-01f, -1.73454911e-01f, 6.31340370e-02f, -9.99054760e-02f, 5.83759472e-02f,
  -7.19226077e-02f, -1.46858275e-01f, 9.19934735e-02f, -1.77477226e-01f, -3.70766461e-01f, -1.67419426e-02f, -2.72622287e-01f, -9.94214937e-02f, 7.47300982e-02f, -1.37139801e-02f,
  -2.64403187e-02f, 5.36899157e-02f, -8.30114037e-02f, 1.87052026e-01f, -7.93862268e-02f, -5.72829060e-02f, 1.40325697e-02f, 1.86334834e-01f, -1.18063651e-01f, -3.43385525e-02f,
  -8.54666382e-02f, -8.63348916e-02f, -6.70481846e-03f, 1.38963750e-02f, -1.95738211e-01f, 4.95249368e-02f, 9.52005014e-03f, 2.84253098e-02f, 6.74495623e-02f, 8.59180372e-03f,
  -7.05864802e-02f, -3.04042771e-02f, -4.41263802e-03f, 7.01568127e-02f, -1.06435604e-01f, -3.13930362e-02f, -1.01932911e-02f, -7.24893883e-02f, 4.29547317e-02f, -2.81696357e-02f,
  -6.49433732e-02f, -7.13160485e-02f, -2.17700470e-02f, 4.77582477e-02f, 4.51167971e-02f, -1.79866049e-02f, -5.73980249e-02f, -1.13989329e-02f, -1.48984091e-02f, -6.99929520e-02f,
  -3.33631784e-02f, 6.73776045e-02f, 2.13836767e-02f, -9.14874673e-02f, 1.34102795e-02f, 3.08941980e-03f, 9.95396450e-02f, 4.21676598e-02f, -3.90701070e-02f, 6.94130287e-02f,
  -6.39037113e-04f, 5.69515377e-02f, 3.90506163e-02f, -6.90670386e-02f, -8.65326151e-02f, -2.17366070e-02f, 1.09016290e-02f, 4.14331816e-03f, -1.32319890e-02f, -7.32411295e-02f,
  -1.71146635e-02f, -9.10202190e-02f, -2.63881385e-02f, -9.46949050e-03f, 1.08798355e-01f, -2.97796391e-02f, 9.05149803e-02f, 2.00062748e-02f, -5.65165356e-02f, 8.05498660e-03f,
  -1.17706217e-01f, -1.37086540e-01f, -3.32295559e-02f, 4.34225425e-02f, -1.13590364e-03f, -9.87106282e-03f, -3.40611525e-02f, 8.87203589e-02f, -1.09926455e-01f, -1.86608117e-02f,
  -1.07986800e-01f, 3.47042158e-02f, 9.83041339e-03f, -3.20973434e-03f, -5.41510396e-02f, -1.25368118e-01f, 7.76654854e-02f, -8.07041898e-02f, -4.42310013e-02f, 4.65229433e-03f,
  -3.99159007e-02f, -1.16250487e-02f, 6.42095432e-02f, 3.18924710e-02f, 1.58629250e-02f, -3.31273116e-02f, -3.83428186e-02f, 4.05264869e-02f, -9.18090343e-02f, -7.81055465e-02f,
  -5.24813652e-01f, 6.65973723e-02f, -2.73295969e-01f, -3.22352489e-03f, -2.40868345e-01f, 4.65273373e-02f, 4.51533832e-02f, -1.97478980e-01f, -2.45088354e-01f, 9.95067358e-02f,
  -8.75704810e-02f, -1.56628191e-01f, 1.47008598e-01f, 1.26563191e-01f, -1.56058177e-01f, 3.16178858e-01f, 1.27791792e-01f, 2.29408802e-03f, 4.33564521e-02f, -1.40659148e-02f,
  5.88126741e-02f, 2.12434590e-01f, 1.94667444e-01f, 9.40649882e-02f, -6.92688152e-02f, -1.01450861e-01f, -9.65437219e-02f, -4.61750217e-02f, 2.95859426e-02f, -1.29916072e-01f,
  -1.54483870e-01f, -2.49692276e-01f, -8.92377049e-02f, -1.10522628e-01f, -3.85575034e-02f, 3.26382443e-02f, -4.57693040e-02f, -2.71130744e-02f, 2.79135574e-02f, 2.63278373e-02f,
  4.55022156e-02f, -8.57098997e-02f, 6.04055040e-02f, -1.77637450e-02f, -4.09992337e-02f, -1.08216099e-01f, 9.01905149e-02f, 9.92754176e-02f, -2.06473097e-02f, -3.89771536e-04f,
  -5.01451967e-03f, 8.21827538e-03f, -7.04565085e-03f, 1.37752099e-02f, 8.94689839e-03f, 3.38662229e-02f, 3.36457454e-02f, -3.08423396e-02f, -1.74056441e-02f, -1.96808334e-02f,
  -6.88380748e-02f, -4.45041358e-02f, 4.59713414e-02f, -1.43450722e-01f, 2.97118872e-02f, -5.17977886e-02f, 2.43102442e-02f, 5.09294309e-03f, -5.91643751e-02f, 7.86592066e-02f,
  -1.47037562e-02f, -4.55977879e-02f, 8.99304077e-03f, 6.86833858e-02f, 7.40936249e-02f, -1.18119143e-01f, 8.17812979e-02f, -1.35592058e-01f, 5.79937473e-02f, -2.25450564e-02f,
  -7.02917855e-03f, -4.10702527e-02f, -2.03721803e-02f, 5.86691201e-02f, 1.47245526e-02f, -1.17148813e-02f, 8.28015804e-03f, 3.92163955e-02f, 7.22266957e-02f, 9.89686605e-03f,
  -2.32790351e-01f, -2.34111980e-01f, -1.63189292e-01f, -8.71818960e-02f, -5.08405566e-02f, 2.64699105e-02f, 6.04547225e-02f, -2.77051460e-02f, 2.23136041e-02f, -1.14662990e-01f,
  -1.19010568e-01f, -3.69477309e-02f, -6.67718351e-02f, -5.52357845e-02f, 4.52699177e-02f, -3.61567438e-02f, -7.62850344e-02f, 6.38065860e-02f, -4.03688811e-02f, -8.43648687e-02f,
  -6.15357123e-02f, -5.13008721e-02f, 5.10531105e-02f, 6.43870085e-02f, 8.69523957e-02f, -5.21899350e-02f, -1.08349010e-01f, -1.81321446e-02f, 1.42241195e-01f, -4.99044098e-02f,
  -3.25452358e-01f, -5.49145788e-02f, -2.21806034e-01f, -1.81097776e-01f, 3.29539686e-01f, 1.51179684e-02f, -1.14700973e-01f, 8.21035448e-03f, -3.02784771e-01f, -1.49594858e-01f,
  -7.73701221e-02f, -5.21412455e-02f, -1.66837379e-01f, -2.39615947e-01f, -2.24164039e-01f, -1.86231315e-01f, -2.14521617e-01f, -1.88185036e-01f, 3.94559316e-02f, -6.53700382e-02f,
  1.80321485e-02f, 1.39524177e-01f, -5.85820526e-02f, 3.32774907e-01f, 3.44848796e-03f, 1.32636473e-01f, -5.34576178e-02f, 1.33894220e-01f, 1.13138363e-01f, 2.15964660e-01f,
  -1.32343978e-01f, -2.64804155e-01f, -2.26090670e-01f, -1.20065436e-01f, -1.35796070e-01f, -6.10384829e-02f, -5.69707453e-02f, 7.35431015e-02f, -8.11041892e-02f, 2.12822556e-02f,
  7.41210356e-02f, 8.35762993e-02f, 6.10416830e-02f, 8.07459950e-02f, 3.99798937e-02f, 5.85933551e-02f, 1.24477610e-01f, -6.43171230e-03f, -9.62577295e-03f, -3.21664028e-02f,
  -2.55578663e-02f, -8.94721597e-02f, -6.01923279e-02f, 2.09678728e-02f, -5.02005517e-02f, 6.66556284e-02f, -3.99528779e-02f, 5.42141721e-02f, -4.33405749e-02f, -3.81897204e-02f,
  7.42860436e-02f, 7.18089566e-02f, 9.70398784e-02f, -1.33096473e-02f, 3.28969881e-02f, 3.50589938e-02f, -9.08984020e-02f, -8.60596001e-02f, 2.56866571e-02f, 5.63240014e-02f,
  -2.33226102e-02f, -1.04245804e-02f, 5.71974292e-02f, -1.13023952e-01f, 3.05788778e-03f, 2.13009631e-03f, 6.33195788e-02f, -1.50916338e-01f, 3.21835279e-02f, 2.13690698e-02f,
  -8.38341191e-03f, -3.06438971e-02f, 5.27940392e-02f, -9.08654369e-03f, -1.15834758e-01f, -6.34194613e-02f, -8.61886069e-02f, -6.41879067e-02f, -3.47215496e-02f, 4.36211750e-02f,
  -1.99220330e-01f, -2.44659603e-01f, -9.41260830e-02f, -1.87369063e-02f, 6.14759177e-02f, -5.54908253e-02f, 4.22375314e-02f, 3.72602642e-02f, -3.25905085e-02f, -2.64498666e-02f,
  -2.49305144e-02f, 5.68060065e-03f, -4.49736044e-02f, -5.00665344e-02f, 2.58502848e-02f, -1.35405976e-02f, -8.86375085e-02f, -1.08100548e-01f, -7.22419098e-02f, 7.12961033e-02f,
  3.69046465e-05f, -5.94603233e-02f, 1.14196464e-01f, 8.32787380e-02f, -3.84866586e-03f, 3.88758928e-02f, 1.75264140e-03f, 3.19265351e-02f, -5.11290096e-02f, -1.29148550e-02f,
  -9.35156569e-02f, -4.62363986e-03f, -2.94632643e-01f, -5.81349954e-02f, -9.30915773e-02f, -2.11639449e-01f, -1.63382232e-01f, -9.16286409e-02f, -3.12520057e-01f, 9.46954489e-02f,
  8.36363435e-02f, -9.63790417e-02f, -4.08437513e-02f, 1.14000767e-01f, -1.88495174e-01f, 1.60795003e-01f, 4.52235080e-02f, -2.60585509e-02f, -8.02018307e-03f, -4.11770679e-02f,
  9.87960547e-02f, 2.90405571e-01f, 1.44997463e-01f, 9.44318399e-02f, 2.57996172e-02f, 8.41427688e-03f, 9.13728625e-02f, 1.14026904e-01f, 5.06909229e-02f, -5.51702753e-02f,
  8.08513984e-02f, -3.17842998e-02f, -1.42686516e-01f, -1.31783977e-01f, -4.15362567e-02f, -8.05309862e-02f, -2.91246735e-02f, 1.51920184e-01f, -3.32322568e-02f, -4.75417189e-02f,
  -2.72676791e-03f, 4.36073951e-02f, 5.23065068e-02f, -7.78945312e-02f, -4.05182540e-02f, -4.91510704e-02f, -1.42078884e-02f, -8.13211277e-02f, -4.27240320e-02f, 1.39909275e-02f,
  -1.14896961e-01f, -5.74621931e-02f, -4.91416492e-02f, 3.45594482e-03f, -8.35301951e-02f, -4.16914783e-02f, -7.59089505e-03f, 1.97429024e-02f, 5.81505336e-02f, -6.13475628e-02f,
  4.66595078e-03f, 8.38133544e-02f, -1.13033503e-01f, -4.14456464e-02f, -7.43895769e-02f, 5.80115616e-02f, -9.23405588e-02f, 6.49672598e-02f, -6.25407472e-02f, 2.18796562e-02f,
  -3.80954407e-02f, 2.31416412e-02f, -2.94317491e-02f, 5.95821850e-02f, 4.57405001e-02f, 3.27568017e-02f, 3.21273394e-02f, 8.50235764e-03f, 9.61572453e-02f, -6.41822666e-02f,
  3.80782187e-02f, -4.74111782e-03f, -2.89913453e-02f, 6.99166162e-03f, -3.10216881e-02f, 1.42165180e-02f, 7.94541165e-02f, 2.15371512e-02f, -1.64306015e-02f, -5.57082668e-02f,
  -1.72095206e-02f, -4.35206927e-02f, -5.41972145e-02f, -2.65823640e-02f, -5.65958209e-02f, 5.00560068e-02f, -5.27279032e-03f, 9.87853631e-02f, -1.01977207e-01f, -1.42870992e-01f,
  -4.51272214e-03f, 2.47930549e-02f, 1.28918856e-01f, -2.56401524e-02f, 3.29358876e-02f, 4.56955470e-02f, -7.16395155e-02f, -8.73783231e-02f, -1.06302999e-01f, -4.25738059e-02f,
  2.35635601e-02f, -6.19480666e-03f, -9.67888981e-02f, -4.75954376e-02f, -3.62321325e-02f, -6.60952032e-02f, -5.58528826e-02f, 1.01214275e-01f, 3.55925485e-02f, -2.38818750e-02f,
  -3.22801650e-01f, -4.83301431e-02f, 2.86903322e-01f, -3.28647763e-01f, 3.28791402e-02f, 2.55627096e-01f, 9.11305472e-02f, 5.27977012e-02f, -2.35683501e-01f, -1.40988767e-01f,
  -4.61384356e-02f, -1.18127592e-01f, 4.57318313e-02f, -1.68805540e-01f, 1.25820979e-01f, 1.43516466e-01f, 3.32127512e-02f, -1.09199313e-02f, 4.73173708e-02f, -4.10552993e-02f,
  -1.06163621e-01f, -1.88262269e-01f, 9.72163081e-02f, -3.72031964e-02f, -1.14838414e-01f, -1.14153236e-01f, -2.14663833e-01f, 1.05622970e-01f, -2.08362311e-01f, 8.72481987e-02f,
  1.05722561e-01f, 4.10811901e-02f, 1.73193470e-01f, 1.16054997e-01f, -4.33174185e-02f, -5.80504350e-02f, 4.24231887e-02f, 4.32487205e-02f, 3.03163417e-02f, 5.34139797e-02f,
  -6.17074333e-02f, -2.27672234e-02f, -5.65533824e-02f, 9.26502720e-02f, 1.99323911e-02f, 4.41646054e-02f, -3.84041667e-03f, -4.30758670e-02f, -5.04815876e-02f, -8.30487162e-03f,
  6.32303208e-02f, 9.75159332e-02f, 2.94074435e-02f, -1.24042980e-01f, -2.23488603e-02f, -7.43260840e-03f, -3.36344279e-02f, 9.71764922e-02f, -4.26069349e-02f, -3.65345776e-02f,
  -1.36655375e-01f, -2.48657558e-02f, 6.35802746e-02f, 6.36161771e-03f, 7.48683605e-03f, -1.16545865e-02f, -1.98463537e-02f, 2.58995201e-02f, 4.74343263e-02f, -5.78883998e-02f,
  -3.31477188e-02f, 2.64025526e-04f, 1.28304169e-01f, 1.41446767e-02f, -7.78294802e-02f, -9.09749940e-02f, -7.97192100e-03f, 6.07357062e-02f, -6.61898497e-03f, -3.84272188e-02f,
  -2.08897479e-02f, 7.54458532e-02f, 3.62188518e-02f, 3.36305127e-02f, -1.41515909e-02f, -2.88330670e-02f, -1.22852959e-01f, 4.05922830e-02f, 5.43023571e-02f, -3.56987379e-02f,
  1.05878152e-01f, 8.57419968e-02f, 3.00577376e-02f, 1.00013658e-01f, 8.74871537e-02f, 5.52144367e-03f, 5.86520955e-02f, -1.12078130e-01f, -1.04857115e-02f, 1.61884502e-02f,
  -5.36687765e-03f, -3.14361714e-02f, -3.29974294e-02f, -1.02436254e-02f, 9.05227959e-02f, 1.08955532e-01f, -7.83631578e-02f, -4.30960357e-02f, -6.60117269e-02f, 9.36846659e-02f,
  7.68487826e-02f, 7.32947066e-02f, -1.45263020e-02f, -1.01208821e-01f, 3.90747376e-02f, -2.24616583e-02f, -8.96384865e-02f, -6.55874163e-02f, 5.41480072e-03f, -1.48801627e-02f,
  -1.12267703e-01f, -3.67185920e-02f, -1.43460765e-01f, -1.09093145e-01f, 2.39856392e-02f, -1.83011442e-01f, -6.18486106e-02f, 8.28814879e-02f, -9.70851034e-02f, 1.99967101e-01f,
  -7.34382961e-03f, -1.94998719e-02f, 4.28167097e-02f, -2.97758073e-01f, -2.60683388e-01f, -2.65774876e-01f, -1.31525978e-01f, -1.66319594e-01f, -1.39542431e-01f, 1.42601598e-02f,
  -5.91380894e-02f, -4.07138653e-02f, -2.07544833e-01f, 6.62326217e-02f, -5.15587442e-02f, 1.89009711e-01f, 2.72782326e-01f, 7.17260092e-02f, -2.15999540e-02f, -4.89169359e-03f,
  -1.34353623e-01f, 3.70349176e-02f, 1.56267248e-02f, 7.87154771e-03f, 1.35258391e-01f, 8.08345005e-02f, 1.04008824e-01f, -8.73669833e-02f, 2.80275829e-02f, -5.43943699e-03f,
  -4.00598161e-02f, 5.27584413e-03f, -5.51885068e-02f, -7.23322779e-02f, -5.01672290e-02f, -1.98391061e-02f, -2.16262974e-02f, 3.72789837e-02f, -2.09014136e-02f, -4.18666489e-02f,
  -7.50132129e-02f, -2.38744486e-02f, 8.22354555e-02f, 2.15140008e-03f, 4.15892564e-02f, 1.00664154e-01f, 3.05249263e-02f, -3.26334722e-02f, -5.48800938e-02f, -5.83643988e-02f,
  6.49271533e-02f, -1.03462720e-02f, -1.03957094e-01f, -1.52659774e-01f, 5.52928122e-03f, 7.29525015e-02f, 7.29090795e-02f, 4.73090969e-02f, 5.84680215e-02f, 1.37955612e-02f,
  -2.32426147e-03f, 3.80466469e-02f, -5.77617474e-02f, 2.34966576e-02f, 2.64320727e-02f, 4.60886583e-02f, -1.37433261e-02f, 6.61163554e-02f, -2.23954972e-02f, -1.27015701e-02f,
  1.01108477e-01f, -4.56925333e-02f, -8.18269998e-02f, -4.42429706e-02f, -1.11737043e-01f, 2.23934334e-02f, -3.04928020e-04f, -3.09317764e-02f, -1.01594754e-01f, -5.21761402e-02f,
  9.62520316e-02f, 2.00849563e-01f, -5.14181890e-02f, -2.93799080e-02f, 4.35256176e-02f, 7.05348980e-03f, -2.68718917e-02f, -1.29662463e-02f, 6.86205253e-02f, 7.02692568e-02f,
  9.26400125e-02f, -6.21536113e-02f, 1.10532336e-01f, -4.85452451e-02f, -3.08085904e-02f, 3.29614617e-02f, 1.20903123e-02f, 4.90514114e-02f, 1.18477471e-01f, 6.09263079e-03f,
  8.83503482e-02f, 2.21139770e-02f, 2.08697971e-02f, -5.67063466e-02f, 8.33798870e-02f, 8.40454176e-02f, 3.75633575e-02f, 2.31311526e-02f, 5.59261441e-02f, -6.49145397e-04f,
  7.50325099e-02f, -2.77266473e-01f, 1.26023948e-01f, -1.17997050e-01f, 3.99553515e-02f, 8.91335532e-02f, 1.48443207e-01f, -2.67138243e-01f, -9.45232585e-02f, -1.33812875e-01f,
  7.24905953e-02f, 2.06703633e-01f, 2.26018503e-01f, -2.38953605e-02f, 3.42154026e-01f, 1.14086933e-01f, -1.01908624e-01f, 9.37094633e-03f, -1.05293512e-01f, -7.68404379e-02f,
  -2.54772278e-03f, -1.56942472e-01f, 7.46359676e-02f, -2.87666351e-01f, -1.27141148e-01f, -8.53175595e-02f, 7.97522068e-02f, 1.02042019e-01f, -7.71070346e-02f, 7.57530183e-02f,
  -1.01217993e-01f, -1.45393431e-01f, -6.63012564e-02f, -1.20249745e-02f, -6.23047911e-02f, 4.30733673e-02f, 1.61879510e-02f, 1.39620185e-01f, -1.07576601e-01f, -1.15237921e-01f,
  -9.95016377e-03f, 8.20729584e-02f, -6.60961941e-02f, -6.02616370e-02f, -1.89141616e-01f, -4.81605269e-02f, -9.53673571e-02f, -6.80352002e-02f, 9.83656012e-03f, 8.38521123e-02f,
  7.05517903e-02f, 8.83164406e-02f, 9.90270972e-02f, -9.96849686e-03f, -1.16266795e-02f, -6.84403852e-02f, 4.46247123e-02f, 1.51688069e-01f, -1.17701732e-01f, 2.78800838e-02f,
  -4.41701300e-02f, -4.24115406e-03f, 2.16665789e-02f, 2.04296261e-02f, 4.51986715e-02f, 1.22900875e-02f, -3.09392121e-02f, 6.34723231e-02f, 1.44034997e-03f, -2.70230751e-02f,
  2.45877933e-02f, -3.45949754e-02f, 1.89643782e-02f, 1.59872565e-02f, -5.29042967e-02f, 5.81709668e-03f, 1.84753969e-01f, -1.46131357e-02f, 9.64772552e-02f, 5.52890599e-02f,
  -7.14743435e-02f, 2.01937854e-02f, 7.33196642e-03f, -4.76315841e-02f, 5.89121729e-02f, 1.06172241e-01f, 2.98496131e-02f, 5.77215552e-02f, -5.11846878e-02f, 5.66673130e-02f,
  -2.21150115e-01f, -2.27242857e-01f, -9.89520997e-02f, -7.95712173e-02f, -1.15132973e-01f, -5.57136610e-02f, -3.01554725e-02f, -9.99517962e-02f, -3.31691690e-02f, 7.50164082e-03f,
  -1.13094129e-01f, 8.13801363e-02f, -5.45580685e-02f, 3.56567767e-03f, -1.35089844e-01f, -1.45731211e-01f, -5.63707463e-02f, -1.12029146e-02f, -8.44404176e-02f, 3.70371006e-02f,
  8.26410949e-02f, -1.01794899e-02f, 1.44331098e-01f, -1.24546431e-01f, -2.95112822e-02f, 1.58103198e-01f, 2.54049245e-02f, 9.01030526e-02f, -4.40882966e-02f, 4.97132726e-02f,
  -3.39748204e-01f, -6.10229895e-02f, -2.02198029e-01f, 1.61984086e-01f, -1.07444666e-01f, -1.24878496e-01f, 1.49943277e-01f, 3.00319083e-02f, 1.86245888e-02f, 2.50733495e-01f,
  2.32037261e-01f, -9.54066366e-02f, 1.86799213e-01f, 2.63843775e-01f, -3.05730790e-01f, 8.13050047e-02f, 1.75472368e-02f, 1.07757092e-01f, -6.07815944e-02f, -1.44632876e-01f,
  -7.08709210e-02f, 1.70082033e-01f, 2.47728694e-02f, 1.24103101e-02f, -6.27975464e-02f, -3.18637490e-02f, 1.07044242e-01f, -7.28983432e-02f, 5.27557433e-02f, -8.54126140e-02f,
  -1.17985882e-01f, 5.18081374e-02f, 9.46855322e-02f, -3.73033434e-02f, 4.92637642e-02f, -9.59899556e-03f, -3.85498591e-02f, 3.53126861e-02f, 1.03913330e-01f, -3.10047101e-02f,
  -2.26577520e-02f, -3.89571078e-02f, -4.26044688e-03f, 4.77274358e-02f, -5.41964620e-02f, -7.11475164e-02f, 6.12330250e-02f, 2.79181991e-02f, 5.13123646e-02f, -6.46038502e-02f,
  -4.84185368e-02f, -1.44822402e-02f, 2.48239972e-02f, 4.83652614e-02f, 5.67579642e-02f, 3.95676941e-02f, -4.76418808e-03f, -4.63616252e-02f, 1.34599265e-02f, -1.04995251e-01f,
  -1.87779311e-02f, -5.02644703e-02f, 8.40622410e-02f, 3.44420150e-02f, 8.38036463e-02f, 8.38138908e-02f, 1.51458867e-02f, 7.24868476e-02f, -6.27515763e-02f, -2.24547796e-02f,
  6.91803470e-02f, -5.30693457e-02f, 7.95421004e-02f, 7.79302716e-02f, 4.73303758e-02f, -6.54487461e-02f, -1.24395162e-01f, -8.26131478e-02f, -1.11244367e-02f, 3.12214419e-02f,
  7.05819502e-02f, -2.52316110e-02f, -3.91455218e-02f, -6.57439604e-03f, 1.08137578e-02f, -2.75743436e-02f, 5.49933314e-02f, 5.68645261e-03f, 4.17113751e-02f, -9.65640694e-02f,
  -2.69917488e-01f, -1.58262655e-01f, 9.34624579e-03f, -2.68864795e-04f, 2.23630350e-02f, -7.61351967e-03f, -6.03444763e-02f, -9.13998410e-02f, -1.01182565e-01f, -5.15294597e-02f,
  -7.59137869e-02f, -1.72219668e-02f, -1.42086968e-01f, 4.07973025e-03f, 1.67396776e-02f, -1.35902241e-02f, -2.86508091e-02f, 1.03155226e-02f, -1.01741683e-02f, -9.91841778e-03f,
  -4.90925349e-02f, -7.55702928e-02f, -1.18961222e-02f, -3.52476491e-03f, 1.27061442e-01f, 9.28137742e-04f, -7.54704922e-02f, -7.34226685e-03f, -5.45867085e-02f, -1.11337369e-02f,
  1.04060099e-01f, -1.34664685e-01f, -8.50350261e-02f, 3.29632498e-02f, -1.16723124e-02f, -2.18184382e-01f, -4.90141436e-02f, -2.23557085e-01f, 5.46957217e-02f, -2.49675736e-01f,
  1.03200674e-01f, 8.90718177e-02f, 1.50402918e-01f, -1.21179633e-01f, 3.96415979e-01f, 2.23557934e-01f, -8.59397873e-02f, 2.56776158e-02f, -2.30217203e-02f, 6.40071929e-03f,
  4.14314866e-03f, -9.88588184e-02f, 3.39578018e-02f, -3.03379893e-01f, -1.51706949e-01f, -9.55590606e-02f, 7.31710866e-02f, -1.00427806e-01f, -1.90765530e-01f, 8.66628066e-02f,
  -9.89233255e-02f, 3.51690426e-02f, -9.87769440e-02f, -8.77993777e-02f, -1.30432829e-01f, 1.73898358e-02f, 4.16815653e-02f, 9.35580730e-02f, 1.09747283e-01f, -3.45424563e-02f,
  6.38609752e-02f, 8.12354013e-02f, -1.58047825e-02f, 4.41521369e-02f, -1.71496317e-01f, -3.29600945e-02f, -2.76186615e-02f, 3.61645818e-02f, -4.47825901e-02f, -1.86198466e-02f,
  4.22092453e-02f, -9.97580495e-03f, -5.63093349e-02f, -5.27863018e-02f, 8.54034275e-02f, 3.35185304e-02f, -1.58259757e-02f, 7.39278346e-02f, 1.12498468e-02f, 4.26376462e-02f,
  -1.15836978e-01f, 3.12848613e-02f, -9.83918980e-02f, -8.18718076e-02f, -7.74528831e-02f, 2.97171087e-03f, 2.16190354e-03f, -5.79374135e-02f, 8.33824724e-02f, -2.66624335e-02f,
  9.34444927e-03f, 1.24441095e-01f, 2.77134916e-03f, 3.48066213e-03f, 5.52565195e-02f, -2.07788013e-02f, 2.59367544e-02f, -8.85330886e-03f, 6.01992160e-02f, -2.78570894e-02f,
  1.28648793e-02f, 1.16839632e-02f, -2.88828090e-02f, 5.34098893e-02f, -1.63688790e-02f, -3.00574536e-03f, -1.25244036e-01f, -6.07060567e-02f, 3.76169011e-02f, 1.23496661e-02f,
  -3.46742459e-02f, -5.08741774e-02f, -1.61123779e-02f, 2.63898261e-02f, -7.41574392e-02f, 1.09788679e-01f, 1.51150478e-02f, 2.29389537e-02f, 2.34606098e-02f, -4.50182520e-02f,
  -8.28194842e-02f, -1.55960377e-02f, -4.77383360e-02f, 1.04543716e-02f, 1.31671708e-02f, 1.86338220e-02f, 8.20623189e-02f, 7.09293857e-02f, 5.22529781e-02f, 6.93184584e-02f,
  -3.22898962e-02f, -1.63785070e-02f, 3.63843865e-03f, -5.59325963e-02f, 4.81183045e-02f, 7.94491693e-02f, -2.06221268e-03f, -1.37042515e-02f, 5.34796081e-02f, -1.40925851e-02f,
  1.75572842e-01f, -1.25171080e-01f, -8.18893984e-02f, -1.05972007e-01f, 4.84632179e-02f, -5.59171326e-02f, 9.69581306e-03f, -1.99073881e-01f, -1.51170930e-02f, -3.09316516e-01f,
  9.14420485e-02f, -2.35782117e-02f, -7.24889636e-02f, -7.29513094e-02f, 4.24387723e-01f, 4.25903723e-02f, 8.98061972e-03f, 1.28258720e-01f, -3.83555330e-02f, -9.04679149e-02f,
  -2.35975105e-02f, -5.00323065e-02f, -1.73044086e-01f, -1.99375987e-01f, -1.25294417e-01f, -2.04135761e-01f, 1.65971085e-01f, 3.49566713e-03f, -1.05879359e-01f, 2.17604190e-02f,
  2.02540308e-02f, -5.74071379e-03f, -9.23729166e-02f, 3.53193209e-02f, -1.04946211e-01f, -2.04664692e-02f, -5.37362359e-02f, 8.68793726e-02f, 2.67061982e-02f, -1.06968030e-01f,
  1.24719240e-01f, 5.99705949e-02f, -2.98433825e-02f, 1.11028753e-01f, -8.96952823e-02f, -1.09408490e-01f, 3.22648250e-02f, 2.24359240e-02f, 1.45235723e-02f, 3.19545995e-03f,
  -6.72002286e-02f, -5.58220856e-02f, 8.94914493e-02f, 4.90774438e-02f, 6.87923506e-02f, 7.59901926e-02f, -8.27759951e-02f, 1.86479334e-02f, 5.29758073e-02f, -1.33558139e-01f,
  -3.76246572e-02f, 3.40260975e-02f, -5.91111034e-02f, -1.16743380e-02f, 2.20856834e-02f, -6.15847260e-02f, 1.61219183e-02f, -9.99367423e-03f, -1.72993183e-04f, 6.61337748e-02f,
  -1.59035083e-02f, -9.03504714e-02f, -4.91069704e-02f, -4.41670604e-02f, 2.05263719e-02f, 1.48887455e-03f, 5.01736924e-02f, -6.16635792e-02f, -3.13551165e-02f, 4.11459021e-02f,
  3.98626365e-02f, 5.48647083e-02f, -3.96387242e-02f, -2.74791438e-02f, 2.39826478e-02f, -1.48500083e-03f, -1.86288580e-02f, -5.85238682e-03f, -3.67077887e-02f, -2.02944949e-02f,
  4.44652401e-02f, -2.50389457e-01f, -1.72390081e-02f, 6.11377396e-02f, 6.07695198e-03f, 2.71667354e-02f, -4.74046320e-02f, -4.98185009e-02f, 5.42031191e-02f, 9.74461716e-03f,
  -6.44664317e-02f, -3.25248502e-02f, -6.46867827e-02f, 5.68380505e-02f, 8.52407515e-02f, -6.02171058e-03f, 8.22136998e-02f, -2.95668039e-02f, -4.71283607e-02f, -2.00856384e-02f,
  5.48907034e-02f, -6.19650669e-02f, 2.30451487e-02f, -4.97660041e-02f, -5.44157065e-02f, 1.31802455e-01f, -4.47606295e-02f, 1.30305290e-01f, 6.79559112e-02f, 6.05653797e-04f,
  3.00253898e-01f, -1.16112962e-01f, 2.13701189e-01f, 1.78940445e-01f, 8.97119120e-02f, -4.97477781e-03f, 6.65277019e-02f, -4.12577800e-02f, 1.60722807e-02f, -6.27748296e-02f,
  6.26744628e-02f, 1.03912279e-01f, -2.25838304e-01f, 1.00487739e-01f, -1.11292727e-01f, -1.76035985e-01f, -7.51809925e-02f, 1.04815893e-01f, 3.50247249e-02f, 8.43933001e-02f,
  5.04872948e-02f, -1.60419479e-01f, -8.73845294e-02f, -1.06650241e-01f, 1.08126253e-01f, 1.04872525e-01f, -1.09888658e-01f, -8.32100064e-02f, 1.07698239e-01f, -7.20146745e-02f,
  8.53093341e-02f, -3.82754914e-02f, 5.46837039e-02f, 3.86074036e-02f, -6.17753454e-02f, -1.41576510e-02f, 3.63275260e-02f, -2.53086872e-02f, 1.41168348e-02f, -1.55095896e-02f,
  1.06626838e-01f, 2.25281604e-02f, 1.33394450e-03f, -6.25649914e-02f, 2.71627884e-02f, 8.54246244e-02f, 6.46203533e-02f, 4.66039069e-02f, 2.16755588e-02f, -1.17071031e-03f,
  1.16458789e-01f, 7.25638866e-02f, -2.91618966e-02f, 5.39537482e-02f, 4.09087427e-02f, 5.14547899e-02f, 7.09508732e-02f, 1.30293919e-02f, 4.82884096e-03f, -8.21343437e-02f,
  -1.41702756e-01f, 4.58665714e-02f, -1.88638549e-02f, 1.92954484e-02f, 5.54625429e-02f, 3.26851979e-02f, -5.06245382e-02f, -5.93697727e-02f, -5.04473522e-02f, -2.14316393e-03f,
  7.80268013e-02f, 6.14754148e-02f, 1.38409004e-01f, 6.30134344e-02f, -7.05455020e-02f, -3.03848577e-03f, -2.49489602e-02f, 5.44535816e-02f, 1.24877319e-02f, -7.41358399e-02f,
  -3.50576863e-02f, 2.06886455e-02f, -8.89896080e-02f, -5.00496365e-02f, 3.03742122e-02f, 1.93469077e-02f, -8.94827861e-03f, -3.27713341e-02f, 3.82224768e-02f, 1.67429447e-02f,
  -2.05193963e-02f, -1.75200716e-01f, -6.46203160e-02f, 4.65051569e-02f, -1.50337545e-02f, -7.79026523e-02f, 7.08657652e-02f, -1.80534255e-02f, -1.02222636e-01f, -1.71652380e-02f,
  1.57915264e-01f, 1.27633199e-01f, -8.78779888e-02f, 5.09544685e-02f, -3.94436494e-02f, -7.27091432e-02f, -5.22409566e-02f, 9.48894303e-03f, 6.90887123e-02f, -1.90282017e-02f,
  6.14570789e-02f, 2.48441771e-02f, -4.64421660e-02f, -6.48753904e-03f, 4.92016748e-02f, -1.16140440e-01f, 8.53408501e-02f, 9.24167857e-02f, -5.98360486e-02f, -6.38344232e-03f,
  -4.77640241e-01f, 1.73079103e-01f, -2.56817579e-01f, 2.37508919e-02f, 9.19702351e-02f, 4.25786525e-02f, -3.61135565e-02f, 3.49983200e-02f, -1.12261765e-01f, 2.33993873e-01f,
  -3.75845749e-03f, -2.31045872e-01f, 2.70981696e-02f, -1.36814490e-02f, -2.66591579e-01f, -6.79191872e-02f, -1.15449883e-01f, -3.09141874e-02f, -1.43459290e-02f, -3.04188505e-02f,
  -7.02316165e-02f, 8.96260366e-02f, -9.51210484e-02f, 1.05458468e-01f, 2.72201421e-03f, -4.39792387e-02f, 9.27579403e-02f, 6.80866987e-02f, 1.41706914e-01f, 6.22863397e-02f,
  3.06328479e-02f, -2.70121954e-02f, -7.10653141e-02f, -1.61326960e-01f, -3.16275023e-02f, -3.55659127e-02f, 8.53468925e-02f, -3.89196388e-02f, 8.67851451e-02f, 2.17041168e-02f,
  -4.47522216e-02f, -1.04728537e-02f, -6.68170443e-03f, -6.08922960e-03f, -2.12144218e-02f, -1.19176611e-01f, 8.86528268e-02f, -1.65623516e-01f, 1.38752647e-02f, 6.71761110e-02f,
  -3.36382948e-02f, 2.35220743e-03f, -1.00698173e-02f, 5.82344607e-02f, -4.50109877e-02f, 7.21777007e-02f, 4.67025079e-02f, 2.58642863e-02f, 1.18053649e-02f, -3.64495418e-03f,
  -1.76978279e-02f, -5.85831180e-02f, 3.41946236e-03f, -1.04734994e-01f, 9.27979499e-02f, 4.83914874e-02f, 3.41951400e-02f, 3.35651524e-02f, -1.01336874e-01f, -2.68134419e-02f,
  -9.77687351e-03f, 4.56322283e-02f, -2.76133139e-02f, -6.82937494e-03f, 8.29935819e-03f, 3.61150801e-02f, -6.59454912e-02f, -3.43670659e-02f, 1.16243288e-02f, -5.57816699e-02f,
  -3.57095711e-02f, -2.34626178e-02f, 7.01144338e-02f, 4.36373521e-03f, 9.41157192e-02f, -2.01784819e-02f, -6.67415932e-03f, 8.56831223e-02f, 3.05662192e-02f, 5.18782958e-02f,
  1.76919132e-01f, 2.05800787e-01f, 3.25630344e-02f, 1.97053719e-02f, 5.26372194e-02f, 7.76157388e-03f, -1.34246219e-02f, -1.96679384e-02f, 5.16779609e-02f, 5.20587452e-02f,
  7.37434775e-02f, 2.76696794e-02f, -5.65252043e-02f, -3.11935712e-02f, -2.74953134e-02f, -2.59914137e-02f, 1.23958729e-01f, -4.51612771e-02f, 6.78854138e-02f, 1.20875321e-01f,
  1.61120251e-01f, 6.81202635e-02f, -4.56908606e-02f, -3.26637737e-02f, 3.74969691e-02f, -5.16802631e-02f, 4.16830294e-02f, 4.20898385e-02f, 6.77846000e-02f, -2.46293917e-02f,
  -1.29535407e-01f, 1.37538940e-01f, -1.12918906e-01f, -1.02664895e-01f, -2.06598788e-01f, 5.98197095e-02f, 1.18760534e-01f, -1.81707740e-03f, 1.95695400e-01f, 2.47261867e-01f,
  2.01556608e-02f, 1.00258261e-01f, 7.41930082e-02f, -8.36119056e-02f, -1.25009999e-01f, -6.34722114e-02f, -1.79001838e-02f, 1.44769073e-01f, 4.41783145e-02f, -1.54932095e-02f,
  -1.05303824e-01f, -1.71282053e-01f, -2.91571021e-01f, -1.13307983e-01f, -9.07334685e-02f, 8.06463659e-02f, -1.25871107e-01f, -7.15409219e-02f, -2.19613519e-02f, 7.27301836e-02f,
  -4.62233797e-02f, 5.95402457e-02f, -3.34302038e-02f, 8.47365800e-03f, -5.43702021e-03f, -5.33871315e-02f, 2.96370517e-02f, 3.69744338e-02f, 1.02230802e-01f, 1.16490684e-02f,
  -1.26867918e-02f, -7.44580850e-02f, 6.77751377e-03f, -3.94316018e-02f, -8.57095197e-02f, -2.26334352e-02f, 6.94478154e-02f, -6.21164143e-02f, 4.84114476e-02f, -1.16810091e-01f,
  -1.69030279e-01f, 2.52802717e-03f, -2.76732352e-02f, 7.17665330e-02f, -8.12819973e-02f, 5.85826114e-02f, 1.14151746e-01f, -1.49945468e-02f, 2.38952022e-02f, 1.10937029e-01f,
  -3.31978290e-03f, 1.12687424e-01f, 1.60121992e-02f, -2.69232178e-03f, 1.29075041e-02f, 3.90054472e-02f, 2.72292774e-02f, 8.74557346e-02f, 9.08541009e-02f, 1.88339259e-02f,
  -8.69393423e-02f, -8.47609416e-02f, -4.95574996e-03f, 1.04916833e-01f, 7.24641830e-02f, -9.46190115e-03f, -3.27397287e-02f, -3.59512977e-02f, -1.38423033e-02f, 2.51318980e-02f,
  1.01875558e-01f, 3.01130600e-02f, 3.67040001e-02f, -8.99559632e-02f, 6.24831393e-02f, -1.02726229e-01f, -2.58114915e-02f, 7.54002631e-02f, 5.54394275e-02f, -7.42490143e-02f,
  3.94604057e-02f, 3.44361603e-01f, 1.34430408e-01f, -5.06081469e-02f, 1.17444806e-02f, -4.39202078e-02f, -8.80009495e-03f, -1.38426311e-02f, 1.56936750e-01f, 6.99127614e-02f,
  4.29415554e-02f, 3.29034440e-02f, -2.08854191e-02f, -8.30881074e-02f, 2.22220998e-02f, 1.18795916e-01f, -2.22068019e-02f, -2.19461694e-02f, -3.83198671e-02f, -2.81401239e-02f,
  -9.79951322e-02f, 3.05811483e-02f, 3.52645554e-02f, 4.06551883e-02f, 1.12855555e-02f, 2.52027865e-02f, 6.64260536e-02f, -7.18811154e-02f, 2.44494863e-02f, -3.24560404e-02f,
  -4.39940058e-02f, -1.40087575e-01f, -2.00752407e-01f, -9.99023765e-02f, -4.73915562e-02f, -3.05942118e-01f, -2.53036529e-01f, -2.08514854e-01f, 3.65510508e-02f, -8.09425935e-02f,
  -1.19265653e-01f, -1.69271715e-02f, 1.12417839e-01f, -3.12472492e-01f, 9.27969515e-02f, 9.50960964e-02f, -2.25003585e-01f, -1.78601399e-01f, -7.59528205e-02f, -1.68720260e-01f,
  3.33115198e-02f, -1.66678786e-01f, -1.24460846e-01f, -1.80443138e-01f, -1.51715443e-01f, -7.97623321e-02f, 1.39347121e-01f, 4.09794152e-02f, -2.26936549e-01f, -3.34484736e-03f,
  -8.47103447e-02f, 1.27731293e-01f, 3.42145264e-02f, -6.58965111e-02f, -9.65045020e-02f, -2.16094274e-02f, -1.14854993e-02f, 4.39971201e-02f, -2.26501059e-02f, -2.69059725e-02f,
  -1.22608067e-02f, 1.06846593e-01f, -5.12845144e-02f, 8.70882645e-02f, -3.93517800e-02f, -1.02549009e-01f, 1.64504722e-02f, 4.81285155e-02f, -3.39984447e-02f, -1.28732875e-01f,
  -6.04350530e-02f, 8.10703337e-02f, -1.03311837e-02f, 1.37053400e-01f, 1.35761211e-02f, 3.19624543e-02f, 6.49681538e-02f, -1.41318627e-02f, 6.10912032e-02f, 1.04729302e-01f,
  8.65698159e-02f, -2.86070462e-02f, -7.22147599e-02f, -5.35370708e-02f, -4.70659584e-02f, -2.93436851e-02f, 1.53264701e-02f, 8.35299194e-02f, 1.92173962e-02f, -4.98041362e-02f,
  5.71015775e-02f, -3.57647287e-03f, -1.19350282e-02f, -3.58826891e-02f, -8.81833732e-02f, -1.72693990e-02f, 1.23993307e-01f, 4.32136431e-02f, 3.66171412e-02f, 3.85583229e-02f,
  6.43911138e-02f, 2.68410761e-02f, -1.09732226e-01f, 3.83149758e-02f, 8.68405588e-03f, 4.02409397e-02f, -4.14393693e-02f, 6.04004227e-03f, -1.08636871e-01f, -1.11633604e-02f,
  -4.47180830e-02f, 1.57270655e-01f, 3.56283679e-04f, -6.41770959e-02f, 4.64796536e-02f, 3.53961550e-02f, 1.51904738e-02f, -1.04675330e-02f, -3.21669690e-02f, -4.83135693e-02f,
  -6.34556115e-02f, -5.38888201e-02f, -1.47724245e-02f, -5.08379191e-03f, 5.26650157e-03f, -3.66378427e-02f, 4.90032099e-02f, 1.09084630e-02f, -2.80078743e-02f, -4.32799235e-02f,
  6.47101551e-02f, -1.75205246e-02f, 2.51297280e-02f, 1.93260740e-02f, -2.57484764e-02f, 3.69725120e-03f, 3.42676789e-02f, 1.78938080e-02f, 1.66553050e-01f, -5.67113841e-03f,
  2.68269897e-01f, -1.31277651e-01f, 1.10970646e-01f, 1.76779568e-01f, 2.29960352e-01f, -6.93135411e-02f, 7.42027089e-02f, -6.46937117e-02f, 1.70039922e-01f, -2.07541212e-01f,
  -7.17298016e-02f, 1.63800478e-01f, -2.29934752e-01f, 5.15674241e-02f, 4.07378115e-02f, -1.60248786e-01f, -2.97133215e-02f, 6.05780110e-02f, 6.66221306e-02f, 9.77478735e-03f,
  2.06600651e-01f, 7.58754164e-02f, 5.01658097e-02f, -1.72229990e-01f, 2.84285340e-02f, 9.86960009e-02f, -1.24567434e-01f, -2.01848805e-01f, 6.29605427e-02f, -5.70594147e-02f,
  4.60665040e-02f, 1.12195499e-01f, 7.08623156e-02f, -1.66887920e-02f, -6.83186352e-02f, 5.03556281e-02f, 5.33382297e-02f, -2.58584302e-02f, 8.95004719e-02f, 6.69901399e-03f,
  -5.64932711e-02f, -2.34820824e-02f, 1.00918971e-01f, 3.18956710e-02f, 2.07618818e-01f, -8.04500189e-03f, 3.09585277e-02f, 6.11789860e-02f, 1.22044012e-01f, 5.55750728e-02f,
  5.71675673e-02f, 7.14749992e-02f, -4.28216010e-02f, -1.57723781e-02f, 3.59267294e-02f, 3.63845602e-02f, -2.35458720e-03f, 8.12022109e-03f, -1.21540003e-01f, 5.31653948e-02f,
  -1.41374609e-02f, 5.28772958e-02f, -1.37969658e-01f, -4.39385772e-02f, 1.65172294e-02f, 1.48678035e-01f, 2.75165606e-02f, 2.41607238e-04f, -8.96743077e-05f, 7.01716691e-02f,
  3.18104364e-02f, 1.74773727e-02f, 8.63523111e-02f, -4.17151377e-02f, -8.13789014e-03f, 3.69195119e-02f, 5.71196079e-02f, -1.67855620e-01f, -8.62035751e-02f, 8.49347338e-02f,
  5.94934672e-02f, 4.95899692e-02f, -8.39769840e-02f, 6.12982959e-02f, -6.20939303e-03f, -2.72936691e-02f, -1.05309010e-01f, 2.40105335e-02f, 7.28395768e-03f, 5.70699684e-02f,
  -1.48731753e-01f, -2.89515138e-01f, 5.96526079e-02f, 4.66631353e-02f, -1.73465833e-02f, -1.10495966e-02f, -3.31576318e-02f, -2.15456430e-02f, 9.35151894e-03f, 1.03474343e-02f,
  -3.60285901e-02f, 5.30904680e-02f, -1.38970325e-02f, -9.43166669e-03f, 6.26792237e-02f, -3.81022505e-02f, -2.33004298e-02f, -5.98228686e-02f, 8.66921246e-02f, -7.44223595e-02f,
  -2.60328446e-02f, -3.03538004e-03f, -1.02164466e-02f, 5.31901792e-02f, 3.70930173e-02f, -5.86206540e-02f, -9.78785753e-02f, 8.90673921e-02f, -1.80975709e-03f, -4.54735868e-02f,
  -3.38967025e-01f, 2.91412771e-01f, 3.95753756e-02f, 2.21401438e-01f, 1.95174050e-02f, -1.57136559e-01f, -5.28519191e-02f, -5.58294989e-02f, 9.28028766e-03f, 1.44611105e-01f,
  -3.64192910e-02f, 1.42213637e-02f, 8.82966164e-03f, 1.12168685e-01f, -1.19237632e-01f, 1.44575208e-01f, 3.83031853e-02f, -1.35482192e-01f, 8.79459381e-02f, 1.35361865e-01f,
  -2.90759131e-02f, 1.14024259e-01f, 2.74544675e-02f, 5.21859266e-02f, -4.54555079e-02f, -5.77998273e-02f, -1.90627687e-02f, 1.40285805e-01f, 4.34604064e-02f, 5.33371083e-02f,
  7.78739750e-02f, 1.74177855e-01f, -8.65049437e-02f, -4.79684845e-02f, -1.08409122e-01f, -2.30574999e-02f, -1.93120450e-01f, -7.94339087e-03f, 6.09746277e-02f, -6.01510750e-03f,
  6.40129447e-02f, -7.29273707e-02f, -2.27879547e-02f, 1.36365732e-02f, -1.21076189e-01f, -6.96244463e-02f, 4.83165756e-02f, -1.69369817e-01f, 5.22373477e-03f, -4.04912457e-02f,
  8.22257400e-02f, 4.23751101e-02f, -5.39140590e-03f, 2.69774292e-02f, -7.10052485e-03f, 4.04978264e-03f, -3.55000654e-03f, -1.46262711e-02f, 4.32479754e-02f, -1.42825702e-02f,
  2.58322749e-02f, -5.20420447e-02f, -9.26433131e-02f, 4.41547483e-02f, 4.97330874e-02f, -1.18333295e-01f, -9.30406600e-02f, -2.38756146e-02f, -2.85362508e-02f, -1.24508487e-02f,
  -1.47548513e-02f, 6.86220650e-04f, -7.84709901e-02f, -8.45329612e-02f, 2.32753232e-02f, -6.48722127e-02f, 3.84762771e-02f, 1.32945195e-01f, 7.33383223e-02f, -3.34264189e-02f,
  1.00703053e-01f, -1.59791745e-02f, -3.68796550e-02f, -6.20753691e-02f, -6.15562722e-02f, 1.24073727e-02f, 2.28919238e-02f, -4.79420237e-02f, -2.52781734e-02f, 2.84795389e-02f,
  1.63607046e-01f, 3.23717564e-01f, 5.83405159e-02f, -1.56656608e-01f, 2.55000610e-02f, 1.24765765e-02f, 4.49683554e-02f, -2.00966070e-03f, 7.65558779e-02f, 5.15454598e-02f,
  -3.02544944e-02f, -4.19952869e-02f, 1.15511179e-01f, -8.23303778e-03f, 8.16759013e-04f, 1.00608759e-01f, 5.62604442e-02f, 7.21959099e-02f, -3.39494497e-02f, 1.15210731e-02f,
  -3.46097164e-02f, -7.07301199e-02f, 4.20414517e-03f, -4.44509424e-02f, -1.89015809e-02f, 5.99188656e-02f, -5.16009592e-02f, 2.94729229e-02f, 5.62349148e-02f, 7.58244423e-03f,
  -1.11522188e-03f, 3.22899759e-01f, 2.72612959e-01f, 1.19030289e-01f, -6.10665977e-02f, -6.06220663e-02f, -9.69323739e-02f, 7.28101507e-02f, 1.69613048e-01f, 3.16680856e-02f,
  -2.04545185e-01f, 3.22029024e-01f, -1.29536703e-01f, 1.04439422e-01f, -3.25421065e-01f, -1.94228917e-01f, -1.84318021e-01f, 1.78973973e-02f, 9.43747908e-02f, 1.10464968e-01f,
  -3.08007170e-02f, -2.77850688e-01f, -7.02386945e-02f, -4.07034867e-02f, 8.90509933e-02f, 9.20635164e-02f, -3.00935805e-01f, -1.52020389e-02f, 1.48597276e-02f, -5.25884219e-02f,
  5.56918699e-03f, 6.47262260e-02f, -1.10285625e-01f, 2.53356788e-02f, -7.08406344e-02f, -3.86037827e-02f, -4.07562144e-02f, -4.30406071e-02f, 2.73377150e-02f, -1.97958648e-02f,
  2.65216772e-02f, -1.25151023e-01f, 2.09334325e-02f, -3.78947742e-02f, 4.45690528e-02f, 9.79590416e-02f, 1.28473043e-01f, 1.39889434e-01f, 1.02755174e-01f, 9.27364454e-02f,
  1.07114911e-01f, 9.35963020e-02f, 4.11982611e-02f, -3.47955339e-02f, -7.63900876e-02f, 2.46923156e-02f, -3.21164951e-02f, -2.54552867e-02f, 2.23304797e-02f, 6.44882321e-02f,
  3.86288762e-02f, -6.73170574e-03f, -4.05881219e-02f, -2.26437617e-02f, 8.76998380e-02f, -3.63186784e-02f, 9.93682593e-02f, 1.28578907e-02f, 1.20326169e-01f, -3.13272737e-02f,
  -8.22095200e-02f, 8.52746740e-02f, 1.10608265e-01f, 5.61936609e-02f, 9.34973434e-02f, 1.20800231e-02f, -7.66686201e-02f, 6.32358864e-02f, 5.83525039e-02f, -2.61679292e-02f,
  -1.15006536e-01f, -1.48240462e-01f, 6.84448183e-02f, -1.33587018e-01f, 2.50128098e-02f, -1.47463130e-02f, 3.86882648e-02f, -7.54512055e-03f, -4.36816663e-02f, 1.29332971e-02f,
  -2.02045396e-01f, -1.49388954e-01f, -2.43621394e-01f, -6.40049875e-02f, -1.00632920e-03f, -1.63325310e-01f, -1.11510113e-01f, -7.37554133e-02f, -7.13234767e-02f, -8.90869573e-02f,
  4.97494452e-02f, -2.57706363e-03f, -2.84481002e-03f, -1.21229999e-01f, -8.72016102e-02f, 1.24292606e-02f, -3.43357250e-02f, 1.69129744e-02f, -1.26715258e-01f, -5.89547679e-02f,
  -1.73673518e-02f, -1.59470737e-02f, -1.52740115e-02f, 1.64462663e-02f, -9.88113880e-02f, -5.53554036e-02f, 4.22079340e-02f, -2.43695788e-02f, 6.10103421e-02f, 7.19176903e-02f,
  2.59419173e-01f, -3.40967864e-01f, -1.31133765e-01f, 2.09213540e-01f, 1.91447407e-01f, -3.86607200e-02f, 5.18435948e-02f, 1.22314759e-01f, 1.27686158e-01f, -2.27377161e-01f,
  5.80146536e-02f, -1.18272603e-01f, -2.75584459e-01f, 2.58061171e-01f, 1.71421036e-01f, -1.66676730e-01f, 1.84217572e-01f, -2.74161696e-02f, 7.07708672e-02f, -2.34749429e-02f,
  9.56004784e-02f, 1.69117227e-01f, 1.73725504e-02f, 1.13461658e-01f, 1.13931932e-01f, 4.20835875e-02f, 7.78400600e-02f, -1.23284683e-01f, 2.23822191e-01f, 6.22953810e-02f,
  4.25435081e-02f, -8.51317942e-02f, -2.51536048e-03f, -6.76492602e-02f, 2.95130666e-02f, 6.96317409e-04f, -1.19198471e-01f, -3.85075063e-02f, 3.91877741e-02f, -2.62335292e-03f,
  -1.39795661e-01f, 2.37391237e-03f, 3.81876193e-02f, -5.19281961e-02f, 6.90105185e-03f, 5.42679839e-02f, -3.82463075e-02f, 5.23584001e-02f, -3.31622927e-04f, -6.05409518e-02f,
  -2.12403499e-02f, -7.43201971e-02f, -1.91466790e-02f, -3.87108419e-03f, 5.39895855e-02f, 7.59523138e-02f, -1.05550736e-02f, -5.13113029e-02f, 1.87144801e-03f, -2.66298372e-02f,
  -1.68992549e-01f, -8.68806168e-02f, -7.24177584e-02f, 6.23812899e-02f, 1.08323582e-02f, 4.05702069e-02f, 2.39925385e-02f, 7.73400962e-02f, 5.38516045e-03f, -2.09293445e-03f,
  1.35222197e-01f, -4.70795818e-02f, 4.71390150e-02f, -1.20078726e-02f, -2.69296356e-02f, -2.57624779e-02f, 2.81728357e-02f, 4.55485880e-02f, 6.63626865e-02f, -5.70130423e-02f,
  -4.30388376e-02f, 1.02498215e-02f, -5.95512986e-02f, -2.72315089e-02f, 9.47724730e-02f, -5.74697368e-02f, 3.08568142e-02f, -5.54717258e-02f, 4.12231646e-02f, 6.23375177e-03f,
  -7.93818086e-02f, -1.41231045e-01f, 3.02216597e-02f, -3.62309860e-03f, 2.32086312e-02f, 5.98567426e-02f, 4.05599363e-02f, 2.79660486e-02f, -6.37190863e-02f, 2.04605311e-02f,
  -4.48011272e-02f, -2.42790468e-02f, -1.27316751e-02f, -2.27186065e-02f, 5.64683788e-02f, 9.84759908e-03f, -5.13000637e-02f, -7.32618645e-02f, 1.39427736e-01f, -2.24340837e-02f,
  -4.46651243e-02f, 2.61508506e-02f, 2.00244933e-02f, 8.16955883e-03f, 1.39815629e-01f, -7.45390430e-02f, -3.67041230e-02f, -8.01665485e-02f, 4.64970097e-02f, 2.56837737e-02f,
  8.12197328e-02f, -5.31891100e-02f, 1.19916787e-02f, 2.46108726e-01f, -2.01067533e-02f, -2.28086442e-01f, -1.06980249e-01f, 2.43791163e-01f, -1.45450151e-02f, -1.28612489e-01f,
  -3.66707556e-02f, -1.61816046e-01f, -1.49838775e-01f, 5.24344062e-03f, 4.23618332e-02f, -1.12690628e-01f, 1.47860467e-01f, -1.63112268e-01f, 7.91464821e-02f, -8.57042242e-03f,
  1.49948955e-01f, 7.50193745e-02f, 7.10724220e-02f, 1.23188429e-01f, 1.08069435e-01f, 6.39582947e-02f, 1.73340350e-01f, -8.29363540e-02f, 8.41023698e-02f, 5.84429763e-02f,
  -1.05578639e-01f, 2.68011205e-02f, -1.53282564e-02f, -7.33112963e-03f, 2.66007788e-04f, -8.01278837e-03f, 3.97445969e-02f, -2.18687970e-02f, 8.26274976e-02f, -5.97302206e-02f,
  -1.23461083e-01f, 4.26762886e-02f, 2.91974680e-03f, -2.86419075e-02f, 9.42226648e-02f, 1.37752980e-01f, 6.97625615e-03f, -1.36646042e-02f, 3.47674266e-02f, -5.44138253e-02f,
  1.64462835e-01f, -1.34374544e-01f, 3.93047892e-02f, 3.74447517e-02f, 8.27945303e-03f, -3.74137387e-02f, 4.69615571e-02f, -1.74857620e-02f, 5.51959276e-02f, 1.04619183e-01f,
  -4.98381183e-02f, -5.41741438e-02f, 1.81348063e-02f, 3.89430784e-02f, 6.83505759e-02f, -2.85190064e-04f, 1.13784015e-01f, 5.41349836e-02f, 6.53236434e-02f, 2.24961396e-02f,
  5.10159433e-02f, 4.55207154e-02f, 6.53677061e-02f, -3.18959244e-02f, 1.69804171e-02f, 5.60395140e-03f, -5.49799427e-02f, -5.20880185e-02f, -2.74405405e-02f, 3.27461995e-02f,
  -4.65408117e-02f, 5.37719801e-02f, 1.00707151e-02f, -2.83578131e-02f, -4.13921736e-02f, -1.52284242e-02f, 1.62675288e-02f, 3.32580395e-02f, 1.54413218e-02f, 2.05158498e-02f,
  1.21637555e-02f, 5.47289811e-02f, -7.68434107e-02f, 2.99417078e-02f, 4.17021625e-02f, -6.68821260e-02f, 6.26182109e-02f, 3.63144018e-02f, 1.08087480e-01f, -7.31173307e-02f,
  1.81904696e-02f, -4.48470190e-02f, -4.59812060e-02f, 3.76429316e-03f, -2.13779230e-02f, -1.38668763e-02f, -2.15341849e-03f, 6.44340888e-02f, 1.35360122e-01f, -1.04226321e-02f,
  -5.81558049e-02f, -9.99983400e-02f, -7.87702017e-03f, 3.37676592e-02f, 5.03172614e-02f, 3.07768825e-02f, 6.20544478e-02f, 5.32537065e-02f, -6.39881939e-02f, 3.75743173e-02f,
  2.03967929e-01f, -1.90036878e-01f, 2.60425031e-01f, 1.91916421e-01f, 7.22071305e-02f, 2.17459545e-01f, 4.11027580e-01f, 8.76180679e-02f, 2.22076431e-01f, -1.63087413e-01f,
  -1.65505722e-01f, 1.18272327e-01f, 4.23427969e-02f, 3.70128192e-02f, 2.50634104e-01f, 1.58074647e-01f, -9.07648578e-02f, -6.51017874e-02f, 6.98529556e-02f, -4.90657091e-02f,
  -9.68405884e-03f, -1.42363593e-01f, 2.98297610e-02f, -2.32926309e-01f, -1.41778216e-01f, -4.86409739e-02f, -2.08090812e-01f, 6.69901222e-02f, -2.60389864e-01f, 8.41550529e-02f,
  -2.36627925e-02f, -1.73132904e-02f, -8.94150957e-02f, -1.04218706e-01f, -1.02467552e-01f, -2.56791543e-02f, 8.60066339e-02f, 9.32916179e-02f, 3.76114398e-02f, -1.91426575e-02f,
  -1.40354969e-02f, 4.33847941e-02f, -7.13467896e-02f, -1.69551615e-02f, -7.85196424e-02f, -3.03327646e-02f, -7.26426467e-02f, -1.01837590e-01f, -2.74780653e-02f, -3.82381678e-02f,
  -7.43911862e-02f, -4.84534306e-04f, 4.38304581e-02f, -3.67587842e-02f, 6.33708164e-02f, -2.64478885e-02f, -1.67549942e-02f, 1.57412559e-01f, 6.95173591e-02f, -3.09517607e-02f,
  -7.16653094e-02f, 6.44123405e-02f, -4.44939267e-03f, 1.74697023e-02f, -2.69657038e-02f, -1.19944951e-02f, -1.21450890e-02f, 1.35678323e-02f, -1.91605370e-02f, 1.38980104e-02f,
  7.54056592e-03f, 5.94061054e-02f, 1.24170072e-01f, 7.67645612e-02f, -6.47660866e-02f, -1.12561435e-01f, 3.53618413e-02f, 9.27880704e-02f, 3.15987207e-02f, -1.06229566e-01f,
  2.34202053e-02f, -3.94143350e-02f, 5.66519946e-02f, 5.07291332e-02f, 1.79623952e-03f, 1.77741814e-02f, -7.17089325e-02f, 8.86593908e-02f, -9.18545201e-03f, -4.91385907e-02f,
  2.15681009e-02f, 3.32712982e-04f, -6.11157268e-02f, -3.18453647e-02f, -8.80778674e-03f, -5.17404042e-02f, 7.62937292e-02f, 3.34059075e-02f, 2.81051034e-04f, 8.99764244e-03f,
  -1.43112633e-02f, -8.38985387e-03f, 4.42440510e-02f, -1.06290979e-02f, -3.77554372e-02f, -6.89439550e-02f, 1.33345779e-02f, -6.12240024e-02f, 3.33008729e-02f, -7.00807422e-02f,
  -2.16009635e-02f, 1.73396822e-02f, 1.31034004e-02f, -4.33457009e-02f, -9.19499323e-02f, -2.03944719e-03f, -3.64235081e-02f, 5.11774281e-03f, 5.66700697e-02f, -1.06463231e-01f,
  3.58606309e-01f, -5.81171922e-02f, -2.14033693e-01f, 1.30150467e-01f, 1.72273323e-01f, 2.18567923e-01f, 3.16775382e-01f, 1.14206038e-01f, 3.47952843e-01f, 1.35907605e-01f,
  9.58099365e-02f, 3.14799845e-02f, -9.01103690e-02f, 1.72507823e-01f, 1.96561277e-01f, 9.94161591e-02f, 3.21099728e-01f, 7.96695426e-02f, 1.68289974e-01f, 1.35311127e-01f,
  1.40996814e-01f, 2.48903558e-01f, -2.35980392e-01f, -1.24659859e-01f, 8.12222138e-02f, -2.79268026e-01f, -2.40117460e-01f, -1.65952548e-01f, -1.81058362e-01f, 3.05275097e-02f,
  6.92322329e-02f, 8.11262354e-02f, -1.09860592e-01f, -5.70610873e-02f, 3.83306369e-02f, -7.16932416e-02f, 1.78816915e-02f, -8.32739398e-02f, -9.09813959e-03f, 6.70956224e-02f,
  -5.84128201e-02f, 6.91576898e-02f, 6.17439635e-02f, 2.49884222e-02f, 1.10363424e-01f, -9.48135089e-03f, -1.78281292e-02f, 1.72110256e-02f, -2.28268318e-02f, 1.64688211e-02f,
  -2.44444422e-02f, -6.11696988e-02f, 9.23215672e-02f, 2.88273878e-02f, -8.79356563e-02f, 1.40281282e-02f, -3.01750768e-02f, -3.78912352e-02f, 4.27455269e-02f, 4.35500182e-02f,
  6.13602735e-02f, 8.46386477e-02f, 6.98007829e-03f, 2.13102680e-02f, 3.37574594e-02f, -5.51901944e-02f, 4.64209961e-03f, -4.44453806e-02f, 1.48686077e-02f, 2.30652913e-02f,
  -8.00080597e-03f, 3.15874368e-02f, 4.77456897e-02f, -1.47330537e-02f, 8.50604102e-02f, 4.55319174e-02f, 1.61759946e-02f, 4.34067287e-02f, 2.68845614e-02f, 5.48311025e-02f,
  -3.16008888e-02f, 4.73407172e-02f, -6.71140701e-02f, -6.63106963e-02f, -6.10556155e-02f, -5.23306020e-02f, 4.76292297e-02f, -1.76936518e-02f, -5.38635291e-02f, 3.62428278e-02f,
  1.45486847e-01f, 7.94395059e-02f, -2.94263735e-02f, -3.35453153e-02f, -1.33979589e-01f, -5.38972765e-03f, 8.16525593e-02f, 3.40928622e-02f, 8.86732340e-02f, 1.21867180e-01f,
  -6.22099712e-02f, 5.59217343e-03f, 1.09486906e-02f, -2.73002610e-02f, -1.35225197e-02f, -8.05622339e-03f, 4.67872545e-02f, -1.34072741e-02f, 2.06489721e-03f, -5.05593121e-02f,
  -9.13517624e-02f, 1.18539721e-01f, 8.59347582e-02f, 4.10252064e-03f, -5.07648773e-02f, -5.83323687e-02f, -6.43366715e-03f, -1.08243279e-01f, -2.50390619e-02f, 8.55791476e-03f,
  4.89922650e-02f, -1.62346601e-01f, 1.60076693e-02f, -5.10681793e-03f, 1.26174407e-03f, 7.96741527e-03f, -2.05088243e-01f, -1.20543465e-02f, -2.31492952e-01f, -2.84045003e-02f,
  4.47027087e-02f, -7.32108504e-02f, -1.21362485e-01f, -1.51375523e-02f, 8.05613473e-02f, -9.55310315e-02f, 8.02833214e-02f, 4.75541838e-02f, -3.17037180e-02f, 9.79975164e-02f,
  9.97237489e-02f, 1.10980347e-01f, 4.69587743e-02f, 1.60306379e-01f, 3.66178490e-02f, 1.54198438e-01f, 2.16357067e-01f, 4.61806767e-02f, 1.69797421e-01f, -7.18272245e-03f,
  -6.70352578e-02f, -2.62360852e-02f, -3.48496553e-03f, 4.62059751e-02f, 9.37466770e-02f, 3.73160504e-02f, 3.71894091e-02f, 5.14639579e-02f, 3.53252031e-02f, -7.53331482e-02f,
  -3.74089777e-02f, 2.73356102e-02f, 3.43638472e-02f, 7.08810007e-03f, -7.67312348e-02f, 1.05016157e-01f, -7.45868906e-02f, -2.53568068e-02f, -1.39372960e-01f, 2.57171243e-02f,
  -1.90287642e-02f, 3.86972688e-02f, 3.11194547e-03f, 4.70884666e-02f, -9.72112566e-02f, -6.57804757e-02f, -5.48106208e-02f, 4.94594201e-02f, -1.24254534e-02f, -2.48207320e-02f,
  6.38175085e-02f, 5.70835061e-02f, -4.25927080e-02f, -1.20875882e-02f, -7.66181052e-02f, -1.55099370e-02f, -8.82750526e-02f, -6.73304945e-02f, 4.04132158e-02f, 3.26406257e-03f,
  7.11943880e-02f, -6.58273473e-02f, -1.74401309e-02f, 5.47903776e-02f, 7.57119358e-02f, 1.12904971e-02f, 1.10046297e-01f, -3.42758698e-03f, 9.36950520e-02f, -4.31084745e-02f,
  -1.40420813e-02f, -1.58579517e-02f, 8.43663067e-02f, -6.19097799e-02f, 1.47666167e-02f, 9.76518840e-02f, 8.94810855e-02f, 1.38317766e-02f, 1.17699131e-02f, 3.12710851e-02f,
  -5.52514335e-03f, 8.05227086e-02f, -9.67049748e-02f, 2.07797773e-02f, -4.87735458e-02f, -2.60828771e-02f, 9.08385292e-02f, -2.95735300e-02f, 6.49813190e-02f, -6.63713366e-02f,
  1.99112743e-01f, -8.23607296e-03f, 6.91054612e-02f, 1.89387947e-02f, -4.38279100e-02f, 7.04191998e-02f, 5.63302711e-02f, 2.10053697e-02f, -2.97081601e-02f, 2.11681109e-02f,
  1.38690509e-02f, 6.75119013e-02f, -7.39013702e-02f, 1.04183489e-02f, 1.64549835e-02f, -8.77800118e-03f, 7.94453844e-02f, 1.02469005e-01f, -6.50921613e-02f, 1.53706381e-02f,
  -4.21314448e-01f, -1.60186626e-02f, 1.65936768e-01f, -1.55386373e-01f, -1.73296824e-01f, -1.01489581e-01f, -1.10980213e-01f, 4.84887064e-02f, 6.39615506e-02f, 2.55814701e-01f,
  3.88623513e-02f, 7.67802820e-02f, 1.68249667e-01f, 7.31863827e-02f, -1.01916373e-01f, 9.66741964e-02f, -5.26402332e-02f, 8.92776472e-04f, -6.96488544e-02f, -1.00419946e-01f,
  -1.21919274e-01f, -8.17074254e-02f, -9.98937264e-02f, -3.84167209e-02f, -2.89298855e-02f, 3.76875363e-02f, -1.12208165e-01f, 4.62062769e-02f, -4.97445315e-02f, -2.38969289e-02f,
  -2.97726274e-01f, -8.22459534e-02f, -1.08532719e-01f, 4.17636819e-02f, -4.71240841e-02f, -3.66089568e-02f, -4.83141057e-02f, 6.79842476e-03f, 2.23203003e-02f, 8.69127214e-02f,
  -3.06133050e-02f, -2.68540159e-02f, -7.13742897e-02f, 5.86620644e-02f, -4.92426828e-02f, 7.69976601e-02f, 1.32233366e-01f, -7.76635855e-02f, -6.28194830e-04f, -1.09671270e-02f,
  9.84771773e-02f, 1.21400738e-02f, -2.13981699e-02f, 1.90184005e-02f, 2.26585176e-02f, 5.14138937e-02f, -1.37026491e-05f, -1.34100646e-01f, -1.63160861e-01f, -6.75167714e-04f,
  7.56238848e-02f, 1.84046719e-02f, 1.53353615e-02f, 1.11681052e-01f, 9.40071717e-02f, -3.70252703e-04f, -2.68468447e-02f, -8.17818791e-02f, 3.21471430e-02f, -6.12708665e-02f,
  -1.97293684e-02f, -1.42008156e-01f, -3.08918227e-02f, -1.91286448e-02f, 3.87154706e-02f, -3.10135596e-02f, 4.26305719e-02f, -3.83767262e-02f, -6.94238171e-02f, 8.82240571e-03f,
  9.68954712e-02f, 6.05612062e-02f, 4.25203796e-03f, -5.88607229e-02f, -4.25110050e-02f, 6.20673411e-02f, -2.45560631e-02f, -2.98634060e-02f, -8.25754702e-02f, -7.66094327e-02f,
  -4.46269065e-01f, -1.08016483e-01f, -2.01248042e-02f, -8.42321888e-02f, 1.20407149e-01f, -8.82782340e-02f, -4.30677049e-02f, 4.95291092e-02f, -4.20470722e-02f, -2.03313362e-02f,
  -3.25364619e-02f, -2.38415133e-03f, -1.17155038e-01f, 3.46935466e-02f, 2.45316699e-02f, 6.97060078e-02f, -1.16156697e-01f, -4.44482304e-02f, 8.09120294e-03f, -4.93132602e-03f,
  -6.96701780e-02f, -4.57441583e-02f, 6.61444888e-02f, 1.39022758e-02f, -5.56438603e-02f, -1.23217013e-02f, -1.33584425e-01f, -5.31667806e-02f, -6.89309165e-02f, -4.82038558e-02f,
  -3.96320336e-02f, 3.59449536e-02f, -1.76266637e-02f, 1.59246057e-01f, 6.61110654e-02f, -2.11099416e-01f, -1.42532915e-01f, 5.80210723e-02f, -6.33867234e-02f, -1.94677450e-02f,
  1.70222856e-02f, 9.98480618e-02f, -7.41735473e-02f, 1.49594948e-01f, 2.03479037e-01f, -2.17850178e-01f, 2.00803176e-01f, -2.52112765e-02f, -9.35677141e-02f, 1.62665293e-01f,
  -3.85398529e-02f, 1.01667829e-01f, 1.48658186e-01f, 1.73006132e-01f, 6.71329349e-02f, 1.37530705e-02f, 2.86296964e-01f, -8.54017306e-03f, 1.68510377e-01f, 8.06148648e-02f,
  1.80484354e-02f, 3.75345871e-02f, -2.45995726e-03f, -1.19508542e-02f, 3.05216219e-02f, -7.10024312e-02f, 2.85923928e-02f, 3.02789472e-02f, -2.13753991e-02f, 5.32782525e-02f,
  -6.59696832e-02f, 6.87437505e-02f, 5.87469712e-02f, 8.76052119e-03f, -1.21249147e-01f, 7.08801299e-02f, -2.41157059e-02f, 2.74156742e-02f, 6.38824478e-02f, 6.75670728e-02f,
  3.88067141e-02f, 5.15064709e-02f, -3.60920802e-02f, 3.46082747e-02f, -6.87592924e-02f, -2.40022093e-02f, 4.24289368e-02f, 7.06774369e-02f, 3.68667319e-02f, -5.82285561e-02f,
  -3.89714129e-02f, 6.85153753e-02f, -1.00964360e-01f, -6.06365725e-02f, -2.49564685e-02f, 1.04153911e-02f, -4.90452200e-02f, -4.31129187e-02f, -3.31710465e-02f, 1.12267219e-01f,
  -2.66196355e-02f, 5.92085496e-02f, 3.23821381e-02f, 9.07368809e-02f, 9.66755003e-02f, -2.28083152e-02f, 5.29488102e-02f, -3.10753789e-02f, 5.36877066e-02f, -4.16946113e-02f,
  9.52957664e-03f, 4.50020544e-02f, 7.76396645e-03f, -1.41615063e-01f, -2.68341396e-02f, 3.07676494e-02f, -3.59512456e-02f, -4.18893527e-03f, -5.29872663e-02f, 5.48922122e-02f,
  -2.21259557e-02f, 9.59043950e-02f, -3.11681051e-02f, -3.25633921e-02f, -7.58312223e-03f, -2.66663767e-02f, -4.99673374e-02f, -1.36741605e-02f, 4.42823023e-02f, 8.22854321e-03f,
  1.01936392e-01f, -2.92493068e-02f, -5.22511080e-02f, 8.02620798e-02f, 6.85737878e-02f, -2.91543901e-02f, 6.82316944e-02f, 1.12021109e-02f, 4.63073999e-02f, 9.09940600e-02f,
  4.07719389e-02f, 2.55076941e-02f, -7.51356930e-02f, -9.19774473e-02f, 1.92363858e-02f, -2.31405403e-02f, -2.13584974e-02f, 1.12512566e-01f, 7.25214109e-02f, -6.20048344e-02f,
  1.51240081e-01f, -1.12898782e-01f, -2.06226543e-01f, -1.72232777e-01f, -8.51283967e-02f, -1.63283110e-01f, -8.55547786e-02f, -2.46450990e-01f, -6.34141415e-02f, -1.79268196e-01f,
  -8.05879682e-02f, 4.30400111e-02f, 1.97901696e-01f, -1.18312769e-01f, 2.72079736e-01f, 2.72633225e-01f, -1.57861620e-01f, -1.04472227e-02f, -1.29731908e-01f, -2.67951675e-02f,
  8.04761017e-04f, 9.78688523e-03f, -8.33803266e-02f, -2.62897283e-01f, -2.31024981e-01f, -1.12695314e-01f, -8.46574381e-02f, -8.69228691e-02f, -2.26447403e-01f, 5.55960573e-02f,
  -8.65355432e-02f, 4.63640839e-02f, 5.81758283e-03f, -3.76691520e-02f, -1.21205553e-01f, -1.45771364e-02f, 2.44013406e-02f, -1.34142097e-02f, 4.85304855e-02f, 4.26781103e-02f,
  3.46532911e-02f, 8.32680315e-02f, -2.88206171e-02f, 6.08274303e-02f, -5.38850427e-02f, -2.48529781e-02f, -6.17223680e-02f, 3.73678189e-03f, -8.28717873e-02f, 5.11945970e-02f,
  -2.32147854e-02f, -8.44253078e-02f, -2.37790942e-02f, 5.11478670e-02f, -1.08522378e-01f, -1.43994719e-01f, 1.84443835e-02f, 8.93940032e-03f, 5.01002558e-02f, 1.17902895e-02f,
  5.71152791e-02f, 1.33443521e-02f, 2.46189330e-02f, -9.31047425e-02f, 6.97283745e-02f, 1.54997809e-02f, -2.46872995e-02f, -3.96065079e-02f, 9.81029123e-03f, 4.33739722e-02f,
  -3.31950113e-02f, 5.44152372e-02f, -2.44619288e-02f, 1.31964749e-02f, -3.13302176e-03f, 9.83877182e-02f, 5.79470322e-02f, -2.18496025e-02f, -1.11095168e-01f, -9.40205231e-02f,
  -1.00636052e-03f, 4.38954234e-02f, 4.46973089e-03f, 7.09282458e-02f, 1.12667168e-02f, 8.17369223e-02f, -8.74172375e-02f, 5.19242371e-03f, 1.02179594e-01f, 7.15080053e-02f,
  2.29120925e-02f, -2.75465194e-02f, -4.06778269e-02f, 3.20633538e-02f, -5.09445406e-02f, -8.90671983e-02f, 7.45788729e-03f, 3.44286039e-02f, 1.14056617e-01f, 3.53111699e-02f,
  -1.79572534e-02f, -3.09223421e-02f, -2.84341024e-03f, -1.38640590e-02f, 5.97125553e-02f, -8.43250193e-03f, 1.55976042e-02f, 1.25635907e-01f, -8.35383385e-02f, -3.20927612e-02f,
  5.62994555e-02f, 2.10321210e-02f, 1.00996092e-01f, -6.52880520e-02f, 2.69725025e-02f, -3.01104803e-02f, 4.98247519e-02f, -4.52322364e-02f, 1.37042746e-01f, -2.04227362e-02f,
  -4.12364572e-01f, 2.01613680e-01f, -1.10803723e-01f, 1.07190326e-01f, -1.34237841e-01f, -2.08809868e-01f, 1.68151911e-02f, 3.80074047e-03f, -4.66312654e-02f, 2.74083108e-01f,
  1.09862991e-01f, -1.55159950e-01f, 1.73256904e-01f, 1.68101445e-01f, -2.08096266e-01f, 1.35580331e-01f, 3.80779393e-02f, 1.42998621e-01f, -1.02682918e-01f, 6.76847398e-02f,
  -1.02909088e-01f, 1.21970266e-01f, 1.27138123e-01f, 7.83144087e-02f, -8.01508948e-02f, 4.03581075e-02f, 1.87282592e-01f, 3.09114140e-02f, 4.41656038e-02f, -7.56805167e-02f,
  6.45695552e-02f, 1.47659466e-01f, 1.17442980e-02f, -3.31896245e-02f, -3.02529279e-02f, 5.46153460e-04f, -1.90984290e-02f, -9.37656462e-02f, 4.08934280e-02f, -1.63300242e-02f,
  1.75347988e-04f, 7.95888230e-02f, 7.52180070e-02f, 5.97481914e-02f, 1.95033848e-02f, -4.86851931e-02f, -4.26265635e-02f, -6.74385875e-02f, 2.49631535e-02f, 5.23521565e-04f,
  1.05832495e-01f, -5.02647273e-02f, 8.75492916e-02f, 4.25860519e-03f, -1.81961954e-02f, 1.20857105e-01f, 4.02190834e-02f, -5.08288518e-02f, 5.26277572e-02f, 2.85857487e-02f,
  -9.82897952e-02f, -2.85623390e-02f, 1.43073171e-01f, 3.42298095e-04f, -6.36680275e-02f, -3.81273888e-02f, 8.44779983e-02f, 1.95724647e-02f, -4.12380397e-02f, 9.93312299e-02f,
  -8.65714103e-02f, 3.30659002e-03f, 8.68592337e-02f, 1.26362190e-01f, 3.15373689e-02f, -7.97527283e-03f, 3.29818316e-02f, 1.22746736e-01f, -1.99455321e-02f, 6.48254976e-02f,
  9.47745442e-02f, 1.77576207e-02f, 2.78400145e-02f, -2.90464964e-02f, -2.41162926e-02f, -1.96815189e-02f, -9.94859356e-03f, 4.58214618e-02f, 4.98038195e-02f, -4.53383140e-02f,
  -1.15250470e-02f, 1.47730812e-01f, 1.61783281e-03f, -4.44164537e-02f, 3.26717496e-02f, 7.76404375e-03f, -6.77188113e-02f, -3.52504291e-02f, 9.48845968e-02f, -1.33712413e-02f,
  -7.57110789e-02f, 8.92428681e-02f, -3.15513723e-02f, -2.79308390e-02f, -5.73641732e-02f, 2.65887715e-02f, 1.18022278e-01f, -4.10250686e-02f, -5.89967845e-03f, -1.28696533e-02f,
  9.79203060e-02f, -4.37562652e-02f, -1.17119215e-01f, -3.13193351e-03f, -5.15423827e-02f, 3.52088511e-02f, -6.44325092e-02f, -2.62625292e-02f, -7.62037858e-02f, -1.16897253e-02f,
  -8.41497257e-02f, -3.81494984e-02f, -5.02755269e-02f, -1.61135957e-01f, 9.08079091e-03f, -1.95017785e-01f, -2.24320412e-01f, -3.83297876e-02f, 1.61158480e-02f, -6.75869808e-02f,
  -1.77666888e-01f, 2.63022855e-02f, 1.90298676e-01f, -1.84714392e-01f, 2.95565099e-01f, 5.89314662e-02f, -1.47238985e-01f, -6.83669448e-02f, -2.12019552e-02f, -9.03300121e-02f,
  -2.01169755e-02f, -6.00355901e-02f, 6.24416582e-02f, -5.76916733e-04f, -1.48572057e-01f, 5.91680110e-02f, -1.70780141e-02f, 1.09246552e-01f, -1.06453590e-01f, 8.87556821e-02f,
  -1.01448633e-01f, -1.78760067e-01f, -9.11589637e-02f, -5.54430112e-02f, -6.05311766e-02f, -5.16900269e-04f, -2.11555641e-02f, 3.74109522e-02f, -9.91722718e-02f, -5.03110103e-02f,
  5.08822165e-02f, -2.62102636e-04f, -4.99081463e-02f, 1.43757343e-01f, -5.11222593e-02f, -8.85635242e-02f, 1.26594484e-01f, -6.65572658e-02f, 3.93724218e-02f, -1.14751887e-02f,
  2.05419790e-02f, -1.96356438e-02f, -3.40434611e-02f, -2.93130577e-02f, 1.21371590e-01f, -1.19520470e-01f, -7.24977329e-02f, 2.44495291e-02f, -2.33001541e-02f, -2.59340815e-02f,
  1.49779797e-01f, 5.46649024e-02f, -3.37785482e-02f, 3.69111747e-02f, -6.96351007e-02f, -4.47975807e-02f, 4.87034991e-02f, 6.72979839e-03f, -4.14348841e-02f, -1.17184408e-01f,
  -4.76987958e-02f, 5.87514900e-02f, -1.34274200e-01f, -6.21933527e-02f, -5.97296935e-03f, 1.47618558e-02f, -5.24414405e-02f, -1.01249956e-01f, 2.72844639e-03f, 2.88110785e-02f,
  -8.97827384e-04f, 9.62063111e-03f, -8.48975405e-03f, -4.96516898e-02f, -5.11646606e-02f, 5.13346419e-02f, -6.73478171e-02f, 3.53615731e-02f, 3.21363173e-02f, 2.87864245e-02f,
  -1.30737890e-05f, -1.78975966e-02f, -1.06340103e-01f, -1.01728976e-01f, -5.29183485e-02f, -2.54163239e-02f, 9.37972218e-02f, -2.38525104e-02f, -6.49062768e-02f, 9.57400128e-02f,
  -6.44061789e-02f, -4.32224385e-02f, -3.98675026e-03f, 8.57682433e-03f, 1.42867602e-02f, -7.20599666e-02f, 4.57769632e-02f, -6.48335442e-02f, -8.61823335e-02f, -3.18443403e-02f,
  6.30670227e-03f, -4.42904141e-03f, 9.19916704e-02f, -5.37916459e-02f, 6.13503810e-03f, -5.44538498e-02f, -2.91659050e-02f, -3.95098254e-02f, 1.08943284e-01f, 6.43245950e-02f,
  -1.68188512e-01f, 8.63117054e-02f, 1.73942670e-01f, -8.05474967e-02f, -5.23700975e-02f, -1.36169344e-01f, 2.29816101e-02f, -1.49281761e-02f, 1.97326109e-01f, 1.46812946e-01f,
  1.08826578e-01f, 1.50678486e-01f, 1.19623236e-01f, -5.13414927e-02f, -1.32237703e-01f, -8.68654996e-02f, -1.01298749e-01f, 5.36850393e-02f, 1.40354037e-01f, -1.85543999e-01f,
  -1.30473241e-01f, -2.50451982e-01f, -1.21550877e-02f, -1.24872245e-01f, -2.65412661e-03f, 9.26880091e-02f, -1.50234759e-01f, 1.24478139e-01f, -1.03467919e-01f, 1.55762359e-01f,
  7.70782456e-02f, 2.12311909e-01f, 5.49554974e-02f, 5.57410717e-02f, -2.89916024e-02f, -1.05932534e-01f, -3.88657749e-02f, 1.39095545e-01f, 6.66300359e-04f, 1.36460969e-03f,
  -8.48193318e-02f, 5.31782694e-02f, -8.11964739e-03f, -4.62442376e-02f, -7.38991648e-02f, 1.40051499e-01f, -6.11807592e-02f, -1.02289006e-01f, 1.17030613e-01f, -4.42945020e-04f,
  4.83536385e-02f, 7.00364038e-02f, -1.14711702e-01f, 3.90555733e-03f, -6.30971491e-02f, 1.37582764e-01f, -5.03223315e-02f, -5.86026087e-02f, -7.72171095e-02f, -6.19319491e-02f,
  -1.55261919e-01f, -5.53219244e-02f, 5.13788387e-02f, 1.46110445e-01f, 1.09509639e-01f, 8.93924460e-02f, -4.84606735e-02f, -4.65324055e-03f, 5.40862530e-02f, 2.25265539e-04f,
  3.37282941e-02f, -2.44234335e-02f, -1.00901362e-03f, -1.13657773e-01f, -3.06404140e-02f, 3.35844345e-02f, 4.76784557e-02f, 6.68183565e-02f, -7.59308860e-02f, -3.70092019e-02f,
  6.42012730e-02f, 2.39850171e-02f, 4.59982194e-02f, 2.24219030e-03f, 1.37949690e-01f, -2.16346066e-02f, -9.18777287e-02f, 1.34232610e-01f, 3.29057686e-02f, -7.87315220e-02f,
  4.05888148e-02f, 1.01472363e-01f, 1.85055077e-01f, 7.53256604e-02f, 6.50289878e-02f, -1.02741225e-02f, -1.04746252e-01f, -4.00578231e-02f, 4.19725850e-02f, -1.17479779e-01f,
  1.74343109e-03f, 4.74931709e-02f, 1.09709660e-02f, 7.18866289e-02f, -2.35969294e-02f, -1.39924521e-02f, 2.56518293e-02f, -1.91349834e-02f, -3.37465666e-02f, 3.44634689e-02f,
  3.19630466e-02f, 1.02220275e-01f, 4.21786495e-02f, -1.29157035e-02f, -4.71605398e-02f, -1.47157125e-02f, -6.53550103e-02f, 7.00693801e-02f, -4.87513021e-02f, -3.95031534e-02f,
  -4.88137275e-01f, 2.82021701e-01f, 1.85501322e-01f, -2.46114537e-01f, -1.24554532e-02f, 1.37135759e-01f, -1.20637700e-01f, 2.31909335e-01f, 1.22931497e-02f, 2.12360751e-02f,
  -7.72646442e-02f, 2.70423517e-02f, 1.14339486e-01f, -1.99583899e-02f, -1.88178763e-01f, -1.78820472e-02f, -2.47034542e-02f, 6.82660704e-03f, 1.89143285e-01f, 1.42656034e-03f,
  -8.50193761e-03f, -2.14372441e-01f, 4.13787998e-02f, 1.08149648e-01f, 1.71789490e-02f, -9.25032943e-02f, -2.60521770e-01f, 2.06947997e-02f, -1.02900669e-01f, 3.17954756e-02f,
  -1.73272610e-01f, -1.07386746e-01f, 9.25791636e-02f, 4.12880518e-02f, -1.36512397e-02f, 4.69715744e-02f, -2.41489969e-02f, 8.01163316e-02f, -5.03193028e-02f, 6.88682199e-02f,
  -3.56494449e-02f, 8.88863429e-02f, -6.57210350e-02f, -5.65426499e-02f, 1.61389530e-01f, 5.33578023e-02f, 8.84055495e-02f, 1.14097841e-01f, 3.24498601e-02f, 6.18619137e-02f,
  7.91419148e-02f, 7.25291595e-02f, 2.06195470e-02f, 2.05098316e-02f, 4.47058231e-02f, 5.31028584e-02f, -4.67860438e-02f, 4.34865244e-02f, -3.71726118e-02f, -7.67707676e-02f,
  4.17276025e-02f, 6.97441995e-02f, -1.82301477e-02f, 5.07677943e-02f, -5.41651025e-02f, -8.90752953e-03f, -3.32716219e-02f, -7.66083896e-02f, 6.69486523e-02f, -4.62550186e-02f,
  -8.47754255e-03f, -5.20871133e-02f, 3.44075896e-02f, 8.77692476e-02f, -1.00290785e-02f, -5.17619364e-02f, -9.58761200e-03f, -1.85002051e-02f, 1.68333221e-02f, -1.89365029e-01f,
  -2.25531310e-02f, -1.04914360e-01f, -9.49623622e-03f, -8.17395821e-02f, 1.01418704e-01f, -2.88576856e-02f, 1.03156075e-01f, 6.01642653e-02f, -2.46785302e-02f, -1.40241593e-01f,
  -3.00027907e-01f, -9.80094299e-02f, 8.72229133e-03f, 8.83510709e-02f, -3.02477404e-02f, 2.17925347e-02f, 9.71999764e-02f, -1.62220020e-02f, -4.22439128e-02f, 5.69818765e-02f,
  9.10876766e-02f, 8.51877183e-02f, -1.34874638e-02f, -2.29839720e-02f, -4.72697541e-02f, -8.71822089e-02f, -8.59569386e-02f, -8.32246710e-03f, -4.66281921e-03f, 8.40840191e-02f,
  1.23384362e-02f, -5.78076504e-02f, -1.38356149e-01f, 4.06481624e-02f, 3.19514312e-02f, -5.79497777e-02f, -1.18147485e-01f, -2.28691101e-02f, -1.13151386e-01f, -3.13554443e-02f,
  1.67662248e-01f, 1.87037468e-01f, -1.41396103e-02f, -6.39671972e-03f, -1.33269578e-01f, 1.67920608e-02f, -5.63644152e-03f, -8.63179415e-02f, 2.60506243e-01f, 7.44153559e-02f,
  -2.13783130e-01f, 3.44691157e-01f, -1.49244636e-01f, -1.21288426e-01f, 4.40671248e-03f, 9.24596116e-02f, 1.85386837e-01f, 7.94991553e-02f, 1.08170949e-01f, 1.91985834e-02f,
  -1.13719599e-02f, -1.34011164e-01f, -1.97353318e-01f, -1.15925521e-01f, -7.46741518e-02f, -9.12239626e-02f, -7.68598169e-02f, -2.01445818e-01f, -1.34770617e-01f, 4.23416309e-02f,
  -5.20019196e-02f, 1.18095160e-01f, -1.00603640e-01f, -1.29343001e-02f, -1.24196194e-01f, -7.48310331e-03f, -6.10671528e-02f, 2.35050675e-02f, -7.48434663e-02f, -4.79348302e-02f,
  8.09189007e-02f, 3.08730174e-02f, 9.84502062e-02f, -4.43278402e-02f, 1.43691655e-02f, -6.47531524e-02f, 5.99008352e-02f, 8.90987832e-03f, 2.10268870e-02f, 2.24390323e-03f,
  -4.22053039e-02f, -8.49156603e-02f, -3.86471897e-02f, 5.01526007e-03f, -2.68695392e-02f, 8.47093910e-02f, 1.05326138e-01f, -6.87697977e-02f, 6.33609891e-02f, 1.36122271e-01f,
  -2.51881815e-02f, 1.29418746e-01f, -6.92809969e-02f, 3.44093740e-02f, -1.68828620e-03f, -8.36103857e-02f, -2.15962669e-03f, -6.37155473e-02f, 2.11778376e-02f, 2.31522340e-02f,
  -1.10986605e-01f, -6.73285574e-02f, -7.42911026e-02f, 1.04818329e-01f, 1.01382658e-01f, -2.53651105e-02f, 4.04189266e-02f, -5.95325429e-04f, -1.50269596e-02f, 4.77197915e-02f,
  -1.08892165e-01f, 7.75459781e-02f, 2.99431733e-04f, -6.81530742e-04f, -4.75894213e-02f, -2.23027561e-02f, 1.52186556e-02f, 3.92969474e-02f, -3.81028689e-02f, -4.11151312e-02f,
  4.38500755e-02f, 3.24076086e-01f, 1.75124593e-02f, -2.73676962e-02f, 7.10138008e-02f, -3.33834812e-02f, -2.25162692e-02f, 7.63826892e-02f, 1.36249050e-01f, 5.54177128e-02f,
  -1.71542149e-02f, 8.50181561e-03f, 3.14177535e-02f, -3.91761214e-02f, 1.93659738e-02f, 1.88026093e-02f, 7.38307983e-02f, 8.63822177e-02f, -3.22717875e-02f, -3.32761295e-02f,
  5.99700585e-03f, 8.51391926e-02f, -3.69511684e-03f, 3.06670498e-02f, -6.01520203e-02f, 8.30670223e-02f, 9.00615379e-02f, -4.36979681e-02f, 1.85454951e-03f, 8.62766802e-02f,
  1.84236988e-01f, -1.16965875e-01f, 1.59976140e-01f, 1.84507500e-02f, 2.00627953e-01f, 9.85914692e-02f, 6.93674684e-02f, 1.18288929e-02f, 1.43437997e-01f, -2.46960059e-01f,
  -1.15538143e-01f, -1.63129523e-01f, 2.54719164e-02f, -9.66284946e-02f, 1.56197160e-01f, 2.30383649e-02f, 8.34105909e-02f, -1.09883629e-01f, 3.79993841e-02f, 6.33490924e-03f,
  1.43897712e-01f, -1.47982209e-03f, 8.15812871e-02f, -6.09942116e-02f, 1.55134406e-03f, 2.53821481e-02f, -1.25446215e-01f, 1.09792702e-01f, -1.36384591e-01f, 7.69897848e-02f,
  1.53313307e-02f, -5.76379560e-02f, 2.29814127e-02f, 1.53810801e-02f, 3.64564080e-03f, 2.17915606e-02f, -9.23570544e-02f, 9.03425589e-02f, 8.06385353e-02f, -5.62298335e-02f,
  -1.27475783e-01f, -3.55508029e-02f, 6.09469786e-03f, 2.12198105e-02f, 5.77997742e-03f, 5.57395145e-02f, 8.43101181e-03f, -5.22771254e-02f, 1.15352003e-02f, 5.55169582e-02f,
  -1.59020873e-03f, 4.26700749e-02f, 2.83506559e-03f, -6.51432425e-02f, 9.92788672e-02f, 6.26564175e-02f, -6.36291802e-02f, 1.07739344e-01f, -3.96800861e-02f, 2.59616338e-02f,
  -3.02293804e-03f, 7.34586492e-02f, 2.93669454e-03f, -4.08280790e-02f, -4.93871830e-02f, 1.01503931e-01f, 7.48806447e-02f, -8.84010494e-02f, -1.30348548e-01f, -1.09936886e-01f,
  -2.98908129e-02f, 4.55660932e-02f, -2.31725117e-03f, 7.69882426e-02f, -7.84490781e-04f, -5.41744791e-02f, -1.07485712e-01f, -1.79214776e-02f, -1.32108172e-02f, 2.19336171e-02f,
  -9.90142673e-03f, -5.20071015e-02f, 1.24901384e-01f, 7.34157339e-02f, -1.30273234e-02f, 5.47767803e-03f, -1.39290392e-01f, 5.14878966e-02f, -8.56131986e-02f, 5.15625477e-02f,
  -2.95425177e-01f, -2.40078181e-01f, -6.03222251e-02f, -1.03554867e-01f, -9.20536518e-02f, -1.16094232e-01f, 3.95961888e-02f, 1.50042158e-02f, -3.33650485e-02f, -3.03425603e-02f,
  -5.65101719e-03f, -9.65034887e-02f, -9.15013924e-02f, 8.67381617e-02f, -1.06186397e-01f, -2.25408897e-02f, -3.79323959e-02f, -7.26157278e-02f, -1.08007729e-01f, -3.14134471e-02f,
  2.32207906e-02f, -2.13845372e-02f, 7.27510601e-02f, 5.35192117e-02f, -1.02582328e-01f, 1.34117855e-02f, 3.55552509e-02f, 4.73781787e-02f, 1.68087613e-02f, 5.83666898e-02f,
  1.56319991e-01f, 1.18076056e-01f, 4.20997329e-02f, -1.39326155e-01f, -7.60289794e-03f, -3.39638703e-02f, -1.89877436e-01f, -7.36396164e-02f, -1.28068343e-01f, 3.21522683e-01f,
  -4.20570970e-02f, 1.56519562e-01f, -8.56092945e-02f, -8.56747255e-02f, -4.48314190e-01f, -3.08046281e-01f, -5.01562580e-02f, 1.36485979e-01f, -1.10189699e-01f, 1.95822299e-01f,
  -2.34015822e-01f, -2.20326751e-01f, -3.32334042e-01f, 7.83683732e-03f, 2.03256398e-01f, 1.86716735e-01f, 6.62149936e-02f, 3.30755115e-02f, 1.47960767e-01f, -1.19957596e-01f,
  -5.42800538e-02f, -9.79846418e-02f, 1.07088335e-01f, -2.19041500e-02f, 9.25833136e-02f, 1.30045608e-01f, 1.63862690e-01f, -7.25490078e-02f, -7.60484040e-02f, -9.69923940e-03f,
  4.26887013e-02f, -1.90701261e-01f, -4.98446450e-02f, -1.10419907e-01f, 8.15561265e-02f, 6.10259473e-02f, 5.14726974e-02f, 4.54488173e-02f, 4.49117459e-02f, -1.42556457e-02f,
  8.34525898e-02f, 5.82262613e-02f, 2.36940905e-02f, 8.90480168e-03f, 9.02111735e-03f, -5.71966879e-02f, -4.54797260e-02f, -3.55893373e-02f, 1.05789982e-01f, -9.02109295e-02f,
  4.92505543e-02f, 1.44189730e-01f, -1.03045069e-01f, 1.84390284e-02f, -6.56777918e-02f, 4.45879512e-02f, -3.05685475e-02f, 1.94832683e-03f, -5.05939573e-02f, 2.78384686e-02f,
  3.57027613e-02f, -4.95296270e-02f, -8.97975862e-02f, 7.94833750e-02f, -2.63286363e-02f, 8.70872140e-02f, -4.37848605e-02f, -2.17354130e-02f, 6.81124181e-02f, -8.06373507e-02f,
  -4.58386615e-02f, -9.82466638e-02f, 2.66987551e-02f, 3.45304050e-02f, -9.06297639e-02f, -9.67571437e-02f, -7.76806250e-02f, 2.23450884e-02f, 7.96661153e-02f, -5.17943315e-02f,
  -7.09235785e-04f, 6.61958680e-02f, 2.45979931e-02f, 2.11258382e-02f, 3.90740372e-02f, 4.04568352e-02f, -1.41493918e-03f, 3.45794261e-02f, -4.63269092e-02f, 3.41068991e-02f,
  2.11366251e-01f, -3.44715491e-02f, 1.26532435e-01f, -1.19030755e-02f, -4.44121957e-02f, 1.01393536e-02f, 6.67314306e-02f, -7.96038136e-02f, 1.08268246e-01f, 3.62784415e-02f,
  2.05946177e-01f, 5.42196333e-02f, 1.45585313e-02f, -2.89032459e-02f, -6.04091585e-02f, 2.00387225e-01f, -6.62837625e-02f, -2.55148690e-02f, 3.96866016e-02f, 3.16353627e-02f,
  -1.08270958e-01f, 7.56090358e-02f, -7.19930083e-02f, -7.47591108e-02f, -6.86531141e-02f, -3.88558395e-03f, 7.77903944e-02f, -4.03469726e-02f, 2.29883403e-01f, -8.84854719e-02f,
  -1.26219720e-01f, 1.06203534e-01f, 1.32156610e-01f, -1.46739423e-01f, 7.99134672e-02f, 1.98455468e-01f, -1.58986092e-01f, -9.20166299e-02f, 6.89854696e-02f, -3.26615684e-02f,
  -6.99657053e-02f, -1.19068734e-01f, 8.42130836e-03f, -1.27548993e-01f, -2.25513548e-01f, -3.54851559e-02f, -1.77787274e-01f, -2.37889253e-02f, -1.02966048e-01f, 1.14282399e-01f,
  -8.33639503e-02f, 6.48178458e-02f, -9.93597507e-02f, -4.58118618e-02f, -1.24155819e-01f, 7.91404396e-02f, -3.67816091e-02f, -6.92039579e-02f, 4.16114256e-02f, -5.73060140e-02f,
  3.43658179e-02f, -7.41858557e-02f, -6.43423349e-02f, 6.68537617e-02f, -1.58490285e-01f, -8.84314328e-02f, 8.78018737e-02f, -3.44573446e-02f, 1.51570039e-02f, -9.15148184e-02f,
  -2.56226081e-02f, -4.26697172e-02f, -4.18727286e-02f, -8.51683877e-03f, -2.89492629e-04f, -6.28607273e-02f, 8.55129361e-02f, -3.82235390e-03f, -4.47802758e-03f, -2.92887297e-02f,
  3.78986187e-02f, 1.07049337e-02f, -1.53936502e-02f, -7.07848296e-02f, 6.69177249e-02f, 7.07749799e-02f, -4.78627440e-03f, 2.67580785e-02f, -3.27636488e-02f, -6.27067238e-02f,
  -3.96663602e-03f, -3.75050493e-02f, -9.55517963e-02f, -1.44553259e-02f, 1.85576780e-03f, 5.53728491e-02f, 1.55480085e-02f, -1.39156595e-01f, 4.01919335e-02f, -4.96819466e-02f,
  -2.84132529e-02f, -9.51492190e-02f, 6.41393289e-02f, 6.35822192e-02f, 5.48958071e-02f, -4.69499528e-02f, -1.01954015e-02f, 1.37279153e-01f, 8.55035260e-02f, -5.95616810e-02f,
  -9.85980481e-02f, 9.77025032e-02f, -2.10699551e-02f, -3.66181023e-02f, 3.88570689e-02f, -1.27400860e-01f, 5.55080436e-02f, -5.88669293e-02f, -3.12062912e-02f, 7.50953183e-02f,
  -1.02770276e-01f, -1.45244941e-01f, -4.70535867e-02f, 6.42426312e-02f, 6.37636259e-02f, -2.55501624e-02f, -4.30292450e-02f, -3.39821428e-02f, -3.20352614e-02f, -4.26632948e-02f,
  -3.36602740e-02f, -2.43188869e-02f, 9.14988965e-02f, -4.70793210e-02f, -6.26625866e-02f, -3.51049155e-02f, -3.18749659e-02f, -2.94433925e-02f, 7.37325698e-02f, 5.44130541e-02f,
  1.41505837e-01f, -2.02110693e-01f, -1.43714219e-01f, 2.12901793e-02f, -4.74961028e-02f, -1.51325747e-01f, -2.98686415e-01f, -3.04513257e-02f, -2.09685341e-01f, -2.27600396e-01f,
  4.13744897e-02f, 5.57132438e-03f, -1.29265621e-01f, 1.72803000e-01f, 2.32271731e-01f, -1.23629853e-01f, 1.67132959e-01f, -1.02482513e-02f, 6.09773397e-03f, 4.20081951e-02f,
  1.21169783e-01f, 1.85455412e-01f, 1.08182155e-01f, 1.50765628e-01f, 1.37501240e-01f, 6.87399879e-02f, 2.01721221e-01f, -9.02480334e-02f, 1.70636982e-01f, 6.60144761e-02f,
  5.90004511e-02f, 2.37097256e-02f, -6.82019293e-02f, -3.89867499e-02f, -8.10198300e-03f, 5.23557886e-02f, 8.11660662e-02f, 1.48316130e-01f, -1.67118814e-02f, -3.81393284e-02f,
  -2.09758934e-02f, 1.09472191e-02f, -3.39966863e-02f, 4.68164235e-02f, 1.59228723e-02f, -8.64376343e-05f, 2.64375526e-02f, -1.58708394e-02f, 1.95150077e-02f, 2.55499035e-02f,
  -1.13111250e-01f, -3.40648592e-02f, 5.30337542e-02f, 4.15830798e-02f, -3.49333249e-02f, -5.40819624e-03f, 1.09093292e-02f, -4.18871120e-02f, 2.88825929e-02f, 7.49164000e-02f,
  7.90071562e-02f, 8.77967104e-02f, -2.37274133e-02f, -1.56254191e-02f, 5.30258454e-02f, 4.19720933e-02f, 5.49799763e-02f, 4.13695090e-02f, -1.91676673e-02f, 1.35390192e-01f,
  5.11143282e-02f, 5.35463057e-02f, 4.89871837e-02f, -2.01142635e-02f, -1.63476709e-02f, -8.19092020e-02f, -4.42454070e-02f, -2.97163911e-02f, 1.68043561e-03f, 4.64315107e-03f,
  -1.32037681e-02f, 7.89505541e-02f, -7.20167831e-02f, 9.15066153e-02f, 9.22203064e-02f, 2.33029202e-02f, -4.63779271e-03f, 4.18486819e-02f, -9.08906683e-02f, 6.36956096e-02f,
  -3.18940654e-02f, -2.28990465e-02f, -9.56256688e-02f, 7.36951828e-02f, -3.41534205e-02f, 4.29481715e-02f, 7.14236870e-02f, -5.75282704e-03f, 3.09094712e-02f, 6.98302984e-02f,
  8.43003243e-02f, -5.93247972e-02f, -2.31148694e-02f, 9.08456445e-02f, 8.56534094e-02f, -7.71210790e-02f, -5.81656843e-02f, 1.03093967e-01f, 5.61726391e-02f, 4.55631614e-02f,
  2.02785362e-03f, -3.89737748e-02f, 2.90167574e-02f, -1.35848641e-01f, 4.14542301e-04f, 1.91979017e-02f, -3.23941074e-02f, -3.58701311e-02f, 4.42719087e-02f, -3.27334106e-02f,
  -2.56045520e-01f, 6.15423433e-02f, 1.95264630e-02f, -3.21274549e-01f, 1.36174140e-02f, -1.40154302e-01f, -1.25367641e-01f, 9.18595542e-05f, -1.36395589e-01f, -2.32812569e-01f,
  -1.89427331e-01f, -1.84550080e-02f, 3.34784538e-02f, -1.81077316e-01f, -1.19595090e-02f, 2.15951875e-01f, -1.74328923e-01f, -1.23322226e-01f, 5.80261908e-02f, -4.87408452e-02f,
  7.78236166e-02f, 7.34509453e-02f, 3.07476502e-02f, 6.76984638e-02f, -4.66587171e-02f, -2.59758849e-02f, -6.35572895e-02f, 2.34666727e-02f, -1.50407791e-01f, 1.31028593e-02f,
  -1.03306487e-01f, -1.76380575e-01f, 3.98121141e-02f, -5.25339581e-02f, -1.22762784e-01f, 2.14066971e-02f, -5.35607375e-02f, 1.79799245e-04f, -1.20682353e-02f, -2.62494795e-02f,
  5.76466545e-02f, 3.33362967e-02f, -2.32127262e-03f, 1.44932136e-01f, -5.23873754e-02f, -2.37397524e-03f, 4.85629514e-02f, 2.04966031e-02f, 6.74621612e-02f, 3.30874957e-02f,
  2.25417558e-02f, -5.25559783e-02f, 8.64180736e-03f, -6.68414757e-02f, 7.00593963e-02f, -1.06564425e-01f, -2.30459962e-03f, -4.19745520e-02f, -1.35435387e-01f, -8.31624717e-02f,
  1.64185673e-01f, 1.13090560e-01f, 2.84189973e-02f, -4.87294607e-02f, -2.97790710e-02f, -1.21100144e-02f, 4.40990999e-02f, 1.54004721e-02f, -7.25914463e-02f, 1.26649775e-02f,
  -2.77686212e-02f, -2.76140738e-02f, 1.01341335e-02f, -3.47614549e-02f, 5.25317527e-02f, 4.08570170e-02f, -7.10509121e-02f, -4.69820611e-02f, 3.53672951e-02f, 4.01405655e-02f,
  5.39402179e-02f, -1.16885733e-02f, -2.20784973e-02f, -7.39760399e-02f, -2.81099603e-02f, 4.88680638e-02f, 1.50068160e-02f, -8.56545195e-02f, 8.30554310e-03f, 1.09523199e-02f,
  -1.32739186e-01f, -1.95856720e-01f, 4.05840129e-02f, -1.50571078e-01f, -1.25821773e-02f, -1.70326624e-02f, 8.97102877e-02f, -3.57752815e-02f, -3.49627845e-02f, -1.73859149e-02f,
  7.58272856e-02f, -1.07002586e-01f, -3.12706048e-04f, -5.66707104e-02f, 1.21757835e-01f, 2.34757513e-02f, -9.46100801e-03f, -6.28812909e-02f, -1.27215624e-01f, -9.03446749e-02f,
  -5.06137833e-02f, 4.36172299e-02f, -2.79784445e-02f, 6.40038922e-02f, -2.56966371e-02f, -9.74193439e-02f, -3.37001309e-02f, -9.04203132e-02f, 1.10159323e-01f, 7.50823766e-02f,
  -5.54218173e-01f, -1.21039776e-02f, 6.74269795e-02f, -1.74846631e-02f, -1.81971658e-02f, 4.46417123e-01f, 2.86705166e-01f, -5.85021116e-02f, -1.90403000e-01f, 2.00401396e-01f,
  1.29901603e-01f, -5.54257669e-02f, 1.64300948e-01f, 3.07609230e-01f, 2.41907433e-01f, 2.40841523e-01f, 1.09907031e-01f, 1.76408663e-01f, -1.00146554e-01f, -1.39873058e-01f,
  -5.05331047e-02f, 7.21398890e-02f, 3.06482553e-01f, -1.69252098e-01f, -1.01529323e-01f, -2.91011453e-01f, -9.31153297e-02f, 2.28165425e-02f, 1.29116684e-01f, 1.08414382e-01f,
  -1.12296827e-01f, -2.85783917e-01f, -8.78906529e-03f, 4.38648351e-02f, 3.99045311e-02f, 1.75425466e-02f, 8.31347331e-02f, 8.98551047e-02f, 2.18527019e-02f, -6.18971605e-03f,
  2.51438208e-02f, -5.38933203e-02f, -7.69031793e-02f, 2.33274139e-02f, -7.72619098e-02f, 1.10800356e-01f, -5.75344078e-02f, 1.07149534e-01f, 7.72734433e-02f, 3.61893997e-02f,
  1.08919032e-01f, -7.16427015e-03f, -2.91599985e-03f, 2.93873269e-02f, 2.98209246e-02f, -1.07627712e-01f, -4.53748181e-02f, 2.84875333e-02f, 4.05157954e-02f, 8.25031288e-03f,
  -1.17237329e-01f, -6.59992024e-02f, -1.92530360e-02f, 9.27516539e-03f, -2.80038337e-03f, 3.02417181e-03f, 1.38103694e-01f, -2.23679114e-02f, 4.60238419e-02f, -4.86441441e-02f,
  1.34254480e-02f, -8.13638233e-03f, -4.88255695e-02f, 2.68451348e-02f, -1.06887817e-01f, -2.14085188e-02f, 2.74952687e-02f, -8.69044568e-03f, -1.95529573e-02f, -3.60929780e-02f,
  4.47061332e-03f, -1.62677169e-02f, -9.94924456e-02f, 3.08524296e-02f, -2.58358684e-03f, -1.47096897e-02f, -4.41293269e-02f, -1.67651419e-02f, -1.71368364e-02f, -3.52055207e-03f,
  -1.57543138e-01f, -2.74871200e-01f, -2.65107937e-02f, -5.58475070e-02f, 1.69345178e-02f, -7.42006823e-02f, -3.62220183e-02f, -2.83143166e-02f, -6.86667627e-03f, -3.36521901e-02f,
  3.18445042e-02f, -3.93944532e-02f, -8.12842399e-02f, -4.64708619e-02f, 9.65275317e-02f, -1.23749012e-02f, -1.00551032e-01f, -1.13568790e-02f, 1.19532473e-01f, 1.93105324e-03f,
  4.05251123e-02f, 5.02500236e-02f, 9.05455425e-02f, -6.16064854e-02f, -2.11942494e-02f, 3.73853706e-02f, -1.04811713e-01f, -5.10661677e-02f, -1.53346285e-02f, -2.32615625e-03f,
  2.77401619e-02f, 3.92080694e-02f, 1.16145857e-01f, 2.50019908e-01f, -1.31035626e-01f, -4.75702226e-01f, -2.85096884e-01f, 1.54846460e-01f, 2.48343825e-01f, -9.66230258e-02f,
  4.50811051e-02f, 1.49253443e-01f, 1.18720956e-01f, -7.25959018e-02f, 9.20532197e-02f, 9.89356041e-02f, -4.92067598e-02f, -1.45918265e-01f, 1.63776651e-01f, 4.17343760e-03f,
  1.58442795e-01f, 5.29388711e-02f, 1.03553407e-01f, -1.04830433e-02f, -1.71493903e-01f, 1.77507311e-01f, 1.13476671e-01f, -1.34271100e-01f, -1.29123926e-01f, -2.27194250e-01f,
  -1.26062140e-01f, 1.32820293e-01f, -2.15165373e-02f, -1.32656619e-01f, 1.22862207e-02f, -1.25976175e-01f, -6.01859540e-02f, -1.55791581e-01f, 2.17756424e-02f, -5.22084944e-02f,
  7.25714639e-02f, 1.08382804e-02f, 2.09400430e-02f, -2.67375726e-02f, -4.83444072e-02f, 1.21250272e-01f, 1.47112431e-02f, -6.64586499e-02f, 8.58030189e-03f, -8.01647380e-02f,
  3.33775878e-02f, -6.72323480e-02f, -3.39423344e-02f, -7.45310541e-03f, 1.28981560e-01f, 5.20342477e-02f, -3.08992136e-02f, -3.25697325e-02f, 1.02512941e-01f, 5.48871011e-02f,
  -8.39171559e-02f, -1.97399445e-02f, -6.44866005e-02f, 7.43047446e-02f, -2.00143941e-02f, -4.75010574e-02f, -4.72464748e-02f, 5.05232438e-02f, 2.81962473e-02f, 1.75861418e-02f,
  -2.34654173e-02f, 4.17407183e-03f, -1.37454667e-03f, -7.64516219e-02f, 1.51278332e-01f, -4.48259003e-02f, 3.58742028e-02f, -8.72512721e-03f, 6.49754703e-02f, 8.21451694e-02f,
  6.69017108e-03f, -2.84914449e-02f, 4.65627238e-02f, -7.38027468e-02f, -6.02121018e-02f, 7.79765695e-02f, -9.41797812e-03f, 2.64218617e-02f, -1.53673077e-02f, 3.11345533e-02f,
  -2.98992218e-03f, 1.96175694e-01f, 5.43794446e-02f, -8.10460374e-02f, 7.90105537e-02f, -6.68649524e-02f, -2.83297077e-02f, -9.40480381e-02f, 7.44854882e-02f, -4.64711934e-02f,
  3.69265191e-02f, -6.99480101e-02f, 9.24341604e-02f, -8.64759311e-02f, 2.01427303e-02f, 5.74923716e-02f, 7.43853748e-02f, 1.23600297e-01f, 5.13023064e-02f, 5.79408929e-03f,
  1.41644673e-02f, 1.80301927e-02f, -3.71889472e-02f, -1.49423480e-02f, -4.44194973e-02f, 7.00993463e-02f, 7.11070448e-02f, -3.15014422e-02f, 6.69352412e-02f, 3.21143232e-02f,
  3.28857936e-02f, 2.32332107e-02f, 2.09318325e-02f, 1.36261676e-02f, -1.48128271e-01f, -2.02579111e-01f, -5.21102175e-02f, -1.68280490e-03f, 2.93042511e-01f, 1.58405125e-01f,
  -2.12283775e-01f, 2.43691921e-01f, 4.71097380e-02f, -1.47900373e-01f, 1.15785509e-01f, 1.35299787e-01f, -2.30770186e-01f, -1.21407144e-01f, -4.49115336e-02f, -1.53300822e-01f,
  -4.77167070e-02f, -1.49481013e-01f, -1.19023375e-01f, -9.99173224e-02f, -1.89416945e-01f, -7.96287879e-03f, -5.91430068e-02f, -3.40690874e-02f, -1.12383291e-01f, -5.73097393e-02f,
  -1.88183039e-02f, 1.63500123e-02f, -1.10371687e-01f, -1.72004774e-02f, -7.45315701e-02f, -5.66965081e-02f, -6.97761700e-02f, -4.82585169e-02f, -8.49450082e-02f, -2.77431291e-02f,
  1.67535618e-01f, 3.51453684e-02f, 7.06743896e-02f, 6.04902348e-03f, 8.89074802e-02f, 4.18452285e-02f, -9.50489566e-03f, -4.00212035e-02f, -2.07255855e-02f, -3.81979607e-02f,
  -5.74756898e-02f, -8.22714567e-02f, -6.26285672e-02f, 2.91899592e-02f, -8.14337283e-02f, 9.90640074e-02f, -4.20113690e-02f, -7.21686557e-02f, 5.18592596e-02f, 5.30266091e-02f,
  1.11967558e-02f, -4.47670668e-02f, -5.15330210e-02f, -3.10453400e-02f, -2.38571111e-02f, -4.38295677e-03f, -4.77097146e-02f, -1.47433458e-02f, 5.51351160e-03f, -4.40393873e-02f,
  6.97825253e-02f, -1.13649383e-01f, -1.02891028e-02f, 2.94502266e-02f, 4.73788157e-02f, 7.75859430e-02f, 3.35460086e-03f, -6.99576689e-03f, 5.63525856e-02f, 1.19055592e-01f,
  7.84996003e-02f, 6.12619426e-03f, -1.27468177e-03f, -6.57859072e-03f, -1.51879909e-02f, -7.94687197e-02f, 2.93167140e-02f, -4.99602929e-02f, -1.16587775e-02f, -6.24311417e-02f,
  -7.90041685e-02f, 1.03303485e-01f, -8.24830532e-02f, 4.15429249e-02f, 7.41929421e-03f, 1.88634582e-02f, -1.64806657e-02f, 3.32815796e-02f, -1.24258816e-01f, 5.07892668e-02f,
  8.11411366e-02f, -9.10083652e-02f, 8.82623792e-02f, 6.04663752e-02f, 2.20217500e-02f, 2.32517086e-02f, 1.12060867e-02f, 9.32947397e-02f, -1.01762205e-01f, -6.00219294e-02f,
  4.56960052e-02f, 1.07727072e-03f, 5.28303199e-02f, 8.36792868e-04f, -3.53430770e-02f, 5.91660570e-03f, 1.61837824e-02f, 6.11703889e-03f, 1.99884791e-02f, 6.68016970e-02f,
  7.67096505e-02f, 1.03118895e-02f, 1.63693294e-01f, 2.74296492e-01f, 8.04363936e-03f, -1.64243177e-01f, -1.13944799e-01f, 9.82645899e-02f, 1.53060451e-01f, -1.27076760e-01f,
  -2.71890853e-02f, -9.77243856e-02f, -6.22277185e-02f, 4.82430420e-04f, -8.06511864e-02f, -1.95789009e-01f, 1.51745128e-02f, -9.32255834e-02f, -4.41036373e-02f, 5.38468361e-02f,
  1.34875387e-01f, -2.93114707e-02f, 2.61042174e-02f, 7.27255791e-02f, 5.51802404e-02f, 1.61324456e-01f, 2.24584397e-02f, -7.71261305e-02f, 5.65367006e-02f, -1.88020412e-02f,
  3.33258659e-02f, -7.87563697e-02f, 3.99376862e-02f, -4.52434784e-03f, -2.29160693e-02f, 8.12502801e-02f, -3.22012082e-02f, 6.19615130e-02f, 3.02195102e-02f, -1.42131031e-01f,
  1.00012980e-02f, 6.49987683e-02f, -7.18364120e-02f, -1.19596608e-01f, 1.90243702e-02f, 4.33663167e-02f, -4.78111617e-02f, 1.35917619e-01f, 1.27469867e-01f, -6.03429452e-02f,
  1.82646573e-01f, -4.04429855e-03f, -2.70090601e-03f, -6.70625046e-02f, -1.28877955e-02f, 3.53587791e-02f, -4.04657014e-02f, -6.21516444e-03f, 5.36355451e-02f, -6.86783195e-02f,
  -1.41661629e-01f, -1.61436535e-02f, -7.62418061e-02f, 1.56251732e-02f, 2.32496718e-03f, -2.14458108e-02f, -5.32559752e-02f, 8.14727172e-02f, 7.64448792e-02f, 9.01015848e-02f,
  5.88637814e-02f, -4.75058658e-03f, 9.20208450e-03f, 8.16941634e-02f, -8.90080854e-02f, -2.62578353e-02f, 5.91330193e-02f, -9.72633343e-03f, 1.20090723e-01f, 6.03608266e-02f,
  -9.10184905e-02f, 6.13740645e-02f, -7.81592354e-02f, -5.79074807e-02f, -1.27992630e-01f, -3.91522571e-02f, -2.44191214e-02f, 7.66841546e-02f, 3.76658998e-02f, 5.44234999e-02f,
  -2.94085648e-02f, 2.71109864e-03f, -4.81280498e-03f, -7.21085742e-02f, 1.20083345e-02f, 7.62420148e-02f, 9.08473600e-03f, 9.88371391e-03f, -3.71210575e-02f, -1.57111399e-02f,
  1.28703192e-01f, 7.04154149e-02f, -4.61232625e-02f, 4.08170857e-02f, -2.39672158e-02f, -1.21405974e-01f, 5.18602841e-02f, 1.02384746e-01f, 1.12435095e-01f, -5.22288755e-02f,
  -7.23489746e-03f, 2.81601045e-02f, 1.42159257e-02f, 6.48603737e-02f, 5.50748073e-02f, -1.36155833e-03f, -5.32738939e-02f, -4.23128046e-02f, 1.02968194e-01f, 4.57490236e-03f,
  -3.29437442e-02f, 4.56524976e-02f, 9.13432091e-02f, -7.12321848e-02f, -1.17739046e-03f, -1.09918557e-01f, -1.14139929e-01f, -7.53281116e-02f, 1.42029941e-01f, -9.46800038e-02f,
  -1.84829533e-01f, 2.10497831e-03f, 3.61801172e-03f, -2.30826363e-01f, 7.47544542e-02f, 2.57947966e-02f, -1.10889316e-01f, -8.96937698e-02f, 1.75258249e-01f, -1.84603810e-01f,
  -1.92850828e-01f, -2.68295288e-01f, -6.97989836e-02f, -9.84135494e-02f, -1.61739990e-01f, 6.13717772e-02f, -7.84581825e-02f, -4.55127768e-02f, -1.24248222e-01f, 3.13942134e-02f,
  1.52925635e-02f, -3.09928097e-02f, 1.04938388e-01f, 8.15770868e-03f, -1.65575266e-01f, -6.26657903e-02f, 4.28608395e-02f, 4.18243073e-02f, 1.78475693e-01f, 5.27478643e-02f,
  1.40960496e-02f, -7.96709061e-02f, 7.65006170e-02f, 6.16642321e-03f, 7.03643486e-02f, -5.38810901e-02f, -8.83802697e-02f, 3.56118716e-02f, 1.44418478e-01f, 2.32331809e-02f,
  4.88404781e-02f, 1.16280600e-01f, -5.77770174e-02f, -6.11152127e-02f, 7.16880336e-02f, 3.56178475e-03f, -4.54294607e-02f, 1.48547381e-01f, -5.41345179e-02f, 5.48964925e-02f,
  -1.02230772e-01f, -6.92084134e-02f, -7.53303841e-02f, 4.94361520e-02f, 8.60360544e-03f, -2.70203147e-02f, 1.13891903e-02f, -1.01969406e-01f, 5.35729108e-03f, -2.62133665e-02f,
  6.11829013e-02f, -2.02225577e-02f, -6.83508143e-02f, -6.77448045e-03f, -1.22010507e-01f, 1.93906147e-02f, 1.41626252e-02f, 1.10023441e-02f, -6.23159111e-02f, -4.23536897e-02f,
  -1.57383353e-01f, -8.94126371e-02f, -2.76399422e-02f, -6.29584566e-02f, 7.80860707e-02f, 7.75990784e-02f, -8.01980942e-02f, 9.22490209e-02f, -9.39736550e-04f, -4.59382124e-02f,
  6.24640398e-02f, -2.04213277e-01f, 7.17227757e-02f, 2.40076110e-02f, 5.66463210e-02f, -9.52281896e-03f, -1.34285823e-01f, 6.22355454e-02f, 1.00472659e-01f, -1.06140554e-01f,
  -7.51459152e-02f, -1.03357397e-01f, 9.12295356e-02f, 9.71986130e-02f, -3.55219692e-02f, -2.40183678e-02f, -6.54516974e-04f, 1.03118248e-01f, 6.76860735e-02f, -3.58267091e-02f,
  1.47546846e-02f, -8.12497959e-02f, -1.00074001e-01f, 9.64246131e-03f, 1.11955497e-02f, -2.08697934e-02f, -6.20368421e-02f, 4.05959710e-02f, -3.25277075e-02f, 1.07784178e-02f,
  -5.53217351e-01f, 2.95018673e-01f, -2.60538906e-01f, 1.30986214e-01f, -1.73396349e-01f, 1.46777973e-01f, 2.24105880e-01f, 4.40576710e-02f, 2.93277651e-02f, 2.48490885e-01f,
  3.30972932e-02f, 1.12859337e-02f, -1.05965964e-03f, 1.60778746e-01f, -2.25831136e-01f, 1.22857414e-01f, 1.01406343e-01f, 4.62175012e-02f, -2.89724879e-02f, -9.41026304e-03f,
  -4.64017801e-02f, 6.18204027e-02f, -9.48117077e-02f, 1.65699217e-02f, -1.11716636e-01f, -7.79776350e-02f, -2.41323337e-02f, -1.86372548e-02f, 1.63668439e-01f, -1.04266226e-01f,
  -1.50592297e-01f, -2.46226445e-01f, -1.17196694e-01f, -6.23659194e-02f, -4.35182378e-02f, 1.35036716e-02f, -8.70670974e-02f, 4.71297977e-03f, -7.74391145e-02f, 2.90193763e-02f,
  -5.83429039e-02f, -2.19076611e-02f, 2.67322883e-02f, -7.36438157e-03f, 8.07102621e-02f, -4.64096405e-02f, 8.61951262e-02f, 9.49346423e-02f, 2.01829486e-02f, -2.15215441e-02f,
  1.38971880e-01f, -1.58732105e-02f, 3.55186723e-02f, -1.07659645e-01f, -4.44089621e-02f, 3.72665115e-02f, -1.37326159e-02f, 3.88560072e-02f, 8.40093866e-02f, 2.46813875e-02f,
  -3.63543369e-02f, 4.15819138e-02f, 4.91142198e-02f, 4.88365553e-02f, 3.50268073e-02f, -1.55599304e-02f, 1.28192287e-02f, 3.42466868e-02f, 1.72115564e-02f, -2.49407231e-03f,
  -5.08057848e-02f, -2.40604091e-03f, 1.04754488e-03f, 1.73163880e-02f, 1.19944640e-01f, -6.52845278e-02f, -4.65562195e-02f, -9.89253223e-02f, 8.79545510e-02f, 4.95413356e-02f,
  -3.86278406e-02f, 4.28533740e-02f, 9.82639715e-02f, 1.13540031e-02f, 3.90786417e-02f, -1.21213570e-01f, -5.43223694e-02f, 1.11403791e-02f, -6.11406341e-02f, 1.49273500e-03f,
  1.15848007e-02f, 6.48783706e-03f, -1.42682225e-01f, 1.39737809e-02f, -4.65365723e-02f, 2.13640537e-02f, -3.64220589e-02f, -7.43426010e-02f, 3.53644378e-02f, -1.02779739e-01f,
  -5.92808239e-02f, -9.25354380e-03f, -2.52343304e-02f, -7.34495521e-02f, 1.96411666e-02f, 5.53280264e-02f, 2.79520545e-02f, -4.84101400e-02f, 1.85206924e-02f, -6.07388876e-02f,
  -3.56401801e-02f, 2.29761694e-02f, -5.58674382e-03f, -3.60450856e-02f, 2.59908289e-02f, 5.74428178e-02f, -2.63963155e-02f, -3.45272049e-02f, 6.80450723e-02f, 2.17441395e-02f,
  -2.87554532e-01f, -2.18703255e-01f, -8.53988752e-02f, 3.89731340e-02f, 4.93181534e-02f, -1.52101368e-01f, -1.60212457e-01f, 3.91980968e-02f, -1.50859982e-01f, -1.28623351e-01f,
  -9.97855049e-03f, 4.87013347e-02f, 4.55384701e-02f, 7.84413368e-02f, 2.10409224e-01f, -5.28027490e-02f, 3.37735489e-02f, 4.31955233e-02f, 1.21429758e-02f, -2.62182895e-02f,
  1.37650400e-01f, 1.98824584e-01f, 2.02453092e-01f, 1.70564488e-01f, 1.29640689e-02f, 1.73875377e-01f, 1.86179355e-01f, 2.29324549e-01f, 2.39220321e-01f, 6.41775429e-02f,
  -1.64610773e-01f, -1.33359805e-01f, -2.21121237e-02f, 4.19428386e-02f, 5.75108044e-02f, -1.91280358e-02f, -6.17869990e-03f, 6.37434050e-02f, -8.07676371e-03f, 7.05192238e-02f,
  -1.35103203e-02f, 5.22419363e-02f, 6.93823025e-02f, -9.45905130e-03f, -1.84944272e-01f, 7.52897114e-02f, 6.28752112e-02f, 7.31294975e-03f, 7.53419027e-02f, 2.43699551e-02f,
  5.78337125e-02f, 1.05559332e-02f, -6.22804351e-02f, 8.70898087e-03f, 3.48553471e-02f, -2.39628740e-02f, -1.27140716e-01f, 8.60345364e-02f, -3.34361903e-02f, -1.66662902e-01f,
  4.46336018e-03f, 6.13225177e-02f, 3.39141190e-02f, 7.20920712e-02f, -2.73763072e-02f, -3.37487757e-02f, 1.23691680e-02f, 7.41067678e-02f, 3.06533221e-02f, -2.22316571e-02f,
  -1.15034483e-01f, -2.41290294e-02f, -7.91494176e-02f, -1.23976938e-01f, 1.05128527e-01f, -7.30477944e-02f, 1.98957622e-02f, 5.52741475e-02f, -2.88487747e-02f, -3.80028486e-02f,
  -1.43780664e-01f, 3.28851566e-02f, -4.07480299e-02f, -5.70697412e-02f, -1.76079180e-02f, 4.44115326e-02f, -2.57939156e-02f, 1.29515305e-02f, -4.61170799e-04f, 5.39444238e-02f,
  -1.31216362e-01f, 3.62625606e-02f, -1.23221148e-02f, -1.10142805e-01f, -6.79791644e-02f, 9.11984518e-02f, -5.72772026e-02f, 2.46604681e-02f, 5.07851839e-02f, 4.50428650e-02f,
  6.46531815e-03f, 2.64875102e-03f, 1.21007329e-02f, -1.15000650e-01f, 7.22292289e-02f, -1.33242041e-01f, 1.50287233e-03f, 1.39397094e-02f, 5.80652170e-02f, 1.65149495e-02f,
  4.16108668e-02f, 2.61939485e-02f, 3.83576714e-02f, 1.98317617e-02f, -1.25325415e-02f, 2.66422518e-02f, -2.25476902e-02f, -1.19878754e-01f, 9.94407237e-02f, -3.97841297e-02f,
  1.13699343e-02f, 9.80269834e-02f, -2.14247540e-01f, -1.10293746e-01f, -4.87795146e-03f, 3.64146829e-01f, 3.09418142e-01f, -2.18617767e-01f, -1.76212832e-01f, 1.75924405e-01f,
  1.41664490e-01f, 9.19566303e-02f, 1.55687869e-01f, 3.40777963e-01f, 2.70033598e-01f, 2.67412812e-01f, 2.49862060e-01f, 2.08917394e-01f, -1.39024556e-01f, 3.66946347e-02f,
  -1.10160291e-01f, 2.23110273e-01f, 3.22502702e-02f, -1.26269236e-01f, 2.07403108e-01f, -2.81162620e-01f, 6.63835481e-02f, -7.09741563e-02f, 7.74274245e-02f, 9.72191244e-02f,
  1.31077051e-01f, 4.74670231e-02f, -3.48285586e-02f, -1.10050421e-02f, 2.34170444e-02f, 2.03655697e-02f, 3.44219133e-02f, 9.48877539e-03f, -9.89507958e-02f, -1.71224251e-02f,
  7.19551146e-02f, -8.04461390e-02f, -3.24892998e-02f, 3.43168713e-02f, -2.70578563e-02f, -1.78964846e-02f, 2.21017115e-02f, -8.94735903e-02f, -6.55208826e-02f, 4.78860252e-02f,
  3.13701294e-02f, -6.19025826e-02f, -8.49660635e-02f, -2.48945616e-02f, -7.58033916e-02f, 4.94847968e-02f, 1.26012787e-03f, -1.33794835e-02f, 8.35753046e-03f, -4.63982113e-02f,
  3.89614217e-02f, 3.06824315e-02f, -5.83356246e-02f, 6.86908737e-02f, -5.22981063e-02f, -1.54645890e-02f, 3.25933956e-02f, -4.72370610e-02f, -1.88300058e-01f, -9.41764843e-03f,
  1.93822719e-02f, 6.72456548e-02f, 1.54256552e-01f, -2.33596768e-02f, -3.03060170e-02f, -2.43381076e-02f, 5.27622085e-03f, 2.23415717e-02f, -7.84839913e-02f, 9.15822685e-02f,
  -1.21738240e-01f, -1.13362357e-01f, -9.47334804e-03f, 1.93088260e-02f, 7.63263404e-02f, -1.46589363e-02f, 8.95533524e-03f, 3.27079184e-02f, 1.98987368e-02f, 5.85952699e-02f,
  1.38229623e-01f, -4.79146093e-03f, -8.60968232e-02f, 7.89538473e-02f, 3.02672088e-02f, 8.48351568e-02f, 1.19940870e-01f, 3.59996706e-02f, 2.18466613e-02f, 7.52726058e-03f,
  -3.16229574e-02f, -1.82725731e-02f, -1.00649418e-02f, -8.37855786e-02f, -7.95500204e-02f, -2.55114418e-02f, 1.45633593e-01f, 2.01619994e-02f, -3.61322029e-03f, -5.88402245e-03f,
  -4.36173519e-03f, -7.63484016e-02f, -4.58605029e-02f, -9.07565653e-03f, 5.72705120e-02f, 8.46929774e-02f, 3.44842896e-02f, -1.00633577e-01f, 2.76735555e-02f, -6.85586110e-02f,
  2.74316162e-01f, 3.35305929e-01f, 5.55351488e-02f, 2.24660203e-01f, -2.36821666e-01f, -6.98135719e-02f, 1.97962224e-02f, -9.99704525e-02f, 1.46734446e-01f, 2.31502205e-01f,
  -1.03406467e-01f, 3.81829202e-01f, -1.36688143e-01f, 2.49071375e-01f, -2.54757166e-01f, -7.75911938e-03f, -6.76820753e-03f, 2.16689676e-01f, 6.99950978e-02f, 1.45244775e-02f,
  -9.36172307e-02f, -1.96816713e-01f, -8.75577182e-02f, -1.45502955e-01f, 6.65161610e-02f, 7.86591228e-03f, -2.88622588e-01f, -1.08466618e-01f, 6.28531724e-02f, -1.54562324e-01f,
  3.62409689e-02f, 2.83443723e-02f, 1.40042230e-01f, -1.46409273e-02f, -1.07523493e-01f, -2.33602725e-04f, -2.53316611e-02f, -1.46696903e-02f, -2.28923000e-03f, -2.05745062e-04f,
  -1.43193873e-02f, -7.44559169e-02f, 5.16325012e-02f, 1.17649652e-01f, 1.78057700e-01f, -3.80621143e-02f, 1.01806954e-01f, 7.95203894e-02f, 1.44003093e-01f, 1.08468182e-01f,
  7.69278407e-02f, 1.44476742e-02f, -5.36523312e-02f, 1.17955953e-01f, 5.52375452e-04f, -1.98697671e-02f, -2.93316506e-02f, 1.07507505e-01f, 1.16679147e-01f, -8.83316994e-03f,
  1.65275962e-03f, -2.61558630e-02f, 4.82092761e-02f, -3.71132419e-02f, -6.08627163e-02f, -7.37001980e-03f, -1.49581814e-02f, -3.13579501e-03f, -2.84239780e-02f, -3.36544064e-04f,
  4.83539738e-02f, 5.67507334e-02f, -7.11914375e-02f, 6.97067976e-02f, 4.19607535e-02f, 3.54956873e-02f, 1.17431559e-01f, 2.96792306e-04f, -3.88015667e-03f, -5.29416278e-02f,
  -9.49332267e-02f, -8.52843001e-02f, 9.13510507e-04f, -8.27968717e-02f, 6.93765804e-02f, -1.42198697e-01f, -6.36116713e-02f, 3.90729830e-02f, 5.78592122e-02f, -6.88450858e-02f,
  -7.40769133e-02f, -3.35455798e-02f, 1.04573302e-01f, 4.86252941e-02f, 5.53253032e-02f, -5.76719046e-02f, 6.93612173e-02f, 2.91460566e-02f, 6.64710812e-03f, -5.39310351e-02f,
  -3.37270498e-02f, -1.82492845e-02f, -1.36911869e-01f, 7.82171637e-03f, -7.08208093e-03f, -5.62247029e-03f, 5.25629409e-02f, 4.92626540e-02f, -8.14405903e-02f, -9.29445960e-03f,
  5.07207029e-02f, 3.37467194e-02f, 1.26637906e-01f, 3.57191861e-02f, 1.19651265e-01f, -5.30426949e-02f, 7.02846348e-02f, 9.12919715e-02f, -1.32244527e-01f, -1.80668328e-02f,
  2.17404157e-01f, 1.26776800e-01f, -1.20141745e-01f, -6.64443895e-02f, -1.00677676e-01f, 9.79089066e-02f, 1.24805748e-01f, -1.24495469e-01f, 5.12563363e-02f, 3.30095589e-02f,
  -8.79029557e-03f, 4.66670431e-02f, -4.69817221e-02f, -6.85895979e-02f, 2.30211988e-01f, 1.17678173e-01f, 5.65251103e-03f, 8.12774226e-02f, 4.60534245e-02f, 4.78026532e-02f,
  -1.02771103e-01f, 2.97577530e-02f, -1.25397563e-01f, -6.25738800e-02f, -8.10010433e-02f, -1.65724203e-01f, -1.23548642e-01f, -1.12508498e-01f, -1.54905871e-01f, 3.11760269e-02f,
  -9.74372204e-04f, 9.28801894e-02f, -7.11875856e-02f, -4.26274230e-04f, 6.47265017e-02f, 2.66895536e-02f, 1.53289130e-02f, 2.25368682e-02f, -3.42660584e-04f, 6.04281835e-02f,
  -4.50088605e-02f, -1.13885831e-02f, 3.34517509e-02f, -3.48014571e-02f, 5.38151152e-02f, -2.06203237e-02f, -1.03013692e-02f, -5.69355004e-02f, -6.87732920e-02f, -2.25846283e-02f,
  -1.63056124e-02f, 2.33362522e-02f, 2.62559000e-02f, -1.94597431e-02f, -1.85735766e-02f, -9.29811373e-02f, -5.50089031e-02f, -9.43966508e-02f, -1.38596632e-02f, 2.49599349e-02f,
  1.61289200e-01f, -1.16704069e-02f, 1.02331810e-01f, 1.54123316e-02f, -3.63932289e-02f, -1.01325952e-01f, -5.99975772e-02f, -5.03266528e-02f, -9.03445203e-03f, 2.84942482e-02f,
  -3.27844061e-02f, 1.52156064e-02f, 7.65248537e-02f, -2.90567391e-02f, -1.79314855e-02f, -4.09866013e-02f, -6.86323270e-03f, -8.43599290e-02f, -1.73298493e-02f, 2.22085658e-02f,
  -2.70227087e-03f, -8.48525539e-02f, -2.89150537e-03f, -9.09215435e-02f, -3.84821631e-02f, 9.84200537e-02f, 2.64068656e-02f, 4.33851294e-02f, 5.28467000e-02f, 5.46477027e-02f,
  -9.34245437e-03f, 4.49249666e-04f, 4.09174301e-02f, 1.59998089e-02f, 1.66045818e-02f, -4.00133058e-02f, -1.79497078e-02f, 3.08447555e-02f, 7.79193044e-02f, 2.06635036e-02f,
  -6.45423308e-02f, -3.35442722e-02f, 1.13094181e-01f, -4.97668460e-02f, -6.19062334e-02f, -4.71797101e-02f, 1.34289218e-02f, -4.23074961e-02f, -2.23615952e-02f, 2.82685366e-02f,
  -7.70195648e-02f, 5.26682800e-03f, 5.99229001e-02f, -1.00603774e-02f, -8.39860588e-02f, -1.02884948e-01f, -3.15808393e-02f, -1.63807310e-02f, 9.85028744e-02f, -1.29362762e-01f,
  2.57182062e-01f, -1.29021360e-02f, -1.76772967e-01f, 4.82505113e-02f, 3.54881883e-02f, -8.17128792e-02f, -7.40782693e-02f, 4.67260890e-02f, 2.59175450e-02f, -4.18367833e-02f,
  8.99533704e-02f, -8.67986530e-02f, -1.74170271e-01f, 2.64643312e-01f, 1.19417578e-01f, -7.32304975e-02f, 1.35752439e-01f, 1.09895505e-01f, -5.81334755e-02f, 1.82859555e-01f,
  3.55394348e-03f, 3.38270128e-01f, -1.73512071e-01f, 9.94376559e-03f, 5.38291186e-02f, -1.01905480e-01f, 6.82254881e-02f, -2.79464096e-01f, 7.79853091e-02f, 4.55995314e-02f,
  -8.06428045e-02f, 4.14657257e-02f, -7.43394624e-03f, -3.83460820e-02f, 6.98095560e-02f, -3.67035381e-02f, -1.15500249e-01f, -4.12857756e-02f, -8.42986032e-02f, 9.64005366e-02f,
  -1.39251258e-02f, 2.73881741e-02f, 7.29557797e-02f, 2.53056977e-02f, 8.27952996e-02f, 3.34330387e-02f, 6.53794408e-02f, -8.92123580e-02f, -1.42883854e-02f, 7.66085635e-04f,
  -1.00566044e-01f, 8.08544531e-02f, 2.14615557e-02f, -1.07906789e-01f, -6.30683266e-04f, -4.55704927e-02f, -1.49014413e-01f, -5.23947179e-02f, -4.75022011e-02f, 5.45243993e-02f,
  2.37405673e-02f, 3.53744961e-02f, 8.17912593e-02f, 1.39995851e-02f, -4.93612774e-02f, -7.73802400e-02f, 1.46048106e-02f, -9.85406637e-02f, 4.24654000e-02f, 5.18209748e-02f,
  2.52656676e-02f, -8.01246688e-02f, -2.68693287e-02f, -7.64037445e-02f, -9.92220268e-03f, -2.97110137e-02f, -1.07749198e-02f, 3.92152406e-02f, 4.70310226e-02f, 7.29236603e-02f,
  -1.35029554e-01f, -1.58250164e-02f, 1.35149345e-01f, -4.26744409e-02f, -7.73891583e-02f, 5.12414090e-02f, 2.22491890e-01f, -2.26881802e-02f, -1.12843074e-01f, 1.13334749e-02f,
  1.25804367e-02f, 6.76879063e-02f, 2.41240133e-02f, 3.22174467e-02f, -4.04059626e-02f, -1.17780117e-03f, -4.87576388e-02f, 3.53484824e-02f, -1.05662115e-01f, 5.33917025e-02f,
  -4.20993119e-02f, -1.36194274e-01f, 4.61575948e-03f, -7.35580996e-02f, -8.52871016e-02f, 3.91185395e-02f, 4.38078605e-02f, -3.91602665e-02f, -3.95088904e-02f, 1.47405863e-01f,
  -3.54797132e-02f, 7.92279653e-03f, 4.23093438e-02f, -9.88374501e-02f, 1.05049700e-01f, 3.32359294e-03f, -8.85346606e-02f, -4.20075059e-02f, 2.66682375e-02f, 1.47639178e-02f,
  4.52538908e-01f, -1.86650857e-01f, -1.22230537e-01f, 1.52031183e-01f, 2.29622319e-01f, 2.25556850e-01f, 1.76532775e-01f, 1.96773544e-01f, 2.90500551e-01f, -5.82599528e-02f,
  7.65006542e-02f, -2.08780646e-01f, -1.62436947e-01f, 1.29669547e-01f, 1.05149277e-01f, -1.19573683e-01f, 1.39772683e-01f, 8.04820880e-02f, 9.98052880e-02f, 1.40236169e-01f,
  1.88796222e-01f, 2.10216790e-01f, -1.27832726e-01f, -8.23801234e-02f, 1.92072406e-01f, -1.47367239e-01f, -1.73575431e-01f, -2.39864036e-01f, -2.04816684e-02f, -1.49072977e-02f,
  4.92935963e-02f, 9.03956518e-02f, -1.43818706e-01f, 7.65397549e-02f, -4.63791862e-02f, -7.72136673e-02f, -1.46219954e-01f, -7.04638287e-02f, -2.18717218e-03f, 8.92245490e-03f,
  -1.50110442e-02f, 5.06092981e-02f, 1.11748882e-01f, 9.19451863e-02f, 1.06557660e-01f, 2.01308485e-02f, -6.16311766e-02f, -1.82704385e-02f, -5.95202856e-02f, -1.30880415e-01f,
  -6.04857095e-02f, -6.74543530e-02f, 6.35351837e-02f, -7.74168447e-02f, -8.36739838e-02f, -6.46670908e-02f, -3.58944945e-02f, -1.25851393e-01f, 6.80683330e-02f, -1.41325789e-02f,
  -3.67096299e-03f, -2.80759409e-02f, 4.96436991e-02f, 5.40771671e-02f, 4.52430658e-02f, -1.76965061e-03f, 1.59329504e-01f, 4.21793312e-02f, -4.16979007e-02f, 5.75895095e-03f,
  -1.39972605e-02f, -2.57402994e-02f, 1.33298591e-01f, -2.67220922e-02f, -1.04173794e-02f, 2.78212987e-02f, -8.75493325e-03f, -4.65463325e-02f, -2.36976054e-03f, -1.57533623e-02f,
  6.30356148e-02f, -1.18945636e-01f, -6.83843419e-02f, -2.79271789e-02f, -1.25592560e-01f, 3.90852755e-03f, -1.67081924e-03f, -1.66427018e-03f, -3.98990214e-02f, 5.31913489e-02f,
  4.43997309e-02f, -1.18863568e-01f, -9.28793103e-02f, 7.78897330e-02f, -1.32615298e-01f, 5.99819012e-02f, -1.23134991e-02f, 3.13356072e-02f, -1.07545920e-01f, 6.27005994e-02f,
  -4.70341332e-02f, 4.37178388e-02f, 4.73781601e-02f, 5.18297888e-02f, -8.83895457e-02f, 7.62742162e-02f, -1.48823801e-02f, -7.94048384e-02f, -3.56019773e-02f, -1.28510728e-01f,
  -7.17564002e-02f, 5.10379560e-02f, -4.19739000e-02f, -7.33085384e-04f, -1.63297076e-02f, -9.45784431e-03f, 4.52116877e-02f, 6.43711071e-03f, 4.83355261e-02f, -6.22967910e-03f,
  -3.19013804e-01f, 4.04476933e-02f, -1.35207593e-01f, -2.37289332e-02f, 3.20809707e-02f, -2.66506851e-01f, -8.53652060e-02f, 1.40289158e-01f, 1.64038199e-03f, 1.97189227e-01f,
  9.49803740e-02f, 6.27154559e-02f, 1.76685169e-01f, -5.20578437e-02f, -2.33404949e-01f, -6.67089783e-03f, -1.78198010e-01f, -1.65685236e-01f, 9.04634688e-03f, 8.21831673e-02f,
  -1.40857026e-01f, 4.88104075e-02f, -1.07333153e-01f, 1.21856369e-01f, -9.71176475e-02f, -3.46056186e-04f, 8.49665925e-02f, 9.78077129e-02f, -5.43228425e-02f, 6.99730441e-02f,
  9.16865319e-02f, 1.78167254e-01f, -5.90256527e-02f, -1.08733932e-02f, 2.29974533e-03f, 3.82101792e-03f, -1.33941740e-01f, -4.64402847e-02f, -4.99996021e-02f, 2.83936225e-02f,
  -2.12806631e-02f, 5.83462678e-02f, -2.77009793e-02f, 3.98353785e-02f, -1.88346598e-02f, 7.88000450e-02f, -6.98279962e-02f, -6.14706613e-02f, 1.30430737e-04f, -8.03831443e-02f,
  -5.63253164e-02f, 4.43471037e-02f, -9.85732824e-02f, 4.46749665e-02f, -5.95867671e-02f, 5.48474677e-03f, -6.07406534e-02f, -1.90109722e-02f, -1.20544303e-02f, 4.36517235e-04f,
  1.04720525e-01f, -8.33207443e-02f, -1.18378490e-01f, -5.13286777e-02f, 4.13238956e-03f, 3.51246931e-02f, -2.87961084e-02f, 1.39410775e-02f, -3.28488052e-02f, 1.20629929e-03f,
  1.14534892e-01f, -1.77621897e-02f, 4.36167940e-02f, -1.67658836e-01f, -5.83659261e-02f, 4.19106558e-02f, -1.09365612e-01f, 1.13013253e-01f, 3.70345116e-02f, 3.16514894e-02f,
  1.54899105e-01f, -1.07202949e-02f, 4.55532894e-02f, 4.09212820e-02f, 5.70501536e-02f, -8.18422884e-02f, -7.81603083e-02f, 3.47890742e-02f, 2.38760319e-02f, -3.80453207e-02f,
  1.24218233e-01f, 2.35745758e-01f, 8.05280209e-02f, 1.12703172e-02f, 2.39443164e-02f, -3.36290686e-03f, -5.55647425e-02f, -7.39516318e-02f, -2.90482957e-02f, -9.03232582e-03f,
  -5.55046163e-02f, -7.98061118e-02f, -9.74331200e-02f, -3.19643952e-02f, 6.48950934e-02f, 1.93036646e-02f, -5.27797230e-02f, 2.82321889e-02f, -4.29022238e-02f, 1.34765685e-01f,
  -2.37484146e-02f, 7.19310343e-02f, -1.31774604e-01f, 5.67323826e-02f, -2.74198353e-02f, -2.38920609e-03f, -4.22430299e-02f, 3.76864336e-02f, 7.83228576e-02f, 2.91016027e-02f,
  -2.27541581e-01f, 1.28208339e-01f, -9.21665281e-02f, -3.12158763e-01f, 2.30109021e-02f, -2.67281383e-01f, -1.62837327e-01f, 2.27803774e-02f, -8.06106627e-02f, 1.64167080e-02f,
  -9.92070436e-02f, -5.30388653e-02f, 5.26160225e-02f, -1.50645316e-01f, -1.41626462e-01f, 8.85913894e-02f, -3.37133318e-01f, -2.89977282e-01f, 1.00188285e-01f, -1.17300965e-01f,
  -1.09199248e-01f, -3.40800211e-02f, -1.45263240e-01f, 1.25686795e-01f, -1.13166913e-01f, -3.77524719e-02f, -7.52182156e-02f, 1.93271115e-01f, -7.88876414e-02f, 1.13991231e-01f,
  -2.71234438e-02f, -1.24483302e-01f, 7.47280419e-02f, -3.07516987e-03f, -1.14021428e-01f, -1.65571600e-01f, -2.98806094e-03f, 8.07669386e-03f, 1.50552429e-02f, -3.32753547e-02f,
  -8.17559473e-03f, -1.00280710e-01f, 5.02813905e-02f, 3.28217037e-02f, -6.35509044e-02f, -5.19546457e-02f, -3.87070961e-02f, -1.18211629e-02f, 4.26565260e-02f, 6.62704557e-03f,
  -4.27947342e-02f, 8.11211579e-03f, -1.21037230e-01f, -1.19833492e-01f, -5.10795414e-02f, 4.75972928e-02f, -1.73525829e-02f, -5.14265597e-02f, -1.12935528e-01f, -3.00024878e-02f,
  -3.69856283e-02f, -1.30826421e-02f, 1.32029608e-01f, -7.03077018e-02f, 9.90664810e-02f, 8.00601691e-02f, 1.12858601e-02f, 4.34984230e-02f, -6.06108680e-02f, -3.64906862e-02f,
  -2.00411305e-02f, -7.93920085e-02f, 5.80961294e-02f, -1.73160195e-01f, -1.41609773e-01f, 5.99305145e-02f, 4.23562042e-02f, -7.81562626e-02f, 6.41119555e-02f, -9.59807448e-03f,
  -5.95090240e-02f, -3.32484953e-02f, 1.08106337e-01f, 6.06820285e-02f, 1.97249260e-02f, -3.17735262e-02f, -5.19506596e-02f, -8.35354626e-02f, 7.01490343e-02f, 6.18929490e-02f,
  -4.39464264e-02f, -1.81779221e-01f, -1.67894922e-02f, 3.28826457e-02f, 3.04839425e-02f, 1.43605378e-02f, 2.43599061e-02f, -7.84151535e-03f, -4.86302078e-02f, -1.93164386e-02f,
  -7.10981414e-02f, -1.61981553e-01f, -5.52125601e-03f, 1.09608382e-01f, -9.99154672e-02f, 4.52070720e-02f, -4.39976752e-02f, 1.03442736e-01f, -1.80459604e-01f, -2.93566752e-02f,
  4.55086958e-03f, 4.85483324e-03f, 2.29175974e-04f, 4.18258645e-02f, -2.78379116e-03f, -7.57083967e-02f, -3.88238952e-02f, -2.46678963e-02f, -4.96560708e-02f, -8.08729306e-02f,
  2.49329463e-01f, -7.92852864e-02f, 1.84495538e-01f, 1.58871353e-01f, 3.79370861e-02f, 1.20811909e-01f, 6.36684988e-03f, -5.41888438e-02f, 8.09542015e-02f, -1.59746166e-02f,
  -5.00898212e-02f, 1.68236092e-01f, -1.07959040e-01f, 2.17518788e-02f, -1.78222567e-01f, -9.43058580e-02f, 5.91107793e-02f, 2.03709230e-02f, 2.39143334e-02f, 2.66246758e-02f,
  -3.71445008e-02f, -2.02759504e-01f, 1.21832918e-02f, -5.21117263e-02f, 1.48877010e-01f, 1.04379922e-01f, -1.95960566e-01f, -4.41044234e-02f, 7.94585571e-02f, -2.53880061e-02f,
  8.48998576e-02f, 6.30391464e-02f, -3.00318450e-02f, 5.96601963e-02f, -2.74175797e-02f, 1.14040717e-01f, 2.05682274e-02f, 2.40120199e-02f, 1.30366990e-02f, -8.34257156e-03f,
  -6.96571544e-02f, -1.78569667e-02f, -1.90131720e-02f, 6.01304062e-02f, 1.48135975e-01f, 1.07726052e-01f, 1.16294630e-01f, 8.93819481e-02f, 1.32683362e-03f, 1.24747306e-01f,
  2.15080116e-04f, 4.90912572e-02f, 2.07319316e-02f, 6.36971928e-03f, -1.07584232e-02f, -1.18612871e-02f, -2.75773499e-02f, 6.72588125e-02f, 3.12290303e-02f, -1.41007500e-02f,
  -4.42274213e-02f, 2.38716835e-03f, 1.62234232e-02f, -3.35850231e-02f, 1.56318638e-02f, 2.27244478e-02f, -6.94246218e-02f, -2.10275110e-02f, -1.28310770e-01f, -6.75114021e-02f,
  -2.51227873e-03f, 8.24538544e-02f, -6.80513680e-02f, 2.64903326e-02f, 9.02505666e-02f, 3.25597040e-02f, -6.10822737e-02f, -1.06260650e-01f, -1.08535610e-01f, -3.18402909e-02f,
  -4.95783389e-02f, -6.89157248e-02f, 3.91254649e-02f, 4.45995256e-02f, 8.29910785e-02f, 4.34597768e-03f, -1.47423623e-02f, 6.70910701e-02f, -9.63846315e-03f, -1.01428464e-01f,
  -9.05983075e-02f, -1.99575916e-01f, -2.02431306e-02f, -3.46456692e-02f, 2.75663603e-02f, -1.72831155e-02f, -9.38055590e-02f, 4.56464849e-02f, -1.92874465e-02f, -1.34793431e-01f,
  -6.64272681e-02f, 9.16761234e-02f, -3.98673490e-02f, 1.43517569e-01f, -4.63723168e-02f, -6.33883697e-04f, 8.47523063e-02f, -8.05857107e-02f, -9.68990549e-02f, 3.75191905e-02f,
  1.78879537e-02f, 5.58003783e-03f, 7.70117389e-03f, 2.88577583e-02f, 1.35644019e-01f, -1.32467642e-01f, 8.78739916e-03f, -1.11295156e-01f, -2.32424140e-02f, 4.90019396e-02f,
  1.24962360e-01f, -3.65523994e-01f, 6.42748624e-02f, 2.91559380e-02f, 3.09596598e-01f, 2.36608878e-01f, 1.88264340e-01f, -5.44229858e-02f, -1.65744737e-01f, -1.66817263e-01f,
  -4.17083725e-02f, -6.92318678e-02f, -1.67790070e-01f, -4.79773208e-02f, 3.07222039e-01f, -1.20854281e-01f, 2.43016910e-02f, 2.33616363e-02f, -6.85403571e-02f, -1.04190595e-01f,
  5.45587987e-02f, 1.17288247e-01f, 1.72446623e-01f, -6.37267977e-02f, -3.98352335e-04f, 2.29653269e-02f, -2.47367769e-02f, 1.34963870e-01f, 1.20324597e-01f, 1.37559921e-01f,
  -1.36396781e-01f, -1.87001780e-01f, -1.04309961e-01f, -3.11028101e-02f, -4.98217940e-02f, 7.93677196e-02f, 1.24760726e-02f, 9.72612426e-02f, 7.05019757e-03f, 4.42212224e-02f,
  -1.03309467e-01f, 5.31286560e-02f, 7.64308795e-02f, 4.78638187e-02f, 5.71118221e-02f, 3.29921837e-03f, 3.01425457e-02f, -6.59618294e-03f, -5.49398363e-03f, 5.92287183e-02f,
  2.01392965e-03f, -3.94170210e-02f, -7.73122115e-03f, 3.81801423e-04f, 6.43954650e-02f, -1.97692979e-02f, -4.69176695e-02f, 8.90282467e-02f, 1.90900005e-02f, 4.71471213e-02f,
  5.62668219e-02f, 5.17702289e-03f, 3.18217613e-02f, -6.33067712e-02f, -4.64263596e-02f, -4.10213321e-02f, 4.33437601e-02f, 6.14724085e-02f, -9.90617201e-02f, -2.20645964e-02f,
  -5.65814078e-02f, 3.13923997e-03f, -7.68331364e-02f, -3.76479886e-02f, 7.48120397e-02f, -8.21426511e-02f, -5.75889088e-02f, -4.71129678e-02f, -1.65853620e-01f, -2.90414002e-02f,
  -3.34299635e-03f, -2.87990104e-02f, -2.94725951e-02f, 6.81154430e-02f, 1.77590847e-02f, -1.04937833e-02f, -8.78129434e-03f, -1.22712078e-02f, -2.04660892e-02f, 3.61089259e-02f,
  -4.02535200e-01f, -2.79976040e-01f, -1.78908259e-02f, -4.13704365e-02f, -1.16201319e-01f, -1.27080917e-01f, 5.13134245e-03f, 3.22765633e-02f, -2.66198851e-02f, -7.36909511e-04f,
  -1.01762032e-02f, 7.65977008e-03f, -8.19820091e-02f, 8.04907531e-02f, 4.70110811e-02f, -3.36777372e-03f, -2.17180047e-02f, 1.43467505e-02f, -6.37737736e-02f, -1.07642487e-01f,
  -1.54130548e-01f, -4.67480440e-03f, 3.87536129e-03f, -2.52260435e-02f, 1.37396278e-02f, 3.22897434e-02f, -8.74487683e-02f, -8.23827907e-02f, 2.34009512e-02f, 2.71391440e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.14286102e-01f, 1.94604710e-01f, -7.03260070e-03f, 3.49611431e-01f, 9.31157023e-02f, 8.55343863e-02f, 7.52511919e-02f, 1.23085700e-01f, 1.05022170e-01f, 1.34643450e-01f,
  1.39174208e-01f, 1.28872126e-01f, 2.12422177e-01f, 1.05788685e-01f, -2.14297920e-02f, 1.53284177e-01f, 4.26520817e-02f, 2.63041019e-01f, 1.03959426e-01f, 3.87573354e-02f,
  1.65639907e-01f, 1.95925400e-01f, 8.14469457e-02f, 1.21524647e-01f, 1.92096196e-02f, 4.42222618e-02f, 6.27774559e-03f, 1.15950406e-01f, 6.91211224e-02f, 5.09988405e-02f,
  1.97467461e-01f, 1.83279708e-01f, 1.05361901e-01f, 1.41572610e-01f, -3.77297066e-02f, 5.16289435e-02f, 2.43573278e-01f, 1.22794762e-01f, 9.49096009e-02f, 1.36662376e-04f,
  9.62447226e-02f, 6.87638745e-02f, 8.06569755e-02f, 1.42353222e-01f, 1.22770384e-01f, 1.27654281e-02f, 2.06052754e-02f, 1.05396368e-01f, 6.20391443e-02f, 5.20358756e-02f,
  1.51177302e-01f, 1.70901045e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -8.96459371e-02f, -8.69548023e-02f, -3.61504965e-02f, -1.05841108e-01f, 5.46393655e-02f, 1.05334884e-02f, 2.06565447e-02f, -1.33742422e-01f, 8.54766220e-02f, -5.90224452e-02f,
  -6.02612793e-02f, 1.18884899e-01f, 2.00873479e-01f, 1.34734482e-01f, -1.22486286e-01f, 2.87500508e-02f, 1.07921485e-03f, -1.96509987e-01f, 2.48694550e-02f, -2.30786473e-01f,
  1.09374687e-01f, -1.92979515e-01f, -1.46610498e-01f, -5.16216494e-02f, -4.91691157e-02f, -5.27988672e-02f, -6.59911186e-02f, 4.15037721e-02f, -1.01867765e-02f, 1.34466112e-01f,
  9.03037563e-02f, 1.04933552e-01f, -3.96312810e-02f, 2.76009947e-01f, -1.81672238e-02f, -1.08297117e-01f, 5.91551811e-02f, -1.46745324e-01f, 1.08076982e-01f, -1.05111510e-01f,
  -2.07710583e-02f, 7.32690319e-02f, 1.57893337e-02f, -5.44114932e-02f, 1.03430338e-01f, -3.55415069e-03f, 5.60906306e-02f, 6.68360572e-03f, -1.60098225e-01f, 1.89747393e-01f,
  -1.91313699e-02f, 6.53323829e-02f, -1.35985330e-01f, 2.93460954e-02f, 1.65153109e-02f, -2.73779482e-02f, 9.35703143e-02f, -6.38029305e-03f, 1.74033821e-01f, 2.81899065e-01f,
  2.34407231e-01f, 4.11737114e-02f, 5.05166873e-02f, -1.10117279e-01f, 1.01759195e-01f, -3.36639695e-02f, 1.17745176e-01f, 1.66433193e-02f, -1.56756602e-02f, 1.27164438e-01f,
  2.67711300e-02f, 9.13918093e-02f, -2.42719650e-02f, -7.85437822e-02f, -3.18345465e-02f, -3.04565970e-02f, -6.25706539e-02f, -5.03990240e-02f, 1.17734686e-01f, 2.99104545e-02f,
  2.25372855e-02f, -1.98909407e-03f, 9.73818526e-02f, -1.09473363e-01f, -1.86287001e-01f, -1.16044357e-01f, -9.57546607e-02f, 3.37966643e-02f, 5.37123904e-02f, 1.52857020e-01f,
  -4.32046689e-02f, 3.63869481e-02f, -1.97819956e-02f, 1.11343004e-01f, -8.69428515e-02f, -2.37863325e-02f, 6.35603517e-02f, -5.88860996e-02f, -3.61351781e-02f, -3.17567959e-02f,
  -4.96007577e-02f, 3.73460054e-02f, -4.11523357e-02f, -6.57906458e-02f, 9.12197381e-02f, 2.32455701e-01f, 8.25257078e-02f, 4.93510552e-02f, 1.58941805e-01f, -5.99705800e-02f,
  -1.07319601e-01f, -4.10867818e-02f, 1.59565080e-03f, -1.54309750e-01f, -5.83527312e-02f, -1.26569584e-01f, 8.65565240e-03f, 8.95967558e-02f, -1.41120195e-01f, -6.85281828e-02f,
  2.05996707e-01f, 9.73769203e-02f, -6.60523698e-02f, -6.91193789e-02f, 6.40430748e-02f, -9.75493863e-02f, 1.36979461e-01f, 9.11537707e-02f, 6.27680449e-03f, -4.50454876e-02f,
  1.00764073e-01f, -1.88423954e-02f, 3.67105789e-02f, 4.59184051e-02f, -3.38648818e-02f, 1.28636852e-01f, -6.31707832e-02f, 1.73003394e-02f, 1.63979754e-01f, -1.61200210e-01f,
  -1.52751818e-01f, -1.28870517e-01f, -1.29856005e-01f, -4.60489392e-02f, -2.44430155e-02f, 7.61575177e-02f, 4.13260013e-02f, 2.12372229e-01f, -1.68526679e-01f, 8.87009501e-02f,
  1.10517919e-01f, -2.66302731e-02f, -7.43665472e-02f, -4.94870394e-02f, 1.73412532e-01f, 8.63289908e-02f, -2.17369050e-01f, -2.15808943e-01f, -1.09442854e-02f, -5.79647161e-02f,
  8.38091820e-02f, 4.95682471e-03f, 8.42521433e-03f, -2.37827692e-02f, -6.44079819e-02f, 9.38608199e-02f, -1.12858541e-01f, 3.53367701e-02f, -8.56373683e-02f, -1.71360314e-01f,
  5.14153130e-02f, 6.80011362e-02f, -5.47923446e-02f, 5.65698110e-02f, 2.87368968e-02f, 4.49422654e-03f, -7.72823915e-02f, -8.25393945e-02f, 1.07982129e-01f, 6.70433566e-02f,
  1.89106792e-01f, -1.77211925e-01f, 1.99924745e-02f, 1.84977464e-02f, -8.44126791e-02f, 9.12785828e-02f, 8.60819127e-03f, 9.45301056e-02f, -2.04083666e-01f, 3.69159728e-02f,
  9.49255526e-02f, 1.10163093e-01f, 4.67832536e-02f, 2.68131644e-02f, -3.39596719e-02f, 7.80902281e-02f, 5.42640872e-02f, 1.24819092e-01f, -1.02399237e-01f, 1.63423076e-01f,
  -2.17598416e-02f, -1.44779338e-02f, 1.11546088e-02f, -3.54200881e-03f, -1.21888652e-01f, 2.35385392e-02f, 1.46410868e-01f, 4.13214117e-02f, 2.60320362e-02f, 1.84654221e-01f,
  -8.51921737e-02f, 9.18297246e-02f, 1.82786301e-01f, -1.13734594e-02f, 2.86024455e-02f, 5.20004109e-02f, -4.03522961e-02f, 3.21717262e-02f, -1.65048927e-01f, 1.97783578e-02f,
  1.60499793e-02f, 4.34917994e-02f, 5.21231815e-02f, -1.26657367e-01f, 1.75926700e-01f, 8.87321755e-02f, -1.51482210e-01f, 1.35792971e-01f, -1.11905836e-01f, 5.74511103e-02f,
  -4.83440720e-02f, -1.47609398e-01f, 2.41310358e-01f, 1.61132187e-01f, -1.38545454e-01f, 3.17208469e-02f, -8.51048753e-02f, 3.81955169e-02f, -1.32626995e-01f, 3.48159969e-02f,
  3.41258347e-02f, -3.24717090e-02f, -1.08562306e-01f, -1.08090967e-01f, -3.43549214e-02f, 1.25967368e-01f, -2.13898858e-03f, 1.99001670e-01f, 1.22769456e-02f, 1.13460332e-01f,
  -4.96553257e-02f, 1.14759222e-01f, -6.32158667e-02f, -1.11452769e-02f, 1.55960754e-01f, 1.33366004e-01f, 1.98745783e-02f, -7.32699633e-02f, 6.46787435e-02f, -1.88717395e-01f,
  -1.42091677e-01f, -7.97999948e-02f, -2.68770456e-01f, 3.17365788e-02f, -1.24130081e-02f, -1.46465808e-01f, -2.05388099e-01f, -8.91155079e-02f, -1.07785769e-01f, 1.70784459e-01f,
  7.88106546e-02f, 1.65835202e-01f, 6.65131211e-02f, 2.48390436e-01f, -1.24050742e-02f, -1.14535503e-02f, 2.27553472e-02f, -1.18369155e-01f, 6.52316287e-02f, -5.29848710e-02f,
  2.17300802e-01f, 1.51713192e-01f, 3.59330513e-02f, -2.15637282e-01f, 1.44387111e-01f, -1.41242981e-01f, -3.83187272e-02f, -1.04338922e-01f, -7.57142454e-02f, 1.29383743e-01f,
  -9.37670618e-02f, 3.49213630e-02f, -1.10318080e-01f, 1.91940114e-01f, 2.02878881e-02f, 1.01223312e-01f, 8.48824382e-02f, 8.31835419e-02f, -9.98039842e-02f, -2.94563677e-02f,
  -3.64994369e-02f, 1.14431001e-01f, 1.36148548e-02f, 8.57162476e-02f, 1.98143035e-01f, -1.13090724e-01f, -1.13612972e-01f, -1.82290256e-01f, 7.88567141e-02f, 2.04588875e-01f,
  6.75723702e-02f, 6.53559193e-02f, -2.00353906e-01f, 1.13278903e-01f, -1.29439741e-01f, -9.37754735e-02f, 1.76262364e-01f, 1.50598213e-01f, -8.50400850e-02f, 4.65601422e-02f,
  4.80607413e-02f, -2.67277043e-02f, 1.38045698e-01f, 8.15083832e-03f, 3.74456756e-02f, 3.58770937e-02f, -1.52474970e-01f, -8.99719745e-02f, 1.72957666e-02f, -1.63566336e-01f,
  -1.56983271e-01f, 9.06924605e-02f, 1.14873387e-01f, 2.23083809e-01f, 1.45376340e-01f, -2.43967753e-02f, 3.62155139e-02f, -6.76841661e-02f, 5.71634471e-02f, -8.23133811e-02f,
  -9.24064592e-02f, -1.03684232e-01f, -1.02403171e-01f, -7.62627125e-02f, 2.18808353e-01f, 1.68696269e-01f, 3.69961187e-02f, -1.08115919e-01f, 2.67044008e-01f, 1.26807079e-01f,
  -1.31611481e-01f, -3.44280340e-02f, -8.90129507e-02f, -9.07384679e-02f, 6.32746965e-02f, 4.97822054e-02f, 1.23647138e-01f, -4.64373082e-02f, 1.69983685e-01f, 9.36409235e-02f,
  -3.46348770e-02f, 5.77628650e-02f, 1.98483378e-01f, -1.36821359e-01f, 1.83046550e-01f, -4.37208451e-02f, 2.25618258e-02f, 8.42233077e-02f, 3.53735536e-02f, 8.11635405e-02f,
  7.31463805e-02f, -2.91027781e-02f, -5.71790449e-02f, 2.00838849e-01f, 1.86115816e-01f, 1.18582234e-01f, 1.19304501e-01f, 1.17332965e-01f, 1.39946878e-01f, -2.15411514e-01f,
  5.25314733e-02f, 1.28256485e-01f, -8.29984993e-02f, -1.54901877e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.01715425e-01f, 8.33339542e-02f, 1.41301945e-01f, 3.05625834e-02f, 1.55033678e-01f, 1.59911141e-01f, -6.12033196e-02f, 2.16010138e-01f, -1.28395349e-01f, 1.32926777e-01f,
  -8.62481371e-02f, -6.18405305e-02f, -1.33574419e-02f, 6.96769543e-03f, -8.62330422e-02f, -1.59768835e-02f, -5.27295517e-03f, 2.22398460e-01f, -1.14863232e-01f, 1.52461126e-01f,
  -1.15906604e-01f, 1.26667038e-01f, 1.19604610e-01f, -1.79213155e-02f, -7.92795420e-02f, -3.15688290e-02f, 1.14951409e-01f, 5.01618013e-02f, 1.06626399e-01f, 5.28652258e-02f,
  -9.24735051e-03f, 6.03015721e-03f, 2.35944152e-01f, -2.43792031e-02f, 2.92505939e-02f, 1.60621535e-02f, -6.74711093e-02f, 2.50674058e-02f, -1.34003386e-01f, 7.28839561e-02f,
  4.86646686e-03f, -1.91020779e-02f, 9.63639170e-02f, -2.00972594e-02f, -2.49013677e-01f, 1.10245451e-01f, -5.94355352e-03f, 1.13340639e-01f, 1.41519770e-01f, 6.87075481e-02f,
  3.34413908e-02f, -1.70171827e-01f, 1.54355377e-01f, -7.97825381e-02f, 4.30689938e-02f, -2.53796689e-02f, -9.40409675e-03f, -2.26076003e-02f, -1.58665121e-01f, -1.67649597e-01f,
  -7.38625526e-02f, 7.08910823e-02f, -6.97168857e-02f, 1.17064670e-01f, 9.34133977e-02f, 1.01811126e-01f, 3.66897471e-02f, 9.59490053e-03f, -2.78607421e-02f, -2.78197788e-02f,
  -1.18660936e-02f, 1.53757274e-01f, -1.04543261e-01f, 1.58426315e-01f, -6.16618767e-02f, -2.17328325e-01f, -2.38769591e-01f, -6.30238056e-02f, 1.90786108e-01f, 4.59809862e-02f,
  1.45886049e-01f, 3.04895490e-01f, -1.52757049e-01f, 2.79250622e-01f, -5.68222888e-02f, 1.55236617e-01f, 3.42785269e-02f, 2.17757691e-02f, -2.65709162e-02f, 1.85990892e-02f,
  1.12323850e-01f, 1.72121320e-02f, -2.49197930e-02f, -1.10053703e-01f, -4.37592864e-02f, -1.24154791e-01f, 7.62700066e-02f, -2.62374878e-01f, 6.67081624e-02f, 7.31500909e-02f,
  -6.65093511e-02f, 1.55790299e-01f, -5.81352711e-02f, 1.68132320e-01f, 2.20794261e-01f, 1.71127409e-01f, -1.60296082e-01f, 1.19706944e-01f, -9.73934382e-02f, 6.52996674e-02f,
  8.66053477e-02f, 2.18653202e-01f, 2.31172845e-01f, -1.05428100e-01f, 9.03659165e-02f, -7.54214078e-02f, 4.36651744e-02f, 8.54861513e-02f, 1.99137837e-01f, 9.43501815e-02f,
  -2.36264929e-01f, 7.44655952e-02f, -1.05608322e-01f, -1.47856370e-01f, 1.25705704e-01f, 1.42997921e-01f, 4.27878089e-02f, 2.63255775e-01f, 1.23202875e-01f, 8.03571343e-02f,
  4.92611900e-02f, 2.56094988e-02f, 5.15019745e-02f, 1.27820885e-02f, 1.02244034e-01f, -3.74433398e-02f, 7.34588355e-02f, 1.71119049e-01f, 1.44258767e-01f, -1.61650762e-01f,
  -4.92871739e-02f, -1.11057185e-01f, -5.18552251e-02f, 7.69525096e-02f, -1.31655578e-02f, -6.03952110e-02f, -8.76966044e-02f, 2.00091720e-01f, 6.33182004e-02f, 9.66517255e-02f,
  7.58315623e-02f, 1.19120859e-01f, -3.60411555e-02f, -1.38662860e-01f, -8.96892324e-03f, 1.97484061e-01f, -1.95416957e-01f, -1.97803646e-01f, 1.16962127e-01f, 4.85203750e-02f,
  8.22705775e-02f, -6.84379339e-02f, 1.23023158e-02f, -1.08673356e-01f, -7.25733116e-02f, 5.04164957e-02f, -1.46323472e-01f, 2.30119340e-02f, 1.41045905e-03f, -1.10962674e-01f,
  -1.27928227e-01f, 1.21846303e-01f, -2.97117978e-01f, 5.52986376e-02f, 3.53352949e-02f, 7.34046027e-02f, -3.32873315e-02f, -1.11089190e-02f, -1.12289079e-01f, 2.32378561e-02f,
  1.74756779e-03f, -1.84856668e-01f, 9.09885019e-02f, 1.88508406e-02f, -1.67123422e-01f, -1.10500410e-01f, -7.01616518e-03f, 4.66694050e-02f, -1.76581070e-01f, -1.99546088e-02f,
  8.46186057e-02f, 2.07776070e-01f, -2.97198948e-02f, 4.70667407e-02f, -6.78725690e-02f, 4.72830050e-02f, 7.02677369e-02f, -4.92049009e-02f, -4.49829623e-02f, -8.92568976e-02f,
  -2.09244080e-02f, 4.36661877e-02f, -9.42467153e-02f, 1.60109237e-01f, 1.83568850e-01f, -1.27709031e-01f, 1.66572541e-01f, -2.38106325e-01f, -1.61210988e-02f, -1.64436653e-01f,
  -1.43605664e-01f, 8.53802487e-02f, 2.00744003e-01f, 8.18253756e-02f, 5.61273098e-02f, -9.78512224e-03f, -9.13354680e-02f, 8.83818120e-02f, -8.22440442e-03f, -5.13649210e-02f,
  1.07218221e-01f, -4.37793694e-02f, 1.15900613e-01f, 1.02761082e-01f, -7.29021579e-02f, 9.68977287e-02f, 4.16337550e-02f, 6.96786046e-02f, 1.49317220e-01f, 6.18330985e-02f,
  2.25865424e-01f, 6.10075949e-04f, -1.07937343e-01f, -1.33749589e-01f, 5.80022521e-02f, -3.28112170e-02f, 7.74104223e-02f, -3.51084918e-02f, 1.31657630e-01f, -1.08347103e-01f,
  2.12787554e-01f, 1.80663407e-01f, 1.17843058e-02f, 5.49125522e-02f, -9.21734571e-02f, 1.12999402e-01f, -2.71691084e-02f, 2.62952715e-01f, 2.07481503e-01f, 1.19619239e-02f,
  1.37300789e-01f, -1.35620004e-02f, -1.01754688e-01f, -1.28145337e-01f, -1.54279564e-02f, -1.27706885e-01f, 5.76152653e-02f, 1.27599776e-01f, 4.26372215e-02f, 1.00757100e-01f,
  1.60282329e-01f, 1.40164807e-01f, 1.11358829e-01f, 4.94791083e-02f, 1.47455081e-01f, 2.04950366e-02f, -1.52478933e-01f, 8.51725265e-02f, -2.33224601e-01f, 2.44193897e-01f,
  1.63729712e-01f, 1.80546626e-01f, 1.20186567e-01f, 1.48588225e-01f, 2.01033652e-01f, -1.30611911e-01f, 1.71236888e-01f, -2.56645471e-01f, -6.40697256e-02f, 1.58712089e-01f,
  2.50586599e-01f, -3.79729900e-03f, -1.12154938e-01f, -9.69593413e-03f, 3.83981913e-02f, 2.18515977e-01f, -1.30847067e-01f, -1.05522521e-01f, -7.40938857e-02f, -3.59799922e-01f,
  7.09668398e-02f, 1.65434897e-01f, 3.09512690e-02f, -1.40422389e-01f, 1.07975960e-01f, -8.30041245e-02f, 2.12455347e-01f, 2.37526119e-01f, -5.57862446e-02f, -2.05343924e-02f,
  1.48834080e-01f, -1.43666649e-02f, -1.04879141e-01f, 5.79710454e-02f, 1.76090971e-01f, -1.31729335e-01f, 9.94758774e-03f, 1.40780076e-01f, 8.92955214e-02f, 1.64620638e-01f,
  6.88542873e-02f, -1.32813528e-01f, 1.34553477e-01f, -1.17060222e-01f, -1.68715358e-01f, -1.85956642e-01f, 1.59485370e-01f, 2.41693377e-01f, 3.70603465e-02f, 3.98783796e-02f,
  1.08706035e-01f, 1.83409423e-01f, 7.32998699e-02f, 1.42431691e-01f, 1.79444611e-01f, 1.15410499e-01f, -9.02644619e-02f, -1.95902064e-02f, 4.07680906e-02f, -7.41646215e-02f,
  -1.39977798e-01f, 7.74555057e-02f, -1.63378362e-02f, 8.90651122e-02f, -1.01770841e-01f, 1.82296768e-01f, 1.53226042e-02f, 4.44185361e-03f, 1.02502622e-01f, -1.20230608e-01f,
  -1.31141245e-01f, -1.48442253e-01f, -1.45340979e-01f, 1.71559602e-01f, 5.34636416e-02f, 8.34586546e-02f, -1.22122161e-01f, 1.13919713e-01f, 7.41085634e-02f, 2.43353873e-01f,
  -4.54760641e-02f, -8.18062797e-02f, -1.46693559e-02f, -2.56743375e-02f, 4.55547199e-02f, -7.59588256e-02f, 5.21113649e-02f, -1.55768827e-01f, -2.50957850e-02f, -4.17185295e-03f,
  3.48494612e-02f, 1.26065612e-01f, 2.05788627e-01f, -1.16788018e-02f, 3.21922064e-01f, 2.53981203e-02f, -7.97415376e-02f, -7.08827078e-02f, -5.70647307e-02f, -1.11375570e-01f,
  9.01363492e-02f, -4.48653288e-02f, 5.70684187e-02f, 3.93163748e-02f, -6.17682561e-02f, -7.78619722e-02f, 2.87800908e-01f, 3.41232829e-02f, -2.88544297e-02f, 8.21036100e-02f,
  -5.61065413e-02f, 8.97709280e-02f, 1.04635112e-01f, -4.82771397e-02f, 2.43558791e-02f, -1.69209912e-02f, -1.12110220e-01f, 1.63109396e-02f, -1.77151728e-02f, -1.80983499e-01f,
  2.55649954e-01f, -1.51084751e-01f, 4.54811528e-02f, 2.73184199e-03f, -1.04336347e-02f, 2.56592065e-01f, 1.41902044e-01f, 2.06261337e-01f, -1.01716697e-01f, -1.90947447e-02f,
  5.31475386e-03f, 3.24820727e-02f, 1.44532025e-01f, -3.63562144e-02f, 1.56124860e-01f, 1.06037959e-01f, -2.92252675e-02f, -1.61435068e-01f, 5.11481427e-02f, -6.64463593e-03f,
  2.24040166e-01f, -8.49938095e-02f, 2.09468693e-01f, 1.57469869e-01f, -1.94725394e-02f, 1.16697222e-01f, -4.71397825e-02f, -1.62736431e-01f, 1.23976059e-01f, 1.06547661e-01f,
  7.60524198e-02f, -8.27996731e-02f, 2.34241113e-01f, 1.28222853e-01f, 1.01271428e-01f, -6.43423647e-02f, 1.40994210e-02f, -3.16450931e-02f, 3.43224816e-02f, 8.69969651e-02f,
  1.24795184e-01f, 8.69562179e-02f, -3.32068443e-01f, 2.63240755e-01f, 7.86917731e-02f, 1.15270659e-01f, 1.15909509e-01f, 2.44464667e-04f, 8.82842541e-02f, -1.12052828e-01f,
  -1.48906056e-02f, 2.22525839e-02f, 2.87754964e-02f, -2.47317880e-01f, 2.71551669e-01f, 2.39999995e-01f, -1.48134887e-01f, -2.01758176e-01f, 1.11466080e-01f, -1.93477143e-02f,
  7.73886293e-02f, 7.70686492e-02f, 8.48880336e-02f, 3.14353891e-02f, 1.88064396e-01f, -1.19522378e-01f, 1.72814336e-02f, 1.86546534e-01f, 9.29616317e-02f, 5.53572923e-02f,
  1.47444466e-02f, -1.88323893e-02f, -6.33398294e-02f, 8.28809738e-02f, -3.77948508e-02f, -1.08924873e-01f, 1.61655936e-02f, -1.22342907e-01f, 1.70674101e-02f, 1.83486808e-02f,
  -1.24142356e-01f, -1.07360473e-02f, 6.74734870e-03f, -1.32600695e-01f, -1.21361829e-01f, 3.87591943e-02f, -2.39334023e-03f, -1.33756131e-01f, 2.43059888e-01f, 1.57797217e-01f,
  -9.38832611e-02f, -1.13511840e-02f, -5.55785955e-05f, -9.39462036e-02f, 4.87515107e-02f, -1.59216896e-01f, 9.92780030e-02f, 2.16881298e-02f, -1.08948216e-01f, -1.12033993e-01f,
  -4.69858944e-02f, 3.48890908e-02f, -5.24558835e-02f, -7.46437684e-02f, 1.19911209e-01f, -8.05734172e-02f, -1.06971443e-01f, 1.88102484e-01f, -3.07645574e-02f, 1.32986769e-01f,
  -1.10994145e-01f, -3.51453424e-02f, 1.56760156e-01f, -1.65878907e-01f, -9.33478549e-02f, -1.64208382e-01f, -4.40967679e-02f, -6.97632432e-02f, -3.35085876e-02f, -4.77678031e-02f,
  -9.01824050e-03f, 4.75782380e-02f, 2.04525590e-01f, 1.78097010e-01f, 6.08589798e-02f, 1.17608123e-01f, 1.08931698e-01f, 1.66595444e-01f, 1.37870178e-01f, -1.32986709e-01f,
  6.78024143e-02f, 1.51920216e-02f, 5.55231515e-03f, 8.66848379e-02f, 8.67007487e-03f, 2.25422263e-01f, -1.17229208e-01f, 2.92197168e-01f, 8.07852000e-02f, -1.45288795e-01f,
  2.76980847e-01f, -8.91230032e-02f, -9.39738899e-02f, -9.66155380e-02f, -9.69947129e-02f, 2.17791662e-01f, 1.09146826e-01f, 2.58795023e-02f, -4.65122471e-03f, 1.20047800e-01f,
  4.21009548e-02f, 2.44730309e-01f, -9.54368059e-03f, 4.82010432e-02f, -1.58465788e-01f, -3.03484172e-01f, 1.06305771e-01f, -1.62297785e-01f, 1.25058040e-01f, -1.66052908e-01f,
  5.96785210e-02f, -7.69593846e-03f, -3.15339975e-02f, -1.41358571e-02f, -7.23952949e-02f, -2.41821036e-02f, 3.79571021e-01f, -2.88457666e-02f, 4.16728407e-02f, -7.16667920e-02f,
  -1.79772377e-01f, -4.79448624e-02f, -6.01208545e-02f, 1.48294434e-01f, 4.51449789e-02f, -6.48547113e-02f, 4.11453024e-02f, -2.61486560e-01f, 2.54131734e-01f, -9.77665335e-02f,
  -8.07575658e-02f, -7.93144107e-02f, 6.59057871e-02f, 1.07743517e-01f, 1.27036020e-01f, -4.48249839e-02f, -1.70943085e-02f, -3.78555879e-02f, 4.68318276e-02f, 9.70990285e-02f,
  -3.58145759e-02f, 9.08559375e-03f, 4.14492264e-02f, 1.00520059e-01f, 1.87081099e-02f, 3.57689522e-02f, 1.20982856e-01f, -1.25276163e-01f, -1.85900301e-01f, -5.21020256e-02f,
  -1.53095201e-01f, -5.57593741e-02f, -1.37208641e-01f, 1.81692466e-01f, -3.26959528e-02f, 2.40482658e-01f, -6.74790889e-02f, 1.30248845e-01f, 5.15131392e-02f, -5.19540831e-02f,
  -1.28903776e-01f, 6.34952262e-02f, 2.06035942e-01f, 7.58869797e-02f, -7.14090690e-02f, -1.87924102e-01f, -1.13474347e-01f, -6.80975765e-02f, 2.43742317e-01f, 5.13832495e-02f,
  -6.08636811e-02f, 7.31078535e-02f, -1.41168162e-02f, 1.89198300e-01f, -1.23291425e-01f, 9.80483964e-02f, 1.04943871e-01f, -1.17836744e-01f, -2.05015927e-03f, 1.04494661e-01f,
  -1.09288253e-01f, 1.41993746e-01f, -1.16093233e-01f, 4.21017706e-02f, 4.35981080e-02f, 1.41579479e-01f, 6.48513287e-02f, -7.81125873e-02f, 2.05106884e-01f, -1.12665839e-01f,
  3.23566794e-02f, 9.51561332e-02f, -1.22528799e-01f, 6.36425018e-02f, -1.45159557e-01f, -5.21811917e-02f, 6.16372079e-02f, -4.40485217e-02f, 4.31259722e-02f, 1.29081532e-01f,
  -5.65916337e-02f, -5.92518561e-02f, -1.54476345e-01f, -4.65486199e-02f, -4.52151000e-02f, -1.19123287e-01f, -7.44056180e-02f, -1.15845434e-01f, -5.08985221e-02f, -4.42570150e-02f,
  -8.59600902e-02f, -4.03212197e-02f, -5.26183173e-02f, 2.01009348e-01f, 2.26277873e-01f, 2.64978856e-02f, 9.55512971e-02f, -1.27629817e-01f, 1.19452011e-02f, -1.90900713e-02f,
  1.71995759e-01f, 8.26848224e-02f, 2.83193421e-02f, -4.81625721e-02f, -8.99752788e-03f, 9.65237692e-02f, 1.54028222e-01f, -2.36298181e-02f, -5.04162489e-03f, -6.53398037e-03f,
  9.56430193e-03f, 1.21957380e-02f, -1.03448279e-01f, 1.72636434e-02f, -1.34960786e-01f, 1.43136531e-01f, -7.76037499e-02f, 1.56084031e-01f, 1.26205698e-01f, 5.25175687e-03f,
  1.55052453e-01f, -1.68771222e-02f, 1.10713523e-02f, -1.59592147e-03f, -4.51367684e-02f, 4.29163873e-02f, -2.59823203e-02f, 8.15457404e-02f, -3.66250277e-02f, 1.24266803e-01f,
  1.33104548e-01f, -2.56487001e-02f, 6.87261373e-02f, 1.07186690e-01f, -1.23530813e-02f, -4.22939658e-03f, 8.45675692e-02f, -5.99805918e-03f, 2.91977916e-02f, -1.50980145e-01f,
  1.56841978e-01f, 1.91979200e-01f, -6.03178293e-02f, -1.82772636e-01f, 7.55370557e-02f, 4.07802723e-02f, 1.76551882e-02f, 1.92231461e-02f, -2.05575153e-02f, -3.09490040e-02f,
  -1.88966505e-02f, -1.49829805e-01f, 6.58243969e-02f, 5.26127815e-02f, 7.98240080e-02f, 2.30745226e-03f, 3.51163447e-02f, -6.65353835e-02f, -1.49541065e-01f, 3.31385173e-02f,
  -6.38182834e-02f, -7.94713199e-02f, 4.95955497e-02f, -3.52291577e-03f, 5.61192892e-02f, 3.98367718e-02f, 4.81774751e-03f, 4.45196331e-02f, -5.46597093e-02f, -9.00920033e-02f,
  -2.49550138e-02f, -4.87767719e-02f, -3.13812532e-02f, -1.04104273e-01f, 7.14158490e-02f, 8.48217383e-02f, -7.67749846e-02f, -1.81906801e-02f, 3.52096744e-02f, -7.36173987e-02f,
  -4.41269726e-02f, 5.51948994e-02f, -8.14902633e-02f, -3.34362872e-03f, -7.46598616e-02f, -1.29993662e-01f, -1.04361714e-03f, 2.99688578e-02f, 1.76766387e-03f, -4.15561832e-02f,
  2.27646176e-02f, -3.21312845e-02f, -7.88989197e-03f, 1.32764375e-03f, -2.44721826e-02f, -3.43095548e-02f, 3.86816449e-02f, -3.61551493e-02f, -1.49464235e-02f, 1.88152418e-02f,
  -5.05995117e-02f, -4.38179448e-02f, 1.00229621e-01f, 7.65085444e-02f, -1.42403245e-01f, 9.37462039e-03f, 3.56509499e-02f, -1.13498410e-02f, 9.52509418e-02f, 2.35816315e-01f,
  1.95426598e-01f, 2.11698830e-01f, 2.45021619e-02f, 2.24439859e-01f, 1.65644646e-01f, 9.73803252e-02f, -1.86395109e-01f, 1.06741488e-01f, -1.02382571e-01f, 1.23891860e-01f,
  1.87157080e-01f, -1.21195599e-01f, -1.27565891e-01f, -1.36352211e-01f, -1.70647159e-01f, -5.09447418e-02f, -1.12313181e-01f, 6.36533648e-02f, 2.39460357e-02f, 8.98133814e-02f,
  2.26352923e-02f, 1.85768291e-01f, -2.30856329e-01f, -9.13827855e-04f, -1.03842705e-01f, 2.30820596e-01f, -3.40769626e-02f, 2.21620873e-01f, 7.97201023e-02f, 1.10992059e-01f,
  2.64583439e-01f, 2.08161056e-01f, -1.44544989e-01f, -4.03334051e-02f, -1.16271853e-01f, 1.01114027e-02f, -1.30400151e-01f, -2.96706650e-02f, 1.62199527e-01f, 1.57653615e-01f,
  6.18083216e-02f, 1.66225120e-01f, 2.30138320e-02f, 1.25821054e-01f, -6.92349151e-02f, 3.41457427e-02f, -6.23428188e-02f, 1.78053409e-01f, 1.08380377e-01f, 2.76778545e-02f,
  1.07851774e-01f, -1.13050796e-01f, -2.58614719e-01f, -1.36515766e-01f, 2.43272886e-01f, 2.86943112e-02f, -2.27335822e-02f, 2.45055586e-01f, -7.66354874e-02f, -1.26689494e-01f,
  1.44069210e-01f, -2.44916063e-02f, 1.50261074e-01f, 8.32013637e-02f, 6.36550114e-02f, 1.51018232e-01f, 9.20992903e-03f, 6.85183257e-02f, -5.98915443e-02f, 8.11090991e-02f,
  -1.34555280e-01f, -6.73903301e-02f, 7.28953034e-02f, -4.94555533e-02f, 2.31070504e-01f, -7.35101625e-02f, -1.80099368e-01f, -1.62466496e-01f, -1.05698705e-01f, -3.90015617e-02f,
  4.67586471e-03f, 8.28923360e-02f, -1.66899455e-03f, 1.62121177e-01f, 8.50575566e-02f, 7.22859204e-02f, -1.17725052e-01f, 2.08198950e-02f, 5.31105474e-02f, 7.01870918e-02f,
  -7.68167675e-02f, -6.80154115e-02f, 8.45729634e-02f, 1.50368690e-01f, 2.60047197e-01f, 2.65840679e-01f, -3.13440710e-02f, 6.15279973e-02f, -5.85117489e-02f, 1.30654678e-01f,
  -1.17080770e-01f, 6.65094927e-02f, 6.48790598e-02f, -3.41086537e-02f, 1.99810416e-01f, 7.96530992e-02f, -1.05187751e-01f, 1.81763083e-01f, -1.31869346e-01f, -5.29918075e-03f,
  -1.46603037e-03f, 2.14989170e-01f, 3.36134396e-02f, 7.71061257e-02f, 1.06522962e-01f, -3.25457379e-02f, -9.85364392e-02f, -6.84916682e-04f, 1.52797818e-01f, 8.47431049e-02f,
  7.40258843e-02f, 2.23126680e-01f, -1.16526969e-01f, -1.41536832e-01f, -1.99353527e-02f, -5.86795295e-03f, 1.07807912e-01f, 1.74737841e-01f, 2.05567107e-01f, 2.11975113e-01f,
  6.60979226e-02f, 1.44651905e-01f, 5.80632128e-02f, 1.82960883e-01f, -1.11022122e-01f, -3.77214118e-03f, -1.60222232e-01f, -4.91328053e-02f, -2.31327385e-01f, -2.18988676e-02f,
  3.53527606e-01f, 1.66271701e-01f, 1.75943762e-01f, 1.72881007e-01f, -9.13848877e-02f, 1.83381915e-01f, 1.95472389e-01f, -1.77837759e-02f, -4.72500809e-02f, 9.11292881e-02f,
  2.73068268e-02f, -1.40032694e-01f, -2.46463567e-01f, 3.35170031e-02f, -8.47764313e-02f, 2.54347533e-01f, 8.15040469e-02f, -2.38511916e-02f, 3.16532925e-02f, -2.84000158e-01f,
  1.36077985e-01f, 2.51449287e-01f, -6.04803823e-02f, -1.49650350e-01f, 2.27324963e-02f, 5.02452031e-02f, -1.80015527e-02f, 3.03452939e-01f, -1.25433028e-01f, 1.90343738e-01f,
  -8.72912258e-03f, 4.94384300e-03f, 1.66150909e-02f, 9.38139707e-02f, 3.57589632e-01f, -2.15135261e-01f, -8.35120529e-02f, 1.19199932e-01f, 9.38557610e-02f, 1.58855498e-01f,
  7.48049617e-02f, -4.79822941e-02f, 8.89796913e-02f, -9.83837470e-02f, -8.08882788e-02f, -1.24894470e-01f, -1.83399186e-01f, 3.63198668e-02f, 1.24256559e-01f, 2.33682051e-01f,
  1.56770959e-01f, 2.90018599e-03f, 1.75682202e-01f, -1.86484698e-02f, -5.74478768e-02f, -4.94533218e-03f, 5.63013218e-02f, -1.41817078e-01f, 4.27404381e-02f, 3.61433960e-02f,
  7.36549422e-02f, -4.89414781e-02f, 1.61523178e-01f, 8.18648562e-02f, -8.26807171e-02f, 1.41701913e-02f, 1.13569967e-01f, -9.82666910e-02f, 4.22304012e-02f, 3.74102928e-02f,
  1.33788376e-03f, 1.10879242e-01f, 1.95893183e-01f, -1.28718782e-02f, 7.67068863e-02f, 2.70314291e-02f, 1.73785850e-01f, 3.56440619e-02f, -1.01666525e-01f, -1.82561785e-01f,
  7.46124834e-02f, 6.52101189e-02f, -9.69775617e-02f, 1.28039494e-01f, 1.02623276e-01f, -1.25331655e-01f, -1.09666474e-02f, 2.14096755e-01f, -1.20680593e-01f, 9.54588279e-02f,
  -1.14091985e-01f, -1.93720192e-01f, 1.08123653e-01f, 4.25538048e-02f, 3.47789787e-02f, -4.32795621e-02f, 1.46089226e-01f, -3.37555781e-02f, -1.04292579e-01f, -8.69472045e-03f,
  8.28797445e-02f, -7.09993094e-02f, 1.04300745e-01f, -1.59260724e-02f, 4.77810018e-02f, 1.13505926e-02f, 3.30839083e-02f, 4.70571965e-02f, 1.30055636e-01f, 2.15482920e-01f,
  -1.50420293e-01f, -3.45343985e-02f, -6.58078343e-02f, -2.38381652e-03f, 7.29067624e-02f, -1.45406276e-02f, 7.10558146e-02f, 1.16054140e-01f, 1.17101721e-01f, -6.84712548e-03f,
  5.08538745e-02f, 1.09616317e-01f, -7.70207047e-02f, 1.30325228e-01f, -4.93824705e-02f, -2.00141426e-02f, -1.71104744e-01f, -1.15389870e-02f, -1.56752989e-01f, -5.38455136e-02f,
  -1.22167856e-01f, 1.02758586e-01f, -1.18854657e-01f, 2.54283279e-01f, -1.25584975e-02f, 1.54696479e-01f, 2.70362832e-02f, 2.52073482e-02f, -1.00647338e-01f, -1.72398482e-02f,
  8.00678786e-03f, 8.14786330e-02f, -1.57800198e-01f, 1.30073950e-01f, -1.59109116e-01f, -1.38711199e-01f, 1.22086525e-01f, -1.86684772e-01f, -4.70941514e-02f, 1.74259674e-02f,
  -3.28733437e-02f, 8.85264501e-02f, -1.40796259e-01f, 1.52423620e-01f, 6.55081943e-02f, 9.46527198e-02f, -1.03647925e-01f, 1.72243744e-01f, -1.00365601e-01f, 7.03085065e-02f,
  -7.02282414e-02f, 1.09713048e-01f, 5.82387894e-02f, -4.45904247e-02f, 2.77671572e-02f, -2.94290241e-02f, 1.19936109e-01f, -5.13128713e-02f, 5.15394136e-02f, 3.46826091e-02f,
  -5.63918129e-02f, 1.10443532e-02f, -8.81435797e-02f, -8.08066875e-03f, -7.47930408e-02f, 2.08098758e-02f, 4.84627113e-02f, 8.26660022e-02f, 1.40050754e-01f, 1.53518647e-01f,
  6.75057545e-02f, 7.02365786e-02f, 1.48215294e-01f, -8.27546567e-02f, 1.21536382e-01f, -6.97073042e-02f, 1.29292443e-01f, 9.79589820e-02f, 2.87882350e-02f, 1.07319511e-01f,
  1.50577381e-01f, 1.35371923e-01f, -1.22887470e-01f, 4.74785380e-02f, 6.47979826e-02f, -9.21997949e-02f, 1.90638140e-01f, -7.81116635e-02f, -7.71322101e-02f, 3.04899532e-02f,
  3.67358997e-02f, -8.71820077e-02f, 1.82731301e-01f, -3.42074968e-02f, 5.72567955e-02f, -9.41838250e-02f, 8.50157291e-02f, -1.29502028e-01f, 9.69503261e-03f, 1.43896759e-01f,
  -9.72146243e-02f, -1.72759742e-01f, 6.74970970e-02f, -9.38423946e-02f, 1.91703871e-01f, 5.12723811e-02f, 9.67504736e-03f, 8.49504694e-02f, -4.80422750e-02f, -1.69701487e-01f,
  -1.18195303e-02f, -6.18620450e-03f, 1.39350757e-01f, -3.35510448e-02f, 1.37581438e-01f, 4.71936725e-03f, -1.76193938e-01f, 1.80053011e-01f, 4.61412454e-03f, 1.41638845e-01f,
  -2.59707915e-04f, -9.21599120e-02f, 2.04300940e-01f, -1.70300826e-01f, -1.62917733e-01f, -1.43051311e-01f, -4.15047742e-02f, -2.75947541e-01f, 8.01525936e-02f, 1.24849550e-01f,
  -1.56681776e-01f, -2.07949318e-02f, 7.15096220e-02f, 1.09569177e-01f, 6.09072968e-02f, 4.43619154e-02f, 2.11544964e-03f, 5.12355007e-02f, -1.16018102e-01f, -7.80732557e-03f,
  1.35968938e-01f, 6.20097062e-03f, 2.63878200e-02f, -5.86965680e-02f, -6.39971271e-02f, -7.09717220e-04f, -6.20234311e-02f, 1.96592048e-01f, 1.56640392e-02f, -2.95214616e-02f,
  8.70914459e-02f, -1.15678065e-01f, -8.44170749e-02f, -6.93613291e-02f, 6.85230792e-02f, -4.84276712e-02f, 8.82223919e-02f, 4.59648408e-02f, 5.08086616e-03f, -1.75198968e-02f,
  -5.95169608e-03f, -8.64238292e-02f, -1.10528991e-02f, -1.28895165e-02f, -1.06830053e-01f, -7.61711299e-02f, 2.63225194e-02f, -1.58152416e-01f, 4.26540524e-03f, -4.43967730e-02f,
  -2.56866100e-03f, -3.72510217e-02f, -4.70649973e-02f, -4.06794399e-02f, -4.39937674e-02f, -8.40631947e-02f, 2.09188849e-01f, -4.04305570e-02f, 3.40263546e-02f, -4.31751534e-02f,
  -6.01325780e-02f, -1.53418511e-01f, -3.68839949e-02f, 9.29240137e-03f, 7.30703538e-03f, -5.30866086e-02f, 4.17176448e-03f, -9.66791064e-02f, -6.66275173e-02f, -8.33732635e-02f,
  2.17118487e-02f, -6.15248494e-02f, -2.56159659e-02f, 5.28613813e-02f, -3.85666862e-02f, 5.25955558e-02f, 1.37508959e-01f, 1.61307696e-02f, 1.13066465e-01f, 1.80476248e-01f,
  2.70134006e-02f, 1.43573016e-01f, 1.17527373e-01f, -1.81767747e-01f, 5.41430153e-02f, 1.54516965e-01f, 2.00982735e-01f, -1.62288219e-01f, -2.96421093e-03f, -1.13799952e-01f,
  -1.02939509e-01f, 1.69496998e-01f, 6.69995248e-02f, -6.95308223e-02f, 1.23829907e-03f, 7.89517015e-02f, -4.21762615e-02f, -5.32115484e-03f, 1.39553845e-01f, 9.66390744e-02f,
  4.61367443e-02f, -1.23902880e-01f, -6.67246729e-02f, 1.96813971e-01f, -2.06880629e-01f, -2.08267257e-01f, 2.58873522e-01f, 2.08418798e-02f, -3.24143842e-02f, -4.07160521e-02f,
  -1.01266578e-02f, -1.47366062e-01f, 1.01585165e-01f, -7.43507734e-03f, -1.69089362e-01f, 7.13522360e-02f, -5.81006408e-02f, -5.10403514e-02f, -1.73475727e-01f, 1.23290783e-02f,
  -1.12546772e-01f, -8.92358348e-02f, 1.38122782e-01f, -7.93939643e-03f, 5.35875931e-02f, -1.28053322e-01f, -1.30074054e-01f, 4.06728238e-02f, 1.22325812e-02f, -1.13830626e-01f,
  7.32478201e-02f, -4.80305078e-03f, -1.37451395e-01f, -8.56492668e-02f, 7.54413679e-02f, 1.56116873e-01f, -3.49435024e-02f, -2.87486557e-02f, 1.37113869e-01f, 2.63712943e-01f,
  2.14305997e-01f, 1.13046981e-01f, 1.48001820e-01f, 1.68497786e-01f, 4.98536974e-02f, -4.04770952e-03f, 7.88623840e-02f, 2.04742268e-01f, -1.35641038e-01f, 1.10237218e-01f,
  -1.20016791e-01f, -8.65995884e-02f, -7.75188357e-02f, -8.26502405e-03f, -2.95340680e-02f, 1.35654509e-01f, -7.32605010e-02f, 2.47954249e-01f, 3.41026508e-03f, 6.59252927e-02f,
  -6.62588561e-03f, 4.10039797e-02f, 5.06214015e-02f, -6.64495975e-02f, 6.98048696e-02f, 1.08626194e-01f, 4.67307270e-02f, 8.61447398e-03f, 6.77606240e-02f, 9.09475610e-02f,
  -7.40237981e-02f, -4.59767804e-02f, 9.41786841e-02f, -1.73794031e-01f, -3.64979729e-02f, 6.23100176e-02f, -1.86494403e-02f, 1.02519944e-01f, -1.21806860e-01f, 1.40384212e-01f,
  1.23692743e-01f, 1.37432694e-01f, 8.60510096e-02f, 6.78647682e-02f, -2.10119680e-01f, 1.50031939e-01f, -4.08167690e-02f, 1.56307369e-01f, 1.02186233e-01f, -6.39922097e-02f,
  6.09528832e-02f, -4.22574393e-02f, 1.78974390e-01f, 8.19832180e-03f, 2.18625762e-03f, -8.72563347e-02f, -1.24987319e-01f, 5.90460598e-02f, -7.88542703e-02f, -4.07359526e-02f,
  3.22092921e-02f, 5.57954572e-02f, -4.47589122e-02f, 1.37239441e-01f, 8.02221969e-02f, 1.17418498e-01f, 9.71727669e-02f, 6.61930889e-02f, -3.24968211e-02f, 1.95739698e-02f,
  6.66804984e-02f, -2.26907387e-01f, 3.49419378e-02f, 3.09447423e-02f, 1.08490162e-01f, 9.77139268e-03f, 1.00793064e-01f, -6.40686974e-02f, -1.24785483e-01f, 1.67054445e-01f,
  -5.73196867e-03f, -5.74184991e-02f, 1.33389413e-01f, -2.08387598e-01f, 6.90852478e-02f, -2.65750531e-02f, 3.92739987e-03f, 5.99161386e-02f, 9.48330685e-02f, -7.24038333e-02f,
  -7.04514682e-02f, 3.00112963e-02f, -1.01872772e-01f, -4.22781743e-02f, 1.36382282e-01f, 8.76715779e-02f, -1.32711917e-01f, 1.73842877e-01f, -1.67585351e-02f, -2.38031238e-01f,
  -1.31719232e-01f, -1.54949769e-01f, -5.27785048e-02f, -9.77385491e-02f, -1.45767525e-01f, -1.54654995e-01f, -2.25380715e-02f, 7.20840413e-03f, 1.33462310e-01f, -1.58915371e-01f,
  4.75349501e-02f, -8.69141668e-02f, -8.37867036e-02f, -6.51716143e-02f, -8.97619966e-03f, 7.72974715e-02f, -5.31816296e-02f, -7.40526915e-02f, -9.78842601e-02f, 1.91543177e-02f,
  5.65173402e-02f, 1.75107867e-02f, 1.76467717e-01f, 2.44832605e-01f, -1.45249516e-01f, -9.23952907e-02f, 8.29519145e-03f, 1.13472290e-01f, 7.66967088e-02f, 1.05740197e-01f,
  -4.97141853e-02f, 7.87344053e-02f, 1.62340999e-02f, 2.74292603e-02f, 1.36464432e-01f, -6.11674562e-02f, 4.72615436e-02f, 1.07216023e-01f, 6.16428144e-02f, 5.19496948e-02f,
  7.71168992e-02f, -8.30680877e-02f, -7.75611624e-02f, 1.82515681e-01f, 4.01015431e-02f, -9.14779156e-02f, -1.10276313e-02f, -1.02421306e-02f, 1.16867267e-01f, -4.52517308e-02f,
  -1.05039142e-01f, 1.59994438e-02f, 1.86436865e-02f, -1.25584781e-01f, -1.57858238e-01f, 1.26299128e-01f, -8.33388194e-02f, -7.13417158e-02f, 2.01462165e-01f, 1.39376983e-01f,
  -7.50175351e-03f, 1.36209270e-02f, 6.90571815e-02f, -1.55665740e-01f, 4.27530496e-04f, -1.55702636e-01f, -5.48674800e-02f, -6.61615878e-02f, -1.49431169e-01f, -1.35988370e-01f,
  -6.26780018e-02f, 2.03130022e-02f, -1.44605845e-01f, -9.60041508e-02f, 1.43258005e-01f, -7.30035156e-02f, -8.08902085e-02f, 1.66580200e-01f, -4.22628671e-02f, 1.10051326e-01f,
  -1.06191270e-01f, -1.39384329e-01f, 1.78909376e-01f, -1.68665752e-01f, -6.71709031e-02f, -1.85375527e-01f, 1.39645129e-01f, 9.89961475e-02f, -8.14655349e-02f, -4.51963730e-02f,
  -1.92241073e-02f, 1.63538367e-01f, 3.70233804e-02f, 1.39960781e-01f, 1.62022784e-01f, 1.36146605e-01f, 8.81545171e-02f, 9.24986005e-02f, -4.60729003e-03f, 1.76407266e-02f,
  -2.75494494e-02f, 1.00842789e-01f, 4.62433547e-02f, -6.29501492e-02f, 7.39024803e-02f, -1.56253457e-01f, -1.99316531e-01f, -1.83950514e-02f, -1.26296565e-01f, -1.23612806e-01f,
  -3.34988162e-02f, 1.35650495e-02f, 4.08418290e-02f, 9.43218097e-02f, 6.34322092e-02f, 1.08211093e-01f, -8.04676339e-02f, 5.95197119e-02f, 2.13785190e-02f, 1.63413763e-01f,
  -1.42488047e-01f, -7.55870938e-02f, 1.93420779e-02f, 7.02119395e-02f, 2.04860896e-01f, 2.49939948e-01f, 5.43880537e-02f, -7.32319355e-02f, -4.24193479e-02f, 6.36204183e-02f,
  -1.06428631e-01f, -1.46935983e-02f, -4.77358922e-02f, -5.16745076e-02f, 1.08493790e-01f, 5.56446649e-02f, -1.13709472e-01f, 1.12596460e-01f, -1.06509933e-02f, -4.43397239e-02f,
  -6.87702596e-02f, 7.03419670e-02f, 1.50208220e-01f, 7.04309270e-02f, 7.35878274e-02f, -8.22507963e-02f, -7.86245316e-02f, 3.09948847e-02f, 1.45026073e-01f, 3.36494707e-02f,
  6.06121868e-02f, 1.99960291e-01f, -9.35918912e-02f, -8.02047923e-02f, 2.89098322e-02f, 1.43290043e-01f, 2.07816303e-01f, 2.11048961e-01f, 1.48336321e-01f, 1.30596802e-01f,
  5.37833385e-02f, 2.40132615e-01f, 9.32914838e-02f, 3.79739106e-02f, -1.35280058e-01f, 1.06171109e-01f, 1.14974724e-02f, 4.68348563e-02f, 1.27568007e-01f, -5.03680967e-02f,
  -9.24744383e-02f, -4.46949527e-02f, -1.59148127e-01f, 3.71501520e-02f, 1.13823516e-02f, -1.75650552e-01f, -8.27092007e-02f, -1.36538491e-01f, -1.30148865e-02f, 1.03971750e-01f,
  -1.69216275e-01f, 1.12367786e-01f, -2.46183142e-01f, 2.09971294e-01f, -2.99081560e-02f, 2.90435165e-01f, -3.40324230e-02f, 1.09641135e-01f, 1.71794578e-01f, 8.78359154e-02f,
  -7.87663758e-02f, 6.91682193e-03f, -5.09941839e-02f, -7.82563761e-02f, -1.22625262e-01f, -1.56923354e-01f, 1.33409366e-01f, 1.50089532e-01f, 9.39362049e-02f, 1.66726522e-02f,
  1.12593256e-01f, 3.02111004e-02f, -1.52595565e-01f, -1.59259737e-01f, -1.62934884e-01f, 1.16498865e-01f, 1.55247003e-01f, 3.07769757e-02f, 9.27073061e-02f, 1.97123569e-02f,
  -2.18960062e-01f, -1.54933155e-01f, 3.29096019e-01f, 5.42726927e-02f, 3.35856080e-02f, 2.42170826e-01f, -9.75319147e-02f, -1.42608404e-01f, 2.05644712e-01f, -4.05131355e-02f,
  1.46873847e-01f, 4.94055897e-02f, 1.31635964e-01f, -3.83785516e-02f, -4.32795510e-02f, -2.31795777e-02f, 2.90718861e-02f, -9.52272564e-02f, 1.25514999e-01f, -1.61965057e-01f,
  9.21033025e-02f, -2.33704969e-02f, 1.68259844e-01f, -1.71787757e-02f, -1.60912007e-01f, 1.25540689e-01f, 1.39854133e-01f, -1.17624044e-01f, 1.08757146e-01f, -1.42672077e-01f,
  -7.96256773e-03f, -6.22132346e-02f, -1.04756597e-02f, 3.73959914e-02f, 1.99749798e-01f, 7.28091272e-03f, 1.13243740e-02f, 4.87713553e-02f, 1.23741567e-01f, -7.07340762e-02f,
  1.28212497e-01f, 9.65171158e-02f, -2.12734729e-01f, 1.78821266e-01f, 1.57713667e-01f, -2.58694619e-01f, 1.29088372e-01f, -9.67158675e-02f, -4.45757248e-02f, -6.45985305e-02f,
  -2.20216632e-01f, -1.54953033e-01f, 9.45734531e-02f, -8.60294774e-02f, 1.15770571e-01f, -1.72850937e-01f, 1.53216600e-01f, -1.83669582e-01f, 9.20402035e-02f, -6.56154528e-02f,
  -1.12782262e-01f, -9.36543103e-04f, -1.52430281e-01f, -1.39995115e-02f, 5.34070991e-02f, 1.69787873e-02f, -7.90282413e-02f, 8.84585679e-02f, 2.12812230e-01f, 1.67034164e-01f,
  4.87912744e-02f, -1.65203303e-01f, -1.06323073e-02f, -3.38630565e-02f, -5.00046834e-02f, 5.36616938e-03f, -6.96062669e-02f, 5.72383255e-02f, 2.84242425e-02f, -1.21849149e-01f,
  1.67548582e-01f, -4.94574793e-02f, 1.81566190e-03f, 2.65819579e-01f, 1.36022165e-01f, 6.61995634e-02f, 4.98166010e-02f, -8.87150168e-02f, -3.44661474e-02f, -3.23437601e-02f,
  8.52838345e-03f, 1.41975760e-01f, -2.79642106e-03f, 2.89517909e-01f, 1.11385472e-01f, 2.23790765e-01f, 2.28950322e-01f, 5.85104041e-02f, -1.27032369e-01f, -1.20524190e-01f,
  1.81215614e-01f, 1.16349503e-01f, 3.19409668e-02f, -1.43275738e-01f, 1.17739268e-01f, 1.65683135e-01f, 5.53199016e-02f, -6.95899948e-02f, 6.71500713e-02f, 1.78546794e-02f,
  4.02395241e-02f, 1.30624622e-01f, -1.39379567e-02f, 8.69004503e-02f, 3.27342749e-02f, -1.22724541e-01f, -2.56448779e-02f, 4.88532931e-02f, -2.21586615e-01f, 4.13229950e-02f,
  1.03378743e-01f, 1.05484784e-01f, 6.04785532e-02f, 1.41426265e-01f, -4.17290293e-02f, 1.56003773e-01f, 4.08672467e-02f, -2.39701614e-01f, 2.70075291e-01f, 8.17753300e-02f,
  -2.12339699e-01f, -3.35221253e-02f, -3.53612676e-02f, -1.17749952e-01f, 5.95607124e-02f, -2.53205914e-02f, -1.80563740e-02f, 1.59109876e-01f, 1.65619403e-01f, 2.20983773e-01f,
  1.95494413e-01f, 2.13449419e-01f, 3.57467979e-02f, 8.87810960e-02f, 9.75663140e-02f, 2.23173529e-01f, -6.97202012e-02f, 2.72719413e-02f, -1.09706230e-01f, 7.19449148e-02f,
  1.58717901e-01f, -1.40111327e-01f, -1.19535841e-01f, -1.53989613e-01f, -2.17019692e-01f, 2.95849182e-02f, -1.66610274e-02f, 6.05322309e-02f, -4.27357405e-02f, 1.44463897e-01f,
  -4.11008783e-02f, 1.59253880e-01f, -8.64010453e-02f, 1.23114467e-01f, -7.19590560e-02f, 7.33765811e-02f, 3.93134579e-02f, 2.37565607e-01f, 7.58645013e-02f, 3.11202761e-02f,
  3.00151646e-01f, 1.68358937e-01f, -9.83392075e-02f, -8.53374042e-03f, -1.05938390e-01f, 2.61316337e-02f, -1.21697403e-01f, 7.36232623e-02f, 7.43476450e-02f, 3.97322997e-02f,
  1.90302983e-01f, 2.02458933e-01f, -7.69983232e-02f, 2.52801701e-02f, -1.44789293e-01f, 4.47351821e-02f, -7.43723065e-02f, 1.21514708e-01f, 1.65886641e-01f, 9.01976079e-02f,
  1.13385133e-01f, 3.03484406e-02f, -2.04143763e-01f, -5.39820753e-02f, 1.21899046e-01f, 6.14201687e-02f, -9.85547602e-02f, 2.17379089e-02f, -1.54116824e-01f, -4.61751595e-02f,
  1.41965687e-01f, 3.78648634e-03f, -4.98346724e-02f, 6.79531042e-03f, -1.53082134e-02f, 9.07866955e-02f, 1.59328222e-01f, 1.30977035e-01f, -8.95350873e-02f, -1.24711707e-01f,
  1.19371101e-01f, 1.29605373e-02f, -1.08849347e-01f, 1.22298814e-01f, -6.50094301e-02f, 2.48457119e-01f, 1.72411829e-01f, 1.03161216e-01f, 8.33634064e-02f, 2.35376526e-02f,
  8.50658417e-02f, -6.71204180e-02f, 1.83751732e-01f, -8.23699981e-02f, -7.70818517e-02f, 9.79105383e-02f, 3.00051328e-02f, 6.31620316e-03f, -6.44365251e-02f, 6.66227266e-02f,
  1.14990689e-01f, 1.28103465e-01f, -5.92726618e-02f, -3.30698863e-02f, -7.73901418e-02f, -5.63622862e-02f, -5.63319176e-02f, 1.55932382e-01f, 5.54722846e-02f, -1.12744302e-01f,
  2.32499376e-01f, -1.07957348e-01f, 1.33108497e-01f, 1.18701711e-01f, -1.82050876e-02f, -1.70745909e-01f, 1.94353625e-01f, -4.32072431e-02f, -1.41140431e-01f, -6.15251698e-02f,
  1.52596191e-01f, 5.72112538e-02f, -7.90804550e-02f, 5.21992259e-02f, -4.75165900e-03f, 6.02677129e-02f, -6.67487085e-02f, -7.08732903e-02f, 1.53705657e-01f, -1.31017253e-01f,
  -1.65984720e-01f, -1.20424345e-01f, 4.62908708e-02f, 4.39175814e-02f, 2.63428893e-02f, -1.26773477e-01f, 1.39067054e-01f, -2.71564610e-02f, 1.14431098e-01f, 3.15555409e-02f,
  -4.67964113e-02f, 3.31862755e-02f, 2.72848904e-02f, 1.38474882e-01f, -1.37110129e-01f, 1.02783494e-01f, 7.91589245e-02f, -1.78794399e-01f, -2.28004694e-01f, 7.44165778e-02f,
  9.40359682e-02f, 6.66657761e-02f, 9.04746801e-02f, 3.37139368e-02f, -9.50601399e-02f, 1.21444456e-01f, -1.16752669e-01f, 8.92093033e-02f, 6.60573915e-02f, -7.40134418e-02f,
  -2.27975622e-02f, -5.15873842e-02f, 1.62405044e-01f, -2.79867295e-02f, 5.40386513e-02f, -1.14119239e-01f, -8.87840241e-02f, -7.86084533e-02f, 5.80311343e-02f, -8.46973956e-02f,
  -6.54300004e-02f, 7.34332427e-02f, -2.01906245e-02f, 2.01458663e-01f, -8.26357454e-02f, 1.14026457e-01f, 1.34714216e-01f, -6.99869618e-02f, 1.08196519e-01f, -4.64426689e-02f,
  -9.45243537e-02f, 4.71455082e-02f, 4.89726365e-02f, 1.29628032e-01f, -1.33499773e-02f, 1.22691236e-01f, 1.32805690e-01f, -1.03687346e-01f, 8.76396000e-02f, -1.04307353e-01f,
  1.01157315e-01f, 1.18092664e-01f, -1.69157907e-01f, 2.60500461e-02f, -8.66035968e-02f, -2.09348351e-01f, -3.27761136e-02f, 9.24332961e-02f, -1.18771158e-01f, 1.10541902e-01f,
  2.79340148e-02f, 4.16352823e-02f, -1.80385206e-02f, 6.20850213e-02f, -1.93522349e-02f, -1.16108349e-02f, 2.45466724e-01f, -3.38644162e-02f, -6.57007843e-02f, 1.15163378e-01f,
  6.89537451e-02f, -4.06097881e-02f, 6.86106905e-02f, -5.96844330e-02f, -8.06262717e-02f, 6.52708784e-02f, 1.39274411e-02f, -1.85981214e-01f, -3.30272764e-02f, 5.50363623e-02f,
  7.17551634e-02f, 1.01106688e-01f, -3.54322530e-02f, 4.91241813e-02f, -1.18177995e-01f, -1.27755970e-01f, -1.19870432e-01f, 2.01627105e-01f, -1.30327523e-01f, 5.14353588e-02f,
  1.95221424e-01f, 7.40342364e-02f, 7.51284361e-02f, -7.57671148e-02f, 3.41857448e-02f, -9.69597995e-02f, 7.70757720e-02f, -1.56306237e-01f, 8.03645421e-03f, -1.08089022e-01f,
  -6.30639866e-02f, -7.71760866e-02f, -6.25724420e-02f, 1.70875564e-01f, -9.40677375e-02f, -5.45499660e-02f, 1.08160414e-01f, -8.15413222e-02f, -1.53439641e-01f, 1.37339190e-01f,
  -4.75640371e-02f, 6.87224343e-02f, -5.85986115e-03f, -1.07370660e-01f, 2.31218487e-02f, -1.75531730e-01f, 1.18448645e-01f, -1.36219457e-01f, 5.58896400e-02f, 4.41015922e-02f,
  -7.89104924e-02f, -1.65609433e-03f, 5.66818975e-02f, 7.84350783e-02f, -6.94955280e-03f, -3.67178880e-02f, -6.59097508e-02f, -1.03255361e-01f, 5.59447519e-02f, -2.23251730e-01f,
  2.87335187e-01f, -1.11699261e-01f, -5.77606857e-02f, 1.18396908e-01f, 5.24938330e-02f, 2.17073575e-01f, 1.97530851e-01f, -4.94303145e-02f, -5.78456186e-02f, -1.47951469e-01f,
  5.26819900e-02f, 3.75062935e-02f, -4.74828295e-02f, -3.41190072e-03f, -7.14606494e-02f, 1.12430833e-01f, -7.77303800e-02f, -7.98653066e-02f, -1.21304408e-01f, -1.70366079e-01f,
  -2.43852828e-02f, -3.52956951e-02f, 1.77976891e-01f, 4.49709110e-02f, 9.88117531e-02f, 1.71388209e-01f, 2.53522880e-02f, -5.61866723e-02f, 3.20580974e-02f, -7.53142461e-02f,
  1.13211982e-01f, -3.37133631e-02f, 8.77496228e-02f, 2.95464806e-02f, -9.25352052e-02f, -8.72523859e-02f, 3.97029966e-02f, 6.58329427e-02f, -4.69214767e-02f, -2.64510047e-02f,
  4.48650941e-02f, -2.39240304e-02f, -1.67381302e-01f, 3.50598544e-01f, 5.64593403e-03f, 1.03676014e-01f, -3.78210433e-02f, -1.04953118e-01f, 1.36757031e-01f, -1.42579034e-01f,
  -6.67325854e-02f, -6.11630008e-02f, 5.49778379e-02f, -5.11751994e-02f, -5.39271533e-03f, -7.33663663e-02f, -1.07844330e-01f, -1.17020741e-01f, 8.90694186e-03f, 1.32175818e-01f,
  4.86193523e-02f, 7.23344684e-02f, 3.81920300e-02f, -4.13518725e-03f, 1.92152429e-02f, -1.01177849e-01f, 1.24111727e-01f, 1.53100230e-02f, 6.24943450e-02f, 9.91312191e-02f,
  9.30359215e-02f, 6.05018623e-02f, -8.06029066e-02f, 1.31219149e-01f, 1.25973627e-01f, -1.09154016e-01f, 9.84694958e-02f, -5.17466255e-02f, -5.16843274e-02f, 2.94745304e-02f,
  5.81279248e-02f, 7.76796341e-02f, 1.55094296e-01f, -5.37398569e-02f, 1.02196053e-01f, -3.03945597e-02f, -3.33562605e-02f, -6.12902865e-02f, 2.01525837e-01f, 1.14512958e-01f,
  -1.98636249e-01f, 2.30177138e-02f, 1.52755082e-01f, -1.76009879e-01f, 1.20122269e-01f, 1.06095765e-02f, 3.37591358e-02f, -1.40039586e-02f, -1.66026190e-01f, -1.54455662e-01f,
  8.53843540e-02f, 1.12628657e-02f, 1.64903656e-01f, -1.23160861e-01f, 1.41685396e-01f, -6.30573407e-02f, -1.05604917e-01f, 9.73965451e-02f, 7.04145757e-03f, 6.97124973e-02f,
  4.76444652e-03f, -8.00741240e-02f, 2.17818350e-01f, -5.95114753e-02f, -1.58000886e-01f, -3.50171290e-02f, 2.46754810e-02f, -5.88357560e-02f, 7.96582390e-05f, 4.64681685e-02f,
  -8.03870782e-02f, 7.95136467e-02f, 3.89739051e-02f, 9.60882083e-02f, 7.77900219e-02f, 8.61587748e-02f, 5.73796630e-02f, 1.57486320e-01f, 1.36131018e-01f, 4.79977988e-02f,
  -8.29396471e-02f, 2.18508825e-01f, 1.38529316e-01f, 1.60378944e-02f, -1.40226290e-01f, -6.66803718e-02f, -1.23085834e-01f, 1.54134184e-01f, -1.07220463e-01f, 7.16856942e-02f,
  -1.36461526e-01f, 1.12282880e-01f, 8.34106132e-02f, 2.84907166e-02f, 2.61691734e-02f, 2.04583168e-01f, -1.95113987e-01f, -1.60276115e-01f, -7.27148205e-02f, 1.77252501e-01f,
  -1.83982790e-01f, 1.14587396e-01f, 1.21088699e-01f, 4.11177576e-02f, 1.61061864e-02f, -1.38337715e-02f, -5.66886030e-02f, 2.30650362e-02f, -7.62330443e-02f, -8.82325396e-02f,
  -1.78029224e-01f, -7.20693916e-02f, -8.08048761e-04f, 1.08963721e-01f, -1.34417892e-01f, 2.14901581e-01f, -3.29230875e-02f, -7.32695162e-02f, 6.43508732e-02f, 6.85365265e-03f,
  -7.28214458e-02f, -5.04142568e-02f, -7.85685107e-02f, 6.36306331e-02f, 1.58607602e-01f, -4.73570563e-02f, 2.18541995e-02f, -7.75662623e-03f, -1.49879660e-02f, 8.85005109e-03f,
  3.07267578e-03f, 2.29668871e-01f, -1.47267118e-01f, -6.86654523e-02f, 1.87016308e-01f, 2.15982914e-01f, 5.98154999e-02f, 4.70356345e-02f, 1.15978837e-01f, 5.08162491e-02f,
  1.43096313e-01f, 4.52036504e-03f, -1.21160932e-01f, -2.34826773e-01f, 1.66376889e-01f, -1.82793289e-02f, -1.61235645e-01f, 7.73013802e-03f, 5.99210104e-03f, 1.76533401e-01f,
  1.96635649e-01f, 1.07659087e-01f, 1.60377532e-01f, -7.66447112e-02f, 8.92685801e-02f, -2.12338883e-02f, 1.77400619e-01f, -1.67753152e-03f, -1.66566891e-03f, 5.08299144e-03f,
  2.40049884e-01f, 1.77310944e-01f, 5.57631515e-02f, -1.65694833e-01f, 7.55666122e-02f, -1.09497115e-01f, 8.82527307e-02f, -1.39547428e-02f, -9.35224965e-02f, -6.44226596e-02f,
  2.91605126e-02f, 1.08901896e-02f, -2.18156986e-02f, -4.86968718e-02f, 1.92102477e-01f, 5.33790961e-02f, -8.93905386e-02f, -9.61535498e-02f, 4.92523015e-02f, -1.53525993e-01f,
  9.00282338e-02f, 7.24856406e-02f, 8.42028409e-02f, 9.48581696e-02f, 1.23323821e-01f, 8.97297636e-02f, -2.88856998e-02f, -8.66979584e-02f, -3.94143127e-02f, 5.89848198e-02f,
  6.31353855e-02f, 1.09652348e-01f, -3.24107185e-02f, 1.89858843e-02f, 5.91788106e-02f, 1.06434003e-02f, 2.15648562e-02f, 1.28205344e-01f, -5.63845448e-02f, -1.52469771e-02f,
  4.58750129e-03f, 7.07946345e-02f, 2.58035380e-02f, 1.22867696e-01f, 8.98776427e-02f, 1.48871258e-01f, 2.20464334e-01f, 3.55656296e-02f, -7.25087896e-02f, 7.65237808e-02f,
  1.25746191e-01f, -2.26812903e-02f, -4.76480834e-02f, 8.06130394e-02f, 6.54135048e-02f, 1.62240639e-01f, -3.34464721e-02f, -9.55628045e-03f, -4.74120937e-02f, -1.61724240e-02f,
  3.58539633e-02f, 8.33356753e-02f, -4.11254092e-04f, 5.17208800e-02f, -9.34133157e-02f, -1.62020952e-01f, 2.32978947e-02f, 7.27792159e-02f, -1.28213361e-01f, 1.03775084e-01f,
  1.35066479e-01f, 6.02171905e-02f, 5.48730567e-02f, -6.17544800e-02f, -2.35809926e-02f, 3.64379399e-02f, -1.06961943e-01f, -1.21588064e-02f, -1.18345849e-01f, 8.64567161e-02f,
  -9.81877148e-02f, 1.03935733e-01f, -2.67138798e-02f, 1.44959822e-01f, -5.71568236e-02f, 6.77649230e-02f, 3.04294983e-03f, 1.43864587e-01f, -1.13851413e-01f, 2.20348239e-02f,
  -5.52053712e-02f, 1.08407274e-01f, 5.76419905e-02f, -8.78040642e-02f, 4.77575995e-02f, -1.74718633e-01f, 1.55242328e-02f, -4.44828272e-02f, -9.67727005e-02f, 8.93248767e-02f,
  -1.95382476e-01f, 1.17281556e-01f, 6.39194921e-02f, 1.13874838e-01f, 6.85400155e-04f, 7.28728175e-02f, 3.80121171e-02f, 1.04659013e-01f, 6.84236661e-02f, -4.48487327e-02f,
  -7.74543807e-02f, -1.67153195e-01f, 6.64396510e-02f, -1.44291874e-02f, -1.26789778e-01f, 6.42715544e-02f, 1.25319082e-02f, 2.33422697e-01f, 7.65455738e-02f, 1.49362937e-01f,
  1.39058068e-01f, -7.71778077e-02f, 1.67985886e-01f, 7.61639467e-03f, 1.72507584e-01f, 3.90557460e-02f, -4.67090830e-02f, -7.89207295e-02f, 1.98700473e-01f, 9.86253023e-02f,
  2.24101543e-01f, -7.51861036e-02f, 9.77666005e-02f, -2.65135281e-02f, -8.81526694e-02f, 5.43426275e-02f, -1.47239015e-01f, 6.86664507e-03f, -5.76114245e-02f, -2.38230489e-02f,
  -8.21647700e-03f, 6.70137927e-02f, 2.44398236e-01f, -2.97763534e-02f, 8.75412524e-02f, 2.45203059e-02f, -3.87888082e-04f, -6.16866015e-02f, -3.14685330e-02f, -9.39698610e-03f,
  -2.25877017e-02f, 1.32345662e-01f, -3.53512019e-02f, 1.48114935e-01f, 8.83280709e-02f, -9.74698290e-02f, 9.71619785e-02f, 1.13071665e-01f, 9.84950885e-02f, 2.84827314e-02f,
  -7.34152943e-02f, -4.49647047e-02f, 7.37494752e-02f, -9.63450149e-02f, 2.06523776e-01f, 1.84469312e-01f, -1.29154786e-01f, -2.05182627e-01f, 2.14892954e-01f, -3.77551690e-02f,
  2.76958011e-02f, 1.05922427e-02f, 7.10780174e-02f, 1.78297698e-01f, -1.12875633e-01f, -1.20263763e-01f, 4.30348888e-02f, 3.36525552e-02f, 8.40322748e-02f, -1.22870818e-01f,
  5.67888469e-02f, -2.32133493e-01f, 5.46715632e-02f, 1.00820057e-01f, 7.69159943e-02f, 7.77242258e-02f, -3.22207101e-02f, 3.13317403e-02f, 1.43536106e-01f, 2.41670031e-02f,
  1.31882876e-01f, 2.98531470e-03f, -5.62428450e-03f, -1.64090589e-01f, -6.20263480e-02f, 1.39823332e-01f, -9.78107601e-02f, -2.26337910e-01f, 1.62662894e-01f, 1.59937125e-02f,
  6.29609525e-02f, 1.22284494e-01f, 4.73248437e-02f, -8.19562674e-02f, 9.20625851e-02f, -3.53918523e-02f, -1.11243702e-01f, -3.05059273e-02f, -9.71442740e-03f, -3.04829441e-02f,
  -1.09550856e-01f, -6.93517691e-03f, -9.75467414e-02f, -2.26476528e-02f, 2.15463340e-01f, -6.17832281e-02f, 2.19672114e-01f, -2.09510580e-01f, -8.06747377e-02f, -3.97745967e-02f,
  -3.94509472e-02f, 6.61639050e-02f, 8.67137536e-02f, 1.59126461e-01f, -2.80106105e-02f, 2.97815055e-02f, 1.13978133e-01f, 1.01155668e-01f, -9.08261444e-03f, -8.12102631e-02f,
  9.37415436e-02f, 2.16537043e-01f, 2.57623017e-01f, 1.58424690e-01f, 2.80011058e-01f, 1.30518794e-01f, 1.05768330e-01f, 1.39132679e-01f, -1.93426952e-01f, -2.29991600e-02f,
  2.35167205e-01f, -6.36906475e-02f, -1.24963121e-02f, -2.22817659e-02f, -1.34641770e-02f, -5.05353808e-02f, 2.44346857e-02f, 1.38458699e-01f, 2.32713595e-02f, 9.19962749e-02f,
  1.77443102e-01f, -1.00826110e-04f, -1.15244940e-01f, -4.78562117e-02f, 4.84785549e-02f, 1.26959058e-02f, 8.74350145e-02f, -3.17297963e-04f, -1.81011900e-01f, 3.14290300e-02f,
  -8.00303221e-02f, -5.18531650e-02f, 1.49823606e-01f, 5.33670783e-02f, -2.04556175e-02f, -2.29394212e-02f, 2.21616954e-01f, -1.22890733e-01f, 8.85247290e-02f, -9.49405059e-02f,
  3.45771722e-02f, 3.07961572e-02f, -1.66004404e-01f, -1.16486892e-01f, 6.15861416e-02f, 4.56104847e-03f, 2.02026993e-01f, -2.30129417e-02f, 1.57808274e-01f, -7.76214227e-02f,
  1.87249541e-01f, -2.50279248e-01f, 1.76692158e-02f, 5.14583252e-02f, -7.35011771e-02f, 5.75323179e-02f, 7.12010786e-02f, 1.87642142e-01f, -2.19857227e-02f, -1.98112335e-03f,
  4.03226204e-02f, 1.46428458e-02f, -8.53227638e-03f, -1.33017510e-01f, 3.29780206e-02f, 1.77693382e-01f, -7.11980881e-03f, -4.50415071e-03f, 9.16221291e-02f, 2.46898513e-02f,
  1.28604500e-02f, 5.80765046e-02f, 1.40806824e-01f, -5.22240475e-02f, 7.70115554e-02f, 1.15619063e-01f, 9.41519961e-02f, -6.96208002e-03f, -5.15266210e-02f, -2.40455389e-01f,
  -4.11794707e-02f, 1.23243004e-01f, -2.82172002e-02f, 3.15315016e-02f, -1.82117015e-01f, 1.06127352e-01f, 1.01800196e-01f, 1.88543707e-01f, 1.22329138e-01f, 1.61418125e-01f,
  -1.33014441e-01f, -2.52223551e-01f, -1.22618273e-01f, 1.09021813e-01f, -7.10622966e-02f, -2.12355852e-01f, 2.61756420e-01f, 1.11397751e-01f, -1.48361642e-02f, -3.35517377e-02f,
  1.96251627e-02f, -6.02799281e-02f, 6.10848553e-02f, 4.63717282e-02f, -1.06779918e-01f, -1.53175145e-02f, 5.27724698e-02f, -1.56126857e-01f, -1.88391820e-01f, 1.73298437e-02f,
  -2.94978589e-01f, -6.23824727e-03f, 1.68597609e-01f, 3.26929009e-03f, 1.28630355e-01f, -6.42833710e-02f, -1.14484251e-01f, 9.08312425e-02f, -6.78943098e-03f, -1.50823295e-01f,
  1.84291780e-01f, 1.39837995e-01f, -1.82296917e-01f, -1.06302060e-01f, 2.22473685e-02f, -1.95355602e-02f, 7.20765628e-03f, -9.71570686e-02f, -1.93397868e-02f, 1.53084606e-01f,
  -1.43852875e-01f, -4.39385213e-02f, -6.36231154e-02f, -2.64381710e-03f, 4.94613796e-02f, -6.92373365e-02f, 2.19793975e-01f, 2.51566786e-02f, 1.44089898e-02f, 1.93892449e-01f,
  6.64669052e-02f, 6.46442249e-02f, 3.02529079e-05f, 6.48727268e-02f, 2.08900254e-02f, 6.17110310e-03f, -3.64427269e-02f, 5.35585769e-02f, -7.36931115e-02f, -7.91631825e-03f,
  7.64708072e-02f, -1.30505506e-02f, -3.26856971e-02f, 5.35706580e-02f, -6.16405308e-02f, -9.53583345e-02f, -2.26154309e-02f, 5.52643239e-02f, 8.92517641e-02f, 9.78334770e-02f,
  3.20473909e-02f, 5.21156332e-03f, 5.98206632e-02f, -1.60241760e-02f, -4.64417040e-02f, 7.17550330e-03f, -4.61180694e-02f, -5.33682108e-02f, 2.25768927e-02f, -3.01020220e-04f,
  1.05693012e-01f, -3.40994857e-02f, -9.07539949e-02f, 6.08972982e-02f, -3.82072665e-02f, -2.21442655e-02f, -2.02291179e-02f, 2.83520389e-02f, -1.19918644e-01f, 9.99427810e-02f,
  1.76522229e-02f, 1.15988418e-01f, 8.07430521e-02f, -6.90863505e-02f, 1.52822221e-02f, 2.32735537e-02f, 8.70668963e-02f, 8.91818404e-02f, 4.80872393e-03f, 1.29502222e-01f,
  1.75955981e-01f, 6.42465651e-02f, 3.64623480e-02f, 5.11372928e-03f, 2.54003346e-01f, 1.43904284e-01f, 1.56229645e-01f, 1.28112122e-01f, -3.02832983e-02f, 2.14376718e-01f,
  -1.68619767e-01f, 1.06386706e-01f, -8.73973686e-03f, -1.20036684e-01f, -7.60534033e-02f, -7.78268725e-02f, -1.70481965e-01f, 2.09450915e-01f, 8.78230482e-02f, 2.64292508e-01f,
  1.60625502e-01f, 1.61931276e-01f, 3.11702751e-02f, 4.74938899e-02f, -8.64363536e-02f, 9.79111120e-02f, 1.21640235e-01f, -1.52040005e-01f, 1.24117345e-01f, 1.83095023e-01f,
  1.24177724e-01f, -5.24148047e-02f, 4.70810346e-02f, -3.58002319e-04f, -1.69009954e-01f, 6.31486624e-02f, 5.40698916e-02f, -8.65741372e-02f, -5.05136885e-02f, 9.58940163e-02f,
  1.47189209e-02f, 1.60801828e-01f, 1.27501264e-01f, 1.37497902e-01f, 3.11630517e-02f, 1.19919561e-01f, 1.02600008e-01f, 5.38964607e-02f, -8.01946074e-02f, 1.74966171e-01f,
  -2.59000789e-02f, 1.27905443e-01f, 4.71309349e-02f, -2.18594018e-02f, 8.42386708e-02f, -1.40579998e-01f, -3.72317582e-02f, 1.57632276e-01f, -9.31511912e-03f, 6.52470887e-02f,
  -4.82897386e-02f, 1.40866518e-01f, -3.18590254e-02f, -1.40427232e-01f, 4.12132703e-02f, 1.79895282e-01f, -9.68305171e-02f, -1.69445714e-03f, -1.72541477e-02f, 2.70962901e-02f,
  9.96170044e-02f, 3.93797830e-02f, -9.70522966e-03f, 1.47300884e-01f, 9.52586085e-02f, -6.02457598e-02f, -8.87839943e-02f, 5.94197325e-02f, 2.12070808e-01f, -2.27992609e-02f,
  3.68407033e-02f, -3.62439789e-02f, -2.22516358e-01f, 1.98363326e-02f, -5.04379980e-02f, -3.70864011e-02f, -5.90656251e-02f, -2.52924934e-02f, 9.11052600e-02f, 1.25639141e-01f,
  1.43707067e-01f, 4.89920657e-03f, -1.07337981e-01f, -3.36265936e-02f, 4.56739739e-02f, 1.08471341e-01f, -1.87234104e-01f, -8.17804039e-02f, 2.11523801e-01f, 7.09129646e-02f,
  7.16383234e-02f, 2.57217765e-01f, -3.25206742e-02f, -1.96997169e-02f, -1.36607662e-01f, 1.45164639e-01f, -9.77388211e-03f, -1.40799098e-02f, -9.15951282e-02f, -1.66709110e-01f,
  4.00253460e-02f, 1.84885621e-01f, -2.19771802e-01f, -2.32645888e-02f, -9.21581686e-02f, -2.42129564e-02f, -1.08788423e-01f, -2.89474521e-03f, -1.31043408e-03f, 7.91906565e-03f,
  9.59469378e-02f, -1.52778566e-01f, -1.40199468e-01f, -1.09698519e-01f, 3.20508368e-02f, 1.26007125e-01f, 1.45179734e-01f, 2.46673718e-01f, -1.02361426e-01f, -5.02504036e-02f,
  4.46862467e-02f, 7.34658465e-02f, 2.18492467e-02f, 1.11257538e-01f, 2.47709006e-01f, -1.19896196e-01f, 5.44735231e-02f, 5.57388701e-02f, -3.07782710e-01f, -4.58553992e-02f,
  -1.00318581e-01f, -1.78732917e-01f, -1.19638301e-01f, -3.14875990e-02f, 7.55187124e-02f, -1.40132159e-01f, 2.62663662e-01f, -3.48434210e-01f, 1.99941710e-01f, -3.34771127e-02f,
  -2.08910167e-01f, 1.30973116e-01f, 2.39299864e-01f, 2.94432268e-02f, -4.95284125e-02f, 2.31021270e-02f, 9.07794610e-02f, 5.95948063e-02f, -1.98479921e-01f, -1.20956846e-01f,
  1.40043244e-01f, -8.09899047e-02f, -5.26167527e-02f, -8.22896510e-02f, 8.00436661e-02f, 2.54802704e-01f, 4.65275906e-02f, 5.46416603e-02f, -4.71549891e-02f, 1.36046186e-01f,
  2.93791920e-01f, -8.58165845e-02f, 5.64553402e-02f, -8.01545233e-02f, 3.63946483e-02f, -1.72861785e-01f, -7.48763904e-02f, 1.44212544e-01f, 7.18724041e-04f, -1.59708485e-01f,
  4.24308956e-01f, -1.27094969e-01f, -9.53653082e-03f, -8.58183205e-02f, -1.88047364e-01f, 3.26400816e-01f, -1.90371498e-01f, 4.40768301e-01f, 1.36780649e-01f, 9.12835002e-02f,
  1.28227189e-01f, 1.25513181e-01f, -4.21416834e-02f, -1.72406152e-01f, 8.03014338e-02f, -1.41414255e-01f, 8.43221471e-02f, 1.12376347e-01f, 8.63034800e-02f, 8.97756964e-02f,
  1.07436523e-01f, 3.29766646e-02f, -2.71932911e-02f, 6.32011592e-02f, 8.73853453e-04f, -8.03330466e-02f, -5.64297065e-02f, -2.10265014e-02f, 3.45549844e-02f, 3.33610736e-02f,
  1.63347676e-01f, -5.34172356e-02f, 3.03519219e-02f, -6.99985027e-02f, -7.15274438e-02f, 4.65375558e-02f, 6.96525574e-02f, 2.10689846e-02f, -4.18839082e-02f, -1.22362755e-01f,
  -1.54100563e-02f, 9.77005661e-02f, 8.52157734e-03f, 4.83529493e-02f, 6.97892979e-02f, 1.27343878e-01f, -4.25721295e-02f, -6.24106266e-02f, 8.40181783e-02f, 6.47044480e-02f,
  -7.46293813e-02f, 1.58547848e-01f, 3.00417952e-02f, 7.35396296e-02f, 1.30302399e-01f, 6.49775341e-02f, 1.03464797e-01f, 5.40079959e-02f, 1.44616142e-01f, -4.84132245e-02f,
  -2.12523475e-01f, 1.13343351e-01f, -1.47650674e-01f, 5.82735874e-02f, 2.71423534e-02f, 5.77894449e-02f, 1.19753443e-01f, -1.21549204e-01f, -4.04448435e-02f, 1.00842282e-01f,
  -9.93481576e-02f, -4.66308603e-03f, 4.23583500e-02f, 3.98903452e-02f, -5.14270626e-02f, -1.60748176e-02f, 5.85299800e-04f, -8.33931204e-04f, 1.61570553e-02f, -1.02962650e-01f,
  1.38054192e-01f, 2.19973996e-01f, 1.54659510e-01f, 1.20444119e-01f, 7.09456354e-02f, 1.62265554e-01f, -5.70544749e-02f, -2.88384990e-03f, 7.15990365e-02f, -7.93113858e-02f,
  -1.31124243e-01f, -4.52560261e-02f, 1.82503741e-02f, 2.90058017e-01f, -1.21037990e-01f, 2.33207762e-01f, -1.01764575e-01f, -6.07743487e-02f, 8.65576342e-02f, -1.26321733e-01f,
  -9.41837579e-03f, 1.23442197e-02f, -8.44312832e-02f, 1.08883664e-01f, 9.00053233e-02f, 2.45463282e-01f, 7.07142130e-02f, 4.11955044e-02f, 1.28492251e-01f, 2.37593099e-01f,
  -4.23498489e-02f, 6.85173497e-02f, 6.14266843e-03f, -1.35514401e-02f, -9.97966528e-02f, 4.59615737e-02f, -3.63723077e-02f, 3.50117162e-02f, -2.31290907e-02f, 4.50255871e-02f,
  2.23378122e-01f, 1.20995991e-01f, 2.29647845e-01f, 4.52742204e-02f, 8.33322853e-02f, 1.42595947e-01f, -1.05065301e-01f, 2.39783227e-02f, -2.58052766e-01f, 1.60505533e-01f,
  1.50165215e-01f, 1.14553370e-01f, 1.37308165e-01f, -1.38912991e-01f, 1.61416195e-02f, -1.92197412e-01f, 1.93197057e-01f, 9.04879440e-03f, -5.13261370e-02f, 4.17982377e-02f,
  1.71349376e-01f, 1.78211257e-01f, -6.48653135e-02f, -1.06027834e-01f, 1.93803921e-01f, 9.39258859e-02f, 2.25023612e-01f, -6.69587329e-02f, 4.93473709e-02f, 9.03101563e-02f,
  -1.70274809e-01f, -1.41215503e-01f, 9.35985297e-02f, -1.64363950e-01f, -3.23223770e-02f, 9.20813233e-02f, 1.62824586e-01f, -1.75572485e-01f, 7.39310756e-02f, -1.63283899e-01f,
  1.31131202e-01f, -8.41775015e-02f, -1.27136474e-02f, -4.33383398e-02f, 3.37784030e-02f, -3.51439156e-02f, 4.63116989e-02f, 7.42862048e-03f, 2.14272719e-02f, 6.09236546e-02f,
  -4.69421111e-02f, -4.86412831e-02f, -2.67481282e-02f, -1.20206527e-01f, 1.05052657e-01f, -4.69478108e-02f, -2.65815519e-02f, 3.26385260e-01f, 1.78810246e-02f, -1.18054584e-01f,
  3.15636061e-02f, 1.23032868e-01f, 1.91031881e-02f, -1.04592413e-01f, -2.14580148e-01f, -1.37798324e-01f, 2.08676696e-01f, -1.01157770e-01f, 4.60803648e-03f, -3.85982059e-02f,
  1.02858126e-01f, -2.12075144e-01f, 1.58750728e-01f, -8.11069459e-02f, -2.55034044e-02f, -5.93289696e-02f, -1.77535772e-01f, 2.08551779e-01f, -1.38904661e-01f, 2.90186882e-01f,
  9.89382640e-02f, 1.42713472e-01f, 1.61331102e-01f, 2.33619243e-01f, -2.85026543e-02f, -2.07701579e-01f, 3.09323482e-02f, -5.67214563e-02f, 2.13191152e-01f, 3.27623598e-02f,
  1.68139145e-01f, 9.41620991e-02f, 9.97866020e-02f, 2.48331875e-01f, 1.07829235e-01f, 1.46752059e-01f, -6.07914999e-02f, -1.59834269e-02f, -5.71921468e-02f, -1.44507706e-01f,
  -1.17133304e-01f, 1.34828970e-01f, 2.85475366e-02f, 2.33236760e-01f, 1.09834768e-01f, 2.45362341e-01f, 5.66579290e-02f, 1.27739266e-01f, 1.50682135e-02f, -4.43426110e-02f,
  -1.44259166e-02f, -2.55813897e-02f, 1.14522934e-01f, 3.38956378e-02f, 1.52263064e-02f, 2.56968127e-03f, 5.10601290e-02f, 1.01336785e-01f, -1.25209853e-01f, 6.76258095e-03f,
  -3.11954250e-03f, -2.48916149e-01f, 5.55192418e-02f, 1.46613106e-01f, -4.07321751e-02f, -3.89478542e-02f, -1.19228713e-01f, 1.38945848e-01f, 1.14594750e-01f, 2.61237115e-01f,
  1.35149345e-01f, 4.62055542e-02f, 1.21749729e-01f, 5.48586957e-02f, 3.18425484e-02f, 8.44519585e-02f, 7.24029467e-02f, -1.01547077e-01f, 9.38621834e-02f, 1.95814651e-02f,
  1.81659579e-01f, 1.10145196e-01f, 7.47230724e-02f, -5.68828024e-02f, 1.00749731e-02f, -1.02889035e-02f, -1.30502626e-01f, -1.35210559e-01f, 5.10224476e-02f, 7.96378404e-02f,
  7.96102360e-02f, 3.73140089e-02f, 1.01336978e-01f, -9.93783250e-02f, -9.79523659e-02f, -3.70339639e-02f, 7.70942196e-02f, -7.24161565e-02f, 1.04802009e-02f, -7.39859715e-02f,
  1.93958413e-02f, -5.42531125e-02f, -5.42439381e-03f, -1.14488803e-01f, -6.66720644e-02f, 1.82038724e-01f, 3.14891897e-02f, 2.39664778e-01f, 1.32505566e-01f, -4.67745587e-02f,
  5.31542972e-02f, 1.25885047e-02f, -4.69765998e-02f, 1.36369720e-01f, 1.49861559e-01f, -1.81916922e-01f, 2.06196606e-02f, 6.63121417e-02f, 2.57581085e-01f, -3.87964374e-03f,
  1.32325828e-01f, 3.20010330e-03f, -9.47812721e-02f, 7.97624607e-03f, -1.03759542e-01f, -1.26253113e-01f, -1.19048327e-01f, 8.62877965e-02f, -5.74529879e-02f, 1.38637081e-01f,
  3.01568005e-02f, 1.94847494e-01f, 8.29403624e-02f, -4.00259383e-02f, 1.35828540e-01f, 1.17192872e-01f, -2.74335127e-03f, 1.53114796e-01f, 2.18976885e-02f, 1.78657457e-01f,
  -2.93131858e-01f, 2.21387789e-01f, 1.97067365e-01f, -1.94947387e-03f, 1.63637057e-01f, -1.07029207e-01f, 5.05758561e-02f, -1.47959709e-01f, 4.17809524e-02f, -2.91994726e-03f,
  7.66787794e-04f, -2.32415438e-01f, 1.40748620e-01f, 2.87214577e-01f, -9.98572037e-02f, -1.61389410e-01f, 9.88318175e-02f, 7.79307559e-02f, 8.53894055e-02f, 1.61886048e-02f,
  3.42926644e-02f, 8.01227838e-02f, -1.76977247e-01f, -1.04729056e-01f, 2.60866910e-01f, -8.17852169e-02f, 7.82891363e-02f, -1.20644614e-01f, 1.03039052e-02f, -2.45706830e-03f,
  -8.70434791e-02f, 1.84618682e-01f, 2.93830223e-02f, -1.23590775e-01f, 2.03512505e-01f, -1.74773529e-01f, -1.75439883e-02f, -2.93979514e-02f, 5.98176010e-02f, 2.32647583e-02f,
  1.02169424e-01f, 7.67755508e-02f, -9.54218674e-03f, 2.66087037e-02f, 4.07362618e-02f, -1.91061586e-01f, 1.45494908e-01f, 7.37278387e-02f, -2.57612169e-01f, -2.02943124e-02f,
  1.20081991e-01f, -2.87203997e-01f, 1.02926195e-01f, -1.09095670e-01f, -8.27634484e-02f, -3.97169441e-02f, -1.24336064e-01f, -1.58183068e-01f, -8.78941193e-02f, -7.24891871e-02f,
  2.46614426e-01f, -8.45100358e-02f, 1.18678160e-01f, -5.73093034e-02f, 1.21345386e-01f, -2.45807230e-01f, 1.54443842e-03f, -6.74530044e-02f, -1.39883131e-01f, 4.49685864e-02f,
  4.91666645e-02f, 5.69514669e-02f, -1.83638513e-01f, -1.36184454e-01f, 8.46511424e-02f, 3.24319229e-02f, -3.12084500e-02f, 1.37882738e-03f, -1.16294893e-02f, 8.43798295e-02f,
  -1.77976564e-02f, -1.98127851e-02f, -8.50087032e-02f, -4.34445217e-02f, -3.47286649e-02f, -2.34109052e-02f, -3.09806354e-02f, -9.26324278e-02f, 1.17570244e-01f, 3.70123014e-02f,
  1.18095167e-01f, -6.27679527e-02f, -1.16213299e-02f, -2.41102040e-01f, -5.16577885e-02f, 5.36669567e-02f, 7.64325187e-02f, 9.15783457e-03f, -1.72086760e-01f, 1.22782148e-01f,
  1.11051209e-01f, 8.12487602e-02f, 1.78648606e-01f, 1.16982535e-01f, -9.61620063e-02f, -1.64101914e-01f, -2.40734946e-02f, 6.94919825e-02f, -4.80920961e-03f, -2.16990873e-01f,
  1.99424461e-01f, -6.54280139e-03f, -4.51319106e-02f, 7.60495365e-02f, 5.74047156e-02f, -1.11638494e-01f, 2.75794864e-02f, 1.36139899e-01f, -7.64372945e-02f, -6.75970763e-02f,
  -6.21253066e-02f, -1.83311164e-01f, -1.69543952e-01f, -8.16879347e-02f, -7.48629123e-02f, -1.07346214e-01f, 2.78171986e-01f, -1.02554820e-01f, 2.27290094e-01f, -8.93760622e-02f,
  -4.95752133e-02f, -3.95471752e-02f, 1.84512492e-02f, 2.88818758e-02f, 4.36891839e-02f, 2.00812832e-01f, -7.24949762e-02f, 2.18419664e-04f, 1.58127487e-01f, 1.29234761e-01f,
  6.34072199e-02f, -1.41493753e-01f, 2.16037240e-02f, 1.13443099e-01f, -1.06968090e-01f, -6.69739172e-02f, -1.22806035e-01f, -4.56623398e-02f, -7.39301890e-02f, -1.54477015e-01f,
  1.84238121e-01f, -2.01169122e-02f, -8.97604972e-02f, 1.05594985e-01f, -5.62100448e-02f, 1.38705552e-01f, 1.34945109e-01f, -9.56380740e-03f, -4.45942320e-02f, -1.36473119e-01f,
  1.03401709e-02f, 2.89850757e-02f, 3.67011204e-02f, -7.89785478e-03f, -1.90115422e-02f, 5.20025045e-02f, -4.05764617e-02f, -4.24737036e-02f, 4.89867292e-03f, -7.31565356e-02f,
  -3.28986682e-02f, -5.32994792e-02f, 1.20938674e-01f, -3.19865830e-02f, -9.08918958e-03f, 5.51740602e-02f, 1.62936328e-03f, 5.03851194e-03f, 9.48697701e-02f, -8.18868354e-02f,
  1.67789772e-01f, -7.42183328e-02f, 1.46818608e-01f, 8.26719590e-03f, -4.97590825e-02f, -7.45508224e-02f, 9.85768810e-03f, 1.43536329e-02f, -4.88116853e-02f, -7.42656738e-02f,
  1.68678641e-01f, -1.77351385e-02f, -1.07261389e-01f, 2.19016314e-01f, -3.67588028e-02f, 7.19525144e-02f, -9.74911898e-02f, -3.48258205e-02f, 1.00622170e-01f, -1.75836030e-02f,
  -5.84911183e-02f, 3.13166678e-02f, 7.64357448e-02f, -1.88953765e-02f, -2.67039100e-03f, -8.82944539e-02f, -3.42171453e-02f, -8.97414014e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  9.17293690e-03f, 1.48833007e-01f, -1.55686755e-02f, 9.97810885e-02f, 1.38193786e-01f, 1.79324791e-01f, -2.97196559e-03f, -2.50987820e-02f, 1.11155137e-01f, 5.30788116e-02f,
  2.81528626e-02f, 6.21156655e-02f, 7.71917999e-02f, 1.49949133e-01f, 7.72553831e-02f, 1.25765145e-01f, 1.57735378e-01f, 9.74302646e-03f, -2.25862376e-02f, 1.04398452e-01f,
  9.27456468e-02f, 4.95218970e-02f, -9.33387429e-02f, 1.18831545e-01f, 1.05919957e-01f, 7.61407167e-02f, 8.50319713e-02f, 1.41939938e-01f, -3.39727215e-02f, -3.76249813e-02f,
  -5.94264455e-02f, -1.45808375e-02f, 3.74445505e-02f, 1.58545524e-01f, 1.38086066e-01f, -2.99972203e-02f, 1.78910434e-01f, 8.66655633e-02f, 1.74377486e-01f, -4.30441871e-02f,
  -6.74632266e-02f, 1.62745401e-01f, 5.92699163e-02f, 6.07385077e-02f, 1.24552459e-01f, 1.17379427e-01f, 1.19953334e-01f, 1.56178653e-01f, 1.07349299e-01f, 4.72660363e-02f,
  3.58848758e-02f, -6.73821345e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.26248375e-01f, 2.74015218e-02f, -2.28789687e-01f, -1.15708597e-01f, -1.25059754e-01f, -1.30121574e-01f, -9.15065855e-02f, -1.18658721e-01f, 1.28310248e-01f, 7.33585358e-02f,
  1.72099113e-01f, -1.38030604e-01f, 6.03783391e-02f, 2.16633916e-01f, 4.04241867e-03f, -1.77792949e-03f, 1.23147927e-01f, -1.57890305e-01f, 2.01471150e-01f, -9.91986990e-02f,
  -2.29020059e-01f, 1.14229091e-01f, 1.28928423e-01f, -5.46421250e-03f, -9.92426500e-02f, -8.20011199e-02f, 1.34642437e-01f, -1.21688753e-01f, 9.48793367e-02f, -7.90923163e-02f,
  -4.15104702e-02f, -1.02360681e-01f, 5.65304533e-02f, -1.99210837e-01f, -2.01253504e-01f, -3.28365639e-02f, -1.92291513e-01f, -1.97588429e-01f, 1.33344278e-01f, -1.18831545e-01f,
  1.28736615e-01f, 1.76181898e-01f, -9.97711495e-02f, -5.00566699e-02f, -1.29935279e-01f, -4.86465432e-02f, 8.07829276e-02f, 7.75053650e-02f, 1.28839701e-01f, 2.77987327e-02f,
  -1.86573014e-01f, 1.29611120e-01f, 1.11796305e-01f, 9.11518186e-02f, -5.28273173e-02f, 1.13074139e-01f, -2.43782904e-02f, -5.25316000e-02f, -9.21961963e-02f, 1.76137295e-02f,
  9.42983851e-02f, -1.74937755e-01f, 1.07056074e-01f, -1.82954371e-02f, 5.42908534e-02f, -5.66452742e-02f, -8.04343354e-03f, 6.12163804e-02f, -3.04875746e-02f, 3.29875648e-02f,
  9.20151398e-02f, 9.13405865e-02f, -9.67856124e-02f, 1.26811445e-01f, 7.85944387e-02f, 1.58588246e-01f, -1.23623632e-01f, -3.42890732e-02f, -1.50090650e-01f, 6.15788391e-03f,
  8.92052427e-02f, 1.36577934e-01f, -1.28905654e-01f, -1.51346773e-01f, 8.78500342e-02f, -8.25895146e-02f, 3.32471952e-02f, -1.10555843e-01f, -4.33487482e-02f, -1.41375735e-01f,
  1.10465586e-01f, -1.73806958e-02f, -1.11418188e-01f, -1.76025793e-01f, 6.96505513e-03f, -1.14993669e-01f, -1.11772127e-01f, -6.52988777e-02f, -1.19426213e-01f, -1.21575162e-01f,
  -4.22528908e-02f, 1.43496168e-03f, -1.76128030e-01f, -1.44491531e-02f, 1.63707495e-01f, -1.18180513e-02f, -8.59058723e-02f, -9.11253616e-02f, -9.26723406e-02f, -3.62728722e-02f,
  5.79918660e-02f, -2.84425169e-02f, -6.34155646e-02f, -9.10073053e-03f, -2.78532766e-02f, -1.44806951e-01f, -8.82084146e-02f, 4.06853817e-02f, -1.72588229e-01f, 1.27073944e-01f,
  -6.65684463e-03f, 6.20775707e-02f, 1.58575866e-02f, 1.02471210e-01f, 3.59053947e-02f, 1.70803200e-02f, -7.09143728e-02f, -9.14594829e-02f, -1.34377489e-02f, -2.41633616e-02f,
  9.67171341e-02f, -8.08428451e-02f, -2.11677849e-02f, 3.67523544e-02f, 4.28088270e-02f, 1.37151763e-01f, -1.44736320e-02f, -3.56942206e-03f, 8.43081772e-02f, 1.42812401e-01f,
  -4.69884984e-02f, -1.78527072e-01f, -2.07790419e-01f, 1.03983745e-01f, -1.72428459e-01f, -9.27423220e-03f, -4.19452190e-02f, -9.42840949e-02f, -3.28504667e-02f, 5.20349517e-02f,
  -4.18921895e-02f, -3.00277919e-02f, -1.11622997e-01f, 1.24826759e-01f, -1.96480796e-01f, -4.46995487e-03f, -1.04511678e-01f, -8.30311514e-03f, -5.16770594e-02f, -2.01259568e-01f,
  -7.51801953e-02f, 1.68897789e-02f, -1.03735983e-01f, 3.37930833e-04f, -7.49837235e-02f, 7.43128508e-02f, -1.07426360e-01f, 4.91693467e-02f, -5.76959774e-02f, -1.33644357e-01f,
  -1.65267229e-01f, -2.13661753e-02f, -4.22657095e-02f, -2.03235194e-01f, -1.23196589e-02f, -1.96767583e-01f, 8.82292464e-02f, 5.58544360e-02f, -1.27844922e-02f, -1.89215735e-01f,
  3.84129435e-02f, 5.67410374e-04f, -1.02839276e-01f, 3.24285507e-01f, -1.48647623e-02f, -1.18855536e-01f, 2.19168097e-01f, -1.52554497e-01f, -1.22943886e-01f, -1.02742258e-02f,
  6.57083839e-02f, 1.33752814e-02f, -4.81300652e-02f, -1.87983960e-02f, -3.43231671e-02f, -1.45338839e-02f, 1.49181988e-02f, 6.56330734e-02f, -5.35808541e-02f, 4.35495079e-02f,
  9.44465920e-02f, 9.66928750e-02f, 1.03348643e-01f, 1.28485039e-01f, 5.76129444e-02f, 1.59571618e-01f, -9.67689976e-02f, -1.66624913e-03f, 1.82197511e-01f, 1.57434586e-02f,
  -2.03155968e-02f, -1.24124162e-01f, 1.68782696e-02f, -1.29524022e-01f, 1.96939304e-01f, -9.15355757e-02f, 1.35662062e-02f, -1.41571939e-01f, 1.08918473e-01f, -1.24692120e-01f,
  5.02510741e-03f, -1.41895890e-01f, -5.20837083e-02f, -6.07314073e-02f, 1.58718298e-03f, -1.42051727e-01f, -1.46163836e-01f, -8.43405649e-02f, -5.03227450e-02f, -8.83337483e-02f,
  -4.24188748e-02f, -8.76592472e-02f, 1.63646609e-01f, 1.15447469e-01f, -1.19409703e-01f, -1.04206644e-01f, -6.80981502e-02f, 3.38281207e-02f, 5.14066294e-02f, 3.69115733e-02f,
  1.21948637e-01f, -7.68778175e-02f, -5.88911697e-02f, -1.26528427e-01f, -8.97309631e-02f, 1.50054246e-01f, -1.41471863e-01f, 1.25265688e-01f, 4.99942601e-02f, -6.99035674e-02f,
  6.69095442e-02f, -3.07568256e-02f, 7.01763257e-02f, -4.71223099e-03f, -7.98967779e-02f, -7.79854953e-02f, -7.53014833e-02f, 4.15394157e-02f, 1.60756381e-03f, -8.15397725e-02f,
  4.04908098e-02f, 3.65297496e-02f, 6.16770424e-02f, -1.47229269e-01f, -2.80732401e-02f, -1.25389174e-01f, 1.47698700e-01f, 3.72007973e-02f, -1.66427210e-01f, -6.49832934e-02f,
  -5.69251962e-02f, 7.29134157e-02f, -1.03955895e-01f, -7.76081830e-02f, -4.24923599e-02f, 6.44175857e-02f, 7.01992214e-02f, -1.49464577e-01f, -9.89418477e-03f, -8.72470066e-03f,
  -1.89242572e-01f, -3.89547944e-02f, -1.09248966e-01f, 1.51131619e-02f, -1.34354606e-01f, 9.83513799e-03f, 6.94998577e-02f, 1.13921218e-01f, -9.01358202e-02f, 4.88748029e-02f,
  5.51313870e-02f, -8.17838088e-02f, -1.86091021e-01f, 1.62414014e-01f, 3.62404734e-02f, -1.97059661e-01f, -7.36639947e-02f, -7.41524771e-02f, -6.20742934e-03f, 5.73435519e-03f,
  1.61842499e-02f, 3.98305915e-02f, 9.62754935e-02f, 4.27030446e-03f, 3.66146080e-02f, 9.05277580e-02f, 6.67741224e-02f, 9.84315872e-02f, 1.49297472e-02f, -6.89002126e-02f,
  -1.25891432e-01f, 7.08262026e-02f, -1.35712937e-01f, -3.94465774e-02f, 3.22518758e-02f, 5.57122901e-02f, -6.27698302e-02f, 1.29758909e-01f, 9.07927379e-02f, 3.86189558e-02f,
  -7.06524178e-02f, 1.23428769e-01f, -4.88334112e-02f, -3.69986333e-02f, -3.17332149e-03f, -3.10471877e-02f, 2.78094430e-02f, -2.89801210e-02f, -2.19294112e-02f, 1.25534430e-01f,
  3.40867601e-02f, -4.76135276e-02f, 8.85075107e-02f, 3.29552814e-02f, -3.11609693e-02f, 2.03783344e-02f, -9.03561488e-02f, -7.27004884e-03f, -1.50322625e-02f, -9.93987694e-02f,
  -1.44080192e-01f, 2.20483080e-01f, 2.19740085e-02f, 3.44687216e-02f, 4.08043303e-02f, 8.92893076e-02f, -1.04817249e-01f, 1.03301601e-02f, 1.37743782e-02f, -4.09850366e-02f,
  -1.02902085e-01f, -9.67297107e-02f, 1.47124991e-01f, -6.27752617e-02f, -1.08846173e-01f, 1.44676000e-01f, -5.45998290e-02f, 1.99448969e-02f, 8.86287987e-02f, -3.21973562e-02f,
  -7.95507953e-02f, 7.32099265e-02f, -4.31603044e-02f, -5.64629287e-02f, -1.00967698e-01f, -7.25052729e-02f, -3.37213501e-02f, -5.49421608e-02f, 4.46511768e-02f, 3.38427387e-02f,
  2.60525513e-02f, 2.44723279e-02f, 1.06183283e-01f, 2.67847851e-02f, 4.97179441e-02f, 2.03042284e-01f, 1.42840862e-01f, 8.44699889e-02f, 1.49942771e-01f, -1.11048751e-01f,
  6.71750531e-02f, -8.87276828e-02f, 1.73564553e-01f, -1.96094550e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  7.88000897e-02f, 1.11445367e-01f, 1.60284877e-01f, 7.36013874e-02f, 1.18131284e-02f, 1.41547889e-01f, 1.15643270e-01f, 3.76652330e-02f, -9.16764289e-02f, -3.83050516e-02f,
  8.84277150e-02f, 1.23093657e-01f, -1.50972176e-02f, -1.23384349e-01f, -1.43009529e-01f, 8.89625284e-04f, 1.23685002e-01f, 1.99632093e-01f, 2.41056494e-02f, -8.57149512e-02f,
  1.81326628e-01f, -8.48090723e-02f, 3.85980383e-02f, -1.14901615e-02f, 1.97237507e-01f, 1.18683949e-01f, -1.45283192e-01f, 6.56754598e-02f, -3.39508466e-02f, 1.11826370e-02f,
  5.09580150e-02f, 7.66524114e-03f, -4.90905866e-02f, -2.71285214e-02f, -1.05329454e-01f, 3.80581841e-02f, 2.02670753e-01f, 2.06529628e-02f, -1.35538369e-01f, 7.47829750e-02f,
  9.39993560e-02f, -2.72719897e-02f, -4.33973670e-02f, -4.52641733e-02f, 2.70376429e-02f, -7.54159316e-02f, 1.61903858e-01f, 3.91984060e-02f, 1.00579888e-01f, -7.44174719e-02f,
  5.27447239e-02f, -1.27523288e-01f, -8.28637630e-02f, 1.79281607e-01f, 8.54518488e-02f, -9.05222893e-02f, 6.06127363e-03f, 2.12592989e-01f, 7.32217133e-02f, -1.99010689e-02f,
  7.07495436e-02f, 2.80509386e-02f, -1.68624073e-01f, -8.47533047e-02f, -7.76563818e-03f, 1.04474768e-01f, 5.60124218e-02f, 6.01042546e-02f, 5.58497086e-02f, 1.10276774e-01f,
  -3.64972055e-02f, -4.82781976e-02f, 5.98780811e-02f, 1.24026269e-01f, 1.23374790e-01f, 1.02938920e-01f, 1.27638236e-01f, 4.85380813e-02f, -7.33617395e-02f, -2.35112733e-03f,
  4.08489890e-02f, -4.85432305e-04f, 1.00688376e-01f, -9.88182276e-02f, -8.52536410e-02f, 1.14421025e-01f, 1.98119596e-01f, -3.98920253e-02f, -7.46285841e-02f, 3.41310464e-02f,
  -8.29635933e-02f, -5.49807027e-03f, -6.75104782e-02f, -1.51918698e-02f, -5.68538113e-03f, -1.04550011e-01f, 6.54602721e-02f, -8.20341483e-02f, -8.58902633e-02f, 5.67105636e-02f,
  -1.49881035e-01f, -8.57452974e-02f, 2.03662775e-02f, 1.90938376e-02f, -3.64923920e-03f, 1.72387600e-01f, -1.08325489e-01f, -8.55448991e-02f, -4.48400266e-02f, -1.77843630e-01f,
  1.93021476e-01f, 5.51830865e-02f, 2.15125129e-01f, -1.30585358e-01f, -6.43994436e-02f, -4.99442406e-02f, -1.50328979e-01f, 2.14908749e-01f, 2.01779529e-02f, 3.27712297e-02f,
  1.94588110e-01f, 1.89407796e-01f, -1.09185718e-01f, 1.82741106e-01f, 2.57486969e-01f, -3.25240083e-02f, -9.22259316e-03f, -5.84747717e-02f, 8.69079083e-02f, -3.40236314e-02f,
  6.00588880e-02f, -1.06987534e-02f, -1.87439591e-01f, -4.16508038e-03f, 1.75824407e-02f, 6.77479506e-02f, -4.55861688e-02f, 1.24863282e-01f, -1.87211514e-01f, -1.98372863e-02f,
  4.44957614e-02f, -1.31409034e-01f, -1.01099554e-02f, -8.26048180e-02f, 3.63109186e-02f, 5.37806302e-02f, 7.85128027e-03f, 2.19820719e-02f, 8.03223848e-02f, -8.42680037e-02f,
  -5.47247473e-03f, -4.61268947e-02f, 1.88727811e-01f, 2.19896045e-02f, 7.13099726e-03f, -3.88130993e-02f, -6.06645197e-02f, -6.35006279e-02f, -4.27571796e-02f, -7.73068443e-02f,
  -6.59004524e-02f, 8.73133615e-02f, 2.40181088e-02f, 1.35487765e-01f, 2.58668453e-01f, -3.50604355e-02f, -1.16478272e-01f, 1.92112520e-01f, 3.44951674e-02f, -1.32736355e-01f,
  7.32870102e-02f, 4.17761505e-02f, -6.25620931e-02f, 1.71533898e-01f, -7.11259171e-02f, 1.68667033e-01f, 4.22864780e-03f, -7.13133663e-02f, -6.92719221e-02f, -1.34540666e-02f,
  8.98320526e-02f, -7.86334127e-02f, 2.73139998e-02f, -1.28214985e-01f, -1.69169549e-02f, 1.20141208e-01f, -1.04889877e-01f, 3.55689973e-02f, -3.23427916e-02f, -1.37840629e-01f,
  -7.03907385e-02f, 4.44284789e-02f, 5.74451797e-02f, 2.26502940e-02f, -3.53336930e-02f, 3.24276313e-02f, 6.54463246e-02f, 1.30866468e-02f, 7.01770633e-02f, -6.70957863e-02f,
  -1.40992552e-01f, -9.91464853e-02f, 9.26086903e-02f, 4.07158025e-02f, -1.02821760e-01f, -2.41330881e-02f, -4.40320186e-02f, 7.13183209e-02f, 1.63759384e-02f, 1.82807650e-02f,
  -5.25856093e-02f, 9.48405340e-02f, 1.50756150e-01f, -1.97764814e-01f, -5.54591715e-02f, 6.07567988e-02f, -2.51273870e-01f, 6.01846585e-03f, 8.33505839e-02f, 1.56875938e-01f,
  -2.13387117e-01f, 1.38048545e-01f, 7.31299073e-02f, 1.41101152e-01f, -1.81424916e-01f, 4.73605804e-02f, 1.29849866e-01f, 3.99033427e-02f, -1.47022918e-01f, 2.59612322e-01f,
  5.84013276e-02f, -1.83611736e-01f, -1.08381808e-02f, -9.78652108e-03f, 7.56703690e-02f, 5.34000099e-02f, 2.31966481e-01f, -4.53568250e-02f, 2.27034196e-01f, -1.49528205e-01f,
  9.32244807e-02f, 1.63272277e-01f, 1.24990381e-01f, 2.03031525e-01f, -2.43939506e-03f, -2.11546291e-02f, 3.70364566e-03f, 2.05047339e-01f, -2.69345585e-02f, -1.70183182e-01f,
  2.00461775e-01f, -5.17605506e-02f, -2.25023739e-02f, 2.32094541e-01f, 1.67100415e-01f, 5.60904332e-02f, 2.21652910e-02f, -2.99645476e-02f, 1.11271933e-01f, 8.92206747e-03f,
  2.89719719e-02f, 8.29746500e-02f, -2.13250816e-02f, 1.01026386e-01f, -4.40321676e-02f, 6.68283701e-02f, 8.27289298e-02f, 1.21127725e-01f, -6.46668896e-02f, 7.95476213e-02f,
  -5.08673815e-03f, -2.12011456e-01f, 1.88494936e-01f, 1.88723221e-01f, 2.30839034e-03f, 3.36273434e-03f, 2.77956963e-01f, -1.32710189e-01f, -6.89322129e-02f, -6.60814270e-02f,
  -3.79463956e-02f, -1.40736997e-01f, 2.08493963e-01f, -6.87195882e-02f, 4.40049469e-02f, -9.57731437e-03f, 6.58315346e-02f, 4.00199741e-03f, 1.73601419e-01f, -1.95039939e-02f,
  -9.34313796e-03f, -1.87478557e-01f, 1.20147496e-01f, -1.85927451e-02f, -1.01081751e-01f, -8.36404040e-02f, 4.88984697e-02f, 7.68291131e-02f, -1.07719963e-02f, -5.99652417e-02f,
  -1.96579602e-02f, 1.16541281e-01f, -1.91792585e-02f, 1.10395484e-01f, 1.49067506e-01f, -1.13966152e-01f, -5.18186837e-02f, -8.09379816e-02f, -1.47788692e-02f, 1.17061563e-01f,
  -1.78138569e-01f, -2.81183213e-01f, -6.14607148e-02f, 2.00611696e-01f, -2.82513440e-01f, 1.23482287e-01f, 1.33625701e-01f, 4.70797084e-02f, -1.11908719e-01f, -3.77794914e-02f,
  7.33774751e-02f, 7.74998739e-02f, 1.64842963e-01f, 1.10744433e-02f, 8.51104036e-02f, 5.17677255e-02f, -8.64742398e-02f, 9.29187536e-02f, -7.33678490e-02f, 6.08256124e-02f,
  -4.65028696e-02f, 9.11502764e-02f, 1.63812637e-02f, -1.92661844e-02f, -1.68848615e-02f, 5.00826351e-02f, 5.14681190e-02f, 8.55076090e-02f, -1.51260570e-01f, -6.44328594e-02f,
  3.96996439e-02f, -2.16302369e-02f, -7.29093105e-02f, -2.94849910e-02f, 8.00174549e-02f, 2.74681542e-02f, 1.00075707e-01f, -1.20793603e-01f, 5.57879964e-03f, -2.61433236e-02f,
  2.74299756e-02f, 3.56229171e-02f, -2.16279421e-02f, -1.24489898e-02f, -3.22775985e-03f, 8.60522166e-02f, 1.18452989e-01f, -1.17954321e-01f, -9.28167626e-02f, 1.30928293e-01f,
  1.14148289e-01f, -2.85972804e-02f, -6.84054196e-02f, -1.10938936e-01f, -9.27168690e-03f, -2.01363117e-02f, 7.80825838e-02f, -2.76406948e-02f, 2.60986537e-02f, -2.60392632e-02f,
  1.88303530e-01f, -2.94259731e-02f, -8.17320496e-02f, -3.21915634e-02f, -8.56272057e-02f, 1.69703677e-01f, 3.37808467e-02f, 6.53758273e-02f, -7.11121783e-02f, 9.22120810e-02f,
  -2.04008445e-01f, 5.81436455e-02f, -1.08634368e-01f, -9.29010808e-02f, 8.37292373e-02f, -4.41804715e-02f, -2.45808326e-02f, 6.64244667e-02f, -1.35657027e-01f, 2.55646221e-02f,
  1.51725635e-02f, 7.90438205e-02f, -2.27413177e-02f, 1.06240120e-02f, -8.33777594e-04f, 5.65504543e-02f, 2.65059248e-03f, -9.71193239e-02f, -1.01407617e-01f, 1.68860108e-01f,
  1.07472524e-01f, 9.23788920e-02f, -4.35811505e-02f, -6.16556890e-02f, 1.07178695e-01f, -1.70334458e-01f, 4.96746860e-02f, -7.17823282e-02f, 2.31511593e-01f, 2.16673128e-02f,
  1.95245162e-01f, -1.46927536e-01f, -5.44708222e-02f, -1.15681648e-01f, -8.24623555e-02f, -7.53956139e-02f, -2.30639689e-02f, -7.13154525e-02f, -3.68627049e-02f, -5.02224490e-02f,
  2.07097769e-01f, -1.19462460e-01f, -9.71236154e-02f, 7.29025900e-02f, 1.32383317e-01f, -9.85872447e-02f, 2.47106068e-02f, -1.05205143e-03f, -1.06253706e-01f, 3.58450934e-02f,
  3.62952873e-02f, 9.43245292e-02f, 7.46970326e-02f, 1.94855034e-02f, 3.83948795e-02f, -9.10510942e-02f, 5.96492812e-02f, -1.49746714e-02f, -7.70991817e-02f, 1.68960661e-01f,
  7.42339343e-02f, -1.64440069e-02f, -4.05643359e-02f, -3.28825489e-02f, -1.26047090e-01f, -1.41218692e-01f, -6.53530434e-02f, 1.28160678e-02f, -4.87636067e-02f, 3.17074396e-02f,
  7.34058172e-02f, 7.68431053e-02f, 2.04641894e-01f, 8.70281234e-02f, -2.00022444e-01f, 4.35097190e-03f, 1.15926325e-01f, 2.13780217e-02f, 8.70825872e-02f, -1.36115626e-01f,
  8.53884220e-02f, 1.23902984e-01f, 2.22502738e-01f, -1.58705384e-01f, 1.73764348e-01f, 1.36402110e-02f, -1.94421411e-01f, -8.32684524e-03f, 1.47133032e-02f, 6.74825981e-02f,
  -1.99292257e-01f, 1.61519013e-02f, -1.42409205e-01f, -9.44178551e-02f, 2.51081556e-01f, -3.54155637e-02f, 1.04058743e-01f, 1.12721594e-02f, 1.16013385e-01f, 2.53063232e-01f,
  1.82403415e-01f, -5.94737716e-02f, 1.22207142e-01f, -4.14936692e-02f, -1.90535933e-01f, -8.71901512e-02f, 1.55920699e-01f, -3.05233654e-02f, -1.43066704e-01f, 2.97938623e-02f,
  3.35372835e-02f, -1.71210945e-01f, 8.78540650e-02f, 1.26234561e-01f, -3.66099179e-02f, 6.30432218e-02f, -1.54460505e-01f, 2.07838297e-01f, 2.30510339e-01f, 2.36833751e-01f,
  -1.02666587e-01f, -1.98368430e-02f, -6.10499233e-02f, -2.42643356e-01f, -6.97504506e-02f, -1.48460850e-01f, -1.76608369e-01f, 1.72406524e-01f, -4.07768525e-02f, 1.46973997e-01f,
  1.28905877e-01f, -5.83343059e-02f, 8.19911063e-02f, 1.40785143e-01f, 8.94601271e-02f, 4.95351478e-02f, -4.12927270e-02f, 1.17312651e-02f, -5.59367575e-02f, -1.50157735e-02f,
  -1.56015545e-01f, -1.55633390e-02f, 1.95201129e-01f, 7.67409708e-03f, 1.77076235e-02f, -3.25717889e-02f, -6.46592379e-02f, 6.59750104e-02f, 1.89653888e-01f, -1.56731997e-02f,
  -9.43451151e-02f, -2.04036236e-02f, -1.51582044e-02f, -3.57500836e-02f, 1.07441712e-02f, -1.10221803e-01f, -1.83223411e-02f, -1.33007005e-01f, 1.93564847e-01f, -1.84214652e-01f,
  -4.17583771e-02f, -1.18651120e-02f, -1.57083161e-02f, -6.54083118e-02f, -1.96070336e-02f, -1.10100694e-01f, -8.01213011e-02f, -7.20996857e-02f, -1.47639047e-02f, 7.07704807e-03f,
  -2.86790747e-02f, -5.27876429e-02f, 2.38016576e-01f, -4.95402105e-02f, -5.95360734e-02f, -6.27110749e-02f, -8.63228291e-02f, -4.37847413e-02f, 2.14014590e-01f, -2.06012707e-02f,
  1.02813803e-01f, 2.42541097e-02f, 6.40147403e-02f, -4.51569706e-02f, -3.46608981e-02f, 3.36957797e-02f, -1.36584803e-01f, 2.62353778e-01f, 2.19248957e-03f, -2.23260280e-02f,
  7.44596422e-02f, 5.50736710e-02f, -8.89485702e-02f, -1.37441205e-02f, -9.28077027e-02f, 2.56299420e-04f, 1.04975708e-01f, 1.02767937e-01f, 3.28774750e-02f, 3.21974084e-02f,
  2.35646553e-02f, 8.08194503e-02f, 5.62621169e-02f, 2.10985858e-02f, -1.21515729e-01f, 8.78726617e-02f, 1.04694769e-01f, 1.31652787e-01f, -1.60480458e-02f, -7.31403455e-02f,
  -1.13806762e-01f, 1.21809781e-01f, 6.41002432e-02f, 1.86445609e-01f, -4.85323668e-02f, -3.71026658e-02f, 9.51900259e-02f, -9.02140886e-02f, 2.59876791e-02f, -4.54489700e-02f,
  7.26884604e-02f, 7.53172636e-02f, 3.01094633e-02f, -1.46886170e-01f, -1.07308269e-01f, -2.80361362e-02f, 1.01235090e-02f, -1.36454478e-01f, 6.24664081e-03f, -6.03287779e-02f,
  -6.75119087e-02f, -2.65444554e-02f, 1.28950000e-01f, -6.52638599e-02f, -1.70979232e-01f, 1.71581089e-01f, 1.23407535e-01f, -5.08118086e-02f, -2.46053282e-02f, -1.34174293e-02f,
  -3.78549546e-02f, -2.92217676e-02f, 6.13920726e-02f, -5.94331995e-02f, 5.80261126e-02f, -1.93196181e-02f, 4.56053056e-02f, -1.03097983e-01f, -5.03791608e-02f, 7.36275092e-02f,
  -8.04038346e-02f, 9.81168523e-02f, 8.44042450e-02f, 1.22734316e-01f, 5.21028088e-03f, 1.21774599e-01f, -7.07316697e-02f, -5.96535541e-02f, -1.68895543e-01f, -2.11662482e-02f,
  -9.62518994e-03f, 3.62720266e-02f, 5.13981506e-02f, 3.00626904e-02f, 6.45007491e-02f, 1.78166315e-01f, -6.14824481e-02f, 1.22781605e-01f, 1.20461937e-02f, 7.16702789e-02f,
  -4.36537564e-02f, 7.84645379e-02f, 3.72617170e-02f, 7.19799846e-02f, 1.74980126e-02f, -7.67418742e-02f, 1.35907903e-01f, 1.62209123e-01f, -2.04383992e-02f, -7.01147392e-02f,
  1.41010240e-01f, 2.81738155e-02f, -2.13044174e-02f, -4.26035114e-02f, 4.52942029e-02f, 1.69213600e-02f, 1.28028631e-01f, -2.42842305e-02f, 1.02415644e-01f, -6.26214594e-02f,
  1.99706834e-02f, -3.71499024e-02f, 1.71069637e-01f, -6.16392829e-02f, -1.05109639e-01f, 7.26755559e-02f, 1.42647415e-01f, -5.39193973e-02f, -9.11780521e-02f, 7.58828521e-02f,
  7.18683377e-02f, 5.82879931e-02f, -7.14138225e-02f, -9.52453166e-02f, -4.81574312e-02f, -3.26777361e-02f, 1.78439228e-03f, 3.65099907e-02f, -6.51957616e-02f, -1.43983066e-01f,
  -2.46939808e-03f, -1.12316437e-01f, -5.14075756e-02f, 8.59858170e-02f, -1.31775990e-01f, -1.83077022e-01f, -1.26709156e-02f, 1.75426871e-01f, -1.75506473e-01f, 2.08178714e-01f,
  -7.29183387e-03f, -8.65435600e-02f, -1.16600938e-01f, -4.17549945e-02f, -4.16864157e-02f, 6.72599524e-02f, 2.55589699e-03f, 3.73129584e-02f, 1.60553142e-01f, 1.38262823e-01f,
  -1.53144255e-01f, 4.78557944e-02f, 3.53176072e-02f, 6.29836768e-02f, 9.67280567e-02f, 6.99209571e-02f, 1.21077806e-01f, 1.37047201e-01f, 8.52779299e-02f, -1.83874637e-01f,
  -1.44011211e-02f, -3.05653904e-02f, -6.90680444e-02f, -2.04521213e-02f, -1.28428057e-01f, 3.42971534e-02f, 2.09386908e-02f, -1.97256412e-02f, 4.21813689e-02f, 3.54773290e-02f,
  6.91157952e-02f, 9.66400653e-02f, 4.64294516e-02f, -8.83776918e-02f, 6.84860675e-03f, 1.81507483e-01f, 1.62386686e-01f, -5.33514470e-02f, 1.21601801e-02f, -2.13335268e-02f,
  -7.38310441e-02f, 5.02343439e-02f, 1.61089860e-02f, 4.29350659e-02f, -1.76731527e-01f, 9.35864002e-02f, -4.77169529e-02f, -1.22007646e-01f, 2.41094772e-02f, 7.33760819e-02f,
  -1.06625967e-02f, 1.28902048e-01f, 4.24747393e-02f, 9.98178348e-02f, 4.32100426e-03f, 6.37483317e-03f, -6.28797784e-02f, 1.49497703e-01f, 8.91504213e-02f, -1.41045406e-01f,
  1.17077820e-01f, -4.49403748e-02f, -1.04966238e-01f, 1.29055545e-01f, 1.09372519e-01f, 2.82619242e-02f, -3.78957018e-02f, -8.58936533e-02f, 6.40176982e-02f, 4.03851416e-04f,
  9.18611214e-02f, 1.19876400e-01f, 2.88319774e-03f, 2.06556275e-01f, -1.12650609e-02f, 7.36012235e-02f, -1.77397251e-01f, 1.04571171e-01f, 9.37521458e-02f, 2.42261320e-01f,
  1.24575935e-01f, -1.34897873e-01f, -2.03592643e-01f, 1.56389400e-01f, -1.04030180e-04f, 1.43126911e-02f, -1.42326504e-01f, -5.75584657e-02f, -1.27116188e-01f, -1.12969831e-01f,
  -2.22814754e-02f, -1.48895001e-02f, 1.53364792e-01f, 1.79701686e-01f, -2.84390361e-03f, -7.79994801e-02f, -6.69179186e-02f, -8.06736052e-02f, -7.92653859e-02f, -1.56377643e-01f,
  5.82048520e-02f, -4.47311476e-02f, -1.71667319e-02f, 8.83283839e-02f, 1.95803836e-01f, 4.75721620e-02f, -2.10159734e-01f, 1.84584737e-01f, 5.30587547e-02f, -3.37041356e-02f,
  -5.46793528e-02f, 5.60432673e-03f, -6.70183524e-02f, -1.47071749e-01f, 2.53774915e-02f, -1.09821565e-01f, 1.39323026e-02f, -3.70920599e-02f, 2.76749916e-02f, -7.21399635e-02f,
  -3.76918688e-02f, 2.30142437e-02f, -5.51283211e-02f, 2.21182898e-01f, 1.72544137e-01f, 8.75621662e-02f, 3.60825509e-02f, -5.35631031e-02f, -6.73655346e-02f, -9.83982533e-02f,
  -1.11767955e-01f, -5.04883379e-02f, 1.38934582e-01f, -2.19687298e-02f, 4.88199219e-02f, 1.69670042e-02f, 4.02500406e-02f, -3.73195275e-03f, -7.83483163e-02f, 1.15042357e-02f,
  1.02048576e-01f, 8.59722048e-02f, -1.19318858e-01f, -7.64601082e-02f, 2.23852977e-01f, 1.13669530e-01f, 5.84827326e-02f, 5.20213060e-02f, -1.89965665e-01f, 4.16822470e-04f,
  -5.35654351e-02f, -7.30480105e-02f, -1.43291697e-01f, 1.38900295e-01f, 7.49231875e-03f, 7.82814547e-02f, 2.63821095e-01f, 1.37878627e-01f, -3.87276374e-02f, 5.49612492e-02f,
  1.33472547e-01f, -7.05602318e-02f, -7.34029636e-02f, 1.26244366e-01f, 1.94126710e-01f, -3.15627689e-03f, -2.12573092e-02f, 2.07618445e-01f, 1.08706519e-01f, 7.09485030e-03f,
  2.74276156e-02f, 2.65623212e-01f, -1.83100477e-01f, 1.57025665e-01f, 8.56412575e-03f, -5.49167097e-02f, -6.89577870e-03f, 3.77539247e-02f, -1.41100124e-01f, 9.20231640e-02f,
  4.97551262e-03f, -7.00914487e-03f, 8.13937187e-02f, 4.51922826e-02f, -9.27411616e-02f, 1.32766217e-01f, 1.41671658e-01f, 1.04300261e-01f, 1.11296922e-01f, -9.54985525e-03f,
  5.31778298e-02f, 1.12543195e-01f, 5.81951737e-02f, -1.02059603e-01f, -8.85799155e-02f, -7.84679204e-02f, 1.79188959e-02f, 1.55644313e-01f, 1.40560195e-01f, 3.94837782e-02f,
  1.95773855e-01f, 1.50440514e-01f, -6.16687387e-02f, 6.50544018e-02f, 5.29893823e-02f, 1.02528058e-01f, 2.96586990e-01f, 1.07570127e-01f, -9.52327624e-03f, 1.71353981e-01f,
  6.41378760e-02f, 5.13955019e-02f, -2.06974417e-01f, -2.81953532e-03f, -2.36130938e-01f, -1.76859256e-02f, -1.23337634e-01f, 4.71780673e-02f, -5.07798679e-02f, 3.70184593e-02f,
  4.44706716e-02f, 8.62407535e-02f, 1.20470136e-01f, 1.27197787e-01f, 2.35174838e-02f, -6.62567690e-02f, -5.21568432e-02f, 2.24371068e-02f, 4.79882136e-02f, 3.82097997e-02f,
  -9.90362391e-02f, 5.05726747e-02f, -4.14431766e-02f, 1.96323227e-02f, -7.30153322e-02f, -1.15090664e-02f, -6.87152743e-02f, 2.27088388e-02f, -1.27514258e-01f, -1.23269655e-01f,
  1.60923915e-03f, -1.67684183e-02f, 1.63591027e-01f, -1.49179384e-01f, 6.05941489e-02f, 2.35228300e-01f, 2.20259666e-01f, 1.03080593e-01f, -1.01072989e-01f, 1.24185301e-01f,
  1.27761528e-01f, 3.28291625e-01f, 1.52547881e-01f, -1.41260937e-01f, 2.30527908e-01f, -4.26230729e-02f, -1.31955668e-01f, 5.26481830e-02f, 2.35356599e-01f, -2.21388061e-02f,
  -1.65106788e-01f, 1.52347321e-02f, -1.55794457e-01f, -1.27404360e-02f, 2.12178566e-02f, 2.00368781e-02f, -1.92250267e-01f, -3.84707563e-02f, 1.38066962e-01f, -7.56040215e-02f,
  -1.28972709e-01f, 5.26370816e-02f, 1.98439330e-01f, 1.45932764e-01f, 4.79132123e-02f, -6.16297312e-02f, -1.37809977e-01f, -1.34126380e-01f, 3.03066615e-02f, -6.93705380e-02f,
  -9.06105265e-02f, 8.82648379e-02f, 5.92300184e-02f, 7.03696609e-02f, -3.50411274e-02f, -3.89629528e-02f, -1.03117943e-01f, 1.30390018e-01f, 1.69678271e-01f, 5.37398225e-03f,
  -3.28453556e-02f, 1.12793773e-01f, 1.52011946e-01f, -6.41969964e-02f, -1.01247057e-01f, 5.77656105e-02f, -1.97005317e-01f, -1.26643434e-01f, 1.82412252e-01f, 7.93232620e-02f,
  -1.49196908e-01f, 1.81387514e-01f, -4.18684706e-02f, -3.25854719e-02f, 6.92203790e-02f, -1.47363609e-02f, -1.28910672e-02f, 8.96311253e-02f, -4.15595844e-02f, 7.60138500e-04f,
  6.51693568e-02f, 9.38768014e-02f, -4.06865105e-02f, 1.03844658e-01f, -7.97897875e-02f, -1.00607082e-01f, 2.76572257e-02f, -3.91286649e-02f, -3.02811805e-02f, 1.54327899e-01f,
  2.04909712e-01f, -1.47630339e-02f, 4.29654727e-03f, -3.32470946e-02f, 6.88015968e-02f, 1.28839687e-01f, 1.74052849e-01f, 1.57253608e-01f, 1.89654469e-01f, 1.82305232e-01f,
  1.23894382e-02f, 1.35435358e-01f, -5.14063276e-02f, -1.61957771e-01f, -2.43164357e-02f, 2.07094684e-01f, 4.17309552e-02f, -1.53158963e-01f, -1.40720293e-01f, 8.89648050e-02f,
  -1.37131095e-01f, 2.06250548e-01f, -1.21302187e-01f, 4.66906242e-02f, 9.21947211e-02f, -4.42994535e-02f, -1.08385213e-01f, 1.07649833e-01f, 1.31971493e-01f, 2.11637989e-01f,
  -3.38974804e-01f, 1.76233500e-01f, -1.29346997e-01f, 2.16717184e-01f, 1.13492273e-01f, 1.01765906e-02f, 7.81966466e-03f, 1.61175013e-01f, -3.79653126e-02f, 1.75218493e-01f,
  1.70303792e-01f, 1.23412751e-01f, -2.31845692e-01f, 1.85728341e-01f, -1.33787230e-01f, 3.29157291e-03f, -1.45843774e-01f, -4.10077944e-02f, 1.97683707e-01f, -1.63493574e-01f,
  2.23253388e-02f, -2.17948392e-01f, -2.65203118e-02f, 3.67892757e-02f, 2.21185893e-01f, -1.91584751e-01f, -1.16171658e-01f, 1.10484004e-01f, 1.06363585e-02f, 3.52555024e-03f,
  2.54874565e-02f, 1.48391053e-01f, 2.58856237e-01f, 6.49261773e-02f, 5.67457378e-02f, 2.24616975e-01f, -1.50468498e-01f, -6.26021624e-03f, 5.58441989e-02f, 5.27453385e-02f,
  -5.35486192e-02f, -3.82307880e-02f, -2.95662284e-02f, -2.19557178e-03f, -5.47104701e-02f, -5.44571988e-02f, 1.70061916e-01f, 9.98515859e-02f, -1.52445167e-01f, -2.05864936e-01f,
  -3.23727191e-03f, 8.02998692e-02f, 1.32356957e-01f, -1.60790965e-01f, -1.89449242e-03f, -2.40133516e-02f, -1.89710528e-01f, 1.29237726e-01f, 8.44213888e-02f, 2.39750333e-02f,
  -9.37303528e-02f, 5.61595932e-02f, 8.08819085e-02f, 5.70201278e-02f, 1.63180381e-01f, 3.85876894e-02f, 9.75934416e-02f, -9.74375531e-02f, 2.88795102e-02f, 2.23078191e-01f,
  6.01340309e-02f, 8.75616074e-02f, 8.59318301e-02f, 7.79054314e-02f, 9.41444039e-02f, 3.74898277e-02f, 1.87025499e-02f, 7.09888935e-02f, -5.60320951e-02f, -6.55068979e-02f,
  9.28199738e-02f, -1.35250658e-01f, 6.10976890e-02f, 1.63905516e-01f, -6.12077340e-02f, 1.29038319e-01f, -1.53500497e-01f, 1.79220870e-01f, 7.08821937e-02f, 1.36215925e-01f,
  3.87178622e-02f, -9.58364010e-02f, 9.80721563e-02f, -4.97337915e-02f, -7.11453706e-02f, -6.35464266e-02f, -2.93139238e-02f, 8.09646919e-02f, -1.65679693e-01f, 6.78486526e-02f,
  1.68035179e-01f, -8.57508108e-02f, 8.33753273e-02f, 4.34975736e-02f, 2.24103183e-02f, 6.08219802e-02f, 1.38757735e-01f, -1.74577795e-02f, -1.05510363e-02f, -2.43027546e-02f,
  -5.72306849e-02f, -1.29294470e-01f, -2.95875799e-02f, 4.40306589e-02f, -6.07011765e-02f, -8.37224722e-02f, -5.90988109e-03f, 6.56473115e-02f, -8.44369531e-02f, 1.15263894e-01f,
  6.92917258e-02f, 1.06760420e-01f, 1.80155262e-01f, -6.50449991e-02f, -1.36046231e-01f, 5.89860715e-02f, -7.98257738e-02f, -6.67812452e-02f, -1.62228823e-01f, 5.07075638e-02f,
  -8.35515708e-02f, 2.02391267e-01f, 8.98847058e-02f, 3.36435474e-02f, -6.04417995e-02f, 2.87759211e-02f, 7.38876238e-02f, -1.99531689e-02f, -6.53257445e-02f, 1.59916446e-01f,
  3.76806371e-02f, -5.15764803e-02f, -2.96991765e-02f, -2.50784699e-02f, 9.70369671e-03f, 9.05594155e-02f, 1.31820500e-01f, -5.05373999e-02f, 1.02033384e-01f, -1.28139958e-01f,
  2.09397469e-02f, 9.79874134e-02f, 1.34866774e-01f, 5.73624447e-02f, -8.98407325e-02f, 2.08543856e-02f, -7.51962513e-02f, -1.75554026e-02f, -2.01469641e-02f, -3.28649692e-02f,
  2.25333646e-02f, -3.27795036e-02f, 2.92025190e-02f, 1.90487072e-01f, -2.45367829e-02f, 7.80429244e-02f, -1.26766711e-01f, -4.83049825e-02f, -1.28222167e-01f, 7.93439895e-02f,
  1.18820623e-01f, 8.43136311e-02f, -7.54395053e-02f, -6.66378811e-02f, 2.93276291e-02f, 1.54735800e-02f, -6.10825233e-03f, 1.01902679e-01f, 1.94466248e-01f, 1.02772497e-01f,
  9.91278142e-02f, 9.17062461e-02f, -1.54689163e-01f, 5.22735044e-02f, 8.78600776e-02f, -9.95668489e-03f, -1.10246047e-01f, 1.72901765e-01f, 1.97617203e-01f, 3.06201074e-02f,
  -1.91205498e-02f, 2.09923252e-01f, -1.66575119e-01f, 1.00225750e-02f, 1.38128474e-01f, 8.68723914e-02f, -1.07512519e-01f, -1.12739988e-01f, 1.20567717e-01f, -1.37403831e-01f,
  -6.54997304e-02f, 8.57779309e-02f, -1.74036726e-01f, -9.32425708e-02f, 1.53691635e-01f, 1.20525822e-01f, -3.36365551e-02f, 1.79768741e-01f, -2.41173413e-02f, 6.85611442e-02f,
  5.42422757e-02f, -1.01749822e-01f, 1.79558516e-01f, -7.41392225e-02f, 1.56774640e-01f, -1.49994284e-01f, -8.16505402e-02f, 5.15990239e-03f, -1.35601744e-01f, 6.98875040e-02f,
  -3.33626457e-02f, -2.17669960e-02f, 1.69639722e-01f, 1.52281061e-01f, -5.43043874e-02f, 1.65370718e-01f, 2.09461272e-01f, -1.33127138e-01f, -1.04334420e-02f, 1.56883914e-02f,
  6.73015416e-02f, -2.87117995e-02f, 3.35607976e-02f, 8.07735603e-03f, -2.61643231e-01f, -5.60123622e-02f, 1.00305323e-02f, 4.73937355e-02f, 6.18202947e-02f, 8.33497271e-02f,
  -2.64055133e-01f, -1.97373375e-01f, -1.29418120e-01f, -2.15036124e-01f, 4.81328480e-02f, -2.86751986e-03f, 8.54333118e-02f, 9.08952281e-02f, 4.41768356e-02f, 7.76939318e-02f,
  1.84255004e-01f, -1.54210404e-01f, -2.09793169e-02f, 3.38249467e-02f, 2.12630451e-01f, -1.53776277e-02f, 1.03219323e-01f, 3.47268768e-02f, -1.10442014e-02f, -4.24625874e-02f,
  -2.33379211e-02f, 1.07386924e-01f, -4.17018076e-03f, 1.11499675e-01f, 9.54204649e-02f, 3.52739170e-02f, 2.17876345e-01f, -3.88249345e-02f, -9.69693717e-03f, 9.13966000e-02f,
  6.02672696e-02f, -1.91736907e-01f, 1.12924531e-01f, 7.22642466e-02f, 2.91838534e-02f, 1.67578712e-01f, -1.51527330e-01f, 8.99221525e-02f, -1.26330137e-01f, -8.85845274e-02f,
  -5.97547665e-02f, 8.60229041e-03f, 1.20196953e-01f, -2.21316934e-01f, -3.36139649e-03f, -1.40419111e-01f, 3.13359685e-02f, 2.84416676e-02f, -1.69480473e-01f, 2.94904858e-02f,
  1.09788571e-02f, -5.91683015e-02f, -6.30560145e-02f, 2.05424521e-02f, -5.92339672e-02f, -7.57604688e-02f, 3.16989459e-02f, 8.72502923e-02f, -1.23852946e-01f, 1.75922699e-02f,
  2.64973566e-02f, 3.71408537e-02f, -1.04926258e-01f, 5.88482320e-02f, 2.72220094e-03f, 6.62268996e-02f, -1.12766847e-01f, -3.41914780e-02f, -4.12942544e-02f, 5.61937355e-02f,
  2.49426588e-01f, 2.18145028e-01f, 1.62262231e-01f, -5.13876155e-02f, 3.13891709e-01f, -8.12128484e-02f, 2.93532182e-02f, -2.83967629e-02f, 7.08894047e-04f, -1.84607357e-01f,
  1.48234040e-01f, -9.17071402e-02f, 6.12806045e-02f, 1.30621335e-02f, 4.88304943e-02f, -5.80040850e-02f, -3.90070975e-02f, -5.05945235e-02f, -2.44104303e-02f, -1.03536330e-01f,
  3.57844271e-02f, -8.21807310e-02f, -8.99568899e-04f, -4.30828743e-02f, 2.10239291e-01f, -5.18869013e-02f, 9.33222547e-02f, 1.58245917e-02f, -2.52688415e-02f, 6.85523674e-02f,
  4.40049097e-02f, 2.23178677e-02f, 1.18257068e-01f, -1.24998428e-01f, 4.06049825e-02f, -2.14863643e-02f, -1.20649720e-02f, -5.03973812e-02f, -1.48370892e-01f, 3.91654931e-02f,
  6.91262260e-02f, 1.75242499e-01f, -9.47821364e-02f, -1.69719495e-02f, 9.73826647e-02f, -2.13800650e-03f, -4.86789607e-02f, 3.83098386e-02f, 1.52167976e-01f, 5.61597310e-02f,
  1.54165015e-01f, 1.17969923e-01f, 2.40309015e-01f, 2.23091021e-01f, -3.16656269e-02f, 1.00253098e-01f, -5.10689691e-02f, 3.99045385e-02f, 3.32590073e-01f, 1.90456316e-01f,
  -3.99116054e-02f, -3.59522291e-02f, -1.83400437e-01f, 3.81418392e-02f, -4.36302908e-02f, 1.48432195e-01f, -2.17858076e-01f, -1.25215366e-01f, -4.81261015e-02f, -1.01475455e-01f,
  -5.01806401e-02f, -1.06312027e-02f, -2.11263653e-02f, -2.73025464e-02f, 8.98490772e-02f, 1.18838042e-01f, -1.18255563e-01f, -7.44418651e-02f, -3.73412413e-03f, -6.89316839e-02f,
  7.06508458e-02f, 4.04714830e-02f, -4.14267816e-02f, -2.88191764e-03f, 8.40931460e-02f, 1.59252331e-01f, -2.31478229e-01f, 9.47896764e-02f, -1.76010542e-02f, 3.70474793e-02f,
  -1.94176868e-01f, -1.60763949e-01f, 4.01945524e-02f, -1.13624759e-01f, 1.69756129e-01f, -1.56946540e-01f, 9.40688699e-02f, 1.52439609e-01f, 2.51206547e-01f, -8.97176862e-02f,
  -1.79884031e-01f, 1.63440213e-01f, 4.24919985e-02f, 2.92830408e-01f, 1.39453322e-01f, -5.53746298e-02f, 1.87758088e-01f, 5.77226132e-02f, -1.77673288e-02f, 1.05925120e-01f,
  -6.94472715e-02f, -6.00237884e-02f, -1.57449488e-02f, 8.77272617e-03f, -6.11238517e-02f, -7.12067112e-02f, 5.02099805e-02f, 2.01962534e-02f, -1.08059838e-01f, -1.18193869e-02f,
  -4.15443294e-02f, 1.69448271e-01f, 1.35018855e-01f, -9.96656567e-02f, 1.42958120e-01f, 3.05349946e-01f, 4.61020991e-02f, -2.05667257e-01f, 1.96126759e-01f, -3.86326090e-02f,
  3.47731486e-02f, -6.55794218e-02f, -1.08207926e-01f, 1.67568207e-01f, -1.29023073e-02f, -6.94201142e-02f, -2.71938834e-02f, -1.30745009e-01f, 2.14148551e-01f, -4.50829975e-02f,
  1.17243260e-01f, -6.98657781e-02f, -3.78166027e-02f, 7.97889568e-03f, 2.13257879e-01f, -1.38767213e-01f, -9.63314846e-02f, -1.48259491e-01f, -1.18236065e-01f, -1.11907877e-01f,
  1.22045621e-01f, -1.45016909e-02f, -7.62205645e-02f, 1.62339374e-01f, -7.41992295e-02f, -7.49901086e-02f, -3.16115506e-02f, 1.51508644e-01f, 2.53906362e-02f, 4.84981425e-02f,
  5.77333458e-02f, -3.29874083e-02f, 4.16688286e-02f, 5.10123558e-02f, -1.03216665e-03f, 1.38753369e-01f, -6.57251552e-02f, -9.47389603e-02f, -4.81961519e-02f, -8.68749171e-02f,
  -1.17400162e-01f, 2.48325467e-01f, 5.11663295e-02f, -3.06855366e-02f, 2.48319730e-02f, -4.41213064e-02f, -9.19307098e-02f, 9.86278355e-02f, -1.12351514e-01f, 9.21280310e-02f,
  4.79192324e-02f, -1.07355669e-01f, -1.31295487e-01f, -8.06238279e-02f, 1.86939195e-01f, 3.89623456e-02f, -1.72323644e-01f, -2.61644602e-01f, 9.81696174e-02f, 7.44208619e-02f,
  1.83573872e-01f, -1.27910048e-01f, -5.15514053e-02f, -1.17146999e-01f, -9.77986902e-02f, 1.52312204e-01f, -1.29429668e-01f, 1.95656121e-01f, 5.08101238e-03f, -9.17768851e-03f,
  6.01245649e-02f, 8.99345055e-02f, 9.31459293e-02f, 5.35069779e-02f, 5.64410351e-02f, -6.31035417e-02f, -6.14596298e-03f, 1.79226369e-01f, 1.78371385e-01f, 3.33978534e-02f,
  1.78547755e-01f, 1.36005655e-01f, -1.28792956e-01f, 2.01253612e-02f, 1.81949541e-01f, 9.22570303e-02f, -1.50288165e-01f, 5.24674989e-02f, 4.82468009e-02f, -3.62291522e-02f,
  -9.99604817e-03f, 1.61205322e-01f, -3.46701816e-02f, 1.37408718e-01f, -7.17102811e-02f, 1.95672542e-01f, -2.51637027e-02f, 2.12955683e-01f, -2.81383060e-02f, 9.69299152e-02f,
  1.25336781e-01f, -1.92114040e-01f, 1.08780703e-02f, -1.16412066e-01f, -1.40264556e-01f, 4.30232771e-02f, 9.31658596e-02f, 5.19938990e-02f, 1.35227621e-01f, -8.39353874e-02f,
  6.89908192e-02f, 3.48831080e-02f, 2.48522293e-02f, 1.66186720e-01f, -1.43878117e-01f, -5.61190732e-02f, 3.80327404e-02f, -5.48771769e-02f, 9.44690630e-02f, -1.28463998e-01f,
  -2.61843234e-01f, -3.29241715e-02f, -2.77428795e-03f, -1.71554640e-01f, 9.41312462e-02f, 1.34660453e-01f, -8.31244141e-02f, 1.17934786e-01f, 1.25869615e-02f, 1.46825761e-01f,
  1.81875303e-01f, 1.65713727e-02f, -1.18530057e-02f, 2.66047623e-02f, 2.38589108e-01f, 1.21575981e-01f, -1.54177383e-01f, 2.09710196e-01f, -9.74693336e-03f, 7.20654353e-02f,
  3.83993387e-02f, 9.42432433e-02f, 7.11937696e-02f, 1.40133739e-01f, 1.52880639e-01f, 1.23991922e-01f, 1.12489820e-01f, 9.08102021e-02f, 5.33628166e-02f, 1.78801075e-01f,
  -2.38032825e-02f, -2.31676921e-02f, 1.56905740e-01f, 3.10950540e-02f, 5.84687740e-02f, 1.89703941e-01f, 7.31700733e-02f, 1.63068324e-01f, 7.42555261e-02f, 4.80604619e-02f,
  1.90742500e-02f, 1.61965825e-02f, 2.23799888e-02f, -2.17200872e-02f, 1.78026482e-01f, -5.20378426e-02f, -3.21474262e-02f, 4.07806039e-02f, 6.11886717e-02f, 5.94773004e-03f,
  1.16768986e-01f, 5.67465350e-02f, -3.71191651e-02f, -1.32333217e-02f, 5.06528094e-02f, -1.48105742e-02f, 7.01397434e-02f, 6.09781109e-02f, 1.12603642e-01f, 1.04603358e-02f,
  -2.84355823e-02f, -9.15507749e-02f, -4.78473604e-02f, -1.57828465e-01f, -6.08340800e-02f, 1.45474762e-01f, 1.26433996e-02f, -6.29987121e-02f, -1.02638756e-03f, 1.89647395e-02f,
  1.69867724e-01f, 1.01267122e-01f, 2.13035718e-01f, 1.45423174e-01f, 2.13078827e-01f, -1.04084471e-02f, -7.25470036e-02f, 9.81881749e-03f, -1.73261851e-01f, -8.61277431e-02f,
  -2.16205880e-01f, 6.52990118e-02f, -9.16177779e-02f, 2.42127240e-01f, 1.26346186e-01f, 2.60663535e-02f, -2.63027940e-02f, 1.04994357e-01f, 9.16182771e-02f, 5.38091967e-03f,
  -7.89938793e-02f, 1.83260873e-01f, 1.00652561e-01f, -1.61144987e-01f, 1.04576960e-01f, -5.70675917e-02f, 4.67801392e-02f, 1.38989046e-01f, 2.23344848e-01f, -1.15433797e-01f,
  1.77438542e-01f, -6.06620871e-03f, 1.84429526e-01f, -4.47158841e-03f, 9.21512619e-02f, 9.51445699e-02f, -1.07265137e-01f, 8.64362866e-02f, -5.97891621e-02f, -3.09227914e-01f,
  -6.85621053e-02f, 1.91255733e-01f, -1.45420374e-03f, 9.05404836e-02f, 3.47571597e-02f, 1.74666643e-01f, -8.03114101e-02f, 6.47049099e-02f, -3.33538279e-02f, -6.37652874e-02f,
  2.76652426e-02f, -6.66916743e-02f, -3.73882316e-02f, 6.96082786e-02f, 3.89102064e-02f, 1.96682494e-02f, -2.34195832e-02f, 1.43294588e-01f, 1.39363214e-01f, -2.84015536e-02f,
  4.68885079e-02f, 1.13614455e-01f, -3.49068781e-03f, -1.16290696e-01f, 1.41586155e-01f, 1.42106405e-02f, 6.03721850e-02f, -3.18608782e-03f, -4.80077527e-02f, -1.73643418e-02f,
  2.18944196e-02f, -4.84506004e-02f, -6.73889667e-02f, -1.98087454e-01f, 2.37548426e-01f, -1.38754666e-01f, -9.45323613e-03f, -1.21883124e-01f, 9.57311783e-03f, -1.74656976e-02f,
  -2.64499541e-02f, -1.19859286e-01f, -2.51548477e-02f, -1.53762609e-01f, -3.83312888e-02f, -9.52235833e-02f, -3.67383622e-02f, -6.21490963e-02f, 2.67677307e-02f, -3.94034460e-02f,
  -4.32002395e-02f, -4.16423865e-02f, -9.96953472e-02f, -2.02244259e-02f, -1.59452669e-02f, 2.47476287e-02f, 1.32911503e-01f, 1.70406625e-02f, -3.66804861e-02f, -1.17192380e-02f,
  2.20180787e-02f, 8.99361446e-02f, -1.36441365e-01f, -9.68624204e-02f, 3.79089862e-02f, 1.01411916e-01f, -1.16429664e-01f, 1.19331339e-02f, 2.62094568e-02f, -6.74150139e-02f,
  -9.69973020e-03f, -2.66852826e-02f, 2.14116961e-01f, -1.04763347e-03f, 1.10871486e-01f, 4.12700474e-02f, -3.60300615e-02f, -2.24133972e-02f, 5.28006330e-02f, 1.07101738e-01f,
  5.37311751e-03f, 1.44681215e-01f, -1.58168495e-01f, -1.28267571e-01f, 1.01603612e-01f, -8.15072432e-02f, 4.22309572e-03f, -1.35917097e-01f, -6.34855479e-02f, 3.31559293e-02f,
  -1.46826386e-01f, 2.81603746e-02f, 6.54424727e-02f, 3.58207487e-02f, -4.45724698e-03f, 3.68631892e-02f, 2.04478577e-01f, 1.78406343e-01f, 4.79732975e-02f, -3.72047760e-02f,
  6.57385737e-02f, -1.51523086e-03f, -5.00818714e-02f, 1.50666341e-01f, 4.24024127e-02f, 1.36023000e-01f, 9.50974226e-02f, 2.04752952e-01f, 2.14396462e-01f, -1.27799287e-01f,
  -1.12725720e-01f, 2.16222122e-01f, -3.35711986e-02f, -4.66594622e-02f, 3.31141911e-02f, -3.58334891e-02f, 2.30226386e-02f, 2.30119079e-01f, -3.81917097e-02f, 7.26099312e-02f,
  -7.63913020e-02f, -1.17867067e-03f, -2.95385011e-02f, 2.05368903e-02f, -1.75278541e-02f, 2.74001025e-02f, 1.41949877e-01f, -5.73696271e-02f, -7.54035311e-03f, 9.29657817e-02f,
  6.96858242e-02f, 4.65158336e-02f, -1.13189027e-01f, -9.87364165e-03f, -5.85490763e-02f, -8.73336568e-02f, 9.77173746e-02f, 6.03507981e-02f, 3.05174422e-02f, 5.46876714e-02f,
  -2.21754033e-02f, 1.29277140e-01f, 4.75519113e-02f, 4.10195906e-03f, -1.13262624e-01f, -9.81973484e-02f, 2.03856546e-02f, 1.70589864e-01f, -3.91161293e-02f, 7.19173923e-02f,
  6.05603009e-02f, 4.66647148e-02f, 2.15923995e-01f, 8.93871486e-02f, 1.83914542e-01f, 1.42192781e-01f, 2.85157472e-01f, -6.24194629e-02f, 3.63600925e-02f, -1.64389126e-02f,
  -1.73905522e-01f, -2.11224243e-01f, 1.42148510e-01f, 6.65837303e-02f, -4.55920100e-02f, 2.34448239e-01f, 1.41024634e-01f, 5.13948016e-02f, 1.07966274e-01f, -1.95511766e-02f,
  1.48513883e-01f, -8.08436424e-02f, -1.32128403e-01f, 2.00634040e-02f, 9.84252989e-02f, -1.89412236e-01f, 1.60676479e-01f, -2.61367746e-02f, 1.11372657e-01f, 4.02211435e-02f,
  8.07798654e-02f, -8.65345746e-02f, 2.07250625e-01f, 5.92165366e-02f, 2.09582716e-01f, -3.87038291e-02f, 1.11996159e-01f, 3.04944385e-02f, -1.13058642e-01f, 1.81217447e-01f,
  -1.36577561e-01f, -1.29108876e-01f, -6.27444386e-02f, 4.42426316e-02f, -1.84396729e-01f, 2.11524725e-01f, 1.17566861e-01f, 1.61860317e-01f, 2.70148627e-02f, 1.33066084e-02f,
  -2.89340634e-02f, -3.55823408e-03f, 7.72322267e-02f, 4.71899547e-02f, 1.66887864e-01f, 9.34156924e-02f, -3.69973406e-02f, -2.53170473e-03f, 2.99465861e-02f, 7.77550191e-02f,
  -7.96625838e-02f, 4.02479172e-02f, 1.50720790e-01f, 1.64075896e-01f, 1.67116359e-01f, 6.27057487e-03f, -2.17608124e-01f, -7.62948394e-02f, -1.86055005e-01f, -6.99516907e-02f,
  -1.13259301e-01f, 2.22388878e-01f, -1.60608329e-02f, 4.10873517e-02f, 2.03742608e-01f, 2.19735220e-01f, -9.32286531e-02f, 1.71302751e-01f, 1.59799814e-01f, 3.00927553e-02f,
  -5.57044409e-02f, 2.01701075e-01f, 1.65514037e-01f, 3.16670127e-02f, 2.12856364e-02f, 1.80513680e-01f, 7.13437945e-02f, -8.11610604e-04f, 7.10942224e-02f, 7.28520453e-02f,
  -1.53102741e-01f, 1.71511754e-01f, 1.99507480e-03f, -1.09358922e-01f, -3.40709463e-02f, -5.26224496e-03f, -7.94000253e-02f, 6.64945245e-02f, -8.75692144e-02f, 1.69878870e-01f,
  5.92521727e-02f, 5.35625927e-02f, -1.52967408e-01f, 2.01450199e-01f, 8.71338248e-02f, 4.90731746e-02f, 6.62145540e-02f, -3.36902402e-02f, 5.85450977e-02f, 8.35702270e-02f,
  6.86140582e-02f, 2.40264982e-02f, 1.11753764e-02f, -9.88714620e-02f, -1.05354041e-02f, -8.26844722e-02f, 4.94613089e-02f, -1.02531733e-02f, -1.53865650e-01f, -5.28909452e-02f,
  2.19643973e-02f, -1.65466994e-01f, 1.65751521e-02f, -6.41626343e-02f, -2.57020116e-01f, -7.52911940e-02f, 1.01598442e-01f, 1.10576013e-02f, 8.74088332e-02f, 1.70074895e-01f,
  -1.00165933e-01f, -1.36790454e-01f, 2.89371639e-01f, 1.96109295e-01f, -5.27385399e-02f, 1.26602933e-01f, 2.43645031e-02f, 5.64420521e-02f, 1.46108985e-01f, 1.00833461e-01f,
  -7.08563998e-02f, 8.03010687e-02f, -7.95994885e-03f, 2.21175283e-01f, -7.03076199e-02f, 6.59258515e-02f, 2.49517057e-03f, 1.70573108e-02f, 2.18933165e-01f, 5.44412732e-02f,
  1.63942985e-02f, 4.10523154e-02f, 2.54995883e-01f, 1.34376973e-01f, -8.12277123e-02f, -2.02241838e-02f, 1.70060813e-01f, 2.98372537e-01f, 1.99303851e-01f, 1.25031635e-01f,
  -5.72235584e-02f, 7.75246844e-02f, 3.22082974e-02f, 6.81359088e-03f, 1.39229577e-02f, 2.43206367e-01f, 1.64381906e-01f, -9.92150530e-02f, 6.59474880e-02f, -1.86555505e-01f,
  8.93872697e-03f, -6.16429374e-02f, 2.69428939e-02f, -7.43896514e-02f, 7.16067925e-02f, -3.49532180e-02f, 1.21256307e-01f, 1.70561150e-01f, -8.53568036e-03f, 1.04029670e-01f,
  8.11432600e-02f, 6.55647442e-02f, -8.67984444e-02f, -1.47097232e-02f, 5.42008318e-03f, -2.14884430e-02f, -1.47475004e-01f, 3.73980179e-02f, -2.32376792e-02f, 8.34963694e-02f,
  8.54127035e-02f, 8.89366046e-02f, 2.14010999e-02f, -1.32821202e-01f, 1.45738333e-01f, 9.15655419e-02f, 2.59036183e-01f, 1.25424176e-01f, 2.45480791e-01f, -6.83789924e-02f,
  3.74137722e-02f, -1.36090470e-02f, -1.09614529e-01f, -9.84598100e-02f, 8.25640094e-03f, -1.04577065e-01f, -5.66712245e-02f, 2.40617990e-01f, 6.76071569e-02f, 1.88278332e-02f,
  7.61257559e-02f, -9.95421130e-03f, 5.05851917e-02f, -1.82360172e-01f, -6.20646551e-02f, -4.50694188e-03f, 1.31130502e-01f, 1.91675462e-02f, 1.64735511e-01f, 1.11118317e-01f,
  -1.84550919e-02f, 1.19836651e-01f, 1.31328329e-01f, -9.30962265e-02f, 1.50142893e-01f, 1.73210397e-01f, 2.28100598e-01f, -3.34061235e-02f, 1.59548055e-02f, 4.60248627e-02f,
  -7.08690062e-02f, 1.79818138e-01f, -6.44485727e-02f, -3.85030538e-01f, 1.52293995e-01f, 2.39278957e-01f, -1.46246687e-01f, 2.09689856e-01f, 2.60915011e-01f, 5.68965040e-02f,
  -1.34282753e-01f, 8.93968418e-02f, 1.21426366e-01f, -6.53725937e-02f, 1.58589240e-02f, 9.74661261e-02f, -1.22545481e-01f, -7.26002455e-02f, 3.73225398e-02f, -8.14434588e-02f,
  -2.33441801e-03f, -8.69279951e-02f, -2.40978897e-01f, -1.63099721e-01f, 2.18497515e-02f, -1.46686673e-01f, 9.22608823e-02f, 9.56985652e-02f, 5.77888638e-02f, -2.60399301e-02f,
  6.99349716e-02f, 1.12614691e-01f, 1.17787533e-01f, -1.74406003e-02f, -3.95495221e-02f, 4.02023494e-02f, 8.55119824e-02f, -3.99323739e-02f, -2.97369901e-02f, -3.67854200e-02f,
  7.84831960e-03f, 9.41910222e-02f, -2.39290278e-02f, 6.79655820e-02f, -2.86109000e-02f, 5.13577200e-02f, 1.56069353e-01f, 3.70505638e-02f, 8.68444890e-02f, 6.33069547e-03f,
  5.28415255e-02f, 1.01449311e-01f, -2.82333754e-02f, -1.51457787e-01f, 1.13559969e-01f, 1.04243405e-01f, 1.17248155e-01f, 1.39137432e-01f, -6.99241906e-02f, 7.93853924e-02f,
  -6.45394549e-02f, -9.99018736e-03f, 3.48029695e-02f, 1.32884279e-01f, 5.85427992e-02f, -2.11429402e-01f, 4.73980494e-02f, -1.18403852e-01f, -3.15676704e-02f, -3.30591537e-02f,
  -5.92940785e-02f, -5.86524419e-02f, -6.90178648e-02f, 1.50681939e-02f, -2.79706661e-02f, 4.38669771e-02f, -2.75368001e-02f, 5.35411574e-02f, 1.16076976e-01f, -1.58474352e-02f,
  -2.13809628e-02f, 1.75612364e-02f, -9.56837088e-02f, 3.39109264e-02f, -8.46573059e-03f, 4.86284271e-02f, 6.53052479e-02f, 8.53557885e-02f, 1.07389703e-01f, 2.09821612e-01f,
  -7.27475733e-02f, -1.33125424e-01f, 2.36709505e-01f, 1.33455440e-01f, 1.74015209e-01f, -1.70040596e-02f, 1.42636448e-01f, -7.10078981e-03f, 8.42567384e-02f, -6.09625839e-02f,
  -7.92423636e-02f, -3.03630922e-02f, 1.13203526e-02f, -3.20176072e-02f, 1.20650537e-01f, -5.22733619e-03f, 2.04068609e-02f, 4.95085726e-03f, 1.98758915e-01f, -1.10950001e-01f,
  -5.09463511e-02f, -1.07024036e-01f, -5.31540960e-02f, -2.32188608e-02f, 3.63925658e-02f, -1.50036868e-02f, -5.31048067e-02f, 1.41328946e-01f, -2.98726726e-02f, -1.36281364e-02f,
  5.87221831e-02f, -2.24411394e-02f, 1.05456702e-01f, 1.12640887e-01f, 2.07816005e-01f, -1.41039446e-01f, -5.80500485e-03f, -7.45743588e-02f, -1.07485976e-03f, 1.70077682e-01f,
  -1.01094261e-01f, -2.46511638e-01f, 1.14958607e-01f, 1.84890196e-01f, -7.75958076e-02f, 1.88662007e-01f, 2.97443181e-01f, -4.82792445e-02f, -2.04933826e-02f, -3.26276273e-02f,
  1.79832920e-01f, 1.37336791e-01f, 1.33805603e-01f, 1.31770939e-01f, -1.06752636e-02f, 1.11788109e-01f, -1.28291264e-01f, 8.03109556e-02f, 5.66822253e-02f, 1.17805190e-02f,
  -1.57215521e-01f, -3.69228236e-02f, 8.84871259e-02f, -6.56789467e-02f, 6.64894804e-02f, -1.82303071e-01f, 1.98322430e-01f, 1.81862593e-01f, -1.28656462e-01f, -2.79660020e-02f,
  2.18708217e-01f, -3.28766406e-02f, -1.53460100e-01f, -5.79045489e-02f, 2.53177643e-01f, -8.15479159e-02f, 2.67498136e-01f, -1.36840656e-01f, 6.47193342e-02f, 2.84079872e-02f,
  8.50537047e-02f, 2.05154583e-01f, 1.54164553e-01f, 1.86542179e-02f, 6.07974268e-02f, 1.74503066e-02f, 1.86444849e-01f, 2.61042900e-02f, -1.12778187e-01f, 1.84172675e-01f,
  -3.12349591e-02f, -6.72859745e-03f, 4.43062820e-02f, -1.61779314e-01f, 4.46338691e-02f, 1.49268970e-01f, -1.42869771e-01f, 6.29286543e-02f, -4.14048508e-02f, -3.98190618e-02f,
  1.82755426e-01f, -1.17682023e-02f, -2.32966226e-02f, -6.68201670e-02f, 2.21701730e-02f, -1.61492303e-01f, -2.71622892e-02f, 1.50609985e-01f, -9.47596654e-02f, 8.36011842e-02f,
  -1.83882177e-01f, 7.98422471e-03f, -7.62086362e-02f, -5.66583425e-02f, 2.41940059e-02f, 1.43008918e-01f, 7.33290315e-02f, 5.52658103e-02f, 1.35202199e-01f, 1.83095530e-01f,
  -2.30774358e-01f, 9.16748792e-02f, 1.07358918e-02f, 9.00096968e-02f, 1.80348620e-01f, 1.57907620e-01f, 2.15411693e-01f, 2.40709811e-01f, 1.25947800e-02f, -6.24750294e-02f,
  1.56927330e-03f, -4.35679071e-02f, -1.08726211e-01f, -5.30692451e-02f, -1.52199805e-01f, 8.40309486e-02f, -1.06306992e-01f, -4.87670340e-02f, 1.27872089e-02f, -3.51884216e-02f,
  2.77066857e-01f, -1.01160251e-01f, 2.02417299e-02f, -6.06871061e-02f, -5.40025979e-02f, 1.12658203e-01f, 2.07660019e-01f, -1.29614592e-01f, -7.15067908e-02f, -9.06348228e-02f,
  -8.38793740e-02f, 2.53197439e-02f, -2.67442502e-02f, 1.34837598e-01f, -1.77604593e-02f, 5.89793511e-02f, -6.81452528e-02f, -1.32588923e-01f, -1.59796625e-02f, 3.96746285e-02f,
  8.65018368e-02f, -1.05639389e-02f, -6.61044121e-02f, 1.65657982e-01f, 1.98726580e-01f, 4.44840044e-02f, -1.44951255e-03f, 1.68181941e-01f, -2.39766732e-01f, 2.40998745e-01f,
  9.73520577e-02f, -9.66639593e-02f, -6.49772882e-02f, 1.76258147e-01f, -6.98248371e-02f, -1.72329210e-02f, -2.85027809e-02f, -5.74405417e-02f, -8.27291906e-02f, 1.30962599e-02f,
  1.14730716e-01f, -6.01415224e-02f, 1.65873095e-01f, 7.29959756e-02f, 1.81699231e-01f, -8.83869901e-02f, -7.43252635e-02f, -1.00367315e-01f, 1.44059747e-01f, 8.22964534e-02f,
  -6.51297271e-02f, 5.12474775e-03f, 1.84794180e-02f, 2.11574763e-01f, -7.68090636e-02f, 3.58229503e-02f, 4.80273739e-02f, 8.06204602e-02f, 8.23182464e-02f, -2.21701205e-01f,
  1.13433208e-02f, 2.44749431e-02f, -4.96489555e-02f, -7.29472190e-02f, -2.42339894e-02f, 1.81468368e-01f, -1.36152223e-01f, 1.07203186e-01f, 2.29735263e-02f, 1.89554080e-01f,
  -1.29230231e-01f, 1.01868920e-01f, 9.08733755e-02f, -1.13464789e-02f, -1.40091926e-01f, 2.51512587e-01f, 1.00510471e-01f, -1.47091433e-01f, -6.39763698e-02f, -2.76053119e-02f,
  5.81296906e-03f, 7.94196799e-02f, 1.72848657e-01f, -5.22151403e-02f, 4.32480164e-02f, -9.55941528e-02f, 3.88077386e-02f, 1.68108016e-01f, 1.98972046e-01f, 2.09106341e-01f,
  -3.15435939e-02f, -6.20513707e-02f, -6.54773936e-02f, 3.74243744e-02f, 5.53780410e-04f, -1.87022403e-01f, 2.23819196e-01f, -1.22657627e-01f, -9.82215777e-02f, 2.19071612e-01f,
  2.29538441e-01f, 6.46731555e-02f, 1.52067885e-01f, -1.04869148e-02f, 2.17578202e-01f, 4.75678109e-02f, 6.45791069e-02f, 2.43666008e-01f, -5.43170460e-02f, 1.21119894e-01f,
  2.54265987e-03f, 2.82607675e-02f, 1.16331369e-01f, 2.29059890e-01f, 1.10164173e-01f, -3.64342108e-02f, -1.73556596e-01f, -1.86758637e-01f, 1.64132804e-01f, 2.18959585e-01f,
  -8.40927809e-02f, -4.26210389e-02f, 1.46802887e-01f, 7.83783477e-03f, -7.21037090e-02f, -3.08927037e-02f, 1.70406550e-01f, -3.88266481e-02f, 1.36249676e-01f, -1.01682685e-01f,
  7.17737153e-02f, 2.17663646e-02f, 2.59836894e-02f, -8.30776840e-02f, 1.63114443e-01f, -6.26759902e-02f, -9.42652822e-02f, -3.33841629e-02f, 1.98398590e-01f, -3.01720779e-02f,
  -1.39755920e-01f, 1.61510870e-01f, 1.00183554e-01f, 1.85932815e-02f, -1.25726268e-01f, -1.29611447e-01f, 3.98052298e-02f, -4.71797809e-02f, 6.32051900e-02f, -2.56397445e-02f,
  8.90295208e-02f, -2.65379865e-02f, 9.68099162e-02f, -1.59247324e-01f, -1.15769051e-01f, 1.56450644e-01f, -1.46028817e-01f, -2.43521720e-01f, 3.05448994e-02f, 2.63126165e-01f,
  -1.31621256e-01f, 1.82689339e-01f, 9.58180726e-02f, 5.84784448e-02f, -2.15919405e-01f, -1.05346777e-01f, -2.31066290e-02f, 1.22270323e-01f, 1.59864739e-01f, -3.70335672e-03f,
  2.46145993e-01f, 1.20914005e-01f, 1.79022178e-02f, 6.48136213e-02f, -4.71622162e-02f, -1.41783625e-01f, 1.71035141e-01f, 1.90846115e-01f, -1.15065075e-01f, -1.24066003e-01f,
  -6.07092604e-02f, 4.55303751e-02f, -1.02663757e-02f, 1.66197252e-02f, 3.51354070e-02f, 5.55359013e-02f, 9.47689936e-02f, -1.49424911e-01f, -1.76937208e-01f, 8.53252411e-02f,
  -1.40073717e-01f, 6.05165958e-03f, -1.54920310e-01f, 1.13988429e-01f, -1.38821676e-01f, 1.64611116e-01f, 1.35900065e-01f, 1.28803730e-01f, -1.35634094e-01f, 1.38935298e-01f,
  5.02676331e-02f, 1.62815955e-02f, -6.99255392e-02f, 2.36277714e-01f, -1.42841097e-02f, -1.34538814e-01f, 5.34150489e-02f, -6.88761771e-02f, -3.22438218e-02f, 2.76970584e-02f,
  2.42168278e-01f, -5.77096865e-02f, 1.81705296e-01f, -1.50201589e-01f, 7.66266510e-02f, 9.02285129e-02f, 2.51954317e-01f, 1.79134756e-02f, -7.77009353e-02f, -1.35047836e-02f,
  1.69101392e-03f, 2.24109888e-02f, -1.56433716e-01f, -4.55064513e-02f, 1.58265442e-01f, -7.97106624e-02f, -1.04151636e-01f, 2.99044818e-01f, 1.09035179e-01f, -1.58542953e-02f,
  -8.62506628e-02f, 7.05110803e-02f, -3.44822705e-02f, -9.94180664e-02f, 1.10178880e-01f, 1.17087111e-01f, -2.34288976e-01f, 2.36202423e-02f, -7.01752631e-03f, 1.75833493e-01f,
  1.14134334e-01f, -2.22712359e-03f, 1.36990055e-01f, 2.85783052e-01f, 1.84492189e-02f, 2.24708151e-02f, 3.66343521e-02f, -9.09285173e-02f, -1.25184488e-02f, -9.50234979e-02f,
  -1.89899817e-01f, 1.49593249e-01f, 2.01470871e-02f, -1.28268972e-01f, -8.19090530e-02f, -4.09125015e-02f, 3.25852185e-01f, -1.84239596e-01f, 1.80225000e-01f, -1.72259614e-01f,
  -1.20830387e-01f, -1.67504475e-02f, -1.37380073e-02f, -2.74072319e-01f, -1.54795200e-01f, -1.21585920e-01f, -8.26417506e-02f, -1.55834451e-01f, 1.70282647e-01f, 4.33822386e-02f,
  7.02395588e-02f, 9.69959795e-02f, -1.09860577e-01f, -4.59360108e-02f, -1.57645926e-01f, 7.41316825e-02f, -1.17334016e-02f, -3.90112661e-02f, -7.91655034e-02f, 1.75463155e-01f,
  1.23369887e-01f, 1.35162085e-01f, 9.06416215e-03f, 1.10197701e-01f, -1.86438411e-01f, 3.11654836e-01f, 1.11941062e-02f, -1.56218871e-01f, -4.62077558e-02f, 5.39860241e-02f,
  -1.36267841e-01f, -1.35158047e-01f, 1.08255081e-01f, -4.01190333e-02f, 6.07266426e-02f, 7.09943175e-02f, 6.33573607e-02f, 5.25068119e-02f, 4.76743728e-02f, 1.21427149e-01f,
  -3.27492729e-02f, 1.34143919e-01f, -1.10362895e-01f, 1.41159385e-01f, 9.47336778e-02f, 9.88032743e-02f, -7.82718789e-03f, 1.21366046e-01f, -9.74942297e-02f, 7.61003569e-02f,
  1.41644984e-01f, 6.73690364e-02f, -6.18848503e-02f, -4.71353643e-02f, -9.42063034e-02f, -1.67555332e-01f, 6.22703284e-02f, -1.30952135e-01f, 7.00568333e-02f, -8.04211348e-02f,
  2.69469798e-01f, -1.53919712e-01f, -8.59013200e-02f, -1.29477918e-01f, -9.57916901e-02f, -9.73494351e-02f, 9.06278640e-02f, -1.33357614e-01f, -1.15398966e-01f, -7.80186653e-02f,
  -4.79618311e-02f, -8.18105713e-02f, -1.14261121e-01f, 2.97829844e-02f, 7.01974109e-02f, 1.97188277e-02f, -8.61233249e-02f, -8.31172019e-02f, -1.23616382e-01f, -5.60813062e-02f,
  9.68723521e-02f, -6.92620203e-02f, 1.25813290e-01f, 2.15115864e-02f, 1.20329373e-01f, -2.26598550e-02f, 1.69779453e-02f, 2.17790268e-02f, -1.68728888e-01f, 1.48044869e-01f,
  1.37321532e-01f, -6.29559681e-02f, 5.23532107e-02f, 7.71859661e-02f, -1.57054231e-01f, -8.22110549e-02f, -6.98970333e-02f, -3.81146036e-02f, 1.04936384e-01f, -5.30382060e-02f,
  -8.77043903e-02f, 1.29812852e-01f, -6.87248558e-02f, 8.79563624e-04f, 3.57815735e-02f, 2.21355837e-02f, 9.92641747e-02f, -3.99495028e-02f, -1.99064851e-01f, -7.38986302e-03f,
  1.14979655e-01f, 1.06481684e-03f, 1.02235362e-01f, 1.70233715e-02f, -1.60740241e-02f, 6.88289404e-02f, 1.31861418e-02f, -7.11581809e-03f, 1.00713465e-02f, 1.42984316e-01f,
  1.08733311e-01f, 3.57091054e-02f, 2.07520232e-01f, 1.07598186e-01f, -1.15829088e-01f, 9.46852937e-02f, 6.11776859e-02f, -6.31739050e-02f, -4.20355722e-02f, 4.32689898e-02f,
  1.25868201e-01f, 8.55639111e-03f, -1.62457861e-02f, 1.18518889e-01f, 1.01934634e-01f, -9.52399224e-02f, -2.70745512e-02f, 7.09360316e-02f, 3.47718000e-02f, 5.44477580e-03f,
  5.40760718e-02f, 1.58663765e-02f, -1.96175035e-02f, 6.63157627e-02f, -7.16261640e-02f, 5.16717806e-02f, 1.25328764e-01f, -1.34176789e-02f, -1.22289360e-01f, -9.88129079e-02f,
  1.75995100e-02f, -1.30061293e-03f, 2.10255742e-01f, -1.84529811e-01f, 1.09276816e-01f, 2.04724953e-01f, -1.36513725e-01f, 8.46981481e-02f, 1.80451259e-01f, -1.29440859e-01f,
  -1.01976812e-01f, -5.27191758e-02f, 8.50893781e-02f, -9.58542153e-02f, 6.94588423e-02f, -2.09182501e-02f, -1.11010455e-01f, -9.17504430e-02f, 6.68815970e-02f, -1.15931295e-02f,
  -9.48099494e-02f, -2.33099312e-02f, 3.96198742e-02f, 3.35532683e-03f, -1.29693359e-01f, -9.24036279e-02f, -5.67330681e-02f, 1.79738432e-01f, -2.48528458e-02f, 1.05184309e-01f,
  1.71306264e-02f, 3.91433053e-02f, 7.01145157e-02f, -1.68577418e-01f, 5.13550534e-04f, 2.35374421e-02f, 6.69968799e-02f, -6.27568811e-02f, 6.74812049e-02f, 1.72448337e-01f,
  -1.51504934e-01f, 9.17658433e-02f, 1.39206881e-02f, -1.23490477e-02f, -1.63650572e-01f, 1.50239229e-01f, 4.83465530e-02f, -4.55695651e-02f, 5.08837700e-02f, 1.51370943e-01f,
  -1.35876890e-03f, -4.38943990e-02f, -7.25167803e-03f, -1.24193147e-01f, 4.77872342e-02f, 7.31511340e-02f, 1.12804629e-01f, -9.91328713e-03f, 1.36895284e-01f, -9.21013728e-02f,
  -3.87750007e-02f, 1.71505377e-01f, 1.19266711e-01f, 4.13695425e-02f, -2.00034231e-02f, -1.37244850e-01f, 6.65381923e-02f, 1.57080188e-01f, -5.04057780e-02f, -1.50054380e-01f,
  1.67922661e-01f, 3.76969725e-02f, -7.94990510e-02f, 7.04849437e-02f, 1.62274241e-01f, 7.86060244e-02f, 3.29378508e-02f, -5.01573645e-02f, 6.77175894e-02f, 1.75869651e-02f,
  -1.35695055e-01f, -1.19302981e-02f, -2.52756607e-02f, 1.00826979e-01f, -5.33429869e-02f, 5.74959479e-02f, -2.34104514e-01f, -2.83615645e-02f, 2.76470575e-02f, -1.20206580e-01f,
  -6.06624484e-02f, 4.69469838e-02f, 8.45035613e-02f, 1.47113115e-01f, -8.76608714e-02f, -3.22021358e-02f, 1.05300531e-01f, -4.08026986e-02f, -5.05683012e-02f, -5.67512438e-02f,
  1.66772366e-01f, 1.27418801e-01f, 1.03548214e-01f, -1.31324366e-01f, 6.24618977e-02f, -9.94629338e-02f, -8.79207402e-02f, -6.22645654e-02f, 5.86613826e-02f, -2.56865397e-02f,
  -1.81079842e-02f, 3.52634788e-02f, 1.75870180e-01f, -9.42164809e-02f, -8.85960609e-02f, 1.36747003e-01f, 5.75372539e-02f, -7.98780173e-02f, 9.72654745e-02f, 4.47922712e-03f,
  -8.07750076e-02f, 1.57803968e-01f, -1.98295027e-01f, 6.20483644e-02f, -1.29376128e-01f, -5.84125668e-02f, -2.84727383e-02f, -4.73967344e-02f, 8.22400227e-02f, -5.58229238e-02f,
  4.92354929e-02f, -1.00284867e-01f, 7.86055550e-02f, 1.24584004e-01f, -3.19476649e-02f, 7.70448521e-02f, -1.29888624e-01f, -1.95174858e-01f, -1.06841870e-01f, 7.13865180e-03f,
  -2.66553592e-02f, 3.03214565e-02f, 3.48601900e-02f, -2.92886868e-02f, 1.34344604e-02f, 6.37161732e-02f, 4.23698649e-02f, 9.34564695e-02f, -6.34705275e-02f, 6.34324038e-03f,
  3.44446301e-03f, 1.62126780e-01f, 1.17567889e-01f, 1.28649790e-02f, -1.60342351e-01f, -3.76249701e-02f, -2.34159306e-01f, 7.90181309e-02f, -1.44668240e-02f, -4.18180786e-02f,
  -1.16322972e-01f, -5.55354916e-02f, 2.25983206e-02f, 1.00102797e-02f, 1.32645011e-01f, 1.85818717e-01f, 8.88427906e-03f, 8.16101655e-02f, -1.26599818e-02f, -5.36116995e-02f,
  -6.18456863e-02f, -1.36803776e-01f, 2.66974065e-02f, 1.86948646e-02f, -2.93464027e-02f, 7.81917125e-02f, 8.08798522e-02f, 1.22326225e-01f, -1.00872442e-01f, 1.27341732e-01f,
  -8.30066949e-02f, 3.07716690e-02f, 1.27305752e-02f, -3.55806877e-03f, 3.66478711e-02f, -9.29367617e-02f, -3.84570360e-02f, -3.83337848e-02f, -1.93728842e-02f, -5.25463149e-02f,
  -4.70094122e-02f, -1.54803231e-01f, -4.33246680e-02f, 9.27038416e-02f, 1.49849430e-01f, 8.26932024e-03f, 1.62375584e-01f, 1.29277498e-01f, 1.36072859e-01f, 1.08610816e-01f,
  1.54407009e-01f, -1.73532125e-02f, -1.24276504e-01f, 7.18233036e-03f, 1.13609269e-01f, 9.40301046e-02f, 4.65185642e-02f, 1.30885467e-01f, 2.28934661e-02f, 9.32865664e-02f,
  -9.52653140e-02f, 1.25136375e-01f, -1.40153952e-02f, 1.78188965e-01f, -1.10480472e-01f, 2.54607536e-02f, 2.18450800e-01f, 1.15497380e-01f, 9.02425870e-02f, -6.69521540e-02f,
  -7.63959959e-02f, 4.40327786e-02f, -1.40194789e-01f, -8.18571746e-02f, -1.90788805e-02f, 1.14869773e-02f, -2.00196594e-01f, -2.66971253e-02f, 2.37576157e-01f, 1.77172139e-01f,
  2.13784367e-01f, -2.66471819e-04f, 1.75825387e-01f, -4.62981425e-02f, -7.06133470e-02f, 2.24384312e-02f, 1.41712770e-01f, -6.69402704e-02f, -8.03157762e-02f, 1.18705168e-01f,
  2.53865272e-01f, -1.57318771e-01f, 1.20292110e-02f, 2.41687849e-01f, -7.94981495e-02f, -5.39860502e-03f, -1.52311670e-02f, -6.05911352e-02f, -1.06560394e-01f, 1.78744987e-01f,
  -1.41320884e-01f, 6.25182018e-02f, -1.63869962e-01f, 1.25233188e-01f, 8.57640281e-02f, 6.52675256e-02f, -3.33271623e-02f, -6.20044135e-02f, -1.34221520e-02f, 9.83500257e-02f,
  1.60446346e-01f, -4.61995509e-03f, 1.62135288e-02f, 1.97598115e-01f, -2.00074986e-01f, -1.36836261e-01f, -4.46933620e-02f, -8.43621716e-02f, 2.18257960e-02f, 3.86741459e-02f,
  -1.91533193e-02f, -6.72159046e-02f, -2.07535783e-03f, 1.36386780e-02f, 1.47612065e-01f, -8.52145106e-02f, -1.62094042e-01f, 5.81868067e-02f, 1.83448806e-01f, 9.62300003e-02f,
  -6.93983957e-02f, -3.90883200e-02f, -8.38218182e-02f, 1.58283651e-01f, -1.84141397e-02f, -7.48143857e-03f, 1.62579313e-01f, 2.27343570e-02f, 3.26386020e-02f, -4.98444028e-02f,
  7.79350176e-02f, 2.94289775e-02f, -1.11728832e-01f, -6.51023760e-02f, 1.35380430e-02f, 2.22490057e-02f, -1.31263554e-01f, 5.48726059e-02f, 7.13710440e-03f, 5.37083298e-03f,
  7.24341571e-02f, -5.54175535e-03f, -7.05944300e-02f, -6.79700747e-02f, -6.99593350e-02f, 1.87825605e-01f, 2.67514214e-02f, -1.08770058e-01f, 1.61340013e-01f, 2.98096668e-02f,
  -1.59125365e-02f, 1.31489441e-01f, 5.42536825e-02f, -1.41869307e-01f, 1.29259303e-01f, -2.24718247e-02f, 2.40948364e-01f, 6.48548082e-02f, 1.35811670e-02f, -7.57209286e-02f,
  -1.15259904e-02f, 1.19317345e-01f, 1.79027487e-02f, 1.19327620e-01f, 9.90888774e-02f, 1.04576714e-01f, 1.51029527e-01f, -2.58436985e-02f, 8.14029202e-02f, 4.54781065e-03f,
  1.27064168e-01f, 1.20403022e-01f, 1.73430249e-01f, -1.76565442e-02f, 1.50999084e-01f, 1.22414365e-01f, -3.78878564e-02f, 4.21270989e-02f, 1.50588974e-02f, 1.45792454e-01f,
  1.97875523e-03f, 8.46775174e-02f, -1.46780565e-01f, 6.41336069e-02f, 7.14580342e-02f, -1.33336395e-01f, -7.25948736e-02f, -8.59783217e-02f, 1.06778927e-01f, 2.13320136e-01f,
  -2.16042679e-02f, -2.72705741e-02f, 2.20588729e-01f, -7.80206770e-02f, -9.44564119e-02f, -3.24564725e-02f, 1.31583080e-01f, 5.68606704e-02f, 4.32617292e-02f, -5.17377891e-02f,
  9.88800600e-02f, -2.39827856e-02f, -4.42678435e-03f, 7.75618479e-02f, -4.57008146e-02f, 2.08671521e-02f, -3.26537937e-02f, 1.12824298e-01f, 2.45996028e-01f, -3.19411494e-02f,
  -1.25310734e-01f, 2.30762780e-01f, 1.32382095e-01f, -6.54754639e-02f, 2.00798735e-02f, -6.90087453e-02f, -5.76405749e-02f, 9.26534608e-02f, -9.88544598e-02f, 5.00502363e-02f,
  -2.39107199e-02f, -4.70952876e-02f, 5.30264154e-02f, -1.52594939e-01f, -9.42657981e-03f, -1.01353317e-01f, -5.86913787e-02f, -1.22096360e-01f, 4.35049385e-02f, 9.65301022e-02f,
  -1.78915426e-01f, 9.29214731e-02f, -7.98370838e-02f, -4.51598279e-02f, -1.33036420e-01f, -4.39731441e-02f, 1.00850068e-01f, 1.71441793e-01f, 1.90269724e-01f, 1.80133894e-01f,
  2.00064510e-01f, 1.52207240e-01f, -9.30634290e-02f, 1.36542365e-01f, 7.61087090e-02f, -6.48277299e-03f, 9.06474292e-02f, 4.76983190e-02f, 3.24380137e-02f, 1.20795250e-01f,
  1.38332173e-01f, -5.66883013e-02f, 1.93048030e-01f, 7.53961504e-02f, -2.53292382e-01f, 1.44879548e-02f, 1.27001420e-01f, 1.14569291e-02f, -2.23724589e-01f, 6.27629459e-02f,
  -5.92487976e-02f, -9.80728418e-02f, 2.69701421e-01f, -1.89622119e-02f, 8.09799805e-02f, -4.04720195e-02f, 1.10087760e-01f, 2.71369010e-01f, -1.81804672e-02f, 1.33506134e-01f,
  7.68237785e-02f, 4.07916084e-02f, -6.07689563e-03f, 1.22505486e-01f, -3.43058445e-02f, -8.06081742e-02f, -6.10954985e-02f, -1.57448575e-02f, 4.08256128e-02f, -2.51346946e-01f,
  4.63267639e-02f, 2.08559006e-01f, 3.11756600e-02f, 6.70737326e-02f, -1.27451614e-01f, 1.81355849e-01f, 3.11378866e-01f, 1.16766118e-01f, -8.75199735e-02f, 1.03147894e-01f,
  -8.32987502e-02f, 7.26034641e-02f, 1.73668712e-02f, -1.42908439e-01f, 1.50118709e-01f, 1.41171038e-01f, -2.04324752e-01f, 2.78148144e-01f, 1.38097629e-01f, -1.61317408e-01f,
  -9.27165523e-02f, 4.53731269e-02f, -1.55984193e-01f, -1.40083894e-01f, -1.72612920e-01f, -3.67827900e-02f, 2.11669710e-02f, -1.05260856e-01f, -1.40901744e-01f, 3.54909115e-02f,
  1.38754919e-01f, 7.24555505e-03f, -8.35820735e-02f, 1.01236090e-01f, -4.86807227e-02f, 1.02389835e-01f, 2.00411066e-01f, -5.05446643e-02f, 6.61825314e-02f, -2.72601396e-02f,
  -5.89489937e-03f, -7.22418055e-02f, 1.42390653e-01f, -9.87429023e-02f, -1.44688979e-01f, -2.05176726e-01f, 2.85145223e-01f, -2.40050077e-01f, -5.30282259e-02f, -9.28701684e-02f,
  -8.27465132e-02f, -1.40729129e-01f, -1.92388035e-02f, -2.03057662e-01f, -5.99159207e-03f, -2.23223999e-01f, -1.86263606e-01f, -9.65626016e-02f, 1.04202054e-01f, -2.06733584e-01f,
  1.46273255e-01f, -3.15201916e-02f, 3.83772478e-02f, 3.52240913e-02f, -1.54122710e-01f, -5.94660752e-02f, 1.35001212e-01f, -1.32564222e-02f, 2.02271476e-01f, -2.15231385e-02f,
  -7.98259825e-02f, 1.14023022e-01f, 2.06457436e-01f, 3.62294316e-02f, -1.62524790e-01f, 2.05610529e-01f, 1.41340092e-01f, -1.12669587e-01f, -2.57575754e-02f, 8.52622166e-02f,
  -5.62699325e-02f, -7.66091496e-02f, 9.28217694e-02f, 8.12299699e-02f, 2.21918914e-02f, -6.83876267e-03f, -1.07918359e-01f, -1.68501809e-02f, -1.47115616e-02f, -3.75957489e-02f,
  7.56039694e-02f, -1.28475323e-01f, 2.35987604e-02f, -8.11328962e-02f, -2.14830548e-01f, -1.43334344e-01f, 1.41609758e-01f, 3.13705131e-02f, 1.05372600e-01f, 1.72294006e-01f,
  -1.74334288e-01f, -9.69775990e-02f, 1.41086489e-01f, 1.45192355e-01f, -5.45275770e-02f, 1.65068552e-01f, 1.19956443e-02f, 4.66058925e-02f, 2.01461211e-01f, 2.67441303e-01f,
  -1.79445028e-01f, 1.00788504e-01f, 1.73262823e-02f, 1.56152621e-01f, -6.78616464e-02f, 6.53181598e-02f, 4.71801534e-02f, 1.37876607e-02f, 1.07155666e-01f, 2.00788230e-01f,
  -1.17385807e-02f, 1.23508081e-01f, 1.65689245e-01f, 8.77555236e-02f, -1.03234224e-01f, 1.16903342e-01f, 9.51688811e-02f, 1.67984962e-01f, 1.15279928e-01f, -6.47594547e-03f,
  2.88421512e-02f, 4.45701890e-02f, 6.92327619e-02f, 6.57520164e-03f, -2.44868957e-02f, 1.09103121e-01f, -6.84639961e-02f, -6.31682575e-02f, 9.83877704e-02f, -5.70716113e-02f,
  1.08671151e-01f, -1.58587769e-02f, 2.16358416e-02f, 4.08759750e-02f, 1.16827108e-01f, -4.51002680e-02f, 5.21863997e-02f, 1.11374043e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  -9.97060630e-03f, 2.89931968e-02f, 4.83298749e-02f, 4.06281687e-02f, 8.11866596e-02f, 1.35904878e-01f, -4.16002944e-02f, 7.49488175e-02f, 1.22466952e-01f, 7.35624041e-03f,
  5.12286909e-02f, 9.11562294e-02f, 8.55348699e-05f, 2.25044899e-02f, 8.08084309e-02f, -8.33339766e-02f, 2.00037450e-01f, 4.04408574e-02f, 8.82371441e-02f, 6.95174038e-02f,
  -5.26790917e-02f, -5.34015410e-02f, 1.63755491e-01f, 1.01697773e-01f, -1.08615188e-02f, -6.49929866e-02f, 1.58840179e-01f, 6.29807934e-02f, 1.23754270e-01f, 9.51919630e-02f,
  1.03737444e-01f, 7.36744031e-02f, 1.49992928e-01f, -2.81109903e-02f, 8.57004449e-02f, 8.80155787e-02f, 2.47833710e-02f, 1.44700650e-02f, 7.96790123e-02f, 1.14831209e-01f,
  9.49434042e-02f, 1.07302792e-01f, 3.21928561e-02f, -5.51551729e-02f, -1.66421030e-02f, -4.90323901e-02f, 6.26614392e-02f, 1.12027861e-01f, 1.00626692e-01f, 1.57971695e-01f,
  -7.68994391e-02f, -1.12123434e-02f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  8.74966606e-02f, 1.01494798e-02f, 5.09095564e-03f, 5.33561222e-03f, -1.59269366e-02f, -2.85984315e-02f, -2.42855608e-01f, -7.26085827e-02f, 9.06003490e-02f, -1.65573642e-01f,
  -3.33001651e-02f, -2.20679656e-01f, 1.27174705e-03f, 5.38386926e-02f, -2.43280847e-02f, 8.64700451e-02f, -8.58860686e-02f, -6.89637363e-02f, 4.58994210e-02f, -1.26326308e-01f,
  5.16477264e-02f, -8.21850821e-03f, -9.26950108e-03f, -4.22488041e-02f, 7.80408531e-02f, -6.24579145e-03f, 7.70416036e-02f, 1.04983173e-01f, 1.36299238e-01f, 1.00840300e-01f,
  1.78750753e-02f, 4.71984744e-02f, -1.30833797e-02f, -9.68774036e-02f, -3.98587435e-02f, -1.05452128e-01f, 8.39604959e-02f, 5.13247177e-02f, -8.51420090e-02f, -9.68291610e-02f,
  1.50384484e-02f, -3.13213281e-02f, 5.98065183e-02f, 5.91619313e-02f, -5.65558821e-02f, 7.64609873e-02f, -3.10178269e-02f, -3.10487188e-02f, -6.38108924e-02f, 2.05327794e-02f,
  -7.65539035e-02f, 6.03163689e-02f, -1.04633681e-01f, 4.13181745e-02f, 1.27975792e-01f, 5.38300425e-02f, 6.57036295e-03f, 5.70034347e-02f, 3.95973623e-02f, -9.68813002e-02f,
  -3.76876481e-02f, -1.31444109e-03f, -3.95996682e-02f, 1.40694082e-01f, -3.22232172e-02f, -4.01556194e-02f, 1.34513676e-02f, -1.13279738e-01f, 4.55647632e-02f, 2.36422736e-02f,
  1.92462400e-01f, 3.33068147e-02f, -7.45787844e-02f, -2.38434179e-03f, 7.70458430e-02f, 2.06727944e-02f, -4.30187061e-02f, 1.02897510e-01f, -7.05911890e-02f, -4.20365445e-02f,
  1.23970367e-01f, 1.02569714e-01f, -9.84296552e-04f, 1.40194610e-01f, 1.90132529e-01f, -8.29102937e-04f, 2.33681034e-02f, -7.39943795e-03f, -9.65944603e-02f, -1.28347417e-02f,
  -1.42121986e-01f, 1.29467204e-01f, -1.12051062e-01f, 7.65552297e-02f, 6.78842515e-02f, 1.22465260e-01f, -4.96631972e-02f, 6.36750832e-02f, -8.63584727e-02f, 1.01618044e-01f,
  8.29613358e-02f, -2.00883988e-02f, 9.80778858e-02f, 1.44801755e-02f, -4.10124362e-02f, 8.16023275e-02f, -1.16211794e-01f, 5.62525541e-02f, 2.08002508e-01f, 1.21468697e-02f,
  3.85677814e-02f, 4.37720530e-02f, 1.10231690e-01f, -3.77737097e-02f, -8.21646396e-03f, 1.61853861e-02f, 3.30379680e-02f, 1.24617353e-01f, 8.38949978e-02f, -1.04612611e-01f,
  -1.35538518e-01f, -1.25026062e-01f, -2.77471519e-03f, -5.11573963e-02f, -1.17401630e-01f, 7.17002004e-02f, 7.01440200e-02f, 1.14043001e-02f, -2.47772202e-01f, 1.11033574e-01f,
  6.44753575e-02f, -6.75504804e-02f, 3.21486630e-02f, 8.48617926e-02f, 1.69171572e-01f, -7.21745659e-03f, 6.93585277e-02f, 5.54461293e-02f, -7.95016512e-02f, 1.35987941e-02f,
  5.85028753e-02f, 1.64276697e-02f, 4.81693260e-02f, -8.64510983e-03f, -5.13367867e-03f, -2.41058785e-02f, 6.72961995e-02f, -7.70802572e-02f, 5.12722395e-02f, 4.11593169e-02f,
  -2.90576257e-02f, 2.13772170e-02f, 3.40972021e-02f, -6.53735772e-02f, -8.58366489e-02f, 8.54023732e-03f, -6.24734201e-02f, -7.61889592e-02f, -7.93263316e-02f, -1.04398794e-01f,
  5.58362566e-02f, -2.59116665e-02f, 3.71408053e-02f, 1.24186501e-02f, -1.23846091e-01f, -5.17311171e-02f, 5.08825742e-02f, 6.98320642e-02f, -7.80277848e-02f, 1.69858355e-02f,
  -2.12364700e-02f, 6.67719021e-02f, 2.45113559e-02f, 3.18255499e-02f, -6.87199980e-02f, 1.96105372e-02f, 3.97344306e-02f, 5.43745086e-02f, 1.09146133e-01f, -7.69847706e-02f,
  -1.11417770e-02f, 1.00009188e-01f, -4.43353169e-02f, 4.02150489e-02f, 6.10698462e-02f, 3.92184071e-02f, 2.09550071e-03f, 2.15915386e-02f, 1.23021960e-01f, 5.53652607e-02f,
  1.63125038e-01f, 7.21605495e-02f, -1.00647546e-01f, 1.01442672e-01f, -8.87412280e-02f, -1.31387515e-02f, 8.60419963e-03f, -3.86111401e-02f, 1.17421664e-01f, -3.77012119e-02f,
  2.87935510e-03f, -1.07794486e-01f, 9.56834331e-02f, -4.80645262e-02f, -1.63103580e-01f, -8.98014754e-02f, -1.58396959e-02f, -5.02749160e-03f, 4.67648767e-02f, -4.14931178e-02f,
  -1.71410181e-02f, -2.05507372e-02f, -7.45395944e-02f, -1.05818816e-01f, -7.49084055e-02f, -6.36576042e-02f, -1.36969602e-02f, -1.18816659e-01f, -5.75384051e-02f, -5.40361293e-02f,
  -2.23635033e-01f, 2.91449409e-02f, -9.69528407e-02f, -1.11906923e-01f, 2.91465186e-02f, -8.02138746e-02f, -8.30682665e-02f, -8.16594586e-02f, 5.29172421e-02f, -3.59627642e-02f,
  -1.80611357e-01f, 2.22765505e-02f, -8.62398669e-02f, -1.20998025e-01f, -1.62565649e-01f, -1.02024317e-01f, -5.97243384e-02f, -5.93102798e-02f, -3.10901329e-02f, 9.12535936e-02f,
  -1.18941456e-01f, 5.10621874e-04f, 1.57339382e-04f, -5.47651239e-02f, 5.58000207e-02f, -3.08651049e-02f, -1.35620907e-01f, -7.52195567e-02f, -2.79049557e-02f, 2.23697703e-02f,
  -6.64062276e-02f, -9.99902710e-02f, -2.72132782e-03f, -4.75172959e-02f, 5.16129062e-02f, -1.52230129e-01f, 5.12274019e-02f, 1.07751730e-04f, -7.95250200e-03f, 8.80726948e-02f,
  6.12042621e-02f, 1.06582128e-01f, 3.27853598e-02f, -5.42751141e-02f, -4.97654602e-02f, -9.67637002e-02f, -2.39844657e-02f, -4.57855910e-02f, -3.50313932e-02f, -9.77031142e-02f,
  2.46917829e-02f, 1.11335613e-01f, -7.93475583e-02f, -1.94766764e-02f, -1.98157746e-02f, 1.01576343e-01f, -4.49053273e-02f, 6.44550696e-02f, -2.58069299e-02f, 1.28925368e-01f,
  -3.92992012e-02f, 1.10922754e-01f, 8.30800682e-02f, 6.92459010e-03f, 5.30714653e-02f, 5.05069736e-03f, 2.95351143e-03f, 1.03923075e-01f, 8.03813413e-02f, -1.62877683e-02f,
  -3.20850872e-02f, 1.04854152e-01f, 1.80670425e-01f, 4.34415340e-02f, -9.40005109e-02f, 1.72949620e-02f, 5.27710989e-02f, -3.80352023e-03f, 1.11164764e-01f, 2.85807531e-02f,
  -3.71166877e-02f, -2.65477486e-02f, -3.14576514e-02f, -9.95015129e-02f, 1.00470828e-02f, 7.18204007e-02f, -1.23752169e-01f, 1.82581376e-02f, 8.73956084e-02f, -5.75602911e-02f,
  -5.15302569e-02f, -1.09545803e-02f, 3.96775417e-02f, 7.27911443e-02f, -4.63873111e-02f, -4.91324067e-02f, -1.39725760e-01f, -2.38305684e-02f, -3.49655822e-02f, 6.61017839e-03f,
  -1.40151665e-01f, 1.27898723e-01f, 3.71361524e-02f, 8.40674248e-03f, -1.06301069e-01f, 2.11366247e-02f, -1.84764817e-01f, -3.35494541e-02f, -3.09288502e-04f, 4.58133928e-02f,
  4.06137221e-02f, -4.67819758e-02f, 2.16538191e-01f, -8.37533474e-02f, 8.10608715e-02f, -4.63265218e-02f, -5.28983548e-02f, -7.89215695e-03f, 1.29171267e-01f, -1.08047649e-01f,
  9.34526473e-02f, 1.21622756e-01f, -2.76297554e-02f, -3.53747755e-02f, 1.75504118e-01f, -6.98252395e-02f, -5.20986952e-02f, -9.10702646e-02f, 1.14792064e-01f, 2.55856421e-02f,
  -1.20559447e-02f, 2.13612579e-02f, 6.76317737e-02f, 5.53728007e-02f, 1.80887029e-01f, -3.79676521e-02f, -7.83364475e-03f, 1.52083889e-01f, 6.17002510e-02f, 2.52001863e-02f,
  6.48047626e-02f, 3.38814668e-02f, -5.30946255e-02f, -5.07676564e-02f, 2.99074110e-02f, 2.83434335e-02f, -1.99111719e-02f, 9.73940194e-02f, 6.90026805e-02f, 2.15799119e-02f,
  6.40732124e-02f, 3.87853011e-02f, -1.27651185e-01f, 2.54778117e-02f, 7.14541152e-02f, 4.44229469e-02f, 3.74990925e-02f, 1.59596816e-01f, 6.08508214e-02f, 4.96694036e-02f,
  3.08316220e-02f, 2.34928615e-02f, -8.17301869e-02f, 4.98367511e-02f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  7.90193602e-02f, 3.44845876e-02f, 1.61334321e-01f, 2.12842688e-01f, -1.04482897e-01f, 9.00500268e-03f, -1.79976165e-01f, -8.02631453e-02f, 1.42727792e-01f, -1.08409896e-01f,
  5.14953732e-02f, 9.52398404e-02f, -2.61864476e-02f, 1.81930736e-01f, -1.83087096e-01f, 1.86655775e-01f, -2.74479389e-01f, 1.00060858e-01f, 7.53753632e-03f, 2.69544441e-02f,
  7.31503069e-02f, 1.32437155e-01f, -4.33845371e-02f, 8.40749517e-02f, 9.29013416e-02f, 1.28104791e-01f, 2.29188696e-01f, 2.11699218e-01f, 2.43104473e-01f, -4.35783230e-02f,
  1.33108482e-01f, 2.45713845e-01f, -2.24171042e-01f, -7.11077228e-02f, 2.86174774e-01f, -4.35873419e-02f, 9.56711695e-02f, 1.00640133e-01f, 5.54547086e-02f, -1.10910729e-01f,
  -9.99021605e-02f, -8.68754908e-02f, 1.83455557e-01f, -5.39505444e-02f, -1.06922142e-01f, -1.24902293e-01f, -8.83489698e-02f, -4.71450724e-02f, 5.57335503e-02f, 1.73862398e-01f,
  -8.31292048e-02f, 1.63220182e-01f, 1.08460225e-01f, 4.85186093e-02f, -4.75731306e-03f, 9.83209834e-02f, -8.15197453e-02f, 9.39097628e-02f, 6.70990422e-02f, 9.08155441e-02f,
  -2.05983669e-01f, 5.02013825e-02f, -1.25880539e-01f, 1.83317751e-01f, 8.73099118e-02f, -6.36015981e-02f, -1.65224541e-02f, -6.31107315e-02f, 1.31358176e-01f, -1.44804925e-01f,
  2.40541741e-01f, -1.15096822e-01f, -1.26213327e-01f, 1.95410289e-02f, -1.57730550e-01f, -7.18643442e-02f, 1.66239962e-02f, 2.10156515e-01f, -2.25352142e-02f, -6.61128163e-02f,
  1.86599851e-01f, -1.29966766e-01f, -1.71547502e-01f, 1.00145802e-01f, -1.30268648e-01f, -1.97489373e-02f, 4.66932133e-02f, 3.41217667e-02f, -4.94201183e-02f, 6.86678514e-02f,
  -4.80669327e-02f, 1.42580599e-01f, -9.62757245e-02f, 3.94395813e-02f, -8.50444585e-02f, 9.83099639e-02f, -6.92021381e-03f, 6.93606213e-02f, -1.55086786e-01f, 1.02815725e-01f,
  2.08612323e-01f, 8.31442997e-02f, -4.45336811e-02f, 8.81097317e-02f, 5.37900627e-02f, 5.57973385e-02f, 1.50516137e-01f, 8.73875767e-02f, 1.23154163e-01f, -4.61009368e-02f,
  2.05556974e-01f, -6.94550350e-02f, -6.82533607e-02f, 3.37840170e-02f, 1.20821424e-01f, -1.67850614e-01f, -1.55188948e-01f, 1.75867435e-02f, 1.38249844e-01f, -6.60261214e-02f,
  -6.78573474e-02f, 5.99045902e-02f, -2.44353935e-02f, -3.58707756e-02f, -1.26932248e-01f, -1.98731199e-02f, 1.01390660e-01f, 1.97695300e-01f, 3.47691961e-02f, -9.00985599e-02f,
  6.63178228e-03f, 5.49910171e-03f, -4.28433046e-02f, 5.95859662e-02f, -2.01969013e-01f, 1.92884647e-03f, -1.41686127e-01f, -7.70119503e-02f, 1.01089083e-01f, -1.34309292e-01f,
  -1.60422951e-01f, -1.14980288e-01f, -3.52371596e-02f, 1.66705251e-01f, -9.62587520e-02f, 7.80099109e-02f, -6.26685545e-02f, 1.38571948e-01f, -9.75606591e-02f, -1.40594095e-01f,
  -1.24473587e-01f, 3.83219980e-02f, -7.69655854e-02f, -3.40693854e-02f, 2.26668596e-01f, 7.88701791e-03f, 9.13426951e-02f, 2.59137869e-01f, 7.98251703e-02f, -1.31669149e-01f,
  9.77990106e-02f, -1.53190926e-01f, 5.26976250e-02f, -1.15092330e-01f, 9.26783234e-02f, 1.77323297e-01f, 9.45655555e-02f, -7.71615133e-02f, 1.67830333e-01f, -5.91301769e-02f,
  1.36849374e-01f, 1.77854225e-01f, -1.97557267e-02f, 1.50170818e-01f, -1.26008853e-01f, -2.12470889e-02f, -3.71886455e-02f, 2.59771079e-01f, -1.85870662e-01f, 1.39076144e-01f,
  -8.11724961e-02f, -9.90218893e-02f, 1.16556153e-01f, 1.51188076e-01f, -2.48362422e-02f, -2.84495149e-02f, 1.31009653e-01f, -4.76895869e-02f, -5.62527813e-02f, 1.25678018e-01f,
  -1.09212339e-01f, 1.22381061e-01f, 7.79828522e-03f, 4.37567048e-02f, 4.04232070e-02f, -7.69522227e-03f, 1.64579209e-02f, 4.10866886e-02f, -1.15859052e-02f, -1.00329872e-02f,
  3.98749821e-02f, 3.72430906e-02f, 1.87939122e-01f, -3.20831500e-02f, -8.12122449e-02f, 3.13770063e-02f, -1.33646712e-01f, 1.75189689e-01f, -3.23987231e-02f, 6.88750520e-02f,
  -1.08992510e-01f, 7.63907433e-02f, 3.33064795e-02f, -1.45322040e-01f, -1.81530192e-01f, -6.74655661e-02f, -2.28229091e-02f, -1.15538105e-01f, 6.44277930e-02f, -5.33390157e-02f,
  3.14728320e-02f, 4.78046015e-02f, 1.36035472e-01f, -1.72987372e-01f, -1.23385405e-02f, 1.13659650e-02f, 1.11730449e-01f, -5.79322614e-02f, -5.75531609e-02f, 8.90992880e-02f,
  1.49149328e-01f, -3.05641759e-02f, -9.75800529e-02f, 9.91591439e-02f, -5.46184331e-02f, -4.73082112e-03f, 3.36199813e-02f, 4.84291911e-02f, -3.29447612e-02f, -8.09072237e-03f,
  1.01395294e-01f, 2.22817183e-01f, -1.69440299e-01f, 2.54825175e-01f, 5.61933815e-02f, -3.20532210e-02f, -1.86564267e-01f, 1.41493812e-01f, -1.39229283e-01f, -1.51338860e-01f,
  -1.20244488e-01f, 4.76879068e-02f, -1.39081821e-01f, 1.91359580e-01f, 3.16021359e-03f, 6.24220110e-02f, -7.47384354e-02f, 1.92831054e-01f, 8.85527581e-02f, 9.18340385e-02f,
  5.88711463e-02f, -1.11129973e-02f, -3.26578990e-02f, 1.04181282e-01f, 1.44814238e-01f, -8.31276830e-03f, -2.37476570e-03f, 7.59687349e-02f, 1.17176346e-01f, 1.27736092e-01f,
  8.26026723e-02f, -3.92771326e-02f, -1.44048065e-01f, 1.41046181e-01f, 1.53823838e-01f, -3.08369279e-01f, 3.99748385e-02f, 2.26641074e-01f, -7.83829764e-02f, -7.27376863e-02f,
  2.95379966e-01f, 1.68815255e-01f, 2.51453608e-01f, -7.88508058e-02f, 1.94416404e-01f, -2.15932857e-02f, 1.43479332e-02f, 1.36941960e-02f, 3.18844803e-02f, -1.21507607e-02f,
  7.80623704e-02f, -1.78565130e-01f, -1.55724332e-01f, -5.34297004e-02f, -8.24780837e-02f, -2.09374316e-02f, 1.28010899e-01f, -5.46388179e-02f, 2.30876170e-02f, -1.01511568e-01f,
  -2.09299967e-01f, -7.40996227e-02f, -1.19610712e-01f, -7.95393288e-02f, 6.70455396e-02f, 7.25753903e-02f, 4.17555757e-02f, -1.16830440e-02f, 6.87352791e-02f, 1.17297158e-01f,
  2.45422148e-03f, 1.82372078e-01f, 1.43255845e-01f, 2.27589145e-01f, 6.00307100e-02f, 1.42979890e-01f, 5.66229522e-02f, -6.08644523e-02f, 5.43552265e-03f, 2.26252228e-02f,
  7.79004246e-02f, 1.08409546e-01f, 4.26104255e-02f, 2.46331200e-01f, 2.89230980e-03f, 7.37735555e-02f, -2.28924200e-01f, 1.36582598e-01f, -2.87907030e-02f, 1.32618798e-02f,
  6.03468269e-02f, -6.94362372e-02f, 3.88119817e-02f, -1.08424120e-01f, -8.70226771e-02f, 6.49072379e-02f, -5.31287417e-02f, 9.94621292e-02f, -3.00505739e-02f, 1.50561720e-01f,
  -8.87671299e-03f, 5.24369022e-03f, -2.63525248e-02f, 4.63853888e-02f, -5.18594608e-02f, -1.50918933e-02f, 5.13038598e-02f, -1.02099821e-01f, 2.69906223e-01f, 6.82280213e-02f,
  9.15242881e-02f, -8.05460140e-02f, -7.37646520e-02f, -5.31802662e-02f, 2.24099278e-01f, -7.28295743e-02f, -7.56968185e-02f, 1.33090168e-01f, 2.62895040e-02f, -6.18982315e-02f,
  6.70894310e-02f, 8.87870509e-03f, 3.68885361e-02f, -7.06068277e-02f, -1.27189010e-01f, -6.44211471e-02f, 5.75001165e-03f, 3.16133983e-02f, 7.58756250e-02f, 1.14186220e-01f,
  1.43418953e-01f, 1.54719785e-01f, -1.54798046e-01f, -8.50955322e-02f, -5.90535663e-02f, 1.44427031e-01f, -1.44864265e-02f, 5.37249632e-02f, 1.21665604e-01f, 4.15113904e-02f,
  8.42598602e-02f, 2.00341716e-01f, -2.45383203e-01f, -6.59750327e-02f, -2.45483462e-02f, -7.45553151e-03f, -5.78719825e-02f, -4.25355285e-02f, 1.08731911e-01f, -6.35278746e-02f,
  9.97165665e-02f, -1.60122648e-01f, 5.36050787e-03f, -2.51525547e-03f, -3.57332118e-02f, -6.91040307e-02f, -2.36724410e-02f, 2.14842707e-01f, -5.44095077e-02f, -5.51708713e-02f,
  -3.54595046e-04f, -9.26755294e-02f, -4.62625772e-02f, -1.88515615e-02f, -1.26735806e-01f, -2.82319393e-02f, 2.93013304e-02f, 1.63104191e-01f, -3.63693535e-02f, -1.77274365e-02f,
  -6.25155196e-02f, 1.56889543e-01f, -1.36062264e-01f, -3.50962579e-02f, -7.75204897e-02f, 1.99169502e-01f, -6.00665249e-02f, 4.74181734e-02f, 9.55419149e-03f, 1.08088858e-01f,
  8.85120258e-02f, -9.01239086e-03f, -3.21233794e-02f, 5.00701293e-02f, -2.77476031e-02f, 2.27779150e-02f, -1.78119000e-02f, 2.80232597e-02f, 1.40404820e-01f, 4.65747202e-03f,
  1.32192433e-01f, -1.75532028e-01f, -8.63131732e-02f, -5.40499501e-02f, 1.46206869e-02f, -1.34495959e-01f, -1.53263152e-01f, -7.23467628e-03f, 1.64136589e-01f, -1.60041936e-02f,
  -4.28982340e-02f, 1.33178830e-01f, -2.76437998e-02f, 3.33386883e-02f, -9.80265215e-02f, -2.58888096e-01f, 5.55482768e-02f, 8.73274058e-02f, 7.76166767e-02f, 8.11546519e-02f,
  1.22418210e-01f, -5.90831451e-02f, -6.49852306e-02f, 8.47514272e-02f, -7.04285353e-02f, 2.56507788e-02f, 3.19542065e-02f, 1.49905263e-02f, 1.71436295e-01f, 6.81569874e-02f,
  1.30498499e-01f, -5.37302829e-02f, -4.42509204e-02f, 7.29893297e-02f, 7.44677335e-02f, 5.41367680e-02f, 1.67891055e-01f, -8.71893093e-02f, 1.95233271e-01f, 1.05173670e-01f,
  -4.65857647e-02f, 1.30597070e-01f, 1.08961083e-01f, -7.00253248e-02f, 7.62156993e-02f, -9.87454280e-02f, 2.31318623e-02f, -3.66638857e-03f, 5.13590919e-03f, -5.86614646e-02f,
  -8.41369554e-02f, 1.24792397e-01f, 1.86335638e-01f, -1.77430958e-02f, -1.16498396e-01f, -8.30348358e-02f, 4.06501815e-02f, 5.80202192e-02f, -5.26892282e-02f, 1.29777178e-01f,
  -1.16207972e-01f, 2.72752419e-02f, 7.55891055e-02f, -2.14139232e-03f, 1.68464370e-02f, -6.66619539e-02f, 1.53204441e-01f, 1.67567477e-01f, 4.04018201e-02f, 1.13726199e-01f,
  3.69898938e-02f, 1.93696037e-01f, -1.51769876e-01f, -4.13303711e-02f, -2.83790529e-02f, 5.40658683e-02f, -3.40466425e-02f, 2.50573337e-01f, 1.33011807e-02f, 1.80797547e-01f,
  9.86203775e-02f, 7.52197253e-03f, 3.90999354e-02f, 1.29909990e-02f, 8.48287791e-02f, -3.61626893e-02f, 2.18351241e-02f, -9.40922797e-02f, 1.19594701e-01f, -3.45232822e-02f,
  6.46898299e-02f, 1.09053522e-01f, -1.82211116e-01f, 1.55520052e-01f, 2.29534939e-01f, 1.97910160e-01f, 7.18320832e-02f, -7.28528127e-02f, 3.41059379e-02f, 1.04689576e-01f,
  2.82105468e-02f, -8.40139166e-02f, -2.65589706e-03f, 5.72454408e-02f, 1.21945113e-01f, 3.44155766e-02f, 1.97632924e-01f, 6.94102943e-02f, 3.31233516e-02f, 2.98228506e-02f,
  -3.41927893e-02f, -6.90162405e-02f, -7.76183829e-02f, 1.89724401e-01f, -8.51602778e-02f, -6.56928271e-02f, 1.78886980e-01f, 2.00095659e-04f, 1.28277931e-02f, -5.48315160e-02f,
  -2.63126679e-02f, 4.30411547e-02f, 1.05741285e-01f, -1.06770530e-01f, 5.02711572e-02f, -5.32716000e-03f, 2.03438729e-01f, -2.70548053e-02f, 1.32201433e-01f, 2.19380353e-02f,
  -2.05736216e-02f, -1.47345871e-01f, 1.70301154e-01f, -1.94815844e-01f, -1.71789213e-03f, 3.19072530e-02f, 6.87090531e-02f, -1.27604991e-01f, 1.60518638e-03f, 1.87779471e-01f,
  5.14131896e-02f, 1.81189269e-01f, 5.42020462e-02f, -5.93741722e-02f, -4.31332141e-02f, 3.37201767e-02f, -3.87786590e-02f, -2.43776571e-02f, 1.16748558e-02f, -9.57908407e-02f,
  -1.35492161e-02f, -7.73730315e-03f, 8.66163447e-02f, -7.54903117e-03f, 1.09288067e-01f, -1.11634336e-01f, 8.77016857e-02f, 1.17814727e-01f, -2.11561378e-02f, 9.30413976e-03f,
  -7.04936534e-02f, 1.33108079e-01f, -2.00624429e-02f, -5.53886686e-03f, 4.72480394e-02f, -2.31595457e-01f, 2.07310498e-01f, 1.09102331e-01f, -1.30921319e-01f, -6.82711378e-02f,
  4.51953001e-02f, 1.56381726e-02f, 1.17956035e-01f, -8.91222358e-02f, -1.60558388e-01f, -8.94476548e-02f, -1.47645595e-02f, 1.14353551e-02f, -5.89407235e-02f, 6.95568100e-02f,
  4.74926271e-02f, -5.38220480e-02f, -1.03304751e-01f, -4.67828065e-02f, -3.99409197e-02f, 3.86413410e-02f, -1.90094963e-01f, -1.46736298e-02f, -8.46013948e-02f, 1.56369463e-01f,
  -2.77457964e-02f, -1.58372056e-02f, -1.28221661e-01f, -2.88683355e-01f, -2.03178804e-02f, 9.00776461e-02f, -2.08295017e-01f, 1.20710909e-01f, 1.24625079e-01f, 5.99633791e-02f,
  -1.07944608e-01f, 1.82303086e-01f, -9.51316059e-02f, -8.08045734e-03f, -1.89044066e-02f, 2.46651858e-01f, -2.31160313e-01f, -5.90950660e-02f, 2.92082042e-01f, 1.35573834e-01f,
  3.48497219e-02f, -1.35367334e-01f, 1.10538661e-01f, -6.33433163e-02f, 1.87597293e-02f, -7.35259354e-02f, -1.93487912e-01f, -8.73685107e-02f, -1.21579356e-01f, -1.33273855e-01f,
  8.03843290e-02f, -1.16399415e-01f, 1.58074331e-02f, 6.08434118e-02f, -5.95413037e-02f, 1.45779893e-01f, 2.36256663e-02f, -3.31503786e-02f, -1.10008322e-01f, 1.90370265e-04f,
  -3.48235145e-02f, 3.91586982e-02f, -1.75429434e-02f, -7.47800320e-02f, -9.95974392e-02f, -1.10955529e-01f, -2.35352814e-01f, 1.00964040e-03f, 1.03934199e-01f, 2.87719686e-02f,
  4.98575568e-02f, 6.81930855e-02f, -1.70777198e-02f, 7.12660700e-02f, -1.19524315e-01f, -7.74211660e-02f, 4.03436041e-03f, 1.40292600e-01f, 2.61663496e-01f, -2.17456296e-02f,
  -9.53025892e-02f, 7.08638579e-02f, -8.15100670e-02f, 1.99366003e-01f, 2.86688834e-01f, 3.78545821e-02f, 9.08487290e-02f, -8.73047784e-02f, -4.79271524e-02f, 1.28102139e-01f,
  6.25857487e-02f, 1.66287273e-01f, -1.65748194e-01f, -1.20295145e-01f, 8.30013230e-02f, 9.45599228e-02f, -8.12306851e-02f, -3.76833677e-02f, -2.15885192e-01f, 1.03109419e-01f,
  -8.06208253e-02f, -9.34450887e-03f, -2.31323838e-02f, 2.08923504e-01f, -7.98133016e-02f, 2.01891258e-01f, 1.93097785e-01f, 1.54315382e-01f, 6.08764961e-02f, 9.49603096e-02f,
  -3.35619837e-01f, 4.03690040e-02f, 1.98693886e-01f, -7.95848668e-02f, -1.19135752e-01f, 3.41093428e-02f, 1.98957503e-01f, 2.14045332e-03f, 1.16242386e-01f, 5.46520986e-02f,
  -1.03336520e-01f, 8.27992335e-02f, 1.87114820e-01f, -2.83428311e-01f, -8.47726408e-03f, 1.55355647e-01f, -7.98820406e-02f, 1.20259915e-02f, 2.54511178e-01f, 1.78922817e-01f,
  1.16864048e-01f, -4.12233658e-02f, 2.20504418e-01f, -4.25334983e-02f, 2.02457067e-02f, 7.27311671e-02f, 4.86012734e-02f, -1.62964642e-01f, 2.07987189e-01f, -2.03908741e-01f,
  -7.64243901e-02f, 1.06628537e-01f, -3.19211744e-02f, -1.59191787e-01f, 1.63686052e-01f, -2.01960072e-01f, 1.51661143e-01f, -1.18819550e-01f, -2.50286907e-01f, 8.26229807e-03f,
  -7.23972246e-02f, -4.90631163e-02f, -2.16649603e-02f, -4.28275578e-02f, 9.50370505e-02f, -2.47971006e-02f, -1.26919687e-01f, 8.21128115e-02f, 1.19813576e-01f, 9.02716741e-02f,
  7.48418868e-02f, 2.18246013e-01f, 1.26725137e-01f, -2.36402750e-02f, 6.08694106e-02f, 2.03195643e-02f, -1.16092145e-01f, 1.21453620e-01f, -1.29611250e-02f, -9.07369331e-02f,
  8.77876505e-02f, 1.19450651e-02f, -1.95020437e-03f, 3.34342010e-02f, -1.95468828e-01f, -1.47601441e-01f, -8.63190815e-02f, -1.36596292e-01f, 3.87214608e-02f, -1.04405150e-01f,
  1.17680915e-01f, 5.21423556e-02f, -3.09783705e-02f, 6.70588166e-02f, 7.69370794e-02f, -7.57399946e-02f, -1.35374904e-01f, -1.30103886e-01f, -3.97446612e-03f, 2.05659717e-02f,
  -3.32303084e-02f, -5.26364930e-02f, -2.01498605e-02f, -4.55810502e-02f, -1.17176287e-01f, -1.75962951e-02f, 4.72012796e-02f, -1.95431843e-01f, 1.09492891e-01f, 2.02749386e-01f,
  -1.29235769e-02f, 6.86321259e-02f, -4.90523688e-02f, 7.82153085e-02f, -9.98242199e-02f, 3.78384418e-03f, 2.27081180e-01f, -8.63927975e-03f, -3.76898162e-02f, 1.96764052e-01f,
  -9.50431153e-02f, 1.72540173e-01f, 2.53008604e-01f, 3.94164883e-02f, 1.04233831e-01f, -1.25681162e-01f, -1.73237666e-01f, -1.66551865e-04f, 4.43134084e-03f, -1.66266747e-02f,
  -2.01339185e-01f, -6.63217902e-02f, 7.64826313e-02f, -1.77900195e-02f, -7.36201108e-02f, -8.45138356e-02f, -1.26861319e-01f, 6.07429668e-02f, -1.78289542e-03f, -1.51014656e-01f,
  -1.79042593e-02f, 1.47635564e-01f, -5.65533079e-02f, -1.87303987e-03f, -7.04954714e-02f, -1.05793178e-01f, 7.14296326e-02f, 7.44953752e-02f, 2.15722188e-01f, -2.66884062e-02f,
  -7.60178268e-02f, 2.18140986e-02f, -1.30600750e-01f, 9.14161205e-02f, 1.19914385e-02f, 2.34076232e-01f, 9.99565721e-02f, -1.14304468e-01f, 9.97297168e-02f, 9.37533114e-05f,
  -6.40665297e-04f, -4.53381278e-02f, -9.40886978e-03f, 1.45464242e-01f, 7.99843073e-02f, 7.08572343e-02f, 1.00795045e-01f, 1.51171863e-01f, -3.37701361e-03f, 5.34650348e-02f,
  -1.40880063e-01f, 2.95660878e-03f, -1.55018479e-01f, 1.97943151e-01f, 5.87011650e-02f, 5.52726388e-02f, -3.40778604e-02f, 1.84817761e-01f, 1.48444861e-01f, -3.35504860e-02f,
  -1.36705995e-01f, 7.65300319e-02f, 9.62666422e-02f, -3.05058085e-03f, 8.24140385e-02f, 5.23986481e-02f, 2.23811314e-01f, -1.12086616e-03f, 1.91635296e-01f, 5.42789698e-02f,
  1.18617341e-01f, -1.48796529e-01f, 1.69722095e-01f, -2.03540757e-01f, -9.45610479e-02f, -1.09502990e-02f, 1.91159710e-01f, 6.46659965e-03f, 1.51596233e-01f, 1.45462871e-01f,
  1.53551176e-01f, 1.14674367e-01f, -1.81769039e-02f, -1.02448516e-01f, 2.52510104e-02f, 1.46501943e-01f, 8.53394568e-02f, -9.79485661e-02f, 2.32978035e-02f, -8.48602410e-03f,
  3.26414332e-02f, 3.50639597e-02f, -1.29409224e-01f, -1.13490134e-01f, -8.76152366e-02f, -1.00087896e-01f, 4.33359258e-02f, -7.98613280e-02f, 1.96989179e-02f, -3.84529158e-02f,
  2.63696164e-02f, 6.51203468e-02f, -6.81481659e-02f, -5.64970821e-02f, -4.10881341e-02f, -6.34491593e-02f, -1.00754924e-01f, -1.03759822e-02f, -4.25145477e-02f, -3.45177762e-02f,
  -1.09652635e-02f, -2.47673038e-02f, -1.49587438e-01f, 6.23491034e-03f, 3.31139341e-02f, -7.09640980e-02f, 1.71658054e-01f, 7.20712021e-02f, 1.38368709e-02f, -3.26585546e-02f,
  -1.28838286e-01f, -1.54861128e-02f, 1.91765334e-02f, 8.09388682e-02f, 1.75347224e-01f, -4.55797538e-02f, -5.49260043e-02f, 1.09600544e-01f, -6.67368202e-03f, 2.21226886e-01f,
  1.37901410e-01f, 7.69025460e-02f, 1.84295811e-02f, -8.26726481e-02f, -3.34244706e-02f, 1.47457317e-01f, -7.72084743e-02f, -1.82801094e-02f, -2.77681667e-02f, -8.13692957e-02f,
  1.06486464e-02f, 1.06606632e-01f, -1.40372990e-02f, 1.24497265e-02f, -4.30123508e-02f, 5.31190671e-02f, -4.74767089e-02f, -4.39982787e-02f, -3.03695109e-02f, 1.02721296e-01f,
  9.34922695e-02f, 8.27222466e-02f, 8.60032141e-02f, 2.14171037e-02f, 1.16038688e-01f, -6.54149279e-02f, 1.30125582e-01f, -9.01056677e-02f, 3.99802737e-02f, 1.39205111e-02f,
  -1.25525236e-01f, 4.51142751e-02f, -6.36935374e-03f, 6.51068464e-02f, -8.74766409e-02f, -1.95538297e-01f, 2.85284612e-02f, -7.57522434e-02f, -9.70133469e-02f, 3.59943099e-02f,
  -1.04887225e-01f, 9.80948955e-02f, 4.95149903e-02f, 7.42848590e-02f, 1.44014075e-01f, 1.73229381e-01f, 9.31131989e-02f, 6.42870814e-02f, -8.97169765e-03f, -3.34991664e-02f,
  -1.01776026e-01f, 2.00560644e-01f, -9.27939788e-02f, -1.12846017e-01f, -1.68459956e-02f, 1.40293315e-01f, 1.21119261e-01f, 1.03445724e-02f, 2.43786373e-03f, 5.27982377e-02f,
  3.39055881e-02f, 4.54981588e-02f, 1.03564516e-01f, -3.77679989e-02f, 1.38100572e-02f, -9.32148844e-02f, 1.45119622e-01f, -4.40932550e-02f, 1.35759234e-01f, -1.64741576e-01f,
  7.04764649e-02f, -1.41269356e-01f, -4.67125699e-02f, -2.87383255e-02f, 8.19915608e-02f, -8.90974328e-02f, -7.54811317e-02f, 6.63903058e-02f, -6.49175197e-02f, -4.08224463e-02f,
  -1.42463624e-01f, -9.71059501e-02f, -6.78908601e-02f, -4.48767394e-02f, 1.27493501e-01f, 2.04396904e-01f, 7.00024292e-02f, 1.00973323e-01f, -3.84635590e-02f, -1.01635521e-02f,
  1.24696624e-02f, 1.50391906e-01f, -2.29247194e-03f, 1.89200088e-01f, -1.18371166e-01f, 1.24879880e-02f, -5.82234003e-02f, 2.20053732e-01f, -1.83233663e-01f, 9.31748282e-03f,
  1.35512382e-01f, 1.30816773e-02f, -1.98519021e-01f, 2.01856315e-01f, -1.35400534e-01f, 3.84049006e-02f, 1.74450427e-01f, 1.95897982e-01f, -4.05627713e-02f, 3.54965962e-03f,
  8.92634317e-02f, 2.00301573e-01f, 1.15992710e-01f, -5.07346727e-02f, 6.10681437e-02f, 1.47896335e-01f, -1.14667177e-01f, -1.62063181e-01f, 1.32738233e-01f, 1.92384511e-01f,
  1.04166679e-01f, -9.44472402e-02f, 1.15729952e-02f, -4.70223315e-02f, -9.50276777e-02f, 1.12163261e-01f, 6.07102513e-02f, -1.81460321e-01f, 7.39526972e-02f, -1.33276924e-01f,
  1.83267012e-01f, -6.83049783e-02f, 2.24628687e-01f, 1.64503306e-02f, 9.00527090e-02f, 2.16505349e-01f, 8.57543573e-02f, -7.51828179e-02f, -3.12508084e-03f, -1.80838574e-02f,
  -1.45998865e-01f, 1.55038580e-01f, -6.28861710e-02f, -3.23710740e-02f, -9.67971049e-03f, 7.56690130e-02f, -2.20572233e-01f, -3.29376720e-02f, 8.36551115e-02f, 2.61258423e-01f,
  7.38318563e-02f, 2.09166259e-02f, 7.64726102e-02f, 1.52168930e-01f, 1.18904613e-01f, 6.91891760e-02f, 2.53982227e-02f, 2.06738889e-01f, -1.01663291e-01f, 1.34592265e-01f,
  -9.21593085e-02f, 9.85970199e-02f, 4.49289940e-02f, -1.01822779e-01f, 9.26336944e-02f, 1.24863364e-01f, 3.68495472e-02f, 2.29899183e-01f, 5.55852689e-02f, 4.28229868e-02f,
  1.55504122e-01f, 1.29772455e-01f, 6.48251642e-03f, 1.47599846e-01f, -2.79236436e-02f, 9.35057998e-02f, 6.28837869e-02f, 7.61575699e-02f, -8.37559626e-02f, 1.84914023e-02f,
  -7.25409985e-02f, -1.72985390e-01f, 4.82803471e-02f, 1.01429075e-01f, 6.36691153e-02f, -1.41027838e-01f, -1.44952953e-01f, 1.11778779e-02f, 1.47858039e-01f, -1.21265829e-01f,
  1.21138573e-01f, -1.52144924e-01f, -6.83938414e-02f, -3.85465138e-02f, 1.72755167e-01f, 9.73375291e-02f, 2.26515293e-01f, -2.08582327e-01f, 2.29967773e-01f, -7.18439445e-02f,
  1.86717659e-01f, 8.07399824e-02f, -9.50714294e-03f, -1.87752858e-01f, 9.79263932e-02f, 5.86060323e-02f, 2.24813819e-01f, -1.68560609e-01f, 1.60040721e-01f, -7.54668610e-04f,
  -1.10296324e-01f, 1.46241663e-02f, -5.90454601e-02f, -1.30791590e-01f, -3.58352624e-02f, -2.11911835e-02f, 1.26124192e-02f, -4.80096452e-02f, 3.74026865e-01f, 6.46989867e-02f,
  2.78430358e-02f, 6.66025206e-02f, -1.39264181e-01f, 1.01905860e-01f, -2.30355382e-01f, 9.28114951e-02f, -1.26759276e-01f, 1.44078016e-01f, -9.00167748e-02f, 1.92352501e-03f,
  -5.59313446e-02f, 1.96416482e-01f, -8.50714892e-02f, -5.85329942e-02f, -3.32703888e-02f, 8.38225782e-02f, 7.32535496e-02f, 1.69316754e-01f, 9.71969888e-02f, 1.95353851e-01f,
  -1.03360191e-01f, 1.36662632e-01f, 8.45753327e-02f, 1.48281842e-01f, -5.62608130e-02f, -1.03619784e-01f, 3.19641121e-02f, 2.29089350e-01f, 1.05564155e-01f, -8.08006153e-02f,
  -5.90668898e-03f, 8.40467289e-02f, -7.33456761e-02f, 5.19847199e-02f, 1.90345645e-01f, 8.63929391e-02f, 1.30480736e-01f, 3.15529071e-02f, 1.84109718e-01f, -1.90655291e-02f,
  2.28369117e-01f, 1.08031534e-01f, -8.52987394e-02f, -2.43836325e-02f, 2.96894997e-01f, 6.56498522e-02f, 3.17439772e-02f, -4.38103303e-02f, 2.49935091e-02f, 5.10871224e-02f,
  1.75558887e-02f, -4.83799800e-02f, -9.50794518e-02f, 3.95732699e-03f, 1.90973565e-01f, 5.29788658e-02f, -1.45729939e-02f, -5.66528104e-02f, -2.46917158e-02f, -2.32868046e-02f,
  1.01082744e-02f, -5.13924100e-02f, 1.37115819e-02f, -8.22492093e-02f, -8.73823389e-02f, -6.77099377e-02f, 9.57126319e-02f, -5.85740730e-02f, -7.38931447e-02f, -1.81136541e-02f,
  5.19995578e-02f, -2.80273636e-03f, -1.08506523e-01f, -8.86453018e-02f, 2.46610586e-02f, -8.08737800e-02f, -6.81884512e-02f, -2.90885707e-03f, -3.36929783e-02f, -8.25981647e-02f,
  7.90954903e-02f, -1.27292639e-02f, -9.13707465e-02f, -2.62782499e-02f, 1.12823308e-01f, -3.75798494e-02f, 1.13932304e-01f, 9.14420262e-02f, 9.52447951e-03f, -3.25004160e-02f,
  -1.16050206e-01f, -3.46447192e-02f, -2.43976023e-02f, 1.27336895e-02f, 9.29892808e-02f, -3.85867879e-02f, -2.10078042e-02f, 2.35234387e-02f, -7.59205073e-02f, 2.18958557e-01f,
  5.98894805e-02f, 8.09076205e-02f, -4.65716831e-02f, -1.65496290e-01f, -6.85491115e-02f, 1.59989417e-01f, -6.99856728e-02f, 2.25954317e-02f, -1.69025920e-02f, -3.82766128e-02f,
  1.11824255e-02f, 2.43626256e-02f, 3.12610306e-02f, 6.83686808e-02f, -3.02609187e-02f, 7.75047094e-02f, -1.71100739e-02f, -1.34586141e-01f, 4.37384993e-02f, 1.97657943e-01f,
  -1.33270817e-02f, -1.40039288e-02f, 2.34601162e-02f, 3.74800502e-03f, -2.62432378e-02f, -3.45544219e-02f, 4.83111627e-02f, 4.25658226e-02f, -8.33660439e-02f, 7.57859722e-02f,
  -1.56100765e-01f, -7.47243920e-03f, -1.24982581e-01f, -1.53175339e-01f, 1.53834403e-01f, -2.06283927e-02f, 9.50832292e-03f, 2.21286491e-01f, 3.12333275e-02f, 1.49234205e-01f,
  8.17394443e-03f, 2.65311692e-02f, 8.88864100e-02f, 1.57187134e-01f, 1.05218440e-01f, 1.98673889e-01f, 9.91386101e-02f, 3.21477130e-02f, 4.24244665e-02f, 1.91552758e-01f,
  -1.71115790e-02f, -8.39107018e-03f, 1.51831239e-01f, -8.55446085e-02f, 4.42146044e-03f, 1.06956556e-01f, 1.56063855e-01f, 1.25936672e-01f, -1.57130122e-01f, 2.06620954e-02f,
  2.38945708e-01f, -1.12493373e-01f, 2.21524402e-01f, -8.78896639e-02f, -1.42793715e-01f, 1.13831900e-01f, -1.04212992e-01f, 2.36428171e-01f, 8.30940157e-02f, -1.04110420e-01f,
  -2.00457387e-02f, -6.00828491e-02f, 1.04051359e-01f, 5.73415756e-02f, 3.02744601e-02f, -3.44270132e-02f, 1.31461963e-01f, -5.20157740e-02f, 3.08102190e-01f, -1.27537474e-01f,
  1.54717863e-01f, 2.15455964e-01f, -2.89939828e-02f, 5.15858419e-02f, -3.65695618e-02f, -6.59674928e-02f, -5.84172830e-02f, -4.14841296e-03f, 1.45176668e-02f, 2.00668480e-02f,
  1.90475717e-01f, -9.66793671e-02f, -4.13375758e-02f, -5.78884855e-02f, -2.82462072e-02f, 2.25879569e-02f, -1.04858764e-01f, 1.54081047e-01f, -7.28056654e-02f, -1.52502907e-02f,
  8.39994177e-02f, 1.14705088e-02f, -1.09382890e-01f, 1.62491858e-01f, 5.36773242e-02f, -7.75680840e-02f, 8.19199160e-02f, 1.36405960e-01f, -9.77059975e-02f, -9.97220725e-03f,
  5.85642010e-02f, 1.37277737e-01f, -7.57758245e-02f, 1.41782977e-04f, -1.09695597e-02f, 1.35772005e-01f, -3.80053259e-02f, -1.77899934e-02f, -8.82692114e-02f, 8.60584751e-02f,
  1.85136050e-01f, -4.10290994e-02f, -1.03999777e-02f, 2.48190463e-02f, -2.27530785e-02f, 7.94570670e-02f, 7.12594669e-03f, 7.24983439e-02f, 1.00160755e-01f, -2.73406338e-02f,
  1.55479819e-01f, -8.99823979e-02f, -2.54424661e-02f, 3.03665139e-02f, 3.65907587e-02f, -2.11164616e-02f, 9.58507061e-02f, -6.52563274e-02f, 1.60395261e-03f, -5.58675341e-02f,
  -1.08405590e-01f, 3.58114541e-02f, -2.19522621e-02f, 2.62494516e-02f, -1.16998255e-01f, 2.49761287e-02f, 1.25140935e-01f, 2.86142323e-02f, 1.73796937e-01f, 6.17501736e-02f,
  -6.74357489e-02f, 7.24215135e-02f, 7.26720914e-02f, -1.09854065e-01f, -1.40582621e-01f, -4.66903895e-02f, -4.03410681e-02f, 4.82455594e-03f, 1.61280185e-01f, -9.75347981e-02f,
  7.86736608e-02f, 5.02738468e-02f, -1.18546970e-01f, 2.20616847e-01f, 1.20981388e-01f, -1.41106918e-01f, -1.43975064e-01f, 2.01281473e-01f, -9.59893689e-02f, -7.13613853e-02f,
  2.94423825e-03f, 1.91428185e-01f, -1.60923004e-01f, -8.20744038e-03f, 2.06475630e-02f, 8.46054628e-02f, 1.48135439e-01f, -6.00680895e-02f, 1.63801506e-01f, -7.97041040e-03f,
  -1.33717328e-01f, -2.99226958e-02f, 8.25929344e-02f, -1.33574847e-02f, 8.87173936e-02f, 1.41705712e-03f, 2.22104922e-01f, -3.93948518e-02f, -1.12412058e-01f, 2.29293093e-01f,
  2.36432571e-02f, 3.06283869e-02f, 2.13259473e-01f, -2.16418467e-02f, 2.53836632e-01f, -4.58585620e-02f, 2.72528715e-02f, 1.65012345e-01f, 3.77714373e-02f, 1.43232852e-01f,
  -1.53499871e-01f, -1.40071586e-01f, -6.01476580e-02f, 3.00483983e-02f, -1.96537629e-01f, 2.27590222e-02f, -2.38414362e-01f, 7.73410201e-02f, -1.38627350e-01f, 1.73032388e-01f,
  -8.84342268e-02f, 6.95772618e-02f, -5.20184264e-02f, -1.68515798e-02f, -1.77305907e-01f, -5.01440130e-02f, -1.26668319e-01f, 2.00102217e-02f, 2.61541069e-01f, 9.42008272e-02f,
  6.98825121e-02f, 5.56504391e-02f, 9.58367735e-02f, 5.64304888e-02f, -7.25123216e-04f, -5.41157946e-02f, -7.99577311e-02f, 1.50537148e-01f, 9.39155929e-03f, -1.48424208e-02f,
  1.42110839e-01f, 1.82506710e-01f, 2.00318709e-01f, -4.84470949e-02f, -1.18533842e-01f, -5.47857434e-02f, 3.94904278e-02f, -7.00438349e-03f, 1.19510934e-01f, 3.04960255e-02f,
  -2.67852396e-01f, 6.31347150e-02f, -4.11394797e-02f, -2.29997877e-02f, 5.46426699e-02f, 1.07888319e-01f, 6.85322210e-02f, 1.43646166e-01f, 8.56457949e-02f, -1.50042355e-01f,
  -1.62804246e-01f, 3.42412181e-02f, -1.11256368e-01f, 1.56665877e-01f, -1.19818589e-02f, 5.97248301e-02f, 4.65555936e-02f, -4.55153687e-03f, 1.60661172e-02f, 8.92959610e-02f,
  2.04635754e-01f, 1.30035982e-01f, -1.19501084e-01f, 1.33795775e-02f, 3.16693246e-01f, 1.77544847e-01f, -1.56386882e-01f, 1.10484608e-01f, -2.60776971e-02f, -2.86780950e-02f,
  -5.11679333e-03f, 9.55399349e-02f, -6.35572970e-02f, 2.21518338e-01f, 2.11517587e-01f, -1.10013276e-01f, 1.70489226e-03f, 9.47603509e-02f, 2.86162477e-02f, -5.15864715e-02f,
  9.51289386e-02f, 1.39146030e-01f, 1.40511885e-01f, 1.37241986e-02f, -1.27692938e-01f, 1.05491653e-01f, -1.55449837e-01f, -5.79893328e-02f, -1.17104523e-01f, -1.81365870e-02f,
  5.15812598e-02f, -2.27558985e-01f, 2.01926038e-01f, -2.47720964e-02f, -3.72921787e-02f, 1.18538842e-01f, -1.43897325e-01f, -1.13431461e-01f, 1.42539874e-01f, 2.02670693e-01f,
  -6.74783140e-02f, 1.43564850e-01f, -9.64324176e-02f, 1.37236372e-01f, -1.64960280e-01f, 1.29829124e-01f, -1.06629387e-01f, 1.25318885e-01f, 1.26551151e-01f, -1.39822988e-02f,
  -7.41059408e-02f, 2.42165819e-01f, 1.33643255e-01f, 7.55984278e-04f, -1.04491770e-01f, 3.24444547e-02f, 9.89035890e-02f, 2.98995222e-03f, 1.18647404e-01f, -8.63205828e-03f,
  1.95890248e-01f, -7.13052321e-03f, 1.44318208e-01f, 2.30337515e-01f, 2.05981173e-02f, -1.51240319e-01f, 6.16407059e-02f, -1.13096558e-01f, -4.37597744e-02f, -9.70957801e-03f,
  9.83254239e-02f, -9.09666941e-02f, 9.58552510e-02f, -2.56894231e-02f, 1.36761069e-01f, -4.32692729e-02f, 1.61823228e-01f, 1.39775142e-01f, -3.40840220e-02f, -2.71458477e-02f,
  4.07688282e-02f, 1.94277227e-01f, 1.46447584e-01f, 1.08545676e-01f, 1.09335199e-01f, -1.12720467e-02f, -1.49995953e-01f, -9.53982472e-02f, 1.06257927e-02f, 3.14898752e-02f,
  -1.36996627e-01f, -2.15621218e-02f, 2.34370902e-02f, 1.46429047e-01f, -3.76688838e-02f, -8.03244412e-02f, -1.36381714e-02f, 1.14124054e-02f, -1.38631508e-01f, -7.71665871e-02f,
  -1.18560623e-02f, 3.86897549e-02f, 1.54821919e-02f, 1.26409411e-01f, 3.18728872e-02f, 2.79311389e-01f, 4.42964472e-02f, 3.59253027e-02f, 2.22988442e-01f, -3.05675697e-02f,
  2.76605934e-02f, 4.19323295e-02f, -1.17275476e-01f, -2.08694696e-01f, 1.34714559e-01f, 9.66886505e-02f, 1.78158060e-01f, 1.41447425e-01f, -2.45527271e-02f, 1.11052208e-02f,
  1.82379216e-01f, -7.51435682e-02f, 1.91688910e-01f, -7.40833804e-02f, 7.81486854e-02f, -2.74780523e-02f, -2.20237002e-02f, 6.00609742e-02f, 1.48376405e-01f, -3.68496068e-02f,
  7.81397372e-02f, -2.97075305e-02f, -9.79570486e-03f, -3.74023281e-02f, 1.12162247e-01f, -1.08985692e-01f, -3.91547680e-02f, 6.16476163e-02f, 1.88473433e-01f, 2.31498741e-02f,
  -9.73782390e-02f, 5.97226135e-02f, -1.39985532e-01f, 4.18403670e-02f, 4.97999080e-02f, -1.18740745e-01f, -7.87063316e-02f, -4.10528369e-02f, -6.99890032e-03f, -3.89858894e-02f,
  -1.65264711e-01f, -2.50849500e-02f, -1.90927550e-01f, -9.02265906e-02f, 2.42231190e-02f, -2.09481135e-01f, 1.80903710e-02f, 4.65200283e-02f, 8.85878950e-02f, 2.06678852e-01f,
  1.20213009e-01f, -1.46681875e-01f, -6.65262565e-02f, 1.10975914e-01f, -8.40552002e-02f, 8.43547517e-04f, -8.14061388e-02f, 5.32742552e-02f, -3.38124484e-02f, -5.19744828e-02f,
  -1.12380199e-01f, -8.45956504e-02f, 8.98706913e-02f, 1.15292482e-01f, 9.99895930e-02f, -6.36378676e-02f, 1.25781283e-01f, 4.07943316e-02f, -6.53775185e-02f, -4.93339915e-03f,
  2.81703640e-02f, 1.44377366e-01f, 1.56908140e-01f, 3.99930552e-02f, 1.53781492e-02f, 2.00489447e-01f, 7.65563846e-02f, 1.98644847e-01f, 1.35804355e-01f, 1.25983864e-01f,
  1.26481459e-01f, 6.06376119e-02f, -1.71517476e-01f, 1.28005043e-01f, 6.73089102e-02f, 3.88827026e-02f, -1.17317609e-01f, -7.00214729e-02f, 7.48393014e-02f, 7.64867216e-02f,
  4.26527066e-03f, 3.14634368e-02f, -1.98579058e-01f, 1.18971728e-01f, 4.15533818e-02f, 5.86308539e-03f, -5.55499755e-02f, 1.05739780e-01f, 4.94324565e-02f, -9.40582678e-02f,
  1.13362772e-02f, -3.57592888e-02f, -4.27708551e-02f, 4.95389327e-02f, -1.22835673e-01f, -1.25520706e-01f, -2.59553045e-02f, -1.41262010e-01f, 5.23881949e-02f, -3.50173898e-02f,
  -5.25678210e-02f, -7.62425587e-02f, 8.12419131e-02f, 8.40190649e-02f, -1.35108918e-01f, -1.04730718e-01f, 3.37547176e-02f, -1.46549568e-01f, -8.47375244e-02f, -7.68785714e-04f,
  -8.48146603e-02f, -1.08708270e-01f, 3.87192555e-02f, -2.73881219e-02f, -1.14989489e-01f, -4.14657071e-02f, 6.03262745e-02f, -1.44447729e-01f, 7.29878917e-02f, 1.08535089e-01f,
  2.34221090e-02f, -5.14034070e-02f, -9.69249457e-02f, -4.09560911e-02f, -8.69090110e-02f, -5.90443499e-02f, 7.28627741e-02f, -2.39952374e-02f, -1.07846797e-01f, 1.06376737e-01f,
  -8.40873644e-02f, 1.18332356e-01f, 1.25870764e-01f, 5.60625382e-02f, -7.31716305e-02f, -9.80581194e-02f, -9.02480856e-02f, 1.47234887e-01f, -1.37570769e-01f, 1.17378302e-01f,
  -4.53032069e-02f, -3.73362601e-02f, -3.08682807e-02f, 2.68263947e-02f, 5.40995896e-02f, 1.76502522e-02f, -5.37043065e-02f, 2.04876080e-04f, -9.58736986e-03f, -1.95726529e-01f,
  3.34420986e-02f, 1.37965426e-01f, 2.94944700e-02f, 8.93330351e-02f, -6.56964928e-02f, -7.10076913e-02f, 1.12938762e-01f, 4.43627387e-02f, 2.94164300e-01f, 9.06026959e-02f,
  -9.81625766e-02f, 1.80319667e-01f, -1.99607894e-01f, 8.46813619e-02f, -3.87439914e-02f, 3.89346778e-02f, 8.70215371e-02f, -2.15851828e-01f, 5.56437708e-02f, 9.31118652e-02f,
  1.39011651e-01f, 1.22686535e-01f, 1.82010233e-02f, 6.85754642e-02f, 2.28456184e-01f, 1.61582559e-01f, 2.23257672e-02f, 2.04022750e-01f, -5.80157489e-02f, 1.49742410e-01f,
  -1.32228926e-01f, -6.22573867e-02f, -1.31696582e-01f, 1.05216846e-01f, 1.09065726e-01f, 9.06072259e-02f, 5.58063481e-03f, 9.86498073e-02f, 6.22412525e-02f, -5.87409772e-02f,
  -2.21714750e-01f, -1.15648471e-02f, 1.49315875e-02f, -1.30686313e-01f, -7.09911436e-03f, -7.62821138e-02f, 6.57059848e-02f, -1.81682277e-02f, 2.00735539e-01f, 8.94504264e-02f,
  2.04776078e-01f, -1.38001412e-01f, 1.99917540e-01f, -2.30487108e-01f, 2.00828269e-01f, 9.18808430e-02f, 1.47670567e-01f, -9.06512141e-02f, 2.03078911e-01f, 3.83460596e-02f,
  1.92686707e-01f, -1.50712132e-01f, 6.99442178e-02f, 1.19167015e-01f, 2.34779716e-02f, 5.75924926e-02f, 3.52081656e-02f, 2.10744608e-02f, 1.71987116e-01f, 1.42117128e-01f,
  -3.87786552e-02f, -1.69730317e-02f, -1.54633567e-01f, -4.39415826e-03f, 6.97455704e-02f, -2.10099295e-01f, 1.13785312e-01f, -1.14867054e-01f, 7.90019110e-02f, 2.80488655e-02f,
  -9.65648592e-02f, 2.50919074e-01f, -1.02968000e-01f, 7.61493519e-02f, 8.42054607e-04f, -9.48803052e-02f, 1.87321350e-01f, 8.07624981e-02f, -1.48086175e-01f, -1.49029002e-01f,
  6.56276122e-02f, -2.00769678e-01f, 9.80869904e-02f, -1.21530458e-01f, 1.66494846e-01f, -1.54142544e-01f, 1.16098076e-01f, -1.09955579e-01f, -6.52067736e-02f, 6.45635203e-02f,
  2.10765190e-02f, -1.71362832e-02f, -2.15682700e-01f, 9.69729386e-03f, 2.20374703e-01f, -6.77314997e-02f, -1.88990042e-01f, 2.26771355e-01f, -1.39197007e-01f, 8.98771808e-02f,
  1.21044099e-01f, 2.69940384e-02f, -8.32263455e-02f, -1.57318622e-01f, -1.96188688e-02f, 1.06585011e-01f, -2.69039925e-02f, 1.25621289e-01f, 5.34428395e-02f, 1.73040777e-01f,
  -1.64709464e-01f, 1.46346420e-01f, -1.60075143e-01f, -8.60784128e-02f, -8.76021609e-02f, 2.29120672e-01f, -9.69561115e-02f, 1.21142948e-02f, 2.07760230e-01f, 4.10569422e-02f,
  2.13313103e-02f, -9.72352698e-02f, -1.01159096e-01f, 1.82721857e-02f, -5.02705313e-02f, -1.79868013e-01f, 9.06215888e-03f, -3.07549480e-02f, -1.29975870e-01f, -3.56618315e-02f,
  -3.00076175e-02f, -3.92677039e-02f, -1.42514631e-01f, -8.11367184e-02f, -3.91650759e-02f, 6.65146718e-03f, -5.19617237e-02f, -4.54647467e-02f, -1.35253966e-01f, 1.10080972e-01f,
  -1.51201308e-01f, -1.48177728e-01f, -1.00136578e-01f, 1.44217104e-01f, -1.64661959e-01f, 1.04428411e-01f, 4.45437878e-02f, 5.52136935e-02f, -7.49748796e-02f, 2.26045519e-01f,
  -2.34512892e-02f, 1.61174331e-02f, 6.86519742e-02f, -8.19941387e-02f, -1.41610071e-01f, -1.04725081e-02f, 2.76647389e-01f, 1.87516466e-01f, -6.10117801e-02f, -3.98298800e-02f,
  1.78066239e-01f, -2.08525434e-02f, 1.13592423e-01f, 9.44785774e-02f, 3.93353328e-02f, 8.72537568e-02f, -3.69178131e-02f, 6.96727559e-02f, 8.95139761e-03f, 1.09567726e-02f,
  -1.48813814e-01f, -1.03120077e-02f, -7.02934936e-02f, -1.76976323e-01f, 1.12218954e-01f, 1.62222665e-02f, -3.33650112e-02f, -4.65070531e-02f, 6.62852526e-02f, -9.83181819e-02f,
  -1.30417660e-01f, 1.49382412e-01f, -6.52269274e-02f, 1.75520778e-01f, 5.92937060e-02f, 1.48464695e-01f, 2.22147793e-01f, 2.84564346e-01f, -4.09592912e-02f, 4.70278673e-02f,
  -2.73680240e-01f, 1.13610178e-01f, 1.18932858e-01f, 6.35646060e-02f, -4.12042532e-03f, -4.71801236e-02f, 2.31508285e-01f, 1.80331164e-03f, -8.92243534e-02f, 1.08291499e-01f,
  8.75937790e-02f, 1.06546156e-01f, -3.44443098e-02f, -1.33651674e-01f, 2.33520307e-02f, -2.34897267e-02f, 3.07563543e-02f, 9.24716368e-02f, 1.33629262e-01f, 5.89807108e-02f,
  -3.23725492e-02f, 7.21472055e-02f, 3.54001045e-01f, -7.16391504e-02f, 1.70712769e-01f, 1.49363562e-01f, -1.49089783e-01f, 1.30436458e-02f, 1.38452291e-01f, -1.21501796e-01f,
  -1.08088151e-01f, 7.73240179e-02f, 2.27663398e-01f, -3.44153270e-02f, -5.64743504e-02f, 1.17919229e-01f, 1.17890157e-01f, -1.37734994e-01f, 1.44876957e-01f, -4.46502939e-02f,
  4.35220823e-02f, 9.81396958e-02f, -3.36409137e-02f, 1.12514617e-02f, 1.39224797e-01f, 2.44526356e-01f, -2.33509883e-01f, -3.54920514e-02f, -1.37144718e-02f, 5.05641699e-02f,
  -5.19996099e-02f, 8.58493447e-02f, -9.68034938e-02f, 2.69060452e-02f, 1.06845777e-02f, 8.88319686e-02f, -3.20351690e-01f, -6.06984310e-02f, -1.57608300e-01f, -9.63330865e-02f,
  -2.00193629e-01f, -2.69161910e-01f, -9.92894396e-02f, -3.41333523e-02f, 1.73380822e-01f, 5.71773686e-02f, -1.30743489e-01f, 2.79003382e-02f, 7.04633370e-02f, -3.42083238e-02f,
  4.38729674e-02f, -2.64413822e-02f, 1.95513621e-01f, 2.60191243e-02f, 2.56332785e-01f, 4.70018163e-02f, 1.47913456e-01f, -2.32051201e-02f, 1.39476031e-01f, 2.30709706e-02f,
  6.91602156e-02f, 3.27667817e-02f, -9.69650075e-02f, -5.90541959e-03f, -1.51722252e-01f, -2.28568129e-02f, -2.48993725e-01f, 3.99209000e-02f, -9.12780091e-02f, -1.15651794e-01f,
  2.51474679e-01f, 2.28570253e-01f, -2.02238932e-02f, 3.00577171e-02f, 5.71871363e-02f, 7.50617534e-02f, 1.82246249e-02f, 1.85662135e-01f, 2.06861589e-02f, 1.29857928e-01f,
  -5.96593879e-02f, 1.35156617e-01f, 8.22336525e-02f, 1.43282622e-01f, 1.81908607e-01f, 3.18806395e-02f, 5.55604547e-02f, 5.09038828e-02f, 2.47576702e-02f, -1.16547517e-01f,
  -3.64507437e-02f, 2.89705433e-02f, 4.76310588e-03f, 8.58481899e-02f, 9.93851870e-02f, 5.67824394e-02f, 6.90048411e-02f, 6.73513934e-02f, 7.91048817e-03f, 7.21204951e-02f,
  2.06647828e-01f, -7.18589276e-02f, 5.53579144e-02f, 1.73329696e-01f, -1.73688214e-02f, 7.53484666e-02f, 4.66915928e-02f, 1.33803813e-02f, -4.35197121e-03f, 1.93647191e-01f,
  -1.04350075e-02f, 1.53474048e-01f, -4.44672890e-02f, -2.07946878e-02f, -8.63631889e-02f, -9.95526314e-02f, -4.77291718e-02f, 1.31163925e-01f, 1.01252809e-01f, -9.66332778e-02f,
  1.49114372e-03f, 1.41539782e-01f, -6.24213517e-02f, -1.17766000e-02f, 5.43112345e-02f, 6.88050911e-02f, 8.79796296e-02f, -4.38598543e-03f, 7.80333877e-02f, 1.10527180e-01f,
  1.40099093e-01f, -5.32533415e-02f, -1.34508545e-02f, -5.22437058e-02f, -1.41774705e-02f, -9.62088779e-02f, 9.58520398e-02f, 1.17280319e-01f, -6.47405237e-02f, -1.04452027e-02f,
  -4.20618393e-02f, -6.51084185e-02f, -1.04559399e-01f, 8.56910739e-03f, 2.66208109e-02f, -1.19826540e-01f, 3.84157598e-02f, -3.10010258e-02f, 1.30432844e-01f, 6.86848816e-03f,
  8.76557752e-02f, 8.27199742e-02f, 1.43010005e-01f, 5.09682521e-02f, -9.34774503e-02f, 4.50352691e-02f, 7.18184263e-02f, 9.01596397e-02f, 2.84783524e-02f, 7.75140971e-02f,
  4.80622314e-02f, -1.22495323e-01f, -3.09400577e-02f, 9.24108103e-02f, -7.57287517e-02f, -4.78291102e-02f, -2.58585364e-02f, 9.60268751e-02f, 1.72066450e-01f, 1.38569111e-02f,
  1.61698554e-02f, 4.79497277e-04f, 2.13069171e-01f, 1.92238286e-01f, 2.95817889e-02f, 2.09276855e-01f, 1.45495050e-02f, 1.31777450e-01f, 1.54582188e-01f, 1.80439040e-01f,
  6.67125732e-02f, -1.57369316e-01f, 2.25712955e-01f, 1.68797672e-01f, 1.57000855e-01f, 6.25296310e-02f, 2.84118652e-01f, 2.53421456e-01f, 2.97617838e-02f, 6.75188750e-03f,
  2.16292128e-01f, -1.48817524e-01f, -9.26366150e-02f, -1.61653280e-01f, 1.73775274e-02f, 2.98469746e-03f, -1.54945091e-03f, 5.93886478e-03f, -1.97363202e-03f, 2.69487530e-01f,
  6.47816882e-02f, 1.04976557e-01f, -2.60129601e-01f, -2.21091107e-01f, 1.39575347e-01f, 1.47489205e-01f, 6.03277162e-02f, 2.74009049e-01f, -1.29332423e-01f, -2.22708449e-01f,
  2.25351080e-01f, -5.51334657e-02f, 1.21105656e-01f, 1.30978242e-01f, 1.84080482e-01f, -2.19652280e-01f, 2.37756029e-01f, -5.38161397e-02f, 1.26899496e-01f, 2.93963134e-01f,
  -1.30600125e-01f, -1.42900214e-01f, 1.31436169e-01f, 3.91980307e-03f, 7.24069178e-02f, 7.76943937e-02f, 1.74136937e-01f, 7.57303014e-02f, 2.11425871e-01f, -2.01976061e-01f,
  -1.23424254e-01f, -8.59349407e-03f, -2.52466626e-03f, -1.58365548e-01f, -4.83943895e-02f, 2.84835976e-03f, 1.95257276e-01f, 5.86273447e-02f, -3.12106661e-03f, 5.18032797e-02f,
  -1.46373728e-04f, 7.24279787e-03f, -1.88434482e-01f, 3.18103656e-02f, 6.73819240e-03f, 8.36783350e-02f, -2.23832671e-02f, 8.27741101e-02f, -2.75199562e-02f, 1.74699813e-01f,
  5.92362136e-02f, 4.76390384e-02f, -1.42128821e-02f, 2.26184484e-02f, 2.86750980e-02f, 5.29944077e-02f, 4.98036742e-02f, 5.13640903e-02f, -1.08824879e-01f, 2.01079980e-01f,
  -2.18642130e-02f, 4.68244255e-02f, -4.18121032e-02f, -3.44389789e-02f, 7.98089653e-02f, 1.34080052e-01f, 1.92817539e-01f, -2.07213927e-02f, -2.42133928e-03f, 6.87060207e-02f,
  3.20549384e-02f, 2.79286876e-02f, 1.59454882e-01f, 9.02630985e-02f, -4.68621142e-02f, 1.34655923e-01f, -1.04048982e-01f, 6.39981776e-02f, 1.82052985e-01f, -1.89427808e-02f,
  2.51767784e-02f, -1.13191694e-01f, 2.21506074e-01f, 1.06327765e-01f, 1.27714418e-03f, -3.52759436e-02f, -3.83078158e-02f, -6.30775094e-02f, 3.89392562e-02f, -1.27477601e-01f,
  -1.29944637e-01f, 1.98076308e-01f, 9.19910297e-02f, 1.07435562e-01f, 2.44543683e-02f, -6.59304298e-03f, 4.76513915e-02f, 2.20552385e-01f, -1.82473958e-02f, -2.66628992e-02f,
  -1.81046367e-01f, -1.23910084e-01f, 8.43174309e-02f, -3.02758776e-02f, -1.09401114e-01f, -9.83380750e-02f, 5.74624240e-02f, 4.86110151e-02f, 7.43748546e-02f, -8.42744187e-02f,
  -1.56314254e-01f, 5.62198907e-02f, 7.55641460e-02f, -1.00534856e-01f, -9.18345153e-02f, -5.49901426e-02f, -3.28570008e-02f, 5.22820763e-02f, 1.47602201e-01f, 2.58579165e-01f,
  6.07700497e-02f, 6.23475760e-02f, 1.92056358e-01f, 1.61889766e-03f, 3.59274857e-02f, 1.75216217e-02f, 8.20244849e-02f, -1.31045952e-01f, 1.35366216e-01f, -8.68368670e-02f,
  1.03856221e-01f, 2.74888635e-01f, -5.42194434e-02f, -1.59300759e-01f, 1.54875487e-01f, -1.46268561e-01f, 2.78418839e-01f, 6.35515004e-02f, -1.40576735e-01f, 3.14450115e-02f,
  -8.26341808e-02f, 6.48544356e-02f, 9.56122801e-02f, -5.71471788e-02f, -1.42589122e-01f, -1.08894911e-02f, -3.81522183e-03f, -6.58313408e-02f, 1.66516170e-01f, 9.15562436e-02f,
  1.25501901e-01f, 1.03959151e-01f, 1.02688007e-01f, -7.13387802e-02f, 3.44645903e-02f, -6.89728856e-02f, -1.39707699e-01f, 2.67560661e-01f, -5.47794066e-02f, -1.81422934e-01f,
  -1.74412534e-01f, -9.75855663e-02f, -1.27198324e-01f, -1.17755100e-01f, 1.23179138e-01f, 1.09797768e-01f, -1.87025309e-01f, 3.33152004e-02f, 3.49785984e-02f, -6.42662495e-02f,
  -1.76240101e-01f, -1.28827557e-01f, 5.16554117e-02f, 8.35618079e-02f, 8.81981328e-02f, 5.24678342e-02f, 2.58190613e-02f, 1.18399389e-01f, -9.10801515e-02f, -5.07837646e-02f,
  8.28184411e-02f, -3.13673094e-02f, -9.41149071e-02f, -8.95821825e-02f, -1.32558107e-01f, 9.67019424e-02f, -1.25858471e-01f, 1.14294149e-01f, -1.96092147e-02f, -3.87942716e-02f,
  1.83522105e-01f, 1.38743341e-01f, -2.70566314e-01f, 2.55955551e-02f, 1.50314167e-01f, 9.83175412e-02f, -1.06801264e-01f, 1.15097193e-02f, 7.17959926e-02f, -2.96539441e-03f,
  4.68694232e-02f, 1.18227974e-01f, 6.72711655e-02f, 1.18927509e-01f, 4.49792966e-02f, 1.79849640e-01f, -5.08279279e-02f, 9.81810242e-02f, -2.34188829e-02f, -5.98002784e-03f,
  1.65787544e-02f, -1.55525133e-01f, 6.66199401e-02f, -1.20105837e-02f, 1.46729782e-01f, -1.67548954e-01f, 4.12070155e-02f, -1.79075941e-01f, 1.17340766e-01f, 1.11355230e-01f,
  2.46457830e-02f, 5.91604114e-02f, 3.98186222e-02f, -1.32043019e-01f, 1.14273066e-02f, -5.58042414e-02f, -3.69676016e-02f, -5.03855422e-02f, -1.91792026e-01f, -1.27886266e-01f,
  -1.49338365e-01f, -1.77865669e-01f, 1.05427317e-01f, -1.89383343e-01f, 9.30101722e-02f, 9.67918634e-02f, 1.83772579e-01f, 2.90790033e-02f, 1.33579209e-01f, -1.06215268e-01f,
  2.17525139e-02f, -1.62799180e-01f, -6.30726889e-02f, -4.86914441e-02f, 4.03662212e-02f, -9.50362310e-02f, -1.02505490e-01f, 1.01640776e-01f, -1.89167202e-01f, 1.04291905e-02f,
  5.80991171e-02f, 1.35405257e-01f, 5.54786362e-02f, -1.96915958e-02f, 1.78315192e-01f, 8.18838254e-02f, -1.37079120e-01f, -1.72638461e-01f, 3.68872359e-02f, 2.39772350e-01f,
  1.56544119e-01f, -2.36247163e-02f, 9.03285071e-02f, 2.19711602e-01f, -5.65689839e-02f, 2.38930762e-01f, 2.08878919e-01f, 1.20731369e-01f, 7.73288831e-02f, 1.60123818e-02f,
  -7.16009066e-02f, 9.03753564e-03f, 5.49682695e-03f, 4.65902351e-02f, -2.62950450e-01f, -2.11209223e-01f, 1.63042828e-01f, 8.95193294e-02f, 7.47947469e-02f, 6.60040975e-02f,
  -1.38818815e-01f, 1.20135054e-01f, 9.26603824e-02f, -2.01116391e-02f, 7.27335140e-02f, 1.51628718e-01f, 8.48948956e-03f, -1.13598779e-01f, -2.78104637e-02f, -2.07604188e-02f,
  1.13485027e-02f, -1.80033334e-02f, -1.78551674e-02f, -5.40847145e-02f, -5.79773076e-02f, -6.12584390e-02f, 7.47992694e-02f, -5.69025427e-02f, -7.56687820e-02f, -1.37257978e-01f,
  -8.38741362e-02f, 2.70237297e-01f, -7.55765066e-02f, -7.76998401e-02f, -4.23971526e-02f, 4.55870256e-02f, -4.07827795e-02f, -4.85771410e-02f, -1.60658658e-01f, -8.66772979e-02f,
  -1.62297204e-01f, 5.50776646e-02f, 1.47556156e-01f, -5.96498735e-02f, 1.65634491e-02f, 8.23466629e-02f, 1.16451323e-01f, -7.57044330e-02f, 1.75271183e-02f, -1.00691885e-01f,
  9.43039879e-02f, -5.85076809e-02f, 6.48318678e-02f, 2.04570610e-02f, 1.00053161e-01f, -6.72901720e-02f, 3.92376184e-02f, 2.29684468e-02f, 5.72667606e-02f, 5.42152785e-02f,
  -6.51469454e-02f, 3.50821912e-02f, -7.80306756e-02f, -1.41216561e-01f, -3.57353278e-02f, 2.78102309e-01f, -2.61104047e-01f, 7.00679421e-02f, -2.94059459e-02f, -5.03839590e-02f,
  -1.04810484e-01f, 2.12710515e-01f, -7.30804503e-02f, 6.16332293e-02f, -2.98874434e-02f, 1.03588723e-01f, -1.32720023e-01f, 4.58790995e-02f, -5.40158972e-02f, 9.83885862e-03f,
  -5.41726574e-02f, 6.16363212e-02f, -8.02763551e-02f, -1.26625821e-01f, -5.51696494e-02f, -3.08092404e-02f, 7.87096322e-02f, 4.47391793e-02f, 6.77123070e-02f, 9.55091491e-02f,
  -1.35503281e-02f, 8.47362354e-02f, -1.28673650e-02f, -5.57545796e-02f, 8.22528303e-02f, 1.83526933e-01f, 6.75302232e-03f, 6.94624335e-02f, 1.42743483e-01f, -4.38462757e-02f,
  6.34839460e-02f, 3.81376073e-02f, 2.15168744e-02f, 6.53059781e-02f, 8.68604332e-02f, 9.45578143e-03f, 2.35280886e-01f, -1.26949757e-01f, -4.07333113e-03f, 7.78388083e-02f,
  -4.76158634e-02f, -1.27238914e-01f, 8.97693560e-02f, -2.59236470e-02f, 2.34247506e-01f, 4.14810888e-02f, 4.15575020e-02f, -8.65380317e-02f, -2.04501227e-01f, 7.30846950e-04f,
  1.10409699e-01f, -1.09149680e-01f, 9.33882222e-03f, -2.65252329e-02f, -3.65229556e-03f, -1.98099799e-02f, -4.76882011e-02f, 6.69748113e-02f, 1.52902514e-01f, 1.11847796e-01f,
  -2.99110208e-02f, -2.93504894e-02f, 1.06429793e-01f, 1.97114676e-01f, -1.14239193e-01f, 1.50022537e-01f, 4.47249636e-02f, 3.34873013e-02f, 1.49519652e-01f, 1.29918873e-01f,
  -3.06405239e-02f, 1.27907455e-01f, 1.08879693e-01f, -5.82498983e-02f, -1.01259455e-01f, 5.06859720e-02f, 4.85699512e-02f, -2.13834271e-02f, 1.12771928e-01f, -2.47672461e-02f,
  -2.34439045e-01f, 1.11053390e-02f, -6.51660785e-02f, -2.19185315e-02f, -8.74452740e-02f, -4.28606644e-02f, 2.05272183e-01f, 1.58782989e-01f, 1.68729872e-01f, -1.47653297e-01f,
  1.89354584e-01f, 1.40263259e-01f, 2.15044409e-01f, -1.75489649e-01f, 2.31653242e-03f, 2.67095178e-01f, 2.27793604e-01f, 3.79624777e-02f, 1.46740213e-01f, -2.62450427e-03f,
  -1.79423541e-01f, -1.00307375e-01f, 1.57134637e-01f, -7.78617412e-02f, -6.55094385e-02f, 6.51144832e-02f, 2.08875343e-01f, 2.91779399e-01f, 6.05890602e-02f, 2.67177001e-02f,
  -1.03323705e-01f, 1.40424043e-01f, 1.47051781e-01f, 9.93682072e-02f, 7.60372952e-02f, 1.54239208e-01f, -1.01422451e-01f, 1.61902606e-02f, 2.65645951e-01f, 7.54215792e-02f,
  2.20112979e-01f, 1.64476216e-01f, -1.49657369e-01f, -2.10779458e-01f, 2.02643394e-01f, -6.50305077e-02f, -2.66595572e-01f, -1.15756616e-02f, 1.71388045e-01f, 8.59461650e-02f,
  1.42366201e-01f, 5.92161119e-02f, -1.54042188e-02f, 1.80876367e-02f, 1.39065430e-01f, -7.79247135e-02f, -3.42866965e-02f, -6.30130759e-03f, -7.68415108e-02f, -1.73606277e-01f,
  3.00239660e-02f, -1.89957526e-02f, 4.56938595e-02f, -1.17431484e-01f, 1.05180830e-01f, -3.94550711e-02f, 8.11768789e-03f, 2.16920674e-02f, -8.61831084e-02f, 8.09711665e-02f,
  -8.10360610e-02f, -4.63762693e-02f, -4.14666831e-02f, 1.42623698e-02f, -1.93420127e-01f, 6.80700243e-02f, -4.40507047e-02f, 1.60184368e-01f, -6.55409619e-02f, -1.07948139e-01f,
  -1.03279658e-01f, 1.17277220e-01f, -2.29632668e-02f, 1.39252856e-01f, 8.50534588e-02f, -7.48782698e-03f, -9.59434137e-02f, 1.85952410e-01f, 1.39988204e-02f, 2.19958462e-02f,
  1.16959418e-04f, -1.69391721e-01f, -1.07344523e-01f, -7.88441487e-03f, 2.25348398e-01f, 1.93024287e-03f, -7.79134929e-02f, -1.07941337e-01f, 2.13318132e-02f, -1.85707644e-01f,
  4.21077758e-02f, 9.95869488e-02f, -1.32037073e-01f, 8.56224522e-02f, -1.75237596e-01f, -4.04292382e-02f, 3.97351719e-02f, 8.57068002e-02f, -1.54253945e-01f, -2.20588557e-02f,
  1.38752600e-02f, -9.01536718e-02f, -7.19162673e-02f, 4.56346236e-02f, -7.00365454e-02f, -9.21429247e-02f, 1.26252383e-01f, -5.82809858e-02f, -3.00376061e-02f, 1.54256329e-01f,
  -2.83159800e-02f, 1.31977677e-01f, 3.56943086e-02f, 1.03153914e-01f, -9.36528146e-02f, 1.79190278e-01f, 7.47113824e-02f, 7.75359645e-02f, -1.51484430e-01f, 1.02437325e-01f,
  -1.21798269e-01f, 4.96188886e-02f, 4.11984771e-02f, -1.11891504e-03f, 8.01817924e-02f, -1.09637668e-02f, 8.32010955e-02f, -2.66923308e-02f, -3.72048002e-04f, 1.41206309e-01f,
  -7.80028850e-03f, 1.87223896e-01f, -6.77928030e-02f, 1.62982699e-02f, 1.35561734e-01f, 8.83811060e-03f, -9.10575762e-02f, 3.92108746e-02f, 7.37213120e-02f, -8.73390064e-02f,
  1.45112410e-01f, 2.10442826e-01f, 3.96644101e-02f, -1.90266237e-01f, 7.98478276e-02f, -1.74786970e-02f, 5.01951538e-02f, 2.53632981e-02f, 1.33541569e-01f, -6.12434419e-03f,
  1.78248659e-02f, -5.43432198e-02f, 1.34526417e-01f, 4.32612896e-02f, 2.72628777e-02f, -1.73747942e-01f, -2.13231705e-02f, 1.49529368e-01f, -1.11497484e-01f, 3.41417462e-01f,
  2.25626901e-02f, -1.80247426e-02f, 1.34541899e-01f, -2.34526973e-02f, -1.00232936e-01f, -3.76014002e-02f, 1.29504532e-01f, 2.39239614e-02f, 9.17678326e-02f, 2.25805910e-03f,
  1.75186321e-01f, -1.43032700e-01f, 2.01283455e-01f, 2.88537741e-01f, -1.21300600e-01f, 5.74098080e-02f, -2.50671115e-02f, 1.99754536e-01f, 2.05571756e-01f, 1.20072111e-01f,
  8.85783136e-02f, 4.11364771e-02f, -3.25820612e-04f, -6.57375231e-02f, 2.52864867e-01f, -1.75182037e-02f, -1.16216376e-01f, 1.80928990e-01f, 7.16546783e-04f, 9.58548486e-03f,
  -1.19146369e-01f, -3.04957237e-02f, -1.46919653e-01f, 8.74880329e-02f, 1.15201166e-02f, 1.10139810e-02f, 1.08318821e-01f, 6.38572201e-02f, -4.61888164e-02f, 7.23785535e-03f,
  2.19412610e-01f, 1.10586107e-01f, 2.31839210e-01f, -7.24125281e-03f, 8.18899125e-02f, -1.20439511e-02f, -2.59562600e-02f, 1.36816472e-01f, -2.46638626e-01f, -1.90098614e-01f,
  1.05362944e-01f, -4.21307944e-02f, 5.36062382e-02f, -1.38138860e-01f, -1.84215844e-01f, -8.96931589e-02f, -1.63120348e-02f, -2.21561790e-01f, 1.70302257e-01f, -1.61946252e-01f,
  -2.91478157e-01f, -1.60533190e-01f, -2.21718252e-02f, -5.02315685e-02f, 2.11254209e-01f, -6.02576695e-02f, -3.82768624e-02f, -1.69169419e-02f, 2.09119737e-01f, 2.09664926e-01f,
  -9.92766917e-02f, 2.28978172e-02f, 1.50365885e-02f, 6.75186962e-02f, 1.12884678e-01f, 2.91028339e-02f, -3.04602645e-02f, 1.57600150e-01f, -2.22181883e-02f, 4.52237092e-02f,
  1.10143825e-01f, 1.96675599e-01f, 7.84801133e-03f, 1.88509554e-01f, 1.23063577e-02f, 3.74974310e-02f, -2.09593877e-01f, 1.72788084e-01f, -1.05627980e-02f, 9.22663882e-02f,
  9.82517190e-03f, -3.97180356e-02f, 1.75121367e-01f, -5.09466194e-02f, 8.74376744e-02f, -3.17269340e-02f, 1.23150796e-01f, 7.85326660e-02f, 6.80425689e-02f, -5.16604483e-02f,
  -7.52454018e-03f, 1.48019820e-01f, 1.84312016e-01f, -1.42081887e-01f, 1.39575168e-01f, -6.99462965e-02f, 4.68042865e-02f, -5.62864207e-02f, 1.64030656e-01f, -5.08670136e-02f,
  7.74627551e-02f, -1.06118791e-01f, 4.78993058e-02f, 2.26628140e-01f, 1.32270977e-01f, -1.45502508e-01f, -2.42632404e-01f, 2.57490091e-02f, 6.10814914e-02f, -9.85795483e-02f,
  -3.61502580e-02f, -6.18011095e-02f, -8.50690082e-02f, -2.36985043e-01f, -8.05221871e-02f, -3.09246220e-02f, 8.24905932e-03f, 1.41804919e-01f, 7.29840770e-02f, 3.06933559e-02f,
  1.77578598e-01f, 1.44306868e-01f, -7.07013085e-02f, -2.15452239e-02f, -4.86389222e-03f, 3.27284373e-02f, 1.33607611e-01f, 9.81517229e-03f, 6.18893765e-02f, 3.66439335e-02f,
  1.75583392e-01f, 1.75773218e-01f, -2.40779459e-01f, -1.70109525e-01f, 9.68507379e-02f, 1.85580682e-02f, 1.41709680e-02f, 1.95077494e-01f, -9.60361212e-02f, 1.86770990e-01f,
  1.47273585e-01f, -6.94421679e-02f, 7.24203065e-02f, 1.63428828e-01f, 1.04467936e-01f, 1.69834539e-01f, -7.57712498e-02f, 1.05645142e-01f, -5.43810427e-02f, 1.60530761e-01f,
  -5.21688350e-02f, -2.30370499e-02f, -5.79894409e-02f, 1.03389002e-01f, 5.20233922e-02f, -9.88280401e-02f, 1.32025331e-01f, 2.04649404e-01f, -9.81080681e-02f, -3.76782827e-02f,
  2.69856751e-01f, 1.91826984e-01f, -5.40120294e-03f, 8.83831233e-02f, -2.32872497e-02f, 1.12441657e-02f, -1.92607462e-01f, -9.51455161e-02f, 2.38996118e-01f, 2.43345946e-01f,
  -1.36514194e-02f, -1.83643103e-01f, 4.68697250e-02f, 7.46703297e-02f, -8.77889022e-02f, -5.53992167e-02f, 9.25536901e-02f, -9.07006711e-02f, 7.55599746e-03f, -1.97056845e-01f,
  -6.40647659e-06f, 4.03965265e-02f, 1.70203239e-01f, 1.10283799e-01f, 1.55296493e-02f, 2.07841083e-01f, 1.84112892e-01f, 2.05942243e-02f, 6.62952662e-02f, 7.06137717e-02f,
  -1.46425873e-01f, 2.72940379e-02f, 1.16464496e-01f, 1.66647598e-01f, -1.32572174e-01f, 2.45659262e-01f, 4.28019557e-03f, -9.10132367e-04f, 6.64693490e-02f, 9.29036085e-03f,
  3.89658734e-02f, 1.26193970e-01f, -4.75961622e-03f, 1.64851956e-02f, -2.88741201e-01f, 5.69859073e-02f, -1.57203779e-01f, -4.24388759e-02f, 1.18125148e-01f, -2.18251050e-01f,
  8.76228660e-02f, -1.93826020e-01f, 1.79912791e-01f, 9.64639857e-02f, 2.17236951e-03f, 7.96218067e-02f, 8.54215547e-02f, -3.48283872e-02f, -1.72763821e-02f, -3.45637463e-02f,
  -6.32727519e-02f, -6.13760278e-02f, -2.60847677e-02f, 9.04410481e-02f, -1.80917561e-01f, -1.70937628e-01f, 9.30931494e-02f, 1.49125502e-01f, 8.76738876e-02f, -2.35097229e-01f,
  1.95958003e-01f, 1.14137838e-02f, -5.42327464e-02f, -1.93836689e-01f, 3.18238474e-02f, 2.29629666e-01f, 2.26589367e-01f, -1.28648773e-01f, 1.97418898e-01f, 1.20749556e-01f,
  -4.07315828e-02f, 8.51441920e-02f, 1.34083048e-01f, 7.89262652e-02f, -6.26306683e-02f, 1.32326901e-01f, -1.35657549e-01f, 2.91732810e-02f, 2.76019666e-02f, 9.59954262e-02f,
  -2.38288149e-01f, -5.71577251e-02f, 5.92528544e-02f, 1.51148275e-01f, 1.41103983e-01f, -1.17443828e-02f, 5.88494726e-03f, -4.15749550e-02f, 1.23216346e-01f, -1.47338491e-02f,
  -1.15027264e-01f, 4.87900898e-02f, 4.78345416e-02f, 2.22145114e-02f, 4.34038937e-02f, -1.88336030e-01f, -6.60371734e-03f, 1.23858266e-02f, 2.19936207e-01f, 4.41765673e-02f,
  1.12832621e-01f, 9.98123959e-02f, -3.67890447e-02f, 2.15461165e-01f, 1.67864934e-01f, 2.62618691e-01f, 2.51627378e-02f, -1.06407568e-01f, 1.48386136e-01f, 7.23318309e-02f,
  -7.19686970e-02f, 7.63185397e-02f, 1.01638608e-01f, 6.15617521e-02f, 1.46891564e-01f, 1.25047863e-01f, 1.26624942e-01f, 5.40873371e-02f, 8.04941952e-02f, 2.73530427e-02f,
  7.02103004e-02f, -1.23206817e-01f, -3.69381085e-02f, 1.09075747e-01f, -1.33000284e-01f, -6.90863281e-02f, 1.23203531e-01f, 1.44673184e-01f, -2.25846861e-02f, -1.82618529e-01f,
  4.07228284e-02f, 2.14411229e-01f, -6.80268779e-02f, 3.18854079e-02f, 9.92490798e-02f, -1.19890161e-01f, 2.46763781e-01f, -1.56875551e-01f, 2.09439993e-01f, 4.24432084e-02f,
  1.66157633e-01f, -1.13557726e-01f, 2.31058165e-01f, -6.63723946e-02f, 3.61070931e-02f, 1.52205870e-01f, 1.04028285e-02f, -1.63073868e-01f, -7.72437826e-02f, 4.93104085e-02f,
  -1.41365558e-01f, 5.05341589e-02f, -8.81653279e-02f, -1.11573845e-01f, -1.38314748e-02f, -5.35690971e-02f, -6.86754361e-02f, 4.00801934e-02f, 6.47790283e-02f, 2.64283661e-02f,
  -9.59724188e-02f, 6.22087829e-02f, 7.65139312e-02f, 1.60455421e-01f, -8.68277252e-03f, 1.69992641e-01f, 1.21566929e-01f, -3.19812335e-02f, 1.21351648e-02f, 7.97916576e-02f,
  -4.84505333e-02f, 1.40586987e-01f, 2.31268853e-01f, 1.35035545e-01f, 1.13384619e-01f, 1.77515805e-01f, 2.50355214e-01f, 1.18695654e-01f, 6.71344921e-02f, 4.17565480e-02f,
  -1.24928541e-01f, -1.39652997e-01f, -7.35218450e-02f, -7.13411793e-02f, -4.58326079e-02f, -3.11494991e-02f, 8.55479538e-02f, -6.41814098e-02f, 2.38474607e-02f, 1.18877448e-01f,
  4.43264768e-02f, 8.21078345e-02f, -1.21307872e-01f, -1.64806187e-01f, 9.17666033e-02f, 1.01351485e-01f, -7.28358477e-02f, 2.77091712e-01f, -1.61841497e-01f, -2.03126773e-01f,
  2.26048753e-01f, -5.16207330e-02f, 1.67702869e-01f, 1.16602629e-01f, 1.73309650e-02f, -5.76035827e-02f, 1.78219631e-01f, 1.77497063e-02f, 4.65835109e-02f, 1.87213346e-01f,
  -1.57891095e-01f, 1.74075440e-02f, -1.41251106e-02f, -1.00537471e-01f, -1.85617000e-01f, 1.14093274e-01f, 3.51517051e-02f, 1.59592837e-01f, 1.19961187e-01f, -2.71624446e-01f,
  -1.36376813e-01f, -8.25853348e-02f, -5.32535650e-02f, -1.81691721e-01f, -5.08988872e-02f, -1.28678188e-01f, 9.70306918e-02f, -1.70115218e-01f, 4.24757786e-02f, -7.36538470e-02f,
  1.15017623e-01f, 4.24563475e-02f, 1.49986045e-02f, 1.85170770e-01f, -2.72832029e-02f, 7.68125132e-02f, -7.22446665e-02f, 2.98146904e-03f, 1.38592660e-01f, -2.35650703e-01f,
  9.57437828e-02f, 7.64151737e-02f, -5.26009537e-02f, -5.23988977e-02f, 9.49871466e-02f, -6.76519126e-02f, -4.43933010e-02f, 4.64888029e-02f, -2.50508264e-02f, -9.49097127e-02f,
  4.72729877e-02f, 2.26243958e-01f, 2.93340790e-03f, 1.61116168e-01f, 1.09312877e-01f, 1.03141129e-01f, -2.11023353e-02f, 1.46803027e-02f, 2.92100664e-02f, 3.38214114e-02f,
  -1.55101791e-01f, 1.67591870e-01f, -1.13269404e-01f, 1.40896827e-01f, 1.41704753e-01f, 6.68736547e-02f, 1.36380762e-01f, -2.83455938e-01f, 2.09227037e-02f, -1.84427598e-03f,
  9.02013574e-03f, 4.57974710e-03f, 1.52305737e-02f, 8.35158862e-03f, -3.36275026e-02f, 1.08325444e-01f, -1.00493208e-01f, 4.23649140e-02f, -1.96545035e-01f, 2.47465119e-01f,
  -1.79263562e-01f, -2.68949211e-01f, 3.04390550e-01f, 7.94852003e-02f, -7.51207843e-02f, -5.74606732e-02f, -6.04023039e-02f, -4.60013747e-02f, -3.20457965e-02f, 1.41691770e-02f,
  -3.48381884e-02f, 8.47448483e-02f, 8.93864036e-02f, -1.13100074e-01f, 1.96164787e-01f, 5.39582185e-02f, 9.77860242e-02f, 7.10940287e-02f, -8.35573003e-02f, 2.76204109e-01f,
  -2.13520378e-02f, 1.11325912e-01f, 4.30077780e-03f, 4.78252433e-02f, 2.08722368e-01f, 5.03092147e-02f, -6.57329857e-02f, -1.81372482e-02f, 1.27071917e-01f, 4.60682996e-03f,
  2.14352399e-01f, -9.84879211e-02f, -5.03994524e-02f, -3.68741564e-02f, 6.72047138e-02f, -5.21053784e-02f, -3.77329662e-02f, 1.34046935e-02f, 1.50322258e-01f, -5.32676689e-02f,
  2.06203833e-02f, 1.20332185e-02f, 4.21002544e-02f, -4.84975427e-02f, 2.36310046e-02f, 2.18177035e-01f, -1.50807664e-01f, -2.42617670e-02f, -2.27518640e-02f, 2.33862475e-02f,
  -3.07351202e-02f, -9.54314098e-02f, 4.75527197e-02f, 2.67874151e-01f, -8.95865187e-02f, 1.99917242e-01f, -4.41022180e-02f, 1.56184137e-01f, -6.86016679e-02f, 6.80225343e-02f,
  -1.07408285e-01f, -7.89608434e-02f, -1.67401671e-01f, 6.58982918e-02f, -9.82055217e-02f, 2.08065316e-01f, 4.95680496e-02f, -3.20109054e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  5.76959848e-02f, -1.12225570e-01f, 3.79883423e-02f, 9.55422521e-02f, -4.19879891e-02f, 4.32021543e-02f, -9.93347913e-02f, 1.39500529e-01f, -1.86946448e-02f, -7.11350515e-02f,
  3.11808903e-02f, 1.26012206e-01f, -3.30394581e-02f, 7.97432438e-02f, 3.36426334e-03f, 2.06444133e-02f, 1.33447021e-01f, 1.54695898e-01f, 5.00556128e-03f, 3.91519740e-02f,
  1.54262900e-01f, -2.50378866e-02f, 1.14017576e-02f, -1.04688052e-02f, 1.10542439e-01f, 1.15686275e-01f, -5.79918027e-02f, 3.18172947e-02f, 8.88638571e-02f, 4.19782400e-02f,
  -7.36144334e-02f, -3.30648758e-02f, -4.17499505e-02f, -3.97908874e-02f, 1.07002571e-01f, 3.39706019e-02f, -1.45584121e-02f, -1.47526830e-01f, 1.07213343e-02f, -7.63574019e-02f,
  2.94522825e-03f, 1.13390625e-01f, -8.90443847e-02f, 1.32007837e-01f, -4.09374340e-03f, 2.58478126e-03f, 7.83940628e-02f, -3.60831395e-02f, 9.94434059e-02f, 1.14562668e-01f,
  -2.85569858e-02f, 1.23195924e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  4.12750384e-03f, 9.77529958e-02f, 7.05043972e-02f, 7.51238540e-02f, 1.52935209e-02f, 7.83962980e-02f, -8.50001872e-02f, 4.11943942e-02f, 1.17930718e-01f, 2.67315179e-01f,
  -6.17647767e-02f, -2.01162159e-01f, 5.67617379e-02f, -2.79264897e-01f, -1.69362813e-01f, 1.10504642e-01f, 1.24279410e-01f, -2.24199101e-01f, -1.08424991e-01f, 1.67316735e-01f,
  -9.37715843e-02f, 3.50497156e-01f, -9.34670568e-02f, 1.12495571e-02f, -1.20600760e-01f, -1.00914419e-01f, -5.21557927e-02f, -9.81353745e-02f, -1.54474378e-01f, -4.77729179e-02f,
  1.03874244e-01f, 5.88971861e-02f, -7.61595294e-02f, 5.28430752e-02f, -2.42758229e-01f, 3.10311824e-01f, -3.08553338e-01f, -2.20542371e-01f, -1.96546927e-01f, 2.64951438e-02f,
  8.15217849e-03f, 2.00010389e-01f, 1.39247300e-02f, -2.60315090e-01f, 4.90393564e-02f, -1.65685132e-01f, 6.97722137e-02f, 1.32602632e-01f, -2.63536777e-02f, -1.25790998e-01f,
  -6.93529472e-02f, -3.26584578e-02f, 1.57177702e-01f, -1.11441649e-02f, 4.46537696e-02f, -2.72590965e-01f, 1.50534615e-01f, -1.45035595e-01f, 1.54129818e-01f, -1.25747964e-01f,
  -2.87328772e-02f, 1.44679755e-01f, 1.94790736e-01f, 2.37910196e-01f, 2.15819608e-02f, -3.97140160e-03f, 5.20336330e-02f, 2.43849978e-02f, -1.66733190e-02f, 4.08139406e-03f,
  3.64710279e-02f, -1.74806267e-01f, -6.54625073e-02f, -2.13950835e-02f, 7.50790536e-02f, 1.72704577e-01f, 2.34340250e-01f, -2.10556895e-01f, 1.66873723e-01f, 1.47039652e-01f,
  8.84224400e-02f, 1.96719304e-01f, -1.80933680e-02f, 2.09724128e-01f, -2.83649087e-01f, 1.51500806e-01f, -9.56951007e-02f, 1.35208219e-01f, -6.47550374e-02f, -2.90505618e-01f,
  -7.88615644e-02f, -1.73084795e-01f, 3.38442028e-02f, -1.97443843e-01f, -1.34992301e-01f, -6.40989542e-02f, -7.32374489e-02f, -1.99207455e-01f, 7.84394294e-02f, -6.15427345e-02f,
  -6.09808639e-02f, 4.29439098e-02f, -4.17958796e-02f, -1.10765165e-02f, -3.05963039e-01f, 1.25337243e-01f, -1.56243742e-01f, 9.78409052e-02f, -2.80942023e-01f, 6.03024364e-02f,
  -2.94243127e-01f, -1.83268726e-01f, 6.92180693e-02f, -2.71638632e-01f, -1.04128659e-01f, 2.15083405e-01f, 5.14515974e-02f, -3.33820939e-01f, -1.28606975e-01f, 4.21526358e-02f,
  1.15346842e-01f, 1.19903661e-01f, 2.49053180e-01f, -7.87591115e-02f, -2.01433137e-01f, -9.67341438e-02f, -2.03369588e-01f, 2.12835729e-01f, 6.13044500e-02f, -5.80368787e-02f,
  -4.73325178e-02f, -1.04326881e-01f, -8.64102766e-02f, -4.67113927e-02f, 5.09483041e-03f, 8.87416825e-02f, -2.85094623e-02f, 7.27873072e-02f, 6.92986026e-02f, 2.95413528e-02f,
  3.58845405e-02f, 7.15561062e-02f, 2.01771125e-01f, 1.76604927e-01f, -3.01220834e-01f, 3.63571867e-02f, -6.09028675e-02f, -1.41197786e-01f, -2.29648635e-01f, -1.02133922e-01f,
  7.98257217e-02f, -3.48903328e-01f, -9.14016291e-02f, -2.65166014e-01f, 9.06594284e-03f, -5.46243340e-02f, 9.17591713e-03f, -2.15303570e-01f, 2.41340682e-01f, 5.97692514e-03f,
  2.81599234e-03f, 6.97224960e-02f, 1.89244583e-01f, 1.75686896e-01f, -1.16514117e-01f, -1.00345358e-01f, 1.91498637e-01f, -1.32645622e-01f, -2.73862988e-01f, -9.01551023e-02f,
  1.94521621e-01f, -1.32595092e-01f, 2.31038891e-02f, 6.76928386e-02f, -1.60850257e-01f, 1.88100338e-01f, -8.99174511e-02f, 2.34851822e-01f, 3.47859114e-02f, 1.65573522e-01f,
  4.22173962e-02f, -2.40175486e-01f, 1.70641765e-01f, 1.42987072e-01f, -2.52726823e-01f, -2.20422208e-01f, -5.82366213e-02f, 6.44609928e-02f, -9.31124017e-02f, -7.74902552e-02f,
  -2.17829078e-01f, 1.17290869e-01f, -1.42831579e-01f, 5.73491678e-02f, -1.52732715e-01f, 1.53607773e-02f, -1.89887807e-01f, 1.42300334e-02f, 1.39061420e-03f, -1.38549566e-01f,
  4.03204225e-02f, 1.70675218e-01f, 6.49017990e-02f, 1.77505729e-03f, -4.41658229e-01f, 1.83837712e-01f, 3.78256179e-02f, -2.59006143e-01f, -3.73598351e-03f, -4.19447958e-01f,
  1.35297850e-01f, 1.58735067e-01f, 1.73790544e-01f, 9.50700119e-02f, 1.98469572e-02f, -9.78315845e-02f, 1.22806318e-01f, 1.53886482e-01f, -8.06206688e-02f, 6.36880621e-02f,
  -1.15015276e-01f, -1.37435466e-01f, -1.45143256e-01f, -7.78860748e-02f, -3.81941319e-01f, 7.08284974e-02f, 2.42895149e-02f, -1.00003950e-01f, -8.15018862e-02f, -2.14561284e-01f,
  5.91718480e-02f, -8.09247196e-02f, -5.89610897e-02f, -4.52133752e-02f, 6.19601905e-02f, -1.10646993e-01f, 1.02322035e-01f, -2.16005936e-01f, 1.47879556e-01f, -2.14789674e-01f,
  -1.07662551e-01f, 1.70456339e-02f, 1.03631474e-01f, 6.40545264e-02f, -1.54291600e-01f, 2.15084940e-01f, 2.11448167e-02f, -2.15146229e-01f, -1.96132421e-01f, -6.52049258e-02f,
  -1.66717008e-01f, -2.63376027e-01f, 1.89365625e-01f, 6.79720342e-02f, 1.89010888e-01f, 7.23726600e-02f, -1.28490388e-01f, -3.06652728e-02f, -1.40120275e-02f, -6.42988458e-02f,
  4.21649218e-02f, 9.87920389e-02f, -1.65925696e-01f, -9.07439515e-02f, 1.86881006e-01f, -1.68245137e-02f, -2.23693162e-01f, -1.86627641e-01f, -2.19212115e-01f, 3.81166376e-02f,
  -3.75889510e-01f, -9.93164629e-03f, -5.03411852e-02f, -1.43985167e-01f, -1.51586859e-02f, 3.04645058e-02f, 5.64474836e-02f, -4.66564968e-02f, -3.63922805e-01f, -6.50007725e-02f,
  -3.08436722e-01f, 1.71784490e-01f, -6.54552877e-02f, 8.58592689e-02f, 1.56167835e-01f, 2.03173473e-01f, 1.15141511e-01f, -9.43867397e-03f, -1.61293019e-02f, 4.88377847e-02f,
  3.55084166e-02f, 1.53875247e-01f, 1.56163111e-01f, 4.72789146e-02f, -5.04220091e-02f, -5.10159321e-02f, 1.74185380e-01f, -2.22540364e-01f, -1.84932828e-01f, -9.69890803e-02f,
  1.00108027e-01f, 1.11420982e-01f, 1.41791001e-01f, 5.92302307e-02f, -3.11430901e-01f, -3.50876115e-02f, -3.58071625e-01f, -1.62664324e-01f, 7.54133016e-02f, 4.40706685e-03f,
  -7.71304891e-02f, -2.23909467e-02f, -2.50571389e-02f, -5.99724939e-03f, 1.00466855e-01f, -1.77457377e-01f, 1.83903053e-01f, 1.02331944e-01f, -8.20617825e-02f, -5.55253327e-02f,
  3.15621197e-02f, 3.68125178e-02f, 2.49588668e-01f, 6.01911126e-03f, 1.63109779e-01f, -6.95961565e-02f, 9.42886248e-02f, -1.22919001e-01f, 1.04856513e-01f, 4.79044542e-02f,
  -8.42041001e-02f, 9.24172178e-02f, 1.49753168e-01f, -2.06635639e-01f, -1.39023840e-01f, -2.17291400e-01f, 2.48591587e-01f, 3.07092778e-02f, -1.64085045e-01f, -6.81486633e-03f,
  1.78540185e-01f, -3.18941712e-01f, -4.71147224e-02f, 2.35728353e-01f, -1.49775445e-01f, 5.26027568e-03f, -1.38748899e-01f, 1.01251893e-01f, 4.94236201e-02f, 1.65198967e-01f,
  -2.52559315e-02f, -1.42251492e-01f, 6.84263259e-02f, -2.36014038e-01f, -3.55790526e-01f, -1.99822769e-01f, -1.08073972e-01f, 2.21835211e-01f, -2.29085296e-01f, -2.98221540e-02f,
  2.63872184e-03f, -2.81544924e-01f, -1.87703356e-01f, 1.44580752e-01f, -3.98343086e-01f, -2.44038273e-02f, 3.48708369e-02f, 2.61158161e-02f, 1.65064931e-01f, -3.25195044e-01f,
  -2.90788919e-01f, -2.79667765e-01f, 6.15411475e-02f, 1.15019642e-01f, 7.72956014e-02f, 4.60703038e-02f, 3.02133292e-01f, 8.11436027e-02f, -1.14997111e-01f, -5.50190248e-02f,
  8.95155072e-02f, -2.58611888e-01f, -1.34027615e-01f, -7.25819990e-02f, 7.43771866e-02f, 8.32248479e-02f, 6.40885606e-02f, 1.22259691e-01f, 1.58354566e-01f, -9.54498500e-02f,
  6.89724758e-02f, -1.02248769e-02f, -2.19762459e-01f, -4.95633818e-02f, 1.02198616e-01f, 2.16579273e-01f, -1.90702572e-01f, 4.71115224e-02f, 1.76167965e-01f, -1.70621440e-01f,
  -1.01348899e-01f, -8.73585325e-03f, -1.38045833e-01f, -2.41477042e-01f, -5.68634644e-02f, 6.17372282e-02f, -6.72314540e-02f, 6.00284971e-02f, -2.67961230e-02f, 5.39822057e-02f,
  -7.61322752e-02f, -2.37086937e-02f, -2.59455889e-01f, -2.25441679e-02f, -1.00931950e-01f, -8.08691904e-02f, 2.36012995e-01f, -8.94375741e-02f, -3.12484175e-01f, -2.17768401e-01f,
  1.36373863e-01f, 1.58983409e-01f, 1.14875391e-01f, -3.55805643e-02f, -1.32174576e-02f, -1.39158830e-01f, 1.68491766e-01f, -2.50303298e-01f, 6.59419447e-02f, -1.36049673e-01f,
  -3.58510464e-01f, 7.37467632e-02f, 2.07461968e-01f, 9.21759084e-02f, 2.20814034e-01f, -3.76003445e-03f, 4.31322493e-02f, 6.50613159e-02f, 1.01323038e-01f, 1.94224566e-01f,
  -1.28727913e-01f, -1.33236915e-01f, -2.63892263e-01f, 2.25827068e-01f, -2.76173145e-01f, -1.81768104e-01f, -7.87060186e-02f, -2.64508694e-01f, -2.34737992e-02f, 7.12543949e-02f,
  1.01099201e-01f, 6.01664297e-02f, -1.37828827e-01f, -7.05059916e-02f, 1.50761917e-01f, -7.77560659e-03f, -1.06133027e-02f, -1.15880355e-01f, 2.43685454e-01f, 1.28369287e-01f,
  1.53987825e-01f, 2.50504822e-01f, -1.64548367e-01f, -1.58315241e-01f, -4.33121063e-02f, -1.85952783e-01f, 2.11921424e-01f, -2.92398393e-01f, 5.96987009e-02f, -1.88982543e-02f,
  5.69446608e-02f, 5.41048460e-02f, 1.09931387e-01f, 1.48826405e-01f, -1.53065557e-02f, 1.91125110e-01f, 1.44912913e-01f, -8.73893220e-03f, 1.08880311e-01f, -1.46302795e-02f,
  -2.02436984e-01f, 1.49906278e-01f, 1.33086935e-01f, -2.60871142e-01f, 7.36541003e-02f, 1.24470368e-01f, 5.09155840e-02f, -9.74198729e-02f, 8.17974880e-02f, -2.07484677e-01f,
  1.17790187e-03f, 1.31662875e-01f, -5.25940545e-02f, 2.93086395e-02f, -3.19744915e-01f, -1.08908251e-01f, 1.19065538e-01f, -7.37447515e-02f, 1.34833083e-01f, -1.62926793e-01f,
  -2.64789551e-01f, 9.95979682e-02f, -4.47488949e-02f, -2.42195398e-01f, -4.13056314e-02f, -2.14740902e-01f, -5.12645440e-03f, -1.68471634e-01f, 4.63668108e-02f, -1.78212762e-01f,
  1.11346945e-01f, -2.43770450e-01f, -7.38548720e-03f, 3.12293554e-03f, 5.91654405e-02f, -9.34422761e-02f, 6.15557581e-02f, 8.37215409e-02f, 1.53080076e-01f, 1.48623273e-01f,
  -4.56388518e-02f, 6.22090660e-02f, 2.20009953e-01f, 7.04606995e-02f, 2.24764813e-02f, -3.83272916e-02f, 8.85616913e-02f, 8.35982859e-02f, -1.42166391e-01f, -9.90677625e-02f,
  -1.34167355e-02f, 6.93212003e-02f, -7.80289769e-02f, 1.25344634e-01f, 2.38659978e-01f, -9.94483456e-02f, 2.32378855e-01f, 2.52453368e-02f, 2.63538241e-01f, -1.10128030e-01f,
  -1.99195445e-01f, -9.64710042e-02f, 4.70452197e-02f, 2.53227413e-01f, -2.96463847e-01f, -1.80950370e-02f, 1.63701788e-01f, -1.35206491e-01f, -1.60245046e-01f, -4.12578508e-02f,
  1.92478910e-01f, 2.61846393e-01f, -1.03241950e-01f, 1.89984545e-01f, -4.84414957e-02f, -2.89108586e-02f, -7.89988562e-02f, -1.14625461e-01f, -2.10215449e-01f, -5.68928756e-02f,
  -1.53479790e-02f, -6.17618323e-04f, 1.60590172e-01f, 8.24564025e-02f, -2.19718680e-01f, 4.08911780e-02f, -7.79486969e-02f, -2.35163897e-01f, -1.46888152e-01f, -1.54863194e-01f,
  -1.73088104e-01f, 1.05009548e-01f, -8.59913528e-02f, -6.45013526e-02f, 1.86334968e-01f, 3.85089405e-02f, 1.14833295e-01f, -6.44888207e-02f, 4.27915677e-02f, -1.66355651e-02f,
  1.14625099e-03f, 1.65705346e-02f, -1.38855889e-01f, 1.63152069e-01f, -1.87491745e-01f, -4.96147834e-02f, 1.12578578e-01f, -2.27110818e-01f, 9.00335461e-02f, 1.58381790e-01f,
  -2.09238119e-02f, -4.47929762e-02f, -3.60678971e-01f, -6.41478300e-02f, -1.32053401e-02f, -3.03154469e-01f, -7.41728246e-02f, -9.37204883e-02f, -1.84134468e-01f, -1.71218634e-01f,
  2.52998639e-02f, 2.41770651e-02f, -1.41436845e-01f, 9.40817967e-02f, 2.37551462e-02f, 1.41260281e-01f, 1.92312360e-01f, -4.32489067e-02f, 1.38755068e-01f, 1.45045251e-01f,
  -1.85327426e-01f, -1.67803317e-02f, 1.60680667e-01f, 6.81781769e-02f, -1.41980827e-01f, 5.69845848e-02f, 1.59112602e-01f, -2.23269183e-02f, 9.38378200e-02f, -3.07901442e-01f,
  -1.66292951e-01f, -1.24631256e-01f, -2.97654063e-01f, 9.90306661e-02f, 1.16631344e-01f, 9.17490572e-02f, -3.17337245e-01f, -1.09500274e-01f, -1.41441628e-01f, -4.18302268e-01f,
  1.67665780e-01f, 7.15056360e-02f, 1.49812371e-01f, -2.00477853e-01f, 1.98344991e-01f, -2.14438438e-01f, -1.06428996e-01f, -2.59288877e-01f, -2.13755563e-01f, -2.53631055e-01f,
  6.78025857e-02f, -4.10641991e-02f, 1.34894565e-01f, 1.23110138e-01f, -1.45740762e-01f, -9.19754505e-02f, -1.49280891e-01f, 7.10988650e-03f, 3.30126062e-02f, -4.74476032e-02f,
  -2.46391624e-01f, 1.00939631e-01f, -8.80751908e-02f, -2.01281235e-01f, -6.83421567e-02f, 1.12893015e-01f, -1.28535494e-01f, 8.76412988e-02f, -2.79630065e-01f, 1.00942671e-01f,
  -1.22049145e-01f, -2.32159808e-01f, 1.37155533e-01f, -7.72523209e-02f, 8.10614377e-02f, -3.06579590e-01f, -2.23193206e-02f, -1.10877231e-01f, 1.75806224e-01f, 3.72668542e-02f,
  -3.23843509e-01f, -2.57998258e-01f, -1.99518606e-01f, -1.29646594e-02f, 1.93274051e-01f, -9.21224579e-02f, -1.29728869e-01f, -2.96404101e-02f, 6.56037405e-02f, -1.45995453e-01f,
  -2.97811896e-01f, 1.91131338e-01f, -1.28585786e-01f, 2.70222574e-01f, -2.23562121e-01f, -1.17718417e-03f, 1.54156864e-01f, 1.87136214e-02f, -3.14855874e-01f, -1.99520513e-01f,
  2.63552573e-02f, -1.60050601e-01f, -2.09439173e-01f, 1.49775907e-01f, -1.76869005e-01f, 1.36140093e-01f, -2.18967140e-01f, 1.72782406e-01f, 9.89211649e-02f, 1.26608595e-01f,
  3.24987620e-02f, 2.34452009e-01f, -1.50450096e-01f, 1.46992236e-01f, 4.59529422e-02f, 1.52873561e-01f, 4.03615721e-02f, -1.09401368e-01f, -1.14360042e-01f, 1.16148323e-01f,
  -6.08258136e-02f, -5.28985076e-02f, 1.74417570e-01f, 1.16812393e-01f, -1.48437932e-01f, -7.05098584e-02f, -4.08975065e-01f, -5.14078103e-02f, -1.80970296e-01f, -9.25707892e-02f,
  7.83794522e-02f, -8.45972542e-03f, -8.47322121e-02f, -8.55425596e-02f, -3.77437635e-03f, 4.31203423e-03f, -8.40851292e-02f, 1.20091267e-01f, -3.69509049e-02f, 3.94273140e-02f,
  -2.16306522e-02f, -1.86921164e-01f, -1.95880711e-01f, 5.61215691e-02f, -3.37346256e-01f, -2.79088039e-02f, 9.09645334e-02f, -2.09896490e-01f, -2.79026955e-01f, -1.10538244e-01f,
  8.20799544e-02f, -1.72806308e-01f, 3.21779735e-02f, -5.19534238e-02f, 1.66473716e-01f, -2.13320196e-01f, -3.02339256e-01f, 5.71024530e-02f, 1.24217719e-01f, -5.35153202e-04f,
  6.43291846e-02f, -2.69514918e-01f, -4.65931138e-03f, 1.44781992e-01f, 1.06530443e-01f, 3.74400318e-02f, -7.37056881e-02f, 3.05752605e-01f, -2.48501495e-01f, 1.49090514e-01f,
  -1.92870498e-01f, 3.06759775e-01f, -3.65887165e-01f, 1.06646046e-01f, -2.08055511e-01f, -2.22817417e-02f, -1.69461027e-01f, -1.33057415e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -6.68609589e-02f, 2.88061481e-02f, -1.36615941e-02f, -5.74662015e-02f, 1.01732641e-01f, 7.85196852e-03f, 6.10121600e-02f, -1.86865792e-01f, -4.52696718e-02f, -2.58636735e-02f,
  8.98617506e-02f, 9.23609361e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    