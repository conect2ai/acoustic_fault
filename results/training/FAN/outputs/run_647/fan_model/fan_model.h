/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.30972731e-01f, 2.70545095e-01f, -3.22421610e-01f, 1.90225720e-01f, -8.32245648e-02f, -2.44806737e-01f, -2.28465989e-01f, 1.72334760e-02f, 1.83219060e-01f, 1.65125728e-01f,
  3.59661952e-02f, 1.15829028e-01f, -1.54440984e-01f, -2.14311361e-01f, -2.90969282e-01f, -2.30770588e-01f, -2.04042763e-01f, -3.62275392e-01f, -3.00922662e-01f, 5.10896789e-03f,
  6.78316802e-02f, 2.45048970e-01f, 1.25881642e-01f, 4.98955660e-02f, 3.25506389e-01f, -8.58089030e-02f, 6.50516301e-02f, 1.57333925e-01f, -1.48845792e-01f, 1.60854056e-01f,
  -3.81624289e-02f, 1.03627324e-01f, -2.11265892e-01f, -1.16437845e-01f, -4.97241318e-03f, -9.21269357e-02f, -1.15181826e-01f, 1.80422049e-02f, -6.53698370e-02f, -6.73519075e-02f,
  -2.76588704e-02f, -6.22097701e-02f, -2.55488515e-01f, -4.72663380e-02f, -8.85726064e-02f, -6.92204162e-02f, -3.01486813e-02f, -1.68330252e-01f, -1.24021403e-01f, -3.79386637e-03f,
  4.52912673e-02f, 6.74987445e-03f, -4.73998189e-02f, -1.72432974e-01f, -1.74615219e-01f, -2.47109115e-01f, 4.26659547e-03f, -1.49862487e-02f, -2.94304669e-01f, 1.84619933e-01f,
  7.82634467e-02f, 3.43737379e-02f, -9.84830502e-03f, 1.73117612e-02f, -1.68872590e-03f, -1.40317623e-02f, -9.01739392e-03f, 3.03316135e-02f, -5.13744801e-02f, 4.54508848e-02f,
  -1.05230212e-01f, -4.03437056e-02f, -1.84508096e-02f, 4.38382737e-02f, -2.54331604e-02f, 1.21301878e-02f, -5.08784875e-02f, 5.02576493e-02f, -2.31613629e-02f, -4.77615930e-02f,
  -1.76919568e-02f, -5.94621710e-03f, 2.36689299e-02f, -4.81369980e-02f, -4.52134646e-02f, -9.05548129e-03f, -1.31140696e-02f, 2.23377272e-02f, 6.06721500e-03f, 7.49990270e-02f,
  5.60934655e-02f, -3.80815834e-01f, 8.67819879e-03f, 2.23706085e-02f, -2.11432371e-02f, -3.53839546e-02f, 2.19226535e-02f, -8.41647908e-02f, -1.43687101e-02f, -6.30414672e-03f,
  -7.79927373e-02f, -1.04229517e-01f, -4.79214117e-02f, -7.89396465e-02f, -1.28030404e-01f, -8.06757659e-02f, 5.28392605e-02f, -3.19273137e-02f, -1.15684777e-01f, 6.78097755e-02f,
  6.81865541e-03f, -3.93121466e-02f, -5.99162765e-02f, -1.42064288e-01f, -4.69654202e-02f, -1.51870564e-01f, -1.39387220e-01f, -3.73018011e-02f, -2.73075104e-01f, 6.80899397e-02f,
  8.76910627e-01f, -4.09274280e-01f, -3.33183706e-01f, 3.67724031e-01f, -5.08438125e-02f, -1.18013240e-01f, -4.34061259e-01f, -4.38438132e-02f, 2.35632822e-01f, -1.07487880e-01f,
  -2.13148929e-02f, 2.08864853e-01f, 1.09650314e-01f, -7.94379190e-02f, -1.22630715e-01f, -3.07610512e-01f, -3.18202108e-01f, -2.06268113e-02f, 2.55854070e-01f, 6.97085336e-02f,
  8.88958946e-02f, 1.17722541e-01f, 3.36582839e-01f, 4.92278337e-02f, 7.69169927e-02f, 2.11524248e-01f, -2.71778435e-01f, -8.58393908e-02f, -3.16705376e-01f, -3.21887940e-01f,
  7.08674714e-02f, -1.07724935e-01f, -5.75555898e-02f, 8.47327933e-02f, 2.47649872e-03f, 1.03658497e-01f, 9.67523307e-02f, 2.22473200e-02f, 5.70224002e-02f, -1.74547937e-02f,
  -5.67871928e-02f, 9.67416912e-02f, 4.73764911e-02f, -3.33308764e-02f, -4.36134748e-02f, -6.06742222e-03f, -2.11059153e-02f, -3.30921225e-02f, -7.45739415e-02f, -4.55715507e-02f,
  -5.19376136e-02f, 3.49775050e-03f, 2.75670197e-02f, -1.44912928e-01f, -1.33848324e-01f, 5.39766923e-02f, -1.29686162e-01f, -1.66619513e-02f, -9.11012739e-02f, 5.88866249e-02f,
  1.49337938e-02f, -3.66162173e-02f, 4.02476378e-02f, 4.62165363e-02f, 9.11432430e-02f, 1.05503323e-02f, -1.32331019e-02f, -4.10591532e-03f, -2.22154725e-02f, -2.29735635e-02f,
  -4.27085124e-02f, 1.48055153e-02f, 3.21601219e-02f, -4.39714119e-02f, 3.37962131e-03f, 2.29534451e-02f, 1.12142162e-02f, 3.35220085e-03f, -1.63700758e-03f, 1.08788246e-02f,
  4.86935973e-02f, -7.06289038e-02f, -3.51577811e-02f, 3.03003518e-03f, -9.45225954e-02f, 3.26829627e-02f, 1.54561047e-02f, 3.01436633e-02f, 2.82136165e-02f, 3.33665125e-02f,
  1.84536710e-01f, -1.22548036e-01f, 5.92737719e-02f, -7.72781149e-02f, 5.12399944e-03f, -6.42383024e-02f, 9.38742515e-03f, 2.77231238e-03f, -4.53078821e-02f, -1.28953820e-02f,
  -5.48078194e-02f, 4.80845831e-02f, -7.33883604e-02f, -4.44290191e-02f, 8.03064480e-02f, -3.04015889e-03f, 1.00303032e-02f, 6.34889081e-02f, -7.23104598e-03f, 1.03490520e-02f,
  -6.26679733e-02f, 5.14954887e-02f, 1.69744715e-01f, 4.03574668e-03f, 9.27534048e-03f, 6.45471290e-02f, 3.76226055e-03f, 7.42631033e-02f, 4.33239527e-02f, 3.07178721e-02f,
  -1.63430601e-01f, -1.66135013e-01f, -3.96040946e-01f, -2.19556734e-01f, -3.46190840e-01f, -1.11610182e-01f, -4.75230776e-02f, 1.15286060e-01f, 2.59904176e-01f, -1.09376706e-01f,
  4.47741598e-02f, 1.16961867e-01f, 1.84904814e-01f, 1.56888291e-01f, 4.43885103e-02f, -1.75277382e-01f, -3.40797901e-01f, -1.64451092e-01f, 6.65634945e-02f, 6.27540499e-02f,
  8.45669210e-02f, -1.13579795e-01f, -3.01731247e-02f, 4.31863219e-02f, -8.26513171e-02f, 3.40945870e-02f, -1.47756591e-01f, -1.96856901e-01f, 2.57548932e-02f, -2.71502316e-01f,
  -1.56705558e-01f, -3.92088413e-01f, -3.49796079e-02f, 3.37391347e-02f, -2.14310229e-01f, -3.25743258e-02f, -7.44167566e-02f, -2.06236005e-01f, -6.18802905e-02f, -8.31815749e-02f,
  -2.49691710e-01f, -1.25350654e-01f, -1.16047539e-01f, -8.32068026e-02f, -7.08836988e-02f, -5.40141799e-02f, 2.79397033e-02f, -1.32592112e-01f, 4.55832994e-03f, -8.87585729e-02f,
  6.12581335e-02f, -2.18671679e-01f, -2.01092675e-01f, 1.10586911e-01f, -7.03904033e-02f, -5.99247105e-02f, -9.65549052e-02f, -8.06617439e-02f, -3.68888751e-02f, -2.12396570e-02f,
  8.49589854e-02f, 1.39954075e-01f, 1.21220872e-01f, 6.75038025e-02f, 9.93128642e-02f, 4.75484431e-02f, 7.64396638e-02f, 3.80636267e-02f, 1.15879335e-01f, 9.24208835e-02f,
  5.75453006e-02f, -5.90846688e-02f, 7.69041330e-02f, 6.11551069e-02f, 2.56288480e-02f, -1.93922687e-02f, 1.93870872e-01f, 1.44963428e-01f, -4.70666448e-03f, -1.17540127e-03f,
  5.66251688e-02f, 6.11590855e-02f, 6.51821448e-03f, 1.36568576e-01f, 5.05326837e-02f, 8.20107311e-02f, 6.24186210e-02f, -1.13614118e-02f, 7.82816261e-02f, -5.11366427e-02f,
  2.75503933e-01f, -5.11785969e-02f, -8.08920264e-02f, -2.10297517e-02f, -1.36736885e-01f, -5.99013567e-02f, -8.19853097e-02f, -8.52391496e-02f, -1.07270278e-01f, -9.79771763e-02f,
  -5.09656966e-02f, -2.27364432e-02f, -1.10274896e-01f, -2.08234806e-02f, -7.94106349e-02f, -1.94424298e-02f, -4.42187525e-02f, -2.47468315e-02f, -1.55017236e-02f, -1.41305681e-02f,
  -8.76977108e-03f, 4.59766909e-02f, 1.42451063e-01f, 3.67615069e-03f, -3.24085653e-02f, -6.76678540e-03f, -5.05537055e-02f, -2.38659326e-02f, 4.68541235e-02f, 8.53565708e-02f,
  -6.55275881e-01f, -3.52968752e-01f, -1.08412288e-01f, -4.38236922e-01f, -2.47682855e-01f, -1.64108083e-01f, -2.46473789e-01f, -1.58395350e-01f, -2.01928779e-01f, -3.01176101e-01f,
  2.06885953e-02f, 1.22704349e-01f, -1.11339549e-02f, 6.15441985e-02f, -2.02594817e-01f, -2.67919064e-01f, -2.85255253e-01f, 6.16360679e-02f, 4.06125635e-02f, -7.19905570e-02f,
  -6.85944036e-02f, -2.95247078e-01f, -1.21168606e-01f, -7.12289009e-03f, -1.26922891e-01f, 7.89485723e-02f, 3.91309038e-02f, -7.62037635e-02f, 1.42374873e-01f, -2.00097442e-01f,
  -9.70195681e-02f, -2.25880533e-01f, 3.93046578e-03f, -8.88908580e-02f, -8.63613784e-02f, -8.66492689e-02f, -1.73214287e-01f, 5.01578599e-02f, 2.86409408e-02f, -1.43948317e-01f,
  -1.18557714e-01f, -1.10072959e-02f, -1.34810051e-02f, -7.34050875e-04f, -1.55099377e-01f, -9.11613926e-02f, -2.57842168e-02f, 1.02382796e-02f, 7.34150992e-04f, -3.79500650e-02f,
  -5.43742732e-04f, 1.80432182e-02f, -1.41679375e-02f, 2.21688244e-02f, 1.67027693e-02f, 8.67967214e-03f, 6.49055094e-02f, 9.94340330e-02f, 7.96908662e-02f, -8.18592533e-02f,
  1.60278380e-03f, 5.91825247e-02f, -2.53095711e-03f, -9.03522782e-03f, 6.01429343e-02f, 1.46775171e-01f, 1.02284081e-01f, 1.42621752e-02f, 6.29984289e-02f, 4.47738394e-02f,
  2.42144149e-02f, 8.50779265e-02f, -3.06189880e-02f, -1.82662699e-02f, 2.52380744e-02f, 1.04869172e-01f, 8.19264278e-02f, 9.39064566e-03f, 6.54301271e-02f, 1.40952617e-01f,
  9.30982456e-02f, 1.22192830e-01f, 1.82365882e-03f, 1.58045441e-01f, -4.85421829e-02f, -4.70644683e-02f, 1.29678892e-02f, 9.32039991e-02f, 2.57931836e-02f, 7.32123107e-02f,
  -5.42243607e-02f, 1.25235498e-01f, -1.63107783e-01f, -5.29505573e-02f, -7.01286048e-02f, 1.71581341e-03f, -1.53322630e-02f, 8.62834416e-03f, 5.97541109e-02f, -4.38458920e-02f,
  2.63177250e-02f, -9.10307392e-02f, -1.04905955e-01f, 2.54557841e-02f, -1.41175315e-01f, -6.30193651e-02f, -8.49765465e-02f, 2.62827077e-03f, 3.85666490e-02f, 5.65929525e-02f,
  1.59405544e-02f, -9.13257301e-02f, -5.71241661e-04f, 6.13617562e-02f, -3.77474166e-02f, 1.39539957e-03f, 1.23392209e-01f, 2.78124176e-02f, 2.97038946e-02f, -1.45294175e-01f,
  -3.24224919e-01f, -5.88233352e-01f, -1.53568849e-01f, -6.22934699e-02f, 7.12304860e-02f, 2.79877067e-01f, 1.93026140e-01f, 1.80783883e-01f, 3.81324004e-04f, -1.50777847e-01f,
  -1.83403954e-01f, -1.33500531e-01f, -2.47840464e-01f, -5.56330308e-02f, 1.44416653e-02f, -6.46165758e-02f, -2.04659551e-02f, 1.02057122e-02f, 2.28291988e-01f, 3.92917097e-01f,
  1.12795815e-01f, -1.88278988e-01f, -9.06764492e-02f, 5.88924289e-02f, -1.55989960e-01f, -1.77133176e-02f, -1.97408423e-01f, -9.13790613e-02f, 1.28716156e-01f, -4.47892249e-01f,
  -2.57686228e-01f, -1.21496111e-01f, 1.43724218e-01f, -2.77376007e-02f, -7.83250332e-02f, -8.29774328e-03f, 4.33050506e-02f, -1.52645737e-01f, -5.53668179e-02f, -8.79580528e-02f,
  -2.86103729e-02f, -4.02897336e-02f, 4.49181627e-03f, -4.23421152e-02f, 2.08509043e-02f, 5.65189980e-02f, -8.76720548e-02f, -1.29976556e-01f, -2.78870463e-02f, 7.15115145e-02f,
  -1.31749839e-01f, 5.62602207e-02f, -1.22878170e-02f, 1.34858377e-02f, 6.90847486e-02f, -2.24271864e-02f, -4.64163348e-02f, -6.13023452e-02f, -9.98565089e-03f, -2.42153287e-01f,
  8.12207907e-02f, -8.15761276e-03f, -4.39666882e-02f, 8.86879861e-03f, -6.05381429e-02f, 1.69561151e-02f, -4.56575071e-04f, -4.86236103e-02f, 5.40320538e-02f, 1.29054859e-02f,
  -2.26852912e-02f, -5.95254637e-02f, -4.85487506e-02f, -3.11150029e-02f, -1.45390267e-02f, -8.40452835e-02f, 5.50364628e-02f, -3.66058946e-03f, 1.10034151e-02f, 2.49099731e-02f,
  -4.30664904e-02f, 6.26786277e-02f, 4.03361581e-03f, -3.41984257e-02f, 1.88552104e-02f, -2.97180321e-02f, -2.32746657e-02f, 3.19687873e-02f, -3.20054544e-03f, 8.35578293e-02f,
  -1.55303672e-01f, -3.94839421e-02f, -9.90316495e-02f, 2.72105038e-02f, -2.27570441e-02f, -5.08462973e-02f, -1.14044800e-01f, -3.00684683e-02f, -1.06710359e-01f, -3.86704914e-02f,
  5.51120192e-02f, -1.50657343e-02f, -5.55502139e-02f, 2.76155863e-02f, -1.53991776e-02f, 4.62901630e-02f, -1.42825942e-03f, -2.36210860e-02f, 2.01059785e-02f, -3.02514564e-02f,
  -3.45963985e-02f, 2.97306422e-02f, 6.69013262e-02f, 2.81648654e-02f, 3.49609330e-02f, 5.95940910e-02f, -4.48962189e-02f, 5.98937608e-02f, 2.07534749e-02f, -7.32132196e-02f,
  -2.33516991e-01f, -2.55065143e-01f, 7.07496107e-02f, -1.19798981e-01f, -5.47597148e-02f, -1.21837638e-01f, -4.67324197e-01f, -1.46507680e-01f, 5.02890386e-02f, -3.34699079e-02f,
  -4.74625789e-02f, 1.74493104e-01f, 7.98779875e-02f, 1.29388690e-01f, -5.53141907e-02f, -1.42369330e-01f, 3.93999256e-02f, 7.98432156e-02f, -1.20895572e-01f, -1.74979135e-01f,
  8.80636722e-02f, 8.23494885e-03f, -4.57974784e-02f, -9.29875579e-03f, 2.66552895e-01f, 1.56608880e-01f, 8.82646367e-02f, 1.70181781e-01f, -8.11158027e-03f, 4.03979093e-01f,
  1.79564375e-02f, 7.77246952e-02f, -1.20222434e-01f, -2.15402176e-03f, 5.21454215e-03f, 1.68723855e-02f, 3.77241597e-02f, -3.73891555e-02f, 5.78990839e-02f, -3.22634540e-02f,
  -2.57714260e-02f, -1.02641238e-02f, 7.61434063e-02f, -6.29393905e-02f, -7.09642842e-02f, -1.26493871e-01f, -1.48372546e-01f, -5.91063201e-02f, 3.19404854e-03f, 5.51025905e-02f,
  1.02340452e-01f, -1.11106234e-02f, -9.86642241e-02f, -4.36114594e-02f, 6.04998358e-02f, 9.27635096e-03f, -6.69896975e-02f, -6.44859066e-03f, 2.20493302e-02f, -1.30170181e-01f,
  -1.23220704e-01f, 6.07914589e-02f, 1.88220218e-02f, -1.56620368e-01f, -1.06745489e-01f, 4.67302538e-02f, -1.41784772e-02f, -1.64423250e-02f, -3.23488563e-02f, -4.55669835e-02f,
  -3.62270586e-02f, -2.37293858e-02f, 6.85281381e-02f, 3.12131438e-02f, 1.68939233e-01f, -3.03362380e-04f, -2.03714222e-02f, -1.24892421e-01f, -7.14639798e-02f, 2.43600141e-02f,
  5.52978106e-02f, 3.20569798e-02f, 5.86830378e-02f, 3.60750444e-02f, 1.54354036e-01f, 4.03194018e-02f, 1.70290153e-02f, 8.59582797e-02f, 7.16381669e-02f, 5.20853922e-02f,
  -3.01093251e-01f, -4.28470224e-03f, -1.67771310e-01f, -1.76332846e-01f, 8.67315626e-04f, 4.39221375e-02f, 4.83052842e-02f, -1.00705922e-01f, 6.78752512e-02f, -1.94908082e-02f,
  3.08579970e-02f, -3.70587246e-03f, -2.97014266e-02f, -4.00389358e-02f, -1.33187234e-01f, -1.08688042e-01f, -2.01078877e-01f, -1.07120648e-01f, 2.39782734e-03f, 1.50298856e-05f,
  -3.02926339e-02f, -1.31687194e-01f, -2.22168460e-01f, -2.35744610e-01f, -2.25543976e-02f, -1.41169593e-01f, -1.62892535e-01f, -1.54478624e-01f, -2.26269111e-01f, -4.57193732e-01f,
  1.86914667e-01f, -5.22783846e-02f, 1.68069646e-01f, -9.98092964e-02f, -2.26790324e-01f, -8.38699788e-02f, 4.12810072e-02f, 9.43890363e-02f, -1.93846732e-01f, -2.37185031e-01f,
  1.75136745e-01f, 1.81013912e-01f, 1.32474542e-01f, 2.39679545e-01f, 3.32265615e-01f, -2.17170060e-01f, -2.39427000e-01f, 2.36261666e-01f, 4.24056649e-01f, 2.28563577e-01f,
  -2.99737547e-02f, -5.56810647e-02f, 3.26942235e-01f, 2.89455205e-01f, -3.14404249e-01f, -1.86483070e-01f, -2.08973542e-01f, -1.14213578e-01f, 2.37375144e-02f, -4.91931975e-01f,
  1.36333741e-02f, 3.08089465e-01f, 1.36076167e-01f, 7.41484314e-02f, 3.75447720e-02f, 5.16976006e-02f, 9.31334794e-02f, 8.82657617e-02f, -2.01610234e-02f, 9.72753856e-03f,
  4.71440889e-02f, 8.04852843e-02f, 6.20084666e-02f, 7.70091563e-02f, 8.86564553e-02f, 7.85172880e-02f, 7.39623383e-02f, 3.08430046e-01f, 2.45881751e-01f, 4.59506735e-02f,
  5.82583575e-03f, 1.17448933e-01f, 2.06819773e-01f, 1.90472975e-01f, 2.97281921e-01f, 1.99845776e-01f, 1.27118006e-01f, 1.03263721e-01f, 1.99964702e-01f, -3.50436389e-01f,
  -1.44691780e-01f, -1.91116333e-02f, -5.02905473e-02f, -1.44626908e-02f, -3.02917361e-02f, -5.84286042e-02f, -7.31915012e-02f, -1.98012274e-02f, 2.50629685e-03f, -3.39752249e-03f,
  1.12955990e-04f, -6.29183277e-03f, 7.85094313e-03f, -3.15115526e-02f, -6.06813468e-02f, -1.17733302e-02f, 5.58046512e-02f, -2.28345804e-02f, 8.46613944e-02f, 2.22292524e-02f,
  9.33880061e-02f, 3.71378362e-02f, -1.10607035e-01f, 6.64781481e-02f, 4.85050604e-02f, 7.15017840e-02f, 2.71915598e-03f, 8.47252607e-02f, 2.18830314e-02f, 4.39595580e-02f,
  -1.92008629e-01f, 2.45298252e-01f, -9.70934182e-02f, 5.58454134e-02f, -7.43935704e-02f, 4.67041247e-02f, -3.13152112e-02f, 4.02306244e-02f, 3.63207683e-02f, 3.69548984e-02f,
  8.85014087e-02f, 3.10487230e-03f, 1.62745919e-03f, 2.68973093e-02f, -7.26353824e-02f, 1.60227995e-02f, -3.64430919e-02f, -1.66539215e-02f, 3.89684848e-02f, 8.72161798e-03f,
  -5.79494983e-04f, -1.10903285e-01f, -3.13583761e-02f, -7.59131089e-02f, -3.53438570e-03f, -4.07117046e-02f, -3.41467634e-02f, -5.74349724e-02f, 8.06938186e-02f, -3.73081684e-01f,
  -1.15782144e-02f, -9.81767103e-02f, 1.47655478e-03f, 4.06854041e-02f, 1.51680708e-01f, 1.79466620e-01f, 9.48311239e-02f, 4.52728644e-02f, 9.80669912e-03f, -1.26691749e-02f,
  3.76068771e-01f, 3.00868660e-01f, 1.20434463e-01f, 8.04808661e-02f, -5.35497889e-02f, -3.05968791e-01f, -4.32048202e-01f, -2.20967740e-01f, 1.14803687e-01f, 7.34069720e-02f,
  -8.70660618e-02f, -1.37629181e-01f, -4.06001434e-02f, -1.57219157e-01f, -3.22876394e-01f, -6.94183335e-02f, -2.45267272e-01f, -1.96334362e-01f, -1.71606034e-01f, -5.70386410e-01f,
  -5.78220896e-02f, -2.32587699e-02f, -6.06131628e-02f, -1.28825521e-02f, -9.23948735e-03f, -1.30905047e-01f, -6.23161756e-02f, -1.65660679e-01f, 6.78055510e-02f, -8.94696116e-02f,
  4.17243876e-03f, 7.89792910e-02f, 3.49906832e-02f, -5.23778275e-02f, -5.88698639e-03f, -1.78567339e-02f, -1.16602354e-01f, -2.15311408e-01f, -6.58085123e-02f, -6.63238391e-02f,
  -1.49066091e-01f, 1.78480092e-02f, 2.98476610e-02f, -7.92967081e-02f, -1.32313341e-01f, -1.14217557e-01f, -6.21054843e-02f, -2.51106828e-01f, -1.79596469e-01f, -3.87973130e-01f,
  -4.52189781e-02f, 2.93357167e-02f, 6.04887344e-02f, 2.90572513e-02f, -5.10026002e-03f, 6.86983243e-02f, 1.09172300e-01f, 9.34494212e-02f, 6.33870661e-02f, 5.88152632e-02f,
  1.03203148e-01f, 3.11903749e-02f, 4.98196818e-02f, 3.17224488e-02f, 3.02715171e-02f, 3.66826952e-02f, -1.26790414e-02f, -3.40335667e-02f, -1.99023895e-02f, 5.43948300e-02f,
  2.97809057e-02f, 6.65386021e-02f, 7.46000782e-02f, 2.99759973e-02f, 5.23765991e-03f, 1.43713113e-02f, -3.29393409e-02f, 5.65092675e-02f, 7.95168951e-02f, -4.18956345e-03f,
  -1.85668899e-03f, 1.90222099e-01f, -1.58083394e-01f, -1.27755553e-01f, 4.30051377e-03f, -9.86552015e-02f, -1.31702006e-01f, -2.79013067e-02f, 1.39980502e-02f, -3.43751796e-02f,
  1.35851026e-01f, 2.32907124e-02f, 7.77797177e-02f, -4.77542430e-02f, -6.12986041e-03f, 3.75434421e-02f, 8.76405984e-02f, 2.47844346e-05f, -9.03085843e-02f, -1.20116904e-01f,
  -5.56939058e-02f, -9.87459496e-02f, -7.15447217e-03f, 1.59549844e-02f, -5.60815632e-02f, -5.42793870e-02f, -5.73213026e-02f, -1.22747153e-01f, -1.19025342e-03f, -3.47706914e-01f,
  2.10153326e-01f, -4.37052429e-01f, -2.66581208e-01f, 1.41714051e-01f, -1.07868873e-01f, 6.49199784e-02f, -3.64866018e-01f, 2.14069150e-02f, 2.42430076e-01f, -2.00663194e-01f,
  -1.74227148e-01f, 3.11453342e-01f, 6.74825609e-02f, 1.95198670e-01f, 8.24516043e-02f, -3.14281493e-01f, -1.64277434e-01f, 9.41236243e-02f, 4.20103431e-01f, 1.95800513e-01f,
  7.74835795e-02f, 3.74248661e-02f, 1.97155014e-01f, 1.12642862e-01f, -5.77222370e-02f, 1.30210638e-01f, -2.47716591e-01f, -1.73990712e-01f, -6.03555366e-02f, -3.52106154e-01f,
  -1.77772537e-01f, -2.40366340e-01f, 9.69432369e-02f, 1.22080438e-01f, -1.27550215e-01f, 8.48872215e-02f, -1.67507697e-02f, -5.86346202e-02f, 2.00929381e-02f, -2.90963333e-02f,
  6.96298806e-03f, 4.30931114e-02f, 2.00353637e-02f, -7.32680038e-02f, -9.18749720e-02f, -2.67607421e-02f, 2.98932865e-02f, -2.62903199e-02f, 4.22525480e-02f, -6.79207817e-02f,
  -2.24800240e-02f, -4.40208539e-02f, -1.67432800e-01f, 1.16433147e-02f, 6.21580258e-02f, 1.69009343e-01f, -1.15377963e-01f, -2.12950725e-02f, -2.79391482e-02f, -2.53279805e-01f,
  -5.42755350e-02f, -1.21845528e-02f, 8.76031443e-02f, -4.88160774e-02f, 3.82980518e-02f, 4.08382714e-03f, 3.44259366e-02f, 1.69580653e-02f, 2.96692457e-02f, 1.21888043e-02f,
  5.98253421e-02f, -7.91543126e-02f, -1.37172751e-02f, -4.92775552e-02f, 2.82118507e-02f, -4.87982668e-02f, -5.93529898e-04f, -1.86542422e-02f, 7.15201646e-02f, 2.52858154e-03f,
  4.74363901e-02f, 2.88194623e-02f, -4.26031463e-03f, 9.22131911e-03f, 3.22351344e-02f, 4.49560471e-02f, -1.79425422e-02f, 1.56130847e-02f, 7.14062229e-02f, 7.82555118e-02f,
  4.74057719e-02f, 3.46850529e-02f, -8.74182582e-02f, -4.39616255e-02f, 6.67570829e-02f, 5.95561974e-02f, 1.23889688e-02f, -4.44479287e-02f, -4.19270732e-02f, -8.23074207e-02f,
  -2.17196848e-02f, 6.59198090e-02f, -3.43796052e-02f, 2.53710281e-02f, 9.49647874e-02f, 7.62778074e-02f, -3.18918424e-03f, 4.45466414e-02f, 2.26277020e-03f, -7.22487345e-02f,
  -1.66575965e-02f, -6.21985085e-03f, 1.20617941e-01f, 4.15983312e-02f, -9.57332738e-03f, 9.46644843e-02f, -3.84962372e-02f, 4.43471372e-02f, 9.25746337e-02f, -1.02512248e-01f,
  -1.39628649e-01f, -4.62870091e-01f, 4.25123185e-01f, 1.40465260e-01f, 1.86556771e-01f, -2.88716972e-01f, -3.59588534e-01f, -3.24515879e-01f, -6.92289462e-03f, 6.27728999e-02f,
  -6.04072295e-04f, 1.30577400e-01f, 7.83871710e-02f, 6.45794123e-02f, -2.35886812e-01f, -1.32935926e-01f, 8.80460367e-02f, 1.12677924e-01f, -1.12904422e-02f, -1.75234720e-01f,
  -8.80881995e-02f, 9.23805386e-02f, -3.32156084e-02f, -3.14691127e-03f, 1.54292077e-01f, 1.78797185e-01f, 2.22938299e-01f, 4.91277874e-02f, -1.92692384e-01f, 4.56057429e-01f,
  4.63692755e-01f, -4.91200350e-02f, 5.14744557e-02f, -7.75527731e-02f, 4.82911728e-02f, -5.12931123e-02f, 3.82713191e-02f, 1.11277811e-01f, -2.05460880e-02f, 1.37760248e-02f,
  1.31205127e-01f, 2.46691443e-02f, 5.15143983e-02f, 6.11939877e-02f, 2.26887502e-02f, 3.03836297e-02f, -1.28912508e-01f, -3.12731043e-02f, 8.58895481e-02f, -6.10294528e-02f,
  6.39657155e-02f, -3.72167081e-02f, -1.21144250e-01f, -1.28095850e-01f, -6.74291626e-02f, -1.67977158e-02f, -4.94877715e-03f, -4.41893674e-02f, -6.13246635e-02f, 8.22922811e-02f,
  3.64526873e-03f, 7.03716651e-02f, -3.44409235e-02f, -7.04491884e-02f, -5.84463142e-02f, 4.61694114e-02f, -5.47222281e-03f, 1.16046360e-02f, -1.47176499e-03f, 2.66038589e-02f,
  -4.53332700e-02f, 2.30531637e-02f, 2.58358326e-02f, 1.61304772e-02f, 7.83125311e-02f, -5.17658982e-03f, -8.80827196e-03f, 4.60110459e-04f, 9.61813703e-03f, -3.75964306e-03f,
  -4.04335856e-02f, 1.54381022e-02f, 2.27556117e-02f, 2.23939726e-03f, -1.49147483e-02f, 4.33439463e-02f, 2.56870016e-02f, -4.29293327e-02f, 4.44892049e-02f, -1.59059558e-03f,
  5.76685071e-02f, -1.11315744e-02f, 1.73787311e-01f, 1.98914409e-02f, 6.58098534e-02f, -3.77887823e-02f, 7.92593062e-02f, 4.68435790e-03f, 7.14621693e-02f, -2.66512167e-02f,
  -7.62176663e-02f, -9.50484443e-03f, -3.98296379e-02f, 7.05106941e-04f, -9.62128863e-03f, -2.61096247e-02f, -5.01304679e-02f, 6.61108270e-02f, -4.06104438e-02f, -3.79719660e-02f,
  -1.09486952e-01f, -5.76141030e-02f, -5.33132441e-02f, 7.65279494e-03f, -3.93312350e-02f, 1.07284576e-01f, 6.13133758e-02f, 4.28991094e-02f, -3.13612493e-03f, -8.42246115e-02f,
  -1.01175749e+00f, -4.49447215e-01f, -2.04683885e-01f, -1.62863880e-01f, 2.40759835e-01f, 2.07589462e-01f, -1.70411468e-01f, 5.17650098e-02f, 1.11748204e-01f, -7.40130097e-02f,
  4.14465331e-02f, 1.32644728e-01f, -2.11592130e-02f, 9.77623314e-02f, -2.61356533e-01f, -2.64668345e-01f, -3.70297045e-01f, -2.75784343e-01f, 9.75078121e-02f, 1.75484926e-01f,
  2.69171804e-01f, -3.16866748e-02f, -1.06412768e-01f, -1.08451524e-03f, 5.94720617e-02f, 2.08835781e-01f, -7.11925104e-02f, -1.17104255e-01f, -2.17351271e-03f, -1.77362442e-01f,
  -2.72596478e-01f, -3.16347361e-01f, 8.77446756e-02f, 6.77445456e-02f, -3.26500945e-02f, -8.69282708e-02f, 2.05923095e-02f, -7.68727809e-02f, 8.54748562e-02f, 2.51594950e-02f,
  2.97630336e-02f, 6.25726506e-02f, -1.00818790e-01f, 3.98952626e-02f, -6.08416647e-02f, 3.99355441e-02f, -5.79594523e-02f, -1.91404402e-01f, -1.34984329e-01f, 3.92624848e-02f,
  1.61671788e-01f, 1.38071114e-02f, -1.25509501e-01f, 8.09578691e-03f, -8.46493840e-02f, 2.54957732e-02f, -9.02350992e-02f, 9.70881283e-02f, -1.33303152e-02f, -5.88060245e-02f,
  -5.87700866e-02f, -3.25010903e-02f, 1.87763255e-02f, -1.22187901e-02f, 2.83377822e-02f, 6.07402064e-02f, -5.85298017e-02f, 7.00137839e-02f, 8.62299576e-02f, -1.51576297e-02f,
  -2.96988506e-02f, 3.96620072e-02f, 9.64957010e-03f, -1.07297480e-01f, 1.02265157e-01f, 3.19139734e-02f, -5.68787642e-02f, 3.00637055e-02f, 6.76404238e-02f, -4.85598557e-02f,
  3.00425105e-02f, -1.20136403e-02f, 9.94781498e-04f, -2.91751754e-02f, -3.48489732e-02f, -4.30327207e-02f, 3.62995714e-02f, 7.66720027e-02f, 1.05800956e-01f, 5.30047156e-03f,
  -3.26023856e-03f, -1.99209452e-01f, -1.49339110e-01f, 2.47546118e-02f, -7.15347603e-02f, 5.01759239e-02f, -1.25160944e-02f, 1.57910269e-02f, -3.12820971e-02f, -1.79578643e-02f,
  3.50696295e-02f, -8.43826160e-02f, -1.53247282e-01f, 2.37579569e-02f, 2.05957219e-02f, 1.48060158e-01f, -1.59888864e-02f, 8.66532791e-03f, 3.36796567e-02f, 8.07903633e-02f,
  1.91239733e-02f, 1.14732115e-02f, 5.05837239e-02f, 2.30410229e-02f, -1.05611840e-02f, 3.49015705e-02f, 7.27487728e-04f, 5.15697747e-02f, -5.65647632e-02f, 4.65373285e-02f,
  4.94012326e-01f, -5.59785292e-02f, -2.46027797e-01f, 1.14942499e-01f, -8.56453180e-02f, -1.44613743e-01f, -2.04449743e-01f, -1.28147483e-01f, -1.05785169e-01f, -1.24220654e-01f,
  -3.32110971e-02f, 5.18283211e-02f, 3.81716378e-02f, 2.32321788e-02f, 1.18626520e-01f, -5.90516031e-02f, 3.39091360e-03f, 1.12924092e-01f, 2.92902976e-01f, 1.64971948e-01f,
  2.17407048e-01f, 2.07595527e-01f, 2.42306352e-01f, 2.16727614e-01f, 4.77956720e-02f, -3.89977954e-02f, -2.88525522e-01f, 7.60092661e-02f, 8.87770131e-02f, 2.05601126e-01f,
  1.11720255e-02f, -1.55790895e-01f, 4.73658033e-02f, 1.10745251e-01f, -4.34128977e-02f, -3.81120592e-02f, -1.60778277e-02f, -7.19499439e-02f, -3.20688039e-02f, -4.15440053e-02f,
  1.88239403e-02f, 8.45733956e-02f, -5.40473908e-02f, 1.35334609e-02f, 7.37200677e-02f, 2.26609223e-02f, 1.03515396e-02f, 7.29748756e-02f, -2.30584275e-02f, -8.55968371e-02f,
  6.78943694e-02f, 9.09527987e-02f, -7.39271268e-02f, -1.02936536e-01f, -5.17147817e-02f, 7.03870729e-02f, -7.69588500e-02f, -1.79638376e-03f, 6.19970681e-03f, 3.33864763e-02f,
  -3.02029327e-02f, -9.37314630e-02f, -8.69343057e-03f, -7.56407827e-02f, 2.65733190e-02f, -3.23894545e-02f, 2.79950984e-02f, 4.33943979e-02f, 6.08722307e-02f, -9.48773045e-03f,
  4.65273000e-02f, -3.84906381e-02f, 4.58391570e-02f, 2.32358277e-02f, 1.10294791e-02f, -1.23172579e-03f, 6.59254491e-02f, 3.17821652e-02f, 5.46375886e-02f, 1.60249755e-01f,
  1.38096675e-01f, 5.18328398e-02f, 3.77843454e-02f, 1.24920383e-01f, -6.69263629e-03f, 1.61905997e-02f, 5.37372008e-02f, 7.21299350e-02f, -3.75017673e-02f, -1.40507407e-02f,
  -2.10834041e-01f, 7.40440115e-02f, 1.63336340e-02f, 6.35649040e-02f, 4.60588597e-02f, 5.32356724e-02f, 6.58883771e-04f, 9.21679512e-02f, 5.38391359e-02f, 3.24955024e-02f,
  5.02465591e-02f, 9.53686833e-02f, -4.79324274e-02f, 7.02685267e-02f, 5.46302609e-02f, 6.45013452e-02f, 8.32917169e-02f, 7.79667199e-02f, 1.87268592e-02f, 3.81760448e-02f,
  -1.73917804e-02f, 5.44787645e-02f, -2.02931147e-02f, 3.39326747e-02f, 4.04269099e-02f, 6.85710534e-02f, -6.42306432e-02f, -1.54735614e-02f, 3.69769968e-02f, -7.31641203e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.56238902e-01f, -5.45645475e-01f, 2.38390103e-01f, 2.22279251e-01f, -4.23757508e-02f, -1.22394279e-01f, -3.90270442e-01f, -7.82286301e-02f, 2.08673805e-01f, -1.48280129e-01f,
  -1.34139419e-01f, 3.09786767e-01f, 2.89691359e-01f, 9.55682769e-02f, 2.98059642e-01f, 5.59308901e-02f, 2.33202294e-01f, 4.50318754e-01f, 5.44367492e-01f, 8.70422423e-02f,
  -1.88933656e-01f, -8.50233436e-02f, 2.75778830e-01f, 1.17524460e-01f, -3.23750228e-01f, 1.44647732e-01f, -1.55906275e-01f, -1.10199332e-01f, -1.24812186e-01f, -1.56957656e-02f,
  6.34652525e-02f, -2.90313794e-04f, 3.06560218e-01f, 6.36352152e-02f, -1.90023363e-01f, -8.01037438e-03f, 5.93691058e-02f, 3.50606441e-03f, -6.56267954e-03f, -2.14479188e-03f,
  3.58386151e-02f, -7.13036805e-02f, -2.36857310e-02f, -1.72745377e-01f, -7.20764995e-02f, -1.29690230e-01f, -1.57288700e-01f, 7.76806921e-02f, 6.58646598e-02f, -4.87393793e-03f,
  -2.39028677e-01f, -5.41769117e-02f, 1.47550598e-01f, 3.88349243e-03f, 3.64189148e-02f, 1.67346418e-01f, -1.49153844e-01f, -1.06436394e-01f, 8.76438767e-02f, 1.31325759e-02f,
  1.24458767e-01f, 4.00005952e-02f, -6.35731816e-02f, 4.76554222e-02f, -8.25924426e-02f, 1.14122562e-01f, 2.35493183e-01f, -1.65084321e-02f, -2.69847978e-02f, -4.71968092e-02f,
  -5.56058139e-02f, 1.06686875e-01f, -3.29876132e-02f, 7.18080252e-02f, 5.49903661e-02f, -7.77399242e-02f, -1.62811309e-01f, -1.85379088e-02f, -8.34262893e-02f, -1.32042812e-02f,
  -1.43277850e-02f, 5.36549278e-02f, -1.29117758e-03f, -1.52864382e-01f, -4.50685099e-02f, -3.26724686e-02f, -2.77019199e-02f, -1.73641473e-01f, -1.81772619e-01f, -1.98637955e-02f,
  1.68721542e-01f, 4.47804540e-01f, 1.53285310e-01f, 6.47353604e-02f, 1.87770408e-02f, -1.92781076e-01f, -2.28842646e-02f, 8.84776115e-02f, 5.80890290e-03f, -3.28795761e-02f,
  2.20796019e-02f, -5.99112138e-02f, -1.22487791e-01f, -1.06728978e-01f, 1.16101228e-01f, -4.26794402e-03f, -7.23643079e-02f, 1.69951051e-01f, 1.53706953e-01f, -9.85831916e-02f,
  -1.23790614e-01f, 1.08993873e-01f, 2.44529486e-01f, 1.47179484e-01f, 1.64017648e-01f, 3.38798761e-01f, 1.10818092e-02f, 3.99187170e-02f, 1.83866709e-01f, -2.28648353e-02f,
  8.01498771e-01f, -1.66340068e-01f, -1.13874733e+00f, 3.41967732e-01f, -6.56063437e-01f, -4.68407005e-01f, -7.96776593e-01f, 3.51191312e-01f, 6.15348399e-01f, -5.14458299e-01f,
  -1.30145624e-01f, 2.40853146e-01f, 1.75219253e-02f, -1.66928038e-01f, -6.31280839e-02f, -8.37207913e-01f, -6.82716668e-01f, -3.73453021e-01f, -1.19414151e-01f, -9.26714987e-02f,
  -9.54525694e-02f, -7.50689534e-03f, 2.08519801e-01f, 1.11516781e-01f, -1.72262460e-01f, 1.79067835e-01f, -2.64630318e-01f, -1.15088306e-01f, -1.87874749e-01f, -6.38155937e-01f,
  -7.57287621e-01f, 4.80363891e-02f, 4.16762792e-02f, 5.99043854e-02f, -1.07519217e-01f, 1.70224056e-01f, 3.49832326e-02f, 1.09519131e-01f, 1.42777175e-01f, -1.05640907e-02f,
  -3.66845615e-02f, 6.35512499e-03f, 1.79573148e-01f, -4.20069695e-03f, 4.81954329e-02f, -2.50853207e-02f, -6.49034604e-02f, 3.47065702e-02f, -9.49439108e-02f, -1.77348126e-03f,
  -1.36811193e-02f, -1.75264105e-01f, -1.90646186e-01f, 1.34933472e-01f, 1.05076745e-01f, -5.16407117e-02f, 2.84855161e-02f, 1.34410426e-01f, 1.32104591e-01f, 1.04900219e-01f,
  -1.57213565e-02f, -8.02687109e-02f, -1.26298904e-01f, 1.09809294e-01f, 9.44234505e-02f, -1.31194713e-02f, -4.81945612e-02f, -1.62978098e-01f, 1.44485429e-01f, -4.67258282e-02f,
  1.31815830e-02f, 1.40779335e-02f, 7.16294497e-02f, -1.29260831e-02f, -5.78907318e-02f, -1.05575174e-01f, 7.51732208e-04f, -8.27308148e-02f, 5.35506848e-03f, 9.87596810e-02f,
  1.13034584e-01f, 1.74402837e-02f, -4.16321307e-03f, 1.08683437e-01f, -9.95428264e-02f, -1.01251483e-01f, 1.54414773e-02f, 4.66731898e-02f, 7.88169727e-02f, -5.67304380e-02f,
  2.43428230e-01f, 1.14919553e-02f, -8.14190656e-02f, 1.13292247e-01f, -3.43436822e-02f, -1.20702669e-01f, -3.64190005e-02f, 3.97065170e-02f, 3.92211191e-02f, 3.86012308e-02f,
  2.07376331e-02f, -1.98298339e-02f, -1.45735666e-01f, -9.50450525e-02f, 3.43012139e-02f, 6.97839260e-02f, -5.31130005e-03f, -6.51762858e-02f, -3.96067649e-02f, -6.57128543e-02f,
  -6.05059043e-02f, -8.28440338e-02f, 3.51533107e-02f, -3.58424112e-02f, 1.00608505e-01f, 3.30514833e-02f, -2.56979078e-01f, -3.36085185e-02f, -7.60406582e-03f, 1.62039220e-01f,
  5.70154309e-01f, 2.45001361e-01f, 4.95649964e-01f, 7.70521685e-02f, 8.37904029e-03f, 2.38783255e-01f, 4.82748210e-01f, 2.38864645e-01f, 2.64407527e-02f, 3.97143997e-02f,
  -4.00237560e-01f, -6.29425049e-01f, -3.94417226e-01f, -2.32175946e-01f, 1.11140586e-01f, 3.61265898e-01f, 4.34880853e-01f, 4.14889306e-01f, 1.49501994e-01f, 5.07956147e-02f,
  -9.07923505e-02f, 1.52508780e-01f, 1.59942463e-01f, 2.46204302e-01f, 1.43606350e-01f, -2.74257779e-01f, 1.08728409e-01f, 1.81768253e-01f, 9.33947489e-02f, 3.93476784e-01f,
  -9.10777971e-02f, 3.91827196e-01f, -3.02444190e-01f, -3.64268571e-01f, -3.27277370e-02f, 5.99851385e-02f, -6.40655011e-02f, 1.45637333e-01f, -1.01166330e-01f, 5.58343939e-02f,
  -1.44178644e-01f, 6.36659712e-02f, 1.91304490e-01f, -4.55328338e-02f, 1.23513423e-01f, 8.21046010e-02f, 2.22332790e-01f, 1.42721191e-01f, -1.29968986e-01f, -1.79451913e-01f,
  -1.64912522e-01f, 3.06885820e-02f, 1.26436353e-01f, 6.35100603e-02f, 1.98317662e-01f, -3.22792172e-01f, 2.89393626e-02f, 1.13426127e-01f, -3.18614091e-03f, 1.43001392e-01f,
  -1.11061782e-01f, 1.61018163e-01f, 1.94895700e-01f, 6.56192973e-02f, 1.08926438e-01f, 3.45502427e-04f, 1.55322384e-02f, -2.91703828e-03f, 9.75581929e-02f, 3.34941685e-01f,
  -7.37518966e-02f, 7.30351135e-02f, -7.28516728e-02f, 5.88779990e-03f, -2.02044800e-01f, 3.68385352e-02f, -3.11810281e-02f, 1.26491813e-02f, -8.49613547e-02f, -3.32984552e-02f,
  1.31556690e-01f, 1.39855698e-01f, -2.36656647e-02f, 1.97653264e-01f, -3.13134789e-02f, 1.06571056e-02f, 5.92160039e-03f, -4.54584919e-02f, 1.30353393e-02f, 4.68066856e-02f,
  -6.77876174e-01f, -3.07602763e-01f, -9.07715037e-02f, 1.92968950e-01f, 5.13963439e-02f, -4.84214500e-02f, -2.00401947e-01f, -6.67545423e-02f, -2.15241581e-01f, -7.14421198e-02f,
  -2.43816860e-02f, 8.81098807e-02f, -3.63791324e-02f, 1.37531936e-01f, 8.00727159e-02f, -2.40896158e-02f, -9.47429091e-02f, -8.14271867e-02f, -8.04230049e-02f, -1.33948833e-01f,
  3.19550484e-02f, -6.08542711e-02f, -1.62695587e-01f, 4.79959920e-02f, -1.48837522e-01f, -3.51875335e-01f, -1.52892590e-01f, -4.12577391e-02f, -1.71196178e-01f, -9.82371122e-02f,
  -1.32229245e+00f, -6.28099382e-01f, 3.66644591e-01f, -2.51628727e-01f, 1.55034333e-01f, -3.69771919e-03f, -4.38702583e-01f, 2.12233528e-01f, 1.53574020e-01f, -4.65870231e-01f,
  -1.23471409e-01f, -3.09219688e-01f, -1.87816292e-01f, -1.11790590e-01f, -2.42940113e-01f, -2.54706502e-01f, -1.71631038e-01f, -6.12259544e-02f, 3.15844029e-01f, 1.76328212e-01f,
  -3.73866498e-01f, -2.45304644e-01f, -7.10392147e-02f, 2.42605850e-01f, -4.89642948e-01f, -3.14342499e-01f, -6.71046451e-02f, -2.05015168e-01f, -9.31914821e-02f, -8.79568875e-01f,
  -1.35911047e-01f, 2.68700987e-01f, 2.98679560e-01f, -2.78287649e-01f, -5.83187044e-02f, -3.61063033e-02f, 1.82844520e-01f, 2.12124556e-01f, 2.57261693e-02f, 6.03071973e-02f,
  -2.74997950e-02f, 4.67259437e-01f, -7.61576295e-02f, 1.64488822e-01f, 6.47807643e-02f, -1.58248648e-01f, 2.01752802e-04f, 1.69516504e-01f, -1.29496865e-02f, -6.29693791e-02f,
  -3.18125457e-01f, -4.80790734e-01f, -7.10245669e-02f, 1.95874676e-01f, 3.74969602e-01f, 2.29485497e-01f, 1.87562630e-01f, 3.63720837e-03f, 1.80499375e-01f, -8.21636558e-01f,
  8.24801251e-02f, 1.83849875e-02f, 1.02558121e-01f, 1.38581485e-01f, -2.15762526e-01f, -2.14752611e-02f, -7.38566071e-02f, -1.41448647e-01f, 9.61938575e-02f, -2.58603990e-01f,
  1.37816891e-01f, 3.90467644e-02f, 1.43695518e-01f, -1.32597864e-01f, 1.09666601e-01f, -1.38643950e-01f, -2.40980349e-02f, 7.52770081e-02f, -3.77728157e-02f, -1.17620990e-01f,
  -1.83884203e-01f, -1.35309882e-02f, 4.83513577e-03f, 8.68448392e-02f, 4.90782112e-02f, 1.50178477e-01f, -1.05524577e-01f, 1.30155072e-01f, 8.09441209e-02f, 1.16110131e-01f,
  -5.31586647e-01f, 3.72506827e-01f, -2.55940646e-01f, 2.09436238e-01f, 4.36699837e-02f, -7.26657361e-02f, 6.98853061e-02f, 1.69258118e-01f, -1.43323705e-01f, -1.63193345e-01f,
  1.94454983e-01f, -2.04271197e-01f, 5.55030815e-03f, 1.25107512e-01f, -2.31376871e-01f, 3.57333873e-03f, -1.73248395e-01f, -1.96982518e-01f, -3.08230463e-02f, -1.92031428e-01f,
  -2.05557663e-02f, -4.64428872e-01f, -6.56680167e-01f, -3.22320431e-01f, -3.17836493e-01f, -3.80846441e-01f, -1.22729376e-01f, -6.63347170e-02f, -3.82270843e-01f, -8.99387777e-01f,
  4.70467627e-01f, -5.58872640e-01f, 3.95612806e-01f, 5.42071640e-01f, 7.12585986e-01f, 5.66625297e-01f, 2.48519316e-01f, 5.92474453e-02f, 2.53330678e-01f, 6.36686683e-02f,
  -2.23638546e-02f, -3.05891782e-02f, -2.18503699e-01f, -1.61789566e-01f, -2.99451768e-01f, 1.08535066e-01f, 1.72099054e-01f, 4.90880795e-02f, 3.11329246e-01f, 4.11157161e-01f,
  2.34748989e-01f, 3.24136972e-01f, 9.07671526e-02f, 3.98972444e-02f, 5.96352853e-02f, 2.06462786e-01f, 9.70413312e-02f, 1.32988200e-01f, -1.98061690e-02f, 1.94791958e-01f,
  4.47908603e-02f, 7.29893148e-02f, 7.15755224e-02f, -1.78580716e-01f, -8.88181925e-02f, -2.18448356e-01f, -5.14873415e-02f, -1.79702818e-01f, -1.96476266e-01f, -7.66165033e-02f,
  -3.59821357e-02f, -5.94176613e-02f, 2.51106564e-02f, -4.86844741e-02f, 8.23198631e-02f, 1.11221364e-02f, -1.43509984e-01f, -1.77060440e-01f, 3.70977744e-02f, -1.92641914e-01f,
  -5.25030605e-02f, 1.97768003e-01f, 2.04200357e-01f, -3.96263860e-02f, 1.20557845e-02f, 1.10216521e-01f, -8.41939822e-02f, -4.90325727e-02f, 4.74859402e-02f, -6.65283650e-02f,
  1.73576415e-01f, 1.85913190e-01f, 1.50266871e-01f, 1.99369173e-02f, 1.64412379e-01f, -5.62238805e-02f, 1.20391332e-01f, 6.03844263e-02f, 2.49159247e-01f, 1.38258278e-01f,
  4.22829464e-02f, 1.27693012e-01f, 6.22566752e-02f, 7.09621757e-02f, 4.68269922e-02f, -1.13711124e-02f, 5.18769398e-02f, -1.06081642e-01f, -3.09857782e-02f, -5.65394200e-02f,
  4.99017909e-02f, -5.12064509e-02f, -8.30506384e-02f, -1.63962111e-01f, -1.35844618e-01f, -5.76359257e-02f, 8.64066556e-02f, -3.03240009e-02f, 4.40988038e-03f, 3.73164122e-03f,
  -6.85469806e-02f, -1.30066708e-01f, 9.54051018e-02f, -1.62264362e-01f, 1.49350822e-01f, -1.05032004e-01f, 1.62428916e-01f, -1.35860503e-01f, -1.50809959e-01f, -1.28073841e-01f,
  1.01343598e-02f, -1.15225092e-01f, -2.65734084e-02f, -5.71892131e-03f, 2.48445198e-01f, 1.79537773e-01f, -3.61214466e-02f, 8.77593458e-02f, -9.41275880e-02f, -2.46105641e-02f,
  -1.42685100e-01f, 1.86763853e-01f, 1.75139561e-01f, 9.26197171e-02f, 1.10786498e-01f, 1.69892997e-01f, 1.97875760e-02f, -6.43619383e-03f, 4.76753861e-02f, 1.80308986e-02f,
  -7.97792152e-02f, 2.32235149e-01f, 1.19522978e-04f, 6.19237274e-02f, 4.49506789e-01f, 5.99712610e-01f, 7.63355076e-01f, 2.42287084e-01f, 1.11477040e-02f, 3.05955589e-01f,
  3.40278059e-01f, 2.34401062e-01f, 1.97892532e-01f, 1.94404066e-01f, 2.19702736e-01f, 9.23341587e-02f, 8.71175528e-02f, -1.67457819e-01f, -3.42807360e-02f, 1.69777930e-01f,
  1.24445327e-01f, -2.09689960e-01f, -3.23245972e-01f, -1.15346126e-01f, -1.30022019e-01f, -9.46409181e-02f, 3.36445693e-04f, -8.90801176e-02f, 2.05505401e-01f, -4.66714889e-01f,
  -1.84780285e-01f, 2.64224410e-02f, 9.23411623e-02f, -3.90405506e-02f, 5.46810217e-02f, -1.71335936e-01f, -6.44586980e-02f, -2.72102922e-01f, 6.61286190e-02f, -8.53600129e-02f,
  -4.67099696e-02f, -1.11816846e-01f, 7.98872337e-02f, 3.44763771e-02f, -1.43361703e-01f, -8.58684815e-03f, -9.17169526e-02f, 1.11921303e-01f, 1.54992908e-01f, 1.04724236e-01f,
  1.92176163e-01f, -1.34750651e-02f, -1.09197609e-01f, 2.49037698e-01f, 2.28810623e-01f, 3.49757671e-02f, -1.99263566e-03f, 9.74465385e-02f, 1.47355139e-01f, -1.00001790e-01f,
  1.79288089e-01f, 3.58604230e-02f, 9.95067731e-02f, -1.40384827e-02f, -8.00341889e-02f, 4.04283544e-03f, -6.24412224e-02f, -8.48100632e-02f, 7.83831403e-02f, -1.59883678e-01f,
  -2.86185853e-02f, 2.40632594e-02f, 9.42124650e-02f, 9.16914046e-02f, 5.50407916e-02f, 5.23609780e-02f, -4.62232810e-03f, -5.84405661e-02f, -2.01934613e-02f, -7.68026942e-03f,
  3.04848179e-02f, -5.19597940e-02f, -7.50177493e-03f, -7.89138675e-02f, 6.18576780e-02f, 8.06166679e-02f, -1.19007640e-01f, 8.12402889e-02f, -1.91061925e-02f, 1.01772517e-01f,
  -1.43065825e-01f, 5.17748475e-01f, 1.16253095e-02f, -3.15663107e-02f, -1.37821585e-01f, -1.48540527e-01f, 9.59186181e-02f, -8.60497430e-02f, -1.36107460e-01f, -8.02414492e-02f,
  -8.50905403e-02f, -4.74488102e-02f, 1.92129947e-02f, -3.75616737e-02f, -2.41595656e-01f, -5.16651198e-02f, -2.88891252e-02f, 1.01448866e-02f, 9.36587304e-02f, -9.37551707e-02f,
  7.71878809e-02f, -1.25847861e-01f, -3.60156685e-01f, 3.15015800e-02f, -3.46549638e-02f, -1.34363145e-01f, -1.62507385e-01f, -8.90998319e-02f, -2.04152204e-02f, -2.29370207e-01f,
  -8.93302619e-01f, -2.32356250e-01f, -9.41656977e-02f, 3.18663120e-01f, 3.20938468e-01f, -3.07402045e-01f, -6.62123322e-01f, -2.38133788e-01f, 3.24665904e-01f, -1.91611573e-01f,
  -2.66618550e-01f, 2.99317002e-01f, 2.91476965e-01f, 7.23851845e-02f, -2.25683793e-01f, -6.71201870e-02f, 6.08644605e-01f, 1.75062954e-01f, -1.71288893e-01f, -2.41645470e-01f,
  2.38879219e-01f, 1.11841988e-02f, -1.22111328e-01f, -1.99963734e-03f, 3.00930202e-01f, 2.81489015e-01f, 2.03676984e-01f, 1.28874168e-01f, -1.94699049e-01f, 6.46462202e-01f,
  -5.95290363e-01f, -3.90076488e-01f, 6.49595484e-02f, -2.23161727e-02f, 1.29159763e-01f, -2.47558549e-01f, -2.49445572e-01f, 8.80574211e-02f, 2.06250548e-01f, -5.20794764e-02f,
  1.67809382e-01f, -6.17342591e-02f, 3.47169548e-01f, 1.11919992e-01f, -4.87170108e-02f, -9.97640938e-02f, 6.96982145e-02f, -1.09192744e-01f, 3.18717994e-02f, -3.90138775e-01f,
  4.12268430e-01f, 5.23669235e-02f, -1.65682048e-01f, -1.10345492e-02f, -5.28698042e-02f, 3.94248605e-01f, -1.78832814e-01f, -8.90972652e-03f, -3.68514568e-01f, -2.62270391e-01f,
  -2.72284448e-02f, -6.15042076e-03f, -1.87872514e-01f, -3.62469628e-03f, 6.72301501e-02f, 3.20492648e-02f, 1.16699830e-01f, 1.14628943e-02f, 8.18346217e-02f, -2.27204058e-02f,
  2.48001590e-01f, -7.52019435e-02f, 1.26601681e-01f, -1.38194710e-01f, 5.73779941e-02f, -2.02860422e-02f, -8.11897069e-02f, 2.62653809e-02f, 9.81372148e-02f, -1.49666116e-01f,
  1.63896501e-01f, -6.21769167e-02f, 6.81422353e-02f, 2.03171596e-01f, -3.62503662e-04f, 5.12352102e-02f, 6.29877150e-02f, -2.62229815e-02f, -6.52218610e-02f, -2.21754745e-01f,
  3.67499292e-02f, 4.15595770e-01f, -3.00646544e-01f, -1.02947421e-01f, -8.86340886e-02f, 2.08000556e-01f, 5.36617078e-02f, -6.93608001e-02f, -8.97832797e-04f, -1.73354205e-02f,
  -5.23176417e-02f, -2.57717699e-01f, 2.75591016e-02f, 1.64953154e-02f, -5.11035025e-02f, -3.66365649e-02f, -4.28307615e-02f, -2.49409839e-03f, 3.30933221e-02f, 9.84487161e-02f,
  2.23681144e-02f, -2.54422516e-01f, -2.91506261e-01f, -1.87758178e-01f, -1.25779063e-01f, -1.19433925e-01f, -1.25260532e-01f, -2.90471971e-01f, -4.56114501e-01f, -5.22675633e-01f,
  1.25560194e-01f, 2.42076442e-01f, 1.32391244e-01f, 2.01550096e-01f, -4.59206812e-02f, -4.89247173e-01f, -6.03915930e-01f, -3.52659076e-01f, -1.83203649e-02f, 6.76530078e-02f,
  2.22323295e-02f, 2.35799536e-01f, 1.76751852e-01f, 2.14016780e-01f, -1.61207497e-01f, 1.57422140e-01f, 2.95901775e-01f, 1.30126536e-01f, -2.32913829e-02f, 7.06808269e-02f,
  3.12638789e-01f, 2.23845556e-01f, 1.42828777e-01f, -1.09634651e-02f, 4.29984778e-01f, 3.24912667e-01f, 1.42544806e-01f, 1.52705058e-01f, 1.17058963e-01f, 8.27668428e-01f,
  -1.13813534e-01f, -1.73528969e-01f, 1.44305393e-01f, 2.58056939e-01f, 1.53643921e-01f, -1.57513469e-02f, 3.48337591e-02f, 2.57355161e-02f, -2.16248501e-02f, -1.05437115e-01f,
  1.24250323e-01f, -6.90617636e-02f, 1.01293370e-01f, 6.98111802e-02f, -1.00231908e-01f, -1.71692476e-01f, -3.37190926e-02f, 2.11328529e-02f, -5.74226417e-02f, -1.15649141e-01f,
  1.93191290e-01f, -1.51926689e-02f, -2.84336984e-01f, -2.47132391e-01f, -1.79308057e-01f, 1.54643655e-01f, -1.52211234e-01f, 3.81138735e-03f, -1.83098361e-01f, 9.98493866e-04f,
  1.25368804e-01f, 2.17838705e-01f, 8.43687877e-02f, -3.33888344e-02f, 6.32477552e-02f, -7.43441805e-02f, -1.96929991e-01f, -2.75891349e-02f, 3.87579799e-02f, -7.34052109e-03f,
  -6.76173270e-02f, -6.58349767e-02f, -7.73815811e-02f, -2.62923270e-01f, -7.78079033e-02f, 4.24329601e-02f, 2.48746872e-02f, -5.64310467e-03f, -1.73600212e-01f, 8.49384591e-02f,
  -1.08665926e-02f, -4.64608707e-02f, -6.25185966e-02f, -1.37328738e-02f, 7.30176568e-02f, 7.30725601e-02f, 1.86208896e-02f, 2.80527994e-02f, 7.69398361e-02f, 1.36598989e-01f,
  -2.80622333e-01f, -1.68188393e-01f, 2.40108207e-01f, 1.43623069e-01f, 1.18394256e-01f, 2.21898973e-01f, 2.46131346e-01f, 6.07163422e-02f, 6.12719059e-02f, -1.01658916e-02f,
  3.71016338e-02f, 3.32853757e-02f, 9.90196094e-02f, -2.43727807e-02f, -1.08726680e-01f, -2.46573123e-03f, 1.35056213e-01f, 3.68673056e-02f, -1.15789808e-02f, -6.08841851e-02f,
  2.67974343e-02f, -2.60507911e-01f, -2.45296642e-01f, -1.60474896e-01f, 3.44122685e-02f, -1.44312784e-01f, -2.42397115e-01f, -6.83092326e-02f, -3.17748845e-01f, -3.16896528e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  3.51833284e-01f, 2.34627590e-01f, 6.85228527e-01f, 1.13617890e-01f, 5.23131967e-01f, 7.26201534e-01f, 5.50581872e-01f, 6.19949400e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  3.52993637e-01f, -6.40001655e-01f, -1.17995143e-01f, 7.17616156e-02f, -1.25609428e-01f, 1.57087013e-01f, -4.42221723e-02f, -1.66454520e-02f, 4.42747846e-02f, -1.27255648e-01f,
  -1.29407421e-01f, 1.11069925e-01f, 2.44503422e-03f, 2.19874382e-02f, 1.33954197e-01f, 4.10011038e-02f, -1.09962985e-01f, -1.55053481e-01f, 1.44467726e-01f, -1.52146831e-01f,
  6.28911033e-02f, -4.73370105e-01f, -9.12090912e-02f, 5.08298695e-01f, 7.56017938e-02f, 1.34743437e-01f, -3.69900584e-01f, 4.66736127e-03f, -2.07137726e-02f, 2.83928663e-01f,
  1.87608764e-01f, 3.37767899e-01f, 1.65554602e-02f, 1.97950512e-01f, 2.00943366e-01f, -6.24270886e-02f, -1.38313347e-03f, -9.77432132e-02f, 1.23972915e-01f, -2.38693450e-02f,
  4.93039578e-01f, 1.09699443e-01f, 1.76113397e-01f, 2.20843971e-01f, -3.63171697e-01f, -5.28061569e-01f, -8.39828923e-02f, 1.71316843e-02f, 5.94558381e-02f, 1.05262406e-01f,
  -1.70246586e-01f, -1.69942588e-01f, -3.60331267e-01f, 1.47801429e-01f, 1.53043374e-01f, -9.21920612e-02f, -4.69481312e-02f, -2.96020895e-01f, 2.46921420e-01f, 2.09131420e-01f,
  -1.60699397e-01f, -3.48704278e-01f, 3.30421984e-01f, 8.91361013e-02f, 7.12080300e-02f, 7.72491843e-02f, -3.39301348e-01f, 5.04542254e-02f, 8.24308246e-02f, -1.02827653e-01f,
  -5.24280481e-02f, 2.16884747e-01f, 2.40918204e-01f, -4.11548764e-02f, 3.16563427e-01f, 7.36619160e-02f, 2.52657175e-01f, 2.77288824e-01f, -8.54999572e-02f, -4.91557755e-02f,
  -6.39109462e-02f, -9.69002023e-02f, -3.66430193e-01f, -9.24278200e-02f, -2.28624254e-01f, -1.53511301e-01f, 1.27287805e-02f, -6.52231425e-02f, -3.75938535e-01f, -1.15394428e-01f,
  9.87508297e-02f, -4.00208384e-01f, 2.71007959e-02f, 7.59668127e-02f, 1.60699844e-01f, 2.35351875e-01f, 6.88101500e-02f, 1.84350356e-01f, 1.09338388e-01f, -2.85832975e-02f,
  1.36823254e-02f, -5.78458384e-02f, 2.02445202e-02f, 3.48518975e-02f, -3.26824486e-02f, -6.30218387e-02f, 1.06361084e-01f, -7.62499273e-02f, 4.28224683e-01f, 3.63614917e-01f,
  -1.51489049e-01f, 2.30358839e-01f, -2.27117643e-01f, 1.37747720e-01f, -1.97707042e-02f, -8.31501335e-02f, 2.26347938e-01f, 1.87067360e-01f, -2.64319986e-01f, 1.80728495e-01f,
  1.77805021e-01f, 5.01883984e-01f, -9.88734663e-02f, -1.69291884e-01f, -1.99318096e-01f, -1.03277173e-02f, 4.92712200e-01f, 1.74734652e-01f, -1.50227733e-03f, 2.37795085e-01f,
  7.23248124e-02f, -9.49593261e-03f, 3.28965455e-01f, -2.65162230e-01f, 3.31766009e-01f, 8.52164254e-02f, 5.01771748e-01f, -1.67422295e-02f, 3.23859036e-01f, 1.07497707e-01f,
  3.28560024e-01f, 2.04619229e-01f, 4.66197610e-01f, 9.41832364e-02f, -1.35892451e-01f, -1.94996417e-01f, -4.04819012e-01f, 1.38738036e-01f, 1.27112821e-01f, -1.74560741e-01f,
  2.35417202e-01f, -2.41625145e-01f, -2.41470754e-01f, -9.14638937e-02f, -4.57683921e-01f, 3.69185984e-01f, 1.49485677e-01f, 2.91901052e-01f, 2.19416350e-01f, 6.55311719e-02f,
  -5.73340058e-02f, -1.55565411e-01f, -9.47579183e-03f, 1.33920699e-01f, 7.67536908e-02f, 2.56524086e-02f, -1.41395507e-02f, -2.43949331e-02f, -5.35218790e-02f, -3.97290699e-02f,
  1.17173634e-01f, 1.46646738e-01f, 9.23428610e-02f, 3.30134369e-02f, 7.42387474e-02f, 6.08040318e-02f, 9.96522531e-02f, -4.81637120e-02f, -4.76823114e-02f, -1.38779366e-02f,
  1.49898510e-02f, -6.13977425e-02f, 9.64702070e-02f, -6.69325665e-02f, -1.15700699e-01f, 5.07838011e-01f, -9.31960251e-03f, -1.87485535e-02f, -2.36879647e-01f, -1.77333221e-01f,
  -1.62967667e-01f, -1.19229712e-01f, 1.50006354e-01f, 5.82726579e-03f, -1.34942904e-01f, 1.57440919e-02f, -6.89158738e-02f, 2.10206315e-01f, 1.15919553e-01f, 3.64222974e-02f,
  -2.11206779e-01f, 2.09357932e-01f, -1.39096215e-01f, 2.87209988e-01f, 2.82365009e-02f, 5.18702030e-01f, -2.14004725e-01f, -1.48960039e-01f, 6.88378960e-02f, -1.72556937e-01f,
  1.82037830e-01f, -4.74188663e-02f, 2.35646889e-01f, -1.24788992e-01f, -6.59724832e-01f, 3.65403265e-01f, -9.07548796e-03f, 2.34327182e-01f, 5.07130861e-01f, -7.63612762e-02f,
  -6.13100715e-02f, 1.68843381e-03f, -2.18156010e-01f, -9.73390117e-02f, 4.43019643e-02f, -2.09446564e-01f, 1.27319638e-02f, 5.16423397e-02f, 4.17124443e-02f, 1.05452441e-01f,
  -1.41390711e-01f, -5.22146001e-02f, -2.61045426e-01f, -9.75760594e-02f, -2.21251309e-01f, 1.34496778e-01f, 5.63914776e-02f, 2.22340357e-02f, -3.46134640e-02f, -8.41096565e-02f,
  -3.00717354e-01f, -1.93076506e-01f, 3.77340555e-01f, 2.99752086e-01f, 1.84957683e-01f, -1.35993376e-01f, -1.47192687e-01f, 5.59339672e-02f, -2.35426039e-01f, 3.53406072e-01f,
  4.35252599e-02f, 2.03399286e-01f, -1.74560770e-02f, 4.21670973e-01f, -2.34491259e-01f, -3.41264457e-01f, -2.40888953e-01f, 1.52209094e-02f, 1.13240838e-01f, -4.65073213e-02f,
  1.44895911e-01f, -1.31635830e-01f, -2.20446642e-02f, 2.23664120e-01f, 1.58034146e-01f, -1.60552308e-01f, 5.58642089e-01f, -8.85364339e-02f, 3.99676375e-02f, 1.09527178e-01f,
  -4.18614835e-01f, 5.64486831e-02f, 1.27473220e-01f, 1.99479476e-01f, -2.32539520e-01f, -3.59883010e-02f, -1.01362988e-01f, 2.45947450e-01f, -6.24784678e-02f, -3.86277810e-02f,
  -1.93551630e-01f, -2.64981478e-01f, -9.60005298e-02f, -1.19496033e-01f, 2.63899386e-01f, -1.19824439e-01f, 2.73928821e-01f, 3.45606148e-01f, -1.79914564e-01f, 1.85694948e-01f,
  6.18097261e-02f, 4.51187082e-02f, -6.26480859e-03f, -1.52141482e-01f, 3.53010558e-02f, -9.07752141e-02f, 2.79546261e-01f, -2.58058846e-01f, 1.27485991e-01f, -2.48664916e-01f,
  2.68656969e-01f, -4.27494615e-01f, 1.27170319e-02f, 1.86475534e-02f, -1.91799790e-01f, 8.71230140e-02f, -2.55275518e-01f, 3.12654227e-02f, -4.50000793e-01f, 1.73443317e-01f,
  2.91442513e-01f, -2.39843354e-01f, -2.22791612e-01f, -1.04401693e-01f, -1.40361950e-01f, -3.34125832e-02f, -1.57089278e-01f, -1.03872925e-01f, 2.52773106e-01f, 2.23639578e-01f,
  4.60923463e-02f, -8.24526101e-02f, 2.85003185e-01f, -2.10143223e-01f, -1.20272018e-01f, -3.15703116e-02f, 1.95183650e-01f, 1.74020380e-01f, 4.66610074e-01f, 3.08849186e-01f,
  1.88259915e-01f, 1.69414543e-02f, -5.05473256e-01f, -9.54591110e-02f, -7.33237118e-02f, -2.71835853e-03f, 3.20323199e-01f, 2.46170670e-01f, -2.91005611e-01f, -2.66996324e-01f,
  -6.90143406e-02f, 1.76130212e-03f, 3.19168083e-02f, 5.43324910e-02f, 1.16121642e-01f, -1.85162127e-01f, 3.30127001e-01f, -1.92600146e-01f, 2.25190399e-03f, -3.41898113e-01f,
  4.35540289e-01f, 1.76637471e-01f, -2.02812552e-02f, 7.54407942e-02f, 2.69221626e-02f, 4.86622304e-02f, -2.03953266e-01f, -7.89199993e-02f, -1.46883130e-01f, -1.30995944e-01f,
  2.57400423e-02f, -4.94750887e-02f, -2.73895383e-01f, -4.22700383e-02f, -3.00743375e-02f, -3.69486183e-01f, -1.66122481e-01f, -9.53616500e-02f, 7.80585557e-02f, 1.13504991e-01f,
  3.85150053e-02f, -2.53502458e-01f, -2.33782724e-01f, -1.29221138e-02f, -1.12734646e-01f, 1.56852952e-03f, -3.67984354e-01f, 1.28532648e-01f, 2.01935694e-01f, 2.13719964e-01f,
  3.94638963e-02f, -5.68541065e-02f, 5.10190368e-01f, 1.15599729e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.26379743e-01f, 1.47608757e-01f, 1.77859232e-01f, -4.82190430e-01f, 4.35967952e-01f, 1.03045382e-01f, 2.48055592e-01f, 4.52292264e-01f, 8.67244720e-01f, 3.76010120e-01f,
  6.64905250e-01f, 4.83290017e-01f, -4.43046749e-01f, 2.85559297e-01f, 4.97236460e-01f, 8.11053440e-02f, 5.69202185e-01f, -5.76453984e-01f, -5.56655943e-01f, 9.20827612e-02f,
  1.15652926e-01f, 5.08805178e-02f, 4.75664437e-01f, -6.76788330e-01f, -2.24037960e-01f, 2.80892700e-01f, 6.00247979e-01f, -2.33775880e-02f, 3.45002860e-01f, 3.12188357e-01f,
  -9.47953224e-01f, -4.21052396e-01f, 6.34675741e-01f, 2.92229831e-01f, 6.17836893e-01f, -3.47752213e-01f, 7.19393373e-01f, 1.55222312e-01f, 2.30466902e-01f, 5.85490018e-02f,
  1.11989945e-01f, 3.91500175e-01f, 2.74078935e-01f, 4.16177273e-01f, -4.43431228e-01f, 6.12665005e-02f, 6.63852155e-01f, 6.25134468e-01f, -1.93184495e-01f, 3.47760171e-02f,
  5.15831769e-01f, 5.38972974e-01f, 4.82020199e-01f, 6.32012963e-01f, 4.43723619e-01f, -2.08861545e-01f, -5.45052774e-02f, 5.41743457e-01f, -3.14959973e-01f, 8.34477305e-01f,
  -5.01236856e-01f, -9.44267735e-02f, 4.94038492e-01f, 2.32988782e-02f, -3.55032653e-01f, -3.36657882e-01f, -5.72319143e-02f, 1.39844760e-01f, 1.16992377e-01f, -1.33325189e-01f,
  9.52867121e-02f, 3.19822222e-01f, 8.10367316e-02f, -1.98826164e-01f, 3.19325894e-01f, -1.25704572e-01f, 5.44781983e-01f, -9.75692645e-02f, -2.22194120e-01f, -1.25622571e-01f,
  -6.28174424e-01f, -4.69743498e-02f, -3.39364201e-01f, 3.33110750e-01f, -3.42492878e-01f, 2.58901846e-02f, 1.69567242e-01f, 2.79276758e-01f, -1.51384041e-01f, 4.56654251e-01f,
  1.57970972e-02f, -7.14069605e-01f, 4.13518071e-01f, 6.64312184e-01f, 7.03592956e-01f, 6.70324266e-01f, 4.42886412e-01f, -7.16072679e-01f, 4.33664113e-01f, -1.38159096e-01f,
  3.79817456e-01f, 3.75556797e-01f, 2.47422438e-02f, 2.50536531e-01f, 2.48643205e-01f, 5.01150727e-01f, 4.53644851e-03f, 5.74463606e-01f, -4.87562686e-01f, -1.48448265e+00f,
  1.90625176e-01f, 1.09027952e-01f, 7.19127730e-02f, 3.54160219e-01f, 3.62982154e-01f, -4.56756689e-02f, -5.23793638e-01f, -9.52386141e-01f, 2.23773882e-01f, -2.00066715e-01f,
  -9.44383621e-01f, -5.82100868e-01f, 3.72805625e-01f, 7.63814986e-01f, -1.92255259e-01f, 4.40604419e-01f, 7.15144575e-01f, -1.90315142e-01f, 7.69924894e-02f, -9.00316164e-02f,
  3.96411240e-01f, -1.72789153e-02f, 1.82836339e-01f, -1.69648658e-02f, 2.69501042e-02f, 2.01698139e-01f, 8.87833312e-02f, 1.88071951e-01f, 6.82750881e-01f, 4.31307375e-01f,
  -6.22092664e-01f, 7.83428073e-01f, -2.58718759e-01f, 7.19335973e-02f, 5.06753325e-01f, -1.37476565e-03f, -1.22832119e-01f, 1.88038871e-02f, 6.60270393e-01f, -9.81392246e-03f,
  -1.88102767e-01f, 4.86538827e-01f, 2.55184680e-01f, 9.52496886e-01f, 1.27558544e-01f, 8.44707042e-02f, 5.82012177e-01f, 1.80210635e-01f, 1.25829184e+00f, -2.81097405e-02f,
  2.00546458e-02f, 9.74259198e-01f, 4.40446511e-02f, 2.71435589e-01f, 6.56163216e-01f, -1.45974353e-01f, 6.91957712e-01f, 6.23909831e-01f, 1.05182612e+00f, 7.32532656e-03f,
  1.11596382e+00f, 2.27047071e-01f, 7.26208329e-01f, 5.70193708e-01f, -9.83727127e-02f, -1.68881826e-02f, -4.67382073e-01f, 1.17504887e-01f, -1.09943187e+00f, -1.96876630e-01f,
  -1.59390718e-01f, 4.85945255e-01f, 1.38574138e-01f, -3.31842273e-01f, -3.41338754e-01f, 9.98829827e-02f, 5.26232012e-02f, -2.58271154e-02f, 3.67422134e-01f, -8.19918036e-01f,
  2.79859453e-01f, 2.76905656e-01f, -1.60023436e-01f, 2.68174142e-01f, 1.92938805e-01f, -1.14901640e-01f, -3.78120720e-01f, 7.02488348e-02f, 2.25449085e-01f, -6.41798794e-01f,
  1.02117732e-01f, 1.50652686e-02f, -1.44282007e+00f, 1.31861344e-01f, 8.44696343e-01f, -6.09114528e-01f, -1.96562290e-01f, -1.14868313e-01f, 3.08856368e-01f, 3.82751197e-01f,
  1.84102297e-01f, 1.02531821e-01f, -3.60559165e-01f, -1.89931273e-01f, 4.89984006e-02f, -3.53370279e-01f, -8.93466592e-01f, 5.89173198e-01f, 5.81062555e-01f, 7.38048434e-01f,
  -2.68846937e-02f, 9.13312584e-02f, 2.15643287e-01f, -2.61589676e-01f, 1.87717855e-01f, 4.22535866e-01f, 9.30350572e-02f, 2.14758709e-01f, 7.29093701e-02f, 1.63647741e-01f,
  4.01273400e-01f, -4.92438972e-01f, 1.28916949e-01f, 4.40100998e-01f, -6.62364304e-01f, 3.19579661e-01f, 3.99925798e-01f, 2.26935279e-02f, -4.88044143e-01f, -6.31832957e-01f,
  -3.15259010e-01f, 1.14059791e-01f, 3.49837448e-03f, -2.20560536e-01f, -4.28298593e-01f, 9.34705287e-02f, -5.10861814e-01f, 3.58349055e-01f, 3.61836404e-02f, -6.11948609e-01f,
  1.03925681e+00f, -5.05099893e-01f, -1.17868595e-01f, -2.18374863e-01f, -5.31661451e-01f, 8.96174252e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  4.88402843e-01f, 3.36853147e-01f, 3.29260789e-02f, 4.52536613e-01f, 7.39953667e-02f, 4.64196384e-01f, 5.56247592e-01f, 3.39025646e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -2.04251446e-02f, 2.75385112e-01f, -1.00361228e-01f, -4.36557651e-01f, -3.32588881e-01f, -3.61672163e-01f, 2.45036259e-01f, -4.35742468e-01f, -4.69543666e-01f, -1.55556843e-01f,
  -4.20307428e-01f, 6.79787248e-02f, 4.89112705e-01f, -8.54065716e-01f, -1.27605975e-01f, 1.49130244e-02f, 5.63149929e-01f, -2.70972371e-01f, 5.33354342e-01f, -1.94600880e-01f,
  1.98400076e-02f, -6.27510905e-01f, -1.76576003e-01f, 5.45131147e-01f, -6.55713141e-01f, 3.02646220e-01f, -7.12517083e-01f, -5.24188995e-01f, 3.04240752e-02f, -8.14173162e-01f,
  6.64628625e-01f, -2.76804030e-01f, -6.39218166e-02f, -3.78370881e-01f, 2.64474005e-01f, 2.76022404e-01f, 4.20212328e-01f, -5.62280595e-01f, -2.30324715e-01f, -8.04106370e-02f,
  -2.30284587e-01f, -8.12365770e-01f, 3.78380567e-01f, -8.78005803e-01f, 3.28939199e-01f, -6.37053728e-01f, -1.12364018e+00f, -3.92147154e-02f, 2.32275695e-01f, 8.48296106e-01f,
  3.01665246e-01f, 7.47128010e-01f, -3.67565081e-02f, -1.03808239e-01f, -1.16168022e-01f, -9.15150285e-01f, 1.00702018e-01f, 5.58143139e-01f, 1.25241190e-01f, -9.88629103e-01f,
  2.39638850e-01f, -9.62730825e-01f, -9.22661245e-01f, 1.76948637e-01f, 3.88839729e-02f, -4.75973904e-01f, 1.03866376e-01f, -1.15866072e-01f, 1.26771048e-01f, 3.73870730e-01f,
  5.25781155e-01f, -1.88807279e-01f, 2.36887425e-01f, 9.24090594e-02f, -5.64422607e-01f, -2.12211221e-01f, 6.87360764e-01f, 5.67616522e-02f, -4.14678037e-01f, 4.89685595e-01f,
  2.36264959e-01f, -8.23500395e-01f, 4.33152691e-02f, -6.36735857e-01f, 3.17918032e-01f, -6.08694591e-02f, 8.33578408e-02f, 4.99184817e-01f, -1.18931448e+00f, 5.63360035e-01f,
  -7.14366674e-01f, 3.96499425e-01f, 1.48563683e-01f, 1.31102502e-01f, -1.15873301e+00f, -1.96696386e-01f, 1.23811848e-01f, -2.12493852e-01f, -1.39814734e-01f, 1.15676858e-01f,
  -7.15018585e-02f, 9.04909551e-01f, -1.80887371e-01f, 6.14775009e-02f, -3.06362361e-01f, 2.61411220e-01f, -9.87626961e-04f, 2.51514852e-01f, 5.65231979e-01f, 3.48643124e-01f,
  -3.25236350e-01f, -1.37224138e+00f, 3.85671586e-01f, 4.74589258e-01f, -6.30048275e-01f, 2.96521515e-01f, -6.40851438e-01f, 3.17900479e-01f, 1.83270231e-01f, 4.09636408e-01f,
  1.70459405e-01f, 1.24717541e-01f, -7.32707739e-01f, 8.42187941e-01f, -1.20645559e+00f, -1.35442328e+00f, 3.90341669e-01f, -9.28203940e-01f, 7.90010989e-02f, -2.97016036e-02f,
  1.36987055e-02f, 1.91807330e-01f, 2.67021537e-01f, 2.23131731e-01f, 4.03021425e-01f, 4.60399061e-01f, 5.18519461e-01f, 5.77472076e-02f, 4.15077984e-01f, 2.81861156e-01f,
  -7.48868823e-01f, 5.04235208e-01f, -2.98038989e-01f, 1.07123458e+00f, -9.85161960e-01f, 1.07925570e+00f, -4.87155110e-01f, 5.37907064e-01f, -7.81207830e-02f, 1.24167323e+00f,
  -2.65712231e-01f, 7.01692522e-01f, -1.05015583e-01f, 1.59556895e-01f, 1.18850291e-01f, -2.86957979e-01f, -7.26468042e-02f, 3.92636023e-02f, 2.77924746e-01f, -2.37355411e-01f,
  9.37559381e-02f, 2.45277524e-01f, 3.27081829e-01f, -5.04099667e-01f, -9.27382886e-01f, -6.40913188e-01f, 8.96665081e-02f, 1.89988732e-01f, 4.24667150e-01f, 7.02625096e-01f,
  1.83573127e-01f, 3.93310875e-01f, 8.44493389e-01f, -8.62747729e-01f, 1.10976028e+00f, 7.09741294e-01f, 7.48434439e-02f, 5.47398508e-01f, 5.24176478e-01f, 5.32979846e-01f,
  -6.31436765e-01f, -6.42284393e-01f, -2.43207231e-01f, -8.00143242e-01f, 1.88824490e-01f, -2.70563841e-01f, -5.05633280e-02f, -5.49192607e-01f, 8.97799060e-03f, 5.48329234e-01f,
  -2.41923541e-01f, -3.58909607e-01f, 2.72497684e-01f, -3.83926332e-01f, 3.92098516e-01f, -2.46923715e-01f, 1.15029857e-01f, -3.72849345e-01f, -4.60020810e-01f, 2.25032121e-01f,
  3.82110417e-01f, 1.54906929e-01f, -6.00620091e-01f, -3.19152921e-02f, -3.79294515e-01f, 1.04335465e-01f, 1.49285898e-01f, 4.74064082e-01f, -6.47653401e-01f, -6.20754421e-01f,
  5.93903400e-02f, -5.84776103e-01f, 5.41401863e-01f, 2.96266556e-01f, 3.12403828e-01f, 5.31852506e-02f, -9.06982601e-01f, -1.70214698e-01f, -1.58089042e-01f, -6.35068536e-01f,
  -5.12807429e-01f, 1.02416962e-01f, 8.87807086e-02f, 7.91805267e-01f, -2.49278843e-01f, -3.22733223e-01f, -3.75390768e-01f, 3.09322983e-01f, 2.04714686e-01f, -3.53188455e-01f,
  1.36907026e-01f, 4.26392496e-01f, -2.91365236e-01f, 8.10293928e-02f, -3.09341699e-01f, -2.68426389e-01f, 1.18705399e-01f, -2.89256513e-01f, 6.49895743e-02f, 2.66492844e-01f,
  -3.27364445e-01f, -3.38685304e-01f, -2.41444215e-01f, -1.07837811e-01f, -1.19734384e-01f, 1.23019218e-01f, -3.24574322e-01f, 4.96903881e-02f, -2.47911811e-01f, -6.04105353e-01f,
  2.87922949e-01f, 7.68009782e-01f, 2.13779867e-01f, -5.29862225e-01f, -3.19231868e-01f, -3.76828283e-01f, 1.19931594e-01f, 3.95038188e-01f, -1.16480619e-01f, -1.22898452e-01f,
  3.11477154e-01f, 1.14857942e-01f, -1.06906362e-01f, -7.29659274e-02f, -4.78654593e-01f, -7.69813836e-01f, -3.82077336e-01f, -1.50791198e-01f, -7.84803689e-01f, 3.28659445e-01f,
  -1.24064721e-01f, -5.70738196e-01f, 2.62652725e-01f, -8.20934117e-01f, 5.11620283e-01f, -9.24650311e-01f, 4.82135475e-01f, -7.43165612e-01f, 4.62186515e-01f, -3.38573068e-01f,
  5.25058568e-01f, -1.13057923e+00f, -4.22835678e-01f, -4.52698052e-01f, 1.92458823e-01f, 2.93896616e-01f, -5.66420794e-01f, -1.10606663e-01f, 1.89525127e-01f, 4.12779242e-01f,
  -5.89465976e-01f, -6.30938932e-02f, 4.91885878e-02f, 3.77887577e-01f, 6.41059756e-01f, -4.39080864e-01f, -7.39275336e-01f, -1.09631956e-01f, -6.16458096e-02f, -1.40612379e-01f,
  5.82745075e-01f, 2.89529920e-01f, 3.34186524e-01f, -8.69883632e-04f, 4.05574322e-01f, 8.37715156e-03f, 2.98220217e-02f, -6.50319636e-01f, -2.71436542e-01f, 1.79507896e-01f,
  7.66693428e-02f, 3.80173683e-01f, -1.28125310e+00f, -1.35189101e-01f, 4.64256883e-01f, -1.06515265e+00f, -3.14685166e-01f, 8.33104491e-01f, -1.02808237e+00f, -1.03478819e-01f,
  -2.36671224e-01f, 3.75209004e-02f, 2.95467287e-01f, 6.12367272e-01f, -1.43100042e-02f, 6.14106596e-01f, -1.05809838e-01f, 9.10871997e-02f, 6.33798659e-01f, 2.99236953e-01f,
  4.97381628e-01f, 6.05158746e-01f, -1.13148701e+00f, 4.71765548e-01f, 1.83079213e-01f, -7.80718684e-01f, 4.16469723e-01f, -4.30540234e-01f, -9.12539482e-01f, -8.70728016e-01f,
  1.36958390e-01f, 9.47549999e-01f, -1.87104177e-02f, -6.34450376e-01f, 6.82067871e-01f, 4.30788815e-01f, -8.01816821e-01f, -4.15435195e-01f, -1.35465837e+00f, 5.78693569e-01f,
  -9.22854483e-01f, -8.08342636e-01f, 1.54672667e-01f, 5.02264023e-01f, 2.08489031e-01f, 4.07857299e-01f, 3.90485108e-01f, -2.16834828e-01f, -6.45850122e-01f, -4.17050153e-01f,
  2.08463520e-01f, -2.43071079e-01f, 8.06385577e-01f, 5.31901836e-01f, -5.87275207e-01f, 3.10014635e-01f, 5.68188608e-01f, -8.67779493e-01f, -3.81938428e-01f, -4.61936086e-01f,
  8.08998764e-01f, 1.17294800e+00f, 7.33409729e-03f, -6.92231774e-01f, -7.30540231e-02f, 2.55208194e-01f, 2.86319535e-02f, -1.00787961e+00f, 8.55958983e-02f, 7.04671562e-01f,
  -8.16860199e-01f, -3.80849689e-01f, 3.73274833e-01f, 1.21363923e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.41971388e-02f, -9.73311216e-02f, 1.81327820e-01f, 1.90177649e-01f, 1.79654714e-02f, 1.46359419e-02f, -9.53504536e-03f, -1.02840386e-01f, -1.53249027e-02f, -4.23816629e-02f,
  2.31414303e-01f, -5.66647314e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    