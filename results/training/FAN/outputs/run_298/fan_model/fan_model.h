/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.12155148e-01f, 4.42292333e-01f, 9.64718871e-03f, -6.56254217e-02f, -1.91220641e-01f, 1.10300101e-01f, 1.41568244e-01f, 3.87055539e-02f, 2.21362904e-01f, 3.65017921e-01f,
  -9.84598175e-02f, 3.75948139e-02f, 1.49611339e-01f, 1.10146746e-01f, -4.78238463e-01f, 6.74033612e-02f, 1.13026025e-02f, 1.03421107e-01f, 8.51624534e-02f, 2.28194613e-02f,
  -1.56483173e-01f, -1.53151214e-01f, -1.20639011e-01f, -2.38253977e-02f, -1.28442431e-02f, 4.73527201e-02f, -2.37874046e-01f, -7.27792364e-03f, -2.15062704e-02f, -2.64272597e-02f,
  8.83552954e-02f, 4.83015552e-02f, 4.17435281e-02f, 7.45804980e-02f, -5.52684069e-03f, -7.78791606e-02f, -1.73082575e-02f, -9.97958183e-02f, -3.62382531e-02f, 7.21500218e-02f,
  2.28829477e-02f, -2.28727330e-02f, -7.14116963e-04f, -5.61962090e-02f, -6.76866341e-03f, 4.40175235e-02f, -1.97691303e-02f, -8.99360839e-06f, 7.45776966e-02f, -9.23073851e-03f,
  4.71425503e-02f, 1.73773170e-02f, -3.99850570e-02f, 5.18985689e-02f, -4.33086157e-02f, -1.13739353e-02f, 2.44993977e-02f, -7.46626931e-04f, 1.84970964e-02f, 1.30860321e-02f,
  -7.15428665e-02f, -1.30516710e-02f, 5.71474666e-03f, 4.19568196e-02f, -2.17165146e-02f, 2.24503712e-03f, -2.08930224e-02f, -3.30868587e-02f, 8.42116075e-04f, -3.55736949e-02f,
  1.12474337e-02f, -4.11901623e-02f, -3.69219072e-02f, -3.73720750e-02f, -6.10587001e-03f, 2.12499034e-02f, -4.01874483e-02f, 3.02167274e-02f, 1.01610683e-02f, -4.67448980e-02f,
  5.50888106e-02f, -6.97360374e-04f, 5.00139706e-02f, -2.96513457e-02f, 8.03495466e-04f, -2.42854469e-02f, -1.21810725e-02f, 2.16618367e-02f, -3.31355669e-02f, -4.57704887e-02f,
  -7.43351355e-02f, 1.26132116e-01f, 5.67921512e-02f, 1.68319400e-02f, 6.41281381e-02f, 1.72262406e-03f, -9.86297801e-03f, 2.93281563e-02f, 3.83917876e-02f, -2.83931158e-02f,
  -1.57109946e-02f, 2.28142831e-03f, 2.55550607e-03f, 1.00842342e-02f, -5.70442304e-02f, 1.82105752e-03f, 8.02043453e-03f, -1.02257598e-02f, -5.18311374e-02f, -4.29430902e-02f,
  -3.81717905e-02f, -1.66967157e-02f, -1.71208400e-02f, -5.34822233e-03f, -2.03128699e-02f, 1.64822768e-02f, -8.72539356e-03f, 3.46140936e-02f, -5.80447204e-02f, 2.15901881e-02f,
  -2.25612134e-01f, 3.07372212e-03f, -2.40849972e-01f, -2.39043340e-01f, 3.04568671e-02f, 6.60289973e-02f, -3.12244464e-02f, 5.20093553e-02f, 1.57096967e-01f, 1.77509993e-01f,
  1.38537899e-01f, -1.19583301e-01f, 2.95667470e-01f, -6.94056228e-02f, -2.92211205e-01f, 1.94581583e-01f, -1.48180768e-01f, -4.14607041e-02f, 7.84731209e-02f, -5.22188321e-02f,
  -1.39761478e-01f, 1.57580189e-02f, -2.20373586e-01f, 4.18961756e-02f, -1.39220744e-01f, -8.22118744e-02f, -1.90059647e-01f, 7.26732053e-03f, -2.81473249e-01f, -4.86036874e-02f,
  2.96205748e-02f, 9.42778289e-02f, -5.91875948e-02f, -3.84519212e-02f, -4.08729054e-02f, 1.03847673e-02f, -4.80072834e-02f, 6.08058386e-02f, 9.63424705e-03f, -2.70095896e-02f,
  1.49037084e-02f, -2.76565086e-02f, -1.26451058e-02f, 8.55396912e-02f, 2.32987721e-02f, -7.88706765e-02f, -6.20538034e-02f, -2.92419046e-02f, -1.99649595e-02f, -5.45370951e-03f,
  2.67539406e-04f, -8.98302794e-02f, -4.09000665e-02f, -1.78808793e-02f, -4.85686809e-02f, -2.52347495e-02f, 1.79502163e-02f, -5.14813997e-02f, -5.03405891e-02f, -3.93060856e-02f,
  3.01424805e-02f, 4.70369756e-02f, 5.02772965e-02f, 3.66565399e-02f, 3.77312005e-02f, -1.01519027e-03f, -3.18366513e-02f, 4.25878614e-02f, 1.44518688e-02f, -1.94562296e-03f,
  -2.69552842e-02f, 8.34395364e-03f, 4.53135855e-02f, -1.99813824e-02f, -1.53762652e-02f, 5.90269268e-02f, -1.42027223e-02f, 4.28800732e-02f, 8.98854155e-03f, -3.50213274e-02f,
  8.42480361e-02f, -8.41824152e-03f, 1.56383291e-02f, -4.27822433e-02f, 1.75329875e-02f, 1.15597313e-02f, 2.32456205e-03f, -2.63024755e-02f, 2.57002078e-02f, -2.41345149e-02f,
  -8.98202732e-02f, -3.12392954e-02f, 9.76193137e-03f, 8.26266930e-02f, -2.07350701e-02f, -3.38167464e-03f, -2.72359196e-02f, -7.58198798e-02f, -6.80277571e-02f, 5.06626815e-02f,
  -3.05518061e-02f, 1.68466903e-02f, 9.07351787e-04f, -2.30833571e-02f, -4.69693355e-02f, 2.71619223e-02f, -1.55058568e-02f, -5.83280623e-02f, -4.82346565e-02f, -3.63595076e-02f,
  -1.11682285e-02f, 5.57323508e-02f, -2.97400299e-02f, 1.00582987e-02f, -5.87882027e-02f, -2.60481648e-02f, -4.57501188e-02f, -2.67924853e-02f, -3.66970710e-02f, -4.35672030e-02f,
  3.37502003e-01f, -3.62735838e-01f, -9.12116766e-02f, 1.61738694e-01f, 1.11899674e-01f, 1.96593061e-01f, 1.03353508e-01f, -1.13061443e-01f, -1.10737517e-01f, -2.62944490e-01f,
  4.28249054e-02f, 1.16776312e-02f, -7.27067664e-02f, 1.28931567e-01f, 4.28906292e-01f, -8.04543942e-02f, 1.26930922e-01f, 5.72957247e-02f, -4.76669930e-02f, -8.49726126e-02f,
  8.64809602e-02f, 5.90452403e-02f, 1.33286670e-01f, -1.89519465e-01f, 9.32762399e-02f, -1.11312501e-01f, 1.70716196e-02f, -1.16841711e-01f, 4.01867069e-02f, 1.15760140e-01f,
  1.24708466e-01f, -5.79792485e-02f, -3.47539820e-02f, -1.50705762e-02f, -3.33942100e-02f, 1.22403596e-02f, 3.67188267e-02f, 1.10036217e-01f, 8.35658014e-02f, 3.79740521e-02f,
  2.02164389e-02f, 3.73355150e-02f, 6.69925613e-03f, -1.10526085e-02f, 4.10856456e-02f, 3.84021066e-02f, 1.01534622e-02f, 4.52881120e-02f, -1.93627235e-02f, 6.18087091e-02f,
  -1.71288702e-04f, -6.62126997e-03f, -7.24527054e-03f, -2.88248267e-02f, 1.61398873e-02f, -2.89905909e-02f, 3.27617163e-03f, 3.41706648e-02f, -3.61720920e-02f, -3.18041183e-02f,
  1.53836692e-02f, 2.05059871e-02f, 3.22423317e-02f, 1.11914147e-02f, 3.49605344e-02f, 3.10397334e-02f, 8.03916343e-03f, 2.91293412e-02f, 3.33823599e-02f, -2.06780694e-02f,
  3.76991220e-02f, 5.97133376e-02f, -1.96827855e-02f, 2.31002141e-02f, 5.98623827e-02f, 1.90150607e-02f, 5.20259924e-02f, -1.35742398e-02f, -1.14171440e-03f, 4.86161783e-02f,
  3.66513687e-03f, 2.50436626e-02f, -2.49321554e-02f, 4.93332408e-02f, 2.34250538e-03f, 1.37214623e-02f, -1.81599502e-02f, 7.67199090e-03f, -2.33901031e-02f, 4.97864559e-02f,
  -8.64150077e-02f, -3.20501000e-01f, -7.61920884e-02f, 1.30981151e-02f, -1.76414307e-02f, 1.87370386e-02f, -3.83433178e-02f, -6.36249036e-02f, -6.88321143e-02f, -4.61127497e-02f,
  -2.57250164e-02f, -6.34903507e-03f, -1.71584170e-03f, 6.34490326e-02f, -1.31291356e-02f, -7.38586634e-02f, 8.18044227e-03f, 8.97835661e-03f, -1.74685300e-03f, -1.92898568e-02f,
  -2.44527403e-02f, 3.27849276e-02f, 2.11775675e-02f, -2.24520881e-02f, 9.35313758e-03f, 4.15813103e-02f, -3.80279198e-02f, -3.15644890e-02f, 3.85319926e-02f, -3.67298946e-02f,
  -1.20010771e-01f, 3.04471612e-01f, 2.27552354e-01f, -9.59060043e-02f, 2.29774620e-02f, 8.22687894e-02f, -1.35372892e-01f, 1.32946774e-01f, 3.03807613e-02f, -1.47734992e-02f,
  -1.28141999e-01f, 2.80842930e-02f, -3.13416822e-03f, -8.51742774e-02f, -2.76192337e-01f, 1.03801705e-01f, -2.63121426e-01f, -6.86621666e-02f, 5.07816635e-02f, -7.14044645e-02f,
  -3.88171338e-02f, -2.36454040e-01f, 4.34562005e-02f, 4.36912589e-02f, -1.36965951e-02f, 7.60077983e-02f, -3.09661984e-01f, 9.60754007e-02f, -6.88141137e-02f, -3.61540541e-02f,
  5.20116091e-02f, -1.21806934e-02f, 5.81208132e-02f, 9.75767225e-02f, -5.22766449e-02f, 6.25412688e-02f, -4.48360555e-02f, -5.48940301e-02f, 2.37182947e-03f, 1.49365282e-02f,
  3.87232788e-02f, 2.66583916e-03f, 2.54919603e-02f, 2.01940909e-02f, 9.23363939e-02f, 1.43229932e-01f, 6.10925108e-02f, 6.15412369e-02f, 2.54671387e-02f, 8.35348144e-02f,
  6.47372529e-02f, 5.29677570e-02f, -1.15702907e-02f, -4.16848883e-02f, -1.71317235e-02f, 2.46598050e-02f, -6.17615357e-02f, -4.62297723e-02f, -5.90647664e-03f, 7.30981026e-03f,
  1.82509441e-02f, -4.78566885e-02f, 3.29648070e-02f, 3.06365490e-02f, 4.79483046e-03f, -2.26371158e-02f, 5.05782440e-02f, -5.39812371e-02f, 2.37036198e-02f, -2.45307758e-02f,
  -3.28900814e-02f, -2.24165935e-02f, 4.05336395e-02f, -1.04443962e-02f, 7.29644066e-03f, -4.37195152e-02f, -4.07645926e-02f, -5.96739445e-03f, -1.69024561e-02f, -1.34010930e-02f,
  -4.15209979e-02f, -3.07120997e-02f, 2.31192186e-02f, -5.49320988e-02f, 5.30792698e-02f, -1.26589015e-02f, 7.04908418e-03f, 7.34500736e-02f, 4.13510501e-02f, -8.54206234e-02f,
  -1.25370294e-01f, -1.93183720e-01f, -5.05867861e-02f, -1.48881553e-03f, 3.63253765e-02f, -3.55982557e-02f, 1.25964358e-02f, 4.30954061e-02f, 5.91524877e-03f, 3.27871256e-02f,
  -9.35433954e-02f, 2.33899523e-02f, -7.67657086e-02f, -2.09242827e-03f, -3.46879065e-02f, -7.52709880e-02f, -1.19788475e-01f, -2.42184307e-02f, -6.45714104e-02f, -4.35902476e-02f,
  -1.24791160e-03f, -9.20528471e-02f, -8.39135796e-02f, -2.73850709e-02f, -2.90582869e-02f, -3.62960584e-02f, 2.36477889e-02f, 8.47702324e-02f, -4.46219295e-02f, 3.55901457e-02f,
  5.13455808e-01f, -2.56567508e-01f, 2.12925032e-01f, 3.62172216e-01f, 1.44079691e-04f, -9.72297415e-02f, -5.05703874e-02f, -5.70048355e-02f, 1.09650739e-01f, -3.60693187e-01f,
  -1.04750134e-01f, 1.35518596e-01f, -2.42193699e-01f, -2.71200836e-02f, 3.58143717e-01f, -1.33247763e-01f, 6.00844622e-02f, -1.36603519e-01f, 6.20746315e-02f, 2.73933057e-02f,
  1.61003873e-01f, -1.30745351e-01f, 7.61002824e-02f, -1.56184092e-01f, 1.42378896e-01f, 1.83357015e-01f, 8.35270807e-02f, -5.07277623e-02f, 5.27293421e-02f, 5.32915443e-02f,
  2.01635696e-02f, -5.77474758e-02f, 1.81155149e-02f, -1.20214494e-02f, -1.20199062e-02f, -3.09936665e-02f, -1.02504268e-02f, -3.27369734e-03f, 7.02972487e-02f, 5.97063394e-04f,
  -1.49630010e-02f, 2.87429299e-02f, -1.84922596e-03f, -2.06253724e-03f, 2.61187796e-02f, 6.88801333e-02f, 4.64499630e-02f, 7.59492666e-02f, 7.06490176e-03f, 5.14400005e-02f,
  7.95176625e-03f, 1.64597798e-02f, 2.96168625e-02f, -2.43611522e-02f, 1.75480619e-02f, -3.66845429e-02f, 7.13446224e-03f, 1.95632391e-02f, 7.21705053e-03f, 5.30396588e-02f,
  -6.22517727e-02f, -4.43838574e-02f, -1.84039231e-02f, 2.32589804e-02f, 5.48267476e-02f, -6.02919795e-02f, 4.01798040e-02f, -5.02417609e-02f, 3.75538990e-02f, -1.38859136e-03f,
  4.15134653e-02f, 1.58042610e-02f, -2.87341140e-02f, 1.88172963e-02f, -1.84398498e-02f, -3.04114260e-03f, -7.93838501e-03f, -3.34655754e-02f, 4.89723915e-03f, 1.41352424e-02f,
  -1.58958510e-02f, 1.36472024e-02f, -2.26922370e-02f, -8.46871454e-03f, -3.88741605e-02f, 6.75629228e-02f, -3.53400223e-03f, 8.53411946e-03f, 1.15541993e-02f, 3.84134650e-02f,
  -1.53780371e-01f, -7.70388544e-02f, -5.44762751e-03f, -2.54587512e-02f, -5.62392687e-03f, 1.68004613e-02f, -8.79523903e-03f, 2.99962871e-02f, 7.57845677e-03f, 5.39045967e-03f,
  -7.85751268e-02f, 6.70003006e-03f, -1.83730896e-04f, 1.67725142e-02f, 7.47317355e-03f, -2.11640839e-02f, -6.05591200e-02f, -3.57972160e-02f, 2.26593222e-02f, -1.89147200e-02f,
  2.48272270e-02f, -2.92438604e-02f, 1.88444518e-02f, -4.21615690e-02f, -3.22633050e-03f, 4.29083221e-03f, 2.60663237e-02f, 1.57093313e-02f, -1.74041204e-02f, -3.95687151e-04f,
  5.31788945e-01f, -3.55908304e-01f, -5.54248616e-02f, 3.29768717e-01f, 6.50635660e-02f, -2.80146956e-01f, 1.96436923e-02f, -1.75015051e-02f, 2.24348679e-01f, -2.76351035e-01f,
  -8.55631083e-02f, -9.04013515e-02f, -8.75754878e-02f, -1.66662529e-01f, 1.59862578e-01f, -1.27122281e-02f, -4.13432606e-02f, -1.33101374e-01f, 2.57118791e-02f, 8.15182328e-02f,
  1.79632276e-01f, -8.04745182e-02f, 1.15874028e-02f, -8.43706205e-02f, -9.63748842e-02f, 8.46677274e-02f, 3.19772027e-02f, -5.97125888e-02f, -1.20241500e-01f, -6.56283051e-02f,
  6.39724210e-02f, 2.82713056e-01f, -3.53299044e-02f, -5.01508415e-02f, 1.19347097e-02f, -3.27690877e-02f, -2.20595840e-02f, 1.06136762e-02f, 6.00848123e-02f, -2.26166416e-02f,
  -3.24468873e-02f, 1.37506370e-02f, -6.33466814e-04f, -2.14030687e-03f, -3.68566737e-02f, -2.24260390e-02f, -5.56609780e-02f, -5.89908734e-02f, -9.54281725e-03f, -4.25345898e-02f,
  -7.60117453e-03f, -2.07418166e-02f, 3.06750722e-02f, -8.12404901e-02f, 3.98534276e-02f, -1.24712358e-03f, 8.16688035e-03f, -1.91518031e-02f, -1.72370523e-02f, 1.97635386e-02f,
  3.64699513e-02f, 5.97401056e-03f, -4.85941283e-02f, -2.01835539e-02f, -6.42003072e-03f, 5.92546798e-02f, -3.58483493e-02f, -2.04483024e-03f, -1.42231612e-02f, 1.53649906e-02f,
  3.92174199e-02f, -5.87969832e-03f, 8.32183100e-03f, -9.62326583e-03f, 1.60900839e-02f, 3.13260779e-02f, -2.85023395e-02f, -1.05081396e-02f, 2.62988210e-02f, -2.42600087e-02f,
  2.85065807e-02f, -6.86004013e-03f, -2.92278100e-02f, 6.69275736e-03f, -1.78006161e-02f, -4.70050052e-02f, 7.67238147e-04f, -1.88882798e-02f, 4.27592285e-02f, 6.00574203e-02f,
  -3.20220105e-02f, 1.74909562e-01f, 6.72403257e-03f, 1.60258431e-02f, -6.47245273e-02f, -4.14759815e-02f, 1.89096425e-02f, -1.24550322e-02f, -7.70861357e-02f, 4.50444967e-02f,
  2.10006256e-02f, 5.61634973e-02f, 1.24824848e-02f, -3.66131999e-02f, -8.21948983e-04f, 5.05666016e-04f, -1.95616577e-02f, 3.27549200e-03f, -2.81909183e-02f, -1.15425345e-02f,
  -3.86467390e-02f, 1.88682601e-02f, 7.54356338e-03f, 1.12413913e-01f, 8.39912519e-03f, -1.14880810e-02f, 3.14260162e-02f, 1.95588786e-02f, -5.82652399e-03f, 2.10739626e-03f,
  -4.77913842e-02f, 3.37633342e-01f, 5.48008829e-02f, 1.93291083e-02f, -5.34395836e-02f, -4.76164818e-01f, -4.49020445e-01f, 1.01419576e-01f, -6.18553646e-02f, 6.52026683e-02f,
  -2.37928005e-03f, 5.77320680e-02f, 1.09262645e-01f, -2.34070182e-01f, -2.65623957e-01f, -8.23210403e-02f, -2.74409682e-01f, -1.35461465e-01f, -3.27226408e-02f, 7.94952437e-02f,
  -1.24621419e-02f, -1.00836895e-01f, -7.11490065e-02f, 7.68043548e-02f, -1.54591417e-02f, 1.83785886e-01f, 1.87952086e-01f, 5.83384708e-02f, 9.23457295e-02f, -9.61969048e-02f,
  -8.94304067e-02f, 1.19357720e-01f, 4.50515486e-02f, 1.11969514e-02f, -3.63769494e-02f, 2.73904279e-02f, -6.03375584e-02f, -9.96402055e-02f, -1.03179645e-02f, -1.30710949e-03f,
  -2.20762310e-03f, 1.73488222e-02f, -7.06061423e-02f, 1.76583417e-02f, -4.38361475e-03f, 2.99433395e-02f, 2.62651574e-02f, 2.60979328e-02f, 4.72835004e-02f, 4.06737663e-02f,
  3.38710621e-02f, 4.50237282e-02f, 3.76366153e-02f, -9.17720329e-03f, 3.10487729e-02f, 2.12886967e-02f, -6.91769123e-02f, 2.37444136e-02f, -2.02517975e-02f, -1.35112461e-02f,
  6.02291152e-02f, 1.33385416e-02f, 9.06698685e-03f, -1.10978577e-02f, 2.87524238e-03f, 1.53052912e-03f, -3.01380595e-03f, -1.41333351e-02f, 3.56229693e-02f, 7.81600829e-03f,
  -3.01462468e-02f, 7.40066869e-03f, 1.54814795e-02f, -2.43091732e-02f, -6.64475793e-03f, 5.85892517e-03f, -9.40585230e-03f, 3.55866514e-02f, 1.70652231e-03f, -4.65529598e-02f,
  1.87058486e-02f, -8.25278834e-03f, 2.69023478e-02f, 1.78613197e-02f, -3.58738676e-02f, -8.30532517e-03f, 2.69498639e-02f, 5.84076606e-02f, 1.92363411e-02f, -5.43800294e-02f,
  -7.46598840e-02f, 2.38451362e-01f, -2.49236580e-02f, -6.16490990e-02f, 6.21571671e-03f, -1.76804606e-03f, -1.19885057e-02f, 4.95708659e-02f, 3.88322547e-02f, -1.54301710e-02f,
  6.46364465e-02f, -2.76945867e-02f, 4.09256369e-02f, 6.07802719e-03f, -3.43227647e-02f, -1.55021204e-03f, 2.46838331e-02f, -1.78085845e-02f, -3.88078503e-02f, 3.14827636e-02f,
  9.14749503e-02f, -2.73957253e-02f, -3.80160622e-02f, -1.69586260e-02f, -3.12974527e-02f, -1.55454753e-02f, 6.51053935e-02f, 1.71271600e-02f, 7.88075700e-02f, 1.19273979e-02f,
  -9.14246365e-02f, -4.19465452e-02f, -2.48252377e-01f, -1.88873082e-01f, 2.26340890e-01f, -1.40358567e-01f, -2.54137009e-01f, 2.73374282e-03f, -1.16831690e-01f, -2.96039153e-02f,
  -9.91774276e-02f, -3.82413119e-02f, -1.51104316e-01f, -2.79852360e-01f, -1.76399425e-02f, -2.99105376e-01f, -3.43102515e-02f, -1.62697554e-01f, 4.51716967e-03f, 5.10468595e-02f,
  2.20667776e-02f, 4.34789434e-02f, 1.95537303e-02f, 2.51244307e-01f, 8.13320875e-02f, 2.09888399e-01f, 3.37754220e-01f, 1.30630791e-01f, 2.43205279e-02f, 1.24099486e-01f,
  5.94554916e-02f, -1.02386989e-01f, -2.39786617e-02f, -6.59884810e-02f, 4.43218835e-02f, 3.97878401e-02f, 6.64597601e-02f, -9.31857973e-02f, 7.82366097e-03f, -3.77913825e-02f,
  -6.73244707e-03f, -7.59871751e-02f, -5.55261374e-02f, 2.23345440e-02f, 2.28733905e-02f, -2.62137093e-02f, -5.41023687e-02f, 4.92770374e-02f, 5.84422424e-03f, -1.04682907e-01f,
  -1.37301490e-01f, -2.93359775e-02f, -2.96708699e-02f, -3.33528779e-02f, -1.26861185e-02f, 1.78061984e-02f, -2.71676481e-02f, 2.14567464e-02f, 7.17481226e-02f, -2.64690481e-02f,
  5.34975640e-02f, 1.71835104e-03f, 2.47761756e-02f, 2.32937350e-03f, -3.70073132e-02f, 1.28999259e-02f, 2.35803742e-02f, -5.33678532e-02f, 3.84140909e-02f, -2.82528135e-03f,
  6.78733736e-02f, 2.73738820e-02f, -3.16869095e-03f, -3.56897935e-02f, -2.25089919e-02f, -4.17436734e-02f, -1.55916894e-02f, 1.76568236e-02f, 1.22105395e-02f, -4.15400825e-02f,
  -1.68941021e-02f, -2.62531471e-02f, -3.64065683e-03f, -4.87506948e-03f, 4.23687063e-02f, -4.25328352e-02f, 2.08960492e-02f, -7.82084614e-02f, -1.58682428e-02f, -1.02387806e-02f,
  2.59678721e-01f, 2.83303767e-01f, 3.50809321e-02f, 4.87605371e-02f, 3.17209102e-02f, -3.67026292e-02f, -1.45516969e-05f, -9.46258008e-03f, 6.23117760e-02f, -2.84629893e-02f,
  4.06340547e-02f, 1.99198835e-02f, 1.11466900e-01f, -2.28089374e-02f, 7.96118937e-03f, 7.05605745e-02f, 5.09804562e-02f, 4.41514030e-02f, 1.32596672e-01f, 5.67279719e-02f,
  6.43182248e-02f, -2.74779834e-03f, 2.29216069e-02f, 8.20050761e-02f, 1.10305054e-02f, -1.40753211e-02f, 9.41265821e-02f, -1.82986129e-02f, 3.48452106e-02f, 4.15241756e-02f,
  -5.90124607e-01f, -1.19170971e-01f, -3.04808199e-01f, -3.36235076e-01f, 6.56562950e-03f, -1.57530978e-01f, -2.25062847e-01f, -6.95293844e-02f, -2.79344052e-01f, 1.98581100e-01f,
  1.14287496e-01f, -1.89211398e-01f, 1.80058926e-01f, -7.69108236e-02f, -2.43875563e-01f, 3.44935171e-02f, -1.17913671e-01f, -8.49388763e-02f, -5.61136417e-02f, -1.20197512e-01f,
  -1.92596585e-01f, 3.61027606e-02f, -9.83498394e-02f, 1.09478839e-01f, -1.87713653e-01f, -4.56082039e-02f, 2.45296061e-01f, 3.69085297e-02f, 1.04612648e-01f, 2.05428973e-02f,
  -7.79727772e-02f, -6.57565519e-02f, -5.71218170e-02f, -8.07888806e-03f, -2.21094256e-03f, 1.51729099e-02f, 3.65672372e-02f, 1.37840332e-02f, -5.59206400e-03f, -4.97953705e-02f,
  2.32562032e-02f, -1.99191310e-02f, -1.37588661e-02f, 2.19703605e-03f, -9.34317261e-02f, -3.79847549e-02f, -3.62925418e-02f, -4.43172008e-02f, -2.74326559e-02f, -2.82261125e-03f,
  -9.33993384e-02f, -2.85640433e-02f, -2.78138034e-02f, 4.48673554e-02f, -5.74600436e-02f, -2.64445450e-02f, -1.67054180e-02f, 1.30491704e-02f, -2.29669660e-02f, -2.33393312e-02f,
  5.54967346e-03f, 3.56402248e-02f, 2.40373565e-03f, 1.22440718e-02f, -5.42977154e-02f, 2.53146216e-02f, -1.95348915e-02f, 5.49173132e-02f, -7.03703389e-02f, -1.24652032e-02f,
  -2.99225785e-02f, -1.09449178e-02f, -1.91004761e-02f, 9.18792374e-03f, -1.27743864e-02f, -2.55854777e-03f, -1.41276745e-02f, 4.09439094e-02f, -7.01182485e-02f, -2.17229668e-02f,
  2.39314754e-02f, -1.18345208e-02f, -5.07302629e-03f, 3.62539440e-02f, 1.27198212e-02f, 4.52800049e-03f, 1.83148328e-02f, -2.65460704e-02f, 1.79143110e-03f, 9.68053564e-03f,
  9.80391577e-02f, 1.09576352e-01f, -5.48231823e-04f, 5.78704849e-03f, 9.91398655e-03f, 1.57411825e-02f, -4.91058789e-02f, -1.05125187e-02f, -3.61801721e-02f, -6.95120730e-03f,
  4.27324623e-02f, 3.20045091e-02f, 1.80517845e-02f, -1.85786206e-02f, 2.32311282e-02f, 3.64289023e-02f, 5.78705445e-02f, 2.46715043e-02f, -8.76287464e-04f, -2.32088678e-02f,
  3.64772826e-02f, 2.59125289e-02f, -3.82830873e-02f, -3.38385664e-02f, 3.74012403e-02f, 8.21020082e-03f, -2.38741841e-03f, 3.47439051e-02f, 8.00343901e-02f, -1.24428570e-02f,
  -8.56929179e-03f, -2.50774443e-01f, 2.94578016e-01f, 6.29773140e-02f, 1.05177745e-01f, 9.86132212e-03f, -1.45044494e-02f, -1.23729110e-02f, 2.18247533e-01f, -4.06565160e-01f,
  -1.69427365e-01f, -1.14712022e-01f, 6.34322986e-02f, -2.36099929e-01f, 3.62921327e-01f, 1.76966190e-01f, -1.79917306e-01f, -1.88144013e-01f, 1.91251323e-01f, -1.75831184e-01f,
  9.24701244e-02f, -1.87759325e-01f, 1.54338911e-01f, -1.02087550e-01f, -1.10750027e-01f, -1.31292641e-02f, -8.63470510e-02f, 1.64624110e-01f, -2.41817147e-01f, 8.50294009e-02f,
  -8.50065202e-02f, 9.25298631e-02f, -2.28245538e-02f, 2.29849983e-02f, -1.09416656e-01f, -3.68817933e-02f, -1.34713231e-02f, 6.63630292e-02f, 4.74234521e-02f, 9.67238564e-03f,
  -1.23034373e-01f, 2.18347106e-02f, -3.13438438e-02f, 1.43646607e-02f, -1.41368061e-03f, -4.79853479e-03f, 5.40822931e-03f, -1.36215687e-02f, 7.49646174e-03f, 3.61058339e-02f,
  5.77140898e-02f, -3.71729955e-02f, -3.10425553e-02f, -7.11650327e-02f, 7.74935260e-02f, 6.91947788e-02f, 3.82851847e-02f, 3.37760001e-02f, -1.16958329e-02f, 4.62640375e-02f,
  9.13627073e-02f, 9.46875289e-03f, 1.63479652e-02f, 1.81538928e-02f, -2.79435329e-02f, 2.76896711e-02f, -2.86143217e-02f, -2.15678755e-02f, -7.20210280e-03f, -6.99616969e-02f,
  -3.08837872e-02f, -2.90776975e-02f, 2.47312547e-03f, -2.86811194e-03f, -2.57985778e-02f, -2.22642459e-02f, 1.15067912e-02f, -3.23995166e-02f, 2.26494903e-03f, -6.41279062e-03f,
  2.90064886e-02f, -4.09218157e-03f, -1.76394787e-02f, -2.46528978e-03f, 9.54206754e-03f, -2.35754554e-03f, -2.94355731e-02f, 1.92782618e-02f, 1.65228322e-02f, -2.45879814e-02f,
  -2.93709695e-01f, -2.26407200e-01f, -8.05812404e-02f, -8.43602419e-02f, -4.99088259e-04f, -4.97890972e-02f, 5.54915629e-02f, 5.99852018e-03f, -5.15843090e-03f, 3.06233647e-03f,
  -8.01316090e-03f, -6.74702823e-02f, -2.02171560e-02f, 3.74619626e-02f, 4.16179486e-02f, 9.53319855e-03f, 2.08084788e-02f, -5.31626679e-02f, -1.01024516e-01f, -5.66822886e-02f,
  -6.85882121e-02f, -2.82075107e-02f, 7.00907707e-02f, 1.53362229e-02f, -7.98940584e-02f, -9.14443508e-02f, -4.07498144e-02f, 2.50647385e-02f, -3.86734642e-02f, -2.80574970e-02f,
  3.60810421e-02f, -9.71040800e-02f, 1.77793190e-01f, 1.83974534e-01f, 1.46367833e-01f, 2.77943313e-01f, 2.11382031e-01f, 1.60978645e-01f, 3.79193842e-01f, -5.47209829e-02f,
  -1.59347791e-03f, -3.05660013e-02f, -1.29381955e-01f, 1.11648791e-01f, 1.17727049e-01f, 3.95967029e-02f, 1.90260246e-01f, 1.35888876e-02f, 8.36045444e-02f, -1.06113635e-01f,
  1.02861486e-01f, -1.29266351e-01f, -7.15216622e-02f, -1.11972153e-01f, -7.64446631e-02f, -3.95765975e-02f, -1.81925625e-01f, -1.62117422e-01f, -6.57809079e-02f, -3.09868855e-03f,
  7.94557482e-02f, -6.15443550e-02f, -4.87690829e-02f, 3.57235484e-02f, 1.04851559e-01f, 5.99617232e-03f, -1.08397622e-02f, -1.06179707e-01f, 2.89375708e-02f, -2.00726613e-02f,
  -3.04103587e-02f, -2.75420453e-02f, 9.48428065e-02f, 2.61762701e-02f, -2.77262703e-02f, 5.77280819e-02f, -2.66212784e-02f, 7.03809112e-02f, -4.17120829e-02f, -1.18270761e-03f,
  3.73760983e-02f, 2.27333885e-02f, 1.70731377e-02f, -1.23898471e-02f, 3.28955217e-03f, -4.81773540e-02f, 3.81295606e-02f, -8.87096580e-03f, 5.15992418e-02f, 1.02707513e-01f,
  -1.87277887e-02f, -3.28621594e-03f, -1.02601405e-02f, 3.36802490e-02f, -3.59246545e-02f, -5.17201833e-02f, -3.72721627e-02f, -4.96013872e-02f, 2.79920418e-02f, -3.00278962e-02f,
  5.60848266e-02f, -1.45436106e-02f, 7.70638585e-02f, 4.69641108e-03f, 3.21666780e-03f, 2.86075007e-02f, -9.77666397e-03f, 2.14926600e-02f, 4.06607762e-02f, 2.43166015e-02f,
  -5.61071038e-02f, 3.80933820e-03f, -2.87307613e-03f, 3.69897258e-04f, 5.27180638e-03f, -2.64249668e-02f, -1.92260165e-02f, 3.11545767e-02f, -1.27977002e-02f, -1.64300315e-02f,
  1.00657038e-01f, 4.38688844e-02f, 3.03583518e-02f, -6.96492643e-05f, -5.81029058e-02f, 3.96757945e-02f, 3.70046794e-02f, 7.58944005e-02f, -1.52852889e-02f, 2.89066415e-03f,
  5.20914048e-02f, 3.54773216e-02f, -4.78676930e-02f, -5.41592529e-03f, 1.91476699e-02f, 7.90920854e-03f, -6.62102178e-02f, 1.92298088e-02f, 3.69492881e-02f, -2.53937040e-02f,
  -3.66097353e-02f, -2.34034732e-02f, 1.55738397e-02f, 2.15956401e-02f, 5.23490869e-02f, 1.83847509e-02f, 4.72957008e-02f, 1.17036456e-03f, -3.14740613e-02f, -2.30022836e-02f,
  -1.03390440e-01f, 1.59711856e-02f, 2.08587661e-01f, -1.24621816e-01f, -1.05428539e-01f, -8.61314535e-02f, 2.61560362e-02f, -1.01290673e-01f, -1.14708096e-01f, -2.10409284e-01f,
  -1.48319155e-01f, 7.42477924e-02f, -2.52654832e-02f, -4.30026539e-02f, -3.96464430e-02f, 1.69795174e-02f, -2.02588275e-01f, -1.21009536e-01f, 1.62687246e-02f, -2.35933512e-01f,
  -5.61098708e-03f, -3.16871554e-01f, 1.93449199e-01f, -1.03062004e-01f, -9.73754376e-02f, 5.76933846e-02f, -2.29180828e-01f, 4.16803285e-02f, 3.08741666e-02f, 8.66342559e-02f,
  -2.74959579e-02f, -1.56719849e-01f, -1.69414263e-02f, 3.05764340e-02f, -8.43106285e-02f, 1.09978151e-02f, 9.71157756e-03f, 1.12523936e-01f, 1.00316629e-01f, 6.17931895e-02f,
  3.79931405e-02f, -4.78861220e-02f, 5.62879406e-02f, 2.83635166e-02f, -7.08734170e-02f, -2.50284355e-02f, 1.57453008e-02f, 1.59987882e-02f, 4.88351434e-02f, 9.35561806e-02f,
  1.07499652e-01f, 1.26426574e-03f, -2.80855093e-02f, 2.07484625e-02f, 5.18493168e-02f, -2.95153018e-02f, 1.14789130e-02f, 2.72866562e-02f, -9.33948457e-02f, -6.22050837e-02f,
  -4.35208194e-02f, -3.20799882e-03f, -3.09165400e-02f, 2.55747791e-02f, -4.83909473e-02f, -7.95972161e-03f, -1.94641091e-02f, 2.90507376e-02f, -1.75008196e-02f, -2.04114965e-03f,
  -3.28186117e-02f, 3.98689173e-02f, -1.71147864e-02f, -2.77189026e-03f, 5.69105148e-03f, 1.21684966e-03f, 3.78419831e-02f, -5.05151525e-02f, -5.89752977e-04f, 3.93279865e-02f,
  -1.14233978e-02f, -2.33385824e-02f, -1.63850561e-02f, -1.10915564e-02f, -1.32219614e-02f, 6.14478663e-02f, -7.38750324e-02f, 1.17329098e-02f, -1.06444275e-02f, 2.39039194e-02f,
  -3.91704500e-01f, -3.82057726e-01f, 3.36133763e-02f, -6.80115372e-02f, -9.73135885e-03f, -9.46140811e-02f, -2.40369681e-02f, 1.65535361e-02f, -1.25682086e-01f, -7.94327259e-02f,
  -4.33306098e-02f, 9.98995267e-03f, -5.08678705e-02f, -2.66356077e-02f, -6.93873363e-03f, -1.32812178e-02f, -3.57529707e-02f, 1.42975869e-02f, -1.07026301e-01f, -8.68973434e-02f,
  -4.80194651e-02f, 2.72817770e-03f, 8.27567093e-03f, -4.98298593e-02f, -3.19041759e-02f, 2.54178740e-04f, -3.65558155e-02f, 6.65002167e-02f, 6.17378913e-02f, -4.29438576e-02f,
  -2.85140306e-01f, 2.55159497e-01f, 2.11702567e-02f, 2.81144101e-02f, -2.05653206e-01f, -2.97385782e-01f, -2.11377770e-01f, -8.35139751e-02f, 3.69604975e-02f, 2.49868110e-01f,
  -1.38117939e-01f, 1.91328526e-01f, 2.46040709e-02f, -6.36917129e-02f, -4.48490977e-01f, 8.94986540e-02f, -2.17305437e-01f, -5.32908067e-02f, 1.11625241e-02f, -1.86836183e-01f,
  -1.11504853e-01f, -2.33306155e-01f, -1.23190925e-01f, -1.22502968e-02f, -1.21745460e-01f, 1.08120114e-01f, -5.34818769e-02f, 6.82196692e-02f, -5.57504110e-02f, 1.18425870e-02f,
  -4.37498512e-03f, 1.04931660e-01f, 6.18253974e-03f, 2.47161314e-02f, -1.81956798e-01f, -5.49619384e-02f, 3.24259773e-02f, 6.44444525e-02f, -4.42091972e-02f, -4.46579158e-02f,
  -1.71715356e-02f, 2.03759894e-02f, -1.33848879e-02f, -2.27327701e-02f, -2.26834845e-02f, 4.77676839e-02f, -1.71517394e-02f, -3.23969941e-03f, 3.85051928e-02f, -6.91357907e-03f,
  1.33151934e-02f, 1.25394799e-02f, -2.81327199e-02f, 6.29675866e-04f, -2.79440023e-02f, 1.39870178e-02f, 2.26766076e-02f, 8.61512795e-02f, 3.21494695e-03f, 2.08639037e-02f,
  -3.64202298e-02f, -1.72810368e-02f, -1.47082750e-02f, -2.98021827e-02f, -7.53705809e-03f, -1.89140737e-02f, -3.97237279e-02f, 1.05401548e-02f, 4.49060611e-02f, 3.47144576e-03f,
  -2.58534420e-02f, -2.49408092e-02f, -1.76582150e-02f, -2.16706898e-02f, -2.76176967e-02f, 1.67707801e-02f, -1.91313867e-02f, 3.36358473e-02f, 3.04325577e-02f, -2.33046245e-02f,
  2.15549190e-02f, -2.52204016e-02f, 9.52510722e-03f, 3.92070301e-02f, 1.24398549e-03f, 1.55447740e-02f, 1.36019047e-02f, 3.88115793e-02f, -2.65240334e-02f, -3.66581455e-02f,
  -1.26379251e-01f, -9.48894694e-02f, 5.64809144e-02f, 3.81042436e-02f, 1.00231379e-01f, 7.09646731e-04f, -2.55745109e-02f, -5.56109473e-02f, -1.32525647e-02f, -8.13122541e-02f,
  -5.41901924e-02f, 5.48791047e-03f, 4.15484002e-03f, 5.53937890e-02f, 4.14611277e-04f, -6.03813455e-02f, -3.29406336e-02f, 1.87619478e-02f, -9.15480331e-02f, -9.19116940e-03f,
  -7.46642845e-03f, -2.14993209e-03f, -7.73651712e-03f, 9.69601981e-03f, 1.03861149e-02f, -3.77304628e-02f, -5.27402870e-02f, 1.84925459e-02f, -1.14723539e-03f, 4.62714098e-02f,
  4.49384183e-01f, -2.86490768e-01f, -3.32243145e-01f, -6.89041317e-02f, 3.20548207e-01f, -1.45139724e-01f, -2.20222041e-01f, 2.19775252e-02f, 7.69707114e-02f, -1.82595879e-01f,
  -1.23645226e-02f, 1.76989473e-02f, -2.81897962e-01f, -2.47842610e-01f, -1.52377397e-01f, -3.10182512e-01f, -1.07437484e-01f, -3.74268331e-02f, -3.04188803e-02f, 3.90334353e-02f,
  3.27061042e-02f, -7.97599703e-02f, -3.08054745e-01f, 1.28875691e-02f, 1.20494470e-01f, 8.94377157e-02f, 5.04316986e-02f, -7.44630247e-02f, 5.77673353e-02f, -6.60655573e-02f,
  9.66852531e-02f, 1.93961076e-02f, 1.10795004e-02f, -9.49272215e-02f, 7.51365349e-02f, 5.87896630e-02f, -2.03371681e-02f, -6.77413642e-02f, 5.32054855e-03f, 3.02515049e-02f,
  1.53235756e-02f, 9.14990827e-02f, 1.95422601e-02f, -6.08965717e-02f, 9.66400206e-02f, -6.10647397e-03f, 5.34450598e-02f, -2.09792946e-02f, -4.85511608e-02f, -3.49337198e-02f,
  -4.21661399e-02f, -4.77171130e-02f, 2.77406909e-02f, -8.83391649e-02f, -2.87377797e-02f, -3.15541178e-02f, -4.12154980e-02f, -1.82760172e-02f, -1.23013295e-02f, 2.70619188e-02f,
  -2.17387397e-02f, 4.87599857e-02f, -4.75939400e-02f, 6.15610369e-02f, -4.23278054e-03f, 2.85066515e-02f, -3.22057046e-02f, 2.03293911e-03f, -4.38928232e-03f, 4.13612947e-02f,
  2.69230902e-02f, 4.94789928e-02f, 1.21818129e-02f, -2.93473341e-02f, 1.91144552e-02f, 3.97023372e-02f, 1.24620944e-02f, 2.10787877e-02f, 4.45872694e-02f, -1.47574376e-02f,
  -1.41424211e-02f, -8.75036325e-03f, 6.05144724e-03f, -5.24916360e-03f, -1.59217063e-02f, -4.96208854e-03f, -3.41372043e-02f, -5.73066389e-03f, -1.41262356e-02f, 7.84223154e-03f,
  8.54309946e-02f, -6.47174641e-02f, -5.54368459e-02f, 4.37777154e-02f, -2.07266305e-02f, 5.97652420e-03f, -1.80120654e-02f, 5.72016314e-02f, -1.07831284e-01f, 6.77151233e-03f,
  2.40606833e-02f, 1.46513022e-02f, 5.51124029e-02f, 4.65310402e-02f, -7.37592056e-02f, -1.95456855e-02f, -4.76753712e-02f, 1.66097376e-02f, 4.45697969e-03f, 1.19349454e-02f,
  -1.12532163e-02f, 5.32272160e-02f, -5.17025627e-02f, 7.80630484e-02f, 4.15741280e-02f, 6.91520423e-02f, 5.74549660e-02f, 1.37142157e-02f, 2.27413680e-02f, -3.22265811e-02f,
  -2.04428852e-01f, 2.11593464e-01f, 1.09288476e-01f, -6.45950139e-02f, 6.65091425e-02f, 1.76791903e-02f, -1.00793742e-01f, 2.12506250e-01f, -2.20923588e-01f, 6.30541444e-02f,
  2.56561458e-01f, -3.11186481e-02f, 1.01715408e-01f, 1.91196829e-01f, 4.19279039e-02f, 1.40426122e-03f, 7.75717385e-03f, -6.54268488e-02f, -9.51748714e-03f, 1.46891356e-01f,
  -9.54510085e-03f, 1.12263158e-01f, 1.46546155e-01f, 2.50473440e-01f, 1.16665706e-01f, -9.78085492e-03f, 3.23372036e-02f, 8.74599293e-02f, 2.57848412e-01f, 1.40783802e-01f,
  1.09864041e-01f, 3.79702486e-02f, 4.18112911e-02f, -4.21728753e-02f, 2.66533848e-02f, -5.93060032e-02f, -5.68777137e-03f, 9.91561115e-02f, -2.23609805e-02f, -1.10432543e-02f,
  -5.60865588e-02f, 6.01070300e-02f, -5.10297157e-03f, -2.70425566e-02f, -1.14731854e-02f, 5.57606993e-03f, -1.52610044e-03f, -2.03196835e-02f, -2.48943530e-02f, 5.89724854e-02f,
  8.02132208e-03f, 6.41584471e-02f, -4.36290987e-02f, -6.92580193e-02f, -2.44278349e-02f, -4.03905585e-02f, 9.44297854e-03f, -1.17501104e-03f, -8.29480886e-02f, -9.83745325e-03f,
  1.08754430e-02f, -9.89636481e-02f, 4.20632176e-02f, -2.48332303e-02f, 6.69786707e-03f, 1.48556614e-02f, 2.21042354e-02f, -7.57402042e-03f, -7.90139213e-02f, 2.16948446e-02f,
  1.65607836e-02f, 5.74638182e-03f, 3.62240453e-03f, -7.92780519e-02f, -6.68990891e-03f, -3.91682982e-02f, -3.61164287e-02f, -2.62758601e-02f, -2.54915711e-02f, 8.50412250e-03f,
  -3.74760441e-02f, 1.34970825e-02f, -7.92221446e-03f, 1.34954844e-02f, -2.61079166e-02f, 7.99161009e-03f, 4.23717313e-02f, -3.95764224e-03f, 1.67154111e-02f, 5.46374619e-02f,
  4.52678464e-03f, 1.48341224e-01f, 1.30528826e-02f, 3.63027072e-03f, 8.29319004e-03f, 8.74882415e-02f, -5.49094118e-02f, 7.77954236e-03f, 6.12300728e-03f, -5.85081475e-03f,
  1.30849276e-02f, -5.06445579e-02f, -5.04220985e-02f, 1.79963466e-02f, 6.98289089e-03f, 2.04673521e-02f, -3.31621170e-02f, -2.19074879e-02f, 6.01291424e-03f, 9.48574767e-02f,
  4.40921560e-02f, -7.53595084e-02f, -2.41035800e-02f, -1.88639536e-02f, -4.75028381e-02f, -1.07338233e-03f, -4.83030230e-02f, -5.91430813e-03f, 4.96222302e-02f, -2.65580434e-02f,
  -1.98895335e-01f, -1.15080783e-02f, -4.93477099e-03f, -2.93998748e-01f, -5.12019247e-02f, 1.59264266e-01f, 6.57692179e-02f, -1.82481691e-01f, -1.28657622e-02f, -1.07248716e-01f,
  -3.89116653e-03f, 4.57369685e-02f, 2.46955767e-01f, -1.65137529e-01f, 3.24905187e-01f, 3.82496387e-01f, -8.20446759e-02f, -2.73795258e-02f, 6.71009868e-02f, -1.44140676e-01f,
  -6.66292086e-02f, -1.27989352e-01f, 1.27071694e-01f, -1.49061441e-01f, -1.68922037e-01f, -2.26871610e-01f, -1.00427546e-01f, 2.90649626e-02f, -1.94650054e-01f, 1.03466094e-01f,
  8.58521014e-02f, -7.19401091e-02f, -6.77459985e-02f, 7.40652531e-02f, -4.50641625e-02f, -5.01737967e-02f, -3.53712179e-02f, 5.72135001e-02f, 2.34647524e-02f, 2.71484219e-02f,
  1.72734801e-02f, 3.06924619e-02f, -5.56961596e-02f, -1.56965312e-02f, -6.14305809e-02f, -5.62893115e-02f, 5.34699559e-02f, -3.46554480e-02f, -3.97762060e-02f, 4.88664620e-02f,
  -2.32396442e-02f, -5.64544089e-03f, -5.71392365e-02f, -9.02337581e-03f, -1.48806078e-02f, -7.56743597e-03f, 1.78105310e-02f, 1.76251475e-02f, 1.66985597e-02f, -1.82611458e-02f,
  -3.19894329e-02f, -5.41568843e-05f, 1.43353231e-02f, 7.17523228e-03f, 4.05213349e-02f, -3.84861194e-02f, -6.87400019e-03f, 4.99461778e-02f, 7.90810119e-03f, 8.65222421e-03f,
  -6.51068101e-03f, -2.83423830e-02f, -6.27501030e-03f, 1.40429055e-02f, -4.53871265e-02f, -2.55187321e-02f, -9.44600999e-03f, 1.33789927e-02f, -2.86196060e-02f, -2.24648826e-02f,
  -7.08700344e-03f, -1.15244435e-02f, -7.46475626e-03f, -4.69620079e-02f, 1.91839579e-02f, 2.62387679e-03f, -3.25782299e-02f, -1.44548602e-02f, -2.60004681e-02f, 4.09746356e-03f,
  4.09483649e-02f, 3.00339758e-02f, 6.87037501e-03f, -1.50996046e-02f, 7.69966543e-02f, -6.88647013e-03f, 4.09178957e-02f, -4.70657907e-02f, -5.67716343e-05f, -2.18656976e-02f,
  -9.58435461e-02f, -7.13815019e-02f, 5.78200035e-02f, -1.67906731e-02f, 4.35364060e-03f, 2.07716785e-02f, -4.12261561e-02f, 5.37047954e-03f, -5.23243472e-02f, -4.14767973e-02f,
  -2.99166329e-02f, 3.00445277e-02f, 1.54357906e-02f, -3.67208757e-02f, -2.62149516e-03f, 1.40954452e-02f, -5.97854294e-02f, 4.09494601e-02f, 8.33465066e-03f, 3.49909440e-02f,
  -1.17689274e-01f, 2.60904461e-01f, 1.04604267e-01f, 2.11773980e-02f, -1.76873356e-01f, -3.74758244e-01f, -2.57018566e-01f, 2.98116598e-02f, 9.01537985e-02f, 1.69655219e-01f,
  1.41961187e-01f, 4.33589369e-02f, 2.48797759e-01f, 1.07791997e-01f, -2.52818078e-01f, 6.12530448e-02f, -1.28742382e-01f, -1.46161824e-01f, 6.13578735e-03f, -6.76569482e-03f,
  4.60865349e-02f, -3.05915661e-02f, 1.56886548e-01f, 8.38851109e-02f, 2.02726200e-02f, 3.13704163e-02f, 8.01283983e-04f, -5.47860600e-02f, -1.71897095e-02f, -1.30527318e-01f,
  6.76453486e-02f, 6.58265501e-02f, 9.22872499e-02f, -1.67555045e-02f, -2.47356817e-02f, -2.81587858e-02f, -1.87665001e-02f, -7.98731670e-02f, -4.58033495e-02f, 1.77503023e-02f,
  4.60363142e-02f, -2.19603758e-02f, 7.87426066e-03f, -1.20627228e-02f, -6.35354221e-02f, 3.18262093e-02f, 6.57261908e-02f, 9.11653489e-02f, 5.57935275e-02f, 4.53765169e-02f,
  9.41738784e-02f, 3.59699652e-02f, 2.54846103e-02f, 4.77153882e-02f, 1.11987414e-02f, -9.89282653e-02f, -3.98376286e-02f, -2.12721322e-02f, 1.97519735e-02f, -2.20439322e-02f,
  -6.95411041e-02f, -3.90024781e-02f, 8.86925086e-02f, 8.44952762e-02f, 4.86124195e-02f, 7.42172673e-02f, 4.35143104e-03f, 3.72985043e-02f, -4.52715233e-02f, 4.43961620e-02f,
  4.91939597e-02f, 4.93156835e-02f, 6.55235117e-03f, 9.89376474e-03f, 8.56819004e-03f, 9.54608694e-02f, 5.54843806e-03f, -1.32207628e-02f, -2.77088135e-02f, 2.46599615e-02f,
  2.27397233e-02f, -4.76359613e-02f, 7.26561248e-02f, 2.09428966e-02f, 6.80522295e-03f, -1.94840878e-02f, 6.69915974e-02f, 6.32735118e-02f, 6.77151754e-02f, -1.98367406e-02f,
  -1.64413020e-01f, -1.14178911e-01f, 4.19451073e-02f, 4.96760197e-02f, -5.36721647e-02f, 1.44740343e-02f, 2.34493222e-02f, -9.24823433e-02f, -1.48828104e-01f, -2.83651948e-02f,
  -7.11490363e-02f, -7.11626606e-03f, -4.80034389e-02f, -3.32149118e-02f, 9.05783661e-03f, -4.56387643e-03f, -2.48660073e-02f, -4.23517041e-02f, -1.16276570e-01f, -4.66931565e-03f,
  -2.27610953e-02f, 4.17017564e-02f, -5.57553731e-02f, -5.43208048e-02f, 1.21172406e-02f, -7.83688668e-03f, -8.06690976e-02f, -4.47739772e-02f, -8.64536390e-02f, -3.36149405e-03f,
  2.05802798e-01f, 2.26061136e-01f, 4.57189195e-02f, -8.82285684e-02f, -2.33143553e-01f, -6.43986985e-02f, -1.28314272e-01f, -1.27460986e-01f, 1.95785120e-01f, 5.62192164e-02f,
  -2.83000827e-01f, 2.84858257e-01f, -5.24592325e-02f, -3.35917771e-02f, -1.03138231e-01f, 2.59387046e-02f, -1.21150821e-01f, 2.27646977e-02f, 1.47603959e-01f, -3.84760834e-02f,
  -6.13321513e-02f, -2.48218492e-01f, -2.40062356e-01f, -9.48131382e-02f, -2.03786939e-01f, 3.18417996e-02f, -1.32014096e-01f, -4.50149179e-02f, -1.46234214e-01f, 4.29223031e-02f,
  -1.14129543e-01f, 1.05742082e-01f, -8.66898596e-02f, 8.63008853e-03f, -1.34151787e-01f, -1.35632828e-01f, 1.41624017e-02f, 4.83026616e-02f, -3.94485425e-03f, 2.15426441e-02f,
  -1.38206901e-02f, 3.35270818e-03f, 5.51048554e-02f, 5.01062013e-02f, -1.20247575e-02f, 2.56604701e-02f, -1.90449300e-05f, -2.29856689e-02f, 1.82436928e-02f, -2.75541637e-02f,
  -2.14131754e-02f, 1.84203777e-02f, 3.07969772e-03f, 3.34622450e-02f, -3.71831283e-02f, 4.23740707e-02f, 6.92930669e-02f, -6.05996102e-02f, -4.94289491e-03f, 3.43677476e-02f,
  3.11936848e-02f, 5.06728701e-02f, -6.17333204e-02f, -7.99493119e-02f, 6.42455649e-03f, -7.66735896e-02f, -1.67304948e-02f, -1.73881222e-02f, -2.30426490e-02f, -2.36272458e-02f,
  1.79906841e-02f, 8.69107433e-04f, 2.37123109e-02f, 9.66718234e-03f, -3.72566804e-02f, 5.52748665e-02f, 3.11322324e-02f, -1.33716483e-02f, -3.61089744e-02f, 1.74404923e-02f,
  -6.21428266e-02f, 5.17294295e-02f, -5.09068780e-02f, -8.43539555e-03f, -4.90106130e-03f, 1.48829194e-02f, 7.32230209e-03f, -8.21054913e-03f, 1.33642880e-02f, -6.90181702e-02f,
  4.16615680e-02f, 2.23460034e-01f, 4.07044925e-02f, 2.91860178e-02f, 6.43179789e-02f, -1.69824958e-02f, 4.70387414e-02f, -2.45934967e-02f, 8.85992963e-03f, 3.39298323e-02f,
  1.32658873e-02f, -2.93124449e-02f, 2.63455976e-02f, -7.73477033e-02f, 9.78642330e-03f, -4.85466085e-02f, 5.12560569e-02f, -2.95715071e-02f, 6.47020177e-04f, -1.93953607e-02f,
  -4.99453284e-02f, -3.01867863e-03f, -2.91664600e-02f, -5.66653125e-02f, -3.59066539e-02f, 2.62966678e-02f, 4.40134741e-02f, 4.82086763e-02f, -1.14677111e-02f, 3.25119644e-02f,
  -1.61257073e-01f, -7.94675425e-02f, 1.50409445e-01f, -1.45346105e-01f, -4.56707552e-02f, 2.09083170e-01f, 3.90233248e-01f, -1.22868128e-01f, 1.10646524e-01f, -2.65943073e-02f,
  7.89822917e-03f, -1.63723767e-01f, 2.78958827e-01f, -2.42290884e-01f, -1.72613747e-02f, 2.45311186e-01f, -9.74432603e-02f, 7.40155764e-03f, -2.80099586e-02f, -1.57433107e-01f,
  3.19209620e-02f, -1.59284025e-01f, -2.08091289e-02f, -1.30151615e-01f, -1.59397900e-01f, -7.52893761e-02f, -2.14776874e-01f, 1.65921062e-01f, -2.48156294e-01f, -1.44652516e-01f,
  -2.50683036e-02f, -1.22511953e-01f, 8.98283347e-03f, 1.44431274e-02f, 1.29886819e-02f, -2.36365367e-02f, 5.18257394e-02f, 2.85941605e-02f, 1.91758864e-03f, 2.81773414e-03f,
  9.00689326e-03f, -9.03157145e-02f, -9.89071429e-02f, 6.30905703e-02f, -1.44574642e-02f, 1.46708209e-02f, -4.51395214e-02f, 3.08521315e-02f, -4.89673018e-02f, 1.94290690e-02f,
  1.14801228e-02f, -8.75925645e-02f, 1.93601847e-02f, -3.53644378e-02f, -1.47646675e-02f, 2.38306616e-02f, 1.44626535e-02f, -5.13697006e-02f, -1.24802822e-02f, -2.67430134e-02f,
  -4.05613966e-02f, 8.97820666e-03f, 6.91019222e-02f, -4.92037460e-02f, -3.01324707e-02f, -2.13582404e-02f, -1.27314767e-02f, -1.43240383e-02f, -2.96774842e-02f, 3.23974602e-02f,
  -1.46000246e-02f, -7.71461707e-03f, -4.30253148e-02f, -1.60874687e-02f, 4.36698459e-02f, 1.20214242e-02f, 2.19489094e-02f, -3.94684933e-02f, 2.89842975e-03f, -3.41086686e-02f,
  -7.25701125e-03f, -3.81930359e-02f, 2.53843293e-02f, 2.40582321e-02f, 6.48253262e-02f, -4.20888886e-03f, -3.94878127e-02f, 1.40566733e-02f, 4.29332256e-02f, 3.31588835e-02f,
  -9.23783146e-03f, -6.11043833e-02f, 7.85851851e-02f, -4.77198660e-02f, 3.79107594e-02f, -5.03295660e-03f, -3.97220366e-02f, -3.53919454e-02f, 3.17128859e-02f, -1.61541998e-02f,
  -5.38296849e-02f, 8.14162940e-02f, -6.52424991e-02f, -8.07235911e-02f, 2.05602217e-02f, -4.57061827e-02f, 2.50353012e-02f, -2.16315836e-02f, 1.42344264e-02f, -6.42193109e-02f,
  -4.79772948e-02f, 2.99690906e-02f, 9.96195897e-03f, 3.03034242e-02f, 6.93134824e-03f, -2.93836780e-02f, 2.70144679e-02f, 5.11815958e-02f, -3.54478247e-02f, 2.69286567e-04f,
  -5.72154950e-03f, -5.22155724e-02f, 3.40351880e-01f, 9.94155630e-02f, -1.66465208e-01f, -2.02726677e-01f, 3.86250578e-02f, -1.30724654e-01f, 1.61461309e-01f, 1.90320797e-02f,
  -1.04296260e-01f, 2.74985075e-01f, 1.41521215e-01f, -2.09627986e-01f, 2.08390336e-02f, -2.14452017e-02f, -6.67424425e-02f, 5.10870628e-02f, -9.07985568e-02f, -4.09544185e-02f,
  -3.66110243e-02f, -2.90875405e-01f, 1.96060967e-02f, -2.59033978e-01f, -3.00400816e-02f, 1.41638502e-01f, 6.34851828e-02f, 1.40251582e-02f, -2.32406259e-02f, -4.66791093e-02f,
  -2.11152196e-01f, 1.12832129e-01f, 9.46552679e-02f, 1.22928694e-01f, 1.05878964e-01f, -1.60723180e-02f, 4.20038588e-02f, 5.65964123e-03f, 4.69613634e-02f, -1.08451373e-03f,
  1.26091540e-01f, 3.28379273e-02f, -3.78563441e-02f, -1.05184224e-02f, -6.67845085e-02f, 1.43134454e-02f, -2.86919228e-03f, 2.26057321e-03f, 4.60391566e-02f, -4.16456722e-02f,
  1.09083503e-02f, 2.61487532e-02f, 5.69655746e-03f, 3.16729280e-03f, 4.18914370e-02f, 5.25972433e-03f, 8.42882693e-02f, 1.84039399e-02f, 7.14384252e-03f, -6.05422407e-02f,
  -1.87126677e-02f, -3.40170390e-03f, -4.48508374e-02f, -2.67205406e-02f, -6.65099025e-02f, -1.74893867e-02f, -2.95839310e-02f, 6.40675649e-02f, -4.41099517e-02f, -1.87602956e-02f,
  -5.98553158e-02f, 2.46109851e-02f, 7.82222580e-03f, -5.15355077e-03f, 2.40088273e-02f, 3.16617601e-02f, 3.16807139e-03f, 1.61770396e-02f, -5.77381700e-02f, -6.78849127e-03f,
  5.34454500e-03f, -6.70704916e-02f, 5.47622070e-02f, -5.44930324e-02f, -8.06202888e-02f, 4.91223373e-02f, -2.84466315e-02f, -5.10109887e-02f, -8.32720101e-03f, -5.73477037e-02f,
  1.73973162e-02f, 9.43152830e-02f, -6.46574497e-02f, 2.99069863e-02f, -4.02836651e-02f, -3.23452987e-02f, 2.26258878e-02f, -9.07150730e-02f, 1.77959204e-02f, -2.06481051e-02f,
  -2.87421104e-02f, 8.01632851e-02f, -2.16993298e-02f, -1.59405004e-02f, 6.90433607e-02f, -6.97870553e-02f, 2.69708000e-02f, 8.00233558e-02f, -3.48632922e-03f, 5.10119162e-02f,
  5.45916036e-02f, -3.05665396e-02f, 6.40177801e-02f, 3.08618210e-02f, -2.95166932e-02f, 6.03825413e-02f, -5.55706844e-02f, 3.90607193e-02f, -2.64669228e-02f, 9.03509185e-02f,
  -4.21180904e-01f, 4.44150828e-02f, -2.29794294e-01f, -2.62302719e-02f, -2.12899357e-01f, -2.51657963e-01f, -2.24389493e-01f, -2.61843670e-02f, -1.45141721e-01f, 3.88111062e-02f,
  -1.23272324e-02f, -1.71451330e-01f, 3.77787165e-02f, 1.05950460e-01f, -9.73873734e-02f, 1.63929909e-01f, 1.20812999e-02f, -1.05236724e-01f, 1.17647663e-01f, -8.64446387e-02f,
  -8.01491830e-03f, 1.34635910e-01f, 2.21233830e-01f, 2.26649508e-01f, -1.20160736e-01f, 9.51159820e-02f, 1.17896877e-01f, 4.15235609e-02f, 7.40545616e-02f, 6.17237873e-02f,
  -1.59052402e-01f, -1.15711279e-02f, -1.87131211e-01f, 2.80433632e-02f, -1.09558865e-01f, -1.36283875e-01f, -8.28937069e-02f, 5.20446571e-03f, 4.90534976e-02f, -5.25723435e-02f,
  -6.07734993e-02f, -4.86555248e-02f, 1.91253908e-02f, 1.03629157e-02f, 3.22304200e-03f, -2.64217164e-02f, -2.86959521e-02f, -2.12146845e-02f, 3.38926911e-02f, -3.72854844e-02f,
  -1.78887900e-02f, 8.63008760e-03f, 1.30176181e-02f, 5.16586043e-02f, 6.76081807e-04f, 3.50969173e-02f, 1.49195390e-02f, -4.09984030e-04f, -7.53308907e-02f, -5.94328120e-02f,
  5.98084070e-02f, 8.24487302e-03f, -3.34397703e-02f, -3.24860178e-02f, 2.99963430e-02f, -1.04068704e-02f, 5.91676170e-03f, 3.48655172e-02f, 4.31241728e-02f, 6.02470944e-04f,
  2.50231326e-02f, -3.88519280e-02f, 3.55763249e-02f, 1.69843191e-03f, 2.76642502e-03f, -2.78176330e-02f, -1.60169285e-02f, 7.18553038e-03f, -4.43399884e-02f, 5.71962707e-02f,
  -3.07208183e-03f, 5.44257974e-03f, 2.12520268e-03f, 3.96416197e-03f, -9.87873320e-03f, -6.96788030e-03f, 1.67336017e-02f, -1.21933278e-02f, -2.25299988e-02f, -7.47227762e-03f,
  -2.08297893e-01f, -5.53109078e-03f, 3.00330594e-02f, -4.19910178e-02f, -2.14039385e-02f, -3.99842858e-03f, 8.37378353e-02f, -3.21845561e-02f, 2.50998400e-02f, 1.37419468e-02f,
  -5.84461577e-02f, 4.34065796e-02f, -3.86397541e-02f, 7.30956066e-03f, -3.31804603e-02f, -3.55865210e-02f, -2.79842280e-02f, -1.82373300e-02f, -6.71530217e-02f, 1.76702831e-02f,
  -7.11627305e-02f, -5.71066998e-02f, 4.08311449e-02f, -1.72806010e-02f, 6.20178878e-03f, -2.73485370e-02f, -5.20747080e-02f, -3.40609858e-03f, 1.71281006e-02f, -8.89032893e-03f,
  -1.91950902e-01f, -2.88364470e-01f, -3.11632156e-01f, -1.50128633e-01f, 9.51040015e-02f, -1.68905091e-02f, 4.88027334e-02f, -3.04985214e-02f, -2.96457231e-01f, 1.65379494e-01f,
  2.46018663e-01f, -2.72418350e-01f, -9.45361797e-03f, 9.38492119e-02f, -1.19072191e-01f, 9.64032952e-03f, -4.94468324e-02f, 4.80713360e-02f, -1.42631784e-01f, -1.39766350e-01f,
  3.01079650e-04f, 2.91284531e-01f, -1.07754439e-01f, 1.53869823e-01f, 2.64797900e-02f, -1.21781886e-01f, 2.60717779e-01f, -7.55613903e-03f, 1.50465548e-01f, 1.36702582e-01f,
  1.30669642e-02f, 2.50073033e-03f, 1.95922107e-02f, -8.68718177e-02f, 3.50216706e-03f, 4.69099320e-02f, 2.51432918e-02f, 3.57511714e-02f, 1.50240585e-02f, -2.42588595e-02f,
  -4.04343307e-02f, 7.16453325e-03f, -1.62341204e-02f, 1.64806098e-02f, -6.14122003e-02f, -5.05703203e-02f, -8.94179102e-03f, -1.08018620e-02f, -9.19182673e-02f, 1.03267701e-03f,
  -8.23582560e-02f, -1.39468126e-02f, -2.48938203e-02f, -1.46700372e-03f, -9.18984264e-02f, 1.61740780e-02f, -4.86626010e-03f, -4.55301479e-02f, 9.16618761e-03f, -6.96185231e-02f,
  2.05402039e-02f, -3.29073183e-02f, 3.26997750e-02f, 4.75846510e-03f, 3.96344848e-02f, 9.62201655e-02f, -1.17812166e-02f, 6.35893270e-02f, -2.49337349e-02f, 4.48059589e-02f,
  2.11538896e-02f, -5.99818258e-03f, 3.08700558e-02f, 8.15805420e-03f, 6.66928142e-02f, -3.39915454e-02f, 3.55060436e-02f, 2.45951489e-02f, -3.88437063e-02f, -2.10147724e-02f,
  5.45989722e-02f, -1.91189554e-02f, 3.92716937e-02f, 4.80068214e-02f, 5.37202992e-02f, -1.07723277e-03f, 2.45871581e-02f, -3.26899588e-02f, 7.60573801e-03f, 3.84063013e-02f,
  -6.73312247e-02f, -1.40769735e-01f, -5.00300303e-02f, 2.21859738e-02f, 1.89160872e-02f, 1.57700535e-02f, -1.35165853e-02f, -2.73659676e-02f, -8.76073763e-02f, -1.31117795e-02f,
  7.63281714e-03f, -6.42473437e-03f, 3.42582427e-02f, 1.05614979e-02f, 1.04048969e-02f, 4.58193198e-02f, 8.08207411e-03f, 4.75328369e-03f, 6.35274127e-02f, -7.52719992e-04f,
  2.67401468e-02f, 3.90276499e-02f, 2.26364173e-02f, 1.14036901e-02f, 6.05870076e-02f, 4.50671650e-02f, -1.47693930e-02f, -4.02069017e-02f, 4.65256460e-02f, 9.09518450e-03f,
  1.64036632e-01f, -4.25738901e-01f, -1.33511260e-01f, -1.68520868e-01f, 2.61550486e-01f, -1.82531998e-01f, -2.30152667e-01f, -1.24509437e-02f, 7.74212852e-02f, -9.74152759e-02f,
  -1.93455089e-02f, -2.23837122e-01f, -2.03847259e-01f, -1.72407225e-01f, -1.89325377e-01f, -2.01599851e-01f, -2.28973180e-01f, -1.72459647e-01f, 6.19389042e-02f, -1.17922261e-01f,
  3.85629497e-02f, -6.70314729e-02f, -1.53186008e-01f, 4.12536152e-02f, 1.47576770e-02f, 1.48766218e-02f, 7.16447383e-02f, 1.05409443e-01f, -7.96982720e-02f, 3.11231147e-02f,
  6.89615235e-02f, -5.15336022e-02f, -4.51968843e-03f, -9.01363697e-03f, -6.21434934e-02f, 3.70687507e-02f, -6.63992614e-02f, -2.71213409e-02f, 6.35535046e-02f, -7.02441379e-04f,
  -1.89167392e-02f, 2.94814259e-02f, 6.31691217e-02f, 1.36250108e-02f, 7.63844475e-02f, -1.58185642e-02f, 2.29553375e-02f, 5.77914864e-02f, -1.37550635e-02f, -3.65617797e-02f,
  -2.67828833e-02f, -3.88054885e-02f, 1.40013127e-02f, -8.47124681e-02f, 3.24228331e-02f, 3.41365859e-02f, -2.93072090e-02f, -6.51976168e-02f, -5.87436520e-02f, -2.47754194e-02f,
  -3.24596688e-02f, -1.43208811e-02f, -1.15951244e-02f, 1.12869851e-02f, -1.42603181e-02f, -3.80956731e-03f, -6.06187014e-03f, 1.83426291e-02f, 2.76346002e-02f, -5.76571636e-02f,
  6.96670189e-02f, -5.68517074e-02f, 3.71387973e-02f, 2.52922438e-02f, -3.79200131e-02f, 1.20101338e-02f, -1.12695461e-02f, -5.07121123e-02f, -8.78081424e-04f, 1.28989415e-02f,
  -8.18903465e-03f, -3.99593450e-02f, 4.71773604e-03f, 3.34986262e-02f, -3.10908183e-02f, 2.83041294e-03f, 1.77715905e-02f, 1.80467602e-03f, 4.24118899e-02f, -2.68054921e-02f,
  -1.75386071e-01f, -3.36296767e-01f, -1.11450013e-02f, -4.46228543e-03f, -3.56230401e-02f, -1.95952486e-02f, 6.61312090e-03f, -8.46578088e-03f, -1.31558487e-02f, -2.83261873e-02f,
  -3.32950219e-03f, -2.67061777e-03f, -3.85398306e-02f, -5.04290825e-03f, -3.34121287e-02f, 2.70731514e-03f, -5.10825850e-02f, -9.07323323e-03f, -3.27345580e-02f, -3.85827385e-02f,
  -6.76081190e-03f, -2.49918364e-02f, -1.51867568e-02f, 5.68311960e-02f, -6.17927387e-02f, -1.04901325e-02f, -3.62742133e-02f, 5.08398674e-02f, -6.88001066e-02f, -3.66442576e-02f,
  -2.66716722e-03f, -5.88470921e-02f, -9.43769068e-02f, 1.89996451e-01f, -7.79440999e-02f, 1.78393275e-01f, 2.43044704e-01f, -1.94942877e-01f, 4.54923846e-02f, 2.28851184e-01f,
  -4.45783464e-03f, 8.32654238e-02f, -1.03961848e-01f, 2.55116940e-01f, 4.13052663e-02f, 2.16794126e-02f, 3.17190349e-01f, 3.05545419e-01f, -4.10137959e-02f, -2.09817104e-02f,
  6.59046844e-02f, 8.73081163e-02f, -7.57757761e-03f, -1.55169219e-01f, 3.75140682e-02f, -1.16582386e-01f, -2.33707279e-02f, -1.98164746e-01f, 9.15142149e-02f, 6.34341326e-04f,
  8.74449685e-02f, -1.40560074e-02f, 2.38254126e-02f, 7.26317763e-02f, 1.80282257e-02f, 8.64554644e-02f, 9.63972881e-02f, -3.14225331e-02f, 3.92825678e-02f, 3.04007661e-02f,
  6.77528530e-02f, -5.94890639e-02f, 6.61517531e-02f, -1.60985291e-02f, 3.39438915e-02f, 2.51752120e-02f, 2.06770375e-02f, 1.81460120e-02f, 2.12099310e-02f, -1.04294932e-02f,
  3.20312344e-02f, 8.14597309e-02f, 3.91617827e-02f, 7.08480030e-02f, -4.55134213e-02f, 7.80724967e-03f, 7.83114657e-02f, 3.77521738e-02f, 2.05229111e-02f, 2.15712134e-02f,
  -7.32567385e-02f, 9.92316753e-03f, 1.47589603e-02f, -4.33968492e-02f, -2.59310119e-02f, 2.46872883e-02f, 1.75455250e-02f, -3.39621864e-02f, 1.90898646e-02f, -4.50988971e-02f,
  4.51638885e-02f, -1.02507500e-02f, -3.64739485e-02f, 3.79012078e-02f, 5.51042520e-02f, -6.87135896e-03f, -5.22350185e-02f, 6.22089161e-03f, 1.83423795e-02f, 2.69682389e-02f,
  -1.84017867e-02f, -1.66909758e-03f, 3.52872512e-03f, 5.21558672e-02f, -8.22803751e-03f, -5.10367416e-02f, -2.90662628e-02f, 8.99079815e-03f, 3.74641083e-02f, 3.32800811e-03f,
  3.48360762e-02f, -1.27913013e-01f, -3.52426246e-02f, -3.84146236e-02f, 3.48628722e-02f, 6.38604444e-03f, 7.34446719e-02f, -1.02732293e-02f, -8.02316517e-02f, -4.46167290e-02f,
  5.32921730e-03f, 5.27189635e-02f, 2.72580087e-02f, -4.72693667e-02f, 1.68075114e-02f, -7.61705711e-02f, 5.17444573e-02f, 5.11415266e-02f, 7.69199952e-02f, -6.80280477e-02f,
  4.15185379e-04f, -3.60122807e-02f, 1.22287013e-02f, -1.46108614e-02f, 6.73026070e-02f, -1.19788740e-02f, -5.67368269e-02f, -1.65651471e-03f, 6.63544517e-03f, -2.01018695e-02f,
  -6.67757466e-02f, 1.31460011e-01f, 2.70895213e-01f, 3.35835442e-02f, -4.58026603e-02f, -1.47256330e-01f, -6.78758919e-02f, -6.98037222e-02f, -1.32880583e-01f, -3.99060361e-02f,
  -1.53049394e-01f, 2.03915443e-02f, -4.88433652e-02f, -2.52727926e-01f, -3.20144713e-01f, -1.77208290e-01f, -2.98441071e-02f, -1.40364340e-03f, -1.89767405e-02f, 6.62505031e-02f,
  -1.81616269e-04f, -2.76690274e-01f, 1.38734076e-02f, -1.05463885e-01f, 3.64133082e-02f, 1.39663130e-01f, 2.15563271e-02f, 2.56535746e-02f, 5.38796745e-02f, -7.74333403e-02f,
  -4.48497012e-02f, -1.05848711e-03f, 7.33180046e-02f, -5.29877283e-02f, 2.56222077e-02f, 1.06559522e-01f, 1.10870034e-01f, -8.12781677e-02f, 1.50055708e-02f, 2.73364056e-02f,
  3.72040421e-02f, -3.41019519e-02f, -2.99975816e-02f, -4.70992550e-02f, 6.22374099e-03f, 5.69782294e-02f, -8.35821382e-04f, 1.04238488e-01f, 1.24570681e-02f, 1.78857613e-02f,
  8.73940066e-02f, 1.16814390e-01f, 7.05827400e-02f, -9.53116361e-03f, 1.98027049e-03f, 2.95087416e-03f, 5.19082211e-02f, 6.71884194e-02f, 4.49336804e-02f, -5.58790676e-02f,
  4.83567407e-03f, 4.20018844e-02f, -1.34452302e-02f, -3.87837887e-02f, 1.21034624e-03f, 1.13161542e-02f, 1.70499925e-02f, -5.00057004e-02f, 5.03615774e-02f, -4.26520742e-02f,
  -6.49262685e-03f, 2.48945411e-02f, -1.36232097e-02f, 1.24791125e-03f, 3.35463397e-02f, 4.46193246e-03f, 3.53074223e-02f, -6.36989437e-03f, 2.80821472e-02f, 3.37832645e-02f,
  -2.80046891e-02f, -7.67318625e-03f, -4.48138714e-02f, 5.14380224e-02f, -4.05062884e-02f, -3.71614955e-02f, -4.89240810e-02f, 1.14583224e-03f, 4.51205969e-02f, 7.25743547e-02f,
  1.47821885e-02f, 5.05321994e-02f, -2.88558993e-02f, 3.99969742e-02f, 5.25888652e-02f, 5.61427884e-02f, -7.92828798e-02f, -4.74718325e-02f, -8.82768035e-02f, -7.36537650e-02f,
  5.18207066e-02f, 6.71475083e-02f, -5.42873889e-03f, 3.11910012e-03f, 3.67777399e-03f, -5.13910726e-02f, 3.34520787e-02f, 1.31183704e-02f, 2.73936111e-02f, 8.38048011e-02f,
  3.48714329e-02f, -2.05374025e-02f, 1.99948978e-02f, 4.33201827e-02f, -5.93381282e-03f, 2.66106166e-02f, 2.30670813e-02f, -1.96338980e-03f, 3.17988396e-02f, -2.38266867e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.52545691e-02f, 8.47304463e-02f, 3.86253092e-03f, -3.29767913e-02f, -2.27644220e-02f, 2.50142328e-02f, -4.13201377e-02f, -5.23845218e-02f, -5.93688898e-02f, 3.09034996e-03f,
  -5.26621155e-02f, 8.17050412e-02f, -1.88187342e-02f, 1.07297614e-01f, 3.91331874e-02f, -5.06826583e-03f, 6.76536188e-02f, 1.16250865e-01f, 5.67017272e-02f, 8.41971114e-02f,
  1.04851395e-01f, -1.43285678e-03f, 1.58063576e-01f, 1.36784568e-01f, 1.04734987e-01f, 2.30053682e-02f, -3.55645944e-03f, -3.01741064e-02f, 7.18152225e-02f, 3.57386172e-02f,
  8.42699781e-02f, 4.49035391e-02f, 9.45205465e-02f, 8.42951313e-02f, 3.49870883e-02f, -5.21561168e-02f, -3.41452546e-02f, 5.83792143e-02f, -4.11790470e-03f, -2.96309311e-02f,
  3.75466794e-02f, 8.75659138e-02f, -1.07346531e-02f, 2.27888674e-02f, -8.83564912e-03f, 2.91562993e-02f, 1.02971762e-01f, 7.60382414e-02f, -5.75905889e-02f, 3.87719087e-02f,
  2.07259133e-02f, 5.17583899e-02f, 3.00594047e-02f, 2.60418095e-02f, -1.12991035e-02f, -3.37800793e-02f, -6.34522438e-02f, -1.39653301e-02f, 7.84535855e-02f, 6.63335100e-02f,
  1.21252947e-01f, -6.18160702e-02f, -1.10163413e-01f, 5.38788997e-02f, 2.72017270e-02f, -7.23260716e-02f, 4.11996990e-02f, 6.42614737e-02f, 3.29309292e-02f, 1.30711459e-02f,
  -8.83211195e-02f, 5.55497259e-02f, -7.67396018e-02f, 1.75165255e-02f, 2.35406719e-02f, -2.01047510e-02f, -5.00597209e-02f, 5.07064126e-02f, -5.09420596e-02f, 1.14501826e-02f,
  5.54270856e-02f, -7.61244521e-02f, 7.97414780e-03f, -8.76835734e-02f, -2.75550950e-02f, -2.57450789e-02f, 6.24723770e-02f, -5.51834842e-03f, 7.39593655e-02f, -1.24082556e-02f,
  -3.11923474e-02f, 8.97668079e-02f, 2.42302231e-02f, -6.47962838e-02f, 7.36735482e-03f, 1.42218573e-02f, -5.14011569e-02f, 8.56815800e-02f, 8.03561211e-02f, 1.19954525e-02f,
  5.15793562e-02f, 1.01838298e-02f, 1.02308042e-01f, 4.79024388e-02f, -3.71413082e-02f, 6.03385158e-02f, -5.70332110e-02f, 7.32393935e-02f, -5.72837405e-02f, -2.11540777e-02f,
  -4.83240150e-02f, -2.02949513e-02f, 4.08429913e-02f, -5.94565645e-02f, 3.83416265e-02f, -3.24448966e-03f, 9.64081287e-02f, 7.37728998e-02f, 6.17505275e-02f, 2.56836824e-02f,
  6.52758628e-02f, -1.13531975e-02f, 1.07792661e-01f, 1.21886440e-01f, -1.29691511e-01f, -6.42398894e-02f, -1.87796712e-01f, -1.01249643e-01f, -5.42400144e-02f, -1.17237993e-01f,
  -1.44098222e-01f, 2.52831072e-01f, -3.82731259e-01f, 1.68507487e-01f, -7.01070875e-02f, -1.73677489e-01f, 1.99681167e-02f, 1.06142215e-01f, -3.10433330e-03f, 5.03748562e-03f,
  1.81377791e-02f, -2.77779866e-02f, 7.65311792e-02f, 7.41909221e-02f, 4.86751571e-02f, 5.97502440e-02f, 9.13012251e-02f, -5.54757006e-03f, 3.06759894e-01f, 1.31957158e-01f,
  -1.11898780e-01f, -4.19598930e-02f, 4.36094403e-02f, 8.31033438e-02f, -2.65445095e-02f, -2.90817302e-02f, 9.11770314e-02f, -1.53372353e-02f, -2.68216413e-02f, 3.16170752e-02f,
  1.75647456e-02f, -5.89305907e-03f, 1.86150596e-01f, 6.88349605e-02f, 3.31278914e-03f, 1.05757937e-01f, 4.77585420e-02f, -8.03854782e-03f, 4.15636078e-02f, -4.93945181e-02f,
  1.03075374e-02f, 2.20204387e-02f, -3.04768775e-02f, 1.18856810e-01f, -3.29113603e-02f, 2.29973122e-02f, 3.01572494e-02f, 2.90167760e-02f, 1.45435393e-01f, 7.37536550e-02f,
  6.91154823e-02f, 5.54538285e-03f, -2.08200067e-02f, 7.67419040e-02f, 2.45100074e-02f, -9.82032530e-03f, -5.39662726e-02f, 3.48090604e-02f, 4.13182154e-02f, -4.75862473e-02f,
  1.65989231e-02f, -4.87746373e-02f, 4.95557562e-02f, -1.08398218e-02f, -5.51731996e-02f, 6.79536760e-02f, -5.74865611e-03f, -4.50960658e-02f, 2.53745206e-02f, -2.82991137e-02f,
  -6.36076778e-02f, 3.69669534e-02f, -2.24486273e-02f, -6.21016994e-02f, 3.14300247e-02f, -5.97518869e-02f, 1.29112331e-02f, 5.06696925e-02f, -4.16255295e-02f, 1.79498922e-02f,
  -1.83408737e-01f, -5.91720305e-02f, -4.14818376e-02f, -6.13811053e-03f, 6.19071396e-03f, 3.91671881e-02f, 1.48902182e-02f, 2.97374129e-02f, -4.81630526e-02f, -6.62179217e-02f,
  -3.20918933e-02f, 5.06992452e-02f, -2.70479731e-02f, 2.70812288e-02f, 9.18618143e-02f, 3.71621698e-02f, 4.62429412e-02f, 2.31821067e-03f, 1.93590131e-02f, 4.68154512e-02f,
  -8.18975968e-04f, -8.76191631e-02f, 4.39077765e-02f, 6.39837421e-03f, 3.22325081e-02f, -3.56201157e-02f, 5.43249324e-02f, 5.36613958e-03f, 8.17403644e-02f, 4.64548618e-02f,
  -1.35230109e-01f, -1.41599685e-01f, 1.38344422e-01f, -3.73409316e-02f, 7.42534772e-02f, 2.26458665e-02f, 7.25964876e-03f, -5.79794459e-02f, -3.42305213e-01f, -2.20781192e-01f,
  -1.89403161e-01f, -7.52558932e-02f, -2.60212496e-02f, 1.89078618e-02f, 2.15930104e-01f, 5.51938713e-02f, -2.71103363e-02f, 8.82909074e-02f, 2.89351237e-03f, 2.39019878e-02f,
  2.25308314e-01f, 3.58629003e-02f, 3.16757768e-01f, 1.58679008e-01f, 1.14443921e-01f, 8.81948695e-02f, 1.21668614e-01f, 2.93383688e-01f, 1.09745495e-01f, 1.49702996e-01f,
  -3.57164294e-02f, -1.55785143e-01f, 6.75971359e-02f, -6.37898147e-02f, -4.30538505e-02f, 2.83319969e-04f, 1.43462466e-02f, 1.24858946e-01f, 6.82511702e-02f, 7.10645970e-03f,
  6.83362260e-02f, 6.94722161e-02f, -3.45144011e-02f, 6.51832670e-02f, -8.80287495e-03f, 1.91970654e-02f, 9.67238322e-02f, -7.86996335e-02f, -3.38654332e-02f, 6.07718118e-02f,
  2.75532268e-02f, 4.79929373e-02f, -3.91686196e-03f, 6.67812228e-02f, 3.17564756e-02f, 1.68892443e-02f, -6.98887091e-03f, 2.15060767e-02f, -2.18667053e-02f, -2.04116367e-02f,
  -1.33360727e-02f, 5.66292219e-02f, 2.69391853e-02f, -1.09585812e-02f, 3.45006324e-02f, -1.17347054e-02f, -1.52621241e-02f, -6.08707182e-02f, -3.83113697e-02f, 5.01445532e-02f,
  -6.68511465e-02f, -6.65559620e-02f, 1.99882742e-02f, -6.20901177e-04f, 6.99208900e-02f, -7.59881064e-02f, 1.15953006e-01f, 2.32155900e-02f, 1.20614339e-02f, 1.62824281e-02f,
  2.16081887e-02f, 5.69834113e-02f, -7.78788701e-02f, 1.14561543e-02f, 6.85717613e-02f, 7.46745244e-02f, -2.78787147e-02f, -8.90819915e-03f, 3.69831659e-02f, 7.11179674e-02f,
  1.07336855e-02f, -2.06211209e-02f, -7.10301027e-02f, 1.50275892e-02f, 3.45097333e-02f, 5.88161908e-02f, -1.63505729e-02f, -6.64477497e-02f, 4.42071408e-02f, -6.52870536e-02f,
  -5.58882877e-02f, 8.36241692e-02f, -5.31379431e-02f, 4.58462909e-02f, 1.32226758e-02f, -9.07453448e-02f, -7.83347152e-03f, -5.47604971e-02f, -4.60582227e-02f, 7.82359485e-03f,
  -4.40137368e-03f, -4.68800068e-02f, 5.41093349e-02f, -4.12194543e-02f, -3.33004147e-02f, -1.15967274e-01f, -4.77500260e-02f, 4.55702953e-02f, 5.65592200e-02f, 1.92239415e-02f,
  -9.80711579e-02f, 1.42420381e-01f, 1.16183259e-01f, 1.17329285e-02f, -3.38764535e-03f, -1.79437786e-01f, -1.17563233e-01f, 1.13060065e-01f, -5.71499951e-02f, 9.59172621e-02f,
  -5.11544161e-02f, -1.17113270e-01f, 4.94204573e-02f, -9.06450301e-02f, -1.03731729e-01f, -8.87220949e-02f, -2.63821688e-02f, -1.26457229e-01f, 4.69898358e-02f, 1.93642944e-01f,
  1.36518821e-01f, 4.24752869e-02f, 1.32838801e-01f, 1.74439400e-01f, 5.34621887e-02f, 2.21772432e-01f, 2.21151203e-01f, 1.23730041e-01f, 9.59661091e-04f, -6.10775314e-02f,
  -5.58886640e-02f, 7.52642676e-02f, -1.01963291e-02f, -1.03905902e-03f, 1.21625520e-01f, -8.78399387e-02f, -8.29802454e-02f, 6.28455169e-03f, -1.67133901e-02f, 4.47180122e-02f,
  3.43170464e-02f, 1.93875190e-02f, -5.94898546e-03f, 2.14728322e-02f, -5.48677780e-02f, 4.37376648e-02f, 2.47812681e-02f, 1.58773232e-02f, 9.12559479e-02f, -8.68869573e-02f,
  1.98829807e-02f, -6.85983151e-02f, -6.39001578e-02f, -3.84164415e-02f, 3.25489119e-02f, 3.26317623e-02f, 1.79999005e-02f, 3.37713659e-02f, -6.78219274e-02f, -5.46779558e-02f,
  8.17471147e-02f, -8.16186797e-03f, -4.63633426e-02f, -9.08696800e-02f, -7.41992593e-02f, -2.96704452e-02f, -5.94118014e-02f, -2.73120832e-02f, 2.01442391e-02f, 5.40961337e-04f,
  6.79533705e-02f, -4.11020406e-02f, 9.96896531e-03f, 2.36873869e-02f, 4.95875031e-02f, -5.55779524e-02f, -4.14463170e-02f, 4.27931659e-02f, -9.06393165e-04f, -3.76675203e-02f,
  6.11938052e-02f, -4.69173305e-02f, 1.15844829e-03f, 3.98483835e-02f, -7.86597654e-02f, -3.15824747e-02f, -4.27719690e-02f, 6.01213705e-03f, 3.36632915e-02f, 5.71601950e-02f,
  1.35650665e-01f, 2.38773704e-01f, 1.24978498e-01f, -3.83965496e-04f, 8.63592178e-02f, -1.03354521e-01f, 1.77936349e-02f, 1.94928292e-02f, 1.20508112e-01f, -1.41975060e-02f,
  -5.47559895e-02f, -3.38481367e-02f, -2.69678552e-02f, 5.72374091e-02f, -3.96212116e-02f, 2.77594887e-02f, 4.24696244e-02f, 6.92619830e-02f, 6.42456487e-02f, 8.00156295e-02f,
  1.28571689e-01f, -7.08307475e-02f, -1.61726531e-02f, 2.12187972e-02f, 8.39871466e-02f, 8.39972198e-02f, -5.72057925e-02f, 8.16617906e-02f, 5.56763709e-02f, -6.09301031e-02f,
  6.30805567e-02f, -2.61977404e-01f, -1.61774322e-01f, -5.43726496e-02f, 1.56289771e-01f, 2.15710878e-01f, 1.13503397e-01f, -1.29683539e-01f, -3.07599485e-01f, 5.14873257e-03f,
  1.36931047e-01f, -9.54114422e-02f, -9.48168784e-02f, -4.64517958e-02f, -4.00546193e-02f, -1.19133644e-01f, -5.82663203e-03f, -1.81918871e-02f, -1.86235324e-01f, 2.75536273e-02f,
  9.77100711e-03f, 7.69734904e-02f, -1.03209838e-01f, 7.94840902e-02f, 4.22577597e-02f, 1.07080050e-01f, 1.74099237e-01f, 5.27046993e-02f, 1.28497601e-01f, 1.49498612e-01f,
  3.22768465e-02f, -5.62944785e-02f, -1.11347310e-01f, -6.07342608e-02f, 3.35835367e-02f, 1.03473023e-01f, 1.35664687e-01f, 1.81352720e-02f, -1.62294917e-02f, -2.79656053e-02f,
  7.80502260e-02f, -7.13342009e-03f, -1.13582071e-02f, -7.69228563e-02f, -8.73955563e-02f, -2.35112887e-02f, -1.32357061e-01f, -1.16175391e-01f, -1.23143151e-01f, -3.34958099e-02f,
  -4.62374128e-02f, 2.23774947e-02f, -7.37333670e-02f, 2.95780413e-02f, 1.39633920e-02f, 1.38971778e-02f, -1.20775364e-02f, 1.11551538e-01f, -5.90408444e-02f, 7.19566941e-02f,
  8.21657032e-02f, 1.31893679e-02f, -3.70051265e-02f, -9.80461463e-02f, -2.14399677e-03f, -5.84121421e-02f, -5.22008054e-02f, -1.17123164e-02f, 2.25592051e-02f, -4.82494533e-02f,
  -3.44818942e-02f, -7.86298364e-02f, 1.46842496e-02f, 3.16207968e-02f, 8.88723731e-02f, 1.47252949e-02f, 2.28077956e-02f, 1.76489893e-02f, 5.58879077e-02f, -7.12881312e-02f,
  -1.12650171e-01f, 6.36322871e-02f, 4.13933098e-02f, 1.42622935e-02f, -3.82020399e-02f, -3.78046408e-02f, 7.13646337e-02f, 2.15461683e-02f, -5.12751341e-02f, 4.93210666e-02f,
  1.17050178e-01f, 1.06030300e-01f, 8.70765094e-03f, 2.89726369e-02f, -5.83499111e-03f, 8.18111449e-02f, 3.59745249e-02f, -3.05048581e-02f, -1.57233682e-02f, -7.30310380e-03f,
  5.80853559e-02f, -3.43122929e-02f, 9.90500376e-02f, -3.03563680e-02f, -9.73017700e-03f, -1.07310154e-02f, 1.10209718e-01f, 4.57175747e-02f, -2.79596820e-02f, 7.88650736e-02f,
  5.12795988e-03f, 5.31434193e-02f, 8.15527420e-03f, -5.04069217e-03f, -1.27757797e-02f, 4.55395356e-02f, 1.11896850e-01f, 1.72723997e-02f, -1.03055835e-01f, -5.27033359e-02f,
  7.17375726e-02f, -9.70873535e-02f, -1.64946333e-01f, -1.53799713e-01f, -1.06081255e-01f, -1.52254298e-01f, -3.23149920e-01f, -1.88852802e-01f, -1.11929618e-01f, -9.05513987e-02f,
  -1.68826491e-01f, -8.69649202e-02f, 1.66762188e-01f, -1.90320268e-01f, 4.40879241e-02f, 1.96331844e-01f, -1.72973379e-01f, -1.25186011e-01f, 2.51741894e-02f, -1.23068690e-01f,
  3.72799262e-02f, -1.16211213e-01f, -1.65230297e-02f, -1.36250973e-01f, -2.17762932e-01f, -1.63727820e-01f, 1.81912873e-02f, -8.79628062e-02f, -1.07790574e-01f, -1.13015503e-01f,
  2.65728012e-02f, 3.09253987e-02f, -4.74820286e-02f, 5.19490093e-02f, 3.04817911e-02f, -5.41237590e-04f, 8.72491393e-03f, -3.98265608e-02f, -6.21560812e-02f, -9.79109108e-02f,
  3.76881137e-02f, 6.12125136e-02f, -1.10790439e-01f, 8.62661228e-02f, 1.81832258e-02f, -2.49121431e-02f, -9.66348220e-03f, -4.09018919e-02f, -9.66695696e-02f, 7.93763027e-02f,
  -4.50878106e-02f, -8.07033032e-02f, -4.87702936e-02f, -5.25241643e-02f, 2.24741865e-02f, 3.59198563e-02f, 4.83222231e-02f, 1.72289368e-02f, -7.79326707e-02f, 6.12217039e-02f,
  5.37625700e-02f, -5.13250753e-02f, 4.40018019e-03f, 3.81742939e-02f, -1.37466993e-02f, -3.92848738e-02f, 4.14327942e-02f, -3.83517258e-02f, 8.93971510e-03f, 1.28250697e-03f,
  5.89533001e-02f, 1.08859455e-03f, 1.24940863e-02f, 5.20910881e-02f, -4.86291237e-02f, 3.00131813e-02f, -7.73938596e-02f, 2.74808556e-02f, -4.07479927e-02f, -1.33594582e-02f,
  7.73219541e-02f, -4.38689031e-02f, -1.45476321e-02f, 4.03115638e-02f, -5.42792529e-02f, -7.14480579e-02f, -3.80799696e-02f, 4.76165041e-02f, 7.59033160e-03f, 1.22903232e-02f,
  -6.68220147e-02f, -9.54325944e-02f, -1.60402916e-02f, -6.36709034e-02f, 2.13918067e-03f, 9.99364187e-04f, -9.23976942e-04f, -1.73746608e-02f, -5.95056079e-02f, 2.87156980e-02f,
  3.05878520e-02f, -2.18997374e-02f, -8.01649764e-02f, 3.62519473e-02f, -4.96696457e-02f, -4.38251495e-02f, 3.75802331e-02f, 5.78960925e-02f, -6.17902679e-03f, -5.36446460e-02f,
  1.99620314e-02f, 3.77352275e-02f, 7.57711008e-02f, 1.95573084e-02f, -1.91478860e-02f, -1.16088860e-01f, 1.22961560e-02f, 3.30801047e-02f, 5.62116131e-02f, 2.85246167e-02f,
  2.02473521e-01f, -1.10065062e-02f, -2.51629144e-01f, -1.77456155e-01f, -1.26212716e-01f, -4.07070518e-02f, 3.38423364e-02f, -2.23148428e-03f, 1.51243478e-01f, 1.14209481e-01f,
  -6.95066005e-02f, 7.06093460e-02f, 8.42418671e-02f, 2.42625177e-02f, 2.63131618e-01f, 3.47410113e-01f, 2.05482051e-01f, 1.80688664e-01f, 5.05955964e-02f, -6.52028695e-02f,
  -4.91022058e-02f, 4.75875027e-02f, -1.64216742e-01f, -1.21128969e-01f, -1.47137910e-01f, -1.78976923e-01f, -7.33684748e-04f, -2.55457133e-01f, -1.42448306e-01f, 5.15221581e-02f,
  1.87869510e-03f, -4.30026650e-02f, -1.26287371e-01f, -8.69186521e-02f, -1.00652695e-01f, 4.21210341e-02f, -3.16040739e-02f, -7.78510049e-02f, -1.60497110e-02f, -7.54103288e-02f,
  6.90496564e-02f, 2.67283916e-02f, 6.75728247e-02f, 1.97859239e-02f, -1.74720734e-02f, -8.88939947e-02f, -8.85914713e-02f, -2.47897431e-02f, -3.51584665e-02f, -1.01817384e-01f,
  -3.10090967e-02f, 2.09082086e-02f, -1.13635764e-01f, -4.78408439e-03f, -1.03844672e-01f, -5.58178499e-02f, -4.43516076e-02f, -4.16670134e-03f, -1.60512291e-02f, 8.97095166e-03f,
  8.10624361e-02f, 1.31945893e-01f, 1.17424317e-01f, -8.09128731e-02f, 2.91626472e-02f, -8.53459090e-02f, 7.20976964e-02f, -1.69854541e-03f, -7.28858076e-03f, 4.97008860e-02f,
  -3.95071879e-02f, -6.93271086e-02f, 3.62446308e-02f, 4.90118526e-02f, 4.07645777e-02f, -5.05887009e-02f, -9.95480195e-02f, 5.85894799e-03f, -6.64651543e-02f, 3.84266861e-02f,
  6.38802350e-03f, -3.86643745e-02f, -6.74285442e-02f, -6.95880130e-02f, -3.55024934e-02f, -3.53578106e-02f, -3.05427890e-02f, -3.89512163e-03f, 4.74978015e-02f, 7.72684533e-03f,
  1.26582190e-01f, 1.11443199e-01f, 1.15178078e-02f, 2.54679788e-02f, 2.04129443e-02f, 2.10149698e-02f, 4.33629425e-03f, 1.03422262e-01f, 8.56089592e-02f, 8.45031068e-03f,
  1.55669590e-02f, 1.97037682e-03f, 9.12726298e-02f, -4.17456329e-02f, 6.60550548e-03f, 1.18467219e-01f, -4.54243049e-02f, 1.23267891e-02f, -2.34297421e-02f, -3.07503697e-02f,
  -2.38408474e-03f, -1.23787588e-02f, 5.73822297e-02f, 2.11934578e-02f, -3.20247654e-03f, -9.02762695e-05f, 3.49763259e-02f, -3.38222310e-02f, -8.31146259e-03f, 7.15839714e-02f,
  -7.98580274e-02f, -5.92726059e-02f, -4.58415896e-02f, 1.79491386e-01f, -1.23589158e-01f, 7.87114203e-02f, 1.26877040e-01f, -7.28947744e-02f, -1.62615776e-02f, 1.32684708e-01f,
  1.98007852e-01f, 4.75997292e-02f, -2.63150869e-04f, 3.64157259e-02f, -3.37253250e-02f, 5.91692924e-02f, 1.98779076e-01f, 8.25416744e-02f, -2.71442942e-02f, 1.17164493e-01f,
  1.24970481e-01f, 2.25991849e-02f, 1.06567323e-01f, 2.64256503e-02f, -8.00585561e-03f, 1.43870831e-01f, 3.85195240e-02f, -1.26453713e-01f, 1.80116758e-01f, -3.68085168e-02f,
  5.53407408e-02f, -5.77684976e-02f, -4.42977473e-02f, 3.61129344e-02f, 1.25922821e-03f, 6.99479356e-02f, -5.22947013e-02f, 2.71447730e-04f, 5.91164641e-02f, -5.78709804e-02f,
  -3.90626155e-02f, 4.94448319e-02f, -6.71637580e-02f, 3.19806412e-02f, -5.14810607e-02f, 5.10261394e-04f, -6.98808730e-02f, 5.43791242e-02f, -9.85831544e-02f, -1.11079507e-01f,
  -2.08366569e-02f, -1.81625783e-02f, -1.33009118e-04f, 4.38302495e-02f, -1.63157824e-02f, 4.31929193e-02f, -2.88639613e-03f, 7.85309076e-02f, 1.94836780e-02f, 4.24045324e-03f,
  -4.86384854e-02f, 5.24990298e-02f, 7.43075833e-02f, -3.03038582e-02f, 4.52668183e-02f, 6.54491335e-02f, -4.43064794e-02f, -3.26430425e-02f, -1.08817391e-01f, -1.01290233e-02f,
  -3.67799401e-02f, 2.48364713e-02f, -1.01545937e-01f, 6.64532408e-02f, 3.41743343e-02f, -6.08792752e-02f, -2.16159057e-02f, -3.23778316e-02f, 8.82687792e-02f, -2.50715879e-03f,
  -7.03329518e-02f, 5.02511077e-02f, 6.43898826e-03f, -4.07202952e-02f, -5.80644011e-02f, -2.02616919e-02f, 2.27397922e-02f, -1.24051822e-02f, 8.04799944e-02f, -4.23180917e-03f,
  8.05944651e-02f, 9.76850316e-02f, -5.84308878e-02f, -4.42156121e-02f, 6.00444861e-02f, -3.11290175e-02f, -5.19950911e-02f, 3.63798290e-02f, -5.98956285e-05f, -3.33363526e-02f,
  -2.38467120e-02f, 8.89462605e-02f, 3.53713930e-02f, 1.12299053e-02f, -3.52762118e-02f, 6.29176013e-03f, 1.21053547e-01f, 7.98785016e-02f, 1.10509448e-01f, -3.72720286e-02f,
  5.56347892e-02f, 1.99637953e-02f, 8.17839727e-02f, 4.93054204e-02f, 4.47474141e-03f, 2.83494517e-02f, 1.19666103e-04f, 3.88145773e-03f, 5.53779081e-02f, 3.59189659e-02f,
  -8.83298144e-02f, -1.37156188e-01f, -2.96364516e-01f, 4.24930528e-02f, -1.27764389e-01f, 1.82796896e-01f, 2.45558754e-01f, -1.60155043e-01f, -7.96610862e-02f, 2.09173501e-01f,
  2.15675309e-01f, -9.57885310e-02f, -2.43066847e-02f, 2.84993559e-01f, 1.34171098e-01f, 1.63861752e-01f, 3.61357838e-01f, 1.77712157e-01f, -1.08789518e-01f, -1.22033887e-01f,
  -1.01808589e-02f, 2.19171122e-01f, 8.06764290e-02f, 8.41004103e-02f, 1.86396260e-02f, -6.38546944e-02f, 1.26771659e-01f, -1.02870405e-01f, 2.58568615e-01f, 6.95618168e-02f,
  6.95307553e-02f, -5.63187823e-02f, -1.18366419e-03f, 3.50314341e-02f, -1.27765998e-01f, 3.15574482e-02f, -5.96084930e-02f, 2.81734075e-02f, 1.48286428e-02f, -1.27113178e-01f,
  2.42277216e-02f, -7.20628351e-02f, -1.58830881e-02f, -4.61397134e-02f, -3.55350338e-02f, 3.99419339e-03f, 7.98042770e-03f, -6.69406429e-02f, -6.17591701e-02f, -6.56067282e-02f,
  -5.33654802e-02f, -1.45523557e-02f, -8.16367865e-02f, -5.42140799e-03f, -3.33165051e-03f, 4.24557142e-02f, 3.54025699e-02f, -6.91585615e-02f, 1.53420586e-02f, -4.30075116e-02f,
  3.18797156e-02f, 5.31500652e-02f, -8.05820376e-02f, 6.19934238e-02f, -7.36785457e-02f, 4.42351587e-03f, 2.19852906e-02f, 1.13551796e-03f, -2.99806409e-02f, 2.65527796e-02f,
  -2.20811497e-02f, -7.09757879e-02f, 4.73133810e-02f, 3.84222157e-02f, -4.70386706e-02f, 3.84118482e-02f, 4.98975515e-02f, 6.17767461e-02f, 2.86807567e-02f, -1.66039206e-02f,
  2.51939171e-03f, -5.57555631e-02f, 1.55465482e-02f, 7.53320009e-02f, 6.38929754e-02f, -5.44993579e-02f, 1.30118607e-02f, -3.84104364e-02f, 4.49393764e-02f, -7.92912170e-02f,
  7.79898390e-02f, -1.94642082e-01f, -6.93411455e-02f, 2.48013437e-02f, 8.77660885e-02f, -7.55925477e-02f, 5.35943285e-02f, -4.11874764e-02f, -1.27569893e-02f, 1.19134998e-02f,
  -2.83092372e-02f, 4.61225808e-02f, -4.48884331e-02f, 8.29483122e-02f, 6.71526268e-02f, 6.76899403e-02f, -1.67018026e-02f, 2.57152375e-02f, 6.47585690e-02f, -6.91208318e-02f,
  1.58957411e-02f, -3.36627699e-02f, -1.45300170e-02f, 9.54065879e-04f, 8.85667577e-02f, -3.16728605e-03f, -6.93208538e-03f, -2.60900538e-02f, 5.71501255e-03f, 4.47682068e-02f,
  5.53125516e-03f, 1.85915381e-01f, 4.89078648e-02f, 1.17442645e-01f, -1.21491455e-01f, -3.55922669e-01f, -2.12126389e-01f, 6.26772419e-02f, 2.52720445e-01f, -8.10709968e-03f,
  -5.13822995e-02f, 1.02080613e-01f, 1.53253213e-01f, -4.17570658e-02f, 7.24039376e-02f, 7.90084004e-02f, -9.28091034e-02f, -7.13674352e-02f, 1.20206594e-01f, 2.55918503e-02f,
  -1.59799214e-02f, 1.16500616e-01f, -2.81206742e-02f, -5.17803058e-02f, -1.31896855e-02f, -3.71625833e-02f, 8.40073153e-02f, 3.23259793e-02f, -2.43446585e-02f, 2.00901851e-02f,
  -1.70009121e-01f, 4.29134257e-02f, -5.30345552e-02f, -2.99262553e-02f, -1.16594620e-02f, -1.06013551e-01f, -7.62012154e-02f, -9.42899436e-02f, -4.74947169e-02f, 8.27261433e-02f,
  6.07736297e-02f, -6.87469169e-02f, 5.61958477e-02f, 1.16141811e-02f, -1.73890870e-02f, 5.68967499e-02f, -4.26446423e-02f, -1.06680900e-01f, 3.05921547e-02f, -6.16115816e-02f,
  -6.28714859e-02f, -1.11932188e-01f, -6.56786337e-02f, -2.15653442e-02f, -4.12357263e-02f, -2.68475544e-02f, -3.77559327e-02f, -5.27268425e-02f, -7.75148794e-02f, 7.60862604e-03f,
  8.01589191e-02f, -6.91752657e-02f, 4.39221151e-02f, -5.60794771e-02f, -1.85867250e-02f, 2.40206216e-02f, 3.75439003e-02f, -7.64827207e-02f, 6.36238083e-02f, -1.25574321e-01f,
  -4.74211089e-02f, 4.76840772e-02f, -2.26231720e-02f, -2.51799803e-02f, 6.88705547e-03f, -2.21829433e-02f, 2.46253740e-02f, -5.45114838e-02f, 3.95517573e-02f, -4.35487702e-02f,
  -3.28085870e-02f, 2.18658522e-02f, 2.67721284e-02f, -8.16533342e-02f, 3.20501663e-02f, -2.38003824e-02f, 8.76292735e-02f, -9.76261031e-03f, -3.05067990e-02f, 2.53292695e-02f,
  5.69062419e-02f, 2.46449739e-01f, 6.35383651e-02f, -4.33068350e-02f, 1.05341068e-02f, -3.64630632e-02f, 8.21406320e-02f, -6.93291724e-02f, 1.06625013e-01f, -8.33860338e-02f,
  -1.10374115e-01f, -5.34012653e-02f, -8.87747705e-02f, 2.98441220e-02f, 2.57416293e-02f, 7.81917572e-02f, 1.14115559e-01f, 7.16243312e-02f, -2.59958860e-02f, 8.17444734e-03f,
  -6.22130232e-03f, 4.53669280e-02f, -2.52443179e-02f, -1.91112887e-02f, 4.65683192e-02f, -3.07629630e-02f, 2.45688539e-02f, 2.68022008e-02f, -1.68455280e-02f, 1.71985142e-02f,
  -2.46852636e-02f, -2.26905167e-01f, 1.18282780e-01f, -5.25051430e-02f, -2.33230263e-01f, 5.01586944e-02f, 3.37536991e-01f, -3.43124151e-01f, -4.39170539e-01f, -6.02023080e-02f,
  5.22961356e-02f, 8.59685168e-02f, 4.73276198e-01f, -1.17644615e-01f, 3.69990796e-01f, 2.87843376e-01f, -1.14016727e-01f, 9.32240412e-02f, -1.30333841e-01f, -1.30301654e-01f,
  -1.72457010e-01f, -1.88351065e-01f, 1.83319464e-01f, -3.29133123e-01f, -7.06309751e-02f, -2.44721532e-01f, 7.35380948e-02f, 1.92651719e-01f, -1.73713565e-01f, 7.60167390e-02f,
  -1.28701985e-01f, -2.62727320e-01f, -1.06891617e-02f, -3.06691825e-02f, -2.99859960e-02f, 1.94349736e-02f, 1.30584151e-01f, 1.73621848e-01f, -6.51375428e-02f, -5.52811958e-02f,
  8.96079317e-02f, -8.75937641e-02f, -1.34473026e-01f, 7.15835541e-02f, -1.29583448e-01f, -1.29764065e-01f, -1.06248222e-01f, 1.37844197e-02f, -8.43961723e-03f, 2.70463852e-03f,
  1.78987961e-02f, -2.27950718e-02f, -3.03366333e-02f, -1.53262727e-02f, 4.79660220e-02f, -1.22943453e-01f, 6.17799163e-02f, 1.47280157e-01f, -5.93751855e-02f, -4.34891544e-02f,
  -1.80367026e-02f, -1.12489341e-02f, 2.86693685e-02f, 3.96473007e-03f, 4.00473252e-02f, -2.65272381e-03f, 6.15016595e-02f, -3.77334729e-02f, 6.67571053e-02f, 1.11425603e-02f,
  -4.02703620e-02f, -2.88832188e-02f, -1.56889260e-02f, -1.53583772e-02f, -2.96674650e-02f, 1.02615878e-02f, 5.06231934e-02f, -5.35801575e-02f, 1.20110270e-02f, -3.28218378e-02f,
  1.06625117e-01f, 8.83262022e-04f, 4.95566614e-02f, 8.01251922e-03f, -4.04870957e-02f, 6.79289699e-02f, -7.99149647e-03f, -1.84267350e-02f, -2.95587722e-02f, 1.28616109e-01f,
  -1.94570139e-01f, -1.49209008e-01f, -6.99225441e-02f, -9.78647768e-02f, -2.43069045e-02f, -9.09946039e-02f, -7.17073679e-02f, -9.09579322e-02f, 2.97086630e-02f, -3.96798775e-02f,
  -6.52677268e-02f, 3.42575200e-02f, -2.54688505e-02f, 3.03676934e-03f, -4.04655794e-03f, -8.64357874e-02f, 3.27908471e-02f, -4.10210062e-03f, -2.55699363e-02f, -3.22021991e-02f,
  -4.60260408e-03f, -3.49880718e-02f, 6.18395880e-02f, -7.95326605e-02f, 5.25779615e-04f, 4.17734496e-02f, -6.42291084e-02f, 2.02742517e-02f, -1.64770596e-02f, -5.81297614e-02f,
  7.01229200e-02f, 1.50281399e-01f, -8.12251717e-02f, 1.50349081e-01f, 3.62569317e-02f, -2.10710196e-03f, 1.33346036e-01f, 1.87559202e-01f, 2.02884987e-01f, 8.40010494e-02f,
  1.91509888e-01f, -3.63651873e-03f, -6.08786121e-02f, 2.64827907e-01f, 1.71056718e-01f, 3.30773145e-02f, 3.44304383e-01f, 1.86011463e-01f, 8.98155868e-02f, 1.36248529e-01f,
  7.68291354e-02f, 2.12961674e-01f, -4.83183935e-02f, -7.64037296e-02f, 4.79281247e-02f, 3.67746828e-03f, -7.27147236e-02f, -1.20955877e-01f, 7.48350099e-02f, -1.54085800e-01f,
  -4.27763239e-02f, 7.96104893e-02f, -4.66834567e-02f, -3.64640877e-02f, -8.25407505e-02f, 3.43207046e-02f, -2.97844354e-02f, -8.29117466e-03f, 5.90613438e-03f, 1.53625691e-02f,
  2.78604422e-02f, -7.72949755e-02f, 8.67039040e-02f, -1.07704632e-01f, -6.71387166e-02f, -6.05794117e-02f, 8.48565344e-03f, 4.35946584e-02f, 5.91432024e-03f, 2.55441125e-02f,
  2.72399862e-03f, -3.05887945e-02f, -1.22182183e-02f, 5.94380312e-02f, 5.82916066e-02f, -5.83468052e-03f, 6.15380816e-02f, 3.89253371e-03f, 7.21367495e-03f, 4.41849381e-02f,
  -4.82170209e-02f, 3.37612592e-02f, 5.68652675e-02f, 9.69578605e-03f, -4.84406576e-02f, 6.59205485e-03f, 8.04564729e-02f, -2.60851383e-02f, 4.42675799e-02f, -1.45324431e-02f,
  2.02290714e-02f, -4.52993959e-02f, 1.09641545e-01f, 1.98826510e-02f, 8.95426869e-02f, 7.79881328e-02f, 4.08038078e-03f, 2.63747070e-02f, -4.47405353e-02f, -4.97239642e-02f,
  9.23245121e-03f, 1.42722577e-02f, -3.19724567e-02f, -4.03846614e-02f, -4.36860807e-02f, -4.46893089e-02f, 4.36102450e-02f, -3.73408869e-02f, -8.43353048e-02f, -5.00575900e-02f,
  1.98154345e-01f, 1.83399722e-01f, 5.01117855e-03f, 1.70990061e-02f, 1.91811621e-02f, 2.05693655e-02f, 8.95118993e-03f, -6.62799403e-02f, -1.66039690e-02f, 5.94271645e-02f,
  -5.18161543e-02f, -3.83954719e-02f, -5.85695058e-02f, 4.69891988e-02f, 1.85527548e-04f, 5.19313924e-02f, 8.02826956e-02f, 1.71923824e-02f, -5.91737553e-02f, -4.16821092e-02f,
  -4.17539105e-02f, 6.12214245e-02f, 9.21785682e-02f, -2.94755306e-02f, 7.88535085e-03f, -6.36224747e-02f, -7.21863583e-02f, -1.52963139e-02f, -8.74485448e-02f, 4.45755385e-02f,
  -2.53646135e-01f, 8.38640481e-02f, 1.17905787e-03f, -6.97846115e-02f, -1.09638833e-02f, 2.08005071e-01f, 7.83740506e-02f, 1.23580679e-01f, -8.85656755e-03f, 1.71034932e-02f,
  4.71430011e-02f, -2.19123930e-01f, 5.46443909e-02f, 1.54317155e-01f, -2.96872705e-02f, 6.21238276e-02f, 1.03826478e-01f, 4.55076136e-02f, -3.23538780e-02f, 2.44263988e-02f,
  -1.89509953e-03f, 1.53608965e-02f, 1.12979978e-01f, 8.42577815e-02f, 5.22694774e-02f, -1.36521965e-01f, -1.02437176e-01f, -9.40944105e-02f, -4.84151095e-02f, 1.92549080e-02f,
  -2.34571286e-02f, -9.83006433e-02f, -8.45992342e-02f, -1.33932129e-01f, -1.45816235e-02f, -6.09881356e-02f, -5.23715988e-02f, -1.08167648e-01f, -5.95046282e-02f, 7.19965622e-02f,
  -8.57349858e-02f, 2.89302245e-02f, 2.66640708e-02f, 7.13641346e-02f, 5.93672739e-03f, -2.35957224e-02f, 2.97767669e-02f, 1.17769793e-01f, -2.57446747e-02f, 4.85361181e-02f,
  8.70863944e-02f, 3.28713134e-02f, 6.42343145e-03f, 7.63862431e-02f, 6.68376982e-02f, 4.72497307e-02f, -4.95451130e-03f, 1.67930126e-02f, -8.31685066e-02f, 8.64373073e-02f,
  1.56195471e-02f, 3.28383557e-02f, -6.65806606e-02f, 2.05997359e-02f, -7.22038448e-02f, 7.75117576e-02f, -6.97922856e-02f, 3.95883061e-02f, -1.10524975e-01f, -9.88104008e-03f,
  -2.79272608e-02f, 2.97860485e-02f, 2.33593415e-02f, 2.36445554e-02f, -3.34945880e-02f, -1.03441626e-02f, -1.09685279e-01f, -2.54549365e-02f, -8.51992145e-03f, 6.10271581e-02f,
  2.12937295e-02f, 4.59288396e-02f, -5.74230179e-02f, -5.28973192e-02f, -8.12923461e-02f, -2.25413144e-02f, 9.18931812e-02f, -1.18316514e-02f, 4.20903116e-02f, -8.12899247e-02f,
  -1.16162844e-01f, -1.44320339e-01f, -7.91096687e-03f, 6.30421564e-03f, 1.44511815e-02f, -2.51125768e-02f, 2.66153403e-02f, 3.08552533e-02f, -6.34827837e-02f, -4.50861873e-03f,
  -6.33698553e-02f, 3.65710482e-02f, -3.62919196e-02f, 1.68753977e-04f, -2.62759663e-02f, 8.32724720e-02f, 3.98068801e-02f, -3.38259824e-02f, -9.67731327e-02f, 1.18669355e-02f,
  -6.04243129e-02f, -5.73175736e-02f, 2.82332823e-02f, -4.76837568e-02f, -5.48568815e-02f, -6.54752105e-02f, 8.87592882e-03f, -9.17287767e-02f, 2.36043390e-02f, 7.29302764e-02f,
  2.05338851e-01f, 6.40904829e-02f, -2.12847754e-01f, -1.01309553e-01f, -1.45821407e-01f, -4.36415896e-02f, 8.65853131e-02f, 1.27505558e-02f, -9.26213432e-03f, 1.15520731e-01f,
  -1.14665084e-01f, 6.84521049e-02f, 9.02204141e-02f, 8.12646933e-03f, 1.90619335e-01f, 1.45265475e-01f, 1.34657815e-01f, -3.22000682e-02f, 3.08428854e-02f, 6.57211095e-02f,
  1.20527536e-01f, 9.18033794e-02f, -7.98786208e-02f, -1.10971518e-01f, -1.06041260e-01f, -6.91520348e-02f, -4.46537696e-02f, -1.19895972e-01f, -1.52532682e-01f, 2.87897233e-02f,
  2.15189159e-03f, 3.44288759e-02f, -6.62221089e-02f, -6.74579442e-02f, -3.10927704e-02f, 3.16035300e-02f, -7.27687478e-02f, -9.44636911e-02f, -5.97810820e-02f, 9.36621949e-02f,
  1.74816996e-02f, -4.90676146e-03f, 7.37628376e-04f, -1.73658784e-02f, 5.54069206e-02f, -5.26207276e-02f, -7.33290091e-02f, -1.03450514e-01f, -4.17070538e-02f, 5.90401217e-02f,
  1.37628079e-03f, -5.93128800e-02f, -1.10935807e-01f, 3.08530242e-03f, -1.90983880e-02f, -5.52280881e-02f, 5.62001653e-02f, 6.72530606e-02f, 5.86102717e-02f, 1.69156515e-03f,
  1.34587377e-01f, -4.10595015e-02f, 2.56734118e-02f, 3.97174880e-02f, 4.21985388e-02f, -7.39025846e-02f, 2.70274770e-03f, -8.25804025e-02f, 9.01303999e-03f, 6.13657571e-03f,
  -2.21132413e-02f, -3.84647213e-02f, -8.40570256e-02f, 6.45557940e-02f, 6.59310669e-02f, 7.08893016e-02f, 5.35702407e-02f, -1.12971887e-02f, -4.24439907e-02f, -1.55079819e-03f,
  -1.98241677e-02f, 2.09874753e-02f, 2.95741782e-02f, -3.65994237e-02f, 5.27618118e-02f, -4.65506837e-02f, -6.92772940e-02f, 9.05142650e-02f, -5.34823611e-02f, 3.30518298e-02f,
  1.74366534e-02f, 3.51888478e-01f, -7.56472256e-03f, 5.16826436e-02f, -5.64464927e-02f, -4.22741808e-02f, 1.16715334e-01f, 6.86387345e-02f, 8.67149681e-02f, 1.04646720e-01f,
  -1.79142822e-02f, -1.08371601e-02f, -2.57148128e-03f, 6.71739653e-02f, -4.71089669e-02f, -1.59442835e-02f, 1.02994956e-01f, 3.01676579e-02f, 4.62482385e-02f, 5.45332730e-02f,
  -8.55322033e-02f, 5.19669503e-02f, -1.99751835e-02f, -1.52444365e-02f, -2.13874262e-02f, -1.16778888e-01f, 3.51777822e-02f, 1.13819707e-02f, 1.02244698e-01f, -6.23765588e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -1.22851571e-02f, 6.36452660e-02f, 1.57279611e-01f, 1.87544942e-01f, 9.58952606e-02f, 1.19813152e-01f, 2.28760511e-01f, 1.49673328e-01f, 2.04322204e-01f, 1.90418169e-01f,
  2.53076911e-01f, 1.60326138e-01f, 7.94811547e-02f, 2.44991615e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -1.45883486e-01f, 5.37902340e-02f, 1.09590203e-01f, 4.91459779e-02f, -3.50506693e-01f, -3.72598946e-01f, 3.55591811e-02f, -2.94908434e-01f, 1.93343803e-04f, 3.29735875e-02f,
  8.58185738e-02f, 1.36379674e-01f, 1.81709737e-01f, -5.96024573e-01f, 1.42072141e-01f, 8.29783380e-02f, -3.92703190e-02f, 1.18179202e-01f, 7.43792877e-02f, 4.21059094e-02f,
  -2.01887667e-01f, -1.33392364e-01f, -2.32335046e-01f, -3.26479554e-01f, -1.23445563e-01f, 4.88374621e-01f, 3.60627890e-01f, -3.80522339e-03f, -2.10537061e-01f, -3.28633159e-01f,
  -2.77442724e-01f, -3.24155062e-01f, -2.94669479e-01f, 4.44921076e-01f, -5.12236834e-01f, -1.63193722e-03f, 3.31745623e-03f, 1.40150294e-01f, -3.97225529e-01f, -5.53947361e-03f,
  1.27487853e-01f, 3.10690433e-01f, -3.12462151e-01f, 2.62511224e-01f, -7.63145685e-02f, 4.71777618e-01f, 4.53737020e-01f, -3.02664548e-01f, 5.13262033e-01f, -1.33629873e-01f,
  -6.25484511e-02f, -1.59994625e-02f, -2.56606460e-01f, -1.47314027e-01f, -8.21856782e-02f, -3.39494497e-02f, 1.71270624e-01f, 2.33066544e-01f, 5.76818287e-01f, -1.53520539e-01f,
  3.47434402e-01f, 1.63946062e-01f, 3.13994229e-01f, -8.04825500e-02f, 2.75495440e-01f, 2.96672702e-01f, 1.49409816e-01f, -1.45470053e-01f, 2.91688323e-01f, -4.15168516e-02f,
  5.02011962e-02f, 2.27972463e-01f, 2.88111478e-01f, -3.72379214e-01f, -2.04143971e-01f, -4.29619312e-01f, -2.09503040e-01f, 1.04876988e-01f, 3.00092436e-02f, 2.79658914e-01f,
  3.76627445e-02f, -1.29874423e-01f, 1.02412507e-01f, -2.22368985e-01f, -3.49414535e-02f, -1.74133889e-02f, -2.23978758e-01f, -7.06764087e-02f, -3.00516099e-01f, -1.29067123e-01f,
  1.23944301e-02f, 4.47629273e-01f, -3.20821226e-01f, -2.53909647e-01f, -4.36963379e-01f, -9.28276405e-02f, 1.75866663e-01f, -1.23925112e-01f, -6.56729400e-01f, 5.09548262e-02f,
  -5.08784175e-01f, -5.71468294e-01f, 5.52435257e-02f, 3.17041516e-01f, -5.17046377e-02f, -3.20816189e-01f, -1.06429778e-01f, -5.15496731e-01f, -4.14064407e-01f, -3.29926431e-01f,
  4.84756857e-01f, -2.96604902e-01f, 5.13443612e-02f, -4.05553102e-01f, 1.32608458e-01f, -2.12171718e-01f, -2.56273240e-01f, -2.00174376e-01f, 3.14261049e-01f, 1.29967704e-01f,
  3.98008853e-01f, 9.44529101e-02f, 2.86444992e-01f, -1.66970029e-01f, -2.37072662e-01f, 3.02586168e-01f, 8.81529897e-02f, 4.06279653e-01f, -3.89236331e-01f, -3.36148530e-01f,
  -4.65442359e-01f, -1.23325221e-01f, -2.53975779e-01f, 1.18808202e-01f, -1.20493442e-01f, 3.35389860e-02f, 8.66959170e-02f, 2.31238320e-01f, 1.76527411e-01f, 1.40498638e-01f,
  -4.31654714e-02f, -3.91118750e-02f, 1.36758775e-01f, -1.74580470e-01f, -7.80216455e-02f, -9.12557095e-02f, -2.48306736e-01f, -6.82567507e-02f, 9.06804278e-02f, -2.55109191e-01f,
  -1.27130821e-01f, -1.01865344e-01f, -4.81577627e-02f, -3.79410565e-01f, -2.87433684e-01f, 4.11391497e-01f, -2.93343544e-01f, 4.20389622e-01f, 8.70209485e-02f, -3.30291808e-01f,
  1.44911811e-01f, -5.13960011e-02f, 5.49725182e-02f, 1.16409697e-02f, 7.67975971e-02f, -2.34021410e-01f, 2.20029533e-01f, 2.24479198e-01f, -3.42306495e-01f, -3.48896086e-01f,
  -2.66844541e-01f, -4.98122603e-01f, -2.61104852e-01f, 3.50690424e-01f, 3.80381584e-01f, 1.84663028e-01f, 1.81558162e-01f, -3.75203431e-01f, 6.30316138e-02f, 4.95798767e-01f,
  2.89592773e-01f, -1.40168950e-01f, 2.57641226e-01f, -1.35447472e-01f, -1.13362178e-01f, 6.13120310e-02f, 4.28034693e-01f, -1.61301389e-01f, -3.10258538e-01f, -7.32921958e-02f,
  -4.78768423e-02f, -2.79082835e-01f, -3.10098231e-01f, -5.02050102e-01f, -3.99834335e-01f, -9.52742323e-02f, -4.12730098e-01f, -9.17689279e-02f, -2.38461554e-01f, 3.55306923e-01f,
  -2.29255170e-01f, 2.51058817e-01f, -1.52420420e-02f, 4.17084135e-02f, -3.94709736e-01f, 3.69075060e-01f, 2.32476726e-01f, 2.62009978e-01f, -2.62164026e-01f, -4.51461524e-02f,
  2.11705476e-01f, -2.62701176e-02f, 5.78691959e-02f, 1.58590823e-01f, 5.64306378e-02f, -2.31010914e-01f, 1.50629073e-01f, 2.84591526e-01f, 5.22799313e-01f, -4.12939042e-01f,
  4.36621010e-01f, -4.28411782e-01f, -2.86283135e-01f, 3.98386180e-01f, 2.65690207e-01f, 5.56353152e-01f, -8.34936872e-02f, -4.81072873e-01f, 1.43816963e-01f, 5.50224483e-01f,
  1.04329087e-01f, 2.84681797e-01f, -8.92333537e-02f, 3.54000986e-01f, 1.26476914e-01f, 8.28861892e-02f, -6.09076805e-02f, 4.46089298e-01f, 2.80110180e-01f, 3.41133833e-01f,
  -3.34225804e-01f, 5.54848649e-03f, -1.61497056e-01f, -1.12230256e-01f, -1.43665746e-01f, 1.92453742e-01f, -2.23472238e-01f, 1.12002539e-02f, -2.61103779e-01f, -2.90942103e-01f,
  -1.81705236e-01f, 2.15646252e-01f, -2.56551653e-01f, -7.16653243e-02f, 1.76081844e-02f, -6.45769387e-02f, 6.75723702e-02f, 2.53176212e-01f, 3.24736804e-01f, -2.64690012e-01f,
  2.79755920e-01f, 1.90773997e-02f, 4.23201114e-01f, 1.80544287e-01f, 5.23047149e-01f, -1.22046797e-03f, 8.92624334e-02f, -2.72244006e-01f, 1.88995123e-01f, -5.53893484e-02f,
  2.81133391e-02f, -1.66613271e-03f, 2.25989088e-01f, 8.53650793e-02f, 2.40760837e-02f, -1.39123246e-01f, 3.72057706e-02f, 2.81913489e-01f, 3.82454067e-01f, 2.82148898e-01f,
  2.79277623e-01f, 2.48888344e-01f, 2.56733596e-01f, -3.62926990e-01f, 5.15665233e-01f, -4.01753247e-01f, -6.15188360e-01f, -2.10071847e-01f, -2.82033682e-01f, 1.41863674e-01f,
  6.98499978e-01f, 1.52973369e-01f, 3.84382933e-01f, 1.04832366e-01f, -5.28306723e-01f, 2.07509995e-01f, 6.13288820e-01f, 5.99678531e-02f, -1.38511077e-01f, 3.16159934e-01f,
  -2.56143332e-01f, 3.64711910e-01f, -1.67989612e-01f, 3.01581947e-03f, -3.52515370e-01f, 4.37657833e-02f, 1.11000545e-01f, -1.14379235e-01f, 4.02646512e-01f, 4.26192917e-02f,
  -1.08278267e-01f, 6.78617582e-02f, -2.02498332e-01f, -2.88910806e-01f, -2.47235417e-01f, -3.03695798e-01f, 1.74994841e-02f, -3.37013245e-01f, 3.16245764e-01f, -1.14021361e-01f,
  -4.71510866e-04f, -8.94495621e-02f, 4.03922886e-01f, 2.29062244e-01f, 1.18048906e-01f, 3.61962050e-01f, 1.13109261e-01f, 4.92951982e-02f, 9.26659182e-02f, 3.63100976e-01f,
  -2.87495703e-01f, 1.86499357e-01f, 4.41913247e-01f, 1.07669234e-01f, 1.09975815e-01f, 2.81164981e-02f, -1.35270804e-01f, -3.22696380e-02f, 1.29834592e-01f, 1.72894627e-01f,
  1.30929604e-01f, -7.21725672e-02f, -2.36331865e-01f, 4.49577421e-02f, 5.18461652e-02f, 5.58248520e-01f, 1.12654328e-01f, -2.77237803e-01f, -6.73610121e-02f, -1.28375292e-01f,
  1.38298003e-02f, -3.57908785e-01f, -4.20453921e-02f, -4.89776731e-01f, 1.55867577e-01f, 4.49991971e-01f, -5.27377903e-01f, -1.19699776e-01f, -3.71892959e-01f, -4.01100248e-01f,
  2.24014476e-01f, -3.87914300e-01f, 5.96982181e-01f, 1.64425820e-01f, 1.96752325e-01f, -3.66534173e-01f, -4.46683228e-01f, -6.01632416e-01f, 2.74674982e-01f, -2.71567971e-01f,
  4.41259556e-02f, -4.40674974e-03f, -2.55270094e-01f, -8.97890627e-02f, -7.33062625e-02f, -1.15901917e-01f, 4.21960980e-01f, 5.33656925e-02f, -7.93698058e-02f, 1.71340957e-01f,
  -1.92389652e-01f, 1.60053432e-01f, -9.10127833e-02f, 3.78029406e-01f, 2.40468115e-01f, 2.37130702e-01f, -3.15236114e-02f, 2.94406384e-01f, -3.51480931e-01f, -3.41479391e-01f,
  4.86812666e-02f, -2.11590752e-01f, -5.85597754e-01f, -2.79551625e-01f, -3.08979034e-01f, 2.21081823e-01f, 2.12543122e-02f, 1.65464059e-01f, 1.12923831e-01f, 6.08616583e-02f,
  1.70130044e-01f, 1.22822095e-02f, 4.35997635e-01f, 2.28124633e-01f, 1.79320145e-02f, 1.29372969e-01f, 6.45354614e-02f, 1.36488089e-02f, 1.85129821e-01f, -2.36713231e-01f,
  -3.31185795e-02f, 3.11645389e-01f, 2.99136061e-03f, 6.14406824e-01f, 7.01704562e-01f, -4.23821300e-01f, -8.51153433e-02f, -5.35491288e-01f, 5.88090003e-01f, 4.08344984e-01f,
  -9.73642897e-03f, -5.07396877e-01f, 4.33783054e-01f, -4.69747037e-01f, -2.81026095e-01f, -1.71850085e-01f, -1.70330852e-01f, 2.70696700e-01f, -9.03031528e-02f, -3.73819709e-01f,
  -2.61734605e-01f, 5.24944961e-01f, -2.71911249e-02f, -1.26297206e-01f, -1.25308350e-01f, -9.27973688e-02f, -2.43690148e-01f, 7.87654310e-04f, -1.71935663e-01f, -1.74425557e-01f,
  -4.72375564e-02f, 1.13972723e-02f, -2.42217332e-01f, -7.34568983e-02f, -4.76523489e-01f, 1.65810287e-01f, 1.48916364e-01f, -1.31506220e-01f, 5.51320128e-02f, -1.14561118e-01f,
  2.46877521e-01f, -3.50029133e-02f, 9.28076357e-03f, -1.57301351e-02f, -1.19225435e-01f, -1.54641420e-01f, 3.77042070e-02f, -1.69418350e-01f, 4.26241942e-02f, -9.48515981e-02f,
  -1.90315709e-01f, 4.52721789e-02f, -3.23799759e-01f, -3.76685560e-01f, -9.91207883e-02f, -3.15566391e-01f, -1.78662866e-01f, -1.23503961e-01f, -6.88423291e-02f, 9.54788700e-02f,
  2.88089446e-04f, -1.65648177e-01f, 1.48202246e-02f, -1.47862121e-01f, 9.22696516e-02f, 3.56237777e-02f, -5.30317798e-03f, 1.79606259e-01f, 4.08513457e-01f, 4.10341173e-01f,
  1.16541922e-01f, 3.74785244e-01f, 2.88336039e-01f, -7.73254335e-02f, 1.80239320e-01f, 4.97348070e-01f, 2.97835678e-01f, -4.43516970e-01f, 3.90129238e-01f, 1.85850069e-01f,
  2.67380863e-01f, -1.84598476e-01f, 2.65557170e-01f, 7.01819733e-02f, -3.68245542e-02f, 4.32730317e-01f, -1.13382511e-01f, -5.31688817e-02f, -6.40861094e-02f, 1.04173064e-01f,
  -7.66103938e-02f, -4.44115028e-02f, -1.88382238e-01f, 6.42782688e-01f, 3.94139081e-01f, -1.33296430e-01f, -1.64605826e-01f, 2.10235864e-01f, 2.65981585e-01f, -2.10698724e-01f,
  -2.24671826e-01f, 1.98310420e-01f, -2.17071399e-02f, -3.60438585e-01f, 1.95686102e-01f, -1.66925222e-01f, -1.46832734e-01f, 6.03995658e-02f, -3.72249454e-01f, -1.22684136e-01f,
  1.31962374e-01f, 1.08746745e-01f, -3.30463350e-02f, -1.67068571e-01f, 5.29638641e-02f, 1.31846622e-01f, -3.49702090e-01f, -1.27470776e-01f, 9.73103940e-02f, 1.25411078e-01f,
  -3.47900003e-01f, -2.30834875e-02f, -1.48330167e-01f, 9.88668576e-02f, -1.65251270e-01f, -9.34694037e-02f, 5.95522225e-02f, -2.62703359e-01f, -4.48777318e-01f, -1.76691487e-01f,
  -2.16222212e-01f, 3.49921167e-01f, 3.35006207e-01f, 5.34734130e-01f, 1.65049896e-01f, -1.23117618e-01f, -1.06091648e-01f, -2.39565015e-01f, -4.11350489e-01f, -1.19289033e-01f,
  -3.47739220e-01f, 4.21242326e-01f, -3.94935906e-01f, 3.07863533e-01f, -1.22414641e-01f, -2.60027081e-01f, 1.67880327e-01f, 3.01831812e-01f, -1.68580249e-01f, -4.13926691e-01f,
  -2.55280614e-01f, 6.05581738e-02f, 1.92499310e-01f, 7.37101585e-02f, 2.45050207e-01f, 5.02217472e-01f, -7.15259537e-02f, -1.14546776e-01f, -1.16319515e-01f, 2.15937585e-01f,
  -2.11366534e-01f, 3.58820319e-01f, -1.42480135e-01f, 2.59063989e-01f, -8.41765925e-02f, 1.53449520e-01f, -1.34812087e-01f, 2.15269461e-01f, -3.87137026e-01f, 1.38585836e-01f,
  -9.36560566e-04f, 1.18538365e-01f, -1.62160918e-01f, 5.97704481e-03f, 3.04776765e-02f, -1.83864504e-01f, 1.85911447e-01f, -1.04231238e-01f, -9.52889845e-02f, 5.82557619e-02f,
  -4.87652384e-02f, -2.08269224e-01f, -1.30407736e-01f, 1.51344135e-01f, -1.41044125e-01f, 1.15438364e-01f, 9.21137333e-02f, 1.64552137e-01f, 2.41149161e-02f, 1.87765196e-01f,
  -1.49385288e-01f, -4.09391075e-01f, -1.50698394e-01f, 3.28270644e-01f, -3.03161860e-01f, 3.89982343e-01f, 9.54334512e-02f, -3.71711314e-01f, -3.12843442e-01f, -2.11522952e-01f,
  3.59309852e-01f, -1.11219753e-02f, 3.39289606e-01f, -1.62400857e-01f, -2.87981927e-01f, -9.89341438e-02f, 4.37958181e-01f, -2.77300388e-01f, -2.63472497e-01f, 3.76599908e-01f,
  3.41639191e-01f, -3.31339121e-01f, 9.83671620e-02f, -1.05587579e-01f, 6.21267408e-02f, -1.58217810e-02f, -1.30825028e-01f, -1.66671410e-01f, 2.29142159e-01f, -2.76644856e-01f,
  1.41730726e-01f, -3.28713824e-04f, -1.35423094e-01f, -8.29142183e-02f, 9.14070464e-04f, -1.43508866e-01f, 9.80940878e-01f, -4.11682546e-01f, -2.49712214e-01f, -4.65841480e-02f,
  2.87048161e-01f, 3.70726734e-01f, 6.28488744e-03f, 2.25326464e-01f, 1.87794343e-02f, 2.69487917e-01f, 3.42120565e-02f, -3.84845108e-01f, -3.10953945e-01f, -1.88583061e-01f,
  7.99501538e-02f, 2.29200684e-02f, 3.93864483e-01f, -4.51988839e-02f, 5.32970503e-02f, 4.25415151e-02f, 1.64217904e-01f, 9.45747867e-02f, 1.77916333e-01f, 9.90768448e-02f,
  1.86667114e-01f, -1.08435497e-01f, 1.36165649e-01f, -4.30617891e-02f, -1.69840664e-01f, 1.18670471e-01f, 1.46166801e-01f, -4.51795548e-01f, -2.16281980e-01f, -4.91678119e-01f,
  -1.70835555e-01f, 4.28091854e-01f, 4.72365350e-01f, 6.37149811e-01f, -4.34582174e-01f, -2.47491345e-01f, -4.47854877e-01f, 1.39586657e-01f, 6.33676469e-01f, -2.34506582e-03f,
  -3.98131907e-01f, -1.95103750e-01f, -1.90566167e-01f, -1.08986251e-01f, -2.02479935e-03f, -1.45361871e-01f, 3.10237885e-01f, 2.59783179e-01f, -5.96514232e-02f, 4.18885469e-01f,
  -1.51987121e-01f, -1.48291290e-01f, -3.50365452e-02f, 2.11637676e-01f, 4.75538760e-01f, -1.25452757e-01f, -2.57524550e-01f, 1.14791192e-01f, -1.31474942e-01f, -3.14986765e-01f,
  -1.57485187e-01f, -1.16796121e-01f, -2.87753604e-02f, -1.80228397e-01f, -9.84704867e-02f, 3.28512549e-01f, 1.68468684e-01f, -1.08853966e-01f, 1.07463069e-01f, 2.89379537e-01f,
  -8.63724761e-03f, 2.80355632e-01f, 1.78733021e-02f, 1.35797083e-01f, 2.79146433e-01f, 1.29739523e-01f, -1.09237202e-01f, 2.41050884e-01f, 2.82584935e-01f, 5.19300736e-02f,
  3.11315171e-02f, -1.60658538e-01f, 1.42754465e-01f, -2.08149612e-01f, -1.09828517e-01f, -2.68255413e-01f, 1.56201601e-01f, 4.36377563e-02f, -3.62213165e-01f, 4.82564151e-01f,
  -3.52668881e-01f, -2.92838365e-01f, 4.99673307e-01f, 2.68410712e-01f, -2.21408874e-01f, 3.89223605e-01f, -2.71060824e-01f, -5.14686227e-01f, -2.89919108e-01f, 1.22645512e-01f,
  4.19875056e-01f, 5.65951526e-01f, 2.03177720e-01f, -1.37423724e-01f, -6.74097121e-01f, 3.37637603e-01f, 3.07769388e-01f, -3.02774638e-01f, 4.43170428e-01f, -3.41844946e-01f,
  -4.83791232e-01f, -2.49301717e-01f, 2.01553941e-01f, 4.71239537e-01f, 1.67316452e-01f, 4.05347675e-01f, -1.08134523e-01f, 3.81141109e-03f, -2.00826734e-01f, -1.40996352e-01f,
  -1.99898124e-01f, -1.14458995e-02f, -1.93883941e-01f, -2.25071609e-02f, -1.80670291e-01f, -5.49470745e-02f, -2.08501205e-01f, -1.78780720e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.47828743e-01f, -1.38081029e-01f, 4.01419923e-02f, 1.61822721e-01f, -2.15238836e-02f, -1.27511904e-01f, 1.89697117e-01f, -6.30153120e-02f, -3.37314941e-02f, -4.67589237e-02f,
  1.37423761e-02f, 3.63470316e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    